#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.24857140f, -0.99502510f, -0.57123554f, -0.39303768f, -0.92344129f, 0.91726404f, 0.46778598f, 0.30231461f, 
    0.02752850f, 0.14539406f, 0.36792833f, -0.30893594f, -0.27283531f, -0.37468547f, 0.13156143f, -0.10685197f, 
    0.04250608f, 0.03556124f, 0.23512277f, -0.13353787f, -0.19185545f, -0.27255234f, 0.09868389f, 0.20754242f, 
    0.16616543f, -0.82693368f, -0.34942785f, 0.27415884f, -0.23529750f, 0.39045370f, -0.20153087f, -0.44696122f, 
    -0.53889257f, -0.67817152f, -0.45904478f, 0.30288824f, -0.61451662f, 0.05785000f, -0.45497331f, -0.04775161f, 
    0.21183623f, 0.22711992f, 0.26053643f, 0.01115962f, 0.28847080f, 0.15722105f, -0.17053610f, 0.02563868f, 
    -0.09305210f, 0.21060824f, 0.98990798f, 0.29362124f, 0.58291489f, 0.27183551f, -0.01523876f, -0.53807580f, 
    -0.41966006f, -0.00434370f, -0.53317308f, -0.80789053f, -0.17734027f, -0.00670407f, 0.23947413f, -0.00469107f, 
    0.32644671f, 0.01537247f, -0.18560599f, 0.16611084f, 0.03740323f, -0.05016769f, -0.03180940f, 0.16743211f, 
    0.13583188f, 0.28179190f, -0.15962300f, -0.21497397f, 0.28626102f, 0.51850456f, 0.25703844f, -0.67985225f, 
    0.66687322f, -0.45668972f, -0.58653808f, 0.02507561f, -0.13986096f, 0.51419592f, -0.37580720f, 0.08245946f, 
    -0.13322455f, -0.05145676f, 0.26658207f, 0.30743119f, -0.00803228f, -0.18638676f, -0.41051695f, -0.13471994f, 
    0.22292887f, 0.28645992f, -0.25466913f, -0.09619943f, 1.00296295f, 0.23815668f, 0.00325708f, -0.69415390f, 
    -0.88454485f, 0.04392483f, 0.15265457f, 0.27929580f, -0.06730168f, -0.05213460f, 0.05305164f, 0.18055516f, 
    0.20450267f, -0.27480480f, -0.17159367f, -0.19645038f, 0.26866189f, 0.15315785f, -0.24063256f, -0.26379171f, 
    0.01698128f, -0.15392229f, -0.33226880f, 0.14907925f, -0.36967394f, 0.17124452f, -0.10338159f, 0.35410053f, 
    -0.78397506f, -0.44585267f, -0.05980467f, 0.12790857f, 0.21927918f, 0.29832596f, 0.23758371f, -0.10223211f, 
    -0.17587452f, 0.13586436f, -0.39061528f, 0.16359535f, 0.00427719f, 0.04398300f, -0.00722661f, -0.11170952f, 
    0.05213953f, -0.19925998f, -0.14454004f, 0.18914057f, 0.16383134f, -0.06457424f, -0.05953892f, -0.65466082f, 
    -0.22119667f, -0.26674137f, -0.23632497f, -0.37426785f, -0.67717940f, -0.48064488f, -0.30112851f, -0.81106770f, 
    0.76060742f, -0.30374402f, 0.02771134f, 0.17459695f, 0.65565228f, -0.30191985f, -0.01395613f, -0.06141382f, 
    0.07646032f, 0.03516473f, -0.21727024f, -0.06073993f, 0.28984213f, 0.08382570f, -0.19463630f, -1.12808335f, 
    -0.49144468f, 0.01859520f, 0.50687313f, 0.65520978f, 0.36005831f, -0.05945697f, 0.17676702f, 0.27791175f, 
    0.36262065f, 0.20426589f, -0.19324951f, -0.05801842f, 0.27628919f, -0.32284039f, -0.29698050f, -0.20223972f, 
    0.17122944f, -0.31674045f, 0.20184553f, 0.25436848f, -0.10578310f, 0.12633471f, 0.01655731f, 0.16068129f, 
    0.12091336f, 0.47611105f, 0.37973863f, 0.34275639f, 0.22879203f, -0.27730259f, -0.40248320f, -0.08844665f, 
    0.04020240f, -0.00603867f, -0.13534409f, 0.25898352f, -0.26275516f, -0.14472362f, -0.30179745f, -0.14047462f, 
    -0.04968523f, -0.15514226f, -0.00161693f, 0.18577123f, -0.30263826f, -0.28079432f, -0.19461696f, -0.49213892f, 
    -0.58728987f, -0.43018362f, 0.35792997f, 0.54733825f, 0.31355956f, 0.04653755f, -0.85911524f, -0.52981627f, 
    0.30926824f, -0.18526717f, -0.09616911f, 0.10841426f, -0.18075681f, 0.48768881f, -0.11303142f, 0.37346652f, 
    -0.22816260f, -0.21862590f, 0.08477551f, -0.30074146f, -0.36889058f, -0.12706405f, 0.09667076f, 0.22532611f, 
    0.31765750f, 0.45971370f, -0.95036483f, -0.84202582f, -0.71837997f, 0.31552574f, -0.22028770f, 0.13330199f, 
    0.13319522f, -0.31520662f, -0.15692127f, 0.04392286f, 0.68380338f, 0.34374690f, 0.10093918f, 0.07082897f, 
    0.25998801f, -0.05931026f, -0.05127512f, -0.19218378f, 0.13685372f, -0.14289670f, -0.18665345f, -0.29052845f, 
    -0.01933133f, 0.21528396f, -0.40769127f, 0.57683945f, 0.38968769f, -0.28947133f, 0.22643116f, -0.16661330f, 
    0.09966265f, -0.40057445f, -0.24508165f, 0.16842841f, 0.12290580f, 0.08370601f, 0.46654060f, -0.22022843f, 
    -0.19041437f, -0.09365242f, -0.18572547f, -0.19338535f, 0.02923917f, -0.05123771f, 0.01057453f, -0.11886575f, 
    -0.13843673f, 0.27901751f, 0.21171567f, -0.07821316f, 0.05688510f, 0.08859283f, 0.34682229f, 0.20081130f, 
    0.33810520f, 0.41770363f, -0.06183423f, -0.27914822f, 0.22518155f, 0.24899042f, -0.02159817f, -0.02372540f, 
    0.04151652f, 0.02175846f, 0.18675698f, -0.02537615f, -0.14193442f, -0.18403238f, 0.00471781f, -0.33864602f, 
    -0.06757127f, 0.02805542f, -0.03901173f, -0.28544629f, -0.42219061f, 0.78158808f, 0.05420396f, -0.34543443f, 
    -0.44511890f, -0.04158347f, -0.23926932f, 0.20059572f, 0.31492296f, 0.24365759f, -0.41779307f, -0.27951589f, 
    0.06112250f, -0.07321265f, 0.16401854f, 0.40806916f, 0.11677444f, -0.21022420f, -0.17585790f, 0.00789795f, 
    -0.02451623f, 0.05027179f, -0.24612984f, 0.15007141f, 0.25488558f, -0.08664916f, 0.60941255f, -0.06130013f, 
    0.35187292f, -0.49332339f, -0.45054397f, 0.04339679f, -0.22661957f, 0.35719219f, 0.19317129f, 0.12944248f, 
    0.43173867f, -0.67571145f, 0.15600279f, -0.22248945f, -0.25406864f, -0.29955924f, 0.22831790f, -0.21186063f, 
    0.01986593f, -0.09343778f, 0.09890280f, 0.36320704f, -0.34363440f, -0.10254463f, 0.12461653f, -0.92724544f, 
    -0.21256365f, -0.02175687f, 0.68863189f, -0.01571069f, 0.16307144f, 0.13972257f, 0.04047546f, 0.32097396f, 
    0.34218806f, -0.22024517f, -0.50499135f, -0.69419169f, 0.34646598f, -0.31840152f, 0.47802314f, 0.43008170f, 
    -0.12739682f, 0.07452714f, -0.30431461f, -0.15550777f, -0.13924742f, -0.14178231f, -0.25578105f, -0.08195667f, 
    -1.04256094f, -0.48117962f, -0.70347947f, -0.67460382f, -0.73376119f, 0.98896372f, 0.19581077f, 0.18221523f, 
    0.35373381f, 0.41766509f, -0.18324286f, -0.03553560f, -0.19769992f, -0.15906979f, -0.49654117f, 0.02772883f, 
    -0.28083697f, -0.12400823f, -0.03806871f, -0.01271317f, -0.11594398f, -0.04455848f, 0.17650142f, -0.24794221f, 
    -0.26603025f, -0.42524216f, -0.30145353f, -0.33846280f, -0.48350683f, -0.69669205f, 0.01134978f, -0.22281896f, 
    -0.22823794f, -0.41877744f, 0.01486827f, -0.14655684f, 0.52816838f, -0.20537627f, -0.24072662f, -0.04228608f, 
    -0.04473527f, 0.10159179f, -0.05192474f, 0.14580880f, -0.25769359f, 0.21871176f, 0.22813763f, -0.00384070f, 
    0.31485477f, 0.40077788f, 0.72333157f, 0.65660679f, 0.66299361f, 0.24249662f, 0.25696108f, -0.09054811f, 
    -0.18826719f, -0.29035336f, -0.24368615f, -0.25381702f, 0.28631026f, -0.04116862f, -0.09750389f, 0.26206112f, 
    -0.10703032f, 0.20589456f, -0.04162024f, -0.10100546f, -0.11413891f, 0.22277127f, 0.12157070f, 0.17373985f, 
    0.05908182f, -0.08087297f, -0.27672726f, 0.46924511f, 0.66470152f, 0.53087628f, -0.40142596f, -0.87115467f, 
    -0.01848403f, -0.70504409f, -0.17838535f, 0.39219370f, -0.65345627f, -0.28444403f, -0.46387064f, -0.37373260f, 
    -0.11270685f, 0.16091560f, -0.08452121f, -0.12084560f, -0.16199853f, 0.30534035f, 0.10170958f, -0.23297589f, 
    -0.30754009f, -0.18228877f, 0.01284731f, 0.14450471f, -0.06563881f, -0.68284625f, -0.53627640f, -0.67860430f, 
    -0.58593023f, 0.35755840f, 0.35580805f, 0.46567684f, 0.37814409f, 0.31688273f, -0.04691669f, 0.29883334f, 
    0.06771566f, 0.16280927f, -0.09340172f, 0.01163284f, -0.09002719f, 0.03094420f, 0.29026648f, 0.21869335f, 
    0.14954522f, -0.21242262f, 0.25167665f, -0.24342349f, -0.35112515f, 0.21565360f, 0.01050418f, 0.20052032f, 
    0.15261365f, -0.11151655f, -0.29023856f, 0.00204752f, 0.13505878f, 0.29061475f, 0.18234277f, -0.35644189f, 
    -0.08706303f, 0.72651845f, -0.32971418f, -0.18990225f, -0.18984836f, -0.15492406f, -0.17196155f, 0.07410491f, 
    -0.11313809f, 0.04107165f, -0.07432959f, -0.34940407f, 0.07254163f, 0.36877516f, 0.17555322f, -0.60511726f, 
    -0.74734998f, -0.39752898f, -0.16565105f, -0.26498246f, -0.19939877f, -0.36012328f, 0.31659061f, -0.74047434f, 
    -0.01284241f, 0.22672606f, -0.01676647f, -0.33390313f, -0.38561264f, -0.38934964f, -0.15886748f, -0.01151968f, 
    -0.66988635f, 0.12238957f, -0.10789306f, 0.10500650f, 0.13070549f, -0.10300960f, 0.36686522f, 0.26496089f, 
    0.74507362f, 0.13042568f, -0.78967685f, 0.11937495f, -0.31076643f, 0.50733191f, 0.49418849f, -0.69260287f, 
    -0.41190732f, -0.49826849f, 0.30963323f, -0.08959144f, -0.22398888f, 0.05168198f, 0.14989258f, 0.18328100f, 
    0.10959256f, -0.31713486f, 0.23486279f, -0.13449083f, -0.24934037f, -0.24806854f, 0.19702892f, 0.25884387f, 
    0.16272907f, 0.07622393f, -0.61201435f, -0.50681823f, -0.27652940f, 0.09488901f, 0.01585879f, 0.13784066f, 
    0.16997048f, 0.17263362f, 0.03504509f, 0.30318210f, -0.13420717f, -0.08711834f, -0.16042206f, -0.62604654f, 
    -0.41382566f, -0.08867417f, 0.24247323f, 0.01495618f, 0.18153724f, 0.38626856f, 0.24889369f, 0.09311115f, 
    0.51967937f, -0.86206377f, -0.33508512f, -0.05079259f, 0.25811437f, -0.23028079f, -0.06118631f, -0.16114897f, 
    0.75369358f, 0.01385816f, -0.23126571f, -0.10773814f, -0.21568075f, 0.12009052f, -0.05823413f, 0.02259663f, 
    0.42268032f, 0.22156784f, 0.03370950f, 0.01254671f, 0.31528836f, -0.16907656f, -0.55507708f, -0.04534206f, 
    -0.23505172f, -0.37427503f, -0.87481368f, -0.58835846f, 0.18302362f, 0.56913996f, 0.40665394f, 0.86046845f, 
    0.63078701f, 0.14501798f, -0.84512967f, -0.19754110f, -0.02007290f, -0.43803158f, 0.58804607f, -0.35365915f, 
    -0.29129952f, -0.41132611f, -0.04478127f, -0.10067453f, 0.09364644f, 0.14235471f, 0.17619747f, -0.04316186f, 
    -0.25297818f, 0.13069080f, -0.06736232f, -0.64411533f, -1.06659567f, 0.08614813f, 0.31294590f, 0.78501993f, 
    -0.59856987f, -0.43983951f, 0.13044165f, 0.80438328f, 0.38104308f, -0.49280208f, -0.05400920f, 0.29498026f, 
    0.01870148f, 0.30366197f, -0.06266099f, 0.00483529f, 0.14562871f, 0.14463587f, -0.28340191f, -0.27639261f, 
    0.32166055f, -0.24992083f, 0.05896476f, 0.24823394f, -0.37025568f, -0.73910964f, -0.05199710f, -0.34810796f, 
    -0.21061210f, 0.22665867f, -0.53173804f, -0.89112389f, -0.53060400f, -0.03815164f, -0.17220937f, -0.31748524f, 
    -0.08692992f, 0.48685437f, -0.19345473f, 0.11469559f, 0.02735168f, -0.38301045f, -0.41652218f, -0.32787758f, 
    -0.57157439f, -0.10469922f, -0.17832310f, -0.23566733f, -0.11333311f, 0.57443869f, 1.18857682f, 0.77177411f, 
    -0.98540360f, -0.78048414f, -0.50687391f, -0.38856533f, -0.22376016f, -0.12038083f, -0.32719597f, 0.25075573f, 
    0.17824101f, 0.46400073f, -0.11755498f, 0.05504055f, 0.33506763f, 0.06204678f, 0.00170192f, -0.33296144f, 
    -0.40719563f, -0.22198629f, 0.31973007f, -0.04619197f, -0.25579536f, -0.20188867f, -0.73640800f, -0.58258820f, 
    -0.52970588f, -0.27222544f, 0.29709429f, -0.21181878f, -0.11962645f, -0.22771050f, -0.32479823f, -0.06283902f, 
    0.08636093f, 0.54181427f, -0.30409274f, -0.57042742f, -0.54071629f, 0.08362090f, 0.33525226f, -0.53406370f, 
    -0.22136609f, -0.49422100f, 0.10181956f, 0.25217032f, -0.07404044f, -0.39586219f, -0.48126739f, -0.65343761f, 
    0.30424976f, -0.22385876f, 0.06507078f, 0.37290588f, 0.34491369f, 0.23693064f, 0.32278192f, 0.27811524f, 
    0.36420372f, -0.08058265f, 0.13247450f, -0.27658370f, -0.23731168f, 0.32590133f, -0.09692240f, -0.12957044f, 
    0.08212095f, 0.02573654f, -0.00045503f, 0.01833577f, 0.24942683f, 0.10959187f, 0.12290298f, 0.25250366f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25982878f, -0.02633426f, 0.23524339f, 0.40026167f, 0.27172056f, 0.24060529f, 0.28934848f, 0.26301393f, 
    0.08069512f, 0.23460338f, 0.29191768f, 0.39734018f, -0.18159831f, 0.11198846f, 0.32778603f, 0.04472599f, 
    -0.17655617f, -0.10910105f, -0.00989839f, 0.09797201f, 0.03345286f, 0.25504643f, 0.21449462f, 0.26621014f, 
    0.32363096f, -0.22176665f, 0.38122737f, 0.44684470f, 0.19677763f, 0.38645875f, 0.21458985f, -0.07718956f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04391227f, 0.02099613f, 0.04906721f, 0.00538287f, -0.01382281f, -0.01261754f, -0.03131949f, -0.02786763f, 
    -0.02994618f, 0.01972162f, -0.01623204f, 0.00802640f, 0.02911043f, 0.01609409f, -0.00977488f, 0.03245771f, 
    0.04233718f, -0.03154472f, -0.05703306f, 0.02081606f, -0.05818773f, -0.02998455f, -0.05381359f, -0.02576563f, 
    0.00543152f, 0.02034992f, 0.00757410f, -0.05744214f, -0.00958752f, 0.01937803f, 0.01831612f, 0.00421011f, 
    -0.03544736f, 0.00946443f, -0.04672007f, -0.02519975f, -0.01924550f, -0.05656258f, -0.02959005f, -0.01918115f, 
    0.02896654f, 0.01908989f, 0.00705379f, -0.03969061f, -0.03519540f, -0.02992601f, -0.00330291f, -0.04446573f, 
    -0.07956025f, -0.02055813f, -0.03966925f, -0.05227574f, -0.00873730f, -0.05359731f, -0.00545732f, -0.00934442f, 
    -0.02382230f, -0.01475049f, -0.02977459f, 0.01887721f, 0.02273924f, -0.02678282f, -0.03280695f, 0.01117126f, 
    -0.04693657f, -0.00585715f, 0.00058926f, -0.02455653f, 0.01333382f, 0.00484661f, 0.04964105f, 0.04913207f, 
    0.00307586f, 0.02649723f, 0.04980869f, 0.05664201f, 0.04419617f, 0.00182000f, -0.00631471f, -0.03140592f, 
    -0.00258391f, 0.00601295f, 0.01527914f, -0.04014425f, 0.02896431f, -0.04714767f, -0.02233663f, -0.01083315f, 
    0.01878297f, 0.00917236f, -0.04037661f, -0.00765713f, -0.04262156f, 0.00461979f, -0.04090498f, -0.02795380f, 
    -0.00330208f, -0.00462817f, -0.08056342f, 0.00430791f, -0.06004334f, -0.01271055f, -0.03068206f, 0.03003629f, 
    -0.03696407f, -0.03152009f, -0.04823272f, 0.00711190f, -0.03542422f, 0.00079952f, -0.01798483f, -0.01221006f, 
    -0.00299231f, -0.04475944f, -0.00382764f, -0.04193185f, 0.02109553f, -0.03865256f, -0.06619067f, -0.05276752f, 
    0.00110680f, -0.00281964f, 0.02425113f, -0.03201511f, -0.02397986f, -0.05013029f, -0.01977832f, -0.01599488f, 
    0.03567360f, -0.02619037f, 0.00752120f, -0.05827372f, 0.02175177f, -0.03559262f, 0.00164789f, -0.05987748f, 
    -0.06171381f, -0.03300973f, -0.02917789f, 0.02693909f, 0.00378373f, 0.01366945f, -0.06865122f, 0.01082256f, 
    0.01881466f, -0.07010834f, -0.04423213f, -0.03010525f, -0.03753338f, -0.01933862f, -0.05136889f, -0.04424175f, 
    -0.04871516f, -0.03278223f, 0.01256973f, 0.00214099f, 0.01259667f, -0.03292568f, -0.02280169f, -0.06767925f, 
    -0.01904984f, -0.01198154f, -0.02694224f, -0.03415628f, -0.05474143f, 0.01594616f, -0.04489275f, 0.03892220f, 
    0.01062277f, -0.06874771f, 0.01507538f, -0.03316815f, -0.06207696f, 0.02200043f, -0.02250047f, -0.02935354f, 
    -0.00735670f, -0.00152653f, -0.02333052f, -0.02957223f, 0.03676612f, -0.01134083f, 0.00606303f, -0.06847260f, 
    -0.01277628f, -0.04775111f, -0.00885398f, -0.00496959f, 0.02049186f, -0.00698120f, -0.02564570f, -0.03898817f, 
    -0.04630028f, -0.05980388f, -0.01369940f, 0.01118030f, 0.00860496f, 0.05181988f, 0.01991993f, 0.00152714f, 
    -0.00033757f, -0.03928648f, 0.00333334f, 0.03747417f, 0.03537001f, 0.02434284f, -0.00063159f, 0.05089431f, 
    -0.02960390f, -0.05245510f, -0.00219481f, 0.03515734f, -0.02581296f, -0.01976430f, -0.07821649f, 0.01126901f, 
    -0.03601988f, -0.05977577f, -0.03837343f, -0.05954457f, 0.02579375f, -0.02184511f, 0.03788539f, 0.01797628f, 
    0.02475065f, -0.02754050f, -0.01705651f, 0.00186319f, 0.03837237f, -0.02040358f, 0.00708108f, -0.03174455f, 
    -0.00740730f, 0.00021917f, -0.03348747f, -0.02740735f, 0.00908635f, 0.01291750f, -0.02449370f, 0.01661249f, 
    -0.05143113f, 0.00185024f, -0.06403559f, 0.02880185f, -0.00306104f, -0.01998116f, 0.01342621f, 0.03457285f, 
    0.01189225f, 0.03881938f, -0.00826860f, 0.02379660f, -0.06207724f, -0.01762422f, 0.02322182f, -0.03104035f, 
    -0.04195893f, -0.05243053f, -0.00573110f, 0.00472674f, -0.04392862f, -0.03644792f, -0.06299498f, -0.05581495f, 
    -0.04584064f, -0.01752413f, 0.00234118f, -0.02285994f, 0.00504000f, -0.05200984f, 0.00242585f, -0.04034455f, 
    -0.01730554f, -0.03250774f, 0.00036865f, 0.01435585f, 0.00532523f, -0.02655699f, -0.03440193f, -0.05318213f, 
    0.02367579f, -0.03186954f, 0.01477784f, -0.03908805f, 0.01002941f, -0.04506486f, -0.05308380f, 0.01664525f, 
    -0.02358354f, -0.04015249f, -0.03722703f, -0.06009712f, -0.00867813f, -0.00000650f, -0.06329919f, -0.00982425f, 
    -0.00336439f, -0.03703015f, -0.07348079f, -0.04298754f, 0.00289536f, -0.06726915f, -0.06128576f, -0.06227947f, 
    0.02564761f, -0.03415268f, -0.06691594f, -0.04564363f, -0.01790176f, -0.05084763f, 0.01473485f, 0.01440843f, 
    0.01062769f, -0.02919737f, -0.02011219f, 0.03997267f, -0.02373845f, -0.03463518f, 0.01238426f, 0.01252912f, 
    -0.04635942f, -0.04039125f, 0.00024121f, -0.04694918f, -0.01362470f, -0.00606838f, -0.04927907f, 0.03994535f, 
    -0.03342560f, -0.03048928f, 0.01727549f, -0.00759684f, 0.01693146f, -0.02539547f, -0.01885111f, -0.02990222f, 
    -0.01348319f, -0.03147077f, 0.01014067f, 0.03033238f, -0.00957572f, 0.01446140f, -0.05371266f, -0.01419760f, 
    -0.07591426f, -0.06631763f, -0.07320687f, -0.07092691f, 0.03240725f, 0.01835518f, -0.06919706f, -0.05485978f, 
    -0.05928925f, -0.04852658f, -0.02159541f, -0.03227162f, 0.02685791f, -0.04656130f, -0.01877213f, -0.07276552f, 
    -0.03517891f, -0.02685869f, 0.01458424f, 0.04267344f, -0.04956235f, -0.02562035f, -0.03880871f, -0.04812854f, 
    0.00481912f, -0.06189903f, 0.02635999f, -0.06913256f, 0.03268204f, -0.04350777f, -0.05630305f, 0.00911398f, 
    0.01958132f, 0.00259058f, -0.00363170f, -0.05016232f, 0.05778070f, 0.01440002f, -0.00703956f, 0.02731056f, 
    0.00747812f, 0.03510450f, 0.01180396f, 0.02868909f, -0.05301678f, 0.02630217f, -0.05594764f, -0.00598710f, 
    -0.04308769f, 0.03643186f, 0.01144486f, -0.04957620f, -0.04267329f, -0.03883815f, -0.01624209f, -0.01739683f, 
    0.01430263f, 0.02829533f, 0.02567565f, 0.02909384f, -0.01950676f, -0.03946718f, 0.01957545f, -0.05989405f, 
    -0.05104049f, 0.01619174f, -0.04803120f, 0.00963834f, 0.03124910f, 0.01395823f, 0.01414263f, 0.03751860f, 
    0.01976790f, 0.00427661f, -0.02873431f, -0.02770519f, 0.03045578f, -0.04278351f, -0.01100991f, 0.01786607f, 
    -0.03931177f, -0.04425551f, -0.03952626f, -0.00108512f, -0.02773771f, 0.00052871f, -0.01066465f, -0.05143212f, 
    -0.04011226f, 0.00151616f, -0.02612017f, -0.05754874f, 0.00096700f, 0.01518290f, 0.00773206f, 0.01473411f, 
    -0.01648161f, 0.02765390f, -0.04895137f, -0.00352271f, 0.03712972f, -0.02245116f, -0.00823982f, -0.02874281f, 
    0.01040015f, 0.03187818f, 0.03664037f, -0.00407401f, 0.03554999f, 0.03664630f, 0.00814964f, -0.05439253f, 
    -0.05548121f, -0.04384254f, 0.00695205f, 0.02896909f, -0.01263316f, -0.03658899f, -0.00808336f, 0.01775354f, 
    -0.05142977f, -0.00230701f, 0.01704673f, -0.00456449f, 0.01926131f, 0.02376389f, -0.06128874f, -0.00562251f, 
    -0.01746072f, -0.04633236f, -0.01922330f, 0.01265773f, 0.02375886f, 0.02649697f, 0.01767739f, 0.01574890f, 
    -0.04668098f, 0.03361481f, -0.01733512f, -0.04597428f, -0.03312678f, -0.03093968f, -0.00054324f, 0.00598414f, 
    -0.04288774f, -0.04840060f, 0.00058159f, -0.02840284f, 0.01842735f, 0.00807584f, 0.03532266f, -0.02367378f, 
    -0.03501232f, 0.00243245f, -0.03134647f, 0.00884838f, -0.03516238f, -0.01392732f, 0.03273637f, 0.01214375f, 
    -0.04242382f, -0.04679171f, 0.00122405f, -0.04340808f, -0.01187712f, 0.00477847f, 0.00157052f, -0.02480165f, 
    0.00915109f, -0.03081507f, 0.04272585f, -0.02529632f, -0.06374085f, 0.02308683f, 0.01493140f, 0.03517622f, 
    -0.04903514f, -0.05799048f, 0.03755492f, -0.05565998f, 0.02736850f, -0.03935238f, 0.00960412f, -0.04943091f, 
    0.03042813f, -0.01152314f, -0.00739626f, 0.01887080f, -0.00532415f, -0.03604852f, 0.04096971f, 0.02322239f, 
    -0.00314792f, -0.01550476f, 0.02591764f, -0.00975298f, 0.01512894f, -0.04006639f, -0.02922885f, 0.03841088f, 
    -0.02080577f, -0.01696551f, 0.03839284f, -0.03615167f, 0.00059911f, 0.01464408f, -0.02474774f, 0.01158703f, 
    0.03164484f, 0.03975923f, 0.00843713f, -0.02626275f, -0.04288134f, -0.01281315f, 0.02257315f, -0.01962336f, 
    -0.04842481f, -0.02867270f, -0.02623446f, -0.01566112f, 0.02197311f, -0.01006746f, -0.03427044f, -0.03682027f, 
    0.02400744f, -0.03732412f, 0.03630764f, -0.01902909f, -0.04293505f, -0.05185911f, -0.03302183f, 0.01903248f, 
    -0.03955211f, -0.04161836f, 0.00379897f, -0.03282963f, 0.02088689f, -0.03663538f, -0.00077680f, -0.04104137f, 
    -0.01069725f, 0.04246485f, 0.03215310f, -0.03509921f, -0.04917973f, 0.01991295f, -0.01774514f, 0.01397634f, 
    -0.03841035f, -0.00237978f, 0.02605459f, 0.01328579f, 0.01204070f, -0.01234737f, -0.04045137f, -0.05239607f, 
    0.01069890f, -0.01638080f, 0.00236327f, -0.04686439f, 0.04154020f, -0.01626362f, -0.01299603f, -0.02471754f, 
    -0.01689004f, 0.03863039f, -0.03191444f, 0.01920352f, 0.03214394f, 0.01629252f, -0.04722919f, -0.05218139f, 
    -0.01784940f, -0.02672806f, 0.00594772f, -0.05848764f, -0.03751516f, -0.00565424f, 0.00133499f, 0.05198658f, 
    -0.00285970f, -0.02339762f, 0.03375763f, 0.02608272f, -0.04214399f, -0.00543108f, 0.02068375f, 0.01880990f, 
    0.00664977f, 0.00379775f, 0.01504840f, 0.02639632f, -0.03456536f, 0.03170731f, 0.02518722f, 0.01901277f, 
    0.00687109f, -0.03625911f, 0.01889644f, -0.05396406f, 0.02159639f, 0.02593656f, 0.02393817f, 0.03611238f, 
    -0.00858533f, 0.00053019f, -0.03913009f, -0.05723369f, -0.04017761f, 0.03879869f, 0.00129560f, -0.05103049f, 
    0.02051851f, -0.03919780f, 0.02931098f, 0.02235513f, -0.01862068f, 0.01936131f, -0.04328590f, 0.02303482f, 
    0.02662707f, -0.02155607f, 0.01888257f, -0.03192832f, -0.02215751f, 0.01837117f, -0.03131196f, 0.02317622f, 
    -0.06035106f, -0.05031623f, 0.00724645f, -0.03573297f, -0.01526958f, 0.00996518f, 0.03311423f, -0.02824586f, 
    -0.01485106f, 0.02499005f, 0.00474433f, -0.04095301f, -0.01648284f, -0.04808727f, 0.00126902f, 0.02697731f, 
    0.01981852f, 0.04083258f, -0.00857214f, -0.03470349f, 0.01586715f, 0.02685917f, 0.05053953f, 0.01338364f, 
    -0.03305395f, -0.00264999f, -0.00106874f, 0.02919038f, -0.04117877f, -0.03130687f, 0.04222273f, -0.02475693f, 
    0.03562555f, 0.00372546f, -0.02608158f, 0.00371264f, -0.02632138f, 0.00473177f, -0.01529108f, -0.00132804f, 
    -0.00313944f, -0.03890799f, -0.03480071f, -0.03892539f, -0.04175444f, 0.04850209f, 0.03871948f, -0.03378355f, 
    0.03403922f, -0.03196940f, -0.00504093f, 0.00155925f, 0.03890049f, 0.04841604f, 0.00447161f, -0.00193358f, 
    0.00960417f, -0.04245244f, -0.03682749f, 0.01930448f, 0.03671167f, -0.03539956f, -0.03488329f, 0.01760908f, 
    0.01064949f, -0.06223368f, 0.03082657f, -0.02656398f, 0.05573024f, -0.01708752f, 0.03581659f, 0.00342162f, 
    -0.01498858f, -0.02442397f, -0.01190609f, -0.05192332f, -0.02080322f, -0.03013211f, -0.03176120f, -0.00284362f, 
    -0.00966496f, 0.01081026f, -0.04306622f, -0.05568707f, 0.00019897f, 0.01488295f, -0.00809388f, -0.06216114f, 
    0.02649709f, -0.05340544f, 0.02552735f, -0.00463510f, -0.04787776f, -0.00145248f, -0.02830035f, 0.02693035f, 
    -0.49143115f, -0.23337105f, 0.18570985f, 0.24823950f, -0.02780518f, -0.09686735f, 0.12331857f, 0.03808143f, 
    -0.08789559f, -0.04600464f, 0.26472691f, 0.16186844f, 0.08623114f, -0.03587073f, 0.13842890f, 0.08325927f, 
    -0.03290716f, -0.05957884f, -0.15271358f, -0.00052386f, 0.13576989f, -0.05044228f, -0.06235145f, -0.14833771f, 
    0.35541281f, -0.06430961f, 0.14872497f, 0.25057340f, 0.21721119f, 0.05957084f, -0.00933393f, -0.05481738f, 
    -0.00737402f, -0.06802166f, -0.08327457f, 0.19142003f, -0.06521460f, -0.01592691f, 0.37175024f, 0.17213546f, 
    -0.18237214f, 0.05545092f, 0.05855561f, -0.20450006f, 0.12787813f, 0.16220203f, -0.09095833f, -0.24049440f, 
    -0.17759608f, 0.14709805f, 0.22388111f, 0.15207647f, -0.03117745f, 0.01482149f, 0.15871972f, 0.07142918f, 
    0.00170479f, 0.23884621f, -0.00813975f, 0.04536698f, 0.31049889f, -0.00202308f, 0.02447654f, 0.10203814f, 
    0.02911953f, 0.02312841f, -0.02020376f, -0.01512946f, -0.11194990f, -0.09969772f, -0.01351619f, 0.00068010f, 
    0.20308435f, -0.44532406f, -0.06826066f, -0.01390278f, 0.10325790f, 0.16052774f, -0.10031337f, 0.07042849f, 
    0.05574648f, -0.21814376f, -0.01168537f, -0.09268575f, -0.07210367f, 0.00365306f, -0.00773436f, -0.09615403f, 
    0.10801128f, 0.02957835f, -0.13489074f, -0.11959046f, 0.03194148f, -0.00757587f, 0.02943780f, 0.02203108f, 
    -0.03686527f, -0.08717438f, -0.15483449f, -0.04795229f, -0.04092658f, 0.21245606f, 0.15574230f, 0.00407318f, 
    0.01980347f, 0.10640187f, 0.07429790f, 0.10278569f, 0.50686014f, 0.23723893f, -0.22110666f, -0.06141625f, 
    0.10014513f, -0.12947217f, -0.00859879f, 0.13062496f, -0.13232376f, -0.06954186f, 0.00995634f, -0.00349348f, 
    -0.12477209f, -0.22480606f, -0.09165311f, 0.05557413f, 0.03260515f, 0.02529312f, 0.05519741f, 0.01919371f, 
    -0.00092563f, -0.07125634f, 0.06194206f, -0.06561260f, 0.22394700f, -0.10648661f, -0.02586476f, 0.18226762f, 
    -0.01696790f, 0.02037897f, 0.03439195f, 0.00161340f, -0.14382425f, -0.00363678f, -0.14560555f, -0.02901647f, 
    -0.04651932f, 0.00136891f, -0.20245950f, -0.11257022f, -0.02208705f, 0.11022884f, -0.07365022f, -0.00054282f, 
    0.14899576f, 0.09972725f, 0.13157849f, 0.11156400f, 0.01670544f, -0.17930458f, -0.09180063f, -0.21245082f, 
    0.08427611f, -0.22349066f, -0.06295086f, 0.14187145f, -0.10041949f, -0.15229641f, 0.13002720f, 0.09722123f, 
    -0.11586852f, 0.06830831f, 0.01814530f, 0.32883379f, -0.13019349f, -0.04953715f, 0.06559983f, -0.25330770f, 
    -0.10265703f, 0.16411759f, 0.13747965f, -0.11954020f, 0.15498003f, 0.49525616f, -0.29785776f, 0.15132697f, 
    -0.09971939f, -0.07573461f, 0.08436397f, -0.04012425f, -0.09548362f, 0.03629132f, 0.47086748f, -0.03303245f, 
    0.09380166f, -0.25756919f, -0.06032061f, -0.05659273f, 0.08698002f, 0.02899043f, 0.05396331f, -0.03982133f, 
    -0.01919093f, 0.10928515f, 0.25007629f, 0.24480891f, -0.14973527f, -0.13664173f, -0.20831951f, 0.09549745f, 
    0.08378092f, -0.22840197f, -0.00423454f, -0.03595328f, 0.02748998f, -0.03778240f, -0.17877184f, -0.14291574f, 
    0.09873764f, -0.03860059f, 0.08889205f, -0.05974219f, -0.00616586f, 0.06865687f, 0.05358603f, -0.03843088f, 
    -0.12515923f, -0.21522167f, -0.00732771f, -0.09860691f, 0.09678582f, -0.51397902f, 0.28767347f, 0.20774923f, 
    0.01352892f, -0.05337495f, 0.13001588f, 0.14132138f, 0.02089619f, -0.17153476f, 0.12149408f, 0.03834734f, 
    -0.06676913f, -0.04665164f, 0.08698254f, 0.08408178f, 0.06491966f, 0.29970354f, -0.03177514f, -0.05268652f, 
    -0.07838969f, -0.05981530f, 0.06645183f, 0.04358497f, 0.19130729f, -0.05537004f, -0.01553898f, -0.07011843f, 
    0.12596102f, -0.02999514f, 0.05061306f, -0.00402561f, -0.17349578f, 0.25425977f, -0.03148473f, 0.04730621f, 
    -0.14135534f, -0.38231865f, -0.05247703f, -0.02083740f, 0.18105248f, -0.06500059f, 0.00220057f, 0.25601327f, 
    -0.05253146f, 0.09455772f, 0.02719441f, -0.11759149f, -0.16562180f, 0.02817573f, 0.29226226f, -0.08915680f, 
    -0.24226533f, -0.14345014f, -0.14317131f, 0.04665880f, -0.05869148f, -0.04294073f, -0.18125416f, 0.14471266f, 
    -0.04064735f, -0.15864880f, -0.02447218f, 0.18113427f, 0.07952257f, -0.17632124f, -0.12432127f, -0.08596718f, 
    -0.08476762f, 0.12777291f, 0.04233369f, 0.02608092f, 0.03390696f, 0.24285877f, -0.17203678f, -0.02740901f, 
    0.12526095f, 0.09110554f, 0.26377413f, 0.19783102f, 0.18292469f, -0.05801034f, 0.14206415f, 0.12523642f, 
    -0.56564319f, 0.59890926f, 0.00051825f, -0.10858792f, 0.06334194f, 0.19949363f, -0.08579198f, -0.17101479f, 
    -0.18723671f, 0.05607027f, 0.16888390f, 0.14561683f, 0.48540407f, -0.07383858f, -0.25666460f, -0.31820181f, 
    0.38106740f, -0.13990989f, 0.02315550f, -0.02121372f, 0.15925841f, 0.20350786f, -0.00981076f, 0.16006427f, 
    -0.20474109f, -0.22304699f, -0.05163766f, 0.06333708f, 0.02928168f, 0.12853244f, 0.03405216f, 0.11783588f, 
    0.03775268f, 0.00312130f, -0.02004593f, 0.04329155f, 0.01487792f, 0.35678849f, 0.02607961f, -0.03539827f, 
    -0.03057940f, 0.03987463f, 0.16947514f, 0.29282284f, -0.00304592f, 0.14899397f, 0.13608411f, -0.07480066f, 
    -0.05594924f, -0.14728986f, -0.09657373f, 0.02894875f, 0.13721889f, 0.05313914f, 0.02670730f, 0.06743079f, 
    -0.00694200f, 0.28466120f, 0.08155968f, -0.12645522f, -0.18832193f, 0.05841054f, -0.10027509f, 0.01295175f, 
    0.00820244f, -0.10588411f, -0.03672950f, 0.00656402f, -0.19057170f, -0.01392681f, -0.03561040f, 0.01913644f, 
    -0.18779190f, 0.25131583f, 0.23303166f, 0.12787163f, -0.00192008f, -0.00466595f, -0.01993249f, -0.02009069f, 
    -0.22196494f, 0.00091450f, 0.13001624f, 0.14936000f, -0.45395857f, -0.42341971f, 0.05835254f, 0.30154276f, 
    -0.08419640f, 0.09656542f, -0.12805492f, -0.05008363f, 0.04973321f, -0.04477124f, -0.09293545f, -0.08041169f, 
    0.21336523f, 0.16609508f, 0.04446376f, 0.02135187f, 0.14399624f, -0.08291775f, -0.01574642f, 0.25086039f, 
    -0.02514802f, -0.08186591f, -0.04776693f, 0.04171140f, -0.01406478f, -0.00919236f, 0.27806944f, 0.48647365f, 
    -0.05598849f, 0.17186476f, 0.19067784f, -0.14001286f, 0.00161123f, -0.09202420f, 0.03151140f, 0.10970993f, 
    -0.03554575f, 0.25262335f, 0.31195116f, -0.15482639f, 0.05823253f, -0.03992989f, 0.13654731f, 0.10284435f, 
    0.08641512f, 0.11718161f, 0.02304381f, -0.03994186f, 0.09307440f, 0.14613107f, 0.19140933f, -0.23553474f, 
    0.02285536f, 0.03431534f, 0.13701536f, -0.10366464f, -0.05000105f, 0.20167764f, 0.05655849f, 0.04489284f, 
    -0.20989150f, -0.17089067f, 0.15882133f, 0.37152490f, 0.01110997f, -0.00754582f, 0.03420177f, 0.07350563f, 
    0.05022981f, -0.02389326f, -0.02224868f, -0.01674756f, -0.16934717f, 0.27960035f, -0.06495421f, 0.02927283f, 
    0.05446748f, 0.06141029f, -0.01893395f, -0.11033481f, 0.03419386f, 0.03714297f, -0.00508619f, -0.00304536f, 
    0.15007834f, 0.04762668f, 0.11188713f, -0.02773464f, -0.05140208f, 0.04531030f, 0.11080003f, -0.01764557f, 
    0.17201632f, 0.14970437f, -0.04951761f, 0.07658568f, 0.07435341f, -0.01230756f, 0.03949666f, 0.15250587f, 
    0.05732108f, 0.04528031f, 0.05091633f, 0.00884056f, -0.09796638f, -0.08376674f, -0.01876082f, -0.07460897f, 
    -0.14874503f, -0.22429271f, 0.06721093f, 0.22387697f, -0.00249697f, 0.01589400f, -0.16008833f, 0.07120962f, 
    -0.17317091f, 0.11852312f, 0.18501785f, 0.08549541f, 0.16638882f, -0.11391623f, 0.18334985f, 0.16169472f, 
    -0.02684686f, 0.13645759f, 0.02751696f, -0.05751236f, 0.01653743f, 0.08196861f, 0.00691328f, -0.08139000f, 
    0.12999339f, 0.11783341f, -0.13042781f, 0.02377268f, -0.13917106f, 0.00595440f, -0.00205075f, -0.12645668f, 
    0.06106443f, 0.10758890f, 0.03521670f, 0.04850361f, 0.24062298f, 0.03925928f, -0.12308776f, -0.07048619f, 
    -0.05586062f, 0.10315182f, -0.06168386f, 0.10524471f, -0.06445688f, 0.10083108f, 0.08030597f, 0.06809594f, 
    0.09181239f, -0.05413703f, 0.11600909f, 0.03052846f, -0.18210877f, 0.00801663f, 0.18502103f, -0.10220029f, 
    -0.04041209f, 0.13843161f, 0.03042075f, 0.03248248f, 0.00584940f, 0.37363455f, -0.19393553f, 0.42462841f, 
    0.03316663f, 0.01123468f, -0.02661344f, -0.14865051f, 0.07617550f, -0.06516623f, 0.18662068f, 0.02854350f, 
    0.04256194f, -0.10259594f, 0.08130922f, 0.07393851f, 0.06781275f, -0.23847093f, -0.17916097f, 0.05393716f, 
    0.02993738f, -0.05423117f, -0.06296567f, -0.11771742f, -0.15303664f, -0.02125993f, 0.22437482f, 0.03702494f, 
    -0.21371508f, -0.13383882f, -0.04151282f, -0.02789650f, 0.00236324f, -0.00958024f, -0.10419860f, -0.11256745f, 
    0.30310214f, 0.00172602f, -0.04701803f, -0.15469137f, -0.15306900f, 0.01429553f, 0.06987041f, 0.09342606f, 
    -0.00293815f, 0.02039419f, -0.10021108f, -0.05312198f, 0.12354013f, -0.37212494f, 0.02939009f, 0.26092541f, 
    -0.06471115f, 0.05800952f, 0.24174905f, -0.03076166f, 0.07339344f, 0.09487902f, -0.08643050f, -0.02118363f, 
    -0.02167012f, 0.23073415f, 0.10450497f, -0.05547845f, -0.03483197f, -0.29806656f, -0.04291686f, -0.10437157f, 
    -0.00240354f, -0.01801481f, -0.02612687f, -0.09854229f, 0.09366105f, -0.01104282f, 0.31860915f, -0.11806308f, 
    0.01230677f, -0.01155647f, -0.10494100f, -0.10438293f, 0.02523751f, 0.05465566f, -0.01685832f, -0.19322245f, 
    -0.33933252f, 0.01262806f, 0.20385075f, 0.11304399f, -0.05628832f, -0.13609703f, -0.05938767f, 0.21915679f, 
    -0.00227581f, 0.09471325f, -0.06527966f, -0.04968981f, 0.21229620f, -0.01835021f, 0.30024713f, -0.18721992f, 
    -0.11584754f, 0.12340175f, 0.06127607f, 0.00750731f, -0.09066748f, -0.00636515f, -0.03773557f, 0.06890924f, 
    0.26116300f, 0.05403240f, 0.22308424f, -0.05768152f, -0.04968315f, 0.12998480f, 0.18638052f, 0.05539340f, 
    -0.07790110f, 0.04247798f, 0.03533418f, 0.03144505f, -0.01282294f, 0.07260378f, 0.16627593f, -0.10616926f, 
    0.01996434f, -0.02678980f, -0.17714818f, 0.17534594f, -0.04199508f, -0.05775178f, -0.15197286f, 0.14922133f, 
    -0.65754759f, 0.05557708f, 0.17144442f, 0.20291869f, 0.15447120f, 0.18416396f, -0.05827118f, 0.00909859f, 
    -0.10475187f, 0.01767010f, 0.09539545f, -0.01135458f, -0.01241972f, -0.10166528f, -0.01449628f, 0.32695580f, 
    0.05459747f, 0.00241451f, 0.10377245f, 0.01276454f, -0.03862000f, 0.19656120f, 0.14076643f, -0.09601294f, 
    -0.33159798f, -0.06166485f, -0.03969266f, 0.28425840f, 0.04048010f, -0.03684565f, -0.07364964f, 0.09064326f, 
    0.08599120f, 0.27371261f, -0.00992129f, -0.01661035f, -0.05336105f, 0.00612982f, 0.30521312f, -0.14989063f, 
    0.11291935f, -0.07021816f, 0.19492298f, 0.10471690f, 0.07698270f, -0.12408664f, -0.02545362f, 0.14222057f, 
    -0.23471984f, -0.19921327f, 0.03933870f, 0.10684464f, 0.12564923f, -0.16447172f, -0.07369446f, 0.16046509f, 
    0.11240449f, 0.06458556f, 0.10487937f, -0.00694018f, -0.06518760f, -0.01474184f, -0.06874581f, -0.04237231f, 
    0.04053383f, 0.01533217f, -0.06043932f, -0.04784033f, 0.06460359f, 0.06731844f, -0.05871620f, -0.10981733f, 
    0.01826864f, -0.05121314f, 0.01807824f, 0.01965035f, -0.04312803f, -0.01384638f, -0.03133436f, -0.03643575f, 
    0.01870808f, -0.03568269f, -0.02462385f, 0.04143008f, -0.01459000f, -0.01455815f, 0.03367866f, -0.05397496f, 
    0.01708808f, 0.02805243f, -0.04687202f, -0.05622298f, 0.04452212f, 0.01028527f, -0.00861571f, -0.01600694f, 
    0.04243216f, 0.04170556f, 0.01761648f, -0.01120772f, -0.01805000f, -0.02970840f, -0.02738305f, -0.03545908f, 
    -0.03065710f, 0.00239030f, 0.01569408f, 0.04264039f, -0.04219757f, -0.04478275f, -0.00985761f, -0.02533404f, 
    0.04012579f, -0.01094692f, 0.02001753f, -0.02451899f, -0.00487269f, 0.02183967f, -0.01789813f, -0.00440320f, 
    0.03163299f, 0.00404410f, 0.01661647f, -0.01334279f, -0.01306749f, -0.03682328f, -0.05639925f, -0.00344496f, 
    0.02553262f, 0.04270991f, -0.03052322f, 0.00096542f, 0.01107224f, -0.01566440f, -0.00046480f, 0.00100647f, 
    -0.02429739f, -0.05277442f, -0.04781744f, -0.05047562f, -0.03349843f, 0.01554506f, 0.01585335f, -0.00002174f, 
    -0.02709539f, 0.04429399f, 0.01948029f, -0.00300935f, 0.01577054f, 0.00207212f, 0.03910602f, -0.04123544f, 
    0.02221856f, -0.03504234f, 0.01294714f, -0.02963444f, -0.01392308f, 0.02867188f, -0.03688423f, -0.02698208f, 
    -0.00753139f, -0.02183396f, 0.02532727f, -0.00694712f, 0.01037558f, -0.00935000f, -0.04522221f, -0.04839857f, 
    0.00711668f, 0.01418014f, 0.01479382f, -0.04484651f, -0.02369886f, 0.02521835f, -0.03638422f, 0.01622015f, 
    0.03324415f, 0.02931660f, -0.00849390f, 0.01463514f, 0.02236286f, -0.00067230f, -0.04660496f, 0.01189515f, 
    -0.00460840f, -0.05544743f, -0.01996274f, 0.04927555f, -0.05036302f, -0.01469622f, 0.00981871f, 0.01260939f, 
    -0.02838073f, -0.01821442f, 0.03888403f, 0.02199619f, -0.04339042f, 0.02081562f, -0.00978093f, -0.01616353f, 
    0.02263443f, 0.02638590f, -0.02058247f, -0.00268359f, 0.03444253f, -0.03494375f, -0.02650049f, -0.05161984f, 
    -0.04441589f, -0.03472161f, 0.02526121f, -0.01254257f, -0.03990637f, 0.01450342f, 0.00622560f, 0.00788157f, 
    -0.04643284f, 0.03970173f, -0.04806275f, 0.01331849f, 0.04111391f, -0.00801877f, 0.03168162f, -0.02366419f, 
    -0.05242448f, 0.03171752f, 0.00932787f, -0.03667974f, 0.00688098f, -0.00089321f, 0.02853864f, -0.02508658f, 
    0.01856218f, 0.03571150f, -0.04066932f, 0.00499633f, 0.02013908f, 0.03532801f, -0.01265595f, 0.04227843f, 
    -0.04705722f, 0.02959768f, 0.03124218f, -0.00754126f, 0.00248414f, 0.04370756f, -0.05280740f, 0.04445456f, 
    0.03138938f, -0.01494469f, -0.01934298f, -0.03177959f, -0.04954041f, -0.01691183f, 0.03289435f, -0.02238103f, 
    -0.00934092f, -0.01064549f, -0.01575460f, 0.01574752f, -0.04903265f, 0.02392868f, 0.01851127f, -0.04391917f, 
    0.00894145f, -0.00310276f, -0.03964926f, 0.01675596f, 0.01896515f, 0.01232844f, 0.03349676f, -0.03813440f, 
    -0.02094509f, -0.00244333f, -0.02361033f, -0.05323268f, -0.02541564f, -0.04806215f, -0.00858545f, -0.00303991f, 
    -0.03358737f, -0.03354551f, 0.02046004f, 0.04549219f, -0.04417548f, -0.01093246f, -0.01120059f, -0.02599610f, 
    -0.00482237f, 0.00305038f, -0.01965210f, -0.04828913f, 0.00095981f, 0.04274494f, -0.03434206f, -0.04953021f, 
    0.02166033f, 0.03419967f, -0.03999306f, -0.01673451f, 0.01838804f, -0.03058335f, -0.01110460f, 0.01020248f, 
    -0.02128614f, 0.00519588f, -0.03963359f, -0.05437418f, -0.04337718f, -0.02334952f, 0.00601288f, -0.00681484f, 
    0.01976543f, 0.01036039f, -0.01294431f, -0.00080775f, -0.04299029f, -0.02141404f, 0.02548245f, 0.01170795f, 
    -0.03175493f, 0.03738759f, -0.00747411f, -0.02851075f, -0.04507043f, -0.03678067f, 0.01235034f, -0.01512063f, 
    0.02684760f, 0.00762870f, -0.03903935f, 0.03809031f, -0.05427451f, -0.05612864f, -0.04733239f, -0.00085765f, 
    -0.04158672f, -0.01460069f, -0.00440172f, -0.02199330f, 0.03360036f, -0.00276506f, -0.03438341f, 0.03082094f, 
    -0.04125978f, 0.01636626f, -0.01694246f, -0.04092232f, -0.01830740f, -0.03441122f, 0.02175280f, 0.01926122f, 
    0.00633597f, -0.03597444f, 0.02765290f, 0.00015746f, -0.01765668f, -0.00612959f, -0.00540016f, 0.03158398f, 
    0.03593450f, -0.04201241f, 0.03901460f, -0.01245843f, -0.00523979f, 0.02201780f, -0.05422853f, -0.01166752f, 
    0.00084703f, 0.01273032f, -0.00231850f, 0.02559768f, -0.04282293f, -0.04729895f, -0.00794171f, 0.04268493f, 
    0.02064400f, -0.02071238f, 0.00606673f, 0.01631008f, 0.01880133f, -0.01703262f, 0.03096921f, 0.03620829f, 
    -0.01257222f, -0.05239635f, 0.01139493f, -0.02868569f, 0.03956110f, -0.00140267f, -0.03733888f, -0.01073881f, 
    -0.04018587f, -0.05566882f, -0.02205199f, 0.01597460f, -0.02099139f, -0.00301444f, -0.00282138f, -0.05235699f, 
    -0.02104490f, 0.02566088f, 0.04368523f, 0.02016358f, -0.03975305f, 0.01629438f, -0.03912688f, 0.00745785f, 
    -0.04760758f, -0.04121923f, -0.00505094f, -0.02137318f, 0.01047267f, -0.04215347f, -0.02079743f, 0.02666514f, 
    -0.01818497f, 0.02942178f, -0.04761879f, -0.05114177f, 0.01322694f, 0.02398887f, -0.01730917f, -0.03414869f, 
    0.00690225f, -0.03230600f, 0.03391930f, -0.03096410f, -0.00351538f, -0.05150517f, -0.02010486f, -0.04760026f, 
    -0.04910171f, 0.01705177f, 0.03017594f, -0.05172203f, -0.01788942f, -0.02279824f, -0.00384836f, -0.00835681f, 
    0.01165754f, -0.02749663f, 0.00848471f, -0.00134909f, 0.02809528f, -0.00853943f, 0.01915758f, -0.01467709f, 
    0.02261010f, -0.04923904f, 0.01229475f, -0.03079328f, -0.03828287f, -0.03239160f, 0.02296571f, 0.01955079f, 
    -0.03592198f, -0.02663451f, -0.02811771f, 0.01284374f, -0.05593538f, -0.03920998f, 0.02771367f, -0.01439760f, 
    -0.04843161f, -0.00438373f, -0.02416402f, -0.02665455f, 0.00793108f, -0.02304577f, -0.04585917f, -0.02276520f, 
    0.02490977f, -0.03383913f, -0.02560655f, 0.01104487f, -0.01074060f, -0.00754146f, -0.00155015f, 0.00579537f, 
    -0.01652978f, -0.03743416f, -0.01942084f, -0.02140012f, -0.01091188f, 0.00276615f, -0.03058113f, 0.03859553f, 
    -0.05403036f, -0.05538691f, -0.05071460f, -0.03500526f, 0.02993685f, 0.00057393f, 0.02400165f, -0.02995578f, 
    -0.00946442f, -0.04433229f, -0.01439966f, 0.00256947f, -0.04201701f, -0.02190483f, 0.00734388f, -0.01283460f, 
    -0.04873629f, -0.03802911f, 0.01616821f, -0.02060874f, -0.01293923f, -0.04326896f, -0.03720574f, -0.04850318f, 
    -0.00295759f, -0.02452474f, 0.04087231f, 0.03332673f, -0.01754811f, 0.04061329f, 0.04941480f, -0.00859467f, 
    0.01772019f, 0.02505251f, 0.03896911f, -0.01796031f, -0.01258276f, -0.04810764f, -0.03559154f, 0.01870283f, 
    -0.03072239f, -0.00814414f, 0.02207047f, -0.00648740f, -0.01147948f, 0.03569162f, -0.00976435f, 0.01563086f, 
    -0.01472455f, 0.03797375f, -0.04525450f, 0.04377875f, -0.00359149f, 0.01725562f, -0.03214315f, -0.04250344f, 
    -0.01000077f, 0.02038668f, 0.02483647f, -0.02951401f, -0.04558918f, -0.04306723f, 0.03928573f, 0.03746525f, 
    -0.01930022f, 0.01702385f, -0.03056734f, -0.00075119f, 0.02812674f, -0.02304608f, -0.05808879f, 0.00482051f, 
    0.02430554f, -0.02819451f, 0.01331092f, -0.02999143f, -0.02676608f, 0.02096071f, 0.00358880f, -0.04874290f, 
    0.00335802f, -0.01079084f, 0.00185557f, -0.00112618f, 0.01806403f, 0.01708197f, -0.01681966f, -0.03679134f, 
    -0.04416627f, -0.04353886f, -0.04619957f, -0.04281853f, -0.04267314f, -0.04913610f, -0.03779912f, -0.03625494f, 
    -0.03607447f, -0.04587642f, -0.02071009f, -0.03285621f, 0.04225229f, -0.02666769f, -0.02414315f, -0.04409432f, 
    0.01632137f, 0.00734421f, -0.01771391f, -0.04616612f, -0.03495327f, -0.02349987f, -0.04024368f, -0.03327950f, 
    -0.03396671f, -0.02696614f, -0.03290866f, 0.00038099f, -0.00745312f, -0.02782180f, 0.04144689f, -0.02879517f, 
    -0.03112512f, 0.04007665f, 0.03413649f, -0.05063960f, -0.04294481f, -0.00571709f, -0.01991187f, 0.01853945f, 
    -0.01381770f, -0.04844725f, 0.02294674f, 0.00726028f, 0.02873085f, 0.00447422f, 0.02917472f, -0.01488237f, 
    -0.01666008f, 0.02101327f, -0.02947458f, -0.04587168f, -0.04355305f, 0.01010844f, 0.03819402f, 0.01480506f, 
    -0.04211659f, -0.04462713f, -0.05865073f, 0.00611873f, -0.01044292f, -0.03096225f, 0.03508153f, 0.00650624f, 
    0.03382903f, 0.03497211f, -0.02399208f, -0.00882986f, -0.05213334f, -0.02214159f, -0.05186804f, 0.00110030f, 
    0.03805071f, 0.01765843f, 0.01017254f, 0.03540947f, -0.03449947f, 0.02346840f, -0.00278172f, 0.01856067f, 
    0.02730280f, 0.00543546f, -0.01406182f, 0.03109228f, -0.01835482f, -0.02820422f, -0.01253216f, -0.03474882f, 
    -0.03567037f, -0.04515729f, 0.02068492f, 0.02566546f, -0.04171288f, -0.01393026f, 0.00846548f, -0.05474397f, 
    0.00241549f, -0.02318758f, -0.04005425f, -0.00073476f, 0.01181777f, 0.03657295f, -0.00541751f, -0.00888378f, 
    -0.01350905f, 0.04795902f, -0.03544054f, 0.00305795f, -0.03926936f, 0.01383526f, 0.00991582f, -0.05794575f, 
    -0.03195235f, -0.05718606f, 0.00834103f, 0.02316825f, 0.00029672f, 0.02693740f, -0.03881887f, -0.02798527f, 
    0.02033216f, -0.03045923f, -0.01447722f, 0.04771860f, 0.00118302f, -0.01350126f, 0.01569076f, 0.02948296f, 
    -0.02746381f, 0.00751760f, -0.00187604f, -0.05069298f, -0.04315096f, -0.04089800f, -0.01922972f, -0.02722683f, 
    -0.01645869f, -0.01642403f, 0.00640987f, 0.00011383f, 0.03909011f, 0.00176237f, 0.02239604f, 0.01734370f, 
    -0.02674251f, -0.05520812f, -0.03223730f, 0.00237229f, -0.05042162f, 0.04032649f, -0.03250402f, -0.02586215f, 
    0.00465284f, -0.00174791f, -0.00157989f, -0.05753576f, -0.04253063f, 0.04643711f, 0.02198552f, 0.05042260f, 
    0.01058441f, 0.03136531f, 0.01416617f, 0.03511902f, -0.00070232f, 0.00179626f, -0.03301739f, -0.03341461f, 
    0.02222713f, -0.04902276f, -0.02921418f, -0.03044639f, -0.03359118f, -0.04011110f, -0.03128970f, 0.03589252f, 
    -0.04459704f, -0.02165039f, -0.00569173f, -0.03850598f, -0.01813001f, -0.01894546f, -0.00185950f, -0.00096372f, 
    -0.00537145f, -0.01329422f, -0.05454516f, -0.01639960f, -0.01579582f, 0.01876014f, 0.04037978f, 0.03351762f, 
    0.03395350f, -0.05096334f, 0.02392433f, 0.02195967f, -0.04186912f, -0.01158302f, -0.03456274f, 0.00955739f, 
    0.00383766f, -0.05039024f, 0.03678305f, -0.01832033f, -0.01841997f, -0.04576536f, -0.04661802f, -0.01859199f, 
    -0.04600510f, 0.00450994f, 0.00661174f, 0.03735049f, 0.02730461f, -0.00990989f, 0.01100969f, 0.01134826f, 
    -0.02999781f, -0.01324350f, 0.03515023f, -0.03745812f, -0.05563702f, 0.01271372f, 0.00102841f, 0.04203995f, 
    0.01516164f, 0.02404311f, 0.03860177f, -0.03693652f, 0.01105653f, 0.03761932f, 0.02332783f, 0.03548841f, 
    -0.04990454f, -0.04159378f, 0.01004548f, -0.01810306f, 0.03400237f, -0.00174502f, -0.01409036f, -0.05388402f, 
    -0.04838586f, -0.01020079f, 0.01026626f, 0.01960525f, -0.04084120f, 0.03582047f, 0.04150574f, 0.01042956f, 
    0.02734988f, -0.04319954f, 0.00551840f, -0.05778404f, 0.02552617f, 0.00454631f, 0.01628907f, -0.04537788f, 
    0.01364549f, -0.01070110f, -0.03935927f, -0.04917813f, -0.02938769f, -0.02090870f, 0.02532109f, -0.04739723f, 
    -0.06125353f, 0.01020646f, 0.41113147f, 0.08935343f, -0.03152412f, 0.05192817f, -0.27509370f, 0.10157648f, 
    0.07774958f, 0.17814945f, -0.03855637f, 0.06082137f, -0.20789362f, -0.06735344f, 0.20888768f, 0.26573247f, 
    0.05539273f, 0.18439892f, 0.12855980f, 0.04708625f, -0.04254344f, 0.00845675f, -0.00008833f, 0.15470216f, 
    -0.37378314f, -0.12037534f, -0.08676577f, 0.01381045f, 0.25318980f, 0.15135291f, 0.32563236f, 0.17367178f, 
    -0.04902182f, -0.04412469f, -0.00479905f, -0.04636989f, 0.17013529f, -0.05204080f, -0.40140015f, 0.28498340f, 
    0.27962035f, 0.03946188f, -0.04419760f, 0.04407445f, 0.08016477f, -0.16253109f, -0.08185983f, 0.04743061f, 
    -0.05314032f, 0.42916620f, -0.09864707f, -0.13450463f, 0.08385407f, 0.04298270f, -0.00306285f, 0.00714063f, 
    0.04036942f, -0.12594680f, 0.12801188f, -0.06710490f, -0.05611318f, 0.07581000f, -0.03555763f, 0.01171027f, 
    0.03265891f, 0.03330813f, -0.04728860f, 0.11231960f, 0.11319103f, 0.03025168f, 0.09672529f, -0.00201679f, 
    -0.04604862f, 0.19338916f, 0.04788838f, 0.32089141f, 0.00928817f, -0.05861645f, 0.01959248f, 0.01130684f, 
    -0.00910707f, 0.03233989f, -0.04897684f, 0.01672614f, -0.03440584f, -0.16256446f, 0.09190474f, 0.23967183f, 
    -0.04035067f, -0.09997987f, -0.05326295f, -0.05309016f, 0.05845764f, -0.00291380f, 0.12401224f, 0.11397537f, 
    0.10059147f, -0.22653386f, -0.11506840f, 0.04178671f, 0.00562784f, 0.08398303f, 0.09408546f, -0.16364820f, 
    0.05843608f, -0.00132085f, -0.06219903f, -0.10941495f, -0.08594816f, -0.21428238f, 0.04456519f, 0.12756859f, 
    -0.00250242f, 0.14071816f, 0.04769775f, 0.09375548f, 0.01025730f, -0.00229341f, 0.00317132f, 0.08057472f, 
    -0.11324807f, 0.15084752f, 0.17544252f, 0.10896427f, -0.03990947f, 0.07126565f, -0.09994132f, 0.12522760f, 
    0.02605356f, 0.05826126f, -0.16263902f, -0.14057268f, -0.05533874f, -0.01326263f, -0.11847597f, -0.09105694f, 
    0.00236785f, 0.13381825f, 0.04469433f, 0.04983201f, 0.09424703f, -0.01527312f, 0.11583081f, -0.02058821f, 
    -0.08999450f, -0.16848670f, -0.07782418f, -0.24278194f, -0.02682923f, 0.00826180f, -0.09099548f, -0.10421102f, 
    0.15745755f, 0.01120589f, -0.06620440f, 0.24126543f, -0.43140951f, -0.01776246f, -0.04545050f, -0.43201676f, 
    0.09886971f, -0.00862693f, -0.21562050f, 0.08247843f, 0.14426908f, 0.08925601f, -0.01154320f, 0.08513066f, 
    0.15463853f, 0.26261234f, -0.05909743f, 0.11949927f, 0.03289206f, -0.09666863f, 0.10104503f, -0.04006510f, 
    0.14690647f, -0.00852353f, 0.13797915f, 0.14066783f, -0.11900733f, -0.12723143f, 0.08698753f, -0.05967366f, 
    -0.14611578f, 0.04230770f, -0.07691055f, 0.06080358f, -0.07431677f, -0.00891807f, 0.12387892f, -0.04936244f, 
    -0.41509923f, -0.26024640f, 0.01422329f, 0.09188827f, -0.03102787f, -0.14082266f, -0.04820543f, -0.04319653f, 
    0.07066476f, -0.13306318f, -0.01222901f, -0.10199180f, -0.13078427f, -0.10469609f, 0.18305366f, -0.06301194f, 
    -0.03644663f, -0.03349203f, 0.05661656f, -0.01259777f, -0.02320779f, 0.03490517f, 0.06227779f, -0.04346416f, 
    -0.31565556f, -0.23073842f, -0.12762186f, -0.08998854f, 0.18552020f, 0.11976266f, 0.09203040f, -0.17236416f, 
    -0.05550458f, -0.05973789f, -0.13851416f, -0.12886760f, -0.02799478f, 0.07759774f, -0.25294244f, 0.21029314f, 
    0.06129378f, -0.06402151f, 0.01679078f, 0.02882248f, 0.03892424f, 0.10818775f, -0.00621912f, 0.08480130f, 
    -0.01764308f, 0.08394767f, 0.16901681f, -0.01578829f, 0.01535024f, -0.20546909f, -0.08380539f, 0.12305962f, 
    0.02838527f, 0.05850125f, -0.02498565f, -0.02712734f, -0.15333718f, 0.15611942f, 0.08756012f, 0.19706944f, 
    -0.03697336f, -0.02686995f, -0.04203910f, 0.07121594f, 0.05636208f, -0.06127509f, 0.07801895f, 0.09783445f, 
    -0.14221935f, -0.06884645f, 0.19407669f, -0.09710534f, -0.10667710f, -0.06230787f, -0.08634418f, -0.09146878f, 
    0.08029101f, 0.00309454f, 0.14626502f, 0.10656139f, -0.49021041f, 0.07555255f, -0.09293353f, -0.21236931f, 
    0.10513752f, 0.04209039f, -0.08626052f, 0.16089374f, 0.00239279f, -0.11364760f, 0.14278768f, -0.06256706f, 
    -0.02994814f, 0.04494936f, 0.14258406f, 0.02654491f, -0.07920996f, 0.00817411f, 0.12892921f, -0.11192672f, 
    0.14497732f, 0.07391278f, 0.13165262f, 0.04316627f, -0.12142194f, -0.15722926f, -0.01816357f, 0.03821936f, 
    -0.17198329f, -0.02059296f, -0.08794538f, 0.11615288f, -0.15856507f, -0.03748528f, 0.01521022f, -0.11642732f, 
    0.06999709f, -0.42056978f, 0.44191083f, 0.33169541f, -0.03712231f, -0.01009811f, -0.16996823f, 0.01344100f, 
    0.07896529f, -0.05162852f, -0.18007417f, -0.00318100f, 0.26173699f, -0.16395655f, 0.17271690f, 0.30641651f, 
    0.07537235f, 0.01325888f, 0.00727127f, 0.09625535f, 0.06875888f, 0.00287125f, 0.01179497f, 0.10215248f, 
    -0.10222591f, 0.04658394f, -0.04534138f, -0.24222329f, -0.06603163f, 0.02132705f, 0.08953436f, -0.03656648f, 
    0.05436353f, 0.04657478f, -0.04266907f, 0.08800931f, 0.00311818f, 0.27320039f, -0.11055832f, 0.18115923f, 
    0.20028058f, 0.04791092f, 0.28810635f, -0.06454828f, -0.00596513f, -0.02605394f, 0.06937958f, -0.00696611f, 
    -0.19728987f, -0.11374111f, 0.27399960f, -0.12722132f, -0.06276883f, -0.09308197f, -0.09049376f, -0.11976344f, 
    0.00683511f, -0.08946396f, 0.27873984f, -0.11081045f, 0.00135987f, -0.11330654f, 0.00706536f, -0.07889905f, 
    -0.08093667f, -0.06990220f, -0.10055687f, -0.03393132f, 0.08708067f, -0.08389410f, 0.03679595f, 0.14116189f, 
    -0.61188185f, 0.19750310f, 0.05787347f, 0.34350508f, 0.01905957f, 0.01941496f, -0.05622837f, 0.13174498f, 
    0.08188459f, 0.13830806f, 0.12318961f, 0.15632382f, -0.07727090f, 0.03622907f, 0.18651469f, 0.44598937f, 
    0.15019386f, 0.20559905f, -0.05193499f, 0.06612278f, 0.01033951f, 0.00724309f, 0.00463907f, 0.11656432f, 
    -0.59155399f, -0.18658057f, 0.13250121f, 0.35162070f, 0.16822924f, 0.01226580f, 0.03907566f, 0.20874780f, 
    -0.00211113f, -0.04670278f, -0.03677422f, -0.03998842f, 0.30636829f, -0.17611228f, 0.35513300f, 0.21214032f, 
    -0.06624505f, 0.03198490f, 0.03772774f, -0.17035957f, 0.04390040f, 0.04564761f, 0.00637586f, 0.11455689f, 
    -0.33733889f, 0.14889851f, -0.24370170f, 0.43628615f, -0.09565661f, -0.09604622f, -0.06810804f, 0.02276819f, 
    -0.08207582f, -0.03939862f, -0.06193566f, -0.10140423f, 0.11820068f, -0.01170250f, -0.16468516f, 0.30973345f, 
    -0.01944630f, 0.20475788f, -0.06247058f, 0.22779062f, 0.07469694f, -0.06695317f, 0.02669581f, 0.07874648f, 
    -0.09230900f, -0.02282715f, -0.14564034f, 0.42618525f, 0.19794881f, 0.26295802f, 0.02688428f, 0.07792825f, 
    0.00853710f, -0.02895159f, 0.03609110f, 0.04302651f, 0.10025153f, 0.37558088f, 0.00068545f, -0.66287792f, 
    -0.03703133f, 0.10045888f, -0.08311381f, -0.01740054f, 0.01830491f, 0.02642022f, 0.05940288f, -0.02480514f, 
    -0.03048754f, -0.02513528f, 0.11208804f, -0.08012266f, -0.08399217f, -0.01012271f, 0.12112128f, -0.06765597f, 
    0.15561981f, 0.03521413f, -0.06538742f, -0.11035786f, 0.29700056f, 0.08072331f, 0.13126153f, 0.20758463f, 
    -0.08344480f, 0.01177588f, 0.05612836f, 0.07520114f, 0.03274158f, -0.03374585f, 0.10135995f, 0.16939649f, 
    -0.16046582f, -0.00777721f, -0.22228120f, -0.07685859f, 0.13557300f, 0.31296769f, 0.00449281f, -0.03978324f, 
    -0.00159809f, 0.04070158f, -0.13420016f, -0.12717338f, -0.28940767f, 0.13058817f, 0.06795090f, -0.21540450f, 
    -0.00900388f, -0.08363669f, 0.02264031f, -0.10216182f, 0.09437642f, -0.01368074f, 0.01104180f, -0.00407690f, 
    0.04690775f, -0.00975932f, 0.07609440f, -0.27661845f, -0.16087794f, 0.01470151f, 0.01213174f, -0.05611953f, 
    0.20924187f, -0.08908296f, -0.03952227f, 0.12938298f, -0.38812822f, 0.40316060f, -0.19070005f, -0.13720459f, 
    -0.01823630f, -0.02589329f, -0.10040080f, 0.10456952f, -0.01789566f, 0.02003083f, 0.21119474f, 0.14858812f, 
    -0.20078014f, 0.05034239f, 0.12255201f, 0.31537622f, 0.04278267f, 0.00249831f, 0.01671222f, -0.03621215f, 
    0.05100961f, 0.03469704f, 0.11517347f, 0.05171714f, 0.09721147f, 0.36832967f, 0.09529714f, -0.39964834f, 
    -0.13941851f, 0.14277565f, -0.08682612f, 0.10983509f, -0.31523937f, 0.09504554f, 0.11561589f, -0.31307897f, 
    0.07347962f, -0.57165974f, -0.12921208f, -0.00773556f, 0.17538172f, 0.03875574f, 0.09230813f, 0.20146103f, 
    0.09176998f, 0.09712309f, 0.07434997f, -0.01600855f, -0.19741090f, -0.32582515f, -0.02400962f, 0.42457762f, 
    0.14022297f, 0.00711931f, 0.18071568f, -0.07566047f, 0.04030497f, 0.03298506f, 0.20887455f, 0.09281870f, 
    -0.43517959f, -0.27936888f, -0.04718565f, -0.19895658f, -0.03666681f, -0.13877079f, -0.02646782f, -0.15538898f, 
    0.04613049f, -0.06543213f, -0.10848635f, -0.15988322f, -0.00404381f, -0.05156774f, 0.23020652f, 0.30693898f, 
    -0.00085371f, 0.14448749f, 0.06318351f, 0.11324095f, 0.05252191f, 0.00875749f, 0.00111649f, 0.01562144f, 
    -0.02147216f, -0.09483244f, 0.03703562f, 0.14135635f, 0.13092446f, -0.04259561f, -0.00837821f, 0.16979735f, 
    -0.08354285f, 0.02122859f, -0.03984411f, 0.00452061f, -0.07135871f, 0.11212894f, -0.03844488f, -0.09111935f, 
    -0.03110285f, -0.08485832f, -0.11489759f, -0.02817155f, -0.03834721f, 0.11544225f, 0.04875281f, 0.07749250f, 
    -0.13618556f, -0.13672358f, -0.01230968f, 0.23778604f, 0.01740637f, -0.02822813f, -0.00916469f, 0.07094638f, 
    -0.00496209f, 0.06638624f, 0.12422132f, 0.00408291f, -0.15853265f, 0.14811663f, 0.16269474f, 0.12679857f, 
    -0.18535668f, -0.13471809f, 0.14602245f, 0.01938305f, -0.08175912f, -0.13219731f, 0.15733843f, 0.05210242f, 
    -0.03867165f, -0.04032714f, -0.05565777f, 0.28527737f, -0.14738706f, -0.13095817f, 0.08429202f, -0.16036673f, 
    0.14957969f, 0.11363561f, 0.27188641f, 0.14761715f, 0.37054014f, 0.04559737f, -0.06296419f, -0.04414731f, 
    -0.00684891f, 0.06694081f, 0.00612015f, 0.18233311f, -0.07295486f, -0.01142328f, -0.18514431f, 0.09795955f, 
    -0.13480891f, 0.52169806f, -0.00552450f, -0.16304496f, 0.05495640f, -0.08650026f, -0.05502105f, -0.03663249f, 
    -0.10092132f, 0.02789165f, -0.02205019f, 0.09747087f, 0.29001412f, -0.11427088f, -0.07938656f, -0.49563143f, 
    0.01643779f, 0.06601442f, 0.03828195f, -0.03246960f, 0.12809183f, 0.02028200f, -0.13664164f, 0.07072271f, 
    -0.33872518f, 0.03561850f, -0.04497818f, 0.08984444f, -0.03152993f, 0.08697468f, 0.05456518f, 0.03100903f, 
    0.03038793f, 0.03969025f, -0.08764967f, -0.00838325f, -0.09917414f, 0.13326162f, 0.00699907f, 0.36799893f, 
    0.07350256f, -0.02352713f, 0.16731226f, 0.07906976f, -0.00879431f, -0.16447739f, 0.04704308f, 0.01455351f, 
    -0.10056963f, -0.27728307f, -0.05013930f, -0.09516428f, 0.09428949f, -0.12478006f, 0.02295126f, 0.10807688f, 
    -0.08537556f, -0.03808480f, 0.03803702f, -0.04703844f, 0.17205943f, -0.20021786f, -0.04864090f, -0.45035857f, 
    -0.08648284f, -0.21850523f, -0.01574253f, -0.08118173f, 0.10844380f, -0.12717557f, 0.17892295f, 0.03645806f, 
    0.00954849f, -0.25587276f, -0.50258130f, 0.06809532f, -0.06467070f, -0.00700771f, 0.00437819f, 0.10011908f, 
    -0.13831836f, 0.02614166f, 0.03368053f, -0.02736522f, 0.10362087f, 0.02059532f, 0.11985903f, -0.07612360f, 
    0.02738837f, -0.12780102f, 0.03909215f, -0.05374481f, 0.00762751f, -0.12400855f, -0.00978617f, -0.11455543f, 
    0.46064371f, 0.10047224f, 0.11007567f, 0.00933967f, -0.07507672f, 0.02602546f, -0.03075980f, 0.02356714f, 
    -0.13735582f, -0.06809855f, -0.07245348f, 0.00611279f, -0.19164428f, 0.10386016f, 0.06457017f, 0.22473663f, 
    0.15468015f, 0.17185609f, 0.16101956f, -0.02590635f, -0.05940205f, 0.00453876f, 0.12490913f, -0.02675428f, 
    0.33766600f, -0.34805459f, 0.13549143f, 0.01271902f, -0.01040807f, -0.02459112f, 0.14396986f, 0.11733013f, 
    0.15596180f, -0.08953803f, 0.16796558f, -0.05350238f, -0.00336638f, -0.11276439f, 0.02591141f, -0.13888547f, 
    -0.00078175f, -0.10017198f, 0.00424386f, -0.10260368f, -0.01362436f, -0.03492443f, -0.08909498f, -0.19850875f, 
    0.00652346f, 0.05135718f, 0.01575824f, 0.22691728f, -0.02062131f, -0.11503928f, 0.10484578f, -0.22290982f, 
    0.00402964f, -0.00253140f, -0.09545377f, -0.07026207f, 0.01223589f, -0.00649877f, -0.06143156f, 0.07182052f, 
    -0.02395479f, -0.05774719f, 0.06070306f, -0.09335092f, 0.06174608f, 0.03064637f, 0.02724111f, -0.04323007f, 
    0.10677773f, 0.06495528f, 0.09068812f, 0.13530564f, -0.03202768f, -0.02794601f, -0.03727934f, -0.00616840f, 
    0.05109722f, -0.01923127f, -0.02924803f, 0.11573725f, 0.06194275f, 0.07985768f, 0.20166722f, -0.09204281f, 
    0.00127794f, 0.17118177f, -0.07754284f, -0.08161451f, -0.20129518f, -0.03297016f, -0.14501514f, -0.15785834f, 
    -0.28156903f, -0.03483092f, -0.35032645f, 0.01867345f, 0.08419890f, -0.14797600f, 0.03343740f, 0.00864013f, 
    0.01962114f, 0.10924823f, -0.00480225f, 0.03166209f, 0.30869681f, 0.23396082f, 0.12074483f, 0.31144139f, 
    0.00426139f, -0.01082226f, -0.02382530f, -0.03650905f, -0.08027746f, -0.03874531f, -0.06734554f, -0.12597330f, 
    -0.04018169f, 0.07283807f, -0.00161632f, 0.25852588f, -0.04506401f, -0.02250108f, -0.01105132f, 0.00020163f, 
    0.04194498f, -0.06251048f, 0.03153632f, -0.13083291f, 0.54994106f, -0.07558370f, 0.09052123f, 0.11904712f, 
    -0.13885090f, 0.07933859f, -0.08542901f, 0.08851270f, -0.00430360f, 0.01896509f, -0.10432595f, -0.12552887f, 
    0.37178069f, -0.02486048f, 0.33664024f, 0.17981094f, -0.08694363f, -0.00509878f, -0.04783665f, -0.06359736f, 
    -0.03301271f, 0.01424887f, -0.03869344f, 0.11104724f, 0.01604388f, -0.23728497f, -0.17399196f, 0.19593915f, 
    -0.05506790f, -0.04399810f, 0.01596051f, -0.08448812f, 0.00429381f, 0.03857721f, 0.02905709f, 0.28233147f, 
    -0.52439988f, -0.32610482f, -0.52299756f, -0.35918733f, 0.08442901f, -0.06571566f, -0.01114260f, -0.02284318f, 
    0.02428422f, -0.07154532f, 0.18211251f, 0.13174985f, -0.11714827f, 0.18838841f, -0.08241890f, -0.13363776f, 
    0.06755532f, 0.10736374f, -0.09054928f, -0.05582972f, -0.10121629f, -0.09222570f, -0.13879667f, -0.03447909f, 
    0.29385206f, 0.16762923f, 0.17079563f, 0.11748100f, -0.07248171f, -0.04309459f, -0.06739277f, 0.02153460f, 
    -0.11390796f, -0.10018482f, -0.00011623f, -0.03543462f, 0.62542164f, -0.30440146f, 0.12291197f, 0.11033999f, 
    -0.03778945f, 0.09181459f, 0.12811793f, 0.15409739f, -0.10110728f, -0.03929355f, -0.08767235f, 0.03287374f, 
    -0.23871115f, -0.30571520f, -0.24188609f, -0.14423425f, -0.05253712f, -0.02021320f, -0.06936535f, 0.00497097f, 
    -0.17909791f, 0.05961723f, -0.03475475f, -0.10914195f, 0.28392133f, -0.00551530f, 0.32474750f, 0.04791797f, 
    -0.08044918f, -0.00024695f, 0.00970587f, -0.04932072f, -0.02447371f, 0.08225396f, 0.00161689f, 0.00251515f, 
    -0.10957243f, -0.33770403f, -0.11573246f, -0.04046731f, -0.01068301f, 0.03520251f, -0.15673654f, -0.01336471f, 
    0.01534933f, -0.02270621f, -0.07296522f, 0.05093513f, 0.30182269f, 0.07467357f, 0.02147114f, 0.10607640f, 
    0.06641504f, 0.08681283f, -0.08944624f, 0.01101925f, 0.07505754f, 0.03917104f, -0.06562939f, 0.04179969f, 
    -0.05843989f, -0.11367410f, -0.00592746f, -0.12588811f, -0.01951445f, 0.24784903f, -0.12184238f, -0.02397843f, 
    0.03003727f, -0.00967544f, -0.10220874f, -0.12132262f, -0.23260790f, -0.14665496f, 0.02179280f, -0.22245508f, 
    0.14385773f, -0.05334150f, 0.10185264f, 0.00380177f, 0.15191159f, 0.03782493f, 0.10081244f, 0.10156956f, 
    0.02490041f, 0.18220027f, 0.02441353f, 0.25563109f, 0.07851585f, 0.10181423f, 0.08234882f, -0.03905068f, 
    0.17462397f, 0.04977255f, 0.05703279f, 0.03411654f, -0.14474350f, -0.24744950f, 0.19360392f, -0.06465410f, 
    0.05423204f, 0.21258739f, 0.06421717f, -0.04384487f, -0.07543280f, -0.00664890f, 0.13877280f, -0.18580732f, 
    0.07316475f, -0.00603918f, -0.12500614f, -0.04981213f, 0.09727463f, -0.08017907f, -0.05264313f, -0.11670801f, 
    0.04586410f, -0.03380162f, 0.00227907f, 0.12396276f, 0.14613466f, -0.21673098f, 0.26575756f, -0.14565697f, 
    0.03831108f, 0.20564325f, 0.09850255f, 0.03537006f, 0.01249363f, -0.09615311f, 0.20312712f, 0.13641340f, 
    -0.26497453f, -0.03960216f, -0.15729272f, -0.17188595f, 0.09956256f, -0.06935419f, 0.11708112f, 0.10332671f, 
    0.02057596f, 0.06932700f, 0.20817727f, 0.06325346f, -0.11185047f, 0.08946679f, -0.05102547f, 0.03561625f, 
    -0.07651451f, -0.03844259f, -0.04242826f, -0.10087293f, 0.00288301f, 0.01979891f, -0.04946691f, -0.05478505f, 
    -0.48374432f, 0.47209898f, 0.28656366f, -0.11630807f, 0.02043446f, 0.01279587f, 0.14775236f, -0.05604715f, 
    0.04063942f, 0.00510618f, 0.16295820f, 0.04233960f, -0.05984142f, 0.06931263f, -0.09723575f, -0.18977048f, 
    -0.04692280f, -0.25041237f, -0.13007902f, -0.10603456f, 0.02713322f, 0.01642574f, -0.05178317f, -0.08956550f, 
    0.09126684f, 0.02826708f, 0.03165887f, 0.12259721f, -0.10040469f, -0.08884982f, 0.06863675f, -0.05632358f, 
    0.06042625f, -0.04774699f, -0.03842150f, 0.00050481f, -0.11598715f, -0.01711077f, 0.39575642f, -0.17270008f, 
    0.01454778f, -0.13862668f, -0.09194963f, 0.16940187f, 0.13761468f, 0.21900187f, 0.02550265f, -0.12023479f, 
    0.01857082f, 0.04927984f, 0.05649572f, 0.08274891f, -0.01816852f, -0.06220725f, 0.14136252f, -0.09542841f, 
    0.19678763f, 0.14414658f, 0.04874209f, 0.07156208f, 0.14218268f, 0.13592988f, -0.04835934f, 0.07386652f, 
    0.09783342f, 0.15164220f, -0.06856919f, 0.00714090f, 0.03897335f, 0.07064835f, -0.02054270f, 0.02055815f, 
    -0.13239750f, -0.36153826f, -0.00204381f, -0.25088611f, 0.04424540f, 0.19591805f, 0.13690080f, -0.13383649f, 
    0.01384929f, -0.09258628f, -0.01252765f, -0.03670998f, 0.06624449f, -0.08321760f, -0.12930672f, -0.08227213f, 
    0.11682585f, 0.01927392f, 0.01876656f, 0.03523547f, 0.00661451f, 0.10376870f, -0.05217259f, 0.01625834f, 
    0.06950909f, 0.12796423f, -0.03014516f, -0.02357100f, -0.02788401f, 0.01763224f, -0.06805605f, 0.06958264f, 
    -0.01485019f, -0.10055475f, -0.04017837f, 0.04849550f, 0.38970208f, 0.19697875f, -0.42624858f, 0.07808773f, 
    0.08840300f, 0.03510988f, 0.00766566f, 0.05230886f, -0.03984375f, 0.05884412f, 0.00617858f, -0.05122087f, 
    0.08021668f, -0.26836717f, 0.07122188f, -0.05280887f, -0.05537226f, -0.13641016f, 0.19470486f, 0.05314426f, 
    -0.01266849f, 0.00802151f, 0.13322531f, 0.12585260f, -0.02757317f, 0.15666838f, 0.17879853f, 0.06204227f, 
    0.07088039f, -0.08191348f, -0.05107975f, -0.03036583f, 0.09573364f, -0.04858691f, -0.15137358f, -0.03751780f, 
    0.07391541f, 0.09556243f, 0.00442642f, -0.04850601f, -0.02014714f, 0.01113126f, -0.04815823f, 0.04331803f, 
    -0.01086413f, -0.05334177f, 0.11278935f, -0.07861289f, 0.08645123f, 0.03700186f, -0.02933104f, 0.16832054f, 
    -0.08198026f, 0.03001352f, 0.09221638f, -0.02857760f, -0.03525280f, -0.09461343f, 0.07185560f, -0.04788502f, 
    -0.14087276f, 0.22272880f, 0.12867849f, 0.13116983f, 0.01580715f, -0.00309379f, -0.13189228f, -0.00211487f, 
    0.01709508f, 0.06120476f, -0.02447385f, 0.10570221f, 0.09322789f, -0.07551762f, -0.10036617f, 0.14321034f, 
    0.06796679f, -0.02879530f, -0.12006580f, -0.02755334f, -0.14356068f, 0.00070519f, 0.03463652f, 0.05641275f, 
    -0.05260507f, 0.11770850f, 0.18148077f, 0.13289802f, 0.04557318f, 0.01020728f, 0.23807520f, -0.01643589f, 
    0.04098805f, 0.16650237f, 0.01119768f, 0.17122257f, -0.08376152f, -0.04827065f, -0.23021631f, 0.14596123f, 
    0.13503020f, -0.06367280f, -0.03241045f, -0.18713786f, 0.00795565f, -0.07015421f, -0.14706537f, -0.05228657f, 
    -0.03883901f, 0.13122536f, 0.16142452f, -0.16933486f, -0.08726108f, -0.06022549f, -0.04221557f, 0.12608875f, 
    -0.04190705f, -0.16094291f, 0.03254701f, -0.02152912f, -0.17213750f, -0.17992263f, 0.51775116f, -0.15186146f, 
    -0.01525350f, 0.08479276f, 0.16208968f, 0.09552493f, -0.02116787f, -0.12614164f, 0.01575705f, -0.05069681f, 
    -0.05335420f, 0.08393080f, -0.01930153f, 0.10144401f, -0.02765498f, 0.18393083f, 0.11145887f, 0.00235823f, 
    0.02178179f, -0.09031230f, 0.15167022f, 0.06125364f, 0.26380616f, -0.09011674f, -0.17270850f, -0.07166361f, 
    0.05404550f, -0.01741857f, -0.02192156f, -0.02008112f, -0.11957567f, 0.15147181f, -0.06139356f, -0.15001686f, 
    -0.06614245f, -0.09037808f, -0.20726936f, 0.03208549f, 0.02724715f, 0.10201494f, 0.14721967f, -0.15039793f, 
    -0.04087634f, 0.02147341f, -0.05738914f, -0.04625675f, 0.14507855f, 0.21126945f, -0.02025125f, -0.09807871f, 
    0.02827184f, -0.11179664f, -0.04091483f, 0.06252408f, 0.05448800f, 0.08638882f, -0.09548906f, 0.02087123f, 
    -0.06033373f, -0.03555450f, -0.07615971f, 0.06383974f, 0.23835182f, 0.06791867f, -0.17604242f, 0.03775617f, 
    -0.02045744f, -0.04128727f, 0.05898096f, -0.04216132f, 0.07374763f, 0.05918673f, -0.25377902f, 0.02100500f, 
    0.03062470f, -0.04398370f, 0.36252037f, -0.18084489f, 0.17970148f, 0.03494956f, 0.16346607f, 0.12364646f, 
    -0.03380610f, 0.64232254f, -0.35388488f, -0.25052550f, 0.14061683f, -0.06727910f, 0.10806555f, 0.04279098f, 
    0.03702348f, 0.08260728f, 0.08214225f, -0.15724677f, 0.42640719f, -0.13243298f, -0.27780297f, -0.05777281f, 
    0.14173698f, 0.03275220f, -0.13453375f, 0.11581379f, 0.04785672f, 0.25299966f, 0.05782629f, 0.06072483f, 
    -0.14889280f, -0.33296233f, 0.19050957f, 0.09419681f, 0.05800039f, 0.04697273f, -0.07852157f, -0.06568574f, 
    0.00822364f, -0.07327235f, 0.06153327f, 0.03557104f, -0.06239995f, 0.08083097f, 0.11315935f, -0.23789677f, 
    0.16878612f, 0.09541832f, -0.14469314f, 0.03944994f, 0.07530656f, 0.02802082f, 0.06457852f, 0.08873484f, 
    -0.00521196f, -0.02489972f, -0.19694351f, -0.00400895f, 0.02414680f, 0.09350359f, 0.13014294f, 0.01547594f, 
    0.06591162f, 0.06034200f, -0.16135323f, 0.00046939f, -0.07683991f, -0.03208861f, -0.05193409f, 0.01238956f, 
    0.12653618f, 0.03525643f, -0.04937043f, 0.01658351f, -0.14383270f, -0.04979328f, -0.04990882f, 0.05702119f, 
    0.40362677f, -0.25486448f, -0.02462486f, -0.20603237f, -0.05308844f, -0.06195094f, -0.05222300f, -0.08331765f, 
    0.09430670f, -0.04422151f, 0.03267131f, -0.05535422f, 0.14290197f, 0.09894300f, -0.04209558f, -0.22943285f, 
    0.17079167f, 0.13195235f, 0.13113110f, 0.21639863f, 0.01623049f, 0.06417079f, 0.06092906f, 0.06438234f, 
    -0.28820425f, -0.45538357f, -0.26481783f, 0.12337066f, 0.11682143f, -0.03913767f, 0.08753125f, -0.07811306f, 
    0.06625537f, -0.05715769f, -0.03177809f, -0.03081538f, 0.16518965f, -0.02859732f, -0.04145580f, -0.21005613f, 
    -0.01679684f, 0.21249385f, 0.06997152f, 0.19313523f, -0.00281357f, 0.04241112f, 0.00423740f, -0.00531547f, 
    -0.10402133f, 0.11769199f, -0.01291659f, 0.16543861f, -0.07994225f, 0.03252877f, -0.05900311f, -0.04834217f, 
    0.01837476f, -0.00471034f, 0.01908036f, 0.14564440f, 0.33309805f, -0.07576013f, 0.00638687f, 0.03385563f, 
    -0.00709380f, -0.04947741f, -0.06040750f, -0.06783661f, 0.10369490f, 0.05413797f, 0.02242921f, 0.08579679f, 
    0.24247040f, -0.15548673f, -0.13362081f, -0.28887942f, 0.28125203f, 0.09892706f, 0.07835104f, 0.05266137f, 
    -0.00489391f, 0.02277868f, 0.06090863f, 0.00597651f, -0.17665754f, -0.11180964f, 0.15465122f, 0.13234539f, 
    -0.02748189f, 0.04279955f, -0.09669137f, -0.03140250f, 0.04515046f, -0.04900670f, 0.09536763f, 0.06174151f, 
    -0.37688223f, -0.17161497f, -0.05454060f, 0.01161523f, 0.05017468f, 0.07808816f, 0.07546427f, 0.05359277f, 
    -0.07822420f, -0.13462089f, 0.01039606f, -0.15595493f, -0.01263427f, -0.04179352f, -0.11514375f, 0.01577169f, 
    0.11407648f, 0.01469557f, -0.02044029f, 0.06664321f, 0.06406620f, 0.08854143f, 0.04085293f, 0.13308872f, 
    0.00662898f, 0.10138172f, 0.19738448f, -0.00415062f, 0.10686845f, 0.13648561f, -0.11941015f, -0.04902846f, 
    -0.01220473f, -0.10492522f, -0.06519088f, -0.02960517f, -0.14246875f, -0.22481455f, -0.09083947f, -0.20540743f, 
    0.07741556f, 0.05065649f, -0.03330817f, 0.00897055f, 0.02464039f, -0.00062840f, 0.05659338f, 0.17232664f, 
    -0.15176255f, -0.08228453f, 0.02128690f, 0.02691245f, 0.07429136f, 0.01657497f, 0.01775118f, -0.02300440f, 
    -0.05660599f, 0.13972227f, 0.06946659f, -0.10917794f, -0.43052137f, -0.11930541f, 0.02280558f, -0.02373343f, 
    0.14406665f, -0.15192464f, 0.01714946f, -0.15001273f, 0.03245408f, 0.05090947f, 0.10634476f, -0.00903195f, 
    -0.04224826f, 0.01934002f, -0.33757079f, -0.02057830f, -0.06018898f, -0.00856820f, -0.07695206f, 0.04640742f, 
    -0.01467418f, 0.04818280f, 0.07167538f, 0.04633797f, 0.19466490f, 0.44829181f, -0.00120868f, -0.06831165f, 
    0.02580674f, 0.01744082f, -0.07832370f, 0.06979165f, 0.08680209f, -0.05881216f, 0.00341379f, -0.17847882f, 
    0.06515461f, 0.04446550f, 0.08365662f, -0.08726265f, 0.08468366f, 0.18615021f, -0.10835509f, -0.03367124f, 
    -0.07169577f, -0.08912348f, -0.02899842f, 0.05436399f, 0.02303051f, -0.03129341f, -0.01004800f, -0.11578244f, 
    0.14574046f, 0.11517064f, 0.15353791f, 0.26608378f, -0.01578245f, 0.01881698f, 0.07404886f, 0.05153213f, 
    -0.39564738f, -0.34327051f, -0.37650883f, -0.00694347f, 0.07696846f, 0.00665364f, 0.10257566f, -0.01154604f, 
    0.04607375f, -0.03955366f, 0.01242973f, 0.02333750f, -0.10020009f, -0.27925661f, -0.09339091f, -0.02077642f, 
    0.17349984f, 0.01472728f, -0.15235397f, 0.09631961f, -0.08292145f, 0.05289852f, 0.00744956f, 0.03038237f, 
    0.05974411f, -0.15433073f, 0.02319025f, 0.05767896f, 0.13286367f, 0.06270580f, -0.12461695f, -0.08436365f, 
    0.03149626f, 0.11320608f, 0.14355768f, 0.14769097f, -0.16029902f, -0.14893796f, -0.29315045f, 0.27755165f, 
    0.04119353f, -0.00694110f, 0.00481568f, -0.03956313f, -0.00938416f, -0.02913386f, 0.07707847f, 0.20636860f, 
    0.24004471f, 0.18274374f, 0.05110455f, -0.12975769f, 0.16284220f, 0.11734048f, 0.21570259f, 0.10535995f, 
    -0.06349543f, -0.01479832f, 0.00609123f, -0.01112579f, -0.15902986f, -0.23636906f, -0.01515744f, -0.07660443f, 
    0.06425744f, -0.07555755f, 0.07535076f, -0.04152082f, 0.09286497f, -0.05298572f, 0.07279393f, 0.03893834f, 
    0.09633116f, 0.03251236f, 0.12733100f, 0.14469285f, 0.03840913f, -0.04112766f, -0.01479016f, -0.08905401f, 
    0.12543665f, 0.25684553f, 0.14153752f, 0.14192982f, 0.00088653f, 0.21892808f, -0.14619043f, 0.03629165f, 
    0.02680249f, -0.12403194f, -0.27574998f, -0.03683246f, 0.08584801f, 0.07656401f, 0.00723432f, -0.02861325f, 
    -0.15415946f, 0.15811111f, 0.15879510f, 0.10585047f, 0.01376638f, -0.00701091f, -0.12770833f, 0.07464024f, 
    -0.07540602f, -0.07854827f, 0.11111046f, 0.00085563f, -0.06326380f, 0.28038210f, 0.25074619f, 0.27403900f, 
    0.06049346f, -0.12486976f, 0.07533179f, 0.05126635f, 0.24919520f, 0.01286698f, -0.17008239f, 0.14275096f, 
    0.10412754f, 0.00739930f, -0.04219844f, 0.10819934f, 0.03697667f, 0.11616463f, 0.00827301f, 0.02916960f, 
    -0.01404529f, -0.07030712f, -0.10693434f, -0.18760009f, 0.03762435f, 0.14078987f, -0.12092294f, -0.03973163f, 
    -0.12063503f, -0.14377511f, 0.01175685f, 0.04877744f, -0.00199327f, -0.00390448f, -0.07583382f, -0.11923045f, 
    0.01750742f, 0.21237634f, 0.09158323f, 0.14414477f, 0.01415364f, 0.05613525f, 0.01491532f, 0.02011765f, 
    0.02868946f, -0.03579109f, -0.24250889f, 0.07359951f, -0.11066472f, -0.00135738f, -0.00249416f, 0.00360771f, 
    -0.01657572f, -0.05160782f, 0.04114969f, -0.09288999f, 0.03308745f, 0.07743613f, 0.08093004f, 0.18147653f, 
    1.04669487f, -0.25726762f, 0.38927090f, -0.22501840f, -0.08761783f, -0.01625982f, 0.11197825f, 0.02493842f, 
    0.01223082f, -0.07858258f, -0.03713328f, -0.06277469f, 0.08617112f, 0.10519057f, -0.20623113f, -0.24800314f, 
    -0.05540079f, -0.06664495f, 0.07347532f, 0.04723154f, 0.09428727f, -0.03796792f, -0.03047828f, 0.03396012f, 
    -0.03403351f, 0.21313205f, -0.27064803f, -0.28013352f, -0.16664532f, -0.08620936f, -0.11099766f, -0.27262965f, 
    -0.12969445f, 0.03506499f, 0.04876282f, 0.05761123f, -0.08829039f, 0.10916356f, -0.11034211f, -0.20982364f, 
    0.04244958f, 0.10102767f, -0.05381010f, 0.40784100f, -0.12122680f, 0.09976965f, -0.02797009f, 0.08256825f, 
    0.22676003f, -0.11738390f, 0.23826753f, -0.22427127f, 0.06774107f, 0.06143876f, -0.09869494f, 0.08767799f, 
    0.02100155f, -0.03578681f, -0.11056168f, -0.04718236f, -0.24222817f, 0.10419895f, 0.12531886f, -0.04754445f, 
    -0.14665762f, 0.00216037f, 0.03229944f, 0.01083845f, -0.06334074f, 0.00455036f, 0.16082332f, -0.08096821f, 
    0.03304599f, 0.21810320f, 0.06566826f, -0.13906260f, -0.00799340f, -0.11537965f, 0.01558146f, 0.15700442f, 
    -0.11449897f, 0.12385810f, 0.00765533f, 0.10556161f, 0.21979542f, 0.04788319f, -0.06835647f, 0.00669389f, 
    -0.09217872f, 0.03322825f, 0.01232398f, 0.02092921f, 0.04168664f, 0.13387081f, 0.10046387f, 0.00555975f, 
    -0.03296098f, 0.00215917f, -0.05416319f, -0.16007408f, 0.07022829f, -0.00373833f, -0.05788305f, -0.01533322f, 
    -0.00545308f, 0.07329710f, 0.13716272f, -0.05671284f, -0.28150681f, -0.04733400f, -0.22019735f, 0.02629409f, 
    0.07519427f, -0.05177974f, -0.02141680f, -0.12945774f, 0.03734395f, 0.01642773f, 0.03201227f, 0.03623156f, 
    0.33935171f, -0.15568143f, 0.11712159f, -0.08812702f, -0.10963577f, -0.02324348f, -0.01831613f, 0.27741194f, 
    0.09910481f, -0.00553808f, 0.02820959f, -0.02459653f, 0.22116974f, -0.01367782f, 0.17854041f, -0.19421156f, 
    -0.04088291f, -0.00151614f, 0.01064153f, 0.00563607f, 0.12157949f, -0.05113409f, 0.07110588f, -0.01864179f, 
    0.09039712f, -0.01066820f, 0.02782124f, -0.01177774f, -0.00552688f, -0.07267809f, -0.05282340f, 0.03334304f, 
    0.01710043f, 0.22927268f, 0.12192570f, -0.16384982f, -0.04423502f, 0.18417969f, 0.15000628f, 0.01438585f, 
    0.05933428f, 0.03833784f, 0.06760601f, -0.15503116f, 0.08543634f, 0.13081716f, 0.05241894f, -0.06964027f, 
    0.01487802f, 0.09178349f, 0.04614528f, -0.13790445f, 0.00277523f, -0.01301504f, -0.08639752f, 0.04323353f, 
    0.00899256f, -0.00759648f, -0.05504405f, 0.00576580f, -0.05126904f, -0.12267142f, 0.11522102f, 0.24318670f, 
    0.06572270f, -0.07741145f, -0.13964653f, -0.07035409f, 0.46756351f, 0.02142652f, -0.29614431f, 0.05611450f, 
    0.13064896f, 0.35034767f, -0.03656407f, -0.08920179f, -0.05197457f, 0.02897259f, -0.13367561f, 0.06077048f, 
    0.12998483f, -0.00985509f, -0.14457381f, -0.19838591f, 0.09855758f, 0.07411230f, 0.08541497f, -0.15209128f, 
    0.03799175f, 0.21262054f, 0.02484988f, 0.36262041f, -0.07443447f, -0.03283362f, 0.01927621f, 0.00305392f, 
    -0.07697107f, 0.11162014f, -0.19159026f, -0.10632588f, -0.08298909f, -0.09867942f, -0.04470446f, -0.01515807f, 
    -0.06571756f, 0.01501246f, -0.02412302f, 0.03052781f, -0.21274225f, 0.39048126f, -0.31251633f, -0.25872111f, 
    0.23162387f, -0.09534133f, 0.01344345f, -0.26414537f, -0.02634907f, 0.03500045f, 0.03817446f, -0.01521246f, 
    0.09345194f, -0.00636377f, -0.06557401f, -0.07614712f, -0.06708141f, -0.10358819f, -0.11057226f, -0.01131330f, 
    0.01856839f, -0.01005435f, 0.04450772f, -0.02470509f, 0.05675569f, 0.33274949f, -0.15952061f, 0.32358941f, 
    -0.04297564f, 0.09552825f, 0.04365139f, -0.07115203f, 0.06364849f, 0.02261522f, 0.10524171f, 0.11422259f, 
    0.10216252f, 0.11252524f, -0.11984178f, -0.13649447f, -0.04921222f, -0.03904310f, 0.19559421f, 0.06270087f, 
    0.04245489f, -0.03390143f, -0.11386198f, 0.08947418f, -0.18159746f, -0.03883164f, -0.07708953f, 0.04438958f, 
    0.02978160f, 0.02513228f, 0.22400804f, -0.21904337f, 0.05666176f, 0.12419099f, 0.04325533f, 0.01911023f, 
    0.02199405f, 0.09397914f, 0.22334957f, -0.11115049f, 0.08821627f, -0.11978140f, 0.26806328f, 0.06371897f, 
    -0.17058198f, 0.12082986f, -0.12532344f, 0.06709612f, -0.10586294f, -0.05071381f, -0.07076264f, 0.07082672f, 
    0.01097103f, -0.02952302f, -0.07182804f, -0.05535550f, 0.26377937f, -0.02088639f, -0.02784303f, -0.29104796f, 
    0.75154233f, -0.44379133f, 0.13734253f, 0.25311196f, -0.19326307f, -0.08250064f, 0.00006555f, 0.02649939f, 
    0.13922909f, 0.10824620f, -0.03213322f, 0.05559876f, 0.19060795f, 0.24694467f, -0.08442410f, 0.17182136f, 
    0.06413032f, 0.08563515f, 0.13334309f, -0.24332711f, 0.06104142f, -0.03841969f, 0.08055053f, 0.04240841f, 
    0.32042706f, 0.03822602f, 0.03364937f, -0.02331879f, 0.13079315f, -0.10060664f, 0.15391882f, 0.09612981f, 
    0.15366767f, -0.00263468f, 0.03576964f, -0.16023777f, -0.24506979f, -0.03401697f, -0.13888688f, 0.09232524f, 
    -0.05138528f, -0.06857129f, 0.07382465f, 0.15134533f, -0.02443182f, -0.04461434f, -0.01926076f, 0.10765617f, 
    0.10731143f, 0.10466886f, 0.10741519f, 0.12101197f, -0.08227882f, 0.06483249f, -0.06445796f, 0.00897343f, 
    0.07260454f, 0.01942357f, -0.23307024f, 0.00835662f, 0.07006403f, -0.08387361f, 0.12001900f, -0.02680799f, 
    -0.09186167f, 0.01041617f, 0.06749080f, -0.10459057f, 0.01468909f, 0.09720660f, 0.15150462f, 0.01868271f, 
    -0.03274635f, -0.00842465f, -0.05584269f, -0.01406180f, -0.00615960f, -0.01178862f, 0.01177373f, 0.02410369f, 
    -0.00026253f, 0.03109882f, -0.04249747f, 0.00671611f, 0.00439182f, -0.04804496f, 0.03962823f, 0.00659980f, 
    -0.00750624f, -0.03698383f, -0.01333598f, -0.05270657f, -0.01473948f, -0.01859451f, -0.02211029f, 0.01914840f, 
    -0.02036996f, -0.01324476f, -0.04650875f, -0.05540952f, -0.01285614f, -0.05203644f, -0.03469920f, 0.00102455f, 
    -0.04211407f, 0.01627735f, 0.00147066f, 0.01754738f, -0.03396355f, 0.01234453f, 0.01503700f, -0.05412292f, 
    -0.03109219f, 0.01307395f, 0.03841139f, -0.01151627f, 0.02986789f, -0.03860329f, -0.04057257f, -0.04396505f, 
    -0.01310957f, -0.01369185f, -0.04439775f, 0.00038389f, 0.03001759f, -0.05515097f, -0.00996436f, 0.02983228f, 
    -0.03731197f, 0.00917979f, 0.01176727f, -0.00812523f, 0.02700808f, -0.01680116f, 0.01976840f, -0.03760285f, 
    0.02334730f, 0.00745544f, -0.04458490f, 0.00753981f, -0.03740714f, -0.03191842f, 0.00917795f, 0.02194032f, 
    -0.05102274f, -0.05661166f, -0.00004363f, -0.03098775f, -0.01519758f, -0.02260648f, 0.02969115f, 0.00259550f, 
    -0.05405761f, -0.00542618f, 0.03911054f, -0.01491610f, -0.02664650f, -0.02999816f, 0.03632309f, -0.01893066f, 
    -0.01953822f, 0.03169820f, -0.04129355f, -0.02533020f, -0.02682219f, 0.03387902f, 0.02160958f, 0.03957935f, 
    0.03373946f, -0.04968503f, 0.01324494f, -0.03329039f, 0.01598139f, 0.04237312f, 0.00799776f, -0.02268924f, 
    0.04475319f, -0.04396030f, 0.03085934f, -0.03817142f, 0.01763334f, -0.01113128f, -0.02975092f, -0.00277546f, 
    -0.04421495f, -0.02650498f, 0.02809223f, 0.00190066f, 0.03536456f, -0.04544737f, 0.01466402f, -0.05693403f, 
    -0.00793773f, -0.04330248f, -0.02561630f, 0.03978970f, -0.03346523f, 0.03966149f, 0.03418868f, -0.04122293f, 
    0.03046892f, -0.00123677f, -0.05173352f, 0.04369730f, 0.04937514f, -0.05275567f, 0.00461383f, 0.05690237f, 
    -0.00601305f, -0.05364092f, -0.03420658f, 0.00006872f, 0.02295142f, -0.05373646f, -0.04088155f, 0.01135718f, 
    0.05014846f, 0.00408556f, -0.02735015f, -0.03287997f, -0.04678756f, -0.04508459f, 0.01670912f, 0.03102863f, 
    0.01173757f, -0.00728340f, 0.02793733f, -0.03855145f, 0.05233311f, 0.04746431f, -0.01377913f, 0.01534271f, 
    -0.04070551f, -0.01401135f, 0.02538379f, -0.02738729f, 0.04440582f, 0.02476400f, 0.00252131f, -0.03654237f, 
    -0.02738077f, -0.04409402f, 0.01408451f, -0.03016232f, 0.04020288f, 0.00697724f, 0.01185122f, 0.04117631f, 
    -0.03296986f, 0.00792155f, 0.03126845f, -0.00033366f, 0.04279640f, 0.00953135f, -0.03590668f, -0.01751819f, 
    0.02448157f, 0.02705532f, 0.00986513f, 0.02393961f, -0.01117735f, 0.03529690f, -0.02186640f, 0.01094714f, 
    0.01380610f, 0.00343622f, -0.03192018f, -0.05330762f, -0.02927595f, 0.02468085f, -0.03320818f, 0.00566934f, 
    0.04334349f, -0.03905940f, 0.01707920f, -0.03786112f, -0.04320816f, -0.02524175f, 0.00821328f, 0.01280640f, 
    -0.00856006f, 0.04160044f, -0.03946898f, 0.04327873f, 0.04005467f, -0.04901620f, -0.02574714f, -0.03119474f, 
    -0.03613622f, 0.02634032f, 0.02791376f, 0.02151176f, 0.00692146f, -0.00108150f, -0.03646611f, -0.02631667f, 
    -0.02149238f, -0.00861504f, 0.01168064f, 0.04448261f, 0.01099653f, 0.02734577f, -0.01303944f, 0.01698512f, 
    -0.03582518f, -0.02362015f, -0.02222185f, 0.00136115f, 0.03429088f, 0.00150308f, -0.01016286f, -0.00365529f, 
    -0.00889758f, 0.01398460f, 0.00308868f, -0.01435264f, -0.03118747f, -0.05112019f, 0.02279684f, -0.02210009f, 
    0.04212507f, -0.04812415f, -0.05543859f, -0.04817818f, 0.04192211f, -0.04310028f, 0.00276349f, -0.01798608f, 
    -0.02058468f, -0.03239112f, -0.00562237f, 0.00683903f, 0.01160419f, -0.03618483f, 0.03162584f, 0.03286340f, 
    -0.04553188f, 0.00558531f, -0.01433304f, -0.04567919f, -0.01421077f, -0.05101253f, -0.03963608f, 0.00750287f, 
    -0.03591390f, 0.02352032f, -0.00276640f, -0.03504774f, 0.00760333f, -0.00844666f, 0.01451758f, -0.01809892f, 
    0.03442828f, -0.04767619f, 0.00474103f, 0.03915018f, 0.02698613f, -0.03857393f, -0.03591875f, 0.00346406f, 
    0.00928995f, 0.02466342f, 0.00709210f, 0.03249220f, -0.02405041f, -0.03850617f, -0.01516739f, 0.04437504f, 
    -0.03195386f, 0.03351085f, -0.01945153f, -0.01050027f, -0.03624412f, 0.00435922f, 0.04149971f, -0.04863258f, 
    -0.02496625f, 0.03898213f, -0.02572078f, -0.01250241f, -0.03120719f, -0.05111469f, 0.02814247f, 0.04480296f, 
    -0.03569438f, -0.04492874f, 0.03474637f, -0.01936182f, 0.02338965f, -0.02228930f, -0.00727219f, 0.03418127f, 
    -0.03117670f, 0.01464573f, 0.00388883f, 0.04466632f, 0.04349625f, -0.00437067f, 0.04262328f, -0.03024548f, 
    -0.05344371f, -0.01133653f, -0.02354519f, -0.01383968f, -0.03950324f, 0.04257479f, -0.02647355f, -0.02619618f, 
    0.00420069f, 0.00446895f, 0.02513574f, -0.01675721f, -0.04963471f, -0.02046033f, 0.03785795f, 0.02088719f, 
    -0.00755283f, 0.03836136f, -0.01711831f, -0.01714169f, -0.02849799f, 0.01570879f, -0.03435534f, -0.01577475f, 
    -0.01666346f, -0.05609488f, -0.04488390f, 0.00115047f, -0.05377059f, 0.02848098f, 0.02485470f, -0.02677272f, 
    -0.02444762f, 0.03717361f, 0.01373138f, 0.03175440f, -0.04116653f, 0.00270845f, -0.03826446f, -0.00658038f, 
    0.01693784f, 0.04209906f, 0.03139626f, -0.05261974f, -0.03824900f, 0.03094259f, 0.04472088f, 0.03843981f, 
    -0.01309827f, 0.01882764f, -0.03702805f, 0.00601503f, -0.04242026f, -0.05331065f, -0.00677620f, 0.00195780f, 
    0.27909526f, -0.18118222f, -0.01664427f, -0.27668512f, -0.12774563f, 0.14045243f, -0.10176903f, -0.10893655f, 
    0.07254306f, 0.08747441f, -0.01721772f, -0.04832172f, -0.24478874f, -0.08023604f, 0.19131316f, -0.12819502f, 
    0.00735081f, 0.01315971f, 0.21113320f, 0.16605842f, -0.04792306f, -0.01725584f, 0.04189124f, 0.12021392f, 
    -0.06966558f, -0.13304724f, -0.27458686f, -0.09961066f, 0.13763759f, -0.04955667f, 0.06806627f, -0.00942190f, 
    -0.10593834f, 0.02444997f, 0.00306105f, -0.04564679f, 0.05604453f, 0.10035116f, 0.03976087f, 0.19229507f, 
    0.14156957f, 0.20568892f, 0.15588395f, 0.18740323f, 0.16589829f, -0.09754284f, 0.30191708f, 0.09701543f, 
    0.09286136f, 0.27273667f, -0.00959916f, -0.03607748f, 0.02068341f, 0.09675270f, 0.05944379f, 0.11870232f, 
    0.21255070f, -0.18081674f, 0.04949056f, -0.22042856f, 0.28707060f, -0.04510825f, 0.00808786f, -0.06648295f, 
    0.01305951f, 0.02167762f, -0.01865286f, 0.01508411f, 0.13448328f, 0.12358014f, 0.03001714f, 0.01906673f, 
    0.02879540f, 0.10282248f, 0.00571856f, 0.05358541f, 0.13071953f, 0.02908399f, 0.08812549f, -0.20716821f, 
    -0.00730559f, 0.03660882f, -0.03421918f, 0.03966332f, -0.28691098f, -0.24899177f, -0.04464687f, 0.37163824f, 
    -0.03490946f, -0.11519485f, -0.14070226f, -0.01200647f, 0.30855703f, 0.00287886f, 0.41328138f, 0.22465864f, 
    -0.01466644f, -0.17550099f, -0.06450521f, 0.04738723f, 0.06629851f, 0.02761794f, 0.05821513f, -0.05275512f, 
    -0.08223116f, -0.16739963f, -0.13097860f, -0.37715003f, 0.30581406f, -0.15473697f, -0.03984987f, 0.04365513f, 
    -0.00248907f, 0.20784661f, -0.04900431f, -0.08812494f, 0.07735523f, 0.10434440f, 0.05728970f, 0.19300094f, 
    -0.39840201f, -0.13078503f, 0.11806748f, -0.12196430f, 0.00346467f, 0.04794182f, 0.06555088f, 0.05173431f, 
    0.05275753f, -0.04016546f, -0.08605832f, -0.26614839f, 0.54314017f, 0.08685498f, 0.10204645f, 0.04104746f, 
    0.04189552f, 0.06562722f, 0.08305065f, 0.05014357f, 0.11531134f, 0.09826318f, 0.08004470f, 0.12624487f, 
    -0.03959104f, -0.08902586f, -0.03225185f, -0.07823185f, -0.04915863f, -0.06414715f, -0.03894918f, -0.10748747f, 
    0.11262966f, 0.01293716f, 0.05231850f, -0.28341213f, -0.04723205f, -0.08734795f, -0.00065526f, -0.17535760f, 
    0.10964182f, -0.08827902f, -0.12548780f, 0.09909334f, 0.13773039f, 0.19411820f, 0.01644406f, -0.02301325f, 
    0.31771711f, 0.26991847f, -0.00931820f, 0.34423059f, -0.07493459f, -0.12562746f, -0.01134538f, -0.25236326f, 
    0.10618586f, -0.05349841f, 0.24149576f, 0.29723540f, -0.20342885f, 0.02753578f, 0.13780573f, 0.29564297f, 
    -0.11400571f, -0.05305312f, -0.17222308f, -0.05179788f, -0.22066449f, -0.31847602f, 0.10019683f, -0.15059929f, 
    -0.45629522f, -0.15456493f, -0.06901073f, -0.35627818f, 0.01082927f, -0.03494240f, -0.11518992f, -0.09971251f, 
    -0.07144000f, -0.22733574f, 0.09002962f, -0.19436501f, -0.23320326f, -0.11098339f, 0.04625824f, -0.17058471f, 
    0.02830999f, 0.14350587f, 0.00965350f, 0.07891784f, -0.02472730f, -0.09169635f, 0.05127576f, 0.07417624f, 
    -0.17226450f, 0.05727569f, 0.16592705f, -0.13328557f, -0.01528867f, -0.01386186f, 0.00558015f, -0.06493454f, 
    -0.07257155f, -0.12120192f, 0.02211645f, -0.10932935f, 0.09536421f, -0.24152736f, -0.04619635f, 0.17635562f, 
    -0.02509075f, -0.06886877f, 0.01213840f, -0.05963838f, -0.02466371f, 0.09304447f, -0.05679374f, 0.18436664f, 
    -0.07942984f, -0.24385473f, -0.20473006f, -0.26050839f, -0.04173226f, -0.03003484f, -0.05760162f, 0.12772204f, 
    -0.00189203f, 0.12295673f, 0.24293293f, -0.14930248f, 0.07000645f, -0.02293016f, 0.20273861f, 0.38427174f, 
    -0.06505554f, -0.03129986f, -0.02921999f, -0.11459248f, -0.02030200f, 0.02023357f, 0.11844172f, 0.38169548f, 
    -0.07016076f, 0.06109138f, 0.06670301f, -0.02799459f, -0.06560098f, 0.13574947f, 0.06851886f, -0.05875594f, 
    0.07403480f, 0.13676813f, 0.20532732f, 0.16498350f, -0.09635600f, -0.07607771f, 0.00532765f, 0.00702352f, 
    0.12557650f, -0.01459884f, -0.18616317f, 0.07583723f, 0.00555006f, -0.06454659f, -0.01076115f, 0.24800016f, 
    0.01152705f, -0.13656521f, 0.08099063f, -0.01660041f, -0.11252547f, 0.21501873f, 0.05319208f, -0.16312918f, 
    0.10915737f, 0.25516880f, 0.14221169f, 0.11640627f, -0.17162462f, 0.01387195f, -0.07038301f, -0.04337253f, 
    0.01701172f, 0.01615726f, -0.21429934f, 0.01244663f, 0.02750838f, -0.30390397f, -0.05155315f, -0.30663639f, 
    -0.38362014f, 0.21817254f, 0.31746772f, 0.36375183f, -0.11704373f, -0.07618472f, -0.10702702f, 0.05852980f, 
    0.29227787f, 0.08447252f, 0.02866258f, -0.01195129f, 0.26684025f, -0.45956233f, 0.23318617f, 0.45760533f, 
    0.17275494f, 0.02250475f, 0.05528129f, 0.14083953f, 0.18430805f, 0.11411005f, 0.00011192f, 0.14066602f, 
    -0.11129636f, -0.05352835f, 0.06950705f, -0.10649520f, 0.06800786f, 0.07688941f, 0.09573004f, -0.18192966f, 
    0.10870053f, -0.05307275f, -0.11779891f, -0.03767458f, -0.22790405f, 0.25300929f, -0.02699692f, -0.17272291f, 
    0.16253392f, -0.14049588f, 0.20868169f, 0.12214794f, -0.03741409f, -0.03543689f, 0.05176378f, -0.03583063f, 
    -0.22630566f, 0.15522686f, 0.20727342f, -0.09262288f, 0.10761095f, 0.03864689f, 0.07429019f, 0.04140723f, 
    0.09788574f, 0.02676647f, 0.08475577f, 0.00376020f, -0.24139167f, -0.13361593f, 0.01035318f, -0.01527184f, 
    -0.04665015f, 0.06771477f, -0.08700950f, -0.05739838f, 0.28737834f, 0.12608537f, 0.25368237f, 0.30169946f, 
    -0.00575624f, 0.02861175f, -0.01652954f, 0.01492039f, -0.01422612f, -0.02419015f, -0.03746153f, -0.00967900f, 
    0.02799366f, 0.00728391f, 0.00165810f, -0.00172107f, 0.02091882f, -0.03268865f, -0.05843509f, 0.03984226f, 
    -0.02605907f, -0.00012085f, 0.02341503f, -0.05495322f, -0.03022102f, -0.03145135f, -0.03852637f, 0.02698751f, 
    -0.05107537f, 0.03608510f, -0.05975553f, -0.04672884f, -0.03160906f, -0.00769597f, -0.03654473f, -0.03368997f, 
    -0.05200011f, -0.01463036f, 0.00986964f, -0.03439726f, -0.04213353f, -0.02809684f, -0.04058420f, 0.03487761f, 
    -0.01878014f, -0.05552578f, -0.04929824f, 0.01628595f, 0.00838921f, -0.03986842f, -0.02768997f, -0.00523978f, 
    -0.03875196f, -0.01893658f, 0.04107373f, 0.03349194f, -0.03133049f, 0.00542171f, 0.02967162f, -0.00776842f, 
    -0.03456759f, -0.05024140f, -0.02464111f, -0.04681705f, -0.02595240f, 0.03339862f, 0.03517416f, -0.00456035f, 
    0.03407339f, 0.00690873f, 0.03377602f, -0.02836672f, -0.04426356f, 0.00586731f, 0.03210887f, 0.02201099f, 
    -0.01755844f, 0.02830006f, 0.03421920f, -0.05937152f, -0.03152107f, 0.02795953f, -0.00215541f, 0.00051924f, 
    -0.03570532f, 0.03295947f, -0.03120511f, -0.03665205f, -0.03936327f, -0.03628445f, -0.03459780f, 0.04598438f, 
    -0.02895165f, -0.05534561f, 0.02580461f, -0.05014016f, 0.04458322f, 0.01893583f, 0.01206088f, -0.00731063f, 
    -0.00627277f, -0.03723421f, -0.01888352f, 0.00061455f, -0.03696584f, 0.03929227f, -0.03365574f, 0.03128057f, 
    0.00275858f, -0.01291166f, 0.02539567f, -0.04498067f, -0.03347839f, 0.02592404f, -0.02035960f, -0.01269925f, 
    -0.00973985f, 0.03775447f, -0.03391479f, 0.02618433f, -0.04174287f, 0.02562705f, -0.03545669f, -0.05714710f, 
    -0.03107045f, 0.02713619f, 0.04130725f, -0.02187504f, 0.01339072f, 0.00708798f, 0.00852556f, -0.02937597f, 
    -0.04009636f, -0.00510399f, -0.01870227f, -0.02146609f, -0.00553880f, -0.01817040f, -0.03893970f, -0.03042769f, 
    -0.01197917f, 0.01200246f, 0.00440107f, -0.03793802f, -0.05818349f, 0.01786861f, -0.01272126f, -0.02972169f, 
    -0.04630218f, -0.04204379f, -0.04113206f, 0.02281751f, 0.05074851f, -0.01629953f, -0.01570608f, 0.00304733f, 
    0.01066185f, -0.02996843f, -0.03382115f, 0.00619834f, -0.01045826f, -0.00970406f, 0.04433412f, -0.01669495f, 
    -0.02499286f, 0.03165988f, -0.03343522f, 0.03232400f, 0.01477865f, -0.00785260f, -0.01236014f, -0.02444740f, 
    0.02115425f, -0.00209710f, -0.04352239f, 0.01981636f, -0.05309565f, -0.01221033f, -0.03617076f, 0.03980781f, 
    -0.04435536f, -0.05690496f, -0.02862226f, 0.03984868f, 0.02275509f, 0.01382621f, 0.03518749f, -0.04348033f, 
    0.03903630f, 0.03462289f, -0.01167751f, -0.01553459f, 0.03325738f, -0.01089984f, -0.01330348f, -0.02962119f, 
    0.00153814f, -0.01705537f, 0.00882272f, -0.00976327f, 0.03943944f, -0.04307602f, 0.03548478f, -0.04256251f, 
    -0.04576320f, -0.05845436f, 0.04068105f, -0.04921775f, 0.02300038f, 0.01368003f, -0.00663996f, 0.01216953f, 
    -0.00434777f, -0.03536016f, 0.02794433f, -0.04538861f, 0.01094447f, -0.00351348f, 0.02092448f, -0.01246086f, 
    0.00182375f, -0.02837081f, -0.03038854f, 0.02220820f, -0.05321325f, 0.00499512f, -0.05309266f, 0.00708638f, 
    -0.03586934f, 0.02202944f, 0.03714934f, 0.03688030f, -0.04357030f, -0.00920210f, -0.05901303f, -0.00642756f, 
    -0.01743675f, -0.05616824f, -0.01692346f, -0.00423316f, -0.01031869f, -0.05032292f, -0.02175396f, -0.02868017f, 
    0.01015984f, 0.01761978f, 0.02737414f, -0.00373962f, -0.02175170f, 0.03533144f, -0.01139485f, 0.03807106f, 
    -0.01110743f, 0.00689103f, -0.04892029f, 0.03135409f, -0.05035497f, 0.04099586f, -0.05393727f, 0.02460472f, 
    -0.01561790f, -0.05364004f, -0.04351196f, 0.00413489f, -0.01544013f, -0.00101692f, -0.03707420f, -0.02889286f, 
    -0.00119910f, -0.02993883f, -0.00827236f, 0.03879566f, -0.04734856f, 0.02594814f, -0.00615169f, 0.00952927f, 
    0.02498691f, -0.05746031f, -0.03487571f, -0.02290352f, 0.04822593f, -0.05052627f, 0.02418652f, 0.03805534f, 
    -0.03170375f, 0.03731643f, -0.02682176f, 0.01567767f, -0.01401190f, 0.00783615f, -0.05259055f, -0.00065071f, 
    -0.01650445f, -0.02233346f, -0.03960954f, -0.00200512f, -0.03843115f, -0.03429714f, 0.03756505f, 0.01745209f, 
    -0.02527348f, 0.00597678f, 0.03530888f, 0.03142802f, 0.02951675f, -0.03124495f, -0.00449372f, 0.00004074f, 
    0.02058257f, -0.01026779f, -0.03224755f, -0.05569817f, -0.03219905f, 0.00461883f, -0.03726691f, -0.05835569f, 
    0.03957044f, -0.04800653f, -0.01617542f, -0.01602211f, -0.02157895f, -0.03671276f, -0.05018688f, -0.03300262f, 
    -0.01657320f, 0.00728334f, 0.02039297f, -0.01741424f, -0.02675236f, 0.03021748f, -0.04273489f, 0.02959262f, 
    0.01967795f, -0.00273729f, -0.03611436f, -0.01587901f, 0.01899746f, 0.03711068f, 0.03936219f, 0.00015735f, 
    0.02824804f, -0.02855825f, -0.00674829f, 0.03173126f, -0.00094361f, 0.00694534f, 0.01940589f, 0.00420008f, 
    0.01341476f, 0.00061772f, -0.02380295f, 0.02619888f, 0.03135158f, 0.01238294f, -0.01338738f, -0.05528184f, 
    -0.01522814f, -0.00729294f, -0.02345147f, -0.01498464f, 0.00902124f, -0.03444469f, -0.03691414f, 0.01876925f, 
    0.02794265f, 0.03976869f, -0.03501873f, -0.05094782f, -0.00669101f, -0.02448916f, -0.05184560f, -0.00469967f, 
    -0.03071510f, 0.02174073f, -0.03100093f, -0.05057722f, -0.02694333f, 0.04031212f, -0.04014229f, 0.04771153f, 
    -0.04806435f, 0.03270176f, -0.04893298f, -0.05506556f, -0.01331800f, -0.05128464f, 0.03718364f, -0.03747333f, 
    0.28985643f, 0.13786563f, 0.15909949f, 0.31197765f, 0.08842726f, -0.06876021f, 0.02720980f, 0.00021703f, 
    0.01768041f, 0.03336163f, 0.25884578f, 0.12367160f, -0.27105328f, -0.17894474f, -0.02474558f, 0.33577418f, 
    -0.04184190f, -0.05843849f, -0.12507835f, -0.31792226f, -0.08678982f, -0.09046414f, -0.02088838f, -0.03640211f, 
    0.42851955f, 0.08775769f, 0.05571067f, -0.09208266f, 0.04327143f, 0.12627541f, 0.13757816f, -0.09397264f, 
    -0.03731700f, -0.06293104f, -0.02468960f, 0.07099936f, 0.00151297f, 0.11220075f, -0.18597397f, 0.17213331f, 
    0.10083872f, -0.02615912f, 0.07736603f, -0.00208139f, -0.04043643f, 0.15998286f, -0.10731263f, -0.02354196f, 
    0.44970718f, -0.03316775f, 0.19708990f, -0.18956040f, 0.10638862f, -0.16151851f, 0.10046202f, 0.07792364f, 
    0.10218312f, 0.06217139f, 0.04593802f, -0.05798580f, -0.13170178f, 0.15668303f, -0.08097515f, 0.12223013f, 
    0.00802592f, -0.12050512f, -0.06678558f, 0.02939048f, -0.01669302f, 0.03913908f, 0.23067616f, -0.01137645f, 
    -0.28346300f, -0.03763013f, 0.15108669f, 0.25779477f, -0.04739311f, -0.08488074f, -0.13123924f, -0.02950897f, 
    -0.00700262f, -0.10486134f, 0.07816114f, 0.09692704f, -0.05020455f, -0.09213877f, -0.07410340f, 0.05537568f, 
    -0.08491241f, -0.17243718f, -0.02709183f, -0.04073611f, 0.10631149f, 0.07735639f, 0.03759429f, 0.17433701f, 
    0.15709884f, 0.03878516f, -0.06734989f, -0.00726588f, -0.06300440f, -0.04868603f, 0.00709187f, -0.01839334f, 
    -0.04658224f, 0.12862363f, 0.08514383f, 0.03176123f, -0.04828259f, -0.09317415f, -0.18734214f, -0.17825076f, 
    0.09373078f, -0.10330870f, 0.03179561f, 0.12598434f, -0.01884799f, 0.02086652f, 0.00969188f, -0.03017611f, 
    -0.33440056f, 0.03004873f, 0.05276872f, 0.07076190f, -0.22182764f, 0.11880972f, 0.05707506f, 0.09219411f, 
    0.01919801f, 0.10365372f, 0.10908206f, -0.00331028f, 0.10504132f, -0.05085034f, -0.01827841f, 0.13156207f, 
    -0.06395490f, -0.03988753f, 0.07978132f, -0.06569108f, 0.06927633f, 0.04388783f, 0.02721504f, -0.11517399f, 
    -0.00855045f, 0.07093549f, -0.12573464f, -0.04702539f, -0.02230724f, -0.06169470f, -0.05808097f, 0.03889752f, 
    -0.05823260f, 0.07131216f, -0.02982313f, 0.11547331f, 0.32268670f, 0.03123975f, 0.15691312f, -0.14497422f, 
    0.04199702f, 0.03462863f, -0.04726757f, 0.01373218f, -0.00245257f, -0.01354414f, 0.20796779f, 0.08548152f, 
    0.31014189f, 0.43905744f, 0.06550521f, 0.02260459f, 0.02169972f, -0.03161884f, 0.01788754f, 0.03370561f, 
    0.00163116f, 0.22337715f, -0.01897369f, -0.11890832f, -0.10042381f, 0.03524664f, -0.09291244f, 0.07291740f, 
    0.01803713f, -0.07935836f, 0.08677586f, -0.00272273f, 0.06423590f, 0.14673133f, 0.01869370f, 0.23661572f, 
    -0.07609998f, 0.04881155f, 0.03411091f, 0.20587401f, -0.13039051f, -0.18166779f, 0.02633459f, -0.08007399f, 
    0.02884595f, 0.05713308f, 0.00385581f, -0.01088820f, -0.01124640f, -0.02107256f, 0.13155483f, 0.12217052f, 
    -0.09930235f, -0.09633295f, -0.00742558f, -0.12774046f, -0.11598457f, -0.01407510f, -0.04492624f, -0.10536932f, 
    0.25314745f, 0.00006545f, -0.06751306f, 0.09879493f, -0.05868390f, 0.09695704f, -0.04120348f, -0.12205750f, 
    -0.11812977f, -0.00606262f, -0.11429457f, -0.14761658f, -0.06515950f, -0.05805792f, -0.09758911f, 0.02093209f, 
    0.08186944f, 0.00171756f, 0.15670358f, -0.16846961f, -0.01523943f, 0.00434213f, 0.01100361f, -0.00424294f, 
    -0.16755712f, 0.21332058f, 0.07820725f, -0.08579961f, -0.07737123f, -0.11340862f, -0.10690331f, -0.04506853f, 
    0.08209478f, 0.04522973f, -0.09933186f, 0.00088855f, 0.06854777f, 0.24977468f, -0.02949322f, -0.11473294f, 
    -0.11974107f, -0.01744920f, -0.05239788f, -0.06280836f, -0.01956188f, 0.11744762f, -0.14058271f, -0.06881933f, 
    -0.18373047f, -0.15797253f, 0.05274844f, 0.02755983f, 0.03513540f, -0.05410429f, -0.09269845f, 0.01220402f, 
    0.10096676f, 0.00688364f, -0.02763682f, 0.11703452f, 0.04900625f, -0.09622846f, 0.05523226f, -0.13455479f, 
    -0.07192427f, 0.08110315f, 0.04056386f, -0.03874689f, 0.13545480f, -0.13428803f, -0.02831374f, -0.10313239f, 
    0.01151109f, 0.22902398f, 0.24228844f, 0.03540574f, 0.07926935f, 0.00145889f, -0.00771556f, 0.04040938f, 
    -0.00979466f, 0.01306935f, -0.10731866f, 0.00883801f, -0.37801135f, 0.01791684f, -0.07393865f, 0.06127458f, 
    -0.10773997f, -0.13187267f, 0.08339521f, 0.08299532f, -0.13352568f, -0.05779966f, 0.03360794f, -0.07659330f, 
    -0.00493941f, -0.48692071f, 0.32385412f, 0.12918362f, 0.08242033f, 0.11701521f, -0.01216321f, -0.16516075f, 
    0.06691490f, 0.02200579f, 0.00695801f, 0.17256589f, -0.24307890f, 0.08369918f, -0.23653416f, 0.01816486f, 
    -0.02420759f, -0.09219256f, 0.10574741f, 0.21508653f, -0.05811299f, 0.15630746f, -0.01726410f, 0.17760056f, 
    -0.14474981f, -0.08628493f, -0.03358269f, 0.08104530f, 0.08736041f, -0.00963490f, 0.09009882f, 0.07981092f, 
    0.11030915f, 0.10072401f, 0.05144569f, 0.11140298f, 0.27625346f, -0.14493221f, 0.04222413f, -0.10415053f, 
    0.14563468f, 0.08870819f, 0.21149707f, 0.20782454f, 0.03674154f, 0.04828805f, 0.03142229f, 0.06676634f, 
    -0.17300260f, -0.24549966f, 0.08000042f, 0.11423882f, -0.12913433f, 0.03580953f, -0.06526249f, 0.06031484f, 
    -0.04238087f, 0.10299145f, 0.14201084f, -0.02880260f, -0.08915605f, -0.06334081f, -0.00022001f, -0.03935830f, 
    0.02468613f, -0.03547395f, -0.10878327f, 0.01476956f, 0.02552393f, 0.10903755f, 0.01106296f, 0.04516995f, 
    0.51818949f, -0.47417274f, 0.00849264f, -0.29560235f, -0.02196788f, -0.09534457f, -0.04761814f, -0.03116988f, 
    0.12262446f, 0.06780653f, -0.10968445f, -0.01722257f, -0.21727973f, 0.03783504f, -0.06637508f, -0.28274786f, 
    0.09703844f, 0.02719777f, -0.04228501f, 0.06808159f, -0.03264674f, 0.02271988f, -0.05248266f, -0.12198842f, 
    0.31269729f, -0.01191410f, 0.01035703f, 0.12045446f, 0.09322930f, 0.06876547f, 0.04613614f, 0.09388256f, 
    -0.14530039f, -0.04635291f, -0.07626508f, -0.03745447f, 0.21009646f, 0.04128664f, -0.19785234f, 0.04631680f, 
    0.11248186f, 0.24992892f, -0.00286217f, 0.12703209f, -0.02331780f, -0.03129038f, -0.10258296f, -0.00137609f, 
    0.08836043f, 0.02601162f, 0.18430187f, -0.14038044f, 0.01610522f, 0.06738559f, 0.04947599f, 0.02107789f, 
    0.06996140f, -0.04561605f, -0.01208803f, 0.05427628f, -0.06175547f, 0.04068265f, -0.01269730f, -0.06520002f, 
    -0.04982785f, -0.05030283f, -0.03559091f, -0.01926151f, 0.04999366f, -0.00760618f, 0.00677674f, -0.11906835f, 
    0.45013294f, -0.19290248f, -0.21985599f, -0.25800860f, 0.11706191f, -0.11451475f, 0.08840112f, 0.38705894f, 
    -0.06731613f, -0.01042595f, 0.05166855f, -0.08891719f, 0.18278284f, 0.12782106f, 0.12010080f, 0.19847591f, 
    -0.07666132f, 0.04417887f, -0.05215443f, -0.06584089f, -0.04208394f, 0.03820507f, -0.01966381f, 0.04860681f, 
    0.07398170f, 0.03132812f, 0.17023014f, 0.16251817f, -0.04831306f, 0.02828388f, 0.03572696f, 0.04230082f, 
    0.06172254f, 0.04200437f, 0.12347954f, 0.11102984f, -0.22192685f, -0.05597012f, 0.03087504f, 0.12173827f, 
    -0.02385723f, 0.06666151f, 0.00580704f, -0.16913283f, -0.11880288f, -0.10529180f, -0.07872630f, -0.07715251f, 
    0.15645449f, -0.09626449f, -0.26365468f, -0.19473520f, -0.03796247f, -0.05558837f, -0.17209502f, 0.00979385f, 
    0.06611587f, 0.10116557f, 0.12208042f, -0.03234008f, 0.24519889f, 0.00573963f, 0.12493299f, 0.07385222f, 
    0.04683249f, 0.04175673f, -0.03095463f, -0.03803618f, 0.01354340f, -0.00075866f, 0.01118356f, 0.00534643f, 
    0.09564684f, 0.14235802f, 0.14170720f, 0.18688455f, 0.01164426f, 0.03097642f, -0.03162641f, -0.05498686f, 
    0.07593621f, 0.30208832f, 0.18727538f, -0.00724388f, 0.09447394f, -0.02899379f, 0.07190246f, 0.04563803f, 
    -0.01700783f, 0.01447575f, 0.09083577f, -0.07089721f, 0.07330001f, 0.03125492f, -0.09716415f, -0.13314483f, 
    0.23847106f, 0.05231746f, -0.17953800f, -0.06063001f, 0.04117282f, 0.02679087f, -0.01124439f, -0.00987931f, 
    -0.10090838f, -0.01513428f, -0.05042125f, -0.21316902f, 0.19971092f, 0.22609313f, -0.05912502f, 0.29252714f, 
    0.00067437f, -0.03832843f, 0.02553617f, 0.02347849f, -0.01002120f, -0.02587184f, -0.06938005f, -0.05039944f, 
    0.00687444f, -0.37200928f, -0.29269350f, -0.24421844f, -0.18078803f, -0.08087023f, -0.06097634f, -0.01757115f, 
    0.02378751f, -0.08498260f, 0.11539337f, 0.01847875f, -0.14597034f, 0.05295579f, 0.00357381f, -0.27669284f, 
    -0.04841841f, -0.00613485f, 0.04218054f, 0.19324307f, -0.10956663f, -0.07135301f, -0.06235582f, -0.06125158f, 
    0.26198941f, 0.07589838f, -0.05597010f, 0.25996614f, 0.04860369f, 0.08584683f, 0.01928595f, 0.04075501f, 
    0.01318749f, -0.02689339f, 0.04991351f, 0.07797536f, 0.32165885f, -0.08272658f, -0.61348325f, 0.17543784f, 
    -0.15952761f, 0.02069595f, 0.16382058f, 0.18618260f, -0.10883500f, 0.04660148f, -0.05381248f, -0.01577501f, 
    0.19803146f, -0.11836037f, 0.00503965f, -0.09990890f, -0.10317494f, -0.10482140f, -0.16875446f, -0.21479432f, 
    0.03260070f, 0.02964296f, 0.01300222f, -0.09120332f, 0.19949602f, 0.22704412f, 0.02077249f, 0.23351914f, 
    -0.03662309f, 0.00620308f, 0.05865405f, -0.08651993f, 0.10340311f, -0.05321613f, 0.01202021f, -0.02390933f, 
    -0.30987129f, -0.31720653f, -0.02171518f, -0.30199289f, 0.13138488f, -0.03669241f, 0.06213778f, 0.30505511f, 
    0.02213837f, 0.00228566f, -0.04176768f, 0.08473139f, 0.00076517f, -0.01357711f, 0.05810598f, -0.02258036f, 
    0.04092537f, -0.09926975f, 0.11756715f, -0.02425232f, 0.13023517f, -0.01641376f, -0.13308930f, -0.01839589f, 
    0.03758918f, 0.00297569f, 0.07663376f, -0.10575627f, 0.07554989f, -0.06073796f, 0.06113167f, -0.06513438f, 
    -0.14455725f, 0.09398451f, -0.09403044f, 0.00516401f, -0.24010231f, 0.06349389f, -0.06342997f, -0.06208549f, 
    -0.08995038f, -0.04831879f, -0.25887135f, 0.04068252f, 0.04989837f, 0.06521394f, 0.00998694f, -0.10570323f, 
    0.16723841f, -0.07837236f, 0.32979324f, 0.27679026f, -0.08336609f, 0.13172542f, -0.05213283f, 0.01791089f, 
    0.10075152f, -0.04701048f, 0.16804659f, -0.01807815f, -0.25085744f, 0.17885648f, 0.15680793f, -0.00754341f, 
    -0.09452264f, -0.14760242f, 0.15462372f, -0.20918040f, 0.00752542f, 0.00725766f, -0.17245160f, 0.04498268f, 
    0.15757698f, 0.18727130f, -0.20917565f, 0.00208603f, 0.00223767f, 0.21101007f, 0.08176430f, 0.19725415f, 
    0.06091154f, 0.12569042f, 0.01014948f, -0.02784991f, 0.03756938f, 0.26205167f, -0.19994248f, 0.23693086f, 
    -0.08198646f, 0.04757837f, 0.22952665f, 0.04328633f, 0.03861751f, -0.11302051f, 0.01155061f, 0.06499414f, 
    -0.24030823f, -0.05101309f, -0.03775721f, 0.00580355f, -0.03560390f, -0.02020863f, -0.05834468f, 0.15018393f, 
    0.00935556f, 0.13857812f, 0.04846783f, 0.02329719f, 0.00887982f, 0.09204941f, 0.15990442f, 0.07487433f, 
    -0.03399826f, 0.02286788f, 0.04742185f, -0.04196822f, -0.06072897f, -0.02277890f, 0.00680286f, 0.03403698f, 
    0.00997232f, 0.76145476f, 0.24922168f, 0.13266808f, 0.00238753f, -0.04297305f, 0.04646104f, -0.11095509f, 
    0.17398247f, -0.02877829f, 0.03483250f, 0.10582492f, -0.37971488f, -0.12071952f, -0.11032146f, 0.05927590f, 
    0.02324309f, -0.14723155f, 0.01375740f, -0.19912075f, -0.02826055f, 0.04819653f, -0.05043831f, 0.04226805f, 
    -0.14924970f, 0.14954501f, 0.08500962f, 0.12929195f, -0.23052804f, -0.25355506f, -0.25426945f, -0.13729127f, 
    -0.11962298f, 0.04122635f, 0.07040909f, 0.03579734f, 0.00762807f, 0.21154311f, 0.43237680f, -0.10758357f, 
    0.15269938f, -0.09982682f, 0.15253873f, 0.17492150f, 0.01892655f, 0.19294856f, 0.12155728f, 0.27159682f, 
    0.17711386f, 0.03547131f, 0.13034905f, 0.09109019f, 0.00014713f, -0.01165470f, -0.07661412f, -0.07510275f, 
    0.05548583f, -0.05061297f, -0.11289031f, -0.12787084f, 0.19066842f, 0.18948428f, 0.12411421f, 0.09453113f, 
    -0.03936914f, -0.00284383f, -0.10384972f, -0.04508290f, 0.02974850f, 0.06214901f, 0.04748845f, 0.11146083f, 
    -0.39779559f, -0.05947907f, -0.03954147f, 0.14314075f, -0.09712672f, 0.00765206f, 0.18927343f, -0.07657045f, 
    -0.01445362f, -0.03397369f, 0.05044338f, 0.13011156f, -0.12426613f, 0.08197019f, -0.36757109f, -0.31988543f, 
    -0.09803460f, -0.04342644f, 0.04144149f, 0.06312671f, 0.12781857f, 0.02530925f, 0.02618527f, 0.22738269f, 
    0.17353918f, 0.30828282f, 0.22322527f, -0.14909934f, -0.11872731f, -0.09107008f, -0.16473007f, -0.02311712f, 
    -0.06229815f, 0.06801850f, -0.23494832f, -0.05068577f, 0.33770603f, 0.09206074f, -0.16416132f, -0.01486673f, 
    0.11333594f, -0.08670738f, 0.01812105f, -0.09642243f, 0.01307435f, 0.14246862f, 0.05825410f, 0.17160097f, 
    -0.26294562f, -0.17890608f, -0.07648987f, -0.05608255f, 0.01326424f, 0.06897388f, 0.26395738f, 0.13214602f, 
    -0.02047259f, 0.01857734f, -0.01826051f, -0.03999766f, 0.05424949f, 0.48864499f, 0.33282295f, 0.04466651f, 
    0.03433738f, -0.13390444f, -0.01767462f, -0.06901968f, 0.15423155f, 0.05120474f, -0.10417337f, 0.09988257f, 
    -0.07924217f, 0.17020780f, 0.01895972f, -0.12952186f, -0.10912590f, -0.11114988f, -0.08284596f, 0.00400591f, 
    -0.13351658f, -0.00411695f, -0.10181498f, -0.21518230f, 0.14057624f, 0.26798591f, 0.25461715f, 0.20984705f, 
    -0.10955469f, 0.12213051f, -0.01441365f, 0.00561529f, -0.05639260f, -0.02859794f, 0.13425052f, 0.05071130f, 
    0.05125589f, 0.60270756f, 0.37050661f, 0.27376103f, -0.02873198f, -0.04437413f, -0.11087990f, 0.03206285f, 
    0.00787694f, 0.10549767f, -0.09343117f, 0.19021085f, -0.04457567f, 0.23287457f, 0.07107902f, 0.00719735f, 
    0.04196453f, -0.03591779f, -0.13346751f, -0.12482750f, -0.01268819f, -0.18483236f, -0.16414067f, 0.16075078f, 
    0.06787694f, 0.29322127f, 0.20729217f, 0.23056833f, -0.02917674f, -0.07068113f, 0.15109491f, -0.03869423f, 
    -0.09416890f, 0.03529170f, -0.23216940f, -0.21275452f, -0.16404249f, -0.13161413f, -0.00924729f, 0.33909264f, 
    0.03361703f, 0.02611027f, 0.07852635f, -0.00785565f, -0.08977052f, -0.03515381f, -0.03467997f, 0.11508696f, 
    -0.10478041f, 0.29833049f, 0.30010501f, -0.19826175f, -0.29535496f, -0.35542247f, -0.21669677f, -0.05209880f, 
    -0.12131892f, -0.05204153f, 0.01144819f, -0.04385585f, -0.17888381f, -0.17927606f, 0.35947400f, -0.15874675f, 
    0.06885576f, 0.05430641f, -0.03154599f, -0.06620605f, -0.04817922f, -0.10926638f, -0.00402841f, -0.13703999f, 
    -0.20691504f, -0.06798805f, -0.05399372f, 0.05705790f, -0.05685806f, 0.03040306f, 0.14851913f, -0.06560358f, 
    -0.01688513f, -0.00368841f, 0.10264588f, -0.10098556f, 0.18159883f, 0.32211915f, 0.10087456f, 0.16974504f, 
    -0.18314034f, -0.05774514f, -0.00732597f, -0.10182623f, 0.00235670f, 0.09822102f, -0.02654673f, 0.01823745f, 
    -0.16551636f, 0.12905243f, -0.20958249f, 0.23645261f, -0.05521131f, 0.09712856f, 0.18958387f, -0.03721602f, 
    0.01536976f, 0.09546269f, -0.01608057f, 0.13405117f, 0.51546377f, -0.10698703f, 0.42209145f, 0.10693337f, 
    -0.18127318f, -0.01809261f, 0.02693556f, -0.01781236f, 0.02026415f, 0.05466460f, -0.02702902f, 0.06053090f, 
    0.00250484f, 0.15198432f, -0.00587558f, 0.19590692f, 0.08918295f, 0.22712380f, -0.07983634f, 0.09986255f, 
    0.06969067f, 0.20382221f, 0.16262098f, 0.07104944f, -0.10714666f, 0.01632857f, -0.14231077f, 0.02254897f, 
    0.08382781f, -0.10820261f, 0.05962093f, -0.03211785f, -0.04984544f, -0.11664013f, -0.34147495f, -0.19054745f, 
    0.03640926f, 0.42744607f, -0.14296772f, -0.04954963f, 0.07256003f, -0.08685506f, 0.14335252f, -0.04369577f, 
    0.06073731f, 0.06036288f, 0.14945830f, 0.00786546f, -0.20251040f, -0.11333350f, -0.42214993f, 0.00440194f, 
    -0.07101147f, 0.09401038f, -0.01524500f, 0.15175869f, 0.01507848f, 0.21764930f, 0.08528468f, 0.05889008f, 
    -0.17158946f, -0.06846305f, 0.12895732f, 0.21828036f, 0.15961519f, -0.01656043f, 0.04559729f, -0.06022323f, 
    0.03912883f, 0.02779805f, 0.02627187f, -0.11914591f, -0.05314865f, -0.20667161f, 0.48979303f, -0.28507429f, 
    0.27197844f, -0.12751095f, -0.12599368f, 0.09516845f, -0.02901462f, -0.08516799f, 0.00757711f, -0.05263091f, 
    -0.17062105f, -0.10145713f, -0.23551615f, 0.07022638f, 0.03689077f, 0.00481148f, 0.03939123f, 0.06113540f, 
    -0.02904745f, 0.06386352f, -0.20375071f, 0.21500669f, -0.20117353f, -0.15479048f, -0.08366887f, -0.08766322f, 
    -0.00384933f, -0.01735706f, -0.09230711f, -0.03052907f, 0.01512402f, 0.15875871f, 0.04756980f, 0.23242965f, 
    0.41671398f, -0.17284811f, -0.16728768f, -0.16696393f, -0.00595330f, -0.00367246f, -0.12614362f, 0.15487008f, 
    -0.15676230f, 0.07169608f, 0.07505931f, -0.01918715f, -0.31811851f, -0.08919960f, 0.32710809f, 0.23229584f, 
    -0.09676774f, 0.00685294f, 0.11356789f, -0.05099387f, 0.00589388f, 0.00122582f, 0.15600726f, 0.10105855f, 
    0.35644805f, -0.02366841f, -0.12411809f, -0.10517350f, 0.17259954f, 0.13737766f, 0.30265218f, 0.01072205f, 
    -0.03829377f, -0.07577763f, -0.06370226f, 0.00219542f, 0.09396294f, 0.03723998f, -0.47473642f, 0.14039697f, 
    0.16001868f, 0.10360190f, 0.10157454f, -0.03719532f, 0.10942172f, -0.16717023f, 0.04995327f, -0.13967058f, 
    0.53317040f, 0.04011099f, -0.12549868f, -0.31372270f, 0.19062930f, 0.02549336f, 0.02749272f, 0.01307404f, 
    0.14089751f, -0.07634526f, 0.26972628f, -0.00784606f, 0.01192384f, -0.03565029f, -0.17159346f, -0.01380128f, 
    0.05041421f, -0.14688195f, 0.08312690f, 0.05829768f, 0.17110360f, 0.03414975f, -0.00917256f, -0.05104623f, 
    -0.01553381f, 0.18388271f, 0.30687371f, 0.21640088f, -0.02146935f, 0.00969587f, -0.00073978f, -0.13035949f, 
    0.03823458f, -0.02883052f, -0.00331481f, -0.00017894f, -0.17800345f, -0.16654238f, 0.18867248f, 0.33346158f, 
    0.02976070f, -0.13883339f, -0.06166956f, 0.00672630f, -0.02050224f, -0.03643578f, 0.17001899f, 0.08974122f, 
    0.23375636f, -0.25969741f, -0.06805588f, 0.23790328f, 0.05570902f, 0.03678970f, 0.10781138f, 0.00999242f, 
    0.00284401f, 0.01620593f, 0.16962793f, -0.00651631f, -0.25975844f, -0.12106536f, 0.16235477f, 0.11702444f, 
    -0.11181510f, 0.23507562f, 0.09351366f, 0.16116641f, -0.00921731f, -0.10491159f, -0.06477376f, 0.02668600f, 
    -0.25282094f, 0.12925486f, 0.19800581f, 0.02194980f, -0.13525848f, -0.04074572f, -0.03824240f, 0.04339082f, 
    0.13281094f, 0.12823242f, 0.01744868f, -0.05640923f, 0.36112109f, 0.00421963f, -0.19708538f, 0.20093536f, 
    0.01265653f, 0.04861193f, 0.07613175f, 0.03470607f, -0.02720265f, 0.06236470f, 0.05753125f, -0.08877950f, 
    0.10981564f, -0.07071380f, -0.03159782f, 0.19350995f, -0.00034154f, 0.02378536f, 0.02102687f, 0.02918062f, 
    0.10118981f, -0.14706853f, 0.00650451f, 0.19002534f, 0.26415983f, -0.24167071f, 0.01658355f, -0.11996454f, 
    -0.01266189f, -0.02227346f, -0.11806467f, 0.14901067f, 0.15990506f, 0.03109928f, -0.14460924f, 0.09683219f, 
    0.65455067f, 0.01832868f, -0.14757605f, -0.17333837f, 0.10232244f, -0.05721904f, 0.13112953f, 0.01364965f, 
    0.07160942f, 0.09388761f, 0.04958183f, -0.01751820f, -0.26508227f, -0.52328020f, -0.04007837f, 0.22925016f, 
    0.01260735f, 0.05947308f, 0.07847619f, -0.04739825f, -0.01409009f, -0.02141921f, 0.08320951f, 0.22896701f, 
    -0.45381644f, -0.02852923f, 0.11600237f, 0.00759229f, -0.17950617f, -0.10129051f, -0.17380069f, 0.05529589f, 
    0.08830245f, -0.13171785f, 0.10023677f, 0.09067506f, -0.09814401f, 0.12080268f, 0.25004882f, -0.13200115f, 
    -0.08143312f, 0.08146385f, 0.07139300f, -0.08829390f, 0.01346592f, 0.03930660f, -0.07961815f, -0.09806548f, 
    0.22743757f, -0.12536420f, -0.01581180f, 0.17143722f, 0.06921720f, 0.19646056f, 0.00784980f, -0.13243164f, 
    0.01093373f, -0.01051819f, 0.01334867f, -0.01648866f, 0.22607031f, 0.16045897f, -0.34425431f, 0.14323096f, 
    0.04551725f, -0.02714973f, 0.09991407f, -0.12834069f, 0.03941087f, 0.04530595f, 0.05976265f, 0.17554896f, 
    -0.06056331f, 0.04826871f, 0.09697630f, -0.15126565f, -0.00997546f, -0.09650462f, -0.06030124f, -0.07383639f, 
    0.08312786f, 0.09172150f, -0.12845108f, 0.10057841f, 0.03426500f, -0.15444426f, 0.10987934f, -0.06933094f, 
    -0.07447625f, 0.00280030f, 0.05924607f, 0.02360092f, -0.01775641f, 0.01146374f, -0.10935700f, 0.03240249f, 
    -0.07906698f, 0.00770779f, 0.24115619f, -0.06543379f, -0.03793857f, 0.02241371f, -0.19904286f, -0.12536705f, 
    0.14727587f, 0.07620469f, 0.08121908f, 0.00595390f, -0.14386000f, 0.02211638f, -0.29651976f, -0.13357909f, 
    0.32445514f, 0.10158660f, -0.06561413f, 0.14103304f, 0.05106854f, -0.07781211f, 0.00459143f, -0.01617110f, 
    -0.00923732f, 0.04546165f, 0.06298234f, -0.18041798f, -0.16541268f, 0.03971887f, 0.05612616f, 0.05250402f, 
    0.12903669f, 0.03082632f, -0.19053440f, -0.04245618f, -0.28834009f, -0.09018347f, 0.06654421f, 0.06223442f, 
    -0.21453756f, -0.10892832f, -0.08582583f, 0.02557873f, -0.04220653f, -0.06223205f, 0.14106040f, 0.09391537f, 
    -0.16332449f, -0.60207540f, 0.50487715f, 0.41818073f, -0.00987900f, 0.03940595f, -0.10751741f, 0.05803006f, 
    0.15940727f, 0.01705940f, -0.10750926f, 0.00218327f, -0.24418247f, -0.27404842f, 0.27386150f, 0.43009266f, 
    -0.07920051f, -0.03863327f, -0.00828625f, 0.22405583f, 0.03777259f, -0.04720701f, 0.06881592f, 0.21375802f, 
    0.02385055f, 0.13118879f, 0.08749545f, -0.08204798f, -0.01598290f, 0.01914746f, 0.05121851f, -0.11193461f, 
    0.05260325f, -0.01087827f, 0.06343941f, 0.15104727f, 0.26545835f, 0.17602827f, -0.14764912f, -0.04825121f, 
    0.09171081f, 0.02286229f, 0.17019127f, -0.00365293f, 0.11081663f, 0.08222368f, 0.07067134f, 0.05890999f, 
    -0.15742022f, 0.10285244f, 0.31937850f, 0.04016661f, -0.11782198f, -0.03399358f, -0.01624343f, -0.01876160f, 
    0.02824437f, 0.04738825f, 0.28792831f, -0.12789428f, -0.13362873f, 0.01469054f, -0.06715436f, 0.12504311f, 
    -0.03861920f, -0.02994953f, -0.11324105f, -0.05050413f, 0.15658061f, -0.03500342f, -0.06685635f, -0.05027724f, 
    -0.16927348f, -0.22419678f, 0.20594321f, -0.46798557f, -0.00426665f, -0.00438568f, -0.21147709f, -0.17873859f, 
    -0.07592997f, 0.17228948f, -0.15927981f, 0.05063572f, 0.03206734f, 0.10771928f, 0.27278349f, 0.06743272f, 
    0.10637189f, 0.21708520f, 0.03890264f, 0.31824902f, 0.09771080f, 0.03215507f, -0.00481776f, 0.17590895f, 
    -0.50250864f, 0.25058645f, -0.15759499f, 0.23831041f, 0.16974339f, -0.22163336f, -0.00423904f, 0.22349951f, 
    -0.03784176f, -0.07265469f, -0.10148723f, -0.35459921f, 0.35027131f, -0.01676825f, -0.19149427f, 0.15307954f, 
    -0.01512114f, 0.16017798f, -0.15297616f, -0.00984271f, 0.13146578f, -0.29465032f, 0.02995512f, -0.01830905f, 
    -0.47389221f, 0.10606892f, -0.06744505f, 0.10734565f, -0.01710162f, 0.06439937f, -0.12847400f, -0.15729056f, 
    0.13276038f, -0.04721805f, 0.07732830f, 0.05824704f, -0.10933251f, -0.03238542f, -0.13429227f, -0.33499408f, 
    0.02638474f, 0.14569487f, -0.08198091f, -0.14438815f, -0.00192843f, 0.01093107f, -0.02912228f, 0.04539557f, 
    0.35075510f, 0.20102391f, 0.10852648f, 0.19066539f, 0.21515879f, 0.16537935f, 0.23336861f, 0.27094018f, 
    -0.02274975f, 0.04863055f, 0.00728322f, 0.00042668f, 0.23415852f, 0.16220215f, 0.02509501f, -0.15938349f, 
    -0.17879480f, 0.14783588f, -0.22917590f, -0.13285917f, -0.04072041f, 0.06622236f, 0.07753696f, -0.06053631f, 
    0.03377124f, -0.11112671f, 0.16063759f, 0.14754592f, 0.11920441f, 0.06108803f, 0.12669356f, -0.04881324f, 
    0.18267943f, -0.02000772f, 0.03154041f, 0.06255785f, -0.18304171f, 0.18099245f, 0.21050224f, 0.51441228f, 
    -0.03207224f, 0.04003137f, -0.12164355f, -0.02240187f, -0.04706405f, -0.14732832f, -0.21985793f, -0.12845194f, 
    0.67955893f, -0.11956245f, 0.00755076f, 0.14865831f, 0.26133645f, -0.03789714f, 0.00694141f, -0.06622637f, 
    0.04078531f, 0.07602538f, -0.04412346f, 0.11003029f, -0.04268277f, -0.03133422f, 0.01816737f, -0.24990721f, 
    0.07382793f, 0.02212130f, -0.21360548f, -0.05465357f, 0.02547261f, -0.09414188f, 0.16795485f, 0.04430158f, 
    -0.03827261f, -0.15397030f, 0.17407216f, -0.11051845f, -0.05718524f, -0.02662314f, -0.11335684f, -0.24487306f, 
    0.21879384f, 0.09495901f, 0.09146626f, 0.18907039f, -0.48053503f, 0.06909358f, -0.45517051f, -0.01135844f, 
    0.06007295f, -0.25509825f, 0.02923582f, -0.17498013f, 0.12199996f, 0.18511723f, 0.00958196f, 0.08651722f, 
    -0.04448594f, -0.15413947f, -0.11455382f, -0.28968978f, -0.11155672f, -0.09034012f, -0.00706895f, -0.23574983f, 
    0.08893460f, -0.19326116f, -0.00788257f, 0.12718652f, 0.07105561f, -0.22917342f, 0.18454380f, 0.04447041f, 
    -0.15648952f, 0.09425725f, -0.02867190f, 0.10132708f, -0.07301198f, -0.05591546f, -0.01216807f, -0.05622656f, 
    -0.07055143f, -0.30402064f, 0.01068839f, -0.07549416f, 0.02756633f, -0.05788948f, -0.02911261f, 0.12072416f, 
    0.11694407f, -0.11467977f, 0.12968723f, 0.08909966f, -0.10096117f, 0.05328364f, 0.07062814f, -0.02998122f, 
    0.00936015f, 0.13032480f, 0.10651875f, 0.19413805f, -0.08982699f, 0.01169443f, 0.05252393f, 0.04102411f, 
    -0.37151185f, 0.00094209f, -0.10816483f, 0.01328878f, 0.17510739f, -0.21024804f, 0.00987244f, 0.01014562f, 
    0.24614760f, -0.18803030f, 0.04393183f, 0.03532220f, 0.14577337f, 0.53011352f, -0.19539122f, 0.36819044f, 
    -0.07173879f, 0.00561318f, 0.01474427f, 0.22388673f, 0.07194635f, 0.22085632f, -0.04541612f, 0.11999944f, 
    0.10947141f, -0.22222492f, -0.16989791f, -0.12702075f, 0.05209580f, -0.26914963f, -0.04082893f, -0.12600462f, 
    0.03712187f, 0.09062547f, 0.02154462f, 0.07291952f, -0.08398657f, -0.08344913f, -0.03918633f, 0.12966017f, 
    -0.04382822f, -0.14805797f, -0.17408673f, 0.05287210f, 0.06732231f, -0.16246952f, 0.16794652f, 0.06715231f, 
    0.08446817f, 0.10473370f, 0.23117585f, 0.11405905f, 0.06743177f, 0.07458458f, 0.13005264f, 0.09294526f, 
    -0.03938029f, -0.01298658f, 0.04098320f, -0.03355058f, -0.28724647f, 0.39949048f, -0.43044081f, 0.14499089f, 
    0.36844507f, -0.18405485f, -0.00806813f, 0.08348145f, -0.19017011f, 0.05688234f, -0.04834362f, 0.03890634f, 
    -0.02717058f, -0.07062896f, -0.05982556f, -0.16233051f, -0.14068115f, 0.07629434f, 0.05223002f, -0.23253742f, 
    -0.02612463f, -0.04058905f, 0.02866300f, -0.06161662f, 0.32791007f, -0.07653829f, -0.14535034f, 0.03448103f, 
    0.00307655f, 0.06691577f, -0.09233019f, 0.07675482f, 0.07438251f, 0.21069624f, -0.03086344f, 0.32540110f, 
    0.00191964f, 0.13183528f, 0.04546539f, 0.03323537f, -0.25721923f, -0.06406820f, -0.14610341f, 0.28536788f, 
    0.10022834f, 0.06128830f, -0.08075991f, -0.12790473f, 0.34213191f, -0.29766196f, 0.36521125f, 0.12315270f, 
    0.05158855f, 0.08070016f, -0.11866572f, -0.24443592f, 0.12208790f, -0.25480103f, -0.01253595f, -0.15726861f, 
    0.03347772f, 0.19558331f, 0.21675572f, -0.13513640f, -0.00520753f, 0.17038654f, 0.02374787f, 0.09883570f, 
    0.03927819f, 0.05628511f, 0.01796931f, 0.06697095f, -0.37917423f, 0.71770161f, -0.12799866f, 0.65148979f, 
    -0.04751893f, 0.06469359f, 0.00394865f, -0.18411845f, 0.12604564f, -0.08931821f, 0.14717284f, 0.03443432f, 
    0.08873920f, 0.12330966f, 0.15864947f, -0.01373694f, 0.17728058f, 0.01650248f, -0.02964760f, 0.04420909f, 
    0.25401342f, -0.15639523f, 0.12177221f, 0.00899580f, 0.34027541f, -0.08890904f, 0.03711584f, -0.33658218f, 
    -0.21447502f, -0.18802060f, -0.11935156f, -0.39259663f, 0.18333171f, -0.24064383f, -0.07461137f, -0.00164577f, 
    0.26582244f, -0.41958454f, -0.50289828f, 0.07718896f, -0.18424185f, 0.11304954f, -0.15009026f, 0.09162121f, 
    0.25501078f, 0.12999199f, -0.07546123f, -0.02017556f, 0.39187714f, 0.33058131f, 0.05222945f, -0.21248734f, 
    0.19228953f, 0.04540738f, 0.32256418f, 0.26523453f, -0.01901817f, -0.03870757f, 0.01357635f, 0.02528229f, 
    -0.26418164f, -0.17475589f, -0.04090726f, -0.18187979f, 0.05531632f, 0.07918432f, -0.01240996f, 0.08667623f, 
    -0.06083934f, 0.12051742f, 0.02925271f, -0.07650764f, -0.06098957f, 0.00869210f, -0.00878054f, -0.10910417f, 
    0.00792789f, 0.08917283f, 0.05582988f, 0.24200667f, 0.03793224f, -0.03806998f, 0.18713975f, 0.20692962f, 
    -0.07513636f, -0.19586957f, -0.11281553f, 0.23240273f, -0.10224145f, 0.16177845f, -0.11172248f, 0.12601107f, 
    -0.13481233f, -0.16981082f, 0.02358529f, -0.05934730f, 0.04583275f, -0.29794413f, 0.10805457f, -0.00077430f, 
    -0.11664971f, 0.03422485f, -0.11701735f, 0.08866154f, 0.15635143f, 0.05034286f, 0.06336822f, 0.04837428f, 
    0.24408075f, 0.26164508f, -0.16146259f, -0.17456722f, 0.09206188f, 0.05233830f, 0.08633868f, -0.00675446f, 
    -0.03443873f, 0.13625258f, -0.04428632f, 0.10283116f, -0.04846843f, -0.27127150f, -0.06207557f, -0.06787959f, 
    -0.14882851f, -0.05888369f, -0.04006813f, -0.09051384f, 0.13195254f, 0.03212495f, 0.13931918f, 0.06654512f, 
    -0.16539802f, 0.03929514f, 0.05015069f, -0.03618475f, 0.08693416f, 0.02628555f, -0.12095481f, 0.05044041f, 
    -0.40160778f, -0.30021855f, -0.21632069f, -0.43411580f, 0.29498097f, -0.01208630f, 0.31517774f, -0.06223469f, 
    0.10932335f, 0.27115428f, -0.02147559f, -0.00183570f, 0.15837143f, 0.12456456f, 0.11426968f, 0.21855094f, 
    -0.02212995f, 0.11578553f, -0.21827401f, -0.25510043f, 0.06990745f, -0.00247795f, 0.13909404f, -0.05432107f, 
    0.08321608f, -0.12439222f, -0.14388150f, -0.15675293f, 0.22946928f, 0.27563587f, 0.10681824f, 0.11280254f, 
    0.02981396f, 0.06320928f, 0.07234878f, 0.18233217f, -0.00110223f, -0.00399876f, 0.10947882f, 0.08264709f, 
    -0.08110178f, 0.04424758f, 0.19067070f, -0.06727521f, -0.01005792f, -0.09858549f, -0.02943190f, -0.04662045f, 
    -0.02319888f, -0.09000520f, -0.04552212f, -0.23555742f, -0.07849994f, -0.12847066f, -0.00057292f, 0.04159871f, 
    -0.03843259f, 0.00842669f, -0.05785884f, 0.17553161f, 0.08804794f, 0.12894094f, -0.12894492f, -0.13544795f, 
    0.07024753f, -0.03592797f, 0.12551039f, 0.50073570f, -0.12409791f, -0.11527187f, -0.04838173f, -0.10428845f, 
    0.13212200f, -0.15316780f, 0.09601191f, 0.30070183f, 0.04247408f, 0.02134318f, 0.39930621f, -0.09700436f, 
    -0.08127736f, 0.01946907f, -0.15564702f, 0.01679391f, 0.00418690f, -0.06750371f, -0.04596760f, -0.09982809f, 
    -0.03260795f, -0.01612885f, -0.33199224f, -0.31364715f, 0.10244214f, 0.20293862f, 0.14865813f, -0.05830435f, 
    -0.04862747f, -0.06002245f, 0.03443008f, -0.18546088f, 0.00393083f, -0.10490348f, -0.11014403f, -0.21372649f, 
    0.16023591f, 0.23854515f, 0.02109163f, 0.20109463f, 0.00381234f, -0.08761519f, 0.11316372f, 0.05878274f, 
    -0.37749508f, 0.14078487f, 0.27074695f, -0.13223112f, 0.02808982f, -0.18194890f, -0.03216822f, -0.16151933f, 
    -0.17673714f, -0.05304763f, 0.00512863f, -0.13304937f, 0.09397852f, 0.16730820f, 0.10896348f, -0.04466582f, 
    0.05743161f, 0.11094972f, -0.08212776f, 0.02139412f, -0.00437188f, -0.08750319f, 0.04510419f, 0.08273899f, 
    -0.15166618f, -0.59591424f, -0.46649724f, -0.08990771f, -0.01995224f, 0.09942119f, -0.01939033f, 0.09881967f, 
    -0.07548720f, 0.14809459f, 0.17886163f, -0.11180659f, 0.14073817f, 0.08174554f, 0.27727339f, 0.38765648f, 
    0.00233234f, -0.02692935f, 0.01097811f, -0.07472745f, 0.05611093f, -0.15992193f, 0.21127006f, 0.32763186f, 
    0.31099951f, 0.08482242f, -0.14036876f, -0.08363058f, 0.10281505f, 0.16929410f, 0.10790557f, -0.08922138f, 
    0.00987934f, -0.05326237f, 0.11476745f, 0.14371175f, -0.21479431f, -0.08524214f, 0.03088325f, 0.24308291f, 
    0.02283728f, 0.09109661f, -0.13627227f, 0.15043622f, -0.05242484f, -0.01038470f, 0.11049139f, 0.28892434f, 
    -0.20202528f, -0.25226575f, -0.30828312f, 0.00060134f, -0.05720197f, 0.09726244f, 0.00129602f, -0.05140828f, 
    0.17517045f, 0.12974317f, 0.12314877f, 0.07718387f, 0.08200223f, -0.13633066f, 0.01313034f, -0.06390397f, 
    0.14277582f, 0.27850321f, 0.00324335f, -0.05544835f, 0.00026519f, -0.12304249f, -0.01238511f, -0.35736570f, 
    0.57027113f, 0.23395567f, -0.04460324f, 0.14453463f, -0.32135323f, -0.16564442f, 0.02659875f, 0.07244703f, 
    0.19986054f, -0.01071639f, -0.01947709f, 0.04496187f, 0.21199766f, -0.00419464f, 0.31314111f, -0.02858450f, 
    0.22341157f, 0.16207926f, -0.03710011f, -0.07157362f, 0.21968143f, 0.04914637f, 0.05864507f, 0.03009848f, 
    0.25360292f, 0.09458317f, -0.08406544f, -0.18189611f, 0.13936904f, 0.01428004f, 0.06897497f, -0.16454418f, 
    -0.08917229f, -0.29237711f, -0.09427456f, -0.05705864f, -0.08082236f, -0.08781837f, -0.08096953f, 0.16427541f, 
    0.02489597f, 0.01359258f, 0.06159947f, 0.15926045f, -0.08407889f, 0.07151340f, 0.03861937f, -0.03078694f, 
    0.20212704f, 0.23675415f, 0.01389162f, -0.09400056f, 0.16030608f, 0.13551983f, 0.21693212f, -0.03049984f, 
    -0.02089800f, -0.12143555f, -0.09576351f, -0.09367251f, -0.23649533f, -0.18481693f, -0.06256459f, -0.07324231f, 
    -0.34980744f, -0.04902834f, -0.05157798f, -0.11274835f, 0.04060665f, 0.07365406f, 0.11825189f, 0.18660186f, 
    -0.22043470f, 0.65413946f, 0.02040659f, 0.25262585f, 0.05617889f, -0.10921808f, 0.09438423f, 0.03074072f, 
    0.08931889f, 0.20759211f, 0.11566374f, -0.05326681f, 0.00933433f, -0.22455674f, -0.49356624f, -0.11986616f, 
    0.09420927f, 0.00681141f, 0.00328996f, -0.02924628f, -0.11153647f, -0.00714691f, 0.03815809f, -0.07040397f, 
    -0.21016024f, -0.17685649f, 0.00616163f, -0.01562827f, -0.09725576f, 0.04494056f, 0.02686567f, -0.12757218f, 
    0.00667597f, 0.02241659f, -0.01029819f, -0.02211282f, 0.04214627f, -0.26306969f, 0.35240275f, -0.21408604f, 
    -0.06687654f, 0.12863553f, 0.09728143f, -0.01450625f, -0.01595697f, 0.27541649f, -0.07586207f, 0.17449257f, 
    0.16560979f, 0.06953406f, 0.15468992f, 0.06154088f, -0.09437595f, -0.00867603f, -0.00485991f, -0.03993080f, 
    0.04261497f, 0.29725340f, 0.03663701f, 0.20678128f, 0.12289849f, 0.16082139f, 0.20013024f, 0.13708894f, 
    -0.06826873f, -0.07410528f, 0.01236339f, 0.09087884f, 0.07612446f, 0.22649252f, 0.05955486f, 0.09604986f, 
    -0.28077069f, -0.08291854f, -0.24151154f, -0.16231833f, -0.12883402f, 0.00938482f, 0.03458370f, -0.01787403f, 
    -0.10184558f, 0.07402153f, 0.03152111f, 0.00218319f, -0.17700191f, 0.13896850f, 0.01221864f, 0.01728077f, 
    0.02086233f, -0.00769477f, -0.00781092f, 0.12097076f, -0.09639977f, -0.03357351f, -0.11659434f, -0.02761124f, 
    -0.22818308f, 0.22656597f, -0.00916608f, -0.09983220f, -0.05721393f, 0.01143035f, 0.00454629f, -0.00312870f, 
    -0.09400974f, -0.04298496f, -0.08452027f, -0.05191746f, -0.07620367f, -0.20850153f, -0.14241193f, -0.13060565f, 
    -0.03969640f, 0.04674142f, 0.01462693f, -0.06299565f, -0.08989289f, -0.06643074f, 0.02080188f, -0.04873572f, 
    -0.04744852f, 0.11625129f, 0.13859226f, -0.09715988f, -0.01534879f, 0.03249120f, -0.01605767f, 0.01029077f, 
    -0.10067253f, 0.12052471f, 0.14304495f, 0.10311788f, -0.29333290f, 0.05363837f, 0.14204231f, 0.13597564f, 
    -0.00580879f, 0.07575820f, 0.04588363f, 0.01848314f, -0.08636259f, -0.03104620f, -0.07687087f, -0.01578913f, 
    0.09078131f, 0.13979204f, -0.04280573f, 0.05775961f, -0.04733532f, 0.00213503f, 0.03630367f, 0.06167335f, 
    -0.23359358f, 0.06623752f, 0.07103568f, 0.00962228f, 0.20095176f, 0.40267447f, 0.00873469f, 0.13028771f, 
    -0.18229796f, -0.03803489f, 0.08344129f, -0.10508624f, -0.13415961f, 0.02810674f, 0.08404515f, -0.16941862f, 
    -0.08596488f, 0.06279448f, 0.22909038f, 0.28227738f, -0.06831583f, 0.05230920f, 0.01138577f, 0.07946862f, 
    0.12176425f, 0.04352556f, 0.01531200f, -0.01166190f, 0.13254744f, 0.33418563f, 0.04542288f, -0.00396407f, 
    0.05686350f, 0.00741999f, -0.04547594f, 0.02695989f, 0.22149232f, 0.31031600f, 0.04730789f, 0.12824067f, 
    0.33937648f, 0.37901446f, 0.19345871f, 0.30188185f, 0.02996362f, 0.09086183f, 0.14785884f, 0.09990766f, 
    -0.04434645f, 0.38268694f, -0.01721457f, 0.01985431f, 0.10389055f, -0.04173031f, -0.04472239f, -0.13403256f, 
    0.04297669f, -0.05203148f, 0.04487440f, 0.00585172f, -0.04638139f, -0.07437291f, -0.02760524f, -0.02452441f, 
    -0.13632897f, -0.16413066f, -0.05682909f, -0.14609091f, -0.11244316f, 0.03174506f, -0.03699538f, 0.02549897f, 
    -0.07819751f, -0.02436386f, -0.04611997f, 0.01462419f, -0.26090679f, -0.08172148f, 0.14729832f, -0.33070216f, 
    0.00649376f, 0.14170967f, 0.16943125f, -0.07197814f, -0.03335863f, -0.00248115f, 0.01669825f, -0.09353951f, 
    -0.02240952f, 0.26795483f, 0.18813859f, 0.20540674f, 0.01060615f, 0.01534197f, 0.09125490f, -0.08344936f, 
    0.07725308f, 0.13220572f, 0.07813551f, 0.14081004f, -0.00197016f, 0.16285795f, 0.02706492f, -0.11254732f, 
    -0.11771730f, 0.05015862f, -0.04191715f, -0.04324329f, 0.03690282f, -0.00964917f, 0.00804373f, -0.11249033f, 
    0.01070293f, 0.20316441f, -0.15201749f, -0.04784958f, 0.04922483f, 0.06290054f, 0.14604819f, 0.01294730f, 
    -0.08010189f, -0.11110117f, -0.15473193f, -0.09784420f, 0.29089680f, -0.27924937f, 0.37707767f, -0.15169182f, 
    -0.04127742f, -0.10957915f, 0.22769724f, 0.04863592f, 0.01176811f, 0.07058050f, -0.02602796f, -0.00381216f, 
    -0.02340753f, 0.22428715f, -0.08690257f, -0.02891915f, 0.07098286f, -0.08894806f, -0.10505231f, 0.05685026f, 
    -0.05857674f, -0.13402772f, -0.03540754f, -0.06040892f, -0.00743406f, -0.00297346f, 0.06084869f, -0.04917351f, 
    0.05629309f, 0.31002346f, 0.10848631f, -0.05120786f, -0.04242023f, 0.15221834f, 0.14610071f, 0.14514323f, 
    0.41006941f, 0.15128714f, 0.00382190f, -0.14840679f, 0.14539231f, -0.04892528f, 0.13892463f, 0.01271138f, 
    0.06013686f, -0.00415101f, 0.10415480f, 0.08014566f, -0.44488499f, 0.58926666f, -0.02219938f, -0.05367507f, 
    -0.11876063f, 0.12379853f, -0.00124700f, 0.10910913f, 0.02561770f, 0.01768927f, 0.07415070f, -0.00565806f, 
    -0.01175469f, -0.08182533f, -0.14090273f, 0.10901202f, 0.04027708f, -0.01578690f, -0.01279576f, 0.11596881f, 
    -0.12646370f, 0.03843153f, 0.09253030f, 0.00187841f, 0.29348579f, -0.45773911f, 0.23385267f, -0.35978627f, 
    -0.02548822f, -0.04196861f, -0.03126106f, -0.02018121f, 0.09803206f, 0.10112859f, -0.10433906f, 0.12667538f, 
    0.13530256f, -0.02689111f, -0.09206025f, 0.10002372f, -0.03776824f, 0.04478248f, 0.12109882f, 0.07937407f, 
    -0.07008652f, 0.00080933f, -0.09636889f, 0.02839021f, -0.02213038f, -0.06812166f, 0.02217915f, 0.06997110f, 
    -0.00342080f, -0.00523978f, -0.01196851f, -0.04678782f, -0.21618772f, -0.02042165f, -0.01201040f, -0.08748287f, 
    -0.02793407f, -0.05271186f, 0.01488886f, -0.02952822f, -0.00537950f, -0.05201503f, -0.03006613f, 0.00391340f, 
    -0.04210369f, -0.03079394f, -0.03726273f, -0.05186189f, 0.01189870f, -0.02416843f, -0.04179624f, 0.04005051f, 
    -0.01841228f, -0.02147076f, -0.02058442f, 0.02907381f, -0.05171484f, -0.03256953f, 0.01092928f, 0.00001646f, 
    -0.05507840f, -0.02059233f, 0.02423052f, 0.02533658f, -0.05074208f, -0.05045732f, -0.00606962f, 0.04085777f, 
    -0.00467134f, 0.02961984f, 0.02240250f, -0.04937747f, -0.01648722f, 0.01734040f, 0.03579216f, -0.05144021f, 
    -0.04192809f, -0.02093101f, 0.01509428f, -0.02334753f, -0.02832589f, -0.02125950f, 0.01273267f, -0.03497015f, 
    0.00741749f, -0.04331324f, -0.05527574f, -0.03475259f, 0.01801926f, 0.00247929f, 0.00646521f, 0.03775553f, 
    -0.00205617f, -0.01423552f, -0.01787933f, -0.01160858f, -0.04220124f, 0.00564871f, 0.02604581f, 0.01465915f, 
    0.00520655f, -0.04478233f, 0.01975273f, -0.03561040f, 0.01485773f, -0.03295715f, 0.03884370f, 0.01767275f, 
    0.01723791f, -0.05529119f, 0.00752286f, 0.02191928f, -0.01439761f, -0.02653274f, -0.00698483f, -0.02341951f, 
    -0.02490883f, 0.01041499f, 0.01355457f, -0.00318807f, -0.03126807f, -0.00778493f, -0.04237001f, 0.02937846f, 
    0.01369239f, -0.04997071f, 0.03779109f, -0.04756609f, 0.04169377f, 0.01070957f, -0.05083324f, -0.01377465f, 
    0.01622902f, 0.04179532f, -0.03746559f, -0.03698374f, 0.01077712f, 0.00405930f, 0.03395891f, 0.00368377f, 
    -0.02407070f, -0.01830622f, 0.02194460f, -0.03507238f, -0.03877806f, 0.01161612f, -0.05723676f, 0.00834927f, 
    -0.04406640f, -0.05390624f, -0.01028329f, -0.01726477f, 0.01496033f, -0.02889504f, 0.00880101f, 0.02463291f, 
    0.04330320f, -0.05437864f, -0.01412869f, -0.03073721f, 0.01446062f, -0.05663171f, -0.01250401f, 0.03715534f, 
    -0.04262326f, 0.02101343f, -0.01726574f, 0.03177897f, 0.01041130f, -0.05812671f, 0.03414916f, 0.01673186f, 
    -0.05234935f, -0.02784520f, -0.04021099f, -0.05341640f, -0.04686935f, 0.01998075f, -0.03824648f, -0.02895401f, 
    -0.02252261f, -0.05238390f, 0.01352236f, 0.03966014f, 0.00541706f, -0.01849910f, -0.00969221f, 0.02618950f, 
    -0.00668182f, 0.02881136f, -0.00883003f, -0.01610673f, -0.00351545f, 0.03310005f, 0.02245065f, 0.00716875f, 
    -0.00306903f, 0.00782530f, -0.04146578f, -0.03733584f, -0.03397086f, -0.00208562f, 0.00913968f, -0.05129421f, 
    0.03828144f, -0.02368200f, 0.04256109f, 0.01338011f, -0.00071737f, -0.03233668f, -0.05127931f, 0.01812277f, 
    -0.05888783f, -0.00392538f, 0.01603614f, -0.04721460f, 0.03752719f, 0.01141029f, -0.02854931f, -0.04603209f, 
    -0.04383647f, 0.03505712f, -0.03930806f, -0.00468812f, 0.01890069f, -0.02545869f, -0.04268051f, -0.04052453f, 
    -0.02241348f, -0.05009615f, -0.00016508f, -0.05520580f, 0.01409011f, 0.00996153f, 0.00132883f, 0.04172395f, 
    0.03324702f, 0.01276257f, -0.04661338f, 0.04474587f, 0.04297100f, -0.05439514f, 0.01671341f, 0.01307558f, 
    -0.01392697f, 0.03700323f, -0.02130399f, 0.01674596f, 0.01670888f, -0.04774886f, 0.00068436f, 0.01214445f, 
    0.03931244f, -0.00207357f, 0.03046271f, -0.03128930f, -0.03564092f, -0.01428512f, -0.02730489f, 0.01535317f, 
    0.02989790f, 0.02026102f, -0.05217830f, -0.03891718f, 0.01896042f, 0.03903827f, -0.03256796f, -0.03835583f, 
    -0.04832507f, -0.02109803f, -0.03134964f, 0.01239786f, 0.04137219f, -0.05339536f, -0.02700347f, 0.00397410f, 
    0.03557333f, -0.02211087f, -0.00011400f, 0.03160622f, -0.05267913f, -0.03088480f, 0.01166762f, 0.03043225f, 
    -0.04506585f, -0.04021209f, 0.01123193f, -0.04998967f, -0.04184524f, -0.04104691f, -0.00283751f, 0.00739651f, 
    0.03008274f, -0.00167453f, -0.05281194f, -0.03263775f, -0.05289440f, 0.00073630f, -0.02467381f, -0.04088276f, 
    0.01611584f, 0.03769984f, 0.00310738f, -0.02068833f, 0.01083046f, -0.05116742f, 0.02469998f, -0.00962480f, 
    -0.00201481f, -0.04364308f, -0.05503393f, 0.03220727f, -0.04816210f, -0.03476629f, 0.02847926f, -0.02570113f, 
    0.00471923f, -0.00636812f, 0.02727914f, 0.00209646f, -0.04867687f, 0.01215610f, -0.00776113f, -0.03003556f, 
    0.04299120f, 0.01781110f, 0.01879156f, -0.00217087f, -0.01098811f, 0.04232996f, -0.00115236f, -0.04546056f, 
    -0.00775332f, -0.05632097f, -0.05579098f, 0.00117056f, 0.02236251f, 0.03023861f, 0.00358052f, 0.00142927f, 
    0.00372648f, -0.00666965f, -0.04677762f, 0.03570884f, -0.01373816f, 0.00481901f, -0.00245351f, 0.02048524f, 
    -0.00594467f, -0.03193986f, -0.05499125f, 0.02876172f, -0.01366933f, -0.03371908f, 0.00793357f, 0.02661084f, 
    -0.02517762f, 0.02902889f, -0.02251774f, 0.03375903f, 0.02843302f, -0.01747167f, 0.00801086f, -0.03248351f, 
    -0.01834432f, -0.03082583f, -0.03550295f, -0.00792727f, -0.01324742f, -0.04422234f, -0.04621700f, -0.00743658f, 
    -0.03518242f, -0.03824596f, 0.04024093f, -0.04849140f, -0.03476595f, -0.00532772f, -0.02034550f, 0.00942243f, 
    0.02165202f, -0.02063838f, -0.00525652f, 0.00321700f, 0.01416389f, -0.05426017f, 0.00002272f, 0.03783953f, 
    -0.04120492f, -0.01363534f, 0.01958161f, 0.01391540f, -0.04967080f, -0.03625861f, -0.00978934f, -0.03384922f, 
    -0.01436873f, 0.03914504f, -0.00593482f, -0.05564722f, 0.00047350f, -0.03857736f, 0.00371860f, 0.03887818f, 
    0.02808782f, 0.03440279f, 0.04000394f, 0.01934849f, 0.03756864f, 0.04325071f, 0.01493423f, 0.02332759f, 
    0.02962716f, -0.04952726f, 0.01609382f, -0.04293136f, 0.02045855f, 0.03976212f, 0.03178288f, -0.00537525f, 
    0.43184909f, 0.40146095f, -0.37271041f, 0.33890286f, -0.02453527f, -0.07452162f, 0.05192069f, 0.00350258f, 
    0.12401579f, -0.02052489f, 0.07798707f, 0.01139907f, -0.03465027f, 0.13373770f, -0.10273197f, 0.16746913f, 
    0.09086300f, 0.10813234f, 0.13656366f, -0.15280269f, -0.08874901f, -0.02791698f, -0.01080453f, 0.02383016f, 
    0.11092023f, -0.00969283f, 0.14600508f, -0.05296607f, -0.16367137f, -0.04241631f, -0.18906967f, -0.17188552f, 
    -0.09604308f, 0.10008679f, 0.09573629f, 0.03514823f, 0.02044109f, 0.06277766f, 0.18008870f, -0.03519805f, 
    -0.01280240f, 0.03456154f, 0.13651638f, -0.05865024f, -0.09577063f, 0.09054326f, -0.00226109f, 0.14418268f, 
    0.39774337f, -0.31004989f, -0.01709059f, -0.03446863f, 0.05502715f, 0.00111811f, -0.13650814f, 0.08928756f, 
    -0.08645590f, -0.10434384f, -0.00685669f, -0.05467723f, 0.17064410f, 0.06669775f, 0.06472845f, 0.10322469f, 
    -0.02815832f, -0.04748002f, 0.08667144f, -0.05500204f, -0.07801794f, 0.08160913f, 0.01129747f, -0.05341658f, 
    -0.28028646f, 0.27759472f, -0.06486115f, 0.23090388f, -0.09351549f, -0.01528737f, 0.16926534f, 0.02654404f, 
    -0.01916786f, 0.01337718f, 0.00540069f, 0.10486943f, -0.10558316f, 0.11422746f, -0.02959701f, -0.08845215f, 
    -0.11602862f, 0.00744044f, 0.05278842f, -0.03557181f, 0.03385039f, 0.06012826f, -0.00956992f, 0.04715084f, 
    -0.06307132f, 0.07752860f, 0.11419821f, -0.10541684f, -0.09049128f, -0.00092440f, -0.07611884f, 0.03869027f, 
    0.10530069f, 0.07268690f, 0.00102672f, -0.02629372f, -0.14615352f, -0.00326982f, 0.45404428f, -0.08792952f, 
    -0.09958748f, 0.01445839f, 0.03382334f, -0.02308044f, -0.03038680f, 0.07273162f, 0.04489418f, 0.14908381f, 
    -0.30644459f, 0.21360518f, -0.12097445f, -0.08584618f, 0.08961589f, 0.22660328f, 0.14468153f, 0.14968617f, 
    0.08408123f, 0.15227771f, -0.09727383f, -0.09970989f, -0.02019009f, 0.24049990f, 0.01230173f, 0.08098761f, 
    0.00583373f, 0.00849487f, 0.01924416f, 0.01659396f, 0.00004460f, -0.00634222f, 0.04098503f, 0.05592781f, 
    -0.10202292f, 0.02538231f, -0.04007149f, 0.09307443f, 0.03234820f, -0.04550925f, 0.02791966f, 0.01392177f, 
    -0.00994745f, 0.12744109f, 0.04040735f, -0.04078994f, 0.38728768f, 0.10716657f, 0.09198598f, 0.11742008f, 
    -0.05346130f, 0.07789619f, 0.04825691f, 0.05613707f, -0.03519031f, 0.11534859f, -0.06026455f, -0.09543467f, 
    0.12855177f, 0.12934276f, 0.28297946f, 0.11529686f, -0.04603121f, -0.00924573f, -0.04814861f, 0.04412156f, 
    0.07826138f, -0.04679632f, 0.05548428f, 0.13260534f, -0.02599947f, 0.12230571f, 0.12468711f, -0.14674535f, 
    -0.00469875f, 0.01412765f, -0.00733945f, -0.06175688f, 0.00062039f, -0.06874240f, -0.29390261f, 0.17922775f, 
    0.33867568f, 0.23302071f, -0.19010451f, 0.04642953f, 0.03856909f, 0.05081429f, 0.05405878f, 0.04837321f, 
    -0.06186898f, 0.08209301f, -0.04881426f, -0.21943857f, 0.13197803f, 0.07519402f, 0.19606902f, 0.28713262f, 
    0.00958225f, 0.13048361f, 0.09766810f, 0.04528721f, -0.04558811f, 0.04697829f, -0.04711492f, -0.00797765f, 
    0.05576884f, 0.00649344f, 0.03417627f, 0.10662501f, -0.13486964f, -0.07258852f, -0.17048626f, -0.03846630f, 
    -0.00608290f, 0.04767152f, 0.00197824f, 0.02360944f, 0.12831552f, -0.06079264f, 0.04665244f, -0.17631914f, 
    0.09899518f, 0.05663965f, -0.13321498f, -0.15532540f, 0.04922196f, -0.03260025f, 0.00895763f, -0.09040834f, 
    -0.00528610f, -0.09356603f, -0.04461221f, 0.05586746f, -0.01126465f, 0.00252577f, 0.01550016f, -0.02128744f, 
    -0.17806578f, -0.04801203f, -0.09761535f, -0.11742037f, 0.09572220f, 0.23458849f, 0.23426408f, 0.11088132f, 
    -0.06331020f, 0.03702525f, 0.05709375f, 0.03154493f, 0.12518051f, -0.01173326f, 0.06102737f, 0.15854363f, 
    -0.03531114f, 0.23724568f, -0.04175505f, 0.34466609f, 0.00343699f, 0.16344683f, 0.08606219f, -0.03231380f, 
    0.02194818f, 0.03063876f, -0.11906741f, 0.02070124f, 0.34229961f, -0.15639389f, 0.14897476f, 0.16266295f, 
    -0.20094381f, -0.05185591f, 0.12870902f, -0.21907063f, 0.09698993f, 0.07741582f, 0.07520171f, 0.04502597f, 
    0.09218364f, 0.21262424f, 0.06645878f, 0.12998867f, -0.14000584f, 0.04755582f, -0.08901129f, -0.02111344f, 
    -0.09735429f, 0.05542358f, 0.01616512f, -0.03310608f, -0.19667014f, 0.00234283f, 0.12223689f, -0.04064300f, 
    0.08785396f, 0.11824407f, 0.01528248f, -0.00993307f, -0.14317381f, -0.06239774f, -0.35715455f, -0.13580090f, 
    0.15959437f, -0.04716579f, 0.10370394f, 0.10010824f, -0.01984964f, 0.01250787f, 0.08850066f, -0.04919818f, 
    0.14514509f, 0.03585373f, 0.06867647f, 0.18895154f, -0.81326640f, 0.26716223f, 0.10363144f, -0.11555517f, 
    -0.19028386f, 0.09216893f, 0.13551924f, 0.11304936f, -0.05645129f, -0.01261792f, 0.01656929f, -0.04327979f, 
    0.11395620f, 0.17855678f, -0.03133967f, 0.33753955f, 0.23128527f, -0.01756722f, 0.11481461f, 0.05783751f, 
    0.10889270f, -0.00810161f, -0.03850818f, 0.05569714f, 0.23386699f, -0.48861384f, 0.32675928f, -0.20533895f, 
    -0.04080557f, -0.04339318f, 0.05000704f, 0.01980536f, -0.16733338f, -0.11897583f, -0.07799639f, 0.05805058f, 
    -0.09201703f, -0.14583884f, -0.09167501f, 0.19615586f, -0.01626926f, -0.08466625f, 0.13518904f, 0.17325243f, 
    -0.09267353f, -0.00340513f, -0.09605371f, 0.07731921f, -0.09263689f, 0.02094745f, 0.06607697f, -0.00423252f, 
    -0.01882092f, -0.02154419f, 0.01518279f, 0.00245580f, 0.02229740f, 0.03103619f, -0.00573382f, 0.00075148f, 
    0.03526807f, 0.00865459f, 0.04306422f, -0.02678816f, 0.01935987f, 0.03367587f, -0.02544368f, -0.03106803f, 
    -0.04423065f, -0.03123037f, -0.02018432f, -0.05262141f, -0.00939470f, -0.03768710f, -0.00198601f, 0.02870367f, 
    0.03582580f, 0.00277726f, 0.00939216f, -0.02174280f, -0.01823444f, -0.02060143f, -0.00351805f, -0.05604422f, 
    -0.03687421f, -0.02531257f, -0.02726377f, -0.00901630f, -0.03792608f, -0.02958745f, -0.00842175f, 0.03041357f, 
    -0.03442897f, 0.03317025f, -0.05007622f, 0.03078729f, 0.01944873f, -0.00265092f, -0.04589493f, 0.00914497f, 
    -0.05829510f, -0.00977640f, 0.03163337f, 0.01220233f, -0.04392489f, 0.02736154f, -0.01305555f, -0.03439180f, 
    0.01567758f, -0.02824476f, 0.04098688f, 0.01447008f, 0.02072019f, -0.02794569f, -0.01199136f, -0.03862227f, 
    -0.04736469f, -0.05094665f, -0.03218159f, -0.03170045f, 0.02887631f, -0.04767440f, -0.00544573f, -0.01587204f, 
    -0.03956464f, -0.00820803f, -0.02085072f, 0.03744379f, 0.01198081f, -0.00274348f, 0.02065029f, 0.00815741f, 
    -0.03204596f, -0.03042525f, 0.01388842f, -0.01786739f, -0.03413294f, 0.01947156f, -0.02781476f, 0.01134825f, 
    -0.04886859f, -0.05583927f, -0.03613464f, -0.04425654f, 0.00244049f, 0.00255509f, -0.03987138f, -0.00215077f, 
    -0.02258754f, -0.04473964f, -0.02358606f, 0.00885311f, -0.05029415f, 0.03418036f, 0.03686992f, -0.01973850f, 
    -0.00017236f, -0.01328600f, 0.02708741f, -0.04491676f, -0.01653207f, 0.00994211f, -0.04269136f, 0.00137196f, 
    0.04032281f, 0.01115737f, -0.02207456f, -0.00757426f, -0.03499448f, 0.03583909f, 0.02777038f, 0.04039941f, 
    -0.05473369f, -0.02155623f, -0.03773420f, -0.05730880f, 0.03177119f, 0.03375249f, -0.01172638f, -0.02662605f, 
    0.03539135f, -0.04057371f, 0.00822932f, -0.01784918f, 0.00154004f, -0.04996778f, -0.00121300f, 0.04076224f, 
    0.04237128f, 0.01666009f, 0.00797768f, -0.01386078f, 0.00397180f, 0.03661000f, 0.01929963f, 0.00394952f, 
    -0.02576760f, 0.01803290f, 0.03599555f, 0.02135585f, 0.02470202f, 0.01342075f, -0.04270786f, 0.04002940f, 
    0.00142841f, 0.01593186f, 0.00928356f, 0.04180266f, -0.03929913f, 0.01866133f, -0.03042416f, -0.03353377f, 
    0.03704064f, -0.01236203f, 0.04167434f, -0.05579462f, -0.05322828f, -0.03280516f, 0.02327674f, 0.01162832f, 
    0.03366314f, 0.04156992f, -0.03331826f, -0.00010959f, -0.02359190f, -0.04218503f, -0.04285901f, -0.05662734f, 
    -0.04546251f, 0.03086992f, -0.02623695f, -0.03984569f, 0.03380272f, 0.00865818f, -0.02828823f, 0.02761413f, 
    0.01715343f, 0.04267013f, -0.04401652f, 0.04127589f, -0.01192966f, 0.00164335f, -0.02016414f, -0.00115318f, 
    0.00035636f, -0.03927825f, -0.04578432f, 0.02359406f, -0.00740277f, -0.02094473f, 0.03324653f, 0.00195465f, 
    -0.02799791f, 0.01025317f, 0.01438715f, -0.01757138f, 0.02481666f, -0.05499295f, -0.04774354f, -0.03570160f, 
    -0.03854140f, -0.02886672f, -0.00095693f, -0.04032038f, -0.00790689f, 0.01302718f, -0.02849580f, 0.01804882f, 
    0.04241642f, -0.03167115f, 0.03071207f, -0.00198835f, -0.04445848f, 0.03390352f, -0.00309507f, -0.05328558f, 
    -0.01485442f, -0.00410196f, 0.02642564f, 0.00901062f, -0.03606376f, 0.03312701f, 0.03119757f, 0.00109676f, 
    -0.03770049f, -0.04784772f, -0.00378286f, -0.05586698f, 0.00874600f, -0.00383857f, 0.03922465f, 0.03153214f, 
    0.00804174f, 0.04047718f, -0.04561831f, -0.02242320f, -0.00196410f, -0.00112831f, -0.04373601f, 0.00413936f, 
    0.02450761f, 0.00808633f, -0.02352149f, -0.01111123f, -0.05423696f, -0.00039392f, -0.04632081f, -0.04579047f, 
    -0.01342721f, -0.05105649f, -0.05121062f, 0.00245487f, -0.00716755f, -0.04877066f, 0.00444463f, 0.00599643f, 
    0.04323370f, 0.01467208f, 0.04644671f, -0.03705013f, -0.02107369f, 0.03410727f, 0.01054506f, -0.01880655f, 
    0.01928629f, 0.00270084f, -0.04485560f, -0.02885902f, -0.03102182f, -0.03965180f, -0.03703104f, 0.03633583f, 
    -0.05170928f, 0.00647058f, -0.04857662f, -0.05349975f, -0.01153228f, -0.04562280f, -0.04944224f, 0.03598836f, 
    -0.02479958f, 0.04251729f, 0.01766418f, 0.01827930f, -0.02802944f, 0.01206598f, 0.01176892f, -0.03712477f, 
    0.00466510f, 0.03362364f, -0.03004178f, -0.03871829f, -0.04964434f, -0.05243757f, -0.04744761f, -0.04594237f, 
    -0.00846436f, -0.00060828f, -0.00196883f, 0.00245011f, 0.01852674f, -0.00239090f, 0.03112798f, 0.02852395f, 
    0.00516600f, 0.04342463f, -0.02346335f, -0.01685146f, -0.05767638f, -0.04690005f, -0.01389338f, 0.02905297f, 
    -0.02586776f, 0.00989528f, 0.01901175f, -0.05023297f, 0.03848325f, 0.01791854f, -0.03519459f, -0.02979934f, 
    -0.01353334f, -0.03513559f, 0.02764617f, 0.00099651f, -0.00122479f, -0.03515501f, -0.01749372f, -0.03677916f, 
    0.02612345f, 0.02456174f, 0.01327630f, -0.04420739f, -0.03696084f, -0.04608160f, -0.01876872f, -0.02076249f, 
    0.02912894f, 0.04213111f, 0.02025915f, -0.00968202f, 0.03445213f, -0.03022062f, 0.02931740f, -0.01979323f, 
    0.02391572f, -0.04150413f, 0.03401424f, -0.00001134f, -0.01087786f, 0.02440180f, -0.01888475f, 0.00577067f, 
    -0.03835537f, -0.02182646f, 0.04077652f, -0.03080042f, 0.00127162f, -0.02812334f, 0.02175923f, 0.01602886f, 
    0.03556959f, -0.04519619f, -0.05231407f, -0.00684113f, -0.00019037f, -0.03916683f, 0.02739414f, -0.04285443f, 
    -0.03466564f, -0.03386939f, 0.03115984f, -0.04396421f, 0.00603259f, -0.00888131f, 0.04337231f, -0.01732910f, 
    -0.02859981f, -0.02404412f, 0.03583932f, 0.04025525f, 0.01878225f, 0.01606297f, -0.04156688f, -0.00918898f, 
    0.55120200f, -0.12226915f, -0.16759056f, -0.32804027f, 0.00300012f, 0.02343236f, 0.14952430f, -0.01739006f, 
    0.04226700f, 0.00876161f, 0.05856862f, 0.13298491f, 0.15218993f, 0.38115141f, 0.31784534f, 0.27582151f, 
    0.00608029f, -0.09241838f, -0.04434249f, 0.03171439f, -0.00812493f, 0.04230073f, -0.13008751f, -0.02051169f, 
    0.15690468f, 0.07614563f, -0.23982576f, -0.24458589f, -0.02773116f, 0.11972731f, 0.25070775f, 0.14556672f, 
    0.03437697f, 0.06124879f, 0.09408358f, 0.01561361f, -0.22965057f, 0.11243063f, -0.12052767f, -0.27707753f, 
    0.01538971f, -0.11946809f, 0.04580582f, 0.27087712f, 0.00196596f, -0.06006372f, 0.03250527f, -0.12050790f, 
    0.18163201f, -0.39169139f, -0.11636080f, -0.15818721f, 0.03641138f, -0.08487608f, -0.07309430f, -0.08042195f, 
    0.20198412f, -0.12872051f, 0.05768696f, 0.12223745f, 0.06058220f, -0.22292583f, -0.27996632f, -0.21937168f, 
    0.02301895f, -0.07469321f, -0.01027438f, -0.12061291f, 0.03798622f, 0.05551123f, 0.05979338f, 0.11524123f, 
    0.36466262f, 0.38217172f, 0.49629983f, 0.04758216f, -0.04136137f, 0.06035556f, 0.14086401f, 0.23471305f, 
    -0.07842675f, -0.09677336f, -0.02895960f, -0.06790815f, -0.10177581f, -0.33524749f, -0.20978510f, -0.21350005f, 
    -0.03911152f, -0.03910944f, 0.01464582f, -0.05112641f, -0.00559504f, 0.17670523f, -0.01801038f, 0.04130273f, 
    -0.07055157f, -0.20560594f, -0.13558936f, -0.12909791f, 0.04612077f, -0.08782877f, -0.10088556f, -0.04116975f, 
    -0.05794093f, -0.02142982f, 0.08524751f, 0.02519437f, -0.21073781f, 0.36029369f, 0.07399813f, 0.14784807f, 
    0.18407586f, 0.09181639f, 0.16145039f, 0.14291705f, 0.03224483f, -0.02968485f, -0.07691733f, -0.06900868f, 
    0.22705202f, 0.06785719f, 0.04520998f, 0.11909375f, 0.05219052f, -0.06554522f, 0.12492359f, 0.04079177f, 
    0.09880103f, 0.06411185f, 0.08947370f, 0.09146128f, -0.13279621f, -0.31592292f, -0.27787945f, -0.29034790f, 
    0.00970453f, -0.11424384f, -0.09384372f, -0.04682869f, -0.01839466f, -0.03819338f, -0.08496680f, -0.07517694f, 
    -0.25000888f, -0.36321551f, -0.14530681f, -0.17052267f, 0.03951647f, -0.12787630f, -0.04113644f, 0.01182922f, 
    -0.06633800f, -0.02580721f, 0.05524727f, -0.04564624f, 0.18967037f, -0.31904146f, -0.34486619f, 0.08673742f, 
    -0.04885605f, -0.00329515f, 0.05906568f, -0.15227933f, 0.02612062f, 0.08070569f, 0.02994208f, 0.02766699f, 
    0.09905096f, -0.23324719f, -0.24359486f, -0.49687928f, 0.05361129f, 0.05662400f, -0.12024190f, 0.03259190f, 
    -0.08527157f, -0.08791300f, -0.05390319f, -0.08551746f, 0.07335816f, -0.20216401f, -0.02134585f, 0.01480633f, 
    0.04669443f, -0.01876867f, 0.04445883f, 0.01643326f, -0.00266360f, -0.11275475f, -0.22114928f, 0.00084238f, 
    0.34133428f, 0.57533252f, 0.08023185f, 0.13453580f, 0.06848578f, 0.16262503f, 0.19874567f, 0.33341727f, 
    0.00495631f, -0.19637708f, 0.02650058f, 0.24622540f, 0.34181052f, 0.49912819f, 0.28573161f, 0.28106937f, 
    0.11671498f, 0.10743111f, 0.04116042f, 0.05463512f, 0.01172007f, 0.03299660f, -0.01026187f, 0.10131507f, 
    -0.32584760f, -0.21216506f, -0.38635334f, 0.00622241f, 0.03909112f, 0.06347463f, -0.04208904f, 0.11424866f, 
    0.01169231f, 0.05470012f, 0.10966371f, 0.10556503f, 0.29913139f, 0.40104273f, -0.03503700f, 0.14043991f, 
    0.02385594f, 0.03972771f, 0.00201266f, 0.04906914f, -0.12817894f, -0.02773613f, -0.10567210f, -0.05582475f, 
    -0.00706616f, -0.00451699f, -0.22350773f, -0.02673915f, 0.04288674f, 0.06341174f, 0.00928587f, 0.04716527f, 
    0.13232423f, 0.01385640f, 0.00361764f, 0.09190306f, -0.27225286f, -0.58865166f, -0.42141402f, -0.22730878f, 
    -0.10134391f, 0.00307642f, -0.07558097f, -0.02515173f, 0.00124574f, -0.04629166f, -0.17265923f, 0.00227069f, 
    0.35346475f, 0.30299106f, 0.27478471f, 0.34465861f, 0.02300312f, 0.13027689f, 0.13170135f, 0.04577559f, 
    0.03645075f, -0.03296285f, -0.12180056f, -0.01054917f, 0.05789424f, 0.04612076f, -0.51974976f, 0.08694565f, 
    0.34749821f, -0.01810911f, -0.06177909f, 0.00778436f, 0.04453056f, -0.03175384f, -0.05028064f, -0.00295809f, 
    0.22495486f, 0.07499370f, 0.05049468f, 0.06856488f, 0.03926965f, 0.23253344f, -0.04135653f, 0.15261649f, 
    -0.05351087f, -0.02458171f, -0.10727862f, -0.00328550f, -0.08140574f, 0.04382377f, 0.03459762f, 0.13000675f, 
    0.06711642f, -0.11114459f, 0.09531280f, 0.01653258f, 0.19377881f, 0.16263698f, -0.00180844f, 0.12422449f, 
    -0.29302067f, -0.14306848f, -0.13060015f, -0.09189138f, 0.02394896f, -0.00107037f, -0.03579399f, -0.04226961f, 
    -0.05822015f, 0.13319017f, -0.02803515f, 0.05383166f, -0.17814246f, -0.02885349f, -0.01130465f, 0.03716969f, 
    -0.05573341f, 0.04493346f, -0.12371790f, -0.07016256f, 0.07347491f, 0.03273166f, -0.00267137f, 0.01313867f, 
    0.39410019f, 0.28315917f, 0.42695731f, 0.34304917f, 0.20270997f, 0.04574275f, 0.01967455f, 0.26706445f, 
    0.06476237f, -0.09400631f, -0.03526608f, 0.05846877f, 0.14371507f, 0.32614118f, 0.10716128f, 0.31268525f, 
    -0.05033012f, -0.00188151f, 0.00296208f, 0.17943603f, -0.01862939f, 0.00230875f, 0.11683360f, 0.01023133f, 
    0.24287716f, 0.30745777f, 0.15376535f, 0.36339918f, 0.04273983f, 0.13231751f, 0.03767125f, 0.10507960f, 
    0.08442524f, -0.07545018f, -0.04815845f, 0.09217442f, -0.08444232f, -0.13739829f, -0.23796231f, -0.15789601f, 
    0.11720994f, -0.02182668f, -0.08260474f, -0.03173570f, 0.02136201f, 0.06366315f, 0.00365529f, 0.13563955f, 
    -0.00899972f, -0.04984593f, -0.00878691f, -0.05729912f, -0.04782302f, -0.01175512f, -0.05750073f, -0.00789233f, 
    -0.05142985f, -0.01956405f, -0.02352478f, -0.06185181f, -0.01538242f, 0.01233773f, -0.00773436f, 0.02430455f, 
    0.01396183f, -0.03079137f, 0.03094405f, 0.01530990f, 0.02361492f, -0.01934415f, 0.01477894f, -0.03945364f, 
    0.00214007f, 0.00767489f, -0.02850582f, -0.08192405f, 0.02395191f, -0.00284240f, -0.06314931f, -0.08093871f, 
    -0.04072098f, 0.01403241f, -0.07987721f, 0.00620751f, -0.02556663f, -0.04343786f, -0.02109119f, 0.01242979f, 
    -0.05003199f, -0.00919139f, 0.02027754f, -0.01757039f, -0.05165922f, -0.07056952f, 0.03454452f, -0.00969997f, 
    0.02620130f, 0.01547648f, 0.00182479f, -0.01556343f, -0.03932950f, -0.04229397f, -0.02586487f, -0.04590811f, 
    0.03083686f, -0.03887596f, -0.04481725f, 0.00419385f, -0.02222686f, -0.00331304f, 0.01903106f, 0.03841786f, 
    -0.04742146f, -0.05926796f, -0.04749388f, 0.00691515f, 0.02860151f, -0.01880067f, -0.04740301f, -0.04289133f, 
    -0.00892629f, -0.02773885f, -0.03621215f, -0.04443632f, 0.02408616f, 0.02014341f, -0.05467149f, 0.02020259f, 
    0.00880537f, -0.04054479f, 0.00821925f, 0.00769394f, -0.01295487f, 0.00114029f, -0.03585997f, -0.04116862f, 
    0.00510267f, -0.00182157f, -0.03097779f, -0.07672839f, -0.01403241f, -0.04819055f, -0.01077334f, -0.07211662f, 
    -0.03280919f, 0.02036190f, 0.00415259f, 0.03667263f, -0.03523127f, -0.04817459f, 0.01357008f, 0.01266902f, 
    -0.03798230f, -0.05661518f, 0.01887272f, 0.03078418f, -0.00914944f, 0.02650249f, -0.02236814f, -0.07615848f, 
    0.00127549f, -0.05740821f, 0.00204956f, 0.03334342f, -0.04048404f, -0.03350434f, -0.05865651f, -0.08654589f, 
    0.01660972f, -0.03437069f, -0.02207482f, -0.05453060f, -0.00011204f, -0.04379110f, -0.03535654f, -0.05458360f, 
    -0.06091828f, -0.02459501f, 0.02070850f, 0.01173607f, -0.03162784f, -0.01434828f, -0.07348780f, -0.07973128f, 
    -0.04334034f, -0.00165648f, 0.01059333f, -0.00721933f, -0.06595526f, -0.07182515f, -0.07747380f, -0.07548345f, 
    -0.01321775f, -0.05687678f, -0.03252694f, -0.02091222f, -0.05210584f, -0.00270954f, 0.01081986f, -0.06795590f, 
    0.04002903f, -0.03451719f, -0.08455613f, -0.01305803f, -0.05480897f, -0.06394742f, -0.00589058f, -0.04789074f, 
    -0.07648987f, -0.02078791f, -0.05722737f, -0.02304803f, -0.00426965f, -0.02685705f, -0.07558548f, -0.01528132f, 
    0.00942216f, -0.01019366f, -0.08585741f, -0.02810268f, -0.03516754f, -0.07711101f, -0.07676547f, -0.05766744f, 
    0.01883396f, -0.04396303f, 0.00237754f, -0.02150603f, 0.03605755f, 0.02043559f, 0.03900662f, 0.01324997f, 
    -0.04235826f, -0.06700887f, -0.02283821f, 0.02578064f, -0.03412043f, -0.05069709f, -0.04609790f, 0.01261177f, 
    0.03330427f, -0.02085353f, 0.03927894f, -0.00207928f, -0.00953872f, -0.03805523f, -0.01770305f, 0.02898410f, 
    0.02787101f, -0.05079445f, -0.04626938f, -0.00720664f, 0.01023325f, -0.01853114f, 0.03136773f, -0.04082106f, 
    -0.01286357f, 0.01192244f, -0.05679906f, -0.04399011f, -0.01331395f, -0.05454379f, 0.01141538f, 0.01815947f, 
    -0.08626020f, -0.01539251f, -0.03042751f, -0.04300997f, -0.00012317f, -0.05437406f, -0.03642279f, -0.00119093f, 
    0.01185280f, 0.01337483f, -0.00960775f, -0.01404204f, -0.01078904f, 0.04495021f, 0.01022823f, -0.00498505f, 
    -0.00135068f, -0.05082609f, -0.02181607f, -0.02473914f, -0.04697050f, 0.00879082f, -0.03011652f, 0.01789703f, 
    -0.00572329f, -0.09045865f, -0.03816469f, 0.01107956f, -0.03736516f, 0.01048341f, 0.01348679f, -0.00133813f, 
    -0.02330476f, -0.02225760f, -0.01340854f, 0.00571911f, 0.00829277f, -0.00625184f, -0.05417128f, -0.04514178f, 
    -0.07192621f, -0.00081777f, 0.00195071f, -0.01835698f, -0.02229454f, -0.05865268f, -0.02504321f, -0.05154767f, 
    0.00326981f, -0.02687389f, -0.04160597f, 0.04223501f, -0.02393539f, 0.00581956f, -0.02999891f, 0.00973198f, 
    0.03827539f, -0.03202559f, -0.04593378f, -0.04854599f, -0.08923940f, 0.01252333f, -0.02390727f, -0.04648026f, 
    0.00816587f, -0.02122241f, -0.05962642f, -0.07266320f, -0.05338484f, -0.01144897f, -0.02567741f, -0.04130508f, 
    -0.01483271f, -0.03947067f, 0.01072355f, -0.01317635f, -0.00263882f, 0.00057893f, -0.01727932f, -0.08182624f, 
    -0.04502977f, -0.01896711f, -0.03547479f, 0.00542048f, -0.00140186f, 0.01825534f, 0.01531653f, 0.02902166f, 
    -0.05691174f, -0.00312973f, 0.00369815f, 0.00762173f, -0.01952443f, 0.00263713f, 0.04177560f, 0.01658050f, 
    -0.02149473f, -0.03645569f, -0.04451372f, -0.01853311f, -0.03962628f, -0.06693580f, -0.02454837f, -0.00624021f, 
    -0.07088683f, -0.04878430f, -0.03467644f, -0.00926737f, -0.02583187f, -0.03573415f, -0.06664046f, -0.07691245f, 
    -0.07160075f, 0.03769487f, -0.02155464f, -0.08205428f, -0.00490332f, -0.01862645f, 0.00981437f, -0.08595288f, 
    0.04386873f, -0.01286167f, 0.03461107f, 0.00321757f, -0.00998970f, 0.00984566f, 0.02934485f, 0.01279938f, 
    -0.04072842f, -0.00184903f, -0.01738470f, 0.03851977f, -0.02488925f, 0.03603931f, -0.05559510f, -0.07859425f, 
    -0.00483714f, -0.00890179f, -0.05141591f, -0.04901038f, -0.01044817f, -0.07025058f, -0.02477391f, -0.05871305f, 
    0.01795139f, -0.01365951f, 0.01488428f, -0.04876037f, -0.01134676f, -0.02128270f, -0.01858314f, -0.01373080f, 
    0.00137031f, -0.05383692f, -0.06022925f, -0.01458449f, -0.07315928f, -0.00440044f, -0.06243226f, -0.08134481f, 
    -0.02641419f, -0.03136827f, -0.06859504f, -0.05407505f, -0.02099752f, -0.05909314f, 0.00575437f, -0.08340140f, 
    -0.10875730f, 0.31149033f, -0.13822693f, 0.08027248f, 0.11141657f, -0.13652696f, -0.14224146f, -0.15003482f, 
    0.08037077f, 0.07922532f, 0.07296097f, -0.02142490f, 0.20563050f, 0.16637716f, 0.10390117f, 0.15136702f, 
    0.15734038f, 0.15312953f, 0.01157518f, 0.11107627f, 0.00476604f, -0.00633570f, 0.04494952f, 0.03502548f, 
    -0.12455151f, -0.61972737f, -0.02132752f, 0.22724821f, 0.14740551f, 0.09814187f, 0.24519008f, -0.08850358f, 
    -0.04282941f, -0.17096576f, -0.13598676f, -0.12712942f, 0.15920086f, -0.20959115f, -0.14866526f, -0.26431647f, 
    0.09510620f, -0.00642081f, 0.03129270f, -0.02610024f, 0.19321254f, 0.02470103f, -0.14899495f, 0.05032463f, 
    0.17528291f, 0.09953538f, -0.30513215f, -0.01912945f, -0.05565566f, -0.04232301f, 0.11666236f, -0.07834401f, 
    0.15101957f, 0.16021344f, 0.10495476f, 0.22893576f, 0.42502627f, -0.02406263f, -0.16708572f, 0.19835681f, 
    0.00629572f, -0.16046998f, -0.00469394f, 0.14066499f, 0.10508726f, 0.02761460f, -0.06304543f, 0.11886158f, 
    0.18250060f, -0.05198250f, -0.02874183f, -0.23701985f, 0.13089211f, 0.10795225f, -0.02156484f, -0.02807378f, 
    0.03745064f, 0.05270584f, -0.06583146f, -0.12942876f, -0.09542459f, -0.10815503f, 0.52929217f, 0.43182123f, 
    0.01506352f, 0.04857335f, -0.20964451f, -0.12801918f, -0.07742360f, 0.02042030f, 0.02856300f, -0.01660717f, 
    -0.31408429f, -0.18513191f, -0.20120333f, 0.25394246f, 0.01342051f, 0.10646229f, 0.10621308f, -0.03453444f, 
    0.09617224f, -0.08865897f, 0.14854495f, 0.09656359f, -0.18117897f, -0.24170178f, -0.03461878f, -0.04989854f, 
    -0.12706605f, 0.17877732f, 0.12900218f, 0.03004312f, -0.12256476f, -0.08910849f, -0.22666737f, -0.18161574f, 
    -0.19860876f, 0.48487064f, 0.34706312f, -0.01957007f, 0.10394251f, -0.06831015f, 0.00197733f, 0.03520820f, 
    0.03125027f, 0.03531425f, 0.05367120f, 0.13151111f, -0.13302635f, -0.12010095f, -0.29084510f, -0.08379157f, 
    0.00332087f, 0.10371148f, 0.04578716f, -0.08682470f, -0.08526076f, -0.03342134f, -0.04611766f, -0.04671970f, 
    -0.04211198f, -0.18659844f, -0.05113466f, 0.01311150f, 0.11705391f, 0.07023261f, -0.07069957f, 0.00228058f, 
    0.00872310f, -0.00233347f, 0.05268835f, 0.25452140f, 0.07803942f, 0.05606117f, -0.21598361f, -0.14646590f, 
    -0.03962141f, -0.29903302f, 0.09887536f, -0.15055299f, 0.09653613f, 0.08529274f, 0.20380248f, -0.12114238f, 
    0.08316261f, 0.00982087f, -0.22056040f, 0.00800037f, -0.01118547f, -0.13469775f, -0.01360792f, 0.08909632f, 
    0.16319862f, -0.02314211f, 0.06736804f, -0.04696320f, 0.19426835f, -0.07928829f, -0.01425790f, -0.28556326f, 
    -0.01457682f, -0.03874688f, -0.04361525f, 0.09687249f, -0.00671930f, 0.22051990f, 0.19359267f, -0.00723430f, 
    -0.13008521f, -0.04001475f, 0.30254143f, 0.14153714f, 0.08113112f, 0.13296276f, -0.01196519f, -0.00561954f, 
    0.00038741f, 0.04726943f, 0.07623940f, 0.25868669f, 0.01166419f, 0.12353013f, 0.00430086f, 0.08462254f, 
    0.01599438f, -0.09016941f, 0.02082369f, -0.09647237f, -0.15940967f, -0.15974942f, -0.02197645f, -0.20298092f, 
    -0.26159778f, -0.40950879f, -0.31411156f, 0.30603108f, 0.13181496f, 0.18003914f, 0.03192350f, -0.16494398f, 
    -0.03719554f, -0.20796750f, -0.08457694f, -0.04901845f, 0.21524045f, 0.03343579f, -0.12446824f, -0.17230168f, 
    0.02726852f, -0.00043106f, -0.05431896f, 0.09428874f, 0.08887724f, 0.13714235f, 0.00489864f, 0.00319934f, 
    0.23592991f, 0.36126393f, 0.33453915f, 0.28966483f, -0.03368519f, 0.04393497f, -0.13024130f, 0.08089641f, 
    0.01705447f, -0.01642410f, -0.01400589f, 0.16436110f, -0.07217166f, -0.11179340f, -0.25749087f, -0.08970767f, 
    -0.07187921f, 0.00501304f, -0.00665468f, 0.06850911f, -0.03907109f, -0.06327435f, 0.05550483f, 0.13710345f, 
    0.18745463f, 0.19672921f, 0.18129982f, -0.00528650f, 0.12149588f, 0.15303493f, -0.10304057f, -0.04929867f, 
    -0.05408999f, -0.11595240f, 0.02439290f, -0.01899726f, -0.11944575f, -0.15158728f, -0.18974654f, -0.08359980f, 
    0.11819939f, -0.10838562f, -0.05215307f, -0.01672623f, 0.01265752f, 0.03414680f, -0.00171711f, -0.09547897f, 
    -0.10713413f, 0.14809118f, -0.02380526f, 0.02763356f, -0.10007561f, -0.21474962f, -0.21971373f, -0.15082192f, 
    -0.02537480f, -0.24774870f, -0.11409019f, -0.08698267f, -0.21640950f, -0.00966184f, -0.17363833f, -0.01572165f, 
    0.04386229f, 0.13372238f, 0.11771150f, -0.16797204f, -0.02303030f, 0.16555113f, 0.18962996f, 0.27213681f, 
    -0.05842001f, 0.09152141f, 0.15522513f, -0.01964647f, 0.13435988f, 0.01947082f, -0.13669361f, -0.03580596f, 
    0.05843617f, 0.15846501f, 0.07084741f, 0.05885716f, -0.25306669f, 0.28357962f, 0.33889192f, -0.12144376f, 
    -0.17378895f, -0.03725176f, -0.08119076f, -0.01168647f, -0.00452052f, -0.06832736f, -0.07942595f, 0.09370600f, 
    0.03486036f, 0.10034740f, -0.06165928f, -0.01886999f, 0.09700693f, 0.25108194f, -0.07114844f, 0.02738368f, 
    0.10369740f, 0.01146970f, -0.03960844f, 0.16847497f, 0.46643093f, 0.07547066f, -0.28925633f, 0.06127547f, 
    -0.10031657f, 0.05931608f, 0.05636144f, -0.02599809f, 0.17381306f, 0.08832223f, 0.03302652f, 0.09137443f, 
    -0.07669246f, 0.06577212f, 0.23182094f, 0.15149276f, 0.09301580f, 0.00405185f, 0.07125574f, 0.07601867f, 
    0.00996342f, -0.02688006f, 0.09702880f, 0.10274499f, -0.08304646f, -0.03779145f, 0.02505511f, 0.21745196f, 
    0.05079916f, -0.19423126f, -0.02208531f, -0.06839679f, -0.05610268f, -0.09810528f, 0.06769028f, -0.06026700f, 
    -0.40762463f, 0.42995530f, 0.46654043f, -0.32875293f, -0.00463309f, -0.12335045f, 0.01343321f, -0.18014245f, 
    -0.08440179f, 0.08039233f, 0.08805168f, 0.07439761f, -0.40272108f, -0.18703371f, 0.05251912f, 0.08022522f, 
    -0.04283378f, 0.00815592f, -0.13973379f, 0.11778886f, -0.01015505f, -0.11879772f, -0.04086905f, 0.01476561f, 
    -0.19749783f, 0.41991347f, 0.05804941f, 0.28755951f, 0.11171275f, 0.01250896f, 0.26931530f, -0.10220120f, 
    -0.13425758f, -0.28716210f, -0.24733444f, -0.21955958f, 0.14170627f, -0.04732540f, -0.08732212f, 0.00755791f, 
    0.17176197f, -0.01222153f, -0.05212480f, -0.17370239f, 0.04030236f, 0.02047595f, 0.06944918f, -0.11190458f, 
    -0.06739754f, 0.33073017f, -0.12364616f, -0.11667732f, 0.07620873f, -0.08438867f, 0.13432363f, -0.18116426f, 
    0.30319205f, 0.23889120f, 0.15239953f, 0.16000275f, -0.07969690f, 0.37848407f, -0.12591793f, 0.00335559f, 
    0.01770275f, 0.17237958f, 0.15281174f, -0.04279847f, 0.01115859f, 0.16729781f, -0.02060330f, 0.04673805f, 
    -0.23568344f, -0.11184900f, 0.15380426f, 0.09985022f, 0.03943720f, 0.11231809f, 0.03114559f, -0.02365027f, 
    0.10878465f, -0.09194138f, -0.08722536f, -0.17740126f, 0.16204903f, 0.16437516f, 0.14030559f, 0.05516630f, 
    -0.04943672f, 0.15075703f, -0.01443148f, 0.16454746f, -0.08892278f, 0.03666831f, -0.08229282f, -0.17276096f, 
    0.09341012f, -0.25466236f, -0.12054300f, 0.08468577f, 0.00439822f, -0.04637894f, 0.11790071f, -0.18587762f, 
    0.45535570f, 0.11816704f, 0.35953200f, 0.39316016f, -0.32747993f, 0.17307527f, -0.23756729f, 0.33409837f, 
    0.14639330f, 0.01166986f, -0.08967240f, -0.15810545f, -0.33259547f, -0.37997478f, -0.29119933f, -0.42604885f, 
    0.35435188f, -0.17282788f, 0.49861336f, 0.16762856f, -0.19612387f, -0.06719961f, 0.07090060f, 0.13102573f, 
    0.20302726f, 0.12311672f, 0.07109413f, 0.20726830f, 0.05191320f, -0.05826851f, 0.03291208f, -0.03241845f, 
    0.08818363f, 0.04585006f, -0.28843200f, -0.10966637f, 0.10856123f, -0.14242440f, -0.02697720f, -0.10665966f, 
    -0.06419723f, -0.25329754f, -0.12070331f, -0.16912945f, -0.23392236f, -0.24358258f, -0.14003770f, -0.08844330f, 
    0.20586571f, -0.02759863f, 0.08868386f, 0.49582866f, -0.06688268f, 0.26372704f, -0.21941477f, -0.04139521f, 
    0.00481938f, -0.13557386f, 0.16298020f, -0.09449179f, -0.05331748f, 0.08352392f, 0.02714642f, 0.20877913f, 
    -0.02363826f, 0.02925047f, 0.03372227f, -0.21029827f, 0.10738176f, 0.06585783f, -0.07208298f, -0.09200092f, 
    0.19442968f, 0.07856867f, 0.03355883f, 0.09505921f, -0.06926940f, -0.30896804f, 0.05364952f, 0.16385631f, 
    -0.06337614f, -0.08387473f, 0.11264761f, 0.04199307f, 0.16474152f, 0.27812997f, 0.20310187f, 0.34187156f, 
    -0.20946266f, -0.01586560f, 0.51351553f, 0.34858862f, -0.27524382f, -0.20566095f, -0.00353896f, 0.31524241f, 
    0.20457862f, 0.02257919f, 0.14830311f, 0.28799954f, -0.18522584f, -0.00365587f, 0.04557748f, -0.11687950f, 
    -0.04520775f, -0.05333864f, -0.01595707f, -0.08019742f, -0.31820968f, -0.25656053f, -0.31577647f, -0.27902487f, 
    -0.22062097f, -0.09893248f, 0.03400251f, -0.04213535f, 0.15041998f, 0.17842989f, 0.02918988f, -0.04073975f, 
    -0.09293456f, -0.39613223f, -0.10420547f, -0.03210311f, -0.20020655f, 0.34209681f, -0.05065167f, 0.10624316f, 
    0.20702790f, 0.05167124f, 0.01828575f, 0.21196243f, -0.00618913f, 0.12722054f, 0.05645262f, 0.00809020f, 
    0.07490813f, 0.64023322f, 0.47366843f, 0.25428873f, -0.14226303f, -0.16945603f, 0.10229816f, 0.06459925f, 
    0.03591063f, -0.06004884f, -0.14411967f, 0.16446710f, 0.00233911f, 0.01031178f, 0.01932931f, -0.26746532f, 
    -0.00048668f, -0.11617125f, -0.22211422f, 0.09539834f, -0.15588564f, 0.01154727f, -0.14424689f, -0.15413801f, 
    -0.26247647f, -0.06447532f, 0.21517663f, 0.00295051f, -0.00054177f, -0.05369157f, 0.00169964f, 0.00888479f, 
    -0.03385209f, -0.05643966f, -0.04831747f, -0.24112007f, -0.12607537f, 0.42681390f, -0.40100852f, -0.16199739f, 
    0.24430351f, -0.11573236f, -0.03931054f, 0.08128344f, -0.15103091f, 0.24658735f, -0.09596323f, -0.31605831f, 
    -0.17848630f, 0.18916334f, 0.06081154f, -0.07745640f, 0.05566675f, -0.03722890f, -0.01305819f, -0.19589323f, 
    -0.14724042f, -0.27151579f, -0.21229579f, -0.33138323f, 0.06905735f, -0.17125808f, -0.34959549f, 0.08979632f, 
    -0.10165445f, -0.00120035f, 0.20841841f, 0.09424964f, 0.30669236f, 0.05383677f, 0.35144538f, 0.48817292f, 
    0.00879899f, 0.15937470f, 0.11764383f, -0.02177151f, 0.01813402f, -0.05715422f, -0.04260495f, 0.16684584f, 
    0.01577898f, 0.26289910f, 0.14944907f, -0.09287538f, 0.33007452f, -0.05625057f, 0.03118135f, 0.35683465f, 
    0.00875530f, 0.15534621f, -0.16150884f, 0.07764485f, 0.08275980f, -0.14718437f, 0.13212737f, 0.03207166f, 
    -0.16320249f, -0.20837772f, 0.22102854f, -0.12238605f, -0.08765763f, 0.09767155f, -0.05338058f, 0.01082037f, 
    0.24422614f, 0.09540204f, 0.10353599f, 0.21011618f, -0.05108627f, 0.33696422f, -0.03150517f, 0.21962643f, 
    0.00910927f, 0.15839666f, 0.06304906f, -0.13947514f, 0.23107290f, 0.03734016f, 0.20357008f, 0.11059982f, 
    -0.05379536f, -0.10225834f, 0.22708575f, 0.10686772f, -0.02267648f, 0.00773631f, 0.01953804f, 0.15072389f, 
    0.19527937f, -0.13464317f, 0.28494892f, 0.10017795f, 0.19120720f, -0.22106354f, -0.05011829f, -0.07346756f, 
    0.16478845f, -0.09518998f, -0.29451442f, 0.08184961f, -0.06014516f, -0.19681868f, -0.05429403f, -0.34238094f, 
    0.44487393f, -0.18101270f, -0.07091237f, -0.20824553f, 0.01224007f, 0.01378923f, 0.06575257f, 0.03541230f, 
    0.22951156f, 0.22114061f, 0.06836541f, -0.02807232f, -0.39014468f, -0.14230654f, -0.26103118f, -0.06440917f, 
    0.05320352f, 0.00373807f, -0.09660248f, 0.02987008f, -0.12794879f, -0.12117969f, -0.06850195f, 0.08298007f, 
    0.19070055f, 0.11082207f, -0.01904189f, 0.07118576f, -0.03051239f, 0.04933143f, 0.13673188f, 0.02457218f, 
    -0.11457703f, -0.03822799f, -0.02214363f, -0.03637982f, 0.31792501f, 0.03663902f, -0.12981310f, -0.16065808f, 
    -0.04803782f, 0.08571144f, 0.10346548f, 0.18584451f, -0.04416180f, 0.02356309f, -0.10604276f, -0.01486920f, 
    0.02385118f, -0.02011427f, -0.04806931f, -0.16064861f, -0.00800629f, -0.00729990f, -0.09728555f, 0.05527391f, 
    0.08494872f, -0.03831636f, -0.05263154f, 0.03657572f, 0.04852083f, 0.06955782f, -0.17507519f, 0.03247999f, 
    -0.01539727f, 0.00460445f, 0.03726549f, 0.08558436f, 0.02858593f, -0.00064550f, 0.05285859f, -0.05869692f, 
    -0.01001542f, -0.16698171f, -0.27737471f, -0.23591259f, 0.12231072f, -0.04053816f, 0.15091431f, 0.22305857f, 
    -0.20571624f, 0.00029523f, 0.02630681f, -0.00187009f, 0.29694900f, 0.20440441f, 0.16030422f, -0.07256058f, 
    -0.08330210f, 0.08331853f, -0.03975666f, -0.06338532f, -0.01384665f, 0.13622141f, -0.05168959f, -0.04587669f, 
    -0.06884387f, -0.08994520f, 0.09057799f, 0.09984469f, -0.09041467f, 0.02477732f, 0.01050639f, 0.01744014f, 
    0.04467509f, -0.02861363f, 0.07937760f, -0.01712357f, -0.06609585f, 0.16648045f, 0.03948712f, 0.19284531f, 
    -0.13426003f, -0.01773395f, 0.07264725f, -0.03000030f, -0.01164018f, -0.06126824f, -0.04086496f, -0.01817016f, 
    -0.26708359f, -0.06306119f, -0.11584061f, -0.34258491f, -0.11480561f, 0.07460658f, -0.01427982f, 0.05420770f, 
    0.03379413f, 0.00696738f, -0.01711184f, -0.03975475f, 0.23296037f, 0.17968038f, 0.08234849f, 0.01644499f, 
    -0.04028829f, -0.06979345f, -0.00663837f, 0.02920413f, 0.12723386f, 0.02252475f, 0.01806065f, 0.03582458f, 
    0.06819404f, 0.00503290f, 0.12928908f, 0.11158676f, -0.00344997f, 0.02491692f, -0.00257258f, -0.03095618f, 
    0.20355725f, 0.25635907f, 0.11345379f, 0.01521290f, 0.05881473f, 0.22624353f, 0.07683552f, -0.01596216f, 
    0.01062611f, -0.02204883f, 0.13950445f, -0.03760225f, 0.12344207f, 0.23840870f, 0.17366715f, -0.15111752f, 
    0.19638215f, 0.27657083f, -0.23417915f, -0.04033891f, 0.03627905f, -0.04999140f, 0.02781165f, -0.01916678f, 
    0.00573704f, 0.09550738f, -0.00702440f, -0.09770422f, 0.13373026f, 0.22745048f, 0.08048663f, 0.02171442f, 
    -0.07657259f, 0.02568559f, -0.03450296f, 0.09544884f, -0.05218301f, -0.04241206f, -0.19527915f, -0.01276515f, 
    -0.11936850f, -0.42066461f, -0.28239724f, -0.39232129f, -0.25087288f, -0.17313814f, 0.04569580f, 0.17242491f, 
    -0.17055510f, -0.00042755f, 0.10625151f, 0.04870670f, -0.31618983f, -0.32879779f, -0.28253683f, -0.19350605f, 
    -0.03369079f, 0.08927200f, 0.03517702f, 0.02533813f, -0.05340805f, -0.03861429f, 0.00438986f, -0.01457859f, 
    0.11527789f, 0.07785291f, -0.01848932f, 0.27809164f, 0.00116087f, -0.01829764f, 0.00561561f, -0.01306319f, 
    0.01533302f, 0.09000957f, 0.08459807f, 0.03239138f, -0.11845470f, 0.35956788f, -0.52244574f, -0.17276093f, 
    -0.30724609f, -0.15444262f, 0.19206350f, 0.12192702f, -0.08488297f, 0.00316806f, -0.05871823f, -0.01387821f, 
    0.19077118f, 0.03771442f, -0.06673490f, -0.13776396f, -0.02589619f, -0.02318111f, -0.12955625f, -0.05887298f, 
    -0.16182093f, -0.01597096f, 0.10862263f, -0.03968983f, 0.18955977f, 0.29217392f, -0.19574501f, 0.23447992f, 
    0.01839633f, -0.01647640f, -0.04124876f, -0.03345163f, 0.12606847f, 0.02714847f, -0.09332719f, 0.06823462f, 
    -0.42803204f, -0.41568857f, -0.28219354f, -0.29911259f, 0.04318918f, -0.00946585f, 0.05706390f, 0.14175245f, 
    -0.01728031f, -0.09680972f, -0.17878878f, -0.02404626f, -0.05516855f, -0.09153612f, -0.06450788f, 0.04584009f, 
    -0.05150510f, -0.19162346f, 0.18692617f, -0.17766933f, 0.10684257f, 0.11524240f, -0.07228398f, 0.14000472f, 
    -0.05871564f, 0.18514878f, 0.04217137f, 0.09652456f, 0.01385889f, -0.19540107f, 0.04334268f, -0.14670897f, 
    0.01888661f, 0.29520771f, 0.07305079f, 0.03584942f, -0.17583662f, 0.06363285f, -0.10579485f, 0.01838726f, 
    -0.32437414f, -0.21676466f, -0.25233218f, -0.11476192f, -0.12897399f, -0.30570939f, -0.23767282f, -0.09960314f, 
    0.52900434f, -0.11573423f, 0.17242485f, 0.13806154f, 0.02093473f, 0.15919985f, -0.08534048f, 0.00534539f, 
    0.16807850f, 0.03766650f, 0.05374785f, 0.01841675f, -0.23245461f, 0.09943593f, -0.00040994f, -0.22408508f, 
    -0.11260100f, -0.10521527f, -0.08624622f, -0.15005009f, -0.01814807f, -0.06498206f, -0.00328972f, -0.00902446f, 
    0.01992028f, -0.04649699f, -0.23953772f, -0.04349072f, 0.04867870f, 0.14365183f, 0.17608567f, 0.16914044f, 
    -0.17907067f, -0.15574482f, -0.11295619f, -0.08365743f, 0.11293859f, 0.10639881f, -0.32248825f, 0.20293005f, 
    -0.12346359f, 0.04989212f, 0.18653248f, 0.31825981f, 0.01120835f, -0.10755374f, 0.04948058f, -0.08376694f, 
    -0.45718142f, -0.39137119f, -0.05842623f, -0.12926373f, -0.11060839f, -0.05365413f, -0.18192418f, 0.20096840f, 
    -0.16093664f, -0.22598262f, -0.04750225f, 0.09838572f, 0.14280568f, 0.06427407f, 0.14467707f, -0.01878910f, 
    -0.01405992f, 0.01042730f, -0.04451976f, -0.03810778f, -0.02558037f, -0.07285029f, 0.11002955f, -0.04533801f, 
    -0.45247561f, 0.29008543f, 0.13610758f, 0.23713423f, 0.03818864f, -0.17053770f, -0.12541616f, 0.01152367f, 
    -0.24676405f, -0.05551424f, -0.13111204f, 0.20830868f, 0.07934718f, -0.06836306f, -0.19554776f, 0.11210896f, 
    -0.13977265f, 0.18601023f, -0.08324419f, -0.14167957f, -0.11526135f, 0.01715186f, -0.07054706f, -0.20677221f, 
    0.20941548f, 0.19698854f, 0.31921300f, -0.16117506f, 0.10905098f, 0.09157077f, -0.18271314f, 0.17977537f, 
    -0.02802843f, 0.07888711f, 0.02553051f, 0.06310572f, -0.16875184f, 0.06148507f, 0.04103041f, 0.31535429f, 
    0.07168088f, 0.09757849f, 0.03048365f, -0.31574577f, -0.18266025f, 0.10554019f, -0.00754515f, 0.05800823f, 
    -0.34305266f, -0.21087839f, 0.31730705f, -0.01234035f, -0.00686330f, 0.01503252f, -0.13486318f, 0.00560143f, 
    -0.04496113f, 0.08295423f, 0.03540561f, 0.28426611f, -0.15590540f, 0.03536291f, 0.23184146f, -0.33847195f, 
    0.06534946f, -0.03857651f, 0.07519529f, -0.15788852f, -0.07639945f, 0.10317463f, 0.07413357f, 0.07983845f, 
    0.18933660f, 0.05359895f, 0.12675685f, 0.14739530f, -0.11870033f, -0.19072258f, 0.04312866f, 0.23183103f, 
    -0.03195456f, 0.01285048f, 0.00374035f, 0.05504697f, -0.19565459f, 0.02652721f, -0.13177137f, 0.06612507f, 
    0.06304795f, 0.02910554f, 0.18067740f, -0.00351502f, -0.06434704f, -0.01135897f, -0.01934137f, 0.02480026f, 
    -0.06656834f, 0.09076825f, 0.05836043f, 0.05865171f, -0.19804201f, -0.04797244f, -0.09908479f, -0.09880869f, 
    0.10623216f, 0.00359103f, -0.05377023f, 0.31889838f, 0.16493572f, 0.16240771f, 0.38555428f, -0.21438523f, 
    0.24215816f, -0.05237768f, -0.02564372f, 0.09851404f, -0.06334507f, -0.04830922f, 0.06207007f, -0.07209557f, 
    0.34004614f, -0.01864936f, -0.19779581f, 0.39125660f, 0.10682505f, -0.07399923f, -0.10278842f, -0.08774041f, 
    -0.15247773f, 0.07488310f, 0.10057640f, 0.15504377f, -0.18729690f, -0.11026326f, -0.11134365f, 0.21123461f, 
    -0.10412237f, 0.05730553f, -0.00519333f, -0.02196537f, -0.14645568f, 0.10629566f, -0.00948358f, 0.18562438f, 
    -0.20730516f, -0.00525188f, -0.15567666f, 0.13380070f, -0.08465312f, -0.00162287f, 0.08281221f, -0.05133739f, 
    -0.15416841f, 0.14943679f, 0.09369645f, 0.23579308f, 0.04560755f, -0.35147497f, 0.07655874f, 0.09194489f, 
    -0.16263717f, 0.12912966f, -0.14323711f, 0.00074485f, -0.11944700f, 0.01074423f, -0.12359305f, 0.15492107f, 
    -0.10772802f, -0.18024191f, 0.16938534f, -0.06522451f, -0.14124739f, 0.01308083f, -0.00949449f, 0.16956927f, 
    -0.05106157f, -0.06587770f, -0.08675519f, -0.08007769f, -0.00273129f, 0.09959444f, -0.22509369f, 0.06399009f, 
    0.04001908f, -0.02939985f, 0.18962750f, -0.01406537f, 0.30464372f, 0.18261121f, 0.11966022f, 0.11379100f, 
    0.55670458f, 0.33181378f, 0.20292519f, 0.50189894f, 0.01461613f, 0.02722486f, 0.08932714f, -0.03619983f, 
    -0.15946384f, -0.04194456f, -0.02626218f, 0.05265395f, 0.34378079f, 0.23320121f, 0.15802613f, 0.11179830f, 
    -0.06672597f, -0.08753321f, 0.02510044f, 0.07530964f, -0.09398404f, -0.07362880f, -0.08189318f, -0.09479537f, 
    0.23457968f, 0.24148685f, 0.13084112f, -0.07405405f, -0.07730187f, 0.04234378f, -0.02520582f, 0.09410798f, 
    0.03124521f, 0.06743921f, 0.01852322f, 0.17403507f, 0.12387428f, -0.17817532f, 0.28824520f, 0.13123046f, 
    -0.09665805f, -0.01880519f, -0.05650894f, 0.29922280f, -0.04365508f, -0.08687174f, -0.13217919f, -0.15684137f, 
    -0.07415745f, 0.01731381f, 0.11103277f, 0.08226244f, 0.09004737f, -0.14425428f, 0.18441439f, -0.01768328f, 
    0.03914708f, 0.03046302f, -0.08588214f, -0.04941334f, -0.13244563f, -0.17513596f, 0.42382726f, -0.09078979f, 
    -0.03346810f, -0.01253106f, -0.01611140f, 0.10325634f, -0.01596563f, -0.16683340f, 0.10285177f, -0.22656786f, 
    0.05653081f, 0.14250596f, 0.11993001f, 0.20652436f, 0.12482741f, -0.04103079f, -0.06790866f, 0.22289015f, 
    -0.16149616f, -0.03707527f, -0.05947841f, -0.07991128f, 0.24404384f, -0.09370871f, 0.27075905f, 0.05903969f, 
    -0.08383810f, -0.00841928f, -0.07736894f, 0.15414791f, -0.13886401f, 0.13509823f, -0.06070361f, -0.18129797f, 
    0.25745487f, 0.09599774f, 0.12596335f, 0.05550873f, 0.24609517f, 0.23384885f, -0.08846410f, 0.19359736f, 
    -0.15329786f, -0.19480975f, -0.04102333f, -0.14813735f, 0.07722446f, -0.06397348f, 0.31246465f, -0.16758494f, 
    0.10160868f, 0.09281003f, -0.03766039f, 0.03060934f, -0.10602424f, 0.23614447f, -0.01857979f, 0.19559667f, 
    -0.20348774f, -0.08628055f, -0.01401812f, 0.10810871f, 0.06943371f, 0.11269901f, 0.16368707f, -0.05995150f, 
    -0.18400994f, -0.04127616f, 0.18702376f, 0.08697866f, -0.24438700f, 0.51524764f, 0.05100967f, 0.05576706f, 
    0.05002795f, 0.08703238f, 0.09714522f, -0.09508861f, -0.12081380f, -0.09400954f, 0.10042479f, -0.04510614f, 
    0.05941348f, 0.21648425f, -0.08460817f, 0.19126478f, 0.02894500f, 0.06002639f, -0.06561270f, 0.08347594f, 
    -0.07123682f, 0.10828825f, 0.07506229f, 0.08467589f, 0.02377851f, -0.20835318f, 0.62508637f, -0.04268327f, 
    0.16716407f, 0.01503697f, -0.21817385f, -0.14333141f, -0.08527458f, 0.09689332f, 0.00744297f, 0.18680412f, 
    0.24831249f, 0.09697525f, -0.18064147f, 0.12923943f, 0.12489120f, 0.03882970f, 0.04222323f, -0.12270888f, 
    -0.05422555f, 0.14619614f, 0.00607470f, 0.13077767f, -0.06194583f, 0.08868722f, -0.07617204f, 0.12638165f, 
    0.14124787f, 0.12581518f, 0.04590713f, 0.09345510f, 0.02680059f, 0.17867117f, -0.14106052f, -0.09942825f, 
    -0.37802631f, -0.48152196f, -0.19762789f, 0.28753904f, -0.01348472f, 0.13212267f, -0.05538091f, 0.05503406f, 
    -0.11200181f, -0.02329016f, -0.18823341f, 0.08872281f, 0.39457172f, 0.27223900f, 0.05854097f, 0.12458509f, 
    0.05589197f, 0.21017389f, 0.11493578f, 0.12711267f, 0.05492004f, 0.00980134f, -0.01608677f, 0.02662040f, 
    -0.08988914f, 0.14727780f, 0.21051350f, -0.03425022f, 0.04754563f, 0.14912648f, -0.02718089f, 0.22055793f, 
    0.09366301f, 0.07324528f, -0.02179836f, -0.09552802f, 0.00762825f, 0.11631057f, -0.02517278f, 0.22293170f, 
    0.00339089f, -0.15823120f, -0.01864043f, -0.17871946f, -0.00490387f, -0.12820007f, 0.20160769f, 0.04745584f, 
    -0.42449382f, -0.15225393f, -0.25471294f, 0.26410186f, -0.01287302f, -0.02985386f, 0.03563406f, 0.07143748f, 
    -0.16099824f, -0.16998813f, 0.07181118f, -0.04907621f, -0.20001313f, -0.17538397f, -0.08228938f, -0.06154434f, 
    -0.00046440f, 0.13450114f, -0.02052737f, -0.01733117f, 0.03432795f, -0.16306165f, 0.00962052f, 0.04780143f, 
    0.33852655f, 0.28408286f, 0.01764574f, 0.23213266f, 0.05846199f, 0.02295935f, -0.01085980f, 0.14492884f, 
    0.08811205f, -0.01988703f, -0.10986313f, 0.00440716f, 0.23386802f, 0.00125827f, -0.04087853f, -0.17718931f, 
    -0.03230239f, 0.03250142f, -0.00057062f, 0.00574721f, -0.02242744f, 0.00344752f, -0.07812758f, -0.08987038f, 
    0.15056233f, 0.01839074f, -0.00417735f, -0.04130388f, 0.02670283f, -0.07873435f, -0.00316430f, -0.05686627f, 
    -0.01080424f, 0.05145757f, 0.01084081f, 0.01496281f, 0.07321966f, 0.03549485f, 0.36349395f, -0.03436882f, 
    0.10126203f, -0.14611392f, -0.13715924f, -0.00411502f, 0.08278403f, 0.01770083f, 0.05104211f, -0.04688386f, 
    0.19925472f, 0.10341474f, -0.26482108f, 0.02746156f, 0.11776943f, 0.08602118f, 0.03486540f, -0.05417732f, 
    0.13167448f, -0.14825158f, -0.20064461f, -0.11044165f, -0.04655138f, 0.07921520f, -0.09493516f, -0.01402895f, 
    0.01063938f, -0.01563402f, -0.02811625f, 0.00268080f, 0.00610937f, 0.00052984f, 0.04987743f, -0.03239938f, 
    -0.07608832f, -0.06208053f, 0.03125281f, -0.13754517f, 0.07720314f, 0.03949467f, 0.06134408f, -0.04994369f, 
    0.09635736f, -0.14638117f, -0.24889129f, 0.04144115f, -0.13088240f, 0.02407591f, -0.02119152f, -0.02092489f, 
    0.15958491f, 0.04304101f, -0.08785075f, 0.06987322f, 0.04391597f, -0.04327942f, 0.02569971f, 0.20029294f, 
    -0.00567106f, -0.26067808f, 0.24440351f, 0.19711755f, 0.03183356f, -0.01895664f, -0.02224834f, -0.07496095f, 
    -0.02763091f, -0.11819044f, 0.19001587f, 0.02949737f, 0.06813039f, -0.27085635f, 0.26664305f, -0.39575028f, 
    -0.01643963f, -0.01097561f, 0.02459368f, 0.07068664f, -0.11679221f, 0.24827433f, 0.06193818f, -0.05322656f, 
    -0.03696161f, -0.38239706f, -0.32977894f, -0.10190828f, 0.02402155f, 0.05125419f, -0.04020729f, 0.13190171f, 
    -0.04578146f, -0.16998549f, 0.20264030f, -0.03712622f, 0.13991895f, -0.02847723f, -0.06408594f, 0.13355035f, 
    -0.00612494f, 0.08056992f, -0.00194962f, 0.01184462f, 0.05182496f, 0.03175467f, 0.13824964f, -0.03210890f, 
    0.02369048f, 0.04313019f, 0.18289253f, 0.04320383f, 0.07449074f, 0.01551181f, 0.02251646f, -0.07527304f, 
    0.03796569f, 0.12811457f, 0.00823032f, -0.02592780f, 0.09018011f, 0.46980006f, 0.05911700f, 0.29548699f, 
    0.02985079f, -0.10869025f, -0.22084892f, 0.16369882f, -0.04628558f, -0.01065414f, 0.02823931f, 0.07545964f, 
    0.00957655f, -0.17704104f, -0.09244054f, -0.08002788f, 0.03418371f, 0.03434642f, 0.04723028f, 0.19977386f, 
    0.05689836f, 0.00330111f, -0.15401010f, -0.04527309f, 0.04930373f, -0.02331761f, 0.21529579f, -0.09626032f, 
    0.02445151f, -0.04780478f, -0.07515071f, 0.07683077f, -0.03576690f, 0.01374271f, 0.05080280f, 0.07766563f, 
    0.12769195f, -0.19709259f, -0.02293445f, -0.03398787f, -0.00744996f, 0.00823221f, -0.05779891f, -0.00947109f, 
    -0.01034713f, -0.06545182f, 0.12807198f, 0.10183413f, -0.23226400f, 0.28025207f, -0.08833759f, 0.22825035f, 
    -0.08540326f, 0.16638951f, -0.14152510f, 0.15595703f, -0.05605468f, -0.10974607f, 0.08952719f, -0.01726871f, 
    -0.00907386f, -0.22612864f, 0.02655502f, 0.06989391f, -0.04375311f, 0.10353431f, 0.15376429f, -0.10809532f, 
    0.10513654f, -0.14985520f, 0.05316462f, 0.07213739f, 0.16836949f, -0.13464653f, 0.13921016f, -0.09393881f, 
    0.04448223f, 0.18691248f, 0.08667499f, 0.11621813f, -0.15575308f, -0.02735559f, 0.03463092f, 0.17414396f, 
    0.46503806f, -0.05724275f, 0.02678863f, -0.03347914f, -0.08341581f, -0.02251267f, 0.01560524f, -0.07981212f, 
    -0.01115094f, -0.04543954f, -0.20890565f, 0.01524001f, 0.55482918f, -0.13118975f, 0.09819354f, -0.37029985f, 
    0.11506622f, 0.01523818f, -0.00288891f, -0.06380935f, -0.02008581f, -0.20584105f, -0.13407350f, -0.09864594f, 
    0.15473346f, 0.20284753f, -0.04937580f, -0.22111191f, -0.03026100f, 0.05734145f, 0.05765796f, -0.09143654f, 
    -0.04569921f, -0.12054868f, -0.08997147f, 0.15020801f, -0.12060770f, 0.14039537f, -0.11435743f, 0.54118544f, 
    -0.11622276f, 0.21600723f, 0.10349470f, -0.13898902f, -0.11135447f, 0.05406164f, 0.17617774f, -0.11665551f, 
    0.17448613f, 0.08485112f, -0.04329434f, -0.13449083f, -0.00496157f, 0.05610575f, 0.09765802f, -0.07583659f, 
    -0.06711323f, -0.15125854f, 0.30388132f, -0.04874264f, 0.15268116f, 0.02131370f, 0.04290089f, -0.14020900f, 
    0.02363793f, -0.02607693f, 0.05547076f, 0.03676009f, 0.06103439f, 0.02173557f, 0.01307900f, 0.02998721f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01082183f, 0.04154897f, -0.01236312f, 0.02914447f, 0.01637267f, -0.03398448f, 0.16847090f, -0.01849515f, 
    0.02832578f, 0.07306586f, 0.07754389f, 0.09628878f, -0.05663668f, 0.17841507f, -0.02202935f, 0.13601817f, 
    0.01366063f, 0.21295965f, 0.12340375f, 0.00589517f, 0.06172477f, 0.08088827f, -0.03247725f, 0.03956171f, 
    0.02061109f, -0.03181175f, -0.05380544f, -0.01450508f, 0.07295915f, 0.10484259f, 0.00425792f, -0.13930824f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13052507f, 0.15352981f, -0.23985830f, -0.73496622f, -0.10652047f, -0.13169800f, -0.51490510f, -0.32298189f, 
    -0.14756677f, -0.07194192f, 0.21458544f, -0.00357357f, -0.10164820f, -0.69515735f, -0.13957345f, -0.57465124f, 
    0.02540176f, -0.69828445f, -0.12778683f, 0.11202773f, 0.41796273f, 0.19425282f, 0.07375500f, 0.04720618f, 
    0.07046819f, 0.12632099f, 0.01826826f, 0.29758358f, -0.28052294f, -0.43049458f, 0.11460263f, 0.23507611f, 
    -0.00140968f, 0.04554369f, -0.35686278f, -0.07554252f, -0.10697591f, 0.03630829f, -0.45755202f, -0.60522366f, 
    0.32904467f, -0.00547580f, 0.06076794f, 0.29484105f, 0.15755476f, -0.09645136f, -0.08228450f, 0.17149389f, 
    0.51934743f, 0.27484262f, 0.03037843f, -0.45825285f, 0.01771588f, 0.09154663f, -0.05841772f, 0.27100179f, 
    -0.10302222f, 0.29779819f, 0.07055508f, -0.13529103f, -0.72334439f, 0.23605950f, -0.04574275f, -0.19305906f, 
    -0.10292381f, 0.16251031f, -0.32746461f, 0.01690496f, -0.02160839f, 0.08501974f, -0.04954415f, -0.20156679f, 
    -0.53255117f, 0.29041293f, 0.06575944f, 0.02738599f, 0.04955574f, -0.06123575f, -0.10461231f, -0.15919815f, 
    -0.72359860f, 0.49680051f, -0.05323157f, -0.10002831f, -0.36839408f, 0.34560141f, -0.11875094f, -0.03551591f, 
    0.02875541f, -0.32417920f, -0.04157435f, 0.01681753f, 0.41220164f, -0.35818762f, 0.09292616f, -0.33579445f, 
    0.00413383f, 0.12320215f, 0.41765541f, 0.09460052f, 0.11482392f, 0.10851787f, -0.44890803f, 0.54199976f, 
    -0.34569603f, 0.16573735f, 0.17799993f, -0.82795829f, 0.07835541f, -0.32559356f, 0.09200038f, -0.23542522f, 
    0.05048018f, 0.23371024f, -0.46394530f, 0.04757457f, -0.23953980f, 0.03148356f, 0.00499986f, 0.08870928f, 
    0.09327857f, 0.10878630f, 0.13624667f, 0.17760345f, -0.20255563f, -0.33563378f, 0.10484274f, -0.11131122f, 
    -0.08047983f, -0.09170155f, -0.40338308f, -0.08609753f, -0.17423157f, -0.15510669f, 0.31153819f, -0.05621475f, 
    -0.18175238f, -0.07136030f, -0.15134241f, -0.21268991f, -0.05326205f, -0.59678352f, -0.12908873f, 0.16310298f, 
    -0.51473284f, -0.36882213f, 0.28931630f, 0.14965165f, -0.39269572f, -0.29714569f, 0.00664846f, -0.00936631f, 
    -0.09833916f, 0.22000796f, 0.08346749f, 0.11690550f, 0.18444782f, 0.06786644f, 0.10024679f, 0.18894617f, 
    -0.03235855f, -0.00483642f, -0.22856516f, -0.25072533f, -0.13476391f, -0.07428348f, 0.29617858f, 0.01161924f, 
    0.14361843f, -0.03683809f, 0.17809233f, -0.07613756f, -0.07257880f, 0.47481433f, -0.00706066f, -0.20141466f, 
    -0.17361751f, -0.15732387f, 0.30311656f, 0.21023847f, 0.35831615f, -0.41179267f, 0.11375935f, 0.01255116f, 
    -0.08479841f, 0.14528161f, -0.09364752f, 0.10920180f, -0.38754332f, -0.21570700f, -0.41110587f, 0.05794853f, 
    0.15010200f, 0.06936523f, 0.32802626f, 0.02208633f, -0.03310052f, -0.14036711f, 0.03037773f, 0.02008731f, 
    -0.11927393f, 0.17973068f, 0.02889014f, -0.10258713f, 0.15224464f, -0.02736544f, 0.15833251f, 0.43258956f, 
    -0.23366567f, -0.05809950f, 0.28320664f, -1.11347806f, -0.42569742f, 0.31735942f, -0.18081391f, -0.03645983f, 
    -0.03697614f, -0.92374951f, -0.16117646f, 0.34689876f, 0.07509585f, 0.05905114f, -0.61222970f, -0.34986389f, 
    -0.08559674f, 0.05950997f, 0.02156004f, 0.15386890f, -0.17118649f, -0.05895154f, -0.31438524f, 0.49631807f, 
    -0.08960649f, 0.13644730f, -0.38504559f, 0.21030030f, 0.16336069f, -0.23272373f, -0.16077332f, -0.20735347f, 
    -0.04259824f, -0.08722511f, -0.21055768f, 0.49559650f, -0.18413769f, -0.10007974f, 0.00799460f, -0.17898762f, 
    -0.12679265f, -0.49218199f, -0.14938512f, -0.53947753f, 0.26295009f, 0.13052545f, -0.58356214f, 0.23322175f, 
    0.00907292f, 0.06698923f, 0.31611165f, -0.30375406f, 0.13519034f, 0.07328448f, 0.20403950f, 0.43510783f, 
    -0.38953051f, 0.12701739f, 0.01416107f, 0.18858576f, 0.13330829f, 0.18820283f, -0.01674057f, 0.08559558f, 
    -0.20606476f, 0.28241032f, -0.42637628f, -0.18217716f, 0.46423477f, -0.14146933f, -0.04418500f, -0.19039008f, 
    -0.10941675f, -0.58585221f, 0.05644154f, -0.60990006f, -0.51741749f, -0.06141574f, -0.13409309f, 0.19081052f, 
    0.04533982f, 0.14599901f, 0.28082767f, 0.25162944f, -0.07649078f, 0.01547947f, 0.15734264f, -0.45382982f, 
    -0.48848987f, -0.16353285f, 0.35827225f, 0.21177189f, -0.00142424f, 0.07139179f, -0.18416962f, 0.02086109f, 
    0.35301772f, -0.64596707f, 0.20717409f, 0.13398840f, -0.75765252f, -0.21696985f, -0.04634572f, -0.59411806f, 
    0.12822457f, -0.00676691f, 0.05467200f, 0.08976290f, 0.03208047f, 0.08379934f, -0.03930303f, -0.44108126f, 
    -0.16537106f, -0.07478308f, -0.52834976f, 0.40670004f, -0.11522105f, 0.02879174f, 0.42274007f, 0.40499666f, 
    -0.35842201f, -0.60766882f, -0.02969309f, -0.10366783f, -0.12855709f, 0.13198964f, 0.01396070f, 0.14602745f, 
    -0.43240827f, 0.13743950f, 0.02620076f, -0.26407835f, 0.09227145f, 0.22346628f, 0.16155234f, 0.36165658f, 
    0.15282544f, -0.39274415f, -0.02108361f, -0.17020892f, -0.76167077f, -0.12544931f, 0.15075198f, 0.00197250f, 
    0.00484313f, 0.06853464f, 0.34359199f, 0.38097942f, -0.14600787f, -0.05049638f, -0.31280833f, -0.33462173f, 
    0.43701702f, 0.15667079f, -0.51126754f, -0.37515962f, 0.07196523f, 0.08999604f, 0.05131952f, 0.09524240f, 
    -0.21282859f, 0.13095973f, 0.13867784f, -0.49640477f, -0.01636842f, -0.09135941f, 0.00506229f, -0.03777548f, 
    0.04465975f, -0.09667578f, 0.06991811f, -0.36915529f, -0.21296759f, -0.47426596f, 0.43683398f, -0.03591758f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01113362f, -0.05056246f, -0.01482396f, -0.02726360f, -0.05015698f, -0.07601008f, -0.12189505f, -0.08885305f, 
    0.17968276f, -0.03163391f, -0.17523867f, -0.11684635f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
