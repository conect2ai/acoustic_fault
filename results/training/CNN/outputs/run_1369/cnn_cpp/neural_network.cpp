#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00188847f, -0.48867044f, -0.35920209f, -0.49575901f, -0.56295949f, -0.20475610f, 0.65254837f, -0.23455842f, 
    0.28390193f, 0.58127677f, -1.13991678f, -0.37557578f, -0.71151149f, -0.40529463f, -0.17329508f, 0.07933646f, 
    -0.06266845f, 0.01648916f, -0.62891471f, 0.92118555f, -0.11464367f, -0.56395817f, -0.44384649f, -0.52503550f, 
    0.03074190f, 0.08024814f, 0.28518355f, 1.04268682f, -0.71735835f, -0.92231822f, 0.31853530f, 0.64053679f, 
    0.28102285f, -0.43775237f, -0.15162906f, -0.08634288f, -0.00224035f, -0.92257398f, -0.53598356f, -0.03810929f, 
    0.37362328f, 0.44360614f, 0.33462411f, -0.25378594f, 0.05745824f, 0.15173085f, -0.37170231f, -0.13983878f, 
    -0.39566457f, 0.03039623f, 0.39653930f, -0.06729862f, 0.16587286f, 0.10460155f, -0.75049067f, -0.16106600f, 
    -0.76672703f, 0.39414975f, -0.23116681f, 0.44607037f, -0.25622714f, -0.28286099f, -0.08092689f, -0.54802710f, 
    -0.19061871f, -0.57858211f, 0.01382763f, -0.40237936f, -0.67672795f, -0.38575882f, -0.19677818f, -0.46318161f, 
    -0.18701182f, -0.18909772f, -0.30693069f, -0.43419641f, -0.44820124f, -0.58297372f, 0.14145249f, -0.25444815f, 
    -0.34106478f, -0.54144508f, 0.27858889f, 0.31985173f, -0.04711492f, -0.36597449f, -0.19036217f, 0.33424219f, 
    0.17376643f, 0.24560919f, -0.68650025f, -0.06823651f, 0.36961335f, -0.53906137f, -0.37131003f, -0.27801704f, 
    0.07059496f, -0.58313215f, 0.29302707f, -0.41006309f, 0.16162953f, 0.31337833f, 0.31604800f, -0.75559396f, 
    0.45994645f, -0.12794459f, 0.23024014f, -0.20730042f, 1.10644722f, -0.92081207f, -0.71914399f, 0.37952653f, 
    0.05759748f, -0.09127998f, -0.14785765f, -0.12574910f, 0.25804383f, -0.72885305f, -1.05492747f, 0.96180612f, 
    0.30539113f, 0.39231589f, -0.12964453f, 0.14769958f, -0.26033291f, -0.06136923f, -0.01700110f, 0.80996031f, 
    -0.22584026f, -0.39886123f, -0.42347243f, 0.08618749f, -0.09004885f, 0.35665330f, 0.33542976f, 0.76052600f, 
    -1.12041605f, 0.51618117f, -0.46898705f, 0.02201930f, 0.33576864f, 0.15769348f, -0.34590292f, -0.06809314f, 
    0.74743700f, 0.37406206f, -0.09454700f, -0.66843206f, 0.27563095f, 0.26927105f, -0.51330554f, -0.10731889f, 
    -0.30278158f, -0.47714663f, 0.96050888f, 0.07094673f, -0.94901657f, 0.08058804f, 0.14035946f, 0.15968120f, 
    0.42148241f, -0.04430949f, -0.10106659f, 0.63282508f, -0.20687903f, 0.45252901f, 0.33544773f, -0.01160243f, 
    0.04120979f, -0.22302620f, -0.34639412f, -0.55357212f, 0.14172083f, 0.40656891f, -0.18479313f, 0.58255672f, 
    -0.43127832f, 0.04252671f, 0.18328749f, -0.22575700f, -0.21661723f, 0.37344104f, -0.18622661f, -0.43962860f, 
    0.07553162f, -0.30522397f, 0.37650865f, 0.44901407f, -0.12911309f, 0.08981931f, 0.45220488f, -0.66699421f, 
    -0.08913947f, 0.42332947f, 0.54033864f, -0.34144211f, -0.03661103f, -0.39824387f, 0.05191334f, 0.14350682f, 
    0.12445228f, -0.11497854f, 0.24386145f, 0.22886996f, -0.18687464f, 0.35375217f, -0.07739386f, -0.30617851f, 
    0.19649063f, 0.10365777f, -0.09761005f, 0.02474866f, 0.33460003f, -0.47663575f, -0.14084660f, 0.40645960f, 
    -0.90455961f, -0.63048488f, -0.56203097f, 0.77055168f, 0.34399408f, 0.31611428f, 0.20984900f, -0.26645660f, 
    0.15076077f, 0.31633449f, 0.63087457f, -0.77886170f, -0.41403610f, 0.55125690f, -0.45298657f, 0.28562200f, 
    -0.17555650f, 0.07368559f, 0.14846277f, 0.37254992f, 0.30074644f, -0.22536770f, -0.04598415f, -0.06126358f, 
    -0.00688730f, 0.03332803f, 0.11012840f, -0.52645087f, 0.07518052f, 0.21145660f, -0.73912120f, -0.31456035f, 
    0.33280152f, -0.59099448f, -0.48884991f, -0.19552264f, -0.47273889f, 0.18302810f, 0.27826265f, -0.19820191f, 
    0.13078238f, 0.08586397f, -0.05184503f, -0.06700251f, 0.16403350f, 0.55032855f, 0.59556127f, -0.82657397f, 
    -0.04203788f, -0.21666063f, 0.02833250f, 0.43033990f, 0.02191121f, -0.29906720f, -0.92993659f, 0.55283397f, 
    0.07255021f, -0.37109673f, -0.53381443f, 0.34049484f, 0.47164184f, 0.12487525f, -0.11822002f, -0.06188341f, 
    0.89172083f, -0.92746401f, -0.33413237f, 0.01986430f, -0.63064975f, -0.06905231f, -0.27257374f, -0.22658132f, 
    0.30942842f, -0.04641946f, 0.22387666f, -0.53596598f, 0.31607327f, -0.01948566f, -0.19963714f, -0.16970889f, 
    0.36036623f, 0.81847131f, 0.04815844f, -0.70222276f, -0.42849329f, -0.08148836f, 0.54351848f, 0.37030873f, 
    -0.37022132f, -0.15436682f, -0.49110231f, -0.44953772f, 1.04675305f, -0.21827021f, 0.41869667f, -0.63867068f, 
    -0.30637208f, 0.21786739f, 0.44480789f, -0.72949696f, -0.10866756f, 0.15902846f, 0.09875020f, 0.37966874f, 
    0.11371064f, -0.13819359f, 0.27864918f, -0.16493592f, -0.72403622f, -0.30259365f, -0.23697428f, 0.71397018f, 
    -0.54681998f, -0.32131675f, -0.09503247f, 0.36215803f, 0.29606447f, -0.49923134f, -0.86445636f, 0.31947693f, 
    0.02495821f, -0.25205976f, -0.42862943f, 0.58201462f, -0.46715429f, -0.49908832f, 0.06167457f, -0.05230687f, 
    -0.31230602f, 0.25222060f, -0.02114411f, -0.69120723f, -0.12105189f, 0.62288046f, 0.03176691f, 0.18096051f, 
    -0.20480895f, 0.22093070f, -0.10310321f, 0.17965116f, 0.13290931f, 0.16415796f, 0.14121194f, -0.38171792f, 
    -0.00025286f, -0.69212908f, 0.25603250f, 0.00176678f, -0.57191056f, -0.33210480f, -0.28723803f, -0.16046000f, 
    -0.30725330f, 0.45445523f, 0.05723907f, -0.50272584f, -0.66310161f, -0.21327987f, 0.50930339f, -0.38791230f, 
    0.35298994f, 0.50108653f, 0.75907314f, 0.10359489f, -0.68329883f, -0.01522527f, 0.51684773f, -0.61761796f, 
    0.14534593f, 0.14793876f, -0.04205652f, 0.43201989f, 0.27378851f, -0.39731449f, -0.43936840f, -0.90024215f, 
    -0.73483229f, -0.33124390f, -0.42367533f, -0.11692963f, -0.04943827f, -0.44693717f, -0.64238101f, -0.00274956f, 
    0.35392299f, 0.25272125f, -0.02035547f, 0.31340405f, 0.04205647f, 0.66621470f, 0.15748191f, 0.45478535f, 
    0.08427371f, -0.17526713f, -0.07462174f, 0.07927392f, -0.10822377f, -0.00312064f, 0.48903140f, -0.29917172f, 
    -0.57023722f, 0.04488778f, -0.35280609f, -0.34740704f, 0.38464582f, 0.35490754f, 0.28139433f, -0.75900137f, 
    -0.12330770f, 0.40918058f, -0.49878168f, -0.59263617f, 0.28493688f, -0.04031040f, 0.58813643f, -0.28177765f, 
    -0.19420925f, 0.13076504f, 0.11114228f, 0.28517255f, -0.33254352f, 0.19278683f, 0.02044767f, -0.58457583f, 
    0.42232722f, 0.42938676f, 0.08891280f, -0.37790379f, 0.31415555f, 0.13262998f, 0.02588945f, -0.09867398f, 
    0.45280060f, -0.31444100f, 0.72306949f, -0.56386518f, -0.74346650f, 0.62694097f, 0.37706852f, 0.26449242f, 
    -0.22024956f, -0.26442280f, -0.23284154f, 0.54115731f, 0.30096105f, 0.50732130f, -0.02713447f, -0.35693228f, 
    -0.50803941f, 0.46087497f, -0.37009999f, -0.08779057f, -0.77361059f, -0.15055332f, 0.49320173f, 0.63837874f, 
    0.25081286f, -0.73440492f, -0.38766581f, -0.14455955f, -0.54921931f, -0.61725515f, -0.29932815f, -0.65493816f, 
    0.52987856f, -0.25081518f, 0.15985441f, 0.22308305f, 0.14501670f, 0.41774070f, 0.58609998f, 0.46611798f, 
    -0.74553931f, -0.38839707f, -0.00764215f, -0.56512374f, -0.29067135f, -0.06675067f, -0.44771856f, -1.23282659f, 
    0.35017619f, 0.64862084f, -0.46301925f, 0.28077555f, 0.52051264f, -0.10781120f, 0.02675434f, -0.03156368f, 
    0.19649076f, -0.06219155f, -0.47547138f, 0.97688264f, -0.41596806f, -0.42557976f, 0.01430130f, -0.06002568f, 
    0.24437803f, -0.90124738f, 0.68204635f, 0.18354939f, 0.31470910f, -0.07305953f, -0.20493059f, -0.18451446f, 
    -0.36001274f, -0.09340090f, -0.44468892f, 0.37256268f, -0.01588696f, -0.13045844f, 0.66302156f, -0.21546058f, 
    -0.18032338f, -0.27910322f, 0.15102781f, -0.20294592f, -0.68710065f, 0.12364130f, 0.21985392f, 0.20457569f, 
    0.50425094f, -0.41614380f, -0.26839036f, 0.51581854f, -0.04335061f, -0.34412900f, 0.17276669f, 0.46698084f, 
    -0.21467593f, -0.02601396f, -0.55924523f, 0.27554470f, 0.25855845f, -0.92470008f, -0.86181408f, -0.15231921f, 
    0.44390711f, 0.41389644f, -0.18388708f, -0.33379087f, -0.52095884f, -0.44735673f, -0.16326761f, 0.53899485f, 
    -0.36812875f, -0.12900254f, 0.52946955f, -0.21018890f, -0.36771145f, 0.03216054f, 0.26452744f, -0.34472734f, 
    0.49234861f, 0.68076181f, -0.69635820f, -0.72231376f, 0.27615127f, -0.03174618f, -0.20537962f, -0.48953274f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10800399f, 0.05037126f, 0.04716392f, -0.00534715f, 0.13201414f, -0.08512041f, 0.06259397f, -0.50147480f, 
    -0.10014300f, -0.44481310f, -0.23889403f, -0.10786935f, 0.23188797f, -0.06053682f, -0.13182989f, 0.02055188f, 
    0.09603869f, 0.05234938f, -0.19047037f, -0.00433570f, -0.08109566f, 0.09664094f, -0.19596778f, 0.15139502f, 
    0.03557193f, -0.13405886f, -0.01432031f, -0.34792387f, 0.26333097f, 0.00618175f, 0.23775865f, -0.10386834f, 
    0.08596750f, -0.04498696f, -0.11297527f, 0.01978481f, 0.04020487f, -0.23913771f, -0.08561961f, -0.06064261f, 
    -0.07970595f, -0.02229298f, 0.14168791f, -0.22449896f, 0.10547643f, -0.19087975f, -0.11427560f, 0.01462173f, 
    -0.25706008f, 0.05104332f, 0.06223531f, 0.22335374f, -0.25179914f, 0.07652417f, -0.09038077f, 0.03876897f, 
    0.20750917f, -0.13650493f, -0.04294298f, -0.17144009f, -0.14549263f, -0.37788671f, 0.11244017f, -0.02478720f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.32397407f, 0.27754340f, 0.04363919f, -0.36328247f, -0.08850513f, 0.08515453f, 0.06574019f, -0.06711859f, 
    -0.02141570f, 0.02237465f, 0.00226610f, 0.06417763f, -0.02739359f, 0.00585213f, 0.01806804f, 0.01903399f, 
    -0.03529058f, -0.00877519f, -0.04743436f, 0.05703477f, 0.20541570f, 0.21808925f, 0.03502237f, -0.32193056f, 
    -0.11967985f, 0.12863383f, 0.01412243f, 0.12394538f, -0.08622296f, 0.05122829f, -0.04084459f, 0.01107581f, 
    -0.03568492f, 0.00218258f, -0.03513455f, -0.00332332f, -0.04715503f, 0.00600526f, 0.08167928f, 0.08904894f, 
    0.01564000f, 0.18974653f, 0.00541905f, -0.13068184f, -0.11369341f, -0.03456985f, -0.09446727f, -0.08112106f, 
    0.04032024f, 0.02942399f, -0.00256523f, -0.00245789f, 0.03174232f, 0.01998924f, 0.01155930f, -0.07566728f, 
    0.01101150f, 0.07063657f, -0.11378142f, 0.01672145f, 0.03865564f, -0.21671166f, -0.31011760f, 0.17412515f, 
    -0.10217696f, 0.03963041f, 0.01797213f, 0.07222351f, -0.04506701f, 0.06857084f, 0.03247349f, -0.04055601f, 
    -0.18702607f, -0.01105235f, -0.01821347f, 0.00117470f, 0.08119756f, -0.07966113f, 0.01326534f, 0.01134561f, 
    0.28519675f, 0.08886475f, -0.16021559f, -0.05411819f, 0.01551616f, 0.17249666f, 0.07476027f, 0.16768561f, 
    -0.13918045f, 0.01276863f, -0.02614047f, 0.01972419f, -0.11644927f, 0.06556283f, 0.06178127f, 0.06134491f, 
    0.02438352f, -0.02612190f, 0.02613175f, 0.00947881f, 0.04145313f, 0.09569988f, 0.02587848f, 0.02235189f, 
    0.02093440f, 0.04095234f, -0.02815354f, 0.04113042f, -0.02580871f, -0.10718477f, -0.15346761f, 0.00669270f, 
    -0.05604306f, 0.01016745f, 0.04017321f, 0.04224637f, -0.06953017f, -0.02139443f, -0.00221165f, -0.02565248f, 
    0.18318349f, 0.10259864f, 0.06493231f, -0.19437344f, -0.04869709f, -0.02341693f, 0.09023377f, 0.16890962f, 
    -0.04890953f, 0.03069680f, -0.04550263f, -0.00675771f, 0.03061987f, -0.03184933f, 0.05539616f, 0.02093350f, 
    0.05118878f, -0.02021531f, -0.09142531f, -0.03269601f, 0.27849206f, 0.24787039f, 0.08439235f, -0.14537640f, 
    -0.04001533f, 0.15146282f, 0.22072558f, 0.17652024f, 0.00734049f, 0.12253337f, -0.00067188f, -0.02807499f, 
    0.00930165f, -0.07171772f, -0.07120803f, -0.06261079f, -0.11904381f, -0.08421155f, -0.11321163f, 0.05935422f, 
    0.19762655f, 0.14964782f, 0.13475394f, -0.21835300f, -0.07610328f, 0.04854478f, 0.12727211f, 0.01085617f, 
    -0.03992193f, 0.06955666f, 0.03748652f, 0.01138415f, -0.02977820f, -0.02521119f, 0.00553781f, -0.03094959f, 
    -0.02365056f, -0.08437130f, 0.00601589f, 0.05433720f, 0.05887111f, 0.10280584f, 0.12139894f, -0.00217480f, 
    0.02203644f, 0.03458558f, 0.03351412f, 0.08408658f, 0.01026080f, 0.06839989f, 0.14128406f, 0.04005735f, 
    -0.02661993f, -0.01846354f, -0.00039736f, -0.02004227f, -0.00528353f, 0.00764409f, -0.07557923f, 0.06621073f, 
    0.30264035f, 0.24553883f, 0.12910803f, -0.30408829f, 0.04274938f, 0.05370246f, 0.13170597f, 0.07187998f, 
    0.11471477f, 0.02814731f, 0.02815194f, -0.02433086f, 0.03290336f, -0.07592203f, -0.04544239f, -0.03429782f, 
    -0.05729950f, 0.03928945f, 0.01982263f, -0.10904799f, -0.52008486f, 0.27894932f, 0.36953565f, -0.27707687f, 
    0.21658687f, -0.05462546f, -0.02091563f, 0.03657643f, 0.04669855f, 0.03032894f, -0.01492520f, 0.10902149f, 
    -0.05855933f, -0.01267039f, 0.00152887f, -0.09440267f, -0.01634641f, -0.06621798f, -0.19218129f, 0.01643634f, 
    -0.00160085f, 0.00402357f, -0.32772022f, 0.10977664f, 0.01504204f, 0.04748958f, -0.02860716f, -0.05152349f, 
    -0.06493187f, -0.17894123f, -0.10608368f, -0.06604225f, -0.09476937f, 0.01822617f, -0.03505536f, -0.08352091f, 
    0.08646372f, -0.12851685f, -0.02634328f, 0.00742357f, 0.36418101f, -0.07874510f, -0.14474700f, -0.35270023f, 
    -0.02891306f, -0.06512052f, 0.01533597f, 0.12179906f, -0.01345845f, -0.04247965f, 0.02846328f, -0.04328673f, 
    -0.12748244f, 0.08743633f, -0.05879949f, 0.01847540f, 0.07830948f, 0.04308343f, -0.02307570f, 0.02912755f, 
    0.03320737f, 0.00296910f, -0.00541187f, 0.05355712f, -0.03869976f, -0.01467439f, -0.15111279f, 0.00412692f, 
    0.01382105f, 0.06534316f, 0.04248764f, -0.00273822f, -0.02419921f, 0.02533201f, -0.05105946f, -0.05514947f, 
    -0.01658876f, -0.01895314f, -0.02678501f, -0.06318832f, -0.15503500f, -0.52293569f, -0.01741122f, -0.59884495f, 
    0.15606017f, -0.10486539f, 0.01008122f, 0.02769493f, -0.08196051f, 0.07813298f, -0.08291855f, 0.00979544f, 
    -0.07611613f, 0.04847420f, 0.03917309f, 0.02642412f, -0.03753169f, -0.01017100f, -0.06695577f, -0.03330108f, 
    -0.46580219f, 0.05910407f, 0.23921348f, 0.13510698f, -0.22143732f, -0.00151929f, 0.01306228f, -0.04584557f, 
    0.04116322f, 0.05684696f, 0.05569678f, -0.00776145f, -0.01400999f, 0.01766269f, 0.05449766f, 0.08272658f, 
    0.13592169f, -0.06352465f, -0.00236798f, -0.11252773f, -0.06075599f, -0.02903086f, 0.20318678f, 0.05030998f, 
    -0.14497787f, -0.23141091f, -0.11817344f, 0.10690618f, -0.04344631f, 0.03079256f, 0.05152971f, 0.03421541f, 
    -0.10376918f, -0.02043404f, 0.02890327f, -0.07499953f, 0.00732791f, -0.03694244f, -0.21090209f, 0.02060464f, 
    -0.09719824f, -0.09359766f, -0.17411920f, -0.03504696f, -0.16341846f, 0.02850385f, 0.03456050f, 0.01005102f, 
    0.07031418f, 0.06060170f, 0.12407712f, -0.00087690f, 0.11204644f, 0.07271302f, 0.02848404f, 0.00983119f, 
    0.15842472f, 0.14483738f, -0.02468078f, 0.07060297f, -0.04686380f, -0.10783970f, 0.06687190f, -0.08713450f, 
    -0.09189605f, -0.25712746f, -0.03181111f, 0.09141591f, 0.05085373f, -0.04855197f, -0.10756458f, -0.08609036f, 
    -0.06802318f, -0.12162660f, -0.28681496f, 0.01703615f, -0.09097312f, -0.02591924f, -0.06996837f, 0.03970483f, 
    0.18817769f, 0.14635988f, 0.00223521f, -0.02092599f, -0.02503507f, 0.00080008f, -0.01944393f, -0.05508348f, 
    0.02026591f, -0.02283555f, 0.03358406f, 0.09718266f, -0.05590826f, 0.01148040f, -0.00559522f, -0.04713707f, 
    -0.03998060f, -0.04311879f, -0.07586730f, 0.02579208f, -0.12423185f, -0.27386513f, -0.21361665f, 0.17715092f, 
    -0.25283828f, 0.02522124f, 0.03294721f, 0.00341951f, 0.04581801f, 0.07946534f, 0.08301697f, -0.02009937f, 
    -0.04552720f, -0.03631023f, -0.04002282f, -0.06243449f, 0.02531617f, -0.06452860f, -0.08797662f, -0.06691201f, 
    -0.03674616f, -0.01835293f, 0.03725573f, 0.06262044f, 0.04089819f, 0.02599717f, 0.05123255f, 0.03900680f, 
    0.04283129f, 0.01198427f, -0.09894873f, -0.06728876f, 0.00100277f, -0.14392607f, -0.12569436f, -0.04042448f, 
    -0.12284029f, 0.02475302f, -0.00654161f, 0.02198018f, -0.63697946f, -0.25096676f, 0.15622491f, -0.00482597f, 
    0.05883091f, 0.03550663f, -0.01470845f, -0.05452568f, 0.02310721f, -0.02193893f, -0.00650850f, 0.02437934f, 
    0.00080619f, -0.05328428f, -0.00008303f, -0.10805646f, -0.04932776f, -0.10789385f, -0.03544591f, -0.12144459f, 
    0.21056239f, 0.05923098f, -0.23004586f, -0.08193429f, 0.06154345f, 0.11374959f, 0.18009183f, 0.10599286f, 
    -0.03011048f, -0.04600663f, -0.05193685f, -0.02807114f, -0.05909088f, -0.01275189f, 0.10445271f, 0.03536847f, 
    0.08248170f, 0.07149548f, 0.04013805f, -0.00954329f, -0.07477277f, 0.03983160f, -0.18518710f, 0.12254401f, 
    -0.16980137f, 0.02049703f, -0.02715536f, -0.07100349f, -0.11366345f, 0.14756629f, -0.02189793f, 0.01189960f, 
    0.00836496f, -0.02930038f, -0.00728408f, -0.06002441f, 0.02225704f, -0.10230752f, -0.18538839f, -0.11051068f, 
    -0.10779610f, -0.07576747f, -0.04067163f, 0.04775570f, 0.01738868f, 0.05696196f, 0.02908828f, -0.01446421f, 
    0.00519968f, 0.00403698f, 0.03848930f, 0.03726882f, -0.00637878f, 0.05303603f, 0.03251306f, -0.00062923f, 
    -0.02743086f, -0.02908149f, -0.04810128f, 0.01222896f, 0.04970602f, 0.17709328f, 0.33304170f, -0.09045944f, 
    0.06662461f, -0.08726520f, 0.08015004f, -0.00464678f, -0.06969044f, -0.09020519f, -0.01242409f, 0.00446466f, 
    0.02851262f, -0.04269145f, -0.06448971f, -0.11402434f, -0.07522481f, 0.00917150f, -0.00539088f, 0.01934794f, 
    -0.11481676f, -0.08211952f, 0.10217737f, -0.04793462f, 0.03966314f, -0.02711910f, -0.02483915f, 0.02849311f, 
    0.04392856f, 0.00370002f, -0.13673119f, -0.05472330f, -0.17775956f, -0.11829704f, -0.10229719f, -0.07005098f, 
    -0.13057303f, 0.00070138f, -0.06561296f, -0.01694648f, -0.10450080f, -0.04045659f, -0.24968497f, 0.14748870f, 
    -0.13256735f, -0.12015854f, -0.06670456f, -0.23338260f, 0.05116971f, 0.05216511f, -0.01178675f, 0.02904848f, 
    -0.01988713f, -0.03642150f, 0.02165279f, -0.12855501f, -0.03965290f, -0.04689190f, -0.08874718f, -0.10227337f, 
    0.03989008f, 0.21210890f, 0.20219341f, -0.19366828f, -0.10907228f, -0.12472071f, -0.00360596f, -0.09332632f, 
    0.04823315f, -0.10477472f, 0.08050452f, -0.04301297f, -0.15124443f, -0.07468723f, -0.03217800f, -0.03507668f, 
    -0.02275496f, -0.01567666f, -0.15266998f, 0.07422957f, -0.03015364f, 0.19476713f, 0.04918938f, 0.00096977f, 
    -0.20506309f, 0.03140632f, 0.03125093f, -0.03879859f, -0.02759202f, -0.01094184f, -0.01006256f, -0.03810999f, 
    -0.00831275f, 0.02410696f, 0.03962845f, -0.03365621f, 0.03986402f, 0.01455313f, 0.01947141f, 0.03915029f, 
    -0.53891975f, -0.34076700f, 0.24601074f, -0.01876646f, -0.28238451f, -0.00795922f, -0.06497359f, -0.04422658f, 
    -0.02467603f, 0.06427173f, -0.00304187f, 0.03197338f, 0.01569645f, 0.02136076f, 0.01809939f, 0.01982545f, 
    0.03433546f, 0.00636291f, -0.18502118f, -0.06233814f, -0.39902535f, -0.12368117f, -0.49309531f, -0.02861370f, 
    -0.45267242f, -0.00054485f, 0.03240751f, -0.08657637f, 0.10558274f, -0.03249341f, -0.02608882f, -0.02823256f, 
    -0.02331834f, -0.01903130f, 0.16271548f, -0.07896464f, -0.09825376f, 0.06303533f, 0.08282774f, -0.05212122f, 
    0.31676337f, 0.18214630f, 0.02793870f, -0.10001713f, 0.00737351f, -0.15401995f, -0.09883943f, 0.02306476f, 
    -0.12622955f, -0.05220164f, 0.01267575f, -0.11895174f, -0.01784544f, -0.13898236f, -0.11353287f, -0.00462962f, 
    0.00455110f, -0.11836948f, 0.06524464f, -0.09767784f, -0.10992935f, -0.08878324f, -0.03308591f, -0.00139327f, 
    0.01721674f, 0.01046103f, 0.06690761f, 0.07214307f, 0.01918832f, -0.00072516f, -0.08535732f, -0.09612081f, 
    -0.03069103f, -0.03208396f, -0.08046173f, 0.03063864f, 0.04952050f, -0.00471940f, -0.03816753f, 0.02724591f, 
    0.27556527f, 0.21157725f, -0.05050416f, -0.19281688f, -0.02246997f, -0.05768877f, 0.03905697f, 0.00837302f, 
    -0.02380763f, -0.04064178f, -0.03908620f, -0.09256787f, 0.02442454f, -0.04271677f, 0.01815888f, -0.03002470f, 
    -0.04728226f, 0.01680484f, -0.01924729f, -0.01815179f, 0.42654246f, 0.14706947f, 0.15559296f, -0.46793568f, 
    0.03529217f, 0.17298451f, 0.19081023f, 0.07399302f, 0.02311609f, 0.05143430f, 0.05269013f, 0.01539255f, 
    -0.08412080f, -0.01700848f, 0.03421288f, 0.03100960f, -0.08524805f, -0.17218983f, -0.10972860f, 0.15055701f, 
    0.29283625f, 0.20507437f, -0.22801799f, 0.03147026f, -0.02779865f, 0.00578785f, 0.04324015f, 0.06291256f, 
    0.00666416f, 0.12263226f, -0.01977511f, -0.08951419f, 0.00217836f, -0.09135455f, 0.01453647f, 0.00242458f, 
    -0.02375709f, -0.23001330f, -0.06966050f, 0.02200812f, -0.07764134f, -0.05312671f, -0.03732207f, 0.03557657f, 
    0.00464327f, -0.01440849f, 0.01276062f, 0.01200602f, 0.00870972f, 0.02766290f, -0.02589145f, -0.11881170f, 
    0.00982795f, 0.04851392f, -0.02864319f, 0.00022892f, -0.10109609f, 0.01596013f, -0.06135815f, 0.04485960f, 
    0.24581125f, 0.16789342f, 0.02951445f, -0.27849805f, 0.00946472f, 0.02532143f, 0.01925910f, 0.12986028f, 
    -0.07684744f, 0.05083932f, -0.01783504f, -0.02273588f, 0.01783990f, -0.04834360f, -0.14148960f, -0.03586916f, 
    -0.08141494f, -0.12653305f, 0.02069693f, 0.03679100f, 0.07169425f, 0.10680664f, 0.04604096f, -0.01794651f, 
    -0.11556719f, -0.02284259f, -0.02911022f, -0.04469591f, -0.14994377f, -0.10992672f, -0.14524078f, -0.00958910f, 
    0.01613811f, 0.10452206f, 0.05618393f, -0.06581568f, -0.09370949f, -0.01592279f, -0.04984355f, -0.06404747f, 
    -0.07173487f, -0.00258159f, -0.28341070f, 0.10799191f, -0.07741462f, -0.03747476f, -0.02678629f, -0.04111812f, 
    -0.01816590f, 0.03435493f, -0.16311973f, 0.00075071f, -0.07606393f, -0.09928776f, -0.14138301f, -0.07648775f, 
    -0.03481666f, -0.12637366f, -0.16177455f, -0.00175137f, 0.03943064f, 0.28165647f, 0.10320341f, -0.20104276f, 
    -0.12172894f, 0.03364148f, -0.00877589f, -0.03445812f, 0.04702325f, 0.02999117f, 0.01244564f, -0.03361873f, 
    0.01803678f, 0.03141648f, 0.01752371f, -0.00438531f, -0.00632043f, 0.10427687f, 0.04457929f, 0.12006826f, 
    0.21480821f, 0.12568234f, -0.19030511f, 0.03957406f, 0.04283505f, 0.14574771f, 0.07152413f, 0.09975284f, 
    -0.16410126f, -0.15733185f, -0.06477860f, -0.02585310f, -0.02486837f, -0.00977131f, 0.04567246f, 0.04133639f, 
    0.01594749f, -0.03691996f, -0.00718376f, 0.00211966f, -0.12715606f, -0.10642768f, -0.09078237f, -0.01866272f, 
    0.10854382f, 0.05078700f, 0.03872100f, -0.00963084f, 0.02060540f, 0.03849633f, 0.06457515f, 0.05155787f, 
    0.06311800f, 0.07278917f, 0.04500774f, -0.01037659f, 0.03347775f, -0.15450865f, -0.05607738f, -0.02604483f, 
    0.25348070f, 0.18922605f, -0.12091044f, 0.00841243f, 0.03566572f, 0.08007374f, 0.01963110f, 0.01380995f, 
    0.07952804f, -0.09141709f, 0.04570908f, 0.06339831f, 0.02437394f, -0.00444402f, 0.06549001f, -0.00134345f, 
    -0.01608041f, -0.02775584f, -0.02368236f, 0.03601240f, 0.10390587f, 0.19232959f, 0.15088178f, -0.26439169f, 
    -0.14346516f, -0.00682823f, 0.10219005f, 0.06211683f, 0.04171970f, -0.07845853f, 0.00834126f, 0.01257891f, 
    -0.05792333f, 0.02252038f, 0.01465436f, -0.00358908f, -0.00667452f, -0.01037770f, -0.08683435f, -0.01471759f, 
    -0.03218523f, -0.14678140f, 0.09632797f, -0.15634008f, 0.04996080f, 0.02651769f, 0.04443668f, -0.03079211f, 
    0.08156762f, 0.02841085f, -0.05740777f, 0.18733335f, 0.03917228f, -0.06498693f, -0.16417564f, -0.11642857f, 
    0.00619002f, -0.00059218f, 0.01490270f, -0.01151437f, -0.08550301f, -0.06277912f, -0.04196928f, 0.06470945f, 
    -0.00027375f, -0.02424104f, 0.02027971f, 0.01027409f, 0.00341287f, 0.02746260f, -0.11918451f, -0.07715365f, 
    -0.18975322f, -0.23363595f, -0.07314128f, -0.03361404f, -0.00039954f, 0.00536011f, -0.01775742f, 0.03729995f, 
    0.16570444f, -0.52227408f, -0.78877062f, 0.14483944f, -0.12327865f, 0.00677358f, 0.03090503f, 0.03805329f, 
    -0.01815886f, 0.06016582f, 0.00404111f, 0.01869139f, -0.21835983f, 0.00583082f, -0.04422064f, -0.04264984f, 
    0.09169342f, -0.01861924f, -0.00656637f, -0.01612342f, -0.41687238f, -0.21571682f, -0.09350147f, -0.11846489f, 
    -0.03998872f, 0.02280620f, 0.07505622f, -0.04410128f, 0.00339986f, -0.01980714f, 0.00048039f, 0.03474046f, 
    0.03494741f, 0.05597658f, 0.04828096f, 0.04786041f, -0.00277207f, 0.02692316f, -0.14731869f, -0.07964049f, 
    0.40014857f, 0.27284753f, -0.18491830f, -0.25071260f, 0.03250870f, -0.07453145f, -0.12758768f, 0.07174802f, 
    0.07693616f, 0.07387435f, 0.04033684f, 0.01492096f, -0.01239355f, -0.12305424f, -0.13949005f, 0.04308531f, 
    -0.08253688f, 0.03781947f, -0.03124860f, 0.15276965f, 0.17850442f, 0.15181580f, -0.05999125f, -0.05079089f, 
    0.06795021f, 0.11142989f, 0.12088643f, 0.11030889f, -0.05314123f, -0.19717072f, -0.04483790f, -0.03784533f, 
    -0.00967941f, -0.00876969f, 0.05515281f, -0.01568588f, 0.02118272f, -0.00806043f, -0.02376348f, 0.00127660f, 
    -0.07541645f, 0.16170557f, 0.03480515f, -0.09287149f, -0.30259719f, -0.12354679f, -0.10201691f, -0.15685302f, 
    -0.04296536f, 0.05138529f, -0.02844244f, -0.02787255f, -0.01771881f, -0.00864851f, 0.00505948f, 0.01750047f, 
    -0.00646074f, 0.06517769f, 0.12121392f, 0.18668720f, -0.48957926f, -0.21872397f, 0.41649750f, -0.06135333f, 
    0.03847487f, -0.18758954f, -0.10633501f, 0.13196965f, 0.07760577f, -0.12144768f, -0.09726164f, -0.11366489f, 
    -0.07504769f, -0.03552974f, -0.13238978f, -0.09566901f, -0.05522570f, 0.02894415f, -0.09329385f, -0.03694559f, 
    0.11148834f, -0.00411172f, -0.65011871f, 0.00091480f, 0.02099299f, -0.11376522f, 0.06414059f, 0.03255624f, 
    -0.11062407f, -0.15537325f, -0.12827070f, -0.08874393f, 0.01140159f, 0.00324574f, 0.04126304f, -0.17211840f, 
    -0.01055888f, -0.16812915f, -0.02295409f, -0.04373732f, -0.13484362f, 0.20953602f, -0.08535690f, -0.16036294f, 
    0.12357683f, -0.05041912f, -0.04930340f, -0.00444951f, 0.06024302f, 0.01461941f, 0.03520895f, -0.01664105f, 
    0.00557879f, -0.01367349f, 0.07885740f, 0.01115745f, 0.02396815f, -0.00766652f, -0.00944050f, 0.02530826f, 
    0.02669483f, -0.06360626f, 0.00733759f, -0.09429149f, 0.00500254f, -0.00076261f, -0.02734630f, -0.03346127f, 
    0.01763546f, 0.00223842f, 0.02894019f, -0.07643179f, 0.01137752f, 0.11024780f, -0.05907303f, -0.15399066f, 
    -0.10472849f, 0.05625939f, -0.13988881f, -0.02036176f, -0.01231424f, 0.00394180f, -0.03506527f, -0.00357379f, 
    0.05568854f, 0.08931557f, 0.07534069f, 0.04836964f, -0.02424800f, -0.03696309f, 0.03005955f, 0.03441986f, 
    0.05169777f, -0.09095190f, -0.05737855f, 0.02417113f, 0.10969609f, 0.08214576f, 0.03175052f, -0.02123930f, 
    -0.10191412f, -0.04401244f, 0.12885723f, -0.03058470f, 0.09049483f, -0.05770426f, 0.14559387f, -0.03509466f, 
    -0.14292040f, -0.06586079f, -0.13922833f, -0.11231885f, 0.09323869f, -0.10968260f, 0.10016224f, -0.09905945f, 
    0.03454495f, -0.02632667f, -0.03509924f, -0.05459706f, 0.39527634f, 0.18854670f, -0.05847606f, -0.18963797f, 
    -0.09877881f, 0.14621085f, 0.10900834f, 0.18945217f, 0.10455663f, 0.09785277f, 0.04001161f, 0.05596421f, 
    -0.03788052f, 0.01341808f, 0.02637677f, -0.02165940f, 0.03869447f, 0.08311468f, -0.03717678f, -0.04521048f, 
    -0.52607197f, -0.34449768f, -0.04175664f, 0.10335110f, 0.00821314f, 0.02708035f, -0.01689429f, -0.06519100f, 
    -0.03501751f, 0.04704091f, -0.02976499f, -0.04207439f, -0.07680797f, -0.15871862f, 0.03230824f, -0.09954873f, 
    -0.00899388f, -0.00958327f, -0.09860637f, -0.10701407f, -0.26995862f, 0.26515928f, 0.35478696f, -0.19611207f, 
    0.08099248f, -0.29598242f, -0.20759965f, -0.18311535f, -0.04212746f, -0.10889775f, 0.01971493f, -0.01347632f, 
    -0.01819794f, 0.00328365f, 0.03876445f, 0.10289922f, 0.08438447f, 0.06276195f, -0.03903607f, 0.03343752f, 
    -0.31449240f, 0.14434759f, -0.08545044f, 0.09798589f, 0.10081056f, -0.06618427f, -0.00203174f, 0.14214034f, 
    -0.07648635f, -0.03319396f, 0.05867425f, -0.02346294f, 0.06115392f, 0.03788904f, 0.04682990f, -0.01946370f, 
    -0.03657769f, 0.01396997f, -0.15670413f, -0.00938909f, -0.21692930f, 0.23219678f, -0.00910586f, 0.10193837f, 
    0.20442185f, -0.13383792f, -0.00735572f, 0.01937356f, -0.24178459f, 0.14519802f, 0.02427295f, -0.05316065f, 
    0.06468190f, 0.01598405f, 0.06126472f, 0.00138579f, 0.03094955f, 0.05607484f, -0.24436432f, 0.01211103f, 
    -0.13357052f, -0.16381294f, -0.11370344f, 0.03026705f, -0.08159187f, 0.09258250f, -0.04506800f, -0.31581977f, 
    -0.14264598f, 0.02945556f, -0.08755530f, 0.05059926f, -0.00979865f, 0.09392823f, 0.06629503f, -0.01906927f, 
    0.06679527f, -0.01187774f, -0.23366138f, 0.00117385f, 0.94848090f, -0.00695115f, 0.07553110f, 0.14964776f, 
    -0.26864761f, 0.00666897f, -0.00347352f, -0.02515880f, 0.03224755f, -0.03292127f, 0.08562507f, -0.16263671f, 
    -0.02073549f, -0.12532085f, -0.07413728f, 0.08977569f, -0.01493055f, -0.12483390f, -0.02179221f, 0.01611894f, 
    -0.21216466f, 0.02366868f, -0.10360650f, 0.07671464f, -0.20091565f, -0.06527986f, 0.03077178f, 0.11907758f, 
    -0.25962102f, 0.03185197f, 0.00845063f, -0.13869850f, 0.01806026f, -0.12537673f, -0.05226547f, 0.01632155f, 
    0.02310735f, 0.03008192f, -0.03536494f, 0.00544764f, 0.02610791f, -0.04719668f, -0.01464690f, -0.01851290f, 
    -0.04511516f, -0.02733298f, 0.09855732f, 0.03166971f, -0.13530320f, 0.09811818f, 0.04481813f, 0.03158212f, 
    0.00772558f, 0.02310874f, -0.03650487f, -0.07082218f, 0.04865056f, 0.05225305f, 0.04165376f, 0.06278294f, 
    -0.13309267f, 0.18236738f, 0.05854990f, -0.07456376f, -0.14875606f, -0.03326474f, -0.06004577f, -0.12393735f, 
    -0.10259549f, -0.02448634f, 0.03683967f, 0.02899868f, -0.01982721f, -0.08416872f, -0.03997887f, 0.08362909f, 
    0.07714336f, -0.08806512f, -0.04714140f, 0.07403813f, 0.25038597f, 0.34608254f, 0.22060890f, 0.35429180f, 
    0.05452741f, 0.07286441f, -0.11501763f, -0.12595625f, -0.00533001f, -0.03717843f, -0.00528568f, 0.02161166f, 
    0.02902872f, -0.06309097f, 0.04252276f, -0.12990290f, -0.06753183f, -0.03468532f, -0.12876646f, 0.14853393f, 
    0.03784106f, 0.20998152f, 0.03035128f, 0.09924813f, 0.09702920f, 0.04829948f, -0.05939225f, 0.02538589f, 
    -0.02313753f, 0.02262434f, -0.03021620f, 0.01100881f, 0.04379899f, 0.00911241f, 0.10766289f, 0.00398598f, 
    0.02123120f, 0.08491942f, -0.24190883f, -0.02568003f, -0.10813675f, -0.01292043f, -0.04419685f, -0.05118246f, 
    0.00600101f, 0.02275969f, 0.02260383f, -0.00677438f, 0.14023097f, 0.05929769f, -0.25862858f, 0.15078747f, 
    -0.02180567f, 0.12643209f, -0.00018401f, -0.07579728f, -0.02209659f, 0.00169560f, 0.02293243f, 0.00289806f, 
    -0.23421483f, 0.22072755f, -0.11127905f, 0.20562024f, 0.25317010f, -0.01420255f, -0.11909746f, 0.10471550f, 
    -0.13452227f, -0.15498036f, 0.04626131f, 0.05048132f, -0.00289984f, -0.03910828f, -0.00940626f, -0.06470658f, 
    0.07902189f, 0.07788687f, -0.37818405f, -0.08548965f, -0.19246860f, -0.02586835f, 0.09895200f, -0.17116766f, 
    0.01916365f, -0.01826333f, -0.04950251f, 0.03168255f, 0.06195157f, -0.01910176f, 0.00618069f, -0.05285322f, 
    0.12242030f, 0.02337984f, 0.01291184f, -0.15612142f, 0.24234977f, 0.17067528f, 0.06728061f, -0.18126810f, 
    0.78813314f, -0.03755251f, -0.08051571f, 0.09180503f, -0.32879519f, 0.06489432f, 0.10520417f, 0.05435904f, 
    -0.10523536f, -0.02257399f, 0.16249946f, -0.07330712f, 0.17794487f, -0.03294709f, -0.03172055f, 0.02076132f, 
    0.09859364f, 0.06723345f, -0.00776303f, 0.08459520f, 0.09223931f, -0.28410915f, -0.09003730f, -0.05538602f, 
    0.07320018f, -0.07934421f, 0.03163857f, 0.05504707f, 0.10123271f, -0.07064471f, 0.12239941f, -0.04346709f, 
    0.11689275f, -0.07062234f, -0.26992777f, 0.06079737f, -0.01589980f, -0.00514872f, 0.00837329f, -0.09002507f, 
    -0.05945588f, -0.05859233f, 0.06667845f, -0.05724686f, -0.02205506f, 0.11409418f, -0.02040721f, -0.01674062f, 
    -0.01032983f, 0.05293174f, -0.03827324f, -0.09220526f, 0.03389806f, 0.17712671f, 0.02196911f, -0.09758568f, 
    0.04212031f, -0.16638128f, 0.02794723f, 0.04173791f, -0.11937704f, 0.42696089f, -0.17267375f, 0.15599377f, 
    0.28291351f, -0.06444467f, 0.14650917f, -0.08474131f, -0.06991467f, 0.07328050f, -0.09278113f, -0.07066467f, 
    -0.06748750f, 0.02868004f, -0.04268305f, -0.14664698f, 0.09100861f, 0.16676474f, 0.00382474f, -0.18680702f, 
    0.62843591f, 0.13033204f, 0.15798070f, 0.08913606f, 0.08425821f, -0.03854069f, -0.01532564f, -0.00350429f, 
    -0.02243342f, 0.03307432f, -0.01119670f, 0.00510929f, -0.01268792f, 0.01640783f, 0.05201295f, 0.00851853f, 
    -0.01491310f, -0.06935073f, 0.11272414f, 0.07902289f, -0.05318385f, -0.24409847f, 0.14572974f, -0.11502246f, 
    -0.03386138f, 0.00260199f, 0.10157693f, -0.23792888f, 0.03280006f, 0.06614787f, 0.07822115f, -0.09487168f, 
    0.03421326f, 0.12270949f, 0.04899407f, 0.00447989f, 0.06915733f, -0.11073019f, 0.16234024f, 0.00624278f, 
    0.05794501f, 0.10454702f, 0.09841939f, 0.21925794f, 0.15123534f, -0.05377720f, -0.04140022f, 0.00230819f, 
    -0.02725958f, -0.02207479f, -0.09627607f, 0.01684743f, -0.01129977f, -0.02877803f, 0.21912940f, -0.02640687f, 
    -0.22203074f, -0.25744629f, 0.02736074f, -0.04310894f, 0.16285494f, -0.13309461f, 0.01010225f, -0.18432790f, 
    0.16683704f, -0.16638355f, 0.09873970f, -0.08983754f, 0.12742124f, 0.04004922f, -0.04421003f, -0.00038150f, 
    0.10159665f, 0.02514358f, 0.04869512f, -0.12739131f, -0.01609902f, 0.10565494f, 0.16766261f, -0.20238495f, 
    -0.10822273f, -0.14134684f, -0.03925570f, -0.02980218f, -0.08148581f, -0.03560222f, 0.13201125f, -0.10107811f, 
    0.04684807f, 0.06548698f, 0.07753021f, 0.08092372f, -0.06958033f, 0.14258872f, 0.10071407f, -0.01739941f, 
    -0.02071693f, -0.04188386f, 0.11157862f, 0.09519567f, 0.12992400f, -0.03979858f, 0.28372389f, 0.08820982f, 
    -0.03026044f, -0.00296794f, 0.00433599f, -0.00616753f, -0.01683608f, 0.00950614f, -0.04655869f, 0.09151661f, 
    -0.10787746f, -0.02496401f, -0.06626827f, 0.08916070f, -0.09606117f, 0.01331868f, 0.07258467f, -0.04256293f, 
    0.09897330f, 0.03128716f, 0.16515741f, 0.10104496f, 0.08344471f, -0.01635931f, -0.03635104f, -0.00569496f, 
    -0.05436994f, -0.01057375f, 0.07230519f, -0.00212166f, -0.00035163f, -0.00435558f, 0.02327018f, -0.15479569f, 
    -0.06148377f, -0.08730099f, -0.01071701f, 0.02374183f, -0.04963581f, -0.07120842f, 0.09313524f, 0.07264075f, 
    0.15720542f, -0.00503375f, -0.03148367f, 0.03885932f, -0.02002630f, -0.04710772f, -0.00292586f, 0.06683608f, 
    -0.01019179f, -0.07296740f, 0.02035280f, 0.17464389f, 0.15672231f, -0.02440495f, 0.00194099f, 0.02902926f, 
    0.01770641f, -0.09739763f, -0.09547197f, -0.07794704f, -0.10109597f, 0.06714546f, -0.02671231f, 0.03243063f, 
    -0.04135880f, -0.16753057f, 0.06992103f, -0.06067245f, -0.04834413f, -0.09217118f, 0.00359401f, 0.01426915f, 
    -0.00513405f, -0.05159365f, -0.00955897f, 0.02120823f, -0.17402476f, -0.20399238f, -0.09828068f, -0.16905428f, 
    -0.27508378f, -0.07525404f, -0.15617724f, -0.00743074f, 0.04491392f, 0.01432191f, 0.00253826f, -0.01973876f, 
    -0.00469262f, 0.01141233f, -0.02099401f, 0.07700111f, -0.08608909f, -0.02947188f, 0.16954552f, 0.05546278f, 
    0.16057549f, 0.06390530f, 0.05073200f, 0.04601070f, 0.05792173f, 0.00104609f, -0.01889912f, -0.02394511f, 
    -0.00267250f, -0.01412404f, -0.00428531f, -0.00793161f, 0.03056609f, -0.00335091f, -0.00346445f, -0.01096762f, 
    0.05425316f, -0.03968189f, 0.01833380f, -0.00108364f, -0.38553709f, 0.12512241f, -0.02704578f, -0.10113627f, 
    -0.00886096f, 0.13897474f, -0.05235735f, -0.03101695f, -0.05785262f, -0.06464721f, 0.04029600f, 0.04181184f, 
    -0.00410634f, -0.04064576f, -0.00244734f, -0.07623397f, -0.24075536f, 0.05012248f, -0.07760867f, -0.01635141f, 
    0.05131746f, 0.01428600f, 0.03842327f, 0.07112686f, 0.09969242f, -0.02220122f, -0.01260875f, 0.02160420f, 
    0.01031939f, 0.03914238f, 0.06844074f, 0.01027776f, 0.02918658f, 0.02599504f, 0.06532875f, -0.03549277f, 
    -0.04449910f, 0.00922716f, 0.06479009f, -0.03803156f, -0.07278997f, -0.07390857f, 0.16071455f, 0.01858516f, 
    -0.18600625f, 0.13658781f, -0.01192215f, -0.02775194f, 0.02148295f, -0.06311580f, 0.01129626f, -0.09146099f, 
    0.01000845f, 0.11605272f, -0.03073854f, 0.13000534f, -0.09849530f, 0.09520379f, 0.10963984f, -0.05042893f, 
    -0.57467884f, -0.21284305f, 0.08752499f, -0.07117535f, 0.05192452f, 0.06967757f, 0.10032087f, -0.05702604f, 
    0.00108215f, -0.03411406f, -0.04981282f, 0.00761670f, -0.02415984f, 0.07398895f, 0.04155695f, 0.05973091f, 
    -0.01202114f, 0.04087529f, 0.03530734f, -0.08112472f, -0.33408368f, -0.00821193f, -0.15892623f, -0.13511524f, 
    -0.50188768f, 0.06709938f, -0.17593898f, -0.24961126f, -0.19317949f, 0.16489179f, -0.00131875f, 0.00565988f, 
    -0.02234193f, 0.03302400f, -0.01764662f, -0.09452713f, -0.00035754f, -0.25932160f, -0.15849306f, -0.09053828f, 
    0.42452362f, 0.15519865f, 0.00029366f, -0.04638961f, 0.04034088f, -0.04884133f, 0.01079752f, 0.01556281f, 
    -0.08316592f, -0.04161225f, -0.08662005f, 0.00900709f, 0.01969949f, -0.02223672f, 0.05681236f, 0.06249072f, 
    -0.00820471f, -0.02315463f, -0.00370850f, 0.02154603f, 0.21485505f, 0.30804664f, 0.17397568f, 0.18722871f, 
    -0.33389872f, 0.02536511f, 0.03953492f, 0.08279160f, -0.06952051f, 0.04202833f, 0.01752933f, -0.05120713f, 
    -0.07933854f, 0.10336919f, -0.12410465f, -0.12253245f, -0.06364936f, 0.07711967f, 0.01220522f, -0.07260467f, 
    -0.22108954f, 0.28245172f, 0.02050737f, -0.01015683f, 0.17913207f, -0.02524704f, -0.08102261f, 0.25822166f, 
    0.11639698f, 0.12155271f, 0.04437113f, 0.05074345f, 0.21130590f, 0.09363766f, -0.10497771f, -0.11827493f, 
    -0.03166657f, 0.10966981f, -0.16255833f, -0.16576712f, 0.00986012f, -0.10484020f, 0.03137703f, 0.03235834f, 
    -0.03532917f, -0.03394412f, -0.03359608f, 0.03282593f, 0.00853222f, -0.01002402f, -0.01809798f, 0.01793937f, 
    -0.07578438f, 0.03148948f, -0.03728854f, -0.01641827f, 0.00158937f, -0.04732466f, 0.05364357f, -0.02884572f, 
    -0.22013222f, 0.07118411f, -0.05898857f, 0.09270143f, -0.03442742f, -0.04573363f, 0.09864832f, 0.06033126f, 
    0.16907296f, -0.07136875f, -0.04244128f, 0.02940374f, 0.04086814f, -0.00709759f, -0.01320656f, -0.02857612f, 
    0.12052196f, 0.02068755f, -0.02424154f, 0.06514565f, 0.08754101f, 0.23545152f, -0.08105617f, -0.22039849f, 
    0.29776061f, -0.00191659f, -0.15531969f, -0.12717500f, 0.17582393f, -0.01133761f, 0.07766253f, -0.03444201f, 
    0.04057416f, -0.10302879f, 0.05788338f, 0.01007188f, 0.04088512f, 0.09642954f, -0.05758386f, -0.15376291f, 
    -0.10800026f, -0.06650870f, -0.07371001f, 0.01697293f, -0.11809974f, 0.08598194f, -0.00023765f, -0.02863282f, 
    0.08462693f, -0.10504640f, 0.04521474f, 0.03596849f, -0.07426410f, 0.08141827f, 0.01719520f, -0.05863806f, 
    0.04806252f, 0.04139583f, 0.14487177f, 0.07757900f, 0.14641422f, 0.02461130f, 0.06595162f, 0.11194322f, 
    0.07107396f, -0.01297215f, 0.02250963f, 0.00520007f, 0.01029769f, -0.03028412f, 0.00709790f, 0.00902394f, 
    0.06701273f, -0.04301814f, -0.05003736f, -0.14762735f, -0.05613812f, 0.01218820f, -0.01691409f, -0.03575193f, 
    -0.06316399f, 0.11831266f, -0.14969145f, 0.14765486f, 0.06386075f, 0.03830581f, -0.01775898f, -0.09403304f, 
    0.15383582f, 0.02711460f, 0.00608562f, -0.01248544f, 0.06456552f, -0.04211037f, 0.01782937f, -0.08522212f, 
    -0.06283866f, -0.07602315f, -0.14670575f, 0.00947433f, -0.12177148f, -0.19885689f, 0.03607755f, -0.05553284f, 
    -0.08845447f, -0.07204421f, 0.12592469f, 0.13636406f, -0.12209547f, 0.13862108f, 0.04056020f, -0.03882061f, 
    0.00311012f, 0.13439335f, 0.00595291f, -0.01613187f, 0.01045217f, -0.02198427f, 0.08028984f, 0.11206592f, 
    0.07347319f, -0.00861409f, -0.08756655f, 0.03530696f, -0.14166838f, -0.02249216f, -0.03724857f, -0.02923208f, 
    0.08089728f, -0.03579295f, 0.01420029f, 0.09855694f, -0.00943671f, 0.04826540f, 0.09980745f, 0.04985439f, 
    -0.05621986f, 0.00748331f, 0.16675474f, 0.05146077f, -0.06638546f, -0.01197616f, -0.41112480f, -0.05520913f, 
    -0.60727543f, 0.03832740f, -0.12734388f, -0.11592057f, -0.21970032f, 0.05916867f, -0.05979418f, 0.01649815f, 
    0.01762307f, 0.01804364f, 0.04099134f, -0.02644438f, -0.02296642f, -0.26066169f, -0.20664726f, -0.16221443f, 
    0.11371923f, -0.13170372f, -0.11622898f, -0.03559322f, -0.09750302f, -0.08494326f, 0.10559998f, 0.05732470f, 
    -0.11497460f, -0.07303565f, 0.01497990f, -0.04608533f, -0.05461542f, 0.02070059f, -0.00552748f, -0.03057419f, 
    0.00254053f, -0.03697574f, 0.02271315f, 0.07489228f, 0.26267830f, 0.12392503f, 0.05068610f, 0.14531620f, 
    0.16840626f, -0.05112271f, -0.05367392f, -0.05922757f, -0.02899967f, -0.05242258f, -0.01946713f, 0.00354468f, 
    0.00080648f, 0.06028613f, -0.02598086f, 0.02294274f, 0.03352180f, 0.03562940f, 0.07643323f, -0.00820679f, 
    -0.08580736f, -0.07580792f, -0.12851636f, -0.01468288f, -0.07279987f, 0.03380582f, 0.02307759f, 0.10147836f, 
    -0.08641782f, -0.02224027f, 0.17844078f, 0.01611162f, 0.00514764f, 0.08006343f, 0.05009075f, 0.01568206f, 
    -0.04141076f, -0.01057469f, 0.01032098f, 0.03611408f, -0.44574657f, 0.03551199f, -0.19275635f, -0.09044489f, 
    0.16774048f, -0.02518140f, 0.03846114f, -0.06423260f, 0.12820435f, -0.08956486f, -0.01588236f, 0.01594207f, 
    0.01068529f, 0.01002434f, -0.00264014f, -0.02296631f, 0.03279129f, -0.01336464f, -0.05197020f, -0.07199777f, 
    -0.11282396f, 0.09914488f, 0.00972588f, 0.08719759f, 0.13489394f, -0.03742544f, -0.05715087f, -0.00046972f, 
    0.03950649f, -0.07819393f, -0.01068430f, 0.20074876f, -0.00050476f, -0.23397370f, 0.06738694f, 0.05922775f, 
    -0.00259789f, -0.01135477f, -0.06372219f, 0.04058805f, 0.28484237f, -0.00053535f, 0.05202204f, 0.07903410f, 
    0.02350400f, 0.00243711f, 0.01922246f, 0.01853063f, -0.00315437f, -0.04821296f, -0.01920121f, 0.13397750f, 
    -0.11130972f, -0.07366481f, -0.07517544f, -0.10107043f, -0.08935062f, -0.04569178f, 0.01409233f, -0.01446617f, 
    1.04369855f, 0.00913682f, -0.00540878f, 0.11546170f, -0.22201027f, -0.00898508f, -0.00975740f, -0.00637541f, 
    0.02459429f, -0.01806590f, 0.15242611f, -0.23237735f, -0.03816518f, -0.17297497f, -0.08927937f, 0.11436044f, 
    -0.02803317f, -0.19942838f, 0.03301562f, 0.02310652f, 0.26858982f, 0.13633454f, 0.03833862f, -0.10035745f, 
    0.08933436f, -0.06788044f, -0.06898674f, -0.09229828f, -0.00220645f, -0.04080787f, 0.01245041f, -0.01377295f, 
    0.01250067f, 0.05744549f, 0.03501500f, 0.09311198f, -0.00253294f, 0.06352252f, 0.19929372f, -0.00881687f, 
    0.06257126f, -0.07895413f, -0.08123796f, -0.01477167f, 0.17918585f, 0.07662582f, -0.07651113f, -0.08369730f, 
    0.07728999f, -0.03418788f, 0.11666458f, -0.00271021f, 0.08197789f, 0.04091955f, 0.16235837f, -0.13899603f, 
    -0.40833947f, -0.13774242f, -0.08131721f, -0.27431840f, -0.18307100f, -0.09259105f, -0.10524455f, -0.07996244f, 
    -0.03669722f, -0.00483443f, 0.09374645f, 0.09862360f, 0.06000394f, -0.12037756f, -0.11919159f, 0.02617754f, 
    0.03466394f, 0.03316851f, -0.04010990f, -0.00620300f, 0.00011265f, 0.00085862f, -0.05527850f, 0.03687203f, 
    0.09513158f, 0.01054728f, -0.28522053f, -0.18243441f, -0.57389736f, 0.01137051f, -0.08771095f, -0.10005006f, 
    -0.09655918f, -0.04214472f, -0.04006678f, -0.01464059f, -0.05596103f, 0.03853072f, -0.00423803f, -0.06560235f, 
    -0.10025119f, -0.16613880f, -0.06216262f, -0.06929974f, -0.32669702f, -0.42111292f, 0.02775573f, 0.01122566f, 
    0.04895305f, 0.03815977f, -0.03289447f, 0.01338031f, 0.01710993f, 0.03113671f, -0.02956336f, 0.07450403f, 
    -0.06970354f, 0.02910861f, 0.01978504f, 0.08946476f, 0.03002053f, 0.03345102f, 0.14718021f, -0.03971104f, 
    0.25917658f, 0.18086824f, -0.33497581f, -0.07295864f, 0.05011991f, 0.16751371f, -0.03328575f, -0.04666377f, 
    0.07637457f, -0.18263660f, 0.02668100f, 0.05237637f, 0.09899026f, -0.05693127f, -0.03927779f, 0.06764500f, 
    0.02877499f, 0.04560656f, 0.08948695f, 0.12110090f, -0.39293003f, -0.13916756f, -0.14117995f, 0.16080758f, 
    0.12338449f, 0.03383265f, -0.05417900f, 0.03293855f, -0.08856647f, -0.02878352f, 0.09629994f, 0.03804929f, 
    0.01647983f, -0.06465253f, 0.09853148f, -0.05540960f, -0.07857503f, 0.03818491f, -0.09167962f, -0.20824398f, 
    -0.16486873f, -0.53393954f, 0.19393061f, -0.10200403f, 0.21871586f, 0.00438956f, 0.06088585f, 0.08304615f, 
    -0.03174666f, -0.03531479f, 0.13406605f, -0.02852705f, -0.08885368f, -0.04810243f, 0.00043113f, 0.30764079f, 
    0.10755243f, -0.15303990f, -0.02036888f, -0.00665006f, -0.13831685f, -0.23275462f, 0.22679365f, 0.04432423f, 
    -0.03380120f, -0.06191256f, 0.03964182f, 0.04729743f, -0.06615083f, -0.09000964f, 0.06458919f, -0.17324264f, 
    0.04438552f, -0.04387618f, -0.02505344f, 0.07127474f, 0.07133340f, -0.00522723f, -0.02278967f, -0.00804820f, 
    -0.10715959f, -0.13587163f, 0.09738742f, 0.06731223f, -0.04006510f, 0.01822053f, -0.09488211f, 0.20051242f, 
    0.01416284f, -0.09486067f, -0.08619460f, 0.01939811f, -0.01638879f, 0.15599667f, -0.16307405f, 0.10733371f, 
    0.20967980f, -0.03542814f, -0.07303959f, 0.04035278f, 0.32855305f, 0.17287233f, 0.34980240f, 0.10745873f, 
    0.08318122f, 0.01157905f, -0.17345200f, -0.12520589f, 0.15241665f, -0.00708270f, 0.08150072f, -0.00130206f, 
    -0.00673198f, -0.16840100f, -0.03640706f, 0.15011154f, -0.10091000f, -0.20209131f, 0.08778585f, -0.05771753f, 
    0.05439671f, -0.17084904f, 0.08619530f, 0.03319154f, 0.06970847f, -0.04008650f, 0.04341674f, 0.02043242f, 
    0.03576049f, -0.05375627f, -0.01986266f, 0.05409284f, -0.00423147f, 0.01743371f, -0.04088004f, 0.03128896f, 
    0.16136043f, -0.24391919f, -0.02175580f, 0.08419663f, -0.20613290f, -0.33931303f, -0.19555838f, -0.41748115f, 
    0.02868947f, 0.13614337f, -0.04080302f, -0.15440600f, 0.06954627f, -0.19307767f, -0.02025073f, -0.00471283f, 
    0.00305406f, 0.00016615f, 0.02773520f, 0.03385454f, 0.04055544f, -0.02219049f, -0.02123836f, -0.19801967f, 
    -0.30161023f, -0.20465772f, -0.38996342f, -0.11336178f, -0.16766144f, 0.11827598f, 0.06540354f, -0.00343932f, 
    -0.04540495f, -0.07642553f, -0.00960200f, 0.04064996f, 0.08303569f, 0.04935543f, 0.01842105f, 0.02435313f, 
    0.02239585f, -0.03662676f, 0.02207532f, -0.00552302f, -0.16552344f, 0.15801442f, -0.24028268f, 0.17504464f, 
    -0.39720812f, 0.12569195f, 0.14364377f, 0.01136653f, -0.03838524f, 0.05729309f, 0.00237129f, 0.06625056f, 
    0.05934512f, -0.01184945f, -0.00671331f, 0.01827372f, 0.06074594f, -0.07904633f, 0.01518770f, 0.02041104f, 
    0.16157377f, -0.59948575f, -0.00338297f, -0.19993529f, -0.04872069f, 0.16646855f, -0.03983367f, -0.10420472f, 
    -0.01988619f, 0.01464509f, -0.00873947f, 0.02124726f, -0.03993173f, -0.03650352f, -0.02991948f, 0.02584426f, 
    0.01625153f, -0.03755484f, 0.12631337f, 0.13963629f, -0.26234666f, 0.16143452f, 0.47229603f, 0.01153802f, 
    -0.04150092f, 0.02743317f, -0.06080262f, -0.00737614f, -0.05902240f, 0.13042292f, -0.01444094f, -0.02711129f, 
    -0.00612060f, -0.04564290f, -0.02629958f, 0.00415551f, 0.05983103f, -0.03619515f, 0.04569782f, -0.10341042f, 
    0.07762890f, 0.16152462f, 0.37863064f, 0.06007052f, 0.36931115f, -0.02537928f, 0.03593833f, -0.01290939f, 
    0.07198038f, 0.04349429f, 0.00372725f, 0.07250449f, 0.08304230f, -0.05391676f, 0.11626022f, 0.04173290f, 
    0.01388188f, -0.02694327f, 0.03000052f, -0.01379774f, 0.01090425f, 0.07526554f, 0.02163154f, 0.03277553f, 
    0.09131314f, -0.04784182f, 0.02174144f, 0.02943231f, -0.00204182f, -0.11266965f, 0.05755392f, 0.11278239f, 
    -0.04734401f, 0.02903993f, 0.04925751f, 0.02250833f, -0.04445900f, 0.01604692f, -0.00413179f, -0.00354799f, 
    -0.14973050f, 0.13923430f, 0.33043230f, 0.33793962f, 0.17007507f, 0.05849863f, -0.09854548f, 0.08222764f, 
    0.04979350f, -0.00439972f, 0.01441640f, 0.00206302f, 0.01828773f, 0.03575756f, 0.06259251f, 0.01966606f, 
    0.02322810f, -0.00778169f, -0.03487888f, 0.00609344f, -0.65821117f, -0.88763225f, -0.28304040f, 0.03471141f, 
    -0.68754220f, -0.11197903f, -0.08134042f, -0.01279579f, 0.08052588f, -0.14647895f, -0.02147727f, -0.00092795f, 
    -0.01059884f, 0.02846637f, -0.00464679f, -0.08248004f, 0.00848557f, -0.01643348f, 0.02560633f, -0.00895528f, 
    -0.31942248f, -0.29576954f, -0.28981072f, 0.01694682f, -0.40590084f, 0.07766876f, 0.03189790f, 0.04859681f, 
    0.06382460f, -0.02486029f, -0.01824910f, -0.01865071f, 0.02099908f, 0.03018229f, -0.02252191f, -0.05476764f, 
    -0.01823043f, 0.07062241f, 0.01973673f, 0.09240869f, 0.04090665f, 0.02387259f, 0.00753157f, 0.00209398f, 
    0.01829915f, 0.03582834f, -0.06913868f, -0.00063909f, 0.01745683f, 0.06176886f, -0.05770726f, -0.11740648f, 
    -0.05752304f, 0.00716720f, -0.06668043f, 0.01675895f, -0.03932360f, -0.04846605f, 0.05994141f, -0.05240992f, 
    -0.18878305f, -0.50861162f, -0.65573704f, 0.03994415f, -0.23146990f, -0.11627816f, -0.03465613f, -0.03195965f, 
    0.00040931f, 0.14045057f, -0.01218074f, -0.01135895f, -0.00377811f, -0.04198361f, -0.04540456f, -0.04588869f, 
    0.01494747f, 0.04007318f, -0.18572249f, -0.01628523f, 0.05248095f, -0.01278218f, -0.45955548f, -0.18671796f, 
    0.03172662f, 0.02561362f, 0.01044771f, -0.05391642f, 0.00549787f, 0.01525363f, 0.02378776f, -0.07015801f, 
    -0.08026115f, 0.07035689f, 0.01225016f, -0.01823846f, -0.01844046f, 0.09019069f, 0.10196409f, -0.00155975f, 
    -0.12934130f, 0.24506176f, 0.17651021f, 0.05525637f, -0.13341989f, -0.04493427f, -0.02354335f, -0.00181393f, 
    -0.10641979f, 0.02917213f, -0.01161297f, 0.03330777f, 0.11713488f, -0.03614248f, -0.02691467f, -0.01955898f, 
    -0.02759833f, 0.03740960f, 0.10321341f, -0.08644193f, 0.46883389f, 0.10181224f, 0.48228702f, 0.14628462f, 
    0.32899821f, -0.03845220f, 0.05870086f, -0.08713254f, 0.05555516f, -0.00856163f, 0.03561881f, 0.04111712f, 
    0.09531011f, -0.15642245f, 0.03541521f, 0.01281085f, 0.05341408f, -0.01769947f, -0.07398311f, 0.00006018f, 
    -0.04388710f, -0.05141273f, 0.04370789f, -0.01052972f, 0.11203274f, -0.03647738f, -0.12660350f, -0.16585891f, 
    -0.04438701f, 0.00909110f, 0.01410878f, -0.02941757f, -0.00727483f, 0.02306884f, -0.03696966f, -0.00941870f, 
    -0.11967592f, -0.10353980f, -0.06032254f, -0.04035205f, -0.19736676f, 0.25157347f, -0.36439052f, 0.23210472f, 
    -0.03798307f, -0.00363764f, -0.05360031f, -0.09441900f, -0.08595381f, 0.07863051f, 0.04967724f, 0.07478578f, 
    0.06067055f, 0.10901779f, -0.08038276f, 0.14679176f, 0.06640980f, 0.02118361f, 0.04495228f, 0.03415452f, 
    -0.27493942f, -0.35335222f, 0.02967597f, -0.04576456f, -0.20902966f, 0.00609115f, 0.00122048f, 0.00601601f, 
    0.01418496f, 0.07791384f, 0.03711846f, 0.01486032f, -0.03258163f, 0.05694053f, 0.00707975f, 0.01835469f, 
    -0.01833784f, 0.10703331f, 0.00641875f, -0.15807508f, 0.02690019f, -0.04553645f, 0.03915524f, -0.04761072f, 
    0.10080847f, -0.00373948f, -0.06483989f, -0.30228913f, -0.14036280f, 0.02139395f, 0.00943739f, -0.04719540f, 
    -0.01106125f, 0.05881583f, -0.10896849f, 0.04428700f, -0.09312149f, 0.00899804f, 0.00038573f, -0.03618040f, 
    0.17835285f, -0.39585370f, -0.39858478f, -0.48642501f, 0.01668347f, 0.03202730f, -0.00757817f, -0.00037731f, 
    0.03373639f, 0.02152970f, 0.03183567f, -0.05924135f, 0.00597910f, -0.00130263f, -0.07497416f, 0.11771626f, 
    0.02560544f, -0.08758697f, 0.02079608f, 0.01344162f, 0.28666028f, -0.05885193f, -0.11790893f, -0.15065946f, 
    0.05784421f, 0.03819698f, -0.00254279f, -0.05278620f, 0.00391649f, 0.16853924f, -0.15579553f, -0.02999618f, 
    0.10566916f, -0.05102867f, -0.10520290f, 0.14310543f, -0.05976015f, -0.06281088f, 0.05764269f, 0.04136969f, 
    0.06847277f, -0.04798399f, -0.07363439f, -0.00528226f, 0.02260718f, 0.01221642f, 0.01041070f, -0.18649685f, 
    -0.08012109f, -0.12702481f, 0.00682302f, -0.13426104f, -0.02828783f, 0.01512518f, -0.01868059f, 0.05315043f, 
    -0.01715257f, -0.06077840f, -0.00300367f, 0.00639614f, 0.04060286f, -0.10541344f, 0.11210852f, -0.08553219f, 
    0.03551405f, -0.00304455f, -0.06130807f, 0.00829542f, -0.01133931f, 0.07435405f, 0.07506210f, -0.09226193f, 
    -0.10922752f, 0.07035191f, 0.07912003f, 0.03866757f, 0.10097737f, -0.08050772f, 0.13843460f, -0.05415192f, 
    -0.01332123f, -0.06032900f, -0.00457010f, -0.01855516f, 0.04234446f, -0.04036397f, -0.02062151f, 0.03744615f, 
    0.02904420f, 0.04074957f, -0.00542961f, -0.03330185f, -0.11105911f, 0.07786204f, 0.04056564f, 0.01197125f, 
    -0.00897712f, 0.02288554f, 0.01188899f, -0.01599023f, 0.00730941f, 0.07946895f, -0.12930290f, -0.02018374f, 
    -0.01739153f, -0.00368406f, 0.03999916f, 0.00397230f, 0.03182515f, -0.04315926f, 0.01288683f, 0.02486677f, 
    0.03022380f, -0.03121918f, -0.02606763f, -0.02296696f, 0.11820723f, 0.09011085f, 0.03504393f, -0.03229753f, 
    -0.18985912f, -0.12440433f, 0.48361325f, 0.25108200f, 0.22360946f, -0.02606126f, -0.01240735f, 0.07949736f, 
    0.11704963f, -0.11496493f, 0.09176113f, 0.05370775f, 0.05400159f, -0.05416369f, 0.03497438f, -0.00854529f, 
    0.01137722f, 0.05333596f, 0.00921327f, -0.04207685f, 0.05589876f, -0.29416952f, 0.12668061f, -0.20203109f, 
    0.00268537f, 0.03600238f, -0.07898007f, -0.23970443f, -0.01454523f, -0.12560616f, -0.02317810f, -0.03838978f, 
    0.02817464f, 0.01856565f, -0.01359759f, 0.10295022f, -0.04055965f, -0.08178911f, 0.10129356f, 0.00344306f, 
    -0.12294093f, 0.01390633f, 0.14467654f, -0.09545517f, 0.09136087f, -0.02399912f, 0.00476546f, -0.04092598f, 
    0.02861683f, 0.05188282f, -0.00446473f, 0.00407634f, 0.04266951f, 0.01488988f, 0.00917670f, -0.11553669f, 
    -0.10747114f, -0.08296145f, 0.00089214f, -0.05507993f, -0.04885482f, -0.09569585f, -0.51363546f, 0.23278618f, 
    0.04887936f, -0.12170152f, -0.07638884f, -0.03645204f, -0.11885404f, 0.06858807f, 0.01180410f, -0.02481287f, 
    -0.00757914f, -0.02743104f, -0.07367331f, -0.06273910f, 0.04799419f, -0.04481253f, 0.00750655f, 0.08582099f, 
    0.11936618f, 0.00116566f, -0.02255983f, -0.02155337f, 0.06266014f, -0.00222001f, -0.02074113f, 0.01179401f, 
    0.01830014f, 0.07443561f, -0.09325579f, -0.00235137f, -0.00341613f, -0.01031824f, -0.01259075f, 0.04295273f, 
    -0.02236320f, 0.00444547f, -0.01023612f, -0.02184825f, -0.15234780f, -0.02631336f, 0.14906758f, -0.02219182f, 
    -0.10209176f, -0.05433233f, -0.09794664f, -0.14814962f, -0.05173851f, 0.02469355f, 0.02141384f, 0.02909836f, 
    -0.01639085f, 0.07802044f, 0.03177539f, 0.05375770f, 0.01015154f, -0.13048224f, -0.01925365f, -0.01571089f, 
    0.24219267f, 0.20006236f, -0.33602864f, 0.02768626f, 0.01239737f, 0.14004526f, 0.05899621f, 0.03419276f, 
    0.01644397f, -0.00869505f, -0.04101549f, -0.04810195f, 0.02266700f, 0.04479249f, -0.03107128f, 0.01596154f, 
    0.01757229f, -0.01008087f, 0.05300165f, 0.18393286f, 0.33612242f, -0.96226388f, 0.25349194f, -0.35607570f, 
    -0.19897647f, 0.11940856f, -0.01704973f, -0.09305140f, 0.01374878f, -0.17867577f, -0.04050603f, -0.04666653f, 
    0.01107205f, -0.07110441f, 0.01337498f, 0.06511050f, -0.01726309f, -0.14062537f, 0.19508845f, 0.02293327f, 
    -0.23909850f, 0.01477919f, -0.09000183f, -0.10990307f, 0.02989187f, 0.02456076f, -0.01619462f, 0.02370526f, 
    -0.02491154f, 0.00385164f, -0.02893932f, 0.00009096f, 0.00821708f, 0.03806345f, 0.02213074f, 0.00534894f, 
    -0.00415017f, -0.12179770f, 0.07225318f, -0.01284592f, -0.73341489f, 0.45098051f, -0.01869811f, 0.21089011f, 
    -0.22532193f, 0.03675229f, 0.00167731f, -0.01983095f, -0.07726005f, 0.18288228f, -0.00740123f, 0.04604121f, 
    -0.06223682f, 0.11633162f, -0.10139444f, 0.02732810f, -0.07771691f, 0.03755057f, 0.06782723f, -0.10002550f, 
    0.59513056f, 0.19913055f, -0.03007449f, 0.03187492f, 0.14448158f, -0.04781112f, -0.00759394f, -0.12462477f, 
    -0.03964674f, 0.33582467f, -0.14828417f, -0.09682691f, 0.08809343f, -0.06776073f, 0.00156286f, 0.03908724f, 
    0.02539984f, -0.03956683f, 0.01635528f, -0.01415735f, 0.10394017f, -0.08737278f, 0.09946901f, 0.04860760f, 
    0.16300635f, -0.00463776f, 0.03115395f, 0.07067335f, 0.09834137f, 0.00101993f, -0.07888123f, 0.03043175f, 
    -0.01270653f, 0.02367104f, -0.01368303f, 0.04415203f, -0.04037084f, -0.02074860f, 0.02072997f, 0.03064666f, 
    0.11438967f, -0.14297532f, 0.04519764f, 0.35113412f, -0.02345287f, 0.06164759f, -0.11766475f, -0.04784142f, 
    0.13473831f, -0.03580923f, 0.00947853f, 0.05227364f, -0.02854565f, 0.04037975f, -0.03194020f, 0.02140902f, 
    0.01734759f, 0.06598990f, 0.09273648f, -0.02977756f, -0.28552687f, -0.17288348f, 0.07626559f, 0.13348025f, 
    0.02360865f, -0.01171692f, 0.08891472f, -0.06976229f, 0.19448365f, -0.03155404f, -0.03090394f, 0.00479285f, 
    -0.00145846f, 0.07129197f, -0.10920139f, -0.10506785f, 0.04664567f, 0.03994425f, -0.26139131f, -0.08073117f, 
    0.04575485f, -0.18214901f, -0.06974625f, -0.11039741f, -0.02565566f, 0.05906583f, -0.14983650f, -0.13811332f, 
    0.12988780f, -0.31909797f, 0.06682793f, 0.08536807f, -0.03452199f, 0.01669050f, -0.00138836f, 0.01781275f, 
    -0.00449832f, -0.00754514f, 0.16146886f, -0.10009240f, -0.01782005f, -0.09157469f, -0.03960834f, -0.04857163f, 
    0.05684425f, 0.00797656f, -0.02842660f, 0.00759448f, 0.03528270f, 0.02448667f, 0.11928157f, 0.07426605f, 
    0.02062051f, 0.00942392f, 0.02715047f, 0.04982338f, 0.02583591f, 0.03299391f, 0.05991047f, -0.02496406f, 
    -0.14420654f, -0.09853952f, -0.18515648f, 0.06990875f, -0.20418356f, 0.02857451f, 0.00321371f, -0.04878689f, 
    0.04972703f, 0.01188310f, -0.00470919f, -0.01216670f, -0.04216988f, 0.00069528f, 0.01267151f, -0.06127393f, 
    0.03103727f, 0.11085531f, 0.05960104f, 0.03472233f, -0.14295222f, 0.08467589f, -0.06070286f, 0.01487615f, 
    0.11698876f, -0.15462603f, 0.10106941f, -0.01730035f, -0.29925835f, -0.17306808f, 0.05908731f, 0.07856843f, 
    0.01883489f, 0.03297150f, 0.01257042f, 0.00180216f, -0.06408358f, -0.04325493f, -0.07189392f, -0.05259905f, 
    -0.10320324f, 0.02004016f, 0.03852134f, -0.11598223f, 0.00637297f, -0.03827186f, -0.08322030f, -0.17111994f, 
    -0.02477204f, 0.03229936f, 0.00596772f, -0.07198440f, -0.01177062f, -0.02086476f, -0.03265337f, 0.05593319f, 
    -0.00954126f, -0.16777079f, 0.01305781f, 0.03684396f, -0.85117882f, -0.50912112f, 0.26163909f, -0.13624258f, 
    -0.36686504f, 0.05983711f, -0.04467320f, -0.11609917f, -0.03657010f, -0.12256970f, -0.00185572f, 0.02332927f, 
    -0.02443147f, -0.00513316f, -0.02499920f, -0.10740961f, -0.01205723f, 0.06828569f, -0.01964803f, 0.10025867f, 
    0.08538003f, 0.16510095f, 0.34870273f, 0.11099853f, 0.18176623f, -0.03058822f, 0.00602939f, 0.08667470f, 
    0.06696413f, -0.03310968f, 0.04395318f, 0.08383208f, 0.01132375f, -0.02276077f, 0.10354462f, 0.02903536f, 
    -0.01474554f, -0.03629840f, 0.04383254f, -0.02777860f, -0.43305844f, -0.11561988f, 0.00061453f, -0.35618272f, 
    -0.15032059f, -0.06088949f, -0.01594203f, -0.03544626f, -0.00162224f, 0.06017575f, -0.00614863f, -0.01283822f, 
    0.03439378f, 0.03599093f, -0.01501101f, -0.08688922f, -0.16866218f, 0.05433494f, 0.02488024f, -0.04664274f, 
    -0.12630892f, 0.07868239f, -0.03275829f, 0.00974764f, 0.02629531f, 0.03847497f, -0.07474709f, -0.25439271f, 
    0.02666449f, -0.31750152f, 0.04443910f, 0.01090268f, 0.03396753f, 0.00100656f, -0.01655355f, 0.01100656f, 
    -0.03439310f, -0.03454122f, -0.04622263f, -0.03838525f, 0.23569329f, 0.05928858f, -0.48446938f, 0.09100576f, 
    -0.12391977f, 0.13136950f, 0.13174674f, 0.18136781f, 0.04167210f, 0.06103984f, -0.05871855f, 0.01533971f, 
    -0.08676200f, 0.05145268f, -0.02241920f, 0.00497178f, 0.00808712f, 0.02921023f, -0.19167061f, 0.02576685f, 
    -0.23361479f, -0.04832704f, -0.22280557f, -0.00819820f, 0.05514541f, 0.00437417f, -0.03986562f, 0.04214862f, 
    0.03736879f, -0.04415674f, -0.04689378f, 0.02649307f, 0.03995420f, -0.10389104f, 0.00058960f, -0.13875712f, 
    0.00300771f, 0.00902258f, -0.03638676f, 0.03352166f, -0.01982776f, -0.00524012f, 0.04604978f, -0.03305573f, 
    -0.00834729f, -0.03043666f, -0.04479113f, 0.00375624f, 0.02159284f, 0.03004129f, -0.05033444f, -0.04469290f, 
    -0.09184001f, 0.10621413f, 0.16260776f, 0.08226733f, -0.03082130f, -0.01946315f, 0.06350012f, -0.02323085f, 
    -0.43712533f, 0.17881213f, 0.53246534f, -0.16832319f, -0.01092866f, 0.02618695f, -0.06606420f, -0.04804038f, 
    -0.02432268f, 0.07518158f, 0.02018442f, 0.03306514f, -0.05616042f, -0.07731298f, -0.01188184f, 0.02058219f, 
    0.03852449f, 0.13361171f, 0.09708448f, -0.13288076f, -0.46185544f, 0.00992885f, 0.08224072f, -0.44221491f, 
    -0.13516498f, 0.00548206f, -0.02103596f, -0.02485721f, 0.05002477f, 0.06178307f, 0.05571348f, 0.03334345f, 
    0.01044790f, 0.08026797f, -0.01572090f, -0.12839371f, -0.07571504f, -0.09306765f, -0.08085439f, -0.03623108f, 
    -0.08869370f, -0.01437021f, 0.06151579f, 0.30342335f, 0.07378379f, 0.06053511f, -0.06237482f, -0.08935718f, 
    0.08211748f, -0.04804394f, -0.00936405f, 0.01490696f, -0.04506271f, -0.17498837f, 0.07060675f, 0.10456415f, 
    0.13968527f, 0.00088986f, -0.02850773f, 0.03605276f, 0.05978144f, 0.04807994f, 0.11182770f, 0.20184228f, 
    0.04650639f, 0.05636419f, -0.06068778f, 0.07516059f, 0.08575873f, -0.23103014f, 0.02071055f, 0.02402930f, 
    0.01805008f, 0.03706463f, 0.02610505f, 0.02030915f, -0.05400016f, 0.00186181f, 0.03538067f, 0.00374127f, 
    -0.11486241f, -0.23570514f, 0.36466357f, -0.01270587f, -0.33060876f, -0.10792524f, -0.10164917f, -0.07081335f, 
    -0.02739590f, 0.06703541f, 0.02766993f, -0.03497670f, 0.02350875f, 0.01599914f, 0.01956239f, 0.09127454f, 
    0.04528338f, 0.03490413f, 0.05976701f, 0.09793835f, 0.54475325f, 0.02096312f, -0.23206715f, -0.08470355f, 
    0.21634424f, -0.12915923f, 0.10666689f, -0.04970898f, -0.05815803f, 0.02541739f, -0.07258922f, -0.04066770f, 
    -0.04208840f, 0.05906853f, -0.13703182f, 0.09530003f, 0.02413982f, 0.00913623f, -0.02286105f, 0.09510963f, 
    -0.02490414f, 0.06701300f, -0.00256648f, 0.04177426f, -0.11785265f, 0.10649190f, -0.12874676f, -0.01963311f, 
    0.11733226f, -0.10934501f, -0.05673737f, 0.15402780f, 0.05008037f, -0.00605936f, -0.02992661f, -0.01497143f, 
    -0.06188170f, -0.12198777f, 0.15152813f, -0.04191674f, 0.02460728f, 0.12111672f, -0.08321305f, 0.12618797f, 
    0.17940174f, 0.04932264f, 0.03413959f, -0.04818268f, -0.00476015f, -0.02354998f, 0.01210784f, 0.05985956f, 
    0.01401098f, -0.06508993f, 0.01421679f, 0.09451037f, 0.15776871f, 0.02371100f, 0.04596762f, 0.07672135f, 
    0.06842812f, -0.19993584f, -0.09009355f, -0.18468022f, 0.04235701f, 0.07496887f, -0.00328536f, -0.00875089f, 
    -0.00795030f, -0.01300075f, -0.02579143f, -0.07213566f, 0.04153444f, -0.01389102f, 0.08367918f, 0.12736394f, 
    0.02232591f, -0.05719014f, 0.12675314f, -0.09715676f, 0.07294975f, -0.08365481f, 0.12826458f, 0.17017776f, 
    0.10475068f, -0.06337974f, 0.04143392f, 0.10019087f, -0.07086618f, -0.20607515f, 0.07018812f, -0.03753392f, 
    0.09720533f, -0.06350785f, 0.01987132f, -0.04177986f, 0.01734745f, 0.07979733f, -0.00158749f, -0.03719170f, 
    0.04957927f, 0.18816979f, -0.16242680f, 0.10369176f, 0.00319606f, 0.01892016f, 0.00597761f, 0.05849931f, 
    0.07518037f, -0.19256276f, 0.04897879f, 0.03133159f, -0.01189786f, 0.06474063f, 0.06012979f, 0.04613869f, 
    -0.08753213f, 0.02085460f, 0.19527532f, -0.09465534f, -0.37152484f, -0.43685329f, 0.68595183f, 0.42314926f, 
    0.29120556f, -0.22510755f, -0.16296929f, -0.24232920f, 0.12658423f, -0.13809276f, 0.00196747f, 0.00853929f, 
    -0.01000075f, -0.14937969f, 0.01077436f, 0.03787993f, 0.05256417f, -0.00324511f, -0.08841626f, -0.04569961f, 
    0.27392554f, -0.15767129f, -0.03631085f, -0.21294016f, -0.01666882f, 0.04723560f, -0.05941346f, -0.01492482f, 
    -0.02720829f, 0.02240823f, -0.05362369f, -0.10055809f, 0.05652894f, -0.09342202f, 0.02379579f, -0.00127028f, 
    0.02214719f, -0.10668846f, 0.13687518f, -0.04256032f, -0.08197099f, 0.06858626f, 0.03806616f, 0.07588929f, 
    -0.02220803f, -0.05059311f, 0.03972816f, -0.01874836f, -0.02213575f, 0.07698326f, 0.04161783f, 0.00746208f, 
    0.00952283f, 0.02454324f, -0.02746338f, -0.05703862f, 0.04981948f, 0.08310116f, 0.01140883f, 0.01475799f, 
    0.05498431f, -0.11514027f, -0.11740927f, -0.00215905f, 0.09890583f, 0.03655019f, 0.12018470f, -0.03807737f, 
    0.01710661f, 0.09131563f, 0.03173892f, -0.04579532f, 0.00532843f, -0.02440728f, -0.02228187f, 0.07074876f, 
    -0.00947853f, 0.07204194f, -0.08679628f, 0.04013696f, -0.18546835f, 0.05299618f, -0.10310665f, 0.17510599f, 
    0.13297085f, -0.06651520f, -0.04031595f, 0.00563478f, -0.05956147f, 0.03939950f, -0.06972676f, 0.03863071f, 
    0.02067160f, -0.01153697f, -0.03098536f, -0.07140273f, -0.03786744f, -0.00641583f, -0.07874019f, -0.04275165f, 
    0.11010224f, 0.03026998f, 0.02413742f, -0.15503539f, 0.26018798f, -0.05247054f, 0.14182210f, 0.00343450f, 
    -0.08574028f, 0.02840797f, -0.05595010f, 0.01099827f, -0.06722864f, 0.03002403f, 0.00160180f, -0.05725362f, 
    -0.12145526f, -0.04615776f, 0.00933956f, 0.02298071f, 0.00533056f, 0.39820495f, -0.05716499f, 0.12030705f, 
    0.04620769f, 0.04206369f, -0.06303677f, 0.06527404f, 0.08167151f, 0.01450343f, -0.05434960f, -0.04180611f, 
    -0.00537677f, -0.00925747f, 0.01270745f, -0.04901550f, -0.05704900f, -0.00001744f, 0.01793646f, -0.02298244f, 
    -0.22709794f, 0.26614347f, 0.00809149f, -0.01649438f, 0.23556997f, 0.07708270f, -0.03525233f, -0.10491607f, 
    -0.11978075f, -0.01328964f, -0.12991792f, 0.00466571f, 0.06415947f, 0.00414223f, 0.05745559f, 0.01389806f, 
    -0.06735076f, 0.03211955f, 0.01935350f, 0.04688229f, -0.17095128f, 0.01240036f, -0.15551610f, -0.03262509f, 
    0.12557308f, 0.00591984f, -0.07120956f, 0.03341612f, 0.01001389f, 0.00293175f, -0.00700654f, 0.03697541f, 
    -0.05111641f, -0.03006387f, -0.00643731f, 0.12448852f, -0.09922216f, -0.02228232f, -0.00766975f, -0.03538744f, 
    0.14480038f, -0.16222790f, -0.17025693f, -0.01981577f, 0.20973924f, 0.09283820f, -0.00749225f, -0.11335429f, 
    -0.01091533f, -0.10060943f, -0.00274168f, 0.06685179f, 0.08161011f, 0.14678049f, 0.05419234f, -0.05644891f, 
    0.12541352f, 0.16252246f, 0.04098113f, 0.02109094f, 0.08434302f, -0.12904969f, -0.27002192f, 0.06992267f, 
    0.21780944f, 0.03376122f, 0.03377080f, -0.03430683f, 0.01196354f, 0.10557072f, -0.03758595f, 0.08293241f, 
    -0.04605478f, -0.04139391f, -0.00897136f, 0.05429419f, 0.05846003f, 0.01825427f, 0.00721172f, 0.08843423f, 
    0.00141100f, -0.09262348f, -0.16495730f, 0.07129485f, 0.18661216f, -0.02536500f, 0.02966029f, -0.04560142f, 
    0.04213675f, 0.02471989f, 0.03079227f, -0.00151640f, -0.01155081f, -0.09731934f, 0.00789015f, -0.03107014f, 
    -0.03165776f, -0.00343251f, -0.05163995f, -0.01156255f, 0.08099628f, 0.02076635f, 0.02900200f, -0.23647779f, 
    0.30343443f, 0.05671943f, 0.13597503f, 0.05482370f, 0.08595855f, -0.01226115f, 0.10756563f, -0.00652600f, 
    -0.19320041f, 0.08144993f, -0.01631996f, 0.15427208f, 0.08015832f, 0.11338890f, 0.11125597f, -0.05733396f, 
    0.11507177f, -0.00439005f, -0.07721742f, -0.11977341f, 0.18428569f, 0.04304320f, 0.05483362f, -0.13877039f, 
    -0.00045908f, 0.02379035f, -0.13189831f, 0.08990490f, -0.08258643f, -0.07375438f, -0.06466202f, 0.01525779f, 
    -0.04077663f, 0.03404076f, -0.01951027f, -0.00905737f, 0.32047632f, 0.34839693f, -0.06392263f, -0.37943277f, 
    -0.51298374f, 0.14883198f, 0.08163819f, 0.10384605f, 0.14727378f, 0.13554281f, 0.16635650f, 0.04121657f, 
    -0.04098098f, 0.03402725f, -0.07566159f, 0.03526528f, -0.05236363f, 0.21045995f, -0.15298198f, -0.13472484f, 
    -0.40367278f, 0.17165534f, -0.09017289f, 0.10758016f, 0.27927649f, 0.02496976f, -0.11355722f, -0.06887367f, 
    -0.20964620f, 0.07245462f, 0.03084271f, 0.03984505f, -0.03252300f, 0.01522372f, -0.01749863f, 0.12185123f, 
    -0.02693988f, 0.06101292f, -0.00249038f, -0.10921115f, -0.57239228f, 0.61408919f, 0.17431660f, -0.28597727f, 
    0.17842458f, 0.11174036f, 0.08821169f, -0.15548025f, -0.09031986f, -0.04530716f, -0.11906235f, -0.04034811f, 
    -0.04936225f, -0.06337962f, 0.03701540f, 0.01527232f, 0.12347230f, -0.06214226f, 0.05705020f, -0.07986110f, 
    -0.32208839f, 0.12522244f, 0.60486889f, -0.18062294f, 0.44633210f, -0.02780688f, 0.04010951f, -0.13613071f, 
    -0.07589009f, -0.00294704f, 0.18468340f, 0.02931088f, -0.06658401f, 0.00993887f, 0.17341994f, 0.11353265f, 
    -0.07699047f, 0.08764154f, -0.09802974f, -0.05139781f, -1.49022126f, 0.73239917f, -0.02186092f, 0.00445241f, 
    -0.35808668f, 0.10498419f, 0.04024002f, -0.17063786f, -0.10698368f, -0.18501385f, -0.04118397f, 0.15304421f, 
    -0.04444110f, -0.07206903f, -0.18597203f, 0.08337568f, 0.15861468f, 0.17099841f, -0.05183867f, -0.11624775f, 
    -0.15054740f, -0.23064470f, 0.50048035f, 0.01011935f, 0.12611371f, -0.15474485f, -0.06500667f, -0.00303988f, 
    0.15853453f, -0.12098813f, 0.01695110f, 0.01414636f, 0.10376953f, 0.04578342f, 0.02198643f, -0.12502275f, 
    -0.06901273f, -0.08279797f, 0.05496844f, -0.01299804f, 0.24454094f, 0.16123711f, 0.24223146f, -0.45086649f, 
    0.20300731f, -0.02221704f, -0.04194313f, -0.05574322f, -0.09007797f, -0.03360463f, -0.07940461f, -0.08670804f, 
    0.02719096f, -0.13059303f, 0.11678920f, -0.05414181f, -0.08194418f, -0.24948847f, 0.05084046f, -0.08333896f, 
    -0.56099844f, -0.25411370f, -0.56379873f, 0.08832993f, -0.41254997f, 0.39017320f, 0.30838472f, 0.15760137f, 
    0.10068032f, 0.22646844f, -0.03542440f, -0.04813685f, 0.15461387f, -0.21759169f, -0.03873857f, 0.00263259f, 
    -0.14762910f, -0.20902058f, 0.17499319f, 0.07956028f, 0.43809965f, 0.74305910f, -0.15525480f, -0.44474107f, 
    0.03612649f, 0.00190126f, -0.06603387f, -0.03637875f, -0.20999600f, 0.04590863f, -0.02586779f, -0.19509886f, 
    0.07315212f, -0.09171428f, 0.01109943f, -0.02938526f, 0.12431403f, 0.08223304f, -0.01957207f, 0.09688628f, 
    -0.01931955f, -0.07218618f, -0.13006991f, -0.09006888f, 0.14868200f, 0.10707045f, 0.05688066f, 0.03842211f, 
    0.00404000f, -0.01309034f, 0.03966022f, -0.09323417f, -0.03162512f, -0.07911966f, 0.00536512f, 0.08061458f, 
    -0.06011177f, -0.05778782f, -0.01448276f, 0.02760956f, 0.46861815f, -0.07429597f, 0.01072648f, 0.05987871f, 
    -0.27518138f, 0.08778206f, 0.06815819f, 0.04422777f, 0.09900514f, -0.11890861f, -0.10839864f, -0.12963864f, 
    0.08927079f, 0.02369151f, -0.04250439f, -0.07494342f, -0.03613517f, -0.00291409f, 0.00409368f, -0.02831564f, 
    -0.19879302f, -0.28552717f, -0.16898726f, -0.04909151f, -0.31756642f, 0.09039246f, -0.18951035f, 0.00402114f, 
    -0.10756582f, -0.04687170f, -0.03732798f, -0.04702073f, 0.01719206f, 0.00672534f, 0.01261745f, 0.05939924f, 
    0.12854248f, -0.10883075f, -0.04126161f, -0.03619672f, 0.41912729f, 0.10926269f, -0.10554563f, -0.14664523f, 
    -0.30559888f, -0.06414600f, 0.04689402f, -0.09968772f, -0.02969473f, -0.04932012f, -0.09750851f, 0.07699975f, 
    0.06788934f, 0.06453073f, -0.08744303f, 0.03759295f, -0.00966113f, -0.09140954f, -0.06123566f, -0.07487367f, 
    -0.17384988f, 0.12407107f, -0.01068326f, -0.10363165f, 0.28949934f, 0.21821146f, 0.08086634f, -0.00573573f, 
    -0.01581627f, -0.11686985f, -0.14962807f, 0.01669571f, 0.09291213f, 0.05019254f, 0.05892185f, -0.11057726f, 
    0.07672552f, 0.00314824f, 0.09755121f, 0.04600347f, -0.33221909f, 0.38359377f, -0.26336062f, 0.20172386f, 
    0.37854654f, -0.13496448f, -0.12029717f, -0.07078794f, 0.11906976f, 0.01832710f, -0.15561524f, -0.06587054f, 
    0.03588801f, -0.30294845f, -0.03813157f, -0.09282944f, 0.10692499f, -0.02898457f, 0.21298875f, -0.02867389f, 
    -0.30722222f, -0.26154208f, 0.08540120f, -0.20973116f, -0.18815811f, -0.24199319f, -0.18782152f, -0.02392674f, 
    0.03794314f, -0.14488773f, 0.07651792f, -0.02291674f, 0.01672317f, -0.02266508f, 0.03605475f, 0.05715786f, 
    0.08211251f, -0.03126407f, -0.07465078f, -0.14249668f, 0.29031640f, 0.02368154f, -0.07317173f, -0.21731497f, 
    0.06724308f, -0.13141751f, 0.08173493f, 0.01583887f, 0.15275373f, -0.02787986f, -0.07347805f, 0.08504818f, 
    0.06192850f, 0.06853817f, 0.01213766f, 0.00202374f, 0.00762897f, -0.02822341f, -0.01253800f, -0.04156253f, 
    0.15153109f, 0.20469543f, 0.04342647f, -0.14966072f, -0.20946145f, -0.08159635f, -0.13796754f, -0.07934684f, 
    -0.16717032f, -0.09793369f, -0.03430393f, -0.00957840f, 0.06462357f, -0.10689756f, -0.08008558f, 0.00405059f, 
    0.04513827f, -0.17238463f, 0.00846013f, -0.09849301f, -0.29824793f, 0.02940746f, 0.08703490f, 0.21642551f, 
    0.40032056f, -0.10145795f, 0.00563755f, -0.07408047f, -0.00125886f, -0.06811550f, -0.00813516f, 0.05894174f, 
    0.02947727f, -0.04446409f, -0.06974294f, 0.05794032f, 0.08909234f, 0.06778750f, -0.05522941f, 0.03379178f, 
    0.24642515f, 0.01867521f, -0.12861763f, -0.19379835f, 0.05686749f, 0.07037720f, -0.00252095f, 0.08053672f, 
    0.02201719f, -0.15114500f, 0.02802712f, -0.02692107f, 0.01832540f, -0.04320890f, -0.00169360f, -0.08293974f, 
    -0.07405023f, 0.02431759f, 0.08859490f, -0.02458086f, 0.04292999f, -0.21036929f, -0.05875555f, 0.11057280f, 
    0.44351536f, -0.01674313f, 0.08398659f, -0.05043797f, 0.01096644f, 0.06471093f, -0.05564128f, -0.03539854f, 
    -0.04234253f, -0.12853459f, -0.00315095f, 0.00844664f, -0.01936117f, -0.02589803f, 0.04320110f, -0.04942394f, 
    -0.15577452f, 0.22153300f, -0.13203223f, -0.03567020f, -0.37439656f, 0.02810561f, -0.29778814f, 0.06450339f, 
    0.11080720f, -0.12935448f, 0.11211231f, 0.06054012f, 0.17897651f, -0.11013673f, -0.04665672f, 0.00403882f, 
    -0.09185912f, -0.17018700f, 0.13068591f, -0.10086957f, -0.36377871f, -0.08809408f, 0.11819343f, 0.16186035f, 
    0.11492925f, -0.11258541f, -0.25420499f, -0.05587951f, -0.07393109f, -0.11056583f, -0.00550851f, 0.04951716f, 
    -0.04428173f, -0.14793596f, -0.05531854f, -0.08160617f, 0.04964425f, 0.00754660f, -0.08026348f, 0.03461099f, 
    -0.10429221f, 0.36506072f, -0.11093278f, -0.19731602f, 0.11960451f, -0.05699822f, -0.17698637f, -0.03083394f, 
    0.01648627f, -0.05157745f, -0.07943450f, 0.02109462f, -0.11908337f, 0.00570152f, 0.07988162f, 0.13195115f, 
    0.00463833f, 0.17448851f, -0.24400733f, 0.02373038f, 0.13590476f, 0.36750224f, -0.07752127f, -0.05123866f, 
    0.07506303f, 0.15800940f, -0.03004887f, -0.04035604f, -0.06547838f, -0.09723517f, -0.21530621f, -0.06100979f, 
    -0.07220070f, -0.03796216f, 0.00514550f, -0.03751228f, -0.00789424f, -0.09538178f, 0.10983631f, 0.07761161f, 
    -0.15272148f, -0.06843106f, -0.30609235f, 0.00623172f, 0.23522051f, 0.12815917f, -0.05835721f, -0.08389056f, 
    0.12805291f, -0.01805483f, -0.04485023f, 0.06387135f, -0.07933629f, 0.15354271f, -0.00380209f, -0.01558401f, 
    -0.04270101f, 0.11232590f, 0.07753785f, 0.03878106f, -0.32151151f, 0.04993532f, -0.01599067f, -0.03226693f, 
    0.21245608f, -0.02964155f, 0.07926605f, -0.09312902f, 0.05656419f, -0.00766017f, 0.01054200f, 0.01845860f, 
    -0.00817262f, 0.04239336f, 0.02974873f, -0.05592405f, 0.03476987f, 0.10096315f, -0.04501905f, 0.02669168f, 
    -0.24929462f, -0.09599814f, -0.20521396f, -0.02556834f, 0.09665485f, 0.08626480f, 0.00304264f, 0.04070069f, 
    0.01548068f, 0.08425844f, -0.00990748f, -0.05393105f, -0.03875623f, 0.08209983f, -0.09967710f, 0.02284403f, 
    -0.11403937f, 0.08963629f, -0.03934940f, -0.00072604f, -0.36899534f, -0.19340335f, -0.23553663f, -0.19794394f, 
    -0.24071717f, 0.16338840f, -0.04940317f, 0.05049089f, -0.08812007f, -0.10444041f, -0.07753592f, 0.09987611f, 
    0.01895783f, -0.02034382f, -0.16508248f, -0.09338418f, -0.10049116f, -0.03424883f, 0.11576182f, -0.09624333f, 
    -0.22642836f, -0.01180424f, -0.08435917f, 0.10263646f, 0.12900893f, -0.04267987f, 0.00347468f, -0.00083561f, 
    -0.04284155f, 0.03201483f, -0.14931792f, 0.04499651f, -0.04011280f, -0.04413068f, 0.01747572f, 0.02612702f, 
    -0.05173396f, 0.09917941f, -0.18651676f, -0.04086689f, -0.08785871f, 0.04049811f, -0.09503575f, 0.23872006f, 
    0.13548985f, 0.02854031f, -0.10519859f, 0.13833503f, -0.04058520f, -0.04973683f, 0.04756386f, 0.09977434f, 
    -0.00764907f, -0.07155552f, 0.07996485f, -0.03288834f, 0.04871344f, 0.13704386f, 0.04357023f, -0.11583697f, 
    -0.32416898f, 0.32049859f, -0.21134247f, 0.28420120f, 0.08774227f, 0.02122051f, -0.18434845f, -0.01262098f, 
    0.02073663f, -0.03454598f, 0.02019032f, -0.03844399f, 0.00683511f, -0.08953296f, -0.09770275f, 0.01838061f, 
    0.14871384f, 0.05794900f, 0.08906618f, -0.18869135f, -0.02625446f, -0.25314024f, -0.09156429f, 0.15599865f, 
    0.36223316f, -0.14582181f, 0.11668252f, 0.05693642f, 0.09657462f, 0.12252863f, 0.05028325f, 0.07380565f, 
    -0.06073307f, -0.06963721f, 0.00722851f, -0.13625811f, 0.01392678f, -0.04179499f, -0.01897923f, 0.02047656f, 
    -0.02628812f, 0.05661175f, -0.01077408f, 0.10697617f, 0.20694241f, -0.01013406f, -0.07165486f, 0.01820141f, 
    -0.09927901f, -0.00853347f, -0.13558930f, 0.05415288f, 0.01187939f, -0.04307240f, 0.01803544f, 0.05483345f, 
    -0.05165144f, 0.11333407f, 0.02428661f, 0.03199852f, -0.63488781f, -0.41442347f, -0.44930974f, -0.30171153f, 
    -0.22760069f, 0.06039741f, -0.06112837f, -0.01706058f, -0.09040827f, -0.00450649f, 0.07108818f, 0.11215614f, 
    0.05387278f, 0.13104132f, -0.00633037f, 0.03015800f, 0.11053143f, 0.14080392f, -0.11790658f, -0.10302402f, 
    -0.34037101f, -0.04811909f, -0.03188480f, 0.14450894f, 0.22890012f, 0.13760380f, 0.08241235f, 0.13387038f, 
    -0.10088008f, 0.14882654f, 0.02409261f, 0.02051237f, 0.05103339f, 0.02826465f, -0.19343525f, 0.21957348f, 
    0.06196833f, 0.15635280f, -0.02266490f, -0.00334025f, 0.17778187f, 0.07352620f, -0.18951628f, -0.25738415f, 
    0.12433666f, 0.04925900f, -0.00167160f, 0.01188043f, 0.02703604f, -0.08966128f, 0.10751313f, -0.07603224f, 
    -0.03921837f, -0.00998878f, 0.01847618f, 0.00444082f, -0.03694135f, 0.11139111f, -0.05823175f, 0.08356084f, 
    0.19858111f, -0.15851569f, 0.22757231f, -0.35725063f, -0.35766965f, -0.05107254f, 0.40550977f, -0.14798523f, 
    -0.02075393f, -0.11723507f, 0.14596280f, 0.12136378f, 0.23831959f, -0.13276488f, -0.07436681f, 0.10959769f, 
    0.21342009f, 0.06331716f, -0.24543688f, -0.43212473f, -0.24297409f, -0.08010098f, -0.11933465f, 0.11068150f, 
    -0.18146542f, 0.12817624f, -0.10685235f, -0.05519635f, -0.03623074f, -0.08023310f, -0.01413245f, -0.02268153f, 
    0.11444484f, 0.01588832f, -0.17190488f, -0.03467640f, 0.01587973f, 0.04131103f, -0.05387731f, -0.04395205f, 
    -0.03209957f, 0.75968421f, 0.12829646f, -0.02909209f, 0.14847976f, 0.25240725f, 0.06608535f, 0.02023426f, 
    0.13048191f, 0.13481207f, -0.07519567f, -0.06064761f, 0.04437684f, 0.02637346f, 0.08959857f, -0.02546786f, 
    -0.07957025f, -0.01434077f, -0.05694713f, 0.02509634f, -0.36937201f, -0.37925777f, 0.42888290f, 0.09287959f, 
    0.16154805f, -0.13988979f, 0.03630028f, 0.02274935f, -0.05146062f, -0.05458065f, 0.13149130f, 0.05875918f, 
    0.00439512f, 0.05109498f, 0.09888767f, -0.08205750f, 0.04480121f, 0.09002797f, -0.01901369f, -0.03765570f, 
    0.01238132f, 0.42436734f, -0.05428015f, 0.07938253f, -0.01105807f, 0.10613661f, 0.08521150f, 0.02108097f, 
    -0.08118272f, 0.20543449f, -0.15667276f, 0.10499117f, -0.00607476f, -0.10025560f, 0.08804165f, -0.09775993f, 
    -0.10021800f, 0.11092550f, 0.19585718f, 0.02832006f, -0.23783332f, -0.13824192f, -0.17600314f, -0.00016220f, 
    0.31777722f, 0.14721996f, 0.00396832f, -0.01797135f, -0.00190126f, -0.03746525f, -0.07441793f, 0.07368868f, 
    0.04142258f, 0.06656045f, 0.02953361f, 0.02920697f, 0.02798591f, 0.20817970f, 0.08050847f, 0.01351303f, 
    -0.00802712f, -0.17652623f, 0.13907334f, 0.28590247f, 0.40157294f, -0.10381019f, 0.00113348f, -0.02182822f, 
    0.13174577f, 0.00100902f, 0.03478599f, -0.00449929f, 0.01616349f, -0.06090344f, 0.03788428f, 0.01031805f, 
    0.09577139f, -0.08325730f, 0.09797279f, 0.03756703f, 0.87058932f, 0.80181372f, -0.00667624f, -0.44028568f, 
    -0.07025708f, 0.11748611f, -0.00157323f, -0.17777596f, -0.23982559f, -0.07988071f, -0.20470294f, -0.00770793f, 
    -0.00678090f, -0.03845575f, 0.03075265f, 0.11074305f, 0.13595150f, -0.17582396f, 0.06609255f, 0.10436939f, 
    -0.12900734f, -0.19955446f, -0.04621083f, -0.11513393f, 0.23761183f, 0.11983079f, 0.05505674f, -0.05438772f, 
    -0.13874060f, 0.06417036f, -0.04078950f, -0.03043142f, -0.10095264f, -0.01359778f, -0.02942541f, -0.13908295f, 
    -0.15342930f, 0.14930047f, 0.07231639f, -0.07751216f, 0.41559419f, 0.20103399f, 0.26473886f, -0.20282434f, 
    0.10369626f, -0.04068510f, 0.14524639f, 0.02021318f, -0.06988162f, 0.12052450f, -0.11486737f, 0.05888918f, 
    0.11297697f, -0.07707467f, 0.03940484f, -0.05034722f, -0.13631974f, -0.04101095f, 0.11465930f, 0.02244604f, 
    0.41024032f, 0.23078501f, -0.07980533f, -0.17969929f, -0.33859992f, 0.11389466f, -0.01793901f, -0.04116362f, 
    -0.00931761f, 0.16256081f, -0.09725100f, -0.11121054f, 0.13755237f, -0.12703258f, -0.04402048f, -0.06646515f, 
    -0.04254610f, -0.00948891f, 0.07403474f, -0.05493502f, -0.62748545f, 0.68785048f, -0.19535501f, -0.16478635f, 
    0.13957319f, 0.29671487f, 0.17084253f, 0.07860472f, 0.11265438f, 0.07015069f, -0.12315528f, -0.08149240f, 
    -0.01816681f, -0.02256410f, 0.12205240f, -0.07629600f, 0.12488709f, -0.12225484f, 0.04901072f, -0.19714363f, 
    -0.55105573f, 0.10798237f, -0.19367345f, -0.26189807f, -0.06774165f, 0.00515301f, 0.05847459f, 0.01717785f, 
    0.17841679f, 0.02631899f, -0.13106346f, -0.06985360f, -0.23082449f, 0.05643931f, 0.05311770f, -0.13691567f, 
    -0.17748742f, 0.08496130f, -0.07415189f, -0.18390943f, -0.14892402f, 0.23704176f, -0.11142431f, -0.00778196f, 
    0.29123348f, 0.13644914f, 0.08237275f, 0.01977428f, 0.03139681f, 0.13150565f, -0.09652372f, 0.12028194f, 
    0.00567916f, 0.06848630f, 0.14252388f, -0.08794905f, 0.07373261f, 0.01904584f, 0.07166168f, 0.11844622f, 
    0.08021416f, 0.04428595f, -0.01625249f, -0.06883997f, -0.36765975f, 0.07396090f, -0.04253004f, -0.04325435f, 
    -0.06052076f, 0.02419291f, -0.12646924f, -0.11191531f, -0.04263139f, 0.02438817f, -0.06740598f, -0.06363170f, 
    -0.12775196f, -0.01432548f, 0.01450581f, -0.13036549f, 0.23372141f, -0.14054365f, 0.19560593f, -0.22179914f, 
    0.16605859f, -0.13597071f, 0.07367622f, 0.03452512f, 0.09568447f, 0.06975359f, 0.06207318f, 0.01374563f, 
    0.03104299f, -0.01641514f, 0.08238474f, -0.02791494f, -0.08223084f, 0.01716242f, -0.02282413f, -0.01951153f, 
    0.12312887f, 0.06984490f, 0.29487312f, 0.23200184f, 0.11928243f, -0.10425673f, -0.04310620f, -0.06741153f, 
    0.05261836f, 0.09635367f, 0.09225900f, 0.01604614f, -0.00542150f, -0.03288989f, 0.00715037f, 0.01037043f, 
    0.01709969f, -0.11869753f, 0.05230547f, -0.17543930f, 0.07899825f, -0.02783330f, 0.28836468f, 0.06360409f, 
    0.15323862f, -0.06352666f, 0.09549656f, 0.06960649f, -0.09131660f, -0.07923495f, -0.00102363f, -0.03249460f, 
    -0.01132690f, 0.05039391f, 0.05085931f, -0.05052548f, 0.00609585f, -0.09266951f, -0.05495270f, -0.13149153f, 
    0.15354034f, 0.10974202f, 0.11559375f, 0.30054551f, 0.15338732f, -0.04330323f, 0.07027388f, 0.02861290f, 
    0.06423354f, 0.06323034f, 0.06618558f, -0.03006846f, 0.00750551f, -0.03360621f, 0.00077192f, -0.03160921f, 
    -0.03443127f, -0.06675939f, -0.02507118f, -0.14976440f, -0.33423373f, -0.09601157f, 0.04109826f, -0.29253137f, 
    0.00712096f, 0.03816600f, 0.10151508f, -0.10235287f, 0.06109653f, 0.04292198f, -0.06296357f, -0.02148798f, 
    -0.05676105f, 0.14554325f, -0.02186978f, -0.04411086f, 0.07428084f, 0.02854933f, -0.00215831f, -0.01366429f, 
    0.05394739f, -0.07512383f, 0.22914073f, -0.00017019f, 0.08330411f, -0.25121260f, -0.03726622f, -0.12675866f, 
    0.02746159f, -0.06292078f, 0.02856196f, -0.02334434f, -0.05028075f, 0.05748194f, -0.01520089f, 0.00572951f, 
    0.01118301f, 0.01252295f, 0.07316484f, -0.03165267f, 0.09860327f, -0.02370274f, 0.09814903f, -0.05750669f, 
    0.02187626f, 0.00194395f, -0.01848166f, -0.06578852f, 0.03848989f, 0.01610359f, 0.08429933f, -0.00253191f, 
    0.03956192f, 0.01351799f, 0.01518148f, 0.00097630f, -0.05668042f, -0.02760246f, -0.03437206f, -0.00863188f, 
    -0.07978202f, -0.11000489f, 0.15223330f, 0.24671000f, 0.09472422f, -0.12909691f, 0.00405257f, -0.00722226f, 
    0.02889408f, -0.03969327f, 0.01078806f, 0.03787098f, -0.03153449f, -0.03040393f, -0.02992180f, -0.02299181f, 
    0.00462815f, -0.00719698f, 0.02291263f, 0.01210862f, -0.06835379f, -0.02779310f, 0.20173293f, 0.18036357f, 
    0.12211773f, -0.09782753f, 0.09580077f, -0.04365510f, 0.05858644f, 0.08118375f, -0.02132877f, 0.02372346f, 
    0.02512750f, 0.02277802f, 0.04196000f, 0.08753072f, 0.07002389f, 0.01721121f, 0.03871660f, 0.05026254f, 
    0.01752809f, 0.09499731f, 0.19098367f, 0.12353921f, 0.08880382f, -0.06970480f, -0.00114746f, -0.06008401f, 
    0.01134388f, 0.10237002f, -0.00686128f, -0.02414923f, 0.01795268f, 0.04515450f, -0.02279137f, -0.00795550f, 
    0.02094910f, -0.06149931f, 0.02600729f, 0.05208975f, -0.01315150f, 0.14222994f, -0.00035347f, 0.07768533f, 
    0.00827815f, 0.09196807f, 0.11683182f, -0.08728500f, 0.01283867f, 0.12730940f, 0.00549411f, -0.00485842f, 
    0.06718401f, 0.05713735f, 0.04572121f, 0.06158090f, -0.04404303f, -0.03876746f, -0.13760678f, -0.05896076f, 
    -0.05302313f, 0.05377731f, 0.10047446f, 0.25546131f, 0.02590335f, -0.08743093f, 0.06021767f, 0.02245869f, 
    -0.11401492f, 0.01589586f, 0.03176913f, -0.03717727f, 0.00458058f, 0.07983384f, 0.04933215f, -0.00492667f, 
    -0.01407787f, -0.05331390f, -0.01855560f, 0.02162798f, 0.38712180f, -0.42700046f, -0.18625240f, 0.08252887f, 
    -0.26094699f, 0.00529776f, -0.03180224f, 0.08071770f, -0.00843411f, 0.00227738f, -0.02537848f, -0.01408157f, 
    -0.05114127f, -0.01628870f, 0.08977852f, 0.00732208f, -0.00577203f, -0.02460792f, -0.00291808f, 0.02266397f, 
    0.11818621f, -0.28514096f, 0.21208595f, -0.15520106f, 0.03744889f, -0.01073942f, -0.02348633f, -0.01056675f, 
    -0.12636657f, -0.21738844f, -0.02255976f, -0.12694405f, -0.00839787f, 0.11654840f, -0.02946720f, -0.06773554f, 
    -0.06192521f, -0.04339181f, -0.05072435f, -0.11474082f, -0.14526257f, -0.33000535f, -0.00661082f, 0.13499919f, 
    0.00627595f, -0.21168722f, -0.21009579f, 0.07900858f, -0.16999121f, -0.01912882f, -0.18075487f, 0.10234263f, 
    0.01186184f, -0.03943013f, -0.15022364f, -0.05257353f, -0.05438983f, 0.02326846f, 0.00365970f, 0.09864771f, 
    0.05910946f, 0.06745523f, -0.03316341f, 0.06949259f, 0.08560363f, 0.06744330f, 0.14075236f, 0.04198107f, 
    0.03479955f, 0.03111682f, 0.07392781f, 0.03318799f, 0.03658061f, -0.11950801f, 0.08741467f, -0.08279626f, 
    -0.07241543f, -0.05409437f, -0.04330761f, -0.05748156f, -0.04776761f, -0.52787900f, 0.10596110f, -0.62217283f, 
    -0.15036353f, -0.10775338f, -0.06874286f, 0.03800310f, 0.24720082f, -0.08725185f, 0.04375898f, -0.01661141f, 
    -0.02182785f, -0.05921535f, 0.00558413f, -0.07726645f, 0.02016418f, -0.14058991f, 0.03300142f, 0.01660782f, 
    -0.26920861f, 0.28707373f, -0.49222264f, -0.22926046f, 0.01663219f, 0.08119211f, -0.00388569f, 0.05242043f, 
    0.06921422f, 0.03766941f, 0.11552180f, -0.00073687f, 0.04313291f, -0.00360029f, 0.03103007f, 0.09454995f, 
    0.09725630f, 0.22200689f, -0.10556781f, 0.14152989f, 0.02464681f, 0.07352382f, -0.10662070f, 0.12523526f, 
    0.05934016f, 0.12324740f, 0.10908722f, 0.03590190f, -0.02693619f, -0.01065723f, 0.11631571f, -0.10368644f, 
    0.08958293f, -0.05953472f, 0.04418941f, -0.12852015f, 0.01701221f, -0.05271029f, -0.21803835f, -0.07805134f, 
    0.41765860f, 0.15089740f, 0.12460005f, -0.25327522f, -0.23302938f, 0.07229501f, 0.01979995f, 0.07217060f, 
    0.04937683f, 0.05670350f, 0.03551276f, 0.01360793f, -0.04051233f, 0.01621289f, -0.08013411f, -0.18002664f, 
    -0.03646283f, -0.00230810f, -0.13508494f, 0.17630905f, -0.07567359f, -0.32465592f, -0.12174284f, 0.28443357f, 
    -0.18284263f, 0.09505519f, -0.08616179f, -0.02582550f, -0.18607835f, -0.04894275f, -0.04088241f, -0.03011388f, 
    -0.10807975f, 0.05283003f, 0.06370788f, -0.03707720f, -0.01925825f, -0.09567550f, -0.30049440f, 0.03008615f, 
    -0.00345531f, 0.11351929f, 0.09607522f, 0.07390992f, 0.03379527f, 0.04627364f, 0.03254813f, 0.04703017f, 
    -0.09154245f, 0.18262538f, 0.02054879f, -0.04327944f, 0.13124706f, -0.04048567f, 0.03509858f, -0.06567125f, 
    -0.03701401f, -0.07003009f, -0.14876014f, -0.11042877f, -0.47242635f, 0.13074657f, -0.10098244f, -0.54347140f, 
    -0.08658646f, 0.12600739f, 0.00951066f, -0.01286105f, 0.08672453f, 0.07369983f, -0.03446853f, 0.04531980f, 
    0.04391759f, -0.05618963f, -0.02058174f, -0.01861821f, 0.00509178f, 0.00024052f, -0.23880531f, 0.24465483f, 
    0.00699311f, 0.04163993f, -0.05083092f, -0.04684544f, -0.01590641f, 0.11896832f, 0.07386511f, 0.03176493f, 
    0.04193278f, 0.05600128f, 0.05180671f, 0.06562655f, -0.01247693f, -0.00265766f, 0.12213717f, 0.10848247f, 
    0.00895014f, 0.00267360f, -0.00324030f, 0.03142157f, 0.09381588f, -0.15780726f, -0.10696129f, -0.17470519f, 
    -0.21578878f, 0.03016243f, -0.03044104f, 0.00289443f, 0.04309052f, 0.00014483f, 0.03301116f, -0.09226719f, 
    0.02736473f, -0.08988999f, 0.08028971f, -0.18169218f, -0.06499268f, 0.04291169f, -0.02061560f, -0.04920993f, 
    0.12677221f, -0.08283832f, 0.25259668f, 0.15988354f, 0.06539202f, -0.15970196f, -0.03332297f, -0.03705673f, 
    -0.02456020f, 0.11105492f, 0.02243380f, 0.07602870f, -0.03503808f, 0.01774861f, 0.00587305f, 0.03751599f, 
    0.06690538f, -0.00736062f, -0.01619874f, 0.00861711f, 0.05298129f, -0.12431813f, -0.06525937f, -0.00216801f, 
    -0.18947668f, 0.09264217f, 0.02252096f, -0.02765212f, -0.09093837f, 0.07075088f, 0.11107418f, -0.02326607f, 
    0.02058317f, 0.00053020f, 0.00712976f, -0.20850782f, 0.04012951f, -0.07034135f, -0.17503498f, -0.11634749f, 
    -0.01823065f, -0.03463748f, -0.04180518f, 0.06353047f, 0.04336327f, 0.04635632f, 0.06436832f, 0.04846337f, 
    0.02548878f, 0.00465596f, 0.06123029f, 0.05680180f, 0.00541126f, -0.01513168f, 0.08373493f, -0.01044684f, 
    0.00415559f, 0.06124863f, 0.00952026f, 0.04495322f, -0.08579372f, -0.13467886f, -0.05920053f, 0.10889780f, 
    0.01930448f, -0.06136718f, 0.06734265f, -0.05218270f, -0.04173769f, -0.00170608f, 0.00303966f, -0.01679252f, 
    0.00755022f, -0.01889567f, 0.04007084f, 0.02289875f, 0.18261644f, -0.00778423f, 0.09528226f, 0.19670570f, 
    -0.02765171f, -0.04477154f, -0.10847750f, -0.05489678f, -0.08756816f, 0.02920735f, 0.03884727f, -0.01504695f, 
    -0.02559100f, -0.01056813f, 0.01447987f, -0.08531098f, 0.00101565f, 0.08110359f, 0.05883274f, 0.09111507f, 
    -0.01489187f, -0.03058182f, -0.02413065f, -0.01089645f, -0.04696986f, -0.09885171f, 0.03777362f, -0.25028539f, 
    0.06776811f, 0.07109424f, 0.05481360f, 0.12410706f, -0.09035288f, -0.02828367f, -0.02023452f, -0.03455457f, 
    0.10759027f, -0.01985022f, -0.01771440f, -0.10706729f, 0.05667797f, -0.01862017f, -0.03448764f, -0.04214793f, 
    0.04141800f, 0.03620667f, 0.03751491f, 0.15948166f, 0.02133108f, -0.07240070f, -0.05361154f, -0.03741659f, 
    -0.04339558f, -0.01135277f, 0.08604962f, -0.04559445f, 0.09647461f, 0.02702275f, -0.04058577f, -0.05079137f, 
    0.00380441f, -0.05651511f, -0.13904984f, -0.16477890f, 0.08975965f, 0.14693144f, 0.12960756f, 0.14756228f, 
    0.04883954f, -0.00632586f, 0.12034724f, -0.04069575f, 0.12977721f, 0.09781568f, -0.01682063f, -0.00450833f, 
    0.00391065f, 0.02822793f, -0.07223053f, -0.02430662f, 0.05121510f, 0.00658976f, -0.01411814f, 0.14162479f, 
    -0.11604522f, -0.11606176f, 0.01235175f, -0.07809583f, 0.16902234f, -0.03539230f, 0.05844740f, -0.03522881f, 
    0.08345131f, -0.03481606f, 0.05958315f, -0.07343252f, -0.05305646f, -0.01228090f, 0.08230698f, -0.21742284f, 
    -0.09326935f, 0.07644691f, -0.00925338f, -0.09516295f, -0.20170195f, -0.26416242f, 0.15902546f, -0.51908457f, 
    -0.12401607f, -0.02010068f, -0.08985786f, -0.06008986f, 0.09818581f, -0.04262237f, 0.05784758f, -0.07109200f, 
    0.04896959f, -0.09394784f, -0.08350331f, 0.07373648f, 0.02980525f, -0.04763937f, -0.01450051f, -0.04688314f, 
    -0.11983026f, -0.04261193f, 0.04408627f, 0.06803381f, -0.03858692f, -0.00246309f, -0.06217981f, -0.09348042f, 
    -0.00023109f, 0.07860202f, 0.00348552f, -0.04248960f, -0.11109285f, 0.06848506f, 0.12857547f, -0.05174070f, 
    -0.15753926f, 0.03577590f, -0.19481964f, -0.29937762f, 0.07049306f, -0.13024713f, 0.08081818f, 0.02198414f, 
    0.01388106f, -0.04866725f, -0.07582607f, -0.02427649f, -0.00580428f, 0.06772450f, 0.07180305f, -0.03041945f, 
    -0.03087991f, -0.06887920f, 0.04487639f, 0.03133402f, 0.01645687f, 0.02618016f, -0.02192523f, -0.02202096f, 
    0.15421307f, 0.11299981f, 0.17594898f, 0.14781776f, -0.01301345f, -0.05322168f, -0.12613595f, 0.05552204f, 
    -0.08438506f, 0.00908712f, 0.06047729f, -0.02567369f, 0.02775082f, 0.03056774f, 0.07661188f, 0.00103754f, 
    -0.07979429f, -0.00822714f, -0.04462919f, -0.08775929f, -0.09975494f, -0.00243290f, -0.07122450f, 0.15347305f, 
    -0.14485452f, -0.14192373f, -0.05317343f, -0.09279338f, -0.16455925f, -0.02046533f, -0.08186754f, 0.05983254f, 
    -0.04802310f, 0.02583082f, -0.01354156f, 0.11123838f, -0.00159554f, -0.11052142f, 0.03485598f, 0.10466465f, 
    0.07937138f, 0.15023410f, 0.23114182f, 0.01891744f, -0.06220697f, 0.04089138f, -0.19805266f, -0.02858808f, 
    -0.03737295f, 0.21238656f, 0.05678929f, 0.00568488f, 0.06260797f, 0.00495649f, 0.02822689f, 0.04015287f, 
    -0.06673269f, -0.12409584f, -0.14483882f, -0.11616925f, -0.00114632f, 0.00710736f, -0.05096484f, -0.09178301f, 
    -0.04486939f, 0.06498843f, 0.00104595f, -0.00373874f, 0.06766658f, 0.04092995f, 0.02604659f, 0.04041819f, 
    -0.05522857f, -0.05132508f, 0.04693854f, 0.11120465f, 0.07669040f, -0.03213268f, -0.01122392f, 0.09367040f, 
    -0.01062822f, -0.03295773f, 0.12431993f, 0.01972222f, 0.05473318f, -0.11137730f, 0.10771659f, -0.02154393f, 
    -0.07099513f, -0.03809908f, -0.02523745f, 0.00551775f, -0.04168338f, 0.02707876f, 0.01463073f, 0.00366243f, 
    0.08169341f, -0.04184631f, 0.07842880f, 0.09785342f, 0.06571499f, -0.03098982f, 0.10322286f, -0.10867065f, 
    0.05980017f, 0.12299557f, -0.04431713f, -0.07485433f, -0.07136432f, 0.00166852f, -0.06507444f, -0.02217234f, 
    -0.01747979f, -0.10174058f, -0.03406048f, -0.00522717f, -0.15482707f, 0.00106823f, -0.07982640f, -0.07827384f, 
    0.05003705f, -0.14161392f, 0.00355197f, -0.09080023f, -0.04838986f, 0.06962491f, 0.02270795f, 0.10526205f, 
    -0.13865350f, 0.03819631f, 0.05892980f, 0.02825888f, 0.08745745f, -0.01854977f, 0.00950172f, -0.02187876f, 
    -0.07201468f, -0.06820731f, -0.08585880f, -0.05022704f, 0.13373898f, 0.13538371f, 0.27735618f, 0.15671813f, 
    0.16384518f, 0.05625479f, 0.21886379f, 0.06133321f, 0.16172555f, 0.18032831f, 0.04626196f, -0.03315274f, 
    -0.01105012f, 0.00913847f, 0.01366485f, 0.03140621f, 0.05990490f, -0.09595220f, 0.14991945f, 0.17355633f, 
    0.00671913f, -0.07403211f, 0.14483915f, 0.04286857f, 0.10091031f, -0.14717059f, 0.00414255f, -0.10279535f, 
    -0.01955919f, -0.00705672f, 0.05481395f, -0.05061091f, 0.00112985f, 0.00898611f, 0.04718486f, 0.01992193f, 
    0.03186620f, 0.02510718f, -0.02132063f, -0.05531347f, 0.04632432f, 0.02242622f, 0.03632566f, 0.15822001f, 
    0.16112681f, 0.06761741f, 0.08073272f, 0.02973077f, 0.08278740f, 0.04023324f, 0.06384824f, 0.09414292f, 
    -0.01947214f, 0.01805903f, 0.08057239f, -0.04508938f, -0.12462134f, -0.13149135f, 0.02937574f, 0.05941727f, 
    0.13615564f, 0.05331425f, 0.24833009f, -0.09672138f, 0.02163068f, 0.08048602f, -0.02110756f, 0.01939911f, 
    -0.04887716f, 0.14292680f, 0.03076111f, -0.00010714f, 0.09685759f, 0.02211128f, 0.03502280f, 0.01594465f, 
    0.00124430f, -0.07852276f, -0.07244985f, -0.12195054f, 0.05677848f, 0.03053529f, 0.16575465f, 0.24174593f, 
    0.06042328f, -0.15955713f, -0.07835105f, -0.00835446f, -0.07517018f, 0.13447210f, 0.03653239f, -0.04352740f, 
    0.07832383f, -0.02795870f, 0.01799371f, -0.05098130f, -0.05211861f, -0.03458340f, -0.11408232f, -0.17372860f, 
    0.13017252f, 0.02669173f, -0.08425601f, -0.04425105f, -0.12026203f, 0.02504179f, 0.05370150f, 0.01335129f, 
    -0.03366653f, 0.03823759f, 0.03242396f, -0.16944923f, -0.04332913f, -0.04961341f, 0.06834976f, -0.03684204f, 
    -0.08871169f, 0.02437461f, 0.01897419f, -0.04695019f, 0.02098736f, 0.04742089f, -0.05406272f, -0.06202175f, 
    -0.04928879f, 0.01109198f, 0.02895766f, 0.06038926f, -0.04240612f, 0.06345828f, 0.00973734f, -0.08081684f, 
    -0.02669930f, -0.07541527f, 0.03700665f, 0.11271716f, 0.07728754f, -0.07417230f, -0.08856606f, 0.01908033f, 
    -0.47392154f, -0.14720760f, 0.05529187f, -0.27970159f, -0.13804121f, 0.06105271f, 0.09807970f, -0.07362603f, 
    0.06936429f, 0.07405968f, -0.04113988f, 0.01205280f, -0.05761475f, 0.13376617f, -0.03897738f, -0.07783087f, 
    0.03280508f, -0.02595314f, -0.02002996f, 0.07279782f, 0.09375560f, 0.03205876f, -0.01935872f, 0.28119546f, 
    0.16586888f, 0.11241505f, 0.04871192f, 0.04095441f, 0.08255855f, 0.11557081f, 0.04886962f, 0.03904196f, 
    -0.03110650f, -0.00975538f, 0.02451548f, -0.00147254f, 0.00165164f, -0.15053488f, -0.01353384f, 0.02755227f, 
    -0.16108461f, -0.40517598f, 0.07341482f, 0.05630358f, -0.01414215f, -0.03281980f, 0.01010131f, 0.08462257f, 
    -0.18825436f, -0.03124270f, -0.04578236f, 0.05962954f, 0.02622975f, 0.08952171f, -0.10317933f, -0.11669298f, 
    0.21002127f, 0.08140866f, 0.03404204f, 0.15779667f, 0.13683820f, 0.08874505f, 0.11356767f, 0.14938642f, 
    0.06569103f, -0.07994515f, -0.08302869f, -0.12532474f, -0.02047854f, -0.00660121f, 0.17869976f, -0.05607700f, 
    0.01269894f, 0.06661703f, 0.02322811f, 0.07740664f, 0.04831693f, -0.02341838f, -0.04114255f, -0.01843833f, 
    -0.15309720f, 0.20347650f, -0.05261158f, 0.01330048f, 0.08959883f, 0.02757537f, -0.00888241f, -0.01692559f, 
    0.03193193f, 0.09426108f, 0.01779285f, 0.02346595f, 0.02057634f, 0.01655991f, -0.01845300f, 0.10152634f, 
    0.11286325f, 0.16729599f, 0.02523095f, 0.18741073f, 0.02102764f, -0.68160599f, -0.16684589f, -0.06016545f, 
    -0.14378498f, 0.06374979f, -0.15019317f, -0.01981247f, -0.03757731f, -0.03334450f, 0.00116713f, -0.17824207f, 
    0.11641733f, 0.03774408f, -0.07079647f, -0.07407749f, -0.23384003f, -0.01711674f, -0.10506364f, 0.00095662f, 
    0.10498820f, -0.00183195f, 0.37920016f, -0.02745968f, -0.17962135f, 0.03255875f, -0.23340549f, -0.13378438f, 
    0.04003945f, -0.03431024f, 0.04517987f, -0.04850570f, -0.01900048f, 0.04797402f, 0.01125996f, 0.06058150f, 
    0.00986502f, -0.16966602f, -0.17696533f, -0.08494304f, 0.35668728f, -0.43848494f, -0.18708296f, 0.02686473f, 
    -0.35998791f, 0.06591097f, -0.01182953f, 0.00975044f, -0.02892353f, 0.01851376f, 0.05068044f, -0.04566885f, 
    -0.04819493f, 0.04873431f, -0.08196781f, -0.00362858f, 0.16603848f, 0.07218064f, -0.01402969f, 0.21169357f, 
    0.14268441f, -0.31237495f, 0.01985608f, 0.06798689f, -0.22643766f, 0.06542778f, 0.02199473f, 0.02368335f, 
    0.03137767f, 0.02356219f, -0.09238167f, -0.01847668f, -0.04830607f, -0.17150576f, 0.10081752f, -0.11684038f, 
    0.05149740f, 0.07452729f, -0.15234478f, -0.08939882f, 0.18543771f, -0.06094498f, 0.03241565f, -0.11537493f, 
    -0.01224868f, -0.12376849f, -0.10842071f, -0.02648399f, 0.08903971f, 0.15234157f, 0.03705652f, -0.00901966f, 
    -0.02927414f, 0.02999561f, -0.03874408f, -0.00306764f, -0.00311634f, 0.00519991f, 0.00381381f, 0.01760718f, 
    0.37162566f, -0.26065576f, -0.04751659f, -0.07517333f, -0.21070524f, 0.03154781f, -0.18847565f, -0.02430249f, 
    0.16491066f, 0.05622519f, 0.03167610f, -0.00579095f, -0.00181791f, -0.06461638f, -0.06701453f, -0.06501850f, 
    -0.10609195f, 0.10873602f, -0.12008777f, -0.13294360f, -0.26656696f, -0.23947255f, 0.03864352f, 0.16834623f, 
    0.22378159f, -0.16230318f, 0.01738655f, -0.00704452f, -0.26082972f, 0.03381681f, 0.00727608f, 0.04381674f, 
    0.02720885f, -0.06170338f, -0.08882135f, -0.04024583f, 0.05394451f, 0.04335567f, 0.01037748f, 0.04671582f, 
    0.15046771f, -0.06282202f, -0.05024786f, -0.06709641f, -0.23709247f, 0.07487458f, 0.04004199f, -0.00920042f, 
    0.07706863f, -0.00177822f, 0.00016533f, -0.06247927f, 0.07507356f, -0.17145450f, 0.05436340f, 0.01997148f, 
    -0.07792100f, 0.04723871f, -0.19736198f, -0.05046201f, 0.33646321f, 0.06274144f, -0.21812552f, 0.35791984f, 
    0.03039895f, -0.09006400f, 0.06009289f, 0.05373229f, 0.02782064f, 0.10149454f, 0.03480627f, -0.03204397f, 
    0.01088675f, 0.04804598f, 0.04087287f, 0.04392201f, 0.11955009f, -0.08712807f, 0.00629993f, 0.10085273f, 
    0.14289038f, -0.06900404f, 0.11851450f, 0.06450469f, -0.15306744f, 0.13343015f, 0.16755007f, -0.03775374f, 
    -0.00998958f, 0.00316264f, -0.06132522f, -0.03956492f, -0.02770042f, 0.01798701f, -0.01768787f, -0.02882023f, 
    0.06282264f, -0.00756409f, 0.12987725f, 0.13740797f, 0.32604969f, -0.10828039f, 0.14960915f, -0.00792426f, 
    -0.27838647f, 0.17647238f, 0.11314513f, -0.17260835f, 0.15404181f, 0.04307589f, 0.04665750f, -0.01951785f, 
    -0.02293786f, 0.00948894f, -0.05149016f, -0.02713002f, -0.00438228f, -0.05732263f, 0.11602002f, 0.05116291f, 
    -0.09575783f, 0.18921015f, 0.27270034f, 0.02561591f, -0.18448861f, -0.04600153f, 0.01420361f, 0.16253805f, 
    0.14597996f, -0.07510828f, 0.00843372f, -0.03331470f, 0.03697946f, 0.02073940f, -0.02100849f, 0.05430525f, 
    -0.01972876f, 0.07624353f, -0.03396466f, 0.03746576f, -0.27311534f, 0.13041002f, -0.13963418f, -0.28206268f, 
    0.01567484f, -0.03422566f, -0.03742299f, 0.02325335f, -0.04767978f, 0.01143184f, 0.02752544f, 0.13355765f, 
    0.02526633f, -0.10462358f, 0.02025872f, -0.05208417f, -0.10363000f, 0.10795956f, 0.01947502f, -0.04278983f, 
    0.15293553f, -0.17041513f, -0.14553055f, -0.13475171f, -0.12602139f, 0.08976711f, 0.06850219f, -0.02247107f, 
    0.09832074f, 0.03582916f, 0.02883762f, 0.08692286f, -0.01206550f, 0.05718917f, -0.00939635f, -0.06580221f, 
    0.02439276f, 0.03803781f, 0.00803635f, 0.03466372f, 0.10822484f, -0.16617134f, -0.07294051f, 0.06518435f, 
    -0.07111879f, 0.08441253f, -0.01630357f, -0.05720903f, 0.15665533f, 0.09863193f, 0.01645451f, -0.02676416f, 
    0.02538175f, -0.05805488f, -0.04428798f, 0.00107255f, 0.14344789f, -0.00199735f, -0.06274149f, 0.07618643f, 
    -0.17740861f, 0.13768762f, -0.13222030f, -0.08420906f, -0.07257277f, 0.05884065f, 0.01987896f, 0.08939311f, 
    -0.00437861f, 0.08544327f, 0.03087999f, -0.05586597f, -0.05039480f, 0.00313019f, -0.03153421f, -0.05854015f, 
    -0.11658490f, 0.02202964f, 0.02813026f, 0.02986077f, -0.25815064f, -0.03756313f, 0.16217121f, -0.12115785f, 
    -0.08175401f, 0.17277160f, -0.09045830f, 0.05975790f, -0.00715936f, -0.16112302f, 0.02311970f, -0.00713970f, 
    0.03422537f, 0.04443246f, 0.03137701f, 0.07270662f, -0.01704227f, -0.19991648f, -0.07615218f, -0.25827372f, 
    0.03734477f, 0.03096024f, 0.21167688f, 0.05600295f, -0.06881018f, 0.04989903f, 0.03742489f, 0.06353463f, 
    0.03870835f, -0.12514271f, 0.03179298f, -0.01810970f, -0.02191217f, 0.04101776f, 0.01189373f, 0.02939800f, 
    0.01300671f, -0.09694915f, 0.03910974f, -0.08164976f, 0.03905901f, 0.07248878f, 0.06264362f, -0.01081607f, 
    -0.05538034f, -0.08323395f, -0.14052799f, 0.04805084f, -0.07457002f, -0.09711839f, 0.20439187f, -0.19442771f, 
    0.01705740f, -0.10823163f, 0.02959546f, -0.00584423f, 0.05134402f, -0.01642634f, -0.00868509f, 0.01733316f, 
    0.07744898f, -0.10550626f, 0.28222460f, 0.01545792f, -0.25740722f, 0.16191515f, 0.05950181f, -0.06283432f, 
    0.14157225f, 0.02504623f, -0.00925116f, -0.00014313f, 0.03162372f, 0.04205097f, 0.12897357f, 0.06168341f, 
    0.01727137f, -0.12112642f, -0.04918484f, 0.11810393f, -0.42156923f, -0.02359792f, 0.12763426f, 0.19300826f, 
    0.12317830f, -0.00646432f, 0.05677543f, -0.12385119f, -0.04607296f, 0.07376903f, 0.00139017f, 0.04482077f, 
    -0.06952222f, 0.02321571f, -0.08379506f, 0.16398141f, -0.19748841f, -0.23180680f, 0.04308052f, 0.00719251f, 
    -0.20938616f, 0.07684147f, -0.06338688f, -0.27646017f, -0.09867033f, -0.04647583f, 0.00644716f, -0.07237258f, 
    0.10973445f, 0.18727520f, -0.01136286f, 0.13245288f, -0.07339272f, -0.15023670f, -0.01210898f, 0.03720963f, 
    -0.09044217f, -0.03100733f, 0.09128700f, 0.17661184f, -0.14855334f, -0.05368711f, 0.00577811f, 0.04197701f, 
    -0.34904429f, 0.15781657f, -0.05419322f, 0.03849743f, -0.00710615f, 0.00219068f, 0.09059069f, 0.00516996f, 
    -0.15173988f, 0.03912788f, 0.32724416f, 0.01957902f, -0.01455191f, 0.06136705f, 0.02557363f, -0.01297105f, 
    0.02491423f, 0.10297451f, -0.05706161f, 0.09122271f, -0.03037972f, -0.18992005f, -0.01496224f, 0.06489610f, 
    -0.05663784f, 0.03325921f, -0.16230309f, 0.06738865f, -0.08365855f, -0.10422353f, -0.06358879f, 0.20933670f, 
    0.02578800f, 0.17640434f, -0.11334764f, 0.03595908f, 0.76364517f, -0.56779116f, 0.24190274f, 0.02818779f, 
    -0.18629381f, 0.11422536f, -0.14880493f, 0.07903770f, -0.08559658f, 0.03723533f, 0.02685341f, 0.07998805f, 
    0.09439571f, -0.03023520f, 0.14825611f, -0.07690226f, -0.16759928f, 0.03791507f, 0.07103700f, 0.09890814f, 
    0.10945670f, -0.20979911f, -0.18791506f, 0.06110089f, -0.07451773f, 0.07573079f, -0.01268599f, -0.04132802f, 
    0.00030742f, 0.02406968f, 0.01309405f, -0.00210472f, 0.00260900f, -0.04148754f, 0.00246321f, -0.17939882f, 
    -0.23166221f, 0.07343850f, 0.13721675f, -0.08751335f, -0.25569537f, 0.18443909f, -0.17347310f, 0.28083783f, 
    -0.02723520f, 0.09028726f, -0.25347358f, 0.10343186f, 0.07239597f, 0.02008085f, -0.21025507f, 0.19422862f, 
    -0.06927066f, -0.00125560f, -0.07350666f, 0.12120971f, -0.02192424f, 0.30625877f, -0.11030194f, 0.03965129f, 
    0.00474029f, 0.12518084f, -0.18996926f, -0.23548608f, 0.13836747f, 0.04223319f, -0.02328777f, -0.08865869f, 
    -0.02618355f, -0.01240351f, 0.18477759f, -0.03319323f, -0.13508801f, 0.02887452f, -0.03778081f, -0.11201203f, 
    0.10207547f, 0.22699186f, 0.07580319f, -0.19324231f, -0.39353925f, 0.15215845f, 0.12374325f, 0.13279194f, 
    -0.05251971f, 0.20843442f, -0.30148086f, -0.01206657f, 0.12272242f, -0.17682071f, 0.18898523f, 0.06108291f, 
    -0.10474006f, 0.06135904f, 0.06787086f, 0.06071860f, 0.01990995f, 0.00727303f, -0.05138417f, 0.03866187f, 
    -0.02962056f, 0.14685504f, 0.10632785f, -0.02874784f, -0.01042702f, -0.01556553f, -0.21865985f, 0.14723463f, 
    0.01962791f, -0.14367473f, -0.15009530f, -0.06861573f, -0.09017232f, -0.03264781f, -0.04153212f, 0.02597681f, 
    0.04297851f, 0.15851979f, -0.05898742f, -0.00522732f, 0.23741528f, 0.28643730f, -0.24654754f, 0.00393671f, 
    0.23927797f, 0.02489932f, -0.04477589f, -0.02841094f, -0.04503225f, -0.00028569f, 0.12852013f, -0.02182407f, 
    0.03704451f, 0.03897846f, 0.11151543f, -0.10668974f, -0.03800229f, 0.11151094f, 0.04402024f, -0.22840142f, 
    -0.06198282f, -0.12175103f, -0.18913177f, 0.02125071f, 0.02531419f, 0.04816373f, -0.00278152f, -0.08659388f, 
    -0.00605295f, -0.00337307f, -0.07688612f, -0.01705366f, 0.07281251f, 0.13082038f, -0.04449609f, 0.10917201f, 
    0.11239659f, 0.12902623f, 0.00910965f, -0.04513446f, -0.05504170f, -0.03250849f, -0.04634131f, 0.21753882f, 
    0.08168330f, 0.04158018f, 0.01588277f, -0.03188623f, -0.04296851f, 0.08254713f, -0.06373139f, -0.06171227f, 
    -0.04058517f, 0.06265164f, -0.00344113f, -0.00157374f, -0.14320584f, 0.03423562f, 0.05363334f, 0.20762606f, 
    -0.43037933f, 0.11836489f, -0.38060281f, -0.26474941f, -0.18320663f, -0.00802795f, 0.00750964f, 0.00734700f, 
    0.01006083f, 0.11360481f, 0.04822154f, 0.05941647f, -0.01570626f, 0.05100156f, -0.10513348f, -0.05699251f, 
    -0.03061695f, 0.05115898f, -0.01713292f, 0.01706317f, 0.31384826f, 0.24113916f, 0.02895778f, -0.18241173f, 
    0.23167804f, 0.12507486f, -0.01269697f, -0.03291596f, -0.18531674f, -0.04776105f, -0.04167983f, -0.04460465f, 
    -0.07353591f, 0.08154494f, 0.04997632f, 0.08313565f, 0.11937436f, 0.19774693f, -0.01606979f, 0.10678313f, 
    -0.20571634f, -0.14333439f, -0.12666760f, 0.11999507f, 0.02108921f, 0.02041852f, 0.00476198f, -0.01909226f, 
    0.03435427f, 0.01799296f, -0.02209572f, -0.01954452f, 0.02202800f, -0.03243610f, -0.02366182f, 0.07230207f, 
    -0.06346761f, 0.05241530f, -0.01926217f, -0.02840976f, 0.08184235f, -0.00762104f, 0.14471674f, 0.16070423f, 
    -0.18426692f, 0.06087653f, -0.11181261f, -0.03580600f, -0.06243147f, 0.08072379f, 0.02855578f, 0.06134450f, 
    0.05217159f, 0.00658284f, 0.05788714f, 0.02523407f, 0.01664725f, -0.07144855f, -0.35217029f, -0.35457700f, 
    -0.11206587f, -0.07637288f, -0.06430173f, 0.04718773f, 0.01929050f, 0.03120095f, -0.03734485f, -0.05477268f, 
    0.05335347f, 0.00620320f, 0.08910608f, 0.01948582f, 0.02795490f, -0.02544734f, -0.01034393f, 0.01189818f, 
    0.08964466f, 0.03776566f, 0.01945970f, 0.04505983f, 0.43300053f, 0.11222357f, -0.27489084f, -0.27034160f, 
    0.22183242f, -0.01460712f, -0.02366544f, -0.06098063f, -0.09154397f, 0.11106820f, 0.02501216f, 0.11655758f, 
    -0.10120252f, -0.04855849f, -0.04725701f, -0.03473746f, 0.05668666f, -0.03822837f, -0.10038130f, 0.09391332f, 
    -0.09574758f, 0.18243115f, 0.11172161f, 0.15415147f, -0.10707179f, -0.06429807f, 0.01218372f, 0.07793214f, 
    -0.02776501f, 0.11615464f, -0.05696645f, 0.02511520f, -0.00109170f, -0.06309803f, 0.04788948f, -0.05654484f, 
    0.02163187f, -0.01063604f, 0.03950034f, 0.16815037f, 0.35695520f, 0.28428465f, 0.10518332f, -0.09442765f, 
    0.07637977f, 0.00682914f, -0.01961504f, 0.18265557f, 0.02545202f, 0.06826204f, 0.02231194f, 0.02895785f, 
    -0.01467916f, 0.00255947f, 0.05936510f, 0.06971040f, -0.07489595f, -0.00486622f, -0.09423906f, -0.12590703f, 
    -0.07027064f, -0.33384708f, -0.13536505f, 0.14368193f, 0.14520879f, 0.03735804f, 0.03449912f, -0.05263138f, 
    -0.09274877f, 0.13023834f, 0.06015631f, 0.03793139f, 0.07075951f, -0.00402965f, -0.00437759f, 0.04711574f, 
    0.05902568f, 0.10757033f, -0.10878197f, 0.11070902f, 0.48780411f, -0.40841094f, -0.23030475f, -0.16982068f, 
    0.41431245f, 0.00866545f, -0.01824832f, -0.12585169f, -0.03996300f, 0.09091500f, 0.01123698f, 0.04790144f, 
    0.06335811f, 0.08039773f, 0.06270678f, 0.10606211f, 0.12681423f, -0.12888779f, 0.02329036f, 0.00991663f, 
    -0.21439041f, -0.61519676f, 0.22820693f, 0.06149423f, -0.24934496f, 0.03832851f, -0.00799630f, -0.16819933f, 
    0.15424569f, -0.03398904f, 0.03900615f, 0.05010708f, -0.00220825f, -0.01566824f, 0.09374017f, 0.07973383f, 
    0.04539794f, 0.03261369f, 0.23617503f, 0.48283273f, -0.27939332f, 0.13515115f, -0.27828854f, -0.06367313f, 
    -0.09543658f, 0.04648874f, 0.02821678f, -0.03276631f, 0.04256564f, -0.01506345f, 0.17366166f, 0.01408849f, 
    0.06044873f, 0.02823468f, 0.00953615f, 0.02202624f, 0.06989177f, 0.10682520f, -0.02980895f, -0.00193927f, 
    -0.19121568f, -0.04272953f, 0.15981910f, -0.18883646f, -0.13624100f, 0.09600154f, 0.02860283f, -0.05181058f, 
    -0.09313677f, 0.05062487f, 0.15976259f, 0.04806661f, -0.05312362f, -0.02716915f, 0.04404613f, 0.02405896f, 
    0.00198474f, -0.04277965f, 0.07634525f, 0.14497051f, 0.02670586f, -0.07006045f, 0.18163544f, 0.12689590f, 
    -0.22004536f, 0.04137086f, 0.03725403f, 0.33410788f, -0.16515389f, -0.12095708f, 0.05571347f, -0.04093684f, 
    -0.01703527f, 0.07205146f, 0.01467810f, -0.08695887f, -0.06563369f, -0.01043182f, 0.03505093f, -0.17744818f, 
    0.10798321f, 0.03441382f, 0.17897037f, -0.17067772f, 0.07448553f, -0.09068043f, 0.02596075f, 0.05443951f, 
    -0.12221486f, -0.12696826f, 0.02073164f, 0.03083907f, 0.06852667f, 0.00351652f, -0.01592252f, 0.10153103f, 
    0.01922346f, 0.00803766f, -0.02768287f, 0.16416290f, -0.08424102f, -0.11128206f, -0.06997561f, -0.01262663f, 
    0.05783146f, 0.03288402f, -0.04635289f, -0.02788835f, -0.06647839f, -0.02342300f, -0.02289971f, -0.05658953f, 
    -0.07902611f, 0.09120896f, 0.15937084f, 0.02156804f, 0.01397427f, 0.10565385f, 0.06473758f, -0.08213715f, 
    0.20242028f, 0.03278379f, 0.23523423f, -0.02713551f, -0.15913203f, 0.10638207f, 0.01929530f, 0.03527460f, 
    0.04160804f, 0.08959275f, 0.02259253f, 0.00037979f, 0.01509068f, -0.01992864f, 0.01830710f, -0.01802296f, 
    -0.02315448f, -0.08766745f, -0.04784652f, -0.09064823f, 0.30030411f, -0.00997792f, -0.07344326f, 0.13212587f, 
    -0.10481346f, 0.06184938f, -0.13989325f, -0.07835221f, 0.06156617f, 0.10021902f, 0.12878941f, -0.07190315f, 
    -0.06112262f, -0.10058782f, -0.08360296f, 0.14802811f, 0.10609854f, 0.01084258f, -0.04274919f, 0.19367802f, 
    0.12994912f, -0.01667360f, 0.05063266f, -0.26930988f, 0.19279034f, 0.00470944f, 0.05508089f, 0.09756345f, 
    -0.07244953f, 0.00417113f, 0.05302610f, -0.22260591f, -0.11000424f, -0.02444763f, -0.07085727f, 0.00184728f, 
    0.08254398f, 0.09335639f, -0.06212883f, -0.06331144f, 0.20386136f, 0.15516745f, 0.13472465f, -0.00004543f, 
    -0.03285155f, 0.04724132f, -0.01576730f, 0.03518048f, 0.08164067f, 0.10312638f, 0.05808641f, 0.05906038f, 
    0.03020263f, -0.00799183f, -0.01355967f, -0.01904241f, 0.03845321f, -0.12168524f, -0.14009722f, -0.18397953f, 
    -0.15416363f, -0.12139530f, -0.20102991f, -0.13643594f, -0.09897055f, 0.14878358f, -0.03072901f, 0.06931419f, 
    0.08120365f, 0.18323253f, -0.00243389f, 0.01242538f, 0.00589637f, 0.01838868f, -0.10112081f, 0.00226188f, 
    0.03746103f, 0.02374423f, -0.06581574f, 0.01436162f, -0.28381646f, -0.21871623f, -0.09972160f, 0.03766109f, 
    0.05033560f, 0.06800560f, 0.04199691f, -0.00411611f, -0.03155838f, -0.04948732f, 0.04204269f, -0.05947804f, 
    -0.06015351f, -0.07183132f, -0.04874159f, 0.00765223f, -0.01890069f, 0.09432513f, -0.07108410f, -0.01140425f, 
    0.07221713f, -0.04520679f, 0.07745948f, -0.18119222f, -0.01034316f, -0.05402865f, 0.01885414f, 0.02563722f, 
    -0.07489835f, 0.01678381f, -0.15494499f, -0.03136295f, -0.00635211f, -0.06919374f, -0.03422586f, 0.00670118f, 
    0.12652828f, -0.00002903f, 0.03571478f, 0.14349768f, 0.06727114f, -0.07100957f, 0.29800618f, 0.16918929f, 
    -0.12765004f, -0.00739039f, 0.12132413f, -0.03178105f, -0.12130180f, 0.03063731f, 0.00834361f, -0.00272497f, 
    -0.02377199f, -0.00330814f, 0.07004142f, -0.03074010f, 0.03351778f, -0.01685085f, 0.03481106f, 0.20202029f, 
    0.10297265f, -0.11449046f, 0.15462726f, 0.05367307f, 0.00223474f, 0.04215157f, -0.00235648f, -0.05200582f, 
    -0.08714344f, 0.08245500f, 0.00324111f, -0.35164341f, -0.09704021f, 0.27183446f, -0.01494786f, 0.03186900f, 
    0.01323412f, 0.05898134f, 0.00200624f, 0.07870888f, -0.09614864f, -0.08606058f, -0.29258826f, -0.15186329f, 
    0.03490429f, 0.04412447f, 0.04138793f, -0.00315290f, -0.07794878f, -0.02141833f, 0.16217375f, -0.03829835f, 
    0.10291139f, 0.07170532f, 0.08732575f, 0.00395345f, 0.03536871f, 0.18473025f, 0.02933766f, -0.05939178f, 
    -0.34191602f, 0.06718223f, -0.28081691f, -0.49921426f, 0.07331500f, -0.04736443f, 0.01956732f, -0.01845317f, 
    -0.01052205f, -0.08994246f, -0.00143148f, 0.11442822f, -0.04844314f, -0.09283003f, 0.14018284f, -0.05076354f, 
    -0.04927053f, 0.11866041f, 0.05091281f, -0.11506887f, -0.22089739f, -0.04931648f, -0.26784641f, -0.08837515f, 
    0.05612925f, 0.16355136f, -0.00054121f, 0.02839197f, 0.00961274f, -0.02423483f, 0.02298959f, -0.01888887f, 
    0.00839718f, -0.01110686f, 0.02336901f, 0.05610103f, 0.07251740f, 0.02641177f, -0.10660194f, -0.03978656f, 
    -0.37192577f, 0.04482678f, 0.18956345f, -0.27166405f, -0.19747713f, -0.04397243f, -0.00215974f, 0.05832161f, 
    0.00863653f, -0.13553081f, -0.04736984f, -0.01240904f, -0.04024784f, -0.07111795f, -0.04404806f, 0.07404649f, 
    -0.00096456f, -0.18844673f, -0.00507117f, 0.02684833f, -0.20840491f, -0.03159794f, -0.02518102f, -0.14583832f, 
    -0.17380275f, -0.02359721f, -0.00012673f, 0.03386458f, -0.03219734f, 0.16554129f, 0.12441690f, 0.04453261f, 
    -0.04708688f, -0.09168644f, -0.04788336f, -0.04112826f, 0.04268793f, 0.02704049f, 0.07421457f, 0.05857196f, 
    0.36955580f, 0.12681757f, 0.03083624f, -0.12604769f, 0.14894509f, 0.03552950f, 0.06083245f, 0.04992779f, 
    -0.04804352f, 0.00390453f, 0.02321825f, 0.06920395f, 0.02947944f, -0.01919352f, -0.01763676f, -0.21874145f, 
    -0.18920068f, -0.19246510f, -0.02145474f, -0.21165939f, -0.36588162f, 0.28267840f, -0.15240119f, 0.20977522f, 
    -0.08885976f, 0.04240426f, -0.06732927f, -0.16634730f, 0.13517520f, 0.01565992f, 0.15868384f, -0.01909465f, 
    -0.16223046f, -0.01503203f, 0.10818636f, -0.03791484f, 0.12992367f, 0.10841951f, -0.10819173f, 0.05723931f, 
    -0.16988854f, -0.02402639f, 0.15003863f, -0.19301718f, -0.11172142f, -0.14274111f, 0.14438836f, 0.14313717f, 
    -0.13199399f, 0.14568999f, 0.11025877f, 0.00544042f, -0.06020601f, 0.05379118f, 0.04056422f, 0.03750311f, 
    -0.03545083f, -0.05907974f, 0.05768346f, 0.08807519f, -0.50396007f, 0.28467607f, 0.24390370f, -0.11584169f, 
    0.01578009f, 0.02488530f, -0.00762170f, -0.07439636f, 0.11753219f, -0.03562924f, -0.06437807f, -0.05079382f, 
    -0.02033219f, 0.03106160f, -0.03326330f, -0.02628584f, -0.14000325f, -0.02383000f, 0.03370389f, -0.12879205f, 
    -0.26433098f, 0.63757730f, -0.19153911f, 0.14707217f, 0.04703862f, -0.06712028f, -0.10662452f, -0.03184718f, 
    0.03940999f, -0.02011508f, -0.04914062f, 0.08001750f, 0.03858570f, 0.13886327f, -0.01202445f, -0.13903326f, 
    -0.11550543f, 0.08743703f, 0.16089037f, 0.05897870f, 0.18351059f, -0.41763505f, -0.25091475f, -0.12548265f, 
    -0.03833972f, 0.14601023f, -0.07848804f, -0.13552919f, -0.01598975f, 0.10245144f, -0.05907565f, 0.22544244f, 
    -0.10156098f, -0.00591607f, 0.03631121f, -0.04902989f, -0.07110441f, 0.00710202f, 0.02701039f, 0.16528153f, 
    -0.09063800f, -0.09168974f, -0.03695855f, 0.02828224f, -0.07017410f, 0.01070907f, 0.00584694f, -0.23239355f, 
    -0.15749766f, 0.08341388f, 0.19130041f, 0.08813605f, 0.01908137f, -0.14037988f, 0.11671274f, 0.04399287f, 
    -0.09536839f, -0.01817661f, 0.16752842f, 0.13714997f, -0.29487798f, 0.01276695f, -0.07195465f, -0.20340022f, 
    -0.37402794f, -0.06477747f, -0.09585176f, 0.05964063f, -0.12511306f, -0.14580245f, -0.00796131f, -0.02220204f, 
    -0.06376953f, 0.01007067f, 0.04945046f, -0.24789637f, -0.16301844f, -0.07197565f, -0.16446748f, -0.09069586f, 
    -0.04610126f, 0.43134567f, -0.33473170f, 0.07814572f, 0.10104869f, -0.03215616f, -0.04927673f, -0.02708233f, 
    -0.11833353f, 0.04147365f, 0.15019767f, -0.07834608f, 0.06051299f, 0.06516489f, -0.12196376f, 0.09014307f, 
    -0.12887073f, 0.18392582f, 0.17433070f, 0.10853516f, -0.28257385f, -0.02273072f, 0.15695308f, 0.07790374f, 
    -0.40583241f, 0.09077177f, -0.04109863f, -0.03046003f, -0.00450584f, 0.26598683f, -0.04326220f, 0.11042138f, 
    -0.03690019f, -0.03345090f, -0.01738902f, -0.14620626f, -0.26128176f, 0.13038792f, -0.01669073f, -0.02685869f, 
    -0.57221782f, -0.30267760f, -0.19408838f, -0.10716463f, -0.19661783f, -0.13330735f, -0.09139664f, -0.13550152f, 
    -0.03991139f, -0.20587435f, 0.04083211f, -0.01091519f, -0.02950353f, -0.07512134f, 0.03642940f, 0.00334740f, 
    0.03443124f, 0.00231407f, 0.09966136f, -0.04023927f, -0.33089665f, -0.16530132f, -0.69487429f, -0.36299559f, 
    -0.28501049f, -0.22090979f, 0.09314581f, -0.01169658f, 0.02779660f, -0.18592547f, 0.06665847f, -0.05235960f, 
    -0.03709611f, 0.01513045f, 0.01943259f, -0.01481621f, 0.01255973f, 0.08896193f, 0.00565219f, -0.02864235f, 
    -0.74216288f, -0.61769545f, -0.71684384f, -0.28527880f, 0.31476620f, -0.07162961f, 0.05858011f, 0.05673547f, 
    -0.02827881f, -0.30038404f, 0.02244043f, -0.02011397f, -0.05264560f, 0.00320254f, 0.05780257f, -0.01736733f, 
    0.00247676f, 0.11167675f, 0.15257345f, 0.00119692f, -0.21587780f, 0.20667124f, 0.01960699f, -0.02874155f, 
    0.23393346f, -0.03590593f, -0.01588734f, 0.02112198f, 0.03322772f, -0.06594529f, 0.11716854f, 0.10720316f, 
    0.04942338f, 0.07374823f, 0.05311208f, 0.09487759f, -0.00920921f, 0.03649591f, 0.04480641f, 0.02367154f, 
    -0.51376468f, 0.57205296f, 0.21901423f, 0.02391597f, 0.29452911f, -0.18585473f, -0.03268631f, -0.05778679f, 
    0.08013552f, 0.13524267f, 0.07242540f, 0.02864582f, 0.02650134f, -0.02177963f, 0.01569960f, 0.03801793f, 
    -0.00802315f, 0.02750622f, 0.10560203f, -0.02424085f, -0.09387561f, 0.29101092f, 0.05809700f, -0.04142407f, 
    -0.00175456f, -0.12773640f, -0.09180380f, -0.08940835f, 0.04036838f, 0.09019636f, -0.03412589f, -0.02763750f, 
    -0.03096253f, 0.03554897f, 0.00745499f, 0.04516542f, -0.06795812f, -0.05022885f, 0.03399110f, -0.09080674f, 
    -0.24223800f, -0.29876330f, -0.04892195f, -0.08782700f, 0.42500013f, -0.11459721f, -0.16582224f, -0.03880249f, 
    -0.05793041f, 0.09560342f, -0.02484564f, 0.03682692f, 0.03144250f, 0.03854941f, -0.02043269f, 0.01830538f, 
    0.02445077f, 0.01937174f, 0.05315639f, 0.00735274f, -0.34923306f, -0.32445225f, -0.72680479f, -0.24370115f, 
    -0.16181785f, -0.01725941f, -0.13851233f, -0.21165824f, -0.06759942f, -0.20284674f, -0.01157288f, 0.01667823f, 
    -0.02766765f, -0.02036159f, -0.06332078f, -0.07460874f, -0.02537565f, 0.13945594f, 0.06349119f, -0.04960142f, 
    -0.38282716f, -0.40109408f, -0.53612655f, -0.11878905f, 0.04753609f, -0.11636995f, -0.03909533f, -0.05468530f, 
    -0.10925636f, -0.25801831f, 0.01420754f, -0.01184045f, -0.03813428f, -0.05512489f, -0.01106901f, 0.02353740f, 
    0.00233724f, 0.07628144f, 0.11322404f, 0.05442459f, -0.15549476f, -0.13769297f, 0.02266076f, 0.01538343f, 
    0.04821936f, -0.12884372f, -0.02728374f, -0.06301644f, -0.03848757f, -0.02500705f, 0.17884785f, -0.07802434f, 
    0.01868759f, 0.01173001f, 0.01315254f, -0.01896402f, -0.04644976f, -0.04348699f, 0.02675830f, -0.15739155f, 
    -0.42950237f, -0.53104067f, -0.50660461f, -0.21932676f, 0.30747476f, 0.01244207f, -0.12385742f, 0.04820937f, 
    -0.27084053f, -0.17119548f, -0.00921880f, -0.00999680f, -0.01201435f, 0.07525158f, 0.01033306f, -0.00391940f, 
    -0.01680822f, -0.06332727f, 0.20601359f, 0.12086052f, -0.02796604f, 0.02253064f, -0.01211862f, 0.10020952f, 
    0.04521448f, -0.02198061f, 0.08559511f, -0.02822135f, -0.01350145f, 0.07968380f, 0.02273290f, -0.05191264f, 
    0.02763089f, -0.07858495f, 0.00438372f, 0.09927287f, 0.00189528f, -0.05809580f, 0.02985713f, 0.00228984f, 
    -0.18234481f, 0.59002906f, -0.15463434f, 0.05067579f, 0.25836715f, -0.05842567f, -0.04029259f, -0.03981730f, 
    0.06158611f, -0.02589311f, 0.07353286f, 0.10925861f, -0.00959622f, 0.11426790f, 0.13480671f, 0.08388209f, 
    -0.09068946f, 0.07562219f, -0.05894010f, 0.01434401f, -0.22616293f, 0.03651560f, 0.29106948f, -0.00613056f, 
    0.03307189f, -0.00355602f, -0.02075519f, -0.13828690f, -0.09445961f, 0.21743454f, -0.15100890f, 0.05085685f, 
    0.07750539f, 0.00514456f, -0.15637854f, 0.02781822f, 0.05867385f, -0.07197694f, 0.07872573f, 0.04090864f, 
    0.10124167f, -0.05266275f, -0.20047523f, -0.18542454f, 0.11850396f, -0.04515658f, 0.02148311f, 0.12138559f, 
    0.15203264f, -0.04300819f, 0.02308793f, -0.07949612f, -0.07210909f, -0.01483270f, -0.00705396f, -0.01507198f, 
    -0.02048491f, 0.02104130f, 0.07142092f, -0.02083220f, -0.10061498f, 0.26968288f, -0.26258522f, -0.05047288f, 
    -0.00520786f, -0.00506978f, 0.03814163f, 0.05947561f, 0.12140388f, 0.12374761f, 0.12164519f, -0.07742261f, 
    0.08141781f, 0.07328959f, 0.08711898f, 0.04146542f, 0.10991511f, -0.01704623f, 0.02717533f, 0.10791665f, 
    -0.12873624f, -0.05525019f, -0.07546640f, -0.37315303f, -0.06438787f, -0.01120121f, -0.00974727f, 0.09889001f, 
    -0.00310297f, -0.02771979f, 0.01849693f, -0.02049929f, 0.00354028f, -0.04206304f, -0.03214738f, 0.04395990f, 
    0.12746963f, -0.02036902f, -0.10023884f, 0.19601062f, 0.05829218f, -0.18500295f, -0.12719294f, -0.18750802f, 
    0.22110108f, -0.13587070f, 0.04530609f, 0.18265325f, 0.11897079f, 0.05272697f, 0.02853667f, 0.07345616f, 
    0.03965755f, -0.19291429f, 0.04969335f, -0.01251827f, -0.01951920f, -0.06521150f, 0.11732095f, 0.00855905f, 
    -0.25259635f, -0.10087671f, 0.15951510f, -0.18615843f, -0.12218216f, -0.01679120f, -0.05841887f, -0.05606772f, 
    -0.03861356f, -0.02361981f, -0.02818255f, -0.07054202f, -0.03816324f, -0.00948956f, -0.06876453f, 0.04043821f, 
    0.14513214f, 0.12713398f, -0.05012078f, 0.03819437f, -0.06981605f, -0.18731228f, 0.19004045f, 0.11847384f, 
    0.22613822f, -0.07799152f, 0.07229424f, 0.00693061f, -0.02581126f, -0.01635518f, 0.03794059f, 0.01832510f, 
    0.04819572f, 0.02130952f, -0.05855618f, 0.00762442f, 0.04313055f, -0.01002604f, 0.05967417f, -0.06036957f, 
    -0.01268507f, -0.08549702f, 0.08920597f, -0.01660241f, 0.03007931f, -0.05709856f, 0.05833808f, -0.11839381f, 
    0.04495397f, -0.06203231f, 0.04402546f, -0.07212559f, 0.00742360f, -0.05460440f, 0.03650867f, -0.01933255f, 
    -0.00018656f, 0.05944043f, 0.03364693f, -0.18668431f, -0.06078590f, 0.04053432f, 0.09967439f, -0.10042441f, 
    0.22779313f, -0.04192618f, -0.01439454f, -0.04584275f, 0.07129022f, -0.01133269f, 0.06062590f, 0.05432210f, 
    0.05021939f, 0.02274432f, -0.08254251f, 0.06423574f, 0.11327430f, -0.01376843f, 0.04778552f, 0.02943302f, 
    0.05225156f, -0.02339095f, -0.02047173f, -0.08180188f, -0.01136956f, 0.00464711f, -0.01006687f, 0.02602836f, 
    -0.03616194f, 0.02711164f, -0.18592110f, -0.04405119f, -0.12220152f, -0.06764857f, -0.05877748f, -0.05454727f, 
    -0.01954561f, -0.03916441f, -0.01065241f, 0.01775351f, -0.03610592f, 0.13370052f, -0.01305193f, -0.10970223f, 
    0.06700160f, -0.00875840f, 0.04030838f, 0.03690659f, -0.06242426f, 0.03931867f, 0.02270594f, -0.00724799f, 
    -0.07109456f, 0.00551242f, -0.00306667f, 0.07453997f, -0.00949089f, -0.01819075f, 0.00708042f, 0.02729938f, 
    -0.48953870f, 0.39027506f, 0.46629062f, -0.01825377f, 0.27583775f, -0.08953142f, -0.14790855f, -0.03468101f, 
    -0.14955671f, 0.25363538f, -0.04791865f, 0.05854102f, 0.01233706f, 0.08132903f, 0.07588252f, 0.01461925f, 
    0.04102292f, -0.00401692f, 0.03510021f, 0.02712064f, 0.30958951f, -0.04233432f, -0.04991411f, -0.00259897f, 
    -0.01716498f, -0.01690547f, 0.07673465f, 0.20134972f, 0.24160707f, -0.08483420f, 0.09298564f, 0.09443432f, 
    -0.02186694f, -0.13636889f, 0.03459294f, 0.05075161f, 0.01045492f, 0.01257929f, -0.25605410f, 0.02054103f, 
    0.09606330f, -0.11195470f, -0.10093911f, -0.07754175f, 0.09061797f, 0.01296324f, 0.07916307f, 0.09928539f, 
    0.01993432f, 0.05393560f, -0.06122304f, -0.04579059f, -0.12376849f, -0.01383627f, 0.00635829f, -0.12412138f, 
    -0.08785579f, -0.12351830f, 0.03000080f, -0.00332648f, -0.02971478f, -0.26509681f, -0.44343299f, -0.39211461f, 
    0.19854648f, -0.14375612f, 0.06824790f, 0.04836009f, -0.02221349f, -0.01917321f, 0.00720862f, -0.05058736f, 
    -0.03498983f, 0.07724124f, 0.03908433f, 0.00893361f, 0.03781901f, -0.09142653f, 0.16041422f, -0.05603853f, 
    -0.02823834f, -0.00398369f, 0.00139708f, -0.04183520f, -0.00400823f, -0.00699709f, 0.02340736f, 0.01162075f, 
    0.00665680f, 0.06140560f, 0.06171264f, 0.05423904f, 0.01349727f, 0.02169796f, 0.00243345f, -0.00673804f, 
    0.01222684f, -0.06261961f, 0.01382811f, -0.03983487f, 0.36113000f, 0.03618849f, -0.18570787f, -0.16684367f, 
    -0.07887745f, 0.04181985f, 0.07071463f, 0.19169892f, 0.15259138f, -0.07885415f, 0.12557562f, 0.00937981f, 
    -0.02387146f, -0.26459104f, 0.05133095f, 0.08445764f, 0.02498360f, -0.09133740f, -0.01834466f, 0.04991787f, 
    -0.50150275f, -0.28133994f, -0.10565989f, -0.04692122f, 0.02538890f, -0.12866670f, -0.00912008f, -0.01712698f, 
    -0.00772869f, -0.00452719f, 0.04775662f, -0.05382350f, 0.07901501f, -0.11824618f, 0.00441777f, 0.01987941f, 
    0.00295181f, -0.01604926f, 0.15872782f, -0.16460124f, -0.61379057f, -0.66310805f, -0.47678086f, 0.20552938f, 
    -0.13172576f, -0.13548534f, 0.22106439f, -0.05236319f, 0.11517493f, -0.55883759f, 0.00564126f, -0.02179838f, 
    0.01517975f, 0.02291437f, 0.09118858f, -0.02091192f, 0.01711851f, 0.21999128f, -0.00631240f, 0.00521688f, 
    0.04685538f, -0.12101955f, -0.20643373f, -0.02727062f, 0.08609357f, -0.01633379f, 0.04815593f, 0.09933180f, 
    0.02843445f, 0.02855250f, 0.02094182f, -0.01713931f, -0.10383738f, -0.03538522f, 0.04943130f, 0.13700950f, 
    0.13086031f, -0.08966310f, -0.02701931f, 0.06811421f, 0.40299338f, 0.37595454f, -0.24554534f, -0.06151935f, 
    -0.09934016f, 0.02661477f, -0.11084551f, 0.06426471f, 0.12278417f, -0.01789212f, 0.22242096f, 0.05409377f, 
    0.09282041f, -0.16439243f, -0.00490927f, -0.01660359f, 0.17650703f, -0.22409770f, 0.11159997f, 0.12308133f, 
    -0.33434364f, -0.44630894f, -0.10734727f, 0.11501800f, 0.20935057f, 0.07128177f, 0.19516611f, -0.06382356f, 
    0.00607964f, -0.14597861f, 0.13950536f, -0.04417386f, -0.13726585f, 0.12738876f, -0.02832703f, 0.02731351f, 
    0.01352419f, -0.07936990f, 0.19980092f, 0.00465179f, -0.13920125f, -0.01600997f, 0.28918567f, 0.11617169f, 
    0.05708311f, -0.05852704f, -0.05235923f, -0.00374565f, -0.05666905f, 0.07753008f, -0.08776269f, 0.05845483f, 
    0.06904520f, -0.00161551f, 0.08159336f, 0.00778437f, 0.02989887f, -0.04648233f, -0.00581125f, 0.04060110f, 
    -0.51212269f, -0.05255411f, 0.20129803f, 0.04547793f, -0.22882929f, -0.04792528f, -0.16041343f, -0.07978400f, 
    -0.12530239f, 0.03459042f, -0.01109296f, 0.05773593f, -0.03810091f, 0.05386626f, -0.00204158f, -0.01617836f, 
    -0.02013741f, 0.10807509f, -0.06142740f, 0.01657706f, -0.40700585f, -0.58263570f, -0.33283553f, -0.01381387f, 
    -0.05697716f, 0.01757541f, -0.04285390f, -0.07802531f, -0.15504448f, -0.14675491f, -0.06139058f, -0.00352160f, 
    -0.00756636f, -0.14833114f, -0.03985708f, 0.02685682f, -0.02228671f, -0.01343350f, 0.14439625f, -0.06950251f, 
    -0.29886809f, -0.12668872f, 0.02326374f, 0.06009495f, -0.12280323f, 0.10846737f, 0.00412899f, -0.19411811f, 
    -0.08135493f, -0.28024316f, -0.08437467f, 0.00514096f, -0.08260703f, 0.03646847f, -0.01139652f, -0.00156528f, 
    -0.01281127f, 0.24565299f, -0.28191835f, -0.11298376f, 0.03670734f, 0.12364151f, -0.01190468f, -0.03528108f, 
    -0.02896408f, 0.04873499f, -0.01024880f, -0.04923621f, -0.05116928f, 0.05587696f, -0.00002948f, -0.09962591f, 
    -0.00382994f, -0.00930245f, -0.08215430f, -0.04713371f, 0.03830526f, -0.11120095f, -0.02631840f, 0.05530452f, 
    -0.34083116f, -0.46471995f, -0.42036298f, 0.04550284f, -0.06124209f, 0.01975074f, -0.05265699f, 0.03752980f, 
    -0.12816083f, -0.16449906f, -0.00605263f, -0.00933143f, -0.02894125f, 0.04465272f, 0.03129290f, -0.02195663f, 
    -0.03311132f, 0.13739288f, 0.16588280f, 0.01505756f, 0.16730936f, 0.21967208f, -0.39945304f, -0.23037834f, 
    0.17612784f, -0.07463377f, -0.04798346f, -0.08079167f, 0.28225732f, 0.08440496f, -0.02433631f, 0.01495085f, 
    -0.04019384f, -0.00283210f, -0.00889147f, -0.03818776f, 0.00665987f, 0.03703900f, 0.04606255f, -0.07973314f, 
    0.17875911f, 0.09714371f, 0.04689128f, 0.12846647f, -0.01180636f, 0.08146267f, 0.06021642f, 0.03008353f, 
    -0.04220153f, -0.08642627f, 0.03182115f, 0.13037264f, -0.04811631f, 0.01948225f, 0.04847836f, 0.05024288f, 
    -0.05225366f, -0.01134342f, -0.26224083f, -0.01923655f, -0.44808814f, -0.70302564f, -0.70573586f, -0.15588953f, 
    0.04775802f, -0.17676730f, 0.01715156f, -0.02398258f, -0.10790170f, -0.56728780f, 0.03838641f, -0.03961648f, 
    -0.01090840f, 0.05580226f, 0.09258664f, -0.03961348f, 0.02799192f, 0.12652475f, 0.14011356f, 0.03892442f, 
    -0.43132699f, 0.47819868f, 0.39297864f, -0.00003408f, 0.19344352f, -0.08804079f, 0.00404236f, -0.10943479f, 
    0.00044897f, 0.14526121f, 0.04043831f, 0.04771907f, 0.00209801f, 0.06278556f, 0.03925168f, 0.02388829f, 
    -0.04546217f, 0.01469508f, -0.01882817f, -0.02698628f, 0.18521632f, -0.16288066f, -0.12611763f, -0.13135308f, 
    0.04602386f, -0.00908886f, 0.10289142f, 0.10606994f, -0.10203952f, -0.01111624f, -0.02227499f, -0.08370661f, 
    -0.06832901f, -0.03673754f, 0.02419021f, -0.10160590f, -0.06520722f, -0.16439043f, 0.01946807f, 0.10493106f, 
    0.01176083f, 0.23415622f, -0.02896073f, -0.03431189f, -0.01633383f, -0.12853985f, -0.07904069f, -0.22031660f, 
    -0.05548619f, -0.20260966f, -0.02923590f, -0.14586902f, -0.07314939f, -0.02712269f, 0.04639190f, -0.02545366f, 
    -0.04366513f, 0.07571371f, -0.08075703f, -0.16328545f, -0.54524678f, -0.37516302f, -0.43518844f, 0.00967432f, 
    0.14713199f, -0.14254794f, -0.07259244f, 0.03211336f, 0.01366034f, -0.03907334f, 0.03659568f, -0.01899632f, 
    0.00511864f, -0.03641389f, 0.00546526f, 0.01325910f, 0.02557454f, 0.00808692f, 0.19493602f, -0.03742074f, 
    -0.01724529f, 0.09798332f, 0.03294946f, 0.00674383f, 0.07943246f, -0.11014374f, -0.06062121f, -0.06038951f, 
    0.03027216f, 0.08548451f, -0.06245640f, -0.09740341f, -0.13822211f, 0.18627343f, -0.04759872f, -0.02790667f, 
    -0.09635743f, -0.08278613f, -0.02145279f, 0.06448045f, 0.04756696f, 0.07080105f, 0.02446751f, -0.05652572f, 
    -0.03117009f, 0.03092633f, -0.02800471f, -0.03562292f, -0.02560594f, 0.00482686f, -0.06541296f, 0.08724230f, 
    0.04570828f, 0.02473949f, 0.06010107f, 0.06397737f, -0.06014583f, 0.03520012f, -0.12076590f, 0.02139975f, 
    -0.22822037f, 0.19063485f, 0.15531164f, -0.06348331f, 0.24654403f, -0.03075856f, 0.00222714f, -0.00795583f, 
    0.02703664f, -0.01267530f, 0.14339314f, 0.13641888f, 0.15841761f, 0.18043996f, 0.06919371f, 0.06872498f, 
    0.06123831f, 0.06890092f, -0.00201878f, 0.06240675f, 0.17089766f, -0.20799723f, -0.19858320f, -0.18273017f, 
    0.10057425f, 0.03147093f, 0.13599704f, 0.08723807f, -0.08166172f, -0.00507433f, -0.01816536f, -0.03793810f, 
    -0.00949448f, -0.01784863f, 0.02271143f, -0.04165957f, -0.02694403f, -0.02284530f, 0.04868104f, 0.09521309f, 
    0.24475966f, -0.19979213f, -0.02057780f, 0.10707328f, -0.21347247f, 0.04472083f, 0.05324277f, -0.07334933f, 
    0.02457424f, 0.10366289f, -0.04810283f, 0.05240311f, 0.06331431f, 0.07675644f, -0.12333856f, -0.03775490f, 
    0.13276219f, 0.16697289f, -0.02110096f, -0.01440385f, -0.46885237f, 0.36166513f, 0.33116898f, -0.13113402f, 
    -0.04671611f, -0.08008662f, -0.08428321f, -0.09303404f, -0.09503678f, 0.20562971f, -0.16147898f, 0.04345607f, 
    -0.00645771f, 0.09996249f, 0.05923076f, 0.02874484f, -0.01649608f, -0.05156789f, -0.04208985f, 0.00375480f, 
    -0.18807866f, -0.31543580f, -0.15838833f, 0.11062156f, -0.30200994f, -0.00541792f, 0.16981930f, 0.12998238f, 
    0.08878548f, -0.23928596f, 0.02588921f, 0.00100482f, -0.01184907f, 0.00485215f, 0.03686210f, 0.03914852f, 
    -0.03263938f, 0.09959496f, -0.01277940f, 0.01617701f, -0.23469004f, -0.00825435f, -0.06119815f, -0.00743657f, 
    0.20013499f, -0.08560396f, 0.08405382f, 0.01608127f, -0.00795932f, 0.20021407f, 0.03489107f, 0.07872199f, 
    0.21087639f, 0.00781388f, 0.06065451f, -0.14791964f, 0.13468175f, -0.06914348f, 0.06860005f, -0.03868578f, 
    -0.13879772f, 0.23110454f, 0.25504181f, 0.01974627f, 0.04364132f, 0.04483128f, -0.26528883f, 0.01527976f, 
    -0.04216516f, -0.12637468f, 0.01125593f, 0.00384482f, -0.00146667f, 0.16212490f, 0.00528729f, 0.01109448f, 
    0.03258082f, 0.10204016f, -0.33621451f, 0.04334799f, -0.09147319f, -0.11204805f, 0.06377140f, -0.03572709f, 
    -0.15038341f, -0.02527164f, -0.00028708f, -0.00514373f, -0.02900119f, 0.03614571f, -0.02239837f, -0.00119532f, 
    0.03570478f, 0.07863257f, -0.01748591f, 0.03666637f, 0.03857592f, 0.06273837f, -0.02151211f, 0.01709582f, 
    -0.04375482f, -0.07330218f, 0.15179108f, -0.06895319f, 0.06284279f, -0.03851172f, 0.05720707f, 0.03337520f, 
    -0.02668819f, 0.07534096f, 0.07030398f, 0.10384072f, 0.02417688f, 0.22240685f, 0.01695593f, 0.03465053f, 
    0.07617486f, -0.01119787f, 0.04498643f, 0.09757137f, -0.20701866f, 0.35416326f, 0.09089714f, -0.08181676f, 
    0.16429868f, -0.04033829f, -0.00526852f, -0.03616364f, -0.02236445f, 0.24034563f, -0.05720997f, 0.12285120f, 
    -0.03971057f, 0.12179706f, 0.02174877f, 0.04981266f, -0.01623121f, -0.05968169f, 0.04772143f, 0.02585041f, 
    0.02530026f, 0.09806339f, 0.02720261f, 0.01276827f, 0.05164665f, 0.10417642f, -0.06577150f, 0.00380459f, 
    0.01541775f, 0.06137642f, -0.02445701f, 0.12871282f, -0.04288625f, 0.14892969f, -0.01810401f, 0.01100979f, 
    0.03251469f, 0.04538034f, -0.18346106f, 0.11107326f, -0.20860974f, -0.69568115f, -0.56041759f, -0.30843240f, 
    0.24452293f, -0.08089595f, -0.02458034f, 0.00679416f, -0.12355531f, 0.07068891f, -0.02559744f, 0.03821161f, 
    0.01417594f, -0.05652852f, -0.31907591f, 0.06169406f, 0.10826313f, -0.00515613f, 0.11318395f, 0.05564082f, 
    0.00341237f, -0.01412099f, 0.18297327f, 0.00165713f, 0.05241784f, 0.02039605f, 0.02756043f, 0.09332733f, 
    0.03498752f, -0.02967666f, 0.05949194f, 0.06340341f, -0.00787996f, 0.06789502f, 0.01717279f, 0.01465648f, 
    -0.01264500f, 0.03687366f, -0.08012637f, 0.05866463f, -0.38583767f, -0.09893819f, -0.81387806f, -0.16915713f, 
    0.16431487f, -0.07554699f, 0.18681307f, 0.16670756f, -0.00361375f, 0.00852892f, -0.05298956f, -0.00030321f, 
    0.00155214f, -0.01784213f, 0.05174843f, 0.00211747f, 0.00955381f, -0.15066543f, 0.08223128f, -0.10714029f, 
    -0.27322102f, -0.53059125f, -0.28737494f, 0.09838051f, 0.07242687f, -0.03510983f, 0.04654522f, 0.04681920f, 
    0.08373602f, -0.05105057f, 0.01182820f, 0.11970261f, 0.03951067f, 0.00535305f, 0.03136332f, 0.02398876f, 
    0.05767956f, 0.00669649f, -0.03439528f, -0.05668619f, -0.75715828f, -0.41909957f, -0.33658889f, 0.10656418f, 
    0.34305358f, -0.00767980f, -0.05671712f, 0.17282635f, -0.00659387f, -0.01165579f, -0.00038582f, 0.05540746f, 
    -0.03742732f, -0.04133926f, -0.03237511f, 0.01810227f, 0.04606247f, -0.00935337f, 0.08745501f, -0.09265979f, 
    -0.17319432f, -0.42884192f, -0.05472638f, 0.43033937f, -0.21759287f, -0.00150634f, 0.00637584f, 0.05109401f, 
    -0.02779831f, 0.10552710f, -0.02474649f, 0.00164661f, 0.00792278f, -0.00877810f, -0.07057399f, 0.00427827f, 
    -0.02720646f, -0.11476362f, 0.03679786f, 0.02967883f, -0.24412821f, -0.13530025f, 0.09607508f, 0.15440235f, 
    0.03275365f, 0.04458847f, 0.00135446f, 0.18968143f, -0.02038469f, 0.02439793f, -0.10700016f, 0.08191285f, 
    0.02754378f, 0.07159433f, 0.04707534f, -0.03220747f, -0.02949044f, -0.00031110f, -0.00205052f, 0.10763137f, 
    0.23635213f, -0.44704479f, -0.59808373f, -0.31760240f, -0.26018378f, 0.05563362f, -0.16191459f, 0.15275413f, 
    0.12594248f, -0.09010797f, -0.03717139f, 0.09082390f, -0.00848804f, 0.01693772f, 0.02498424f, 0.03323785f, 
    0.03689461f, 0.01482417f, 0.03671541f, 0.03295400f, 0.04987910f, -0.09177056f, -0.11879519f, 0.00658278f, 
    -0.09695816f, 0.04516005f, 0.02053244f, 0.02331520f, 0.03986852f, 0.01787022f, -0.16588518f, -0.01361167f, 
    0.09056186f, 0.00972293f, -0.00648266f, 0.01814960f, 0.01785582f, 0.02931557f, -0.02149848f, -0.02898611f, 
    0.36016920f, -0.40324688f, -0.41430271f, -0.52173412f, -0.32241845f, 0.05767703f, 0.06827682f, -0.05097883f, 
    0.16134758f, -0.03708578f, -0.00968767f, -0.00788973f, -0.01159760f, -0.00324181f, -0.01843052f, -0.05700920f, 
    -0.00160031f, -0.00332100f, -0.01600080f, 0.00713025f, -0.06721563f, -0.37091821f, 0.13573545f, -0.33137175f, 
    -0.03423557f, -0.02972437f, 0.05208503f, -0.06743605f, 0.15219070f, 0.22731096f, 0.01189968f, 0.02305403f, 
    -0.01243552f, -0.07460134f, 0.00530252f, -0.03063515f, 0.06082708f, -0.02887289f, 0.03099865f, -0.09553441f, 
    -0.16215672f, -0.33353215f, -0.12470569f, 0.20722841f, -0.01505644f, -0.01758982f, 0.05667379f, -0.05428588f, 
    0.06156296f, 0.10154397f, -0.00364348f, -0.00288811f, -0.00197113f, -0.06793451f, -0.02447888f, -0.04541101f, 
    0.02274510f, -0.08695063f, 0.04023172f, -0.09133357f, 0.09477876f, -0.09302590f, -0.01243346f, 0.09866361f, 
    -0.01401171f, 0.06276874f, 0.03501458f, 0.06219812f, -0.02274472f, -0.04282637f, 0.00153366f, -0.15677577f, 
    0.11965065f, 0.05204511f, 0.01824502f, 0.03740225f, 0.00579037f, 0.05203701f, 0.03367797f, -0.00840512f, 
    0.24304056f, -0.39846444f, -0.30061552f, 0.44483298f, -0.14915662f, 0.17401198f, 0.04085437f, 0.03098683f, 
    0.04896102f, 0.09915669f, 0.05676734f, 0.01160002f, 0.03335672f, -0.02967007f, -0.06254405f, 0.01991831f, 
    -0.00141456f, -0.06605873f, 0.07849525f, -0.04956221f, 0.10826381f, 0.12791963f, -0.01449957f, -0.03058926f, 
    -0.01126802f, 0.04449667f, 0.05165626f, -0.08024203f, -0.01776310f, -0.12089770f, -0.03396843f, 0.06577775f, 
    0.05645317f, -0.02903005f, -0.00621126f, -0.07822156f, -0.04054578f, 0.05547118f, -0.03462552f, -0.01817009f, 
    -0.45410857f, -0.47589460f, 0.46919924f, -0.20069340f, 0.35719523f, -0.02725486f, -0.04090421f, 0.10897630f, 
    -0.01049916f, -0.02804806f, -0.05441795f, 0.03001003f, -0.02985987f, 0.01479695f, 0.01571665f, -0.02789025f, 
    -0.03667252f, -0.01211881f, 0.00440565f, -0.01737792f, 0.32090157f, 0.02486498f, -0.35068256f, -0.43260145f, 
    -0.03571175f, 0.08793470f, 0.00621752f, -0.18411617f, 0.02011626f, 0.10853573f, -0.05403235f, 0.04639892f, 
    -0.06820258f, 0.00261310f, 0.06103780f, 0.01118462f, 0.01988941f, -0.00547648f, 0.00665559f, 0.03645283f, 
    -0.04068162f, 0.04821453f, -0.09447018f, 0.06933539f, -0.12244469f, 0.02039725f, -0.03331411f, 0.03097130f, 
    0.03849543f, 0.01499627f, 0.08860294f, 0.00627318f, 0.06166179f, -0.00477008f, 0.03188777f, 0.09298765f, 
    -0.05524036f, 0.06541869f, -0.01230237f, 0.06642914f, 0.09537125f, -0.28078872f, 0.04386578f, 0.03060181f, 
    0.05560517f, 0.02022555f, 0.05164079f, 0.13511989f, -0.21689296f, 0.01370425f, -0.04203993f, 0.04231169f, 
    0.01524106f, 0.00887789f, -0.05617008f, -0.00041525f, -0.00489866f, -0.05940681f, -0.03740237f, 0.02417530f, 
    -0.09314702f, 0.14781691f, -0.12983739f, 0.00387943f, -0.11961625f, -0.03110727f, 0.03724862f, 0.07273421f, 
    -0.07123818f, -0.02079586f, 0.05839532f, 0.05894650f, 0.02026633f, -0.02475776f, 0.01415456f, 0.07034093f, 
    -0.01459503f, -0.01751460f, -0.13489419f, 0.07684834f, 0.07121398f, 0.06216737f, -0.19420168f, 0.04452037f, 
    -0.22721709f, 0.06020092f, -0.03119485f, 0.10442510f, -0.06733890f, 0.01724749f, 0.03129085f, 0.02643329f, 
    0.03885048f, 0.02155288f, 0.00607877f, 0.05689732f, -0.07289050f, 0.07957597f, -0.11275169f, -0.00613372f, 
    0.04575377f, 0.05911502f, 0.04836909f, 0.07193916f, -0.07132845f, 0.01470089f, 0.06657942f, 0.08146462f, 
    0.03146884f, -0.02648167f, 0.08939569f, -0.02711426f, 0.04287405f, -0.09339687f, -0.05736903f, 0.09128323f, 
    -0.03455253f, 0.05044088f, 0.00768727f, 0.05296955f, 0.08410548f, 0.09000338f, -0.15603799f, 0.05636627f, 
    -0.12389672f, 0.04333553f, 0.04467415f, 0.11989628f, 0.00943030f, 0.05117854f, -0.06758264f, -0.00074322f, 
    0.00035525f, -0.13805166f, -0.10296459f, -0.01061079f, -0.05068544f, -0.07259306f, -0.03139549f, -0.00660738f, 
    0.00960851f, -0.15000734f, -0.10908792f, 0.08940477f, -0.02823440f, 0.12743349f, -0.03612382f, 0.02270066f, 
    0.00839605f, 0.08269420f, 0.10638963f, -0.06250173f, 0.14042902f, 0.03034930f, -0.02139835f, 0.01881358f, 
    -0.02694263f, -0.04968385f, -0.03249797f, -0.00819852f, -0.04901211f, 0.07876798f, -0.16885822f, 0.15306561f, 
    -0.16535501f, -0.00144027f, 0.02862555f, 0.09538514f, -0.03793852f, -0.02567606f, -0.07619800f, -0.06727722f, 
    -0.09391951f, 0.02803756f, 0.03320601f, -0.00303796f, -0.11878387f, -0.04321748f, 0.01534646f, 0.18151367f, 
    0.01333227f, 0.11396445f, 0.05818217f, 0.02561831f, -0.10562126f, 0.00342628f, -0.03002671f, 0.02358646f, 
    0.01002209f, -0.06385708f, -0.01886256f, -0.07976416f, -0.05431870f, -0.04429945f, -0.03122691f, 0.02536925f, 
    -0.04773894f, 0.08068586f, 0.04891549f, 0.04056269f, 0.02580505f, 0.13353135f, -0.23745365f, 0.04037570f, 
    -0.17005813f, 0.00116453f, 0.07853317f, 0.06002035f, -0.05673176f, -0.02093596f, -0.03642424f, 0.01620144f, 
    0.03276429f, 0.05032310f, -0.06740988f, -0.09626148f, -0.05807585f, 0.03903810f, -0.04565582f, -0.06689001f, 
    0.60447133f, -0.36620077f, -0.64719009f, -0.12403297f, -0.18984760f, -0.02296387f, -0.09432832f, -0.14312653f, 
    0.10237651f, -0.07368883f, -0.01298899f, 0.05027945f, 0.00989935f, 0.05406006f, 0.01109344f, 0.05430695f, 
    0.02652412f, -0.02404793f, 0.08538815f, 0.05847019f, -0.21403623f, 0.05960298f, 0.24547099f, 0.04654736f, 
    0.04764689f, 0.01015425f, 0.03328180f, -0.09604108f, 0.12801968f, 0.01261868f, 0.13167542f, 0.02103353f, 
    0.01091465f, -0.01070966f, 0.02183112f, 0.00282209f, -0.08828870f, -0.05604853f, -0.11739082f, -0.03470230f, 
    -0.03828814f, 0.10707241f, 0.02046049f, -0.00959952f, -0.09311031f, 0.00593076f, -0.02106335f, -0.06627151f, 
    0.02207410f, -0.02630968f, 0.03822538f, 0.02727458f, -0.00743440f, -0.03307690f, -0.01973603f, -0.11593921f, 
    -0.26077029f, 0.08187489f, 0.04380066f, 0.01010867f, -0.15363003f, -0.06697290f, -0.48094705f, 0.32846820f, 
    -0.30661011f, 0.16303505f, 0.09425031f, -0.04383385f, -0.02931375f, 0.02930061f, 0.02826236f, -0.01051896f, 
    -0.03230445f, 0.02117375f, 0.00674925f, -0.06264938f, 0.04038956f, 0.03248595f, 0.07786389f, 0.08179852f, 
    0.10997406f, 0.13643627f, -0.08248156f, -0.03691486f, -0.11110650f, 0.01234456f, 0.02743420f, -0.00263084f, 
    -0.02811765f, -0.10446618f, -0.21789217f, -0.02901390f, -0.07017868f, -0.05272495f, -0.15362038f, -0.01424241f, 
    -0.02303505f, -0.00250179f, -0.02710500f, -0.01822822f, -0.11391880f, 0.08557355f, 0.04775190f, -0.02527836f, 
    0.08369924f, 0.03628004f, 0.03683027f, 0.02412495f, -0.00981857f, 0.04940311f, 0.07359695f, 0.02318481f, 
    0.02379154f, -0.02038585f, 0.04940723f, 0.01100045f, -0.02115079f, -0.03794957f, 0.02872153f, -0.07511603f, 
    0.57641608f, -0.33630013f, -0.38234484f, 0.36732656f, -0.26960850f, -0.00910596f, 0.07467239f, -0.07247893f, 
    -0.00084999f, -0.04211206f, 0.04550746f, 0.02937753f, 0.03319976f, 0.01569380f, 0.02208948f, -0.02987610f, 
    0.05146712f, 0.03121353f, -0.12349962f, -0.18156639f, -0.51744932f, -0.26856124f, 0.21672751f, 0.15840645f, 
    0.08003540f, 0.06149987f, -0.05977767f, 0.18466218f, 0.01651474f, 0.13728496f, 0.04886559f, -0.00364465f, 
    0.02303371f, -0.04857750f, 0.00207334f, -0.01258819f, 0.04916514f, 0.01339420f, -0.01975843f, -0.06566053f, 
    -0.03653155f, 0.12181543f, -0.03503799f, 0.03637946f, -0.17902218f, -0.02239780f, 0.01834522f, -0.00734593f, 
    -0.01750676f, 0.00033961f, -0.01107418f, 0.04919018f, -0.03648693f, 0.05285639f, -0.03498018f, -0.13307261f, 
    -0.05784682f, 0.04541545f, -0.06196893f, 0.04087880f, -0.06073406f, 0.08223724f, 0.14714640f, -0.08303542f, 
    0.03623610f, -0.01155643f, 0.07790274f, 0.08109725f, -0.11150894f, -0.03790705f, -0.04691604f, 0.13352980f, 
    0.09976963f, 0.02190865f, 0.11550791f, 0.02144695f, 0.05063414f, 0.12375173f, -0.03252312f, 0.10267978f, 
    0.17935598f, -0.00031458f, -0.16347253f, 0.02182275f, -0.03238209f, 0.03492266f, 0.21808673f, 0.08184220f, 
    -0.10891487f, -0.12564969f, 0.01235754f, 0.04252078f, 0.07522732f, -0.06605937f, -0.13743123f, 0.09449027f, 
    -0.07775165f, 0.05687661f, -0.02070973f, 0.02724889f, 0.25542992f, 0.17236486f, -0.05393243f, -0.13758890f, 
    -0.20112218f, 0.00327244f, -0.01795806f, -0.06548432f, -0.00258261f, -0.03590749f, -0.02895692f, -0.12602253f, 
    0.09557532f, -0.05061162f, -0.06010229f, 0.02811585f, 0.00560270f, -0.01056755f, 0.01628829f, 0.00965221f, 
    0.48986828f, -0.45685098f, 0.42549756f, -0.38509196f, -0.08225860f, -0.05372129f, 0.12940499f, -0.10946484f, 
    0.08577586f, -0.11409224f, 0.00963000f, 0.01838869f, 0.04201513f, -0.04209225f, -0.00776291f, -0.01174030f, 
    0.02281000f, -0.01043569f, 0.00730538f, 0.01333391f, 0.14456241f, -0.67921168f, 0.06471820f, -0.07486137f, 
    0.10921275f, -0.14088690f, 0.08146124f, -0.00659757f, 0.19459599f, 0.10739908f, -0.04883353f, 0.04427327f, 
    -0.11983825f, -0.02833906f, 0.06056381f, -0.08032156f, 0.05384385f, -0.23492478f, 0.18982546f, -0.07722382f, 
    -0.37178773f, -0.20315120f, 0.10156304f, 0.00659419f, 0.11629147f, -0.03213717f, 0.26477274f, 0.01271724f, 
    0.01907158f, 0.12076548f, -0.00610144f, 0.03504778f, 0.07789128f, -0.00414055f, 0.01530736f, -0.04107325f, 
    0.01128406f, -0.11595634f, -0.09012097f, 0.03353753f, 0.06236159f, 0.06715731f, 0.03965696f, -0.02468332f, 
    -0.11982508f, -0.02635469f, 0.03155055f, -0.00438437f, -0.01486808f, -0.05065244f, 0.03808966f, -0.05640976f, 
    -0.05463414f, -0.09704526f, -0.08317879f, 0.04957648f, -0.07376762f, -0.05176095f, 0.09652080f, 0.04541798f, 
    -0.32729822f, -0.29043302f, 0.34730890f, 0.02590416f, 0.21412085f, -0.02277225f, -0.02921292f, -0.07553086f, 
    0.08965556f, 0.04155751f, 0.01235031f, -0.00842759f, -0.06651045f, -0.01751974f, -0.06522032f, 0.02216767f, 
    0.00063191f, 0.00152635f, 0.05158091f, -0.04856699f, -0.24708529f, -0.03652937f, -0.12915266f, 0.08325769f, 
    -0.00715904f, 0.03319092f, -0.00148970f, 0.03433776f, 0.06523044f, 0.06072329f, -0.00445587f, 0.06056680f, 
    0.02975363f, -0.02002020f, -0.09597364f, 0.04839205f, -0.03582280f, 0.10561740f, -0.11193730f, 0.06583644f, 
    -0.17449923f, -0.01745596f, 0.22170284f, 0.00864222f, 0.07706353f, 0.00655075f, -0.02625480f, -0.03726851f, 
    0.00200409f, 0.03632144f, 0.08874949f, -0.00759443f, 0.03425951f, -0.02005984f, -0.03107037f, -0.06842828f, 
    -0.08481385f, -0.03121039f, -0.01779317f, -0.03608902f, -0.65504187f, -0.42248902f, 0.33264637f, 0.23281787f, 
    0.07471610f, 0.21189225f, 0.06414445f, 0.11971381f, 0.09829906f, 0.20852247f, 0.04591890f, 0.01157611f, 
    -0.01242423f, 0.03974880f, -0.06920522f, 0.05284614f, 0.02812816f, 0.04712042f, 0.03394193f, -0.06012720f, 
    0.18732820f, -0.33573431f, -0.21063775f, -0.15680665f, -0.23903365f, 0.01570930f, -0.11238328f, 0.01185316f, 
    0.08574419f, 0.01444874f, -0.05548665f, -0.04076031f, 0.09524863f, -0.00099666f, 0.02753854f, 0.03963820f, 
    0.00960411f, 0.03084139f, 0.03496708f, 0.02587943f, 0.01395081f, 0.09496447f, 0.03409097f, -0.03117648f, 
    -0.04653854f, 0.00414694f, -0.00793406f, -0.02694319f, -0.00183268f, 0.00141806f, 0.03531144f, -0.00874709f, 
    0.04743478f, -0.00216483f, -0.02107519f, -0.02531417f, -0.11346953f, -0.15435837f, 0.07288238f, -0.01456693f, 
    -0.19776234f, -0.20230976f, 0.10292923f, 0.11515004f, 0.14067432f, 0.04311313f, 0.03892303f, 0.07056569f, 
    0.03494396f, 0.12439003f, 0.02064923f, 0.15249324f, 0.08458282f, 0.06493307f, 0.03871680f, 0.03291852f, 
    0.00988740f, -0.00180729f, -0.04740522f, -0.03638167f, 0.20731682f, -0.33161089f, -0.30927667f, 0.38221437f, 
    -0.06490000f, 0.05939921f, 0.01321891f, 0.06135388f, -0.01685037f, 0.04386382f, 0.06961433f, 0.04219858f, 
    0.06766377f, -0.01245443f, -0.01545194f, 0.02434524f, 0.02882463f, 0.01786750f, 0.03059339f, -0.03315832f, 
    0.10176488f, 0.11020064f, -0.09266087f, -0.06593239f, -0.07032959f, 0.02649478f, -0.00688115f, 0.03512797f, 
    0.02120563f, 0.00221005f, -0.08484021f, 0.00406129f, 0.00974027f, -0.08502650f, -0.13721199f, -0.04930066f, 
    -0.02696636f, -0.01251652f, 0.05619656f, 0.00809608f, -0.02192122f, 0.06483299f, 0.06222772f, 0.02273397f, 
    -0.02086348f, 0.03067904f, -0.03525456f, 0.00412184f, -0.01762873f, -0.01455867f, 0.08957488f, -0.20081511f, 
    -0.09829527f, -0.11741113f, -0.14561471f, -0.01512525f, -0.01047447f, -0.01663526f, -0.00393081f, 0.01454636f, 
    -0.19626510f, -0.15122068f, 0.00951183f, 0.09594681f, 0.14434215f, 0.06424619f, 0.02633193f, 0.14909333f, 
    0.01556791f, 0.04856779f, -0.07785358f, 0.10093218f, 0.06783753f, 0.11499456f, -0.05020195f, -0.04105240f, 
    -0.06307521f, -0.13716532f, 0.12270579f, 0.16578516f, -0.02619042f, 0.03763946f, 0.09407578f, -0.04622427f, 
    -0.04592940f, -0.03702017f, -0.03164720f, -0.06546407f, -0.01534456f, 0.03046693f, 0.04189255f, 0.03998647f, 
    0.01991496f, -0.00461947f, -0.05366977f, -0.11584662f, -0.13827291f, -0.17560202f, 0.05158448f, -0.02666686f, 
    0.42221841f, -0.57672584f, 0.11670920f, -0.24664499f, -0.02204449f, 0.00808099f, -0.07824309f, -0.14688525f, 
    0.22672771f, 0.06541123f, -0.02878531f, -0.00331584f, -0.06834903f, -0.14800885f, -0.08285316f, 0.08427343f, 
    0.03418926f, -0.07142408f, -0.03242241f, 0.10823539f, 0.43935600f, -0.25876305f, -0.15307307f, -0.12603468f, 
    -0.06269985f, -0.01558868f, 0.03467505f, -0.03765730f, 0.00304139f, -0.04834021f, 0.02854727f, -0.06799900f, 
    0.03057035f, 0.02534275f, 0.00388141f, -0.02080143f, -0.00379404f, -0.02424543f, 0.03358300f, -0.02159639f, 
    -0.53812176f, 0.08914581f, 0.27098337f, -0.01055491f, 0.15732288f, 0.10119304f, -0.03661157f, -0.00927200f, 
    -0.01010551f, 0.04446847f, 0.08568042f, 0.03315737f, 0.06716689f, 0.03044358f, 0.04043069f, 0.04138838f, 
    -0.00743043f, 0.06440119f, -0.10999234f, -0.10277103f, 0.33551949f, 0.52329695f, -0.18625750f, 0.02361517f, 
    -0.46786314f, 0.07559448f, 0.05927311f, 0.05979099f, -0.05796518f, -0.03540408f, -0.09089295f, 0.00001301f, 
    0.10998429f, -0.04845306f, -0.11130535f, -0.02048353f, -0.09730990f, 0.02546217f, -0.03963268f, -0.12367483f, 
    -0.18619317f, -0.07962666f, 0.39929721f, -0.43923450f, 0.29937842f, -0.32571453f, 0.07799074f, 0.03597206f, 
    0.05718292f, -0.02265530f, 0.01583173f, 0.07739022f, -0.00817571f, -0.01758013f, -0.08976062f, -0.10896696f, 
    0.00153117f, 0.01629898f, 0.00318728f, -0.00227791f, 0.20810415f, 0.13395369f, -0.06570810f, 0.07806730f, 
    -0.18383309f, -0.03417107f, 0.06627954f, 0.00753102f, 0.06827773f, 0.04143547f, -0.06484327f, -0.01858943f, 
    -0.02759274f, -0.01144704f, -0.01469823f, 0.02868964f, 0.02326618f, -0.05241103f, -0.06695757f, 0.05168589f, 
    0.10611954f, 0.21851966f, -0.23671119f, 0.02466390f, -0.31779441f, 0.05164476f, 0.05266568f, 0.02520064f, 
    -0.02105839f, 0.04033919f, -0.05961650f, -0.12351909f, -0.07140128f, -0.01175611f, -0.02483802f, 0.00113326f, 
    0.03081499f, -0.00334631f, -0.11265960f, 0.10313291f, 0.19888929f, 0.09890757f, -0.21986261f, -0.06132307f, 
    -0.14872192f, 0.06151607f, 0.08577258f, -0.07010911f, -0.03358337f, 0.01305189f, 0.03482430f, 0.01367220f, 
    0.04341007f, 0.05602900f, 0.04888220f, -0.01646749f, -0.01136044f, 0.02685072f, 0.02983912f, 0.03396405f, 
    0.18592641f, 0.03211268f, 0.24554013f, -0.15918124f, 0.03779498f, -0.29965270f, 0.23414218f, -0.12921676f, 
    -0.02016901f, 0.03577072f, -0.02567064f, 0.02866746f, 0.07206257f, -0.11412763f, -0.08240676f, -0.16674519f, 
    0.04761490f, 0.03243778f, -0.03504318f, 0.08045532f, 0.46972609f, -0.55124676f, -0.55995375f, -0.66324306f, 
    -0.37386766f, 0.08867971f, 0.04554212f, -0.11476056f, 0.30218458f, 0.04447354f, 0.05444040f, 0.05540496f, 
    -0.02703358f, 0.13728894f, 0.04886575f, -0.09704580f, 0.00358213f, -0.18595219f, 0.01752292f, 0.07318422f, 
    0.01708183f, 0.11907350f, 0.04687421f, -0.00060166f, -0.10616887f, 0.02524490f, 0.03124234f, 0.06371064f, 
    -0.02328268f, -0.04748497f, -0.01997351f, -0.06035164f, -0.00803212f, -0.01873869f, 0.07532787f, -0.17285810f, 
    -0.00809552f, 0.11584409f, -0.11307253f, 0.00694605f, -0.07749372f, 0.22035767f, 0.06406426f, 0.18253925f, 
    -0.14837894f, 0.00358235f, 0.10731181f, -0.02238467f, -0.00565543f, -0.02617963f, 0.02918413f, 0.06498893f, 
    0.02017340f, 0.02783386f, -0.02442458f, -0.05362591f, 0.08378720f, -0.06472252f, -0.06713855f, 0.06471962f, 
    0.10906202f, -0.31322607f, -0.41047686f, -0.22538531f, 0.11692100f, 0.02684639f, -0.15538734f, -0.00515928f, 
    0.08546904f, 0.02979233f, -0.08451114f, 0.01999113f, -0.02570619f, -0.03965485f, -0.04032519f, -0.01981659f, 
    0.03161255f, 0.08786221f, 0.05241103f, 0.13012624f, 0.49316102f, -0.62623477f, -0.59029055f, -0.01829365f, 
    0.02695977f, 0.04325270f, -0.07762025f, -0.04548924f, -0.01294155f, 0.05055021f, -0.00319152f, -0.01078697f, 
    0.02246583f, 0.01128738f, -0.01067877f, 0.00289364f, 0.02964968f, 0.04249833f, -0.01617608f, 0.06291419f, 
    0.49500179f, -0.02245429f, -0.02945629f, -0.23468773f, -0.20203672f, 0.05496711f, -0.11367966f, 0.01382759f, 
    0.02672456f, -0.30106029f, -0.05794433f, 0.02475178f, 0.05644462f, 0.01363404f, 0.04965086f, 0.04776868f, 
    0.01078745f, 0.02758325f, 0.03103427f, 0.02410733f, -0.20508167f, -0.46687707f, 0.15834782f, 0.04926711f, 
    0.27370232f, -0.08090304f, 0.05360645f, -0.08574375f, -0.09636183f, -0.03789790f, -0.02102546f, -0.00284690f, 
    0.02182924f, 0.08103816f, 0.05531549f, -0.00306236f, -0.08460022f, 0.00409406f, -0.03808403f, -0.11987386f, 
    -0.01883378f, -0.61317462f, -0.53738689f, -0.33402738f, 0.31266800f, 0.03333900f, 0.14283133f, 0.15508771f, 
    0.11951178f, 0.02025564f, 0.00851282f, -0.15041053f, -0.15859090f, -0.02070798f, -0.07403542f, 0.00583419f, 
    -0.01861238f, -0.00308438f, -0.03274092f, -0.08214926f, 0.06164018f, -0.05175063f, -0.15633820f, 0.01635951f, 
    -0.00949097f, -0.05836080f, 0.02908924f, 0.02796678f, 0.00168631f, 0.06612410f, 0.03642402f, 0.00814838f, 
    -0.04734373f, 0.02957295f, -0.04006074f, 0.01052306f, 0.03525050f, 0.06128078f, 0.10646174f, -0.02723638f, 
    -0.07015319f, -0.39332309f, -0.72279835f, -0.16430396f, 0.09702489f, 0.06185443f, 0.02351440f, 0.14878125f, 
    0.06958986f, 0.00116458f, -0.04009390f, -0.07374857f, -0.00123907f, 0.00525262f, 0.04904594f, 0.02540101f, 
    -0.00105405f, -0.04323957f, -0.10316417f, -0.07644854f, -0.13963571f, -0.27361950f, -0.49119133f, -0.50278783f, 
    -0.30077308f, -0.11426210f, -0.27749348f, 0.00512356f, -0.20887531f, -0.36199009f, -0.00579199f, -0.00577132f, 
    0.00484148f, -0.00963611f, 0.08365660f, 0.12491271f, 0.11136021f, 0.17421231f, 0.00450438f, -0.24236427f, 
    -0.07112676f, -0.24615714f, -0.21552035f, -0.23761520f, -0.01237496f, -0.05325578f, -0.13904840f, 0.01242450f, 
    -0.11039721f, -0.21822858f, -0.01126174f, 0.04317846f, 0.04285518f, 0.06534225f, 0.05319698f, 0.07258664f, 
    0.03895577f, 0.11519536f, -0.00792812f, -0.07698309f, 0.08507709f, -0.07487336f, -0.04148570f, -0.03235631f, 
    -0.08347736f, -0.06604010f, -0.09581813f, -0.15027526f, -0.09205152f, -0.02357899f, -0.02552409f, 0.12313790f, 
    0.11268569f, -0.08037846f, -0.03739866f, -0.02083176f, 0.10778514f, 0.09468795f, 0.14187010f, 0.12682597f, 
    -0.10635863f, -0.12935922f, -0.41582206f, -0.30765778f, -0.08496562f, -0.01296100f, -0.28901154f, -0.05434487f, 
    -0.01090888f, -0.09297128f, 0.01559202f, -0.01678101f, 0.01673840f, 0.01172691f, 0.02638523f, 0.05971249f, 
    0.02835296f, 0.08046672f, 0.00185976f, 0.03503868f, 0.23316690f, 0.02505037f, -0.01454945f, 0.01203494f, 
    0.08527754f, 0.01642706f, -0.08978701f, -0.01669304f, -0.00707849f, -0.05011212f, -0.02739256f, 0.00286645f, 
    0.04695500f, 0.00135941f, 0.01106498f, -0.03470122f, 0.02164868f, -0.17525676f, 0.01875605f, -0.04088029f, 
    -0.03563515f, -0.55704510f, -0.21015251f, 0.20806772f, 0.22067478f, 0.11610158f, 0.12668414f, 0.07036795f, 
    -0.07772213f, 0.10790221f, 0.04779995f, 0.00988058f, -0.04177503f, 0.01603148f, -0.03710958f, 0.02304373f, 
    0.00112696f, 0.02544119f, -0.09187920f, 0.04165886f, -0.00600512f, 0.03069982f, -0.39910984f, -0.21941304f, 
    -0.13745901f, -0.03906808f, -0.02805951f, -0.06277786f, 0.16985326f, -0.03675626f, 0.14039221f, -0.02107427f, 
    0.09161382f, -0.01880173f, 0.05335013f, -0.06868840f, -0.04489799f, 0.01827250f, -0.00018697f, -0.03122118f, 
    0.01341594f, -0.00043196f, -0.01895067f, -0.00128520f, -0.14461249f, -0.06787252f, -0.07750514f, -0.07465415f, 
    -0.01975663f, -0.10730383f, -0.04174699f, 0.05455175f, 0.09095997f, 0.01877170f, -0.01309731f, 0.03455926f, 
    0.07488899f, 0.08324182f, 0.13001831f, 0.10403945f, 0.73830730f, 0.23851059f, 0.13841745f, -0.05962412f, 
    0.09872268f, 0.05867865f, -0.01128750f, -0.09933404f, -0.07045706f, 0.07487256f, 0.16475055f, -0.06270055f, 
    0.01435598f, -0.00900991f, -0.05471129f, -0.14361690f, -0.08247185f, 0.06236018f, -0.12154182f, -0.07592540f, 
    -0.64627117f, 0.09945296f, 0.24217404f, 0.16026799f, 0.00970895f, -0.03749758f, -0.04637902f, -0.09106440f, 
    -0.08422639f, -0.02608470f, -0.06462762f, -0.06678496f, 0.00062362f, -0.08815356f, -0.09259743f, -0.08672938f, 
    -0.15818696f, -0.16410357f, -0.17437781f, -0.14240442f, 0.39824566f, 0.15500945f, -0.02611846f, -0.06499048f, 
    -0.08158750f, -0.07786251f, 0.03203603f, -0.08632733f, 0.00166841f, -0.23801526f, -0.00341846f, 0.04454305f, 
    0.10304379f, -0.00574488f, -0.00426932f, -0.00190891f, 0.02554118f, 0.07541000f, 0.16760500f, 0.05165561f, 
    -0.23573245f, -0.06774956f, 0.10364302f, -0.01071432f, -0.24732979f, -0.08003035f, -0.04630267f, -0.06525620f, 
    -0.00647404f, -0.11830511f, -0.08397995f, 0.00577728f, 0.00574563f, 0.01420019f, 0.01928096f, -0.09168563f, 
    -0.00442206f, -0.10102741f, -0.09754781f, -0.03233579f, -0.01721292f, 0.11546823f, -0.01825639f, 0.04704932f, 
    -0.17677960f, 0.05759757f, 0.10186104f, -0.00044769f, 0.04124690f, -0.16439523f, 0.05449599f, 0.15185966f, 
    0.00469054f, 0.06759396f, 0.15433837f, -0.15378402f, 0.05895443f, -0.00186578f, 0.04647900f, 0.03995381f, 
    0.09973912f, -0.01852472f, -0.05815747f, -0.00165157f, 0.01201144f, -0.06234167f, -0.04973982f, -0.02413509f, 
    -0.01600239f, -0.10183214f, -0.05410875f, 0.09479079f, 0.01912704f, -0.01439078f, -0.03467790f, -0.06626814f, 
    0.03110466f, 0.12115481f, 0.17771722f, 0.06170664f, -0.26252797f, -0.07534420f, 0.18559101f, 0.06038284f, 
    0.06130500f, -0.10386758f, 0.03021992f, -0.08435231f, -0.02136683f, -0.08249278f, -0.10993796f, -0.00557071f, 
    0.10460459f, -0.02446801f, 0.00905897f, -0.02938629f, -0.01926643f, -0.12406858f, 0.01895967f, -0.12245458f, 
    -0.11396705f, 0.05658704f, 0.07905658f, -0.06901140f, -0.12010673f, -0.08746330f, -0.00846318f, 0.02097520f, 
    0.02194593f, -0.01903961f, -0.02777402f, 0.03843890f, 0.01662843f, 0.11578394f, 0.09810687f, 0.01242807f, 
    0.08033206f, 0.00232708f, 0.08850912f, 0.02000933f, 0.06877913f, 0.10698482f, 0.04008144f, 0.04779824f, 
    -0.08784067f, 0.00359616f, -0.02089485f, 0.01752488f, 0.00925341f, -0.02710465f, -0.02920363f, -0.05343634f, 
    -0.01623828f, 0.02353091f, 0.02560011f, 0.05183396f, 0.02413991f, 0.07751714f, 0.01027702f, -0.03842729f, 
    -0.07459890f, -0.50149453f, -0.67495573f, -0.25048444f, 0.05048185f, -0.03143910f, 0.02837583f, 0.18861039f, 
    0.13233012f, 0.04227832f, 0.10031709f, -0.07003676f, -0.09661851f, -0.04223976f, -0.12242383f, -0.04636313f, 
    -0.03477563f, -0.00631527f, -0.05968101f, -0.06028531f, -0.29364657f, -0.09180944f, -0.04198678f, 0.07977139f, 
    0.20657744f, 0.05893799f, 0.01956232f, 0.01127747f, 0.07327186f, -0.12043250f, -0.05273149f, 0.06331377f, 
    0.08061454f, 0.01938127f, 0.02910241f, -0.09654743f, -0.13169654f, 0.06173268f, 0.13671967f, 0.07372897f, 
    -0.09967553f, 0.13051662f, 0.09861405f, 0.02045589f, -0.12794615f, -0.01166866f, -0.03910403f, -0.02545791f, 
    0.00126195f, -0.05117170f, -0.06839927f, 0.01140535f, -0.01161036f, 0.03107497f, -0.01363101f, 0.08210950f, 
    0.06196669f, 0.03342875f, 0.03035141f, 0.01063327f, 0.21944237f, 0.05981050f, -0.08075241f, -0.04735018f, 
    -0.02279625f, 0.18356429f, 0.04551293f, 0.10698601f, 0.24848481f, 0.05488367f, 0.04569745f, -0.00594098f, 
    0.06673089f, 0.06926811f, 0.00666693f, 0.08566581f, -0.10628029f, -0.05313191f, -0.05682561f, -0.24008533f, 
    0.08681079f, 0.03679661f, -0.02350564f, -0.02857467f, -0.10192899f, -0.05112651f, 0.00136461f, -0.00175996f, 
    0.01587510f, -0.02071815f, 0.04461334f, 0.05952899f, 0.04163073f, 0.05730079f, 0.04040781f, 0.05554356f, 
    0.06634584f, 0.04952976f, 0.08836233f, 0.04989254f, -0.28224263f, -0.03629510f, 0.05991528f, 0.05767328f, 
    0.11376230f, -0.01938757f, -0.05697476f, 0.03473527f, 0.05349218f, -0.07623690f, -0.00342762f, -0.04456902f, 
    0.04281955f, -0.00574754f, 0.01018030f, -0.08343530f, 0.00512613f, 0.04494346f, 0.13072820f, 0.14623564f, 
    0.37636191f, -0.09944519f, -0.22477201f, -0.19291127f, 0.17789277f, 0.11133414f, 0.05610803f, 0.03957202f, 
    0.05715614f, 0.14579047f, -0.00827290f, 0.03758864f, 0.06553684f, 0.02067166f, -0.02548791f, 0.06099885f, 
    -0.00841688f, 0.00780659f, -0.01468077f, 0.10981966f, -0.33109549f, -0.34830371f, 0.01811528f, -0.11986207f, 
    0.15200752f, -0.01949565f, 0.00981215f, -0.05788238f, -0.12946418f, -0.30025193f, 0.01080854f, 0.05884108f, 
    0.06155512f, 0.00288999f, 0.04035691f, 0.04177854f, 0.00057443f, -0.08806997f, -0.07562008f, -0.23986325f, 
    0.00616665f, 0.12357067f, 0.06018723f, 0.10567454f, -0.09443055f, 0.01983494f, 0.02218318f, -0.05322947f, 
    -0.05302799f, 0.04125364f, -0.02196719f, 0.00434084f, 0.01166761f, 0.02454372f, -0.00253377f, 0.06553314f, 
    0.05023880f, 0.07893459f, 0.01983817f, -0.08655088f, -0.43801168f, -0.07059985f, 0.14190747f, 0.01768647f, 
    0.42575756f, 0.01912241f, 0.06584918f, -0.10624961f, -0.07650695f, -0.00589380f, 0.05007001f, -0.12523770f, 
    0.02841640f, -0.05593538f, -0.06203331f, -0.07565601f, -0.06051324f, -0.01473185f, -0.06730824f, -0.04927670f, 
    0.42775768f, 0.14290793f, -0.06858660f, -0.02986908f, -0.39115852f, -0.12683170f, 0.00423163f, -0.20069514f, 
    -0.03435983f, 0.00986091f, 0.07811222f, 0.04298881f, -0.10316466f, -0.06085028f, 0.02315348f, -0.00075054f, 
    0.15244444f, -0.03335157f, 0.12166169f, -0.02748649f, -0.07277066f, -0.12966838f, -0.16552876f, -0.09391864f, 
    -0.09342068f, -0.05937802f, 0.08645649f, 0.10584218f, 0.04240331f, -0.02398450f, 0.11742211f, 0.01228356f, 
    0.05355620f, 0.02069616f, 0.04011131f, 0.01221615f, 0.04513476f, -0.00175321f, 0.08990035f, 0.00319461f, 
    0.02516025f, -0.20961055f, -0.50341249f, -0.12436809f, 0.09864019f, 0.03162176f, 0.01230815f, 0.09876831f, 
    -0.01233685f, 0.19042692f, -0.02678325f, -0.02240600f, -0.04119569f, 0.01284860f, -0.03540996f, 0.01655735f, 
    0.08499280f, 0.05882701f, 0.01030060f, 0.02401615f, -0.05075954f, -0.05501185f, -0.52986091f, -0.29403499f, 
    -0.13176174f, 0.10009623f, -0.09162211f, 0.05531957f, 0.06212835f, -0.03362765f, -0.04467227f, -0.00227130f, 
    -0.01316792f, 0.07273120f, 0.09106451f, 0.00770653f, 0.07335438f, 0.09842191f, -0.15892218f, 0.01370890f, 
    -0.07077640f, -0.11095287f, -0.11843639f, 0.15504448f, -0.06328040f, -0.13214529f, -0.00691403f, 0.00666147f, 
    0.02275986f, 0.03349808f, -0.02728515f, 0.03803458f, -0.14415482f, -0.07055955f, 0.02769497f, -0.07345927f, 
    0.16671723f, 0.11345175f, 0.20357980f, -0.04619833f, -0.12123431f, 0.05264219f, 0.04396410f, -0.04885691f, 
    -0.10721083f, -0.03373910f, -0.01346282f, -0.04759611f, 0.01321276f, 0.03479207f, -0.02974376f, -0.02165937f, 
    0.02110415f, 0.06167151f, 0.10170998f, -0.01120298f, 0.07466935f, 0.01715637f, 0.04494731f, 0.00313136f, 
    0.23987100f, -0.06582133f, -0.08364314f, -0.14382952f, -0.07972402f, -0.07855350f, -0.21765116f, 0.03152690f, 
    -0.09317613f, -0.11766964f, 0.02983639f, 0.01410630f, -0.00581733f, 0.10550973f, 0.04953231f, 0.07389006f, 
    0.09064789f, 0.04240413f, -0.14234269f, -0.24052469f, -0.11097529f, -0.17041922f, -0.09073206f, 0.09879659f, 
    -0.04971176f, 0.03326844f, -0.00913296f, -0.02010509f, 0.02923208f, 0.02100709f, 0.06854552f, -0.09028951f, 
    0.02481576f, 0.05992335f, -0.02187548f, 0.00714715f, 0.09301636f, 0.03437634f, 0.14300124f, 0.05761211f, 
    -0.26146427f, -0.09927723f, 0.01092767f, 0.08125619f, 0.02993612f, -0.01966732f, 0.00745501f, -0.02826392f, 
    0.01171764f, 0.01387276f, -0.02572654f, 0.03730555f, 0.06010816f, 0.06975490f, 0.02723393f, 0.01868950f, 
    0.01509424f, 0.08295766f, 0.10360101f, 0.15611941f, -0.14957558f, -0.35301140f, 0.06676295f, -0.02257333f, 
    -0.22902735f, -0.03113531f, -0.24128571f, -0.12795985f, -0.25196773f, -0.37118700f, -0.03720225f, -0.00279903f, 
    0.01051273f, -0.03890043f, 0.03730132f, 0.10002604f, -0.00166374f, 0.00330287f, -0.17661628f, -0.37614420f, 
    -0.15935364f, -0.50782478f, -0.34972599f, -0.13908558f, 0.04057891f, -0.07303412f, 0.20486790f, 0.06904743f, 
    0.08601446f, 0.10027654f, 0.10427893f, -0.02795892f, -0.07805165f, -0.09346913f, -0.06942715f, -0.00853011f, 
    0.03917319f, -0.01074473f, 0.04679770f, -0.09475116f, -0.18455988f, 0.07597221f, 0.11196908f, -0.00348499f, 
    -0.14675668f, 0.00426216f, -0.10924522f, -0.05692318f, -0.04499982f, -0.01484387f, -0.05356575f, -0.07221198f, 
    -0.05817225f, -0.01176555f, -0.04592242f, 0.04739163f, 0.06568912f, 0.04557227f, -0.04280046f, 0.04256522f, 
    -0.01572196f, -0.12280963f, -0.09350204f, 0.03685731f, 0.04533388f, -0.09839884f, -0.11532142f, -0.14021143f, 
    0.00896028f, 0.04145209f, -0.02502053f, 0.04053194f, -0.11428636f, -0.04382094f, 0.00457371f, -0.05235564f, 
    0.10581699f, 0.06379000f, 0.12061061f, 0.06175176f, 0.13179564f, -0.10370397f, -0.29212156f, -0.14552596f, 
    -0.04652595f, 0.09362417f, 0.01874715f, -0.00568206f, 0.05510836f, 0.02336054f, 0.02427029f, -0.02919701f, 
    -0.01407847f, 0.02285278f, -0.02775215f, 0.06779723f, 0.02538082f, -0.00310280f, 0.03694128f, -0.04975882f, 
    -0.03844342f, -0.07502732f, -0.16812007f, 0.02313558f, -0.15582323f, 0.03695890f, -0.05281605f, 0.05184801f, 
    -0.00663594f, -0.04544391f, -0.03069009f, 0.08632348f, -0.04081003f, 0.13812043f, 0.03729206f, 0.05353656f, 
    0.00870176f, 0.00074751f, -0.03130947f, 0.12234021f, -0.28038856f, -0.04726250f, 0.11314097f, 0.02532586f, 
    -0.06018923f, -0.05501619f, -0.01270870f, 0.02361864f, 0.00543548f, 0.02452011f, 0.06712397f, 0.04498158f, 
    0.04518521f, 0.08188530f, 0.08127698f, 0.00484242f, 0.05772896f, -0.00375815f, 0.05371235f, 0.04838981f, 
    -0.44281539f, -0.40232256f, 0.19727598f, 0.14786665f, 0.15981893f, -0.08605594f, -0.00158275f, -0.05762339f, 
    -0.09659510f, -0.10398428f, 0.03122679f, -0.05894074f, 0.02158175f, 0.03382945f, -0.00427449f, -0.09260888f, 
    -0.06944410f, 0.03871971f, -0.12262092f, -0.03164249f, -0.14986850f, 0.16074121f, 0.12436300f, 0.07261254f, 
    -0.12658079f, -0.00604406f, -0.14026059f, -0.02882542f, 0.01478968f, -0.12847488f, -0.01571395f, 0.01468850f, 
    0.02328824f, -0.09314485f, 0.00892260f, -0.08542577f, 0.03704622f, 0.02682229f, -0.01591372f, 0.02922025f, 
    0.05777399f, 0.27092561f, -0.15682866f, -0.06667848f, -0.04508442f, 0.02122460f, -0.05619013f, 0.03702030f, 
    0.04821590f, 0.02391669f, 0.00850309f, -0.01182899f, -0.05003259f, 0.14243288f, -0.00002950f, -0.10615344f, 
    -0.21505617f, 0.02420669f, -0.28141120f, -0.36534417f, -0.12382343f, -0.30854839f, -0.36659577f, -0.20516500f, 
    0.00034562f, -0.01442743f, 0.05232418f, 0.06220111f, 0.03493269f, 0.20359214f, 0.06850091f, -0.03287862f, 
    -0.05182080f, -0.07753956f, -0.09923056f, -0.00805052f, 0.03830273f, 0.03358126f, 0.03877574f, -0.00684426f, 
    -0.42641613f, -0.29073772f, 0.16696480f, 0.11574153f, 0.13011983f, 0.08716267f, 0.11503273f, -0.02431087f, 
    -0.07502963f, -0.02522951f, -0.01600507f, -0.02329182f, -0.00329870f, -0.08058218f, -0.00592240f, -0.01910688f, 
    -0.18128893f, -0.10888468f, -0.09278321f, -0.22885260f, 0.22577266f, -0.00505032f, -0.12174184f, -0.22625163f, 
    -0.24586672f, -0.02319859f, 0.11308296f, 0.07887483f, 0.08991410f, -0.09984279f, 0.04755564f, -0.01095624f, 
    0.05607266f, 0.04487551f, 0.10531017f, 0.02423410f, -0.02523302f, -0.05657654f, 0.08045734f, -0.04554696f, 
    -0.27033433f, -0.29866213f, -0.11870878f, 0.03790870f, 0.05889670f, 0.05501193f, -0.01363369f, 0.02822714f, 
    0.10621398f, 0.19162583f, 0.13008340f, -0.03177668f, 0.00556479f, -0.04849099f, 0.06417762f, -0.02130222f, 
    0.14482714f, 0.02390989f, -0.07277885f, 0.10893908f, 0.21593668f, 0.13943478f, 0.03335279f, -0.08269204f, 
    -0.12204216f, -0.08174714f, -0.12342028f, -0.03609344f, -0.04567970f, -0.06942923f, -0.00367037f, 0.03754445f, 
    -0.05170111f, 0.02806896f, 0.02096388f, -0.11444337f, -0.13449074f, -0.09363560f, -0.25460291f, -0.16162486f, 
    0.05045728f, 0.05084999f, -0.00896915f, -0.00336443f, -0.09769654f, -0.06562860f, 0.02079092f, -0.07270651f, 
    0.09253581f, -0.07794055f, 0.09957048f, 0.09845347f, 0.01886602f, 0.06018686f, 0.04997517f, 0.06259039f, 
    -0.04915995f, -0.02726493f, 0.00384721f, -0.00150984f, -0.02978905f, -0.35334265f, -0.32092926f, -0.03259093f, 
    -0.11057492f, 0.03043430f, 0.10233492f, 0.14388640f, 0.03335936f, 0.01524167f, 0.06991145f, -0.04207731f, 
    -0.08118313f, 0.01596058f, -0.09182521f, -0.00737383f, -0.05152313f, 0.03261774f, 0.07775337f, -0.11120930f, 
    0.21529084f, -0.02176950f, -0.23976658f, -0.04081998f, -0.02233822f, 0.05564069f, 0.01311691f, 0.00580320f, 
    0.13905348f, 0.12230927f, 0.14596400f, 0.01553675f, -0.03691482f, -0.01183916f, -0.00758788f, -0.01177683f, 
    0.12655687f, -0.03390126f, 0.03959002f, -0.03950052f, -0.15556778f, -0.05415372f, -0.77764648f, -0.43067649f, 
    -0.07250880f, -0.06641221f, 0.03458717f, 0.13821313f, 0.08569755f, 0.02452621f, -0.00998061f, -0.05406870f, 
    -0.06529149f, 0.05530554f, 0.05614419f, 0.09831211f, -0.07443424f, 0.10606717f, -0.06000032f, -0.09330960f, 
    -0.15526505f, -0.03567139f, 0.01834157f, 0.03429458f, -0.05243351f, -0.08628803f, 0.03314175f, 0.03708418f, 
    0.13634112f, -0.05898737f, -0.08674229f, 0.12633926f, 0.03721959f, 0.05000547f, 0.08036597f, 0.11069495f, 
    0.07269722f, -0.02306677f, 0.11629182f, 0.02910379f, 0.34351984f, 0.29728606f, 0.12971580f, 0.12851453f, 
    -0.04270792f, 0.09180521f, -0.15114108f, 0.03028793f, -0.02369432f, -0.14776126f, -0.01289440f, -0.01011130f, 
    0.03632318f, -0.01873409f, -0.03325710f, 0.05414072f, -0.01931374f, -0.02063415f, -0.04091089f, -0.24434888f, 
    0.01300904f, 0.04151105f, 0.20478483f, -0.20679821f, -0.20335051f, 0.03174644f, -0.18592586f, 0.07625571f, 
    0.12869583f, 0.08028189f, -0.09808291f, -0.00840233f, -0.02809539f, -0.03581690f, -0.03180674f, 0.03841894f, 
    -0.04360856f, 0.06446249f, -0.09874206f, -0.26310590f, -0.18632354f, -0.09356591f, 0.38934404f, 0.00195986f, 
    -0.13623539f, 0.01785017f, -0.24971437f, -0.01701491f, 0.04808803f, 0.13572134f, -0.07839135f, 0.00792035f, 
    0.01982972f, -0.05049049f, -0.01619702f, 0.03698676f, 0.06167877f, -0.00242481f, -0.02519325f, -0.05025872f, 
    -0.21215537f, 0.23137891f, -0.63574117f, -0.00922648f, -0.16273363f, -0.07545481f, -0.02755343f, 0.05395309f, 
    -0.12327889f, 0.17582017f, 0.02762596f, 0.00432361f, -0.01194829f, -0.03578945f, -0.06730030f, 0.05557974f, 
    -0.02046096f, 0.04657155f, 0.03992507f, -0.13376850f, 0.00185914f, -0.27053773f, 0.02021165f, -0.21417180f, 
    -0.15212134f, 0.02106329f, -0.10478468f, 0.03434178f, 0.10258616f, -0.04200285f, -0.07550109f, 0.10544448f, 
    0.01956379f, 0.02936858f, 0.01532698f, 0.03126248f, 0.05354825f, 0.09954332f, 0.00981628f, 0.13964123f, 
    0.12985376f, -0.07272167f, 0.34086728f, 0.35928079f, -0.74062496f, 0.28377613f, -0.14865957f, -0.19083278f, 
    0.03121880f, -0.15705135f, 0.00650086f, 0.02258856f, 0.02089627f, 0.06739295f, 0.00110649f, -0.00041528f, 
    -0.01831179f, -0.00468563f, -0.03119867f, 0.08755354f, -0.14594199f, 0.06786714f, 0.29241571f, 0.08464473f, 
    -0.12796113f, 0.06821852f, -0.08244455f, -0.06115863f, -0.06431979f, -0.15967669f, -0.00184133f, 0.02513960f, 
    0.04697915f, -0.00160204f, 0.04882338f, -0.06373289f, -0.07340892f, -0.09746202f, -0.00336887f, -0.04022072f, 
    0.19732240f, 0.06614123f, 0.00197092f, 0.19803888f, -0.50160271f, -0.00605368f, 0.01592830f, -0.11783086f, 
    0.10491641f, -0.03293224f, 0.04917704f, -0.05918490f, 0.04275361f, 0.04550958f, 0.08322218f, 0.03272917f, 
    0.02166609f, 0.05090076f, -0.00406560f, 0.09365213f, -0.08875924f, -0.47104159f, -0.13149272f, 0.10184532f, 
    -0.18260592f, -0.18383901f, -0.00110807f, -0.00248251f, 0.00651427f, 0.07008900f, 0.06459218f, 0.00755937f, 
    0.06262561f, 0.00814951f, -0.14239413f, -0.03589478f, 0.08262271f, 0.08277550f, 0.10157525f, 0.09447541f, 
    -0.08519644f, -0.14396772f, 0.08769091f, 0.04911214f, -0.11815804f, -0.01437667f, -0.15182832f, 0.05979716f, 
    0.12432090f, 0.19868051f, -0.04073873f, 0.04751809f, 0.04381035f, -0.02055162f, -0.08811777f, 0.01033194f, 
    0.06355475f, 0.06604167f, 0.06254673f, 0.03403456f, -0.04125816f, -0.01223069f, -0.07846169f, 0.07674088f, 
    0.03342737f, -0.05976794f, 0.01347634f, -0.00542780f, -0.02202586f, -0.08312210f, -0.00343285f, -0.02366845f, 
    -0.10253979f, -0.05217929f, 0.03351335f, 0.09831564f, -0.03572148f, -0.08086139f, 0.00407202f, -0.16558595f, 
    -0.32272747f, -0.19002455f, -0.36027801f, 0.12549801f, -0.36691070f, -0.06130996f, -0.08775470f, 0.03090475f, 
    0.11985660f, 0.17209840f, 0.04032636f, 0.00334064f, 0.02832221f, -0.02734545f, -0.00541378f, -0.06183014f, 
    -0.02623143f, 0.16635551f, 0.16013163f, -0.04796475f, -0.04754434f, -0.09384546f, -0.44246718f, 0.04606869f, 
    0.01105715f, -0.08630727f, 0.14645503f, 0.14250618f, -0.13755023f, -0.02370797f, 0.09247836f, -0.05351170f, 
    0.06831079f, 0.05354978f, -0.11658334f, -0.00485376f, 0.01178555f, -0.16447319f, 0.02773468f, 0.17971016f, 
    -0.01614802f, -0.14518721f, 0.33645579f, -0.38262627f, -0.45654270f, -0.08460015f, -0.06402559f, -0.00664301f, 
    -0.00082221f, 0.03052010f, 0.01648648f, 0.07284650f, -0.02819259f, 0.14145167f, -0.02922894f, -0.05311942f, 
    0.00011221f, -0.01001907f, -0.05339376f, -0.09028815f, -0.34322760f, 0.13145453f, -0.03623127f, 0.57420081f, 
    -0.13209833f, -0.09854204f, 0.19739296f, -0.26279914f, 0.07100951f, -0.16788703f, 0.08554779f, -0.12263365f, 
    0.09221906f, 0.04414481f, 0.11915759f, 0.05643705f, 0.08267698f, -0.04280112f, -0.01168333f, 0.04737975f, 
    -0.28207260f, 0.34728038f, -0.15792392f, 0.03004511f, -0.14643800f, -0.00552172f, 0.08009841f, 0.12354431f, 
    -0.00370261f, 0.00373691f, 0.11846562f, -0.02441333f, -0.07678878f, -0.12454882f, -0.06866099f, 0.09990263f, 
    0.02986619f, -0.19298758f, 0.04602948f, -0.10797157f, -0.27457160f, -0.33483925f, -0.14933154f, -0.18134962f, 
    0.04721036f, 0.08654885f, -0.04443008f, -0.04503590f, -0.01527464f, -0.21469824f, 0.01617913f, 0.01245590f, 
    -0.01147648f, -0.11530220f, -0.05060928f, 0.03662650f, 0.07629254f, -0.24452443f, 0.00487820f, 0.09272484f, 
    -0.28900379f, -0.14016691f, -0.50628078f, -0.13108246f, 0.19489220f, 0.08949443f, -0.00228381f, 0.15760979f, 
    0.07173212f, 0.04337813f, 0.01729499f, -0.03391378f, -0.04784450f, 0.02400639f, -0.00934155f, 0.04255327f, 
    0.03545163f, -0.02662118f, 0.06035120f, 0.00317444f, -0.46786192f, 0.30939147f, -0.39370289f, -0.01650461f, 
    -0.00953425f, 0.04876594f, 0.09993056f, 0.11234959f, -0.07777619f, 0.09295551f, 0.10070273f, -0.04550818f, 
    -0.19337910f, 0.00358954f, -0.08330597f, 0.05797692f, 0.05243095f, -0.21479043f, 0.03630754f, -0.07520856f, 
    -0.10431165f, -0.10036982f, -0.14389758f, 0.17540945f, 0.32976797f, -0.03971974f, 0.00433508f, 0.07302344f, 
    -0.08077313f, 0.05048957f, -0.07256512f, 0.01803503f, -0.01643719f, -0.06345659f, -0.18887727f, 0.17232038f, 
    0.09259065f, 0.08042096f, 0.04115090f, 0.13911578f, -0.44483036f, -0.21081819f, -0.06068973f, -0.00371317f, 
    0.00347726f, -0.01723190f, 0.22981338f, -0.21751338f, 0.06186246f, -0.03604768f, 0.02138731f, 0.05271057f, 
    -0.01975963f, 0.01890253f, 0.05102034f, 0.12024327f, -0.01935201f, -0.11936657f, -0.01697341f, -0.01029061f, 
    -0.05789565f, 0.12037672f, 0.07320333f, -0.10771216f, 0.04506610f, 0.09089166f, 0.00614053f, 0.07326298f, 
    -0.00173354f, 0.07457995f, -0.00486718f, 0.04207327f, -0.03656075f, 0.00301793f, -0.01202084f, 0.03387520f, 
    0.00326052f, -0.08209344f, 0.01908223f, -0.07052369f, -0.02459741f, -0.01418873f, -0.12340012f, 0.01707616f, 
    0.03608853f, 0.00130973f, -0.09582692f, 0.10034868f, -0.00317173f, -0.05020335f, -0.05077358f, 0.05974076f, 
    0.02970470f, 0.01699330f, 0.06056248f, 0.07162334f, 0.14128838f, 0.04469509f, 0.06155544f, 0.23307963f, 
    -0.20122524f, 0.01262532f, -0.03915503f, -0.03071346f, 0.11164093f, 0.02526109f, 0.06103552f, 0.11591901f, 
    0.01403375f, -0.06361292f, 0.16677853f, 0.08627011f, 0.06660633f, -0.00038613f, -0.01597082f, 0.15348616f, 
    -0.01941418f, 0.01143022f, 0.05608710f, 0.06816605f, -0.12881458f, 0.10459592f, -0.10847818f, 0.15944648f, 
    0.06593002f, 0.06673396f, -0.11843222f, 0.07360974f, 0.01175430f, 0.05685109f, 0.04281475f, 0.01595748f, 
    0.02281549f, 0.10679977f, -0.05262262f, -0.04499597f, -0.00866062f, 0.03818769f, 0.04561909f, 0.06753399f, 
    0.23770291f, 0.19470181f, 0.18668868f, 0.38801652f, -0.41696838f, 0.02268465f, -0.09480538f, -0.38442904f, 
    -0.03416480f, -0.17535476f, 0.05300975f, -0.08198223f, 0.06326565f, 0.11518802f, 0.08231299f, 0.08568431f, 
    0.01687576f, 0.02325273f, 0.01479559f, 0.00316895f, -0.19922705f, 0.50116467f, -0.27073562f, -0.70067495f, 
    0.04523071f, 0.04108564f, 0.01733138f, 0.03943246f, -0.08631183f, 0.18592420f, 0.05099048f, 0.05964707f, 
    -0.16464853f, 0.02041386f, 0.00466494f, 0.04402651f, 0.09789629f, -0.06152209f, 0.00095500f, -0.13685589f, 
    -0.04049066f, 0.05786834f, -0.27957886f, 0.00643734f, -0.03733174f, 0.04918308f, 0.06896732f, 0.16143896f, 
    0.05216186f, 0.01504130f, 0.03685319f, 0.02317695f, 0.03095957f, 0.04349660f, -0.01117298f, 0.04868063f, 
    0.00185770f, 0.04558696f, 0.01735574f, 0.06819155f, -0.26230299f, 0.18957141f, -0.35691348f, 0.15977229f, 
    -0.21290845f, 0.13519719f, -0.22195771f, 0.12063823f, 0.07512905f, 0.06903144f, -0.00131451f, 0.05313896f, 
    -0.00385206f, 0.08196432f, -0.01141592f, -0.07949011f, -0.05539864f, 0.21112934f, 0.12361135f, 0.29751742f, 
    -0.19877762f, 0.09764537f, -0.03018228f, 0.20487748f, 0.12745801f, -0.05647427f, 0.00165330f, -0.01236267f, 
    -0.02577489f, -0.03298614f, -0.01306600f, 0.04352550f, 0.01842820f, -0.05371477f, 0.04827385f, -0.01729994f, 
    0.00308659f, 0.00016626f, -0.01322618f, 0.00869498f, -0.03249288f, 0.15152216f, -0.10828092f, -0.19869946f, 
    -0.05622580f, -0.10104302f, -0.02091310f, -0.01987429f, 0.04721210f, 0.13538112f, -0.02948766f, 0.03879580f, 
    -0.01896597f, -0.08715880f, -0.02540415f, 0.11171643f, 0.12347015f, -0.06411985f, 0.00541601f, -0.09532144f, 
    -0.28853959f, 0.02577602f, 0.07641282f, 0.11980169f, -0.20828333f, 0.03325454f, -0.15932140f, 0.08916151f, 
    -0.14267714f, 0.09742279f, 0.07256497f, 0.02584886f, 0.02567243f, 0.01698949f, -0.00877205f, 0.02773987f, 
    0.01798697f, -0.04280003f, 0.07272890f, -0.04657589f, -0.05667202f, 0.17883359f, -0.40965500f, -0.34669530f, 
    -0.02281597f, -0.13754590f, -0.11495619f, -0.03815429f, -0.16144153f, 0.19203112f, -0.06758906f, 0.06372693f, 
    -0.03981416f, 0.07947495f, 0.02728177f, 0.01247888f, 0.09192584f, 0.12860790f, -0.01211312f, 0.06870469f, 
    -0.35824239f, 0.06409575f, -0.25408402f, -0.30291811f, 0.09947171f, 0.24155965f, 0.01128130f, 0.10716224f, 
    0.08358667f, -0.03073241f, 0.06822246f, 0.03349717f, -0.02988241f, 0.04848845f, -0.00199985f, -0.11573248f, 
    -0.06774243f, 0.06178940f, 0.01395586f, 0.04185451f, -0.36848566f, -0.38903919f, -0.25196767f, -0.47878587f, 
    -0.02691779f, -0.03840042f, -0.17209646f, 0.13743947f, 0.01427986f, -0.10495821f, -0.09781194f, 0.04411841f, 
    -0.16985872f, -0.09681542f, 0.09046099f, 0.10396783f, 0.02076822f, 0.08185478f, -0.06459875f, 0.07037767f, 
    -0.45341769f, -0.27695531f, -0.32680973f, -0.07273940f, -0.08473377f, -0.05633137f, 0.16985983f, -0.16231872f, 
    0.06069806f, -0.10451795f, -0.09198849f, -0.07796583f, -0.13683043f, -0.06235750f, -0.01782984f, -0.00075422f, 
    -0.08035165f, 0.00921242f, -0.15940787f, -0.09939778f, -0.05649045f, 0.25782606f, 0.07830581f, 0.26537070f, 
    0.10740152f, 0.06877624f, 0.08262414f, -0.21735968f, -0.10664331f, -0.11966584f, 0.08565345f, 0.00190895f, 
    -0.01476736f, 0.11171491f, 0.03811172f, 0.10282467f, 0.00255069f, -0.03336374f, 0.00542399f, -0.01173024f, 
    -0.03160860f, -0.18591003f, -0.09608727f, -0.11968203f, -0.04370323f, -0.20607224f, 0.01062624f, 0.03607865f, 
    -0.03312618f, 0.04615809f, -0.00362382f, 0.02072481f, 0.00301112f, 0.02672159f, 0.03022664f, 0.06182986f, 
    -0.04659356f, -0.02082055f, 0.01387917f, -0.14340478f, -0.13023762f, -0.24626330f, 0.11633157f, 0.30904046f, 
    -0.51349223f, -0.04733421f, -0.14730476f, -0.08682964f, 0.12022277f, 0.16673867f, 0.06002780f, 0.00135450f, 
    0.05095034f, 0.01267356f, -0.01139106f, -0.04496409f, 0.06504051f, -0.15890113f, 0.08588649f, 0.09897419f, 
    0.19872980f, -0.14475197f, 0.10605481f, -0.15657924f, 0.01647894f, -0.16332766f, 0.01945011f, 0.06411055f, 
    0.05443741f, 0.07329487f, -0.11976839f, 0.11050617f, -0.02570875f, 0.00066674f, -0.05812629f, 0.02920274f, 
    -0.02480981f, -0.03952676f, -0.13717312f, -0.01112525f, -0.11675738f, -0.06898979f, 0.01669231f, 0.05760360f, 
    0.15330878f, -0.08136763f, 0.08772209f, -0.04354586f, 0.00818382f, -0.13521269f, 0.01624149f, 0.13220331f, 
    0.08501193f, -0.14244027f, -0.03357123f, 0.18050794f, -0.06637832f, -0.07917394f, -0.03547549f, 0.03246200f, 
    0.05628275f, -0.21613294f, -0.12707745f, 0.03212795f, -0.10354467f, -0.13597503f, -0.01637822f, 0.01131783f, 
    0.12617777f, 0.10267055f, -0.03341803f, 0.02826448f, 0.07564184f, 0.04849925f, -0.03731988f, -0.04591104f, 
    0.08180583f, 0.02693338f, 0.12395887f, 0.07724609f, -0.42685089f, 0.33734539f, 0.28031862f, -0.02927280f, 
    -0.24659579f, 0.03924464f, -0.24667528f, 0.04805700f, -0.02755974f, -0.13503157f, -0.01416998f, -0.06079464f, 
    -0.00126114f, -0.07910396f, 0.04292621f, -0.09049869f, -0.09245358f, -0.05299640f, -0.03205064f, -0.11443777f, 
    0.07774609f, 0.14418598f, 0.11818533f, -0.37352833f, 0.03265332f, 0.00269043f, 0.04468051f, 0.02573683f, 
    0.11063536f, 0.10227141f, 0.07666834f, 0.07769477f, 0.02265979f, 0.04399944f, 0.04089616f, 0.03999425f, 
    0.08174557f, -0.07226750f, -0.06380737f, -0.02870936f, 0.51106256f, -0.39696360f, -0.48205480f, 0.07842514f, 
    0.03047182f, 0.02820290f, -0.04528272f, 0.05431507f, -0.02084865f, 0.18144217f, -0.01590602f, 0.08270748f, 
    -0.07456780f, -0.01676643f, 0.01597578f, -0.01679633f, 0.00639939f, 0.15961854f, 0.08062887f, 0.05799113f, 
    0.13061027f, 0.03762110f, 0.27289277f, 0.12057667f, -0.37896830f, 0.10420272f, -0.19000076f, -0.18607801f, 
    0.02507745f, -0.08982297f, 0.00625947f, 0.05726417f, 0.05398135f, 0.07635929f, 0.06233719f, -0.04712458f, 
    -0.01809789f, 0.03629610f, -0.02851682f, 0.01523272f, -0.02541881f, -0.13793284f, -0.33280030f, -0.02922010f, 
    -0.13732810f, 0.03417113f, 0.10193730f, 0.17854579f, 0.01994138f, 0.11837803f, 0.02663031f, 0.01547553f, 
    -0.02872131f, 0.02441986f, -0.08927619f, 0.11352050f, 0.11672696f, 0.01294037f, -0.04852248f, 0.05612308f, 
    0.11943252f, 0.14008000f, 0.47738117f, -0.08713669f, -0.12713447f, 0.00518308f, -0.00371866f, -0.02093656f, 
    0.09656068f, 0.05880476f, -0.09862471f, -0.00145446f, 0.07804486f, -0.06554700f, 0.00450980f, 0.06779643f, 
    -0.01161120f, -0.03483637f, -0.11085345f, -0.13679051f, -0.28338182f, -0.03804651f, -0.10598214f, -0.01465467f, 
    -0.23888488f, 0.02107858f, -0.33437306f, 0.09351795f, -0.15370502f, 0.11830346f, -0.03167025f, 0.01110218f, 
    0.02497216f, -0.00421516f, -0.07650665f, -0.00554344f, -0.01587700f, -0.01473047f, 0.08977462f, 0.02501821f, 
    -0.11064200f, 0.07162398f, -0.23569195f, 0.10960051f, -0.17359674f, -0.01705224f, 0.05427634f, 0.16159835f, 
    -0.08725578f, 0.06693523f, 0.00082723f, 0.13194449f, 0.01751825f, -0.17608333f, -0.15475120f, 0.05918215f, 
    0.12805009f, 0.00302614f, 0.03628207f, -0.07627899f, -0.00061912f, -0.01937924f, 0.11817116f, -0.20807825f, 
    0.09065017f, 0.00266207f, -0.03520406f, -0.03006293f, 0.15021276f, -0.07465805f, 0.13202471f, 0.10229722f, 
    0.06813476f, -0.06683123f, 0.01607027f, 0.09863995f, 0.05809218f, -0.06526668f, 0.04825880f, 0.10286545f, 
    0.09451894f, -0.24858813f, 0.04573555f, -0.12649949f, -0.01667068f, -0.00215997f, -0.14445829f, -0.03633265f, 
    0.12691480f, -0.12598754f, -0.07178105f, 0.07882911f, 0.07238786f, 0.02495981f, -0.06899662f, 0.13436560f, 
    0.04298408f, 0.09673644f, -0.03933330f, 0.15858728f, 0.23310733f, -0.18155685f, -0.43620968f, 0.11239247f, 
    -0.04367161f, 0.02325736f, 0.13834254f, 0.22895007f, 0.11462327f, 0.17666200f, -0.00050016f, -0.06504317f, 
    -0.06910805f, -0.02244367f, -0.07156133f, 0.05609809f, 0.05906492f, 0.02413528f, -0.04301146f, 0.01219649f, 
    -0.43432724f, -0.35883203f, -0.09471279f, 0.14470866f, 0.15363963f, -0.09332013f, 0.16744950f, -0.17169425f, 
    0.00983409f, 0.09673870f, 0.09143958f, -0.07358448f, 0.05397397f, 0.08445500f, -0.02367719f, 0.10163110f, 
    0.11915350f, 0.01031567f, 0.09177196f, 0.04862312f, 0.22395711f, 0.04879511f, 0.22169635f, 0.02726536f, 
    -0.17251517f, 0.00837535f, -0.11209262f, -0.30194092f, -0.08764081f, -0.06516100f, 0.06204148f, 0.01325656f, 
    0.10042743f, 0.07997669f, 0.06288897f, 0.02025840f, -0.09060336f, 0.00156633f, -0.05537462f, -0.07199081f, 
    0.20392747f, -0.34973991f, -0.42958042f, -0.38917944f, 0.18868746f, 0.00387950f, -0.00120243f, 0.08866305f, 
    0.13719480f, 0.14151327f, 0.00006346f, 0.00839367f, -0.00501676f, 0.00475176f, -0.03262029f, 0.01157683f, 
    0.14602658f, 0.03645140f, -0.07546457f, 0.07270638f, -0.83435249f, 0.20039870f, -0.14002874f, 0.46177995f, 
    -0.01669953f, -0.06132722f, -0.06675322f, -0.18190484f, -0.05902400f, -0.15504424f, 0.06347014f, 0.06228412f, 
    -0.00373005f, -0.15266488f, 0.03524503f, -0.02937985f, -0.17032874f, -0.05517126f, 0.06549377f, 0.05529456f, 
    0.19943351f, -0.22851013f, 0.02165927f, -0.13971284f, -0.01794255f, -0.10073961f, 0.19820291f, -0.12711564f, 
    0.04076905f, 0.06485392f, 0.03367424f, 0.04254190f, -0.01307818f, 0.01675302f, 0.06121266f, 0.12733705f, 
    -0.08765808f, 0.06281704f, -0.01780939f, -0.12424588f, -0.26848075f, -0.19102587f, -0.06479900f, 0.12556101f, 
    0.16146453f, 0.04326376f, 0.13104576f, 0.07779918f, -0.04538290f, 0.13606143f, 0.00306771f, -0.11138128f, 
    0.01628995f, 0.03194528f, -0.09173179f, 0.09493756f, 0.00729287f, -0.00968585f, 0.07252464f, 0.03744152f, 
    -0.22150926f, 0.02681973f, 0.06296196f, 0.17049621f, 0.12364669f, 0.02262074f, 0.06885443f, -0.10769136f, 
    0.10263935f, -0.02188211f, 0.02799399f, -0.01503038f, 0.05991199f, -0.02084943f, -0.04018593f, 0.05729043f, 
    0.04643365f, -0.00013910f, -0.09112342f, 0.06809226f, 0.06842314f, 0.17496461f, 0.03022197f, 0.37321880f, 
    0.06490377f, -0.09287505f, -0.13373908f, -0.18538803f, -0.04417247f, -0.21446674f, 0.01525521f, -0.00715598f, 
    -0.00852240f, 0.05410380f, -0.10082918f, 0.03073879f, -0.01972687f, -0.04088341f, -0.04816171f, 0.02983815f, 
    -0.05413940f, 0.06297173f, -0.06248612f, -0.17586926f, 0.22902820f, -0.13042419f, 0.00274642f, -0.05128463f, 
    -0.15976843f, -0.10138955f, 0.07850488f, -0.04127983f, -0.11135651f, 0.01383296f, -0.06952064f, 0.05154706f, 
    -0.10344002f, 0.00450178f, -0.13358581f, -0.01235285f, -0.10365168f, 0.07745524f, -0.14035837f, 0.44652015f, 
    -0.51705945f, 0.04208405f, 0.09587124f, -0.25961533f, 0.11126360f, -0.09614118f, 0.04456818f, -0.07045089f, 
    0.06725533f, 0.01595656f, 0.00053551f, 0.07020347f, 0.09465318f, 0.10815922f, 0.11593231f, 0.12161860f, 
    -0.23333131f, 0.16336533f, -0.04838893f, -0.13749678f, 0.09421930f, 0.05984941f, -0.03139915f, -0.03227172f, 
    -0.06921069f, 0.08593956f, 0.02463978f, 0.10836003f, -0.03439961f, 0.11521520f, 0.04354075f, 0.04938748f, 
    0.01669242f, -0.01500307f, -0.05680725f, -0.01492815f, -0.04090334f, -0.03933951f, -0.86647886f, 0.14431095f, 
    -0.09155614f, -0.04426725f, 0.08557741f, 0.19164038f, -0.02462324f, 0.02724836f, 0.02464643f, 0.06385270f, 
    -0.02030798f, 0.03962342f, -0.07284516f, -0.08493321f, 0.06597289f, 0.02178693f, 0.14341573f, 0.11766136f, 
    -0.27043596f, 0.00078662f, -0.09775639f, 0.14947666f, 0.14478303f, -0.17485198f, -0.03454883f, -0.03090648f, 
    -0.10677654f, -0.08902474f, -0.09428915f, 0.01284244f, 0.03207102f, 0.08326750f, 0.10034374f, 0.03291409f, 
    -0.03665566f, -0.08860573f, 0.00152606f, 0.26198119f, -0.49520540f, 0.16933095f, -0.41257975f, 0.01319931f, 
    0.04588472f, -0.07568912f, -0.08451518f, -0.25742871f, 0.14522478f, -0.03379434f, -0.01353727f, 0.06612480f, 
    -0.00993022f, 0.04261266f, 0.06043186f, 0.02289029f, -0.03919078f, -0.13789801f, -0.01692921f, -0.00530184f, 
    -0.15176837f, -0.13215460f, 0.02827086f, -0.12566350f, 0.12374606f, -0.12921718f, 0.05216429f, 0.29319942f, 
    -0.04180501f, 0.09885040f, -0.01269293f, 0.16306116f, 0.03381352f, 0.04041408f, 0.00432090f, 0.10132895f, 
    -0.04530712f, 0.07950059f, -0.01872390f, -0.13682364f, -0.22758715f, 0.18940288f, -0.12306976f, 0.00772667f, 
    0.00780834f, 0.03786254f, -0.00828267f, 0.00102936f, 0.05531685f, 0.00435941f, 0.01568880f, 0.04525739f, 
    -0.03729747f, 0.03393301f, 0.02132294f, -0.08291496f, -0.01471955f, -0.11146023f, 0.04214532f, -0.16827112f, 
    -0.29888016f, 0.15487424f, 0.00709691f, 0.17557847f, 0.04657691f, -0.05401989f, -0.07829002f, -0.13361932f, 
    0.01335519f, 0.01222582f, 0.03429647f, -0.06887215f, -0.01171071f, 0.00023151f, -0.06463973f, -0.00175829f, 
    -0.04212787f, -0.00329859f, -0.11921059f, 0.02476726f, -0.27943894f, -0.05426257f, 0.07243743f, -0.04613583f, 
    -0.04619436f, 0.01097766f, 0.00333030f, -0.08001780f, 0.03885147f, -0.04197030f, 0.11142744f, -0.10319871f, 
    -0.02937960f, -0.04730899f, 0.04834523f, 0.05688681f, 0.10252084f, 0.03369777f, 0.03846116f, 0.07164511f, 
    0.11421137f, 0.01366725f, 0.08765912f, 0.11442468f, 0.13542251f, -0.05385035f, 0.02241827f, 0.04466515f, 
    0.04967330f, 0.10834474f, -0.10235221f, 0.10561598f, -0.07977639f, -0.11449477f, -0.20144482f, 0.05102942f, 
    -0.00628077f, 0.05812230f, 0.03858353f, -0.00044699f, -0.20570363f, -0.06400537f, -0.61718816f, -0.14186823f, 
    -0.05971396f, -0.04813455f, -0.03879859f, -0.00390458f, -0.12442209f, -0.05867528f, 0.01955742f, 0.11215114f, 
    0.03952191f, 0.09194092f, 0.05738368f, 0.08575598f, -0.01204412f, -0.06715970f, -0.08918027f, -0.12916245f, 
    -0.24521151f, -0.03156159f, -0.33281907f, -0.04436388f, 0.01754573f, 0.03553012f, -0.09378292f, -0.03558811f, 
    -0.12865502f, -0.07263015f, -0.02307534f, 0.05464906f, -0.00821818f, 0.03713899f, -0.00471997f, 0.06769372f, 
    -0.05595929f, -0.05166839f, -0.10418727f, -0.08864246f, -0.22956227f, -0.22804125f, 0.00987130f, -0.19634306f, 
    0.01607472f, -0.07116864f, 0.01169344f, 0.03918093f, -0.08385658f, -0.02031149f, 0.03832683f, 0.05986242f, 
    -0.08202213f, 0.09758539f, 0.03788777f, 0.05545233f, -0.01084628f, 0.16675180f, 0.02010204f, 0.23727947f, 
    -0.22875220f, -0.14619043f, 0.11268935f, -0.01577025f, 0.17543736f, -0.10529792f, -0.05703578f, -0.21232978f, 
    -0.13801153f, -0.00246920f, -0.07254875f, 0.11037878f, 0.05101825f, 0.06494661f, 0.09357997f, 0.13523693f, 
    -0.11337645f, -0.13177581f, -0.03663018f, -0.14073133f, 0.10779924f, 0.04165493f, 0.24196339f, 0.40223631f, 
    0.15729301f, -0.14043239f, 0.01578449f, 0.05746704f, -0.12784484f, -0.10190047f, -0.06582591f, -0.02000911f, 
    -0.00416008f, -0.04380571f, 0.03653901f, 0.09079855f, -0.25722444f, -0.00308655f, 0.13690932f, 0.16348767f, 
    -0.23172431f, 0.29360279f, -0.36664614f, 0.14174280f, 0.16490513f, 0.04305443f, -0.09988174f, 0.00668027f, 
    0.25724116f, 0.10052215f, -0.02205902f, -0.01310297f, 0.04268926f, 0.03076500f, 0.11765898f, 0.00617886f, 
    0.05007705f, -0.28110263f, 0.23187198f, 0.05221823f, 0.14393777f, 0.23912530f, 0.07053670f, -0.10411143f, 
    -0.00484472f, 0.09106002f, -0.21985269f, 0.11373056f, 0.07774749f, 0.05748625f, -0.19527009f, 0.03317141f, 
    -0.13497062f, 0.06050879f, -0.06841727f, -0.08767479f, -0.09525214f, -0.01124444f, -0.06321120f, -0.02906525f, 
    -0.38428852f, -0.35098183f, 0.04438385f, -0.15632822f, -0.14352174f, 0.04643466f, 0.02894759f, 0.20742065f, 
    -0.02136728f, -0.05566652f, -0.14543702f, 0.03736863f, 0.06871857f, -0.00075110f, -0.03676885f, -0.07820090f, 
    0.04571552f, 0.22539358f, 0.13126701f, 0.04250266f, -0.70330584f, 0.12071571f, 0.10323908f, 0.09735775f, 
    -0.08766270f, 0.07210255f, 0.04781622f, 0.05319927f, 0.31682867f, 0.08104714f, -0.17530754f, -0.00618923f, 
    -0.03411560f, -0.05157364f, 0.04977789f, 0.11048196f, -0.13972865f, 0.03214996f, 0.08446338f, 0.09015600f, 
    -0.12957720f, -0.09958657f, -0.04981444f, 0.06392223f, 0.08643793f, -0.13973841f, -0.02522074f, -0.06368365f, 
    -0.10268753f, -0.18047179f, -0.13253424f, 0.06558105f, -0.01744537f, 0.00887624f, 0.03148909f, 0.00545313f, 
    0.00887948f, -0.20471469f, -0.16778824f, -0.20041625f, -0.12996067f, -0.48558071f, 0.22831292f, -0.08935890f, 
    -0.09709958f, -0.03566234f, 0.00401835f, 0.26638439f, 0.12466093f, -0.01697764f, -0.13142484f, 0.03240601f, 
    0.04269031f, -0.01811830f, 0.08357102f, 0.02359779f, 0.13496141f, 0.23427616f, 0.09357278f, 0.05300396f, 
    0.19793321f, -0.51133704f, 0.01146654f, 0.09600593f, -0.62077421f, -0.05463311f, -0.10485709f, 0.09069114f, 
    -0.13202479f, -0.07743117f, -0.02809361f, 0.05310944f, -0.21075344f, 0.03150865f, 0.00858841f, -0.09815809f, 
    0.16281994f, 0.02285023f, 0.01906659f, -0.25232816f, 0.26173365f, -0.09255332f, 0.36750388f, 0.03131398f, 
    -0.01110087f, 0.02059740f, -0.17408484f, 0.08098482f, 0.04731918f, -0.07060021f, 0.09247209f, 0.02781359f, 
    0.02897476f, 0.02327176f, 0.07154924f, 0.04017438f, 0.02313207f, 0.10788520f, 0.00795870f, 0.10100579f, 
    -0.23089498f, -0.13376395f, 0.14145447f, -0.06982737f, -0.01545315f, -0.03660497f, -0.02802041f, 0.17888640f, 
    0.08151481f, -0.04423133f, -0.01887321f, 0.04225681f, 0.12564619f, 0.06198623f, -0.02871518f, 0.07596895f, 
    0.06262301f, 0.17521416f, 0.11041993f, 0.24350269f, 0.11637574f, -0.07040205f, 0.13482168f, -0.06903777f, 
    -0.12013457f, 0.00044352f, 0.02713273f, 0.04214740f, -0.04376667f, -0.10009789f, 0.08644988f, 0.08022732f, 
    -0.03571511f, 0.13162600f, -0.08067946f, -0.01434084f, -0.08996072f, 0.10224140f, -0.19224693f, -0.11912221f, 
    -0.06129427f, -0.29549590f, 0.04709131f, -0.18650439f, -0.15020920f, -0.02837332f, -0.15922517f, -0.00865733f, 
    0.01487172f, -0.04255006f, 0.02066412f, -0.00969023f, 0.07408657f, -0.00619143f, 0.03857969f, 0.08257312f, 
    0.04796860f, 0.04619655f, 0.09182730f, -0.07785381f, 0.15205172f, -0.18378325f, 0.19387533f, -0.01479344f, 
    -0.03780062f, -0.16610885f, -0.02877743f, -0.01610212f, 0.01193624f, 0.04540527f, 0.02891660f, -0.04061533f, 
    -0.01337102f, 0.11578272f, 0.01842750f, 0.06647654f, -0.07050657f, 0.05872989f, 0.07396553f, -0.04506486f, 
    0.26117945f, 0.10764937f, 0.05975598f, 0.05098322f, 0.09213775f, 0.04750336f, -0.08657975f, -0.09744883f, 
    -0.04633546f, 0.10743310f, -0.13196073f, 0.13755433f, -0.10997083f, -0.04892923f, -0.09354538f, -0.00947450f, 
    -0.05443481f, -0.01572449f, 0.03482363f, 0.01497383f, 0.05201298f, -0.17181480f, 0.30159366f, 0.44303161f, 
    -0.08318714f, -0.06092833f, 0.17588556f, 0.25873700f, -0.08552048f, -0.15696837f, -0.00091900f, -0.13191028f, 
    -0.12580562f, 0.16712530f, -0.01812962f, 0.00097464f, 0.09749206f, 0.16672240f, -0.01028921f, 0.17174160f, 
    -0.10904609f, -0.32827932f, -0.07124803f, -0.21948230f, -0.18596549f, -0.19356713f, -0.13394505f, 0.04281713f, 
    -0.01125009f, -0.08612409f, -0.07451216f, 0.01496107f, -0.03170248f, -0.01389973f, -0.06061737f, 0.08342921f, 
    0.00414590f, 0.06022324f, 0.07184252f, -0.01237350f, -0.06554497f, -0.22658052f, -0.02657809f, -0.00097788f, 
    0.05824297f, -0.22119880f, 0.16130102f, -0.03821397f, 0.06959330f, -0.02438080f, -0.04240055f, 0.07650079f, 
    -0.07036298f, 0.05628103f, 0.06008599f, 0.24637936f, -0.12745771f, -0.00266052f, -0.11997682f, -0.26169017f, 
    0.23606147f, -0.20522632f, 0.20229506f, -0.12051998f, -0.07699977f, -0.04555204f, -0.02316124f, 0.04609141f, 
    -0.02993516f, -0.01930108f, 0.03761904f, -0.00809889f, -0.06534114f, 0.04206041f, 0.05838565f, -0.04727003f, 
    0.07208579f, 0.10820343f, 0.00505222f, 0.01152556f, 0.04702797f, -0.16470775f, -0.18703455f, 0.22581266f, 
    -0.04131046f, 0.09591079f, -0.01305455f, 0.25511017f, -0.02449448f, -0.03086262f, -0.08689178f, 0.00882770f, 
    -0.07559309f, 0.08900792f, 0.13912055f, -0.05099120f, -0.11657716f, 0.20238724f, -0.05535933f, 0.11435999f, 
    0.03035729f, 0.06521013f, 0.06627500f, -0.11178385f, 0.09993885f, -0.13852029f, 0.03951815f, 0.15660307f, 
    0.10672946f, 0.06157577f, -0.12616321f, 0.03767293f, -0.06579098f, 0.04252006f, 0.07564659f, 0.07625201f, 
    -0.03820601f, 0.03634878f, -0.05617292f, 0.05026131f, 0.00810110f, -0.17752425f, -0.03469892f, 0.16383556f, 
    -0.09094739f, -0.00993223f, -0.09346063f, 0.31220645f, -0.09539610f, -0.15907069f, 0.12548952f, -0.02111770f, 
    -0.02525114f, 0.04257361f, -0.05375585f, -0.02746713f, -0.04892936f, 0.18703732f, -0.27403376f, -0.01748538f, 
    -0.09987231f, -0.14898336f, 0.18822698f, 0.09901035f, -0.01134434f, -0.28877664f, -0.02400343f, -0.05355636f, 
    0.17034735f, -0.17445131f, -0.20694228f, 0.04940263f, 0.04875358f, 0.02988557f, -0.00834971f, 0.01855209f, 
    0.09660549f, 0.02114300f, 0.17587382f, -0.02321965f, -0.10933264f, -0.09017468f, -0.16243093f, 0.37696415f, 
    0.08878883f, -0.02609130f, -0.05348385f, -0.07440532f, 0.01880275f, -0.07593051f, -0.02800453f, 0.07435194f, 
    -0.06532153f, 0.00667385f, 0.16638452f, 0.08087955f, -0.10720009f, 0.05609709f, -0.18874145f, 0.03762376f, 
    -0.23179358f, -0.33353662f, 0.22789592f, 0.04286015f, -0.01191560f, -0.00083263f, -0.02852427f, 0.05578764f, 
    0.11350145f, 0.07162087f, -0.05334692f, 0.06456800f, -0.02048105f, 0.20512384f, 0.01636056f, -0.06858048f, 
    0.19128470f, 0.05168470f, 0.03985330f, 0.03824357f, 0.40307939f, 0.08459642f, 0.13681783f, -0.07466169f, 
    -0.13921167f, 0.00745386f, -0.08306817f, -0.06455590f, -0.02515940f, 0.01437747f, -0.08968665f, 0.05685360f, 
    -0.00367543f, -0.01879715f, -0.02053519f, -0.02099301f, -0.00166974f, 0.03719097f, 0.05443022f, -0.05318543f, 
    0.06548034f, 0.13623440f, -0.17596254f, 0.04311151f, 0.25380200f, 0.05927148f, 0.08632974f, 0.06144044f, 
    0.03915916f, 0.05532136f, -0.14864260f, 0.04244414f, 0.07303118f, -0.03900368f, -0.02002480f, 0.00856253f, 
    0.01979524f, -0.17101903f, 0.11977198f, 0.04918848f, -0.40508613f, -0.00450490f, -0.52167499f, 0.05855445f, 
    0.09026557f, -0.00270800f, -0.15910129f, -0.01786146f, -0.10163195f, 0.15706134f, -0.10548577f, -0.02161725f, 
    -0.09126662f, 0.08126535f, 0.04243483f, 0.06082956f, -0.12644850f, -0.05000063f, 0.03006214f, 0.07771402f, 
    -0.31859034f, -0.02129291f, 0.09864376f, 0.01009786f, 0.13562916f, 0.06541768f, 0.11204658f, 0.08251906f, 
    -0.01660884f, 0.14089938f, -0.00416483f, -0.01466268f, 0.13305540f, 0.02242866f, -0.06300762f, -0.05162419f, 
    0.06935584f, -0.01766962f, 0.05350714f, 0.21935333f, -0.07093254f, -0.10784992f, 0.09463464f, -0.07864705f, 
    -0.19275258f, 0.01398243f, -0.11776333f, 0.09186533f, 0.04366818f, -0.00718447f, -0.06097053f, -0.00737394f, 
    0.04290022f, -0.00969716f, -0.03085852f, -0.00891585f, -0.06323483f, 0.06634573f, -0.02045134f, 0.03221095f, 
    -0.30694288f, 0.02078848f, -0.41871259f, 0.08744602f, 0.04202392f, -0.04929578f, 0.00983870f, -0.00329605f, 
    -0.00531202f, 0.05194183f, 0.02734273f, 0.05759253f, -0.01751751f, 0.03308666f, 0.02522025f, 0.07627115f, 
    -0.06449822f, -0.17419375f, -0.12761287f, -0.05187488f, -0.46387753f, -0.14487979f, 0.00387428f, -0.01934006f, 
    -0.04563257f, 0.13109307f, 0.07855138f, -0.16477737f, 0.14783858f, -0.00404377f, -0.03858724f, -0.15684968f, 
    0.02310908f, -0.03045111f, 0.02570410f, 0.06288228f, 0.18345724f, -0.04131552f, 0.16659500f, -0.00567278f, 
    0.05857004f, -0.05330191f, 0.18514407f, 0.27500761f, -0.04340392f, 0.01117708f, 0.02980394f, 0.03837754f, 
    0.04166173f, -0.00489802f, -0.02857067f, -0.08702530f, -0.03688048f, 0.08533127f, 0.01324829f, 0.03029834f, 
    0.01906665f, 0.10349631f, 0.18861997f, 0.13316904f, -0.20033999f, -0.20981365f, -0.56721479f, -0.15483959f, 
    -0.02809644f, 0.00228689f, -0.16845818f, 0.06469789f, -0.13874510f, -0.16185634f, 0.01646830f, 0.10208625f, 
    0.02196623f, -0.00707325f, -0.05928391f, 0.11037926f, -0.12478654f, -0.12902629f, -0.36378095f, -0.25465682f, 
    -0.01153336f, 0.08128071f, 0.03455310f, -0.03435464f, -0.04557886f, -0.00539479f, -0.02731541f, -0.17881384f, 
    0.09757683f, 0.01436155f, -0.00167528f, 0.01307232f, -0.06442901f, -0.02148297f, -0.12567918f, -0.04320103f, 
    -0.00790152f, 0.07472599f, 0.00586643f, -0.02443025f, -0.19196573f, -0.47833160f, -0.57369977f, -0.15836392f, 
    -0.36243409f, -0.15904242f, -0.28115258f, 0.00544149f, 0.15836513f, -0.00206450f, -0.15505135f, 0.02386977f, 
    -0.11758219f, -0.12473121f, -0.01291135f, 0.04882601f, -0.06327652f, 0.00175872f, 0.13549769f, 0.10058372f, 
    -0.29296491f, -0.01934733f, -0.28203529f, 0.12806705f, 0.00706985f, -0.03947045f, -0.01188354f, 0.02689733f, 
    0.15858018f, 0.04578652f, -0.08995457f, -0.17742147f, 0.04151844f, 0.04593411f, 0.00080545f, 0.05575697f, 
    -0.00505145f, -0.08109740f, 0.18056832f, 0.27491862f, -0.11188958f, 0.05915840f, 0.16879797f, -0.07236435f, 
    0.10188884f, -0.11237936f, -0.04620787f, -0.09885401f, 0.17630568f, -0.17104746f, -0.14122798f, 0.11427660f, 
    0.10292993f, 0.01467110f, 0.07973577f, 0.10106415f, -0.01807119f, -0.01454119f, 0.12380277f, -0.01697291f, 
    0.00226447f, -0.46756500f, 0.21511224f, 0.35370532f, 0.11384238f, -0.02967811f, -0.13073090f, -0.01617238f, 
    -0.16684149f, -0.05098847f, -0.23077443f, -0.04019729f, -0.06188285f, 0.11086626f, 0.16248642f, -0.03942237f, 
    -0.06919669f, -0.00669483f, 0.19294095f, 0.20395176f, 0.01292621f, -0.10653757f, 0.12684569f, 0.11222889f, 
    -0.15443560f, 0.02510537f, -0.07639139f, -0.04999264f, -0.01834655f, 0.07384688f, -0.06771064f, 0.07472786f, 
    0.06917855f, 0.08293509f, -0.04684273f, -0.07774130f, 0.00731781f, 0.07284340f, 0.04699630f, 0.01049585f, 
    -0.16007736f, 0.23593968f, -0.35340190f, 0.15168561f, 0.05060177f, 0.05614553f, -0.04928938f, -0.05922374f, 
    -0.03557484f, 0.04932658f, -0.04012568f, 0.03758202f, -0.10916761f, -0.01902573f, -0.04817150f, -0.06313697f, 
    -0.04430895f, -0.14016558f, 0.05460377f, -0.07598963f, -0.03374448f, -0.22251654f, -0.29387760f, 0.16099644f, 
    -0.05562579f, -0.11811199f, -0.17229973f, 0.06391031f, -0.00672438f, 0.03249507f, -0.09232137f, 0.09479658f, 
    -0.09421011f, 0.00633535f, 0.05495581f, 0.05672906f, -0.14429113f, -0.04600051f, 0.01011236f, 0.10373051f, 
    0.08086576f, -0.06475651f, 0.08228810f, 0.08514485f, 0.07406774f, 0.13355613f, -0.02398415f, 0.01277197f, 
    -0.13656968f, -0.17291468f, 0.03796697f, 0.00092773f, 0.08489813f, 0.12494793f, 0.13505085f, -0.06984282f, 
    -0.06996694f, -0.14054319f, -0.07451570f, -0.21003613f, 0.12130842f, 0.00810948f, -0.02871418f, 0.12627055f, 
    0.11136399f, 0.00451011f, -0.00426521f, -0.06178781f, 0.01763807f, 0.10063950f, -0.14320640f, 0.05710120f, 
    0.07016373f, -0.07842685f, -0.04155788f, 0.03633324f, 0.03167762f, -0.08772741f, 0.09856272f, 0.10483180f, 
    -0.02368315f, 0.00674114f, 0.07548958f, 0.11454467f, -0.05565014f, 0.08635049f, 0.01337463f, 0.12264091f, 
    -0.12318756f, -0.13703071f, 0.04607154f, 0.00270845f, -0.01754643f, 0.06399925f, -0.03364078f, 0.03157965f, 
    -0.05769879f, -0.04111385f, -0.36264756f, -0.11449737f, 0.53753752f, -0.14104715f, 0.25825307f, -0.29419976f, 
    -0.06085381f, -0.16598478f, -0.02886293f, 0.05773152f, -0.00738079f, -0.08388364f, 0.05055179f, -0.03179900f, 
    -0.03658238f, -0.07871051f, -0.04655440f, 0.04597577f, -0.02281792f, 0.09096143f, 0.01173750f, -0.11903069f, 
    0.21155378f, 0.18542762f, -0.54811561f, 0.26098782f, 0.18853915f, 0.10921887f, 0.05376241f, 0.11830193f, 
    -0.08194052f, 0.19203611f, -0.17667483f, 0.01844677f, 0.04035001f, 0.00370139f, 0.00585629f, -0.04833443f, 
    0.11121643f, -0.12185992f, 0.16671792f, 0.16445903f, 0.31103826f, -0.17456611f, -0.01711298f, 0.06231933f, 
    0.01679496f, -0.01584140f, 0.03581048f, 0.10338575f, -0.06131045f, -0.02174270f, 0.06201778f, -0.03888420f, 
    -0.03809389f, -0.00113200f, 0.02733003f, -0.03555127f, -0.16527142f, -0.10993858f, -0.06924040f, -0.13533209f, 
    0.28952095f, -0.19362076f, 0.34944224f, 0.01485800f, 0.01281580f, -0.06411592f, -0.02173494f, 0.02467200f, 
    -0.04919188f, -0.08115803f, -0.07296603f, 0.04191408f, -0.07404925f, 0.04862449f, -0.06434581f, -0.12262379f, 
    0.07461593f, 0.17026110f, -0.13377289f, -0.05146034f, -0.14837500f, -0.03561890f, 0.17616995f, -0.00749163f, 
    -0.12248175f, 0.01549594f, -0.22958010f, -0.18744367f, 0.12271941f, 0.07976099f, -0.02614395f, 0.00814296f, 
    0.01079123f, -0.05322955f, -0.16224277f, 0.02077451f, -0.00689949f, 0.01021069f, 0.02143677f, -0.12334880f, 
    -0.15955099f, 0.07425854f, -0.06492913f, 0.16122597f, 0.07927399f, 0.07887695f, 0.03010586f, -0.10194995f, 
    -0.08510496f, 0.20923743f, -0.11915839f, 0.03390161f, 0.03611617f, -0.05205196f, 0.04376523f, -0.02102597f, 
    0.14936680f, -0.15717910f, 0.06379012f, 0.00084755f, -0.08401623f, 0.04397837f, -0.21315165f, -0.13594063f, 
    -0.02830864f, 0.15104942f, -0.14198235f, 0.05693408f, -0.04312954f, -0.02704819f, -0.08923444f, 0.09516518f, 
    -0.04126440f, -0.17634453f, -0.09581001f, 0.03940019f, -0.02234190f, 0.08051952f, -0.05761648f, -0.12725176f, 
    0.12659259f, -0.03660060f, 0.26460817f, 0.01094363f, -0.08738509f, -0.05339029f, 0.07436460f, 0.14475110f, 
    0.05678250f, 0.01220505f, 0.02200682f, -0.05043703f, -0.07452802f, 0.09453171f, -0.07827134f, -0.10332997f, 
    0.08784853f, 0.15700611f, -0.05046842f, 0.01069173f, -0.07585938f, -0.24440894f, -0.02538416f, -0.19476016f, 
    0.06518871f, -0.00658301f, -0.06688095f, 0.00805940f, -0.08827063f, -0.18349206f, -0.08881285f, 0.04306705f, 
    -0.00464845f, 0.01467587f, 0.03630866f, 0.23107296f, -0.24200021f, -0.03623103f, -0.13097744f, -0.07918027f, 
    -0.06660181f, -0.39353365f, -0.10743603f, 0.11255569f, -0.01088971f, -0.20983715f, -0.31679535f, 0.01985625f, 
    -0.17140241f, -0.10278323f, 0.05812650f, 0.04695301f, -0.00069245f, -0.05921130f, -0.06324008f, 0.04882392f, 
    -0.03008023f, 0.01934351f, 0.07404009f, -0.14676777f, -0.30472076f, -0.40838787f, -0.28005645f, -0.09636603f, 
    -0.06048552f, 0.04462373f, -0.21456061f, -0.04548311f, 0.10920389f, -0.23289937f, -0.07742919f, 0.06728748f, 
    -0.01520905f, -0.05639220f, 0.03646286f, 0.05232193f, -0.00054024f, 0.04813455f, 0.19551769f, 0.01489219f, 
    0.13371202f, -0.42247340f, 0.11806029f, -0.11654859f, 0.01537996f, -0.00006711f, -0.27893925f, -0.20106483f, 
    0.11632447f, -0.07482401f, 0.03394851f, 0.04740228f, -0.01973170f, 0.07525095f, -0.06544239f, -0.04626850f, 
    -0.04706958f, -0.08482941f, 0.02251606f, 0.13377520f, -0.42476779f, 0.03909458f, -0.34593964f, 0.26256594f, 
    -0.02651643f, -0.03617785f, 0.12936695f, -0.03107693f, 0.09971184f, -0.01938015f, -0.19062074f, 0.03669924f, 
    0.05649873f, -0.00641626f, -0.01740915f, 0.02355473f, 0.01292278f, 0.07144798f, -0.05887412f, 0.13367313f, 
    -0.19551864f, -0.12572789f, -0.11384401f, 0.14853351f, -0.47380394f, -0.08347629f, 0.04556553f, -0.10902888f, 
    0.06737155f, -0.06104534f, -0.02609259f, 0.06253644f, 0.06099073f, 0.01553091f, 0.00742147f, 0.00059371f, 
    -0.00869717f, 0.02513913f, 0.04479386f, 0.07564465f, -0.04143080f, -0.10828356f, -0.01751761f, 0.04833226f, 
    0.04697123f, 0.11902197f, 0.05990605f, 0.02212443f, 0.08199011f, -0.15634085f, -0.00595132f, 0.04645054f, 
    0.05717596f, -0.10079625f, 0.12779316f, -0.01599044f, -0.06427957f, 0.00071425f, -0.02808711f, 0.00162467f, 
    -0.01206099f, -0.17599857f, 0.22531815f, -0.21188179f, -0.45503750f, -0.02707766f, -0.11184169f, -0.06284721f, 
    -0.10156493f, -0.02396973f, -0.02350877f, 0.01520880f, 0.03899161f, 0.01913992f, 0.03027379f, 0.03479297f, 
    -0.02255334f, 0.01240221f, 0.09756615f, 0.05080661f, -0.04101757f, -0.25267559f, -0.31201756f, -0.28099471f, 
    -0.12160069f, -0.23391040f, -0.11078555f, 0.08698869f, -0.14129494f, -0.01541368f, 0.00198099f, 0.02333757f, 
    -0.00961874f, -0.06086989f, -0.07013454f, 0.08527450f, 0.00109747f, -0.10783488f, -0.07428817f, 0.01837157f, 
    0.05219550f, -0.19660239f, -0.13432759f, -0.18484581f, 0.00061211f, -0.14658950f, -0.17696570f, 0.00981921f, 
    -0.10773006f, -0.08453936f, -0.00925895f, 0.02686372f, 0.00265625f, -0.06254034f, -0.04738426f, 0.04019085f, 
    -0.05161453f, -0.02262190f, -0.01554795f, -0.02245975f, -0.09123766f, -0.02919846f, -0.03597696f, 0.07414408f, 
    0.00736673f, -0.00528034f, -0.03951280f, -0.00101433f, -0.08635464f, -0.06986573f, -0.02025250f, 0.08031330f, 
    -0.07208034f, -0.04205705f, -0.08306617f, 0.04386546f, -0.13344434f, -0.13779806f, -0.30102062f, -0.06510957f, 
    0.06687094f, -0.45694256f, -0.24312343f, -0.34406143f, -0.09025073f, -0.12256431f, -0.09081523f, 0.02580770f, 
    0.03566001f, -0.10486805f, 0.03806384f, -0.03480089f, 0.06762291f, -0.08298006f, -0.07598302f, 0.01034423f, 
    0.02986252f, -0.00934360f, 0.05808927f, -0.05200762f, 0.03832625f, -0.15586169f, 0.13864729f, 0.02377477f, 
    -0.11349739f, 0.18614486f, 0.02123025f, 0.11809057f, 0.02072695f, 0.03539657f, -0.08456600f, 0.07077245f, 
    -0.19280872f, 0.03129626f, -0.01573772f, 0.05358908f, 0.11086353f, 0.20233808f, -0.08586334f, 0.15712725f, 
    -0.51519597f, -0.16411614f, -0.03167315f, 0.24214925f, -0.21904251f, -0.09283183f, 0.01822158f, -0.06596012f, 
    0.18676753f, 0.03206153f, -0.16106749f, -0.03186411f, -0.07130480f, -0.11669213f, 0.07403272f, 0.02795123f, 
    0.07147971f, 0.11443186f, -0.04128272f, -0.08274029f, -0.50459939f, -0.11632070f, -0.30250069f, 0.15025367f, 
    0.00613509f, 0.14640519f, 0.15542248f, 0.13362664f, -0.12799346f, 0.00351711f, -0.01240425f, -0.02889037f, 
    0.07713732f, 0.17575656f, 0.04201932f, 0.04057123f, -0.05462883f, 0.06951338f, 0.03419204f, 0.05064055f, 
    0.35938907f, 0.03473917f, 0.33162168f, 0.06281056f, 0.00593949f, 0.11058611f, 0.12638943f, -0.16636874f, 
    0.12291396f, 0.00773505f, -0.04770019f, 0.11494575f, -0.01118005f, 0.09083000f, 0.02977818f, -0.16082981f, 
    -0.02892509f, -0.06206198f, -0.15702130f, 0.01996033f, -0.20798862f, -0.12307405f, 0.08666024f, 0.46423417f, 
    -0.13433343f, 0.00811729f, 0.05034704f, 0.12180901f, 0.09908044f, -0.19335872f, -0.00661005f, -0.06722318f, 
    -0.02134378f, 0.03388623f, -0.01928373f, 0.12992628f, -0.00910037f, -0.03285095f, 0.03862351f, 0.00388250f, 
    0.48344690f, -0.12541538f, 0.04611111f, 0.16625246f, 0.06832217f, -0.06142997f, 0.06434102f, -0.13003336f, 
    0.12040511f, -0.14368938f, -0.06460239f, -0.00526560f, -0.02209086f, -0.05251767f, -0.07351924f, 0.13137372f, 
    0.00183412f, 0.02302856f, 0.03823867f, 0.04470899f, 0.30036399f, 0.09864659f, 0.13122998f, -0.04226448f, 
    0.16075702f, 0.05473070f, 0.18079691f, -0.13633627f, 0.05920637f, 0.00562884f, -0.13750680f, 0.04817820f, 
    0.00187141f, 0.12606132f, 0.01282794f, 0.04727516f, -0.09978855f, -0.12237275f, -0.20812550f, 0.16708617f, 
    -0.38186184f, -0.10911381f, -0.21320157f, -0.06735825f, 0.09556164f, -0.04084564f, 0.06509330f, -0.12473936f, 
    0.10915373f, 0.04387616f, -0.17681797f, 0.10592274f, 0.02025718f, 0.06264065f, -0.07316216f, 0.17073716f, 
    -0.00517152f, 0.02352131f, 0.04049025f, -0.14250146f, -0.21869545f, 0.13533996f, -0.24545979f, 0.14294294f, 
    0.10143034f, 0.02255967f, 0.11659385f, 0.08265495f, -0.17048055f, 0.14471990f, 0.00397605f, 0.13353795f, 
    -0.06816637f, -0.01453971f, -0.04589031f, 0.06837299f, 0.08024671f, 0.09636006f, 0.08360501f, 0.00194649f, 
    -0.05522221f, 0.00696270f, -0.15544815f, 0.12758392f, 0.14826901f, -0.09228203f, -0.00229853f, -0.05906171f, 
    -0.09947035f, -0.06667060f, 0.03144295f, 0.10627203f, -0.02470913f, -0.07678019f, 0.02700744f, 0.03340667f, 
    -0.10432922f, -0.09958053f, -0.12111144f, -0.03813384f, 0.02617520f, -0.14900638f, -0.14982960f, -0.00286953f, 
    0.05157422f, -0.03650055f, 0.11828397f, -0.10449014f, 0.05570612f, -0.11372335f, -0.11257531f, 0.04039672f, 
    0.04307872f, -0.00801357f, 0.01460054f, 0.02476830f, 0.00878826f, 0.07894814f, 0.01524765f, 0.00444302f, 
    0.10078400f, 0.02530139f, -0.04856061f, 0.01680646f, 0.02528104f, -0.02939660f, 0.15337096f, 0.00763970f, 
    0.10875607f, 0.00229323f, -0.14693667f, 0.04241411f, 0.05112893f, 0.00422950f, -0.03177084f, 0.05823906f, 
    -0.07050455f, 0.03377052f, -0.18753734f, 0.01589724f, 0.14024392f, -0.10282996f, 0.10878342f, -0.20828962f, 
    0.10048032f, 0.04239705f, 0.05346759f, -0.00948344f, 0.15128694f, -0.08751108f, 0.05865614f, 0.05220832f, 
    0.00154919f, 0.04670434f, 0.00609907f, -0.06473663f, 0.03571910f, -0.05972125f, -0.01088357f, -0.05330389f, 
    -0.42081669f, -0.13208182f, -0.31887788f, 0.06216504f, -0.42654878f, -0.08116377f, 0.02452510f, 0.01779337f, 
    -0.04086452f, 0.01713265f, -0.16028675f, -0.04875347f, 0.12779324f, -0.03888220f, -0.06308306f, -0.01517035f, 
    -0.02099502f, 0.00010462f, 0.00113896f, 0.05074211f, 0.20813562f, -0.03144531f, 0.00822395f, 0.36681578f, 
    0.24519166f, -0.00633657f, 0.18944436f, -0.20055950f, 0.12367724f, 0.11427623f, -0.02012078f, 0.00741623f, 
    -0.03586248f, -0.02295934f, 0.04912380f, 0.01850492f, 0.14189146f, -0.11024517f, 0.07084323f, 0.06164430f, 
    0.28550413f, 0.12372703f, 0.24450994f, -0.11399561f, -0.10637026f, -0.01648493f, 0.10540281f, -0.00533343f, 
    0.05141340f, 0.01383022f, -0.08041907f, 0.03441521f, 0.01648816f, 0.03027865f, -0.05919477f, -0.00080649f, 
    0.08150554f, 0.01505266f, -0.06185753f, 0.07757253f, 0.18151493f, -0.40322781f, 0.30027238f, -0.35575041f, 
    0.16497894f, -0.17668471f, 0.04847530f, 0.02355641f, 0.03968204f, -0.15794624f, -0.06413814f, 0.01113444f, 
    0.04559651f, -0.04793761f, -0.06562395f, 0.05165376f, 0.18064612f, -0.09289671f, -0.03843992f, -0.10071854f, 
    -0.03864520f, -0.03994717f, 0.05051006f, -0.10006814f, 0.09204859f, 0.07422296f, 0.09960907f, 0.06355861f, 
    0.07327176f, 0.05306917f, 0.03085766f, 0.03618494f, -0.02386474f, -0.00236430f, 0.01228395f, -0.06575167f, 
    -0.00766159f, -0.06529865f, -0.08534580f, -0.00794360f, 0.10526294f, -0.02436719f, 0.15972197f, 0.31859308f, 
    0.04902105f, -0.09694611f, 0.09767383f, -0.11058611f, 0.14057995f, 0.05512954f, -0.09873316f, -0.03580862f, 
    0.03786755f, 0.07385527f, 0.01581269f, -0.08342415f, 0.02921302f, 0.03072751f, 0.05901599f, -0.10628502f, 
    0.09178829f, -0.33029863f, 0.06640317f, -0.06587385f, 0.25512165f, 0.02284634f, -0.14544936f, -0.18244410f, 
    0.05359169f, -0.02573614f, 0.04125282f, 0.06016501f, -0.01029793f, 0.02392741f, -0.01136113f, 0.11018127f, 
    0.03611019f, 0.03225857f, -0.00495298f, 0.00761066f, -0.05688201f, -0.48378104f, -0.11274523f, 0.14158420f, 
    0.31487456f, -0.10051365f, -0.03930524f, -0.16571075f, 0.13260718f, -0.08226142f, 0.08922244f, 0.08137967f, 
    0.05056518f, -0.05510229f, 0.00269186f, 0.11087134f, -0.01388257f, -0.09859567f, 0.18626247f, -0.01092212f, 
    0.31988719f, 0.18271764f, 0.26863223f, 0.10442097f, 0.03456842f, 0.02666871f, 0.01260833f, 0.05064518f, 
    0.08367112f, -0.08199757f, -0.04742162f, -0.00389607f, -0.06548148f, -0.04589655f, -0.11141913f, 0.11968421f, 
    -0.05522604f, -0.01882587f, 0.09020401f, 0.02251128f, 0.26398024f, -0.38450116f, 0.16952369f, 0.24385846f, 
    -0.05406509f, -0.09095359f, 0.16709505f, 0.03535357f, 0.17238787f, -0.23593409f, -0.16089597f, -0.11044471f, 
    0.07875267f, -0.01273052f, -0.01128260f, -0.05302193f, -0.06640305f, 0.10551259f, 0.06804404f, -0.03098677f, 
    -0.28709951f, 0.17491367f, -0.16711320f, 0.20186850f, 0.00167772f, 0.08822305f, -0.03843221f, 0.21104534f, 
    -0.29827911f, -0.07235210f, -0.09480158f, 0.14194921f, 0.03527450f, -0.05214535f, 0.05835528f, -0.00290994f, 
    -0.11526079f, -0.02940673f, 0.03678111f, -0.04573099f, -0.15701646f, -0.04776752f, -0.29544863f, -0.10311933f, 
    -0.04962677f, 0.02191212f, 0.10864263f, 0.04933834f, -0.04049239f, 0.07740986f, -0.01893115f, 0.00063716f, 
    0.07212437f, 0.08616177f, 0.01522292f, 0.00357415f, -0.09191786f, -0.03260152f, -0.04481650f, 0.07556810f, 
    -0.25534648f, -0.13901269f, -0.09675119f, 0.28027472f, -0.08918141f, -0.06101469f, -0.15590286f, -0.09595262f, 
    -0.14278886f, 0.00314868f, -0.03826482f, -0.10379200f, -0.06828053f, -0.06945108f, -0.04938889f, 0.07257263f, 
    -0.02516562f, 0.00162622f, 0.03125909f, -0.07325429f, 0.04260530f, -0.18899170f, -0.20705609f, 0.15373151f, 
    -0.16379914f, -0.14393447f, -0.00238886f, 0.04732654f, -0.15650509f, 0.03598703f, 0.03308897f, 0.01741382f, 
    0.17763396f, 0.03796690f, -0.07757343f, 0.03140993f, -0.06969919f, 0.13453068f, -0.03942461f, -0.02398629f, 
    -0.20274088f, 0.04541634f, -0.14723140f, 0.40327582f, 0.20206024f, -0.13447799f, 0.00075310f, -0.03041633f, 
    -0.15083186f, -0.05547678f, 0.02140448f, -0.09577049f, -0.07782137f, -0.01281293f, 0.08861059f, -0.01961836f, 
    -0.04611675f, 0.05569017f, -0.06821284f, -0.21352774f, -0.06420811f, 0.05347218f, -0.01514501f, 0.09783266f, 
    -0.06373922f, 0.00404359f, 0.05830165f, 0.10631489f, 0.08076603f, 0.00336215f, -0.07465767f, -0.00222746f, 
    -0.06509876f, 0.05210657f, -0.14878668f, 0.06307519f, 0.01599803f, 0.06286672f, -0.08629850f, -0.02684705f, 
    -0.06691746f, -0.26532626f, -0.06755847f, 0.09348723f, -0.06067283f, -0.01654289f, -0.16054900f, 0.06316364f, 
    -0.11179088f, -0.16784027f, -0.03137600f, 0.00208308f, 0.03490415f, 0.02441468f, -0.02248114f, 0.03810634f, 
    -0.06348142f, 0.04799831f, 0.02604269f, -0.03004256f, 0.43020484f, -0.14256553f, 0.35615137f, 0.19931836f, 
    0.11601023f, 0.01444043f, 0.20447211f, -0.08524720f, 0.14678422f, -0.11612660f, -0.05008529f, 0.13586392f, 
    0.01710705f, -0.08129614f, 0.19849485f, -0.04444733f, -0.11329326f, 0.03196275f, -0.03793730f, -0.17548999f, 
    0.03946317f, 0.00238301f, -0.08843181f, 0.21223867f, 0.13789441f, -0.02440244f, 0.22481981f, -0.02606471f, 
    0.10426445f, 0.12540403f, -0.03785080f, -0.02901867f, -0.03304617f, 0.00723981f, 0.09602744f, -0.02263271f, 
    0.06738602f, -0.06134359f, -0.05860958f, -0.09265153f, 0.11012036f, -0.31312603f, -0.03801179f, -0.07626715f, 
    0.00535782f, -0.17548852f, -0.24058495f, -0.14244480f, -0.04298792f, -0.20823918f, -0.03912073f, 0.05410813f, 
    0.00744952f, -0.00675583f, 0.00455713f, 0.02685012f, -0.02253676f, 0.07780276f, 0.16575892f, -0.01640688f, 
    -0.29851514f, -0.08591665f, -0.26362062f, 0.17390977f, -0.11270808f, -0.02450526f, 0.02958693f, -0.04658056f, 
    0.16924414f, -0.15519287f, -0.00959212f, -0.01550201f, 0.07551154f, -0.08523449f, 0.05153232f, 0.01077258f, 
    -0.05194519f, 0.03896726f, -0.02715140f, 0.05662119f, 0.32701954f, 0.25238565f, 0.29265386f, -0.03016787f, 
    -0.47068048f, -0.09722235f, -0.02039213f, 0.05563559f, 0.09764420f, -0.01970888f, -0.10302332f, -0.01677909f, 
    0.01505402f, -0.06164696f, -0.00848064f, -0.00977094f, 0.10162561f, 0.01495512f, 0.01879462f, -0.00955228f, 
    -0.16877972f, -0.24713451f, -0.09821066f, 0.28312835f, 0.04088299f, -0.11542562f, -0.09474804f, 0.02799783f, 
    0.00981868f, -0.13802235f, 0.00016847f, 0.03704859f, -0.09474932f, -0.10610501f, 0.04032876f, -0.08874654f, 
    0.00217407f, 0.09294906f, -0.12985444f, -0.31882742f, 0.14628205f, -0.42414355f, 0.07764269f, -0.29529777f, 
    0.13443021f, 0.08850160f, -0.03854754f, -0.10415124f, 0.02199828f, -0.12756310f, -0.03236633f, 0.01372159f, 
    0.00320949f, 0.09185556f, -0.03124903f, 0.07134350f, 0.07689644f, 0.07458948f, -0.02498846f, -0.05680111f, 
    0.04221005f, -0.11972325f, 0.19386607f, -0.14810733f, -0.15694657f, 0.09352892f, 0.08254968f, 0.07156797f, 
    0.20442590f, 0.08222603f, 0.25805742f, 0.05016224f, 0.14628394f, -0.00366028f, -0.01370210f, -0.02041366f, 
    0.09956849f, -0.15156423f, 0.11406569f, -0.34622023f, -0.06601126f, -0.00838117f, -0.18659551f, 0.22766253f, 
    0.11147197f, -0.05611958f, 0.12149983f, 0.03115122f, 0.13099509f, 0.12160303f, -0.09834795f, -0.02578435f, 
    0.02438193f, 0.11912435f, -0.04807886f, -0.04615401f, 0.06762122f, 0.03550879f, -0.11102334f, -0.07945403f, 
    -0.64565581f, 0.07002442f, -0.29873618f, 0.25936607f, -0.15524076f, -0.02582897f, 0.10539319f, -0.01410766f, 
    0.01099787f, 0.01112545f, -0.24820851f, -0.03976300f, 0.14065890f, 0.08368611f, -0.00351744f, 0.08889082f, 
    0.02809917f, 0.05078631f, -0.08299784f, 0.06841233f, 0.30766448f, 0.20474662f, 0.37570056f, 0.14033307f, 
    -0.31710958f, -0.09902763f, -0.02773342f, -0.03359246f, -0.02899978f, -0.02904218f, -0.03249377f, -0.04894275f, 
    0.06532118f, 0.00102359f, -0.01519040f, -0.03112653f, 0.08752645f, 0.04381252f, 0.03352883f, 0.01670151f, 
    -0.48854151f, -0.07333459f, -0.19745478f, 0.11460437f, 0.01982023f, 0.11018488f, 0.12357166f, 0.16785081f, 
    -0.20974399f, 0.06803918f, 0.01447278f, 0.03385771f, 0.04768442f, 0.08427679f, 0.15864825f, 0.08811504f, 
    0.14932276f, 0.15320748f, 0.16341400f, 0.12442627f, -0.30103654f, -0.26113650f, -0.08979301f, 0.18209718f, 
    -0.11836325f, -0.05456664f, -0.15783609f, -0.02523631f, -0.01329177f, 0.03576184f, -0.08017079f, -0.07797758f, 
    -0.10044185f, -0.23310897f, -0.08099347f, -0.04526750f, -0.08337703f, -0.03958236f, -0.01021522f, -0.13582624f, 
    0.12366270f, -0.31387115f, -0.08754712f, 0.24373348f, 0.18961601f, -0.01967691f, 0.04626705f, -0.09050905f, 
    -0.01419490f, -0.09250063f, -0.01520967f, 0.00407750f, 0.08442333f, -0.03651365f, 0.08646668f, 0.09220128f, 
    -0.04713525f, 0.03270708f, 0.12542483f, -0.00376188f, -0.09307743f, -0.33865243f, 0.09158360f, -0.23245013f, 
    0.38957205f, 0.15674050f, 0.33898246f, 0.17096426f, -0.04630984f, 0.06903311f, -0.01526930f, 0.08437711f, 
    0.11181597f, 0.12269743f, 0.08807370f, -0.03452920f, 0.12710550f, 0.03107196f, -0.14568816f, 0.09010867f, 
    -0.46254534f, -0.00429307f, 0.11386202f, 0.27365685f, -0.09915633f, -0.14546065f, 0.04827354f, 0.08009450f, 
    0.20537692f, 0.15387627f, -0.10363937f, -0.09206562f, -0.11368534f, -0.09872492f, -0.09325602f, 0.04262472f, 
    -0.00152447f, 0.12004410f, 0.10838547f, -0.13167727f, -0.25528529f, -0.20417185f, -0.09650021f, -0.15132779f, 
    0.09583601f, -0.01353732f, 0.09067664f, 0.09735693f, 0.03287540f, 0.02892508f, -0.00805824f, 0.12363174f, 
    0.04755378f, 0.04239412f, -0.01374080f, -0.03859587f, 0.09010376f, 0.04803729f, 0.06988294f, 0.01392574f, 
    -0.10071662f, 0.11548916f, -0.32133192f, 0.28221062f, 0.22236308f, 0.05332664f, 0.06419139f, 0.03135079f, 
    0.00507015f, 0.00646922f, 0.06034412f, -0.01333813f, 0.00312884f, -0.07882376f, -0.07413121f, -0.05109714f, 
    0.00553870f, 0.10463601f, 0.21734574f, 0.04180911f, -0.23363157f, 0.13484703f, -0.07167171f, 0.04108885f, 
    -0.17946772f, 0.05020697f, 0.10256498f, 0.05010835f, 0.05008915f, -0.02836557f, -0.01924286f, -0.15332851f, 
    0.08874749f, -0.01036276f, 0.16143502f, 0.07107574f, -0.09570488f, -0.06498328f, -0.15057474f, -0.04983686f, 
    -0.24236736f, 0.17682652f, 0.10836265f, 0.18838231f, -0.00831589f, 0.06000292f, -0.00025626f, 0.18658303f, 
    0.01858324f, -0.04550051f, -0.08430045f, -0.18187609f, -0.02576355f, -0.11500355f, 0.20368133f, 0.09421344f, 
    -0.31998894f, 0.01438750f, 0.12469097f, -0.14181226f, -0.38417968f, -0.26223359f, -0.37027666f, -0.01935410f, 
    -0.41946667f, 0.03966090f, 0.16920319f, 0.06751047f, -0.24286090f, -0.00967007f, -0.04414297f, -0.00485206f, 
    0.16075240f, 0.22628976f, 0.02952523f, -0.01557690f, 0.04095042f, 0.13336647f, 0.00574873f, 0.11590135f, 
    0.14710346f, 0.03389589f, 0.01563083f, 0.13123159f, 0.21927069f, -0.01181727f, 0.06556784f, -0.15084244f, 
    0.14032741f, 0.03804429f, 0.03755962f, 0.10680372f, -0.09085514f, -0.01281924f, 0.03021753f, -0.04533518f, 
    0.01272951f, -0.01315294f, 0.04422653f, -0.06526343f, 0.45969957f, -0.19386947f, 0.43546781f, -0.15055218f, 
    0.10084993f, 0.02680524f, -0.04534946f, 0.01969731f, 0.07556169f, -0.02001050f, -0.03978060f, -0.06957963f, 
    -0.02424908f, 0.00908692f, -0.06154343f, 0.08221384f, 0.02901334f, 0.08045438f, -0.16236612f, 0.15283801f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15700033f, 0.11081886f, 0.00669308f, -0.05124487f, -0.03770272f, 0.00483389f, 0.05875311f, -0.07136518f, 
    0.01221450f, 0.05875363f, 0.03959407f, 0.00704048f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
