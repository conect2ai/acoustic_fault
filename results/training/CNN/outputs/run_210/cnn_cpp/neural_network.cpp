#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13964087f, 0.20882297f, 0.64965183f, 0.70340824f, -0.22421457f, 0.17030932f, 0.19575796f, 0.12068476f, 
    0.30063260f, 0.29854578f, 0.09669670f, -0.26166677f, -0.37648624f, -0.29165381f, -0.06872735f, -0.16977315f, 
    -0.11049155f, -0.00390151f, -0.11178157f, -0.24738270f, 0.25882387f, -0.12158629f, -0.23855422f, -0.17143868f, 
    -0.05689808f, 0.40757492f, -0.06763552f, -0.48972693f, -0.24079819f, 0.22533512f, 0.43497279f, 0.50984144f, 
    -0.44604966f, -0.06548218f, 0.28035232f, -0.01846546f, 0.38657808f, -0.10553420f, 0.27590719f, -0.11441664f, 
    0.22931413f, -0.20699808f, 0.13602157f, -0.16850303f, 0.11957584f, -0.07468163f, 0.07105161f, 0.10918051f, 
    0.05337251f, -0.05807642f, 0.34341499f, -0.02487203f, 0.63967878f, 0.70533377f, 0.01072900f, 0.66890997f, 
    -0.30947378f, -0.42069677f, -0.08310046f, 0.25253502f, -0.18254955f, 0.24161282f, 0.15999654f, -0.07962962f, 
    -0.16034791f, -0.00619663f, 0.22477354f, -0.01966818f, 0.08864840f, 0.15654287f, 0.20699471f, 0.09263985f, 
    -0.29543340f, 0.01058762f, -0.13076489f, -0.15131699f, 0.04567499f, -0.20497042f, -0.39431629f, -0.32561830f, 
    0.28340790f, -0.48828858f, -0.03796884f, 0.04002195f, -0.01173356f, -0.24322388f, -0.25252697f, -0.28045040f, 
    -0.13141200f, -0.30115151f, 0.22044520f, 0.26268625f, -0.19559544f, -0.32042232f, 0.05346547f, -0.00481215f, 
    0.12768407f, 0.10485631f, 0.25055748f, -0.23764633f, -0.06963460f, -0.41510710f, -0.25762993f, -0.39845109f, 
    -0.22218521f, -0.42983291f, -0.39867315f, -0.13778472f, 0.11310656f, -0.17489547f, -0.32204926f, -0.07887858f, 
    -0.11290953f, -0.31786263f, 0.02809203f, 0.02162600f, -0.12047210f, 0.19004397f, -0.03794051f, 0.10823575f, 
    0.02061658f, 0.25955006f, 0.11705995f, 0.19074930f, -0.11082443f, -0.54525882f, -0.00295122f, 0.21590458f, 
    -0.33283743f, -0.43468478f, 0.63613266f, -0.38071615f, 0.01953313f, -0.12854406f, 0.27729732f, 0.18534817f, 
    0.07321119f, 0.20952137f, 0.35947636f, 0.33426046f, -0.23499203f, -0.11952812f, -0.33348086f, -0.03534171f, 
    -0.00496631f, -0.09251480f, 0.13080733f, 0.22406487f, 0.14840287f, 0.16696571f, -0.31302515f, -0.48875052f, 
    -0.36748701f, -0.37169793f, -0.01864535f, -0.31263945f, 0.03721916f, -0.17417304f, -0.02733813f, 0.14092390f, 
    0.34878942f, 0.14630872f, 0.29375339f, 0.31045568f, 0.37562266f, 0.08325827f, -0.11514860f, -0.20294815f, 
    0.08741576f, 0.04175583f, 0.34059280f, -0.01933183f, 0.28144446f, 0.00495386f, 0.12106454f, -0.48931667f, 
    -0.48973244f, -0.19433115f, 0.05661864f, -0.42844835f, -0.14938676f, -0.18997324f, 0.17596380f, -0.04878968f, 
    0.23002657f, 0.22919172f, 0.21066198f, -0.24513516f, 0.15554413f, -0.11775458f, 0.03006137f, 0.35473934f, 
    0.12349075f, 0.13191524f, -0.08962886f, -0.34219670f, -0.32221001f, 0.18582329f, -0.14263292f, 0.04524839f, 
    -0.06892161f, -0.46153194f, -0.37004286f, 0.25050062f, -0.34538239f, -0.40456009f, -0.38773164f, -0.26106364f, 
    0.45610994f, -0.30606514f, 0.13227013f, 0.17165303f, -0.00520952f, 0.24413647f, -0.13060172f, -0.10750720f, 
    -0.18645576f, 0.02050399f, 0.26331127f, 0.02410878f, -0.04055975f, 0.07128651f, -0.31733069f, -0.02629245f, 
    0.00182872f, -0.35754007f, -0.49989507f, -0.21945979f, -0.32239601f, -0.45819560f, -0.03235552f, 0.11283369f, 
    -0.32317114f, -0.09941292f, 0.14886919f, 0.26402754f, 0.20078652f, -0.14385493f, 0.15275976f, -0.22981726f, 
    0.09896729f, 0.01073602f, 0.25589666f, 0.00166939f, 0.10721622f, 0.14177607f, 0.05061454f, -0.27360362f, 
    0.10586061f, 0.14202178f, 0.28026226f, 0.67396981f, 0.35469073f, 0.15682964f, 0.12062587f, -0.24420589f, 
    0.18012060f, -0.03363712f, -0.35001278f, 0.28115189f, -0.19171138f, 0.20115082f, 0.19872288f, 0.00985066f, 
    0.17503349f, -0.28197229f, -0.25785375f, -0.13105285f, -0.38567510f, -0.24176201f, -0.07450908f, 0.15121256f, 
    0.02922731f, 0.24447761f, 0.18039307f, -0.10269909f, -0.22274689f, 0.33128771f, 0.22483176f, -0.07408505f, 
    -0.03235028f, 0.28520274f, -0.00311293f, 0.50065041f, 0.45939630f, -0.34362534f, 0.27002940f, 0.11224646f, 
    0.46425483f, -0.32249194f, -0.18966568f, -0.02437870f, 0.43247089f, -0.19588631f, -0.06309463f, 0.30338988f, 
    0.02532625f, 0.05773016f, -0.16457736f, -0.00264650f, 0.39214584f, -0.29167405f, -0.53936523f, -0.43519741f, 
    -0.39834347f, -0.06204250f, 0.52751386f, 0.59832913f, 0.08844141f, 0.29756168f, 0.03023349f, -0.20594592f, 
    -0.11312893f, -0.14803103f, 0.20314044f, -0.12789713f, -0.10918029f, 0.06590067f, 0.17528056f, 0.20176421f, 
    -0.11648919f, -0.02435670f, -0.05349539f, 0.33849236f, 0.02984213f, -0.69057214f, -0.33158013f, -0.32550487f, 
    -0.05418992f, -0.11245732f, 0.45707810f, 0.49455076f, 0.17338309f, 0.40037537f, 0.48517948f, 0.11799558f, 
    -0.42506295f, -0.02420053f, -0.37104535f, -0.04954588f, 0.17080678f, -0.08973552f, 0.05922857f, -0.11447759f, 
    -0.07439440f, -0.22762896f, -0.16919424f, 0.07760827f, -0.02106323f, 0.04716530f, -0.46972698f, 0.38721102f, 
    0.38314569f, 0.15554538f, 0.50926983f, 0.56400001f, 0.41800734f, -0.20129921f, -0.07966534f, -0.09989557f, 
    0.06252615f, 0.16324587f, 0.19168034f, -0.06259276f, -0.03365028f, 0.00520339f, 0.13473995f, 0.09542502f, 
    0.00964095f, -0.03379216f, 0.28266314f, 0.16607489f, -0.04491670f, 0.02603830f, -0.18485783f, -0.57072407f, 
    0.58302474f, -0.33493885f, -0.43421364f, -0.29786971f, 0.62933040f, -0.22386466f, -0.28609860f, 0.06425974f, 
    0.24189584f, -0.24956323f, -0.20271635f, -0.22644527f, 0.11348660f, -0.10854442f, -0.19522689f, 0.03385578f, 
    -0.02850471f, -0.02697588f, 0.09886626f, -0.00775313f, -0.07861078f, 0.01450449f, 0.02954912f, 0.11839147f, 
    0.17246483f, -0.13254672f, 0.06818175f, 0.05723949f, 0.37793204f, -0.04305397f, 0.46988428f, -0.30140820f, 
    -0.53232384f, -0.08429255f, -0.06223841f, 0.12196235f, 0.16889466f, -0.14216724f, -0.01407386f, -0.37485468f, 
    -0.00031124f, -0.05538567f, -0.31571761f, -0.44006640f, 0.09833306f, -0.11397408f, 0.31009290f, 0.13511148f, 
    0.05037568f, -0.20376737f, -0.38710877f, -0.47985104f, 0.09047061f, 0.37636685f, 0.41970596f, 0.65963537f, 
    0.25037414f, 0.02307281f, 0.28239936f, -0.06907305f, 0.12943263f, -0.07147795f, 0.20419332f, -0.17854877f, 
    -0.03538663f, 0.20775175f, -0.36091191f, -0.18964992f, -0.07959495f, 0.26436874f, -0.22710833f, 0.09337499f, 
    -0.08518039f, -0.03073816f, -0.27692232f, -0.37922037f, -0.27046365f, -0.34345916f, -0.30014771f, -0.23072556f, 
    -0.05522871f, -0.03704600f, 0.07120888f, 0.26730761f, -0.15863110f, 0.15183672f, -0.22236872f, 0.16967757f, 
    -0.11261450f, 0.22579868f, 0.01933817f, 0.26956162f, 0.03122132f, -0.22848004f, -0.17492761f, 0.10239822f, 
    -0.18147446f, 0.23372076f, 0.34595695f, 0.60552764f, 0.26686755f, -0.33463785f, 0.47630250f, -0.39315474f, 
    0.04780704f, 0.19121373f, -0.07927386f, -0.35253814f, 0.05871793f, 0.02075053f, 0.07979836f, 0.22103648f, 
    0.17323032f, 0.17996444f, 0.24389082f, -0.07466277f, -0.05220374f, 0.14014907f, 0.14070532f, 0.36177152f, 
    0.05979217f, -0.14136252f, 0.29908881f, -0.14891155f, -0.71903980f, -0.60443729f, -0.32419649f, 0.45970759f, 
    0.43060049f, 0.29488805f, 0.32811579f, 0.05023061f, 0.19758426f, -0.50819021f, -0.30905473f, -0.16565804f, 
    -0.27878335f, 0.32162154f, 0.15735224f, -0.13507321f, -0.14538784f, -0.32529181f, -0.10404877f, -0.14917886f, 
    -0.10499693f, -0.05637532f, 0.00265491f, 0.00593490f, -0.02282538f, 0.04829932f, 0.66581780f, 0.42889094f, 
    -0.36287317f, 0.33796653f, -0.15921828f, 0.07674061f, 0.39882261f, -0.06942136f, 0.03598822f, -0.00936317f, 
    0.20801087f, -0.04068490f, -0.01025695f, -0.04582442f, 0.22232273f, -0.12911862f, -0.10128058f, 0.10712153f, 
    0.28141886f, -0.29711279f, -0.25568905f, 0.04300794f, -0.35588041f, 0.13457914f, 0.56687164f, -0.05976277f, 
    0.28489685f, 0.74736744f, -0.05671886f, 0.33282876f, 0.23322727f, 0.13697085f, 0.22104022f, -0.19491433f, 
    -0.27960432f, 0.10357349f, -0.07579740f, -0.09250369f, -0.18928227f, 0.13560647f, 0.06390653f, -0.01685990f, 
    -0.03713805f, 0.22557046f, -0.24527003f, -0.15639892f, 0.09952525f, 0.21155736f, 0.16854286f, 0.25194085f, 
    -0.42964846f, -0.65704429f, 0.31419435f, 0.33709088f, -0.10976438f, 0.53195316f, 0.58615804f, 0.24479564f, 
    0.19252919f, 0.07884344f, -0.22121872f, 0.07063347f, -0.37326613f, -0.31405926f, -0.17390482f, 0.00545944f, 
    -0.23371376f, 0.20982458f, -0.19224858f, -0.03629635f, 0.07858447f, -0.19684096f, 0.33347309f, 0.00902307f, 
    0.29599309f, 0.47084495f, 0.39470237f, 0.37482393f, 0.01083863f, -0.06214180f, -0.09246048f, -0.20472984f, 
    -0.50053561f, 0.29718238f, -0.08198427f, -0.21278039f, 0.00240952f, 0.18090358f, 0.02710168f, 0.05881949f, 
    0.26495832f, -0.03256707f, 0.08161434f, -0.06833831f, 0.29071394f, 0.26943550f, 0.12025226f, 0.12389822f, 
    0.17526130f, 0.50249219f, 0.30992857f, -0.37124038f, -0.32704502f, 0.56040078f, -0.10811329f, -0.68117321f, 
    0.36781725f, 0.19512774f, 0.39069074f, -0.09620783f, -0.15717161f, -0.00910800f, -0.20508575f, -0.13683292f, 
    0.03643180f, -0.10157426f, -0.13071060f, 0.09146188f, -0.11269271f, -0.10948739f, 0.12389319f, -0.00353821f, 
    0.16435224f, -0.22507396f, -0.26574910f, 0.60262609f, 0.52206117f, 0.08594546f, 0.66843379f, 0.59702986f, 
    -0.34074470f, -0.87833190f, 0.16719070f, -0.42365515f, 0.05911668f, -0.00353000f, 0.25500757f, 0.08120286f, 
    -0.31039831f, 0.23996522f, 0.07841732f, -0.01884809f, -0.00316223f, -0.13712974f, -0.05867952f, -0.02666395f, 
    0.07207776f, 0.09642678f, 0.00562707f, 0.48830155f, -0.23309760f, -0.56679881f, -0.10752401f, -0.15830339f, 
    -0.06240404f, 0.69671702f, -0.05936754f, 0.27378204f, 0.39600012f, -0.01106613f, -0.06978145f, -0.18221578f, 
    -0.05670805f, 0.12784179f, -0.32457450f, 0.10780669f, -0.00508316f, 0.16808401f, -0.07300409f, 0.07541105f, 
    0.15308966f, 0.04911585f, -0.41943330f, -0.05968491f, 0.03037151f, 0.30638710f, -0.38152888f, -0.67805171f, 
    -0.30343372f, 0.23578574f, -0.40708542f, -0.01350628f, -0.17395787f, -0.52287811f, 0.05109250f, 0.28024006f, 
    -0.11254437f, -0.07150661f, -0.14187516f, 0.16958915f, -0.36408564f, -0.04374221f, -0.06508490f, 0.21358353f, 
    -0.11513027f, -0.17612329f, -0.14138831f, -0.00760425f, -0.01087075f, -0.16441256f, -0.04601843f, -0.23808761f, 
    0.16901045f, -0.27810019f, -0.34817618f, -0.43581393f, 0.19717897f, 0.33800650f, -0.23782375f, -0.47465649f, 
    0.23767985f, 0.04203665f, -0.02293189f, -0.37323058f, -0.06888445f, 0.18540969f, -0.11388152f, -0.01487845f, 
    -0.33949497f, 0.19086900f, -0.21115895f, 0.20209834f, 0.09694303f, -0.06719106f, 0.64046878f, 0.53283173f, 
    -0.39628586f, -0.34390306f, -0.00293438f, 0.43757546f, 0.04936435f, -0.52449805f, -0.00864371f, -0.23514718f, 
    -0.04595700f, -0.25412834f, 0.14064495f, 0.27676600f, 0.08900639f, -0.01758717f, 0.06879890f, -0.19255841f, 
    0.12389709f, 0.26139927f, 0.02764687f, 0.12869292f, -0.11927261f, -0.33031529f, 0.19673082f, 0.08744725f, 
    0.26546085f, 0.22324082f, -0.16775137f, 0.11452079f, 0.23112494f, 0.44749427f, 0.27361271f, 0.33679745f, 
    0.41888988f, -0.30224690f, 0.28276792f, -0.05863208f, -0.10801430f, 0.04521659f, -0.15672265f, -0.24073520f, 
    -0.18579449f, -0.02766631f, -0.02020552f, 0.04542012f, -0.28792495f, 0.28876641f, 0.03627608f, -0.25972083f, 
    -0.47310692f, 0.48615068f, 0.56151110f, 0.08027669f, -0.15605369f, -0.38575420f, 0.08877982f, -0.60711581f, 
    -0.74638462f, -0.29655257f, 0.24696432f, 0.31014431f, 0.18475217f, 0.05533716f, 0.17137095f, -0.16843013f, 
    -0.12010796f, 0.18216641f, -0.10312181f, 0.30927730f, -0.00419830f, 0.15543433f, 0.13139963f, 0.11085387f, 
    0.01331662f, 0.97467476f, -0.08832191f, -0.23014671f, 0.46406117f, 0.20936093f, 0.05136126f, 0.21296707f, 
    0.08527478f, -0.21193983f, -0.12060194f, -0.35637245f, -0.13722543f, 0.00289684f, -0.02257194f, -0.04525723f, 
    0.03829706f, -0.02775460f, 0.27183130f, 0.19480066f, 0.01780504f, 0.32735875f, -0.10657194f, 0.10502798f, 
    -0.22985135f, 0.14082836f, -0.02196096f, 0.41868854f, 0.54893935f, 0.60580486f, 0.23610315f, 0.06080502f, 
    0.02709757f, -0.18269092f, 0.09374715f, 0.11497672f, 0.32797316f, -0.39678791f, 0.19436325f, 0.00143812f, 
    -0.24744917f, -0.20143528f, 0.16052890f, 0.22541778f, -0.23363939f, 0.18368410f, -0.09134695f, -0.00604876f, 
    0.14471577f, -0.01980319f, -0.05516126f, 0.58885807f, 0.36257181f, 0.58650470f, -0.33535215f, -0.22323699f, 
    0.18309066f, 0.18149772f, -0.57111257f, -0.21272446f, -0.07522722f, 0.08243177f, 0.38213998f, -0.25470102f, 
    -0.08737393f, 0.12534089f, 0.07599926f, -0.40482664f, -0.23722649f, -0.18404254f, -0.03236053f, 0.00223957f, 
    0.14347787f, 0.04232110f, -0.02812304f, 0.00601928f, -0.40937233f, -0.52237493f, -0.53201348f, -0.28576097f, 
    0.11204585f, -0.10787681f, 0.07589840f, 0.29039821f, -0.19636253f, 0.02648604f, -0.12658899f, 0.37640464f, 
    0.28131014f, 0.15924555f, 0.06102525f, -0.15585151f, 0.22340971f, -0.02318923f, 0.00916637f, 0.18780716f, 
    0.03593729f, 0.19616471f, -0.29606214f, -0.22873294f, -0.24409364f, 0.02538309f, 0.41553402f, -0.59086645f, 
    0.36517838f, 0.11181978f, -0.00458076f, -0.56509042f, -0.61311197f, -0.27344197f, 0.07138108f, -0.25771087f, 
    0.08405995f, 0.11158703f, 0.13884404f, -0.02850246f, -0.02816053f, -0.08944908f, 0.19520588f, 0.00329605f, 
    -0.31527519f, 0.09190162f, -0.10971571f, -0.01880333f, -0.35295060f, -0.12093507f, 0.14636073f, 0.21049385f, 
    0.49411696f, 0.35505608f, 0.05196059f, 0.10146766f, -0.05310577f, 0.44570234f, 0.16737388f, -0.06719930f, 
    -0.01224794f, -0.30383769f, -0.00161043f, 0.04764834f, -0.03348569f, 0.09262178f, -0.15070036f, 0.09410895f, 
    -0.28405374f, 0.07465749f, -0.19880815f, 0.31448358f, 0.32655665f, 0.38089997f, -0.17579278f, 0.51446819f, 
    0.42049006f, 0.40480399f, 0.47294313f, -0.09196977f, 0.11975911f, -0.06738582f, -0.01605693f, 0.26805341f, 
    -0.07975522f, -0.00198068f, 0.20390706f, 0.04465221f, -0.09335025f, 0.22921732f, 0.13107604f, -0.26426294f, 
    0.18295079f, -0.12393509f, 0.10141923f, -0.00110134f, -0.22109134f, 0.29267931f, 0.15758984f, 0.27296361f, 
    -0.31139472f, -0.39166239f, 0.22880924f, 0.22104177f, -0.25156638f, -0.19038962f, 0.47908130f, -0.37067679f, 
    0.05470303f, 0.30788404f, 0.16649403f, -0.06218382f, -0.54901415f, -0.37225235f, -0.34246826f, -0.01882256f, 
    0.15551542f, -0.23137455f, 0.21744518f, 0.15859984f, -0.00617596f, -0.07507123f, 0.13643856f, 0.11742572f, 
    -0.01640230f, 0.49788341f, 0.31229797f, 0.34540135f, 0.26891297f, 0.23554581f, -0.38667342f, 0.15060060f, 
    -0.29282749f, -0.33751082f, -0.19523321f, 0.06551743f, -0.08045142f, 0.29216748f, 0.02011174f, -0.09875333f, 
    0.11378320f, 0.01780869f, 0.42546302f, 0.16789113f, -0.08074848f, -0.31310603f, -0.18431026f, 0.04404361f, 
    -0.24451523f, 0.02087168f, -0.16299090f, -0.58733165f, -0.28213757f, -0.24948522f, 0.65718263f, -0.49192363f, 
    0.16147406f, -0.05856730f, -0.16017683f, -0.01775021f, 0.08352945f, 0.05853433f, -0.00182763f, -0.10544768f, 
    -0.02075216f, 0.03732262f, -0.06580124f, -0.12193136f, 0.04026495f, 0.23063907f, -0.17631146f, -0.10845112f, 
    -0.16436985f, 0.35160032f, -0.19818100f, -0.22621693f, -0.41893449f, -0.67103916f, -0.08337652f, 0.44365540f, 
    0.08867451f, 0.11125275f, -0.02080041f, 0.08684217f, 0.14492844f, -0.11049356f, -0.05785860f, -0.14969085f, 
    0.19519514f, -0.03873855f, -0.06247919f, -0.39967245f, -0.21987930f, -0.29158199f, -0.06540481f, 0.10909526f, 
    -0.05099767f, -0.15675640f, 0.18160708f, 0.27825078f, -0.14906538f, -0.20692812f, -0.43271697f, -0.20068239f, 
    -0.03756467f, 0.31345931f, -0.20931038f, -0.28709430f, 0.07652476f, -0.40746334f, -0.24488871f, -0.27000639f, 
    0.36104378f, -0.22167386f, -0.33405456f, 0.02147203f, 0.18536773f, 0.20958760f, 0.37802070f, -0.23021631f, 
    -0.15733297f, 0.05007773f, 0.19610898f, 0.12704112f, 0.05349486f, 0.27200043f, 0.30245179f, 0.06603294f, 
    0.31897926f, 0.39303505f, -0.56565034f, -0.60723311f, 0.02980908f, -0.37651625f, -0.00841878f, 0.03179627f, 
    -0.18512832f, 0.28818047f, 0.01986246f, 0.22652476f, 0.16367421f, 0.34827599f, -0.06064745f, -0.15617758f, 
    -0.13475232f, -0.01189236f, -0.12295065f, -0.02603470f, 0.18104449f, 0.36726093f, -0.37242591f, 0.44130930f, 
    -0.24979696f, -0.23859361f, -0.44240752f, 0.52495527f, -0.17106158f, -0.32023308f, -0.21828164f, 0.09668634f, 
    -0.34173596f, -0.01419529f, -0.16970456f, 0.22221024f, 0.16923138f, -0.14232379f, 0.33561128f, -0.04666921f, 
    0.25624725f, 0.18435280f, 0.05856306f, -0.23811933f, -0.18881322f, 0.03043923f, 0.10486509f, -0.34467807f, 
    0.63330817f, -0.05101586f, -0.52975541f, -0.05214017f, -0.21056588f, -0.47810274f, -0.33667019f, -0.34309039f, 
    -0.17305103f, 0.30157489f, -0.10079260f, 0.30061060f, 0.34715930f, -0.08318516f, -0.12515686f, 0.18153647f, 
    -0.01921630f, 0.03357851f, 0.08088221f, 0.30801395f, -0.04026005f, 0.19819604f, 0.27702582f, -0.16800383f, 
    -0.69888508f, 0.60675746f, 0.18361561f, 0.54912537f, 0.15169489f, -0.10214572f, 0.60804474f, -0.15922238f, 
    0.24984069f, 0.33007720f, -0.47154436f, -0.08201165f, 0.36720926f, -0.14541557f, -0.06167381f, 0.01632480f, 
    -0.01830303f, 0.12198257f, -0.01818708f, -0.14305484f, -0.24962603f, -0.08713820f, -0.33699718f, 0.06676248f, 
    -0.20059125f, -0.74094373f, -0.61660969f, -0.42343995f, 0.09467522f, -0.42636749f, 0.54451889f, 0.06398892f, 
    -0.03717485f, 0.35935169f, 0.30412257f, -0.02432078f, -0.19311273f, 0.08278735f, 0.18374291f, 0.33520895f, 
    -0.07069316f, 0.21564126f, -0.28930476f, -0.17729546f, 0.11305874f, 0.03715238f, 0.12491890f, 0.36588711f, 
    0.20424357f, -0.06682373f, -0.37410584f, -0.14002630f, 0.54257399f, -0.21460558f, -0.23229447f, 0.32461971f, 
    -0.53153855f, -0.01877299f, 0.09477025f, 0.40768582f, 0.39602840f, 0.24500598f, -0.28493324f, 0.14119278f, 
    -0.14214234f, -0.11499381f, 0.16472822f, -0.04441800f, -0.11151210f, -0.01202026f, 0.29867139f, 0.21911795f, 
    -0.16282666f, 0.12961861f, 0.06411397f, 0.02566710f, -0.31003451f, -0.11351208f, 0.01980278f, -0.25994870f, 
    -0.34300259f, 0.10294213f, -0.44427946f, 0.03340909f, 0.05340235f, 0.08675197f, 0.04970726f, -0.04511752f, 
    -0.03741996f, 0.36509597f, -0.14068636f, -0.50227571f, -0.13625044f, 0.17323294f, -0.26044762f, 0.33525214f, 
    0.34379983f, 0.22410986f, -0.19926237f, 0.21264817f, -0.40365851f, -0.00405700f, -0.13683708f, -0.36605841f, 
    0.25572440f, 0.25213087f, 0.03523267f, 0.17152828f, -0.23597552f, 0.42921528f, 0.26975116f, -0.29697743f, 
    0.25583801f, -0.46777901f, 0.15476334f, -0.13283898f, 0.29023340f, 0.26436642f, 0.38577408f, -0.48637030f, 
    0.14096962f, -0.20535684f, 0.27402222f, -0.04111069f, 0.25383049f, -0.60020846f, -0.06313756f, 0.49047139f, 
    0.63101405f, 0.45533893f, -0.44971916f, -0.03976602f, 0.12507296f, -0.36178938f, -0.11961772f, 0.29053915f, 
    0.16872384f, -0.14332640f, 0.28381297f, 0.11724900f, -0.19531369f, -0.12327591f, -0.10817106f, 0.08979785f, 
    0.34581515f, 0.02455156f, 0.02814560f, -0.19819215f, 0.05510318f, -0.13763243f, 0.49566379f, 0.02986535f, 
    -0.55708295f, -0.50547904f, -0.16788301f, -0.47336176f, 0.02966036f, 0.36447904f, 0.11319534f, 0.03373643f, 
    -0.03191835f, -0.01165718f, 0.36642808f, -0.05614826f, -0.02336010f, -0.15703380f, -0.04001157f, -0.20275730f, 
    -0.05911820f, 0.04951837f, 0.31046823f, 0.10374586f, -0.03592556f, -0.16236292f, -0.05466273f, 0.63939351f, 
    0.47425133f, -0.25922188f, 0.40706840f, -0.09434237f, 0.13732226f, 0.32305613f, 0.27400500f, 0.48078269f, 
    0.36620939f, -0.19508132f, -0.03199217f, -0.00084522f, -0.48355514f, 0.23156339f, 0.05315097f, 0.11235631f, 
    -0.14540559f, 0.09292029f, 0.14089906f, -0.06675287f, -0.14669479f, 0.10022828f, -0.20201176f, -0.17889096f, 
    0.51418638f, -0.32531565f, -0.04897196f, -0.36034271f, 0.50627029f, -0.17839879f, 0.14312272f, -0.07709838f, 
    0.12457944f, -0.37878436f, -0.11687548f, 0.27792042f, -0.23122917f, 0.17877284f, 0.11327425f, -0.29389459f, 
    -0.25221816f, -0.47765616f, 0.07118064f, -0.08352187f, -0.36776239f, 0.09331803f, -0.18201828f, 0.05166348f, 
    -0.00810303f, 0.25869694f, 0.62725961f, 0.23255490f, 0.41919106f, 0.33993718f, -0.06819315f, 0.10206651f, 
    0.17107208f, -0.05971215f, -0.21641913f, 0.09277928f, 0.17426823f, -0.20175704f, 0.02674579f, 0.11551693f, 
    0.22476959f, -0.08673462f, 0.15987653f, -0.00101777f, 0.14286309f, -0.11585855f, -0.13462864f, -0.05764676f, 
    0.03230631f, 0.06613702f, 0.43483254f, 0.42389509f, 0.49217725f, -0.40578195f, -0.63476723f, -0.04632220f, 
    -0.57297486f, -0.01561117f, -0.12599991f, 0.02696598f, 0.36220187f, 0.26253206f, -0.09302227f, 0.19557257f, 
    -0.05844138f, 0.00838187f, 0.13648844f, -0.12546690f, 0.02177870f, -0.00307563f, -0.01464918f, 0.23346001f, 
    0.15992256f, -0.00974853f, 0.30292442f, -0.37349322f, -0.42299634f, 0.03998923f, 0.66647315f, 0.72910774f, 
    -0.61275375f, -0.15514968f, -0.18127596f, -0.33113676f, 0.28157753f, 0.50656343f, -0.02933763f, 0.11992185f, 
    -0.15418018f, -0.17246939f, 0.18428180f, -0.01035569f, 0.13610229f, 0.10105189f, 0.17925958f, 0.00695088f, 
    -0.22044860f, 0.18828729f, 0.14270085f, -0.06209060f, -0.17181298f, 0.23202319f, -0.40764087f, 0.07506109f, 
    0.04905399f, -0.11529609f, -0.23039179f, 0.04506877f, 0.08763950f, -0.38867673f, 0.00228866f, -0.26030695f, 
    -0.15294760f, -0.19677544f, -0.40445077f, -0.25249708f, 0.28425151f, -0.21729907f, 0.12258850f, -0.05873104f, 
    -0.36040571f, -0.44339243f, -0.18982758f, -0.12079094f, 0.12223610f, 0.26730004f, -0.19167270f, 0.45799118f, 
    0.62707913f, 0.35050112f, -0.25954318f, 0.10874615f, 0.32020190f, 0.37814391f, -0.25705346f, -0.17073594f, 
    -0.37176794f, -0.11060897f, 0.06128796f, 0.02362251f, 0.14637659f, -0.10471078f, -0.00343812f, 0.02678367f, 
    0.20059271f, 0.13292323f, 0.23504664f, -0.23648980f, 0.01662040f, -0.18664151f, -0.09784306f, 0.40084529f, 
    -0.29361323f, -0.66755784f, -0.50637615f, 0.02803149f, -0.03730320f, -0.12741083f, 0.21860127f, 0.38335410f, 
    0.22067884f, 0.07050896f, -0.28274795f, 0.11334739f, -0.20678052f, -0.06252186f, -0.33243394f, 0.12144169f, 
    0.14260800f, 0.44342878f, 0.00031129f, 0.15670505f, -0.01029395f, -0.10065461f, 0.15394503f, -0.86697847f, 
    -0.16066606f, 0.14865792f, -0.39700589f, 0.09738026f, 0.38026333f, 0.58198881f, 0.02230646f, 0.08620059f, 
    0.26942575f, 0.28830397f, 0.03102700f, 0.27782372f, -0.37366712f, -0.19597153f, 0.13744563f, -0.15842314f, 
    0.16570470f, 0.05836888f, -0.13863389f, -0.07869557f, -0.13710056f, 0.07117798f, -0.09843870f, -0.02332057f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06699345f, -0.00536245f, 0.16888078f, -0.13628216f, 0.17963915f, 0.02555576f, -0.01211711f, -0.12080601f, 
    0.19418389f, 0.03591120f, 0.02711094f, 0.09791224f, 0.03084831f, -0.15379564f, -0.04330723f, 0.20130000f, 
    0.17916630f, -0.12118254f, 0.15829881f, 0.15008415f, -0.06588231f, -0.05299694f, 0.05529278f, 0.11108755f, 
    0.21368700f, 0.05569548f, 0.01008261f, -0.07728057f, 0.01422469f, -0.09627550f, 0.22395991f, 0.06420483f, 
    0.04956691f, -0.08643407f, 0.14774626f, 0.10724790f, 0.30468738f, 0.15828660f, 0.08042732f, 0.26242173f, 
    0.16186748f, 0.01465009f, 0.12577955f, 0.19012372f, 0.09679334f, -0.13758475f, 0.04350518f, 0.03101053f, 
    0.05440636f, 0.16096216f, 0.11359247f, 0.03356202f, 0.04387154f, -0.15665814f, -0.05731517f, 0.15031417f, 
    0.15154153f, 0.05386009f, 0.18238036f, 0.13204890f, 0.05926383f, 0.11943892f, -0.01186859f, 0.04083373f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00942756f, 0.00114342f, -0.01577672f, -0.00896145f, -0.03663511f, -0.01257163f, 0.01189030f, 0.02180466f, 
    -0.01984024f, -0.02027841f, 0.00051944f, 0.01150429f, -0.02258347f, -0.00196003f, -0.01354282f, 0.02752648f, 
    -0.03154638f, -0.02394024f, -0.01371260f, -0.03460148f, -0.01623150f, -0.01004072f, 0.02099609f, 0.02545011f, 
    -0.00704201f, 0.02660215f, -0.01001748f, -0.01268369f, -0.02726701f, 0.01187512f, -0.02610053f, 0.02927350f, 
    -0.00436503f, -0.00332390f, 0.01498943f, -0.03583998f, -0.03116620f, -0.00375540f, -0.01612028f, -0.02738351f, 
    -0.00532246f, -0.02624859f, -0.02905583f, -0.03773962f, 0.02917407f, -0.00768099f, -0.00990402f, -0.03200141f, 
    -0.02288019f, 0.00459403f, 0.01986235f, -0.02678052f, 0.00783968f, -0.01837224f, 0.02830115f, 0.02324836f, 
    -0.04242299f, -0.04002746f, -0.03908533f, -0.03099163f, -0.02075996f, -0.01888567f, -0.01981410f, -0.00495878f, 
    -0.03069135f, -0.03297372f, 0.01114461f, 0.01519051f, -0.02779071f, 0.00949871f, 0.01683831f, -0.01683284f, 
    0.02366692f, -0.03841162f, -0.03395716f, 0.01329758f, -0.02621708f, -0.02642077f, 0.00171968f, 0.01001958f, 
    0.01619290f, -0.02709520f, 0.01984471f, -0.00579506f, 0.01041275f, 0.02032950f, -0.02893465f, 0.00853183f, 
    0.00772054f, -0.00842670f, -0.01378168f, -0.00089026f, -0.01950869f, 0.01038102f, -0.01522271f, -0.02129604f, 
    -0.00192631f, -0.03936462f, -0.02059533f, -0.03217050f, -0.00863670f, -0.02822988f, -0.04346974f, 0.00403904f, 
    -0.03829611f, -0.03525396f, 0.00475917f, -0.00369240f, 0.02668943f, -0.01312422f, -0.03766771f, 0.00914145f, 
    -0.02991376f, -0.02675304f, -0.01034953f, 0.02640933f, -0.03648270f, 0.01803351f, 0.01598675f, -0.04049283f, 
    0.01260434f, 0.02265596f, 0.02221991f, -0.00403802f, 0.00941541f, 0.00463030f, -0.02902894f, -0.03606590f, 
    0.02425890f, 0.01580374f, 0.01754944f, -0.03635713f, -0.00004743f, -0.03144616f, 0.00581294f, 0.01450550f, 
    0.01956970f, -0.02028368f, -0.03372184f, -0.01989197f, -0.02593696f, -0.03385361f, -0.00407777f, -0.03689072f, 
    0.00653365f, -0.03410610f, 0.01740452f, -0.03234051f, 0.02762131f, 0.02886524f, -0.01457035f, -0.00991964f, 
    -0.00585999f, -0.03391435f, 0.02238165f, -0.01002783f, 0.00918982f, 0.02875788f, -0.01755758f, 0.01147905f, 
    -0.00636136f, -0.01189772f, 0.00423367f, -0.03111964f, -0.01110100f, -0.03613855f, 0.02674585f, -0.04043397f, 
    -0.00331492f, -0.01157279f, -0.02292325f, -0.03578717f, -0.03642990f, 0.01545148f, 0.02958539f, -0.02323343f, 
    0.02757091f, -0.03290621f, -0.00536958f, 0.00885877f, -0.01372506f, -0.00079307f, -0.02374125f, -0.03497984f, 
    -0.03291615f, 0.00777139f, -0.00302970f, 0.00822445f, 0.00931131f, -0.00153757f, 0.01305826f, -0.00616735f, 
    -0.01199921f, 0.02010680f, -0.02792389f, -0.02818641f, 0.01938854f, 0.00035654f, 0.00639410f, -0.02860487f, 
    -0.02813296f, -0.00496121f, 0.00713919f, 0.00309878f, 0.01755864f, -0.02284841f, -0.01224756f, -0.03759149f, 
    0.02743258f, 0.02875244f, -0.03456920f, -0.02740586f, -0.00198115f, -0.03858735f, -0.01766089f, 0.00894525f, 
    0.01649911f, 0.00352288f, -0.02264869f, 0.02239968f, 0.00434581f, 0.02848525f, 0.02270824f, 0.00999615f, 
    -0.04147171f, -0.03532991f, -0.03858312f, -0.02793187f, -0.03827710f, -0.00974144f, -0.02852501f, -0.00945144f, 
    -0.03517789f, -0.02429169f, -0.02956924f, 0.01279512f, -0.02001345f, -0.04097240f, -0.03699570f, -0.00185652f, 
    0.02947065f, -0.03630086f, -0.00620286f, 0.02430080f, -0.02885128f, -0.02234631f, 0.01220025f, 0.00398939f, 
    -0.00161372f, -0.02005001f, 0.01928513f, -0.02934851f, -0.03836399f, -0.03847961f, -0.02508712f, 0.02538728f, 
    -0.03886168f, 0.00685630f, -0.00583976f, -0.00405600f, 0.01855749f, 0.00486317f, -0.01465641f, -0.01934816f, 
    -0.00154333f, -0.00601291f, -0.00476034f, 0.01201132f, 0.02565515f, -0.02143162f, -0.02516019f, 0.01426629f, 
    -0.02759851f, 0.00584773f, -0.01797987f, 0.00241264f, -0.03338357f, -0.00429795f, 0.01813125f, -0.01765615f, 
    -0.01565449f, 0.02292683f, 0.02071250f, 0.01019530f, -0.02987958f, -0.01892006f, 0.00049225f, -0.00614018f, 
    -0.03867427f, -0.00235050f, 0.02656139f, 0.01865368f, -0.02357867f, -0.03173678f, 0.01814987f, -0.00817077f, 
    -0.00859634f, -0.02945012f, -0.01132900f, 0.00066318f, -0.04206645f, -0.03304072f, -0.02373708f, 0.00439264f, 
    0.01205241f, 0.01901893f, 0.02315705f, -0.01679495f, 0.01686006f, -0.02429895f, -0.02452946f, 0.02554613f, 
    -0.02515349f, -0.01726704f, -0.00388651f, 0.00792560f, -0.01441031f, -0.01781643f, 0.00789969f, -0.03981905f, 
    0.00824534f, -0.03118391f, 0.02455908f, -0.01347129f, 0.02849635f, -0.00456701f, -0.01467832f, 0.02512230f, 
    -0.02333369f, 0.02667852f, -0.01001461f, 0.02722427f, -0.00961302f, -0.03040724f, -0.00854723f, -0.01884825f, 
    -0.00020205f, -0.00779549f, 0.01512989f, -0.03711496f, -0.01043319f, 0.02410075f, -0.00064455f, 0.00134519f, 
    0.00714127f, 0.02538619f, 0.00916029f, -0.01800345f, 0.02613248f, -0.02872541f, -0.03261220f, -0.00543506f, 
    -0.02895053f, 0.02138279f, -0.00508824f, -0.00174795f, 0.02499989f, 0.00558991f, -0.02594420f, -0.01058422f, 
    0.00359546f, -0.02452000f, 0.02371508f, -0.01108841f, -0.03291689f, -0.03467066f, 0.02779073f, 0.02669539f, 
    -0.03989918f, 0.00337563f, -0.01287561f, 0.00911453f, 0.01871132f, 0.01397940f, 0.00254578f, -0.01378437f, 
    -0.00956046f, -0.01723742f, 0.00501738f, -0.00442820f, 0.01876750f, 0.02753882f, 0.00429590f, -0.02424355f, 
    -0.01492452f, 0.00285620f, 0.02582899f, -0.00365844f, -0.03065476f, -0.00153293f, 0.00982303f, -0.04016917f, 
    0.01007019f, 0.00482918f, 0.01321666f, -0.02534078f, 0.00574300f, 0.00863784f, -0.03541084f, 0.00081915f, 
    0.00725701f, 0.00005681f, 0.02590379f, 0.02341475f, -0.02897013f, 0.00592249f, -0.01641588f, -0.01604354f, 
    -0.01529983f, -0.00774691f, -0.01526370f, 0.02445334f, -0.03211284f, 0.00909595f, -0.00652057f, -0.04287951f, 
    -0.01906754f, -0.02888005f, -0.03354254f, 0.00401189f, -0.00726979f, -0.02390271f, -0.02897463f, -0.01802857f, 
    0.02963470f, -0.00864870f, -0.00370822f, -0.02749182f, -0.00874634f, 0.00197750f, -0.00152366f, 0.01322989f, 
    -0.00682811f, 0.02162652f, 0.00605365f, 0.01318917f, 0.00577942f, 0.02311810f, -0.04178193f, -0.00025455f, 
    -0.02331293f, 0.01565539f, -0.01606516f, 0.01152155f, -0.01214396f, -0.02447570f, -0.03239009f, -0.01145600f, 
    -0.02471220f, -0.03250478f, -0.02159030f, -0.01620496f, -0.02007145f, -0.00312783f, 0.02245357f, 0.01193262f, 
    -0.03727083f, 0.01834725f, -0.02189585f, 0.01223116f, -0.01196267f, -0.01848042f, 0.02105345f, -0.02917615f, 
    -0.01635265f, 0.02489413f, -0.00676210f, -0.03217106f, 0.01441993f, -0.00957182f, -0.00506579f, -0.02662856f, 
    -0.03508876f, -0.00722329f, 0.00549710f, -0.02659753f, -0.02507971f, 0.00437272f, 0.00235275f, -0.00209553f, 
    -0.00076895f, -0.02801949f, -0.01274409f, 0.00741284f, 0.02689132f, -0.00438630f, 0.00911407f, -0.00864525f, 
    0.02843039f, -0.03722414f, 0.02550387f, -0.03832062f, 0.00598478f, -0.01903099f, -0.03618725f, 0.01101675f, 
    0.02827520f, 0.02707551f, -0.02334121f, 0.02604175f, -0.00954975f, 0.00044497f, 0.00322054f, -0.02445947f, 
    0.00723159f, -0.02272688f, 0.02456889f, -0.01774850f, -0.02700558f, -0.00757685f, -0.00395030f, -0.00676176f, 
    0.00584459f, 0.01713203f, 0.02401850f, -0.02121782f, 0.02650939f, 0.02772806f, -0.03178564f, 0.01051174f, 
    0.01552293f, 0.02242515f, -0.02633578f, -0.02502463f, -0.02587673f, 0.02653651f, 0.01677199f, 0.02859183f, 
    -0.02955972f, 0.00164698f, -0.02494403f, -0.02439757f, -0.03481914f, 0.01595824f, -0.01131636f, 0.01758170f, 
    0.02888373f, -0.02945342f, -0.01401277f, -0.03709592f, 0.00212958f, -0.00510671f, -0.02967710f, 0.00204234f, 
    0.02265004f, 0.01174301f, 0.00524939f, 0.02746817f, -0.02580696f, -0.02690702f, -0.02768140f, 0.00878469f, 
    -0.00609979f, -0.01914988f, -0.01811998f, 0.00864786f, -0.02160524f, 0.02066836f, -0.01410555f, 0.02346396f, 
    0.00522790f, -0.01785264f, -0.04074157f, 0.01267438f, 0.00338746f, -0.03618464f, 0.02036055f, -0.02897368f, 
    -0.00193440f, -0.00623261f, -0.01036955f, 0.01974836f, 0.01351438f, -0.03527972f, -0.00339554f, -0.01682457f, 
    -0.01173943f, -0.01016767f, -0.01191256f, -0.01014297f, -0.00852626f, 0.02457148f, -0.02282616f, 0.02700679f, 
    -0.02375965f, 0.00528108f, -0.02082745f, 0.02662000f, -0.02475283f, -0.00854285f, 0.00643534f, -0.00383328f, 
    0.01690255f, -0.00809334f, 0.00129838f, -0.02031444f, -0.04136382f, -0.03363494f, -0.03952560f, 0.00844540f, 
    -0.01090644f, -0.01612275f, -0.02746378f, 0.02955123f, -0.03721987f, -0.00119465f, 0.01237228f, 0.00904708f, 
    -0.01992390f, 0.01643921f, -0.03936784f, -0.02244418f, -0.03500692f, -0.02349517f, 0.02563646f, 0.01845537f, 
    -0.00513264f, -0.01427342f, 0.00883413f, 0.00856036f, 0.00576952f, -0.00292309f, 0.01733480f, -0.01804815f, 
    0.00546899f, 0.02112952f, 0.01906094f, 0.00978309f, 0.00158345f, 0.00425792f, 0.01269909f, -0.02514877f, 
    -0.01471631f, -0.00978823f, -0.04078311f, 0.02720772f, 0.01692072f, -0.00545443f, -0.01597052f, -0.00531255f, 
    -0.01426637f, -0.03068608f, 0.01835205f, -0.03538680f, -0.01326106f, -0.01865404f, -0.02628539f, 0.00004531f, 
    0.01471963f, 0.00500574f, -0.02253219f, -0.04279974f, -0.03859466f, 0.00352334f, -0.01988882f, -0.03232548f, 
    0.02799635f, -0.01547491f, -0.02294124f, -0.03550044f, 0.01660637f, -0.04267623f, 0.01001461f, -0.00154780f, 
    0.02286283f, -0.02074568f, 0.00736436f, 0.00836389f, -0.00555181f, 0.02098767f, -0.01465768f, 0.02299494f, 
    0.01212414f, 0.02290014f, -0.01024851f, 0.01111815f, -0.03811468f, -0.01073623f, -0.00875374f, -0.01177038f, 
    -0.01017767f, -0.00123491f, -0.04135305f, 0.02736825f, 0.01605476f, -0.03551912f, -0.03952420f, -0.00517273f, 
    -0.01159627f, 0.01680649f, -0.03982349f, 0.01899630f, 0.02714083f, -0.01568413f, 0.00361648f, 0.00212228f, 
    -0.02867352f, 0.02520300f, 0.02895990f, 0.00534957f, 0.00397949f, -0.03244294f, -0.00593085f, 0.00390565f, 
    -0.03410017f, 0.02861287f, -0.04127851f, -0.02179306f, -0.00882491f, -0.00008961f, 0.02819827f, 0.00883332f, 
    0.02780826f, -0.01831958f, 0.01857873f, 0.00188939f, -0.02340957f, -0.00177199f, 0.00021462f, -0.04126757f, 
    -0.03622749f, -0.02389471f, -0.02873104f, 0.00812206f, -0.01187354f, 0.01080862f, -0.01960825f, 0.00256469f, 
    -0.02977926f, 0.00296700f, -0.03202491f, -0.03248764f, -0.03915400f, -0.04189311f, -0.00765431f, -0.00749908f, 
    -0.00218120f, -0.01083567f, -0.01775633f, -0.01482047f, -0.01674253f, -0.02475291f, -0.01558328f, -0.00735746f, 
    0.01396971f, 0.02686841f, -0.02930292f, 0.04154091f, 0.00233922f, 0.01693083f, -0.01215661f, 0.02813034f, 
    -0.00040550f, -0.02403822f, -0.01800462f, 0.00287957f, 0.01718017f, 0.00982822f, -0.02266654f, -0.01077410f, 
    0.01745312f, -0.02186196f, -0.04101186f, -0.02687111f, 0.01480631f, -0.01562327f, -0.02589088f, 0.00083868f, 
    -0.05275248f, 0.18202095f, 0.08019806f, 0.11570190f, 0.12393631f, 0.01439508f, 0.02044384f, 0.05079682f, 
    -0.05620760f, 0.07151617f, -0.04954470f, -0.02836108f, 0.19387959f, -0.10172778f, 0.11906216f, -0.13678856f, 
    0.05606890f, -0.04207615f, 0.02499905f, 0.00744263f, 0.06100279f, -0.03982241f, -0.06180452f, 0.09168315f, 
    -0.10997039f, 0.08949746f, 0.12402152f, 0.05447905f, -0.03964069f, 0.02528929f, -0.06971543f, -0.05982473f, 
    0.07296094f, 0.04155662f, 0.11701821f, 0.02187735f, -0.02885350f, -0.03922774f, 0.15788113f, -0.21864279f, 
    0.12406968f, -0.04977219f, 0.03316161f, -0.11563162f, 0.19122843f, -0.02951412f, -0.02756381f, -0.07767320f, 
    -0.06966326f, -0.07879826f, 0.19949263f, 0.06006339f, 0.07570525f, 0.08402071f, 0.10454223f, 0.05001997f, 
    0.03861544f, 0.09422434f, 0.02993717f, 0.10419286f, -0.17766559f, 0.09855384f, 0.03678358f, -0.16073009f, 
    -0.00297075f, 0.02221343f, 0.06125145f, -0.07104915f, -0.03173259f, 0.05173295f, -0.06253938f, 0.01940519f, 
    0.16602491f, -0.19134298f, -0.01502107f, 0.00676704f, 0.04262170f, 0.07750780f, 0.02116347f, 0.04125401f, 
    -0.03537288f, 0.07101592f, -0.10378841f, -0.01627932f, 0.01466948f, 0.04557695f, -0.02558361f, 0.15731890f, 
    0.00988897f, -0.06184579f, 0.05050143f, -0.03819016f, -0.06080627f, -0.00158975f, 0.10303253f, 0.16520071f, 
    -0.09993426f, -0.13347706f, -0.07182059f, 0.09959494f, -0.02159781f, 0.04706840f, -0.08641746f, 0.23868570f, 
    -0.07310753f, 0.06822290f, 0.03873449f, 0.16374341f, -0.02423178f, -0.09171838f, 0.04896472f, 0.05905362f, 
    0.09626311f, 0.00136726f, 0.02256751f, 0.08109520f, 0.06098242f, 0.06868309f, 0.06594057f, 0.01659947f, 
    0.19933267f, 0.14247325f, 0.12821855f, 0.17190532f, 0.02037613f, 0.13117126f, 0.10177287f, 0.03227977f, 
    0.11076280f, 0.00368059f, -0.01129456f, -0.05938626f, 0.18482777f, 0.07983504f, -0.11116795f, 0.11511555f, 
    -0.12541983f, 0.04990694f, 0.03862624f, 0.06155770f, 0.12568647f, -0.02365706f, 0.03500974f, -0.05289020f, 
    0.18618585f, -0.14038356f, 0.10430258f, 0.04119962f, 0.01124842f, -0.06339093f, -0.02019338f, 0.13031484f, 
    -0.00400107f, 0.00839823f, -0.00086559f, 0.18148355f, 0.06170103f, 0.05038922f, -0.01202510f, 0.14852735f, 
    0.16870700f, 0.00223512f, 0.01230163f, 0.00180248f, 0.03572036f, -0.01626574f, -0.06415525f, -0.08690494f, 
    -0.09690165f, 0.22373496f, 0.04849974f, -0.04905325f, -0.00789333f, -0.04775571f, -0.11089125f, -0.04837630f, 
    0.01391145f, 0.03517497f, 0.13954665f, 0.02332342f, -0.23618883f, -0.17702311f, 0.09980234f, -0.12142794f, 
    0.04796517f, -0.02638531f, -0.05472606f, -0.00111622f, 0.01384553f, 0.07521556f, 0.04318443f, -0.06604011f, 
    0.07359562f, 0.13845438f, -0.08175194f, -0.06616509f, -0.01993129f, 0.07604655f, 0.05463577f, 0.06319468f, 
    0.06082480f, -0.13053223f, 0.02095715f, -0.06493723f, 0.22037274f, 0.07537732f, -0.08110136f, 0.05829560f, 
    0.09817570f, -0.06826631f, 0.02454816f, 0.11237852f, 0.01841501f, 0.05132363f, -0.09879768f, -0.03043586f, 
    -0.01038439f, -0.00835073f, 0.04252341f, 0.15340963f, 0.18120219f, 0.05552562f, 0.01075033f, 0.21701033f, 
    -0.01710820f, 0.03057671f, 0.04256592f, 0.00418334f, 0.04273178f, 0.10960379f, -0.03279728f, 0.12105195f, 
    0.00695626f, 0.01777305f, -0.00678876f, 0.03459368f, 0.12190792f, 0.14778571f, 0.01798313f, 0.13809817f, 
    0.08974816f, 0.08331706f, -0.25461075f, 0.04048520f, 0.01194919f, 0.10015528f, 0.02218614f, 0.11927996f, 
    -0.11457250f, 0.13950957f, -0.10201559f, 0.00524717f, 0.24158528f, 0.08619951f, -0.04531066f, -0.02788403f, 
    0.04544283f, -0.02120315f, -0.06200399f, -0.09853933f, -0.02231216f, 0.03805245f, 0.06110395f, 0.09551108f, 
    0.15972242f, 0.18787792f, -0.01402760f, 0.18664777f, 0.00948031f, 0.06122015f, 0.03154644f, -0.06782263f, 
    0.04286829f, -0.04999905f, 0.06181942f, 0.07225501f, 0.13960098f, 0.01330399f, -0.09066404f, 0.23200610f, 
    0.08784290f, 0.06054764f, -0.15177722f, 0.03583057f, 0.11688039f, -0.11578025f, -0.05102344f, 0.05207169f, 
    0.00754003f, 0.07425320f, 0.10182280f, 0.16101529f, -0.05867445f, -0.01387514f, 0.03455988f, 0.03871271f, 
    0.11784544f, 0.05345917f, 0.07321212f, 0.04476924f, 0.16813020f, -0.17227003f, 0.15968084f, -0.01860413f, 
    0.06088302f, -0.17477907f, 0.11076987f, 0.05076088f, 0.07598731f, -0.01092116f, 0.01762381f, 0.16234852f, 
    -0.19461486f, 0.08126166f, 0.14511764f, -0.02472494f, 0.03722505f, 0.07448629f, -0.03123181f, 0.01392530f, 
    0.01655331f, 0.05809220f, 0.09705963f, 0.02124781f, 0.29648066f, -0.12753037f, -0.05763716f, 0.04270424f, 
    0.10612877f, -0.11988539f, 0.01087383f, 0.09121209f, 0.03214606f, 0.03039350f, -0.08839841f, -0.04071332f, 
    -0.12151754f, -0.01941098f, 0.11045796f, -0.17491363f, 0.03205462f, -0.00805885f, 0.04656373f, -0.00733392f, 
    -0.04473590f, 0.18414684f, 0.06782032f, 0.00625304f, -0.16707163f, -0.14874032f, -0.16495499f, -0.12388001f, 
    -0.04875230f, -0.01804056f, -0.01627944f, 0.08401057f, -0.01530012f, -0.15498985f, 0.01895877f, 0.04204971f, 
    0.01445565f, -0.18733574f, 0.10829574f, -0.23114876f, 0.08912331f, -0.07905102f, 0.06572538f, 0.00190836f, 
    -0.07914600f, 0.05461198f, 0.01370197f, 0.03091083f, 0.25763851f, 0.21319745f, 0.09358282f, -0.03052899f, 
    -0.02090947f, 0.08525839f, 0.08346906f, 0.03700780f, -0.01360907f, 0.06816473f, 0.11560597f, 0.01262754f, 
    -0.25021672f, 0.00656609f, -0.01512362f, -0.08595283f, -0.10657648f, 0.08043053f, 0.08306818f, -0.03239544f, 
    0.04451993f, 0.08369486f, 0.15402128f, 0.09399227f, 0.14013061f, 0.05362957f, -0.08826698f, 0.30923727f, 
    -0.02032752f, -0.03668321f, -0.06378876f, 0.00780058f, 0.15838639f, 0.02856115f, -0.08120777f, -0.01062563f, 
    -0.04257230f, 0.07871754f, 0.12009937f, 0.22342214f, 0.07137637f, 0.00179720f, 0.00139725f, -0.03837524f, 
    -0.04131294f, -0.08040603f, 0.08040774f, -0.06435633f, 0.01025704f, 0.03255871f, 0.19955888f, -0.19444351f, 
    0.04192244f, 0.04007445f, 0.03490614f, -0.03745816f, 0.01624240f, -0.04550806f, -0.12426999f, -0.00706281f, 
    0.01349223f, 0.04637335f, 0.05722894f, 0.04679870f, 0.13766055f, 0.02035477f, -0.01640181f, 0.06064614f, 
    0.03846546f, 0.01336521f, 0.03953623f, -0.07848908f, -0.32408965f, -0.23759688f, -0.02749772f, -0.24160554f, 
    -0.07293890f, -0.12141893f, 0.00154616f, 0.03430210f, 0.04658363f, -0.04467591f, -0.00096410f, -0.05477903f, 
    0.01626067f, 0.21553814f, 0.02529701f, 0.15682060f, -0.02197766f, -0.02922997f, 0.01400170f, -0.08052324f, 
    0.03166663f, 0.09847275f, 0.08430429f, 0.03655630f, 0.13838896f, 0.06845849f, 0.19248720f, 0.16934779f, 
    -0.00641494f, 0.08013842f, 0.06220233f, 0.04439618f, 0.03111057f, 0.05872186f, 0.06459106f, 0.12810116f, 
    -0.01787136f, -0.19578160f, -0.16035327f, 0.10945721f, -0.01254247f, 0.00242272f, 0.05013325f, -0.02185051f, 
    0.04258125f, 0.09514380f, -0.08611301f, 0.06340440f, 0.01535191f, -0.04019573f, -0.11048455f, 0.14896542f, 
    0.09737674f, 0.04656191f, 0.03194891f, -0.01442932f, 0.05797779f, -0.07369844f, 0.12825310f, 0.01402145f, 
    0.13069773f, -0.18144913f, -0.10352622f, -0.10986201f, 0.11287771f, -0.02633482f, -0.02303225f, -0.10559568f, 
    0.01516975f, 0.03176064f, 0.01400697f, 0.07986311f, 0.05916581f, -0.07301223f, -0.14535449f, -0.03779765f, 
    0.13335435f, 0.05968858f, 0.01598830f, 0.11905832f, 0.00615468f, 0.00140434f, -0.05456791f, -0.04947579f, 
    -0.20771898f, -0.15049617f, 0.10445973f, -0.11800165f, 0.17972866f, 0.03370570f, 0.01854296f, 0.01535935f, 
    0.06941467f, -0.03344707f, 0.06968003f, 0.02006278f, 0.00892023f, 0.04432205f, 0.03905464f, 0.21264791f, 
    -0.06786731f, -0.00288426f, -0.02585804f, 0.00299085f, -0.07126244f, 0.03892464f, -0.00787252f, 0.11668324f, 
    -0.25991836f, -0.07194737f, 0.03441747f, -0.23735450f, 0.11184184f, 0.12492801f, -0.02436539f, -0.03660058f, 
    -0.09622627f, 0.11119670f, -0.08513443f, -0.01608980f, -0.13716130f, -0.04379147f, -0.02431473f, -0.15011032f, 
    0.03135084f, -0.01459049f, 0.12806135f, -0.05895063f, 0.09458767f, 0.06094284f, 0.09174877f, -0.02201832f, 
    0.12626939f, -0.04058383f, -0.11387155f, 0.08235608f, 0.05314557f, 0.16480152f, -0.04725471f, -0.03503384f, 
    -0.03051155f, -0.01513250f, 0.10119899f, -0.09333835f, -0.16521695f, 0.02680505f, 0.06755289f, 0.10130215f, 
    0.22301863f, 0.01597776f, -0.00172533f, -0.03355241f, 0.02610175f, 0.05150936f, -0.07179751f, 0.10279620f, 
    -0.02406660f, 0.05229226f, 0.03633271f, -0.05109454f, -0.13053623f, 0.07431636f, -0.02350551f, 0.04991085f, 
    0.09635268f, -0.05241302f, 0.01691494f, 0.02431602f, -0.11358296f, -0.15212648f, -0.07770848f, 0.16438095f, 
    0.02978605f, 0.03591774f, 0.05616798f, 0.07174055f, -0.02765667f, 0.03590894f, -0.12853876f, 0.07306718f, 
    0.20202050f, 0.07061954f, -0.05775333f, 0.01192525f, 0.08053951f, -0.01731976f, -0.08445407f, 0.07866096f, 
    0.17212981f, 0.03003562f, 0.09533067f, 0.04915771f, -0.12812969f, 0.07408936f, 0.00047408f, -0.00679684f, 
    0.02901922f, -0.07768819f, -0.13394456f, 0.00441450f, -0.25209945f, 0.04251814f, 0.06180520f, -0.01454288f, 
    0.16917148f, -0.12481382f, 0.03678290f, -0.12358007f, 0.05540448f, -0.04713378f, 0.06352374f, 0.10873455f, 
    -0.11206687f, -0.01888403f, -0.12759675f, -0.10059547f, 0.49020034f, 0.03813455f, 0.06344638f, 0.04516809f, 
    0.07433547f, -0.10693935f, -0.01668927f, -0.04079963f, -0.03704065f, 0.11198007f, -0.06083905f, 0.02374214f, 
    0.04865039f, -0.04728780f, -0.01876308f, 0.03431426f, 0.07187644f, 0.00581550f, 0.04400338f, 0.06470881f, 
    -0.11666273f, 0.04288096f, -0.12635951f, -0.02590298f, 0.09447633f, -0.05718586f, 0.05770772f, 0.28304571f, 
    0.08575017f, 0.02572563f, -0.02719206f, -0.04442441f, 0.01378003f, 0.06961913f, -0.04741079f, 0.11622516f, 
    -0.05846399f, 0.12655200f, 0.12986487f, -0.17859188f, 0.03122622f, 0.00442356f, 0.00475874f, 0.02243499f, 
    0.06265841f, -0.02450600f, 0.18794230f, 0.02524798f, 0.05391626f, -0.16299443f, -0.06629783f, -0.03359442f, 
    0.10108972f, -0.01139153f, -0.05556418f, 0.05875618f, -0.01489893f, 0.01446410f, 0.00776255f, 0.08299761f, 
    -0.12586823f, -0.26422119f, -0.10511217f, -0.12826099f, 0.10025351f, 0.04909708f, -0.19954716f, -0.02977469f, 
    -0.14687490f, -0.01201993f, -0.02312804f, -0.02444267f, -0.02140821f, 0.05652386f, -0.15224758f, 0.23704728f, 
    -0.01691010f, 0.00258753f, -0.02894447f, 0.00317816f, 0.06071076f, 0.18357353f, 0.00494925f, 0.07474485f, 
    0.02166122f, -0.12033813f, 0.14677070f, -0.19921887f, -0.06108122f, -0.05154640f, 0.07502621f, 0.10934825f, 
    0.02801078f, -0.01047789f, 0.02362092f, 0.10129447f, 0.04204974f, -0.11572856f, -0.04833171f, -0.08818785f, 
    0.06895658f, -0.02126261f, 0.05419265f, 0.00030965f, -0.04872327f, 0.02724984f, 0.04109750f, -0.02708150f, 
    -0.00869114f, -0.02493159f, -0.00335088f, 0.00383108f, 0.01731020f, -0.03887321f, 0.01228133f, 0.00622842f, 
    0.02198239f, 0.00914806f, -0.02158942f, -0.02732546f, -0.01509304f, -0.01228568f, -0.00046703f, -0.01407498f, 
    -0.03697194f, -0.02132436f, 0.01294686f, 0.00969643f, 0.00203051f, 0.01957943f, -0.00639909f, -0.04008766f, 
    -0.02046348f, -0.03802204f, 0.02040145f, 0.01483195f, 0.00018374f, 0.01297857f, -0.02754975f, -0.01353516f, 
    -0.02593446f, 0.02582642f, -0.00384664f, -0.00535274f, 0.01989494f, 0.03022471f, -0.00585308f, -0.00444379f, 
    -0.00683021f, -0.01104575f, 0.01878718f, 0.01075643f, -0.03062485f, -0.01140633f, -0.04151060f, -0.01919621f, 
    0.00029976f, -0.02149671f, -0.02827017f, 0.02655559f, -0.03463548f, 0.02774078f, 0.02820055f, -0.00744622f, 
    0.01729402f, 0.00060029f, -0.03382026f, -0.04253397f, 0.01442325f, -0.04199168f, 0.02039695f, -0.00897057f, 
    -0.02985660f, -0.03304394f, -0.01885916f, 0.00163388f, -0.01653851f, 0.00560664f, 0.01504134f, -0.01358993f, 
    -0.03687251f, -0.00068787f, 0.00786209f, -0.03843280f, 0.03042618f, 0.00925257f, -0.03779093f, 0.01510530f, 
    -0.04363705f, -0.01424032f, -0.02203597f, -0.02674592f, -0.02481436f, -0.03896989f, -0.00040741f, -0.00571562f, 
    0.01480082f, -0.03311300f, 0.01769782f, 0.01901137f, -0.02552027f, 0.00345928f, 0.01548067f, 0.00508029f, 
    -0.00867163f, -0.01941724f, -0.03734469f, -0.01774435f, -0.03413657f, -0.01965140f, 0.02353789f, -0.00131796f, 
    0.01608316f, -0.01399885f, -0.02475492f, 0.01002307f, -0.02349372f, 0.00919555f, -0.00244894f, 0.02146126f, 
    0.02129403f, -0.01005987f, 0.00220062f, 0.02226483f, -0.02860314f, -0.03613610f, 0.02025566f, 0.00859540f, 
    -0.02931940f, 0.00402091f, -0.02110054f, 0.01931593f, 0.01261167f, -0.01142064f, -0.00242423f, 0.00575168f, 
    -0.01845085f, -0.00381650f, -0.02415963f, -0.01465843f, -0.02151225f, -0.00874160f, -0.03777203f, -0.00842675f, 
    0.01911690f, -0.01353575f, -0.00035083f, -0.01557994f, 0.01835465f, 0.01438987f, -0.01849864f, -0.04169597f, 
    0.01687630f, 0.00138829f, 0.00944860f, -0.03387818f, 0.00060320f, 0.00563752f, -0.02984897f, 0.01971139f, 
    0.01274281f, -0.00791358f, 0.02406730f, -0.02506954f, -0.03336154f, -0.00288623f, -0.02965019f, -0.00876623f, 
    -0.02061118f, -0.02101312f, -0.02366312f, -0.01019400f, -0.02654885f, 0.00250491f, -0.00451806f, 0.01969740f, 
    -0.03532790f, 0.01564674f, 0.00956385f, 0.01554015f, -0.02233154f, -0.01636845f, 0.02532702f, -0.02043997f, 
    0.01196514f, -0.01052042f, 0.01445815f, -0.02953653f, -0.01632524f, 0.02828615f, 0.00389169f, 0.00293912f, 
    0.01598896f, -0.04176055f, -0.02920719f, -0.04079231f, 0.00196266f, 0.01103170f, 0.02107568f, 0.02558503f, 
    -0.00967050f, 0.00198857f, -0.04182583f, 0.02440454f, 0.00680805f, 0.02542766f, 0.02462087f, 0.00874447f, 
    0.01409326f, -0.01699650f, -0.01005001f, -0.02382826f, 0.01032579f, -0.03980406f, -0.01255969f, -0.04209679f, 
    0.01894383f, -0.03408699f, -0.03049356f, 0.00755548f, 0.02996677f, 0.00823322f, -0.00903955f, 0.01519343f, 
    0.02086465f, 0.01562033f, 0.01039790f, 0.00257410f, 0.00681720f, 0.00658309f, 0.00840695f, -0.02357841f, 
    -0.02316927f, -0.02207525f, -0.01641884f, -0.03427985f, -0.03666914f, -0.02041779f, -0.03012868f, -0.03517117f, 
    -0.01104053f, -0.03226800f, -0.02007876f, -0.00167383f, -0.03440770f, -0.03117854f, 0.00706251f, -0.02124780f, 
    0.01465036f, -0.01522143f, 0.00059725f, -0.03712376f, 0.00011471f, -0.01066829f, 0.00079857f, -0.00151773f, 
    -0.02705645f, -0.01964275f, -0.01899367f, -0.01636615f, -0.01045832f, -0.00169090f, -0.03345821f, 0.01167928f, 
    -0.03922743f, -0.04136573f, -0.04157322f, 0.01086579f, -0.04328295f, -0.00530078f, 0.01663629f, -0.00774603f, 
    -0.02339676f, -0.02812533f, -0.01749053f, -0.00858501f, -0.00832652f, -0.03932822f, 0.00124461f, -0.00580045f, 
    0.00315798f, -0.03451973f, -0.02996133f, -0.02590566f, -0.02831475f, -0.00679342f, -0.01914950f, 0.00367393f, 
    0.01763686f, 0.01916252f, 0.02511896f, -0.01076813f, -0.01254745f, -0.00925787f, 0.01882403f, -0.00440399f, 
    -0.00249071f, 0.00677979f, -0.03329649f, -0.03955120f, 0.01131963f, -0.02701942f, 0.02592840f, 0.02647437f, 
    0.00010339f, -0.01661422f, -0.02899364f, -0.04033902f, 0.01020545f, -0.04448328f, -0.00871271f, 0.01978646f, 
    -0.01150051f, -0.04272379f, -0.03809482f, 0.01244012f, -0.01122985f, -0.04277316f, -0.01832515f, -0.00162501f, 
    -0.01028689f, -0.04111736f, -0.03287732f, -0.03966450f, -0.00026443f, -0.01466037f, -0.03208504f, -0.00034996f, 
    -0.03121421f, -0.03138001f, 0.00825705f, -0.01657213f, -0.00267012f, -0.01360482f, -0.01946170f, -0.02476478f, 
    0.02078762f, 0.02276769f, 0.00197679f, -0.00010041f, -0.00640364f, 0.01076822f, -0.00606047f, -0.03028786f, 
    0.03396678f, 0.00320886f, 0.02320203f, 0.00776055f, 0.02707966f, 0.02346279f, 0.02657564f, 0.01689339f, 
    0.00826688f, 0.01773646f, -0.02428983f, -0.00894271f, 0.02751384f, 0.02167360f, -0.01831599f, -0.02115181f, 
    -0.03352321f, 0.02236392f, -0.02049160f, -0.02423071f, -0.00354826f, -0.00847498f, -0.02410462f, -0.02351266f, 
    -0.00819095f, -0.02768276f, -0.01828864f, -0.02254148f, 0.00717140f, -0.03284194f, 0.02132062f, 0.00864986f, 
    -0.01839176f, 0.00902235f, -0.02004871f, 0.02577482f, 0.02875129f, 0.00315860f, 0.02344123f, 0.00092067f, 
    -0.00721283f, -0.01312141f, -0.03108913f, -0.02241540f, -0.02407548f, -0.01591199f, 0.02670362f, 0.02031644f, 
    -0.01707095f, -0.00545091f, 0.00411220f, -0.00860715f, 0.03062429f, -0.00400488f, 0.00580275f, -0.01004452f, 
    0.00598960f, 0.02660169f, -0.02871992f, 0.02492740f, -0.02671884f, 0.00528480f, -0.02244260f, -0.02679560f, 
    0.02358692f, -0.02722738f, 0.01823313f, -0.04066887f, -0.00564515f, -0.01489753f, -0.03032105f, 0.00745792f, 
    0.01803177f, 0.01530168f, 0.00585021f, 0.02395015f, 0.00967647f, -0.03283052f, 0.02635896f, -0.01964858f, 
    -0.01621328f, -0.00137331f, -0.02043546f, -0.01318883f, -0.00763057f, 0.00395574f, -0.00311257f, 0.01067386f, 
    -0.01632057f, -0.03361942f, 0.02836384f, -0.01428010f, -0.00108449f, -0.01436313f, -0.02573839f, -0.02989656f, 
    -0.01994486f, -0.00156202f, -0.01875250f, -0.01880114f, -0.01439282f, 0.00768695f, -0.02940733f, 0.02683122f, 
    -0.03947492f, -0.00308561f, -0.00240070f, -0.03520124f, 0.00230388f, -0.03922601f, 0.02788320f, -0.01485942f, 
    0.02116210f, -0.03061386f, -0.01284580f, 0.01021728f, -0.03036949f, -0.00976235f, 0.00336248f, 0.00881844f, 
    -0.04213337f, -0.02187252f, 0.01329939f, 0.02220619f, 0.01971230f, 0.01187797f, 0.00539402f, 0.03286935f, 
    0.03364648f, 0.02003087f, -0.01094689f, -0.02129223f, 0.01534533f, -0.00838513f, -0.00528450f, -0.01475481f, 
    -0.01063622f, -0.01683151f, 0.01046716f, 0.02639944f, 0.02440570f, -0.01918899f, -0.00074973f, -0.00103740f, 
    -0.02860626f, 0.01064857f, -0.02028974f, -0.02623338f, 0.01082584f, -0.01865740f, -0.01326049f, -0.02729903f, 
    0.00664084f, -0.00841376f, 0.01800908f, -0.03126868f, 0.00459185f, -0.00635095f, 0.01987617f, -0.01853120f, 
    -0.00504271f, 0.01320310f, 0.01199720f, -0.02003935f, 0.01798173f, -0.03771546f, -0.00038662f, -0.03579768f, 
    0.01450511f, -0.03325554f, -0.01761555f, -0.02749664f, -0.01925443f, -0.02677667f, -0.03266691f, -0.00931752f, 
    0.01715653f, 0.00962528f, -0.04037721f, 0.01584517f, -0.00553984f, -0.01184178f, -0.00589891f, -0.03640324f, 
    -0.01487193f, -0.00867156f, -0.02723376f, -0.00948144f, -0.01280574f, 0.00768642f, -0.03973664f, -0.00719832f, 
    -0.02839530f, -0.00514929f, -0.00582194f, -0.03522302f, 0.02711370f, -0.00588531f, -0.01157096f, 0.02966810f, 
    -0.00635575f, 0.02021126f, 0.00170426f, -0.00341631f, 0.01866878f, -0.02508603f, -0.02583200f, -0.01668488f, 
    -0.00961478f, 0.02734338f, 0.00899293f, -0.01250145f, 0.00725906f, -0.02677038f, -0.04127199f, 0.01871007f, 
    -0.00201200f, -0.02913037f, -0.03773036f, -0.00280597f, 0.02299390f, 0.02890414f, 0.00983669f, 0.00928113f, 
    -0.03857595f, 0.01654545f, -0.02080335f, 0.01680425f, -0.02748285f, -0.00019068f, -0.02553742f, -0.00381327f, 
    0.01983805f, -0.00842013f, -0.01274736f, -0.03266783f, 0.01310688f, -0.01755434f, -0.00460487f, 0.01637773f, 
    0.02036617f, 0.01098539f, -0.03193323f, -0.00602422f, 0.02016059f, -0.03761595f, -0.02458678f, 0.02020237f, 
    0.02519931f, -0.01321867f, -0.01524430f, 0.01123924f, 0.02053048f, -0.01867731f, -0.03429906f, 0.02027459f, 
    0.00630014f, 0.02861661f, -0.03364786f, 0.00812406f, 0.01439101f, -0.02528217f, -0.01031639f, -0.02466658f, 
    -0.03754755f, -0.00081967f, -0.02479634f, -0.00968228f, 0.00158636f, 0.02084423f, 0.00762011f, -0.01731952f, 
    -0.00875850f, -0.00073045f, -0.04412800f, 0.02781365f, 0.01956601f, -0.01059130f, 0.00681528f, 0.01607490f, 
    -0.00215057f, -0.00692627f, -0.01599068f, -0.04216783f, -0.03537938f, -0.02253826f, -0.04351981f, 0.01961765f, 
    -0.01668809f, 0.00032514f, 0.02929590f, -0.02924004f, 0.00852156f, -0.02192076f, -0.02024937f, -0.02925947f, 
    -0.03636474f, -0.03145263f, -0.03613132f, 0.02410735f, 0.02731720f, 0.02232894f, 0.00096199f, -0.01974350f, 
    -0.03190635f, -0.01642139f, 0.01866060f, -0.00828312f, 0.02422603f, 0.01456880f, -0.02665849f, -0.02607456f, 
    -0.01414848f, -0.02745826f, -0.00073430f, 0.01991990f, -0.03366833f, 0.02067108f, -0.02365862f, 0.01480833f, 
    -0.00517347f, -0.01408373f, -0.01561617f, 0.00381383f, -0.02581473f, 0.01793460f, 0.02521344f, 0.01196987f, 
    -0.01776786f, -0.02005388f, -0.02815036f, -0.04359119f, -0.01907188f, -0.00966357f, 0.02597264f, 0.02299424f, 
    -0.00730038f, 0.02602157f, -0.00427078f, -0.02233729f, 0.01546812f, 0.00573736f, -0.00264045f, -0.04296253f, 
    0.01318852f, -0.03479412f, 0.01854467f, -0.04263403f, -0.03447504f, -0.00617796f, 0.00737528f, -0.02999473f, 
    0.00183295f, 0.02169592f, -0.03241515f, 0.00363511f, 0.00264914f, -0.03739639f, -0.03618776f, 0.02169472f, 
    0.00249124f, 0.02417183f, 0.01417163f, -0.01945500f, -0.01576849f, 0.01229769f, -0.00928888f, 0.02933600f, 
    -0.04294306f, 0.02474206f, -0.02607275f, -0.02528611f, 0.02555598f, 0.02536787f, -0.03364387f, 0.02986134f, 
    -0.00793629f, -0.02152579f, -0.01911492f, 0.00572287f, -0.01713233f, -0.03782383f, -0.00398351f, -0.04264259f, 
    -0.03622364f, 0.00054257f, -0.00358476f, -0.00744432f, 0.02311551f, -0.01268650f, -0.01291861f, -0.02546674f, 
    -0.00488284f, 0.00997782f, -0.00520814f, -0.00332485f, 0.00045612f, 0.01482787f, 0.00167464f, -0.03465470f, 
    -0.01122641f, -0.01992682f, 0.00947999f, -0.01797828f, -0.01197915f, 0.02331083f, 0.00360171f, 0.01089694f, 
    -0.03884876f, -0.00516590f, -0.01167591f, -0.03343818f, -0.01183556f, 0.00107207f, -0.03708383f, 0.01817436f, 
    0.01774755f, 0.00233891f, -0.01337037f, 0.02093945f, 0.00896912f, -0.02082624f, 0.02325604f, 0.01554205f, 
    0.00245203f, -0.01742730f, -0.00648409f, 0.01172680f, 0.02435397f, -0.00513190f, 0.01520619f, -0.04013047f, 
    0.00586953f, -0.01417725f, -0.01981314f, -0.02387019f, -0.01593746f, 0.02002480f, 0.03183502f, -0.01918462f, 
    0.02496094f, 0.00986575f, -0.01718489f, 0.00767024f, -0.03720113f, 0.02566980f, -0.00534514f, 0.03548081f, 
    -0.03464425f, 0.02094531f, -0.02021712f, 0.01725514f, -0.03941192f, 0.00291024f, -0.01908110f, 0.01769990f, 
    -0.02737259f, -0.00344352f, 0.00789945f, 0.00453869f, 0.00954255f, -0.01578623f, -0.00384803f, -0.00524313f, 
    0.00305581f, -0.04021273f, 0.01299372f, -0.03797303f, 0.02509574f, 0.00451853f, -0.02580365f, -0.00947268f, 
    -0.02154619f, -0.00832051f, 0.02448229f, 0.02275974f, 0.02720497f, 0.01605421f, 0.00149541f, -0.00021319f, 
    0.01455833f, -0.03408061f, 0.01964017f, -0.02247920f, 0.03153669f, -0.01159295f, -0.03740051f, -0.04121910f, 
    -0.03986504f, -0.04296093f, 0.02301842f, -0.02785611f, -0.00064211f, 0.02323986f, 0.01324508f, -0.01815897f, 
    -0.01688804f, 0.02174199f, -0.01499764f, -0.03244969f, 0.01727939f, 0.01125963f, 0.00564197f, -0.00603518f, 
    0.00205384f, -0.03969538f, -0.03768150f, 0.00918063f, -0.03518656f, -0.03585966f, -0.01277648f, -0.02254947f, 
    -0.02351632f, -0.01542867f, -0.03347015f, 0.02445834f, 0.01349235f, -0.02014585f, -0.00184537f, -0.02451426f, 
    0.02365706f, 0.01073517f, -0.03620958f, 0.01415202f, 0.01193002f, -0.02009806f, 0.01822543f, -0.00527427f, 
    -0.02169903f, -0.04455462f, 0.01170251f, -0.01349278f, -0.03225694f, -0.00203170f, 0.02616104f, -0.01690838f, 
    0.01000283f, -0.03573813f, 0.00991908f, 0.01808922f, -0.03109973f, -0.00077281f, 0.01459892f, -0.02888405f, 
    -0.01754980f, -0.02756052f, -0.00877015f, -0.02996353f, 0.00013109f, -0.01780726f, -0.02524290f, 0.02465846f, 
    0.00845664f, -0.00997997f, -0.00694238f, -0.03220423f, -0.03520631f, 0.00817692f, -0.02684154f, -0.00842809f, 
    -0.00040777f, 0.01212393f, 0.01579599f, 0.02143352f, -0.01215163f, -0.00736770f, -0.03736015f, -0.03989409f, 
    -0.04198402f, 0.01651689f, -0.02677498f, 0.01286317f, 0.00145488f, -0.04644441f, 0.01741966f, -0.04447916f, 
    -0.03346460f, -0.00113293f, -0.00219692f, -0.01973293f, 0.00299088f, 0.00021446f, -0.00572120f, -0.03018800f, 
    0.00951473f, 0.01284548f, 0.00839187f, -0.02579831f, -0.04733332f, 0.01586629f, -0.01152592f, -0.03726797f, 
    -0.00507407f, -0.01490347f, 0.01278919f, -0.04102987f, 0.02684286f, -0.00930852f, 0.00725509f, 0.01636204f, 
    -0.01467843f, -0.03483394f, 0.00651632f, 0.01695787f, -0.02688832f, -0.03162164f, 0.01350026f, -0.02101253f, 
    -0.04212934f, 0.01240277f, -0.00324631f, 0.01766633f, -0.02503997f, 0.01411795f, 0.02224272f, -0.01871011f, 
    0.00322851f, 0.01939929f, -0.01309187f, 0.02280973f, -0.04671471f, 0.02433320f, -0.02784611f, -0.02748729f, 
    0.01863651f, 0.02164670f, 0.00174516f, -0.03171534f, -0.00301002f, 0.01464607f, -0.02304291f, 0.02660733f, 
    0.01525988f, -0.03295459f, -0.02483581f, 0.00689798f, 0.02122967f, -0.01614984f, -0.03546981f, -0.02488999f, 
    0.01914022f, 0.03007112f, 0.00003412f, -0.03488594f, -0.01968943f, -0.02901752f, -0.00945584f, -0.03138275f, 
    -0.00452794f, -0.04284283f, -0.00359196f, -0.04069549f, -0.02163098f, -0.01664368f, -0.04384525f, 0.01314421f, 
    -0.04418171f, -0.04065989f, -0.00236391f, 0.00743657f, -0.04096107f, 0.00797655f, -0.02950184f, -0.01072708f, 
    0.01473342f, 0.00207087f, -0.00324487f, -0.01565930f, 0.01739027f, 0.00117955f, -0.04228241f, 0.01960027f, 
    0.02340562f, -0.01899422f, 0.00634429f, 0.00505904f, -0.01578027f, -0.03329112f, -0.03233672f, -0.00738281f, 
    -0.00097684f, 0.02047349f, -0.01905566f, -0.03919921f, 0.00769184f, -0.01182261f, -0.03620597f, -0.04200555f, 
    -0.02198781f, 0.00357365f, -0.02739103f, -0.03029954f, 0.01294781f, 0.00443630f, 0.02293788f, -0.03839839f, 
    -0.01549094f, -0.02084494f, 0.02360732f, 0.00753379f, 0.02590107f, 0.01883568f, 0.03243669f, -0.02962703f, 
    0.02276650f, -0.02033859f, -0.00703632f, -0.03243139f, 0.02135915f, 0.01784677f, 0.02976632f, -0.01770214f, 
    -0.02824639f, -0.01886283f, 0.02152098f, -0.00104468f, -0.02949307f, -0.02474303f, -0.00996388f, -0.03791986f, 
    -0.01501284f, -0.03950205f, 0.00363835f, -0.01560992f, -0.03325704f, 0.01641591f, -0.01362895f, -0.03795857f, 
    -0.02802959f, -0.01612675f, 0.00451495f, -0.03367410f, -0.03398688f, -0.01822435f, -0.04618103f, -0.00590125f, 
    0.00036407f, 0.00253184f, -0.02679151f, -0.03349318f, -0.02387669f, -0.02370353f, -0.01665290f, 0.00308655f, 
    -0.00463511f, 0.01819520f, -0.02119405f, 0.02695780f, -0.03194772f, -0.00381460f, 0.02178471f, -0.00515623f, 
    0.01979240f, 0.02323792f, -0.02778878f, 0.01431283f, 0.01853453f, -0.03329874f, 0.02283095f, -0.01682709f, 
    -0.04021443f, -0.02210321f, 0.01594771f, -0.02685143f, 0.01265208f, 0.00929131f, -0.00191141f, -0.00617966f, 
    0.00037372f, 0.02746951f, -0.00280977f, -0.01777143f, -0.01994153f, -0.00794252f, -0.01200109f, -0.03248043f, 
    0.00891662f, 0.01149905f, -0.04171985f, 0.00729630f, 0.02666692f, 0.00451813f, 0.01084129f, -0.02972439f, 
    -0.00674387f, -0.03706421f, -0.02547333f, 0.02073077f, -0.00412313f, -0.02268944f, -0.01137887f, 0.00372816f, 
    -0.04832795f, 0.00824637f, -0.02574146f, -0.02659208f, -0.01167324f, 0.01337021f, -0.02103519f, 0.00826425f, 
    -0.01170571f, -0.00131928f, 0.00512947f, 0.00043563f, 0.01095007f, -0.00325285f, 0.01088281f, -0.03626084f, 
    -0.02192638f, 0.02348734f, -0.03699552f, -0.03563897f, 0.00091347f, 0.01893359f, -0.02470623f, 0.01110394f, 
    -0.01343603f, -0.01076430f, -0.01262767f, -0.00357962f, -0.02320091f, 0.01554092f, 0.00954420f, 0.02450868f, 
    -0.01795555f, -0.03009565f, -0.01159056f, -0.03211166f, 0.01147519f, -0.01244261f, 0.00080995f, 0.00426516f, 
    -0.01337235f, -0.03063448f, -0.02528105f, -0.03333193f, -0.04577637f, -0.03701666f, -0.00942949f, 0.01293895f, 
    -0.03115238f, -0.01045271f, -0.00055378f, -0.02281029f, -0.01224335f, 0.00766166f, 0.03118878f, -0.02595941f, 
    -0.02431618f, -0.03381386f, 0.02045082f, -0.04584619f, 0.03402469f, -0.03387724f, 0.01565897f, 0.02045599f, 
    -0.03467573f, 0.00732885f, -0.00484417f, -0.00574642f, 0.01764933f, 0.02052135f, -0.01327895f, -0.01251335f, 
    0.00923296f, -0.01986319f, 0.01826515f, 0.02298398f, 0.00730493f, 0.01759398f, 0.00310249f, 0.02232233f, 
    -0.01498265f, 0.01408212f, 0.00232700f, -0.02677702f, -0.02632284f, 0.02079421f, 0.01803865f, -0.00584281f, 
    -0.00148929f, -0.04186358f, -0.01587880f, -0.03401406f, -0.03506236f, -0.00869995f, -0.01851272f, -0.01989027f, 
    0.03749993f, 0.01106247f, 0.03100240f, -0.01365200f, -0.02202493f, 0.01805615f, 0.02500234f, -0.03176481f, 
    0.00562856f, 0.02653178f, -0.01983281f, -0.03204574f, 0.00370527f, -0.01306304f, -0.03888105f, 0.02132669f, 
    -0.00748548f, -0.04125014f, 0.00727841f, 0.02460057f, 0.00537139f, -0.02938444f, -0.03691426f, -0.01482960f, 
    -0.00217974f, 0.00378083f, -0.04334803f, 0.02187421f, -0.04438103f, -0.02541608f, -0.04143228f, -0.01750167f, 
    0.02386397f, 0.00350564f, -0.04233978f, -0.03272223f, 0.00713890f, -0.00563290f, 0.01574139f, -0.01838198f, 
    -0.02286224f, -0.00387095f, -0.00977768f, 0.01886708f, 0.02875301f, 0.01436891f, -0.04464965f, -0.01901449f, 
    -0.04596637f, -0.03583649f, -0.03307164f, -0.00439127f, -0.03484341f, 0.00629920f, -0.00374499f, -0.00271856f, 
    0.02730488f, 0.02185483f, -0.01777142f, -0.03392825f, 0.00954220f, 0.00752404f, -0.01525444f, -0.03418238f, 
    -0.02492683f, -0.01095031f, -0.00323086f, 0.02281840f, -0.00869307f, -0.01168780f, 0.01983660f, 0.00152746f, 
    0.01764284f, -0.03504913f, 0.01227352f, -0.01046823f, 0.02975558f, -0.03712349f, 0.00670338f, -0.00643151f, 
    -0.03521018f, 0.02308315f, -0.02240459f, 0.01372820f, -0.01033747f, -0.02557649f, -0.03572769f, -0.01691110f, 
    -0.03276344f, 0.01471871f, 0.01106517f, -0.01212676f, -0.02988824f, -0.03045247f, -0.01309504f, -0.01076164f, 
    -0.01542396f, 0.00320133f, -0.03171540f, -0.00717138f, 0.01298418f, -0.03591465f, -0.03157737f, 0.02547943f, 
    0.02605863f, 0.00981993f, -0.02743726f, -0.00066235f, -0.00251131f, -0.01346657f, 0.01358927f, -0.01354973f, 
    -0.01954669f, 0.01882519f, -0.01135386f, -0.02592509f, 0.01693485f, -0.02023630f, -0.03698160f, 0.00294492f, 
    0.00010854f, 0.01099388f, -0.03223040f, -0.02452978f, -0.04020218f, 0.02490544f, -0.00392019f, 0.00361414f, 
    -0.02124844f, -0.04146133f, -0.02877919f, 0.01609270f, 0.02131886f, -0.03064159f, -0.01225525f, 0.02114711f, 
    0.02027443f, -0.04147730f, -0.03141343f, 0.02157907f, 0.01260199f, -0.00588606f, -0.03517130f, 0.02045840f, 
    0.01713252f, -0.00705476f, -0.00453301f, -0.04374665f, -0.02442513f, 0.00763918f, -0.01295760f, 0.02538930f, 
    -0.02612880f, 0.02092393f, 0.01375973f, 0.00107240f, 0.02658650f, -0.02378677f, -0.03652985f, -0.01433885f, 
    -0.03668158f, -0.03530991f, 0.02293122f, 0.00164990f, 0.02326502f, -0.01549592f, -0.02563993f, -0.02570457f, 
    -0.01332984f, -0.01837827f, -0.00330256f, 0.01168969f, -0.02242620f, 0.00153332f, -0.03888244f, -0.02923184f, 
    -0.00915763f, -0.00970790f, -0.02069095f, -0.00763452f, 0.01216983f, 0.02404121f, 0.02073046f, -0.01082068f, 
    -0.03854477f, -0.00878227f, 0.00647098f, -0.04459058f, -0.03505801f, -0.02427469f, 0.01913901f, -0.03634555f, 
    -0.01938472f, 0.02425232f, 0.00434277f, 0.01506726f, -0.02068846f, 0.01150163f, -0.00004357f, 0.02052801f, 
    -0.02663634f, -0.01370851f, -0.02384640f, -0.02495935f, 0.02179651f, 0.00183495f, 0.01858913f, -0.01088451f, 
    0.01681854f, -0.04269666f, -0.02200698f, -0.01416557f, -0.00427941f, -0.04731589f, 0.02854639f, 0.02501175f, 
    0.00953288f, -0.04446401f, -0.03858868f, -0.03683002f, 0.00672398f, -0.01024886f, -0.03090365f, 0.01864604f, 
    -0.02538014f, -0.02373674f, 0.01404759f, -0.03095219f, 0.01982422f, 0.02188099f, 0.00130512f, 0.01707217f, 
    -0.04337781f, -0.01525214f, -0.03370454f, -0.01309533f, -0.02947379f, 0.00439120f, -0.01341500f, -0.03298816f, 
    0.00200440f, 0.00303067f, -0.00409288f, -0.01874670f, 0.02069056f, -0.04633161f, 0.00422657f, -0.01995418f, 
    -0.01151231f, 0.01889279f, -0.03771595f, 0.02133108f, -0.00378249f, -0.00898825f, -0.01315658f, -0.04390618f, 
    0.01998711f, 0.01138124f, 0.02287720f, 0.02191431f, -0.00945808f, 0.01471858f, 0.01623607f, 0.01430403f, 
    0.01337797f, -0.03176010f, -0.03842899f, 0.02484843f, 0.01120828f, 0.00732234f, -0.02187302f, -0.02612644f, 
    -0.00519222f, 0.00486029f, 0.00178380f, 0.02454943f, 0.02618385f, -0.01512307f, -0.02156757f, -0.00826882f, 
    0.00575147f, -0.02312011f, -0.01768183f, 0.02071004f, -0.00642771f, 0.00883366f, -0.02539849f, 0.01596976f, 
    0.02032935f, 0.01142281f, 0.01869727f, -0.02094723f, -0.02669017f, 0.02365253f, -0.03715521f, -0.03131803f, 
    0.00733054f, -0.03527962f, 0.02144726f, 0.01109779f, -0.00330990f, 0.01226812f, 0.00922151f, 0.01119980f, 
    -0.01015283f, -0.00868763f, 0.01030614f, 0.02211347f, 0.01052148f, -0.00576544f, 0.02581085f, -0.00492527f, 
    -0.04168230f, -0.01420136f, 0.02628188f, 0.02950415f, 0.03576397f, -0.03591153f, -0.00229894f, -0.01329328f, 
    -0.01448521f, -0.03012819f, -0.01509065f, 0.03016413f, -0.00383622f, 0.02457492f, -0.02313670f, -0.00577061f, 
    -0.02277764f, -0.03121027f, 0.00221868f, 0.03079657f, -0.01804588f, -0.01878651f, -0.03900167f, -0.02220933f, 
    0.01246399f, 0.01630331f, 0.00253142f, -0.00495856f, 0.01575051f, 0.01855430f, -0.02491720f, 0.03184720f, 
    0.00962313f, -0.02790902f, -0.01445093f, 0.02309185f, -0.00487003f, -0.04025247f, 0.01098017f, -0.01781409f, 
    0.02723444f, -0.04077914f, -0.00282190f, 0.00188513f, 0.02692728f, 0.03167176f, -0.04069291f, -0.02061650f, 
    0.02018052f, -0.01122692f, 0.00045773f, -0.00042724f, -0.02341910f, 0.00849311f, 0.00692774f, -0.02494490f, 
    -0.00511104f, 0.01654386f, 0.03286334f, 0.00820378f, 0.02254607f, -0.04207826f, 0.02687249f, 0.01764699f, 
    -0.02364591f, -0.02578993f, 0.00378651f, 0.01034644f, 0.01024686f, -0.01434785f, 0.03789832f, 0.03247556f, 
    -0.02306165f, -0.02470694f, 0.00734040f, 0.02915853f, 0.01298490f, 0.02097735f, -0.02797876f, 0.01734953f, 
    0.01520995f, 0.02905325f, -0.03134300f, 0.01732491f, -0.02244105f, 0.02818404f, 0.02062443f, 0.00852350f, 
    -0.01289962f, 0.01279684f, 0.00632497f, -0.03447266f, 0.03456179f, -0.03694475f, -0.02846125f, -0.00899055f, 
    0.00910854f, -0.03611934f, -0.00005575f, 0.02612208f, -0.03741561f, 0.02411674f, 0.02057415f, -0.02245818f, 
    -0.03006291f, -0.03552762f, -0.02239317f, -0.00439894f, 0.01903350f, 0.00980484f, -0.00553267f, -0.03132629f, 
    0.00697811f, 0.02921202f, -0.02771879f, 0.02171956f, -0.00182099f, -0.00845735f, -0.00418930f, 0.00635601f, 
    -0.03450037f, -0.01963251f, -0.02303128f, -0.03382312f, 0.02510070f, 0.00455492f, -0.02774462f, -0.03407220f, 
    -0.01260372f, 0.00936912f, 0.02663976f, 0.01561420f, -0.00603419f, -0.02325263f, 0.00609246f, -0.01736680f, 
    -0.03055633f, -0.02174238f, -0.02084437f, -0.01659583f, -0.01910604f, -0.03935947f, 0.01114892f, -0.02090356f, 
    -0.03560277f, 0.01888686f, -0.01803995f, 0.02054479f, 0.00226268f, 0.02926608f, 0.02922246f, 0.02349359f, 
    0.01135222f, 0.01916414f, -0.02799227f, 0.03098715f, -0.02336978f, 0.01915659f, 0.00522075f, -0.01062873f, 
    -0.03438188f, 0.02509542f, 0.00540919f, 0.02289451f, 0.01406824f, 0.01144744f, -0.00595971f, 0.02100584f, 
    -0.00568538f, -0.02460416f, -0.03340848f, -0.00169497f, 0.00579011f, -0.03269539f, -0.03557986f, 0.03374217f, 
    -0.01497162f, -0.03664836f, -0.00683810f, -0.02345214f, -0.01546781f, -0.03925310f, -0.01004267f, 0.02783078f, 
    -0.03191335f, -0.03996745f, 0.00032449f, 0.02055136f, 0.01105629f, 0.01555958f, -0.03243387f, 0.01315207f, 
    0.00472222f, 0.01254369f, 0.01419383f, -0.01461840f, 0.02598079f, 0.00267786f, -0.03101808f, 0.03091760f, 
    -0.01537847f, 0.01866269f, -0.02324295f, -0.00086760f, -0.01760622f, -0.01685563f, 0.01706251f, -0.02367988f, 
    0.00943212f, 0.00083987f, -0.01878586f, -0.01585853f, -0.00981408f, 0.00638159f, 0.03762246f, 0.01124824f, 
    -0.00297145f, -0.01467944f, 0.00447702f, -0.00658955f, 0.01879031f, -0.01641378f, -0.01814093f, 0.01310765f, 
    -0.02851460f, 0.00978142f, 0.00782860f, -0.02866800f, -0.02813141f, 0.00270063f, -0.02567264f, 0.02822506f, 
    0.00325637f, 0.01140057f, -0.03596917f, -0.02742637f, 0.00657559f, 0.02813515f, 0.00209401f, -0.00132621f, 
    -0.00124136f, -0.03499522f, -0.03324216f, 0.01691781f, -0.01913418f, -0.03889181f, -0.01827741f, -0.00080530f, 
    -0.02287832f, 0.01527143f, -0.03493941f, 0.03197229f, -0.02177056f, -0.02962042f, -0.01085445f, 0.00151600f, 
    -0.00916968f, 0.02261112f, 0.01422703f, -0.02851630f, -0.02612265f, -0.01577151f, -0.01909017f, 0.01899834f, 
    0.02187859f, -0.03894072f, 0.01773838f, 0.02601089f, 0.01586555f, 0.00437671f, -0.00503609f, 0.02634965f, 
    -0.00444164f, -0.02496246f, 0.01967159f, 0.02391657f, -0.00528767f, 0.01831000f, 0.01875615f, -0.01623169f, 
    -0.03274794f, 0.01348264f, -0.01168919f, 0.02409299f, -0.01243110f, 0.01847061f, -0.02863767f, -0.03259644f, 
    0.02248219f, -0.00228265f, -0.01691382f, 0.02928175f, -0.02577009f, 0.02393724f, 0.02538380f, -0.02587712f, 
    -0.00012626f, 0.02956191f, -0.01816783f, -0.02110831f, -0.00801193f, 0.02248250f, 0.03184178f, -0.01640785f, 
    -0.00309896f, -0.00887992f, 0.02309918f, 0.03003571f, 0.02506080f, 0.02740790f, 0.00467879f, 0.02859958f, 
    -0.03737049f, -0.00780682f, 0.00346368f, -0.03614898f, -0.00858683f, 0.03230714f, 0.00170664f, 0.03578403f, 
    -0.02896996f, 0.01731062f, 0.01692607f, 0.03353325f, -0.04175055f, -0.02144593f, 0.01323950f, 0.01568114f, 
    0.00874469f, -0.00530543f, -0.02620451f, 0.03714364f, 0.00634846f, -0.01870130f, 0.00962430f, 0.02749075f, 
    -0.02068992f, 0.01091172f, -0.01505127f, -0.01020918f, 0.02670761f, 0.01033149f, -0.03382312f, 0.01801318f, 
    -0.01644071f, -0.03302945f, 0.01953723f, -0.01234310f, -0.01774261f, 0.02593403f, 0.00399556f, 0.00481396f, 
    -0.01165043f, -0.00100603f, -0.03097784f, -0.02247705f, -0.02881731f, 0.00600410f, -0.01261360f, 0.01415441f, 
    0.01133966f, -0.03021048f, -0.02052795f, -0.02186518f, -0.01672894f, 0.02810707f, -0.01895334f, 0.03158070f, 
    -0.02305764f, 0.01852843f, -0.02905406f, -0.01293105f, -0.02406815f, 0.02964963f, 0.01546212f, 0.03539329f, 
    -0.00332366f, -0.03715704f, -0.03531755f, 0.01905165f, 0.00869578f, -0.00208465f, 0.00187439f, -0.00561688f, 
    -0.00376101f, -0.01091895f, -0.02079033f, 0.00951213f, 0.01678690f, 0.02135344f, -0.03297318f, 0.03043879f, 
    -0.03769279f, -0.02530750f, 0.02609044f, -0.02485119f, -0.02603278f, 0.01971274f, 0.02363578f, 0.03062313f, 
    -0.02783175f, 0.00308746f, 0.01982373f, 0.02434470f, 0.00851538f, -0.00946800f, -0.00109740f, -0.02430422f, 
    -0.03055868f, 0.01078559f, 0.00592807f, -0.02832256f, 0.01297699f, -0.01350638f, -0.01650500f, -0.02379822f, 
    -0.00431027f, -0.00373064f, 0.01691999f, -0.01921952f, -0.01105926f, -0.02711904f, -0.03014728f, -0.00783323f, 
    0.02904261f, -0.02815340f, -0.03883547f, 0.01679198f, 0.02462040f, 0.02821492f, 0.01800016f, -0.01536092f, 
    -0.02010802f, -0.00929502f, 0.00594962f, 0.01444195f, -0.01521382f, 0.02290137f, -0.00821574f, -0.03759452f, 
    0.00685937f, -0.00858457f, -0.01251308f, 0.03045183f, -0.00318504f, 0.00078823f, -0.02233064f, -0.01172084f, 
    -0.02360921f, -0.00813843f, -0.02938956f, -0.02582554f, 0.01702335f, -0.02275308f, 0.01897987f, 0.00374084f, 
    0.01747838f, -0.02754779f, -0.00405612f, 0.00921893f, 0.01163265f, -0.02168494f, -0.01607361f, 0.01969447f, 
    0.00922312f, -0.03685536f, -0.00857108f, 0.00406682f, -0.03311862f, -0.02849003f, 0.02327196f, 0.00777524f, 
    -0.01485796f, -0.02096732f, -0.00667393f, 0.03281965f, 0.01232131f, -0.01791911f, 0.00626750f, -0.03099674f, 
    -0.01985299f, 0.01401767f, 0.02089761f, -0.01892097f, 0.01202684f, 0.00999152f, -0.01793435f, -0.02902929f, 
    0.00774841f, 0.01813237f, 0.00477919f, -0.01888452f, -0.03383898f, 0.02078781f, -0.01823944f, -0.01202690f, 
    0.02689788f, -0.00961100f, 0.03020709f, 0.02287622f, -0.02290532f, 0.02827959f, 0.02639966f, 0.02659440f, 
    0.00799270f, -0.02758047f, 0.00627376f, 0.01275995f, 0.02552102f, -0.00854080f, -0.01951556f, -0.00785111f, 
    -0.02355237f, -0.01795311f, -0.00930733f, -0.03565304f, 0.01207273f, -0.02056193f, 0.02665155f, -0.03676328f, 
    -0.01488837f, 0.00210604f, 0.00259477f, -0.03119523f, -0.01591574f, -0.00101470f, 0.02235470f, -0.02559594f, 
    -0.03845697f, 0.01476599f, -0.03285411f, 0.01620583f, -0.01792981f, -0.01662914f, 0.00338255f, 0.02939924f, 
    0.00588127f, 0.02981035f, 0.03335592f, -0.03873244f, -0.00140862f, -0.01021311f, 0.02068913f, 0.02539850f, 
    -0.00058644f, -0.00900285f, -0.02432646f, 0.00226006f, -0.03292330f, 0.00861303f, -0.02429793f, 0.02187260f, 
    -0.00961990f, 0.02225873f, -0.00764647f, 0.02675512f, 0.02488367f, -0.02967855f, 0.01354546f, -0.00307701f, 
    -0.03300864f, 0.02748425f, -0.02956981f, -0.00653624f, -0.00743027f, -0.03983441f, -0.01660585f, 0.00146835f, 
    -0.01581875f, 0.01205702f, 0.00168832f, -0.02814719f, -0.01023987f, 0.01469786f, 0.01950445f, 0.01111765f, 
    -0.00227131f, -0.00453248f, 0.02870794f, -0.01058223f, 0.00281099f, 0.00628238f, -0.01599680f, -0.03306019f, 
    -0.03148632f, -0.00834645f, 0.01875129f, -0.03635080f, 0.01698232f, -0.02427357f, 0.01468987f, -0.03711819f, 
    0.01807925f, -0.04016994f, 0.01014197f, -0.02233964f, -0.02954000f, 0.02058043f, 0.01311969f, -0.02136296f, 
    0.00731931f, -0.01527708f, 0.01840566f, 0.00920337f, 0.00586153f, 0.03063073f, -0.02910619f, 0.00390252f, 
    -0.01351742f, -0.03583948f, -0.03451274f, 0.02708622f, -0.01133836f, 0.02239370f, 0.00505704f, 0.00475208f, 
    0.00525205f, -0.00140088f, 0.03183657f, -0.03824917f, 0.02076807f, 0.04049549f, -0.03702736f, 0.00999512f, 
    0.01604760f, -0.00409847f, 0.00012911f, -0.02737805f, -0.03734602f, -0.02756993f, -0.02314549f, 0.00203679f, 
    -0.03557117f, -0.01867676f, 0.02231902f, -0.01869866f, 0.00051471f, 0.02339515f, 0.02774342f, -0.01034613f, 
    -0.01999969f, 0.02225678f, -0.02720356f, 0.02740840f, 0.02744557f, -0.01704353f, -0.02421104f, -0.01416470f, 
    -0.03869295f, 0.01720147f, 0.02909837f, -0.02998110f, 0.03476533f, -0.00153045f, 0.01389327f, -0.03664831f, 
    -0.00338656f, 0.00565244f, 0.01700607f, 0.02416713f, 0.02670786f, 0.03285291f, -0.01221681f, 0.01532326f, 
    0.00961423f, -0.03512268f, -0.01703479f, -0.00788054f, -0.02974243f, 0.02882558f, 0.02634064f, -0.00376425f, 
    0.00498723f, 0.02881599f, 0.02495846f, -0.01739149f, 0.02192271f, -0.01637385f, 0.02355260f, 0.00980224f, 
    0.00735200f, 0.00094336f, 0.03113754f, -0.00400623f, -0.00750544f, 0.01284926f, -0.02248893f, -0.01587588f, 
    -0.00164195f, 0.00525390f, -0.02076988f, -0.03824155f, -0.02955464f, -0.01076749f, 0.02282250f, 0.01915760f, 
    -0.03508308f, 0.00948037f, 0.00659838f, 0.00943935f, 0.02888842f, -0.02510934f, 0.00488879f, -0.02595572f, 
    -0.02936110f, -0.01452092f, 0.01396762f, -0.01842577f, 0.02031644f, 0.00629772f, 0.00857917f, -0.00904890f, 
    -0.03318233f, -0.00233260f, -0.00164045f, 0.02238300f, -0.01430212f, -0.00004460f, -0.01492176f, 0.02646663f, 
    0.02587948f, -0.02650290f, 0.00572749f, -0.00916542f, -0.00745455f, -0.03814292f, -0.01474761f, 0.02071242f, 
    -0.02404557f, -0.03739217f, -0.00284086f, 0.02354727f, 0.02995251f, 0.02636157f, -0.01682640f, 0.00056394f, 
    0.00562070f, -0.03572358f, -0.01529136f, 0.01448696f, 0.00436936f, 0.02524492f, -0.00820742f, 0.00202060f, 
    -0.00982229f, -0.01682283f, -0.00983636f, 0.00054138f, -0.00535029f, -0.03966297f, 0.00736125f, -0.01186377f, 
    0.02166688f, -0.01329508f, 0.00069319f, -0.00929500f, 0.02978781f, 0.00260038f, 0.00481858f, -0.03599221f, 
    -0.02418781f, 0.01443340f, -0.02367881f, -0.00616749f, -0.00190104f, -0.03869670f, -0.03534947f, -0.02438313f, 
    0.28202626f, -0.07233340f, 0.03829995f, -0.18803848f, 0.04389248f, 0.00137432f, -0.11170381f, 0.08625895f, 
    0.02218238f, 0.01521888f, 0.04284656f, 0.04419513f, 0.06557140f, -0.02335131f, -0.07696297f, 0.14596723f, 
    0.04298190f, 0.04516402f, 0.07524129f, -0.00071034f, 0.09187181f, -0.06046781f, 0.02641593f, 0.06461816f, 
    0.13116080f, -0.01851144f, 0.15098727f, -0.16966738f, 0.14496727f, 0.05532609f, -0.08524451f, 0.07139838f, 
    0.05843219f, 0.02063284f, 0.05059959f, -0.00002396f, 0.13186423f, 0.03398382f, 0.00299226f, 0.17273441f, 
    -0.03934209f, -0.00433349f, -0.05882300f, 0.00864188f, -0.02147741f, -0.10547601f, 0.00794125f, 0.02611281f, 
    0.06665522f, 0.18992803f, -0.12123508f, 0.02562172f, -0.00622666f, -0.03861504f, -0.05453740f, -0.00975836f, 
    -0.02052929f, 0.03066676f, -0.03679549f, -0.03617666f, 0.00910135f, -0.11384579f, 0.07166141f, 0.19113445f, 
    -0.03871162f, 0.05614948f, 0.06183115f, 0.06275234f, 0.07033651f, 0.02880484f, 0.01838484f, -0.02787723f, 
    0.03486494f, 0.08454847f, 0.08582429f, 0.00607106f, 0.08089515f, 0.03554981f, 0.02505571f, -0.00084203f, 
    0.02937774f, 0.11700021f, 0.00609195f, 0.06591474f, 0.00341554f, 0.07582246f, 0.11053509f, -0.02231467f, 
    0.02468889f, 0.01132751f, -0.02610141f, -0.05336266f, 0.10550984f, -0.07300718f, 0.03566917f, -0.02681524f, 
    0.03175859f, 0.13218416f, 0.06629732f, -0.19395277f, 0.06752554f, 0.08698814f, -0.07418881f, -0.04504472f, 
    0.04150390f, 0.09578349f, 0.12389704f, -0.03074523f, 0.12660578f, 0.07497519f, -0.00110367f, 0.08574072f, 
    0.11291968f, 0.04817933f, -0.03097231f, -0.01460038f, 0.03517706f, -0.03391997f, 0.03389768f, -0.04887855f, 
    0.15861627f, 0.03478328f, -0.01629511f, 0.02057132f, 0.10153465f, 0.05805120f, -0.01118336f, 0.00107685f, 
    -0.01730875f, 0.06017875f, 0.14402601f, -0.03204431f, -0.04199883f, 0.01599043f, 0.11178954f, -0.04980014f, 
    0.12139484f, 0.13352287f, -0.10241023f, 0.05051920f, 0.05071560f, 0.01499613f, 0.06597438f, 0.03421028f, 
    -0.16248666f, 0.20823604f, 0.01924868f, 0.19988616f, 0.03058359f, 0.00419138f, 0.02884736f, 0.01334168f, 
    0.00396015f, 0.05644858f, -0.06599808f, 0.02647450f, -0.27435717f, -0.17666721f, 0.08243690f, 0.05994523f, 
    -0.07378272f, -0.08425178f, 0.05009798f, 0.04070637f, -0.06383746f, -0.07198156f, -0.08119544f, -0.03040371f, 
    -0.00355169f, 0.11449414f, -0.01674208f, 0.08304659f, 0.11729476f, 0.07891474f, -0.04050914f, 0.03322781f, 
    0.09326157f, -0.01356879f, 0.06014858f, -0.04384427f, -0.14417583f, -0.07758407f, 0.03154171f, 0.20125709f, 
    -0.03290852f, 0.05978741f, -0.03947080f, -0.03439387f, -0.01775785f, -0.01566556f, -0.00641275f, 0.09237291f, 
    0.05619602f, 0.01842802f, -0.08835400f, 0.26302782f, 0.07814141f, 0.04273741f, 0.08067518f, -0.03777653f, 
    0.03386123f, -0.05692475f, 0.06360153f, -0.01748671f, -0.00145827f, -0.03215102f, 0.00182216f, 0.01307382f, 
    0.02144054f, -0.02016764f, 0.01139086f, -0.02455451f, -0.00704366f, -0.14859027f, 0.03991386f, 0.04541383f, 
    0.06623214f, 0.14657936f, -0.00947317f, 0.08366841f, -0.07661351f, 0.06083403f, -0.02738149f, -0.07527956f, 
    0.04198914f, 0.02231831f, 0.10388463f, -0.00998528f, 0.00090210f, 0.04382752f, 0.08413945f, 0.09378273f, 
    0.09626245f, -0.01886245f, 0.03655564f, -0.00662377f, 0.03912680f, 0.01288238f, 0.07417306f, -0.08465438f, 
    0.04757394f, -0.13879216f, 0.17883943f, -0.21023963f, 0.10798978f, 0.02180113f, 0.01347562f, -0.01846904f, 
    0.04760031f, 0.08334941f, -0.02075366f, 0.09383448f, 0.16546698f, 0.06572489f, 0.12456091f, 0.24555622f, 
    0.01762952f, 0.06723679f, -0.11166886f, -0.02267690f, -0.04016190f, 0.04351045f, -0.00006893f, -0.00924092f, 
    -0.03556740f, -0.01274690f, 0.22759517f, -0.24571994f, 0.02602586f, -0.00145928f, -0.01871847f, -0.05758266f, 
    -0.05120473f, 0.06965866f, 0.04752085f, 0.00703358f, -0.08183952f, -0.01954838f, 0.09657258f, -0.06039706f, 
    0.02443648f, -0.03640859f, 0.02851170f, 0.06751531f, 0.02522344f, -0.05596707f, 0.01192627f, -0.07379010f, 
    0.17762884f, 0.04990653f, 0.04494147f, -0.01323118f, 0.06150967f, 0.02912715f, 0.05095743f, 0.01349375f, 
    0.06943513f, 0.04650834f, 0.05759210f, 0.03754289f, -0.04877745f, 0.19515939f, -0.20209198f, 0.20342049f, 
    0.13272606f, -0.04637762f, -0.02017769f, 0.01939976f, 0.02173161f, 0.04402347f, 0.01036723f, 0.02486120f, 
    -0.22557794f, -0.08682093f, -0.06119145f, 0.20265724f, 0.04081275f, 0.05011092f, 0.04289824f, 0.04942349f, 
    0.02207316f, 0.04984597f, 0.10830150f, 0.10455263f, -0.03754127f, 0.24843290f, -0.06566606f, 0.15283759f, 
    -0.02773838f, 0.03870269f, 0.02693686f, 0.09503362f, 0.01952962f, -0.00009052f, 0.06692038f, -0.08421601f, 
    0.07303062f, 0.09064169f, -0.15453546f, 0.11972425f, 0.15796362f, 0.00769214f, -0.01083826f, 0.03345810f, 
    0.10548597f, 0.00421645f, -0.01441450f, 0.08001070f, -0.02195565f, 0.15373057f, -0.02803056f, -0.07694572f, 
    0.07022587f, 0.14806388f, 0.08590712f, 0.03678391f, -0.00499005f, -0.02118594f, 0.07990433f, 0.05520655f, 
    0.04678023f, 0.01696487f, -0.08639967f, 0.28270969f, 0.10307842f, 0.10944328f, 0.01374811f, -0.06754276f, 
    0.07649758f, 0.08643093f, 0.04285211f, 0.02580335f, -0.06170086f, -0.00758533f, -0.01747531f, 0.11460941f, 
    0.00997308f, -0.01407460f, -0.01958829f, 0.04545547f, 0.02532779f, 0.03683131f, -0.02515240f, 0.02231668f, 
    0.36796436f, -0.23607197f, -0.01443207f, 0.13347588f, -0.09245550f, 0.00608565f, -0.03763077f, -0.06223725f, 
    -0.00537365f, 0.04773491f, -0.01795397f, 0.01244290f, -0.37164864f, 0.07365614f, 0.10011081f, -0.12257495f, 
    0.16934040f, -0.03946489f, 0.08751494f, -0.06746787f, 0.08912960f, -0.02339931f, 0.01002697f, -0.02621487f, 
    0.11103901f, -0.04997056f, 0.09122824f, -0.08965059f, 0.13494800f, 0.08141743f, -0.06901593f, 0.07527421f, 
    0.02281742f, 0.01977789f, 0.05669255f, 0.04505970f, 0.28804335f, 0.00641738f, -0.06304146f, 0.21500093f, 
    0.06898408f, 0.05951062f, 0.06947359f, -0.08794390f, 0.07245439f, 0.00234283f, 0.00374467f, 0.12174913f, 
    -0.03862711f, -0.02049462f, 0.02628583f, 0.09245097f, 0.00023103f, 0.05239881f, 0.03420019f, -0.00999160f, 
    0.05138290f, 0.07255034f, 0.02615789f, 0.05113102f, -0.13163708f, 0.01259654f, -0.12912826f, 0.13689262f, 
    0.14001526f, 0.02720593f, 0.00882680f, 0.03407756f, -0.01872826f, 0.03600974f, 0.08378781f, 0.04225976f, 
    0.18162666f, -0.03570133f, 0.11961837f, -0.05845282f, 0.16766466f, 0.05848557f, 0.01093721f, 0.05160634f, 
    0.02337805f, 0.02850910f, 0.05070203f, -0.01124112f, 0.06036956f, 0.05938245f, 0.09564516f, -0.09476046f, 
    0.11828555f, 0.12375546f, -0.00622303f, -0.04609916f, 0.08917858f, 0.04310525f, 0.02341138f, 0.03373080f, 
    0.10668489f, 0.02556648f, -0.03591235f, -0.01302534f, 0.02834626f, 0.02908272f, 0.02177240f, 0.01979617f, 
    -0.03368581f, -0.02567367f, 0.02550025f, 0.05194016f, -0.06729622f, -0.08538747f, 0.03469941f, -0.04463725f, 
    0.14397968f, -0.03606970f, -0.00792494f, -0.11313213f, -0.05331271f, -0.02121329f, 0.10023520f, 0.11384840f, 
    -0.02044608f, 0.07168198f, 0.01418946f, 0.06763764f, 0.01879604f, -0.12106235f, -0.00184516f, 0.00864883f, 
    -0.04689668f, 0.06450821f, 0.04441682f, 0.07198180f, 0.05439870f, 0.00296463f, 0.02909622f, -0.00944863f, 
    0.11034065f, 0.04039253f, 0.04549453f, 0.03757122f, 0.04610761f, 0.02818218f, 0.05193739f, 0.09226390f, 
    0.08006401f, 0.11900400f, -0.03505517f, 0.08470641f, -0.07958999f, 0.00727947f, -0.01956358f, -0.01393453f, 
    0.01795670f, -0.07855421f, 0.07051346f, -0.06796965f, -0.16661456f, 0.10973912f, -0.17985691f, -0.06568130f, 
    0.06867076f, -0.00701470f, 0.02575057f, 0.02558232f, 0.12233368f, 0.00522563f, 0.02659365f, 0.15204458f, 
    -0.08470839f, -0.15542312f, 0.01767270f, 0.13436793f, -0.08385583f, 0.04928891f, -0.06264292f, -0.08438197f, 
    0.01154439f, -0.07461885f, 0.07540897f, -0.06812400f, 0.15771069f, -0.08167585f, -0.14811182f, 0.15748988f, 
    0.03534981f, -0.07259256f, -0.02164063f, 0.05284498f, 0.01447719f, 0.04591879f, -0.01099848f, 0.04071369f, 
    -0.13059348f, 0.00657911f, 0.04377002f, -0.14571068f, 0.10748379f, -0.03904488f, -0.01370736f, -0.01314238f, 
    -0.00798719f, 0.06888496f, 0.08917730f, 0.05763138f, -0.10828775f, -0.05167163f, 0.17273395f, 0.10649743f, 
    0.02646235f, -0.00308858f, 0.14950816f, 0.04553669f, -0.01539274f, 0.01800691f, -0.05827655f, 0.07042681f, 
    0.16392303f, -0.12302250f, 0.01339217f, 0.00846526f, 0.04892481f, 0.02684629f, 0.01315912f, 0.06702714f, 
    -0.05804901f, -0.01501882f, 0.00790059f, 0.06489093f, 0.16705891f, 0.02438846f, 0.07884995f, -0.01954722f, 
    0.03047829f, -0.03552726f, -0.04625180f, -0.00637016f, 0.06757812f, 0.04257484f, 0.05619447f, 0.04622059f, 
    0.00482110f, -0.11902833f, 0.05193480f, 0.26016331f, -0.15621182f, 0.12610593f, 0.11259093f, -0.06546026f, 
    -0.08669385f, 0.01080979f, 0.12178440f, -0.08334692f, 0.22930890f, -0.04243983f, -0.14640474f, -0.01627574f, 
    0.12800777f, -0.02793757f, -0.04429523f, 0.16148442f, 0.11716946f, 0.14752094f, -0.05626788f, 0.09318960f, 
    -0.06700762f, 0.29156008f, 0.07114182f, 0.16747147f, 0.00918630f, 0.08476482f, -0.02917331f, 0.00604605f, 
    0.05680043f, -0.02130577f, 0.07927335f, -0.03519465f, -0.07754461f, 0.18089072f, 0.04469894f, -0.04546961f, 
    0.11783553f, 0.04403801f, 0.07377271f, -0.02612167f, -0.00519997f, -0.03406609f, -0.01095787f, -0.01750448f, 
    -0.12106166f, -0.06806348f, -0.07167409f, 0.10728123f, 0.05083157f, 0.09178763f, 0.03608064f, -0.04103323f, 
    0.05958743f, 0.03209499f, -0.02243702f, 0.01465169f, 0.10592918f, 0.02151622f, -0.07197727f, 0.02700463f, 
    0.16978456f, 0.13392757f, -0.07045568f, -0.09434349f, 0.04281681f, -0.00842964f, 0.07931081f, 0.03026516f, 
    0.25301564f, 0.11232289f, -0.06047074f, 0.03559342f, -0.02383376f, 0.03584624f, -0.03626624f, -0.00010621f, 
    0.09481799f, 0.07939991f, 0.05893591f, 0.05445881f, -0.03338346f, 0.16630375f, -0.14073832f, -0.14447783f, 
    0.03663340f, -0.01408671f, 0.03353044f, 0.10236167f, 0.00311111f, -0.00511165f, 0.07432387f, 0.13097668f, 
    0.02154219f, -0.00061375f, 0.00160366f, 0.00134644f, -0.03507167f, 0.07510474f, -0.04066742f, -0.04008291f, 
    0.01354119f, 0.04744828f, 0.07234214f, 0.03643601f, 0.00466991f, 0.02248873f, 0.06537926f, -0.14421897f, 
    0.10263207f, 0.00679914f, -0.05093614f, 0.09601361f, 0.01015068f, -0.00836693f, 0.02368403f, 0.09063133f, 
    0.11890259f, 0.06486384f, 0.03560236f, 0.32051620f, -0.00306449f, 0.03167569f, -0.05016407f, -0.04447848f, 
    -0.04530359f, 0.02262271f, 0.04928591f, 0.00653414f, -0.14562990f, 0.03494241f, -0.03443949f, 0.20439473f, 
    0.00079108f, 0.03453064f, 0.07837503f, 0.04352412f, -0.02320221f, -0.01863398f, 0.08026659f, -0.04180082f, 
    -0.21440357f, 0.04468147f, -0.13969699f, 0.00829102f, -0.03086754f, 0.12286162f, 0.14403966f, -0.14841129f, 
    0.01294859f, 0.11264984f, 0.04435034f, -0.07807299f, 0.12771478f, 0.03897357f, 0.09631536f, -0.08037212f, 
    0.00386699f, -0.01358706f, 0.02297522f, 0.03269454f, -0.06698831f, 0.00935713f, 0.09585287f, -0.07383987f, 
    -0.05615972f, -0.02695511f, -0.07305706f, 0.18770461f, -0.05717025f, -0.01263569f, 0.10991987f, -0.03429568f, 
    -0.00639463f, -0.02762371f, -0.09776875f, -0.01570068f, -0.00477213f, -0.07904512f, -0.08005214f, -0.07504413f, 
    0.03661051f, 0.10737598f, 0.03632187f, 0.07127325f, -0.02874197f, -0.00165870f, 0.03335819f, 0.06921029f, 
    -0.02372331f, -0.08789766f, 0.04271555f, 0.04025411f, 0.03749799f, -0.01480769f, -0.02528815f, 0.04009776f, 
    0.05905844f, -0.00415663f, 0.04173018f, 0.06653954f, 0.22401398f, 0.33376181f, -0.00733314f, -0.24746592f, 
    0.08494474f, -0.03619597f, -0.12928271f, -0.00533876f, 0.05017947f, 0.03299177f, 0.04630819f, 0.00001341f, 
    0.17871542f, -0.01229140f, -0.04879368f, 0.01355803f, -0.00487897f, -0.06017090f, -0.10885838f, -0.00130696f, 
    -0.02161699f, -0.08878506f, -0.05427228f, -0.05430819f, 0.00450028f, -0.16126287f, 0.07099861f, -0.05597818f, 
    -0.11180335f, 0.02622707f, -0.04362489f, 0.12549342f, -0.06573466f, 0.00077343f, 0.10406108f, -0.04263089f, 
    0.07899439f, -0.04941371f, -0.01906432f, 0.00759005f, 0.02713669f, -0.01150158f, 0.00053253f, 0.01870188f, 
    0.04549809f, -0.01132534f, -0.08671652f, 0.05619889f, -0.04308545f, -0.14137612f, 0.13084424f, -0.07949820f, 
    -0.05629642f, -0.07503062f, -0.04445275f, 0.01668890f, 0.00339341f, -0.04741029f, -0.01419772f, 0.11764387f, 
    0.05204594f, -0.14533663f, -0.00162007f, 0.01510766f, -0.00751973f, 0.00988444f, 0.05582627f, -0.00934262f, 
    0.03596702f, 0.04378906f, -0.06127136f, 0.03466124f, 0.08480201f, 0.02191791f, -0.11809244f, -0.02634449f, 
    -0.22838718f, 0.03732316f, 0.16022819f, 0.00764329f, 0.00784656f, 0.02509221f, -0.08570743f, -0.03735247f, 
    0.02795434f, 0.01276709f, 0.05613845f, 0.11181068f, 0.04773211f, -0.09342910f, 0.03284494f, 0.18645285f, 
    -0.07902647f, -0.08624098f, 0.09716296f, 0.04830845f, 0.27434164f, 0.03995482f, 0.03914097f, 0.05568842f, 
    -0.05690571f, -0.02602435f, -0.00643329f, 0.14708892f, 0.00388149f, 0.02274907f, 0.10100710f, -0.06641219f, 
    0.32148007f, -0.09149158f, 0.09815370f, 0.05078953f, -0.07120140f, -0.00533180f, 0.04947043f, -0.08892659f, 
    0.02692878f, -0.01414220f, -0.04689065f, 0.08633924f, 0.17451733f, 0.11096916f, -0.04439412f, -0.10678215f, 
    0.03664896f, 0.00889819f, -0.03600643f, 0.07137106f, -0.04237251f, 0.00816053f, 0.03033505f, 0.02873121f, 
    -0.00403991f, 0.00915171f, 0.12801209f, -0.09414185f, 0.05367997f, 0.04669257f, -0.02467696f, -0.04434112f, 
    -0.04102536f, 0.11400641f, -0.05733082f, 0.11068684f, 0.16342336f, -0.00272111f, 0.07822315f, 0.01830603f, 
    -0.01711423f, 0.03375505f, 0.00717876f, 0.03814919f, 0.02415666f, 0.15930313f, 0.02012401f, -0.03663694f, 
    0.07036022f, -0.12800799f, 0.09737047f, 0.01892146f, -0.07788417f, -0.12003210f, -0.01075680f, 0.03293490f, 
    0.00121509f, 0.00597764f, -0.06876878f, 0.03141288f, 0.09597212f, -0.09324940f, -0.09384700f, -0.10985494f, 
    0.00220472f, -0.00809699f, 0.03860752f, -0.02133290f, -0.01193914f, 0.01030645f, -0.08999984f, 0.11907804f, 
    0.10307534f, 0.00908630f, -0.06736512f, 0.17794439f, -0.05958758f, 0.03247575f, -0.01205672f, 0.03626560f, 
    0.05214342f, -0.12031309f, 0.03786333f, 0.04057766f, 0.05176903f, -0.02391693f, -0.17732263f, -0.04816239f, 
    0.05179772f, 0.03580980f, 0.08034759f, 0.15064833f, -0.05156712f, 0.00162307f, 0.01977472f, -0.09045982f, 
    -0.01669678f, -0.06467056f, -0.19526313f, 0.07996571f, -0.01384407f, -0.04094842f, -0.01518130f, 0.13592763f, 
    -0.05607832f, 0.02206840f, -0.01937562f, 0.02017457f, 0.09135257f, 0.07781117f, -0.09110785f, 0.17684087f, 
    0.08325183f, -0.05692497f, 0.02742172f, 0.07071530f, -0.07230446f, 0.00003112f, 0.03317794f, 0.04238278f, 
    -0.03700242f, -0.09944066f, -0.04660023f, 0.08692495f, 0.00889747f, 0.11335950f, -0.04752389f, 0.00560150f, 
    -0.03486621f, -0.04973401f, -0.00462312f, -0.00586075f, 0.10080166f, 0.07682309f, 0.03803814f, -0.00010168f, 
    0.00325692f, 0.06949279f, 0.10515997f, 0.05887137f, 0.05009426f, 0.03691621f, 0.01422756f, 0.03221444f, 
    0.46013758f, 0.00316190f, 0.04268651f, 0.07551410f, 0.05296353f, -0.02305050f, -0.05269495f, -0.02123957f, 
    0.04026482f, -0.04425733f, -0.05135569f, -0.11144942f, -0.00231212f, -0.03384700f, 0.17158502f, -0.01591543f, 
    0.02614166f, 0.02167932f, 0.03941702f, 0.01877235f, -0.01605495f, -0.04613839f, -0.03944193f, 0.05756613f, 
    -0.14763661f, -0.06186881f, 0.15921439f, -0.23206869f, -0.06034983f, -0.00134593f, 0.07128524f, -0.00766393f, 
    -0.02087902f, 0.08341476f, 0.04682214f, -0.08143580f, -0.04261914f, 0.07744961f, 0.01361404f, -0.00864309f, 
    -0.04946372f, -0.00783878f, -0.06277955f, 0.02492106f, -0.01091289f, 0.09111482f, -0.12456931f, 0.02896807f, 
    0.11568762f, -0.02384860f, 0.16702384f, -0.15524921f, 0.04202909f, -0.08879535f, 0.04441543f, 0.00695749f, 
    -0.03046312f, -0.06282558f, -0.07414643f, 0.00049197f, 0.16688412f, 0.08445056f, -0.06959151f, -0.06905621f, 
    0.03517274f, 0.11336999f, 0.06955994f, 0.00878101f, -0.09294648f, -0.04114216f, 0.02443221f, -0.03949003f, 
    -0.16865569f, 0.19558531f, -0.12352489f, -0.09008494f, 0.07537704f, 0.09611801f, 0.04245688f, 0.04258383f, 
    0.03348095f, -0.00507710f, 0.00133341f, -0.08871596f, -0.02752006f, 0.02600282f, -0.08246595f, 0.08717237f, 
    0.02255735f, 0.04459798f, 0.00106451f, 0.08080722f, -0.06986815f, -0.05745417f, 0.00855635f, 0.00012231f, 
    0.01404908f, -0.02151438f, -0.17455252f, 0.26744166f, -0.07489333f, 0.05847076f, 0.00798744f, -0.05531483f, 
    -0.06036149f, -0.01489424f, -0.02943680f, -0.00180311f, 0.07523246f, -0.00852944f, 0.11875984f, -0.17707789f, 
    -0.03126323f, -0.03103835f, 0.06735315f, 0.05306105f, 0.01620635f, 0.06179009f, 0.02502223f, -0.09118123f, 
    0.18283249f, -0.01005243f, -0.03006651f, 0.06138581f, -0.06491914f, -0.03835565f, -0.02567439f, 0.01070424f, 
    -0.02012027f, -0.05466885f, -0.02685517f, -0.03913539f, 0.19579454f, -0.01434750f, -0.00902548f, -0.18278289f, 
    0.07103381f, 0.01444163f, 0.08152334f, -0.07470352f, 0.06290798f, -0.01735872f, -0.05566563f, -0.11283316f, 
    -0.10221790f, 0.08313598f, -0.08766636f, 0.05044558f, -0.13960624f, 0.09856303f, -0.07672170f, 0.00048115f, 
    -0.06842063f, -0.08059047f, -0.07704145f, -0.03990660f, 0.02620692f, -0.11015031f, -0.16047302f, -0.05914862f, 
    0.01620784f, -0.01340518f, 0.00556988f, 0.01831123f, -0.12249311f, -0.01045173f, -0.02354006f, -0.05891751f, 
    -0.04617525f, -0.16770206f, 0.09918378f, -0.02157305f, -0.03188142f, 0.05017594f, -0.02143265f, 0.06913579f, 
    -0.00341973f, 0.05284803f, -0.00439863f, -0.00436894f, -0.00269415f, 0.09038412f, -0.06247764f, 0.12204892f, 
    0.01446254f, 0.04123192f, 0.00350278f, 0.03159517f, -0.02482590f, 0.08360945f, -0.05537923f, -0.06034353f, 
    0.04422935f, -0.07117226f, 0.01550252f, 0.00280934f, -0.02925499f, 0.10767594f, -0.03370076f, 0.04057771f, 
    0.09242848f, -0.06588937f, 0.04259393f, -0.04458724f, 0.04996872f, 0.04602141f, -0.04049738f, 0.07278223f, 
    -0.01082322f, -0.06377071f, -0.06054257f, -0.05749802f, 0.05797214f, 0.03364096f, 0.00054386f, 0.06383535f, 
    -0.12137068f, -0.20178907f, -0.03033859f, 0.06058960f, 0.04847064f, -0.06431407f, 0.00621849f, 0.01877169f, 
    -0.03444010f, 0.01960013f, -0.02039216f, 0.08373590f, 0.20126949f, -0.09488498f, 0.02117938f, 0.05461919f, 
    0.02795828f, 0.02230322f, 0.04373126f, -0.03476866f, 0.00825898f, 0.01283049f, -0.01030840f, -0.14809015f, 
    0.11066128f, 0.12234804f, -0.00680212f, -0.16965021f, -0.00102448f, -0.01418983f, 0.03296673f, 0.11778746f, 
    -0.04631414f, -0.03796548f, -0.03351955f, 0.09888990f, 0.06210228f, 0.16148855f, 0.03889954f, -0.17272690f, 
    0.02690613f, 0.19018587f, 0.03785993f, -0.05594299f, 0.10663114f, -0.07496122f, -0.00546590f, -0.05824887f, 
    0.17412245f, -0.01420537f, -0.14987250f, 0.07180865f, -0.05946026f, 0.05906403f, 0.03389531f, 0.07395597f, 
    -0.00880382f, -0.03568747f, -0.05212894f, -0.04485427f, 0.29858759f, 0.10036601f, -0.05600381f, 0.00119778f, 
    -0.00276763f, -0.03408058f, -0.12392117f, 0.02510315f, -0.03805928f, -0.08406352f, 0.04918760f, 0.06292664f, 
    0.11103296f, 0.08317327f, 0.15191253f, -0.12718974f, -0.12230016f, 0.06247464f, 0.08492277f, 0.03093458f, 
    0.02114014f, -0.02212414f, 0.00752440f, -0.04993638f, 0.05278286f, 0.03234059f, -0.05170534f, -0.09564732f, 
    0.02465063f, 0.03307265f, 0.00150184f, -0.06344463f, -0.00951957f, -0.06306797f, 0.00497061f, -0.05372060f, 
    0.10382976f, 0.04427379f, 0.12002680f, -0.02608648f, 0.04958396f, -0.06342506f, -0.00215793f, 0.02823054f, 
    -0.07329230f, 0.05194085f, -0.09770768f, 0.06773505f, 0.01405839f, 0.18701798f, 0.10774601f, 0.23490587f, 
    0.04007996f, 0.12794024f, 0.01115640f, -0.13368684f, -0.05076230f, -0.13334344f, 0.04378905f, -0.04800751f, 
    -0.06486358f, 0.01419012f, -0.08078884f, 0.03847900f, 0.02725253f, -0.05752835f, 0.06610002f, 0.01082791f, 
    -0.04663617f, 0.08673098f, -0.02595359f, 0.08134233f, 0.09641608f, -0.09035664f, -0.14098337f, 0.01148237f, 
    -0.02149055f, -0.03993314f, 0.09482674f, 0.04979980f, 0.05453308f, -0.02717344f, 0.05107298f, 0.03336798f, 
    -0.08643053f, 0.14200918f, -0.04805396f, -0.05740777f, 0.00992648f, -0.03421455f, 0.01488030f, 0.01834021f, 
    0.09293745f, 0.02413500f, 0.10918131f, -0.03771491f, 0.02663843f, -0.08424674f, -0.06277914f, 0.07712783f, 
    -0.06444193f, -0.03877098f, 0.07196087f, 0.07661707f, -0.13420981f, 0.00172209f, 0.01795378f, -0.12236535f, 
    -0.03590902f, -0.10929234f, 0.06697133f, -0.05798070f, 0.00410853f, -0.00134716f, 0.06654046f, -0.00715725f, 
    -0.00406513f, -0.02440077f, -0.03727114f, -0.07569992f, -0.04285252f, -0.08402391f, 0.13764617f, 0.27521676f, 
    0.06528184f, 0.07051237f, -0.05318667f, -0.05342649f, -0.05696521f, 0.06201987f, -0.02946144f, -0.14588541f, 
    0.05198998f, -0.02426448f, -0.02747802f, -0.03824329f, -0.03461971f, -0.03816615f, 0.01923126f, 0.04038544f, 
    -0.01242146f, -0.04207806f, 0.08261584f, 0.01176787f, -0.08801122f, 0.02523345f, -0.06277335f, 0.16544683f, 
    -0.05477259f, 0.05329681f, 0.07090963f, -0.02493314f, 0.05186903f, -0.06191494f, 0.04334482f, 0.01936234f, 
    -0.05911942f, -0.02724185f, 0.25122058f, -0.14939231f, -0.00434799f, 0.03772282f, 0.04688265f, 0.02629721f, 
    -0.05247654f, 0.01578334f, 0.02268010f, -0.02667915f, 0.24783643f, -0.03567804f, 0.15752336f, 0.00561162f, 
    -0.04604081f, -0.01205353f, 0.02442063f, 0.06691970f, -0.01206574f, -0.00484449f, 0.01896356f, -0.02497349f, 
    -0.03086186f, -0.03141250f, 0.02745346f, -0.01731120f, 0.01682049f, -0.02403160f, -0.01614800f, 0.00638830f, 
    0.02350434f, 0.01365258f, 0.02282495f, -0.02175126f, 0.01742130f, 0.02494037f, -0.03113972f, -0.00876096f, 
    -0.00996236f, -0.02905563f, 0.00594343f, -0.00148836f, 0.02019192f, -0.01517495f, -0.03284604f, -0.02251186f, 
    0.03309381f, 0.02652154f, -0.02635609f, -0.03196273f, -0.01123182f, 0.02847005f, -0.00118659f, -0.01930583f, 
    -0.01411054f, 0.02785485f, 0.01731193f, -0.00939130f, 0.00881001f, -0.02254248f, -0.02788443f, -0.02208578f, 
    -0.00653796f, -0.00593151f, 0.00844170f, 0.00132239f, -0.00384835f, 0.01513379f, 0.03202316f, 0.02523016f, 
    0.01336512f, 0.00361758f, 0.02705620f, -0.01758523f, -0.00580315f, 0.03193211f, -0.02296019f, 0.02090787f, 
    -0.00347312f, -0.01721434f, -0.02137307f, -0.02217300f, -0.01942917f, -0.00182026f, 0.00091838f, 0.01706457f, 
    0.02097951f, 0.00300974f, 0.01530102f, 0.01504966f, -0.01192019f, -0.02866539f, 0.01177199f, 0.02621962f, 
    0.00507888f, -0.02139261f, 0.02541291f, 0.01878272f, -0.02145743f, -0.01230949f, -0.00007631f, 0.02841399f, 
    -0.01973984f, -0.03597505f, -0.00413236f, -0.00921143f, 0.01453854f, -0.01274328f, -0.02924901f, -0.01983852f, 
    -0.00302324f, -0.03235570f, 0.00753075f, -0.00145559f, -0.02224158f, -0.02776016f, -0.03425530f, -0.02539380f, 
    -0.00040274f, 0.00064789f, -0.00246648f, 0.02974785f, 0.01746519f, -0.02766269f, -0.03349810f, 0.00741379f, 
    0.00692430f, 0.01142165f, 0.02885401f, -0.02156853f, -0.00650794f, -0.02220204f, -0.01509262f, 0.01432352f, 
    -0.03195038f, 0.01817596f, -0.03466146f, 0.02940448f, -0.01142072f, 0.00030755f, 0.02390927f, -0.03144589f, 
    -0.02101726f, 0.02028830f, 0.01573373f, -0.02581664f, 0.02167947f, -0.02528446f, -0.03072184f, -0.02142377f, 
    0.00609960f, 0.00949416f, -0.02441994f, -0.03179981f, -0.03689757f, 0.01988156f, -0.00011774f, 0.03103568f, 
    -0.03786290f, 0.02698012f, 0.02135995f, 0.02911392f, 0.01124415f, -0.00604047f, -0.02658749f, 0.00327532f, 
    0.00593899f, -0.03468385f, 0.00862981f, 0.00171147f, 0.02754803f, 0.02984505f, -0.00443739f, 0.00917561f, 
    -0.03445107f, -0.00690227f, -0.00584449f, -0.02513862f, 0.00437904f, -0.02089873f, 0.00503444f, 0.02085164f, 
    0.01352529f, 0.02292785f, -0.01161832f, 0.03085385f, 0.00561609f, 0.00212386f, -0.03886419f, -0.01720517f, 
    0.00565553f, 0.02454519f, -0.00751234f, -0.03606975f, -0.01402754f, 0.02848699f, -0.00180555f, -0.00178281f, 
    0.03295280f, 0.02761948f, -0.00617388f, 0.01183071f, 0.03053408f, -0.03211107f, 0.00828169f, -0.03023842f, 
    0.00601023f, 0.03071260f, 0.02326687f, 0.01388342f, 0.00225802f, 0.00378236f, 0.00317181f, 0.00550714f, 
    0.00490853f, 0.01232810f, -0.00070106f, -0.02166041f, 0.00832412f, -0.02045545f, 0.00913300f, -0.02645164f, 
    -0.03650528f, -0.03497028f, -0.04072811f, 0.00896036f, 0.00298173f, -0.01876152f, 0.00309839f, -0.00047259f, 
    0.01722000f, -0.03841087f, -0.00982406f, 0.01711717f, -0.00404152f, -0.03026204f, -0.03319270f, -0.00529110f, 
    -0.02036554f, -0.01165621f, -0.01676368f, 0.02822443f, -0.00687112f, -0.02866827f, -0.01593415f, 0.00702459f, 
    0.00977172f, 0.01962060f, 0.02032913f, -0.03601487f, 0.00852336f, -0.01003456f, -0.02552198f, -0.01730486f, 
    -0.03633272f, 0.01607335f, -0.02144497f, -0.00832951f, -0.00000809f, -0.02500903f, -0.00656273f, -0.01776242f, 
    -0.02780769f, 0.02819626f, -0.01226613f, -0.01098489f, -0.01298722f, -0.02461119f, -0.03344700f, -0.01508124f, 
    0.01912258f, -0.01127458f, 0.02678435f, 0.01917700f, -0.02129624f, -0.03324897f, 0.03362326f, 0.03243456f, 
    -0.03137768f, 0.02807609f, 0.00024430f, 0.02351535f, -0.03245382f, 0.02771517f, -0.02555271f, -0.03427215f, 
    -0.03101240f, -0.02672041f, 0.03177755f, -0.03563892f, -0.02715098f, -0.03001918f, 0.01675720f, 0.00455646f, 
    -0.00756999f, -0.02296561f, 0.02017065f, 0.02215999f, 0.03198605f, 0.00328309f, -0.01040142f, -0.01443710f, 
    -0.00157595f, 0.01792524f, -0.00263999f, -0.02511121f, 0.01250121f, -0.01187932f, -0.03480572f, -0.03445730f, 
    -0.00300073f, -0.02862981f, -0.01879527f, -0.02653117f, 0.01548632f, -0.02198632f, -0.03635502f, 0.00081418f, 
    -0.02737146f, 0.00361856f, 0.01492607f, 0.00018509f, -0.02612951f, 0.00070069f, 0.00499446f, -0.03758454f, 
    -0.01754805f, 0.01556182f, -0.02911344f, 0.02496167f, -0.03305561f, -0.02237073f, -0.02488161f, -0.02925791f, 
    0.00957445f, 0.02036890f, -0.00027181f, -0.02478901f, -0.02377779f, -0.00415930f, 0.02970497f, -0.03709748f, 
    -0.02541973f, -0.01740446f, -0.03030499f, -0.01121316f, -0.02040722f, 0.02713691f, -0.02234846f, 0.01658507f, 
    0.00016833f, -0.02272576f, 0.03136605f, -0.02945931f, 0.02221973f, -0.03690259f, -0.03606107f, -0.02656544f, 
    0.00082013f, -0.01683573f, 0.02896751f, -0.00410255f, -0.01779825f, 0.02160596f, -0.01575370f, -0.03284322f, 
    0.03491427f, 0.02421742f, 0.00845932f, -0.01504782f, 0.00663717f, 0.02098771f, 0.00900383f, -0.01012907f, 
    -0.00141123f, 0.02287098f, 0.01889153f, 0.02803013f, 0.02503311f, 0.02918297f, -0.01634951f, 0.03159393f, 
    -0.03354558f, 0.00361834f, -0.02353804f, -0.02730286f, 0.00093776f, -0.03630804f, 0.01285760f, -0.01167459f, 
    -0.01114818f, -0.02783540f, -0.02871533f, 0.01142031f, 0.02285052f, 0.01342016f, 0.01016733f, -0.03273217f, 
    0.01346252f, 0.01488832f, -0.02133815f, 0.01734049f, 0.02473925f, 0.00699451f, -0.01975165f, -0.03195867f, 
    0.01635264f, -0.02843469f, -0.01909622f, -0.02366886f, 0.02643532f, 0.00330975f, -0.03144208f, -0.00620490f, 
    -0.03305345f, 0.02674060f, 0.01575168f, 0.02409160f, -0.01533309f, -0.00717494f, 0.00552456f, -0.03274108f, 
    -0.00167063f, -0.02680965f, -0.00574041f, -0.01037494f, 0.00120663f, -0.00303048f, -0.03492164f, -0.00583300f, 
    0.01006325f, 0.01156809f, -0.02133664f, -0.01447671f, -0.00861453f, -0.00280174f, -0.02878987f, -0.03055584f, 
    -0.02091085f, 0.02846259f, 0.02971947f, 0.02578135f, -0.01429724f, 0.01702716f, -0.00203860f, -0.01290131f, 
    -0.01472611f, -0.01829743f, 0.00983056f, -0.03099461f, -0.02581154f, -0.01853041f, -0.00639672f, -0.00742209f, 
    0.01912458f, -0.03726282f, 0.00287317f, 0.01427033f, -0.01254403f, 0.02684184f, 0.00365622f, -0.00885650f, 
    -0.03925892f, -0.03162584f, -0.01381336f, -0.03918502f, -0.00249581f, -0.03811600f, 0.00959820f, -0.03253979f, 
    -0.01651905f, 0.00335055f, 0.01918565f, 0.02730302f, -0.03344319f, -0.02775726f, 0.00028142f, 0.00621640f, 
    -0.01806472f, -0.00824206f, -0.00641764f, -0.01417078f, -0.00519527f, -0.03671848f, 0.00468601f, -0.02780044f, 
    -0.00716244f, -0.03775312f, -0.02960898f, -0.02003853f, 0.01479750f, -0.00747389f, 0.03059302f, 0.00452080f, 
    -0.01370814f, -0.01336390f, 0.01188298f, -0.02892758f, 0.01375598f, -0.00151740f, 0.02397056f, -0.03284081f, 
    -0.02500058f, 0.02998415f, 0.00145387f, -0.02356424f, -0.03028818f, -0.03739454f, -0.03797060f, -0.01800929f, 
    0.00825768f, -0.03042273f, -0.03286498f, 0.02474696f, 0.02899577f, 0.01156770f, -0.02419129f, -0.03162631f, 
    0.02978810f, 0.02652501f, 0.01252322f, 0.02010494f, -0.01873416f, 0.02274505f, -0.03756903f, -0.00891458f, 
    -0.02043916f, -0.01965944f, 0.00447616f, -0.02613262f, -0.02600105f, 0.02388184f, 0.00462461f, -0.01243587f, 
    0.00737691f, 0.00110787f, -0.02092100f, 0.00088609f, 0.00078145f, -0.01480795f, -0.02848310f, -0.01301789f, 
    0.01074945f, -0.01157545f, 0.00107488f, 0.02754496f, 0.00817059f, -0.00853675f, -0.03535371f, -0.02984756f, 
    -0.01742154f, 0.00743514f, -0.01885772f, 0.00544449f, 0.01122942f, -0.01406624f, -0.03293802f, -0.00164042f, 
    -0.02518788f, -0.00252966f, 0.02682393f, -0.03612268f, -0.02612217f, 0.01280444f, -0.02625639f, 0.00219391f, 
    -0.01555291f, 0.00271693f, -0.02268093f, -0.01573957f, 0.00929007f, -0.01921030f, 0.00950988f, 0.01983993f, 
    -0.03241902f, -0.01411312f, -0.01006537f, -0.00416789f, 0.00651718f, -0.00581124f, -0.03679180f, 0.03352554f, 
    0.01693037f, 0.00659765f, 0.01960460f, -0.00384124f, 0.02207659f, 0.03003556f, -0.02818155f, -0.00342407f, 
    0.01151913f, -0.03727861f, 0.01621255f, -0.03438098f, 0.02752437f, -0.00139682f, 0.02367549f, 0.00059025f, 
    0.01475143f, 0.02801330f, -0.01749575f, 0.03014518f, -0.01460840f, -0.01287748f, -0.00870620f, -0.03437315f, 
    -0.03825685f, -0.03727224f, -0.03247268f, -0.01694824f, -0.01547793f, 0.00083889f, -0.00930747f, -0.01950200f, 
    0.00820860f, -0.03192249f, -0.01688193f, 0.02193226f, 0.01776245f, -0.02421703f, -0.03811794f, -0.02779190f, 
    -0.03222109f, -0.02070327f, -0.03634118f, -0.00657614f, -0.01798351f, 0.01559887f, -0.00062781f, -0.00771389f, 
    0.02907600f, 0.01877824f, 0.00111710f, -0.01735524f, -0.02685944f, 0.02783944f, -0.03689576f, 0.03328878f, 
    -0.00962544f, -0.02262450f, -0.02049729f, -0.02751602f, -0.02407869f, -0.00427155f, 0.02410474f, -0.02591336f, 
    -0.01646239f, -0.01196608f, -0.00109330f, -0.00236912f, -0.00683894f, -0.02822811f, 0.01337538f, 0.00962789f, 
    -0.03048432f, 0.03115197f, -0.02367226f, -0.03507458f, 0.02138886f, -0.02632794f, -0.00653948f, -0.01887193f, 
    0.01381136f, -0.00550957f, -0.00510720f, -0.02898057f, -0.02317809f, 0.01314605f, 0.02885490f, 0.02874488f, 
    0.00797958f, 0.02529829f, -0.02262747f, -0.00181552f, -0.01906961f, -0.01753375f, -0.03181893f, 0.00330436f, 
    0.02770478f, -0.01583323f, 0.01087029f, -0.01966854f, -0.00439475f, 0.03058995f, 0.01506315f, -0.02129750f, 
    0.03058419f, 0.00207337f, -0.01956848f, 0.00941991f, -0.03531133f, 0.00347798f, -0.02629451f, -0.00338988f, 
    -0.02637251f, 0.01960639f, -0.02931309f, 0.02942702f, 0.02647279f, 0.00640624f, -0.02358637f, -0.02348735f, 
    -0.00143248f, -0.01755421f, 0.02603015f, 0.03337293f, -0.03501954f, -0.02600682f, -0.01717775f, -0.03789777f, 
    -0.00572888f, 0.03217025f, 0.03044624f, 0.01016822f, -0.03408524f, 0.02335863f, 0.02584332f, 0.02321366f, 
    0.01869011f, 0.01419327f, 0.01016679f, -0.02207838f, 0.02856328f, 0.02121671f, -0.01866941f, 0.01760037f, 
    -0.03807461f, 0.02124829f, -0.01408335f, 0.00385051f, -0.02843059f, 0.01201291f, 0.01563118f, 0.01221915f, 
    -0.00615706f, -0.02161847f, -0.03424615f, -0.00947403f, 0.00131674f, -0.03451996f, -0.01151710f, 0.00652216f, 
    -0.02819131f, -0.02217947f, 0.01950612f, -0.00208958f, -0.03042060f, 0.01363169f, 0.01848707f, -0.02903884f, 
    0.00599159f, 0.03393844f, 0.01956112f, 0.01828329f, -0.03355666f, -0.00555719f, -0.02966719f, 0.01767994f, 
    -0.03191507f, -0.02878849f, -0.02142072f, 0.00629152f, 0.01449542f, 0.01329465f, -0.02466846f, 0.00392124f, 
    -0.02204141f, 0.00709687f, 0.00685461f, 0.01288135f, 0.02964847f, -0.01032891f, 0.00793210f, 0.01956334f, 
    0.00682333f, -0.02360410f, -0.00716319f, -0.01461099f, -0.00798879f, 0.00292133f, -0.00994095f, -0.02935579f, 
    -0.01099089f, -0.00702386f, 0.02751911f, -0.02322521f, 0.01770269f, 0.02924764f, -0.01221070f, -0.02962686f, 
    -0.03901272f, -0.01170021f, 0.00069180f, 0.01626806f, 0.03168261f, 0.00431395f, -0.00052639f, 0.01722196f, 
    -0.02019947f, 0.02195514f, -0.03309530f, -0.03366448f, -0.02495753f, -0.02390770f, -0.04001580f, 0.01050539f, 
    0.00733941f, -0.00108906f, 0.01405845f, 0.01413174f, 0.00690980f, 0.02587250f, -0.03300534f, 0.01710922f, 
    0.00845128f, -0.03633664f, 0.00599754f, 0.00891911f, -0.00948181f, -0.03811404f, 0.01005116f, -0.03882119f, 
    -0.01191008f, -0.00555081f, 0.00478394f, -0.00369937f, 0.00617101f, -0.02147007f, -0.00124612f, 0.00963328f, 
    0.00079571f, 0.02095019f, 0.00411328f, 0.02143426f, -0.02691785f, -0.02266382f, 0.00032011f, -0.02600396f, 
    0.01399462f, -0.01954833f, -0.02920668f, 0.00174246f, -0.03686271f, 0.02574836f, -0.03432938f, 0.02965205f, 
    0.02616621f, 0.01455688f, 0.02512818f, -0.01990878f, 0.03364056f, -0.00168755f, 0.03086597f, -0.01982091f, 
    0.00286084f, -0.01016947f, -0.03782671f, -0.00325113f, 0.03004785f, 0.00990135f, -0.01451406f, -0.02120118f, 
    0.03810412f, -0.02768132f, 0.01237180f, 0.01947667f, -0.02636272f, -0.02946513f, -0.02380281f, -0.00539256f, 
    0.01405366f, 0.00595407f, 0.02158137f, 0.01275031f, -0.02304940f, -0.00946032f, 0.02466818f, -0.04150980f, 
    0.00393141f, 0.02622519f, 0.02586244f, -0.01139591f, 0.02178730f, 0.01905409f, -0.00282415f, 0.01455222f, 
    -0.00930709f, -0.02452082f, 0.01507007f, -0.02462229f, -0.03730577f, 0.00274318f, -0.00071008f, 0.01711402f, 
    0.03359744f, -0.02430750f, -0.01099669f, 0.02512561f, 0.01853604f, 0.03957884f, -0.02481754f, -0.04013279f, 
    0.02771003f, -0.03570500f, 0.00721202f, 0.03515783f, -0.01005362f, 0.01864013f, 0.00520005f, 0.01992339f, 
    -0.02917122f, -0.00293343f, -0.00662905f, 0.00691972f, -0.00151304f, 0.03703330f, 0.02993946f, -0.03358587f, 
    -0.01557384f, 0.03235976f, 0.00990354f, 0.02479051f, -0.00686589f, 0.02627491f, -0.00662477f, 0.01360010f, 
    -0.01790852f, -0.03136289f, 0.02618129f, 0.02522255f, -0.03302386f, -0.00215660f, 0.02617803f, 0.02904435f, 
    0.01617682f, -0.00711966f, -0.00578063f, 0.02482651f, 0.01868681f, -0.03664749f, 0.00146496f, -0.00768317f, 
    -0.02580396f, -0.02921454f, 0.02904937f, -0.02588639f, 0.03516200f, 0.01287454f, 0.02340531f, 0.01427301f, 
    0.00805684f, -0.00994026f, -0.01754350f, -0.01775120f, -0.00201400f, 0.02574109f, -0.00293649f, 0.01113844f, 
    0.03172467f, -0.02879892f, -0.03361065f, -0.01501844f, -0.00646393f, -0.02206410f, 0.00705835f, -0.01378319f, 
    -0.00778481f, 0.02916162f, -0.01869807f, 0.02883497f, -0.01265152f, 0.03257794f, 0.02933690f, -0.02123700f, 
    0.00241406f, 0.01607002f, -0.02065026f, -0.01169214f, 0.03203275f, -0.00201966f, -0.02831472f, 0.02828407f, 
    -0.03716981f, -0.03331203f, 0.00234647f, 0.03227461f, 0.02683646f, 0.03103956f, -0.01889193f, 0.00327132f, 
    0.00521812f, 0.01317883f, 0.03362322f, 0.03264612f, 0.03895000f, 0.00987161f, -0.02013828f, 0.00258607f, 
    -0.01984272f, 0.00601930f, 0.01676203f, -0.00082986f, -0.03306041f, 0.00468702f, 0.00169140f, 0.03444552f, 
    -0.00894347f, -0.02438587f, 0.03750219f, -0.00624718f, 0.01283102f, 0.00549716f, 0.02661567f, 0.01930903f, 
    0.01180874f, 0.01247143f, -0.01028723f, 0.01798196f, -0.03916461f, 0.00227380f, -0.00077473f, -0.01302368f, 
    0.01063684f, 0.00409393f, 0.00270383f, -0.01958198f, -0.00144506f, 0.00370006f, -0.02530161f, 0.01611920f, 
    -0.02404782f, 0.01420245f, -0.01771658f, 0.03524424f, -0.01408321f, 0.01462885f, -0.00207748f, 0.01617483f, 
    0.00402022f, 0.02991831f, 0.00607840f, -0.00825748f, 0.00431170f, 0.01982475f, -0.02045526f, -0.03991700f, 
    0.02478732f, -0.03492868f, -0.02393165f, 0.00036773f, -0.01776700f, -0.00153301f, 0.02114643f, -0.01349973f, 
    0.01205713f, -0.01290013f, -0.02904047f, -0.01274710f, -0.03491132f, -0.02862459f, 0.02264207f, 0.01424418f, 
    -0.03125668f, 0.01923350f, 0.01560998f, -0.00824513f, 0.01788830f, -0.00140572f, -0.03687140f, -0.00510228f, 
    -0.01003741f, 0.01230713f, 0.00243738f, -0.01682648f, 0.00960459f, -0.01771134f, 0.02859576f, -0.01440285f, 
    0.00433973f, -0.00604509f, 0.02774428f, -0.03199448f, -0.01692612f, -0.00778938f, 0.00087050f, 0.00636809f, 
    -0.02566840f, -0.01068900f, -0.00596551f, 0.02455055f, 0.00996689f, -0.02571987f, -0.03853524f, 0.01639182f, 
    -0.01006534f, -0.02004273f, 0.02216959f, 0.01999643f, 0.02399145f, -0.00724856f, -0.00609601f, 0.01331971f, 
    -0.02923198f, -0.02167132f, 0.01527309f, -0.02608857f, -0.01814603f, 0.02741310f, -0.01139236f, -0.00927341f, 
    0.02502115f, -0.01589080f, -0.00876748f, 0.02094817f, 0.00333684f, -0.02447381f, -0.04086332f, 0.00129934f, 
    -0.03038254f, 0.00775986f, -0.03917089f, -0.00193390f, -0.01560773f, 0.03381107f, 0.01175198f, -0.01413189f, 
    -0.02669005f, -0.02419567f, -0.01987366f, 0.00952069f, -0.01796891f, 0.00659610f, -0.01906379f, -0.01546822f, 
    0.00050500f, -0.01486588f, -0.03033475f, -0.02711065f, -0.02538171f, 0.02770645f, -0.02291372f, 0.02638721f, 
    0.01782070f, -0.01631233f, -0.00343468f, -0.01224356f, 0.00310355f, -0.03225166f, 0.00097351f, 0.00664249f, 
    -0.00498421f, 0.01558189f, -0.00990909f, -0.03406508f, -0.02467804f, -0.02259124f, 0.03004057f, 0.02785440f, 
    -0.00994501f, -0.03515854f, -0.01940492f, -0.03436919f, -0.02224886f, 0.01518639f, -0.04072177f, 0.02871111f, 
    -0.00703099f, -0.00162037f, -0.02358023f, -0.01981447f, -0.00713841f, -0.02447983f, -0.00642253f, 0.03333888f, 
    0.02319865f, -0.00721669f, -0.00207464f, 0.02965470f, 0.02798998f, -0.00491880f, -0.00512141f, -0.00328484f, 
    -0.01193109f, 0.00096758f, -0.03782458f, -0.01991812f, -0.03197651f, -0.00145855f, -0.00138302f, -0.01143342f, 
    -0.03913827f, 0.00988523f, 0.02668092f, -0.01873200f, 0.00146384f, 0.00565502f, -0.03382427f, -0.02091573f, 
    -0.00584139f, -0.02131446f, 0.00708797f, 0.03298090f, 0.00133992f, -0.02202281f, 0.01821270f, 0.00017093f, 
    -0.03287935f, -0.02541801f, 0.01135150f, 0.02005276f, -0.01597469f, -0.04314435f, -0.00854570f, 0.00749505f, 
    -0.01805734f, -0.01769524f, -0.03562331f, 0.00875316f, -0.01568017f, 0.01655987f, -0.01971778f, -0.01059471f, 
    0.00665540f, -0.02438086f, 0.01221486f, -0.02158330f, -0.01643948f, -0.00531287f, -0.02427912f, 0.02403914f, 
    -0.02348351f, -0.01961972f, -0.03259569f, 0.00287603f, 0.00410852f, -0.02900695f, -0.00385253f, -0.00155818f, 
    -0.00093121f, -0.00880047f, 0.02406143f, -0.01490128f, -0.01675405f, 0.01039108f, 0.00146366f, -0.01578785f, 
    0.00268473f, -0.01405543f, -0.04012545f, 0.02073966f, -0.03471748f, 0.00663767f, 0.00631125f, -0.00528668f, 
    0.02820009f, -0.03082297f, -0.02560589f, -0.02825403f, 0.00083176f, 0.02697828f, 0.02898287f, -0.01529482f, 
    -0.01606611f, -0.02690071f, -0.01700775f, -0.00203532f, 0.01984966f, 0.00698823f, -0.01379777f, -0.01211154f, 
    -0.00448069f, 0.02476115f, 0.01535342f, 0.00159364f, 0.01324603f, -0.01275808f, 0.01317452f, 0.03094398f, 
    0.01027991f, -0.00013892f, -0.02511365f, -0.00579939f, -0.03035577f, -0.00911053f, -0.03942708f, -0.03391768f, 
    0.02662706f, -0.00519646f, 0.00414293f, -0.04241802f, -0.00455442f, -0.00857734f, -0.03615050f, 0.00114303f, 
    -0.01494804f, 0.03996014f, 0.01095451f, -0.02755413f, 0.01472017f, -0.00751391f, 0.00600485f, 0.00813984f, 
    0.01148358f, -0.01297042f, -0.01804599f, -0.01449202f, 0.01524638f, -0.02933621f, -0.00588842f, -0.00921406f, 
    0.01104953f, -0.03814900f, -0.00442639f, -0.00430844f, 0.01777234f, 0.00975617f, 0.00143468f, -0.00935834f, 
    -0.01792737f, 0.01489109f, -0.01443062f, 0.02215414f, 0.01911089f, -0.01160255f, 0.02879662f, 0.02992352f, 
    -0.01111099f, 0.01525791f, -0.02876267f, -0.00425457f, 0.00034572f, -0.04054555f, 0.00184703f, -0.03275811f, 
    -0.01432012f, -0.02482626f, -0.00061904f, -0.02866479f, -0.00708970f, -0.01222444f, -0.00574760f, -0.03585852f, 
    -0.03077280f, 0.01439185f, -0.01636313f, 0.03436764f, -0.01133708f, -0.02169264f, -0.02027445f, -0.03459683f, 
    0.02647883f, -0.01988575f, 0.03225454f, 0.00156728f, 0.02560851f, -0.02896943f, -0.03697904f, 0.00600054f, 
    -0.02069059f, 0.01306944f, -0.01818763f, -0.01108678f, -0.03617519f, -0.03938932f, 0.00784144f, 0.00286018f, 
    -0.03561124f, -0.01872320f, 0.02755050f, -0.02913514f, -0.01060458f, -0.03560986f, 0.01886093f, -0.02799457f, 
    0.01609684f, 0.02481707f, -0.01355834f, -0.01748474f, -0.02209814f, 0.03498667f, 0.01648429f, 0.00064246f, 
    0.01195475f, 0.00196169f, -0.03522210f, 0.00185327f, -0.01991581f, -0.02075587f, -0.00121252f, -0.02661929f, 
    -0.02059199f, -0.01634055f, -0.00702648f, -0.00511393f, -0.00769750f, 0.00363431f, -0.02027981f, 0.00177281f, 
    -0.00627435f, -0.01302384f, 0.00533723f, -0.03703578f, -0.00284879f, 0.02700964f, -0.02040723f, -0.01705376f, 
    0.01047370f, 0.03144784f, -0.02735040f, 0.00323382f, 0.00118575f, 0.00578054f, 0.00677444f, -0.01972021f, 
    -0.02376286f, 0.02167305f, 0.02718871f, 0.00935508f, 0.00418869f, -0.02720373f, -0.00194989f, 0.02803828f, 
    -0.01504498f, -0.02318322f, 0.02309453f, 0.02508621f, 0.00986959f, 0.00511889f, 0.03155375f, 0.00257676f, 
    -0.01090698f, 0.01496838f, -0.00780271f, 0.01571186f, 0.01213618f, 0.00690961f, 0.02457634f, -0.01343939f, 
    0.03434739f, 0.01594774f, 0.02337182f, 0.01373028f, -0.03590484f, 0.00005162f, 0.02855036f, -0.03029512f, 
    0.01944192f, -0.01185567f, -0.02532514f, 0.02276894f, 0.02574772f, -0.03948639f, -0.03655999f, 0.03064389f, 
    -0.03314485f, 0.00990910f, 0.01571907f, 0.02083659f, -0.00424371f, -0.01246250f, -0.01225745f, -0.03382890f, 
    0.02868663f, -0.02032174f, 0.02191698f, -0.02196597f, -0.03271608f, 0.00108239f, 0.01463983f, 0.01113994f, 
    0.02562685f, 0.01093126f, 0.00267884f, 0.00943927f, -0.00849272f, -0.03377519f, -0.00120211f, -0.00218868f, 
    0.03091968f, 0.02914533f, -0.00770364f, 0.00592358f, -0.03648113f, 0.00471884f, -0.03350960f, 0.02294756f, 
    -0.00874610f, -0.01562139f, 0.00578029f, -0.03304593f, -0.02996982f, 0.01593444f, 0.01079818f, -0.01652064f, 
    -0.00916017f, -0.01867540f, -0.02259407f, -0.01872880f, -0.01836845f, 0.00834109f, -0.02751965f, -0.01176333f, 
    -0.01098335f, 0.00181088f, -0.00681795f, -0.01710397f, -0.02313436f, 0.01928334f, -0.00302790f, 0.00082397f, 
    0.01101198f, 0.02507203f, -0.02609068f, 0.01455031f, 0.00352075f, 0.01528179f, 0.03198810f, -0.03211039f, 
    -0.02390169f, -0.03819279f, 0.00153332f, 0.02139085f, -0.02564507f, 0.01184441f, 0.01897383f, -0.01399777f, 
    -0.02661703f, -0.01821512f, 0.02285192f, -0.00968813f, -0.02000946f, 0.03285052f, -0.03935792f, 0.02904645f, 
    0.00583132f, 0.00022493f, -0.01862823f, -0.02842337f, -0.00130487f, -0.00573831f, 0.00586798f, 0.00797288f, 
    0.00555942f, -0.00463003f, -0.00546322f, -0.02668485f, 0.01640535f, 0.04082847f, 0.03067288f, -0.02404643f, 
    -0.00290863f, -0.00195240f, 0.01636270f, -0.03000818f, -0.01994511f, 0.01044408f, 0.02198698f, -0.00733024f, 
    0.23149022f, 0.08415271f, 0.11440752f, 0.15127888f, 0.08128030f, -0.02691760f, 0.08609890f, 0.03513724f, 
    0.02161129f, -0.02798223f, -0.03943365f, 0.07752167f, 0.26599246f, -0.16120487f, -0.09877399f, -0.12960014f, 
    0.07783365f, 0.03218464f, -0.05103597f, 0.05689868f, 0.01164635f, 0.05985742f, -0.01146089f, -0.00944170f, 
    0.09597442f, 0.00701472f, 0.17958727f, -0.02629672f, -0.22722454f, -0.03316687f, -0.00155241f, -0.06418181f, 
    0.04142071f, -0.05702611f, 0.21203855f, -0.08215034f, -0.09231879f, -0.02394316f, 0.05894794f, -0.36231014f, 
    -0.08121786f, -0.06275070f, 0.02301978f, -0.12822568f, 0.11452177f, 0.01459794f, 0.07281742f, -0.03950768f, 
    -0.10539395f, 0.07554698f, 0.15066190f, -0.10223196f, 0.05923558f, 0.02754393f, 0.06465322f, -0.00972147f, 
    -0.00761971f, 0.00328257f, 0.05279125f, 0.18372951f, -0.17762464f, 0.05333067f, 0.03996799f, -0.02483409f, 
    -0.04825329f, 0.10295200f, 0.03737461f, -0.07010923f, -0.06121537f, -0.01235279f, -0.01647522f, -0.02834106f, 
    -0.00992175f, -0.04174431f, 0.01904680f, -0.04978901f, 0.12702546f, 0.26834437f, 0.06071530f, 0.06068397f, 
    0.03388785f, 0.01916494f, -0.01345101f, -0.08674263f, -0.11229664f, 0.10540169f, -0.04351948f, 0.09205986f, 
    -0.05821811f, -0.08564591f, 0.04448553f, 0.08225468f, -0.06980671f, 0.03946489f, 0.01484278f, 0.06819469f, 
    -0.15386707f, -0.05119687f, 0.01500840f, -0.00296516f, 0.05843434f, 0.02602507f, 0.10814338f, 0.14509641f, 
    -0.08126170f, 0.04177516f, 0.02511249f, 0.12476342f, -0.06121114f, -0.05613938f, -0.13021757f, -0.06045031f, 
    -0.01418473f, 0.04981827f, 0.08892251f, 0.03167902f, -0.00298710f, 0.11841144f, 0.08633003f, -0.05259316f, 
    0.14650479f, 0.29555646f, 0.04860032f, 0.11913932f, 0.03546749f, 0.08277217f, 0.06707142f, 0.02942095f, 
    0.07931101f, 0.01129843f, -0.04813601f, 0.08883806f, 0.16833065f, -0.08959980f, 0.05860404f, 0.16336145f, 
    -0.05621731f, 0.09129710f, 0.03490018f, 0.12233701f, 0.01438417f, 0.07918262f, 0.10206401f, -0.05318127f, 
    0.21052143f, -0.21475892f, -0.06457675f, -0.17534499f, 0.15845855f, -0.03130545f, -0.03267484f, -0.03594539f, 
    0.05044341f, -0.01161726f, -0.04517420f, 0.09672653f, 0.15492438f, -0.18239662f, -0.03707673f, -0.05551475f, 
    -0.05003219f, 0.06315416f, -0.05148116f, -0.02115690f, 0.04046367f, 0.12584795f, -0.11386096f, 0.12218457f, 
    0.07285953f, -0.04671077f, -0.15556549f, 0.06734945f, 0.00961601f, -0.00770804f, -0.00230966f, -0.05993633f, 
    0.01369818f, -0.01359311f, 0.05629611f, -0.03734479f, -0.12295443f, -0.07498781f, 0.03353122f, -0.16740626f, 
    -0.06036267f, -0.01774529f, -0.01621013f, 0.05140567f, 0.07154718f, 0.12369023f, 0.00030495f, -0.00519771f, 
    0.23692656f, 0.09398471f, -0.09269756f, -0.04551085f, 0.02767415f, 0.08204510f, 0.12471774f, 0.04837541f, 
    0.07053104f, -0.00707029f, 0.06146491f, 0.08608083f, 0.14328822f, -0.15553814f, 0.04299184f, 0.01395427f, 
    0.05140691f, -0.03095122f, 0.02593132f, 0.11611667f, 0.09444290f, 0.01548589f, 0.07070940f, 0.09488716f, 
    -0.06857346f, -0.04308527f, -0.05656467f, -0.09045801f, 0.08394345f, 0.01258824f, 0.03964964f, -0.00618323f, 
    -0.01099938f, 0.12690507f, -0.01848215f, 0.03569549f, 0.19822526f, 0.03609280f, -0.08192636f, 0.23285703f, 
    0.07032164f, 0.01263745f, -0.04051711f, 0.00473026f, 0.07563242f, 0.14647532f, 0.01680863f, 0.08943542f, 
    0.24311951f, 0.03563189f, -0.03808518f, 0.19348009f, 0.03921951f, 0.01203584f, -0.01842323f, -0.00328272f, 
    -0.02463303f, 0.06173057f, -0.02354733f, -0.03023861f, 0.02214144f, 0.18885265f, -0.04047646f, 0.06171354f, 
    0.13603117f, -0.00853833f, 0.05296317f, -0.03109080f, 0.14900747f, -0.00140357f, 0.03053966f, 0.04092516f, 
    0.05883850f, -0.03926804f, 0.13724859f, 0.13547291f, 0.05963188f, 0.09133630f, 0.02843776f, -0.01602409f, 
    0.05983752f, -0.07398160f, 0.10051637f, 0.01314001f, 0.06957480f, -0.14869605f, -0.03181344f, 0.14127159f, 
    0.16881925f, 0.05301023f, -0.01209250f, 0.03921546f, 0.16391438f, 0.00751548f, 0.00385568f, 0.21607228f, 
    0.15900205f, 0.21758848f, 0.05922908f, 0.02949798f, 0.07746169f, 0.04402291f, 0.08136808f, 0.03119920f, 
    0.04210399f, 0.05089053f, -0.00645684f, -0.08649834f, -0.02237067f, -0.09137990f, 0.32168174f, -0.08467897f, 
    0.03560747f, -0.01167373f, 0.09049294f, 0.09896848f, 0.11795957f, 0.03291034f, 0.06848234f, 0.14589682f, 
    -0.08752534f, -0.02336536f, 0.10726009f, -0.11787929f, 0.00793874f, 0.02958982f, 0.01443618f, -0.00037883f, 
    0.04283913f, 0.03744702f, 0.07811088f, -0.03048880f, 0.24723887f, -0.20100324f, -0.12376580f, -0.03935795f, 
    0.06637128f, -0.05110600f, 0.03476661f, 0.03895883f, -0.02370292f, 0.05908051f, 0.04974615f, 0.04695120f, 
    0.02958832f, -0.02115904f, -0.00035990f, -0.14571615f, -0.02728178f, 0.09070021f, 0.13731113f, -0.06320364f, 
    -0.00401913f, 0.09179946f, 0.05508570f, 0.12759981f, -0.37546089f, 0.00493093f, -0.00288830f, -0.10940184f, 
    -0.03432221f, -0.12010588f, -0.03072813f, 0.04002399f, 0.06835938f, -0.02801247f, -0.01717929f, -0.00988260f, 
    0.14893962f, -0.29441521f, -0.05261462f, -0.13070697f, -0.01743248f, 0.04604008f, -0.03108654f, 0.01634986f, 
    0.00852963f, 0.07243293f, 0.04778166f, 0.03574457f, 0.09643359f, 0.03383171f, 0.07114368f, 0.12769850f, 
    -0.10197834f, 0.04941854f, 0.04843168f, 0.02923176f, 0.09274272f, 0.13391262f, -0.01448700f, 0.07486808f, 
    0.08313671f, 0.01695902f, -0.05575405f, -0.23839258f, 0.00416631f, 0.01856698f, 0.05079615f, -0.01382024f, 
    0.04657936f, 0.03379108f, 0.09806424f, -0.06568710f, 0.23732470f, -0.20565251f, 0.00257672f, 0.14541337f, 
    -0.05243907f, -0.04008142f, -0.03227241f, 0.09825289f, 0.05088527f, 0.06861992f, 0.05141356f, 0.06428157f, 
    0.25063807f, 0.10376570f, 0.11820958f, 0.04880554f, 0.01849590f, -0.10564400f, 0.09163239f, -0.00336133f, 
    0.07651714f, -0.00254123f, 0.06227269f, -0.05089927f, 0.13074744f, 0.07418764f, 0.06920122f, -0.07901464f, 
    -0.00134947f, 0.03208432f, 0.04474648f, 0.02590260f, -0.00102187f, 0.00966961f, 0.01077950f, 0.03300354f, 
    0.07184113f, 0.06519098f, 0.00941278f, -0.09187480f, 0.02027870f, -0.04690860f, 0.14026135f, 0.07136939f, 
    0.04568462f, -0.00233819f, 0.08287714f, -0.01889652f, -0.08465575f, -0.01771978f, 0.06556816f, -0.11576819f, 
    0.05770173f, -0.11550451f, -0.08768462f, -0.01186450f, 0.11802878f, 0.08006867f, 0.02399166f, -0.05316462f, 
    0.02575669f, 0.12024608f, 0.02320551f, 0.13907084f, 0.10112085f, -0.06006696f, 0.04667357f, 0.01147066f, 
    -0.00045863f, 0.07157324f, 0.04766948f, 0.10473857f, -0.01184411f, 0.09015735f, 0.14702626f, 0.20457762f, 
    -0.03054303f, -0.02726824f, 0.01029786f, 0.01155837f, 0.11941519f, 0.14913841f, -0.00063255f, 0.14314239f, 
    0.12824418f, -0.11295234f, -0.14114481f, 0.04147909f, -0.00317990f, 0.01674454f, 0.01393769f, -0.05976670f, 
    0.05859578f, -0.06644969f, -0.00515027f, 0.05495402f, 0.20220485f, 0.17416316f, -0.07867572f, 0.01999305f, 
    0.08293539f, 0.00062989f, 0.01451309f, 0.02961047f, 0.11694472f, 0.05280092f, -0.03325744f, -0.01436735f, 
    0.18929429f, 0.11573809f, 0.06357780f, -0.09381206f, -0.05835656f, 0.05324750f, 0.01179090f, 0.00677485f, 
    0.09522210f, -0.06636006f, 0.04180487f, 0.01049233f, 0.09198856f, 0.02257071f, 0.12719642f, -0.10044800f, 
    0.02576283f, 0.00377074f, -0.00534660f, 0.05478607f, -0.01267332f, -0.05422889f, -0.02972279f, -0.04167978f, 
    -0.05720964f, -0.02932586f, 0.07743219f, -0.20859715f, 0.04884988f, 0.01348968f, -0.01102739f, -0.00312582f, 
    0.06373742f, 0.03825010f, 0.00787884f, 0.02391348f, -0.06835363f, 0.19514120f, 0.03962342f, -0.05099788f, 
    0.07933181f, 0.04543787f, -0.01308899f, 0.06141940f, 0.09681755f, 0.05696863f, -0.08626831f, -0.02058366f, 
    -0.07386401f, -0.02310424f, -0.02167357f, -0.09387758f, -0.02165172f, 0.05741053f, 0.01542189f, 0.01088890f, 
    0.05078823f, 0.11256132f, -0.04700004f, -0.05446449f, -0.07052408f, -0.05711184f, -0.05786425f, -0.25909293f, 
    0.04391843f, -0.00163123f, 0.04207528f, 0.02063533f, -0.06001048f, 0.04271115f, 0.12233213f, -0.04246750f, 
    0.24284963f, 0.00006614f, 0.01139292f, 0.12070540f, -0.00168780f, 0.15873583f, -0.02379208f, -0.01729182f, 
    0.05694072f, 0.05611789f, 0.14360772f, -0.04189415f, 0.11804612f, 0.07170255f, 0.09364324f, -0.06216133f, 
    0.04218657f, 0.02109332f, 0.04959938f, -0.06637550f, -0.03063599f, 0.06634305f, 0.02632064f, 0.13582776f, 
    -0.19171758f, 0.03024933f, -0.09677516f, -0.06709228f, -0.05543411f, -0.01379442f, -0.00232245f, 0.00979275f, 
    0.07544910f, 0.04237836f, 0.11061773f, 0.01958846f, -0.10103840f, 0.06291012f, -0.09082016f, 0.01343901f, 
    0.13404375f, 0.12045171f, 0.04417300f, 0.11167241f, -0.04592575f, -0.00516419f, 0.04625999f, 0.11771812f, 
    0.14884116f, 0.05575476f, -0.03257294f, -0.00805464f, 0.04366616f, 0.09610415f, -0.10952139f, 0.01396793f, 
    0.05730130f, 0.06551153f, 0.03351396f, -0.01953239f, 0.01009809f, 0.02852503f, 0.05635105f, 0.02257529f, 
    -0.04147925f, -0.06111192f, -0.02298209f, 0.12514707f, -0.04527937f, -0.02929577f, 0.08141133f, -0.04699493f, 
    -0.00453278f, -0.03970440f, -0.01139936f, -0.15107921f, 0.09218328f, -0.03867054f, 0.02455622f, 0.06003344f, 
    0.01133569f, -0.02814598f, 0.01895437f, -0.06418546f, 0.13361688f, -0.03016296f, 0.03833511f, 0.19834645f, 
    0.06226045f, -0.00786607f, 0.05733071f, 0.04326512f, 0.06091419f, 0.03137651f, -0.06135019f, 0.06767271f, 
    0.16269158f, -0.06394234f, 0.03484424f, -0.03339630f, 0.03345941f, -0.09825832f, 0.02268716f, 0.04370700f, 
    0.02817841f, 0.13456580f, -0.04167461f, 0.06807151f, 0.01252137f, 0.18785509f, 0.01396846f, 0.15964694f, 
    0.07382820f, -0.04911131f, -0.01594676f, 0.03471409f, 0.12505502f, 0.07988980f, -0.09266742f, 0.12313982f, 
    -0.00225184f, 0.13347095f, -0.05136740f, -0.05011274f, 0.05607369f, 0.03360583f, -0.05156690f, 0.01460843f, 
    0.04849850f, -0.04228082f, 0.10765395f, 0.00193772f, 0.18756211f, 0.04423346f, -0.01135042f, -0.06805807f, 
    0.01530672f, 0.00746149f, 0.02234751f, 0.07516764f, -0.05702755f, -0.09589097f, 0.02389590f, 0.01873806f, 
    -0.11950914f, -0.11745542f, 0.00142698f, -0.02665601f, 0.01983575f, 0.02792955f, -0.05901989f, -0.07976691f, 
    0.03207628f, -0.01191141f, -0.10228463f, 0.01022470f, 0.08811034f, -0.02648357f, 0.06527383f, 0.19749264f, 
    0.05502447f, 0.00085354f, -0.03184743f, 0.09402311f, 0.02399619f, 0.05266541f, -0.03899236f, 0.08769085f, 
    -0.13192727f, -0.09107598f, -0.16615596f, -0.00393313f, -0.08397302f, 0.03226805f, 0.06681982f, 0.09035067f, 
    0.11924259f, -0.02253985f, 0.00334110f, 0.04168992f, 0.03847325f, -0.24314234f, -0.13854672f, -0.06358080f, 
    -0.05981362f, 0.02160038f, 0.02464121f, 0.05681941f, -0.00465531f, 0.04625020f, -0.05740038f, 0.07663672f, 
    -0.02824028f, -0.00589663f, 0.01990468f, 0.00822051f, -0.02441376f, 0.00631839f, -0.02222505f, -0.00899718f, 
    -0.02173334f, -0.02646102f, -0.02222897f, 0.02327590f, 0.00468942f, 0.01723880f, 0.01718980f, 0.03027779f, 
    -0.03918223f, 0.02692988f, 0.00395751f, -0.02714050f, -0.00666904f, -0.03475576f, 0.03041930f, -0.00156327f, 
    -0.03301872f, 0.00959403f, 0.02725841f, 0.00533523f, -0.00118985f, -0.01328681f, 0.00097550f, 0.00334912f, 
    0.02013493f, -0.01168640f, 0.00727556f, -0.03542120f, 0.01153614f, 0.00770493f, 0.01082030f, 0.03396900f, 
    -0.00119809f, -0.01437787f, 0.02358370f, -0.04099340f, -0.00172168f, -0.01361157f, -0.03963549f, -0.00323995f, 
    0.00292541f, 0.01231449f, -0.03013034f, 0.00015994f, 0.02875069f, -0.02085723f, 0.00474272f, 0.00998213f, 
    -0.02962742f, -0.02961899f, 0.03118884f, -0.02008295f, 0.02607788f, 0.00033331f, -0.03020982f, 0.01702327f, 
    -0.01172100f, 0.01105259f, 0.00579073f, -0.00238699f, -0.03532154f, -0.00718103f, -0.01996784f, -0.01956369f, 
    0.00770311f, 0.01596760f, 0.00224413f, -0.02019031f, -0.03526343f, 0.01309738f, -0.00240367f, 0.01502374f, 
    0.02043900f, 0.02240773f, -0.02152607f, -0.03143960f, -0.03237529f, -0.01372285f, -0.03334947f, 0.00927353f, 
    0.02088377f, -0.02233111f, -0.00522749f, 0.00909972f, 0.02916789f, -0.01218483f, 0.01089721f, -0.01633967f, 
    -0.01236432f, -0.00977104f, 0.01050666f, -0.02223460f, -0.00009968f, 0.01660885f, 0.01744180f, -0.01250735f, 
    0.02063596f, -0.01607878f, 0.03227417f, 0.02985138f, 0.01246724f, 0.01943193f, -0.02191680f, 0.01504561f, 
    0.00391556f, -0.02334385f, -0.02627090f, -0.01565337f, -0.00571394f, -0.00453884f, 0.02079213f, -0.03378754f, 
    -0.01558972f, 0.00060407f, -0.03411438f, 0.02556400f, -0.02235966f, -0.01367307f, -0.00814504f, -0.01662041f, 
    -0.01410735f, -0.02842416f, 0.01715679f, 0.00382332f, 0.00029789f, -0.03410640f, 0.02646069f, -0.01815000f, 
    0.02438426f, 0.00307259f, 0.01734147f, 0.02483156f, -0.00124950f, 0.01059665f, -0.01317013f, -0.00704565f, 
    0.03312610f, -0.03018522f, 0.02750299f, 0.01388459f, -0.02298434f, 0.01641312f, -0.03820694f, 0.02698185f, 
    -0.02742684f, -0.04335875f, 0.01236415f, -0.03389844f, 0.02954388f, 0.02953070f, 0.00569162f, 0.01607861f, 
    0.03269191f, 0.03108305f, 0.00317333f, -0.02252506f, -0.00105052f, 0.00693491f, -0.00817600f, -0.00548958f, 
    0.00443843f, -0.03258904f, 0.03206236f, -0.01010606f, -0.02196766f, -0.03712020f, -0.03556421f, 0.00583282f, 
    -0.01522876f, 0.02542270f, -0.03094133f, -0.04192933f, 0.00190177f, 0.02895161f, 0.02214255f, -0.02349501f, 
    0.03322069f, -0.01935332f, 0.00896165f, -0.03464029f, 0.03505591f, -0.01363934f, 0.04237510f, -0.00865803f, 
    -0.03433013f, -0.03285249f, -0.01569883f, -0.04054286f, 0.00034119f, 0.03318362f, -0.01070089f, -0.03294460f, 
    0.01502715f, -0.03923309f, 0.01271939f, -0.00575659f, 0.01212506f, -0.01742302f, 0.02719233f, 0.01347601f, 
    -0.03875969f, 0.02503286f, 0.02620278f, -0.00481813f, -0.03058622f, 0.00637187f, 0.02996164f, 0.00537032f, 
    -0.00400147f, -0.01748034f, -0.00829394f, -0.02250073f, -0.00684377f, 0.01384546f, 0.00787828f, 0.02924938f, 
    0.03182704f, 0.03058391f, -0.02495011f, -0.03012744f, 0.01790430f, 0.00118689f, 0.02555876f, -0.02836312f, 
    -0.00311202f, -0.03319868f, 0.02078035f, -0.00857066f, 0.01421178f, -0.03058069f, -0.02420790f, -0.00710846f, 
    -0.01718773f, -0.00960713f, 0.02722144f, -0.00453455f, -0.01802950f, -0.01060610f, 0.01634412f, 0.00992227f, 
    0.00385661f, 0.00424465f, 0.01984726f, -0.01177214f, 0.00233254f, -0.01984730f, -0.02330753f, -0.02533116f, 
    0.02189766f, -0.02152030f, -0.01742085f, 0.01491567f, -0.02340943f, 0.02708318f, -0.02281421f, 0.01661494f, 
    -0.01736083f, -0.01786410f, -0.03917215f, 0.01467423f, 0.01181817f, 0.00409943f, 0.00415459f, 0.00202712f, 
    -0.00047884f, -0.00081686f, 0.00398831f, 0.02170202f, -0.00722647f, 0.02097908f, -0.01870312f, 0.01807307f, 
    0.02909603f, -0.01572747f, 0.03491107f, 0.02277327f, -0.01020049f, 0.02155009f, -0.00860453f, 0.02836336f, 
    0.00232801f, -0.00956849f, -0.01615327f, -0.01159746f, 0.02387401f, 0.03741696f, 0.01301323f, -0.00646667f, 
    0.01129465f, -0.01346954f, -0.00924411f, -0.02676949f, 0.03390754f, 0.02047642f, 0.00660424f, -0.02973709f, 
    -0.03580829f, 0.00824973f, -0.01626260f, -0.03366075f, -0.00468980f, -0.02729785f, -0.00769443f, -0.03580511f, 
    -0.02789094f, -0.03971087f, -0.02585633f, -0.03743546f, -0.02109173f, 0.00770132f, -0.00644965f, -0.02968586f, 
    0.02554637f, -0.00111654f, -0.01270128f, -0.02994407f, 0.02246907f, -0.00493526f, -0.03385372f, -0.00956206f, 
    -0.02491875f, -0.02229295f, 0.00369590f, 0.00933079f, -0.02530174f, -0.00711299f, -0.03830178f, -0.00014722f, 
    -0.02382069f, -0.03965205f, 0.00709962f, 0.01468009f, 0.00431379f, -0.03731102f, -0.03609538f, -0.00633637f, 
    -0.03108591f, 0.01407706f, 0.00405906f, -0.04159733f, -0.02358200f, -0.01063308f, -0.01172636f, -0.03962840f, 
    0.02824570f, -0.01699688f, -0.01247177f, -0.03583416f, -0.03108949f, 0.02067948f, -0.00078064f, -0.00913138f, 
    -0.00696260f, 0.00762507f, -0.02877632f, 0.02152725f, -0.02397217f, 0.02482811f, -0.02540932f, 0.01089967f, 
    -0.02996136f, -0.03441712f, 0.00489553f, 0.02256656f, 0.01957665f, -0.02787301f, 0.00779383f, -0.01832166f, 
    -0.01147220f, -0.03499119f, -0.00075363f, 0.01475036f, -0.01199443f, -0.03342926f, -0.02521447f, -0.03008596f, 
    -0.01885486f, -0.00826108f, 0.01008126f, -0.03092076f, 0.02509027f, -0.03437630f, -0.00234252f, -0.02595921f, 
    0.01221224f, -0.03591616f, -0.00790917f, -0.00593421f, 0.03155162f, -0.03985867f, -0.01147260f, 0.01806096f, 
    0.01783293f, 0.03996940f, 0.00130690f, -0.01803325f, 0.01803465f, -0.03841665f, 0.01323701f, -0.02041216f, 
    -0.02014862f, 0.01303147f, -0.00898856f, -0.01828903f, 0.01570036f, -0.02304673f, -0.00412527f, -0.00244058f, 
    0.00400837f, -0.00481260f, -0.02453655f, 0.00964683f, -0.02144123f, -0.03125825f, 0.03324270f, 0.03632697f, 
    0.01517482f, -0.00487297f, 0.02465684f, -0.01422792f, -0.03262389f, -0.00806184f, -0.03553662f, 0.02078257f, 
    -0.03481443f, 0.02088962f, 0.03216941f, 0.02131277f, 0.02907705f, -0.03099441f, -0.02005566f, -0.02295375f, 
    0.00659964f, -0.01867935f, -0.01344054f, -0.01301196f, -0.03074004f, -0.02536925f, 0.03142835f, -0.02383844f, 
    -0.00534409f, -0.03977881f, -0.02002194f, -0.03316449f, -0.02424818f, 0.02119521f, 0.02163889f, 0.02612351f, 
    -0.03261328f, -0.00455393f, 0.00525415f, -0.02919541f, -0.00387525f, 0.02424434f, 0.00422332f, -0.01865969f, 
    -0.00540723f, -0.01471094f, 0.00707837f, 0.01265866f, -0.02736134f, 0.01450693f, -0.02379201f, -0.00830170f, 
    0.01389346f, -0.02192442f, -0.01332081f, -0.00560783f, 0.01877655f, -0.00011856f, -0.02906434f, 0.00466259f, 
    0.01525011f, 0.02709706f, -0.01912648f, -0.03217034f, -0.02417837f, 0.01306289f, -0.02484503f, 0.03512290f, 
    0.00950801f, -0.02635549f, 0.01552399f, -0.02798521f, -0.02580033f, -0.01316855f, 0.00939287f, -0.00844687f, 
    -0.01684999f, 0.01918157f, 0.02379045f, -0.00208507f, -0.00411283f, 0.02794015f, -0.00376579f, -0.03955555f, 
    0.01218091f, 0.02687792f, -0.01150991f, -0.01419744f, -0.01532276f, 0.03764480f, -0.01850676f, -0.00066856f, 
    -0.02967246f, -0.02211800f, -0.00951393f, -0.03768786f, 0.02472551f, -0.01409946f, -0.02405301f, 0.01708825f, 
    -0.01883726f, -0.02441248f, 0.02808155f, -0.03048905f, -0.00454589f, 0.02207420f, 0.03066875f, -0.03148022f, 
    -0.03041521f, -0.04085766f, -0.03427158f, 0.00842085f, 0.01595592f, 0.01385964f, -0.01509412f, -0.00161083f, 
    0.00998661f, 0.01405348f, -0.00440316f, 0.02645438f, 0.02014386f, 0.00634239f, -0.03216291f, -0.03579934f, 
    -0.01033770f, -0.03997698f, 0.03092627f, 0.03582879f, 0.02408693f, -0.01682292f, -0.02695047f, 0.00350359f, 
    -0.03526368f, -0.00997983f, -0.03782312f, -0.01661541f, 0.00622841f, 0.04027862f, 0.00609207f, 0.00590450f, 
    -0.00187333f, -0.02745203f, 0.00096608f, -0.00448607f, 0.01822418f, -0.03494949f, 0.01720193f, 0.02275609f, 
    -0.02223405f, -0.01373160f, -0.00821262f, -0.00936447f, 0.00488837f, -0.00227952f, -0.00374417f, -0.00564684f, 
    -0.03006437f, 0.03674711f, 0.01799248f, -0.03679583f, -0.01369825f, 0.02647953f, -0.01415427f, -0.01193273f, 
    0.00116128f, -0.02559285f, 0.03086229f, -0.01098784f, 0.01411505f, -0.02356679f, 0.00219972f, 0.00120253f, 
    -0.02288829f, 0.02160143f, 0.00035671f, -0.01316612f, 0.01791195f, 0.01397915f, -0.02060915f, 0.01172358f, 
    0.00653532f, -0.00332693f, -0.03101726f, 0.00868901f, 0.02971372f, -0.03747594f, 0.00353618f, -0.02651167f, 
    0.00028360f, 0.02671309f, -0.01469339f, 0.01121336f, 0.02726077f, -0.01021160f, 0.01869680f, -0.01902948f, 
    0.02428708f, -0.02667274f, 0.01854785f, -0.00512627f, -0.02417506f, 0.00819052f, -0.02013568f, 0.02225021f, 
    0.02741739f, 0.02403654f, -0.03392943f, 0.02725860f, 0.02666850f, -0.01235671f, 0.02269039f, 0.00721260f, 
    -0.01663881f, 0.02281306f, -0.02311603f, 0.02080499f, -0.02359913f, 0.00934061f, 0.01979017f, 0.00429528f, 
    -0.03503432f, -0.01301638f, -0.03248968f, -0.00970254f, 0.02534778f, -0.02155800f, -0.03524577f, -0.01775618f, 
    0.00218864f, 0.00280153f, 0.01680406f, -0.03399048f, -0.02796722f, 0.00357204f, -0.00714542f, -0.03387475f, 
    0.01807572f, 0.00126397f, -0.00799676f, 0.00758370f, 0.00857224f, -0.01286425f, 0.00873997f, -0.02283257f, 
    0.01135039f, 0.00289370f, -0.01373259f, 0.00508674f, -0.01884553f, 0.02809922f, -0.04145230f, 0.02495804f, 
    -0.02436040f, -0.02691801f, -0.01267928f, -0.03471910f, -0.01523852f, 0.01206787f, -0.00724394f, -0.03474388f, 
    -0.00922787f, -0.02693944f, -0.03147032f, -0.00452809f, 0.00322074f, 0.02190549f, 0.01941244f, -0.02046053f, 
    -0.03772487f, 0.02088175f, -0.01328832f, 0.02907853f, -0.04217700f, 0.00777633f, -0.04153736f, 0.02779669f, 
    0.01498112f, 0.02958754f, -0.01685306f, -0.03054008f, -0.01121855f, -0.02983529f, -0.03232119f, -0.03560630f, 
    -0.01623589f, 0.01306204f, -0.02595234f, 0.02218671f, 0.00612207f, -0.00910747f, 0.01074450f, -0.04124271f, 
    -0.01134036f, 0.01186454f, -0.00735511f, -0.02006533f, -0.02944452f, 0.01237706f, -0.03865308f, -0.00340273f, 
    0.00978796f, 0.01431205f, -0.00921665f, 0.02506951f, 0.04058179f, 0.00379619f, 0.01318947f, 0.00807875f, 
    0.02293054f, 0.01918791f, -0.03408284f, -0.01329609f, -0.00917229f, -0.03074417f, 0.00810497f, 0.00733453f, 
    -0.04034278f, 0.00883524f, -0.00922469f, 0.00279596f, -0.00489636f, -0.03372510f, 0.02463059f, -0.02196716f, 
    -0.01238781f, -0.02323806f, 0.00733703f, 0.02729459f, -0.03541885f, -0.02622433f, -0.01161232f, 0.00666783f, 
    0.01869268f, -0.03056808f, -0.00996256f, -0.03102026f, 0.02740386f, -0.03729942f, -0.01330123f, -0.01994520f, 
    0.02953317f, 0.01458950f, -0.00611345f, -0.04112701f, 0.00544750f, 0.01513352f, 0.01409620f, -0.02889621f, 
    0.21208970f, 0.06470361f, 0.04849286f, 0.25377581f, 0.06808185f, -0.03190968f, -0.12310027f, -0.01754210f, 
    -0.01317735f, -0.12198275f, -0.03503289f, -0.08137752f, -0.08255465f, -0.08655263f, 0.04496102f, -0.05100660f, 
    -0.04208223f, -0.07154258f, 0.06243775f, -0.04854768f, 0.05410471f, 0.08318097f, 0.10971456f, 0.02500711f, 
    0.20907021f, 0.02886829f, 0.03479562f, 0.17626491f, -0.06740902f, -0.06966034f, 0.01387264f, -0.04631386f, 
    -0.06870493f, 0.10789086f, 0.04351087f, -0.00532623f, 0.07366939f, -0.09425598f, 0.11069153f, -0.05647741f, 
    -0.06919923f, -0.07977957f, 0.00665654f, -0.12492014f, 0.10425039f, 0.02206289f, -0.06684256f, -0.13502185f, 
    -0.19003776f, -0.12910961f, 0.01521925f, -0.01245150f, 0.06150687f, 0.05296197f, 0.00884028f, -0.00195007f, 
    -0.00681218f, -0.05581823f, -0.12351122f, -0.07398014f, -0.17107803f, -0.11572076f, 0.04010711f, 0.11246692f, 
    -0.08496451f, 0.08970320f, 0.07496260f, 0.04684197f, -0.06210762f, 0.06659491f, 0.10954665f, 0.03655124f, 
    -0.34651080f, -0.09773941f, 0.01388161f, -0.09533565f, 0.04473209f, -0.00670689f, 0.05983353f, 0.04661544f, 
    0.05491365f, 0.08705434f, 0.07306854f, -0.01537813f, -0.30932865f, 0.06296045f, -0.12585182f, -0.07644484f, 
    0.14003414f, 0.01832823f, 0.07078885f, 0.00846429f, 0.13989623f, 0.09714555f, -0.08664347f, 0.04928019f, 
    -0.22501385f, -0.11799394f, -0.04832915f, 0.04397993f, -0.02765223f, -0.04237609f, 0.03457044f, -0.04105881f, 
    -0.01352577f, -0.07695271f, 0.10664769f, 0.12310563f, -0.23401399f, -0.08295915f, -0.20926008f, 0.00444355f, 
    -0.08155736f, -0.01270433f, 0.00205337f, -0.14444968f, -0.00590006f, 0.01850024f, 0.02949309f, -0.07236344f, 
    0.00010724f, 0.21228357f, -0.06692767f, -0.03028384f, -0.02804439f, 0.09453193f, 0.01591502f, 0.07367707f, 
    -0.16822384f, -0.08923333f, 0.01567184f, 0.02929691f, -0.03898119f, -0.11508785f, -0.04027813f, 0.17646413f, 
    0.11261675f, -0.09839238f, -0.01887644f, 0.10952077f, -0.04941405f, 0.08765978f, -0.00002109f, -0.01668429f, 
    0.01352301f, 0.11166255f, -0.07796164f, -0.28473109f, 0.08527939f, -0.03256406f, 0.00554258f, -0.15465483f, 
    0.00467199f, 0.02004177f, -0.01781846f, -0.05005106f, 0.26454237f, 0.06963792f, -0.02365261f, -0.25929090f, 
    0.04156213f, 0.08965868f, 0.07350484f, -0.08277215f, 0.00328600f, -0.01060398f, -0.03880563f, 0.02635811f, 
    -0.14761940f, -0.16431417f, 0.27896723f, 0.05735322f, 0.00170602f, 0.03228562f, 0.02478219f, -0.02358205f, 
    0.00041975f, 0.01795242f, -0.10068132f, -0.02877957f, 0.22713883f, -0.01352792f, 0.00649590f, -0.10834196f, 
    0.01098316f, 0.02492866f, 0.01574887f, -0.06739892f, -0.05612127f, -0.02796240f, 0.04150135f, -0.05138469f, 
    0.04995854f, 0.02725872f, 0.05731226f, -0.03939766f, -0.10774543f, -0.11177720f, -0.00438769f, -0.00232956f, 
    -0.05728623f, 0.02674974f, 0.11142416f, -0.00370461f, -0.18979637f, 0.12145067f, 0.12503618f, -0.14705417f, 
    0.03040625f, 0.00094757f, -0.02271250f, 0.21992941f, 0.05862523f, -0.04094872f, -0.06570362f, -0.01568127f, 
    -0.19247736f, -0.10270437f, -0.21174237f, -0.15676720f, 0.09056731f, 0.11920227f, -0.07986326f, -0.13106875f, 
    0.03046416f, 0.02751562f, -0.02856802f, -0.00230283f, 0.13273111f, 0.14543611f, 0.09480702f, -0.04261760f, 
    -0.02883819f, 0.06235085f, -0.02720380f, 0.05684528f, 0.00564408f, -0.05561580f, 0.14374521f, -0.05934175f, 
    -0.33051711f, 0.23530906f, 0.10544459f, 0.00391838f, 0.17283848f, 0.01613185f, 0.04587869f, -0.00120963f, 
    -0.01649054f, 0.03368299f, -0.03154477f, -0.13377067f, -0.03337092f, 0.11372704f, 0.18816051f, 0.02154766f, 
    0.02823692f, 0.00073306f, 0.02461670f, -0.01693074f, 0.10637248f, 0.05849974f, 0.03480474f, 0.06770274f, 
    0.10988561f, 0.03523875f, 0.03582192f, 0.18805791f, 0.00517650f, 0.05425879f, 0.00227618f, -0.08983624f, 
    0.03860470f, 0.00158736f, -0.03206386f, -0.00208864f, -0.11029515f, 0.24963923f, 0.00665762f, -0.14428954f, 
    0.05991685f, 0.08880284f, 0.03676225f, 0.00103434f, 0.07261056f, 0.02067232f, 0.04821835f, 0.01875647f, 
    0.07475440f, 0.18227157f, 0.05050575f, -0.07441301f, 0.08194216f, -0.01482105f, 0.08062233f, -0.02864605f, 
    -0.03335558f, -0.02352454f, -0.01810314f, 0.03968545f, -0.03160935f, 0.04793317f, 0.39514953f, -0.26005569f, 
    0.08745682f, 0.03930533f, -0.04232716f, -0.04794618f, -0.08116590f, -0.09645393f, 0.05804261f, -0.07173067f, 
    -0.16849674f, -0.11187863f, 0.13280323f, 0.00224742f, -0.12461996f, -0.05481738f, 0.04062935f, -0.10867054f, 
    -0.00632797f, 0.05911268f, -0.01940802f, 0.08322138f, -0.01561802f, -0.15777586f, -0.08602361f, -0.13322495f, 
    0.03209838f, -0.04297403f, -0.04629166f, 0.01889940f, 0.10397200f, -0.05023519f, 0.02132140f, -0.01999364f, 
    0.02070134f, 0.09370165f, 0.07517920f, -0.04094704f, -0.10094940f, -0.01758432f, -0.05697890f, -0.10725698f, 
    -0.01804462f, -0.10779686f, -0.10480712f, 0.07949083f, -0.22708049f, -0.00634677f, 0.00502300f, 0.16138403f, 
    0.07653619f, -0.04569381f, 0.06937701f, -0.09050425f, 0.05448413f, -0.07780115f, -0.02385146f, -0.00238486f, 
    -0.03085774f, -0.04961096f, -0.02515915f, -0.12753738f, -0.06862145f, 0.00126568f, -0.02954150f, -0.04264586f, 
    0.08693783f, 0.00022921f, 0.05355806f, 0.10675010f, 0.21095830f, -0.04150977f, -0.04631668f, -0.10828188f, 
    -0.17386870f, -0.04248406f, 0.00589252f, -0.04151603f, 0.01477672f, 0.01889280f, -0.01464855f, 0.07649477f, 
    0.05838700f, 0.14980337f, -0.03313191f, 0.13021418f, 0.08651403f, 0.01183994f, -0.00215288f, 0.03323963f, 
    -0.07262339f, 0.11466890f, 0.08515211f, 0.04195405f, 0.16233034f, -0.01557995f, 0.09157639f, 0.08207624f, 
    -0.07121047f, -0.05174618f, -0.12685472f, 0.12945661f, 0.02613994f, 0.11908215f, 0.00033156f, -0.04453354f, 
    0.17913382f, 0.08522625f, 0.00860582f, 0.03198658f, -0.07795582f, -0.03491974f, -0.03854976f, -0.01156413f, 
    -0.03227243f, 0.07876229f, 0.02458552f, 0.10442282f, -0.06778286f, 0.06455342f, 0.06687249f, 0.03277776f, 
    -0.01522046f, 0.04769019f, 0.05437502f, 0.00728296f, -0.09543481f, -0.00899466f, -0.01862352f, -0.03678313f, 
    -0.28895649f, -0.10563100f, -0.03129189f, -0.16541308f, 0.08192429f, 0.02532358f, -0.03745991f, 0.04322470f, 
    0.11116732f, 0.00398394f, 0.00138803f, -0.03740516f, 0.04973922f, 0.10264754f, 0.12265747f, -0.05965392f, 
    -0.03648543f, -0.07102502f, -0.01641443f, 0.07305479f, -0.04397398f, -0.00526026f, -0.05097368f, 0.03652537f, 
    0.03341874f, 0.03673710f, -0.05659863f, 0.13281399f, 0.06877660f, 0.01235997f, 0.12319436f, -0.04422401f, 
    0.01045317f, -0.02424407f, 0.02730395f, 0.01844168f, 0.13571465f, 0.12455283f, 0.02927914f, 0.12154859f, 
    0.04948547f, 0.04605945f, 0.01611785f, -0.03128852f, 0.01940839f, 0.01232468f, 0.02433552f, -0.00181323f, 
    0.12036490f, 0.01143715f, 0.01180253f, -0.06238092f, 0.01921839f, 0.00020513f, -0.00780963f, 0.00098004f, 
    0.09666121f, -0.01276823f, -0.03854014f, 0.05161361f, 0.28134236f, 0.17724967f, 0.03996634f, 0.05855816f, 
    -0.07585686f, -0.04924610f, -0.02179225f, -0.01307821f, -0.00091574f, 0.02029259f, 0.05165331f, 0.10326900f, 
    -0.03350407f, 0.06517026f, 0.07565192f, -0.22339217f, -0.02120789f, 0.06900518f, 0.02139594f, -0.08141157f, 
    -0.04387835f, -0.02481199f, -0.02625336f, 0.03514276f, -0.23331918f, 0.01463179f, 0.14723681f, -0.15217717f, 
    -0.04130908f, 0.06624161f, 0.03170978f, 0.03591665f, 0.04780848f, 0.02707045f, -0.07773235f, -0.08951879f, 
    -0.14269407f, -0.00649705f, 0.07157679f, -0.08082812f, 0.10367829f, -0.03058069f, -0.07259123f, 0.01107291f, 
    0.00437021f, 0.05536971f, -0.00743074f, -0.03850193f, 0.09219306f, 0.22114718f, 0.13805109f, -0.06976759f, 
    0.15105605f, -0.03727240f, -0.03908673f, 0.04801772f, -0.12693676f, -0.12316018f, 0.12358244f, 0.01746454f, 
    0.10466661f, 0.01437639f, 0.06010167f, -0.06532615f, 0.03645836f, -0.00831688f, -0.06689475f, -0.09138520f, 
    -0.02342073f, 0.00277459f, 0.11338463f, -0.00581411f, -0.19401774f, 0.06689502f, 0.09828254f, 0.07856941f, 
    -0.05967494f, -0.04782357f, -0.04628526f, 0.03847080f, -0.13535361f, 0.00037098f, 0.08902811f, -0.00583774f, 
    0.15217347f, 0.03533743f, 0.15367335f, 0.08471648f, -0.00203456f, 0.00210383f, -0.02689458f, -0.17417686f, 
    0.03838088f, 0.09070963f, 0.07784402f, -0.04263027f, -0.01235454f, -0.03464485f, 0.00920141f, -0.14409448f, 
    -0.01919037f, 0.02309945f, 0.08691939f, -0.01177872f, -0.01315719f, 0.07015426f, -0.04183144f, -0.08838876f, 
    -0.18105498f, -0.07536238f, -0.07394348f, 0.28772390f, -0.07067546f, -0.00157770f, 0.03683808f, -0.13473895f, 
    0.12365056f, 0.01806405f, 0.05100544f, 0.07183474f, -0.14935096f, -0.04033069f, 0.03616491f, 0.10445892f, 
    0.03441681f, 0.09714463f, 0.10511742f, 0.15526770f, 0.00832720f, 0.03852896f, -0.12128805f, -0.01517475f, 
    -0.08546212f, -0.02493886f, 0.07196523f, -0.14150499f, 0.15991834f, 0.12434023f, -0.12647754f, -0.04301879f, 
    0.18788143f, -0.03726960f, -0.01001406f, -0.03856646f, 0.17826690f, -0.07786249f, 0.12454476f, 0.04553995f, 
    -0.03757785f, 0.08514298f, 0.05324628f, -0.00547612f, 0.06502257f, -0.04499355f, 0.08867307f, 0.11140122f, 
    -0.37148556f, -0.10086998f, -0.06878527f, -0.15123539f, 0.09951628f, -0.02100711f, 0.11100990f, 0.07522526f, 
    0.06375129f, -0.06192238f, 0.01740439f, 0.01167253f, 0.08698796f, 0.05321616f, -0.02063522f, -0.02990617f, 
    -0.03486760f, -0.02764448f, -0.05636305f, -0.07359237f, -0.13971835f, 0.07260370f, -0.02112335f, 0.04309483f, 
    0.28539702f, 0.04059149f, 0.12630540f, -0.10141765f, -0.00055834f, 0.04126114f, 0.00397036f, 0.07912824f, 
    -0.09528068f, -0.01800372f, 0.01818837f, -0.04734302f, 0.01964550f, 0.16791347f, 0.13520455f, -0.04769583f, 
    0.02700393f, 0.00877047f, 0.03244001f, -0.01959055f, 0.01921844f, 0.05263871f, 0.01997087f, 0.06770157f, 
    -0.21198915f, 0.24404864f, -0.08898827f, 0.13593408f, 0.01876642f, -0.04243452f, 0.01598827f, 0.03374452f, 
    -0.06368411f, -0.09393815f, -0.02185614f, 0.09351479f, 0.28540927f, -0.01142597f, -0.00486004f, -0.07079599f, 
    -0.11617196f, 0.01495347f, 0.02597553f, -0.05942256f, 0.07375776f, 0.05003488f, -0.00117864f, 0.08213053f, 
    -0.24807845f, 0.12772173f, 0.03926289f, 0.05651609f, 0.06592558f, -0.03802852f, 0.00874909f, -0.03705176f, 
    0.09590304f, -0.00934635f, -0.06610890f, -0.06243838f, 0.12760624f, 0.06136522f, 0.05330924f, 0.15581919f, 
    0.04902237f, 0.06471118f, 0.00409355f, -0.02437937f, 0.02311300f, 0.01276168f, -0.04856176f, -0.06089352f, 
    0.14057431f, -0.06686490f, -0.25017163f, -0.02578535f, -0.01391619f, 0.00041044f, 0.09433278f, -0.12256217f, 
    0.02748678f, -0.04575136f, 0.05867579f, 0.10292868f, 0.01882001f, -0.27606893f, 0.06870642f, -0.18798488f, 
    -0.03532835f, 0.01700523f, -0.11791733f, -0.09750425f, -0.00016496f, -0.03857635f, -0.09169531f, -0.01174973f, 
    -0.24264503f, -0.12083130f, -0.16377102f, -0.12990241f, 0.00769933f, -0.04055339f, -0.17901246f, -0.04587154f, 
    -0.12366900f, -0.05998929f, -0.00897105f, -0.12706298f, 0.01340508f, 0.06267045f, -0.13432063f, 0.07591995f, 
    -0.08815677f, -0.01677579f, 0.07768294f, -0.04415230f, 0.05864468f, -0.08455931f, 0.12599026f, 0.06827497f, 
    -0.13265127f, -0.20141642f, -0.00452114f, 0.06822357f, 0.08604430f, -0.03121385f, -0.01732126f, -0.04373691f, 
    0.00239530f, 0.03812803f, 0.03551711f, 0.03343577f, -0.02645677f, 0.10820121f, 0.08831072f, 0.09903043f, 
    0.03914052f, -0.05474129f, 0.05653923f, -0.01577130f, -0.06705720f, 0.00647578f, 0.04714627f, 0.00389910f, 
    0.16940244f, 0.01135372f, 0.06307866f, 0.06582305f, 0.12858851f, 0.04667785f, -0.00339725f, -0.04103347f, 
    0.04041567f, 0.06818443f, -0.02561737f, -0.00516357f, -0.14758448f, -0.02996000f, 0.04427240f, 0.14280204f, 
    0.04928386f, 0.00935414f, 0.14244220f, -0.00215908f, 0.05933096f, 0.02886631f, 0.03959628f, -0.01056566f, 
    0.18176171f, 0.06365057f, -0.00982837f, -0.01197253f, -0.03875899f, 0.11621672f, 0.07179551f, -0.06934898f, 
    0.08983792f, 0.10881773f, 0.01412649f, 0.08580507f, 0.10964051f, 0.05833479f, 0.14270258f, -0.06522282f, 
    0.11187875f, -0.12226177f, 0.04702362f, -0.14530265f, -0.00142107f, -0.00852377f, 0.02721194f, 0.09788061f, 
    0.17642887f, 0.04728149f, 0.10467215f, -0.05508344f, 0.10695988f, -0.00985268f, -0.06746281f, -0.02759885f, 
    -0.01904629f, 0.03921607f, 0.03150893f, 0.00345429f, 0.17609319f, 0.07477064f, -0.07119440f, -0.04029782f, 
    0.00382057f, 0.04404106f, 0.02890127f, 0.03951272f, 0.02568511f, 0.02913510f, 0.10108247f, -0.05010787f, 
    -0.19156244f, -0.20478183f, -0.11191762f, -0.05171910f, 0.02906455f, 0.00316069f, -0.06356851f, -0.02186667f, 
    0.07516374f, 0.01909060f, -0.02724181f, -0.09074517f, -0.01663654f, 0.07169080f, 0.00532265f, 0.05295619f, 
    -0.01510457f, 0.06321391f, 0.00672258f, 0.07663810f, 0.12623279f, -0.03306773f, 0.13313384f, -0.00493336f, 
    0.08177339f, -0.06505123f, -0.08342616f, 0.01993669f, -0.09609388f, 0.07005817f, 0.14297718f, -0.00827871f, 
    0.00174143f, 0.03791190f, -0.06302285f, 0.02246258f, 0.14910932f, 0.13260712f, -0.00612933f, -0.05795421f, 
    0.01446231f, -0.05661170f, 0.08766465f, -0.05294371f, -0.00282374f, -0.05123198f, -0.03037149f, -0.09580649f, 
    -0.10884024f, -0.02229735f, -0.15901865f, -0.03402472f, -0.01382307f, -0.10867814f, -0.04324977f, 0.05071326f, 
    -0.05477392f, 0.00122215f, 0.08869625f, 0.10659546f, -0.07097438f, 0.14865580f, -0.02203617f, 0.01299035f, 
    0.04542014f, 0.01406972f, 0.06459071f, 0.06293718f, 0.00592127f, 0.00999840f, -0.01822601f, -0.03743945f, 
    -0.00642910f, 0.00428396f, -0.02540700f, 0.13993941f, -0.04384850f, 0.00687765f, 0.10473247f, 0.03378534f, 
    0.05928139f, -0.02586303f, 0.08706556f, -0.12038694f, 0.13518502f, 0.13557337f, -0.04865949f, 0.00732451f, 
    -0.10562693f, -0.05422941f, -0.00822128f, 0.06572632f, -0.18626642f, -0.04684823f, -0.00090117f, -0.03386569f, 
    0.12367240f, 0.16682124f, -0.00484699f, -0.05331214f, 0.07340436f, 0.16813818f, 0.01614784f, 0.02871629f, 
    -0.00716636f, 0.01711462f, 0.02954582f, -0.02114722f, -0.06948493f, -0.25399470f, -0.01022832f, 0.09553558f, 
    0.02095442f, -0.04411267f, 0.03508842f, 0.01152540f, 0.03066227f, 0.03296119f, 0.00785338f, 0.09858460f, 
    0.22871064f, -0.05216381f, 0.17277218f, 0.09953696f, 0.00086854f, -0.03855601f, 0.01325432f, 0.05593717f, 
    -0.04022959f, -0.00775587f, -0.16290405f, -0.11119929f, -0.13502704f, -0.04928655f, -0.03095763f, -0.05699101f, 
    0.07452875f, -0.09943018f, -0.17080083f, -0.01802140f, -0.04376869f, 0.03922382f, -0.11342361f, 0.08484361f, 
    -0.13295567f, -0.18951750f, 0.02000131f, -0.09526511f, -0.05442282f, -0.01415149f, -0.00667030f, -0.08443861f, 
    0.01419088f, 0.07100035f, -0.02718457f, 0.00060941f, 0.14903569f, -0.06243096f, 0.04799905f, -0.01177555f, 
    -0.10494296f, 0.01055387f, 0.02407079f, 0.01596455f, 0.05616791f, -0.03114756f, -0.06404139f, -0.07374240f, 
    -0.16651016f, -0.09811516f, -0.04192616f, -0.00890734f, -0.03875640f, -0.09704385f, -0.02784793f, -0.00021923f, 
    0.09426729f, -0.03752678f, -0.00741635f, 0.09105223f, -0.20400497f, -0.01218879f, -0.06387874f, 0.20722757f, 
    0.02833951f, -0.04695766f, -0.05696151f, 0.03784903f, 0.12647556f, -0.05543834f, -0.03747753f, -0.01424782f, 
    -0.02599686f, -0.13287024f, -0.18040055f, -0.02927616f, 0.06688525f, -0.03382760f, 0.01535294f, 0.09060992f, 
    0.02263219f, -0.02862514f, 0.01470273f, 0.00990379f, 0.10158823f, -0.01790110f, -0.15081310f, 0.04214946f, 
    -0.03505939f, 0.05868494f, 0.00240884f, -0.04055535f, 0.01896310f, 0.01136211f, -0.07127883f, -0.10639767f, 
    0.15692079f, -0.06201002f, -0.08146606f, -0.08216082f, 0.01436477f, 0.00720766f, -0.00632889f, 0.09705606f, 
    -0.06649396f, 0.02976251f, -0.12485060f, -0.05365622f, 0.17128865f, 0.03423538f, 0.04657875f, 0.03435785f, 
    -0.04415056f, 0.09376179f, -0.00637269f, 0.03729996f, 0.04625311f, -0.08545988f, -0.07324267f, 0.08828989f, 
    -0.16611423f, -0.04519214f, -0.04130951f, 0.06141363f, -0.02685569f, -0.03148985f, 0.02459749f, -0.02269039f, 
    0.06585713f, 0.04903892f, 0.04438787f, 0.10465080f, -0.08140898f, 0.08566007f, -0.09524921f, -0.02670033f, 
    0.00989492f, -0.02903434f, 0.05866557f, -0.02955517f, 0.00340222f, -0.00426192f, 0.06765512f, -0.08081689f, 
    0.09492806f, 0.21549304f, -0.02074540f, 0.08272375f, -0.02119119f, -0.09061076f, -0.03658687f, 0.03197061f, 
    -0.01197101f, 0.06046668f, 0.05378710f, 0.05189640f, -0.21441200f, -0.24256729f, 0.19296160f, -0.00092726f, 
    -0.06140138f, -0.00819448f, -0.06025384f, -0.04326069f, 0.10593267f, -0.01357020f, 0.01785743f, 0.02442638f, 
    -0.26003510f, -0.12521425f, -0.03761395f, -0.04955854f, 0.10023087f, -0.04908122f, -0.04561105f, 0.01206463f, 
    -0.03340408f, 0.05900976f, 0.02607537f, 0.02831588f, -0.11308262f, -0.13683940f, -0.07625861f, 0.00688316f, 
    0.00353690f, -0.01428854f, 0.01538268f, 0.03006480f, -0.00815708f, -0.06463950f, -0.04470909f, -0.01499997f, 
    0.15112349f, 0.05024815f, 0.03825814f, -0.08931365f, -0.10727415f, -0.00513647f, 0.09223653f, 0.06181914f, 
    -0.07798095f, 0.05889740f, -0.01510764f, 0.04084650f, 0.21020067f, 0.02791099f, -0.11658878f, 0.06649175f, 
    0.08838563f, -0.02143214f, 0.01865279f, 0.01373983f, -0.02979877f, -0.01675315f, 0.06348759f, -0.03961870f, 
    -0.25417849f, -0.15484375f, 0.09349398f, -0.07663598f, 0.00712789f, -0.02513367f, 0.00053241f, -0.09097711f, 
    0.05588381f, 0.03174619f, 0.11259060f, 0.00698691f, -0.17108156f, -0.25832319f, -0.06550227f, -0.11038945f, 
    0.07098753f, 0.03093175f, -0.03112430f, 0.04471568f, 0.06675767f, 0.04267275f, 0.02025070f, 0.08928166f, 
    0.06687167f, 0.18536535f, 0.09114928f, -0.00991838f, 0.09692849f, -0.02460844f, 0.03246014f, 0.04575557f, 
    0.09663329f, -0.00225472f, 0.00695912f, 0.12993498f, -0.17373578f, -0.20556718f, -0.08300075f, -0.06853879f, 
    0.03138403f, -0.00530928f, 0.00059821f, -0.05145451f, -0.12636609f, -0.01145601f, 0.07827297f, 0.00614436f, 
    0.14663096f, 0.14563572f, 0.10488016f, 0.07712524f, 0.05195166f, -0.08746383f, 0.04712237f, 0.04104644f, 
    0.05976915f, 0.01095671f, 0.01668086f, 0.02814674f, 0.19413938f, 0.09381633f, 0.00421455f, 0.05835994f, 
    0.06038732f, -0.02220333f, 0.01800237f, 0.02707898f, 0.08700121f, -0.01165183f, -0.01053322f, 0.00984078f, 
    0.11387958f, 0.10688546f, -0.02110574f, 0.02697704f, 0.08863610f, 0.07213123f, 0.00190000f, 0.04237157f, 
    0.05930587f, -0.01218806f, 0.02951200f, -0.04713522f, 0.02566656f, -0.04797453f, -0.05889554f, 0.00822343f, 
    0.05818290f, -0.02494465f, -0.00411481f, -0.02456932f, -0.08780348f, -0.04317474f, -0.09085606f, 0.15857424f, 
    -0.01477079f, -0.02915939f, -0.10001237f, 0.12422856f, 0.08013079f, 0.07621465f, 0.05340598f, -0.00598141f, 
    -0.00000540f, 0.00302742f, 0.03245109f, -0.08389787f, 0.15719269f, 0.19257556f, -0.06002222f, -0.08014676f, 
    0.11130776f, -0.00702196f, -0.03016649f, -0.01092942f, 0.11144803f, 0.08455193f, 0.03253595f, 0.06092804f, 
    -0.34173855f, -0.07667802f, -0.12693080f, 0.00371914f, 0.06104323f, -0.11929065f, -0.17573225f, 0.02463611f, 
    -0.02648674f, -0.00524088f, 0.03311872f, -0.00666656f, 0.10893722f, 0.00027999f, 0.09484231f, 0.01854873f, 
    -0.02774653f, 0.01341015f, 0.10168429f, -0.02790336f, -0.00579391f, 0.04257948f, 0.04851263f, -0.00735256f, 
    -0.16896865f, 0.02253381f, 0.08833902f, 0.09820158f, 0.08130343f, -0.05180081f, 0.05623886f, 0.06845782f, 
    0.00190596f, 0.08894596f, 0.05019996f, 0.03375538f, 0.17937241f, 0.01213089f, 0.07928497f, 0.15062217f, 
    -0.00356881f, -0.02271054f, 0.07666243f, 0.01192005f, 0.07787117f, 0.06974005f, -0.04543355f, -0.02467456f, 
    0.05884259f, 0.16037136f, 0.05073864f, 0.10089678f, -0.07420640f, -0.00378545f, 0.02415614f, 0.03687115f, 
    0.01691059f, -0.00089356f, 0.14049262f, -0.04921934f, -0.03002411f, 0.16581681f, -0.03543977f, -0.13137548f, 
    0.00317438f, -0.19381015f, -0.08781618f, 0.08248655f, -0.00376061f, 0.02730647f, 0.03004474f, 0.05710903f, 
    -0.00337019f, 0.03304552f, 0.06897756f, 0.04945807f, -0.00864854f, 0.04064906f, 0.00052970f, -0.08642686f, 
    -0.00090490f, 0.04077380f, -0.10711066f, 0.04750351f, -0.18501417f, -0.13515475f, -0.12416124f, -0.07109776f, 
    -0.00774586f, 0.04227814f, -0.09024619f, -0.06161111f, 0.03990657f, 0.03015249f, -0.03426834f, -0.00687112f, 
    0.01812876f, -0.01835131f, -0.01916875f, 0.16857855f, -0.00502887f, 0.03850491f, 0.13369526f, 0.01043064f, 
    0.02155372f, 0.01257466f, -0.01841507f, 0.02004699f, -0.20298679f, -0.11294796f, -0.11650514f, -0.04668100f, 
    -0.03791636f, -0.06307015f, -0.08245459f, -0.05300618f, -0.04105275f, 0.03024722f, -0.04834160f, 0.09386485f, 
    -0.12163553f, 0.01947934f, 0.06689073f, 0.07613636f, 0.12006550f, -0.09796738f, 0.00421920f, 0.00558877f, 
    0.06155387f, 0.07429205f, 0.06476153f, 0.13208222f, 0.16612078f, 0.14481437f, -0.07281048f, -0.05816402f, 
    0.00216585f, -0.07495996f, -0.03889280f, 0.06675222f, -0.09313417f, -0.04862710f, 0.04964799f, 0.10644074f, 
    0.16853555f, 0.04734858f, 0.12519242f, 0.08689371f, 0.06278987f, 0.06409948f, -0.05159507f, 0.02570272f, 
    -0.00887447f, 0.00263260f, -0.06171661f, -0.00801626f, -0.23671293f, -0.12854262f, 0.05493583f, -0.17848781f, 
    -0.04162166f, -0.13805264f, -0.04585601f, -0.02845373f, -0.01905658f, 0.04650213f, 0.07491563f, 0.04597264f, 
    -0.06053098f, 0.05783555f, -0.00960323f, -0.01938022f, 0.08764869f, 0.00103090f, -0.05693758f, 0.10306555f, 
    0.10185007f, 0.11964208f, -0.06641608f, 0.04504414f, 0.04789323f, 0.16901352f, -0.04047566f, 0.08635998f, 
    0.04008451f, -0.09145996f, -0.01157388f, 0.03009008f, -0.05594281f, -0.05495779f, 0.07659204f, -0.05355401f, 
    -0.03099045f, -0.02169561f, -0.01842389f, 0.02096495f, -0.03522997f, -0.03017059f, 0.00943543f, 0.00717176f, 
    -0.00793314f, -0.03908041f, 0.01369441f, -0.00085589f, 0.02284797f, -0.04054536f, 0.01978312f, -0.00372248f, 
    0.00171331f, -0.00226088f, -0.03657063f, 0.00993496f, -0.03470377f, -0.01411552f, 0.02825030f, -0.02612328f, 
    0.00502482f, -0.01093080f, -0.02868361f, -0.03225437f, 0.00605813f, -0.00366274f, 0.01735748f, -0.02400083f, 
    0.00830308f, -0.00679987f, -0.01501330f, 0.00504449f, -0.02298408f, -0.00096669f, -0.01700067f, 0.01561754f, 
    -0.01017918f, 0.02011612f, 0.01038636f, 0.00699235f, 0.01498704f, 0.02651273f, 0.01262281f, 0.02535060f, 
    0.00256369f, -0.00369277f, 0.01282260f, -0.01620439f, -0.01478920f, -0.02090472f, -0.02028535f, -0.00259607f, 
    -0.03512308f, 0.02636429f, -0.01825945f, -0.04171167f, -0.01279635f, -0.01916140f, -0.01119035f, 0.00322626f, 
    0.00579448f, -0.00369672f, -0.01925164f, -0.00912710f, 0.01316467f, -0.03312787f, -0.00398659f, -0.01363759f, 
    -0.02296537f, -0.02195266f, -0.00188623f, -0.03383029f, -0.03205248f, 0.01979028f, 0.00854015f, 0.01821261f, 
    -0.00736223f, -0.03964955f, -0.03757159f, -0.02733946f, -0.03762837f, -0.02299998f, -0.02265133f, 0.01144165f, 
    -0.01693780f, -0.03310694f, -0.00892653f, -0.03184373f, -0.02275207f, 0.00528972f, -0.03443435f, -0.00869870f, 
    0.00334056f, -0.00693863f, -0.00747988f, -0.03861271f, -0.02847199f, -0.04111911f, 0.01114890f, 0.00877262f, 
    0.02720335f, -0.00673996f, 0.00304449f, 0.00068680f, 0.02632699f, -0.00146678f, -0.01889314f, 0.00470233f, 
    -0.03092892f, 0.01015825f, -0.00785819f, 0.02658032f, -0.00066180f, -0.03429402f, 0.01580045f, -0.02598779f, 
    0.00223056f, -0.02536939f, -0.00902572f, -0.00921105f, 0.02140433f, -0.03044982f, 0.01891733f, -0.02606473f, 
    -0.00900495f, 0.01007189f, 0.00357798f, -0.02074512f, 0.00422266f, 0.02518290f, -0.03451324f, -0.03353491f, 
    0.01760558f, -0.02978024f, -0.03728222f, -0.03896871f, -0.01543909f, -0.03363226f, 0.00963669f, -0.03923819f, 
    -0.01037064f, -0.02129563f, 0.02868201f, -0.02647905f, 0.00545168f, 0.01497678f, -0.03628133f, -0.01662667f, 
    -0.02747362f, -0.01486747f, -0.00326006f, -0.00107575f, 0.02538991f, -0.02347334f, 0.02221093f, 0.02210153f, 
    -0.02154906f, 0.01832752f, -0.01530410f, -0.01846130f, 0.01765855f, -0.02295723f, 0.00353908f, -0.03218777f, 
    -0.01434891f, -0.00229365f, 0.01153366f, 0.02442686f, -0.03341205f, -0.00469482f, 0.01838261f, 0.01272529f, 
    -0.02589220f, -0.03644401f, 0.01888655f, -0.01997972f, -0.00426010f, -0.03140555f, -0.00316041f, -0.03151995f, 
    -0.01385981f, 0.01939984f, 0.00436107f, -0.00595236f, -0.03972944f, -0.00374993f, -0.00603308f, 0.02878329f, 
    -0.02927902f, -0.03914430f, 0.01382840f, -0.03962534f, -0.02761193f, -0.00059230f, 0.00226123f, 0.01860446f, 
    0.00751707f, -0.00730495f, -0.02081056f, -0.02688899f, -0.00337371f, 0.02619935f, -0.01274051f, -0.02885541f, 
    0.01178925f, 0.01104928f, -0.03055786f, -0.03006466f, 0.01452044f, 0.01008172f, -0.02605289f, 0.02795708f, 
    0.02894636f, -0.01606950f, -0.02129616f, -0.01791627f, -0.01134655f, -0.02106724f, -0.00880352f, 0.00256347f, 
    0.02979200f, 0.02469770f, -0.03927140f, -0.03652696f, -0.00254022f, 0.00016217f, 0.00047572f, -0.01798512f, 
    -0.03406001f, -0.02059356f, 0.00817927f, -0.03344920f, -0.03183077f, -0.01819726f, -0.01819772f, -0.00681457f, 
    0.01245985f, 0.00361533f, -0.00333686f, -0.03410882f, 0.02036616f, -0.00634660f, -0.02205792f, -0.00165312f, 
    0.02061471f, 0.01693948f, 0.02646484f, -0.00123319f, -0.00329653f, -0.02205054f, -0.03653058f, 0.00453074f, 
    -0.00659093f, -0.02626717f, 0.02837292f, -0.00773996f, 0.01314225f, -0.02131567f, -0.04115282f, 0.01600356f, 
    0.01170319f, -0.00580887f, -0.02862143f, 0.01042817f, -0.03874921f, -0.01266886f, -0.04059370f, 0.00027271f, 
    -0.02669500f, 0.00514089f, 0.01610876f, -0.00606362f, 0.02452622f, -0.03032559f, -0.03993927f, -0.02437077f, 
    -0.00633924f, -0.03492909f, 0.01940512f, -0.02061756f, -0.01238973f, 0.02737794f, -0.02441789f, 0.02667677f, 
    -0.02515932f, 0.01018321f, -0.00880052f, 0.00042562f, 0.00265485f, -0.00691785f, 0.02174068f, -0.02685194f, 
    0.02122848f, 0.02465080f, -0.01215934f, -0.03064763f, -0.03515187f, -0.01561713f, 0.02374003f, -0.01911505f, 
    -0.01416338f, -0.01583001f, -0.00801950f, 0.02342935f, 0.00357069f, 0.01694809f, 0.00548209f, 0.01468179f, 
    -0.00987057f, 0.00026019f, 0.01755377f, -0.00011075f, -0.01909923f, -0.03214750f, -0.00925968f, -0.02428108f, 
    -0.02907615f, 0.01033395f, -0.03211031f, -0.02384372f, 0.01814728f, -0.03542758f, 0.01625923f, 0.00282351f, 
    -0.01996589f, -0.02046991f, 0.02897634f, -0.00132405f, 0.00517156f, -0.01417772f, -0.00852193f, -0.03524873f, 
    -0.04002271f, -0.00935317f, -0.01307402f, 0.02939985f, 0.01350889f, -0.00123958f, 0.01586615f, -0.03314540f, 
    -0.01295364f, -0.03961876f, -0.01425489f, 0.01686596f, -0.02017767f, -0.02223905f, 0.02719415f, 0.02339936f, 
    0.02852894f, -0.03069587f, 0.01981814f, -0.03435806f, 0.02538204f, -0.02825802f, 0.00455702f, -0.02131082f, 
    0.01390480f, 0.02157403f, 0.02294108f, 0.01490487f, -0.02425200f, 0.01256804f, -0.00801399f, -0.01102500f, 
    0.01978608f, -0.01186419f, -0.02692706f, -0.03421498f, -0.03673609f, 0.00940068f, -0.02097891f, -0.00402045f, 
    0.00502978f, 0.02409883f, 0.02543777f, 0.01260439f, -0.00300824f, -0.01238789f, 0.01649571f, -0.00093259f, 
    -0.01801381f, 0.02256770f, -0.02382351f, 0.02833200f, -0.00861724f, -0.00167050f, -0.00856354f, -0.03995879f, 
    -0.00194857f, -0.01976050f, -0.00655306f, 0.01444196f, -0.03105699f, -0.01765105f, -0.01835581f, 0.01934585f, 
    -0.02645965f, 0.02151707f, -0.01488297f, -0.01095126f, 0.01754100f, -0.01385440f, -0.03831952f, -0.04122350f, 
    -0.00604692f, 0.00557649f, 0.00631838f, 0.01544478f, 0.00060856f, -0.00199337f, 0.00427668f, -0.01959515f, 
    0.01118645f, -0.01014736f, -0.00930110f, -0.00892020f, -0.03625410f, -0.01665385f, -0.04199211f, -0.03695207f, 
    -0.01552421f, 0.00032012f, -0.01323223f, -0.03404195f, 0.02124153f, -0.03577982f, -0.02921208f, 0.01839555f, 
    -0.03412251f, -0.02486815f, 0.02160282f, 0.02119551f, 0.02891964f, -0.02209089f, -0.01244076f, 0.00728406f, 
    0.00802704f, 0.00587205f, 0.02801394f, 0.02511967f, -0.00631715f, 0.01079846f, -0.03357350f, -0.00159755f, 
    -0.02509556f, 0.02694213f, -0.00957294f, 0.02884965f, -0.03248858f, 0.02283033f, -0.02407407f, -0.01697472f, 
    0.00601147f, -0.02821632f, 0.01953231f, -0.00482558f, 0.00485330f, 0.00108028f, 0.01766476f, -0.02830931f, 
    0.02069942f, 0.00721009f, -0.00114440f, -0.01109120f, 0.00205284f, 0.02439060f, -0.01065051f, -0.03733439f, 
    0.00989487f, 0.01315512f, 0.02148277f, 0.01600220f, -0.03009263f, 0.00239876f, -0.00718262f, 0.02647563f, 
    -0.01293879f, -0.01338745f, -0.00341795f, 0.01072471f, -0.00057514f, -0.01620646f, -0.00057322f, 0.00654188f, 
    -0.00680021f, 0.00949891f, -0.04148296f, 0.01502420f, -0.02670383f, 0.00345856f, 0.02000622f, -0.03185925f, 
    -0.01194580f, -0.03641772f, -0.02861398f, 0.01919009f, -0.00243914f, -0.03757324f, -0.02014456f, -0.03453968f, 
    -0.02052163f, -0.01274849f, 0.00449155f, 0.01302413f, -0.02499616f, 0.00611739f, 0.01888028f, -0.01110513f, 
    -0.00380210f, -0.00728691f, -0.03215064f, 0.02548850f, 0.01602265f, -0.04101933f, -0.02054110f, -0.01585084f, 
    0.02535953f, -0.00559024f, 0.00149272f, -0.00881508f, 0.02260238f, -0.03713764f, 0.02248016f, -0.01630280f, 
    0.00261077f, -0.00442452f, 0.01748187f, 0.00290664f, 0.01063640f, -0.00049721f, 0.00824177f, 0.02594928f, 
    0.01427085f, -0.02096337f, -0.02910095f, 0.01897803f, 0.00112625f, 0.01342195f, -0.03240882f, 0.00770306f, 
    -0.02406673f, -0.00020965f, -0.01991074f, -0.00579385f, 0.00804757f, 0.00059349f, -0.02200019f, 0.01088012f, 
    0.00889316f, 0.00278306f, -0.01439714f, -0.02119128f, -0.01021289f, 0.01089264f, -0.02562270f, -0.01263814f, 
    -0.00559512f, -0.01042033f, 0.02547476f, 0.02698649f, -0.00299937f, -0.02251610f, 0.02529269f, 0.01884007f, 
    -0.02012743f, 0.02944792f, 0.02116605f, -0.01206117f, -0.01587282f, -0.02706775f, 0.01409613f, -0.01257744f, 
    0.01647118f, -0.03545704f, -0.04026497f, 0.02000389f, 0.01307524f, 0.00461691f, 0.00485244f, -0.02162440f, 
    0.02673504f, -0.00597788f, -0.03351442f, -0.00926313f, 0.00286261f, -0.01474405f, -0.00247561f, -0.03141248f, 
    0.00313452f, 0.00641034f, -0.01467599f, 0.00243042f, -0.02110680f, -0.01551718f, 0.02044124f, -0.02247438f, 
    0.02449360f, -0.01895392f, 0.00005614f, -0.02526410f, -0.02593247f, -0.00447299f, -0.01686892f, -0.01659274f, 
    0.00492422f, 0.00829053f, -0.01441379f, -0.02613519f, -0.01129174f, -0.03306978f, 0.00058875f, 0.00619688f, 
    0.02030530f, 0.00601706f, 0.00433276f, -0.03059729f, 0.00247936f, -0.01808403f, 0.02368630f, 0.02741368f, 
    0.02816339f, 0.01351433f, 0.00986065f, 0.01015769f, -0.01341804f, -0.00990005f, -0.02226917f, 0.00997292f, 
    -0.00521803f, -0.00052876f, -0.03980246f, 0.00266848f, -0.00830102f, -0.03289406f, -0.01162427f, -0.02187338f, 
    -0.02283117f, 0.00397331f, -0.00030312f, 0.01428621f, -0.01287971f, -0.01491289f, -0.00551778f, -0.02879038f, 
    -0.00354811f, 0.03007501f, -0.03293193f, -0.01402671f, 0.00989525f, -0.00580343f, 0.00178064f, 0.02815039f, 
    -0.02649618f, -0.02774305f, 0.02051024f, -0.03447814f, 0.01014598f, -0.00642446f, 0.00283513f, -0.01287582f, 
    -0.02497207f, -0.02231991f, -0.02546998f, 0.00021469f, 0.02174242f, 0.00733051f, 0.00904678f, 0.00620112f, 
    -0.00538094f, 0.02517495f, 0.01337603f, 0.02849092f, 0.01043094f, -0.01126838f, -0.03788547f, 0.00432420f, 
    0.00562970f, -0.03814411f, -0.01578891f, -0.02531562f, 0.02867662f, -0.01869291f, -0.00715556f, -0.00034950f, 
    -0.02988694f, -0.03824177f, -0.00056379f, -0.01478627f, 0.01012499f, -0.02994959f, 0.00823609f, 0.02380169f, 
    -0.03463168f, -0.00818858f, 0.00941785f, -0.00141720f, -0.03153824f, 0.00344452f, 0.02096641f, 0.02595445f, 
    0.00205310f, -0.02479235f, -0.04028098f, -0.02585706f, -0.00927772f, 0.00615250f, -0.03546946f, -0.03182995f, 
    -0.02577051f, -0.03996007f, 0.01441200f, 0.02156443f, 0.00750108f, -0.02208600f, -0.03181732f, 0.00689797f, 
    -0.00346763f, -0.03667522f, -0.01403065f, 0.00954138f, -0.00149186f, -0.03807373f, -0.00177932f, -0.00096280f, 
    -0.00257948f, -0.01356604f, 0.02284680f, -0.03780670f, -0.03079238f, -0.00891794f, -0.01885119f, 0.02005493f, 
    -0.02691224f, -0.02925219f, -0.02610200f, 0.00589237f, 0.01666645f, -0.03750286f, -0.03123600f, 0.01049436f, 
    -0.00317590f, 0.02752871f, -0.02400087f, -0.01176553f, -0.01997074f, 0.01683988f, -0.01983577f, -0.03810712f, 
    0.00490393f, -0.00819053f, -0.02322670f, -0.01906157f, 0.02572750f, -0.00906367f, -0.04008551f, 0.01585158f, 
    0.01190635f, 0.00141553f, 0.00495808f, -0.00739917f, -0.02985720f, -0.03493755f, -0.03367504f, -0.03649735f, 
    0.02271711f, -0.02325905f, -0.14480756f, -0.13384455f, 0.08264539f, 0.02254901f, -0.06752366f, -0.12516040f, 
    -0.00021021f, 0.04861367f, -0.01970491f, -0.10165505f, 0.15375109f, 0.16059551f, -0.03903788f, -0.03515130f, 
    -0.01998620f, 0.00466008f, 0.03966117f, 0.10604192f, 0.07239142f, -0.00354065f, 0.11945471f, 0.08437295f, 
    0.03759417f, -0.08902919f, 0.00844404f, 0.02839790f, 0.02746267f, -0.02824805f, 0.03936028f, -0.03542475f, 
    -0.01278224f, 0.07525525f, 0.12265793f, -0.10592096f, -0.06974921f, 0.00927601f, -0.01810181f, -0.14053416f, 
    -0.02451693f, -0.08996344f, 0.04538582f, -0.01538775f, 0.00771227f, -0.08742935f, -0.03951257f, -0.00551113f, 
    0.01219585f, 0.03616558f, 0.05048627f, 0.03352972f, 0.04587077f, 0.03162102f, -0.09712781f, 0.01269373f, 
    0.03708074f, 0.08957723f, 0.03155572f, 0.03789297f, -0.13140893f, 0.24993572f, 0.05709785f, 0.00470602f, 
    -0.06408522f, -0.05552233f, 0.14286934f, -0.02035999f, 0.09695970f, 0.06749925f, 0.04417346f, -0.03438287f, 
    0.08851701f, -0.00372336f, 0.09773485f, 0.00478225f, -0.08092452f, 0.10945117f, -0.05082810f, -0.09096970f, 
    0.05738091f, 0.10961001f, 0.02360748f, -0.01189703f, -0.02902255f, -0.02801650f, 0.11746550f, -0.07171032f, 
    -0.03085501f, -0.12575559f, 0.02219563f, 0.02871246f, 0.01012103f, -0.05055239f, 0.07058063f, -0.04089740f, 
    0.04260196f, -0.05634266f, 0.13326459f, -0.07570625f, 0.02441640f, -0.00595005f, 0.00424946f, -0.01691102f, 
    0.00788898f, 0.09610555f, 0.09121036f, 0.01785977f, 0.06249939f, -0.13766986f, -0.10281297f, -0.10971602f, 
    -0.02575332f, -0.02673020f, 0.01586366f, -0.04598911f, 0.01313971f, 0.00367896f, 0.02900208f, 0.01835822f, 
    0.20590369f, -0.01339474f, -0.19934785f, -0.16958988f, 0.10502643f, 0.21979606f, 0.02563451f, -0.07203305f, 
    0.00549586f, 0.03066134f, -0.00077723f, -0.02195615f, 0.17481700f, -0.10913651f, -0.00966631f, -0.01149218f, 
    -0.08488979f, 0.00951531f, 0.12378147f, 0.08820876f, 0.05280345f, 0.01217363f, 0.06749534f, 0.11673342f, 
    0.24717461f, 0.07427800f, -0.10046469f, 0.03744024f, -0.00206894f, -0.02402284f, 0.11630230f, 0.06215095f, 
    -0.01901032f, -0.00405514f, -0.07068895f, 0.09451467f, 0.24377108f, -0.02696587f, 0.06712290f, -0.10863960f, 
    -0.07643490f, -0.05795636f, 0.06869154f, -0.02469751f, 0.04616167f, 0.02735184f, -0.14684981f, -0.12120629f, 
    0.13152561f, -0.13159195f, 0.03154337f, 0.02666697f, 0.03906498f, -0.05747043f, -0.10494255f, -0.06383536f, 
    0.07739195f, -0.10679329f, 0.04086844f, 0.04734902f, -0.28272894f, 0.09938841f, 0.12231385f, -0.19413176f, 
    0.01123123f, 0.02200683f, -0.04116763f, 0.02314638f, 0.04017675f, -0.00218892f, -0.02790854f, -0.06103218f, 
    -0.01129029f, 0.04252489f, -0.14370243f, 0.08372126f, 0.06125223f, 0.13461603f, 0.06267452f, -0.01738006f, 
    0.11846428f, 0.04258013f, 0.12211471f, -0.06498019f, 0.24533889f, 0.05770164f, 0.00881802f, 0.00311231f, 
    -0.09544955f, -0.03989035f, -0.08886431f, -0.01432712f, -0.00125183f, 0.00487774f, -0.08815463f, -0.00255861f, 
    -0.00727566f, -0.03331766f, -0.08480391f, -0.09316999f, -0.04871143f, 0.05585161f, -0.03743701f, -0.07621034f, 
    -0.01715166f, -0.01791023f, -0.01052417f, 0.01203196f, -0.00528475f, -0.06070111f, -0.01556353f, 0.03059743f, 
    0.05658901f, 0.00188784f, 0.12407710f, 0.08252382f, 0.04248324f, 0.06535140f, 0.03779396f, 0.07246956f, 
    0.28828767f, -0.04023302f, 0.14557326f, 0.22470537f, -0.03099576f, 0.05269118f, -0.07308255f, 0.00260598f, 
    -0.03570423f, 0.01340652f, -0.03033032f, -0.08558071f, 0.11318790f, -0.10918010f, -0.03842342f, 0.00934998f, 
    0.18488391f, 0.01422975f, -0.10116944f, 0.00743099f, 0.00230082f, 0.13175988f, -0.04945728f, 0.03774508f, 
    0.01435669f, -0.15829368f, -0.02569845f, -0.02630701f, 0.03912545f, 0.04843419f, 0.05701420f, -0.03175202f, 
    0.01844038f, 0.06237632f, 0.01121522f, 0.07848534f, 0.20301121f, -0.05373003f, -0.04014035f, 0.06210421f, 
    0.07645166f, -0.05110766f, 0.02504344f, 0.05482094f, 0.04545217f, 0.00930155f, 0.01160630f, 0.00225780f, 
    0.01186145f, -0.01817821f, -0.08252610f, -0.08263522f, 0.03818843f, 0.03674508f, 0.06675162f, 0.02725781f, 
    -0.01790685f, -0.06714111f, -0.02399544f, 0.01685394f, -0.08940400f, 0.22587067f, 0.08710321f, 0.04530640f, 
    0.03579893f, 0.00349313f, 0.08949959f, 0.12199727f, 0.07738844f, -0.07969611f, 0.00003439f, 0.09600323f, 
    0.10458060f, -0.23311171f, -0.04598380f, 0.03240421f, 0.13704722f, 0.00980202f, 0.09965869f, 0.00342732f, 
    0.01703902f, 0.09455268f, -0.01070924f, -0.12098517f, 0.18144855f, 0.05777621f, -0.20449351f, -0.05436113f, 
    0.05394233f, 0.01063191f, -0.02143638f, 0.03117205f, 0.07674234f, -0.00050908f, -0.00654668f, 0.01647016f, 
    -0.09843245f, 0.05151478f, 0.06577653f, -0.11504431f, -0.04702411f, 0.00064862f, -0.03868954f, 0.04609310f, 
    0.05938273f, 0.10336456f, -0.10996611f, 0.03187035f, -0.14676495f, 0.04542438f, -0.05741803f, 0.08660729f, 
    -0.04838446f, -0.05752141f, -0.01779196f, 0.06726031f, 0.09500998f, -0.17880222f, -0.01960526f, 0.07074101f, 
    0.01387492f, -0.04310590f, 0.10436740f, -0.00873844f, 0.06016027f, 0.05299567f, 0.05817801f, -0.04940736f, 
    0.05879778f, 0.08627348f, -0.00009484f, 0.02593430f, 0.18301719f, -0.00338379f, -0.11422466f, -0.10019182f, 
    -0.00905242f, -0.02983958f, 0.04546747f, -0.00942796f, 0.06095252f, 0.06888846f, -0.09008135f, -0.04607743f, 
    0.31693447f, 0.30488345f, -0.18214877f, -0.06694720f, -0.05559889f, -0.00605999f, -0.00093229f, 0.11257511f, 
    -0.02791892f, 0.09649813f, 0.03444427f, -0.01751843f, -0.34244454f, -0.08630639f, -0.10996156f, 0.05364902f, 
    -0.00486830f, -0.01692226f, 0.01098965f, 0.13783062f, 0.05603106f, 0.06302618f, 0.03913490f, 0.05428162f, 
    0.02172427f, -0.08230142f, -0.13543515f, 0.00463440f, 0.06904350f, -0.01278311f, -0.02242266f, 0.00650036f, 
    -0.04427709f, 0.10988926f, 0.03320451f, 0.02765526f, 0.31204295f, 0.03134417f, 0.01318320f, -0.02800068f, 
    -0.01447290f, 0.00928536f, 0.10206886f, -0.01526327f, 0.03520066f, 0.00752504f, -0.07130604f, 0.00590765f, 
    0.21907975f, -0.05001205f, 0.00578336f, -0.00721910f, -0.07252780f, -0.03544914f, 0.06386182f, 0.07374126f, 
    -0.05342353f, -0.01577794f, 0.01448420f, -0.01539547f, 0.04950265f, 0.06121410f, -0.14069591f, -0.15669394f, 
    0.14300142f, -0.08219945f, 0.05133104f, 0.01811883f, -0.06918835f, 0.03331243f, -0.00586712f, -0.14584179f, 
    -0.02499591f, -0.06875999f, 0.03458192f, -0.04179465f, 0.07467121f, 0.05031867f, 0.03467358f, -0.01107627f, 
    -0.02192516f, -0.00255794f, 0.03567861f, 0.03078843f, 0.02772711f, -0.09734732f, -0.07479751f, -0.12628609f, 
    0.08065859f, 0.10533159f, 0.05299301f, 0.02992824f, 0.06580491f, 0.04106920f, 0.02684988f, 0.12574585f, 
    0.05665960f, -0.14062983f, 0.12979463f, 0.00543686f, 0.06653286f, 0.05680882f, 0.02024274f, 0.04821456f, 
    0.16168940f, -0.09948092f, -0.09880842f, 0.09164910f, -0.01941136f, -0.07028980f, -0.15680343f, -0.00001826f, 
    0.07502978f, 0.02589251f, 0.02771544f, -0.00716873f, -0.07114915f, 0.00926351f, 0.08329410f, 0.04542458f, 
    0.18696362f, 0.04071463f, 0.12485547f, 0.05664614f, 0.00090296f, -0.00529370f, -0.02563422f, -0.00145997f, 
    0.01153400f, -0.04323231f, -0.01902737f, 0.05955799f, 0.14311242f, 0.09687005f, 0.07056007f, 0.03143450f, 
    -0.08910056f, 0.06395014f, -0.01449353f, -0.04246603f, 0.14385329f, 0.07274566f, -0.09510585f, 0.06817333f, 
    -0.15225440f, -0.06439888f, 0.15404230f, 0.06989931f, 0.00484679f, 0.01322511f, -0.03360823f, -0.05291998f, 
    0.05731843f, -0.06958517f, 0.00389442f, -0.08076087f, -0.02406418f, 0.06311651f, -0.22218004f, -0.25526235f, 
    0.16382536f, 0.03010711f, 0.02800352f, 0.08645274f, -0.08459141f, -0.09985250f, -0.05264840f, 0.05380807f, 
    -0.19164263f, -0.02038845f, -0.00022127f, -0.18717779f, -0.09308720f, -0.04175909f, -0.06059970f, 0.00577647f, 
    -0.00147586f, -0.10884275f, -0.04275572f, -0.04750097f, 0.09739298f, 0.17697625f, -0.00605956f, -0.20234239f, 
    0.14076911f, 0.00254183f, -0.06232788f, 0.04008607f, 0.03189367f, 0.09245644f, 0.07671186f, -0.07092678f, 
    0.19709738f, -0.14234458f, -0.09250910f, -0.05014082f, 0.04189985f, -0.06775221f, -0.05129889f, -0.03375101f, 
    -0.00182354f, -0.07553957f, 0.11280122f, 0.04846651f, 0.18577665f, 0.06510826f, 0.10004370f, -0.03003902f, 
    -0.07491849f, -0.08388470f, 0.09167317f, -0.00475971f, 0.00404754f, 0.08382671f, 0.08196619f, 0.04100510f, 
    -0.14599659f, -0.07011332f, 0.11445770f, 0.06264300f, 0.02281110f, -0.05454070f, 0.11168804f, 0.09636363f, 
    -0.00880284f, 0.01151372f, 0.11805975f, 0.06946092f, 0.14508675f, -0.03221977f, 0.06684171f, 0.13863529f, 
    0.05817123f, 0.08649384f, 0.05273956f, -0.03594153f, 0.07340679f, 0.07861558f, 0.02887512f, 0.07790852f, 
    0.07041609f, 0.03251149f, 0.13520649f, 0.09756335f, -0.02469808f, 0.13635710f, -0.01561834f, -0.10044348f, 
    0.04071316f, 0.03360088f, 0.03708332f, -0.01615367f, 0.28730085f, 0.04624189f, 0.01822325f, -0.06032679f, 
    0.08233563f, 0.02244157f, -0.12532444f, 0.06722106f, 0.07530289f, 0.00442523f, 0.03849750f, 0.04911214f, 
    -0.21579865f, 0.23952174f, -0.01310403f, 0.07431756f, 0.05607611f, 0.01088134f, 0.03002533f, -0.00960360f, 
    0.02650095f, 0.09607322f, -0.08976150f, 0.01225658f, 0.06124565f, -0.01496802f, -0.14518318f, -0.09335117f, 
    0.02758581f, 0.03052749f, 0.04184100f, -0.02417217f, 0.01287409f, 0.05836115f, -0.05097942f, 0.02989517f, 
    0.03535467f, 0.01656489f, -0.06278640f, 0.04174684f, -0.00075761f, 0.05258597f, 0.12087564f, 0.01716289f, 
    0.03725715f, 0.05770687f, 0.05409709f, -0.04202308f, -0.09444011f, -0.05625148f, -0.15756924f, -0.00889485f, 
    0.13885024f, -0.00228740f, -0.05070354f, -0.01321232f, -0.04306496f, 0.09999231f, -0.03145424f, 0.09253512f, 
    0.10106872f, 0.21182647f, 0.06556824f, -0.00451488f, 0.10377376f, -0.02511755f, 0.02140589f, 0.05002056f, 
    0.09428420f, 0.02283102f, 0.08224745f, 0.06957711f, 0.20521431f, 0.02945467f, -0.03915086f, -0.02520769f, 
    0.01987886f, -0.02620759f, -0.00089769f, -0.03427728f, -0.08513568f, -0.00292449f, 0.02345928f, 0.06121207f, 
    -0.11268120f, -0.03757599f, 0.05815868f, 0.07064310f, -0.02455132f, 0.01686597f, -0.02839080f, -0.04087113f, 
    0.06763212f, -0.03126094f, -0.09770475f, -0.04826928f, -0.19680662f, -0.09431493f, -0.07057710f, -0.05171941f, 
    0.02983253f, -0.01087323f, -0.04216757f, -0.02677977f, -0.07890274f, 0.00632967f, 0.07002929f, 0.12561278f, 
    -0.05446398f, -0.00269188f, 0.14081827f, -0.03797812f, -0.03764811f, 0.01635730f, -0.11064636f, -0.01983320f, 
    0.00023534f, 0.09982398f, -0.01012133f, 0.09788790f, 0.13782474f, -0.17931055f, 0.06484558f, 0.07612664f, 
    0.02237271f, 0.02083680f, -0.04503634f, -0.00325777f, 0.06523707f, -0.04618240f, -0.02795079f, -0.04514536f, 
    -0.00146497f, -0.00563993f, 0.08719924f, 0.15592936f, -0.09898298f, -0.00543610f, 0.04549239f, 0.09535488f, 
    0.15904287f, -0.04996730f, 0.03769523f, 0.09831241f, -0.17739646f, 0.15070233f, 0.02480739f, 0.14444780f, 
    -0.05249812f, 0.03476064f, 0.03499950f, 0.03531949f, 0.04270848f, 0.07831132f, 0.00942914f, -0.08054175f, 
    0.20339172f, 0.11213084f, -0.15004814f, 0.00900037f, 0.08933211f, -0.04583207f, 0.08032912f, 0.11912110f, 
    -0.10224533f, 0.02362035f, -0.06766008f, 0.09662464f, 0.31295350f, 0.04166060f, 0.02619223f, 0.17457762f, 
    0.01991960f, 0.11566669f, -0.04121982f, 0.21731019f, -0.05392765f, 0.01995797f, 0.02489641f, 0.02585835f, 
    0.11151899f, 0.04192824f, -0.07772979f, 0.04599288f, -0.03424063f, -0.07466033f, -0.04507415f, 0.09840477f, 
    0.03329596f, -0.09811155f, 0.01622352f, -0.11620222f, 0.00823141f, -0.19556019f, -0.02316862f, 0.06060847f, 
    0.04160821f, 0.01725559f, 0.03386553f, 0.08182869f, 0.07298997f, -0.04175627f, 0.11462540f, 0.02475813f, 
    -0.31182206f, 0.03390718f, -0.09140301f, 0.09141013f, 0.05344580f, -0.10724536f, 0.07847317f, -0.04586931f, 
    0.08026932f, -0.05261047f, 0.06912983f, 0.13684335f, -0.10489662f, -0.00065353f, -0.11973031f, -0.13848834f, 
    0.14680077f, 0.15162356f, 0.00446909f, 0.05400550f, 0.21385387f, 0.11963295f, -0.02692776f, -0.08445982f, 
    0.05447168f, 0.11264754f, -0.02653867f, 0.10376908f, -0.03122299f, -0.02366350f, 0.06377468f, -0.14416133f, 
    0.07663044f, -0.06084548f, 0.04535842f, -0.04266496f, -0.09339311f, -0.01736756f, -0.03912454f, 0.06207661f, 
    0.00501123f, 0.03394474f, 0.02983903f, 0.00344272f, 0.00435634f, -0.00429681f, -0.10094637f, 0.05400719f, 
    -0.00537895f, -0.19045292f, -0.03484017f, -0.05627011f, -0.09414312f, -0.08845934f, -0.01741498f, 0.10809596f, 
    -0.10334063f, -0.04266163f, 0.06959793f, -0.05574288f, -0.17888127f, 0.04062975f, 0.11571660f, -0.09462873f, 
    0.22726822f, -0.01858578f, -0.09364197f, -0.04604359f, -0.00379560f, 0.04862563f, -0.09003334f, 0.07411544f, 
    -0.10761538f, 0.12193400f, -0.14192164f, -0.09744320f, 0.06959496f, 0.04914994f, -0.06671456f, -0.04019694f, 
    -0.00868340f, 0.04921956f, 0.03428372f, -0.04878211f, -0.08855946f, -0.01981070f, -0.15927581f, -0.21151678f, 
    0.09297774f, 0.11014767f, 0.10021254f, -0.02163207f, -0.01630691f, -0.04261510f, 0.08358285f, 0.02856675f, 
    -0.04480857f, -0.04027457f, 0.15940772f, 0.09634624f, 0.00844925f, 0.10053787f, 0.08883124f, 0.10784970f, 
    -0.06397159f, 0.08788089f, -0.09689133f, 0.00391530f, 0.25674003f, -0.03578782f, 0.08797939f, -0.03221758f, 
    0.02254955f, 0.07074969f, 0.05589481f, 0.00592183f, 0.05239502f, -0.04394640f, 0.06692542f, 0.01549723f, 
    -0.15935448f, -0.07362714f, 0.05690833f, 0.07902645f, 0.01384544f, -0.01235060f, -0.01439761f, 0.02529356f, 
    -0.05519804f, 0.07207841f, -0.03460504f, 0.05337984f, -0.28331211f, 0.10726164f, -0.02820325f, -0.12402602f, 
    0.11082224f, 0.12036248f, -0.02567036f, -0.08354812f, 0.05393334f, 0.01990387f, 0.07718890f, -0.06759012f, 
    -0.02581373f, 0.02810963f, -0.01278810f, -0.05660265f, -0.05052824f, 0.04261244f, 0.02438662f, -0.05779124f, 
    0.02677591f, -0.01989136f, -0.00083249f, 0.07149763f, 0.09035619f, 0.11177777f, 0.05589156f, -0.13267325f, 
    0.02060343f, -0.00934285f, 0.06253483f, -0.04193646f, -0.08207586f, -0.09398242f, 0.04620564f, -0.07457960f, 
    -0.28872648f, 0.20461325f, 0.11481210f, 0.07062008f, 0.01571381f, -0.00861064f, 0.13404347f, -0.01153527f, 
    0.02059607f, -0.07850236f, 0.22247922f, 0.11264042f, -0.07863954f, -0.20048040f, 0.24421120f, 0.01001508f, 
    -0.08851300f, 0.08264945f, 0.13273317f, 0.10136614f, 0.16109644f, 0.02744139f, 0.06457654f, -0.03789024f, 
    0.08440295f, 0.05804671f, -0.03706959f, 0.07452033f, 0.07038384f, -0.03841811f, 0.02782829f, 0.09930231f, 
    0.00363201f, 0.00801322f, -0.00552370f, 0.01368554f, -0.22519921f, 0.16742294f, 0.06108600f, -0.23676246f, 
    0.02399196f, 0.02529418f, 0.09913812f, -0.03840085f, -0.09385281f, 0.09306382f, 0.04509598f, -0.07089770f, 
    0.12200793f, -0.00869568f, -0.01755722f, -0.09376520f, -0.00381925f, 0.00566397f, 0.02234808f, 0.04218553f, 
    -0.02382762f, -0.09314726f, 0.00325289f, -0.03837880f, 0.20836039f, 0.19856685f, 0.02108983f, -0.01750574f, 
    -0.03929668f, 0.13206540f, -0.10592426f, -0.04616999f, -0.06060244f, 0.05079158f, 0.05943823f, -0.07059701f, 
    0.01879695f, -0.00821070f, 0.03514175f, 0.02942857f, -0.11209351f, -0.12823234f, -0.00160626f, 0.03764505f, 
    -0.03586679f, -0.00293633f, -0.14615326f, 0.03805719f, -0.21207875f, 0.08176447f, 0.02885879f, -0.01793763f, 
    0.02440786f, 0.12577750f, -0.05826390f, -0.00870573f, 0.07923405f, -0.04349788f, 0.05865660f, 0.07629649f, 
    0.08012884f, 0.10758507f, 0.18775809f, 0.27924791f, -0.00797817f, 0.03492672f, -0.02943235f, 0.12275662f, 
    0.06969786f, -0.10509219f, 0.06220338f, -0.03918125f, 0.17927942f, 0.05318191f, 0.15847771f, 0.27422652f, 
    0.08603324f, -0.02185544f, 0.02934187f, 0.01613474f, -0.00482910f, 0.16210990f, 0.05758996f, 0.02782476f, 
    0.13298926f, 0.25554192f, -0.01441369f, 0.17816652f, -0.08392278f, 0.03184534f, -0.02116701f, 0.05312937f, 
    0.00291624f, -0.05128288f, -0.04636190f, 0.01618823f, -0.18791458f, -0.18694416f, 0.03013260f, -0.10008363f, 
    0.04728908f, -0.04296445f, -0.00816665f, -0.03774608f, 0.07359447f, -0.06353658f, -0.06145697f, -0.00785042f, 
    0.05129350f, -0.03476935f, 0.07991391f, 0.22859676f, 0.08416951f, 0.04486181f, -0.03366471f, 0.13417843f, 
    -0.04536908f, -0.05555672f, -0.07886716f, 0.02365322f, 0.10478297f, 0.16740255f, -0.02737601f, 0.04350295f, 
    0.05740891f, 0.07135372f, 0.11128712f, 0.02555674f, -0.08171686f, 0.01547076f, 0.06906486f, 0.08140406f, 
    0.00515339f, 0.05603656f, -0.07231849f, -0.10590977f, -0.05568533f, 0.03722645f, -0.02779344f, 0.05366865f, 
    0.09301899f, 0.07322965f, -0.05096005f, 0.09011299f, 0.13440238f, 0.08873475f, -0.02931534f, 0.27832210f, 
    -0.11174634f, -0.03679750f, -0.08614787f, -0.00480897f, -0.07449906f, 0.09640806f, 0.05138524f, -0.02347478f, 
    -0.16366839f, -0.13371058f, -0.16348970f, 0.07123980f, 0.11677469f, 0.04973963f, -0.05047952f, -0.01049850f, 
    0.07868717f, 0.14954276f, -0.04046284f, 0.06502613f, 0.23714106f, 0.20409633f, 0.15937030f, 0.19497240f, 
    -0.07632425f, 0.11455084f, 0.06760020f, 0.08357155f, -0.09216322f, -0.02216325f, 0.01919464f, 0.17628390f, 
    0.15938725f, -0.08576983f, -0.06183135f, 0.06170090f, 0.03547960f, 0.07798469f, 0.06354739f, 0.03437629f, 
    0.09530140f, -0.02956333f, -0.09913881f, -0.04760784f, 0.07713856f, 0.09330687f, -0.10220033f, -0.07242513f, 
    -0.03760917f, -0.00803377f, -0.00103125f, -0.00325966f, -0.00484705f, -0.06925546f, 0.00535654f, -0.09974784f, 
    -0.09445282f, 0.11546114f, 0.07232204f, 0.01841242f, 0.03790085f, 0.05894744f, -0.00859096f, 0.11692075f, 
    -0.00213543f, 0.01478722f, 0.05043469f, -0.09470262f, 0.15102035f, 0.11368101f, 0.17333481f, -0.00810669f, 
    -0.13585998f, -0.05492710f, 0.03052306f, 0.03925851f, 0.00960399f, -0.00325941f, -0.03128355f, 0.06043978f, 
    -0.21963614f, 0.15020739f, -0.01417024f, 0.11784055f, -0.00791536f, 0.02006314f, 0.08241859f, 0.07579205f, 
    -0.07854270f, 0.10696940f, 0.05985027f, 0.02645357f, -0.12671863f, 0.14792444f, 0.01771556f, 0.06174031f, 
    -0.05082569f, 0.06478245f, 0.07075152f, -0.07438254f, 0.01340847f, 0.03745199f, 0.07937479f, 0.01614779f, 
    0.23261580f, 0.09249066f, -0.00171314f, 0.18655638f, -0.03117633f, 0.04410079f, 0.01186434f, 0.08229926f, 
    -0.00652008f, 0.08091752f, -0.00924652f, 0.07362575f, 0.12702586f, -0.08405917f, 0.03577184f, -0.01669516f, 
    -0.03500726f, -0.09222958f, 0.04322921f, 0.04159976f, -0.04212185f, -0.02182974f, 0.04955005f, -0.10404187f, 
    0.23312469f, 0.03054601f, 0.22250694f, 0.02070765f, 0.00049258f, -0.04912343f, -0.02706792f, 0.04136933f, 
    0.06531025f, -0.10569965f, 0.11759914f, 0.11261029f, 0.06237976f, -0.10807271f, 0.24422421f, 0.32263619f, 
    -0.15049449f, -0.04589529f, -0.02277154f, 0.08767087f, -0.00638051f, -0.12301292f, -0.05468199f, 0.14141886f, 
    0.09953608f, 0.04908021f, 0.27476034f, 0.00996778f, -0.04969944f, -0.07157672f, 0.15123954f, 0.03749786f, 
    0.09095337f, -0.01656515f, -0.06358987f, 0.08795117f, -0.12012292f, -0.06806140f, -0.20798974f, -0.14823803f, 
    0.02582110f, 0.06490004f, 0.02889683f, 0.10060468f, 0.00255040f, 0.00793319f, 0.10905365f, -0.08254421f, 
    0.05104775f, -0.06957117f, -0.07179866f, 0.06132236f, 0.12757027f, 0.01617629f, 0.06079959f, -0.06401590f, 
    -0.01294021f, 0.01047029f, 0.01173839f, 0.06182512f, -0.10968196f, 0.02501593f, 0.03640543f, 0.01403911f, 
    0.01687022f, -0.01516696f, 0.02395095f, -0.03830319f, 0.07408243f, 0.04915009f, -0.00450990f, 0.03407329f, 
    -0.10645140f, -0.03062771f, 0.05787089f, -0.19821239f, 0.02351528f, 0.03541777f, 0.10402248f, 0.04636895f, 
    0.08020808f, -0.02032722f, -0.00089237f, 0.02436577f, -0.07255590f, -0.09733285f, 0.09338138f, -0.00096127f, 
    0.00988950f, 0.08416478f, 0.17876033f, -0.03372131f, 0.13392362f, -0.02002434f, -0.03728000f, 0.04991217f, 
    -0.08684543f, -0.10274415f, 0.02275970f, 0.11662291f, 0.02236547f, 0.07958058f, 0.03067059f, 0.02248304f, 
    0.05904237f, 0.04924533f, 0.05087860f, 0.11826590f, -0.18588981f, 0.06178000f, 0.00674122f, -0.03696863f, 
    -0.10616508f, 0.07379192f, 0.02316463f, -0.00358586f, 0.00136248f, 0.01673757f, 0.05870767f, 0.05105340f, 
    0.11170530f, 0.08195125f, 0.06472954f, -0.01073975f, 0.01622978f, 0.02723945f, -0.00295561f, 0.01625361f, 
    0.05371584f, 0.02110887f, 0.12330831f, 0.05776099f, 0.08199270f, 0.01570626f, 0.06643543f, -0.18117537f, 
    -0.08220585f, 0.07406604f, 0.12716359f, 0.02511920f, 0.07724692f, -0.03641280f, 0.08898840f, -0.11216156f, 
    0.30982143f, -0.07001542f, 0.03489143f, 0.11317079f, -0.08985151f, -0.00892143f, 0.01630034f, 0.01974236f, 
    -0.07544768f, -0.01428758f, -0.08888483f, -0.01216011f, -0.26655719f, 0.12392759f, 0.17578234f, 0.00311071f, 
    0.05303571f, -0.00021903f, 0.03618505f, -0.05487775f, 0.10701960f, 0.04500969f, -0.01970387f, -0.07056996f, 
    0.07088727f, 0.30628559f, 0.07350528f, 0.13673237f, -0.04368159f, -0.03752813f, 0.15629946f, 0.05435192f, 
    0.09163116f, 0.10008284f, 0.08853152f, 0.09319098f, 0.18701348f, 0.01849712f, 0.15456581f, -0.02846724f, 
    0.03940074f, 0.07163695f, 0.12243573f, -0.01246107f, 0.06310664f, -0.07601862f, 0.01323269f, -0.01123894f, 
    0.18092091f, 0.00016909f, -0.01323276f, -0.05100575f, 0.01010701f, 0.01363594f, -0.00079134f, -0.09737489f, 
    -0.08484624f, -0.02521080f, 0.04388849f, -0.00255425f, -0.10677467f, -0.07761576f, 0.02526323f, -0.02922395f, 
    0.10691915f, 0.13780349f, -0.02231718f, -0.01466389f, 0.05290254f, -0.01489749f, -0.03693461f, -0.02966596f, 
    -0.01027476f, -0.03703892f, 0.01606400f, 0.01306000f, 0.00131384f, -0.01044961f, 0.00051562f, 0.02353719f, 
    0.01350583f, 0.01822208f, 0.00037229f, -0.01549517f, -0.03043455f, -0.02792190f, -0.02588362f, -0.00934345f, 
    -0.01976600f, -0.02826422f, -0.02779181f, 0.02489659f, -0.03347168f, -0.02218007f, -0.02942211f, -0.01224880f, 
    0.00685320f, 0.00824034f, 0.02732933f, -0.01563761f, -0.00947993f, 0.00063195f, -0.00716603f, -0.00677012f, 
    0.01658740f, 0.00287141f, 0.02262025f, 0.02712099f, 0.02701534f, 0.00910318f, 0.02002484f, -0.04160469f, 
    0.00903957f, 0.02363986f, 0.00698620f, -0.02736257f, 0.00417411f, 0.00017977f, 0.00429800f, 0.00655478f, 
    -0.00518723f, -0.01853559f, 0.02222124f, 0.01257947f, -0.04119135f, 0.01125869f, 0.02917580f, -0.00121437f, 
    -0.03552345f, -0.03486574f, 0.01962413f, -0.00955667f, 0.00478488f, 0.02235406f, -0.00222245f, -0.02541312f, 
    0.02308510f, 0.02729048f, -0.00427321f, 0.02979614f, -0.01722803f, -0.02436046f, -0.00368119f, -0.01335393f, 
    -0.01448660f, -0.04197749f, 0.00987412f, -0.02115923f, -0.00185194f, -0.02447700f, -0.01728370f, 0.01116055f, 
    0.00727437f, 0.01751874f, -0.02068412f, -0.01173036f, 0.02927531f, 0.00788381f, -0.03742643f, -0.01452995f, 
    0.02965111f, -0.03226695f, -0.04092936f, -0.01592691f, -0.04041995f, -0.00305137f, -0.03912012f, -0.04011545f, 
    -0.00318172f, 0.00485625f, 0.00154230f, 0.00100131f, -0.02981162f, 0.02056070f, 0.00576864f, -0.01923895f, 
    -0.01102067f, 0.00704599f, 0.00012052f, -0.02107395f, 0.01274648f, -0.03178671f, 0.01829268f, -0.03047092f, 
    -0.04050213f, 0.00047206f, 0.00969890f, -0.03364832f, 0.00254651f, -0.03184295f, -0.00828072f, 0.01766196f, 
    -0.02477706f, 0.00159033f, 0.01015010f, 0.01062644f, 0.01629478f, -0.02955876f, 0.02369463f, -0.00053609f, 
    -0.02844106f, 0.02076875f, -0.02015449f, -0.00363506f, -0.00594037f, 0.02398853f, 0.02383431f, -0.03811893f, 
    -0.01177733f, 0.02811559f, 0.02079776f, 0.00201904f, -0.01289634f, -0.02459701f, 0.02083668f, 0.00629728f, 
    -0.03823118f, 0.02821517f, 0.00582844f, -0.01445429f, -0.01662944f, -0.03591765f, -0.02263262f, -0.02691291f, 
    0.01259477f, -0.02388178f, -0.03959316f, 0.01964335f, -0.00782335f, -0.02133597f, 0.02255049f, -0.00080092f, 
    -0.02402601f, 0.02853906f, -0.02999595f, 0.02554318f, -0.02403983f, -0.02670725f, 0.02286975f, 0.01708536f, 
    -0.02026630f, -0.01772249f, 0.02315884f, -0.02269374f, 0.02128203f, -0.01653359f, -0.03888848f, 0.02922461f, 
    -0.02620427f, -0.01410691f, -0.00845035f, -0.02663473f, 0.02652047f, -0.00643199f, -0.03633852f, -0.03142960f, 
    -0.00794404f, -0.01041719f, 0.00397268f, 0.02516602f, -0.04057616f, 0.00519717f, -0.01327349f, -0.01603174f, 
    0.00652848f, -0.00929643f, 0.02486083f, 0.01443410f, 0.02827632f, 0.02618770f, 0.00178061f, 0.01318443f, 
    0.00091916f, -0.00283453f, 0.01312766f, 0.02836753f, -0.00983748f, 0.01704945f, -0.00085669f, 0.00008657f, 
    -0.01965983f, -0.00320390f, -0.03245431f, 0.01721962f, 0.00265184f, -0.00826139f, 0.02459163f, -0.03467874f, 
    -0.02959618f, 0.02136339f, 0.02413404f, -0.00731199f, 0.02464160f, -0.00383527f, 0.02880257f, -0.03104607f, 
    0.01855963f, 0.00967408f, -0.00634961f, -0.03102759f, 0.00676751f, 0.01868906f, -0.02915674f, -0.00657689f, 
    -0.03699311f, 0.01033627f, -0.03987334f, 0.02867955f, -0.00004478f, -0.03273217f, 0.01732396f, -0.01484642f, 
    -0.01279222f, -0.01958418f, 0.01238103f, 0.02504013f, 0.00465288f, 0.02977324f, -0.00938768f, -0.00950580f, 
    0.02210486f, 0.01052506f, 0.02934304f, -0.03517108f, 0.01838424f, -0.03626299f, -0.02387045f, 0.02850502f, 
    -0.00273473f, 0.01461570f, 0.01456796f, -0.01798548f, 0.00624005f, 0.01119115f, 0.01017755f, -0.03627602f, 
    0.02281736f, -0.00244628f, 0.01079003f, -0.01143297f, -0.01232957f, -0.02927638f, 0.02394738f, -0.03612474f, 
    -0.02834411f, -0.02470925f, -0.03452568f, 0.02094246f, 0.00384106f, 0.01350101f, -0.00330387f, -0.01265097f, 
    -0.02478099f, 0.02130414f, 0.00565309f, -0.01578625f, 0.00480500f, 0.01511565f, 0.02305849f, -0.02198375f, 
    -0.04128338f, 0.02641930f, -0.01780367f, -0.00835340f, 0.00002242f, 0.02868628f, -0.00207784f, 0.01449190f, 
    -0.02127702f, -0.00685987f, -0.04019221f, 0.00240257f, -0.04082312f, -0.00893216f, 0.00145229f, -0.00833387f, 
    -0.03035458f, -0.03873805f, -0.02221821f, 0.02131318f, -0.03464701f, 0.00084035f, 0.02804542f, -0.01940544f, 
    -0.02835604f, 0.02833456f, -0.02972604f, 0.00929298f, 0.01749604f, -0.03648759f, -0.02639962f, 0.00168608f, 
    -0.03854502f, 0.01707749f, -0.04106665f, 0.02884343f, -0.01627451f, -0.01840886f, 0.00889349f, -0.02550193f, 
    -0.02871536f, -0.01347909f, -0.01968748f, -0.00286040f, 0.01311148f, 0.01748361f, 0.01700661f, 0.01094483f, 
    -0.00173567f, -0.02297789f, -0.00499967f, -0.01336848f, -0.02950999f, -0.04102144f, 0.02069670f, -0.02400478f, 
    -0.03991515f, -0.00951266f, 0.02553847f, -0.00935613f, -0.01677427f, -0.01152087f, 0.01224555f, -0.02160989f, 
    0.01503229f, 0.01272276f, 0.01949733f, -0.02157630f, 0.02238545f, 0.01787307f, -0.03337682f, 0.01908485f, 
    -0.04116487f, 0.00540926f, -0.01225838f, -0.01895237f, -0.03016419f, -0.00413070f, -0.03574327f, -0.03116489f, 
    0.02385951f, 0.01511039f, -0.02741332f, 0.00643813f, -0.02693355f, -0.00386400f, 0.00433838f, 0.00661093f, 
    0.00583792f, -0.02559673f, 0.00327049f, -0.00556839f, -0.02251890f, -0.03497778f, -0.03796890f, 0.02263884f, 
    -0.02452151f, 0.00657042f, 0.00979886f, 0.00488695f, 0.02398041f, -0.02490299f, 0.02179976f, 0.02043729f, 
    -0.02457489f, -0.00291211f, -0.04004084f, 0.02057207f, 0.00842233f, -0.00430149f, 0.02320842f, -0.03106242f, 
    0.00043909f, 0.00197443f, -0.01353648f, 0.02381803f, 0.01738439f, -0.01624230f, -0.03414907f, -0.04051476f, 
    0.01893357f, -0.01617827f, 0.01954654f, 0.01904378f, -0.01327098f, 0.01067150f, -0.02437007f, -0.01188454f, 
    -0.00976803f, 0.02031597f, -0.03881132f, -0.02145661f, -0.00049548f, -0.03722823f, -0.03688839f, -0.00047095f, 
    0.01622357f, 0.02034865f, -0.00734565f, -0.02127343f, -0.00906303f, 0.01685081f, -0.02069426f, -0.03650437f, 
    -0.03366467f, -0.01935534f, 0.01292426f, 0.00049979f, -0.00650402f, 0.00165115f, 0.02840098f, -0.03064272f, 
    -0.00018369f, -0.03117817f, -0.02920651f, 0.00414436f, 0.02942286f, 0.00511811f, -0.01406266f, 0.01673700f, 
    -0.03705099f, -0.00515549f, -0.01951752f, 0.02348719f, -0.01459156f, -0.03270453f, -0.03126280f, 0.02441240f, 
    -0.00954084f, -0.03171487f, -0.03926060f, -0.01413257f, -0.01731639f, -0.00700446f, 0.02829733f, 0.01960005f, 
    -0.02957263f, -0.03883990f, -0.00127376f, 0.01728408f, -0.01638563f, -0.02890721f, -0.03214129f, -0.01580484f, 
    0.02553772f, -0.03012192f, -0.01983426f, 0.01754486f, 0.02189700f, -0.00805396f, -0.01591001f, -0.03222438f, 
    -0.00737648f, 0.01928308f, 0.00098052f, -0.03665761f, -0.00418423f, 0.02379147f, -0.01487538f, 0.00551041f, 
    -0.00489492f, 0.02021119f, -0.01508243f, -0.03909001f, -0.03258028f, -0.02524501f, -0.02832251f, 0.00383703f, 
    0.02571211f, -0.01056332f, 0.01578010f, -0.01392709f, -0.00701032f, 0.01642599f, -0.03792989f, -0.00512013f, 
    -0.00289659f, -0.02790141f, -0.01657000f, -0.00738774f, 0.00419750f, -0.01218336f, -0.01079440f, -0.03574327f, 
    -0.00241089f, -0.03565120f, -0.04107079f, -0.00151938f, 0.01940703f, -0.00242733f, 0.02929903f, 0.01849475f, 
    0.00411939f, 0.02025401f, -0.01527951f, -0.00780903f, -0.01828517f, -0.03796799f, -0.02391800f, -0.03893824f, 
    -0.04154989f, -0.02522962f, 0.00810171f, -0.04073006f, -0.00613662f, 0.00036690f, -0.02864782f, -0.01382091f, 
    -0.04149246f, 0.00294430f, -0.00469194f, -0.01896198f, -0.02571285f, 0.02152619f, -0.03188658f, 0.01493430f, 
    -0.03273637f, 0.02688969f, -0.02303589f, -0.00560072f, -0.03204028f, -0.00359027f, 0.01472492f, -0.01527285f, 
    -0.01753302f, -0.03602046f, -0.01920914f, 0.01212320f, 0.00926400f, -0.04005011f, -0.02491131f, -0.00161347f, 
    -0.02000919f, -0.02605248f, -0.01927389f, -0.03711090f, -0.00179286f, -0.02602324f, -0.01748758f, -0.00140685f, 
    -0.00051416f, -0.03576279f, -0.03830941f, -0.03733951f, -0.03103528f, -0.01439182f, 0.00417954f, -0.00686503f, 
    0.02801545f, 0.01286373f, 0.00748684f, -0.01470198f, -0.03815404f, 0.00584125f, 0.02782490f, 0.02176312f, 
    0.02944063f, 0.01489535f, -0.02733802f, 0.01622873f, 0.01762309f, -0.03569143f, -0.01895995f, -0.00687293f, 
    -0.01552080f, 0.01041911f, 0.01295392f, 0.01038870f, 0.00709893f, -0.02676260f, -0.02070868f, 0.02007049f, 
    0.02719587f, -0.02716056f, -0.03363280f, -0.01430619f, -0.03095456f, -0.04026353f, 0.00836007f, 0.02478988f, 
    -0.03580805f, -0.02433834f, -0.00801550f, 0.02555959f, 0.02733325f, -0.00931500f, -0.02648528f, -0.03390815f, 
    0.02022803f, -0.00814949f, -0.02518519f, 0.00779843f, 0.00948578f, -0.02889891f, -0.00319893f, -0.03915999f, 
    0.02313640f, 0.00940740f, -0.02738888f, -0.01073939f, 0.01666035f, -0.00499775f, -0.03712279f, 0.01462237f, 
    -0.01802667f, 0.02251145f, 0.02455241f, -0.00059176f, -0.01215573f, -0.02614611f, -0.01098926f, -0.01750460f, 
    -0.02610194f, 0.01645262f, 0.02663693f, -0.02926500f, 0.02353741f, 0.02785338f, 0.02052094f, 0.02880207f, 
    -0.01196451f, 0.02468992f, -0.00389710f, -0.03427389f, 0.00461809f, -0.01935393f, -0.03704381f, -0.00476781f, 
    0.01649005f, 0.00252276f, 0.00300612f, -0.01157418f, 0.02006044f, -0.01991098f, 0.00550344f, 0.02713107f, 
    0.01758135f, -0.03665550f, 0.00901339f, -0.01265765f, 0.02925943f, -0.01103041f, 0.02726570f, -0.02848992f, 
    -0.03060184f, -0.03234075f, -0.03130277f, 0.00080737f, 0.02328115f, -0.02513968f, -0.00364261f, -0.01552791f, 
    0.02315453f, 0.00725815f, -0.02419258f, -0.03386035f, 0.02182688f, 0.00403008f, 0.00154806f, 0.01922302f, 
    0.00915262f, 0.00460428f, -0.00906095f, -0.02946006f, -0.01455496f, -0.02302345f, 0.02515289f, 0.01535015f, 
    0.01364405f, -0.01077312f, -0.02867449f, 0.01867889f, 0.00712646f, -0.04128227f, -0.03993124f, 0.01598553f, 
    -0.03029293f, -0.00945705f, -0.03896233f, -0.03475175f, -0.03335672f, -0.03043523f, -0.00755776f, -0.01101901f, 
    -0.02553969f, -0.01931446f, -0.01702650f, 0.00945030f, 0.00217786f, -0.01923384f, -0.00853515f, -0.00315322f, 
    -0.02756305f, -0.04182987f, 0.01850619f, -0.04125530f, -0.02689693f, -0.03536447f, -0.03047508f, -0.00274022f, 
    0.00543397f, -0.02721852f, 0.00671261f, 0.00642751f, 0.00716440f, -0.00607118f, 0.01305375f, -0.00895144f, 
    -0.02114180f, 0.00056610f, -0.03692633f, -0.01339133f, -0.01545550f, -0.01841141f, 0.00690129f, -0.01931386f, 
    -0.01351136f, 0.02009012f, -0.03928183f, -0.00419838f, -0.00644401f, 0.02015621f, 0.00806799f, 0.01524811f, 
    0.02120734f, -0.01770600f, 0.01816249f, -0.00632432f, 0.01528965f, -0.00485151f, -0.02810254f, -0.01927389f, 
    -0.01866729f, -0.02387171f, -0.02055621f, -0.03926012f, -0.00823134f, 0.02612471f, -0.02575818f, -0.02299990f, 
    0.06970821f, -0.01501384f, -0.02352459f, -0.07917961f, -0.06849506f, 0.03545636f, 0.02705000f, -0.05684423f, 
    0.06290748f, -0.04095061f, 0.05972142f, 0.07738508f, -0.17437358f, 0.04702200f, 0.04533730f, -0.04646632f, 
    -0.05721142f, -0.00196238f, -0.03735932f, -0.09274972f, 0.04395930f, 0.00029669f, -0.13055058f, 0.00394741f, 
    -0.10106058f, 0.15156630f, -0.09002682f, -0.11513814f, -0.00650295f, 0.03012433f, -0.04032868f, 0.02298190f, 
    0.04214766f, -0.00352876f, -0.03882370f, 0.01939422f, 0.07198909f, 0.15716265f, 0.05557299f, 0.19150615f, 
    0.11760330f, 0.06106326f, -0.02631887f, 0.02030957f, -0.00735774f, 0.09836242f, 0.03679193f, 0.09146268f, 
    0.06064673f, 0.07894334f, 0.07813454f, 0.06625637f, 0.06509271f, 0.06328066f, 0.03422726f, -0.03007536f, 
    -0.05179436f, 0.02431737f, -0.00853734f, -0.07941867f, 0.22105028f, -0.00571726f, -0.06616276f, 0.11347470f, 
    -0.02636308f, 0.00316782f, 0.03203456f, 0.00419839f, 0.01004926f, -0.00888661f, -0.05189913f, -0.06351812f, 
    0.06812026f, 0.11063848f, 0.11032967f, 0.06875749f, -0.06281314f, -0.04577252f, 0.06815056f, -0.03387894f, 
    -0.05385530f, 0.01502562f, 0.12010964f, 0.00356984f, 0.26836711f, 0.03988175f, 0.09986499f, 0.21819364f, 
    0.10597734f, 0.06328475f, -0.06088594f, 0.00101930f, -0.05670647f, 0.09768492f, -0.01476586f, 0.00057545f, 
    0.11156645f, 0.07314716f, 0.02304699f, 0.13794087f, -0.10490225f, -0.04659620f, 0.01389212f, -0.00124526f, 
    -0.06782365f, -0.02975557f, 0.04020786f, -0.04171133f, 0.12027589f, 0.28588483f, 0.28241062f, 0.24282224f, 
    0.06377213f, 0.07444254f, 0.08840959f, 0.12047935f, 0.00047657f, 0.07521972f, 0.00068165f, 0.01698087f, 
    -0.12956789f, -0.08879431f, 0.01338741f, -0.11586284f, 0.01932458f, -0.03933110f, -0.08278059f, 0.00020628f, 
    -0.02187490f, -0.00132389f, -0.00655671f, -0.03667408f, -0.05389049f, -0.02266311f, -0.14666504f, -0.02584302f, 
    0.01183759f, -0.02720105f, -0.01038292f, -0.08638763f, -0.03789791f, -0.07678169f, 0.00177679f, 0.00520847f, 
    0.14385413f, 0.02451920f, 0.17303288f, -0.03373449f, -0.05603704f, 0.03780248f, 0.04535636f, -0.03102854f, 
    0.01182707f, 0.05477775f, 0.04911030f, 0.07276101f, -0.11128865f, 0.23035772f, 0.13271426f, 0.07401364f, 
    0.14875503f, 0.13569100f, 0.03006904f, -0.00889073f, 0.03488458f, 0.06798038f, 0.12698598f, 0.01804873f, 
    -0.16938391f, 0.20967236f, 0.00722282f, -0.09437859f, 0.00885827f, -0.09730978f, 0.01713282f, -0.02256299f, 
    -0.03748230f, 0.08799903f, -0.06834087f, 0.00232993f, 0.03701282f, 0.16097030f, -0.02519290f, 0.13185948f, 
    0.15081501f, -0.06282826f, 0.10251400f, 0.05947917f, 0.00958710f, 0.03962486f, 0.01501154f, -0.05838850f, 
    -0.04035946f, -0.04659671f, 0.03325029f, -0.06673971f, -0.04761368f, -0.01771635f, -0.17157452f, 0.02400386f, 
    -0.01162440f, -0.05460702f, -0.06162565f, 0.00024177f, -0.02067345f, 0.06482282f, -0.03725636f, -0.00721885f, 
    -0.06262473f, -0.09569189f, 0.03639624f, 0.04000039f, -0.02120110f, -0.00990986f, 0.04056666f, -0.01496117f, 
    0.11573138f, 0.17699243f, 0.15379642f, 0.20227194f, 0.18687126f, 0.07693174f, 0.08470087f, 0.06898239f, 
    0.01859298f, -0.03549286f, 0.04082141f, 0.02475947f, -0.06661341f, 0.11540332f, 0.09686828f, -0.22868457f, 
    -0.15617390f, -0.02494453f, 0.01307259f, -0.03092952f, -0.00608835f, -0.02029451f, -0.04179088f, -0.08170114f, 
    -0.17278813f, -0.04586701f, 0.06246943f, -0.24873656f, -0.08187168f, 0.06066579f, 0.01878596f, -0.02807753f, 
    -0.00336943f, 0.00039835f, 0.05535627f, 0.05416443f, 0.11875142f, 0.05324738f, 0.08492186f, -0.00298696f, 
    -0.09233066f, -0.01787807f, -0.02020253f, -0.02266751f, -0.04273982f, -0.01816122f, -0.01812437f, 0.00369439f, 
    0.20886338f, 0.14964984f, 0.03856512f, 0.01782143f, -0.08979689f, -0.04072759f, -0.00306153f, 0.01101377f, 
    -0.01348166f, -0.01093323f, -0.04308194f, -0.09142948f, 0.17797676f, 0.12976083f, -0.00330408f, -0.11815235f, 
    -0.11244715f, -0.01152440f, -0.10514807f, -0.02293265f, 0.06790336f, 0.00744220f, -0.05552864f, 0.04742967f, 
    -0.02639642f, -0.02093260f, 0.01040596f, -0.06289469f, -0.10128155f, -0.04464845f, -0.01181556f, -0.06270889f, 
    -0.08864924f, 0.05597805f, -0.01188438f, -0.01189923f, 0.19866945f, -0.06465205f, -0.14210515f, 0.00993516f, 
    0.01214891f, -0.04080030f, -0.04126752f, -0.07202128f, -0.13096087f, 0.03589064f, -0.04786624f, -0.04997650f, 
    -0.23894231f, 0.22371626f, -0.10122515f, 0.01073311f, -0.03639354f, -0.03062420f, 0.03413085f, -0.09031006f, 
    -0.21383753f, 0.05880518f, 0.04293395f, -0.03436723f, 0.08396275f, 0.06000243f, 0.07272665f, 0.01410555f, 
    -0.03912524f, -0.03387586f, -0.02703042f, -0.00680288f, 0.01173500f, 0.03604710f, -0.06801527f, 0.00008366f, 
    0.06012968f, 0.16345409f, -0.03254814f, 0.18586560f, 0.07742946f, -0.03444539f, 0.00145175f, 0.09520639f, 
    -0.00500924f, -0.02156608f, 0.02118186f, -0.11392497f, 0.27159202f, -0.04043375f, -0.02116942f, 0.04489145f, 
    -0.09044886f, 0.05205183f, -0.01766374f, 0.02876006f, -0.10970726f, -0.05043593f, 0.07029939f, 0.00615208f, 
    -0.07263482f, 0.19819382f, -0.06725094f, 0.01273002f, -0.02121685f, -0.02639101f, 0.08438830f, 0.00490171f, 
    -0.00783994f, 0.01401976f, 0.00163098f, -0.02562177f, 0.15300962f, 0.14256272f, -0.03779325f, -0.02240065f, 
    0.07565966f, -0.02225613f, -0.02308832f, -0.06616566f, 0.07045402f, -0.05865491f, 0.05920956f, 0.00340349f, 
    0.04916110f, -0.15607002f, 0.07143173f, 0.01471048f, -0.06846698f, -0.03580512f, -0.02064063f, -0.01898060f, 
    -0.05878552f, 0.01763967f, -0.17441347f, 0.02024155f, 0.16862659f, 0.12873884f, 0.05165788f, -0.03785951f, 
    -0.05664498f, -0.01610765f, 0.07745203f, -0.08454370f, -0.05464764f, -0.02415391f, -0.11503422f, 0.02081017f, 
    -0.12340368f, -0.10937171f, 0.10034617f, -0.01141454f, 0.03974309f, 0.05970851f, 0.01789540f, -0.08068234f, 
    -0.01958588f, -0.02170733f, -0.03368768f, 0.00461302f, -0.14450389f, -0.04758284f, -0.12852727f, -0.00803650f, 
    -0.05530124f, 0.05940631f, -0.06106314f, -0.03588799f, -0.00053303f, -0.07734306f, -0.01661439f, -0.00817654f, 
    0.01136785f, 0.06799051f, 0.16745783f, 0.03252565f, 0.10152514f, 0.04009525f, -0.01355793f, 0.01270766f, 
    -0.00417308f, 0.06653250f, -0.06382027f, -0.00072080f, -0.19214495f, 0.07074439f, -0.02585817f, 0.04570219f, 
    -0.09578484f, -0.05306348f, 0.00438975f, -0.02846829f, -0.05647791f, 0.00549989f, -0.01469269f, -0.03463864f, 
    0.06809917f, -0.02753308f, -0.03331457f, -0.05833410f, -0.01506137f, 0.01764932f, -0.03968523f, -0.00710778f, 
    -0.01237498f, 0.12023427f, 0.01814909f, -0.01137256f, 0.02962704f, 0.07259940f, -0.00195526f, -0.07810214f, 
    -0.05961954f, -0.06452889f, 0.01153282f, -0.05428803f, -0.06436691f, -0.02841211f, 0.01291046f, 0.01302431f, 
    0.02108879f, 0.22016633f, 0.09703387f, 0.04352335f, 0.03172312f, -0.02862403f, -0.01668232f, -0.02589637f, 
    -0.10372724f, 0.01195343f, 0.08633328f, -0.09165704f, 0.02735526f, -0.08875196f, 0.00918431f, 0.00357224f, 
    -0.04992210f, 0.04952539f, -0.04950352f, 0.01443666f, -0.02566206f, 0.03208735f, -0.05431677f, -0.05705454f, 
    -0.10710395f, -0.08197454f, 0.11459034f, 0.00022092f, 0.10611969f, -0.03658180f, 0.04927080f, 0.01511350f, 
    0.01232197f, 0.02962722f, 0.05102410f, -0.02145816f, -0.14960629f, -0.05867336f, -0.01890266f, 0.07067523f, 
    0.12187752f, 0.04011213f, -0.00195439f, -0.05011953f, -0.01126331f, -0.03775429f, 0.01688810f, -0.04296914f, 
    0.07015613f, 0.22370170f, 0.03270761f, 0.01852298f, 0.08503743f, 0.00413387f, 0.02613753f, 0.11897644f, 
    -0.11733512f, 0.02113714f, 0.02451459f, 0.06967091f, 0.11471008f, -0.06882503f, 0.07553953f, 0.08348738f, 
    -0.03259889f, -0.01751874f, -0.06116970f, -0.02075351f, -0.01814551f, 0.06037869f, 0.02537923f, -0.12052228f, 
    0.05853539f, 0.12288473f, -0.01146353f, 0.16001204f, 0.15279445f, -0.03082767f, 0.06209109f, 0.08482201f, 
    0.04706173f, 0.04035583f, -0.01998211f, -0.01492528f, -0.07580122f, 0.08851154f, 0.06816301f, 0.10927172f, 
    -0.03502620f, -0.10997368f, 0.01195500f, -0.04468638f, -0.01603728f, -0.00472432f, -0.06738295f, -0.05358364f, 
    -0.25474802f, 0.05745785f, 0.03416405f, 0.00596745f, 0.06912063f, 0.00646700f, -0.06844024f, 0.01192060f, 
    -0.08012439f, 0.05330419f, -0.07189023f, 0.00469934f, -0.14249027f, 0.07741310f, 0.09378695f, 0.18839532f, 
    0.11010786f, 0.10984496f, 0.02390522f, -0.00868565f, 0.00363513f, -0.05467416f, 0.00677110f, 0.04364672f, 
    0.03430983f, 0.13341475f, -0.01718553f, 0.04775623f, -0.00141683f, 0.01727445f, -0.01216146f, -0.02970852f, 
    0.01596694f, -0.04665170f, -0.02226345f, -0.02307074f, 0.08564874f, 0.07229140f, 0.04961618f, 0.04841555f, 
    -0.11115879f, -0.06689473f, -0.03616680f, -0.04583929f, -0.06949098f, -0.09449291f, 0.03593486f, 0.00142881f, 
    -0.09495751f, 0.00203588f, -0.02503095f, 0.00076998f, 0.01753412f, -0.06121134f, -0.01087113f, 0.11067060f, 
    -0.05954726f, -0.02149939f, 0.15020643f, -0.05893693f, -0.17504708f, -0.33533388f, -0.14067642f, -0.10850641f, 
    -0.03124835f, -0.00081364f, -0.02628541f, -0.16102515f, 0.01469843f, -0.01486546f, -0.12665066f, -0.07716490f, 
    0.34329876f, 0.13399245f, 0.04483195f, -0.03587457f, -0.03466830f, -0.07065275f, -0.01352059f, -0.11212713f, 
    0.02815276f, 0.08356270f, 0.01187927f, 0.02895872f, 0.24545930f, 0.09869020f, 0.10470395f, -0.10385942f, 
    0.00203262f, -0.04654261f, -0.12508519f, -0.05512739f, -0.00972897f, -0.01144338f, -0.00966860f, -0.02753105f, 
    -0.04618990f, -0.19982089f, -0.05276412f, 0.01978422f, -0.07948234f, -0.07171959f, -0.05100252f, -0.08401684f, 
    -0.09271750f, -0.10400348f, -0.02215822f, 0.04235326f, 0.05613984f, -0.05625423f, 0.06736469f, 0.00514122f, 
    -0.06487843f, -0.06796030f, 0.00649130f, -0.05821482f, 0.03663034f, -0.05349146f, 0.01846395f, -0.00268602f, 
    -0.13028409f, 0.02753502f, -0.06277708f, -0.01175213f, -0.06044180f, 0.00775455f, 0.00452120f, -0.05225079f, 
    -0.02036417f, -0.02055259f, -0.00713854f, -0.08619152f, -0.18528439f, -0.27329174f, -0.06406194f, 0.01626527f, 
    -0.04451334f, 0.03195338f, -0.08350134f, -0.06798961f, 0.06828956f, -0.05576897f, 0.09968171f, -0.09390374f, 
    0.08441618f, 0.06012368f, 0.04791225f, 0.05545587f, 0.08139873f, 0.04714312f, -0.08186291f, 0.05679600f, 
    -0.00688541f, -0.00486857f, 0.02511113f, 0.02900224f, 0.14979409f, -0.01187225f, -0.06959037f, -0.01719177f, 
    -0.04805472f, 0.01061003f, -0.00447322f, -0.09365965f, 0.02545003f, 0.04693705f, 0.02390477f, -0.07484341f, 
    0.04626760f, 0.22218777f, 0.03575264f, 0.08632410f, 0.13948087f, -0.06383098f, 0.10676458f, -0.09949365f, 
    0.09595736f, 0.00649007f, 0.09911218f, -0.05668903f, -0.05897767f, 0.12851201f, 0.10033339f, 0.00234447f, 
    0.07722226f, 0.02139447f, 0.05540729f, -0.02012167f, 0.03058319f, 0.10698467f, 0.05064620f, 0.00166655f, 
    -0.05342517f, 0.02794032f, 0.04623900f, 0.12404352f, -0.02934387f, 0.07118154f, 0.07693972f, 0.09205404f, 
    0.08158994f, 0.01841318f, 0.00413923f, 0.15336944f, -0.09650590f, 0.01980070f, 0.15954183f, -0.01278589f, 
    0.09764757f, 0.05508396f, 0.04341113f, -0.01088361f, 0.10241713f, 0.03275800f, -0.00693877f, -0.02614925f, 
    0.07097048f, 0.22845721f, -0.10379405f, -0.07587663f, 0.11528617f, 0.05695730f, -0.02498577f, 0.11282543f, 
    -0.02454614f, -0.00807526f, -0.06622888f, 0.08539475f, 0.11864429f, 0.03882710f, 0.05676579f, 0.22680314f, 
    0.13738300f, 0.11253330f, -0.05806831f, 0.07910374f, -0.00961417f, 0.10193489f, 0.02916911f, 0.00887988f, 
    0.03608590f, -0.02184192f, -0.01423387f, 0.09340288f, 0.04320362f, 0.00847653f, 0.04796103f, 0.05747660f, 
    0.00506657f, -0.04907325f, 0.05413419f, -0.05962889f, 0.08598769f, -0.14088650f, -0.03413036f, 0.03103233f, 
    0.11353080f, 0.04193443f, -0.00583003f, 0.07899043f, 0.04842662f, -0.01252651f, -0.00247007f, 0.02116222f, 
    -0.12774445f, -0.01721225f, -0.02718407f, 0.08947396f, -0.01088197f, -0.13543484f, 0.06296317f, 0.05812234f, 
    0.04510692f, -0.04546410f, 0.02649067f, 0.10844848f, 0.10842633f, 0.09176950f, -0.10361691f, 0.12000471f, 
    0.21380186f, 0.17918465f, -0.03081184f, 0.00983623f, 0.10776553f, 0.08068009f, 0.00679521f, 0.04851302f, 
    0.02175290f, 0.06847633f, -0.10297003f, 0.20331524f, -0.07579460f, 0.00766254f, 0.01841369f, 0.02082991f, 
    0.11160636f, 0.02562795f, -0.00314603f, 0.03857084f, -0.02315231f, 0.10454094f, 0.07893584f, 0.14039309f, 
    0.09581436f, 0.02456737f, 0.06687075f, 0.09935463f, 0.03149201f, 0.03809819f, -0.01947117f, 0.00683929f, 
    0.01170522f, -0.05698224f, 0.12528951f, -0.04339921f, -0.02395607f, -0.00964425f, -0.01834490f, 0.12874785f, 
    -0.03946399f, -0.01896210f, 0.07987589f, -0.03167115f, -0.05324947f, 0.07020863f, -0.02486284f, 0.00194428f, 
    0.15884852f, -0.00191195f, -0.06768715f, -0.08850075f, -0.01222079f, 0.07567000f, -0.10833614f, 0.03964758f, 
    -0.05930746f, 0.04114405f, 0.06517287f, -0.02172345f, 0.07450631f, 0.07354695f, -0.06764874f, 0.07189861f, 
    0.01463877f, 0.06306931f, 0.11626265f, 0.00356822f, -0.06135039f, 0.18007275f, -0.10010513f, 0.02264414f, 
    0.15370718f, 0.09738302f, 0.04863705f, 0.09447099f, 0.05569743f, -0.00077372f, 0.10282487f, 0.01457706f, 
    -0.14629817f, 0.17298236f, 0.09600497f, -0.09813198f, 0.05341772f, 0.06805309f, 0.03257994f, 0.10289463f, 
    -0.09455791f, 0.08531778f, 0.00383437f, 0.00867662f, 0.21132843f, -0.02098905f, 0.05256456f, 0.09861744f, 
    0.04369479f, 0.02811098f, 0.08102385f, 0.07310701f, 0.07350877f, 0.01479007f, 0.13151838f, 0.05394373f, 
    -0.10539627f, 0.02827614f, 0.09347764f, -0.06132487f, 0.04060954f, -0.01693727f, -0.05756221f, 0.10854167f, 
    -0.01148278f, 0.03308197f, 0.03364994f, 0.05358296f, -0.13344379f, 0.10789335f, -0.02232190f, -0.06535193f, 
    0.09733620f, 0.03426814f, 0.07913410f, 0.03345459f, 0.05370242f, 0.03038880f, 0.08614679f, -0.04349645f, 
    0.00782755f, -0.00722032f, 0.07200251f, 0.18777680f, 0.09639494f, -0.00018818f, 0.10129686f, 0.13999085f, 
    -0.00046770f, 0.01061007f, -0.01970339f, -0.00870211f, -0.04872623f, 0.23520647f, 0.09195868f, -0.16640086f, 
    0.00483419f, 0.10796861f, 0.02526730f, -0.02411872f, 0.04609265f, -0.05575443f, 0.01885793f, -0.03193826f, 
    -0.22943255f, 0.14294341f, -0.09280517f, -0.07056946f, -0.00484134f, -0.04107672f, 0.13923968f, 0.09598396f, 
    0.02179933f, -0.01410830f, 0.07927835f, 0.12096547f, 0.04624779f, -0.05033514f, 0.16958062f, -0.08976927f, 
    -0.06911264f, 0.08661099f, 0.12694882f, 0.01071696f, 0.06645401f, 0.03524749f, 0.05757232f, 0.04461198f, 
    0.13544191f, 0.28121534f, -0.03092670f, 0.02236148f, 0.04741030f, -0.00724358f, 0.05614318f, 0.06749392f, 
    0.06756660f, 0.04267741f, 0.04187278f, 0.06735663f, -0.06708945f, 0.19818215f, 0.01893129f, -0.10064740f, 
    0.02106883f, 0.05713262f, 0.00076310f, -0.02613956f, -0.02529493f, 0.02866737f, 0.03053916f, -0.03316467f, 
    0.03553244f, 0.00132799f, 0.09483843f, -0.01186909f, 0.05095397f, 0.07959755f, -0.02689921f, 0.05361897f, 
    0.02511065f, 0.00747922f, 0.04906549f, 0.03437993f, 0.18879013f, -0.11798365f, 0.00543569f, -0.00604569f, 
    -0.00967322f, 0.04076308f, -0.04006732f, -0.04885451f, -0.01968382f, 0.05338838f, 0.09983651f, -0.02988743f, 
    -0.16194734f, 0.28186616f, 0.04988346f, -0.09915259f, -0.06160850f, -0.00396104f, 0.00268727f, 0.03868171f, 
    -0.02112972f, 0.00873657f, 0.03177112f, 0.09447800f, -0.10866915f, -0.00554994f, 0.09811421f, 0.08926864f, 
    0.04687423f, 0.06751457f, 0.01224009f, 0.00149995f, 0.04765452f, 0.01055947f, 0.00820978f, 0.04897597f, 
    0.07217537f, 0.01763993f, 0.21414131f, 0.21874225f, 0.06758964f, -0.05579153f, -0.01250500f, 0.11647994f, 
    0.02281971f, -0.00040543f, 0.14015371f, -0.04152513f, 0.21236707f, -0.06513178f, 0.03453705f, 0.13668181f, 
    0.03453709f, 0.05123572f, 0.02120583f, -0.00155203f, -0.04181002f, 0.09841983f, 0.09024555f, -0.03371368f, 
    0.00760390f, 0.21221069f, 0.12513493f, 0.05476532f, 0.07140253f, 0.00647208f, 0.06611449f, 0.08831512f, 
    0.00653877f, -0.05336526f, 0.03684232f, -0.00983639f, -0.01697932f, -0.03408625f, 0.10103598f, -0.06420365f, 
    0.13234548f, 0.06882019f, -0.01313190f, -0.04207446f, 0.00869134f, -0.04657985f, 0.05410664f, 0.01094724f, 
    -0.15330389f, -0.07963579f, 0.18709582f, 0.15920019f, 0.01906135f, 0.08380365f, -0.04942044f, -0.03103729f, 
    -0.03052461f, -0.03085192f, 0.01306481f, 0.14830966f, 0.23892154f, 0.23945691f, -0.02723303f, 0.06424210f, 
    0.08263077f, 0.02415683f, 0.10873232f, -0.03449425f, -0.00225787f, 0.00646807f, -0.03601757f, 0.03788580f, 
    -0.12498988f, 0.05365036f, 0.05053050f, -0.03502214f, -0.00381581f, 0.09077054f, 0.02638826f, 0.03950797f, 
    0.00465266f, -0.00613887f, -0.03090941f, 0.02515383f, -0.15414129f, -0.00212128f, 0.11487875f, 0.02847094f, 
    0.02558284f, 0.05540049f, -0.04378469f, -0.00401062f, -0.03229320f, -0.00768818f, 0.02610791f, 0.00960956f, 
    -0.02950133f, 0.01655840f, -0.05781395f, 0.15626088f, 0.18966649f, 0.12201980f, -0.05941227f, 0.04619570f, 
    0.10429078f, 0.13933070f, -0.01766333f, -0.00838751f, -0.12686828f, 0.02288854f, 0.18533292f, 0.17461774f, 
    -0.08663320f, 0.13855428f, 0.05147146f, 0.04791664f, -0.01447450f, -0.00829848f, 0.02256457f, 0.26092556f, 
    0.09822583f, 0.05975343f, -0.05426380f, 0.04751828f, 0.00639106f, 0.10291254f, 0.00738854f, 0.03091994f, 
    0.06734029f, 0.05538940f, -0.01715266f, 0.04026893f, 0.09653117f, 0.12243610f, 0.00714651f, -0.01612254f, 
    -0.02445599f, 0.01221497f, 0.03439819f, -0.02359171f, -0.02716141f, -0.03486479f, -0.00012540f, -0.04007578f, 
    -0.06581912f, 0.11970352f, 0.02757465f, 0.12797166f, 0.00535898f, 0.05087818f, 0.01360238f, 0.07780623f, 
    -0.05108380f, 0.09937152f, 0.07732314f, -0.09927328f, 0.04210187f, 0.08061036f, 0.15502423f, -0.00150951f, 
    -0.08715490f, 0.02426074f, 0.01843890f, 0.04660533f, 0.08942918f, -0.03089261f, -0.01223767f, 0.03859748f, 
    -0.09395859f, -0.08921301f, -0.06039821f, 0.07860326f, 0.10986900f, -0.00025039f, 0.02034888f, 0.03808028f, 
    0.00081981f, 0.13846886f, 0.04170013f, 0.01989566f, -0.10817553f, -0.02764666f, -0.07675103f, 0.06712990f, 
    0.05017476f, 0.01876406f, 0.04343734f, 0.04167248f, 0.00158192f, -0.00687706f, 0.08384547f, -0.00369086f, 
    0.06295152f, 0.12139643f, -0.00540211f, 0.14016415f, 0.05769457f, 0.12026491f, 0.05234304f, 0.09250246f, 
    0.00566773f, 0.08483133f, -0.00196457f, 0.06289541f, 0.12340167f, -0.09719659f, 0.14166826f, 0.11043943f, 
    -0.10495815f, 0.03867021f, 0.03765387f, -0.00195673f, -0.01475888f, 0.05116943f, 0.09796270f, 0.02792904f, 
    0.11838656f, 0.06126824f, 0.18269011f, 0.07837099f, 0.13812277f, 0.04761101f, 0.06154551f, 0.03158227f, 
    0.02225026f, 0.11460058f, 0.06623283f, 0.14133932f, -0.03510265f, -0.14307089f, 0.21563105f, 0.22732794f, 
    -0.12475865f, 0.01652372f, 0.00723683f, -0.00269888f, -0.02702359f, -0.06231666f, -0.04162609f, 0.08882283f, 
    0.01164775f, 0.02256783f, 0.13150340f, -0.01453757f, 0.03334285f, 0.08070654f, 0.09876385f, 0.07389532f, 
    0.02568469f, 0.10975952f, -0.09895623f, 0.07704011f, -0.14865601f, 0.00201684f, -0.15097833f, 0.04963813f, 
    0.13751563f, 0.11422333f, -0.01327553f, 0.08106208f, 0.09320823f, -0.03151302f, 0.05633171f, -0.00583665f, 
    0.18259905f, 0.11068255f, -0.04892020f, 0.02266472f, 0.10318759f, 0.02004154f, -0.01586673f, -0.06299385f, 
    0.02660567f, 0.07999856f, -0.01811515f, -0.00690465f, -0.11689964f, -0.01756963f, -0.01891957f, 0.09743697f, 
    -0.00064440f, -0.05008111f, 0.06271382f, -0.00589187f, 0.01754201f, -0.00644233f, -0.04232737f, 0.07524522f, 
    -0.00388658f, -0.01701664f, -0.05627521f, -0.10352340f, 0.07621218f, -0.06421786f, 0.09891174f, 0.15016656f, 
    0.04739141f, -0.03356687f, 0.10457873f, 0.06805687f, -0.14462277f, -0.04986211f, 0.00827036f, -0.07186946f, 
    0.02625487f, 0.00293884f, 0.12955981f, -0.06151209f, -0.02053099f, 0.03178665f, 0.02655200f, 0.05440809f, 
    0.24239565f, -0.18390203f, 0.07003184f, 0.08341969f, 0.01244126f, 0.06507063f, 0.12195887f, 0.06901722f, 
    -0.00388002f, -0.00730387f, 0.08268800f, 0.02174649f, 0.04852877f, 0.14425212f, 0.14792319f, 0.03521035f, 
    -0.03120332f, 0.11630853f, -0.02010674f, -0.02796876f, 0.06092743f, 0.02206767f, 0.06222527f, 0.03801014f, 
    -0.00318228f, 0.02077373f, 0.06404756f, -0.00281314f, -0.00668993f, 0.00196416f, -0.04075990f, 0.05589626f, 
    0.00081816f, 0.01883687f, 0.05191348f, 0.07997466f, 0.09460229f, -0.01261256f, 0.11217418f, -0.03320561f, 
    -0.02521860f, 0.06303606f, 0.05468128f, 0.00913304f, 0.10066164f, -0.03461563f, 0.05189650f, -0.03330825f, 
    0.05694136f, -0.01871447f, 0.16267021f, -0.00085643f, -0.07966690f, 0.04760926f, 0.09514802f, 0.03026581f, 
    -0.02249500f, 0.07086086f, 0.03126227f, -0.01427921f, -0.17342649f, -0.00172851f, 0.07585859f, 0.02624304f, 
    0.04540227f, 0.03044948f, 0.01527014f, 0.00286064f, 0.17243201f, 0.07534777f, 0.07815292f, 0.02194406f, 
    0.03114690f, 0.12809291f, 0.03301339f, 0.09052247f, 0.02579634f, -0.00395541f, 0.06799912f, 0.10977446f, 
    0.05758922f, 0.11984660f, 0.08895566f, 0.09858996f, 0.19811913f, 0.11444629f, 0.01810461f, 0.02906784f, 
    -0.02207829f, 0.06319695f, 0.11056207f, -0.00009805f, 0.13896000f, 0.04370571f, 0.04412014f, -0.00679290f, 
    0.16794136f, -0.04970730f, 0.13609616f, -0.02245239f, 0.06198378f, -0.08656104f, 0.11665087f, -0.05768628f, 
    -0.01140697f, -0.08140750f, 0.09084064f, -0.07863215f, -0.00135403f, 0.13186941f, 0.00459883f, -0.06279822f, 
    0.12436067f, 0.04639640f, 0.07003103f, 0.02688023f, 0.05411147f, 0.05000937f, 0.02880783f, 0.02454258f, 
    0.01336868f, -0.01958676f, 0.02300501f, 0.01378741f, -0.00333814f, 0.02329820f, -0.03950420f, -0.02059591f, 
    -0.01339198f, 0.00829549f, -0.01467075f, 0.01195732f, 0.01592839f, -0.02751929f, -0.03317699f, 0.00991430f, 
    0.00723622f, 0.02019355f, -0.00276364f, -0.01843586f, -0.00987504f, 0.00049661f, 0.01732035f, -0.02407916f, 
    -0.00162384f, -0.03733988f, 0.02423004f, 0.01722379f, -0.01652375f, -0.03323410f, 0.02844081f, 0.00269987f, 
    -0.03867606f, 0.00876941f, -0.04170644f, -0.03167075f, -0.00719527f, 0.02891672f, -0.02707603f, -0.02825293f, 
    -0.03447404f, -0.03886581f, 0.01291722f, -0.01663421f, 0.02660884f, 0.01123954f, -0.01480506f, -0.01525289f, 
    -0.01890203f, -0.01960240f, -0.01245505f, -0.00335168f, -0.02261095f, 0.02007600f, -0.03563634f, 0.02382609f, 
    0.02867670f, -0.03193322f, -0.00926910f, 0.00591793f, -0.00513831f, 0.01521280f, -0.01162887f, 0.01287630f, 
    0.02393252f, 0.00672683f, 0.00499711f, -0.01822330f, 0.02221147f, -0.00729521f, -0.00276314f, -0.03282593f, 
    -0.03818854f, 0.00812262f, -0.00628642f, 0.02213003f, 0.01617597f, -0.00765951f, -0.00147668f, -0.02046569f, 
    -0.01165455f, -0.02322984f, -0.01431504f, -0.01596580f, -0.03151786f, 0.02902968f, -0.03950138f, 0.02678258f, 
    -0.03644884f, 0.00129677f, -0.02129179f, 0.00409453f, -0.03820118f, -0.02515175f, 0.01790655f, 0.02576055f, 
    -0.02677042f, -0.01109965f, -0.03722775f, -0.03644880f, -0.01218666f, -0.00978090f, 0.00207722f, 0.01700800f, 
    0.00016082f, -0.01341045f, -0.01937894f, -0.00675381f, 0.00013101f, 0.02994457f, -0.03100133f, -0.01806175f, 
    -0.02603384f, -0.03565423f, -0.04106654f, -0.03715092f, 0.01500393f, 0.02933243f, 0.01447086f, -0.03470776f, 
    -0.00936248f, 0.00196480f, 0.00171584f, 0.00931160f, 0.00384115f, 0.00491915f, -0.03897002f, -0.00587536f, 
    0.01312968f, 0.00147004f, 0.02855143f, -0.02514345f, -0.01823181f, 0.00865995f, 0.02485918f, -0.01657578f, 
    -0.01988168f, 0.02924283f, -0.00751576f, -0.01015693f, 0.02453041f, -0.01492012f, 0.02110788f, -0.03528768f, 
    0.02604167f, -0.03543082f, -0.02445848f, 0.00337826f, -0.00865996f, -0.00865829f, 0.02168226f, -0.01537995f, 
    0.00522313f, -0.02071254f, -0.03139319f, -0.04183591f, -0.02267745f, 0.00965180f, -0.03279614f, -0.01512657f, 
    -0.04094625f, -0.03345350f, -0.04203780f, -0.03603229f, -0.00842704f, 0.02779529f, -0.04135788f, -0.00840266f, 
    0.00412642f, -0.02881629f, 0.00795766f, 0.00928511f, 0.01685537f, -0.00371018f, -0.01538905f, 0.01694037f, 
    0.02313537f, -0.02885786f, 0.01358922f, -0.02476875f, 0.04048223f, -0.02317887f, -0.00624618f, 0.02371771f, 
    0.01478283f, -0.01707503f, 0.00907129f, 0.01777725f, 0.02755945f, 0.02614051f, 0.00675039f, 0.02952754f, 
    -0.01855915f, 0.01445833f, -0.00912104f, -0.02261315f, -0.02998822f, 0.00132846f, 0.01803281f, -0.00538497f, 
    0.02611225f, -0.03043591f, -0.01657554f, -0.01631544f, 0.02192827f, 0.01772377f, -0.03809474f, -0.01966765f, 
    -0.00156246f, -0.02513905f, -0.01794922f, 0.02738451f, -0.00220967f, -0.01500443f, 0.00009676f, -0.01981510f, 
    0.02682131f, -0.04152970f, -0.01534249f, 0.02559047f, 0.00424526f, -0.01992135f, -0.00994617f, -0.03861791f, 
    -0.01067655f, -0.03973673f, 0.00657090f, -0.01489468f, -0.02591234f, -0.00811356f, -0.02809964f, -0.02215848f, 
    -0.01966088f, -0.03259586f, 0.00549170f, -0.03587462f, -0.03744919f, -0.01660671f, -0.01103739f, 0.00958178f, 
    -0.04139016f, -0.00398275f, -0.00264088f, -0.01259285f, -0.03484238f, -0.02970566f, 0.02107498f, -0.02920827f, 
    -0.01502160f, 0.00299600f, 0.02017508f, -0.02093290f, 0.01861011f, 0.02999745f, 0.00974622f, -0.03962596f, 
    -0.01282585f, -0.01061415f, 0.01344775f, 0.01460465f, 0.02803627f, 0.02428650f, 0.02289658f, 0.01481968f, 
    0.01526814f, -0.03416149f, 0.02706091f, 0.02190027f, 0.00622620f, 0.01377642f, 0.01703795f, -0.03135934f, 
    -0.00721687f, 0.00365104f, -0.03792283f, -0.01229045f, 0.01372060f, -0.04067881f, -0.01787380f, -0.01225744f, 
    -0.00938580f, -0.03454098f, 0.00528244f, -0.01361226f, -0.02296069f, 0.00918759f, -0.03448091f, 0.00218535f, 
    -0.01305004f, 0.00741494f, -0.03681223f, 0.00001906f, -0.00190434f, 0.00930138f, -0.00856182f, 0.02383853f, 
    -0.03029656f, 0.02878932f, 0.01788499f, 0.01836108f, 0.02578465f, 0.00165871f, -0.02137570f, -0.00658688f, 
    -0.01795768f, -0.01549561f, -0.04051881f, 0.02021056f, 0.02397068f, 0.02754802f, 0.02034308f, -0.01505033f, 
    -0.03276889f, 0.01947502f, 0.00111092f, 0.01489048f, -0.03691534f, -0.02058986f, -0.02527694f, 0.02488612f, 
    -0.03802383f, -0.00871484f, 0.01001839f, 0.00470472f, -0.02849163f, 0.01699520f, 0.00504531f, 0.01733995f, 
    0.00116515f, -0.02083499f, 0.01994466f, -0.03666331f, -0.00025595f, -0.00315815f, -0.02682179f, -0.03075051f, 
    -0.02069460f, 0.00828954f, 0.00438076f, 0.00766933f, -0.00529987f, -0.02710403f, -0.01779898f, 0.01871426f, 
    0.01066049f, -0.00830407f, -0.01993598f, -0.03763818f, -0.04185713f, -0.02668409f, 0.00037375f, -0.00505386f, 
    0.00061859f, -0.01712146f, -0.00624823f, -0.01457547f, -0.00743842f, 0.00191063f, -0.02227176f, 0.01339357f, 
    -0.00495011f, -0.01412057f, -0.02235092f, -0.03833740f, 0.00721515f, 0.02455579f, 0.02194029f, -0.01950893f, 
    0.01413455f, 0.02340611f, 0.02708648f, -0.01199244f, -0.02292143f, -0.01877096f, -0.03222612f, -0.00138930f, 
    -0.03358583f, -0.00779178f, -0.02378092f, -0.02073515f, 0.01146359f, -0.01938221f, -0.01744537f, -0.01204631f, 
    -0.03908256f, -0.03385647f, -0.00735619f, -0.03857972f, -0.01663153f, -0.02344786f, -0.04155201f, 0.00283656f, 
    0.02298137f, -0.03085759f, -0.01633243f, 0.01517183f, 0.02684559f, -0.03781885f, 0.03272790f, 0.02608052f, 
    0.02415766f, -0.00324007f, 0.01324266f, -0.00223262f, 0.02618270f, 0.01350800f, -0.03821290f, 0.02792555f, 
    -0.00304553f, 0.01172313f, -0.00776592f, -0.02555663f, 0.01157602f, 0.02966616f, 0.02650969f, -0.02317171f, 
    -0.01998721f, -0.02360252f, 0.01348645f, 0.02680732f, -0.00827768f, 0.00851855f, -0.04029361f, 0.00316371f, 
    0.02742472f, 0.02377787f, 0.01433191f, -0.02558259f, -0.02315463f, 0.01251593f, 0.02666850f, 0.01128276f, 
    0.01790224f, 0.01021282f, 0.01460807f, -0.02481431f, 0.00007648f, 0.02586786f, 0.01950033f, -0.01987888f, 
    -0.03685735f, 0.00840657f, -0.02175856f, 0.01499886f, -0.03923895f, 0.02579669f, -0.03953307f, 0.00483382f, 
    -0.02489312f, 0.01218023f, 0.00531318f, 0.00724976f, -0.03696781f, -0.01416306f, -0.04139371f, -0.02342813f, 
    -0.00057650f, -0.02750104f, -0.00394132f, 0.00992030f, -0.01687861f, 0.02918744f, -0.02998779f, -0.03689116f, 
    0.00761187f, 0.02516517f, -0.02378185f, 0.01432755f, -0.01016325f, -0.02460024f, -0.03451864f, 0.00950038f, 
    -0.03117084f, 0.02348166f, 0.01943538f, -0.00330375f, -0.00664106f, -0.02037493f, -0.03157828f, -0.04203220f, 
    -0.01252352f, 0.01964893f, -0.01699879f, -0.00569010f, -0.00897469f, -0.01398685f, -0.02049639f, 0.01008873f, 
    -0.00564058f, -0.03770826f, -0.04113212f, -0.01754463f, 0.01295940f, -0.00869564f, -0.01429509f, 0.01188185f, 
    -0.03596753f, -0.03590477f, -0.00211934f, -0.02320974f, 0.02645597f, -0.01898935f, -0.00695406f, 0.02067674f, 
    -0.02683059f, -0.01003335f, 0.00847707f, 0.02903543f, 0.01679487f, 0.03003166f, 0.01277712f, -0.03916244f, 
    -0.00780874f, -0.03511974f, 0.02035075f, 0.00603043f, -0.02993483f, 0.00747977f, 0.02598233f, -0.04141168f, 
    -0.01485848f, -0.00720574f, 0.01996849f, -0.03687578f, -0.03086562f, 0.01896571f, -0.02780233f, -0.01512104f, 
    0.00181142f, -0.00512737f, -0.01625205f, -0.00841648f, 0.02733066f, -0.01709493f, -0.02034419f, -0.03660141f, 
    0.02377131f, -0.00229243f, -0.03646046f, -0.02433583f, -0.01049095f, -0.00944349f, -0.03475320f, -0.02326841f, 
    0.00379923f, -0.01360142f, -0.01539957f, -0.02834895f, -0.01059248f, -0.03711361f, 0.03745995f, 0.01456333f, 
    -0.01824601f, -0.04031030f, 0.00001532f, -0.02873563f, -0.03494683f, -0.02054207f, -0.01587145f, -0.03894220f, 
    0.02414630f, 0.00435976f, 0.01278472f, -0.02422223f, -0.03492543f, -0.03328535f, 0.00337969f, 0.00406550f, 
    -0.00021421f, -0.02010912f, -0.01233204f, -0.03172165f, 0.00483510f, 0.01290042f, 0.01787375f, -0.03322476f, 
    -0.03589077f, 0.00524797f, 0.02166291f, -0.03333599f, -0.03484352f, -0.01085592f, -0.03897376f, 0.02196337f, 
    -0.02421438f, 0.00566150f, 0.02505293f, -0.02317489f, -0.03925121f, 0.02147612f, -0.03573013f, 0.01396046f, 
    -0.00391235f, -0.00109149f, -0.00950750f, 0.01425056f, 0.02613316f, -0.01931201f, 0.00983304f, 0.01587453f, 
    0.01805645f, -0.00412876f, -0.01941695f, -0.03119525f, 0.02785286f, -0.03356813f, 0.02785038f, -0.02068720f, 
    -0.03156025f, -0.00996251f, 0.00705235f, -0.02143345f, 0.02131718f, 0.00726182f, 0.02698284f, 0.00370707f, 
    -0.00234442f, -0.03234357f, 0.00550848f, 0.01505364f, -0.03110312f, -0.00084491f, -0.02176488f, -0.02324819f, 
    -0.02114487f, 0.00738497f, 0.02963414f, -0.00492608f, 0.00210516f, -0.01433853f, -0.01123374f, 0.00717180f, 
    -0.00067712f, -0.02523256f, 0.02588689f, -0.01217576f, 0.02004297f, -0.00373992f, -0.01371778f, -0.02011667f, 
    -0.03112030f, -0.03742313f, -0.01124122f, -0.03302051f, -0.00704533f, 0.02462257f, 0.01842988f, 0.01195119f, 
    0.02444463f, 0.01280376f, 0.01091017f, -0.01196773f, -0.00184950f, -0.00090296f, 0.01776833f, 0.00719965f, 
    0.00922501f, -0.02515482f, -0.00092753f, 0.00171812f, -0.02342480f, -0.00645880f, 0.01959456f, -0.00353104f, 
    -0.02226105f, 0.00770305f, 0.02218300f, 0.02948697f, -0.03240469f, -0.02342173f, -0.00148760f, -0.01239969f, 
    -0.01249030f, -0.02555800f, -0.02746536f, 0.02621672f, -0.03174691f, 0.00093538f, 0.02627797f, -0.01367024f, 
    -0.01719477f, -0.00864146f, 0.02863957f, -0.03539645f, -0.03582846f, -0.02544501f, -0.02239223f, -0.00046630f, 
    -0.00606336f, -0.00783504f, -0.02888563f, 0.01048294f, -0.03003284f, 0.01582156f, 0.01390537f, 0.01217410f, 
    0.02893997f, -0.04006086f, -0.02391421f, -0.00272215f, 0.01337286f, 0.01801206f, -0.02874980f, -0.02959426f, 
    -0.01994690f, -0.02396108f, 0.00160947f, 0.00001495f, 0.04006308f, 0.02227052f, -0.02027574f, -0.03882837f, 
    0.02046821f, -0.02851423f, 0.00069147f, -0.02353243f, -0.01387304f, 0.01742754f, 0.02721061f, -0.03879814f, 
    0.00953897f, 0.00502588f, -0.03656901f, -0.00762781f, 0.00258393f, -0.03823671f, -0.03763446f, 0.02505790f, 
    -0.02575628f, -0.02355089f, -0.01517610f, -0.01142960f, -0.02395814f, -0.03074588f, 0.01977090f, -0.00056727f, 
    -0.03178635f, -0.03634298f, -0.00228855f, -0.03802402f, -0.00884139f, -0.02887659f, 0.02117757f, 0.01547378f, 
    0.02144255f, 0.00462060f, 0.01548618f, -0.01919611f, -0.02864145f, -0.02719020f, -0.02711009f, 0.02072722f, 
    -0.00620781f, 0.01641394f, 0.02410726f, -0.03851083f, -0.03785760f, -0.02143688f, 0.02416385f, 0.02497645f, 
    -0.03396537f, 0.02085787f, 0.01278048f, -0.03145678f, 0.02890135f, 0.01874945f, -0.00746652f, -0.03046064f, 
    -0.01031753f, 0.03039647f, -0.07648686f, 0.00794931f, -0.01730463f, -0.03371689f, 0.01440549f, -0.22311817f, 
    0.00396094f, -0.00255534f, -0.00412967f, 0.08704372f, -0.14508554f, 0.34325948f, -0.00578659f, 0.05517218f, 
    0.06870268f, 0.03518048f, -0.00281649f, 0.10352647f, 0.06096191f, 0.02921379f, 0.02360552f, -0.09800015f, 
    0.07013866f, 0.10612522f, -0.08305760f, -0.10898176f, 0.04671745f, -0.06888261f, -0.01869586f, 0.04985740f, 
    -0.08191529f, 0.02634053f, -0.11631071f, 0.04043793f, 0.04395731f, -0.03736776f, -0.01858412f, -0.07739183f, 
    0.03802914f, 0.03956972f, 0.01240476f, 0.08680488f, -0.09077477f, 0.08787719f, 0.05887837f, 0.13137136f, 
    0.03564339f, 0.01274902f, -0.02267271f, -0.01699356f, -0.00136587f, -0.02022825f, -0.08172037f, 0.02665312f, 
    0.00073861f, -0.05585924f, 0.06183728f, -0.06050456f, 0.22813852f, 0.10378448f, -0.05226500f, -0.11429533f, 
    0.13266912f, -0.09272240f, -0.03292218f, -0.01440454f, 0.13903229f, 0.00473618f, 0.07097004f, -0.01924086f, 
    -0.12402347f, -0.03910053f, -0.12992083f, 0.00568362f, -0.01660919f, -0.07820469f, -0.05688145f, -0.03298272f, 
    0.04145046f, -0.13569050f, -0.00909690f, -0.14297868f, 0.03025499f, -0.11958046f, 0.02645893f, -0.03725167f, 
    0.03381509f, 0.05790661f, -0.01284009f, 0.08770556f, -0.01133001f, -0.04655957f, -0.06438348f, -0.20953113f, 
    0.11660603f, -0.00760042f, 0.09444066f, -0.09808499f, 0.07937849f, 0.02656803f, 0.04114615f, 0.00830423f, 
    0.03571102f, -0.01324969f, -0.05250030f, -0.03780814f, 0.05198550f, -0.12817177f, 0.12708396f, -0.12806608f, 
    -0.00212954f, 0.02153974f, -0.00621789f, 0.00139008f, -0.02331391f, 0.00622968f, -0.11102597f, -0.01511390f, 
    0.14590250f, -0.16189221f, -0.04937207f, -0.08948066f, 0.00526217f, -0.03059714f, -0.11607581f, -0.10801949f, 
    0.04598457f, -0.01605813f, -0.02841843f, 0.13892618f, 0.04043049f, -0.11399806f, 0.04845069f, 0.05298565f, 
    -0.04350812f, 0.03949634f, -0.04147900f, 0.02042336f, 0.07641027f, -0.00217726f, -0.05246674f, 0.00806023f, 
    -0.09068578f, 0.26635641f, -0.01791787f, 0.12517326f, 0.00296975f, 0.01697795f, -0.01288461f, 0.09064490f, 
    0.00235323f, -0.04341387f, 0.02045944f, 0.00839128f, 0.21956497f, 0.07551061f, 0.10914323f, 0.03200004f, 
    -0.02644214f, 0.06141644f, 0.01200712f, 0.10581948f, -0.05105019f, 0.02662777f, 0.09074739f, -0.00255598f, 
    0.10980262f, 0.04173430f, -0.09184209f, -0.10404772f, -0.06779133f, -0.08707179f, -0.05691617f, -0.02039983f, 
    -0.11742645f, -0.07068449f, -0.03447632f, 0.05578135f, 0.17419775f, 0.02842983f, 0.08566342f, -0.09440696f, 
    -0.06659096f, 0.00442439f, 0.01482984f, 0.06995384f, -0.01438212f, -0.03781870f, 0.00192791f, 0.09162565f, 
    -0.12265427f, 0.04707262f, -0.13503641f, 0.03301285f, 0.02672977f, -0.02046399f, -0.06727986f, -0.04088050f, 
    0.04555106f, 0.16770034f, 0.00908181f, 0.12402949f, 0.03439162f, 0.03543004f, 0.06713130f, -0.00658093f, 
    0.02635981f, 0.09045572f, -0.09603973f, -0.03907667f, 0.06416133f, 0.16108711f, 0.02372443f, 0.07048946f, 
    0.03361129f, -0.11617036f, 0.10957561f, 0.00493613f, -0.01032573f, -0.05264972f, -0.00164521f, -0.03713923f, 
    -0.04032311f, 0.02189338f, -0.14472385f, 0.03165733f, -0.10465848f, 0.06754991f, -0.17676856f, -0.01882066f, 
    -0.00144431f, -0.02342078f, 0.08483049f, -0.13644411f, 0.02235703f, -0.04619889f, -0.00533523f, 0.02424063f, 
    0.03804655f, -0.06369769f, 0.01569784f, 0.25316939f, -0.03228273f, -0.04810509f, 0.00925072f, 0.10189075f, 
    0.02503852f, -0.03511816f, 0.10053234f, 0.06571963f, -0.00007615f, -0.18045397f, 0.00057533f, -0.09902938f, 
    0.10190573f, 0.02339676f, -0.08599306f, 0.10218006f, 0.11087219f, -0.02331742f, 0.00519414f, -0.05569855f, 
    0.04429409f, -0.00618526f, -0.13671111f, 0.07905738f, 0.06483203f, -0.08686147f, -0.14569679f, -0.09989367f, 
    0.02318691f, 0.00281005f, 0.01452126f, 0.02505306f, -0.09345295f, 0.13420367f, -0.10473273f, 0.12322023f, 
    0.05252784f, -0.00843627f, 0.09150282f, 0.00734832f, -0.04128135f, 0.03028583f, 0.09949701f, 0.08711626f, 
    -0.00654156f, 0.04858919f, -0.04971456f, 0.00847604f, 0.04845663f, -0.02487019f, -0.07036825f, -0.08897091f, 
    -0.05926254f, -0.03804249f, 0.02192547f, 0.00484288f, 0.08366007f, 0.10288799f, -0.02051335f, 0.02843151f, 
    -0.06243643f, 0.10093521f, -0.03213767f, -0.01356607f, -0.02233029f, 0.06761035f, 0.15067038f, 0.05037829f, 
    -0.03744599f, 0.04608322f, -0.07007616f, -0.28199372f, 0.01014233f, -0.17119001f, -0.10224823f, 0.03257229f, 
    0.00775805f, -0.01235095f, 0.04605042f, -0.12841363f, -0.23520626f, 0.21918501f, 0.02297187f, 0.04599073f, 
    -0.01684542f, 0.10125424f, 0.08031568f, 0.01388396f, -0.01142674f, 0.03420416f, 0.10692987f, 0.11712903f, 
    0.01184376f, 0.04061433f, 0.10433760f, -0.09773353f, -0.02211931f, 0.05047615f, 0.03675809f, 0.03115200f, 
    0.08702262f, -0.05503733f, -0.00362805f, -0.07916486f, 0.00444244f, 0.07329191f, 0.02374809f, 0.04775209f, 
    0.01455005f, 0.03387293f, -0.03209410f, -0.05575648f, -0.04008906f, 0.18132988f, 0.04169526f, 0.01546842f, 
    -0.16384341f, 0.21745278f, 0.11152217f, -0.10378528f, -0.00980187f, 0.07392935f, -0.08069474f, 0.02562033f, 
    0.08046224f, -0.04062716f, -0.01156149f, -0.01436090f, 0.11096851f, -0.11366309f, -0.11284707f, 0.02064453f, 
    0.06936259f, 0.08866658f, -0.09283221f, -0.07285870f, -0.00113133f, -0.01873261f, 0.00641439f, 0.04668995f, 
    0.01869892f, 0.12742732f, -0.08291063f, -0.09718995f, 0.17060184f, 0.05203762f, 0.02077120f, 0.00752804f, 
    0.05400580f, -0.00396559f, -0.05304687f, -0.01407890f, -0.15411629f, 0.14899282f, -0.17363136f, 0.20397297f, 
    -0.14608876f, 0.03006127f, 0.08527222f, -0.06859187f, -0.14577727f, 0.09853570f, 0.10217117f, 0.07166308f, 
    0.03418691f, 0.00618607f, -0.14864163f, -0.08269572f, -0.00654086f, -0.12005537f, -0.15265147f, 0.07648227f, 
    0.05061136f, 0.11943147f, -0.10993849f, -0.03360960f, 0.14121965f, 0.08404557f, 0.09001050f, -0.11211748f, 
    0.04048526f, -0.04599018f, -0.07320815f, -0.03645370f, 0.08419177f, 0.06858128f, 0.03166541f, 0.11670160f, 
    0.11515078f, 0.00608349f, 0.02682563f, -0.01916565f, -0.04246430f, -0.00278006f, 0.02503843f, -0.01466258f, 
    0.00302002f, -0.00745176f, -0.10008294f, 0.04415327f, 0.02965429f, 0.05596962f, 0.06473872f, -0.06766322f, 
    0.01727675f, 0.11277991f, 0.02866013f, -0.02226816f, -0.01399827f, 0.05311426f, 0.04548821f, 0.05514473f, 
    0.07752780f, -0.08253335f, -0.02951676f, -0.05709261f, -0.04670588f, 0.05211823f, -0.23990151f, 0.01863019f, 
    0.00673022f, -0.02802341f, 0.00643178f, 0.02996159f, -0.02272643f, 0.00753054f, -0.08730223f, -0.08770567f, 
    0.09559588f, -0.06574753f, -0.15137649f, -0.09937134f, -0.03649280f, -0.04030340f, 0.01397706f, 0.01554498f, 
    0.03382417f, -0.16893500f, 0.16595854f, 0.07648604f, 0.00077150f, 0.05019794f, 0.01550141f, 0.01927408f, 
    0.06397127f, -0.00053849f, -0.10949531f, 0.07868021f, 0.06480825f, 0.06642207f, -0.05402315f, -0.00178410f, 
    -0.06973894f, -0.07314309f, -0.09664524f, -0.02218613f, 0.02582367f, 0.15547955f, -0.08315384f, -0.03956239f, 
    0.01678805f, 0.06883415f, 0.01159650f, 0.11070866f, -0.02595362f, 0.04323163f, 0.01687323f, 0.12436462f, 
    0.03122720f, -0.09928308f, 0.09723596f, -0.02933824f, 0.00113939f, 0.17087562f, 0.18043664f, 0.13901526f, 
    -0.06642508f, -0.07647634f, -0.01208047f, 0.00535954f, 0.02310432f, 0.10427880f, 0.10134947f, 0.19302957f, 
    -0.00086049f, -0.05903884f, 0.01256507f, 0.10539483f, 0.00301535f, 0.03748418f, 0.07677334f, -0.02519276f, 
    0.02392274f, 0.02996752f, -0.06763202f, -0.07818987f, -0.00210199f, -0.09528204f, 0.03124348f, -0.09760989f, 
    0.01489653f, -0.13025507f, 0.01080504f, -0.03717572f, -0.02716019f, 0.01265985f, 0.09468951f, -0.09996787f, 
    0.10235660f, 0.06557442f, 0.02392066f, -0.09876471f, -0.11131173f, -0.06803192f, 0.01974116f, 0.10913917f, 
    -0.01000240f, -0.04614975f, -0.14210704f, 0.11725323f, 0.04574293f, 0.04337018f, -0.00636478f, -0.19059473f, 
    -0.01209147f, 0.02848930f, -0.00707439f, -0.09868416f, 0.06018043f, -0.01986163f, -0.04584250f, -0.04953349f, 
    0.27711841f, -0.09466453f, 0.00139460f, 0.12786110f, -0.04168373f, -0.11893183f, 0.00392101f, 0.06409768f, 
    0.02290547f, 0.00022412f, -0.10484787f, 0.03529860f, 0.27455994f, 0.02306618f, 0.08672173f, -0.00814112f, 
    0.01380099f, -0.01002040f, -0.02973882f, 0.07626063f, 0.00363470f, -0.03709344f, 0.06977459f, 0.00591239f, 
    0.11083259f, -0.03201938f, 0.07819611f, -0.08651626f, 0.04572295f, -0.02386372f, 0.10441601f, -0.02252888f, 
    -0.12276432f, 0.03599408f, 0.03734638f, -0.02711404f, -0.06870255f, -0.07348452f, -0.02881614f, -0.01329144f, 
    0.11686295f, 0.06529687f, 0.03374653f, -0.18666117f, 0.02714840f, 0.09073770f, 0.05698229f, 0.08177366f, 
    0.05844657f, 0.02602549f, 0.10943677f, -0.07663831f, 0.01973572f, -0.02224650f, 0.08048478f, 0.04343238f, 
    -0.06566122f, -0.03681147f, -0.09173305f, 0.07141806f, 0.03983871f, 0.03400915f, 0.02208092f, 0.07087399f, 
    -0.01703935f, 0.01171238f, 0.01442174f, 0.06074434f, 0.07902268f, -0.08582792f, 0.09233245f, -0.02267930f, 
    -0.21359339f, 0.14337099f, -0.04577222f, 0.08879410f, 0.03026286f, 0.16681542f, 0.03342239f, 0.05568936f, 
    -0.05537469f, 0.05564695f, 0.05513704f, 0.14708647f, -0.18594866f, -0.03294323f, -0.16700593f, 0.06243502f, 
    -0.03697338f, 0.02541472f, 0.11492494f, -0.07422477f, 0.14940113f, 0.04088661f, 0.08322629f, 0.12893699f, 
    -0.01132012f, 0.14604566f, -0.15470664f, -0.07789239f, -0.03415254f, -0.05227190f, -0.02115743f, 0.01045534f, 
    0.08663029f, 0.01597590f, 0.04668180f, 0.04038201f, 0.04454848f, 0.04821915f, -0.02664689f, -0.07487760f, 
    -0.05341958f, -0.13056219f, -0.13457792f, 0.06236232f, 0.01272558f, -0.02579880f, -0.00488543f, -0.09007599f, 
    0.14563136f, -0.00400077f, 0.10023844f, -0.09320893f, 0.06914669f, -0.00519032f, 0.01174132f, -0.07917181f, 
    -0.00059276f, 0.00617547f, -0.05052686f, 0.02201524f, -0.03327542f, 0.08632494f, 0.19269285f, 0.16253902f, 
    0.00498215f, -0.16100809f, 0.02573610f, 0.05768292f, 0.02864070f, 0.08310115f, 0.00455820f, -0.10595276f, 
    -0.05162944f, 0.02409134f, 0.01869584f, -0.00005099f, -0.02142786f, -0.08474208f, 0.08131837f, 0.09771663f, 
    0.09405056f, 0.04571027f, 0.00752483f, 0.04396375f, 0.14731266f, -0.01811444f, -0.03785677f, 0.12460120f, 
    -0.03167998f, -0.05415923f, -0.03334255f, -0.07489974f, -0.05421392f, -0.10336661f, 0.05382632f, 0.02124656f, 
    0.06712221f, -0.01993161f, 0.16026863f, -0.07147980f, 0.01809398f, 0.04940599f, -0.02590900f, 0.01103775f, 
    -0.01092551f, -0.04235424f, 0.02441067f, -0.06721698f, 0.23316705f, 0.08141463f, 0.23940389f, 0.06526613f, 
    0.06012288f, 0.01252308f, -0.00005603f, 0.08562604f, -0.07156824f, -0.05420930f, 0.03982848f, -0.00708025f, 
    -0.34308004f, 0.05262672f, -0.10307270f, 0.02400687f, 0.00123172f, -0.00194852f, -0.01538556f, 0.05412800f, 
    0.01164683f, -0.04036446f, -0.11088961f, -0.02558551f, -0.18173033f, -0.01958539f, 0.14062802f, -0.03702315f, 
    0.01927192f, -0.03092052f, 0.08756244f, -0.06363038f, 0.12674558f, -0.01581517f, -0.00288641f, 0.02021866f, 
    -0.08295440f, 0.07797184f, -0.13657846f, 0.06900497f, 0.11091816f, -0.00963390f, 0.00914646f, 0.02279295f, 
    -0.02002303f, 0.10445820f, 0.05134380f, 0.11803393f, 0.02588087f, -0.02676898f, 0.13656208f, 0.22156380f, 
    0.11700796f, 0.02852193f, 0.03247894f, -0.02907930f, 0.01796224f, 0.11241058f, -0.05841926f, -0.06820787f, 
    0.10528596f, -0.23925282f, 0.10862584f, 0.16743538f, 0.04084301f, 0.02723276f, 0.08217399f, 0.04431812f, 
    0.08675410f, 0.09532841f, 0.04685241f, -0.12772770f, -0.12219989f, -0.10372496f, -0.06761600f, -0.10331827f, 
    0.07029790f, 0.04868143f, 0.03339671f, -0.01752412f, 0.05489558f, 0.04406006f, 0.02353228f, 0.05516350f, 
    0.03973486f, -0.12693723f, -0.13765194f, 0.04904931f, -0.00576848f, -0.14423175f, 0.01894700f, 0.04860229f, 
    -0.01375891f, 0.08204041f, -0.03283468f, 0.11169083f, 0.11208685f, 0.02129078f, -0.09006607f, -0.03950404f, 
    0.19531609f, 0.08626502f, 0.01724173f, -0.10797931f, 0.02228530f, 0.05980914f, 0.06653360f, 0.16065073f, 
    0.06447935f, -0.03254089f, -0.06353100f, 0.19124742f, 0.01577662f, 0.05965095f, -0.01362168f, -0.04344806f, 
    0.05165384f, -0.02926333f, 0.04014691f, 0.04613698f, 0.00941367f, 0.00760346f, -0.00812660f, 0.13365851f, 
    0.03430807f, 0.01766801f, -0.01566397f, 0.04567822f, 0.05050607f, 0.02326071f, 0.02825304f, 0.06715709f, 
    -0.24784549f, -0.17820705f, 0.07236134f, 0.01037497f, -0.02311750f, 0.06265555f, -0.01182784f, 0.07877558f, 
    0.06922554f, -0.02606899f, -0.01790567f, -0.07467914f, -0.08867063f, 0.17299445f, -0.09692673f, 0.01283129f, 
    0.07982802f, -0.09559485f, 0.02599664f, -0.04952866f, 0.00214292f, 0.01309114f, 0.01911887f, 0.03079328f, 
    -0.05181879f, -0.14847934f, -0.04924000f, -0.05516037f, -0.05503684f, 0.09850661f, -0.03455577f, 0.04353207f, 
    0.01985995f, 0.02632364f, 0.05357879f, -0.02137707f, -0.01603316f, 0.32214683f, -0.14271514f, -0.04824028f, 
    0.19815831f, 0.05245913f, 0.05439768f, -0.06450488f, 0.05447448f, -0.10598359f, 0.04880423f, -0.10354456f, 
    -0.30492464f, 0.17501344f, 0.16172446f, -0.15607512f, 0.04883570f, 0.00605462f, -0.02996830f, 0.04653629f, 
    0.00891250f, 0.07020324f, 0.06773262f, 0.04837422f, 0.19304024f, -0.10310645f, 0.01356871f, 0.04395668f, 
    0.15029170f, 0.04189971f, 0.07422835f, 0.07109129f, 0.04324755f, 0.02607434f, 0.07223278f, -0.05898072f, 
    -0.10255934f, 0.09246886f, 0.16237324f, -0.04026848f, -0.04984539f, -0.04713698f, 0.02469870f, 0.10158263f, 
    0.06663863f, -0.01042693f, 0.00971308f, -0.07697972f, -0.11895534f, 0.24395008f, -0.14082226f, -0.14082757f, 
    0.06061080f, 0.03130806f, -0.03181558f, 0.11684122f, 0.00564721f, 0.05493064f, -0.01085704f, -0.03942937f, 
    0.03483905f, -0.00488183f, 0.01909127f, 0.10612436f, 0.12332381f, 0.11214497f, 0.05703260f, 0.13436510f, 
    -0.01430109f, -0.00515296f, 0.02616164f, -0.01806546f, -0.17208147f, -0.01572212f, 0.08992426f, -0.07890346f, 
    0.03419071f, 0.03600213f, 0.03324645f, 0.03760471f, 0.04786773f, -0.01919091f, 0.05374211f, 0.04286077f, 
    -0.21299544f, 0.15390714f, -0.13323762f, -0.10972875f, 0.05476285f, -0.03033422f, 0.10092965f, 0.14186211f, 
    -0.07382273f, -0.01564241f, -0.08320417f, -0.03182919f, -0.13182156f, -0.08182334f, 0.09631444f, -0.27325094f, 
    -0.09913117f, 0.03626611f, -0.04636313f, -0.03190311f, 0.04042562f, 0.04593804f, 0.00425968f, 0.10430783f, 
    -0.03535523f, 0.16963512f, -0.12642781f, 0.10129718f, -0.04281759f, 0.02268848f, -0.00291186f, -0.01587363f, 
    0.07554213f, 0.04901758f, -0.01346652f, 0.03051031f, -0.03948893f, 0.12923446f, -0.15275630f, -0.03776254f, 
    -0.06233151f, 0.13501932f, -0.05343858f, -0.06577126f, -0.02029219f, -0.03316104f, -0.00734155f, -0.09322321f, 
    -0.18227006f, -0.03108091f, 0.10675766f, 0.02983285f, -0.00553943f, -0.00859892f, 0.00250636f, -0.00621208f, 
    0.08129552f, 0.02917009f, 0.05092357f, 0.14038904f, 0.09456312f, -0.26878938f, 0.03540603f, -0.01314797f, 
    0.03299066f, -0.04268202f, -0.00777286f, -0.09134033f, -0.00278184f, -0.07589792f, 0.00384368f, -0.08010373f, 
    -0.08110399f, 0.19271106f, 0.05859828f, -0.12914330f, 0.05653661f, 0.01861727f, -0.04366377f, -0.00035243f, 
    0.00544422f, 0.00506032f, -0.01578356f, 0.07098568f, -0.09312492f, -0.15348046f, 0.02270091f, 0.01453711f, 
    0.03368730f, 0.00306946f, 0.02085817f, -0.05881196f, 0.00375426f, -0.03023397f, -0.00129114f, 0.02945692f, 
    0.02920756f, -0.12456729f, 0.20273934f, 0.05810466f, 0.02205550f, -0.03263353f, -0.07733963f, 0.13435158f, 
    -0.04180892f, -0.05637132f, -0.00538013f, -0.04690980f, 0.37245402f, -0.14326960f, 0.03543578f, 0.09251434f, 
    0.03696893f, 0.03217135f, 0.00916109f, -0.02743992f, -0.03921989f, -0.03388227f, -0.00966118f, 0.05461084f, 
    -0.16497456f, 0.11137138f, 0.15115064f, -0.05070734f, -0.00073141f, -0.05475998f, 0.06905103f, 0.08374383f, 
    0.00870727f, 0.02147169f, -0.02233672f, 0.08245539f, -0.06616903f, 0.06155822f, 0.01320849f, -0.24010700f, 
    0.03708211f, 0.05573999f, 0.02488398f, -0.06152453f, 0.01159996f, -0.06249605f, -0.00384552f, -0.06626838f, 
    -0.38521203f, 0.27467459f, 0.17825782f, 0.20251057f, -0.06645668f, 0.02278084f, -0.00477191f, 0.01702623f, 
    0.02009368f, 0.10704794f, 0.06125237f, 0.12547234f, 0.09977933f, 0.03904266f, 0.02922249f, 0.06181899f, 
    -0.08044083f, -0.00905170f, 0.01039365f, -0.05849240f, 0.10047469f, 0.02006026f, -0.01877919f, 0.02478237f, 
    -0.32748830f, -0.00250022f, 0.00196010f, -0.02756862f, 0.03174670f, 0.02842367f, 0.01396255f, -0.00123540f, 
    -0.01725846f, -0.04327341f, 0.05596206f, 0.12377760f, -0.48400667f, -0.02354707f, 0.22834967f, -0.02190632f, 
    0.00412285f, 0.04090346f, -0.04435265f, 0.00675890f, 0.02524384f, -0.04602932f, -0.05768970f, -0.01136080f, 
    -0.01914946f, -0.03976186f, -0.08248442f, 0.01949650f, 0.15057082f, 0.10633873f, -0.12720674f, -0.01268801f, 
    0.00995531f, 0.09914819f, 0.00473591f, 0.02614723f, 0.12864305f, 0.00082064f, 0.20529765f, 0.05784163f, 
    -0.09705170f, 0.07085796f, 0.07289454f, 0.05854208f, -0.05350374f, -0.03656565f, 0.03738945f, 0.17458701f, 
    -0.14370084f, 0.03517859f, -0.08554451f, -0.02249227f, -0.03703661f, 0.01544928f, 0.05349014f, 0.00168051f, 
    0.14246780f, 0.05044686f, 0.10010403f, -0.01430415f, -0.06509927f, -0.07618225f, -0.04165804f, -0.03717386f, 
    -0.01242607f, 0.05207207f, 0.04865711f, -0.00208877f, 0.01208736f, -0.00101502f, -0.01068166f, 0.03104205f, 
    -0.16559239f, 0.10579161f, 0.03973908f, 0.06651287f, 0.03638684f, 0.01015082f, 0.03642879f, 0.03082858f, 
    0.04189093f, 0.12423760f, -0.03039531f, 0.04282655f, -0.15916371f, -0.04717426f, 0.10911071f, 0.02722402f, 
    -0.15524405f, 0.02186048f, 0.04851101f, 0.05422862f, 0.01825125f, -0.02938371f, 0.07691275f, 0.05095957f, 
    0.03506334f, -0.13606368f, -0.11697476f, -0.02268177f, 0.13147464f, -0.01176025f, 0.03405711f, -0.03576270f, 
    -0.07266111f, 0.06001997f, 0.01347170f, 0.03298631f, 0.01734415f, -0.00754249f, -0.21073572f, 0.03424555f, 
    0.04810892f, 0.00188536f, 0.06346686f, 0.04856039f, 0.01366871f, -0.01287152f, -0.00478048f, -0.04099855f, 
    0.03599545f, 0.09668335f, -0.00879495f, 0.08855337f, 0.17256047f, 0.05622922f, 0.01462416f, 0.08490354f, 
    0.01002070f, 0.09480771f, 0.06475231f, 0.06317247f, 0.08278054f, -0.11443132f, 0.21230321f, 0.25136343f, 
    -0.04427064f, 0.01766042f, 0.02108205f, -0.05659578f, -0.13005057f, -0.02306136f, 0.07080021f, 0.11151668f, 
    0.00713303f, 0.00626296f, 0.03825783f, 0.05640743f, 0.21197270f, 0.07413941f, 0.05860602f, -0.03272016f, 
    -0.04207632f, 0.13343352f, -0.00888173f, 0.04349399f, 0.01050124f, 0.06166136f, 0.18531027f, 0.13275874f, 
    -0.01060392f, -0.04609288f, 0.03263662f, -0.05076774f, 0.10922422f, 0.05849711f, -0.05202379f, 0.09118704f, 
    -0.17860629f, 0.00744924f, -0.03988460f, 0.02177797f, 0.02012199f, 0.04872046f, -0.03680837f, -0.02763309f, 
    -0.01137461f, -0.01257081f, -0.07059853f, 0.00322951f, -0.16437805f, 0.00321976f, -0.23474765f, 0.06377345f, 
    0.10059478f, 0.05623659f, -0.02862934f, 0.01203030f, 0.09185579f, 0.09370943f, 0.00069218f, -0.00895326f, 
    -0.00211546f, 0.11333857f, -0.02581424f, 0.08590297f, 0.07261603f, 0.01547800f, -0.05393532f, -0.05975508f, 
    0.09917530f, 0.10468114f, -0.00048110f, 0.04461063f, -0.05951532f, -0.14243478f, 0.02570700f, 0.19676432f, 
    -0.01746228f, -0.04616104f, 0.07024768f, -0.02581860f, 0.04316764f, 0.06971180f, -0.12905699f, -0.01319946f, 
    -0.01610040f, 0.05829303f, -0.00153941f, -0.02778007f, 0.13284653f, -0.07021890f, -0.01943063f, 0.10239766f, 
    0.18409593f, -0.04099322f, 0.10900983f, 0.08237886f, -0.18668084f, 0.03501619f, 0.04886596f, -0.12790173f, 
    -0.03551317f, -0.05951433f, -0.00550721f, -0.02879491f, -0.08284590f, 0.02976419f, 0.01059563f, 0.14871974f, 
    0.12552026f, -0.31564590f, 0.04731530f, -0.03935658f, -0.04900072f, 0.00458515f, 0.06868202f, 0.02006675f, 
    -0.07604128f, -0.01232897f, -0.03323986f, 0.01080409f, 0.11602525f, -0.04413382f, -0.00974816f, -0.06943870f, 
    -0.04804103f, 0.02088877f, -0.05743226f, -0.04559748f, 0.02354182f, 0.03928270f, -0.00720742f, 0.05833804f, 
    0.01114986f, 0.02576058f, 0.11966453f, 0.01202423f, -0.04138630f, 0.06506904f, 0.02063310f, 0.02982896f, 
    -0.09238040f, -0.00827565f, -0.10875739f, -0.04315826f, -0.10176831f, -0.08678120f, 0.08844177f, -0.04096342f, 
    -0.06831813f, 0.01172443f, -0.04173952f, 0.01479638f, 0.03799973f, -0.03415056f, 0.02160725f, 0.05736892f, 
    -0.18135531f, -0.02152012f, 0.22652592f, 0.04864920f, 0.01264447f, 0.03245451f, 0.10661622f, 0.04845211f, 
    0.00733975f, 0.05950893f, 0.03754605f, 0.08674920f, 0.14251806f, -0.02219026f, 0.05327815f, -0.03542845f, 
    0.06551819f, -0.02497179f, -0.04559826f, 0.01044642f, 0.16616865f, 0.02306671f, 0.01754103f, 0.11787362f, 
    0.09342873f, 0.03222866f, 0.01424196f, 0.06650824f, 0.10084213f, 0.05205705f, -0.00346393f, 0.08825955f, 
    0.00401942f, 0.07856376f, 0.01024064f, 0.01046376f, 0.01597375f, 0.08705162f, -0.08637326f, 0.02323706f, 
    0.00148717f, -0.01721660f, 0.08407903f, -0.01369264f, 0.05499741f, 0.10192075f, 0.02991650f, -0.04259300f, 
    0.04476932f, -0.14030954f, 0.09158047f, -0.17334649f, 0.04339266f, -0.05582853f, 0.03791335f, 0.01212811f, 
    0.05980972f, 0.04177889f, -0.01006163f, -0.01056826f, -0.04985789f, 0.24417010f, -0.09222593f, -0.10672217f, 
    0.15600801f, -0.04639434f, 0.00547748f, -0.06383044f, 0.03709269f, -0.02911967f, -0.00741925f, -0.01793597f, 
    -0.01425259f, -0.07999557f, -0.11530417f, -0.22097483f, -0.04630596f, 0.10849754f, -0.01354758f, -0.14226025f, 
    -0.10774820f, 0.02939294f, 0.05425156f, 0.00429838f, -0.08537589f, -0.01322602f, 0.04909666f, -0.02249455f, 
    0.05828657f, -0.00667091f, 0.12072118f, -0.00176325f, 0.04999169f, 0.06892943f, 0.00968640f, 0.01242456f, 
    -0.16467689f, -0.01814115f, -0.02355615f, -0.05708157f, 0.01272498f, 0.02204624f, 0.04542042f, -0.01301117f, 
    0.03299004f, -0.06312604f, -0.07577064f, 0.06215088f, -0.16158967f, 0.09948023f, -0.00958726f, 0.14983350f, 
    -0.02017466f, 0.03877109f, -0.00908648f, -0.15839642f, -0.13580653f, 0.01825113f, 0.06007838f, 0.06996327f, 
    0.05486508f, -0.00132048f, 0.00255780f, 0.11403706f, 0.05987363f, 0.00306759f, -0.01834849f, -0.07921387f, 
    0.00445539f, 0.00306875f, 0.05720768f, 0.05713592f, 0.15732060f, 0.10549985f, 0.01945653f, 0.12981424f, 
    0.00574758f, 0.04417529f, -0.08319851f, 0.02107363f, -0.02235303f, 0.02849839f, -0.02142444f, 0.00996458f, 
    0.19186565f, 0.00047425f, 0.04027219f, -0.02994831f, 0.03404992f, 0.03203936f, -0.04960867f, 0.07618950f, 
    0.06879357f, -0.04850511f, -0.02217160f, -0.05132245f, 0.20401245f, 0.08508890f, 0.11976802f, 0.07134596f, 
    -0.06589330f, 0.07384709f, 0.02292344f, 0.00014770f, -0.12429950f, -0.01673824f, -0.06513773f, -0.06130076f, 
    0.04965819f, 0.10963669f, 0.07246875f, -0.08946007f, 0.15655801f, 0.02368111f, -0.02141566f, -0.04094662f, 
    0.04240843f, 0.01518836f, -0.15267184f, -0.08027869f, 0.12237155f, 0.02883834f, 0.14427905f, -0.00529364f, 
    -0.00823690f, 0.02015903f, -0.02458308f, 0.02091723f, -0.01858113f, -0.02333240f, -0.00825292f, -0.03558484f, 
    -0.08057611f, 0.07130051f, -0.02178064f, -0.08705179f, -0.01109368f, -0.04545602f, -0.01306609f, 0.00445896f, 
    0.12555504f, 0.11966617f, -0.06366173f, 0.12498972f, -0.03270780f, 0.06375647f, -0.03361941f, 0.02660065f, 
    -0.09915429f, 0.06258898f, 0.07221361f, 0.06266350f, -0.01451305f, 0.03906053f, 0.03237805f, -0.01324241f, 
    0.01626274f, 0.09754981f, 0.06738264f, 0.08983987f, -0.01442199f, 0.01465815f, 0.07747380f, -0.00515552f, 
    -0.00489596f, -0.02511803f, 0.00561100f, -0.07339515f, 0.24469014f, 0.11837507f, 0.12978898f, 0.11259614f, 
    -0.10815643f, 0.01659195f, -0.00453374f, 0.10644739f, -0.00570752f, 0.06106202f, 0.01645669f, 0.03575409f, 
    0.12708884f, -0.11847286f, -0.17095324f, -0.09527772f, 0.04814307f, 0.00996373f, 0.08460116f, -0.03091057f, 
    0.02756544f, -0.05366988f, 0.04542375f, 0.06703593f, 0.14892669f, 0.15125459f, -0.20560227f, 0.22935535f, 
    0.01504815f, 0.03762569f, 0.03170078f, 0.00262254f, -0.00392654f, 0.08360171f, -0.01605596f, 0.05201713f, 
    0.13384829f, -0.08072546f, 0.01282167f, -0.01645671f, -0.00766427f, -0.03529838f, -0.00698250f, -0.05568445f, 
    -0.01842613f, 0.09022143f, 0.03068209f, 0.02442765f, 0.19574681f, -0.01170280f, 0.17327040f, 0.08655445f, 
    -0.01154361f, -0.02893744f, 0.07612220f, 0.04210121f, -0.02370610f, 0.05040481f, -0.02093983f, 0.09128763f, 
    0.09665956f, -0.00256467f, 0.07320511f, 0.10102712f, -0.08498083f, -0.05088315f, -0.04839809f, -0.10596770f, 
    -0.01092529f, -0.02571359f, 0.01604046f, -0.02837542f, -0.24129288f, -0.05202596f, 0.00347687f, 0.05382839f, 
    0.03202186f, 0.07688548f, 0.01305508f, 0.03807512f, 0.03428427f, 0.03568217f, 0.00206430f, 0.02649729f, 
    0.23157376f, -0.22700733f, 0.04699149f, -0.05170027f, -0.04320436f, -0.03237100f, -0.11026354f, 0.07317567f, 
    0.12930796f, -0.08557198f, -0.13875708f, -0.07351973f, -0.14728594f, -0.01817202f, -0.13946174f, -0.13336477f, 
    -0.01211130f, -0.02324952f, -0.03855009f, 0.03772686f, 0.00565993f, -0.08761084f, -0.01599725f, -0.11338007f, 
    -0.27223867f, -0.03904763f, -0.04497441f, -0.20781124f, -0.03055645f, 0.05798145f, 0.00515127f, 0.04206130f, 
    0.05518125f, 0.06762425f, -0.00647925f, -0.05130335f, 0.17450707f, -0.06091435f, -0.02102098f, 0.05497446f, 
    0.00221860f, -0.02002197f, 0.04057964f, 0.04456346f, 0.03862945f, 0.04217456f, 0.01370644f, 0.00315903f, 
    -0.04970203f, 0.06621699f, 0.01381166f, -0.08438515f, 0.06094720f, 0.02476044f, -0.03968421f, -0.05326569f, 
    0.00157061f, 0.08956824f, 0.05294030f, -0.00371914f, -0.13018420f, -0.05566873f, -0.02636838f, 0.04147768f, 
    0.04886344f, 0.05447033f, 0.14292771f, -0.00616441f, 0.03088612f, 0.06252027f, 0.00258611f, -0.04595827f, 
    0.06259999f, 0.13302480f, -0.14390130f, -0.15492310f, 0.06374934f, -0.04187966f, 0.02150350f, 0.01271473f, 
    0.02816075f, -0.01586177f, 0.15275228f, 0.02066334f, -0.13235115f, 0.06739153f, 0.16622309f, 0.05557219f, 
    0.00443522f, 0.04103847f, 0.19390371f, -0.03215958f, -0.03566487f, -0.00534302f, 0.08603350f, 0.00065115f, 
    0.09515645f, -0.18622799f, -0.07414255f, -0.08674967f, 0.02790726f, -0.01981586f, -0.03387651f, -0.10736320f, 
    -0.06084651f, -0.05926659f, -0.04094192f, -0.03134538f, 0.04510444f, 0.21002096f, 0.02405738f, -0.07210255f, 
    0.04894713f, 0.15873438f, -0.02577834f, -0.00382594f, 0.00483362f, 0.14373830f, -0.02379087f, -0.05977645f, 
    -0.22129174f, -0.07003118f, 0.05418475f, 0.04348847f, 0.02772471f, -0.04297480f, 0.05569424f, 0.08465371f, 
    0.07135955f, -0.00743109f, 0.09262195f, 0.02771066f, -0.02488153f, 0.06180232f, -0.11787317f, 0.01162780f, 
    0.04691322f, 0.10418988f, 0.01167593f, 0.05504670f, -0.05204253f, 0.04183904f, 0.01134778f, 0.03017700f, 
    0.07290441f, 0.20075896f, -0.03984163f, -0.03512062f, 0.08439174f, -0.03156712f, 0.01138664f, -0.03196377f, 
    0.06640818f, 0.05625507f, -0.07486103f, 0.02047913f, -0.21063146f, -0.04048024f, -0.00538102f, -0.13715887f, 
    -0.04444147f, 0.07567330f, 0.02947111f, 0.01820333f, -0.07558004f, 0.06795906f, 0.00648634f, -0.02014030f, 
    -0.08904918f, -0.00123967f, -0.12724458f, -0.15837087f, -0.01887859f, 0.00681781f, 0.01728495f, 0.05553555f, 
    0.06140408f, 0.03146121f, 0.00061371f, 0.02975221f, -0.23420466f, -0.12129276f, 0.06971771f, -0.15086463f, 
    0.05326433f, -0.02377009f, -0.00827310f, 0.02245041f, 0.07899742f, -0.03075362f, 0.13090245f, 0.06696767f, 
    0.21296245f, 0.12395837f, 0.12182834f, -0.03023280f, -0.10501076f, 0.01227205f, 0.11063246f, 0.04474416f, 
    -0.03347734f, -0.09207673f, 0.02075501f, 0.05526515f, 0.08724637f, 0.01207768f, 0.00143752f, 0.02684970f, 
    0.17172216f, -0.02986196f, 0.01273002f, -0.07465929f, 0.03009095f, 0.04523708f, -0.02747190f, -0.05557792f, 
    -0.12739247f, -0.04275880f, -0.04446040f, -0.16658349f, -0.15990475f, 0.06566015f, -0.13758434f, 0.06828725f, 
    -0.07078645f, 0.02444576f, 0.09272089f, 0.02478221f, -0.16290534f, -0.05877891f, -0.07630799f, -0.11432275f, 
    0.01847698f, -0.06356405f, -0.02329956f, 0.02868227f, 0.02085391f, 0.09527457f, -0.00956313f, 0.02489413f, 
    0.20546435f, -0.02338585f, 0.17308415f, 0.00211676f, -0.04307708f, -0.03022500f, 0.00903325f, -0.04139863f, 
    -0.07807257f, 0.03534091f, 0.03305135f, 0.13116698f, -0.09547678f, 0.01634070f, -0.02778056f, -0.08893789f, 
    -0.05433504f, 0.01004178f, -0.07910480f, 0.00300326f, -0.03069182f, 0.16577770f, -0.03665145f, -0.07382535f, 
    0.26488000f, -0.03466045f, 0.05399996f, 0.02255460f, 0.04196551f, 0.11877168f, -0.03008026f, 0.06885500f, 
    0.09784516f, -0.09975065f, 0.03180939f, -0.01234231f, 0.16546592f, -0.06649546f, 0.08234600f, 0.10431033f, 
    0.01696975f, -0.08207047f, -0.05709364f, 0.00454917f, 0.08372433f, -0.00971162f, 0.02643933f, 0.09511991f, 
    0.07986964f, 0.07308022f, -0.04342129f, 0.07301516f, -0.04108433f, -0.02512931f, 0.01259825f, -0.17969051f, 
    -0.03568986f, 0.06179487f, 0.02556948f, -0.00640158f, -0.02398514f, 0.12115543f, 0.06415295f, -0.07669996f, 
    0.01983824f, 0.01800265f, 0.09278201f, -0.10673088f, 0.09376241f, 0.11323209f, 0.14353199f, -0.03544241f, 
    0.10509510f, 0.10941266f, -0.21969241f, 0.30463943f, 0.00943369f, -0.02354761f, 0.02949220f, -0.01873297f, 
    -0.01195083f, 0.05073058f, -0.03137106f, 0.02015688f, -0.01155126f, 0.17840666f, -0.09628095f, 0.00023783f, 
    0.16315761f, 0.18167652f, -0.00462761f, -0.01912312f, -0.00248805f, 0.11482499f, -0.05143183f, 0.01244775f, 
    -0.04631214f, 0.03966127f, -0.12033662f, -0.12975934f, 0.05036328f, -0.02869864f, -0.04105378f, 0.12608367f, 
    -0.02658142f, 0.00945730f, -0.07827920f, -0.02492793f, 0.34375489f, 0.07057913f, 0.08092980f, 0.15247419f, 
    -0.10368906f, 0.04019086f, -0.00354935f, 0.05667518f, 0.04461680f, 0.03471836f, 0.00220012f, 0.01813688f, 
    0.03483671f, 0.09159648f, 0.11068006f, 0.04763000f, 0.05195646f, -0.00433675f, 0.01468261f, 0.06516446f, 
    -0.02883209f, 0.07549417f, 0.01993089f, -0.00444957f, 0.19415358f, 0.09096061f, 0.04006464f, -0.07212659f, 
    0.03800027f, -0.00980119f, 0.00258989f, -0.08722387f, 0.04801618f, 0.04193097f, 0.12247360f, -0.08191951f, 
    0.00817039f, 0.09092091f, 0.01400589f, 0.17247079f, 0.00080167f, -0.04219436f, 0.02880125f, 0.01208857f, 
    -0.21163288f, 0.13807231f, -0.10476654f, 0.06111083f, 0.26733780f, 0.22742161f, -0.17092296f, 0.06928138f, 
    -0.05113977f, 0.03637327f, -0.04124882f, 0.04785431f, 0.14247093f, -0.06263409f, 0.03391929f, 0.00185113f, 
    -0.04145006f, 0.11806785f, 0.01877836f, 0.06450987f, -0.02421048f, -0.03213787f, -0.01811956f, -0.12147361f, 
    0.03878493f, -0.04359337f, 0.06970645f, 0.07087199f, -0.29936999f, -0.09048763f, -0.02325113f, -0.09240041f, 
    0.07530633f, 0.05901240f, 0.11970583f, 0.11226937f, 0.07471749f, -0.04581715f, -0.01848014f, 0.00695810f, 
    -0.10072342f, 0.03279091f, -0.01858087f, -0.04560774f, -0.05888903f, -0.06956798f, 0.04869247f, 0.02167951f, 
    0.11472666f, -0.00355493f, -0.01201376f, -0.07747006f, -0.00276500f, 0.00160221f, -0.12911323f, -0.18098946f, 
    -0.08429033f, -0.02932029f, -0.00630317f, 0.01295006f, -0.02833370f, -0.01731616f, -0.01686145f, -0.04116366f, 
    -0.24294259f, -0.03974107f, 0.11910181f, 0.07863401f, 0.05864245f, -0.02717877f, -0.03421206f, -0.08264089f, 
    0.00560611f, 0.02582958f, -0.03383078f, -0.02818303f, 0.42396715f, 0.05980154f, -0.05933537f, 0.10594395f, 
    -0.00178626f, 0.07194907f, -0.02856174f, 0.05283943f, -0.08292182f, -0.07912961f, 0.03093965f, 0.00329267f, 
    0.08221368f, -0.07602710f, 0.02256216f, 0.01886985f, -0.01502891f, -0.03448306f, 0.04505214f, 0.01172428f, 
    0.05077190f, -0.06696866f, -0.00845683f, -0.03855814f, -0.09705877f, 0.08029517f, -0.10989684f, -0.14226674f, 
    -0.00854708f, 0.07760084f, 0.04234682f, 0.08717743f, -0.05726992f, -0.10116190f, 0.04894388f, 0.03367023f, 
    -0.07007340f, 0.03657268f, 0.04838631f, 0.18398246f, 0.07861067f, 0.03390116f, -0.01098561f, -0.01997171f, 
    0.05389316f, 0.08422787f, -0.06500410f, -0.12750292f, 0.26488689f, 0.20221935f, 0.10578322f, 0.14383091f, 
    -0.03531513f, -0.03550957f, 0.06799940f, 0.08421981f, -0.00689159f, 0.03453775f, -0.01886224f, 0.04181794f, 
    -0.01188146f, -0.01545343f, 0.01454453f, -0.03315219f, -0.00896570f, 0.02679153f, -0.00120101f, -0.00644676f, 
    -0.02228814f, 0.03326746f, 0.02138962f, -0.03239094f, -0.03711062f, 0.01246035f, 0.01840519f, -0.01945321f, 
    0.01648690f, -0.04200866f, -0.01699287f, 0.02620362f, -0.03115011f, -0.01760010f, 0.02258500f, 0.03042673f, 
    0.02176751f, -0.00460224f, 0.00153162f, 0.01613977f, -0.03659984f, 0.02052494f, -0.03176172f, 0.02337256f, 
    0.03291315f, -0.02995861f, -0.02490501f, 0.02738604f, -0.02742889f, 0.00413453f, -0.02274350f, -0.01731136f, 
    0.01173129f, 0.03790949f, -0.00300771f, 0.02406698f, 0.01209004f, -0.00399590f, 0.00817460f, -0.00393406f, 
    -0.01696387f, -0.01766958f, 0.01334925f, 0.01962721f, -0.00495067f, -0.01837253f, 0.02566304f, -0.02666872f, 
    0.01610428f, 0.01755221f, 0.02118331f, 0.01150484f, 0.02628339f, 0.02043151f, -0.01710659f, 0.02290237f, 
    0.00488843f, -0.01986025f, 0.00171874f, -0.02812504f, 0.00132050f, 0.00515484f, 0.00900598f, -0.02766575f, 
    -0.01171017f, -0.02733407f, -0.03485298f, -0.01004426f, 0.00682418f, -0.01456567f, 0.00864937f, -0.01504104f, 
    0.00827792f, -0.03595667f, 0.03296917f, 0.02078559f, -0.02341865f, -0.02112551f, -0.00589686f, -0.04170247f, 
    0.00443110f, 0.00978637f, -0.03678112f, 0.01891968f, 0.00700438f, 0.02493500f, 0.02219293f, -0.01149950f, 
    -0.01530770f, -0.04325160f, -0.03874904f, -0.02373091f, 0.00428274f, 0.02639089f, -0.02854396f, -0.02366333f, 
    -0.01759198f, 0.02658248f, -0.00131099f, 0.01861274f, -0.02971476f, 0.01918366f, 0.02523080f, 0.01677191f, 
    -0.02264586f, 0.00226407f, -0.02314131f, 0.00135384f, 0.03135641f, -0.04071885f, -0.01548371f, 0.02179315f, 
    0.01296079f, -0.02769972f, -0.00688528f, 0.03695969f, -0.00315905f, -0.03010707f, 0.01674581f, 0.00477834f, 
    0.01267423f, 0.00040455f, 0.01239671f, -0.00798100f, -0.01642343f, 0.00840836f, 0.01558106f, -0.00910741f, 
    0.03061767f, -0.00599978f, -0.01589037f, -0.00451027f, -0.03281301f, -0.01020284f, -0.04161164f, -0.03457638f, 
    0.00247008f, -0.01279625f, 0.00199015f, 0.02808642f, -0.00456735f, 0.00846046f, -0.00505723f, -0.00223383f, 
    0.00007256f, -0.02996913f, 0.00281235f, 0.01297815f, 0.02117267f, -0.01722395f, -0.00088405f, 0.00472995f, 
    -0.03134923f, -0.00386463f, -0.02976462f, 0.01353180f, -0.01487211f, 0.01128829f, 0.02139863f, -0.00858138f, 
    0.02681256f, -0.02851986f, 0.01949523f, 0.01913832f, 0.02066635f, -0.04079524f, 0.02707640f, -0.03657984f, 
    -0.01832788f, -0.00800223f, -0.00130279f, -0.02056318f, 0.02423566f, 0.02803050f, -0.02446718f, -0.00514049f, 
    -0.00509377f, -0.00450568f, -0.04179741f, 0.02264803f, 0.03142688f, 0.02187130f, -0.02821828f, -0.02452440f, 
    -0.01881958f, 0.02769214f, 0.01054236f, -0.00789701f, -0.00773599f, -0.03448011f, 0.00014051f, -0.02089584f, 
    0.01960761f, -0.02441112f, -0.02916100f, -0.02245675f, -0.00418682f, -0.00435478f, -0.03931697f, 0.01043908f, 
    0.03381960f, -0.03377725f, -0.02335557f, 0.00905643f, -0.00822019f, 0.00391131f, -0.03253705f, -0.02057582f, 
    0.00323185f, -0.00103595f, 0.00797574f, -0.00100286f, -0.02975278f, 0.00429776f, -0.01691318f, -0.01991127f, 
    0.01108736f, -0.02272034f, -0.02386762f, -0.01968706f, 0.01014817f, -0.03320917f, -0.01898293f, 0.01233072f, 
    -0.02796642f, 0.02981781f, -0.00323985f, 0.02437964f, -0.00870959f, 0.02433317f, -0.01615027f, -0.02220540f, 
    -0.00724139f, -0.02206373f, -0.01355836f, -0.02075272f, 0.03382630f, 0.01151673f, -0.00097806f, 0.00042312f, 
    0.01696638f, -0.02453697f, -0.03747580f, 0.01790000f, -0.00131788f, 0.00553420f, -0.00240866f, -0.03242015f, 
    -0.00148113f, 0.02575590f, -0.03023050f, -0.00514265f, -0.02540938f, 0.00413302f, 0.01122749f, -0.02640862f, 
    -0.03181155f, 0.03027757f, -0.00207617f, -0.03388856f, -0.03084183f, -0.03736751f, -0.02639168f, 0.01590615f, 
    0.02330982f, -0.00793226f, 0.01941987f, 0.00958509f, 0.00548004f, -0.00744091f, 0.02985697f, 0.02956736f, 
    0.01348488f, -0.04064637f, -0.02510192f, -0.02452512f, -0.01358374f, -0.02201202f, -0.02478777f, 0.00568673f, 
    0.02151353f, -0.03887915f, -0.03079320f, -0.02645407f, -0.02964764f, -0.02691530f, -0.01033751f, 0.00255133f, 
    0.02726240f, 0.00023593f, 0.00619236f, 0.00436927f, 0.02222661f, -0.00772455f, 0.00431554f, -0.01213995f, 
    -0.01339509f, -0.00238373f, 0.02619717f, -0.00232692f, -0.03942627f, 0.00613552f, 0.01804231f, 0.01677202f, 
    -0.00790058f, -0.01158625f, -0.02143258f, -0.01257898f, 0.01679118f, 0.00679362f, 0.01338073f, -0.01513371f, 
    0.01151555f, -0.03259963f, -0.01737175f, -0.02966124f, 0.01022201f, -0.03184240f, 0.03404185f, 0.02144174f, 
    -0.00589173f, 0.01879686f, 0.01246650f, -0.04216572f, -0.01597945f, -0.03870663f, -0.02121494f, -0.02420172f, 
    -0.00721165f, -0.03580941f, -0.00186285f, -0.02169120f, 0.03583729f, -0.03145726f, 0.00839640f, 0.02574820f, 
    -0.00161906f, -0.00024770f, 0.00692628f, 0.01714097f, 0.01257741f, -0.02236253f, -0.03058840f, 0.03777647f, 
    0.01498897f, -0.03558967f, -0.02307367f, -0.03741033f, 0.00145176f, -0.00726330f, 0.02527013f, 0.02904945f, 
    -0.02718574f, 0.01532278f, -0.00358085f, -0.00576243f, 0.02167803f, 0.02451827f, 0.02530086f, -0.02800959f, 
    -0.03213788f, 0.00443663f, 0.02730019f, -0.01570327f, -0.03054433f, -0.01699787f, 0.01858337f, 0.01887010f, 
    0.01401334f, -0.02088044f, -0.02591446f, -0.00831151f, 0.02821427f, -0.03226564f, -0.02770090f, 0.02893432f, 
    -0.02485023f, 0.01107189f, 0.04386486f, 0.01833756f, 0.01384917f, 0.01371107f, -0.00498503f, 0.00276327f, 
    0.00857996f, 0.01501332f, -0.01041938f, -0.01717496f, -0.03548466f, -0.00700585f, -0.02429061f, -0.01906045f, 
    0.03886634f, -0.03295678f, -0.00257709f, -0.01890421f, 0.01068689f, -0.02511912f, 0.01917426f, -0.01275051f, 
    0.01512866f, -0.02529915f, -0.00194887f, -0.01370666f, -0.02009644f, -0.01666073f, 0.02941463f, -0.00203989f, 
    -0.04150029f, 0.01967140f, -0.01840891f, -0.00257828f, 0.02365850f, 0.01893398f, -0.01208428f, -0.02593295f, 
    -0.01178058f, -0.04330598f, -0.00683263f, 0.00605719f, -0.00975767f, 0.00254625f, -0.02696955f, 0.00612504f, 
    -0.03244272f, -0.03545728f, -0.03906931f, 0.02852050f, 0.01034578f, 0.00359093f, 0.01948357f, 0.01022044f, 
    -0.03357536f, -0.03980565f, -0.04214444f, 0.02830175f, 0.00766027f, 0.03007026f, -0.02578962f, -0.00316293f, 
    0.02677549f, -0.03176713f, -0.02044698f, -0.01294485f, 0.02662259f, -0.01234793f, 0.00130772f, 0.02935910f, 
    -0.00871929f, -0.00075476f, 0.01515858f, 0.03105780f, 0.03189653f, -0.00788297f, 0.01525178f, -0.00450493f, 
    0.01894556f, 0.01617438f, -0.01332975f, -0.01655651f, 0.00006145f, 0.00000071f, 0.00335251f, -0.03213544f, 
    -0.00027994f, 0.00828834f, -0.01798197f, -0.00587842f, -0.03384043f, 0.00123255f, -0.00231410f, -0.03405330f, 
    0.00712720f, 0.00902817f, 0.01436376f, -0.01816645f, -0.01889636f, 0.00743235f, -0.01929800f, 0.02941434f, 
    0.00792456f, -0.03397441f, -0.02100152f, 0.02249994f, 0.02867630f, 0.00146352f, 0.01545637f, 0.02308193f, 
    0.03122319f, 0.00910455f, -0.02899505f, -0.03342916f, -0.01736923f, -0.02408010f, 0.03546138f, -0.03400626f, 
    0.00931870f, -0.02227612f, 0.00989512f, -0.00251375f, -0.03282330f, -0.00707084f, 0.01128688f, 0.03038439f, 
    0.03380385f, 0.01793382f, 0.01199870f, 0.02791044f, -0.00192270f, -0.01950022f, -0.01525067f, -0.01169448f, 
    -0.00425899f, -0.00201988f, 0.00088171f, 0.01534509f, -0.02788307f, -0.01070901f, -0.01715017f, 0.02231112f, 
    -0.01670920f, -0.02560873f, -0.01438399f, 0.00448753f, 0.01072732f, -0.00426305f, -0.02432155f, 0.01715273f, 
    -0.03446197f, 0.03034365f, -0.02803552f, -0.04104719f, 0.00236117f, -0.00162701f, -0.00407122f, 0.00701765f, 
    -0.01767599f, 0.01617359f, -0.03674917f, -0.03226223f, 0.00557433f, -0.02214678f, -0.00737641f, -0.02916717f, 
    -0.03012184f, -0.04201614f, -0.01693808f, -0.02180766f, -0.03290358f, 0.03441839f, -0.01505683f, 0.01666261f, 
    0.02259894f, -0.00909053f, 0.00715311f, -0.03324532f, -0.03086202f, -0.03677603f, -0.02572178f, 0.02275422f, 
    -0.00653739f, 0.00199463f, -0.01515438f, 0.01757839f, -0.03337195f, -0.01381090f, -0.02030444f, 0.01492333f, 
    0.02720727f, 0.02574641f, -0.02256665f, 0.02629101f, -0.01095548f, 0.03352211f, -0.00304082f, 0.00425977f, 
    -0.03123285f, -0.00257428f, -0.02013699f, -0.01306161f, -0.04078722f, 0.02153711f, 0.00106365f, -0.02762043f, 
    0.03524980f, -0.02001697f, -0.01905603f, -0.03106190f, -0.01025916f, -0.00666875f, -0.01867421f, 0.00308529f, 
    0.01751043f, -0.02936843f, -0.00452443f, -0.02893387f, 0.02766679f, 0.01434272f, 0.00891691f, -0.01403667f, 
    -0.02359163f, 0.02167833f, -0.03092832f, -0.04156392f, 0.02172149f, -0.00752021f, -0.03832307f, 0.02047952f, 
    0.02605495f, -0.00171734f, -0.02408677f, -0.01640755f, -0.03221211f, -0.01719974f, -0.01071490f, -0.02676567f, 
    0.00677989f, -0.00767086f, -0.02127685f, -0.00685568f, -0.02507414f, -0.01230235f, -0.00155077f, 0.00732033f, 
    0.02157891f, 0.00221332f, 0.02987479f, -0.02863107f, -0.03270253f, -0.01504364f, -0.00834466f, 0.01701681f, 
    -0.03794052f, 0.00445835f, 0.01372091f, 0.02812353f, -0.02323797f, 0.01800086f, 0.01154599f, 0.02327785f, 
    -0.02479914f, 0.01358807f, 0.02154476f, -0.03153218f, 0.01247211f, 0.01649350f, 0.01990643f, -0.02289972f, 
    0.02503541f, 0.02706194f, 0.02426790f, -0.00776471f, 0.03453164f, -0.01077736f, -0.01790196f, 0.03724623f, 
    -0.00383157f, -0.00847976f, 0.02596872f, -0.04131501f, 0.02555157f, -0.01126383f, -0.00597316f, 0.00599814f, 
    0.02160756f, -0.03570292f, 0.02265483f, -0.04018526f, -0.02496139f, 0.00083099f, -0.00498821f, 0.02369077f, 
    0.00075542f, 0.02567144f, -0.00610742f, 0.00758912f, 0.03514679f, -0.01188925f, 0.00061615f, -0.01902412f, 
    0.01434574f, -0.01344879f, 0.00106814f, 0.02989958f, -0.01967675f, 0.01302646f, 0.00741347f, 0.01282691f, 
    0.01770572f, 0.00794840f, 0.01996826f, -0.02980960f, 0.01668385f, 0.02707009f, -0.03601401f, 0.01299044f, 
    -0.02617527f, -0.02548163f, 0.00781169f, 0.00279245f, 0.01988795f, 0.00130090f, -0.02693308f, 0.00454336f, 
    0.02552182f, -0.00842309f, -0.03172642f, 0.00458881f, -0.02397815f, -0.00291083f, -0.01567597f, -0.00049532f, 
    -0.02711513f, 0.00671027f, -0.03106496f, -0.00453759f, -0.00059181f, -0.03052401f, 0.00916552f, -0.01684256f, 
    -0.01003287f, -0.02093580f, 0.01480596f, -0.01928380f, 0.02987854f, -0.00989438f, -0.01258701f, 0.03265433f, 
    -0.00405452f, -0.03312158f, -0.00261300f, -0.01748740f, -0.02746186f, -0.00813262f, 0.00513593f, -0.02930921f, 
    0.02632679f, -0.02229597f, -0.00421691f, -0.02737727f, -0.04323951f, 0.00887640f, -0.01969266f, -0.03876393f, 
    0.01187101f, 0.00154825f, 0.00567400f, 0.01422373f, -0.00319485f, -0.01980562f, 0.02490222f, -0.01152422f, 
    -0.00210453f, 0.00059243f, 0.01528330f, -0.00301630f, -0.02932134f, 0.01776758f, -0.00348262f, -0.00707584f, 
    -0.29844970f, -0.11195211f, -0.18823546f, 0.06511601f, -0.03471944f, 0.08398342f, 0.03944135f, 0.03254754f, 
    -0.05613795f, 0.12579535f, 0.13086274f, -0.07944885f, 0.18177326f, -0.03431489f, 0.00740235f, -0.02409396f, 
    -0.04843491f, -0.05082188f, 0.10675511f, -0.01544808f, -0.06797360f, 0.01139459f, 0.04634420f, 0.05985803f, 
    -0.09989534f, -0.20347349f, -0.13472502f, 0.39385083f, 0.05000191f, -0.06256673f, 0.15948808f, -0.02541446f, 
    0.06070861f, 0.10270365f, -0.04390153f, 0.15909715f, 0.02513778f, -0.04648335f, 0.05600432f, 0.02766112f, 
    -0.02165791f, -0.00968040f, 0.07246745f, -0.01821426f, 0.04375022f, 0.08356751f, -0.08261332f, -0.03382064f, 
    0.06193352f, -0.14222081f, 0.19174202f, 0.03561694f, 0.07048994f, 0.05895102f, 0.03764000f, -0.00271125f, 
    -0.00763128f, 0.04839602f, 0.02000387f, -0.01107195f, 0.21014151f, -0.02785033f, 0.02931089f, -0.16809718f, 
    0.10354960f, 0.03906019f, -0.07363908f, -0.04399385f, 0.01371099f, 0.04453991f, 0.05780174f, 0.03354895f, 
    0.19561392f, 0.15702562f, 0.00807211f, -0.01556913f, 0.04192927f, -0.02663025f, 0.02459824f, 0.06974689f, 
    -0.03881633f, 0.07414898f, 0.08983254f, 0.03180926f, 0.09659750f, -0.06499275f, 0.08593316f, -0.04728089f, 
    -0.04653764f, 0.06821413f, 0.06725492f, 0.02922823f, -0.07849233f, 0.06560005f, -0.02098749f, 0.23866297f, 
    0.20680001f, -0.04140848f, -0.00097033f, 0.10228803f, -0.02821044f, -0.00067537f, -0.03367844f, 0.09863575f, 
    0.02514717f, -0.07823996f, 0.00221653f, 0.03474834f, 0.08639599f, 0.09166040f, 0.25351316f, -0.00983753f, 
    -0.17372327f, 0.00839570f, 0.02160285f, 0.13260397f, 0.00346790f, 0.00306402f, 0.00633396f, 0.06536761f, 
    -0.23775756f, -0.20920210f, -0.00756881f, 0.11696137f, -0.04537994f, -0.09620082f, -0.00614617f, 0.00925772f, 
    0.16981795f, 0.04513361f, -0.04724853f, -0.04029774f, -0.03496639f, 0.19757591f, -0.13724440f, 0.01585541f, 
    -0.10874691f, -0.01215845f, 0.13773486f, 0.06629732f, 0.07691442f, -0.02945597f, 0.04073506f, -0.06608275f, 
    0.13483651f, -0.14531033f, 0.00402320f, -0.10533167f, -0.10220441f, 0.05554749f, 0.11080860f, -0.04714926f, 
    -0.00350938f, 0.02029242f, 0.07356460f, 0.04230909f, 0.25232828f, 0.36665004f, 0.12406928f, -0.02995099f, 
    0.07915573f, -0.01715620f, 0.00729172f, 0.05505100f, 0.00929689f, -0.05566835f, 0.14426431f, -0.12321801f, 
    0.00079246f, -0.03518106f, 0.13499753f, 0.06526094f, -0.14283060f, -0.03402703f, 0.05247410f, 0.05100476f, 
    0.07536846f, 0.10710284f, 0.07084459f, 0.13062185f, 0.36461899f, 0.09987094f, -0.08320635f, -0.03457270f, 
    0.02957992f, -0.00133144f, 0.09942330f, 0.05281250f, 0.04141453f, 0.04113908f, -0.00867172f, -0.03155875f, 
    -0.05698422f, 0.01587036f, 0.27017060f, 0.00750155f, -0.08737306f, -0.01173233f, 0.04391250f, -0.00800909f, 
    0.02359052f, 0.09733955f, -0.04556931f, 0.12084183f, 0.08627064f, 0.23191193f, -0.02846260f, 0.06295663f, 
    -0.01138869f, -0.05050750f, 0.07899521f, 0.01454105f, -0.08618382f, 0.08715867f, 0.02717377f, -0.02144684f, 
    0.15134524f, 0.04910299f, 0.11758132f, -0.03010570f, 0.06225326f, -0.02806555f, 0.01321392f, 0.12130585f, 
    0.02826101f, -0.01625369f, -0.03982235f, -0.04528405f, 0.28673652f, -0.28691339f, -0.08074708f, 0.02357450f, 
    -0.03894212f, -0.05876889f, -0.03288026f, -0.05466431f, 0.03550777f, 0.06655578f, 0.01972392f, 0.13554603f, 
    -0.09028963f, 0.16244014f, -0.02824182f, 0.03840674f, -0.05528835f, -0.05120989f, 0.03162724f, 0.03913184f, 
    0.01606702f, -0.12325366f, -0.01118632f, 0.02980802f, -0.15447879f, 0.04073110f, -0.19026799f, -0.26676369f, 
    0.02474014f, -0.04626948f, -0.03172755f, 0.09513959f, 0.06682014f, 0.06301529f, 0.02418403f, 0.10138299f, 
    0.10181364f, -0.07964160f, -0.13207349f, 0.22610776f, -0.03061192f, -0.11837968f, -0.00336048f, 0.02424173f, 
    0.06073350f, 0.08959585f, 0.02830954f, 0.08005757f, 0.08290053f, 0.17977826f, -0.10176730f, 0.06838077f, 
    -0.08801261f, 0.00981283f, 0.05394849f, 0.00637705f, 0.03583492f, -0.01948048f, 0.01185493f, 0.09040625f, 
    -0.04519961f, -0.20405360f, -0.03365494f, 0.28919601f, -0.14478524f, -0.07981177f, -0.04534743f, 0.05643170f, 
    0.10772019f, 0.03697881f, 0.02723247f, 0.12545475f, 0.16543293f, -0.18674920f, -0.06727416f, -0.05690842f, 
    0.02861973f, 0.00961471f, -0.03591181f, -0.02510473f, 0.00559964f, 0.01175029f, -0.04452631f, -0.02191101f, 
    0.38254353f, -0.14447024f, 0.06557742f, 0.14953522f, 0.00447190f, 0.01522092f, -0.05440650f, 0.06398872f, 
    0.06776182f, 0.01524759f, -0.03551598f, 0.05797753f, 0.12201893f, -0.02808181f, 0.02879276f, 0.05087953f, 
    -0.03735670f, -0.01182149f, 0.05214106f, -0.04840057f, -0.04188110f, 0.07501265f, -0.03805529f, 0.00703703f, 
    0.14216709f, 0.01012023f, -0.01742406f, -0.13328639f, -0.07070348f, 0.00075951f, 0.12923270f, 0.01737497f, 
    -0.12477075f, 0.05008492f, -0.10303322f, -0.02246546f, 0.19329451f, 0.03066546f, 0.00125830f, -0.02740877f, 
    -0.01921650f, 0.02022753f, -0.05355250f, 0.02809018f, -0.02552406f, 0.06476958f, -0.08760691f, 0.03320452f, 
    0.13958350f, 0.00812233f, 0.00077296f, -0.13833132f, -0.12600324f, -0.08609335f, 0.00012795f, 0.09903192f, 
    -0.03068683f, 0.01774723f, 0.05714445f, 0.06468327f, 0.02894831f, 0.16138147f, -0.08471137f, -0.11371120f, 
    0.06719401f, 0.05970153f, 0.13000500f, 0.02832009f, 0.05095731f, -0.03539281f, 0.08133374f, 0.02807808f, 
    -0.37362659f, 0.16714235f, 0.09711996f, 0.11158260f, 0.03436823f, -0.00438228f, 0.04649382f, 0.00874248f, 
    0.11397853f, 0.09260637f, 0.02009129f, 0.00974490f, 0.29656687f, -0.10633614f, 0.22086343f, 0.23140045f, 
    -0.09494423f, 0.09256332f, -0.06799681f, -0.01221653f, 0.07930288f, -0.04874472f, 0.03719358f, 0.00981132f, 
    -0.02329927f, -0.15176092f, -0.13311049f, 0.36189774f, 0.00778572f, -0.05647948f, 0.03611363f, 0.04513768f, 
    0.03454361f, 0.04914392f, 0.06307325f, 0.02342465f, -0.17584047f, -0.06630323f, -0.06068523f, -0.19462673f, 
    0.01595159f, -0.02610544f, 0.08619788f, 0.06532440f, -0.04112187f, -0.02645795f, 0.03715646f, -0.03239974f, 
    -0.00839640f, 0.12961507f, 0.00628681f, -0.06488633f, -0.06583052f, 0.00623623f, 0.03883268f, 0.01964876f, 
    0.01731401f, -0.02622934f, 0.09665755f, 0.02337273f, 0.38979751f, -0.04654351f, -0.00271602f, 0.08544729f, 
    -0.02219007f, 0.02679633f, 0.03843354f, -0.04065270f, 0.11071121f, -0.04489647f, 0.12278266f, -0.12704575f, 
    -0.14679347f, -0.06504434f, 0.00985221f, 0.17507598f, -0.18980837f, -0.06846426f, -0.06919204f, -0.01085081f, 
    0.07350186f, 0.00545892f, 0.01419094f, -0.07988663f, 0.13329448f, -0.25671929f, -0.22363906f, 0.10743245f, 
    0.03419618f, -0.06326596f, -0.03712416f, 0.11650221f, 0.02958320f, 0.00696787f, 0.01266449f, 0.01090251f, 
    -0.12409575f, 0.17141022f, 0.08052194f, -0.00483078f, -0.03040754f, -0.05008778f, -0.00226396f, 0.02058691f, 
    0.02715587f, 0.06229341f, -0.00286869f, 0.08121189f, -0.06567811f, -0.11405785f, -0.07220726f, 0.25070095f, 
    0.01233468f, 0.09669794f, -0.00132507f, 0.00948469f, 0.02421305f, 0.02544459f, 0.05243033f, -0.03900016f, 
    -0.15082937f, 0.13363853f, 0.05217313f, 0.12892677f, 0.07633685f, -0.05273063f, 0.10376644f, 0.14295344f, 
    0.09054811f, 0.01515021f, -0.01809420f, 0.03396214f, 0.11480549f, 0.07281821f, -0.07491009f, 0.12940235f, 
    0.03748599f, -0.04930217f, 0.03112973f, 0.01295688f, -0.02970750f, 0.00698243f, 0.02672455f, -0.02339395f, 
    0.14759691f, 0.02296152f, -0.02037054f, -0.00970990f, 0.06570014f, -0.08420831f, 0.02620896f, 0.07585683f, 
    0.06961851f, -0.08350551f, 0.10283671f, 0.09166074f, 0.17294221f, -0.13192655f, 0.10347510f, 0.31112668f, 
    -0.04313319f, -0.02019319f, 0.00218377f, -0.02285824f, 0.05554828f, 0.02209131f, -0.02206974f, -0.02981732f, 
    0.38484889f, 0.01874461f, -0.11858794f, 0.04246039f, 0.15599313f, 0.07482892f, 0.11447750f, 0.06942894f, 
    0.06725018f, 0.08620907f, -0.00846593f, 0.07880981f, 0.06919211f, 0.25777319f, 0.05748703f, -0.11990798f, 
    0.01626997f, 0.08196823f, 0.10959087f, -0.06302721f, 0.14495993f, -0.00905219f, 0.00724752f, -0.05097439f, 
    -0.33701393f, 0.16481847f, -0.21551840f, 0.19040799f, -0.03372704f, 0.00597701f, -0.07982238f, 0.06917147f, 
    0.04824825f, -0.00388627f, -0.02299829f, -0.04968009f, 0.14806195f, 0.10918090f, -0.06359164f, 0.08200608f, 
    0.04661221f, 0.00492351f, -0.04381604f, 0.07060127f, -0.04544007f, -0.06475193f, 0.06851782f, -0.02731066f, 
    -0.12360922f, 0.13730627f, 0.19786718f, 0.06714016f, -0.05618175f, 0.02887669f, -0.05148280f, 0.00391047f, 
    0.11047491f, 0.03970380f, -0.10566697f, -0.01248828f, 0.09587646f, 0.11040582f, 0.04667681f, 0.06776403f, 
    0.00728807f, 0.01910693f, 0.01663228f, 0.02499492f, 0.03531319f, 0.03047095f, -0.00943615f, -0.09961382f, 
    0.07759272f, 0.18713655f, 0.10431447f, -0.07487404f, 0.13485560f, -0.10742354f, -0.02375272f, 0.07286370f, 
    0.11176462f, -0.01000207f, 0.01764964f, 0.04628675f, -0.54368609f, 0.08785100f, 0.13915554f, 0.17252037f, 
    0.04257963f, 0.00744049f, 0.00337783f, -0.09128276f, -0.07294226f, -0.01871888f, 0.05887356f, -0.00068220f, 
    0.13015389f, -0.18599787f, -0.08071262f, -0.23571593f, -0.00511608f, -0.04963605f, 0.03805164f, -0.03246728f, 
    -0.05750746f, 0.09488605f, 0.01519428f, 0.06672555f, 0.13552284f, -0.21390893f, -0.10633976f, -0.03704016f, 
    0.00346482f, -0.09779724f, -0.06181408f, 0.05349012f, 0.02249015f, 0.08656714f, -0.02013266f, 0.00221922f, 
    0.00904277f, -0.08739309f, 0.04618859f, 0.01389886f, -0.02463347f, -0.01962550f, -0.02267538f, 0.02919040f, 
    0.01169085f, -0.00257023f, 0.05110485f, -0.05253676f, -0.01729626f, -0.10391369f, 0.08340853f, 0.09619299f, 
    -0.09998870f, -0.04973849f, -0.00266324f, 0.12745877f, -0.05825048f, 0.04404277f, 0.01461756f, 0.04565725f, 
    -0.07524920f, -0.20899981f, -0.04290526f, -0.06238069f, 0.04725409f, -0.00595372f, 0.06385733f, 0.05230081f, 
    0.06142351f, 0.03970369f, -0.00740679f, 0.03090660f, -0.18295589f, -0.10188413f, 0.06961455f, 0.31611571f, 
    0.09293219f, 0.06841172f, 0.00207330f, 0.09718681f, -0.00073587f, 0.03722204f, -0.04538190f, -0.03184103f, 
    0.18291076f, 0.09800504f, 0.07235486f, -0.06662983f, 0.08645640f, 0.07126599f, -0.02089334f, 0.10458935f, 
    -0.05789277f, -0.07395914f, 0.01386455f, 0.00383885f, -0.11930765f, -0.10601708f, -0.05692667f, 0.28332877f, 
    -0.11311152f, -0.00573073f, 0.08460774f, -0.01000981f, 0.07546639f, 0.02042662f, 0.07627761f, -0.08131861f, 
    0.01106439f, 0.14296298f, 0.01855489f, -0.24501957f, 0.07486741f, 0.11682201f, 0.06843238f, 0.07855795f, 
    0.15792289f, 0.10064298f, 0.06749842f, 0.15003511f, 0.03375029f, 0.39531669f, 0.20725435f, -0.06980417f, 
    -0.08052874f, -0.02389760f, -0.06690303f, 0.00426850f, 0.06037415f, -0.06163312f, -0.00453725f, 0.03970144f, 
    0.02402596f, -0.03692052f, -0.03054596f, -0.03913324f, -0.00990895f, 0.01365792f, -0.03689161f, 0.00276289f, 
    0.00617746f, -0.00057049f, -0.02639273f, -0.03476224f, -0.04302472f, -0.00002475f, 0.00701144f, 0.01149032f, 
    -0.02808507f, 0.01774100f, 0.02014736f, -0.02089984f, -0.03610981f, -0.02874657f, -0.01444839f, 0.03438675f, 
    0.00044844f, 0.02033452f, -0.02541443f, 0.02316384f, -0.00801693f, -0.01943863f, -0.02499479f, -0.02460386f, 
    0.01480715f, -0.01424606f, 0.02217855f, -0.03265318f, -0.00990746f, -0.00973585f, 0.02850249f, -0.02859892f, 
    0.02827064f, -0.01515496f, 0.01438650f, 0.02091566f, -0.03009554f, 0.00806761f, 0.01074299f, 0.00864037f, 
    0.02143807f, -0.04423835f, -0.03322425f, 0.02747052f, -0.01630645f, 0.01244833f, -0.01599171f, 0.02736900f, 
    -0.02127429f, 0.01482568f, 0.01594145f, 0.02373610f, 0.02198221f, -0.03289632f, -0.01239714f, -0.00030007f, 
    -0.04418481f, -0.03799945f, 0.02491935f, 0.01517110f, 0.00602871f, -0.03296001f, -0.00508151f, 0.00595915f, 
    -0.01249974f, 0.02877456f, -0.00879428f, -0.03462918f, -0.01625442f, 0.01580895f, 0.00199688f, 0.01241765f, 
    -0.01088373f, -0.02199392f, -0.04394704f, -0.04112342f, -0.02636361f, -0.03350725f, -0.02992496f, 0.01742633f, 
    -0.01114351f, -0.03009812f, 0.02399270f, 0.00091217f, -0.01238119f, -0.00787463f, -0.02144644f, 0.02236367f, 
    0.02398497f, -0.00082276f, 0.00221557f, -0.01116196f, -0.02462891f, 0.00247996f, -0.00479003f, -0.02811516f, 
    0.00671680f, -0.02146779f, -0.04409751f, -0.03768553f, -0.02628472f, 0.01681178f, 0.02414873f, 0.01668003f, 
    -0.00501613f, -0.02434233f, 0.00295771f, -0.01212733f, 0.00358444f, 0.02491219f, -0.04147776f, -0.00570894f, 
    0.01226160f, 0.01989579f, -0.01452315f, -0.01416128f, 0.01454970f, 0.01037938f, -0.02983012f, 0.02596661f, 
    0.02327545f, -0.02966662f, -0.02386547f, 0.01680234f, -0.01261372f, -0.01755759f, -0.01467020f, -0.02218230f, 
    -0.00100122f, 0.03144399f, 0.00914142f, -0.01615481f, -0.04175043f, -0.00375884f, -0.01872684f, 0.00805280f, 
    0.00084541f, -0.02975503f, 0.02656964f, -0.02232905f, 0.00173021f, -0.01459580f, -0.03108647f, -0.00045340f, 
    -0.02326858f, -0.03644610f, -0.01962549f, 0.01208513f, 0.00524256f, -0.03931844f, -0.02425776f, -0.03500764f, 
    -0.02947034f, -0.02288397f, 0.02553601f, -0.03371080f, 0.00192906f, 0.03136859f, -0.02239935f, -0.02613248f, 
    0.02700142f, 0.00605703f, -0.00932158f, 0.01325014f, -0.02296066f, -0.03398034f, 0.01572023f, -0.00029800f, 
    0.00442918f, -0.02034982f, 0.00795608f, -0.00854800f, -0.00718447f, 0.02076424f, 0.00243235f, 0.00998661f, 
    -0.02645193f, -0.00975613f, 0.00813491f, 0.01048994f, 0.00563433f, -0.04166814f, -0.03741735f, 0.00160294f, 
    -0.03072591f, 0.01341227f, 0.00709049f, -0.00044305f, 0.00693892f, -0.00731471f, 0.01200817f, -0.02703350f, 
    -0.03415315f, 0.02421420f, -0.03625947f, -0.02862605f, 0.00589453f, -0.00406703f, 0.02579223f, -0.02546436f, 
    -0.03552254f, -0.00026919f, 0.02464345f, -0.02648302f, 0.00283704f, -0.02049983f, 0.00011798f, -0.03487691f, 
    -0.01971254f, -0.01109359f, -0.00614804f, -0.01156775f, -0.00292570f, 0.02578194f, -0.03626992f, 0.00799382f, 
    0.01619184f, 0.02398583f, -0.00067424f, -0.00256610f, -0.04357896f, -0.03598845f, 0.02299219f, -0.00792294f, 
    0.01359726f, -0.03566543f, 0.00251392f, -0.04129775f, -0.04312840f, -0.04100748f, -0.01072098f, -0.00371983f, 
    -0.02606274f, 0.01524383f, -0.01434455f, -0.01802088f, -0.01334138f, 0.00615131f, -0.01652783f, -0.04396632f, 
    -0.01396403f, 0.02930541f, -0.02288233f, 0.02459274f, -0.00664308f, 0.01274935f, 0.01199194f, -0.02836430f, 
    -0.00101560f, -0.02140330f, 0.02779732f, -0.02537439f, -0.03932134f, -0.00464287f, 0.01169224f, -0.02831524f, 
    -0.01843759f, 0.01696867f, 0.02050924f, 0.00897666f, 0.00845422f, 0.01069738f, -0.00957953f, -0.00908866f, 
    -0.00209038f, -0.02920433f, 0.02155109f, -0.02257095f, -0.02419107f, -0.03815535f, 0.02701196f, -0.03818677f, 
    0.00887810f, 0.01162085f, -0.03192709f, -0.02096405f, 0.00480492f, -0.02017087f, -0.02600179f, 0.02089499f, 
    -0.03401012f, 0.02304083f, 0.02599138f, 0.01913970f, -0.03041869f, 0.02711801f, 0.02529461f, -0.02124223f, 
    -0.00066587f, 0.00849932f, -0.03049552f, 0.01570339f, -0.01841980f, 0.00745195f, -0.01711371f, 0.01810799f, 
    0.02371629f, -0.04072107f, -0.01307791f, -0.00663330f, -0.00506502f, 0.02416442f, -0.03408525f, -0.02913641f, 
    -0.01139039f, -0.01002517f, -0.00187992f, 0.00896415f, -0.03020145f, 0.02480142f, 0.01773144f, -0.03756054f, 
    0.02590151f, -0.01560998f, 0.01107141f, -0.00756043f, 0.02647892f, -0.03463871f, -0.00210382f, -0.04244838f, 
    -0.03017093f, 0.01955519f, 0.01722906f, -0.00536351f, -0.03868938f, 0.02803264f, -0.02038950f, 0.03774430f, 
    0.01013984f, -0.03197616f, 0.00151995f, -0.03914641f, 0.00388951f, 0.00100083f, 0.00817914f, 0.00211915f, 
    -0.01867172f, 0.01332021f, -0.02570389f, 0.00890993f, -0.02807219f, 0.01281862f, 0.00194160f, -0.01015654f, 
    -0.00220712f, -0.02822219f, -0.00516461f, -0.00039989f, -0.01570820f, -0.00803159f, 0.00520768f, -0.02733996f, 
    0.00037293f, -0.00186465f, 0.02194514f, -0.04204332f, 0.00982019f, -0.00684560f, 0.01829758f, -0.02579900f, 
    -0.00412815f, 0.00050112f, -0.03887696f, -0.03051953f, 0.02066153f, 0.01344303f, 0.02716557f, -0.01092122f, 
    -0.01627448f, -0.01164709f, -0.03854289f, 0.02546031f, 0.00123133f, 0.02417638f, -0.01897332f, -0.03213612f, 
    0.01662844f, 0.00256431f, -0.03282599f, -0.00877105f, -0.02356670f, 0.00769315f, -0.02713927f, 0.01952012f, 
    -0.01983920f, -0.02024217f, 0.02218496f, -0.00659763f, 0.01687808f, -0.02755348f, -0.02382279f, -0.03508323f, 
    -0.03614261f, -0.01574374f, -0.02828041f, -0.00445125f, -0.01981616f, -0.01075548f, -0.02570393f, 0.01201690f, 
    -0.03207026f, -0.02134325f, -0.00802479f, 0.01334582f, -0.02633912f, -0.03555657f, -0.03923118f, -0.03138762f, 
    -0.00491537f, -0.02784657f, -0.01078877f, -0.00517977f, -0.01737803f, -0.03276202f, 0.01087365f, -0.03271993f, 
    0.00071495f, -0.02821754f, 0.02215608f, -0.03913331f, -0.04390416f, -0.01056840f, 0.02083073f, -0.00336833f, 
    -0.00306524f, -0.03853510f, -0.03901791f, 0.02618264f, 0.00780778f, -0.03551168f, -0.04344475f, -0.00055506f, 
    0.01651941f, -0.02238089f, 0.00516261f, -0.00234115f, -0.00611558f, 0.00078229f, -0.03378772f, 0.02755865f, 
    0.01592689f, -0.02909190f, -0.02783552f, -0.02834959f, -0.04229625f, -0.02978063f, -0.01134732f, -0.00948486f, 
    -0.04424080f, 0.02286875f, -0.02228672f, 0.01515043f, 0.02347556f, -0.02751781f, 0.01132652f, -0.00215632f, 
    -0.01506550f, 0.02495469f, -0.02201262f, -0.03043508f, 0.02681136f, -0.00680775f, 0.00432570f, -0.02681826f, 
    -0.02243176f, -0.02903343f, -0.03227497f, 0.01329367f, 0.00809095f, -0.02830000f, -0.03127804f, -0.03570188f, 
    -0.03121751f, 0.02151737f, -0.04258604f, -0.01227383f, -0.00281379f, -0.01927136f, -0.03470665f, -0.00323919f, 
    -0.01227607f, 0.01484562f, -0.04104929f, 0.00050431f, -0.01167199f, 0.03250308f, -0.02039275f, 0.01910075f, 
    0.01119221f, 0.00241684f, 0.02050964f, -0.03576611f, -0.02229643f, 0.00430774f, -0.00948618f, -0.03646974f, 
    -0.02648094f, -0.01522737f, 0.02203122f, -0.01388118f, 0.02431257f, -0.03791366f, 0.01952476f, 0.00314219f, 
    -0.02850075f, 0.02529875f, -0.04078071f, -0.01445299f, -0.02075083f, 0.02651109f, -0.00468778f, -0.03815964f, 
    -0.00526537f, 0.01710951f, -0.00217949f, -0.03944447f, -0.00674966f, 0.01913122f, -0.02819394f, -0.03699046f, 
    -0.00891016f, -0.02991991f, -0.02068138f, -0.00415213f, -0.03749265f, -0.01608235f, -0.00597129f, -0.00337817f, 
    -0.01385374f, -0.00897112f, -0.03005222f, 0.00673306f, 0.02101715f, -0.03839384f, 0.00823677f, 0.01320357f, 
    0.00060904f, -0.01956951f, 0.01586479f, 0.02735298f, 0.01001675f, -0.02581861f, 0.02225135f, 0.02761899f, 
    -0.00908663f, -0.01793841f, 0.00787161f, -0.03384528f, -0.01347428f, -0.01241825f, -0.03829704f, 0.00197024f, 
    -0.02291817f, 0.02712140f, 0.00248790f, -0.03234775f, -0.01968577f, -0.03143413f, 0.02009763f, -0.02680140f, 
    0.01072648f, 0.02850775f, 0.02508985f, -0.04027993f, -0.02698651f, -0.01307461f, -0.01552730f, -0.02620597f, 
    -0.02116717f, -0.00616835f, 0.02866544f, 0.01100036f, -0.00396644f, -0.03293451f, -0.03797601f, 0.00492698f, 
    -0.04301691f, 0.01255625f, -0.01105552f, -0.02510703f, 0.01483504f, -0.00685757f, -0.02061011f, -0.01582092f, 
    -0.01165920f, -0.00623766f, -0.00991172f, -0.01793535f, -0.00326483f, 0.00822695f, 0.02221652f, -0.01762216f, 
    0.02214648f, 0.01008320f, -0.01818202f, -0.00979383f, -0.04264541f, 0.03210446f, 0.00834867f, -0.02725018f, 
    -0.00495962f, -0.00356972f, -0.00515092f, -0.02543432f, -0.00755602f, -0.01455955f, 0.00481623f, 0.00161108f, 
    0.03152716f, -0.04313947f, -0.03796953f, 0.01355959f, 0.01262944f, -0.04297576f, 0.01840536f, 0.01106114f, 
    0.00308762f, 0.01981025f, -0.01177374f, -0.03577600f, -0.00321544f, 0.00302380f, -0.01895734f, -0.01449437f, 
    -0.02430722f, 0.00718779f, 0.01401190f, 0.02099566f, -0.00445856f, -0.03252756f, 0.01966256f, -0.00860725f, 
    -0.01727023f, -0.01230049f, 0.01579427f, 0.00644345f, -0.04433497f, -0.00172097f, -0.00550367f, -0.01252604f, 
    -0.03804548f, 0.01900052f, 0.02646032f, -0.00874638f, 0.02729449f, 0.00736377f, -0.03632782f, 0.02349264f, 
    0.00307464f, 0.01333268f, 0.02461106f, -0.01707191f, -0.01333364f, 0.00421819f, -0.04240344f, -0.03679578f, 
    -0.00596818f, -0.03581046f, 0.02023564f, -0.00677855f, -0.01523366f, -0.03981273f, 0.01218724f, -0.03786617f, 
    -0.03965350f, 0.00753813f, -0.03731708f, 0.00774177f, -0.02182402f, -0.02446651f, -0.01581766f, -0.01447411f, 
    0.02308947f, 0.01908340f, -0.00835840f, -0.01818830f, -0.03755568f, 0.00333584f, -0.00164600f, -0.03243778f, 
    -0.02153106f, -0.02009845f, -0.02379929f, -0.00890481f, -0.00850173f, -0.04317014f, 0.01312501f, -0.04124453f, 
    0.02083655f, -0.00861729f, -0.03794060f, -0.04333475f, -0.00771189f, 0.01364376f, -0.02444016f, -0.02696891f, 
    -0.02535122f, -0.00966536f, 0.01205810f, 0.00221705f, 0.00307726f, -0.01185142f, -0.02117212f, -0.01039612f, 
    -0.00177877f, 0.02711818f, 0.01457620f, 0.00177031f, 0.02225271f, -0.01038236f, 0.00575568f, -0.02664603f, 
    -0.00620547f, -0.03982862f, 0.01490306f, -0.01786336f, 0.01435292f, 0.01320573f, 0.01206059f, 0.01738341f, 
    0.00206587f, 0.02657348f, -0.03988846f, -0.02351139f, -0.01863313f, 0.01545046f, -0.04001411f, 0.02615240f, 
    -0.02144838f, -0.04205475f, 0.01448754f, 0.01656009f, 0.01529912f, 0.01216166f, 0.01088602f, 0.00814147f, 
    -0.03082174f, 0.00192856f, -0.03508390f, 0.01541657f, 0.02765122f, 0.02695625f, 0.00182582f, 0.02135285f, 
    -0.01033991f, 0.01296654f, 0.01572669f, 0.01183657f, 0.00922693f, -0.03474688f, 0.00963540f, -0.01538704f, 
    -0.03938886f, -0.00077140f, -0.03080978f, 0.00084445f, 0.02042198f, 0.02897269f, 0.02041078f, 0.00615649f, 
    -0.03301084f, -0.01994495f, -0.01376031f, -0.19401966f, -0.08468886f, 0.06270750f, 0.03861406f, -0.03866344f, 
    0.05111495f, 0.06245052f, 0.09344379f, 0.20153366f, -0.10293360f, 0.04736254f, 0.03529881f, 0.05018854f, 
    0.15832776f, 0.05724115f, -0.06480397f, 0.08848657f, 0.00350039f, 0.09874261f, 0.00600268f, -0.08856627f, 
    0.02042510f, 0.09193302f, -0.10697042f, -0.22285463f, 0.04557336f, 0.09737134f, 0.06810860f, 0.00747818f, 
    -0.02595199f, -0.11969970f, -0.06954165f, 0.02330754f, 0.05381363f, -0.03775210f, -0.10092317f, 0.07982147f, 
    -0.08134803f, 0.11591246f, -0.06948163f, 0.09751877f, -0.15069985f, -0.04565033f, 0.08057788f, 0.12895635f, 
    0.12094325f, 0.12421815f, -0.12226945f, 0.01000938f, -0.07447234f, -0.01221892f, -0.06682738f, -0.01533524f, 
    0.01034378f, -0.08509491f, 0.04242997f, 0.06587508f, 0.27528766f, -0.03345249f, -0.08975306f, -0.06235052f, 
    0.08684272f, 0.04100217f, -0.08607483f, 0.00511944f, 0.07246137f, -0.09010597f, -0.04578710f, 0.02859554f, 
    0.04491462f, -0.00570644f, -0.07251699f, 0.05162176f, 0.06837571f, -0.00896005f, 0.03708827f, -0.03182466f, 
    0.00971248f, -0.14921162f, -0.06264023f, -0.02828171f, 0.09608066f, 0.03626851f, -0.07933794f, -0.01744356f, 
    -0.05502124f, 0.05478868f, -0.06442761f, 0.10894376f, -0.01346717f, 0.02667773f, 0.01650397f, -0.15008102f, 
    0.03313475f, 0.16813339f, -0.05012884f, -0.09802073f, 0.06331977f, -0.01404756f, 0.03336883f, -0.05309352f, 
    0.10404710f, 0.02305156f, -0.15338825f, -0.09630412f, 0.00963255f, -0.00718107f, 0.06137250f, -0.06853675f, 
    0.02736760f, 0.03033466f, 0.00081469f, 0.01573634f, -0.05732516f, -0.00536917f, -0.10063650f, -0.00689034f, 
    0.07260814f, -0.03782254f, 0.03073717f, -0.10416926f, -0.01456170f, -0.10943960f, -0.01276867f, -0.02759895f, 
    0.11216516f, 0.06505038f, 0.00145027f, 0.17594464f, -0.08422732f, 0.07341948f, 0.05221941f, -0.10530123f, 
    0.04806598f, 0.10350658f, 0.02647126f, -0.07451643f, -0.04024919f, 0.11607564f, -0.08230878f, 0.08514372f, 
    -0.22545014f, 0.01832776f, 0.04900080f, 0.20271072f, 0.10119202f, 0.00843601f, -0.02826811f, 0.06702638f, 
    0.01139346f, -0.00520475f, 0.05812614f, -0.07713748f, -0.17078233f, -0.10808820f, -0.12257786f, 0.00733476f, 
    -0.09287560f, -0.01716205f, -0.08604817f, 0.23703052f, -0.05444615f, 0.05288109f, 0.11655775f, 0.10317889f, 
    0.19345717f, -0.01978265f, -0.25212911f, -0.07156719f, 0.09213111f, 0.10460912f, 0.04165628f, 0.01819848f, 
    -0.10690369f, -0.03273068f, 0.05900856f, -0.00342095f, 0.00014148f, -0.06537871f, -0.03191943f, 0.12888825f, 
    -0.08028258f, -0.01234828f, -0.02478048f, -0.01560339f, 0.03168169f, -0.00886239f, 0.00980555f, 0.13543563f, 
    -0.01804119f, -0.00370522f, -0.03700957f, -0.02443787f, 0.09661565f, 0.02958918f, -0.13318074f, 0.00746394f, 
    -0.06030119f, 0.12265154f, 0.00637696f, 0.16350108f, -0.03644552f, -0.13289148f, -0.04723633f, -0.03480146f, 
    0.12629895f, 0.06003506f, 0.05434789f, -0.09093374f, 0.01248554f, 0.03839479f, 0.14142559f, 0.03296923f, 
    0.13466617f, -0.07848177f, 0.07764215f, 0.01976478f, -0.12555094f, -0.17944416f, 0.01296182f, 0.00725743f, 
    -0.02251719f, 0.02140914f, 0.02277785f, 0.00101864f, -0.20003532f, -0.01045559f, -0.00397146f, 0.00660298f, 
    0.09175216f, 0.01084769f, 0.08169710f, -0.02777612f, -0.01228722f, -0.07698862f, -0.09713572f, -0.02338122f, 
    0.23400132f, -0.10498808f, -0.07319614f, 0.07823836f, -0.01018063f, -0.08339768f, -0.07644620f, 0.07373104f, 
    0.14888985f, -0.05980136f, 0.15338239f, 0.14216390f, -0.05312389f, -0.13627486f, -0.05838414f, -0.03231057f, 
    -0.06282606f, 0.05992765f, 0.11102173f, 0.07278417f, 0.00090559f, -0.08070012f, 0.02242802f, -0.16759320f, 
    -0.14834236f, 0.04620384f, -0.01682199f, -0.21796128f, 0.04986094f, 0.02052975f, -0.08888141f, 0.11788413f, 
    -0.02759626f, 0.03214661f, 0.04058737f, 0.00614835f, -0.09622080f, -0.11940173f, -0.04983440f, 0.00347759f, 
    0.11412921f, -0.04757238f, 0.10026356f, 0.01319635f, -0.09141260f, 0.15020168f, 0.08185900f, -0.00087927f, 
    0.04811839f, 0.02050823f, -0.00396071f, -0.02045792f, 0.05165682f, 0.05604409f, -0.01910421f, -0.00328514f, 
    -0.00899738f, 0.00090954f, 0.01271335f, -0.08007103f, -0.03181746f, 0.05788917f, -0.14181904f, 0.12485432f, 
    -0.06886069f, 0.09491032f, 0.06591517f, 0.04950851f, -0.01252957f, 0.15853129f, -0.00702704f, -0.03771899f, 
    0.14127846f, 0.16377436f, -0.12587693f, -0.11030468f, 0.00534413f, -0.02492214f, 0.01443127f, 0.10158820f, 
    -0.05074162f, -0.06330040f, -0.00288878f, -0.03672955f, -0.23793428f, 0.12352314f, 0.16106632f, 0.10384918f, 
    0.01150101f, 0.03769419f, 0.13521296f, -0.00789552f, -0.04818004f, 0.06864112f, 0.07059176f, 0.06562220f, 
    0.05940168f, -0.18389675f, 0.02590158f, 0.06395295f, -0.00024162f, 0.04954487f, 0.04544375f, 0.01633027f, 
    0.10828799f, -0.06173788f, 0.10740133f, -0.08931959f, 0.10614967f, 0.19862407f, 0.10287926f, -0.01198907f, 
    0.02838087f, 0.10461904f, 0.01119276f, 0.03833326f, -0.05659301f, 0.25430489f, 0.04699614f, -0.07318089f, 
    -0.00964202f, 0.04493836f, 0.08721753f, 0.11907732f, 0.04425393f, 0.00110619f, -0.05134191f, 0.07431724f, 
    0.02347776f, -0.08643921f, -0.03757691f, -0.10451289f, -0.24181826f, -0.11828240f, 0.02564226f, 0.01045045f, 
    0.09414389f, 0.11701130f, -0.05959297f, 0.01808814f, -0.01206477f, -0.02227664f, 0.00943004f, 0.02322152f, 
    0.06652267f, -0.03906205f, 0.07369632f, 0.03413181f, 0.02784061f, 0.00286451f, -0.03766043f, -0.05650450f, 
    0.08609104f, -0.09025581f, -0.08011199f, 0.00345174f, -0.24733204f, 0.16767095f, -0.11999809f, -0.07693671f, 
    0.13764162f, 0.04951781f, 0.13526654f, -0.01801699f, -0.08152819f, -0.06848792f, 0.02065822f, 0.07184891f, 
    0.02110534f, 0.00467189f, -0.06118090f, -0.23630361f, -0.02062306f, 0.02862574f, 0.00530213f, 0.06886348f, 
    0.08420367f, 0.05564639f, -0.08701020f, -0.01983648f, 0.08212923f, -0.03402701f, 0.09017818f, 0.03949925f, 
    0.00974906f, -0.07194895f, -0.05866100f, -0.02437764f, 0.07651108f, 0.01799137f, 0.11421865f, 0.10033701f, 
    0.18348712f, 0.03792695f, -0.08709973f, 0.08516653f, -0.02024194f, 0.00922116f, 0.05549083f, -0.02419570f, 
    0.03979509f, 0.03032332f, -0.01395320f, -0.00875062f, 0.05011027f, 0.04320072f, 0.02952442f, 0.14075215f, 
    0.12173469f, 0.14601344f, 0.03831168f, -0.07778419f, 0.00086319f, 0.02342124f, -0.01973343f, 0.06877204f, 
    -0.03052854f, 0.01656896f, -0.00821565f, -0.13765946f, -0.02762372f, 0.15372814f, -0.12729424f, 0.08968008f, 
    -0.05418580f, -0.01343505f, -0.00558891f, 0.06065871f, -0.15271319f, 0.01831234f, -0.02997555f, -0.21345918f, 
    0.00287002f, -0.02201786f, -0.04821989f, -0.00895648f, 0.01284323f, -0.00142934f, -0.00716050f, -0.04059505f, 
    0.00448186f, -0.06238702f, 0.06327854f, 0.07956360f, -0.00900603f, 0.01554296f, -0.04391855f, 0.02545457f, 
    -0.05175419f, -0.00514763f, 0.06870970f, -0.06008995f, -0.05679785f, 0.11567233f, 0.06151667f, -0.12341397f, 
    -0.03954040f, -0.05022194f, -0.01575959f, 0.01982488f, 0.05765843f, 0.06742370f, -0.13103551f, -0.04252821f, 
    0.07150807f, -0.01355293f, -0.05649291f, 0.16629705f, 0.03726710f, 0.05179279f, -0.01664443f, 0.13246861f, 
    0.09188213f, 0.01479535f, 0.11831395f, -0.05836666f, 0.16135870f, 0.01703286f, 0.04151000f, 0.09732220f, 
    0.03249187f, -0.12250659f, 0.00829533f, -0.04353541f, -0.02039173f, 0.03304677f, 0.08881693f, 0.14479646f, 
    0.15540040f, -0.04523800f, 0.00199772f, 0.18266962f, -0.07535224f, -0.00292772f, 0.03895818f, -0.05386697f, 
    -0.04669970f, 0.09743227f, -0.06261957f, 0.02849302f, 0.02441170f, -0.06777097f, 0.01750018f, -0.06023373f, 
    -0.06793956f, -0.01252364f, 0.06908211f, -0.01318230f, 0.10456143f, 0.10340890f, 0.08847360f, -0.13500787f, 
    0.08241192f, -0.01456745f, 0.03348590f, 0.13621308f, -0.10128833f, 0.02823981f, 0.02356600f, 0.07467975f, 
    0.04579432f, -0.02115429f, -0.08073818f, 0.13220447f, 0.16532654f, -0.10829882f, -0.06800652f, 0.07296545f, 
    -0.00123987f, 0.14018250f, -0.04901600f, -0.03688570f, 0.01157498f, -0.05180028f, -0.14414231f, 0.03507418f, 
    0.10362680f, 0.00053087f, -0.00508296f, -0.08533943f, -0.07739168f, -0.01625964f, 0.07902965f, 0.16631523f, 
    0.01832524f, -0.00063917f, -0.06911842f, 0.10308208f, 0.16160777f, -0.05111492f, -0.12918448f, -0.00094960f, 
    0.00116208f, 0.01878207f, -0.03115347f, 0.08551595f, 0.02930077f, -0.12631823f, 0.11168863f, -0.02357312f, 
    0.19123282f, 0.04512684f, 0.06104510f, -0.17345497f, 0.08433776f, 0.01507046f, -0.00303935f, 0.02628581f, 
    -0.09644084f, 0.05044571f, -0.01872598f, -0.02936621f, -0.00895997f, 0.04718840f, -0.04639133f, -0.11790637f, 
    0.02008618f, -0.04991065f, 0.00767949f, -0.14772929f, 0.01754252f, 0.03338810f, 0.07591239f, 0.10883550f, 
    -0.00634441f, -0.03124914f, -0.01595541f, 0.00886244f, -0.14019282f, -0.02538280f, 0.14623144f, 0.08337265f, 
    -0.18207873f, 0.15570718f, -0.03159907f, 0.06451822f, 0.02774994f, 0.17150174f, -0.11459603f, 0.10841959f, 
    0.02195448f, 0.07264327f, 0.06529678f, 0.01012504f, 0.15704645f, -0.00521969f, -0.01459688f, -0.06884547f, 
    -0.03304048f, 0.05052412f, 0.02480557f, 0.12916842f, -0.04889630f, 0.02748710f, 0.01588484f, -0.02120322f, 
    0.00494142f, -0.00808972f, 0.13010077f, 0.06899285f, -0.43991855f, -0.05480070f, -0.02909668f, 0.02941015f, 
    0.00101633f, 0.12398724f, 0.16693869f, 0.08901215f, 0.12146191f, -0.07329942f, 0.17926428f, 0.05027606f, 
    -0.11085835f, 0.10903143f, -0.08074097f, 0.00748999f, 0.04075608f, -0.07313140f, -0.05886058f, -0.02571201f, 
    0.14111692f, 0.05144343f, 0.10359734f, 0.00725360f, 0.07874709f, -0.04868269f, -0.03493769f, -0.13959225f, 
    -0.02903432f, 0.00225529f, 0.04313285f, 0.04963890f, -0.00848363f, -0.09603694f, 0.02908158f, -0.16416074f, 
    0.15915085f, -0.14614418f, 0.13788812f, -0.00193990f, -0.01594028f, 0.03728401f, 0.00077854f, -0.03536032f, 
    0.00878777f, 0.12911429f, -0.06789419f, -0.08784019f, -0.06111952f, 0.18718609f, 0.08493569f, 0.17004804f, 
    0.03488136f, -0.00054062f, 0.01875928f, 0.06683980f, 0.04250248f, 0.02878914f, 0.04089753f, -0.11231441f, 
    0.13615511f, 0.00206774f, -0.00386418f, 0.06101088f, -0.02697521f, -0.07429977f, 0.08481093f, 0.08486401f, 
    0.04151588f, 0.07202628f, 0.06918016f, 0.03922315f, 0.06396914f, 0.02539410f, 0.02064820f, -0.12884253f, 
    -0.00839625f, -0.00206819f, 0.03554699f, -0.00682234f, -0.00606856f, -0.15266384f, 0.04761856f, 0.03956756f, 
    -0.01887042f, -0.08766284f, 0.18134591f, 0.07002763f, 0.01068010f, 0.02926093f, -0.04273588f, -0.06129641f, 
    -0.02715057f, -0.01453258f, -0.05375818f, -0.08141167f, 0.05615698f, 0.15678003f, -0.06185235f, 0.10512627f, 
    0.03040233f, 0.01441098f, 0.11000171f, 0.17472145f, -0.03758897f, 0.05087429f, 0.06946521f, 0.00085049f, 
    0.00614744f, -0.00796484f, -0.00141219f, 0.03764403f, -0.02001901f, -0.02579702f, 0.02861068f, -0.01737767f, 
    -0.01398591f, -0.01461549f, -0.00890118f, 0.01836091f, -0.02481101f, 0.02493874f, -0.03770555f, -0.00576108f, 
    -0.02399824f, -0.01061118f, -0.01444688f, 0.00182029f, -0.02814221f, -0.03001616f, -0.02682332f, 0.02146660f, 
    -0.01545219f, -0.02550405f, 0.03085686f, -0.02080844f, 0.01933235f, 0.00578452f, -0.00373179f, -0.03051969f, 
    -0.02690976f, -0.01204344f, 0.02565321f, -0.01629292f, 0.00212017f, 0.01330194f, 0.02158274f, -0.00660546f, 
    0.01323504f, -0.02397961f, -0.01148451f, -0.02285638f, 0.01334507f, 0.01925312f, -0.01763011f, -0.01808050f, 
    -0.00472219f, -0.01751512f, -0.01105977f, 0.01995028f, 0.02829119f, -0.01555089f, -0.02021140f, 0.02555316f, 
    0.01056783f, -0.03297861f, -0.00099976f, 0.02236200f, 0.02428727f, 0.00971972f, 0.01415507f, -0.01163049f, 
    -0.04192803f, -0.03135690f, 0.02250900f, -0.01696916f, 0.02223963f, 0.01562257f, 0.02310187f, 0.01017450f, 
    -0.00351542f, 0.00724475f, -0.03847168f, 0.02276286f, 0.02320126f, -0.01892962f, -0.02998609f, -0.02412848f, 
    0.02596555f, 0.03078835f, -0.02667237f, -0.01013561f, -0.03264348f, -0.02482107f, -0.02726984f, -0.02629219f, 
    -0.03710881f, 0.03528958f, -0.02964797f, -0.02213145f, -0.03804771f, -0.00038739f, -0.02443774f, -0.01091670f, 
    -0.02569700f, 0.01152010f, -0.02332122f, -0.00535147f, 0.02537083f, -0.01287460f, 0.02035574f, -0.03272716f, 
    0.01632851f, -0.04354792f, -0.01563793f, 0.01905927f, -0.03789133f, 0.02871917f, -0.01852139f, -0.01586230f, 
    -0.01885929f, -0.04198849f, 0.01828439f, 0.02749967f, -0.00761756f, -0.00065212f, 0.01233087f, 0.01145672f, 
    -0.00383565f, -0.03240484f, 0.01316014f, -0.00062226f, -0.02538840f, -0.00760166f, 0.00472452f, -0.01810737f, 
    0.03073934f, -0.02743133f, -0.00643104f, -0.01390590f, 0.01046691f, -0.00133552f, -0.02357722f, -0.03698343f, 
    -0.03479059f, -0.01813674f, 0.02593761f, 0.01225037f, 0.01198208f, 0.01908937f, -0.02955060f, 0.00627808f, 
    0.02456751f, 0.00225024f, -0.00571314f, -0.03616353f, -0.03949722f, -0.00177974f, 0.00943848f, -0.02860885f, 
    -0.02974829f, 0.03295239f, 0.02002759f, -0.03715039f, -0.01608676f, -0.01868550f, -0.03451693f, 0.02234063f, 
    -0.02586163f, 0.00314240f, 0.02436992f, 0.02496953f, -0.01521206f, 0.01609996f, -0.03032084f, -0.00223149f, 
    0.02127959f, -0.00645478f, -0.00074229f, -0.00738185f, 0.02296099f, -0.01034244f, -0.00709393f, -0.03255501f, 
    0.00506856f, 0.01532973f, 0.02041927f, 0.01738397f, 0.01931708f, -0.02507354f, -0.00208547f, 0.03876474f, 
    0.02285236f, -0.00506639f, -0.00748403f, 0.03306354f, -0.01212076f, 0.02744291f, 0.01592227f, -0.03093235f, 
    0.02362786f, -0.01984896f, -0.03121828f, -0.01089491f, 0.01367873f, -0.04060235f, 0.00635134f, -0.01047992f, 
    -0.00915727f, 0.00465930f, -0.01631777f, -0.00511271f, 0.04023269f, 0.00059898f, -0.03806332f, 0.00141375f, 
    -0.03232944f, 0.02901856f, -0.01991968f, -0.03251534f, 0.03356232f, -0.03453158f, -0.01638497f, 0.02241119f, 
    0.00356082f, -0.03658788f, 0.00740473f, -0.01536495f, -0.02104909f, -0.00634778f, 0.02360710f, -0.00753624f, 
    -0.01180670f, -0.01269568f, 0.00441232f, -0.04203556f, 0.03082301f, -0.01065993f, 0.00022825f, -0.01269637f, 
    -0.04131367f, -0.00831082f, -0.01555453f, 0.01177050f, -0.01295639f, -0.00755668f, 0.00063612f, -0.02580131f, 
    0.03356062f, -0.02520358f, -0.03906694f, 0.01230360f, -0.00488763f, -0.03904591f, -0.00697659f, -0.02160615f, 
    0.01107692f, -0.02228297f, -0.01127713f, 0.00328943f, 0.02045910f, 0.04184826f, 0.01750337f, -0.00016840f, 
    0.02803930f, -0.00249279f, 0.01429516f, -0.04471967f, 0.00003393f, 0.02696134f, -0.00769634f, 0.02998384f, 
    0.03750011f, -0.00306969f, -0.01753554f, -0.03057770f, -0.01981705f, -0.00326221f, 0.02198962f, -0.01158405f, 
    0.02241723f, -0.00727676f, 0.02738606f, 0.01606343f, 0.02651149f, 0.02398625f, 0.02488886f, -0.03548788f, 
    -0.02439969f, 0.01622662f, -0.01324529f, -0.00801533f, -0.00776483f, 0.03746067f, 0.01496776f, -0.02273379f, 
    -0.02867261f, -0.00659768f, 0.00837587f, -0.01218128f, -0.01285974f, -0.03069854f, -0.01707612f, 0.02651958f, 
    0.01480633f, -0.02183215f, -0.01866753f, 0.03779231f, -0.02485794f, 0.01984216f, 0.00058553f, -0.01906145f, 
    0.02263860f, 0.00194475f, -0.03040190f, 0.01966391f, 0.02629867f, -0.01519506f, 0.00538522f, -0.00296614f, 
    0.00824609f, -0.03438241f, 0.03626455f, 0.01254208f, 0.01343287f, 0.02940037f, 0.02596941f, 0.01611675f, 
    0.02247688f, -0.00469123f, 0.03049806f, 0.00933597f, -0.02415404f, -0.03676127f, 0.00143501f, -0.03341756f, 
    0.00737851f, -0.03776589f, -0.03018477f, -0.03600845f, 0.03549109f, -0.00032465f, -0.01722340f, -0.03262121f, 
    -0.01785763f, 0.02292625f, 0.00808237f, -0.01955917f, -0.00988562f, 0.00063165f, 0.01710906f, 0.00880037f, 
    0.00834459f, 0.01437433f, -0.00837205f, -0.03704753f, -0.00355564f, 0.00501526f, 0.02944648f, -0.02902135f, 
    -0.00499150f, -0.02193890f, -0.03515484f, 0.01400446f, -0.00506408f, -0.00675844f, -0.03711929f, 0.02794910f, 
    -0.01313781f, -0.00094223f, -0.01169905f, 0.01071347f, 0.01611833f, -0.03810079f, -0.00094220f, -0.01566654f, 
    -0.00471684f, -0.00845870f, 0.02077513f, 0.01890500f, -0.03052143f, 0.00277073f, 0.02714810f, 0.00571401f, 
    0.02080011f, 0.00523579f, -0.02681389f, 0.01436314f, -0.01159993f, -0.01862633f, -0.00253680f, 0.03785875f, 
    -0.01739190f, -0.03209785f, 0.02451518f, 0.00671059f, -0.00200091f, -0.02633316f, -0.01877656f, -0.02705681f, 
    0.01791819f, 0.01624708f, 0.01729386f, -0.04328316f, -0.02383357f, -0.02958821f, -0.02887763f, -0.00448365f, 
    -0.00026212f, -0.02198933f, 0.02383936f, 0.01325988f, 0.02068003f, 0.02095710f, 0.00054855f, -0.02150830f, 
    0.01320301f, -0.01314287f, -0.02226202f, 0.00253275f, -0.04355036f, -0.01331914f, 0.01356280f, -0.00382138f, 
    -0.01643895f, -0.02356110f, -0.00225002f, 0.03176177f, -0.00201614f, 0.01878262f, 0.00554115f, -0.01340542f, 
    0.01469676f, -0.00329524f, -0.00728174f, 0.00248683f, 0.01829654f, -0.00890970f, -0.02191485f, 0.01269368f, 
    -0.03292094f, 0.02282088f, -0.00817240f, 0.01011982f, 0.01010347f, 0.01197295f, -0.00332444f, 0.00025702f, 
    -0.02284470f, 0.01007789f, 0.01249936f, 0.01218443f, -0.01717871f, 0.00897407f, -0.03798744f, 0.03516519f, 
    -0.02548537f, -0.02293452f, 0.00031473f, -0.03675009f, -0.03032547f, 0.00046443f, 0.01837832f, -0.03898891f, 
    0.02142908f, 0.00573275f, -0.02700599f, 0.00772358f, -0.04425081f, -0.02817849f, 0.00518303f, -0.03471712f, 
    -0.03516964f, -0.00860707f, 0.01523146f, -0.02757982f, -0.00202905f, -0.03030119f, 0.02755205f, 0.01005694f, 
    -0.03389486f, -0.03162831f, -0.04366437f, 0.02135905f, 0.00722846f, -0.00854223f, -0.01555698f, -0.01533053f, 
    0.01040929f, -0.02544580f, -0.02963285f, 0.00013441f, 0.00655594f, 0.02818589f, 0.01964239f, -0.00614255f, 
    0.00296139f, 0.02502606f, -0.01977676f, 0.01399542f, -0.02991444f, -0.02158658f, -0.01597049f, 0.02250778f, 
    -0.02577085f, 0.01702467f, 0.02927074f, 0.01498241f, 0.00465142f, 0.01292939f, 0.02669831f, -0.03176448f, 
    -0.00270160f, -0.03808191f, -0.01538432f, -0.02987005f, -0.02057196f, -0.00866832f, -0.00578518f, -0.04222983f, 
    0.01978661f, 0.00036364f, 0.02450401f, -0.01236274f, -0.03213734f, 0.00558647f, 0.01992482f, -0.03588299f, 
    -0.01493051f, 0.00530690f, -0.03651898f, -0.00689281f, -0.02631610f, -0.02119309f, -0.00168992f, 0.01976350f, 
    -0.02606785f, -0.03788945f, -0.02373103f, 0.00793291f, 0.01467935f, 0.02328960f, -0.00178674f, 0.01397501f, 
    0.01872530f, 0.03471531f, -0.03666489f, 0.01356065f, -0.01543766f, -0.04525884f, -0.03853463f, 0.00800054f, 
    0.02537370f, -0.01018718f, -0.04506682f, 0.01632240f, -0.02257201f, 0.02059702f, -0.01463232f, -0.02069276f, 
    -0.02479324f, 0.01548704f, -0.01057770f, -0.01745717f, -0.03217091f, -0.03718601f, 0.00887438f, 0.00652951f, 
    0.03143788f, -0.01621215f, -0.01932471f, 0.01632880f, 0.00553741f, 0.01387520f, 0.00011341f, 0.00548745f, 
    0.02109046f, -0.03477889f, -0.03224593f, -0.00269871f, -0.03170215f, 0.02941445f, -0.02211531f, -0.01577509f, 
    -0.03666745f, 0.02820160f, 0.02341728f, 0.00128237f, -0.00669408f, 0.01071639f, 0.01174221f, 0.01926233f, 
    -0.02996403f, -0.00971048f, -0.02675973f, -0.00044158f, -0.02617982f, -0.03553084f, 0.01989852f, -0.01182765f, 
    -0.04270633f, 0.00006901f, -0.02164903f, 0.00705607f, -0.00882720f, 0.00587803f, -0.00389778f, 0.01986342f, 
    0.00369178f, -0.02034003f, -0.03094625f, -0.01385060f, 0.01742007f, 0.00248957f, -0.00600729f, 0.00011604f, 
    0.02437692f, 0.02828392f, 0.00476815f, 0.00478591f, 0.00864044f, -0.00661362f, -0.01740548f, 0.01569178f, 
    0.01723095f, -0.01699407f, 0.01305820f, -0.00337050f, -0.02611466f, -0.00957357f, -0.00314125f, -0.04182895f, 
    -0.03744636f, -0.01829077f, -0.02611151f, 0.02586190f, -0.00879472f, 0.01364397f, -0.01412646f, 0.00120812f, 
    -0.01457380f, -0.01830912f, -0.01491208f, -0.00292763f, -0.04488721f, -0.01520950f, -0.01736316f, 0.00746660f, 
    -0.01756489f, 0.00559767f, 0.00979939f, -0.00586158f, -0.01178173f, 0.02011486f, -0.00205958f, 0.01767557f, 
    -0.01168525f, 0.00774987f, -0.02776980f, 0.00237749f, 0.03198013f, -0.00477660f, 0.02561424f, 0.00454123f, 
    -0.03503476f, -0.03607731f, 0.03235143f, -0.02613276f, 0.00295863f, 0.01845734f, -0.02449518f, -0.01395060f, 
    0.00509093f, -0.02182831f, -0.00837949f, -0.02918078f, -0.00961037f, 0.01797907f, -0.00533489f, -0.02471071f, 
    0.00964906f, 0.01003081f, -0.03525575f, -0.00483606f, -0.02899935f, 0.02089975f, -0.02645829f, 0.01093336f, 
    0.00463384f, -0.02861684f, -0.01005048f, -0.03813801f, 0.01949905f, -0.02910526f, 0.01759471f, -0.01018107f, 
    0.02686081f, -0.01643559f, -0.00072885f, -0.04249026f, -0.00510427f, 0.01269641f, 0.02598312f, -0.03777406f, 
    -0.01203608f, 0.01763986f, 0.02204682f, -0.01126860f, 0.01790957f, 0.00843440f, -0.01752074f, -0.02616197f, 
    0.01627923f, -0.03176154f, -0.00030456f, -0.00502117f, -0.02685049f, -0.00335254f, -0.02819230f, -0.02867746f, 
    0.01746596f, 0.00940787f, -0.03587759f, -0.03803874f, 0.02577112f, -0.04538397f, 0.01264439f, -0.01750100f, 
    0.02983803f, 0.01737997f, 0.00619882f, -0.01557217f, -0.01967328f, 0.01892484f, 0.00586707f, -0.01127396f, 
    -0.02508235f, 0.01322101f, -0.02688349f, -0.02210141f, -0.02609991f, -0.02616453f, 0.01651352f, -0.02066180f, 
    -0.01285945f, -0.01503327f, 0.02566730f, -0.03082713f, -0.01548102f, 0.01733929f, -0.01173314f, -0.04118477f, 
    0.02160376f, 0.01903157f, -0.00035102f, 0.00967241f, 0.00257633f, -0.02726212f, -0.00587479f, -0.00177671f, 
    -0.01749872f, 0.01525967f, 0.00829699f, -0.02996629f, 0.01442588f, 0.00171955f, 0.00800140f, -0.02890683f, 
    -0.02638973f, -0.03399187f, 0.01928204f, 0.01309978f, 0.02547119f, 0.01061940f, 0.02207130f, -0.00724348f, 
    0.00289793f, 0.01770371f, -0.00915986f, -0.00069706f, -0.04118415f, -0.03460665f, -0.00851896f, 0.00594722f, 
    0.00596882f, -0.01402924f, 0.02065829f, -0.00302015f, 0.02518912f, -0.01311807f, -0.04342301f, -0.00702461f, 
    -0.03205320f, 0.00081245f, -0.02811082f, 0.01214285f, 0.01961724f, -0.03987503f, 0.00568765f, -0.00342660f, 
    -0.01070110f, 0.02925246f, 0.00955791f, 0.02661098f, -0.01864887f, 0.02662314f, -0.04181576f, -0.04323786f, 
    -0.02989486f, -0.03375978f, 0.01758102f, -0.00419653f, 0.02522512f, -0.01763187f, -0.02091049f, -0.00489435f, 
    -0.03642694f, -0.01559910f, -0.03218690f, -0.03648918f, -0.04384983f, -0.00546966f, 0.00256130f, -0.03700379f, 
    -0.01712997f, 0.01606085f, 0.02644533f, 0.00294901f, -0.00890408f, 0.01488709f, -0.00350402f, -0.00453638f, 
    -0.01613919f, -0.00390618f, -0.00450377f, 0.00166265f, -0.01085275f, 0.00379509f, -0.00262784f, -0.00029706f, 
    0.02122956f, -0.04019187f, 0.02054141f, -0.03517862f, -0.01590158f, -0.02857313f, 0.00824717f, -0.02277314f, 
    0.02596597f, -0.02940271f, 0.00264880f, 0.02133019f, 0.01132513f, 0.02167735f, 0.02635210f, -0.01685184f, 
    0.00506007f, 0.02644877f, -0.02005018f, -0.00144355f, -0.03108243f, -0.00334656f, 0.01299976f, -0.03659211f, 
    0.02756249f, -0.03924847f, -0.02405992f, 0.01484124f, 0.00787532f, -0.03831746f, -0.01217054f, -0.04314464f, 
    0.01132969f, -0.01358157f, -0.04194160f, -0.01834474f, 0.00274531f, 0.01585978f, -0.01869908f, -0.01383876f, 
    -0.01471673f, -0.01759564f, 0.00560069f, -0.02142279f, -0.00529812f, -0.01334212f, -0.02474219f, -0.00088029f, 
    0.01741747f, 0.01085496f, -0.01642643f, -0.01176661f, 0.02288166f, 0.01768810f, -0.02692407f, -0.02251704f, 
    -0.00663377f, -0.01510970f, 0.00911532f, 0.02756606f, 0.00228395f, 0.02375095f, 0.01445308f, -0.01608563f, 
    -0.03782032f, -0.04431284f, 0.00967778f, 0.02074095f, 0.01928745f, 0.02642946f, -0.00804567f, -0.04360623f, 
    0.01840862f, -0.02923276f, -0.04176867f, 0.02384420f, 0.00052782f, 0.00323881f, -0.03554281f, 0.00497040f, 
    0.02579424f, -0.03342415f, 0.00095173f, -0.03581477f, 0.01429286f, -0.01745994f, -0.02846760f, -0.03102124f, 
    -0.02632868f, -0.00665932f, -0.03525263f, -0.03383612f, 0.01066368f, -0.02883543f, 0.02549416f, 0.00823648f, 
    -0.03298477f, -0.03798141f, -0.02822407f, 0.00332525f, 0.02627644f, 0.02498025f, 0.01267296f, -0.02971639f, 
    -0.01858809f, 0.00835288f, 0.00618586f, -0.00079809f, 0.01487951f, 0.02247551f, -0.00236147f, -0.01972655f, 
    -0.02466732f, 0.02672789f, -0.02082149f, 0.00840107f, 0.02204701f, -0.03375548f, -0.01081610f, 0.01850405f, 
    -0.03422384f, -0.02551412f, 0.02230380f, -0.03776840f, -0.00251100f, -0.00465192f, -0.02298897f, -0.03223780f, 
    -0.00368606f, -0.04241458f, 0.02548783f, 0.00409527f, 0.00374063f, 0.02409458f, -0.02777871f, -0.01496313f, 
    -0.02207143f, -0.02424763f, -0.00363868f, -0.01872990f, -0.04071753f, 0.00752916f, -0.02598216f, -0.03435232f, 
    -0.01652261f, 0.01080066f, -0.02799727f, -0.00929180f, -0.03128352f, -0.01145105f, -0.01432785f, 0.00221811f, 
    -0.00617280f, -0.03975618f, -0.00698420f, -0.02076559f, 0.00899368f, -0.02004581f, 0.01314280f, -0.01719783f, 
    0.02549073f, 0.01562553f, -0.01781296f, -0.01640479f, -0.01107025f, -0.01984875f, 0.02466140f, 0.02260818f, 
    -0.00895336f, 0.02722967f, 0.00317957f, -0.00072275f, -0.01075761f, 0.00565636f, 0.02009152f, 0.02284309f, 
    -0.02558453f, 0.01198299f, -0.03468947f, -0.02428907f, 0.02722902f, 0.00724821f, -0.02049157f, -0.03772484f, 
    0.02073844f, -0.00696175f, 0.00801311f, 0.01951325f, 0.00051361f, -0.03983425f, -0.01405636f, 0.00992956f, 
    -0.03940053f, -0.01641302f, -0.03299437f, -0.00331499f, -0.04064014f, 0.01629534f, -0.02634802f, -0.04099610f, 
    0.00120441f, -0.02420113f, -0.00526065f, 0.00278094f, 0.00669086f, -0.02143171f, -0.04021755f, -0.04166042f, 
    -0.00419419f, -0.00125659f, 0.02552000f, -0.03721211f, -0.02590461f, 0.00187204f, 0.01243583f, -0.02298721f, 
    0.01265264f, -0.03016637f, 0.01648734f, -0.02274689f, -0.00502191f, 0.02502867f, -0.01489598f, -0.02440088f, 
    0.00786165f, -0.03137982f, -0.00793842f, 0.01559500f, -0.03901442f, -0.02437505f, -0.03567702f, 0.00082439f, 
    -0.02860469f, -0.01072595f, 0.00656763f, -0.01044551f, 0.01253722f, -0.00035878f, -0.02850355f, -0.00279421f, 
    0.01554650f, 0.01567069f, -0.02436721f, -0.01403213f, 0.01166706f, 0.02078131f, -0.00791147f, 0.02620621f, 
    -0.02082069f, -0.01680219f, -0.02956018f, 0.00765125f, 0.00790455f, -0.02624728f, 0.00423407f, -0.01879901f, 
    -0.03231987f, -0.00934966f, -0.01716814f, -0.01192216f, 0.01889490f, -0.00329488f, -0.01168018f, 0.01585316f, 
    -0.03721232f, -0.03986890f, -0.01907600f, -0.01500715f, -0.00182149f, 0.01723076f, -0.03513698f, -0.02422173f, 
    0.02172056f, 0.02711602f, -0.02690164f, 0.01785522f, -0.00507079f, 0.01390389f, 0.00107717f, 0.00251524f, 
    -0.02503453f, 0.01140389f, 0.00279625f, -0.03355623f, 0.02355650f, -0.01812405f, -0.03543517f, -0.03793418f, 
    0.00126064f, -0.00594907f, -0.03482275f, -0.03292698f, -0.03226374f, -0.02360500f, -0.02895242f, 0.00455957f, 
    -0.00918115f, 0.00572108f, 0.01336956f, 0.00215567f, -0.00566311f, 0.02075546f, 0.00476619f, -0.00032847f, 
    -0.01927024f, -0.03722280f, -0.03000544f, -0.02821164f, -0.01638132f, -0.01688800f, 0.02809155f, -0.02295497f, 
    -0.00388932f, -0.00124995f, 0.01153399f, -0.01953952f, -0.04322745f, 0.02637045f, 0.01799279f, -0.04522315f, 
    0.02587231f, -0.03649211f, -0.01085994f, -0.01685249f, -0.01464230f, -0.02761019f, -0.01659444f, 0.01305375f, 
    -0.04249252f, 0.00827863f, -0.03690923f, 0.00249561f, 0.02040310f, 0.00031174f, 0.01930383f, -0.01866578f, 
    0.02521935f, -0.03053996f, -0.00900447f, -0.02752378f, 0.00730337f, 0.00565153f, 0.02067604f, -0.02928017f, 
    -0.03615762f, -0.02161541f, 0.00082996f, 0.02078652f, -0.03231802f, -0.03441691f, 0.01694359f, 0.00099682f, 
    0.02229007f, 0.01764302f, 0.00423253f, -0.01984760f, -0.00483207f, -0.04022554f, -0.03997793f, -0.01230872f, 
    0.01765132f, -0.00292527f, -0.01876465f, -0.02194259f, -0.01399494f, 0.00544802f, -0.02780562f, -0.00319932f, 
    0.02295405f, 0.01569323f, -0.04151186f, 0.02539738f, 0.00995670f, 0.00565147f, -0.03232465f, 0.01726476f, 
    -0.02228702f, 0.02604664f, 0.01878184f, 0.01400344f, 0.02018165f, 0.01804003f, -0.03386153f, -0.01184688f, 
    0.00663072f, -0.01851667f, 0.02427180f, -0.00007941f, -0.03553079f, 0.02723746f, -0.04073364f, -0.01823285f, 
    -0.02768888f, 0.00339689f, 0.00592531f, 0.00185123f, 0.02202865f, -0.02023630f, 0.01660175f, 0.01000427f, 
    0.01115395f, -0.00900919f, -0.01406652f, -0.03070290f, -0.00713031f, 0.00887133f, -0.02472920f, -0.03569102f, 
    -0.02349641f, -0.02708730f, 0.00279887f, -0.01980531f, -0.02018600f, -0.04190305f, 0.02011147f, -0.01384521f, 
    0.01788354f, -0.02265253f, -0.01076073f, 0.01812047f, 0.00234673f, -0.03788025f, -0.02721928f, -0.00258169f, 
    0.02051574f, 0.02087164f, -0.04092855f, -0.01078464f, -0.00331240f, 0.02753156f, -0.02127555f, 0.01368195f, 
    0.00202191f, -0.00149308f, -0.03603551f, 0.00264859f, 0.02461132f, 0.02854230f, 0.01231353f, -0.03975812f, 
    -0.01851788f, 0.02555658f, 0.01925809f, 0.02766621f, 0.00694474f, -0.03642510f, 0.00949475f, -0.02585573f, 
    -0.00044342f, 0.01498024f, -0.01319536f, -0.04055458f, -0.01947157f, 0.02835962f, -0.01610527f, 0.01953363f, 
    0.02265591f, -0.00473413f, 0.02255382f, -0.00404824f, 0.01438143f, -0.02112376f, -0.02947340f, -0.04364011f, 
    -0.03244206f, -0.00445812f, -0.01263328f, -0.04243373f, 0.00814168f, -0.00174546f, -0.03763013f, -0.03919721f, 
    0.02568043f, -0.02167188f, -0.01194723f, -0.01398046f, -0.02156904f, -0.03498923f, -0.03379580f, 0.01609795f, 
    -0.00255658f, -0.02957636f, 0.00063439f, -0.01699004f, 0.01163784f, 0.00933309f, -0.00909973f, -0.01475471f, 
    0.01397572f, -0.01795601f, -0.02088846f, 0.01079014f, -0.01424988f, 0.00479540f, -0.00143796f, 0.02262043f, 
    -0.01424705f, 0.01865090f, -0.02452784f, -0.03025763f, -0.01854647f, -0.01615521f, -0.01379258f, -0.00209442f, 
    0.01837881f, -0.04332821f, 0.00528173f, -0.00633470f, -0.00949794f, 0.00364205f, -0.04191391f, -0.00221125f, 
    -0.04359129f, -0.04038592f, 0.01382704f, -0.01439719f, -0.01275613f, -0.03606905f, -0.00572978f, 0.02682371f, 
    -0.00131662f, -0.02288944f, -0.04130456f, 0.02553177f, -0.03280120f, -0.01371139f, 0.00002837f, -0.02025310f, 
    -0.01603019f, -0.00762609f, 0.00988086f, -0.00033967f, -0.02115215f, 0.01041733f, 0.00436342f, 0.00762838f, 
    -0.03801319f, -0.01024478f, -0.03419239f, -0.02839349f, -0.03884430f, 0.02277001f, 0.02563581f, 0.01587816f, 
    0.01065979f, 0.00306814f, -0.01207852f, -0.01213537f, -0.02267829f, 0.00475269f, 0.02877275f, -0.03820886f, 
    -0.03377036f, -0.04165636f, 0.00427938f, -0.04397596f, -0.03472823f, -0.01624802f, 0.01514389f, -0.00578373f, 
    -0.02915474f, -0.01184250f, 0.01089002f, -0.00166138f, -0.00705957f, 0.02722649f, -0.00445617f, 0.00378602f, 
    0.01746015f, -0.01392652f, -0.01211168f, 0.02103144f, -0.01308108f, -0.03833355f, 0.02642446f, -0.00569445f, 
    -0.01445503f, -0.01913348f, 0.02095642f, 0.01845599f, -0.00482938f, -0.01836761f, -0.01342006f, 0.01682278f, 
    0.01531523f, 0.01976918f, -0.00934806f, -0.01003241f, -0.02528531f, 0.02237085f, 0.01128645f, 0.02684207f, 
    -0.03985364f, -0.03677203f, -0.02374674f, 0.01667529f, 0.00489838f, 0.02421864f, 0.00744985f, 0.00540067f, 
    0.02647340f, -0.01503926f, 0.00142214f, 0.00261481f, -0.02435986f, -0.02693331f, 0.00304327f, -0.01707680f, 
    -0.02518391f, -0.01439912f, 0.02664985f, 0.01237004f, 0.01634746f, -0.02106259f, -0.01711836f, -0.02441712f, 
    0.01507853f, 0.00655414f, 0.01383418f, -0.04198902f, -0.04307938f, -0.03893464f, -0.03318580f, 0.00349145f, 
    -0.03441880f, 0.02098241f, 0.03168553f, -0.01287225f, -0.00170174f, -0.02595274f, -0.03880029f, -0.01048520f, 
    0.02359602f, -0.00265134f, 0.00674749f, 0.00194423f, -0.00283032f, -0.00788393f, -0.00891681f, 0.02016629f, 
    -0.00763791f, 0.02266626f, -0.01309596f, -0.00365908f, -0.01775941f, 0.00271724f, -0.03659312f, 0.01102288f, 
    -0.00124212f, -0.00763982f, -0.02208974f, 0.01895802f, -0.00555203f, 0.01401892f, -0.01840676f, 0.02461112f, 
    -0.03125946f, -0.01746279f, -0.00204231f, -0.03034413f, 0.02427076f, -0.02217818f, -0.00404977f, -0.00240747f, 
    0.00340840f, -0.03217116f, 0.00074959f, -0.03008536f, -0.01993129f, 0.00295576f, 0.00634940f, 0.02395965f, 
    -0.02716176f, -0.03445863f, 0.00112914f, 0.02127549f, 0.02672974f, -0.03736218f, 0.01959165f, -0.03859678f, 
    -0.01187128f, 0.02127919f, 0.02622631f, -0.01189754f, -0.01884871f, 0.00391939f, 0.01621064f, -0.03776744f, 
    -0.00705046f, 0.00856036f, -0.02614036f, -0.01742930f, 0.00477683f, -0.00621887f, 0.01696775f, -0.03752904f, 
    -0.01014542f, -0.00284640f, -0.02085020f, -0.01232215f, -0.01213341f, -0.00011691f, 0.02185736f, -0.03425036f, 
    0.17559874f, -0.15078323f, -0.07362810f, -0.23565525f, -0.11622637f, 0.05176902f, -0.11433946f, 0.04754885f, 
    0.07507879f, 0.07347260f, 0.13982695f, 0.05621265f, 0.11759368f, -0.08836669f, -0.07534929f, 0.12343454f, 
    -0.03417950f, 0.02157509f, 0.08296081f, -0.01473601f, -0.10627760f, -0.05465866f, -0.03323863f, 0.05044991f, 
    0.09021625f, -0.14062665f, 0.03460428f, -0.01791477f, 0.12768829f, 0.01836442f, 0.01073622f, 0.11531844f, 
    0.07148629f, 0.03922445f, -0.05921658f, 0.06250045f, 0.22015065f, 0.04338687f, -0.05493789f, 0.16989392f, 
    -0.04798415f, -0.02380388f, -0.03603497f, 0.12834981f, -0.08171536f, -0.08386762f, -0.01880394f, 0.03753784f, 
    0.11925104f, 0.18416111f, -0.08786737f, -0.00155527f, 0.02958823f, -0.02972172f, -0.03911457f, -0.02896955f, 
    -0.04481489f, -0.00023062f, -0.01407747f, -0.02557517f, 0.15875342f, -0.13984755f, 0.01558749f, 0.05863028f, 
    -0.00681260f, 0.04806315f, 0.00155522f, 0.12748066f, 0.05419224f, 0.00233447f, 0.02634885f, -0.00508482f, 
    0.03740191f, 0.18585552f, 0.06101981f, 0.02973487f, 0.08227691f, -0.00035464f, 0.03581766f, -0.05843256f, 
    0.04258121f, 0.04671985f, 0.05965701f, 0.05745656f, 0.00707386f, 0.01456871f, 0.04094784f, -0.11799385f, 
    -0.05147956f, 0.03524849f, -0.01883581f, -0.01102972f, 0.13807324f, -0.01904500f, -0.02091667f, -0.05471031f, 
    0.13160509f, 0.14133736f, 0.00491883f, -0.15489486f, 0.03272434f, -0.00694406f, -0.04271801f, -0.06050851f, 
    0.07779127f, 0.01569033f, 0.07566711f, -0.14068887f, 0.17012554f, 0.10857370f, 0.07037105f, 0.03618528f, 
    0.07477863f, 0.09011758f, -0.03776323f, -0.01350038f, 0.07084082f, -0.05687507f, -0.01412424f, 0.00645119f, 
    0.08940543f, -0.13034298f, -0.09434330f, 0.02194222f, -0.00436194f, -0.11838030f, -0.06994548f, -0.03179134f, 
    0.00084201f, 0.09070452f, 0.13336369f, -0.02394350f, -0.15323423f, 0.07130991f, 0.08556410f, -0.20097835f, 
    0.11020543f, 0.05840895f, -0.05134336f, -0.02614304f, -0.00132548f, -0.07841757f, -0.02543624f, 0.06101961f, 
    -0.07678791f, 0.09418066f, 0.00850750f, 0.08938128f, -0.00342370f, 0.02810452f, 0.09341493f, -0.04137153f, 
    -0.04671729f, 0.07094293f, -0.04012743f, 0.00402049f, -0.26844531f, -0.06926367f, 0.08485787f, -0.04249362f, 
    -0.02512198f, -0.02589625f, 0.06072219f, 0.03401374f, -0.11510873f, -0.05774480f, 0.01407513f, -0.08991090f, 
    0.13076685f, -0.05060184f, 0.03991652f, 0.14153835f, -0.03963856f, 0.04365353f, -0.05580042f, 0.02834860f, 
    0.09463649f, 0.01148602f, 0.03028113f, -0.01947297f, 0.00716570f, 0.04850143f, 0.01098269f, 0.11005601f, 
    0.02360784f, 0.05732890f, 0.02015910f, -0.02937938f, 0.00564099f, -0.10935327f, 0.02914922f, 0.04329058f, 
    -0.06741938f, -0.05502274f, 0.11008704f, 0.21434262f, 0.06851419f, 0.00637701f, -0.00047114f, -0.11267400f, 
    -0.02277101f, 0.00087347f, -0.00795289f, 0.08018212f, -0.06555891f, -0.01004713f, -0.02727255f, 0.02272689f, 
    -0.02434164f, 0.00590186f, 0.09079982f, -0.17511013f, -0.08150011f, -0.13290325f, 0.02578599f, 0.02122383f, 
    0.09228671f, 0.15380190f, 0.03736179f, -0.06264476f, -0.07860009f, 0.01691984f, -0.04224837f, -0.03116338f, 
    0.03594241f, -0.00754428f, 0.06113282f, 0.01790525f, 0.14158210f, -0.09515016f, 0.05459192f, -0.00779633f, 
    0.03053241f, -0.09122558f, 0.01292817f, -0.04583855f, -0.05321716f, -0.03276688f, -0.01600672f, -0.06917509f, 
    0.02033594f, -0.02874232f, 0.15342441f, -0.24996418f, 0.07078452f, 0.03465591f, 0.04507821f, -0.04619697f, 
    0.00737974f, -0.01561978f, 0.09344546f, 0.15555401f, 0.09719373f, 0.07028580f, -0.02964808f, 0.19844717f, 
    -0.06293018f, 0.03188660f, -0.07077115f, 0.00483254f, -0.02738051f, 0.04708597f, 0.04929641f, -0.07175916f, 
    0.00346599f, -0.11655167f, 0.09890082f, -0.21714640f, 0.00940376f, -0.10349061f, -0.06439678f, -0.05369817f, 
    -0.04790710f, 0.13942564f, 0.00320849f, -0.02753739f, -0.02922930f, -0.01929429f, 0.09584488f, -0.15189244f, 
    -0.06014668f, -0.12952173f, 0.11696755f, 0.00335818f, -0.06597503f, -0.02529716f, 0.00653689f, -0.10494487f, 
    0.25015065f, -0.18648088f, -0.05542292f, 0.07615563f, -0.05344156f, -0.01966538f, -0.02575737f, -0.02405608f, 
    0.01851822f, -0.04019200f, 0.01925618f, 0.05887207f, 0.09260389f, 0.24305151f, -0.30755901f, 0.15859991f, 
    0.08432685f, 0.00494633f, -0.11729770f, 0.04118872f, -0.03507385f, 0.05680449f, -0.01465622f, 0.01671664f, 
    0.17458422f, -0.24300197f, -0.01333744f, 0.39515513f, 0.03140062f, 0.01001497f, -0.02022677f, 0.04702872f, 
    0.06027996f, -0.01729510f, -0.01600597f, 0.06778009f, 0.00614901f, 0.17240578f, -0.03038150f, 0.07101399f, 
    -0.05708016f, 0.04892125f, 0.02379824f, 0.03747117f, -0.00278343f, -0.01835645f, -0.01620034f, -0.06556154f, 
    0.07137730f, 0.06323464f, -0.18523689f, 0.13534568f, 0.11744803f, 0.01915142f, -0.01270222f, 0.02941865f, 
    0.11816993f, 0.02715081f, -0.05849848f, 0.01171867f, 0.15042517f, 0.16652022f, -0.06364238f, -0.02831351f, 
    0.05853251f, 0.09865920f, 0.00545661f, 0.00348833f, 0.00002994f, 0.10295580f, 0.07649131f, 0.01650658f, 
    0.18689179f, 0.05470073f, -0.14386779f, 0.27086020f, 0.04524861f, 0.04391369f, -0.01135339f, -0.11253815f, 
    0.04086887f, 0.03870021f, -0.01975933f, 0.00000369f, -0.11047120f, -0.03773160f, -0.07336229f, 0.02860664f, 
    0.08181801f, 0.01069592f, -0.00765977f, 0.03099238f, -0.03898808f, -0.03564664f, -0.00521457f, -0.01036230f, 
    0.30173579f, -0.23534635f, -0.04442412f, 0.19929677f, -0.09163322f, -0.01829955f, -0.09209200f, -0.01724095f, 
    -0.02073493f, -0.03058619f, -0.01350468f, 0.00535784f, -0.17659244f, 0.03244736f, 0.19984901f, -0.15325521f, 
    0.16138980f, -0.00599927f, 0.05965551f, -0.05142369f, 0.01042127f, -0.09519704f, -0.01689210f, -0.03660948f, 
    0.10649543f, -0.16807601f, -0.02980921f, 0.03210907f, 0.06892382f, 0.06216217f, -0.08012334f, 0.05719846f, 
    0.05333420f, 0.06458548f, 0.06841858f, -0.00146315f, 0.36939046f, -0.03856276f, -0.21589677f, 0.16178639f, 
    -0.06258570f, -0.02486011f, 0.07343286f, -0.05773430f, 0.01946178f, 0.04268613f, 0.02488213f, 0.06223698f, 
    -0.04805827f, 0.03151022f, 0.01697820f, 0.03016687f, -0.04345019f, 0.03156554f, 0.03050689f, -0.04208301f, 
    0.02898786f, 0.03074567f, 0.00394250f, 0.06378999f, 0.17362511f, 0.03590138f, -0.19348444f, 0.19663361f, 
    0.08794391f, 0.07676815f, 0.01832136f, -0.01266905f, -0.00857158f, -0.00118104f, 0.09343239f, -0.00389306f, 
    0.15128098f, -0.07617261f, 0.05267443f, 0.00115358f, 0.07945323f, -0.00969170f, -0.02457341f, 0.05671357f, 
    0.00656217f, -0.06113424f, -0.02622334f, -0.07981720f, 0.15739751f, -0.04160002f, -0.01419186f, -0.06170931f, 
    0.07558338f, 0.02347946f, -0.04213440f, -0.04668940f, -0.00677150f, -0.04980012f, 0.02149951f, -0.02203942f, 
    -0.01292920f, 0.17265198f, -0.01700855f, -0.06310407f, -0.02590227f, 0.03330354f, -0.03500837f, 0.01724832f, 
    -0.09694714f, -0.07151911f, 0.09320051f, -0.05254155f, -0.01211836f, -0.11919604f, 0.04736465f, 0.09246641f, 
    0.10991170f, 0.00320194f, -0.01312675f, -0.10409091f, -0.00843497f, -0.09053284f, 0.03762919f, 0.03904168f, 
    -0.25593555f, 0.08716054f, 0.06330305f, 0.15011761f, 0.04530671f, -0.09061298f, -0.01042263f, 0.10627364f, 
    -0.05099237f, 0.08059295f, 0.00541158f, -0.00387117f, 0.18380275f, 0.01509813f, 0.02878803f, 0.07262868f, 
    0.06232376f, 0.02208369f, 0.03905813f, -0.06632797f, 0.01409955f, 0.05738360f, 0.08398444f, 0.04371423f, 
    0.23757686f, 0.11171530f, -0.08953265f, 0.13867952f, -0.13439924f, -0.06047743f, -0.02388285f, 0.00746115f, 
    0.01562546f, -0.15944053f, 0.02110470f, -0.03684431f, -0.01465209f, 0.02313088f, -0.20609482f, 0.04138396f, 
    0.02103243f, -0.04820309f, -0.04642805f, -0.02034479f, 0.08148935f, -0.05864908f, -0.07156223f, 0.11503655f, 
    0.14876039f, -0.07644258f, 0.02406609f, 0.10889355f, -0.03236395f, -0.01275126f, -0.02139300f, -0.04088642f, 
    0.09026001f, -0.15966949f, 0.10046273f, 0.00099458f, 0.23096463f, 0.03900806f, -0.11780694f, 0.19663313f, 
    -0.01023405f, -0.04683867f, -0.01874800f, 0.03952572f, 0.05081221f, -0.05781585f, -0.04976800f, 0.10909031f, 
    -0.31265271f, 0.07281855f, -0.07259557f, -0.06879075f, 0.00877663f, -0.13009502f, -0.00764651f, 0.05383827f, 
    0.01939802f, -0.03757030f, -0.02561913f, 0.08423470f, 0.02276535f, -0.05610884f, 0.05874522f, 0.03211957f, 
    0.06161636f, 0.01360609f, 0.04013103f, 0.13396722f, -0.08790956f, -0.09920330f, -0.00588574f, -0.03155698f, 
    0.10203142f, -0.15495257f, 0.01377344f, -0.00549621f, -0.00562425f, 0.06666978f, 0.02004049f, 0.02582170f, 
    -0.08450631f, -0.06484462f, -0.09359454f, -0.01323883f, 0.23302054f, 0.06070540f, 0.10537238f, -0.09566401f, 
    0.05193726f, -0.08535235f, -0.11490305f, -0.05696154f, 0.02732750f, -0.05207968f, 0.12934428f, 0.00612375f, 
    -0.01987922f, -0.09577812f, 0.02676009f, 0.06173486f, -0.11545517f, 0.05861675f, 0.09974397f, -0.03513323f, 
    -0.08043882f, 0.00507945f, -0.00114672f, -0.13727643f, -0.04062561f, -0.08207714f, -0.05811227f, 0.09944966f, 
    0.05218054f, 0.01415565f, -0.01350671f, -0.02804348f, 0.10808112f, 0.07796655f, -0.06491410f, -0.01454569f, 
    0.06499100f, 0.32527453f, -0.05088362f, 0.11541946f, 0.02896993f, 0.05720161f, -0.02199917f, -0.04022129f, 
    0.03376022f, 0.07574164f, 0.04126848f, -0.01126949f, -0.08959914f, 0.09642116f, -0.01812218f, -0.12427723f, 
    0.05164850f, 0.04008899f, 0.01148273f, 0.01913929f, 0.03053690f, -0.04864965f, 0.02143458f, -0.09936330f, 
    -0.17937066f, -0.10428965f, 0.00440192f, 0.10119579f, 0.00881791f, 0.04983677f, 0.02095765f, -0.09779957f, 
    0.08191989f, -0.03198956f, 0.06472738f, 0.03655190f, 0.13248320f, -0.08398443f, -0.03358380f, 0.05997107f, 
    0.05608098f, 0.07067714f, -0.00028784f, -0.00503458f, -0.05270879f, -0.02511167f, 0.11653835f, -0.07786238f, 
    0.27582559f, -0.08640118f, -0.16156325f, -0.01463092f, -0.08825312f, -0.02360297f, 0.01335715f, -0.03193027f, 
    0.10783799f, 0.08298589f, 0.00662191f, 0.02372322f, -0.30484614f, 0.09431767f, -0.10341914f, 0.02264156f, 
    0.10568833f, 0.04373111f, 0.02916539f, 0.03459753f, -0.06953970f, 0.05775012f, 0.00042729f, 0.03618381f, 
    0.17667787f, 0.16852112f, 0.03579946f, 0.03788359f, 0.00709825f, 0.06201268f, 0.00317414f, 0.00293828f, 
    0.04751517f, 0.01884721f, 0.09632944f, 0.03459078f, -0.09420025f, -0.07570273f, 0.10544918f, -0.10348499f, 
    0.03058938f, -0.03034172f, -0.06097519f, 0.03645724f, 0.02817570f, -0.06955735f, 0.02947163f, -0.00805697f, 
    0.12487525f, 0.17142797f, 0.02547229f, 0.11531973f, 0.03531890f, 0.14953968f, -0.05767253f, 0.01071255f, 
    -0.02717949f, 0.04210194f, 0.06812637f, -0.02549745f, -0.20202613f, 0.09690217f, 0.07633207f, 0.12816778f, 
    -0.01746816f, 0.01758663f, -0.01630712f, 0.11660967f, -0.01486456f, -0.02280926f, 0.06312684f, -0.01894849f, 
    -0.00781988f, 0.00371649f, 0.12302379f, 0.04296813f, 0.02047852f, 0.01785574f, 0.02377600f, 0.02548508f, 
    0.09691749f, 0.04588358f, -0.01733225f, 0.10406993f, -0.24535796f, 0.08497372f, 0.04846701f, -0.00364445f, 
    0.05991265f, 0.04531997f, -0.05706974f, 0.06314020f, 0.08537685f, 0.02724122f, -0.00700310f, -0.02582376f, 
    0.01215515f, 0.20874859f, -0.02200753f, -0.07894909f, -0.00593995f, 0.10457550f, -0.03401462f, 0.04979504f, 
    -0.02817415f, -0.02899353f, -0.06976677f, 0.02360582f, 0.08603866f, -0.11850011f, -0.02524958f, 0.03640987f, 
    0.08769652f, 0.16876882f, 0.00294124f, 0.08397419f, 0.05456622f, -0.02113627f, -0.02463903f, 0.04062200f, 
    -0.07185514f, -0.06981415f, -0.09766591f, 0.01900684f, -0.02765243f, -0.02120368f, 0.00201320f, 0.10111620f, 
    0.06513233f, -0.05569123f, 0.00154972f, -0.04920573f, 0.14675903f, 0.01894894f, -0.07877257f, -0.23002978f, 
    0.01208067f, 0.04672847f, -0.07457249f, -0.02155357f, -0.04407303f, -0.05851807f, 0.06193728f, 0.02426810f, 
    -0.17058112f, -0.13528830f, -0.10279284f, 0.02007969f, 0.03263499f, -0.07456657f, -0.01065118f, 0.05200576f, 
    -0.00055797f, -0.08392670f, -0.04158863f, 0.00206312f, -0.11889098f, -0.18485668f, -0.06895520f, -0.06268606f, 
    0.03399009f, 0.10702108f, -0.03663991f, 0.12097804f, 0.05629718f, -0.06849822f, 0.03165694f, -0.12301584f, 
    -0.15506205f, -0.05600548f, -0.04190575f, 0.04170638f, -0.01878647f, 0.03809027f, 0.05981398f, -0.01741265f, 
    0.07855535f, 0.01276754f, -0.07797574f, 0.07432767f, -0.12011572f, -0.21309398f, -0.06095566f, -0.05647041f, 
    0.11927318f, -0.03026122f, -0.00593588f, 0.04332604f, -0.01366988f, -0.03031051f, -0.03332765f, 0.06630143f, 
    0.04734236f, 0.02578486f, 0.07772041f, 0.07769618f, -0.02784764f, -0.02418319f, -0.03153183f, -0.02738032f, 
    -0.05767599f, 0.02112519f, 0.07646960f, 0.03650071f, -0.02499598f, -0.00884208f, 0.01304284f, -0.03626451f, 
    0.07273905f, -0.00931702f, -0.00234083f, -0.08189517f, -0.03978003f, 0.15974309f, -0.06650089f, 0.10282344f, 
    -0.28708541f, 0.12742013f, -0.02192423f, 0.16902274f, 0.06097601f, 0.01196144f, -0.11720225f, 0.10062701f, 
    -0.08882228f, -0.08767228f, 0.12199247f, 0.02155657f, -0.07004818f, -0.15076905f, -0.10084691f, 0.02631925f, 
    0.02094828f, -0.02950013f, -0.03298778f, 0.08770453f, 0.02892262f, -0.00832894f, 0.03187063f, 0.00999795f, 
    0.13954225f, -0.01969294f, 0.08836091f, 0.00373634f, 0.06179642f, 0.07072744f, 0.05640078f, -0.00124626f, 
    0.01254492f, -0.03192499f, -0.05092542f, 0.01725695f, 0.10231494f, -0.11895226f, 0.06820019f, 0.00265485f, 
    -0.00250913f, 0.05406689f, 0.02265893f, -0.02283572f, -0.05009801f, 0.01445445f, 0.07561713f, 0.07809870f, 
    -0.13458402f, 0.13441674f, 0.03838928f, -0.06612728f, 0.11620062f, -0.03996516f, -0.05486089f, 0.06872635f, 
    -0.01556755f, 0.04518247f, -0.05417121f, 0.06114541f, -0.16966827f, -0.02970849f, 0.00574260f, -0.08227246f, 
    0.12498335f, 0.10353879f, 0.02266887f, 0.09051557f, 0.11377387f, 0.07573272f, -0.01065779f, -0.03583694f, 
    -0.06623044f, -0.18696463f, -0.00685294f, 0.09599613f, -0.02517146f, -0.07964037f, 0.08239003f, 0.02512952f, 
    0.01775653f, -0.02041068f, -0.01846766f, 0.04757636f, -0.15424828f, 0.23788983f, 0.00329671f, -0.06749864f, 
    0.01940927f, 0.07322434f, 0.02122013f, -0.00331123f, -0.06372549f, -0.10513967f, 0.03538599f, -0.03225666f, 
    -0.16595685f, -0.02319122f, -0.11654473f, 0.02706062f, -0.01786413f, -0.01891550f, 0.06742996f, 0.10284650f, 
    0.03124474f, -0.04406126f, 0.09271847f, 0.14839737f, 0.19652095f, -0.11690513f, 0.09098388f, 0.01372967f, 
    -0.05440328f, 0.14720109f, 0.07984362f, 0.00169561f, -0.01378208f, 0.03548292f, 0.10954433f, -0.05420313f, 
    -0.06591722f, 0.17790426f, -0.07453275f, 0.03980642f, 0.05973718f, 0.06190261f, -0.01178741f, 0.09530475f, 
    0.02220645f, 0.01244842f, 0.04971381f, 0.05749961f, -0.22618720f, 0.10319550f, -0.04043008f, 0.04730259f, 
    0.09406526f, 0.04164046f, 0.04300496f, -0.03567329f, -0.06920760f, 0.05746355f, 0.07571740f, 0.04620457f, 
    -0.03987236f, 0.12359168f, 0.13305199f, 0.00224377f, 0.06390146f, 0.11109000f, -0.03761472f, -0.02597446f, 
    -0.04840972f, 0.02325847f, -0.00809004f, -0.01327366f, -0.03825229f, 0.05014776f, 0.06916020f, -0.00014975f, 
    -0.06555403f, 0.06106669f, 0.06168076f, -0.04157913f, 0.05159504f, 0.07479674f, 0.11785199f, 0.03914433f, 
    0.19140305f, 0.21566758f, 0.06866825f, -0.03640576f, 0.00520731f, 0.01939534f, 0.03260752f, -0.04237086f, 
    -0.00225700f, -0.00437352f, -0.03951514f, -0.00504006f, -0.27441844f, -0.00249024f, 0.09360464f, 0.04283644f, 
    0.06025670f, 0.03422147f, -0.03172830f, 0.08640794f, 0.04406168f, -0.05768907f, 0.01348509f, 0.10478994f, 
    -0.14742760f, 0.04546129f, 0.17799725f, 0.03939859f, 0.05310497f, 0.00007057f, -0.01210804f, -0.06193254f, 
    0.06061702f, -0.07911941f, 0.16145793f, 0.04777196f, -0.01481438f, -0.02205770f, 0.01838081f, 0.10552948f, 
    0.12289119f, 0.04983077f, 0.02888930f, -0.00258780f, 0.04229422f, 0.10820887f, 0.04168672f, 0.06356356f, 
    0.02573109f, 0.06946035f, 0.12660560f, 0.00284897f, 0.09096095f, -0.01417763f, 0.05388823f, -0.04293859f, 
    -0.01903400f, -0.05934487f, -0.03214126f, -0.03078509f, 0.06839347f, -0.08915868f, 0.01291213f, 0.00574716f, 
    0.00396680f, -0.01100584f, -0.06647804f, -0.01222904f, -0.10100339f, 0.02030707f, 0.02661568f, 0.04387923f, 
    -0.02283674f, 0.09285816f, 0.09872501f, -0.02091801f, 0.02394585f, 0.07910436f, -0.00598241f, 0.00944881f, 
    0.04977288f, -0.05526813f, -0.02760268f, 0.05591218f, -0.02610994f, 0.23850584f, -0.19425972f, -0.01809087f, 
    0.09004392f, -0.02722667f, 0.05043743f, -0.03513315f, -0.00501498f, 0.06431304f, 0.03220146f, 0.12125490f, 
    0.07020949f, 0.17848679f, -0.00771951f, 0.04870464f, -0.05519399f, 0.05668234f, -0.01669734f, -0.01148156f, 
    -0.00447487f, -0.00011291f, -0.03569700f, 0.06343386f, -0.10695300f, 0.15031554f, 0.17807825f, 0.05093596f, 
    0.00196159f, 0.07054238f, -0.03672148f, -0.04085962f, 0.08404215f, 0.01728923f, 0.03588449f, 0.01719488f, 
    -0.07879506f, -0.07781913f, -0.16343597f, 0.11325466f, 0.11093225f, 0.02875693f, -0.04753456f, 0.05209791f, 
    0.04557295f, 0.04011109f, -0.04028144f, -0.08447730f, -0.11594673f, -0.00249782f, 0.14777310f, -0.01527977f, 
    0.01540605f, 0.09630442f, 0.04184579f, 0.07044876f, -0.00875413f, 0.01487132f, -0.06718393f, 0.15380612f, 
    0.11498409f, 0.09480688f, -0.09953528f, 0.06346496f, -0.05431843f, 0.13083059f, -0.00132961f, 0.02101464f, 
    -0.04001880f, 0.02833989f, -0.02644845f, 0.01990030f, 0.03199992f, 0.13689095f, 0.08642200f, 0.02297910f, 
    0.00430655f, 0.08822033f, 0.05092558f, 0.02165069f, -0.10599426f, -0.00049224f, 0.03334755f, -0.11830766f, 
    -0.08232275f, -0.15931179f, 0.05648724f, 0.02256927f, -0.01392770f, 0.02984502f, 0.02846346f, 0.12432776f, 
    -0.00633046f, 0.02413129f, 0.05131961f, -0.03890066f, 0.05342739f, 0.18721475f, 0.13315856f, 0.02935803f, 
    -0.03793148f, 0.03704834f, 0.01935307f, -0.00721112f, 0.02143604f, 0.03201932f, -0.06446909f, 0.06050115f, 
    -0.00127930f, -0.04329763f, -0.07921745f, -0.10410712f, -0.02488267f, 0.10290728f, -0.00549457f, -0.02523974f, 
    -0.02456894f, 0.00498385f, 0.03364443f, -0.00233475f, -0.16483791f, -0.01097513f, -0.05138099f, 0.01256803f, 
    -0.03870366f, 0.02648232f, 0.03421905f, -0.03565262f, 0.01001443f, 0.03855978f, 0.06170319f, 0.05402607f, 
    -0.20065522f, -0.14916940f, -0.01660504f, 0.09068260f, -0.02286750f, 0.01546963f, -0.02376202f, 0.00246242f, 
    0.00033621f, 0.07376432f, -0.12475357f, 0.10380413f, 0.09777821f, 0.01149241f, 0.12895542f, 0.01067563f, 
    -0.09903671f, -0.01875796f, 0.05012837f, -0.01386629f, -0.00797475f, 0.04255308f, 0.07968616f, -0.09358111f, 
    -0.03109325f, 0.03782660f, 0.12702179f, -0.17786667f, -0.02168730f, -0.01119661f, -0.03255706f, 0.00444438f, 
    -0.12879525f, -0.04913378f, 0.06832029f, 0.07238949f, -0.02829207f, -0.04779365f, 0.05830083f, 0.08731080f, 
    -0.11438908f, 0.03461876f, 0.03323428f, -0.06801695f, -0.02282338f, -0.09323306f, -0.05281441f, 0.04344497f, 
    0.37502244f, -0.05931678f, 0.17647485f, -0.00083346f, -0.06829605f, 0.09455988f, 0.16070659f, -0.01714483f, 
    0.03861548f, 0.04414492f, -0.05672122f, 0.03863008f, -0.14948362f, -0.10146040f, -0.07938246f, -0.02633222f, 
    0.04764184f, 0.03423712f, 0.01507309f, 0.05768283f, -0.00029377f, -0.01794848f, 0.00813788f, -0.04147575f, 
    0.22785068f, 0.00151357f, -0.01293754f, -0.14625670f, -0.03751808f, 0.03797757f, 0.00639829f, -0.00431459f, 
    0.02728996f, -0.03331041f, 0.05289451f, 0.02250791f, -0.15027954f, -0.08700003f, -0.04351034f, -0.03881220f, 
    -0.03488136f, 0.03578547f, 0.01714685f, -0.06587134f, 0.04560890f, 0.05282412f, 0.02167071f, 0.00185228f, 
    -0.06768738f, -0.09046020f, -0.02385481f, -0.01606493f, 0.05958946f, -0.02492425f, 0.05786312f, 0.06011709f, 
    -0.00875715f, -0.00431600f, -0.03214195f, 0.17413729f, 0.17196316f, 0.04227911f, 0.12929206f, 0.06027004f, 
    0.03434080f, 0.17388913f, 0.12153315f, 0.02210241f, 0.06901284f, -0.01644899f, -0.01228991f, 0.03645092f, 
    -0.10482610f, -0.05378377f, 0.01829846f, 0.16292076f, 0.03735836f, 0.02589048f, 0.13718373f, 0.07294300f, 
    0.00725510f, -0.05960906f, 0.01590045f, 0.03285440f, 0.08079335f, 0.06079691f, 0.02251857f, 0.07268606f, 
    -0.05020242f, 0.06892905f, 0.06693777f, 0.02943759f, 0.02516129f, -0.00734347f, 0.12443462f, 0.05761456f, 
    -0.03683479f, 0.26946944f, -0.03115864f, -0.13788418f, 0.06056542f, -0.01833429f, -0.00647077f, 0.03003819f, 
    0.01102813f, -0.00357250f, 0.04696163f, 0.06970913f, 0.14256997f, 0.03479453f, 0.13168649f, 0.01939719f, 
    0.03837445f, 0.06879132f, 0.04147240f, -0.04213873f, 0.01927734f, 0.02223218f, 0.10343822f, -0.01294465f, 
    0.01346669f, 0.03802383f, 0.13640326f, 0.01244597f, -0.07680926f, 0.08320054f, 0.06426623f, 0.02028354f, 
    -0.02118166f, -0.09159900f, -0.02124800f, -0.03861605f, -0.02065130f, 0.06009302f, 0.18024907f, 0.07143687f, 
    0.00595075f, -0.03280004f, 0.06192812f, -0.02435277f, 0.10231012f, 0.10481048f, -0.00829765f, -0.04172159f, 
    -0.10062410f, 0.03834688f, -0.05161000f, 0.07173647f, -0.08072272f, -0.06508790f, 0.10167851f, 0.03860525f, 
    0.02923417f, 0.06939261f, 0.06253154f, 0.04189176f, 0.07773574f, 0.16266349f, 0.01075263f, 0.07691419f, 
    0.04934058f, 0.02427906f, -0.02867094f, -0.01514772f, 0.05601602f, -0.04961088f, 0.04185486f, 0.03092572f, 
    0.09977068f, -0.11092444f, 0.18352818f, 0.05185243f, -0.04660225f, -0.01682796f, 0.02779273f, -0.07991291f, 
    -0.15045257f, -0.13376643f, 0.05649739f, -0.05011108f, 0.07154570f, -0.18222092f, -0.05781204f, -0.01369310f, 
    0.08293738f, 0.01629238f, 0.08457574f, -0.00174227f, 0.06291627f, -0.01129048f, -0.02538456f, 0.00314894f, 
    0.24579957f, -0.07281063f, 0.00832227f, -0.09770177f, -0.00183805f, -0.04692066f, -0.07641535f, 0.05842762f, 
    -0.03471970f, 0.01877229f, 0.11824226f, 0.09064093f, 0.08727274f, -0.37435514f, -0.10737853f, -0.09308678f, 
    -0.04011074f, 0.00149021f, 0.05766052f, 0.00179541f, -0.02737989f, 0.09840080f, -0.14257045f, -0.01077724f, 
    0.07184541f, -0.11371545f, 0.16973384f, 0.05271925f, -0.10959430f, 0.07234211f, -0.01282316f, -0.03114036f, 
    0.12350931f, -0.10050079f, 0.05269996f, -0.07260866f, -0.09759754f, -0.01075776f, -0.00592402f, 0.08476611f, 
    -0.12765341f, 0.07634661f, 0.00510179f, -0.04116448f, 0.14394417f, 0.11058881f, 0.04923771f, 0.02268878f, 
    -0.08014994f, -0.10105503f, 0.01107894f, 0.04163735f, 0.00805033f, 0.01136371f, 0.05085102f, 0.00423077f, 
    -0.02369121f, 0.06169331f, 0.05802048f, 0.15287402f, 0.11475777f, 0.01310825f, 0.03581453f, 0.06974269f, 
    -0.07706613f, 0.07282868f, -0.08814534f, 0.06549817f, -0.19577459f, -0.01340951f, -0.05799778f, -0.06752881f, 
    0.08755996f, 0.11567440f, 0.13070905f, -0.16814351f, 0.04841438f, 0.03509646f, -0.04344903f, -0.02652897f, 
    -0.00277345f, -0.06805274f, 0.01792801f, -0.08673934f, 0.02536646f, 0.10364780f, 0.06920172f, -0.02424291f, 
    -0.07136200f, -0.01217318f, 0.06891223f, 0.06989591f, 0.02825405f, 0.00755535f, -0.18511657f, 0.09244163f, 
    -0.14763033f, -0.00386471f, 0.09320369f, 0.04568271f, 0.09268995f, 0.05045668f, 0.10040948f, 0.09334639f, 
    -0.02587528f, -0.01839489f, 0.05567499f, 0.05382672f, 0.08681748f, 0.12493400f, -0.00327482f, -0.07209756f, 
    -0.08005182f, -0.07607717f, 0.02636416f, -0.03676374f, -0.06011114f, 0.08330832f, 0.04611998f, -0.05118174f, 
    -0.31050387f, 0.19249304f, 0.10603336f, 0.10104065f, -0.00204612f, -0.07903039f, 0.01975286f, 0.02092266f, 
    -0.04363667f, 0.08627980f, -0.05316822f, 0.12424920f, 0.07293586f, -0.06467443f, -0.02492566f, 0.09531369f, 
    0.04887183f, -0.06422660f, -0.03490975f, -0.01154671f, -0.10589828f, 0.02483919f, 0.12797701f, 0.00019497f, 
    0.13888431f, -0.28452313f, -0.09906201f, -0.12413961f, 0.07052900f, -0.00881726f, 0.03853436f, -0.10282833f, 
    -0.00345416f, -0.04434260f, 0.00263496f, -0.00182723f, 0.06549441f, -0.14807029f, -0.16169785f, -0.11743899f, 
    -0.12979376f, 0.03887665f, -0.01292565f, -0.02688114f, -0.01653987f, 0.02105562f, 0.00797928f, 0.09157140f, 
    0.20961244f, -0.18777560f, -0.05690390f, 0.09530312f, 0.07454757f, 0.00605562f, 0.07538235f, 0.08036513f, 
    0.01130572f, 0.11356767f, -0.09248763f, -0.04556529f, 0.26289836f, 0.20308967f, -0.06447051f, 0.16883776f, 
    -0.02837135f, 0.08310419f, 0.07031763f, 0.01310072f, 0.02879051f, 0.11102679f, 0.04958779f, 0.13327977f, 
    0.26748073f, 0.01413006f, 0.21776804f, -0.02058058f, 0.08550040f, -0.02718654f, 0.02788408f, 0.07179500f, 
    0.00794740f, 0.03166257f, 0.04764540f, 0.15008853f, 0.05026951f, -0.16552672f, 0.01546744f, -0.09498473f, 
    -0.06897733f, -0.02289640f, 0.10023186f, 0.12657341f, 0.06123362f, -0.12448081f, 0.09106413f, 0.12267411f, 
    0.08401912f, -0.00238926f, -0.10169234f, -0.02490303f, -0.03294577f, -0.14904194f, 0.02243594f, -0.03542653f, 
    0.05550254f, 0.07308000f, 0.10840281f, 0.00056515f, 0.17723724f, 0.00269637f, 0.09833331f, 0.07877050f, 
    0.00369336f, 0.08173899f, -0.14161699f, 0.03649485f, -0.06022274f, 0.02114228f, -0.00191079f, -0.03295425f, 
    0.09989980f, -0.08569864f, -0.01440351f, -0.21994416f, -0.04922844f, -0.02196640f, 0.06855306f, -0.05669576f, 
    0.11135216f, -0.01708048f, 0.02609314f, 0.03394623f, -0.09890683f, 0.31037223f, -0.08593690f, 0.14486180f, 
    0.01393671f, 0.03266235f, 0.15076414f, -0.07493430f, 0.02505838f, -0.05599219f, 0.01935966f, 0.04692492f, 
    -0.21507490f, -0.03739453f, 0.21836939f, -0.12135468f, -0.06353468f, 0.06754056f, -0.00151226f, 0.03672620f, 
    0.05608114f, 0.01080235f, -0.01341757f, -0.08230742f, 0.16570070f, -0.12041137f, 0.09249505f, -0.16557974f, 
    -0.03483187f, -0.00497528f, 0.04399163f, 0.05718537f, 0.05419867f, 0.07329557f, -0.00348249f, 0.15446660f, 
    -0.02728118f, 0.08137832f, 0.09635938f, -0.01031930f, 0.11463068f, 0.05800130f, 0.00083249f, -0.01373586f, 
    -0.01899458f, 0.09273227f, 0.01943321f, 0.06395072f, -0.29849759f, -0.13757092f, 0.08291294f, -0.02219527f, 
    0.10054886f, 0.02925409f, 0.07990300f, -0.09736580f, 0.03751453f, 0.05868903f, 0.02178062f, -0.00517986f, 
    0.40235165f, -0.03487942f, 0.03531860f, 0.24584237f, 0.09626622f, 0.08088528f, -0.01625653f, 0.02049795f, 
    -0.05518154f, 0.00992428f, -0.05126060f, 0.08447607f, 0.13117462f, -0.31235117f, 0.06580428f, 0.01278296f, 
    -0.05457394f, 0.05527412f, 0.12291713f, -0.00284459f, 0.00087458f, -0.09824856f, 0.06783500f, -0.00823922f, 
    0.15934315f, -0.05092179f, -0.18296719f, 0.09053431f, 0.00150680f, 0.03732483f, 0.12738615f, -0.08766371f, 
    -0.03115481f, -0.03095008f, 0.07373791f, 0.17298622f, 0.03375306f, 0.06802557f, 0.07869836f, -0.01400969f, 
    0.04567334f, 0.01766735f, 0.00369045f, -0.01151544f, 0.06362100f, 0.15857898f, 0.05891323f, 0.03095419f, 
    0.17213571f, -0.16945976f, -0.12203024f, 0.14899009f, -0.05104428f, -0.08599953f, 0.04290801f, 0.01955858f, 
    0.10058645f, 0.02026085f, 0.09399749f, 0.00032800f, 0.01125896f, 0.01131983f, 0.00331512f, 0.07755724f, 
    -0.08800432f, -0.00348082f, 0.00070375f, 0.15935022f, 0.04460565f, -0.01742408f, 0.00313712f, 0.15976276f, 
    -0.01856833f, 0.03104236f, 0.11213654f, -0.06315359f, 0.11384383f, -0.07060476f, 0.02055182f, 0.04722039f, 
    0.00722946f, -0.07064588f, -0.08390523f, -0.06145399f, 0.42622864f, -0.21138863f, 0.31402668f, -0.28760645f, 
    -0.00467644f, -0.00610620f, -0.04834618f, 0.03475840f, -0.00713380f, 0.00357070f, 0.05152704f, 0.04938851f, 
    0.23621857f, 0.06263992f, 0.08661576f, 0.01562524f, 0.02392957f, -0.03338176f, 0.09081980f, 0.00228201f, 
    0.07688554f, -0.01003466f, 0.03910517f, 0.03482274f, -0.37715507f, 0.03366067f, -0.02394310f, 0.09609637f, 
    0.08149942f, 0.06822582f, 0.03954777f, 0.09608854f, 0.04411330f, 0.01470536f, 0.00390157f, -0.03162439f, 
    -0.01225790f, 0.12606549f, -0.02068279f, -0.09710990f, -0.04115782f, 0.03653144f, 0.12585977f, 0.11843902f, 
    0.03179277f, -0.06846235f, 0.01672808f, 0.08163422f, 0.23335750f, 0.05264563f, 0.13311394f, 0.21414235f, 
    0.06778929f, 0.05652342f, -0.00266893f, 0.05174825f, 0.10529393f, 0.01194991f, 0.03774131f, 0.12112733f, 
    -0.06886161f, 0.07478675f, -0.04869552f, 0.00333333f, 0.00829468f, -0.08877068f, 0.05085099f, 0.09789319f, 
    -0.05103488f, 0.06751067f, -0.01891948f, 0.06068710f, -0.08534529f, 0.06260750f, 0.10819933f, 0.13802718f, 
    0.01267383f, -0.08547535f, 0.06820285f, 0.02675442f, 0.05700492f, 0.09865326f, -0.02435751f, 0.04382958f, 
    0.09867332f, 0.10822235f, 0.05996963f, -0.10458905f, -0.07021368f, 0.04255620f, 0.05356741f, -0.07130112f, 
    -0.05755306f, -0.09727041f, 0.13160063f, -0.04695018f, 0.06872269f, 0.21645291f, 0.18515806f, 0.04108953f, 
    0.11876737f, 0.09933125f, -0.07203224f, 0.00042859f, 0.03088760f, -0.03737919f, -0.09635668f, 0.01579648f, 
    0.18098798f, 0.21374710f, 0.11837912f, -0.09089037f, -0.03414783f, 0.03322065f, 0.07194293f, 0.04214986f, 
    0.00860423f, 0.00024112f, 0.05596228f, 0.03940161f, 0.07740131f, -0.12364554f, 0.09616172f, -0.06168871f, 
    -0.01041288f, -0.02862526f, 0.03163882f, 0.01848280f, 0.00790136f, -0.05487354f, 0.10095659f, -0.00950924f, 
    0.18168652f, 0.08653438f, -0.05966602f, -0.15531857f, -0.13995962f, -0.03770967f, -0.08669726f, 0.07972805f, 
    -0.00121324f, 0.09602346f, -0.01044611f, 0.07866062f, 0.06077422f, 0.21338809f, 0.10484957f, 0.07511660f, 
    0.11548967f, 0.09383934f, 0.08325680f, -0.09959877f, 0.09484774f, -0.00343873f, -0.05931653f, -0.09622175f, 
    0.25459224f, 0.09635234f, -0.01506395f, 0.22008508f, -0.01418070f, -0.00763345f, 0.07502083f, 0.02429813f, 
    0.11450347f, 0.03192860f, 0.08689301f, 0.01797595f, -0.07364824f, 0.02522856f, -0.03397698f, 0.12598158f, 
    0.07677399f, 0.02998769f, 0.00867855f, 0.06338996f, -0.17971340f, 0.12547430f, -0.01598898f, 0.02696349f, 
    -0.13034977f, 0.12955439f, -0.01654038f, -0.01708133f, 0.05390894f, -0.00742240f, 0.02966329f, 0.01233477f, 
    0.00737644f, 0.05458617f, 0.07930478f, 0.02788936f, 0.24410836f, 0.04502621f, -0.01350917f, -0.14347887f, 
    -0.14668079f, 0.05845913f, 0.01411545f, -0.07719792f, -0.00945089f, 0.03141017f, -0.02679359f, -0.01722507f, 
    0.03427536f, 0.05731762f, -0.03109263f, 0.05342531f, -0.05202198f, -0.01943726f, -0.01338824f, -0.02448326f, 
    0.07436617f, 0.08086801f, -0.01934980f, 0.01380224f, 0.05482052f, 0.18186674f, 0.09022222f, -0.10711665f, 
    -0.01412298f, -0.01916045f, -0.04384970f, 0.05778378f, -0.04333529f, -0.09849897f, 0.17337494f, -0.04188270f, 
    -0.06381916f, 0.06369501f, 0.03637843f, 0.07010152f, -0.02287873f, 0.03185576f, -0.09406936f, 0.01575932f, 
    -0.06861040f, -0.00354050f, -0.06545817f, -0.02067279f, 0.20322710f, 0.06916191f, 0.04515019f, 0.01766418f, 
    -0.00727632f, 0.03262885f, 0.01860485f, 0.01540055f, -0.00511563f, 0.00595101f, -0.07318834f, -0.07699777f, 
    0.22399180f, -0.16115725f, -0.08161955f, -0.01183574f, 0.00746397f, -0.08884215f, 0.12865445f, -0.16613998f, 
    0.05016375f, -0.05169810f, 0.11974731f, 0.03328339f, -0.00300464f, -0.03916832f, 0.04527010f, 0.04049961f, 
    0.04388820f, 0.02513732f, -0.02392890f, 0.08236628f, -0.02104244f, -0.12198007f, -0.00571237f, 0.04773663f, 
    0.08391729f, 0.08318415f, 0.21069831f, -0.04847347f, 0.05976466f, 0.03135971f, 0.07274783f, 0.02662146f, 
    0.07060084f, -0.05601398f, 0.05325181f, 0.10896118f, -0.02061745f, 0.21463025f, 0.05406373f, -0.07746340f, 
    0.01637728f, -0.03831550f, 0.03889874f, -0.02098472f, 0.03499472f, -0.05961419f, 0.02603973f, 0.04836206f, 
    -0.34003195f, -0.08142348f, -0.08034453f, 0.19629627f, 0.05269315f, 0.06632173f, -0.00901285f, 0.08392887f, 
    -0.01786323f, -0.04499793f, -0.05317363f, -0.11433037f, 0.35043257f, 0.04045763f, 0.08110482f, -0.04463691f, 
    -0.05549718f, -0.00424426f, 0.03332693f, 0.03387176f, -0.08659768f, -0.05617082f, 0.00852939f, -0.08819774f, 
    0.04538137f, 0.10790357f, 0.10627296f, 0.05514650f, -0.00052480f, 0.04092719f, 0.11814661f, -0.00200620f, 
    0.12093725f, -0.01977533f, 0.01727280f, 0.11960202f, -0.01738252f, 0.02845152f, 0.05787853f, -0.09873521f, 
    0.06830367f, 0.10246492f, 0.08173762f, 0.12741123f, -0.00300827f, 0.03469893f, 0.04520033f, -0.00025074f, 
    -0.13021913f, -0.03325727f, -0.22643802f, 0.27601120f, -0.07876241f, 0.06530234f, 0.09339570f, -0.06624290f, 
    0.04607129f, -0.07467321f, -0.00591090f, -0.01865663f, 0.17736100f, -0.05270388f, -0.18473980f, -0.05201158f, 
    -0.09267008f, -0.05406759f, -0.02795199f, 0.06631573f, 0.01426114f, 0.04898034f, -0.10779335f, 0.13812242f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00541913f, 0.01752802f, -0.01136918f, 0.02100757f, 0.02150274f, 0.08476379f, -0.01641586f, -0.01476167f, 
    0.03429451f, 0.01977664f, -0.01267035f, -0.03762373f, 0.05799062f, -0.02060476f, 0.02239320f, 0.01168919f, 
    -0.03736475f, -0.04674074f, 0.04395163f, 0.01489384f, 0.05863769f, 0.03205308f, 0.00949559f, -0.01693200f, 
    -0.00268060f, 0.02227437f, 0.00437249f, -0.01521152f, 0.00374640f, 0.04084023f, 0.01141920f, 0.03842985f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16454951f, 0.01440328f, 0.12894064f, 0.06325281f, -0.16777840f, 0.04373295f, 0.00863449f, 0.15586515f, 
    0.13301603f, 0.13034247f, 0.13111089f, 0.34965482f, -0.35007435f, -0.11956526f, -0.25304213f, 0.02761243f, 
    -0.07595602f, 0.06304099f, 0.12835611f, 0.00002123f, -0.10686254f, -0.23423970f, -0.14086111f, 0.14930333f, 
    0.19389573f, 0.00240380f, -0.15850289f, 0.11931975f, -0.08316053f, 0.03076206f, 0.12934998f, 0.30845049f, 
    -0.06342947f, -0.02018877f, 0.09539248f, -0.10306235f, 0.15028541f, -0.06303145f, 0.03984008f, -0.14449878f, 
    0.16274893f, -0.15732744f, 0.00692701f, -0.13173692f, -0.09811002f, -0.06289881f, -0.34964195f, 0.05976155f, 
    -0.02381171f, 0.34842482f, 0.12400698f, 0.01206810f, 0.27553895f, 0.15700395f, 0.28971967f, -0.00940097f, 
    0.30246505f, -0.07825962f, -0.00441039f, -0.01842966f, -0.04535075f, -0.17898647f, 0.07692198f, 0.17897911f, 
    0.04382797f, -0.20869218f, 0.12968427f, 0.04622465f, 0.06753355f, 0.28350896f, 0.12900947f, -0.08838030f, 
    0.16939992f, 0.12057187f, 0.06981044f, -0.27833506f, -0.25825104f, -0.01491781f, -0.21032271f, -0.01644624f, 
    0.03506432f, -0.23133487f, -0.08889892f, -0.05374071f, -0.13976651f, -0.27731571f, 0.01287920f, 0.05548696f, 
    0.07196272f, -0.15391006f, 0.35547191f, -0.05881419f, -0.07776250f, 0.35839194f, 0.07735050f, 0.33268887f, 
    -0.17352809f, 0.00228366f, 0.02909260f, -0.14420328f, 0.13610871f, 0.23347981f, -0.23810034f, 0.11694825f, 
    0.04910085f, -0.01786506f, -0.09312893f, 0.20223363f, 0.30150661f, 0.05171688f, 0.28813577f, 0.13513042f, 
    0.07840378f, -0.37086889f, -0.10889847f, 0.08245186f, 0.26445758f, 0.27177992f, 0.00411633f, 0.09857886f, 
    0.19526678f, -0.11213354f, -0.38127714f, -0.14072089f, 0.14593054f, -0.08290765f, -0.13047740f, -0.14448886f, 
    0.00668882f, -0.01705662f, 0.15705396f, -0.10857179f, -0.04464661f, 0.19623664f, 0.47771132f, 0.14976525f, 
    0.14897767f, -0.10742527f, -0.12819400f, -0.30493954f, 0.25160071f, -0.14079715f, 0.22179665f, -0.11035769f, 
    0.05116802f, 0.24411158f, 0.08008367f, 0.01607002f, 0.41123682f, 0.12434290f, 0.43590146f, 0.10290665f, 
    0.23630853f, 0.05871369f, 0.34748065f, -0.03638895f, 0.06071536f, 0.14417215f, -0.15326571f, -0.18532269f, 
    0.08486500f, -0.09954999f, -0.00978280f, 0.12730911f, -0.07475183f, 0.23526238f, -0.52159196f, 0.02862249f, 
    -0.05573983f, -0.11816756f, -0.15799578f, 0.25554451f, 0.04531638f, 0.13718098f, -0.09877405f, 0.13086668f, 
    -0.14815409f, 0.23391560f, 0.07890736f, 0.06076523f, -0.35269669f, 0.18128037f, -0.13699429f, -0.15510318f, 
    -0.21194051f, -0.11950154f, -0.19202849f, 0.04127636f, -0.02743277f, -0.01572383f, 0.11159609f, 0.25251371f, 
    -0.07704421f, 0.31538984f, 0.09923182f, -0.08505808f, -0.02702141f, 0.08163568f, -0.00701003f, 0.09664421f, 
    0.10914385f, 0.00818810f, -0.10440066f, -0.04800076f, 0.27927136f, 0.06544760f, -0.27448282f, -0.24255726f, 
    -0.03309916f, 0.52801341f, 0.09009605f, -0.16102636f, -0.36107773f, 0.26729685f, 0.16929138f, -0.17170395f, 
    0.31823939f, -0.16842110f, -0.28992707f, 0.03949508f, -0.14383589f, -0.17083319f, -0.06069096f, 0.19227080f, 
    0.01381038f, 0.06123214f, -0.08549667f, -0.15459803f, -0.02543958f, 0.09297094f, -0.11720509f, -0.09432096f, 
    -0.12888506f, -0.10317173f, -0.15203255f, -0.15234230f, -0.16537553f, -0.15020317f, -0.03043731f, -0.10656393f, 
    -0.03706114f, 0.07144616f, -0.05193476f, 0.11335011f, -0.02016813f, -0.12035093f, -0.19050536f, -0.16674411f, 
    -0.04718518f, 0.15000817f, -0.10654496f, 0.07059479f, -0.04543072f, 0.12705506f, -0.09110025f, -0.14279675f, 
    0.00990905f, 0.31732956f, 0.01316249f, 0.14360447f, 0.10444046f, 0.35616860f, -0.11570717f, 0.16911674f, 
    -0.08550312f, 0.13887124f, -0.12172949f, -0.01778018f, -0.06226664f, -0.06064105f, 0.37432775f, -0.10742238f, 
    0.04836185f, 0.14125091f, 0.16327046f, -0.13260348f, 0.17368259f, -0.31577358f, 0.00578846f, -0.07881942f, 
    -0.18946859f, 0.16907942f, -0.13162182f, -0.13124377f, -0.06544056f, -0.10919233f, 0.15808734f, -0.16893929f, 
    -0.15092579f, 0.20349568f, -0.05078539f, 0.02344900f, -0.04309257f, 0.22688609f, -0.16051388f, 0.14486596f, 
    -0.15941212f, 0.22034970f, 0.13899902f, 0.22375034f, 0.36764929f, -0.05877899f, 0.24796942f, -0.06726322f, 
    0.07718159f, -0.33415508f, -0.07091618f, -0.12899162f, -0.41356808f, 0.01227253f, -0.23447937f, -0.13269322f, 
    0.26973295f, 0.03528216f, -0.39294866f, -0.16934089f, -0.03382997f, 0.30868000f, -0.06554055f, -0.03838296f, 
    -0.12608495f, 0.26267403f, 0.03876784f, 0.10168859f, 0.10312650f, 0.08821709f, -0.14159666f, 0.13762496f, 
    0.10270531f, 0.34803665f, -0.11485182f, -0.16910787f, 0.28676891f, 0.14390321f, 0.32580799f, -0.02621858f, 
    0.11686637f, -0.24275172f, -0.16543880f, 0.00729795f, 0.09747537f, -0.09374917f, 0.25651777f, -0.02064638f, 
    -0.19363096f, -0.09846533f, 0.18912953f, 0.06058579f, -0.10297917f, -0.17113940f, -0.15182048f, 0.10942761f, 
    0.08864981f, 0.05949383f, -0.07950800f, 0.00834917f, 0.08395289f, 0.32782248f, 0.00720250f, 0.01456694f, 
    -0.00230739f, -0.21970870f, 0.02267906f, -0.06905869f, 0.37616718f, 0.09600450f, 0.55853015f, 0.19317210f, 
    0.13855039f, -0.37710172f, 0.02957481f, -0.02992790f, 0.29674771f, -0.05812202f, -0.22659636f, -0.02617923f, 
    -0.30098680f, 0.09359980f, -0.18465827f, -0.13310552f, 0.02240589f, 0.21030664f, 0.22594351f, -0.40800634f, 
    -0.13366295f, -0.20086792f, -0.02939314f, -0.12870799f, 0.07566532f, -0.10216013f, 0.21985388f, 0.12361607f, 
    -0.07082234f, 0.21558356f, 0.02796491f, 0.15381919f, -0.04188323f, 0.02377883f, 0.37194204f, -0.03082477f, 
    -0.04664572f, -0.48113307f, 0.07844896f, 0.15814374f, 0.37432024f, -0.30290762f, 0.22026819f, -0.07827328f, 
    0.20361660f, 0.03635501f, 0.00801005f, -0.07591208f, -0.07593603f, -0.07238232f, 0.10889536f, 0.27780461f, 
    -0.11538271f, -0.02263673f, 0.09610758f, 0.02615686f, -0.05688771f, 0.23637167f, -0.29718813f, 0.06075905f, 
    -0.08322322f, 0.26408949f, 0.04849698f, -0.04009781f, -0.09595861f, -0.11991390f, 0.05199125f, 0.06886186f, 
    0.02187468f, 0.02661457f, 0.05562919f, 0.04836588f, -0.21488148f, -0.18727276f, -0.17388289f, -0.12124106f, 
    -0.10871262f, -0.04714896f, 0.02355866f, 0.07827137f, 0.01455011f, 0.03616072f, -0.13088308f, 0.09390473f, 
    0.07519906f, -0.10301976f, 0.06442017f, 0.06948663f, 0.08625519f, 0.13847873f, 0.17130230f, 0.08686488f, 
    0.00030648f, -0.17302573f, -0.10631599f, -0.36351204f, 0.05849050f, 0.00843321f, -0.04822304f, 0.28056508f, 
    -0.14788735f, -0.21609214f, 0.11349124f, -0.15330908f, 0.37462789f, -0.04210978f, -0.11165439f, 0.11985250f, 
    0.15405275f, 0.13365597f, 0.27265567f, -0.07737541f, -0.17727879f, 0.20217311f, 0.25378859f, -0.18060671f, 
    -0.07259325f, 0.28716701f, -0.02964099f, 0.07065845f, 0.11539166f, -0.28453586f, 0.38523158f, 0.17361863f, 
    0.00816271f, 0.01516380f, 0.17796837f, -0.16808528f, -0.07425776f, 0.13405102f, 0.08615201f, -0.04775639f, 
    0.02851792f, 0.04425491f, 0.17403710f, 0.00438426f, -0.04811503f, 0.41921878f, -0.28250575f, -0.01033692f, 
    0.10417025f, -0.11942813f, 0.01255136f, -0.15640815f, -0.04238946f, -0.29484805f, 0.30615553f, 0.07785450f, 
    -0.05914583f, 0.22986424f, 0.04214574f, -0.04025422f, -0.09681179f, 0.17145941f, -0.36687011f, -0.10290243f, 
    0.08749146f, 0.06486642f, -0.12520401f, -0.25657603f, 0.26186198f, -0.08171561f, -0.16074657f, -0.23704757f, 
    -0.10463270f, 0.33111420f, 0.19779421f, 0.04571740f, -0.11315841f, 0.14214724f, -0.02584816f, -0.12342460f, 
    -0.20632450f, -0.16286853f, -0.00358187f, 0.04592076f, 0.02309705f, 0.07580085f, -0.02498512f, 0.08853418f, 
    0.11262966f, -0.27527782f, -0.04122526f, -0.02061412f, 0.09377371f, 0.18906374f, -0.08692951f, 0.03546404f, 
    -0.02035207f, -0.24445213f, -0.06750529f, -0.17211930f, 0.36833221f, 0.09432733f, 0.24872060f, 0.24659157f, 
    -0.01026782f, -0.23202689f, 0.12049720f, -0.05801031f, 0.31233549f, 0.10181110f, 0.22267404f, -0.05479133f, 
    0.03675736f, -0.01314420f, 0.42377773f, 0.09756120f, 0.00173699f, 0.13000053f, -0.04289707f, 0.06841651f, 
    0.05353427f, 0.06718980f, 0.09146573f, -0.00766201f, -0.03777482f, 0.09357905f, -0.00609202f, 0.12548737f, 
    0.00459038f, -0.12596203f, 0.00427856f, -0.29754221f, -0.11574195f, -0.08984099f, 0.08331329f, -0.10199259f, 
    0.15463719f, 0.50094783f, 0.02913585f, 0.12006657f, 0.09878822f, -0.09853947f, 0.19593558f, -0.01043451f, 
    0.19061793f, 0.13312532f, -0.29475135f, 0.11020949f, -0.04031655f, 0.18067011f, -0.25529063f, -0.15896229f, 
    0.09533001f, -0.21909690f, -0.05216319f, -0.04669999f, -0.00631157f, 0.13870226f, -0.34986424f, 0.13693552f, 
    -0.01739519f, -0.19247054f, -0.07967659f, -0.00602763f, 0.28947598f, 0.06453048f, -0.19407195f, 0.10963859f, 
    -0.17675857f, 0.11376428f, 0.22457075f, -0.02427155f, -0.33158356f, 0.23121415f, 0.08115976f, 0.01797673f, 
    0.07882311f, 0.01597353f, 0.13081650f, 0.13878991f, -0.10926279f, 0.40054712f, -0.17282593f, 0.22937132f, 
    -0.15233260f, -0.05526935f, -0.11278599f, -0.10365123f, 0.02434544f, 0.08087720f, 0.03752363f, -0.14460230f, 
    0.08508546f, 0.06653818f, 0.13111746f, -0.02856172f, -0.02826403f, 0.15111838f, -0.10153919f, 0.13728128f, 
    0.04753307f, -0.29213172f, 0.10322256f, 0.08738029f, -0.27125931f, 0.14511250f, 0.18088388f, -0.11242327f, 
    0.11838085f, -0.01021438f, 0.15220571f, -0.04838458f, 0.04320851f, 0.05874591f, 0.16562833f, 0.22671103f, 
    0.14873269f, 0.07933228f, -0.17902079f, -0.11785024f, -0.10799267f, -0.00457235f, -0.42502183f, 0.12755120f, 
    -0.16264215f, 0.12023044f, 0.08519432f, 0.36105075f, -0.25104085f, 0.13288735f, -0.17585154f, 0.25919503f, 
    -0.02344867f, 0.26889271f, 0.28513840f, -0.01304822f, -0.14564736f, 0.31211370f, -0.23758547f, -0.15258108f, 
    -0.07314251f, -0.15935023f, -0.05212593f, -0.05429310f, -0.17197271f, -0.29456478f, 0.19858482f, -0.17169657f, 
    0.17061691f, -0.06579596f, 0.07393931f, -0.04133095f, 0.07232712f, -0.08670852f, -0.18639319f, -0.16855231f, 
    -0.16017213f, 0.11134280f, 0.11079273f, -0.15088458f, -0.16477202f, 0.01282722f, -0.02933976f, 0.12782831f, 
    -0.11625069f, -0.15615159f, -0.12501428f, 0.06603844f, 0.04734334f, 0.03899465f, -0.12436797f, -0.06381886f, 
    0.05481933f, 0.03082680f, 0.14582701f, 0.09600947f, 0.01380675f, -0.06924687f, -0.05276617f, -0.00669966f, 
    -0.10648647f, 0.23906316f, -0.11256206f, -0.06150490f, 0.16886029f, -0.25777733f, 0.34126440f, 0.11262687f, 
    -0.02170156f, 0.26457229f, -0.15672009f, 0.49233025f, -0.11904769f, 0.00602158f, 0.15089399f, 0.09662744f, 
    0.04962509f, -0.32335103f, 0.10157039f, 0.13129248f, 0.24772741f, 0.16011655f, 0.19636716f, 0.15673865f, 
    -0.16247131f, 0.13141631f, -0.08337636f, -0.01641526f, -0.06222176f, -0.30495363f, 0.36149883f, 0.29207236f, 
    -0.17305696f, -0.13546401f, 0.10470252f, 0.09025357f, -0.15444282f, 0.05771419f, -0.21636353f, -0.16739437f, 
    0.02835792f, -0.14555044f, 0.15740667f, 0.15597416f, -0.19523224f, -0.06914094f, -0.34610733f, 0.28268212f, 
    0.10679337f, 0.37610692f, 0.19958320f, 0.07301296f, 0.28543830f, 0.22890697f, 0.02451545f, -0.00778190f, 
    0.07728424f, 0.00776938f, 0.11718035f, 0.07878663f, -0.07036462f, 0.23643728f, -0.01652210f, -0.12975539f, 
    0.05161475f, -0.19937409f, 0.08899979f, -0.00524885f, -0.09582113f, -0.07244658f, 0.01041464f, -0.13909155f, 
    0.03796983f, -0.19530410f, 0.14018619f, -0.39026305f, 0.36713502f, 0.15431128f, -0.01014065f, 0.20360492f, 
    -0.12009453f, 0.49183726f, 0.16945846f, -0.17563100f, -0.14202482f, 0.09857499f, -0.03112043f, 0.15795961f, 
    0.29968289f, -0.12142213f, -0.05797046f, 0.03069671f, 0.11154778f, 0.27619460f, -0.27207816f, 0.11585520f, 
    0.03654199f, 0.11104278f, 0.10918743f, -0.08293152f, -0.07007347f, 0.07499772f, 0.06210994f, -0.08529332f, 
    -0.13612717f, -0.19884920f, 0.08653450f, -0.11030528f, 0.14643563f, 0.02814537f, 0.11029163f, -0.14597723f, 
    0.00584281f, -0.06470571f, -0.01887233f, -0.03324546f, -0.17686665f, -0.14361288f, -0.07081137f, 0.04017422f, 
    -0.05603461f, 0.14456190f, -0.09922647f, 0.02148294f, 0.08192598f, -0.16133004f, 0.02469074f, -0.01295865f, 
    0.03989030f, 0.11844739f, -0.06313930f, 0.06850356f, 0.03205064f, -0.30706814f, -0.05026424f, -0.01740921f, 
    0.13896127f, 0.24097933f, 0.14689793f, 0.13166516f, -0.09701214f, 0.14350694f, -0.26483762f, 0.19655718f, 
    0.01677724f, 0.00942000f, 0.11043356f, 0.01075885f, 0.06383380f, 0.18676916f, 0.00512480f, -0.12250564f, 
    0.31670126f, -0.00209362f, 0.14700864f, -0.09251502f, 0.11917416f, -0.35640815f, -0.11965020f, 0.04320191f, 
    0.13080029f, -0.12611532f, 0.07689841f, -0.03639372f, -0.14375679f, 0.34254447f, -0.15997100f, -0.10010312f, 
    -0.12766047f, -0.09954082f, -0.14097148f, -0.23290314f, -0.30898392f, 0.17262641f, -0.24840979f, 0.29148489f, 
    -0.13179974f, -0.24992590f, 0.13237552f, 0.08177985f, 0.23419288f, -0.15100807f, 0.06663645f, 0.17906207f, 
    -0.29418501f, -0.05656188f, 0.46782804f, -0.00642302f, -0.11503849f, 0.29944015f, 0.26842359f, -0.05788908f, 
    -0.03128501f, 0.35300812f, 0.06331205f, -0.05601799f, -0.08593262f, 0.16868158f, 0.05699759f, 0.04917190f, 
    -0.03751891f, -0.03498809f, -0.14578125f, -0.13653637f, 0.08732124f, -0.09715493f, 0.31520271f, -0.00223445f, 
    -0.06916521f, 0.47648194f, -0.10645952f, -0.11252189f, -0.37179449f, -0.15238301f, -0.02971328f, -0.11875460f, 
    0.16977751f, 0.01723273f, -0.31885332f, 0.05786714f, -0.16936578f, 0.28277940f, -0.04502356f, -0.03874702f, 
    0.00963412f, 0.33457166f, 0.01891284f, 0.10609725f, 0.00974138f, -0.09755620f, 0.25977102f, -0.04647234f, 
    -0.03367507f, 0.15824346f, -0.11182803f, 0.04914825f, -0.33419225f, 0.14064722f, -0.23296891f, 0.14685459f, 
    -0.15921001f, -0.01502127f, 0.17879184f, 0.04046025f, 0.22248429f, 0.01542428f, -0.33668739f, -0.16067341f, 
    0.24266228f, 0.03537451f, -0.03141175f, -0.11872163f, -0.03321052f, 0.07743789f, 0.20286490f, -0.25929630f, 
    -0.15905496f, -0.06970209f, 0.12087162f, 0.13202728f, 0.03091903f, 0.08855989f, -0.06531501f, 0.05249785f, 
    -0.09053943f, 0.13476588f, -0.07698691f, 0.58235162f, -0.13176435f, -0.11436675f, 0.03377193f, 0.20842597f, 
    -0.07444038f, 0.31248748f, 0.08746143f, -0.12498032f, -0.07882976f, -0.21985725f, -0.31523329f, -0.06498744f, 
    0.09456473f, 0.16400348f, -0.42437211f, -0.05825443f, -0.03055687f, 0.16802025f, -0.14839044f, 0.23486336f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07558087f, -0.07921118f, 0.09292801f, 0.10106330f, 0.05113000f, -0.08701556f, 0.11138508f, 0.07709638f, 
    0.11246323f, 0.08985054f, 0.18832895f, 0.11438213f, 0.12597089f, 0.05842666f, 0.02033066f, 0.19429503f, 
    0.18425871f, 0.02359459f, 0.12185259f, -0.09133034f, 0.02539650f, 0.02915350f, -0.08996622f, -0.01232221f, 
    -0.00431757f, -0.01963244f, 0.10884608f, 0.01253875f, -0.04595323f, 0.06942888f, 0.12718628f, 0.06942529f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10564898f, 0.22413464f, -0.48294437f, 0.14329210f, 0.04317584f, -0.45744449f, -0.08133928f, 0.01223463f, 
    -0.15714704f, -0.08022515f, -0.25347647f, -0.54147363f, 0.19196686f, -0.32335439f, -0.14346807f, 0.08078132f, 
    -0.61405009f, -0.14756699f, -0.35992593f, -0.29368061f, -0.16002744f, 0.10413302f, -0.02907055f, 0.24411605f, 
    0.17591545f, -0.36754900f, -0.01464831f, 0.28387645f, -0.30511811f, -0.34262383f, 0.21036831f, 0.23348778f, 
    -0.01304119f, -0.21891555f, -0.13579692f, -0.19930664f, -0.18947810f, -0.20223841f, 0.29145807f, -0.11654089f, 
    0.08044791f, 0.23342966f, 0.24323784f, -0.65936297f, -0.11203680f, 0.17010397f, -0.43965164f, 0.26936841f, 
    0.06233844f, -0.42571726f, 0.04673101f, -0.20115966f, -0.14107983f, 0.11345412f, -0.11685217f, 0.08964654f, 
    -0.39610866f, 0.20104390f, 0.15118784f, 0.17180556f, -0.42756355f, 0.22626144f, 0.17676918f, 0.06090587f, 
    0.13855958f, 0.05086817f, 0.03563759f, -0.28032306f, 0.26781112f, -0.27184194f, -0.02688982f, -0.03981647f, 
    0.17833829f, -0.14817849f, 0.08542185f, -0.00379283f, 0.10456079f, -0.25498334f, -0.10717516f, 0.18323760f, 
    -0.22344127f, -0.11696092f, -0.68580949f, -0.44880319f, 0.13737160f, -0.49655274f, -0.10933558f, 0.29523647f, 
    -0.56475782f, -0.65113807f, -0.14271788f, -0.31848630f, -0.14582752f, 0.18758790f, -0.16868620f, -0.21376756f, 
    -0.14415516f, 0.02471625f, 0.12720773f, 0.02567493f, 0.11797176f, -0.22509761f, -0.08252495f, 0.08550296f, 
    -0.60280263f, 0.01772331f, -0.39337167f, -0.34549958f, 0.06498860f, -0.31326240f, 0.26011154f, 0.21520209f, 
    -0.38106352f, 0.20986696f, -0.23102607f, 0.10296762f, -0.01657732f, -0.41467276f, 0.15790124f, -0.11485872f, 
    -0.07004249f, 0.33465898f, -0.06317414f, 0.02296828f, -0.21057872f, 0.00696289f, -0.05677930f, 0.01515633f, 
    0.08601853f, 0.28412476f, 0.21099235f, -0.40232152f, -0.01393782f, -0.00484856f, 0.15154459f, -0.15102667f, 
    -0.10767540f, -0.24074979f, -0.21630983f, -0.69574124f, -0.30609563f, -0.11437349f, 0.11637755f, 0.19298406f, 
    0.19260697f, -0.12063063f, -0.19466086f, 0.02318026f, -0.05508290f, 0.04536034f, -0.11696260f, -0.13935088f, 
    0.15220925f, -0.10335448f, -0.10944574f, 0.09309100f, 0.22695531f, -0.15856962f, 0.15264994f, -0.27552474f, 
    0.08195049f, -0.17720987f, -0.30894551f, 0.14183894f, -0.32264936f, 0.52757871f, 0.01154226f, -0.11579079f, 
    -0.01141071f, 0.19393918f, -0.25963974f, 0.30383539f, -0.30522192f, -0.03963609f, -0.23149653f, 0.12016568f, 
    -0.00781562f, -0.16384672f, -0.55250025f, 0.15392122f, 0.07925591f, 0.30359596f, -0.06471297f, 0.10767635f, 
    0.04347036f, -0.01140765f, -0.00857180f, -0.16386901f, -0.01805168f, 0.09979805f, -0.16496494f, 0.21200906f, 
    0.15462483f, -0.00784831f, 0.39142132f, -0.33433038f, -0.27490032f, 0.26688713f, -0.36114410f, -0.17528553f, 
    -0.04448816f, -0.14757746f, 0.23155072f, -0.42520657f, 0.31218913f, 0.26921815f, -0.15336733f, -0.23872031f, 
    -0.11055865f, 0.02865777f, -0.66086042f, 0.03579718f, -0.02877276f, 0.05330447f, -0.10648479f, 0.14753552f, 
    -0.08301535f, -0.42587253f, -0.17503867f, -0.05238144f, 0.20337799f, -0.53758192f, -0.24240565f, 0.12647650f, 
    -0.20780633f, 0.07298657f, -0.12879729f, -0.25196859f, 0.16713290f, 0.12531663f, 0.18400374f, 0.16716917f, 
    0.05240794f, -0.28298000f, -0.21000138f, -0.24454241f, -0.33769655f, 0.02561452f, -0.09592314f, -0.34030259f, 
    0.14334562f, 0.10979250f, 0.38475320f, 0.19825366f, -0.17672595f, 0.01585829f, 0.06646801f, -0.45030755f, 
    0.22731124f, 0.18509655f, -0.00723273f, -0.20124352f, -0.05618804f, 0.15057759f, -0.22178830f, 0.04926911f, 
    0.06221885f, -0.41907597f, 0.00862278f, 0.36963525f, -0.03315023f, -0.17314743f, -0.18251555f, -0.10431650f, 
    0.27396196f, 0.37254405f, 0.12182739f, 0.50708860f, 0.12481447f, 0.14970262f, -0.03741465f, -0.32039279f, 
    0.00824824f, -0.21346077f, 0.14243565f, -0.35351351f, -0.30029830f, -0.24553759f, -0.16073006f, -0.16896071f, 
    -0.19474071f, -0.25693366f, -0.07007819f, -0.42376110f, -0.16992939f, 0.30870312f, 0.07952840f, 0.22650580f, 
    -0.28695375f, -0.18009233f, -0.26021934f, -0.00194259f, 0.07182029f, -0.21773386f, -0.61377805f, -0.15817550f, 
    0.21793570f, -0.36116612f, -0.01460531f, 0.58435571f, -0.04277336f, 0.03957033f, 0.22464760f, 0.27084610f, 
    -0.06988151f, 0.15684606f, -0.19328292f, -0.21873312f, -0.18158430f, 0.20342767f, -0.11014596f, 0.05562618f, 
    -0.04636040f, -0.41358769f, 0.04725586f, -0.10133713f, 0.31271109f, -0.29458073f, 0.12771669f, -0.34461510f, 
    -0.37847018f, -0.00099166f, -0.19223095f, 0.33409649f, 0.19009614f, 0.03409349f, 0.24585372f, -0.06401826f, 
    -0.10701413f, 0.17873995f, 0.40829062f, -0.09063507f, 0.13830064f, 0.00384205f, -0.19178221f, -0.08131093f, 
    0.23378903f, 0.19843058f, -0.31587404f, 0.02196212f, -0.02607247f, -0.18941915f, -0.11896688f, -0.10358030f, 
    -0.08109592f, -0.05418512f, 0.09748767f, -0.04120079f, -0.34652582f, -0.12415425f, -0.66206545f, -0.54752785f, 
    -0.14702551f, -0.27348399f, 0.39836594f, -0.12988867f, 0.14496854f, -0.25438890f, -0.39320239f, -0.03462097f, 
    0.04639353f, 0.11729252f, 0.06560497f, 0.27505729f, 0.03818507f, 0.16337131f, 0.04241262f, -0.24442896f, 
    -0.13397127f, 0.12704521f, -0.37046337f, 0.15926200f, -0.07698201f, -0.35251257f, -0.16451034f, -0.26661032f, 
    0.00777133f, -0.14684343f, 0.00493695f, -0.29953519f, 0.36782280f, 0.08256710f, -0.09758736f, -0.10070314f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11911508f, 0.13530667f, -0.05759161f, -0.01803413f, 0.11005029f, -0.07419199f, 0.06441750f, -0.17030223f, 
    0.08876195f, 0.12080891f, -0.05745980f, 0.12184285f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
