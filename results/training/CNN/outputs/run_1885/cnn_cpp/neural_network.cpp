#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34482050f, 0.23251256f, -0.52514863f, -0.21037306f, 0.65044880f, -0.52806920f, 0.04811772f, 0.02727927f, 
    0.03443691f, 0.09309094f, 0.19595826f, 0.30910990f, 0.28610379f, -0.29701212f, 0.20895953f, 0.00602473f, 
    -0.42136028f, -0.33221450f, -0.01842666f, 0.18154323f, 0.09016745f, -0.52670723f, 0.36199519f, 0.51682621f, 
    0.24975230f, 0.03811171f, 0.48077381f, -0.50631118f, 0.17866167f, 0.13206580f, 0.04542623f, 0.17751282f, 
    0.62222457f, -0.79916698f, -0.38563812f, 0.01619931f, -0.25809819f, 0.30625540f, 0.24521932f, 0.19886434f, 
    0.45920897f, 0.34474075f, 0.19343312f, -0.73620564f, 0.19866343f, -0.87350297f, -0.67009884f, 0.05766578f, 
    0.29892221f, 0.62617695f, 0.58499253f, -0.05675700f, -0.04768080f, 0.19223386f, -0.39386877f, -0.22470309f, 
    -0.32521835f, 0.22574517f, 0.45125028f, 0.53693455f, -0.25478354f, 0.53324479f, 0.06540736f, 0.50575000f, 
    -0.14262718f, -0.56596553f, 0.59925169f, -0.10279459f, 0.43554124f, -0.65545541f, 0.19747999f, 0.10326802f, 
    -0.39638761f, -0.49293035f, 0.98905593f, -0.13694102f, 0.68678880f, -0.53820789f, 0.26983649f, 0.01163068f, 
    0.04043616f, 0.11289810f, 0.07159666f, -0.45987177f, -0.52771562f, -0.38370633f, -0.60470921f, -0.28175855f, 
    -0.11542273f, 0.20842673f, 0.13166611f, 0.12411958f, -0.23250599f, -0.24787797f, 0.28178042f, -0.41025096f, 
    0.53926921f, 0.47098589f, 0.58204252f, -0.20957801f, 0.26840422f, 0.53085452f, 0.44690120f, -0.66607499f, 
    -0.27962768f, -0.43087128f, -0.02157816f, -0.40908578f, -0.61542338f, -0.35971874f, -0.42442897f, 0.28323823f, 
    -0.26437733f, -0.48413429f, 0.03121420f, -0.27261931f, 0.01425968f, -0.37582472f, 0.55706251f, -0.00426096f, 
    0.27104458f, 0.31115589f, 0.42187816f, -0.16630931f, 0.50918496f, -0.43811345f, -0.16200216f, -0.75263721f, 
    -0.15625842f, 0.03226106f, 0.21679640f, 0.56163329f, -0.27761608f, -0.22997797f, -0.44056448f, 0.55259311f, 
    -1.17928731f, 0.80658364f, 0.22075887f, 0.06655157f, -0.20916034f, -0.12541434f, -0.25413081f, -0.21098858f, 
    0.33799613f, 0.47089708f, 0.03618498f, -0.31904432f, 0.29184249f, -0.11412120f, -0.29032743f, 0.68950558f, 
    -0.50676733f, 0.61442506f, -0.18207686f, 0.26651564f, 0.39736611f, 0.07963328f, -0.09240992f, 0.11156588f, 
    0.45126683f, 0.27929831f, 0.12798756f, 0.24854575f, 0.17342608f, -0.11742565f, 0.20949802f, 0.10898361f, 
    -0.24929747f, -0.22610836f, 0.54839599f, 0.08683338f, 0.18470971f, -0.70635647f, -0.18111743f, -0.45979589f, 
    0.73582751f, 0.23779608f, -0.01630494f, -0.15339747f, 0.25758493f, -0.64465696f, 0.53270304f, -0.44437838f, 
    -0.10086617f, 0.43038356f, 0.43135524f, -0.47797877f, 0.47927266f, -0.43085024f, 0.13068770f, 0.16189186f, 
    -0.55980849f, -0.45442080f, -0.60979903f, 0.27112579f, 0.10504048f, 0.25638312f, -0.77459240f, -0.25444347f, 
    0.52959925f, -0.50136495f, -0.86696321f, 0.21751830f, 0.51795107f, 0.48537689f, -0.24507788f, 0.51423043f, 
    0.15042496f, -0.08316997f, -0.18977605f, 0.01852657f, 0.16182278f, 0.47605422f, 0.20887710f, -0.17171077f, 
    -0.29147843f, -0.44479242f, -0.26970637f, 0.08723813f, -0.03355474f, -0.05033494f, -0.54550707f, -0.26630241f, 
    -0.45622513f, 0.60306722f, 0.53727055f, -0.47027957f, -0.38674384f, 0.05029061f, -0.24501297f, -0.03264095f, 
    0.42256543f, 0.35911882f, -0.94318831f, 0.39007726f, -0.58103549f, 0.66228139f, -0.36398050f, 0.63015121f, 
    -0.20590729f, 0.37984481f, -0.06090757f, 0.58198893f, 0.04645550f, 0.84098440f, -0.44547457f, -0.17842445f, 
    -0.11200558f, 0.34858796f, 0.44512516f, -0.28966185f, 0.48452765f, -0.06996651f, 0.37973499f, 0.07169405f, 
    0.25018066f, 0.53545868f, 0.13768396f, 0.31993914f, -0.05057505f, -0.47846299f, 1.11815238f, -0.64571434f, 
    -0.19269037f, -0.05441049f, -0.00707790f, 0.21057989f, -0.18365671f, 0.40539798f, 0.07239816f, -0.10678514f, 
    -0.08134288f, -0.17895992f, -0.45228913f, -0.19965027f, 0.20205420f, -0.48374605f, -0.53781229f, 0.01502746f, 
    -0.40262815f, -0.42580211f, -0.51998729f, 0.13815811f, -0.47251245f, -0.18653482f, -0.16636099f, 0.60413587f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12626489f, 0.35556176f, 0.13285160f, -0.28427792f, 0.18638737f, -0.02550833f, -0.28027573f, 0.09858756f, 
    -0.18586399f, -0.31041536f, -0.11712937f, -0.07881505f, -0.16468892f, -0.11028510f, -0.36908138f, -0.11549381f, 
    0.12614511f, -0.21793532f, 0.22875832f, 0.17951682f, 0.28022018f, 0.42559090f, 0.19463085f, 0.02504067f, 
    0.34252706f, 0.28380960f, -0.04744584f, -0.22989954f, 0.23556478f, -0.14157371f, -0.33420858f, -0.09293436f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03348948f, 0.12759084f, 0.36959386f, -0.17964157f, -0.05473767f, 0.02957344f, 0.00082928f, 0.07548946f, 
    -0.02229226f, -0.07508218f, -0.12250980f, -0.00418467f, -0.04280240f, -0.04180066f, -0.00104112f, 0.09655011f, 
    0.04306364f, 0.08355079f, -0.10719878f, 0.10714090f, -0.09009538f, -0.00895593f, 0.06577366f, 0.00757841f, 
    -0.06353831f, -0.05310941f, -0.02235846f, -0.39735907f, 0.09812278f, -0.32491609f, -0.04821106f, -0.09588625f, 
    0.08258983f, -0.07728559f, -0.01072935f, -0.02791638f, 0.13778865f, 0.08633897f, 0.04208300f, -0.11334801f, 
    0.07820126f, 0.13480575f, 0.11442225f, 0.09119257f, 0.19661926f, -0.15461972f, 0.53790581f, 0.07898154f, 
    -0.08371486f, -0.08860260f, -0.19128105f, 0.04137015f, 0.07464183f, 0.03653564f, 0.10193094f, 0.21565859f, 
    0.05009163f, 0.07831611f, -0.25273710f, 0.01548331f, 0.01707889f, 0.08528900f, 0.04371086f, -0.28233090f, 
    0.10894994f, 0.12751096f, 0.11761914f, -0.07917198f, 0.08348960f, 0.09118275f, -0.00244781f, 0.15030581f, 
    -0.47598207f, 0.08252971f, 0.00493087f, 0.00579029f, -0.06685443f, -0.53452313f, 0.11111791f, -0.02431257f, 
    -0.09844776f, -0.02647781f, 0.22517464f, 0.22386886f, -0.06428061f, 0.04893286f, -0.14332710f, 0.14720415f, 
    0.02279291f, -0.16297927f, -0.10315528f, 0.03784335f, 0.04028901f, 0.13694844f, 0.02446568f, -0.03335634f, 
    -0.13905126f, -0.17826831f, -0.22058010f, -0.39989918f, -0.27665266f, 0.04082921f, -0.28474346f, 0.12676184f, 
    -0.31101391f, 0.11491113f, 0.03689777f, 0.00171678f, -0.08185523f, -0.14936347f, 0.19640268f, 0.02956125f, 
    0.07895024f, -0.10900219f, 0.07787741f, 0.00167779f, 0.16606790f, 0.01933481f, 0.36512196f, 0.04441723f, 
    -0.00002195f, 0.05357576f, 0.08747683f, -0.04962640f, 0.08439364f, -0.04616119f, -0.22145787f, 0.01082522f, 
    0.00211579f, 0.28506267f, 0.04663165f, 0.17029303f, -0.16856702f, -0.09641636f, 0.06975059f, -0.09317532f, 
    -0.23473351f, -0.47925088f, 0.08461764f, 0.02783694f, 0.21483147f, 0.13415706f, -0.14346589f, -0.05452967f, 
    -0.22083925f, -0.17575887f, 0.05848861f, -0.01260668f, 0.05717971f, -0.06644648f, 0.07097857f, 0.10330255f, 
    -0.04960316f, 0.02842963f, -0.07521203f, 0.09186798f, 0.06083821f, -0.02610378f, 0.19906068f, -0.05049999f, 
    -0.13682158f, -0.15351723f, -0.12686509f, 0.00154879f, -0.27965569f, -0.03409567f, 0.07222719f, 0.05121781f, 
    0.11525938f, 0.03317545f, -0.01624587f, -0.20212908f, 0.15682921f, 0.13131608f, 0.06498437f, 0.06986637f, 
    0.08857521f, 0.04102612f, 0.07242037f, -0.06658369f, -0.23510464f, -0.05636569f, 0.06928506f, 0.01632056f, 
    0.05049560f, -0.01209219f, -0.10690781f, 0.11497622f, -0.16446182f, 0.04424375f, 0.07910971f, 0.21765606f, 
    0.06588341f, -0.05080292f, -0.18674429f, 0.07572713f, -0.02837152f, -0.07865360f, 0.08567940f, 0.00010050f, 
    0.19363877f, -0.00643577f, 0.01679015f, -0.10197788f, 0.02381771f, 0.06064232f, -0.06037941f, -0.02916907f, 
    -0.03893038f, -0.12249956f, 0.12638722f, -0.03924811f, -0.00408416f, -0.03841733f, -0.08260269f, -0.05933263f, 
    -0.02559513f, -0.04698916f, 0.18153705f, 0.22168411f, 0.21727277f, 0.11147104f, 0.06860267f, -0.07786816f, 
    0.14962769f, -0.02650544f, 0.10149195f, 0.06938030f, 0.17860028f, 0.08176780f, 0.01961348f, 0.02487977f, 
    -0.00082124f, -0.32048011f, 0.02040777f, 0.22103450f, 0.35694781f, 0.01924937f, -0.12244096f, -0.19447325f, 
    0.21102780f, 0.08473619f, -0.04672379f, -0.03162336f, -0.23891413f, -0.24730881f, 0.07512474f, 0.23300396f, 
    0.11235604f, 0.03745740f, -0.06585886f, -0.25105816f, 0.00931544f, 0.11400770f, -0.02915336f, -0.03339756f, 
    -0.06716695f, 0.00161661f, 0.15075907f, 0.10225920f, -0.05834078f, -0.32304347f, -0.05534119f, 0.14483805f, 
    -0.04010753f, 0.12396736f, -0.07505688f, -0.01482421f, -0.17434293f, -0.16522783f, 0.15842929f, -0.21405442f, 
    0.27424806f, 0.21152537f, -0.19270226f, -0.14659289f, 0.09875330f, -0.17791739f, 0.12500335f, -0.07671736f, 
    0.32048982f, 0.20345283f, -0.01392543f, -0.25558808f, -0.05120262f, 0.02362978f, 0.02822525f, -0.03183060f, 
    0.01626893f, 0.02121311f, -0.03319599f, 0.05662078f, -0.03400948f, -0.04932713f, 0.01477326f, 0.01940555f, 
    -0.04229104f, 0.01191978f, 0.04962671f, 0.00693735f, -0.02132547f, -0.02902194f, 0.02225710f, -0.03272581f, 
    0.03776336f, -0.05468643f, 0.03142985f, 0.02288886f, -0.00208776f, -0.04083178f, 0.00419944f, -0.04768220f, 
    -0.05449031f, 0.04308962f, 0.01922763f, 0.04836918f, 0.04056291f, -0.05244128f, -0.02173373f, -0.00953478f, 
    -0.06628378f, 0.02032444f, 0.00849928f, -0.01221587f, 0.03230604f, 0.01839606f, 0.01344579f, -0.03865667f, 
    0.01857386f, 0.02230807f, -0.01590462f, -0.02870735f, -0.02626599f, 0.01562976f, 0.00828768f, 0.01852030f, 
    -0.03357372f, 0.02321643f, 0.01728794f, -0.06087679f, -0.01047533f, 0.03883997f, 0.03979835f, 0.01990716f, 
    -0.05471449f, 0.00554794f, -0.06245099f, -0.02279791f, -0.03576045f, -0.03764999f, -0.02659394f, -0.02272664f, 
    -0.01932492f, -0.05821714f, -0.01365980f, -0.06238388f, 0.04481350f, -0.02622500f, 0.03259817f, 0.03000068f, 
    0.01553197f, -0.00037794f, 0.05062827f, -0.03221448f, -0.04300096f, -0.05397434f, 0.03449720f, -0.00427670f, 
    0.03801616f, 0.01366706f, -0.03165067f, 0.01158930f, 0.00391303f, 0.02903105f, -0.01145076f, -0.01806980f, 
    -0.06224167f, -0.02881682f, -0.04461400f, -0.01474760f, -0.05399934f, 0.01686682f, -0.04488254f, -0.04816987f, 
    -0.03200676f, 0.03221054f, -0.05531672f, 0.00380860f, -0.03851481f, -0.00493447f, 0.03916027f, -0.06616607f, 
    -0.06540614f, 0.01932987f, -0.03690782f, -0.04895813f, -0.05452180f, -0.02057909f, 0.05204846f, 0.04430255f, 
    -0.00747380f, -0.05794450f, 0.03363221f, 0.01769372f, 0.03458677f, -0.00056081f, 0.00414522f, -0.05088411f, 
    -0.02540750f, -0.01694130f, -0.00140092f, -0.03257152f, -0.03529768f, -0.04421377f, -0.04741959f, -0.00642221f, 
    0.05051818f, 0.03576814f, 0.00201763f, -0.01911412f, -0.00972871f, -0.00626811f, 0.00681078f, -0.01312209f, 
    0.03072688f, -0.02559053f, -0.04154495f, 0.04249095f, 0.00692711f, 0.02317389f, 0.00639685f, 0.00450327f, 
    -0.06274531f, 0.01034183f, 0.01796789f, 0.03665368f, 0.02603967f, 0.00493037f, 0.02140613f, -0.01362030f, 
    0.05169927f, -0.03424377f, -0.01951606f, 0.04206910f, -0.05657149f, 0.00561533f, -0.03268841f, 0.01415358f, 
    -0.06020257f, -0.04872545f, 0.03554137f, 0.02663410f, -0.03789082f, 0.01871124f, 0.00988415f, 0.01339201f, 
    0.04611348f, 0.04785504f, 0.03556409f, 0.03715697f, 0.03422279f, -0.06705875f, 0.00185708f, -0.05767805f, 
    -0.02247348f, -0.06348339f, 0.04054862f, 0.03513142f, -0.01805555f, -0.01015075f, 0.03366560f, -0.03239476f, 
    -0.04767251f, -0.06120703f, 0.00463364f, -0.06054149f, -0.02066114f, 0.04213153f, -0.05674614f, 0.00552961f, 
    -0.06338129f, -0.01253418f, -0.05977543f, 0.02575873f, -0.00149241f, 0.03228348f, 0.00212374f, -0.06329925f, 
    -0.03103729f, -0.02238555f, -0.00368066f, -0.04373369f, -0.01716137f, -0.00531463f, -0.05338464f, -0.04507111f, 
    0.03475338f, -0.04226254f, 0.04723247f, 0.02050953f, -0.05946644f, 0.01890532f, -0.04704745f, -0.02950254f, 
    -0.00607404f, 0.01658478f, -0.06090938f, 0.01211450f, -0.05954744f, -0.01637084f, -0.01167518f, -0.02009275f, 
    -0.06315630f, 0.04048977f, 0.02973698f, 0.02129058f, 0.01209629f, 0.03486663f, -0.03129619f, -0.01426289f, 
    -0.03388086f, 0.02685654f, 0.00629176f, 0.02952809f, 0.01772431f, -0.01090500f, -0.00395422f, 0.03863445f, 
    0.05076056f, -0.04018793f, -0.05103915f, -0.04004616f, 0.04598977f, -0.04459648f, -0.03175807f, -0.02063511f, 
    0.00832897f, -0.02310067f, -0.06462152f, -0.02124530f, -0.02665405f, -0.01181710f, 0.02321398f, 0.04862365f, 
    -0.03735347f, -0.02872567f, -0.02959289f, -0.06210274f, 0.00810196f, -0.06254635f, -0.03164952f, -0.01685062f, 
    -0.01530773f, 0.01487808f, -0.01416950f, -0.03903109f, -0.02823029f, -0.02086710f, -0.01321587f, -0.02847475f, 
    -0.02443867f, -0.04416235f, 0.02245607f, 0.04629775f, 0.04717721f, -0.00185689f, 0.03175085f, -0.04104574f, 
    0.03546001f, 0.05223724f, 0.05247026f, 0.02399401f, 0.04687646f, 0.03803314f, -0.06483557f, 0.02436769f, 
    -0.55202115f, -0.16715091f, -0.27311498f, -0.16896923f, 0.19869511f, 0.13692440f, 0.12796466f, 0.08522134f, 
    0.12984361f, -0.24480009f, 0.07247813f, 0.09997828f, 0.05564878f, -0.19822374f, 0.03581228f, 0.06846203f, 
    0.07884909f, 0.12451635f, 0.10616677f, 0.14150850f, 0.07011607f, 0.02537999f, 0.04832067f, -0.02281631f, 
    0.01377412f, -0.10740960f, 0.02282188f, -0.37652728f, -0.31602800f, 0.19004001f, -0.01262321f, -0.06493706f, 
    -0.17761175f, -0.13907160f, 0.00651683f, 0.03937151f, -0.13961038f, 0.18137603f, 0.30230257f, -0.09917836f, 
    -0.16419315f, 0.01722129f, 0.07229515f, -0.13113235f, 0.21898274f, 0.20554474f, -0.42553821f, -0.26296949f, 
    -0.20490251f, 0.06328686f, 0.08845514f, 0.09573076f, -0.12537001f, 0.01890594f, -0.04827139f, -0.65282023f, 
    -0.27066883f, -0.12863711f, 0.11854988f, 0.11952823f, 0.13478689f, -0.12386690f, 0.05643390f, 0.30735853f, 
    -0.29680672f, -0.01770143f, -0.15669540f, 0.06179648f, -0.06519242f, 0.01364677f, 0.00208174f, -0.05355975f, 
    0.24673124f, -0.31225488f, -0.21411385f, -0.23252903f, -0.03995328f, 0.08427137f, 0.02175737f, -0.06481203f, 
    0.13286115f, -0.09785718f, -0.18033203f, -0.23529136f, -0.07875767f, -0.08876864f, -0.17542681f, 0.03740979f, 
    -0.00893515f, 0.12577587f, -0.16287903f, -0.10131229f, -0.25362903f, -0.03052991f, -0.00268211f, 0.03202427f, 
    -0.04728056f, -0.03375549f, -0.04628472f, -0.40015677f, 0.05177945f, -0.22894388f, -0.03434042f, -0.25695601f, 
    -0.21273348f, -0.03701870f, 0.11797485f, 0.10356958f, 0.29076663f, 0.23109448f, 0.02365837f, 0.14014716f, 
    -0.17247987f, 0.12737447f, 0.05942065f, 0.03785111f, 0.07463630f, 0.06840619f, 0.01056001f, 0.24514593f, 
    -0.11334431f, 0.06925569f, -0.12595174f, 0.04934517f, 0.01376161f, 0.05381607f, 0.30034292f, 0.14948189f, 
    0.11154890f, -0.24032855f, -0.04249709f, -0.12180192f, 0.11142520f, 0.16856720f, -0.16318943f, 0.60892934f, 
    -0.27831939f, -0.57049429f, -0.08979306f, 0.02710261f, -0.07013899f, -0.00510328f, -0.00439491f, -0.17415375f, 
    -0.39186487f, -0.03445158f, 0.27562037f, 0.02910139f, 0.09427817f, -0.04179738f, 0.06377122f, -0.01218115f, 
    0.07421891f, 0.13687652f, 0.04227173f, 0.10288513f, -0.06698736f, -0.05441177f, -0.05833221f, 0.09401779f, 
    0.01110885f, -0.15419844f, 0.00136811f, 0.10552023f, 0.32489899f, 0.04988567f, 0.05121916f, 0.04032391f, 
    0.06986258f, -0.00570274f, 0.08936145f, -0.06127828f, -0.12794752f, -0.09765386f, 0.06566448f, 0.04686284f, 
    -0.00171716f, 0.04856594f, 0.05444915f, -0.10118051f, 0.34678751f, 0.17165478f, -0.24299394f, 0.08568214f, 
    0.20102140f, -0.20118740f, 0.11548825f, 0.02711666f, -0.02385873f, 0.27342218f, 0.11311965f, 0.02910312f, 
    0.00822639f, -0.06475700f, 0.02797672f, 0.08200063f, 0.13639258f, 0.24275140f, 0.10701839f, 0.03406295f, 
    -0.14950833f, 0.09263723f, -0.00290705f, 0.02878302f, 0.04681015f, -0.07477312f, -0.04910666f, -0.16019295f, 
    0.14752659f, 0.25901034f, 0.02455550f, 0.06146574f, -0.02616425f, 0.00924224f, -0.04992479f, 0.10970493f, 
    0.21681362f, 0.18524992f, 0.00214143f, 0.07726165f, -0.02128134f, 0.04928079f, 0.12600514f, 0.08182187f, 
    -0.00608128f, -0.42306671f, -0.21323310f, -0.13589725f, 0.02494556f, -0.02003314f, 0.11280471f, 0.14105147f, 
    0.06040021f, 0.07630064f, -0.23953956f, -0.35612488f, -0.73576355f, -0.09237820f, 0.05459597f, 0.03873913f, 
    -0.16092622f, 0.07327008f, -0.16233823f, 0.17510723f, 0.09074324f, -0.06755333f, 0.01532718f, -0.31037489f, 
    -0.14660293f, 0.01339715f, -0.03925391f, 0.09680291f, -0.02020970f, 0.29595095f, 0.29638115f, -0.08523025f, 
    0.07229528f, -0.06217145f, 0.00704632f, -0.00346215f, 0.02948833f, 0.25905532f, -0.48881653f, -0.41320562f, 
    -0.11665988f, -0.06789852f, -0.14138623f, 0.26222706f, -0.04677438f, -0.01355516f, 0.02984650f, 0.09754483f, 
    -0.24707890f, -0.07257032f, -0.16967039f, 0.10304646f, 0.02979195f, 0.05613865f, 0.05161842f, 0.13754188f, 
    -0.22521740f, -0.30867589f, -0.09116245f, 0.05724272f, -0.11433427f, 0.09229162f, -0.03407809f, 0.01069192f, 
    0.09233762f, -0.21134812f, 0.09962569f, 0.00675237f, 0.24996109f, 0.04019178f, 0.12289047f, 0.05137839f, 
    0.05305952f, -0.06695614f, 0.12759261f, 0.08992478f, 0.10356434f, 0.01757181f, 0.00882141f, 0.02510963f, 
    0.05911379f, 0.23483248f, 0.20161441f, -0.00430052f, -0.18353428f, -0.06479607f, -0.04984516f, 0.06145004f, 
    0.05991263f, 0.09938391f, -0.03121107f, -0.15356216f, -0.12355825f, -0.46902290f, -0.18363157f, 0.03428937f, 
    0.03358463f, -0.00765809f, 0.04291907f, 0.08199774f, -0.00599259f, 0.00653598f, -0.14160195f, 0.05154065f, 
    0.08058178f, -0.06914920f, -0.02030985f, 0.05938698f, 0.08920941f, -0.18444198f, 0.17256375f, 0.10842508f, 
    -0.15797989f, 0.17565371f, 0.05044131f, -0.01324790f, 0.01606932f, 0.03010657f, -0.07622921f, 0.03951533f, 
    0.34612125f, -0.14024743f, 0.16616976f, -0.19311665f, 0.03815943f, -0.02721876f, 0.06419549f, -0.20836462f, 
    0.04369518f, -0.01078440f, -0.12092102f, 0.00828287f, 0.13249445f, 0.02350014f, 0.12562114f, 0.14738655f, 
    -0.20945950f, -0.47064418f, 0.04225684f, 0.17161900f, -0.02471584f, -0.17650412f, -0.00818439f, 0.04710196f, 
    -0.07960743f, -0.09907002f, -0.25465089f, -0.05053347f, -0.10114670f, 0.00378247f, -0.12280465f, -0.03641243f, 
    0.07154836f, 0.04287410f, -0.15568143f, -0.29094386f, -0.09202752f, -0.13756949f, -0.00765879f, -0.18946220f, 
    0.05897070f, 0.03292029f, -0.16084938f, -0.29177129f, 0.04809224f, -0.05804158f, -0.14124367f, 0.01504228f, 
    -0.20412654f, 0.16537310f, -0.11745355f, 0.08055700f, -0.16633119f, -0.04908636f, 0.19174837f, -0.12529950f, 
    0.00530495f, -0.10910448f, -0.09690929f, 0.00150408f, 0.20869449f, -0.05235548f, -0.09312989f, -0.11951119f, 
    0.13877818f, -0.09137458f, -0.12339113f, -0.02106017f, 0.07436850f, -0.00914020f, 0.15615888f, 0.04367163f, 
    0.09688593f, -0.04805683f, -0.08611041f, 0.05186009f, -0.03684562f, 0.13575564f, 0.21342672f, 0.17123951f, 
    -0.04845621f, -0.32995975f, -0.25735748f, 0.16512133f, 0.00060626f, -0.04517759f, -0.23404256f, -0.00482137f, 
    0.25748467f, -0.10376756f, 0.06140996f, -0.01129717f, 0.02509361f, 0.02810306f, -0.02982962f, -0.03803049f, 
    0.19390747f, -0.04052299f, 0.01223016f, -0.17614155f, -0.31551442f, 0.02125755f, -0.11220670f, 0.08036241f, 
    -0.10536295f, 0.00163153f, 0.07351101f, -0.01889202f, 0.02414771f, 0.03573868f, 0.12263973f, -0.02608525f, 
    0.09183025f, 0.06821549f, 0.11894262f, 0.20849900f, 0.07696266f, 0.05195187f, 0.11351863f, -0.00952987f, 
    0.01688872f, 0.13097292f, 0.16293076f, 0.11370768f, 0.32091463f, 0.04273961f, 0.20007606f, 0.08536444f, 
    -0.01613318f, 0.10694404f, -0.03766916f, 0.20355751f, -0.01542675f, -0.03248076f, -0.40290949f, 0.03999487f, 
    0.12493639f, 0.06516771f, -0.14176698f, 0.00374823f, 0.07382727f, -0.06823497f, 0.14682803f, -0.22399819f, 
    -0.08544642f, -0.01847093f, 0.10676590f, 0.03866514f, 0.05236745f, 0.03049866f, -0.10479105f, 0.13620672f, 
    0.16229150f, -0.10977829f, -0.08356646f, 0.03443132f, -0.05087842f, 0.01525553f, 0.06290367f, 0.08873640f, 
    0.17077464f, 0.19492713f, 0.18198414f, -0.04342349f, 0.09016693f, 0.06292792f, 0.06186470f, 0.07444996f, 
    0.14033651f, 0.33357701f, -0.00267929f, -0.06549678f, 0.02720454f, 0.05343284f, -0.06045207f, 0.10622730f, 
    0.09861547f, -0.07664792f, -0.39939979f, 0.03558615f, 0.08352392f, 0.10811169f, -0.05624791f, -0.17037866f, 
    -0.13781844f, 0.10576663f, -0.06303097f, 0.34255427f, -0.25988409f, -0.24474405f, -0.07521313f, -0.02225970f, 
    -0.09227729f, -0.00594403f, -0.05020432f, 0.05166034f, 0.09806206f, 0.24942371f, -0.02428964f, -0.14608586f, 
    0.07878789f, 0.07563775f, 0.02091671f, 0.08435450f, 0.05331707f, 0.07364151f, -0.76357031f, -0.61364949f, 
    0.02391931f, -0.29189613f, 0.11955317f, -0.01578411f, -0.19888303f, -0.31254536f, -0.11113742f, -0.19581467f, 
    0.11119170f, -0.26274943f, 0.03819771f, -0.25427029f, -0.05357200f, -0.05748065f, 0.24133712f, -0.11211960f, 
    -0.30567375f, 0.06484591f, 0.07772940f, 0.03772281f, -0.08964076f, 0.05486365f, -0.13516226f, 0.12416377f, 
    0.13610928f, 0.02028256f, 0.05918776f, 0.00554107f, 0.14410463f, 0.12324478f, 0.04523024f, 0.08157162f, 
    0.18677576f, 0.08956069f, 0.01481461f, 0.01574018f, 0.05362275f, -0.07124607f, 0.01567965f, 0.01896100f, 
    -0.01340193f, -0.02072839f, 0.01800887f, -0.01753763f, -0.06003232f, -0.01909545f, 0.08668216f, 0.07475039f, 
    0.12649398f, 0.22287832f, 0.27815139f, 0.03971552f, -0.17933390f, -0.07267775f, -0.03985569f, -0.09467973f, 
    -0.17215787f, -0.14292470f, -0.24192713f, 0.02955575f, -0.02518615f, -0.20663011f, 0.07298114f, 0.20434339f, 
    0.06486557f, -0.06000700f, -0.12288689f, 0.07259493f, -0.07031982f, 0.02258291f, 0.00493711f, 0.09365009f, 
    0.11930230f, 0.06909239f, 0.01291237f, -0.25351304f, -0.04879752f, -0.13170877f, 0.06081941f, 0.11064972f, 
    0.00750090f, 0.02396347f, 0.21010429f, 0.11673925f, 0.06247503f, -0.18576883f, -0.00204010f, -0.05898765f, 
    -0.02099644f, -0.10243188f, 0.16697387f, 0.01809414f, 0.00203916f, 0.19456995f, -0.13609070f, 0.31398734f, 
    0.38244909f, -0.11926389f, 0.22739166f, 0.08653590f, 0.08649497f, 0.06118623f, -0.24033476f, -0.01250382f, 
    0.08151766f, -0.20575728f, -0.08063319f, -0.12804775f, -0.00450922f, 0.16874234f, 0.07951775f, 0.03864309f, 
    0.15166925f, 0.13055229f, 0.10003453f, -0.01937543f, 0.04269982f, -0.02253530f, -0.13404638f, -0.05671415f, 
    0.28090283f, 0.15619375f, 0.27316156f, -0.11501969f, -0.22931062f, 0.06902735f, -0.00110048f, 0.08422156f, 
    0.08552556f, -0.14061497f, -0.23997344f, -0.11825540f, -0.12819314f, 0.09923755f, 0.04723000f, -0.12267864f, 
    0.04982989f, 0.10279998f, 0.07625153f, 0.10675780f, -0.06359820f, -0.02412280f, -0.17440119f, 0.04233086f, 
    0.05693373f, 0.00533306f, 0.09673613f, 0.05408645f, 0.07923309f, -0.03917129f, -0.25414509f, -0.10465544f, 
    -0.11317959f, -0.06553513f, -0.12287498f, -0.15847160f, -0.29955444f, -0.08939233f, -0.44729254f, -0.12289195f, 
    0.12367903f, 0.02152580f, -0.07862936f, -0.08572693f, -0.04910240f, 0.13913907f, -0.12189392f, -0.14611195f, 
    -0.06365666f, -0.03556157f, 0.05029655f, 0.09508375f, -0.01493381f, 0.20285526f, 0.03447095f, -0.08929908f, 
    -0.02053062f, 0.05396392f, -0.12368537f, -0.05857899f, 0.06711825f, 0.13602100f, 0.04061610f, 0.26855037f, 
    -0.04433766f, 0.18979162f, 0.05318559f, -0.14567326f, 0.06441218f, -0.02651104f, 0.08794707f, 0.11456444f, 
    0.07033084f, -0.04773012f, 0.09597430f, 0.19633210f, 0.06989983f, 0.29758820f, -0.03030969f, 0.03860014f, 
    -0.11225414f, -0.04493821f, -0.14761013f, 0.07215749f, 0.11203776f, 0.08002265f, 0.01584536f, 0.05625984f, 
    0.03807660f, -0.00785894f, 0.11675078f, 0.19344586f, 0.06755354f, 0.06690311f, 0.04604385f, 0.02020403f, 
    0.00838405f, -0.07362070f, 0.00526241f, 0.01993356f, 0.14795783f, 0.12617411f, 0.22673482f, 0.05450011f, 
    0.09159561f, 0.00493791f, -0.05788654f, 0.02654527f, -0.06721517f, 0.03970090f, 0.10770329f, 0.12478095f, 
    -0.00770638f, -0.09136743f, 0.17512730f, -0.09565453f, 0.10712201f, 0.06905373f, 0.03245053f, 0.11134060f, 
    -0.12075774f, 0.05451103f, 0.03869001f, -0.04789847f, -0.01114366f, 0.07051498f, -0.06495127f, -0.12259703f, 
    -0.09854650f, 0.03127385f, -0.05126886f, 0.08006980f, 0.15357931f, -0.02696158f, -0.03212569f, 0.15344790f, 
    0.03103063f, 0.06955620f, 0.09480630f, 0.13296068f, 0.34926277f, 0.06768873f, 0.11155180f, 0.13393304f, 
    0.03362057f, -0.15943232f, -0.09295646f, -0.02062899f, -0.08706422f, -0.04425138f, 0.09908962f, 0.16152990f, 
    -0.02663542f, 0.06731182f, 0.15649883f, 0.13446963f, -0.08216426f, -0.08267833f, -0.10547385f, 0.10254090f, 
    0.13798128f, 0.15531775f, -0.07358261f, 0.04153324f, 0.10412946f, 0.34890968f, -0.13312711f, 0.54675561f, 
    -0.20589294f, -0.11398376f, -0.10154469f, 0.12020215f, 0.10126542f, 0.07334397f, -0.31733200f, 0.04681613f, 
    -0.18602613f, -0.01001723f, -0.04925067f, 0.19524482f, 0.02114060f, 0.00605059f, 0.03187000f, -0.03654881f, 
    -0.13617875f, -0.14787352f, -0.07680422f, -0.00359214f, -0.06766838f, 0.10104518f, 0.00600833f, 0.18815897f, 
    0.04186551f, -0.04826014f, -0.01995052f, -0.05558552f, 0.02102806f, 0.01559186f, -0.00168967f, -0.02268660f, 
    -0.04713762f, 0.02596009f, -0.01961486f, 0.00287288f, 0.00643249f, -0.05919914f, 0.00512972f, -0.05234779f, 
    -0.05410470f, 0.00607893f, -0.02782172f, 0.01816946f, -0.02320096f, -0.05391358f, 0.00104566f, -0.02529091f, 
    -0.00848450f, 0.00798479f, -0.00252602f, -0.02331266f, 0.02206779f, 0.04511142f, -0.05762387f, 0.00220170f, 
    -0.04349883f, -0.00504127f, 0.02487550f, 0.04280355f, 0.01922296f, 0.00237149f, 0.04662322f, -0.02665810f, 
    -0.04254815f, 0.03393920f, 0.04898650f, 0.00947517f, -0.04794149f, 0.04983573f, 0.03893583f, 0.01887972f, 
    -0.05239448f, 0.04383942f, -0.00292998f, -0.04674576f, -0.05514153f, -0.06702576f, 0.04337153f, -0.00303435f, 
    -0.00367365f, -0.03496918f, 0.00843606f, -0.06466972f, -0.05028491f, -0.04430398f, 0.04824410f, -0.02395622f, 
    -0.06486587f, -0.02229088f, 0.00064237f, -0.02435310f, 0.02038561f, 0.00469204f, -0.03749342f, -0.05363765f, 
    0.04893823f, -0.02181558f, -0.05690221f, -0.00724632f, 0.00985703f, -0.04817403f, -0.05064933f, 0.05346626f, 
    -0.04031897f, -0.03049239f, -0.02854677f, 0.04676090f, 0.03849701f, -0.05125985f, 0.04505692f, -0.00622975f, 
    -0.05566467f, -0.00373597f, -0.01921739f, 0.05014421f, 0.02235009f, -0.00500471f, -0.04711591f, 0.01621123f, 
    -0.01273770f, -0.05806495f, 0.01744198f, -0.01537097f, 0.03750093f, -0.04972574f, 0.00009153f, -0.04522762f, 
    -0.01319949f, 0.04626700f, 0.04419944f, -0.03020903f, -0.02100157f, 0.00686669f, -0.05164877f, 0.02642341f, 
    -0.01382930f, 0.03627834f, -0.01681487f, 0.00887051f, -0.01621663f, 0.03684612f, -0.04599959f, 0.04023401f, 
    0.00678512f, -0.03383773f, -0.00686302f, -0.06653113f, 0.03043335f, 0.01062960f, 0.01241756f, -0.00908684f, 
    0.02044372f, 0.02967957f, 0.03811141f, -0.02789457f, 0.05484372f, 0.04462139f, -0.02538969f, 0.01201682f, 
    -0.00251954f, -0.04997084f, -0.01134023f, -0.02595404f, 0.03652931f, 0.01100498f, -0.01375656f, 0.01455513f, 
    -0.00867112f, -0.02678677f, -0.03591620f, 0.02335048f, 0.00458104f, 0.04239099f, 0.05086173f, 0.01117739f, 
    -0.06068157f, -0.06236693f, 0.01652200f, -0.02966914f, 0.01776892f, -0.04895156f, -0.06191019f, -0.02421051f, 
    -0.01597918f, -0.06619744f, 0.01550357f, 0.04286439f, -0.00640076f, -0.06456239f, -0.03084967f, -0.00675808f, 
    0.03027363f, -0.00196993f, -0.02520197f, 0.03621366f, 0.01392066f, -0.00254466f, 0.03062358f, -0.03148462f, 
    0.00761421f, -0.06057118f, -0.01787186f, -0.00863119f, 0.01166984f, -0.01756234f, -0.01251086f, 0.04029904f, 
    -0.04125854f, -0.04182396f, -0.05980067f, 0.01791059f, 0.05521142f, 0.01118627f, -0.05930112f, 0.00400592f, 
    0.03142839f, -0.00079633f, -0.02252064f, -0.02220248f, -0.05992773f, 0.04321959f, 0.01399474f, -0.02200299f, 
    -0.00830067f, -0.05981912f, 0.01938055f, -0.01348137f, 0.01837620f, 0.02070511f, -0.03023154f, -0.05159334f, 
    0.03021429f, -0.05425671f, 0.04744973f, 0.00779618f, 0.01489640f, -0.04963919f, -0.01115619f, 0.04580154f, 
    -0.06550856f, -0.00616614f, -0.02337367f, -0.06247624f, -0.00474911f, -0.01944724f, 0.04998275f, 0.02690894f, 
    -0.02469359f, 0.03379926f, 0.02072424f, 0.05072102f, -0.03888768f, 0.04761940f, -0.02787346f, -0.05425424f, 
    -0.02743947f, -0.02101632f, -0.02682580f, -0.00431058f, -0.00840428f, 0.01053067f, -0.00085572f, 0.02003503f, 
    -0.03063468f, -0.05012996f, 0.00053947f, -0.05092361f, -0.02381535f, -0.01427238f, -0.04031532f, -0.02370385f, 
    0.02470656f, 0.01628957f, -0.00387842f, 0.00776285f, 0.03492108f, -0.02416536f, -0.05837121f, 0.01910307f, 
    0.03242153f, -0.03578828f, 0.04156722f, -0.05418178f, 0.04186948f, 0.01439021f, -0.03169681f, 0.01957990f, 
    -0.05853795f, 0.01565645f, -0.04332811f, -0.05296594f, -0.03664672f, -0.00745811f, 0.02193183f, -0.06796648f, 
    -0.04489213f, -0.05078645f, 0.00125762f, -0.06040623f, 0.03037172f, 0.03992525f, -0.02506649f, 0.01153398f, 
    0.03610745f, -0.06664271f, -0.06482869f, -0.03206207f, -0.06078390f, 0.04149656f, 0.03569563f, -0.01174338f, 
    -0.36751097f, -0.30106291f, -0.04420420f, 0.17747040f, -0.07105008f, -0.11276276f, -0.07778285f, 0.16305429f, 
    0.19717759f, -0.15121289f, -0.08317067f, -0.03042125f, 0.06414974f, -0.11350149f, -0.06965873f, 0.00468193f, 
    -0.05735973f, -0.05596600f, 0.04884695f, -0.18453166f, -0.02132899f, 0.10792477f, -0.05705848f, -0.01411322f, 
    0.06265369f, 0.04964517f, -0.03855837f, -0.20499004f, -0.13682398f, 0.16346195f, 0.10173997f, 0.05691729f, 
    0.03010760f, 0.06484614f, 0.15242995f, 0.02403522f, -0.09367749f, -0.08954970f, -0.18135907f, 0.06597266f, 
    -0.13772300f, 0.04609368f, 0.05074044f, -0.06017762f, -0.01090107f, 0.25555971f, -0.49656564f, -0.22947320f, 
    0.10029909f, 0.06156149f, 0.06980161f, -0.11448078f, 0.04197806f, -0.01040395f, 0.12436893f, -0.15789714f, 
    -0.19594106f, 0.00278130f, 0.00848240f, 0.02076314f, -0.06652720f, -0.07022838f, -0.03397373f, 0.14955673f, 
    0.03659533f, -0.24437596f, -0.00258113f, -0.07382727f, -0.09358985f, -0.01318061f, 0.08480036f, -0.01050063f, 
    0.17747393f, 0.00771584f, 0.17860603f, 0.16348818f, 0.06994343f, -0.06397609f, -0.10032949f, 0.05063058f, 
    0.04513384f, 0.08425854f, 0.11847104f, 0.13254054f, 0.00939348f, 0.03320299f, 0.04009986f, -0.03261314f, 
    -0.10976865f, -0.00767885f, 0.12165504f, 0.04550046f, 0.23053564f, -0.07388045f, -0.06405772f, -0.08022538f, 
    0.06616161f, -0.01719523f, -0.07281739f, -0.27105799f, -0.20015173f, -0.00653306f, 0.05887229f, 0.04507723f, 
    -0.01354597f, 0.00045853f, -0.03397457f, -0.10245957f, 0.33847097f, 0.23806833f, 0.00973215f, 0.05409032f, 
    0.16202039f, 0.04470756f, -0.12887655f, 0.04871216f, -0.00159741f, -0.23303477f, -0.01953575f, -0.18354277f, 
    0.12855214f, -0.03141052f, 0.04076916f, -0.01334068f, -0.10206975f, 0.15380701f, 0.35958153f, -0.22079225f, 
    0.12636206f, 0.08149910f, 0.09811760f, 0.04103110f, 0.05153857f, -0.10251138f, 0.00193962f, 0.46098837f, 
    -0.38055858f, -0.18132436f, 0.06606185f, 0.06116205f, 0.15911758f, -0.05378868f, -0.13366356f, -0.02685774f, 
    -0.29468155f, -0.21390569f, -0.03972507f, 0.12437852f, 0.14042316f, 0.14809862f, -0.02186925f, 0.06789982f, 
    -0.04106554f, -0.21364263f, -0.28737673f, -0.14236720f, 0.11283512f, 0.06818964f, 0.11110634f, 0.05596798f, 
    -0.13205521f, 0.07712923f, -0.10576262f, -0.19553846f, -0.04765181f, 0.12810233f, 0.09939700f, 0.01032454f, 
    0.02990536f, -0.09072942f, -0.12781969f, 0.13654503f, 0.12306792f, -0.02479590f, 0.00094904f, 0.07734364f, 
    -0.12051467f, 0.06766412f, 0.10191517f, 0.06378040f, -0.16167133f, 0.16143301f, 0.05135915f, -0.03520169f, 
    -0.01636001f, -0.05526092f, -0.13865940f, 0.08438575f, 0.02057147f, 0.02172333f, 0.20647258f, 0.15956469f, 
    -0.00591840f, 0.08442702f, -0.03121648f, -0.02827585f, 0.03504457f, 0.04216932f, 0.07134045f, 0.17087166f, 
    0.21060377f, -0.05452029f, 0.01813811f, -0.03554297f, 0.11609413f, 0.20018949f, 0.05750329f, 0.07243481f, 
    -0.10845321f, -0.09132735f, -0.00113089f, 0.13792591f, -0.03798797f, -0.05725477f, 0.05663799f, -0.00812436f, 
    0.23071401f, 0.05596495f, 0.18140212f, -0.00855879f, 0.05595764f, 0.03979237f, -0.07034602f, -0.00252494f, 
    0.01396772f, -0.08963042f, -0.40321866f, -0.17261569f, 0.06732529f, 0.06546561f, -0.04679960f, 0.01154193f, 
    0.09761361f, -0.05261654f, -0.29555714f, 0.10801230f, -0.11618007f, -0.16507567f, -0.00768747f, 0.20865045f, 
    -0.00566373f, 0.13848229f, 0.12893568f, -0.08932243f, -0.09796344f, 0.06053218f, -0.11135051f, 0.23063970f, 
    0.15801273f, -0.12344696f, -0.00548202f, -0.09256342f, -0.01058142f, -0.35420540f, -0.27458608f, 0.02991366f, 
    -0.05571575f, 0.01325173f, -0.00505145f, -0.09543406f, 0.00880548f, 0.01760476f, -0.14325275f, 0.04459491f, 
    0.05171025f, -0.01545393f, 0.22458342f, 0.00261237f, 0.21021779f, 0.13292146f, 0.17714524f, 0.27526227f, 
    0.01920068f, -0.07536075f, 0.02340420f, 0.05303327f, -0.05543334f, -0.04456754f, 0.11294235f, 0.20585631f, 
    0.15777449f, 0.23241843f, -0.04818659f, -0.03790079f, 0.08315663f, 0.07297265f, 0.00109620f, 0.11375103f, 
    -0.00652994f, 0.00298133f, -0.03625339f, 0.01073221f, 0.04592172f, 0.03864871f, -0.06470075f, 0.01109545f, 
    -0.01051158f, 0.02736224f, -0.04990130f, -0.06050941f, -0.04184652f, -0.03019978f, -0.01642094f, 0.03837534f, 
    -0.04722627f, -0.01065645f, -0.03765563f, 0.03779807f, -0.00409083f, 0.04347607f, -0.00782009f, -0.04175404f, 
    -0.04420739f, 0.04240618f, -0.02688846f, -0.06440604f, 0.02476881f, 0.00192020f, -0.02724452f, -0.02645100f, 
    -0.05132036f, 0.02660916f, -0.06233322f, -0.04504909f, -0.06837612f, 0.01196149f, -0.00247182f, -0.02726855f, 
    0.03138799f, 0.03002628f, -0.00212539f, 0.03830573f, -0.06564166f, -0.06756446f, 0.03389861f, 0.00516131f, 
    0.03675619f, 0.05623244f, -0.00077716f, 0.05069406f, -0.01587920f, -0.01636101f, 0.04643191f, 0.03149335f, 
    -0.05992083f, -0.05747491f, -0.02555736f, -0.03255546f, -0.00165245f, 0.00158091f, -0.04780678f, 0.04064927f, 
    -0.04999297f, 0.01031580f, -0.04744973f, 0.03862391f, -0.02179223f, 0.02150592f, 0.03402002f, -0.00906473f, 
    0.02440075f, -0.03943694f, -0.04644834f, -0.02766374f, -0.02995867f, 0.03086532f, -0.03919886f, -0.03494253f, 
    -0.01002313f, -0.02299270f, 0.00420369f, -0.06236526f, -0.01636294f, -0.03266413f, -0.04399593f, 0.03085691f, 
    -0.05152168f, -0.05253373f, -0.03181666f, 0.01775412f, 0.02787004f, 0.00937826f, -0.05009320f, -0.04467098f, 
    -0.01064772f, -0.05868976f, -0.03942686f, -0.06510554f, 0.03097385f, -0.01957894f, -0.00507443f, 0.04129782f, 
    -0.06512757f, 0.00445801f, -0.03426128f, 0.02378562f, 0.01995522f, 0.04152456f, -0.03877054f, 0.02081421f, 
    0.04388233f, 0.00468566f, -0.00829493f, 0.01673907f, 0.00685662f, -0.06822368f, 0.01593553f, 0.01289853f, 
    0.04772983f, 0.01535418f, -0.06507274f, 0.05085607f, 0.01941482f, -0.02239185f, -0.00265809f, -0.05288415f, 
    0.03399502f, -0.02994948f, 0.03760565f, 0.00113990f, 0.00930369f, 0.03514921f, -0.03336194f, 0.01798941f, 
    0.02258932f, -0.05521743f, 0.04370160f, -0.03202384f, -0.00752392f, 0.02793371f, -0.04751477f, -0.03060860f, 
    0.04281063f, -0.01810302f, -0.05212832f, 0.01897000f, -0.00454591f, -0.03601588f, -0.01090535f, 0.01950872f, 
    -0.00915135f, -0.06358552f, -0.02774753f, -0.02286356f, -0.01171742f, -0.05537425f, -0.01426282f, -0.04143449f, 
    0.00161577f, -0.03887146f, 0.01629976f, -0.02790242f, -0.03908770f, 0.03094977f, -0.02384813f, 0.00828795f, 
    -0.00985455f, -0.03047976f, 0.04031353f, -0.06667993f, -0.06891298f, -0.02609812f, 0.03880955f, 0.00253680f, 
    0.02749965f, 0.03119949f, 0.01874165f, 0.00532271f, 0.03068608f, -0.04412504f, -0.01406176f, 0.03744460f, 
    -0.05316790f, 0.02019072f, 0.01141461f, -0.02145510f, -0.00314750f, 0.00107827f, 0.02491955f, -0.04230863f, 
    -0.04326125f, 0.01811300f, 0.02953637f, -0.03062743f, -0.03880988f, 0.00360665f, -0.00564341f, -0.01413464f, 
    -0.00667399f, -0.06174470f, -0.01800539f, -0.02473263f, 0.00831727f, -0.00067292f, 0.01387943f, -0.00249831f, 
    -0.03986943f, 0.02576556f, -0.00348300f, 0.03486648f, -0.04935802f, 0.01495677f, -0.00188432f, 0.03235837f, 
    -0.02434345f, -0.02970013f, -0.05154197f, -0.06030622f, 0.03854663f, -0.03172805f, -0.05294902f, -0.03045538f, 
    -0.03984176f, 0.03509273f, -0.00858234f, -0.02403333f, 0.01284301f, -0.05665684f, 0.01481429f, 0.03224040f, 
    0.00196840f, -0.04586067f, 0.04491715f, -0.05140737f, 0.03873721f, 0.03859223f, -0.02218290f, 0.02729957f, 
    -0.03893513f, -0.02914662f, -0.01689976f, -0.02789927f, -0.01629191f, 0.05170405f, -0.01076369f, -0.02301255f, 
    0.02858569f, -0.01122609f, -0.03213129f, 0.04228920f, -0.00864103f, -0.02487450f, 0.00456445f, -0.07032623f, 
    0.04533704f, 0.00337192f, -0.00102648f, 0.03222372f, -0.05914443f, -0.00304949f, -0.04815772f, -0.01216272f, 
    -0.04969429f, -0.02729657f, -0.01996001f, 0.02584281f, 0.01599116f, -0.03924975f, 0.04156844f, -0.04728457f, 
    0.01327708f, 0.03194681f, -0.02648385f, 0.02912530f, 0.00403231f, 0.03045053f, 0.02695073f, -0.05584022f, 
    -0.02657501f, 0.01766643f, 0.03221461f, -0.02041271f, -0.06330065f, -0.00822039f, -0.06034146f, -0.00324951f, 
    -0.02319049f, -0.05632785f, -0.03019959f, 0.01182646f, 0.04446294f, 0.00310156f, -0.01763228f, 0.02351402f, 
    0.05167263f, 0.02246705f, -0.03545051f, 0.01445980f, -0.04181432f, 0.03211062f, -0.03881804f, -0.04622665f, 
    0.00038923f, -0.01327278f, 0.02343063f, 0.00826463f, -0.01050435f, 0.04597056f, -0.05818198f, 0.01236013f, 
    -0.02639968f, -0.00894054f, -0.04067554f, 0.02436940f, 0.04294117f, 0.01331765f, -0.04639868f, -0.00444000f, 
    -0.02343079f, -0.02055346f, 0.00716623f, -0.03666904f, -0.00619720f, 0.02604362f, -0.04445507f, 0.03606583f, 
    0.01960184f, 0.04928766f, -0.05439832f, 0.03608354f, 0.02248097f, 0.05204180f, 0.00045680f, 0.01732448f, 
    -0.04298802f, 0.05177072f, 0.04475230f, 0.00694926f, -0.01560103f, -0.02177820f, -0.05326739f, -0.01855468f, 
    -0.03655332f, 0.02714305f, -0.04804554f, 0.02803441f, 0.01761168f, -0.06012816f, -0.02652827f, -0.02401339f, 
    0.02962870f, -0.01448167f, -0.02610689f, -0.03912248f, 0.01234725f, -0.01436349f, -0.01139476f, 0.03302061f, 
    0.04245323f, -0.01960311f, -0.02847617f, -0.03815584f, -0.04408123f, -0.06040127f, 0.04774417f, 0.03429354f, 
    -0.05796953f, -0.02847291f, 0.02732215f, -0.03924763f, 0.04823336f, 0.01892375f, -0.05911960f, -0.00255414f, 
    0.01515258f, -0.00360771f, 0.03041005f, -0.00007212f, -0.07023706f, -0.04438570f, -0.03390819f, 0.02108122f, 
    -0.01478816f, -0.02152821f, -0.05949225f, 0.02250260f, -0.00136633f, 0.01727903f, -0.02197211f, 0.02675532f, 
    -0.03408403f, 0.04171543f, -0.04552841f, -0.00470190f, -0.03333910f, 0.04430448f, 0.00165236f, -0.04009965f, 
    0.02191984f, 0.03479116f, 0.04526893f, -0.03658223f, -0.02315355f, 0.00780500f, 0.00653372f, 0.03274970f, 
    0.03905437f, 0.02645114f, 0.02522149f, -0.05349528f, 0.00663174f, 0.04274026f, 0.04186898f, 0.03081439f, 
    0.00990284f, 0.00487296f, 0.03366268f, 0.02023473f, -0.00193460f, -0.01921685f, -0.05332000f, 0.03778483f, 
    0.00669413f, 0.00019324f, 0.01344893f, -0.04166407f, 0.02521496f, 0.02017944f, 0.03126022f, -0.05307406f, 
    -0.03715274f, 0.00089099f, 0.01253499f, -0.00088270f, -0.05474936f, -0.05890508f, -0.07250591f, -0.01220200f, 
    0.01520846f, 0.01204186f, -0.01460655f, -0.01234092f, -0.02546022f, -0.06946588f, -0.04748476f, 0.00961274f, 
    -0.03291853f, 0.04417841f, 0.00121635f, -0.05888850f, 0.02407036f, -0.03104864f, -0.05362615f, -0.01284423f, 
    -0.00803083f, -0.00746664f, -0.00443031f, 0.04261759f, -0.05820081f, 0.04422334f, 0.00853762f, -0.00484577f, 
    -0.01144143f, -0.04486942f, -0.06054299f, 0.03831263f, 0.00276784f, 0.05049716f, -0.07237399f, -0.05622357f, 
    0.00776068f, -0.00993483f, -0.05474362f, -0.01423796f, -0.02040882f, -0.03398018f, -0.04576378f, 0.03110608f, 
    -0.05254846f, -0.04943746f, -0.06094161f, -0.04581093f, -0.03878860f, -0.03537727f, -0.06194322f, 0.02472594f, 
    0.03000756f, 0.01091332f, 0.00823604f, 0.04564495f, -0.03238753f, -0.00474253f, -0.02842020f, -0.00155385f, 
    -0.03985389f, -0.01963370f, -0.02221581f, -0.04513129f, 0.02181137f, 0.02462987f, 0.01462666f, -0.04638328f, 
    -0.01294802f, 0.02611472f, -0.00783891f, 0.01054235f, 0.01586878f, 0.00250644f, -0.05171435f, 0.05096555f, 
    0.00730605f, 0.04314643f, -0.04665181f, 0.00896251f, 0.02069278f, -0.00571685f, 0.04230911f, -0.04182190f, 
    -0.02630829f, 0.00474652f, -0.03616825f, 0.00739868f, -0.02770576f, -0.00377996f, -0.05802940f, 0.01301414f, 
    -0.01653592f, 0.03036270f, 0.02403130f, 0.02213994f, 0.02613959f, 0.02150549f, -0.03706074f, -0.06527678f, 
    0.01368386f, 0.02400897f, -0.06951494f, -0.03779585f, -0.04033430f, 0.00683475f, 0.04589147f, -0.04447723f, 
    -0.06192765f, -0.02977210f, -0.01194074f, -0.05232120f, 0.01760888f, -0.00444851f, 0.06572484f, -0.04897346f, 
    0.00526506f, -0.01024346f, -0.05131311f, -0.02835229f, 0.03322500f, 0.00935970f, -0.02655900f, 0.04423607f, 
    -0.01602530f, 0.02279766f, 0.02887585f, -0.03324158f, 0.00359445f, -0.05912500f, -0.06699246f, 0.00278488f, 
    0.01061377f, -0.05078103f, 0.02351275f, 0.03108483f, -0.04593264f, -0.04543937f, 0.01057666f, -0.02291785f, 
    0.03810554f, 0.00696872f, -0.04875804f, 0.11126275f, -0.14307597f, 0.06091008f, 0.01471053f, 0.01385486f, 
    -0.02331051f, -0.03167357f, 0.04735128f, 0.00923959f, 0.00258631f, -0.02938849f, -0.04351335f, -0.28205022f, 
    -0.15228766f, -0.31560463f, 0.14826596f, 0.19090790f, 0.08044017f, -0.08044201f, -0.06594234f, 0.09621387f, 
    -0.08904450f, -0.04644885f, 0.08875784f, 0.25489089f, 0.25067377f, -0.01291036f, 0.02030438f, -0.12485263f, 
    0.20834842f, -0.17019179f, -0.10678238f, -0.22321881f, 0.07420118f, 0.09428025f, -0.07136396f, 0.04253917f, 
    -0.08569387f, 0.07581621f, -0.06710231f, -0.02892590f, -0.09995078f, -0.08102145f, -0.00526384f, -0.08155182f, 
    0.13380535f, -0.01215281f, 0.11117249f, -0.02737954f, -0.00900555f, -0.02093301f, 0.06294116f, 0.07123702f, 
    0.13989404f, 0.06065717f, -0.06745300f, -0.00752142f, -0.03142014f, -0.13488345f, 0.00028088f, 0.00795739f, 
    -0.01846047f, 0.09331044f, -0.09426297f, -0.16338181f, -0.04044206f, -0.10654169f, -0.12175175f, -0.06968343f, 
    -0.13593100f, 0.51235777f, 0.35717198f, 0.07419870f, 0.12652330f, -0.01427049f, -0.17175989f, 0.07486498f, 
    0.02800586f, 0.18132485f, 0.25317007f, -0.16000760f, 0.03728222f, 0.01843359f, 0.05411822f, 0.18640609f, 
    0.07507899f, 0.04270239f, 0.14235216f, 0.14878170f, 0.01189523f, -0.19389284f, -0.13167958f, -0.00983943f, 
    0.11078711f, 0.16561876f, 0.27968353f, 0.02355875f, -0.07855598f, -0.11583173f, 0.09036832f, 0.11355636f, 
    -0.02233755f, -0.13266058f, -0.12268274f, -0.12280491f, -0.00130526f, 0.07682429f, 0.01400566f, 0.05470395f, 
    0.17036109f, -0.15301128f, -0.02533299f, -0.12020019f, -0.14030321f, -0.03207695f, 0.00524884f, 0.01447615f, 
    0.22639129f, 0.23211774f, 0.06226239f, -0.15453751f, 0.00484196f, -0.16181527f, -0.14085911f, 0.07264879f, 
    -0.36010635f, 0.05991843f, -0.06055192f, 0.18843263f, -0.21481235f, -0.00083888f, -0.25952727f, 0.12764156f, 
    0.36612895f, 0.20270129f, 0.06855860f, 0.07388112f, 0.08832403f, -0.17656423f, -0.13021505f, -0.06376766f, 
    0.08009470f, 0.09052487f, -0.05611436f, 0.20378935f, 0.20468505f, 0.03121654f, 0.01350662f, -0.09293191f, 
    -0.20708711f, 0.09126280f, 0.06756838f, 0.12848867f, 0.05747516f, 0.19751374f, 0.02423395f, -0.17123245f, 
    0.03910224f, 0.29202604f, 0.05800691f, 0.04173755f, 0.05525729f, -0.09696480f, 0.03395388f, 0.00919313f, 
    -0.14828263f, -0.07889176f, 0.15437895f, -0.01500674f, 0.00259360f, 0.11126944f, -0.06944077f, 0.00722925f, 
    -0.02642363f, -0.01330169f, -0.01423127f, 0.13129903f, -0.03180471f, 0.16837226f, 0.29125148f, -0.12982917f, 
    -0.11631249f, 0.21009111f, -0.14662555f, -0.01885566f, 0.01961206f, 0.00482751f, 0.02727959f, -0.16236423f, 
    0.01294647f, -0.03246521f, 0.03833869f, 0.02043596f, 0.11158444f, 0.02345455f, -0.03016731f, 0.15537086f, 
    -0.02957408f, -0.01227681f, -0.09643005f, -0.08862142f, -0.15821314f, -0.01873526f, 0.00606671f, 0.11835164f, 
    0.07946920f, 0.11771739f, -0.06033157f, -0.04225376f, 0.08157234f, -0.21750233f, -0.02604742f, -0.03431730f, 
    -0.03387494f, -0.04477671f, 0.03059787f, -0.00386864f, -0.11486695f, -0.13254438f, -0.13270907f, -0.19371217f, 
    -0.21223094f, 0.09436250f, -0.04027247f, -0.00871639f, -0.07307197f, -0.06642850f, -0.02168629f, 0.04542352f, 
    -0.03990461f, 0.15230730f, -0.07422729f, 0.21949068f, 0.24592857f, 0.19006246f, -0.03132484f, 0.01031401f, 
    0.11039583f, -0.06939770f, -0.03448758f, 0.02942015f, 0.39692169f, -0.02680586f, 0.06493242f, 0.24333440f, 
    0.02362674f, -0.13640727f, -0.04396055f, -0.02173343f, -0.06725280f, 0.00760527f, 0.13666412f, 0.04301711f, 
    -0.04509746f, 0.06186477f, -0.15354159f, -0.12849368f, -0.05247734f, 0.03154346f, 0.48348004f, 0.37054467f, 
    -0.01483038f, 0.06148478f, 0.39686465f, 0.15138645f, 0.18449824f, -0.03327998f, 0.02310377f, -0.11480460f, 
    -0.01833242f, 0.07714300f, 0.04264941f, -0.01272816f, -0.00367756f, 0.05475501f, -0.17074363f, 0.26336509f, 
    0.02359471f, 0.20655777f, 0.03184809f, 0.05565507f, -0.12712833f, 0.17727453f, -0.06528977f, 0.11306912f, 
    -0.23317622f, -0.14324239f, 0.27216351f, 0.09960006f, 0.03400858f, 0.01658659f, -0.00276619f, 0.04397450f, 
    0.11356770f, 0.00638410f, 0.10116959f, 0.25374207f, -0.01511015f, 0.03574995f, -0.13374676f, 0.00837761f, 
    0.11939814f, 0.11259654f, -0.18671149f, 0.17316215f, -0.06859475f, 0.12758642f, -0.01105550f, -0.07294160f, 
    0.00327882f, 0.02273444f, 0.17089590f, -0.75051409f, 0.09993069f, -0.18889816f, 0.08861186f, 0.00416035f, 
    -0.12549689f, 0.07548825f, -0.22750567f, -0.06260454f, -0.32203823f, -0.04249594f, 0.07388569f, -0.04297648f, 
    -0.14011374f, -0.11194664f, 0.09851000f, -0.13305141f, -0.07439347f, -0.36514756f, -0.25285497f, -0.28881994f, 
    -0.13651456f, -0.03758145f, 0.00271441f, 0.06369030f, -0.05163962f, 0.08440662f, -0.10459084f, -0.12571608f, 
    -0.28631416f, -0.09228016f, -0.07420436f, -0.11935385f, 0.03398874f, -0.06986559f, -0.04589948f, 0.00603843f, 
    -0.07644150f, -0.20558561f, 0.02775021f, -0.00714748f, -0.00864319f, -0.00575658f, -0.17694961f, -0.14173137f, 
    -0.76107210f, -0.21509966f, -0.06377663f, 0.10903270f, 0.19842379f, 0.06037101f, -0.03468744f, -0.03019270f, 
    -0.00159186f, -0.05084003f, 0.25393674f, 0.04243031f, -0.08306174f, 0.16094093f, -0.08290745f, 0.14496811f, 
    0.06300735f, -0.02765281f, 0.02535284f, 0.01596424f, 0.08226132f, 0.03446453f, 0.10751757f, -0.08900722f, 
    0.08173910f, 0.27284220f, 0.10539738f, -0.29456118f, -0.23038155f, 0.30244690f, 0.01722107f, 0.08686865f, 
    -0.38426003f, -0.11768591f, 0.15327962f, 0.12259496f, -0.16921604f, 0.09927297f, 0.01524391f, -0.16869499f, 
    0.01816551f, -0.04101126f, 0.13720109f, 0.03100266f, -0.09363605f, -0.16237324f, -0.04871389f, -0.08054952f, 
    0.07533652f, -0.10084012f, -0.06983873f, -0.04223131f, -0.03253125f, -0.09317948f, -0.40393493f, 0.00783084f, 
    0.04507475f, -0.10012349f, -0.16632812f, -0.08174611f, -0.19354214f, -0.12727767f, 0.11410603f, 0.25752342f, 
    -0.25749940f, 0.01970727f, -0.12918812f, 0.10479428f, 0.02665695f, -0.10456551f, -0.11751428f, 0.08815207f, 
    0.09164190f, 0.01855135f, 0.31931543f, 0.01655729f, -0.04802057f, -0.04395483f, -0.03553267f, 0.17480995f, 
    0.09865674f, 0.00647613f, -0.11200164f, 0.00773868f, -0.09351849f, 0.00486827f, 0.09171093f, -0.00325671f, 
    0.06073493f, 0.07181252f, 0.05558354f, 0.16222399f, 0.08834160f, -0.04139521f, 0.01159478f, 0.10981195f, 
    0.03269899f, 0.01236038f, -0.08176949f, -0.16890940f, 0.09783126f, 0.09129902f, -0.07982557f, -0.07732680f, 
    0.14491588f, 0.00845630f, 0.02892591f, 0.05552275f, -0.14770992f, 0.31584519f, 0.29950273f, 0.02925080f, 
    0.14972940f, 0.13144775f, -0.01727723f, 0.07603555f, 0.11611793f, -0.17351644f, 0.07370699f, 0.23178838f, 
    0.00533349f, 0.15792620f, 0.00404006f, 0.05028760f, 0.16103964f, 0.20546019f, -0.27128765f, 0.05680747f, 
    0.25825125f, -0.01819446f, 0.11725572f, -0.01820346f, -0.09462753f, 0.18471891f, 0.15289231f, -0.06148447f, 
    0.10165547f, 0.14145868f, -0.08904850f, 0.02849936f, 0.05147729f, -0.01818939f, -0.01310723f, 0.17489426f, 
    -0.03485319f, 0.08274284f, -0.04026665f, 0.01405859f, 0.06892783f, 0.05747527f, 0.06026476f, -0.09860095f, 
    -0.00542729f, 0.15108845f, -0.03442085f, -0.07125249f, -0.06569647f, 0.10678663f, 0.07824051f, 0.11094835f, 
    0.13509463f, 0.09319047f, -0.31997019f, 0.13116764f, -0.18152128f, 0.02182816f, -0.03719430f, -0.15236884f, 
    -0.03872397f, -0.00238343f, -0.18387982f, -0.01528094f, 0.40091753f, 0.32433057f, -0.02642009f, 0.13335912f, 
    -0.00984641f, -0.14259155f, 0.18933682f, -0.03421594f, -0.03012301f, 0.00428093f, 0.24589819f, -0.09715249f, 
    -0.11592003f, -0.01957514f, -0.05246943f, -0.00818261f, 0.03883465f, -0.31984454f, 0.02584478f, -0.17206161f, 
    -0.17246509f, 0.07380011f, 0.47564250f, 0.04642277f, -0.10038292f, -0.11568451f, -0.08061559f, -0.00589417f, 
    -0.08676357f, -0.08747740f, -0.02449477f, -0.03491825f, 0.06016768f, 0.07840563f, -0.00076078f, -0.01050382f, 
    0.10117795f, 0.17019825f, -0.16830809f, 0.01979345f, 0.03579297f, 0.06066818f, 0.04805537f, -0.01262074f, 
    0.00592492f, -0.14399913f, 0.15591200f, 0.13657628f, 0.09997462f, 0.05325271f, 0.09414340f, 0.16843796f, 
    -0.01561463f, 0.17917350f, 0.02982597f, 0.03060814f, -0.01426652f, -0.03772650f, -0.03942761f, 0.12904246f, 
    -0.05235386f, -0.01523433f, 0.12662400f, 0.00517581f, -0.03653345f, 0.06418101f, 0.03060092f, 0.16070017f, 
    -0.14098664f, 0.10120770f, 0.15270765f, 0.03116451f, 0.06642627f, -0.04116564f, -0.12273178f, -0.00815516f, 
    -0.07699391f, 0.07856604f, 0.02155372f, 0.06474254f, -0.03242046f, -0.05957605f, -0.04201769f, -0.06508928f, 
    -0.03406931f, -0.12700208f, 0.14789122f, 0.00323885f, 0.11518213f, -0.02458025f, -0.01024643f, -0.16161923f, 
    0.06455176f, 0.09540860f, -0.07836790f, -0.06692645f, 0.03839944f, -0.01788818f, 0.03375474f, 0.09818024f, 
    -0.14921609f, 0.08896179f, 0.04136902f, 0.04583299f, -0.03388641f, 0.00536481f, 0.08960716f, -0.02173188f, 
    0.05984759f, -0.09598234f, -0.12990819f, -0.12330557f, 0.05422320f, -0.07182010f, 0.02072505f, -0.11553720f, 
    -0.38848695f, -0.09797533f, 0.03316854f, 0.02923109f, 0.05115280f, -0.12951189f, -0.02246193f, 0.23338477f, 
    -0.04452391f, -0.29209265f, 0.07992164f, -0.24876636f, -0.10528233f, 0.00202215f, -0.09639065f, 0.10399103f, 
    -0.04662997f, 0.00579951f, -0.08227254f, -0.17273027f, -0.14094038f, -0.04386985f, 0.01857491f, -0.01599593f, 
    0.18281336f, -0.00770283f, 0.02753723f, 0.05560974f, -0.01343540f, 0.09564138f, 0.05776887f, 0.15596984f, 
    -0.12023800f, 0.09099276f, -0.05725514f, -0.03959665f, -0.26459634f, 0.12022854f, -0.05619092f, 0.02657501f, 
    0.11883408f, -0.17309791f, -0.01248733f, -0.12123425f, -0.08367544f, 0.05040344f, -0.03663790f, -0.10774858f, 
    0.19592480f, 0.03898516f, -0.02700288f, -0.04980624f, 0.02116483f, 0.12586933f, -0.05927170f, -0.05853670f, 
    -0.09718177f, 0.01471543f, -0.04145666f, -0.04006907f, -0.05958913f, 0.02355273f, 0.03950488f, -0.10880413f, 
    0.05584109f, -0.22941592f, -0.02622140f, 0.20745435f, 0.10194355f, 0.04216183f, -0.17431238f, -0.02714086f, 
    0.18561618f, -0.03404168f, 0.16942041f, -0.00827746f, 0.14367552f, -0.04502937f, -0.00257455f, 0.07445467f, 
    0.19875151f, 0.02557556f, -0.00829841f, -0.21654509f, -0.15429921f, 0.06227426f, 0.17408538f, -0.12504961f, 
    -0.02135705f, 0.21337855f, 0.14074083f, 0.12584922f, 0.20249531f, -0.15286957f, -0.02625482f, 0.07638677f, 
    0.02212286f, 0.09809694f, 0.03873383f, 0.01359454f, -0.10503210f, -0.15351379f, -0.04683088f, -0.01269508f, 
    0.06163529f, 0.14022259f, -0.07922370f, -0.13529257f, 0.07194633f, 0.00076418f, 0.34908190f, 0.00812275f, 
    -0.08858991f, -0.04286238f, 0.05508094f, 0.03037523f, 0.05911069f, -0.22075820f, -0.13956194f, -0.15993059f, 
    0.07084329f, 0.00779235f, -0.05032085f, 0.13130431f, -0.01230674f, 0.14950457f, -0.21151000f, -0.08667973f, 
    0.07777420f, -0.02077135f, -0.02852043f, -0.00417190f, -0.06829049f, 0.08341738f, -0.06209306f, 0.14369290f, 
    0.03216234f, -0.03288271f, 0.00870661f, 0.13827302f, 0.03963221f, 0.03467807f, 0.03732226f, 0.00530176f, 
    0.07106189f, 0.04293410f, -0.05217614f, 0.06692330f, -0.05155066f, -0.09554669f, -0.03239842f, -0.09995759f, 
    0.01733494f, 0.28671536f, -0.02493432f, 0.13185892f, 0.16008927f, 0.07252663f, 0.07824776f, 0.08035930f, 
    -0.04009720f, 0.12298511f, -0.19621748f, 0.23737574f, -0.07708872f, 0.20454992f, 0.06797094f, 0.04794727f, 
    -0.06312002f, 0.04641890f, -0.08372421f, 0.37476239f, -0.01371572f, 0.18781134f, 0.00347265f, 0.13080303f, 
    -0.01028930f, -0.00763619f, -0.11632821f, 0.10264124f, 0.11825300f, 0.03179668f, -0.04116391f, -0.18401222f, 
    0.03640453f, 0.15145583f, -0.01772172f, 0.03888214f, -0.02257490f, -0.35960329f, 0.17868568f, 0.10135001f, 
    -0.07418495f, -0.06282283f, 0.29806054f, 0.00559963f, -0.00161540f, -0.06029967f, -0.26533473f, -0.04840244f, 
    -0.25642309f, -0.05238399f, 0.01267362f, -0.06465161f, 0.12412485f, -0.09750491f, -0.13610828f, -0.18836851f, 
    -0.01153969f, -0.13768806f, 0.00877968f, -0.02150878f, -0.09899243f, 0.01249356f, -0.17320900f, 0.07750388f, 
    -0.05098633f, -0.00324518f, 0.03128863f, 0.02130504f, -0.02489599f, -0.04150762f, -0.06438991f, 0.01147553f, 
    0.00779880f, 0.01133387f, 0.00605785f, -0.02445027f, 0.02991996f, 0.02794367f, 0.03109994f, -0.00303095f, 
    -0.02073050f, -0.01756226f, -0.03460734f, -0.06951885f, 0.02215843f, -0.04945630f, -0.00229106f, -0.00844874f, 
    0.02798976f, -0.04730123f, -0.03997837f, 0.04583887f, 0.00904633f, -0.02543480f, 0.01868054f, 0.02651554f, 
    0.03938119f, 0.05078670f, 0.04104769f, -0.06106507f, -0.03423939f, -0.05850812f, -0.05548548f, -0.03050595f, 
    -0.00889351f, -0.04312178f, 0.00603042f, -0.03814618f, -0.04406058f, -0.04799779f, 0.04021979f, 0.03704473f, 
    0.04712425f, -0.03884439f, 0.01166586f, 0.00809269f, -0.00295636f, 0.00342692f, -0.01435156f, -0.03748799f, 
    0.01042094f, 0.02834602f, -0.01112063f, -0.04787507f, -0.00425617f, -0.02787504f, -0.03839269f, -0.00751049f, 
    0.00708288f, -0.03992390f, -0.03482025f, -0.02007234f, 0.02592114f, -0.00976711f, -0.05023169f, -0.02104907f, 
    -0.03418307f, -0.06771187f, 0.00831483f, -0.00155862f, -0.03017531f, 0.02187857f, 0.03506258f, 0.01833964f, 
    0.02161587f, -0.01720035f, 0.00267610f, 0.03373399f, 0.03798107f, 0.02800126f, 0.00346448f, -0.00915741f, 
    -0.05957951f, 0.00465988f, -0.04881345f, -0.05823601f, 0.01226938f, -0.00195636f, 0.05053821f, -0.02504611f, 
    0.03475510f, 0.03611889f, -0.02309071f, -0.04247262f, 0.02735688f, -0.06308611f, 0.01512876f, -0.02127917f, 
    0.04475332f, 0.04529851f, -0.06913912f, 0.01312364f, 0.02477796f, 0.02712433f, -0.03269409f, 0.00294311f, 
    -0.02841597f, 0.02229375f, 0.04511165f, 0.04520756f, -0.05039501f, -0.04572015f, -0.05874434f, 0.00727044f, 
    -0.00870010f, -0.03053912f, -0.04899178f, 0.03746390f, -0.05463529f, 0.00479256f, -0.04844518f, -0.03594323f, 
    0.04215708f, 0.02620485f, -0.04634405f, 0.04123218f, 0.00784605f, -0.01020889f, -0.05147936f, 0.05576223f, 
    0.01471642f, -0.02504529f, -0.00132970f, -0.03125739f, 0.02542700f, 0.04612591f, -0.06300773f, 0.00126212f, 
    -0.05175610f, -0.05168737f, -0.03815187f, -0.05876958f, -0.03501401f, -0.00332322f, 0.03369852f, 0.03311725f, 
    0.00384744f, 0.01323720f, -0.01519098f, -0.06139765f, 0.00044620f, -0.04847052f, 0.04661512f, -0.00894239f, 
    0.04713806f, -0.01067538f, -0.06616614f, 0.02558548f, 0.04438005f, -0.06838366f, -0.02028348f, 0.00182822f, 
    0.00188344f, 0.05282470f, -0.02112481f, -0.01670807f, -0.00933083f, -0.00174184f, -0.02994899f, 0.00733466f, 
    0.04886527f, -0.03237066f, 0.00968754f, -0.05199839f, -0.06726019f, -0.01267586f, 0.03867028f, -0.00659234f, 
    -0.00734404f, -0.04674177f, -0.02263802f, -0.05817756f, -0.03922664f, -0.05070032f, -0.03830315f, -0.02644210f, 
    0.01409811f, -0.00694345f, 0.04134842f, -0.00877614f, 0.00050089f, 0.03099768f, 0.04806574f, -0.03605382f, 
    -0.04197220f, -0.06951497f, 0.04153314f, -0.00682189f, 0.02322381f, -0.03800975f, 0.02327205f, -0.04264175f, 
    0.02831791f, -0.02718512f, -0.00763729f, -0.01642164f, 0.03922835f, 0.02691522f, 0.00117539f, 0.04142727f, 
    0.05422670f, -0.05764771f, -0.00371261f, -0.05959400f, 0.00353332f, 0.04199385f, -0.03902173f, 0.00099364f, 
    -0.04473503f, 0.03236606f, -0.02235660f, -0.06323498f, -0.02601706f, -0.06610236f, -0.02173137f, 0.04374681f, 
    -0.01999666f, -0.00118008f, -0.03737338f, 0.00906980f, 0.03395599f, 0.03972396f, 0.03402169f, 0.02289118f, 
    -0.04407804f, 0.02838585f, 0.00525045f, -0.03039144f, -0.02821922f, -0.06128097f, -0.05512616f, 0.04076653f, 
    0.02892801f, 0.03059771f, 0.00522907f, 0.01599493f, 0.03176241f, 0.01784069f, -0.00611298f, 0.01925195f, 
    -0.05185445f, -0.05458351f, -0.02805425f, -0.00054184f, -0.00452491f, 0.01662600f, 0.01923377f, 0.04350782f, 
    0.04855486f, -0.03325857f, -0.04918811f, -0.00663679f, -0.03251747f, -0.04644617f, -0.01446210f, 0.00859416f, 
    0.05452841f, -0.03800279f, 0.03864800f, 0.02806934f, 0.04832702f, -0.04298977f, 0.00255708f, -0.05660689f, 
    -0.05150048f, 0.03476236f, -0.00896346f, -0.00106360f, -0.01888423f, -0.02188233f, 0.04560329f, -0.04270823f, 
    -0.09497156f, -0.20308331f, -0.23240513f, 0.02489438f, 0.00555642f, -0.09405937f, 0.07709134f, 0.11615823f, 
    0.17200366f, 0.05328212f, -0.02465812f, -0.10168443f, 0.07451107f, -0.03848935f, 0.06300870f, 0.11073821f, 
    0.07879533f, -0.11729099f, 0.20233950f, -0.36197966f, -0.01373990f, -0.17867291f, 0.06245764f, 0.04932218f, 
    0.09683671f, 0.06010198f, 0.04006524f, -0.86968672f, -0.17631002f, 0.12929933f, 0.11489777f, -0.00947616f, 
    0.00269566f, 0.09647990f, 0.05793375f, -0.03684924f, -0.35884801f, 0.17367882f, -0.13259740f, -0.24702775f, 
    -0.12300000f, -0.18243319f, 0.07251211f, -0.06071641f, 0.12344826f, 0.17916732f, -0.54510373f, -0.16961698f, 
    -0.06198742f, -0.07609503f, 0.24430980f, -0.01255851f, 0.01866899f, 0.12327366f, -0.32961321f, -0.48956901f, 
    -0.44728372f, -0.03011202f, -0.07555728f, 0.01458657f, -0.18326840f, 0.13768396f, 0.06155820f, 1.02766955f, 
    0.14539233f, -0.18595904f, 0.00741569f, -0.14026175f, -0.08164809f, 0.03692207f, 0.00685596f, -0.00050387f, 
    0.02567773f, -0.28698716f, -0.03454706f, -0.22950128f, -0.10003041f, 0.03153697f, -0.06195883f, 0.08927251f, 
    -0.04510797f, -0.07762914f, 0.02073592f, -0.05584157f, 0.06007519f, -0.21126856f, -0.10193921f, -0.02504459f, 
    -0.04537748f, 0.20854682f, 0.43144494f, -0.02171477f, -0.12375174f, -0.04814449f, 0.06139176f, -0.00700334f, 
    0.15844303f, -0.05024317f, -0.07408690f, -0.56848562f, 0.05204387f, -0.40593860f, -0.01094710f, -0.07888377f, 
    -0.06448016f, 0.10880377f, 0.01511854f, -0.13417968f, 0.31330580f, 0.27853355f, 0.10504417f, 0.03295283f, 
    0.11562689f, 0.14027560f, 0.01650837f, -0.10160510f, 0.15107000f, -0.32629535f, -0.22454603f, -0.29144192f, 
    -0.13255805f, -0.14073457f, -0.00372771f, 0.04067580f, 0.00649567f, 0.02230683f, 0.29943609f, -0.07338780f, 
    0.34817034f, -0.09876815f, -0.19148174f, 0.09508054f, 0.07193599f, 0.09760378f, -0.03822760f, 0.40739757f, 
    -1.05753589f, -0.49638218f, -0.02108661f, -0.02438945f, 0.18716089f, 0.26536512f, -0.19017498f, -0.09686690f, 
    0.19373684f, -0.50082928f, 0.12610662f, 0.01742008f, 0.13381113f, 0.05862487f, 0.07592498f, 0.05257626f, 
    -0.17205186f, -0.45151913f, -0.21116760f, -0.34200153f, 0.02820465f, -0.05051512f, 0.19875473f, 0.13889955f, 
    0.08024450f, 0.12946992f, 0.15104845f, -0.21511899f, 0.13934006f, 0.01390596f, 0.01087378f, 0.02476463f, 
    0.08029999f, -0.02129225f, 0.08863448f, -0.02494173f, 0.14998965f, 0.21781051f, -0.02472199f, -0.01043026f, 
    0.04599060f, 0.15508646f, 0.17638503f, -0.05917384f, -0.27840742f, 0.31673923f, -0.01307244f, -0.29519582f, 
    0.13467877f, 0.10849253f, -0.08664383f, 0.03618781f, 0.02545703f, 0.02537259f, 0.13578498f, 0.05507481f, 
    -0.11545368f, -0.01828429f, -0.22017157f, -0.06993683f, -0.00004345f, 0.02462188f, -0.32027683f, 0.24177201f, 
    0.23548006f, -0.07312875f, 0.00405162f, -0.10588164f, 0.02630017f, 0.17110077f, -0.03275625f, -0.00988004f, 
    -0.03060797f, 0.49014851f, -0.17495675f, 0.13100646f, -0.03222875f, 0.12415526f, 0.10185182f, -0.02185769f, 
    0.11019345f, 0.09927120f, 0.26211807f, -0.03074133f, -0.03879519f, 0.08291023f, 0.12623216f, 0.10635174f, 
    -0.02059201f, -0.00725498f, -0.36895847f, -0.45967901f, 0.00621814f, 0.07669617f, -0.12328336f, 0.05231554f, 
    0.03191693f, -0.07269825f, -0.91431159f, 0.04358699f, -0.25292471f, -0.19611982f, -0.00962993f, 0.13018174f, 
    -0.00437395f, 0.04352150f, 0.05592389f, 0.23130517f, -0.17328966f, -0.15522783f, -0.11858717f, 0.02804295f, 
    -0.20848039f, 0.02916095f, -0.00658228f, -0.07295987f, -0.14385860f, -0.42526746f, -0.16612539f, -0.10350449f, 
    0.05433802f, 0.19080113f, 0.06582986f, 0.08211958f, 0.02822619f, -0.31001872f, -0.56798273f, -0.18038967f, 
    0.16284730f, -0.24106061f, -0.11532422f, -0.10148451f, 0.07507768f, -0.07654860f, 0.03663386f, 0.13620107f, 
    0.03341769f, 0.15012924f, 0.00472341f, 0.03506946f, 0.04126796f, -0.05355867f, 0.14074139f, 0.14689068f, 
    0.13616635f, 0.15948151f, 0.00626279f, -0.05407714f, 0.08302636f, 0.08045086f, -0.08958579f, 0.16914549f, 
    -0.00300077f, 0.02419624f, 0.02978303f, 0.02665498f, -0.05389623f, 0.02727529f, 0.03957660f, 0.01253769f, 
    -0.05261390f, -0.03130174f, -0.04137682f, 0.00904310f, -0.01812272f, -0.01567334f, 0.00405205f, 0.03916352f, 
    0.00349954f, -0.06697391f, -0.01762114f, -0.01303867f, -0.04392065f, -0.03366609f, -0.04930220f, 0.03235051f, 
    0.01183138f, 0.01940196f, -0.02092782f, -0.04941705f, 0.01635391f, 0.05027426f, -0.01207198f, 0.02211268f, 
    0.03630625f, -0.03041899f, -0.04401213f, -0.06003266f, -0.04484321f, -0.01927206f, 0.01468846f, -0.02127036f, 
    -0.03491193f, 0.01820934f, -0.00242587f, -0.04689127f, 0.03606179f, 0.01365641f, 0.02707539f, -0.01432068f, 
    -0.02730384f, 0.00781787f, 0.03938626f, -0.01119822f, -0.00548787f, 0.02943712f, 0.01729796f, -0.02277492f, 
    0.03726449f, 0.00913038f, -0.04750494f, -0.04285307f, -0.01754824f, -0.02056795f, -0.00718442f, 0.03897934f, 
    0.02931209f, 0.00135119f, -0.06070612f, -0.06006389f, -0.00757263f, -0.06016316f, 0.04134563f, -0.04502260f, 
    -0.06223198f, -0.00146852f, 0.03108769f, 0.02460820f, 0.05650074f, 0.03806433f, -0.04818434f, -0.05913281f, 
    -0.00123570f, -0.00451698f, -0.05201365f, -0.00846558f, 0.03297442f, -0.05109821f, -0.06028983f, 0.02856281f, 
    0.03837971f, -0.05667621f, -0.06028676f, 0.05277150f, 0.00326177f, -0.02703660f, 0.04156678f, 0.04910145f, 
    -0.04435998f, 0.03231839f, 0.04243866f, -0.01858678f, 0.04221958f, 0.01548915f, -0.03908534f, -0.03033511f, 
    -0.02375934f, -0.02534248f, 0.01474523f, 0.02725902f, 0.01043690f, 0.00820043f, 0.03807344f, -0.04540108f, 
    0.04689715f, -0.05358201f, -0.05133584f, -0.05455478f, 0.03293854f, -0.03349615f, -0.02872675f, -0.02626289f, 
    0.02760331f, 0.00132797f, -0.04133696f, 0.03835272f, 0.02518643f, 0.00095197f, 0.01191446f, -0.01634404f, 
    -0.00044183f, -0.06263980f, 0.03287166f, 0.04439763f, 0.00057051f, -0.03722415f, -0.00752244f, 0.01496787f, 
    -0.00655434f, -0.05992917f, 0.00462841f, 0.02011985f, 0.03282372f, -0.06817108f, -0.04838111f, 0.02146892f, 
    0.04715080f, -0.01091732f, -0.00636264f, -0.00863735f, 0.03465234f, 0.02562215f, -0.05332689f, 0.02788468f, 
    0.00233934f, -0.05845080f, 0.04187049f, -0.04427656f, 0.02197323f, 0.05336760f, -0.00102925f, 0.02526371f, 
    0.01801303f, -0.04886957f, -0.01937297f, 0.03438366f, 0.00387542f, 0.00543481f, -0.02462956f, 0.03553237f, 
    -0.05400046f, 0.00853911f, -0.04075261f, 0.02552424f, 0.02242417f, -0.03679112f, 0.03628397f, -0.01003648f, 
    -0.00866116f, -0.04597814f, -0.06062466f, 0.00168428f, -0.05341801f, 0.03290918f, -0.02920274f, 0.00090767f, 
    0.02612700f, 0.00654494f, -0.01395679f, -0.05633804f, -0.04043631f, -0.01055053f, 0.02989143f, 0.03774783f, 
    -0.05584571f, 0.02190088f, 0.01564083f, -0.03476018f, -0.02938143f, -0.00381354f, -0.05480640f, 0.00662118f, 
    -0.03827627f, 0.00452966f, 0.02365112f, 0.02457199f, 0.03857715f, -0.00364134f, 0.01028331f, -0.04821122f, 
    -0.01930634f, -0.00723178f, 0.01474269f, 0.04442155f, -0.01317149f, 0.01233193f, -0.01749945f, 0.04183027f, 
    0.04500653f, -0.02760357f, -0.00739897f, -0.05246022f, 0.04716421f, -0.04200709f, -0.06387959f, 0.01871670f, 
    -0.03821623f, 0.04531532f, -0.02912130f, -0.05185033f, -0.04232662f, -0.01907153f, 0.00994068f, 0.00666502f, 
    -0.00574341f, -0.01640791f, -0.06485394f, -0.03958099f, -0.01636206f, 0.01531844f, 0.03232618f, 0.05281804f, 
    -0.02084364f, 0.05017189f, -0.04057791f, 0.02307574f, 0.02633106f, 0.05007564f, 0.05077982f, 0.01401277f, 
    0.01485983f, 0.00509394f, 0.00193782f, 0.03530908f, -0.05056538f, 0.00298955f, -0.06190932f, -0.01983763f, 
    -0.04432359f, 0.04198386f, -0.00039941f, -0.05950459f, -0.05417974f, 0.04500415f, -0.02524058f, -0.01728828f, 
    0.01999477f, -0.04266743f, 0.04537783f, -0.01402080f, 0.01607673f, -0.02234882f, -0.00749739f, -0.01447577f, 
    0.02674604f, -0.03365458f, -0.03665546f, 0.03245407f, -0.04757110f, -0.05663969f, 0.03261810f, -0.02399754f, 
    -0.02024030f, -0.02483961f, -0.01206398f, -0.03783701f, 0.02709506f, 0.02530037f, 0.00438765f, 0.00346320f, 
    -0.05542845f, -0.03811374f, -0.04775903f, 0.03996077f, -0.03033174f, -0.00779439f, -0.05255991f, 0.01428499f, 
    0.03528136f, 0.02042174f, 0.01665339f, -0.05572649f, 0.05214730f, -0.03625980f, -0.00957812f, -0.01097181f, 
    -0.03782573f, 0.04774338f, -0.02841876f, -0.04590458f, 0.02118754f, -0.03148856f, -0.01158861f, -0.02477685f, 
    0.02346468f, 0.00884256f, 0.03665488f, 0.05468279f, 0.02952803f, 0.05338228f, 0.02237688f, -0.02633672f, 
    -0.02703740f, -0.02581859f, -0.02301279f, -0.03904898f, 0.03074464f, -0.03291009f, 0.03049232f, 0.01219958f, 
    -0.03023607f, -0.01293120f, 0.01188223f, -0.02078771f, -0.01788609f, 0.04366796f, -0.01866177f, 0.05346872f, 
    -0.05810223f, -0.03164170f, 0.03483237f, 0.01382983f, -0.01724419f, -0.02166565f, -0.04475893f, 0.04975402f, 
    0.01146389f, -0.04888059f, 0.04879750f, -0.01627047f, -0.02878709f, -0.04751865f, -0.03200471f, 0.01878530f, 
    -0.05959947f, -0.03428310f, -0.01383918f, 0.05053240f, 0.00839533f, -0.03740387f, -0.00866280f, 0.00964913f, 
    -0.03039847f, -0.01070033f, 0.01864045f, 0.03413566f, -0.03034879f, -0.04199775f, -0.03124930f, 0.03832891f, 
    -0.04631734f, 0.01220088f, -0.00526684f, -0.00558716f, -0.06079601f, -0.05494766f, 0.04858921f, 0.00210638f, 
    0.04208163f, -0.04737780f, -0.02784363f, 0.03213309f, -0.04071869f, 0.04116141f, -0.02404672f, -0.00215940f, 
    0.02057814f, -0.02253316f, -0.03594097f, 0.02542000f, 0.04151037f, -0.05774353f, -0.02797382f, 0.00805768f, 
    -0.01558569f, 0.00412365f, -0.05563228f, 0.02762950f, -0.03156230f, -0.01038383f, 0.02800274f, -0.02519318f, 
    -0.03970037f, -0.01000765f, 0.02925140f, -0.01177697f, -0.04079288f, -0.05013084f, -0.03744896f, 0.04424039f, 
    -0.02214965f, -0.03553771f, -0.06182721f, -0.05591960f, 0.00136524f, 0.00911052f, 0.01066808f, 0.02048821f, 
    0.03045275f, -0.03315022f, 0.03832558f, -0.05686954f, 0.05362235f, 0.01324741f, -0.01283886f, 0.02007818f, 
    0.02804752f, -0.04432570f, -0.00199999f, 0.03710767f, -0.04580442f, 0.00379370f, -0.02714897f, 0.02296146f, 
    -0.01381445f, -0.03521113f, 0.04613634f, 0.03292764f, -0.03505455f, 0.00032535f, 0.04441792f, 0.01979770f, 
    0.01380575f, 0.01613187f, -0.03133674f, -0.03747213f, -0.05235775f, 0.01564273f, 0.01041885f, -0.03551681f, 
    -0.00254310f, 0.02295740f, -0.03465518f, -0.01336464f, 0.04062049f, 0.00072012f, -0.00232524f, -0.00345252f, 
    -0.00143709f, -0.03035351f, -0.05698022f, -0.05745125f, 0.03013389f, -0.01562444f, -0.01156437f, -0.01051963f, 
    -0.03028568f, -0.06170077f, 0.03291456f, 0.01665694f, -0.05416836f, -0.04887316f, -0.05332036f, -0.01848384f, 
    0.02637269f, -0.03854047f, 0.01831337f, 0.01410894f, -0.00360661f, -0.03965514f, 0.02543446f, 0.01495087f, 
    0.01069228f, -0.04103727f, 0.05331608f, 0.04239124f, -0.02082422f, 0.01507630f, -0.05016559f, -0.04089584f, 
    -0.02819354f, 0.02904612f, -0.00081475f, -0.05390938f, 0.02233231f, 0.04977299f, -0.05200947f, -0.03131694f, 
    -0.05729749f, -0.05679600f, 0.02948535f, 0.03470913f, -0.00998925f, 0.04882991f, -0.01153305f, 0.01038745f, 
    -0.01969484f, -0.03758309f, -0.03760724f, -0.02475577f, 0.00911112f, -0.00786532f, -0.05137351f, -0.05913134f, 
    -0.04407418f, 0.05351914f, -0.05772803f, -0.04369547f, 0.01190207f, -0.04282984f, -0.05948756f, 0.00189751f, 
    -0.01450538f, -0.00520349f, -0.05224439f, 0.02493304f, 0.02821693f, -0.03318311f, 0.03719131f, 0.02376354f, 
    0.01811464f, -0.04935229f, -0.04381604f, 0.04084169f, -0.01463088f, -0.02939956f, 0.03602235f, -0.01353582f, 
    -0.05979565f, -0.01632976f, 0.00634395f, -0.04449277f, 0.00411888f, -0.03935028f, -0.02633168f, -0.06068171f, 
    -0.03855919f, 0.04064791f, -0.02178990f, -0.01792374f, 0.00423095f, -0.00832637f, 0.00753253f, -0.03767468f, 
    0.01676548f, -0.05633803f, -0.05363027f, 0.01629117f, 0.00523738f, 0.02636644f, 0.02467685f, 0.05072411f, 
    0.05079978f, 0.00665173f, 0.03995477f, -0.03024497f, 0.04352882f, -0.03195318f, -0.05106849f, 0.04036936f, 
    0.00775832f, -0.05331272f, -0.00459117f, 0.04907864f, 0.01838731f, -0.02027074f, -0.03121902f, 0.02317501f, 
    -0.05059078f, 0.25431788f, 0.13674708f, 0.12886654f, 0.18521464f, 0.04690372f, 0.05388078f, 0.06744339f, 
    -0.13315701f, 0.12646477f, 0.11112769f, 0.06492900f, 0.12406754f, -0.00742529f, -0.17853311f, -0.04081770f, 
    0.18437311f, 0.22127752f, 0.22370705f, -0.01965098f, -0.11718743f, -0.13238144f, -0.26500446f, -0.02941461f, 
    0.09748333f, 0.05333681f, -0.09903397f, 0.05233648f, 0.00827085f, -0.14422898f, -0.03812013f, -0.15135205f, 
    0.01362185f, -0.02256893f, -0.02855869f, 0.41592619f, 0.19032274f, 0.08541311f, -0.05834942f, -0.26445648f, 
    -0.10684565f, -0.04363602f, 0.06311492f, 0.12327279f, 0.13976276f, -0.02946152f, -0.04552913f, -0.08193827f, 
    -0.13580383f, 0.02912756f, 0.00754138f, -0.04623457f, 0.11056244f, 0.09200814f, -0.02994150f, 0.06000651f, 
    -0.11507413f, -0.02956014f, -0.19267166f, 0.03505357f, 0.04586028f, 0.16547604f, 0.01226712f, -0.03826701f, 
    0.07242199f, -0.04998982f, -0.05214350f, 0.02668384f, 0.15551800f, 0.06712893f, 0.09515875f, 0.14578560f, 
    -0.38209814f, -0.45029911f, -0.11988237f, -0.13618454f, -0.01681959f, -0.06568251f, 0.00430840f, 0.12133281f, 
    0.10219851f, -0.10375004f, -0.20381472f, -0.15882622f, -0.09409229f, -0.13004164f, -0.24009769f, -0.08007836f, 
    -0.09232622f, -0.03379494f, 0.24943109f, 0.10959584f, -0.05387601f, -0.08099391f, -0.07737328f, 0.04265297f, 
    0.11579251f, 0.09793064f, -0.08341432f, -0.05466055f, 0.04522540f, -0.05462177f, 0.14173585f, 0.02044751f, 
    -0.07674929f, 0.01373433f, -0.00718109f, 0.20480922f, -0.17321947f, -0.03252302f, 0.04273809f, -0.10865992f, 
    0.00596873f, -0.13851622f, -0.18681930f, -0.13463141f, -0.00898922f, 0.09842128f, 0.09116678f, 0.00353390f, 
    -0.33482191f, -0.21867779f, 0.00019226f, 0.01512251f, 0.11247587f, -0.02480882f, 0.01099269f, -0.13130338f, 
    -0.12094400f, -0.16500968f, 0.13053326f, 0.12864262f, -0.05606250f, 0.01435254f, 0.17292231f, -0.05771605f, 
    -0.21794637f, -0.07272927f, 0.13290696f, 0.05852931f, -0.13299349f, 0.03924746f, 0.21679501f, -0.06841598f, 
    -0.01599437f, -0.10641280f, -0.15313365f, 0.08757772f, 0.15432850f, -0.09582761f, -0.08473129f, 0.08719804f, 
    0.13496125f, 0.16179605f, 0.04069277f, -0.11230692f, -0.08579371f, -0.06646176f, -0.04656629f, 0.04984941f, 
    -0.16395956f, -0.09915781f, 0.11328501f, -0.06376882f, -0.04516267f, 0.01736237f, 0.11525569f, -0.01719231f, 
    -0.02514990f, 0.00562908f, -0.02938278f, 0.26013017f, -0.04006245f, -0.04020000f, -0.01808326f, 0.12377767f, 
    0.10840366f, 0.10164886f, 0.19845872f, -0.07192367f, 0.32099408f, -0.12687621f, 0.09811257f, 0.06474909f, 
    0.11986952f, 0.03492756f, -0.10657640f, 0.01732596f, -0.13387333f, -0.37482283f, -0.58648366f, -0.13761275f, 
    0.00691194f, 0.08788557f, -0.20489684f, 0.13027802f, -0.02717756f, -0.03007229f, -0.29462585f, -0.16561078f, 
    0.17985752f, 0.10063619f, 0.23013082f, -0.01891693f, 0.09105510f, 0.21019001f, -0.05933246f, 0.24176949f, 
    0.07752437f, -0.11368503f, -0.05011753f, -0.03853511f, 0.13202141f, 0.13266532f, 0.05051900f, -0.07351274f, 
    -0.13023633f, -0.12459010f, -0.15528013f, -0.11797044f, -0.03124416f, 0.02965661f, -0.02423188f, -0.08691565f, 
    0.05028778f, 0.21536115f, -0.04089809f, -0.20045780f, -0.04912338f, 0.09184258f, 0.27095708f, 0.08306129f, 
    -0.12641601f, -0.20484352f, -0.03430850f, -0.34673664f, -0.03721508f, -0.05152576f, 0.01930222f, 0.09059104f, 
    -0.06454577f, -0.07848712f, 0.05884030f, -0.03223351f, -0.54109669f, -0.18044269f, 0.20285493f, 0.05784981f, 
    0.07555961f, -0.01670120f, 0.09502283f, -0.13960353f, 0.18002070f, 0.07454947f, -0.04798800f, 0.06120756f, 
    -0.02850969f, 0.06092811f, 0.12306307f, 0.05980449f, -0.08633716f, -0.07447489f, -0.22961685f, -0.56551063f, 
    -0.12473191f, 0.03121832f, -0.13973700f, 0.17424589f, 0.17141882f, -0.10421437f, -0.29060596f, 0.00407236f, 
    0.16815186f, -0.05891508f, 0.07565861f, -0.19082899f, -0.17640127f, -0.09160189f, 0.05376808f, -0.06288841f, 
    -0.19161569f, -0.03230551f, -0.00590507f, -0.03213308f, -0.05799216f, -0.12599623f, -0.02082184f, -0.18136273f, 
    -0.00857994f, 0.43549430f, 0.14905635f, 0.06475110f, 0.02641120f, 0.00897750f, 0.13652462f, 0.03610672f, 
    0.22129568f, 0.07436469f, 0.19777046f, 0.14124122f, 0.03446070f, 0.08649013f, 0.06601522f, 0.14524488f, 
    0.20655245f, 0.02162783f, -0.04769233f, 0.06104984f, 0.03557296f, 0.02763059f, 0.00488587f, -0.09606379f, 
    -0.00063581f, -0.17154826f, -0.08250409f, -0.11565874f, -0.33806202f, -0.23524444f, 0.08896908f, 0.00969168f, 
    0.14167312f, -0.04780075f, 0.07391989f, -0.05802632f, 0.00342878f, -0.11283948f, -0.15336095f, 0.13931121f, 
    0.18281084f, -0.02011238f, 0.07574081f, 0.05637609f, -0.01590143f, -0.02031737f, -0.14074296f, 0.03793209f, 
    0.06348888f, 0.09314922f, 0.16003466f, -0.09060093f, -0.10861287f, 0.03351240f, -0.12053049f, -0.06352586f, 
    -0.03370184f, 0.07920070f, 0.00442518f, 0.19799134f, -0.26198402f, -0.12895723f, -0.12407879f, -0.06387767f, 
    -0.22227772f, 0.05045311f, 0.23186632f, 0.05430221f, 0.16466570f, -0.05658499f, 0.11815208f, 0.13488062f, 
    0.10234917f, -0.25354344f, 0.01393739f, -0.00376010f, 0.15456401f, 0.05773747f, 0.06758870f, 0.06845311f, 
    0.11514160f, 0.06273805f, 0.04256864f, 0.24178649f, 0.30635202f, 0.08048988f, 0.09633950f, 0.02351847f, 
    0.05354591f, 0.09867726f, -0.15926665f, -0.10346670f, -0.04733554f, -0.04811973f, -0.14354272f, -0.12953506f, 
    -0.22559987f, -0.29940623f, -0.38101655f, 0.40096211f, 0.09049055f, 0.20526144f, 0.08795074f, -0.05787958f, 
    0.18017712f, 0.05746632f, 0.09275933f, 0.03969809f, 0.07556221f, 0.03235285f, 0.01737438f, 0.10801487f, 
    0.03483503f, 0.10169163f, 0.10706033f, 0.10686550f, 0.09406061f, -0.20511878f, 0.01268220f, -0.03302582f, 
    0.14045505f, 0.05035166f, 0.18927146f, 0.04778393f, -0.19950464f, 0.11923833f, -0.14884803f, 0.07475179f, 
    -0.20183784f, -0.05146769f, -0.03561928f, 0.19028428f, -0.01802308f, 0.33330324f, 0.19659373f, -0.35284358f, 
    0.13949294f, -0.10989105f, -0.03293293f, 0.12685603f, -0.04845060f, 0.08055871f, 0.13351235f, 0.19562413f, 
    -0.02006587f, 0.22198839f, 0.05234878f, -0.00833536f, -0.04224277f, 0.23539545f, 0.05956326f, -0.07474301f, 
    0.14016721f, -0.03814939f, 0.11286155f, 0.04018140f, -0.00974590f, -0.06903662f, -0.03047666f, -0.06369232f, 
    0.03025361f, -0.19392611f, 0.10040577f, 0.13416617f, 0.06781702f, 0.11628163f, 0.12675831f, -0.11229970f, 
    0.11156113f, -0.06671011f, 0.05951880f, 0.18007465f, 0.06749046f, 0.24746867f, 0.12457425f, 0.37208334f, 
    0.05440832f, 0.10191224f, 0.21025045f, 0.19308406f, 0.20027114f, 0.09922732f, -0.01658666f, 0.03423674f, 
    0.25868213f, -0.04316927f, 0.15537602f, 0.10230742f, -0.16175391f, 0.19124158f, 0.03260138f, -0.01607327f, 
    0.17282297f, 0.03400110f, 0.11415616f, -0.02276105f, -0.16218451f, -0.06113599f, 0.18476354f, 0.05064268f, 
    -0.18372458f, 0.22027312f, 0.11313679f, 0.15870102f, 0.06316979f, -0.03987886f, -0.05758465f, -0.06444580f, 
    0.20542972f, -0.02087364f, -0.01269623f, -0.01479927f, 0.11719152f, -0.12455884f, -0.07164825f, -0.11475195f, 
    0.14775556f, 0.15617999f, 0.12337052f, 0.10497649f, -0.07061889f, 0.19074291f, 0.10196301f, 0.17913072f, 
    0.24419369f, -0.22339059f, 0.21318176f, -0.04050672f, 0.06593651f, -0.09136368f, -0.14071266f, -0.02353486f, 
    -0.15335104f, -0.11079200f, 0.17353898f, -0.14228439f, -0.06106427f, 0.25453249f, 0.06116252f, 0.06556325f, 
    -0.13417156f, -0.00682537f, 0.12659459f, -0.05128596f, 0.21061771f, -0.12863941f, 0.05707232f, -0.08627485f, 
    0.10103984f, -0.03423920f, -0.12950501f, -0.01166765f, 0.03758559f, 0.23272933f, 0.13777541f, 0.04638184f, 
    0.04990883f, 0.08091712f, -0.01862762f, 0.05777476f, 0.11162020f, -0.42248285f, 0.17513601f, -0.15238552f, 
    -0.05279760f, 0.07465459f, -0.11595351f, -0.01948867f, -0.32770810f, 0.03853640f, 0.08511311f, 0.16245951f, 
    0.14576626f, 0.14112085f, 0.18815739f, 0.01496771f, -0.07363478f, 0.07177792f, 0.11903321f, 0.05427324f, 
    0.01811301f, -0.02270947f, 0.24144498f, 0.09965440f, 0.15352190f, -0.02934422f, 0.05208382f, -0.01330647f, 
    -0.26169616f, -0.04661836f, 0.23522016f, -0.01211058f, -0.09013915f, -0.06835745f, 0.00856438f, 0.14085065f, 
    0.11478268f, -0.23611018f, -0.32671449f, 0.10464063f, -0.10054375f, -0.04638095f, 0.00074826f, 0.23384124f, 
    -0.01151434f, 0.13465804f, -0.36817795f, 0.15212302f, -0.30175036f, 0.12711053f, -0.01690456f, 0.04226967f, 
    -0.02998826f, -0.00237680f, 0.07857259f, -0.31463772f, 0.11074891f, -0.26543823f, -0.10615671f, 0.00066184f, 
    -0.02213537f, 0.12076624f, -0.04932444f, -0.01520957f, -0.01865964f, -0.03478104f, -0.16883254f, -0.09655366f, 
    0.01807890f, 0.05857521f, -0.01649626f, 0.05464204f, 0.10008094f, -0.04258819f, 0.18562575f, -0.13304290f, 
    -0.12425575f, 0.07814393f, -0.01398040f, -0.00670383f, -0.07743233f, 0.13223410f, 0.00493355f, 0.04488306f, 
    -0.11468077f, -0.04186217f, -0.11959365f, 0.19691476f, -0.02595783f, 0.05077043f, -0.01802485f, -0.20006195f, 
    0.12012786f, 0.01417040f, 0.09286302f, -0.15333715f, -0.08974737f, -0.01640536f, 0.03592356f, 0.15595224f, 
    -0.20426969f, 0.29832366f, -0.21455780f, -0.15034765f, 0.07576527f, -0.27123299f, 0.13463502f, -0.00159004f, 
    -0.07555852f, 0.11317661f, 0.14243393f, 0.18097840f, 0.03740177f, 0.29143351f, 0.02542801f, -0.05353950f, 
    0.03788732f, -0.07041172f, 0.09648728f, -0.08518697f, -0.04507518f, 0.12298504f, 0.01437224f, 0.10617472f, 
    0.17084703f, 0.22952761f, 0.11896072f, -0.50918823f, -0.39711052f, 0.14859523f, -0.19023329f, 0.04183017f, 
    -0.23965566f, 0.01814189f, 0.07464884f, -0.08001310f, 0.06490508f, 0.04750865f, 0.20288225f, -0.09518692f, 
    -0.12023976f, -0.13511115f, 0.03623349f, 0.00205976f, 0.01188820f, 0.01314694f, 0.24144435f, -0.06889432f, 
    0.03839232f, 0.08084477f, 0.06338855f, 0.04511053f, 0.18612836f, 0.08089361f, -0.35876244f, -0.02453165f, 
    -0.05875484f, 0.03287278f, -0.13358299f, 0.00360970f, -0.07436829f, -0.16270919f, 0.22572924f, -0.23057507f, 
    -0.55354935f, -0.55084193f, 0.00105992f, 0.13935755f, 0.25889426f, 0.08642691f, -0.13471171f, -0.17021768f, 
    -0.07965098f, -0.20888241f, 0.10893046f, -0.01924516f, 0.03484428f, -0.10272689f, 0.14739537f, 0.17249705f, 
    -0.08031720f, -0.06558607f, -0.18944953f, 0.13605216f, -0.01698721f, 0.03487206f, -0.04203759f, -0.01416691f, 
    -0.08809976f, 0.20204096f, 0.01775721f, -0.19044365f, -0.16640875f, -0.12969229f, 0.01903204f, -0.04183187f, 
    -0.09372288f, -0.10635755f, -0.01595079f, -0.01936248f, 0.26872692f, -0.12966916f, 0.14269622f, -0.23358096f, 
    0.04518186f, -0.10586663f, 0.26967999f, 0.12893654f, -0.28205022f, 0.33113924f, -0.12872326f, 0.11021268f, 
    0.00208544f, -0.00306054f, -0.25456133f, 0.02592769f, 0.04810250f, 0.18852367f, 0.17825459f, 0.23843811f, 
    0.01028541f, -0.02708404f, 0.02695520f, 0.02521207f, 0.04870022f, 0.05482637f, 0.16041483f, 0.16142903f, 
    0.12256321f, -0.04928064f, -0.08018651f, -0.00299227f, 0.22073369f, 0.18018559f, 0.12722026f, -0.13497232f, 
    0.28498885f, -0.13853551f, 0.07254392f, 0.02940879f, -0.05477518f, -0.06830034f, -0.03715308f, 0.10582787f, 
    -0.05453152f, -0.02248752f, 0.13416113f, 0.09702482f, 0.06991906f, -0.05159239f, -0.03655020f, -0.09622141f, 
    0.00451487f, -0.13634706f, -0.16301580f, -0.07255010f, 0.05798185f, 0.03298952f, -0.05142987f, 0.05595652f, 
    0.12785566f, -0.16280739f, 0.11082987f, 0.22084464f, 0.42181706f, 0.06668090f, -0.14240646f, 0.02107126f, 
    0.01824863f, -0.10691486f, -0.05723904f, 0.00776506f, 0.38222724f, -0.13426495f, -0.05642497f, 0.08114804f, 
    -0.17213430f, 0.19484100f, 0.06562427f, 0.00378531f, -0.14926104f, -0.05723470f, -0.10753950f, -0.14785573f, 
    -0.06110785f, -0.07260802f, 0.06102889f, 0.03922718f, 0.20269115f, -0.11963034f, 0.08169731f, 0.00798422f, 
    0.11188209f, 0.19664773f, -0.14436893f, 0.03164119f, 0.07856168f, -0.11580585f, 0.19141312f, 0.07050209f, 
    0.02876539f, -0.03854988f, -0.13002904f, -0.02068194f, 0.01971666f, -0.00913055f, 0.08669397f, 0.09055696f, 
    0.41164175f, 0.12775232f, -0.05973741f, 0.00379558f, -0.05114616f, -0.00496239f, 0.10271944f, 0.06064106f, 
    -0.00299711f, -0.04643273f, -0.05775116f, 0.02136782f, 0.04183133f, -0.06755792f, 0.02373849f, -0.03084647f, 
    -0.00761729f, -0.04179273f, 0.00499824f, -0.02837711f, -0.03478014f, -0.02949582f, 0.03494168f, -0.03184292f, 
    -0.00041427f, 0.02382388f, 0.03367987f, -0.00081147f, 0.00465922f, 0.01188564f, -0.02009157f, -0.01339334f, 
    0.04224983f, -0.06352609f, -0.00688324f, -0.03592381f, -0.00958733f, -0.03739955f, -0.01144383f, -0.04409388f, 
    -0.03275464f, 0.02942520f, 0.01304988f, 0.04702771f, -0.00431413f, -0.05073937f, -0.04054881f, 0.04232123f, 
    0.03282215f, 0.04267523f, -0.01693253f, -0.03789045f, -0.00257954f, 0.00989001f, 0.04087606f, -0.02455541f, 
    -0.02797074f, -0.01875447f, 0.01842287f, -0.05722483f, -0.04335960f, -0.00186589f, 0.02199725f, -0.01868782f, 
    -0.00524508f, 0.02605506f, -0.05049335f, -0.00680362f, 0.03189578f, -0.00933719f, -0.00202703f, 0.03526903f, 
    -0.04617112f, 0.00840368f, 0.04265207f, 0.03984695f, -0.00154339f, 0.03195562f, -0.03564440f, 0.04219565f, 
    0.05041612f, 0.01809887f, -0.01149830f, -0.01085222f, -0.06301852f, 0.01395516f, -0.04000717f, -0.05080308f, 
    0.03337412f, -0.05492461f, 0.04999818f, 0.04199664f, -0.04575197f, -0.03718804f, -0.03148145f, 0.00334458f, 
    0.02547249f, -0.04458935f, 0.00909610f, -0.03480494f, -0.00591338f, -0.04095232f, 0.00888410f, -0.03211088f, 
    -0.05274968f, 0.01360556f, 0.00998375f, 0.00512597f, -0.00793699f, 0.01240303f, -0.02890472f, -0.01227351f, 
    -0.04952503f, -0.02704223f, 0.01398456f, 0.03808667f, 0.00476285f, 0.01887829f, -0.04886309f, 0.03608661f, 
    -0.04049570f, -0.05218599f, -0.03014703f, -0.01630396f, 0.00290240f, 0.03081072f, -0.01134908f, 0.01030700f, 
    0.01864097f, -0.02942736f, 0.04394417f, -0.03403886f, -0.04656811f, 0.04341800f, -0.00606860f, -0.06634617f, 
    -0.01379659f, -0.03671626f, -0.00900976f, 0.03297307f, -0.00138069f, -0.02471939f, -0.04977361f, 0.02089280f, 
    -0.01976629f, 0.03528928f, -0.04069055f, 0.02851626f, 0.01035084f, 0.03912123f, -0.01845134f, 0.04146019f, 
    -0.04372514f, -0.02680931f, 0.01330147f, -0.04806973f, 0.03396749f, 0.00424769f, -0.05532248f, 0.03350101f, 
    0.03611695f, 0.02042868f, -0.03668981f, -0.01371484f, -0.02624233f, 0.02806581f, -0.00471642f, -0.06180581f, 
    0.02267967f, -0.01795061f, 0.04620241f, 0.04712066f, -0.02402557f, 0.00800515f, 0.04259802f, -0.03288591f, 
    -0.06759017f, 0.00039982f, -0.04651190f, 0.03989928f, 0.00531397f, 0.02061542f, -0.03872077f, -0.00085033f, 
    0.04325536f, 0.04185599f, -0.01172063f, -0.03616872f, -0.02363771f, 0.01504362f, -0.06136846f, 0.03075589f, 
    0.03721295f, -0.02809385f, 0.04001782f, -0.05075630f, 0.01710759f, -0.04815809f, -0.03102892f, -0.04010823f, 
    -0.05749565f, -0.02187423f, -0.02105448f, -0.03801721f, -0.03207360f, -0.03769907f, 0.01343921f, -0.05565317f, 
    0.01944002f, 0.02501546f, 0.01603568f, -0.02930425f, 0.02060590f, -0.00176045f, -0.06690314f, -0.03361095f, 
    0.00789005f, -0.01542829f, 0.00420466f, 0.00709512f, -0.04454033f, -0.02292833f, -0.06100917f, -0.05164854f, 
    -0.03883272f, -0.02723412f, -0.05392991f, -0.02778837f, -0.05577733f, -0.00471909f, -0.00307205f, -0.05226551f, 
    -0.00463310f, -0.04802548f, 0.02101998f, 0.04601038f, -0.02344970f, -0.02555972f, 0.03812190f, -0.04713582f, 
    -0.05428254f, 0.02721070f, -0.05228831f, -0.06720521f, -0.00417646f, -0.00351225f, -0.01367959f, 0.01629191f, 
    -0.06342791f, 0.02338712f, 0.00699488f, -0.03700141f, -0.04661115f, 0.03056163f, -0.00264530f, -0.04870535f, 
    0.03682736f, 0.02748383f, -0.04400090f, 0.03630574f, 0.01648160f, -0.02431656f, -0.00043829f, -0.00021127f, 
    -0.02233883f, -0.04318434f, 0.03088932f, -0.03033122f, -0.04419782f, -0.00647292f, -0.00155602f, 0.03540520f, 
    0.00254355f, 0.02034756f, -0.04752741f, 0.03471403f, 0.02071930f, -0.05434642f, -0.05050769f, -0.01640225f, 
    0.01325071f, -0.02118738f, 0.02080800f, 0.03641019f, 0.01655770f, -0.02503999f, 0.02233655f, 0.01934316f, 
    -0.01009049f, -0.01280518f, 0.02266374f, 0.02268116f, -0.04437776f, -0.04838675f, 0.03001121f, -0.05316718f, 
    -0.13870449f, -0.03309247f, 0.44214478f, -0.00715700f, 0.09608694f, 0.14419189f, -0.13412875f, -0.00559824f, 
    -0.06467030f, -0.06907135f, -0.09665203f, 0.14294697f, 0.03235791f, -0.03204960f, -0.02089866f, -0.07880358f, 
    -0.16681013f, 0.05550802f, -0.13497950f, 0.29269835f, 0.02732828f, 0.06656783f, -0.04132918f, -0.02538608f, 
    -0.06472953f, 0.01326645f, 0.05580711f, 0.07474715f, 0.22824240f, 0.17506590f, 0.02494231f, -0.20232995f, 
    -0.12611392f, 0.03511712f, 0.01084500f, 0.12151127f, -0.06977522f, 0.20547971f, 0.15439776f, -0.26560098f, 
    0.04898880f, -0.07677522f, -0.23866464f, -0.05987226f, -0.04120015f, 0.36438966f, 0.02910696f, -0.37458020f, 
    0.18728350f, -0.13442454f, -0.19207640f, 0.12806451f, 0.10000200f, -0.00857486f, 0.22249590f, -0.09240277f, 
    -0.21600546f, -0.04870844f, -0.09406011f, -0.20295238f, 0.21847092f, 0.05808527f, 0.05462198f, 0.05442165f, 
    -0.22252190f, 0.08843580f, 0.00848428f, 0.01796965f, 0.08089928f, 0.08097187f, -0.13010906f, -0.13434723f, 
    -0.34512371f, 0.30997038f, -0.09306904f, 0.05509193f, 0.19795753f, -0.15389569f, 0.02415731f, -0.03984628f, 
    0.06693627f, 0.15430544f, 0.06069680f, -0.13637082f, 0.03507101f, 0.07189651f, 0.02072995f, -0.05322151f, 
    -0.11421291f, 0.00560809f, -0.00199754f, 0.08636665f, 0.21085282f, -0.16093169f, 0.07552020f, 0.10396069f, 
    0.20750809f, 0.10867774f, 0.31782082f, -0.07955026f, -0.33454376f, 0.24968904f, -0.05551408f, -0.00679209f, 
    -0.10516424f, -0.08142371f, -0.06314880f, 0.04546049f, 0.27724802f, -0.05846986f, -0.42918131f, -0.07457217f, 
    0.02535146f, -0.12494300f, -0.02173046f, 0.06982501f, -0.05377333f, 0.24062103f, 0.22026135f, 0.20193848f, 
    -0.22860758f, -0.02326946f, -0.09852229f, 0.00458417f, -0.06140360f, 0.02288781f, 0.07925837f, 0.13736932f, 
    0.07872939f, 0.08712284f, -0.10030703f, 0.07828927f, -0.02571276f, -0.00901400f, 0.07308680f, -0.13672955f, 
    -0.09868284f, -0.23856026f, 0.16538441f, 0.07336393f, -0.02314881f, -0.03319218f, -0.10655484f, -0.15689379f, 
    -0.06447847f, 0.01467466f, 0.14374213f, 0.05691951f, 0.06165407f, -0.11831831f, 0.05219132f, 0.01772404f, 
    -0.05477713f, -0.14144056f, 0.00787715f, 0.29885954f, -0.26585314f, -0.11172538f, -0.23442572f, 0.17031533f, 
    0.02991606f, 0.26286289f, -0.11261793f, 0.03273397f, 0.00835103f, -0.04451739f, -0.12001924f, -0.00877468f, 
    -0.13576736f, -0.04465033f, 0.14188804f, -0.01652359f, -0.35751918f, -0.13919596f, 0.05504308f, -0.12337080f, 
    -0.05237681f, 0.07777669f, -0.02240353f, -0.07283179f, 0.14418556f, 0.05669821f, -0.09070655f, -0.02338405f, 
    0.02166720f, 0.10658764f, -0.05205742f, 0.07348150f, -0.07822797f, 0.04187847f, -0.01946829f, 0.10166700f, 
    0.09930490f, 0.04449777f, 0.08715259f, 0.07194488f, 0.13417219f, 0.09436168f, 0.01640855f, 0.20854169f, 
    0.09661116f, 0.06688326f, -0.11553141f, -0.00762069f, 0.16261154f, 0.07166871f, 0.09793623f, -0.10509370f, 
    -0.01133000f, -0.00074199f, -0.05658443f, -0.07166387f, 0.13034570f, -0.00004758f, 0.08995304f, 0.10378817f, 
    0.11269169f, -0.17253837f, -0.33307442f, 0.00357083f, -0.10144714f, -0.11710668f, -0.11240585f, -0.03900193f, 
    -0.13656664f, -0.19145443f, 0.07674019f, 0.07674027f, -0.07269014f, 0.01678391f, -0.04349864f, -0.08438516f, 
    0.01931320f, 0.23362043f, 0.62777632f, 0.06714673f, -0.24861740f, 0.02203960f, 0.26677516f, -0.12009921f, 
    0.03483983f, 0.06093371f, 0.03232204f, 0.05186907f, -0.10095712f, 0.03566303f, -0.09794810f, -0.09847820f, 
    0.11814774f, 0.04355741f, -0.01467230f, 0.21447450f, 0.03949650f, -0.05377628f, 0.15168415f, -0.05693948f, 
    -0.16514920f, -0.17190391f, -0.03995782f, -0.04721956f, 0.02601955f, 0.17190228f, 0.29157999f, -0.05700494f, 
    -0.00616041f, 0.11150018f, 0.10035992f, 0.10414704f, 0.05749815f, -0.11651365f, 0.10786067f, -0.09611315f, 
    -0.23344700f, 0.06683103f, 0.12212338f, 0.16862366f, -0.10535090f, 0.12060908f, 0.23692064f, 0.02224314f, 
    0.19419731f, -0.29257098f, -0.11390537f, 0.10572633f, -0.08708742f, -0.02240434f, -0.12239449f, 0.02042242f, 
    0.10612242f, -0.10922409f, 0.54122031f, 0.05151415f, 0.16491380f, 0.15717854f, 0.03211890f, 0.14625549f, 
    0.04089799f, -0.00537038f, 0.09657458f, 0.25116998f, -0.00202832f, 0.06285986f, -0.02258445f, 0.11874884f, 
    0.01307087f, 0.09128580f, 0.09361698f, 0.20862354f, -0.08757754f, -0.00199683f, 0.08884913f, 0.01088007f, 
    -0.24582948f, -0.08429819f, -0.11353053f, -0.22605947f, 0.09651785f, -0.41588137f, 0.08930676f, -0.06224860f, 
    -0.04429313f, -0.00237937f, -0.16479927f, -0.13945794f, -0.03769672f, 0.34311253f, -0.01625754f, -0.02138994f, 
    0.00105789f, -0.12745826f, 0.04734727f, -0.04131360f, -0.05273300f, 0.20136790f, 0.32598379f, -0.60528457f, 
    -0.06254706f, 0.02344788f, -0.19318779f, 0.01044117f, -0.01356788f, -0.19545695f, 0.13831617f, 0.22787555f, 
    -0.32622120f, -0.08604994f, 0.11650978f, -0.08482976f, -0.14967079f, 0.12750012f, -0.09184539f, 0.07033397f, 
    -0.05667415f, 0.13511220f, 0.08786314f, -0.04650467f, 0.24593310f, 0.12255497f, 0.04185497f, -0.04982926f, 
    -0.29270503f, 0.07603612f, -0.27468279f, 0.19001219f, -0.06219541f, -0.16303870f, -0.09313316f, -0.01835875f, 
    0.00398877f, 0.40594569f, 0.02935409f, -0.19107367f, -0.22590296f, -0.03521028f, 0.00963029f, -0.03442150f, 
    -0.16352004f, 0.06931839f, 0.00933976f, 0.12562755f, -0.00912835f, 0.01776896f, 0.04456233f, -0.10431491f, 
    -0.27332222f, -0.05527545f, 0.01734368f, -0.01573298f, 0.13369836f, 0.29120144f, -0.18795167f, 0.02997958f, 
    -0.04558403f, 0.09174964f, 0.10079253f, 0.01896998f, -0.05416070f, -0.24885687f, 0.03175510f, -0.10798810f, 
    0.24408099f, 0.00489456f, -0.07333349f, 0.07366376f, 0.13318798f, 0.12880772f, 0.38316023f, 0.07691614f, 
    -0.07390318f, -0.04455315f, 0.01521225f, -0.13240013f, -0.08799919f, -0.05167962f, -0.04529541f, -0.21627130f, 
    -0.25774428f, -0.08215600f, -0.04234131f, 0.07492143f, 0.17970127f, 0.00386088f, 0.12554185f, -0.05800570f, 
    -0.35704961f, 0.04479338f, 0.18639223f, 0.04859250f, 0.09206496f, 0.00270529f, -0.12457864f, 0.16279103f, 
    -0.05651604f, -0.09775995f, 0.11279729f, -0.00771047f, 0.04256925f, -0.05840219f, 0.05200532f, 0.14016579f, 
    0.00518552f, 0.07974855f, 0.01079307f, 0.07301542f, -0.04289491f, 0.10777888f, 0.02919366f, 0.01367704f, 
    0.11890528f, -0.13534163f, 0.06143425f, 0.20482801f, -0.00814471f, 0.02556930f, -0.01614783f, -0.22235270f, 
    0.21354091f, 0.11654866f, -0.10980684f, 0.19411646f, -0.06948888f, 0.12576219f, -0.00634795f, 0.08336543f, 
    0.07681343f, -0.01164908f, 0.04090711f, 0.02948528f, 0.16188732f, -0.02892067f, 0.08498553f, 0.27771005f, 
    -0.14093761f, -0.00809182f, -0.08730709f, -0.05258719f, -0.07018340f, -0.28815851f, -0.34655252f, -0.18435812f, 
    -0.06406984f, -0.08392537f, -0.10986561f, -0.03685504f, -0.13233349f, -0.08403962f, -0.31158593f, -0.09113419f, 
    0.16939509f, 0.02283141f, -0.02605497f, -0.02112124f, -0.09498350f, -0.13493414f, 0.01919267f, 0.23304442f, 
    0.05339064f, -0.08621134f, 0.07646360f, 0.18381000f, 0.02180748f, -0.06073494f, 0.06869035f, -0.10942101f, 
    -0.05566162f, -0.09860986f, -0.10923686f, 0.09473313f, 0.12673029f, 0.07882138f, 0.07744095f, 0.12810828f, 
    0.08402534f, 0.23898116f, 0.02468792f, 0.05922750f, 0.00566709f, 0.15479712f, -0.03561167f, 0.00680273f, 
    0.05268241f, -0.10416417f, 0.20008403f, 0.04509757f, -0.20818418f, -0.21010111f, -0.14489041f, -0.07424191f, 
    -0.15860075f, -0.09901657f, 0.05993563f, -0.00287232f, -0.26047918f, -0.03063690f, 0.13177319f, -0.05503149f, 
    -0.07044034f, -0.20588943f, -0.11349358f, -0.06451015f, 0.22841756f, 0.15053360f, -0.04953494f, 0.04305465f, 
    0.16901642f, 0.02304024f, 0.02729780f, 0.01705334f, -0.16257681f, -0.01199233f, -0.18551497f, -0.26012647f, 
    -0.03491599f, -0.11915456f, -0.03729842f, -0.12882666f, -0.03782275f, -0.04977028f, -0.22103542f, -0.11473597f, 
    0.46696556f, 0.03592537f, -0.02428560f, 0.14715862f, -0.11364425f, -0.05041117f, -0.00930079f, 0.16131604f, 
    -0.29854646f, 0.29301006f, 0.14737923f, 0.01696475f, 0.04789678f, 0.07054116f, -0.07856574f, 0.12912105f, 
    0.17242973f, -0.33836487f, -0.14699402f, -0.01911222f, 0.21424218f, -0.01736137f, 0.02792035f, 0.23451348f, 
    0.04467210f, 0.17863920f, -0.04190600f, 0.15053584f, -0.01863441f, -0.00565346f, 0.00138686f, 0.12473247f, 
    -0.00060980f, 0.03145707f, 0.06466125f, 0.05570204f, 0.11928459f, -0.12356851f, 0.07835796f, -0.00737167f, 
    -0.08801560f, -0.00148067f, 0.06496262f, -0.17706105f, 0.06373266f, 0.01054965f, -0.10945395f, -0.03847061f, 
    -0.17282435f, -0.23963480f, -0.08766860f, -0.11443122f, -0.06946331f, -0.05836790f, -0.00989338f, 0.02202424f, 
    0.06942347f, -0.14411272f, -0.00704575f, 0.01920096f, 0.13267742f, -0.22538534f, -0.04157621f, 0.13391772f, 
    0.16818334f, -0.00864223f, -0.00080124f, 0.01312415f, -0.01682909f, -0.08724879f, -0.24214484f, 0.21778812f, 
    0.11181925f, -0.01326561f, 0.11187932f, -0.05379801f, 0.05750974f, -0.03085003f, 0.04601476f, 0.00794010f, 
    0.08998990f, 0.01093147f, -0.01894106f, 0.01777498f, -0.27507573f, -0.07406600f, -0.03435680f, 0.03028435f, 
    -0.17400420f, -0.26418984f, -0.02896649f, 0.13328753f, 0.08486868f, -0.00721584f, 0.05404109f, 0.01531838f, 
    0.25099713f, -0.16809212f, -0.09015272f, -0.32598856f, 0.11352632f, -0.06845294f, -0.07336780f, 0.12425630f, 
    0.10937512f, 0.32894540f, -0.12964401f, -0.24490263f, -0.07031237f, -0.05278976f, -0.01606211f, -0.07790747f, 
    0.09039007f, 0.09164956f, 0.02884261f, 0.09534722f, -0.14089218f, -0.05329921f, -0.01704050f, -0.02587818f, 
    -0.05697722f, 0.15570150f, -0.04725992f, -0.07295881f, -0.01646699f, 0.14891365f, 0.31330302f, -0.08323222f, 
    -0.02163733f, 0.01977207f, 0.02224133f, 0.01607295f, -0.08258375f, -0.12596564f, -0.16606268f, -0.07712223f, 
    0.14232762f, 0.12192328f, -0.16564301f, 0.03354565f, -0.02413768f, 0.16545343f, -0.36054319f, -0.05907751f, 
    0.28651190f, -0.01318070f, -0.16250619f, -0.17543089f, -0.11322840f, -0.18230081f, 0.06544284f, 0.10835381f, 
    0.19374651f, -0.22633754f, -0.02106044f, -0.15906765f, 0.23317213f, 0.05502377f, 0.02040639f, 0.06262947f, 
    0.32375935f, -0.11867782f, 0.10428678f, -0.10747182f, 0.01979951f, -0.00881765f, 0.03671784f, 0.12990621f, 
    0.08381814f, -0.00107182f, 0.13321190f, -0.05217890f, -0.24861278f, -0.06444062f, -0.03907569f, -0.09191777f, 
    -0.06653525f, 0.03625037f, 0.24442069f, -0.01888489f, 0.28562206f, -0.13465714f, 0.09088298f, 0.09922913f, 
    0.01871570f, -0.01131295f, 0.10509799f, 0.03752739f, -0.11549633f, 0.12861826f, -0.04871172f, -0.07210802f, 
    -0.06280126f, 0.08596734f, 0.05102919f, 0.15381789f, 0.18141080f, 0.18415126f, 0.15290825f, -0.08436864f, 
    0.03907017f, 0.08582800f, 0.08624104f, 0.21324448f, 0.04805834f, -0.22437780f, -0.23518658f, -0.02808403f, 
    0.11729509f, -0.00340684f, -0.01263911f, 0.15344405f, 0.11600919f, 0.13667315f, -0.14535271f, -0.16186704f, 
    -0.23046906f, -0.11790496f, -0.05636840f, -0.03592506f, 0.07997371f, 0.06914827f, 0.00522616f, 0.28219360f, 
    0.05159448f, -0.05907974f, -0.24470322f, -0.09101414f, 0.00052363f, -0.20809798f, -0.07388917f, 0.02348786f, 
    0.07726727f, 0.00092386f, 0.12789650f, -0.02716971f, -0.02005599f, -0.01031999f, -0.05454151f, -0.06718815f, 
    0.00606609f, 0.38296852f, -0.20292555f, 0.13360423f, -0.00456964f, -0.08002458f, -0.05938383f, 0.00424023f, 
    0.11480405f, 0.05526573f, -0.26342532f, 0.15240458f, 0.18574584f, 0.15584429f, 0.10247651f, -0.13258380f, 
    -0.03380994f, 0.10634239f, -0.01219165f, 0.48053792f, 0.05780139f, -0.02742012f, -0.22138730f, -0.02527310f, 
    0.04457081f, 0.04321955f, -0.20552747f, 0.12798053f, 0.15099397f, 0.15352310f, 0.09448010f, -0.26826623f, 
    -0.05445368f, 0.12514213f, -0.16007981f, -0.11785220f, 0.12643138f, 0.16629644f, -0.68967360f, 0.42153478f, 
    0.20660445f, -0.10858619f, -0.10091108f, -0.01556365f, 0.03639209f, 0.02097611f, -0.12979501f, -0.15917727f, 
    -0.45497203f, -0.01239995f, -0.05454285f, -0.02184006f, 0.10502972f, -0.01121759f, 0.00202863f, -0.05938120f, 
    -0.09380054f, -0.32241833f, 0.07423103f, -0.06259666f, -0.01878668f, 0.04831109f, -0.01148254f, 0.14594804f, 
    0.04726466f, -0.00316878f, 0.00092459f, -0.04748495f, -0.06498494f, 0.03416252f, -0.02609624f, -0.06044972f, 
    0.04514256f, -0.01127841f, -0.02342694f, -0.01695259f, 0.03845786f, 0.03954988f, 0.04442924f, -0.05098195f, 
    -0.05889665f, -0.04666450f, -0.04831745f, 0.02095663f, -0.01159899f, -0.04945015f, 0.04709404f, -0.04094013f, 
    -0.01088530f, 0.00436570f, 0.00476045f, 0.01905381f, 0.01208697f, -0.06641655f, -0.02877752f, 0.02539080f, 
    0.04588516f, 0.04905893f, -0.04464499f, -0.04690089f, 0.00784787f, -0.04631274f, 0.02958672f, -0.00623766f, 
    -0.01502701f, 0.02979610f, 0.00274472f, -0.02228827f, -0.01316930f, -0.06136617f, 0.00846271f, -0.06509104f, 
    -0.06848571f, -0.02941390f, 0.02855017f, -0.01840916f, -0.05465412f, -0.03380903f, -0.03868432f, -0.05489052f, 
    -0.02828324f, 0.01233641f, 0.04418138f, 0.00067353f, 0.04253120f, 0.04281426f, -0.06125160f, -0.00272198f, 
    0.01195499f, -0.02061525f, 0.04360922f, -0.03466294f, -0.04058079f, -0.03339995f, 0.01756779f, -0.02623774f, 
    -0.04648675f, 0.02884481f, -0.01631317f, -0.04820995f, -0.03542323f, 0.01428170f, -0.05728316f, -0.04655854f, 
    0.02629310f, 0.00469646f, -0.05600300f, 0.02724435f, -0.06308147f, -0.03490654f, 0.02476239f, 0.00062404f, 
    -0.01872328f, -0.04459957f, -0.04036881f, 0.03137578f, -0.02710337f, -0.03093877f, -0.05559071f, 0.00668799f, 
    -0.00573422f, 0.04274008f, -0.01850879f, 0.01046157f, -0.06259072f, -0.02579562f, -0.05101442f, 0.00764304f, 
    0.00691146f, 0.01766936f, 0.02592924f, -0.01629020f, 0.00929678f, 0.01670252f, -0.04978102f, -0.05269540f, 
    0.04450442f, 0.02811377f, -0.03492433f, -0.05650061f, -0.05377591f, 0.01180069f, -0.05178229f, -0.01708175f, 
    -0.01723030f, -0.04327511f, 0.03944917f, -0.00009444f, 0.03858640f, 0.02795919f, 0.01075752f, -0.04373337f, 
    -0.00800462f, 0.02273983f, -0.04300041f, -0.00952737f, -0.00454945f, -0.05751202f, -0.04084073f, -0.05065308f, 
    -0.00207968f, 0.03636185f, 0.01395995f, -0.03543600f, -0.03057624f, 0.01439750f, -0.04000253f, -0.03954044f, 
    -0.03419687f, 0.01133363f, -0.02777672f, -0.02339111f, -0.03175836f, -0.02610940f, -0.02251411f, 0.02820760f, 
    -0.04474037f, 0.04667687f, -0.00878559f, -0.02207935f, -0.01255010f, -0.00645464f, 0.01072639f, 0.02747075f, 
    0.04642408f, 0.04347496f, -0.06196391f, 0.01463944f, 0.02364052f, -0.01117097f, 0.02551069f, -0.06006248f, 
    0.00988957f, 0.04771253f, -0.05712768f, 0.02552718f, -0.01271281f, -0.04645684f, -0.05238419f, 0.04560984f, 
    -0.00532366f, -0.03761966f, -0.04299619f, -0.01643119f, -0.05638651f, -0.05814725f, -0.04053849f, -0.00617040f, 
    0.01186439f, -0.02022029f, -0.03225645f, 0.04437858f, -0.05633559f, -0.03733786f, -0.04423301f, 0.00069923f, 
    0.01846185f, -0.05132404f, 0.01322212f, 0.04430697f, -0.04685026f, -0.01023936f, 0.03869490f, 0.04193371f, 
    0.03983159f, -0.02588393f, 0.04285832f, -0.01585860f, -0.01672571f, 0.01662411f, 0.02140154f, -0.03263222f, 
    -0.05302322f, 0.02208598f, 0.01650829f, -0.04675310f, -0.03332828f, -0.06211631f, -0.04810287f, 0.02205181f, 
    0.02506365f, -0.01199136f, -0.03884411f, -0.03109626f, -0.00465224f, 0.02437168f, -0.00458419f, 0.03868882f, 
    -0.05377233f, 0.00680359f, -0.01409764f, -0.01032318f, 0.03608074f, 0.00056545f, -0.05743583f, -0.01522025f, 
    0.02083462f, -0.03026173f, -0.02540892f, 0.02491554f, -0.05120225f, -0.05614790f, -0.02891896f, -0.03180528f, 
    -0.00834847f, -0.01602393f, 0.03421556f, -0.05227749f, -0.00879550f, -0.06636304f, 0.02088361f, -0.04385384f, 
    0.00986305f, -0.02019837f, 0.03439329f, -0.03973074f, 0.00404657f, 0.00903126f, 0.03545565f, 0.04675341f, 
    -0.03855728f, -0.06170901f, 0.00430199f, -0.02914740f, -0.02306670f, 0.00929884f, -0.04684798f, 0.01726063f, 
    -0.03097306f, 0.06028683f, 0.03915675f, -0.06376582f, 0.02930461f, -0.04299224f, 0.01647563f, -0.04172832f, 
    0.00004071f, -0.06284148f, -0.06112413f, -0.00301321f, -0.05852788f, -0.06124771f, -0.05812987f, -0.02144786f, 
    0.00978854f, 0.02902685f, -0.05444663f, 0.01126754f, 0.02755152f, 0.02529747f, -0.03129372f, -0.03500717f, 
    0.02535245f, 0.20091201f, 0.15244821f, -0.02869928f, 0.03591254f, -0.09912692f, -0.10202476f, 0.03824937f, 
    -0.03872760f, 0.03184709f, 0.13656051f, -0.11399584f, -0.01911553f, 0.05593115f, 0.05094033f, -0.06722926f, 
    -0.28078091f, -0.16032825f, -0.03152680f, -0.17687757f, -0.10329353f, -0.22538669f, 0.08820548f, -0.27303129f, 
    0.05418396f, 0.15599239f, -0.01581616f, 0.03113086f, -0.01400583f, -0.24498156f, 0.24445084f, 0.18866703f, 
    -0.21246587f, -0.24853611f, 0.03801794f, -0.04936270f, 0.02568446f, 0.05642842f, 0.04791682f, -0.12390865f, 
    0.03562642f, -0.12915911f, -0.01408769f, 0.00723177f, -0.20463923f, -0.08491169f, 0.05705437f, 0.01998248f, 
    -0.05052812f, 0.11630344f, -0.21471226f, -0.00203847f, 0.02371211f, 0.07189913f, 0.11868621f, 0.03909193f, 
    0.27019703f, -0.09696982f, -0.00103101f, -0.36083761f, -0.10216533f, -0.06377764f, 0.15999839f, -0.03134392f, 
    0.03281464f, 0.11501424f, 0.03586394f, -0.10945430f, -0.09292038f, -0.02484190f, 0.00545445f, 0.05810396f, 
    0.46992424f, 0.22693326f, -0.25639546f, 0.00433919f, -0.00073336f, 0.02703567f, 0.15150219f, -0.05598029f, 
    -0.08627642f, 0.08938161f, 0.04359163f, 0.31352282f, -0.13319126f, -0.00410979f, 0.16540864f, 0.06320070f, 
    -0.05206197f, -0.37951440f, -0.20338324f, -0.13041198f, -0.19921012f, -0.05446237f, -0.15803500f, -0.12733673f, 
    0.09835132f, 0.12128738f, -0.00908177f, 0.17020488f, 0.27793330f, -0.04212510f, 0.00844170f, 0.14810804f, 
    -0.18640929f, -0.26177230f, -0.02053964f, 0.12122462f, 0.03674008f, -0.25181937f, -0.11763796f, 0.09410623f, 
    -0.04362267f, 0.06783392f, 0.19459863f, 0.01725762f, 0.02693350f, 0.16550867f, -0.13179867f, 0.21513321f, 
    -0.09457789f, -0.01769054f, -0.16255546f, -0.06681067f, 0.06102276f, 0.04149886f, 0.04070669f, -0.00930059f, 
    -0.23333985f, 0.09956452f, 0.29710788f, -0.00495435f, 0.01050777f, -0.23973507f, -0.14336091f, 0.21274847f, 
    -0.01133013f, 0.03812701f, -0.16634689f, 0.13073929f, 0.01760510f, 0.07438181f, -0.17385332f, -0.27004829f, 
    -0.26737058f, 0.34794301f, 0.03137857f, 0.06128825f, -0.10554458f, -0.17487432f, -0.05033939f, 0.12642451f, 
    0.08048602f, 0.04055150f, 0.03603524f, 0.00019078f, 0.03975440f, -0.17149083f, -0.18602292f, 0.10309068f, 
    -0.11603606f, -0.02611135f, 0.10566669f, 0.03118240f, -0.13533866f, 0.01333395f, -0.03776269f, -0.05371471f, 
    -0.00457332f, 0.11903856f, -0.10874350f, 0.14308257f, 0.20388101f, -0.11082367f, 0.05793251f, 0.03409673f, 
    0.05476442f, 0.10892208f, -0.03426571f, 0.12100606f, -0.07966258f, 0.16754976f, -0.13615128f, -0.05381180f, 
    -0.11008105f, -0.03252238f, 0.05614452f, 0.11463325f, -0.05005336f, 0.03346960f, 0.10224485f, 0.13594855f, 
    -0.05859387f, -0.09213796f, -0.02256187f, -0.01493581f, -0.07020195f, 0.05281267f, 0.36596805f, 0.19484815f, 
    -0.37565929f, -0.05700194f, -0.02691677f, -0.13466284f, 0.13821796f, 0.02977042f, 0.07226195f, -0.14194299f, 
    0.02400671f, -0.07446145f, 0.00888080f, -0.15119775f, -0.19719009f, 0.11664704f, 0.13669695f, 0.02865160f, 
    -0.13365316f, -0.14808454f, -0.06340954f, 0.00590925f, 0.11463273f, 0.11253963f, 0.16456866f, -0.17376812f, 
    -0.09716686f, -0.05672555f, 0.02831850f, 0.07245126f, -0.14640139f, 0.11268331f, -0.15062362f, 0.13980439f, 
    0.07917377f, -0.05694256f, 0.00201018f, 0.14071755f, 0.26422840f, -0.05728724f, -0.02944243f, 0.00924355f, 
    -0.08567898f, 0.13351177f, 0.10914114f, -0.25175551f, 0.35161242f, -0.09695852f, 0.11394807f, 0.20656231f, 
    -0.24457677f, 0.15573512f, 0.17702693f, 0.06063177f, -0.02201680f, -0.03922898f, -0.11071320f, 0.02470120f, 
    -0.12985431f, -0.15996280f, 0.06834979f, 0.04937672f, 0.04356348f, -0.19094625f, 0.52710730f, 0.01775469f, 
    -0.16030766f, 0.38000748f, 0.03028208f, 0.22526251f, 0.27102065f, -0.01838445f, 0.08850360f, 0.17048150f, 
    0.19482504f, 0.22048335f, 0.00846215f, 0.13580957f, -0.01539334f, -0.09537134f, -0.34434965f, 0.21787313f, 
    -0.12104537f, 0.07254846f, -0.06862368f, -0.02816575f, 0.08669393f, 0.12996978f, 0.04095149f, 0.10352273f, 
    0.10052232f, 0.33291215f, 0.33336976f, -0.00468522f, 0.07033761f, 0.15508401f, 0.17045498f, 0.16576375f, 
    -0.01999930f, -0.26569977f, -0.00510273f, -0.10142999f, 0.20529112f, 0.02446111f, 0.14824040f, -0.11835985f, 
    -0.05552173f, 0.08919067f, 0.00761061f, -0.23894152f, -0.17537941f, -0.00344920f, -0.02961885f, -0.04857883f, 
    0.20916651f, -0.00886867f, 0.03877840f, -0.08750572f, -0.31257999f, -0.22068912f, 0.11322560f, -0.14863497f, 
    -0.13759486f, -0.08944456f, -0.01504646f, -0.09272256f, -0.00682210f, 0.01271095f, -0.02705799f, 0.09695284f, 
    -0.08330020f, -0.10672501f, -0.04379746f, -0.02089000f, -0.13903819f, -0.35984206f, -0.38569790f, -0.53751665f, 
    0.02055796f, -0.18358883f, -0.05135168f, 0.08067416f, -0.04033742f, 0.03641268f, -0.28523004f, -0.52915817f, 
    -0.45925733f, 0.01909197f, -0.20007119f, 0.04146649f, -0.00662808f, -0.07044625f, 0.07736521f, -0.15617254f, 
    -0.05213812f, -0.00425257f, 0.10118752f, 0.05342340f, -0.31656826f, -0.01728899f, 0.11220123f, 0.06573731f, 
    -0.24067737f, 0.30475354f, -0.31871843f, -0.01377507f, 0.15187900f, -0.37554285f, 0.17149460f, 0.00182624f, 
    -0.22996588f, -0.11135845f, 0.11681329f, 0.36832902f, 0.01631430f, 0.06304042f, 0.15135649f, 0.10370628f, 
    0.06776796f, -0.22628339f, -0.09734390f, 0.00113978f, -0.05047332f, -0.07078854f, -0.03804604f, -0.02184976f, 
    -0.05021015f, 0.04800989f, 0.19403766f, -0.19468522f, -0.12720020f, -0.13257895f, 0.10086884f, 0.16163287f, 
    -0.08260843f, -0.30631974f, -0.11132472f, -0.07770230f, -0.20471716f, -0.01270084f, 0.14046602f, -0.07545710f, 
    -0.01186313f, 0.07213946f, 0.11524979f, -0.06581745f, 0.23028331f, 0.09138349f, 0.00340087f, -0.12437727f, 
    -0.01872715f, -0.09261960f, 0.00643244f, -0.10919363f, -0.00732750f, 0.00157618f, -0.02915997f, -0.21842501f, 
    -0.40470672f, -0.19118556f, -0.13168657f, 0.11303486f, 0.11338558f, 0.00032147f, -0.01946811f, -0.30904129f, 
    -0.11212797f, -0.13482368f, 0.03924496f, -0.08315431f, 0.03253647f, 0.01138937f, 0.04055059f, -0.44779539f, 
    -0.19129613f, 0.20778900f, 0.05894978f, 0.05756332f, -0.00878460f, 0.06481656f, 0.01949192f, 0.11728657f, 
    -0.08004781f, -0.03554359f, -0.09020722f, -0.08236048f, -0.06719223f, -0.08235418f, -0.14587022f, 0.00687373f, 
    0.02050895f, 0.17507771f, -0.09407816f, -0.10706631f, -0.19250178f, 0.03806942f, 0.03999351f, -0.12295049f, 
    -0.13968375f, 0.00027391f, 0.21623155f, 0.10994589f, 0.01497961f, 0.07461680f, 0.00456854f, -0.04710234f, 
    -0.04143651f, 0.03392969f, -0.00659851f, 0.06511274f, 0.06977826f, 0.08800574f, -0.01169740f, 0.11748234f, 
    0.14804736f, -0.01093285f, 0.05606480f, -0.03566209f, 0.10153861f, 0.12507416f, 0.22002140f, 0.34610581f, 
    -0.03938972f, 0.07885701f, 0.09612472f, -0.03350690f, -0.08767614f, 0.10095453f, 0.34646776f, 0.00588305f, 
    0.16256326f, 0.02201515f, -0.05115291f, 0.08153697f, 0.21898590f, -0.06917103f, 0.16737333f, -0.07793461f, 
    -0.04263385f, -0.11677337f, 0.25327256f, -0.10720418f, 0.05330027f, 0.16689269f, -0.01709130f, -0.01175806f, 
    0.06793139f, 0.07851459f, 0.27759552f, 0.04595452f, -0.07748301f, 0.22791968f, 0.21623497f, 0.09632932f, 
    0.04024495f, 0.14666632f, 0.08431675f, 0.03037327f, 0.05232996f, 0.15909484f, 0.03923216f, 0.17533658f, 
    0.15083745f, 0.14821494f, -0.16545360f, -0.20568927f, -0.05309927f, 0.08635525f, 0.06256710f, -0.02380731f, 
    0.07732330f, 0.00389551f, 0.07928467f, -0.16010687f, 0.33514547f, -0.07273440f, 0.34260020f, 0.05120691f, 
    -0.31655395f, -0.02675321f, 0.20157786f, -0.18690555f, -0.02414267f, 0.04291344f, -0.04117909f, 0.07469752f, 
    -0.01543938f, -0.06237622f, 0.04980842f, 0.15619369f, 0.00528637f, -0.08955353f, 0.28389362f, -0.14094332f, 
    -0.31629080f, 0.40651000f, 0.00288327f, 0.17949051f, 0.32296276f, 0.04474230f, -0.09531509f, -0.00444718f, 
    0.28344277f, 0.10133242f, 0.05838530f, 0.27836907f, 0.14968762f, -0.23394451f, -0.18795207f, -0.10129506f, 
    0.15908147f, 0.28900772f, -0.24045245f, 0.14785156f, 0.00560168f, -0.00585375f, 0.21603855f, 0.09736126f, 
    0.48676923f, -0.00540780f, 0.06926949f, 0.19606034f, -0.00126077f, 0.16428435f, 0.11271522f, 0.12533398f, 
    0.21012163f, 0.04576415f, -0.03442295f, 0.00572256f, -0.05689902f, 0.08495414f, 0.15958421f, -0.09566861f, 
    0.00396667f, -0.07819209f, -0.16057068f, -0.06553330f, -0.06840763f, 0.03392180f, -0.15923741f, 0.03228227f, 
    0.00850940f, 0.08200740f, 0.17795502f, 0.00500355f, 0.01283062f, -0.21628466f, -0.02310177f, -0.17756997f, 
    -0.03092572f, 0.13773911f, -0.23405896f, -0.00305302f, -0.04611181f, -0.01817840f, -0.04531654f, -0.22692178f, 
    0.15909219f, -0.13438438f, 0.20761152f, -0.08780125f, -0.16188204f, -0.05551127f, 0.06318296f, 0.02991875f, 
    0.13432060f, -0.09935718f, -0.27671859f, -0.03757037f, -0.08446492f, 0.09606917f, -0.06399701f, 0.04914450f, 
    -0.23291536f, 0.13959153f, -0.06808668f, -0.17993100f, -0.07400639f, -0.07341859f, 0.06943125f, 0.19913487f, 
    0.29637179f, -0.23330690f, 0.06209326f, -0.17336909f, 0.16592260f, 0.00451427f, 0.01676847f, 0.14218818f, 
    -0.16042466f, -0.41391695f, 0.11690145f, 0.20929641f, 0.09843226f, -0.23818225f, 0.17679793f, -0.00889546f, 
    0.11935209f, -0.26063126f, -0.18137774f, -0.21416709f, -0.00451106f, 0.07862414f, 0.19804497f, 0.16867629f, 
    0.17431630f, 0.02271943f, -0.17120357f, -0.20298427f, -0.04319652f, 0.11431850f, 0.02757655f, -0.12399422f, 
    0.03047078f, 0.16821738f, 0.04597588f, -0.22760230f, -0.32501981f, -0.01007968f, -0.05897540f, 0.02009952f, 
    0.09927183f, 0.00902989f, -0.17285623f, -0.14735369f, -0.26181272f, -0.03658564f, 0.12781014f, -0.09920657f, 
    -0.05626890f, -0.09146547f, 0.03569750f, 0.02442793f, -0.04692606f, -0.14560877f, -0.02118195f, -0.11659094f, 
    0.18879417f, -0.05956759f, -0.11971167f, 0.11271894f, -0.14685223f, -0.02616051f, 0.11048154f, 0.00832223f, 
    0.30249545f, 0.03960587f, -0.18727098f, -0.04656974f, -0.09275153f, -0.14037009f, -0.03400872f, -0.02035474f, 
    -0.25268587f, -0.01098592f, -0.26486415f, -0.03167737f, -0.12810338f, -0.03859597f, -0.16988596f, -0.01200800f, 
    0.19293208f, -0.25402528f, -0.13510723f, -0.19909449f, -0.09041907f, 0.00634965f, 0.17270939f, -0.13560244f, 
    0.20822534f, -0.19897833f, -0.09936245f, -0.18664578f, -0.05492753f, 0.10062028f, -0.08877084f, 0.10424159f, 
    0.15507303f, 0.09180123f, -0.02256074f, 0.07024483f, -0.10413438f, -0.02437447f, -0.06761231f, 0.10358156f, 
    0.19530202f, 0.09552347f, -0.10238307f, 0.06329990f, 0.12126180f, 0.17343323f, -0.04439930f, -0.32489821f, 
    0.14731902f, 0.01243143f, 0.22615871f, 0.22674483f, 0.24732193f, 0.06632835f, -0.00564380f, 0.16301130f, 
    0.11116457f, 0.20899227f, 0.23383527f, 0.18951413f, 0.15447907f, 0.16198590f, 0.02585771f, -0.05563692f, 
    0.10635431f, 0.07559802f, 0.14953382f, 0.13941157f, 0.04124010f, 0.04830359f, 0.01145130f, 0.01611673f, 
    0.15234371f, 0.02030485f, 0.12570840f, 0.12818453f, 0.02029513f, 0.11293542f, 0.17148869f, 0.07448442f, 
    -0.04970310f, -0.12848914f, 0.03196601f, 0.03906747f, -0.13104707f, 0.01028969f, 0.14291742f, 0.12527874f, 
    0.01571413f, 0.08198860f, 0.27861139f, 0.04913126f, 0.02310682f, 0.10558128f, 0.10206605f, 0.10626782f, 
    0.05619101f, 0.23042558f, 0.05253663f, 0.10035831f, -0.08060263f, 0.05668688f, 0.02705905f, 0.17046495f, 
    0.35542393f, 0.11644302f, -0.15227656f, 0.06968760f, -0.14510848f, 0.09061377f, -0.15515700f, -0.18035676f, 
    -0.09476028f, -0.11597373f, 0.13945706f, 0.12542191f, -0.34122571f, -0.12775235f, -0.16514334f, -0.08178651f, 
    -0.12502043f, 0.15369044f, 0.01220113f, 0.24044584f, -0.13227957f, 0.09768711f, -0.06536907f, 0.07134388f, 
    0.17794178f, -0.07239027f, 0.02967611f, 0.09287540f, -0.00361235f, -0.11566027f, -0.48116976f, -0.26127118f, 
    0.13399458f, -0.27250585f, 0.07377230f, 0.10472959f, -0.03813602f, 0.10774390f, -0.33467406f, -0.25840002f, 
    0.06077691f, -0.07148811f, -0.08118148f, 0.16070525f, -0.05316075f, 0.30627045f, -0.18032981f, -0.03226060f, 
    -0.03386245f, -0.06616897f, 0.02423503f, 0.03366276f, 0.06293256f, 0.03881788f, 0.03623328f, 0.09875854f, 
    -0.19024809f, 0.03006069f, 0.17853191f, -0.16107376f, -0.24909176f, -0.07747570f, 0.00084340f, -0.03691803f, 
    0.00871854f, -0.00799207f, 0.02062627f, -0.16047521f, 0.07553638f, -0.02477700f, 0.13146515f, 0.04083923f, 
    0.13208254f, -0.03821162f, -0.03737247f, -0.12080006f, 0.07990080f, -0.06497903f, 0.06257013f, -0.20349407f, 
    0.06008051f, 0.14338413f, 0.07577964f, 0.04590996f, -0.12245744f, -0.10582750f, 0.01557825f, -0.03999595f, 
    0.01454195f, -0.12898876f, 0.30584329f, -0.05504027f, 0.11534951f, -0.09204365f, -0.03323125f, -0.10225510f, 
    -0.06814679f, 0.02218884f, 0.07015603f, 0.25138691f, 0.08351610f, 0.05461946f, 0.15301672f, 0.22324118f, 
    -0.05460316f, 0.08009861f, -0.07668453f, -0.01796555f, 0.02737155f, 0.11185453f, 0.02952840f, 0.08786392f, 
    0.32731479f, -0.07144240f, 0.02039590f, 0.08247292f, 0.10337216f, -0.03901427f, 0.04923120f, -0.04233860f, 
    -0.01757960f, -0.04336872f, 0.00386806f, -0.09549316f, 0.07644852f, 0.11984465f, 0.06222663f, 0.00937502f, 
    0.04277937f, -0.16828839f, 0.19660355f, -0.05130900f, -0.01460914f, 0.09036664f, -0.10710566f, -0.24801885f, 
    0.04292804f, -0.08705939f, -0.04322244f, 0.18038201f, -0.06238486f, -0.03957897f, 0.05474445f, 0.00401675f, 
    -0.11489780f, -0.00886031f, -0.15084150f, 0.10767291f, 0.34197709f, -0.04579731f, 0.02059583f, 0.02092467f, 
    0.00759037f, -0.04714237f, -0.22393435f, 0.04795971f, 0.11468557f, -0.14332630f, 0.01007547f, -0.07607701f, 
    -0.00116234f, -0.09184508f, 0.13374782f, 0.19153386f, 0.00316673f, -0.20884641f, -0.23528650f, -0.03764540f, 
    -0.01222850f, -0.20523201f, 0.07897259f, -0.14114706f, 0.10595831f, 0.07416987f, -0.11209649f, 0.02365949f, 
    -0.37746015f, 0.03005563f, -0.05005514f, 0.08041871f, 0.17371599f, 0.02074707f, 0.00301418f, -0.00833132f, 
    -0.11382835f, -0.06469799f, 0.06087321f, -0.15751128f, 0.06254097f, -0.12007810f, -0.03553018f, -0.19918346f, 
    -0.00712893f, 0.33850345f, 0.00317455f, -0.09452129f, -0.20036826f, 0.26456028f, 0.00247881f, 0.07369026f, 
    -0.21721070f, -0.15495077f, 0.01114353f, -0.16462275f, -0.02014477f, 0.08636288f, 0.05045759f, 0.14707085f, 
    0.04168777f, -0.07863680f, -0.01365893f, 0.05725268f, 0.08727896f, -0.07106578f, 0.10813567f, 0.24029225f, 
    0.00918004f, -0.01787731f, -0.18831003f, -0.16234767f, -0.11856118f, -0.02021659f, 0.06051173f, 0.04772437f, 
    0.09951264f, 0.23502411f, 0.13720724f, 0.02586221f, -0.03740641f, 0.09727088f, 0.05382078f, -0.11940522f, 
    0.01222746f, -0.01961719f, 0.02421937f, 0.03528653f, -0.11391474f, 0.00325410f, -0.12878667f, 0.00097110f, 
    -0.01153692f, 0.09826128f, -0.01029447f, 0.07812537f, 0.02591165f, 0.15063304f, 0.14979734f, 0.15179034f, 
    -0.09607573f, 0.05908115f, 0.12017360f, -0.06546605f, -0.31075701f, -0.34940210f, 0.24524339f, -0.03287482f, 
    0.05564469f, -0.03029163f, -0.02142332f, -0.01235983f, -0.02737495f, 0.09352821f, -0.20796604f, -0.29414380f, 
    -0.11091912f, 0.03647145f, -0.18717073f, -0.07196430f, 0.01965825f, 0.00874038f, 0.13080457f, -0.08891763f, 
    0.12353476f, 0.12946279f, -0.07539642f, -0.06722155f, 0.05073549f, -0.15105866f, 0.15356694f, -0.11313881f, 
    0.20366140f, -0.26424274f, 0.10354330f, 0.09906962f, -0.22123131f, -0.00503033f, 0.05109389f, -0.04335391f, 
    0.01548878f, -0.06407217f, 0.21495511f, 0.07946479f, 0.28311214f, 0.01896944f, 0.06903816f, -0.02246817f, 
    -0.02429655f, -0.07548816f, 0.00810095f, -0.42845985f, -0.13886383f, -0.13883342f, 0.11639464f, 0.23481436f, 
    0.20769441f, 0.01234156f, 0.04150402f, -0.07621939f, -0.12832756f, -0.15228897f, 0.09261799f, -0.11652133f, 
    0.04048890f, 0.08345432f, 0.12371500f, 0.20161448f, 0.07316981f, 0.07161545f, 0.06904010f, 0.09260601f, 
    -0.04063885f, -0.06215285f, 0.05015567f, 0.06936958f, 0.05971754f, -0.13721134f, 0.10128589f, 0.03340502f, 
    -0.12432881f, 0.14357968f, 0.00113442f, 0.02610717f, -0.00044936f, 0.08325075f, -0.02333385f, -0.04994605f, 
    -0.08353414f, 0.09522434f, 0.01130900f, 0.06047591f, 0.13521668f, 0.00330601f, -0.18085870f, -0.01393803f, 
    -0.14184313f, -0.00715354f, 0.14944725f, 0.10413878f, 0.22678040f, 0.12587899f, 0.02140524f, -0.06416818f, 
    0.09626596f, -0.22669421f, -0.17974345f, -0.00753280f, 0.05288286f, 0.02247567f, 0.13551660f, 0.11342710f, 
    -0.00407773f, -0.06715444f, -0.00112892f, -0.04701451f, -0.14088693f, 0.02049218f, -0.03735999f, 0.10031469f, 
    0.10536855f, 0.00505478f, 0.08165602f, 0.06582301f, 0.13669369f, 0.08239125f, 0.16304630f, -0.16793343f, 
    -0.04528974f, 0.24299330f, -0.08236326f, -0.36190751f, -0.22551270f, -0.16409978f, -0.01492840f, 0.04724182f, 
    0.16743191f, 0.08550863f, 0.04701813f, -0.15936141f, -0.19102120f, 0.12695152f, 0.19526920f, 0.13746667f, 
    0.13625000f, -0.16397433f, 0.18922448f, 0.10044090f, 0.02141484f, 0.03614208f, 0.00389031f, 0.01795939f, 
    0.02677760f, 0.09985375f, -0.05947628f, -0.04518243f, 0.15073934f, -0.07644822f, 0.07614466f, 0.11529142f, 
    0.07975611f, -0.03071913f, 0.04778653f, 0.11595756f, -0.01498390f, 0.04523607f, 0.07635080f, -0.30601370f, 
    0.10310169f, -0.03579915f, 0.08339079f, -0.01107639f, 0.20329875f, 0.05781641f, -0.45662540f, 0.18087697f, 
    -0.02753688f, -0.20394436f, -0.09497352f, -0.07191154f, 0.09552919f, 0.20220748f, 0.00128591f, 0.27066869f, 
    0.13446847f, -0.31256044f, 0.02963938f, -0.01295384f, 0.02735951f, 0.09268228f, -0.05179728f, 0.02846391f, 
    0.08578286f, -0.04332682f, 0.20957977f, -0.17126900f, -0.28594971f, -0.08502530f, -0.08440170f, -0.06941640f, 
    0.18379086f, 0.05533521f, -0.11545675f, -0.02535368f, 0.13449289f, 0.14478666f, 0.10138787f, -0.05639021f, 
    0.12164900f, -0.07842170f, 0.03663516f, -0.06019107f, -0.03089368f, -0.06895483f, -0.05978437f, -0.08332431f, 
    0.25566852f, 0.07927919f, 0.05446621f, 0.00080109f, -0.02649585f, -0.10263608f, 0.06989373f, 0.30820599f, 
    0.10748433f, -0.02616304f, -0.04199946f, 0.05981378f, -0.10530096f, 0.05278036f, -0.50712180f, -0.10549261f, 
    -0.22362134f, 0.11829697f, -0.23517717f, 0.32384259f, -0.17239863f, -0.01091552f, -0.08689921f, -0.46911198f, 
    -0.05741936f, -0.12933175f, -0.05835189f, -0.02544047f, -0.15218568f, 0.02688415f, 0.08023586f, 0.11376483f, 
    -0.00029022f, -0.06889836f, -0.20478754f, -0.14372483f, 0.03241556f, 0.01164574f, 0.05140108f, 0.16430819f, 
    -0.14426120f, 0.00916725f, -0.04216038f, -0.16257726f, -0.11435103f, 0.04457195f, 0.00238101f, -0.00682738f, 
    0.15769359f, 0.02283888f, 0.05941802f, 0.13450469f, 0.15889192f, 0.04305534f, -0.02922637f, -0.04010961f, 
    0.13154992f, -0.02207665f, 0.06662099f, -0.18423709f, 0.13344781f, 0.34925348f, -0.10636424f, 0.01120488f, 
    0.12490163f, -0.15625098f, 0.12286678f, 0.26012823f, 0.11108831f, 0.10898545f, 0.24146117f, 0.08581918f, 
    -0.02652968f, 0.05737861f, 0.09426424f, 0.09738392f, 0.19108646f, 0.06349156f, 0.17412889f, -0.00206790f, 
    0.41620836f, 0.06725892f, -0.00615220f, 0.16900882f, 0.00591762f, -0.00983574f, 0.00831458f, -0.21516138f, 
    0.01075360f, -0.03624187f, 0.01306898f, -0.03057575f, 0.00895743f, -0.21160616f, 0.02262531f, 0.14177087f, 
    0.13298890f, 0.20228875f, 0.17208755f, 0.16195601f, -0.00076058f, 0.04992217f, 0.05741397f, 0.12377568f, 
    -0.14809005f, -0.17608890f, -0.09963394f, 0.00005133f, 0.10207275f, 0.05474933f, 0.04027157f, 0.20506255f, 
    0.04749301f, 0.23635104f, 0.09866715f, 0.20927390f, 0.16376401f, -0.10257562f, 0.04776249f, -0.10252356f, 
    0.13579695f, 0.06107399f, -0.12191774f, -0.21268229f, -0.13533694f, 0.01540135f, 0.03589574f, -0.14926490f, 
    -0.18854056f, -0.06130247f, 0.05279855f, -0.00865223f, -0.08711991f, -0.15335557f, -0.18844227f, 0.08135149f, 
    0.02489268f, -0.02687812f, -0.13062075f, 0.04570242f, -0.01946247f, -0.25306073f, -0.10029633f, 0.13236547f, 
    0.13595341f, -0.20201907f, -0.01178410f, 0.10977054f, -0.07818528f, -0.29482219f, -0.07366141f, 0.13480842f, 
    -0.31306025f, -0.00251423f, 0.05620468f, -0.02942576f, 0.06024292f, 0.01176284f, -0.23037706f, -0.08761463f, 
    0.14962280f, 0.12721239f, -0.03520706f, 0.09842721f, -0.11313588f, 0.19471236f, -0.06154121f, -0.04191580f, 
    0.35673112f, -0.09388161f, 0.05640918f, -0.08618154f, 0.13683565f, -0.03005046f, 0.00342555f, -0.05279451f, 
    -0.03889243f, 0.08253460f, -0.05885915f, 0.20549881f, 0.00549483f, 0.03024760f, -0.01036895f, 0.00697878f, 
    0.13311993f, 0.30466807f, -0.02076945f, 0.08338218f, 0.06425458f, 0.05845821f, 0.07988231f, -0.02176615f, 
    -0.04951121f, 0.02678567f, -0.10797458f, 0.02852915f, 0.10530718f, 0.27231720f, -0.05464888f, -0.05626399f, 
    -0.21925455f, -0.05727138f, -0.04109917f, 0.17873615f, 0.05008215f, 0.26675099f, 0.27913156f, -0.36417767f, 
    -0.00622351f, -0.10638706f, -0.02200169f, 0.00966046f, 0.09953194f, 0.14740285f, 0.33775342f, -0.07064598f, 
    0.02220416f, -0.31562182f, -0.32371533f, 0.09380174f, 0.02906847f, -0.02419936f, 0.20148066f, 0.19510327f, 
    -0.16415381f, 0.08966312f, -0.13004175f, -0.18571177f, -0.02770174f, 0.07076023f, -0.06250657f, 0.42078403f, 
    0.05165553f, -0.24707997f, -0.10245939f, -0.14103737f, 0.04738484f, -0.00887705f, -0.04366528f, -0.04467519f, 
    -0.62623537f, -0.05478863f, -0.00528437f, -0.24371701f, -0.24874438f, 0.00162906f, -0.02758759f, -0.17676727f, 
    -0.01518730f, 0.22791001f, -0.10534505f, -0.21814397f, -0.12575638f, -0.03367117f, -0.19284920f, 0.03796354f, 
    -0.07932640f, 0.15073907f, 0.34249583f, 0.29758647f, 0.04861465f, 0.07005314f, 0.15953161f, 0.04130661f, 
    -0.02056420f, 0.00394875f, -0.08308893f, 0.07735394f, -0.12617204f, 0.40315452f, -0.02545569f, 0.13381785f, 
    -0.00233690f, 0.12923184f, -0.00596496f, 0.19926646f, 0.51537126f, 0.00140419f, -0.04517348f, -0.16349511f, 
    -0.04289277f, -0.33761483f, 0.10895259f, -0.00877690f, 0.10308193f, 0.14294094f, 0.31913564f, 0.14249170f, 
    -0.23027304f, -0.28196004f, -0.09150838f, -0.01078970f, 0.06722502f, 0.06018234f, 0.22815838f, 0.02500002f, 
    0.04556985f, 0.04395649f, -0.10312184f, 0.11727570f, -0.17790712f, 0.13202432f, 0.06323745f, -0.29876223f, 
    -0.03398579f, -0.12917751f, 0.05675342f, 0.04910742f, -0.18125157f, 0.13514020f, 0.02500418f, 0.29876691f, 
    -0.07410404f, -0.19215490f, -0.00196708f, 0.23232269f, 0.03671594f, -0.10524930f, 0.08211501f, 0.07263024f, 
    0.03450474f, 0.16859990f, 0.08189972f, 0.24724548f, 0.19916971f, -0.05273563f, -0.00988210f, 0.01217287f, 
    -0.03018702f, 0.09021808f, -0.01833164f, 0.00311193f, 0.11243174f, -0.00975072f, 0.05516931f, -0.05068236f, 
    0.05113407f, 0.01357488f, 0.05244162f, -0.06254144f, -0.26354131f, -0.26421797f, -0.03920189f, -0.08257818f, 
    -0.03855398f, -0.12256385f, 0.24026105f, -0.21033084f, 0.02713823f, -0.13495627f, -0.02844598f, -0.06996308f, 
    0.06190836f, 0.08634863f, -0.09123167f, 0.02416455f, -0.12160084f, -0.10101075f, 0.02642764f, -0.05685708f, 
    -0.04248839f, 0.04236243f, -0.10652701f, -0.08899691f, -0.03158542f, -0.06414935f, -0.23312201f, 0.19798954f, 
    0.26224992f, -0.11129431f, -0.07848073f, 0.03991552f, 0.06404600f, 0.04028903f, 0.00499380f, 0.16459100f, 
    -0.13246590f, -0.02880368f, 0.09567708f, 0.07227034f, -0.03750983f, 0.07038485f, 0.01210846f, -0.11053433f, 
    0.03417174f, -0.23687303f, -0.40657195f, 0.03131992f, 0.02603538f, 0.02547414f, -0.01595214f, -0.00161045f, 
    0.03146498f, 0.17392066f, 0.19442499f, 0.07010318f, 0.02436531f, 0.02081431f, 0.08823746f, 0.11791399f, 
    -0.03056087f, -0.22456904f, 0.43982312f, 0.13992968f, -0.31818828f, -0.17326833f, 0.08852490f, -0.13067317f, 
    0.17383122f, -0.01482860f, -0.08524300f, -0.01483162f, -0.37775940f, 0.11240038f, 0.06964743f, 0.04573863f, 
    0.16092645f, 0.09551029f, -0.17019206f, -0.14551648f, 0.12060804f, -0.02329105f, 0.09969144f, 0.11760738f, 
    0.04189058f, -0.10368739f, 0.04256378f, 0.03172671f, 0.11998656f, -0.15400967f, 0.07989337f, -0.42629606f, 
    -0.10884057f, -0.02349422f, 0.07201193f, 0.14421460f, -0.10052875f, -0.30496138f, 0.06175118f, -0.28566936f, 
    0.25594199f, -0.05356429f, -0.14888449f, 0.07550905f, 0.03235146f, -0.02540601f, 0.29343525f, -0.03322280f, 
    0.29261380f, -0.13832633f, -0.19216089f, -0.03958452f, -0.12989241f, 0.05710759f, 0.09660744f, -0.12959510f, 
    -0.26397744f, 0.12654749f, -0.26831573f, -0.04038821f, -0.06697708f, 0.17280366f, 0.05679037f, -0.10897791f, 
    0.00186782f, -0.10418703f, 0.11364505f, -0.07787035f, 0.06230481f, 0.10958240f, 0.02978751f, 0.18939848f, 
    0.06020555f, -0.01599630f, 0.14104706f, -0.23176752f, -0.15900405f, 0.02942887f, -0.07363204f, 0.18394522f, 
    0.03705627f, -0.03668087f, 0.00281078f, 0.19427855f, -0.11857557f, -0.19679321f, -0.04893275f, 0.08199432f, 
    -0.01671245f, -0.12059875f, 0.18575299f, 0.02868740f, 0.05286068f, 0.06181601f, -0.10302977f, -0.03544169f, 
    -0.05648759f, 0.08013008f, 0.13131580f, 0.05589921f, 0.11784275f, 0.03102792f, -0.45913708f, 0.06410001f, 
    0.00865654f, -0.06486819f, 0.11251076f, 0.01949342f, 0.14704481f, 0.08870684f, -0.19111609f, -0.46765825f, 
    -0.34959924f, 0.12351400f, -0.00356367f, 0.13844316f, 0.07255978f, 0.05526580f, 0.10776287f, 0.28509954f, 
    0.25664872f, -0.47079003f, -0.07535895f, 0.02981420f, 0.06281926f, 0.00811182f, 0.25698036f, -0.04993093f, 
    0.46076193f, -0.25356901f, 0.03630529f, -0.04145283f, -0.08128864f, 0.05966989f, 0.21867615f, 0.04500794f, 
    -0.03517701f, 0.08675879f, 0.14863782f, 0.06056724f, -0.10060212f, -0.04957613f, -0.02725621f, -0.03408738f, 
    -0.05511988f, -0.10933395f, 0.17870949f, 0.10266398f, -0.13455164f, 0.08449429f, 0.16055165f, 0.11537341f, 
    -0.04420564f, -0.09397195f, 0.03068011f, -0.31840283f, 0.18454066f, -0.10705357f, -0.04133806f, 0.11846604f, 
    0.22669235f, 0.00724526f, 0.02216676f, -0.02407511f, 0.34449831f, 0.08482350f, -0.01785254f, 0.06498221f, 
    0.00631873f, 0.07217111f, 0.04669979f, -0.01508471f, -0.01923592f, -0.06662964f, 0.03262415f, -0.14763577f, 
    -0.19531663f, -0.14055377f, -0.05037166f, 0.03674118f, -0.12147294f, 0.19017108f, 0.35295662f, -0.14554894f, 
    0.18272603f, -0.19930893f, 0.11805823f, 0.08971725f, 0.07683008f, -0.07643218f, -0.04255467f, -0.03802513f, 
    -0.16305882f, -0.37109631f, 0.06145683f, 0.01849969f, 0.15266225f, 0.03549155f, 0.14202857f, -0.06984983f, 
    -0.26517165f, -0.07506372f, 0.02310530f, 0.11099049f, -0.02480504f, 0.01336985f, 0.14966153f, -0.13462295f, 
    -0.00728388f, 0.14053974f, -0.00404804f, -0.14841659f, 0.12560761f, 0.10357232f, 0.05183288f, -0.05640351f, 
    -0.00560386f, 0.16483586f, 0.10686186f, -0.16339667f, -0.16734874f, 0.21407354f, 0.05962437f, 0.05135655f, 
    0.04962234f, 0.05873452f, 0.00460666f, 0.07534680f, 0.09927087f, -0.28855526f, -0.04812859f, 0.08414688f, 
    -0.01031774f, 0.00517964f, 0.19591182f, 0.02870237f, 0.01133682f, 0.19551043f, -0.08406021f, -0.07467159f, 
    0.16015822f, 0.02461747f, -0.01240015f, 0.00873263f, 0.02075251f, 0.17973003f, 0.21727332f, 0.33287880f, 
    -0.18614252f, -0.09023765f, -0.13490075f, -0.12240952f, -0.02709278f, 0.08610756f, 0.11706410f, 0.00603605f, 
    0.28208804f, 0.15753588f, 0.04764906f, -0.04906600f, -0.03024262f, -0.02152951f, 0.09590161f, 0.10641917f, 
    0.11602686f, -0.27959478f, 0.01993367f, -0.00203654f, 0.02821070f, -0.00608518f, -0.05689715f, 0.03727742f, 
    0.24151203f, -0.00467103f, 0.22652125f, -0.05988651f, -0.01729022f, 0.07372276f, -0.05555900f, -0.06962472f, 
    -0.02278040f, -0.00045297f, 0.00448193f, -0.12860386f, -0.08491574f, -0.01451027f, 0.17301323f, 0.12143039f, 
    0.06093233f, -0.14264834f, -0.32723105f, -0.08105592f, -0.21863471f, -0.10982981f, 0.02664865f, 0.15249580f, 
    -0.01184055f, 0.02249028f, 0.11365014f, 0.02304023f, -0.36286360f, -0.12114910f, 0.06533178f, -0.19675827f, 
    -0.08195553f, -0.13251749f, -0.09706067f, -0.05443847f, 0.32421750f, -0.01708738f, -0.23910935f, 0.18738233f, 
    -0.06509753f, -0.10404380f, -0.00588838f, 0.12180249f, 0.18051118f, -0.07967977f, 0.04891805f, -0.49081892f, 
    -0.25400817f, 0.02186468f, -0.02570475f, 0.07154995f, 0.15010081f, 0.06998891f, -0.01931068f, 0.17504230f, 
    0.01399727f, 0.05730101f, 0.04755452f, 0.13615631f, -0.00871067f, -0.16756408f, 0.12693615f, 0.14041707f, 
    0.28600913f, 0.00042119f, 0.00335393f, 0.09040749f, 0.13024329f, 0.11244940f, 0.04732805f, -0.10625329f, 
    0.06036791f, 0.07042282f, 0.28952101f, 0.15502127f, -0.10174616f, 0.11727899f, -0.00574751f, 0.02620464f, 
    -0.04014406f, 0.08916883f, 0.19472437f, 0.25541508f, -0.08971851f, 0.12159768f, -0.01378065f, -0.02397900f, 
    0.16436557f, 0.10745383f, 0.09260994f, 0.06785835f, -0.15336971f, 0.10047562f, -0.08296151f, 0.05840823f, 
    -0.09399731f, 0.01190802f, 0.07228708f, -0.23333639f, 0.10568482f, -0.28393289f, 0.20751791f, -0.04093332f, 
    -0.28636295f, -0.00181884f, -0.29516411f, 0.14105000f, -0.05237821f, 0.01985569f, 0.02637061f, -0.04123248f, 
    -0.13463242f, -0.19635482f, 0.00951154f, 0.12598774f, 0.02911136f, -0.08483247f, -0.35056663f, -0.43964723f, 
    -0.12415108f, -0.17231865f, -0.00476005f, 0.02069809f, 0.00040642f, 0.10540706f, -0.12192028f, -0.24692845f, 
    -0.49834535f, -0.02020434f, 0.01775100f, -0.08482389f, -0.12372317f, -0.04746480f, 0.11756809f, 0.14456852f, 
    0.00671790f, -0.12099598f, -0.20914434f, 0.08684727f, -0.12851758f, -0.03014490f, -0.14785023f, -0.04806013f, 
    -0.27744818f, -0.31198487f, 0.09840484f, 0.05211849f, 0.24291287f, 0.12086922f, 0.32385042f, 0.06693497f, 
    -0.26026052f, -0.10031240f, -0.16682260f, -0.08283034f, -0.01501202f, 0.18302433f, -0.06634103f, 0.10771713f, 
    0.02217872f, 0.02345247f, -0.04318787f, -0.07590416f, 0.06580761f, 0.16781497f, 0.02498050f, 0.02807179f, 
    -0.04292066f, -0.11072142f, 0.05969535f, 0.20602793f, 0.26772663f, 0.07974869f, -0.06286133f, 0.05994060f, 
    -0.07221328f, -0.08085738f, 0.06434223f, 0.04371038f, 0.07409041f, 0.07342902f, 0.05548617f, -0.14204226f, 
    -0.11311295f, -0.25175571f, -0.03138266f, 0.08958629f, -0.06429790f, 0.08593733f, 0.10717750f, -0.08267789f, 
    0.06874119f, -0.07173918f, 0.02388118f, 0.01557598f, -0.11136444f, 0.02958428f, -0.36514610f, 0.13462754f, 
    -0.26511204f, -0.01509255f, -0.11283378f, 0.13920215f, -0.13991551f, 0.01236909f, 0.07450686f, 0.08465335f, 
    -0.03515905f, 0.00183908f, -0.11561275f, 0.28694260f, -0.06356524f, -0.03400406f, 0.00762341f, 0.02818360f, 
    0.26426589f, 0.15323743f, 0.34894475f, 0.06163045f, -0.22720997f, -0.11043531f, 0.00116677f, 0.08271372f, 
    0.04608398f, 0.15338576f, -0.05373481f, 0.02011785f, -0.05620551f, -0.18687260f, 0.11518723f, 0.23339000f, 
    0.02637810f, -0.03587258f, 0.18887435f, 0.28467476f, 0.11357335f, 0.04259350f, -0.05489247f, -0.21776897f, 
    -0.01475051f, 0.02434524f, -0.01004132f, -0.44415098f, -0.01709573f, -0.35185224f, -0.01665168f, 0.06015050f, 
    0.08494847f, 0.00487430f, 0.15394239f, 0.09400619f, -0.02788216f, 0.06379064f, 0.13529974f, -0.00571412f, 
    0.14226194f, -0.11129774f, 0.07319409f, 0.25815564f, -0.07791452f, -0.29485649f, -0.02433119f, 0.14347170f, 
    -0.00067194f, 0.02710956f, -0.11575680f, 0.00329026f, 0.06571782f, -0.00732838f, -0.39209592f, -0.16554523f, 
    0.25541657f, 0.07868853f, 0.00758500f, -0.01417475f, 0.01573781f, 0.07520822f, -0.14946347f, 0.22069699f, 
    0.03168657f, 0.11856801f, 0.08031926f, -0.06476350f, -0.01272365f, -0.04121261f, 0.06124106f, -0.03473867f, 
    -0.19039495f, -0.20348705f, -0.46060520f, -0.09833336f, 0.03668105f, 0.11423842f, -0.06719165f, -0.06421459f, 
    0.14332442f, 0.10917541f, 0.19212060f, 0.14503872f, -0.00448753f, 0.06351300f, 0.17900527f, 0.04037000f, 
    -0.08271829f, 0.12084956f, 0.02763602f, -0.00154804f, -0.62830096f, 0.03597600f, 0.00832213f, -0.04747827f, 
    -0.00627079f, -0.13303962f, 0.03458091f, 0.39085925f, 0.07843821f, 0.21078968f, -0.36412644f, -0.11883001f, 
    -0.01510137f, -0.01593500f, 0.11934026f, -0.16370885f, 0.31115919f, 0.12604246f, 0.14434089f, 0.02590971f, 
    -0.14227638f, -0.00665466f, -0.01375979f, 0.09457811f, -0.05405968f, -0.03085482f, 0.14973244f, -0.69399244f, 
    -0.02973624f, 0.19930418f, 0.19176339f, 0.03647975f, 0.19769263f, -0.14380765f, -0.16920221f, -0.16618702f, 
    0.12786582f, -0.17693116f, 0.03286361f, -0.12503836f, -0.09058798f, 0.02963202f, 0.06039882f, -0.07013579f, 
    -0.11614999f, -0.04138890f, -0.10522532f, 0.07816813f, -0.04946727f, -0.03365196f, -0.10960933f, -0.02226144f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10547494f, -0.02206229f, 0.20593423f, 0.14989589f, 0.10957146f, 0.02640118f, -0.03408701f, -0.01548535f, 
    0.02869446f, -0.17020410f, 0.08760540f, -0.01405072f, -0.05186186f, -0.04790058f, -0.02053927f, 0.04901107f, 
    0.11783892f, 0.22572505f, -0.04489720f, -0.03768123f, -0.07440782f, 0.05239983f, 0.13491379f, 0.02348702f, 
    0.03965080f, 0.11485228f, 0.25123990f, 0.07077214f, 0.13801594f, 0.04158377f, 0.02899598f, 0.08134487f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22602470f, 0.02384708f, 0.40896955f, -0.11878884f, 0.15357652f, -0.12048580f, 0.36226529f, -0.07805191f, 
    0.09511264f, 0.09448203f, 0.17027676f, 0.06760065f, 0.06479663f, 0.72882295f, -0.14147402f, -0.00689619f, 
    -0.25393400f, -0.27880281f, 0.17331252f, -0.13829343f, 0.22317018f, 0.15821694f, 0.20128947f, -0.02780787f, 
    0.06965622f, 0.05840403f, -0.22511315f, -0.21475911f, 0.30997699f, -0.02579654f, 0.18290851f, 0.19469844f, 
    0.39878550f, -0.06353348f, -0.46596086f, 0.33529180f, 0.04238175f, -0.06614408f, 0.02861609f, 0.01873300f, 
    0.13033374f, -0.09641036f, 0.38804436f, 0.24853851f, 0.14901644f, -0.04365292f, -0.02008798f, 0.04707006f, 
    0.08940391f, 0.02422728f, 0.07448752f, 0.03963618f, -0.12303180f, 0.44463351f, 0.16755274f, 0.13712010f, 
    -0.28385687f, 0.01665870f, 0.27971056f, -0.18869165f, -0.05330816f, 0.00740180f, -0.20865549f, 0.41877463f, 
    0.49783862f, 0.09631187f, -0.22729306f, 0.22521792f, -0.18894310f, -0.14322147f, -0.20708776f, 0.01923487f, 
    -0.08114395f, -0.20145486f, 0.01824500f, 0.14949705f, 0.00705380f, -0.40552101f, -0.11560334f, -0.09844644f, 
    0.32766217f, 0.26630679f, 0.25563714f, -0.06806821f, -0.01085999f, 0.41945142f, 0.03321775f, 0.10040107f, 
    -0.21019299f, -0.02824126f, 0.12543856f, -0.12854885f, 0.12576938f, 0.10377205f, -0.18894446f, 0.04903987f, 
    -0.24422289f, -0.08681271f, 0.84578311f, 0.23072562f, -0.04613743f, 0.00478155f, 0.11219685f, -0.07204002f, 
    0.04014512f, 0.03744053f, -0.25078681f, -0.27039608f, -0.07307002f, -0.07608256f, -0.06140773f, 0.00249775f, 
    0.18687592f, -0.08316414f, -0.26205820f, 0.15404464f, 0.16341756f, -0.11304267f, -0.26354623f, 0.17813170f, 
    0.30844298f, 0.28367478f, 0.20708615f, -0.20831820f, 0.04068640f, 0.10837959f, 0.07233527f, 0.06227893f, 
    -0.61603171f, -0.07382040f, 0.39619941f, 0.25799024f, 0.09099150f, 0.00675211f, 0.31706432f, 0.07427899f, 
    0.00410850f, -0.00182889f, 0.09677298f, -0.00786530f, -0.14491744f, 0.56238812f, -0.10827778f, -0.15043840f, 
    -0.30912811f, 0.04838727f, -0.26780769f, 0.13687930f, -0.29769075f, -0.25370851f, 0.35810524f, 0.02423497f, 
    0.17726018f, -0.00563846f, 0.11789151f, 0.09784245f, -0.07810663f, -0.10790578f, 0.48832449f, 0.05521363f, 
    0.30607834f, 0.16422728f, -0.32647493f, 0.05925368f, 0.18475233f, -0.04686330f, -0.00487794f, 0.04985425f, 
    -0.14971989f, -0.30372465f, -0.20587888f, -0.17347315f, 0.06258842f, -0.51647425f, -0.08666640f, -0.09145961f, 
    0.40221524f, 0.20418261f, 0.12204190f, 0.14295113f, -0.45262238f, -0.14984353f, 0.06065758f, 0.16013213f, 
    0.18351816f, 0.22397597f, 0.08523788f, 0.16635378f, -0.06054210f, -0.10068384f, 0.02057762f, -0.57787937f, 
    0.07307851f, 0.03562683f, 0.31696635f, 0.56195432f, 0.18639395f, 0.05191470f, -0.19709896f, -0.07566381f, 
    0.03434730f, -0.03645437f, 0.05683665f, -0.00088443f, -0.14748408f, -0.15171628f, -0.08442694f, -0.08829675f, 
    -0.13728282f, 0.03888883f, -0.12402065f, 0.11191144f, -0.10247421f, -0.14337891f, 0.30688512f, -0.07768381f, 
    -0.21630420f, -0.02099602f, 0.38050026f, -0.06650741f, 0.27067098f, -0.31432489f, -0.12995762f, 0.23407841f, 
    0.09113983f, -0.08049192f, 0.02269172f, 0.38576803f, 0.09044721f, -0.05080023f, 0.37441745f, -0.02727072f, 
    -0.04432826f, 0.20664190f, 0.34963715f, 0.23894428f, -0.09196299f, 0.22131598f, -0.10239384f, 0.03987869f, 
    0.02129325f, -0.14523764f, 0.14882144f, -0.15788879f, -0.46048051f, 0.08803532f, 0.35016125f, -0.14329796f, 
    -0.15049917f, -0.11795653f, 0.14504616f, -0.08297175f, -0.00970510f, -0.32987416f, -0.11996162f, 0.24293576f, 
    0.09122554f, 0.09056883f, -0.23451845f, 0.42405558f, 0.16345300f, 0.07370508f, -0.25634655f, -0.16709109f, 
    -0.12675647f, 0.17336129f, 0.23366086f, 0.11594220f, -0.13625625f, 0.24093810f, -0.03133030f, -0.03008115f, 
    -0.26225263f, -0.08807449f, 0.13114555f, 0.00200005f, -0.20293523f, 0.24162959f, 0.07511798f, 0.00623451f, 
    -0.23271167f, 0.17480101f, 0.35745868f, -0.26238716f, 0.14359719f, -0.23857170f, -0.16130678f, 0.05897916f, 
    0.54247665f, 0.01027973f, 0.11684081f, -0.02065596f, -0.05998704f, 0.05596814f, -0.22535524f, 0.00738914f, 
    0.03297025f, 0.17423606f, 0.21851046f, 0.16537663f, -0.07513465f, -0.14128302f, 0.15219137f, -0.14214449f, 
    -0.13497968f, 0.01256050f, -0.28207430f, 0.09646625f, -0.07425302f, -0.08593153f, -0.09842826f, 0.05684267f, 
    -0.30423316f, -0.35505795f, -0.00577160f, -0.24175270f, -0.15401296f, 0.11284396f, -0.23015526f, -0.07351736f, 
    0.11965679f, -0.05065596f, -0.02640721f, -0.08210892f, 0.03376620f, 0.17048898f, -0.09137855f, 0.05091573f, 
    0.06799943f, -0.14869979f, -0.07793356f, 0.05031170f, 0.10653000f, 0.15178938f, 0.01730521f, -0.04881810f, 
    -0.09021132f, -0.14102724f, -0.06588420f, 0.10191557f, 0.11968985f, -0.00023545f, -0.06764826f, -0.08958603f, 
    -0.10536200f, -0.13447900f, -0.18000907f, -0.14974454f, -0.09936564f, -0.02254870f, -0.21362785f, 0.01699072f, 
    -0.08817650f, 0.02952106f, -0.02593443f, -0.25634208f, 0.23210022f, -0.05566277f, 0.29656059f, -0.09959991f, 
    0.02358267f, 0.16774166f, -0.04817329f, 0.11789887f, -0.04485429f, -0.30293202f, 0.05057315f, -0.06055025f, 
    -0.24670967f, -0.19491297f, 0.07745709f, 0.02096458f, 0.24922071f, -0.35257617f, -0.00536498f, -0.15029071f, 
    0.29596797f, 0.30523023f, 0.02753899f, 0.13834423f, 0.22116008f, -0.21753933f, -0.00901392f, -0.22148117f, 
    0.22454995f, 0.13934655f, -0.25359753f, 0.05557799f, -0.09748272f, 0.02336785f, -0.22130255f, 0.02083261f, 
    -0.06989186f, -0.38455975f, -0.07338985f, -0.18729146f, 0.03326348f, -0.28881592f, 0.10344140f, 0.15435231f, 
    -0.13528036f, 0.28505969f, 0.13123080f, 0.10806741f, -0.46825030f, -0.01749368f, -0.29446754f, -0.16673508f, 
    -0.07289424f, 0.24230376f, 0.02583141f, 0.30822590f, 0.13770702f, 0.20140253f, 0.21325965f, -0.28608212f, 
    -0.24381375f, 0.06301593f, -0.09874291f, 0.15137881f, -0.01775864f, 0.02975041f, -0.06188421f, -0.04707683f, 
    -0.09785252f, 0.20670247f, 0.08172640f, 0.00907333f, -0.10478713f, -0.07719055f, -0.16375740f, 0.00724133f, 
    0.08235621f, 0.01376612f, -0.54032099f, 0.07077935f, -0.10678993f, 0.17045882f, 0.16961688f, -0.07337467f, 
    -0.17148452f, -0.29934540f, 0.15739419f, -0.02013814f, -0.11613166f, 0.32332709f, -0.00131621f, 0.01500889f, 
    0.07144139f, -0.07099187f, 0.32675412f, 0.19626527f, 0.05423234f, -0.05316550f, 0.12237212f, 0.14978404f, 
    -0.14928739f, -0.50548422f, -0.16483608f, -0.18996429f, -0.10025036f, -0.26614082f, -0.10216034f, 0.09044012f, 
    -0.06752336f, 0.17646919f, -0.02900711f, -0.03858731f, -0.44400126f, -0.35534713f, -0.00054209f, -0.03459230f, 
    0.18451731f, 0.05439887f, -0.09948213f, 0.39553362f, 0.11237661f, -0.25705737f, 0.30121213f, -0.32359064f, 
    -0.16806845f, -0.12293383f, 0.79742378f, 0.14182536f, 0.10983483f, -0.14210241f, 0.10412375f, 0.01563866f, 
    0.00833848f, -0.05908800f, 0.00098694f, -0.05657688f, -0.17781241f, 0.23654360f, -0.02971788f, -0.08702473f, 
    -0.29320693f, -0.07484978f, -0.26798904f, 0.03880537f, 0.08126768f, -0.02015566f, 0.27563819f, -0.17923929f, 
    -0.26578400f, -0.00379945f, 0.15150569f, -0.00246961f, 0.28868544f, -0.18253441f, -0.10550150f, 0.43625215f, 
    0.18491289f, 0.12099414f, -0.47745332f, 0.51418245f, -0.14316835f, -0.01704318f, 0.02176022f, 0.12864985f, 
    0.10877901f, -0.10810211f, 0.28932029f, 0.10960989f, 0.15707053f, 0.14916217f, -0.12890176f, -0.13434957f, 
    0.48226979f, 0.16477148f, 0.38287544f, 0.04185010f, -0.18715446f, -0.01081352f, -0.05784177f, 0.11134359f, 
    0.23016809f, 0.22622600f, 0.16912471f, 0.15977089f, 0.03702895f, -0.17133979f, 0.16520825f, 0.03756659f, 
    0.02307374f, 0.08679702f, -0.28957728f, -0.17338155f, 0.07749813f, -0.17791852f, -0.49965999f, -0.06736752f, 
    0.05198005f, 0.26911747f, -0.16990191f, 0.02298498f, -0.08171862f, -0.30493778f, -0.09724620f, 0.06452490f, 
    -0.09441552f, 0.08175433f, -0.03985232f, 0.01051214f, 0.07310996f, -0.26168138f, -0.18117647f, 0.10608975f, 
    -0.23614581f, -0.05394742f, 0.05035359f, 0.15410061f, 0.19143651f, 0.39140418f, 0.05260979f, 0.22812018f, 
    -0.21816823f, -0.13003710f, 0.78362834f, 0.06131295f, 0.29659045f, -0.17307420f, 0.00682384f, 0.15616533f, 
    -0.03406408f, -0.14426680f, -0.39412016f, -0.39277878f, -0.02002119f, -0.16698477f, 0.11725420f, 0.12530483f, 
    -0.14927125f, 0.11515778f, -0.15753049f, 0.08782803f, -0.14018178f, -0.14660993f, -0.45095626f, 0.08689578f, 
    0.16778715f, 0.06947119f, 0.24235369f, 0.17973600f, 0.30929762f, -0.30957758f, 0.30167231f, -0.42256576f, 
    -0.19457512f, 0.16690169f, 0.62287360f, 0.29591155f, 0.23464267f, -0.07085163f, -0.13610291f, 0.00788614f, 
    0.05968426f, -0.04089874f, 0.08981035f, 0.06247998f, 0.15187307f, -0.01960959f, 0.05114965f, 0.16007476f, 
    0.19096017f, -0.24395730f, 0.22865106f, -0.05156010f, 0.12120374f, 0.14850020f, 0.12364706f, 0.07598084f, 
    0.03865382f, -0.05615093f, 0.21918173f, -0.10197581f, 0.25454628f, -0.44361547f, -0.03916812f, 0.01682553f, 
    -0.07391909f, 0.15374489f, -0.03242639f, -0.13919570f, 0.07497755f, 0.01335046f, -0.04588587f, -0.07840735f, 
    0.01135644f, -0.35332647f, -0.14314829f, -0.20734479f, 0.03066900f, 0.51497185f, -0.11893503f, -0.00626148f, 
    0.09213895f, 0.31026542f, -0.00823759f, 0.05425546f, -0.04152192f, 0.06751428f, -0.38620436f, 0.11989336f, 
    0.01693485f, 0.26912135f, 0.20869888f, 0.07959678f, 0.06259738f, 0.38364318f, 0.58941674f, -0.00729845f, 
    0.03175072f, -0.17143753f, 0.03495924f, 0.09820209f, 0.24207987f, -0.15077768f, 0.37309626f, -0.01240412f, 
    0.02939843f, 0.17119625f, 0.50763369f, -0.02151263f, -0.07298260f, -0.14126952f, -0.17730913f, 0.06026141f, 
    -0.15166710f, -0.08840834f, 0.28775904f, 0.03433110f, -0.45020187f, -0.02809441f, 0.32571331f, -0.02002784f, 
    0.23391759f, 0.36655182f, -0.12605117f, 0.18902725f, 0.16327026f, -0.61716318f, -0.02435246f, 0.12559450f, 
    -0.23548798f, 0.00895667f, 0.02731719f, 0.23698415f, 0.16685446f, 0.09506100f, -0.19472997f, -0.08805971f, 
    -0.17756251f, 0.08320706f, 0.20307869f, 0.21243867f, -0.16417256f, -0.08306226f, 0.08849648f, 0.15353902f, 
    -0.20793581f, 0.12842315f, -0.33681998f, 0.09655697f, 0.14043280f, 0.19868742f, 0.21569355f, 0.11600320f, 
    0.18481529f, 0.16359529f, 0.19974299f, -0.08135483f, -0.07864746f, -0.26877436f, -0.03793164f, -0.11811883f, 
    0.03519799f, -0.09412141f, 0.14207043f, -0.37448007f, -0.09558595f, -0.11828782f, 0.29254451f, -0.08718809f, 
    -0.07184033f, -0.00750856f, 0.22049068f, -0.22386900f, 0.13709578f, 0.61677533f, 0.02860460f, -0.06891248f, 
    -0.21016614f, -0.05208038f, 0.06085198f, -0.03776398f, 0.11200870f, -0.29909337f, -0.17001317f, 0.03889311f, 
    0.08217742f, 0.27212882f, 0.13702935f, 0.28264683f, 0.16827489f, 0.20432210f, 0.29355013f, -0.07971789f, 
    0.23922555f, 0.03609076f, -0.17897846f, -0.23556589f, -0.02260797f, -0.10330860f, 0.37637353f, 0.13143376f, 
    -0.09584388f, 0.19645108f, 0.37662196f, -0.06353430f, -0.09620699f, -0.20012468f, -0.05207360f, 0.07380034f, 
    -0.41839403f, 0.04517309f, 0.47866827f, -0.16428220f, -0.10800357f, -0.03916664f, 0.12935744f, 0.07867011f, 
    0.22317912f, 0.21926679f, -0.20622884f, -0.02885514f, -0.22831658f, -0.13308282f, -0.10330544f, -0.30987003f, 
    0.11445573f, -0.01151517f, 0.30633456f, -0.07932547f, -0.03407137f, 0.03626898f, 0.11168503f, -0.06109609f, 
    -0.11993206f, -0.26300684f, 0.11163376f, -0.04848639f, 0.17300457f, 0.37945926f, 0.02313953f, -0.12660195f, 
    0.22220263f, -0.04053421f, 0.31923333f, -0.15423191f, 0.25189483f, 0.47192848f, -0.00433545f, 0.16385618f, 
    -0.15634237f, -0.04199935f, -0.12526384f, -0.23847961f, -0.03171390f, 0.20323811f, 0.13063575f, 0.43317258f, 
    -0.21124808f, 0.13628851f, 0.24648002f, -0.14801940f, 0.01454783f, -0.12878188f, 0.21897529f, -0.01564927f, 
    0.03319003f, 0.18143810f, 0.18098666f, 0.14199652f, 0.02749910f, 0.98183948f, -0.02750940f, -0.07508323f, 
    0.13397411f, -0.14255220f, -0.22084348f, 0.07830199f, -0.06202886f, 0.18665691f, 0.31694442f, 0.17082195f, 
    -0.15201433f, -0.23709434f, 0.12204352f, -0.04522379f, 0.04391159f, 0.06696816f, 0.33978292f, 0.23440991f, 
    0.15558258f, 0.04476763f, -0.28764611f, -0.46290809f, -0.24202845f, 0.02928481f, 0.38048893f, -0.00900006f, 
    0.16017370f, -0.08986201f, 0.20701562f, 0.03838603f, 0.04503938f, 0.76188403f, 0.08755952f, 0.09652490f, 
    -0.00487447f, -0.16250335f, 0.51001441f, 0.08352947f, 0.13868731f, 0.19448094f, -0.28277567f, 0.14847197f, 
    -0.11448898f, 0.08935750f, 0.08032994f, 0.03852186f, 0.07311333f, 0.28328246f, 0.25389943f, 0.35904312f, 
    0.19201499f, -0.14094189f, -0.16034441f, 0.49672481f, 0.22791123f, 0.14859480f, -0.40812275f, 0.16123310f, 
    0.05271820f, 0.06560500f, -0.15544082f, 0.25145087f, 0.13724533f, -0.54088551f, -0.11956278f, -0.11658434f, 
    0.42364743f, 0.28180081f, -0.09015601f, 0.08760920f, -0.18243738f, 0.07940587f, 0.05987401f, 0.13393456f, 
    0.15328792f, 0.09880568f, 0.13257593f, 0.24155647f, -0.15453947f, -0.10632814f, -0.04471422f, -0.20262611f, 
    0.22595967f, 0.10076614f, 0.15961698f, -0.28524289f, 0.08418439f, -0.13464457f, 0.00465507f, 0.13099337f, 
    -0.17055231f, -0.02718714f, 0.22591363f, 0.06057185f, 0.02726139f, 0.05831961f, 0.01972426f, 0.04739963f, 
    -0.41397530f, -0.05678833f, 0.55584109f, -0.12228747f, 0.14607795f, -0.10584692f, -0.16871037f, 0.06589994f, 
    -0.12790096f, 0.23040344f, 0.09910941f, 0.02686083f, 0.28147197f, -0.16555588f, -0.01909219f, 0.34415251f, 
    0.13164124f, 0.09261575f, -0.43607181f, 0.49107996f, 0.13531628f, 0.14632343f, -0.12148405f, -0.06817780f, 
    -0.03025923f, 0.04095924f, 0.36705437f, 0.03124567f, 0.05718970f, -0.48681134f, 0.03119727f, 0.17292649f, 
    -0.11357295f, 0.25771052f, -0.00172273f, 0.05376405f, -0.42667431f, 0.02919700f, 0.01789880f, -0.08633765f, 
    0.12674327f, 0.38396063f, 0.26026925f, 0.11951406f, -0.22357453f, -0.26042175f, -0.09800929f, -0.27464959f, 
    0.28531000f, -0.02194342f, -0.15816112f, -0.16131839f, -0.09353007f, 0.09140000f, 0.32454285f, -0.05196300f, 
    0.11776795f, -0.30410007f, -0.26162705f, 0.12562491f, -0.05181555f, -0.07263580f, -0.09387994f, 0.00867966f, 
    0.42023581f, 0.14848177f, 0.23183753f, -0.00729403f, 0.30182862f, 0.27544731f, -0.30011666f, -0.02509824f, 
    0.11229640f, -0.09797897f, -0.02840268f, -0.13555112f, -0.15276648f, 0.27034071f, 0.30276480f, 0.04724333f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15464722f, 0.12310223f, 0.24700074f, -0.05387289f, 0.30260342f, 0.31575361f, 0.38093561f, -0.02749411f, 
    0.25657430f, 0.07094010f, -0.14466076f, -0.11139165f, 0.31382072f, -0.15074739f, 0.03569463f, -0.04507555f, 
    -0.02740725f, -0.23190597f, 0.07255071f, 0.07952659f, 0.35421494f, 0.16670167f, 0.20484316f, 0.14843212f, 
    0.01626603f, -0.18138504f, 0.08841798f, 0.05196597f, 0.29628208f, -0.07486226f, 0.32959053f, -0.14966963f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17251974f, -0.51063651f, -0.52952373f, 0.03517857f, 0.08047786f, 0.08039367f, -0.60964203f, -0.12718490f, 
    -0.34465215f, 0.01622411f, 0.08000979f, 0.15828288f, -0.22339186f, 0.03033002f, 0.19304933f, -0.04016275f, 
    0.05935176f, 0.11816272f, 0.12465625f, -0.12935364f, -0.08372203f, -0.10444813f, -0.38210040f, 0.27932480f, 
    0.07145678f, -0.06605179f, 0.09694128f, 0.16865064f, -0.56351972f, 0.03496445f, -0.22978128f, 0.16948949f, 
    -0.39656532f, -0.06117187f, 0.00709084f, -0.16630748f, 0.39549828f, 0.26115048f, -0.00362811f, -0.01412326f, 
    -0.07838452f, -0.03790621f, -0.08608697f, -0.16595428f, 0.36763328f, 0.07710289f, 0.09027734f, -0.09438891f, 
    0.17390716f, 0.03449985f, -0.03956421f, -0.27944601f, 0.46321708f, 0.19026612f, 0.02882940f, 0.15585412f, 
    0.12486204f, -0.39293760f, 0.10628057f, 0.02383563f, 0.08132061f, -0.26413223f, 0.36300412f, -0.02313823f, 
    -0.05436788f, -0.06544353f, -0.09310094f, 0.06203929f, 0.00055286f, -0.08777436f, -0.11187753f, -0.06316332f, 
    -0.22551665f, -0.02475371f, -0.01754521f, -0.18009502f, -0.18734835f, -0.19871747f, 0.07921907f, 0.02569830f, 
    0.06778091f, -0.18226223f, -0.17647316f, -0.05058147f, 0.06583521f, 0.13020295f, -0.23149663f, -0.18225390f, 
    0.15870281f, -0.03002138f, 0.07356104f, -0.02366738f, 0.10674179f, -0.14964585f, -0.21008319f, -0.00202501f, 
    0.12188405f, -0.04317210f, -0.21354248f, 0.37532508f, -0.04647112f, 0.11757565f, -0.23828506f, -0.41869652f, 
    0.19534689f, -0.10974512f, 0.02419701f, -0.15661889f, 0.16267800f, -0.19935197f, 0.02800908f, 0.11663859f, 
    0.04901375f, -0.01444371f, 0.25963542f, -0.22895233f, 0.47492558f, 0.03760905f, -0.06198603f, 0.43750831f, 
    0.02323007f, 0.09364235f, -0.16049939f, 0.38280800f, -0.23007460f, 0.18257214f, 0.02097840f, 0.02788186f, 
    -0.19042446f, 0.33226755f, -0.10584689f, 0.07194315f, 0.27772343f, 0.33482766f, 0.31916091f, 0.28711250f, 
    0.37490201f, -0.18137541f, 0.08117311f, 0.26308340f, -0.18955813f, 0.08528937f, -0.15628605f, -0.17452343f, 
    0.06339660f, -0.14290620f, 0.05844182f, 0.00613624f, -0.08908002f, 0.28805828f, 0.23048034f, -0.13970797f, 
    0.29980800f, -0.35967883f, -0.32254025f, -0.29716259f, 0.37344390f, 0.08351577f, 0.55607504f, -0.26089868f, 
    -0.11907333f, 0.24719904f, 0.07859827f, -0.43925545f, 0.19889659f, -0.33707726f, 0.23513858f, -0.06015101f, 
    0.16260239f, 0.18030022f, -0.01804211f, -0.14164299f, 0.10666682f, -0.04764581f, -0.07134094f, 0.34904376f, 
    -0.00488690f, 0.05893258f, 0.08803805f, -0.16129526f, 0.04438802f, -0.22217529f, 0.15735196f, 0.25078559f, 
    -0.30325556f, -0.11583155f, 0.19006988f, 0.28591856f, -0.11209533f, 0.00327693f, 0.01865001f, -0.04634809f, 
    -0.31212321f, 0.29181039f, 0.35595140f, -0.28134859f, -0.25151810f, 0.37953904f, -0.00004433f, 0.14859775f, 
    0.11498659f, -0.21474059f, 0.07048397f, -0.18663952f, 0.38814950f, -0.06196634f, 0.21399324f, -0.29411796f, 
    0.38960147f, 0.03574230f, -0.24394546f, -0.11029059f, 0.12333733f, 0.22001070f, -0.04245827f, -0.25868422f, 
    0.25552723f, -0.02606090f, -0.30601436f, 0.11401353f, 0.13287745f, 0.01375804f, 0.22392765f, 0.17712246f, 
    -0.06311753f, -0.23980473f, -0.06824365f, 0.02890136f, 0.09326731f, -0.00510755f, -0.58041340f, 0.09179909f, 
    -0.33133179f, 0.09033415f, -0.15602273f, 0.01714302f, 0.03115401f, 0.13722584f, -0.03261334f, -0.13274866f, 
    0.03085085f, -0.41715479f, 0.12421527f, -0.24218966f, 0.17610009f, 0.12572807f, -0.43055254f, 0.21754335f, 
    0.18553807f, 0.21517631f, -0.05027358f, 0.15735471f, -0.53082967f, 0.06255350f, -0.17427529f, 0.30560130f, 
    0.22567114f, -0.09342837f, 0.16920203f, 0.29605606f, -0.11165076f, -0.42880854f, 0.22899729f, -0.28865194f, 
    0.13009275f, -0.06247853f, -0.15022835f, -0.00499766f, -0.21081781f, -0.58074385f, -0.33208585f, 0.50875068f, 
    0.03244612f, -0.58817005f, 0.18472038f, 0.29085961f, 0.40410739f, -0.11563925f, -0.24355005f, 0.03648651f, 
    -0.49098182f, 0.37329155f, 0.14888290f, 0.09743692f, -0.14826667f, 0.28239617f, -0.21420899f, 0.09157079f, 
    0.11159933f, -0.30868298f, -0.26124591f, -0.26520684f, 0.09148240f, 0.44198844f, -0.24338710f, 0.19740416f, 
    -0.12360206f, -0.19781984f, -0.09298910f, 0.17234628f, 0.34202349f, -0.05878431f, 0.31266043f, -0.37821361f, 
    0.25910428f, 0.11882691f, 0.29927018f, 0.12641509f, 0.06416690f, 0.30159760f, -0.10982518f, 0.21212932f, 
    0.13167922f, -0.35140660f, -0.32840344f, -0.09156813f, 0.08447210f, 0.08877269f, 0.24329993f, -0.13819288f, 
    -0.05520750f, 0.10422014f, 0.08837190f, 0.07292073f, -0.02401952f, -0.03012064f, -0.27408269f, -0.65520620f, 
    -0.16577415f, -0.00027866f, -0.11225754f, 0.12149166f, 0.17707925f, 0.08788691f, -0.02524560f, -0.57976609f, 
    -0.00269648f, 0.10851599f, 0.08753954f, 0.01312970f, 0.40240344f, -0.12504150f, -0.06867398f, 0.32107624f, 
    0.09204902f, 0.18719408f, 0.11572263f, 0.48020110f, 0.00943621f, 0.24943143f, 0.17988020f, 0.36428854f, 
    -0.09950063f, -0.14755857f, 0.12310091f, -0.06089084f, -0.06860773f, 0.04287494f, -0.14087632f, -0.01452956f, 
    -0.02096684f, 0.03823147f, -0.06524684f, -0.12294094f, -0.01972338f, 0.08722074f, -0.07851943f, -0.08804744f, 
    -0.09229780f, -0.01891929f, 0.15984824f, -0.00742963f, -0.00478331f, -0.10529599f, 0.04966456f, -0.13435233f, 
    0.00015916f, -0.14169180f, -0.18666548f, 0.02708356f, -0.14618868f, -0.03151840f, -0.00672455f, -0.00705524f, 
    0.42253080f, -0.00762978f, -0.16195226f, 0.03807507f, 0.37376133f, -0.27045542f, 0.15669371f, 0.04977799f, 
    0.03404972f, -0.02586007f, 0.00234463f, -0.07034919f, -0.18196250f, -0.40972361f, -0.08781049f, 0.52101433f, 
    0.11765555f, -0.16595352f, 0.05437885f, 0.33788836f, 0.13372332f, 0.29160011f, -0.18567565f, 0.09704120f, 
    -0.01930166f, 0.12339762f, 0.13693090f, 0.35099044f, -0.08435445f, 0.32935116f, -0.23322783f, -0.03333417f, 
    0.12037523f, 0.22891732f, 0.28606811f, -0.16328746f, -0.27962136f, -0.34050256f, -0.00495549f, -0.07004581f, 
    0.16750582f, -0.40640846f, 0.10573859f, 0.08328695f, -0.08848665f, -0.39365873f, -0.57028073f, 0.04193056f, 
    0.25323921f, -0.25179714f, -0.35220391f, 0.05419143f, 0.04653502f, 0.01943533f, -0.15752663f, 0.35041186f, 
    0.36363643f, 0.37985519f, -0.22192241f, 0.63014156f, -0.22298154f, 0.35079566f, 0.06433284f, 0.25382540f, 
    0.02362665f, 0.37803757f, 0.25497246f, -0.04032892f, -0.02839459f, -0.10776415f, -0.05715512f, 0.40309507f, 
    0.16492189f, 0.12788226f, 0.15388925f, -0.59157127f, 0.17769906f, -0.14873171f, -0.31936088f, -0.15457471f, 
    0.37618735f, -0.30405024f, -0.50006455f, -0.05478999f, 0.07885733f, 0.08202878f, -0.04309396f, -0.12560149f, 
    -0.13772658f, 0.44651935f, 0.33793205f, 0.44156110f, 0.17390420f, -0.24762107f, 0.03653927f, 0.24173599f, 
    0.25299361f, 0.06898692f, -0.12947316f, -0.04186208f, 0.35516155f, -0.34090963f, 0.27871889f, 0.37359720f, 
    0.06992189f, 0.13858838f, 0.15387008f, 0.05132239f, -0.03728148f, 0.06989426f, 0.34988502f, 0.61851853f, 
    -0.11773183f, 0.15987346f, 0.15290095f, -0.06216197f, 0.18857293f, 0.02509376f, -0.05253337f, 0.18733880f, 
    0.02353432f, 0.00237954f, 0.22818710f, 0.02980469f, -0.08996789f, -0.02013030f, -0.07135363f, -0.20017590f, 
    0.13056327f, -0.22911112f, -0.17623046f, 0.01757246f, 0.10814109f, -0.04802437f, -0.16648901f, -0.07163613f, 
    -0.00980688f, -0.06716131f, 0.02459531f, 0.43779561f, -0.21996874f, 0.04647446f, 0.02403757f, -0.41120842f, 
    0.06546186f, 0.02183905f, 0.02544374f, -0.24255767f, 0.07687424f, 0.22376877f, -0.21365669f, 0.54211807f, 
    0.46777889f, -0.36220846f, -0.19777374f, 0.41260538f, -0.09599832f, 0.08650064f, -0.10694788f, 0.05463981f, 
    -0.07705966f, -0.17217150f, -0.17613955f, 0.00455203f, -0.29945660f, 0.24176235f, -0.24124582f, 0.41881984f, 
    -0.00420483f, -0.07602811f, -0.09359804f, 0.37661660f, 0.20990694f, 0.16601481f, 0.02483171f, -0.10588159f, 
    -0.41287777f, 0.30976096f, -0.02963021f, -0.25517875f, -0.38672274f, 0.03277989f, -0.05919864f, 0.05765529f, 
    0.18809655f, -0.23209369f, -0.19007359f, 0.07303461f, 0.24857470f, -0.24548911f, 0.12211286f, 0.12838833f, 
    0.02654210f, -0.17742594f, -0.33044720f, -0.15302610f, 0.27953961f, 0.02852935f, -0.16659832f, -0.03963489f, 
    0.28687155f, -0.11251646f, 0.01481955f, 0.12849662f, 0.09217299f, 0.05925655f, -0.01314415f, -0.08971669f, 
    0.11350549f, -0.03424938f, 0.22560386f, 0.07184131f, 0.20679775f, 0.01066402f, -0.15169658f, 0.14317946f, 
    -0.04063717f, -0.36309591f, 0.27543810f, 0.18135272f, -0.47306058f, 0.00061504f, -0.21501145f, -0.37545598f, 
    0.16535702f, 0.36993778f, 0.22998035f, -0.18725432f, -0.26481780f, -0.06548854f, 0.38776681f, 0.41126004f, 
    0.42473248f, -0.10349692f, 0.02903549f, 0.00935516f, 0.07277542f, -0.10356268f, -0.29916531f, 0.08823158f, 
    0.07243178f, -0.01879081f, 0.03424009f, 0.41435614f, -0.29358670f, 0.12346635f, -0.01615958f, 0.02893929f, 
    -0.01723599f, 0.24737711f, -0.17250523f, -0.03951200f, 0.19850470f, 0.52280897f, 0.14254901f, -0.24537136f, 
    -0.24611360f, 0.16462451f, -0.05378442f, -0.15290874f, -0.33539829f, 0.39947131f, 0.09664159f, 0.50771689f, 
    -0.02295483f, 0.32631564f, 0.10394516f, -0.04242995f, 0.21945341f, 0.18864505f, 0.21569952f, -0.03806590f, 
    -0.11016677f, 0.18858679f, -0.09160636f, -0.16394134f, -0.44491062f, -0.25234103f, -0.20947839f, -0.43317223f, 
    -0.19210291f, -0.02897967f, 0.11802854f, 0.12836847f, 0.06811344f, -0.05343515f, -0.14994338f, -0.14667572f, 
    -0.26006243f, -0.00069572f, 0.24005853f, 0.35923541f, 0.00002149f, 0.43397239f, 0.27140629f, 0.14236967f, 
    0.15400194f, 0.18097945f, 0.08821338f, 0.07038201f, 0.00462358f, -0.05548585f, 0.02945447f, 0.11853787f, 
    0.25463974f, -0.33487719f, 0.40164909f, 0.20926303f, -0.14825723f, 0.16827516f, 0.23469105f, -0.29311004f, 
    0.02777404f, -0.33658364f, -0.39736623f, -0.52997369f, 0.27848557f, -0.23027682f, 0.28830588f, -0.25587934f, 
    0.04503500f, -0.16115487f, 0.00228516f, -0.14044961f, 0.10877127f, 0.04957458f, -0.13784561f, 0.16485053f, 
    -0.08671920f, 0.08069661f, -0.11883070f, 0.04514404f, -0.06801855f, -0.05907574f, -0.15629195f, -0.07838213f, 
    -0.01468048f, -0.04218157f, 0.12758099f, 0.17186855f, -0.05391370f, 0.08813319f, -0.11281104f, 0.06788698f, 
    -0.14191371f, 0.04117038f, -0.12469716f, -0.13914365f, 0.08012292f, -0.14809085f, -0.13260110f, -0.19272381f, 
    -0.66582423f, 0.08017154f, 0.33797291f, 0.08671471f, -0.04822471f, 0.45145780f, 0.30223262f, -0.70064580f, 
    -0.06552334f, 0.14438458f, -0.13018444f, -0.22864416f, 0.18040571f, -0.19955423f, 0.14897428f, 0.20484099f, 
    -0.03272493f, 0.01116698f, 0.36005938f, 0.04838603f, 0.25458568f, -0.20413613f, -0.03183834f, 0.01029408f, 
    -0.17935602f, -0.17968248f, -0.41552559f, -0.15169327f, 0.28230244f, -0.13123558f, 0.13771957f, 0.30007330f, 
    -0.48005816f, 0.24171312f, 0.33468077f, -0.47703537f, 0.09513426f, 0.59132236f, 0.24986747f, 0.12275458f, 
    0.23343693f, -0.06765354f, 0.07392192f, -0.45379910f, 0.49182585f, 0.01891599f, 0.46270248f, -0.45195192f, 
    0.22331691f, -0.07730765f, 0.21689893f, -0.17004175f, 0.42840493f, -0.18649285f, -0.24696262f, -0.01946261f, 
    -0.30807069f, -0.19837980f, 0.06930953f, -0.12582579f, 0.26219109f, -0.12000968f, 0.17879909f, -0.13632450f, 
    0.27494866f, 0.18974376f, -0.05693896f, -0.31405568f, 0.17856540f, -0.25135806f, 0.21260527f, 0.58646613f, 
    0.10960365f, 0.43440628f, -0.02898876f, -0.13275447f, -0.28683227f, -0.03385097f, -0.34336552f, 0.43464053f, 
    -0.17008403f, -0.13087572f, -0.09956923f, 0.04172061f, -0.18728526f, 0.25828773f, -0.01350464f, 0.22022615f, 
    0.25626779f, -0.02574918f, 0.06946576f, 0.22817023f, -0.36509356f, 0.39938417f, 0.05612924f, -0.42767885f, 
    0.01035218f, -0.09672158f, -0.10741437f, 0.33983934f, 0.33115682f, -0.12649894f, 0.53827316f, 0.27098724f, 
    0.25716189f, 0.32688135f, -0.07991683f, -0.05972642f, -0.17265414f, 0.11781403f, -0.26997668f, 0.59884077f, 
    0.15118109f, -0.26494932f, 0.02347810f, 0.24866168f, 0.17113788f, 0.06631002f, 0.12699430f, 0.06105426f, 
    -0.22542341f, -0.27154437f, 0.36098748f, -0.36078024f, 0.01602738f, -0.13368611f, 0.15087107f, -0.36742684f, 
    0.14542297f, 0.10891082f, -0.11612996f, 0.08894388f, 0.32206023f, -0.18138680f, 0.08975894f, 0.34222054f, 
    -0.23759115f, -0.01814799f, -0.10407371f, 0.08295338f, -0.04867127f, 0.09956288f, -0.35328257f, 0.02306147f, 
    -0.06870399f, -0.04834124f, -0.36146176f, -0.34111825f, -0.05158631f, -0.22863418f, -0.04387826f, 0.03287062f, 
    0.16633496f, 0.01603761f, -0.10411539f, 0.07576104f, 0.18667693f, -0.50764817f, -0.09421711f, 0.15913904f, 
    0.12091561f, 0.13611989f, -0.03553155f, 0.26054183f, 0.27301347f, -0.17125553f, 0.00071589f, -0.25550258f, 
    -0.07975797f, 0.36214811f, -0.18634121f, -0.22542083f, -0.19606714f, -0.24899498f, 0.10127218f, 0.39519545f, 
    0.14101632f, -0.29993895f, 0.40560189f, 0.17190430f, 0.30761212f, 0.11814222f, 0.17060530f, 0.12017809f, 
    -0.49437097f, 0.24749087f, 0.24603945f, -0.14320070f, -0.09383035f, -0.37228966f, -0.12046664f, 0.25056458f, 
    0.06491300f, -0.22227660f, -0.25798497f, -0.06749384f, 0.31092760f, 0.26147720f, -0.07364940f, 0.09567713f, 
    -0.09082995f, -0.07495735f, -0.14495406f, 0.52037787f, 0.09833544f, -0.09205201f, 0.62108749f, 0.06772106f, 
    0.09235595f, -0.28887504f, 0.29125139f, 0.22079344f, 0.00882381f, 0.41413406f, -0.06817577f, 0.32379118f, 
    0.43485081f, -0.27962804f, -0.31680697f, -0.24049301f, -0.09019198f, 0.31062785f, 0.31656578f, -0.29854494f, 
    -0.25660214f, -0.24405338f, 0.12104230f, 0.15733425f, 0.12912023f, 0.20550419f, -0.15342501f, -0.73249984f, 
    -0.26664236f, 0.14764154f, -0.05376606f, -0.26810050f, 0.50426632f, -0.12899867f, 0.30571896f, 0.08172080f, 
    -0.05820871f, 0.27892217f, 0.15076987f, -0.43280295f, 0.34307510f, -0.01592649f, -0.45513076f, 0.09918273f, 
    0.08507526f, 0.24356349f, -0.37227258f, 0.24117255f, 0.03179776f, 0.17870925f, 0.05564675f, 0.33366820f, 
    -0.15112665f, -0.11078955f, -0.00601808f, -0.03418281f, -0.15938091f, 0.09110162f, 0.04719387f, -0.34868681f, 
    0.06143488f, -0.07344536f, 0.11593001f, 0.22950068f, 0.48254859f, -0.09669394f, 0.51951796f, 0.25709462f, 
    0.03186943f, 0.60950154f, 0.47594497f, 0.17645843f, 0.24878368f, 0.14410253f, 0.01718447f, 0.21170390f, 
    -0.20030788f, -0.41061911f, -0.38168797f, -0.19085535f, 0.04713367f, 0.30412498f, -0.11794741f, -0.11852399f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26794699f, 0.36547399f, -0.10255618f, 0.18091561f, 0.09130955f, 0.17567866f, 0.23305486f, -0.25449032f, 
    -0.06165412f, 0.14251202f, 0.12899317f, -0.09421717f, -0.03962222f, -0.02382973f, 0.01550420f, 0.09832983f, 
    -0.17547432f, -0.25941384f, 0.14524254f, -0.05393508f, 0.15327011f, 0.18697259f, -0.08713181f, 0.12524968f, 
    0.12152963f, -0.06104003f, 0.22164398f, 0.08109213f, 0.10698272f, 0.13051181f, 0.23002756f, 0.30088401f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.72609282f, -0.01141424f, -0.05174121f, 0.25655237f, -0.61512458f, -0.17819001f, -0.36481878f, 0.43505019f, 
    0.12335901f, -0.11814779f, -0.04654645f, -0.05277773f, 0.20957424f, 0.11401070f, -0.02233985f, 0.14638047f, 
    0.00577538f, 0.04351368f, -0.10091689f, -0.39574996f, -0.16228752f, -0.29773146f, -0.02680891f, -0.20936638f, 
    -0.41381526f, 0.04077009f, -0.05511943f, -0.16132319f, 0.04231336f, 0.12891266f, 0.28921321f, 0.05368648f, 
    -0.84068722f, -0.23840705f, -0.06326015f, 0.07378780f, -0.19966576f, 0.26221022f, -0.57239175f, -0.88917118f, 
    0.31256598f, -0.21387891f, -0.10618736f, 0.00881250f, 0.35287127f, 0.03218279f, 0.07275330f, 0.20937458f, 
    0.02811999f, 0.01986947f, 0.51413286f, -0.02256534f, 0.15572955f, -0.46142513f, 0.01914611f, -0.73981404f, 
    -0.36765605f, 0.26437318f, 0.21135610f, -0.03644437f, 0.15922254f, -0.04602515f, -0.49337789f, -0.06912839f, 
    -0.14440829f, 0.16868274f, -0.03202324f, -0.73803747f, 0.06027327f, -0.08466943f, 0.12335224f, -0.24515121f, 
    -0.41487193f, 0.14615740f, -0.30050045f, 0.03232111f, -0.19105011f, -0.88993466f, -0.39715594f, 0.06292749f, 
    -0.56040740f, 0.03585373f, -0.60791934f, -0.04023005f, 0.18112305f, 0.35445201f, 0.11756250f, 0.24608652f, 
    0.29406393f, -0.38430715f, 0.13279198f, 0.23500979f, 0.07059260f, 0.23394655f, -0.19725752f, 0.29248169f, 
    -0.23132277f, 0.22581279f, -0.11580829f, 0.23614505f, 0.00940409f, -0.12891452f, -0.17161267f, -0.15840587f, 
    -0.14805959f, 0.21574582f, 0.25315574f, -0.09941712f, -0.19209987f, -0.24197392f, -0.56995875f, -0.08529411f, 
    0.04109664f, -0.20535862f, -0.02770127f, -0.35003161f, -0.79449230f, -0.08775666f, -0.13195612f, 0.22868530f, 
    -0.07920929f, -0.48700985f, -0.14682005f, -1.19421220f, 0.00880535f, 0.19501676f, 0.33935612f, 0.19966696f, 
    -0.72035396f, -0.05760955f, 0.11646292f, 0.13911206f, -0.21282405f, -0.24567986f, 0.22601292f, -0.08512722f, 
    -0.25647327f, 0.23709691f, 0.11447922f, -0.06140784f, 0.13178235f, 0.06604160f, 0.24305062f, 0.05437364f, 
    0.05729583f, -0.28551272f, 0.06941722f, -0.01390109f, -0.21700758f, -0.79114574f, -0.09694893f, -0.56116855f, 
    0.02908665f, -0.05009983f, -0.92179114f, -0.06863901f, -0.16412807f, 0.15363967f, 0.21918172f, -0.03871526f, 
    -0.10594276f, 0.21270226f, 0.10718611f, 0.19617516f, 0.20163645f, -0.16546486f, -0.23161082f, -0.24530703f, 
    -0.17092296f, 0.13959518f, 0.07542160f, -0.04193748f, 0.06774494f, -0.12388875f, 0.03405539f, 0.11539285f, 
    0.05748203f, -0.33537629f, 0.10755361f, -0.09959144f, -1.08047593f, -0.06709362f, -0.01194297f, -0.59634560f, 
    -0.19621778f, -0.01448397f, 0.22723721f, 0.02429361f, 0.21625426f, 0.18418850f, -0.45181951f, -0.10896998f, 
    0.00431038f, 0.17121372f, -0.08606941f, -1.25761819f, 0.27058923f, -0.26790667f, 0.33570495f, -0.05813601f, 
    -0.14628144f, -0.79399681f, -0.24527623f, -0.08471333f, -0.98100370f, -0.18832231f, 0.21842775f, -0.45503449f, 
    -0.34318191f, 0.30341855f, -0.11435045f, -0.05685415f, -0.21069193f, 0.41532654f, -0.17084996f, 0.25250497f, 
    0.43679208f, -0.74576205f, 0.08382960f, 0.04170434f, 0.18032318f, -0.98552918f, -0.40495107f, -0.85340476f, 
    -0.32611731f, -0.72583294f, 0.04866637f, 0.34483066f, -0.38270131f, -0.04941190f, 0.11711324f, -0.04172477f, 
    0.47185457f, -0.54013950f, 0.13735984f, -0.12581737f, 0.28689185f, 0.42455560f, 0.25976139f, -0.28926781f, 
    -0.87817758f, -0.17635319f, -0.11670458f, 0.12459851f, -0.01356569f, -0.21689551f, 0.00750327f, 0.11273909f, 
    -0.25660124f, -0.39379892f, -0.40514976f, -0.23260023f, 0.27398640f, -0.69533288f, 0.00833282f, -0.94578749f, 
    -0.37065288f, -1.28850782f, 0.12682790f, -0.13315585f, 0.15105405f, -0.27926910f, -0.60068059f, -0.06720433f, 
    0.33050773f, -0.33891448f, -0.69570148f, -0.11978092f, 0.29635081f, -0.38219193f, -0.48047343f, 0.22501245f, 
    -0.32497916f, 0.06662045f, -0.79808623f, 0.24401227f, 0.25460300f, 0.38913855f, 0.15891007f, -0.01567825f, 
    -0.37213841f, 0.22012483f, 0.33087242f, -0.00305226f, 0.16204466f, 0.05695476f, -0.54910117f, 0.04775072f, 
    -0.11985681f, 0.19679584f, -0.02213569f, 0.07783793f, 0.02962376f, 0.28504539f, 0.14257826f, -0.24327455f, 
    0.01143369f, -0.35150227f, 0.27649641f, -0.16406351f, -0.51545048f, 0.06746624f, -0.08516239f, -0.19904825f, 
    -0.66666287f, -0.62464952f, -0.25858641f, 0.14571700f, -1.48889661f, -0.15154105f, -0.12207720f, 0.33806542f, 
    0.29730356f, -0.30225250f, -0.03992042f, 0.01895934f, 0.02772007f, -0.37557176f, 0.17890978f, 0.19434069f, 
    -0.13152772f, -0.41573086f, 0.13819246f, -0.44554463f, 0.41098186f, -0.68549120f, 0.22904561f, -0.43160564f, 
    -0.41222069f, -0.00583665f, 0.00248291f, -0.02524030f, 0.02924878f, 0.38807836f, -0.43130901f, -0.38190055f, 
    0.24609157f, -0.27176154f, -0.25768140f, 0.26612434f, -0.61387032f, 0.04188424f, 0.01651487f, -0.28589672f, 
    -0.68424183f, 0.22773816f, -0.17960334f, -0.83294827f, -0.87519920f, 0.29693013f, -0.46058267f, -0.07009661f, 
    -0.08914211f, -0.11030240f, -0.05122806f, -0.51432765f, 0.28531969f, 0.18171029f, 0.23791343f, -0.15757230f, 
    -0.22868675f, -0.43401572f, -0.54429299f, -0.07957033f, -0.22346087f, 0.10982657f, 0.20167981f, 0.03940354f, 
    -0.49825674f, -0.12221655f, -0.39148226f, 0.26946899f, -0.63049155f, 0.01215999f, -0.05196044f, -0.38636717f, 
    0.05656216f, 0.33242491f, 0.19671115f, 0.03867522f, -0.24209763f, -0.27349311f, -0.28053790f, -0.13582523f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08963472f, 0.02559036f, 0.00489298f, -0.02682310f, 0.07673368f, -0.06315579f, 0.05410201f, -0.09974690f, 
    0.05693154f, 0.24848512f, 0.02955848f, -0.15202144f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
