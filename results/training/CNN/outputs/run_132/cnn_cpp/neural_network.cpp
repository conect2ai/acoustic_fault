#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.01332283f, -1.00704789f, -1.16998219f, 0.09494694f, 0.06619232f, 0.56162363f, -0.28035799f, -0.25514942f, 
    -0.04424209f, 0.10746426f, -0.13414811f, 0.21265292f, 0.38509825f, 0.18968733f, 0.07796041f, -0.07720254f, 
    0.12373952f, 0.20305423f, -0.31935471f, -0.07075159f, -0.05511599f, -0.12468042f, -0.49146637f, -0.35750467f, 
    -0.42030251f, 1.28450680f, 0.22897871f, 0.73648030f, 0.84196037f, 0.82737595f, 0.02954149f, 0.12989749f, 
    -0.29579371f, -0.72121727f, 0.02813553f, 0.31990463f, 0.38123289f, -0.24805781f, 0.29344237f, 0.08982970f, 
    -0.26743454f, -0.06185999f, 0.15736814f, 0.11973612f, -0.08175439f, -0.11212736f, 0.08545412f, 0.11436202f, 
    -0.01942629f, 0.09014948f, -0.66018349f, -0.37093589f, -0.30565241f, -0.33418056f, -0.69291651f, 0.39080423f, 
    1.21547747f, -0.17109661f, -0.31304422f, 0.38516021f, -0.33415556f, 0.04640859f, -0.04490018f, -0.26974002f, 
    -0.09093890f, -0.12609240f, 0.04733938f, -0.02833242f, 0.03052119f, -0.15501729f, 0.01896930f, -0.09019069f, 
    0.20504922f, -0.03493303f, 0.13903704f, -0.77944642f, 0.46337026f, 0.76371109f, -0.06861740f, 0.39297646f, 
    0.01552095f, 0.36937824f, 0.33014706f, -0.39792427f, -0.25148776f, 0.31215551f, 0.31011438f, 0.43491465f, 
    0.27781945f, 0.36282432f, -0.30652103f, -0.23966482f, 0.14992422f, 0.38843128f, 0.72708338f, 0.02615791f, 
    -0.00275481f, 0.10620110f, 0.45268714f, 0.42595232f, -0.76356512f, -0.33838880f, -0.02694645f, -0.31858435f, 
    -0.35430464f, -0.99244320f, 0.05934881f, -0.57683599f, -0.81952012f, -0.23322128f, -0.31616712f, 0.55024892f, 
    0.34455755f, 0.46589288f, -0.05522874f, 0.03782443f, -0.44419631f, 0.21366681f, 0.15551060f, 0.12286542f, 
    0.19418494f, 0.29672980f, -0.34131321f, 0.17672953f, 0.42567611f, 0.53738421f, -1.00607860f, -0.88296974f, 
    0.17331237f, 0.49780065f, 0.60585511f, 0.87707192f, 0.75787890f, 0.60741198f, 0.51519358f, -0.12281120f, 
    0.07228297f, -0.35623139f, 0.27324256f, -0.26505485f, -0.23393092f, -0.29010999f, 0.10892743f, 0.30187401f, 
    -0.00174839f, -0.07088693f, -0.16838086f, -0.25658816f, 0.09086353f, -0.00797881f, -0.40058681f, -1.10691333f, 
    -0.22241156f, 0.67232054f, -0.39414835f, -1.27605629f, 0.23151231f, 0.16289073f, -0.31381246f, 0.14987259f, 
    0.60908276f, 0.72012419f, -0.43753207f, -0.03539224f, -0.17595652f, 0.19942775f, 0.13383189f, -0.14685747f, 
    0.38694191f, -0.08750643f, 0.22512867f, -0.20141700f, 0.12791441f, 0.11978141f, -0.11012410f, -0.29918972f, 
    0.15847282f, -0.69907945f, -1.02130401f, -0.73363090f, 0.48487422f, 0.39481077f, 0.26646090f, 0.40264329f, 
    0.68300730f, 0.05266743f, -0.53427613f, -0.30198541f, -0.16196492f, 0.04631760f, -0.02843646f, 0.15104987f, 
    -0.18992214f, 0.16354601f, -0.31656444f, -0.34855139f, -0.31735995f, -0.23063608f, -0.25262156f, 0.16051953f, 
    -0.37796953f, -0.87708884f, 1.08806276f, 0.59254950f, -0.77687198f, 0.15030971f, -0.29981998f, 0.71237808f, 
    -0.00720517f, -0.52504975f, 0.03656884f, -0.37479466f, 0.09456091f, 0.59969693f, -0.15161631f, 0.05183657f, 
    0.28253335f, 0.07241637f, -0.30262613f, -0.20407678f, -0.08523758f, 0.03160927f, 0.24453354f, -0.07082322f, 
    -0.09947149f, -0.06843103f, 0.69855982f, 0.79882973f, -0.32639045f, 0.36275247f, -1.21145809f, -0.68113422f, 
    -0.40899888f, -0.48996705f, -0.89291608f, 0.46868783f, 0.33156690f, -0.20046470f, -0.04629251f, 0.21494670f, 
    -0.11061211f, 0.17637151f, -0.31702703f, -0.21709055f, 0.03981656f, 0.16446126f, 0.11624587f, 0.07879411f, 
    0.38214466f, 0.08228131f, 0.26420194f, -0.30018431f, -0.57462543f, -0.86857933f, 0.20104003f, -0.04169800f, 
    0.48055682f, -0.57072234f, 0.18252242f, -0.51847512f, 0.16666973f, -0.30361199f, -0.57981026f, -0.42498440f, 
    -0.25230587f, 0.50790405f, -0.30612051f, -0.16013446f, -0.35973132f, -0.11287265f, 0.38975129f, 0.27799511f, 
    0.09229896f, 0.14026265f, -0.08133111f, 1.09175384f, 0.69221491f, 0.81067157f, -0.17135426f, 0.09508540f, 
    -0.23425718f, -0.01176465f, -0.50157702f, 0.21521871f, -0.17450157f, -0.32145590f, -0.06336233f, 0.24004832f, 
    0.20502634f, 0.34083813f, 0.21354154f, 0.19318162f, -0.12831613f, 0.13522562f, 0.47143170f, -0.09346761f, 
    0.04271110f, -0.00484797f, -0.46358815f, 0.17026307f, 0.98987681f, 0.98980433f, 0.96331716f, -0.32219180f, 
    -0.35273200f, -0.74998850f, 0.85527587f, -0.41993454f, -0.31151935f, 0.66134417f, 0.15547140f, 0.17605843f, 
    -0.11036903f, -0.01288402f, -0.07040931f, 0.03899865f, -0.29304734f, 0.14658879f, 0.17416635f, -0.24339099f, 
    -0.01356709f, 0.18017045f, 0.02030917f, 0.11731247f, 0.38161793f, -0.45837668f, 0.14089729f, 0.86039156f, 
    0.77080339f, 0.05665657f, 0.39405155f, 0.84407729f, -0.25559881f, 0.33021542f, 0.22707586f, -0.44675046f, 
    -0.26066318f, -0.47081649f, -0.01924586f, -0.18699019f, -0.24947192f, -0.24980897f, -0.56119215f, -0.38849050f, 
    -0.50964016f, 0.14552073f, -0.01009449f, -0.35853523f, 0.16989884f, -0.42214039f, -0.00264044f, -0.75837260f, 
    -0.53686452f, -0.70916933f, -0.46375206f, 0.38586250f, 0.09692769f, -0.50051200f, 0.14157167f, 0.36429265f, 
    0.93296188f, 0.24964064f, -0.10201680f, 0.08371563f, -0.29553482f, 0.28063574f, 0.04955361f, 0.01854283f, 
    -0.29084584f, 0.12835963f, -0.00178161f, 0.10524721f, 0.05603099f, 0.23539643f, 0.05077600f, 1.10893011f, 
    0.70918483f, 0.09459666f, 1.44084990f, 0.50341296f, 0.02907507f, 0.55677503f, 0.60129023f, 0.19706737f, 
    -0.05983984f, -0.43388760f, -0.07612111f, 0.09822227f, -0.28646398f, -0.07905610f, 0.03624452f, 0.04488124f, 
    0.04458088f, -0.03409069f, -0.02559423f, 0.01598511f, -0.28148732f, -0.19174932f, 0.19779977f, 0.00548080f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29515746f, -0.02438028f, -0.04472395f, 0.17686267f, 0.14855418f, -0.07733819f, 0.39314049f, 0.03170622f, 
    0.03946961f, 0.35108060f, 0.29114553f, 0.06992185f, 0.25990522f, -0.00269679f, 0.26033184f, 0.20064712f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04472198f, -0.02976219f, 0.01155696f, 0.03176522f, -0.04823919f, -0.05324633f, -0.04468968f, 0.02166553f, 
    -0.00796747f, -0.06005307f, 0.02287557f, -0.04675451f, 0.01233409f, -0.04727283f, -0.06172222f, -0.06799271f, 
    -0.05342126f, -0.05492563f, -0.04394463f, 0.00544282f, -0.04289974f, -0.06098296f, -0.06824629f, -0.04712880f, 
    -0.03073558f, -0.06790993f, 0.00434979f, 0.05113620f, -0.06061275f, 0.05644887f, -0.00194998f, -0.02133335f, 
    -0.01873789f, -0.01151629f, 0.03634874f, -0.08022239f, 0.04282891f, -0.01137582f, -0.05201608f, 0.04664521f, 
    0.04815268f, -0.02859781f, 0.01573734f, -0.06291383f, 0.04119525f, -0.04112008f, -0.01194660f, -0.06606841f, 
    -0.05963743f, -0.01334849f, -0.03372607f, 0.03439562f, -0.05534922f, 0.01190084f, 0.00592578f, 0.04249163f, 
    -0.01431725f, -0.02996908f, -0.06051076f, 0.01611608f, 0.04543033f, 0.01287240f, 0.04729298f, -0.03991956f, 
    -0.06964327f, 0.04265656f, 0.01278010f, 0.01038851f, 0.02459629f, 0.01761859f, 0.01954591f, -0.02981605f, 
    -0.05957194f, 0.05833640f, -0.00607725f, 0.04049868f, -0.01734979f, -0.01043283f, -0.08035045f, -0.00204250f, 
    -0.01899429f, 0.04707869f, 0.01137805f, -0.05189119f, -0.07296204f, 0.00763525f, -0.07219221f, -0.00014237f, 
    -0.04820731f, -0.04980500f, -0.01962588f, 0.03654239f, 0.05617245f, 0.01143208f, 0.02123190f, -0.03416655f, 
    -0.07785492f, -0.03428577f, -0.03736824f, -0.05647115f, -0.02403015f, -0.04802672f, 0.01089424f, 0.00911030f, 
    -0.01473067f, -0.05578316f, 0.00232512f, -0.07237151f, -0.05411214f, -0.06568076f, 0.05415015f, -0.05590540f, 
    0.02615204f, -0.01092739f, -0.01452787f, -0.02115794f, 0.01093316f, 0.01002920f, -0.07191315f, -0.04589725f, 
    -0.04706614f, 0.04395486f, 0.02517017f, -0.00491037f, 0.00788891f, -0.01287776f, -0.00417875f, -0.06141425f, 
    -0.03918847f, -0.04140175f, 0.02708790f, 0.04997920f, -0.00447928f, 0.02511412f, -0.07200340f, -0.04459817f, 
    0.06986199f, 0.05796224f, 0.00481849f, -0.02450292f, -0.07366995f, 0.04572580f, -0.05196678f, 0.02665843f, 
    -0.02512062f, -0.07530875f, -0.06319671f, 0.05603460f, -0.02486789f, 0.03349124f, 0.02011528f, -0.01162174f, 
    -0.01978718f, 0.01028024f, -0.00826839f, 0.04401335f, 0.05542548f, -0.06928871f, -0.00929470f, 0.02672789f, 
    -0.06516053f, -0.04519900f, -0.07773118f, -0.02888174f, -0.07692641f, -0.06102133f, -0.02333413f, -0.04741547f, 
    0.06288200f, -0.04702915f, 0.02141597f, 0.03993288f, -0.03704990f, -0.06647435f, 0.05306867f, -0.04642468f, 
    -0.00877720f, -0.04822965f, -0.01880442f, -0.03001095f, -0.01570476f, 0.05437075f, 0.06296329f, -0.07071077f, 
    -0.03499487f, 0.00621983f, -0.07939732f, 0.01969297f, -0.00457917f, -0.05071700f, -0.04401392f, 0.01097080f, 
    -0.08871368f, 0.00605983f, -0.05604019f, -0.02926053f, -0.02471409f, -0.03338021f, -0.03709009f, -0.02419966f, 
    0.03892190f, -0.06829936f, 0.00285104f, 0.04688832f, -0.00823398f, 0.01946007f, -0.08303162f, -0.04764042f, 
    -0.00320417f, -0.03404965f, -0.00253185f, -0.06053061f, -0.03344281f, -0.05169628f, 0.00331548f, 0.00813805f, 
    -0.08163788f, 0.00731887f, 0.02264510f, -0.05848914f, -0.00074814f, -0.02115735f, -0.04278095f, -0.03256362f, 
    -0.01275458f, -0.04837072f, -0.04365583f, 0.02123269f, -0.03501049f, -0.02539541f, -0.09196411f, -0.07435481f, 
    -0.07771933f, -0.04625404f, -0.02649469f, 0.03584766f, 0.06810120f, 0.01454680f, 0.03690903f, 0.01433950f, 
    0.03289825f, 0.02787605f, -0.03920758f, 0.07108546f, -0.00857469f, 0.03550440f, 0.02533128f, -0.01973348f, 
    0.01977340f, -0.10910558f, -0.03277528f, -0.05498429f, -0.05504195f, 0.03355764f, -0.03828388f, -0.08505145f, 
    -0.07182704f, 0.05901760f, 0.00882865f, 0.01625827f, -0.03017884f, -0.06303777f, 0.00318509f, 0.05286213f, 
    -0.08315304f, -0.00424205f, -0.05448566f, 0.01528485f, -0.06854930f, 0.02087223f, -0.04695958f, -0.05709960f, 
    0.01446455f, -0.13717386f, -0.01259934f, -0.03152636f, 0.02405568f, -0.03110628f, -0.06192235f, -0.04885991f, 
    0.02493505f, -0.00889821f, -0.00702894f, -0.00739456f, 0.02851957f, -0.09411211f, 0.00926764f, 0.05239893f, 
    -0.04054683f, 0.03651264f, 0.02069123f, -0.10889303f, -0.06809113f, 0.02014222f, -0.07386357f, -0.01328064f, 
    0.03836149f, 0.08430587f, -0.02793263f, -0.00181931f, 0.03362842f, -0.02874730f, -0.05083583f, 0.04094265f, 
    0.04816387f, -0.03267375f, -0.05580051f, -0.04819782f, -0.07016299f, -0.06656904f, 0.03180208f, 0.01467108f, 
    -0.06514581f, -0.03201254f, -0.01682333f, -0.05737429f, -0.03224663f, 0.02111292f, -0.09857590f, 0.05323310f, 
    -0.04428440f, -0.06366443f, -0.01298359f, -0.04224155f, -0.05235681f, -0.04044389f, -0.08038530f, -0.09782557f, 
    -0.04265781f, -0.06432350f, 0.03807480f, 0.05390213f, -0.01243380f, 0.05600640f, -0.05048132f, 0.05300037f, 
    -0.00376877f, -0.02889740f, -0.07657323f, -0.02953273f, -0.00626924f, -0.02381389f, -0.06963911f, 0.00774489f, 
    -0.01571763f, -0.08004460f, -0.00665791f, -0.07184257f, -0.08371130f, 0.02223475f, -0.05781778f, 0.02827545f, 
    -0.09502614f, 0.03740454f, -0.06814670f, 0.02941449f, -0.04792012f, -0.01302796f, 0.01260025f, -0.09634023f, 
    0.02045841f, -0.04724199f, -0.05931720f, 0.01458521f, 0.01462010f, 0.05726465f, -0.04835941f, -0.08430997f, 
    0.01417972f, 0.00627877f, -0.08469564f, -0.04616596f, -0.06150928f, -0.03284116f, -0.02641857f, 0.04032968f, 
    -0.07965526f, -0.02016537f, -0.08550133f, -0.01482728f, 0.03037746f, 0.00039321f, 0.02005188f, 0.03887432f, 
    0.28755617f, 0.30714655f, -0.13605820f, -0.05458177f, -0.05537148f, -0.07741978f, -0.03628961f, 0.12640977f, 
    -0.16561054f, -0.14434467f, 0.01849292f, 0.10195272f, 0.44252163f, 0.08614748f, 0.08661443f, -0.20088236f, 
    -0.21990839f, -0.15545146f, 0.02184467f, -0.00572274f, -0.05479120f, 0.19445530f, -0.00822537f, 0.07991827f, 
    0.47351643f, 0.11148600f, -0.33603409f, -0.09639408f, -0.03182474f, 0.05830579f, 0.11307423f, -0.08152932f, 
    0.29867315f, -0.08532526f, 0.11831261f, -0.09880628f, 0.17477402f, -0.01086922f, 0.00469317f, 0.24811713f, 
    -0.13202301f, 0.14244442f, -0.12232579f, -0.05921170f, 0.26299956f, 0.35693398f, -0.01736809f, 0.18932126f, 
    0.33520132f, -0.12153158f, -0.15650274f, -0.01389720f, -0.06869612f, 0.17305969f, 0.05420706f, 0.07996999f, 
    -0.10387826f, -0.00205708f, 0.17372733f, -0.32550138f, 0.39748639f, -0.73388296f, 0.18883990f, -0.27497631f, 
    -0.00596890f, -0.00921246f, -0.12924477f, 0.28259456f, 0.08016604f, 0.03013236f, -0.16663471f, 0.10238061f, 
    0.66752487f, 0.08869658f, -0.14760785f, -0.02146397f, -0.02352446f, 0.08883397f, 0.05445383f, 0.02253096f, 
    0.07954393f, -0.19348064f, -0.08703585f, 0.13153611f, 0.03338312f, 0.01461468f, -0.23088175f, -0.01502888f, 
    0.21376522f, 0.08941527f, -0.15259612f, -0.23473772f, -0.05126038f, -0.00057679f, -0.05258910f, -0.03965320f, 
    -0.64428908f, -0.14409609f, 0.01763839f, 0.16893995f, -0.07164411f, 0.14613365f, 0.17152059f, -0.11130606f, 
    0.15587901f, 0.03025158f, 0.05977087f, -0.07843338f, 0.14365979f, 0.30890596f, -0.15709040f, 0.09665424f, 
    0.06933452f, 0.06910849f, 0.02827276f, 0.28335324f, 0.08522920f, -0.04412152f, -0.21077822f, 0.17823647f, 
    0.21580094f, -0.24029423f, -0.03408766f, 0.06871289f, 0.13154252f, -0.10286365f, 0.05606250f, -0.03332723f, 
    0.15572612f, -0.11632768f, -0.24863982f, -0.10036366f, -0.18446174f, 0.20622012f, 0.17434454f, 0.00624336f, 
    -0.10837390f, -0.04708225f, 0.12643528f, -0.05375405f, 0.12922750f, 0.05443892f, 0.11265761f, 0.06008377f, 
    0.02343754f, 0.33845580f, 0.08700118f, -0.02136489f, 0.07818609f, -0.08411074f, 0.16815896f, 0.00692974f, 
    0.20843799f, -0.00961735f, -0.09142283f, 0.19791268f, 0.30037704f, -0.13539922f, 0.04661597f, -0.02085608f, 
    0.00317086f, 0.07728664f, -0.03207641f, -0.00454887f, -0.29618299f, 0.03309143f, -0.06694096f, -0.09353959f, 
    -0.06248840f, -0.03064971f, -0.43972817f, -0.03130565f, -0.03433259f, -0.06829098f, 0.04214400f, -0.17175196f, 
    0.05192289f, 0.10515267f, -0.15062472f, -0.07389356f, -0.48662299f, 0.13136756f, 0.13997903f, -0.41480136f, 
    -0.08266423f, 0.23892315f, -0.10153416f, 0.09824684f, 0.08291624f, -0.10718061f, -0.01902275f, 0.02670209f, 
    -0.04571673f, 0.11434606f, 0.10541508f, 0.17329074f, -0.16385540f, 0.16685392f, -0.12363011f, -0.01818721f, 
    -0.03653741f, 0.00114753f, -0.11041517f, 0.12054481f, 0.12056713f, 0.28857803f, 0.09769230f, -0.05638385f, 
    0.19404896f, 0.05898116f, -0.03326735f, -0.00079020f, 0.00980109f, -0.12143676f, -0.03989942f, 0.04640841f, 
    -0.37417075f, -0.30165631f, -0.29363886f, 0.23823209f, 0.09516306f, 0.04893088f, -0.11363288f, -0.01332759f, 
    -0.05010537f, -0.02258267f, 0.09140229f, 0.02980789f, 0.56292135f, -0.20519960f, -0.06220603f, -0.06452557f, 
    -0.05967145f, 0.04607828f, -0.07016853f, -0.10701456f, -0.28389490f, -0.01786408f, -0.00253884f, -0.23562229f, 
    -0.06987549f, 0.16090509f, -0.15110998f, -0.16072431f, 0.03553544f, -0.13207914f, 0.03085527f, -0.02588570f, 
    0.11047929f, -0.03452547f, 0.19607365f, -0.00425192f, 0.17293105f, -0.37348467f, 0.23721133f, 0.05898834f, 
    0.05903935f, -0.03588517f, -0.10925963f, 0.29922560f, 0.16314271f, -0.10039600f, 0.02329038f, 0.18257277f, 
    -0.11408229f, -0.09385940f, -0.12123051f, 0.00916955f, -0.10781890f, -0.00138713f, 0.00320492f, -0.02167111f, 
    -0.05680919f, -0.03047601f, 0.11380045f, 0.05850988f, -0.40952703f, -0.06441674f, 0.15166372f, 0.09599347f, 
    -0.01513622f, -0.14475064f, -0.21673110f, 0.06726389f, -0.11107603f, 0.09808475f, 0.07221954f, -0.03874252f, 
    0.08997830f, 0.07661003f, 0.02988209f, -0.44532821f, 0.00138349f, 0.06689841f, 0.00464519f, 0.09798173f, 
    -0.06642808f, 0.06922186f, -0.01018403f, 0.09443310f, 0.13118620f, -0.14581755f, -0.24823971f, -0.24209969f, 
    0.11004561f, 0.06919777f, 0.07005650f, 0.28426722f, 0.19084860f, 0.06343260f, -0.00462610f, -0.07475349f, 
    0.20452993f, -0.14886583f, -0.28648150f, 0.16932908f, 0.16101399f, 0.04917800f, -0.27377906f, -0.02573544f, 
    -0.07599797f, -0.02453700f, -0.13529347f, 0.05600408f, 0.49834865f, 0.26667351f, -0.05193577f, 0.39480031f, 
    0.07943260f, 0.08809530f, 0.01573914f, -0.14502090f, -0.07876330f, -0.01129925f, 0.07179205f, -0.03449085f, 
    0.79896659f, 0.36708528f, -0.07154917f, -0.02264277f, 0.06222782f, -0.14755444f, -0.00287844f, 0.05636327f, 
    0.00872754f, -0.02278512f, 0.18167941f, 0.26822585f, 0.32688323f, -0.09174866f, -0.03178995f, -0.04710224f, 
    -0.02463035f, 0.01755984f, 0.01945991f, 0.04594333f, 0.09226143f, 0.09304337f, 0.24905168f, -0.04872108f, 
    0.06108436f, -0.15812607f, 0.00372032f, -0.02722747f, 0.00806066f, 0.02034698f, -0.03577397f, 0.06016932f, 
    -0.08412405f, 0.00127757f, -0.11476754f, -0.06765821f, 0.01952423f, 0.03940479f, 0.15437454f, 0.16471221f, 
    0.28643757f, -0.00230113f, 0.05161365f, 0.02800594f, -0.04114484f, 0.03516773f, -0.12197946f, 0.05367703f, 
    -0.14764953f, -0.33803296f, 0.07889430f, -0.19939943f, -0.04524998f, -0.15925933f, 0.03637994f, 0.00609097f, 
    0.13448694f, -0.05638470f, 0.04692107f, -0.23768482f, -0.12893279f, -0.16123463f, 0.04874424f, 0.57160228f, 
    0.18262413f, 0.18705375f, -0.07034846f, -0.04369915f, 0.09506257f, 0.01308284f, 0.07419597f, 0.14279984f, 
    0.34392524f, -0.09363577f, 0.16535915f, -0.03624246f, -0.19379978f, -0.20563081f, -0.04718337f, 0.17931817f, 
    -0.03051987f, -0.21931753f, 0.13839553f, -0.04238064f, -0.02957394f, 0.29021251f, -0.07107315f, 0.06874286f, 
    0.13355973f, 0.09334534f, 0.02878106f, 0.02279731f, 0.03347214f, 0.19978607f, 0.16482846f, 0.03032416f, 
    -0.05740862f, 0.07862478f, -0.20757301f, -0.46539727f, -0.06149805f, -0.04066718f, -0.04627137f, 0.06018868f, 
    0.16098282f, 0.16069505f, -0.08092096f, 0.09269045f, 0.10550868f, 0.44824684f, -0.17270109f, 0.29984632f, 
    -0.12471221f, -0.01409630f, 0.10616258f, -0.02773418f, 0.01383977f, -0.10719369f, 0.00294683f, -0.09004129f, 
    0.06985784f, -0.20526952f, 0.20841700f, -0.15442917f, 0.07865185f, 0.02085111f, 0.06829979f, -0.15934460f, 
    0.13524923f, -0.05613024f, 0.08340180f, 0.14712141f, 0.23133339f, 0.22771859f, 0.26452604f, 0.01830673f, 
    -0.25698480f, 0.02330054f, 0.00220875f, 0.11634971f, -0.26114577f, -0.04426681f, -0.18964286f, -0.08419526f, 
    -0.64101976f, 0.05290887f, 0.03664400f, 0.09758529f, -0.11949720f, 0.09831850f, -0.00217303f, 0.08705609f, 
    -0.09245919f, -0.02967742f, 0.01514123f, -0.05100113f, -0.05972361f, 0.53749442f, -0.00246927f, 0.00017314f, 
    0.14652894f, 0.01862075f, 0.11016138f, -0.02016820f, 0.26273125f, 0.11088465f, -0.11217622f, -0.05221288f, 
    -0.18882798f, 0.18940750f, 0.06838049f, -0.47142741f, -0.15192986f, 0.04753167f, -0.15929748f, 0.03316287f, 
    0.28131914f, -0.05397353f, -0.05234480f, 0.08493245f, -0.43722484f, -0.32761160f, -0.21453963f, -0.02277807f, 
    0.00500857f, -0.05144388f, -0.08371366f, 0.07756103f, 0.06718741f, 0.03715777f, -0.11321691f, 0.16330546f, 
    -0.15892582f, 0.22160915f, -0.40878865f, 0.03702192f, 0.01950223f, 0.14410074f, 0.06386316f, -0.05329014f, 
    0.03212480f, 0.13756585f, 0.12149214f, 0.02870141f, 0.13534024f, -0.11901449f, -0.27534428f, 0.14346999f, 
    0.01702603f, 0.10867016f, 0.03692676f, -0.01652313f, 0.01560621f, 0.05216661f, 0.11169431f, -0.14918205f, 
    0.07304327f, 0.03702169f, 0.54144865f, -0.18187322f, -0.09178734f, 0.04930269f, 0.01180739f, -0.01753411f, 
    0.11329679f, -0.10362389f, 0.14437485f, 0.19569851f, 0.51069677f, -0.32392582f, -0.37582800f, 0.38792911f, 
    0.12511827f, -0.06070159f, -0.00630087f, -0.11498299f, -0.07611673f, 0.14104952f, 0.16019225f, 0.01224698f, 
    0.03980421f, -0.07649002f, 0.01104821f, 0.05780741f, -0.00299024f, -0.06108318f, 0.05961404f, 0.04219447f, 
    0.03755331f, -0.07110006f, 0.05229196f, -0.00365239f, -0.08184781f, -0.05585374f, 0.05510150f, -0.01091626f, 
    0.03493415f, 0.02733127f, -0.03198931f, 0.00491121f, 0.03708788f, 0.06255408f, -0.01825664f, -0.03823832f, 
    0.02232832f, 0.03886468f, -0.03322078f, -0.03187462f, -0.07781155f, -0.05676340f, -0.04422789f, -0.00798078f, 
    0.03141765f, -0.00201414f, 0.06408498f, -0.04824204f, 0.01093819f, 0.05674474f, 0.02011246f, -0.02944162f, 
    -0.06266394f, -0.04521277f, -0.08217648f, -0.04566599f, -0.05943203f, -0.06067201f, 0.04184980f, -0.05585171f, 
    0.05583928f, -0.02433757f, -0.01119969f, -0.02616236f, -0.03797851f, -0.04217057f, -0.05264202f, -0.00865770f, 
    0.03594242f, 0.04351824f, 0.01662162f, -0.02083721f, -0.01821894f, -0.03166116f, 0.03671794f, -0.00730440f, 
    0.03759080f, 0.03746759f, -0.07895678f, 0.02644800f, 0.04326148f, -0.05776937f, 0.01516946f, -0.02015324f, 
    -0.03477789f, -0.03146149f, -0.00885429f, -0.05912379f, -0.06489471f, 0.01374521f, -0.02393398f, 0.03451160f, 
    -0.01101868f, -0.06262095f, -0.00116568f, -0.00237384f, -0.05245886f, 0.01910859f, 0.02197956f, -0.01116349f, 
    0.01595156f, -0.03373042f, 0.00220755f, -0.04696592f, 0.06069596f, 0.00654030f, 0.01746207f, -0.03837422f, 
    -0.01008112f, 0.01250549f, 0.02108544f, -0.06353863f, 0.04619779f, -0.04846276f, 0.02055898f, -0.06187966f, 
    0.01133342f, 0.00662325f, 0.02286801f, -0.01921936f, -0.07838389f, 0.04686502f, -0.03619797f, -0.00431606f, 
    -0.03533714f, 0.02946177f, -0.05380905f, -0.07992585f, -0.02285581f, -0.02248305f, -0.02084995f, 0.06190450f, 
    -0.03120727f, -0.01365674f, 0.02699333f, -0.05176711f, 0.03094061f, 0.05220182f, 0.00311470f, -0.04585587f, 
    -0.06005890f, -0.02700154f, -0.01378143f, -0.02769055f, 0.02409630f, -0.01501558f, 0.02462839f, 0.01405782f, 
    -0.07269136f, 0.05828883f, -0.00044930f, 0.05059744f, 0.06448366f, 0.01097288f, -0.04312657f, 0.04459501f, 
    -0.00283750f, -0.02988737f, -0.00144985f, 0.04973513f, -0.06370863f, 0.02959277f, -0.02348818f, -0.00825967f, 
    0.03631233f, -0.05845503f, 0.00164387f, -0.07920828f, -0.06388637f, -0.01726844f, 0.00001551f, 0.06219673f, 
    0.03942156f, 0.04173715f, -0.02430563f, -0.06814466f, 0.04821897f, 0.01086989f, 0.03076594f, -0.05888058f, 
    -0.03022008f, 0.00781314f, 0.03264823f, -0.03145727f, -0.01019182f, -0.04098538f, -0.04224666f, 0.05048656f, 
    -0.02237117f, -0.08184707f, 0.03219108f, 0.02257435f, 0.06033086f, 0.05287744f, -0.02800956f, -0.04298854f, 
    -0.01948735f, -0.03801891f, -0.05238988f, 0.01077789f, 0.03846396f, -0.08250748f, 0.05148543f, 0.05328196f, 
    -0.20466419f, -0.02814435f, -0.16557963f, 0.17904909f, 0.31815720f, 0.14223638f, 0.11456674f, 0.11705530f, 
    -0.11362508f, 0.06165798f, 0.04319286f, -0.04281947f, -0.58625454f, -0.13295841f, 0.01598551f, -0.17396091f, 
    -0.14650768f, 0.05092136f, 0.11926937f, -0.08550583f, 0.05614372f, -0.03949248f, 0.03971984f, 0.02385931f, 
    -0.35649708f, 0.18430395f, 0.06494255f, 0.04732941f, 0.08859958f, 0.21056838f, 0.09628623f, 0.05083449f, 
    -0.00608739f, 0.13979860f, -0.08315894f, -0.07691541f, -0.35801521f, 0.12194753f, 0.04565053f, -0.37301505f, 
    0.16798055f, -0.06248220f, 0.24065636f, -0.02564473f, -0.02202878f, -0.00534296f, -0.09307110f, 0.18690178f, 
    0.37879696f, 0.06144558f, 0.22180113f, 0.45104393f, 0.23889300f, -0.01824502f, -0.09941196f, 0.03780239f, 
    -0.14319050f, 0.31103125f, 0.06631048f, 0.21542783f, -0.30364761f, 0.36389571f, -0.22722910f, -0.07461400f, 
    0.14210971f, 0.03189065f, -0.17655654f, -0.30993471f, -0.09465959f, 0.03063407f, -0.01043009f, -0.23587289f, 
    -0.20695466f, 0.00815440f, 0.20657782f, 0.19749209f, 0.14864187f, -0.09649485f, -0.05212181f, 0.15305568f, 
    0.11213709f, 0.11304329f, -0.06658598f, -0.04784724f, 0.26214150f, -0.10981467f, -0.11795171f, 0.04254477f, 
    0.05741802f, 0.11827447f, 0.20383240f, 0.06973700f, 0.05486863f, -0.02996608f, 0.08381365f, 0.28835067f, 
    0.60224015f, -0.06858856f, -0.17704295f, 0.26807293f, 0.16100888f, -0.08345413f, 0.05289651f, -0.10106950f, 
    -0.03131263f, 0.02146384f, -0.03563028f, -0.09166761f, 0.10705330f, 0.07593852f, 0.21277989f, 0.23926079f, 
    -0.13069411f, -0.04618234f, 0.02263503f, -0.03054075f, -0.16986392f, -0.03951764f, 0.17676954f, 0.13714653f, 
    0.16591902f, -0.05571191f, 0.36442858f, 0.30194667f, 0.10109529f, 0.21676102f, 0.13585906f, 0.05738590f, 
    0.05072674f, 0.16630839f, 0.13292345f, -0.03381836f, -0.04558338f, -0.12342471f, 0.30193105f, -0.19750391f, 
    -0.00989601f, -0.06230959f, 0.00585024f, -0.03896121f, -0.16897514f, 0.09862489f, -0.01616435f, 0.16583246f, 
    -0.47936773f, -0.48728213f, 0.18486561f, -0.17921674f, -0.12850259f, 0.05024463f, -0.09172209f, 0.00219642f, 
    -0.01166231f, 0.02215715f, -0.09627011f, -0.12129634f, -0.67329830f, 0.43031681f, 0.01948757f, 0.00824069f, 
    -0.13914648f, -0.25520846f, -0.05719996f, 0.13578212f, 0.16097936f, -0.02725174f, -0.33962637f, 0.04619034f, 
    -0.16140720f, 0.07453308f, -0.02427770f, 0.42870998f, 0.30327979f, -0.00042207f, 0.06508970f, 0.00370401f, 
    0.14498895f, 0.02265814f, -0.01419057f, 0.11820361f, -0.16776003f, -0.01047947f, 0.23482233f, -0.22719634f, 
    -0.22278917f, 0.01000185f, 0.03715482f, -0.15194725f, -0.03419698f, 0.01810568f, -0.06703744f, 0.10373336f, 
    -0.20655727f, -0.25932047f, 0.28384480f, -0.02346435f, 0.12482302f, 0.05367808f, -0.01243875f, -0.02140459f, 
    -0.16400859f, -0.05060398f, 0.13096939f, -0.01940623f, 0.11772951f, 0.24459295f, -0.23067182f, 0.22706452f, 
    -0.12821853f, -0.08524910f, 0.24309462f, 0.00894040f, -0.03047065f, -0.04372789f, 0.06611893f, 0.10337514f, 
    0.36614159f, 0.16034065f, -0.43463635f, -0.37249887f, 0.07836942f, -0.02624839f, 0.04086708f, -0.15655042f, 
    0.22636956f, -0.07653520f, 0.10731882f, -0.11094005f, 0.16383186f, -0.19913580f, -0.11945558f, -0.14782199f, 
    0.11402394f, 0.05365474f, 0.01135586f, -0.10383503f, 0.27811965f, 0.17900743f, 0.02814111f, 0.34802583f, 
    -0.01703119f, -0.30694267f, -0.40153188f, 0.02299384f, -0.20041616f, 0.02834879f, 0.07332932f, -0.00449598f, 
    -0.09521375f, 0.25141853f, 0.01934849f, -0.29760754f, 0.55457616f, 0.15681472f, 0.08093338f, -0.14418796f, 
    0.11129341f, 0.09539741f, -0.20295770f, 0.18100606f, 0.04922247f, 0.18166405f, -0.00319999f, 0.03054725f, 
    -0.10520379f, -0.51226550f, -0.01890205f, 0.26097259f, -0.01644766f, -0.24216484f, -0.00725693f, 0.06128933f, 
    0.15383516f, -0.14378759f, -0.07251108f, 0.21487390f, 0.28384423f, 0.30854747f, -0.10715287f, -0.54167235f, 
    0.06104759f, 0.17309189f, -0.00977136f, -0.14321107f, 0.04402200f, 0.02242251f, -0.15315263f, -0.15099268f, 
    0.11630367f, 0.17029947f, 0.03337470f, 0.56373686f, -0.06063270f, -0.23171917f, 0.22171092f, -0.00182936f, 
    0.13360429f, 0.33093768f, 0.16016750f, 0.07841806f, 0.24643345f, 0.11796582f, -0.13013600f, -0.26708362f, 
    0.06001355f, -0.06932838f, -0.08451214f, 0.19013271f, 0.16788541f, -0.11319285f, 0.16251834f, 0.35696378f, 
    -0.13339427f, 0.00940544f, 0.02566246f, -0.05748981f, 0.13512971f, 0.19032291f, -0.00109018f, 0.03435334f, 
    0.15218957f, 0.05959640f, -0.24872871f, -0.12162705f, 0.24200520f, -0.13784674f, 0.17767416f, -0.27055162f, 
    0.14816417f, 0.13976325f, -0.13076191f, -0.09358506f, 0.12324306f, 0.09953245f, -0.02292933f, 0.21772102f, 
    0.88687658f, -0.03242443f, -0.16612658f, -0.02226772f, 0.22078662f, -0.02194684f, -0.09312002f, 0.05121615f, 
    0.00790659f, 0.01636249f, 0.05673251f, 0.15482219f, -0.27466962f, -0.09597551f, 0.20425361f, 0.20918301f, 
    0.00937077f, -0.06260651f, -0.19600213f, -0.17141235f, -0.11396813f, -0.20771010f, -0.26908886f, -0.10597779f, 
    -0.15582737f, -0.22698694f, -0.00175902f, 0.01878242f, 0.19182448f, 0.00192155f, 0.06896213f, -0.21437825f, 
    0.02250572f, 0.00272065f, 0.01054556f, 0.20337124f, -0.16577806f, 0.32783204f, -0.17223679f, 0.19684321f, 
    -0.02893485f, 0.12414987f, -0.12105586f, -0.00872040f, 0.12435486f, -0.13807502f, 0.01627539f, 0.18435013f, 
    -0.03891186f, 0.00706899f, -0.02805020f, -0.00598120f, 0.12564853f, 0.03934761f, 0.09932962f, -0.14302231f, 
    0.08579739f, 0.10702097f, -0.17380950f, 0.14042705f, 0.17666595f, -0.07229017f, -0.12716964f, -0.11185385f, 
    0.06370931f, -0.03021141f, -0.03391542f, 0.15713604f, 0.10275793f, -0.04461853f, -0.02525534f, -0.10846039f, 
    -0.07776190f, -0.03629255f, 0.16326109f, 0.08856268f, 0.01984433f, 0.24184076f, -0.09462760f, 0.03832767f, 
    -0.13220754f, 0.15522324f, -0.04772288f, 0.30524114f, 0.01514068f, -0.22746381f, 0.30196500f, -0.01308998f, 
    -0.05325419f, -0.02295575f, 0.18113109f, 0.10771304f, -0.02887602f, -0.36733377f, -0.12164289f, -0.16646945f, 
    -0.31860855f, 0.31146780f, 0.31542212f, 0.37009352f, 0.08053850f, -0.06004994f, 0.03923388f, -0.19959095f, 
    -0.00972545f, -0.23573653f, -0.16814393f, 0.26420113f, -0.43258935f, 0.22616689f, -0.04455332f, -0.20697480f, 
    0.13524920f, 0.01464181f, 0.21520412f, -0.19556589f, 0.04384630f, 0.06855105f, 0.29059586f, -0.04589923f, 
    -0.36470488f, 0.43706325f, 0.09681515f, 0.10575473f, 0.11395969f, -0.08734940f, -0.05946034f, 0.02147436f, 
    0.00840774f, 0.20541811f, 0.15474629f, -0.41566652f, -0.01630735f, -0.09640614f, -0.08763389f, -0.15352045f, 
    0.09842297f, 0.02932073f, 0.10404875f, 0.18207961f, 0.23794037f, 0.01162134f, 0.13356212f, 0.20175123f, 
    0.83616823f, -0.16349822f, 0.17901762f, -0.02953822f, 0.24342556f, 0.02247193f, -0.03130700f, -0.01922650f, 
    -0.13172083f, 0.01960563f, -0.20444578f, 0.13757223f, -0.04093125f, -0.31751215f, 0.28369310f, 0.32382354f, 
    -0.03886588f, -0.08904558f, -0.06744058f, -0.09869894f, -0.14843899f, -0.15483518f, 0.17564349f, -0.17739263f, 
    -0.13667364f, 0.31827828f, 0.14851706f, 0.17993997f, -0.01847097f, -0.05279450f, 0.15231498f, -0.05757775f, 
    -0.23485644f, 0.06476616f, 0.34011480f, 0.14455187f, 0.40757731f, 0.32191989f, -0.13043031f, 0.13687192f, 
    -0.16690578f, 0.00519282f, 0.08749489f, 0.09693799f, 0.10639049f, -0.11291362f, 0.00086506f, -0.28340265f, 
    0.11958537f, -0.04035649f, 0.19411598f, 0.14789158f, -0.00597176f, 0.00568119f, -0.08166917f, 0.05719155f, 
    -0.08624430f, 0.01236711f, 0.12229986f, -0.19559233f, -0.21299207f, -0.07282338f, 0.15874600f, 0.06013095f, 
    -0.05837986f, -0.07580945f, 0.14338829f, -0.03704186f, 0.12268832f, 0.04682393f, 0.25299785f, 0.25519216f, 
    0.11278693f, 0.09541710f, -0.27675292f, 0.08809695f, -0.04900724f, 0.03971893f, -0.02582575f, 0.07544752f, 
    -0.05643456f, 0.03208213f, -0.04539099f, -0.12108881f, -0.27501836f, -0.01961370f, 0.17580518f, -0.09330208f, 
    -0.05062157f, -0.10608160f, 0.20037235f, -0.00776210f, 0.00354553f, 0.07866222f, 0.08027016f, -0.14445628f, 
    -0.66896242f, -0.09245526f, 0.30299857f, -0.20722020f, 0.20277666f, 0.13363326f, -0.00384601f, -0.18540154f, 
    0.10228102f, 0.17784274f, -0.00175554f, 0.09036698f, 0.59441715f, 0.15145902f, 0.12788431f, -0.04846847f, 
    -0.03951643f, -0.01438710f, -0.06225516f, 0.00915812f, -0.06749013f, 0.08774174f, 0.06636231f, 0.02730822f, 
    0.39091194f, 0.28680080f, 0.21830004f, 0.16138116f, 0.29196334f, 0.16328596f, 0.05936335f, 0.17575406f, 
    -0.01358787f, -0.08486877f, -0.09401426f, 0.13295200f, 0.27446464f, -0.17236175f, 0.20912150f, 0.34958771f, 
    -0.14056358f, 0.05564344f, 0.07069901f, -0.04850333f, -0.02860796f, -0.03832845f, -0.03261119f, -0.03904178f, 
    0.07335772f, -0.26335207f, 0.16243878f, 0.29279584f, 0.15899439f, 0.01314962f, 0.03152803f, -0.03772900f, 
    -0.02474245f, -0.12967446f, 0.10448992f, 0.02378944f, -0.31678438f, 0.31296927f, 0.07924711f, -0.10123707f, 
    -0.27359888f, -0.18375194f, 0.08017264f, -0.16392212f, -0.06489857f, 0.01746919f, 0.06529605f, -0.11969450f, 
    0.52285570f, 0.08728637f, 0.08115444f, -0.17636470f, 0.11982934f, -0.08357977f, 0.06068273f, 0.04238335f, 
    -0.03313915f, 0.03879128f, 0.08588414f, -0.12498481f, 0.10614949f, 0.12570256f, -0.22632211f, 0.58905286f, 
    0.22863722f, 0.23875624f, 0.07535712f, -0.06207652f, 0.04493045f, 0.00963767f, 0.04686363f, 0.02754203f, 
    -0.17539984f, -0.29020593f, 0.25730494f, -0.12113603f, 0.04694371f, 0.04401154f, -0.10872927f, -0.08410794f, 
    -0.13291843f, -0.13024361f, -0.02841977f, -0.03235704f, 0.13144760f, -0.42649603f, 0.08221617f, 0.35736382f, 
    -0.17272529f, -0.19731694f, -0.29505172f, -0.07777729f, -0.15735671f, -0.03086957f, -0.16032864f, 0.06110290f, 
    -0.07552878f, 0.11873715f, -0.12585138f, -0.22619377f, 0.16075727f, 0.02946792f, 0.00082923f, -0.03933940f, 
    -0.00464596f, -0.07223006f, -0.13464889f, 0.02034704f, 0.09300827f, 0.27027962f, -0.20550399f, -0.02114528f, 
    -0.15350419f, 0.15185079f, 0.11733837f, -0.00993854f, 0.01496288f, 0.09359287f, 0.09085673f, -0.00871073f, 
    0.08833713f, -0.06531180f, -0.12234162f, -0.07139731f, 0.03085216f, -0.05279326f, 0.09714202f, -0.02824295f, 
    -0.12590814f, 0.06009554f, -0.00934717f, -0.17744634f, 0.12253996f, -0.14632557f, 0.18466064f, 0.01419544f, 
    0.03640619f, -0.03935667f, 0.02646410f, 0.06283983f, 0.00781635f, 0.03612327f, -0.06613579f, 0.09581988f, 
    -0.15995362f, 0.33735827f, 0.09177330f, 0.23003025f, -0.12975189f, 0.12374406f, 0.07668786f, 0.06882624f, 
    -0.05699761f, 0.01591752f, -0.07445119f, -0.08327340f, 0.33246800f, 0.22686023f, 0.52738690f, -0.06859007f, 
    -0.09088881f, 0.11678775f, 0.16156074f, -0.15755703f, -0.08526706f, 0.04951005f, 0.00337836f, -0.13405147f, 
    0.39689296f, -0.12904821f, -0.28909788f, 0.09014130f, -0.07582244f, 0.09554468f, -0.02804986f, -0.14586280f, 
    -0.12726767f, 0.01622240f, -0.18253951f, 0.12209856f, 0.19982025f, 0.16751474f, -0.10248473f, -0.11076271f, 
    -0.06211210f, 0.01266541f, -0.02823713f, 0.02507096f, 0.02619657f, -0.01526408f, -0.07339772f, -0.00714508f, 
    0.35709155f, -0.02803442f, -0.04346319f, 0.11353198f, 0.00989455f, 0.06437259f, 0.00540401f, -0.05443784f, 
    0.15267561f, 0.06182078f, 0.14306985f, -0.02074848f, 0.37695080f, -0.24665780f, 0.03938485f, 0.11940555f, 
    -0.06087363f, 0.00250147f, 0.00173887f, 0.03714010f, -0.02829430f, -0.05724159f, -0.12905972f, 0.00718564f, 
    0.01583255f, 0.16311562f, -0.18057154f, -0.07324419f, -0.15402642f, -0.01496193f, 0.00524332f, 0.05404150f, 
    -0.09162652f, -0.01933717f, -0.10530011f, -0.11105045f, 0.33435729f, -0.27631587f, 0.27642480f, -0.17472622f, 
    0.09745796f, 0.01735836f, -0.05428439f, 0.09401964f, 0.02650666f, 0.02013924f, -0.11269677f, 0.15369242f, 
    0.25433367f, 0.21702941f, -0.00192439f, 0.12669188f, -0.08397478f, 0.02667016f, 0.10475355f, -0.04154993f, 
    0.09403796f, -0.00919655f, 0.06759834f, -0.07221872f, -0.23938681f, 0.18381588f, 0.09827921f, -0.15921851f, 
    0.13756242f, -0.12611891f, -0.03902622f, 0.15334797f, -0.02134675f, 0.11541044f, 0.04225310f, -0.19200982f, 
    0.24236290f, 0.10952616f, -0.08054063f, 0.01646805f, -0.02552775f, 0.10696431f, -0.02929236f, 0.07909377f, 
    0.24989660f, -0.01030800f, -0.06275076f, -0.03296857f, 0.17768209f, -0.11238053f, -0.13947384f, 0.02698692f, 
    0.17537421f, 0.21608216f, 0.07236719f, 0.24927785f, -0.02484321f, 0.00722667f, -0.01763867f, -0.13862146f, 
    0.01459214f, -0.05798710f, -0.16830356f, 0.42887223f, 0.09598108f, -0.02600994f, 0.05624125f, -0.00097345f, 
    -0.00318076f, 0.00967321f, -0.01876839f, 0.08225331f, 0.33860496f, 0.35411173f, -0.13868099f, 0.06459180f, 
    -0.03138283f, 0.16137810f, 0.06690149f, -0.06288156f, 0.04724986f, -0.14538178f, -0.01732605f, -0.17026311f, 
    0.91636652f, 0.42181548f, 0.19511181f, -0.02671439f, -0.09122837f, -0.10037246f, -0.00879425f, 0.06041795f, 
    -0.11264758f, -0.06210887f, 0.15078776f, 0.16540171f, 0.34739211f, -0.11608467f, 0.14804460f, -0.11268546f, 
    0.04921295f, 0.04695548f, 0.07763679f, -0.14664352f, 0.07064192f, 0.15653381f, 0.18630384f, 0.08688118f, 
    0.09905633f, -0.35166055f, -0.36099589f, -0.12141590f, -0.05760197f, -0.06811155f, -0.06881612f, -0.06232643f, 
    0.04447421f, 0.06991265f, -0.03639773f, -0.17279316f, -0.65248924f, -0.05152052f, 0.01291962f, -0.20810899f, 
    0.13601983f, 0.07965240f, 0.14220874f, -0.11890393f, 0.15623495f, -0.14848486f, -0.07967001f, -0.07159861f, 
    0.00943353f, 0.11693963f, -0.06961073f, 0.05367609f, -0.18666212f, 0.09268985f, -0.06967229f, 0.08742855f, 
    0.14374857f, 0.26196525f, 0.20606768f, 0.10419188f, -0.46711069f, -0.20626868f, 0.17392175f, 0.01394530f, 
    0.29432032f, 0.25794551f, -0.00016154f, 0.00254801f, 0.12487759f, -0.15440062f, 0.04520657f, 0.25049204f, 
    -0.88566417f, -0.29656312f, -0.32336766f, 0.15152662f, -0.17777358f, -0.01592604f, 0.00854144f, -0.04675749f, 
    -0.07899789f, -0.23326416f, 0.09346651f, -0.24807850f, -0.04355149f, 0.03521749f, 0.12695388f, -0.01236569f, 
    0.09259078f, 0.02024054f, 0.00734399f, 0.11118753f, -0.10606118f, 0.19892918f, 0.00086041f, -0.02067264f, 
    -0.06782350f, 0.32878068f, -0.13998935f, 0.07521531f, 0.12352032f, -0.19883448f, -0.08729693f, -0.03309552f, 
    0.23901494f, 0.12429267f, 0.44945979f, 0.33624211f, -0.05330708f, 0.12711573f, -0.12060732f, 0.10438053f, 
    0.14156076f, -0.06439964f, -0.04148093f, -0.05203988f, 0.04742398f, -0.16981855f, -0.09461704f, 0.00661314f, 
    -0.56013387f, 0.19326191f, 0.02016290f, -0.29374608f, 0.09824479f, 0.01644503f, 0.05900756f, 0.10262262f, 
    0.01745047f, 0.07209132f, -0.02622574f, 0.13870476f, -0.22753865f, -0.17764530f, 0.03963200f, 0.03715624f, 
    -0.21222913f, -0.11461730f, -0.15288639f, -0.14960748f, -0.24214804f, 0.00291330f, 0.02619510f, -0.08136652f, 
    -0.04120430f, 0.04001383f, 0.06915607f, -0.35284379f, 0.08264954f, -0.00867270f, 0.01371784f, 0.09693095f, 
    -0.04727753f, 0.02435298f, 0.11184807f, 0.12288377f, 0.09777141f, 0.01047814f, 0.12010901f, 0.02106979f, 
    0.13947873f, 0.09016302f, 0.20827350f, 0.23107260f, 0.15463352f, 0.09521330f, -0.09570255f, 0.13384706f, 
    0.34519824f, -0.15929256f, 0.05760219f, 0.15572338f, 0.09626339f, 0.13949344f, -0.10235511f, -0.02729997f, 
    0.09992158f, 0.21829346f, -0.06315622f, 0.02441942f, 0.39195716f, 0.04935522f, -0.01599853f, 0.34136093f, 
    0.18562715f, 0.03944984f, -0.16184321f, -0.05843207f, -0.12082665f, 0.21295534f, 0.27707964f, 0.15852152f, 
    0.20985000f, 0.03674177f, -0.06763163f, 0.12015543f, 0.01668545f, -0.08933322f, -0.04824750f, -0.03341718f, 
    0.04095865f, 0.00171740f, 0.19630541f, 0.23530591f, -0.10502957f, -0.00859596f, -0.09856397f, 0.01677568f, 
    0.03469494f, -0.17015383f, -0.05561716f, 0.32157928f, 0.21700172f, 0.20113696f, -0.16753916f, -0.06110156f, 
    0.24424158f, -0.16471015f, 0.07775373f, 0.02925234f, 0.08343199f, -0.05272977f, 0.00530198f, 0.07542314f, 
    0.01670741f, -0.12717411f, -0.05134291f, 0.18747705f, 0.09321744f, -0.20382255f, 0.23713551f, -0.04979727f, 
    0.47484753f, -0.01156990f, 0.01799140f, -0.03901991f, -0.15689415f, 0.01567433f, -0.16405366f, 0.09745353f, 
    -0.65468961f, -0.36147842f, -0.45030805f, -0.03558142f, 0.08564233f, 0.10173272f, -0.05109795f, 0.29702324f, 
    0.11664524f, 0.24757397f, -0.16289300f, -0.09344790f, -0.17856151f, 0.32557184f, 0.62519449f, -0.07843688f, 
    -0.03551818f, 0.19609955f, 0.05329015f, 0.08181335f, -0.02052134f, -0.02997329f, -0.03843274f, 0.05757304f, 
    -0.77359790f, -0.27559531f, 0.00151588f, -0.28460762f, 0.14468385f, -0.18390308f, 0.11172859f, 0.05345467f, 
    0.03462800f, 0.05106590f, -0.06557969f, -0.12899731f, 0.00959792f, 0.16778614f, -0.10883740f, -0.13763507f, 
    0.12114659f, -0.09055435f, 0.13737153f, 0.01133130f, -0.06369735f, -0.05084942f, 0.20863251f, -0.12017939f, 
    -0.15014556f, -0.40001762f, -0.08614931f, 0.13699158f, 0.10927876f, -0.11687024f, -0.10447340f, 0.04408063f, 
    -0.01320572f, -0.00019038f, -0.01822278f, -0.18942982f, -0.07289008f, 0.12733437f, -0.00732816f, -0.22666393f, 
    0.07051969f, -0.04765187f, 0.08638505f, 0.08273324f, 0.05506580f, 0.02492063f, -0.04224180f, -0.01184076f, 
    -0.00565541f, -0.38187507f, -0.25961381f, 0.35576651f, -0.18198718f, -0.08598246f, -0.08973782f, 0.13593212f, 
    0.12563647f, 0.03156146f, 0.04861198f, -0.10837059f, -0.03801553f, -0.24267705f, 0.05209496f, -0.03582614f, 
    0.11228054f, -0.06634486f, 0.15454537f, 0.23987919f, 0.16927566f, -0.11607678f, 0.04176836f, 0.08358381f, 
    0.33631638f, 0.14612794f, -0.41194800f, 0.12779604f, -0.02417865f, 0.08095798f, -0.07697719f, 0.06571368f, 
    0.16074049f, 0.06579477f, -0.08155125f, 0.26375881f, 0.05086284f, 0.30773470f, 0.08046044f, 0.16004138f, 
    -0.36227861f, -0.31586173f, 0.12523474f, -0.11482060f, 0.01515473f, 0.17563596f, 0.22489987f, 0.05525720f, 
    -0.18690293f, -0.13818631f, 0.05429200f, -0.06032903f, 0.28983304f, -0.03281680f, 0.02317783f, 0.16957586f, 
    -0.12351734f, 0.07848994f, -0.02618610f, 0.11105652f, -0.03724305f, 0.42038605f, 0.32389084f, 0.00345368f, 
    0.40079829f, 0.12042435f, 0.04594378f, -0.14683154f, 0.07491482f, 0.19531168f, 0.05685667f, 0.12849160f, 
    -0.61610901f, 0.01525641f, 0.70686847f, 0.04862172f, -0.08230803f, 0.07261728f, 0.12730372f, -0.03511236f, 
    0.01178528f, -0.11707021f, 0.00768907f, -0.09629083f, -0.36989844f, 0.25205949f, -0.09460188f, -0.13373414f, 
    0.08490709f, 0.01399672f, 0.06979793f, 0.10123131f, 0.13574100f, 0.11024398f, -0.02027880f, 0.02005641f, 
    -0.29521629f, -0.27486721f, -0.03835059f, -0.18220548f, 0.22915637f, -0.05759169f, 0.03803102f, 0.26986638f, 
    0.08243975f, -0.03916149f, -0.03883200f, 0.06020770f, 0.37364066f, 0.48566768f, 0.19703260f, 0.05085102f, 
    0.13394453f, 0.07190040f, -0.07650464f, -0.06418695f, 0.00865302f, 0.02903957f, -0.03451623f, 0.23318796f, 
    0.01354316f, -0.06751018f, -0.07205182f, -0.00313329f, -0.01565451f, 0.01280114f, 0.05676937f, -0.04438210f, 
    0.00671273f, -0.06977172f, -0.03624044f, -0.00509019f, -0.04092041f, 0.05814945f, -0.07762702f, -0.03865351f, 
    0.04683205f, -0.00683017f, -0.02853164f, -0.06454935f, 0.01660063f, -0.04836103f, 0.02330011f, -0.02401152f, 
    -0.02287546f, -0.07927286f, 0.01274521f, 0.00209806f, -0.07059390f, 0.06179677f, -0.04898966f, -0.00577581f, 
    -0.02057636f, -0.04856012f, -0.02393978f, -0.06831762f, 0.04724316f, -0.01409873f, 0.03959468f, 0.02500399f, 
    0.04090532f, 0.02076205f, -0.04007372f, -0.05938416f, 0.01278556f, -0.02613685f, -0.05712560f, -0.03101302f, 
    -0.06109441f, 0.01253567f, -0.01633744f, 0.05742944f, 0.05774594f, -0.00091944f, -0.00615742f, 0.05746565f, 
    0.02307341f, -0.01553534f, -0.05908109f, -0.00974600f, 0.06801455f, 0.03253229f, 0.05783902f, -0.02212416f, 
    -0.07476845f, -0.00585739f, 0.04166978f, -0.04621943f, -0.05167687f, 0.01267861f, 0.04428631f, -0.01562690f, 
    0.02220026f, 0.04841005f, -0.04926506f, 0.02229544f, 0.05773517f, 0.00085010f, -0.01235826f, -0.00803776f, 
    0.03328953f, 0.01617534f, -0.01847686f, -0.06572065f, 0.05439524f, -0.00702281f, -0.07957152f, -0.02320284f, 
    -0.01347372f, 0.05642964f, 0.01231006f, -0.00745044f, 0.02012772f, -0.07558357f, 0.01422605f, -0.06674336f, 
    -0.04022188f, -0.05868897f, -0.00959368f, 0.06259537f, 0.00415164f, 0.02368774f, -0.03648690f, -0.01621306f, 
    -0.07291865f, -0.04929087f, -0.05770727f, 0.00425567f, -0.01485106f, -0.01984121f, -0.02991870f, -0.00681401f, 
    0.03013005f, 0.05088072f, -0.06617175f, -0.03147260f, -0.05230911f, 0.03305414f, 0.03850565f, -0.06304702f, 
    0.05854687f, 0.01087089f, -0.05078883f, 0.02299324f, -0.06977651f, 0.04064699f, 0.04927303f, 0.05729025f, 
    0.01956283f, 0.02134528f, 0.00211117f, -0.00070588f, -0.00111750f, 0.03293049f, -0.00301762f, 0.01191949f, 
    -0.01357512f, -0.02722452f, -0.05101830f, -0.02694531f, 0.05448928f, -0.03888515f, 0.05586329f, -0.07569585f, 
    -0.02780413f, 0.00256534f, 0.05908292f, 0.04777770f, -0.03802634f, 0.04354952f, -0.01700714f, -0.01138177f, 
    0.06415238f, 0.01473174f, -0.04573403f, 0.05023930f, -0.01164430f, -0.02689010f, -0.02758591f, -0.00877447f, 
    0.02114248f, -0.05717907f, 0.03848802f, -0.07106902f, -0.03528539f, 0.03609391f, -0.02838656f, -0.03130916f, 
    -0.03285758f, -0.02078901f, -0.04438467f, 0.02002013f, -0.01437977f, -0.00138028f, -0.06610319f, 0.02678254f, 
    0.00441076f, -0.02258150f, -0.02436212f, -0.03666604f, -0.04824829f, 0.03231947f, -0.05492637f, 0.05484056f, 
    -0.06639025f, -0.02307229f, -0.04802961f, -0.04890136f, -0.05487481f, -0.01792568f, -0.05448526f, 0.05030746f, 
    0.05660152f, -0.01454913f, -0.00006600f, -0.00084180f, -0.07259978f, 0.02099985f, -0.06939790f, -0.07357631f, 
    -0.01887922f, 0.01446855f, -0.04754556f, -0.04356733f, 0.00634417f, 0.00947407f, -0.03603908f, -0.02302508f, 
    -0.01416227f, -0.02217568f, -0.00361810f, 0.00337950f, 0.04410844f, -0.05159639f, -0.07826188f, -0.00479499f, 
    -0.00502968f, 0.01985979f, 0.00131874f, 0.07366513f, -0.07483031f, -0.05379190f, -0.01348791f, -0.02891119f, 
    0.05066373f, -0.04143351f, -0.06584478f, 0.04724108f, 0.02121658f, -0.00059861f, -0.03820390f, 0.01417609f, 
    -0.00979045f, 0.05638093f, 0.05538274f, -0.04183999f, 0.05131353f, 0.06613278f, -0.07308832f, 0.07136793f, 
    0.02215467f, -0.03160483f, -0.00891636f, 0.07214368f, -0.00553830f, -0.05605965f, 0.04607147f, 0.06499288f, 
    0.01649462f, -0.06455386f, -0.06855263f, 0.00617154f, -0.00079811f, 0.00462416f, 0.01127621f, 0.00335386f, 
    -0.04400280f, 0.05355531f, 0.01206783f, 0.02037128f, -0.04318290f, -0.06258847f, -0.07259470f, -0.04764920f, 
    0.00768526f, -0.05546922f, 0.06002985f, 0.01984647f, -0.04480605f, -0.02523079f, -0.03168677f, -0.06447083f, 
    0.00169242f, 0.04966659f, -0.05477521f, -0.03864470f, -0.06704085f, -0.03419864f, -0.06610225f, -0.03676264f, 
    -0.02083578f, -0.02736016f, 0.05951929f, -0.02440587f, -0.00807501f, 0.04761358f, 0.03110384f, 0.01848327f, 
    -0.01615511f, -0.02772827f, -0.01874247f, 0.05485307f, -0.02926909f, -0.02704819f, -0.07098905f, 0.00725999f, 
    -0.03685540f, 0.06984440f, -0.00541359f, -0.03958149f, 0.03329295f, -0.04770417f, -0.01342007f, 0.05858545f, 
    -0.06897326f, 0.06812827f, -0.00178306f, 0.04999202f, 0.04518201f, 0.01941966f, 0.03706168f, -0.03317396f, 
    -0.01427916f, 0.02658577f, -0.06747603f, -0.04215917f, 0.05224272f, 0.02302898f, -0.02005453f, -0.02031864f, 
    0.04401022f, -0.01243869f, -0.06143769f, -0.01741908f, 0.02585969f, -0.02897780f, -0.06772492f, -0.05460067f, 
    -0.04794037f, 0.00193622f, 0.03948143f, 0.03829043f, -0.05395174f, 0.00820797f, -0.07292824f, -0.05444878f, 
    0.02678023f, -0.01703237f, 0.04796358f, -0.06875235f, 0.05892266f, 0.00552902f, 0.04411986f, -0.04439133f, 
    -0.01824519f, 0.00628643f, 0.02237060f, -0.03745150f, -0.00583139f, -0.01731559f, 0.02297173f, -0.05855896f, 
    -0.02488506f, 0.05320915f, -0.01035423f, 0.00862532f, -0.01420844f, -0.05250563f, -0.05994755f, 0.02541781f, 
    0.04030242f, 0.01222378f, -0.07147728f, 0.05959819f, -0.00668305f, -0.07449657f, 0.06127192f, -0.05181390f, 
    0.02450646f, -0.06803247f, 0.00440937f, -0.00482092f, -0.04386637f, 0.04245672f, -0.03289745f, -0.05354060f, 
    0.03299192f, 0.00179631f, -0.05472820f, -0.01269771f, -0.07231083f, -0.01304018f, -0.07074770f, 0.00780246f, 
    0.11655647f, -0.00932693f, -0.28360632f, -0.01333290f, 0.00968298f, -0.07885766f, 0.03999138f, 0.22248055f, 
    0.05409145f, -0.17912450f, 0.02128759f, 0.12628634f, 0.32982585f, 0.04673914f, 0.43359125f, 0.05650426f, 
    -0.17703336f, 0.12806810f, -0.10952252f, 0.18505390f, -0.03849831f, 0.15914062f, 0.03251032f, -0.06554827f, 
    0.35006055f, -0.04957826f, -0.01173025f, -0.55283302f, -0.12005088f, -0.18264288f, -0.15612935f, 0.07560468f, 
    0.23505959f, -0.07294039f, -0.00872925f, 0.33217973f, -0.34643364f, 0.12108150f, 0.06778158f, 0.04813438f, 
    0.15614836f, -0.11346132f, 0.03185694f, 0.04363891f, 0.18282849f, 0.02556487f, -0.01899299f, 0.09605775f, 
    -0.17681581f, 0.13717331f, 0.08309767f, 0.10409717f, 0.02457222f, 0.11134017f, 0.07969012f, 0.17432053f, 
    -0.23545177f, 0.00357301f, -0.09220867f, 0.19684501f, 0.18002431f, -0.15913555f, -0.06956302f, -0.20036083f, 
    0.19666433f, -0.13762997f, -0.05468172f, -0.00608726f, 0.15162371f, -0.14089397f, 0.12640977f, 0.21788733f, 
    0.15631764f, 0.07188970f, -0.10299171f, 0.26589316f, -0.06670405f, 0.00149263f, -0.00007392f, 0.06343392f, 
    0.13737501f, -0.13623451f, -0.09146801f, -0.07748012f, 0.22706294f, -0.09444494f, -0.13891302f, -0.24115273f, 
    0.05009963f, -0.05634494f, 0.00380214f, 0.01449007f, 0.08035067f, 0.06912564f, -0.07405492f, 0.15026145f, 
    -0.37821352f, 0.02172124f, -0.06996986f, 0.23743050f, -0.03523419f, 0.24635221f, 0.19786668f, 0.14812665f, 
    0.12261207f, 0.07657707f, -0.10205723f, -0.00499009f, -0.09531215f, 0.76254284f, -0.02321783f, 0.22009747f, 
    0.04307377f, 0.28392956f, 0.09693426f, 0.05270766f, -0.09830447f, -0.12216903f, -0.11358685f, 0.05110709f, 
    -0.00155897f, 0.06391217f, 0.03887666f, -0.25587901f, 0.04751727f, -0.15789537f, 0.32346299f, -0.00597760f, 
    0.15460180f, 0.09356502f, -0.03328956f, -0.03167115f, -0.06960505f, 0.42128849f, 0.17535745f, -0.31662220f, 
    -0.00214740f, -0.03968299f, 0.16567719f, 0.10048375f, 0.21461873f, -0.14724441f, -0.18098889f, -0.02367955f, 
    -0.87576771f, 0.46696788f, 0.21594104f, -0.06457151f, -0.11568584f, 0.09779153f, 0.06807250f, -0.03221169f, 
    0.11818480f, -0.01757006f, -0.10765414f, -0.08947959f, 0.15578462f, -0.10969005f, 0.12606825f, 0.29350203f, 
    -0.02060863f, 0.07817898f, 0.19269753f, 0.06881775f, -0.04304447f, 0.08907314f, 0.22337998f, -0.11190224f, 
    0.07458539f, -0.43289050f, -0.29054207f, -0.16142966f, -0.09493677f, -0.02026746f, -0.05927020f, 0.05382858f, 
    -0.01773364f, -0.03876584f, 0.12945743f, -0.00476307f, -0.12106537f, -0.13491948f, -0.15773295f, -0.09403686f, 
    -0.20562878f, 0.20841482f, 0.02671196f, 0.16744302f, 0.10573927f, 0.01788587f, 0.25158322f, 0.01545157f, 
    -0.03119793f, 0.28010345f, -0.17882666f, -0.27929348f, -0.04411484f, 0.07833491f, 0.09929395f, -0.04755257f, 
    0.03057504f, 0.19596870f, 0.21612954f, -0.03642227f, -0.01648134f, -0.34543151f, 0.10468604f, -0.09724528f, 
    -0.04554445f, 0.04405143f, 0.05249882f, -0.15275636f, 0.15384240f, 0.09898783f, 0.02356612f, 0.12287979f, 
    -0.27524909f, 0.06580240f, -0.08964122f, 0.25913572f, 0.01377049f, 0.23781399f, 0.17971742f, -0.09620734f, 
    0.06134746f, -0.06079212f, 0.00234337f, -0.25415570f, -0.10952141f, 0.09839828f, 0.41388899f, 0.21230710f, 
    -0.07059732f, 0.12283482f, 0.06760822f, 0.13189410f, 0.05689505f, 0.31904435f, 0.00593553f, 0.02051687f, 
    0.05479443f, 0.00682186f, 0.13034946f, 0.29521096f, 0.11007462f, -0.05323599f, -0.18744445f, -0.15032803f, 
    0.19492957f, -0.04055744f, 0.44283125f, 0.08594283f, -0.31136867f, 0.02935987f, -0.10426269f, -0.23472263f, 
    -0.00830385f, -0.09387535f, 0.05706321f, -0.22370209f, -0.01286302f, 0.09508296f, -0.12262345f, -0.03616989f, 
    -0.11492292f, 0.56467116f, 0.01450083f, -0.34371310f, 0.30813229f, 0.05008557f, 0.01585187f, 0.02413788f, 
    -0.07238311f, 0.12346236f, -0.13916706f, 0.01574742f, 0.00023747f, -0.08248475f, -0.34763655f, 0.15131040f, 
    0.05468073f, 0.05366037f, -0.06026142f, -0.16429679f, -0.14205208f, 0.06408651f, -0.01297917f, -0.06755311f, 
    -0.46818218f, -0.29132399f, 0.27592024f, -0.13015866f, 0.10382019f, 0.09045997f, 0.08897656f, -0.08651313f, 
    -0.05120154f, -0.03077368f, 0.21173872f, -0.09674834f, 0.00009023f, -0.05120374f, 0.20957404f, 0.46739367f, 
    0.06081681f, -0.00634521f, 0.02973174f, 0.15776977f, 0.02822142f, 0.04448486f, -0.09229790f, 0.29344377f, 
    0.29115310f, -0.22130382f, 0.28902301f, 0.14652546f, 0.11814915f, 0.04963890f, 0.04214667f, -0.02791684f, 
    0.05749371f, 0.04210320f, -0.01606998f, 0.03383690f, -0.02743194f, -0.04953845f, 0.01565696f, 0.14103988f, 
    -0.05417005f, -0.05769828f, 0.00676885f, -0.02402784f, -0.12948951f, 0.22339259f, 0.31142217f, 0.05113683f, 
    -0.05763073f, -0.14000426f, -0.08953607f, 0.14874254f, 0.11962880f, -0.16340442f, 0.10385051f, 0.06517985f, 
    0.03324043f, 0.13879332f, 0.08454138f, 0.08902259f, -0.28656635f, 0.07874509f, -0.09672283f, -0.14358431f, 
    0.05843628f, -0.07468584f, -0.10211668f, 0.24084377f, -0.02554126f, 0.06333345f, -0.20187290f, -0.01887938f, 
    0.00283643f, 0.24706289f, -0.12957209f, 0.15844291f, -0.04771448f, -0.00452075f, 0.06613791f, -0.14478415f, 
    0.13787229f, 0.04534771f, -0.06638255f, 0.00064858f, 0.00220901f, -0.00039840f, 0.46982062f, -0.55116624f, 
    0.14135827f, -0.03206865f, -0.04549178f, -0.07490713f, -0.03447554f, -0.00276813f, -0.00955979f, 0.05943339f, 
    0.24996203f, -0.02830214f, -0.22771984f, -0.01941283f, -0.20287880f, -0.09025886f, 0.17053914f, 0.07436576f, 
    0.15344630f, 0.13968898f, -0.01330943f, 0.13723436f, -0.36670223f, -0.02986074f, -0.27392569f, -0.59508377f, 
    0.06437980f, -0.01209661f, -0.20044287f, 0.06056818f, -0.00324376f, -0.09409994f, 0.04434094f, -0.02119821f, 
    0.18511203f, -0.08231039f, 0.02704541f, 0.21829802f, -0.26725426f, 0.21364918f, 0.20082389f, 0.07090218f, 
    -0.06228611f, 0.02713983f, 0.06916550f, 0.12842032f, 0.07240160f, 0.11285048f, 0.19763437f, -0.06961975f, 
    -0.05812831f, -0.11246278f, 0.00879467f, 0.12851986f, 0.24747264f, 0.07061126f, -0.08970373f, 0.00030012f, 
    0.12916416f, 0.10786048f, 0.02674992f, -0.04903326f, -0.03356589f, 0.07917802f, 0.10714008f, -0.14140828f, 
    -0.04023727f, -0.02986766f, -0.08928950f, 0.09878346f, -0.21788785f, -0.08254687f, -0.04376212f, -0.11698931f, 
    -0.02113935f, 0.00488758f, 0.22693767f, 0.19175227f, 0.11597466f, 0.00656886f, 0.22027656f, -0.09499909f, 
    0.08523818f, 0.61342496f, 0.35519254f, -0.13694358f, 0.25060439f, 0.06586460f, 0.14174943f, 0.00088653f, 
    -0.01740858f, 0.14794429f, 0.17619231f, -0.00761848f, -0.23487604f, 0.00337998f, -0.12890843f, -0.00298469f, 
    -0.12271781f, 0.04795456f, 0.10469765f, 0.10093822f, 0.10668390f, -0.01194619f, -0.06473565f, 0.24746685f, 
    0.62102681f, -0.31294271f, 0.41988575f, 0.01915516f, 0.17188071f, -0.02422788f, 0.16503939f, 0.25277334f, 
    -0.17887415f, 0.11526868f, -0.01016658f, 0.24517664f, 0.13483956f, -0.05330791f, 0.23177513f, -0.14486513f, 
    0.20314428f, 0.04732693f, -0.04548634f, -0.01145457f, -0.03013133f, 0.19491573f, 0.05790555f, -0.08578308f, 
    0.10848624f, 0.20076422f, 0.18273616f, 0.45156401f, -0.00160554f, -0.07031522f, 0.02003282f, 0.10982342f, 
    -0.15594187f, -0.08843396f, 0.47758663f, 0.15284672f, -0.70999533f, -0.22089374f, 0.16885599f, 0.08641396f, 
    0.02551473f, -0.00228465f, -0.04022620f, 0.13083315f, 0.03532463f, 0.00444555f, 0.00588080f, -0.23855194f, 
    -0.80807090f, -0.24220142f, 0.09531082f, 0.54348898f, 0.15699761f, 0.04910506f, -0.10093287f, 0.06881332f, 
    0.00884947f, 0.21577694f, 0.00923451f, 0.10838123f, 0.23932381f, -0.20565438f, -0.05640326f, -0.15293978f, 
    0.33572972f, 0.12412498f, -0.04058217f, -0.04650411f, 0.12304685f, -0.00458704f, 0.31611925f, 0.29715076f, 
    0.18802388f, 0.45553771f, -0.26364499f, 0.06614884f, -0.22319672f, -0.06469674f, 0.06064356f, 0.07115404f, 
    0.09384476f, 0.09764893f, 0.18796207f, 0.12508829f, -0.59877515f, -0.41809911f, -0.14878865f, -0.34748319f, 
    -0.10815405f, -0.17496720f, 0.04015740f, -0.00450916f, 0.07016864f, 0.00850185f, 0.14649251f, 0.04038042f, 
    -0.16547322f, -0.47508538f, 0.18438500f, -0.05172764f, 0.05352450f, 0.11031260f, 0.03107180f, -0.09675218f, 
    -0.02159849f, 0.03541047f, -0.25435126f, -0.15062523f, -0.16547842f, 0.27937832f, -0.40091807f, -0.20618561f, 
    0.18993720f, 0.05161009f, 0.15961827f, -0.05412130f, -0.14648236f, 0.01254668f, 0.08115088f, 0.08593938f, 
    0.40789324f, 0.18511835f, 0.10415906f, 0.07281999f, 0.03144574f, -0.08401426f, 0.06170217f, 0.13244991f, 
    0.20055756f, -0.08537678f, 0.02432722f, -0.16590755f, 0.19700681f, 0.07656151f, -0.17410883f, 0.15873641f, 
    0.01961260f, 0.11857180f, 0.07855802f, 0.03334067f, 0.00359378f, 0.08213014f, 0.12768424f, 0.30034816f, 
    0.22724478f, -0.23633391f, -0.48857287f, 0.04300854f, -0.12283504f, 0.08313492f, 0.04400178f, -0.09361786f, 
    -0.06669213f, 0.14702642f, -0.07187731f, -0.05879145f, -0.10174186f, 0.61535633f, 0.08209658f, 0.24602874f, 
    -0.02994768f, -0.07361987f, 0.03738061f, 0.22536811f, -0.01199786f, 0.02246770f, -0.18756820f, -0.23997766f, 
    0.24350952f, -0.34037781f, 0.23454031f, 0.00412917f, 0.00785126f, 0.01155473f, 0.06894410f, -0.00931736f, 
    0.20133311f, 0.03740757f, 0.03587585f, 0.00072997f, 0.31712255f, 0.24338666f, 0.26923749f, 0.27018422f, 
    -0.04109917f, -0.09691986f, 0.08708380f, 0.11111428f, -0.09795012f, -0.09890836f, -0.01593005f, -0.02834174f, 
    0.30032685f, 0.16283901f, -0.03523662f, 0.22491799f, -0.10274088f, -0.05458124f, -0.18304448f, 0.06352445f, 
    0.14673203f, 0.11823419f, 0.04638008f, -0.12242821f, 0.26589406f, -0.07408909f, -0.24624385f, -0.17845331f, 
    -0.05522138f, 0.04256994f, -0.04990791f, -0.12130807f, 0.01321590f, -0.16084953f, 0.17280404f, 0.05510094f, 
    -0.35550433f, 0.01418538f, 0.00754334f, 0.17627093f, 0.07036649f, 0.05375041f, 0.07325137f, 0.00887369f, 
    0.24867897f, 0.03966156f, 0.11240455f, 0.04920489f, -0.28214347f, -0.10769189f, 0.16395378f, -0.49845749f, 
    0.17338756f, 0.26607722f, -0.05360256f, -0.06741866f, 0.00962031f, 0.05050476f, -0.07252047f, 0.13289897f, 
    0.45579246f, -0.19700851f, 0.09569637f, -0.12748620f, 0.06700784f, 0.15053734f, 0.13275199f, -0.02001983f, 
    -0.11680306f, 0.06278695f, -0.01435322f, -0.02028772f, -0.15331438f, -0.10901333f, 0.04810562f, -0.28090525f, 
    0.06193028f, -0.03432051f, -0.08021090f, -0.02678841f, 0.05720062f, -0.04411931f, -0.21548600f, 0.13827771f, 
    0.02415922f, -0.08726246f, 0.37301886f, 0.10246591f, 0.25745216f, -0.06531253f, 0.03603919f, -0.06029656f, 
    0.16512939f, -0.02185952f, 0.00217924f, -0.07430538f, -0.34602043f, 0.10966975f, -0.35421598f, -0.35033306f, 
    0.27103245f, -0.01803401f, -0.05080060f, -0.14510895f, -0.05096324f, 0.02731732f, -0.00636701f, 0.20452115f, 
    -0.00052312f, -0.01233340f, 0.02081053f, 0.02083226f, 0.01862991f, 0.00475867f, 0.02027253f, 0.02383545f, 
    0.04409260f, 0.03802522f, -0.06803833f, -0.08124651f, -0.01596654f, 0.01868192f, 0.03961495f, 0.01332937f, 
    0.02743194f, -0.03551278f, 0.00043786f, 0.04987270f, 0.03962692f, 0.05668350f, -0.00960783f, -0.05650163f, 
    -0.07599042f, -0.04949031f, -0.06161162f, -0.03411622f, -0.07403816f, 0.03670643f, -0.01329412f, -0.07581972f, 
    -0.05484989f, -0.00975108f, -0.03511254f, 0.04254241f, -0.02955319f, 0.04014704f, -0.03278105f, 0.03942480f, 
    -0.00077789f, 0.04054994f, 0.04159882f, 0.06102165f, -0.00352493f, -0.06854194f, -0.05032903f, 0.01641944f, 
    -0.04221655f, 0.00869966f, -0.06247511f, 0.02885337f, -0.05328144f, -0.01215534f, 0.03794644f, 0.00229564f, 
    -0.03627959f, 0.05121997f, 0.06021609f, -0.07029409f, 0.03831184f, -0.00976089f, -0.04046239f, 0.02593020f, 
    -0.03961531f, -0.07982450f, -0.02120654f, 0.05773311f, -0.01423083f, -0.05937929f, 0.04309669f, -0.06321523f, 
    0.06926513f, 0.04424521f, 0.02297683f, -0.04954363f, -0.03871969f, -0.07645164f, -0.04654496f, 0.00077409f, 
    0.03984594f, -0.05798249f, 0.03519880f, -0.01625416f, 0.03178141f, 0.01251649f, 0.06862568f, 0.01063448f, 
    -0.07671603f, -0.06156030f, -0.05805941f, -0.05511769f, 0.02373810f, 0.04445062f, 0.04014632f, -0.06228393f, 
    -0.07326218f, 0.01479137f, 0.03084455f, -0.00874564f, -0.06802596f, 0.01196145f, 0.03012965f, -0.03751756f, 
    0.01774283f, 0.01731031f, -0.05098173f, -0.03886096f, -0.04091160f, -0.03942712f, -0.03226020f, -0.07869244f, 
    0.01387576f, 0.00030141f, -0.07413393f, -0.07507818f, 0.03124225f, 0.00058213f, 0.02707727f, 0.00276097f, 
    0.01713809f, 0.04886392f, -0.04660516f, -0.04603454f, -0.02053439f, 0.04873962f, -0.06865009f, 0.00459986f, 
    0.03852611f, 0.00135864f, 0.05316839f, 0.02458445f, -0.05282445f, -0.03241012f, 0.04409993f, -0.06889782f, 
    -0.03773205f, -0.00600482f, 0.02788859f, 0.02697671f, -0.08351987f, -0.00664510f, 0.03310121f, -0.05271178f, 
    -0.03648956f, 0.01729931f, 0.01346312f, 0.04803628f, -0.05430068f, -0.05234725f, 0.01224426f, -0.03301675f, 
    -0.05292570f, -0.07971853f, -0.06232732f, 0.06112497f, 0.05193172f, 0.06012667f, -0.04500053f, -0.06961280f, 
    -0.05787379f, -0.00460456f, 0.04723616f, -0.00295932f, -0.01236844f, -0.01174082f, -0.02123171f, 0.03536709f, 
    -0.01099110f, 0.00927494f, -0.00879076f, -0.00463883f, -0.00128998f, 0.02862045f, 0.05316416f, 0.03462243f, 
    0.03651731f, -0.00559272f, 0.01242188f, -0.02462467f, 0.02610859f, 0.05289998f, -0.04670051f, 0.01590590f, 
    0.00883827f, 0.00124925f, -0.02257394f, -0.06230590f, -0.01526464f, -0.02465081f, 0.03161708f, -0.06624483f, 
    0.98393101f, 0.16176145f, -0.18055531f, 0.27110708f, 0.06409220f, -0.12456139f, 0.02503010f, -0.03375321f, 
    0.17525555f, -0.14274292f, -0.20052913f, -0.07015012f, 0.20909676f, 0.05661093f, -0.23095515f, -0.07805587f, 
    -0.01660380f, -0.27354765f, -0.00527353f, 0.03484436f, 0.12511136f, 0.21890292f, -0.14793560f, -0.03402419f, 
    0.10221010f, -0.14318371f, 0.12056884f, 0.09894162f, -0.17699496f, -0.06047677f, -0.12860402f, -0.02437922f, 
    0.08145607f, 0.19944194f, -0.17188822f, 0.04576388f, -0.20537047f, 0.07246209f, -0.14115530f, 0.00243983f, 
    -0.09991191f, 0.10449124f, -0.17707688f, 0.15669344f, 0.09201343f, -0.09014908f, 0.12033538f, 0.08422639f, 
    -0.30896521f, 0.15677805f, -0.01461623f, -0.27030218f, -0.28460112f, 0.11903390f, 0.18061030f, 0.11322767f, 
    0.05610105f, 0.00395957f, -0.16322529f, -0.12727861f, -0.04290171f, -0.33850184f, -0.25919136f, 0.18593337f, 
    0.18002854f, 0.05992589f, 0.35697657f, 0.27288204f, 0.00033960f, 0.01885537f, 0.02321878f, 0.07409236f, 
    -0.06549817f, 0.00739558f, -0.28725925f, 0.08768197f, -0.01272324f, 0.19983275f, 0.17816171f, -0.00941142f, 
    0.08630136f, 0.09118043f, 0.13387433f, -0.08081053f, 0.18444507f, -0.27708015f, 0.28128198f, -0.13691643f, 
    -0.10803442f, -0.16737071f, 0.21248408f, 0.14543138f, 0.01401519f, 0.01168355f, 0.10206490f, 0.02254747f, 
    -0.07843831f, 0.41109750f, -0.19015203f, -0.02223716f, 0.00867377f, 0.19208732f, -0.01186803f, 0.06382672f, 
    0.14435415f, -0.03447595f, 0.05346720f, -0.10405773f, -0.09340495f, 0.16871947f, -0.06707515f, -0.05844919f, 
    -0.07109273f, 0.09939747f, -0.05494402f, -0.21934038f, 0.25731188f, 0.17365594f, 0.09901933f, -0.19198957f, 
    -0.16214573f, -0.09974062f, 0.02639060f, -0.05009193f, -0.08869416f, -0.19022016f, -0.02617781f, 0.06923437f, 
    0.09357743f, -0.12669320f, 0.33670971f, 0.08300980f, -0.19065568f, -0.08746099f, -0.03044363f, -0.15961839f, 
    -0.08446669f, -0.09425995f, -0.11456371f, -0.06179285f, 0.13991439f, -0.01629632f, -0.12673897f, 0.03351517f, 
    0.05407501f, 0.15353249f, 0.27488345f, 0.07820226f, -0.09211718f, -0.02529925f, -0.08397415f, -0.03353591f, 
    0.13132007f, 0.06685673f, -0.07038055f, -0.02910681f, 0.31776100f, 0.12767735f, -0.11767840f, -0.13484359f, 
    0.12830180f, 0.16238385f, 0.02469503f, -0.11316059f, -0.04312922f, -0.01376068f, 0.19378896f, 0.26494101f, 
    0.23663203f, -0.19752015f, 0.03411343f, -0.41435322f, 0.04714577f, 0.01885746f, 0.03096208f, 0.17629753f, 
    -0.08256254f, 0.02321871f, 0.03986544f, -0.07998957f, 0.00320103f, 0.02450358f, -0.55642492f, 0.14615768f, 
    0.02004623f, -0.01318699f, -0.10582790f, 0.20973685f, 0.06640314f, 0.21357843f, 0.12139034f, 0.09946600f, 
    0.03319570f, 0.04179672f, -0.02182938f, -0.01472157f, 0.02326064f, -0.04836685f, -0.04511460f, -0.07473762f, 
    -0.01775880f, -0.01821356f, -0.00698992f, 0.06392123f, -0.01810316f, 0.00808818f, -0.06480369f, 0.00433340f, 
    0.04890739f, -0.00762808f, -0.04035498f, 0.05685727f, -0.07108122f, -0.08264747f, 0.02282906f, -0.03940076f, 
    0.01580008f, -0.00176867f, 0.05206542f, -0.03311107f, 0.04866263f, -0.05941183f, 0.01808373f, -0.00823889f, 
    0.04295485f, 0.01403309f, -0.05069686f, 0.03865602f, -0.06755843f, -0.00343649f, -0.06321699f, 0.02898939f, 
    0.04389645f, 0.02399746f, -0.01322017f, -0.03103183f, -0.07300098f, 0.03824604f, 0.01110957f, 0.01396160f, 
    -0.02099890f, -0.08135088f, -0.02555170f, -0.05558204f, 0.05386128f, 0.05511594f, 0.05228254f, 0.00612184f, 
    -0.03578717f, 0.05347481f, -0.01764628f, 0.00628832f, -0.00701106f, 0.03507293f, -0.06590072f, 0.01126446f, 
    0.05016149f, 0.05011688f, -0.08212330f, -0.07627547f, -0.05664571f, 0.05893337f, 0.04893672f, -0.05916855f, 
    -0.06967953f, -0.07305890f, 0.02610695f, 0.02147203f, 0.03834730f, 0.03829409f, -0.04756112f, -0.02020670f, 
    -0.04812935f, -0.01721164f, 0.04770895f, 0.05161183f, -0.05861550f, -0.01781601f, -0.04801925f, 0.04318706f, 
    0.05663720f, 0.02109886f, -0.04679165f, -0.02383395f, 0.05960904f, -0.02670993f, 0.06651060f, 0.01820433f, 
    -0.07395757f, 0.04321520f, -0.06996667f, -0.04720199f, 0.05801719f, 0.03189404f, 0.01755501f, -0.03291029f, 
    0.00345606f, 0.03289877f, -0.04125293f, 0.01048295f, 0.03640530f, 0.01629984f, -0.00881896f, -0.00223591f, 
    0.05023917f, -0.03030574f, 0.03261052f, 0.00388307f, 0.05521000f, 0.01903675f, 0.02478652f, 0.00766454f, 
    -0.03719660f, 0.00173908f, -0.07336430f, -0.03869798f, 0.01001048f, 0.01883763f, 0.00141837f, -0.01671650f, 
    -0.03634036f, -0.01032747f, -0.07009632f, -0.06590385f, -0.03216948f, -0.07014857f, -0.02909859f, 0.00822036f, 
    -0.01617470f, 0.05984209f, 0.00772030f, -0.06177892f, -0.06072721f, -0.02132125f, -0.05753904f, -0.01609190f, 
    0.03609932f, -0.03883632f, -0.07351428f, -0.05258737f, 0.00111243f, 0.01455713f, 0.02144891f, 0.03039582f, 
    0.00610433f, -0.03936574f, 0.05893134f, 0.03142078f, -0.06007564f, -0.01756237f, -0.03888763f, -0.00393722f, 
    -0.07994862f, -0.05111575f, -0.00873947f, 0.05475871f, -0.03940615f, -0.04579726f, 0.01084019f, 0.05420341f, 
    0.05619935f, 0.04806522f, -0.01975289f, -0.03985516f, 0.06705204f, -0.07055179f, -0.05915596f, -0.04862092f, 
    -0.07674659f, 0.03813623f, 0.00219856f, -0.04004359f, 0.03932046f, 0.00313281f, -0.06463295f, -0.06122756f, 
    -0.03777457f, -0.03817988f, -0.07903159f, -0.02935236f, -0.02320375f, -0.01581404f, -0.06245018f, -0.01199530f, 
    -0.00369146f, 0.06217812f, -0.06060984f, -0.06460427f, -0.03730174f, -0.00177101f, -0.02600448f, 0.04526061f, 
    -0.03098894f, -0.06220124f, -0.07975604f, -0.03378185f, -0.04727352f, -0.00424501f, 0.00703976f, -0.04875517f, 
    0.03862956f, -0.06938807f, -0.00565789f, 0.00468196f, 0.05842558f, -0.07204476f, -0.05738114f, 0.04252242f, 
    -0.05516993f, 0.05125147f, -0.00506334f, 0.01236017f, 0.05456036f, -0.03960911f, 0.04892410f, -0.01927903f, 
    0.02286154f, -0.02017737f, 0.02272323f, 0.00063367f, 0.04492147f, -0.05367167f, 0.04375337f, 0.05970369f, 
    -0.02423770f, 0.01565066f, -0.06305405f, -0.01299993f, 0.06090048f, -0.03418205f, 0.05414396f, -0.04506702f, 
    0.01353925f, -0.01761112f, 0.04384873f, 0.03078368f, -0.01871450f, -0.00213046f, -0.02506994f, -0.06785975f, 
    -0.06272145f, -0.07309939f, 0.03743680f, 0.05167843f, -0.02182777f, 0.02730255f, -0.02199576f, -0.05186784f, 
    0.01406030f, -0.07012790f, 0.03888397f, -0.08245287f, 0.05476837f, 0.03991224f, -0.05707197f, 0.00243653f, 
    0.00318080f, 0.00256951f, -0.05182027f, -0.02329933f, 0.00924444f, 0.04995913f, 0.01682896f, 0.05885844f, 
    -0.07324488f, 0.03911411f, 0.05466802f, 0.03550288f, -0.01423752f, -0.00145212f, -0.02802270f, -0.06089335f, 
    0.06631997f, 0.03183659f, 0.05061698f, 0.05127651f, 0.04869370f, 0.01012009f, -0.05793815f, -0.02676028f, 
    -0.01359929f, -0.00526055f, -0.03938238f, -0.06018062f, 0.04631675f, -0.00032013f, 0.05454998f, 0.02217168f, 
    0.00541210f, -0.02272871f, -0.05378517f, 0.03456491f, -0.05473322f, 0.05114425f, -0.00746013f, -0.00898540f, 
    0.02601154f, -0.01199172f, -0.06720064f, -0.03223548f, 0.00392284f, -0.07180052f, -0.02755706f, -0.01112903f, 
    0.02202447f, 0.00282148f, 0.01579686f, -0.04377262f, -0.05318516f, -0.07331835f, -0.06179344f, 0.02622965f, 
    -0.03680375f, 0.00530283f, -0.07100397f, -0.05723848f, 0.04724507f, -0.01396543f, 0.02956980f, -0.01736082f, 
    0.02341200f, 0.03812817f, 0.00418600f, -0.07853918f, -0.03721458f, 0.01185668f, -0.05196313f, -0.01080742f, 
    0.05785319f, 0.02042307f, 0.02186394f, -0.06257854f, 0.02077588f, 0.00462575f, 0.04717652f, -0.08437243f, 
    -0.05242890f, -0.05499449f, 0.03317301f, -0.06110200f, 0.02052563f, 0.02263989f, 0.05309500f, -0.02130226f, 
    0.06237865f, 0.03593900f, -0.01676999f, -0.03169197f, -0.05674325f, 0.03720023f, -0.02735328f, 0.02744819f, 
    -0.07636530f, -0.06312392f, 0.01096509f, -0.01685862f, -0.00880615f, 0.05371284f, 0.01662632f, -0.04082213f, 
    -0.03384562f, 0.01773368f, -0.06691208f, -0.01204900f, 0.03663332f, -0.05158050f, -0.07181876f, -0.04762701f, 
    -0.07871283f, -0.06896149f, 0.03671917f, 0.04026503f, -0.03903648f, 0.00812334f, -0.01142714f, -0.00539610f, 
    0.04160761f, -0.04441025f, 0.21791133f, 0.19539648f, 0.00506554f, 0.07754066f, 0.01724149f, -0.09868383f, 
    0.15071954f, 0.12903661f, -0.18041390f, 0.08977395f, 0.20317434f, 0.44561249f, -0.15376171f, -0.65068942f, 
    0.19121531f, -0.07010735f, -0.08370854f, 0.13327521f, -0.02016344f, 0.08883774f, -0.07271263f, -0.03212031f, 
    -0.01259249f, -0.19877185f, 0.27647287f, 0.25725991f, 0.06082487f, -0.02359423f, -0.17707662f, -0.01776180f, 
    -0.08190836f, 0.10216849f, -0.05665274f, 0.08939320f, 0.25997889f, 0.00327219f, -0.20594051f, 0.19849084f, 
    -0.04314151f, 0.03099471f, -0.08959394f, -0.01316479f, -0.01448806f, -0.19668430f, -0.07355288f, -0.22508025f, 
    -0.06242372f, -0.25397775f, -0.05840045f, -0.09763908f, -0.01065990f, -0.02668858f, 0.19747210f, -0.11034845f, 
    -0.16601177f, -0.25973776f, -0.22358796f, -0.02910325f, -0.54800403f, -0.00713281f, 0.00990056f, 0.35053241f, 
    0.11767669f, -0.12018530f, 0.38544628f, 0.29410231f, -0.00642170f, 0.02300614f, 0.07740454f, -0.02427640f, 
    0.21842234f, -0.10741881f, 0.06609349f, -0.07141594f, 0.02542602f, 0.23220016f, 0.13855207f, 0.06499934f, 
    -0.10535034f, 0.13331950f, 0.18340997f, -0.28239790f, -0.04964721f, -0.34628800f, 0.12704413f, 0.57817602f, 
    0.07901854f, -0.11761941f, 0.17881058f, 0.22415793f, 0.02149700f, -0.11566924f, 0.31187660f, 0.25652173f, 
    0.37101218f, 0.09068272f, -0.09124866f, -0.28594446f, 0.09864216f, 0.16302367f, -0.18373957f, 0.12666656f, 
    -0.08712984f, -0.03029239f, 0.01199599f, 0.02875436f, 0.07757185f, -0.20867625f, -0.15029524f, -0.17168574f, 
    -0.22352059f, 0.02276315f, -0.10779722f, -0.20637910f, 0.05263039f, 0.01952882f, 0.13809004f, -0.10105924f, 
    -0.16403878f, 0.12552483f, -0.19453108f, 0.06665983f, 0.05362759f, -0.04468742f, -0.06823315f, -0.01031092f, 
    -0.07840963f, -0.02801322f, 0.44124597f, 0.08078794f, -0.35246953f, 0.17687251f, 0.30915147f, -0.03834689f, 
    0.04020554f, 0.11629143f, -0.02819852f, -0.00080443f, 0.10716826f, -0.06773856f, -0.07397919f, -0.27292693f, 
    -0.20358758f, -0.25114718f, 0.50358129f, 0.12321035f, 0.00906067f, 0.07996747f, 0.11284263f, 0.00741743f, 
    0.03552656f, 0.04582322f, -0.12513694f, -0.11828020f, 0.39525843f, 0.00498071f, 0.11612935f, -0.25896436f, 
    0.20566940f, 0.01852995f, -0.02366240f, 0.17431593f, 0.00322472f, 0.01792656f, 0.25859755f, 0.31728986f, 
    0.07632494f, 0.28235766f, 0.23067968f, -0.06473687f, 0.13365412f, -0.02466997f, 0.02981004f, 0.14032124f, 
    -0.02869869f, 0.19392288f, 0.05877097f, -0.29004246f, -0.09446861f, 0.16638155f, -0.12104863f, -0.18614754f, 
    0.16006756f, 0.03551609f, 0.07427961f, 0.07093047f, -0.09015524f, 0.18548498f, 0.08940517f, -0.00246219f, 
    0.53438377f, 0.52087730f, -0.16722633f, 0.16369376f, 0.02021465f, 0.00725627f, 0.14993817f, 0.00684520f, 
    -0.17476906f, -0.06563589f, 0.05129898f, -0.23340511f, -0.22284620f, -0.32902071f, -0.15958884f, -0.03749632f, 
    0.36680683f, 0.06109863f, -0.08167331f, -0.14903480f, 0.00810966f, -0.13550271f, 0.02866207f, -0.19175203f, 
    -0.02154718f, 0.29047775f, 0.39638129f, 0.38048381f, -0.01440508f, -0.00997814f, 0.04274599f, 0.13633101f, 
    -0.09776049f, -0.13111787f, -0.03747874f, -0.19610327f, -0.19759831f, -0.11146103f, 0.12983064f, 0.03000543f, 
    0.02912294f, -0.05294277f, -0.03869211f, 0.10863007f, -0.23844700f, -0.08936635f, -0.10315590f, -0.00804625f, 
    0.39248484f, 0.40787151f, 0.19465432f, -0.05362881f, 0.09264562f, -0.09001498f, -0.12771998f, 0.03275758f, 
    0.13336326f, -0.04184574f, -0.02432039f, -0.02993239f, 0.08160935f, -0.01788763f, -0.15948734f, 0.14708073f, 
    0.04447337f, 0.01143450f, 0.12262436f, 0.11932429f, 0.04303579f, 0.14482144f, -0.01937053f, 0.04290247f, 
    0.19199958f, 0.31567320f, 0.39558300f, -0.10636362f, 0.07950000f, 0.23334269f, -0.07243121f, 0.12702835f, 
    -0.07004333f, 0.05364574f, -0.01647304f, 0.16462775f, -0.04163408f, 0.13255879f, 0.23991378f, 0.38978761f, 
    -0.05428907f, -0.10113779f, 0.23618233f, 0.13688853f, -0.02802728f, -0.04930290f, 0.03003335f, 0.02625731f, 
    -0.10738517f, -0.09475382f, 0.13724279f, 0.04262129f, -0.14984372f, -0.21951275f, -0.05762133f, 0.16399507f, 
    -0.08969487f, 0.03985973f, 0.00173706f, 0.09655775f, 0.17639425f, -0.02394369f, -0.02376225f, 0.13477191f, 
    -0.05720684f, 0.03369743f, 0.14353797f, -0.03647220f, -0.16709755f, -0.12919638f, -0.17802368f, -0.12424982f, 
    0.34046784f, -0.06515091f, -0.06188336f, 0.38424805f, -0.23012061f, 0.15862696f, -0.04352418f, -0.09592448f, 
    -0.08051722f, 0.03921879f, 0.10755532f, -0.10012351f, 0.13027252f, -0.15559751f, -0.39948148f, 0.17150438f, 
    0.00300023f, -0.15406311f, 0.08651527f, -0.02680906f, -0.08413722f, -0.06737770f, -0.09557270f, 0.08794531f, 
    0.11730085f, -0.14217447f, -0.16520956f, -0.32317051f, -0.11970593f, -0.01027332f, 0.02104471f, -0.03943957f, 
    0.01277280f, -0.13651954f, -0.06102690f, 0.18616876f, -0.15290825f, 0.02474353f, -0.18960218f, -0.50006407f, 
    -0.21946652f, -0.12621604f, 0.00319504f, 0.11583745f, 0.22153696f, 0.13983677f, 0.08046787f, 0.25600091f, 
    0.32392207f, 0.23850836f, 0.19222660f, 0.30312836f, 0.21405122f, -0.11836005f, 0.20971595f, 0.06847256f, 
    -0.03624884f, -0.01878990f, -0.01847845f, -0.21747226f, 0.05269345f, -0.55129433f, -0.15100037f, -0.61693954f, 
    0.07332800f, -0.07160028f, -0.16902980f, -0.00829333f, 0.18208246f, -0.02482403f, 0.09700805f, -0.10337389f, 
    0.02247145f, 0.03217833f, -0.07275487f, -0.04672345f, 0.03452266f, -0.04019725f, -0.07732505f, -0.04161051f, 
    -0.06153420f, 0.04196822f, 0.01100875f, 0.03230304f, 0.04618136f, 0.04567602f, 0.06340966f, -0.03851181f, 
    -0.05934389f, -0.05360803f, 0.06440805f, -0.04730170f, 0.03131466f, -0.00711269f, -0.02154474f, -0.04759319f, 
    0.00763095f, 0.04888401f, -0.05509965f, 0.01837630f, -0.02074926f, -0.00785792f, -0.06505439f, -0.06141209f, 
    -0.03210239f, 0.03461473f, 0.02282275f, 0.04073913f, 0.05324152f, -0.05650845f, 0.05535663f, -0.01381905f, 
    -0.02154555f, 0.01124593f, -0.02080177f, -0.01610103f, 0.03988934f, -0.06912731f, -0.03936326f, 0.00654910f, 
    -0.03297757f, 0.05518873f, -0.04243802f, 0.00412682f, 0.02537117f, 0.04769745f, -0.03988178f, -0.04925228f, 
    -0.01919105f, 0.02694459f, -0.00996698f, 0.04988056f, -0.02772394f, -0.03658440f, -0.06640137f, 0.03233625f, 
    -0.03782829f, 0.03325222f, 0.05875403f, 0.06292158f, 0.04682544f, -0.05421053f, -0.00888030f, -0.03239323f, 
    -0.01007047f, -0.03678653f, -0.04364916f, -0.04038583f, -0.02994337f, -0.05788593f, -0.05298847f, -0.02472767f, 
    -0.06395115f, -0.01287748f, -0.06123875f, -0.03041441f, -0.05141173f, 0.01335416f, 0.03839658f, -0.04545307f, 
    0.06094033f, 0.03927857f, 0.03781883f, -0.05536573f, 0.02749931f, -0.00334918f, -0.04824508f, 0.05466442f, 
    0.06729826f, 0.00657046f, 0.03451991f, 0.04176810f, -0.05506558f, 0.04798583f, 0.04912454f, 0.06660975f, 
    -0.05688835f, -0.05291390f, -0.00124523f, 0.05664985f, 0.03821464f, 0.05343913f, -0.02145664f, -0.04064887f, 
    -0.07376830f, -0.04123624f, 0.02456089f, -0.06584720f, -0.01747154f, -0.03957664f, -0.04963691f, -0.05296609f, 
    -0.05566371f, 0.00981843f, -0.00056696f, 0.04622192f, 0.04876600f, 0.05857680f, -0.04995196f, -0.03373355f, 
    -0.00274170f, -0.02742867f, -0.06810962f, 0.06176435f, -0.03700101f, -0.05072809f, 0.01446633f, 0.00344842f, 
    -0.04402510f, 0.05304929f, 0.03408966f, 0.03746671f, 0.04137111f, -0.05650928f, -0.05379579f, -0.00288892f, 
    -0.07712357f, 0.05547519f, -0.00738583f, 0.03848565f, -0.04272569f, -0.06145657f, -0.02160608f, 0.01021357f, 
    0.01373125f, -0.03895603f, -0.04608167f, 0.05423668f, -0.05897345f, 0.07290457f, -0.04374815f, 0.04381473f, 
    0.00661266f, -0.03983824f, 0.05091370f, -0.06423427f, -0.04644852f, -0.03347163f, 0.02156839f, -0.00896717f, 
    0.00196617f, 0.02828729f, 0.05893714f, -0.04332530f, 0.03541049f, -0.05182337f, -0.06978184f, -0.00830091f, 
    0.03863145f, -0.02525781f, -0.01812278f, 0.01064475f, -0.02781613f, 0.06141750f, 0.03803125f, 0.03608624f, 
    -0.03960737f, -0.01848257f, -0.02438554f, -0.01777169f, -0.07250369f, 0.00059534f, 0.05578005f, -0.05466251f, 
    0.01590491f, -0.01668849f, 0.04896093f, -0.06561941f, -0.05184445f, 0.06635001f, -0.05765803f, 0.00943280f, 
    -0.01430828f, -0.06071365f, 0.00630370f, 0.01689488f, -0.08033702f, 0.03340577f, -0.06373138f, 0.00835150f, 
    0.04114498f, 0.02285666f, -0.08641839f, 0.01098594f, 0.01610689f, 0.02036479f, -0.05498426f, 0.02069402f, 
    0.05930843f, -0.01182002f, 0.01973836f, -0.03124523f, -0.07397281f, 0.00032575f, 0.05710200f, 0.03163832f, 
    -0.05348837f, -0.04641524f, -0.05838953f, -0.05655956f, 0.04067165f, 0.04928276f, 0.03601588f, -0.02958229f, 
    -0.03148055f, -0.00333725f, -0.08122821f, 0.02695577f, 0.00537795f, -0.03090356f, 0.05478980f, 0.02820365f, 
    0.00242476f, 0.02669871f, 0.04619621f, 0.02053440f, 0.02761479f, -0.06676858f, 0.04617226f, 0.02929865f, 
    0.01398933f, -0.08035801f, -0.00695462f, -0.00029285f, 0.01848599f, 0.01311057f, -0.00561962f, -0.07683541f, 
    -0.02541125f, -0.00397712f, 0.05974190f, -0.02231759f, -0.03128841f, -0.00422276f, -0.03886416f, -0.01667323f, 
    -0.06466004f, 0.01972914f, 0.01241213f, -0.06363311f, -0.08054955f, -0.04834944f, -0.04433801f, -0.01482546f, 
    0.02801066f, -0.01426750f, 0.04540954f, -0.07349095f, -0.07659407f, 0.00606891f, 0.05072643f, -0.05272181f, 
    -0.04602122f, -0.08504584f, -0.02748811f, 0.01336975f, -0.02226216f, -0.00568029f, -0.03381994f, -0.02319903f, 
    -0.03976375f, -0.07612734f, 0.05048959f, -0.02668737f, 0.00238558f, -0.01863147f, -0.04358088f, 0.01247976f, 
    -0.00139722f, 0.00276611f, -0.04952708f, 0.03814360f, -0.01315420f, 0.04765197f, 0.04637296f, -0.03606920f, 
    0.05623572f, -0.01512266f, -0.07584012f, -0.02062576f, 0.04494667f, 0.02975503f, 0.03064753f, 0.04655505f, 
    -0.02469937f, 0.03061194f, -0.06298638f, -0.05918369f, 0.04186479f, 0.00224958f, 0.03533486f, -0.05567936f, 
    -0.08006686f, 0.05393419f, 0.06161151f, -0.01477112f, 0.04611871f, -0.04343582f, -0.06758405f, -0.07539218f, 
    0.03186872f, 0.05428170f, 0.04780036f, 0.00057794f, -0.05986007f, 0.04279687f, 0.02825661f, -0.01315684f, 
    0.05079523f, -0.03423909f, -0.02704216f, -0.02785023f, -0.03004889f, -0.03525634f, -0.04559649f, -0.04835384f, 
    -0.04665474f, 0.00342860f, 0.01958078f, 0.02756178f, -0.02448010f, -0.00227246f, 0.01353232f, -0.09052002f, 
    -0.05598160f, -0.01970736f, -0.00110916f, -0.01338849f, 0.05018774f, 0.00146918f, -0.00273627f, -0.01158528f, 
    -0.03311595f, 0.03971100f, 0.04303823f, 0.04401015f, -0.04251970f, -0.01692619f, 0.05353142f, 0.04736508f, 
    0.02442256f, -0.04764517f, -0.01511143f, 0.00007045f, -0.00412744f, -0.06150969f, -0.02531037f, -0.06544118f, 
    -0.00755856f, 0.00232997f, -0.08678529f, -0.04033461f, -0.01806673f, 0.00756934f, 0.05173021f, -0.07513768f, 
    0.19688922f, 0.36438856f, 0.18714397f, 0.18039486f, 0.22845137f, -0.00097647f, -0.03782253f, 0.09825394f, 
    0.06346642f, 0.01115937f, 0.24038242f, 0.06492788f, 0.38101625f, -0.03341497f, 0.12314787f, 0.24965823f, 
    -0.09062088f, -0.16653964f, 0.03937550f, 0.05648217f, 0.20059694f, 0.14800563f, -0.04377957f, 0.08549646f, 
    -0.67569464f, 0.09240078f, -0.12868436f, -0.02753533f, 0.15144961f, 0.08327248f, -0.00663820f, -0.08596463f, 
    -0.01152817f, 0.00681744f, -0.09138351f, -0.09767902f, -0.30080035f, -0.11694112f, -0.07638805f, -0.03420736f, 
    -0.05103438f, -0.00459571f, -0.05089730f, -0.12239873f, -0.01584038f, 0.12338629f, 0.06333498f, 0.04196832f, 
    -0.21248083f, 0.02695804f, 0.15150997f, 0.36288819f, -0.15679923f, -0.10738416f, 0.07927128f, 0.33922774f, 
    0.17279898f, -0.01741524f, 0.30155280f, -0.16878179f, -0.01918280f, -0.23122929f, -0.12837780f, 0.02720588f, 
    0.22507696f, 0.13495962f, 0.03216814f, -0.06728590f, 0.01258911f, 0.05063100f, -0.09631047f, 0.02399014f, 
    -0.53534853f, 0.01723931f, -0.65694189f, 0.09589040f, -0.00310583f, -0.07724167f, 0.01019143f, 0.21143551f, 
    -0.09845241f, -0.02286406f, -0.09999203f, 0.18221451f, 0.19351435f, -0.27139106f, -0.07847035f, -0.20547119f, 
    0.13341571f, -0.02083328f, -0.01484139f, -0.16749759f, 0.07813789f, 0.08178951f, 0.18704700f, -0.09118652f, 
    -0.67312914f, 0.23455983f, -0.04814337f, -0.12193752f, 0.04683647f, -0.04540178f, 0.04182151f, -0.12998992f, 
    -0.05519795f, -0.09250696f, 0.05940486f, -0.09977242f, -0.31189504f, -0.02012212f, 0.16401012f, 0.13638093f, 
    -0.21727605f, -0.10813856f, 0.07582825f, 0.01857416f, 0.14713152f, 0.02223141f, -0.01136371f, 0.15658075f, 
    0.14137757f, -0.06345758f, 0.18727469f, -0.33326420f, -0.11163721f, -0.01892780f, -0.07494185f, 0.10032929f, 
    -0.07061258f, -0.00903399f, -0.16783004f, -0.08826356f, 0.65446401f, 0.14225903f, -0.01843739f, 0.09001751f, 
    -0.12767757f, -0.10513800f, -0.01200922f, 0.01501581f, -0.04781338f, 0.10308174f, 0.05410568f, 0.17882301f, 
    0.54268700f, 0.26162228f, -0.03007795f, -0.27831027f, 0.05919947f, -0.18478258f, -0.05942167f, -0.03317674f, 
    0.23073621f, 0.14217269f, 0.08137831f, 0.06139500f, -0.34236440f, 0.30304840f, -0.01980919f, 0.16139193f, 
    -0.16418648f, -0.06329274f, 0.05555204f, 0.15692616f, -0.32190031f, -0.03565809f, -0.23570344f, 0.00872718f, 
    0.10697804f, -0.18458830f, -0.13713007f, -0.06454929f, 0.03608100f, 0.11760990f, 0.14884913f, 0.19227393f, 
    -0.18529686f, -0.09195599f, -0.13429922f, 0.04001158f, 0.52815330f, 0.21996625f, 0.22275761f, 0.34477082f, 
    0.03896721f, 0.15964873f, -0.18405825f, 0.13903412f, 0.09825087f, 0.08156058f, -0.09769724f, 0.03313521f, 
    -0.00167396f, 0.38959038f, 0.19552645f, 0.17699262f, -0.00787600f, -0.16187853f, -0.12145875f, 0.28429395f, 
    -0.19523716f, -0.09620262f, 0.08600455f, -0.03928203f, -0.19939122f, 0.05188494f, 0.18587866f, 0.27297866f, 
    0.01265462f, 0.06694944f, -0.03310596f, 0.01620662f, -0.05486630f, 0.00805599f, -0.10877080f, -0.08586261f, 
    0.03782349f, 0.17145208f, 0.00315751f, 0.05649667f, 0.10146552f, -0.16440636f, 0.17256120f, -0.07507078f, 
    0.02532374f, 0.14111479f, 0.09506799f, 0.08756423f, 0.27774227f, 0.27471626f, -0.18355677f, -0.22927025f, 
    0.00918342f, -0.07219651f, -0.10464703f, -0.20643759f, -0.07447406f, -0.03305507f, 0.10676508f, -0.13057959f, 
    0.26257449f, -0.09508049f, 0.12044951f, -0.39326337f, 0.05453587f, -0.01277743f, 0.08829101f, 0.13973446f, 
    0.24656695f, 0.04839983f, 0.05393350f, -0.09498092f, 0.67362916f, -0.37202492f, 0.19382572f, 0.23178416f, 
    -0.05606606f, 0.14284906f, -0.20169930f, -0.01989513f, -0.00345840f, -0.02703732f, 0.20379744f, 0.05671223f, 
    0.13093680f, -0.43739274f, 0.05108005f, 0.11438449f, -0.30442980f, -0.02377840f, 0.02715181f, 0.02833600f, 
    -0.08518728f, -0.09011345f, 0.00312428f, 0.27067468f, -0.11916626f, 0.24102202f, 0.16784960f, 0.00133357f, 
    -0.02024597f, 0.06169356f, -0.07891406f, -0.01678374f, 0.08584206f, 0.01281099f, -0.07171965f, 0.04203442f, 
    -0.11066977f, 0.18853740f, -0.12560022f, -0.09255100f, -0.09036230f, 0.01186581f, 0.06584460f, -0.02706621f, 
    -0.10318635f, -0.02825371f, 0.01292448f, 0.19846535f, -0.35387352f, -0.18203965f, -0.02463767f, -0.45597318f, 
    0.23458523f, 0.07439450f, 0.09721054f, -0.01391260f, 0.14507626f, 0.26138055f, -0.02043988f, 0.00810393f, 
    0.21272774f, -0.00834263f, -0.22518001f, -0.21405379f, -0.15874255f, 0.13446322f, -0.32872164f, 0.17960119f, 
    -0.09881306f, -0.05849218f, -0.14942689f, -0.15146039f, -0.15113725f, -0.37951005f, 0.04011443f, 0.26618570f, 
    0.16518980f, -0.11455164f, 0.10586613f, 0.19703330f, 0.05130229f, -0.03048156f, 0.02606062f, 0.05502099f, 
    -0.28949043f, -0.03354133f, -0.25204986f, 0.12943450f, 0.15161140f, 0.05894599f, 0.00108343f, -0.02212289f, 
    0.22993518f, -0.05311488f, -0.01333847f, 0.03732781f, 0.33305660f, 0.22301060f, -0.06772131f, 0.10456391f, 
    -0.03671898f, 0.08764976f, 0.00981470f, -0.01622378f, 0.09710468f, -0.08728094f, -0.04802194f, -0.17491172f, 
    -0.09794836f, 0.45546553f, 0.37465772f, 0.10127670f, -0.12318999f, 0.06564112f, 0.02088033f, 0.16760764f, 
    0.03306847f, 0.00305863f, 0.11777993f, 0.14949749f, 0.66180682f, 0.01434863f, -0.10206926f, 0.70106471f, 
    -0.09691642f, 0.03537669f, -0.04915489f, 0.14563036f, 0.05087237f, 0.02991833f, -0.06293256f, 0.04279918f, 
    0.52099138f, 0.13169421f, -0.12509085f, 0.16740356f, 0.17729501f, -0.20585269f, -0.02258893f, -0.04032206f, 
    -0.06361174f, -0.24623252f, -0.05248355f, -0.07025836f, 0.06419078f, -0.33879474f, 0.14223622f, 0.60916644f, 
    -0.17166656f, -0.03885791f, 0.04412074f, -0.06679972f, 0.07573909f, 0.13582955f, 0.00583026f, -0.08816689f, 
    0.32997021f, 0.30219576f, 0.46917018f, -0.27838269f, 0.08410219f, -0.09865258f, -0.01923307f, 0.19501801f, 
    0.07044410f, 0.06176012f, -0.00106813f, 0.11797322f, -0.34856421f, 0.14807783f, 0.03053486f, -0.19591288f, 
    0.10056780f, -0.07589894f, 0.01358708f, 0.11581896f, 0.02170358f, -0.06095451f, 0.16962668f, 0.03431287f, 
    -0.02192844f, 0.22822261f, 0.44753864f, 0.03909820f, -0.03955354f, -0.01082528f, -0.16626677f, 0.16023690f, 
    0.26023155f, 0.01635823f, -0.21306999f, 0.06184739f, 0.19770810f, 0.06006023f, -0.17535976f, 0.04766811f, 
    -0.04069416f, 0.24776202f, 0.03654887f, -0.17451362f, -0.00430564f, 0.08917127f, -0.11298762f, -0.04588484f, 
    0.18813463f, -0.13222785f, -0.03469277f, 0.28302425f, -0.04964371f, 0.02948481f, -0.14101489f, -0.01932543f, 
    0.02616765f, -0.03710336f, -0.07347696f, 0.06359950f, 0.18074377f, 0.14168324f, 0.13300471f, -0.37191245f, 
    0.02784809f, 0.05047701f, 0.23310944f, 0.16670878f, 0.14370009f, 0.07272350f, 0.01910310f, -0.06742500f, 
    -0.29469022f, 0.29875275f, -0.21633077f, 0.26773956f, -0.06476665f, 0.01448060f, 0.00977996f, -0.06185358f, 
    0.13677756f, 0.01820725f, 0.06043807f, -0.31762931f, -0.37732771f, 0.13243303f, 0.13577604f, 0.20941316f, 
    0.07215982f, -0.03659619f, -0.01824721f, -0.23724326f, -0.07171907f, -0.05338993f, 0.06840379f, -0.27193362f, 
    -0.20072128f, 0.03586234f, 0.24494505f, -0.10996056f, -0.19371510f, 0.00572745f, 0.22673921f, -0.11476962f, 
    0.14290103f, 0.03291225f, -0.00890090f, 0.01463490f, 0.01481906f, -0.09956180f, -0.22153334f, -0.02215891f, 
    -0.08923661f, -0.09123348f, 0.07611728f, 0.07028664f, 0.10223224f, -0.08294542f, -0.19923727f, 0.17676732f, 
    -0.03700060f, 0.07617668f, -0.15126894f, -0.29254031f, -0.12561214f, 0.10247150f, -0.01274662f, 0.05895118f, 
    0.13748001f, -0.02678541f, -0.08926265f, -0.11027471f, -0.25015584f, 0.35050818f, -0.16832258f, 0.08708312f, 
    -0.22484966f, 0.06647640f, 0.19390523f, -0.04355887f, 0.01230134f, 0.11611465f, 0.13215666f, 0.04121655f, 
    -0.02996010f, -0.03556008f, 0.22034898f, 0.00017225f, -0.11537880f, 0.09350211f, 0.02065918f, -0.00308866f, 
    0.00538915f, 0.00525737f, -0.00885201f, 0.04704248f, 0.43732166f, 0.03395130f, -0.12650907f, 0.27536738f, 
    -0.16213028f, 0.15270951f, -0.03703398f, 0.11978024f, 0.08960683f, -0.00646340f, 0.06553003f, -0.05788226f, 
    -0.01674532f, -0.04400358f, -0.04863292f, -0.07027210f, 0.02325276f, 0.03934151f, -0.06258339f, 0.00920841f, 
    0.02989754f, 0.06495553f, 0.02329211f, 0.01712521f, 0.02665738f, -0.06302658f, -0.03804597f, 0.05172908f, 
    0.06521937f, 0.01898672f, 0.00481003f, -0.04228748f, -0.00492871f, 0.04031168f, -0.06449530f, -0.06354128f, 
    -0.06278405f, -0.06229702f, -0.03728877f, 0.02068241f, -0.00124271f, -0.02629616f, -0.00433878f, -0.03859548f, 
    0.03895422f, 0.02392271f, -0.06734032f, 0.01459165f, -0.04735156f, 0.06399224f, -0.06517542f, 0.03616572f, 
    -0.04932284f, -0.01381861f, 0.03658593f, -0.00753380f, 0.03542320f, -0.01982245f, 0.02520230f, -0.05341933f, 
    -0.00206624f, 0.02619833f, -0.00062712f, -0.06080459f, -0.07250019f, -0.04399408f, -0.00754392f, -0.03357911f, 
    0.04306921f, 0.03694363f, 0.04620241f, -0.04462211f, 0.01214536f, -0.01984709f, 0.01906336f, -0.03744373f, 
    -0.02527181f, -0.00469868f, -0.06937540f, -0.00407944f, -0.01819213f, -0.03245148f, 0.00563715f, -0.05209910f, 
    -0.05966747f, 0.04491843f, -0.02404165f, -0.05099774f, 0.01454269f, -0.04717540f, -0.05723073f, 0.05018615f, 
    0.04216529f, 0.05492267f, 0.01783837f, 0.00047831f, 0.05963129f, -0.03302180f, 0.03578866f, 0.05144377f, 
    0.06364242f, -0.06233863f, -0.05786581f, -0.05153449f, -0.05287801f, -0.04414043f, -0.07246726f, -0.00437461f, 
    -0.07078256f, -0.05581507f, -0.00075253f, 0.04506788f, 0.03394207f, 0.04041328f, 0.01266368f, 0.04396231f, 
    -0.01030430f, 0.01965428f, -0.02996019f, -0.04458572f, -0.05760648f, -0.01285910f, -0.01778077f, -0.01417943f, 
    -0.02566028f, 0.06387853f, 0.02577712f, 0.01594920f, 0.01658691f, 0.03472237f, 0.00985993f, 0.02664547f, 
    0.03463513f, -0.05476230f, 0.05670966f, 0.00200293f, -0.06731383f, -0.01783543f, -0.07239717f, -0.04878483f, 
    0.04391140f, -0.02317855f, 0.01630722f, -0.07308150f, -0.00334228f, 0.03120495f, 0.04674296f, -0.05368048f, 
    0.05144590f, -0.02126690f, -0.04429608f, -0.01119165f, -0.03450073f, -0.06591291f, -0.04262323f, -0.05907376f, 
    0.05505626f, -0.05935715f, 0.00889858f, -0.04979924f, -0.02027130f, 0.02827587f, 0.02239828f, 0.01134364f, 
    -0.02647612f, -0.01794454f, -0.06446789f, -0.07514902f, 0.06075040f, -0.05153802f, -0.04875463f, -0.05184628f, 
    -0.03929073f, -0.01299732f, -0.05851383f, 0.00656300f, 0.02617676f, 0.01412230f, 0.03714864f, -0.06763540f, 
    -0.01813971f, -0.05090202f, 0.00360417f, -0.00284297f, 0.05768150f, -0.01146189f, 0.00322872f, -0.06072043f, 
    -0.02759911f, -0.03112896f, 0.00974980f, -0.03593549f, 0.04828286f, -0.01397295f, 0.06117167f, -0.06756204f, 
    0.01034531f, -0.02105586f, -0.04862610f, 0.02163865f, 0.01929983f, -0.01101219f, -0.07400128f, -0.06235751f, 
    -0.18412545f, -0.06115692f, 0.03524013f, -0.12757207f, 0.25534514f, -0.00159774f, -0.06209096f, -0.05426003f, 
    0.21772951f, 0.11162888f, 0.15320469f, 0.02193551f, 0.45631534f, -0.12193357f, 0.12252860f, 0.36140701f, 
    -0.02211194f, -0.01790859f, 0.02354792f, 0.04826406f, 0.10006651f, -0.02734042f, 0.13800986f, 0.01271295f, 
    -0.12786140f, 0.01370543f, 0.06442507f, -0.34831750f, -0.00295490f, 0.12351886f, -0.19083850f, -0.00834996f, 
    -0.00040532f, -0.02352202f, -0.09069431f, 0.33508164f, -0.31649220f, -0.32544428f, 0.11432544f, -0.06256539f, 
    0.13438907f, -0.02659085f, 0.21287879f, 0.07126599f, 0.03091303f, -0.18878894f, -0.10186782f, 0.04881836f, 
    -0.50074947f, 0.24263626f, 0.19031547f, 0.34603736f, 0.00308590f, -0.04578444f, 0.07973596f, 0.05398675f, 
    0.02220944f, -0.08989281f, -0.04042255f, 0.29628339f, 0.00750610f, 0.14877273f, 0.02496420f, -0.05072987f, 
    0.18690772f, 0.00074187f, 0.05611245f, -0.26672369f, -0.01402816f, -0.06797171f, 0.20585868f, 0.00710499f, 
    -0.58087718f, 0.19007793f, -0.17496054f, 0.22714289f, 0.00034022f, -0.22701940f, -0.00234699f, -0.08019749f, 
    0.06183035f, 0.08948173f, 0.06365261f, -0.12073536f, 0.17644483f, -0.11441663f, -0.04955358f, -0.28635547f, 
    0.11048021f, 0.20317377f, -0.02245335f, 0.06430654f, 0.07097301f, 0.08742960f, 0.06847112f, 0.05846373f, 
    0.12840569f, -0.07078320f, 0.09433119f, -0.03756128f, 0.05667777f, -0.12089723f, 0.09383458f, 0.09006456f, 
    -0.00254693f, -0.06083494f, -0.08927776f, 0.13120772f, -0.08488480f, 0.08390370f, 0.25767320f, 0.09256794f, 
    -0.08357231f, -0.06712139f, -0.02047798f, 0.03643755f, 0.00998929f, -0.13773571f, -0.04252872f, 0.06089366f, 
    -0.09087972f, 0.20322892f, 0.09029961f, -0.33513162f, 0.03552205f, -0.01294420f, 0.09904151f, 0.11449703f, 
    0.00225366f, 0.08601722f, 0.03033471f, 0.13040705f, 0.71482593f, 0.35506907f, -0.20748553f, 0.01159618f, 
    -0.11692140f, -0.06369040f, 0.06900683f, 0.10335913f, 0.18108962f, -0.03266679f, 0.02695978f, 0.01959297f, 
    0.18183327f, 0.23872925f, -0.19877465f, 0.02361860f, -0.04846423f, -0.08024777f, -0.25406754f, -0.07915021f, 
    -0.00897614f, 0.09085362f, 0.11744788f, -0.22352588f, -0.26405343f, -0.20969214f, 0.17132764f, 0.41159120f, 
    -0.17066681f, 0.04053998f, 0.16604102f, -0.05291935f, -0.01754708f, -0.07356731f, 0.11928624f, -0.04150678f, 
    0.01624927f, -0.15871033f, -0.27173346f, -0.09032647f, 0.02694593f, 0.20687574f, 0.07328752f, 0.03667546f, 
    -0.18700193f, -0.15906239f, 0.00033844f, 0.09736609f, 0.32563803f, -0.01348410f, 0.02448629f, 0.32611671f, 
    -0.12462230f, 0.04895566f, 0.11485606f, -0.05053582f, -0.00731868f, 0.10190482f, 0.17501593f, -0.04661337f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00973915f, 0.00904244f, -0.06553695f, 0.06607872f, 0.04176125f, -0.03259520f, -0.02496733f, -0.12189102f, 
    0.00119264f, -0.17588218f, -0.07975272f, 0.15274264f, 0.01222014f, -0.06782269f, -0.02329675f, 0.00316263f, 
    0.14856686f, 0.24127579f, -0.03818373f, -0.05432750f, 0.15336537f, -0.02418287f, -0.05898117f, 0.06376887f, 
    0.04215581f, -0.05247856f, 0.01334682f, 0.05191475f, 0.06522167f, -0.06064248f, -0.07007015f, -0.04509445f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03022482f, -0.03015937f, 0.00761649f, -0.41905293f, 0.13698305f, 0.07379114f, 0.03495012f, 0.44817412f, 
    0.08760380f, 0.01957102f, -0.16839123f, -0.59833181f, -0.06423332f, 0.11229736f, 0.08628234f, 0.44389528f, 
    -0.40329841f, -0.34672761f, 0.00246501f, -0.11774468f, 0.37446731f, -0.04240177f, 0.13969144f, -0.37835222f, 
    -1.00846946f, -0.04761967f, -0.03662891f, 0.21678109f, -0.06985451f, 0.50272995f, -0.03526079f, 0.44329953f, 
    0.06166498f, -0.02267941f, 0.25067303f, 0.30183762f, -0.09542609f, 0.10553332f, -0.40498286f, 0.27221560f, 
    -0.39871949f, -0.30641621f, 0.08302362f, 0.02872330f, 0.30782011f, -0.10331152f, -0.06444351f, 0.06367265f, 
    -0.23479725f, -0.49930665f, -0.56297404f, -0.10508594f, 0.14643890f, -0.12080777f, 0.02673080f, -0.56948680f, 
    0.43707284f, 0.10875208f, -0.03399929f, 0.43966344f, 0.45373857f, 0.19832271f, 0.08448932f, 0.04272765f, 
    0.03327496f, -0.14660907f, 0.26679006f, 0.16184767f, 0.38898408f, 0.09012464f, -0.92350012f, -0.10878649f, 
    -0.64560181f, 0.11630604f, 0.29589751f, -0.23244177f, 0.04003734f, 0.13100937f, 0.00961414f, 0.33594230f, 
    -0.58031005f, -0.41809753f, 0.49996489f, 0.07749036f, 0.29602122f, -0.00900401f, 0.00080127f, 0.39185792f, 
    0.16796619f, -0.15843232f, 0.13780665f, -0.48540998f, 0.09355509f, 0.15355803f, -0.13196912f, -0.47667521f, 
    0.16675417f, -0.04576536f, -0.41870993f, -0.17113151f, 0.17489401f, -0.12256542f, 0.21324721f, -0.75297445f, 
    0.40234384f, -0.39818442f, 0.10312641f, 0.22270183f, -0.50596040f, -0.17017886f, 0.12487032f, 0.19210954f, 
    0.14129475f, 0.39041400f, -0.67870814f, -0.10670210f, -0.04336632f, -0.15279743f, -0.05047890f, -0.71190840f, 
    0.28676909f, -0.16618775f, -0.05984724f, -0.57336706f, 0.02571998f, 0.34827444f, 0.15557462f, 0.12321971f, 
    0.00436652f, -0.11596576f, -0.57171875f, -0.06107365f, 0.02408505f, 0.01996377f, 0.33288023f, -0.56623518f, 
    0.13728520f, 0.17860310f, -0.91091549f, 0.16480425f, 0.39643234f, -0.07083753f, -0.09455221f, -0.08760902f, 
    0.08741501f, -0.04765515f, -0.29614803f, -0.14778918f, 0.13276115f, -0.09865349f, 0.06392117f, 0.48751625f, 
    0.11504707f, 0.11413421f, 0.14458090f, 0.32570228f, 0.16942319f, -0.04603218f, -0.17064422f, 0.08103367f, 
    -0.05142093f, 0.03085658f, 0.15515436f, 0.01918667f, -0.28941357f, 0.13739413f, 0.54188442f, 0.31754786f, 
    0.01841069f, 0.26609328f, -0.03881808f, 0.26006705f, 0.38372332f, -0.16143671f, 0.14437118f, 0.11325511f, 
    0.33246857f, -0.38968164f, 0.17006484f, 0.05668738f, -0.88004225f, 0.11542647f, 0.04266163f, -0.55468267f, 
    -0.30869853f, 0.17958984f, 0.06072281f, 0.18446581f, -0.39860275f, -0.25022915f, -0.08007552f, 0.20655978f, 
    -0.08598037f, -0.07846742f, 0.52844638f, 0.19324352f, -0.45978239f, -0.15989007f, -0.62967885f, -0.14653035f, 
    0.19283831f, 0.38579765f, 0.28241542f, -0.22897936f, -0.00156697f, -0.01541186f, -0.15538400f, 0.26751211f, 
    0.04638696f, 0.37999445f, -0.48692274f, -0.09571890f, -0.14665510f, -0.15721293f, 0.13140744f, 0.36909968f, 
    -1.21759796f, 0.14211205f, 0.07336698f, -0.23766325f, -0.02780481f, -0.67506540f, 0.01918517f, 0.03518643f, 
    0.15347911f, 0.04529925f, 0.06344245f, -0.40108696f, -0.28792965f, 0.12642859f, 0.32216650f, 0.13524012f, 
    0.12105964f, 0.55982798f, -0.01473479f, -0.67536610f, -0.50031346f, 0.08617669f, 0.06407958f, -0.69303226f, 
    0.24830781f, 0.05256251f, 0.28278577f, 0.03779593f, -0.41451958f, 0.01804341f, 0.13183512f, 0.05192196f, 
    0.34882584f, -0.08186188f, -0.00786412f, -0.20709895f, 0.20995238f, 0.32458234f, -0.13480163f, -0.56497985f, 
    0.16251090f, 0.08041903f, -0.42000622f, 0.23600961f, 0.58386612f, -0.00971217f, -0.34679323f, 0.53410369f, 
    -0.37174866f, 0.31375825f, -0.32775831f, 0.25652307f, -0.54781973f, -0.13144974f, 0.03881319f, -0.57630193f, 
    -0.06988476f, -0.14159711f, 0.31281650f, -0.14412443f, -0.59782064f, -0.09847294f, -0.11006715f, -0.37291336f, 
    -0.32627207f, 0.02428756f, -0.12433186f, -0.06698509f, 0.37374371f, -0.29829726f, 0.11270851f, 0.16352144f, 
    -0.04933121f, -0.01856570f, -0.48383754f, 0.21789692f, -0.54055083f, 0.09662066f, 0.30532718f, 0.48221728f, 
    0.32776710f, -0.39088517f, 0.34883142f, -0.04046886f, 0.26614714f, 0.04293083f, -0.13707666f, -0.25615036f, 
    -0.68347555f, 0.16016781f, 0.43865222f, 0.15412664f, 0.22164457f, -0.10464900f, 0.12756132f, 0.41655886f, 
    -0.11415319f, -0.12865137f, -0.01218615f, -0.35767427f, -0.12304155f, -0.45457035f, 0.04068242f, -0.05349873f, 
    0.16542882f, -0.19409733f, 0.52379608f, -0.54391021f, 0.23739779f, -0.12481156f, 0.23692606f, 0.18596649f, 
    -0.67064971f, -0.61125100f, -0.40941757f, 0.00575769f, -0.81462598f, 0.07145394f, 0.11788689f, 0.11573724f, 
    0.31530342f, 0.45114526f, 0.25478894f, 0.12437987f, 0.31550977f, -0.11056469f, -0.00592578f, -0.15165477f, 
    0.20999855f, 0.08713602f, -0.09245420f, -0.43862543f, 0.12511359f, 0.01756961f, 0.09333520f, -0.90885061f, 
    0.03800927f, 0.01289087f, 0.06950409f, 0.26434928f, -0.14993434f, -0.11665307f, -0.52242374f, -0.08147922f, 
    0.24475078f, -0.02835307f, 0.53135180f, 0.26058760f, -0.98223776f, -0.13647270f, -0.07367890f, -0.31185049f, 
    0.32215482f, -0.12095761f, -0.06325004f, -0.16132389f, 0.52701187f, -0.08702681f, 0.10254178f, 0.04674179f, 
    0.21663639f, -0.09952161f, 0.00159447f, 0.45102039f, -0.82972604f, -0.07692340f, 0.12875536f, 0.11551997f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05068273f, -0.00375311f, -0.04758272f, -0.04706332f, 0.14568782f, 0.10292971f, -0.15288374f, -0.32374373f, 
    0.09811452f, -0.15107217f, 0.14950195f, -0.06356311f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
