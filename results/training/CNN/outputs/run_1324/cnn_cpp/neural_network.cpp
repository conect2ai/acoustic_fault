#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11265706f, -0.14644092f, -0.65986854f, -0.18568522f, 0.68928993f, 0.32528087f, 0.28876087f, -0.44410920f, 
    -0.45473289f, 0.05785269f, 0.01059372f, -0.05446780f, 0.13942584f, 0.07674482f, -0.28364602f, -0.42150557f, 
    0.19317314f, -0.02814094f, -0.00173483f, 0.00512456f, 0.32805520f, 0.15623890f, -0.03654261f, 0.17822200f, 
    -0.03277270f, -0.54589635f, 0.04086959f, -0.26569712f, -0.49849457f, -0.59091043f, -0.29839447f, -0.01780285f, 
    0.49201807f, -0.01707239f, 0.03129703f, -0.35210451f, -0.39586514f, -0.14621647f, -0.36219802f, -0.14202859f, 
    0.40370899f, 0.04579929f, -0.02595903f, -0.04820137f, -0.20286947f, -0.25078025f, -0.20853429f, -0.43728179f, 
    -0.29662350f, -0.60082734f, -0.69526577f, -0.44080338f, -0.27889401f, -0.55313784f, -0.48944280f, 0.46986860f, 
    -0.21546726f, -0.25876063f, -0.01035724f, -0.02576697f, -0.32625699f, -0.25626704f, -0.05527284f, -0.03495946f, 
    -0.17130537f, 0.30817291f, 0.08411361f, 0.18693048f, 0.02965135f, 0.04316072f, 0.01590127f, 0.32200068f, 
    0.20485944f, -0.12421271f, -0.03547368f, -0.92059469f, -0.42926490f, -0.75411606f, -0.30352205f, 0.26051077f, 
    0.16399384f, 0.06213235f, 0.27438098f, 0.43612880f, 0.69101518f, 0.34498256f, -0.01196199f, -0.27005392f, 
    -0.16317467f, 0.28298265f, -0.12342475f, -0.06659115f, 0.02998915f, -0.06633805f, -0.27367595f, 0.03757357f, 
    0.05628884f, 0.27543056f, -0.05767351f, 0.22438128f, 0.52855217f, -0.01801278f, -0.56133366f, -0.58799571f, 
    -0.55890965f, -0.22793907f, -0.04914699f, -0.04237755f, 0.28575212f, -0.05414905f, 0.35964960f, 0.26158875f, 
    0.28784055f, -0.06406424f, 0.31347883f, 0.07936476f, -0.17825009f, -0.22581701f, -0.25034842f, -0.23982987f, 
    -0.19937083f, -0.12998155f, -0.02074148f, 0.16051136f, -0.16538119f, -0.89210838f, -0.36330754f, 0.03320296f, 
    0.30588546f, -0.06251511f, -0.54592437f, -0.33301464f, -0.08736350f, 0.41401756f, 0.67176735f, -0.18044280f, 
    -0.09285067f, -0.05708017f, -0.22212231f, 0.59335667f, -0.09789070f, -0.04513748f, 0.03691709f, 0.33804390f, 
    -0.02854399f, -0.06469154f, -0.32303643f, -0.18810885f, -0.01044866f, -0.18995814f, 0.26870656f, -0.73539424f, 
    0.19166937f, 0.30075964f, 0.43688267f, 0.10035694f, 0.42169341f, 0.10965246f, -0.29122764f, -0.02892826f, 
    0.13952535f, -0.31929904f, -0.08759278f, -0.11519793f, 0.11671134f, -0.06364332f, -0.09077428f, 0.09506266f, 
    0.07720079f, -0.29088023f, 0.25342095f, -0.24147430f, -0.24966745f, -0.17990293f, -0.16981350f, 0.93447471f, 
    -1.03962362f, -0.86951536f, -0.35256782f, -0.21388978f, 0.50566298f, 0.49345475f, 0.61016518f, 0.07585108f, 
    -0.18982252f, -0.15155964f, 0.18684293f, 0.13939366f, -0.22928219f, 0.10850787f, 0.12447044f, -0.02768656f, 
    0.11398742f, -0.19760531f, -0.10404829f, 0.23682533f, -0.17898738f, -0.09576662f, 0.04163702f, 0.03147936f, 
    0.34290305f, 0.44970834f, -0.44927183f, -0.20100065f, 0.21691263f, -0.60183024f, -0.46099588f, -0.06826396f, 
    0.47735539f, 0.34195027f, -0.28899053f, -0.32809898f, -0.04773916f, 0.20255488f, 0.08074173f, 0.05101417f, 
    0.06729169f, 0.06824863f, -0.07826795f, 0.16619149f, -0.20464870f, 0.14195059f, -0.03893695f, -0.04539513f, 
    0.06045975f, -0.10322468f, -0.57160103f, 0.06376013f, 0.13329259f, -0.66834331f, -0.30365375f, -0.06427711f, 
    -0.22586828f, -0.59790844f, -0.56095159f, -0.19660054f, -0.26022807f, -0.47680816f, 0.20850632f, 0.15525605f, 
    -0.42619702f, 0.01486217f, -0.41537285f, -0.35813656f, -0.25517285f, -0.09184390f, -0.32826623f, 0.12630855f, 
    0.05053035f, 0.15360156f, 0.53457093f, 0.54284251f, 0.39761993f, 0.27186921f, -0.36471817f, -0.19215789f, 
    0.15848826f, 0.18288738f, -0.05568068f, 0.12539771f, -0.08333557f, 0.21869807f, 0.06237670f, -0.03993962f, 
    -0.11650404f, 0.06599464f, 0.17702281f, -0.15379988f, -0.01321978f, -0.14435944f, -0.05815662f, -0.08245458f, 
    0.11544828f, -0.10284739f, 0.00613050f, 0.48413455f, 0.32170239f, 0.18081655f, -0.23139824f, -0.19097622f, 
    0.13052090f, 0.38099480f, 0.12340242f, 0.25456715f, -0.05718833f, -0.22234116f, 0.32001090f, -0.28027269f, 
    0.10964528f, 0.16529877f, -0.24573453f, -0.07832101f, -0.27461898f, 0.20203340f, 0.13733558f, 0.41859326f, 
    0.03203135f, -0.23126407f, -0.25946006f, 0.35855520f, 0.57120389f, 0.62237936f, -0.10053546f, -0.40126380f, 
    0.13349229f, -0.19505306f, 0.06705064f, -0.04110092f, -0.27094635f, -0.01895759f, -0.20313466f, -0.24317750f, 
    0.04381194f, -0.34149033f, 0.36114687f, -0.17317338f, 0.09636316f, -0.05454566f, 0.03072790f, -0.09132228f, 
    -0.31638893f, -0.24237131f, -0.31901267f, -0.34530339f, -0.49750501f, 0.61681533f, -0.49243051f, 0.04934233f, 
    0.47671604f, 0.58941698f, -0.24183021f, 0.41429418f, -0.40824693f, -0.56689864f, -0.40322340f, 0.11893500f, 
    0.13485077f, 0.09306476f, -0.25110841f, -0.13351959f, -0.18181020f, -0.05821672f, 0.12020443f, -0.05474943f, 
    -0.04476998f, -0.04043946f, -0.01678412f, 0.14405878f, 0.14501365f, -0.10350380f, 0.02987083f, -0.52918416f, 
    0.23102173f, 0.73418033f, -0.01936727f, 0.10855192f, -0.25033292f, -0.38906127f, 0.27705804f, 0.05555258f, 
    -0.38362169f, 0.28822142f, 0.12042969f, -0.07299158f, -0.25885448f, -0.07707028f, 0.00637831f, -0.22195208f, 
    0.14036840f, 0.18746865f, -0.06182360f, -0.29800314f, -0.12125719f, -0.07502935f, -0.28285843f, -0.25076693f, 
    -0.19478323f, -0.37971562f, 0.18816373f, 0.08499178f, 0.12832302f, -0.43014306f, -0.58693606f, 0.01069244f, 
    -0.18961224f, -0.08376051f, 0.73845160f, -0.45285639f, 0.49935192f, -0.02158758f, -0.16031218f, 0.09014111f, 
    0.25477025f, -0.10307942f, -0.22724779f, -0.00349143f, 0.09301294f, 0.00092322f, 0.13617179f, -0.03867916f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13478868f, -0.16287753f, -0.04388314f, 0.31276044f, 0.21907690f, 0.16137947f, 0.07791370f, 0.10825320f, 
    0.39161077f, 0.27407870f, -0.05941498f, 0.35205221f, -0.16145736f, 0.33023939f, 0.16997863f, 0.00711661f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04951467f, 0.03939451f, -0.00485628f, 0.03798740f, 0.04647478f, -0.04982696f, 0.04390497f, -0.01878918f, 
    0.05013258f, 0.01548061f, 0.00501780f, -0.02970248f, 0.00591916f, -0.03204105f, -0.02358781f, 0.05093911f, 
    -0.03873104f, -0.05126760f, 0.06513035f, -0.02325639f, 0.00586113f, 0.00765956f, -0.02389633f, 0.03631499f, 
    -0.04974957f, 0.04072267f, 0.03739426f, -0.01991512f, 0.01925474f, -0.04730672f, -0.04745721f, -0.05445653f, 
    0.04219251f, -0.04549915f, -0.03490047f, -0.03588611f, 0.00685478f, -0.01957751f, -0.03385450f, -0.04829539f, 
    -0.04225978f, -0.02937911f, -0.05256292f, 0.05953351f, -0.06163690f, -0.04746705f, 0.05143606f, 0.00771464f, 
    0.05857440f, 0.04335175f, 0.01066307f, -0.05047105f, 0.02688021f, -0.04877255f, -0.00325609f, -0.02606129f, 
    0.03488428f, 0.05209103f, -0.00531917f, -0.01969310f, -0.04226555f, -0.03618989f, -0.03383311f, 0.02813846f, 
    0.03930889f, -0.07715541f, -0.02467992f, -0.07323203f, -0.03631504f, 0.01538598f, -0.05794214f, 0.02710600f, 
    -0.00442405f, 0.02104050f, 0.05790621f, -0.05423656f, 0.05990201f, -0.05269022f, 0.00021401f, -0.07034367f, 
    -0.00449084f, 0.06160304f, 0.03739083f, -0.06126742f, 0.06748080f, -0.06477883f, -0.00316870f, -0.07035954f, 
    0.00833467f, 0.00564649f, -0.07224952f, -0.02138980f, 0.01328929f, -0.05234489f, -0.01962440f, 0.02014109f, 
    -0.05608022f, -0.02366031f, -0.06474354f, -0.00977299f, 0.03808932f, -0.04543529f, -0.02002382f, 0.05268897f, 
    0.02064911f, -0.02224570f, -0.03388602f, 0.04583584f, 0.06472149f, -0.02242548f, 0.01334115f, 0.00078975f, 
    0.06354916f, -0.06955691f, 0.05349348f, -0.04120453f, 0.00670685f, -0.07476633f, -0.02300113f, -0.07034066f, 
    -0.02927093f, -0.03433929f, -0.04710170f, 0.05985047f, -0.07573411f, 0.04898706f, -0.05714169f, 0.06445879f, 
    -0.04069683f, -0.03889760f, 0.00969167f, -0.05087699f, -0.03012510f, -0.07287575f, -0.00914518f, 0.01005372f, 
    -0.02005698f, 0.01357482f, -0.00440450f, 0.01499893f, 0.02995089f, -0.07172330f, 0.03346670f, -0.02866445f, 
    0.05609209f, 0.07010750f, 0.01560944f, -0.03102495f, 0.03001692f, -0.04951412f, -0.02200479f, -0.07165925f, 
    0.03645170f, -0.00105328f, 0.01651243f, -0.04181015f, -0.01947968f, -0.02675158f, -0.05710938f, 0.05739184f, 
    0.01555384f, -0.00938930f, -0.01620996f, 0.00999774f, 0.04535161f, -0.05375763f, -0.06308374f, -0.02598711f, 
    -0.07011371f, -0.07343452f, 0.00478484f, 0.06599119f, -0.03402309f, 0.02070460f, 0.05274997f, 0.06209302f, 
    0.05638958f, -0.02648807f, -0.01760669f, -0.07761132f, -0.05599240f, -0.03823854f, -0.02266722f, 0.02953392f, 
    -0.05005208f, -0.05997545f, -0.06763277f, -0.07213299f, 0.00254411f, 0.03864415f, -0.04034721f, 0.00214040f, 
    0.04704535f, -0.07607087f, -0.02238888f, 0.09253790f, -0.03945962f, -0.03692655f, 0.29362416f, 0.33045626f, 
    -0.00685041f, -0.03417301f, 0.02612738f, 0.14301468f, -0.11246188f, 0.10256247f, 0.07186689f, -0.05682889f, 
    -0.01309038f, 0.00015887f, 0.03821736f, 0.06269510f, -0.05009613f, -0.12950809f, 0.02100062f, -0.22939283f, 
    -0.15920432f, 0.12307153f, -0.04204655f, -0.09313771f, 0.18947709f, -0.04274868f, 0.19821179f, 0.16202958f, 
    -0.13643973f, 0.00771192f, -0.07166341f, -0.10085809f, -0.46580932f, 0.17814109f, 0.11302470f, 0.01586244f, 
    -0.23196264f, 0.01454020f, 0.03515352f, 0.03691899f, 0.15860219f, -0.03252929f, 0.06311984f, 0.15465891f, 
    -0.03436447f, 0.08182206f, -0.12541430f, -0.18469582f, 0.08285220f, -0.06390275f, 0.08991332f, 0.03767564f, 
    0.09601427f, -0.04241363f, -0.01454022f, 0.11192622f, -0.03987823f, 0.10262032f, 0.05169362f, 0.06643486f, 
    0.15644263f, 0.01283457f, 0.09246702f, 0.27360013f, 0.07067838f, -0.03571873f, 0.18656604f, -0.09445515f, 
    0.14123613f, -0.09910890f, 0.09971055f, -0.07843738f, -0.15583843f, 0.03569262f, -0.12207305f, 0.08934721f, 
    -0.03900132f, -0.01035898f, 0.08714448f, -0.21112034f, 0.14703959f, -0.01374928f, -0.00128604f, -0.05428656f, 
    -0.11365655f, -0.02535989f, -0.14456233f, 0.08363286f, 0.00045377f, 0.12128413f, 0.09375253f, -0.01085575f, 
    0.32027116f, 0.21061529f, 0.13838139f, 0.12210757f, 0.15353172f, 0.11106692f, 0.14235768f, 0.20159890f, 
    0.07819009f, 0.06468002f, 0.00930563f, 0.24607784f, 0.04758954f, -0.11446259f, 0.03531940f, -0.18929158f, 
    0.13632807f, 0.17818910f, 0.19063999f, -0.04185179f, 0.17171434f, 0.01893614f, 0.04109654f, 0.07322424f, 
    -0.08905323f, 0.04766025f, 0.08464640f, -0.07039287f, -0.09576253f, -0.09901106f, -0.10937545f, -0.15298723f, 
    0.06816124f, 0.02193836f, -0.14596570f, -0.02716926f, -0.03907889f, 0.01058986f, 0.12914833f, 0.01558451f, 
    -0.12857525f, -0.14165871f, -0.09124234f, 0.01077734f, 0.06764740f, 0.02515632f, 0.02438246f, 0.24361569f, 
    -0.23609538f, -0.44871452f, -0.16239549f, -0.07502833f, 0.02484028f, 0.02854225f, -0.20167944f, -0.00214736f, 
    -0.06746459f, -0.10937071f, -0.06475912f, -0.40653813f, 0.09679333f, 0.01217450f, -0.17019461f, 0.00665241f, 
    -0.21156995f, 0.10739822f, 0.06848121f, 0.15796055f, 0.05433531f, -0.09368118f, 0.08208336f, 0.08210278f, 
    0.08015396f, 0.10790412f, -0.09705344f, 0.17941187f, -0.01909387f, -0.07713947f, -0.03482925f, -0.12541027f, 
    0.09091691f, -0.08539271f, 0.34912553f, -0.16717419f, -0.27611700f, -0.11379386f, -0.03564275f, -0.18492794f, 
    0.08478939f, 0.03257520f, 0.05897521f, -0.01328563f, -0.01872491f, -0.16348623f, 0.17500782f, 0.16656663f, 
    0.13563497f, -0.09692574f, 0.23129264f, 0.00306114f, 0.19950214f, 0.05081360f, 0.15753341f, -0.01383437f, 
    0.04084330f, 0.10513384f, -0.00231298f, -0.05288171f, -0.04401520f, -0.03017151f, 0.08070716f, 0.16415694f, 
    0.12316488f, 0.11166192f, 0.07762875f, 0.12791826f, -0.00632049f, -0.11084131f, -0.08974969f, 0.03152300f, 
    -0.06629696f, -0.17371635f, -0.04084915f, -0.06763119f, 0.04931705f, -0.00728660f, -0.02164024f, 0.12701216f, 
    0.00354281f, -0.07553010f, -0.08199960f, -0.10902886f, 0.44338432f, -0.20718670f, -0.25634676f, -0.34746808f, 
    0.04309459f, 0.04943431f, 0.02647623f, -0.09245237f, -0.03096891f, 0.01326126f, 0.12892462f, 0.10008428f, 
    -0.35078976f, -0.18775111f, -0.16008835f, 0.03191265f, -0.04321437f, 0.03223942f, -0.06763665f, 0.01817076f, 
    0.25913548f, 0.11208554f, 0.12598662f, 0.08848905f, 0.28551683f, 0.02153010f, 0.02626486f, -0.00107308f, 
    -0.11047999f, 0.08479859f, 0.02155149f, -0.09947680f, -0.06135912f, -0.07460257f, -0.05207077f, -0.00022345f, 
    0.15280066f, 0.12563071f, 0.25106955f, 0.08553988f, -0.13999301f, -0.03383578f, -0.07430111f, -0.14824846f, 
    0.02768995f, -0.00061208f, -0.02304474f, 0.00598847f, 0.34180811f, -0.06309958f, -0.01823996f, -0.02713596f, 
    -0.00513602f, -0.13254784f, 0.02584097f, -0.11447631f, 0.09712400f, 0.12905489f, -0.04671950f, 0.12093673f, 
    -0.29855090f, 0.09158957f, 0.09817860f, -0.12407155f, -0.00129401f, -0.10591455f, 0.12366837f, -0.18354398f, 
    0.06108924f, -0.00747861f, -0.11953221f, 0.01278688f, -0.17026262f, 0.04088237f, 0.04919643f, 0.11655673f, 
    0.06769488f, 0.15311541f, 0.03428812f, 0.03775739f, -0.14286925f, -0.05111266f, 0.10319788f, -0.01327930f, 
    0.08155514f, 0.10003304f, -0.03265120f, -0.02520473f, -0.09903436f, -0.12424593f, -0.11358777f, -0.08827956f, 
    0.17524183f, -0.01187986f, -0.08886650f, 0.05739134f, 0.17640415f, 0.21282865f, -0.02707171f, -0.00480215f, 
    -0.09334271f, -0.10412586f, 0.01273973f, -0.02786936f, 0.12271672f, 0.09945844f, -0.11525867f, 0.00660291f, 
    0.01069035f, -0.03334610f, 0.07621642f, 0.03503157f, -0.04658928f, -0.16447747f, 0.02766566f, -0.02269278f, 
    0.08329397f, 0.01073677f, -0.08584453f, -0.01149145f, -0.00149224f, 0.16890849f, 0.11582311f, -0.16112676f, 
    0.02391985f, -0.08856918f, 0.14858218f, -0.05856100f, -0.02776269f, 0.01418829f, 0.10281546f, -0.05425993f, 
    -0.02166892f, 0.26455775f, 0.02816420f, -0.20400241f, -0.01043324f, -0.00284275f, -0.02769994f, 0.02774071f, 
    -0.04712458f, 0.03246295f, -0.10322099f, 0.01048590f, -0.11474380f, -0.30121478f, -0.04464579f, -0.15078312f, 
    0.08936564f, -0.12840861f, 0.00224854f, 0.22235744f, -0.01436622f, 0.05593754f, 0.13030918f, -0.17225203f, 
    0.00699038f, 0.00952859f, 0.07142955f, -0.19778430f, -0.08884180f, 0.09093879f, 0.02562103f, 0.07754627f, 
    0.04827556f, -0.00870668f, 0.11571970f, 0.17516884f, -0.11675660f, -0.11993951f, -0.24779852f, -0.07992969f, 
    0.06965692f, -0.09871477f, 0.15918559f, -0.00628829f, -0.01302844f, -0.06793274f, 0.13219444f, -0.08374197f, 
    -0.10207503f, -0.23261470f, -0.19772376f, -0.07174356f, 0.02769159f, -0.00481124f, 0.03542361f, -0.00711016f, 
    -0.00541875f, -0.02983101f, -0.06273567f, 0.15198433f, -0.01403704f, -0.33953434f, -0.01763881f, 0.09345517f, 
    0.14215170f, -0.03372158f, 0.07746898f, -0.08509956f, 0.09289589f, 0.05773789f, 0.14016716f, 0.09781299f, 
    0.01484907f, 0.09005488f, 0.09296517f, 0.08317969f, 0.04121528f, 0.00373765f, -0.06561629f, 0.02098235f, 
    -0.06324077f, 0.04244078f, 0.17381461f, -0.14969514f, 0.46886784f, -0.38100952f, 0.07461204f, -0.04118297f, 
    0.23770724f, -0.03868108f, 0.03264087f, 0.06331863f, 0.16110049f, -0.08640394f, 0.06073080f, 0.05115916f, 
    -0.08340091f, 0.19570157f, 0.02135015f, -0.06461615f, -0.03199723f, -0.01916824f, 0.03019006f, 0.00491180f, 
    0.03655665f, 0.17127152f, 0.16845655f, -0.08541481f, -0.50785339f, -0.08392146f, 0.08354760f, 0.04008746f, 
    0.13414308f, 0.07094376f, 0.06912342f, 0.01501613f, 0.02952544f, 0.07002544f, 0.08968678f, 0.08892308f, 
    0.27532777f, -0.15995808f, 0.11983853f, -0.03740129f, 0.20691015f, -0.03152724f, 0.03714995f, 0.08954176f, 
    -0.00583532f, -0.05427926f, -0.00784444f, 0.09440605f, -0.13332166f, -0.09060904f, -0.15644273f, 0.16892302f, 
    -0.13678114f, -0.06141484f, -0.14620404f, 0.09388573f, 0.05506491f, -0.02096790f, 0.02821029f, 0.08044416f, 
    -0.21769966f, -0.01998131f, -0.07707632f, 0.12594707f, 0.02368500f, -0.03716759f, -0.06892315f, 0.04625047f, 
    -0.04162781f, -0.01953197f, -0.05700288f, 0.02099017f, -0.24088256f, -0.03460490f, 0.08125807f, 0.00464926f, 
    -0.01790320f, -0.05750138f, -0.05593631f, -0.01387304f, -0.03612475f, -0.08023662f, -0.00124421f, 0.16226998f, 
    -0.08270740f, -0.05101751f, 0.03996739f, 0.08808728f, 0.06291063f, -0.02254852f, -0.00459878f, 0.13973752f, 
    0.20730203f, 0.01562516f, -0.12903473f, -0.13750163f, 0.16813309f, 0.16899732f, 0.17953290f, 0.13896111f, 
    0.09433185f, 0.24747790f, 0.10215408f, 0.05474981f, 0.08600362f, -0.07909233f, -0.02941070f, -0.05837600f, 
    0.12639430f, -0.22931974f, 0.03975116f, 0.13312536f, -0.00971795f, -0.00660359f, 0.07385576f, 0.03126511f, 
    0.16837336f, 0.03670283f, 0.16160099f, -0.00583126f, -0.05013743f, -0.12161663f, 0.04930715f, -0.05154061f, 
    0.07222302f, 0.00385741f, 0.03578603f, -0.10993946f, 0.03103186f, -0.00798516f, 0.00464384f, -0.01226189f, 
    -0.01111521f, 0.13587005f, -0.27566937f, 0.14822114f, 0.05525143f, 0.00844458f, 0.10761102f, -0.06755026f, 
    -0.04371170f, 0.00143219f, 0.05303906f, -0.01925198f, 0.28742522f, -0.06834707f, 0.13403600f, 0.01582793f, 
    0.11827616f, 0.05446481f, -0.03273812f, 0.00760160f, 0.03482934f, 0.12318955f, 0.03986781f, 0.03432456f, 
    0.28375190f, 0.06928808f, -0.17048983f, 0.05757097f, 0.02701371f, 0.00460897f, -0.05820448f, -0.07378037f, 
    -0.03729560f, 0.04240276f, -0.06309542f, -0.08543506f, -0.07955892f, 0.21293266f, -0.15295117f, -0.05986531f, 
    0.11915125f, 0.03797370f, 0.03947290f, 0.01351094f, -0.00283476f, 0.00322692f, 0.15667297f, 0.00292407f, 
    -0.05323937f, -0.08895729f, 0.04663015f, 0.00493941f, -0.02732518f, -0.03210860f, 0.03336212f, 0.13440706f, 
    0.01253643f, -0.00969505f, 0.02190687f, 0.00826504f, -0.15008089f, 0.34480268f, -0.03366280f, -0.27794716f, 
    0.17997003f, 0.15376353f, 0.05585147f, -0.02719197f, 0.06064502f, 0.01209260f, -0.03105250f, -0.05589829f, 
    -0.12626456f, 0.33038229f, -0.12468986f, -0.01780315f, 0.01003843f, -0.01117965f, 0.02809906f, 0.03951612f, 
    0.10909826f, -0.01294544f, 0.06944113f, 0.00150621f, 0.03720063f, 0.24108791f, -0.22230120f, 0.08189999f, 
    -0.07497092f, 0.03599095f, -0.01186445f, 0.07999939f, -0.03804651f, 0.09989907f, -0.02892675f, -0.03897087f, 
    0.04403948f, 0.10820308f, -0.12729432f, -0.08776301f, 0.13446972f, 0.06568681f, -0.10903338f, 0.04508140f, 
    -0.06003063f, -0.08579487f, 0.08963397f, 0.03567063f, -0.05459431f, -0.05779502f, -0.01240731f, -0.07250521f, 
    0.04058366f, -0.06805867f, 0.09049633f, 0.07191201f, -0.00541660f, 0.01935588f, 0.07927431f, 0.05035762f, 
    0.08918729f, 0.08566359f, 0.00175300f, -0.12222771f, -0.06131992f, -0.03527404f, -0.08241949f, -0.10734493f, 
    -0.20305270f, 0.12732124f, 0.03285048f, -0.01239129f, 0.09028887f, 0.04050310f, 0.17096175f, -0.00180522f, 
    -0.02012578f, -0.02748821f, -0.02719107f, -0.04246170f, -0.03489279f, -0.08166225f, 0.02770212f, -0.02004393f, 
    -0.10098346f, 0.12379456f, 0.16184664f, 0.12790014f, -0.02709362f, -0.02365247f, -0.11588796f, -0.07659803f, 
    -0.09779155f, 0.06623377f, -0.02263253f, 0.07276128f, -0.02325075f, 0.24408482f, -0.12393271f, 0.28564805f, 
    -0.06404760f, 0.07235161f, -0.16238993f, 0.08144610f, -0.05324297f, 0.14162928f, 0.00714345f, 0.11260641f, 
    -0.14700830f, 0.29215920f, 0.03335017f, 0.01214515f, 0.04574931f, 0.05167965f, -0.00220528f, 0.00478429f, 
    0.02544542f, -0.03668574f, -0.19800125f, 0.04166943f, -0.04368065f, 0.18246511f, -0.11880717f, 0.19111978f, 
    0.00106307f, -0.02092048f, 0.08357479f, 0.14964186f, -0.00848550f, -0.05632667f, 0.05115217f, -0.02629483f, 
    0.02508639f, 0.34269306f, -0.10703766f, -0.00054115f, 0.08234242f, 0.00875006f, 0.02990696f, 0.15630175f, 
    0.09714808f, -0.07349555f, 0.10705626f, 0.04325189f, 0.21809988f, 0.06678305f, 0.19564117f, -0.02826580f, 
    0.08813144f, 0.06860022f, 0.02396206f, 0.09284470f, -0.14280283f, 0.02262510f, 0.01688608f, 0.10528977f, 
    0.27411792f, 0.11160123f, 0.04985053f, -0.09487182f, 0.12391228f, 0.13262799f, 0.07261672f, -0.02985480f, 
    -0.04831610f, 0.00258607f, -0.07420351f, -0.01142436f, -0.10791808f, 0.05750384f, 0.12555209f, -0.04424681f, 
    0.10628206f, 0.09159098f, 0.01733259f, -0.13473295f, 0.03561162f, -0.03912187f, 0.07776872f, -0.05474363f, 
    0.06584307f, -0.07780182f, -0.10025474f, -0.05813440f, 0.01431516f, -0.09344515f, 0.04615870f, 0.13456139f, 
    -0.02730368f, 0.04463764f, -0.02296019f, 0.00763462f, 0.07817920f, 0.08091671f, 0.26508632f, -0.16586655f, 
    0.10552304f, -0.02761293f, 0.00820713f, 0.00000885f, 0.07095221f, -0.05604218f, -0.11280074f, 0.00782017f, 
    -0.22304682f, 0.20101836f, -0.18220004f, -0.03261087f, -0.06580031f, -0.02128492f, 0.14149210f, -0.10830776f, 
    -0.01411714f, 0.19163530f, 0.13341893f, -0.01777453f, 0.02894139f, -0.16439719f, -0.37394384f, 0.06607455f, 
    0.15560491f, 0.01840560f, 0.14076607f, -0.05951911f, -0.00897744f, 0.04284567f, -0.01668900f, -0.04224019f, 
    0.31428134f, 0.11417295f, 0.38724333f, -0.02642603f, -0.15753855f, -0.12528527f, -0.27083656f, 0.10701820f, 
    0.10024415f, -0.05113501f, 0.05170251f, 0.12513861f, 0.19511306f, 0.03604192f, 0.15723690f, 0.08241174f, 
    0.08100533f, 0.03500600f, 0.10822783f, 0.19312260f, -0.08497798f, -0.01331696f, -0.03413022f, -0.03414752f, 
    0.14690872f, -0.24014992f, -0.02890306f, 0.15755264f, -0.11362382f, -0.05463566f, -0.09954210f, -0.06473375f, 
    -0.03991608f, 0.04306057f, 0.07365303f, 0.11154646f, 0.04226473f, -0.22701374f, -0.33205050f, 0.12990342f, 
    -0.01503200f, -0.08343779f, -0.00197901f, -0.03500596f, 0.01139894f, -0.02699785f, 0.06313907f, 0.19933300f, 
    -0.08300547f, -0.20964229f, -0.06305461f, 0.04989463f, -0.11190131f, 0.09446976f, -0.10355324f, 0.09365641f, 
    0.00456532f, 0.05173785f, -0.05812106f, -0.01917477f, 0.17932506f, 0.30303395f, -0.21183544f, 0.18888979f, 
    -0.07467428f, -0.09674522f, 0.06369191f, -0.01862711f, -0.10105213f, 0.06628191f, -0.04784204f, 0.01403757f, 
    -0.32175407f, -0.06266463f, -0.11061846f, 0.10541168f, -0.04264870f, -0.10357410f, 0.12057645f, -0.07405376f, 
    -0.01802197f, -0.13203126f, 0.08186119f, 0.04305223f, 0.11949819f, -0.03716987f, -0.09080133f, -0.21692699f, 
    0.23173898f, -0.04716286f, 0.10380856f, 0.08561851f, 0.06145419f, -0.11056918f, 0.11706640f, -0.05793970f, 
    -0.29376277f, -0.08750582f, -0.05437870f, -0.12178754f, 0.07886507f, 0.00809556f, -0.09497903f, -0.06868276f, 
    -0.04871462f, 0.14920537f, 0.01378468f, 0.05470350f, -0.16445719f, 0.03064893f, -0.05400277f, -0.07436304f, 
    -0.03910978f, -0.09820888f, 0.11991084f, 0.07900770f, 0.11481656f, 0.00911528f, 0.11512291f, 0.00628971f, 
    -0.23602018f, -0.13591176f, -0.03437733f, -0.03359609f, -0.04643003f, -0.02623425f, 0.13695168f, -0.15542153f, 
    -0.01892798f, -0.01161944f, 0.04090954f, 0.06597364f, -0.15755051f, 0.17823447f, 0.17858219f, 0.14946242f, 
    -0.17614436f, -0.05061638f, -0.07148845f, 0.11494638f, 0.00027700f, 0.06315076f, 0.11129602f, 0.08695466f, 
    0.16100837f, 0.08827332f, 0.08003721f, -0.16749452f, 0.05114331f, -0.03889834f, -0.00430558f, 0.09915618f, 
    0.04781528f, 0.04126748f, 0.06305335f, -0.06284473f, -0.10152954f, -0.04957513f, -0.08041722f, 0.17499693f, 
    -0.06205625f, -0.06149647f, 0.13243823f, 0.09795314f, 0.11455139f, 0.07131130f, 0.03823935f, 0.06797327f, 
    -0.10093350f, -0.22231686f, 0.05258209f, -0.00621306f, 0.04913277f, -0.01382670f, -0.08143543f, -0.02046727f, 
    0.01350656f, 0.16755950f, -0.08903253f, 0.05881336f, -0.24162000f, -0.01969666f, 0.29855639f, -0.20462471f, 
    -0.02067643f, -0.13674754f, -0.22086357f, 0.11694080f, 0.09986182f, 0.10891011f, -0.05688148f, 0.11285257f, 
    0.34876555f, -0.11220290f, -0.14100268f, 0.13279745f, 0.11836428f, 0.15148334f, 0.04153058f, 0.08488826f, 
    -0.08785045f, -0.03794322f, 0.05251946f, 0.03681433f, 0.07593931f, -0.01470400f, -0.06905977f, -0.01474568f, 
    -0.17729893f, -0.01180709f, 0.08758496f, 0.03519700f, 0.12976371f, 0.02394848f, 0.01752409f, -0.00986878f, 
    -0.13386883f, -0.05315913f, -0.07536617f, -0.02910154f, -0.06213903f, -0.07584469f, -0.04440780f, -0.03383642f, 
    0.12592770f, -0.01499050f, -0.05321106f, -0.03781526f, -0.23104699f, -0.12179864f, 0.10154089f, -0.05679156f, 
    0.05772639f, -0.05103517f, -0.01113192f, 0.05832809f, 0.04886642f, 0.02554345f, 0.04247316f, 0.17548138f, 
    -0.03388574f, -0.02775086f, -0.17507270f, -0.17559767f, 0.06365341f, -0.02673290f, -0.03229753f, 0.06343938f, 
    0.11476376f, -0.01895041f, 0.09407450f, 0.06953103f, 0.23526946f, -0.24613343f, 0.12040094f, -0.10670814f, 
    0.10862023f, 0.11208519f, -0.14705275f, -0.03272170f, -0.01560557f, 0.05370869f, -0.09303143f, -0.05598829f, 
    0.26704052f, -0.40507904f, 0.11754934f, 0.22523400f, -0.01287569f, 0.02829401f, -0.09172869f, 0.11827206f, 
    0.09434909f, 0.02506777f, 0.10800551f, 0.10920408f, 0.06400956f, -0.02388106f, 0.15543911f, 0.14511217f, 
    0.04515756f, -0.00133584f, 0.13624506f, -0.12501416f, -0.11697382f, 0.05627530f, -0.10586662f, -0.06357160f, 
    -0.07164536f, 0.17842881f, -0.02757002f, -0.02854161f, -0.07579325f, -0.03593655f, 0.17279428f, 0.06780256f, 
    0.07678139f, -0.09610093f, -0.02359692f, -0.07704414f, 0.05302128f, 0.04144023f, 0.08113798f, -0.05303318f, 
    -0.03292569f, 0.00707613f, -0.02089274f, 0.01445690f, -0.12092017f, -0.13754438f, 0.01223361f, -0.01207423f, 
    0.15901060f, 0.03556373f, -0.00086295f, -0.18038234f, 0.12223765f, 0.15136738f, 0.16638523f, 0.00222429f, 
    -0.08540198f, 0.02549266f, 0.01479897f, -0.01409038f, -0.29958004f, 0.03012971f, 0.00341115f, -0.07210314f, 
    0.00805409f, 0.07835376f, 0.07631823f, 0.01176949f, -0.06542722f, 0.07255654f, -0.00319238f, 0.12079813f, 
    0.01916855f, 0.00751492f, -0.22913924f, 0.09694977f, 0.00978300f, 0.03525163f, -0.05771184f, -0.10806342f, 
    -0.07516033f, 0.09075292f, -0.13778687f, 0.04609852f, 0.17931138f, -0.01026619f, 0.16070415f, 0.08459624f, 
    0.02276460f, 0.06578923f, 0.11829574f, 0.13560392f, -0.01228191f, 0.12819865f, 0.03020096f, -0.00608865f, 
    -0.01917644f, 0.03631585f, -0.05979161f, -0.14825755f, -0.00618158f, -0.09866882f, 0.06162161f, 0.01524440f, 
    -0.06011768f, 0.21359475f, 0.07358765f, 0.01981468f, -0.06093682f, 0.07039202f, -0.17643027f, 0.16161086f, 
    0.02282199f, 0.15702207f, 0.13756314f, 0.16832469f, 0.16286351f, 0.09369518f, -0.01097708f, -0.00857157f, 
    0.09897698f, -0.02341243f, 0.37403208f, 0.03092115f, 0.02981438f, 0.25260100f, -0.18664733f, 0.05851140f, 
    -0.03652177f, -0.00275862f, -0.00399462f, 0.04645822f, 0.14921534f, -0.05061950f, 0.00038007f, -0.17806484f, 
    0.12599282f, 0.03796794f, -0.03896223f, -0.02016879f, -0.00575691f, -0.07251360f, -0.06752297f, 0.09179191f, 
    -0.05477260f, 0.00051998f, 0.16232626f, 0.08975465f, 0.03068473f, 0.03974602f, 0.03880657f, -0.00239178f, 
    -0.11120024f, -0.07620261f, 0.03325843f, 0.05477660f, -0.18755233f, -0.13876857f, -0.17689833f, 0.06809921f, 
    0.05073053f, 0.01477594f, 0.03626555f, 0.00328737f, -0.10306524f, -0.10207487f, -0.05414159f, 0.20925511f, 
    -0.16885459f, -0.26450461f, 0.07476395f, 0.06405742f, -0.00155842f, 0.11262341f, -0.03255669f, 0.03585410f, 
    0.10542492f, 0.02096913f, -0.00158680f, -0.10254741f, 0.11660647f, 0.28158709f, -0.13651656f, 0.15113889f, 
    -0.04984397f, -0.09128682f, 0.15584321f, 0.03596222f, 0.04849409f, -0.01378983f, 0.02692561f, 0.02631166f, 
    -0.08247858f, 0.14038467f, -0.16821970f, 0.12883143f, 0.02038044f, -0.03930816f, 0.05082439f, 0.00885911f, 
    0.00399814f, 0.09302656f, 0.10235013f, -0.16676924f, 0.06704587f, -0.01636999f, -0.19305930f, -0.14820513f, 
    0.14023806f, 0.03079011f, 0.03604702f, -0.05712180f, 0.14152078f, -0.16054063f, 0.02876565f, -0.01672037f, 
    -0.12323125f, 0.37550375f, -0.22913161f, -0.02358081f, -0.10574382f, 0.13814804f, 0.04650011f, 0.18781917f, 
    -0.09228832f, -0.01669594f, -0.05434832f, 0.01149886f, 0.26055866f, -0.01905806f, 0.08540331f, -0.19582701f, 
    -0.08404128f, 0.01674053f, 0.04028530f, 0.05963822f, -0.04372087f, -0.12821154f, -0.02043333f, -0.04307677f, 
    0.19171606f, 0.12560683f, -0.12795694f, -0.16717792f, 0.14449222f, 0.07642404f, 0.13136713f, -0.10463418f, 
    -0.12743858f, -0.03682933f, -0.01452494f, 0.04676139f, -0.34187436f, 0.05650764f, -0.10914160f, 0.11847022f, 
    0.01740428f, 0.08658674f, -0.02662289f, -0.15614659f, 0.01345173f, -0.05560598f, 0.08865251f, -0.00245274f, 
    0.18398215f, -0.03449171f, 0.02905271f, -0.01125694f, -0.11701542f, -0.00528962f, 0.06861378f, 0.01499808f, 
    -0.08469222f, 0.06706425f, -0.03019400f, 0.03230779f, 0.09537388f, 0.15657243f, 0.15595931f, -0.12718642f, 
    0.09067647f, -0.06946906f, 0.08259937f, 0.13861604f, 0.08317964f, 0.06938744f, 0.05258200f, -0.01153589f, 
    -0.05226203f, 0.19558977f, -0.04928208f, 0.05153527f, -0.01420321f, -0.08497804f, 0.04561474f, -0.04703786f, 
    0.04101285f, 0.15587714f, 0.06956992f, 0.10952942f, -0.44252124f, -0.13505782f, -0.48164377f, -0.05319275f, 
    0.10619293f, -0.00407007f, -0.04071319f, 0.19382863f, 0.08463424f, 0.05850102f, 0.00408199f, -0.04627509f, 
    0.38445428f, 0.15126906f, 0.11155388f, 0.05681688f, 0.03743414f, 0.16017978f, -0.01117954f, 0.23919898f, 
    -0.00037734f, -0.04740567f, -0.02716775f, -0.05345106f, 0.08708357f, -0.00498132f, -0.03197204f, 0.09289460f, 
    0.03699113f, 0.03048140f, -0.03013615f, 0.02466921f, 0.08764596f, -0.00730344f, -0.06577067f, 0.11721567f, 
    0.03307006f, -0.14362095f, 0.06170691f, -0.01376218f, 0.01959562f, -0.05734652f, 0.02091302f, 0.00469813f, 
    -0.17357516f, -0.04064139f, 0.03016319f, -0.05927303f, -0.05779004f, -0.26462001f, -0.02496657f, 0.04383603f, 
    -0.06907402f, 0.00151158f, 0.00412112f, 0.00281714f, -0.06585214f, -0.15398259f, 0.07374401f, 0.15212773f, 
    -0.05281322f, 0.01039771f, 0.13377827f, 0.02896882f, -0.11429637f, 0.08115305f, -0.17306069f, 0.05105713f, 
    0.12206761f, -0.03567629f, -0.04159405f, -0.24035601f, 0.27624235f, 0.31953362f, -0.06477779f, 0.22598319f, 
    0.01026448f, 0.20266570f, -0.02635079f, 0.04840230f, -0.01921429f, -0.00374071f, -0.06693471f, -0.03709209f, 
    -0.11965524f, -0.15656689f, 0.12905669f, 0.14845163f, -0.04598025f, -0.05488350f, -0.03498164f, 0.03161996f, 
    0.02124705f, -0.06331915f, 0.01896720f, -0.00935698f, 0.06068705f, 0.31605658f, 0.25818259f, -0.10566901f, 
    0.12627052f, 0.08361493f, 0.23562007f, -0.15785278f, 0.15381187f, -0.02134845f, 0.13485104f, -0.05720687f, 
    0.18012483f, -0.00910352f, -0.02206763f, 0.03388899f, 0.05692422f, -0.08901346f, 0.27853763f, 0.08772336f, 
    -0.01764257f, -0.03053291f, -0.03974022f, -0.01062989f, 0.09020416f, 0.04629296f, 0.18874821f, 0.11302188f, 
    0.09233733f, 0.13083555f, -0.10901291f, 0.04115029f, -0.06186738f, 0.09580012f, -0.12704507f, -0.07523796f, 
    0.08754392f, 0.12366253f, -0.03315232f, 0.01075358f, 0.13373303f, 0.12990095f, -0.04736722f, 0.11070138f, 
    -0.09209022f, -0.00861740f, -0.15888225f, -0.10914660f, -0.01674060f, 0.13445660f, 0.08055458f, -0.04150579f, 
    0.06902109f, 0.08975378f, 0.07562368f, -0.06456783f, -0.03788898f, 0.08726141f, 0.03944569f, 0.04325585f, 
    -0.22129224f, 0.06605572f, -0.12462382f, 0.06810828f, -0.02870482f, 0.03130406f, 0.13474441f, -0.06614585f, 
    -0.00788778f, 0.06045423f, -0.04821501f, 0.07392325f, 0.11068354f, 0.26284814f, 0.18375543f, 0.00175076f, 
    0.08798240f, 0.12902045f, -0.12568469f, 0.11120323f, -0.01720011f, 0.02423688f, -0.03245891f, -0.07642381f, 
    0.16740161f, 0.25835171f, 0.02199162f, 0.01287613f, -0.11314044f, -0.05169851f, -0.12373781f, 0.03416558f, 
    0.07946831f, 0.03397990f, 0.18032204f, -0.17744088f, 0.34934208f, 0.30271783f, -0.06360845f, 0.15202664f, 
    -0.16105525f, 0.00512085f, 0.07956231f, -0.00061762f, -0.10536345f, 0.04033324f, 0.00082753f, -0.00404518f, 
    -0.19916113f, 0.06421208f, 0.08475969f, 0.04448599f, 0.02195063f, -0.02673975f, 0.04140228f, -0.06823282f, 
    0.02114379f, 0.09542201f, -0.03592446f, 0.11223872f, 0.00746426f, -0.14751351f, -0.05026427f, -0.06444633f, 
    0.18899463f, 0.11256729f, 0.09479189f, 0.02085034f, -0.07230598f, -0.01125113f, 0.04599498f, -0.06875462f, 
    -0.00846226f, 0.00773119f, 0.00334920f, -0.10359579f, -0.14540148f, 0.01591905f, -0.13439138f, -0.09657220f, 
    -0.07914175f, -0.01080262f, 0.03944910f, -0.06958312f, 0.24084204f, 0.14730278f, 0.03093411f, 0.08048426f, 
    -0.08980002f, -0.06683566f, 0.00747970f, -0.05727872f, -0.04310064f, 0.03149767f, 0.04021403f, 0.04018581f, 
    -0.05752182f, -0.09233011f, 0.08582068f, -0.03375333f, -0.00997535f, -0.08201980f, -0.00995173f, -0.12861520f, 
    -0.02627660f, 0.11326643f, -0.13670841f, -0.13875121f, -0.26627046f, 0.27133670f, -0.05029617f, 0.17454314f, 
    -0.19428404f, -0.08588906f, 0.02193173f, -0.01683092f, -0.01115217f, -0.06018079f, 0.02200248f, 0.03755942f, 
    -0.29215330f, 0.53921878f, -0.17384934f, -0.03686028f, -0.07966020f, -0.02689841f, 0.01735399f, -0.18317868f, 
    -0.00358786f, -0.14374216f, 0.05333455f, -0.22611763f, -0.12856297f, -0.03694475f, -0.11142503f, -0.10090881f, 
    0.11349398f, -0.03688580f, -0.01534007f, 0.13855737f, -0.00308934f, -0.14083268f, 0.17524458f, -0.06846568f, 
    -0.19948883f, 0.20149586f, -0.05827704f, 0.11263294f, -0.03557255f, 0.19014965f, 0.21726900f, -0.02824504f, 
    -0.04400754f, 0.13525279f, 0.13154340f, 0.13977712f, 0.15137948f, -0.17953198f, 0.08597533f, 0.01354979f, 
    0.08939635f, -0.03068934f, 0.05665455f, 0.21398441f, -0.06827377f, -0.17598394f, -0.03587778f, -0.18401466f, 
    -0.05118183f, -0.04487288f, -0.13639358f, -0.06760235f, 0.27411330f, -0.08986647f, 0.07577463f, -0.03515298f, 
    -0.10394961f, -0.04057443f, -0.05769405f, 0.03109896f, -0.16219580f, -0.02615060f, -0.38150293f, -0.17881735f, 
    -0.21878302f, 0.06203722f, 0.06214851f, -0.02290285f, 0.23707123f, 0.02522582f, 0.18216138f, 0.02982029f, 
    -0.01390542f, -0.02864423f, -0.08136146f, 0.34049582f, -0.08464607f, -0.04822106f, 0.02454441f, 0.14835075f, 
    -0.01961816f, -0.02747106f, -0.02459526f, 0.02953273f, 0.15890442f, 0.08318359f, -0.11022121f, -0.17379636f, 
    0.03606629f, 0.03701910f, 0.25439802f, 0.16051030f, 0.13155660f, 0.03324381f, -0.05914151f, -0.03498545f, 
    -0.10128392f, 0.18406726f, -0.00991189f, -0.17214802f, 0.00622496f, -0.10545499f, 0.00983391f, -0.02668058f, 
    0.02240092f, -0.00974830f, 0.05830469f, -0.07082216f, -0.27032438f, -0.01204595f, -0.35296544f, 0.05433371f, 
    0.00368812f, -0.01640432f, -0.05165161f, 0.12300698f, 0.05511868f, 0.04246620f, 0.09697425f, 0.11991619f, 
    0.41974235f, 0.07299700f, -0.05531965f, -0.00737522f, 0.12145706f, 0.22754179f, 0.05167594f, 0.20358495f, 
    0.06737959f, 0.03744945f, 0.12327807f, -0.00168551f, -0.07334413f, 0.12326042f, 0.06403439f, 0.14300680f, 
    -0.03411260f, 0.15714484f, 0.11286573f, -0.02304762f, 0.18383338f, -0.00463651f, 0.05080139f, 0.18372090f, 
    0.05178993f, 0.10335290f, 0.09486965f, 0.02730368f, -0.05750558f, -0.16978820f, -0.13352507f, -0.13425201f, 
    -0.18556124f, -0.03978899f, -0.15608962f, -0.14606617f, -0.05176208f, -0.02499265f, 0.14414299f, 0.05046118f, 
    -0.13199310f, -0.13626873f, -0.06194475f, -0.18375382f, -0.01378261f, -0.02029562f, 0.17430784f, 0.08547417f, 
    0.02526915f, 0.06786389f, 0.09632883f, 0.04080459f, -0.02023714f, -0.05019502f, -0.13872904f, 0.09256515f, 
    0.07778286f, -0.11969114f, -0.11332031f, -0.32023740f, 0.05557839f, 0.35247666f, -0.02723024f, 0.19417055f, 
    -0.08728660f, 0.14919057f, 0.09627621f, 0.11954679f, 0.02818480f, -0.04055015f, 0.08576643f, 0.06312660f, 
    0.00679536f, 0.13564931f, -0.05569480f, -0.04412346f, -0.04305177f, 0.04359400f, -0.00957279f, -0.02645210f, 
    0.03854305f, -0.01709204f, 0.04958736f, 0.05082069f, -0.37457550f, 0.18778509f, 0.34198686f, 0.19166973f, 
    -0.00382861f, 0.20583352f, 0.08023349f, -0.12087112f, 0.05051622f, 0.02223794f, 0.17434314f, 0.02068777f, 
    -0.00851515f, -0.06648946f, -0.05406820f, -0.07503244f, 0.02216164f, -0.07905228f, -0.04768540f, -0.01437136f, 
    0.04516558f, -0.02417973f, -0.04472579f, -0.05355239f, 0.03455162f, -0.00917797f, 0.00146116f, 0.02713162f, 
    0.04912392f, 0.02094699f, -0.02433285f, -0.00009315f, 0.04481722f, -0.02259635f, 0.05925341f, -0.03976356f, 
    -0.03511867f, -0.03250090f, 0.02753828f, 0.01048558f, -0.06507947f, -0.02291544f, -0.06380931f, -0.02871188f, 
    -0.00900999f, 0.02012295f, 0.04068885f, -0.02499778f, -0.00496724f, 0.05577479f, 0.00648532f, -0.00042639f, 
    -0.04927593f, -0.05863201f, -0.01788897f, -0.01769891f, -0.00012569f, -0.02936575f, -0.07923488f, 0.03982371f, 
    0.03072845f, 0.04212702f, 0.05678270f, -0.01615064f, -0.06965877f, 0.05482092f, -0.00892320f, -0.04407587f, 
    -0.06704102f, -0.05889471f, -0.04303421f, 0.00671214f, 0.06059099f, -0.08378220f, -0.06282899f, 0.04022539f, 
    0.05332237f, 0.04166069f, -0.04936719f, 0.01664802f, -0.03100187f, -0.04097079f, 0.02150943f, 0.03567901f, 
    -0.07018717f, -0.00177523f, -0.02649975f, 0.02750987f, 0.02763723f, -0.06311547f, 0.05760857f, -0.06096846f, 
    -0.03932632f, -0.05750195f, -0.03724376f, -0.04492302f, -0.04394699f, -0.00381716f, -0.06484282f, -0.06741209f, 
    -0.02591947f, -0.03803463f, -0.03920079f, 0.00695595f, -0.07687610f, 0.03671880f, 0.01819234f, -0.05837858f, 
    0.02127655f, -0.04732861f, 0.06185177f, -0.04419678f, 0.05917150f, -0.06125404f, -0.03707336f, 0.06163070f, 
    0.00363209f, -0.01688878f, -0.05444994f, 0.06079252f, -0.02035633f, 0.02670212f, -0.05580598f, 0.03807297f, 
    -0.05357934f, 0.05631527f, -0.01396084f, -0.05867184f, 0.03698121f, 0.01339598f, 0.03010678f, -0.00395627f, 
    0.02211477f, 0.05269703f, 0.05107402f, -0.05077923f, 0.05233960f, 0.05461334f, 0.04092838f, 0.06436525f, 
    0.01758991f, -0.05232304f, -0.00243746f, -0.03566086f, -0.06569934f, 0.01522618f, -0.05930184f, 0.01015120f, 
    -0.01692220f, -0.00926846f, 0.02721136f, -0.07396632f, 0.02810105f, -0.03862950f, -0.04343539f, 0.02998703f, 
    0.02578367f, -0.02401598f, -0.05710611f, -0.07851414f, -0.05758853f, -0.04387534f, 0.03520583f, 0.05347114f, 
    0.02490647f, -0.05095593f, 0.02679057f, -0.01543783f, -0.04364775f, 0.02900414f, 0.04269667f, -0.04348383f, 
    0.02356760f, -0.02384518f, 0.02896718f, -0.06038794f, 0.04614230f, 0.03546982f, -0.07464783f, -0.05845727f, 
    -0.02148116f, -0.01355061f, 0.00274479f, 0.01835188f, -0.01923670f, -0.02321380f, -0.00757123f, -0.05599805f, 
    -0.06481858f, -0.05451165f, 0.03844083f, 0.00379294f, -0.06042225f, -0.00102705f, -0.04714293f, -0.02567894f, 
    -0.08548962f, 0.02315924f, -0.03001348f, -0.02689986f, 0.01168535f, 0.03332984f, -0.02745117f, -0.07526617f, 
    0.04645933f, 0.01527265f, -0.02966048f, 0.04213605f, 0.04969435f, -0.06522252f, 0.02836009f, 0.02502209f, 
    -0.04447424f, 0.03456854f, -0.05021692f, -0.03746898f, -0.01259324f, -0.05855652f, -0.00690678f, 0.05999522f, 
    0.06252079f, -0.02972510f, -0.04584462f, -0.06337890f, 0.06694131f, -0.02874624f, -0.05066678f, -0.04279616f, 
    0.04034532f, 0.05410613f, -0.02254657f, -0.02509954f, -0.02905375f, -0.04935825f, -0.02920181f, -0.00719870f, 
    0.01334124f, 0.00071912f, -0.07961883f, -0.02827965f, -0.05045284f, -0.02974761f, 0.02221039f, 0.03758356f, 
    0.03510848f, -0.03982787f, 0.02139573f, -0.05145854f, 0.00588500f, 0.00304841f, -0.01535713f, -0.05200733f, 
    -0.02955207f, -0.06425060f, -0.01971209f, 0.02659069f, 0.03798738f, -0.02220317f, -0.06079990f, -0.04039138f, 
    -0.06886271f, -0.01450821f, -0.05980676f, -0.02019948f, -0.06356663f, 0.00814670f, 0.01660413f, -0.04640984f, 
    -0.01138224f, -0.00805439f, 0.02034957f, -0.07116002f, -0.01213959f, 0.04435055f, -0.02434199f, -0.01932047f, 
    -0.05612060f, -0.02379054f, -0.05554986f, -0.05824289f, -0.06105698f, 0.05417681f, 0.03932754f, -0.06298172f, 
    -0.07667980f, 0.00932743f, -0.03227009f, -0.06321880f, -0.01776103f, 0.03776724f, 0.01271517f, 0.05383367f, 
    -0.04654174f, -0.04873409f, 0.03109128f, -0.03947065f, 0.01936707f, -0.02913174f, 0.04540589f, -0.01503122f, 
    -0.06798888f, -0.03481377f, -0.07672457f, -0.06890412f, -0.03668195f, 0.01456515f, -0.05459803f, 0.02338818f, 
    0.00063311f, -0.01495976f, -0.02377446f, 0.02345212f, 0.05409084f, 0.04602654f, -0.02421418f, 0.00251774f, 
    -0.04732544f, -0.03606698f, -0.05933198f, 0.05414291f, 0.03980170f, -0.06740215f, 0.00976047f, -0.02877404f, 
    -0.06464230f, -0.01193849f, 0.05957680f, 0.01261805f, -0.05072648f, 0.01764284f, 0.01308710f, -0.04628019f, 
    -0.00588501f, -0.00902017f, -0.06524565f, -0.02513854f, -0.02735609f, -0.00757412f, -0.05915714f, -0.01252897f, 
    0.02589402f, -0.01542563f, 0.03107377f, 0.05198620f, 0.02811980f, 0.01206737f, -0.01787831f, -0.06131857f, 
    0.06429552f, -0.02142248f, -0.00583821f, -0.05931082f, 0.04438969f, -0.05969090f, -0.04119298f, -0.06577893f, 
    0.03537244f, -0.07490653f, -0.04868793f, -0.02608768f, 0.00705624f, -0.03143630f, -0.01795639f, 0.02202108f, 
    0.01019964f, -0.03508658f, -0.01443948f, 0.03506282f, 0.02757220f, 0.01486728f, -0.05834719f, -0.00521122f, 
    -0.04747151f, -0.05095946f, 0.00947006f, -0.06070349f, 0.06119625f, 0.06086193f, -0.05690592f, 0.03815803f, 
    0.02701622f, 0.02466987f, -0.03893067f, -0.03228272f, 0.01706355f, -0.01536755f, -0.00648678f, -0.01032694f, 
    0.03944746f, 0.00702132f, -0.03203222f, -0.04060822f, -0.07774362f, -0.04861477f, 0.05362872f, -0.03405670f, 
    0.07705425f, 0.01468779f, -0.33123484f, 0.03907288f, 0.10004602f, 0.12359956f, -0.16098100f, -0.20478436f, 
    -0.29290441f, -0.20503569f, -0.25228858f, -0.19485448f, 0.05498889f, 0.03935259f, 0.04719854f, 0.08738147f, 
    -0.01984842f, 0.08329872f, 0.14255364f, 0.21989775f, 0.05147785f, 0.17388542f, 0.20494409f, 0.36216265f, 
    0.32289839f, -0.00794014f, -0.04206813f, -0.05867719f, 0.03312765f, 0.07511938f, 0.06110494f, 0.12312295f, 
    -0.02432760f, -0.08612282f, -0.09932052f, 0.06369863f, 0.20173435f, 0.04407552f, 0.14915033f, 0.16699442f, 
    0.28720632f, 0.04406632f, -0.28195435f, -0.28814310f, -0.18355030f, 0.03997278f, 0.09822469f, 0.13052951f, 
    0.16315447f, -0.05044739f, 0.16003296f, 0.04719444f, -0.01346593f, -0.09272958f, -0.04448134f, -0.14829716f, 
    0.02739038f, 0.06405302f, 0.11096559f, 0.11645474f, 0.16767517f, 0.31331524f, 0.05325272f, 0.03656238f, 
    -0.11186007f, 0.07851522f, 0.04699431f, -0.13897346f, 0.04389889f, 0.14960751f, 0.15435931f, 0.29469216f, 
    0.01634537f, -0.28595674f, -0.17605959f, 0.13343273f, -0.06785607f, -0.00372784f, 0.05818186f, -0.08341914f, 
    0.20870300f, 0.06967644f, 0.06377795f, 0.33645737f, -0.29790419f, -0.43727779f, -0.19463502f, 0.09157960f, 
    0.09888451f, -0.13806148f, -0.10385162f, -0.25203738f, -0.03564068f, 0.12846863f, -0.03688222f, 0.09768735f, 
    -0.11212846f, 0.05518677f, -0.09484693f, -0.23763897f, -0.00905798f, -0.04579895f, -0.05771123f, -0.16029631f, 
    -0.05838527f, -0.14239730f, 0.12097134f, -0.15200093f, 0.17742875f, 0.07310539f, -0.02237234f, 0.11711856f, 
    0.00190261f, 0.02834021f, 0.11549005f, 0.23632167f, -0.11088680f, -0.09147932f, 0.03754267f, 0.01937489f, 
    -0.12194118f, -0.10572524f, -0.37884492f, 0.07598281f, -0.10989555f, 0.04312408f, -0.02017086f, -0.06516675f, 
    -0.05222194f, -0.04156025f, -0.10812937f, -0.08406189f, -0.19539693f, -0.14094877f, -0.35053393f, -0.13683248f, 
    -0.13306050f, -0.09764498f, -0.06028339f, -0.33118820f, -0.05967144f, -0.05302996f, -0.16439819f, -0.24375449f, 
    -0.15113187f, 0.37899730f, 0.01949462f, 0.06984021f, -0.19111432f, -0.12822314f, 0.03315363f, -0.06855270f, 
    0.21555740f, 0.09101638f, 0.17105503f, 0.58232701f, 0.38045162f, -0.35338476f, 0.11110806f, 0.10439240f, 
    0.27284777f, 0.02714174f, -0.14265019f, 0.03259957f, -0.16178162f, -0.01182726f, -0.25958708f, -0.23778555f, 
    0.18339303f, -0.29057214f, 0.21073619f, -0.02949122f, 0.09679263f, 0.07569310f, 0.09187764f, 0.07584234f, 
    0.12957074f, 0.10229817f, 0.05380597f, 0.20703135f, 0.30059850f, 0.22972634f, -0.12762685f, 0.00710292f, 
    0.00044630f, -0.07335796f, -0.03280352f, 0.02916064f, -0.15675533f, 0.15926822f, -0.30357698f, -0.18186632f, 
    0.08856321f, 0.07171758f, 0.04688095f, 0.08523645f, 0.00177575f, 0.01307343f, 0.28914416f, 0.08787424f, 
    -0.00717957f, 0.02459178f, 0.15589412f, 0.11313900f, 0.10289508f, -0.09915399f, 0.06654329f, 0.10706416f, 
    0.07862287f, 0.16746411f, -0.03679878f, 0.05147238f, -0.03987012f, -0.12892520f, -0.10657961f, -0.16462170f, 
    0.15953939f, 0.14320683f, -0.05394984f, -0.02934500f, 0.10462351f, 0.09709099f, 0.04942517f, 0.14277799f, 
    -0.09423411f, -0.02501000f, -0.02286890f, 0.02054797f, 0.18483539f, -0.08756496f, -0.30216882f, -0.21826930f, 
    -0.06198578f, 0.07536431f, 0.05733623f, 0.03533420f, 0.00585996f, 0.01543683f, 0.03897091f, -0.01698024f, 
    -0.16951700f, -0.23624030f, -0.11996578f, -0.01760933f, -0.03070848f, 0.11325218f, -0.04049604f, 0.11740374f, 
    0.07045017f, 0.01393126f, -0.07727524f, 0.03991377f, 0.11978402f, 0.17727670f, 0.04711525f, -0.15246709f, 
    0.26605400f, 0.09784218f, 0.02586486f, 0.05308650f, 0.06472643f, 0.02641365f, 0.03377117f, -0.24881633f, 
    0.04304707f, -0.02064405f, -0.04731383f, -0.10734851f, -0.10775347f, -0.01797403f, -0.09203775f, -0.01149224f, 
    -0.02968650f, -0.03115004f, 0.03803812f, -0.09012038f, 0.16098092f, -0.23210858f, -0.19537477f, -0.01837908f, 
    -0.01458856f, 0.12501365f, 0.06923102f, 0.02153275f, 0.04872525f, -0.01097394f, 0.11104225f, -0.05163582f, 
    -0.16225362f, 0.03621002f, 0.08732708f, -0.04490494f, 0.23926215f, 0.04226230f, -0.12093472f, -0.01726895f, 
    0.03367062f, 0.05112617f, 0.06208812f, 0.03252861f, 0.06793632f, -0.10432876f, 0.02271003f, -0.11230774f, 
    0.19741829f, 0.06072713f, 0.05782915f, 0.03465246f, 0.05660131f, -0.03161356f, -0.04856688f, -0.00078911f, 
    -0.09560622f, 0.08507988f, 0.15346748f, -0.03746728f, -0.03458850f, -0.00432705f, -0.05791406f, 0.02317299f, 
    -0.12101489f, -0.07041046f, 0.01492921f, -0.01041264f, -0.07142349f, 0.04999176f, 0.05926497f, 0.10296793f, 
    -0.10083078f, -0.07160068f, -0.02140528f, 0.04139948f, 0.05447772f, 0.12776813f, 0.19388331f, 0.04397279f, 
    -0.24982336f, -0.16815582f, -0.04585819f, 0.06036233f, 0.00229172f, 0.06100522f, -0.08386928f, 0.06511516f, 
    -0.03527468f, 0.03372439f, -0.07260902f, -0.08206663f, 0.02966334f, 0.34666419f, 0.16557953f, 0.11789186f, 
    -0.12367785f, 0.02517236f, 0.01385788f, -0.05430147f, -0.00167189f, 0.01737623f, 0.00698958f, 0.15849607f, 
    0.02858526f, 0.25533167f, -0.08581176f, -0.14876141f, -0.01612348f, 0.00778010f, 0.04731321f, -0.13195416f, 
    0.06449194f, 0.10711378f, 0.01022272f, 0.01252220f, -0.03437760f, 0.14499818f, 0.01694099f, -0.14991233f, 
    0.10545758f, 0.09803536f, 0.15109032f, 0.18324488f, 0.01927902f, -0.08328344f, 0.03056544f, 0.09296782f, 
    0.07012924f, -0.11110303f, 0.07032238f, -0.10876224f, 0.15790246f, 0.12884329f, -0.33557779f, -0.28466699f, 
    -0.06026390f, 0.09893590f, -0.06884300f, -0.03046514f, 0.00778087f, -0.02986962f, -0.12844148f, 0.17994305f, 
    -0.00783847f, 0.09285478f, 0.13747694f, -0.07336817f, 0.06105573f, 0.01707123f, 0.09809490f, 0.12117367f, 
    -0.09271584f, -0.10511073f, 0.04626825f, 0.18719433f, -0.17060953f, -0.06058023f, -0.11656932f, -0.15637933f, 
    -0.03190010f, 0.06773673f, 0.04026297f, 0.11146665f, 0.29422989f, 0.02032754f, 0.00414553f, 0.11107009f, 
    0.10002436f, -0.06275886f, 0.02146836f, -0.04160941f, -0.00346678f, 0.07334747f, 0.06287605f, 0.22380151f, 
    0.11611623f, 0.15853921f, 0.23969610f, 0.11875172f, 0.02416980f, -0.06968735f, -0.01337155f, -0.08029480f, 
    -0.03272406f, 0.01066982f, 0.14478666f, 0.05690436f, 0.06159067f, 0.00744665f, -0.04846124f, 0.01320942f, 
    -0.26835257f, 0.00213671f, -0.10011312f, -0.17571157f, -0.20322359f, -0.08432646f, 0.03657143f, 0.18458501f, 
    -0.06070584f, 0.02673354f, 0.00357650f, 0.15871590f, 0.07760551f, 0.04971099f, 0.07896703f, -0.02565857f, 
    0.06042426f, -0.09507944f, 0.10909843f, 0.04941101f, -0.15248385f, 0.31094930f, 0.23216641f, 0.01521182f, 
    0.03805453f, -0.10727046f, 0.00186187f, -0.06045035f, -0.01963139f, 0.10774346f, 0.13475828f, 0.25743070f, 
    -0.01884757f, -0.00194824f, -0.21043201f, -0.00880608f, -0.33409920f, -0.26799437f, 0.19613123f, 0.10649633f, 
    0.07790715f, -0.02832437f, -0.10297930f, -0.05195405f, -0.06492466f, 0.11884962f, -0.09402902f, 0.09061022f, 
    -0.11416205f, -0.05941176f, 0.05291572f, 0.06310406f, -0.10068277f, -0.08055436f, 0.00827825f, 0.01934747f, 
    -0.00503567f, 0.00555488f, -0.04573262f, -0.08943599f, 0.07196049f, 0.04755413f, 0.04667664f, 0.06802929f, 
    0.17337944f, 0.09746281f, -0.14054634f, -0.03398151f, 0.05005263f, 0.15776655f, 0.01447323f, -0.11129106f, 
    0.05663074f, 0.02223933f, 0.04948855f, -0.02975973f, 0.12255821f, -0.01916619f, -0.18529077f, -0.08075791f, 
    0.09678364f, 0.03840458f, 0.00123757f, 0.00690112f, -0.01645542f, -0.06838652f, 0.14695828f, -0.03072860f, 
    0.12673499f, 0.03322035f, 0.00023669f, 0.23861511f, -0.18303014f, -0.25333437f, 0.01574443f, 0.13746394f, 
    0.12166496f, 0.08834653f, 0.02178171f, 0.01329813f, -0.01564300f, 0.02900016f, 0.04810551f, -0.11231689f, 
    -0.10395914f, -0.01756854f, 0.09294073f, 0.03108022f, -0.05056907f, -0.01365878f, -0.09927567f, -0.01649675f, 
    0.08696526f, -0.05261040f, -0.02856446f, 0.10082363f, 0.19876458f, -0.00997669f, -0.01855141f, 0.08817332f, 
    -0.01511494f, 0.03395092f, -0.03311718f, -0.00261471f, 0.03314234f, -0.01543308f, -0.04200727f, -0.01621913f, 
    0.08074269f, -0.09508958f, 0.05787855f, -0.01124953f, 0.03084949f, 0.04778146f, -0.10714251f, 0.02309026f, 
    -0.00986997f, -0.04091627f, -0.00562082f, -0.15966727f, 0.00445423f, 0.14705153f, 0.13059655f, 0.05770686f, 
    0.12019475f, -0.10376624f, -0.00784048f, -0.08112710f, 0.17192128f, 0.06161796f, 0.01801010f, 0.10568459f, 
    -0.06838975f, 0.15546279f, 0.19705492f, 0.26770943f, -0.14948958f, -0.01487838f, 0.09040899f, 0.05434139f, 
    0.05959452f, 0.03341423f, -0.02379248f, 0.01669798f, 0.14546779f, 0.25845712f, 0.27257890f, 0.19377491f, 
    0.01203193f, -0.05849947f, 0.08811733f, 0.18189825f, -0.00118072f, -0.04542485f, -0.06622071f, 0.12963945f, 
    0.04141206f, 0.20387308f, 0.38207886f, 0.14774588f, 0.05249293f, 0.10234936f, -0.02979595f, -0.15252595f, 
    0.03027878f, 0.02832005f, -0.04456797f, 0.19613200f, -0.19371916f, 0.16899019f, 0.04742385f, 0.21886696f, 
    -0.01353150f, 0.08617534f, -0.02967670f, -0.05352747f, -0.03829732f, 0.00932033f, -0.00266837f, 0.02374463f, 
    -0.16817649f, -0.36153001f, 0.04100520f, 0.05628288f, 0.00698707f, 0.05981696f, -0.10044475f, -0.00879932f, 
    0.03638899f, -0.06042778f, -0.03950028f, 0.14356267f, 0.20344432f, 0.11359673f, 0.47160184f, -0.15945917f, 
    -0.12606452f, -0.10183981f, -0.21571140f, 0.18547790f, 0.01274496f, -0.03107503f, 0.07364177f, 0.08561955f, 
    -0.22729251f, -0.10061913f, -0.32844746f, -0.02419189f, 0.11681954f, 0.04424867f, 0.07128950f, -0.10394283f, 
    0.03337682f, 0.06531897f, -0.03510297f, -0.02550810f, 0.11489674f, 0.20882489f, 0.14168473f, 0.12475076f, 
    0.05528167f, -0.05238695f, 0.01057169f, 0.03074078f, -0.05439936f, -0.04511486f, 0.06500344f, -0.03232305f, 
    -0.19003819f, -0.34232056f, -0.23971002f, -0.17675263f, -0.04955498f, 0.03637283f, 0.08342254f, -0.06501178f, 
    0.12847359f, 0.00380422f, -0.07891035f, -0.11812702f, 0.03115482f, -0.20929997f, -0.17098026f, -0.30616537f, 
    -0.05179662f, 0.06189857f, -0.05614078f, 0.15267928f, 0.04707398f, 0.05947452f, -0.05305886f, -0.18094169f, 
    0.22184312f, 0.22480056f, -0.08152061f, -0.19857615f, 0.01310957f, -0.11504796f, 0.05655749f, -0.17559096f, 
    -0.05211643f, 0.07754005f, 0.02772341f, 0.21010244f, -0.08672198f, -0.14930761f, 0.17322290f, -0.05446147f, 
    0.08016679f, 0.09587328f, 0.03780428f, 0.08899965f, -0.07266616f, -0.03556709f, 0.00505465f, -0.04267902f, 
    0.04975395f, -0.24755564f, 0.00901594f, -0.03740200f, -0.00329319f, 0.10884409f, -0.11325817f, 0.02755505f, 
    -0.08695676f, 0.03764676f, -0.01426829f, 0.10391521f, 0.20812245f, 0.19262123f, 0.29755786f, 0.24684268f, 
    -0.00733609f, -0.04410236f, 0.09612315f, 0.03047769f, -0.01302080f, 0.04618788f, 0.00280050f, 0.04662662f, 
    -0.03237047f, -0.07640757f, 0.05784440f, 0.10940726f, 0.10951547f, 0.01543380f, 0.12012623f, 0.12412143f, 
    -0.07782518f, 0.04825218f, 0.06201586f, 0.04661370f, 0.08472463f, -0.08556051f, 0.03238724f, -0.00633807f, 
    0.15402135f, 0.02999715f, 0.01055988f, 0.03231133f, 0.12541541f, 0.16513492f, 0.01101225f, 0.00209448f, 
    -0.06538838f, 0.05684730f, -0.02946479f, 0.02714811f, -0.02259536f, -0.12612367f, 0.00146725f, 0.08997980f, 
    -0.08854320f, -0.04369806f, 0.04810758f, -0.13847202f, -0.05497460f, 0.09566670f, 0.01363320f, 0.04026035f, 
    0.03720555f, -0.22486548f, -0.06294660f, -0.00595537f, -0.09172200f, 0.04825655f, 0.19027495f, 0.07045756f, 
    -0.23097663f, -0.02348686f, 0.10394866f, 0.02199582f, -0.07255548f, 0.00971114f, 0.09342670f, 0.14010461f, 
    0.08865567f, -0.00088642f, -0.09906551f, 0.08182778f, -0.09560560f, 0.04024339f, 0.00127919f, -0.06395707f, 
    0.16018294f, 0.04693406f, -0.14868529f, 0.05812141f, 0.08458260f, 0.04438189f, 0.02579471f, -0.12914847f, 
    -0.19055772f, 0.42200249f, 0.02333769f, 0.02757473f, -0.02740165f, 0.11339904f, 0.01462487f, -0.07164993f, 
    0.05031880f, -0.05209452f, 0.15880670f, -0.12767889f, 0.06271367f, 0.11492865f, 0.09551138f, -0.06135916f, 
    -0.11050349f, -0.09575395f, -0.12127635f, 0.08379500f, -0.10806835f, 0.05336183f, 0.01567681f, -0.08697008f, 
    0.28559238f, 0.02200228f, -0.15036125f, -0.01070390f, 0.23995191f, -0.02269331f, -0.05392332f, -0.02195245f, 
    0.10419593f, 0.05740485f, 0.05306359f, 0.00723257f, -0.18517077f, 0.05113275f, 0.05718806f, 0.04372427f, 
    0.08131227f, 0.16846728f, 0.10926932f, 0.10909963f, -0.00199361f, -0.00422037f, 0.14183144f, -0.03770631f, 
    0.21187848f, 0.07782293f, -0.00973268f, -0.12528105f, -0.11769990f, 0.01944901f, -0.00427772f, -0.00603113f, 
    -0.05034326f, 0.00875433f, 0.09975830f, -0.08477021f, 0.22772802f, 0.07000351f, 0.17434581f, 0.04957319f, 
    -0.07082979f, -0.08473784f, 0.01615341f, -0.07283253f, 0.06233068f, 0.05968273f, 0.11839991f, -0.06565085f, 
    0.07830073f, 0.04811031f, 0.02552370f, -0.10256076f, -0.11375289f, 0.01312748f, -0.04629220f, -0.03834780f, 
    -0.00393727f, 0.00142829f, -0.12504014f, -0.08178610f, -0.04616870f, 0.27290374f, -0.04135758f, 0.11101747f, 
    -0.20884277f, 0.09085275f, 0.05612775f, 0.00981258f, -0.06369483f, 0.02010995f, 0.08054096f, 0.03175699f, 
    -0.34496972f, 0.25360852f, -0.14102614f, 0.06152263f, 0.00005350f, -0.07342871f, -0.08527019f, 0.03148478f, 
    0.07047509f, -0.00573614f, 0.05719742f, -0.03336164f, -0.30315858f, -0.07823896f, 0.05020085f, 0.06135824f, 
    0.04683075f, -0.06779645f, 0.05024525f, 0.14217968f, -0.11624458f, -0.01732119f, 0.11806773f, 0.02282409f, 
    -0.03676990f, -0.21659614f, 0.23823307f, 0.00575918f, 0.08381699f, 0.01202729f, 0.27379650f, 0.20643622f, 
    -0.02235157f, -0.05109010f, 0.11031227f, 0.14305887f, -0.06151999f, 0.14115821f, 0.01818368f, -0.00654076f, 
    0.07749234f, -0.00191027f, -0.02521907f, 0.02903082f, -0.03171397f, 0.06251111f, -0.02150833f, -0.09248110f, 
    -0.01573051f, 0.05873289f, -0.02129588f, -0.07279539f, 0.06560483f, 0.08056750f, 0.02267751f, 0.15944745f, 
    0.02430104f, -0.10697648f, -0.07625396f, -0.06495163f, -0.08971736f, -0.21558881f, 0.16578594f, 0.00195027f, 
    0.08722854f, 0.05890835f, -0.04785799f, -0.01890269f, -0.04088517f, -0.01371339f, 0.18081550f, -0.03646333f, 
    -0.11512809f, -0.12169012f, 0.02872965f, -0.27391297f, -0.02415630f, -0.06527093f, 0.07665215f, 0.10078859f, 
    0.10308702f, -0.09667192f, -0.03284246f, -0.01496583f, 0.29275236f, -0.13558039f, 0.02862925f, -0.00586644f, 
    0.13371298f, -0.03846563f, 0.04292443f, -0.01236760f, 0.23070900f, -0.03167033f, 0.10911886f, 0.00229249f, 
    0.11040161f, -0.03261244f, 0.08183331f, 0.10609645f, -0.13858402f, 0.00179921f, 0.00556801f, -0.09688567f, 
    -0.02458163f, 0.08928406f, 0.23776548f, -0.20987359f, 0.38819343f, -0.17789586f, 0.12649503f, -0.10188647f, 
    -0.07411747f, 0.05406239f, -0.01589570f, -0.01703333f, 0.02952065f, 0.13770533f, 0.13862577f, 0.01624887f, 
    0.18873326f, 0.06696304f, 0.17574117f, 0.00896828f, 0.40483662f, -0.17656542f, -0.01850657f, 0.01469088f, 
    0.04974642f, 0.13026746f, -0.00994974f, 0.11966140f, -0.13100180f, -0.08950298f, 0.11183851f, -0.22101602f, 
    0.12333138f, 0.04474875f, 0.17359832f, 0.00835356f, 0.01670533f, 0.03364351f, 0.13274100f, 0.02421304f, 
    -0.00827250f, 0.03319210f, 0.02843522f, 0.02107736f, -0.08138143f, -0.05219244f, -0.00005126f, -0.05533677f, 
    -0.00924273f, -0.07841536f, -0.03577413f, 0.07523919f, -0.10010874f, 0.01079753f, 0.05275841f, -0.03802169f, 
    0.01277181f, 0.01944382f, 0.02431718f, -0.06944585f, 0.04658236f, 0.03835782f, 0.11336802f, 0.26094347f, 
    -0.01545156f, -0.22357954f, -0.06427839f, -0.09840214f, 0.06746221f, 0.04851543f, -0.04649431f, -0.02470658f, 
    -0.03932814f, 0.00849316f, -0.07004149f, -0.19057545f, 0.23436126f, 0.04548455f, -0.11838435f, -0.15099099f, 
    -0.14383180f, 0.12978725f, 0.16880839f, -0.00495924f, 0.03669744f, -0.05544856f, -0.02827025f, -0.05140994f, 
    0.15828691f, 0.09015310f, -0.22778971f, -0.01242773f, 0.08265988f, -0.07271864f, 0.04548151f, -0.09821419f, 
    0.03469321f, 0.04304749f, 0.17251264f, -0.10124774f, -0.16014943f, -0.27311227f, -0.30887115f, -0.17619812f, 
    0.03180305f, -0.04460523f, -0.09460364f, 0.23299551f, -0.09094409f, -0.03733100f, -0.16110489f, 0.03154666f, 
    0.16073878f, 0.16333088f, -0.34588215f, 0.07144876f, -0.00500920f, 0.10966580f, 0.00236928f, -0.06912668f, 
    -0.17299187f, -0.14811149f, -0.25182462f, -0.21489379f, 0.08571398f, 0.05188100f, -0.01847481f, 0.02533695f, 
    0.00851860f, 0.12850311f, 0.10036676f, 0.11523452f, -0.01439313f, 0.17999297f, 0.12020256f, 0.32825908f, 
    0.26451555f, 0.07567267f, -0.07379922f, -0.12785749f, 0.07506349f, 0.13012098f, 0.13398042f, 0.11802044f, 
    0.03232406f, 0.06366492f, -0.05355304f, -0.01433684f, 0.22112067f, 0.19232261f, 0.13628042f, 0.14057575f, 
    0.04975144f, 0.06436061f, -0.04939444f, -0.11208925f, -0.05361301f, -0.04248012f, -0.00558215f, 0.08314527f, 
    0.33986303f, -0.00963765f, 0.15252070f, 0.10413077f, -0.11166684f, -0.07789842f, -0.15414646f, -0.16389979f, 
    0.05161304f, 0.06328656f, -0.06116910f, 0.18206733f, 0.07199285f, 0.31495640f, 0.08332587f, -0.02944227f, 
    -0.15424272f, 0.05144905f, -0.03203367f, -0.22679648f, 0.12684959f, 0.10048625f, 0.11508290f, 0.19731668f, 
    0.23213604f, -0.51022655f, -0.12384337f, -0.00901842f, -0.08296392f, -0.13645832f, 0.02423989f, -0.17625815f, 
    0.04561336f, 0.00358271f, 0.05303013f, 0.34688148f, 0.00936912f, -0.36007017f, -0.35562950f, -0.06699427f, 
    -0.07069476f, -0.15808550f, -0.12128394f, -0.07003671f, 0.06805173f, 0.08697229f, -0.06287676f, 0.11988106f, 
    -0.25460383f, 0.18012103f, -0.04865117f, -0.27896595f, -0.16222766f, 0.14085102f, 0.19506222f, -0.05098184f, 
    -0.21706946f, -0.16260925f, -0.09861999f, -0.17234331f, 0.19080351f, 0.01939765f, -0.10741860f, -0.13092124f, 
    0.07272806f, 0.02364562f, 0.09629710f, 0.18368118f, -0.04932508f, -0.02332499f, -0.14751376f, 0.02616208f, 
    -0.25607127f, -0.19137920f, -0.11144252f, 0.35267034f, 0.04752115f, 0.05061062f, 0.05535758f, -0.08525491f, 
    0.01357888f, -0.14076464f, -0.02398187f, -0.00868809f, -0.18180178f, -0.17421556f, -0.30229267f, -0.06418353f, 
    -0.06645733f, -0.02527897f, 0.09592903f, -0.19943033f, -0.14309482f, -0.10485812f, -0.09701886f, -0.15693526f, 
    -0.04050301f, 0.27889940f, -0.03967155f, 0.08021405f, -0.14570211f, -0.05133968f, 0.03395837f, -0.14526017f, 
    0.17532831f, 0.12402301f, 0.22784084f, 0.32151878f, 0.13948350f, -0.37231010f, 0.21602255f, 0.13871193f, 
    0.27854365f, -0.06279983f, -0.22674830f, 0.05946945f, -0.19598860f, -0.07215225f, -0.21780257f, -0.19101655f, 
    0.26872501f, -0.09443673f, 0.40806165f, -0.11192700f, 0.07825699f, 0.02533370f, -0.04931830f, -0.08395223f, 
    0.01925953f, 0.12336622f, 0.07563052f, 0.01344683f, 0.21554148f, 0.34616774f, 0.09039176f, -0.02505220f, 
    0.03914662f, 0.10262380f, 0.01531667f, -0.14600989f, -0.02935825f, 0.08497306f, -0.22894512f, -0.15866470f, 
    0.10667460f, 0.17997783f, 0.08307532f, -0.24625987f, -0.04201511f, 0.04136084f, -0.12832102f, 0.03756746f, 
    -0.06638234f, -0.30083787f, -0.13207854f, -0.16420542f, 0.12580523f, 0.05771513f, -0.05340705f, 0.11792529f, 
    0.03192279f, -0.04671114f, 0.23564664f, 0.14002928f, 0.07650207f, 0.11091570f, 0.18891479f, 0.18780813f, 
    0.07329895f, -0.22353333f, 0.01808578f, -0.02401609f, -0.07308459f, 0.19522938f, 0.08180476f, 0.06015935f, 
    0.13186966f, -0.09094100f, -0.03282840f, 0.33058941f, 0.34323779f, -0.09400935f, 0.31258973f, 0.16513452f, 
    0.05155673f, -0.15660866f, -0.07074425f, -0.20219839f, 0.06716903f, 0.13991636f, 0.01061430f, 0.10772599f, 
    0.01333383f, 0.07590201f, 0.10800506f, 0.18467517f, -0.20898500f, -0.02918605f, -0.01428122f, -0.06778994f, 
    -0.06573232f, 0.19054194f, -0.07372041f, 0.05341271f, 0.52719635f, -0.10730552f, 0.24048357f, 0.08465061f, 
    0.10787806f, -0.02117264f, 0.05113434f, -0.14794333f, 0.03305095f, 0.28459173f, -0.00189043f, 0.22018830f, 
    0.04708974f, 0.03461229f, -0.02437624f, 0.11306098f, -0.10007171f, -0.07060999f, 0.14181425f, -0.04571903f, 
    0.09387718f, 0.34929100f, 0.13034400f, 0.21615611f, -0.40686110f, -0.03276310f, 0.05587962f, -0.04260893f, 
    -0.05134608f, -0.22646116f, 0.27779624f, 0.02869844f, -0.04286026f, 0.13781027f, 0.04677711f, -0.05464351f, 
    0.06544444f, -0.09072898f, 0.20163599f, 0.00874854f, -0.09050280f, 0.00266703f, 0.01758202f, -0.05795663f, 
    -0.10302538f, -0.03340223f, -0.17836355f, -0.34079048f, 0.11482477f, 0.14051586f, -0.09439174f, 0.15574004f, 
    0.06932098f, 0.06345726f, 0.03419587f, 0.12530005f, -0.11919056f, 0.00105960f, -0.20388375f, -0.04920198f, 
    -0.09244563f, -0.08532475f, -0.04085020f, 0.19717376f, 0.07909033f, 0.03183482f, -0.08055630f, -0.10162492f, 
    -0.05958026f, -0.14808761f, 0.06297818f, 0.01835747f, -0.11539918f, -0.10467493f, -0.18259348f, -0.15281162f, 
    0.08472098f, -0.02395092f, -0.33427721f, -0.31909165f, -0.11182520f, -0.15920024f, -0.20511407f, -0.12441044f, 
    -0.03022686f, -0.00699886f, -0.04426579f, 0.11501410f, -0.10284692f, 0.00838401f, -0.05409225f, 0.01246799f, 
    0.31203422f, 0.30427724f, 0.15402296f, 0.25113818f, 0.19549827f, 0.12778154f, 0.32632017f, 0.10179367f, 
    0.23327646f, -0.07704179f, 0.02110340f, -0.02569178f, -0.16906564f, -0.09206620f, -0.09691217f, -0.23073161f, 
    -0.05570641f, -0.07122205f, 0.02452943f, 0.20418432f, -0.03751658f, -0.09849604f, 0.09296910f, 0.06108888f, 
    0.14034192f, 0.08866700f, 0.14048554f, 0.11046731f, 0.22582722f, -0.12400752f, 0.05788657f, -0.24860355f, 
    0.16763549f, 0.05266414f, -0.05773317f, -0.06335255f, -0.03117231f, -0.03818564f, -0.22937787f, -0.12767255f, 
    -0.25976759f, -0.06470983f, -0.16965230f, 0.05783889f, 0.11201452f, 0.07741174f, -0.08618318f, 0.11008583f, 
    -0.04216892f, 0.05023124f, -0.01257685f, -0.06180617f, 0.05430042f, -0.20705824f, 0.00217748f, 0.09501602f, 
    0.01208892f, -0.03143780f, 0.05694284f, 0.03775191f, 0.00446116f, 0.10523255f, 0.04504662f, 0.23811433f, 
    -0.27442724f, -0.21926415f, 0.14042556f, 0.26181161f, 0.00118310f, -0.10516263f, -0.04431725f, -0.12339333f, 
    -0.03941824f, -0.05798754f, -0.03263796f, -0.16974995f, -0.32640898f, 0.11504097f, 0.05907717f, 0.17192024f, 
    -0.14474346f, -0.22468485f, -0.04804437f, 0.25468192f, -0.09305365f, 0.06333056f, 0.03071462f, -0.00488418f, 
    0.05059967f, 0.22002301f, 0.06172554f, 0.16258875f, -0.08677930f, -0.06043499f, -0.04155293f, 0.06154022f, 
    0.02742828f, 0.18173604f, 0.06431638f, 0.12068080f, -0.23343837f, -0.13850710f, -0.31081253f, 0.12233478f, 
    0.00670872f, 0.08590358f, 0.17879210f, -0.22303425f, -0.01907227f, 0.19695674f, 0.08736266f, 0.02418115f, 
    -0.18421495f, 0.37717313f, -0.15350737f, 0.08474496f, 0.22106029f, 0.09305041f, -0.13985717f, -0.04786755f, 
    0.11742095f, 0.07547946f, 0.04237143f, 0.12746507f, -0.13606517f, 0.43650916f, 0.20944959f, 0.08041236f, 
    -0.09976955f, 0.07877451f, -0.19875175f, 0.12464616f, -0.00364238f, -0.09202811f, -0.03300555f, -0.06352158f, 
    0.38891113f, -0.16489156f, -0.01771309f, 0.11036336f, -0.06180944f, 0.17334589f, -0.20401324f, 0.25023413f, 
    0.05559557f, -0.04435572f, 0.06874346f, -0.21818374f, -0.23635460f, -0.03066572f, 0.14641333f, 0.19002113f, 
    -0.19054338f, 0.07363637f, 0.04171744f, -0.05951920f, -0.03637264f, -0.00787223f, 0.10892558f, 0.05269786f, 
    0.32710904f, 0.04524778f, 0.08523267f, -0.24690180f, -0.10883656f, -0.08583696f, 0.00527188f, -0.00904708f, 
    -0.15462275f, 0.02231185f, -0.07386918f, -0.17289174f, 0.07625534f, 0.02936800f, -0.00111834f, 0.03310813f, 
    0.00980812f, 0.01910623f, -0.09397880f, -0.08150069f, -0.10825203f, -0.06057913f, -0.05151402f, -0.07023516f, 
    0.26964557f, 0.00347943f, 0.11177272f, -0.05238800f, -0.07228362f, 0.00560884f, -0.09668562f, 0.00121854f, 
    0.01137474f, 0.13564898f, 0.14496669f, 0.26523194f, 0.10748670f, 0.32937157f, -0.11896905f, 0.20358527f, 
    0.06390258f, 0.11941849f, -0.04463701f, 0.02187480f, -0.08143552f, -0.01034539f, -0.11339743f, 0.06969661f, 
    -0.06818340f, 0.05262783f, 0.02409549f, 0.01485252f, 0.03109137f, 0.01990350f, 0.05891196f, 0.13752432f, 
    0.03129780f, 0.19673233f, 0.03556079f, 0.26340070f, -0.06510276f, -0.18447126f, -0.12423455f, 0.34300137f, 
    -0.20686382f, -0.08712185f, -0.16976970f, -0.02412271f, -0.08775169f, -0.01056187f, -0.18170403f, -0.01664513f, 
    -0.14372768f, -0.02484887f, -0.23702127f, -0.05155134f, -0.00214149f, 0.18996999f, 0.20528887f, -0.13186842f, 
    -0.02001569f, -0.01985187f, 0.01754675f, -0.14951907f, -0.03702460f, -0.38101295f, -0.12318847f, -0.09757157f, 
    0.16026302f, -0.08246741f, -0.06849794f, -0.03724798f, 0.07514227f, 0.03509968f, 0.02010926f, 0.01539303f, 
    0.01905690f, -0.32702282f, -0.82277781f, -0.35392740f, 0.03266308f, 0.01077788f, -0.05371336f, -0.01094954f, 
    -0.00705038f, -0.08850373f, -0.07271431f, -0.08274595f, 0.00798471f, -0.18964222f, -0.16739620f, -0.06562902f, 
    0.11410506f, 0.04773598f, -0.09648311f, -0.17237391f, -0.08978536f, -0.05742655f, 0.04459333f, 0.12404237f, 
    -0.44459850f, -0.19472770f, 0.37734133f, -0.06248751f, 0.07691769f, 0.00975133f, -0.03522764f, -0.00215664f, 
    0.04749022f, 0.01299908f, 0.02098757f, -0.01441831f, -0.10455081f, 0.01748364f, -0.13187213f, -0.18638371f, 
    0.01471419f, 0.03110825f, -0.03745542f, -0.23392154f, -0.01080823f, 0.08499185f, -0.09689292f, -0.02935348f, 
    0.23742899f, 0.10822802f, 0.12953591f, 0.13774349f, -0.11954211f, 0.05607483f, -0.03666189f, -0.03971660f, 
    0.08886556f, 0.08915441f, 0.19889922f, 0.13322343f, 0.23063982f, -0.44450486f, 0.10618936f, -0.08707625f, 
    -0.05347700f, 0.02859814f, -0.12612343f, -0.05058566f, 0.09668311f, 0.17077862f, -0.04523036f, -0.08371787f, 
    0.05081600f, 0.20250462f, 0.11005469f, -0.02198712f, 0.19439432f, -0.06336790f, -0.03358708f, 0.02522573f, 
    -0.07831078f, -0.02485511f, 0.00873405f, -0.00909671f, -0.13951598f, -0.05554197f, -0.30356297f, -0.09473393f, 
    0.03890641f, 0.02741330f, 0.06308143f, 0.24764994f, 0.10929741f, -0.04706161f, 0.01348661f, 0.08486702f, 
    0.07781599f, 0.16613322f, 0.13472852f, 0.03582564f, -0.02586371f, -0.03486356f, 0.02953973f, -0.05916245f, 
    0.08011321f, -0.02154439f, 0.06065696f, -0.04925930f, 0.16242887f, 0.21166323f, 0.03095676f, 0.14165127f, 
    -0.02874230f, 0.04774282f, -0.08065761f, -0.04563639f, 0.08087243f, 0.03650500f, -0.13649595f, 0.01342692f, 
    0.18365012f, 0.13232811f, 0.19694188f, -0.01632504f, -0.02945147f, 0.00017716f, -0.00056469f, -0.04346846f, 
    -0.02284906f, -0.14106026f, 0.09841460f, 0.16505761f, 0.49496934f, 0.37863803f, 0.21420754f, 0.04037116f, 
    -0.09118839f, -0.01984068f, 0.05813449f, 0.07995824f, -0.02174914f, -0.02825184f, -0.00393378f, -0.00949653f, 
    0.21512875f, 0.10477589f, 0.17852725f, 0.05249440f, -0.01281602f, -0.05433191f, -0.06325427f, -0.01060999f, 
    -0.08454712f, 0.05271534f, 0.00109095f, 0.14714196f, -0.11503116f, -0.00723968f, -0.23302217f, -0.14363329f, 
    0.10950589f, -0.03701869f, 0.08794767f, 0.18796673f, 0.07976657f, 0.12915710f, -0.04964151f, -0.06420106f, 
    -0.17217678f, 0.09530668f, -0.07589515f, 0.02481067f, -0.00384842f, 0.03021173f, 0.26044843f, 0.19839785f, 
    0.01261873f, 0.03162147f, 0.05221723f, -0.09801269f, -0.18692045f, 0.23551010f, 0.11813359f, -0.09586739f, 
    -0.03018951f, 0.03249601f, -0.02189178f, 0.00732282f, 0.00623855f, -0.15125090f, -0.04855569f, -0.11711440f, 
    -0.05524971f, 0.08418292f, 0.19701648f, -0.06582928f, 0.04057072f, 0.02289408f, 0.22712362f, 0.01144781f, 
    -0.06629236f, -0.10195217f, 0.02019358f, -0.04717211f, -0.44593921f, 0.01224697f, 0.06531883f, 0.05285864f, 
    -0.05869965f, 0.12521081f, 0.04456764f, -0.01836749f, 0.07802053f, -0.08968464f, -0.08365878f, 0.03616364f, 
    -0.02240756f, -0.12893096f, 0.16213156f, -0.11634850f, 0.02164807f, -0.00590502f, -0.01795775f, 0.04044254f, 
    0.12443562f, -0.01607482f, -0.16245170f, -0.00519309f, 0.01949147f, -0.00859179f, 0.04358072f, 0.10999493f, 
    0.00829042f, -0.12001204f, 0.18020424f, 0.13897292f, -0.00717548f, 0.07153517f, 0.03384478f, -0.12313817f, 
    0.07643374f, -0.20659319f, 0.03182709f, -0.13540244f, -0.05520903f, 0.02990894f, -0.02186261f, -0.01033328f, 
    0.03702870f, 0.00068451f, -0.00811701f, 0.02572017f, 0.01397312f, -0.45031288f, -0.06294464f, -0.08544046f, 
    -0.11653628f, 0.02898263f, -0.00566561f, 0.17737883f, 0.09820798f, -0.01434794f, -0.01236149f, -0.05416817f, 
    0.25348425f, -0.09318413f, 0.25574008f, 0.11654712f, 0.42034104f, 0.18574584f, -0.02230512f, 0.11873672f, 
    0.01704459f, 0.05705642f, 0.06025254f, 0.03174963f, 0.18542925f, -0.03024865f, 0.15039694f, -0.11539385f, 
    -0.06700134f, 0.08126149f, 0.09931428f, 0.08048326f, 0.12731883f, 0.04093533f, -0.01035576f, 0.08440414f, 
    -0.01475756f, -0.01104098f, 0.16476162f, 0.13600866f, 0.05633193f, -0.08580344f, 0.00886272f, 0.02715017f, 
    -0.07101775f, -0.07475464f, 0.03925736f, -0.02951867f, -0.09242320f, -0.10886969f, 0.00518263f, 0.04511803f, 
    -0.02365102f, 0.04540910f, 0.04492255f, -0.03275730f, 0.06762548f, -0.01000310f, 0.11346322f, 0.24213111f, 
    -0.08279078f, -0.06112045f, -0.07340764f, -0.08944086f, 0.03786109f, -0.03370352f, -0.16931440f, -0.05363099f, 
    -0.01357965f, -0.05066615f, 0.02169021f, -0.23159868f, 0.47650021f, 0.19661993f, 0.03791258f, -0.09302794f, 
    -0.04409598f, 0.11220995f, -0.00713546f, 0.04528804f, 0.00861019f, -0.00400824f, -0.04922998f, -0.05130215f, 
    0.28185490f, -0.14457047f, 0.06989590f, 0.11492700f, -0.10047109f, -0.04173036f, -0.06205116f, 0.00608747f, 
    -0.04031562f, -0.02123506f, 0.19049743f, 0.00102162f, -0.01899021f, 0.06274781f, 0.07216813f, -0.05215575f, 
    0.06216200f, -0.01740091f, 0.09341190f, -0.02372383f, 0.01283240f, 0.01260374f, -0.09084490f, 0.03078146f, 
    -0.08096655f, 0.09377375f, -0.18070921f, -0.07426530f, 0.05969352f, 0.16793074f, -0.11935918f, -0.08666945f, 
    -0.00894802f, 0.10859490f, -0.01688375f, 0.11178520f, 0.15120888f, -0.13011619f, -0.01722496f, -0.09011576f, 
    -0.04511767f, -0.13138221f, 0.04208052f, -0.01223841f, -0.04350671f, -0.01035537f, 0.08618613f, -0.08141644f, 
    0.03296792f, -0.04730888f, -0.03305909f, 0.19979604f, -0.12193588f, -0.08905932f, 0.10406134f, -0.08048391f, 
    -0.07910231f, -0.07444569f, -0.09492630f, 0.06035177f, -0.10929383f, 0.19429612f, 0.07983108f, 0.22916937f, 
    0.07881960f, -0.08404339f, -0.00315449f, 0.07782099f, 0.02891490f, 0.04889205f, 0.04782065f, 0.16073263f, 
    -0.07995913f, 0.13359636f, 0.22850960f, 0.09851778f, 0.04569608f, -0.05826001f, -0.01961835f, 0.04234993f, 
    0.04027350f, 0.00842253f, 0.02933685f, -0.00931242f, -0.07966717f, -0.06110540f, -0.01016111f, -0.03955897f, 
    0.03350740f, -0.13477600f, 0.05462776f, -0.01797665f, -0.06078086f, 0.05589629f, -0.01179848f, 0.01210866f, 
    -0.15064849f, 0.05057334f, -0.11861952f, -0.03277515f, 0.02048150f, -0.03671305f, -0.00937527f, -0.04248120f, 
    0.00416962f, 0.10042693f, 0.00146501f, 0.03590020f, -0.45485556f, 0.01114656f, 0.27136382f, -0.02932353f, 
    0.14187208f, -0.03284388f, -0.08348496f, 0.08994342f, 0.10433810f, 0.00656016f, 0.13090366f, 0.03287072f, 
    0.32520387f, 0.02152516f, -0.27937025f, 0.05192964f, 0.11733924f, -0.00844334f, 0.01024002f, 0.17454310f, 
    -0.05220484f, -0.11167369f, -0.02830780f, -0.06272069f, 0.02805294f, 0.16037358f, -0.11559590f, 0.38296875f, 
    -0.06646675f, 0.08243904f, 0.06346788f, 0.18351118f, 0.03207772f, 0.04279469f, -0.01024570f, 0.00135210f, 
    -0.10613032f, -0.08179156f, -0.11421818f, -0.15650842f, 0.06046205f, 0.04246408f, 0.00077317f, -0.04630268f, 
    0.03635632f, 0.10085139f, 0.05668173f, 0.01781907f, -0.20595399f, -0.06686635f, 0.05594435f, -0.06195585f, 
    -0.00387926f, 0.06059191f, -0.06793248f, 0.07813383f, 0.01612221f, 0.02049626f, 0.10496791f, 0.11846668f, 
    0.05630947f, 0.12777063f, 0.16752259f, -0.14777459f, -0.18632048f, -0.05258885f, -0.03777340f, -0.06617308f, 
    0.09117043f, 0.07801601f, -0.11449555f, 0.02906523f, 0.09445048f, 0.16866264f, 0.21933319f, 0.20953731f, 
    0.15597072f, 0.19225928f, -0.13370851f, 0.05434753f, 0.03188630f, -0.04727752f, -0.04292079f, -0.02046185f, 
    -0.09622552f, -0.15195717f, -0.01729911f, 0.12767531f, -0.12751207f, -0.00466325f, -0.09595211f, 0.11345322f, 
    0.12633830f, -0.05292103f, -0.07457628f, 0.17894742f, 0.09652507f, 0.19525699f, 0.18190375f, 0.23357430f, 
    0.01581777f, -0.02284448f, 0.18350120f, -0.13836774f, -0.05952760f, 0.10236122f, -0.03219374f, 0.00761638f, 
    -0.04419832f, -0.12904967f, 0.14069110f, -0.15072742f, 0.02253650f, 0.03757025f, 0.15503664f, 0.15559515f, 
    -0.08209507f, 0.00719759f, -0.01354487f, 0.00046108f, -0.08292318f, -0.09657665f, -0.19750626f, -0.04498151f, 
    -0.03242306f, -0.04702734f, 0.08271992f, 0.04376995f, -0.00073235f, -0.07614560f, 0.04773558f, -0.07312233f, 
    -0.19189373f, -0.15397273f, -0.05588909f, 0.04122589f, 0.03782675f, 0.04776082f, 0.14722675f, 0.06509040f, 
    0.00003110f, -0.08042689f, -0.09786418f, 0.02233855f, 0.11708631f, -0.19359198f, 0.17403093f, 0.12721874f, 
    -0.01433607f, -0.07047548f, -0.02376022f, 0.10940906f, 0.12691481f, 0.06463241f, 0.09623110f, -0.00912651f, 
    -0.02305014f, 0.03966399f, 0.07278462f, 0.02258154f, 0.01140666f, -0.07812598f, -0.11333842f, -0.01071780f, 
    -0.00283458f, 0.09653681f, 0.11348875f, 0.05355251f, 0.36472848f, -0.12588389f, -0.08615160f, 0.08767993f, 
    0.01840231f, -0.08773544f, 0.11504732f, 0.05045493f, 0.02643141f, -0.05513860f, 0.08850294f, 0.13888142f, 
    0.00835751f, -0.17216550f, 0.01388946f, -0.00941595f, -0.01213138f, -0.04697126f, -0.03140932f, -0.04513101f, 
    0.07790065f, 0.04707869f, 0.12033769f, 0.06659890f, -0.42110181f, 0.01857720f, 0.32805353f, -0.13010390f, 
    -0.08477358f, 0.00203064f, 0.03411905f, 0.07289261f, 0.13826706f, 0.11309902f, 0.10292561f, 0.06176072f, 
    0.07790200f, -0.12532339f, 0.00443753f, -0.07888102f, 0.28967464f, 0.03945830f, 0.09270510f, 0.05660401f, 
    0.01130019f, 0.04591472f, 0.07651740f, 0.06357792f, -0.11471195f, 0.09673164f, -0.13109930f, 0.02104786f, 
    -0.08052231f, -0.02452203f, 0.05103821f, 0.06466962f, 0.04032007f, 0.01155293f, 0.04646275f, 0.05702389f, 
    -0.09909500f, 0.12085935f, 0.02958830f, -0.08929399f, 0.09486790f, -0.03242639f, -0.04126233f, 0.06396987f, 
    -0.01730393f, -0.06896427f, 0.00096389f, 0.00426265f, -0.14780633f, 0.10156845f, 0.09450190f, -0.01823350f, 
    -0.06799450f, 0.03744965f, 0.07112332f, 0.04773885f, 0.03734080f, 0.05842295f, 0.01312720f, 0.16665454f, 
    -0.06743017f, -0.10906774f, -0.02239522f, -0.03564864f, -0.08771494f, -0.09349860f, -0.03444160f, 0.01935941f, 
    0.12837920f, 0.09418098f, 0.05922999f, 0.01049946f, 0.08231645f, -0.07542788f, 0.25097713f, -0.18674752f, 
    0.06226128f, 0.07191253f, 0.05222678f, 0.04867039f, 0.10384069f, 0.00428603f, 0.00292389f, -0.20935024f, 
    0.20347680f, -0.06266423f, -0.02338288f, 0.05183102f, 0.10986738f, -0.01090581f, -0.14279173f, 0.03136094f, 
    -0.00464764f, 0.14926477f, 0.02407922f, 0.08072530f, -0.18981494f, -0.08448102f, 0.19868717f, -0.07453878f, 
    -0.03378804f, -0.05606493f, -0.11128419f, 0.05085709f, -0.10123491f, -0.06492089f, -0.03895603f, -0.04910801f, 
    -0.01186671f, 0.32336825f, 0.08719198f, 0.08788304f, -0.08585749f, 0.07410013f, 0.16116229f, 0.19215584f, 
    0.09493915f, 0.10589373f, 0.10422421f, 0.08822362f, 0.13701563f, 0.18587053f, 0.16040163f, 0.01107787f, 
    0.13909218f, 0.17703538f, -0.08247618f, 0.07639015f, 0.02252181f, 0.01026447f, -0.02682445f, -0.18280843f, 
    0.25618273f, 0.36020884f, 0.02036449f, -0.08479070f, 0.15942928f, 0.04383137f, 0.11282033f, 0.11812513f, 
    -0.00039959f, 0.04246025f, -0.10101267f, -0.10360963f, 0.01179233f, 0.02998798f, -0.04685142f, 0.02147598f, 
    -0.12738140f, 0.06359981f, 0.10088023f, -0.01985218f, 0.13088225f, -0.01522669f, 0.09149829f, 0.02699793f, 
    0.18079054f, -0.04072436f, 0.13347122f, 0.02563408f, 0.05305152f, 0.04694467f, 0.05970570f, 0.10899279f, 
    0.04415701f, -0.04535720f, 0.03373812f, 0.01905742f, -0.12230330f, 0.12561657f, 0.20398940f, -0.11592626f, 
    0.08059137f, -0.02819885f, -0.21678326f, 0.05792572f, 0.04837057f, 0.09435049f, -0.04372114f, -0.03183081f, 
    -0.12952065f, -0.11573751f, -0.03879964f, 0.02394029f, -0.09570583f, -0.09969897f, 0.01519898f, -0.10934184f, 
    -0.23590389f, -0.20415731f, -0.00236428f, 0.06870268f, 0.30310184f, -0.37854123f, -0.47960919f, -0.12196952f, 
    -0.15719672f, -0.02255804f, -0.11983109f, 0.04544156f, -0.00984237f, 0.07322830f, 0.08553823f, 0.01895023f, 
    0.02612836f, 0.00194606f, -0.07806816f, 0.02816769f, 0.05876990f, -0.10085361f, -0.00716573f, -0.06069998f, 
    0.03498201f, 0.09405887f, 0.05024806f, 0.11305326f, 0.31798562f, 0.15972573f, 0.21494246f, 0.06092574f, 
    0.27788976f, 0.16366127f, 0.02068865f, 0.19364142f, 0.03699049f, -0.06619417f, -0.08238739f, 0.05178311f, 
    -0.09505666f, -0.38286129f, -0.30029938f, 0.08327985f, -0.03791514f, 0.03545089f, -0.09098855f, -0.08726704f, 
    -0.11582301f, -0.07765245f, -0.11749916f, 0.07388057f, 0.03551613f, -0.17166333f, -0.26891375f, 0.01778100f, 
    -0.12237248f, -0.07003050f, 0.00782979f, -0.10217827f, 0.07788602f, 0.08400082f, 0.10381407f, 0.15324718f, 
    -0.07761776f, -0.11053360f, -0.14229327f, 0.02170762f, -0.04080725f, 0.11712472f, -0.04424410f, -0.05195380f, 
    -0.25463602f, -0.25555551f, -0.05413671f, -0.26603991f, -0.03408476f, -0.15129685f, -0.02462897f, -0.20905711f, 
    0.01849242f, 0.02470563f, 0.08454229f, 0.01591888f, -0.03975841f, -0.06594174f, -0.04674022f, 0.10631096f, 
    -0.21855868f, -0.11541987f, 0.04197703f, -0.23752747f, -0.08630886f, 0.02630359f, -0.03379380f, -0.17650153f, 
    -0.08346730f, -0.21086079f, 0.08051248f, -0.06071910f, 0.18408960f, 0.44469094f, 0.23103087f, -0.11300442f, 
    -0.00042463f, 0.01611948f, 0.29362467f, 0.22390972f, 0.19680646f, 0.08469482f, 0.24218918f, -0.01842295f, 
    -0.24867146f, 0.00800797f, -0.00876161f, 0.06621157f, 0.11790608f, 0.21295519f, -0.09220923f, 0.03045477f, 
    -0.14086592f, 0.03858654f, -0.00589061f, -0.04356525f, -0.12918267f, -0.29124430f, 0.02781776f, -0.09891716f, 
    -0.00693150f, 0.06375777f, 0.04014184f, 0.10900180f, 0.07920476f, 0.11926905f, 0.09168196f, 0.13093024f, 
    -0.23548169f, -0.21761638f, -0.39328533f, -0.46171013f, 0.06734312f, -0.14692305f, -0.18229845f, -0.08225251f, 
    -0.08337639f, -0.01455908f, -0.04252116f, -0.02616611f, -0.17847507f, -0.17215107f, -0.22919720f, -0.22664930f, 
    -0.07464217f, 0.00968189f, -0.15386751f, 0.20082842f, -0.01074761f, 0.01678094f, 0.23710456f, -0.05641882f, 
    0.31222913f, -0.00383768f, -0.09826504f, -0.03944208f, -0.01629601f, -0.02770401f, -0.05406971f, 0.16597567f, 
    0.05457495f, 0.00193442f, 0.17603336f, 0.03447245f, -0.09470470f, -0.07405651f, -0.25879228f, -0.05225454f, 
    -0.10777213f, 0.07273973f, 0.11240575f, 0.04363039f, 0.13059869f, 0.14309905f, 0.06956090f, 0.06313307f, 
    0.08226697f, 0.22225176f, 0.01684751f, 0.09823941f, 0.02096840f, -0.03366832f, 0.12740564f, -0.06272701f, 
    0.16075516f, -0.01886855f, 0.07082025f, 0.11727430f, 0.05431017f, 0.08589704f, -0.29566804f, -0.09940641f, 
    -0.06611643f, -0.01699878f, 0.02359076f, 0.04588350f, 0.07063206f, 0.02026735f, 0.11502865f, -0.01911152f, 
    0.41942549f, 0.05270468f, -0.07612959f, -0.00837261f, -0.15570430f, 0.08929565f, -0.13490334f, 0.23752421f, 
    0.03656243f, 0.05138412f, 0.05238414f, -0.08066770f, -0.30065879f, -0.39696607f, -0.13141516f, -0.13717753f, 
    0.01922262f, 0.01737396f, 0.11959931f, -0.06063167f, -0.05056382f, 0.00556456f, 0.00927766f, 0.02197874f, 
    0.35069430f, 0.07616383f, 0.01860577f, 0.06305496f, -0.09585121f, -0.05564454f, 0.11131703f, -0.06475808f, 
    -0.02596368f, -0.06180927f, -0.01913364f, -0.06877176f, 0.26809204f, 0.10249602f, -0.01143241f, 0.08607908f, 
    -0.01237093f, -0.04753666f, 0.08141067f, -0.10744610f, 0.11509374f, -0.02542464f, -0.01453294f, -0.09524225f, 
    0.11779948f, 0.07470990f, 0.01356098f, 0.04680154f, -0.09797824f, -0.00522737f, 0.05343262f, 0.02900459f, 
    0.11787387f, -0.04121454f, 0.14829665f, 0.08576747f, 0.16106004f, 0.18800910f, -0.07827661f, 0.24886996f, 
    0.14919755f, -0.07474049f, 0.08982494f, 0.01759467f, -0.09744369f, 0.00138241f, -0.08770612f, 0.11928529f, 
    -0.02562423f, 0.05110122f, 0.16558442f, 0.07250313f, -0.04090912f, 0.06926494f, 0.02418070f, -0.00488015f, 
    0.15529951f, 0.18351480f, -0.09150493f, 0.30057281f, -0.37204856f, -0.07638814f, -0.03690631f, 0.21502917f, 
    -0.08315595f, 0.10398947f, -0.07605468f, -0.19301659f, -0.10106848f, -0.00379397f, -0.01106166f, -0.08952473f, 
    -0.15614034f, 0.03144952f, -0.04436083f, 0.04094312f, 0.10439625f, 0.20404702f, -0.02502397f, -0.08062845f, 
    -0.15603296f, -0.05247002f, -0.00201960f, -0.01969326f, -0.28974515f, -0.41033474f, -0.20956345f, -0.25807533f, 
    -0.07282127f, -0.01402824f, 0.04670217f, 0.00210123f, 0.09795229f, -0.00914703f, 0.08908695f, 0.14313544f, 
    -0.50245512f, -0.53541988f, -0.81111920f, -0.69853920f, 0.06059694f, -0.22557792f, -0.16308707f, -0.12201219f, 
    -0.17958540f, -0.00406336f, -0.06925938f, -0.05386037f, -0.25712842f, 0.01618915f, 0.02435780f, -0.19093420f, 
    -0.13997971f, -0.02257547f, -0.00290428f, 0.06653792f, 0.02407576f, 0.10215678f, 0.00758242f, 0.08187947f, 
    0.48470142f, 0.10885888f, -0.09515834f, -0.22889140f, -0.09059083f, -0.04732282f, -0.02274937f, 0.05581805f, 
    0.31411666f, 0.00705902f, 0.21151741f, -0.05108595f, -0.63925683f, 0.06791497f, -0.06565478f, -0.24891268f, 
    -0.22504067f, 0.11337642f, -0.08685365f, -0.01104279f, 0.12696467f, 0.06712909f, -0.10844429f, -0.02562550f, 
    0.12435792f, 0.24691381f, 0.20345592f, 0.09946302f, -0.06715181f, -0.02510305f, 0.02533692f, 0.02745630f, 
    0.13210815f, 0.17850727f, -0.06163032f, 0.08194649f, 0.29027057f, -0.09962833f, -0.28653902f, -0.12171249f, 
    0.02235681f, -0.06955831f, -0.11599419f, -0.02875440f, 0.30639598f, -0.00553089f, 0.13836825f, 0.03420013f, 
    -0.00773675f, 0.21256980f, -0.04225432f, -0.03827424f, -0.05605470f, 0.11940490f, 0.00895834f, 0.04988770f, 
    0.04423075f, 0.00248725f, -0.01483919f, -0.13690080f, -0.28496739f, -0.49302533f, -0.46147129f, -0.29203445f, 
    0.06421567f, 0.12896392f, 0.05332088f, 0.07924946f, -0.01946009f, -0.01613293f, 0.05649396f, 0.11709398f, 
    0.20264263f, 0.03607274f, -0.03605936f, 0.13354416f, -0.06894829f, -0.03070393f, -0.04116811f, 0.02159562f, 
    0.02723067f, -0.01680891f, 0.05941416f, 0.05867283f, 0.13656552f, 0.09862922f, -0.01193490f, 0.19829328f, 
    0.07844967f, -0.02200981f, 0.00810970f, 0.04188614f, -0.00020904f, -0.07306723f, -0.03584221f, -0.09693395f, 
    0.10686313f, -0.02143062f, 0.19626601f, 0.05870681f, 0.01217997f, 0.00950661f, 0.12926455f, 0.05543292f, 
    0.09097023f, 0.02360447f, 0.28554460f, 0.15313645f, 0.29575256f, 0.02124981f, 0.07298172f, 0.39457887f, 
    0.23423949f, 0.03446717f, 0.11730309f, -0.09492147f, -0.05005304f, -0.09176568f, -0.00654003f, 0.11978976f, 
    0.04924253f, -0.01591014f, 0.21101262f, 0.19595844f, -0.07520819f, 0.04432987f, 0.07397350f, -0.03270886f, 
    0.20722108f, 0.18085700f, 0.16825239f, 0.18727331f, -0.32761455f, 0.05858514f, -0.31629291f, -0.08046776f, 
    0.11117576f, 0.19468173f, 0.15145175f, -0.14555882f, 0.03315420f, -0.06280690f, 0.00780901f, 0.01041131f, 
    0.01367562f, 0.12654191f, -0.01775753f, -0.00367399f, -0.10812578f, -0.00955356f, -0.14266796f, 0.01374579f, 
    0.02130801f, 0.04122256f, -0.01521325f, 0.11546955f, 0.19331524f, 0.01939612f, -0.08612756f, 0.03481492f, 
    0.03727593f, 0.08056391f, 0.04958581f, 0.02767476f, -0.01863768f, -0.01511832f, 0.00650164f, 0.07944256f, 
    0.44010988f, 0.11235188f, -0.19678749f, -0.26698968f, 0.02296648f, 0.16083020f, 0.01308383f, 0.03514703f, 
    0.02265554f, 0.00260635f, 0.02045823f, -0.03495747f, 0.34428328f, -0.06180405f, 0.09172750f, 0.12833041f, 
    0.09313603f, 0.01520632f, 0.01812739f, -0.16673318f, 0.05040606f, 0.10249501f, 0.06398053f, -0.00297048f, 
    0.23684704f, -0.04489997f, 0.07430086f, -0.05835581f, 0.02667722f, -0.13713254f, -0.02655314f, -0.01502203f, 
    -0.01293384f, 0.00690024f, 0.10629677f, -0.08501294f, -0.03103293f, -0.03448048f, 0.24333405f, -0.01415530f, 
    0.17776686f, -0.03108962f, -0.12223724f, -0.02825752f, 0.13057235f, -0.03464868f, 0.09683443f, 0.06888996f, 
    -0.04196324f, -0.10743966f, 0.07763761f, -0.05041488f, 0.03625093f, 0.04329235f, 0.04710826f, -0.06315509f, 
    -0.04325431f, -0.01237711f, 0.09005512f, 0.09381708f, 0.03481814f, -0.32651371f, -0.31627730f, -0.14513344f, 
    0.05729820f, -0.17799085f, -0.09480762f, -0.06146602f, -0.00492667f, 0.01936800f, 0.01597179f, -0.04853220f, 
    -0.11548158f, 0.10402174f, -0.26131055f, -0.12069123f, 0.05127445f, -0.24976103f, 0.05283666f, -0.12154181f, 
    0.05806332f, -0.03185628f, 0.05706774f, 0.00415103f, 0.18930632f, 0.08559328f, -0.02429222f, 0.05298517f, 
    0.14190552f, 0.07881342f, -0.04709877f, 0.23377796f, 0.09817763f, 0.04787977f, 0.05990732f, -0.01724420f, 
    -0.28733364f, -0.22793227f, -0.22875047f, 0.10457297f, 0.00612064f, 0.08881535f, 0.00062171f, 0.02309160f, 
    0.03865606f, -0.01933797f, -0.07270797f, 0.04015493f, -0.14620917f, -0.18910643f, -0.17393014f, 0.07605901f, 
    0.01511937f, -0.07656995f, 0.06917306f, -0.15209654f, 0.06663320f, -0.01394919f, 0.12837830f, 0.14787492f, 
    0.01850767f, 0.07562670f, -0.05347213f, -0.02668305f, -0.03195630f, 0.04290137f, 0.14497830f, 0.00540632f, 
    0.12155200f, -0.11291925f, 0.07231884f, 0.15037510f, 0.25853932f, -0.27796793f, 0.17289747f, -0.10715161f, 
    0.07480627f, -0.03542005f, -0.02497153f, 0.09359153f, -0.09094832f, -0.07683624f, -0.08762490f, -0.03414351f, 
    -0.12508786f, -0.19049944f, 0.17038725f, 0.00794264f, 0.01675288f, -0.01208086f, -0.06791862f, -0.04712203f, 
    0.08848552f, -0.12744144f, 0.01113712f, 0.07883438f, 0.35008815f, 0.38914394f, 0.06672413f, -0.17681780f, 
    0.10056137f, -0.11483875f, 0.10016272f, 0.12861678f, -0.01881697f, 0.01971993f, 0.00959665f, -0.09346753f, 
    -0.10465433f, 0.19529709f, -0.00942978f, 0.04780406f, -0.09896282f, 0.04100048f, 0.09051030f, 0.23152468f, 
    0.00288282f, -0.06180723f, -0.00241902f, 0.07242355f, 0.00186989f, 0.09824464f, 0.14147279f, -0.12468649f, 
    -0.03230974f, -0.07202235f, 0.01278700f, 0.15736428f, 0.06011267f, -0.00949995f, 0.00314570f, -0.13310170f, 
    -0.04887586f, 0.29268619f, -0.00829514f, -0.16475527f, 0.21062250f, -0.06802572f, 0.10750505f, 0.04326341f, 
    -0.08947355f, -0.02043775f, -0.02175095f, -0.11501046f, -0.51959538f, 0.12235693f, 0.08638349f, -0.00646431f, 
    -0.05727240f, 0.06598708f, -0.00246622f, 0.11204965f, 0.09269629f, -0.05514119f, 0.10198335f, -0.14573236f, 
    0.31522810f, 0.12949571f, -0.14436808f, -0.14715756f, -0.06115935f, 0.01880377f, -0.02184347f, 0.05047382f, 
    0.13222143f, -0.03095822f, -0.03385219f, -0.02727372f, -0.33324602f, -0.05516869f, 0.05364353f, -0.03184781f, 
    -0.00363787f, 0.02259416f, -0.00664447f, 0.21407461f, 0.17709439f, 0.07682470f, 0.09679740f, -0.12883221f, 
    0.09095219f, -0.05324921f, 0.04978165f, -0.02719621f, 0.05100873f, 0.00723303f, 0.04629452f, 0.00310039f, 
    0.00127373f, 0.05067775f, -0.11423306f, -0.02446397f, 0.18512401f, -0.04721689f, -0.36689824f, -0.17274186f, 
    0.02889957f, -0.00421411f, -0.02763456f, -0.05518429f, 0.16922054f, 0.06432663f, -0.03015410f, -0.11874375f, 
    0.19711141f, -0.02375487f, 0.11621983f, 0.16896790f, 0.13506758f, 0.10584477f, -0.03206981f, 0.05631554f, 
    0.01899253f, 0.00211576f, 0.11029165f, -0.05213528f, 0.14340618f, -0.01864787f, 0.08153401f, -0.08790258f, 
    0.12462899f, 0.02809743f, 0.07165937f, 0.02642520f, 0.05505106f, 0.07006356f, 0.08314209f, 0.07852191f, 
    0.04293759f, -0.07964464f, -0.01329562f, -0.00327158f, 0.02996923f, -0.05524472f, -0.01376187f, -0.00700644f, 
    -0.07472359f, -0.07288451f, 0.08136541f, 0.03872905f, 0.06226325f, -0.08485874f, 0.00257646f, 0.08042554f, 
    -0.01508915f, -0.01363578f, 0.03151585f, -0.09956837f, 0.05193369f, -0.06790472f, 0.10614439f, 0.11078033f, 
    -0.00817504f, -0.07519183f, -0.05056879f, -0.07396762f, 0.06365933f, 0.15071200f, -0.07191628f, 0.12976179f, 
    0.00579961f, -0.10212553f, 0.04550872f, -0.25614420f, 0.22853447f, 0.05817366f, -0.16054557f, -0.05448812f, 
    0.01956524f, 0.00044914f, 0.01437175f, 0.00418392f, -0.05337198f, -0.01477634f, 0.01156826f, 0.13096303f, 
    0.03165775f, 0.02660464f, 0.02287886f, 0.08139240f, -0.04566477f, 0.01416558f, 0.00221623f, 0.03112856f, 
    0.04389758f, 0.13901255f, 0.10978433f, 0.02342019f, -0.26767188f, 0.18399090f, 0.23456572f, -0.05684277f, 
    0.05654530f, 0.04902598f, 0.13685757f, -0.22783019f, 0.07836947f, -0.04601594f, 0.06443118f, 0.07454650f, 
    0.00652598f, -0.42490798f, 0.27132139f, -0.16629362f, 0.16275494f, 0.11242839f, -0.18854614f, -0.04356743f, 
    -0.06379406f, 0.00349620f, -0.09803036f, -0.13512017f, -0.06111676f, -0.08707036f, -0.08137296f, 0.25292316f, 
    0.17544296f, -0.03809808f, 0.06537588f, -0.00325348f, 0.12410590f, 0.07619549f, 0.05706399f, 0.23286383f, 
    -0.24566011f, -0.17396683f, -0.02788245f, 0.15529799f, -0.04332465f, 0.12483206f, -0.08000798f, 0.17463766f, 
    0.09267726f, -0.08894120f, -0.14372236f, 0.04931577f, 0.38264617f, -0.04104127f, 0.27882427f, 0.13480896f, 
    0.11081418f, -0.18046886f, -0.13741773f, -0.10274419f, -0.01921794f, 0.05802416f, 0.03796756f, -0.03029811f, 
    0.01081850f, 0.21512927f, 0.14190787f, 0.13698708f, -0.09221003f, -0.13687350f, -0.00213623f, -0.09236944f, 
    0.04408646f, 0.14172584f, 0.11202783f, -0.02515805f, 0.12129258f, -0.27603975f, -0.14307448f, 0.26074514f, 
    0.02826363f, 0.00346328f, -0.09707712f, -0.24249893f, 0.13949583f, 0.18190631f, 0.09403726f, 0.23287739f, 
    -0.00100903f, 0.20192228f, 0.05034204f, 0.11475244f, -0.00177013f, -0.00626273f, -0.13435154f, -0.04376325f, 
    0.19134326f, 0.07134413f, 0.06257480f, 0.12980652f, -0.18991192f, 0.13033442f, 0.44394055f, -0.03151837f, 
    -0.01657263f, -0.00814363f, 0.13200322f, -0.19379663f, -0.05093009f, 0.01216580f, -0.04696215f, 0.09301229f, 
    -0.18472302f, -0.07968548f, -0.15785472f, 0.04837038f, -0.05066770f, -0.02639210f, 0.06003528f, -0.11845030f, 
    0.01360568f, 0.01854267f, -0.00388075f, -0.21565950f, -0.16252799f, 0.07937358f, 0.00803744f, 0.29984754f, 
    0.01914362f, 0.11766990f, -0.06708776f, 0.06321859f, -0.07926778f, -0.04660140f, -0.00939230f, -0.01930168f, 
    -0.16643980f, -0.00019176f, -0.09277893f, -0.03435168f, 0.03230481f, -0.10644103f, -0.05766615f, 0.00064251f, 
    -0.01325245f, -0.12546296f, -0.10446660f, -0.08562710f, -0.00903046f, 0.07618413f, -0.08870295f, -0.17685732f, 
    0.00127772f, -0.04001428f, -0.09245330f, -0.15821962f, -0.11344502f, 0.00544278f, -0.11460442f, -0.07688420f, 
    0.14984095f, 0.13950045f, -0.02007291f, 0.02409551f, 0.05438049f, -0.07370817f, 0.19442645f, -0.00086503f, 
    0.02326150f, 0.14519982f, 0.07554568f, 0.29283726f, 0.04730899f, -0.01413762f, 0.20648877f, 0.07196590f, 
    0.20501594f, -0.03227868f, -0.00158056f, -0.16013248f, -0.12232653f, -0.12493573f, -0.17483392f, -0.13823828f, 
    -0.03553292f, 0.12605853f, -0.19990110f, 0.00716480f, 0.00482946f, 0.04868665f, 0.04507020f, 0.08046619f, 
    0.07328611f, 0.18444109f, 0.02456910f, 0.18458909f, 0.04720920f, -0.33680665f, 0.03127779f, 0.01152445f, 
    -0.16179144f, -0.00077833f, -0.06886929f, 0.10410801f, -0.05110361f, -0.13872024f, -0.11558799f, -0.07911155f, 
    0.08066280f, 0.12345140f, 0.19797570f, -0.00308557f, 0.09221780f, 0.07321833f, 0.12625399f, 0.16301699f, 
    0.10146250f, -0.06557349f, 0.02482536f, 0.11985275f, 0.02590174f, -0.00021397f, 0.16334809f, 0.06207135f, 
    0.06625991f, 0.05726189f, -0.01245686f, 0.09291354f, -0.01217288f, -0.08648894f, -0.10626914f, -0.11061930f, 
    -0.04771543f, 0.18968908f, 0.11237418f, -0.08580519f, 0.28989705f, 0.06592458f, 0.09314737f, 0.10823944f, 
    -0.00234396f, 0.01349104f, -0.08355370f, -0.14805950f, -0.02790378f, -0.03317954f, -0.05338168f, -0.21534567f, 
    -0.04377538f, -0.08962099f, -0.01631726f, 0.09458628f, 0.06687250f, -0.08650322f, 0.07578389f, 0.11754048f, 
    0.05267121f, 0.08389419f, -0.19880116f, 0.10255080f, -0.03440716f, -0.03441929f, -0.04461747f, 0.12618370f, 
    -0.06587248f, -0.04658457f, -0.02774920f, -0.02339140f, -0.01007174f, -0.04388977f, -0.02410784f, 0.02943694f, 
    0.03616423f, 0.12662393f, 0.03374377f, 0.15891495f, 0.00205132f, 0.06487117f, -0.04840826f, -0.02644772f, 
    0.06648033f, 0.30309445f, 0.05365577f, -0.05640233f, -0.00089987f, -0.04752695f, -0.05101004f, -0.04652277f, 
    0.10172270f, -0.01240934f, -0.00147396f, -0.21075246f, 0.19394344f, 0.22433133f, -0.21110363f, -0.02276651f, 
    -0.05547962f, -0.11868068f, 0.01354225f, 0.02190442f, -0.01091131f, 0.00399050f, 0.14447775f, 0.00882735f, 
    0.15122546f, 0.03903730f, -0.02796100f, 0.10454033f, -0.14378221f, -0.09227964f, 0.04261371f, 0.04573566f, 
    0.11423729f, 0.07194307f, 0.03730559f, 0.00783356f, -0.02076436f, -0.04954195f, 0.18466760f, -0.03157901f, 
    0.12749811f, 0.15046106f, 0.07967032f, 0.00711288f, -0.01294368f, 0.07518996f, 0.08595383f, 0.00867876f, 
    0.22271967f, -0.06648228f, -0.04605507f, 0.05650245f, -0.08190107f, -0.11196902f, 0.00114041f, -0.03972135f, 
    -0.05737299f, -0.08213761f, -0.02436637f, -0.04820590f, 0.14147265f, 0.05871952f, 0.02664772f, -0.01003133f, 
    -0.06872226f, -0.07278416f, 0.01052592f, -0.16025816f, 0.09397696f, 0.03009392f, 0.02108050f, 0.06631970f, 
    0.02710699f, -0.10222522f, -0.11299782f, 0.08811762f, -0.02984765f, -0.06259941f, 0.05352197f, 0.00305101f, 
    -0.02002654f, -0.11218038f, -0.05059859f, -0.26777497f, -0.24443159f, 0.12894373f, -0.15111399f, 0.11350830f, 
    -0.08472473f, -0.01986954f, 0.12556897f, 0.05819263f, -0.04260289f, -0.05093201f, 0.03898254f, 0.08181831f, 
    -0.23931862f, 0.24409291f, -0.04171242f, -0.00457314f, -0.07454406f, -0.06352176f, 0.00626873f, -0.09104116f, 
    -0.03126731f, 0.00702693f, 0.12637371f, -0.11787545f, -0.23052619f, -0.02890641f, 0.05961671f, -0.04859023f, 
    -0.00378346f, 0.11518932f, 0.04226197f, -0.07587792f, -0.03347539f, 0.01552046f, 0.17646678f, 0.00225333f, 
    -0.02279361f, -0.01409464f, -0.03187003f, 0.02046907f, 0.00884748f, 0.05700667f, 0.02926959f, 0.01276185f, 
    0.01131586f, -0.05447481f, 0.00518457f, 0.05591375f, -0.00101373f, 0.04310974f, -0.02829713f, -0.04701090f, 
    -0.06528556f, 0.04597261f, 0.01164202f, 0.06052086f, -0.06968176f, -0.05580467f, -0.03955432f, -0.00624794f, 
    -0.04430195f, -0.00758099f, -0.01020744f, 0.02146387f, 0.00193387f, 0.05700624f, -0.06592125f, 0.03541365f, 
    0.05862512f, 0.01210138f, 0.01145981f, -0.06611098f, -0.03962412f, 0.05595334f, -0.02451499f, 0.01561390f, 
    -0.00829069f, -0.03452859f, 0.04001669f, 0.04210006f, -0.03206966f, -0.08368215f, -0.00697957f, -0.04478633f, 
    -0.04281913f, 0.05619005f, -0.03831452f, 0.05805197f, -0.07775960f, -0.02679258f, -0.07030907f, -0.01125584f, 
    0.02343762f, 0.04327340f, 0.02730493f, -0.02518458f, -0.05522734f, 0.03908351f, 0.02998159f, 0.02978478f, 
    0.00481587f, -0.00344871f, -0.03644679f, -0.04217062f, 0.02583946f, -0.03173729f, 0.01937803f, -0.03155976f, 
    0.01416906f, 0.04198151f, -0.03495421f, 0.00798724f, -0.07761467f, -0.04586942f, -0.03635249f, -0.06930779f, 
    0.00096603f, -0.06434687f, 0.03365692f, 0.03690594f, -0.07324465f, -0.02857378f, -0.05000060f, 0.02741335f, 
    0.00499476f, -0.04371263f, -0.07157016f, -0.08369127f, 0.04125718f, 0.04119374f, -0.07202985f, -0.07578170f, 
    0.01113099f, -0.08050890f, 0.03040969f, 0.04793350f, 0.01786980f, 0.00638924f, -0.03111266f, -0.01289843f, 
    -0.04533358f, -0.05284214f, 0.02149975f, 0.01933635f, -0.04980177f, 0.05542662f, 0.02470053f, -0.07541107f, 
    -0.07314938f, 0.04457207f, 0.01356892f, -0.02690333f, 0.04742622f, 0.03305624f, -0.01630872f, -0.07548728f, 
    -0.03767681f, 0.03522595f, 0.02880559f, 0.00696151f, -0.04238362f, 0.00742426f, 0.02487605f, -0.00359622f, 
    -0.01489460f, -0.00654346f, -0.06696549f, -0.08285055f, -0.02962957f, 0.05509562f, -0.02448396f, -0.06634369f, 
    -0.07537727f, 0.00007581f, -0.01136265f, -0.02793679f, 0.01745957f, -0.01636633f, -0.02668314f, -0.00217704f, 
    -0.04862760f, -0.03185781f, 0.01156959f, -0.00576776f, 0.05059049f, -0.00620274f, -0.07024992f, 0.05809078f, 
    0.05053835f, 0.05281249f, -0.00249690f, 0.01547419f, -0.00797355f, -0.01841023f, -0.01704597f, -0.07529146f, 
    0.00200452f, -0.05406917f, 0.05503257f, 0.02466073f, -0.05485450f, 0.03589346f, -0.00525290f, -0.02952682f, 
    -0.08234449f, -0.02642806f, 0.00332454f, -0.02801396f, 0.06005486f, 0.00995297f, 0.03551025f, -0.01239562f, 
    -0.00670617f, -0.05157642f, 0.00278292f, -0.03055074f, 0.04658043f, -0.02975308f, -0.05144954f, 0.05052241f, 
    0.01257848f, 0.00556140f, -0.02150460f, -0.00234414f, 0.05717582f, -0.01987756f, -0.03175996f, 0.02953243f, 
    -0.06408393f, -0.09065707f, 0.07687135f, 0.23778795f, 0.10734633f, -0.09480578f, -0.03367539f, 0.09881046f, 
    0.00121770f, -0.06893785f, -0.02261550f, -0.10101968f, -0.00543319f, 0.09697329f, 0.15497750f, 0.17500243f, 
    0.00431999f, 0.01691732f, -0.10433282f, 0.03733075f, 0.14143097f, 0.13632506f, -0.10454563f, 0.19735442f, 
    0.06802167f, 0.26018500f, 0.17900954f, 0.22855337f, -0.06725315f, 0.14656495f, -0.11159573f, 0.04937292f, 
    0.06850312f, -0.04285499f, -0.00192543f, -0.00353277f, 0.36475825f, 0.17159253f, -0.09832295f, 0.07227869f, 
    0.05078644f, 0.03588267f, -0.01860579f, -0.00840341f, -0.00229636f, 0.08450085f, -0.00945894f, -0.10333987f, 
    0.07221059f, -0.12008081f, 0.10179397f, -0.08377820f, 0.02024582f, -0.03301356f, -0.05862902f, 0.01661623f, 
    0.07837893f, -0.00723945f, 0.02884794f, 0.02685786f, -0.03168458f, 0.13860425f, -0.06466464f, 0.04656516f, 
    -0.00092876f, 0.02703585f, -0.03630262f, -0.06480484f, 0.17955449f, 0.04293157f, 0.12410451f, 0.10085159f, 
    -0.14886279f, -0.19397303f, -0.09964985f, 0.05834715f, -0.06359478f, -0.03992233f, -0.05472431f, -0.06146406f, 
    -0.05486394f, -0.22339289f, -0.04767304f, 0.16907427f, 0.44071618f, -0.21782114f, 0.08235236f, 0.21970963f, 
    -0.12840742f, 0.07935913f, -0.04054248f, -0.20378323f, -0.00081809f, -0.04220122f, 0.00980106f, 0.14013094f, 
    -0.35723674f, -0.28124842f, -0.06114578f, -0.07146420f, 0.29685658f, 0.08466754f, -0.09098002f, -0.18908149f, 
    0.07391764f, 0.05778172f, 0.05532003f, -0.02992111f, 0.13655125f, -0.00984564f, 0.21496762f, 0.01249829f, 
    0.01119447f, -0.00401249f, -0.00665258f, -0.07481122f, -0.00888654f, -0.02093087f, 0.05740419f, 0.08130576f, 
    -0.30555531f, -0.25945362f, -0.34037814f, -0.22909585f, 0.02145397f, 0.07324647f, -0.08047614f, -0.05668523f, 
    -0.11516751f, 0.02129435f, 0.01052373f, -0.01998062f, -0.00494780f, -0.23861204f, -0.26434648f, -0.18491770f, 
    -0.00435379f, -0.00273737f, 0.02149575f, 0.05555433f, -0.09572572f, -0.01333930f, 0.02067711f, -0.21351247f, 
    0.05582180f, 0.06669996f, 0.00015146f, 0.02981089f, 0.08983357f, -0.00049754f, -0.00756337f, -0.04133592f, 
    -0.21081951f, 0.12545492f, 0.05132236f, 0.37799069f, -0.09714296f, -0.09782995f, -0.20240034f, -0.31545144f, 
    -0.11050910f, 0.04777484f, -0.07315700f, -0.05270277f, -0.07145455f, -0.01047504f, -0.12213794f, 0.05004375f, 
    0.15716836f, -0.16737375f, -0.03116768f, -0.38894832f, 0.09425284f, -0.02878796f, -0.03121512f, -0.05814208f, 
    -0.10097074f, 0.02181255f, -0.11011773f, 0.20843987f, 0.17601307f, -0.02944315f, -0.05899752f, 0.25294444f, 
    -0.15363894f, 0.03723911f, 0.01119323f, 0.19549815f, 0.04553102f, -0.04499094f, -0.15617789f, -0.03986781f, 
    -0.28079429f, -0.22995906f, 0.00472789f, -0.05620768f, 0.12913604f, -0.13410902f, -0.08539689f, 0.14164941f, 
    -0.08478670f, 0.05061420f, 0.01822353f, 0.06785761f, -0.15591444f, 0.05278137f, 0.11086428f, 0.09060709f, 
    0.08851062f, 0.01324425f, 0.06884892f, 0.00317839f, 0.11873522f, 0.10900990f, 0.01143434f, -0.00233895f, 
    -0.11794508f, 0.09923562f, 0.09916767f, 0.02764197f, -0.06376480f, -0.14733312f, 0.07703872f, 0.24446841f, 
    0.07116421f, 0.04056068f, 0.01393613f, 0.05579915f, -0.20241769f, 0.12004724f, 0.02739971f, -0.01715039f, 
    0.00056369f, 0.05084878f, -0.09671802f, 0.08816401f, -0.01314459f, -0.12468160f, -0.00100893f, -0.01313211f, 
    0.08697453f, -0.03272244f, 0.03228957f, -0.15922530f, 0.00073135f, 0.04220062f, -0.00933261f, 0.03775519f, 
    0.13478203f, -0.17578331f, 0.09340134f, 0.06394235f, -0.20829254f, 0.18551354f, -0.01910268f, 0.05843281f, 
    0.01380520f, 0.12693836f, 0.06614763f, 0.02571066f, 0.02791133f, -0.07102185f, -0.04250881f, -0.09001947f, 
    0.15883510f, -0.10472179f, 0.09672578f, 0.01549362f, 0.07033199f, 0.01436193f, 0.04587663f, 0.04815415f, 
    -0.21414714f, -0.21131042f, -0.24941102f, -0.12560365f, 0.28051174f, -0.12289622f, 0.06141854f, -0.15005521f, 
    -0.15325651f, -0.05907850f, -0.11830582f, -0.02486233f, -0.12612848f, -0.09454935f, -0.13648850f, -0.09183438f, 
    -0.05763576f, 0.07410522f, -0.03792309f, -0.04611671f, 0.24259688f, -0.09208769f, -0.12838186f, -0.08404055f, 
    0.09290638f, -0.01773183f, 0.04951854f, 0.09145553f, 0.11929534f, 0.11401309f, -0.02487645f, -0.09716834f, 
    0.11826228f, 0.09240337f, 0.14197150f, 0.10074925f, 0.17766353f, 0.09313675f, 0.10701377f, 0.17980686f, 
    0.12547532f, 0.07002082f, 0.07928620f, 0.01505093f, 0.01167331f, 0.03508803f, -0.03199681f, -0.07819486f, 
    -0.18532145f, -0.01250971f, -0.12288629f, -0.11421323f, 0.11953548f, 0.03736557f, -0.06722742f, -0.01768252f, 
    0.01286541f, 0.00425607f, -0.07098564f, -0.02525814f, -0.02944809f, 0.02295828f, -0.01262392f, -0.41532773f, 
    0.26875645f, 0.13642992f, 0.06237773f, 0.08723360f, 0.13932207f, 0.08060542f, 0.09601324f, 0.12158586f, 
    -0.26725632f, -0.07588311f, -0.04026099f, 0.09063700f, 0.00945852f, -0.17843705f, 0.04848297f, -0.17898691f, 
    -0.11742948f, 0.01307293f, -0.03241313f, 0.00820571f, -0.10808028f, -0.00928884f, -0.06214391f, 0.06032075f, 
    0.21425317f, 0.03617202f, 0.05766999f, -0.02997046f, -0.02171028f, 0.07503577f, 0.01199315f, 0.08920111f, 
    -0.04041554f, 0.16485006f, 0.07011231f, 0.04822544f, -0.06300778f, 0.02224979f, -0.03183886f, 0.04165817f, 
    -0.13098367f, 0.02935422f, 0.03345808f, -0.08330149f, -0.03622220f, 0.05733142f, -0.04457507f, 0.04556353f, 
    0.00834605f, -0.06491528f, 0.26969498f, -0.09922107f, -0.02477437f, 0.11487717f, -0.09013117f, 0.02039690f, 
    0.14409649f, 0.02104155f, -0.01771443f, -0.01246154f, -0.24224582f, 0.18157010f, -0.11556121f, -0.07790364f, 
    -0.05752895f, 0.09362176f, 0.09951102f, -0.03933093f, -0.05045846f, -0.02208319f, -0.08457588f, 0.01314862f, 
    -0.25594667f, 0.04436657f, -0.00565297f, -0.17388506f, 0.02714126f, 0.12619705f, 0.06627104f, 0.12191216f, 
    0.00376120f, 0.01319809f, 0.07739737f, -0.07590283f, 0.09796158f, -0.10720416f, 0.31689391f, 0.10548510f, 
    -0.06147425f, -0.07347783f, -0.04757616f, 0.01818498f, 0.16661476f, 0.04803705f, 0.03229509f, 0.05240443f, 
    0.32059428f, 0.17379794f, -0.02328343f, -0.17967957f, -0.01985212f, -0.04913698f, -0.05977327f, -0.05096780f, 
    0.03627930f, 0.12228084f, 0.10499611f, -0.10593824f, -0.05611065f, -0.39608571f, 0.19024734f, 0.22128248f, 
    -0.26576802f, -0.19800586f, -0.07912485f, 0.13685833f, -0.00492948f, -0.05774700f, 0.08774944f, 0.24809213f, 
    0.04343583f, -0.20365587f, 0.12657587f, 0.16632971f, 0.03750172f, -0.04823713f, 0.01503615f, 0.08548129f, 
    0.02975544f, 0.12439223f, 0.05647025f, 0.02587563f, 0.07613881f, 0.11672321f, 0.18450712f, -0.16916636f, 
    0.07517212f, -0.15436667f, -0.01242219f, -0.07790873f, -0.01318832f, 0.04235383f, 0.01729748f, 0.17010920f, 
    0.09227163f, 0.02474974f, -0.01295433f, 0.10988424f, -0.14341666f, -0.00176591f, 0.16390049f, 0.07991648f, 
    0.04093348f, 0.02239358f, -0.08282368f, 0.03778033f, 0.02422031f, 0.13304462f, -0.01719568f, 0.00449454f, 
    -0.03453507f, -0.00244360f, -0.06168791f, -0.02035670f, -0.01725187f, 0.00105496f, -0.05004042f, -0.10091942f, 
    0.05359039f, 0.06670491f, -0.14884046f, 0.14038160f, 0.03745081f, 0.08644591f, 0.09743316f, 0.04345628f, 
    0.08022057f, 0.01111954f, -0.10138769f, 0.07120419f, 0.02446536f, -0.00501015f, -0.10964605f, 0.09447803f, 
    0.05876493f, 0.04926382f, 0.08598479f, -0.01101636f, 0.06991906f, -0.03703062f, -0.19556868f, -0.01615671f, 
    0.17689438f, -0.06699538f, -0.06676358f, 0.06168924f, -0.09248865f, -0.06189919f, 0.19000199f, 0.01357137f, 
    0.06293717f, -0.04081890f, 0.06459334f, -0.04796734f, 0.21853298f, -0.35566053f, 0.06238640f, -0.10743575f, 
    0.17429920f, 0.04252219f, 0.12138803f, 0.07561865f, 0.07082631f, -0.06634680f, 0.02591555f, -0.15258171f, 
    0.18228121f, -0.13683441f, 0.15167932f, 0.15827879f, 0.02043188f, -0.01971297f, -0.00677938f, -0.03522341f, 
    -0.04044356f, -0.02237556f, 0.12889466f, 0.05687919f, 0.05382171f, -0.11914110f, 0.03870302f, -0.16890764f, 
    -0.02943671f, -0.00648673f, -0.14237049f, -0.22460687f, 0.14478838f, 0.06875529f, -0.00220620f, -0.03711894f, 
    0.23535974f, 0.06030475f, -0.04040752f, 0.03939218f, -0.20279163f, -0.07773092f, 0.06499758f, 0.01434936f, 
    0.06321691f, 0.08563025f, 0.00863203f, 0.07543961f, 0.19839072f, 0.03823676f, 0.06336880f, 0.06819107f, 
    0.02844103f, 0.00392344f, 0.00441361f, 0.07670248f, -0.07899547f, -0.05945977f, -0.10311527f, -0.09926059f, 
    0.23170581f, 0.15962261f, -0.23298122f, -0.01265181f, 0.11622420f, 0.17926562f, 0.10494766f, 0.06445589f, 
    0.00096276f, 0.07303043f, 0.05992863f, 0.09972031f, -0.01794905f, 0.16320543f, -0.02998200f, -0.02726968f, 
    0.04328617f, 0.08725934f, 0.18126947f, 0.11713950f, 0.13502540f, 0.02638054f, -0.02808055f, 0.01929125f, 
    0.05088497f, 0.08951348f, -0.23226690f, 0.17444243f, 0.07775380f, 0.03090606f, 0.03634330f, -0.01145404f, 
    0.11387704f, 0.02180766f, 0.02527634f, -0.21071458f, -0.22688858f, 0.11207362f, 0.29744300f, -0.04963387f, 
    0.14325942f, 0.03699999f, 0.07225763f, 0.13922966f, -0.05419002f, -0.15078136f, -0.12320119f, -0.12573259f, 
    -0.03623191f, 0.09300853f, -0.06026106f, -0.16433272f, -0.03210270f, -0.06675963f, 0.05345597f, 0.08996934f, 
    -0.18115444f, -0.04419114f, 0.02805488f, -0.04384790f, 0.16197379f, -0.07707913f, -0.33887064f, -0.03544185f, 
    0.08582439f, -0.01806904f, 0.02989039f, -0.05471130f, 0.02476649f, 0.04325939f, -0.01260697f, -0.18744196f, 
    -0.26370248f, 0.14883716f, 0.10137643f, 0.04499641f, 0.00107474f, 0.10779969f, -0.10648783f, -0.07685339f, 
    -0.03905447f, -0.02327159f, 0.02918452f, 0.02551845f, 0.22200778f, 0.05491885f, -0.04102764f, 0.01760393f, 
    0.18604757f, 0.14428122f, -0.08563630f, 0.19962622f, -0.00076769f, 0.07195533f, 0.09337746f, 0.05593682f, 
    -0.30041650f, -0.10479712f, -0.01104071f, -0.00880673f, -0.00806385f, -0.05781487f, -0.08233991f, 0.00893615f, 
    -0.05206030f, -0.03987145f, 0.10070465f, -0.04588135f, -0.22366621f, -0.11293376f, -0.01334450f, 0.00569845f, 
    -0.01456567f, 0.01567451f, -0.11136125f, -0.07161510f, -0.00131281f, 0.04577753f, 0.08546720f, 0.07551850f, 
    -0.15126318f, -0.12417044f, -0.07655635f, 0.09532284f, -0.02454933f, 0.04766991f, 0.04335362f, 0.10803139f, 
    -0.02938841f, -0.03026184f, -0.00056560f, -0.17682751f, 0.00741465f, -0.04225696f, -0.01840623f, 0.07023263f, 
    -0.03690900f, -0.13529870f, -0.00983230f, -0.12749308f, -0.02191202f, -0.02537817f, 0.04391244f, 0.07804834f, 
    -0.06883165f, 0.13976528f, -0.05365877f, -0.02509663f, -0.00409076f, -0.01056767f, -0.02314155f, 0.06307072f, 
    -0.03933216f, 0.01449091f, -0.01211243f, -0.15475850f, 0.13675992f, 0.30697751f, 0.06323119f, -0.26609540f, 
    0.19806096f, 0.06385148f, 0.21368371f, 0.10772482f, 0.25445089f, -0.03276955f, 0.20296645f, 0.02483431f, 
    0.04780075f, -0.01915186f, 0.13859379f, -0.07141431f, 0.00899308f, 0.24513924f, -0.18356287f, 0.25036427f, 
    0.08189687f, -0.00205275f, 0.03840012f, -0.04399802f, -0.03035110f, 0.02971804f, 0.00424669f, 0.01132240f, 
    0.15095119f, -0.15346022f, -0.02155540f, -0.02686207f, 0.09689230f, -0.00933275f, -0.00458847f, 0.03729839f, 
    -0.14284661f, 0.06721603f, 0.30402541f, 0.19322303f, -0.05413387f, -0.12815648f, 0.03154107f, 0.04113850f, 
    0.01668843f, -0.08683850f, 0.08919968f, -0.04108982f, -0.23433681f, 0.19463620f, 0.23550653f, 0.20194948f, 
    -0.10283105f, -0.09062345f, -0.06609321f, -0.00432763f, 0.06640875f, 0.06434625f, -0.06824094f, 0.10877556f, 
    -0.09484074f, 0.20541975f, 0.32404539f, -0.16874470f, 0.01849132f, -0.01253243f, -0.03247335f, -0.04577179f, 
    0.01139385f, 0.05678707f, -0.01352072f, 0.05043994f, -0.37909293f, -0.18455184f, 0.08711972f, 0.11075912f, 
    -0.00645096f, -0.07706618f, -0.15537496f, -0.20290768f, 0.02240913f, 0.06172677f, 0.04599623f, -0.03598472f, 
    -0.12520966f, -0.06032076f, 0.15182091f, 0.18340145f, 0.05993651f, -0.01098508f, -0.17136794f, -0.05209501f, 
    -0.07474356f, -0.03760229f, -0.19312014f, -0.04482249f, 0.25323167f, -0.05256061f, 0.38119400f, -0.23002355f, 
    0.02373182f, -0.10406154f, -0.22857243f, 0.10340233f, -0.05825084f, -0.03319944f, 0.08664147f, 0.10041493f, 
    0.16277312f, -0.07985230f, -0.13242279f, 0.05471573f, 0.12259011f, 0.05974470f, -0.00821177f, 0.03276641f, 
    0.04533276f, 0.14053367f, -0.00374554f, 0.02843748f, 0.10963506f, 0.15070093f, 0.15638469f, 0.30919492f, 
    0.06231811f, 0.19281116f, 0.11043268f, 0.15072297f, 0.08800369f, -0.03328568f, 0.01628541f, -0.16716313f, 
    0.15115629f, -0.25032744f, -0.11724469f, 0.01428621f, 0.00925613f, 0.01816377f, 0.00151099f, -0.05388629f, 
    0.20776033f, 0.06403746f, 0.05249265f, -0.00802048f, 0.10663817f, -0.24510857f, -0.12668005f, -0.07976655f, 
    -0.09929178f, -0.02444796f, -0.10040245f, 0.02163306f, 0.09629603f, 0.11701704f, 0.02088231f, -0.02374181f, 
    0.26260307f, -0.00221888f, 0.02744276f, -0.28935257f, 0.00611228f, -0.01263819f, -0.07495628f, 0.00553681f, 
    -0.06331479f, -0.04921144f, -0.20130901f, -0.12216057f, 0.28962415f, -0.06031372f, 0.14307950f, 0.01479790f, 
    0.00502603f, 0.10052113f, 0.06046073f, 0.12610762f, -0.06204984f, -0.21274108f, -0.05132769f, 0.03812785f, 
    -0.06002928f, -0.27304095f, 0.05120121f, 0.24227414f, -0.04036018f, 0.00880386f, -0.04882869f, 0.02170045f, 
    -0.07702793f, -0.02647380f, 0.03475102f, 0.03528047f, -0.12018016f, -0.02477290f, 0.18771006f, 0.19386978f, 
    0.01229208f, 0.05478308f, 0.09936815f, -0.10656152f, 0.12493043f, -0.06440137f, 0.08103807f, 0.12277945f, 
    0.07674603f, 0.08043727f, 0.12050564f, 0.05318717f, -0.09420213f, 0.01866122f, 0.30114233f, 0.13395268f, 
    -0.00632780f, 0.06739371f, 0.06236896f, 0.04721943f, 0.10567255f, -0.05107964f, -0.03940473f, -0.05436362f, 
    -0.03695290f, 0.00331860f, 0.00804644f, 0.06818431f, -0.14657396f, -0.17979342f, -0.21689887f, -0.20193015f, 
    0.06573302f, 0.14053570f, -0.13734278f, -0.08510955f, 0.23823802f, -0.00889419f, 0.08387370f, 0.05389095f, 
    -0.05888449f, 0.03685434f, -0.09608603f, 0.01318953f, 0.02825241f, -0.00668892f, -0.09134278f, -0.17069475f, 
    -0.01940288f, -0.03367982f, 0.04922188f, -0.00710118f, 0.08190025f, 0.07096080f, 0.17421871f, 0.03871758f, 
    0.17285593f, 0.02561663f, -0.21610373f, 0.01839081f, 0.01488734f, 0.04970101f, -0.02164943f, 0.08640721f, 
    0.05837744f, -0.13260724f, -0.03346625f, -0.08365825f, -0.04911432f, 0.01267052f, 0.04020535f, -0.07847689f, 
    0.06591252f, 0.03919709f, -0.12428252f, 0.16895616f, -0.02414548f, 0.01611958f, -0.06175819f, -0.13163756f, 
    0.10927105f, 0.18933846f, 0.08668122f, -0.06899582f, 0.00668513f, -0.08213969f, -0.05395976f, -0.02597130f, 
    -0.09370442f, -0.05404180f, 0.09722036f, -0.12257569f, 0.07185434f, 0.14529891f, -0.34859052f, -0.05467006f, 
    0.06430355f, 0.05800612f, -0.04080712f, 0.03792314f, 0.04855845f, 0.03025832f, 0.09672910f, 0.00621211f, 
    -0.09608450f, 0.14609961f, -0.05613636f, -0.03697406f, -0.04005693f, 0.02825078f, 0.11715414f, 0.01248399f, 
    0.01217241f, 0.06056821f, 0.08410093f, -0.04178414f, 0.01228555f, 0.00760015f, 0.03454269f, 0.04485120f, 
    0.14473030f, 0.20134196f, 0.02674124f, -0.00720588f, 0.04899208f, 0.10206049f, 0.08653545f, 0.08424716f, 
    0.02873056f, 0.08006229f, 0.00348907f, 0.07111372f, -0.03499130f, -0.07236323f, -0.07736569f, -0.09574180f, 
    -0.07740714f, -0.06856877f, 0.01266597f, -0.02894025f, 0.02261615f, 0.00830253f, 0.02308434f, -0.01860496f, 
    -0.04835912f, -0.12030589f, -0.05639691f, -0.14348215f, 0.10006910f, -0.04854940f, 0.09358232f, 0.11119897f, 
    -0.13886854f, -0.10984160f, -0.12827374f, 0.08339443f, -0.09203579f, -0.01634518f, 0.08795863f, 0.07118986f, 
    0.00845440f, -0.15864041f, -0.11300546f, -0.29534522f, -0.24489714f, -0.02267633f, 0.12257208f, 0.14883073f, 
    0.04013685f, -0.07637325f, 0.03824798f, 0.02488561f, 0.06099682f, 0.00110289f, 0.04137592f, 0.06331310f, 
    -0.06708271f, 0.24027821f, -0.07226574f, -0.09652036f, -0.06523739f, 0.00005811f, -0.00312714f, -0.18569572f, 
    -0.02635683f, 0.05268528f, 0.12900563f, -0.07474282f, -0.27133977f, 0.20418070f, 0.22890575f, -0.08827446f, 
    0.11715909f, 0.11567733f, 0.16996565f, 0.03517471f, -0.00039750f, 0.03043634f, 0.15444106f, 0.01267293f, 
    0.01185518f, -0.15952413f, -0.14510512f, 0.01428763f, 0.24018073f, 0.07034172f, 0.13725911f, -0.06670102f, 
    0.06490555f, 0.13208161f, 0.07919606f, 0.04602516f, -0.07830535f, -0.12305249f, -0.11898937f, 0.11026391f, 
    -0.01176563f, 0.12951022f, 0.04794635f, 0.02028892f, -0.07366121f, -0.09305372f, -0.05134034f, -0.25402674f, 
    0.08308771f, -0.27192768f, -0.19489017f, 0.09525497f, 0.18516044f, -0.00077168f, 0.17970860f, 0.07523070f, 
    0.03340423f, 0.09400944f, -0.01351466f, 0.11680887f, -0.17676702f, -0.02741460f, -0.16268009f, -0.14590211f, 
    -0.09910994f, 0.11342413f, 0.05574774f, 0.02912489f, -0.05094856f, 0.15332288f, 0.17125189f, 0.19463229f, 
    -0.10156760f, -0.12632947f, -0.08172408f, -0.08653475f, -0.03743976f, -0.01849278f, 0.04479463f, 0.12842155f, 
    0.20723066f, 0.01861165f, 0.06040965f, 0.11221479f, 0.28295669f, -0.06201350f, -0.08090194f, -0.09044413f, 
    0.01581967f, -0.00987700f, 0.06731238f, 0.07262581f, -0.13456023f, 0.00715492f, 0.09776388f, -0.06514205f, 
    0.10999902f, -0.02345421f, 0.02979522f, -0.01117396f, -0.02973351f, 0.00727865f, -0.06288148f, -0.04890323f, 
    -0.27183980f, -0.04495513f, 0.04740570f, -0.05440656f, -0.20074965f, -0.27906698f, -0.05540069f, -0.08296704f, 
    -0.02597643f, -0.02952183f, 0.04894443f, -0.06192350f, 0.27167341f, 0.10783059f, -0.01263270f, 0.08399089f, 
    -0.10070022f, 0.10944241f, -0.07387902f, -0.15206847f, -0.02469428f, 0.00269849f, 0.07483102f, -0.19421925f, 
    -0.04318560f, 0.01241124f, -0.01836894f, 0.02593068f, -0.13299884f, -0.16502619f, -0.26450351f, -0.19830336f, 
    0.02980831f, 0.07205915f, 0.03924957f, 0.01240576f, 0.12725066f, -0.00419266f, 0.15836792f, 0.17206450f, 
    -0.26425439f, 0.11708132f, 0.02222327f, -0.04328445f, -0.09162295f, -0.11937335f, -0.13574572f, -0.05375056f, 
    -0.06441213f, -0.22246934f, -0.23252824f, -0.09799563f, -0.35245383f, -0.00994647f, 0.06042783f, -0.13890569f, 
    -0.08163781f, -0.01651269f, -0.00398259f, -0.00633308f, -0.07479661f, -0.05593660f, 0.09538443f, 0.12583323f, 
    -0.08819811f, 0.02201839f, 0.11738650f, 0.10787142f, 0.07983971f, 0.02052088f, 0.07837789f, 0.06086180f, 
    -0.07159150f, -0.18552096f, -0.29024693f, -0.17697063f, 0.06168546f, -0.18260211f, -0.07120961f, 0.13666071f, 
    -0.06909935f, -0.05973847f, -0.12051768f, 0.04111262f, -0.02516100f, 0.03949633f, 0.04047330f, 0.08903342f, 
    0.24459086f, 0.10195579f, -0.07178110f, -0.02454710f, 0.00545384f, 0.02614346f, -0.01351407f, 0.10372331f, 
    0.04898981f, 0.03344882f, 0.11682671f, -0.12312683f, 0.23746127f, 0.08175987f, -0.19325618f, 0.08069774f, 
    0.06421246f, 0.15815318f, 0.14313804f, 0.13531104f, 0.06701113f, 0.03911933f, 0.01073404f, 0.02873129f, 
    -0.14842197f, -0.00436862f, 0.14759631f, -0.18308051f, 0.06649009f, -0.03842381f, -0.24214116f, -0.09816298f, 
    -0.06639983f, 0.08443981f, -0.09797685f, 0.03233438f, 0.11662049f, -0.07787807f, -0.16929114f, 0.01934299f, 
    0.04206596f, -0.12630735f, 0.23557846f, 0.17755789f, 0.08491222f, -0.16181202f, 0.16495441f, 0.05747061f, 
    -0.17741205f, -0.18254434f, 0.03212354f, -0.01813334f, -0.05864721f, -0.01478537f, 0.00123207f, -0.09814166f, 
    -0.03525374f, -0.11698280f, -0.04844383f, 0.14995064f, 0.06281825f, -0.02288648f, 0.12462282f, 0.17074402f, 
    -0.12724407f, -0.09500965f, -0.10466122f, 0.18096679f, 0.13853739f, 0.09611762f, 0.13809086f, 0.14039139f, 
    0.14324601f, 0.18813264f, -0.12248217f, 0.14287429f, -0.06569719f, 0.02991803f, -0.01124531f, 0.10045118f, 
    0.02996350f, 0.13355154f, 0.05702750f, -0.03086435f, 0.40630957f, -0.23279908f, -0.13164394f, 0.18586570f, 
    0.01593876f, 0.03069070f, 0.13565798f, 0.14714853f, 0.05524509f, 0.10587949f, 0.03005564f, 0.26247874f, 
    -0.09320830f, 0.22310762f, -0.17833075f, -0.06294553f, 0.07367396f, -0.15572418f, 0.06813130f, -0.01607024f, 
    0.03901926f, 0.34329695f, 0.00630273f, 0.10452904f, -0.56531399f, 0.28100654f, 0.08427212f, 0.03591308f, 
    0.02364335f, -0.01619409f, 0.11001822f, 0.03327966f, -0.00645736f, 0.05219905f, -0.02839095f, 0.07486151f, 
    0.36269340f, -0.13627508f, -0.09189481f, 0.16800687f, -0.16972786f, 0.07525914f, -0.04262367f, 0.23036976f, 
    -0.00245919f, -0.04302397f, -0.03251475f, -0.16098802f, -0.11444735f, 0.13313048f, -0.08004166f, 0.20676726f, 
    -0.08402058f, 0.08138155f, 0.06147356f, -0.05169810f, 0.00685296f, 0.00862176f, -0.03063469f, 0.02614169f, 
    -0.07019363f, 0.00915165f, -0.10441648f, 0.00236928f, -0.03461590f, -0.19174911f, -0.10570020f, -0.09583033f, 
    0.05434505f, -0.05260437f, -0.00941474f, -0.00629894f, -0.13908689f, 0.05024150f, -0.09685047f, -0.02322089f, 
    0.01866881f, -0.02461530f, -0.03835358f, -0.15170273f, 0.01291254f, -0.13258247f, -0.01492457f, 0.07573260f, 
    0.00292973f, -0.08015356f, -0.10825028f, 0.00892402f, 0.09390064f, -0.02018392f, 0.06588754f, 0.18178777f, 
    0.21647651f, 0.13278323f, 0.06290982f, 0.05937387f, 0.03285423f, 0.05605461f, 0.20073844f, 0.27032399f, 
    0.24635932f, -0.05560394f, -0.04291933f, -0.11758526f, -0.01621876f, 0.00973860f, -0.11814348f, -0.05014386f, 
    -0.02056010f, -0.21049522f, 0.08822583f, 0.14563294f, -0.09634873f, -0.00472745f, 0.02230986f, 0.09785946f, 
    0.14110613f, 0.23824742f, 0.13433017f, 0.17850998f, 0.06710455f, -0.14589874f, 0.11200545f, 0.11164745f, 
    0.02618482f, 0.06565410f, -0.13735637f, -0.12947409f, 0.01821858f, -0.07613674f, -0.11647499f, -0.14743055f, 
    0.07136089f, 0.07130095f, 0.04586137f, 0.10712119f, 0.06520246f, -0.02594878f, -0.06019883f, 0.03545636f, 
    -0.09419662f, -0.05519780f, -0.10332543f, -0.11653742f, 0.10208850f, 0.08915575f, 0.10995892f, 0.00958669f, 
    0.13749681f, 0.01858684f, -0.02076099f, 0.02631164f, 0.00349887f, 0.15381508f, 0.01794839f, 0.32173944f, 
    0.26859438f, 0.12033941f, 0.09677311f, 0.01882949f, -0.11109148f, 0.10421215f, -0.15740146f, 0.04230927f, 
    0.08540256f, -0.01693073f, 0.05233451f, 0.02325287f, 0.39813533f, -0.03771679f, 0.00832242f, -0.02162530f, 
    0.18191274f, 0.07844874f, -0.03998203f, 0.00022004f, -0.13758254f, 0.07530085f, -0.00390632f, -0.13643688f, 
    -0.04286954f, -0.24311818f, 0.07123834f, 0.04026851f, -0.04319478f, 0.01928303f, 0.00871231f, -0.01089088f, 
    -0.09637345f, 0.18118888f, 0.07284055f, 0.11296517f, 0.20085901f, 0.28433853f, 0.10943204f, -0.07704931f, 
    0.03037542f, 0.04114953f, 0.04632476f, -0.17231736f, 0.13370885f, 0.14074500f, -0.01324384f, 0.04063413f, 
    -0.02941018f, -0.12328894f, -0.07518183f, 0.05757869f, -0.02717801f, 0.04888337f, -0.00525704f, -0.10108970f, 
    0.11686982f, 0.12143300f, 0.14706084f, 0.17659777f, 0.31922317f, -0.06637962f, 0.13716170f, 0.24904662f, 
    -0.12764545f, 0.02619626f, 0.09447061f, -0.09773735f, -0.11431999f, -0.01236595f, -0.02118198f, 0.07888233f, 
    -0.14667755f, -0.11815605f, 0.23425585f, -0.05512760f, 0.09911161f, 0.00804720f, -0.10856478f, -0.05404340f, 
    -0.05066975f, 0.06700042f, -0.08288247f, -0.09535939f, -0.04972101f, -0.06079568f, -0.02516286f, -0.20984228f, 
    0.09617164f, -0.07917969f, -0.04134751f, -0.05228565f, -0.07785925f, -0.16298881f, -0.06954987f, -0.12500075f, 
    0.05861779f, 0.03463613f, -0.06539699f, -0.06178832f, 0.07548822f, -0.02407676f, 0.02384258f, 0.05797474f, 
    -0.03847355f, 0.03383528f, 0.06237722f, -0.00410545f, 0.07458299f, -0.03677495f, -0.13313854f, 0.01301999f, 
    0.02234017f, 0.06606468f, -0.01208645f, 0.08350562f, -0.01961971f, 0.00375034f, -0.10182098f, -0.13791010f, 
    -0.10424677f, 0.02074273f, 0.05946603f, -0.00627087f, -0.03614284f, 0.01996294f, -0.07918899f, -0.11331915f, 
    0.00173607f, 0.07917773f, 0.03401139f, 0.37401548f, 0.05118905f, 0.15714595f, -0.06287473f, -0.02621935f, 
    -0.16158646f, 0.02129469f, 0.10785627f, 0.03919187f, -0.09145882f, 0.06311841f, -0.03777523f, 0.08124153f, 
    -0.07743825f, 0.15562057f, -0.03792191f, -0.20659186f, 0.02846872f, 0.02934991f, 0.01062588f, -0.04370838f, 
    0.00597716f, -0.08803421f, -0.07563987f, 0.11812632f, 0.24916878f, -0.21644677f, -0.21268089f, 0.00438546f, 
    -0.00516736f, -0.11414936f, -0.17241202f, 0.33880419f, -0.11005937f, -0.05505980f, -0.07110276f, 0.02641809f, 
    -0.19101276f, 0.06781249f, 0.03169049f, -0.05797018f, 0.07337020f, 0.01845824f, 0.00806370f, 0.10446893f, 
    0.03891926f, -0.12327445f, -0.08490907f, -0.20077425f, -0.12537324f, 0.24812670f, 0.18951793f, 0.00996824f, 
    -0.00384854f, -0.02979176f, 0.02922712f, -0.09463374f, 0.06361295f, 0.02516251f, 0.12261608f, 0.05906469f, 
    -0.06184483f, 0.12133927f, 0.38461193f, -0.00606576f, -0.01571226f, -0.01704905f, 0.03195045f, -0.09623183f, 
    0.07993595f, -0.02157897f, 0.02289780f, 0.03289974f, -0.59323508f, 0.13306570f, 0.11491568f, 0.03808343f, 
    -0.10800049f, 0.13248543f, 0.04728499f, 0.07945394f, -0.02688944f, -0.11294322f, -0.01728444f, -0.01457491f, 
    0.11734644f, -0.10983469f, 0.09481027f, -0.19608222f, 0.01272173f, 0.04341496f, -0.03704446f, -0.11147391f, 
    0.02939177f, 0.05052191f, 0.04480707f, 0.05689768f, -0.12741312f, 0.04391209f, -0.12649071f, 0.24759372f, 
    -0.09263096f, 0.08291078f, 0.05796276f, -0.05156540f, -0.01620772f, 0.09955612f, 0.00944699f, 0.13302378f, 
    0.08478384f, -0.10042150f, -0.13850094f, 0.07883640f, 0.07391321f, 0.07687546f, 0.03505783f, 0.04363266f, 
    0.05772925f, -0.04072274f, -0.05142961f, 0.14387327f, 0.31359038f, -0.02421252f, 0.24230725f, 0.02643684f, 
    -0.18643831f, 0.09683643f, 0.03036165f, -0.03229963f, 0.09600783f, 0.09555507f, -0.04673869f, -0.14018817f, 
    0.28334212f, -0.14162660f, 0.31937167f, 0.19139154f, 0.09358335f, 0.15944368f, -0.01301507f, 0.15999964f, 
    0.04311081f, 0.05477145f, 0.05415141f, 0.01868942f, 0.08235198f, -0.03478993f, 0.18080236f, -0.15236910f, 
    -0.01407276f, -0.12919040f, 0.14997303f, -0.14518854f, -0.02529818f, -0.09956474f, -0.08204252f, 0.00480712f, 
    0.18452571f, -0.07991701f, 0.08908077f, 0.00713325f, 0.02203653f, -0.06492878f, 0.13712446f, -0.03442658f, 
    0.00209287f, -0.06623501f, 0.04876588f, -0.02387208f, 0.01745060f, 0.04145887f, -0.17011528f, -0.02943119f, 
    0.05672448f, 0.06013256f, 0.08680814f, 0.04636116f, 0.04181546f, 0.01873477f, -0.15132576f, -0.05063563f, 
    0.15886597f, -0.10168183f, 0.01129713f, -0.10042822f, 0.03095789f, 0.03604696f, -0.02406897f, -0.04146823f, 
    -0.14574425f, 0.00341355f, 0.12082997f, 0.04083402f, 0.23458008f, 0.12388348f, -0.25574327f, -0.08148757f, 
    0.07775347f, 0.02255553f, 0.10737458f, 0.06471273f, -0.09268708f, -0.01764599f, -0.02405132f, -0.00877046f, 
    0.00280562f, -0.14776683f, 0.07775626f, 0.11996839f, -0.06662241f, 0.10111370f, 0.14144759f, 0.05374752f, 
    0.04981447f, 0.03111311f, 0.10025343f, -0.07713921f, -0.00467513f, -0.30676192f, -0.15553537f, 0.18608955f, 
    -0.09183733f, 0.01212182f, -0.06464277f, -0.08764159f, -0.11097832f, 0.03170187f, -0.16187814f, -0.00587434f, 
    -0.23014906f, 0.34601417f, -0.27071461f, 0.16862205f, 0.04654055f, 0.05442154f, 0.02906184f, 0.07993059f, 
    -0.14055486f, -0.16168030f, -0.08513594f, -0.16203766f, 0.14753842f, 0.00175100f, 0.12028412f, -0.30927503f, 
    -0.02034569f, 0.02580530f, -0.09839075f, 0.11433804f, 0.00963420f, 0.09812005f, 0.10844751f, 0.20654196f, 
    0.29157865f, 0.13374151f, 0.17716061f, -0.12027193f, 0.05137296f, -0.05271695f, 0.09121558f, -0.14072581f, 
    -0.09371062f, -0.02837374f, 0.00639365f, -0.00918259f, -0.44039470f, 0.10065379f, -0.17150018f, 0.09532613f, 
    -0.07624039f, 0.12256534f, -0.01624224f, 0.06764885f, -0.07513505f, -0.06855116f, 0.08776855f, -0.08004107f, 
    0.12639430f, -0.30081397f, -0.05731206f, 0.04969609f, -0.00105808f, -0.04950412f, 0.08175632f, 0.10115495f, 
    -0.06116176f, 0.06971154f, -0.04376815f, -0.00095081f, 0.06668158f, 0.16581605f, -0.16659442f, -0.17147239f, 
    0.10357973f, -0.05408553f, 0.12822026f, 0.09044683f, 0.09901870f, 0.18779305f, 0.08818252f, 0.12143903f, 
    -0.04735347f, 0.10347080f, -0.10874928f, -0.01659286f, 0.06238041f, -0.02157902f, 0.12542151f, -0.04689107f, 
    0.19432183f, 0.14795114f, 0.02974582f, 0.24169080f, 0.00794529f, -0.13030566f, -0.28554344f, 0.08995789f, 
    -0.11749319f, 0.01852322f, -0.05213050f, 0.09586179f, 0.06017650f, 0.02208317f, -0.12019057f, -0.03261810f, 
    0.37850294f, -0.12238890f, 0.19678892f, 0.05912666f, 0.04533479f, 0.20909165f, -0.28091103f, 0.10946134f, 
    0.00231707f, -0.00676963f, -0.02928354f, -0.02840837f, 0.19070025f, -0.09785448f, 0.12630679f, -0.22885853f, 
    -0.16774306f, -0.16630964f, -0.02838959f, -0.03940089f, 0.09039581f, 0.02455691f, -0.03229858f, 0.11463244f, 
    0.19611222f, -0.09293794f, 0.08802414f, 0.03285059f, -0.04983863f, -0.02704496f, 0.00316620f, 0.03953665f, 
    -0.10945323f, 0.02498969f, 0.18616492f, 0.04666755f, -0.02374280f, -0.04367838f, 0.04522374f, 0.11462478f, 
    0.08599756f, 0.01091659f, -0.01255421f, -0.05046778f, -0.15691705f, -0.03761011f, -0.08233851f, 0.08616515f, 
    0.05235464f, 0.02724087f, 0.02219038f, 0.06125449f, 0.02922550f, 0.19466105f, -0.07796976f, 0.05773959f, 
    0.14749397f, 0.12703478f, 0.13178991f, 0.01839123f, 0.19155227f, 0.27448785f, -0.11862879f, 0.09115856f, 
    -0.04440166f, 0.11987164f, 0.00912358f, 0.07159977f, -0.04061672f, 0.06129103f, -0.07819384f, 0.00661285f, 
    0.03077159f, -0.10854740f, 0.12370692f, 0.04360429f, -0.00951515f, -0.08325268f, 0.11687054f, 0.09053040f, 
    0.09475690f, 0.04248798f, 0.09565805f, 0.25591254f, 0.22955559f, 0.25134003f, -0.18298815f, 0.14540276f, 
    0.06283004f, -0.02499957f, 0.05652796f, -0.12778604f, 0.10313806f, -0.04764325f, -0.04690762f, -0.01114491f, 
    -0.01563088f, 0.03021343f, -0.02743474f, -0.07425043f, -0.05445125f, -0.03892839f, 0.00658948f, -0.03231364f, 
    -0.02588000f, 0.00636111f, -0.05744101f, -0.00277581f, 0.04181422f, -0.02014444f, 0.03913900f, -0.07546032f, 
    0.02594375f, 0.06501147f, 0.02167139f, -0.02909840f, 0.05406712f, -0.08042037f, -0.06113554f, -0.02022553f, 
    0.02204979f, -0.01241316f, -0.07652502f, -0.00532242f, -0.03694497f, 0.03438345f, -0.04020647f, 0.04047704f, 
    0.02358565f, -0.02892392f, -0.05901257f, -0.00613966f, -0.02909216f, -0.06748829f, 0.00792019f, -0.03208965f, 
    0.03066507f, 0.05246421f, -0.00551323f, -0.06330216f, 0.05723953f, -0.02922468f, -0.06833196f, -0.02195557f, 
    -0.05183131f, 0.01314391f, 0.05839342f, -0.05978671f, 0.03925248f, 0.04900897f, 0.02042372f, -0.03170694f, 
    0.02631280f, 0.05671278f, -0.06392773f, -0.02911237f, -0.02569840f, -0.02559500f, 0.00126355f, -0.00219736f, 
    -0.02923454f, -0.02773189f, -0.02170676f, 0.04648003f, -0.02809177f, 0.01466019f, 0.06227098f, 0.03230068f, 
    0.04679947f, -0.02698554f, 0.02087267f, 0.06315877f, 0.03884618f, -0.06085702f, -0.04132964f, -0.01475152f, 
    0.01599166f, 0.02597022f, 0.04281441f, -0.03591353f, 0.02644314f, 0.05443126f, 0.01188906f, 0.00388915f, 
    -0.00885505f, -0.07168287f, -0.04651362f, 0.01962002f, 0.02914154f, -0.03319676f, 0.01980946f, -0.02826717f, 
    0.05981979f, 0.03746721f, -0.00114184f, -0.06218742f, 0.04231939f, 0.05876870f, 0.03905566f, -0.01701736f, 
    -0.03693589f, -0.03286802f, 0.05245005f, 0.06159655f, 0.05067606f, -0.05158418f, -0.04036044f, 0.05067085f, 
    -0.02686579f, -0.01910466f, -0.05376412f, 0.04737900f, -0.03649464f, 0.03678405f, -0.07758085f, -0.03152997f, 
    -0.06621050f, 0.05536632f, -0.02157265f, 0.04349764f, -0.06368608f, -0.03934252f, 0.06219050f, 0.03391990f, 
    0.05261336f, 0.04457062f, -0.03541052f, -0.06375194f, 0.01842566f, 0.00612940f, 0.00890546f, -0.01104764f, 
    0.05255258f, 0.01198985f, -0.00412605f, -0.06176499f, 0.01431601f, -0.02012687f, -0.04621014f, -0.04484207f, 
    -0.06685741f, 0.00169317f, -0.05279416f, 0.02909323f, -0.06386492f, -0.04202307f, -0.04980437f, -0.04492908f, 
    0.00216807f, -0.02760317f, -0.05199668f, -0.05038485f, -0.04923011f, -0.06990258f, 0.00696574f, 0.02574122f, 
    0.02104666f, -0.06738345f, -0.06997403f, -0.06323443f, 0.01823825f, 0.00318862f, 0.01050566f, 0.04900337f, 
    -0.01530656f, -0.03280940f, -0.03634069f, -0.04734019f, 0.00747907f, -0.02391825f, 0.01434804f, -0.06469771f, 
    -0.03714398f, -0.03450739f, 0.03120950f, 0.02577030f, 0.02075274f, -0.05115811f, 0.02675579f, -0.04888107f, 
    -0.07729464f, 0.01773323f, 0.01415507f, -0.04003504f, 0.04458421f, -0.05069532f, 0.00964569f, -0.03151327f, 
    0.16960363f, -0.24453443f, 0.12294316f, -0.00624424f, -0.00196507f, -0.03980152f, 0.16901235f, 0.08813278f, 
    0.12665817f, 0.02842705f, 0.05000198f, 0.02381602f, 0.08652024f, -0.06733717f, 0.03805866f, 0.21708858f, 
    0.27329451f, -0.06309694f, 0.05035266f, 0.03209540f, 0.01281201f, 0.06660736f, 0.03779314f, 0.03024681f, 
    0.04818898f, -0.13280104f, 0.00917037f, 0.06891691f, -0.05180695f, 0.05095429f, -0.16201954f, 0.12995172f, 
    -0.01701388f, 0.01361393f, -0.02765067f, 0.01886580f, 0.30359751f, -0.28276795f, -0.02221500f, 0.06732593f, 
    0.09775876f, 0.00119259f, -0.02807805f, -0.16323487f, -0.04437694f, 0.16378568f, -0.00406498f, 0.09272549f, 
    -0.33249885f, -0.14284299f, 0.14127277f, 0.01517872f, -0.02852567f, -0.08103435f, -0.07102142f, -0.03186519f, 
    0.13373089f, 0.05556297f, 0.02423398f, 0.02384379f, 0.35466063f, -0.10170413f, 0.03388282f, -0.07055139f, 
    0.23380189f, 0.05823406f, 0.04310197f, -0.19673984f, 0.10196909f, 0.08431087f, 0.03608568f, -0.03961524f, 
    0.11424247f, 0.04436917f, 0.05347288f, 0.04948870f, -0.06598849f, 0.05626222f, 0.00564237f, -0.12254546f, 
    -0.10267369f, 0.06862471f, 0.09089156f, -0.07011289f, 0.04296184f, -0.23958158f, 0.34564734f, 0.14918399f, 
    0.01678637f, 0.03609259f, 0.03549676f, -0.14001216f, -0.11524551f, -0.00978268f, 0.05393466f, 0.04153728f, 
    -0.18298590f, -0.11967515f, 0.12595937f, -0.25414863f, 0.28019202f, -0.08366129f, 0.03769163f, -0.08789424f, 
    0.03219855f, 0.10634550f, 0.11035839f, 0.06677562f, -0.17028344f, -0.06321593f, -0.00142068f, 0.16928729f, 
    0.11488786f, 0.12036245f, -0.00820164f, 0.18546908f, 0.03667439f, 0.08390667f, 0.03267631f, -0.09529416f, 
    -0.16382794f, 0.18920346f, -0.04495075f, -0.03677806f, -0.05388258f, 0.03560517f, -0.03466045f, 0.06882221f, 
    0.04132500f, -0.09674433f, 0.02690362f, -0.01380061f, -0.03131692f, 0.12744114f, -0.03876716f, -0.01022740f, 
    -0.10511521f, 0.04088344f, 0.04163202f, -0.04360696f, -0.04153983f, 0.02458696f, 0.02569871f, 0.10536169f, 
    0.05536207f, -0.04692949f, 0.05373575f, -0.06414853f, 0.06905856f, -0.10461758f, -0.00385556f, 0.02780117f, 
    -0.11659679f, 0.12487762f, -0.05023029f, 0.09042078f, 0.13115127f, 0.26459959f, 0.10758235f, 0.06653029f, 
    -0.12553217f, 0.06714544f, 0.05701780f, -0.09663686f, -0.05776615f, -0.03121902f, 0.03480808f, 0.00249423f, 
    0.08360893f, 0.12606587f, -0.14795008f, -0.05198890f, 0.07746340f, 0.00900865f, -0.03796237f, 0.00355685f, 
    -0.01508110f, 0.08060393f, -0.05793407f, 0.04398076f, 0.00496111f, -0.31819376f, -0.16630755f, -0.13772452f, 
    -0.03159241f, -0.03879265f, -0.07265855f, 0.34944257f, -0.09108179f, -0.07726622f, -0.02576444f, 0.12340122f, 
    -0.28190914f, -0.17009553f, 0.13159099f, -0.07534218f, 0.20250016f, 0.10573515f, -0.07685068f, 0.18131082f, 
    -0.02736700f, 0.03988097f, -0.02620322f, 0.01413220f, -0.30559206f, 0.10140269f, -0.05559090f, -0.15623201f, 
    -0.08615308f, 0.04729149f, -0.01998309f, -0.00283914f, 0.07241709f, 0.13073285f, -0.00617128f, -0.02928031f, 
    -0.25057277f, 0.01082941f, -0.03200827f, -0.03041402f, -0.07530221f, -0.05707278f, 0.06217996f, 0.00355450f, 
    0.03860224f, 0.02431266f, 0.06229614f, 0.01891368f, -0.29699895f, 0.26250032f, 0.37812611f, 0.21005510f, 
    -0.10052676f, -0.06599750f, -0.13176242f, 0.07816041f, 0.03050859f, -0.01254441f, 0.09809097f, -0.07389062f, 
    0.30843428f, 0.17535216f, 0.14589655f, -0.27327359f, 0.02817413f, -0.02528429f, -0.06266481f, 0.02397759f, 
    0.07528546f, 0.12834787f, 0.08859577f, 0.10828766f, -0.19022654f, 0.09247471f, -0.02293736f, 0.26312718f, 
    -0.19541714f, 0.05908781f, -0.02085121f, -0.01721005f, 0.03071558f, 0.07026605f, 0.18677561f, 0.15023600f, 
    0.01118775f, -0.32776183f, 0.06073881f, 0.14587985f, 0.02601241f, 0.05980350f, 0.03949239f, 0.11051887f, 
    0.06892135f, 0.00683801f, 0.02140673f, 0.11189998f, 0.15693615f, 0.11183686f, 0.24105966f, -0.12850168f, 
    -0.13414408f, -0.13744195f, -0.12409347f, 0.01408308f, 0.07332948f, 0.12838180f, 0.11333045f, 0.16902892f, 
    0.28812736f, 0.06191276f, -0.16926116f, 0.07988799f, 0.25281200f, 0.04473110f, 0.35293359f, 0.09171025f, 
    -0.02827048f, -0.01147550f, 0.08144433f, -0.00858201f, -0.03593178f, 0.01370331f, -0.04767990f, -0.16822527f, 
    -0.01310260f, -0.07077511f, 0.02107934f, -0.09209538f, 0.07157623f, -0.00888736f, 0.04365660f, 0.00191783f, 
    0.14599481f, -0.03211818f, -0.10197587f, -0.15346688f, -0.08200546f, -0.02615031f, 0.13518247f, 0.08559109f, 
    0.03105323f, -0.05647524f, -0.17145993f, -0.01751536f, 0.10873690f, -0.04515206f, 0.02878988f, -0.09350060f, 
    0.02326088f, -0.06979185f, 0.14425683f, 0.06011081f, 0.12609239f, -0.00291154f, 0.00275176f, -0.12954359f, 
    0.16858797f, -0.01510195f, -0.12116852f, -0.16503480f, -0.01344232f, -0.03612515f, 0.07303422f, 0.00030289f, 
    0.04349478f, -0.06146860f, 0.12821399f, 0.08874979f, 0.19024155f, -0.43211192f, 0.08455195f, -0.30135101f, 
    0.19501106f, 0.20416632f, -0.10964368f, 0.10217055f, -0.08131837f, 0.02157164f, 0.00558738f, -0.05731907f, 
    0.13927123f, -0.11297467f, 0.06448887f, 0.08332033f, -0.02250704f, 0.09531916f, -0.02143627f, 0.06472422f, 
    0.09642864f, 0.01132707f, 0.04558947f, -0.01760165f, -0.03860117f, -0.00841141f, 0.12705614f, 0.31630185f, 
    0.05778253f, -0.05815417f, -0.05860813f, -0.17347786f, -0.17210147f, 0.06640800f, -0.14563785f, -0.01968059f, 
    -0.07064413f, -0.12049431f, 0.09070861f, 0.11692689f, -0.04135340f, -0.05691608f, 0.14740138f, 0.20240508f, 
    0.12744106f, -0.19002956f, 0.02471613f, -0.10095567f, 0.00079989f, 0.32362434f, 0.19206996f, 0.19423476f, 
    0.08342558f, 0.14133231f, -0.16586016f, 0.00644888f, 0.14253874f, 0.18687160f, -0.13973142f, 0.08127470f, 
    0.19193359f, 0.37891141f, 0.32627517f, 0.15067050f, 0.06225705f, 0.11170366f, 0.03131364f, 0.10413212f, 
    0.00939920f, -0.04167863f, -0.02320227f, -0.14472172f, 0.17524995f, 0.06762055f, -0.04556145f, -0.01826677f, 
    0.06391257f, 0.05088722f, 0.08369696f, -0.02215177f, 0.06512215f, 0.05854517f, -0.00666898f, -0.09406996f, 
    -0.00572578f, -0.20852496f, 0.12155718f, -0.06672805f, 0.03806151f, 0.02665550f, 0.02657190f, -0.04732955f, 
    0.05509146f, -0.05504430f, -0.02057299f, 0.11761472f, -0.08252846f, 0.13539565f, -0.05934224f, 0.07649062f, 
    0.11059863f, 0.01628713f, -0.03675496f, -0.01126594f, 0.14089668f, 0.00793332f, 0.12492610f, -0.00388283f, 
    -0.10143398f, -0.40836236f, -0.04910984f, 0.04189505f, -0.12447296f, 0.02237390f, -0.12733950f, 0.08698199f, 
    -0.06272269f, -0.18122755f, -0.06843979f, -0.01746764f, 0.52343106f, -0.09501846f, 0.09785090f, 0.09274942f, 
    -0.27700669f, 0.10778972f, 0.08014783f, -0.07919929f, -0.09436098f, -0.00573195f, -0.07586757f, 0.02441967f, 
    -0.23898277f, -0.30881810f, 0.17746060f, 0.05052424f, 0.28575948f, -0.01924168f, -0.07572399f, -0.13799357f, 
    0.08704104f, 0.08690292f, 0.06189870f, 0.05583560f, 0.13877019f, -0.03458703f, 0.23439464f, -0.13082440f, 
    0.02572428f, -0.11674851f, 0.09417800f, -0.05411656f, -0.04280596f, -0.09514549f, -0.09285229f, 0.10103551f, 
    -0.19533446f, -0.31026250f, -0.47629628f, -0.57266861f, -0.00168225f, 0.07545239f, -0.03974907f, -0.16299208f, 
    -0.15204555f, 0.02186589f, -0.00301851f, -0.07924849f, -0.02184357f, -0.17806320f, -0.35389921f, -0.31744882f, 
    0.00315234f, 0.09365597f, 0.05017609f, -0.06206638f, -0.08478975f, 0.02612510f, -0.05156510f, -0.07162797f, 
    0.00287661f, 0.03240183f, -0.08842255f, -0.14036307f, 0.07386404f, -0.07432579f, -0.04608731f, -0.15938127f, 
    -0.21207772f, -0.09090138f, -0.04648444f, 0.13080278f, -0.10139211f, -0.07098199f, -0.33962780f, -0.52117711f, 
    -0.31341097f, -0.00551350f, -0.00360291f, -0.05672601f, -0.03857243f, 0.06822245f, 0.02178594f, 0.16017821f, 
    0.13627487f, -0.02533214f, -0.09126837f, -0.30643117f, 0.11044169f, -0.06356938f, 0.15964749f, 0.02027279f, 
    -0.07770120f, -0.12174797f, 0.03803576f, 0.00045903f, 0.16691811f, -0.01214361f, -0.27106437f, 0.13824704f, 
    -0.16363360f, 0.00167487f, 0.00748738f, 0.24622290f, -0.06017925f, -0.20007043f, -0.11384807f, 0.14565372f, 
    -0.21143590f, -0.12721539f, 0.08977617f, 0.03693632f, 0.14050511f, 0.19802679f, -0.10447691f, -0.00018507f, 
    0.06490584f, 0.11863391f, 0.06784201f, 0.06072705f, -0.10928152f, -0.04035968f, -0.08194265f, 0.05041951f, 
    -0.07771132f, -0.08421142f, 0.14216414f, 0.09427116f, -0.00943376f, -0.12955905f, 0.10636395f, 0.06404440f, 
    -0.22895245f, -0.12717222f, 0.14887463f, 0.11604205f, -0.07108063f, -0.09415177f, -0.00108689f, -0.13861439f, 
    0.04138562f, -0.03476822f, -0.09442846f, -0.08739007f, -0.06957340f, -0.03496975f, -0.04352522f, -0.02577249f, 
    -0.08279420f, -0.04005803f, -0.07682423f, 0.17977773f, 0.08730245f, 0.09014359f, 0.00967234f, 0.08400677f, 
    0.03088423f, 0.18432966f, 0.11595329f, 0.07066703f, -0.01994796f, -0.08839079f, -0.04737544f, 0.06445619f, 
    0.18220741f, 0.10579972f, 0.19396132f, -0.05259615f, -0.12615046f, -0.21843591f, -0.25945637f, -0.00785197f, 
    -0.05764335f, -0.01441362f, -0.00518853f, -0.04570687f, 0.09438741f, 0.11595831f, -0.02189935f, 0.01785827f, 
    -0.16437007f, 0.09293566f, -0.02070403f, -0.11186364f, 0.02604121f, -0.05245644f, -0.09681137f, -0.07703380f, 
    0.00035252f, -0.03148565f, -0.08890202f, -0.08542641f, -0.18766122f, 0.12194783f, 0.24875455f, 0.06192127f, 
    -0.08423000f, 0.02678365f, -0.14998148f, 0.07972818f, 0.00073739f, 0.05726272f, 0.02656808f, 0.16331089f, 
    0.42474762f, -0.10462987f, -0.21893804f, 0.08920485f, 0.07478011f, 0.23452944f, 0.03134831f, 0.17132132f, 
    0.05748089f, 0.11069307f, 0.01402167f, -0.04824786f, -0.12753604f, 0.17373364f, 0.05751268f, 0.18793628f, 
    -0.09400526f, 0.01548270f, 0.15001474f, -0.00366368f, 0.05441676f, -0.14126639f, -0.00547501f, 0.06140091f, 
    0.10193577f, 0.12221261f, 0.08924655f, -0.08669112f, -0.06015031f, 0.01424966f, 0.01626513f, -0.03669643f, 
    0.15396203f, 0.06173367f, 0.00059648f, -0.07040129f, 0.11631181f, 0.15592036f, 0.14211048f, -0.07419595f, 
    -0.01527087f, 0.05426285f, 0.09499276f, 0.00261301f, 0.13050501f, 0.13949849f, 0.08395091f, 0.03061785f, 
    0.13599059f, 0.01585423f, -0.15532935f, -0.22283679f, -0.04620670f, -0.10121521f, -0.11079650f, -0.04715563f, 
    -0.05787671f, -0.06159449f, 0.02142413f, 0.05280099f, -0.02855278f, 0.10182490f, 0.05363204f, 0.10200526f, 
    0.06493461f, 0.14472431f, 0.04099285f, -0.03567634f, 0.09485749f, -0.05077386f, 0.00296994f, 0.02507506f, 
    0.07785212f, -0.10236362f, 0.04733364f, -0.01632220f, 0.00772271f, 0.01244818f, -0.09195425f, -0.00878538f, 
    0.01161518f, 0.10565391f, -0.11341172f, 0.13648619f, -0.14379852f, -0.00315176f, 0.17210424f, 0.40138400f, 
    -0.13455273f, 0.12791142f, 0.05530927f, -0.13027140f, -0.03360389f, 0.07721212f, -0.04453505f, -0.02398428f, 
    -0.11837845f, 0.04877876f, 0.01603089f, -0.03680325f, 0.05306455f, 0.09261513f, 0.20842773f, 0.05867643f, 
    -0.02317795f, 0.07743137f, 0.06305990f, 0.02038946f, 0.14940391f, -0.17363667f, -0.02851880f, 0.00214609f, 
    0.06031151f, -0.02716031f, 0.07920706f, 0.02327866f, 0.01861792f, 0.00988398f, -0.02021279f, 0.03352325f, 
    -0.05897926f, -0.20478095f, 0.05827998f, 0.06260441f, 0.09227899f, -0.02011807f, -0.00736974f, -0.09981257f, 
    -0.00996002f, -0.06102892f, -0.01855670f, 0.06048407f, 0.05787070f, -0.22713852f, -0.22864205f, -0.10232878f, 
    -0.04607590f, -0.05229184f, 0.01556732f, 0.06079638f, 0.11478912f, 0.15055560f, 0.14133850f, 0.08237704f, 
    -0.17339203f, 0.07979579f, -0.04781654f, 0.33912110f, -0.03035003f, 0.07666188f, 0.11144709f, 0.06288225f, 
    0.02169305f, 0.09194949f, -0.00718318f, 0.11589272f, 0.43273294f, -0.21964216f, -0.14926279f, -0.05360778f, 
    0.13285534f, 0.07445616f, 0.04770329f, 0.10245515f, 0.04189445f, 0.13796866f, 0.02166480f, -0.05631072f, 
    -0.11611889f, 0.31779647f, -0.08392067f, 0.00208256f, -0.07400387f, 0.03365250f, -0.06759068f, 0.00404699f, 
    0.08838192f, 0.10262031f, 0.18909267f, -0.07278010f, -0.41602528f, 0.14767104f, -0.12975606f, 0.30469516f, 
    -0.02785448f, 0.04268336f, 0.05791660f, 0.10436983f, -0.10153188f, 0.05070222f, -0.00729335f, -0.04634710f, 
    0.12548137f, -0.22265121f, 0.30746475f, -0.01280647f, -0.14690596f, 0.12546420f, -0.10131174f, 0.10244043f, 
    0.00317136f, 0.07880995f, -0.03935415f, 0.02918364f, -0.22833991f, -0.01918343f, 0.02634073f, 0.12994292f, 
    -0.02853656f, 0.14625941f, 0.04828834f, -0.00638029f, -0.01113997f, 0.01828578f, 0.06149001f, 0.04447420f, 
    0.09648082f, 0.05754688f, 0.16765942f, -0.02693103f, -0.08941772f, -0.16208419f, -0.17411578f, -0.06295569f, 
    -0.09818800f, -0.07888558f, -0.03169642f, -0.04943623f, 0.00486935f, -0.00175619f, 0.03252259f, -0.03740033f, 
    -0.16981266f, -0.16960871f, -0.11990083f, -0.11427362f, -0.15254173f, -0.03327491f, -0.05990500f, 0.01567367f, 
    -0.01683249f, -0.06884865f, 0.01009645f, 0.12975205f, -0.02665220f, 0.02580574f, -0.08595181f, 0.01135524f, 
    0.07056403f, 0.15977073f, -0.01967240f, -0.08677056f, -0.12181734f, 0.51409346f, -0.05429518f, 0.25872150f, 
    -0.01094936f, -0.06954625f, 0.03757628f, -0.00661459f, -0.00839452f, 0.01756002f, 0.11162794f, -0.08058958f, 
    -0.22185603f, 0.26880777f, -0.08515200f, 0.08286393f, -0.00524771f, -0.09680532f, 0.12343208f, 0.01268964f, 
    0.11726609f, 0.03864991f, 0.00527207f, 0.06680884f, -0.20700800f, -0.25130454f, 0.08464305f, 0.09198855f, 
    0.01780327f, 0.07163536f, -0.14434750f, 0.07341711f, -0.00270780f, -0.05668802f, 0.15993719f, 0.05689932f, 
    -0.10086554f, 0.08632815f, -0.10064565f, -0.00170455f, -0.01216657f, 0.09936631f, 0.27122295f, 0.16435982f, 
    0.11787762f, 0.10104276f, 0.03236193f, 0.01042471f, -0.09718227f, 0.17893213f, 0.09011861f, -0.09317030f, 
    0.14100522f, -0.03263312f, 0.04162384f, 0.01575297f, 0.04793015f, -0.05098563f, 0.00002179f, -0.14257558f, 
    -0.09490595f, 0.06353182f, 0.22186776f, -0.00553651f, 0.15279292f, -0.00303142f, 0.16775589f, -0.09928124f, 
    -0.12464944f, -0.00355208f, -0.03149266f, -0.06863380f, -0.39308277f, -0.06576288f, -0.26224706f, -0.16852464f, 
    -0.09377461f, 0.05846737f, 0.06323408f, 0.10247614f, 0.13624944f, -0.00200821f, 0.05121183f, -0.05420095f, 
    -0.07815086f, -0.04925960f, 0.00467949f, -0.05928949f, 0.02411165f, 0.05164029f, 0.05586508f, 0.04649340f, 
    0.08689517f, 0.09843408f, 0.05252684f, 0.04865193f, 0.20807140f, -0.22116101f, -0.16664219f, -0.07739048f, 
    0.10007011f, 0.00409844f, 0.15873750f, 0.07464962f, 0.00071342f, 0.06130825f, -0.03098379f, -0.07804680f, 
    0.08593638f, 0.04553450f, -0.09999962f, -0.04985339f, -0.02144148f, -0.01820430f, 0.00824853f, -0.11623673f, 
    -0.07391867f, 0.06116515f, 0.01576078f, 0.03886028f, 0.15309203f, -0.32421196f, -0.10190176f, -0.00433668f, 
    0.00307902f, -0.01901314f, 0.11469241f, -0.00558598f, 0.07521739f, -0.02109850f, -0.05778882f, -0.06303503f, 
    0.31322032f, -0.16671301f, 0.30215585f, 0.07219919f, 0.29257479f, 0.13523690f, -0.22583908f, 0.14402989f, 
    -0.00128111f, 0.00596484f, 0.01644084f, 0.00547084f, 0.05568739f, 0.03742532f, 0.22146729f, 0.09806973f, 
    0.03419663f, 0.02557677f, 0.06009398f, -0.02115942f, 0.15325157f, 0.02893833f, 0.07764150f, 0.13122737f, 
    -0.00585653f, -0.01674280f, 0.09154909f, 0.05977589f, -0.08865938f, -0.02920408f, -0.09347909f, -0.05563518f, 
    -0.09863691f, -0.01398361f, 0.07633162f, -0.04422733f, -0.13602152f, 0.00787567f, 0.00132645f, 0.02916238f, 
    -0.08964243f, -0.01792971f, -0.03666273f, 0.00705246f, 0.02843279f, -0.04701828f, 0.10017499f, 0.18774144f, 
    0.05865850f, -0.09456610f, -0.00850098f, -0.05304453f, -0.02577823f, 0.08159003f, -0.14386123f, 0.13050361f, 
    0.01525776f, 0.04754669f, 0.02679360f, -0.20123567f, 0.36921987f, 0.47798982f, -0.11514498f, 0.08137344f, 
    -0.05736792f, 0.03755442f, 0.02710817f, 0.00761889f, 0.01568044f, 0.03522087f, -0.03116399f, 0.00191294f, 
    0.26939493f, -0.11889862f, -0.00696163f, 0.03196801f, -0.02985638f, 0.03281809f, 0.01864520f, -0.03866566f, 
    -0.05229957f, 0.04464481f, 0.09368404f, 0.08644220f, -0.03835637f, -0.07982291f, -0.13810384f, -0.02064392f, 
    -0.04574322f, 0.03383387f, 0.09737484f, -0.02925251f, 0.13113306f, -0.06463943f, -0.09814718f, 0.08618408f, 
    -0.03128796f, -0.00412174f, 0.29232594f, -0.07218695f, 0.05326741f, -0.02782376f, -0.18259352f, 0.08220304f, 
    0.06054657f, 0.06882771f, -0.09268264f, 0.01902970f, -0.21443152f, 0.11728590f, -0.17184381f, -0.02214167f, 
    -0.10269228f, -0.01517926f, 0.20092614f, 0.08533083f, -0.04461504f, -0.10075697f, -0.10775064f, -0.07960699f, 
    -0.31676540f, 0.04348209f, 0.03423358f, -0.08397868f, -0.06131447f, 0.07166132f, 0.05175176f, 0.04926952f, 
    0.11171451f, 0.06719580f, 0.00287973f, -0.05694322f, 0.15660915f, -0.19761361f, 0.21144325f, 0.04170137f, 
    -0.01870845f, -0.22935347f, -0.06200890f, -0.04525416f, 0.09300623f, 0.11227234f, 0.04758963f, -0.01994364f, 
    0.20153610f, 0.17255630f, 0.02646384f, 0.02327316f, 0.01019830f, -0.05164254f, 0.06410670f, -0.00138875f, 
    -0.01913925f, 0.04547309f, 0.03171268f, -0.06352335f, 0.07819986f, -0.46148393f, 0.00412798f, 0.23945345f, 
    -0.21762677f, -0.13078259f, -0.05014625f, 0.17223155f, 0.05782572f, -0.11655025f, 0.03798755f, 0.14680229f, 
    0.05007797f, -0.15152404f, 0.20606917f, 0.02464610f, -0.01952478f, 0.00991085f, 0.07838473f, -0.03466113f, 
    0.07369188f, -0.00255398f, -0.13590504f, -0.01639001f, -0.06854405f, 0.00254597f, 0.05414942f, -0.09261046f, 
    0.07504968f, -0.12299603f, 0.04501676f, -0.01515918f, -0.02432720f, 0.05787511f, -0.05178564f, 0.10510161f, 
    0.04656798f, -0.09525299f, -0.13925393f, 0.06211585f, -0.08262497f, 0.05071795f, 0.13499755f, -0.03603712f, 
    0.06183639f, -0.03144707f, 0.04272773f, -0.00166212f, 0.07733766f, 0.18738054f, 0.09891508f, 0.17111869f, 
    0.05856770f, 0.00117777f, -0.00308082f, 0.06483440f, -0.04646946f, 0.03956046f, -0.05704008f, 0.05858467f, 
    0.07491837f, 0.09939541f, -0.06069923f, 0.01407629f, 0.08626121f, 0.05811930f, -0.03480682f, 0.04422729f, 
    0.05718836f, -0.08186492f, -0.09894241f, -0.02667891f, 0.09160446f, 0.04564382f, -0.07303812f, 0.01199302f, 
    0.00272447f, -0.00876370f, 0.04029791f, -0.03387690f, 0.00166669f, -0.02237891f, -0.14248115f, 0.06171335f, 
    0.18549576f, 0.10372323f, -0.13209443f, 0.04019852f, 0.02241886f, -0.10427468f, 0.11792541f, -0.04162897f, 
    0.16460641f, -0.08734655f, 0.07744437f, -0.06678653f, 0.12844779f, -0.31427845f, 0.19672333f, -0.22013223f, 
    0.13696149f, 0.03119159f, 0.03591701f, -0.02316699f, 0.06666332f, -0.02653631f, 0.10135724f, -0.04952598f, 
    0.18963990f, -0.16739310f, 0.13536127f, 0.07974802f, -0.04019683f, -0.00608170f, -0.10350142f, 0.09552225f, 
    0.02053546f, 0.07460857f, 0.09028728f, 0.04954773f, 0.01823605f, -0.08788926f, 0.29379839f, -0.18214755f, 
    0.00858580f, 0.03802109f, -0.01515036f, -0.07442452f, 0.13868316f, 0.08671478f, 0.07241479f, -0.06910469f, 
    -0.17009620f, 0.14201544f, -0.16994305f, 0.23221257f, -0.04308550f, 0.11812456f, 0.23237313f, 0.14692342f, 
    -0.02554701f, 0.00400071f, 0.00193472f, -0.02614138f, 0.00071063f, -0.01150798f, 0.17561464f, 0.00805799f, 
    0.07904770f, 0.08866051f, -0.03749767f, 0.10752799f, 0.02604828f, 0.09637199f, -0.04163479f, 0.04812221f, 
    0.18910135f, 0.23891200f, -0.01746023f, -0.02409475f, -0.02077369f, 0.04057505f, -0.01372138f, 0.07636154f, 
    -0.06133539f, -0.02073896f, -0.01104383f, -0.21335341f, -0.06864073f, 0.11728524f, -0.22868167f, -0.16077298f, 
    -0.10569792f, -0.05597518f, -0.09456593f, 0.07643912f, 0.07205957f, 0.09596417f, 0.01754479f, -0.03548986f, 
    -0.01219591f, -0.21057595f, -0.00912540f, 0.10879356f, -0.09248335f, -0.00894572f, 0.07521014f, 0.11376192f, 
    0.01080876f, 0.00245993f, -0.02699905f, 0.13481738f, 0.02693298f, 0.25360197f, -0.09090010f, -0.18298781f, 
    -0.01248468f, 0.07665463f, -0.03308950f, 0.16649061f, 0.04522421f, 0.01035876f, 0.03604320f, -0.03926542f, 
    0.06112574f, 0.24506336f, 0.00755218f, 0.00199796f, -0.07334682f, -0.00274891f, -0.00671158f, -0.00230379f, 
    0.07171305f, -0.08957413f, 0.05483492f, -0.01151305f, 0.27960822f, 0.00549405f, -0.43620560f, 0.02683854f, 
    -0.22585458f, 0.01311774f, 0.02142416f, 0.05603133f, -0.02185375f, -0.05120939f, 0.01346335f, -0.01711426f, 
    0.18492794f, 0.00341026f, 0.01159779f, 0.00413717f, 0.21870381f, 0.11248204f, -0.11070056f, 0.16846643f, 
    0.07854393f, -0.03477069f, -0.01930422f, 0.03082748f, 0.00703697f, -0.08740628f, 0.05853560f, -0.19016659f, 
    0.01130984f, -0.03516975f, 0.14161190f, -0.02179810f, 0.00541935f, -0.00125131f, 0.05458593f, 0.13227326f, 
    0.25702912f, 0.03779295f, 0.02070777f, -0.03424839f, -0.13278808f, 0.04583594f, 0.04258797f, 0.00727623f, 
    -0.24200237f, 0.00727691f, 0.06504848f, -0.13858873f, 0.21836424f, 0.09030786f, 0.12959266f, 0.08199138f, 
    -0.03300712f, -0.04155606f, -0.00613438f, -0.03374163f, -0.02490425f, -0.13439868f, -0.07489722f, -0.03756544f, 
    -0.03053751f, 0.12575267f, 0.11677552f, 0.09086487f, 0.00557219f, -0.05216463f, -0.13753748f, -0.02005211f, 
    -0.00070508f, 0.00249925f, 0.04578207f, 0.03459262f, 0.01705744f, 0.26363823f, -0.14775647f, 0.07010498f, 
    -0.24383086f, 0.07889652f, -0.00124512f, 0.08820200f, -0.06656189f, 0.11313733f, 0.09764063f, 0.07179992f, 
    -0.09477112f, 0.31588390f, -0.00233007f, -0.14895865f, 0.03551659f, -0.01344575f, 0.00295162f, -0.04658927f, 
    0.13334818f, -0.05921686f, -0.04450754f, 0.09508198f, -0.19745900f, 0.17260358f, 0.04509361f, 0.11629884f, 
    -0.08830443f, -0.00530317f, -0.03369939f, 0.03189367f, -0.03500420f, -0.02722099f, 0.03614001f, -0.08377309f, 
    -0.01087833f, 0.43184841f, -0.04501479f, -0.09144423f, -0.00262795f, 0.06441040f, -0.15272810f, 0.10059430f, 
    0.06766474f, -0.15123594f, -0.07573736f, -0.21386506f, 0.14574403f, 0.23488277f, 0.16651721f, 0.01733020f, 
    0.13466391f, 0.09590232f, 0.08737104f, -0.00723297f, 0.02895958f, -0.08958907f, 0.04784550f, 0.09713475f, 
    0.22561429f, 0.29933965f, 0.46081841f, 0.17730835f, 0.08322227f, 0.00405231f, 0.15145093f, 0.06094137f, 
    0.05395729f, 0.01931421f, 0.02254069f, -0.03010071f, -0.02115971f, 0.08975754f, -0.08420551f, 0.10745064f, 
    -0.05372492f, 0.13912888f, -0.03223847f, 0.01000866f, 0.04604942f, -0.05210581f, -0.09741525f, 0.07632832f, 
    0.11369935f, -0.10252038f, 0.15766098f, 0.08049655f, 0.05831627f, -0.01029639f, -0.04164658f, -0.03991756f, 
    -0.07274118f, 0.18165210f, -0.06360269f, 0.11060295f, -0.07611942f, 0.17228572f, 0.21010260f, -0.03926143f, 
    -0.05879947f, 0.06811807f, -0.02411459f, -0.15149045f, -0.11672433f, 0.12497732f, 0.01884261f, 0.06938292f, 
    -0.07540716f, -0.12565266f, -0.05491462f, -0.00370508f, 0.05778924f, -0.01619069f, -0.03061160f, -0.10737367f, 
    -0.04036216f, 0.12604836f, -0.03505828f, 0.15550564f, 0.08210209f, -0.20837110f, -0.16019540f, -0.04050919f, 
    -0.14791669f, -0.06953113f, -0.00111849f, 0.03090876f, 0.08614748f, 0.06724414f, 0.05462887f, 0.06438386f, 
    -0.11359239f, -0.08743490f, 0.33175439f, -0.01124260f, -0.02272647f, 0.14295310f, -0.09824041f, 0.07027410f, 
    0.03143913f, -0.00213341f, -0.04019074f, -0.03993992f, 0.33057034f, 0.17598210f, 0.34141657f, 0.15681270f, 
    0.09659913f, -0.02244780f, 0.11096044f, 0.14405338f, -0.11891811f, 0.02921156f, -0.17498788f, -0.00714131f, 
    0.03125669f, -0.29784912f, -0.04423129f, 0.28194627f, 0.02745170f, -0.03254777f, -0.04498882f, -0.01363673f, 
    -0.02129652f, 0.02620423f, 0.05855744f, 0.03644370f, -0.03399722f, -0.28900063f, -0.41397461f, -0.06636452f, 
    0.01929267f, 0.02799037f, -0.07625875f, 0.10695885f, -0.00519221f, -0.00615703f, -0.14738230f, -0.08210155f, 
    0.04141885f, -0.02604784f, 0.04913364f, -0.00067499f, -0.00890176f, 0.08680442f, -0.21595596f, 0.00164696f, 
    0.08129922f, 0.01403954f, 0.01216555f, -0.02984695f, 0.14175552f, 0.42907566f, 0.03766025f, 0.06454425f, 
    0.09647657f, -0.07614546f, 0.13956365f, 0.17132401f, -0.07623781f, -0.12058067f, -0.10657059f, -0.07826509f, 
    -0.12427294f, -0.23179494f, -0.00260470f, 0.06378401f, -0.00981891f, -0.00231069f, 0.07205077f, -0.02801563f, 
    -0.06235944f, -0.00125742f, 0.02616626f, 0.06286822f, 0.40736836f, 0.22249545f, 0.16391292f, -0.07536083f, 
    0.20819277f, 0.02270629f, 0.01180651f, -0.05003222f, 0.18296696f, -0.01004924f, 0.02140389f, -0.03739581f, 
    0.14065804f, -0.16902864f, -0.28479064f, 0.18542002f, 0.13807939f, -0.02249366f, 0.28001672f, 0.09840243f, 
    0.16771866f, -0.00811060f, 0.11318747f, 0.02089086f, 0.00988330f, 0.11050177f, 0.16614044f, 0.01934390f, 
    0.09133949f, 0.11079228f, -0.23619901f, -0.00271497f, -0.01906793f, 0.19971250f, -0.21612380f, -0.17462334f, 
    0.13030216f, 0.14059611f, 0.01372395f, 0.01961007f, -0.02502230f, 0.08899227f, -0.03696123f, 0.15438664f, 
    0.01114638f, 0.07546150f, -0.08633830f, -0.14954895f, -0.02344854f, 0.13270661f, -0.08626976f, -0.04764654f, 
    0.10004933f, 0.07904359f, 0.12313754f, -0.04457944f, 0.00506633f, 0.06977955f, 0.05376915f, 0.08967740f, 
    -0.16882117f, -0.12415449f, 0.01951351f, -0.06043012f, -0.00795435f, -0.04254783f, 0.08374908f, 0.00391859f, 
    0.13187423f, 0.01774109f, -0.05097416f, 0.04513762f, 0.07847315f, 0.28519022f, -0.04186922f, -0.16194907f, 
    0.10194403f, 0.08195727f, -0.00140799f, 0.03031523f, -0.00276385f, -0.01091002f, 0.04346254f, -0.08810291f, 
    0.21108347f, 0.11814923f, 0.09470871f, 0.10221840f, -0.11775777f, 0.12293970f, -0.17545621f, -0.02216343f, 
    -0.01860114f, -0.07840919f, 0.10911285f, -0.05972763f, 0.59007108f, 0.04730389f, -0.02651506f, 0.17203785f, 
    -0.14486679f, 0.04801808f, -0.07786121f, -0.16223185f, 0.06612986f, -0.03006772f, 0.04548829f, 0.01098143f, 
    -0.35351104f, 0.19628917f, 0.19755463f, -0.11988243f, 0.21170524f, 0.00934510f, 0.03444400f, -0.09024519f, 
    0.02242205f, 0.06338901f, 0.06225476f, 0.07072746f, -0.08226837f, -0.24205577f, -0.01283303f, -0.31814086f, 
    0.15277925f, 0.02573671f, 0.14752012f, 0.02371773f, -0.03059125f, -0.05874833f, 0.06692863f, 0.05007802f, 
    -0.10185547f, 0.14722914f, 0.03499119f, -0.15344468f, -0.13998483f, 0.05769639f, -0.22966310f, -0.11044094f, 
    -0.18566011f, -0.06178685f, -0.04110404f, -0.11565159f, 0.15990128f, 0.14331752f, 0.06367963f, 0.03490386f, 
    -0.13701843f, -0.06145936f, -0.02353762f, 0.05040849f, -0.09433319f, 0.03855657f, -0.00121050f, -0.10414878f, 
    -0.03592494f, -0.09839601f, 0.16033234f, -0.01119305f, 0.02982685f, -0.14983523f, -0.12964828f, -0.12519051f, 
    -0.21039094f, -0.05338025f, -0.09032603f, 0.00665824f, -0.06610913f, 0.10969836f, -0.21980621f, -0.01238836f, 
    -0.37464303f, 0.04892289f, 0.12645990f, 0.07697878f, -0.11680354f, -0.02612332f, 0.08290007f, 0.10094872f, 
    0.03238012f, 0.51858491f, -0.12018748f, -0.11222045f, 0.00416250f, -0.03485002f, -0.07649861f, 0.01302592f, 
    0.03609030f, -0.05476009f, 0.03542329f, -0.09745544f, -0.11857843f, -0.00229561f, -0.27511460f, -0.01839347f, 
    -0.02617816f, -0.05883567f, 0.09158065f, 0.26682970f, 0.08565821f, -0.05328828f, 0.02636533f, 0.14918627f, 
    0.03978204f, 0.00366833f, 0.07481752f, 0.12943777f, 0.04369190f, -0.05816445f, -0.04272279f, 0.02293581f, 
    -0.02760294f, -0.19384079f, 0.00584604f, 0.07787047f, 0.05566163f, 0.09205330f, 0.16410929f, 0.11079378f, 
    -0.00058638f, -0.01966455f, 0.00745448f, 0.07848471f, 0.04083024f, 0.14832458f, 0.06105116f, 0.27596232f, 
    0.31923047f, 0.28770366f, 0.26366833f, 0.09149890f, -0.15527214f, 0.06629711f, -0.08630259f, 0.10909245f, 
    0.07357346f, 0.02682759f, -0.02588320f, 0.05175891f, 0.27547818f, 0.00615349f, 0.10135572f, 0.08895932f, 
    0.12973209f, 0.10422669f, -0.02042846f, -0.07391075f, -0.09952419f, 0.10117202f, 0.09822738f, -0.05820979f, 
    -0.06338637f, -0.14269464f, 0.23353601f, -0.20088404f, 0.00231424f, -0.06172873f, 0.14729835f, 0.01684216f, 
    -0.02661574f, 0.17094010f, 0.06365285f, 0.01882187f, 0.17432116f, -0.01269316f, 0.11464644f, -0.01776013f, 
    0.15747766f, -0.15149122f, 0.13814658f, -0.11549141f, 0.10020875f, -0.05996009f, 0.12503465f, 0.14760575f, 
    -0.22077905f, -0.05277707f, -0.08734063f, 0.12191704f, 0.09470467f, 0.04411751f, 0.01402242f, -0.10452008f, 
    0.06693411f, 0.13069637f, 0.15118909f, 0.17773712f, 0.25371778f, -0.17158161f, 0.05786163f, 0.06829097f, 
    0.07271453f, -0.01225801f, 0.03936749f, -0.11723948f, -0.03207189f, 0.08243216f, 0.03365566f, -0.03197343f, 
    0.02137018f, -0.20287414f, 0.17113569f, -0.06900907f, 0.16921064f, -0.18568270f, -0.20792589f, -0.15035866f, 
    -0.08154733f, -0.05002008f, -0.07223237f, 0.02103468f, 0.10291763f, 0.01233645f, 0.19066381f, -0.00963592f, 
    0.05060305f, -0.08715884f, 0.01729126f, 0.13408595f, -0.06015177f, -0.07741236f, -0.02987707f, -0.07083082f, 
    -0.12206480f, -0.29015639f, -0.21664208f, -0.00320630f, 0.09441389f, 0.06841747f, 0.04343853f, -0.00246040f, 
    0.06263279f, 0.17376709f, 0.10936385f, 0.01372270f, -0.13812935f, -0.27034116f, -0.22910324f, -0.17213409f, 
    0.08373189f, 0.06402549f, -0.02092782f, 0.03914737f, -0.02946394f, -0.01258369f, -0.12500647f, -0.05017526f, 
    -0.06033884f, -0.08314008f, -0.03232251f, -0.01276405f, 0.04786307f, 0.03586986f, -0.09654571f, 0.07039751f, 
    0.01593272f, 0.07026570f, 0.03464117f, 0.27679953f, 0.18610254f, 0.18020238f, 0.01454825f, -0.12260320f, 
    -0.08968743f, -0.01357443f, 0.01032564f, 0.07217343f, -0.10728073f, -0.02097313f, -0.10632918f, -0.06828588f, 
    -0.00801818f, -0.31849781f, -0.02437592f, -0.07646378f, 0.05187793f, -0.03911566f, 0.08871295f, 0.08405971f, 
    -0.06115710f, 0.04539776f, -0.01704341f, 0.25447732f, 0.45154768f, -0.17287208f, -0.24885526f, -0.09673794f, 
    -0.09769516f, -0.05674007f, -0.03014327f, 0.26240233f, 0.00173805f, -0.05253272f, -0.15525918f, -0.00697112f, 
    -0.02061625f, -0.11344412f, 0.14711544f, -0.05469694f, -0.06723157f, 0.06810038f, 0.16833486f, 0.28715706f, 
    0.07310125f, 0.02429007f, 0.07366356f, 0.05691737f, -0.03844151f, 0.14359890f, 0.02453535f, 0.02170312f, 
    0.11775736f, 0.04146251f, 0.07478922f, -0.00300552f, -0.06759746f, 0.04666506f, -0.00556298f, -0.03824382f, 
    -0.04307150f, 0.11622255f, 0.18915901f, -0.15550442f, 0.07297189f, 0.07614852f, 0.00776248f, 0.13516176f, 
    0.00848948f, -0.02863479f, -0.03799285f, -0.02435515f, -0.25514761f, -0.15514025f, 0.12407420f, -0.05549954f, 
    -0.10631710f, 0.00449963f, -0.08329791f, -0.01376776f, 0.02199585f, -0.04936462f, 0.00507751f, 0.00360361f, 
    -0.06995858f, -0.20546326f, -0.01745309f, -0.30971843f, 0.02835237f, 0.01808042f, 0.01892095f, 0.05849697f, 
    0.01489097f, 0.05072498f, -0.00208388f, -0.03843395f, 0.05318120f, -0.23333593f, 0.11460286f, 0.05049150f, 
    0.12368051f, -0.13823584f, -0.00095915f, 0.08000591f, 0.20197544f, -0.05118439f, 0.07303426f, -0.12116636f, 
    0.12492692f, -0.03662278f, 0.13468058f, 0.12557863f, -0.02714698f, 0.01435964f, -0.05070927f, -0.02425423f, 
    0.00947567f, 0.00353984f, 0.22477195f, -0.17612875f, 0.22940990f, -0.32091126f, 0.15461428f, -0.18501270f, 
    -0.02472963f, -0.02403427f, -0.04160975f, -0.08174860f, -0.07902654f, 0.05830630f, 0.07842928f, -0.03387943f, 
    0.26564428f, -0.04148205f, 0.14237377f, 0.02581234f, 0.35113439f, -0.14093658f, -0.12498655f, -0.05385039f, 
    0.14184381f, 0.13181576f, 0.00382120f, 0.10986282f, 0.13270317f, 0.00237466f, 0.13991351f, 0.01102229f, 
    0.17236017f, 0.02481429f, 0.12352481f, 0.15664466f, 0.08780027f, 0.05120123f, 0.08145050f, 0.11774123f, 
    -0.05629528f, -0.00528837f, 0.02757777f, 0.08970255f, 0.02910886f, 0.02572031f, -0.12172274f, -0.10231171f, 
    0.05343326f, -0.06655955f, -0.03979618f, 0.03453656f, 0.01604482f, 0.03378288f, -0.08344936f, -0.01412549f, 
    -0.12505955f, 0.00329136f, -0.13254598f, -0.08485726f, 0.09152887f, 0.13035513f, 0.12208495f, 0.10074950f, 
    -0.02741638f, -0.13540368f, -0.08415671f, -0.17508884f, -0.00025965f, 0.10278759f, -0.01251028f, 0.12859666f, 
    -0.04476245f, -0.16133404f, -0.06829234f, -0.12322880f, 0.46891946f, 0.06665434f, -0.05977210f, -0.17663686f, 
    -0.18265080f, -0.01013490f, 0.08208168f, -0.01829063f, 0.01073120f, -0.03259469f, 0.01264595f, 0.09064895f, 
    0.23232041f, -0.06424553f, 0.03635338f, 0.13055888f, 0.04825624f, -0.07017682f, 0.04617970f, 0.02492977f, 
    0.06914514f, -0.02567632f, 0.13951719f, 0.03482246f, -0.15260585f, -0.24379858f, -0.21216966f, -0.15003072f, 
    0.05860273f, -0.07644358f, -0.02415162f, 0.11368503f, -0.01527645f, -0.10487619f, -0.00685827f, 0.13908562f, 
    0.13561596f, 0.11695076f, 0.17100710f, 0.16759132f, 0.09581978f, 0.03151816f, 0.18695915f, -0.00439645f, 
    0.09324079f, -0.03205827f, -0.01824861f, -0.06196075f, 0.07532858f, -0.00654417f, 0.15121989f, 0.14935435f, 
    0.02167847f, 0.06072254f, 0.10112299f, 0.03137775f, 0.00467347f, -0.08000166f, -0.00259704f, 0.16351132f, 
    0.12824418f, 0.14568035f, 0.23128515f, 0.15198255f, 0.09600217f, -0.00657595f, -0.14936279f, -0.00831819f, 
    -0.08910262f, -0.04095406f, -0.00818578f, -0.01027622f, 0.18939516f, 0.02317809f, -0.28057799f, -0.15355912f, 
    0.02888804f, 0.09315051f, 0.04130204f, 0.04250486f, -0.07212278f, -0.05171698f, -0.00058667f, -0.07339286f, 
    -0.08161882f, -0.20324181f, -0.13737263f, 0.22431426f, 0.02800724f, 0.04685427f, 0.06836998f, -0.03346639f, 
    0.02681241f, 0.10747426f, 0.00891144f, 0.15066881f, 0.12118449f, 0.08899820f, -0.08247733f, -0.11894833f, 
    0.08330243f, 0.18755524f, -0.07251267f, -0.06142246f, 0.04104982f, 0.11080606f, -0.00791532f, -0.05738893f, 
    -0.00933006f, 0.13865127f, -0.07074569f, -0.04163469f, 0.07622626f, 0.01640654f, -0.00894224f, -0.03136803f, 
    -0.06697623f, -0.00185790f, 0.01317352f, -0.00059163f, 0.26358849f, 0.09278440f, -0.05938571f, 0.17661379f, 
    -0.00168820f, 0.12249137f, 0.13716729f, -0.04203300f, -0.02226481f, -0.04697963f, 0.01419326f, -0.10886109f, 
    -0.16453467f, -0.08793832f, 0.35295376f, -0.06368143f, -0.21779652f, 0.18664834f, -0.13954441f, -0.00032708f, 
    -0.01229571f, 0.10904064f, 0.06266903f, -0.06044862f, -0.08087771f, 0.06162637f, 0.20758045f, 0.02180018f, 
    0.08222405f, -0.07917532f, 0.04875304f, -0.09434490f, -0.16427049f, -0.13689035f, -0.05133051f, -0.04720707f, 
    0.03435972f, 0.07065060f, 0.14818953f, 0.06011574f, -0.04753916f, 0.05307837f, 0.01116018f, -0.04427561f, 
    0.04229080f, -0.01891535f, 0.09011690f, 0.02395879f, 0.13946979f, 0.00629958f, -0.13733467f, 0.08317286f, 
    0.05300049f, -0.03198450f, 0.04418161f, -0.05150875f, -0.01875187f, 0.07182714f, 0.01718042f, -0.21402128f, 
    -0.06757160f, -0.01326773f, 0.03995464f, 0.10532881f, -0.03172493f, -0.01656737f, -0.05757978f, -0.02688572f, 
    0.00474892f, 0.11222125f, 0.08007481f, 0.09897932f, -0.19623409f, 0.48937660f, -0.12314282f, 0.09485623f, 
    -0.01460940f, -0.21424848f, 0.15052614f, -0.00573482f, -0.05319698f, 0.12082162f, 0.05830272f, 0.13881250f, 
    -0.12897228f, 0.22137226f, -0.09189042f, -0.13636754f, 0.05776000f, -0.02500603f, 0.10154640f, -0.04844335f, 
    -0.07586917f, 0.15315993f, -0.04329755f, -0.06481698f, 0.02372319f, -0.23332532f, -0.21833551f, 0.06780255f, 
    -0.00985935f, 0.19613616f, -0.12754551f, 0.17242765f, -0.00120786f, -0.07510462f, 0.02170098f, 0.09924273f, 
    -0.05159546f, -0.09847092f, -0.23285881f, 0.04124560f, 0.10637730f, 0.00828819f, 0.17155282f, -0.15219554f, 
    -0.10200099f, 0.03327995f, 0.13082848f, 0.03609277f, 0.09321911f, -0.22329733f, -0.00020928f, -0.05108243f, 
    -0.00106610f, -0.17301118f, -0.16366705f, 0.02025785f, -0.05765995f, 0.05387022f, -0.05701296f, -0.31224939f, 
    -0.01813392f, -0.09386786f, -0.22938190f, 0.14533339f, 0.07748659f, -0.17320134f, -0.03180820f, -0.10684333f, 
    -0.27689198f, -0.07605333f, -0.16630983f, 0.01614159f, -0.17687660f, 0.20288897f, -0.04271139f, 0.10030736f, 
    -0.07784245f, 0.05140034f, 0.07855825f, 0.19204037f, 0.10650329f, 0.06411476f, 0.17412212f, 0.02742275f, 
    -0.00478055f, 0.17662647f, 0.11033104f, 0.06717467f, 0.04409961f, 0.03886083f, 0.10101584f, 0.02521357f, 
    0.18613862f, -0.12821804f, 0.07307562f, -0.13305593f, -0.15818097f, 0.16279443f, -0.15071683f, -0.22213359f, 
    0.14075291f, -0.07373178f, 0.20399636f, -0.00909717f, 0.08834195f, -0.08832791f, 0.00122829f, -0.12328008f, 
    -0.03347422f, 0.15476906f, 0.09088257f, -0.09513727f, -0.16737026f, 0.00623274f, -0.15514950f, -0.02337991f, 
    0.00050458f, -0.08262429f, 0.07852978f, -0.09531014f, 0.04913164f, 0.09146690f, 0.02547862f, -0.01150111f, 
    0.05250396f, 0.05679119f, -0.06981178f, 0.09500956f, 0.12658785f, 0.03883732f, 0.11617792f, 0.07867855f, 
    0.05535130f, 0.05767627f, -0.23064570f, 0.03954737f, 0.32037476f, -0.03214894f, 0.10945227f, 0.09318103f, 
    -0.04222551f, -0.02358460f, 0.13208486f, 0.08252760f, -0.05661029f, -0.00554252f, -0.02416687f, 0.13886195f, 
    -0.04591782f, 0.08833633f, 0.08896439f, -0.01985235f, 0.17838258f, -0.04456011f, 0.12599568f, 0.09053884f, 
    -0.10945438f, 0.04731417f, 0.14812815f, -0.01804681f, -0.03996010f, -0.07607123f, -0.07441720f, 0.03893205f, 
    0.03996756f, 0.12531906f, -0.01169385f, 0.03593451f, -0.10908969f, 0.05121372f, 0.24221814f, 0.11951788f, 
    0.00129173f, -0.01644867f, 0.09669780f, 0.07082196f, 0.04530611f, 0.01011757f, 0.24815458f, 0.11877144f, 
    -0.10086828f, -0.06773643f, 0.05017442f, -0.07664410f, -0.03341240f, -0.11117939f, -0.14143226f, -0.09388460f, 
    -0.06764010f, 0.05495076f, -0.06845724f, -0.21660191f, -0.06622898f, 0.08583992f, 0.02355977f, 0.32585606f, 
    -0.05096702f, 0.22328499f, -0.04205941f, -0.15739404f, 0.04631099f, 0.00842389f, -0.06524180f, 0.13638251f, 
    -0.06506123f, 0.06520488f, -0.02320835f, -0.02260044f, -0.09193496f, 0.02760089f, -0.11086749f, -0.04279518f, 
    0.20591195f, 0.03603588f, 0.06742432f, 0.03206612f, -0.24225436f, 0.10245419f, -0.05228776f, 0.28573945f, 
    -0.03706254f, 0.06503073f, 0.23757763f, -0.00126458f, -0.19381702f, -0.06679186f, 0.00130404f, 0.11608270f, 
    0.15186274f, 0.06242784f, -0.08923444f, -0.06829245f, -0.08961736f, 0.07602230f, 0.10205162f, -0.10695171f, 
    0.09237765f, 0.01471891f, -0.05308363f, 0.06139914f, 0.26366848f, 0.06494777f, -0.11656576f, 0.00751803f, 
    0.08858170f, -0.05358382f, 0.06664214f, 0.03090967f, -0.15817976f, -0.18126599f, 0.03201055f, -0.21587183f, 
    0.17223258f, -0.03645652f, -0.13895822f, -0.14888057f, 0.12360442f, 0.11319300f, 0.15583107f, 0.06468628f, 
    -0.02939198f, 0.03366628f, -0.02225275f, 0.12649630f, 0.00291809f, 0.02745127f, 0.14457186f, 0.11674269f, 
    0.05001996f, -0.06979320f, 0.01157155f, 0.00117583f, 0.07313418f, 0.01010372f, 0.06052514f, 0.10562847f, 
    0.13332801f, 0.25329110f, 0.06004039f, 0.14540382f, 0.01479693f, -0.00644883f, -0.01040606f, 0.05552620f, 
    -0.12484317f, -0.14304289f, -0.11205966f, -0.04258549f, 0.16358066f, -0.05987814f, 0.22180288f, -0.08291734f, 
    0.18436624f, -0.13801380f, 0.07881097f, 0.12765795f, -0.04612062f, -0.07048440f, 0.07847761f, -0.06112961f, 
    -0.09909442f, -0.13285048f, 0.07766287f, -0.14296339f, -0.07713245f, -0.05098891f, -0.05837054f, -0.03479708f, 
    0.04066383f, 0.08171020f, 0.04716145f, 0.09806719f, -0.31132963f, -0.22220941f, -0.06882566f, -0.17719142f, 
    0.15690111f, 0.01348764f, 0.04796594f, 0.06020416f, 0.02990227f, 0.00859949f, 0.07927857f, 0.02355467f, 
    -0.00641303f, 0.11583629f, -0.06894381f, -0.07083789f, 0.03809677f, 0.05528381f, 0.17561646f, -0.01618817f, 
    -0.04284031f, -0.09080419f, 0.05624492f, 0.00806595f, 0.10890424f, 0.15945326f, -0.16652735f, 0.23424563f, 
    0.05646389f, 0.10535059f, -0.10348796f, 0.12025636f, 0.02053072f, 0.11224153f, -0.03459387f, 0.06194641f, 
    -0.26380733f, -0.01481624f, -0.04406235f, 0.04505682f, -0.02086262f, -0.02494420f, 0.01359979f, 0.08068606f, 
    0.00886432f, -0.04180192f, -0.03890508f, 0.08000142f, -0.26972094f, -0.13851272f, 0.07189229f, -0.01227603f, 
    0.05307632f, 0.04764010f, -0.03364804f, -0.04540749f, 0.05806440f, 0.00939518f, 0.14811786f, 0.29747432f, 
    -0.24262124f, -0.18556303f, -0.03891606f, -0.07804005f, -0.01715749f, 0.11184218f, -0.02956378f, -0.00163692f, 
    0.13579820f, -0.01698089f, -0.00876319f, -0.32100114f, 0.17674324f, -0.08938589f, 0.29621974f, 0.09884210f, 
    0.18549621f, 0.14532538f, -0.01143869f, -0.02295646f, 0.11682433f, -0.09482651f, -0.06036588f, -0.07739276f, 
    -0.05036750f, -0.23319744f, 0.00929080f, 0.14630273f, -0.00234001f, -0.02905415f, -0.06651302f, -0.02366417f, 
    0.04384575f, -0.02124627f, 0.08412140f, -0.05051384f, 0.15889591f, 0.23121051f, 0.17399459f, -0.22263302f, 
    0.09331494f, -0.02487145f, 0.26268798f, -0.01786478f, 0.15835968f, 0.01368455f, 0.06455143f, -0.09053919f, 
    -0.20198835f, -0.00469201f, -0.15287618f, 0.09137230f, 0.07386286f, 0.10754465f, -0.09648411f, 0.04532693f, 
    -0.04276175f, -0.06327729f, -0.03256018f, -0.17382534f, -0.03054063f, 0.03423654f, 0.04439507f, -0.08882284f, 
    -0.04286719f, -0.06690499f, -0.09270427f, -0.00959522f, 0.13934122f, 0.11330731f, 0.10671850f, 0.16245438f, 
    -0.08722118f, 0.09119207f, 0.14913866f, 0.04793985f, -0.05877307f, -0.04051411f, -0.01628776f, -0.01488663f, 
    0.06849150f, -0.09902502f, 0.07086656f, -0.09101544f, -0.19172479f, 0.26850745f, 0.20626372f, 0.13375278f, 
    -0.09424459f, -0.09065754f, -0.09551622f, 0.11986270f, -0.01773652f, -0.00518511f, -0.11190825f, 0.04971414f, 
    0.11574532f, 0.06741447f, 0.26011321f, -0.10367169f, -0.08284312f, -0.00902452f, -0.08078221f, -0.05073198f, 
    0.07101455f, 0.04017286f, 0.11420304f, 0.11028896f, -0.34751245f, 0.06768657f, 0.01131483f, 0.14871195f, 
    -0.04655905f, -0.06540421f, -0.10110353f, -0.13689467f, 0.02313084f, 0.05705780f, 0.06207884f, 0.07398859f, 
    -0.07134012f, -0.25037733f, 0.09304572f, 0.18255749f, 0.09505755f, 0.07559443f, 0.00783709f, 0.05052148f, 
    0.08310117f, -0.01864827f, -0.01953575f, 0.18482806f, 0.12364950f, -0.05008206f, 0.31452546f, -0.12836155f, 
    -0.18936443f, -0.07329923f, -0.25137943f, 0.20459639f, 0.03398909f, 0.07786892f, 0.03272758f, 0.04409597f, 
    0.11731043f, 0.02032700f, -0.04800671f, 0.00769764f, 0.14038193f, 0.03268518f, 0.05965845f, 0.12189981f, 
    -0.01753780f, 0.09447286f, -0.00290275f, -0.03874974f, 0.07618124f, 0.06463937f, 0.07677640f, -0.02067012f, 
    0.00262423f, 0.03098651f, 0.00820463f, 0.06864087f, 0.05824653f, -0.04838206f, 0.03000553f, 0.02733017f, 
    0.11216754f, -0.05960728f, -0.02786567f, -0.07340050f, 0.01624734f, 0.02534979f, 0.11314981f, 0.12262133f, 
    0.06590461f, 0.09938348f, 0.04036050f, -0.05615844f, 0.13319546f, -0.08554634f, -0.05143955f, -0.06739039f, 
    0.08732240f, 0.12595794f, 0.01438249f, 0.11880107f, 0.00842255f, 0.04949436f, -0.01036008f, -0.14535052f, 
    0.17152128f, 0.17010304f, 0.03169231f, -0.17394871f, 0.01135865f, 0.02203995f, -0.11586689f, -0.04767931f, 
    0.02458975f, 0.07053877f, 0.07022676f, 0.20781897f, 0.22958848f, -0.19130135f, 0.11683194f, -0.17201631f, 
    0.06060403f, 0.08165251f, -0.10728338f, 0.07221200f, -0.10539744f, -0.02611781f, -0.05622900f, -0.01546798f, 
    0.14579639f, -0.27347803f, 0.16907127f, 0.06977811f, 0.03837381f, -0.07781025f, -0.03894082f, 0.17200324f, 
    0.01750654f, -0.00871105f, -0.07291295f, 0.07051333f, 0.07986365f, 0.18843459f, 0.14186980f, 0.33900616f, 
    -0.12534492f, -0.06434921f, 0.03312841f, -0.06364032f, -0.05745411f, 0.03647035f, -0.07858387f, -0.00968274f, 
    -0.06333862f, 0.02836523f, 0.05337827f, -0.06113152f, -0.06658991f, -0.01209718f, 0.05994117f, -0.06534658f, 
    -0.03578691f, -0.02838635f, 0.01449878f, -0.05728999f, 0.05133476f, -0.06768568f, 0.05113612f, -0.01388812f, 
    -0.03249666f, -0.03109050f, -0.02620265f, 0.05674976f, 0.02736950f, 0.00790549f, -0.00414005f, 0.03359983f, 
    0.01595420f, -0.02405025f, 0.00114782f, -0.02060199f, -0.02742606f, 0.02583095f, 0.06450251f, -0.07098825f, 
    -0.03005898f, -0.06018563f, -0.01526275f, 0.05229193f, -0.07724171f, -0.00235388f, -0.07048114f, 0.02183963f, 
    -0.05238346f, 0.04755146f, 0.04302859f, 0.00072626f, -0.01099810f, -0.07075713f, -0.07335153f, -0.00003441f, 
    0.05289109f, 0.00841338f, -0.03171713f, -0.07043402f, -0.05829206f, 0.02229841f, -0.02732585f, -0.04984084f, 
    -0.06481424f, -0.02032899f, -0.06536324f, -0.07847133f, -0.03953344f, -0.00118579f, -0.03669964f, 0.05565797f, 
    0.04630051f, -0.06849834f, -0.05188029f, -0.01431194f, -0.07396240f, -0.03062304f, -0.02259031f, -0.05953765f, 
    -0.06803726f, -0.02962225f, 0.01171470f, 0.06374773f, -0.07344130f, -0.01136138f, 0.00761030f, -0.07990462f, 
    -0.00379834f, -0.03408238f, 0.02171523f, 0.05268370f, 0.06486352f, 0.04454422f, 0.05766378f, 0.00093191f, 
    -0.03817510f, 0.02702640f, 0.00360089f, -0.02348480f, -0.01102150f, 0.00417942f, 0.04120386f, -0.00960776f, 
    -0.04318505f, -0.05243154f, -0.03063760f, -0.04037436f, 0.02398181f, 0.04560854f, -0.06376605f, 0.04014616f, 
    0.02862821f, 0.03037266f, 0.02318940f, -0.06790113f, -0.01272949f, -0.01725206f, -0.04584968f, 0.03402690f, 
    0.02373186f, -0.07444812f, -0.02779977f, -0.06186759f, -0.06446815f, -0.05369652f, 0.00566778f, 0.02907335f, 
    0.04575277f, 0.00637971f, -0.00109233f, -0.03219029f, -0.00841205f, -0.05479968f, 0.01883417f, -0.05240118f, 
    -0.04034393f, 0.01416229f, -0.05395637f, 0.01494174f, 0.02314348f, -0.02358974f, -0.00203033f, -0.01429700f, 
    0.01679059f, 0.03051701f, -0.05203594f, -0.01765468f, -0.05289895f, -0.00834478f, -0.06156955f, -0.05792899f, 
    0.02525905f, 0.05834500f, -0.05847842f, 0.00923550f, 0.02328687f, -0.05500633f, 0.03125854f, 0.05720694f, 
    0.00736697f, 0.04542969f, -0.03293186f, -0.06502900f, -0.07687514f, -0.02642386f, 0.02073103f, -0.03662415f, 
    0.02825537f, -0.03484226f, -0.02739119f, 0.06588079f, -0.03112354f, 0.03290571f, -0.07044129f, 0.05182506f, 
    0.00716971f, -0.07196550f, 0.02251621f, -0.02523747f, 0.04474204f, 0.03507743f, -0.04368356f, 0.00552035f, 
    -0.07247573f, 0.01857948f, 0.06158075f, 0.05139736f, -0.02743173f, -0.01008901f, 0.00279836f, 0.03693492f, 
    0.01596114f, -0.00644288f, -0.06158314f, -0.00353270f, -0.04241915f, 0.02042936f, -0.02280749f, -0.00044918f, 
    0.03997341f, 0.01036802f, -0.06283458f, 0.05892648f, -0.06795046f, -0.05282930f, 0.04928366f, -0.04987475f, 
    -0.04402705f, 0.02182846f, -0.05874456f, -0.06900379f, -0.05008233f, -0.06363261f, -0.07235289f, -0.01818052f, 
    0.06374004f, 0.00851309f, -0.05353697f, -0.04286538f, 0.05049009f, -0.02938268f, -0.07757027f, 0.00554705f, 
    0.01822142f, -0.02968267f, -0.00064827f, -0.02735790f, 0.01079075f, 0.00329869f, 0.02830216f, 0.00258584f, 
    0.00155970f, 0.05450261f, -0.01591454f, -0.05381118f, -0.00303256f, 0.06402020f, 0.06084431f, 0.01142456f, 
    -0.06654003f, 0.02169024f, 0.06133057f, 0.01751811f, -0.04319871f, -0.07341354f, -0.04608736f, 0.03159178f, 
    -0.05405200f, 0.03204116f, -0.00602995f, -0.01575998f, 0.02482137f, 0.05621028f, 0.01076388f, 0.03130281f, 
    -0.04104387f, -0.05769224f, -0.04107955f, 0.05566055f, -0.08687175f, 0.04881811f, -0.07361277f, 0.00661575f, 
    0.03765837f, 0.04400512f, 0.00817699f, -0.00384006f, 0.05839909f, -0.07677329f, -0.04326655f, -0.02868685f, 
    0.05359480f, -0.00859680f, -0.03713496f, 0.02554742f, 0.03368277f, -0.04241010f, 0.00471264f, 0.02104798f, 
    0.05924261f, -0.06905136f, -0.03568440f, -0.08176710f, 0.04250980f, -0.00129551f, 0.04539546f, -0.01024958f, 
    -0.00956319f, 0.04592409f, -0.07202040f, -0.05999756f, -0.05154357f, -0.02736554f, 0.01397722f, 0.06036539f, 
    -0.01843534f, -0.06604521f, 0.01992092f, -0.06885149f, -0.01133791f, -0.06326192f, 0.06031725f, 0.05433548f, 
    0.02007459f, -0.03371170f, 0.00630298f, -0.08245825f, 0.01937451f, -0.03577430f, 0.01708726f, 0.00263873f, 
    -0.06600649f, 0.02217842f, 0.02952133f, -0.06172292f, -0.03764665f, -0.05020943f, -0.04988346f, -0.03011144f, 
    0.00012684f, 0.04820243f, 0.00563756f, 0.04653960f, 0.00700170f, -0.06415338f, 0.04895250f, 0.05712280f, 
    -0.03921174f, -0.05003441f, 0.03221374f, 0.01591871f, -0.02453324f, 0.05461370f, -0.03259552f, -0.04441406f, 
    -0.06585883f, -0.06220367f, -0.00007290f, -0.04310682f, 0.04966990f, 0.00975653f, 0.00230384f, -0.05795671f, 
    -0.06614275f, -0.03486650f, 0.04305592f, 0.01436324f, 0.06714236f, -0.01591045f, -0.01112745f, 0.00744986f, 
    -0.03586067f, 0.02642950f, -0.01355305f, 0.01031544f, -0.04521860f, 0.03635693f, -0.03940942f, 0.01960593f, 
    0.02506669f, -0.06588350f, -0.04021790f, -0.07136374f, -0.01037979f, 0.04466245f, 0.00154245f, 0.03202311f, 
    -0.00091140f, 0.03419432f, 0.03587291f, 0.03505844f, -0.04122261f, 0.01449879f, -0.05032720f, -0.03191635f, 
    0.02634139f, -0.06366015f, 0.04840656f, -0.01918087f, -0.06508166f, -0.05487465f, 0.04152800f, -0.00847203f, 
    0.04904787f, -0.04243841f, -0.02510364f, 0.00589586f, -0.02170623f, -0.06632470f, -0.04610348f, -0.07019463f, 
    0.14534442f, 0.06975943f, 0.03315562f, -0.19594546f, -0.13281062f, 0.08008119f, -0.00031544f, -0.00864983f, 
    0.04410397f, 0.05042494f, 0.00751566f, 0.00130586f, 0.09736572f, 0.08413107f, -0.03828081f, -0.00388980f, 
    0.01509535f, -0.14032388f, 0.02958304f, -0.07676317f, -0.05424014f, -0.10954112f, 0.03720718f, -0.15361618f, 
    -0.06395709f, -0.07644223f, -0.04914851f, 0.10189371f, -0.15206900f, -0.00136793f, 0.11146284f, 0.01959278f, 
    -0.08639040f, 0.05056572f, -0.02205999f, 0.11013059f, 0.13603885f, 0.21156469f, 0.23535901f, 0.16713266f, 
    -0.06678405f, -0.08041742f, 0.02325438f, -0.02246057f, -0.09969258f, -0.09015819f, -0.05710046f, 0.04885165f, 
    -0.00718604f, 0.04728829f, 0.17720050f, 0.00538281f, 0.00601549f, 0.01796499f, 0.11550827f, -0.04152776f, 
    -0.09009594f, -0.01092769f, -0.10287386f, 0.11154393f, -0.05349298f, 0.07236270f, 0.13021718f, 0.09695359f, 
    0.05470574f, -0.06973182f, -0.08967929f, 0.08884915f, -0.04046390f, -0.05036992f, -0.04782248f, 0.02844452f, 
    -0.04845175f, -0.23173967f, 0.05826610f, -0.11349494f, -0.10080734f, 0.02286422f, -0.00013498f, -0.02041379f, 
    0.06755809f, 0.21945235f, 0.06160506f, 0.17515957f, -0.25802714f, -0.21014127f, 0.10276500f, -0.19542226f, 
    0.04885675f, -0.19592987f, -0.07332344f, 0.16602089f, -0.00468330f, 0.08159881f, 0.00440652f, 0.07195961f, 
    -0.15476047f, 0.05854290f, -0.12452476f, 0.04972260f, -0.01340789f, -0.06896126f, 0.19934280f, -0.02609273f, 
    -0.06321415f, -0.13661523f, 0.00998626f, 0.04218931f, 0.13911094f, 0.25648600f, -0.10157244f, 0.20052031f, 
    0.07682081f, 0.09663139f, 0.00468175f, 0.13113193f, 0.01581308f, 0.02684185f, 0.07919583f, 0.01309159f, 
    -0.38993666f, -0.29747921f, -0.11006231f, 0.02087496f, -0.01547476f, -0.02650478f, -0.09017769f, -0.11153637f, 
    0.03242416f, -0.04172774f, -0.00847667f, 0.10210222f, -0.19796455f, -0.16703324f, 0.05958598f, -0.12617853f, 
    -0.08389270f, -0.12100630f, -0.05823643f, 0.06270903f, 0.04013094f, 0.06029334f, 0.08333913f, 0.04913087f, 
    -0.09930117f, -0.02622888f, -0.07809874f, -0.13516007f, 0.06459334f, 0.09797038f, 0.06318247f, 0.00363635f, 
    0.05745835f, 0.03295008f, -0.01852171f, -0.03641848f, 0.22796407f, -0.07068693f, 0.34116292f, -0.07311630f, 
    0.10883115f, 0.02128999f, -0.11218178f, 0.01723140f, -0.01204690f, -0.03335269f, 0.04933806f, -0.00791809f, 
    0.02757290f, -0.19230632f, 0.01552306f, 0.11103213f, -0.10901101f, 0.08042400f, 0.00447379f, 0.06722020f, 
    -0.01810675f, -0.05991869f, 0.08503299f, -0.00010053f, 0.12609254f, 0.24046551f, 0.40531352f, -0.17261954f, 
    0.14922325f, 0.14047074f, 0.18610325f, 0.05709270f, 0.09384909f, 0.05453165f, 0.15459476f, 0.06168936f, 
    -0.16421363f, -0.10856408f, -0.00074191f, -0.19846740f, 0.00071665f, 0.05689495f, 0.00210674f, 0.03609663f, 
    0.11572746f, 0.06031648f, 0.05444719f, 0.05863579f, -0.22902018f, 0.07497417f, -0.16729650f, -0.14401346f, 
    -0.07476858f, 0.14113872f, 0.05195126f, 0.05486719f, -0.04863544f, -0.03822190f, -0.12201534f, -0.16417789f, 
    -0.26375973f, -0.03348282f, -0.18766840f, -0.21300340f, 0.11703647f, 0.01741855f, 0.10666186f, -0.05401591f, 
    -0.03329857f, 0.01532253f, -0.01219040f, 0.04256572f, -0.38187459f, -0.01769410f, 0.33924216f, 0.06984104f, 
    -0.10825715f, -0.13732292f, -0.00304886f, 0.07324757f, 0.15912376f, 0.02124481f, 0.17514379f, 0.09757420f, 
    0.38512084f, 0.36166251f, -0.00481213f, -0.14919910f, 0.01018219f, -0.01925420f, -0.14313869f, 0.10273929f, 
    -0.00994834f, -0.06275717f, 0.08137400f, -0.10152248f, -0.05782782f, -0.20033400f, 0.04837883f, 0.20376566f, 
    0.02382518f, -0.05115289f, 0.03911406f, 0.20355871f, 0.12377337f, -0.05456128f, 0.07771033f, 0.09146146f, 
    0.12051269f, -0.23048522f, 0.24883913f, -0.00839505f, -0.07053405f, 0.01443729f, 0.06622601f, 0.04681650f, 
    -0.05361648f, 0.00921427f, 0.05275286f, -0.17033145f, -0.05630730f, 0.12086070f, -0.08538190f, -0.26874033f, 
    0.09119089f, -0.01690619f, -0.04792093f, -0.10380226f, 0.09029221f, 0.04833132f, 0.08751439f, 0.07180008f, 
    0.16594532f, 0.08520885f, -0.16364037f, 0.15690163f, 0.13512181f, 0.09805207f, 0.32988068f, 0.02419518f, 
    0.07028340f, -0.03226775f, 0.03348422f, 0.03526422f, 0.06719937f, -0.03352085f, -0.10177725f, -0.04483788f, 
    0.08305795f, 0.09884079f, 0.04720932f, -0.06136744f, 0.17957495f, 0.03208563f, 0.11205346f, 0.17293468f, 
    -0.04698020f, 0.05492882f, -0.14572056f, -0.06187384f, -0.05348445f, -0.05220995f, -0.07152972f, 0.04828903f, 
    0.00166222f, -0.13961282f, -0.14048187f, -0.03829642f, -0.08619510f, -0.07537121f, 0.14075764f, -0.03333168f, 
    -0.00900896f, -0.13694485f, 0.11407955f, -0.07308852f, 0.03949441f, -0.04360795f, 0.03521685f, 0.18853888f, 
    0.03689156f, -0.05303152f, -0.17694861f, -0.03313367f, -0.04093276f, 0.07663763f, 0.18448748f, 0.01724548f, 
    0.11594789f, -0.17497927f, 0.06109167f, -0.10369094f, 0.05556727f, -0.43959579f, 0.13437654f, -0.14658214f, 
    0.14040479f, 0.15801570f, -0.03943238f, -0.04479055f, 0.13596499f, -0.00237027f, 0.04464732f, 0.05301873f, 
    0.23778337f, -0.08449563f, 0.11405366f, 0.11730044f, -0.06299632f, 0.08033518f, 0.03035998f, -0.00407128f, 
    0.17768298f, 0.02969851f, 0.13273039f, -0.08105787f, -0.10703679f, 0.14696981f, 0.28430101f, -0.01637133f, 
    -0.00819232f, -0.00982096f, 0.14466107f, -0.15475562f, 0.03485938f, 0.09532829f, 0.02729430f, -0.07187348f, 
    0.05138745f, -0.12695131f, -0.21898460f, 0.04235383f, 0.11044247f, 0.00830967f, -0.09479085f, -0.21650454f, 
    -0.07434695f, 0.06988198f, 0.07598305f, 0.20957589f, 0.12825607f, -0.15474600f, -0.14278042f, 0.03807679f, 
    0.07922977f, 0.00894458f, 0.08920399f, 0.03944523f, -0.05511452f, -0.05593283f, 0.04064432f, 0.07382654f, 
    -0.13093217f, -0.31017622f, -0.16044681f, 0.17701231f, -0.03676226f, -0.11239246f, -0.07314302f, -0.17518018f, 
    -0.00068443f, 0.07624513f, -0.12530017f, 0.07647838f, 0.02736037f, 0.03588036f, -0.03101932f, -0.00992915f, 
    -0.00643611f, -0.00140516f, 0.06687242f, 0.21530324f, 0.04171280f, 0.14093347f, 0.19201668f, 0.06875654f, 
    0.05768814f, 0.35027823f, -0.20288484f, 0.19050477f, 0.02725100f, 0.03829949f, 0.06600256f, 0.13392480f, 
    0.04320790f, -0.02789566f, 0.09560177f, -0.00501259f, 0.12023389f, 0.06342223f, -0.24293101f, 0.01032454f, 
    0.07769111f, 0.12107582f, 0.17222692f, 0.12345397f, 0.04052059f, 0.02329583f, -0.03920278f, 0.00929938f, 
    -0.06429867f, 0.41527259f, -0.09673604f, -0.09305460f, 0.07322835f, -0.05281516f, -0.17422411f, -0.02843405f, 
    0.09607629f, 0.01617202f, 0.07133961f, 0.02637497f, -0.42609414f, 0.53872263f, 0.13612272f, 0.15618379f, 
    -0.07324279f, 0.22126873f, 0.01610326f, 0.06977402f, 0.07722246f, 0.06620886f, -0.02783047f, 0.12066001f, 
    -0.08328661f, 0.13454327f, -0.23559639f, -0.00248385f, -0.15209578f, 0.06218952f, 0.03183032f, 0.13482575f, 
    -0.02638185f, -0.01059077f, -0.00416245f, -0.08879136f, -0.21030766f, -0.12305741f, -0.16271982f, 0.26552624f, 
    -0.00918273f, 0.07119989f, -0.05208809f, 0.00885106f, 0.00867500f, 0.01864648f, 0.12613347f, 0.00362313f, 
    -0.23124833f, -0.06384411f, -0.08854070f, -0.34927535f, -0.17972653f, -0.23691754f, -0.13783927f, -0.16944638f, 
    -0.14934395f, 0.07361218f, -0.19193064f, 0.04291265f, -0.24091327f, 0.10260869f, 0.24129328f, -0.09889358f, 
    0.03204845f, -0.11889964f, 0.01125290f, -0.07814243f, -0.13463216f, -0.10776405f, 0.06720813f, -0.00376934f, 
    -0.08795933f, -0.13962425f, 0.04669666f, 0.04911688f, -0.03764085f, -0.13293539f, 0.02159878f, -0.04444303f, 
    0.12730056f, 0.15963712f, 0.07252749f, 0.14455342f, -0.39621705f, 0.09037098f, -0.02989553f, 0.39110282f, 
    -0.05686051f, -0.06535362f, -0.15767998f, -0.09314009f, 0.03920661f, 0.03913105f, 0.06192332f, 0.04073929f, 
    -0.07956873f, 0.23142128f, -0.22355436f, 0.06848144f, -0.03623046f, -0.00302016f, 0.03906715f, -0.06121837f, 
    0.24583785f, 0.15033948f, 0.04480959f, 0.16670321f, -0.04752778f, -0.05033754f, 0.04324978f, 0.24160814f, 
    0.03143050f, 0.16884859f, 0.00724337f, 0.01410334f, 0.02478626f, 0.07358445f, 0.07563911f, 0.00548674f, 
    -0.05787433f, 0.08460186f, -0.16953769f, -0.05015477f, 0.16070005f, -0.08238145f, -0.18490268f, -0.24502724f, 
    -0.05215764f, -0.07076913f, -0.11125096f, -0.10133806f, 0.36487597f, -0.02860949f, 0.00344657f, -0.09816115f, 
    -0.10012054f, 0.08776112f, -0.01743495f, -0.11430045f, 0.08306499f, 0.10069335f, 0.13621604f, 0.28794241f, 
    0.19813614f, -0.07833946f, 0.09847694f, 0.13763040f, -0.03401714f, 0.06445964f, 0.05432868f, -0.12660870f, 
    0.02576445f, 0.01970211f, 0.03755667f, 0.10497228f, -0.38033250f, 0.39254364f, 0.15421659f, 0.26817492f, 
    0.10532577f, 0.16877933f, 0.07014679f, 0.00477998f, -0.04851171f, -0.09823774f, 0.02727237f, 0.12494659f, 
    0.03121891f, 0.16543512f, 0.13292617f, 0.00980363f, -0.09167543f, -0.04099897f, -0.01346178f, -0.11839255f, 
    0.03075500f, 0.22740495f, 0.03470723f, 0.06100070f, -0.09752391f, 0.30781326f, 0.14240214f, 0.16089770f, 
    -0.16843265f, 0.11580383f, 0.10118569f, -0.11807732f, -0.07866379f, 0.01838856f, 0.01308444f, 0.15109406f, 
    -0.12529209f, 0.16319564f, -0.06865529f, 0.11573417f, 0.12632623f, 0.03717810f, 0.00124590f, 0.06731471f, 
    0.09354787f, 0.08257338f, 0.06743702f, 0.12883297f, -0.04660643f, 0.39926574f, 0.08759747f, 0.10286955f, 
    0.08143041f, 0.01888928f, -0.00116355f, -0.04475734f, 0.11144008f, 0.23947980f, 0.02426918f, -0.03140846f, 
    0.27374920f, 0.14985837f, 0.03369028f, 0.10941777f, -0.16573779f, 0.01884736f, -0.00342624f, 0.19924997f, 
    -0.00620319f, -0.05629583f, -0.11667132f, -0.07139199f, 0.06584768f, -0.14691317f, -0.07791796f, -0.06821559f, 
    -0.04901440f, -0.10079399f, 0.05626430f, -0.01132268f, -0.00101180f, -0.05241788f, -0.00191408f, -0.09855191f, 
    0.04087665f, -0.02663286f, -0.01792350f, -0.08386745f, -0.06652955f, 0.07089950f, 0.04656738f, 0.08138294f, 
    -0.06490196f, 0.09434058f, 0.03000687f, 0.06980083f, 0.04125866f, -0.01503949f, -0.04693677f, 0.06132023f, 
    0.06657200f, -0.03431105f, -0.03490223f, 0.14074557f, -0.07918017f, -0.13429242f, -0.13646689f, -0.05528053f, 
    0.10858754f, -0.05603550f, 0.13185842f, -0.02271208f, -0.00442740f, 0.02809244f, -0.02550304f, -0.08881484f, 
    0.09547774f, 0.11381269f, 0.13317296f, 0.22530463f, -0.17001081f, 0.10296167f, -0.24735662f, 0.13666053f, 
    0.11203269f, 0.05650256f, 0.00656941f, 0.13572969f, -0.14020862f, 0.01748130f, 0.02237092f, -0.03290865f, 
    -0.28450134f, -0.00916934f, -0.00639026f, 0.25163823f, -0.08569080f, -0.02286724f, 0.04031891f, 0.07678210f, 
    -0.00545809f, -0.10548753f, -0.05409264f, -0.11484435f, 0.24743803f, -0.09083164f, -0.38084713f, 0.09449504f, 
    0.19779700f, 0.02213853f, 0.05255279f, -0.16192615f, -0.03090413f, 0.00942185f, -0.08187937f, -0.08369011f, 
    -0.02127815f, 0.11714651f, -0.07541865f, 0.01857953f, -0.11053342f, 0.29001001f, 0.09647600f, 0.13239671f, 
    -0.09489564f, 0.00700117f, 0.09339397f, -0.05025260f, -0.22005224f, -0.09273777f, 0.06165609f, 0.01633758f, 
    0.15004812f, 0.07889562f, 0.00532542f, 0.01856769f, -0.02849864f, -0.05610830f, 0.05434971f, 0.14753948f, 
    -0.27124569f, -0.08980323f, -0.09882626f, -0.07357313f, -0.01699583f, 0.11960166f, 0.07741161f, 0.17941734f, 
    -0.05302956f, -0.07406570f, -0.02475854f, -0.07375668f, 0.40403363f, -0.23399955f, -0.25342920f, -0.41629204f, 
    0.00283272f, -0.06706343f, 0.01763003f, 0.01608811f, 0.05411342f, 0.02047075f, -0.12507583f, -0.00968583f, 
    -0.46247023f, -0.46262869f, 0.20091954f, -0.00645351f, 0.05338115f, 0.11711618f, 0.02333658f, 0.08186780f, 
    0.08204877f, 0.10995208f, 0.01891953f, 0.07910319f, -0.35018554f, -0.21946828f, -0.13715790f, -0.13915028f, 
    -0.13317685f, 0.03602352f, -0.06712431f, -0.08699039f, -0.10824225f, -0.02352754f, -0.20321052f, -0.04221474f, 
    0.15498273f, 0.04950023f, 0.03252982f, 0.08392946f, 0.00623391f, 0.01940557f, 0.09721813f, 0.00972483f, 
    0.24995402f, -0.04400250f, 0.14059466f, 0.19286531f, 0.11601337f, -0.39041004f, -0.09785784f, -0.09458181f, 
    -0.09146170f, -0.05346807f, 0.02920248f, 0.16223899f, 0.02992004f, -0.01613900f, -0.16023959f, -0.28088862f, 
    0.06340557f, -0.03788071f, 0.06792881f, -0.03295190f, -0.01595649f, -0.09612248f, 0.00877118f, -0.09653788f, 
    -0.06799825f, -0.04698316f, -0.06488792f, -0.04567396f, -0.06595379f, 0.26455683f, 0.14720346f, 0.19451107f, 
    0.03243841f, 0.14976090f, 0.12416907f, 0.16111945f, -0.06518880f, 0.02222242f, -0.12703738f, -0.05234174f, 
    0.21623091f, 0.18111768f, 0.18353571f, 0.18511380f, 0.03525164f, 0.03817713f, -0.02069126f, 0.01652544f, 
    0.08141813f, 0.14488377f, 0.10230225f, 0.05221269f, 0.20946831f, 0.20234090f, 0.04831440f, 0.07966821f, 
    -0.05982399f, 0.10419980f, -0.07830352f, 0.07913327f, 0.21459071f, 0.10894629f, 0.00611663f, -0.08870839f, 
    0.00267563f, 0.08210029f, -0.05842405f, 0.02272245f, 0.00207773f, -0.06649609f, -0.02449331f, 0.07732223f, 
    0.03143767f, -0.02908666f, 0.08870886f, 0.13030483f, 0.49566385f, 0.42034671f, 0.28837690f, 0.13699818f, 
    -0.04864204f, 0.02512377f, 0.01416131f, 0.07623003f, 0.02322840f, 0.05998823f, 0.01878738f, 0.04466506f, 
    0.02733496f, -0.00396909f, 0.10911668f, -0.04560910f, 0.08557871f, 0.01543827f, 0.00606981f, 0.02625541f, 
    -0.09302795f, 0.10572258f, 0.11325970f, 0.19850641f, 0.02916040f, -0.01826410f, -0.03607540f, -0.22271881f, 
    -0.02998905f, -0.06987330f, -0.03741127f, 0.24359569f, -0.04557529f, 0.07809759f, 0.05788863f, -0.12446852f, 
    0.13416910f, 0.09540303f, 0.09572963f, 0.04277878f, 0.00212099f, 0.24544781f, 0.10176332f, 0.19499299f, 
    -0.01073020f, 0.03788034f, 0.01210672f, 0.03029377f, -0.31768644f, -0.05234351f, 0.05989328f, 0.10757227f, 
    0.00256408f, -0.05587590f, 0.10721849f, -0.05995811f, -0.16542627f, -0.08243578f, -0.00529727f, -0.04826703f, 
    -0.14525996f, -0.16704892f, -0.40650985f, -0.36893326f, -0.14105731f, 0.02091515f, -0.11827002f, 0.03289855f, 
    -0.01282977f, -0.01303242f, 0.06582496f, -0.01182292f, 0.44426909f, -0.05754027f, -0.06753471f, -0.27522653f, 
    -0.01475275f, -0.02501258f, -0.06666443f, -0.06002351f, -0.16436183f, 0.07333942f, 0.15641429f, 0.06670333f, 
    -0.42012700f, -0.28891495f, -0.16692677f, -0.05003199f, -0.04050966f, 0.02444922f, -0.01302944f, 0.11170480f, 
    0.27082491f, 0.26098740f, -0.02289350f, 0.07731792f, -0.15911366f, -0.00721303f, 0.02059657f, -0.00948358f, 
    -0.04967427f, 0.10276805f, -0.17763905f, -0.10504790f, -0.31075251f, -0.13881484f, -0.17148946f, -0.13517474f, 
    0.05368800f, -0.07418851f, -0.00078844f, 0.05479176f, 0.08291503f, 0.07402329f, -0.01003698f, 0.07859853f, 
    0.28486001f, 0.02960314f, 0.00069897f, -0.00147408f, 0.22733751f, -0.14955215f, 0.02746760f, -0.12266161f, 
    -0.01291890f, 0.00908022f, 0.03661435f, 0.06917406f, -0.08221796f, 0.22961920f, 0.17243353f, -0.09837648f, 
    -0.00088345f, 0.19842993f, 0.05435125f, 0.02361256f, -0.29026654f, -0.17251450f, -0.06052764f, -0.02969077f, 
    0.01951603f, 0.04283885f, 0.05633171f, -0.02435995f, -0.16035055f, -0.10602663f, -0.29623443f, 0.03798569f, 
    -0.02281089f, -0.03590731f, -0.10493241f, -0.02713547f, -0.09122676f, 0.03924507f, 0.01072645f, -0.04044143f, 
    0.01544063f, -0.01459065f, 0.03282697f, 0.02389410f, -0.03262599f, -0.08661504f, 0.01184761f, -0.08713579f, 
    0.14257877f, 0.07073525f, 0.05701193f, 0.09002402f, 0.19864193f, 0.19091809f, -0.02876591f, 0.00965293f, 
    -0.01218927f, -0.07260314f, -0.00413559f, -0.01152925f, 0.14278926f, 0.08863249f, 0.01807610f, -0.02537446f, 
    -0.17047453f, 0.09674568f, -0.06130178f, -0.00408682f, -0.00514705f, 0.00146701f, -0.03344013f, 0.08189138f, 
    0.00317858f, -0.12640692f, -0.05041591f, 0.21103336f, 0.23866250f, -0.01907426f, 0.24969818f, 0.01043789f, 
    -0.04450062f, 0.01792157f, 0.02685892f, 0.05350000f, -0.08827798f, 0.09384903f, 0.02405782f, 0.06189628f, 
    -0.08858969f, 0.09655309f, 0.07041182f, -0.08565607f, 0.00655851f, -0.03838252f, -0.01253552f, -0.01183685f, 
    0.07139887f, -0.02787362f, -0.03431783f, 0.17895201f, -0.05171584f, -0.13378751f, 0.12147620f, -0.10221330f, 
    -0.05312743f, 0.25919470f, -0.21702391f, 0.18471961f, -0.07641129f, -0.01063134f, 0.12455060f, 0.00006871f, 
    -0.03357528f, 0.12871386f, -0.00850025f, 0.03635056f, -0.00882353f, 0.04423648f, 0.10517909f, -0.12342460f, 
    0.11843295f, 0.01107776f, -0.06434508f, 0.10136226f, -0.25196457f, -0.10132019f, -0.20944078f, -0.20470399f, 
    -0.21718520f, 0.07707889f, 0.09569670f, -0.07427207f, -0.13480762f, -0.12003975f, -0.06890410f, -0.21741962f, 
    0.12762578f, -0.17865942f, -0.10846144f, -0.15603451f, 0.02282118f, -0.01868031f, 0.10830379f, -0.09512398f, 
    0.00872301f, 0.03430619f, 0.00715290f, 0.01316510f, 0.10987989f, -0.32066900f, -0.29149541f, -0.17237702f, 
    0.07582928f, -0.01125732f, 0.08300079f, 0.11159080f, 0.24566634f, 0.01767246f, 0.02803891f, 0.13109930f, 
    -0.10350380f, -0.12587036f, -0.04489788f, 0.17400317f, 0.03079663f, 0.02174986f, 0.11899081f, 0.16448738f, 
    -0.05555282f, 0.09897002f, 0.20473374f, -0.10902496f, 0.34837094f, -0.38041368f, -0.15641426f, -0.12164425f, 
    0.05269204f, -0.24333672f, 0.25626066f, 0.16011523f, 0.09232736f, -0.11258069f, 0.06880570f, 0.14390773f, 
    -0.00961210f, 0.05122057f, -0.04675056f, -0.01357613f, -0.07104445f, -0.10033245f, -0.00969100f, -0.09906849f, 
    0.13156812f, 0.00152252f, 0.18843614f, 0.04397377f, -0.30440643f, -0.19424278f, -0.13374421f, -0.00203872f, 
    0.10892749f, 0.06201646f, 0.00151221f, 0.10114823f, 0.03805596f, 0.02175630f, 0.07532264f, 0.11638352f, 
    0.16299577f, -0.14154881f, 0.06679730f, -0.02395930f, 0.13028510f, 0.02149785f, -0.02626136f, -0.02556542f, 
    0.08589907f, -0.08705354f, 0.02739041f, 0.09157705f, -0.06279895f, -0.04752856f, -0.06241329f, -0.03251962f, 
    -0.13799527f, -0.14026329f, -0.01177346f, -0.03928046f, -0.00404456f, -0.01235042f, -0.06803283f, 0.18458313f, 
    -0.03457925f, 0.08402742f, 0.05622164f, 0.08004251f, 0.13306724f, -0.00096285f, -0.08819398f, -0.00655761f, 
    0.06043999f, 0.05991400f, 0.09759958f, -0.01532391f, -0.18585289f, -0.01620602f, 0.08650881f, 0.04278703f, 
    0.08083652f, 0.05666753f, -0.01367555f, -0.00007452f, -0.04412440f, 0.01852042f, -0.01876332f, 0.10835657f, 
    0.01011697f, 0.02995365f, 0.06355005f, 0.14214201f, 0.00731426f, -0.00028417f, 0.04030564f, -0.02882767f, 
    0.34637567f, 0.05394457f, 0.14464685f, -0.25088719f, 0.25390661f, 0.14428860f, 0.10582656f, 0.11940871f, 
    -0.11457379f, 0.20178175f, 0.04000137f, 0.03505811f, 0.05679396f, -0.01589746f, 0.06352560f, -0.10050833f, 
    0.38411364f, -0.32083380f, 0.05728405f, 0.04628962f, 0.02458174f, -0.05637588f, -0.05441712f, -0.01596482f, 
    0.15223311f, -0.02127470f, 0.10412035f, 0.13260797f, 0.26978791f, 0.26403901f, 0.09715854f, -0.16039462f, 
    -0.01606014f, 0.04109273f, 0.06987064f, 0.08172108f, 0.21643928f, 0.06421591f, -0.00951148f, -0.04801644f, 
    0.05306943f, 0.38973594f, -0.11402822f, 0.11724433f, -0.07462302f, 0.04662207f, -0.16005525f, -0.20148505f, 
    -0.02528107f, 0.02305645f, -0.08128405f, 0.00250362f, 0.18266933f, -0.00977753f, 0.01927976f, -0.01905398f, 
    0.04123773f, 0.08796489f, -0.08066428f, 0.16776234f, -0.03558790f, 0.15148954f, -0.00270192f, 0.01058402f, 
    0.46566081f, 0.26805183f, -0.00613587f, 0.13534267f, 0.00908452f, -0.04441482f, -0.00381969f, -0.05964088f, 
    0.00431083f, -0.01169473f, -0.01437524f, -0.00738795f, 0.47183809f, 0.24131255f, -0.11222205f, -0.05097844f, 
    0.02052169f, 0.00025511f, 0.07715455f, 0.07963051f, -0.01175128f, -0.02634725f, 0.05487112f, 0.02139962f, 
    0.19128260f, 0.00968485f, 0.11474274f, 0.18279834f, 0.07676910f, -0.04574410f, -0.05814525f, 0.07017594f, 
    -0.01988263f, 0.06791310f, -0.02927767f, 0.07963675f, -0.16843110f, 0.23742379f, -0.02917125f, -0.21331373f, 
    0.07925298f, -0.01451861f, 0.00589389f, -0.02745887f, -0.01890341f, 0.05967357f, 0.03114685f, 0.00481264f, 
    -0.33306628f, -0.05681317f, -0.06118879f, 0.02971816f, -0.01476178f, -0.07121084f, 0.02677242f, -0.08661019f, 
    -0.06261756f, -0.10330305f, -0.03050658f, 0.24879192f, 0.07131226f, -0.19509029f, -0.38739422f, 0.01362831f, 
    0.02097011f, 0.03736192f, -0.06138321f, 0.10113803f, 0.02852059f, -0.04998352f, 0.00682475f, 0.06540406f, 
    -0.14405093f, 0.04063474f, -0.32044843f, -0.15592942f, -0.16871364f, -0.04935592f, -0.04074666f, -0.02360682f, 
    -0.02277836f, -0.01484042f, -0.06255847f, -0.09707417f, 0.27344540f, 0.18945004f, 0.17847955f, 0.27671519f, 
    0.03642549f, -0.01123403f, 0.04404839f, 0.15333174f, 0.02142917f, -0.02146244f, -0.07101113f, -0.04988867f, 
    -0.04803636f, -0.27537251f, -0.30435422f, -0.04237009f, 0.04598578f, 0.07612032f, -0.03268740f, -0.06742888f, 
    -0.04468222f, 0.13932776f, -0.03121735f, -0.03695161f, -0.02331647f, -0.17971666f, -0.17955653f, -0.11806032f, 
    0.05405305f, -0.03240991f, 0.05277855f, -0.09954186f, -0.08760925f, -0.11476572f, 0.07402029f, -0.04779605f, 
    -0.07110529f, 0.24484226f, -0.07930334f, 0.15598296f, -0.08291775f, 0.00038819f, 0.05629481f, -0.11995741f, 
    -0.10413773f, -0.03696630f, 0.05029998f, 0.19912443f, 0.00444908f, -0.02251298f, 0.17129226f, 0.03156940f, 
    0.17622739f, 0.00940345f, -0.04081472f, -0.03526661f, -0.11234032f, -0.00718276f, -0.03480294f, 0.05093735f, 
    -0.13111177f, -0.23611446f, 0.14301445f, -0.16405411f, 0.00701444f, -0.00058106f, -0.05323915f, -0.02888089f, 
    0.00832673f, -0.14374106f, -0.03190968f, 0.20342045f, 0.46500465f, 0.61137414f, 0.32079235f, 0.09277677f, 
    -0.03780558f, 0.09435556f, 0.19748823f, 0.09004142f, 0.03076237f, 0.03082729f, 0.04707137f, -0.09752468f, 
    0.24315558f, -0.11540516f, 0.15123226f, -0.20787269f, -0.04015120f, 0.04030486f, -0.03824706f, -0.05661446f, 
    0.10835263f, 0.11913216f, -0.02595874f, 0.00415745f, -0.12753372f, -0.03158922f, -0.06035402f, 0.09006103f, 
    0.00507177f, -0.09518349f, 0.14928405f, 0.07456398f, -0.02486801f, -0.20784761f, -0.14381149f, -0.16376086f, 
    -0.25452709f, -0.10462423f, -0.00296178f, 0.15019105f, 0.09763788f, 0.00037980f, 0.12669189f, 0.05048800f, 
    -0.03687803f, -0.02646457f, -0.01390806f, -0.00163204f, 0.10741885f, -0.13733800f, 0.13610816f, 0.03400505f, 
    -0.07012055f, -0.08490731f, 0.12019395f, 0.00720482f, 0.16367622f, 0.01053247f, -0.02148941f, 0.19931087f, 
    -0.13300487f, 0.23122095f, -0.05157036f, 0.18614788f, 0.06312452f, -0.03430194f, -0.03076170f, -0.12876393f, 
    0.02723191f, 0.05991945f, 0.04878756f, 0.00445248f, 0.07010658f, -0.42045566f, 0.05061555f, 0.05595132f, 
    -0.07356229f, -0.08223330f, -0.07751512f, 0.09124713f, -0.15982831f, -0.11759614f, -0.06014840f, 0.08056510f, 
    0.07406043f, 0.10400119f, 0.15177393f, -0.05732059f, 0.02282726f, -0.06630077f, -0.07821105f, 0.06136446f, 
    0.01347032f, -0.01656190f, -0.09761405f, -0.24497797f, -0.10613589f, -0.00256069f, -0.04161094f, -0.07069022f, 
    0.12952517f, -0.09194580f, 0.06045310f, 0.13117580f, 0.04254999f, -0.05036634f, 0.00116173f, -0.01793634f, 
    -0.24218586f, -0.05014014f, -0.06158718f, 0.15233590f, -0.14314942f, 0.00954856f, 0.11919975f, -0.11777674f, 
    0.06563696f, 0.03331145f, -0.09198701f, 0.02081611f, -0.00958426f, 0.28890115f, -0.04029445f, 0.40415591f, 
    -0.08962636f, 0.10364722f, -0.01036995f, 0.17866293f, 0.02039047f, 0.14215836f, 0.03963212f, 0.02449249f, 
    -0.08180269f, 0.06976837f, 0.05054593f, 0.04021141f, -0.01694639f, 0.00574894f, -0.08284950f, 0.00389161f, 
    0.15924725f, -0.03144140f, 0.01653125f, -0.04473101f, -0.04882613f, 0.02678588f, 0.09087171f, -0.02692552f, 
    -0.01853760f, 0.01821697f, 0.01140908f, 0.01105639f, -0.02757822f, -0.01273094f, 0.02610897f, 0.09544559f, 
    0.04666471f, 0.01835596f, 0.01711151f, -0.01110338f, -0.08507283f, -0.02485307f, 0.12799516f, -0.11764459f, 
    0.15176740f, 0.00969703f, -0.05487684f, -0.23922981f, 0.08849939f, -0.06939951f, 0.29177237f, 0.07276843f, 
    0.03739863f, 0.05244841f, 0.06819151f, -0.07169077f, 0.09148765f, -0.01993398f, 0.10682898f, -0.05428537f, 
    0.17195159f, 0.03064563f, 0.00867004f, 0.09518192f, -0.09689976f, -0.09347728f, -0.15312660f, 0.05613827f, 
    0.03119989f, -0.04054757f, 0.17426366f, -0.05362080f, -0.07916052f, 0.02604356f, 0.36251232f, -0.22619005f, 
    0.10797090f, 0.07166490f, 0.02509943f, -0.14945051f, 0.18692125f, 0.12391946f, 0.12124407f, -0.04930703f, 
    -0.04627136f, 0.08602065f, 0.07800911f, -0.10510447f, 0.02311092f, 0.08613787f, 0.10963197f, 0.13561153f, 
    0.03771954f, 0.08310196f, 0.01660152f, 0.18529050f, 0.01567060f, 0.01607767f, -0.07207888f, 0.03350540f, 
    -0.01977814f, -0.10570521f, 0.18431215f, 0.11524781f, -0.01768207f, -0.13621596f, 0.16427834f, -0.04688974f, 
    -0.07904460f, -0.11580702f, -0.00108499f, 0.08522446f, -0.01432548f, -0.06341540f, 0.04687224f, -0.01132920f, 
    -0.06122511f, -0.02850873f, -0.06659242f, 0.01912777f, -0.11111505f, -0.15217704f, -0.05912136f, 0.14238152f, 
    0.04367250f, -0.06033856f, -0.10578540f, -0.01147772f, 0.12169085f, 0.14265928f, 0.18842649f, 0.12853968f, 
    -0.07198631f, 0.04549597f, -0.00415599f, 0.07087328f, -0.06446109f, -0.14158030f, -0.09522562f, 0.07665478f, 
    0.06316869f, 0.00135720f, 0.06573612f, -0.07965834f, 0.32156888f, -0.24848031f, 0.00844764f, -0.01721445f, 
    0.11727785f, -0.09425505f, 0.08698751f, 0.02385957f, 0.10406841f, 0.04884297f, 0.08257845f, 0.06879327f, 
    -0.11996263f, 0.23603705f, 0.01949571f, -0.05109558f, -0.08961527f, 0.00964614f, -0.02976166f, -0.12772098f, 
    0.00484584f, 0.12433095f, 0.04135634f, -0.13211541f, -0.34570211f, -0.16753882f, 0.10367367f, -0.03517860f, 
    0.16090956f, 0.04628479f, 0.11782212f, 0.03552779f, -0.01532347f, 0.11320691f, 0.09438039f, 0.01532449f, 
    0.43003827f, -0.19616373f, 0.08169615f, -0.05045284f, 0.14163966f, -0.03019013f, -0.05835564f, 0.16567411f, 
    0.06533893f, -0.05290152f, 0.04607582f, -0.00697439f, -0.08602268f, 0.02130705f, 0.02466744f, 0.20506299f, 
    0.00993611f, 0.08052854f, 0.04164657f, 0.10647970f, 0.04086091f, 0.03293251f, 0.05813296f, 0.05606410f, 
    -0.12273670f, 0.03657478f, -0.01864900f, -0.02100917f, -0.00595111f, -0.06235612f, -0.06536818f, -0.02511339f, 
    0.05573803f, -0.03683470f, -0.01761602f, 0.11271924f, -0.13680576f, -0.06211769f, -0.01821934f, -0.02532554f, 
    0.04504700f, 0.07756496f, -0.02306375f, -0.04688622f, 0.10561584f, 0.01382950f, 0.14198814f, 0.23579022f, 
    0.07647578f, -0.19457912f, 0.04956828f, -0.14298393f, -0.10583917f, -0.05072622f, -0.04742060f, 0.09847829f, 
    0.14108667f, 0.01868617f, -0.13368677f, -0.21118057f, 0.23838884f, 0.22023132f, 0.01158103f, 0.08477715f, 
    0.03396587f, 0.07720705f, 0.05924476f, -0.05041929f, 0.06810236f, -0.04594634f, -0.00009056f, -0.13946895f, 
    0.00174410f, -0.19477400f, -0.16571946f, 0.21080628f, -0.02790309f, -0.03918376f, 0.00789154f, -0.08900570f, 
    -0.06100823f, 0.03740139f, 0.09599086f, 0.05287208f, -0.02973333f, -0.15736325f, 0.03278096f, 0.02012720f, 
    0.09866093f, 0.03121031f, 0.00261959f, -0.07953129f, 0.08700327f, -0.05896757f, -0.05356338f, -0.05000735f, 
    0.18799838f, -0.46034282f, 0.07648712f, -0.08145314f, 0.16828330f, -0.07465897f, 0.02666297f, 0.05916727f, 
    0.12977128f, 0.08650360f, 0.12113017f, 0.12674072f, -0.20446369f, -0.10323416f, -0.00828172f, 0.26266891f, 
    0.21277396f, -0.02664817f, -0.11663339f, -0.15906408f, 0.05505120f, 0.12800024f, -0.05466086f, -0.02567478f, 
    -0.16525179f, -0.01250574f, 0.09370064f, 0.36526966f, 0.01304499f, 0.03090935f, -0.04586916f, 0.22441037f, 
    0.09265862f, -0.01253038f, 0.03042168f, 0.06914046f, 0.20450655f, 0.16873100f, 0.17196149f, 0.25046912f, 
    -0.00122050f, -0.08891220f, -0.00469775f, 0.09727387f, -0.06191643f, 0.06252740f, -0.10905917f, 0.08291021f, 
    0.02019285f, 0.22563705f, 0.30745122f, 0.04247154f, 0.07324277f, -0.02136888f, 0.15460205f, 0.00754445f, 
    0.27901462f, 0.07131990f, 0.01622731f, 0.02179408f, 0.02885496f, -0.00989843f, 0.07869980f, 0.08535231f, 
    0.13314024f, 0.08912832f, -0.05006591f, -0.02586378f, 0.08209784f, -0.08594036f, -0.00484069f, 0.01541378f, 
    0.06134725f, -0.09156094f, 0.10947321f, 0.00855470f, -0.03332189f, -0.06203312f, -0.07472815f, -0.08114730f, 
    -0.15430689f, -0.03686479f, 0.03762675f, -0.03586195f, 0.31223631f, -0.08349941f, 0.34239423f, -0.00823129f, 
    0.00775965f, 0.02040922f, -0.08176710f, -0.18034902f, 0.06634527f, 0.03877146f, 0.09233373f, 0.07472074f, 
    -0.31719682f, -0.06856544f, -0.12595327f, 0.00498591f, 0.24681860f, -0.05572290f, 0.08763152f, -0.13970210f, 
    0.10183221f, 0.06792111f, -0.00664443f, 0.11507346f, -0.15213394f, -0.01099394f, 0.07875486f, 0.15562749f, 
    0.06490818f, 0.10547659f, 0.05921144f, 0.11550309f, 0.05903430f, 0.01419014f, 0.16637677f, -0.00040288f, 
    -0.42703235f, -0.16559593f, -0.07892779f, -0.14327398f, -0.07215253f, -0.08591504f, -0.12918980f, -0.17366639f, 
    -0.00580668f, -0.11305757f, -0.15118161f, -0.06952409f, -0.19113623f, -0.06832807f, -0.13713759f, -0.13806842f, 
    -0.13818993f, -0.10098521f, -0.08712274f, 0.06164192f, 0.01091838f, 0.01694212f, 0.01685166f, -0.07889288f, 
    0.13148455f, 0.01640468f, 0.05793184f, -0.12831159f, 0.07530104f, -0.10019728f, 0.03709384f, -0.05028841f, 
    -0.13473073f, 0.03296579f, -0.04944503f, 0.11168900f, -0.10839511f, -0.22015733f, 0.00192539f, -0.02185933f, 
    -0.07164232f, 0.00333349f, 0.08271588f, -0.07580721f, 0.00402392f, -0.00002113f, -0.03059519f, 0.06812239f, 
    0.14889398f, 0.15609971f, -0.08196957f, -0.05280709f, -0.03515304f, 0.02851862f, 0.00184892f, 0.02844447f, 
    -0.17682701f, 0.05536253f, 0.02278345f, 0.00478400f, 0.00720598f, -0.20357123f, -0.07327295f, 0.01406305f, 
    0.04046275f, 0.02470073f, 0.13202941f, 0.37554878f, 0.11731452f, 0.07595337f, 0.05371660f, 0.13208666f, 
    0.06943295f, 0.17207684f, -0.11508966f, -0.11173048f, -0.09064188f, 0.07131795f, 0.18360449f, 0.15195136f, 
    0.10497382f, 0.02250907f, 0.02880291f, 0.08852693f, 0.23495397f, 0.14164495f, 0.10489217f, -0.06019507f, 
    0.06186336f, -0.11780462f, 0.03493428f, 0.05686859f, -0.07460082f, -0.26549363f, -0.01046174f, -0.23705195f, 
    -0.02622448f, 0.14152831f, 0.06576612f, 0.13114506f, 0.22432239f, -0.04362692f, 0.15136005f, 0.00455594f, 
    -0.00549151f, 0.04101926f, 0.04596553f, -0.01469802f, -0.30796176f, 0.11641343f, 0.00058896f, 0.13314793f, 
    -0.14279103f, -0.03291390f, 0.02191651f, -0.08399811f, 0.08402935f, -0.01550315f, 0.03318992f, 0.22847645f, 
    0.00608228f, 0.15486549f, 0.00077362f, -0.00628541f, -0.03564764f, -0.04496856f, 0.01593646f, 0.01933183f, 
    0.00104777f, -0.09823041f, -0.05643128f, 0.04895092f, -0.09221496f, -0.16660410f, 0.10740753f, -0.04523598f, 
    0.08191525f, -0.09419533f, -0.06125105f, 0.13485014f, -0.13264559f, -0.08285673f, -0.04114728f, -0.19958907f, 
    -0.04076385f, 0.24199347f, 0.01055751f, -0.02142014f, 0.01001180f, -0.01343973f, -0.10768099f, -0.03263569f, 
    -0.12921596f, 0.12893263f, 0.07208841f, -0.22306041f, -0.08103051f, 0.13372163f, 0.06091018f, -0.05836608f, 
    0.01290392f, -0.03321554f, -0.15126386f, 0.07947988f, 0.04957562f, 0.09549663f, 0.11320262f, -0.01459794f, 
    0.21859148f, 0.14195833f, 0.10212247f, 0.06199634f, -0.09187493f, 0.06157407f, 0.03530880f, 0.16730471f, 
    0.03897352f, -0.03396711f, 0.07778081f, 0.07410703f, 0.16607392f, 0.13393439f, 0.14583914f, 0.23590030f, 
    0.05281639f, 0.12994599f, 0.05471632f, 0.06848589f, -0.01592806f, 0.00018567f, 0.02650329f, 0.01777989f, 
    -0.10913464f, -0.14743416f, 0.12188890f, 0.07147983f, -0.09689175f, -0.05642644f, -0.17831588f, -0.13866577f, 
    -0.03991388f, -0.14821352f, 0.03503200f, -0.01339517f, -0.01141036f, -0.11358879f, 0.04032984f, 0.04691755f, 
    -0.06789504f, -0.14115646f, -0.17645018f, 0.01890033f, 0.02740911f, 0.06072934f, 0.00654245f, 0.24354336f, 
    -0.02578098f, -0.14111894f, -0.04455044f, -0.12615524f, -0.01912628f, -0.05049594f, -0.07553947f, 0.04624677f, 
    0.02598381f, -0.15364937f, -0.22366425f, -0.44835043f, 0.12807064f, 0.23877461f, 0.01802930f, 0.19456282f, 
    0.02040876f, 0.12186066f, 0.17555970f, 0.07017301f, 0.15853181f, -0.12527442f, 0.07837798f, 0.06217450f, 
    -0.05181130f, 0.03582532f, -0.12709355f, 0.26671818f, -0.11262239f, 0.01630430f, -0.11516216f, -0.13586342f, 
    -0.13139011f, -0.09576104f, 0.31135985f, -0.13802867f, -0.06858907f, -0.03595703f, 0.08835135f, -0.10613562f, 
    0.16891013f, 0.06683666f, 0.26213017f, -0.16171391f, 0.23719802f, -0.05734931f, 0.23085667f, 0.15977895f, 
    0.00187197f, -0.00168815f, -0.06936914f, 0.02017825f, 0.06575317f, -0.03690775f, 0.05419862f, 0.02637435f, 
    -0.00247088f, -0.07147763f, 0.03091804f, 0.05205669f, -0.00616411f, 0.02612700f, -0.05644507f, 0.04491600f, 
    -0.05755407f, 0.01077034f, -0.02931494f, -0.01670883f, -0.02772952f, -0.01584520f, -0.07702693f, 0.03942881f, 
    -0.06786016f, -0.07080680f, 0.02598958f, 0.01480482f, -0.07292654f, 0.00389264f, -0.05985910f, -0.06483417f, 
    0.02693542f, 0.01338284f, -0.02751557f, 0.02563162f, 0.02807132f, -0.04970819f, -0.06091884f, -0.03439898f, 
    -0.05132984f, 0.04365183f, -0.07753254f, 0.05843216f, -0.05763054f, -0.00285696f, -0.00978420f, -0.02556612f, 
    0.01669237f, -0.05331400f, 0.03850688f, -0.05816558f, -0.08037850f, -0.03588188f, 0.00818776f, -0.02363835f, 
    0.04135050f, 0.06746722f, 0.00274846f, -0.02642968f, 0.01374627f, 0.05967398f, 0.00095774f, -0.04223951f, 
    0.02665235f, 0.05600597f, 0.01873230f, -0.04569991f, -0.00800107f, -0.05893116f, -0.06246255f, 0.02917970f, 
    0.01488389f, -0.02852888f, -0.00419388f, 0.01438544f, 0.02640993f, -0.07596464f, 0.06262541f, -0.03965310f, 
    0.02338540f, 0.00266619f, 0.06414317f, 0.04262889f, -0.04461156f, 0.03092304f, -0.04179529f, -0.07900912f, 
    -0.05476870f, -0.01399622f, -0.03306387f, 0.03033300f, -0.05204179f, -0.04486312f, -0.06360988f, -0.03730455f, 
    -0.06475826f, 0.02573550f, 0.00830223f, 0.00223510f, 0.01136625f, -0.06754880f, -0.01615778f, 0.01073595f, 
    0.02312420f, 0.03018542f, 0.03446324f, -0.00344269f, -0.04275512f, -0.04480765f, -0.05782321f, -0.03763786f, 
    -0.03157453f, 0.04598058f, -0.00101276f, 0.00360608f, -0.06648570f, 0.03546166f, -0.06585007f, 0.05065419f, 
    0.00243249f, -0.06896317f, 0.03735823f, -0.03246040f, -0.02293175f, 0.00414968f, -0.04996997f, 0.06459127f, 
    -0.01775028f, 0.02739620f, 0.05913121f, 0.00982775f, 0.00772781f, 0.05355643f, 0.03343141f, -0.00224510f, 
    0.03779396f, 0.01468261f, -0.07078722f, -0.04591324f, -0.00758470f, -0.01109373f, -0.06494149f, 0.04832433f, 
    -0.03424494f, 0.01772113f, 0.04425588f, -0.06882078f, -0.06406149f, -0.05626763f, -0.02982913f, 0.03407833f, 
    0.06715868f, -0.07176003f, 0.05883305f, -0.07111596f, 0.02552848f, 0.02114962f, -0.01423880f, 0.03937824f, 
    -0.07806627f, 0.00758788f, -0.06824607f, -0.08101916f, -0.00600410f, 0.04648387f, -0.03998312f, -0.06073761f, 
    -0.01031886f, 0.02683103f, 0.00982484f, 0.03421323f, -0.06125592f, 0.01632030f, 0.02930482f, -0.03169769f, 
    -0.04879075f, -0.07401015f, 0.02932981f, -0.00376825f, -0.00659807f, -0.01405874f, -0.01200090f, 0.04125799f, 
    0.04602713f, 0.03454436f, -0.00898721f, -0.00499508f, -0.03658212f, -0.02194935f, 0.01162348f, 0.06287539f, 
    -0.06750710f, 0.01182376f, 0.05877460f, -0.01409465f, 0.00145458f, -0.11889379f, 0.15826122f, 0.06353928f, 
    -0.07159089f, 0.05198812f, 0.10540270f, 0.00966419f, -0.22620796f, 0.18407230f, 0.15748350f, 0.08352073f, 
    0.03875111f, 0.14380056f, -0.01449237f, -0.01147868f, 0.04013294f, -0.08546297f, -0.09263190f, -0.03946774f, 
    -0.07859563f, 0.07123713f, 0.06556033f, 0.03611900f, 0.02334403f, -0.03221629f, 0.11952145f, 0.16889580f, 
    -0.13182724f, -0.10164117f, 0.02424560f, -0.08460190f, -0.18713687f, 0.17514178f, -0.02177033f, -0.12044895f, 
    -0.16052790f, 0.06870030f, 0.02379147f, 0.15095194f, 0.14493623f, -0.06226043f, -0.13887377f, -0.04216717f, 
    0.13085239f, 0.03059222f, 0.07461389f, -0.04182423f, 0.01766444f, 0.09752810f, 0.02454286f, 0.00261835f, 
    0.17393917f, -0.04769004f, -0.01634555f, 0.01645589f, -0.34468177f, 0.03749881f, -0.14110421f, 0.04258021f, 
    0.06470554f, 0.07161390f, -0.09383925f, 0.13354971f, -0.04170070f, -0.13632660f, -0.16025719f, -0.19780482f, 
    0.22145072f, -0.26898077f, 0.01802235f, -0.02738555f, -0.02581847f, -0.06719441f, -0.03529346f, 0.01226132f, 
    -0.00512085f, -0.20957509f, -0.18216804f, 0.12680168f, 0.26603359f, -0.17533930f, 0.01237338f, -0.12679958f, 
    -0.14227475f, 0.04045578f, -0.00994885f, 0.02411397f, 0.12982807f, -0.01204674f, -0.08424015f, -0.00778057f, 
    -0.25467345f, 0.12426012f, -0.02791619f, 0.01081086f, 0.14600615f, 0.00257190f, 0.11536749f, 0.05938821f, 
    0.03488810f, 0.09369171f, 0.06824336f, 0.07270942f, 0.07043578f, 0.09782354f, 0.00651100f, -0.11332034f, 
    0.12393805f, 0.00667966f, 0.10433953f, 0.04714465f, 0.00194605f, 0.05095696f, -0.04036317f, 0.16433018f, 
    -0.02320119f, 0.00717519f, 0.14932211f, 0.08606556f, 0.01765179f, -0.04665519f, -0.06230481f, 0.02253899f, 
    -0.01617923f, 0.00737113f, 0.00818169f, -0.05601912f, 0.12523235f, 0.08284875f, 0.17078446f, -0.00508767f, 
    -0.01955813f, -0.04136815f, 0.02796304f, 0.14731161f, 0.07751448f, 0.11823384f, 0.10043134f, -0.10562271f, 
    -0.02461228f, -0.06072742f, -0.09525343f, -0.02167338f, 0.05237256f, -0.04149385f, 0.03415449f, 0.02853087f, 
    -0.08102527f, -0.13913196f, 0.06960725f, 0.01479820f, 0.09680761f, -0.09809467f, 0.11488402f, -0.15846707f, 
    0.00477408f, 0.01154899f, 0.06182036f, 0.07782401f, 0.02509603f, 0.07892268f, -0.02822505f, 0.08512595f, 
    0.12715022f, 0.03614217f, 0.08120999f, -0.12179602f, -0.02506157f, 0.03572624f, 0.02268388f, -0.06428692f, 
    -0.00249101f, -0.05963277f, 0.12987985f, -0.08883578f, -0.04439286f, 0.10492968f, 0.19528624f, -0.01942828f, 
    -0.12552498f, 0.02269298f, 0.07471269f, -0.01778415f, 0.02901911f, -0.07477861f, 0.03188451f, 0.15268312f, 
    -0.07255886f, -0.19581257f, 0.23236078f, -0.07243359f, 0.09579410f, 0.06349309f, -0.15425071f, 0.11938951f, 
    -0.01965089f, 0.10646746f, -0.01568450f, 0.02199647f, -0.26280117f, -0.01015222f, 0.00788551f, 0.00230626f, 
    0.00581315f, -0.03075840f, 0.05775402f, 0.03287141f, 0.14955068f, -0.03012153f, 0.00164399f, 0.05322008f, 
    -0.30197659f, -0.02430495f, 0.10853134f, 0.10704640f, -0.05016743f, -0.05195598f, -0.02137628f, 0.05336254f, 
    0.09969591f, 0.00606275f, 0.00215758f, -0.01515164f, 0.11806302f, 0.16123293f, 0.19416484f, 0.12274810f, 
    -0.07100298f, -0.03335379f, -0.12655516f, 0.00227836f, -0.03450596f, 0.09348781f, 0.05126825f, -0.03747757f, 
    0.17781195f, 0.13268308f, 0.13591300f, -0.11883862f, -0.03365567f, -0.00055387f, -0.00534733f, -0.14483841f, 
    0.10504176f, 0.05833060f, 0.06337632f, 0.08385940f, -0.11104473f, -0.05465315f, -0.13949430f, 0.18434916f, 
    -0.17843230f, 0.11614389f, -0.13501462f, -0.10942135f, 0.03505637f, -0.01829231f, 0.06932186f, 0.13484575f, 
    0.05154643f, -0.15240924f, 0.18738090f, 0.12643009f, 0.07708336f, -0.04581797f, -0.05608295f, -0.01334753f, 
    0.09927528f, -0.04212586f, -0.10784296f, -0.06488687f, 0.25019604f, 0.08065572f, 0.27680936f, -0.11924829f, 
    -0.06298769f, -0.11961859f, -0.05346748f, -0.00731459f, -0.04897161f, 0.07502668f, -0.05226349f, 0.04594807f, 
    -0.03396104f, 0.03431319f, -0.28573173f, 0.07623655f, 0.02012714f, 0.02732924f, 0.24496992f, -0.06183391f, 
    0.10337362f, 0.03071265f, 0.08021802f, 0.02029840f, -0.03945594f, 0.05057068f, 0.07118209f, -0.03111412f, 
    -0.02184173f, -0.00123949f, 0.06212996f, -0.08791923f, 0.02899012f, -0.04085498f, 0.05112301f, -0.02242400f, 
    0.22393113f, -0.00756021f, -0.07950854f, -0.06764451f, -0.04181980f, 0.03502345f, 0.04340465f, -0.02469918f, 
    0.13259000f, -0.00084848f, -0.04115641f, -0.02747134f, 0.32085055f, 0.15337396f, 0.00908379f, -0.04674117f, 
    -0.03522377f, -0.03745456f, 0.00553080f, 0.01206714f, 0.17252925f, 0.09908685f, -0.04345362f, -0.25758204f, 
    0.26997003f, 0.12760574f, -0.16887315f, -0.09624984f, -0.05599897f, -0.09320233f, 0.11693364f, -0.05532286f, 
    -0.07617413f, -0.13523416f, 0.07922176f, 0.18875553f, 0.03165507f, -0.41870579f, 0.14512980f, -0.27811125f, 
    0.19236837f, 0.05757463f, -0.09458975f, 0.12570748f, -0.04332376f, 0.03864296f, 0.06941435f, 0.02029151f, 
    0.08128960f, 0.00670928f, 0.13259457f, -0.03196349f, -0.03643776f, 0.12516388f, 0.00901981f, 0.01433495f, 
    0.01637634f, 0.07666691f, -0.01613137f, 0.01532337f, -0.10810272f, -0.06149500f, 0.21329953f, 0.17461704f, 
    -0.07376703f, 0.05395426f, -0.03061813f, 0.01679570f, -0.14133736f, 0.03931244f, 0.05329301f, -0.00537072f, 
    -0.03872344f, 0.00924420f, -0.12790927f, 0.05711889f, 0.04005154f, -0.03118741f, 0.17333758f, 0.00624002f, 
    -0.02428982f, -0.02815732f, 0.01127012f, -0.12681639f, 0.00334350f, 0.02276413f, 0.21349441f, 0.06421181f, 
    0.02780530f, 0.03801774f, -0.09305177f, -0.04940497f, 0.03572267f, -0.04544777f, 0.15765789f, 0.10879991f, 
    -0.01479763f, 0.11512890f, 0.26288119f, 0.21463038f, -0.01393198f, -0.06105205f, -0.02990828f, 0.02035098f, 
    -0.02149407f, -0.05703009f, -0.03540079f, 0.03539363f, -0.24491088f, 0.27210745f, -0.15333852f, 0.00772459f, 
    -0.06702875f, 0.15430215f, 0.05134048f, 0.05721177f, -0.06083180f, -0.11470798f, -0.17151415f, -0.05057241f, 
    -0.09946667f, -0.15651050f, 0.16327408f, 0.05799215f, -0.06601889f, 0.07149744f, -0.00828091f, -0.06316288f, 
    0.12145549f, 0.05129430f, -0.11365797f, 0.22938074f, -0.06015948f, 0.38559920f, -0.05916186f, -0.05821281f, 
    0.11457314f, 0.21356034f, 0.02235168f, -0.07519680f, -0.00771105f, 0.04724969f, -0.14835234f, -0.10703322f, 
    -0.01412866f, -0.09545998f, -0.21013948f, -0.12716618f, -0.01390697f, 0.05175478f, 0.03351786f, 0.07476421f, 
    0.05261746f, -0.09885789f, -0.08308384f, 0.11394903f, 0.14881666f, 0.00516889f, 0.12191533f, 0.12377188f, 
    -0.16993985f, 0.13193640f, -0.05951387f, 0.07156568f, 0.15130332f, 0.02516663f, -0.05115849f, -0.15355854f, 
    -0.24717136f, -0.01595773f, 0.18070929f, 0.06174264f, 0.19508234f, 0.06981864f, -0.02026228f, 0.08385812f, 
    0.02136083f, -0.02215471f, 0.03602296f, 0.06402842f, 0.05079870f, 0.00701664f, 0.04751556f, -0.11558425f, 
    0.04505323f, -0.00081997f, 0.01871310f, -0.03757348f, -0.03503928f, 0.02781134f, 0.06378362f, 0.08328214f, 
    -0.05127576f, -0.05603695f, 0.19221137f, -0.11101358f, -0.07780956f, 0.00171411f, 0.03951628f, -0.05731168f, 
    -0.10779570f, -0.03433752f, 0.04839783f, 0.07779621f, 0.08202501f, 0.07806291f, 0.05700973f, -0.03295309f, 
    0.00580275f, -0.01627115f, 0.01855955f, 0.18758780f, -0.04613242f, 0.03539563f, 0.03000852f, -0.04178876f, 
    -0.00027237f, -0.04361355f, 0.01634815f, -0.15828006f, 0.04475052f, -0.08649458f, -0.15326643f, -0.04473336f, 
    -0.14287865f, 0.13837549f, 0.13972354f, 0.10559814f, 0.08159925f, 0.26855281f, -0.04020400f, -0.01849960f, 
    -0.11629551f, -0.01491302f, -0.00364959f, 0.06215980f, -0.03948260f, 0.07497208f, 0.03919607f, 0.05613202f, 
    -0.05650419f, 0.16826774f, -0.07525800f, 0.03095522f, -0.07793485f, 0.04578598f, 0.06648526f, 0.03932736f, 
    0.04953525f, 0.01446131f, 0.01175192f, -0.04293905f, 0.04857835f, -0.09475315f, -0.08171621f, 0.22667338f, 
    -0.04494794f, 0.02679472f, 0.12816566f, 0.16419366f, -0.13170891f, -0.02636844f, -0.03971549f, 0.06487732f, 
    -0.04718836f, 0.05124968f, 0.38639468f, -0.20925753f, 0.10303034f, -0.03964018f, -0.19806756f, 0.04063326f, 
    -0.11844180f, -0.11623967f, -0.22780851f, -0.08199310f, -0.10805193f, 0.01566611f, -0.09857847f, -0.08546362f, 
    -0.00107997f, 0.09865908f, 0.23594876f, 0.19290560f, 0.11969831f, -0.12118858f, 0.13567509f, 0.27487895f, 
    -0.05409726f, -0.13141629f, -0.07968884f, -0.16372629f, -0.03583271f, 0.02965598f, 0.11273886f, -0.06868572f, 
    -0.05429334f, -0.03450871f, -0.05348220f, 0.16741189f, 0.25076446f, 0.05654303f, 0.36985698f, 0.20927101f, 
    -0.16905962f, -0.20191915f, -0.09204988f, 0.08688384f, 0.26130942f, 0.03860572f, -0.01316647f, -0.05364448f, 
    0.41045451f, 0.20413370f, -0.02681087f, 0.07749614f, -0.18392110f, -0.12523663f, -0.00190295f, -0.11185361f, 
    0.06683444f, 0.18934782f, -0.02165818f, -0.04037753f, 0.13574646f, -0.10254315f, 0.15430593f, 0.23021181f, 
    -0.03396825f, 0.10866573f, 0.04468796f, 0.25184861f, 0.11074354f, 0.16477713f, -0.03318391f, 0.27581495f, 
    0.03649850f, -0.20141219f, 0.05030007f, 0.02114683f, -0.02460707f, -0.21444204f, 0.15002984f, -0.00052289f, 
    0.11385600f, 0.34809759f, -0.06172764f, 0.17080931f, -0.19937450f, 0.25908384f, -0.02726350f, -0.20088698f, 
    -0.14925286f, -0.33726537f, 0.12055652f, 0.04325113f, 0.11289544f, 0.06741475f, -0.06428991f, -0.03604987f, 
    -0.09747005f, 0.00856126f, -0.08094355f, 0.05548702f, -0.07191394f, -0.00391505f, 0.09296803f, 0.02567458f, 
    -0.05438922f, -0.04530429f, -0.06106121f, -0.20747341f, 0.08943529f, 0.07550856f, -0.08395870f, 0.03242420f, 
    0.08817925f, 0.08126681f, -0.00781582f, -0.02817441f, -0.07225139f, 0.01523636f, -0.08391266f, 0.03114630f, 
    -0.04996456f, -0.14622840f, -0.16519144f, 0.06285311f, -0.01054544f, -0.12267572f, 0.08639538f, -0.05782812f, 
    0.03273509f, -0.03260037f, -0.04809373f, 0.04004594f, 0.03817030f, 0.04996063f, -0.24641885f, -0.08546632f, 
    0.10445604f, -0.02445193f, -0.04573383f, -0.23954271f, 0.06668302f, -0.20035803f, -0.03550128f, -0.11600138f, 
    -0.14661700f, 0.00879903f, -0.36521283f, 0.02434973f, -0.00121823f, -0.02620848f, 0.20847009f, -0.06193076f, 
    0.34690210f, 0.31612399f, 0.33439985f, 0.24354623f, -0.01239866f, -0.29743493f, 0.37562451f, -0.10819053f, 
    0.33898208f, -0.07997590f, 0.00155561f, -0.08006384f, -0.07681642f, -0.08488682f, -0.14283618f, -0.09686390f, 
    0.14083305f, -0.11761449f, 0.19805647f, 0.12289128f, -0.00102794f, -0.00208895f, 0.08226444f, 0.04631395f, 
    0.19233225f, 0.27345043f, 0.10014141f, 0.11092143f, 0.04591619f, -0.04163437f, 0.32055101f, -0.20767117f, 
    0.09834898f, 0.09861010f, -0.02307985f, -0.16222517f, 0.04868276f, 0.02602172f, -0.23288462f, -0.20151016f, 
    0.11896742f, 0.02650468f, 0.01829577f, -0.28284931f, -0.08214187f, -0.01259236f, -0.16052184f, 0.08991007f, 
    0.02265946f, -0.19185740f, -0.21453112f, -0.19399065f, -0.12477750f, 0.11654811f, -0.04944143f, 0.08843211f, 
    0.04363631f, -0.00844050f, 0.21672279f, 0.03742868f, 0.09906425f, -0.00600953f, 0.19142039f, 0.21041991f, 
    0.01418969f, -0.13627625f, 0.07216002f, -0.03134792f, -0.15993822f, 0.03157015f, 0.05552127f, 0.01128785f, 
    0.10089062f, -0.12465417f, -0.02107872f, 0.26465732f, 0.21570981f, 0.02730424f, 0.33682388f, 0.21101715f, 
    -0.08516388f, -0.04419779f, 0.03076089f, -0.06746541f, 0.01575904f, 0.00449020f, -0.01457085f, 0.08347241f, 
    0.13094084f, 0.16270857f, 0.18877466f, -0.04170240f, -0.18672375f, -0.01004103f, 0.00480280f, -0.15076055f, 
    0.06606914f, 0.13523214f, 0.02470035f, 0.01543116f, 0.20374578f, -0.07362843f, 0.17361718f, 0.18232262f, 
    0.06878212f, -0.10109780f, 0.05306498f, 0.04853002f, 0.04346734f, 0.03935548f, -0.08822498f, 0.23531070f, 
    0.25451595f, -0.24891430f, 0.11329146f, 0.06944968f, -0.09693155f, -0.12703712f, 0.05328367f, -0.05316804f, 
    0.03023876f, 0.18748106f, -0.01367272f, 0.27926117f, -0.07490957f, -0.05998996f, 0.36954868f, -0.24323504f, 
    -0.00336070f, -0.18515819f, 0.13757464f, -0.05223693f, 0.15345772f, 0.12437389f, 0.06985249f, 0.02369309f, 
    -0.20862734f, -0.02893475f, 0.06470473f, 0.03341994f, -0.12900841f, 0.04615865f, 0.01644668f, -0.04345087f, 
    0.01783646f, 0.00588094f, -0.08847839f, -0.13237230f, 0.15639156f, 0.13847190f, -0.05253356f, 0.10300900f, 
    0.00368488f, 0.03821477f, 0.01529175f, 0.08412639f, 0.01835979f, -0.05739805f, -0.14919740f, -0.04445269f, 
    -0.28390393f, -0.17573693f, -0.00312501f, 0.24044418f, 0.17975971f, 0.06140099f, 0.10910780f, -0.18299800f, 
    -0.01389177f, -0.18990786f, -0.03942506f, 0.05765027f, -0.13917437f, 0.02295499f, -0.20865060f, -0.02318013f, 
    0.10132228f, 0.04317716f, -0.05091839f, 0.03068796f, -0.09954789f, -0.07074337f, -0.23426805f, 0.00573342f, 
    -0.13985723f, -0.04908365f, -0.00026951f, 0.09536617f, 0.00988102f, 0.10487294f, 0.07917763f, 0.04222187f, 
    0.20856269f, 0.13542598f, 0.16064386f, 0.24349295f, 0.24496588f, -0.16611412f, 0.21057113f, 0.01879518f, 
    0.31931400f, -0.11961202f, -0.09588810f, -0.16060472f, -0.13459548f, -0.07418218f, -0.14255239f, -0.08980882f, 
    0.24252325f, -0.32230374f, 0.21300817f, 0.24765532f, 0.01194270f, 0.03830181f, 0.02535198f, -0.01496132f, 
    0.09004384f, 0.02101642f, 0.17129578f, 0.12667952f, 0.30311501f, -0.06918857f, -0.03995373f, -0.31158569f, 
    0.10814720f, 0.04510731f, -0.05259648f, -0.07799913f, -0.00807362f, -0.09495341f, -0.29588327f, -0.10690243f, 
    -0.00678896f, -0.20523937f, -0.09153271f, -0.00043011f, 0.10715152f, -0.22716492f, 0.01711100f, 0.03582581f, 
    0.05298230f, -0.21265742f, -0.13066401f, -0.15104616f, -0.12556715f, 0.14073382f, 0.15913294f, 0.17490703f, 
    0.01738587f, 0.24701017f, 0.06745720f, -0.03231871f, 0.05395431f, 0.10439584f, 0.16966616f, 0.27080989f, 
    -0.01036718f, 0.13062604f, 0.31681582f, 0.06680453f, 0.10008381f, 0.18825641f, -0.04682347f, -0.05689240f, 
    -0.10271046f, -0.07845875f, -0.08339816f, -0.05442154f, -0.12986596f, 0.19789340f, 0.22025014f, 0.16680667f, 
    0.05673368f, 0.11832393f, 0.04932003f, -0.04439963f, 0.04482625f, -0.05776054f, -0.17761047f, 0.05189793f, 
    0.15696487f, 0.10459778f, 0.04961079f, -0.09938824f, -0.19358756f, 0.03465542f, 0.05731931f, 0.01500317f, 
    -0.00896704f, -0.00291485f, 0.15967132f, 0.22600091f, 0.08797140f, 0.15797484f, -0.01264155f, 0.22835194f, 
    0.05498845f, 0.17363529f, 0.01613389f, -0.01431982f, 0.09700161f, 0.00522314f, 0.18671846f, 0.07700843f, 
    0.10605419f, -0.09673636f, -0.07788610f, 0.04216257f, -0.05935727f, -0.02344022f, 0.01190345f, 0.04887540f, 
    -0.02343065f, -0.02335211f, 0.15969460f, 0.10522398f, 0.47783238f, 0.39253607f, 0.31951925f, 0.18677801f, 
    -0.21796271f, 0.11516881f, 0.06826873f, -0.10706055f, 0.06662232f, 0.03178211f, 0.01710384f, 0.05293876f, 
    -0.24706364f, -0.02663597f, 0.32402477f, -0.01708530f, -0.00267824f, 0.21380879f, -0.07663102f, -0.02645359f, 
    0.01268382f, -0.02545587f, -0.01408212f, 0.13893349f, 0.06886479f, -0.21581259f, 0.15124424f, -0.28915599f, 
    0.17887866f, 0.02298654f, 0.07220820f, -0.09913516f, -0.07157061f, -0.07731052f, 0.02834962f, 0.05368667f, 
    -0.10981045f, -0.16510643f, -0.16821910f, -0.31813309f, -0.01912991f, -0.15602928f, -0.25050986f, -0.08752704f, 
    -0.14959989f, -0.07123124f, -0.07486320f, -0.01095477f, -0.04579676f, -0.02293635f, -0.30153978f, -0.03057915f, 
    -0.02072369f, -0.09096447f, -0.08924383f, -0.00240242f, -0.28024122f, 0.08369443f, -0.15431686f, 0.02503650f, 
    -0.12136335f, -0.28794008f, 0.03014708f, 0.03138389f, 0.04415349f, -0.12233905f, -0.10275320f, -0.07847719f, 
    0.03171548f, 0.18999133f, 0.21500023f, 0.21139002f, -0.18038207f, -0.10962534f, -0.27930692f, -0.09123107f, 
    -0.03105206f, -0.06713989f, 0.15406859f, -0.08746366f, -0.02726336f, -0.02501936f, -0.04646793f, 0.17803930f, 
    0.15592702f, 0.10709047f, 0.02918528f, -0.01019741f, 0.03107832f, -0.10283634f, 0.08075711f, -0.00971329f, 
    0.03178376f, -0.03779314f, 0.14186232f, -0.04423404f, 0.21712266f, -0.33595544f, -0.40123454f, -0.18260501f, 
    -0.01891132f, 0.02498385f, 0.03867682f, 0.09926205f, 0.06497716f, -0.12820800f, -0.19380482f, 0.07445361f, 
    0.06438026f, 0.01459740f, 0.03795747f, 0.11210608f, -0.07204887f, 0.12154508f, -0.00487426f, -0.00758308f, 
    -0.09971896f, -0.02915564f, -0.02915581f, -0.09910016f, -0.14689076f, 0.04663623f, 0.03425999f, 0.05179977f, 
    -0.07092328f, -0.00627388f, 0.04270971f, 0.00957216f, 0.09579451f, 0.04054222f, -0.05804289f, 0.01506930f, 
    0.02759191f, 0.03680549f, -0.19680737f, -0.03334302f, -0.22445729f, -0.04514755f, 0.12031046f, 0.12638894f, 
    0.03508256f, 0.01036679f, 0.03267518f, -0.02298028f, 0.46629372f, 0.02863192f, -0.03556635f, 0.11161886f, 
    0.00437788f, -0.14302950f, -0.00324800f, 0.01346375f, 0.02736044f, -0.05290255f, -0.07546920f, -0.00627906f, 
    -0.04901716f, -0.11280966f, 0.17862305f, 0.10756513f, -0.01797226f, 0.02697401f, 0.02811669f, 0.03896391f, 
    -0.01124875f, -0.05373776f, -0.10243946f, 0.16632518f, -0.01053558f, 0.23020512f, -0.01097200f, -0.03197982f, 
    -0.06548337f, -0.02036024f, -0.09248216f, -0.01568401f, 0.09458946f, 0.13807878f, -0.01555121f, 0.09917808f, 
    -0.02683392f, -0.28302127f, 0.21468426f, 0.05432649f, -0.00436428f, -0.06687758f, 0.01686528f, 0.04104600f, 
    0.29437625f, -0.12618633f, -0.04548462f, 0.10012137f, -0.13703421f, -0.09898765f, 0.09682444f, -0.12793769f, 
    -0.09129827f, -0.10311584f, -0.13886935f, 0.20740801f, -0.02431810f, -0.08824316f, -0.01709442f, 0.03086376f, 
    -0.08897901f, 0.11038188f, -0.28940174f, -0.11956430f, 0.21108408f, -0.02545620f, 0.12618431f, -0.04303144f, 
    -0.00673919f, 0.06069756f, -0.11309773f, 0.04084062f, -0.03126782f, 0.15074869f, -0.03089432f, -0.00106352f, 
    -0.07036682f, -0.00075849f, -0.02759693f, 0.05255902f, 0.07486229f, 0.12687004f, -0.07319380f, 0.04487355f, 
    -0.00049441f, -0.05438744f, -0.08434927f, 0.04230182f, -0.05295474f, -0.04238014f, 0.02381187f, 0.04142982f, 
    0.10788760f, 0.10847719f, 0.06210484f, -0.03110117f, 0.07047912f, 0.00662501f, 0.15159240f, -0.11719144f, 
    -0.06422336f, 0.10256111f, -0.02942126f, 0.00069577f, 0.07908081f, 0.18721618f, -0.08251457f, -0.24354158f, 
    -0.01779597f, 0.21987164f, -0.03402660f, -0.10220771f, -0.04480248f, 0.07043435f, -0.01835670f, -0.09919212f, 
    -0.00310987f, -0.07004953f, 0.08774180f, 0.23604347f, 0.15413232f, -0.23607816f, 0.31889090f, -0.18695757f, 
    -0.11052871f, 0.12150652f, -0.06256402f, 0.09325796f, 0.04013351f, -0.01796385f, 0.08373324f, -0.12765352f, 
    0.20044214f, -0.03349278f, 0.13047712f, -0.04555914f, 0.09998534f, -0.02599960f, -0.10285559f, -0.01287316f, 
    0.04876805f, 0.05556439f, -0.04952526f, 0.11988799f, 0.09480598f, 0.33575493f, 0.40919954f, 0.19084914f, 
    -0.12071692f, -0.09123747f, 0.05066994f, 0.12293092f, -0.02530709f, 0.00656452f, 0.10622545f, -0.13480048f, 
    -0.00202852f, 0.03825339f, -0.03621242f, -0.06249680f, -0.05878979f, 0.00763466f, -0.04371809f, -0.05680659f, 
    0.03596350f, -0.01036089f, -0.07005362f, -0.03342795f, 0.03596857f, 0.03359045f, 0.06308113f, -0.02930440f, 
    -0.05894325f, -0.01584517f, -0.00831702f, -0.07697643f, 0.06077286f, -0.05373929f, 0.01574508f, 0.01043980f, 
    -0.06265584f, -0.02932132f, 0.01693418f, -0.03367794f, 0.04354833f, 0.05690419f, -0.04614352f, 0.02774364f, 
    0.05413521f, -0.05143742f, -0.03252381f, -0.06526507f, 0.05640788f, 0.00404768f, -0.00823964f, -0.02772355f, 
    -0.04480567f, 0.00969009f, -0.02609757f, -0.02028323f, -0.01693076f, -0.05802906f, -0.02500813f, -0.04074682f, 
    0.01091802f, -0.07364055f, -0.00271661f, -0.07179487f, -0.05750893f, -0.06615483f, 0.00666160f, 0.03260838f, 
    -0.07496331f, 0.02852530f, -0.07564752f, 0.04798732f, 0.03732164f, 0.00346769f, 0.01136661f, 0.01876810f, 
    -0.00552333f, 0.04054482f, 0.03905511f, -0.02786692f, -0.03677609f, -0.02182359f, -0.06033861f, -0.06935457f, 
    -0.02136611f, -0.06806270f, 0.03717851f, 0.02822799f, 0.02583331f, -0.01881968f, 0.02811851f, 0.03709738f, 
    0.01419986f, -0.03460556f, -0.02120430f, 0.03712826f, -0.00618631f, -0.07359180f, -0.04930457f, 0.04115092f, 
    0.01212507f, -0.07347871f, 0.05665212f, -0.00786972f, 0.03192048f, -0.05126341f, 0.06046431f, -0.02709798f, 
    0.00305770f, -0.04673268f, 0.05783647f, -0.07731602f, -0.04906461f, -0.02857000f, -0.05156133f, -0.07954636f, 
    -0.03893241f, -0.03507938f, 0.04320441f, -0.01333881f, -0.02523610f, -0.07540510f, 0.01023931f, 0.04957613f, 
    -0.00468134f, 0.00023804f, -0.01311410f, 0.00236416f, 0.02332985f, 0.01846030f, -0.01720289f, 0.00629957f, 
    0.02613505f, 0.06381819f, -0.01551155f, 0.04569180f, 0.01809036f, 0.00093502f, -0.07442752f, -0.04934022f, 
    -0.04604846f, 0.01146163f, -0.07767088f, -0.01051483f, 0.05556129f, -0.03325893f, -0.00060806f, 0.02646095f, 
    0.03614505f, -0.05701649f, -0.06705926f, -0.00110981f, -0.05964750f, 0.03376955f, 0.02161987f, 0.01532889f, 
    -0.00207329f, -0.07595444f, -0.00739755f, -0.06212319f, -0.00997681f, 0.03082567f, 0.03078944f, 0.01829693f, 
    -0.04701428f, -0.03092318f, 0.00148582f, 0.05778544f, -0.04009715f, 0.01111155f, -0.00489585f, -0.04636378f, 
    0.03353770f, -0.01817666f, -0.02093592f, 0.04388519f, -0.07522000f, 0.01833069f, -0.00585226f, -0.04539426f, 
    -0.07403225f, 0.01209851f, -0.02581881f, 0.05545846f, -0.07778715f, -0.03157122f, -0.01608177f, -0.05358702f, 
    -0.05911509f, 0.03399043f, -0.04980240f, -0.06670727f, -0.01449955f, 0.05587489f, -0.00911461f, -0.00655755f, 
    -0.02903654f, 0.02235416f, 0.00137133f, 0.01005866f, 0.04287460f, -0.03619594f, -0.07157660f, -0.07709812f, 
    0.04617371f, -0.08487044f, 0.08207908f, 0.03380732f, -0.01572589f, 0.00400834f, 0.20809954f, 0.06226215f, 
    -0.00715299f, -0.00947648f, 0.08618148f, 0.00686656f, -0.17035390f, 0.16808186f, 0.01940894f, 0.10300623f, 
    0.01582003f, -0.06094435f, -0.06727731f, -0.02375282f, -0.11036347f, -0.05970084f, -0.14126720f, -0.27882105f, 
    -0.16088241f, 0.09913124f, 0.20394605f, 0.06180267f, 0.23589855f, 0.00744887f, 0.10029058f, 0.10387938f, 
    -0.06802516f, 0.01613360f, -0.06409170f, -0.11382505f, -0.18113758f, -0.13891657f, -0.12691422f, -0.09614243f, 
    -0.09386658f, 0.05536642f, 0.04107878f, 0.11629006f, 0.00730482f, -0.11005323f, -0.00777513f, 0.07205947f, 
    -0.08620092f, -0.08530642f, -0.13956778f, -0.10683995f, 0.02240605f, 0.09339734f, -0.03521558f, 0.07885133f, 
    0.09709630f, -0.10175537f, -0.06802934f, -0.07909915f, 0.14255592f, -0.09969047f, -0.05982470f, -0.09474211f, 
    0.12618048f, -0.00637016f, 0.14365982f, 0.13459103f, 0.10307915f, -0.04043695f, 0.00926918f, -0.15573041f, 
    0.24631025f, 0.02216453f, 0.15584269f, -0.14988616f, -0.13248235f, 0.02443666f, -0.16456510f, -0.10770934f, 
    -0.01855643f, -0.02504993f, 0.04270181f, -0.14849737f, 0.16945191f, -0.33282644f, 0.03339235f, -0.17440301f, 
    -0.06520975f, 0.00851623f, 0.04701114f, 0.00349645f, 0.16717599f, 0.07403877f, 0.02090933f, 0.03981060f, 
    -0.05208432f, 0.02716656f, 0.22700001f, 0.02958529f, 0.12852344f, -0.13501297f, 0.00316557f, -0.00250713f, 
    0.15637955f, 0.08884565f, 0.10426255f, 0.14236446f, 0.11820503f, 0.04811091f, 0.22408877f, -0.02939920f, 
    0.09728786f, 0.13132851f, 0.07176325f, -0.01964800f, 0.14657025f, 0.09541297f, 0.07881430f, 0.13307811f, 
    -0.14909975f, 0.12413369f, 0.12245919f, 0.04081016f, -0.02382373f, -0.12270980f, -0.16367213f, -0.05856324f, 
    0.11607756f, -0.05435716f, -0.01534607f, 0.02274800f, -0.07702862f, 0.13777407f, 0.08763842f, 0.08386549f, 
    -0.03184133f, -0.01872885f, -0.10630313f, -0.07560214f, 0.12858848f, 0.15066458f, 0.10614689f, 0.17388339f, 
    -0.12913230f, -0.25922754f, -0.02965805f, -0.02963498f, 0.10724915f, -0.00718742f, -0.11394954f, 0.11761875f, 
    -0.01861731f, -0.03219786f, -0.09070300f, -0.37756959f, 0.02275214f, 0.06029071f, -0.06449915f, -0.03751535f, 
    -0.07652696f, -0.03367557f, 0.09942202f, -0.13294090f, -0.01482417f, -0.05422285f, -0.04724603f, 0.16063882f, 
    0.22069283f, -0.02684501f, -0.06944519f, -0.01390111f, -0.00077285f, 0.02364932f, 0.05563444f, -0.04916050f, 
    -0.00987435f, -0.00826099f, 0.26766160f, -0.13603458f, -0.04537510f, -0.12230826f, -0.15253964f, -0.16387942f, 
    0.03760216f, 0.17480884f, 0.12172915f, 0.16252667f, 0.05179717f, -0.05795537f, -0.01945795f, 0.10921820f, 
    0.05676735f, -0.07029445f, 0.02737159f, 0.03721273f, -0.04660314f, -0.03319672f, 0.01034805f, -0.05090034f, 
    0.04742149f, 0.01768375f, 0.00783935f, -0.00472163f, 0.04987416f, -0.07082132f, -0.06677646f, 0.05642056f, 
    0.02178694f, -0.03639843f, -0.04643087f, 0.04553816f, -0.03033191f, -0.03036390f, -0.02048894f, -0.00294578f, 
    0.03627725f, 0.00818030f, 0.01050405f, 0.05000756f, -0.01577845f, 0.01661051f, -0.04269689f, -0.05967374f, 
    0.00256873f, 0.06120051f, 0.06003767f, 0.05031217f, 0.04826956f, -0.02056687f, -0.06936961f, -0.06941962f, 
    -0.00384424f, -0.00237045f, -0.01554094f, -0.05867752f, 0.05979000f, -0.00261170f, 0.02630300f, -0.01720515f, 
    0.02373885f, 0.02378204f, 0.04078427f, 0.01723843f, -0.05747059f, -0.05178912f, 0.02106293f, -0.00914190f, 
    -0.04787087f, -0.04980260f, -0.01298120f, -0.01932665f, -0.05445113f, -0.00824623f, -0.06663368f, -0.06921026f, 
    -0.06527324f, -0.04863748f, 0.03558331f, -0.06472073f, -0.03522093f, -0.05342686f, 0.04533242f, -0.03396922f, 
    -0.06955366f, -0.00244388f, -0.06774375f, 0.04871262f, -0.00183314f, 0.05044555f, -0.02689081f, -0.01761015f, 
    0.06095105f, -0.03780277f, 0.01139423f, -0.04629600f, -0.06251816f, -0.02622604f, -0.03596778f, -0.05400027f, 
    0.05921244f, 0.03952004f, 0.00609551f, -0.00449971f, -0.06425165f, -0.05520881f, 0.03640833f, -0.05233846f, 
    -0.03457448f, 0.06116279f, 0.01104978f, -0.05609270f, 0.02439946f, 0.05510281f, -0.04724846f, -0.03924953f, 
    -0.01477733f, -0.07548573f, -0.05285626f, -0.06083085f, 0.01523929f, -0.06535888f, -0.01811474f, 0.05092749f, 
    0.06113005f, -0.01743615f, -0.02892935f, -0.00229075f, 0.04851810f, 0.05377841f, -0.05948722f, -0.00297194f, 
    0.00623235f, -0.03634134f, -0.02730365f, 0.04684654f, -0.05478150f, 0.03724327f, -0.02961004f, -0.06075766f, 
    0.02086452f, 0.00819315f, -0.01838113f, -0.03118023f, -0.02834125f, -0.02899787f, -0.01716013f, -0.00436751f, 
    0.05480099f, -0.01564229f, -0.05708923f, -0.00257116f, 0.02642902f, -0.05388561f, 0.01447006f, -0.03025180f, 
    -0.07693922f, -0.04950522f, 0.03230720f, -0.05441353f, -0.04956001f, 0.06267387f, 0.00199554f, -0.01295960f, 
    0.05059230f, -0.03779748f, 0.01290257f, -0.03538197f, 0.06059314f, -0.07682274f, -0.03001519f, -0.02708889f, 
    -0.00730603f, -0.06505054f, -0.00405496f, -0.02365047f, -0.01826949f, -0.01054353f, -0.02804388f, -0.04292085f, 
    -0.05923809f, -0.05421854f, -0.04804947f, 0.07013391f, -0.07008372f, -0.01244315f, 0.03451090f, -0.06178741f, 
    -0.06646354f, -0.02107443f, 0.02373826f, -0.03637149f, 0.03250562f, 0.01508343f, -0.00379703f, -0.05642542f, 
    -0.03600476f, 0.04734296f, 0.00625267f, -0.02049441f, 0.04880164f, -0.07282501f, 0.01976780f, 0.02144143f, 
    0.02921026f, 0.11578385f, -0.09872662f, -0.09759180f, -0.05238654f, 0.01967409f, 0.13161029f, 0.22225481f, 
    0.04140367f, -0.04622972f, 0.14008331f, -0.13675991f, -0.12771757f, 0.05625491f, 0.05404472f, -0.00862202f, 
    0.01486121f, 0.01291006f, -0.05561119f, -0.06610571f, 0.05009731f, -0.17664926f, -0.06989308f, -0.22770552f, 
    -0.19337350f, 0.03480100f, -0.03144577f, 0.04944897f, 0.03332021f, 0.06198836f, 0.23874943f, 0.03853880f, 
    -0.12928697f, -0.04261279f, -0.03189292f, 0.01419812f, -0.16521490f, 0.22043008f, 0.11988661f, 0.06804499f, 
    -0.28365809f, -0.05687598f, -0.09690960f, 0.29903018f, 0.14134227f, 0.03793008f, -0.04506670f, 0.06257860f, 
    0.08623751f, 0.11385126f, -0.03845443f, 0.03307647f, 0.01010772f, 0.10875710f, 0.02091768f, -0.05728344f, 
    0.00628199f, -0.04555788f, -0.10626477f, 0.07606156f, -0.06273987f, 0.09925084f, -0.00479306f, 0.04501561f, 
    -0.05010860f, 0.09929072f, -0.06545225f, 0.13606195f, -0.05447743f, 0.09895464f, 0.04579094f, -0.07470958f, 
    0.26828113f, -0.41275868f, 0.09693945f, -0.07409717f, -0.10656916f, -0.17376925f, -0.23708145f, -0.05718107f, 
    0.05428017f, -0.08891384f, -0.18995900f, -0.00405756f, 0.07938747f, -0.10014952f, 0.04431320f, -0.15381987f, 
    -0.32872215f, -0.12418156f, -0.26301685f, 0.11898522f, 0.10410742f, 0.03816753f, -0.04565279f, 0.06959051f, 
    -0.05617852f, 0.09032787f, -0.00451623f, 0.21280611f, 0.15536074f, 0.16116181f, 0.09663306f, 0.01759779f, 
    0.06501698f, 0.09435201f, 0.04863594f, 0.12347284f, 0.21072474f, 0.18457286f, 0.04248464f, 0.01648167f, 
    0.03224337f, 0.06442297f, 0.09666584f, 0.04489760f, 0.07398389f, 0.05266371f, -0.04467615f, 0.10709075f, 
    -0.46108654f, -0.13308071f, 0.11599898f, 0.03948233f, -0.16216397f, -0.16551194f, -0.29478142f, -0.25255296f, 
    0.02453189f, -0.04673719f, -0.07422571f, 0.02272127f, -0.16286407f, -0.04704979f, 0.08156873f, -0.05337190f, 
    -0.14182785f, -0.09328381f, 0.01190587f, 0.08388116f, 0.14705947f, 0.24722826f, 0.03214062f, 0.12539908f, 
    -0.06088240f, -0.09966220f, -0.18884552f, -0.12600605f, 0.13305041f, -0.09047700f, -0.09288507f, -0.10378246f, 
    -0.05935980f, -0.15785879f, 0.13691860f, -0.10597941f, 0.10079438f, -0.10306699f, 0.16606601f, -0.18571045f, 
    0.04684445f, -0.07973152f, -0.08826249f, 0.00391838f, 0.06581565f, 0.06260308f, -0.01801472f, 0.12811428f, 
    0.35162628f, 0.01718673f, 0.16818507f, 0.01604850f, -0.04509045f, 0.09092419f, -0.14214252f, 0.01746205f, 
    -0.04235610f, 0.00869742f, 0.08043005f, -0.13845444f, -0.05997563f, 0.20596914f, 0.34996924f, 0.01473916f, 
    0.06732246f, 0.15507121f, 0.17956606f, -0.05022639f, 0.03975867f, 0.03758776f, 0.13398118f, 0.17918302f, 
    -0.07751656f, -0.03644665f, 0.07768182f, 0.02438101f, 0.04088870f, -0.02428802f, -0.12875096f, 0.21943632f, 
    -0.01040062f, -0.00493141f, -0.01552210f, -0.05353379f, -0.09248897f, 0.17870085f, 0.05211037f, -0.12401049f, 
    -0.08751104f, -0.04390932f, -0.04699543f, 0.05277974f, 0.02759492f, -0.01020871f, 0.00150710f, 0.01048232f, 
    -0.10803493f, 0.21395484f, 0.04012387f, -0.08966082f, -0.03758378f, 0.08036806f, 0.14538211f, 0.10635193f, 
    0.05886258f, -0.06781937f, -0.00400077f, -0.11764792f, -0.27387524f, 0.25316608f, 0.24600910f, 0.17576724f, 
    -0.12174784f, -0.00329045f, -0.14290665f, 0.05137170f, 0.05943403f, -0.01275600f, -0.03646107f, -0.12570161f, 
    0.30443823f, 0.09075969f, 0.04957438f, -0.30173054f, -0.06006682f, 0.02513243f, 0.01683938f, 0.05950117f, 
    0.05226108f, -0.00825544f, 0.04640029f, -0.00782119f, -0.41962948f, 0.01994200f, 0.18688454f, 0.24300744f, 
    -0.15505455f, -0.09895997f, -0.12354174f, 0.09129827f, 0.09094844f, -0.05598871f, 0.14228949f, -0.00674311f, 
    -0.00361938f, -0.30757853f, 0.18608864f, 0.18594445f, -0.04654931f, 0.04229929f, -0.02621756f, 0.05779866f, 
    0.02460990f, -0.07984668f, -0.03802148f, 0.00488354f, 0.38756546f, -0.05638114f, 0.05545557f, -0.13772339f, 
    -0.12130730f, -0.14089437f, -0.13533565f, 0.01811094f, 0.14877154f, 0.01850305f, 0.05743181f, -0.01367988f, 
    0.06062360f, 0.07036313f, -0.15546826f, 0.12211545f, 0.12028179f, 0.07715641f, 0.12625854f, -0.07390864f, 
    -0.03223417f, 0.11129354f, 0.06295801f, 0.03585943f, 0.09267089f, 0.05363637f, -0.03790710f, -0.19767447f, 
    0.12366683f, 0.04823088f, -0.04037454f, -0.01562987f, 0.13882039f, 0.01072601f, 0.03070510f, -0.04468656f, 
    0.07254862f, -0.07151036f, -0.12710200f, 0.07287586f, -0.02977932f, 0.05797357f, 0.08500800f, -0.04636618f, 
    0.03514376f, -0.02989834f, -0.00277321f, 0.01259888f, 0.16504578f, -0.09996473f, -0.06466170f, 0.08380846f, 
    0.05152600f, 0.04873388f, -0.01538810f, -0.07721286f, 0.02452148f, 0.01552022f, -0.05461400f, 0.01221850f, 
    0.09321079f, -0.00137419f, -0.10585016f, -0.13190265f, 0.09361372f, 0.05323975f, 0.05448997f, 0.01649006f, 
    -0.06697559f, -0.08438721f, 0.11047313f, 0.10104986f, 0.19663499f, -0.34069324f, 0.03834971f, -0.16404885f, 
    0.05176311f, 0.09247128f, -0.05010492f, 0.06015597f, -0.02635881f, 0.04087364f, -0.07281622f, 0.00510291f, 
    0.10749507f, -0.18993852f, 0.11058744f, 0.02592390f, -0.04425639f, 0.11595211f, 0.07324560f, 0.08900621f, 
    -0.06617800f, 0.05531633f, 0.05450252f, -0.06387946f, 0.00114775f, 0.05399014f, 0.20490800f, -0.02216905f, 
    -0.10948925f, -0.10088561f, 0.10212802f, -0.04428486f, 0.05548313f, 0.02059749f, 0.00030489f, 0.04095745f, 
    -0.04509209f, -0.02935916f, -0.28367352f, 0.04195349f, 0.06184777f, 0.07987549f, 0.08132056f, 0.11416287f, 
    -0.05622159f, -0.27072382f, -0.16462763f, -0.17257434f, -0.01247893f, 0.16489069f, 0.12477509f, 0.10313747f, 
    -0.08395298f, 0.16477643f, -0.05866067f, -0.01834255f, 0.05299093f, 0.13967161f, 0.03731344f, 0.31825590f, 
    0.06279509f, 0.12052150f, 0.03127177f, 0.05537343f, -0.19842306f, 0.07038158f, -0.06586435f, 0.01953180f, 
    -0.13437440f, -0.09315152f, 0.02095685f, -0.03064048f, 0.10377097f, 0.24871553f, 0.10935165f, 0.18685657f, 
    0.16596171f, -0.01694608f, -0.05756947f, -0.09530649f, -0.11222637f, 0.13297030f, -0.07525078f, -0.01888445f, 
    -0.15693747f, -0.17701213f, 0.22776428f, -0.02516353f, -0.07176524f, -0.03960621f, 0.01077520f, -0.11655469f, 
    0.08261279f, 0.25960305f, -0.03638329f, 0.13810216f, 0.04243883f, 0.37587467f, 0.14295720f, 0.00723424f, 
    0.01837755f, 0.14500561f, -0.00484665f, -0.10601906f, 0.12062714f, 0.06779437f, 0.09989163f, 0.01956726f, 
    -0.03957698f, -0.11785780f, 0.04145126f, 0.25999540f, -0.12031106f, 0.13508373f, -0.01073269f, 0.08753692f, 
    0.15903006f, 0.04615256f, 0.05614234f, 0.12252317f, 0.10233745f, 0.11962385f, 0.08900069f, 0.25469759f, 
    -0.20302850f, 0.01798691f, -0.02667384f, -0.09801206f, -0.00034113f, 0.01690025f, -0.08621689f, 0.04938117f, 
    -0.06028652f, 0.00978586f, 0.28828549f, 0.03903089f, 0.17222461f, 0.07829093f, -0.10717740f, -0.17869298f, 
    -0.05662868f, 0.03691935f, -0.22669308f, -0.13284308f, 0.03558049f, -0.11955301f, 0.06564794f, -0.28470585f, 
    -0.02303898f, -0.09864152f, 0.04954881f, 0.02607804f, -0.01008902f, -0.22069807f, -0.07349795f, 0.02698045f, 
    0.05442394f, -0.00616812f, -0.05979147f, -0.06824489f, 0.01025616f, 0.01210236f, 0.13395743f, 0.06234619f, 
    -0.02352580f, 0.15469560f, 0.13721073f, -0.09114718f, 0.15650390f, -0.10786133f, -0.12603153f, -0.13582642f, 
    -0.04037852f, 0.07412311f, 0.08621398f, 0.09247954f, -0.03116954f, -0.04093001f, -0.07858305f, -0.21710198f, 
    -0.07573799f, 0.10361295f, 0.06186230f, -0.11159373f, -0.11038987f, 0.00160797f, -0.19612139f, -0.22206101f, 
    -0.04489864f, 0.20945460f, 0.03650164f, 0.34605113f, 0.21923107f, 0.10455083f, -0.05129137f, -0.06396204f, 
    -0.07044310f, 0.09992947f, -0.06597039f, 0.13119651f, -0.27121145f, -0.02132530f, 0.04854914f, -0.03862410f, 
    -0.11398640f, 0.05347714f, -0.08360344f, -0.05426081f, 0.14866173f, -0.16404770f, 0.09014867f, 0.16970402f, 
    0.12834978f, -0.09702352f, -0.18813837f, 0.12117157f, 0.24419050f, 0.16545434f, -0.03425223f, 0.09981192f, 
    -0.07872640f, 0.03109215f, -0.07894939f, 0.09172548f, -0.04569064f, -0.10263682f, -0.10772166f, -0.12851976f, 
    0.04618188f, -0.06353456f, -0.02147945f, -0.00888254f, 0.01338725f, -0.01740418f, 0.04987882f, 0.03704626f, 
    -0.00157083f, 0.00912242f, 0.01331908f, 0.05807777f, 0.04582214f, 0.05600031f, -0.04815549f, 0.06367464f, 
    -0.07100096f, -0.04301517f, -0.07036443f, 0.03897870f, -0.03042045f, -0.01857582f, -0.03977715f, 0.04538408f, 
    -0.07633700f, 0.00587554f, 0.00115205f, 0.06058884f, 0.02799245f, -0.06245985f, -0.07002264f, 0.05269735f, 
    0.04864002f, -0.06056302f, 0.00931223f, -0.04457046f, -0.01870199f, -0.01356298f, -0.04907351f, 0.06151291f, 
    0.01528702f, -0.01793550f, -0.00395837f, -0.01843850f, -0.07232128f, 0.05393527f, 0.02175572f, -0.06575443f, 
    0.03694158f, -0.03820716f, -0.06113962f, -0.02984148f, -0.02265974f, -0.00180191f, -0.03095839f, -0.00414275f, 
    -0.07107787f, 0.04794884f, 0.04910530f, 0.00483175f, -0.01557165f, 0.05325008f, -0.02429184f, -0.00698690f, 
    0.06148707f, 0.01806513f, 0.06478165f, -0.05068682f, -0.06733392f, 0.06373621f, 0.05010848f, -0.07686393f, 
    0.05284880f, -0.00304855f, -0.07379820f, 0.06082274f, -0.07705952f, 0.03603530f, -0.01654077f, -0.05796864f, 
    0.05219699f, -0.07141815f, -0.03674733f, -0.00163913f, -0.00563977f, 0.00201850f, -0.06825510f, -0.05805520f, 
    -0.04708623f, -0.04742698f, 0.00977041f, 0.02747138f, -0.00793346f, -0.06969459f, -0.03500675f, -0.01667630f, 
    0.00511812f, -0.04402614f, -0.05915610f, 0.05073139f, -0.05260901f, -0.05296762f, -0.03290898f, -0.04148443f, 
    0.03896147f, 0.06195020f, 0.02337792f, 0.00739016f, 0.01346096f, -0.04218912f, 0.00670670f, 0.02987964f, 
    0.06475516f, -0.06986636f, -0.01514542f, -0.02782329f, -0.04770014f, -0.00937882f, -0.07225548f, -0.00616438f, 
    0.03067503f, -0.04528854f, -0.01144077f, -0.05971391f, 0.06413660f, 0.04005028f, -0.02340474f, -0.04712108f, 
    -0.04785299f, -0.07478806f, 0.05832823f, -0.05457339f, 0.02084148f, -0.04635415f, -0.05482855f, -0.04178691f, 
    0.02067235f, -0.04189547f, 0.06010041f, -0.04677124f, 0.00182375f, -0.05870959f, -0.07413234f, 0.06121223f, 
    -0.02104779f, 0.01273288f, -0.05592328f, 0.01666150f, -0.04432581f, 0.01419181f, 0.00016269f, 0.02421556f, 
    -0.05919188f, 0.03943843f, 0.01835227f, 0.02037152f, 0.02801896f, -0.04025067f, -0.01779191f, 0.03568447f, 
    -0.01573691f, -0.04603824f, -0.03083875f, -0.04595673f, -0.04592771f, -0.05013431f, 0.04373208f, -0.03534447f, 
    0.00011806f, 0.06002975f, -0.06118443f, -0.01048667f, 0.00826995f, -0.02165999f, 0.01948252f, 0.03634541f, 
    -0.06451514f, 0.02165208f, 0.03886834f, 0.00086519f, -0.02116358f, 0.01836842f, -0.03042041f, 0.03836199f, 
    -0.01838897f, -0.00822621f, -0.06177513f, -0.05127015f, -0.07206999f, -0.00733762f, -0.03860301f, -0.07276065f, 
    0.01617515f, -0.39498705f, -0.01952372f, -0.09541071f, 0.13909301f, 0.12603898f, -0.09376637f, -0.14502373f, 
    -0.10748368f, -0.03533053f, -0.11404148f, -0.17784192f, 0.02306190f, -0.16745330f, -0.16717213f, 0.13414954f, 
    0.09402163f, -0.07427824f, 0.13117573f, -0.01988093f, 0.10858805f, 0.18599533f, 0.14001420f, 0.17201489f, 
    -0.16635525f, -0.21385616f, 0.00441004f, 0.22843182f, -0.07212625f, 0.00476985f, -0.12794705f, 0.02603537f, 
    0.02363268f, -0.08905318f, -0.05827355f, 0.08524958f, 0.27475879f, 0.01810524f, 0.28118247f, 0.16508009f, 
    0.12370794f, -0.17030105f, -0.10984453f, -0.00011860f, 0.01441874f, 0.15194456f, 0.00139977f, 0.01871308f, 
    0.11299384f, 0.34308472f, 0.05323135f, 0.14139956f, -0.12846231f, -0.03453684f, -0.05927806f, -0.12515874f, 
    0.13744409f, 0.12101053f, 0.18408373f, -0.05710098f, 0.07652913f, -0.11146126f, -0.22274259f, 0.19073176f, 
    -0.00891192f, -0.01854296f, -0.00779844f, -0.22770886f, 0.15733023f, 0.06898860f, 0.06128303f, 0.26546824f, 
    -0.14774421f, 0.24680910f, -0.01410334f, 0.16672212f, 0.14980607f, 0.06590357f, -0.16477357f, 0.02348128f, 
    0.18264571f, 0.03207307f, 0.01296613f, 0.10620516f, -0.21321847f, 0.41975844f, 0.48873955f, 0.22985242f, 
    -0.05345500f, 0.03603532f, 0.11083084f, -0.24883403f, 0.03847132f, -0.02807200f, 0.03852195f, 0.08659579f, 
    -0.24917981f, -0.09456826f, -0.08631224f, 0.01529921f, 0.02844285f, 0.07755456f, -0.04915735f, 0.08450506f, 
    -0.03260154f, -0.07495078f, 0.00545972f, -0.21425426f, -0.08534268f, -0.03086029f, 0.04899318f, 0.25513300f, 
    -0.06226187f, 0.04754635f, 0.05972362f, 0.04834520f, -0.02968385f, -0.12320183f, 0.01708889f, -0.06722365f, 
    -0.12477828f, 0.04247912f, -0.00831245f, -0.25005248f, -0.13357237f, -0.09004217f, -0.09900252f, 0.04011671f, 
    -0.11618546f, -0.03799435f, 0.04265393f, -0.05659064f, -0.10098105f, 0.06603223f, 0.11068118f, -0.05369258f, 
    0.05104595f, 0.05699478f, -0.12248293f, -0.15346871f, -0.00977389f, -0.11942014f, -0.09587009f, -0.17034896f, 
    0.13561442f, -0.06274170f, 0.03655165f, 0.02883446f, -0.01088004f, -0.22083372f, 0.04121003f, -0.04129688f, 
    -0.00109447f, 0.18370245f, 0.15248345f, 0.40158635f, -0.09226917f, 0.11546947f, 0.07657653f, 0.17987897f, 
    0.18209727f, 0.02750901f, 0.02423628f, -0.11443518f, -0.07326179f, -0.07469732f, -0.17339039f, -0.08289462f, 
    -0.02320547f, 0.16714849f, -0.15722784f, -0.06207204f, -0.08037244f, -0.04359958f, 0.11229919f, 0.16696113f, 
    0.15218033f, 0.14502184f, -0.04508011f, 0.20568995f, -0.02042582f, -0.23049891f, -0.12058944f, 0.16880685f, 
    -0.18917112f, -0.07691433f, -0.00015691f, 0.22214477f, -0.09545622f, -0.01344487f, -0.28362268f, -0.11167080f, 
    0.04944928f, -0.03676031f, -0.06810740f, 0.08287840f, 0.01888900f, 0.14888901f, -0.05304620f, 0.02712272f, 
    -0.07136659f, 0.04955729f, 0.13556330f, 0.06883290f, -0.03606686f, -0.00359240f, 0.00571238f, -0.05287546f, 
    -0.07967220f, -0.09835129f, 0.03791634f, 0.17904252f, -0.01817434f, -0.00481135f, -0.10612535f, -0.07148315f, 
    -0.02664950f, 0.06768434f, -0.02237663f, -0.04409925f, 0.05484089f, 0.00395917f, -0.04956045f, 0.05548518f, 
    -0.20721853f, -0.12023325f, -0.11995227f, -0.19090842f, 0.01539105f, 0.11078738f, 0.07009321f, 0.09507307f, 
    0.10758339f, 0.02916666f, 0.04890114f, 0.04292338f, -0.06150434f, -0.02845978f, -0.07803574f, 0.03914990f, 
    0.02272930f, -0.00177614f, 0.13176690f, 0.05098040f, -0.11638579f, -0.04602064f, 0.07140628f, 0.10780920f, 
    -0.04855951f, -0.06176676f, 0.11480905f, 0.16464667f, -0.08409265f, 0.23320849f, -0.12874877f, -0.08274620f, 
    0.14917101f, 0.15447183f, 0.07214239f, 0.15980804f, 0.01562720f, 0.01620324f, -0.01390484f, -0.04959039f, 
    -0.02220626f, -0.17954727f, 0.03558267f, 0.06292470f, -0.10021955f, 0.04205841f, -0.07360803f, 0.25374299f, 
    0.02553177f, 0.08899434f, 0.09730078f, 0.10068696f, -0.12716138f, -0.07257841f, 0.02305001f, -0.06407366f, 
    -0.03110523f, -0.03255891f, -0.07526288f, 0.07625347f, -0.07686703f, -0.07583916f, 0.07736658f, -0.02920999f, 
    -0.09112837f, 0.06511167f, -0.13054040f, 0.08534937f, 0.10468987f, -0.04241180f, 0.08763144f, 0.08049366f, 
    -0.03040466f, -0.06653706f, -0.12740937f, -0.10602216f, 0.07950421f, 0.11571554f, -0.02414755f, -0.00223774f, 
    0.10189100f, -0.09242595f, 0.06929919f, -0.06280698f, -0.15429123f, -0.15459639f, -0.01876157f, 0.07463495f, 
    0.02548440f, -0.07673787f, 0.01632131f, -0.10063246f, -0.09373058f, 0.00943613f, 0.08958699f, -0.09410880f, 
    -0.10742446f, 0.00024440f, 0.05051503f, 0.08763350f, 0.06172172f, -0.05955673f, 0.10100301f, 0.05835216f, 
    -0.18888578f, 0.05139953f, -0.14094135f, 0.09317044f, -0.12389901f, -0.04956979f, -0.01352158f, 0.04290216f, 
    0.02953999f, 0.11814106f, -0.03255724f, 0.04333277f, -0.06957424f, -0.13839635f, 0.05553474f, -0.04535692f, 
    -0.11819571f, 0.02278939f, -0.28633371f, 0.08288070f, -0.11795854f, -0.05069111f, 0.04925354f, 0.06890559f, 
    -0.07140760f, 0.07822900f, -0.07267596f, -0.00765381f, -0.19587620f, -0.02862903f, 0.02981214f, 0.09991933f, 
    0.02599006f, 0.11904851f, -0.08287680f, -0.04307060f, -0.14311257f, 0.01410684f, -0.04505707f, -0.05195537f, 
    -0.05690071f, -0.10229061f, -0.01385168f, 0.13675244f, -0.01319336f, 0.11290891f, -0.01671349f, 0.07075875f, 
    0.11189448f, -0.07899049f, -0.09272963f, 0.24639206f, -0.11827440f, -0.11295346f, -0.00348616f, -0.03775827f, 
    0.27730396f, 0.21267122f, -0.21813205f, 0.16296540f, 0.08176677f, -0.01226800f, 0.11347278f, -0.11011737f, 
    -0.00243908f, 0.00907815f, 0.08214952f, -0.01116693f, 0.17538533f, 0.02134426f, 0.03136857f, 0.05055987f, 
    0.14458862f, 0.05643011f, -0.03784684f, -0.08897953f, 0.01184769f, 0.06982017f, -0.06489102f, 0.09847498f, 
    0.16275038f, 0.15812549f, 0.04602978f, 0.20431168f, 0.07198176f, 0.09943724f, 0.00305396f, 0.05999028f, 
    -0.01017901f, 0.06723543f, 0.01695336f, 0.00932356f, 0.15882480f, 0.27265033f, -0.09978059f, 0.05460140f, 
    0.04132054f, 0.06444653f, 0.11547635f, -0.00540865f, -0.09078901f, -0.06222271f, -0.05353934f, -0.03578884f, 
    -0.17894706f, 0.04216208f, -0.04101507f, 0.24476118f, -0.05252941f, 0.08097649f, 0.14711769f, -0.12882729f, 
    -0.02257282f, -0.04354924f, -0.05286008f, -0.03973819f, -0.16250141f, 0.32656565f, 0.17046252f, -0.15210892f, 
    0.19382948f, 0.10258107f, -0.15626514f, -0.06083698f, -0.03423137f, 0.00416152f, -0.06873885f, -0.12357733f, 
    -0.14458822f, 0.33625561f, -0.16360600f, -0.06764013f, -0.03962362f, 0.02819782f, -0.07776066f, 0.08312692f, 
    -0.09566202f, -0.05961795f, 0.00890041f, -0.07377727f, 0.18329412f, 0.34781605f, -0.13758980f, 0.29214182f, 
    0.09852711f, 0.08655090f, -0.04827644f, -0.09187853f, -0.11453369f, 0.05578471f, 0.05882316f, -0.20677559f, 
    -0.29315457f, 0.07023698f, 0.06350493f, 0.06614821f, -0.05891474f, 0.04673783f, -0.07311489f, 0.03135588f, 
    0.08249795f, 0.11231770f, 0.02212564f, -0.01062686f, 0.07796358f, -0.01003927f, 0.03248459f, 0.08169973f, 
    0.13715427f, 0.09773958f, -0.01279126f, 0.11342070f, -0.05077414f, -0.02647520f, -0.02699393f, -0.10998064f, 
    -0.19714229f, -0.14284660f, -0.03095537f, -0.07105017f, -0.10254452f, 0.00246378f, -0.09717503f, -0.07017393f, 
    -0.01385679f, 0.05050172f, 0.12844352f, 0.09729040f, 0.09674533f, -0.04468953f, -0.09675593f, -0.01816344f, 
    -0.01649478f, -0.09802600f, -0.00617409f, 0.12239327f, 0.07073535f, 0.03976973f, 0.14241648f, 0.07403294f, 
    -0.08082224f, 0.05197746f, 0.04383219f, 0.00969559f, -0.09024516f, 0.00519818f, -0.15921871f, -0.12589072f, 
    -0.12904984f, 0.04554839f, -0.06608593f, 0.11039437f, -0.35389152f, 0.18314420f, -0.10443874f, 0.25630194f, 
    -0.07682247f, -0.12964751f, 0.01316484f, -0.06785430f, -0.07947629f, 0.02090523f, 0.00781054f, 0.18735585f, 
    -0.46725529f, 0.31682226f, -0.22178450f, -0.18586075f, -0.00973828f, 0.05457031f, -0.03505084f, -0.03365505f, 
    -0.11229035f, -0.08847772f, -0.08029425f, -0.12972903f, 0.15722215f, 0.09735721f, -0.06864360f, -0.02597276f, 
    0.14328478f, 0.14137800f, 0.05810027f, 0.15044680f, 0.05216023f, -0.02777758f, 0.30317515f, 0.09927385f, 
    0.05434333f, 0.04806591f, 0.17234789f, -0.14838658f, 0.06387392f, 0.02407612f, -0.16182634f, 0.12337857f, 
    -0.01068094f, -0.24455507f, -0.04246892f, -0.24960166f, -0.05507315f, 0.22767600f, 0.13954318f, 0.19757557f, 
    0.08450831f, 0.16288461f, 0.09891976f, 0.07390364f, 0.02885918f, 0.01433128f, 0.13819119f, 0.22314978f, 
    0.06815834f, 0.13509919f, 0.36590952f, 0.25988838f, -0.10726624f, 0.10084272f, 0.00581838f, 0.05819706f, 
    0.12833318f, -0.05514469f, 0.08215549f, -0.02991246f, 0.16696259f, 0.04004745f, 0.03373789f, 0.00097059f, 
    -0.00391018f, 0.03538195f, -0.05466143f, -0.03231456f, -0.06761079f, -0.07056109f, -0.02371079f, 0.11401661f, 
    0.01386920f, -0.08542281f, 0.10771564f, 0.02908141f, -0.04802885f, -0.01965488f, 0.02084141f, -0.16063869f, 
    0.07672136f, 0.16455141f, 0.03719540f, 0.09460647f, -0.02260483f, 0.05832917f, 0.14895657f, 0.10364288f, 
    -0.04325759f, 0.13333082f, 0.08068821f, -0.12046364f, -0.15819806f, -0.00223705f, 0.13231444f, 0.11726408f, 
    0.07934892f, -0.25374258f, -0.09048899f, 0.07452606f, 0.03726061f, -0.04358959f, -0.11328834f, -0.01287711f, 
    0.02358012f, 0.09894388f, -0.02466786f, 0.28431663f, 0.31201279f, -0.20933545f, 0.21513696f, -0.10044481f, 
    -0.17645098f, -0.17471732f, 0.15410253f, -0.02668579f, 0.05285096f, 0.03275969f, 0.04392483f, 0.08479567f, 
    -0.41893515f, -0.28589928f, 0.35675707f, 0.01304850f, -0.03883934f, 0.06919073f, -0.13246581f, -0.21204880f, 
    0.06679143f, -0.04934322f, -0.02274716f, -0.02630828f, 0.16687636f, 0.25335836f, 0.27011904f, 0.08579491f, 
    0.03673830f, -0.01241145f, 0.15400986f, 0.09761266f, -0.13175419f, 0.02435354f, -0.10365541f, -0.07997916f, 
    -0.14380568f, -0.32315198f, -0.09754619f, 0.24420583f, 0.16882893f, 0.08518292f, -0.14296170f, -0.06000200f, 
    0.14530271f, 0.03058308f, 0.04159097f, 0.02798218f, -0.07216589f, -0.20857945f, -0.43643159f, -0.16756429f, 
    0.02955545f, -0.02319868f, -0.01123885f, 0.10538550f, 0.00796135f, 0.09590020f, -0.20120081f, -0.08496468f, 
    0.11183491f, 0.11252286f, -0.12704161f, -0.00252994f, 0.11784315f, -0.02240590f, -0.07971133f, 0.01807601f, 
    0.03078910f, 0.10763782f, 0.05694311f, 0.20346786f, 0.16147363f, 0.15664424f, 0.04941977f, -0.15866530f, 
    0.07551669f, -0.11000355f, -0.00271278f, 0.02952049f, -0.19723625f, 0.00045887f, -0.08405112f, -0.00135967f, 
    0.10317869f, -0.13567892f, 0.19842260f, -0.15693246f, -0.05992163f, -0.05752521f, 0.13385057f, -0.01604074f, 
    -0.09632073f, 0.04693058f, 0.06941728f, 0.09969421f, 0.46052745f, -0.14244567f, 0.04494263f, -0.02700319f, 
    0.01811245f, 0.03486214f, -0.04833625f, 0.18165393f, 0.00927493f, -0.10433318f, -0.26475152f, -0.03000320f, 
    0.10460398f, 0.23068623f, 0.11402985f, 0.01923389f, 0.03923170f, 0.15900792f, -0.01185317f, 0.03388133f, 
    -0.03008194f, 0.01263779f, -0.05768132f, 0.02395169f, 0.16127239f, -0.09212747f, 0.05223411f, 0.16652595f, 
    -0.02827590f, -0.09563935f, 0.12854826f, -0.00130128f, 0.11487295f, -0.08342410f, -0.03134285f, 0.20993470f, 
    -0.01038280f, 0.02807461f, 0.30540204f, 0.30742604f, 0.00408746f, -0.12437779f, -0.11973084f, -0.01181979f, 
    -0.01729520f, 0.06648903f, 0.05927692f, -0.00030868f, 0.29397216f, 0.08521724f, -0.29127461f, -0.22358598f, 
    -0.06807403f, -0.04842462f, 0.02004775f, 0.02497968f, -0.08252516f, -0.02371797f, 0.05015232f, -0.01675380f, 
    -0.04895216f, -0.06341644f, -0.12816104f, 0.24964792f, -0.04802076f, 0.15935594f, 0.06754088f, 0.07472477f, 
    -0.01509849f, 0.04597104f, 0.10319898f, 0.12249110f, -0.23013148f, -0.11458971f, -0.14642963f, -0.15100810f, 
    -0.14090104f, -0.00710628f, -0.14828213f, -0.01738347f, -0.06717907f, -0.12296791f, -0.13214684f, -0.00230699f, 
    -0.07113071f, 0.37965468f, -0.16356187f, -0.03464807f, 0.00909739f, -0.02772311f, -0.02463512f, 0.02665342f, 
    0.17411323f, 0.03439185f, -0.14715926f, 0.04546337f, 0.11302804f, 0.24205384f, -0.15373491f, 0.04498947f, 
    0.08179199f, 0.07119573f, -0.03808994f, -0.02553312f, -0.10870043f, -0.04904936f, -0.03098649f, -0.01304381f, 
    0.03625753f, -0.09828266f, -0.06881832f, -0.00173064f, -0.33739153f, -0.05951841f, -0.16578594f, 0.01082976f, 
    0.11177825f, -0.06447764f, 0.06009325f, -0.06860644f, -0.03161781f, 0.14514099f, 0.24410005f, 0.39961275f, 
    -0.02870308f, 0.05961857f, 0.02831543f, -0.05653760f, -0.13194671f, -0.06183451f, 0.04990772f, -0.07980626f, 
    0.28009591f, -0.00847236f, 0.03688857f, 0.02163164f, -0.08362101f, 0.00240695f, -0.06216322f, -0.07762938f, 
    0.05898768f, 0.07521420f, 0.02919731f, -0.08208729f, 0.22881882f, 0.02950997f, -0.03177070f, 0.09952126f, 
    0.06705842f, 0.01183564f, -0.05797957f, 0.00295601f, 0.03269477f, 0.12824255f, -0.06536899f, -0.10370614f, 
    0.13364129f, 0.19795583f, 0.02279478f, 0.00127801f, 0.00253503f, -0.03340172f, -0.03526798f, -0.04018205f, 
    0.12283020f, 0.10962875f, 0.08576404f, 0.08713171f, -0.14321747f, 0.34761685f, -0.08788344f, 0.25475460f, 
    -0.05886889f, -0.20336322f, -0.01074355f, 0.04620922f, 0.00837895f, 0.02926540f, 0.12904671f, 0.04015753f, 
    -0.19787067f, 0.15398514f, 0.09116028f, -0.09771602f, -0.09355284f, 0.01035596f, -0.02648663f, 0.03409174f, 
    -0.07819230f, 0.02747996f, 0.00195821f, 0.17727327f, 0.08351881f, 0.03237493f, 0.25953594f, 0.10993423f, 
    0.03057301f, 0.24417788f, -0.07676511f, 0.00904453f, -0.01209287f, -0.00766371f, 0.14377283f, -0.10774957f, 
    -0.04595727f, -0.00257607f, 0.28548425f, -0.18871783f, -0.02024680f, 0.01079803f, 0.02509833f, 0.08771121f, 
    0.02045694f, 0.10552030f, 0.05171331f, 0.09621334f, -0.10853105f, -0.05349648f, -0.16245481f, -0.12259327f, 
    0.07791330f, -0.05693402f, 0.08940875f, 0.19502455f, 0.07292996f, -0.11526852f, -0.01428810f, -0.14241262f, 
    -0.18493167f, -0.06698371f, -0.18395676f, -0.10067351f, 0.05418061f, 0.05671672f, 0.10620198f, 0.10723780f, 
    -0.04181751f, 0.03051110f, 0.02682591f, 0.06276231f, 0.03185005f, -0.14473347f, 0.21572389f, 0.06417281f, 
    -0.10384145f, -0.18193924f, -0.01142288f, 0.00674826f, 0.18361585f, 0.12438002f, 0.11385224f, 0.09833455f, 
    0.07621309f, 0.28454202f, -0.09182296f, 0.06884939f, 0.08687653f, -0.02884098f, -0.04796117f, 0.05021438f, 
    -0.00636227f, 0.00283174f, 0.05977710f, -0.04642047f, 0.21018605f, -0.34098518f, 0.14177129f, 0.13429686f, 
    0.02972708f, -0.00626097f, -0.04288868f, 0.22891149f, 0.09724455f, -0.01031919f, 0.09124627f, 0.03228199f, 
    0.09350483f, 0.06531709f, 0.20395045f, -0.00267984f, -0.09178460f, 0.03173666f, -0.06550477f, 0.01637771f, 
    -0.04626444f, 0.09307510f, 0.11094236f, -0.11705260f, -0.30434150f, 0.10274213f, 0.06451323f, -0.09942001f, 
    0.12637629f, -0.14502233f, -0.06975054f, 0.09498921f, -0.02985160f, 0.00732193f, 0.11561250f, 0.13208383f, 
    0.21457933f, -0.01232072f, -0.18490997f, 0.04803334f, -0.00361142f, -0.01673923f, 0.12704924f, 0.06934053f, 
    -0.04301918f, 0.08266984f, -0.00369729f, 0.08439380f, -0.08160412f, 0.12579250f, -0.04938052f, 0.20061915f, 
    -0.00004942f, 0.12244291f, 0.01503043f, 0.07822802f, 0.10760210f, 0.05011288f, 0.02644657f, -0.00082905f, 
    -0.01872994f, 0.07225570f, -0.04690801f, -0.03987932f, -0.00809488f, -0.06738693f, -0.09826387f, -0.05725196f, 
    -0.03138501f, -0.07143136f, -0.10289927f, -0.04114079f, 0.00944123f, 0.00582109f, 0.05748009f, 0.02145971f, 
    -0.12353630f, -0.10670294f, -0.01854304f, -0.10714853f, 0.09161074f, -0.00802173f, 0.06270231f, 0.12643418f, 
    0.02975296f, -0.05763917f, 0.02380375f, -0.01536458f, 0.02839310f, 0.02863299f, 0.02915578f, 0.07209563f, 
    0.08957424f, -0.14579691f, -0.12246338f, -0.35709295f, -0.04636275f, -0.10278573f, 0.17556916f, 0.01225306f, 
    0.04052671f, 0.07510332f, -0.02365307f, 0.10791976f, 0.16237386f, -0.06427426f, 0.01566730f, -0.06170234f, 
    0.06127248f, 0.04687658f, -0.07030743f, 0.21559833f, 0.05540206f, -0.00574102f, -0.10635673f, -0.04657674f, 
    0.06028997f, 0.00876262f, 0.11697215f, -0.13425012f, -0.33108759f, 0.00081761f, 0.31658560f, -0.21195647f, 
    0.03111646f, 0.04908078f, 0.02133902f, -0.20263371f, -0.03143578f, 0.09310456f, 0.08750621f, 0.00515552f, 
    -0.02377073f, 0.00586156f, -0.01191489f, -0.03956066f, -0.05371879f, 0.04535228f, -0.04564846f, -0.08103339f, 
    -0.06675952f, -0.01574515f, -0.02305930f, -0.05563321f, -0.03249884f, -0.03937999f, -0.05033749f, -0.07499615f, 
    0.00785832f, -0.04978767f, -0.05821936f, -0.00693504f, -0.03925743f, -0.04077480f, 0.03183376f, -0.01989718f, 
    -0.02429285f, 0.04423345f, 0.04335080f, -0.00940928f, 0.04785919f, 0.03983244f, 0.03550569f, 0.03089497f, 
    -0.02229629f, -0.03750476f, -0.03676353f, -0.03467560f, -0.06283139f, 0.01918173f, -0.02792113f, 0.02805412f, 
    0.05984938f, 0.03101611f, -0.06729002f, -0.01564345f, 0.01939697f, -0.01037884f, 0.01179018f, 0.02922234f, 
    0.02789783f, -0.06991511f, 0.02097010f, -0.05618488f, 0.01754512f, -0.03666046f, 0.03519716f, -0.01977021f, 
    -0.02526851f, -0.02362017f, 0.06089428f, 0.06270457f, 0.04058534f, -0.01713632f, 0.05734190f, 0.03738136f, 
    -0.05031258f, 0.05158560f, -0.05423246f, -0.06878377f, -0.05166375f, 0.04878040f, 0.05397468f, -0.07663242f, 
    -0.02751733f, -0.02998250f, 0.00021552f, 0.03927172f, -0.06511933f, -0.05136748f, -0.02420679f, -0.03367013f, 
    -0.07939882f, -0.00398442f, -0.02969787f, -0.04817052f, -0.07722846f, -0.07417122f, 0.01960197f, -0.03930945f, 
    0.01334839f, 0.02464242f, -0.06731047f, -0.02959293f, -0.02619004f, -0.06250859f, -0.00190019f, 0.06348100f, 
    -0.01218527f, -0.01434155f, 0.00136078f, -0.06555966f, -0.04055972f, 0.02079750f, -0.03800340f, -0.06499764f, 
    -0.04859626f, -0.04341585f, -0.05722350f, 0.05675367f, -0.02385945f, -0.01763803f, 0.00690975f, 0.05848027f, 
    0.04460574f, -0.06000309f, -0.06093665f, 0.04835790f, 0.01790534f, -0.03335373f, 0.03068539f, 0.01032902f, 
    0.05953842f, -0.06311327f, 0.00622121f, -0.02694415f, -0.07353421f, 0.00863938f, -0.02638182f, -0.04892140f, 
    -0.02687046f, 0.03324596f, -0.02135900f, 0.03935257f, 0.06889566f, 0.02270805f, -0.03027290f, -0.01105154f, 
    -0.05030532f, 0.01938814f, -0.06300538f, -0.00538441f, -0.07221749f, -0.03069582f, 0.03324177f, 0.00626483f, 
    0.06022713f, 0.04115759f, -0.05587206f, -0.07335886f, 0.03065283f, -0.03173930f, 0.02080623f, -0.05921758f, 
    -0.05104266f, -0.06852537f, -0.02397588f, 0.02011009f, 0.04290812f, -0.07085562f, -0.02261904f, -0.01889861f, 
    -0.00075015f, -0.01083083f, 0.03388885f, -0.04245942f, -0.05386410f, -0.00316767f, -0.00869339f, 0.04208636f, 
    -0.04552959f, -0.00944447f, -0.08110230f, -0.01900749f, 0.05125197f, -0.00124837f, 0.05278282f, -0.06423764f, 
    -0.06363557f, -0.00281097f, -0.06123321f, -0.04158508f, 0.00808949f, 0.03974039f, 0.03489842f, -0.01289875f, 
    0.01708825f, -0.03153510f, 0.00363920f, 0.03887687f, 0.00671041f, -0.05940912f, -0.02507678f, 0.04610796f, 
    0.04352986f, -0.07654392f, -0.00149416f, -0.01565700f, 0.05493683f, 0.00570755f, -0.06709103f, -0.05886159f, 
    0.04229670f, -0.04381090f, 0.02263999f, -0.05753084f, -0.03052405f, -0.02536778f, -0.03002187f, -0.00058268f, 
    -0.05938173f, 0.05072360f, 0.05712609f, -0.07925917f, -0.04865941f, -0.02045767f, 0.03333289f, -0.07588866f, 
    0.01097681f, -0.02048267f, 0.06154926f, 0.05899111f, -0.04308035f, -0.00381653f, -0.01601378f, 0.05396780f, 
    -0.01430625f, -0.03718759f, -0.00332054f, 0.05547329f, -0.01694539f, -0.06677731f, -0.00069846f, 0.03095320f, 
    -0.03907226f, 0.05861670f, -0.00806274f, -0.04030007f, 0.00772663f, 0.03453123f, -0.02810672f, -0.01283839f, 
    0.05699381f, 0.01436727f, -0.06625579f, 0.02713034f, 0.02137169f, 0.05315250f, -0.04704989f, -0.06102196f, 
    0.00651829f, -0.00905030f, -0.07306263f, -0.03684865f, 0.00895299f, -0.00232708f, 0.02595412f, -0.00208454f, 
    -0.04695348f, -0.03972490f, -0.06233266f, -0.01822195f, -0.03804222f, -0.04302862f, 0.02243978f, 0.03400041f, 
    -0.05320939f, 0.04704915f, -0.03088181f, 0.02135907f, 0.05531904f, -0.01549382f, 0.00907953f, -0.03111458f, 
    -0.05776131f, 0.03721875f, 0.03990369f, 0.00311280f, 0.06876519f, 0.06400008f, -0.00520785f, -0.01151068f, 
    -0.07084126f, -0.00580019f, 0.00583726f, -0.01631423f, 0.03089615f, -0.06768203f, 0.02291720f, -0.04253021f, 
    0.02926983f, 0.04995683f, 0.04791136f, 0.06756029f, -0.03192214f, -0.03406563f, 0.01633008f, -0.02753737f, 
    -0.05490648f, -0.02955838f, -0.07167167f, 0.03710425f, -0.03831387f, 0.03068693f, -0.00197242f, -0.03155237f, 
    -0.05554074f, -0.03124227f, 0.06442060f, -0.02831018f, 0.06201085f, -0.04362936f, -0.06840373f, 0.02204895f, 
    -0.02282226f, -0.01105119f, -0.04323840f, 0.01811936f, -0.03153883f, 0.00263358f, -0.05128709f, 0.05897612f, 
    0.05378142f, 0.00598645f, -0.05556286f, -0.05444764f, 0.00999345f, -0.07138416f, -0.05424653f, 0.05951118f, 
    0.06302197f, -0.03793169f, -0.04088731f, 0.04104576f, 0.03069044f, -0.06585853f, -0.07464012f, -0.00401265f, 
    0.02421578f, -0.05456828f, -0.00777450f, -0.01889792f, -0.01163017f, -0.06847473f, 0.06707104f, -0.05314039f, 
    0.02053004f, -0.07522500f, 0.00697821f, 0.03019637f, -0.03768779f, -0.04528640f, -0.05267421f, -0.04992720f, 
    -0.00849416f, -0.07258637f, -0.05397641f, 0.01020040f, -0.01353611f, -0.07080497f, -0.04433788f, -0.00620329f, 
    0.05027480f, -0.01505849f, -0.04504193f, 0.06002567f, -0.01106962f, 0.00600689f, -0.07090986f, 0.01491931f, 
    0.03710192f, 0.05117226f, 0.04568288f, 0.04187651f, 0.00026465f, -0.02184388f, 0.04519284f, -0.02144499f, 
    -0.04123838f, -0.06848355f, -0.05074209f, 0.02902334f, -0.05451428f, 0.06292091f, 0.03919421f, 0.04220407f, 
    -0.13272052f, -0.07078944f, 0.19038108f, 0.01569167f, 0.13160601f, 0.03597097f, 0.00408644f, 0.08098152f, 
    -0.11040081f, -0.02198024f, -0.00637042f, 0.04984735f, -0.13190442f, -0.04004051f, -0.03927198f, -0.02634566f, 
    -0.08008114f, -0.07642026f, 0.22121300f, 0.30418709f, 0.00300311f, 0.00411243f, 0.19803114f, 0.21370259f, 
    -0.13579862f, -0.01902499f, -0.22654076f, -0.37642333f, 0.00070726f, 0.01912103f, -0.00797316f, 0.07646334f, 
    -0.03277196f, -0.06726201f, -0.09144413f, -0.05652856f, 0.15362926f, -0.02574801f, 0.35051432f, 0.06329182f, 
    0.01697695f, -0.25441375f, -0.11364107f, 0.07431415f, -0.06943086f, -0.10010469f, 0.22287481f, -0.21793129f, 
    0.13261439f, -0.05725285f, 0.06405319f, -0.22133361f, -0.04067296f, -0.01345543f, 0.09284398f, 0.20213805f, 
    -0.05027782f, 0.16424407f, 0.12581074f, -0.03578542f, 0.12066276f, -0.30240577f, 0.01310652f, 0.01254777f, 
    0.13748018f, -0.02455941f, 0.06505539f, 0.05729419f, 0.26625809f, 0.12054162f, 0.18789512f, 0.04679419f, 
    -0.14627357f, 0.06534467f, 0.10411011f, 0.01869296f, 0.09658413f, 0.05703357f, 0.07803094f, 0.02374723f, 
    0.20822772f, 0.25550044f, 0.05394078f, -0.05537932f, -0.17574608f, 0.13925175f, 0.04892999f, -0.08289028f, 
    -0.04984903f, -0.09458628f, 0.02814093f, 0.13324681f, -0.19736710f, -0.03213773f, 0.08266396f, -0.01886635f, 
    0.46353120f, -0.05392826f, -0.09261004f, 0.02561318f, 0.14911640f, 0.10470692f, 0.02805194f, 0.01017524f, 
    0.00459002f, 0.14040165f, 0.04673449f, -0.01375300f, -0.17137110f, -0.15884420f, -0.08330458f, -0.11183239f, 
    0.03328453f, 0.08163989f, 0.15285785f, 0.09078174f, -0.09308699f, -0.11709948f, 0.08285188f, 0.01960365f, 
    0.18249294f, 0.04328052f, -0.04213473f, -0.03514522f, -0.04255307f, 0.02485891f, 0.09955199f, 0.06794290f, 
    0.02158428f, 0.07484109f, 0.09868906f, -0.05692453f, 0.05095091f, -0.05976646f, 0.02877136f, 0.07506374f, 
    0.03060283f, 0.10996581f, 0.00287500f, -0.11894894f, 0.11143888f, -0.07225497f, 0.12526567f, -0.05474296f, 
    -0.16753346f, -0.10700861f, -0.15807080f, -0.02467470f, -0.01379829f, -0.02590943f, 0.00540922f, 0.10091420f, 
    0.24546173f, 0.16241440f, -0.01651912f, 0.25967395f, 0.04966478f, -0.11038730f, 0.09039558f, -0.02612677f, 
    0.15060364f, 0.11767571f, -0.06154720f, 0.02256576f, 0.04215965f, 0.04625864f, 0.00640766f, -0.02950435f, 
    -0.00926832f, -0.11999514f, -0.08982746f, -0.00570907f, 0.08683824f, -0.06209251f, -0.03982306f, 0.02169033f, 
    0.14510129f, 0.02091000f, 0.08139519f, 0.04606942f, -0.24459770f, -0.24007523f, -0.00308499f, -0.00601722f, 
    0.05562878f, -0.08158161f, -0.07112250f, -0.08260688f, -0.17585364f, -0.02934803f, 0.00952805f, -0.02681009f, 
    0.01886501f, 0.03544014f, -0.06459124f, 0.01312881f, -0.05330173f, 0.05341741f, -0.03401575f, -0.05839333f, 
    0.04374143f, 0.03352012f, -0.00791740f, 0.01535663f, -0.01396037f, -0.06540959f, 0.06054127f, -0.06169922f, 
    -0.05330049f, -0.02419016f, -0.00891505f, 0.00644046f, -0.04124960f, 0.00719187f, -0.03155574f, -0.04019490f, 
    -0.00344233f, -0.02388502f, -0.01492603f, 0.05031864f, 0.05471873f, 0.05463726f, -0.00739329f, -0.06729722f, 
    -0.06587981f, 0.01708983f, -0.05735448f, -0.00445946f, -0.00336016f, -0.02242929f, -0.04927259f, -0.02227505f, 
    0.04052480f, -0.02654148f, -0.03792977f, -0.07264347f, 0.01805022f, -0.05445096f, -0.06167816f, -0.01405590f, 
    -0.05089385f, 0.00550449f, -0.03183115f, -0.06240612f, 0.03307117f, 0.00600432f, -0.01044202f, -0.01722009f, 
    -0.03799005f, -0.06038241f, -0.02451515f, 0.05872386f, -0.00768386f, 0.04227924f, -0.01726411f, -0.05515596f, 
    0.00863215f, -0.04567929f, -0.01063897f, -0.02578050f, 0.00323883f, 0.01825685f, 0.05653997f, 0.04656766f, 
    0.00331645f, -0.04471917f, 0.00236086f, 0.03964486f, -0.01158098f, 0.05035878f, -0.07283705f, -0.06710159f, 
    0.00514922f, 0.05102948f, -0.06810988f, -0.06598617f, 0.00772061f, -0.03319238f, 0.02195884f, 0.03091145f, 
    0.01285838f, -0.01185790f, 0.01450768f, -0.04825708f, 0.03545068f, 0.02092715f, -0.01535890f, -0.00525088f, 
    0.05952299f, 0.00484196f, 0.00107082f, 0.04080454f, -0.02928530f, -0.05246689f, -0.05567266f, -0.06541561f, 
    -0.06240901f, -0.07472538f, 0.04787194f, 0.03583586f, 0.00913681f, 0.04701288f, -0.05611006f, -0.03366021f, 
    -0.03502863f, 0.03425113f, 0.02343092f, -0.05500726f, -0.06490211f, -0.06904465f, -0.01942112f, -0.05554054f, 
    -0.06035671f, -0.04672636f, -0.04614215f, -0.05976757f, -0.07046068f, 0.03723503f, -0.05170661f, -0.06531062f, 
    -0.07179471f, 0.03303607f, 0.05112291f, -0.01573162f, 0.02756853f, -0.07261936f, -0.03467471f, -0.02660157f, 
    0.04980162f, 0.03783076f, 0.03020711f, 0.00409024f, -0.00581835f, -0.06782313f, -0.02683555f, -0.01251855f, 
    -0.07427317f, 0.01846491f, -0.05089429f, 0.03598131f, 0.05110934f, 0.03082384f, -0.00470603f, -0.05809132f, 
    -0.00862865f, -0.01861263f, -0.05408462f, -0.04702921f, -0.07719010f, -0.00753254f, -0.00466051f, 0.03489032f, 
    0.00360039f, -0.00301159f, 0.03124960f, -0.02312272f, -0.04762774f, 0.01941619f, -0.01714581f, -0.03010767f, 
    -0.04387429f, 0.03030101f, -0.07043135f, -0.06507057f, 0.03328767f, -0.05628887f, 0.01142017f, -0.00129901f, 
    -0.01289556f, 0.05146733f, 0.01804150f, 0.00940693f, -0.05013917f, -0.06789629f, 0.00087536f, 0.04527249f, 
    -0.06932411f, 0.06468370f, 0.03956286f, -0.06353373f, -0.04915261f, 0.04802799f, 0.03624706f, -0.04406624f, 
    0.11150046f, -0.05752802f, 0.16343839f, -0.01142180f, 0.19181904f, 0.08491970f, 0.01443053f, 0.08777488f, 
    0.08216470f, 0.11287311f, 0.19080649f, 0.09756048f, 0.05940040f, -0.15772767f, -0.04428251f, 0.06840955f, 
    0.06213510f, -0.05201000f, 0.04607284f, -0.01354223f, -0.00703220f, -0.01123317f, -0.08026121f, 0.07184120f, 
    -0.16658482f, 0.05584576f, 0.08663310f, 0.33979809f, -0.00797383f, -0.09738359f, -0.04533998f, 0.04109643f, 
    -0.08416811f, -0.00269707f, -0.01220936f, -0.10645624f, 0.26726499f, 0.11793157f, -0.04948305f, 0.05673892f, 
    -0.06610484f, -0.16745821f, 0.05319370f, 0.09972868f, 0.01783731f, 0.01912509f, 0.06378791f, 0.06071014f, 
    -0.27886274f, 0.13595948f, -0.04068798f, 0.18214849f, 0.05123062f, 0.07366654f, 0.02379409f, 0.02601047f, 
    0.07460100f, 0.01075044f, -0.02228757f, 0.14784940f, -0.22743197f, -0.00260287f, -0.13254826f, -0.12810068f, 
    0.04087688f, 0.15376584f, -0.16578579f, -0.11531953f, 0.04589847f, 0.03116376f, -0.16734657f, -0.09863864f, 
    -0.18142477f, 0.44783318f, 0.05420640f, -0.07990944f, 0.10295415f, -0.01130936f, -0.14711493f, -0.00828686f, 
    0.03390212f, -0.01875089f, -0.01195865f, -0.16340846f, 0.00001830f, 0.39120445f, 0.08774642f, 0.05560536f, 
    -0.04051578f, -0.02888978f, -0.02209055f, 0.10567279f, -0.03918384f, 0.02608647f, 0.00669502f, -0.06203739f, 
    0.05941105f, -0.10952397f, -0.18971533f, 0.05781125f, -0.08635287f, 0.00808148f, -0.07312126f, -0.03374585f, 
    0.11798277f, 0.14220154f, 0.09599755f, -0.04777152f, -0.16062191f, 0.14964947f, 0.12575160f, 0.23169176f, 
    0.01655983f, 0.06629343f, 0.00958038f, 0.10063807f, -0.05739758f, 0.07329824f, 0.08117257f, -0.07501628f, 
    0.18218912f, 0.03230052f, 0.03618159f, -0.08488194f, -0.14708208f, -0.05490272f, -0.02948567f, -0.12478600f, 
    0.04004101f, 0.11268590f, 0.07864692f, -0.02667898f, 0.18150949f, 0.10518076f, 0.01658988f, 0.00774351f, 
    -0.12034741f, 0.00272406f, -0.08957238f, -0.03196920f, 0.00194456f, 0.12624998f, 0.09596548f, -0.03444834f, 
    0.18426903f, 0.13218848f, 0.09017602f, -0.10757409f, -0.10157617f, -0.03526191f, -0.01985711f, 0.02635782f, 
    -0.01534277f, 0.13156439f, -0.02730221f, -0.06025077f, -0.14518954f, 0.25363430f, -0.02365384f, 0.18003254f, 
    -0.15028903f, -0.07402403f, -0.05908993f, -0.01336070f, -0.02419688f, -0.03108645f, 0.05277397f, 0.03839361f, 
    -0.35707775f, 0.21523622f, -0.23944181f, -0.04252860f, -0.09545029f, -0.06246537f, 0.02811385f, -0.00096254f, 
    -0.01542653f, 0.07072313f, -0.15353471f, -0.03780547f, -0.24505487f, -0.08959412f, 0.19830237f, 0.20998503f, 
    0.08172652f, 0.06172040f, 0.06829331f, 0.03838270f, -0.17335351f, 0.04350291f, 0.17746866f, -0.02709699f, 
    0.13209239f, -0.26192722f, -0.24341588f, -0.01359945f, 0.12597701f, -0.08808764f, 0.05649735f, -0.00229802f, 
    0.01454273f, -0.11081619f, -0.13858522f, -0.09763261f, 0.09761452f, -0.00810735f, 0.13020958f, 0.18761078f, 
    0.00688048f, -0.02079175f, 0.06786419f, -0.13827606f, 0.07005689f, 0.25633898f, 0.02450177f, 0.22084665f, 
    -0.04523824f, -0.17066149f, 0.08887551f, 0.22756146f, 0.00599725f, 0.14913905f, -0.05448284f, -0.02538226f, 
    -0.01309342f, 0.05175998f, 0.03333453f, -0.02072196f, 0.05066470f, 0.15203364f, 0.10499628f, 0.19085056f, 
    0.16092551f, 0.01429363f, 0.09496466f, -0.06998709f, 0.02012139f, 0.06836016f, -0.11172199f, 0.11721998f, 
    0.02393790f, 0.28019896f, -0.04236564f, 0.20293608f, -0.18850707f, 0.10155543f, 0.09556463f, -0.11570243f, 
    0.09280596f, 0.14399926f, 0.09816447f, 0.11200661f, 0.11809012f, 0.13833453f, -0.01684925f, 0.09434697f, 
    0.00383983f, 0.09835835f, 0.02952816f, -0.03149910f, -0.00760485f, -0.05964794f, 0.10201740f, 0.07315711f, 
    0.07652786f, 0.38700920f, -0.17016563f, 0.11255123f, 0.04812799f, -0.09875440f, -0.14740755f, 0.01516355f, 
    0.09978779f, 0.09227382f, 0.13927297f, 0.06729922f, 0.14603887f, 0.75014395f, 0.20202447f, 0.53362203f, 
    -0.09010022f, 0.16563718f, 0.03888372f, -0.20820843f, -0.03815450f, 0.08839708f, -0.02377259f, 0.13993435f, 
    -0.32526836f, -0.05358026f, 0.23175018f, 0.07942955f, -0.17630491f, 0.19144036f, -0.23724091f, 0.00910375f, 
    -0.09681720f, -0.08211334f, -0.01698611f, -0.06302316f, -0.07297974f, -0.07885012f, 0.08643103f, -0.01064782f, 
    -0.00211419f, 0.04561360f, 0.11038177f, -0.12283770f, -0.14820983f, -0.13342963f, 0.04257482f, -0.05093958f, 
    -0.16245662f, -0.11454870f, -0.10385706f, -0.53623205f, -0.22980796f, -0.26128346f, -0.34336761f, -0.23897129f, 
    -0.12938361f, -0.02727432f, -0.01277569f, -0.00130219f, 0.08871701f, 0.02901708f, -0.12974672f, -0.01848726f, 
    0.04280552f, -0.07335962f, -0.19039169f, -0.04986317f, -0.21653250f, -0.11229142f, -0.17281646f, -0.01782210f, 
    -0.07271700f, -0.10259533f, 0.21992916f, 0.22543660f, -0.05796386f, -0.20929857f, -0.09822089f, -0.12165939f, 
    0.05322143f, 0.28253952f, 0.00532038f, 0.23428917f, -0.29722908f, 0.29347211f, -0.37672102f, 0.35493383f, 
    -0.12402411f, -0.11273818f, 0.03480762f, -0.14007804f, 0.04493391f, -0.01460823f, 0.07020880f, 0.10862778f, 
    -0.22450069f, 0.33947733f, -0.26724544f, -0.04264825f, -0.16407926f, -0.12225049f, 0.12551172f, -0.02900192f, 
    0.05146225f, 0.12881206f, 0.00437994f, -0.06415569f, 0.04989720f, -0.41389772f, -0.46503863f, -0.04815307f, 
    0.00368861f, 0.02423637f, -0.04993471f, 0.04564227f, 0.02368305f, -0.22673742f, -0.08093789f, 0.08005314f, 
    -0.05427570f, 0.29654157f, -0.16013813f, 0.11610337f, 0.00903974f, 0.16802487f, -0.26742634f, -0.16433907f, 
    -0.08280134f, -0.00658074f, -0.11458876f, -0.08454859f, 0.23103207f, -0.04725062f, 0.06188942f, 0.02924157f, 
    0.03578603f, -0.05643699f, 0.00878251f, 0.08585585f, 0.07183381f, 0.11349536f, 0.17266388f, 0.13600460f, 
    0.39116246f, 0.08709490f, -0.05729552f, -0.00307675f, -0.17621021f, 0.04930675f, -0.04062530f, -0.02188874f, 
    0.03943992f, 0.00921608f, -0.02095805f, 0.08966614f, 0.26556382f, 0.16692111f, 0.06955662f, 0.12296812f, 
    0.08226981f, -0.04190831f, -0.08722606f, -0.04557814f, -0.08579488f, -0.02812358f, 0.11504038f, 0.03854282f, 
    -0.03665879f, -0.09392267f, 0.23234025f, 0.02110754f, -0.03998054f, -0.01475828f, 0.00742177f, 0.15438528f, 
    -0.04249815f, 0.03690554f, 0.05927073f, -0.08622400f, -0.07783311f, 0.06487994f, 0.02382771f, -0.10561082f, 
    0.01076689f, 0.01607285f, 0.07318697f, -0.07331371f, 0.09688120f, 0.12637259f, -0.05609023f, 0.13355526f, 
    -0.15870255f, -0.05583628f, -0.04470129f, 0.16584618f, -0.03965170f, 0.08059042f, 0.01593767f, -0.08682823f, 
    0.09818508f, 0.04553949f, -0.03642664f, 0.22307043f, -0.20408928f, -0.10093717f, -0.04708945f, -0.01970943f, 
    0.11577748f, -0.02906648f, -0.09237070f, 0.11969226f, -0.09102067f, 0.04573110f, 0.03827969f, 0.01914505f, 
    0.15748169f, 0.06609731f, -0.23990425f, -0.09028815f, -0.05142067f, -0.17158583f, -0.06965763f, -0.17491639f, 
    -0.02693921f, -0.01564275f, -0.11178218f, -0.21635784f, 0.12425275f, 0.08719664f, 0.00793863f, 0.25009963f, 
    -0.08370394f, -0.16680647f, 0.01303591f, 0.17209120f, 0.02780455f, -0.01074172f, 0.00572044f, -0.08326662f, 
    0.03749553f, -0.22361106f, -0.14004239f, -0.02831983f, 0.04204300f, 0.07663531f, 0.08862866f, 0.11971716f, 
    0.00581202f, 0.16617011f, 0.17929462f, -0.01466422f, -0.00883867f, -0.11506316f, -0.08891718f, -0.13888280f, 
    -0.02000405f, 0.10285986f, 0.08398733f, -0.04409183f, -0.08379042f, -0.05967527f, 0.01802453f, -0.04916392f, 
    -0.02486922f, 0.26591611f, 0.04333680f, -0.04269828f, 0.00950815f, 0.09904630f, -0.06008904f, 0.01359565f, 
    0.22581634f, 0.07564071f, -0.04050984f, 0.21679769f, 0.27709174f, 0.06207064f, 0.17744692f, 0.05006284f, 
    0.03918082f, 0.01213035f, -0.11524840f, 0.00861224f, -0.10862803f, 0.02735960f, -0.08862913f, -0.00254965f, 
    -0.03154973f, -0.23463106f, 0.15418650f, 0.00691152f, -0.00018474f, -0.00348442f, -0.05875249f, 0.11488433f, 
    0.09379333f, -0.04505673f, -0.14683017f, 0.22049606f, 0.44447413f, 0.38717070f, 0.11197667f, 0.20506702f, 
    0.02031831f, -0.00423945f, 0.02108888f, 0.04915871f, -0.03487957f, -0.04785419f, -0.05385017f, -0.17139426f, 
    -0.07038987f, -0.05184085f, -0.01611121f, 0.04476387f, -0.05214132f, 0.03183777f, 0.02488701f, -0.03981001f, 
    -0.01713222f, 0.05409189f, 0.00983270f, 0.01417245f, 0.03917436f, -0.05882862f, -0.00657591f, 0.05041837f, 
    -0.07228084f, -0.06089614f, -0.01755394f, 0.05730352f, 0.01645524f, -0.08107834f, 0.01852051f, -0.05142966f, 
    -0.07408615f, 0.00634224f, -0.02581062f, 0.06242382f, 0.04227620f, 0.00313723f, -0.05980221f, 0.01106599f, 
    0.02580198f, -0.03704105f, 0.01780481f, 0.03340511f, 0.02000923f, 0.00550112f, -0.02823212f, -0.00728124f, 
    -0.04261943f, -0.02131669f, -0.02808354f, -0.01848540f, -0.03847381f, -0.06364889f, -0.05490552f, 0.02348872f, 
    0.05416771f, -0.03965775f, 0.00760771f, -0.04267138f, 0.00562286f, -0.00557623f, 0.00991883f, -0.04846340f, 
    0.01293370f, 0.05455808f, 0.02508522f, 0.05185745f, 0.02516022f, 0.05972922f, -0.04320928f, 0.01114742f, 
    -0.04810052f, -0.03713433f, 0.03804677f, 0.02223025f, 0.01874116f, -0.03119090f, -0.04948923f, -0.02876857f, 
    -0.05680754f, -0.03387044f, 0.02955874f, 0.03992518f, -0.01972799f, 0.03858189f, 0.03476207f, 0.04643267f, 
    0.05417935f, -0.05723067f, -0.02312632f, -0.07341455f, 0.03484613f, 0.05662885f, -0.03298147f, -0.02201825f, 
    0.03726484f, -0.04881109f, -0.04672043f, -0.06560153f, -0.05191092f, -0.07299856f, -0.02609953f, -0.00378256f, 
    -0.01641502f, 0.03668531f, -0.08371362f, 0.00433734f, -0.06905139f, -0.05395602f, -0.07465128f, -0.03346252f, 
    -0.04046260f, -0.02948022f, -0.04240355f, -0.01344784f, 0.05804430f, -0.04252194f, 0.01892456f, -0.01608364f, 
    -0.01934731f, 0.02642473f, 0.02362637f, 0.02773766f, 0.03701796f, 0.05294616f, 0.03698402f, -0.01049888f, 
    -0.00856243f, -0.07180180f, -0.05804683f, 0.02618755f, -0.07279082f, -0.05340485f, 0.06299647f, 0.01679055f, 
    0.03279991f, 0.03943184f, -0.00825691f, -0.04411013f, 0.04465258f, -0.03144886f, 0.06590813f, -0.06755197f, 
    -0.06610975f, -0.03974585f, -0.00063391f, 0.06541610f, 0.06202876f, -0.01671400f, 0.00365117f, 0.05726872f, 
    0.05657642f, -0.07529460f, -0.01963645f, -0.02821922f, -0.06239788f, 0.01513179f, 0.01224313f, -0.05226833f, 
    0.06111810f, 0.05540330f, -0.03557598f, -0.03564114f, -0.00463458f, -0.06347858f, 0.05686575f, 0.03719988f, 
    0.00133737f, -0.06548695f, 0.02263800f, -0.07956981f, -0.04878420f, -0.01449510f, -0.02598625f, 0.02539191f, 
    -0.06720722f, 0.02766056f, 0.05094644f, -0.06416093f, -0.03126952f, -0.08332940f, 0.05514306f, -0.05024260f, 
    -0.05084199f, 0.01502283f, -0.02938921f, 0.01419145f, -0.02218593f, -0.03826759f, 0.03710026f, -0.08221351f, 
    -0.02007210f, 0.00726473f, -0.00899623f, -0.06407065f, 0.03170283f, 0.05691988f, -0.03599387f, 0.04043796f, 
    0.01845708f, -0.09659230f, 0.19817638f, 0.09380159f, 0.09852457f, 0.05084611f, -0.06827330f, 0.02583302f, 
    -0.10113206f, -0.00684560f, 0.00809745f, -0.05813612f, -0.08258367f, 0.13523719f, 0.05221323f, 0.04561905f, 
    -0.13937131f, -0.03327800f, -0.16718398f, 0.00214891f, 0.03745592f, 0.07404511f, 0.00416490f, -0.03422951f, 
    -0.16792890f, 0.09131504f, 0.17677617f, 0.10953328f, -0.05317919f, -0.01664836f, -0.01271530f, 0.21133327f, 
    -0.16910711f, -0.21368413f, 0.02852031f, -0.05040191f, -0.05848990f, 0.25437441f, 0.16106142f, 0.07127815f, 
    -0.08720041f, -0.08576209f, 0.01914291f, 0.09131600f, 0.05074622f, -0.01548553f, -0.03357353f, 0.07573624f, 
    -0.04031283f, 0.13913397f, 0.23077685f, -0.02663470f, 0.03940481f, 0.05309927f, -0.00692607f, -0.01391501f, 
    0.14383900f, 0.00014373f, -0.04481681f, 0.07119170f, -0.38336375f, -0.01773610f, -0.08039501f, 0.17191449f, 
    -0.12999392f, -0.10407636f, -0.26423949f, -0.14932710f, -0.02561890f, -0.04418893f, 0.08547520f, -0.07153953f, 
    -0.11140137f, -0.26218811f, 0.15636951f, 0.08809015f, -0.05438071f, 0.10038686f, -0.10110074f, -0.05942385f, 
    0.08211981f, -0.17356268f, -0.11214329f, 0.03666811f, 0.39867151f, -0.14545995f, 0.25952291f, -0.18878254f, 
    -0.03569859f, -0.02883049f, -0.06895153f, -0.08599022f, 0.10629304f, 0.02296396f, 0.00269463f, 0.09316352f, 
    0.07280052f, 0.09365549f, -0.15321605f, 0.02055145f, 0.23868866f, 0.01941070f, 0.16539603f, -0.04275975f, 
    0.04688396f, 0.04277350f, 0.08454034f, 0.03410674f, -0.00854160f, 0.18377492f, 0.18265028f, 0.10035758f, 
    -0.00957084f, -0.06273287f, -0.00991332f, 0.02003867f, -0.03492867f, -0.00963173f, 0.03101841f, -0.03865664f, 
    0.09850620f, -0.06729654f, -0.06538201f, 0.05596311f, -0.04945026f, -0.01583451f, -0.00149636f, -0.07351840f, 
    0.18864740f, 0.10933371f, -0.04358656f, -0.00203887f, 0.15683644f, 0.08042713f, 0.02948373f, -0.03273521f, 
    0.05460389f, 0.05861636f, 0.03775024f, -0.01446172f, 0.11502077f, 0.16309267f, 0.04243853f, 0.01555613f, 
    0.01800225f, 0.10811710f, -0.27540025f, -0.23573025f, 0.02894741f, -0.10030941f, 0.03459008f, -0.11061797f, 
    -0.10053296f, -0.22779809f, 0.04248366f, 0.01858618f, 0.18691079f, -0.21447557f, 0.09574360f, -0.12226275f, 
    0.11033191f, 0.12392891f, -0.02835648f, 0.02263322f, 0.03735046f, -0.02446519f, 0.06220008f, 0.07916153f, 
    0.08570576f, -0.28903154f, 0.11673173f, -0.02529929f, -0.03519918f, 0.14811440f, -0.04594098f, -0.05372097f, 
    0.00849603f, -0.07020850f, 0.03960954f, 0.04030895f, -0.10231250f, 0.02276297f, 0.07855261f, 0.20730089f, 
    -0.16372289f, 0.08935320f, 0.08646031f, 0.06142483f, -0.13251315f, -0.06334398f, -0.03982085f, -0.00412867f, 
    0.33305734f, 0.02527126f, 0.17790349f, -0.12046540f, 0.06333847f, 0.01737530f, 0.05072241f, -0.08215929f, 
    -0.11074901f, 0.03630750f, -0.11519144f, 0.01166487f, -0.13494065f, -0.12778856f, -0.26415312f, 0.13033026f, 
    0.04425109f, 0.14421952f, 0.21161242f, 0.08976186f, 0.03293971f, -0.08895127f, 0.05870038f, 0.18463968f, 
    0.14307398f, -0.22346498f, -0.17472705f, -0.04955976f, -0.02032564f, 0.12872277f, -0.02955883f, -0.03527512f, 
    -0.05080460f, -0.04459201f, -0.18286584f, 0.08641206f, 0.50815433f, -0.06961327f, 0.04594026f, 0.01214740f, 
    -0.06191562f, 0.07374552f, 0.11142482f, 0.20724803f, 0.15015246f, -0.01708522f, 0.01416139f, -0.00580223f, 
    0.34377071f, 0.07007702f, -0.28212553f, 0.35299984f, -0.03044929f, 0.01553711f, -0.07879127f, -0.01054314f, 
    0.02002302f, 0.10441200f, 0.01633504f, -0.05564884f, 0.37945116f, -0.03398724f, -0.08376928f, 0.00054149f, 
    0.08815566f, 0.14355853f, 0.29497743f, 0.18519132f, 0.00703843f, -0.08642339f, 0.06768698f, 0.14307293f, 
    0.09263013f, -0.10964537f, -0.05809242f, -0.18071267f, -0.12547308f, -0.17456430f, 0.04075618f, 0.07021637f, 
    0.16232453f, 0.16615348f, 0.10844627f, 0.15208286f, -0.30020678f, 0.17520684f, -0.27743295f, 0.02428571f, 
    -0.07418337f, -0.02785147f, 0.20688671f, 0.00193946f, 0.10386469f, 0.03116098f, 0.05555150f, 0.03511821f, 
    -0.20502982f, 0.03098341f, 0.04083528f, 0.01987933f, -0.08990289f, 0.00133220f, 0.18866755f, -0.00090728f, 
    -0.03221977f, -0.11150078f, 0.05860792f, -0.04582089f, 0.08919737f, 0.02880954f, -0.20503487f, -0.07344973f, 
    0.01798140f, -0.01727463f, -0.09544325f, -0.09566762f, 0.01119283f, 0.06433091f, 0.00450297f, 0.00362520f, 
    -0.19046856f, 0.06766432f, -0.01825922f, -0.02206538f, -0.10728944f, -0.08325443f, -0.06828711f, 0.04801488f, 
    -0.08480651f, -0.00758190f, -0.12948552f, -0.00346854f, -0.07555782f, 0.10111136f, 0.00501047f, -0.05854040f, 
    0.04916194f, -0.16206555f, -0.00614347f, -0.08112619f, 0.02907532f, -0.09780923f, -0.06239105f, -0.01450979f, 
    -0.18624356f, -0.01080167f, -0.21369390f, 0.17872246f, 0.00891667f, -0.09959014f, 0.16186836f, -0.03366722f, 
    0.26521501f, 0.12348004f, 0.17103308f, 0.15076658f, -0.11330600f, -0.17004320f, 0.21622239f, 0.19716044f, 
    0.24624778f, -0.11539224f, 0.07656734f, 0.02260990f, 0.03482958f, -0.02144984f, -0.12428493f, -0.18148306f, 
    -0.00185375f, 0.09321425f, 0.06407229f, -0.07017035f, 0.11767194f, 0.04832605f, 0.02020826f, -0.05951189f, 
    0.29332513f, 0.15899006f, 0.11212409f, 0.07332762f, 0.15844347f, -0.00607065f, 0.30874333f, -0.11912124f, 
    0.21056636f, 0.13615249f, 0.00032690f, -0.08370353f, -0.04847338f, -0.04190371f, -0.23259000f, -0.06933357f, 
    -0.12329898f, -0.10896412f, -0.05278169f, 0.05021369f, 0.23765622f, 0.05805493f, 0.16198577f, 0.05574503f, 
    -0.04528134f, 0.05479128f, -0.00548244f, -0.02685417f, 0.06952872f, -0.11274493f, 0.07600309f, 0.08772134f, 
    0.03946081f, -0.02614526f, -0.04066541f, -0.01778858f, 0.04723117f, 0.06495749f, 0.05735663f, 0.03670583f, 
    -0.20004675f, -0.12713930f, 0.14079550f, 0.23908290f, -0.02758805f, -0.04106085f, -0.13386142f, -0.08189679f, 
    -0.01198462f, -0.06888939f, -0.07051313f, 0.01657270f, -0.12858516f, 0.05985462f, -0.02148449f, 0.06614006f, 
    0.04606301f, -0.11764961f, -0.08597978f, -0.01713210f, -0.08103959f, 0.10499974f, 0.05324642f, 0.08005935f, 
    -0.27047059f, 0.12466130f, 0.05146950f, 0.08122484f, -0.01332508f, -0.00517663f, 0.07839312f, -0.02781466f, 
    0.09809715f, 0.04953622f, 0.03273094f, 0.05821848f, -0.01490393f, 0.00332658f, -0.07561827f, 0.06542660f, 
    -0.02963561f, 0.07703786f, 0.02120347f, -0.19751425f, 0.08418043f, 0.12758285f, -0.03957683f, 0.00172778f, 
    -0.12237521f, 0.40065473f, 0.00345093f, -0.01883792f, -0.01194793f, -0.01867751f, -0.07843544f, 0.02307521f, 
    0.03699428f, -0.06169010f, 0.10736658f, -0.08688145f, 0.01949242f, 0.29262698f, 0.21403059f, 0.10539961f, 
    -0.03620766f, -0.02180897f, -0.05806619f, 0.00429573f, 0.00063000f, 0.07675417f, -0.01669806f, 0.09027065f, 
    0.23312956f, -0.13273732f, -0.03429904f, 0.10715631f, 0.15077393f, 0.16551469f, -0.02336017f, 0.13045226f, 
    0.03238996f, 0.00028535f, -0.00637854f, -0.04135738f, -0.18311667f, 0.01221476f, 0.04747916f, 0.13440736f, 
    0.00526247f, 0.13254172f, -0.00505531f, -0.01107822f, -0.02098930f, -0.01049959f, -0.03188661f, -0.01678768f, 
    0.12329504f, 0.06460666f, -0.00765138f, -0.12690055f, -0.05724962f, -0.15309046f, -0.12069663f, -0.03995666f, 
    -0.03233339f, 0.05429295f, -0.00455476f, -0.11348002f, 0.13751988f, 0.00063935f, 0.07372251f, -0.10010481f, 
    -0.03490029f, -0.02306429f, -0.12764591f, -0.00378623f, 0.10457840f, -0.02609857f, 0.06986625f, 0.01909868f, 
    0.14742513f, 0.07278769f, 0.15214470f, -0.12112417f, -0.01437695f, -0.10365129f, -0.10179923f, -0.09414365f, 
    0.03117443f, 0.12719065f, -0.05775430f, -0.06482156f, 0.03672487f, 0.38322082f, -0.04747509f, 0.28624463f, 
    -0.08797467f, 0.05942774f, 0.08303057f, 0.06169994f, -0.05875688f, 0.00231623f, -0.00844871f, 0.09176713f, 
    -0.17893386f, 0.23525269f, -0.16469303f, 0.08292937f, -0.12787554f, -0.05756385f, -0.04617021f, -0.01148576f, 
    -0.03047951f, 0.03298759f, -0.03413719f, 0.05232900f, -0.15997061f, -0.15778629f, -0.00767493f, 0.22331843f, 
    0.03911771f, 0.07888113f, -0.00043353f, 0.07865573f, -0.14314297f, -0.02577577f, -0.04887094f, 0.00333239f, 
    -0.03748964f, -0.21338315f, 0.06734359f, 0.07680240f, 0.18909279f, 0.07594587f, 0.15182433f, 0.09294124f, 
    0.06265849f, 0.07150463f, 0.12767802f, 0.06974549f, 0.12426765f, 0.00222151f, 0.10706509f, 0.10763520f, 
    0.10946748f, 0.01980285f, -0.08118707f, 0.00299933f, 0.00559768f, 0.10627519f, -0.00347039f, 0.06324818f, 
    -0.04498447f, 0.12544958f, 0.15473470f, 0.19065428f, -0.01134529f, 0.04944078f, -0.09972360f, 0.14606510f, 
    -0.06622545f, -0.09980540f, -0.00249807f, -0.05737823f, 0.12772390f, 0.05313316f, -0.06434796f, 0.03247589f, 
    0.06616219f, -0.01868320f, -0.04538777f, -0.09211286f, -0.08374000f, 0.07055231f, 0.14465924f, -0.03613257f, 
    -0.34521413f, -0.10716571f, 0.02676398f, -0.10127535f, -0.06201098f, 0.02658461f, 0.16874380f, 0.03915218f, 
    0.00170653f, -0.03761271f, 0.02146166f, 0.15766633f, 0.03551312f, -0.02408055f, -0.04452524f, -0.00351378f, 
    0.03161583f, 0.17871192f, -0.12421321f, 0.00191655f, 0.04667961f, 0.03618694f, 0.00241291f, -0.12668915f, 
    -0.05470678f, 0.39640623f, 0.11761341f, 0.11867964f, -0.01875121f, 0.02866942f, -0.00781493f, 0.05049307f, 
    0.13337256f, 0.02791667f, 0.10466619f, -0.14389159f, 0.28824502f, 0.13107778f, 0.25401515f, -0.00671230f, 
    -0.05940817f, 0.02826689f, 0.00904308f, 0.00433888f, -0.05463168f, 0.11402011f, 0.07000364f, -0.03374367f, 
    0.02369582f, -0.01632367f, 0.09492432f, 0.01784069f, 0.22253369f, -0.07810665f, -0.04430654f, -0.08061606f, 
    -0.00769406f, 0.11179244f, 0.04788962f, -0.01999954f, -0.20033501f, -0.12296115f, 0.09506787f, -0.04254755f, 
    0.08364233f, 0.05925916f, 0.02523366f, 0.04201083f, -0.08879813f, 0.06110591f, 0.05934063f, 0.02932279f, 
    0.12999427f, 0.04600810f, 0.08850304f, -0.12280820f, -0.07549114f, -0.03099504f, -0.10476914f, 0.01319107f, 
    0.01839994f, 0.02035016f, 0.11256673f, -0.00986772f, 0.16602176f, 0.12274908f, 0.03979323f, 0.05546174f, 
    -0.07904591f, -0.06827251f, -0.06701046f, -0.06577890f, 0.08525311f, -0.00677569f, -0.05806649f, 0.00794864f, 
    -0.01653426f, -0.04730688f, 0.13565658f, -0.14705087f, -0.05237041f, -0.08445719f, -0.04505582f, -0.07633019f, 
    0.00290708f, 0.13705136f, -0.09995877f, 0.10803754f, 0.04861323f, 0.34761578f, -0.10431158f, 0.05297627f, 
    -0.28347844f, -0.00637648f, 0.09029968f, 0.03354085f, -0.06123304f, 0.06991338f, 0.01668438f, 0.02559161f, 
    -0.27679765f, 0.28136438f, -0.14276309f, -0.00975559f, 0.01514968f, 0.05723428f, -0.01877897f, 0.06856125f, 
    -0.05965377f, 0.08906251f, -0.10635992f, 0.07847951f, -0.23977427f, -0.29004723f, -0.17952198f, 0.02611174f, 
    0.00086442f, -0.10199773f, -0.09507737f, 0.25131184f, -0.11555687f, -0.14624919f, 0.09965373f, -0.01105847f, 
    -0.07109002f, 0.27114782f, -0.01283528f, -0.08935270f, -0.09188005f, 0.08691160f, -0.01777330f, -0.00215296f, 
    -0.05690336f, -0.00475932f, -0.02126991f, -0.07556549f, -0.02746219f, 0.26930141f, 0.09296864f, 0.02839557f, 
    0.06122678f, 0.01252488f, 0.13879055f, 0.09795140f, 0.02622973f, 0.01517370f, 0.15086587f, 0.11987502f, 
    0.13530491f, 0.14212942f, 0.16281067f, -0.16144383f, 0.10100601f, 0.00483709f, 0.21302600f, 0.02300481f, 
    0.10929810f, -0.09918577f, 0.04456938f, -0.03238748f, -0.09267514f, -0.08561026f, 0.04904876f, 0.07346286f, 
    -0.00076707f, 0.09736390f, -0.05893332f, 0.03847077f, 0.16359265f, -0.15615596f, -0.05390237f, 0.08203419f, 
    0.23995399f, -0.13698420f, -0.00734216f, -0.04417980f, 0.05413999f, 0.02869029f, -0.07924593f, 0.01423322f, 
    -0.01252574f, -0.01085384f, 0.14993699f, -0.07789382f, 0.08261511f, -0.02430355f, 0.14694096f, 0.12483897f, 
    0.00068667f, 0.03178759f, 0.06890055f, 0.11130644f, 0.02047562f, 0.04695965f, 0.05799999f, 0.25756097f, 
    -0.01022157f, -0.51013291f, -0.04934122f, -0.07907382f, -0.08808284f, -0.11680982f, 0.15119551f, 0.02674860f, 
    -0.02241009f, 0.06264532f, -0.06043895f, 0.21696161f, -0.10072660f, -0.69309789f, -0.32252634f, -0.39693099f, 
    -0.04237913f, -0.01154478f, -0.07382005f, 0.04282077f, 0.10116530f, -0.06203499f, 0.14423697f, -0.00829311f, 
    0.19009417f, 0.06847239f, 0.10878470f, -0.03394130f, -0.05008727f, -0.20059884f, -0.16165222f, 0.05491924f, 
    -0.04938887f, 0.04993892f, 0.04077200f, 0.02884264f, 0.27931425f, 0.17283158f, 0.18414575f, 0.00073928f, 
    -0.01548230f, -0.10114341f, 0.15409717f, 0.06924386f, 0.07162035f, 0.09372180f, -0.06348554f, 0.06080056f, 
    0.14179252f, -0.44133836f, -0.31786069f, 0.32019594f, 0.06968160f, 0.00724747f, -0.00648184f, -0.00182385f, 
    0.18385263f, 0.10616715f, -0.06027881f, -0.03098988f, -0.29214445f, -0.45829672f, -0.44092917f, -0.07656062f, 
    0.02087356f, -0.14221488f, 0.02759418f, -0.04130803f, 0.13692299f, -0.01029313f, 0.05249791f, 0.00526598f, 
    -0.10619102f, -0.04297950f, -0.14613529f, -0.02217579f, -0.04193748f, 0.10584803f, -0.05402691f, 0.04517398f, 
    0.13162525f, -0.02939851f, 0.18629915f, -0.01505194f, 0.52376485f, -0.32178533f, 0.06259613f, -0.18065739f, 
    0.01784045f, 0.09421831f, 0.03501895f, 0.08405416f, 0.05764851f, -0.09186316f, -0.13451333f, -0.10998278f, 
    0.30374879f, -0.54272884f, 0.35977769f, 0.08396516f, -0.02256336f, -0.05101226f, 0.02511258f, 0.01180832f, 
    0.01329644f, -0.11635728f, 0.19149525f, 0.19819660f, 0.12356380f, 0.15219170f, 0.14886592f, -0.09753744f, 
    0.04460491f, 0.01294933f, 0.08949589f, -0.15474615f, -0.02981135f, -0.02552424f, -0.10171144f, -0.04493978f, 
    -0.04508458f, 0.05124105f, -0.03668497f, 0.04649020f, 0.00556124f, -0.09458388f, 0.19452700f, 0.01307338f, 
    -0.04584260f, 0.02353395f, 0.00010992f, -0.06003309f, -0.02569526f, 0.19070165f, 0.08163630f, 0.01450467f, 
    -0.01414214f, 0.01293832f, 0.03156659f, -0.06154750f, -0.11498119f, 0.09205459f, 0.07454505f, -0.08736942f, 
    0.25641322f, 0.13397381f, 0.18699062f, -0.04062894f, 0.13042682f, 0.10491920f, 0.09476825f, 0.01540259f, 
    -0.12356718f, -0.06258824f, 0.00445479f, -0.04623416f, -0.21634938f, -0.00741069f, -0.24625991f, -0.13033669f, 
    0.02401149f, 0.10491199f, 0.03432320f, 0.09067771f, 0.09081110f, -0.06586103f, 0.01869108f, -0.16013460f, 
    -0.06696050f, -0.22679348f, -0.06079705f, -0.14828226f, -0.01682169f, 0.08900379f, 0.01127348f, 0.12131918f, 
    0.10196739f, 0.06063285f, 0.13246760f, -0.08493621f, 0.19213356f, 0.08314577f, 0.03760365f, -0.03712178f, 
    0.10794796f, 0.04839615f, 0.33505791f, -0.00313736f, 0.10616063f, 0.07485233f, 0.08994200f, -0.00396271f, 
    0.16569264f, -0.05757912f, -0.11038634f, -0.18977444f, -0.08021369f, 0.00924494f, 0.03396741f, -0.01197161f, 
    0.02437331f, 0.05478951f, 0.16804492f, 0.02936605f, 0.15653215f, -0.37110296f, -0.11672778f, 0.06767607f, 
    -0.01243111f, 0.13174023f, 0.13333870f, -0.00530287f, 0.19865477f, 0.00695700f, -0.04367656f, -0.14431505f, 
    0.09433305f, -0.09554399f, 0.35686734f, -0.00046991f, 0.28488305f, 0.10979807f, -0.20417497f, -0.01352940f, 
    -0.05386659f, -0.03579203f, 0.06739438f, 0.12945302f, 0.07148054f, -0.09869915f, 0.19562003f, -0.19070069f, 
    0.07671898f, -0.01238825f, 0.17503747f, -0.00171411f, 0.09255964f, -0.05769769f, -0.04436104f, 0.13402018f, 
    -0.09381299f, 0.06981651f, 0.01693300f, -0.03110620f, 0.07399973f, 0.04136244f, -0.07581288f, -0.02137732f, 
    0.01523058f, -0.02770033f, 0.06894417f, 0.00650895f, -0.18080558f, -0.07304516f, 0.01804370f, 0.00586503f, 
    0.05112861f, 0.06560023f, -0.01152838f, -0.05945329f, -0.05519679f, 0.01495234f, 0.04146808f, 0.25359628f, 
    -0.22012985f, -0.18624467f, 0.05061809f, -0.02475118f, 0.09313071f, 0.06643770f, -0.18605798f, 0.05712211f, 
    0.01808262f, 0.08073424f, 0.06110093f, -0.02986955f, 0.22869146f, 0.33385214f, -0.15685362f, -0.04644221f, 
    -0.29590321f, -0.04834173f, 0.10131027f, -0.04124446f, -0.05721489f, 0.09840996f, -0.06369901f, 0.04523803f, 
    0.20627223f, -0.06035269f, 0.04154928f, -0.10817491f, -0.04434305f, -0.05434503f, 0.10641917f, -0.09378521f, 
    0.03789541f, 0.05485529f, 0.08727367f, 0.12911034f, 0.14319375f, -0.11324787f, -0.29193717f, -0.11454593f, 
    -0.03106743f, 0.07484912f, -0.04328057f, 0.23946998f, 0.03627389f, -0.03870305f, -0.14348967f, 0.04889156f, 
    0.15911739f, 0.01918243f, -0.13646607f, 0.01324599f, 0.00088162f, 0.07421122f, 0.26638499f, -0.07790845f, 
    0.01863341f, 0.10084125f, 0.13105309f, 0.01331666f, 0.24410065f, -0.22838113f, 0.03861734f, 0.15029880f, 
    0.07655719f, -0.04195132f, -0.03394545f, 0.06478755f, -0.10404035f, -0.01471255f, -0.05419033f, -0.06131824f, 
    0.01112552f, -0.09778903f, -0.07111423f, 0.29715487f, 0.04955975f, -0.09923424f, -0.01961006f, -0.05778550f, 
    -0.08856627f, 0.06402384f, 0.03134796f, 0.12689985f, 0.11095185f, -0.04026803f, -0.30701745f, -0.04354968f, 
    -0.01881655f, 0.02448813f, 0.04743041f, 0.08668279f, -0.01471868f, 0.02914976f, 0.04635003f, 0.09799580f, 
    -0.26353860f, 0.02003092f, 0.02592689f, 0.43468690f, -0.02869759f, 0.11085057f, 0.12428825f, 0.05875997f, 
    -0.03314777f, 0.02472766f, -0.07552811f, 0.17344314f, 0.17148420f, 0.02707235f, -0.16537614f, -0.22204266f, 
    0.14994946f, 0.15713286f, 0.05553764f, 0.10172227f, -0.14925100f, 0.05493721f, -0.10381864f, -0.12049787f, 
    -0.10276355f, 0.27950281f, -0.08106523f, -0.15922676f, -0.04705202f, 0.03698613f, -0.11803810f, 0.04967472f, 
    -0.01197194f, 0.00060529f, 0.07621392f, -0.13292125f, -0.40724358f, -0.00781119f, -0.12588303f, 0.17996517f, 
    0.03052439f, 0.01268885f, -0.04981768f, 0.16757631f, 0.00034136f, 0.07422632f, 0.04255085f, -0.02594818f, 
    -0.11298975f, -0.01662946f, -0.08502504f, -0.00847568f, -0.12215057f, 0.08128110f, 0.07884717f, -0.05234694f, 
    0.04446998f, -0.01834899f, -0.04576040f, -0.05681781f, -0.18169214f, 0.05091222f, -0.00661075f, 0.24583857f, 
    -0.04906075f, 0.14044666f, 0.05549634f, 0.05438586f, 0.08296426f, 0.08108342f, 0.05668277f, 0.11701821f, 
    -0.22642165f, 0.05860993f, 0.09544478f, -0.07596456f, -0.19632369f, -0.11171761f, -0.20083745f, -0.14894903f, 
    -0.02414489f, -0.05290230f, -0.11464631f, -0.01982239f, -0.22758162f, 0.06611350f, 0.20974110f, -0.15124986f, 
    -0.08494677f, -0.15275900f, -0.14133593f, 0.00159899f, 0.00159904f, -0.04110363f, -0.02071917f, 0.02677062f, 
    0.01521889f, 0.18460594f, 0.11330840f, 0.04633153f, -0.11558035f, -0.00975365f, 0.00325749f, 0.03628318f, 
    0.03685014f, 0.07318702f, -0.09179370f, -0.10215826f, -0.13436858f, 0.39326859f, 0.05414377f, 0.33914527f, 
    -0.06934214f, 0.09396104f, 0.03812820f, 0.10780598f, 0.07252879f, -0.01533736f, 0.12724544f, 0.05105072f, 
    -0.03045069f, 0.15191312f, -0.17818657f, -0.00193195f, 0.01723855f, 0.10344823f, -0.00831707f, 0.06301434f, 
    0.13181123f, -0.01573505f, -0.00464406f, 0.00805430f, -0.10585927f, 0.15222399f, 0.10418236f, 0.12417601f, 
    0.20779558f, 0.20051190f, 0.11091596f, 0.04708527f, 0.06765710f, 0.10768347f, 0.06746515f, 0.11533032f, 
    -0.15405481f, -0.04266444f, 0.14184758f, 0.09128535f, 0.12228213f, 0.11779524f, -0.08681882f, 0.32683021f, 
    -0.04274775f, 0.06164509f, -0.04566209f, 0.03115104f, -0.06065377f, -0.11860220f, -0.06231258f, -0.02087942f, 
    -0.03026850f, 0.05994486f, 0.09044206f, 0.18514523f, 0.03320117f, 0.11102591f, 0.12287366f, 0.14951761f, 
    -0.10681175f, -0.25856200f, -0.32998773f, -0.22767174f, -0.02415225f, 0.07168053f, 0.06386378f, 0.03629667f, 
    0.03007504f, 0.07057241f, -0.05164619f, -0.01680819f, 0.14980438f, -0.01498084f, 0.16726208f, 0.10953104f, 
    0.04388813f, -0.18497463f, -0.05824086f, -0.05025267f, -0.05608256f, 0.12083035f, 0.31401801f, -0.13282803f, 
    0.11902980f, 0.12989734f, -0.08289655f, -0.17705883f, -0.01699489f, -0.00852697f, -0.10989613f, 0.12845650f, 
    -0.04826372f, 0.02432831f, 0.08745549f, 0.18089044f, 0.08276814f, 0.06232111f, -0.09802148f, 0.02604837f, 
    -0.08860090f, 0.03149634f, -0.13050340f, -0.00107998f, 0.22258657f, 0.18146831f, 0.17207471f, 0.13830025f, 
    -0.06646998f, 0.06577468f, 0.08059438f, 0.11754474f, 0.06951766f, 0.02630420f, 0.02222837f, -0.07856558f, 
    0.08276571f, 0.05396419f, 0.06931072f, 0.07263228f, -0.15746114f, 0.19884917f, 0.22037277f, 0.04109557f, 
    -0.03052348f, -0.10632735f, -0.11164917f, 0.07483525f, 0.00843521f, 0.16140731f, 0.12801695f, 0.19156732f, 
    0.45281467f, 0.05191972f, -0.18534757f, 0.00364656f, 0.04525917f, 0.13600919f, -0.05342197f, 0.09860229f, 
    0.05519552f, 0.06855079f, 0.01382765f, -0.01744544f, -0.26315206f, -0.27242506f, -0.17893484f, -0.11283412f, 
    -0.09916248f, -0.02837819f, 0.09741968f, -0.13560459f, -0.05832356f, -0.01130075f, 0.03560002f, -0.03586828f, 
    0.03738583f, 0.06481968f, -0.01471924f, -0.08097324f, 0.02181770f, 0.06125034f, 0.06966329f, 0.09871106f, 
    -0.06389234f, -0.03777506f, -0.04678752f, -0.07999729f, 0.06350913f, 0.03825935f, -0.08838390f, -0.00107123f, 
    0.05800881f, -0.06363816f, 0.07990625f, -0.11640859f, 0.10428417f, -0.05458265f, 0.09663204f, -0.09182940f, 
    0.04496686f, 0.06773469f, 0.07442757f, -0.02454513f, -0.07343804f, 0.05997324f, 0.01140180f, 0.05617154f, 
    0.03905129f, -0.08061947f, 0.10625160f, 0.15607090f, -0.10589404f, -0.13820094f, -0.04514172f, 0.01729079f, 
    0.10565159f, 0.01533434f, 0.02943653f, 0.11219751f, 0.05862076f, 0.03234275f, -0.03969325f, -0.06629007f, 
    0.02125359f, 0.10859868f, 0.05299470f, -0.01477762f, 0.11840561f, 0.05337803f, -0.00884914f, -0.00800747f, 
    0.05636501f, -0.04064666f, -0.17756912f, 0.06858883f, -0.35736924f, -0.18089944f, -0.05913844f, 0.19550046f, 
    0.05093351f, -0.12626684f, -0.06279843f, 0.01910506f, -0.12659109f, -0.00285502f, 0.00407019f, -0.07266705f, 
    -0.24183470f, -0.06143397f, 0.07511318f, -0.08753384f, 0.05634842f, 0.10425207f, -0.00354204f, 0.19449975f, 
    0.00804478f, 0.01550266f, -0.05972771f, 0.04293089f, -0.14224997f, -0.03372538f, -0.03227150f, -0.14485556f, 
    0.00189121f, -0.14149579f, 0.12818284f, 0.02113407f, 0.11878707f, -0.02222064f, 0.03820085f, -0.10742144f, 
    -0.34598428f, 0.06839578f, 0.10549233f, -0.04934602f, 0.06309132f, -0.03532275f, 0.09228339f, -0.04115007f, 
    0.01817137f, -0.00069794f, 0.03579158f, -0.06465678f, -0.37550712f, 0.21312808f, 0.29941472f, 0.13474606f, 
    -0.17820613f, -0.09245527f, -0.11362578f, 0.05930103f, 0.00049053f, -0.08493897f, -0.04497212f, 0.06072946f, 
    0.10053778f, 0.17911568f, 0.17401834f, -0.28248572f, -0.02843053f, -0.06637657f, 0.02200499f, 0.02319549f, 
    0.00484997f, 0.02447002f, 0.09643938f, -0.02828982f, -0.27825883f, -0.19351186f, 0.06657317f, 0.21208502f, 
    -0.09562351f, -0.09466141f, 0.00571888f, 0.03947126f, 0.11799838f, -0.06240340f, 0.12999600f, -0.05352034f, 
    0.02808405f, -0.11363495f, 0.20108341f, 0.01365979f, -0.03996567f, -0.04508443f, -0.08210363f, -0.00206305f, 
    0.02504892f, -0.01155802f, -0.07836714f, -0.05062632f, 0.09060615f, 0.07337286f, 0.20909554f, -0.17360353f, 
    0.00702751f, -0.14968327f, -0.17218325f, -0.01814336f, 0.07451445f, 0.04971047f, -0.00080844f, -0.03522416f, 
    0.44968459f, -0.07660546f, -0.24973565f, 0.22625563f, 0.17487848f, 0.09030254f, 0.01133905f, 0.13616464f, 
    0.07091978f, 0.05214661f, -0.00769324f, 0.08735284f, 0.06126311f, 0.10599811f, 0.09701588f, 0.07814787f, 
    0.00678129f, 0.02595576f, 0.06819548f, 0.00608934f, 0.14228967f, 0.08331250f, 0.03574866f, 0.06313935f, 
    0.11552940f, -0.14854106f, -0.14613688f, -0.00758634f, -0.05433269f, -0.09420708f, -0.00015784f, -0.04708271f, 
    0.13078070f, -0.01192134f, -0.07703590f, -0.00055052f, 0.10837922f, -0.05243091f, -0.02051284f, 0.02242192f, 
    0.01953845f, 0.03174360f, 0.05214851f, -0.08547030f, 0.04820941f, 0.02679626f, 0.02816918f, 0.15019573f, 
    0.21058196f, 0.02724795f, -0.10250624f, -0.27038655f, -0.03839998f, 0.05950328f, 0.03410289f, 0.12157218f, 
    -0.00943101f, -0.03063031f, 0.04798394f, -0.15665109f, 0.26658678f, -0.19338937f, -0.00775069f, -0.14400336f, 
    0.16087341f, 0.10084498f, -0.00147825f, 0.02969836f, 0.05893461f, -0.05505713f, -0.01297546f, 0.00022089f, 
    0.16460539f, -0.26161236f, 0.00750551f, 0.20262699f, -0.05371399f, -0.00440923f, -0.07542528f, 0.11495546f, 
    -0.00278834f, 0.10403303f, 0.18594477f, 0.04443527f, -0.22260520f, -0.06784270f, 0.09207156f, 0.09237167f, 
    -0.04122164f, 0.01384928f, 0.04869789f, -0.13872564f, 0.02055744f, -0.01425080f, -0.09916490f, 0.04971723f, 
    0.01229723f, -0.03640175f, -0.11064599f, 0.02254690f, 0.21477923f, 0.15408997f, -0.02795569f, 0.00621748f, 
    -0.05014670f, 0.10554247f, -0.02596100f, -0.12935278f, -0.05508893f, -0.10349901f, 0.04401433f, 0.14292902f, 
    -0.01206792f, -0.07335533f, 0.01465470f, -0.02623797f, 0.07501389f, 0.00061814f, 0.09924354f, 0.18762308f, 
    -0.16528584f, -0.20599155f, 0.13333161f, 0.39018494f, -0.15372010f, -0.07466234f, -0.14598210f, -0.09377303f, 
    -0.03113740f, -0.01940103f, -0.09788790f, 0.00570976f, 0.11768624f, 0.04633037f, -0.06011908f, 0.09866549f, 
    0.13929065f, 0.03379647f, -0.02424784f, -0.00043050f, 0.06107370f, 0.14720412f, -0.06891765f, 0.12053176f, 
    -0.23219346f, 0.04451611f, 0.16400701f, 0.32719246f, -0.09066027f, 0.05433061f, -0.10948159f, -0.11745448f, 
    0.03116927f, 0.18525715f, 0.05923798f, 0.10225048f, 0.03322621f, -0.04930205f, -0.26137993f, -0.04843865f, 
    -0.06738181f, 0.01981315f, 0.08731619f, -0.26781911f, -0.10921770f, 0.06761975f, -0.06471474f, 0.06867933f, 
    -0.23669206f, 0.32909095f, -0.20196649f, -0.08542323f, 0.04998467f, 0.00401867f, -0.04997754f, 0.05226589f, 
    0.06978062f, -0.00429424f, -0.06105617f, 0.01376901f, -0.19461359f, 0.27758336f, 0.34732988f, 0.26596490f, 
    0.05635840f, 0.07379062f, -0.00114269f, -0.00713578f, 0.02624013f, 0.02394145f, 0.07750894f, 0.10577787f, 
    -0.01017067f, -0.11460518f, 0.11523347f, -0.03499242f, -0.07168778f, 0.18373929f, -0.11678404f, 0.16102336f, 
    0.07681010f, -0.00967250f, -0.06576779f, 0.02900031f, -0.18429728f, 0.08706581f, 0.00156604f, 0.25668874f, 
    -0.15958901f, 0.07235973f, 0.07600451f, 0.02083476f, -0.08802024f, -0.05888467f, -0.09305366f, -0.14405602f, 
    0.01933608f, 0.03656993f, 0.07269062f, -0.08410485f, 0.00389791f, -0.10608850f, 0.03505453f, 0.08815143f, 
    0.01222104f, 0.05632121f, 0.12611663f, -0.04005553f, 0.00047950f, 0.10527786f, 0.13456427f, -0.12011325f, 
    0.00827559f, 0.01187310f, -0.05233725f, 0.09868345f, -0.00955872f, 0.01859587f, -0.06785203f, -0.08585060f, 
    0.06376805f, 0.15977544f, 0.15926385f, -0.18605363f, -0.03727454f, -0.19375639f, -0.10499460f, -0.17527819f, 
    0.00441769f, 0.22456937f, -0.04753799f, 0.15757436f, -0.05173391f, 0.46622580f, -0.06050001f, 0.20952709f, 
    0.01919183f, -0.00653662f, -0.02470390f, 0.02009112f, -0.05055925f, 0.05632811f, 0.11005729f, -0.11363564f, 
    -0.16536675f, 0.06441241f, -0.08268686f, -0.00053477f, -0.08625345f, -0.05534171f, 0.06644370f, 0.10251644f, 
    0.05259736f, 0.02151803f, -0.18356380f, 0.13070634f, 0.07488324f, -0.05019366f, 0.09903273f, 0.41295606f, 
    -0.01179961f, 0.12966065f, -0.11547976f, -0.04897077f, -0.12284414f, -0.00589920f, -0.14789119f, 0.07774238f, 
    -0.07772804f, -0.10983112f, -0.01072259f, 0.06303798f, 0.18590137f, -0.06114215f, -0.12465999f, -0.05378915f, 
    -0.06967547f, 0.00263366f, -0.04090449f, 0.04733700f, -0.18087204f, 0.15057392f, -0.01511123f, -0.03960183f, 
    -0.09558294f, -0.03332066f, -0.15091503f, -0.02656866f, 0.07933510f, 0.19183391f, 0.10416910f, -0.03798619f, 
    -0.10920078f, 0.08992933f, 0.03284436f, 0.02132344f, -0.01349437f, 0.02195478f, -0.14472650f, 0.01094879f, 
    -0.16449933f, -0.15875638f, -0.10683799f, -0.15471518f, -0.09306148f, 0.15874130f, 0.30888563f, 0.08957061f, 
    0.12913018f, -0.11026160f, 0.00937849f, -0.01804458f, -0.09010573f, 0.20163704f, 0.12940840f, 0.00341117f, 
    0.14610323f, 0.14835255f, 0.19836646f, -0.24406512f, -0.09826416f, -0.00401601f, -0.04209454f, 0.00149338f, 
    0.16004200f, 0.14115652f, 0.04138497f, -0.06775638f, -0.27664664f, -0.17356420f, 0.09626127f, 0.13349153f, 
    0.06505660f, -0.07901380f, -0.20979418f, -0.05115040f, 0.14893574f, -0.01956000f, 0.11275581f, 0.07212131f, 
    -0.12837824f, 0.02535320f, 0.12576883f, 0.11779420f, -0.00557166f, 0.02456896f, -0.00361612f, 0.02140865f, 
    0.12176478f, 0.01792228f, 0.11914133f, 0.06385263f, 0.37857166f, 0.25177330f, 0.23701580f, 0.03524441f, 
    -0.01065693f, -0.01913209f, -0.02461728f, -0.17926653f, 0.05405862f, 0.15752113f, 0.09995154f, 0.06801382f, 
    0.07470385f, 0.16054490f, -0.21260497f, 0.06226715f, -0.10394592f, -0.15585001f, 0.17478183f, 0.05090299f, 
    -0.04285846f, 0.06681953f, 0.04242817f, -0.03691352f, -0.02491723f, -0.11887213f, 0.09954660f, -0.08079771f, 
    -0.04783189f, -0.14248446f, -0.04099068f, -0.14139567f, -0.02744094f, -0.14660391f, 0.05776821f, -0.01240467f, 
    0.08435361f, -0.04694865f, -0.04059133f, -0.06968035f, -0.03289010f, 0.07908702f, 0.08209360f, -0.06097408f, 
    0.03009130f, 0.17150284f, -0.01172316f, 0.07743864f, 0.15040517f, 0.01343051f, 0.09456415f, -0.00872322f, 
    0.06108011f, -0.05615697f, -0.02660615f, -0.02605290f, 0.05874257f, -0.05769335f, -0.04981885f, -0.03573478f, 
    0.01804517f, -0.20179725f, -0.13782576f, -0.12538920f, -0.08392841f, -0.03695962f, 0.08960631f, -0.07026174f, 
    0.02795677f, 0.07540467f, -0.00162815f, 0.29108852f, 0.04287646f, -0.32396662f, 0.00273207f, 0.05585198f, 
    0.19826180f, 0.13554527f, 0.01767716f, -0.12133175f, 0.00991823f, 0.01495384f, 0.04621683f, 0.06273418f, 
    -0.10507328f, -0.08885004f, -0.09804665f, 0.07467200f, 0.01989975f, -0.04062185f, 0.05440105f, 0.00958157f, 
    0.22567037f, -0.03481948f, 0.05812714f, 0.21268159f, -0.05307277f, -0.12820427f, -0.28382012f, 0.12512556f, 
    -0.05067777f, -0.26548573f, 0.08058127f, 0.06080807f, -0.21189840f, -0.17612112f, -0.07951263f, -0.07815173f, 
    0.03855341f, 0.00122259f, -0.06818077f, 0.02889230f, -0.06560885f, 0.04091807f, -0.09539317f, -0.27280354f, 
    -0.08719924f, 0.09290765f, -0.07001355f, -0.14513530f, -0.18064919f, -0.07041663f, 0.12408558f, -0.06818949f, 
    0.20767945f, 0.15124659f, -0.17930740f, -0.12209380f, -0.06148931f, 0.17613371f, 0.01065218f, -0.11773289f, 
    0.02087870f, 0.01049358f, -0.02776878f, 0.01512852f, -0.03825943f, -0.05785869f, -0.19514494f, 0.04817766f, 
    -0.17850429f, -0.13947831f, -0.03121454f, -0.04212498f, -0.10130221f, -0.08772864f, 0.06459057f, -0.14776921f, 
    -0.04493432f, 0.06794354f, 0.02506365f, -0.06991480f, 0.06473988f, 0.01292387f, -0.05694847f, 0.22656381f, 
    -0.41088942f, -0.10075606f, 0.30920887f, -0.06363310f, 0.04702967f, 0.03551425f, 0.09361880f, 0.04266794f, 
    0.14088202f, -0.01287971f, -0.00781075f, 0.11966816f, -0.11876240f, 0.08456142f, -0.18143897f, -0.14285973f, 
    0.06386812f, 0.08449461f, -0.13909891f, -0.13329138f, -0.27726501f, -0.24235235f, -0.14755814f, 0.16520248f, 
    0.15420468f, -0.04259527f, 0.08067940f, 0.12866068f, -0.05080899f, 0.12895536f, -0.01122804f, -0.04918409f, 
    0.10660981f, -0.07825936f, 0.10144302f, 0.14935799f, 0.38619885f, -0.09337860f, 0.24908285f, -0.06678661f, 
    -0.11242973f, -0.00444419f, -0.03102464f, -0.05447223f, 0.11357842f, 0.12654236f, -0.08078708f, -0.03217445f, 
    -0.21351179f, 0.23928696f, -0.07089805f, 0.06077777f, 0.15590827f, -0.22067362f, 0.12217550f, 0.03032658f, 
    0.01083322f, 0.05481940f, -0.07404836f, 0.01920649f, -0.10312153f, -0.11652983f, -0.11046423f, 0.15824977f, 
    0.04566605f, -0.04473817f, 0.14808327f, 0.17060183f, -0.09272105f, -0.10482319f, 0.04919620f, -0.24185129f, 
    0.04838784f, 0.10694293f, 0.14617331f, 0.10272424f, 0.02909336f, 0.05365240f, -0.02551508f, 0.01155268f, 
    0.18463889f, 0.12401353f, 0.11088873f, 0.07441506f, 0.18862331f, 0.26039022f, 0.04671690f, 0.09198626f, 
    0.00627817f, -0.05366246f, 0.02794791f, 0.09656168f, 0.16196446f, 0.02830028f, -0.09098288f, -0.00795815f, 
    0.02212367f, 0.10358129f, 0.06514837f, -0.03493963f, -0.10830297f, -0.06347607f, -0.07648186f, -0.22738831f, 
    -0.13873407f, -0.12176475f, 0.06866790f, 0.13719217f, 0.25165382f, 0.06171286f, 0.23936929f, 0.16836002f, 
    0.01014508f, 0.02762610f, 0.01035390f, 0.06675695f, -0.13962470f, -0.02294768f, -0.07272066f, 0.05707718f, 
    0.14992964f, 0.06324545f, 0.05730206f, -0.00933959f, -0.13785829f, 0.02723886f, -0.06125937f, 0.02106493f, 
    0.15803441f, -0.21738210f, -0.14112587f, 0.28973940f, 0.10847530f, 0.12425530f, -0.10514196f, 0.04758094f, 
    -0.05409416f, -0.20585129f, -0.09140831f, 0.26625025f, -0.06802709f, -0.01811235f, -0.10563876f, 0.01302431f, 
    -0.05272346f, -0.16016759f, 0.16852508f, -0.00244781f, 0.16455689f, 0.11923863f, 0.09615160f, 0.09469175f, 
    0.03264004f, 0.04933342f, 0.12243808f, 0.16998751f, 0.09355817f, -0.24146396f, -0.21506453f, 0.09677699f, 
    -0.01561851f, 0.02201704f, 0.22081076f, 0.18839481f, -0.03260839f, -0.02122023f, 0.04651130f, 0.02660418f, 
    0.12784339f, -0.34743500f, -0.26858079f, -0.14105469f, -0.03469863f, 0.11431490f, -0.01298731f, 0.15460257f, 
    0.08765025f, 0.06752033f, -0.02698093f, 0.09599043f, 0.66471815f, -0.32985607f, -0.28305665f, -0.16804302f, 
    0.07720550f, -0.16302317f, -0.03629688f, 0.04155776f, 0.04716439f, 0.09448678f, 0.18667164f, 0.00131905f, 
    0.05006641f, 0.00717339f, -0.15801218f, 0.17876589f, -0.00634706f, -0.09643075f, -0.04206663f, 0.12302059f, 
    -0.01057392f, -0.00115777f, 0.17392194f, 0.01369460f, 0.51441664f, -0.21666227f, -0.23533432f, -0.12094573f, 
    0.19605750f, -0.05634977f, -0.01569421f, 0.00487835f, 0.14780657f, 0.01213603f, 0.09747303f, 0.15582739f, 
    -0.03870764f, -0.00266398f, 0.03565224f, -0.00453396f, -0.10509722f, -0.04611245f, -0.02074862f, -0.05523264f, 
    -0.05053659f, 0.04604150f, 0.13827068f, 0.09061589f, -0.26746500f, 0.16835049f, 0.12217368f, -0.02073752f, 
    0.00072131f, -0.00505295f, 0.04184625f, 0.05809271f, -0.02188340f, 0.03807712f, 0.03210808f, 0.19920409f, 
    -0.03468626f, -0.08656394f, -0.17554025f, -0.11574242f, 0.16483483f, 0.09362250f, 0.04089601f, -0.01340502f, 
    0.12786376f, -0.04637916f, 0.01014278f, 0.02340535f, -0.21164529f, -0.19813837f, -0.12483212f, 0.21450523f, 
    -0.02785053f, -0.08969887f, -0.03701744f, 0.19224250f, 0.04073828f, -0.06390166f, -0.01953650f, 0.00217965f, 
    -0.04066773f, 0.14942838f, -0.06400935f, 0.02680770f, -0.04398384f, -0.00012101f, -0.06024383f, -0.01606284f, 
    -0.03693433f, -0.03304217f, 0.05793368f, 0.02902326f, -0.07335205f, 0.09135733f, 0.07257944f, -0.04933832f, 
    0.01559793f, 0.02551598f, 0.04952750f, -0.06821495f, 0.06473517f, 0.05203499f, 0.04160052f, 0.04089347f, 
    -0.07407474f, -0.07072257f, -0.03449214f, 0.16138400f, -0.10619308f, -0.03006501f, -0.00376747f, 0.02646158f, 
    0.00624216f, -0.07492585f, 0.03983727f, 0.17117418f, -0.25901613f, 0.02024080f, 0.13389485f, -0.00750914f, 
    0.05025686f, 0.15168300f, -0.02491487f, -0.08320674f, 0.13557819f, 0.06649494f, -0.03364768f, -0.11450091f, 
    0.18779907f, 0.03944498f, -0.05192253f, -0.21280636f, 0.04155803f, 0.00689509f, 0.01304961f, -0.05090282f, 
    -0.06243222f, 0.02909205f, -0.08928920f, 0.13018429f, 0.03103841f, -0.02125680f, 0.02938431f, -0.11780622f, 
    0.07178422f, 0.01037760f, 0.02103248f, 0.30802128f, 0.03243994f, 0.10250728f, 0.01411330f, -0.07241157f, 
    -0.38559633f, 0.18014173f, -0.20874184f, 0.09157743f, 0.03053086f, 0.08946621f, -0.06017071f, -0.02124386f, 
    -0.14394419f, 0.00756031f, 0.02487032f, 0.09170783f, 0.26658565f, -0.13476881f, 0.05752104f, -0.15735613f, 
    0.01262232f, -0.05334850f, 0.04656428f, 0.03034827f, 0.05130011f, 0.10843735f, 0.10791866f, 0.06675716f, 
    -0.08963121f, -0.20886683f, -0.06187569f, 0.10673065f, 0.01916738f, -0.19921081f, -0.00864378f, -0.13189852f, 
    -0.06762210f, 0.03454652f, 0.03538411f, -0.07474838f, -0.25607693f, 0.16501184f, -0.11639596f, 0.12069164f, 
    -0.11354841f, -0.15973264f, -0.04680952f, 0.10660685f, 0.02740313f, 0.07302973f, 0.04187218f, 0.02627937f, 
    0.03299351f, 0.11546919f, -0.04819572f, 0.14513557f, -0.11218166f, -0.02636757f, 0.05906438f, 0.05212962f, 
    -0.02938369f, 0.04482360f, -0.01278018f, 0.03421316f, 0.05912167f, -0.06173267f, -0.33515051f, -0.04362321f, 
    0.00502995f, 0.12917298f, 0.14707789f, 0.17169976f, 0.05049966f, 0.16834368f, 0.10390443f, 0.08719919f, 
    -0.14766268f, 0.33295152f, -0.20508242f, -0.03139832f, 0.05710154f, 0.04634992f, 0.02445674f, -0.03371207f, 
    0.10321893f, 0.04014183f, 0.07375440f, 0.09699845f, -0.42915311f, 0.48241630f, 0.01679686f, 0.15826774f, 
    -0.06052853f, 0.00029764f, -0.23526582f, 0.05661293f, 0.00107079f, 0.06669579f, 0.00665569f, 0.04723934f, 
    0.49520737f, -0.09251803f, -0.14014880f, 0.07433625f, 0.04501392f, 0.11773158f, -0.07015867f, 0.27972236f, 
    0.08435493f, -0.00273188f, 0.03264358f, -0.13433813f, -0.20428802f, -0.10239723f, 0.02549840f, 0.17655800f, 
    -0.08521904f, 0.07152858f, 0.12318692f, -0.04049044f, 0.12141350f, 0.08679853f, 0.07133781f, 0.10037602f, 
    0.11565265f, -0.09195866f, 0.07533886f, -0.26229089f, -0.14780150f, -0.02205133f, -0.06774066f, -0.03467798f, 
    -0.11057656f, 0.08462768f, -0.03248833f, -0.09028292f, 0.00106680f, -0.08998205f, 0.05692605f, -0.02889092f, 
    -0.03458367f, -0.01262058f, 0.04672562f, -0.15594035f, 0.02345199f, -0.13911559f, 0.08976931f, 0.05837869f, 
    0.03840173f, 0.02716622f, 0.02217514f, -0.00385162f, -0.03390471f, 0.03105031f, 0.02812095f, 0.03921800f, 
    0.12430600f, 0.14363350f, 0.00479104f, 0.04267456f, -0.01273153f, 0.29757571f, -0.11936702f, 0.32203549f, 
    0.04538766f, 0.01498216f, -0.06264584f, 0.07205117f, -0.04583509f, -0.06902545f, 0.02693558f, 0.00570362f, 
    -0.18945885f, 0.10525495f, -0.10679225f, 0.16594990f, 0.04663990f, -0.01764757f, 0.09246487f, 0.13632753f, 
    0.16556706f, -0.01659952f, 0.04996111f, 0.15550327f, -0.26754081f, 0.00644136f, -0.00007594f, 0.33644843f, 
    -0.08101244f, -0.02786931f, 0.06427225f, -0.08012459f, -0.06429975f, 0.10130715f, 0.07754322f, -0.12372784f, 
    0.08179843f, -0.20250528f, 0.06343162f, -0.18944475f, -0.05931135f, -0.02328678f, 0.04899155f, 0.14945082f, 
    0.12632696f, 0.06216746f, -0.00091084f, 0.01393733f, -0.24990153f, 0.15931924f, -0.08508799f, -0.04588927f, 
    -0.05201958f, 0.09557831f, -0.00077931f, -0.01320079f, -0.03909525f, -0.12232484f, -0.07362158f, -0.08521955f, 
    -0.15163338f, -0.05712068f, -0.07459453f, -0.15922517f, 0.10623199f, 0.07315919f, 0.07559317f, 0.16171955f, 
    -0.01621241f, -0.00188478f, 0.04443942f, 0.12025005f, -0.24914055f, 0.03604553f, 0.44795805f, 0.13631977f, 
    -0.10271171f, 0.05091025f, -0.01793697f, -0.02411609f, 0.02088201f, 0.00193234f, -0.02324396f, 0.12967190f, 
    0.25606087f, 0.23212047f, 0.09808512f, -0.22299187f, 0.00828009f, -0.12310101f, -0.12790342f, -0.08266037f, 
    0.08326807f, 0.07278552f, 0.02162331f, -0.04974952f, -0.12984858f, -0.08685524f, 0.17177051f, 0.21218178f, 
    -0.08277553f, -0.05972252f, 0.00675729f, 0.02213579f, 0.06153574f, -0.09017330f, 0.04622773f, 0.05948703f, 
    0.30164763f, -0.22907001f, 0.27110624f, 0.11879542f, 0.02506207f, 0.06721274f, -0.07652656f, -0.03755724f, 
    -0.18958089f, -0.03653660f, 0.02584505f, 0.03778702f, 0.25812131f, -0.06129127f, 0.17313704f, -0.11140953f, 
    -0.06527800f, -0.14461939f, -0.01977986f, -0.12896848f, 0.14316984f, 0.06605134f, 0.09258055f, 0.12550624f, 
    -0.23751238f, 0.21198764f, -0.00213206f, 0.00197525f, 0.09154165f, 0.02033691f, 0.25918856f, -0.05084084f, 
    -0.01047980f, 0.09937851f, 0.00543989f, 0.16885428f, 0.16413428f, -0.07867318f, -0.08177351f, -0.17876436f, 
    0.15110002f, -0.01357130f, -0.00459237f, 0.03146756f, 0.07244720f, 0.05955314f, 0.05529571f, 0.01377189f, 
    -0.17935045f, -0.08420619f, 0.00697179f, 0.13587932f, 0.06801108f, -0.05112335f, -0.00823499f, -0.03995493f, 
    0.12121335f, -0.05575732f, -0.10144565f, -0.00624929f, -0.10973050f, -0.08354732f, -0.04788942f, -0.06543925f, 
    -0.01976679f, -0.00471522f, -0.04396109f, 0.00936483f, 0.10421723f, 0.00039681f, 0.04713738f, 0.18006454f, 
    -0.00905721f, -0.25164637f, -0.08309258f, -0.06922159f, 0.06647819f, -0.00167303f, 0.19685259f, -0.02128335f, 
    -0.08101349f, -0.08524938f, 0.00386698f, -0.08182751f, 0.16620515f, -0.41940868f, 0.12795687f, -0.16658114f, 
    0.14865206f, 0.05764553f, 0.00178817f, -0.01625339f, -0.02521436f, -0.04635390f, -0.08275335f, 0.05520654f, 
    0.30151421f, -0.10660779f, 0.08177788f, 0.15087965f, 0.04543614f, 0.00694557f, 0.04811479f, -0.00676191f, 
    0.02801253f, 0.01342124f, 0.13294819f, -0.08408518f, 0.04679609f, -0.05465093f, -0.14018002f, -0.18696870f, 
    0.14523846f, -0.01264870f, 0.22303414f, 0.01596336f, 0.12250604f, -0.03344436f, -0.06995890f, 0.17394885f, 
    0.10795535f, 0.01637290f, -0.20569594f, 0.16685109f, 0.06460501f, -0.06566990f, 0.14302173f, 0.01517971f, 
    0.01672843f, -0.06643579f, 0.00819749f, 0.00480119f, 0.10710116f, 0.10580665f, 0.08077112f, 0.14023410f, 
    0.09386835f, 0.10924894f, -0.02524803f, -0.09910157f, 0.03482161f, 0.04757812f, 0.07892274f, 0.04028030f, 
    0.23567288f, 0.15772676f, 0.21909456f, -0.00103219f, 0.11532291f, 0.14622141f, -0.01459666f, 0.05429894f, 
    -0.00260343f, -0.00211661f, -0.04294290f, 0.01791085f, 0.09154532f, 0.01246180f, -0.14671797f, -0.01706738f, 
    0.09726311f, 0.24614431f, 0.01761284f, 0.03308634f, -0.17070878f, -0.02278172f, 0.00124401f, 0.00032859f, 
    -0.04272082f, -0.17799735f, -0.02992892f, 0.04191211f, 0.00422563f, 0.00790600f, 0.02867785f, 0.04329323f, 
    -0.00873629f, 0.07475505f, -0.05469066f, -0.01633724f, 0.17819183f, 0.15930639f, 0.07894759f, -0.01026469f, 
    0.11940467f, 0.06038435f, 0.18442255f, -0.05935327f, 0.08932327f, 0.05838457f, -0.07206082f, -0.05108335f, 
    0.08394970f, 0.08115357f, -0.14747968f, -0.07000019f, -0.01015467f, -0.02413747f, -0.05935777f, 0.01767495f, 
    -0.06150612f, 0.14793926f, 0.10471832f, 0.09278130f, 0.30337399f, -0.17914665f, -0.03863918f, 0.18315382f, 
    -0.04339879f, 0.18573540f, 0.17097491f, -0.09966063f, 0.08372702f, -0.03507593f, -0.02871178f, -0.07397348f, 
    -0.14611915f, -0.06456897f, 0.37769017f, -0.05471800f, 0.15029702f, 0.06718121f, -0.27465075f, -0.08071809f, 
    -0.07163385f, 0.02048286f, -0.00708184f, 0.05936916f, -0.02610165f, -0.03531355f, 0.04404641f, -0.20426330f, 
    0.09527721f, -0.00794856f, -0.01859655f, -0.03580427f, -0.01497290f, -0.05293782f, -0.04702935f, 0.00005111f, 
    -0.22024485f, 0.00796099f, 0.05544671f, -0.02360390f, -0.07025800f, -0.00880731f, -0.15580155f, -0.00437089f, 
    -0.04654387f, 0.00130997f, 0.17062707f, 0.14110427f, -0.19426502f, -0.01396178f, -0.08727466f, 0.07601131f, 
    0.04200594f, 0.03518844f, -0.09212114f, 0.07560246f, -0.01671992f, -0.06923878f, -0.05068741f, 0.01976679f, 
    -0.11991480f, -0.20423564f, 0.05335021f, 0.11754127f, 0.03350072f, -0.08854324f, -0.23326269f, -0.05069710f, 
    0.00762991f, 0.19047828f, 0.00404518f, 0.09530988f, -0.06829009f, 0.46188694f, -0.23446557f, 0.17015205f, 
    -0.25417709f, -0.14067224f, 0.13564265f, -0.09952379f, -0.04041959f, 0.13021059f, -0.01432949f, 0.10933735f, 
    -0.07730625f, 0.18961439f, -0.07508460f, -0.13921402f, -0.03936031f, -0.08526595f, 0.07338127f, -0.00065110f, 
    0.01826191f, 0.12923847f, 0.03694519f, 0.06320383f, 0.17274062f, -0.13599658f, -0.41945457f, -0.03278068f, 
    0.06783286f, -0.02401970f, -0.03724441f, 0.20345251f, 0.00701362f, -0.14149244f, -0.13886444f, 0.08427673f, 
    0.08960241f, -0.18026361f, 0.00875861f, 0.16792884f, -0.02967589f, -0.10839224f, 0.27557665f, 0.02372303f, 
    -0.15985712f, 0.09971847f, 0.17202064f, 0.08908115f, 0.00213658f, -0.09261473f, 0.01069463f, 0.17938946f, 
    0.17061846f, 0.08360212f, -0.07795170f, 0.08548801f, 0.02058097f, 0.05873464f, 0.01249873f, -0.03206476f, 
    0.08790492f, 0.13773890f, -0.22196026f, 0.10492424f, -0.02291372f, 0.07441045f, -0.09188392f, 0.20907502f, 
    -0.01140007f, -0.04302652f, -0.14609165f, -0.02367072f, 0.39409986f, 0.10705318f, -0.07200879f, -0.07048517f, 
    -0.02514266f, 0.06353163f, 0.12312365f, 0.05447138f, -0.03914474f, -0.03687004f, -0.02443116f, -0.07758021f, 
    -0.17592353f, -0.13490517f, 0.04847650f, -0.02839727f, 0.05672410f, 0.09662360f, 0.02008720f, 0.00496385f, 
    0.09825038f, -0.01743823f, 0.00793942f, 0.06512478f, -0.01179777f, 0.39670876f, -0.05427774f, -0.12145542f, 
    0.31474289f, 0.20964217f, -0.07450168f, 0.04257835f, 0.10717054f, -0.04554666f, -0.01781796f, -0.21414211f, 
    0.10052516f, -0.07481327f, 0.04970681f, -0.16070791f, -0.00889086f, -0.01189644f, -0.09156606f, 0.00801319f, 
    -0.00316759f, -0.11635529f, 0.08908767f, 0.05943749f, 0.18321449f, -0.23134728f, 0.00756973f, -0.03953445f, 
    -0.07864348f, 0.01779591f, -0.02896083f, -0.04798645f, 0.08084817f, -0.04695706f, -0.03730363f, -0.02374181f, 
    -0.46156383f, 0.12016174f, 0.05799130f, -0.24133368f, 0.23574804f, -0.10325044f, 0.00598949f, -0.04435676f, 
    0.03355993f, 0.11333599f, 0.02527268f, 0.11379625f, -0.00991428f, -0.12211518f, -0.14154170f, -0.16283618f, 
    0.18668886f, 0.01904471f, -0.00266923f, 0.15502910f, 0.05554449f, 0.05484356f, 0.07525378f, -0.06615107f, 
    -0.20015527f, 0.12348247f, 0.12096053f, -0.08448481f, 0.02979007f, 0.00490230f, -0.02738470f, -0.07096264f, 
    -0.00894904f, 0.04045577f, 0.05183750f, 0.05800436f, -0.09076223f, 0.13060682f, 0.08468787f, -0.06230396f, 
    0.00614063f, -0.03529847f, -0.05224418f, 0.09869358f, 0.04051090f, 0.11014146f, 0.20089558f, -0.03738536f, 
    -0.21804149f, 0.00835784f, -0.11146986f, -0.04813894f, -0.00687014f, 0.01971045f, -0.12995701f, -0.01455500f, 
    -0.13019538f, 0.00523002f, 0.09397368f, 0.06417326f, -0.04815337f, 0.00876728f, 0.18074122f, 0.03796667f, 
    -0.20157409f, 0.01936824f, 0.04156356f, -0.08686565f, 0.01137033f, 0.01116359f, 0.01353964f, 0.16270520f, 
    0.08576048f, 0.21116765f, -0.02543725f, -0.25778824f, 0.09059908f, 0.02889391f, 0.09708671f, -0.15971789f, 
    -0.02226610f, 0.05925579f, 0.01404092f, -0.06776261f, -0.03030450f, 0.05134057f, -0.08276219f, 0.02266304f, 
    -0.02767816f, 0.04822594f, 0.15939154f, 0.34866315f, -0.13772337f, -0.08904795f, 0.01878714f, 0.09148518f, 
    0.20880385f, 0.29067662f, -0.07707777f, 0.08360824f, -0.11601307f, 0.08067703f, -0.01267358f, -0.08287772f, 
    0.07355503f, 0.00850227f, -0.01650209f, 0.09280691f, 0.24572642f, -0.03314369f, 0.03009831f, -0.00394909f, 
    -0.05512748f, -0.00574135f, 0.10031616f, 0.10586841f, -0.07986039f, -0.21980737f, -0.15323043f, -0.35110956f, 
    0.13684492f, 0.17622617f, 0.03287687f, 0.16251647f, 0.05107693f, -0.05191405f, 0.05922684f, -0.05066657f, 
    -0.10473386f, 0.03706358f, 0.06447633f, 0.02508391f, 0.02897209f, 0.07126333f, -0.20140323f, -0.05048840f, 
    0.01783702f, -0.02223400f, 0.07950386f, 0.04965253f, 0.21029718f, -0.00770919f, 0.01471654f, -0.04322488f, 
    -0.04658191f, 0.12160047f, -0.09064557f, 0.35828149f, 0.00938791f, 0.04031664f, 0.08183455f, 0.08161824f, 
    0.01221776f, -0.06312282f, -0.04902108f, -0.13334358f, -0.08308823f, 0.07430581f, 0.09554825f, -0.15057752f, 
    0.08034333f, -0.10322917f, 0.14140771f, 0.21390025f, -0.09309881f, -0.03981501f, -0.14900933f, -0.13887765f, 
    -0.10577785f, -0.01810426f, -0.13309526f, -0.18412009f, 0.03345828f, -0.07048833f, -0.01762315f, 0.04920447f, 
    -0.03268784f, 0.06259868f, -0.01703902f, -0.03800541f, -0.05157228f, -0.15865542f, -0.22055963f, -0.11462084f, 
    0.10758960f, 0.10284758f, -0.00525192f, 0.09504732f, 0.00477285f, -0.03478272f, -0.02728227f, 0.01245664f, 
    -0.07398456f, 0.17899218f, -0.05799413f, 0.00503332f, -0.03775880f, 0.09532820f, -0.09469784f, -0.01750593f, 
    0.07023845f, 0.03169666f, -0.00316083f, 0.11924303f, 0.19101493f, 0.23364788f, 0.08198042f, 0.30551380f, 
    0.07654718f, 0.07179098f, -0.12518083f, 0.17585592f, 0.08268984f, 0.07132383f, 0.02148118f, 0.01595155f, 
    -0.18713556f, -0.03470811f, 0.01593066f, -0.02006587f, -0.03988395f, -0.06919729f, -0.08790305f, 0.02416835f, 
    0.00665877f, 0.09454719f, 0.10602777f, -0.00800614f, -0.11076954f, -0.13075866f, 0.07592908f, -0.04165268f, 
    0.05218230f, 0.01382061f, 0.00968055f, -0.02359030f, -0.05152120f, 0.04345158f, 0.11518398f, 0.25533822f, 
    -0.13612524f, 0.07871442f, -0.06270798f, 0.00520504f, -0.06503370f, -0.02309296f, -0.07567273f, -0.03470865f, 
    0.12151439f, -0.07944202f, 0.03562848f, -0.31241325f, 0.04803261f, 0.23148261f, 0.11497048f, 0.27371410f, 
    -0.11031514f, -0.06240483f, -0.01005297f, 0.01654015f, 0.07621924f, -0.04530327f, 0.05398050f, 0.05919667f, 
    0.03682375f, -0.09889306f, -0.04504168f, -0.06127589f, -0.01897046f, -0.06643854f, -0.02459758f, 0.03452372f, 
    -0.05616044f, 0.03495034f, 0.07735396f, 0.13215473f, 0.12059987f, 0.41338193f, 0.39546695f, -0.08667490f, 
    0.15884890f, 0.14842927f, 0.24905950f, -0.05711078f, 0.24860665f, 0.03647868f, 0.05872693f, 0.00284642f, 
    0.10854851f, 0.17895037f, 0.02335301f, -0.25529894f, -0.17290759f, 0.05148584f, 0.02564962f, 0.07560416f, 
    0.06550234f, 0.08621939f, -0.06392417f, 0.13611493f, 0.04413290f, 0.11649041f, -0.02859726f, 0.07501905f, 
    0.02026958f, -0.11988315f, 0.08633574f, -0.00873277f, -0.05127423f, -0.21771607f, -0.01840600f, -0.14265007f, 
    -0.06594836f, 0.12531251f, 0.05194554f, 0.05637675f, 0.10821276f, 0.02689416f, 0.12269159f, -0.09430081f, 
    -0.00877073f, -0.01104875f, 0.01764201f, -0.03271684f, -0.13292488f, 0.06156354f, 0.19281128f, 0.18794231f, 
    -0.05482145f, -0.03154928f, 0.05567557f, 0.11040167f, 0.10562172f, -0.03505554f, -0.04587912f, 0.04818707f, 
    0.03211925f, 0.23349461f, 0.09772834f, 0.10359547f, 0.14233081f, 0.04699301f, -0.03527608f, -0.04686465f, 
    -0.01136789f, -0.14581150f, 0.00008077f, -0.01417142f, -0.01928392f, -0.18818019f, 0.10096224f, 0.19917242f, 
    0.09378343f, 0.02749628f, -0.01093306f, 0.08168067f, -0.03675735f, -0.03133669f, 0.05874100f, -0.03025112f, 
    -0.20604450f, -0.24438417f, -0.00915166f, -0.16517897f, 0.00031936f, -0.00754413f, -0.02778520f, 0.03863098f, 
    -0.06884671f, 0.09427175f, -0.04491904f, 0.10093466f, -0.14896509f, -0.23402508f, 0.18125777f, -0.21105638f, 
    0.01874947f, -0.07034033f, -0.05680634f, -0.00648399f, 0.06414218f, -0.06238774f, 0.10133786f, 0.01520928f, 
    0.10320996f, 0.04311896f, -0.07402540f, 0.11093388f, -0.15627970f, 0.12087251f, -0.05470482f, 0.01745236f, 
    0.08297984f, -0.03073013f, 0.00962631f, 0.08756677f, 0.09149613f, 0.19273843f, 0.11703364f, 0.30896848f, 
    -0.00352728f, 0.12777852f, 0.05307529f, 0.08637500f, 0.09551667f, 0.08479398f, -0.02804027f, 0.06351919f, 
    -0.30157104f, -0.36085346f, -0.11943696f, -0.06671620f, 0.01516751f, -0.01631356f, -0.14555697f, -0.00740128f, 
    0.18442719f, -0.07927527f, -0.13441771f, -0.05213820f, -0.31903043f, -0.29806787f, -0.17893885f, -0.00676410f, 
    -0.01118123f, -0.10642567f, -0.06385240f, -0.07963387f, 0.15269056f, 0.10611553f, 0.07325304f, 0.17850429f, 
    -0.01194119f, -0.12843493f, -0.10323319f, -0.05652836f, 0.06113658f, 0.04026066f, -0.02563678f, -0.00714397f, 
    0.10400315f, -0.04865504f, -0.02835411f, -0.21085416f, 0.17497690f, -0.03756405f, 0.06279612f, -0.19045642f, 
    0.19155584f, -0.04879938f, 0.12444714f, 0.02899927f, 0.07353018f, -0.08958305f, -0.07372581f, -0.02687220f, 
    -0.02012980f, -0.37164381f, 0.10890987f, 0.11011259f, -0.16104904f, 0.07446137f, -0.09087900f, 0.08514568f, 
    -0.03828514f, 0.05249234f, 0.09246586f, -0.05244857f, 0.01537782f, 0.17638940f, 0.21487643f, 0.00598968f, 
    0.09420935f, 0.07059482f, 0.26216528f, -0.15754895f, 0.14695807f, 0.00429636f, -0.00692955f, 0.08556382f, 
    0.07660029f, -0.05401788f, 0.11353612f, -0.14362669f, -0.08605073f, 0.21015546f, -0.14274338f, 0.14161728f, 
    -0.02404392f, -0.16325048f, -0.02360233f, 0.01483338f, -0.21648157f, -0.07720284f, -0.30142918f, -0.15692660f, 
    0.23642790f, -0.11189372f, -0.03697998f, -0.07705142f, 0.16164720f, 0.03432103f, -0.07459899f, 0.05118302f, 
    -0.17786047f, -0.13242799f, -0.60496694f, -0.51885784f, 0.20111315f, 0.07692777f, -0.05474428f, 0.23179424f, 
    0.02705093f, -0.05525240f, 0.04065618f, 0.00462842f, 0.34137344f, -0.10880671f, -0.00361068f, -0.11267963f, 
    -0.09372070f, 0.02583895f, -0.01211489f, -0.15639670f, 0.12827349f, 0.07551768f, -0.01913944f, 0.15443629f, 
    0.15923278f, -0.04453059f, 0.06363033f, -0.30140075f, 0.02707279f, -0.05353225f, 0.02067044f, 0.02893450f, 
    0.16601864f, 0.07163534f, 0.15271547f, -0.04121443f, -0.42806211f, -0.08267821f, 0.13367710f, -0.23489532f, 
    -0.05834790f, -0.05442239f, -0.10592931f, -0.01135308f, 0.17541385f, 0.03253950f, -0.01788211f, 0.00989375f, 
    0.11560160f, 0.09968252f, 0.29860914f, 0.13576618f, -0.08634368f, -0.04254742f, -0.04999981f, -0.17031649f, 
    -0.05973604f, 0.10289518f, -0.09846387f, -0.04826678f, 0.21478349f, -0.31049100f, -0.10754675f, -0.14459105f, 
    0.00306912f, -0.15922791f, -0.07194590f, -0.01205380f, 0.16487074f, -0.04077255f, 0.11396809f, -0.05102335f, 
    -0.30222285f, 0.10532639f, 0.02154425f, -0.22287574f, 0.05088481f, -0.05111104f, 0.12311188f, -0.24052189f, 
    0.01722351f, 0.06177180f, -0.12700458f, -0.04361608f, -0.07403446f, 0.11787623f, -0.13273418f, 0.07659139f, 
    0.09779917f, 0.11499429f, -0.06257541f, 0.20239700f, -0.00858272f, 0.01517590f, 0.05686510f, 0.00019884f, 
    0.13758081f, -0.01940664f, 0.03515723f, 0.21682256f, 0.02839633f, 0.01735145f, -0.03063435f, -0.12871476f, 
    0.05306310f, -0.05166037f, 0.10316499f, 0.03943337f, 0.10967213f, 0.12353400f, 0.05144546f, 0.05587387f, 
    0.00801651f, 0.01387147f, -0.11037879f, 0.02903820f, -0.16450498f, 0.02166141f, -0.15400665f, -0.04268718f, 
    0.17756259f, 0.21123637f, 0.12676422f, 0.10398401f, 0.04886749f, 0.05602141f, 0.11088246f, -0.01069531f, 
    0.09422018f, 0.00181519f, 0.06477485f, -0.03622063f, 0.38446477f, 0.03031531f, 0.29702613f, 0.16832379f, 
    0.14184488f, 0.06170492f, 0.04452021f, -0.04429358f, 0.00414765f, -0.01031296f, -0.03914250f, -0.02571633f, 
    0.24226941f, -0.07572149f, 0.20736346f, 0.20532751f, -0.07459217f, -0.04199348f, 0.00193551f, -0.16971356f, 
    0.06779454f, 0.05488481f, 0.09975417f, 0.00664805f, 0.02996202f, 0.09903820f, -0.04862028f, -0.47868469f, 
    0.19759075f, 0.13284783f, 0.16006289f, 0.02142888f, 0.12633683f, 0.04904150f, 0.04008288f, -0.01293100f, 
    -0.04982529f, -0.06801801f, 0.02691289f, -0.06117373f, -0.06351756f, -0.00105092f, -0.00777970f, -0.05423145f, 
    0.05770899f, -0.05060283f, -0.04190937f, -0.01992755f, -0.05085380f, -0.05758819f, 0.03495236f, -0.06246395f, 
    -0.03717161f, -0.00600889f, 0.05855154f, 0.05955302f, -0.02330786f, -0.04580936f, 0.00787182f, -0.06353120f, 
    -0.06907527f, -0.02774804f, -0.00635165f, -0.04412075f, 0.02561576f, 0.02938071f, -0.00505828f, -0.00529906f, 
    -0.03240034f, -0.01271761f, -0.06619686f, 0.06574723f, 0.03208750f, -0.00426660f, -0.05386537f, 0.00574372f, 
    0.02237622f, 0.00217173f, 0.02929267f, -0.05458274f, -0.06785629f, -0.03027114f, -0.02644265f, 0.05493858f, 
    0.00172577f, -0.05885265f, 0.05542871f, 0.03088743f, -0.00564734f, -0.03196072f, -0.03667025f, -0.04011096f, 
    -0.02417647f, 0.04306707f, -0.01866027f, -0.05317133f, 0.00163731f, 0.00810369f, 0.00921884f, -0.02314173f, 
    -0.06137840f, -0.02033166f, -0.02160924f, 0.00580773f, 0.01727758f, 0.01036751f, -0.04199900f, -0.04841518f, 
    0.00160856f, -0.01873190f, -0.02444888f, -0.03559212f, 0.06885644f, 0.04933794f, -0.06211504f, -0.03479392f, 
    0.01657959f, -0.01572485f, -0.02308697f, 0.01703440f, 0.00685610f, 0.06064874f, -0.00365038f, -0.02107579f, 
    -0.05196264f, 0.01487114f, 0.00111948f, 0.02003097f, -0.01189842f, 0.02023794f, -0.06016321f, 0.01575730f, 
    0.03587353f, 0.01598982f, -0.01883796f, 0.03408688f, 0.01783619f, -0.01982025f, 0.05824018f, -0.03794140f, 
    0.03803065f, -0.02283245f, 0.06598441f, 0.01231734f, 0.04061100f, -0.04111402f, -0.02769038f, 0.04484551f, 
    -0.05801531f, 0.02134603f, -0.07143386f, 0.01259837f, -0.00533138f, -0.07176171f, -0.04919250f, -0.02309910f, 
    -0.02854201f, -0.07231358f, -0.06122428f, -0.06737716f, -0.01316202f, 0.05805366f, -0.04629864f, 0.06353474f, 
    -0.01328516f, -0.02848989f, -0.07216816f, 0.05863234f, -0.06454569f, -0.02339347f, 0.06096043f, -0.05560658f, 
    -0.02831479f, 0.00498629f, -0.00566368f, 0.00685792f, 0.04470858f, 0.04849144f, -0.01467245f, 0.00324718f, 
    -0.01423368f, 0.04318174f, 0.03157573f, -0.06601962f, -0.06110875f, -0.01558482f, 0.00837388f, -0.02791161f, 
    0.04198270f, -0.06066012f, 0.05522550f, 0.06460132f, -0.04681626f, -0.01590726f, -0.02082874f, 0.01020986f, 
    -0.07769381f, 0.02680316f, -0.04603470f, -0.02897720f, -0.03748445f, -0.00741616f, -0.02914968f, 0.01556475f, 
    -0.05270934f, 0.02508145f, 0.04357863f, 0.02268369f, -0.04861135f, 0.01186391f, -0.01529056f, -0.06962311f, 
    -0.05677190f, -0.04319432f, 0.03424247f, -0.04401714f, -0.00621711f, -0.00476721f, 0.03325447f, -0.06977139f, 
    -0.02968723f, 0.03609028f, -0.02406041f, -0.01835584f, -0.05203317f, -0.07486756f, 0.02362875f, -0.02039141f, 
    0.32034078f, 0.20671098f, 0.12150807f, -0.18911093f, -0.02780398f, -0.00061536f, 0.10063052f, 0.19921772f, 
    0.19753753f, -0.16183923f, -0.10757115f, -0.16185206f, 0.14542881f, 0.12202623f, 0.05692420f, 0.07335218f, 
    0.13308568f, 0.14038296f, -0.06678076f, -0.02207072f, 0.06249409f, -0.06204271f, -0.01495510f, 0.04241060f, 
    0.10814417f, 0.14825396f, 0.10395039f, -0.09733962f, 0.16643366f, 0.13518679f, 0.16118331f, 0.21262528f, 
    0.06948911f, -0.06291722f, 0.02907684f, -0.02308380f, 0.15557803f, 0.05027216f, 0.27805120f, 0.06505447f, 
    -0.05435450f, -0.00321696f, -0.07577164f, -0.16814128f, 0.06418318f, -0.01544982f, -0.09567542f, -0.01813023f, 
    0.01389959f, -0.00484295f, 0.01830687f, -0.07641872f, -0.04328664f, -0.11496299f, 0.01902240f, -0.01741022f, 
    -0.06555973f, 0.03077998f, -0.10378468f, 0.19823948f, 0.05348293f, 0.01266161f, 0.45946574f, 0.04660773f, 
    0.21807785f, -0.06442356f, -0.13843095f, 0.02793768f, 0.06283467f, 0.05640075f, 0.02717247f, 0.00452756f, 
    0.20750269f, -0.06323719f, 0.21854678f, 0.15161398f, -0.16478114f, -0.01005623f, -0.00669520f, -0.10360356f, 
    0.02784672f, 0.19690187f, 0.14834948f, -0.02474096f, 0.32581079f, -0.05987265f, -0.18699290f, -0.13983986f, 
    -0.10096339f, -0.39700419f, -0.07850385f, -0.02691722f, -0.01836005f, 0.10167921f, 0.04079834f, -0.01929009f, 
    -0.16169146f, 0.13081682f, 0.16230787f, 0.01338408f, -0.00954728f, -0.13951176f, 0.10732553f, -0.05642922f, 
    0.08232964f, 0.15662141f, -0.04083471f, 0.12891582f, 0.12630372f, 0.09803328f, 0.00650583f, 0.02242317f, 
    0.28349406f, 0.15226826f, 0.07157256f, 0.17555273f, -0.00557648f, -0.01867354f, -0.03499407f, -0.02487391f, 
    -0.11199187f, -0.10457756f, -0.05663717f, 0.35117859f, -0.13134806f, -0.00766769f, 0.05022465f, -0.08408724f, 
    -0.02529155f, -0.15472807f, 0.03491065f, 0.01532965f, 0.09949278f, -0.03867875f, -0.24929658f, 0.09396153f, 
    -0.20955215f, -0.21976773f, -0.13371330f, -0.11180035f, 0.08620931f, -0.02279381f, -0.03399679f, 0.23633423f, 
    -0.05235261f, -0.06352352f, -0.13720278f, 0.07949761f, -0.08014787f, 0.15262669f, 0.00227637f, -0.06420441f, 
    0.05974363f, -0.08136486f, 0.08653656f, -0.18420838f, -0.03475234f, -0.08045164f, 0.07215151f, -0.14729027f, 
    0.13231927f, -0.12673183f, 0.19070359f, 0.06342421f, 0.01076544f, -0.14790548f, -0.06181953f, -0.07421918f, 
    -0.10446372f, 0.05065107f, -0.06686126f, 0.12750952f, -0.03091552f, -0.02755230f, -0.04394550f, -0.18870163f, 
    -0.02200006f, -0.10005705f, 0.23316291f, -0.19158781f, 0.02486492f, 0.04366180f, 0.10999300f, -0.53714812f, 
    0.12852524f, 0.10311266f, -0.02195182f, 0.05699055f, 0.06178541f, -0.04853353f, 0.16646497f, 0.00194744f, 
    0.10421767f, -0.23275702f, -0.32715991f, 0.02816252f, 0.25916454f, -0.07745735f, -0.07079669f, 0.00241524f, 
    -0.03963905f, 0.00349032f, -0.06166659f, -0.04316744f, 0.15846048f, -0.10855408f, 0.05264106f, 0.09623154f, 
    -0.03133207f, 0.13567552f, 0.14032400f, -0.06405947f, -0.08193789f, 0.18643461f, 0.09996264f, 0.21470886f, 
    0.09322560f, -0.11556737f, -0.00200726f, 0.14512740f, 0.01175327f, 0.02314013f, -0.08679156f, -0.19365446f, 
    -0.17079981f, -0.05577293f, -0.04212190f, -0.06505558f, -0.05999474f, 0.18363164f, 0.16723555f, 0.11010271f, 
    0.13534731f, -0.05968816f, 0.03347611f, -0.05869210f, -0.04442530f, 0.12856278f, 0.07789103f, 0.01335680f, 
    0.01307510f, 0.29457486f, -0.11954608f, 0.13393594f, -0.11482529f, -0.05542909f, 0.16896804f, -0.03960611f, 
    0.00305484f, 0.13287367f, 0.14217983f, 0.00953075f, 0.06182542f, 0.14803980f, -0.09814732f, -0.04186956f, 
    0.02511542f, 0.17442195f, 0.01725545f, -0.01677015f, 0.10829602f, -0.01477909f, 0.08410124f, 0.20424084f, 
    -0.08819459f, 0.34766462f, -0.11141009f, -0.05905909f, 0.08953334f, 0.07343936f, -0.02068968f, 0.01060991f, 
    0.07237723f, 0.09508491f, 0.13689661f, 0.11107963f, -0.06986794f, 0.80272549f, 0.11029667f, 0.35017461f, 
    -0.02035194f, 0.09910829f, 0.12285956f, -0.00462912f, 0.01344097f, 0.04412153f, 0.05323284f, 0.04913756f, 
    0.07154388f, 0.10570594f, -0.03323054f, 0.11022467f, -0.21274062f, 0.13140045f, -0.19637538f, 0.16933060f, 
    0.01970361f, -0.13453059f, 0.05000425f, -0.06173197f, -0.10752565f, -0.18382402f, -0.09355186f, -0.14558449f, 
    0.06082172f, -0.07905470f, 0.02412028f, -0.15331598f, -0.12895945f, -0.10864899f, 0.07263628f, 0.02296231f, 
    -0.00240114f, -0.05180131f, -0.01777657f, -0.31758377f, -0.25307679f, -0.11959731f, -0.03299253f, -0.06332197f, 
    -0.12939847f, 0.15920694f, 0.09258745f, 0.00403121f, 0.12332230f, 0.03348515f, 0.05219378f, 0.14015132f, 
    0.12453707f, -0.09398831f, 0.02690885f, -0.05898575f, -0.13112052f, -0.05173098f, -0.03881688f, -0.00034395f, 
    -0.12377289f, -0.24863401f, 0.08026598f, 0.02170721f, -0.05427644f, -0.18823956f, -0.02313086f, -0.05156730f, 
    0.13540365f, 0.28764102f, 0.12811708f, 0.24565019f, -0.34641659f, 0.10411645f, -0.21179855f, 0.40535510f, 
    -0.02555117f, 0.01647560f, -0.14037846f, -0.02273864f, -0.13857862f, 0.04801869f, 0.01628779f, 0.02760142f, 
    -0.30090892f, 0.24237423f, -0.28318313f, 0.01682496f, -0.06980235f, 0.01571278f, 0.07159878f, 0.08020171f, 
    0.25967005f, 0.11047443f, -0.04113875f, 0.07940590f, 0.04586097f, -0.27128306f, -0.35535350f, 0.15506813f, 
    0.05859724f, -0.06847679f, -0.11920360f, 0.06560554f, 0.02385319f, -0.10337697f, -0.03257622f, -0.12571192f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02232466f, 0.35871667f, 0.02406972f, 0.05288575f, -0.07294732f, 0.06766404f, 0.15632047f, -0.06612922f, 
    0.06077363f, 0.04054483f, 0.05138036f, -0.06252818f, -0.06368524f, -0.12160752f, -0.00984330f, -0.06091430f, 
    0.04932183f, 0.13932696f, 0.14436153f, -0.12287255f, -0.09414969f, 0.13501914f, 0.02591593f, 0.16409332f, 
    0.11647879f, 0.03415083f, 0.05581845f, 0.06965248f, 0.15475070f, -0.01110599f, 0.07720444f, -0.00706133f, 
    0.15295242f, -0.02140493f, -0.08596765f, 0.08896790f, 0.13898325f, -0.01195733f, 0.16391689f, 0.03839662f, 
    0.08448321f, 0.06153004f, -0.13887230f, 0.10139301f, -0.08748686f, 0.03663145f, -0.02807726f, 0.09657281f, 
    0.02221847f, 0.11917768f, 0.03902795f, 0.10596715f, 0.03872653f, 0.04298238f, -0.01043359f, 0.07792594f, 
    -0.00832704f, 0.25276703f, 0.00119364f, 0.15616637f, 0.04105227f, 0.07596000f, 0.04650741f, -0.04133607f, 
    0.03058461f, 0.17325816f, 0.12405991f, -0.11643546f, 0.00087589f, 0.08550251f, -0.04353214f, -0.13913710f, 
    0.02351859f, 0.12131941f, 0.11280340f, 0.19713715f, -0.06422997f, 0.07870075f, 0.12562211f, 0.08212022f, 
    0.07807785f, -0.06741620f, 0.01399434f, -0.01996984f, -0.06968529f, 0.18636675f, 0.02866339f, 0.14462781f, 
    0.11696649f, -0.06622029f, -0.05929658f, 0.02831196f, 0.05658130f, -0.00244519f, -0.07777980f, -0.08148925f, 
    0.16715549f, -0.05040515f, 0.03329776f, 0.06982204f, -0.05953899f, 0.12763847f, 0.00268580f, -0.05163565f, 
    -0.07877365f, 0.22208184f, -0.07506323f, 0.18646032f, 0.16124116f, 0.04242576f, 0.12292036f, 0.03701377f, 
    0.06278638f, 0.22479784f, 0.01165607f, 0.08467125f, 0.14552890f, -0.10071783f, 0.01071486f, 0.21893716f, 
    -0.05947326f, 0.00582014f, -0.00857172f, 0.15627231f, -0.04663040f, 0.05265724f, -0.01174601f, 0.05835884f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07167470f, -0.09825917f, -0.32099754f, -0.25202283f, 0.10741241f, 0.14653872f, -0.28217995f, 0.18393306f, 
    0.09660815f, 0.07156857f, -0.14178219f, -0.04389119f, 0.05896705f, 0.25422144f, 0.07535893f, -0.08074368f, 
    -0.08856334f, -0.27750173f, -0.17428549f, 0.44017428f, 0.16167861f, -0.54528058f, -0.10687285f, 0.02182961f, 
    -0.13816068f, -0.22554609f, 0.14209044f, -0.13388819f, -0.18655799f, 0.17259312f, 0.00839792f, -0.29840904f, 
    -0.09885953f, -0.00499430f, 0.03264039f, -0.21455976f, -0.07090251f, 0.11038452f, -0.24032350f, -0.02687137f, 
    -0.15446517f, -0.20582859f, 0.18310796f, 0.04849283f, 0.14612433f, 0.03248320f, -0.13285537f, -0.12884670f, 
    0.11597579f, -0.52244538f, -0.20381147f, -0.05640467f, -0.26843256f, 0.12684008f, 0.17937842f, 0.16304509f, 
    0.08928999f, -0.18535766f, 0.12256146f, -0.38917315f, 0.05209802f, -0.02332058f, -0.07673965f, -0.08173303f, 
    0.03157399f, -0.21978360f, -0.33922493f, 0.10485245f, -0.32915476f, 0.02272600f, 0.07752080f, 0.11982409f, 
    -0.23837408f, -0.30526462f, -0.23860531f, -0.11432637f, -0.02510200f, 0.03525541f, -0.27498868f, 0.06610751f, 
    0.15040140f, 0.19045927f, 0.14689103f, -0.02183433f, 0.06162291f, -0.15342803f, -0.02301260f, 0.01588719f, 
    0.03013123f, 0.18296458f, -0.02893655f, -0.28908977f, 0.06204076f, 0.10468281f, 0.11710191f, -0.08132288f, 
    -0.28605095f, -0.00754924f, 0.05005908f, -0.11267719f, 0.04061408f, -0.45951802f, 0.05944034f, 0.07343587f, 
    -0.07840703f, -0.33226374f, 0.21686319f, -0.34189776f, -0.25136247f, 0.18009466f, 0.12108073f, -0.22901413f, 
    -0.11690333f, -0.36657679f, -0.30259484f, -0.25716710f, -0.33290392f, -0.24139102f, -0.34978738f, 0.03177473f, 
    0.22935766f, 0.10520446f, 0.06204148f, -0.11565133f, -0.35551193f, 0.04204265f, 0.18652463f, 0.04082787f, 
    -0.02756342f, 0.10950783f, 0.28230110f, -0.47808141f, 0.02091707f, 0.03205571f, -0.27063680f, 0.01504838f, 
    -0.19186217f, 0.18599479f, -0.03932495f, 0.01558444f, 0.00765404f, -0.51010621f, 0.06114389f, -0.15906195f, 
    0.06721960f, 0.06593239f, 0.14385851f, -0.60989237f, -0.60541946f, -0.02377974f, 0.36982408f, 0.06640559f, 
    -0.22939360f, -0.21162415f, 0.15917884f, 0.22202185f, 0.37115574f, -0.06576119f, 0.13164918f, -0.22549072f, 
    0.15431169f, -0.03360036f, 0.34253451f, 0.14125142f, -0.03481765f, 0.04208088f, 0.11000854f, 0.03193503f, 
    -0.13763136f, -0.53324431f, 0.08962273f, 0.13089862f, 0.01203378f, -0.00640353f, -0.01003879f, 0.03584900f, 
    0.53513378f, -0.05702823f, -0.14802726f, 0.10049655f, -0.07083589f, 0.16097942f, 0.03635165f, 0.41834027f, 
    0.09591583f, 0.14569595f, 0.12034303f, 0.00854815f, -0.29609504f, 0.05692196f, -0.05227099f, 0.00722871f, 
    -0.13911745f, -0.05326059f, -0.37586454f, -0.05133881f, 0.13605873f, 0.10976650f, -0.13349470f, -0.05682277f, 
    -0.09420269f, -0.15737882f, 0.11580595f, 0.02717422f, -0.01176396f, 0.12092625f, 0.03054544f, 0.09675623f, 
    -0.65663838f, -0.36970109f, 0.20810387f, -0.07277248f, 0.01017607f, 0.14573549f, -0.04544306f, 0.05061035f, 
    0.12568128f, 0.13501394f, -0.00688986f, -0.31324074f, 0.05048008f, 0.05383754f, 0.06512771f, 0.02433820f, 
    -0.16356926f, -0.04190800f, 0.06083496f, -0.12296137f, 0.00687690f, 0.03179816f, 0.13163137f, -0.16518988f, 
    -0.05793767f, 0.14856941f, -0.52877474f, 0.05965861f, 0.22072119f, -0.08401382f, 0.09437484f, -0.17161556f, 
    -0.06704413f, 0.03077613f, -0.15095107f, 0.19965222f, 0.27430457f, -0.25057119f, -0.18330680f, 0.06896373f, 
    0.14083496f, 0.09911152f, -0.00399097f, -0.04043677f, 0.18326087f, -0.04790253f, 0.05660801f, -0.06053754f, 
    -0.07808053f, 0.20920612f, 0.08816443f, -0.09282994f, -0.14820673f, -0.16627251f, 0.03826120f, 0.05899770f, 
    -0.23002772f, 0.29301405f, -0.19338705f, -0.01503906f, 0.02450028f, -0.61551511f, -0.12210418f, 0.05610386f, 
    0.05805499f, 0.00223381f, -0.00336307f, -0.52398151f, 0.23531903f, 0.08733033f, -0.20343909f, 0.02722133f, 
    -0.02828580f, 0.05254697f, -0.67733115f, -0.54375035f, -0.67718428f, -0.45034817f, -0.09390514f, 0.17943627f, 
    0.00562005f, 0.04373930f, -0.30280617f, 0.03168726f, 0.03757844f, -0.05139955f, 0.09639568f, -0.11848496f, 
    0.06808218f, 0.14017606f, 0.01726621f, 0.16007449f, -0.19102474f, -0.09421884f, 0.04021549f, 0.06892709f, 
    -0.31844419f, -0.01469554f, 0.07480980f, 0.00785381f, -0.04227681f, -0.19108675f, -0.06306080f, 0.23264061f, 
    -0.13572119f, -0.00524084f, 0.08723923f, -0.08541875f, -0.12238673f, 0.01160876f, 0.05777278f, -0.02756601f, 
    0.07518491f, -0.03307264f, 0.10046627f, 0.12815447f, -0.33492538f, -0.10710997f, -0.16355582f, -0.68145466f, 
    0.05191553f, -0.00391366f, 0.19241697f, 0.16257462f, 0.01691372f, 0.05408916f, 0.06299043f, 0.11986157f, 
    0.14402446f, 0.20908329f, 0.30600530f, -0.11833582f, 0.05651282f, 0.03193947f, -0.06434425f, 0.21149583f, 
    0.02331739f, 0.13493393f, -0.07946602f, 0.18931550f, -0.27985910f, 0.00912043f, 0.08443978f, -0.04403546f, 
    -0.00522353f, 0.04972203f, 0.06153664f, -0.11746743f, 0.03444394f, 0.06656656f, 0.47913820f, -0.32970023f, 
    -0.05205111f, -0.06428046f, 0.02387911f, 0.16701421f, 0.13875462f, -0.50117970f, -0.07516459f, 0.03253934f, 
    -0.06067583f, 0.03433233f, 0.25025421f, -0.07120035f, -0.01679317f, -0.20582658f, -0.06965280f, 0.10877035f, 
    0.05647639f, -0.01964010f, -0.14951599f, -0.06173433f, -0.36255231f, -0.05383367f, 0.15873787f, 0.29040360f, 
    -0.03882374f, -0.30128130f, 0.15612718f, 0.15428001f, 0.15467522f, 0.15153292f, -0.26471752f, -0.01821504f, 
    -0.01907553f, 0.06742977f, -0.03215591f, -0.02793927f, -0.03429154f, -0.01325448f, -0.05533203f, 0.09718041f, 
    -0.03355252f, -0.02171429f, -0.22092226f, -0.16173580f, 0.11892081f, 0.15556082f, -0.01542169f, -0.27455077f, 
    0.13784786f, -0.21355310f, -0.02412518f, -0.21823291f, -0.11999463f, 0.06872665f, -0.15303837f, 0.19752744f, 
    -0.01968444f, 0.00499287f, -0.01472727f, -0.36098522f, -0.26774213f, 0.07611962f, -0.03424343f, -0.00008784f, 
    0.05304268f, 0.12294286f, 0.04609786f, -0.19600779f, -0.04993011f, -0.04280851f, 0.14323181f, -0.63737881f, 
    -0.14829145f, -0.10026998f, 0.21833047f, -0.06137032f, -0.20577028f, -0.14763400f, 0.08083289f, -0.09502711f, 
    0.11962705f, -0.26514846f, 0.18543147f, -0.06444385f, 0.05198640f, -0.15678254f, -0.04630217f, 0.05909903f, 
    -0.01182254f, -0.42128408f, 0.35583502f, 0.12656322f, -0.33805111f, 0.02021769f, -0.14923169f, 0.08580714f, 
    0.04252118f, 0.08492442f, 0.02844181f, 0.03631980f, 0.06055151f, -0.39520451f, -0.37801841f, -0.05824116f, 
    -0.13038492f, -0.00450143f, -0.03323494f, -0.32635313f, -0.01515334f, -0.21365952f, -0.00659690f, -0.30444351f, 
    -0.37621447f, -0.06439772f, -0.04648321f, 0.29732588f, -0.05991431f, 0.22752574f, 0.02885031f, 0.26681268f, 
    -0.11759008f, -0.03818104f, -0.00929226f, -0.20305339f, -0.06737536f, 0.17147814f, 0.28465679f, 0.12352269f, 
    -0.01833256f, -0.37065038f, -0.02208233f, 0.10872453f, 0.10166491f, -0.15527841f, -0.04776328f, 0.19721615f, 
    -0.09497743f, -0.26358697f, 0.21801133f, -0.22034380f, -0.33254266f, 0.33977127f, 0.11951840f, -0.36017162f, 
    0.16674523f, -0.09613456f, 0.13281709f, -0.00516724f, -0.01715129f, -0.02818905f, -0.05105094f, 0.28714624f, 
    -0.08447298f, -0.26866689f, -0.36666250f, -0.15250430f, -0.09845940f, -0.15570615f, 0.20265952f, -0.17708108f, 
    -0.12695703f, -0.40065721f, -0.10923447f, -0.07366892f, 0.01621569f, 0.15335351f, -0.17148526f, 0.13043271f, 
    0.23744677f, -0.22634928f, -0.41515413f, 0.21331611f, 0.00600738f, 0.11364729f, 0.05901805f, -0.01515514f, 
    0.11741601f, -0.10266202f, -0.04172337f, -0.03607159f, -0.20535690f, 0.03234985f, -0.06526574f, 0.07239943f, 
    -0.23449220f, -0.02398600f, 0.18620507f, 0.13653938f, 0.04584498f, -0.05731878f, 0.11191116f, -0.19862212f, 
    -0.14649062f, 0.06637995f, -0.02736922f, 0.06301991f, -0.02221104f, -0.05052389f, -0.12840362f, -0.00334878f, 
    0.03201810f, 0.09464058f, -0.20958951f, -0.01671378f, 0.06296381f, -0.19279508f, 0.11522152f, -0.37017465f, 
    0.04416471f, -0.22112840f, 0.02061994f, -0.11230306f, -0.05051142f, 0.15372749f, -0.04735610f, 0.02485080f, 
    0.10634819f, -0.08813580f, -0.09770612f, -0.00279380f, 0.24085630f, 0.08711337f, 0.14670391f, 0.11776874f, 
    0.07671403f, -0.12631322f, 0.06224644f, -0.13319145f, -0.07625928f, 0.09311758f, 0.10181687f, 0.02870393f, 
    0.11424261f, 0.16012457f, -0.02756780f, 0.16465896f, 0.03823799f, -0.13045834f, 0.04786664f, 0.12591016f, 
    0.02697621f, 0.03158069f, -0.06148182f, 0.12535651f, -0.06178771f, -0.09098695f, 0.16241784f, 0.12797926f, 
    -0.15934545f, -0.05128885f, 0.01929182f, -0.49193588f, 0.07788400f, -0.11282387f, -0.05659485f, 0.16214609f, 
    -0.07221171f, 0.10333423f, 0.01838819f, -0.06031555f, -0.25941873f, 0.16713287f, -0.04788201f, -0.05207889f, 
    -0.25237986f, 0.05030208f, 0.15088949f, -0.04079399f, 0.26094359f, -0.19330209f, -0.10977944f, -0.05430342f, 
    -0.07229037f, -0.05829651f, 0.06211983f, 0.10180609f, -0.06457854f, -0.01517122f, -0.15412404f, -0.17305285f, 
    -0.02337862f, 0.14906362f, -0.20557427f, 0.29827654f, -0.19690824f, 0.16098012f, 0.16033638f, 0.09458397f, 
    0.15294021f, -0.13808200f, 0.09263414f, -0.07240409f, -0.02530522f, -0.32364202f, -0.07504407f, -0.13084039f, 
    -0.04317931f, -0.07830897f, 0.01148470f, -0.20532478f, -0.05710085f, -0.37952167f, -0.23127542f, 0.16240190f, 
    0.05012044f, -0.07055396f, 0.18370342f, -0.01456749f, 0.14301610f, 0.12759654f, 0.15528800f, -0.46649876f, 
    0.12001791f, -0.01136920f, -0.29155403f, 0.00471184f, 0.14023952f, 0.07329658f, 0.18564530f, 0.10196209f, 
    -0.03484052f, 0.03493376f, -0.31128442f, 0.04943825f, -0.01357245f, 0.01641761f, -0.17473482f, 0.00627050f, 
    -0.11515138f, -0.04437981f, -0.10911793f, 0.12707151f, 0.13057353f, -0.14497799f, 0.10991298f, -0.31869593f, 
    -0.07584436f, 0.13327840f, -0.05131224f, -0.07218941f, 0.25317296f, -0.03022972f, 0.04264486f, 0.00520637f, 
    0.13212405f, 0.16337642f, -0.37162817f, -0.06079881f, -0.06257809f, -0.17973329f, 0.12334308f, -0.02513736f, 
    0.17275281f, 0.17923528f, -0.10488392f, 0.26519945f, -0.05121474f, 0.02913045f, -0.04164685f, -0.11994176f, 
    0.06378587f, 0.06014492f, -0.13365896f, -0.13933346f, -0.02098040f, 0.12313846f, -0.02358339f, 0.17115928f, 
    0.12597577f, -0.37191245f, -0.05843715f, -0.82039893f, -0.17307904f, -0.10022145f, -0.00917527f, -0.02645233f, 
    0.10342798f, -0.03002968f, -0.03385873f, 0.03151019f, 0.05951660f, -0.12119211f, -0.42840579f, -0.07725706f, 
    0.06365567f, 0.00903828f, -0.18210936f, -0.13803525f, -0.21049866f, 0.27003133f, 0.00304481f, -0.12962924f, 
    -0.09406510f, 0.19030525f, -0.35544744f, -0.09911197f, -0.62786919f, -0.18457274f, -0.13602738f, 0.12846285f, 
    -0.10125431f, -0.21769060f, 0.13593982f, 0.22014047f, 0.36963019f, -0.08810353f, 0.20515813f, -0.52893299f, 
    -0.05384646f, 0.13417263f, -0.27571040f, -0.03533305f, 0.02865508f, -0.38984951f, 0.15804492f, -0.07361163f, 
    -0.11858956f, -0.08655805f, 0.05273695f, 0.07798532f, -0.00137946f, -0.32424000f, -0.18099460f, 0.12875912f, 
    -0.14582247f, -0.00568390f, -0.02261284f, -0.28156942f, -0.14862514f, 0.20248099f, -0.51101536f, -0.17407332f, 
    -0.02278608f, 0.03725143f, -0.55902994f, 0.22889656f, 0.09869941f, -0.29032469f, 0.08915156f, -0.00954739f, 
    0.14377846f, -0.03684947f, -0.11327921f, 0.04980791f, 0.17164254f, -0.11981570f, -0.15765612f, 0.06435750f, 
    0.00729026f, 0.26042834f, -0.12331443f, 0.08813252f, -0.07009082f, 0.02071328f, -0.28149697f, 0.25701928f, 
    -0.17161809f, 0.13523999f, -0.04369982f, -0.18882158f, 0.09601277f, 0.02211225f, -0.62751931f, -0.21811707f, 
    -0.55310845f, -0.10892002f, -0.09441450f, 0.14429089f, -0.17760491f, -0.01354974f, -0.05993106f, -0.07566404f, 
    -0.36578786f, 0.25771943f, 0.44301316f, 0.11263985f, -0.48381686f, -0.03074094f, -0.06461903f, -0.40783656f, 
    -0.13016771f, -0.03501207f, -0.10483027f, -0.17828558f, 0.00471101f, -0.05572328f, 0.16500930f, -0.17537330f, 
    0.24225855f, -0.10942596f, 0.15016073f, -0.16685762f, 0.03570458f, -0.11722369f, 0.02826598f, -0.25261369f, 
    0.13140269f, -0.21385445f, -0.01109553f, 0.19274278f, -0.11990994f, -0.22592744f, -0.63432539f, -0.06193516f, 
    0.11434235f, 0.05521284f, 0.00600096f, 0.19688131f, 0.04531575f, -0.01575278f, 0.23340985f, -0.22167212f, 
    -0.08371028f, -0.04340186f, 0.22731587f, 0.03036300f, -0.08746152f, -0.29370841f, -0.15941572f, -0.16725120f, 
    0.21953939f, 0.17474079f, -0.10305884f, 0.29695308f, -0.29925749f, 0.03473221f, 0.18433373f, 0.12754282f, 
    -0.29566225f, -0.26415572f, -0.33200034f, -0.25677484f, -0.20877746f, -0.08597595f, -0.38241875f, 0.42124331f, 
    -0.00087237f, -0.13755082f, 0.28496072f, 0.15954562f, -0.21857673f, -0.26770249f, -0.32603446f, -0.03338651f, 
    -0.22151653f, -0.03560317f, 0.12678303f, -0.07558683f, 0.07481643f, 0.09471129f, 0.04140659f, 0.01202901f, 
    -0.38749397f, -0.00934349f, 0.04232039f, -0.11952640f, 0.30332690f, -0.20632608f, -0.03599018f, -0.09879777f, 
    -0.36294481f, 0.09764548f, -0.18396278f, 0.04456869f, -0.15870711f, 0.06449410f, -0.10611150f, 0.30415258f, 
    0.14679530f, 0.04089657f, -0.02785804f, -0.28350812f, 0.08553143f, -0.20045412f, -0.20225447f, 0.09029421f, 
    -0.11303005f, 0.15508986f, 0.11478651f, -0.09400671f, -0.28003141f, -0.07965609f, 0.19142348f, -0.10862723f, 
    0.03557546f, 0.06802490f, 0.23799106f, -0.04913268f, 0.17257702f, -0.02879693f, -0.10419224f, -0.28394094f, 
    -0.22528982f, -0.01982655f, 0.18234468f, -0.36359471f, -0.16758423f, -0.23644042f, -0.08250684f, -0.00369522f, 
    -0.17956659f, -0.12152802f, -0.21124429f, -0.31144515f, 0.14738551f, 0.14096500f, 0.08893566f, -0.19514091f, 
    0.15286382f, 0.02271320f, -0.15657890f, -0.33450282f, -0.08754820f, -0.03038939f, 0.09456270f, -0.15372381f, 
    0.29748586f, 0.05369190f, -0.50240171f, 0.24405850f, 0.00557177f, -0.06592809f, 0.01819474f, -0.14500090f, 
    -0.06589436f, -0.26129618f, -0.09463535f, 0.07080288f, -0.06062016f, -0.19036099f, 0.22042535f, 0.13460118f, 
    0.14118624f, 0.02198219f, -0.10204685f, 0.07911939f, 0.06980553f, 0.14398958f, -0.33064726f, -0.14383750f, 
    0.01279892f, -0.10604440f, 0.35290480f, -0.04378039f, 0.04449525f, -0.19401844f, -0.09179611f, 0.03314000f, 
    0.07148685f, -0.17650464f, 0.01802981f, -0.24185354f, -0.19119211f, 0.24877922f, -0.22403750f, -0.19942217f, 
    -0.05921936f, 0.01772584f, 0.02268341f, -0.35933691f, 0.08084482f, 0.01084128f, 0.14041784f, -0.48551899f, 
    0.03418860f, 0.18070556f, 0.01930127f, 0.31107906f, 0.04497196f, -0.33558324f, 0.12463505f, 0.02781207f, 
    -0.06720258f, -0.02080901f, 0.18848419f, -0.08896431f, -0.04005531f, -0.38442332f, 0.22231786f, -0.14930688f, 
    -0.48120973f, -0.06910829f, 0.17644085f, -0.23386061f, -0.27566382f, -0.32178575f, 0.11554872f, 0.15996552f, 
    0.07506566f, 0.19834268f, -0.21150969f, -0.18831378f, -0.23336911f, 0.01133358f, -0.05813418f, -0.16003780f, 
    -0.12815325f, 0.04604859f, -0.22912608f, 0.11060015f, -0.21507217f, 0.05718195f, -0.65276808f, 0.07980565f, 
    0.34747812f, -0.06160131f, -0.18311211f, -0.19754557f, -0.09517672f, -0.00319177f, 0.26455948f, -0.12960728f, 
    -0.28982630f, 0.01768974f, 0.08753224f, 0.19199218f, -0.19882952f, -0.06208709f, -0.36165729f, 0.25327912f, 
    -0.17458840f, 0.10735498f, -0.07384642f, 0.27643049f, 0.28185248f, -0.43811238f, 0.02734357f, -0.01219287f, 
    0.04978471f, 0.09932242f, 0.27163154f, -0.29576674f, -0.05960866f, -0.20213549f, 0.21344598f, -0.35047665f, 
    0.04368219f, 0.18706948f, 0.20829444f, 0.01517632f, 0.02718518f, 0.10767040f, -0.22858606f, 0.05602540f, 
    -0.39837611f, -0.06460099f, -0.06500654f, -0.05739271f, -0.01950075f, 0.27260157f, 0.05483546f, 0.18402213f, 
    -0.28826761f, -0.51358259f, 0.01356145f, -0.03720839f, -0.25576359f, -0.25310159f, -0.47391081f, -0.33770335f, 
    0.03374876f, 0.06001876f, 0.03939730f, -0.13315473f, -0.01029834f, -0.17225793f, -0.18560320f, -0.37956920f, 
    -0.01458642f, -0.07796360f, 0.10590210f, -0.03235561f, -0.06580290f, -0.32157770f, 0.25188076f, 0.25160247f, 
    -0.09299713f, -0.22724894f, -0.03385741f, -0.25845376f, 0.11231675f, 0.23250209f, -0.09417637f, 0.10655250f, 
    0.16074510f, 0.32276663f, 0.10077223f, -0.03438939f, -0.09850019f, 0.05398237f, -0.34741548f, -0.11868937f, 
    0.02888369f, -0.05887228f, -0.12479164f, 0.08004048f, -0.21068969f, -0.03493012f, 0.17533229f, -0.39389315f, 
    -0.33031589f, -0.20617773f, -0.50466329f, -0.02105150f, 0.04375804f, 0.25859505f, -0.34695891f, 0.09404764f, 
    0.14277436f, 0.03708774f, 0.19443883f, 0.12786616f, 0.18958397f, -0.15296157f, 0.30958745f, -0.11185156f, 
    0.07855742f, 0.09234719f, -0.06541805f, -0.20299552f, -0.05514913f, 0.38871905f, -0.23425625f, 0.22682826f, 
    -0.26219648f, 0.02698486f, 0.14460059f, 0.07672465f, 0.17394133f, -0.09366559f, 0.18665026f, -0.22978859f, 
    -0.08376773f, -0.02946553f, 0.08994736f, -0.11655495f, -0.39143011f, 0.01068042f, 0.21572088f, 0.18452889f, 
    -0.04194962f, -0.08903401f, -0.38782689f, -0.33940622f, 0.09521696f, -0.36275399f, -0.24348056f, -0.13583417f, 
    0.25627267f, 0.15875787f, -0.47003344f, -0.12033906f, 0.08744354f, 0.14986107f, 0.06768955f, -0.06893153f, 
    0.16768515f, 0.07724056f, -0.28182289f, -0.04289814f, 0.03043560f, 0.09095561f, -0.13508581f, -0.10490234f, 
    -0.07216711f, 0.04755246f, 0.23938435f, -0.31853235f, -0.05864420f, -0.13234644f, 0.14780734f, -0.28056613f, 
    0.15841664f, 0.24908653f, -0.06369353f, 0.23570602f, 0.07036239f, -0.31724879f, 0.06569567f, -0.25110954f, 
    0.21639220f, 0.13980880f, 0.04652008f, 0.17435221f, 0.21929011f, -0.33472979f, -0.02209023f, -0.47759908f, 
    0.08453476f, -0.04950887f, -0.00440902f, 0.18370943f, -0.04635007f, -0.13532647f, -0.27635852f, 0.20926541f, 
    -0.01993119f, 0.17707807f, -0.08694053f, -0.04531488f, 0.04365525f, 0.23801400f, -0.23131646f, -0.48329389f, 
    0.10651714f, 0.17244387f, -0.21207671f, 0.30214438f, 0.31980893f, 0.05269567f, -0.21490416f, 0.24433604f, 
    -0.30473742f, 0.01520629f, -0.34408686f, -0.01834551f, 0.25294739f, -0.04876636f, 0.07900831f, -0.06256709f, 
    -0.01517207f, 0.11061317f, -0.19968919f, -0.16874796f, 0.34131345f, -0.13300583f, -0.03814637f, -0.25085533f, 
    0.13419071f, 0.28573617f, 0.26632860f, 0.05863644f, -0.03426123f, -0.37174174f, 0.07249250f, -0.09487797f, 
    0.13381320f, 0.28318217f, -0.29940397f, -0.16087954f, -0.37326017f, -0.10019454f, -0.32070357f, -0.11301938f, 
    0.19302939f, -0.09955016f, 0.14854278f, -0.16659412f, -0.35411224f, 0.10653725f, 0.12386136f, -0.21010204f, 
    0.15831465f, 0.02726262f, -0.21115483f, -0.06312872f, -0.36225408f, 0.15440156f, 0.06178867f, 0.26614869f, 
    -0.13826805f, -0.19459178f, -0.28793716f, -0.59571278f, -0.12435308f, -0.04694774f, -0.21581204f, 0.02140969f, 
    -0.45254177f, 0.00628618f, 0.05340062f, -0.24835433f, -0.20261434f, 0.26794153f, -0.16247420f, 0.20430101f, 
    -0.50664055f, -0.27011502f, -0.21067707f, 0.23762070f, 0.11197847f, 0.04408255f, -0.08825468f, 0.04177238f, 
    0.22161631f, 0.06541159f, 0.23913477f, -0.04255456f, -0.09160504f, -0.12822798f, -0.39273334f, 0.15813553f, 
    0.07994237f, -0.14703059f, 0.03020554f, 0.16095690f, 0.03450331f, 0.10212443f, 0.04081588f, 0.05523109f, 
    -0.17830420f, -0.70995843f, -0.59614605f, 0.33988968f, -0.04913329f, -0.23527732f, 0.04898710f, 0.20716080f, 
    0.07559141f, -0.06514943f, -0.05757684f, -0.19626543f, 0.27694422f, 0.29693088f, -0.44601238f, 0.10095070f, 
    0.14601715f, 0.03488278f, 0.02441144f, -0.03645140f, 0.00435760f, 0.32487506f, -0.18421669f, 0.10780852f, 
    0.04851282f, 0.10768006f, -0.10582212f, 0.14398374f, 0.07445920f, -0.47878307f, -0.50345707f, 0.32085115f, 
    0.03195429f, 0.00284936f, 0.02698376f, -0.01735005f, -0.08542071f, -0.08451437f, 0.18287756f, -0.18783410f, 
    -0.40742585f, 0.22067480f, 0.19292627f, -0.06108607f, -0.14468032f, -0.05434107f, 0.04432123f, 0.03421895f, 
    0.06804618f, 0.07852725f, -0.22728375f, 0.07504818f, 0.20644030f, 0.23242007f, 0.13506404f, 0.07421353f, 
    0.25031716f, -0.18130571f, 0.23681532f, 0.01350961f, -0.03024781f, 0.19287722f, -0.11423095f, -0.17136393f, 
    -0.23492971f, 0.18073161f, 0.09478065f, -0.62535453f, 0.06277913f, 0.30833253f, 0.06068303f, 0.26955041f, 
    0.18884784f, 0.06917294f, -0.37101489f, 0.15544277f, -0.21723108f, -0.25127402f, 0.05996623f, -0.33205986f, 
    -0.02680733f, -0.06657457f, -0.42308944f, -0.21710074f, -0.19091450f, -0.48927647f, 0.02919267f, -0.21364173f, 
    -0.17984597f, 0.12339111f, 0.14211123f, 0.26102379f, 0.46252838f, 0.04514845f, -0.00500168f, 0.11149003f, 
    -0.06286831f, 0.15310982f, 0.25319007f, 0.23617709f, -0.16909428f, 0.28690493f, 0.07036304f, -0.07823579f, 
    0.20669718f, 0.07826626f, -0.03110254f, -0.02967578f, -0.25075957f, 0.16564274f, -0.06472793f, -0.03395353f, 
    -0.27490395f, -0.18237884f, -0.14397483f, 0.14676633f, -0.01712764f, -0.31250477f, 0.05621415f, -0.11403869f, 
    -0.37631249f, 0.20768319f, -0.65160543f, -0.02317535f, -0.02547866f, -0.28466734f, -0.11639454f, 0.08525243f, 
    -0.31979007f, -0.36839220f, -0.37904710f, -0.01503590f, -0.07416721f, -0.21617849f, 0.08116379f, -0.39390653f, 
    -0.09768199f, 0.32915506f, -0.02773939f, -0.12637527f, -0.02166926f, -0.37290031f, -0.08226010f, -0.02886852f, 
    -0.05754332f, -0.03184192f, 0.04086094f, 0.19522895f, 0.05883040f, 0.01973923f, -0.32020211f, 0.29503134f, 
    -0.02752551f, -0.13527697f, -0.36046052f, 0.20534952f, 0.16020930f, 0.13591261f, 0.12857096f, 0.02270374f, 
    0.16029386f, 0.09627715f, 0.27388752f, -0.17481248f, -0.24243769f, -0.04923715f, 0.31049407f, -0.41979438f, 
    0.00599343f, -0.45140341f, -0.12625025f, -0.30273852f, -0.30488327f, -0.04934035f, -0.46951661f, 0.08423434f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23537987f, 0.04724748f, 0.13791445f, 0.01528957f, 0.04228239f, 0.13214935f, 0.07439734f, -0.02593912f, 
    0.00969084f, -0.03959827f, 0.01892445f, 0.00800800f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
