#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07590529f, 0.08278462f, 0.32463980f, -0.72152132f, 0.63582134f, -0.14082067f, -0.79565138f, -0.71207875f, 
    -0.78580064f, -0.70250911f, 0.09566417f, 0.54809231f, 0.20548730f, 0.10246101f, 0.00023732f, 0.04236834f, 
    -0.17786188f, -0.07300564f, -0.02983316f, 0.43308026f, -0.04445161f, 0.17973033f, 0.17389406f, 0.28263032f, 
    0.30498478f, 0.31021786f, 0.99771702f, 0.80544275f, 0.42926294f, 0.10523481f, -0.72989464f, 0.51356596f, 
    -0.31227037f, -0.46599042f, 0.18407042f, 0.05845922f, 0.06438637f, 0.03148916f, 0.30860686f, 0.15958229f, 
    0.01611290f, -0.12200283f, 0.20473664f, -0.01792927f, -0.30123076f, 0.19226024f, 0.24046658f, 0.00834694f, 
    0.22374129f, 0.06692290f, 0.73697746f, -0.38775086f, 0.13515460f, 0.24001300f, -0.01944944f, -0.35674474f, 
    -0.60802859f, 0.31159151f, 0.79564697f, -0.40115008f, -0.34873962f, 0.11084941f, 0.19263062f, -0.33034599f, 
    -0.13444027f, -0.26676449f, -0.18831599f, 0.33075956f, 0.32624286f, -0.00456152f, 0.13537872f, 0.22867654f, 
    -0.04130335f, 0.19492956f, -0.42291495f, -0.81694913f, 0.80303603f, 0.35323253f, 0.69602150f, -0.52102852f, 
    0.08949465f, -0.30163646f, -0.23925160f, 0.38715219f, -0.52556467f, 0.04189161f, -0.07444084f, 0.03548582f, 
    -0.01799478f, 0.11712483f, -0.03651870f, 0.26953045f, 0.07942921f, 0.25883272f, 0.16684744f, 0.07091115f, 
    -0.44813424f, -0.36482117f, -0.27008623f, -0.23196557f, 0.25379467f, 0.01840627f, 0.49728400f, 0.48997310f, 
    -0.26046452f, -0.24572863f, -0.85732239f, -0.00482958f, -0.14790300f, 0.23494403f, 0.35098535f, 0.19462487f, 
    0.08312779f, -0.15421018f, -0.21657443f, 0.07311767f, 0.21318839f, -0.20083621f, 0.27867222f, 0.59555137f, 
    -0.32586139f, 0.03002865f, -0.25697872f, -0.36074075f, -0.00244663f, -0.42590430f, -0.10834587f, -0.38766834f, 
    0.33501858f, 0.07942651f, -0.65566337f, 0.06511778f, -0.07459178f, -0.61625659f, -0.50877941f, -0.02885836f, 
    0.20966311f, -0.19654815f, 0.35875297f, 0.08007556f, 0.05000417f, 0.24618375f, 0.08318607f, -0.36404851f, 
    0.11423010f, -0.12791279f, 0.09748034f, 0.28309357f, 0.38390779f, -0.26902130f, 0.58258665f, -0.42019609f, 
    -0.28881449f, 0.14619751f, 0.37108266f, 0.05944288f, -0.30915067f, -0.34654903f, -0.17012687f, -0.12074649f, 
    0.29418033f, 0.31945527f, 0.11883113f, -0.06423251f, 0.51045024f, -0.50543553f, -0.34247357f, -0.37579492f, 
    -0.29455888f, -0.38557547f, -0.09655025f, -0.13279322f, 0.36080348f, 0.39366159f, 0.24586955f, 0.80410552f, 
    0.14984195f, 0.32493505f, 0.24295312f, 0.47273275f, 0.08979365f, -0.38232881f, -0.57358998f, 0.67938638f, 
    -0.25840011f, -0.41136274f, -0.22721007f, -0.34230506f, -0.17366232f, -0.14954591f, 0.30068395f, 0.08092655f, 
    -0.38033020f, 0.10919786f, 0.02434103f, -0.04525734f, -0.28007990f, 0.14169917f, -0.18316299f, 0.15240403f, 
    0.57993954f, -0.08321735f, -0.20337687f, 0.88095587f, 0.76223403f, 0.62175202f, 0.34737694f, -0.08787818f, 
    0.30236113f, 0.34057966f, -0.34270290f, 0.00327672f, -0.28727326f, -0.15719223f, 0.06426682f, -0.14028700f, 
    -0.24137571f, -0.23833732f, -0.21088742f, 0.04089747f, 0.12975794f, 0.16225609f, 0.34419444f, -0.04309823f, 
    0.13078596f, -1.16127014f, -0.61415559f, -0.14369152f, 0.33153906f, -0.13729183f, 0.60891134f, 1.04552734f, 
    0.41341388f, -0.18472077f, -0.01161588f, -0.20374294f, -0.41604370f, 0.09406642f, -0.01252920f, 0.08538165f, 
    -0.09637266f, -0.17348647f, -0.43787944f, -0.18853684f, -0.15721178f, -0.07226073f, 0.08005669f, 0.12468426f, 
    0.10732757f, -0.01487206f, -0.36774197f, -0.34029311f, -0.57518607f, -0.27181059f, -0.08319292f, 0.06850494f, 
    -0.56595176f, -0.19059390f, -0.13174455f, 0.08073542f, 0.02464681f, 0.13619693f, -0.19676878f, -0.17284764f, 
    0.23758608f, 0.13615257f, -0.22504590f, -0.06795108f, 0.03379504f, 0.28380969f, 0.27518544f, 0.43117735f, 
    0.06802938f, -0.39971128f, -0.31758565f, 0.47654861f, -0.04292839f, -0.12545387f, 0.40862533f, -0.53432763f, 
    -0.50526690f, -0.46595344f, 0.55935496f, -0.00056650f, -0.28853989f, -0.32986125f, -0.26042661f, -0.07254291f, 
    -0.25549373f, -0.04378387f, 0.10252155f, 0.28989315f, -0.19045784f, -0.22162351f, 0.01346980f, 0.28588709f, 
    -0.28688291f, 0.12926245f, -0.45420706f, -0.11402383f, 0.64490563f, 0.86858511f, 0.71384078f, 0.73755068f, 
    0.26142055f, 0.30641824f, 0.23436376f, -0.56230450f, -0.16726688f, -0.35080090f, 0.31198305f, 0.12609391f, 
    0.27050307f, 0.01346868f, -0.34624746f, 0.17156076f, 0.04288333f, 0.23795027f, -0.10173212f, -0.17209151f, 
    -0.15101381f, 0.17636468f, 0.03016131f, -0.03369203f, -0.18826976f, 0.94079447f, 0.54044360f, -0.98274350f, 
    -0.71766698f, -0.13502511f, -0.11175483f, -0.35336283f, 0.20599715f, -0.00187445f, -0.17117867f, -0.15908447f, 
    0.34059295f, 0.48550230f, 0.09857725f, -0.40219611f, -0.04212982f, -0.14322832f, -0.08225998f, 0.01622370f, 
    -0.14731550f, -0.06736933f, 0.05769033f, 0.26686102f, -0.12106955f, 0.14697814f, -0.35570538f, -0.55023205f, 
    0.97049564f, 0.44698694f, -0.56262761f, 0.28677785f, 0.18755518f, 0.64697951f, -0.43737370f, -0.46287507f, 
    0.14379451f, -0.26196969f, -0.21710010f, 0.27096838f, -0.03700578f, -0.02962134f, 0.42378569f, 0.09218973f, 
    -0.22294110f, 0.24063440f, 0.08186786f, 0.12028548f, -0.13177912f, 0.17695560f, -0.35204497f, -0.78605533f, 
    -0.34605154f, -0.41285211f, -0.40915394f, -0.14039849f, -0.05488710f, -0.22621420f, -0.04017727f, 0.58412170f, 
    0.09276930f, -0.18961526f, -0.14182796f, -0.28269893f, -0.33962497f, 0.01367437f, 0.33341882f, -0.00549859f, 
    0.10578664f, -0.06990080f, -0.32776088f, 0.24893819f, -0.05272797f, 0.42741093f, 0.05510909f, 0.41957995f, 
    0.07224956f, -0.52653873f, -0.75356686f, -0.41198957f, 0.29770821f, -0.01689442f, -0.06607687f, -0.43552271f, 
    -0.19870208f, -0.30028492f, -0.49566191f, -0.14564306f, 0.43970203f, 0.40022960f, -0.26396427f, 0.04930110f, 
    0.01879037f, -0.04805655f, -0.13197832f, -0.10758281f, 0.00482517f, -0.27640697f, 0.08271535f, 0.12855177f, 
    -0.11576498f, -0.08026639f, 0.86989510f, -0.25757653f, -0.42693496f, -0.03443134f, 0.34988949f, -0.49643338f, 
    -0.72325689f, -0.33928490f, 0.16098036f, 0.33372986f, -0.18564554f, 0.22677399f, -0.10843345f, 0.18516594f, 
    0.15561493f, 0.09514740f, 0.41135517f, 0.29878804f, 0.15922494f, -0.06862634f, 0.26192302f, -0.26935399f, 
    -0.03597147f, -0.22599214f, 0.24768001f, -0.54769707f, -0.90421981f, -0.71568710f, 0.21525031f, 0.65584385f, 
    -0.21264690f, 0.76877022f, 0.64286941f, 0.07526821f, -0.27709115f, -0.09084494f, -0.29029107f, 0.08435030f, 
    -0.05419172f, 0.14264706f, 0.06708647f, 0.11502685f, 0.19401780f, 0.17589509f, -0.01380168f, -0.15357922f, 
    -0.28862551f, -0.19370784f, 0.07828628f, 0.55268055f, 0.42771995f, 0.44918129f, 0.79830909f, 0.47014567f, 
    -0.01709223f, 0.02558343f, 0.20100233f, 0.01503218f, 0.45843381f, 0.18741202f, -0.39166307f, -0.18771753f, 
    0.07195268f, -0.25563630f, 0.21265921f, 0.10139725f, 0.16245210f, 0.12509041f, 0.43679020f, 0.12770879f, 
    -0.11072773f, 0.42000782f, 0.01753784f, 0.03465841f, 0.30799180f, 0.32817683f, 0.11928691f, 0.87068719f, 
    0.35777926f, 0.55387878f, 0.21936958f, 0.30818614f, -0.11777962f, -0.33890888f, -0.21752734f, 0.01686603f, 
    -0.42109385f, -0.13946737f, -0.19778313f, -0.37428540f, -0.03324842f, 0.00967438f, -0.20669439f, -0.33213362f, 
    -0.01254516f, -0.28325248f, -0.51280683f, -0.22457586f, -0.08342394f, -0.07158925f, 0.09072639f, -0.02818511f, 
    -0.68186480f, -0.34543568f, 0.75907940f, 0.38443965f, -0.33383939f, -0.22412932f, 0.02537697f, 0.37932450f, 
    0.46257478f, 0.18062352f, 0.14062835f, 0.40479082f, -0.23735084f, -0.35096562f, 0.13699703f, 0.12155146f, 
    0.03824593f, 0.34644043f, 0.20960332f, -0.08373424f, -0.08947677f, 0.17427213f, 0.08478048f, -0.21462607f, 
    0.58820665f, 0.60852504f, -0.19593437f, 0.25484219f, 0.17675076f, 0.31925312f, 0.53106320f, 0.73283792f, 
    -0.20143418f, -0.02146161f, 0.04251982f, -0.35184494f, -0.28475472f, -0.02345664f, -0.38868460f, -0.37293938f, 
    -0.03524913f, -0.17791174f, 0.33120546f, -0.06345195f, -0.19291086f, -0.03921713f, -0.22524843f, -0.60557950f, 
    0.04043584f, -0.16725142f, -0.54021645f, -0.49491218f, 0.72523648f, -0.19806834f, -0.17542207f, -0.09918352f, 
    0.14146136f, -0.21787214f, -0.56060117f, 0.37590834f, -0.09576192f, -0.49512997f, -0.15150960f, -0.14013650f, 
    -0.06086040f, -0.25361624f, 0.33762592f, -0.03937629f, -0.08304878f, 0.07745655f, 0.10102925f, -0.27777120f, 
    -0.28581837f, -0.43674642f, -0.28575572f, -0.61038738f, -0.54886234f, -0.04611848f, -0.67084473f, -0.15622433f, 
    -0.03132550f, -0.26197541f, -0.04112365f, -0.27986711f, 0.06691585f, -0.13517438f, 0.17881551f, 0.16089687f, 
    0.37069246f, -0.09494299f, 0.23582041f, 0.16190776f, 0.36910415f, -0.23509489f, -0.10717798f, 0.10258678f, 
    0.30127755f, 1.05494165f, 0.35305110f, -0.35788041f, 0.94153976f, 0.39023313f, 0.16162413f, 0.33859280f, 
    -0.45155767f, 0.48960847f, -0.13747340f, -0.23257722f, -0.15010941f, -0.20790638f, 0.19659632f, -0.37064672f, 
    -0.03587893f, 0.08281813f, 0.05832004f, -0.05770389f, -0.14363603f, 0.25780454f, 0.15655828f, -0.03434912f, 
    0.10726303f, 0.17800637f, -0.10742380f, 0.19791862f, -0.57158339f, 0.68576980f, 0.63370723f, 0.66720182f, 
    0.16131152f, -0.45703122f, -0.27582034f, -0.19178727f, -0.53902590f, -0.21526058f, 0.26800948f, -0.07264545f, 
    0.26332200f, 0.27062598f, 0.04650024f, 0.09420292f, 0.22668907f, 0.13163519f, 0.17351714f, 0.27199018f, 
    0.18716618f, -0.15921165f, -0.18352596f, -0.54227448f, -0.95589280f, -0.75054812f, 0.05602406f, -0.26631704f, 
    0.63846076f, 0.81041837f, -0.08461876f, 0.49553767f, 0.52027148f, -0.40237534f, 0.11378101f, 0.05581330f, 
    0.10312097f, 0.21028608f, -0.15242027f, -0.10432889f, 0.22655554f, 0.05811612f, -0.22396874f, 0.13181914f, 
    -0.06164158f, 0.10207395f, 0.17948686f, -0.02553243f, -0.13151847f, -0.16087657f, 0.41915128f, -0.42806798f, 
    -0.37376443f, -0.67571616f, 0.76347631f, -0.38233170f, -0.21576436f, 0.13359752f, -0.12920220f, 0.46457174f, 
    -0.39076158f, 0.01198451f, 0.18014549f, -0.23837107f, -0.17594019f, 0.21713021f, -0.24964474f, -0.19802530f, 
    0.24779396f, 0.09068692f, -0.09108284f, -0.02707979f, -0.06312490f, -0.80795550f, 0.25201556f, 0.13148220f, 
    -0.27289274f, -0.42484528f, 0.29166946f, 0.27966782f, -0.38807043f, 0.02699679f, -0.40513894f, -0.07643655f, 
    -0.01799882f, -0.31427908f, 0.01646481f, -0.25498769f, -0.36366826f, 0.09135342f, -0.27587828f, -0.39878175f, 
    -0.58517838f, 0.32138231f, 0.31233981f, 0.09727388f, 0.23124753f, -0.20211199f, 0.82329375f, 0.62824994f, 
    0.59334546f, -0.19338952f, -0.22595972f, 0.04750417f, -0.17501004f, -0.46852964f, 0.18298712f, -0.08739940f, 
    0.58342028f, -0.08342879f, -0.46552750f, -0.04395303f, -0.25859287f, -0.19355987f, -0.06388152f, -0.27890629f, 
    -0.11588653f, 0.04105249f, 0.32357576f, 0.03433407f, 0.19538778f, 0.00589924f, 0.07962080f, 0.01198945f, 
    -1.06780541f, -0.13059789f, 0.94428176f, 0.16418728f, -0.83661836f, 0.62024528f, 0.39565787f, -0.39639789f, 
    0.37862283f, 0.32908213f, 0.33973667f, 0.12102132f, 0.04890767f, 0.19759589f, -0.20700541f, 0.18395306f, 
    0.18199876f, 0.10397207f, -0.20237175f, 0.22257467f, -0.09745307f, -0.12540969f, -0.07036781f, 0.02263749f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16079907f, 0.09573238f, 0.12432896f, 0.11269993f, 0.08572575f, 0.31229490f, 0.31868437f, 0.17963448f, 
    0.04726539f, 0.09244329f, 0.22873943f, -0.05280661f, 0.02757797f, 0.04641883f, 0.04453707f, 0.15942879f, 
    0.35055813f, 0.03859070f, 0.12069047f, 0.06856926f, -0.09106649f, 0.07048320f, 0.18488666f, -0.01778533f, 
    0.03168504f, 0.14647117f, 0.05858700f, 0.16348110f, 0.13083686f, 0.06146593f, 0.28970093f, 0.28795141f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16488241f, 0.00542626f, -0.15442953f, -0.05956564f, -0.09171496f, 0.09037326f, -0.01064762f, -0.00584854f, 
    0.05971167f, -0.22357613f, -0.04753122f, 0.07607686f, 0.47579050f, 0.10794496f, -0.06190363f, -0.00533257f, 
    0.04798586f, -0.15464677f, 0.01722793f, -0.00693123f, -0.08039729f, 0.12023245f, -0.02819692f, -0.01287488f, 
    0.19636998f, 0.02356881f, -0.00066358f, -0.05726108f, 0.12660818f, 0.00152766f, 0.08647707f, 0.12841503f, 
    0.00023808f, -0.04012149f, 0.04507476f, 0.03465701f, 0.23374692f, -0.04011809f, 0.26573130f, 0.09740989f, 
    -0.16545831f, -0.10172994f, 0.03559304f, -0.04492647f, 0.07334638f, 0.05575768f, 0.01788419f, 0.05064258f, 
    0.03184921f, 0.11001060f, -0.05694601f, -0.14021802f, 0.14369668f, -0.04243472f, 0.12520877f, 0.06514897f, 
    0.06216060f, -0.05653713f, -0.09376713f, 0.00721459f, -0.16250241f, 0.13468994f, -0.08953001f, 0.02806620f, 
    0.06389808f, -0.08613279f, 0.00681225f, -0.06976161f, 0.05862057f, 0.01073224f, -0.02974369f, -0.09209465f, 
    -0.03691592f, -0.06323224f, -0.12668623f, -0.06375802f, -0.01350449f, -0.16439494f, 0.14407629f, -0.08248597f, 
    -0.16486968f, 0.01115347f, 0.02263689f, 0.02326044f, -0.09391945f, 0.07731293f, -0.02854133f, -0.13953252f, 
    -0.10002965f, -0.04573819f, -0.07107488f, -0.02989919f, 0.00285226f, 0.11160909f, 0.17437679f, -0.05663635f, 
    0.05893529f, -0.02093553f, 0.24574256f, 0.15453935f, -0.06513220f, -0.09435453f, -0.09262217f, 0.12637731f, 
    -0.03320961f, -0.03978110f, -0.05676866f, -0.03558265f, 0.15494609f, -0.28697258f, 0.28921598f, -0.05403817f, 
    0.11385342f, 0.19574247f, -0.03674911f, -0.08010212f, 0.07352469f, 0.07214326f, 0.14610574f, 0.00865769f, 
    -0.26623881f, 0.04001524f, 0.18662402f, -0.01426199f, 0.08399561f, -0.02845461f, 0.05996939f, -0.07123875f, 
    -0.00098821f, -0.11460492f, 0.01901420f, 0.01625346f, -0.10164808f, -0.01778784f, 0.04670120f, 0.14854759f, 
    0.00232040f, -0.14546441f, 0.02774438f, 0.07614993f, 0.05537154f, 0.11017258f, -0.02291032f, -0.11775799f, 
    0.32810551f, 0.24875982f, -0.11795446f, -0.03436865f, -0.04944609f, -0.05769088f, 0.02554516f, 0.11953296f, 
    -0.02149540f, 0.01800245f, -0.04404685f, -0.01650517f, 0.08732090f, 0.26215696f, 0.01145036f, 0.02936895f, 
    0.11945800f, -0.01406098f, -0.14792673f, -0.04628608f, 0.10653716f, 0.01067574f, 0.08201315f, 0.01398800f, 
    0.05969841f, -0.03723764f, 0.05404344f, 0.16179101f, -0.04893463f, 0.03570419f, 0.17894515f, 0.02699455f, 
    0.00964203f, -0.02549004f, 0.03257596f, 0.02232693f, -0.13216354f, -0.04431302f, 0.03479915f, -0.19893880f, 
    0.01469594f, 0.05387106f, -0.11149525f, -0.02020993f, -0.00462139f, -0.08800328f, -0.05189391f, 0.00502309f, 
    -0.21560878f, 0.06632502f, 0.10530000f, -0.13583975f, 0.03307956f, 0.09270579f, -0.08953296f, -0.12268233f, 
    -0.00852707f, 0.07175266f, 0.03979699f, -0.06881153f, -0.06729198f, 0.10964853f, 0.03475579f, -0.16501251f, 
    -0.06034338f, -0.05850657f, 0.09005104f, -0.00950649f, 0.06380440f, 0.08553407f, -0.03249398f, -0.02890441f, 
    0.06668416f, 0.14772493f, 0.07007633f, -0.11262784f, 0.04823475f, 0.08613046f, -0.01581473f, -0.01801430f, 
    0.07892890f, 0.01270222f, 0.06654355f, 0.04845866f, 0.27972507f, 0.17969683f, 0.15246598f, 0.13399859f, 
    -0.11617498f, 0.01503996f, 0.07802819f, 0.11863358f, 0.09231209f, 0.07999498f, 0.04401738f, -0.10419024f, 
    0.22038050f, 0.08601534f, 0.04861619f, -0.00175327f, -0.15047096f, 0.10201684f, 0.07713380f, 0.05703869f, 
    0.08730441f, 0.10453375f, 0.04731396f, 0.08627032f, 0.12776060f, -0.03356677f, -0.03223657f, 0.17814337f, 
    -0.05346664f, 0.04755462f, 0.18540651f, -0.01916465f, -0.01292512f, -0.01146244f, 0.11268654f, 0.06025967f, 
    0.09059910f, -0.08277997f, 0.05474621f, 0.20697500f, -0.03894326f, -0.06452035f, 0.08299831f, 0.06551226f, 
    -0.01094791f, -0.08847675f, 0.03976385f, -0.01628773f, 0.22473823f, -0.07120661f, 0.07017343f, -0.22592691f, 
    -0.08050083f, 0.10539953f, -0.06775226f, 0.01331559f, -0.05282615f, 0.00464224f, 0.13355112f, 0.01222111f, 
    -0.16904220f, -0.02137024f, -0.14570458f, -0.06945064f, 0.03456658f, -0.00495990f, -0.06065813f, 0.10787220f, 
    0.03849725f, -0.03029089f, -0.08071429f, -0.17520913f, -0.10537348f, 0.18587020f, 0.09919824f, 0.15778646f, 
    0.08983225f, 0.00324907f, -0.03613004f, 0.11176748f, -0.12942255f, 0.04798646f, 0.00913496f, -0.07250076f, 
    -0.12020358f, 0.01440474f, -0.00577456f, 0.00631330f, -0.06239216f, 0.04039475f, 0.00362292f, -0.15243693f, 
    0.04181789f, -0.00943276f, 0.02020448f, 0.03289089f, -0.09451015f, -0.02512985f, 0.19515803f, -0.15786488f, 
    0.05798955f, 0.20217110f, -0.01944308f, 0.07709733f, -0.02801890f, 0.00140156f, -0.06372546f, 0.04698979f, 
    0.10124313f, -0.29406348f, -0.03174691f, 0.08582977f, -0.03627752f, 0.00451043f, -0.00678899f, -0.00458905f, 
    -0.08322766f, 0.05612919f, 0.08217552f, -0.03128995f, 0.19096118f, -0.22209762f, 0.12666030f, -0.06589556f, 
    0.16744108f, -0.00773994f, -0.00231702f, -0.03509270f, -0.12426851f, -0.01242558f, 0.08262741f, 0.03271187f, 
    0.16136956f, 0.17078514f, -0.10754561f, 0.06605073f, -0.01957233f, -0.02370093f, 0.04336157f, 0.07735293f, 
    0.13192917f, 0.04126756f, -0.05918710f, 0.06946003f, 0.27836603f, -0.05187233f, 0.03247849f, 0.12848076f, 
    -0.07486153f, -0.07769750f, 0.02400647f, -0.00609268f, 0.14819969f, 0.02220826f, 0.04546308f, 0.03039491f, 
    0.02015121f, -0.04650796f, -0.00393657f, -0.01713777f, 0.03342109f, -0.00785781f, 0.04201708f, 0.03493538f, 
    -0.02794432f, 0.02849042f, -0.04534255f, -0.02770375f, -0.02104102f, -0.05903675f, -0.03412646f, -0.04791427f, 
    0.03837883f, -0.01438380f, 0.00232147f, -0.03758470f, -0.01436400f, 0.02085175f, -0.02952321f, 0.03709337f, 
    0.04016166f, -0.02504865f, 0.03034384f, -0.02344328f, -0.00158861f, 0.03682023f, -0.00576928f, 0.01639892f, 
    -0.02097226f, -0.02709184f, -0.01322256f, -0.01498079f, -0.02870609f, 0.02073748f, 0.01481471f, -0.05352187f, 
    0.00648790f, -0.04067670f, 0.02276333f, 0.04003567f, 0.03314836f, -0.02731714f, -0.02836039f, -0.05192750f, 
    -0.00163898f, 0.00021231f, -0.01530321f, 0.00708397f, 0.04027511f, 0.03877643f, 0.03563102f, 0.02795049f, 
    -0.04117018f, -0.02646070f, 0.03680632f, -0.00855406f, -0.01946479f, 0.00728157f, -0.04911629f, 0.03482239f, 
    -0.04954497f, -0.03677026f, -0.01103064f, -0.02752970f, 0.00066770f, -0.03391898f, -0.01678433f, -0.05947285f, 
    -0.04993284f, -0.03112749f, -0.04601725f, -0.05354086f, 0.03193379f, 0.01373339f, -0.04520231f, -0.04274813f, 
    0.03182314f, -0.01754082f, -0.01522309f, 0.00360141f, -0.04475875f, 0.03033414f, 0.00309822f, -0.02517246f, 
    -0.01453414f, -0.03514490f, -0.00761279f, 0.01538040f, 0.03847552f, -0.01513435f, 0.02596064f, -0.01329837f, 
    0.00485878f, -0.02182423f, -0.02531035f, -0.00238690f, 0.00541011f, -0.01729456f, 0.03320051f, -0.01172253f, 
    -0.04354269f, -0.01124514f, -0.00065483f, 0.01995371f, 0.02707715f, 0.04255069f, -0.02469699f, -0.05286697f, 
    -0.03281528f, 0.01043398f, 0.03775038f, -0.02993283f, 0.03081122f, -0.03006289f, -0.01385283f, -0.04833140f, 
    0.00520768f, 0.01121698f, 0.01905034f, -0.00401817f, 0.01082956f, -0.04051094f, -0.03912860f, 0.02354080f, 
    0.00721566f, 0.00237671f, 0.03500685f, -0.04203612f, 0.03678945f, -0.05703022f, -0.05554303f, 0.03934598f, 
    -0.03521932f, -0.00632963f, 0.00156164f, -0.04008696f, 0.00823630f, -0.05856158f, 0.03177170f, -0.03136601f, 
    -0.05119742f, -0.03240313f, -0.02383338f, -0.00674502f, -0.04766347f, -0.02082355f, 0.03586850f, 0.03556732f, 
    0.02814578f, -0.00515592f, -0.05206059f, -0.04846269f, 0.02391615f, -0.04597061f, 0.03341205f, -0.05459745f, 
    0.01005706f, -0.01853519f, -0.05187247f, -0.04410409f, -0.02521284f, -0.05553954f, 0.04100299f, -0.04756250f, 
    0.01398156f, 0.02624101f, 0.00842157f, -0.02341945f, -0.01449268f, -0.02788541f, -0.03369631f, 0.00958372f, 
    -0.02379829f, -0.04442123f, 0.00917348f, 0.00704342f, 0.02148322f, -0.04262709f, -0.05667889f, 0.01330859f, 
    0.00343946f, -0.05739303f, 0.04220610f, -0.03620546f, 0.02009077f, 0.02704722f, 0.02668677f, -0.05760419f, 
    -0.04928963f, 0.03003521f, 0.00566336f, -0.03324403f, 0.03280029f, -0.03095820f, 0.01003460f, 0.02239676f, 
    -0.02837457f, -0.05779304f, -0.02352342f, -0.02055949f, -0.04793407f, -0.02223198f, -0.05948476f, -0.03242188f, 
    0.03504103f, -0.04054028f, 0.02869172f, -0.03854957f, -0.04749343f, 0.04067145f, -0.01434696f, -0.04613424f, 
    -0.02816937f, -0.04558301f, -0.01403870f, 0.03220724f, 0.02994035f, 0.02960966f, 0.01526765f, -0.03429901f, 
    0.01947228f, 0.00482778f, -0.03227096f, -0.00732154f, -0.00725076f, -0.05263390f, -0.03446207f, -0.01163345f, 
    -0.00824581f, 0.00964068f, -0.04340939f, 0.00606041f, -0.05095961f, -0.01804807f, 0.02457995f, 0.00980670f, 
    0.00521117f, 0.00213870f, 0.01335370f, -0.00269857f, 0.00623007f, 0.01769051f, -0.03575423f, -0.02080793f, 
    0.01679882f, -0.01082108f, -0.01267728f, 0.03598946f, 0.00794931f, 0.00269250f, -0.01246722f, 0.03295533f, 
    -0.02781357f, -0.04217300f, -0.01679424f, -0.01921242f, -0.01190863f, -0.02827572f, -0.02294750f, 0.00713266f, 
    -0.04590246f, -0.01973108f, 0.02297321f, 0.01199622f, -0.03885783f, -0.05158417f, -0.03701536f, 0.02359338f, 
    -0.05130967f, -0.04513126f, 0.03317399f, -0.01132474f, -0.01525901f, 0.00281614f, -0.00422230f, -0.01473610f, 
    -0.00304315f, 0.01624283f, -0.01837589f, -0.03780030f, 0.01199435f, 0.02366306f, 0.01723641f, 0.01832932f, 
    0.01893628f, 0.02621306f, 0.02242961f, 0.00390610f, -0.00946126f, -0.05874999f, -0.00848591f, -0.02939829f, 
    -0.00682789f, -0.01450979f, 0.00822675f, 0.02333164f, -0.03990044f, -0.05035591f, -0.04945543f, 0.04692074f, 
    -0.05673822f, -0.00866869f, 0.01965098f, -0.04995240f, 0.02171297f, -0.00936886f, -0.01303774f, 0.02918371f, 
    -0.01319397f, -0.02255539f, 0.00064675f, -0.04699504f, -0.02768488f, 0.01797363f, -0.00469410f, -0.01011072f, 
    0.03229648f, -0.00702146f, 0.01281791f, 0.02891086f, -0.02166487f, -0.05811809f, -0.00127366f, -0.01435682f, 
    -0.00032993f, -0.05839871f, 0.03614758f, -0.03267923f, -0.03029374f, 0.01830706f, -0.04657063f, 0.02279129f, 
    0.01218274f, 0.00509833f, -0.00124020f, 0.01409354f, 0.01926994f, 0.03348699f, -0.02903325f, -0.01218287f, 
    -0.01208822f, -0.01002840f, -0.02549858f, -0.01457932f, 0.01325197f, -0.03560926f, -0.01312634f, -0.03418641f, 
    0.03048352f, -0.00753183f, 0.03132840f, 0.02786592f, 0.00292687f, -0.05953983f, 0.03798833f, -0.00706759f, 
    -0.03398406f, -0.02230399f, -0.05502577f, -0.01220831f, -0.01698196f, -0.05824322f, 0.03462156f, -0.01482971f, 
    0.03522349f, -0.01071053f, 0.00077514f, 0.01693409f, 0.01787206f, -0.03604880f, 0.02045115f, 0.04167091f, 
    -0.05333965f, -0.05954647f, -0.01747083f, 0.02812747f, 0.01996298f, 0.04093904f, -0.04882252f, 0.00622399f, 
    -0.02100431f, -0.04552645f, -0.01094493f, -0.00875705f, -0.02821502f, -0.00903497f, 0.00335842f, 0.00646057f, 
    0.02230052f, -0.02165144f, -0.03992530f, -0.02493719f, -0.00667374f, 0.00132052f, -0.04421166f, -0.03576642f, 
    -0.01743728f, -0.00857791f, 0.04275288f, -0.05039521f, -0.02541779f, 0.01465313f, -0.02275925f, 0.02372498f, 
    -0.01694426f, 0.03388638f, 0.03354811f, 0.00408879f, 0.03197641f, -0.00453662f, -0.01009173f, -0.03052024f, 
    -0.02112065f, -0.04949689f, 0.03193818f, -0.02714455f, 0.01127049f, -0.02012885f, -0.05700092f, -0.04967272f, 
    0.00078103f, -0.00996481f, -0.05028421f, -0.00831118f, -0.01048489f, -0.00628998f, -0.00820921f, -0.03092085f, 
    -0.05376680f, 0.03773031f, -0.01694237f, -0.04758498f, 0.03649687f, -0.02512652f, -0.04457450f, 0.03643543f, 
    0.02183946f, 0.01227595f, 0.00558771f, 0.00182171f, -0.04434345f, -0.05489874f, -0.00232551f, -0.03191642f, 
    0.02069836f, -0.00058513f, 0.00979413f, -0.01463427f, 0.03951415f, 0.00614640f, -0.02927422f, -0.02982946f, 
    -0.03349462f, 0.03809058f, -0.02563573f, 0.03663480f, -0.03091846f, -0.00661879f, 0.01970148f, 0.03999339f, 
    0.01203367f, -0.01168756f, 0.03760181f, -0.01260911f, 0.03182444f, -0.05328294f, -0.02958880f, 0.02331838f, 
    0.03589040f, -0.03898457f, 0.00256558f, 0.04490458f, -0.04123871f, -0.01644041f, 0.02920733f, -0.01367867f, 
    -0.03197454f, -0.02531505f, 0.03782079f, -0.04708171f, 0.00000977f, -0.02079400f, 0.03225691f, -0.00358224f, 
    -0.03351992f, 0.00048918f, -0.00533556f, 0.01555584f, 0.02450083f, 0.02966945f, -0.01969214f, -0.05239768f, 
    -0.03539326f, -0.04896681f, 0.02762900f, -0.01147894f, 0.02370347f, 0.01358174f, -0.04077677f, 0.02869608f, 
    -0.04842696f, -0.01882487f, 0.01325032f, -0.05026410f, -0.01296396f, 0.03437941f, 0.01546346f, -0.01169057f, 
    0.02591549f, -0.00222176f, -0.04664465f, -0.02221554f, 0.00508806f, 0.02184632f, -0.00538410f, 0.04027990f, 
    0.03153858f, -0.01902580f, 0.02459055f, 0.03030997f, -0.00026376f, 0.01247585f, -0.05351129f, -0.02454977f, 
    -0.00606878f, -0.05865316f, -0.04802764f, -0.04254947f, -0.00026873f, -0.02690723f, 0.04814564f, 0.01568685f, 
    -0.03565639f, 0.04351144f, -0.01132807f, -0.03925483f, 0.03100329f, 0.01685831f, -0.01568887f, -0.00332624f, 
    0.00800270f, 0.00334193f, 0.04226801f, 0.02055512f, 0.01849170f, -0.03750999f, 0.03213708f, -0.02481030f, 
    0.02354199f, 0.02518240f, 0.01566774f, 0.00380522f, -0.05292084f, -0.03388238f, 0.02254506f, 0.05045229f, 
    -0.04743767f, 0.01418479f, -0.02366776f, -0.05234242f, 0.00740310f, 0.02222687f, -0.05042809f, 0.02752639f, 
    -0.01959551f, 0.00195522f, -0.01931427f, 0.00872287f, -0.04352432f, 0.01830809f, -0.01108338f, -0.01965352f, 
    -0.00456052f, -0.03444483f, -0.03270723f, -0.04067914f, -0.03032215f, -0.00933280f, -0.01772716f, -0.05430950f, 
    0.01671633f, 0.03928108f, 0.01121399f, 0.04175850f, 0.00083436f, -0.04856107f, 0.05626201f, 0.00606172f, 
    0.01790155f, 0.02990597f, -0.02709297f, -0.04755159f, -0.03881174f, -0.03388242f, -0.05126882f, -0.02793857f, 
    0.00125144f, 0.04049512f, 0.00292116f, -0.01459563f, 0.00671301f, 0.03795577f, -0.01454798f, 0.03086906f, 
    0.03154156f, -0.04577891f, -0.01064596f, 0.04269582f, 0.02894746f, -0.00145117f, -0.03318001f, 0.03006831f, 
    -0.02232317f, 0.00024346f, 0.04316144f, 0.02048836f, 0.00021976f, -0.02096544f, -0.01421578f, -0.00495072f, 
    0.02173309f, 0.02496297f, -0.02120119f, -0.05585363f, 0.03433862f, -0.03038909f, -0.00018500f, -0.03716879f, 
    -0.04777329f, -0.02934118f, -0.02764002f, -0.04950420f, 0.03856218f, -0.03274351f, 0.03515825f, -0.02059803f, 
    -0.04155881f, 0.00739643f, -0.02468517f, 0.00165901f, -0.00723065f, 0.01635538f, 0.00674458f, -0.02409222f, 
    0.01595064f, -0.04689372f, 0.00367366f, -0.03794727f, -0.02488916f, 0.00090568f, -0.02999940f, 0.01869881f, 
    0.01906024f, 0.00442876f, -0.01298211f, -0.01068204f, -0.01736224f, -0.01430669f, -0.02108368f, -0.02446570f, 
    0.03619950f, 0.03383205f, 0.00137263f, 0.03325909f, 0.00468673f, -0.01417447f, 0.03187309f, -0.00030816f, 
    -0.03430371f, -0.03646096f, -0.02997069f, 0.01874101f, -0.05205918f, -0.00966799f, 0.03699285f, 0.01047130f, 
    0.01104262f, -0.01097483f, 0.00501266f, -0.04641351f, 0.02761947f, 0.02280918f, 0.00696845f, -0.02186812f, 
    0.01174861f, 0.00264554f, 0.03784366f, 0.04314763f, 0.01904573f, -0.04348753f, 0.00010040f, 0.02495907f, 
    -0.03669737f, 0.01625515f, 0.03691598f, -0.01954116f, -0.02873643f, 0.03803464f, 0.01904134f, -0.03596877f, 
    0.01818923f, -0.03025256f, -0.00505053f, -0.03148054f, 0.01367360f, 0.03732506f, 0.01248869f, 0.02989756f, 
    -0.04375371f, 0.02617770f, -0.04231248f, -0.03696148f, -0.04533212f, 0.00285863f, -0.00405837f, 0.04443786f, 
    -0.05748995f, -0.04239633f, 0.00254511f, -0.01751526f, 0.04802272f, -0.05109437f, 0.03235137f, -0.00542041f, 
    0.03157151f, 0.02827672f, 0.01635275f, -0.03719263f, 0.01898512f, -0.02421801f, -0.03903812f, -0.00433269f, 
    0.03194238f, -0.05143782f, 0.00533863f, -0.03917302f, 0.02349124f, 0.02857247f, -0.01769624f, -0.04464361f, 
    -0.05029486f, 0.02628735f, -0.05158662f, 0.01651879f, 0.02179371f, 0.01719199f, 0.03523815f, -0.00684188f, 
    -0.01609365f, 0.02337981f, -0.04761065f, -0.03945930f, 0.00074912f, -0.03612905f, -0.03893845f, -0.02960999f, 
    -0.03771202f, -0.04278434f, 0.04194893f, 0.01712907f, -0.00968676f, 0.00570157f, 0.02015070f, 0.01699580f, 
    -0.04040926f, -0.04393391f, -0.01141796f, -0.01761444f, -0.00718216f, 0.02275795f, -0.04959501f, -0.04271924f, 
    0.03283595f, -0.01156507f, -0.01736088f, 0.01131241f, 0.03244542f, -0.00259977f, 0.00610579f, -0.01230920f, 
    -0.05118646f, -0.00098623f, -0.04088260f, 0.04027910f, 0.00382758f, -0.03576939f, -0.02131163f, 0.00788917f, 
    -0.03939407f, 0.00412531f, -0.03318376f, 0.00704235f, 0.00444798f, 0.03144307f, -0.02041268f, -0.00229073f, 
    0.02428382f, -0.01680454f, -0.02078226f, 0.02417254f, 0.04477997f, -0.02043967f, -0.05054621f, -0.03352799f, 
    0.00552109f, 0.02322967f, 0.03443280f, -0.01574714f, -0.02793116f, 0.02081014f, -0.03069602f, 0.02170982f, 
    0.01363623f, -0.05025555f, 0.01177526f, -0.01400096f, 0.00651756f, 0.01079231f, 0.00237960f, 0.03368189f, 
    -0.00909360f, -0.01538989f, 0.02397506f, 0.04088524f, -0.02361803f, 0.00002853f, 0.03923300f, -0.03201226f, 
    -0.02137898f, -0.03516374f, -0.01541194f, 0.00946860f, 0.01217843f, -0.03882496f, 0.01193346f, -0.01969862f, 
    0.03207332f, -0.04001296f, -0.00597712f, -0.03150885f, -0.03690729f, -0.05214959f, -0.00024677f, -0.01811114f, 
    0.02142768f, -0.05579327f, -0.00229163f, -0.04735982f, 0.03538566f, -0.01300597f, 0.01376524f, -0.04527016f, 
    -0.03863402f, -0.05047992f, 0.01989703f, -0.04155716f, -0.00265413f, 0.03307641f, -0.04954717f, -0.00310710f, 
    -0.04970818f, -0.05651212f, 0.00588942f, 0.04476601f, -0.02220243f, 0.01502240f, -0.04301258f, -0.05173574f, 
    -0.04674476f, 0.04275159f, 0.03433279f, -0.01509251f, 0.01720580f, -0.05016192f, -0.02723229f, -0.02425155f, 
    0.04216687f, 0.03756322f, -0.01024884f, -0.01538954f, -0.04613926f, -0.01649903f, -0.00915359f, 0.03985773f, 
    0.01545116f, -0.03529761f, 0.03030170f, -0.03426370f, -0.00936172f, 0.03594675f, 0.03290324f, -0.00556711f, 
    -0.02190580f, 0.00091298f, -0.00110858f, 0.00209537f, -0.00230659f, -0.01332022f, 0.03029939f, 0.01477990f, 
    -0.04173962f, 0.00619549f, -0.01207538f, 0.02687231f, 0.03600530f, -0.01988118f, 0.00549781f, -0.02082120f, 
    0.03067460f, -0.04432063f, 0.00972596f, -0.02241451f, 0.01958496f, -0.01094928f, 0.03530866f, -0.01442649f, 
    -0.05388571f, -0.03588530f, 0.02882015f, -0.02326344f, 0.03222219f, 0.00413010f, -0.02228891f, -0.02928155f, 
    0.04081145f, -0.03255807f, -0.00325685f, 0.01414834f, -0.04488542f, -0.00162873f, -0.01742256f, -0.02278279f, 
    0.03912114f, 0.00450078f, -0.03041890f, 0.03088854f, 0.02301045f, -0.05389187f, 0.03535546f, 0.01479354f, 
    -0.05654618f, -0.05488106f, -0.02346053f, 0.01588145f, -0.01711848f, -0.02706256f, 0.00274707f, -0.00189831f, 
    -0.02732601f, -0.00921293f, -0.00615027f, 0.03401740f, 0.03667628f, -0.02540887f, -0.05466566f, 0.02774142f, 
    -0.04701380f, -0.02761721f, 0.04153734f, -0.00861661f, -0.01180904f, 0.03254315f, -0.03324971f, -0.04620438f, 
    -0.04689747f, -0.05214329f, -0.02379123f, 0.03557893f, 0.02219697f, 0.02409634f, 0.03164661f, 0.00741591f, 
    0.03488468f, 0.02944835f, -0.01814754f, -0.01273041f, 0.03193561f, -0.02876499f, -0.00054846f, -0.05044264f, 
    0.00064147f, -0.05609772f, -0.00331146f, -0.02413988f, 0.01059471f, -0.03951958f, -0.00489762f, 0.03893192f, 
    0.03007000f, 0.00118038f, 0.00422664f, -0.01961695f, 0.01281206f, -0.02495077f, -0.00975648f, 0.01251761f, 
    0.01929037f, -0.05170293f, 0.03033409f, 0.00265751f, 0.03228850f, -0.01779521f, -0.02292928f, 0.00357317f, 
    -0.03752703f, 0.03666393f, -0.04406263f, 0.04089347f, 0.00501989f, 0.00154069f, -0.05186734f, 0.01981122f, 
    0.00948528f, -0.01671273f, -0.00560460f, -0.03942861f, -0.03317497f, 0.04988164f, -0.00511930f, -0.03048510f, 
    0.03284194f, -0.04729667f, 0.01314975f, 0.01411265f, -0.02202014f, 0.00062928f, 0.02519294f, 0.03136587f, 
    0.03258286f, 0.03656764f, 0.03647305f, -0.04227801f, -0.00812699f, 0.00905844f, -0.04199966f, -0.03584013f, 
    -0.05578369f, -0.03326904f, 0.02046574f, -0.05644348f, 0.01802936f, -0.04728949f, 0.04256933f, 0.01753007f, 
    0.04464835f, -0.03114093f, -0.02774016f, 0.00335132f, 0.00709591f, 0.03655353f, 0.00635624f, -0.01880395f, 
    -0.04819074f, -0.01138076f, 0.02625013f, 0.02455965f, -0.00993605f, 0.03917968f, 0.02002119f, -0.04406644f, 
    -0.04230848f, 0.02365095f, -0.01499968f, 0.00851423f, -0.04210360f, 0.02894382f, -0.05624514f, 0.00850254f, 
    0.00205883f, 0.01060708f, -0.02900725f, 0.02068803f, -0.02654140f, 0.02164516f, -0.00832799f, -0.05027800f, 
    0.03436032f, 0.04241272f, -0.00027400f, 0.00459212f, 0.01153906f, -0.04758187f, 0.02027844f, -0.00009165f, 
    -0.04108993f, 0.00078831f, -0.01028492f, -0.04747935f, -0.04427341f, -0.05031678f, -0.04115155f, -0.01882033f, 
    -0.00812376f, 0.02326814f, -0.00328909f, -0.01328919f, 0.02287122f, -0.00709412f, 0.01632792f, -0.00236945f, 
    -0.00061169f, 0.03725045f, -0.03674119f, -0.02321207f, -0.04837275f, 0.03511475f, -0.01218414f, -0.00607512f, 
    -0.03753295f, 0.00873711f, -0.03429787f, -0.02479369f, -0.01403680f, 0.00283249f, -0.01777101f, -0.00647130f, 
    -0.05109781f, 0.04024069f, -0.01889954f, 0.00727934f, -0.00263345f, 0.03172563f, -0.00254750f, -0.04722305f, 
    -0.03766302f, -0.05040056f, 0.01625543f, 0.01295032f, 0.00450097f, -0.02904787f, 0.02346069f, -0.05526503f, 
    0.00510375f, -0.05162556f, -0.04806428f, 0.01284836f, -0.04597808f, -0.04818435f, -0.04570097f, -0.02074763f, 
    -0.00511736f, 0.00460532f, -0.05458979f, -0.04079677f, 0.03457917f, 0.00548103f, -0.01909360f, -0.03844471f, 
    0.00974569f, 0.05171218f, 0.21308893f, 0.07716903f, 0.02845851f, -0.04568347f, -0.09037159f, 0.03137045f, 
    0.12686542f, 0.07298861f, -0.08862698f, -0.10765878f, -0.58875871f, -0.26960602f, 0.18114270f, 0.04270248f, 
    0.01178987f, 0.15225112f, -0.05268573f, -0.07110730f, 0.01799238f, -0.03963848f, 0.00615820f, -0.01763364f, 
    0.10356834f, -0.13222732f, 0.08130290f, -0.01283931f, -0.15589955f, -0.04066120f, -0.03850590f, -0.03559064f, 
    -0.05905427f, 0.02781496f, -0.07299113f, -0.08048906f, -0.04831224f, 0.12384821f, -0.27803496f, -0.03823742f, 
    0.11385028f, 0.03959223f, 0.02673561f, 0.04774163f, -0.04041381f, 0.02800182f, -0.09414826f, 0.00794648f, 
    -0.08780186f, -0.27390724f, -0.12370434f, 0.14773950f, 0.04993110f, 0.05007586f, 0.01754292f, 0.02692088f, 
    0.00435516f, 0.06432464f, 0.04971028f, -0.03656637f, 0.17648281f, -0.11195045f, 0.17196047f, 0.09670929f, 
    -0.01730920f, -0.02398424f, 0.01295986f, -0.00386633f, -0.01400877f, 0.05804902f, 0.09169607f, 0.02505543f, 
    0.04126487f, 0.14226799f, 0.01389585f, -0.00312084f, -0.05143458f, 0.03972251f, -0.03289276f, -0.07636376f, 
    -0.01923697f, -0.02939262f, 0.05160637f, 0.07398554f, 0.19040717f, -0.04913964f, -0.04073909f, 0.04848349f, 
    0.04547499f, -0.06002884f, 0.07289222f, -0.01377825f, 0.00672357f, -0.08839325f, -0.07805052f, 0.04730889f, 
    -0.18120126f, 0.09034792f, -0.31016338f, -0.12053710f, 0.00782271f, -0.00999262f, -0.05990812f, -0.03400052f, 
    -0.02575058f, -0.02079096f, 0.13245137f, 0.08428249f, -0.02332322f, 0.16637062f, -0.10692000f, 0.08012249f, 
    -0.01669720f, -0.04578141f, 0.04987896f, 0.30775532f, -0.04483622f, 0.02251735f, -0.08816533f, 0.11247402f, 
    0.22485118f, 0.12416793f, 0.05885874f, 0.13427331f, 0.03092020f, 0.14302525f, 0.11386049f, -0.00055616f, 
    -0.03764054f, 0.09829688f, 0.00397488f, -0.06822140f, 0.31369981f, 0.00884300f, 0.06208290f, -0.03038866f, 
    -0.10731415f, 0.12380511f, 0.03251313f, -0.05355879f, 0.04010732f, 0.13186385f, 0.06917227f, 0.07842798f, 
    -0.52444971f, -0.10845366f, -0.03119374f, 0.07057160f, -0.08178594f, 0.07163837f, -0.10567720f, 0.08109440f, 
    -0.04197302f, -0.02767352f, 0.00048405f, 0.03003965f, 0.23627478f, -0.10916512f, -0.04526781f, 0.11005061f, 
    -0.28617164f, 0.07761676f, 0.15040655f, 0.10658044f, -0.15757404f, 0.19725375f, -0.07515337f, -0.03926985f, 
    0.15961565f, 0.05014494f, 0.01424874f, -0.17247376f, -0.01484590f, 0.01209759f, -0.04973898f, 0.08743655f, 
    0.11651648f, -0.02160279f, -0.05768990f, 0.04165692f, 0.14048581f, 0.07869116f, 0.14752237f, 0.33795071f, 
    0.04558012f, -0.11001321f, 0.05401603f, 0.12211483f, -0.08141457f, -0.06584506f, 0.01986409f, -0.02186332f, 
    0.19204068f, 0.13078238f, 0.12208047f, 0.21981105f, -0.01937833f, 0.06590749f, 0.01356854f, 0.09217265f, 
    0.02514646f, -0.10594480f, -0.04446824f, -0.00732340f, -0.03636396f, 0.14191827f, 0.03916012f, 0.22406904f, 
    -0.04617685f, 0.07992740f, -0.15545943f, 0.05346145f, -0.06905194f, -0.04444956f, -0.07481980f, -0.04877115f, 
    -0.07455524f, 0.03959847f, -0.01420815f, 0.18615575f, -0.01646098f, 0.04158439f, 0.12592107f, -0.00432196f, 
    -0.00818535f, -0.05894189f, -0.04186400f, 0.02526758f, -0.24107520f, -0.21473153f, -0.11062331f, -0.10940728f, 
    -0.10297149f, 0.10275728f, -0.05836156f, -0.13851483f, -0.05005670f, -0.15626496f, -0.07364709f, -0.01884482f, 
    -0.04927094f, -0.14003956f, 0.00417902f, -0.01745990f, 0.07531247f, -0.01712889f, 0.05421188f, -0.03934104f, 
    0.02336549f, 0.06537221f, 0.04497335f, -0.04182319f, -0.01077664f, 0.14875597f, 0.14612558f, -0.11728830f, 
    0.09051868f, 0.02936055f, -0.14879577f, -0.03034659f, 0.01992158f, 0.01456100f, -0.15289541f, 0.02985218f, 
    -0.26696545f, 0.04962984f, -0.02811471f, -0.23297854f, 0.10092478f, 0.02242850f, 0.05166285f, -0.04977342f, 
    0.04230422f, 0.13111340f, 0.01698515f, -0.00319959f, 0.02503920f, 0.21897015f, 0.18329960f, 0.33549872f, 
    0.11454079f, -0.02934491f, 0.06885131f, 0.11314283f, -0.11481737f, 0.14500450f, -0.08707628f, 0.03065765f, 
    0.28332484f, 0.18844126f, 0.24260840f, 0.36478651f, 0.10167356f, 0.07349174f, 0.23049943f, 0.00401057f, 
    -0.05093762f, -0.17555155f, -0.02657301f, 0.12251655f, 0.08923443f, 0.05453263f, -0.13582636f, -0.12373653f, 
    0.03333477f, 0.05413941f, -0.08601835f, -0.13060880f, -0.03410082f, -0.05744996f, -0.02010912f, 0.10995539f, 
    0.01195534f, 0.11305267f, -0.13409562f, 0.04279418f, -0.02732691f, 0.02466923f, -0.16533983f, 0.16926964f, 
    0.02176793f, -0.07749376f, 0.02117769f, -0.01990134f, -0.17885485f, 0.04926686f, 0.11086985f, 0.11580113f, 
    -0.05969157f, -0.09211342f, -0.00330765f, 0.03917390f, -0.06450012f, -0.04952310f, 0.02163690f, -0.04749691f, 
    -0.02308214f, 0.21752350f, 0.23203385f, 0.01977189f, 0.10248858f, 0.06322645f, -0.10174660f, -0.03348573f, 
    0.10971017f, -0.05298536f, -0.03967904f, 0.06841940f, 0.20987456f, 0.29033640f, 0.07783826f, 0.04545260f, 
    -0.08657593f, 0.02148857f, 0.06560707f, 0.10912894f, -0.00166917f, 0.02084200f, -0.01530731f, -0.00888269f, 
    -0.27292794f, -0.08179793f, 0.06732272f, 0.01981336f, -0.10494613f, 0.11468581f, -0.04011299f, -0.07841460f, 
    -0.08778004f, 0.02740703f, -0.04920803f, -0.02878063f, -0.17239477f, -0.02420713f, 0.13816331f, -0.23794697f, 
    -0.02289043f, 0.01938084f, 0.03527760f, -0.04769659f, -0.19009280f, 0.05659291f, -0.07798725f, -0.03233441f, 
    0.01834221f, -0.00925212f, 0.00149273f, 0.03791570f, 0.05296297f, -0.00815516f, -0.05077321f, -0.06051499f, 
    0.04778117f, -0.04527225f, 0.01204813f, -0.00981894f, 0.04151686f, 0.04116599f, 0.03939854f, 0.02480792f, 
    -0.00904205f, -0.01204899f, 0.00071306f, 0.02785502f, -0.00082697f, -0.01635771f, -0.03900530f, -0.03529819f, 
    -0.02156416f, -0.00108871f, 0.01777729f, -0.03282362f, -0.03187079f, -0.02455045f, 0.00126943f, -0.05184922f, 
    -0.00110973f, -0.02994152f, 0.03801995f, 0.01340939f, -0.05370184f, -0.01729950f, 0.00141476f, -0.04798179f, 
    0.00723178f, -0.03100140f, 0.02691234f, -0.02704621f, 0.04465419f, 0.04637468f, -0.00252968f, 0.01936927f, 
    -0.01232086f, 0.00916919f, -0.01778219f, 0.00915725f, -0.05271010f, 0.02085576f, -0.03491215f, 0.00106160f, 
    -0.04669052f, -0.00909192f, 0.00222833f, 0.00814687f, 0.01866077f, -0.04203444f, -0.04654377f, 0.00342216f, 
    0.02806946f, -0.01649622f, -0.04480219f, -0.01269325f, -0.03246926f, 0.04524801f, -0.01003962f, -0.03178047f, 
    -0.04110485f, -0.00456690f, -0.03586254f, -0.01112532f, -0.03193915f, -0.04330495f, 0.01301868f, -0.01012123f, 
    -0.00071109f, -0.00669397f, 0.04584647f, 0.03886219f, -0.02507383f, -0.05299989f, -0.02374065f, 0.01776123f, 
    0.02827450f, -0.04166077f, -0.00638871f, -0.03198152f, 0.01495107f, -0.03818920f, -0.00433475f, -0.01360111f, 
    -0.02014583f, 0.02518103f, 0.01638656f, 0.04723137f, -0.00565947f, 0.00937310f, -0.01934808f, -0.01920313f, 
    0.02725158f, -0.00440104f, -0.01141358f, -0.01658550f, -0.05233137f, -0.04075018f, 0.04316888f, -0.04835227f, 
    0.04969383f, 0.04864817f, -0.04557553f, -0.05915303f, 0.01412620f, -0.04823089f, 0.02276068f, -0.04831169f, 
    0.03822138f, -0.02503085f, 0.00250251f, 0.02130428f, -0.02675993f, -0.02901094f, 0.01712907f, 0.00094833f, 
    0.00680027f, -0.02455872f, 0.01226956f, -0.04616388f, 0.00760843f, -0.04082074f, 0.00944491f, -0.03550235f, 
    -0.01208803f, -0.04328010f, -0.05252946f, -0.03593488f, -0.05546959f, -0.01918807f, -0.04041949f, -0.04315942f, 
    -0.03164232f, 0.03599325f, 0.02228493f, -0.03593269f, -0.05774574f, -0.03184285f, 0.01879078f, -0.00988818f, 
    -0.02018560f, 0.04740411f, -0.04568420f, 0.02463583f, 0.01867941f, 0.02356370f, 0.04872897f, 0.03298589f, 
    -0.01232284f, 0.02087006f, 0.03754425f, 0.01641921f, -0.01964545f, 0.00793613f, -0.03455022f, -0.03036754f, 
    0.00267666f, -0.04700350f, 0.03594890f, 0.00215239f, -0.01343501f, -0.02555013f, -0.00948440f, 0.02406176f, 
    0.03156342f, 0.01891693f, 0.03617891f, 0.02920685f, 0.00193366f, 0.00036860f, 0.01709434f, 0.01068242f, 
    -0.02865587f, 0.01736986f, 0.02475163f, 0.02736023f, -0.02613493f, -0.03004119f, -0.00244507f, -0.01435856f, 
    -0.05558837f, -0.05115089f, -0.04243216f, -0.04024658f, -0.02964576f, -0.01193732f, 0.03632820f, 0.00865707f, 
    -0.05068468f, 0.00523520f, 0.01484274f, -0.00145092f, -0.04619732f, -0.04241589f, 0.00373136f, 0.02389326f, 
    -0.01270026f, -0.05053023f, -0.04117924f, 0.03361754f, -0.06489171f, -0.03643431f, -0.00068007f, -0.03948256f, 
    -0.01465400f, -0.03162565f, -0.05045430f, 0.00818182f, 0.01034350f, -0.03861007f, -0.05605776f, -0.02952405f, 
    0.03201720f, -0.02239035f, 0.03180472f, -0.01981296f, -0.04048667f, -0.03071993f, -0.03319808f, -0.02156096f, 
    0.01769681f, -0.03868334f, -0.00506205f, -0.00218130f, -0.02752789f, -0.04274591f, 0.01487229f, 0.02812831f, 
    0.02816384f, 0.00136462f, 0.03865926f, 0.03079838f, 0.01183026f, 0.04186568f, 0.03006349f, 0.01278054f, 
    -0.03055243f, 0.00214186f, -0.04839707f, -0.01288647f, -0.01632519f, -0.03540305f, -0.04923765f, 0.03755359f, 
    0.00835445f, -0.00080214f, 0.02148419f, -0.03233698f, 0.03582792f, 0.00599043f, 0.03608890f, -0.03702817f, 
    0.03656996f, -0.01340467f, -0.03247961f, -0.00711326f, -0.04118286f, -0.00684736f, 0.04416662f, 0.04610137f, 
    0.03034094f, -0.05255416f, 0.01316948f, -0.02500817f, 0.03512510f, 0.01657909f, -0.03324974f, 0.00790804f, 
    -0.02667940f, -0.03220610f, 0.04309266f, 0.00494083f, -0.04364387f, -0.04955347f, -0.00587543f, -0.01157256f, 
    -0.03544599f, -0.01949248f, -0.04418686f, -0.02480918f, 0.05267500f, -0.02540814f, -0.01663998f, -0.02264856f, 
    -0.04123024f, -0.03515372f, 0.04726013f, 0.02164422f, 0.01276651f, -0.00150468f, 0.03168338f, -0.01565185f, 
    0.01037354f, -0.00745504f, -0.00661077f, -0.04523975f, 0.00262460f, 0.04957143f, -0.00530236f, 0.00040507f, 
    -0.05249185f, 0.02069963f, -0.00794914f, 0.04698007f, 0.04934131f, 0.04020306f, -0.05309499f, -0.00867832f, 
    0.01624754f, 0.02443673f, -0.02594855f, 0.01183357f, -0.03200539f, 0.01756499f, -0.05863399f, 0.00449030f, 
    0.05149438f, -0.01896793f, 0.02189426f, -0.02473531f, 0.00158689f, 0.03866345f, -0.04472705f, 0.00538020f, 
    -0.01065107f, -0.05453856f, -0.03153367f, 0.01523519f, -0.05655910f, 0.00152721f, -0.04043860f, 0.01308324f, 
    -0.04462184f, -0.01234950f, 0.02433304f, -0.04594690f, -0.06243067f, -0.05167521f, 0.00055440f, -0.02884516f, 
    -0.00617282f, 0.02487287f, 0.00670062f, -0.03555440f, -0.03418750f, 0.03056753f, 0.02720787f, -0.01542383f, 
    0.05072983f, -0.01744835f, -0.03872601f, 0.03869079f, -0.04606727f, -0.04192964f, -0.01692868f, 0.04537664f, 
    0.03155148f, -0.05202705f, -0.04286044f, -0.00909467f, 0.04067570f, -0.01426248f, -0.00707392f, 0.03689169f, 
    0.00703920f, 0.01101055f, 0.01651629f, -0.04182258f, -0.01548817f, 0.02086515f, 0.00339335f, 0.03809499f, 
    -0.02219686f, 0.03876864f, -0.03312796f, 0.00263287f, -0.02833418f, -0.02050348f, 0.02602127f, 0.04159106f, 
    0.03023135f, -0.00420346f, 0.00066363f, 0.00321262f, 0.04045783f, 0.00972897f, -0.02615339f, -0.01027624f, 
    -0.02870816f, -0.05078852f, 0.03981298f, -0.03732387f, -0.05347065f, 0.01129512f, -0.01909713f, -0.00290257f, 
    -0.04482031f, -0.04965324f, -0.03531667f, -0.04468358f, -0.03851134f, 0.00457828f, 0.02470727f, -0.04879443f, 
    -0.02693984f, -0.01691081f, 0.02863523f, 0.03374670f, -0.03065238f, -0.04281639f, 0.02423507f, 0.02237498f, 
    -0.02670150f, -0.00187616f, 0.03699098f, 0.00226041f, 0.01407834f, -0.05400678f, 0.02126984f, 0.03188671f, 
    -0.00759171f, 0.00949441f, -0.01174785f, -0.05246448f, -0.03825368f, 0.02635725f, 0.02679080f, 0.02514397f, 
    -0.01562396f, 0.01563503f, 0.03110911f, 0.02180643f, -0.00361707f, -0.01434208f, -0.05944718f, 0.03488668f, 
    -0.02314635f, 0.02276531f, -0.00671809f, 0.02323249f, -0.03367294f, -0.05464892f, -0.03360313f, -0.04858310f, 
    -0.01936089f, -0.02347358f, -0.03725526f, -0.05226549f, -0.00875747f, -0.04913737f, -0.05144555f, 0.02693093f, 
    -0.04983431f, 0.00482894f, -0.00010311f, -0.04451029f, 0.00709264f, 0.01943495f, 0.01878166f, -0.03264097f, 
    0.00260904f, 0.03967686f, -0.05197081f, 0.02042846f, -0.01656852f, 0.01109065f, -0.01393378f, -0.04252495f, 
    -0.01507595f, 0.04340101f, 0.02121980f, -0.05127598f, -0.04130432f, -0.01378591f, 0.02176036f, -0.05310944f, 
    0.00933411f, -0.03693248f, 0.02270594f, -0.05450311f, 0.01856045f, -0.02818984f, 0.02358444f, 0.01709161f, 
    -0.03165570f, 0.02237511f, -0.02475458f, -0.02919544f, 0.03373752f, 0.03614304f, 0.01870875f, -0.04313131f, 
    -0.01883504f, 0.03911400f, -0.04063020f, -0.00639323f, 0.04093844f, -0.00313397f, 0.04257220f, -0.02673081f, 
    0.03358794f, -0.04998026f, -0.01956792f, -0.02646183f, -0.00805250f, 0.03674164f, -0.02914057f, 0.02140695f, 
    0.03937272f, 0.01314909f, 0.03226573f, 0.02056276f, -0.03442766f, -0.04696903f, -0.05053439f, -0.01386255f, 
    0.01515153f, -0.02939119f, -0.05534671f, -0.03765647f, 0.00653481f, 0.02114354f, -0.04894467f, -0.03299843f, 
    -0.04429092f, -0.01478651f, -0.03597070f, 0.02308728f, -0.03084391f, -0.03479611f, -0.01601126f, -0.02421569f, 
    0.00723296f, 0.00965944f, 0.01172647f, 0.00598584f, -0.01861058f, 0.01183020f, 0.03417538f, -0.01705706f, 
    0.00012785f, 0.03516896f, -0.03414625f, -0.00685618f, 0.03278081f, 0.03764880f, -0.04161238f, -0.03580959f, 
    -0.02095297f, 0.01775165f, 0.02143776f, -0.04676088f, -0.05273600f, 0.03922593f, 0.03202998f, -0.02343792f, 
    0.02689915f, -0.00573865f, -0.03316722f, 0.01251714f, 0.02986980f, -0.03199640f, 0.00011763f, 0.02096799f, 
    -0.05014209f, -0.01260464f, 0.01268621f, 0.00456479f, -0.00547537f, -0.03152700f, 0.00344434f, 0.02036346f, 
    -0.01057698f, -0.03163184f, -0.00135898f, -0.01287982f, -0.02608548f, -0.04415549f, -0.02659378f, 0.00631240f, 
    0.02043061f, -0.00803338f, 0.03238475f, -0.04572964f, -0.00325238f, -0.00485716f, 0.01149822f, 0.02975338f, 
    0.00052250f, -0.03670371f, 0.03151194f, -0.05928242f, 0.03645711f, -0.03730241f, 0.03432379f, -0.02596145f, 
    -0.01748730f, -0.01355307f, -0.03235175f, -0.00141513f, -0.03102474f, 0.03299415f, 0.01812843f, 0.03746916f, 
    -0.03709787f, 0.03947578f, 0.00844599f, -0.00199840f, 0.01998445f, 0.01985501f, 0.02772785f, 0.01031009f, 
    -0.02142308f, 0.04225757f, 0.00052259f, -0.04087606f, 0.00012527f, 0.01723856f, 0.00106167f, 0.00908594f, 
    0.02773117f, 0.02921674f, 0.01086284f, -0.01973884f, -0.02652188f, -0.01108843f, 0.00402667f, -0.04182127f, 
    -0.04613541f, 0.03948060f, 0.03445125f, -0.05886877f, 0.03894714f, 0.02026192f, 0.00313458f, -0.02778654f, 
    0.02318074f, 0.03903766f, -0.01403587f, -0.05285444f, 0.02752023f, -0.03368536f, -0.01468877f, 0.04081056f, 
    -0.04469487f, 0.02599995f, 0.04813239f, -0.01204145f, -0.02349684f, 0.02136033f, 0.00560713f, 0.01279128f, 
    0.00554031f, 0.02589925f, 0.00164421f, -0.04837812f, 0.00604112f, -0.02788782f, -0.02799027f, 0.01521834f, 
    -0.03317590f, -0.05359383f, 0.03843503f, -0.03146951f, -0.01571734f, 0.02393086f, 0.04873946f, 0.03257799f, 
    -0.04416367f, 0.00621282f, 0.00062820f, 0.02929117f, 0.04447539f, -0.00696000f, 0.02723586f, -0.03375375f, 
    -0.05607761f, -0.01514915f, 0.04237315f, 0.01659814f, 0.03993227f, -0.02557675f, -0.04947072f, -0.05536088f, 
    -0.04189074f, 0.01754175f, -0.00900372f, 0.04148846f, 0.00468701f, -0.02454793f, -0.04012313f, 0.03772099f, 
    -0.05575160f, -0.04835040f, -0.03081641f, -0.03833789f, 0.00852200f, 0.01806469f, 0.00699721f, 0.03451141f, 
    0.01359177f, -0.04254323f, 0.00693174f, 0.00472686f, 0.03874698f, -0.04473117f, 0.01221913f, 0.01170612f, 
    0.01156119f, 0.01658272f, -0.03168105f, 0.00914349f, -0.03185708f, 0.04653327f, 0.03263240f, -0.03519471f, 
    -0.00316868f, -0.02338634f, -0.01356766f, -0.00553497f, -0.04465521f, 0.03222064f, -0.03563947f, -0.05777104f, 
    -0.00444692f, 0.02663938f, 0.03712422f, 0.01717527f, -0.02988431f, 0.00086348f, 0.01096034f, -0.00577780f, 
    0.00704462f, -0.01989427f, -0.03405611f, -0.02105887f, -0.01778768f, -0.02655619f, 0.03968018f, -0.05459706f, 
    -0.05353518f, -0.02037673f, 0.04212289f, -0.02191786f, -0.05959359f, -0.00117280f, -0.05272723f, -0.05502775f, 
    -0.01851524f, 0.00681508f, -0.04343934f, -0.01410649f, -0.04815895f, -0.04796752f, -0.04972265f, -0.01342219f, 
    0.03644842f, -0.01860885f, 0.00475183f, -0.00641370f, -0.00992170f, -0.00999253f, -0.00678697f, 0.04516201f, 
    0.01362462f, 0.02557590f, 0.04687974f, -0.02609309f, 0.01317395f, -0.05097236f, -0.04809818f, 0.02777648f, 
    -0.04620643f, -0.00298846f, 0.01541020f, -0.02571062f, -0.01526065f, -0.00552903f, -0.00742065f, -0.03678179f, 
    -0.04242549f, 0.04666154f, 0.00233100f, 0.01365826f, -0.04575709f, -0.02252153f, -0.02433927f, 0.02359738f, 
    -0.02667635f, 0.02217070f, 0.01590730f, -0.03674578f, 0.02394019f, -0.02794864f, -0.04848652f, -0.00258042f, 
    0.03545205f, 0.00169209f, 0.01477128f, 0.00059262f, -0.00244442f, -0.02277696f, -0.04452746f, 0.01048448f, 
    0.02115538f, 0.00935348f, -0.01247073f, -0.03711878f, 0.02163598f, -0.02370862f, -0.02678308f, -0.00815401f, 
    0.00265818f, 0.00194256f, -0.03807673f, 0.04903402f, -0.04183526f, -0.01841901f, -0.03918922f, -0.01221052f, 
    -0.02921977f, -0.02387337f, -0.00618569f, 0.00018314f, 0.04516461f, -0.01263235f, -0.00875416f, 0.00005648f, 
    0.04026110f, -0.01594408f, 0.00964610f, -0.02115915f, 0.01273378f, -0.03503606f, -0.03195392f, 0.02868518f, 
    -0.02141351f, 0.03201925f, -0.04852825f, 0.01057213f, 0.01655114f, -0.02829212f, -0.03900471f, -0.01442205f, 
    -0.03768617f, -0.04401603f, 0.02670474f, 0.00707269f, -0.01296933f, 0.00002279f, 0.00165320f, -0.03924062f, 
    0.03359438f, 0.04999037f, -0.03111939f, 0.03577034f, 0.02707902f, -0.03338725f, -0.04187442f, 0.01160648f, 
    0.02954419f, -0.04767771f, 0.04692564f, -0.01615991f, -0.02056626f, 0.02411280f, 0.03569205f, -0.02886526f, 
    0.03809619f, -0.01139177f, -0.01156464f, -0.04132548f, 0.00033494f, 0.02246353f, 0.00794525f, -0.02251440f, 
    -0.04737690f, -0.03560141f, -0.04746129f, 0.01739218f, 0.02890681f, 0.00099651f, 0.00622624f, 0.04202122f, 
    -0.00749683f, 0.00833332f, -0.03056513f, 0.04294568f, -0.02038005f, -0.03410292f, -0.00635818f, 0.03108019f, 
    -0.02688886f, -0.01904636f, -0.03713505f, -0.02990151f, -0.01595614f, 0.02422882f, 0.00840050f, -0.04014086f, 
    0.01253017f, 0.01539583f, 0.05035352f, -0.00721525f, 0.03541521f, -0.04083592f, 0.04422261f, 0.03326500f, 
    0.04361990f, -0.00428504f, -0.00703078f, 0.00717594f, 0.03949111f, 0.03611859f, -0.00785600f, -0.03089629f, 
    -0.00246730f, -0.03598692f, 0.00028359f, -0.04135015f, 0.03504860f, 0.03257375f, 0.04928962f, 0.04948003f, 
    -0.02991004f, 0.00246270f, -0.01683405f, 0.03871528f, -0.01910578f, 0.02274822f, -0.01933474f, 0.00053456f, 
    0.02239061f, -0.03334381f, 0.04828481f, 0.00571117f, 0.02226518f, -0.03683960f, 0.00432065f, 0.01751506f, 
    -0.04602297f, -0.00146247f, 0.04770117f, 0.04583942f, -0.02259701f, 0.00365945f, 0.01276160f, -0.04710883f, 
    -0.01942348f, -0.01141613f, 0.00731841f, -0.03684261f, -0.04028228f, -0.04740610f, -0.00504146f, 0.00741886f, 
    -0.00718816f, -0.00990612f, -0.04052530f, -0.00096356f, 0.01163293f, 0.01909583f, 0.02882383f, 0.05070638f, 
    0.01912828f, -0.00715100f, -0.05028658f, -0.02643587f, -0.00621503f, 0.02021960f, -0.02004498f, 0.02767307f, 
    -0.02081029f, -0.03170562f, 0.03096221f, 0.02527478f, 0.04542683f, 0.00678590f, 0.03479068f, -0.04437337f, 
    -0.02935603f, -0.04279765f, 0.04393610f, 0.03679943f, -0.02343363f, -0.02299534f, -0.01345922f, -0.05006866f, 
    0.01798293f, -0.04999739f, 0.02416812f, -0.02536357f, -0.01383464f, -0.00027633f, -0.00289328f, 0.02305509f, 
    0.03036484f, -0.01707329f, -0.02704719f, 0.04721171f, -0.02492774f, -0.04811010f, -0.01094292f, -0.03495007f, 
    0.02554795f, -0.00122058f, 0.04393088f, 0.00977911f, 0.02025929f, -0.04784791f, 0.01372303f, -0.00366447f, 
    0.01669039f, -0.00584006f, -0.02904471f, 0.05068705f, -0.03812088f, 0.01714708f, -0.04426211f, -0.03935876f, 
    -0.02316119f, 0.04950406f, 0.00142182f, -0.01805775f, 0.01692938f, -0.03267703f, 0.00383378f, -0.00810785f, 
    0.05013139f, -0.00949293f, -0.04953793f, 0.04952836f, -0.05086248f, 0.04631395f, -0.00412079f, -0.03263816f, 
    -0.01120219f, -0.01291750f, 0.03557701f, 0.04365523f, 0.01379035f, -0.03938622f, -0.03860109f, -0.00541396f, 
    -0.00787586f, 0.02551208f, 0.00879810f, 0.01392268f, 0.00264705f, 0.00368912f, 0.03847738f, -0.00031357f, 
    0.00966072f, 0.00364423f, -0.04319270f, -0.00506923f, -0.04567535f, -0.01667020f, -0.04884756f, -0.02287825f, 
    0.03201652f, -0.05063895f, 0.00046846f, -0.00082379f, -0.03461032f, 0.01055090f, 0.02213810f, -0.04444419f, 
    -0.01357572f, 0.01483309f, -0.02421871f, -0.03855903f, -0.02053685f, -0.03992822f, 0.04664833f, -0.01480651f, 
    -0.03863014f, -0.01546461f, 0.01288355f, -0.03815496f, 0.02719544f, 0.00102970f, 0.04276910f, 0.04559161f, 
    -0.04624544f, 0.00159807f, 0.04829890f, 0.00705263f, -0.00950395f, 0.03668950f, 0.03991995f, 0.04082094f, 
    -0.02406740f, -0.04946038f, -0.02405524f, 0.00799558f, -0.03839065f, -0.04390964f, 0.04982042f, -0.01033333f, 
    0.03316588f, -0.03874128f, 0.01420159f, -0.00198839f, 0.00976872f, -0.01684102f, 0.00428847f, 0.00205409f, 
    -0.00925035f, -0.04417570f, -0.02268260f, 0.01014997f, 0.02099936f, -0.01555614f, -0.03334687f, -0.03045748f, 
    -0.01861262f, -0.04369013f, -0.04733863f, -0.04402059f, 0.02399404f, -0.02603407f, 0.01232616f, 0.01181484f, 
    -0.01459240f, -0.04879930f, 0.04768986f, 0.02102314f, -0.03002497f, -0.03321199f, 0.04487336f, 0.00062417f, 
    -0.04519063f, 0.03746592f, -0.02798623f, -0.02198682f, -0.01951520f, 0.02759311f, 0.01837282f, -0.04346940f, 
    -0.11363555f, -0.09922200f, -0.24876843f, 0.42667896f, -0.12341154f, -0.08322832f, 0.03625513f, 0.01436905f, 
    -0.15953118f, -0.02009956f, 0.00590540f, -0.02171882f, 0.27352223f, 0.02385017f, 0.18948442f, -0.12219831f, 
    0.04847975f, -0.03280712f, 0.06850314f, 0.03962034f, -0.01707245f, 0.02522107f, -0.04851132f, 0.12346783f, 
    0.05324865f, 0.28663656f, 0.00772679f, -0.13159473f, -0.05229584f, 0.05976769f, 0.03050425f, -0.01725980f, 
    -0.09287959f, -0.02703381f, -0.01970032f, -0.08711414f, 0.12916131f, 0.07763334f, 0.23500992f, -0.05425582f, 
    -0.06358989f, 0.17980306f, 0.07854567f, -0.10801999f, 0.03516100f, -0.11629716f, 0.05251288f, -0.04536282f, 
    -0.01706867f, 0.09504436f, -0.05903826f, -0.14916809f, 0.00206894f, 0.09456779f, 0.05779522f, -0.02821002f, 
    0.08473286f, -0.04559638f, -0.05431581f, -0.14871854f, 0.14568615f, -0.04571123f, 0.12732370f, -0.03658799f, 
    -0.03941951f, 0.13887006f, 0.02825744f, 0.10668082f, -0.03489125f, -0.01543746f, 0.02269687f, -0.06081180f, 
    -0.16551241f, 0.14444429f, -0.12898672f, -0.12397888f, 0.03072482f, -0.06576136f, 0.04915455f, 0.09958126f, 
    -0.03760224f, -0.03322890f, 0.09554145f, 0.05314565f, -0.02624911f, 0.38701493f, -0.13396555f, -0.18358709f, 
    -0.04169338f, 0.07111973f, 0.10997704f, -0.02219382f, -0.01459043f, 0.10241836f, 0.07035828f, 0.00450852f, 
    -0.10766489f, 0.13350698f, 0.06647407f, -0.33120060f, 0.02050091f, 0.10215908f, 0.01516920f, 0.07534157f, 
    -0.01124719f, -0.12093233f, -0.06713893f, -0.08642601f, -0.13777421f, -0.21653539f, -0.08659602f, 0.09769075f, 
    0.19121522f, 0.01403443f, 0.01332883f, 0.09050465f, 0.10438760f, 0.09148593f, 0.19280089f, 0.09328923f, 
    0.04707107f, 0.08428974f, -0.07523447f, 0.07697231f, 0.01540649f, 0.04103721f, -0.03891677f, -0.01951724f, 
    0.01470945f, -0.03758870f, -0.05659790f, 0.01528739f, 0.18941011f, 0.31609073f, 0.06226582f, -0.00356349f, 
    0.17336948f, -0.07133092f, 0.22099887f, 0.01208167f, 0.01679139f, 0.03221817f, 0.11815771f, 0.01733609f, 
    -0.05143958f, 0.14574955f, 0.11337846f, -0.14340793f, -0.00549796f, 0.01380229f, 0.03310841f, 0.01025141f, 
    -0.01078522f, 0.02192916f, 0.01901093f, 0.02998065f, 0.03624835f, 0.15096669f, -0.18005058f, 0.32380986f, 
    0.04260068f, 0.07462201f, 0.07812714f, -0.03944745f, 0.00864238f, 0.04504534f, 0.04220068f, -0.02216390f, 
    0.19010885f, -0.08460659f, 0.01784106f, -0.15871698f, -0.04244923f, -0.00297384f, 0.04703349f, 0.08253272f, 
    -0.02208776f, 0.00262677f, -0.00873453f, -0.04957354f, 0.09217928f, 0.03024250f, -0.14705235f, 0.25854683f, 
    0.04518033f, -0.00986765f, 0.01346097f, -0.09296525f, -0.13543539f, 0.00654073f, 0.08834332f, 0.01948445f, 
    0.19638312f, 0.06951902f, -0.13780186f, 0.07101291f, 0.07972666f, 0.01240184f, -0.02827786f, -0.01575996f, 
    0.17170435f, 0.04285062f, 0.01563532f, 0.17330249f, -0.09952977f, -0.15500614f, -0.03150307f, 0.29944971f, 
    -0.00219205f, -0.01135985f, -0.04314017f, -0.00283107f, -0.12656157f, -0.02717847f, -0.05934918f, -0.17848220f, 
    -0.16671219f, -0.03990334f, -0.00304745f, 0.19226013f, 0.05748583f, -0.02134773f, 0.04122127f, 0.00531821f, 
    -0.02393572f, -0.04673532f, -0.06583726f, 0.07854354f, -0.08432005f, 0.16661809f, 0.12633611f, -0.36095327f, 
    0.02365841f, 0.12358251f, -0.02217596f, 0.02277808f, -0.02726304f, -0.15946400f, 0.02378503f, -0.08551265f, 
    0.02767974f, 0.18227395f, 0.15797645f, -0.22847523f, 0.10756904f, -0.00861644f, 0.11009983f, -0.02855181f, 
    0.08008174f, 0.06245980f, 0.07294038f, 0.15858294f, 0.00017820f, 0.05418411f, 0.00734572f, 0.19300324f, 
    0.04650258f, -0.04103014f, -0.00877995f, -0.00119463f, 0.01691284f, 0.02876455f, -0.03917927f, -0.12778209f, 
    0.01635705f, 0.06446525f, 0.10780172f, -0.20559791f, -0.04629900f, 0.01936000f, -0.00761662f, 0.09786400f, 
    -0.04461541f, -0.02334750f, 0.02966036f, 0.07347792f, 0.16323717f, 0.10178765f, -0.08482150f, 0.29279977f, 
    0.02478793f, 0.03466472f, -0.07618768f, 0.00441989f, 0.12864813f, 0.00500524f, -0.01722920f, 0.12470471f, 
    0.20252924f, 0.12734498f, -0.13166445f, 0.24620056f, 0.02502899f, -0.11186692f, -0.13067932f, -0.03733941f, 
    -0.04524823f, -0.08768117f, 0.04158615f, -0.16459659f, -0.21181333f, 0.25476399f, 0.07578534f, -0.33561611f, 
    0.13551258f, 0.10447713f, -0.00943622f, 0.03589091f, -0.09565936f, 0.01640978f, -0.02831120f, 0.04615557f, 
    -0.09029044f, 0.07822865f, 0.19136927f, -0.20918876f, 0.10184950f, 0.13540378f, 0.03492928f, 0.05743041f, 
    -0.10772320f, -0.08460467f, 0.01846992f, 0.04174211f, -0.39187855f, -0.12318312f, 0.07582309f, 0.06879107f, 
    -0.02832230f, 0.15993395f, -0.05947372f, -0.00930738f, -0.01283515f, 0.05912802f, -0.12840930f, 0.03507905f, 
    0.15466675f, -0.01015861f, 0.14467981f, 0.09281459f, 0.11869594f, -0.06594735f, 0.00393963f, 0.03194654f, 
    -0.11728467f, -0.16739073f, -0.00602707f, -0.00111779f, 0.18724754f, 0.05760733f, -0.07302526f, 0.19248715f, 
    0.03161696f, 0.01757537f, 0.04157529f, 0.01355181f, -0.11562511f, 0.03461300f, 0.16097800f, 0.17241360f, 
    -0.08322066f, -0.02368328f, 0.08923111f, 0.09398437f, -0.01038048f, 0.05418535f, -0.01970712f, -0.02515578f, 
    0.04939843f, -0.10304550f, 0.07024503f, 0.01929606f, 0.12137751f, 0.17854278f, 0.13052484f, -0.22486287f, 
    -0.02790804f, 0.07663343f, 0.11345030f, -0.03568735f, 0.06308104f, -0.01772527f, 0.10285586f, -0.08809201f, 
    -0.03466687f, 0.03300284f, 0.02521751f, -0.00352849f, 0.03230750f, -0.04416008f, 0.04720242f, -0.00974474f, 
    0.02152345f, 0.01919042f, -0.04462828f, -0.02918036f, 0.00136077f, -0.02315425f, 0.00747810f, 0.00830191f, 
    -0.01348309f, 0.02420513f, -0.00611579f, 0.04549573f, 0.01092626f, 0.02216920f, -0.05184662f, -0.03717725f, 
    -0.03816916f, 0.03775869f, -0.00847528f, -0.00685623f, 0.04014312f, -0.00791535f, 0.01387006f, 0.01738674f, 
    -0.00626896f, 0.03199697f, -0.05653137f, 0.02448887f, -0.02109630f, 0.02754416f, 0.04228874f, -0.02546199f, 
    0.02283752f, 0.02367979f, 0.02289480f, 0.04167093f, 0.02991247f, 0.01376295f, 0.03957998f, -0.00979142f, 
    0.02223653f, 0.02262795f, -0.01064658f, 0.00818776f, -0.00643322f, 0.01696037f, -0.02450165f, 0.04455127f, 
    -0.05084741f, -0.05336476f, -0.00575006f, 0.04383753f, 0.00702057f, 0.02557772f, -0.02671267f, 0.00145564f, 
    0.00352760f, 0.00905488f, -0.01693191f, 0.01261135f, -0.02809782f, 0.01524460f, 0.00285305f, 0.01603375f, 
    0.00448483f, -0.05155674f, -0.04921373f, -0.00578429f, 0.01360304f, -0.04890736f, -0.00797179f, -0.04381884f, 
    -0.02766700f, -0.01317210f, -0.03683501f, 0.04575885f, -0.04005243f, 0.01791849f, 0.00224413f, -0.03576237f, 
    0.03443658f, 0.03366207f, -0.02314687f, -0.04185451f, 0.00670357f, 0.04146119f, -0.00539932f, 0.04845605f, 
    -0.01837254f, -0.01538241f, 0.01357848f, -0.04170937f, -0.03354043f, 0.03433844f, 0.01767643f, -0.05589582f, 
    -0.04654760f, 0.03505176f, -0.00985077f, -0.03579110f, -0.00479215f, 0.04694315f, 0.03651010f, -0.03587380f, 
    0.03546698f, 0.03825105f, -0.01937593f, 0.00020269f, 0.02962719f, 0.01367663f, 0.01652411f, -0.03286181f, 
    0.05251622f, -0.03568875f, 0.02215106f, -0.02362360f, -0.01081452f, -0.03370236f, -0.02682281f, -0.04197561f, 
    0.03498490f, -0.03331663f, -0.01449895f, -0.00454993f, -0.01509984f, -0.03465906f, -0.02268351f, -0.00106396f, 
    -0.03259328f, 0.01999796f, 0.02037707f, 0.02972342f, 0.02634812f, -0.05562522f, -0.04723708f, 0.04866983f, 
    -0.02271405f, 0.01857745f, 0.04416725f, -0.01521690f, -0.05108132f, -0.01164000f, -0.02444310f, -0.01596151f, 
    0.04623146f, 0.04271817f, -0.00499238f, -0.05000087f, -0.03321449f, -0.04336413f, -0.02240189f, 0.02238859f, 
    0.03456593f, 0.01504058f, 0.01905232f, 0.01619781f, -0.01587816f, 0.01376985f, 0.02683900f, -0.00203747f, 
    0.02947095f, 0.03340840f, 0.01914494f, 0.04258948f, 0.02922173f, -0.04319640f, -0.01069918f, -0.00333297f, 
    -0.04585677f, 0.01595651f, -0.00527773f, -0.03997835f, 0.01313515f, -0.04042010f, -0.01386858f, 0.02114236f, 
    0.00299564f, 0.03399179f, -0.02655541f, 0.00525531f, 0.02615558f, -0.03053365f, 0.03034075f, -0.03006226f, 
    -0.03527912f, 0.00720723f, -0.02561416f, 0.01904397f, -0.03202113f, 0.00755150f, 0.01486120f, -0.02849179f, 
    0.03339258f, 0.01902106f, 0.01307353f, -0.02776155f, 0.03050367f, -0.02187019f, 0.00116742f, -0.04380519f, 
    -0.01837311f, -0.05172712f, -0.01376882f, -0.02429871f, -0.01100767f, -0.03046055f, -0.04069087f, 0.02323784f, 
    -0.01908476f, -0.01152958f, -0.04545868f, -0.04161851f, -0.00723825f, -0.02670957f, 0.04758143f, 0.01852418f, 
    -0.04597055f, -0.02445698f, 0.00262933f, 0.02046972f, 0.02218574f, -0.01898791f, -0.01360321f, -0.00664572f, 
    -0.00029011f, 0.02587156f, 0.01109298f, 0.03000223f, -0.02483351f, -0.04783032f, -0.01852181f, -0.04499574f, 
    0.00359348f, 0.03153643f, -0.01913969f, -0.00231590f, -0.01300250f, -0.04176790f, 0.00646511f, 0.03946916f, 
    -0.01759087f, -0.01472402f, 0.03992298f, 0.03014815f, 0.00789300f, -0.00738869f, 0.03245589f, -0.01960753f, 
    -0.01805233f, -0.00124491f, -0.00387747f, -0.03130279f, -0.01628420f, 0.03979267f, -0.04478659f, 0.00294929f, 
    -0.01584061f, 0.01970146f, -0.04409264f, -0.04840497f, 0.02543489f, -0.03820523f, -0.04695745f, -0.04053511f, 
    -0.04257601f, -0.01211825f, 0.02695347f, -0.02671530f, -0.01733101f, 0.00362805f, 0.03017282f, -0.02639482f, 
    -0.01062766f, 0.02234074f, -0.04755247f, 0.00220780f, 0.01419800f, -0.02491242f, -0.01076688f, 0.03462826f, 
    -0.02744564f, -0.05119539f, 0.03643220f, 0.02699298f, -0.04175092f, 0.05544465f, 0.00914203f, -0.00137516f, 
    -0.05283052f, -0.04188490f, -0.03778826f, 0.01719434f, -0.02278236f, -0.02523363f, -0.03431398f, -0.01889280f, 
    -0.02370445f, -0.03756511f, -0.03040844f, 0.00865620f, -0.04566304f, -0.04578892f, -0.03295307f, -0.02092589f, 
    -0.04041684f, 0.04109145f, -0.04935978f, -0.01668531f, -0.05144960f, -0.04049390f, -0.03970113f, 0.03674087f, 
    -0.00046151f, -0.03963954f, 0.00213423f, -0.00048030f, -0.03486564f, -0.05212422f, 0.01753086f, -0.02391780f, 
    -0.01514164f, -0.04052286f, -0.00225088f, -0.02975368f, -0.05149376f, 0.03957637f, 0.02024300f, 0.02117094f, 
    0.02247075f, 0.01853080f, 0.00558707f, 0.03824576f, -0.03062789f, -0.03653681f, -0.04608209f, -0.03283978f, 
    0.03106709f, -0.04609171f, 0.00794277f, -0.01897878f, 0.01113671f, 0.03873682f, -0.04234252f, -0.01538487f, 
    0.02312942f, 0.03742321f, -0.00630199f, 0.04131076f, -0.02467328f, 0.04573542f, -0.04027503f, 0.03835948f, 
    -0.05605524f, 0.02715154f, 0.02050592f, -0.01901017f, -0.02309868f, -0.01421808f, 0.01614379f, 0.02327031f, 
    -0.04765421f, -0.04855348f, -0.04087589f, 0.03774704f, -0.00493909f, 0.04388375f, -0.02428181f, 0.01860372f, 
    0.01868719f, 0.01099865f, 0.04714225f, -0.04900344f, -0.01960053f, -0.04938018f, 0.02915679f, 0.02876155f, 
    0.29479334f, 0.07332044f, -0.19505063f, 0.01185011f, 0.23245536f, -0.00521112f, 0.02013165f, 0.04294580f, 
    0.13013072f, -0.03498014f, -0.03427586f, -0.07005375f, -0.21491298f, 0.13132472f, 0.08362017f, -0.15209991f, 
    0.09758601f, 0.03406221f, -0.04141621f, 0.00134180f, -0.14982097f, -0.06022891f, -0.07519934f, 0.05991862f, 
    -0.30459648f, 0.18899521f, 0.16270393f, -0.07976019f, 0.15608734f, 0.12548871f, -0.03854623f, 0.09918599f, 
    0.09656196f, 0.08409847f, -0.11473537f, 0.11282064f, 0.08173024f, 0.23993202f, -0.13825858f, 0.16407616f, 
    -0.14278491f, 0.11525528f, 0.11088550f, -0.00466671f, 0.00355768f, -0.01480074f, 0.08478823f, 0.01914527f, 
    0.05195157f, 0.23415017f, 0.08291670f, 0.22570807f, 0.25649044f, 0.08085215f, 0.18298379f, 0.07734685f, 
    0.09612765f, -0.09253167f, 0.06767939f, -0.00648673f, 0.17404659f, 0.22247429f, 0.04106979f, 0.12453698f, 
    0.01544391f, 0.19271371f, 0.02498560f, 0.03605258f, -0.03441269f, -0.01241137f, 0.00424446f, -0.15349093f, 
    0.21838903f, 0.08693568f, -0.04730904f, 0.02541027f, 0.20311168f, 0.03322003f, 0.03896600f, -0.03422183f, 
    0.13768470f, 0.15346223f, 0.17862235f, 0.03009934f, -0.11084076f, -0.14934361f, 0.05687074f, -0.21697415f, 
    0.03016797f, 0.01419283f, -0.01414695f, 0.02313898f, 0.09076516f, 0.03339822f, 0.02065464f, -0.07141788f, 
    -0.18770304f, -0.10089727f, -0.19989873f, -0.09280793f, 0.15791228f, -0.07157121f, 0.00814139f, 0.02655729f, 
    0.00080370f, -0.06768389f, 0.16457233f, 0.07685482f, 0.34915897f, -0.13929731f, -0.03092975f, 0.08424961f, 
    -0.05636565f, -0.12020981f, -0.11235408f, 0.15550096f, 0.08403405f, -0.00322515f, 0.05354154f, 0.13026276f, 
    0.19598189f, 0.00432118f, -0.11075718f, -0.06367125f, -0.08637661f, 0.08882144f, 0.08391421f, -0.05472796f, 
    0.02657618f, -0.10055708f, 0.09592751f, 0.05991831f, -0.17644206f, 0.01998465f, 0.16598952f, 0.09864639f, 
    0.08464246f, 0.10920887f, 0.17458385f, -0.05315769f, 0.09465740f, -0.00801806f, 0.17210254f, 0.09215873f, 
    -0.13541284f, -0.11662474f, -0.11880239f, -0.30921635f, 0.08397215f, -0.01743179f, -0.09313051f, 0.01231344f, 
    0.07872121f, 0.03588982f, -0.00339462f, -0.03151669f, -0.27663541f, -0.16076043f, 0.02325692f, 0.21979760f, 
    0.02497762f, 0.08301552f, 0.14043415f, 0.04037398f, -0.01119752f, 0.17203805f, 0.00585082f, 0.05304423f, 
    0.07077362f, 0.02198048f, 0.11121769f, -0.03299724f, 0.00226814f, 0.17893994f, 0.00779692f, 0.07891532f, 
    -0.04287319f, -0.06199463f, 0.04415124f, -0.00251936f, 0.06774029f, 0.06415761f, -0.17484973f, -0.00159182f, 
    -0.22747806f, -0.21563759f, 0.03494534f, 0.01810316f, -0.06728872f, 0.03762595f, 0.05840927f, 0.03845379f, 
    0.05941334f, 0.02183769f, -0.04004597f, 0.22232296f, -0.01837097f, -0.03040878f, -0.00674956f, -0.01042384f, 
    -0.00840648f, 0.17038582f, -0.12300725f, 0.10403376f, 0.27874163f, 0.00464395f, 0.07749171f, 0.12093215f, 
    0.05068117f, 0.24193533f, -0.06531557f, 0.02724441f, -0.01522718f, 0.02760282f, -0.20241730f, 0.00373013f, 
    -0.05380025f, -0.19471078f, -0.09895156f, 0.19009291f, 0.00801996f, -0.10641905f, 0.17535686f, 0.18170136f, 
    -0.04032046f, -0.06692286f, 0.00768891f, 0.06145226f, -0.26818874f, -0.06758490f, -0.11354831f, -0.23377712f, 
    0.07674944f, 0.05567574f, -0.04554032f, -0.07238966f, -0.11488765f, -0.05797185f, -0.02290011f, 0.03078019f, 
    -0.33140245f, -0.18535540f, -0.22393662f, -0.36347491f, 0.08861940f, -0.07530937f, 0.00197626f, -0.03795534f, 
    0.11561845f, 0.08720236f, -0.00980497f, 0.21087055f, 0.11253849f, -0.15755202f, 0.05928272f, -0.03966928f, 
    0.04201042f, -0.09603658f, 0.02375467f, 0.02720188f, 0.02114659f, -0.05683684f, 0.00949294f, -0.05447211f, 
    -0.21831438f, -0.03606030f, -0.09633215f, -0.16161077f, -0.00268409f, 0.15705171f, 0.07251237f, 0.06285429f, 
    0.03959909f, 0.09243760f, 0.01661488f, 0.12433755f, 0.03371999f, 0.00895992f, -0.17235346f, -0.16327535f, 
    -0.12194011f, 0.00397808f, -0.07318383f, -0.04474173f, 0.15744232f, 0.01198965f, -0.02856204f, 0.31477031f, 
    0.09401236f, -0.10993367f, -0.15498999f, -0.11752444f, -0.09103271f, 0.00658220f, 0.00001639f, -0.10342600f, 
    -0.01733060f, -0.11530553f, -0.09698009f, -0.12737656f, -0.27877527f, -0.02557537f, -0.09184936f, -0.19417842f, 
    0.18157412f, -0.01154235f, 0.04586956f, 0.00639438f, 0.00362404f, 0.15517692f, 0.01189039f, 0.03460763f, 
    0.23063980f, -0.25364298f, -0.05883569f, 0.29617161f, 0.16080049f, 0.05252801f, 0.06822588f, -0.06237728f, 
    0.02136154f, -0.09179188f, -0.14167386f, 0.00662762f, 0.14263116f, -0.17338249f, -0.03259780f, 0.04662675f, 
    -0.06686966f, -0.01698614f, -0.00956671f, 0.04837207f, 0.03628568f, -0.00082365f, -0.09135362f, 0.06834987f, 
    -0.02651162f, 0.05038369f, 0.08048213f, 0.02122690f, -0.04465781f, 0.01697042f, 0.05402104f, -0.02657201f, 
    -0.04713066f, 0.00932647f, 0.04943352f, -0.05087049f, 0.17402743f, -0.04276487f, -0.04769531f, -0.12052696f, 
    -0.00834521f, 0.01602358f, -0.17405139f, -0.12602273f, 0.00081572f, 0.17655791f, 0.27813256f, 0.17591587f, 
    0.12712605f, 0.10865210f, 0.12427862f, -0.05630486f, 0.04269041f, 0.08523077f, -0.01368498f, 0.01488174f, 
    0.08707204f, 0.07972928f, 0.12827381f, 0.08978415f, 0.11527907f, 0.04343756f, 0.03551624f, 0.08039368f, 
    0.10361555f, 0.09723841f, 0.04535858f, -0.00879576f, 0.02317225f, 0.02790071f, -0.05067926f, 0.01636811f, 
    -0.03464615f, -0.02993715f, -0.06761739f, 0.11786840f, -0.00958302f, -0.10413054f, -0.10481241f, -0.04972571f, 
    0.10085762f, -0.20936772f, -0.08100659f, -0.02802022f, 0.24786307f, -0.12941609f, 0.00922981f, -0.05675453f, 
    0.00484949f, -0.14800674f, -0.08434294f, -0.13603705f, -0.28932777f, -0.11617053f, -0.18155636f, 0.01621319f, 
    0.44930857f, -0.01299752f, 0.00961698f, -0.13685438f, 0.06727467f, 0.04903937f, -0.00131836f, -0.00210348f, 
    -0.04241619f, -0.08457426f, -0.06142555f, 0.04731354f, 0.22090113f, 0.24430688f, 0.11341506f, 0.31776538f, 
    -0.13156815f, 0.01201103f, 0.09624424f, -0.00654051f, 0.07646628f, -0.05099067f, 0.01305240f, -0.11065693f, 
    0.28113443f, 0.15107086f, -0.16161898f, 0.11839271f, 0.23591669f, 0.07692526f, 0.11735111f, 0.08949339f, 
    0.04624480f, -0.01507045f, -0.11356247f, -0.02990845f, -0.05712334f, 0.15728705f, 0.08360819f, 0.11877951f, 
    0.04728485f, 0.00322603f, -0.07295046f, -0.00625904f, -0.04874247f, -0.04020509f, -0.07709277f, -0.17003545f, 
    0.11382420f, 0.10023971f, -0.08446036f, 0.10136618f, -0.00164206f, -0.13197511f, 0.05333414f, -0.06231130f, 
    0.07823725f, 0.04533397f, 0.24702898f, -0.08390702f, 0.04469349f, 0.00880700f, -0.02613667f, -0.19301906f, 
    -0.13458163f, -0.10239019f, -0.06104592f, -0.10061759f, 0.03259902f, 0.02758402f, 0.18522890f, 0.03531396f, 
    -0.23781388f, 0.06364443f, 0.03862726f, 0.00139761f, 0.03739909f, -0.17966363f, -0.11098172f, -0.08418861f, 
    -0.03313732f, -0.10232829f, 0.03083914f, -0.01796055f, 0.21753016f, -0.04645682f, 0.29628679f, -0.02748948f, 
    0.01405623f, 0.15465252f, -0.05657373f, 0.11867017f, -0.10013102f, -0.03806861f, 0.17097150f, 0.22374228f, 
    -0.02226909f, -0.16758241f, 0.00268398f, 0.12757860f, 0.08226810f, 0.17127673f, 0.00456607f, -0.06551030f, 
    -0.12945607f, -0.19947338f, 0.13915543f, -0.07681572f, 0.25313458f, 0.06099424f, 0.07801450f, 0.34099320f, 
    0.08948249f, -0.01441617f, 0.26666453f, -0.01665811f, -0.06372842f, 0.23650497f, 0.24353284f, -0.06251953f, 
    0.13565190f, 0.23818341f, -0.20817174f, -0.06832534f, -0.07844907f, 0.03125138f, -0.05961353f, 0.07463759f, 
    -0.05824797f, 0.10584759f, -0.19827685f, -0.10788172f, 0.05672761f, 0.17876856f, 0.13481548f, 0.32887372f, 
    -0.05168833f, -0.00293278f, -0.19083677f, 0.08610919f, 0.12701243f, 0.17018455f, -0.07941835f, 0.06860814f, 
    0.35564876f, 0.04581423f, 0.05690827f, 0.20004945f, 0.01098633f, 0.09144222f, 0.02493924f, -0.00868279f, 
    -0.04019215f, -0.12010180f, 0.05218517f, 0.04893902f, 0.07057416f, 0.10458344f, -0.07613558f, -0.08902024f, 
    0.02633593f, 0.03388300f, -0.00659044f, -0.01715354f, -0.16586187f, -0.01584962f, 0.04981896f, -0.09642740f, 
    -0.09181124f, 0.10638459f, -0.01649286f, 0.23524351f, 0.08425445f, -0.00543687f, -0.11569258f, -0.13300958f, 
    -0.01321445f, 0.17794731f, 0.07279398f, 0.03489083f, 0.11761104f, 0.10118688f, 0.23192653f, -0.01110344f, 
    -0.07367336f, 0.12327784f, -0.20301205f, 0.02244912f, 0.09425130f, 0.05851611f, -0.17650865f, -0.07225246f, 
    0.25464079f, 0.13953446f, -0.16027704f, -0.19449154f, 0.04233975f, 0.05949680f, 0.16821922f, 0.02612190f, 
    0.04247087f, -0.07763927f, 0.09706002f, 0.02751469f, 0.01928765f, 0.05417129f, 0.07341351f, 0.04373955f, 
    -0.10983893f, -0.02337096f, -0.09836338f, -0.16303487f, 0.01089750f, -0.01937149f, -0.02626234f, -0.16669749f, 
    -0.02913140f, 0.14420149f, -0.01779890f, -0.04369270f, -0.14489549f, -0.05619362f, 0.13958080f, -0.05807024f, 
    0.09796032f, 0.22218570f, 0.11840770f, 0.16365589f, 0.00049173f, 0.03895087f, 0.11834823f, -0.04197238f, 
    -0.07451578f, -0.03353906f, 0.11439555f, -0.16253357f, 0.04065464f, 0.05254821f, -0.00714429f, 0.01791896f, 
    0.00551605f, -0.10306027f, -0.11586778f, 0.00227329f, 0.03371267f, -0.02480409f, -0.03622365f, -0.03674443f, 
    0.00147116f, -0.00352698f, 0.03661657f, 0.11975046f, 0.36318177f, 0.04343334f, -0.17262205f, -0.25025344f, 
    -0.10241323f, 0.10533028f, -0.09248458f, 0.01907246f, -0.01955532f, -0.10781968f, 0.02666283f, 0.13378417f, 
    0.02222550f, -0.17238387f, -0.19158229f, -0.02358403f, 0.02397921f, -0.08811805f, -0.05547158f, -0.01245131f, 
    -0.05613676f, 0.03638519f, -0.15414712f, -0.08588821f, -0.16687912f, 0.27834228f, -0.08660050f, -0.10337021f, 
    0.09266101f, -0.10014126f, -0.00945478f, -0.29794130f, -0.13673995f, 0.07251278f, -0.00522443f, -0.07376446f, 
    0.11456303f, -0.04293476f, -0.01662422f, 0.22968166f, 0.00362621f, 0.04193070f, -0.05819552f, -0.25530404f, 
    0.00705314f, -0.13239555f, -0.13398884f, 0.11476148f, -0.15954635f, -0.07084435f, 0.10679292f, -0.36610010f, 
    0.02555741f, 0.14553349f, 0.12745978f, 0.03007037f, 0.02575994f, -0.12661052f, -0.11337344f, 0.10021307f, 
    -0.08529980f, -0.08108617f, 0.01433840f, 0.19409254f, 0.03207896f, 0.02826818f, 0.02181271f, -0.10219552f, 
    -0.09001926f, 0.02665920f, -0.02502091f, 0.09108567f, 0.30781993f, 0.05489506f, 0.16713277f, 0.17917447f, 
    0.19819854f, 0.09989724f, 0.02088004f, 0.00658099f, -0.12207527f, 0.33431670f, 0.25443786f, 0.15595189f, 
    0.18771555f, 0.06403176f, -0.08064944f, -0.09882646f, -0.12840387f, -0.03355007f, 0.01399466f, -0.06111663f, 
    0.06494756f, 0.10139858f, 0.02210389f, 0.01965851f, -0.03946035f, 0.05061270f, 0.03206510f, -0.13716860f, 
    0.04223508f, -0.16716875f, 0.07019144f, -0.07336593f, 0.06795657f, 0.01743552f, -0.22913225f, -0.02705315f, 
    -0.00950785f, 0.00559864f, -0.06365004f, -0.16512279f, 0.00596730f, 0.09299741f, 0.04778828f, 0.08505011f, 
    -0.10130969f, 0.22185718f, 0.06894473f, 0.04069340f, 0.14009264f, 0.16405997f, -0.08726810f, 0.02980740f, 
    0.05928379f, 0.13529004f, 0.01998191f, 0.08052135f, 0.17264694f, 0.07012452f, 0.07156468f, 0.02641325f, 
    -0.17866547f, -0.04097677f, -0.01198020f, 0.03594257f, 0.01572049f, -0.07180741f, 0.05621988f, 0.06315102f, 
    0.01748975f, 0.04057691f, 0.00505458f, 0.10562545f, 0.12001216f, -0.23694126f, 0.00004651f, -0.11418389f, 
    0.18139687f, 0.01979400f, -0.16745239f, -0.03741516f, -0.08411519f, 0.09547894f, 0.02519569f, 0.07346421f, 
    -0.09613341f, 0.10235516f, 0.25329882f, -0.05171667f, -0.09464012f, -0.04784189f, -0.03683797f, -0.07321143f, 
    -0.10152386f, 0.08425394f, 0.06743515f, -0.01413681f, -0.02993628f, 0.01526632f, -0.15172884f, -0.07750597f, 
    -0.00632783f, 0.09188194f, 0.00487845f, 0.06052473f, 0.00312913f, 0.04459101f, 0.11628877f, 0.19750865f, 
    -0.01010763f, 0.00615335f, 0.09994731f, -0.14334750f, 0.03415165f, 0.01740705f, 0.01873837f, 0.07027993f, 
    0.02403264f, -0.05685733f, -0.13783440f, -0.05878353f, 0.07352486f, -0.01984165f, 0.01423735f, 0.17262129f, 
    0.06468730f, 0.09078638f, 0.06702690f, 0.03211692f, 0.05082387f, 0.04925451f, -0.05208523f, -0.05496936f, 
    0.29123309f, -0.05796590f, 0.16196822f, -0.02150070f, -0.00179965f, 0.05467644f, 0.03291838f, 0.03582855f, 
    0.09029240f, 0.14179067f, -0.03768875f, 0.11800174f, -0.00060907f, 0.01763912f, -0.17243876f, 0.04251705f, 
    0.00773414f, 0.04850271f, 0.05319975f, -0.10175411f, 0.00788808f, 0.02059668f, -0.03176157f, -0.15820538f, 
    -0.04572998f, 0.07735290f, 0.07407743f, -0.03032043f, 0.02429926f, -0.08010643f, -0.02368752f, 0.14227960f, 
    0.11539277f, 0.22694205f, -0.07312877f, 0.03490811f, 0.07662189f, -0.06792838f, -0.10232839f, -0.20818956f, 
    0.02756810f, -0.13750800f, -0.07906377f, 0.08505229f, 0.01368084f, -0.03582332f, -0.15511948f, 0.02311770f, 
    0.21727449f, -0.04900623f, 0.19379750f, 0.25978556f, 0.16348743f, 0.03585197f, 0.05657804f, -0.08113569f, 
    -0.01514447f, -0.07982834f, 0.13453633f, 0.00011999f, 0.13507809f, 0.02364150f, 0.05541631f, -0.20589361f, 
    0.21649152f, -0.10149957f, 0.13507165f, 0.04135046f, 0.02119314f, -0.03569038f, -0.01360326f, 0.04271522f, 
    -0.14563595f, -0.00896078f, -0.10919376f, -0.07205366f, 0.07027498f, -0.09668288f, -0.01557263f, 0.08268397f, 
    0.06050256f, 0.06005457f, -0.04134531f, 0.03290081f, -0.04127429f, -0.14832781f, 0.03438850f, -0.02235688f, 
    0.08077481f, 0.09032849f, 0.05978952f, 0.03340197f, 0.07998554f, 0.07629556f, -0.05135619f, 0.13185708f, 
    0.00224345f, -0.17074722f, -0.05594835f, -0.17298724f, 0.03728921f, -0.01914844f, 0.16654141f, 0.02020420f, 
    0.02922039f, -0.08560016f, 0.05452876f, 0.07624064f, 0.01719972f, -0.04606806f, -0.09445562f, -0.13755749f, 
    -0.01397893f, -0.01385573f, 0.09369273f, 0.05329702f, 0.00282214f, -0.07209534f, 0.10425640f, 0.07389890f, 
    -0.19969818f, -0.03670065f, 0.06768499f, -0.09289272f, -0.01330831f, -0.01476718f, -0.08651782f, 0.07691316f, 
    -0.09232903f, 0.08880509f, -0.04178023f, -0.04927170f, 0.17398995f, 0.09834246f, 0.16793436f, 0.07346749f, 
    0.08031788f, -0.06350037f, 0.08787324f, -0.00554799f, -0.02673974f, 0.01198340f, 0.07312967f, 0.21308720f, 
    0.05050561f, -0.08262268f, 0.14425217f, 0.26047745f, 0.04384424f, 0.07206908f, -0.07594346f, 0.05532311f, 
    0.00588940f, -0.06566531f, 0.04952728f, -0.09381345f, -0.03503237f, 0.01891217f, 0.01375170f, 0.00458228f, 
    -0.06343869f, -0.00228873f, -0.10684552f, 0.10370687f, -0.09280727f, -0.03202882f, -0.04193646f, -0.01325339f, 
    0.23322047f, 0.00316920f, 0.06950726f, 0.14409831f, 0.01058292f, -0.03199142f, -0.05047897f, 0.02958806f, 
    0.02332363f, 0.09758270f, 0.08486340f, 0.02606412f, -0.21829364f, -0.02517355f, 0.21110940f, -0.07615288f, 
    -0.01001900f, -0.02511641f, 0.14141397f, 0.06599065f, 0.02978586f, 0.01287772f, 0.13379985f, -0.12960699f, 
    -0.11765113f, -0.02112424f, 0.12935290f, -0.09011780f, -0.01786416f, 0.10931949f, 0.05991911f, -0.04133167f, 
    0.05651226f, 0.11359725f, 0.06934457f, 0.12415355f, 0.20155479f, -0.26750538f, 0.08999032f, 0.03394651f, 
    -0.01797802f, -0.01050807f, -0.00940750f, 0.05238419f, 0.03839188f, -0.09884465f, 0.04154705f, -0.00237844f, 
    -0.06715594f, -0.05782830f, 0.02070132f, -0.07901864f, -0.00622275f, 0.00092484f, 0.04148679f, 0.04879197f, 
    0.03114875f, 0.10001171f, -0.01001647f, 0.02316968f, 0.25165197f, -0.02424289f, -0.03217200f, -0.03547142f, 
    -0.01718881f, 0.02140735f, -0.02513892f, -0.05262712f, 0.08862085f, 0.01832156f, 0.03950289f, -0.00136088f, 
    0.02217859f, 0.14579493f, -0.19523257f, -0.09591711f, 0.03109604f, 0.07371704f, 0.01459312f, 0.05832113f, 
    0.03825041f, -0.02146469f, 0.01575882f, 0.07840311f, -0.16360535f, -0.09935607f, -0.07720251f, -0.04017683f, 
    -0.11243993f, 0.08161632f, 0.03341484f, 0.02464660f, 0.05628325f, -0.13848028f, -0.18418083f, -0.09943680f, 
    0.11614848f, -0.03022348f, 0.02285562f, 0.17467394f, 0.13032462f, 0.00130743f, -0.02256768f, 0.07488700f, 
    -0.06826181f, 0.02142355f, -0.02081844f, -0.01154114f, 0.23574132f, -0.11299929f, 0.05258735f, 0.11962366f, 
    0.02754883f, 0.04381983f, -0.13251673f, 0.06993033f, 0.04033974f, -0.10042858f, 0.14740188f, 0.00405393f, 
    0.03352483f, -0.02851907f, -0.03119438f, -0.03647973f, -0.03040181f, 0.02507789f, -0.04506142f, 0.02271929f, 
    -0.01568098f, 0.00151854f, -0.04040119f, -0.03192110f, -0.01128120f, 0.02285023f, -0.05605396f, 0.02323502f, 
    -0.01924402f, -0.00624931f, -0.02345478f, -0.05323363f, -0.01456347f, -0.01106223f, 0.03264087f, -0.00655501f, 
    -0.01155723f, -0.01114179f, 0.00329796f, 0.00323851f, 0.00992315f, -0.02417723f, 0.04501661f, -0.03086309f, 
    0.02601145f, -0.00446936f, -0.00222913f, -0.00034767f, 0.00146060f, 0.00979662f, 0.01596717f, -0.02559095f, 
    0.03215416f, 0.00140632f, -0.04702235f, -0.04945840f, -0.04300085f, -0.00692971f, -0.05415363f, -0.05004094f, 
    0.02736138f, -0.02918804f, 0.01181124f, -0.03317135f, -0.03837065f, 0.02496948f, 0.00040747f, 0.02947600f, 
    -0.04473356f, -0.01083316f, -0.02741037f, -0.00987471f, 0.00536592f, 0.02878580f, 0.02999142f, -0.05117731f, 
    -0.02739264f, -0.00221236f, -0.02229464f, -0.04720781f, 0.00080642f, -0.05332629f, 0.03256512f, -0.02452187f, 
    -0.02149285f, -0.01012665f, 0.00590142f, -0.00922779f, 0.01607282f, -0.01323657f, 0.02522350f, 0.00763314f, 
    0.02271638f, -0.04236592f, -0.05146305f, -0.02124836f, -0.03873239f, -0.03196539f, -0.04010284f, -0.03087217f, 
    0.04286148f, 0.00884845f, 0.02372910f, 0.02543264f, -0.03453536f, 0.04213485f, 0.01175471f, -0.05002838f, 
    0.04192919f, -0.03575924f, 0.00804966f, 0.02052700f, -0.00062525f, 0.02926611f, -0.03558667f, 0.02955068f, 
    -0.00594740f, 0.00946865f, -0.03101547f, 0.01725714f, 0.01962485f, -0.03787955f, -0.04710878f, 0.01150984f, 
    0.01788051f, -0.00861802f, 0.03619321f, -0.04194817f, 0.04540315f, 0.00971873f, -0.03391344f, 0.00074411f, 
    -0.00457071f, -0.01820013f, -0.01172637f, -0.05631746f, -0.04084197f, -0.04303094f, -0.05626588f, -0.04004778f, 
    0.00902066f, -0.05025984f, -0.02985924f, 0.02072725f, 0.04238247f, 0.03167890f, -0.02695072f, -0.03229928f, 
    -0.02959585f, 0.02812994f, 0.01327341f, -0.04029892f, -0.00811996f, -0.04940717f, -0.01567633f, 0.01134051f, 
    -0.04148199f, 0.02395100f, 0.03876362f, 0.01090841f, -0.03571272f, -0.05520860f, -0.03443022f, -0.02936767f, 
    -0.01997522f, 0.04356077f, 0.03383949f, -0.00442003f, 0.01033208f, -0.03842587f, -0.00893341f, 0.01624513f, 
    -0.00467464f, 0.01332181f, 0.01414573f, 0.03755411f, 0.01330489f, -0.01917933f, 0.04224741f, 0.03380140f, 
    -0.01091545f, -0.05467813f, 0.03544018f, 0.03263554f, 0.02642985f, -0.05635544f, 0.01901981f, 0.01502204f, 
    0.00581797f, -0.01248363f, -0.02109713f, -0.03706031f, 0.03633787f, -0.01283193f, -0.01840553f, -0.05454183f, 
    0.01746346f, -0.02966396f, -0.01213015f, 0.04517724f, -0.05177218f, -0.03601857f, 0.04107493f, -0.02873033f, 
    0.03047938f, -0.00295464f, -0.00041911f, -0.00803536f, 0.03575097f, 0.00910812f, 0.03367644f, 0.04066724f, 
    -0.01217125f, -0.00028258f, 0.03227761f, -0.03916593f, -0.05598889f, -0.01440683f, 0.00060110f, 0.00809159f, 
    0.04384039f, -0.01338238f, -0.00871536f, -0.04922602f, -0.00886751f, 0.01909355f, -0.03055267f, -0.03759249f, 
    0.04516040f, -0.00281497f, -0.00901344f, -0.05531105f, 0.04325933f, 0.03678591f, -0.05050888f, 0.02985495f, 
    -0.04303796f, -0.03864373f, 0.01433049f, -0.03308545f, -0.04501992f, -0.00737503f, 0.03371249f, -0.00143968f, 
    -0.04960123f, -0.01518906f, 0.03600864f, -0.05365846f, 0.02125535f, -0.04308325f, 0.02122797f, 0.01797615f, 
    -0.02697484f, -0.02952414f, 0.01881996f, 0.04089730f, -0.04249050f, -0.01131138f, -0.01598945f, -0.04861120f, 
    0.00769973f, 0.02681109f, -0.03046822f, -0.01304753f, -0.04438955f, -0.00375567f, -0.03672591f, 0.02547117f, 
    -0.02624298f, -0.01438984f, -0.05580738f, 0.00286815f, 0.02786980f, 0.01220269f, -0.04094555f, 0.00871164f, 
    -0.04242601f, 0.04434219f, 0.03248725f, -0.05550463f, -0.04602220f, 0.03666734f, 0.00061166f, -0.02328299f, 
    0.03947758f, -0.00994776f, -0.00386827f, -0.04695867f, 0.03680472f, -0.01486351f, 0.00855288f, -0.03570464f, 
    -0.05265791f, 0.00882290f, -0.00412510f, -0.00798756f, -0.00595688f, 0.03043088f, 0.00816442f, 0.01321104f, 
    -0.04901017f, 0.02591874f, 0.01490674f, -0.03606644f, 0.03494574f, -0.03500222f, 0.00401574f, -0.00273840f, 
    -0.00212024f, 0.03611140f, -0.05095976f, -0.03973884f, -0.01210066f, 0.04099341f, 0.02354059f, -0.00447240f, 
    0.01912287f, -0.03781348f, 0.00387967f, 0.02994511f, -0.01297124f, -0.00167278f, 0.03386475f, -0.05630058f, 
    -0.05415822f, 0.04159109f, -0.03447272f, 0.03521002f, -0.02237127f, 0.04698725f, -0.01195487f, 0.01127697f, 
    0.02390075f, 0.04408622f, 0.00170537f, -0.04255064f, -0.03869106f, -0.04288321f, 0.03924968f, -0.01695490f, 
    -0.02449226f, -0.02867609f, -0.04287713f, 0.03233260f, 0.00219538f, -0.03142443f, -0.03634583f, -0.02964810f, 
    -0.03548366f, -0.04462985f, -0.04778568f, -0.03414470f, -0.05023998f, -0.00338510f, 0.03585468f, -0.02169342f, 
    -0.00230159f, 0.01984945f, 0.04116927f, 0.04162963f, -0.03517183f, 0.03626225f, -0.01905036f, -0.00355141f, 
    0.02687699f, -0.04513200f, 0.02739638f, 0.04328565f, -0.00854253f, -0.03685255f, 0.01249226f, -0.02280330f, 
    -0.01068264f, 0.03130665f, 0.00592503f, -0.04106355f, 0.02315523f, 0.00661159f, -0.00388869f, -0.03960573f, 
    -0.03251554f, 0.03151024f, -0.00504335f, -0.05427258f, 0.02468053f, -0.02396278f, 0.00473393f, -0.05135993f, 
    0.00716715f, -0.03369359f, -0.03130079f, -0.03748426f, -0.03314507f, 0.00687187f, 0.01054159f, -0.00401822f, 
    -0.05529129f, -0.04519868f, -0.03821882f, -0.00874876f, -0.01621076f, -0.01895132f, -0.03817977f, -0.03141017f, 
    -0.05782396f, -0.01615290f, -0.05660148f, -0.00604554f, -0.02691634f, -0.04686812f, -0.03606762f, -0.03582308f, 
    -0.00891442f, 0.01963265f, -0.03379732f, -0.04435628f, 0.01273258f, 0.03831333f, 0.02084200f, 0.04144702f, 
    -0.02244365f, -0.01642731f, -0.02271532f, -0.05594410f, -0.01993457f, -0.00191605f, 0.00759798f, 0.01334723f, 
    -0.03930862f, 0.03681005f, -0.01595640f, 0.02889436f, 0.01523764f, 0.01450102f, -0.03242879f, -0.03070975f, 
    0.02914881f, 0.02321071f, -0.05284066f, -0.04660038f, -0.00658654f, -0.06079565f, -0.01633271f, -0.05594902f, 
    -0.05378515f, -0.00881686f, -0.03949196f, 0.00129264f, -0.02015989f, -0.00066262f, -0.04788400f, -0.05471633f, 
    -0.01296675f, -0.01767930f, -0.04653763f, 0.00156604f, 0.01432436f, 0.02704436f, 0.01976377f, -0.03090883f, 
    -0.00165380f, -0.02203687f, 0.03968294f, -0.03421018f, -0.05903253f, -0.02677709f, -0.00221616f, -0.03461411f, 
    -0.03111413f, -0.00581431f, 0.01712889f, -0.00074845f, -0.05453813f, 0.03564415f, 0.03098541f, 0.00466490f, 
    0.01918386f, 0.04186117f, -0.04166076f, -0.00766293f, 0.03607300f, 0.03891546f, 0.00420306f, -0.05248798f, 
    -0.04121139f, -0.03430216f, -0.05363375f, -0.04134266f, -0.02215145f, 0.03210982f, -0.00886206f, 0.03863174f, 
    -0.05109376f, -0.01457826f, -0.05135962f, 0.03517140f, -0.02378641f, 0.01450102f, -0.03378015f, -0.01933661f, 
    -0.02044361f, 0.01066181f, 0.02542730f, 0.02165199f, -0.02110145f, -0.04458692f, -0.05267079f, 0.02904737f, 
    0.01942036f, -0.04963574f, 0.03275546f, -0.00671668f, 0.03705161f, -0.01823075f, -0.03725841f, -0.00244713f, 
    -0.03752648f, -0.04045426f, -0.01307943f, -0.02404037f, -0.04328419f, 0.02340391f, 0.02543814f, 0.03408894f, 
    0.02579315f, 0.00142574f, -0.00287818f, 0.00570753f, 0.02472197f, -0.04085584f, 0.03023771f, 0.01441927f, 
    0.00138518f, -0.03526423f, -0.04586935f, 0.03920325f, 0.02349362f, -0.00511021f, -0.03120527f, -0.01924063f, 
    0.01908400f, 0.03153025f, -0.02831925f, -0.05234540f, 0.01523121f, 0.03538056f, 0.03136389f, 0.01411988f, 
    0.03790305f, -0.05212624f, -0.05772257f, 0.01343254f, -0.00624741f, 0.02915088f, -0.05386718f, 0.00771808f, 
    0.01369384f, -0.06025556f, -0.03531138f, -0.02352291f, 0.04179458f, -0.05431137f, -0.01120760f, -0.00295323f, 
    -0.01244246f, -0.02311033f, 0.01369273f, -0.01066035f, -0.05612242f, -0.00859332f, -0.03799149f, 0.01813383f, 
    -0.05891224f, -0.04410603f, 0.01593235f, 0.02554787f, 0.02144721f, 0.02756554f, 0.03145711f, 0.00852896f, 
    -0.02248251f, 0.00769387f, 0.01802012f, -0.05716848f, -0.04423967f, 0.00156313f, 0.02701555f, -0.02262513f, 
    0.03858269f, -0.02977628f, -0.01942393f, -0.01962565f, -0.03577700f, 0.02990052f, -0.02341534f, 0.01344310f, 
    -0.01376577f, -0.02697397f, -0.00077489f, -0.03681363f, 0.02519455f, -0.03027740f, 0.04240195f, -0.00815175f, 
    0.02148343f, 0.01407966f, -0.01130008f, -0.04174525f, 0.03485957f, -0.00790571f, -0.05870334f, 0.04135314f, 
    0.02963400f, -0.00120515f, -0.02208986f, -0.04786552f, 0.04111594f, -0.02889852f, 0.01490609f, -0.05282199f, 
    -0.04753391f, -0.00692905f, -0.01946673f, 0.04007718f, -0.05210141f, -0.03319497f, 0.01511417f, 0.02972332f, 
    0.00419718f, 0.02315733f, -0.05951195f, 0.00997034f, 0.00604765f, -0.04149083f, 0.01567873f, 0.04354828f, 
    -0.00094853f, 0.00695858f, -0.00299634f, 0.01801287f, -0.04644317f, 0.02877416f, 0.00377404f, 0.03611204f, 
    0.03829883f, -0.01266993f, -0.04897002f, 0.01568633f, -0.00522522f, -0.02257143f, -0.02149769f, 0.00308317f, 
    0.01363109f, 0.01856090f, 0.02397862f, -0.03711778f, 0.02887014f, -0.00841011f, 0.02210528f, 0.03877924f, 
    0.02078270f, -0.04240146f, 0.00133600f, -0.00402831f, 0.01207815f, 0.02582822f, 0.02694329f, -0.01651147f, 
    -0.00649595f, 0.03785094f, -0.02572117f, -0.00476439f, 0.03079758f, -0.04534693f, -0.04665170f, -0.02168561f, 
    -0.02620295f, -0.01488675f, 0.02358677f, -0.05040859f, -0.05898093f, -0.02778277f, -0.03195419f, -0.03951808f, 
    -0.02878300f, -0.01538611f, -0.00520400f, 0.02268128f, 0.01203098f, -0.00881747f, -0.03442789f, 0.03880155f, 
    -0.00265648f, -0.01021681f, -0.01819364f, 0.00371181f, 0.01838897f, -0.06084160f, 0.00756131f, 0.03482929f, 
    -0.05374219f, 0.03331287f, -0.05298419f, -0.01499065f, 0.03488480f, -0.04980731f, 0.00673483f, 0.00862702f, 
    0.03727884f, 0.00951167f, -0.01377196f, 0.01242612f, -0.03008954f, 0.01461166f, 0.00434299f, 0.03361448f, 
    -0.01079140f, -0.00750028f, 0.00779775f, -0.04289993f, -0.04325862f, -0.05866864f, 0.02763189f, -0.02755827f, 
    -0.04086192f, -0.01950424f, -0.00914965f, 0.01407706f, -0.03428625f, -0.00064755f, 0.03357726f, -0.02329699f, 
    -0.01324456f, -0.01353482f, 0.04182544f, 0.02546608f, 0.00502786f, -0.00383025f, 0.02838902f, -0.05315204f, 
    0.00990579f, -0.00078067f, -0.02853391f, -0.02949055f, 0.01162108f, -0.02422256f, 0.01820035f, 0.02570651f, 
    -0.02524770f, -0.03800108f, -0.05647601f, -0.04919693f, 0.03202548f, 0.00824049f, -0.03163674f, 0.03971629f, 
    0.02081622f, 0.02537055f, -0.02448704f, 0.01328235f, 0.00233126f, -0.02724340f, -0.05231792f, -0.00771176f, 
    -0.03093058f, -0.04517785f, -0.01249170f, 0.03839531f, 0.01459664f, 0.02868434f, -0.01880393f, -0.05130066f, 
    -0.00299906f, -0.00034248f, 0.03487574f, -0.01501272f, -0.00392119f, 0.03439276f, -0.01377095f, 0.03441612f, 
    0.03480257f, 0.02782808f, 0.00371227f, -0.01339102f, -0.00786762f, 0.00746295f, 0.03338524f, 0.03720035f, 
    -0.02059437f, -0.01434910f, -0.01991317f, -0.00038864f, -0.00656502f, -0.01753274f, -0.01703689f, 0.02645112f, 
    -0.01586580f, 0.03909608f, -0.05979881f, 0.00789127f, -0.02795759f, -0.01532981f, 0.02639937f, -0.05044827f, 
    -0.00918302f, -0.00002087f, -0.02202861f, -0.03481251f, -0.00170460f, 0.02570861f, 0.01111296f, -0.04919774f, 
    -0.04027523f, -0.01665169f, -0.02146382f, -0.03535235f, 0.01994852f, 0.01524862f, 0.00310302f, 0.02210137f, 
    0.02859562f, 0.03479238f, 0.04240417f, -0.01059447f, 0.00349493f, -0.03478807f, -0.05031777f, 0.03548248f, 
    -0.00098733f, 0.01166546f, 0.01670220f, -0.00621517f, -0.03926871f, 0.04109782f, -0.02358675f, -0.02559673f, 
    -0.00773242f, 0.01342994f, 0.04396594f, 0.01254918f, -0.05563455f, 0.00924220f, -0.04754999f, -0.03091059f, 
    -0.00353930f, 0.01440352f, -0.04382641f, -0.00566108f, -0.03343409f, -0.02627550f, 0.01930895f, 0.01041647f, 
    -0.03540014f, -0.02897057f, 0.01394582f, 0.02893621f, 0.00514324f, -0.02647452f, -0.01364534f, -0.00489021f, 
    -0.01812817f, -0.03998970f, 0.03803059f, 0.05036368f, -0.04465531f, 0.03483169f, 0.00602256f, 0.01630861f, 
    -0.03038513f, -0.01213022f, -0.03725086f, 0.01230147f, 0.02230684f, 0.00679233f, 0.02034232f, -0.03722022f, 
    0.00216496f, 0.01235261f, -0.04127328f, 0.04385413f, -0.03135451f, -0.02380557f, 0.01600473f, 0.00463837f, 
    0.00027005f, -0.00734492f, -0.02473140f, 0.04321715f, -0.01011114f, 0.00793748f, -0.04050708f, 0.00685933f, 
    0.02536402f, 0.02070063f, 0.03519252f, 0.01157863f, -0.04291857f, 0.04934098f, -0.00993410f, 0.02478797f, 
    -0.05968804f, -0.03276907f, -0.02562274f, -0.02251981f, 0.00259110f, 0.02749386f, 0.04115613f, -0.03394505f, 
    -0.01137439f, -0.02830068f, 0.02002458f, 0.03560045f, 0.01258802f, 0.03462208f, -0.01788192f, 0.03814896f, 
    -0.04542886f, -0.03126870f, 0.05126599f, -0.00914137f, -0.00864717f, -0.04252177f, -0.01508863f, -0.00110023f, 
    -0.02599922f, 0.02725424f, -0.03448945f, -0.02538991f, -0.01029076f, -0.03727886f, 0.01757624f, 0.03368270f, 
    0.02693704f, -0.02987724f, -0.02723611f, 0.03176602f, 0.00770658f, -0.03252485f, -0.04407027f, -0.04336971f, 
    -0.01472437f, 0.05663814f, -0.05933204f, -0.03835846f, 0.01863194f, -0.00032352f, -0.02555523f, 0.03032234f, 
    -0.00050254f, 0.04404264f, -0.03118624f, 0.02272026f, -0.00385427f, 0.01148509f, -0.03553011f, 0.01215057f, 
    -0.02105528f, -0.00659616f, 0.03508243f, -0.03765310f, 0.00019587f, -0.02825076f, -0.03706777f, -0.02487038f, 
    0.01588485f, -0.04980254f, -0.02500938f, -0.01148644f, -0.01008548f, 0.04437792f, -0.03288119f, 0.00378434f, 
    -0.02567103f, -0.04012595f, 0.03507365f, 0.03502364f, -0.03089773f, 0.03897210f, 0.00875887f, -0.01413109f, 
    0.00206528f, -0.00747493f, 0.02428238f, -0.04819770f, 0.00561315f, -0.03739628f, -0.03866595f, -0.00549817f, 
    0.01327827f, -0.00015660f, 0.05011621f, -0.04559198f, -0.05456980f, 0.01892802f, 0.02833167f, -0.02146786f, 
    -0.00318634f, -0.04756434f, 0.00187317f, 0.01337833f, 0.00430004f, -0.02333695f, -0.01499418f, 0.03344503f, 
    0.03458647f, 0.01361037f, -0.01205557f, -0.04178451f, -0.02854683f, -0.03595909f, 0.02817542f, 0.00871104f, 
    -0.01977891f, 0.02306190f, 0.03202271f, 0.00378543f, -0.05398057f, 0.04043734f, 0.03874826f, 0.00378134f, 
    0.00280452f, 0.03046442f, 0.00411763f, -0.03515847f, -0.04809310f, 0.01771891f, -0.03153013f, -0.00543095f, 
    0.03495979f, 0.01628027f, 0.00966432f, -0.04333786f, 0.02279297f, -0.02386208f, -0.05770854f, -0.01585711f, 
    0.01727539f, 0.03514611f, -0.04268386f, -0.04105377f, 0.00241373f, 0.00054962f, 0.04870095f, -0.00693532f, 
    0.04984334f, 0.03038376f, -0.02859744f, -0.00465444f, -0.02775240f, -0.03482273f, -0.02469105f, 0.02286955f, 
    -0.03222290f, -0.03458465f, 0.03418858f, 0.01264730f, 0.01382706f, -0.03831257f, 0.01344354f, 0.00169329f, 
    0.02550112f, 0.01109277f, -0.05037795f, 0.04215556f, 0.02457392f, 0.04830501f, 0.00164983f, -0.02444280f, 
    -0.03096039f, -0.06006629f, 0.03041386f, -0.05349543f, 0.00004766f, -0.04399924f, 0.02819071f, -0.00357619f, 
    -0.05946254f, -0.03747873f, -0.00328562f, -0.02953718f, -0.04677784f, 0.04876323f, -0.05098555f, -0.02945899f, 
    -0.04053486f, 0.02069252f, 0.00099832f, -0.02295615f, 0.01275618f, 0.03526944f, 0.02796672f, 0.00578607f, 
    -0.00826215f, 0.01025760f, -0.05676046f, 0.03390392f, -0.03907950f, -0.03434325f, 0.03574786f, 0.01412203f, 
    -0.04722004f, 0.03481437f, -0.01934662f, 0.01902178f, -0.02321949f, -0.00649971f, 0.00999001f, -0.05252438f, 
    -0.03774950f, 0.02585593f, 0.01558024f, -0.03355385f, 0.00163281f, -0.04145108f, -0.02178770f, 0.01471588f, 
    -0.02574199f, -0.02799327f, -0.04524671f, -0.00861609f, -0.01955706f, 0.02366507f, -0.00470806f, 0.01689970f, 
    -0.00428957f, -0.03394044f, -0.02309385f, -0.02239686f, 0.01010812f, -0.01867878f, 0.03482613f, 0.03344322f, 
    0.00007872f, -0.03078932f, 0.02506700f, 0.03398819f, 0.01876726f, -0.04881619f, -0.04942496f, 0.04394390f, 
    -0.05150177f, 0.04535745f, -0.02918234f, 0.03344148f, 0.00088905f, -0.01826107f, 0.03100988f, -0.01279684f, 
    0.03110417f, -0.05092106f, 0.03087640f, 0.00803382f, -0.00525421f, -0.06407244f, -0.01528966f, -0.05746441f, 
    -0.03083371f, -0.04912405f, 0.04533574f, 0.04144088f, -0.02675962f, -0.02361909f, -0.05306062f, -0.05066870f, 
    -0.04677827f, -0.00689696f, 0.01241764f, -0.00793452f, -0.04813471f, 0.04065087f, -0.04944068f, -0.05373650f, 
    -0.01511235f, -0.01565551f, 0.04253154f, -0.03306770f, 0.04116149f, -0.01739512f, 0.03039257f, 0.02036986f, 
    -0.03232672f, -0.02972294f, -0.02357126f, -0.03130584f, -0.01153335f, -0.03531184f, 0.02559886f, 0.02318780f, 
    0.01683556f, 0.02728536f, 0.04129392f, -0.03350271f, -0.04389149f, -0.02128159f, 0.02275826f, -0.00974047f, 
    -0.03082433f, 0.03625911f, -0.00810004f, 0.01247000f, -0.04871529f, -0.03928282f, 0.03362428f, 0.01921982f, 
    -0.01847889f, -0.01486641f, -0.03503877f, -0.04837196f, -0.02072260f, -0.03442306f, -0.00321330f, 0.03132736f, 
    0.01108493f, -0.03619292f, 0.03819069f, 0.00272729f, 0.03162416f, -0.04810124f, -0.03169250f, 0.00435603f, 
    0.00733808f, -0.03784556f, -0.04763594f, -0.00059592f, 0.01930610f, -0.00781581f, -0.00207877f, -0.01244842f, 
    -0.01438871f, 0.01749001f, -0.02448762f, 0.04092695f, -0.03144233f, -0.01032389f, -0.02784306f, -0.02235488f, 
    -0.03747806f, 0.00345235f, 0.00286666f, 0.00569542f, -0.03814325f, -0.02591775f, -0.02838439f, 0.02036802f, 
    -0.01447394f, 0.03097326f, -0.04840928f, -0.03311922f, -0.00812526f, 0.03679371f, 0.00882761f, -0.03123266f, 
    0.00780658f, -0.05175499f, -0.03251943f, -0.02683446f, 0.02679295f, -0.00070163f, 0.04390612f, 0.02106438f, 
    0.00296007f, -0.04980154f, -0.03325241f, -0.01940782f, 0.00799805f, -0.02728957f, -0.02281530f, -0.02000673f, 
    0.03560185f, -0.00608836f, 0.01330650f, -0.03220065f, -0.03289715f, -0.00235699f, -0.05855221f, 0.01676563f, 
    -0.04687371f, 0.02076223f, -0.01685655f, 0.03341238f, -0.03286274f, -0.05139566f, -0.00799784f, 0.00064178f, 
    -0.02485046f, 0.01981321f, -0.02248143f, 0.03879550f, -0.05651911f, -0.00597874f, -0.04451459f, 0.03037086f, 
    -0.02047203f, -0.04321527f, 0.00667274f, -0.03143308f, 0.02846324f, -0.03562460f, -0.03925185f, -0.01074857f, 
    -0.00671223f, 0.00663105f, -0.04132626f, -0.03207273f, -0.01143943f, 0.03670508f, -0.02321717f, 0.00304685f, 
    -0.00219028f, -0.05128953f, 0.04343201f, -0.04678848f, 0.02378849f, 0.00752552f, -0.05041951f, -0.00933513f, 
    -0.02575787f, 0.00517199f, -0.04094750f, -0.02056791f, -0.04346660f, 0.02224997f, -0.05631784f, 0.03156430f, 
    0.01180593f, 0.03756430f, -0.00169250f, 0.04019996f, -0.04636588f, -0.00355446f, -0.04736646f, 0.01319417f, 
    -0.01903271f, -0.01555687f, -0.05236088f, -0.03778392f, 0.03524264f, -0.05435032f, -0.02080961f, -0.01453566f, 
    0.02874008f, 0.03229113f, 0.01706466f, 0.00562045f, 0.01577898f, 0.02380002f, -0.03212046f, -0.04274568f, 
    -0.01559848f, -0.03397768f, -0.02612889f, 0.00205539f, -0.02046126f, -0.01546515f, -0.02173026f, 0.02013819f, 
    0.02266760f, 0.01185444f, 0.02941304f, -0.04336437f, -0.01909263f, -0.05757377f, 0.00495729f, -0.01472248f, 
    0.01558155f, -0.01231521f, 0.03278996f, -0.02854992f, 0.03679348f, 0.04226842f, -0.00987635f, 0.02911737f, 
    -0.01959067f, -0.00917548f, 0.04344112f, 0.03438978f, -0.03712315f, -0.00188895f, 0.00959084f, -0.02841941f, 
    0.03667369f, 0.03076177f, 0.00347228f, 0.03478286f, 0.02737779f, -0.05079023f, -0.01464582f, 0.00869857f, 
    0.03649793f, 0.00567177f, -0.01508422f, -0.05744881f, 0.00088619f, -0.04365710f, 0.02568452f, -0.02164396f, 
    -0.00732143f, -0.01884726f, -0.01159193f, -0.00333385f, -0.02055609f, -0.02070198f, -0.03542271f, 0.00266119f, 
    0.03863250f, 0.03060174f, 0.00296211f, 0.03241352f, -0.04852857f, 0.03408419f, -0.00308058f, 0.03005812f, 
    -0.05483247f, -0.05547306f, 0.02882545f, 0.03578694f, 0.00135057f, 0.00741536f, 0.00096216f, 0.00079716f, 
    0.03610056f, 0.01966696f, -0.05149310f, -0.01968870f, -0.03005933f, -0.01110535f, 0.01898403f, -0.02197370f, 
    -0.00990530f, -0.05906619f, 0.04245125f, -0.01528380f, -0.01248939f, -0.02512110f, -0.00734314f, -0.02647931f, 
    0.04108641f, -0.04905910f, -0.03958621f, 0.00887044f, -0.04377968f, 0.00303590f, 0.03737257f, -0.04881175f, 
    -0.04590400f, -0.02352389f, 0.02688757f, -0.03417424f, 0.02039817f, 0.01781236f, -0.02278179f, 0.03120837f, 
    -0.01773466f, 0.02055994f, -0.05183769f, -0.01177862f, 0.00663962f, -0.01833662f, 0.03217600f, -0.05104826f, 
    -0.05582479f, -0.04493142f, 0.00414468f, -0.03093428f, -0.02487965f, -0.05799554f, 0.03083867f, -0.05529236f, 
    -0.00758438f, 0.05200226f, -0.05474384f, -0.03775320f, -0.02678188f, -0.00050803f, 0.01099746f, -0.03687548f, 
    0.00393006f, 0.01350073f, 0.03713661f, -0.03762425f, 0.02419027f, -0.05531045f, 0.02873091f, 0.00599584f, 
    -0.03895868f, 0.01940117f, 0.01680752f, -0.04603386f, 0.01564642f, -0.02044156f, -0.02143080f, -0.02988412f, 
    -0.01178406f, -0.02875588f, -0.01344215f, -0.04392334f, 0.03398373f, 0.00501533f, 0.02386773f, -0.01175150f, 
    0.01593143f, -0.01179998f, 0.03604411f, 0.02318092f, 0.02777462f, -0.04950658f, 0.01085072f, 0.02350001f, 
    0.03090641f, -0.00603579f, -0.03897330f, 0.01486249f, -0.04891781f, -0.00382300f, 0.01739086f, -0.05189187f, 
    -0.02203358f, -0.03450059f, -0.05308130f, 0.00719577f, -0.00464619f, 0.03101405f, 0.02884676f, 0.02333072f, 
    -0.02236962f, -0.04454569f, -0.04082910f, 0.03435931f, -0.00823175f, 0.02626112f, -0.00891945f, -0.03349912f, 
    -0.00486198f, -0.02353092f, 0.03249231f, 0.01608637f, -0.02354939f, -0.02475524f, 0.01829778f, 0.04274798f, 
    0.03557556f, 0.02045713f, -0.02206593f, 0.02149932f, 0.02505382f, -0.00807478f, -0.00763426f, -0.02591150f, 
    -0.04174748f, 0.02733451f, 0.00745460f, 0.00616119f, 0.00931826f, 0.00054889f, -0.05452562f, 0.02519162f, 
    -0.04771431f, -0.03085954f, -0.01958264f, 0.01799082f, 0.00116995f, 0.00819291f, 0.02973924f, 0.03428282f, 
    -0.03980838f, 0.03439558f, 0.02507116f, -0.05076073f, -0.03940167f, 0.02680735f, 0.03167006f, -0.01825605f, 
    -0.03097270f, -0.03682809f, -0.02645598f, -0.00016290f, 0.03354257f, -0.00657750f, 0.01986750f, 0.02793778f, 
    0.01657301f, 0.03483960f, 0.00075195f, 0.01755602f, 0.03141137f, 0.01255718f, -0.04757353f, -0.05573821f, 
    0.02444237f, -0.03131047f, -0.04456796f, -0.03958762f, 0.03441904f, -0.03001952f, -0.00600591f, 0.02033617f, 
    -0.05390666f, -0.04938774f, -0.01574108f, -0.01973056f, -0.02809379f, -0.04351319f, -0.00576942f, -0.00566719f, 
    -0.00621103f, 0.03481441f, -0.05112489f, -0.04818030f, 0.00175135f, -0.05356980f, 0.00580188f, -0.01797968f, 
    0.00824043f, 0.04318847f, -0.05110757f, 0.01110466f, -0.04200330f, -0.02903359f, 0.00104952f, -0.02709823f, 
    -0.04355025f, 0.00183019f, -0.04736138f, 0.00714787f, -0.03029839f, -0.01929375f, 0.00396955f, -0.05089303f, 
    -0.05386331f, 0.04053059f, -0.05589696f, -0.04235756f, -0.05186975f, -0.00137899f, 0.01293843f, -0.01128667f, 
    -0.00897800f, -0.04635270f, -0.04059464f, 0.00553107f, 0.02680602f, 0.02867148f, 0.02760724f, -0.04118593f, 
    0.03321934f, -0.02827191f, 0.01122800f, 0.00297857f, -0.02119951f, 0.03799788f, 0.01384089f, -0.03744568f, 
    -0.02173545f, 0.00905233f, -0.03091847f, -0.02960571f, -0.02928641f, 0.03658290f, 0.01855647f, -0.01111320f, 
    0.01894161f, 0.03829971f, -0.03670329f, 0.04354054f, -0.04704029f, -0.02784579f, -0.00853892f, -0.02532846f, 
    -0.00987586f, -0.02851124f, -0.03477551f, -0.01706182f, -0.02893334f, 0.01430486f, 0.00386681f, 0.01633590f, 
    0.02309342f, -0.05636225f, -0.01282427f, -0.00898898f, -0.01471833f, 0.01014999f, 0.03810620f, -0.04171620f, 
    -0.05440893f, 0.01046724f, -0.00111768f, 0.04220206f, -0.02411964f, 0.01636595f, -0.05662088f, -0.03324716f, 
    0.01679947f, -0.03050563f, 0.00182165f, 0.01547422f, -0.03849508f, -0.03554289f, -0.04953738f, -0.00124742f, 
    -0.00843272f, -0.00708112f, 0.03423589f, -0.01803653f, -0.00295098f, -0.02084563f, -0.02374460f, 0.01557232f, 
    -0.04759486f, -0.01052322f, -0.04192711f, 0.02635165f, 0.03717627f, -0.04220517f, -0.00589720f, -0.01460687f, 
    -0.02519619f, 0.01368010f, -0.03979464f, -0.04877928f, 0.03153963f, -0.00897374f, -0.00507507f, -0.01766882f, 
    0.01670384f, 0.00020142f, -0.01253576f, -0.04317726f, -0.02449362f, -0.00745606f, -0.02685659f, -0.05317318f, 
    -0.01368676f, 0.01044512f, -0.01953159f, -0.03904873f, 0.01981622f, 0.01524279f, -0.01726674f, 0.04355725f, 
    -0.01771957f, -0.04611364f, -0.01532827f, -0.01341897f, 0.01641592f, -0.02485075f, -0.05054407f, 0.02296808f, 
    -0.00204786f, 0.00552681f, 0.02751991f, -0.02146734f, -0.00339136f, -0.05288139f, 0.03872670f, 0.00044833f, 
    0.00808188f, -0.02939040f, -0.02428218f, -0.05419092f, -0.02082405f, -0.05566682f, -0.02950380f, -0.01641376f, 
    0.00678364f, 0.03794392f, -0.00237126f, 0.00564379f, 0.02634666f, -0.05561952f, -0.05083385f, -0.01764310f, 
    0.00255464f, 0.00285498f, -0.00765278f, 0.01733769f, 0.04214907f, -0.02454008f, 0.01180767f, 0.04460805f, 
    -0.04623543f, 0.03758226f, -0.04153433f, -0.03148037f, 0.02913853f, -0.00160300f, -0.00921894f, -0.05090011f, 
    0.02195202f, 0.00996490f, -0.03910176f, -0.00099556f, -0.01174246f, -0.03632808f, 0.02676130f, -0.05275400f, 
    0.02453995f, 0.02644785f, -0.02833687f, -0.02265330f, 0.03636221f, -0.05467637f, 0.02941337f, -0.02453545f, 
    -0.03112433f, 0.01967515f, 0.01984001f, 0.03885623f, -0.00328669f, 0.04023712f, 0.02486512f, -0.00803199f, 
    0.02926184f, -0.03050592f, 0.00559439f, -0.04832362f, 0.02169285f, 0.02734750f, -0.03923919f, -0.02928154f, 
    -0.00072328f, -0.03950062f, 0.03312297f, 0.03510732f, 0.00021881f, -0.04397137f, -0.03474815f, 0.03142206f, 
    -0.01062181f, -0.03845228f, -0.01014130f, -0.02142740f, 0.03916702f, -0.03668895f, -0.00608168f, 0.03860753f, 
    0.02867262f, -0.01899952f, -0.03798259f, -0.05423561f, -0.03424421f, 0.03155245f, -0.03799809f, -0.03710169f, 
    -0.01206245f, 0.01036716f, 0.00409611f, -0.00244453f, 0.04307749f, -0.00056076f, 0.00516915f, -0.01645036f, 
    0.04025140f, 0.04340059f, -0.02400702f, -0.01711145f, -0.01576225f, 0.03163242f, 0.02528840f, -0.03158071f, 
    -0.02908427f, -0.01604694f, -0.01531804f, -0.01939521f, 0.03993915f, -0.00663138f, 0.03699941f, 0.00101499f, 
    0.02890318f, 0.00549073f, -0.03795954f, -0.01763840f, 0.02519062f, -0.00648091f, -0.01556720f, 0.00751216f, 
    0.01911110f, 0.00491393f, -0.03278227f, 0.04241585f, -0.04709854f, -0.00688429f, 0.00197263f, 0.03600255f, 
    -0.01830285f, -0.00265390f, 0.02951280f, -0.00493959f, 0.02625321f, -0.03777936f, 0.00826776f, -0.00483884f, 
    -0.02395259f, 0.04414803f, -0.01888826f, -0.00883790f, 0.02095774f, 0.04458792f, -0.01195050f, -0.03085917f, 
    0.02860789f, -0.01392245f, 0.04128458f, -0.05240318f, -0.01775053f, 0.02564862f, 0.01783606f, 0.00521928f, 
    0.02602013f, 0.02730461f, 0.00589442f, -0.04944457f, 0.00312345f, -0.05451808f, -0.04614441f, 0.03121805f, 
    0.01444963f, -0.05696965f, -0.04471651f, 0.02040886f, 0.00627180f, 0.02586219f, -0.00871288f, -0.03125905f, 
    -0.03615496f, -0.03915054f, 0.04150826f, -0.00646596f, 0.00357685f, 0.00109319f, -0.04547709f, -0.04071182f, 
    -0.05192642f, 0.00595577f, -0.02504581f, -0.00045399f, -0.03482451f, -0.01546234f, 0.00457455f, 0.00525524f, 
    -0.03351297f, 0.00698505f, -0.03428321f, 0.00280335f, 0.04405470f, 0.01842951f, 0.02763467f, 0.03525966f, 
    0.04237971f, 0.03100984f, -0.04955471f, 0.01732844f, 0.00971976f, 0.01948319f, 0.02123624f, 0.03231102f, 
    -0.01172549f, -0.01826785f, -0.02148048f, -0.00481974f, 0.01404709f, -0.00986785f, 0.04219465f, -0.02490849f, 
    -0.02980595f, -0.02203043f, 0.02794663f, 0.00618614f, -0.04185306f, -0.00304971f, -0.00386450f, 0.01499054f, 
    -0.01139400f, -0.04101469f, -0.03658918f, -0.03152996f, 0.00951480f, -0.03055834f, 0.03260866f, 0.03248494f, 
    -0.04842401f, -0.05395778f, 0.00117511f, -0.00979054f, 0.03225380f, 0.02928718f, 0.02623393f, -0.03742646f, 
    0.02600296f, 0.00084217f, -0.00469977f, -0.02616575f, -0.01528105f, -0.01194272f, -0.01955771f, -0.05135058f, 
    -0.02593149f, 0.01900798f, -0.00582992f, -0.04107235f, 0.00485539f, -0.03091775f, 0.01252188f, 0.01150207f, 
    0.03485923f, -0.05308587f, 0.02958236f, 0.02391946f, -0.04446983f, 0.02592637f, -0.00158398f, 0.03143517f, 
    0.02347879f, 0.00351371f, 0.02690654f, -0.03801183f, -0.01333143f, -0.03608858f, 0.03191089f, 0.01532126f, 
    0.02694234f, 0.04121250f, -0.01756124f, -0.02086087f, -0.04277822f, 0.01425603f, -0.04273157f, -0.02279125f, 
    -0.02277802f, 0.04773169f, -0.01997677f, 0.05045241f, -0.00498041f, 0.01522823f, 0.04505083f, 0.04138549f, 
    0.04569013f, -0.04520269f, -0.00103406f, 0.01107824f, 0.01574180f, -0.03752868f, 0.04522146f, 0.03181425f, 
    -0.02819085f, -0.02238443f, -0.03292556f, 0.01073259f, -0.05190298f, 0.01748484f, 0.03940721f, -0.04428723f, 
    0.02770559f, -0.02154675f, -0.02666009f, -0.01289670f, -0.00713245f, -0.01905796f, 0.04574728f, -0.03850801f, 
    -0.00829864f, -0.04107290f, 0.03541064f, -0.04837002f, 0.02766973f, 0.01097331f, -0.04157865f, -0.04721290f, 
    0.00253299f, 0.02318816f, -0.03514342f, -0.00946999f, 0.05275498f, -0.00797668f, 0.01295217f, -0.02834164f, 
    0.03283955f, -0.02596471f, 0.02619175f, 0.00803357f, 0.04000899f, 0.00600959f, -0.01500672f, -0.02295658f, 
    -0.00414505f, -0.02336388f, -0.02707589f, 0.02621489f, 0.04461625f, -0.03788130f, 0.00140071f, -0.03039530f, 
    -0.00788683f, -0.02599989f, -0.02159516f, 0.05090896f, -0.00072527f, 0.01560235f, -0.04420867f, -0.03479487f, 
    -0.02730766f, 0.00465858f, -0.00545526f, -0.00253983f, -0.02705275f, -0.03052212f, -0.00504531f, -0.02517729f, 
    -0.05148509f, 0.01915340f, 0.04049785f, 0.05285721f, -0.00876205f, 0.04191326f, -0.03927425f, 0.01261909f, 
    -0.05210285f, -0.02004991f, -0.03910917f, 0.02555233f, -0.02858424f, -0.00685442f, -0.00953742f, -0.03381815f, 
    0.02119917f, 0.02521573f, -0.05019236f, -0.03341930f, -0.01216799f, -0.02203685f, -0.00222500f, -0.02818234f, 
    -0.04968911f, -0.02077026f, 0.02049648f, 0.01185694f, -0.02415022f, -0.04137698f, 0.00939212f, 0.00429771f, 
    -0.01955027f, -0.01874457f, -0.00162466f, -0.02551492f, -0.00647856f, 0.02040855f, 0.03217494f, -0.02160833f, 
    0.03121272f, -0.01259445f, 0.01863720f, -0.05106407f, 0.01248802f, 0.01036390f, -0.00678541f, 0.01384866f, 
    -0.05421192f, 0.03911024f, -0.03736766f, -0.02200249f, -0.04604402f, -0.05262839f, 0.01097787f, -0.02869646f, 
    0.02837042f, 0.03170025f, 0.04417263f, -0.04813497f, -0.00087030f, 0.03347485f, -0.02343974f, -0.02342060f, 
    0.02569801f, -0.03568950f, 0.03216053f, -0.02721857f, -0.05803205f, -0.03706530f, 0.03035503f, 0.04772673f, 
    -0.04177958f, 0.00027476f, -0.03697989f, 0.03446373f, -0.03091431f, 0.02375258f, 0.00462039f, -0.03611549f, 
    -0.02662224f, 0.00702263f, -0.04050577f, -0.00261535f, 0.02779341f, 0.04979212f, 0.00143662f, 0.00056421f, 
    -0.03997299f, 0.00554841f, 0.04958064f, -0.00181835f, 0.04347532f, 0.00110585f, -0.03959823f, 0.02537071f, 
    -0.01106885f, -0.01930181f, 0.00734674f, -0.00802708f, 0.00955057f, 0.03663058f, 0.02804329f, -0.04314043f, 
    -0.03487515f, -0.04937958f, -0.01164717f, -0.01972144f, 0.04245552f, 0.04007320f, 0.02757850f, -0.02310943f, 
    0.01051505f, -0.01999691f, 0.01156275f, -0.05247284f, -0.03331700f, -0.03859526f, 0.02785395f, -0.01580640f, 
    -0.03632359f, 0.04128824f, -0.03931206f, -0.04646591f, 0.00627944f, -0.03223762f, -0.01862564f, -0.02022567f, 
    -0.02376821f, 0.02060902f, 0.03643706f, -0.00542363f, 0.04851536f, 0.00731240f, -0.00099386f, 0.03602822f, 
    -0.00598862f, -0.04198967f, -0.04717240f, 0.00152182f, -0.01678244f, -0.01116254f, 0.02327328f, 0.03269985f, 
    -0.03347748f, -0.05169884f, 0.03553210f, -0.05809250f, 0.03139566f, 0.04023549f, -0.05448999f, -0.01570250f, 
    0.04612055f, -0.03369268f, -0.02801217f, 0.01891356f, -0.04019290f, -0.00976418f, -0.03404830f, -0.02733186f, 
    -0.03835187f, -0.00887074f, -0.02426854f, 0.04548797f, 0.03678812f, 0.03693407f, -0.02495819f, -0.00571909f, 
    0.01109084f, -0.03826681f, -0.01265740f, -0.01914042f, -0.04383284f, -0.01701306f, 0.04035218f, -0.00917817f, 
    0.02765123f, 0.00116055f, -0.03392404f, -0.04183181f, -0.00927317f, 0.02621924f, -0.03574610f, 0.01066855f, 
    0.00070405f, -0.05215423f, 0.03163039f, -0.04155377f, 0.03882998f, -0.04912357f, -0.02968071f, -0.02915091f, 
    0.00866819f, 0.01615955f, 0.04213132f, -0.00181607f, 0.04526907f, -0.00771489f, -0.04039505f, -0.05082094f, 
    -0.03837670f, 0.00353934f, 0.01011574f, -0.01550439f, -0.02828926f, -0.01941776f, -0.03460521f, 0.00361777f, 
    0.14224540f, 0.11537865f, -0.22653326f, -0.50596565f, 0.18743885f, 0.10187417f, 0.08108906f, -0.00202234f, 
    0.08013197f, 0.20730835f, 0.05535863f, -0.00085175f, 0.19648613f, 0.19070804f, -0.20722398f, -0.10934740f, 
    0.07477482f, 0.08680838f, 0.06245571f, 0.03389848f, 0.05344936f, -0.00352416f, -0.01836145f, 0.03827020f, 
    -0.22680719f, -0.02469476f, 0.06959178f, 0.05878450f, 0.10280117f, 0.03141622f, 0.09082323f, 0.10795231f, 
    0.06647218f, 0.02410478f, -0.11442503f, 0.13587932f, 0.13232745f, -0.01854563f, -0.16580190f, 0.25848359f, 
    0.04555247f, -0.01952986f, -0.03080373f, -0.02948326f, 0.02204821f, -0.06016746f, 0.01173766f, 0.03428318f, 
    0.00047422f, 0.18704450f, 0.27161264f, 0.08944241f, 0.11130261f, 0.01778882f, 0.07666036f, 0.04069686f, 
    -0.05551641f, -0.03510108f, 0.00469689f, 0.11853482f, 0.04537212f, 0.12894121f, -0.25988793f, 0.14582705f, 
    0.03644532f, 0.19261438f, -0.07548118f, 0.03574689f, 0.07727298f, -0.06062565f, 0.00507733f, -0.04622385f, 
    0.04073762f, -0.03918907f, 0.04195558f, 0.03953369f, 0.11517137f, 0.05514568f, -0.01321413f, -0.03456579f, 
    0.10768609f, 0.05969908f, 0.05308715f, 0.01718399f, -0.09770775f, -0.16163136f, 0.19277501f, -0.09820428f, 
    0.08913132f, 0.03629135f, -0.08482128f, 0.06082992f, -0.02162760f, 0.03615277f, 0.03097901f, -0.13137668f, 
    0.09788084f, 0.04508508f, -0.10262554f, 0.12336903f, 0.17884624f, 0.04081736f, 0.04214495f, -0.04380093f, 
    -0.01915988f, 0.13520351f, 0.23825935f, 0.15307494f, 0.53927964f, 0.11125934f, -0.02743665f, 0.09843111f, 
    -0.14813906f, 0.04569542f, -0.01934356f, -0.02584250f, 0.04910064f, 0.07725210f, -0.03884322f, -0.03730753f, 
    -0.08010785f, -0.02322195f, 0.00773279f, -0.05942272f, -0.00788182f, 0.08443424f, 0.02151253f, -0.02279095f, 
    0.02452403f, -0.00107462f, 0.07642314f, 0.15681800f, -0.18816707f, -0.11865234f, -0.02126901f, 0.02980807f, 
    -0.00882809f, -0.02280483f, -0.03369451f, 0.13684615f, 0.04324021f, -0.09061363f, 0.04252621f, -0.00010609f, 
    0.26978949f, -0.06575758f, -0.08251418f, -0.23488481f, 0.11820713f, 0.03625197f, 0.00459637f, -0.02550349f, 
    0.03827236f, 0.06692202f, 0.00880658f, -0.14199927f, -0.09890278f, 0.06875709f, 0.23940806f, -0.14719637f, 
    0.19245112f, -0.05582465f, 0.09935910f, 0.05077386f, -0.03339473f, -0.03805587f, 0.00435797f, 0.10781740f, 
    0.16964452f, 0.19364989f, -0.05163566f, 0.19556205f, -0.00230240f, 0.03532267f, 0.02046773f, 0.07230846f, 
    0.08774155f, 0.00604758f, -0.07640064f, 0.02487591f, -0.12597935f, -0.13035274f, 0.06373511f, -0.08396515f, 
    -0.05341352f, -0.13510279f, -0.03034656f, 0.04697004f, 0.16763406f, -0.00238214f, 0.01368674f, 0.00539614f, 
    -0.15547252f, -0.07206140f, 0.01154452f, 0.02589810f, -0.04250126f, 0.00229810f, 0.07019415f, 0.05318867f, 
    -0.06248605f, 0.04940076f, -0.01895573f, -0.06486288f, 0.09473485f, 0.06053288f, 0.11955501f, -0.29466987f, 
    0.06887559f, 0.09944114f, 0.06624962f, 0.02937550f, 0.03886786f, 0.00571040f, -0.01063138f, 0.05584519f, 
    0.02676232f, -0.00740840f, 0.02811962f, -0.05334217f, 0.06988682f, 0.01321011f, -0.06984788f, 0.26799446f, 
    -0.01116571f, 0.00602650f, 0.06277091f, 0.03419243f, 0.11306991f, 0.11981423f, 0.05822833f, 0.15173709f, 
    0.08425310f, -0.04600939f, 0.02876678f, -0.04409912f, -0.00593328f, 0.00415825f, -0.08173814f, 0.10525907f, 
    -0.22943829f, -0.06041945f, -0.20355117f, 0.10172210f, 0.16975479f, 0.06674389f, -0.11158828f, 0.03191293f, 
    0.03956093f, 0.03680633f, 0.05749303f, 0.14401162f, 0.01434683f, -0.02298110f, 0.10405221f, 0.01378056f, 
    -0.01001571f, -0.06775363f, -0.01750400f, 0.03223037f, -0.10258102f, -0.01142215f, -0.05530369f, -0.05039418f, 
    0.14089042f, 0.00227245f, 0.00476936f, 0.16398184f, 0.01916295f, 0.14757161f, 0.10961730f, -0.11261170f, 
    0.07148468f, 0.11932780f, 0.05094060f, 0.10002393f, -0.20393892f, -0.04427496f, 0.19186617f, -0.27426565f, 
    -0.01225939f, 0.04956145f, 0.04430570f, -0.00564170f, 0.09020861f, 0.06033519f, 0.02825829f, 0.06124068f, 
    -0.12607776f, -0.07160137f, 0.04210695f, -0.23915100f, -0.00175566f, 0.06516106f, 0.04564629f, -0.06415547f, 
    -0.01065780f, 0.04433108f, 0.01838381f, 0.09241866f, -0.11571069f, -0.02880674f, -0.02932675f, 0.08838902f, 
    0.02667159f, -0.06817757f, 0.04742688f, 0.11556622f, 0.05669259f, -0.02400680f, 0.04644614f, 0.01462145f, 
    -0.01172821f, -0.18071805f, -0.21396188f, 0.20683874f, -0.00007199f, -0.06044890f, 0.09752775f, -0.00337942f, 
    0.02909523f, 0.09248185f, -0.15297957f, -0.07255866f, 0.52459443f, -0.17600223f, -0.03304566f, 0.02478228f, 
    0.05555652f, -0.06695469f, -0.04445405f, 0.04864332f, 0.06517094f, 0.01208106f, -0.01941706f, 0.15192081f, 
    -0.12578489f, -0.10425854f, -0.20120110f, 0.04118728f, -0.00995009f, 0.03872721f, 0.08490668f, 0.03775078f, 
    0.01640200f, 0.05596807f, 0.00813620f, 0.01005530f, -0.18054658f, -0.13253112f, -0.04469762f, -0.04009145f, 
    0.01087483f, -0.00058003f, -0.11332134f, -0.06915729f, 0.07345907f, -0.09412722f, 0.12992913f, 0.09220609f, 
    0.33626363f, 0.17496720f, 0.03922908f, -0.04065418f, 0.10619985f, 0.05248971f, 0.04937792f, 0.10998875f, 
    0.02609637f, 0.03348508f, 0.04361146f, 0.11723899f, 0.34481740f, -0.25155964f, -0.01973427f, 0.28083402f, 
    -0.01784833f, 0.11165214f, -0.10028140f, 0.06132032f, 0.03645994f, 0.04924209f, 0.04750271f, 0.04109981f, 
    0.05626274f, 0.00757851f, -0.03937671f, -0.01975100f, 0.03061292f, -0.00054438f, 0.03951403f, -0.03291060f, 
    -0.04869470f, 0.01913435f, 0.04365341f, -0.01142840f, -0.00684325f, -0.01746367f, 0.02365375f, 0.03659905f, 
    -0.03873229f, -0.04314493f, 0.03405236f, -0.05373025f, 0.05174965f, 0.02706444f, -0.02973383f, 0.01170345f, 
    -0.04603598f, -0.00654665f, 0.00602857f, -0.01290369f, -0.02718747f, -0.00389218f, -0.04470909f, -0.01127158f, 
    -0.03976206f, 0.00929137f, -0.02701787f, 0.03639623f, 0.01372693f, 0.00225571f, 0.00877951f, -0.01272843f, 
    0.03818104f, -0.02628940f, 0.03322861f, -0.00168364f, -0.04953133f, -0.04057031f, 0.03920454f, -0.02618021f, 
    0.00389313f, 0.03356110f, -0.01564192f, -0.00819880f, -0.00593625f, 0.00969552f, -0.05105583f, 0.00598982f, 
    0.03785748f, -0.00877983f, -0.00298717f, 0.03647659f, 0.00371900f, -0.03653520f, 0.02235530f, -0.02514685f, 
    0.00521121f, -0.00165564f, 0.02833376f, -0.03037924f, -0.04374279f, 0.00563874f, -0.01798270f, -0.03855387f, 
    -0.04695167f, 0.00342230f, -0.05690077f, 0.02005517f, 0.03719490f, -0.00294408f, -0.02383297f, -0.01169917f, 
    -0.05202188f, -0.04429327f, -0.02050095f, 0.03846168f, -0.05136852f, -0.04715491f, 0.00953644f, 0.03011631f, 
    0.02377124f, -0.05488017f, 0.00688749f, -0.03824805f, -0.04560701f, 0.02924485f, -0.03038033f, -0.02712269f, 
    -0.03316124f, 0.01582261f, 0.03268946f, -0.00873232f, 0.04227217f, -0.01393430f, -0.01471570f, -0.01463664f, 
    0.00064740f, -0.00013505f, 0.00944208f, -0.00619253f, -0.04220980f, 0.00406076f, -0.02554056f, -0.05141009f, 
    -0.03301209f, 0.01509075f, -0.01113705f, -0.05250321f, 0.00066555f, -0.00622861f, -0.02715138f, -0.01401153f, 
    -0.00848208f, 0.02506097f, -0.01800362f, 0.03218082f, 0.00566026f, 0.04072898f, -0.04852268f, -0.05121590f, 
    -0.00034323f, -0.03904322f, -0.00453800f, 0.03641551f, -0.01492550f, 0.01571340f, -0.00517107f, 0.00818877f, 
    0.01565996f, -0.04853849f, 0.03109952f, 0.00901464f, -0.02918146f, -0.02579495f, 0.04527474f, -0.04031089f, 
    0.01126466f, 0.03882399f, -0.01643403f, -0.02698322f, -0.02931437f, -0.01026023f, -0.04752224f, -0.03688306f, 
    0.02582690f, -0.04612785f, -0.05273502f, 0.00194161f, -0.04063004f, 0.02328117f, 0.04072052f, 0.03216941f, 
    0.04393180f, 0.03920509f, 0.03348628f, -0.03065722f, 0.00321171f, -0.01162208f, 0.04466123f, 0.00324055f, 
    -0.00768755f, 0.03497865f, 0.00554236f, -0.05631600f, -0.01557637f, 0.02838043f, 0.00091885f, -0.01880901f, 
    0.01268599f, -0.04644953f, -0.01934469f, -0.03497772f, -0.03833320f, 0.01141350f, 0.01980033f, -0.02570627f, 
    -0.03270044f, 0.02590803f, 0.00383292f, 0.00384342f, 0.01882174f, -0.03700569f, 0.01873327f, -0.02553683f, 
    -0.01562542f, -0.04046487f, -0.00795347f, -0.02120672f, -0.02412208f, -0.03531300f, -0.03111592f, -0.01576755f, 
    -0.04423814f, 0.04253167f, -0.05675843f, 0.03530499f, 0.01869573f, 0.04568364f, 0.03649709f, 0.02689567f, 
    0.03476144f, 0.03485274f, -0.00561056f, 0.00415303f, -0.00233592f, -0.04880147f, 0.03440877f, 0.03293627f, 
    -0.04451570f, 0.00385274f, -0.03096689f, -0.03829021f, 0.05046218f, -0.01647712f, 0.04934445f, -0.00748306f, 
    0.02219024f, -0.05606136f, 0.03556491f, -0.00837697f, -0.00784606f, -0.01796576f, -0.02931440f, 0.03067156f, 
    0.00058171f, -0.00568633f, 0.02012498f, -0.00352490f, -0.01245580f, -0.03512597f, 0.01710411f, -0.01687333f, 
    0.03682768f, -0.00413139f, 0.03437828f, -0.04357429f, -0.02913670f, -0.01134796f, 0.02654191f, -0.03200441f, 
    0.03132717f, -0.01069112f, -0.03330263f, 0.00876682f, -0.01739358f, 0.03408058f, -0.04244192f, 0.00404481f, 
    -0.02779754f, 0.03193111f, -0.03820465f, 0.02963168f, -0.04174383f, -0.04155791f, -0.02216246f, 0.00398673f, 
    -0.04752287f, -0.01899725f, 0.03365797f, 0.02761288f, -0.01345421f, -0.04322398f, -0.00519111f, -0.05292696f, 
    0.04405836f, -0.03850405f, -0.04331965f, -0.00937962f, -0.00199763f, -0.00996694f, 0.04770702f, 0.02838043f, 
    -0.04189113f, 0.03789715f, -0.03193716f, 0.01094462f, 0.03094893f, -0.01119056f, 0.02822463f, 0.03156612f, 
    -0.04212982f, 0.03013739f, 0.04431200f, 0.01910310f, -0.05488863f, 0.04461920f, -0.02549133f, 0.01739959f, 
    -0.03260441f, 0.00905311f, 0.01675847f, -0.00706920f, 0.04655453f, 0.00940500f, 0.02499453f, -0.04898626f, 
    -0.03609064f, -0.00907933f, -0.02558459f, 0.00253159f, 0.00993728f, 0.03723981f, -0.00820258f, 0.02573108f, 
    -0.04974194f, -0.03381774f, 0.04822013f, -0.05516095f, -0.03205445f, 0.00251514f, -0.03586483f, 0.05034313f, 
    0.02604768f, -0.00333770f, -0.00222806f, 0.00997808f, -0.05030191f, 0.03978878f, -0.03634105f, 0.03965817f, 
    0.00506104f, -0.04643640f, -0.04411275f, 0.01798110f, 0.01003223f, -0.02295095f, 0.02071276f, 0.02588737f, 
    -0.03612567f, -0.01484933f, 0.03297431f, -0.01845688f, 0.01967845f, 0.00876901f, -0.00416018f, -0.04353547f, 
    0.03762225f, -0.03008701f, -0.04319568f, 0.00145324f, 0.04543908f, -0.04888588f, -0.01652506f, -0.01978768f, 
    -0.00987520f, -0.01456337f, -0.01670508f, 0.01138481f, 0.02968805f, 0.01684097f, 0.03844074f, -0.00655320f, 
    0.01382033f, -0.03603964f, 0.03425890f, -0.02358910f, -0.00565239f, 0.02426898f, -0.04835160f, -0.03452120f, 
    0.03098578f, 0.01197304f, -0.05319301f, -0.01666198f, -0.02707412f, 0.00249728f, -0.05170470f, -0.00444856f, 
    0.02116248f, 0.04902576f, 0.03356406f, 0.03794284f, 0.02193819f, -0.05242420f, 0.00362724f, 0.01939273f, 
    0.02825353f, -0.04249718f, -0.05086434f, -0.03868000f, -0.02057197f, -0.06305587f, -0.05955341f, -0.04133780f, 
    0.00615926f, -0.01031281f, 0.01291055f, -0.01440649f, 0.02765860f, 0.04734702f, -0.04064099f, 0.04134076f, 
    -0.05958900f, 0.04513275f, 0.03593916f, -0.02546675f, -0.01506177f, 0.00756795f, 0.02345043f, 0.04313536f, 
    -0.05758103f, -0.04707134f, 0.00201772f, 0.01939426f, -0.01236289f, -0.00533813f, -0.01062454f, -0.03990613f, 
    0.00864878f, -0.02505652f, 0.00363771f, -0.01914557f, -0.02717065f, -0.01370518f, 0.03011084f, 0.01727946f, 
    0.03259901f, 0.02456391f, 0.02068972f, 0.00418527f, 0.01966418f, 0.01479115f, -0.02700260f, 0.03399819f, 
    -0.03699065f, 0.03125747f, 0.00381227f, 0.02221435f, 0.00054596f, -0.04786411f, -0.03101682f, 0.02491063f, 
    0.00838500f, -0.06081043f, -0.03632894f, -0.05423065f, -0.01192780f, -0.01238973f, -0.00773816f, -0.04269871f, 
    -0.03279285f, -0.03713323f, -0.00363149f, -0.00786549f, -0.01619758f, -0.01233562f, -0.00657107f, -0.03010643f, 
    0.01242681f, -0.03321691f, -0.04042604f, 0.01037639f, -0.01131469f, -0.01050238f, 0.04122819f, -0.05374900f, 
    0.03803637f, 0.01827768f, 0.04852167f, -0.05347914f, 0.00642373f, 0.00263783f, 0.00847501f, -0.01740085f, 
    -0.03477800f, 0.00478717f, -0.03111179f, -0.02986032f, -0.02113772f, -0.00988397f, -0.03651554f, -0.04565748f, 
    -0.05273829f, 0.04272043f, -0.00549749f, -0.02584717f, 0.02830948f, 0.02082817f, 0.03557974f, -0.03743540f, 
    0.04614299f, -0.00511462f, -0.03013646f, 0.01640902f, -0.03069639f, -0.01326754f, -0.05523721f, 0.01904308f, 
    -0.01945627f, -0.03692365f, -0.00778566f, -0.00913375f, -0.00129572f, 0.03068047f, -0.03704574f, 0.02370315f, 
    0.03156408f, 0.03697502f, 0.01143668f, -0.03752911f, 0.00173494f, 0.00023925f, -0.03262276f, 0.01279256f, 
    0.03155039f, -0.04357669f, -0.03377020f, -0.02204520f, -0.01637916f, 0.03684595f, -0.02062375f, 0.00930306f, 
    0.01448242f, -0.02701961f, 0.00259685f, 0.02120504f, -0.03943353f, 0.04670348f, -0.01177468f, -0.00677946f, 
    0.00891117f, -0.04719325f, -0.00499772f, 0.00340251f, -0.06070445f, -0.04506608f, -0.01989860f, -0.02705596f, 
    -0.01588085f, 0.02776230f, -0.02845694f, 0.03885860f, -0.00957433f, -0.03295309f, 0.01631742f, -0.02085286f, 
    0.03901357f, -0.03210789f, 0.00497197f, -0.02175614f, 0.02931775f, -0.03481819f, -0.01374351f, -0.04074065f, 
    0.02359725f, -0.04556281f, -0.04299336f, 0.00350041f, -0.05840320f, 0.03387510f, -0.02318989f, -0.02506608f, 
    -0.02748295f, 0.01197315f, -0.00698578f, -0.02767156f, -0.03805055f, -0.04202053f, -0.00990782f, -0.01326499f, 
    0.02360132f, 0.00391556f, 0.02849512f, -0.03747177f, 0.02273653f, 0.02862685f, 0.03113883f, 0.03853671f, 
    -0.00355981f, 0.02135710f, 0.00797065f, 0.03651027f, 0.04050699f, 0.02958238f, 0.01671204f, -0.05266760f, 
    0.01008064f, 0.00467452f, 0.03540265f, 0.03528426f, 0.02606314f, 0.01219351f, -0.03831804f, -0.04035480f, 
    -0.05008869f, 0.02629488f, -0.03711345f, -0.04263755f, -0.00638446f, -0.05150405f, -0.01000903f, 0.01415262f, 
    -0.03640401f, -0.03541661f, -0.00039866f, -0.04384613f, 0.00593237f, -0.02630425f, -0.02131233f, 0.02957466f, 
    -0.00128582f, -0.04089208f, -0.04395695f, 0.03876074f, 0.02197582f, -0.04150606f, 0.00257276f, 0.02745174f, 
    0.04585367f, -0.00361853f, -0.01438136f, 0.02919981f, 0.04245634f, 0.03402198f, -0.02563517f, 0.02106276f, 
    -0.01313264f, -0.01195477f, 0.01423956f, 0.03445113f, -0.02069834f, -0.02121198f, -0.01092409f, -0.01236520f, 
    0.00837785f, 0.05293949f, -0.04793937f, -0.02952126f, 0.02680515f, -0.00051129f, 0.01291503f, 0.01265039f, 
    -0.03405539f, -0.03563093f, -0.04750035f, -0.04341664f, -0.00289895f, -0.01478925f, -0.01394862f, -0.01183687f, 
    0.02383865f, 0.03361716f, 0.03582683f, 0.03065629f, 0.03421557f, -0.05117758f, -0.01161372f, -0.05572315f, 
    0.03689351f, 0.03839657f, -0.02829580f, -0.03486839f, -0.01294860f, -0.05371626f, 0.00409607f, -0.03570705f, 
    -0.00304910f, -0.01295708f, 0.02715552f, -0.00698900f, -0.01299273f, 0.02839218f, 0.05489640f, -0.02342104f, 
    -0.00341080f, 0.02725564f, 0.02167533f, 0.00016435f, -0.04489323f, 0.03264581f, 0.00488963f, 0.00547440f, 
    -0.02059467f, -0.01469762f, -0.04545392f, -0.04484579f, -0.04957337f, 0.00709988f, -0.02695253f, 0.02749755f, 
    0.03496255f, -0.03772733f, 0.03802208f, -0.01431203f, 0.02865496f, 0.04335502f, 0.03785412f, -0.02988484f, 
    -0.04097145f, -0.01279661f, -0.01892603f, -0.01730595f, -0.00490260f, -0.00077614f, -0.02491592f, 0.02286393f, 
    -0.00578867f, 0.02549411f, -0.04992249f, -0.04700214f, 0.00212044f, -0.01977063f, 0.02755051f, -0.00593712f, 
    -0.04283233f, -0.00732106f, 0.03764049f, -0.04357005f, -0.00980869f, 0.01739943f, 0.03874959f, -0.02336601f, 
    -0.00628162f, 0.00778054f, -0.01900961f, -0.02642740f, 0.00551529f, 0.02178251f, -0.00873435f, 0.03385909f, 
    0.00486989f, 0.04503196f, 0.02365965f, 0.00954492f, 0.02124383f, -0.01548502f, -0.02185193f, 0.01695119f, 
    -0.04816261f, -0.00372473f, -0.03594811f, -0.06096869f, -0.03997575f, 0.04258642f, 0.00873286f, -0.00346225f, 
    -0.03342303f, -0.03901075f, -0.03833750f, 0.03150450f, 0.02325272f, 0.01430562f, -0.01531295f, -0.00878114f, 
    0.02955122f, -0.01132615f, 0.00099108f, -0.02245554f, -0.02120603f, -0.00590079f, -0.01777471f, -0.01061935f, 
    -0.03418407f, -0.00533923f, -0.00875343f, -0.03185197f, 0.01934774f, -0.03816902f, -0.00891729f, -0.02981533f, 
    -0.37349913f, -0.05793242f, 0.23274772f, 0.24173133f, 0.01466520f, 0.03063870f, 0.00834832f, 0.08175720f, 
    -0.04590537f, 0.01795601f, -0.01548428f, -0.00286520f, -0.00841822f, 0.25892356f, 0.03857207f, 0.31237411f, 
    -0.09351431f, 0.01503116f, 0.10170400f, -0.07968073f, 0.11039717f, 0.03353215f, 0.07525919f, -0.10053553f, 
    -0.13444822f, 0.03495064f, -0.14141896f, 0.09940924f, -0.01845711f, 0.01739382f, 0.01513484f, 0.03302540f, 
    0.02862859f, -0.07213400f, -0.05669052f, 0.04736289f, 0.00649484f, 0.09066444f, -0.06831744f, -0.28331262f, 
    0.11233730f, 0.12160732f, -0.00590147f, 0.06667774f, -0.03805596f, 0.05072242f, -0.10915942f, 0.01732007f, 
    -0.10495263f, -0.18060298f, 0.00277364f, 0.21963911f, -0.06132931f, 0.18925563f, 0.00695157f, 0.03385861f, 
    0.00697705f, -0.05047396f, 0.15094550f, -0.10401634f, -0.17246227f, 0.01653583f, 0.07273505f, -0.11072532f, 
    0.01705567f, -0.04309620f, -0.09594509f, 0.03010398f, 0.01023503f, -0.03366758f, 0.08200081f, 0.20314535f, 
    0.15480600f, 0.04451879f, 0.26070246f, -0.12010820f, 0.07190254f, -0.00190867f, 0.01847815f, -0.00620013f, 
    -0.03160635f, -0.02263196f, -0.07790466f, -0.04286654f, 0.36150581f, 0.00290814f, -0.00069944f, 0.31205183f, 
    0.08665375f, -0.03238177f, 0.02511458f, 0.01792342f, 0.03284065f, -0.04638476f, 0.03874260f, -0.08532741f, 
    0.46031946f, -0.24350365f, 0.20304731f, 0.13324778f, -0.05369251f, 0.02456897f, 0.03540097f, -0.02495620f, 
    0.00124908f, 0.07111216f, 0.02185924f, 0.13037488f, -0.51448441f, 0.17811142f, -0.04335158f, -0.10736875f, 
    0.04088450f, 0.04174669f, 0.02309092f, 0.03858696f, 0.07015047f, -0.02433619f, 0.00392264f, 0.00717399f, 
    0.01851027f, 0.03313958f, 0.02762403f, 0.00405211f, -0.05704311f, -0.04232470f, -0.02821361f, 0.12685636f, 
    0.13384181f, -0.02108926f, 0.02039871f, 0.02995568f, 0.18619484f, -0.02426751f, -0.12844265f, -0.08312994f, 
    -0.02162067f, -0.07834745f, -0.12737617f, 0.03699091f, -0.03910368f, 0.04474663f, -0.09835929f, 0.01497598f, 
    0.48865566f, 0.00896513f, 0.16742878f, 0.53290057f, -0.03646919f, 0.00437400f, 0.05506427f, -0.01170069f, 
    -0.01731657f, -0.07215185f, -0.01199896f, 0.08381382f, 0.21025190f, 0.00351247f, -0.06349214f, -0.27989626f, 
    0.02569768f, -0.13187414f, 0.22059987f, -0.04094441f, -0.06374257f, 0.06246651f, 0.02505288f, -0.04647296f, 
    -0.44707909f, 0.06583388f, 0.02928937f, -0.19127227f, -0.09209116f, 0.02874795f, -0.06231193f, 0.05148780f, 
    0.08819391f, 0.00413388f, -0.00553529f, -0.06909300f, 0.18000393f, -0.00561024f, -0.10091878f, -0.00166476f, 
    -0.03151442f, -0.02270032f, -0.01537811f, 0.12043738f, 0.09130742f, 0.10873064f, -0.08851985f, 0.07381225f, 
    -0.00473409f, -0.05015827f, 0.08382542f, -0.11620658f, 0.06620002f, -0.07048381f, 0.20797682f, 0.08359312f, 
    0.14285350f, -0.01444391f, 0.09584724f, 0.09647124f, 0.21183673f, 0.00054099f, 0.12132352f, -0.11124003f, 
    -0.05937490f, -0.05617729f, 0.02301587f, -0.02108223f, 0.09392784f, -0.16076551f, 0.01346367f, 0.04741327f, 
    -0.23327044f, -0.10956182f, -0.06675745f, -0.02844488f, 0.03612370f, -0.04143136f, 0.10014252f, -0.10464404f, 
    0.04174397f, 0.06982151f, 0.00583341f, 0.03616644f, 0.19530925f, -0.05681931f, -0.00660995f, 0.37233579f, 
    -0.05017724f, 0.00284150f, 0.04788943f, 0.06558793f, -0.07675079f, 0.06068476f, 0.04753413f, -0.01811619f, 
    0.21605131f, -0.19687986f, 0.14911599f, 0.19155392f, 0.04302634f, 0.13380073f, 0.15153231f, 0.13912973f, 
    0.07475792f, 0.16177100f, 0.08563746f, -0.06858732f, -0.09741504f, -0.20288523f, 0.14123596f, -0.17709163f, 
    0.07078300f, 0.04502904f, 0.02863170f, 0.03904100f, 0.00366582f, -0.00086480f, -0.09277767f, 0.02199511f, 
    -0.11946851f, 0.01834077f, 0.04001834f, 0.09613823f, 0.04902285f, -0.01915467f, 0.12228279f, 0.15662071f, 
    0.01068694f, 0.10359792f, 0.19252270f, -0.12293695f, 0.10757501f, -0.06203155f, 0.15216124f, -0.04836507f, 
    0.05588918f, 0.04667939f, -0.02495069f, 0.17455494f, -0.11015430f, -0.06052868f, -0.04004970f, -0.03812049f, 
    -0.05105450f, -0.13454632f, 0.04890743f, 0.04962917f, -0.16421013f, -0.08011572f, 0.02459921f, 0.04380281f, 
    0.09828775f, 0.02365914f, 0.07490036f, 0.08060545f, 0.86925966f, -0.28295636f, -0.00456726f, 0.16357923f, 
    -0.07201762f, -0.02391008f, -0.03227935f, -0.06193887f, -0.05542439f, -0.02440580f, -0.01154142f, -0.07596722f, 
    0.01371671f, -0.19105378f, 0.20003164f, -0.10935978f, -0.01307299f, 0.06424973f, -0.10790755f, -0.01879034f, 
    0.09990243f, -0.10192529f, 0.02945398f, 0.09752282f, 0.03099370f, 0.10541096f, -0.08475614f, -0.01073176f, 
    0.05923070f, 0.00799887f, 0.07635136f, 0.03568232f, 0.00239694f, -0.03661479f, 0.03701952f, 0.01583374f, 
    -0.06435854f, 0.23219937f, 0.01670719f, -0.10157321f, -0.07419460f, 0.06179441f, -0.16930541f, 0.02761223f, 
    0.02369048f, -0.00854204f, 0.04266534f, 0.00325204f, -0.01202815f, -0.06127221f, -0.12919268f, -0.29325670f, 
    -0.06596218f, 0.11765866f, 0.05602669f, 0.12566525f, 0.08195396f, 0.04747868f, -0.20968920f, -0.11819532f, 
    0.32947481f, -0.07922740f, -0.03057858f, 0.17287461f, -0.09255031f, 0.04082429f, 0.01700302f, -0.03927682f, 
    -0.04238492f, 0.05421171f, 0.01278765f, -0.06311443f, -0.21501648f, 0.13448106f, -0.03502440f, 0.24613234f, 
    0.06342489f, 0.00667024f, -0.01138009f, -0.11951502f, 0.04717781f, -0.02554421f, -0.03794023f, 0.02170418f, 
    0.12957509f, 0.11688771f, -0.07536856f, -0.20290264f, -0.12536515f, 0.00460748f, -0.04420364f, -0.06130657f, 
    -0.08941124f, 0.13145898f, 0.08762662f, 0.24539824f, 0.26101992f, -0.16099173f, 0.13689364f, 0.04681019f, 
    -0.13139810f, 0.03902316f, -0.06322589f, 0.12085763f, 0.10389119f, 0.02907504f, 0.09294046f, 0.03138726f, 
    0.10356227f, -0.20294215f, 0.03151240f, 0.16637966f, -0.09088003f, -0.15351538f, 0.03230751f, 0.02525674f, 
    -0.01113007f, 0.02705806f, 0.08249984f, -0.04750956f, -0.07472994f, -0.18641248f, 0.23633936f, -0.09397669f, 
    0.07052355f, -0.07175703f, -0.09828851f, -0.10268294f, 0.04948341f, 0.02010678f, 0.07900337f, -0.01177773f, 
    0.00988525f, 0.07395940f, 0.07909181f, -0.21792862f, -0.16446017f, -0.03944435f, -0.01513307f, -0.07419733f, 
    -0.01317048f, 0.11494327f, 0.00702761f, 0.11588300f, -0.14114496f, -0.16011623f, -0.00992571f, 0.06277103f, 
    0.08099461f, -0.00608672f, 0.11540622f, 0.00756645f, 0.02864722f, 0.14021333f, 0.05692879f, 0.15035044f, 
    -0.23024827f, 0.03727726f, -0.01504053f, 0.02440407f, -0.11101133f, 0.06436080f, 0.00422631f, 0.07602631f, 
    -0.05179574f, -0.11184423f, -0.08185062f, 0.06117608f, -0.03880582f, 0.20376439f, 0.12367259f, -0.08189929f, 
    0.00061605f, 0.05525842f, 0.00168635f, -0.09898920f, 0.03526014f, 0.06783830f, 0.02700627f, 0.03679362f, 
    -0.01954753f, 0.25909257f, 0.02908607f, -0.25398186f, 0.09888394f, -0.04368566f, 0.01694645f, 0.04680175f, 
    0.03289519f, 0.06852480f, -0.03510526f, -0.02006568f, -0.12905353f, 0.00711181f, -0.18548009f, 0.02025942f, 
    0.03036189f, 0.09372007f, 0.10291155f, -0.02987348f, -0.04573424f, 0.08056983f, -0.07671648f, -0.05884791f, 
    -0.22184008f, -0.07929639f, 0.05133154f, 0.07696621f, 0.08952783f, 0.04261098f, -0.02473286f, 0.03380802f, 
    -0.02553554f, 0.13014384f, -0.15410458f, -0.03183249f, 0.00789681f, -0.00259253f, -0.13745740f, -0.04581101f, 
    0.06264005f, -0.01104523f, -0.01682619f, 0.04610366f, -0.02832611f, -0.03557066f, -0.06578088f, 0.16708159f, 
    -0.09157208f, 0.08204275f, 0.24177189f, 0.04436634f, 0.12604983f, 0.04667215f, 0.10429783f, -0.09304571f, 
    0.01815649f, -0.01414053f, 0.08714794f, 0.03508169f, 0.02508202f, 0.02213163f, 0.16519374f, 0.10233401f, 
    0.04041934f, 0.04765673f, -0.05190392f, -0.03589238f, 0.02284282f, -0.20128480f, 0.06909613f, 0.04539233f, 
    0.31281683f, 0.11393604f, -0.18261266f, 0.05522699f, 0.10976075f, -0.03822421f, -0.01380298f, 0.04722724f, 
    0.03952343f, 0.12508118f, -0.02390248f, 0.14165220f, -0.17002149f, -0.25937515f, 0.01928245f, 0.07124167f, 
    0.25352886f, 0.12697425f, 0.04351305f, 0.01528214f, 0.02082311f, -0.02693153f, 0.01459621f, 0.08339324f, 
    -0.09013128f, -0.02881406f, -0.16402036f, 0.03028293f, 0.03183030f, 0.11069725f, -0.06437436f, 0.04648437f, 
    0.02331886f, -0.08259550f, 0.11587673f, -0.03480342f, -0.24557102f, -0.07537235f, 0.02077160f, -0.00418366f, 
    -0.07104550f, -0.12444214f, 0.06695075f, 0.06626786f, 0.02172466f, -0.01901935f, 0.15311831f, 0.01821031f, 
    0.04479692f, -0.05114865f, 0.03895494f, -0.14103012f, 0.08586165f, 0.07743352f, -0.13980556f, 0.04697130f, 
    0.05584011f, 0.11908794f, -0.02132726f, -0.01059705f, 0.08518920f, 0.23108551f, 0.19086592f, -0.09584785f, 
    0.07643477f, -0.10901958f, 0.05460945f, -0.08204377f, 0.18344672f, 0.08754630f, -0.00671850f, 0.14722230f, 
    -0.00702166f, 0.31611431f, 0.12979750f, 0.19007495f, 0.12378290f, -0.00312251f, -0.16537322f, -0.01508517f, 
    -0.12243676f, -0.00647851f, 0.04374077f, -0.04133001f, -0.24212939f, 0.06810365f, -0.09094471f, 0.00007044f, 
    0.12190018f, 0.03666740f, -0.04920070f, 0.02129862f, 0.00135335f, 0.04639358f, 0.04172777f, -0.03470501f, 
    0.35257125f, 0.08349776f, 0.13672711f, 0.00683034f, 0.05689376f, -0.19588795f, -0.09551664f, -0.05269645f, 
    0.06891958f, 0.00144085f, -0.12404038f, 0.07193422f, -0.22014703f, -0.12001741f, 0.10622708f, 0.07387850f, 
    0.05338161f, -0.08730686f, 0.10663836f, 0.06044206f, 0.08199379f, -0.05290395f, 0.07726799f, -0.27058744f, 
    -0.02152768f, -0.03717294f, 0.11149239f, 0.02222476f, 0.19136864f, 0.06390143f, 0.03078958f, -0.00430221f, 
    -0.05717429f, 0.04973779f, 0.08192331f, 0.13820332f, -0.30082774f, 0.20172034f, 0.15476064f, -0.01207121f, 
    -0.08697031f, -0.03071271f, -0.01323457f, -0.01108197f, 0.17094649f, -0.13969970f, 0.04903905f, 0.09805892f, 
    0.00338241f, 0.34274626f, -0.02080377f, -0.14599146f, 0.02220615f, 0.05382058f, 0.13889658f, 0.16374621f, 
    -0.07515383f, 0.23330642f, 0.13889422f, -0.01555600f, -0.26158306f, -0.07278412f, -0.16388120f, -0.15814099f, 
    0.16000924f, 0.08902363f, -0.04788107f, 0.01164760f, 0.05679444f, 0.08727795f, 0.10944723f, 0.02089274f, 
    -0.06840888f, -0.28787765f, -0.11004064f, 0.07459917f, 0.12218884f, -0.04663107f, 0.09736809f, -0.06133062f, 
    -0.02492133f, 0.11863123f, -0.07162070f, 0.02199308f, -0.32189515f, -0.08468718f, -0.06317770f, 0.29484582f, 
    0.01444115f, -0.08031485f, 0.16140540f, 0.01642746f, 0.07526157f, -0.08100092f, -0.02796714f, -0.05001851f, 
    -0.05797904f, -0.02654213f, 0.10567255f, 0.06640621f, 0.11733460f, 0.09772989f, -0.11146200f, -0.05127412f, 
    -0.07404747f, -0.02292258f, -0.03992499f, 0.00859853f, -0.25928274f, -0.12547958f, -0.03408304f, -0.18915035f, 
    0.08268677f, -0.03305401f, -0.03582424f, 0.17500192f, 0.09501037f, -0.00402457f, 0.20872313f, -0.06852710f, 
    -0.27793920f, -0.15595812f, -0.07071064f, -0.34851795f, 0.05562528f, 0.10100937f, 0.03852510f, 0.01564536f, 
    0.23469335f, 0.08467927f, 0.01614934f, -0.11969970f, 0.11996781f, 0.20545574f, -0.10760595f, 0.01915022f, 
    0.01033527f, 0.01431650f, 0.15955837f, -0.08080221f, 0.00658410f, -0.00892047f, -0.10875654f, -0.16215615f, 
    -0.17085442f, 0.12531039f, -0.12688233f, 0.09760995f, -0.03889662f, 0.05587895f, 0.05386737f, -0.02434496f, 
    0.03012154f, -0.05766971f, -0.18599451f, 0.21082246f, 0.13262630f, 0.06898373f, -0.35823086f, 0.22414814f, 
    -0.10195585f, 0.07026558f, 0.14696318f, -0.13067514f, -0.08287430f, -0.01928394f, -0.10185937f, 0.06222558f, 
    -0.11825886f, 0.01008853f, 0.05053530f, 0.17422074f, 0.10606154f, 0.00606233f, 0.02727730f, 0.00361282f, 
    -0.03276893f, -0.11239726f, 0.01507860f, -0.07335211f, -0.00053481f, 0.07509650f, -0.40681681f, 0.00229736f, 
    0.00235512f, 0.00676405f, -0.11759597f, -0.03251867f, 0.09577737f, -0.01001926f, 0.09778570f, -0.03828328f, 
    0.15207404f, -0.07751389f, 0.00169171f, -0.11940066f, 0.04019606f, -0.09193895f, -0.09558935f, -0.01495039f, 
    -0.15599619f, 0.01614939f, -0.01585100f, -0.08793923f, 0.02410562f, -0.04746739f, 0.06557174f, 0.09175561f, 
    0.07940776f, -0.04660668f, -0.07212897f, 0.10542723f, -0.09984095f, -0.07890764f, 0.00074419f, -0.13083436f, 
    0.28129154f, -0.11954272f, 0.18653145f, 0.35977331f, 0.00896853f, 0.09470775f, -0.03036727f, 0.01204890f, 
    -0.16278888f, -0.01826192f, 0.14830144f, 0.10328092f, 0.51421785f, 0.12617207f, 0.01710043f, 0.12745304f, 
    -0.04027877f, 0.10096018f, -0.19442394f, -0.02504312f, -0.02254420f, -0.01080191f, -0.07483486f, 0.10606652f, 
    -0.00951512f, 0.03128404f, 0.14831096f, -0.05208196f, 0.02084421f, -0.07905352f, 0.07408937f, -0.02974966f, 
    0.02371723f, -0.11767522f, 0.18322186f, 0.14583820f, -0.02388973f, -0.03350675f, 0.02206143f, -0.00603676f, 
    -0.18655157f, 0.00917115f, -0.12822302f, 0.07799623f, 0.01046979f, 0.01231136f, 0.01141914f, -0.08079809f, 
    0.28085870f, 0.13880295f, 0.09209714f, 0.04909209f, -0.17904261f, -0.03364145f, -0.06632232f, 0.03242928f, 
    -0.05191549f, 0.08120739f, -0.02632977f, -0.11156671f, 0.15286121f, -0.09636141f, 0.09050806f, -0.43075770f, 
    0.07565174f, -0.17294356f, 0.11403562f, 0.14501876f, -0.11800183f, 0.06669225f, 0.10669498f, -0.10307938f, 
    -0.10970061f, 0.14662810f, 0.04804137f, 0.13184842f, -0.17545782f, 0.17873389f, -0.02013270f, -0.06395902f, 
    0.03439782f, 0.03655941f, -0.01347887f, -0.10225528f, 0.05054191f, 0.05701055f, 0.08642633f, -0.15227343f, 
    -0.05626326f, -0.18027261f, -0.22075221f, 0.14363649f, 0.11079391f, -0.06965256f, 0.07682927f, 0.00946485f, 
    -0.27436247f, -0.11083061f, 0.23380566f, -0.25462312f, -0.06402747f, -0.03435731f, 0.15381373f, -0.10793672f, 
    -0.04682614f, 0.07172228f, -0.19887625f, -0.05502581f, -0.01725424f, 0.04160668f, 0.07175976f, -0.26382369f, 
    0.07563116f, 0.00199903f, 0.09082657f, -0.11380418f, 0.05149850f, -0.12368133f, -0.00868546f, 0.02085449f, 
    0.03365682f, -0.01271922f, 0.11647346f, -0.03516177f, 0.08493742f, -0.00243014f, 0.08197378f, 0.16434605f, 
    0.05945490f, -0.00854528f, 0.07789267f, 0.01036125f, 0.26534039f, 0.08849538f, 0.10492654f, 0.33980843f, 
    -0.12686166f, 0.01793288f, 0.02869631f, 0.00412154f, -0.21548519f, -0.07946337f, -0.04396653f, -0.05323026f, 
    0.14554214f, -0.05197990f, -0.02417506f, 0.22107345f, -0.12128663f, 0.09269264f, 0.14801948f, 0.05914069f, 
    -0.00288955f, -0.04940200f, -0.02250627f, 0.08602072f, 0.06407496f, -0.12548871f, 0.10517061f, -0.20826067f, 
    -0.00373403f, -0.06651992f, 0.14460754f, 0.02377976f, -0.04696080f, -0.06145335f, -0.18101273f, -0.07417157f, 
    -0.00328497f, 0.07713265f, 0.00914263f, 0.27173433f, -0.07212510f, 0.32822356f, 0.14060299f, -0.02242158f, 
    0.00943983f, -0.02040003f, 0.08229310f, -0.08933244f, 0.02019189f, 0.15581138f, 0.16434747f, -0.21383692f, 
    -0.03330430f, 0.04387649f, -0.00535018f, -0.00326355f, -0.13974296f, 0.13980123f, 0.00758417f, 0.09889203f, 
    -0.20767832f, -0.03665344f, -0.05355476f, -0.00263274f, -0.10252718f, 0.05288840f, 0.07427425f, 0.03915179f, 
    0.10098090f, -0.02628610f, -0.02147987f, -0.05412539f, 0.32029787f, -0.00915394f, -0.02431499f, 0.35607001f, 
    -0.06901485f, 0.00571854f, 0.01201070f, 0.10722442f, -0.22130559f, 0.11031234f, 0.02865395f, -0.14440827f, 
    -0.07467804f, -0.30476812f, -0.01245490f, 0.13453008f, -0.15426491f, -0.04573423f, -0.16330676f, -0.17496878f, 
    0.07391524f, -0.06756168f, -0.12966184f, 0.08531666f, 0.43498158f, 0.05573339f, 0.14994131f, 0.02636451f, 
    -0.09607225f, -0.01547351f, -0.09735528f, 0.01151672f, 0.03937430f, -0.05719031f, -0.09879075f, 0.16498923f, 
    -0.09302299f, -0.03701792f, 0.05764835f, -0.11130967f, -0.01752393f, -0.02574665f, -0.03285782f, 0.04972072f, 
    -0.01098337f, -0.11915296f, 0.05514708f, -0.02246967f, 0.10712960f, -0.02578693f, -0.07667606f, -0.23173700f, 
    0.05961779f, 0.07028486f, -0.20897061f, 0.00268433f, -0.09968076f, -0.02419903f, 0.00453763f, 0.16211793f, 
    0.10114129f, 0.13415378f, 0.04106408f, -0.04387503f, -0.12788923f, -0.10796770f, 0.10486405f, -0.02052056f, 
    -0.01928967f, 0.06308457f, 0.07570823f, -0.01046753f, 0.53235942f, -0.21914226f, -0.05541708f, 0.33597589f, 
    -0.14886387f, 0.12705685f, -0.04286833f, -0.10361380f, 0.13204287f, 0.06443240f, -0.07760020f, 0.07815924f, 
    -0.02091452f, 0.00531681f, -0.03587500f, -0.04697092f, 0.00113569f, 0.03722067f, -0.01467539f, 0.03261954f, 
    0.03135566f, 0.02689829f, -0.02400133f, -0.02835033f, -0.00548529f, 0.01275576f, -0.04206112f, 0.02383396f, 
    -0.00807094f, -0.00014409f, -0.03205354f, 0.03314305f, -0.02972144f, 0.00773861f, 0.01383755f, -0.03781114f, 
    -0.03519879f, 0.00903632f, 0.01865401f, 0.01487430f, 0.02244915f, 0.04039320f, 0.00501552f, -0.02683874f, 
    0.03278632f, -0.01130302f, 0.03696491f, 0.01501061f, -0.01818028f, 0.00193350f, 0.02901785f, 0.02394125f, 
    0.02908940f, 0.03652544f, -0.05042880f, 0.01436393f, -0.01537542f, -0.00186775f, 0.02028205f, -0.00784522f, 
    -0.02469780f, 0.03441390f, 0.00753931f, 0.02917899f, 0.00814208f, 0.03259659f, 0.01604118f, -0.00666617f, 
    -0.00668037f, 0.02030727f, -0.01674234f, -0.03436201f, 0.00991817f, -0.02774372f, -0.00431306f, 0.00848641f, 
    -0.00713261f, 0.01772296f, -0.00861802f, -0.03530572f, 0.00159923f, 0.02509960f, 0.01150171f, 0.01829227f, 
    -0.05626189f, 0.03044356f, -0.01784327f, 0.03755163f, 0.00883695f, -0.03571409f, 0.00482697f, -0.01001879f, 
    -0.00007535f, -0.02193830f, 0.00033887f, -0.00100535f, 0.02255945f, 0.02554840f, 0.03427546f, -0.02153063f, 
    0.03106168f, -0.04194143f, -0.01632880f, -0.04730709f, 0.01408305f, 0.01216748f, 0.00861331f, -0.05813169f, 
    -0.02785823f, -0.04690613f, -0.02084650f, -0.01919526f, 0.04029479f, -0.00347974f, -0.00433165f, -0.02240397f, 
    0.02393187f, -0.06008903f, -0.02511630f, -0.01938274f, -0.02464592f, -0.04387885f, 0.02272982f, -0.04383728f, 
    -0.02700823f, -0.04456916f, -0.02760023f, 0.01927337f, 0.03805798f, -0.00531162f, 0.02708183f, -0.05646218f, 
    0.00258212f, 0.01917175f, -0.02153339f, -0.00716363f, -0.02527542f, -0.03619128f, -0.02781980f, 0.02631588f, 
    -0.01586444f, 0.03410437f, 0.02583382f, -0.01565478f, 0.00810187f, -0.04249526f, 0.02780010f, -0.03883021f, 
    -0.03294173f, 0.02228402f, -0.03945665f, 0.01827094f, 0.02613283f, -0.04999298f, -0.04053077f, 0.01590341f, 
    0.00876220f, -0.01597063f, 0.03970211f, -0.04490421f, -0.03110373f, -0.04024919f, 0.00737071f, 0.03856957f, 
    -0.02890567f, -0.02215137f, 0.02969092f, -0.03141942f, -0.00421292f, 0.01937944f, 0.03530139f, 0.01240591f, 
    0.01572904f, -0.04294875f, -0.05087676f, -0.00025211f, -0.03139879f, -0.02392350f, -0.01194219f, 0.01804247f, 
    -0.05900187f, 0.03893390f, 0.02974997f, -0.00225536f, -0.04268832f, -0.03451299f, 0.02764866f, 0.01305837f, 
    -0.02793932f, 0.00451681f, 0.02502658f, -0.03933921f, -0.01209522f, -0.04050724f, -0.03254927f, -0.03894492f, 
    0.01730702f, -0.00422707f, -0.06288720f, -0.02732380f, 0.01093370f, 0.02009382f, -0.02063054f, -0.05922221f, 
    0.02706303f, 0.03194142f, -0.05991564f, -0.00286130f, -0.02584210f, -0.02298008f, -0.02828371f, -0.05968183f, 
    -0.00061751f, -0.03504062f, -0.06012952f, 0.02085912f, 0.00413339f, -0.01084198f, -0.00984308f, -0.04693322f, 
    -0.03827338f, 0.02591280f, -0.02577615f, 0.03043341f, -0.01817860f, -0.04301837f, 0.01800567f, -0.00693314f, 
    -0.01182263f, -0.01907978f, -0.03893684f, 0.02287438f, -0.03479026f, 0.01680195f, 0.00488711f, 0.00038380f, 
    0.01646145f, -0.03885413f, 0.01749840f, -0.03536378f, 0.03928963f, -0.01779847f, 0.01903286f, -0.01274540f, 
    -0.04600336f, -0.03114335f, -0.05152227f, -0.03404882f, 0.01092697f, -0.04645734f, 0.00681311f, 0.03259941f, 
    -0.04458159f, -0.03723817f, 0.02021755f, -0.00126707f, 0.00972691f, -0.04987207f, 0.01865258f, -0.02970543f, 
    -0.04087132f, 0.03167372f, -0.02180417f, -0.06041655f, -0.03227259f, 0.00539440f, -0.01578320f, -0.03269305f, 
    -0.02634825f, -0.00504612f, 0.01215424f, -0.03477364f, 0.01281815f, 0.00394085f, -0.05347634f, -0.03598844f, 
    0.02662512f, -0.00323966f, 0.03419280f, -0.04142131f, -0.02906499f, -0.01028887f, 0.02954629f, -0.00390063f, 
    -0.02454561f, -0.05906061f, -0.02108061f, -0.01473565f, -0.03018332f, -0.06437626f, -0.04071789f, -0.01465320f, 
    -0.03155442f, 0.01399721f, -0.04193440f, -0.02341109f, 0.01137018f, -0.03514145f, -0.05093201f, 0.01473183f, 
    -0.02518553f, -0.04963118f, -0.01852794f, -0.03977345f, -0.01597931f, -0.02940672f, -0.02634623f, -0.02757054f, 
    0.03049959f, 0.01663236f, -0.02971146f, -0.02536558f, 0.02578164f, -0.02167503f, 0.02372666f, -0.06174836f, 
    0.01810593f, 0.01691793f, -0.02472037f, -0.01658416f, -0.00593102f, 0.02052487f, -0.00509313f, 0.01554573f, 
    -0.05841931f, 0.01757087f, 0.03060893f, -0.05014010f, 0.00277810f, 0.01197336f, -0.03977371f, -0.01152299f, 
    0.01955182f, 0.02890977f, 0.03941952f, -0.02097452f, -0.05965323f, 0.03036949f, -0.00506741f, -0.00267115f, 
    -0.01851029f, 0.03846255f, 0.03300808f, 0.01564500f, -0.01737625f, -0.00432064f, -0.04894152f, 0.02456891f, 
    0.00307599f, -0.02244332f, -0.02937195f, -0.00832739f, 0.02092335f, -0.05267204f, 0.01161555f, -0.00588876f, 
    0.00324464f, -0.02322709f, -0.02481130f, -0.05239556f, 0.02574995f, -0.05859182f, 0.01928681f, -0.05265893f, 
    -0.04974666f, 0.01234908f, 0.00489749f, -0.01067520f, -0.01819965f, 0.01742483f, -0.02884973f, -0.01199645f, 
    -0.05067961f, 0.00168406f, -0.00953710f, -0.05327043f, 0.00232554f, -0.02167193f, -0.02251854f, 0.01967224f, 
    -0.03005893f, -0.04648897f, 0.01684747f, -0.02026673f, -0.05082639f, -0.04265362f, 0.00359307f, -0.04167468f, 
    -0.04816901f, 0.01520755f, -0.03796709f, -0.04980892f, -0.01585763f, -0.03496797f, -0.00308984f, -0.02174453f, 
    0.02178976f, 0.00209232f, -0.02679670f, -0.00115138f, -0.04140209f, 0.02736722f, -0.04681154f, 0.02698946f, 
    0.01504063f, -0.01411362f, -0.02506392f, -0.04791024f, 0.05912356f, -0.03077259f, -0.02485241f, -0.00453532f, 
    -0.01296129f, -0.04812184f, 0.00471088f, 0.01677948f, 0.00013973f, -0.05551996f, -0.03311921f, 0.03680022f, 
    -0.02905467f, 0.02856603f, -0.01269602f, -0.01306823f, -0.00194966f, 0.02321881f, 0.03572668f, -0.03385715f, 
    -0.01180868f, -0.03740800f, 0.05043757f, -0.02136117f, -0.00951102f, -0.03782502f, -0.00486708f, -0.02046481f, 
    0.00418759f, -0.04423283f, 0.00058189f, 0.01702932f, -0.00480952f, 0.01027597f, 0.03696958f, 0.01403281f, 
    0.00862239f, -0.02449003f, 0.00314546f, 0.01131748f, 0.00010831f, -0.03693924f, -0.01241754f, 0.00611134f, 
    -0.05014854f, 0.03556136f, -0.00398934f, 0.00414180f, -0.02810229f, -0.02391064f, -0.03763316f, -0.01106968f, 
    -0.01594418f, 0.01855614f, -0.05382667f, -0.04515286f, -0.03333794f, 0.00418304f, 0.02878098f, 0.02514931f, 
    -0.03017080f, 0.02931916f, 0.01691474f, -0.04801146f, -0.00757951f, 0.03523936f, 0.03419093f, 0.00262267f, 
    -0.02017448f, -0.00113626f, 0.03032199f, 0.03952667f, -0.02664958f, -0.04676370f, 0.03548725f, 0.02074886f, 
    0.00267121f, -0.03091547f, -0.03904863f, 0.02142636f, 0.03431513f, -0.02096696f, 0.03401140f, -0.00268549f, 
    -0.03336468f, 0.02127529f, 0.00155363f, 0.03371146f, -0.00846958f, -0.02271334f, -0.03826261f, -0.04448661f, 
    0.00258999f, -0.02518311f, 0.02310304f, -0.01089757f, -0.00136185f, 0.00439372f, 0.02032875f, -0.04690021f, 
    -0.03508954f, -0.03241774f, 0.03473513f, 0.00907088f, 0.02398009f, 0.03913329f, 0.00416359f, 0.00449197f, 
    -0.04826654f, -0.03601444f, 0.00471820f, -0.05197503f, -0.05372065f, 0.01015813f, 0.01370427f, -0.03753828f, 
    -0.04676527f, -0.05108235f, -0.00388098f, -0.01244787f, 0.02704120f, -0.02958438f, -0.04399621f, -0.00711592f, 
    -0.00203340f, -0.04087082f, 0.03965794f, -0.03807847f, 0.01699805f, 0.03727370f, 0.00070946f, -0.03666221f, 
    -0.02427158f, -0.05395924f, -0.02048283f, 0.00998958f, -0.04447810f, -0.04678974f, -0.01353116f, -0.00162392f, 
    -0.01951233f, 0.02404650f, -0.00038399f, 0.02054297f, 0.01934426f, 0.01101513f, 0.00514262f, -0.03230708f, 
    0.03416150f, 0.02152762f, 0.03982596f, 0.00979126f, 0.02485941f, 0.00482369f, 0.02420202f, -0.03997285f, 
    0.05679121f, -0.00635933f, -0.00855516f, 0.00022684f, -0.03038199f, -0.01343775f, -0.00334118f, 0.01630787f, 
    0.02636800f, 0.04599800f, 0.02727141f, -0.02127827f, -0.04226494f, 0.01996304f, 0.01559064f, 0.00864015f, 
    0.03604573f, -0.04675938f, 0.04161821f, 0.00231837f, -0.04499329f, 0.00842916f, 0.03207273f, -0.00399690f, 
    -0.00608827f, -0.00076248f, 0.02694922f, 0.01219138f, -0.01447044f, 0.02765496f, 0.04265967f, -0.05597004f, 
    0.02361094f, -0.02365491f, -0.01964482f, -0.03701811f, 0.03767760f, 0.05195694f, 0.04174443f, 0.00292210f, 
    0.03254727f, 0.01559377f, 0.03782732f, -0.00851105f, -0.00865947f, 0.02012340f, 0.03810130f, -0.04157585f, 
    -0.02970919f, -0.02717777f, 0.00879745f, 0.01080118f, 0.00526413f, -0.00058035f, -0.00177863f, 0.03238943f, 
    0.04400088f, -0.03637038f, -0.02113929f, -0.04157418f, 0.03622779f, -0.01707888f, 0.04137745f, -0.03139213f, 
    0.03729466f, 0.04436032f, -0.04179297f, -0.01307860f, -0.03387997f, 0.04816074f, 0.04427039f, -0.03131231f, 
    0.00642239f, -0.05732721f, -0.00784610f, -0.03796317f, 0.04088224f, 0.02265362f, 0.03828350f, 0.01694318f, 
    -0.00723051f, -0.01082562f, -0.03528025f, -0.01964493f, -0.05137794f, -0.04186967f, -0.01845637f, -0.02875982f, 
    0.03056265f, 0.05179267f, -0.01595575f, 0.00750948f, -0.00455047f, 0.02816549f, -0.03495532f, 0.00485754f, 
    -0.04514696f, 0.02335556f, 0.04765870f, -0.05093284f, -0.03911960f, -0.00454523f, -0.03944919f, 0.00623801f, 
    0.01526969f, 0.02312259f, -0.03733344f, -0.01719612f, -0.01615302f, 0.01942854f, 0.00134456f, 0.01267405f, 
    -0.05303836f, -0.05402421f, -0.02715355f, -0.03750441f, -0.03482461f, 0.04517745f, 0.02586067f, 0.01116213f, 
    -0.00259896f, 0.00155350f, 0.00124046f, 0.00263109f, -0.05561034f, 0.00761042f, 0.03846408f, -0.02193761f, 
    0.02359808f, 0.03350953f, 0.00839532f, -0.02025651f, -0.05062788f, -0.01756587f, 0.00159544f, -0.04128370f, 
    0.02436814f, -0.05569201f, -0.03729071f, -0.03608116f, -0.00600345f, 0.02889685f, 0.00382470f, -0.05568238f, 
    0.02552545f, -0.02001583f, 0.05620242f, -0.04738418f, -0.01920416f, 0.01586410f, -0.03189247f, 0.04178276f, 
    -0.04581286f, -0.03424855f, -0.01148059f, -0.00585649f, 0.04112795f, -0.00396778f, -0.00371363f, -0.02230613f, 
    0.01729289f, -0.02325241f, -0.01989448f, -0.05070528f, 0.02040902f, 0.04048434f, 0.00428306f, 0.02691127f, 
    -0.02542892f, -0.02922181f, 0.00098288f, -0.01723136f, -0.01018215f, 0.01874639f, 0.04386271f, 0.02169516f, 
    0.01948936f, 0.02969131f, -0.03208277f, 0.04030463f, -0.02677500f, 0.01514062f, 0.00328248f, 0.00644903f, 
    -0.05250203f, 0.04360026f, -0.05397651f, -0.01549765f, 0.03902994f, -0.02829633f, 0.03486085f, -0.03096519f, 
    -0.04521388f, 0.02794787f, -0.05502587f, -0.01260606f, -0.03586837f, 0.03095876f, -0.00538123f, 0.02032313f, 
    -0.04324030f, -0.04914200f, -0.02126791f, -0.02774107f, -0.02501768f, 0.02999698f, -0.04271974f, -0.00956695f, 
    -0.00986009f, 0.03191033f, -0.02798989f, 0.00581301f, 0.03316698f, 0.03785770f, -0.04325695f, -0.01325378f, 
    -0.00525681f, 0.02156110f, -0.00224629f, -0.04886658f, 0.01155352f, -0.02380414f, -0.01039715f, 0.00243353f, 
    0.02007129f, -0.00944136f, 0.02034730f, 0.00892307f, 0.02348528f, -0.04336508f, 0.02569926f, 0.00754683f, 
    0.04109789f, 0.03039062f, -0.05723875f, 0.03405765f, 0.00084226f, 0.03272472f, -0.00836791f, -0.03345646f, 
    0.00335642f, 0.01381800f, -0.01476993f, 0.03899513f, -0.02222596f, -0.03830042f, 0.04203122f, 0.04228928f, 
    -0.00676960f, 0.00876821f, -0.03301874f, -0.00053423f, -0.05542875f, 0.01667443f, -0.04853027f, 0.03527144f, 
    0.00386245f, 0.00435620f, 0.03866397f, 0.01703264f, -0.03734461f, -0.03008236f, -0.03144700f, -0.04628706f, 
    -0.00680457f, 0.01853431f, -0.04925311f, -0.02899178f, -0.03263430f, -0.01366256f, 0.02754006f, 0.01771331f, 
    0.04311716f, -0.02338237f, -0.01055339f, -0.00301514f, -0.03552026f, -0.01403600f, -0.04924718f, -0.03737778f, 
    0.00521672f, -0.04934239f, -0.05337925f, -0.02825977f, -0.05007429f, -0.05595807f, -0.00994155f, 0.02190973f, 
    0.03348059f, -0.01127995f, -0.04185930f, 0.02709414f, 0.03553559f, -0.02853600f, -0.01336034f, 0.04209486f, 
    0.04391242f, 0.03737349f, 0.04283805f, 0.01725828f, -0.03782735f, 0.00380771f, -0.01527411f, 0.00583733f, 
    -0.04867761f, 0.03052408f, 0.00104018f, -0.05147719f, -0.01517659f, -0.03258624f, 0.00187164f, 0.04275803f, 
    0.02077411f, -0.04666429f, -0.05398606f, 0.02428273f, -0.02271368f, 0.00058984f, 0.03316917f, -0.05123848f, 
    -0.00425928f, 0.02454401f, 0.03585900f, -0.00008360f, -0.03042054f, 0.00777143f, -0.05706988f, 0.03371755f, 
    0.02490133f, -0.03330016f, 0.00590341f, 0.04421508f, 0.00503949f, -0.00770891f, -0.01691988f, 0.02019441f, 
    0.04671267f, -0.03153889f, -0.03606140f, -0.00309177f, 0.03739761f, 0.03950441f, -0.05458022f, 0.01866889f, 
    -0.00046933f, -0.02316227f, -0.02293421f, 0.03729274f, 0.03872751f, -0.04396371f, -0.03891107f, -0.04391830f, 
    -0.00090761f, -0.00770448f, -0.02910559f, -0.03318504f, 0.03356554f, -0.04516101f, 0.00240564f, 0.00261130f, 
    0.03115628f, -0.00407032f, -0.05152659f, -0.04859642f, -0.05885619f, 0.00592998f, 0.02997214f, -0.01898903f, 
    -0.00031829f, 0.01119007f, -0.04565500f, -0.00769148f, -0.04189060f, -0.03812883f, 0.03088237f, 0.03079273f, 
    0.03148098f, 0.02386435f, -0.00225685f, -0.03778405f, -0.01412679f, -0.02738911f, -0.02107019f, -0.00070289f, 
    -0.00259099f, -0.01867387f, -0.04175838f, 0.03574165f, -0.04629704f, 0.02323154f, -0.03792141f, 0.03606064f, 
    0.01694245f, 0.00359415f, -0.03429059f, 0.03413378f, -0.02668010f, -0.00547402f, -0.03091992f, -0.01785250f, 
    0.02543657f, -0.00039163f, -0.01377552f, -0.01287585f, -0.02487782f, 0.02243202f, 0.04038276f, 0.03219116f, 
    -0.04584514f, -0.00150857f, -0.04773632f, 0.00871763f, -0.02931498f, -0.03643807f, -0.01601719f, -0.03716228f, 
    0.01788914f, -0.05820014f, -0.01566916f, 0.02712933f, 0.04564174f, 0.02240309f, 0.00079367f, -0.02348717f, 
    -0.03863582f, 0.00765375f, -0.00114660f, 0.00280989f, 0.01823456f, -0.05227450f, -0.04699612f, -0.04212729f, 
    -0.00010578f, -0.04741379f, -0.03885210f, 0.00811430f, 0.03737457f, -0.05448861f, -0.04119745f, -0.00071718f, 
    0.03274585f, -0.01832065f, -0.03403741f, 0.02622894f, -0.05430586f, -0.04746792f, -0.00234460f, 0.00613131f, 
    -0.04525030f, -0.04153980f, 0.00353782f, -0.00068953f, -0.05007108f, 0.00731685f, -0.05135044f, -0.05033505f, 
    0.02552447f, 0.00979779f, -0.00845128f, 0.01070340f, -0.01923398f, 0.00856901f, -0.03471587f, 0.04128287f, 
    0.00253982f, 0.04209504f, -0.02478685f, -0.02069577f, 0.03086895f, 0.01372474f, 0.01705905f, -0.04164336f, 
    0.02091913f, -0.00990161f, -0.00445523f, -0.02589390f, -0.00712062f, -0.01359360f, -0.04589558f, -0.04630329f, 
    -0.01650379f, -0.03321956f, 0.02250481f, -0.02791869f, -0.00165287f, -0.00573922f, 0.02478047f, 0.02497152f, 
    -0.01469415f, -0.04645053f, 0.03013154f, 0.00623485f, -0.03274267f, 0.03986031f, -0.01883815f, -0.00649001f, 
    -0.00990894f, -0.03643256f, 0.02267452f, 0.04095770f, 0.01956710f, -0.04121957f, 0.00014881f, -0.01517349f, 
    -0.02195832f, -0.01651458f, 0.01032912f, -0.02531096f, -0.05389933f, 0.03248417f, -0.02170528f, -0.00308794f, 
    -0.02995745f, -0.02959043f, 0.00667081f, -0.05714909f, 0.03428415f, -0.00658487f, -0.01991519f, 0.03126833f, 
    -0.01172185f, -0.02191339f, 0.03409163f, 0.03508871f, 0.02475014f, 0.00380172f, 0.00628786f, 0.01018988f, 
    0.02193229f, -0.01285452f, 0.01438232f, 0.02519759f, -0.00018362f, 0.04496263f, 0.03186571f, -0.00690234f, 
    0.03103285f, -0.03799378f, -0.04575398f, -0.04138327f, 0.02781075f, 0.00987891f, -0.00416382f, -0.02162941f, 
    0.00254784f, -0.00296688f, 0.02749754f, 0.00743919f, 0.00490033f, 0.00446415f, -0.01673858f, 0.03761045f, 
    -0.03737127f, 0.04330680f, -0.03675704f, -0.04216416f, -0.04112324f, 0.01603904f, 0.03870801f, -0.04465789f, 
    -0.03083708f, 0.00588172f, -0.01316825f, -0.03494303f, 0.04193554f, 0.02203599f, -0.00268348f, 0.00789221f, 
    -0.03526974f, -0.04368121f, -0.03047863f, -0.04348525f, 0.01994419f, 0.00127894f, 0.03838031f, -0.04428231f, 
    0.01080284f, 0.02603422f, -0.01729022f, -0.05340178f, -0.02444697f, -0.01773057f, -0.03838118f, 0.04192476f, 
    -0.02045817f, -0.02338532f, 0.04206983f, -0.01860686f, -0.03211878f, -0.01932332f, 0.01797856f, -0.01318166f, 
    -0.02593939f, 0.02327312f, 0.01565119f, 0.01298586f, -0.05329805f, -0.01218719f, -0.02610301f, -0.01932986f, 
    -0.04665823f, -0.04099765f, 0.17647801f, 0.15752056f, 0.13559797f, -0.04968340f, 0.01106538f, 0.00460666f, 
    0.02182428f, 0.18565004f, 0.01347627f, -0.14788353f, -0.24970973f, 0.01328780f, -0.06311648f, 0.10863907f, 
    -0.09458429f, 0.03331323f, -0.03616113f, -0.07300422f, 0.06849405f, -0.05358315f, 0.06548639f, -0.02977309f, 
    -0.09772418f, 0.06393393f, -0.12316684f, 0.00869813f, 0.04548496f, 0.11584648f, -0.01704926f, -0.11030397f, 
    0.02295488f, -0.02479198f, -0.04000847f, 0.05952037f, -0.23027469f, 0.12150681f, -0.31024009f, -0.01501180f, 
    0.05230381f, 0.12391248f, 0.04100769f, 0.11083981f, -0.07590697f, 0.03401743f, -0.04672036f, 0.03155735f, 
    -0.10094908f, -0.26012304f, 0.04703235f, 0.19364296f, -0.05064115f, 0.02768322f, -0.08668768f, -0.02575692f, 
    0.03772731f, 0.01573266f, 0.03512778f, 0.00488266f, 0.05920240f, -0.02219457f, -0.01161417f, 0.06185776f, 
    -0.00762520f, -0.01351018f, -0.13411377f, 0.02888061f, -0.00482231f, -0.04433946f, 0.06428413f, 0.06911311f, 
    0.08226003f, -0.08269874f, 0.13157244f, 0.05497058f, 0.01180191f, 0.00400890f, -0.13533795f, -0.04194270f, 
    0.09042214f, 0.07643229f, -0.07547114f, -0.03165835f, 0.28440171f, -0.15993895f, -0.03760124f, 0.26369274f, 
    0.05804624f, -0.02264703f, 0.01937336f, 0.16089152f, -0.00773958f, -0.17308965f, -0.01167784f, -0.00923584f, 
    0.34227094f, -0.17658170f, -0.03598427f, 0.23712148f, -0.03369216f, 0.07321509f, 0.10048077f, -0.05930086f, 
    -0.06171511f, 0.16948782f, 0.01427059f, 0.16509973f, -0.07793327f, 0.35760862f, -0.12300660f, 0.05104517f, 
    0.04723553f, -0.05559506f, -0.01057357f, 0.07845002f, 0.01197191f, 0.01111439f, -0.01827976f, 0.05138484f, 
    0.33222252f, 0.13465333f, 0.05996933f, 0.05858031f, -0.04590489f, 0.03455886f, -0.03372125f, -0.04877375f, 
    0.01977836f, -0.02830504f, 0.03702939f, 0.06285717f, -0.00360447f, 0.09403869f, -0.04208558f, -0.07413521f, 
    -0.13680959f, 0.06576686f, -0.17706747f, 0.05189573f, -0.02396041f, -0.05224344f, 0.05912570f, -0.02244650f, 
    0.07433349f, -0.12397609f, 0.00035601f, 0.11407142f, -0.07207938f, -0.03997803f, -0.05363129f, -0.02683833f, 
    0.01880895f, -0.07613848f, 0.00691644f, -0.01280624f, 0.21327618f, -0.07057577f, -0.10542426f, -0.26788312f, 
    0.03757169f, -0.05932186f, 0.21004802f, 0.09754190f, -0.16456831f, 0.11598468f, -0.00228516f, -0.10203481f, 
    -0.42636552f, 0.06395445f, 0.10286943f, -0.03857040f, -0.07611507f, 0.01068904f, -0.12828717f, -0.02433939f, 
    0.00759700f, -0.00643386f, 0.05096948f, -0.12297823f, 0.22528532f, 0.21452464f, 0.10335709f, 0.08165608f, 
    -0.06650876f, -0.04578077f, 0.07179897f, 0.09489404f, 0.13190275f, 0.12088726f, 0.01701465f, -0.02712100f, 
    0.21557237f, -0.02954372f, 0.12836878f, -0.00355761f, -0.09587170f, -0.06128775f, 0.22734949f, 0.06850595f, 
    -0.04218473f, -0.04708554f, -0.11289338f, 0.03975169f, 0.13211182f, -0.04344755f, -0.05665366f, -0.00334834f, 
    0.10809783f, 0.04368973f, -0.05450431f, -0.09770123f, 0.06920476f, 0.00886979f, -0.05048326f, 0.06716914f, 
    0.13636801f, -0.05439085f, -0.05112633f, 0.13647851f, 0.03886568f, -0.09098680f, 0.09824221f, 0.06750344f, 
    -0.02473585f, 0.00496547f, 0.03507465f, 0.02251725f, 0.05738638f, -0.19126646f, -0.18260610f, 0.21582806f, 
    0.00208871f, 0.03191857f, -0.04496250f, 0.02653900f, -0.13019660f, -0.00426494f, 0.02162765f, -0.06259214f, 
    0.10330316f, -0.07755888f, -0.05499713f, 0.08009455f, 0.08719523f, 0.04113065f, 0.08268534f, -0.06813952f, 
    -0.04798476f, 0.04742694f, 0.02751461f, -0.05240632f, 0.05403661f, -0.15623879f, 0.06222268f, -0.18891735f, 
    -0.04448526f, 0.05253076f, -0.14247879f, 0.03092992f, 0.00004506f, -0.01943586f, -0.17466351f, -0.02804558f, 
    -0.24502149f, -0.02360039f, -0.08489967f, -0.10418320f, 0.06643832f, 0.20982005f, 0.03977067f, 0.04588825f, 
    0.04609855f, 0.05753855f, 0.13464665f, -0.05474504f, -0.03619524f, 0.05745714f, 0.06624497f, 0.15385824f, 
    0.16605540f, -0.08839367f, 0.09522350f, 0.02432600f, -0.05773239f, 0.01484412f, -0.08976421f, 0.15546657f, 
    0.20528086f, 0.20671727f, 0.15830114f, 0.15419549f, -0.11967240f, 0.14100347f, 0.08747324f, 0.03403893f, 
    0.04869425f, 0.00649419f, -0.05989424f, 0.04435141f, 0.47548550f, -0.18611948f, -0.09511703f, 0.15277906f, 
    -0.06860313f, 0.07729716f, 0.03615919f, 0.01848774f, -0.01946793f, 0.05092248f, -0.03266138f, 0.00893881f, 
    0.06098396f, -0.13209726f, 0.01607232f, 0.12427085f, -0.03381599f, -0.03042744f, -0.03266420f, -0.03329478f, 
    0.03813203f, 0.01019762f, -0.06828606f, -0.03546835f, 0.41151479f, 0.22693914f, -0.05520742f, 0.18779071f, 
    0.00890882f, -0.08868393f, 0.10834400f, -0.01166511f, -0.04658665f, 0.01478826f, -0.00638362f, 0.00104045f, 
    0.07891843f, 0.33117351f, 0.11622052f, -0.09451655f, -0.10044393f, 0.07984658f, -0.05305528f, 0.10129007f, 
    0.17261960f, -0.01893671f, 0.03694845f, 0.04546127f, 0.01230829f, 0.19533315f, -0.08713421f, -0.18667786f, 
    -0.06358456f, 0.06119722f, -0.04986525f, 0.01703449f, 0.06511999f, -0.04467564f, -0.14336054f, -0.05302188f, 
    0.07882464f, -0.05864323f, 0.08143257f, -0.01590422f, -0.03390586f, 0.01249453f, 0.00708180f, -0.08561412f, 
    -0.05494041f, 0.05899065f, 0.04534461f, 0.05524085f, -0.04307867f, 0.03617770f, -0.10585450f, 0.14084280f, 
    -0.04285782f, 0.09122091f, 0.00455206f, -0.14496395f, -0.14341356f, 0.00897128f, -0.00869758f, 0.04865878f, 
    0.02928587f, 0.15226547f, 0.36252034f, -0.20629846f, 0.04271329f, -0.00556409f, 0.01287496f, -0.00413264f, 
    0.02956891f, 0.02793525f, 0.11739746f, 0.06040258f, -0.39965227f, -0.07199275f, 0.23731220f, 0.04113511f, 
    -0.12763885f, 0.14408994f, -0.05402828f, 0.06400080f, -0.01127752f, 0.00054122f, -0.03306154f, 0.01065504f, 
    0.11233243f, -0.22003539f, -0.02722464f, 0.21540022f, -0.11127659f, 0.05393562f, 0.00190951f, -0.16003981f, 
    0.12056798f, -0.03879425f, 0.02819412f, -0.01707451f, -0.22402108f, 0.17846398f, -0.05609740f, -0.02777201f, 
    0.07862251f, 0.02048975f, 0.01847865f, 0.07068425f, 0.08207097f, 0.04620343f, 0.01113053f, -0.02832781f, 
    -0.00811956f, -0.08417857f, -0.00873666f, 0.00922647f, -0.03261152f, 0.00303803f, -0.03881744f, -0.06784108f, 
    0.05300967f, 0.04723133f, 0.12891127f, 0.07322454f, -0.01624073f, -0.17849511f, 0.18282440f, 0.17400189f, 
    0.00581279f, -0.06453168f, 0.06690019f, -0.10467309f, -0.00974269f, 0.09331948f, 0.12441834f, 0.11238131f, 
    -0.03268206f, -0.01089362f, 0.02488989f, 0.11653594f, -0.11630353f, 0.02785430f, 0.01665050f, 0.10291997f, 
    -0.08522744f, -0.09587093f, 0.06681841f, 0.02844677f, 0.12201153f, -0.04788210f, 0.17548653f, 0.01033013f, 
    0.01812877f, -0.05545326f, 0.05748685f, 0.07099566f, 0.09237847f, -0.02193773f, -0.02499549f, 0.16715217f, 
    -0.02303679f, 0.17491442f, -0.11639479f, 0.02665650f, 0.04403744f, 0.08412743f, 0.04587359f, -0.00253666f, 
    -0.05374261f, 0.11373398f, 0.09781929f, 0.01377329f, -0.11687519f, 0.30016848f, -0.24765359f, 0.07636521f, 
    -0.01652132f, -0.00644796f, -0.01554700f, 0.11420719f, -0.04562728f, -0.05495887f, -0.12213381f, 0.02278221f, 
    0.05434747f, -0.24616942f, -0.01613152f, 0.16928761f, 0.07761222f, 0.12463319f, 0.13764824f, -0.09158859f, 
    -0.05395981f, 0.06234422f, 0.01231624f, 0.00262625f, 0.07403116f, -0.08266366f, -0.05817462f, 0.17168579f, 
    -0.02154631f, 0.15524384f, 0.01571065f, -0.13587438f, -0.04473379f, 0.04430915f, -0.01291927f, 0.12795581f, 
    -0.38793245f, 0.08912684f, 0.09935059f, -0.09266689f, -0.05411873f, 0.00966362f, -0.08355424f, 0.11571518f, 
    -0.00259651f, 0.07174420f, 0.00898953f, 0.03417923f, -0.01393735f, -0.33996692f, 0.22858600f, -0.05683991f, 
    -0.26636836f, 0.09551895f, 0.07339186f, 0.00451425f, -0.09508739f, -0.00459272f, 0.02140709f, -0.05460108f, 
    0.07520861f, 0.23200488f, -0.08423964f, 0.03056435f, 0.09723021f, 0.02996087f, -0.01619125f, 0.03481684f, 
    -0.05444944f, 0.04035193f, 0.01827234f, 0.13341609f, 0.10823807f, -0.06755850f, -0.10853865f, 0.11315947f, 
    0.19413377f, -0.03026858f, 0.11260893f, 0.06279369f, 0.00298841f, -0.04689822f, 0.04008096f, 0.05702933f, 
    -0.04895717f, 0.05569763f, 0.01645203f, 0.21785845f, -0.05923291f, 0.00016673f, -0.02100660f, 0.12230438f, 
    0.03665467f, -0.00041920f, -0.06586047f, 0.00233760f, -0.06783826f, -0.02756889f, 0.20962100f, 0.00543018f, 
    0.00167064f, -0.04483720f, 0.10454693f, -0.00156154f, -0.04140767f, 0.07464557f, 0.06227364f, 0.08693074f, 
    0.24920492f, -0.03567617f, -0.06136808f, -0.00528398f, 0.01493658f, -0.00509057f, 0.08739918f, 0.02598509f, 
    0.09935138f, 0.02265329f, 0.00124841f, 0.08032919f, -0.12372161f, -0.09797732f, -0.15909475f, 0.04845027f, 
    -0.01749595f, -0.01417341f, 0.03122411f, -0.04357573f, 0.17320132f, 0.01100553f, 0.04423539f, -0.04353241f, 
    -0.15790869f, 0.14190337f, -0.09479588f, -0.03186926f, 0.07144750f, -0.03955168f, -0.00759815f, -0.02597153f, 
    -0.14687602f, 0.02290637f, -0.03457164f, -0.01499289f, -0.21276471f, -0.02506969f, 0.05764041f, -0.15064415f, 
    0.14029582f, 0.00229157f, 0.02626717f, -0.12680089f, 0.12917103f, -0.02333887f, -0.01564106f, 0.06458781f, 
    -0.01970645f, 0.10483085f, -0.06581321f, 0.09623720f, 0.12933496f, -0.03912544f, 0.00260691f, -0.04210869f, 
    -0.01951640f, -0.00523398f, -0.06814938f, 0.02465283f, -0.10728521f, -0.06320874f, -0.05323739f, 0.10329819f, 
    0.12225783f, -0.06581343f, 0.00060631f, 0.04549723f, -0.06407715f, 0.08738324f, -0.04831001f, 0.02954761f, 
    0.14448941f, -0.01980962f, 0.10516694f, 0.06968695f, 0.18262222f, 0.01149268f, 0.11094072f, 0.07343572f, 
    -0.02665671f, 0.03260617f, 0.10342023f, 0.23750527f, -0.01113121f, 0.20156594f, 0.04466360f, 0.04035562f, 
    -0.06972169f, -0.00819557f, 0.01934266f, -0.02562243f, 0.18565676f, -0.01702424f, -0.05829498f, 0.12263475f, 
    0.19733559f, 0.23092856f, -0.02519141f, -0.11684636f, 0.03848422f, 0.06370691f, -0.01947347f, 0.11006632f, 
    -0.09262838f, 0.14148931f, 0.10992652f, 0.04129985f, -0.28149027f, 0.14636323f, -0.13464533f, 0.04212473f, 
    0.07344292f, -0.06794658f, 0.01246662f, -0.03806480f, 0.11962041f, -0.00547982f, 0.05379320f, 0.04120860f, 
    -0.34757102f, -0.32616994f, 0.18101509f, -0.03328679f, 0.09483750f, -0.02528385f, 0.04943860f, 0.04687104f, 
    0.15205726f, 0.04183299f, -0.07925793f, -0.04452251f, -0.09423688f, 0.09422293f, -0.05635179f, 0.09821868f, 
    0.03809023f, -0.04582528f, 0.04756281f, 0.06813802f, 0.09092515f, 0.03986952f, 0.04214513f, 0.03133862f, 
    -0.25786939f, -0.04985722f, 0.26123643f, -0.11547112f, 0.02312475f, 0.01319910f, 0.02180168f, -0.08676558f, 
    0.00104843f, -0.02988745f, -0.06607427f, -0.07626524f, -0.45098254f, -0.04900963f, -0.13595594f, 0.02328756f, 
    0.06899831f, -0.06501859f, -0.06472728f, 0.01521425f, -0.03002250f, 0.04309799f, -0.03910394f, 0.03875629f, 
    -0.08991837f, -0.05066130f, -0.40232170f, 0.21261638f, 0.01487168f, -0.09939969f, 0.08202671f, 0.01668905f, 
    -0.09803732f, 0.28114417f, 0.12107249f, 0.01943834f, 0.33736664f, -0.11529586f, -0.13963759f, 0.12758826f, 
    -0.01512332f, -0.00501749f, -0.01420970f, 0.07783071f, 0.16565269f, 0.02845737f, 0.19459729f, 0.04547411f, 
    -0.32920858f, 0.11541564f, -0.02591388f, -0.00846396f, 0.07894981f, -0.05671457f, -0.11922809f, 0.08483965f, 
    0.07346195f, 0.06509536f, 0.14664581f, 0.02301465f, -0.02464830f, -0.29604632f, 0.00555680f, -0.28262177f, 
    0.05374188f, 0.00037167f, -0.24578533f, 0.02001177f, -0.10358158f, -0.04544440f, -0.06428697f, 0.04880227f, 
    0.07245494f, -0.01768464f, 0.13309631f, -0.09871728f, -0.09060392f, 0.07223839f, -0.06912929f, 0.05200806f, 
    0.06151064f, 0.11349108f, 0.05164881f, 0.03362612f, -0.17011018f, 0.00250338f, -0.10415676f, -0.16059093f, 
    -0.06314950f, 0.00399969f, 0.08253610f, 0.00719597f, 0.01767786f, 0.03009263f, -0.04367774f, 0.16114248f, 
    -0.16586728f, 0.14137541f, -0.05562975f, -0.04082080f, 0.21600933f, 0.16256750f, 0.03723350f, 0.04034893f, 
    0.16475531f, 0.10576525f, -0.05081865f, 0.01819856f, 0.14307176f, -0.08246596f, 0.02981517f, 0.14891623f, 
    0.03630590f, 0.09298849f, -0.04353742f, 0.02498362f, -0.01717283f, -0.00187940f, -0.01077752f, -0.02985064f, 
    0.05547345f, 0.11437952f, 0.00719932f, -0.08874710f, 0.10671172f, 0.02962618f, 0.10432009f, -0.09776302f, 
    0.11705536f, -0.00576729f, -0.02493669f, -0.01340585f, -0.42045146f, -0.04723645f, -0.05923469f, -0.00893515f, 
    0.05616324f, -0.01598026f, 0.12467103f, -0.00330859f, 0.02273767f, 0.08142573f, 0.03349412f, -0.05671239f, 
    -0.08924837f, 0.07870943f, -0.07219830f, -0.08618306f, -0.04130456f, -0.03464969f, -0.10912983f, 0.05038802f, 
    0.12989064f, 0.08458620f, -0.23036255f, -0.01788637f, -0.22902220f, 0.14123465f, -0.19825420f, -0.29696074f, 
    0.14989379f, -0.04479456f, -0.03745728f, 0.20634308f, 0.07078031f, -0.04275126f, -0.01626820f, 0.11023869f, 
    0.28860852f, -0.15806839f, -0.00145564f, 0.19877079f, 0.22604620f, 0.07692072f, -0.04182691f, -0.15109637f, 
    0.01312147f, 0.00726662f, 0.03643734f, 0.06929760f, -0.25318578f, 0.41736776f, -0.24936150f, 0.11570635f, 
    0.12670849f, 0.04997569f, 0.11359658f, -0.11138660f, 0.00889324f, -0.05423063f, 0.00708969f, 0.08866064f, 
    0.11552844f, -0.03194261f, -0.00644623f, -0.30615315f, 0.03835873f, -0.03408027f, -0.08751364f, 0.03324482f, 
    0.05902325f, 0.12516570f, -0.11475143f, 0.09943780f, -0.21930097f, -0.17994955f, 0.04163918f, 0.17272368f, 
    -0.10761613f, -0.02309637f, 0.04514940f, 0.09978618f, 0.07877247f, 0.17537352f, -0.03210531f, 0.08751311f, 
    0.07082383f, -0.03879029f, -0.15351605f, 0.04177342f, -0.01329449f, 0.07661914f, 0.01654123f, 0.08667290f, 
    0.14654621f, -0.04137532f, 0.09123603f, 0.17696494f, 0.09403240f, -0.08971678f, -0.08391431f, 0.06317085f, 
    0.07750818f, -0.02217316f, -0.14842495f, -0.00417070f, -0.01960797f, -0.02354477f, 0.09732369f, -0.01348116f, 
    -0.23676303f, 0.00562159f, 0.06699283f, 0.29969004f, -0.04634443f, -0.09600755f, -0.11960061f, 0.00994389f, 
    -0.16091187f, -0.04946353f, -0.00712131f, -0.07447475f, 0.12339342f, 0.01303445f, -0.16402011f, -0.00111622f, 
    0.30546725f, -0.03699744f, -0.04702711f, -0.00967784f, 0.00663643f, 0.00345966f, -0.01913270f, 0.11546037f, 
    0.02255873f, -0.02469763f, 0.00984962f, 0.05559316f, 0.29912117f, -0.15216275f, -0.10037271f, -0.10888261f, 
    0.03262343f, 0.09396750f, 0.12059201f, -0.06551305f, 0.09245182f, 0.12254895f, 0.03232454f, 0.07749405f, 
    0.02719684f, 0.03870771f, -0.18602552f, 0.05614585f, -0.14519820f, -0.00443059f, 0.01329220f, -0.04733329f, 
    0.15422077f, -0.09484991f, 0.21981651f, -0.18576507f, 0.17204171f, 0.09350931f, -0.06641452f, 0.17124407f, 
    0.08032098f, 0.10433703f, 0.06219420f, 0.00689915f, -0.34443331f, -0.04376210f, 0.09745631f, 0.08202549f, 
    0.06116480f, -0.09069384f, -0.02801594f, 0.01334307f, 0.08754365f, -0.20214042f, -0.01420100f, -0.01775564f, 
    -0.02397947f, 0.12314107f, 0.07589858f, -0.10802364f, -0.18654072f, 0.04426207f, 0.02270791f, -0.00790125f, 
    -0.00643893f, -0.12733096f, 0.06067368f, 0.05395237f, 0.21429448f, -0.07079260f, 0.15005864f, -0.18280315f, 
    0.08025013f, 0.02473494f, 0.01981617f, -0.09168310f, 0.06693100f, -0.12926088f, 0.08526673f, -0.02214133f, 
    0.08733834f, 0.06624036f, 0.14302199f, 0.02332267f, 0.12782463f, 0.07413159f, 0.20404118f, 0.02173738f, 
    0.08949480f, -0.17860624f, 0.02870145f, -0.00878653f, -0.06543618f, -0.12799180f, 0.11634592f, 0.24038883f, 
    -0.01328710f, 0.04655522f, 0.02743432f, 0.06065514f, 0.00810825f, -0.02048452f, -0.04291686f, -0.06366630f, 
    0.30803591f, 0.26672590f, -0.12682678f, -0.14344828f, -0.12205877f, -0.04910827f, 0.02535650f, 0.07164693f, 
    0.00333085f, 0.05872094f, 0.02127989f, 0.04815425f, -0.33247289f, -0.18638757f, -0.12989271f, -0.16458707f, 
    -0.18066736f, -0.06869747f, 0.07881007f, -0.07121926f, 0.10907053f, -0.01745462f, -0.08495795f, 0.00080588f, 
    0.51254171f, 0.01629514f, 0.02799957f, 0.07922179f, 0.05086218f, 0.18728679f, 0.04247274f, -0.08118358f, 
    -0.00836187f, 0.00574129f, 0.04983997f, 0.02236427f, -0.28040791f, 0.18193865f, -0.02820669f, -0.00409757f, 
    0.18015924f, 0.06218614f, 0.00013002f, -0.00023585f, 0.00087951f, 0.01178197f, 0.16717754f, -0.05453564f, 
    -0.01432554f, 0.02270729f, 0.00322828f, 0.00159605f, 0.02278602f, -0.02873105f, -0.05853138f, 0.00825782f, 
    -0.01487032f, 0.01518019f, 0.01107522f, -0.00902149f, -0.00897332f, -0.04328966f, -0.05833377f, 0.01207882f, 
    -0.01792997f, 0.00629964f, -0.02981905f, 0.00414760f, -0.02050016f, -0.02386517f, -0.02126894f, -0.05113940f, 
    -0.05582946f, -0.00718260f, -0.05017079f, -0.02030995f, -0.01063255f, -0.04251318f, 0.03860983f, -0.05125378f, 
    -0.04240954f, -0.03214397f, 0.02007170f, 0.01501571f, -0.04644089f, 0.02983609f, 0.02887071f, -0.02168632f, 
    -0.01242619f, -0.04823638f, 0.02381800f, -0.01759350f, -0.01050319f, 0.02626399f, -0.05170695f, 0.03698200f, 
    -0.05036678f, -0.04518491f, 0.03895996f, -0.05273126f, 0.03946951f, -0.04938208f, -0.04577446f, -0.02050987f, 
    0.03567242f, -0.03886283f, -0.01993212f, -0.02516622f, -0.00399847f, 0.00106188f, 0.03321737f, -0.03792286f, 
    0.03131093f, 0.02234202f, 0.00086260f, -0.04693792f, 0.03552267f, 0.01514001f, 0.00921013f, 0.04388620f, 
    -0.02915037f, 0.01522780f, 0.00419601f, 0.02439996f, -0.00929188f, -0.04427611f, 0.02968483f, -0.00712636f, 
    -0.05969682f, 0.02059127f, 0.03177825f, 0.03066903f, -0.03055288f, 0.00907852f, -0.03126477f, 0.01539230f, 
    -0.06094367f, 0.00104747f, 0.03969150f, -0.02491554f, -0.03487270f, -0.04474336f, 0.03683309f, 0.03109893f, 
    0.02985374f, 0.04670099f, 0.01567319f, 0.03870483f, -0.03447269f, 0.03952427f, 0.04010598f, -0.01024909f, 
    -0.03531311f, -0.01948588f, -0.01449914f, -0.02972798f, 0.03643380f, -0.00585262f, -0.00036470f, 0.00360830f, 
    -0.03401309f, 0.01440489f, -0.02135057f, 0.01806678f, -0.01061701f, -0.04825489f, -0.02199181f, -0.00715196f, 
    -0.02580812f, -0.01153019f, -0.05367154f, -0.01935422f, 0.00719904f, -0.02272573f, 0.04100780f, -0.05831559f, 
    0.01658679f, -0.00166536f, -0.00611051f, 0.00407279f, -0.04689060f, -0.01302946f, -0.01662952f, 0.03173538f, 
    -0.01883117f, -0.04009514f, 0.02474648f, 0.00320038f, -0.04471353f, -0.01843928f, -0.00802067f, -0.00154913f, 
    -0.04527158f, 0.01114133f, -0.00981953f, -0.01302121f, 0.01699593f, 0.03026854f, -0.01879087f, 0.02311457f, 
    -0.03656696f, 0.01816188f, -0.01291466f, 0.00045465f, -0.01261478f, -0.00532310f, -0.00165528f, 0.01102048f, 
    -0.02466140f, 0.01902455f, 0.00961853f, -0.03077124f, -0.00563306f, -0.03316561f, 0.04024535f, -0.05393961f, 
    -0.01337408f, -0.03890593f, -0.00836772f, 0.02042881f, -0.02079470f, -0.05356667f, -0.04724432f, -0.05606969f, 
    0.03855678f, -0.03596306f, -0.06014628f, 0.01076466f, -0.05681063f, -0.02362470f, 0.03058776f, 0.03293565f, 
    -0.04782611f, 0.01590076f, -0.00704149f, -0.02346171f, -0.05542506f, 0.01461832f, -0.00520326f, 0.02555733f, 
    0.02748575f, -0.00171563f, -0.03177545f, -0.05016211f, -0.03229609f, -0.01403835f, 0.00151428f, -0.03572364f, 
    -0.03416089f, -0.00262646f, 0.00135411f, -0.02314426f, 0.03258820f, 0.01754794f, 0.04501041f, -0.03382507f, 
    0.00012694f, -0.01844421f, 0.00276789f, 0.02357257f, 0.01368524f, -0.04919615f, -0.01665308f, 0.03961766f, 
    -0.03501502f, -0.00428432f, 0.00073108f, -0.00528374f, -0.04506302f, 0.00208501f, -0.04709335f, -0.04615328f, 
    -0.01085199f, -0.00337123f, -0.00218173f, -0.05433110f, 0.04273176f, -0.01229193f, -0.02274901f, -0.02565873f, 
    -0.01016008f, -0.01367826f, -0.00402428f, 0.00662965f, 0.02289078f, -0.01858691f, -0.04689201f, 0.04062429f, 
    0.01379896f, 0.00745265f, -0.00387116f, -0.00813265f, -0.03190350f, 0.04595648f, 0.02291533f, -0.04776454f, 
    -0.00505819f, -0.04840052f, -0.00051468f, -0.00674846f, 0.00120273f, 0.02108808f, 0.01038289f, -0.04847337f, 
    -0.03434585f, 0.03065967f, -0.04781016f, 0.01659749f, -0.03232178f, 0.00229791f, -0.05319988f, 0.00957848f, 
    0.02773512f, 0.01697434f, -0.04326436f, -0.03994378f, 0.02258054f, 0.02287510f, 0.00534563f, -0.03766828f, 
    0.00083306f, 0.02880375f, -0.02613435f, -0.04668487f, 0.03444279f, 0.03684938f, 0.00047182f, 0.03866513f, 
    -0.00254698f, -0.04629923f, 0.01437130f, 0.02364187f, 0.01377217f, 0.04398080f, -0.01027151f, 0.03271924f, 
    -0.04821530f, -0.00888483f, -0.05256891f, -0.02212569f, 0.00526375f, 0.00548988f, 0.01889176f, -0.01526948f, 
    -0.03314697f, -0.00933668f, 0.03291382f, 0.02178971f, 0.03941628f, 0.04128007f, 0.02970141f, -0.00906622f, 
    0.03877243f, -0.04701975f, -0.03976143f, -0.03167539f, 0.02490081f, -0.04928512f, -0.04378784f, -0.01649203f, 
    -0.00821597f, 0.01598243f, -0.02968847f, -0.02233539f, -0.05814138f, 0.01879730f, 0.02570868f, -0.03119651f, 
    -0.05307933f, 0.01362703f, 0.00940140f, -0.01585063f, 0.02465987f, -0.03963389f, -0.05949522f, -0.03384002f, 
    0.01714631f, -0.04793301f, 0.00225439f, -0.00698098f, -0.02352161f, -0.02964382f, -0.02144385f, -0.02267556f, 
    -0.01408545f, -0.01869712f, -0.00059083f, 0.00152842f, 0.02845625f, -0.01998546f, -0.05008818f, -0.00758660f, 
    -0.05290515f, 0.02451372f, -0.02264729f, -0.03544375f, -0.04988237f, 0.02464865f, -0.00349710f, -0.05891683f, 
    -0.00116846f, 0.02875180f, -0.00185570f, -0.05069879f, -0.05907958f, 0.00769233f, -0.01253677f, 0.02081818f, 
    -0.00039080f, -0.01380071f, 0.00968409f, -0.03525272f, -0.02941444f, 0.03530750f, 0.03803336f, -0.04870525f, 
    0.03267420f, -0.03803113f, -0.03103296f, -0.05356979f, 0.03557725f, -0.02792662f, -0.00605574f, -0.03215934f, 
    -0.00095612f, 0.02710366f, 0.00076108f, 0.01315558f, -0.03653355f, -0.05412195f, -0.04320190f, 0.03089276f, 
    0.05964827f, 0.00043773f, 0.13762985f, 0.54628992f, -0.08930948f, -0.09452261f, -0.04100185f, 0.03780795f, 
    -0.04830037f, -0.13749370f, -0.00384167f, 0.13096637f, -0.25345123f, -0.06387950f, 0.15708642f, 0.24181196f, 
    0.00179968f, -0.10547240f, -0.05669850f, 0.08389900f, 0.01817381f, 0.02926531f, 0.11034711f, 0.06717376f, 
    0.11289930f, 0.06550989f, 0.12084121f, -0.13812296f, 0.11983747f, 0.04135811f, 0.02322572f, 0.06651116f, 
    -0.07830010f, 0.06683419f, 0.03058986f, -0.11281137f, 0.11041743f, 0.03591450f, 0.24813858f, -0.21418260f, 
    -0.02619362f, 0.07655576f, -0.02208328f, 0.06629073f, 0.07474612f, 0.07701551f, 0.09533885f, 0.03507700f, 
    0.08964903f, -0.12093575f, -0.06730337f, 0.06160067f, -0.03165531f, 0.08648935f, 0.07035085f, 0.05302363f, 
    0.05133101f, 0.02839257f, 0.02052367f, -0.02260386f, 0.00707806f, 0.07014048f, 0.34212625f, -0.12263095f, 
    0.09412491f, -0.10009971f, 0.13718510f, -0.03814590f, -0.02707629f, 0.06088280f, -0.02158117f, 0.08694423f, 
    0.03947981f, 0.09406195f, 0.03381750f, -0.03247976f, 0.09441432f, -0.04301821f, 0.07551623f, 0.02135859f, 
    0.09019060f, 0.03541325f, 0.03775319f, 0.05573944f, 0.07960975f, 0.12155064f, -0.02684643f, 0.08738117f, 
    -0.08278222f, 0.04422351f, 0.12588900f, -0.00631357f, 0.08526640f, 0.05908778f, -0.02421205f, 0.11096495f, 
    -0.02265166f, -0.16914621f, 0.11950912f, -0.17519374f, -0.14722502f, -0.09415846f, -0.00707035f, 0.11283848f, 
    0.05373764f, -0.19007120f, -0.10515509f, -0.06340040f, -0.62790710f, -0.23415157f, 0.08395654f, -0.16733781f, 
    0.14229013f, 0.01746744f, 0.16616073f, 0.02180963f, 0.05872256f, -0.02654851f, 0.04004401f, 0.11190609f, 
    0.09468935f, 0.04366288f, -0.07208653f, -0.05195868f, -0.03174745f, 0.02020766f, 0.01160131f, 0.18782425f, 
    0.08386875f, 0.01515322f, -0.04834009f, -0.12305339f, 0.16249591f, 0.06980158f, 0.23320118f, -0.11309472f, 
    0.20421359f, 0.10060355f, 0.06948653f, -0.01810157f, -0.02085112f, 0.11991507f, 0.01931529f, 0.16976333f, 
    -0.12648602f, -0.12933795f, 0.04272767f, 0.30354998f, -0.04813681f, -0.01312855f, 0.03337666f, 0.01257380f, 
    0.03739882f, -0.02766914f, 0.07125965f, 0.09943301f, 0.08411178f, 0.02501406f, -0.31925234f, 0.33918557f, 
    -0.09466568f, 0.07128615f, -0.01942709f, -0.15079869f, 0.18328039f, 0.03083858f, -0.02743094f, 0.04623832f, 
    -0.12121848f, -0.27499855f, 0.19665675f, -0.23516214f, 0.01132687f, 0.01851930f, 0.00261567f, 0.03597816f, 
    -0.03695256f, 0.00847050f, 0.05787165f, 0.12242051f, 0.12415391f, 0.08071522f, -0.02953215f, 0.01488579f, 
    -0.04713991f, 0.11697910f, 0.02137909f, -0.06813077f, -0.23200105f, 0.02626939f, -0.05464423f, 0.02393306f, 
    0.24285014f, 0.15029366f, -0.14028709f, -0.02323222f, 0.04271914f, -0.02282617f, -0.03123922f, 0.00115151f, 
    0.20055354f, 0.04695346f, 0.17418970f, 0.08728773f, 0.22865431f, 0.06460075f, -0.15790811f, 0.38477907f, 
    0.01114336f, 0.04510433f, -0.11972710f, 0.04486621f, 0.01564642f, 0.04469843f, 0.01294896f, -0.08479484f, 
    -0.37942117f, -0.12489039f, -0.12812540f, 0.04595981f, -0.03221095f, -0.08068697f, 0.11980939f, -0.18086834f, 
    0.07792050f, 0.01150202f, 0.01001204f, 0.02943680f, -0.16549000f, -0.06099692f, 0.05879933f, -0.24244238f, 
    0.04984848f, 0.08838687f, 0.00258527f, 0.12878352f, 0.05742325f, 0.05132917f, 0.08205093f, -0.03921515f, 
    0.22611630f, -0.08656260f, 0.23392929f, -0.14924818f, -0.07104918f, -0.05008389f, 0.11144848f, 0.04710801f, 
    0.04719820f, 0.01427792f, 0.04677330f, -0.03924588f, -0.07393519f, 0.01124630f, -0.19472936f, 0.05621225f, 
    0.05608064f, 0.06828351f, -0.09858005f, 0.07493496f, 0.09661033f, 0.06066613f, 0.15332262f, -0.00467449f, 
    -0.08588482f, -0.08562071f, 0.09906046f, -0.14980012f, 0.02840858f, -0.08762717f, -0.09825826f, 0.21859811f, 
    -0.07808478f, 0.01210045f, -0.00413325f, 0.03428559f, 0.23037107f, -0.00205742f, -0.23546433f, 0.25604486f, 
    -0.03914700f, -0.02272687f, 0.00829562f, 0.07373936f, 0.00211891f, -0.13445036f, 0.00860368f, 0.01880709f, 
    0.10452905f, -0.02755749f, -0.11367906f, 0.12354007f, 0.01733102f, -0.10293043f, -0.03652658f, -0.05419134f, 
    -0.02529042f, 0.03143093f, 0.00175575f, -0.11403120f, 0.22751261f, -0.08159310f, 0.01842415f, -0.16312353f, 
    0.02661530f, 0.05658150f, 0.01833919f, -0.05661363f, 0.02225501f, 0.01277590f, -0.02082059f, 0.04456932f, 
    0.12055627f, 0.08737633f, 0.23645678f, 0.00576119f, 0.11083969f, 0.08056623f, -0.01568270f, 0.16867192f, 
    0.00346888f, -0.13979270f, 0.21156789f, 0.05325519f, -0.45526308f, 0.02390880f, -0.07772649f, -0.10583197f, 
    -0.06234653f, 0.03551179f, 0.02300430f, 0.00133947f, -0.09693775f, -0.00641257f, 0.05798442f, -0.03032210f, 
    0.13880859f, 0.22928682f, 0.03901752f, 0.00059144f, 0.07754295f, 0.01070553f, -0.13271359f, -0.05219327f, 
    -0.10933176f, 0.07221025f, 0.07524101f, -0.05050556f, 0.29984841f, 0.11518659f, 0.09325056f, -0.12521732f, 
    0.02045668f, -0.00127695f, 0.10751161f, 0.13476840f, 0.02533982f, 0.14361072f, -0.05616783f, -0.03305294f, 
    -0.10417059f, -0.14562269f, -0.06751290f, 0.27840045f, 0.04321204f, 0.04883435f, -0.03154955f, -0.04080635f, 
    0.05733046f, 0.01812883f, 0.05264437f, -0.01421483f, -0.43713439f, 0.31006315f, 0.19222496f, -0.19586922f, 
    0.12757634f, -0.04221506f, 0.05795951f, 0.10257716f, -0.00493263f, 0.05290024f, -0.03224099f, -0.05937915f, 
    -0.03100071f, -0.21771917f, -0.14316607f, 0.11928573f, 0.06998631f, 0.08266073f, 0.09123320f, 0.02648109f, 
    0.03798246f, -0.03044744f, 0.03989091f, -0.01461671f, 0.01714759f, 0.19758824f, 0.14864530f, -0.07419649f, 
    -0.04633235f, -0.06770988f, -0.00818966f, 0.13240738f, 0.20816031f, 0.01638819f, 0.04882041f, 0.09044842f, 
    -0.18876824f, 0.00359390f, -0.04809944f, -0.09911474f, 0.20256896f, 0.04157964f, 0.25572696f, -0.11751706f, 
    -0.02000857f, -0.00416476f, -0.09353293f, 0.15826954f, 0.07399513f, -0.11074851f, 0.09777402f, -0.11355358f, 
    -0.01254805f, 0.08772262f, 0.06202914f, -0.06037578f, -0.04939171f, -0.17457877f, -0.05357418f, 0.06198989f, 
    -0.03291909f, -0.09550992f, 0.22791870f, -0.20457049f, -0.03751174f, 0.03454652f, 0.00625138f, -0.00345207f, 
    0.05405217f, -0.04760507f, -0.04743268f, -0.08926214f, -0.11190829f, 0.10930368f, 0.00127822f, 0.14958583f, 
    0.06348427f, 0.07081948f, 0.12721083f, 0.04714276f, -0.11666214f, 0.07651860f, 0.08876538f, 0.07255011f, 
    -0.04743094f, -0.06092946f, 0.02048393f, -0.06151727f, 0.23094450f, -0.18055464f, -0.01974360f, 0.12761804f, 
    0.11157261f, -0.00779363f, -0.05822982f, 0.19822364f, 0.08847312f, 0.29615745f, 0.08829455f, -0.08667327f, 
    -0.12066606f, 0.00183969f, 0.01078853f, 0.18587814f, -0.07421211f, -0.00903154f, 0.07893585f, -0.05680421f, 
    0.24660520f, -0.06999864f, -0.09701473f, -0.02035658f, -0.00547684f, -0.02604812f, 0.07215150f, 0.00419364f, 
    -0.13804685f, -0.08946554f, 0.03922357f, 0.21522413f, -0.20759687f, -0.24530149f, -0.28242180f, 0.09998085f, 
    0.14612490f, 0.09789913f, 0.04764933f, -0.01228562f, 0.08720337f, 0.07347925f, 0.12591696f, 0.16718112f, 
    0.37617078f, 0.25155652f, -0.03045546f, -0.09370296f, 0.08168112f, -0.00864550f, 0.02110254f, -0.00929852f, 
    0.01629264f, 0.06499006f, 0.13670322f, 0.04797764f, -0.25413039f, 0.21761425f, 0.13555455f, -0.15902966f, 
    0.04493858f, -0.05781472f, -0.06101051f, -0.14417112f, 0.04983422f, -0.10397300f, 0.21425189f, 0.25674307f, 
    0.16883719f, 0.12372372f, 0.07765411f, -0.35117891f, 0.01264978f, -0.10271338f, -0.10535551f, 0.00725908f, 
    0.04097486f, -0.01514475f, 0.10771813f, -0.03566375f, 0.15404968f, -0.15128885f, -0.22598462f, 0.23069327f, 
    0.10285688f, 0.04176299f, 0.01386257f, -0.11017670f, -0.05767733f, 0.07844345f, 0.01875341f, -0.02087183f, 
    -0.16059354f, -0.17327246f, 0.17394681f, -0.07891499f, 0.01529906f, 0.11688339f, -0.04875267f, -0.01582717f, 
    -0.15984623f, 0.08326297f, -0.04189101f, 0.03477958f, 0.13992386f, 0.02264092f, -0.05115888f, -0.23522025f, 
    -0.17324857f, -0.11489023f, 0.00146721f, -0.01439833f, -0.08781457f, 0.06609322f, 0.06028355f, 0.02600092f, 
    0.39730549f, 0.03411538f, -0.13362488f, -0.00545332f, -0.00538105f, -0.11953847f, 0.16931444f, 0.07632484f, 
    0.07801539f, 0.01609544f, -0.13614452f, 0.04933174f, 0.24729696f, -0.07464252f, -0.24685274f, 0.21198553f, 
    0.10527012f, 0.08980755f, -0.01234525f, -0.02401974f, -0.06758993f, 0.02972430f, -0.13782056f, -0.06834149f, 
    -0.06904442f, -0.44774505f, -0.01920132f, -0.00440030f, 0.02460034f, -0.10109467f, 0.13104591f, 0.08478903f, 
    -0.00865828f, -0.02912038f, 0.13711426f, 0.00080280f, 0.20443386f, 0.00875506f, 0.09479846f, -0.16925551f, 
    0.02886912f, -0.06237532f, 0.01262691f, 0.10910976f, -0.04643441f, -0.02496975f, 0.02786340f, -0.00771988f, 
    0.21343596f, -0.03385410f, -0.07840744f, -0.25245106f, 0.11427849f, -0.04005278f, 0.04614156f, -0.03952555f, 
    0.07725710f, -0.01998642f, 0.10017061f, 0.13425599f, -0.05715199f, -0.20955713f, -0.22095659f, 0.09680501f, 
    0.13883916f, 0.13689777f, -0.12560594f, 0.00769664f, 0.01910240f, -0.05087609f, -0.11880333f, -0.17921026f, 
    -0.17091803f, -0.07359955f, 0.20182851f, -0.04726663f, 0.02421677f, 0.10414001f, 0.08838727f, 0.10373743f, 
    0.04956915f, -0.03460348f, 0.17403950f, 0.00933669f, -0.13569233f, -0.20834209f, -0.01351153f, 0.10454676f, 
    -0.07957562f, 0.09457999f, 0.00215768f, -0.09403572f, 0.07057889f, 0.08041541f, -0.09365254f, 0.36486021f, 
    0.15393125f, 0.09041070f, -0.01666762f, 0.09093194f, -0.20580223f, 0.14459011f, 0.13013068f, -0.09536626f, 
    0.02429338f, -0.16661191f, -0.05133810f, -0.11197794f, 0.12199393f, 0.13522623f, 0.04747169f, -0.09885836f, 
    0.04000514f, 0.11495990f, 0.02322030f, 0.10761162f, -0.05498787f, 0.03558376f, -0.00142444f, 0.02431012f, 
    0.11274174f, -0.00694842f, -0.25022089f, 0.08470245f, 0.19640639f, 0.10670735f, -0.03091451f, 0.00213533f, 
    -0.04702736f, -0.04275934f, -0.03034790f, -0.08077387f, 0.05667055f, -0.20494361f, -0.01788873f, 0.09468463f, 
    0.09351705f, 0.07278217f, -0.01906989f, -0.05468882f, 0.02559710f, 0.17952226f, -0.07739553f, 0.14084898f, 
    -0.11248431f, -0.06241894f, 0.06333402f, 0.10565763f, 0.03948499f, 0.00072059f, -0.02049333f, -0.06830526f, 
    0.01918088f, -0.05759468f, 0.13707721f, -0.06564938f, 0.04174547f, -0.01738449f, -0.14385037f, -0.14680007f, 
    -0.08695465f, -0.01795093f, -0.05233515f, -0.05076669f, -0.00056889f, -0.08555951f, 0.11809205f, 0.22763647f, 
    0.18717797f, 0.06498612f, 0.11742327f, 0.16418134f, -0.01278577f, -0.00560190f, -0.04652889f, -0.01447733f, 
    0.00689811f, -0.00370183f, 0.13905621f, 0.04807979f, -0.34679249f, 0.05330366f, -0.07170299f, 0.10264071f, 
    0.00265884f, 0.03468268f, 0.03406316f, 0.03370193f, 0.08864092f, 0.04359181f, 0.02152586f, 0.02430285f, 
    -0.01444142f, -0.00282016f, -0.03728027f, 0.02801459f, -0.03659522f, 0.03672193f, 0.00963132f, -0.03811966f, 
    0.02577357f, 0.03639249f, -0.02921016f, 0.02167730f, 0.04259320f, -0.05170911f, 0.00233675f, -0.00081975f, 
    -0.02392911f, 0.00420287f, 0.00403613f, -0.04324213f, -0.04191841f, -0.00722384f, -0.04440760f, 0.00137279f, 
    0.00221294f, 0.04389184f, 0.02102724f, 0.01997613f, -0.03729156f, -0.03583243f, -0.01262347f, 0.03745831f, 
    0.01121957f, 0.03199052f, -0.00348905f, 0.02029455f, -0.00052997f, 0.00255625f, 0.00765239f, 0.02415557f, 
    -0.04178758f, -0.03171401f, -0.00870742f, -0.01101176f, -0.00540822f, -0.03358726f, -0.00090307f, -0.03540662f, 
    0.00698055f, 0.02758723f, -0.01685404f, 0.02586567f, -0.01457728f, -0.02033390f, 0.01322215f, -0.03461245f, 
    -0.04680223f, -0.03440916f, -0.01262759f, -0.01104053f, -0.04910085f, -0.00645074f, -0.01963709f, 0.03878567f, 
    0.02531037f, 0.02162120f, -0.05670165f, -0.03682739f, 0.02379135f, -0.03817522f, -0.01598029f, 0.03908531f, 
    -0.02597221f, -0.05264305f, -0.02153131f, -0.00139139f, -0.03986618f, 0.01846519f, 0.01016932f, 0.01243942f, 
    -0.03571124f, 0.00075748f, 0.04204211f, 0.03182914f, -0.03337982f, 0.01740012f, 0.03487137f, 0.01868473f, 
    0.00412251f, -0.03116836f, 0.02977436f, 0.01208394f, 0.01681944f, -0.04176751f, -0.05431120f, -0.03847103f, 
    -0.05846953f, 0.03708907f, -0.03947988f, 0.03346652f, -0.03672476f, 0.03128823f, -0.04842942f, -0.02033931f, 
    0.03512972f, -0.04057312f, -0.04502682f, -0.01475533f, 0.02077305f, -0.00436171f, 0.00709853f, -0.02796650f, 
    -0.02415575f, 0.03431641f, -0.02369355f, -0.00313252f, -0.03621941f, 0.03613312f, -0.04768366f, -0.01176900f, 
    -0.04691461f, 0.03713522f, 0.02574191f, -0.01192838f, 0.01085195f, -0.03884168f, -0.02089811f, 0.02883060f, 
    0.00919733f, -0.03467660f, 0.03278916f, -0.04896400f, 0.03776143f, -0.05781580f, 0.00862751f, -0.04881749f, 
    0.00022942f, -0.03809554f, 0.01826029f, -0.03981961f, 0.01984750f, -0.05591467f, 0.02562493f, -0.02954996f, 
    -0.00115594f, 0.02410965f, -0.01129824f, 0.00467901f, 0.03632911f, -0.02084839f, 0.00234402f, 0.00439461f, 
    -0.04375625f, 0.00307421f, -0.01384345f, -0.03485866f, 0.02846976f, 0.00918834f, -0.01689409f, -0.01389399f, 
    -0.03724936f, 0.02340535f, -0.04702169f, -0.00179792f, 0.01582994f, -0.03994793f, 0.03375388f, 0.02467033f, 
    -0.01126842f, -0.04882073f, -0.02924966f, 0.02592150f, -0.01550393f, 0.02972499f, 0.01151081f, -0.03058424f, 
    -0.02942995f, -0.04898950f, -0.02578213f, 0.00382258f, -0.02119018f, -0.01817673f, 0.03023434f, 0.03896203f, 
    0.03762354f, -0.04703023f, -0.02095814f, 0.01959857f, -0.04491275f, 0.01884852f, -0.05158771f, 0.04400596f, 
    0.01869488f, 0.00963692f, 0.01919930f, -0.00288728f, -0.04107199f, 0.02333380f, -0.00694380f, 0.01140510f, 
    -0.05288646f, 0.04051941f, 0.02680052f, -0.05185789f, -0.03955823f, 0.00155353f, -0.03636581f, -0.01856541f, 
    0.00055847f, 0.04025959f, 0.03339982f, -0.03672470f, 0.01285459f, -0.04895409f, -0.03848669f, -0.04004112f, 
    0.03299625f, -0.05206401f, 0.01815178f, 0.00537466f, 0.04181357f, -0.01669899f, -0.00080511f, 0.02823937f, 
    0.04127026f, -0.02836951f, 0.00132642f, -0.03354637f, 0.04004429f, -0.00407729f, 0.03328932f, -0.00427055f, 
    -0.00058540f, -0.01429018f, 0.02661549f, -0.00963846f, -0.01617134f, 0.02864896f, -0.04215819f, -0.03413006f, 
    0.03959605f, -0.01480387f, 0.02843546f, 0.02760670f, -0.02288451f, -0.03177221f, 0.00199470f, 0.01549344f, 
    0.01698505f, -0.03279787f, 0.00194690f, -0.00561777f, 0.03086453f, 0.00016286f, 0.03307894f, 0.00929212f, 
    -0.00831562f, -0.01907359f, 0.00242198f, -0.05602662f, -0.02617872f, -0.00393472f, 0.03198097f, -0.02277816f, 
    0.04587267f, 0.02626810f, 0.01752168f, -0.04245923f, -0.04507626f, -0.05377462f, 0.04250530f, 0.03584771f, 
    0.02152379f, 0.00070582f, -0.04121480f, -0.04622809f, -0.02884527f, -0.05345519f, -0.03055447f, 0.00660135f, 
    -0.04631583f, -0.02564249f, -0.01360594f, 0.03130071f, -0.03429985f, -0.01069519f, -0.02031682f, -0.01835928f, 
    -0.03678227f, -0.00003370f, -0.03697515f, -0.05496075f, -0.03004096f, -0.04509559f, 0.03341769f, 0.03307167f, 
    0.00148018f, 0.00067396f, -0.04040240f, 0.03965611f, 0.03794286f, -0.02590268f, -0.02515669f, -0.00416015f, 
    -0.03375081f, -0.04250157f, -0.05566011f, -0.05605839f, 0.03933671f, -0.04411760f, -0.00868396f, 0.00073318f, 
    -0.00037394f, -0.03265922f, -0.00986962f, -0.00788899f, -0.00851661f, 0.01913589f, -0.03089679f, -0.05659072f, 
    0.00820173f, -0.02281417f, 0.03293844f, -0.01081167f, -0.04056889f, 0.03319999f, -0.00395778f, -0.00797493f, 
    -0.01611235f, 0.02298458f, -0.02942550f, -0.04453882f, 0.04097061f, 0.00882487f, 0.01565384f, 0.00175571f, 
    0.02609034f, -0.01201980f, -0.04279273f, -0.03011346f, -0.05673632f, -0.03883123f, -0.00754297f, -0.03957605f, 
    -0.03873698f, 0.03147489f, -0.05412388f, 0.03695021f, -0.04433691f, 0.00241749f, -0.01072672f, -0.02525967f, 
    0.04419640f, -0.00786793f, 0.00471635f, 0.02974425f, -0.04271445f, 0.01862805f, 0.00964513f, 0.02723310f, 
    -0.01879327f, -0.00249424f, 0.03760697f, 0.03469178f, 0.03137120f, -0.05085922f, 0.01112557f, -0.03083123f, 
    0.02576215f, -0.00033784f, 0.01544774f, -0.00458267f, 0.03276623f, -0.04709532f, -0.05739302f, -0.01809610f, 
    -0.00109223f, -0.03761986f, -0.04438378f, -0.03323734f, 0.01626656f, 0.01145325f, -0.04358493f, -0.02270197f, 
    -0.00300195f, 0.03065808f, -0.11016050f, 0.23327006f, 0.04852786f, -0.00645833f, 0.02399253f, -0.00809416f, 
    -0.12098701f, -0.10019448f, -0.03922980f, 0.03602311f, 0.39055976f, 0.26402178f, 0.02712126f, -0.04480897f, 
    0.08739467f, 0.02247635f, 0.12660699f, -0.00343043f, -0.04044938f, 0.04506895f, -0.10381883f, 0.02831350f, 
    -0.22106031f, 0.23959324f, -0.00016447f, -0.05111070f, 0.06308529f, 0.00049624f, 0.10883259f, 0.08118103f, 
    -0.04557895f, 0.07049097f, -0.13245656f, 0.07846018f, 0.32038343f, 0.14822613f, 0.16313826f, 0.22611922f, 
    -0.08800182f, 0.14330322f, 0.08422283f, -0.10461101f, -0.03595263f, -0.03331625f, 0.11192994f, 0.03731021f, 
    0.01702956f, 0.39615896f, 0.03946991f, 0.01007706f, 0.05493861f, 0.00042902f, 0.13490230f, 0.05040970f, 
    -0.01895161f, -0.09586530f, -0.05986600f, -0.03073434f, 0.05443113f, 0.21946707f, -0.06725971f, -0.00227538f, 
    0.01070564f, 0.17199248f, -0.11011512f, 0.14101321f, -0.02453827f, -0.01947930f, -0.00543060f, -0.09881935f, 
    0.04574136f, 0.03099061f, 0.00438027f, -0.10390575f, 0.10291424f, -0.08415257f, 0.01314303f, 0.01694126f, 
    -0.04230767f, 0.09802977f, 0.10636085f, 0.03520019f, -0.09282205f, 0.25714675f, -0.11333986f, -0.08127633f, 
    -0.01690830f, 0.01204631f, -0.01840394f, -0.05985002f, 0.09197251f, 0.21691518f, 0.14793576f, -0.09492739f, 
    -0.02126558f, -0.12344032f, 0.13239671f, -0.32599565f, 0.03446385f, -0.09647757f, -0.13945292f, 0.08828145f, 
    0.11068958f, 0.01008684f, 0.14803556f, -0.05291827f, 0.16561867f, -0.32331699f, 0.02145878f, -0.15109769f, 
    0.09910984f, 0.05102085f, -0.10171079f, 0.07320222f, 0.02495009f, 0.07154419f, 0.18300404f, -0.04007400f, 
    -0.15326986f, 0.01295868f, -0.09674777f, -0.11851040f, -0.00600041f, -0.00994799f, 0.04645595f, -0.03293235f, 
    -0.03527893f, -0.17169939f, 0.04859566f, 0.03311039f, -0.01032970f, 0.00444989f, 0.12290746f, 0.07810547f, 
    0.00504194f, -0.12187387f, 0.04011008f, -0.02587610f, -0.00716543f, 0.08771964f, 0.06523116f, -0.07530943f, 
    0.35384181f, 0.16254592f, 0.07779206f, -0.02050417f, 0.00929011f, -0.04708115f, 0.05802226f, -0.03711767f, 
    -0.04131193f, 0.10749222f, -0.01602395f, 0.01048899f, -0.12026028f, 0.03289567f, -0.02173479f, 0.21042904f, 
    0.20315038f, 0.00043480f, 0.01327395f, 0.06000485f, 0.09571484f, -0.02924654f, 0.02037771f, 0.03656764f, 
    -0.05743422f, -0.14857273f, 0.09559831f, -0.06964877f, -0.07061074f, 0.12858433f, 0.05936569f, 0.01610686f, 
    0.02638734f, -0.01922353f, -0.00109834f, -0.03797702f, -0.08363939f, -0.09854911f, -0.21991083f, -0.01857711f, 
    -0.13316210f, -0.04748047f, -0.17798348f, -0.11494061f, -0.06866249f, -0.02709785f, -0.04655621f, -0.00689003f, 
    -0.03368320f, -0.13093075f, -0.11626893f, -0.12624504f, 0.08002155f, 0.01086457f, -0.06402130f, -0.03656313f, 
    0.08759037f, 0.14985915f, 0.06534611f, 0.08356484f, 0.07166353f, -0.06033134f, 0.11391077f, 0.05146115f, 
    -0.00905753f, 0.05282345f, 0.12690395f, 0.01125996f, -0.02442666f, -0.08220208f, -0.07442108f, -0.08366685f, 
    -0.32875651f, -0.07311949f, -0.08846213f, -0.08229231f, 0.12237771f, -0.03806727f, 0.04648352f, 0.13935740f, 
    -0.02768025f, -0.01761489f, -0.08944284f, 0.05079952f, 0.06003191f, 0.23909560f, 0.26387718f, -0.20157118f, 
    -0.03739451f, 0.16285732f, 0.02452788f, 0.02963918f, -0.08834431f, -0.03538831f, 0.05266112f, 0.13321076f, 
    -0.00272755f, -0.08157804f, 0.07977294f, -0.14603792f, 0.00502873f, 0.09673820f, -0.02872043f, 0.08709252f, 
    0.21297169f, 0.05030222f, 0.11671185f, 0.14904888f, -0.04397271f, -0.21909790f, -0.10180201f, 0.15979914f, 
    -0.04070612f, -0.10120718f, 0.13198817f, 0.16919667f, -0.03364095f, 0.00059401f, 0.00421434f, -0.10874742f, 
    0.06821062f, -0.01527331f, 0.02014853f, -0.05443168f, -0.09289474f, 0.10382932f, 0.09362826f, 0.01996974f, 
    0.02310489f, 0.08932199f, 0.19962427f, 0.06207462f, 0.03413888f, -0.08672477f, 0.03085371f, -0.08489561f, 
    -0.06439641f, 0.13201301f, -0.08527271f, -0.05891074f, 0.08672902f, -0.01277107f, 0.07497660f, 0.01765217f, 
    -0.17166778f, -0.25526670f, -0.19158076f, 0.05116725f, -0.05610396f, -0.10076412f, -0.17326349f, -0.08374545f, 
    0.07888390f, -0.02028035f, -0.07296827f, -0.26422545f, -0.17847821f, 0.02778752f, 0.02054828f, -0.16556752f, 
    0.17632304f, 0.00387008f, -0.05790317f, 0.03760556f, 0.01076758f, 0.09994708f, -0.01805664f, -0.02164664f, 
    -0.12633894f, -0.11215927f, 0.12427045f, 0.02900044f, -0.06647880f, 0.10215753f, -0.07405888f, -0.03780628f, 
    -0.04042568f, -0.06266642f, -0.06226391f, 0.02123114f, 0.00577210f, -0.26891321f, -0.08982050f, -0.26914954f, 
    0.02996948f, 0.08333039f, 0.01803681f, 0.09064632f, -0.02161036f, -0.00055620f, -0.10528997f, 0.05144691f, 
    -0.08390026f, -0.07906354f, -0.10781297f, 0.08452073f, 0.04467267f, -0.03904573f, 0.03833079f, -0.01159255f, 
    -0.12486627f, -0.17030488f, 0.01774202f, -0.05065849f, 0.07265543f, -0.10757980f, -0.01837750f, -0.04434206f, 
    0.02546219f, 0.10642920f, -0.19605659f, 0.01409330f, -0.20052288f, 0.04814365f, 0.18872097f, 0.09083193f, 
    0.12626305f, 0.04801223f, -0.05761272f, 0.11488657f, 0.05586408f, 0.00826581f, 0.03749124f, -0.01271386f, 
    0.00739329f, -0.02298637f, 0.10115349f, 0.03171515f, 0.42850178f, 0.11465370f, 0.06838834f, 0.04802301f, 
    0.03519514f, 0.14782262f, 0.08066893f, 0.10205965f, 0.13730729f, 0.03761246f, 0.02604318f, -0.01140743f, 
    -0.11814805f, 0.03001944f, 0.13869897f, -0.04567099f, -0.06683723f, -0.10149936f, -0.04196547f, -0.08899240f, 
    -0.05280868f, -0.13309991f, 0.09044766f, 0.09206953f, 0.17251317f, 0.14180905f, 0.28486753f, -0.12144518f, 
    -0.02254849f, 0.04626658f, 0.07896319f, -0.01436100f, -0.09295371f, 0.06359169f, -0.09567700f, 0.00285059f, 
    0.11542594f, 0.05765295f, -0.07959273f, 0.09140547f, -0.14162630f, 0.08600965f, 0.05071616f, -0.12526813f, 
    0.04464640f, -0.03561021f, -0.03087284f, 0.01407677f, -0.06310444f, 0.29176426f, 0.11054040f, 0.05527853f, 
    -0.03255089f, 0.15287708f, 0.17385928f, -0.09856135f, 0.02651273f, 0.00996460f, 0.00333061f, 0.01743954f, 
    -0.15114275f, 0.08802163f, -0.05106175f, -0.14946836f, 0.01899266f, 0.06826825f, 0.09289173f, -0.07356142f, 
    0.06864244f, -0.11022826f, -0.07289644f, -0.10161559f, 0.09668287f, -0.05465085f, -0.00908937f, 0.07938942f, 
    -0.00167267f, 0.00834795f, -0.06250987f, -0.05096459f, 0.03194832f, 0.09870517f, 0.10915446f, -0.06622002f, 
    -0.11799750f, -0.08738544f, -0.07260944f, -0.05681489f, -0.19408022f, -0.12643909f, 0.01175863f, 0.07463415f, 
    -0.23744956f, -0.15640041f, 0.11434008f, 0.02735322f, 0.03479090f, 0.38252777f, -0.00663500f, -0.15298901f, 
    -0.04845125f, -0.02782729f, 0.01850829f, -0.00584811f, 0.02309345f, 0.06219532f, 0.02448617f, 0.02829669f, 
    0.00159696f, 0.14141914f, -0.03164500f, -0.13359955f, 0.05857312f, 0.04718376f, 0.01572675f, 0.15497471f, 
    -0.13641168f, 0.01452417f, 0.07810026f, -0.06897727f, 0.07012998f, 0.05616293f, -0.08728494f, 0.07326882f, 
    0.05675239f, 0.12984923f, -0.06120397f, 0.22228837f, 0.11882484f, 0.03675285f, 0.08342002f, 0.17739098f, 
    0.02251427f, -0.09331940f, 0.11704611f, 0.12670660f, 0.06564718f, 0.08754145f, 0.19041197f, -0.10665815f, 
    -0.05546867f, -0.09592094f, 0.09683617f, -0.01093086f, 0.16767083f, 0.12353932f, -0.00985658f, 0.24433231f, 
    -0.04274303f, -0.04579923f, 0.13810137f, -0.14474545f, -0.04404859f, 0.00517326f, 0.06073049f, -0.02080348f, 
    -0.18652442f, 0.43049860f, 0.05095637f, -0.27618572f, -0.04446264f, -0.01494701f, 0.02483569f, 0.13010994f, 
    -0.01046779f, 0.11611219f, -0.06106384f, 0.01985733f, 0.11316100f, -0.14318439f, 0.20920619f, 0.02575106f, 
    -0.10316597f, -0.00828901f, 0.10203452f, 0.03035610f, -0.15182276f, 0.03787132f, 0.05131701f, -0.04169482f, 
    -0.02661743f, 0.16426636f, -0.08786730f, 0.07223667f, 0.04605371f, 0.10118753f, 0.03698311f, -0.02409681f, 
    -0.07197227f, -0.01968993f, 0.10393921f, 0.02022033f, 0.22448000f, 0.03828189f, -0.16122022f, 0.15270004f, 
    0.18525405f, 0.00950805f, -0.01814688f, -0.01080053f, 0.00330333f, -0.08018779f, 0.03925007f, 0.03572548f, 
    -0.07186517f, 0.06514773f, 0.07708208f, 0.06646315f, 0.03242446f, 0.01001835f, -0.13716622f, 0.05544750f, 
    0.09467357f, 0.11044578f, -0.02721995f, 0.00681577f, -0.29556882f, -0.11879047f, 0.19655220f, 0.04819962f, 
    -0.01809321f, 0.01654275f, 0.24082227f, -0.10759084f, -0.04306438f, 0.05221544f, -0.07424410f, -0.03862336f, 
    0.33558580f, 0.05450754f, -0.05420473f, 0.08823760f, 0.19509706f, 0.02592290f, 0.09949112f, 0.06257665f, 
    0.10954621f, -0.03478837f, -0.04479095f, 0.08969721f, 0.06780460f, 0.18769427f, 0.08372467f, -0.13927908f, 
    -0.14025860f, 0.01263174f, 0.05081404f, 0.06670129f, 0.03264871f, -0.00866513f, 0.02758630f, -0.05540022f, 
    -0.00580028f, 0.31696540f, -0.02425998f, -0.19251122f, 0.01448876f, 0.13245657f, 0.06430116f, 0.05051064f, 
    -0.13348801f, 0.04023264f, -0.03288477f, 0.15030636f, -0.15260619f, -0.05764099f, 0.08708645f, 0.00051432f, 
    0.06443359f, -0.01177702f, 0.15908110f, 0.00534193f, 0.10181868f, 0.00554974f, -0.01153698f, -0.04421308f, 
    0.04958855f, 0.22260785f, -0.06863294f, 0.06994873f, 0.01067810f, 0.02735057f, 0.11775295f, 0.03690306f, 
    -0.05751243f, -0.08131975f, 0.01996713f, 0.07952269f, 0.12108362f, -0.00977834f, -0.00808511f, 0.21908464f, 
    0.09300455f, 0.09231060f, -0.12101735f, 0.01075167f, -0.08294071f, 0.22097982f, 0.01589112f, 0.08090442f, 
    0.14006537f, 0.01214162f, -0.00459703f, 0.26886660f, 0.22808349f, -0.05489103f, 0.05380705f, 0.11047175f, 
    -0.04287302f, -0.01983388f, 0.06900076f, -0.06356113f, -0.19214982f, 0.37203112f, 0.01945009f, 0.01557406f, 
    0.02021230f, 0.02105530f, -0.04960002f, 0.10777032f, -0.03338658f, 0.10654669f, -0.06876101f, 0.05306156f, 
    -0.09152676f, 0.15916982f, 0.14342140f, -0.24682742f, 0.04345896f, 0.13064331f, -0.03432767f, -0.01117637f, 
    -0.17476355f, 0.07040714f, 0.07220929f, 0.05652360f, -0.40035495f, 0.12030724f, 0.01219988f, -0.06567029f, 
    0.09341452f, 0.16080318f, -0.05220626f, 0.06182862f, 0.01974261f, 0.01266122f, -0.12731266f, 0.09427253f, 
    -0.16963136f, -0.43912619f, 0.22611117f, 0.04872217f, 0.14307860f, -0.08358836f, 0.06964004f, 0.01661008f, 
    0.00693970f, -0.04047430f, 0.02103981f, -0.10966788f, 0.07951421f, 0.07129546f, 0.00423893f, 0.11728277f, 
    0.09553808f, 0.05599911f, -0.03037417f, 0.07012215f, 0.00593119f, 0.06348796f, 0.14599478f, 0.25100034f, 
    -0.38472641f, 0.04793364f, 0.27521303f, -0.06354108f, -0.04739432f, -0.02125394f, 0.05894877f, -0.07020565f, 
    0.03567915f, -0.15559526f, 0.02648565f, -0.00414976f, 0.16414014f, -0.02844764f, -0.04783796f, -0.01142636f, 
    -0.03918879f, 0.02513826f, -0.03777397f, -0.00454227f, 0.02331502f, 0.00639720f, -0.02518554f, 0.02283040f, 
    0.03604571f, -0.17516100f, 0.34956726f, 0.41255876f, -0.11826864f, -0.01262501f, -0.03845087f, 0.00821002f, 
    -0.01199875f, -0.05383366f, -0.03885021f, 0.06732423f, -0.07612840f, 0.01857807f, 0.05699755f, 0.09391856f, 
    -0.07527329f, -0.04306228f, 0.06509031f, 0.08819325f, 0.08023367f, 0.05207016f, 0.13496985f, 0.00003974f, 
    0.24736339f, -0.00872812f, -0.03907254f, -0.01010072f, 0.00558360f, -0.04751760f, 0.10581803f, -0.09052866f, 
    -0.12289191f, -0.03650744f, 0.03438684f, 0.00946330f, -0.02742353f, -0.07456554f, 0.21168663f, -0.03372497f, 
    0.10323519f, 0.07126535f, -0.02887192f, 0.12144589f, -0.02711960f, 0.14732145f, 0.01949204f, 0.03008024f, 
    0.05818276f, -0.19007425f, -0.10471973f, -0.02695538f, -0.10089617f, -0.01035589f, -0.02599469f, -0.04525914f, 
    -0.06410075f, 0.11238238f, 0.03502344f, -0.00695236f, -0.06846441f, -0.17937849f, 0.18749276f, -0.04572883f, 
    0.07317662f, -0.20604868f, 0.06865346f, 0.05228520f, 0.04334645f, 0.10092246f, 0.00788960f, 0.15806769f, 
    0.07937858f, -0.10207774f, 0.18695393f, -0.01548167f, -0.09490537f, -0.05911246f, 0.00342239f, 0.01501822f, 
    -0.04340403f, -0.02873138f, -0.13786744f, 0.04886473f, 0.12274220f, 0.13440071f, -0.14827843f, 0.18372472f, 
    -0.03699644f, 0.06154260f, 0.09943576f, -0.04318145f, -0.03005022f, -0.00532718f, -0.05750389f, 0.14311713f, 
    0.24847592f, -0.12427467f, 0.27028596f, -0.03544734f, -0.19720142f, -0.03635433f, 0.00918726f, -0.04419842f, 
    0.01883237f, -0.00384299f, -0.15261818f, 0.02099830f, -0.45801672f, 0.00229351f, -0.00952255f, -0.06811488f, 
    0.06116302f, 0.09389389f, 0.15053989f, -0.04950813f, 0.02802068f, 0.03261768f, -0.03413742f, -0.07732940f, 
    0.11622764f, 0.21377504f, -0.03972118f, 0.10313118f, 0.09916016f, -0.11694642f, -0.11826266f, 0.08942558f, 
    0.02475037f, 0.14562045f, 0.06131311f, -0.10091450f, 0.22734585f, 0.13023189f, 0.05687063f, -0.06836406f, 
    -0.05286361f, -0.03260032f, -0.02954192f, -0.01699867f, -0.03908099f, 0.04701152f, -0.11338596f, 0.06505546f, 
    0.11893799f, -0.08445913f, 0.16992295f, 0.35430422f, -0.09434657f, -0.01468448f, 0.10835093f, -0.09666086f, 
    -0.05843553f, -0.08498473f, 0.11701985f, 0.14313790f, 0.45198941f, 0.02085727f, -0.16244999f, 0.00357014f, 
    0.05306917f, -0.10950300f, -0.05515967f, 0.05288624f, 0.12906852f, -0.07918561f, -0.04378645f, -0.05210234f, 
    -0.36834884f, -0.14712557f, 0.16362984f, 0.08306489f, 0.01253155f, -0.09500011f, -0.00012934f, -0.02994850f, 
    0.00316879f, 0.05450447f, 0.06672233f, 0.01544141f, 0.15913378f, 0.14047344f, 0.14931604f, -0.11813923f, 
    0.12310693f, 0.19881748f, 0.06387600f, -0.11180207f, -0.01590593f, 0.06417267f, -0.03437723f, 0.04123183f, 
    0.35453126f, 0.00048805f, 0.03162806f, -0.10100128f, -0.00714397f, -0.02734685f, 0.08778134f, -0.04790436f, 
    0.08616703f, -0.09923936f, 0.11265797f, 0.02293817f, 0.09009103f, 0.02130402f, -0.22594748f, 0.22774364f, 
    0.00272813f, -0.04151868f, -0.03269926f, -0.07813021f, 0.04779951f, -0.05322127f, 0.11787049f, 0.03594551f, 
    0.07465561f, -0.08220692f, -0.04397291f, -0.26892465f, -0.04079585f, 0.00864020f, 0.02840945f, -0.22459421f, 
    0.00615652f, 0.09561684f, -0.06168111f, -0.08345269f, 0.10696429f, -0.00247953f, 0.15529154f, 0.00969890f, 
    -0.03116958f, 0.01146741f, -0.04952107f, 0.03125537f, 0.04273512f, 0.03707125f, 0.15589458f, 0.10579841f, 
    0.32532603f, 0.02106332f, 0.26832801f, 0.08720557f, -0.21062817f, 0.06841909f, 0.04528219f, -0.00717024f, 
    0.02378106f, 0.00408572f, -0.02638192f, -0.05524101f, 0.00127332f, 0.02138170f, -0.18128178f, 0.07795043f, 
    -0.13087435f, 0.04864519f, -0.06227788f, 0.12045030f, 0.07545236f, 0.08307786f, -0.04509056f, -0.00618662f, 
    0.01493132f, -0.01422621f, -0.05531226f, 0.03469656f, 0.00138988f, -0.11010811f, -0.11681331f, 0.07999904f, 
    -0.03391653f, -0.11653846f, -0.01368779f, -0.09362055f, 0.07459271f, 0.00166224f, -0.15633197f, 0.27252164f, 
    0.06400282f, -0.04278438f, 0.19776261f, 0.08521649f, -0.03536958f, -0.07852085f, 0.00076686f, -0.03634712f, 
    0.08850132f, 0.19842406f, 0.10984107f, 0.27426690f, 0.01263911f, 0.03789034f, 0.00955072f, -0.02888956f, 
    0.10492966f, 0.15360729f, 0.06705046f, -0.03023759f, 0.29150146f, -0.11948131f, 0.04275864f, 0.05852839f, 
    -0.12812991f, 0.09535215f, -0.01654387f, -0.02075953f, 0.02834511f, -0.11971501f, 0.05458086f, -0.04282425f, 
    -0.04277741f, 0.16090530f, 0.18851119f, -0.14447382f, 0.01900919f, 0.01113534f, -0.12096553f, 0.12400483f, 
    -0.09569348f, 0.04428907f, 0.26283315f, 0.01481390f, 0.09279947f, 0.17397672f, -0.18959130f, -0.13557462f, 
    -0.07665908f, 0.00862444f, 0.07593709f, -0.11505955f, -0.01128204f, 0.11177676f, 0.10055689f, -0.07927918f, 
    0.14595529f, 0.35843366f, 0.04695600f, 0.09406794f, 0.09069582f, 0.09741819f, -0.17358381f, 0.01639293f, 
    -0.05364580f, -0.01184458f, 0.03257556f, 0.03987779f, 0.08468515f, 0.22730021f, 0.11300596f, 0.09120300f, 
    0.04631060f, 0.06151920f, 0.11357615f, 0.13941452f, -0.03505298f, 0.00909811f, -0.18649004f, -0.14665659f, 
    -0.20914213f, -0.16533227f, -0.16257575f, 0.17809470f, 0.01831096f, -0.00811552f, -0.00430963f, -0.00710206f, 
    -0.02779900f, 0.05784924f, 0.04509098f, -0.07284224f, -0.12677856f, 0.19405685f, 0.13028677f, -0.12136513f, 
    -0.00706153f, 0.07907171f, 0.00419140f, 0.03476441f, 0.03439688f, -0.09432233f, 0.01412747f, -0.00513690f, 
    -0.01377172f, 0.02348901f, 0.00067001f, 0.01994469f, 0.03429315f, -0.05549005f, 0.02333841f, -0.00828442f, 
    0.03339873f, -0.04872578f, 0.00745647f, -0.02054662f, 0.00425756f, -0.01717944f, -0.04673950f, -0.00085406f, 
    -0.01244656f, -0.05505572f, 0.02398559f, 0.02812123f, 0.02548217f, 0.00772146f, 0.00923176f, 0.01524448f, 
    -0.04811073f, 0.02274928f, 0.03759113f, 0.01566063f, -0.01518579f, -0.03056034f, -0.03015126f, 0.00869959f, 
    0.01049099f, -0.00906839f, -0.03144357f, -0.02633639f, 0.02881101f, 0.03678994f, -0.03297176f, 0.00002099f, 
    -0.01268287f, -0.03305723f, -0.03281010f, 0.03644118f, -0.00287229f, -0.01949123f, 0.03914078f, 0.02512245f, 
    -0.02414115f, -0.00389421f, -0.03217485f, -0.02721892f, 0.00032746f, -0.04687982f, 0.02081104f, -0.01352654f, 
    -0.05091377f, -0.05377416f, 0.04265067f, -0.00237984f, 0.00027769f, -0.05115652f, 0.00772713f, 0.01609281f, 
    0.02817140f, 0.00174790f, 0.02141040f, -0.00523494f, -0.02897278f, 0.03875667f, 0.01917882f, -0.00055756f, 
    -0.02350185f, 0.00523523f, -0.00574279f, -0.01775270f, -0.01605414f, -0.04646155f, -0.01286468f, -0.01775724f, 
    -0.00726532f, -0.03238600f, 0.03646944f, 0.01424360f, -0.02688907f, -0.04684675f, -0.02029942f, 0.02958005f, 
    -0.01634190f, -0.03232001f, -0.02988295f, 0.00681752f, 0.03576583f, -0.04411482f, -0.03730735f, 0.01265041f, 
    0.04105515f, 0.00509094f, 0.03792255f, -0.00740049f, 0.04146928f, -0.02942588f, 0.02243792f, 0.01141649f, 
    0.03287585f, -0.01840961f, -0.02251238f, -0.00321541f, -0.05469390f, 0.01200761f, -0.03137100f, 0.01207133f, 
    -0.04644156f, -0.03919700f, 0.00136827f, 0.01507368f, 0.03548673f, -0.04084891f, -0.03294301f, 0.02691558f, 
    -0.04456211f, -0.04368915f, -0.01628536f, 0.00067165f, -0.04481040f, 0.03321718f, -0.04979126f, -0.02687787f, 
    0.02870121f, 0.01293479f, -0.02161579f, 0.00330077f, -0.04129641f, 0.00966594f, 0.05631499f, 0.03735606f, 
    -0.04233849f, 0.04128203f, 0.03562616f, -0.03423136f, 0.01215235f, 0.00095517f, -0.04912290f, 0.00408484f, 
    0.01032266f, 0.00039647f, -0.01726387f, -0.00796382f, 0.01980477f, -0.01620909f, -0.04095270f, 0.04220405f, 
    0.01217973f, 0.02847256f, -0.01341416f, -0.04596819f, -0.05923743f, -0.03503451f, -0.00133788f, -0.05787024f, 
    0.01747502f, -0.02293397f, -0.02711079f, -0.04786218f, -0.00003661f, 0.00481505f, -0.00784579f, 0.02552536f, 
    0.02750352f, -0.02239004f, -0.01520995f, -0.04542463f, -0.04749016f, -0.02355961f, -0.01277276f, 0.02209822f, 
    -0.04596692f, 0.02284545f, 0.00622320f, 0.00065085f, -0.00119324f, -0.04196765f, -0.04109369f, -0.01100422f, 
    0.03752315f, -0.04363511f, 0.01458965f, -0.02937998f, 0.00074170f, 0.00270705f, -0.02531686f, -0.03002864f, 
    -0.05824425f, -0.04117998f, -0.00287753f, -0.04183142f, 0.03379741f, 0.03051114f, 0.00919051f, 0.02576713f, 
    -0.02508330f, -0.05031168f, 0.01857719f, -0.00802260f, 0.00880378f, 0.02703457f, -0.01934356f, -0.00376593f, 
    0.02045027f, 0.00059437f, 0.02064947f, 0.01949286f, 0.02298823f, 0.03497571f, -0.04030158f, 0.00293034f, 
    -0.02521532f, 0.02043128f, -0.01979260f, -0.04432603f, -0.01009757f, 0.00911647f, 0.01864364f, -0.01519648f, 
    -0.02498924f, 0.02065966f, -0.00043224f, -0.02765422f, 0.02084352f, -0.00364526f, -0.00768542f, -0.04883964f, 
    0.01331636f, -0.02536399f, 0.00753704f, 0.02056677f, -0.05699637f, -0.00464188f, -0.04484370f, -0.01717617f, 
    0.03135867f, 0.00437568f, -0.02256145f, 0.01665482f, -0.00023218f, -0.00336516f, -0.02915880f, -0.01693656f, 
    -0.05550833f, 0.03858351f, -0.02735204f, -0.01506148f, -0.05364236f, 0.01403986f, 0.04844560f, -0.02912420f, 
    -0.03835918f, -0.04364100f, -0.00732734f, 0.03182133f, 0.02041138f, 0.03640706f, -0.03588387f, 0.01606862f, 
    -0.00503991f, -0.01880903f, 0.01108802f, -0.01793996f, -0.02007254f, -0.01818135f, -0.04539420f, -0.01989907f, 
    -0.04537303f, 0.01717239f, -0.03229102f, 0.00956682f, 0.01306749f, -0.03393983f, -0.04316482f, 0.00242854f, 
    0.02021734f, -0.03630747f, 0.02836905f, 0.00925938f, 0.02000582f, -0.03622490f, 0.03060395f, 0.02710409f, 
    0.04025708f, -0.00124431f, -0.01127383f, 0.00814354f, 0.02500005f, -0.03309996f, -0.02367623f, 0.00099363f, 
    0.03344000f, -0.01987738f, -0.04092496f, -0.02210175f, 0.02162188f, -0.05615755f, -0.05767489f, 0.04240804f, 
    -0.02769281f, -0.04087723f, -0.03878618f, 0.01227227f, -0.03025752f, -0.03014527f, -0.00356559f, -0.04598935f, 
    -0.02799213f, -0.05038474f, -0.02102323f, 0.01761099f, 0.04705815f, 0.00773483f, -0.02475829f, 0.02368224f, 
    -0.05467515f, -0.00558705f, 0.01344611f, -0.05295973f, -0.04297757f, -0.01521392f, -0.04355650f, -0.00036478f, 
    0.00141428f, -0.04493903f, 0.02097659f, -0.01347013f, -0.01726404f, 0.00216567f, 0.03341988f, -0.04108174f, 
    0.03335772f, -0.02167258f, -0.01184127f, 0.01794621f, 0.01463852f, 0.01957200f, -0.01823225f, -0.02857139f, 
    -0.04205413f, 0.03288534f, -0.02419925f, -0.04299979f, -0.01062675f, -0.01469231f, -0.04253399f, -0.03835639f, 
    0.00808486f, -0.01553427f, -0.02675927f, 0.01595149f, -0.00186020f, 0.01269666f, -0.04194687f, -0.04599450f, 
    0.02291793f, -0.04598224f, -0.05465216f, -0.00837416f, -0.00507697f, 0.02032454f, -0.03193215f, 0.03861846f, 
    -0.04467902f, -0.02919699f, 0.02383580f, -0.05435658f, -0.05235458f, 0.02919591f, -0.00403106f, 0.01207420f, 
    0.00916906f, 0.03428603f, -0.03369791f, -0.05116438f, -0.03353637f, -0.01633148f, -0.01513912f, -0.04785420f, 
    -0.02201528f, -0.03921238f, 0.03401481f, -0.02231200f, -0.02252956f, -0.01911117f, -0.04629144f, 0.01032749f, 
    -0.04621885f, -0.03177105f, -0.00521036f, -0.03736196f, 0.01890956f, 0.00364339f, -0.01898434f, -0.06093000f, 
    -0.03505071f, -0.05882281f, -0.01368172f, -0.05801782f, 0.02882394f, 0.03475614f, -0.02625158f, -0.05684080f, 
    0.03029623f, 0.01413133f, -0.02780098f, 0.01552759f, -0.04458867f, 0.00605400f, 0.00127763f, 0.01200565f, 
    -0.04745559f, -0.02610657f, 0.02382483f, -0.02884653f, 0.03192199f, 0.01025465f, 0.01520288f, -0.03003895f, 
    -0.04262207f, 0.00873596f, -0.04962128f, -0.01820294f, 0.03462009f, -0.00371596f, 0.00219973f, -0.06273907f, 
    -0.00100377f, -0.01268761f, 0.00818977f, 0.03204101f, 0.02641950f, 0.02780719f, -0.02937720f, -0.06132584f, 
    0.03073202f, 0.03049702f, -0.03813624f, -0.03985612f, -0.04849098f, -0.03665658f, -0.02463203f, -0.03085505f, 
    -0.04100680f, -0.05830810f, 0.01415673f, 0.03429243f, -0.05193689f, -0.06134350f, -0.01261658f, -0.02509009f, 
    0.00538636f, -0.05903913f, -0.02291837f, -0.01822615f, 0.02142587f, -0.01589873f, -0.01963454f, -0.02310167f, 
    -0.02049641f, 0.01600719f, 0.00533346f, -0.01981199f, 0.00792575f, 0.00376755f, -0.02443070f, 0.01506862f, 
    -0.02985110f, -0.00050602f, -0.03118929f, -0.05399876f, 0.01887268f, -0.00201085f, -0.04959498f, -0.04101475f, 
    -0.06558348f, -0.05866737f, -0.04681045f, 0.00488335f, 0.01242391f, -0.06159173f, -0.04876519f, -0.06200396f, 
    -0.00965677f, -0.04354944f, -0.02897047f, 0.00638763f, -0.01275496f, 0.01055901f, 0.01146118f, -0.04789645f, 
    -0.02177951f, -0.02642276f, -0.02414442f, -0.00417256f, -0.00368068f, -0.05162223f, -0.05263504f, 0.00679034f, 
    0.03562928f, -0.04693319f, -0.00408357f, -0.01370649f, 0.01252397f, -0.01203923f, -0.06084905f, -0.03221482f, 
    -0.00234072f, 0.00278408f, 0.02538688f, -0.01374540f, -0.01556823f, -0.06049698f, 0.00689256f, -0.01877538f, 
    0.02091028f, -0.01570112f, -0.00351139f, -0.04107931f, -0.03324888f, 0.01389948f, 0.00398274f, 0.04687418f, 
    -0.01226249f, 0.01585882f, -0.01009838f, -0.06209798f, -0.05506907f, -0.05971264f, -0.01617606f, -0.03425546f, 
    -0.05296373f, -0.04191396f, 0.00470408f, -0.00074532f, 0.03559295f, -0.03976802f, -0.04777292f, -0.02715041f, 
    -0.01003652f, -0.06170244f, -0.00409727f, -0.02897606f, -0.01212223f, 0.00626356f, -0.00063156f, -0.04591202f, 
    0.01085270f, -0.03563630f, 0.00642980f, -0.05875838f, -0.05737680f, -0.02281253f, -0.04297300f, -0.05544652f, 
    0.00526939f, -0.06214757f, -0.04991608f, -0.06186254f, 0.01614041f, 0.00755404f, -0.01541076f, 0.03609429f, 
    -0.04449699f, -0.01881795f, -0.03561254f, -0.04197514f, -0.03632996f, -0.03684761f, -0.01447295f, -0.01903274f, 
    0.01549624f, -0.02024576f, 0.00087919f, -0.02770552f, -0.05414542f, -0.04362520f, 0.01064447f, 0.02086581f, 
    -0.04290512f, 0.00524430f, -0.00984952f, 0.02072470f, -0.04337068f, -0.00040969f, -0.02022896f, -0.02933055f, 
    -0.05786129f, -0.01507767f, -0.04428414f, -0.04028910f, -0.00026910f, -0.05664039f, 0.00340690f, 0.00308240f, 
    -0.04274746f, -0.04974052f, -0.00491764f, -0.03850102f, 0.01004195f, 0.00644678f, -0.01896583f, 0.03127905f, 
    -0.00830260f, 0.02032244f, -0.02116999f, 0.01244888f, 0.01188381f, -0.00087535f, -0.01002060f, -0.06342445f, 
    -0.02937612f, 0.01761513f, -0.01941385f, -0.04397625f, 0.01729315f, -0.03784011f, -0.02821626f, 0.02292137f, 
    -0.03351185f, -0.06113717f, 0.00272327f, 0.01512965f, -0.01433651f, -0.00262803f, -0.00924296f, 0.01591060f, 
    -0.00777631f, -0.02151902f, -0.02715254f, 0.00582533f, 0.01244945f, 0.01627425f, -0.00217366f, -0.00650511f, 
    -0.04659275f, -0.03033474f, 0.03665258f, -0.05442113f, -0.02774952f, 0.03444099f, -0.03784627f, 0.01239745f, 
    -0.01871760f, 0.01214085f, -0.03990686f, -0.02094407f, 0.00295785f, -0.03961250f, -0.00067414f, 0.02156380f, 
    -0.01186149f, 0.02998418f, -0.00064477f, -0.05335266f, 0.00568945f, 0.03181738f, -0.04690988f, -0.02405493f, 
    -0.05506828f, -0.05079122f, 0.03343711f, -0.04203158f, -0.01569339f, -0.00393874f, -0.02550101f, -0.00930271f, 
    -0.03629507f, -0.00062024f, 0.02389546f, -0.00782274f, -0.04160102f, -0.02095853f, 0.02312907f, -0.03647216f, 
    0.03063194f, -0.06497002f, -0.00840482f, -0.03379435f, 0.03412884f, 0.01986260f, -0.05433969f, 0.02249401f, 
    0.00867471f, -0.02427100f, 0.02140140f, -0.00654421f, -0.01044366f, 0.02113157f, -0.01021971f, -0.05505893f, 
    -0.00436749f, -0.05223588f, -0.04021436f, 0.01612714f, -0.03509258f, -0.01085561f, 0.01770068f, -0.03311911f, 
    -0.04610690f, -0.04776642f, 0.00413060f, -0.04634900f, -0.06391387f, -0.05686893f, -0.01531279f, -0.02492780f, 
    -0.03328177f, 0.00114968f, -0.03862786f, -0.01683016f, -0.04336777f, -0.02878879f, 0.01491468f, 0.01227322f, 
    0.00979271f, -0.00084689f, -0.06159447f, -0.01472685f, 0.01475780f, -0.00787910f, -0.02565493f, -0.01304801f, 
    -0.03972791f, -0.04742462f, -0.04414512f, 0.03402569f, 0.00436632f, 0.03177263f, 0.01864091f, -0.02681118f, 
    0.03557878f, -0.03965430f, -0.02587029f, -0.01494439f, -0.00833509f, -0.04205471f, -0.04070048f, 0.03065609f, 
    -0.05216563f, 0.00457308f, 0.01338300f, -0.00643144f, -0.02468356f, -0.03359664f, 0.02278680f, -0.00779096f, 
    -0.00211428f, -0.04539535f, -0.03775408f, 0.02479769f, -0.02981628f, -0.03383025f, -0.05940558f, -0.04547059f, 
    -0.02015094f, 0.02016416f, -0.00927710f, 0.00495820f, -0.00853015f, -0.00846476f, -0.02872730f, -0.00346128f, 
    0.13730122f, 0.07971220f, -0.38760227f, -0.34094322f, 0.03267073f, 0.08591165f, -0.03053998f, -0.08875548f, 
    0.09107630f, -0.01170088f, 0.05304334f, -0.07099213f, -0.19020203f, -0.14203528f, 0.16691884f, -0.05575453f, 
    0.26002789f, -0.00207041f, -0.00628657f, 0.12631968f, 0.07757632f, -0.00457066f, 0.03647958f, 0.10253279f, 
    0.02019756f, -0.03529935f, 0.11318587f, -0.08882862f, -0.05493661f, 0.11129105f, 0.14753428f, 0.13134909f, 
    -0.09010331f, 0.23309791f, -0.01443848f, 0.02247856f, 0.38845557f, -0.11394208f, 0.07763314f, 0.03795298f, 
    0.02311520f, -0.10165675f, -0.00064316f, -0.11823729f, 0.10755455f, -0.00905627f, 0.02112176f, -0.00796446f, 
    -0.01594373f, 0.15225035f, 0.03140375f, -0.13716175f, 0.17940392f, 0.03361772f, -0.00616328f, 0.06313100f, 
    0.00810931f, 0.04378374f, -0.06393363f, -0.03852706f, -0.00422051f, 0.01747988f, 0.01757919f, 0.02684746f, 
    -0.07171480f, 0.14093389f, 0.06874200f, -0.02607314f, 0.01124132f, 0.07611193f, 0.01928503f, -0.09135380f, 
    -0.03144485f, 0.24493642f, -0.24585558f, -0.09843611f, 0.18606943f, 0.15020314f, 0.10881519f, -0.00162221f, 
    0.07590737f, 0.06572363f, 0.06898845f, 0.04887430f, -0.28055066f, 0.18733788f, 0.07700796f, -0.24232584f, 
    -0.05726943f, 0.11421838f, 0.06416477f, -0.04539632f, -0.06565624f, 0.07598644f, 0.09372725f, 0.05568997f, 
    -0.25623643f, 0.22119629f, -0.07621214f, -0.11791669f, 0.12820877f, -0.06040674f, 0.03289167f, 0.02923663f, 
    0.06966293f, -0.15484479f, 0.03781389f, -0.03074387f, 0.41844463f, -0.28180310f, 0.04204676f, 0.19003783f, 
    -0.01444367f, -0.16684185f, 0.06397622f, -0.09905643f, -0.00151146f, 0.02135117f, 0.11747404f, 0.11065959f, 
    -0.16162081f, 0.08545402f, -0.04260241f, -0.14590842f, -0.04289973f, 0.07869437f, 0.04907298f, 0.06934267f, 
    0.03829838f, 0.09425062f, -0.01013810f, 0.01539431f, -0.08662060f, -0.08691761f, 0.17076591f, -0.10536585f, 
    0.09963453f, 0.07518449f, 0.21414767f, 0.02523073f, 0.09919836f, 0.09355818f, 0.11735951f, 0.09354123f, 
    -0.23348263f, 0.13411446f, 0.06416573f, -0.14721739f, 0.19653735f, 0.07795494f, -0.02217775f, 0.02401828f, 
    0.00709534f, 0.00718373f, 0.06801364f, -0.01496734f, -0.11798432f, 0.00592902f, -0.14823514f, 0.40909231f, 
    -0.03308124f, 0.20491169f, -0.09376498f, 0.05750023f, 0.08290125f, 0.03715615f, 0.01885908f, 0.04249451f, 
    0.65843052f, -0.03746427f, 0.01285110f, -0.19760840f, 0.09400913f, 0.06078550f, 0.10686182f, 0.10880095f, 
    0.00330037f, 0.02739550f, -0.05114692f, 0.09632330f, -0.25448957f, -0.10325744f, 0.14895561f, 0.04474403f, 
    -0.09937996f, -0.03778333f, -0.04624232f, -0.05329081f, -0.20594344f, 0.07675226f, 0.01165278f, 0.05611501f, 
    -0.12618037f, 0.11804727f, -0.13684177f, 0.02334843f, 0.03880503f, -0.03421608f, -0.16189526f, 0.02238396f, 
    -0.01575501f, 0.02287849f, -0.10753875f, -0.00386155f, -0.06721820f, 0.10846726f, -0.04063841f, 0.06805306f, 
    0.02780105f, 0.07485710f, -0.00455755f, 0.19722596f, -0.07384922f, 0.06188208f, 0.00875719f, 0.03387954f, 
    -0.41682822f, -0.03043303f, 0.10249981f, 0.20639180f, -0.12640230f, 0.06292438f, 0.00570517f, 0.09729016f, 
    -0.04400253f, -0.04477761f, 0.01105586f, -0.00188817f, -0.08744754f, 0.10303488f, 0.11465284f, -0.18880461f, 
    0.04392590f, 0.06826219f, 0.00644626f, -0.08222815f, 0.06356806f, -0.05295818f, -0.01167896f, -0.04881846f, 
    -0.00580945f, 0.08818322f, -0.02423840f, 0.07157966f, 0.09615586f, -0.06380124f, 0.10406253f, 0.02762162f, 
    0.14731900f, -0.02030366f, 0.08418118f, 0.07560349f, 0.13704289f, 0.34252587f, -0.06039971f, 0.11102578f, 
    0.01844475f, -0.01287086f, -0.04553494f, 0.04908793f, -0.07605638f, -0.00528621f, -0.03221350f, -0.00147378f, 
    0.10584171f, -0.15670462f, 0.21585332f, 0.00786757f, -0.00575682f, 0.04996956f, 0.00014543f, -0.04398446f, 
    0.04543843f, 0.10772047f, 0.03819852f, 0.05263907f, -0.07657969f, 0.36841241f, 0.06562597f, 0.03692441f, 
    -0.04175294f, -0.01083229f, 0.02076111f, -0.00014728f, 0.10473146f, 0.08317681f, 0.09114645f, 0.13389629f, 
    0.05733287f, -0.04000527f, -0.12224591f, -0.13070108f, -0.03628742f, 0.00216168f, -0.03360486f, -0.04691451f, 
    -0.00203361f, -0.20805536f, -0.00281727f, -0.09215897f, -0.36974263f, 0.22824878f, 0.07371271f, -0.09845985f, 
    0.09530893f, 0.08111355f, 0.01757420f, 0.01557651f, -0.01214249f, -0.02386609f, 0.10711499f, 0.10232905f, 
    -0.00516606f, 0.17121203f, -0.31060672f, 0.05799744f, 0.07422230f, -0.01818888f, 0.00262712f, 0.13950980f, 
    0.02777202f, -0.09604925f, -0.15910150f, -0.01999444f, -0.17762372f, -0.16648318f, 0.37490726f, 0.20220895f, 
    -0.13208926f, -0.01336099f, -0.07538214f, -0.00983748f, 0.00725155f, 0.13779557f, -0.05086093f, 0.05467737f, 
    0.14982060f, 0.00841835f, 0.04799084f, 0.07016254f, 0.06144772f, 0.00574043f, -0.00655205f, -0.12347402f, 
    -0.11624001f, -0.05118686f, 0.04043012f, 0.09064925f, 0.32492280f, 0.06843019f, 0.07933754f, 0.05548258f, 
    -0.00481495f, -0.07899056f, -0.05806926f, 0.03627988f, -0.01450065f, 0.03486578f, 0.12080546f, 0.16910927f, 
    -0.28285059f, 0.03492608f, 0.05697682f, 0.01017648f, 0.09611952f, 0.08105842f, -0.04764150f, -0.00441133f, 
    0.00907787f, 0.09784284f, 0.09766996f, 0.08167813f, 0.33185586f, -0.14242230f, 0.30245677f, -0.11951983f, 
    -0.03215668f, 0.03224379f, 0.07783066f, 0.15822737f, -0.01719694f, 0.07617307f, 0.00501751f, -0.00738686f, 
    -0.31255043f, -0.08295052f, 0.24279091f, 0.11920469f, -0.05163001f, -0.01638299f, 0.01282958f, 0.08315437f, 
    -0.03764414f, -0.13167351f, -0.00827706f, -0.00295627f, 0.02626377f, -0.10983901f, 0.11500997f, 0.25044301f, 
    -0.19530347f, -0.10754027f, -0.05186428f, -0.05977852f, -0.04414001f, -0.04900924f, 0.02234130f, 0.01860728f, 
    0.28217050f, -0.06754500f, -0.02920434f, 0.04291574f, -0.02317604f, -0.01434701f, -0.08687378f, -0.08213264f, 
    0.03360720f, -0.14845997f, 0.00581997f, -0.04472800f, -0.08254459f, 0.12567170f, 0.00980988f, -0.13345180f, 
    -0.01151723f, 0.13995959f, 0.06955567f, 0.01264108f, 0.06440827f, -0.02064132f, -0.00638462f, 0.02222057f, 
    0.19254714f, -0.17480266f, -0.16904776f, 0.02447929f, -0.08556688f, 0.12853956f, 0.05649049f, 0.07390385f, 
    0.12856932f, -0.00588273f, 0.05074183f, -0.06468939f, -0.33389318f, 0.00638572f, 0.17823678f, 0.08907067f, 
    -0.03790888f, -0.06143428f, 0.06233986f, -0.05060257f, 0.06223885f, -0.01551016f, 0.03342619f, 0.02203548f, 
    -0.00413491f, 0.18239656f, 0.01013648f, 0.14385581f, -0.06598857f, -0.04602439f, 0.06283416f, 0.04673443f, 
    -0.08485480f, -0.06875499f, 0.13286522f, 0.07142680f, 0.29647574f, -0.02050848f, 0.06076863f, 0.12763259f, 
    0.00864815f, -0.01349296f, 0.03440899f, 0.04338401f, 0.00365062f, -0.05006763f, 0.03323103f, 0.01831438f, 
    0.03867623f, 0.10834244f, 0.09053177f, 0.22584523f, -0.01495726f, 0.08332789f, 0.04511766f, 0.00249522f, 
    -0.12420900f, -0.03351258f, 0.02114726f, -0.04318874f, -0.44541472f, 0.06480673f, 0.01882463f, -0.13034785f, 
    0.06373914f, 0.14840017f, 0.04698828f, 0.11995941f, -0.00522187f, -0.03014280f, 0.09195974f, 0.12558983f, 
    -0.07210386f, -0.16982149f, -0.04528917f, 0.08950399f, -0.02897452f, 0.11315545f, -0.00870088f, 0.04109490f, 
    -0.02033235f, -0.12485217f, 0.04027944f, 0.00445467f, 0.14880098f, -0.12959489f, -0.12663312f, 0.16587836f, 
    0.09563505f, 0.01489787f, 0.01322989f, -0.02352924f, -0.04725471f, 0.03977190f, 0.01829818f, 0.00115313f, 
    0.22284696f, 0.16810660f, -0.04265079f, 0.25578800f, -0.12771271f, 0.13479891f, 0.04805604f, 0.08807217f, 
    0.01363098f, 0.05790834f, -0.02360690f, 0.02267767f, 0.22466427f, 0.01760925f, 0.13175459f, -0.03673651f, 
    -0.22828935f, 0.02603470f, -0.00707611f, 0.06537786f, -0.04663287f, 0.08621716f, -0.04741124f, 0.00420007f, 
    -0.00879357f, 0.11679499f, 0.01312581f, -0.13068832f, -0.05982713f, 0.12794250f, 0.06694221f, 0.04181510f, 
    -0.08268130f, -0.03976375f, 0.00872928f, 0.03486305f, 0.12049530f, -0.04850134f, -0.10933752f, -0.03904423f, 
    -0.05893094f, -0.01992444f, 0.06544494f, 0.06839845f, 0.01031826f, -0.07221241f, -0.07577309f, 0.04230390f, 
    -0.14384417f, 0.05433350f, 0.09910630f, 0.10508387f, 0.14352806f, -0.02928091f, 0.02029222f, 0.04800511f, 
    0.04349820f, 0.04769576f, 0.13816792f, 0.05275040f, 0.15433675f, 0.06425200f, 0.28063303f, -0.09447828f, 
    -0.14864844f, 0.07193784f, -0.08739102f, -0.04371064f, 0.04634803f, -0.07784656f, 0.01014311f, 0.05396054f, 
    0.16757794f, -0.04273428f, -0.10125939f, 0.00175647f, 0.06294538f, -0.01198344f, 0.01077867f, -0.08929136f, 
    0.13391781f, 0.10360687f, 0.10860743f, 0.04389104f, 0.12880410f, -0.04248301f, -0.09221251f, 0.17417094f, 
    -0.07143887f, 0.02704458f, 0.04623599f, 0.01467634f, 0.08177209f, 0.01641489f, -0.11370920f, -0.12412296f, 
    0.11088176f, 0.08983116f, 0.02736513f, 0.15570128f, 0.04120366f, 0.00909526f, 0.13924614f, 0.04521448f, 
    -0.00070817f, 0.18636522f, 0.08353809f, 0.04771658f, -0.17074390f, -0.11658521f, 0.14146090f, -0.18224955f, 
    0.12919469f, 0.11450040f, 0.02447586f, -0.17400837f, 0.02033387f, 0.07501189f, 0.00006383f, 0.19686399f, 
    -0.05634196f, 0.15246099f, 0.05491110f, 0.07898788f, 0.19075386f, -0.01239922f, 0.09575548f, 0.08606955f, 
    0.05152622f, 0.02222391f, 0.00273773f, -0.03059863f, 0.05051807f, -0.25732997f, 0.03886200f, -0.04088691f, 
    0.07851557f, 0.09453192f, -0.03598647f, 0.06940952f, -0.12563515f, -0.11156660f, -0.08596668f, -0.12872571f, 
    0.00870039f, -0.10987607f, 0.04017678f, -0.07469676f, -0.06649745f, -0.11456768f, 0.09236430f, 0.11329234f, 
    -0.04946151f, 0.08278197f, -0.00434728f, 0.17358659f, 0.34508869f, 0.15964815f, -0.05003803f, 0.20106886f, 
    -0.02558974f, 0.01115372f, 0.05383366f, -0.12020416f, 0.00298407f, 0.03507584f, -0.06300378f, -0.00305413f, 
    0.22517905f, 0.06677710f, 0.05057318f, 0.00436385f, 0.06090658f, 0.15841842f, 0.03868350f, -0.02071872f, 
    0.01512620f, -0.01053142f, 0.06079879f, 0.08758613f, -0.51141673f, 0.08320002f, -0.10228987f, -0.13086563f, 
    0.16141021f, 0.09078950f, -0.00303149f, 0.01953219f, 0.10886622f, -0.03655111f, 0.04444410f, -0.00555764f, 
    -0.31274238f, -0.16374922f, 0.17805421f, 0.02161933f, -0.07153135f, -0.00403883f, -0.04036336f, 0.03743431f, 
    0.07705407f, 0.13879761f, -0.03196874f, 0.01904103f, -0.00398096f, -0.14261833f, -0.01920431f, -0.01736764f, 
    0.06034305f, 0.09219308f, 0.08801128f, 0.04703396f, 0.06746241f, 0.17096493f, -0.02242061f, 0.05564904f, 
    0.30231333f, 0.02229490f, 0.00730294f, -0.01714116f, -0.10528564f, 0.10188635f, 0.01862855f, 0.02555618f, 
    0.05542408f, 0.05325523f, -0.02460817f, -0.11867182f, -0.83793217f, 0.08500502f, -0.10420550f, 0.11169380f, 
    0.07151359f, -0.14794576f, 0.06477293f, -0.04361748f, 0.05334989f, 0.00972293f, -0.01257769f, -0.02106233f, 
    0.00740850f, 0.03007653f, 0.04253146f, -0.05058798f, -0.04107511f, -0.02243480f, 0.05011465f, 0.00662618f, 
    0.00066085f, -0.01874144f, 0.01407978f, 0.04360880f, -0.03603849f, -0.00965344f, 0.04040774f, -0.01027005f, 
    -0.01220330f, 0.00398080f, -0.00561398f, 0.04449078f, 0.04065390f, -0.00957980f, 0.00537606f, 0.02250307f, 
    0.00939970f, 0.03155820f, 0.02207383f, -0.03219263f, -0.01559334f, -0.00324297f, -0.00627808f, -0.03926848f, 
    0.05171391f, -0.03042032f, 0.00452600f, 0.01576709f, -0.02920817f, -0.01993877f, -0.05301274f, 0.04475605f, 
    -0.04839440f, -0.03298622f, 0.04520429f, -0.05127455f, -0.00173160f, -0.02134869f, -0.05185771f, 0.03900898f, 
    -0.04794763f, 0.04926178f, 0.01129550f, 0.04553184f, -0.05326050f, 0.01110942f, -0.04111061f, -0.01493178f, 
    -0.02402434f, -0.04577600f, -0.04421232f, -0.04170011f, 0.03012305f, 0.01340782f, 0.01456595f, 0.04253365f, 
    -0.04911884f, -0.00413151f, -0.00714853f, -0.03563330f, -0.04403551f, -0.04668708f, -0.05352454f, -0.00168579f, 
    -0.04719447f, -0.02148492f, -0.03842621f, -0.00792151f, -0.01968357f, -0.02805491f, -0.01656062f, 0.01236226f, 
    -0.02337483f, 0.01302886f, -0.00186343f, 0.03543633f, -0.00280383f, -0.03246670f, -0.01388046f, -0.02022544f, 
    -0.02551258f, 0.00915866f, 0.03092203f, 0.02584612f, -0.01367552f, -0.00474769f, 0.03199168f, 0.00119476f, 
    0.00965827f, -0.04316776f, -0.04282568f, 0.02134862f, -0.01938101f, 0.02106605f, -0.02648586f, 0.01154468f, 
    -0.02328678f, 0.02725051f, -0.00347153f, -0.04804102f, 0.00165237f, -0.02999854f, -0.01711367f, 0.04602795f, 
    0.01285987f, -0.03466006f, -0.00491086f, -0.01493178f, -0.02504982f, 0.00854602f, -0.04964148f, 0.04407106f, 
    0.01459669f, -0.02698111f, -0.00270906f, 0.02050363f, 0.01888496f, -0.00450670f, 0.00249382f, -0.00533284f, 
    -0.01957282f, -0.02959975f, -0.04748123f, -0.05378862f, -0.01368274f, -0.02595935f, -0.01097523f, 0.04103940f, 
    -0.01219525f, -0.05118932f, 0.03397499f, -0.04317231f, -0.04677005f, -0.01451096f, -0.04694000f, -0.05089534f, 
    -0.00735716f, -0.01615323f, -0.00785250f, 0.01023417f, -0.01696990f, 0.05144616f, -0.01920871f, -0.04590458f, 
    0.03008595f, -0.01631165f, -0.04232512f, -0.01397621f, 0.01583982f, 0.02789962f, -0.04015654f, 0.00667659f, 
    -0.02314973f, -0.03183074f, -0.03462062f, 0.00638114f, 0.02576902f, 0.00028072f, -0.01154992f, -0.00769188f, 
    -0.03872111f, -0.03174357f, 0.01826717f, -0.02523411f, 0.02464584f, -0.00417193f, -0.03739158f, -0.00577846f, 
    -0.02018588f, 0.02883909f, -0.03877455f, -0.03542775f, -0.02310113f, -0.01141114f, -0.00942087f, -0.00594064f, 
    0.00702641f, -0.04321313f, -0.00277909f, 0.04201127f, 0.02773553f, -0.02437486f, 0.03299285f, 0.00391530f, 
    0.04371978f, -0.03373513f, 0.04330813f, -0.01457957f, 0.00497718f, 0.02308789f, -0.02330698f, 0.01338627f, 
    -0.04803242f, 0.02452247f, 0.00775081f, 0.00194397f, -0.01301837f, -0.02807986f, 0.02377516f, -0.02212645f, 
    -0.01933237f, 0.00889343f, 0.01518515f, 0.00476941f, 0.00719661f, 0.02571949f, -0.02380801f, -0.01390951f, 
    -0.02931046f, 0.03399154f, 0.03456126f, 0.05134229f, 0.00045749f, 0.00339669f, 0.00288600f, -0.00766076f, 
    0.00326783f, -0.04934625f, 0.03601687f, -0.02390411f, 0.01638284f, 0.03442069f, -0.02105436f, -0.03328746f, 
    0.01826045f, 0.04374979f, -0.02045378f, -0.03681122f, -0.00926154f, -0.01770936f, 0.03841707f, -0.02624751f, 
    -0.02057604f, 0.00634157f, -0.04624925f, 0.03872719f, -0.01537740f, 0.03898667f, -0.03913385f, 0.04260096f, 
    -0.01266219f, -0.03945669f, -0.03072673f, 0.01791990f, 0.04718467f, -0.02199246f, -0.04113526f, 0.02971227f, 
    0.01275427f, 0.02391926f, -0.01085979f, 0.01564574f, 0.02054175f, 0.05355730f, 0.03292752f, -0.00877695f, 
    -0.05477574f, -0.04902020f, 0.03697870f, -0.03153150f, -0.01348332f, -0.02064219f, 0.00423814f, 0.00637113f, 
    0.03614711f, -0.01566939f, -0.03303608f, -0.03663062f, -0.04196522f, 0.03244509f, -0.00550123f, -0.00431308f, 
    0.04030871f, -0.02395585f, 0.01419255f, 0.02833169f, 0.03286695f, -0.04124220f, 0.03177295f, -0.05045538f, 
    0.01970783f, -0.02669133f, 0.04266583f, -0.05222104f, 0.02144766f, 0.04771164f, -0.01257679f, 0.04039445f, 
    0.00322747f, 0.02667047f, -0.04452762f, -0.02044144f, 0.04485855f, 0.01688751f, -0.03486196f, -0.04720932f, 
    -0.02528578f, 0.01635042f, -0.02269706f, -0.00350339f, 0.01445415f, 0.03104875f, -0.01076456f, -0.01672198f, 
    0.02371370f, -0.02356288f, -0.00584863f, 0.00672449f, -0.02864166f, -0.01894218f, -0.02428949f, 0.04093795f, 
    0.02785056f, -0.02715375f, -0.02073207f, 0.01912116f, -0.01833511f, -0.02139228f, -0.01673747f, -0.01306777f, 
    -0.04538703f, -0.03356813f, -0.04089023f, 0.04654991f, -0.03230658f, -0.04042518f, -0.02980037f, 0.00516706f, 
    0.02426585f, -0.02071715f, 0.00894544f, -0.05452990f, 0.02444706f, 0.00523154f, -0.00658277f, 0.04271406f, 
    0.00922327f, -0.00690976f, -0.03420436f, 0.03809460f, 0.02895363f, -0.01012549f, -0.03891650f, 0.00304123f, 
    0.02630341f, 0.04589647f, 0.04387449f, -0.00626889f, 0.01192092f, 0.03730520f, -0.05048294f, 0.03056135f, 
    -0.05156834f, -0.02893300f, -0.02345846f, 0.01578170f, 0.01706137f, 0.02717113f, -0.02164750f, 0.01620843f, 
    -0.00625140f, 0.04694898f, -0.00383130f, 0.04459163f, 0.00163983f, 0.04130751f, 0.00714301f, -0.01551684f, 
    -0.00749461f, 0.01132897f, -0.00106224f, -0.04557511f, -0.03682538f, -0.01767269f, 0.03102594f, -0.01148350f, 
    0.02984250f, 0.01218700f, 0.03846045f, -0.02606056f, 0.03079799f, 0.01596148f, -0.02862052f, 0.02442840f, 
    -0.02444727f, -0.01035133f, 0.01472661f, -0.03127768f, 0.02021310f, -0.00666065f, -0.02036906f, -0.00147942f, 
    0.01763101f, -0.00636397f, 0.03008400f, -0.02212738f, 0.04758965f, 0.02553647f, -0.00152797f, -0.01003957f, 
    0.02268988f, -0.02530609f, -0.05708450f, 0.00509824f, 0.04307075f, 0.03529359f, -0.03984756f, 0.01116077f, 
    0.03520749f, -0.04721341f, 0.01324997f, 0.03413983f, -0.01508243f, 0.03254271f, -0.01500536f, -0.01718476f, 
    0.00315492f, 0.01774683f, -0.05358148f, 0.00958326f, -0.01368471f, -0.01428632f, -0.05706132f, 0.01641091f, 
    0.01052381f, 0.02639872f, -0.03023038f, -0.01770025f, 0.03570998f, 0.04098220f, -0.04481598f, -0.01944588f, 
    -0.01350109f, -0.03938079f, 0.01800776f, -0.00693689f, -0.01847677f, 0.00727522f, 0.02191582f, -0.01342472f, 
    0.02608106f, -0.03530977f, -0.05543340f, -0.03204389f, 0.03600775f, 0.03983425f, -0.06088793f, 0.03314497f, 
    0.02071491f, 0.01340584f, -0.00441341f, 0.01157353f, -0.02679778f, -0.05644905f, -0.04672460f, 0.03542274f, 
    -0.00549458f, 0.00226933f, 0.04067402f, 0.01157734f, -0.00161469f, 0.02387099f, -0.00852749f, 0.01179391f, 
    0.01237679f, -0.00314796f, -0.01329181f, -0.04488022f, 0.02044371f, -0.00570382f, -0.01552986f, 0.01986496f, 
    -0.01250871f, -0.01691604f, -0.02388786f, 0.01434618f, -0.04079553f, -0.00022419f, -0.00551996f, 0.00726008f, 
    -0.01494111f, -0.01403681f, -0.04954012f, 0.01204075f, -0.00012537f, 0.01810811f, -0.00925458f, 0.01110868f, 
    -0.03942440f, -0.05577708f, -0.03322267f, 0.02045167f, -0.04076684f, -0.02652680f, 0.00003500f, -0.01773045f, 
    -0.05191321f, -0.00351733f, 0.01053716f, 0.01023050f, 0.00462790f, -0.01192611f, -0.02025969f, 0.01754748f, 
    -0.00863289f, -0.04394399f, 0.01633178f, 0.01753135f, -0.05493149f, 0.03961883f, -0.03497949f, -0.01225429f, 
    0.04971318f, -0.03705082f, 0.02035787f, 0.03612212f, 0.01196322f, 0.03675109f, -0.05688604f, 0.03286470f, 
    -0.00900397f, 0.04178936f, 0.03407152f, -0.01179169f, -0.03611317f, 0.01262314f, -0.03566861f, -0.05037603f, 
    0.02584448f, -0.03623513f, 0.01152868f, -0.02667660f, 0.00615454f, -0.00704948f, 0.02282483f, 0.00613766f, 
    -0.03599066f, -0.01125083f, -0.05209458f, -0.04114990f, -0.01578945f, -0.03549861f, -0.01051389f, -0.04597683f, 
    0.00347558f, 0.00268857f, -0.04585703f, -0.05047945f, 0.02810659f, 0.02355927f, -0.00495094f, -0.03946228f, 
    -0.01369285f, -0.03735324f, 0.03229249f, 0.00537557f, -0.01751642f, -0.00344497f, -0.00231002f, -0.04861587f, 
    -0.05031427f, -0.01987122f, -0.01389832f, 0.03985541f, -0.01968323f, -0.02355839f, -0.00678360f, -0.04744123f, 
    -0.02870652f, 0.03043267f, -0.01671210f, -0.04742394f, 0.01584168f, 0.03612331f, 0.01725555f, -0.05891515f, 
    -0.05129595f, 0.01017003f, -0.02364437f, 0.03207269f, -0.02753043f, -0.02283867f, -0.03174621f, -0.05181206f, 
    0.01293431f, -0.03383929f, -0.03079476f, -0.05330736f, 0.01392350f, -0.05889740f, -0.05457706f, -0.03483663f, 
    0.04057832f, -0.04157360f, 0.04071051f, -0.05762283f, -0.02131689f, 0.02163961f, -0.04066688f, -0.02298335f, 
    0.01611023f, 0.01209297f, 0.03953645f, -0.01814566f, 0.00300300f, -0.04198956f, -0.01851848f, -0.04546516f, 
    -0.00573521f, -0.03562191f, -0.01302644f, -0.02502255f, 0.01223763f, 0.02133378f, 0.01290460f, -0.04936964f, 
    -0.00272607f, 0.01775306f, 0.00192819f, -0.03373368f, 0.02551077f, 0.00737868f, 0.04177402f, 0.03226695f, 
    -0.00633608f, -0.02675297f, 0.00989187f, 0.00559987f, -0.03831347f, -0.03814654f, 0.04491797f, -0.03529190f, 
    0.00138340f, -0.02110084f, 0.02710912f, 0.03249108f, 0.02201748f, -0.04152166f, -0.04732661f, -0.01999843f, 
    0.01365161f, 0.03290384f, 0.00137787f, -0.01931587f, -0.00738572f, 0.00121277f, -0.00781995f, 0.00631807f, 
    0.01626801f, -0.05676177f, -0.04917986f, 0.01106926f, 0.00249756f, -0.05355467f, -0.03314173f, 0.02705846f, 
    -0.03476087f, 0.02535261f, -0.01546314f, -0.00084291f, -0.04735572f, 0.01084649f, 0.03742638f, -0.04889008f, 
    -0.00798409f, -0.04450789f, -0.05737693f, -0.03150661f, 0.03610547f, -0.02491353f, -0.01232063f, 0.02408537f, 
    0.00085786f, -0.05774353f, -0.03235256f, 0.01969795f, 0.01865458f, -0.04170394f, -0.00148020f, 0.03113321f, 
    0.01232078f, 0.00517879f, 0.00669173f, 0.00792305f, 0.00362341f, -0.02291175f, 0.00004588f, 0.00625857f, 
    -0.02224277f, 0.00602172f, 0.02275984f, -0.02201439f, -0.03419362f, -0.01322854f, -0.05814136f, -0.02730040f, 
    -0.01213034f, 0.03182951f, 0.03388883f, -0.05564840f, -0.03581970f, 0.03786382f, 0.03501042f, 0.01896469f, 
    0.01799363f, -0.02878496f, 0.02099865f, -0.02807111f, 0.01577967f, -0.05418190f, -0.02605787f, 0.02390959f, 
    -0.00694731f, -0.00671730f, 0.02769901f, -0.05848639f, -0.05028348f, 0.02545455f, -0.02837636f, -0.00908578f, 
    -0.05451539f, -0.04153662f, 0.03427353f, -0.01938756f, -0.04711553f, 0.02449954f, 0.02404646f, 0.01561042f, 
    -0.04463725f, 0.01791183f, 0.01812821f, -0.02249656f, -0.02802198f, 0.00300191f, -0.04002891f, 0.02653230f, 
    0.03473813f, 0.04165274f, -0.02562850f, -0.03429244f, -0.01337662f, -0.03686218f, -0.05040874f, 0.02710275f, 
    0.01683717f, 0.02031979f, 0.03763483f, -0.02607659f, 0.00334352f, -0.04809826f, 0.02197446f, -0.04062703f, 
    -0.05372991f, -0.05232256f, -0.01253239f, -0.03295720f, -0.02056747f, -0.04307546f, -0.01459816f, -0.01320553f, 
    0.23007920f, 0.24048348f, 0.15888859f, -0.11309583f, -0.03685357f, 0.09954453f, -0.05424990f, -0.01007189f, 
    0.29016754f, -0.19097120f, -0.09546389f, 0.03705097f, -0.38524553f, -0.05105064f, -0.12730826f, 0.11702933f, 
    0.16061904f, -0.02459121f, -0.04917292f, -0.12354545f, -0.09847243f, -0.03854495f, 0.04200567f, -0.08361942f, 
    0.19234367f, -0.10960260f, 0.13424739f, 0.05025204f, 0.11839677f, 0.11793820f, -0.09993238f, 0.09675331f, 
    0.01799560f, 0.08324207f, 0.06197215f, -0.00031677f, 0.05532696f, 0.10731271f, -0.01528099f, 0.21933998f, 
    -0.10491583f, -0.15872644f, 0.02752256f, 0.08371411f, 0.03339447f, 0.17254700f, 0.06942648f, -0.00482546f, 
    0.13415970f, 0.02603220f, -0.07441761f, 0.24488832f, 0.15303209f, -0.02362315f, 0.02867466f, 0.04433441f, 
    -0.02011258f, 0.09705771f, -0.02665442f, 0.14428481f, 0.06281315f, 0.05559302f, 0.11512437f, 0.01100637f, 
    0.07449081f, -0.08256872f, 0.09044446f, -0.07539942f, 0.03404623f, -0.01340610f, -0.10777133f, -0.01640559f, 
    0.20091209f, -0.07738137f, -0.01287260f, 0.09900388f, 0.02426736f, 0.06449851f, 0.13315004f, -0.11601908f, 
    0.00503702f, 0.07937554f, 0.10335704f, -0.05109431f, -0.19164498f, -0.31373313f, 0.06448881f, 0.03137217f, 
    -0.03435732f, -0.13056450f, -0.06782015f, -0.06682064f, 0.08616605f, -0.04850337f, 0.04842354f, 0.15179156f, 
    -0.22345778f, -0.12922367f, -0.01120224f, 0.16250402f, -0.04123595f, -0.08483551f, -0.04688585f, -0.04065272f, 
    0.07490779f, 0.04737534f, 0.03927524f, 0.04294978f, 0.34618491f, 0.05423677f, 0.27410403f, -0.01769802f, 
    -0.14029697f, -0.04271956f, -0.06389365f, 0.08515421f, -0.01922240f, -0.09601422f, -0.04739635f, 0.02764179f, 
    -0.05899070f, -0.06890836f, 0.02635163f, 0.02259588f, 0.01396292f, -0.07858098f, 0.08726554f, 0.02972938f, 
    -0.02758163f, -0.05425865f, 0.12343589f, 0.02167202f, -0.04574132f, -0.19670694f, 0.25110626f, 0.20642243f, 
    0.02449970f, 0.10376119f, 0.10668331f, 0.05589100f, 0.11806023f, 0.11462189f, 0.00795454f, -0.02535135f, 
    -0.25200927f, -0.07094490f, -0.11823183f, -0.06071815f, -0.05025296f, 0.04251590f, -0.10173798f, 0.06402060f, 
    -0.02100770f, 0.04821591f, 0.02455415f, -0.02031863f, -0.22840719f, -0.05032043f, -0.01180506f, -0.00954607f, 
    -0.13049614f, 0.11562394f, -0.09380503f, 0.01343365f, 0.09579302f, 0.02073498f, -0.00849716f, 0.06718273f, 
    0.09343560f, 0.00386625f, 0.04653383f, 0.15704468f, -0.05058762f, 0.06372491f, 0.10664847f, 0.00277086f, 
    0.01486435f, -0.03332731f, 0.11954243f, -0.02242101f, -0.03036159f, 0.12678133f, 0.11750116f, -0.09552210f, 
    0.00972849f, 0.08090911f, -0.01540454f, 0.03777725f, 0.02777975f, -0.04736931f, -0.01283572f, -0.09568372f, 
    -0.18189003f, 0.17330118f, 0.15730137f, 0.06219894f, -0.03728024f, 0.04539168f, -0.10262316f, -0.09834611f, 
    -0.10683840f, 0.03386226f, -0.01992944f, -0.08245178f, -0.02441956f, 0.38281879f, 0.02172823f, 0.02014524f, 
    0.00214279f, -0.02288114f, 0.03425165f, 0.02929967f, 0.13726625f, 0.09789404f, -0.02219586f, 0.13370204f, 
    0.07862808f, 0.19413716f, 0.02878197f, -0.09987377f, -0.07189745f, 0.04570176f, 0.11435226f, 0.02480471f, 
    0.13360201f, -0.03436158f, 0.04858552f, 0.01672015f, -0.23958904f, -0.18420054f, -0.15447846f, 0.11315254f, 
    0.02237906f, 0.03927931f, -0.00409234f, -0.06311769f, 0.00571091f, 0.15331809f, 0.05838365f, -0.05005189f, 
    0.06391494f, -0.19057319f, -0.15796559f, -0.01300960f, -0.24922906f, -0.06306129f, 0.02603218f, -0.04682031f, 
    0.03967091f, 0.01896297f, -0.09624055f, -0.01959882f, 0.15776452f, 0.11130849f, 0.01804706f, -0.03282660f, 
    -0.05855757f, 0.05963070f, 0.12333345f, -0.02192302f, 0.08713434f, -0.01348185f, 0.18481366f, 0.13328360f, 
    -0.04927995f, -0.06992482f, -0.25646293f, 0.09550411f, 0.00739128f, -0.01235458f, -0.08675235f, -0.09337352f, 
    -0.00769029f, 0.02473860f, -0.04611256f, 0.00512257f, 0.32377782f, 0.19124205f, -0.22887591f, -0.11794267f, 
    0.01062169f, 0.00001970f, 0.05091677f, -0.08244711f, -0.02182797f, 0.06270747f, 0.08267692f, -0.00318537f, 
    -0.10370999f, -0.00978073f, -0.04713289f, -0.15461488f, 0.13440514f, -0.05949079f, -0.07121644f, 0.10535405f, 
    -0.01335705f, 0.07810112f, -0.04253042f, -0.05560654f, -0.07186261f, -0.14123155f, -0.01934993f, 0.13311276f, 
    -0.03942311f, -0.04644711f, 0.03246315f, -0.01255902f, 0.03260969f, 0.11472506f, 0.08076808f, 0.03474730f, 
    0.01706100f, -0.06291921f, 0.01547912f, 0.25296125f, -0.01187281f, -0.17316547f, -0.06115013f, -0.10678177f, 
    0.18174361f, -0.03516766f, 0.03490559f, -0.00555378f, 0.11503341f, 0.16201530f, 0.16464512f, -0.02577092f, 
    -0.06682821f, -0.09484250f, 0.14008175f, 0.07506988f, -0.06756265f, -0.01135053f, 0.03218320f, 0.02663151f, 
    0.00609094f, -0.01341251f, 0.09566703f, -0.01990257f, -0.02063889f, 0.07376015f, 0.03082981f, -0.01659038f, 
    -0.03518547f, 0.10506311f, 0.02612568f, -0.05947973f, 0.31554741f, 0.14423382f, 0.26329827f, -0.08107977f, 
    0.10553084f, -0.07542445f, 0.01270355f, -0.01408319f, 0.00554147f, 0.09582167f, 0.06245330f, -0.07485791f, 
    -0.24119698f, 0.05975231f, -0.13026883f, -0.11469261f, 0.03128232f, -0.05668538f, 0.03505639f, 0.03289258f, 
    0.13995089f, 0.05863253f, -0.05675660f, 0.05217073f, 0.22377276f, -0.05781405f, 0.05306364f, 0.02877407f, 
    0.01988493f, -0.03869040f, 0.00341466f, 0.05043837f, -0.04324259f, 0.11137744f, -0.09914309f, 0.10288134f, 
    0.02951550f, -0.01450587f, 0.03841541f, 0.03258045f, -0.01500420f, 0.02783513f, -0.02850191f, -0.01463164f, 
    0.01671225f, 0.00157377f, 0.00859356f, -0.02409788f, -0.05295844f, -0.05971811f, -0.04170927f, -0.04291237f, 
    0.02566935f, 0.03275827f, -0.03522732f, 0.00241844f, 0.01723958f, 0.03274808f, -0.01123751f, 0.03408226f, 
    -0.03731304f, -0.04978703f, 0.00850817f, -0.01058498f, -0.02746363f, 0.00837228f, -0.01399902f, -0.01541920f, 
    -0.00710115f, -0.03019651f, -0.02881524f, -0.01469621f, -0.01323127f, -0.00778849f, -0.04053500f, 0.00673888f, 
    -0.04440979f, -0.04522754f, -0.00461278f, 0.00157141f, 0.00911292f, -0.03833897f, 0.01814035f, -0.02155575f, 
    0.01925110f, 0.01406625f, -0.00173248f, 0.03816072f, -0.05607929f, 0.03889351f, -0.03183442f, 0.01549275f, 
    0.02135946f, -0.01846791f, -0.05094592f, -0.05347706f, -0.05598488f, -0.02026360f, -0.01983732f, -0.03947069f, 
    -0.00230482f, -0.00755553f, -0.03319241f, -0.00150524f, -0.02840208f, 0.01387492f, -0.00043299f, -0.03850132f, 
    0.00416355f, -0.05324262f, -0.01811619f, -0.05481376f, 0.02143347f, -0.01049307f, 0.03454183f, -0.02349663f, 
    0.01036116f, -0.01873260f, -0.04681374f, 0.03978093f, -0.03864009f, 0.04188307f, -0.00881978f, 0.03144720f, 
    0.04388286f, -0.02170164f, -0.01608795f, -0.01547637f, 0.00596007f, -0.05735308f, 0.01861021f, 0.00385789f, 
    0.04007393f, -0.01078553f, 0.02395691f, 0.03346823f, 0.02370168f, -0.03374265f, -0.01748991f, -0.03510304f, 
    -0.04737511f, 0.00578424f, 0.02316550f, -0.00707277f, -0.01228567f, -0.03790309f, -0.02465416f, 0.01086551f, 
    -0.05098972f, 0.04026589f, -0.01771050f, -0.04691217f, -0.05320407f, 0.03189044f, -0.00925752f, -0.05223829f, 
    -0.02588489f, 0.00959321f, 0.01717536f, 0.03694066f, -0.05610002f, -0.02270942f, -0.01116668f, -0.02762422f, 
    -0.00308481f, -0.02028800f, -0.00982134f, -0.00092086f, 0.01181340f, -0.00725132f, -0.01621534f, -0.00312608f, 
    -0.02930808f, 0.01318099f, -0.00472974f, -0.04500746f, -0.01649171f, -0.02217466f, -0.02658826f, 0.03100194f, 
    -0.02417397f, -0.02186557f, -0.03311839f, 0.01994921f, -0.05492153f, 0.03515908f, 0.03667909f, 0.00489930f, 
    -0.02621507f, 0.02671953f, 0.04057352f, -0.01020525f, -0.05220516f, -0.01253961f, 0.00364784f, -0.04268881f, 
    -0.00895040f, 0.01147394f, -0.01363111f, -0.04151219f, -0.05176743f, -0.02256596f, -0.04065480f, -0.01425357f, 
    0.01564955f, 0.00417379f, 0.01907829f, -0.02034685f, -0.03902199f, -0.02312588f, 0.00649890f, 0.01877294f, 
    -0.00681974f, 0.01864931f, 0.00633165f, 0.00758400f, 0.02479392f, -0.01345274f, 0.01865035f, -0.01251179f, 
    -0.03277286f, 0.01033344f, -0.01508780f, 0.02055904f, -0.01197508f, -0.02241101f, -0.00073698f, 0.02466547f, 
    -0.00348899f, 0.01264749f, 0.02175563f, 0.00413863f, -0.04648819f, -0.03803835f, -0.03866424f, -0.02452630f, 
    -0.00898089f, -0.03306790f, 0.00991265f, 0.00808374f, 0.03211353f, -0.02464203f, 0.04386280f, 0.00846611f, 
    -0.04274289f, -0.02993179f, 0.00379390f, -0.02602712f, -0.04600791f, -0.02902418f, 0.00454485f, 0.00382152f, 
    -0.01926722f, -0.02282166f, -0.00523310f, -0.01162999f, 0.00361216f, -0.01710177f, 0.01790367f, -0.02177328f, 
    0.00593471f, 0.03037244f, 0.01434576f, -0.00601204f, -0.03485780f, -0.02819723f, -0.05429528f, -0.00987019f, 
    -0.01548239f, 0.02631073f, -0.03747655f, -0.04496184f, 0.01808088f, 0.02235288f, 0.02997505f, -0.04861110f, 
    -0.01241130f, -0.03882560f, 0.00418208f, 0.03304816f, 0.03987913f, -0.02641296f, -0.00866601f, 0.02630135f, 
    0.00311416f, -0.03107321f, -0.00880620f, 0.01795303f, 0.01553764f, 0.02325601f, 0.04714849f, -0.02148758f, 
    -0.01425997f, 0.01834995f, -0.05441551f, -0.03287046f, -0.02931332f, -0.01587873f, 0.01905367f, -0.02685228f, 
    -0.02402145f, -0.02611411f, 0.01114800f, -0.00089328f, 0.01517561f, -0.05207865f, -0.02444307f, -0.03735261f, 
    -0.01140542f, -0.03157063f, 0.02703212f, 0.03422060f, -0.00040904f, -0.04693104f, 0.00179780f, -0.01804751f, 
    -0.01297719f, -0.04423948f, 0.02034759f, 0.01909047f, 0.03073391f, 0.01983750f, -0.02182667f, 0.03392802f, 
    0.05224062f, -0.03056617f, -0.06030050f, -0.04387968f, -0.02544488f, -0.04475834f, -0.01249926f, -0.05275942f, 
    0.01398342f, -0.03307387f, -0.01673122f, 0.02404971f, -0.05583383f, -0.00269207f, 0.00600643f, 0.03101977f, 
    -0.00990291f, 0.01438275f, 0.03846346f, 0.00216625f, 0.01201179f, -0.04507905f, 0.01887343f, 0.03218956f, 
    -0.02438161f, -0.04341451f, 0.03327782f, 0.00686225f, 0.01930445f, 0.04246441f, -0.01192717f, -0.00620418f, 
    -0.05509260f, -0.04618768f, -0.03830973f, 0.01255972f, 0.02968987f, 0.04278009f, 0.01995960f, -0.04038863f, 
    -0.00038028f, -0.02974696f, -0.03913330f, -0.03657951f, -0.04933465f, -0.04112935f, -0.00790914f, -0.00782838f, 
    0.00974928f, -0.01786640f, -0.01670587f, -0.03006770f, -0.00220687f, -0.03641726f, 0.00370409f, 0.00077129f, 
    0.02706003f, -0.01629494f, 0.01446860f, 0.01446118f, -0.04233817f, 0.02268804f, -0.02175053f, 0.02634949f, 
    -0.04871029f, -0.00659820f, -0.02795114f, -0.02076232f, 0.00512353f, -0.05115964f, 0.03346437f, 0.00619850f, 
    -0.05106876f, -0.01754451f, -0.02378508f, 0.02796989f, 0.02211112f, 0.03203952f, 0.03311861f, 0.01183605f, 
    0.01865910f, -0.05518837f, -0.03409704f, 0.00354504f, 0.03623512f, -0.05060595f, -0.03214101f, -0.04701874f, 
    -0.03484691f, -0.02247607f, 0.03030354f, 0.00638136f, -0.04618501f, -0.05287900f, -0.04059629f, -0.05066799f, 
    0.00816163f, 0.02813714f, -0.03387923f, -0.01398958f, 0.02893637f, -0.03635717f, -0.02847028f, 0.02942689f, 
    0.01673894f, -0.01742925f, 0.00663029f, 0.00679184f, 0.02619455f, -0.02471735f, -0.01037784f, -0.01665192f, 
    -0.00791351f, 0.03742986f, 0.03946497f, 0.04689664f, -0.01380450f, -0.03006253f, 0.03219929f, -0.01366224f, 
    -0.00221685f, -0.01630314f, -0.03800027f, 0.02123142f, -0.02401935f, -0.03061381f, -0.00865777f, 0.03622603f, 
    -0.01831162f, 0.00560776f, -0.01868644f, -0.01378877f, -0.05810557f, -0.03255861f, -0.04096726f, 0.03025346f, 
    0.02465759f, -0.00551077f, 0.01246158f, 0.04890297f, -0.02021132f, -0.01749518f, -0.00515264f, 0.02448278f, 
    -0.03242866f, -0.05855114f, 0.01833807f, -0.02670830f, 0.03844233f, 0.01018241f, -0.05411350f, -0.01415534f, 
    -0.04499270f, 0.01714080f, 0.00724245f, -0.01147370f, -0.05821834f, 0.02648659f, -0.03743336f, 0.03403309f, 
    -0.02529972f, -0.02354718f, 0.00989949f, -0.03695056f, 0.01875279f, 0.00541371f, -0.00693923f, -0.03012504f, 
    0.01201134f, -0.00663029f, -0.04625844f, -0.05567408f, 0.01110711f, 0.02162982f, -0.04194715f, -0.03495356f, 
    -0.05423968f, -0.04530505f, -0.01424428f, -0.05485528f, 0.03448934f, -0.00029151f, 0.03694243f, 0.01243462f, 
    0.02778535f, -0.02323322f, -0.01045520f, -0.02367944f, -0.04709458f, -0.01896392f, 0.03408914f, 0.00372571f, 
    -0.00474695f, 0.01641117f, -0.04091407f, -0.00704439f, 0.03657891f, 0.02146198f, -0.02918191f, -0.01392621f, 
    -0.03805600f, 0.03002401f, -0.03820096f, 0.00699769f, -0.02366074f, -0.02781202f, -0.05423820f, 0.01666157f, 
    -0.03521540f, 0.03913333f, 0.03766939f, -0.02814564f, -0.04801312f, -0.00475362f, -0.06454904f, 0.02675263f, 
    -0.03480348f, -0.03185507f, -0.03801199f, -0.02640422f, -0.01528559f, -0.00381803f, 0.00135292f, 0.01481763f, 
    -0.03299589f, -0.04194751f, -0.02324635f, -0.00506563f, -0.02772054f, -0.01841586f, -0.01303224f, -0.01854783f, 
    -0.03482547f, 0.00337884f, 0.01990064f, 0.00930968f, -0.03831164f, -0.04250159f, -0.00732286f, 0.02985897f, 
    -0.04344262f, -0.04859177f, -0.00427756f, 0.04449019f, 0.01082643f, -0.05324639f, -0.00971846f, 0.05240340f, 
    -0.04554942f, -0.04765573f, 0.02858946f, 0.00822135f, 0.02713847f, -0.01479126f, -0.01774498f, -0.00087927f, 
    -0.03388531f, 0.00141136f, 0.03459293f, 0.00573291f, -0.02448277f, 0.00248152f, -0.00643453f, 0.03948181f, 
    0.03250228f, 0.00575205f, -0.03024091f, -0.00928828f, 0.01386178f, -0.00094971f, 0.02807649f, -0.03029927f, 
    -0.00343541f, -0.03995535f, 0.00074222f, -0.01099198f, 0.02148394f, 0.00020475f, 0.00296974f, 0.03295606f, 
    0.03290150f, -0.04440644f, 0.00449354f, 0.03689041f, 0.04217116f, 0.00268915f, 0.02221632f, 0.03040525f, 
    -0.03814820f, -0.00906636f, -0.03800582f, -0.01338602f, 0.03390642f, 0.03554407f, -0.00610365f, -0.03984837f, 
    0.04201362f, -0.01272782f, 0.00039623f, -0.02312527f, 0.02927676f, 0.03536634f, 0.01240683f, -0.02982119f, 
    -0.00122691f, -0.01750058f, -0.04853192f, 0.02966892f, -0.04925334f, -0.00831945f, -0.00557315f, 0.00459651f, 
    0.03398773f, 0.01923089f, -0.00969441f, 0.04141260f, -0.03520621f, 0.02771960f, -0.04662775f, -0.00125091f, 
    -0.01055198f, -0.05312197f, 0.00354552f, -0.01516699f, -0.05308829f, -0.02456495f, -0.02640934f, -0.00420168f, 
    0.02319391f, 0.01812315f, -0.00620657f, 0.00041432f, -0.02515472f, 0.03904718f, 0.01542548f, -0.03923695f, 
    -0.04556294f, -0.03443301f, 0.03589437f, -0.00172994f, 0.02621749f, -0.04966367f, -0.01493855f, -0.00735786f, 
    0.05080067f, 0.02736923f, 0.01222204f, 0.03408246f, -0.05327092f, -0.03336905f, 0.01157591f, -0.03624637f, 
    -0.04932959f, 0.01502354f, -0.00251322f, -0.03694445f, -0.02235682f, -0.03493869f, -0.04593135f, -0.02022957f, 
    -0.05764852f, -0.02004309f, 0.05062502f, 0.02914200f, 0.01568882f, 0.00670380f, 0.00108205f, -0.03085991f, 
    0.01763028f, -0.05885562f, -0.05114847f, -0.05838218f, -0.01318982f, -0.02591890f, 0.00563822f, 0.03047301f, 
    -0.00773481f, -0.01279843f, -0.03972993f, -0.01127798f, 0.00417499f, 0.03654656f, 0.00615531f, -0.00811078f, 
    -0.02630318f, 0.03644609f, -0.04221296f, -0.01795730f, 0.00617898f, 0.01509643f, -0.02365066f, -0.02228122f, 
    -0.03277186f, -0.05278393f, -0.03609515f, -0.00818669f, 0.02858287f, 0.03381938f, 0.02319485f, -0.05897137f, 
    0.00070955f, 0.00702831f, -0.01020639f, 0.01997209f, -0.04281078f, 0.03376873f, 0.04267909f, -0.00984203f, 
    -0.04551176f, 0.00346771f, 0.02852135f, 0.03869043f, 0.02120537f, -0.01149879f, 0.04580298f, 0.02020229f, 
    -0.01347263f, 0.02831481f, -0.04166212f, -0.05804493f, 0.00292374f, -0.03498297f, -0.04576012f, -0.02936817f, 
    0.01233813f, -0.01965901f, 0.03277262f, -0.00005219f, -0.03803016f, -0.05246992f, -0.01555679f, 0.00286819f, 
    -0.03935874f, -0.03604240f, -0.01346444f, 0.00669696f, -0.05210378f, 0.02012626f, -0.05187685f, 0.00972310f, 
    -0.06015099f, -0.04344618f, -0.05944589f, 0.00954364f, -0.03731244f, 0.00797131f, -0.01702389f, 0.01302513f, 
    -0.00566431f, 0.02785240f, 0.01542501f, 0.00538286f, -0.01872915f, -0.04246853f, -0.05411806f, -0.05822900f, 
    0.02349852f, 0.04289404f, -0.04454404f, 0.00869071f, -0.01866129f, 0.00379660f, -0.01849847f, -0.00881441f, 
    0.04192910f, -0.03982091f, 0.00223342f, -0.01556263f, 0.02816970f, -0.02394130f, -0.04566079f, -0.00318548f, 
    -0.01390012f, 0.00866166f, 0.02534459f, 0.03029123f, -0.01502131f, -0.01346596f, 0.01390579f, -0.02920463f, 
    -0.16996445f, 0.00413896f, 0.38358715f, -0.12471766f, 0.00499466f, -0.07233515f, -0.03624592f, -0.03310251f, 
    0.02844634f, 0.02639171f, 0.03208643f, -0.01085164f, -0.33612019f, -0.20827012f, 0.29698154f, 0.15058382f, 
    -0.09983928f, 0.03935514f, -0.01439247f, -0.00349610f, 0.01541866f, -0.09054998f, 0.06209095f, -0.02973736f, 
    0.29729152f, -0.22694135f, -0.03998012f, 0.18493466f, -0.11681505f, 0.02704565f, 0.05674946f, -0.06831467f, 
    0.08911118f, -0.01597506f, -0.02794112f, 0.01076455f, -0.07520320f, 0.09047570f, -0.04188517f, -0.05596302f, 
    0.11524203f, 0.09340031f, -0.04102692f, 0.04246417f, 0.03728126f, 0.06373908f, -0.05554175f, -0.03983596f, 
    0.04720867f, -0.09704071f, -0.08003919f, 0.03319610f, -0.12555991f, 0.13503525f, 0.04517359f, 0.00580615f, 
    -0.06604856f, 0.07482021f, 0.09735303f, -0.05633929f, -0.19991586f, -0.15893993f, 0.21847561f, 0.08793974f, 
    -0.02063030f, -0.00616269f, -0.01058344f, -0.03246481f, 0.03820685f, 0.04256982f, 0.09748690f, 0.13879162f, 
    -0.07705401f, 0.13303928f, 0.08940613f, 0.07797772f, -0.16949829f, 0.01892586f, -0.05074539f, 0.05154942f, 
    -0.08484894f, -0.05080221f, 0.03436795f, 0.03259483f, 0.26903546f, 0.09457930f, 0.07305358f, 0.05994577f, 
    0.00776921f, -0.03913342f, 0.08398686f, -0.02351199f, 0.08245759f, 0.01008185f, 0.04197189f, 0.03845005f, 
    -0.05179771f, 0.23778977f, -0.05036618f, 0.07698832f, -0.05098027f, 0.05963255f, 0.05300001f, 0.04667667f, 
    0.00147704f, -0.02989273f, -0.00471737f, -0.02411441f, -0.23025142f, 0.17084171f, -0.26695395f, 0.03623043f, 
    0.04896960f, 0.02240675f, 0.05417695f, 0.00709935f, -0.04572321f, 0.00886236f, -0.04442367f, 0.11527644f, 
    -0.10676264f, -0.15892801f, -0.08340403f, 0.10011531f, -0.03942923f, 0.10779481f, -0.04113669f, 0.03666652f, 
    -0.07089897f, 0.09725001f, 0.02253554f, -0.00490721f, 0.30126077f, -0.19126281f, -0.02980032f, 0.05117059f, 
    0.01589303f, 0.08270741f, -0.00987731f, -0.10252351f, -0.02445496f, 0.06746039f, -0.04773378f, 0.08673429f, 
    -0.05098265f, 0.15045306f, 0.19530837f, 0.18406294f, -0.04581508f, 0.10177118f, 0.04275468f, 0.13268949f, 
    -0.02391252f, 0.06517398f, 0.01105889f, 0.01225484f, 0.36038747f, -0.30122837f, 0.25119945f, -0.05312698f, 
    -0.23855841f, 0.00123744f, 0.05795949f, 0.14423576f, -0.06701927f, -0.01492688f, -0.05811822f, -0.04946719f, 
    0.18567365f, 0.19709270f, -0.12082761f, -0.02146692f, 0.08969229f, 0.00216613f, 0.07183920f, 0.08545046f, 
    -0.02107700f, 0.02935090f, 0.03975460f, 0.06479008f, -0.00113830f, -0.16144921f, -0.06068273f, 0.08945210f, 
    0.13801108f, -0.06095874f, 0.03640490f, 0.04576140f, 0.02629220f, -0.03079137f, -0.02473015f, 0.04235830f, 
    -0.14922851f, -0.00627117f, 0.00649204f, 0.07541146f, 0.07782444f, 0.02629499f, -0.02236284f, 0.09373089f, 
    0.06908419f, -0.02852622f, 0.00594388f, -0.06961837f, 0.00234549f, -0.00582352f, 0.24593562f, 0.00546305f, 
    -0.18090001f, -0.04139509f, -0.00974319f, 0.02272991f, -0.06373531f, -0.06924387f, 0.11378128f, 0.09850229f, 
    0.00385434f, -0.09906653f, -0.13023461f, -0.15096109f, -0.01051594f, -0.00462235f, 0.02012692f, -0.11621892f, 
    0.10414385f, 0.11557088f, 0.04223296f, 0.08055461f, -0.01799042f, 0.07664518f, 0.04653297f, 0.14099225f, 
    -0.11356965f, -0.01168792f, -0.01588531f, -0.04547155f, 0.08035815f, 0.08877720f, -0.02851225f, 0.02072940f, 
    -0.00791888f, 0.19531114f, 0.04114574f, 0.33913240f, 0.03139504f, 0.08489668f, 0.13361111f, 0.10739309f, 
    -0.06303180f, 0.01416126f, 0.02661869f, -0.01209141f, -0.25580314f, -0.01592234f, 0.08434857f, -0.23392497f, 
    0.12557937f, -0.02053835f, -0.06343219f, -0.13870688f, 0.04521307f, 0.02662765f, -0.12236036f, 0.07478713f, 
    0.06248929f, 0.18395008f, 0.07790866f, 0.19784164f, 0.10187703f, -0.06694780f, 0.09558854f, -0.04879158f, 
    -0.00233798f, 0.06800561f, -0.07176319f, -0.02650476f, -0.06641009f, -0.05110594f, 0.04663088f, 0.01966453f, 
    0.05939484f, -0.00484587f, 0.10961470f, 0.10522045f, -0.08334929f, 0.05880748f, -0.03782522f, -0.15033045f, 
    0.02104133f, -0.17216803f, 0.11794259f, -0.01636984f, 0.11393157f, -0.08370447f, 0.15670997f, 0.04248300f, 
    -0.09666689f, 0.07406646f, 0.05303541f, 0.14344744f, 0.10639408f, 0.28000048f, -0.02815428f, 0.16905759f, 
    -0.07943180f, 0.05675091f, -0.00774997f, -0.09802850f, 0.05518753f, -0.08213843f, 0.00352222f, 0.11453886f, 
    0.17264406f, 0.23587334f, -0.15419964f, -0.03601088f, 0.03770062f, 0.14157590f, 0.00114622f, 0.16468120f, 
    -0.02948097f, 0.10464037f, 0.06041272f, 0.03597034f, -0.41208863f, -0.02219470f, -0.12518694f, -0.18522620f, 
    0.07016041f, -0.02572431f, -0.09723452f, -0.03397423f, 0.08901859f, 0.00373609f, 0.06283175f, -0.00445091f, 
    -0.34129703f, -0.08240566f, 0.14567417f, 0.04740201f, 0.06667504f, 0.00922168f, -0.08423192f, -0.09260934f, 
    0.09214249f, 0.05673562f, -0.07457335f, 0.09865495f, 0.00763989f, -0.02287027f, -0.02400362f, 0.10890962f, 
    0.03234870f, -0.02273319f, 0.14343037f, 0.15781881f, 0.11569785f, 0.03089171f, -0.00839666f, 0.06013777f, 
    -0.19635102f, 0.02486731f, 0.10139585f, -0.02624716f, -0.00807271f, 0.08012993f, 0.01568125f, 0.01761676f, 
    -0.14678830f, -0.01107937f, -0.03054204f, -0.10796711f, -0.51494896f, -0.09899198f, 0.02567829f, -0.07609369f, 
    0.02830197f, -0.09828292f, -0.01174630f, 0.08485434f, 0.05668824f, 0.01557977f, 0.02005246f, -0.03863460f, 
    -0.03973120f, -0.01647238f, -0.00537025f, 0.00738406f, -0.05503379f, 0.03281811f, 0.01323271f, -0.00735353f, 
    0.02254317f, -0.04202759f, -0.02700204f, -0.03845762f, -0.02520691f, 0.02910046f, 0.01875220f, -0.00459471f, 
    -0.05661958f, 0.03029430f, 0.00739739f, 0.03909739f, 0.02216111f, -0.02813839f, -0.04930094f, 0.03923960f, 
    -0.01314019f, -0.04113028f, -0.01630596f, 0.01712256f, 0.00672196f, -0.00420538f, -0.02169291f, -0.04713464f, 
    -0.00387022f, -0.03024736f, 0.02393108f, 0.00752318f, 0.03986353f, 0.02057929f, -0.03343898f, 0.00973773f, 
    0.01397966f, 0.01673102f, 0.04150136f, 0.03177658f, -0.02255010f, 0.02340032f, 0.03608968f, 0.02321701f, 
    0.02071224f, 0.02254618f, -0.03017319f, 0.03266640f, -0.04160389f, -0.05539144f, -0.05768243f, 0.03651531f, 
    0.02427932f, 0.00566830f, -0.03685977f, -0.05085282f, -0.00535774f, -0.00317536f, -0.01197135f, 0.00682392f, 
    -0.04394646f, -0.04336406f, -0.04553738f, -0.03090591f, 0.01819637f, 0.02345958f, 0.02697012f, 0.02226792f, 
    0.04125494f, -0.04522126f, -0.00370314f, -0.02998736f, 0.03787931f, -0.05365092f, -0.05239314f, -0.03014285f, 
    -0.02768369f, -0.00719283f, 0.00607844f, -0.05113311f, -0.03345560f, -0.05425955f, -0.01574931f, -0.00827243f, 
    -0.00211504f, 0.03980812f, -0.00141811f, 0.02848174f, 0.00524531f, 0.01696080f, -0.05487787f, 0.03015455f, 
    -0.03215784f, -0.01248592f, -0.05075544f, -0.04679202f, 0.04126576f, 0.01173126f, 0.02420819f, 0.01944332f, 
    -0.01579380f, 0.01219407f, -0.00132991f, -0.00246281f, 0.00812573f, 0.01184604f, -0.05178806f, 0.00710198f, 
    -0.01157542f, 0.03449174f, -0.00287073f, 0.03520005f, 0.02258648f, -0.00972598f, -0.04020721f, 0.01208053f, 
    -0.00979078f, -0.02657860f, -0.05549920f, 0.03754582f, -0.01196343f, 0.03938462f, -0.02628567f, -0.05201091f, 
    0.00695897f, 0.00324764f, -0.00344025f, -0.05543061f, 0.02279191f, 0.01651474f, -0.02824424f, -0.00395569f, 
    -0.01640904f, 0.04065426f, 0.02889870f, 0.02460373f, 0.01758380f, -0.00899779f, 0.00561538f, 0.01458253f, 
    0.01059755f, 0.02334979f, -0.01642725f, -0.01483570f, -0.00590558f, -0.05919040f, -0.03560483f, -0.05109206f, 
    0.02997551f, -0.03511640f, 0.03255641f, -0.04522143f, 0.01895122f, -0.05051526f, 0.02866559f, -0.01327712f, 
    -0.02056105f, -0.03690351f, 0.03798229f, 0.02309301f, 0.01437693f, -0.00674942f, -0.01967591f, -0.03699670f, 
    -0.02795551f, -0.05538014f, 0.01402881f, -0.02524689f, -0.01360333f, -0.01025489f, -0.03801139f, 0.01292528f, 
    -0.05612893f, 0.01760382f, -0.03436597f, -0.05187918f, 0.03279193f, -0.05602197f, 0.03222236f, -0.00687986f, 
    0.00807576f, 0.01383569f, 0.02246114f, 0.02938895f, -0.03126506f, 0.01990770f, -0.04598349f, -0.01249331f, 
    -0.03720768f, 0.01771773f, -0.03140054f, 0.03064700f, -0.05444243f, 0.02386441f, 0.02616062f, 0.00638848f, 
    0.01970900f, 0.01032873f, -0.00477633f, 0.01636413f, -0.01430254f, -0.05326771f, 0.03570031f, -0.01247006f, 
    -0.00164018f, -0.02431910f, -0.05574561f, 0.01939748f, -0.04510793f, -0.04075925f, 0.02005919f, -0.00788866f, 
    0.00120026f, -0.03239588f, 0.02616688f, -0.05420665f, -0.00721197f, 0.02438570f, -0.05833631f, -0.00630789f, 
    -0.01674604f, 0.01800103f, 0.00019720f, 0.02297593f, 0.02317040f, -0.02893591f, 0.02957883f, -0.01774536f, 
    0.02824406f, -0.01872790f, -0.02166806f, -0.03629766f, -0.02050540f, 0.04170688f, -0.02621957f, 0.00654444f, 
    0.03519331f, -0.00845327f, -0.01827205f, -0.05721616f, -0.00548969f, 0.02632787f, -0.04467950f, 0.01841373f, 
    0.02899193f, -0.02806774f, 0.03980145f, -0.05744737f, -0.03154777f, -0.03321717f, 0.01645296f, -0.00708223f, 
    -0.04694338f, -0.03173805f, -0.04882896f, -0.02771372f, -0.02936549f, 0.01593524f, -0.04636318f, -0.00667232f, 
    0.01123826f, -0.01921435f, -0.05333268f, -0.01320498f, 0.01296542f, 0.00795962f, 0.03045821f, 0.00453779f, 
    -0.02883822f, -0.05808937f, 0.03747346f, 0.01735186f, -0.04736449f, -0.03044203f, 0.00194756f, -0.00253282f, 
    0.03345239f, 0.03833402f, 0.01979641f, -0.05240555f, 0.00826457f, -0.04137201f, -0.04074177f, 0.01741773f, 
    -0.03676631f, -0.02611912f, 0.00960211f, 0.02549431f, 0.00385844f, -0.04198275f, -0.02586774f, 0.00056006f, 
    -0.01543921f, -0.01611694f, 0.00843368f, 0.03622118f, 0.02358394f, -0.01123125f, 0.03598444f, -0.04907189f, 
    0.00854691f, -0.01762088f, 0.00740635f, 0.04069215f, -0.02941775f, 0.01135467f, 0.02226108f, -0.02414490f, 
    -0.02499611f, -0.03018825f, -0.01478965f, 0.01190226f, -0.03906772f, -0.01849833f, 0.01992638f, -0.02422488f, 
    -0.04509621f, 0.01413968f, -0.05206150f, 0.00242964f, -0.02280670f, -0.02656409f, -0.00142977f, -0.05724677f, 
    0.01612146f, 0.03808608f, -0.05360428f, 0.02917252f, -0.03063263f, -0.03371470f, -0.02403904f, -0.05646172f, 
    0.00704679f, -0.03548252f, -0.00808794f, 0.01289852f, -0.04155144f, -0.01565692f, 0.03092540f, 0.02421577f, 
    -0.03853296f, -0.05475875f, -0.03360385f, 0.00103170f, -0.02978009f, -0.04187866f, 0.03528818f, 0.01408037f, 
    -0.05320127f, 0.03576434f, -0.03162729f, -0.02954558f, -0.04733331f, 0.01265989f, 0.00753756f, -0.01363034f, 
    -0.02675703f, -0.05179267f, -0.01098741f, -0.03470733f, 0.04265399f, -0.05129831f, 0.02401442f, -0.04769595f, 
    -0.03024422f, -0.03538219f, 0.03500218f, 0.03270565f, -0.02178714f, -0.03973331f, -0.04464927f, -0.02648223f, 
    -0.03636397f, -0.04684746f, 0.01161668f, -0.01964776f, 0.00143010f, 0.02875173f, -0.01493903f, -0.03249375f, 
    -0.04806957f, -0.03867863f, -0.03175239f, -0.03023181f, -0.04191763f, -0.00166461f, 0.01422882f, -0.00260953f, 
    -0.04858448f, -0.05840590f, 0.02607341f, -0.05135905f, -0.01700501f, -0.00125676f, 0.01269568f, 0.00884875f, 
    -0.02875513f, -0.01298353f, 0.00383925f, -0.00486646f, 0.01875029f, 0.03871390f, 0.00300499f, -0.03507192f, 
    -0.00522472f, 0.03851138f, -0.00955130f, 0.00782917f, 0.02488509f, 0.02861789f, 0.01026484f, -0.02816871f, 
    -0.00786100f, -0.04272178f, 0.03416970f, 0.00440260f, -0.01986485f, -0.05684834f, -0.03025558f, -0.02626635f, 
    -0.00630302f, 0.00060848f, 0.04129693f, 0.01989456f, -0.05314759f, 0.03150932f, -0.01292024f, 0.03099765f, 
    -0.00350016f, -0.03770278f, -0.02716482f, -0.00062332f, 0.00909580f, -0.00834994f, 0.01573136f, 0.03353516f, 
    -0.02769300f, 0.02629310f, -0.02841708f, -0.02421749f, -0.02428469f, -0.04987323f, -0.01043067f, 0.04015594f, 
    0.02812910f, 0.00360150f, -0.02947135f, -0.02559861f, -0.05413825f, 0.01405588f, 0.01981395f, 0.02683525f, 
    0.03719649f, -0.01334128f, -0.04018834f, 0.00458279f, 0.01172862f, -0.05089702f, -0.03099542f, -0.03352094f, 
    -0.03031606f, -0.04246104f, -0.03020079f, 0.02060489f, 0.04135590f, -0.04112674f, -0.05764218f, 0.02732019f, 
    -0.01623086f, 0.03049456f, -0.03322639f, -0.05555348f, -0.01387281f, -0.00045968f, -0.02965891f, 0.02254464f, 
    0.02891683f, -0.02108321f, -0.02539717f, -0.00477273f, 0.02515034f, -0.04994891f, 0.00219285f, 0.00916284f, 
    -0.01675673f, -0.05220322f, 0.03468973f, -0.05287219f, 0.02896986f, -0.04870395f, -0.00958532f, -0.02831521f, 
    -0.01179781f, -0.01007417f, 0.02586082f, 0.02789157f, -0.01181532f, 0.03320440f, 0.01800678f, -0.03225620f, 
    0.02654775f, -0.04474159f, 0.03522234f, 0.00887309f, 0.00669419f, 0.01560564f, -0.05015156f, -0.02020235f, 
    -0.05498810f, 0.00772691f, -0.04387715f, 0.00092938f, 0.04424712f, -0.01032086f, -0.05356025f, 0.03076512f, 
    0.00535508f, 0.03378639f, -0.02196516f, -0.04040010f, 0.03309438f, -0.02962100f, -0.00516046f, 0.01952492f, 
    0.02427345f, 0.00333885f, 0.00549342f, 0.03653020f, -0.04451550f, -0.00693487f, -0.04227343f, 0.02523099f, 
    0.01254216f, -0.00629122f, -0.05058655f, 0.03670976f, -0.01046705f, -0.05492254f, -0.01903809f, 0.02082379f, 
    0.01702508f, 0.03335958f, 0.03674885f, 0.01052542f, 0.01816604f, -0.00400824f, -0.00808339f, 0.00347806f, 
    -0.05724568f, -0.05084965f, -0.00251177f, 0.00040817f, 0.01591942f, -0.02632155f, 0.02589659f, 0.01921791f, 
    -0.05857050f, -0.04945904f, 0.03635043f, -0.02407842f, -0.00243858f, -0.01784454f, 0.04150031f, 0.02914929f, 
    -0.01426313f, -0.02845851f, 0.01458579f, 0.01461704f, 0.02937185f, -0.02771184f, 0.01946207f, -0.05956509f, 
    0.04242188f, -0.00997737f, 0.00873705f, -0.01078606f, -0.03420707f, 0.03629551f, 0.00956274f, -0.06025863f, 
    0.02756573f, -0.02913453f, -0.03738232f, -0.05180226f, 0.00492600f, -0.03391428f, 0.03163072f, 0.03902034f, 
    -0.05285720f, -0.03185674f, -0.00690131f, -0.04219040f, -0.04545062f, -0.05334938f, -0.03143033f, 0.00093539f, 
    0.02708168f, 0.00662071f, -0.02837987f, -0.04529384f, -0.03839284f, -0.02234526f, -0.03512668f, -0.03805535f, 
    -0.04030971f, -0.01872315f, 0.01022106f, -0.03320105f, -0.00430340f, -0.00421411f, -0.00217316f, -0.03978822f, 
    -0.02703440f, 0.01088777f, -0.02209134f, -0.05499778f, -0.01021784f, -0.04430514f, -0.01371824f, -0.05601805f, 
    -0.03856770f, 0.03875974f, -0.06090627f, -0.06700158f, -0.05590868f, -0.03462721f, -0.05741368f, 0.02226871f, 
    -0.01290177f, -0.02759034f, -0.01425174f, -0.05558569f, -0.00010996f, 0.01951247f, -0.04097369f, -0.04129770f, 
    0.03633734f, -0.05503425f, -0.01378957f, -0.01890744f, -0.05701701f, 0.03009443f, 0.00443594f, -0.06283735f, 
    0.00455683f, 0.00869410f, -0.01764866f, 0.01399312f, -0.05611631f, 0.01807025f, -0.03021675f, -0.02674915f, 
    -0.00615854f, 0.01256441f, 0.00395786f, 0.01096025f, 0.02196728f, 0.04245702f, -0.02963681f, -0.00292792f, 
    -0.01873737f, 0.03767007f, -0.02488063f, -0.01647222f, -0.01980650f, 0.04186900f, 0.01087830f, -0.04618208f, 
    0.02422523f, 0.03772621f, -0.01183848f, -0.00846323f, 0.01805330f, 0.00012897f, -0.03340122f, 0.02249701f, 
    -0.04652516f, -0.00304150f, -0.03064425f, 0.02976445f, -0.05471720f, -0.02970195f, 0.02856586f, -0.01937090f, 
    -0.04680109f, 0.01708723f, -0.00129503f, -0.01391817f, 0.03902937f, 0.00462669f, -0.02470176f, -0.02194512f, 
    0.01067718f, -0.03386851f, -0.02032043f, -0.03251190f, -0.02944993f, 0.00548387f, -0.04454549f, 0.00145393f, 
    -0.06267603f, -0.03935401f, -0.03951673f, -0.00912089f, -0.03340997f, 0.00324995f, -0.02551528f, 0.00520207f, 
    0.02055338f, 0.00513131f, 0.02061210f, -0.05151143f, -0.03256585f, 0.00798568f, -0.05093583f, 0.03451008f, 
    -0.01421054f, -0.02301769f, 0.00247171f, -0.01657419f, 0.01175272f, -0.04824670f, -0.03559364f, 0.00173588f, 
    -0.03633331f, -0.05620492f, 0.03072240f, -0.04204754f, 0.01691332f, -0.02025647f, -0.03756432f, 0.04937057f, 
    -0.01528839f, -0.03967373f, 0.02848656f, 0.01148515f, -0.00020893f, -0.03733527f, -0.00351754f, 0.00495280f, 
    0.01764188f, 0.00593408f, 0.02653601f, -0.00530585f, -0.04039950f, -0.00830221f, -0.02258613f, 0.03559405f, 
    0.01405570f, -0.05035143f, -0.01114078f, 0.01548516f, 0.02075437f, 0.00902619f, 0.02972470f, 0.00478699f, 
    -0.05686853f, 0.02689972f, 0.03016712f, -0.01841361f, 0.00167817f, 0.02559736f, -0.00657640f, 0.02864715f, 
    0.01078688f, 0.00169657f, 0.04457309f, -0.04643193f, -0.04061462f, 0.05057111f, 0.02011381f, -0.04320889f, 
    0.04468079f, -0.00324170f, 0.02488267f, -0.01446753f, -0.01265450f, 0.03380535f, -0.02693209f, -0.02592620f, 
    0.00402923f, 0.02825481f, 0.03591843f, 0.04534097f, -0.01393376f, 0.00393684f, -0.02766822f, -0.02702230f, 
    -0.05601603f, -0.00308698f, 0.00897542f, 0.00688131f, -0.02070823f, -0.04818679f, -0.04247730f, 0.01721574f, 
    -0.01919331f, 0.00386066f, -0.04973028f, 0.00773022f, -0.03494864f, 0.01289123f, 0.02788396f, 0.02569273f, 
    0.03879067f, -0.02381602f, 0.00592565f, -0.04766013f, 0.01914888f, 0.01765574f, 0.01639034f, -0.01527786f, 
    -0.01722170f, -0.01859705f, -0.04611035f, -0.05581190f, 0.04193064f, -0.02463930f, 0.02511861f, 0.00992001f, 
    0.05224751f, -0.01347159f, -0.00844719f, 0.01572837f, -0.00107338f, -0.04888920f, -0.00126572f, -0.01619177f, 
    0.03872038f, -0.00737418f, -0.00569061f, -0.01532177f, -0.02508794f, 0.03500575f, 0.03547502f, -0.01544106f, 
    -0.05047492f, -0.05204996f, -0.00345817f, 0.01332645f, -0.00632499f, -0.00519780f, -0.00706834f, 0.00252445f, 
    -0.02196553f, -0.01217844f, -0.06211884f, 0.00260211f, -0.01867420f, 0.01905961f, -0.05467040f, 0.04124583f, 
    0.03412060f, -0.01808992f, -0.02761898f, 0.01883505f, -0.04919676f, -0.04322189f, -0.03992187f, -0.02400834f, 
    0.01989235f, -0.00777947f, -0.00667551f, 0.02145219f, -0.02244873f, 0.03371422f, -0.01703008f, -0.02383432f, 
    -0.04473922f, -0.00672424f, -0.04878964f, -0.04502677f, 0.02379978f, -0.05041908f, 0.01232035f, -0.00128455f, 
    0.03833491f, -0.01697635f, -0.01958619f, -0.02476225f, -0.02797765f, -0.01533008f, -0.00508313f, -0.04492711f, 
    -0.00289029f, -0.02203768f, 0.00967323f, 0.03475718f, 0.03844762f, 0.04091766f, -0.01944403f, 0.00670729f, 
    -0.01891139f, 0.01727035f, -0.00512870f, -0.04204165f, -0.04940513f, 0.01260295f, -0.03582911f, -0.00244065f, 
    -0.05764792f, -0.04882459f, -0.05154449f, 0.03549588f, 0.00376859f, -0.01768965f, 0.02424473f, 0.01661445f, 
    0.04091042f, 0.00582175f, -0.05099671f, -0.03550730f, 0.04709956f, 0.03575913f, -0.00207469f, 0.02660438f, 
    -0.00517264f, 0.04514471f, 0.02410481f, 0.00861831f, 0.01565457f, -0.04533183f, 0.01510608f, 0.01201711f, 
    -0.05556180f, -0.03202075f, -0.03132600f, -0.03960379f, -0.00712444f, -0.04598219f, 0.01817130f, 0.02598158f, 
    -0.01496246f, -0.00942402f, -0.03606997f, -0.04409254f, -0.02928509f, 0.00263718f, -0.04300413f, 0.01649231f, 
    -0.01609327f, 0.04542840f, -0.01746603f, -0.02578326f, -0.01074710f, 0.00808745f, -0.04141195f, 0.01169336f, 
    -0.02711527f, 0.00030841f, 0.04279675f, -0.03834122f, -0.01854312f, -0.04621147f, 0.00111732f, -0.03817956f, 
    0.02400537f, 0.00588424f, -0.03130573f, -0.05317366f, 0.00366726f, -0.04911846f, 0.03611768f, 0.02477469f, 
    0.03667742f, -0.03131802f, -0.04853031f, 0.02669567f, -0.01238635f, 0.01744330f, -0.03705624f, -0.02487237f, 
    0.04428620f, -0.05233657f, -0.04787033f, -0.03599391f, -0.01907841f, -0.03750295f, -0.01776885f, 0.00861948f, 
    -0.00284317f, -0.04024643f, 0.00208828f, 0.03748114f, 0.03266842f, 0.01598831f, 0.04139575f, 0.04322146f, 
    -0.01068019f, 0.02804564f, -0.00768970f, -0.03156035f, -0.01934176f, 0.02645924f, 0.02601697f, -0.01055549f, 
    -0.01216174f, -0.03646163f, -0.00626693f, -0.02932470f, -0.04300946f, -0.04419457f, -0.02937212f, -0.02698204f, 
    0.02599752f, 0.02538654f, -0.01460657f, -0.03505367f, -0.04101861f, 0.01537141f, 0.03795236f, 0.04609727f, 
    -0.05167129f, -0.00411368f, -0.01484217f, -0.00753773f, 0.01025195f, 0.02289391f, 0.02010434f, 0.00043180f, 
    0.04365464f, -0.02516907f, -0.02580501f, -0.04688657f, -0.01029795f, 0.02346930f, -0.01358277f, -0.00908995f, 
    -0.02155825f, 0.04779647f, -0.00311579f, -0.02652664f, -0.04136723f, 0.04020352f, -0.03654054f, -0.01417333f, 
    0.02380182f, 0.02328206f, -0.01599858f, 0.00183344f, 0.01725681f, -0.01910375f, 0.04223656f, 0.03069065f, 
    -0.04569083f, -0.01271462f, 0.01857811f, -0.02701894f, -0.00477448f, -0.00800768f, 0.01695413f, -0.05158762f, 
    -0.04181655f, -0.03683601f, 0.03568801f, 0.03197028f, -0.00246027f, 0.00729089f, -0.03948255f, -0.01887416f, 
    -0.00176963f, 0.00963908f, -0.04023745f, 0.03319500f, 0.02591604f, -0.03498597f, 0.01204600f, 0.03350104f, 
    -0.05919497f, 0.02377924f, 0.01006373f, 0.03016223f, -0.03711930f, 0.01391122f, -0.03630327f, -0.01566605f, 
    0.02070916f, -0.03062839f, -0.04513849f, -0.01339634f, -0.03386750f, -0.02209114f, -0.05341651f, -0.05124683f, 
    0.03804090f, 0.04516387f, 0.03406257f, 0.00784336f, 0.00900319f, -0.00100120f, 0.04430687f, 0.01497532f, 
    0.03714489f, 0.01834265f, 0.03508092f, 0.00687080f, 0.00052988f, 0.01505593f, -0.03504080f, -0.03342685f, 
    -0.02816912f, 0.02273129f, 0.02003054f, -0.04966201f, -0.00747298f, 0.03408065f, -0.00565074f, 0.04321616f, 
    0.01078590f, 0.04280758f, -0.02775176f, -0.05365897f, 0.01814756f, -0.00888441f, -0.03549116f, -0.00467424f, 
    -0.02781321f, 0.00891470f, 0.00496628f, 0.01264321f, 0.01199186f, -0.01742390f, -0.02603160f, -0.06013210f, 
    0.04482200f, 0.01847909f, 0.03356889f, -0.00788668f, 0.02786445f, 0.04462411f, -0.02826167f, -0.00076417f, 
    0.00341013f, 0.02815770f, -0.01930827f, -0.00143291f, -0.02368632f, -0.02291927f, -0.00578724f, -0.00619556f, 
    -0.01157505f, -0.01651390f, 0.01832910f, -0.04633870f, 0.02548492f, -0.01777345f, -0.00217055f, -0.00385981f, 
    0.09065208f, -0.11593769f, -0.15820992f, 0.31384689f, 0.01996962f, -0.00649741f, 0.02498894f, -0.01296313f, 
    -0.00180938f, 0.04274943f, -0.06177914f, -0.13849574f, -0.15707700f, -0.23542990f, -0.09687191f, -0.25898841f, 
    0.18173783f, 0.00049711f, -0.00208624f, 0.00435461f, -0.08665451f, -0.02887459f, -0.01065130f, 0.14761101f, 
    0.12641972f, -0.05689065f, 0.08627684f, -0.08041893f, 0.08754605f, 0.13945583f, 0.08325228f, 0.04839038f, 
    -0.07231747f, 0.07363076f, -0.08284252f, 0.05154709f, 0.06475996f, -0.00397879f, -0.13335320f, 0.25112668f, 
    0.10917383f, 0.00788181f, 0.05770784f, 0.06122473f, -0.11185698f, -0.07311694f, 0.10329097f, 0.01701959f, 
    0.08763185f, -0.01543417f, -0.10259525f, 0.21758448f, 0.14257501f, 0.02186540f, 0.00387177f, 0.09992602f, 
    0.00927122f, -0.06267983f, -0.09526364f, -0.01529687f, 0.05507470f, 0.07570605f, 0.09603186f, -0.11806529f, 
    -0.01354724f, -0.00924407f, -0.02819666f, 0.17400371f, -0.01880705f, -0.07538485f, -0.05205296f, -0.02060410f, 
    0.15916668f, 0.10475005f, -0.05184913f, 0.01942419f, 0.01669410f, -0.08775070f, 0.03535115f, -0.11218642f, 
    0.19019406f, 0.04048321f, -0.01564464f, -0.05636375f, 0.08347160f, -0.00880873f, -0.20359455f, 0.01210780f, 
    0.01710073f, 0.00359255f, 0.14183892f, -0.00239076f, -0.00987604f, -0.07962826f, 0.18079056f, -0.00175453f, 
    -0.28003705f, -0.14457551f, -0.17148785f, -0.11874590f, -0.05573471f, -0.06972122f, -0.03335897f, -0.10126378f, 
    0.12371782f, -0.00300334f, 0.08292399f, -0.05721549f, 0.14450167f, 0.03701735f, 0.15757723f, 0.12877803f, 
    -0.07420451f, -0.07093799f, 0.00615564f, -0.05240086f, 0.03017011f, 0.02174452f, 0.05221921f, -0.00521793f, 
    0.16254501f, 0.25983348f, 0.00062939f, -0.00242248f, -0.10799333f, 0.07047629f, -0.16184324f, -0.07049856f, 
    -0.04297579f, 0.02941339f, -0.04503742f, -0.05350563f, 0.12846158f, 0.07690568f, 0.04782508f, -0.12683237f, 
    0.08548535f, 0.00171059f, -0.01655564f, 0.13138503f, -0.08764730f, 0.01690035f, 0.05933218f, 0.01657817f, 
    0.07539838f, -0.27766663f, -0.18995228f, 0.10138239f, 0.05743105f, 0.02427324f, 0.00432125f, -0.10124997f, 
    -0.07288557f, -0.01298984f, 0.07688815f, -0.03932028f, 0.24126452f, 0.17965275f, -0.15140612f, 0.30075407f, 
    0.12678558f, -0.00493435f, -0.10428432f, 0.09370672f, 0.10572012f, 0.16586979f, -0.09878312f, -0.00209146f, 
    0.06213286f, -0.20443439f, 0.30201036f, 0.10183559f, 0.01650310f, -0.16300875f, 0.00650853f, 0.08482040f, 
    0.16663480f, -0.00445483f, -0.01932768f, -0.08022548f, -0.05684841f, 0.31001481f, 0.24336085f, 0.00884236f, 
    -0.22038576f, -0.05799340f, 0.11261453f, -0.17888197f, 0.02625163f, 0.07986779f, -0.02929470f, -0.07827982f, 
    0.29650494f, 0.08983815f, -0.00027241f, 0.00338531f, 0.00287553f, -0.00509542f, 0.11875461f, -0.03421326f, 
    0.00229187f, 0.02211311f, 0.00556102f, -0.03623263f, 0.14773309f, 0.02489468f, -0.06609356f, 0.18333466f, 
    0.03398901f, 0.16957776f, -0.30389962f, 0.11169948f, -0.17746070f, -0.06063624f, 0.09655370f, -0.04328350f, 
    0.07363449f, 0.10944867f, 0.05945416f, 0.05739785f, -0.12880892f, 0.04450381f, -0.01393630f, -0.08893570f, 
    -0.17314994f, 0.02877003f, 0.04532473f, -0.13139448f, -0.15422712f, -0.13669866f, 0.04487586f, -0.19497295f, 
    0.04569910f, 0.02912896f, -0.04396370f, -0.07772454f, -0.13145612f, -0.06239387f, -0.05654933f, 0.08068303f, 
    -0.10383897f, -0.19647571f, -0.03270696f, -0.04957587f, -0.06980717f, 0.07450937f, 0.06946976f, -0.04092617f, 
    0.16839811f, 0.15969117f, 0.09585109f, 0.01976686f, 0.38698938f, 0.15024103f, -0.01460328f, 0.15664476f, 
    -0.13938864f, -0.02959507f, -0.15218954f, 0.03816723f, -0.02524511f, -0.01006165f, -0.09994300f, -0.01933916f, 
    -0.29651034f, -0.12732933f, -0.05443035f, -0.11040119f, -0.01343059f, -0.01797607f, 0.01254823f, -0.07123780f, 
    0.21137108f, 0.15978213f, 0.00401440f, -0.00443190f, 0.05011414f, 0.28040770f, 0.06897379f, 0.08652527f, 
    0.00250258f, -0.03883268f, 0.00287053f, 0.11546471f, 0.10408831f, -0.12079329f, 0.08352073f, 0.15901080f, 
    0.04920247f, 0.14451657f, 0.10827095f, 0.05157747f, -0.10598831f, 0.02752450f, 0.01658220f, -0.08183530f, 
    -0.00913768f, -0.03692325f, -0.05285191f, -0.05593883f, -0.10130481f, -0.17529024f, -0.26085502f, -0.24537979f, 
    0.05229987f, 0.02066017f, 0.05233515f, -0.08561993f, -0.03078379f, 0.06224373f, 0.11883761f, -0.00242763f, 
    -0.17381088f, -0.01110589f, -0.05395967f, 0.12131130f, -0.03932892f, -0.00632263f, -0.06531983f, -0.02862561f, 
    -0.03627398f, -0.02449587f, -0.05677783f, -0.04990514f, 0.45223552f, 0.15870270f, 0.10390639f, 0.04487982f, 
    -0.16679521f, -0.02950553f, 0.03346228f, -0.14092049f, -0.01180834f, -0.07377823f, 0.07544270f, -0.08516715f, 
    0.28041759f, 0.44332877f, 0.00019075f, 0.09625699f, -0.02577148f, 0.06801298f, -0.05758112f, 0.04927785f, 
    -0.12267014f, -0.11805847f, 0.02738737f, 0.11730965f, 0.04704562f, 0.18441917f, 0.15800337f, 0.17348455f, 
    -0.02146556f, 0.09806529f, -0.04047146f, 0.01709405f, -0.09946832f, 0.04453285f, 0.04441370f, 0.04084608f, 
    0.14262947f, -0.07269003f, -0.26578239f, -0.02096017f, 0.00208444f, 0.01867118f, -0.01505079f, 0.05878296f, 
    -0.08022158f, 0.12294681f, 0.17237595f, 0.11484511f, 0.23959294f, 0.17914525f, 0.13661487f, -0.08125473f, 
    -0.10206790f, 0.06184506f, 0.08277185f, -0.06004849f, -0.11403707f, -0.04582286f, -0.07236959f, -0.05653907f, 
    -0.03445100f, 0.03083620f, 0.01811688f, -0.00132956f, 0.02217316f, 0.01355585f, 0.00046739f, -0.05267601f, 
    0.03714294f, 0.01573287f, -0.02110370f, -0.03239888f, -0.04582917f, 0.03334550f, -0.05075898f, -0.02684032f, 
    -0.03950191f, 0.02161612f, 0.02621270f, 0.02024839f, -0.05757366f, 0.02240551f, 0.03298590f, -0.00947931f, 
    -0.05109536f, -0.00901684f, 0.01658890f, -0.03361076f, -0.04576417f, -0.04382326f, 0.03002238f, 0.01369972f, 
    0.00909501f, -0.04952892f, 0.00040592f, 0.00859816f, -0.02150926f, 0.01656688f, 0.03845842f, -0.00907958f, 
    -0.03679273f, 0.03760723f, -0.00704061f, -0.04901997f, -0.02756998f, -0.03469235f, -0.03195325f, 0.01666306f, 
    -0.05019604f, -0.02268032f, -0.05670466f, 0.00870922f, 0.02195965f, 0.04093071f, -0.01754839f, -0.03359246f, 
    0.01402515f, -0.03389329f, -0.00665853f, 0.01710676f, 0.00754564f, -0.00723105f, -0.01164623f, 0.00411907f, 
    -0.02641318f, -0.03514520f, 0.01620667f, -0.00914467f, -0.01639587f, 0.03942981f, -0.00770270f, 0.00248404f, 
    0.02067507f, 0.04035785f, 0.03136014f, -0.04630050f, -0.02285160f, -0.02690650f, -0.05249470f, 0.02533790f, 
    -0.04750044f, 0.02992216f, -0.00999975f, -0.01804903f, 0.01622405f, 0.02099021f, -0.00722042f, -0.00124463f, 
    -0.04684315f, -0.05541484f, 0.02307331f, -0.03431938f, 0.03240266f, -0.01929268f, -0.02559530f, -0.02543670f, 
    0.00102689f, 0.03497921f, -0.00395227f, -0.01745175f, 0.02532744f, -0.04883874f, 0.04053633f, 0.02581433f, 
    0.01491474f, -0.02735745f, -0.01545960f, -0.03053317f, -0.02281376f, 0.00742593f, 0.02304656f, -0.04735488f, 
    -0.00291267f, -0.04711859f, -0.04848639f, -0.01251991f, 0.00500933f, -0.05127985f, 0.02610439f, 0.01654633f, 
    -0.05445583f, -0.00234751f, -0.03229078f, -0.05192244f, 0.02800517f, -0.02958383f, -0.02397791f, -0.05361175f, 
    0.00138111f, -0.01922559f, -0.00355531f, 0.02056194f, 0.00121544f, -0.04605581f, -0.01469951f, 0.02904223f, 
    -0.02320893f, -0.02459771f, 0.00090185f, -0.05254418f, -0.01256598f, -0.01599712f, -0.02363446f, -0.01714784f, 
    0.01635902f, 0.04647963f, 0.03241707f, 0.01145053f, -0.05917068f, -0.01602367f, 0.02397199f, -0.01654829f, 
    0.03590842f, -0.05232782f, 0.02629805f, -0.01713744f, -0.01577624f, -0.01967946f, -0.03555521f, 0.03859726f, 
    -0.00347124f, -0.02433578f, -0.03176659f, -0.00843923f, -0.03610396f, 0.02343980f, 0.01500994f, -0.03113881f, 
    0.00725317f, -0.02254994f, -0.00128991f, -0.03029980f, 0.00822020f, -0.04358768f, 0.00926851f, 0.03738437f, 
    -0.02889005f, 0.00209021f, 0.01419567f, -0.04466258f, -0.03567085f, -0.00703397f, -0.05167371f, 0.01763175f, 
    -0.05329201f, -0.01349751f, -0.05281910f, -0.04386996f, 0.00766302f, 0.02608168f, -0.04199266f, 0.01289692f, 
    -0.05955859f, 0.02759147f, -0.04788586f, -0.02099941f, -0.00301652f, 0.02701656f, 0.03898177f, 0.02098696f, 
    0.01846015f, -0.05043722f, 0.00902373f, -0.01152019f, -0.02004829f, -0.04842212f, -0.00707733f, 0.02524355f, 
    0.02848762f, 0.03930940f, -0.01724200f, 0.00541481f, -0.03381673f, -0.04360801f, 0.04311583f, 0.02169881f, 
    0.00437783f, -0.01846115f, -0.01885624f, -0.01382273f, -0.05448857f, -0.01640142f, 0.02999108f, -0.02584109f, 
    -0.04078783f, 0.02313172f, -0.03068351f, -0.03329758f, -0.00023010f, 0.03076705f, -0.03297586f, 0.00316752f, 
    0.00112422f, 0.01834297f, 0.03767178f, 0.03278355f, 0.01785866f, -0.01007580f, -0.00978101f, 0.02011760f, 
    -0.03131213f, -0.05034219f, 0.00927975f, -0.02600513f, 0.00887358f, 0.01990411f, 0.00171396f, -0.02307748f, 
    0.00295217f, 0.03598513f, -0.04502860f, -0.04985856f, 0.00051278f, -0.05522219f, 0.00512835f, -0.00036893f, 
    0.00931857f, 0.00647247f, 0.01379647f, 0.02970352f, -0.02683484f, 0.00781248f, 0.02067571f, -0.05540867f, 
    0.03463640f, -0.00780954f, 0.02135151f, -0.01283611f, -0.02338574f, 0.02915807f, 0.02665597f, -0.03596318f, 
    -0.01105712f, 0.01366748f, 0.03137163f, 0.02371983f, 0.02861748f, -0.02488909f, -0.03844538f, -0.02500115f, 
    -0.05314155f, -0.00492039f, -0.04038992f, -0.02541870f, -0.02774786f, -0.04202465f, -0.01471591f, 0.02934249f, 
    -0.04402240f, -0.01098150f, -0.05027141f, 0.02501085f, -0.00293716f, -0.04368808f, 0.02832649f, -0.01908665f, 
    -0.02552918f, 0.00285957f, -0.02776764f, -0.03983602f, -0.04336971f, 0.03020850f, -0.00151665f, -0.03195569f, 
    0.02503547f, 0.03061477f, -0.05590142f, 0.01457178f, -0.03411157f, -0.00204835f, -0.01887566f, 0.00330002f, 
    -0.04329078f, 0.04249414f, 0.04708488f, -0.02526408f, -0.00692756f, -0.02927702f, 0.00937316f, -0.04395449f, 
    0.00744582f, 0.03725377f, 0.03089930f, 0.04020205f, -0.01659660f, 0.01056162f, 0.03687867f, -0.04737924f, 
    0.02630196f, 0.00149801f, -0.05478922f, -0.00552788f, -0.02156285f, -0.04961164f, 0.00626410f, 0.00760150f, 
    -0.05260945f, 0.04163261f, -0.04961534f, -0.02840222f, 0.02166947f, 0.03734747f, -0.04910051f, 0.02573456f, 
    0.01374068f, 0.03731210f, 0.02956134f, 0.01471786f, -0.01440665f, -0.04003174f, -0.00167727f, -0.01738039f, 
    -0.01441329f, -0.00543692f, -0.01384823f, -0.00779589f, -0.02310576f, -0.00853298f, -0.01385872f, -0.05064853f, 
    -0.02579884f, 0.02489441f, 0.00296011f, -0.01177806f, -0.05898244f, 0.00880811f, 0.01164443f, -0.03247093f, 
    0.03177100f, -0.01766569f, 0.03712868f, -0.00762945f, 0.04098019f, 0.00700767f, -0.04928951f, -0.02082653f, 
    -0.03179039f, -0.02318978f, -0.02546585f, -0.02365592f, 0.02189842f, -0.00598515f, 0.02475908f, 0.01759169f, 
    -0.25744608f, 0.04143310f, 0.06814309f, -0.33850515f, -0.03085668f, 0.05662434f, 0.04999618f, 0.02726100f, 
    -0.08582748f, 0.06273410f, 0.08998378f, 0.15021902f, 0.37501904f, 0.10981587f, -0.13201578f, 0.07381506f, 
    -0.07771251f, 0.08516632f, 0.03519010f, 0.02302544f, 0.09720098f, 0.03150070f, 0.06184166f, 0.02391906f, 
    -0.06295247f, -0.03938395f, -0.08713607f, 0.23984252f, -0.06720763f, -0.06677185f, -0.02428168f, -0.03004320f, 
    0.07176509f, -0.06213962f, 0.17110696f, -0.01404836f, -0.14489658f, -0.11082765f, 0.08574189f, -0.12772287f, 
    0.09558197f, 0.01218909f, -0.15574679f, 0.01270968f, -0.02892064f, 0.10007956f, -0.02574383f, -0.00749537f, 
    -0.18496363f, 0.07870727f, 0.07490010f, -0.12199073f, -0.09477556f, -0.09510826f, -0.06657717f, -0.10227749f, 
    -0.02425482f, 0.05296610f, -0.01153086f, 0.07810847f, 0.03821988f, -0.14884335f, -0.26177311f, -0.14858754f, 
    0.10084257f, -0.13465409f, -0.03610174f, 0.03363398f, 0.08083912f, 0.00840131f, 0.06161896f, 0.08545788f, 
    -0.05505149f, -0.15772671f, 0.13445291f, -0.02316245f, -0.12881854f, -0.01990613f, 0.00691763f, -0.00321373f, 
    -0.10626226f, -0.05109011f, -0.14001992f, -0.07967618f, 0.00615439f, -0.06512170f, 0.02824451f, 0.28600055f, 
    0.05710470f, 0.01916836f, -0.07320383f, -0.01502293f, 0.07451966f, 0.05356187f, 0.00091574f, -0.00819577f, 
    0.20550016f, 0.02326658f, 0.18250294f, 0.22119781f, 0.04652741f, -0.01947320f, 0.00659580f, 0.06767460f, 
    0.00521470f, 0.31360993f, -0.04077098f, 0.07198077f, 0.06968228f, 0.29798675f, 0.06177269f, -0.02742325f, 
    -0.02163711f, 0.01737789f, -0.00043333f, -0.01078926f, 0.02673226f, 0.07788821f, -0.02456646f, -0.11610246f, 
    -0.21661620f, -0.16823295f, 0.14823750f, 0.03617438f, 0.07998170f, -0.05515872f, -0.02942820f, 0.08888460f, 
    -0.00715848f, 0.13417122f, -0.06127255f, 0.01142661f, -0.00451911f, -0.08150113f, -0.23257992f, -0.01662566f, 
    -0.13364883f, -0.07090892f, -0.10100863f, 0.05942946f, 0.00455195f, -0.01404226f, -0.14016566f, -0.01475722f, 
    0.13916443f, 0.14438526f, 0.19080250f, 0.15342602f, 0.09027383f, 0.00521514f, 0.07800154f, 0.00020290f, 
    -0.04220329f, -0.03960618f, 0.03758719f, 0.00796864f, 0.07238773f, 0.13804697f, 0.08844046f, -0.32391465f, 
    0.05204796f, -0.15506771f, 0.10537024f, -0.03502226f, -0.07653855f, -0.11937491f, 0.04488439f, 0.03775749f, 
    -0.26180866f, 0.11037643f, -0.04476523f, 0.09837131f, 0.02041432f, -0.12055185f, -0.08665345f, -0.03720772f, 
    0.08838448f, 0.11908796f, 0.08067189f, -0.09078697f, 0.01713608f, -0.09677960f, -0.05494314f, 0.07698440f, 
    0.13984817f, 0.08292655f, 0.01049113f, 0.03048922f, 0.22825111f, -0.02949962f, -0.01973888f, 0.01914075f, 
    -0.15363771f, -0.13916339f, 0.11254596f, -0.20816436f, -0.04114106f, 0.05285234f, 0.17091246f, 0.04253716f, 
    0.00424953f, -0.12515965f, 0.07396168f, -0.02025580f, -0.38963664f, -0.18339369f, 0.06753336f, -0.23605233f, 
    0.07515845f, -0.17542228f, 0.25386548f, -0.04331663f, 0.09930815f, 0.02924978f, 0.06681208f, -0.01082696f, 
    0.14640187f, 0.30842841f, 0.13786718f, -0.11807632f, 0.11501732f, 0.02244768f, -0.10616489f, 0.06987097f, 
    0.10596801f, 0.02079675f, -0.00647207f, 0.06261630f, 0.29260191f, 0.14355345f, 0.07015925f, 0.32534266f, 
    0.09971721f, -0.12011664f, 0.06921436f, 0.08464836f, 0.00558692f, 0.09705292f, 0.02443368f, 0.10745361f, 
    0.03737096f, 0.09759069f, 0.14789961f, 0.15407981f, -0.01591149f, 0.06903043f, -0.13117015f, 0.08361576f, 
    -0.10078931f, -0.00935928f, -0.01141484f, -0.00750632f, 0.02114552f, 0.00407952f, 0.05741217f, -0.04836291f, 
    -0.10181045f, 0.01171121f, 0.16606538f, 0.04481744f, 0.05259277f, 0.00633461f, 0.12293773f, 0.00445305f, 
    0.26447776f, 0.13588116f, 0.02235190f, 0.32449374f, 0.04454080f, -0.01309643f, -0.01061656f, -0.00296401f, 
    -0.01884271f, -0.04762907f, 0.03838079f, 0.01252735f, -0.02726094f, -0.03993862f, 0.21194983f, -0.08191743f, 
    0.12285609f, -0.07563470f, 0.05360339f, -0.01914717f, -0.08757930f, 0.04347873f, 0.13900712f, -0.17179786f, 
    -0.16716558f, -0.03677725f, 0.13677089f, -0.01479866f, 0.17164361f, 0.04876451f, 0.00731092f, 0.01332633f, 
    0.10336990f, 0.04525593f, 0.09040439f, 0.13771792f, 0.14247888f, -0.09150989f, 0.08427482f, 0.28233692f, 
    -0.05517343f, -0.09350403f, -0.04664507f, 0.03163050f, 0.08387420f, -0.02423468f, -0.00758144f, -0.00749321f, 
    -0.22603945f, 0.05191721f, 0.10604890f, -0.24929647f, -0.07597984f, -0.06600736f, 0.05481784f, -0.04558873f, 
    -0.00166643f, 0.12440917f, 0.09801363f, 0.05830841f, 0.24097826f, 0.16732255f, 0.03979316f, 0.02198124f, 
    0.02081195f, -0.08316625f, -0.01326230f, 0.12832497f, 0.08427137f, -0.02456146f, 0.07962598f, -0.05900326f, 
    -0.01467490f, -0.18455499f, -0.11962114f, -0.15432246f, 0.00095514f, 0.02847752f, 0.08568271f, 0.12132577f, 
    0.13123447f, 0.04443167f, -0.05036369f, -0.08026017f, -0.20278771f, -0.17094336f, 0.00242035f, -0.03590601f, 
    -0.04512746f, 0.05942525f, -0.02122268f, -0.04932534f, 0.08027466f, -0.11400653f, -0.05283928f, -0.11428543f, 
    0.00093971f, 0.00795107f, 0.10808591f, -0.04635580f, 0.02575931f, -0.00002010f, 0.02663384f, 0.00586719f, 
    0.05927458f, -0.10263446f, -0.07226282f, -0.02538478f, 0.38990200f, -0.12206108f, -0.11940158f, 0.11223011f, 
    -0.01356771f, -0.00296477f, -0.11382526f, 0.05789670f, 0.02045533f, -0.05543090f, 0.05991445f, 0.02391436f, 
    0.27938077f, -0.00814630f, -0.23019801f, 0.21788037f, 0.04912054f, -0.08526020f, -0.01585474f, 0.06599175f, 
    -0.12649274f, 0.12805887f, -0.04057956f, 0.11048362f, 0.37987405f, -0.22520140f, -0.11932878f, -0.22049037f, 
    -0.03142700f, 0.06749838f, -0.04532473f, 0.03642445f, -0.17405044f, -0.02759465f, -0.01903004f, 0.07269061f, 
    0.02011113f, 0.12131568f, 0.04698683f, 0.00629390f, 0.01194810f, -0.13383922f, -0.18882960f, 0.03644872f, 
    0.07780430f, -0.06734263f, 0.05624317f, -0.07782888f, -0.21519531f, 0.12715232f, 0.00305792f, 0.18518648f, 
    -0.06602192f, 0.04277159f, 0.03767595f, 0.01146636f, 0.05745994f, -0.02860924f, 0.14981243f, -0.05026310f, 
    0.12687655f, 0.23260570f, -0.11593410f, -0.02259879f, 0.01212763f, 0.00889321f, 0.05252244f, 0.03521688f, 
    0.08552248f, 0.02542547f, 0.06550420f, 0.15396678f, 0.25241816f, -0.05088720f, -0.03191456f, 0.01433215f, 
    0.01033694f, 0.08464846f, -0.01735375f, 0.07784899f, 0.06968315f, -0.03781435f, -0.08712362f, -0.07734840f, 
    -0.17244148f, 0.02305821f, -0.07898738f, 0.17693722f, -0.12741385f, 0.12539841f, 0.04046475f, 0.05478648f, 
    0.00405078f, 0.03481192f, 0.12713094f, -0.02719382f, 0.00497675f, -0.03264678f, -0.02900934f, -0.14271851f, 
    0.05554476f, 0.11600221f, -0.02658776f, -0.00742849f, 0.00262872f, 0.03747702f, -0.02304893f, -0.01511332f, 
    -0.42613733f, 0.18615356f, -0.04202757f, -0.22574741f, 0.14947008f, 0.09106929f, 0.04132365f, -0.08713691f, 
    0.07016315f, 0.11454917f, 0.01887533f, -0.09086610f, 0.12602623f, 0.21051273f, 0.04189043f, 0.07315358f, 
    0.09239458f, 0.06121156f, 0.04412236f, 0.06930140f, -0.02146278f, 0.01684812f, 0.07493404f, -0.02844565f, 
    0.02040360f, -0.08668091f, -0.03785458f, 0.22139637f, 0.03109348f, 0.12873468f, -0.04406164f, -0.10270654f, 
    -0.04515241f, 0.00402390f, -0.08916894f, -0.01564274f, 0.06950770f, 0.20760557f, -0.10240277f, 0.18471979f, 
    0.06928726f, -0.04280127f, 0.12055235f, 0.09336983f, 0.02258431f, -0.00920321f, 0.07701784f, -0.12127160f, 
    -0.13962637f, -0.14620844f, -0.16889884f, -0.15900488f, -0.00182130f, -0.00073308f, 0.03818955f, -0.09566262f, 
    -0.05728811f, 0.07965501f, -0.04353491f, 0.00594357f, -0.23891297f, 0.23988737f, 0.30840456f, 0.13540076f, 
    0.12616111f, 0.08908218f, -0.02658097f, 0.03323856f, 0.04995661f, -0.02736335f, 0.07031212f, 0.04056440f, 
    0.19285369f, 0.11686937f, -0.08526649f, 0.30626628f, -0.00263985f, -0.07642159f, 0.00298504f, -0.03822891f, 
    0.09205446f, 0.02175574f, 0.05899115f, 0.00778496f, -0.05047353f, 0.09708903f, -0.09811352f, 0.14837623f, 
    0.14310370f, 0.02899506f, 0.13762763f, 0.04692149f, 0.08887877f, 0.00944442f, 0.03720199f, -0.01704826f, 
    0.09231444f, -0.02559259f, -0.01092740f, 0.22945462f, 0.06112812f, 0.18089540f, -0.04366573f, -0.04310191f, 
    0.04781517f, 0.09690226f, 0.08356726f, 0.08808166f, -0.03818842f, -0.13106273f, 0.14379045f, 0.06506635f, 
    0.02186988f, 0.02910424f, -0.05180351f, 0.01598220f, 0.04282577f, 0.07717752f, 0.09804891f, -0.07110935f, 
    0.50491798f, 0.31849265f, 0.04170082f, -0.00526573f, 0.10511380f, 0.06613605f, -0.12523817f, 0.02851378f, 
    0.00624892f, 0.03046598f, -0.01853626f, 0.03415074f, -0.22341083f, 0.02302613f, -0.12919088f, -0.17812265f, 
    0.09842695f, -0.04516449f, -0.00326228f, -0.04261992f, 0.16289930f, -0.05925626f, 0.03372888f, 0.07363363f, 
    -0.39549005f, 0.16135186f, -0.06132988f, -0.12638253f, 0.14594217f, -0.05435791f, -0.12785110f, -0.19268054f, 
    -0.06115987f, 0.04019833f, -0.03339981f, -0.04577435f, -0.10590946f, 0.07134283f, 0.13347420f, 0.12295149f, 
    0.03045213f, -0.07444420f, 0.06553409f, 0.02241255f, 0.14003655f, 0.02505791f, 0.06507812f, -0.01867424f, 
    0.08777277f, 0.12537876f, -0.10776726f, -0.29777893f, 0.02161969f, 0.02853141f, -0.10644792f, -0.07548752f, 
    0.05337701f, -0.06558493f, -0.17752084f, 0.07681651f, -0.07675058f, 0.00299052f, -0.09437711f, 0.10694161f, 
    0.02469026f, 0.04825159f, -0.05446067f, -0.02182806f, 0.09638012f, -0.08053134f, -0.07707600f, -0.09204666f, 
    0.04992751f, 0.04336878f, 0.01036261f, 0.03346963f, 0.18420276f, -0.02066296f, 0.03290540f, -0.07881982f, 
    -0.11463107f, 0.11811032f, 0.07948221f, 0.07829238f, -0.63401818f, 0.08637715f, 0.01563774f, -0.28618953f, 
    0.02953683f, -0.03653811f, 0.10040404f, -0.02468989f, 0.01613297f, 0.04626168f, -0.07395531f, 0.07622047f, 
    -0.02902026f, 0.05764864f, 0.21006997f, -0.05118400f, -0.06764882f, 0.03978255f, 0.27362630f, -0.04178597f, 
    -0.09291065f, 0.13605508f, 0.09299646f, 0.05851013f, -0.09016003f, 0.03726466f, -0.06714149f, -0.05881517f, 
    0.12706438f, -0.02443851f, 0.03400632f, 0.07175590f, 0.07555278f, -0.04886762f, 0.01659910f, -0.00431637f, 
    0.12271336f, -0.20507926f, -0.05100390f, 0.16609773f, 0.08936109f, -0.09944392f, 0.17178288f, 0.15187518f, 
    -0.02007017f, 0.05015352f, -0.00767267f, -0.07281605f, -0.41756415f, -0.02783497f, 0.09212720f, 0.37911391f, 
    0.08352461f, 0.04993103f, 0.00575356f, -0.09516316f, 0.00834800f, 0.07251412f, 0.18509254f, -0.08265986f, 
    0.24134459f, -0.04848886f, 0.07606921f, -0.12718143f, -0.01894282f, 0.07742234f, -0.07728578f, 0.02798808f, 
    0.04297371f, -0.05983318f, -0.04766230f, 0.06523787f, -0.04388003f, 0.12867860f, -0.09734236f, -0.20758358f, 
    0.09939518f, -0.00713906f, 0.05965957f, -0.01994011f, -0.02709766f, -0.02535519f, 0.15006316f, 0.04182082f, 
    0.14846954f, 0.04230599f, 0.11863969f, -0.00752263f, 0.08705230f, 0.01278645f, -0.07434251f, -0.00705657f, 
    0.18934900f, -0.00804690f, -0.05357381f, -0.07259183f, -0.16845275f, -0.24514623f, -0.03990149f, 0.07134238f, 
    -0.09050187f, -0.06454147f, -0.04608000f, -0.07167068f, -0.01193261f, -0.04778917f, 0.01445361f, -0.04424697f, 
    0.09793976f, -0.11724477f, 0.10072546f, 0.06026252f, 0.05206984f, 0.07531908f, -0.18291129f, -0.04556344f, 
    0.07118547f, -0.03579954f, 0.01665249f, 0.06013710f, -0.25937557f, 0.11710799f, -0.15195078f, 0.07447530f, 
    -0.00657668f, -0.08314250f, 0.00873718f, 0.12569983f, 0.01801738f, 0.04395992f, 0.02132911f, 0.02127283f, 
    0.17339125f, -0.19992355f, -0.04926776f, 0.15487908f, 0.05831840f, 0.01166763f, 0.01639624f, 0.04307720f, 
    0.05760649f, 0.06112817f, 0.03007087f, 0.19003522f, -0.03259908f, 0.00811362f, 0.16097014f, 0.10956796f, 
    0.04070918f, -0.10144422f, -0.00673117f, -0.08772509f, 0.01184238f, -0.09223359f, -0.00477660f, -0.03654908f, 
    0.10480791f, -0.00352782f, 0.01549179f, 0.31092265f, -0.00536809f, 0.10420201f, -0.00570823f, -0.02145093f, 
    0.13017599f, 0.14220525f, 0.09270500f, 0.00357773f, 0.17986071f, -0.31720340f, 0.08360462f, 0.08902092f, 
    0.03531240f, -0.03124421f, -0.09195966f, 0.08432277f, -0.07271730f, -0.10772593f, -0.01880424f, 0.06990027f, 
    -0.12115154f, 0.03621353f, -0.19453588f, 0.29522669f, 0.05176377f, -0.00206879f, -0.03121304f, -0.07463204f, 
    -0.03002989f, 0.11196519f, 0.02702158f, 0.09227113f, 0.03373574f, 0.25469360f, 0.17535011f, 0.02014638f, 
    -0.00281498f, -0.02915802f, -0.00696350f, 0.07255525f, -0.04703364f, -0.00527013f, -0.03787440f, 0.03276763f, 
    0.20483114f, -0.05744577f, -0.03687976f, 0.12989336f, -0.00416491f, 0.09272823f, 0.03502298f, -0.12782563f, 
    -0.04591617f, -0.00745238f, 0.01588885f, -0.01569655f, -0.08684389f, -0.03081649f, 0.04598127f, 0.09629064f, 
    -0.08542631f, 0.16617039f, 0.01986813f, -0.00156256f, 0.03915317f, -0.09446231f, -0.00348608f, -0.06550515f, 
    -0.09198342f, -0.15175995f, -0.20214351f, -0.03306719f, -0.05461252f, -0.07105830f, -0.07412027f, -0.02613565f, 
    0.03765850f, 0.06962483f, -0.07961824f, -0.02569319f, -0.06717143f, 0.05828458f, 0.07895789f, -0.03346418f, 
    -0.07806910f, 0.10707528f, -0.14613122f, 0.09305116f, 0.05665123f, 0.08194225f, 0.04067554f, 0.00021080f, 
    0.04729090f, 0.09725484f, 0.15805691f, 0.20728771f, -0.00164103f, -0.03410093f, 0.03920986f, -0.04626016f, 
    -0.05790753f, 0.00908987f, 0.08959399f, 0.03969819f, 0.04662491f, 0.15556139f, 0.12241469f, -0.02940277f, 
    -0.07383793f, 0.06781888f, 0.13860364f, 0.13310581f, 0.08575796f, -0.00074704f, 0.06751010f, -0.08456941f, 
    -0.02138798f, 0.15080541f, 0.10618203f, 0.20898408f, -0.03175540f, 0.00400559f, -0.00355181f, 0.00745379f, 
    -0.09187354f, 0.07087987f, -0.09431842f, -0.10492760f, 0.22715211f, 0.11293257f, 0.03115058f, -0.05526492f, 
    0.01410999f, 0.08086218f, -0.09919892f, -0.04672356f, 0.15837932f, 0.06828304f, -0.02175549f, 0.15426323f, 
    0.37822661f, 0.07114836f, -0.01448842f, -0.00913912f, -0.00293448f, 0.01003621f, -0.00342698f, -0.00522400f, 
    0.08531534f, 0.07067743f, 0.12080245f, -0.01420816f, -0.13739850f, -0.25517011f, -0.18455693f, 0.18690692f, 
    0.00599874f, -0.06685326f, -0.05056953f, -0.08485212f, 0.09795750f, 0.11042082f, 0.01548200f, -0.03012642f, 
    -0.08498479f, -0.00872474f, -0.25224948f, -0.04966567f, 0.00988199f, -0.05432496f, 0.00552733f, -0.16578405f, 
    0.01157682f, 0.05602453f, -0.06388871f, -0.06012956f, 0.06622106f, 0.06661397f, 0.13821672f, -0.05528380f, 
    0.01840905f, 0.14112541f, 0.03304019f, -0.12928088f, 0.07695363f, 0.02958454f, -0.03185111f, 0.12614208f, 
    -0.19375260f, 0.01037100f, -0.18399251f, -0.06180643f, 0.11268481f, 0.09978444f, 0.01929962f, -0.03268074f, 
    0.07869140f, -0.01836640f, -0.09131743f, 0.03864171f, 0.01386310f, -0.04340249f, -0.15649505f, -0.02361512f, 
    0.09665350f, 0.01105129f, -0.03085370f, -0.03028213f, -0.04861799f, -0.06741462f, -0.11921979f, 0.03106989f, 
    0.05276434f, 0.07532667f, 0.05278436f, -0.04473564f, -0.04589240f, 0.08323419f, 0.10616009f, -0.00440448f, 
    -0.04214669f, 0.03048956f, -0.11203338f, 0.08880981f, 0.01177385f, 0.01149178f, -0.12578712f, 0.21701534f, 
    -0.13656597f, -0.02734606f, 0.01619416f, 0.01369440f, 0.06030008f, 0.00301625f, 0.03046240f, 0.08993062f, 
    0.24285974f, 0.04774077f, -0.11792791f, 0.30449820f, -0.05685245f, -0.02675438f, 0.04669419f, -0.06452484f, 
    0.09185087f, 0.08203638f, 0.01253611f, 0.07753507f, 0.03210323f, 0.18166766f, -0.01035317f, 0.07878668f, 
    -0.01099520f, -0.03199376f, 0.06255805f, 0.03631575f, 0.02558734f, -0.00401400f, 0.05995534f, -0.01768143f, 
    -0.00750304f, 0.09806812f, 0.11927389f, 0.03720378f, 0.01488370f, 0.04455821f, 0.00793701f, -0.01944980f, 
    0.07575312f, 0.08231626f, -0.02939981f, 0.00676739f, -0.00689269f, 0.06676418f, 0.09588588f, 0.05527474f, 
    0.11936897f, -0.02091729f, 0.06712481f, -0.04792302f, 0.07222562f, 0.03051018f, 0.02222726f, -0.09978925f, 
    0.21718617f, -0.04387392f, 0.01665569f, -0.15384161f, -0.07826436f, -0.00056879f, -0.07029144f, 0.06601194f, 
    0.08016837f, 0.05151493f, -0.05963698f, 0.02991769f, -0.59861284f, 0.05515824f, -0.10135403f, 0.03477265f, 
    0.04116574f, -0.04355226f, 0.06490850f, -0.02359778f, -0.02663407f, 0.08360614f, -0.09693739f, 0.07339995f, 
    -0.04921350f, 0.01050496f, -0.02666442f, -0.18803905f, -0.05878552f, -0.00053059f, -0.02289266f, 0.00412855f, 
    0.14744850f, -0.09867248f, 0.11674357f, -0.04719140f, -0.17254546f, 0.07149678f, 0.11035059f, 0.11922473f, 
    0.09428962f, -0.02182171f, -0.07589435f, 0.07516181f, 0.13551384f, 0.01656305f, 0.04007018f, -0.03786389f, 
    -0.21141988f, 0.08177880f, 0.00198357f, -0.01192689f, 0.04820691f, 0.19404639f, 0.10225987f, -0.05961059f, 
    -0.02732635f, 0.08114000f, 0.04930178f, 0.09751884f, 0.16477151f, -0.15547909f, 0.01819185f, -0.26424965f, 
    -0.04408621f, -0.03003115f, 0.06278368f, -0.00348460f, 0.00998691f, -0.06419823f, -0.10132307f, 0.02686766f, 
    -0.18407916f, -0.14210880f, 0.14290185f, -0.17974254f, 0.08032863f, 0.02526315f, -0.09540913f, -0.05895824f, 
    0.06401528f, -0.07440396f, -0.10244298f, -0.03476908f, -0.05153133f, 0.04900407f, -0.11651639f, 0.03831306f, 
    0.01405835f, 0.01434648f, 0.10386433f, -0.15768747f, -0.02391933f, 0.05110787f, 0.06149391f, -0.04925524f, 
    0.02864482f, -0.02648887f, -0.07652459f, -0.12874669f, 0.15026779f, -0.08317794f, 0.01908772f, 0.03479340f, 
    -0.01149562f, 0.05987467f, 0.03000362f, 0.12302740f, -0.04045378f, 0.05918660f, 0.16755377f, -0.01669523f, 
    -0.08557463f, -0.03064172f, 0.06176001f, 0.14119133f, -0.04507541f, -0.08600797f, -0.00749076f, 0.05202790f, 
    0.20461589f, 0.01298547f, -0.08927817f, 0.13606279f, 0.06678155f, -0.02641485f, 0.03278773f, 0.03892818f, 
    -0.06554154f, -0.04724579f, 0.14748995f, 0.23558895f, 0.11809909f, -0.13303159f, -0.00233484f, 0.09793662f, 
    0.00499844f, -0.00918643f, -0.04324771f, 0.10008476f, 0.10318806f, -0.00121555f, 0.01778742f, 0.11457121f, 
    0.06242404f, 0.03393829f, 0.13239539f, -0.06805748f, 0.04764231f, 0.01374965f, 0.11980850f, -0.01391694f, 
    0.11648882f, -0.10876123f, 0.08057901f, 0.09773944f, -0.39972135f, 0.10447895f, 0.09209048f, -0.16460040f, 
    0.00766006f, 0.10168387f, 0.00589535f, -0.07097849f, 0.13209333f, 0.02594708f, 0.10182860f, 0.21289328f, 
    -0.18820366f, 0.30234420f, 0.03699504f, -0.22684944f, 0.15187855f, 0.02576957f, -0.11573113f, 0.11819253f, 
    0.11217707f, 0.04951683f, 0.04006108f, -0.02367364f, -0.17681637f, 0.00376333f, -0.30856901f, -0.04370514f, 
    -0.11406340f, 0.09660510f, 0.06498991f, -0.14289470f, -0.15518838f, 0.05169044f, 0.09182002f, -0.08598168f, 
    0.06411525f, 0.02927030f, -0.02617495f, -0.22081676f, -0.03837895f, 0.06957496f, -0.02351083f, -0.01771416f, 
    -0.17430131f, 0.06787783f, 0.04082964f, 0.05928567f, 0.09464969f, 0.02013715f, 0.06371018f, 0.07296382f, 
    0.01608003f, -0.05516811f, -0.12547274f, 0.03029105f, -0.08063507f, 0.09324336f, 0.02623662f, 0.05564781f, 
    -0.06538077f, 0.16439708f, 0.00599971f, -0.07410508f, -0.02293444f, -0.06863757f, -0.00580376f, 0.12781785f, 
    -0.01355144f, -0.05450242f, -0.13732809f, 0.05147785f, -0.10720056f, 0.11022787f, -0.12602127f, 0.02044654f, 
    0.16931649f, 0.03693923f, 0.12152731f, -0.03326296f, 0.00535313f, 0.07152700f, -0.11814557f, -0.02655951f, 
    -0.29446614f, -0.11445466f, 0.02727832f, 0.35716933f, 0.00639436f, -0.07356256f, 0.19937696f, 0.10780700f, 
    0.06068416f, -0.10217591f, 0.04306231f, -0.00336206f, 0.10494898f, -0.04375288f, -0.11488781f, -0.01637140f, 
    0.07877117f, 0.02203391f, -0.00525032f, 0.00682583f, -0.07987244f, 0.07056387f, -0.02594672f, -0.12455957f, 
    0.22474720f, -0.05602939f, -0.13895276f, -0.24597950f, 0.05772721f, -0.07532895f, 0.06462796f, 0.05397596f, 
    0.01432398f, -0.02827101f, 0.04646705f, 0.10067655f, 0.20306237f, -0.02524027f, -0.06883944f, 0.00039429f, 
    0.13721210f, 0.14683123f, -0.02501817f, -0.01155286f, 0.00288865f, -0.08169191f, 0.03095272f, 0.03712685f, 
    -0.14101967f, -0.19803321f, 0.02796560f, 0.11884864f, -0.02654733f, 0.12020299f, 0.08650725f, 0.10674808f, 
    -0.01636316f, 0.04128257f, 0.11013308f, -0.06010897f, 0.05191439f, 0.11415213f, 0.04004732f, 0.01264968f, 
    0.01499913f, -0.06216462f, -0.00820315f, -0.05732197f, -0.08341783f, 0.20988086f, -0.01006517f, 0.30983162f, 
    0.15767965f, 0.15134606f, -0.03833053f, 0.02921842f, -0.13407746f, 0.03001967f, 0.04216660f, 0.09226581f, 
    0.08125585f, -0.24880332f, -0.07651349f, -0.08616868f, 0.23365776f, 0.12394091f, 0.13310590f, 0.14885485f, 
    0.08036182f, 0.06591799f, -0.04758768f, 0.09761427f, -0.00103801f, 0.14881970f, 0.07758054f, 0.00314834f, 
    0.06634822f, 0.00841320f, -0.18684778f, 0.04788461f, 0.16028926f, -0.07088811f, -0.16919325f, 0.02628635f, 
    0.12327144f, -0.17121893f, -0.05137604f, -0.09324135f, -0.00788019f, 0.05304326f, 0.27755049f, 0.34331676f, 
    -0.07475293f, 0.06131560f, -0.00852197f, 0.10395945f, -0.02754237f, 0.05627440f, -0.08570433f, 0.01410720f, 
    0.08130536f, -0.15154029f, 0.23034529f, -0.16921914f, -0.04103547f, 0.02267795f, -0.02051622f, -0.04887874f, 
    -0.02365956f, -0.01279045f, 0.09053565f, -0.06146830f, 0.34808818f, -0.02934378f, -0.02455632f, -0.32232934f, 
    -0.02040272f, -0.05773867f, -0.05553802f, -0.00762491f, 0.09436034f, -0.08657436f, 0.05069111f, 0.20720944f, 
    -0.17599258f, 0.15348761f, 0.28808066f, -0.03354377f, 0.05437559f, 0.00257547f, 0.01080733f, -0.12531108f, 
    0.09692390f, -0.03631241f, 0.02516048f, 0.10782614f, 0.25031674f, -0.04920680f, -0.07013545f, 0.16864245f, 
    -0.06439842f, -0.01748385f, 0.07249498f, 0.06456687f, -0.05484405f, 0.07006832f, -0.00950983f, 0.07583814f, 
    -0.03169393f, 0.01469423f, -0.02334072f, -0.05497402f, 0.01614050f, -0.00982349f, 0.03903863f, 0.01024870f, 
    -0.04600107f, 0.01119670f, 0.00977629f, -0.05219206f, 0.02831328f, -0.00812279f, 0.02337701f, -0.00410763f, 
    0.00648566f, -0.01306396f, -0.02590456f, 0.00063737f, -0.02725997f, -0.00711463f, -0.01242071f, 0.01853309f, 
    -0.03819348f, 0.04199089f, -0.01346413f, 0.02481243f, 0.02101167f, 0.00204393f, -0.00072993f, -0.03495815f, 
    0.03636255f, 0.04080614f, -0.00322023f, -0.05199061f, -0.00003063f, -0.05358384f, -0.03174913f, -0.00530907f, 
    0.00783910f, -0.02469549f, 0.02174381f, -0.04077825f, -0.01757108f, -0.05139574f, -0.02668407f, -0.00512401f, 
    -0.01215139f, -0.00110936f, 0.03269274f, -0.05144290f, -0.04557126f, -0.05134728f, -0.04471385f, -0.04509394f, 
    0.01871064f, -0.01978088f, -0.00283079f, 0.01973219f, -0.05672083f, -0.02653264f, 0.01316799f, 0.03746510f, 
    -0.03175286f, -0.02159920f, -0.02052728f, 0.00724181f, -0.00983250f, 0.02716447f, -0.04171051f, -0.04095931f, 
    -0.02739941f, 0.02612494f, -0.01019488f, 0.01807568f, -0.04332006f, -0.03020436f, 0.00515471f, -0.03587315f, 
    0.02216186f, -0.01367614f, -0.01927778f, 0.01463147f, -0.05446193f, 0.02348119f, -0.05959160f, -0.05153259f, 
    -0.04622484f, 0.01699533f, -0.04039038f, -0.01458011f, 0.04043952f, 0.02283346f, -0.04926418f, 0.00886802f, 
    -0.05304563f, -0.05744991f, 0.01450094f, -0.00341231f, -0.00526352f, -0.00850089f, 0.01674592f, 0.03813237f, 
    -0.03563929f, -0.03739865f, -0.00026600f, -0.01658356f, -0.05688148f, 0.02101742f, 0.01868439f, 0.04179514f, 
    -0.03208412f, -0.04898474f, -0.01756554f, -0.04731245f, -0.04624221f, 0.01248524f, -0.00900109f, -0.01882365f, 
    0.01413983f, -0.02102326f, -0.04625893f, -0.05514292f, -0.02841029f, -0.03957338f, -0.05077276f, 0.01279799f, 
    -0.01174222f, 0.03237514f, 0.01454025f, -0.03060515f, 0.03838648f, 0.02287162f, -0.00254568f, -0.00887673f, 
    -0.05000271f, 0.03228411f, 0.01658004f, 0.02408051f, -0.00347741f, -0.03881689f, 0.03815594f, -0.00174647f, 
    0.02406351f, -0.01132320f, 0.01574028f, 0.04123406f, 0.02078740f, -0.03579349f, -0.05802801f, -0.05806940f, 
    -0.01000352f, 0.01200843f, 0.03673667f, 0.04065378f, 0.00921230f, -0.00107263f, 0.03812662f, -0.04607311f, 
    -0.02929767f, -0.04700471f, 0.03924505f, 0.01281494f, -0.01560608f, -0.04870080f, 0.03977432f, -0.00608422f, 
    0.01257273f, 0.00244464f, 0.00198057f, -0.04878909f, -0.02779734f, -0.04525636f, -0.02731421f, -0.03918468f, 
    0.03550082f, -0.01959266f, 0.03212679f, 0.00664779f, -0.03997270f, 0.02999369f, -0.01030859f, 0.02103472f, 
    0.03914116f, 0.00325964f, -0.05738234f, 0.02641738f, -0.05273161f, 0.00745248f, -0.01200325f, -0.04819052f, 
    0.02577081f, 0.01339116f, -0.02669273f, -0.00588362f, 0.02020928f, -0.02867528f, -0.05483957f, 0.01832644f, 
    -0.05570069f, -0.04115828f, 0.01257216f, -0.04835659f, -0.00859985f, 0.00086416f, -0.05018567f, -0.04451550f, 
    0.01981758f, 0.04465327f, 0.00209486f, 0.01522910f, 0.01499785f, 0.03193050f, 0.02093991f, 0.04125899f, 
    -0.02376479f, -0.02675683f, -0.03284564f, -0.03109538f, 0.01804699f, -0.02286552f, -0.03391637f, -0.03544316f, 
    -0.05189535f, -0.04744725f, -0.01382628f, 0.03222422f, 0.04591143f, 0.01664591f, -0.04677629f, -0.02215191f, 
    0.00114458f, -0.05179790f, -0.05182066f, 0.03576896f, 0.02203816f, 0.03116962f, 0.01709283f, 0.01350905f, 
    0.00405950f, -0.01925922f, -0.00514235f, -0.04758568f, -0.01397904f, -0.04108553f, -0.05191021f, -0.02701112f, 
    0.02258650f, 0.04250491f, -0.02369691f, 0.03737230f, 0.01991839f, 0.00105805f, -0.03144421f, 0.01554961f, 
    -0.01254251f, 0.03992272f, 0.02170055f, -0.03421895f, 0.00650977f, 0.02510914f, 0.00359141f, -0.04400647f, 
    0.00702077f, -0.03251790f, -0.03990756f, 0.02198125f, -0.03363190f, 0.03345632f, -0.02548862f, 0.03716492f, 
    -0.00293068f, -0.00406060f, -0.05408570f, -0.04260085f, -0.03029243f, 0.01142209f, 0.00497338f, 0.01505983f, 
    -0.05200934f, -0.00508754f, 0.01337387f, -0.01352177f, -0.01899481f, 0.03010495f, -0.03792902f, -0.00277757f, 
    -0.00595683f, -0.01677078f, 0.01663501f, -0.04206627f, -0.03874055f, -0.00881006f, -0.00759410f, 0.04242850f, 
    -0.00254819f, 0.02593493f, -0.03746304f, -0.04234681f, 0.00610952f, -0.03082929f, 0.01338014f, -0.03250822f, 
    -0.04933397f, -0.00049550f, 0.00698121f, -0.04199919f, 0.01786153f, 0.04144347f, 0.00508717f, 0.03546123f, 
    0.04490237f, -0.00023571f, -0.02342349f, 0.03622964f, 0.04316784f, -0.03971369f, -0.04292021f, -0.05768234f, 
    -0.03810767f, -0.00102518f, 0.03540311f, 0.04242316f, -0.03586470f, 0.03394526f, -0.02470786f, -0.00770851f, 
    0.02377257f, -0.03425619f, -0.05238185f, 0.01967678f, -0.02534621f, 0.02644363f, 0.00978466f, -0.02706818f, 
    -0.04791244f, 0.01084820f, 0.02552334f, 0.00381960f, -0.05996857f, -0.04909603f, 0.01940288f, -0.01516940f, 
    0.02429090f, 0.03187757f, 0.02469751f, -0.05416061f, -0.03491309f, 0.01639896f, -0.01468693f, -0.04990437f, 
    -0.05673479f, 0.02062951f, 0.03310439f, 0.02468752f, 0.04086814f, 0.01455713f, -0.00215081f, -0.03062942f, 
    -0.03904491f, 0.02587729f, -0.02213875f, -0.02103803f, 0.02427675f, -0.02176894f, -0.03238782f, 0.03259143f, 
    -0.05069641f, 0.02886607f, 0.04577610f, -0.01094856f, -0.03802096f, 0.00520756f, -0.04149472f, 0.02850034f, 
    -0.04488999f, -0.01361553f, -0.00864211f, 0.03180595f, -0.03282521f, 0.01190596f, -0.05761292f, 0.03657455f, 
    -0.00118677f, 0.03991644f, -0.02790362f, 0.01174174f, 0.04027315f, -0.02113525f, 0.03588313f, -0.05596348f, 
    0.02630579f, -0.05364750f, 0.03093486f, -0.02655442f, 0.00119036f, 0.00777637f, -0.03176101f, 0.00943451f, 
    -0.01071531f, -0.00311427f, -0.05294504f, 0.00390504f, 0.00790903f, 0.00301741f, -0.01657907f, -0.04269930f, 
    0.02354431f, 0.02717669f, 0.03504470f, -0.02520415f, 0.04013947f, 0.02601906f, -0.00009848f, -0.01229194f, 
    -0.04342684f, -0.02588906f, -0.00169509f, -0.00217055f, 0.02475641f, 0.00112196f, -0.03146014f, -0.03367839f, 
    -0.00672688f, -0.01130033f, 0.02469687f, 0.02791839f, 0.03502090f, -0.01217426f, -0.03744227f, -0.04066903f, 
    0.03672807f, -0.03087051f, 0.02546281f, -0.01988556f, -0.04139813f, 0.04549303f, 0.00108941f, -0.00196032f, 
    -0.01399315f, 0.03676531f, -0.04411392f, -0.00498782f, -0.01941561f, -0.03222295f, -0.06122238f, -0.00076131f, 
    -0.00457290f, -0.05974476f, -0.02323833f, 0.01142448f, 0.00118685f, -0.04457399f, 0.01294188f, -0.02678116f, 
    0.01521320f, 0.02186622f, -0.00060410f, 0.00161463f, 0.01536077f, -0.00911887f, 0.00379851f, -0.03786406f, 
    0.02963862f, 0.02586652f, -0.02973149f, 0.00232531f, -0.01183880f, -0.04095571f, 0.03525415f, 0.01452127f, 
    -0.04692688f, -0.00821142f, -0.05543452f, -0.00960599f, 0.03055248f, -0.01670112f, 0.01912339f, 0.00294742f, 
    -0.00648613f, -0.04385387f, 0.03576000f, 0.02384609f, -0.01692406f, 0.00476290f, -0.03694450f, 0.00351364f, 
    -0.04248748f, 0.02571479f, -0.05879378f, -0.03470891f, -0.02167533f, -0.03769265f, -0.04178969f, -0.00134452f, 
    0.00845604f, -0.01058750f, 0.01513744f, -0.05195604f, -0.02571747f, -0.00380754f, -0.00375506f, 0.00508256f, 
    -0.02940666f, 0.00187872f, -0.00990398f, -0.00800521f, -0.03379450f, 0.03835583f, 0.00585998f, -0.03156402f, 
    -0.05721683f, -0.05386660f, 0.01330127f, -0.03801443f, -0.03278928f, 0.04513181f, 0.04184230f, -0.01031321f, 
    -0.03921131f, 0.02850226f, -0.05825888f, 0.00501597f, 0.01875968f, -0.01789423f, 0.02549232f, 0.02887840f, 
    -0.02659832f, -0.00721230f, -0.02101907f, -0.03725979f, 0.03788333f, 0.03756020f, 0.03478871f, -0.04558802f, 
    -0.01712043f, 0.01550751f, -0.01292017f, -0.01793336f, 0.01278400f, -0.02897538f, -0.05915490f, 0.00243014f, 
    0.03998643f, 0.01265263f, 0.01724986f, -0.04084124f, 0.01262771f, 0.03851943f, 0.04753632f, 0.04181406f, 
    -0.02639164f, 0.00415333f, 0.01503767f, 0.01679581f, -0.02600201f, -0.04673289f, -0.01892306f, 0.00564696f, 
    0.01347471f, 0.03521094f, 0.02194568f, 0.01688245f, 0.02226314f, -0.03800467f, 0.03769372f, -0.00242994f, 
    0.00641490f, -0.01460520f, 0.01786934f, -0.04385042f, 0.02143178f, 0.00586889f, -0.01355699f, -0.04623872f, 
    0.00801489f, -0.06231030f, 0.00800108f, 0.00421705f, 0.01345458f, -0.01778785f, -0.05410200f, 0.02348706f, 
    -0.02532842f, -0.04892679f, 0.04534214f, -0.04894340f, -0.00878502f, -0.05580868f, -0.04353725f, 0.01952654f, 
    0.02368283f, -0.01980799f, -0.04813650f, -0.00951672f, 0.01255136f, 0.02115684f, -0.00633211f, 0.02366648f, 
    -0.00866226f, -0.04780150f, 0.01235942f, -0.03751373f, -0.02871304f, -0.00074051f, 0.00178853f, -0.05789126f, 
    -0.02371418f, -0.01797442f, 0.02687584f, -0.03100024f, -0.00875778f, 0.03140256f, -0.02934394f, -0.01781836f, 
    -0.04687230f, -0.00846319f, -0.02705695f, -0.01199989f, 0.04044703f, -0.02117724f, -0.02827807f, 0.03431218f, 
    0.01875615f, 0.04852656f, -0.03603398f, -0.00840593f, 0.03215083f, 0.03219217f, -0.02004943f, -0.04538375f, 
    -0.04854647f, -0.01649055f, -0.05362178f, -0.05181623f, 0.01199643f, -0.06166601f, 0.05206970f, -0.00904623f, 
    0.04286377f, -0.04329700f, 0.04673971f, 0.01877433f, -0.01478459f, -0.00955222f, -0.04200175f, -0.04153962f, 
    0.03652261f, 0.00616712f, 0.01726956f, -0.00033876f, -0.00878063f, -0.00760452f, -0.05304627f, 0.03555790f, 
    -0.04307366f, -0.03227944f, -0.03665807f, 0.03425667f, -0.01351092f, -0.01140340f, 0.03267655f, 0.02976116f, 
    0.00670505f, 0.04194180f, 0.02355589f, 0.01082458f, -0.04060738f, 0.00843908f, -0.00692487f, -0.03489253f, 
    0.00706374f, 0.00262086f, -0.01053638f, -0.06212893f, 0.03734599f, -0.04708571f, -0.03622374f, -0.05756065f, 
    0.00343542f, -0.00105368f, -0.04315350f, 0.00651676f, 0.01952314f, 0.00705963f, 0.00725303f, -0.02499293f, 
    -0.03745139f, -0.02862683f, 0.02950518f, -0.05743079f, -0.02410231f, -0.04070023f, 0.00326108f, -0.00353513f, 
    -0.00822289f, 0.00376839f, 0.01898360f, -0.00215006f, 0.02853331f, -0.02726237f, 0.02307698f, -0.00333960f, 
    -0.00446626f, -0.02169550f, -0.00769315f, -0.03713685f, 0.01933836f, 0.02770067f, -0.01432829f, -0.02058686f, 
    0.01994050f, -0.01993269f, -0.00477613f, -0.02810058f, 0.00682240f, -0.00855775f, -0.03905201f, 0.03944509f, 
    -0.04829533f, 0.02502712f, -0.04866972f, 0.02288585f, 0.00655227f, 0.00265933f, -0.01458612f, -0.04160258f, 
    -0.00253722f, -0.02415866f, -0.02958737f, 0.04292263f, 0.02694998f, -0.02227537f, 0.03794387f, -0.02786480f, 
    -0.03114572f, 0.01451519f, 0.00447250f, -0.04226630f, -0.04580803f, 0.01135495f, -0.03125431f, 0.04445929f, 
    0.01394813f, -0.03928407f, 0.02796908f, -0.03634597f, -0.01827285f, -0.00140117f, -0.01496590f, 0.01482121f, 
    -0.00496354f, 0.01996971f, -0.01196139f, 0.02402446f, 0.03172833f, -0.04990731f, 0.01549154f, -0.00836832f, 
    -0.02776091f, -0.02443595f, 0.04033470f, 0.00275614f, -0.03138556f, 0.04189603f, -0.04603381f, -0.00687000f, 
    0.02649130f, -0.03698068f, 0.00224291f, -0.01285002f, -0.03365484f, -0.02552873f, 0.01067574f, 0.00148362f, 
    0.02429355f, 0.00343361f, -0.02073444f, -0.00871686f, -0.05193030f, 0.02095615f, -0.03060056f, 0.02739566f, 
    -0.01225958f, -0.05148669f, -0.03019135f, -0.00721132f, 0.00269229f, 0.00450132f, 0.02802930f, -0.04566554f, 
    0.04099969f, -0.02050468f, -0.03118389f, 0.00469003f, 0.02705670f, -0.01437853f, 0.01414380f, -0.01483759f, 
    -0.02580539f, -0.00246926f, -0.01654558f, -0.04643492f, 0.03950331f, 0.04228029f, -0.01596334f, -0.03544731f, 
    -0.02281601f, 0.02400418f, -0.05500652f, 0.01198655f, 0.03236094f, -0.05296509f, 0.00326699f, 0.02294483f, 
    -0.00395535f, 0.01341306f, 0.01054687f, -0.04486354f, -0.00885328f, -0.04750880f, 0.00290223f, 0.03389461f, 
    0.02859011f, 0.02035552f, -0.03299383f, 0.04139808f, -0.04943570f, -0.00562769f, -0.00881126f, -0.05259915f, 
    -0.03531571f, -0.01144246f, -0.00294356f, -0.05073291f, -0.05408068f, 0.01155457f, -0.00717454f, 0.02500020f, 
    -0.00054938f, -0.03156901f, -0.00821834f, 0.01376113f, 0.02223845f, -0.01462949f, -0.03601732f, 0.01473596f, 
    0.03664405f, -0.05693173f, -0.04222070f, 0.00761813f, -0.04057189f, -0.01839869f, 0.02976796f, -0.02212531f, 
    -0.04573499f, 0.03628841f, 0.01918526f, -0.02218429f, -0.00488444f, 0.02146112f, 0.03354884f, -0.00924968f, 
    -0.02282573f, -0.04881083f, 0.01576589f, -0.04630857f, -0.01477691f, 0.01029515f, -0.02249585f, 0.02013331f, 
    -0.03165520f, 0.02287941f, 0.03244366f, 0.02182871f, -0.01563994f, 0.00655848f, -0.00427721f, -0.02734929f, 
    0.00773999f, 0.00047884f, 0.03942507f, -0.02784348f, -0.00731610f, 0.02490042f, -0.04117057f, -0.02007077f, 
    0.03866038f, -0.04393141f, 0.03777315f, 0.02298049f, 0.00674883f, -0.03419985f, 0.03907805f, -0.04010777f, 
    0.03592458f, -0.05520564f, -0.00979798f, 0.01151117f, -0.03943838f, 0.00593411f, -0.00057744f, -0.04788785f, 
    0.02996353f, -0.03206384f, -0.04074073f, 0.01678959f, -0.00869305f, 0.02559222f, -0.02537950f, -0.02061990f, 
    0.02267886f, 0.02924321f, -0.00217204f, -0.01280888f, 0.03174156f, -0.03150507f, 0.03479335f, -0.02563391f, 
    -0.04768569f, 0.03038996f, -0.03983952f, -0.02808053f, 0.03652244f, -0.02682982f, -0.03978593f, -0.00328519f, 
    0.01257794f, -0.03543063f, -0.03890867f, 0.03244517f, 0.00675592f, -0.05732510f, 0.02357918f, 0.02285076f, 
    0.04354372f, 0.03883753f, -0.04332672f, 0.00696378f, 0.00573594f, -0.02570850f, 0.00107389f, -0.02614538f, 
    0.00148626f, 0.00653142f, -0.01319862f, -0.00919943f, -0.03601171f, 0.01601023f, 0.00980469f, 0.03918543f, 
    -0.02558705f, 0.00114499f, -0.02423017f, 0.00062536f, 0.04169154f, 0.01778314f, -0.03879815f, -0.01564662f, 
    0.00347469f, -0.04652840f, 0.02111831f, 0.02709748f, 0.03578518f, -0.04598116f, 0.00877530f, -0.02274190f, 
    -0.04273664f, 0.01203413f, -0.05409776f, -0.05304256f, 0.02721222f, -0.04639576f, 0.00894234f, -0.01626926f, 
    -0.05436653f, -0.00983508f, -0.04425922f, -0.01782484f, 0.01291788f, 0.02719125f, 0.01467750f, -0.05185461f, 
    0.02844859f, 0.02037622f, -0.05066610f, -0.04462215f, 0.02682991f, -0.03771757f, 0.03317456f, -0.04610519f, 
    0.00040514f, 0.01902023f, -0.02931033f, -0.01769957f, -0.03337932f, 0.01583665f, -0.03412855f, 0.02226523f, 
    0.01427999f, 0.01137254f, -0.00272176f, -0.01604023f, 0.01847846f, -0.00814835f, 0.04364599f, -0.01588065f, 
    0.01159105f, 0.00952308f, 0.02183570f, 0.04088251f, 0.01612508f, 0.02846109f, 0.03647196f, 0.02491709f, 
    -0.03704369f, -0.00660353f, -0.01778657f, -0.05391399f, 0.01997846f, 0.01438100f, 0.04580310f, 0.01757442f, 
    -0.03037279f, -0.00673962f, -0.02821853f, 0.00823283f, -0.01595319f, -0.05276093f, -0.01067726f, -0.04452811f, 
    0.00385654f, -0.03334634f, -0.02883509f, -0.01178275f, 0.01132971f, 0.03975281f, 0.02012940f, -0.00621988f, 
    -0.01705565f, 0.00470002f, -0.00119563f, -0.02868170f, -0.00673789f, -0.02463598f, -0.01716141f, 0.02034411f, 
    0.02073609f, 0.03872883f, 0.01700302f, 0.02774424f, -0.04628233f, -0.04559775f, -0.02325882f, -0.00136233f, 
    -0.00659589f, 0.03402308f, -0.05556818f, -0.03248861f, 0.03543679f, -0.03733293f, 0.01212172f, -0.00811854f, 
    -0.01865811f, -0.05089667f, -0.05435085f, -0.04269617f, 0.00418583f, 0.01918436f, 0.01100611f, -0.00258356f, 
    0.03838174f, -0.04154891f, 0.01412831f, 0.04533074f, -0.04501643f, -0.01979247f, 0.00390924f, -0.01290256f, 
    -0.05665296f, -0.02965533f, -0.00767215f, 0.00630814f, 0.03209738f, 0.02498827f, -0.05057485f, 0.00128449f, 
    -0.00887765f, -0.02143086f, -0.03255123f, -0.06077883f, -0.01104642f, -0.01909810f, 0.04165628f, -0.04468415f, 
    -0.04074056f, -0.02359254f, 0.00760581f, 0.00727208f, -0.03141073f, 0.02145481f, -0.03998765f, -0.03644780f, 
    -0.03437211f, 0.02660465f, -0.01418376f, -0.00727768f, 0.00920085f, -0.01910409f, -0.02617835f, -0.04906413f, 
    -0.01079936f, -0.01142516f, -0.04470938f, 0.02054795f, -0.00501740f, 0.01362773f, 0.04013094f, -0.01731132f, 
    0.04144309f, -0.05605190f, 0.04435692f, -0.02724758f, 0.03021074f, -0.02008164f, -0.04326503f, 0.02411326f, 
    -0.02497859f, 0.00854204f, 0.03959931f, -0.04627332f, -0.04495588f, 0.01345164f, -0.03463170f, 0.03026050f, 
    0.01177294f, -0.00838985f, -0.05680570f, -0.03133713f, -0.04859504f, 0.03392674f, -0.02644004f, -0.02023154f, 
    -0.03717094f, 0.03713271f, 0.03179190f, 0.01392010f, 0.03642318f, -0.04782188f, -0.05289645f, -0.04809334f, 
    0.13796219f, 0.06040372f, -0.10050578f, 0.22734985f, -0.03719949f, -0.00047874f, 0.01396325f, 0.00044034f, 
    -0.13350397f, 0.12707701f, 0.10402715f, 0.15457289f, 0.47584948f, -0.04281945f, -0.30019048f, -0.09254204f, 
    -0.00934763f, 0.08841189f, -0.02897665f, 0.01623889f, 0.07942480f, 0.08639514f, 0.18404487f, 0.11490035f, 
    -0.17006440f, 0.08877799f, -0.04356806f, 0.02011232f, -0.00273378f, -0.13821755f, -0.18192561f, 0.03186917f, 
    0.09268503f, -0.01190444f, 0.17119154f, -0.03286801f, -0.25475532f, -0.17679715f, 0.19314320f, -0.10353818f, 
    -0.03849454f, -0.09844135f, -0.24714741f, 0.00719813f, -0.03840636f, 0.13058791f, 0.00957874f, 0.07544201f, 
    -0.01591699f, 0.02936597f, 0.06405821f, -0.11168471f, -0.08703540f, -0.18689236f, -0.15790164f, -0.09903441f, 
    0.01356912f, 0.13814187f, 0.01568551f, 0.16454406f, 0.14538249f, -0.07232019f, -0.11381125f, -0.15605152f, 
    0.02241338f, -0.08755723f, 0.08746095f, -0.00861267f, 0.02406393f, -0.01934683f, -0.08984447f, 0.13740569f, 
    -0.10151777f, -0.14233819f, 0.01694880f, 0.07300085f, 0.01520343f, 0.08867878f, 0.06159301f, 0.15817612f, 
    0.08622900f, 0.05558598f, -0.07483641f, -0.07687303f, -0.07781018f, -0.08611079f, -0.11571359f, 0.05488876f, 
    0.13350642f, 0.13266477f, -0.01364841f, -0.04348685f, -0.05355465f, 0.03888305f, -0.12443247f, 0.08717295f, 
    -0.05378246f, -0.10078174f, 0.09351695f, -0.09753192f, 0.07190105f, -0.01424151f, 0.10778964f, 0.01428626f, 
    0.08026125f, 0.22334331f, -0.15100712f, -0.02617751f, -0.17908223f, 0.19105119f, 0.13435909f, -0.01938521f, 
    -0.00967687f, -0.03774162f, 0.07987211f, -0.01693915f, 0.04629001f, 0.08667590f, -0.10620043f, -0.19820121f, 
    -0.09881398f, 0.07207143f, 0.13967644f, 0.13081597f, 0.06471182f, -0.13191131f, -0.17180242f, -0.01819888f, 
    0.02236503f, 0.11539158f, -0.21838084f, -0.06229101f, -0.16651797f, 0.19877027f, -0.20142144f, -0.11402101f, 
    0.03189472f, -0.03050674f, -0.07870889f, 0.18581800f, -0.00038286f, -0.07528991f, -0.14275798f, -0.03651968f, 
    0.04802996f, -0.20265520f, -0.03969464f, 0.02212569f, 0.18527763f, -0.09374632f, 0.08957341f, -0.11828208f, 
    0.05847409f, -0.01800148f, 0.08238501f, 0.10980560f, -0.24576025f, 0.42442194f, -0.05544729f, -0.04183039f, 
    0.23200460f, 0.05699710f, -0.03381101f, -0.19408999f, 0.09289324f, -0.14071099f, 0.09629203f, -0.03242486f, 
    -0.20684005f, -0.07537521f, -0.09891065f, 0.15264682f, -0.01375779f, -0.24231446f, -0.10374355f, -0.06591304f, 
    0.11433681f, 0.16347040f, -0.02262644f, -0.00220734f, 0.02229428f, 0.02926783f, 0.05819897f, 0.15427184f, 
    0.08713667f, 0.19512735f, 0.13180897f, -0.03071409f, 0.19037864f, 0.10328703f, 0.05924936f, -0.04125952f, 
    0.14820097f, 0.01517719f, 0.00010432f, -0.06046858f, -0.09329236f, 0.16760485f, 0.11750321f, 0.00785579f, 
    0.04576679f, -0.11294276f, 0.16369464f, 0.03904094f, -0.16175297f, -0.16380356f, -0.15727007f, 0.02917776f, 
    0.17143533f, -0.17844963f, -0.00672175f, -0.06719698f, 0.10717853f, 0.04750773f, 0.12122251f, 0.04972078f, 
    0.22107856f, 0.35422438f, 0.23018357f, 0.06792561f, 0.01952376f, 0.08630721f, -0.11358288f, -0.00629676f, 
    -0.01260996f, 0.06032831f, -0.10251710f, -0.10057458f, 0.01185710f, -0.07365540f, -0.19339164f, -0.15200233f, 
    0.27834564f, -0.10399574f, -0.02477385f, 0.01661116f, 0.13256177f, 0.03692108f, 0.15853468f, 0.16600986f, 
    -0.11145089f, 0.03933999f, 0.01194473f, -0.22997445f, 0.07949196f, -0.01946054f, -0.17206874f, -0.18211822f, 
    -0.05709603f, -0.11420392f, -0.08467109f, -0.20233572f, 0.13547555f, 0.14061904f, -0.10053669f, 0.16471559f, 
    -0.02829533f, 0.05175241f, 0.10091498f, 0.11841034f, 0.09316077f, 0.07157105f, 0.17390257f, -0.02099905f, 
    0.24780276f, -0.05582816f, -0.07747699f, -0.18245825f, 0.06440463f, 0.01397851f, -0.16559736f, 0.07004161f, 
    -0.00351777f, -0.01139764f, -0.14827177f, 0.01597175f, -0.03343964f, -0.05249735f, 0.03934339f, 0.15837382f, 
    0.04176529f, -0.10646240f, 0.00794516f, 0.02859071f, 0.05175574f, -0.10532065f, 0.03085668f, -0.22923025f, 
    0.02765772f, 0.19344908f, 0.03895964f, 0.08745909f, 0.06769900f, 0.04276169f, -0.02875861f, -0.00098904f, 
    0.00818922f, 0.05970972f, 0.00197040f, 0.12125252f, -0.15154125f, -0.22501332f, 0.14807659f, -0.09563203f, 
    0.04883904f, -0.06956390f, 0.05487049f, -0.01981665f, 0.11040942f, -0.05367108f, 0.09676858f, -0.00128868f, 
    -0.18664648f, 0.05849287f, 0.33929044f, -0.16424100f, 0.02255391f, -0.06404184f, 0.11462335f, 0.03203539f, 
    0.05957544f, 0.05255494f, 0.20878944f, 0.06822808f, 0.23066860f, 0.19660965f, 0.03709210f, 0.13238099f, 
    0.05602659f, 0.02079163f, 0.11648735f, 0.09000804f, 0.01744235f, -0.05308212f, 0.08320731f, -0.13808125f, 
    0.38869640f, 0.03597868f, -0.23463333f, -0.04457669f, 0.07141795f, -0.06956086f, 0.10116445f, 0.19114539f, 
    0.02677470f, 0.03203224f, -0.00754703f, -0.08985826f, -0.40619892f, -0.05841021f, 0.07654195f, 0.15291882f, 
    -0.02028739f, -0.03723309f, 0.14162292f, -0.11345564f, 0.01432256f, -0.05571974f, -0.09956735f, -0.22697459f, 
    0.22801052f, -0.10966396f, 0.02322225f, -0.01764318f, 0.09092768f, 0.03842329f, -0.06470643f, 0.03011555f, 
    0.04377920f, -0.05628815f, -0.03257261f, 0.09193872f, 0.25933281f, 0.18065895f, -0.10346612f, -0.09044182f, 
    0.18834807f, -0.01042151f, -0.10487205f, 0.07324010f, -0.04306108f, -0.07699911f, 0.14062023f, 0.04180026f, 
    0.21978727f, 0.09940553f, 0.27124643f, -0.16992635f, 0.07440551f, 0.14719583f, 0.02645308f, -0.00510276f, 
    0.04097152f, 0.13574457f, 0.05255664f, 0.06970390f, -0.48962358f, 0.14593381f, 0.00030851f, 0.04229762f, 
    0.04648723f, 0.12956306f, 0.04534858f, 0.07429690f, 0.11178412f, 0.04802947f, 0.14098236f, 0.02654722f, 
    -0.04420747f, -0.11806078f, 0.12076950f, 0.18324499f, -0.03656847f, -0.02527584f, 0.08910844f, 0.06633136f, 
    -0.00399046f, 0.15791309f, -0.06497569f, 0.10222618f, 0.07435074f, -0.04986493f, 0.06547633f, 0.08094712f, 
    0.21452020f, -0.03942092f, -0.09825908f, 0.08307995f, -0.02135467f, 0.15483971f, 0.10256179f, 0.06862851f, 
    -0.08311407f, 0.06892338f, 0.15225002f, 0.18080796f, -0.06348587f, -0.03272201f, 0.04098351f, -0.01423405f, 
    -0.15690719f, 0.16299561f, 0.08913235f, 0.06273298f, 0.01593584f, 0.08278318f, 0.05797635f, -0.04615612f, 
    0.07890097f, -0.02153309f, 0.00267351f, 0.03474163f, 0.02403687f, 0.09206123f, 0.08288745f, 0.20245796f, 
    0.21979231f, -0.11942463f, 0.25404161f, -0.00734648f, 0.00418256f, 0.05913694f, 0.04973100f, 0.04578649f, 
    0.10198651f, 0.01625030f, -0.03820315f, -0.08027453f, -0.12460905f, -0.14245279f, 0.10058533f, 0.16056621f, 
    0.17791638f, 0.06164405f, 0.00236495f, -0.07687403f, 0.04354109f, 0.00414748f, -0.05253620f, 0.06252664f, 
    0.16974558f, -0.22719660f, 0.09578809f, -0.00062743f, -0.10289596f, -0.02681274f, 0.03594328f, -0.02487424f, 
    0.21371238f, 0.10974032f, 0.00204156f, 0.01397129f, 0.11838186f, 0.17454468f, -0.22044961f, -0.02743066f, 
    -0.15558152f, -0.05330122f, 0.10512345f, -0.07772121f, -0.05580398f, -0.05824367f, -0.19376820f, -0.17415786f, 
    0.03464819f, 0.04906693f, -0.05937951f, -0.08361100f, 0.10212708f, -0.12678772f, -0.02857316f, 0.11592387f, 
    0.09641442f, 0.27267379f, 0.01344625f, -0.00295759f, 0.08063073f, -0.24815780f, 0.09888840f, -0.09465146f, 
    -0.00287892f, -0.01643525f, -0.08125533f, 0.02567345f, -0.05558279f, 0.14735252f, -0.13451380f, 0.09241325f, 
    -0.02016568f, -0.23778956f, 0.30195203f, 0.33569384f, 0.11748718f, 0.04488839f, 0.02317803f, -0.04448223f, 
    0.02644422f, -0.08694431f, 0.12313048f, 0.05571745f, 0.14603756f, -0.32402104f, 0.09905297f, -0.04605803f, 
    0.08193926f, -0.08219742f, 0.06772044f, 0.09874516f, 0.07576358f, -0.11155918f, -0.02039458f, 0.05819445f, 
    -0.17161927f, -0.05546609f, -0.00660543f, 0.01861300f, 0.12777656f, -0.04859753f, 0.00974270f, 0.04926325f, 
    0.05576122f, 0.01891497f, -0.00920034f, 0.07606891f, -0.00802620f, -0.08221135f, 0.14951751f, -0.19353667f, 
    0.10224885f, 0.08844982f, 0.03700742f, -0.03347904f, 0.08679154f, 0.06346524f, 0.00738856f, 0.04296248f, 
    0.09459183f, -0.07691029f, -0.06367318f, -0.17191574f, -0.02036574f, 0.02633401f, 0.05821187f, 0.04774645f, 
    0.01498371f, -0.04775777f, 0.10341528f, -0.07508857f, 0.05208625f, 0.06283902f, -0.07915073f, 0.07605813f, 
    -0.03686580f, -0.06010207f, 0.01037957f, 0.07541658f, 0.00044209f, 0.02139338f, 0.11386015f, 0.09685867f, 
    -0.30232835f, -0.14564325f, -0.04666277f, -0.28517890f, -0.03442929f, 0.06071513f, -0.04092665f, 0.05403285f, 
    -0.00916374f, 0.05603065f, -0.01514930f, 0.00444699f, -0.04262014f, 0.02554576f, 0.17005925f, 0.06017940f, 
    0.05906652f, -0.03606520f, 0.03036678f, 0.01036505f, 0.07773017f, 0.05354092f, 0.09660898f, 0.27932397f, 
    0.00583317f, -0.23165791f, 0.19997303f, 0.23680332f, -0.14176661f, 0.11235953f, -0.10546461f, 0.05603877f, 
    0.00243782f, -0.18869869f, 0.00270621f, -0.11544389f, 0.03971477f, -0.00592756f, -0.06363286f, -0.10391956f, 
    -0.12538762f, -0.11176105f, -0.06023952f, 0.14396709f, -0.06137508f, 0.06252494f, 0.02874972f, -0.01104757f, 
    0.13770428f, 0.03120052f, -0.04370157f, 0.17392385f, -0.05171814f, -0.11168724f, -0.06427246f, -0.06491620f, 
    0.02767507f, 0.04596111f, -0.09148838f, 0.00024238f, -0.09953858f, 0.10399523f, 0.02621770f, -0.14841701f, 
    -0.01311039f, -0.03725393f, 0.26499465f, 0.05359432f, 0.07062709f, -0.02258982f, 0.13344204f, -0.16443773f, 
    -0.06025459f, -0.12226913f, 0.07017208f, -0.08510584f, 0.05123074f, 0.00433984f, 0.05510207f, -0.07834191f, 
    0.09072378f, 0.17991881f, 0.00880692f, 0.07596937f, 0.17052858f, -0.37912574f, 0.05453547f, 0.06900411f, 
    -0.06058723f, 0.02568306f, 0.02627283f, 0.01296716f, 0.15422314f, -0.09567118f, 0.14398730f, 0.07128159f, 
    0.01179921f, -0.06061659f, -0.10556934f, 0.05315370f, -0.04124549f, -0.06309483f, -0.06569228f, 0.14202099f, 
    -0.00259921f, 0.18551567f, 0.07321979f, -0.04189678f, 0.38920030f, 0.00524607f, -0.19361858f, -0.13263084f, 
    -0.07472304f, -0.13787095f, 0.03711043f, -0.09829359f, 0.03675506f, 0.02725173f, 0.15649951f, -0.04539801f, 
    -0.12586354f, 0.21826355f, -0.24132083f, -0.03808288f, 0.09892159f, 0.11573692f, -0.07776625f, -0.03199365f, 
    0.02750207f, 0.02890003f, -0.00825083f, 0.15729094f, -0.06886796f, 0.06463712f, -0.01079066f, -0.06029421f, 
    -0.02799446f, 0.03558787f, 0.06471930f, 0.20107064f, 0.03500590f, -0.06276648f, -0.18811934f, -0.11899795f, 
    -0.25396872f, -0.10036927f, -0.08144491f, 0.17196165f, 0.19650602f, 0.04924198f, -0.02278626f, 0.04694255f, 
    -0.04070638f, 0.07454440f, 0.05226566f, -0.06948245f, 0.33825919f, -0.11197474f, 0.11473596f, 0.04632518f, 
    -0.03453641f, 0.09311379f, -0.04755742f, 0.10973093f, 0.05913971f, 0.02991298f, 0.06163249f, 0.04133997f, 
    -0.25398675f, 0.01362378f, -0.21944091f, -0.02429316f, 0.00985438f, -0.14194004f, -0.06222903f, 0.07057554f, 
    0.03768955f, -0.01390366f, 0.05749508f, -0.06074135f, 0.04378842f, -0.20528494f, 0.07465622f, 0.23108992f, 
    0.08182690f, 0.03742652f, -0.17251623f, -0.17183706f, -0.08435118f, -0.11181649f, -0.05799154f, 0.01727263f, 
    0.11898538f, -0.02563085f, -0.14931099f, -0.04426980f, -0.00462400f, 0.15240251f, -0.18410826f, -0.00576508f, 
    0.06669397f, -0.04669745f, 0.16486117f, -0.03987964f, -0.06241875f, 0.09448460f, -0.19462484f, -0.19729418f, 
    0.02752279f, 0.07271273f, -0.01506989f, -0.03342002f, -0.01349359f, -0.12558326f, -0.10755111f, -0.14383370f, 
    0.09646995f, -0.01675370f, -0.07163166f, 0.10153625f, 0.06769028f, 0.17396627f, 0.01785802f, 0.01512948f, 
    0.07280511f, -0.05737682f, 0.01082737f, -0.02163875f, -0.07005700f, -0.07743053f, 0.02842184f, 0.02426449f, 
    -0.05205574f, 0.07476871f, -0.06390433f, -0.13516304f, 0.02173963f, -0.06814314f, -0.01531898f, -0.03646554f, 
    -0.09558690f, 0.29403344f, -0.19129008f, 0.01708479f, 0.00542118f, 0.17035034f, -0.00090049f, -0.01074721f, 
    -0.01138706f, 0.01800575f, 0.11039726f, 0.04702749f, 0.13708444f, -0.07575170f, 0.00798878f, 0.01533806f, 
    -0.02921457f, 0.05504442f, -0.00179033f, -0.00449879f, -0.05247823f, -0.02362962f, 0.03732684f, 0.00633690f, 
    -0.10164230f, 0.26641846f, -0.15918219f, -0.02042761f, 0.18155748f, 0.07770263f, -0.08397296f, -0.01137598f, 
    -0.07854226f, -0.09167009f, 0.10698617f, -0.01005686f, -0.00220241f, 0.06365754f, 0.12216238f, -0.06388728f, 
    0.03531218f, -0.03104119f, -0.02449326f, 0.17740814f, 0.03367642f, -0.06755189f, 0.07636316f, 0.20175159f, 
    -0.03002796f, -0.19363236f, -0.02194166f, 0.08270460f, -0.08851764f, 0.14477788f, -0.00401807f, -0.07024349f, 
    0.00745703f, -0.11120816f, -0.04027434f, -0.02554443f, -0.03608305f, 0.10399301f, -0.18912426f, 0.05032382f, 
    0.13069955f, 0.08520210f, 0.13101064f, 0.11319869f, 0.00325294f, 0.06160349f, 0.11256790f, 0.02597846f, 
    -0.15783432f, 0.09259567f, -0.17715713f, 0.05852265f, 0.09515515f, 0.05938137f, -0.12616265f, 0.02631787f, 
    0.03783079f, 0.09379715f, -0.10324386f, -0.02865887f, -0.18656662f, 0.26698264f, -0.07061160f, 0.05194441f, 
    -0.21021718f, 0.14549917f, 0.09945595f, -0.00038042f, -0.04803332f, 0.12995525f, 0.00591538f, 0.09911963f, 
    0.45944986f, 0.24420933f, -0.09609924f, -0.25954390f, -0.07908466f, 0.06886006f, -0.06519642f, 0.13729741f, 
    0.00847816f, 0.02318675f, -0.04500587f, 0.11711641f, 0.03442257f, -0.12622601f, -0.10305759f, 0.34493607f, 
    0.03024209f, -0.16717373f, -0.02502114f, 0.06206893f, -0.06798933f, 0.00158092f, 0.04647549f, 0.00445178f, 
    -0.26805252f, 0.15094149f, 0.02981171f, 0.25562626f, 0.07220399f, 0.03016793f, -0.04979415f, 0.07971739f, 
    -0.06898129f, 0.11844070f, -0.03800964f, 0.04306394f, -0.10858847f, 0.05114758f, 0.24221072f, -0.07569407f, 
    0.04698676f, 0.09306643f, -0.12544799f, 0.10457509f, 0.11134142f, 0.01643334f, -0.07637166f, 0.00606250f, 
    0.10243536f, 0.27821669f, -0.04620319f, 0.38769856f, -0.04794447f, -0.02069113f, 0.06454317f, 0.08109534f, 
    0.03919182f, -0.11005105f, 0.10594194f, 0.05802166f, -0.17270385f, -0.05912963f, -0.16657560f, 0.08108030f, 
    0.08865630f, 0.00987924f, -0.08287074f, -0.17635319f, -0.01151670f, 0.00161218f, -0.00809172f, -0.10722963f, 
    -0.12621808f, 0.04033687f, -0.17383865f, -0.10943842f, 0.18787733f, -0.20577343f, 0.02773477f, -0.07607826f, 
    -0.04449063f, 0.14951137f, 0.13631195f, 0.12553036f, 0.13002080f, 0.22699702f, 0.33276674f, -0.13997073f, 
    0.08298067f, 0.01176842f, 0.01663045f, -0.11190601f, -0.00359107f, 0.00914655f, 0.02393052f, 0.07347888f, 
    -0.13241406f, -0.05987009f, -0.06813160f, -0.12077875f, 0.11663625f, 0.11774690f, 0.05798241f, 0.01414109f, 
    0.03232761f, 0.13424413f, 0.08519628f, 0.12627962f, 0.08914245f, 0.10108551f, 0.16567756f, -0.05732071f, 
    0.02766418f, 0.02909626f, -0.17566140f, 0.06009451f, 0.01000367f, 0.00441527f, 0.03205594f, 0.15788162f, 
    0.15504289f, -0.00653572f, -0.01401692f, 0.01345891f, -0.04309010f, -0.16207303f, -0.00900244f, 0.07478728f, 
    -0.08729373f, -0.18635251f, 0.02340739f, 0.13667387f, 0.08744570f, 0.23668714f, -0.05084215f, 0.00408879f, 
    0.08675402f, -0.01955018f, 0.00994680f, -0.18629384f, -0.05604995f, 0.05683990f, 0.05845534f, 0.00903543f, 
    0.15237743f, -0.01254903f, 0.00025151f, 0.08503358f, 0.02760115f, 0.05072955f, 0.08103678f, -0.09434088f, 
    0.13924968f, -0.13101454f, -0.01795861f, 0.11860541f, -0.39628145f, 0.01238085f, 0.25003517f, 0.25949427f, 
    0.02130401f, 0.11605557f, -0.02037473f, 0.09897289f, -0.09001067f, -0.12300388f, -0.03702776f, -0.03276775f, 
    0.10045885f, -0.12954310f, 0.21893544f, -0.08187082f, -0.01520779f, -0.00156369f, 0.05556815f, 0.09139539f, 
    0.02655671f, 0.08718222f, -0.02288833f, 0.04740706f, 0.13217928f, -0.13049437f, -0.04044047f, -0.00776530f, 
    0.03777676f, -0.02307301f, 0.06622650f, -0.05824579f, 0.09931557f, 0.13502680f, 0.17087138f, 0.19598959f, 
    0.24374671f, 0.10586214f, 0.19788042f, -0.07411630f, -0.08804420f, 0.08485436f, -0.04416385f, -0.17285170f, 
    0.02371479f, -0.00273279f, 0.02537919f, 0.02378786f, -0.25927231f, 0.12226359f, -0.15467490f, -0.08189064f, 
    0.11607238f, -0.20434929f, 0.08367278f, -0.12662135f, -0.06640372f, 0.12842882f, -0.05096879f, -0.10355715f, 
    0.30575049f, 0.02916634f, 0.27100679f, -0.12914778f, 0.01756970f, 0.16750403f, 0.05787608f, 0.05165499f, 
    0.04089867f, 0.02072744f, 0.01642118f, 0.19961447f, 0.08281074f, 0.36225152f, -0.05114244f, -0.14747162f, 
    -0.19176437f, -0.03203078f, 0.04417593f, 0.04505548f, 0.05879966f, 0.05062367f, 0.08592665f, 0.07906099f, 
    -0.02679617f, -0.14887172f, 0.02924012f, 0.17008103f, 0.17196596f, -0.07696335f, 0.06717689f, -0.02828720f, 
    0.06728003f, 0.00924085f, 0.05009946f, 0.16501424f, -0.15593609f, -0.02837393f, 0.26348615f, 0.15567428f, 
    -0.04914500f, -0.07672215f, 0.03623309f, 0.06156117f, 0.05372261f, 0.09776026f, 0.12777820f, 0.18507414f, 
    0.04213455f, 0.01376823f, 0.14289868f, -0.11796357f, -0.02202871f, -0.12584239f, -0.02645288f, -0.06817582f, 
    -0.01074309f, 0.05053187f, -0.02847659f, 0.12527753f, 0.01948017f, 0.07816561f, -0.07026076f, 0.18528698f, 
    0.16607532f, -0.08160095f, 0.04845629f, 0.00350804f, 0.00535965f, 0.03038680f, 0.03635875f, 0.16531983f, 
    0.04925274f, -0.32859406f, 0.16262069f, 0.07327234f, 0.02732167f, -0.13174286f, -0.02673537f, 0.18883830f, 
    0.02714960f, -0.06521895f, -0.07229748f, 0.04791648f, -0.05689667f, -0.08158979f, 0.12357895f, 0.09935049f, 
    0.01592933f, -0.07807755f, -0.04544357f, 0.08410593f, 0.05280070f, -0.04440901f, -0.03030779f, 0.08117612f, 
    0.20463039f, -0.22697990f, 0.17884248f, 0.11206418f, -0.14088109f, -0.06119717f, 0.07062812f, 0.04820489f, 
    0.01625118f, 0.15993652f, -0.06633687f, 0.15829238f, 0.06329595f, 0.06089884f, -0.06074404f, -0.15299308f, 
    -0.04851194f, 0.14078113f, 0.05260234f, -0.12796532f, -0.02339274f, 0.07328039f, -0.13485304f, -0.05059089f, 
    0.18073156f, 0.07054019f, 0.00178882f, 0.07417789f, 0.21037693f, -0.13589536f, 0.01946620f, -0.02575034f, 
    -0.03798743f, 0.11057319f, 0.06280263f, 0.04626311f, -0.19326149f, -0.05702177f, 0.10241459f, 0.04455357f, 
    -0.03453000f, 0.01334085f, -0.17145561f, -0.09183435f, -0.06754552f, -0.00671921f, -0.04169232f, 0.06240293f, 
    0.15647134f, -0.11369567f, 0.08983979f, -0.18335687f, 0.01623915f, -0.19096693f, -0.03930439f, -0.06417780f, 
    -0.03081772f, -0.05654807f, 0.06782985f, 0.03063819f, 0.06503826f, -0.17680833f, 0.20654278f, -0.17296749f, 
    0.20609841f, -0.12859805f, -0.06949215f, -0.00714604f, 0.03015828f, -0.20115061f, 0.06819148f, -0.02895316f, 
    -0.52892148f, -0.15657285f, 0.07004071f, 0.44254032f, 0.07646219f, 0.00669439f, -0.01034559f, -0.08798670f, 
    -0.06420548f, 0.10823252f, 0.06691913f, 0.00141050f, 0.15637296f, 0.07427007f, -0.04183698f, -0.32361025f, 
    0.08460897f, 0.17735249f, 0.05545786f, -0.03658521f, 0.15287225f, 0.01676604f, 0.01669241f, -0.02395408f, 
    0.26396728f, -0.15628184f, 0.06044260f, -0.06739388f, -0.04963228f, 0.06377224f, 0.18223329f, -0.02017172f, 
    0.00115659f, -0.03855771f, 0.10323223f, -0.04967105f, 0.18030255f, -0.02212043f, -0.06987821f, 0.02302705f, 
    0.02350167f, -0.05655520f, 0.14250989f, -0.14961092f, 0.09758732f, 0.09153412f, 0.02309758f, 0.07707430f, 
    0.26797679f, -0.24453817f, 0.02266153f, -0.45599973f, 0.13112929f, -0.01685875f, -0.01057877f, 0.01060927f, 
    0.10574625f, 0.12196443f, 0.00630955f, -0.01197189f, 0.23969406f, 0.12064716f, 0.06204640f, 0.01151593f, 
    -0.06259909f, -0.09936970f, -0.02636856f, 0.07566349f, 0.05999114f, 0.08827646f, 0.08448015f, 0.18898900f, 
    0.00782901f, -0.03927075f, 0.08028437f, 0.01435660f, -0.12871608f, -0.03056179f, -0.16268240f, -0.06523727f, 
    -0.14395300f, -0.15255520f, -0.05420632f, -0.02770140f, -0.16185084f, -0.23008090f, -0.21769042f, 0.10816018f, 
    -0.05983348f, 0.12828521f, 0.02629063f, 0.16206999f, 0.10295863f, 0.00730143f, 0.02984449f, -0.10607234f, 
    0.12929235f, 0.02756155f, -0.03469471f, 0.16737370f, -0.03957334f, -0.11903973f, -0.11067826f, 0.00543499f, 
    -0.01155725f, -0.07430068f, -0.06712722f, 0.04285508f, -0.05306302f, -0.19473186f, -0.13534154f, -0.05279528f, 
    -0.04206175f, 0.05994576f, 0.20548201f, -0.04151789f, 0.02488007f, -0.03873073f, 0.05571544f, -0.02925957f, 
    -0.09462704f, 0.00364434f, 0.04975922f, -0.05045684f, 0.10952441f, 0.12347995f, 0.06732712f, -0.07275020f, 
    0.07229958f, 0.10357051f, -0.06249041f, -0.05204104f, -0.03720545f, -0.19835731f, 0.02672880f, 0.14418870f, 
    -0.10741185f, -0.02351116f, -0.04670483f, 0.16638224f, 0.16286299f, 0.03751342f, 0.01994286f, -0.00579537f, 
    0.05294875f, -0.01018272f, -0.04221210f, 0.05829539f, 0.03502988f, -0.03589951f, -0.00357300f, 0.00984995f, 
    -0.06884222f, 0.27016258f, 0.15926367f, -0.02689314f, 0.44786245f, 0.03963537f, -0.27903628f, -0.23777106f, 
    0.17101850f, 0.04175140f, 0.08155555f, -0.01624846f, 0.06295232f, 0.11086331f, 0.02760600f, 0.06559478f, 
    -0.15842493f, -0.15486421f, -0.22287183f, 0.05846502f, 0.08817424f, 0.06192583f, -0.02238310f, 0.01419773f, 
    0.03922297f, 0.08095863f, 0.06088435f, -0.03208882f, -0.27303424f, -0.01050169f, 0.05707538f, 0.04665627f, 
    0.08204231f, 0.02825680f, 0.03854251f, -0.06105674f, 0.01370609f, -0.10375898f, -0.10476121f, -0.13157570f, 
    0.01767977f, 0.07391986f, 0.01060345f, 0.11335720f, 0.05375396f, -0.09236180f, -0.07074679f, 0.03950156f, 
    0.07333849f, 0.05208524f, 0.01989029f, 0.05739492f, -0.13621417f, 0.01719947f, -0.08085258f, 0.20479968f, 
    -0.04255377f, 0.03821571f, -0.14313599f, 0.17622221f, 0.08646009f, -0.09814274f, 0.05408522f, 0.06205779f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11707690f, -0.03098767f, 0.01749361f, 0.02868322f, 0.03009426f, -0.04684361f, 0.03223969f, -0.01464778f, 
    -0.01076897f, 0.04790103f, 0.10768134f, -0.05846844f, 0.08266679f, -0.02802796f, 0.04171641f, -0.03381210f, 
    -0.00552468f, -0.02202205f, -0.03577887f, 0.09959906f, 0.00593487f, 0.00714081f, 0.04574696f, 0.03889123f, 
    -0.09726302f, 0.02330448f, -0.00805277f, 0.00837205f, 0.08128343f, 0.05636451f, 0.12215541f, -0.05099012f, 
    0.04201583f, 0.08099037f, -0.00959959f, 0.02018571f, -0.01634970f, -0.00678953f, -0.01231641f, -0.03264434f, 
    0.05416654f, -0.00293265f, -0.02437265f, 0.01664533f, -0.01907715f, 0.02705861f, -0.03632893f, 0.02033277f, 
    -0.00896245f, 0.01772287f, 0.04075922f, 0.05034515f, -0.02170732f, 0.02400881f, -0.03094435f, -0.03143700f, 
    0.03792531f, -0.00172240f, 0.02626147f, 0.01744538f, 0.02508785f, 0.10173950f, -0.02319591f, 0.12791418f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.23783703f, 0.07392184f, -0.00905933f, -0.04413767f, -0.24984275f, 0.01633210f, 0.04431713f, -0.01148090f, 
    -0.38957888f, 0.02887029f, -0.08517808f, 0.39251766f, -0.17386429f, -0.10204403f, 0.02449280f, 0.04036000f, 
    0.06987520f, -0.06285825f, 0.01702737f, 0.05784414f, -0.09509601f, -0.07153883f, 0.09960705f, -0.21891215f, 
    0.28387329f, -0.00310615f, -0.11322986f, 0.11907575f, 0.07984880f, 0.11875285f, -0.56772828f, 0.13394706f, 
    -0.30309644f, -0.15817741f, 0.09506522f, -0.10215131f, 0.17527355f, -0.07789037f, -0.03729481f, -0.06767135f, 
    -0.43332741f, 0.19683453f, 0.09998056f, -0.06873060f, 0.33199635f, -0.11300367f, -0.03309121f, 0.09243788f, 
    0.01186784f, -0.11129616f, 0.10842980f, -0.51102942f, 0.11412515f, 0.13702245f, -0.06905284f, 0.23563832f, 
    -0.06337880f, -0.06009090f, 0.08083335f, 0.01927257f, -0.21046565f, -0.09016433f, -0.04945218f, 0.24595582f, 
    -0.12514544f, -0.06483044f, 0.06178705f, -0.01306006f, 0.18858415f, 0.04699469f, -0.10942075f, -0.00573713f, 
    -0.23988593f, 0.04404396f, -0.34079894f, -0.68936676f, 0.22605042f, 0.01509795f, -0.06377596f, -0.01867031f, 
    -0.04034872f, -0.09270021f, 0.04113691f, 0.15116997f, -0.07185560f, -0.07459335f, 0.22940899f, 0.16738956f, 
    0.20892367f, 0.04594182f, -0.08402442f, 0.01155690f, 0.25385025f, 0.00038100f, 0.04109905f, 0.02712843f, 
    -0.35364723f, 0.19542292f, -0.07064652f, -0.05610203f, -0.03038754f, 0.12478787f, 0.08076993f, -0.06285106f, 
    -0.25325623f, -0.03709855f, -0.03019025f, 0.09157058f, -0.41596672f, -0.11346243f, 0.06142721f, 0.16281408f, 
    -0.00093133f, -0.07383668f, -0.02943647f, 0.08784153f, 0.03746288f, 0.19803871f, -0.19934683f, -0.10341638f, 
    -0.15392590f, -0.11635854f, 0.12530510f, -0.09358675f, 0.00627668f, 0.20566735f, -0.56964785f, 0.28465885f, 
    -0.00255724f, 0.10440356f, 0.06730148f, 0.03556485f, -0.01287895f, 0.06235509f, 0.00066114f, 0.01090816f, 
    0.13904716f, -0.04098252f, 0.19560350f, -0.24775898f, 0.12467221f, -0.05808261f, 0.10783803f, -0.10071968f, 
    -0.11532494f, 0.03545677f, -0.10316914f, 0.22344154f, 0.09506944f, -0.02692307f, 0.19377322f, -0.34646049f, 
    0.35789958f, 0.10813068f, 0.02594335f, 0.08554645f, 0.15044822f, -0.30288234f, 0.06065874f, -0.09311914f, 
    -0.41218519f, -0.35178551f, 0.05454471f, 0.28324422f, 0.13166532f, -0.41995367f, 0.05248201f, 0.04667693f, 
    0.06581374f, -0.39097664f, -0.00465189f, 0.04867321f, -0.03257492f, 0.08748552f, -0.08096094f, -0.38772494f, 
    0.00622478f, 0.11083678f, 0.10479837f, -0.09861949f, 0.08995037f, 0.24423479f, -0.03752245f, -0.45574769f, 
    0.13522503f, 0.03852781f, 0.03476191f, -0.00711226f, 0.13651577f, 0.04507449f, 0.16745283f, -0.44282538f, 
    -0.43672296f, 0.08858555f, -0.02006125f, 0.08054817f, 0.26608405f, -0.14491734f, 0.05149522f, -0.05966868f, 
    -0.16619931f, 0.10162366f, 0.25220481f, 0.20854183f, -0.09485187f, -0.09811430f, -0.00992139f, 0.00920425f, 
    -0.11162718f, 0.03637598f, 0.06470511f, -0.06162772f, 0.02447434f, -0.02509612f, 0.18189980f, -0.51277709f, 
    -0.19070932f, 0.04289726f, -0.07428295f, 0.08744752f, 0.22699487f, -0.04955054f, -0.13943875f, 0.09964205f, 
    0.23171800f, -0.18412368f, -0.09187794f, -0.25332844f, -0.31185150f, 0.10008775f, 0.11071242f, -0.07418649f, 
    0.06133084f, 0.03058305f, 0.06231586f, 0.11269691f, 0.20618680f, 0.07059149f, -0.03899562f, 0.22047265f, 
    -0.11304231f, 0.06057780f, -0.08574181f, 0.27663058f, -0.05071818f, -0.68562156f, -0.09984408f, 0.19082105f, 
    -0.32866889f, 0.08526716f, -0.05822077f, -0.03770216f, -0.39831308f, 0.27651802f, 0.00154865f, -0.21129878f, 
    -0.19942467f, -0.08446219f, 0.03878428f, 0.00874688f, 0.29909009f, -0.01394526f, -0.07147355f, 0.11022063f, 
    0.13464732f, -0.01484083f, -0.07785933f, -0.17993630f, -0.12824306f, -0.10891671f, 0.04581453f, -0.02415254f, 
    0.11513670f, 0.08652946f, 0.04915783f, -0.28569362f, -0.01610798f, -0.06945600f, 0.22459935f, -0.03075592f, 
    -0.15144710f, 0.05049075f, 0.05184369f, 0.05778636f, 0.13173553f, 0.26828352f, 0.06021534f, -0.12031705f, 
    0.27775314f, 0.22838895f, 0.06531820f, -0.27233878f, 0.16965359f, 0.01437618f, 0.07844584f, -0.09821594f, 
    0.03411293f, 0.21790232f, 0.12502998f, 0.01045633f, -0.16719434f, 0.08244087f, 0.08881317f, 0.29432189f, 
    -0.04705017f, 0.06658500f, -0.02131464f, -0.43828300f, 0.06370567f, -0.14977913f, -0.34226185f, -0.04820355f, 
    0.30390406f, -0.08438247f, 0.02029583f, -0.00585257f, -0.37983665f, -0.14013055f, 0.29001650f, -0.29909235f, 
    0.00742699f, -0.10297951f, 0.03132037f, 0.04729669f, -0.34095401f, 0.06650031f, -0.09260011f, 0.08604859f, 
    0.14507821f, 0.11717671f, -0.34867963f, -0.04933124f, 0.04949415f, 0.07714716f, -0.06563690f, -0.09736630f, 
    0.01369416f, 0.07278609f, 0.05936506f, -0.18637849f, -0.05201771f, -0.05058667f, 0.07982451f, 0.34242612f, 
    -0.73736382f, 0.05951764f, -0.06854331f, 0.08989163f, -0.37314954f, 0.07196285f, 0.03582070f, -0.00537552f, 
    0.24291272f, -0.20970325f, -0.08915709f, 0.04199113f, 0.12300257f, 0.19538549f, 0.06467447f, -0.09963072f, 
    -0.21168435f, 0.11009467f, 0.01745901f, -0.09780702f, -0.15387511f, -0.09715299f, -0.05104247f, 0.19279823f, 
    0.12014940f, 0.05352971f, -0.00592096f, -0.32443985f, 0.06115265f, 0.15365663f, 0.24682705f, -0.18831155f, 
    -0.45184115f, 0.00120871f, 0.02247855f, 0.01400277f, 0.38659647f, 0.10390429f, -0.19571084f, 0.12878454f, 
    0.26558384f, 0.06768417f, -0.07953886f, -0.06482946f, -0.38489637f, -0.10104610f, 0.11425356f, -0.06747675f, 
    0.27303916f, 0.00728869f, 0.15665345f, 0.22781721f, -0.04297072f, -0.03643946f, -0.11200575f, -0.04176957f, 
    -0.05446774f, -0.06215778f, -0.07959105f, 0.02271455f, 0.01601971f, 0.07475878f, -0.19637325f, -0.00443379f, 
    -0.01559349f, 0.00582137f, -0.07247097f, 0.10444403f, -0.54659349f, -0.29188964f, -0.26878557f, 0.08279818f, 
    0.14963186f, 0.31377068f, 0.09511462f, 0.37474525f, 0.14766134f, -0.00282745f, 0.07963379f, -0.04827711f, 
    0.37225115f, -0.18560140f, -0.02871583f, 0.09724908f, -0.01778531f, -0.01150746f, 0.02525929f, -0.08763998f, 
    0.00298462f, -0.05455080f, -0.13169631f, 0.09195293f, -0.01490705f, -0.27429935f, -0.27159542f, -0.44781259f, 
    0.12308246f, 0.04959267f, -0.01337601f, -0.11843460f, -0.49854663f, 0.04634133f, -0.42601043f, 0.08272462f, 
    -0.05798552f, -0.04920750f, 0.02645351f, 0.02299628f, 0.26011923f, -0.10009365f, -0.05283536f, 0.00594534f, 
    0.33331522f, -0.00628788f, -0.27444151f, 0.25021508f, -0.31874278f, 0.08769280f, -0.06082508f, -0.04051538f, 
    -0.07754683f, -0.09131099f, -0.12947141f, -0.37925494f, -0.05207774f, -0.09893639f, -0.57450891f, -0.00953686f, 
    -0.03335115f, -0.00149531f, -0.08245576f, 0.04166370f, 0.13538331f, -0.01945075f, -0.24282640f, -0.03695437f, 
    -0.00568029f, -0.19527806f, 0.04336658f, -0.38354099f, 0.25060791f, 0.20182458f, 0.02084235f, -0.07747869f, 
    0.11593413f, -0.25108555f, -0.05944151f, -0.03011197f, 0.03312162f, 0.03962378f, 0.08975730f, -0.06675107f, 
    -0.05765162f, 0.06452116f, 0.00024647f, 0.21673258f, 0.07580232f, 0.04031021f, 0.27634257f, 0.07258900f, 
    -0.10883153f, -0.07994165f, -0.00602118f, -0.04456342f, 0.21723041f, -0.30379865f, 0.17189915f, -0.36290985f, 
    0.24311656f, -0.01146740f, -0.10340537f, 0.09272521f, -0.31195429f, 0.00372521f, -0.10517678f, 0.05043696f, 
    -0.39856973f, -0.12183583f, -0.50735879f, -0.29778308f, 0.18345450f, -0.06069327f, -0.03426750f, -0.00602208f, 
    0.11746443f, -0.10083004f, 0.09892451f, 0.13386065f, -0.04647153f, -0.11336245f, 0.04025127f, 0.14031190f, 
    -0.05183042f, 0.08331138f, 0.05816039f, -0.11861759f, -0.16164905f, -0.50808680f, 0.36243650f, -0.05547151f, 
    -0.03117961f, -0.31217158f, 0.08153864f, -0.32253006f, -0.57871234f, 0.01355129f, -0.03261999f, 0.00317633f, 
    0.31801397f, -0.13674128f, 0.09907620f, 0.03127911f, 0.22946298f, 0.09555057f, -0.01583517f, -0.19193499f, 
    -0.02917323f, -0.12695354f, -0.02928126f, 0.01277999f, 0.11389600f, 0.21484084f, -0.38236818f, 0.00408418f, 
    0.14676569f, -0.05342070f, 0.02791258f, 0.11292843f, 0.29267889f, 0.15489200f, 0.21153280f, -0.14310221f, 
    0.00095818f, 0.07278313f, 0.01034873f, -0.01768333f, -0.01045659f, -0.14545131f, 0.07202224f, -0.03277525f, 
    0.09438349f, 0.08202343f, 0.21566308f, 0.29309294f, -0.14363667f, 0.09683780f, -0.01303285f, 0.10258310f, 
    0.04151930f, 0.11846207f, 0.03648583f, 0.23061162f, -0.00721527f, 0.03277413f, -0.45121661f, 0.28509408f, 
    -0.13896038f, 0.07393969f, 0.05271444f, 0.09442346f, -0.44083601f, 0.18499030f, 0.07329703f, -0.02181816f, 
    -0.38956210f, -0.02471570f, 0.07650428f, -0.05405495f, 0.15399830f, -0.64865994f, 0.02036051f, -0.02715256f, 
    0.32191306f, 0.08186159f, -0.02597396f, 0.12258698f, -0.10889656f, -0.13038443f, -0.11632923f, 0.20937960f, 
    0.07382847f, 0.06465586f, -0.03314629f, -0.26739341f, -0.09789652f, -0.15125401f, 0.34950659f, 0.09306134f, 
    -0.09634207f, -0.07071577f, -0.00716229f, 0.10427319f, -0.23022893f, -0.29801485f, 0.41110733f, -0.32096004f, 
    -0.46777001f, 0.06128178f, 0.07953569f, -0.03248131f, 0.05636849f, -0.01728366f, -0.11707833f, -0.07583456f, 
    -0.20607953f, 0.12220672f, 0.29608679f, -0.46566844f, -0.05890775f, -0.06641621f, 0.06621652f, 0.00336253f, 
    0.03831735f, 0.01164701f, 0.09816791f, 0.11671839f, -0.04953996f, 0.04567738f, -0.53285551f, 0.08819640f, 
    -0.27972069f, -0.05454210f, -0.11251716f, -0.00312201f, 0.13781005f, 0.25475898f, -0.11745092f, -0.11160613f, 
    -0.07919595f, 0.11908489f, -0.10996296f, -0.46506453f, -0.00616367f, -0.07979030f, -0.04815875f, 0.05188273f, 
    0.08656787f, -0.57993066f, 0.08640485f, -0.01949047f, 0.24440053f, -0.01150777f, -0.10995582f, -0.25573638f, 
    -0.07893450f, -0.06102123f, 0.11232416f, -0.10366898f, -0.09715013f, -0.03231552f, 0.14222847f, 0.15500142f, 
    0.16261050f, -0.02244602f, -0.10554834f, 0.09148356f, 0.30701786f, 0.22020185f, -0.34676227f, 0.41519034f, 
    0.01828975f, 0.07477798f, -0.08743064f, 0.07195941f, -0.29107276f, 0.09899084f, 0.04405519f, 0.02005067f, 
    0.20287122f, 0.02832595f, 0.23031731f, 0.09617334f, -0.09456935f, 0.07627595f, -0.06774325f, -0.11611478f, 
    -0.07394488f, -0.04681524f, -0.00851580f, -0.04121106f, 0.07420368f, 0.02170712f, 0.16710679f, -0.37377438f, 
    -0.19653621f, 0.01770165f, 0.09613906f, 0.08890895f, 0.18239507f, -0.41985345f, 0.40311995f, 0.09428696f, 
    0.20486721f, 0.37852266f, -0.13180885f, 0.10646159f, -0.16994630f, -0.00317157f, -0.12684211f, -0.04755064f, 
    -0.25013870f, 0.04356380f, 0.02221784f, 0.07145195f, -0.24879146f, 0.05519618f, 0.03883146f, -0.51368439f, 
    0.01816845f, 0.07147517f, 0.04166546f, 0.10257586f, 0.11139166f, -0.32051608f, 0.15780693f, 0.07804640f, 
    -0.03541984f, 0.08030127f, 0.02940738f, 0.01882666f, 0.28340563f, -0.35713953f, 0.10005261f, 0.04681394f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03830453f, 0.05651741f, 0.10649844f, 0.02465810f, 0.06019832f, 0.08778904f, -0.08067830f, -0.14451396f, 
    0.02317582f, 0.03873209f, 0.06460448f, -0.04307364f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
