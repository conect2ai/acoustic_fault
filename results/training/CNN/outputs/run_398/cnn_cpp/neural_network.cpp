#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81615782f, 0.25708041f, 0.00988427f, 0.36714286f, -0.64178610f, 0.79372340f, 0.36804238f, -0.02759619f, 
    0.50149322f, -0.36223826f, -0.56781989f, -1.03088129f, -0.74527121f, 0.09467366f, 0.03008278f, 0.56357956f, 
    0.02682243f, 0.08079382f, -0.34436211f, -1.06333768f, -0.01448766f, 0.04542567f, 1.00361431f, -0.20149046f, 
    -0.17372920f, -0.40023798f, -0.50179315f, 0.99248058f, 0.50896496f, 0.61427140f, -0.45163411f, -0.12556130f, 
    -0.12829517f, 0.12510113f, 0.05828399f, 0.05643366f, 0.20972776f, 0.72623557f, 0.45507598f, 0.77573347f, 
    0.10298615f, -1.04245830f, -0.08342337f, 0.26127443f, 0.03905829f, -0.86615264f, -0.74658203f, -0.14872804f, 
    0.47996062f, 0.77005154f, 0.57983828f, -0.06187940f, -0.41523197f, -0.22950952f, -1.03100252f, 0.10268463f, 
    -0.50551683f, 0.31919467f, 0.93665117f, -0.66904062f, -0.34698972f, 0.12341745f, 0.23018511f, 1.38304114f, 
    -0.06020224f, -0.85107249f, 0.33336067f, 0.28440720f, -0.17379442f, -0.22232138f, -0.45900032f, -0.00358472f, 
    0.26285911f, 1.15840244f, 0.16946223f, 0.13328442f, 0.15079685f, -0.45721251f, -0.42272425f, 0.22151314f, 
    0.10181232f, -0.64966047f, -1.15290582f, 0.17292126f, -0.51098436f, 0.31357655f, 0.72728425f, 0.09808768f, 
    -0.16076808f, -0.13047679f, -0.13479865f, -0.86820161f, -0.42877150f, -0.68471026f, -0.70298624f, 0.04780953f, 
    -0.24149321f, 0.76865864f, -0.21014005f, -0.79737473f, -0.76414347f, -0.14221644f, -0.13495344f, -0.51503360f, 
    0.54167974f, -0.19327207f, 0.03742765f, 0.18069738f, 0.57318795f, 0.23782240f, 0.38285595f, -0.37331283f, 
    -0.59038407f, 0.45597020f, 0.53527147f, -0.33176562f, -0.51730704f, -0.96113491f, -0.00238299f, 0.26391810f, 
    0.79521024f, -0.37942624f, -0.60070610f, 0.15560859f, 0.30024862f, 0.01051880f, 0.94452530f, 1.16757488f, 
    -0.49925879f, -0.58386612f, -0.30282938f, 0.36533675f, 0.21391882f, -0.07804272f, -0.23351297f, -0.03962383f, 
    -0.36864597f, -0.49646679f, -0.58692563f, -0.69266546f, -0.50453520f, -0.45452210f, -0.19406274f, 0.50738716f, 
    0.87328422f, -0.50440204f, 1.08949268f, 0.31124172f, -0.60775822f, -0.19413798f, -0.27660695f, -0.45574611f, 
    -0.54631674f, 0.86213678f, -1.21675372f, 1.06055844f, 0.78045338f, -0.63241953f, 0.38572124f, 0.20909303f, 
    0.05148941f, -0.63047260f, 1.02150071f, -0.72195065f, -0.27450660f, -0.47806704f, -0.21879801f, -0.48302191f, 
    -0.17642321f, -0.36085942f, -0.18565430f, -0.41867343f, -1.21838021f, 0.03616715f, -0.03704461f, 0.37590858f, 
    0.05294280f, 0.30468750f, -0.13611969f, -0.24650304f, 0.01945115f, -0.53904074f, -0.16923796f, -0.57434714f, 
    -0.96905571f, -0.54520547f, 0.21201479f, -0.42061216f, -0.22200249f, 0.41610363f, 0.88456470f, 0.16542682f, 
    0.62471867f, 0.73224854f, 0.61879623f, 0.38267884f, -0.55683488f, -0.42082581f, -0.32571834f, 0.05841109f, 
    0.18201739f, -0.81605285f, -0.39687842f, 0.72241187f, 0.68224990f, -0.36946598f, -0.14980747f, 0.45133680f, 
    0.42698243f, -0.59957463f, -0.59878349f, 0.49833772f, -0.94081247f, 0.38157895f, 0.39309919f, 0.34253269f, 
    0.28540576f, 0.90858299f, 0.79035765f, -0.50832832f, 0.55842382f, 0.17549191f, -0.22135143f, 0.36587092f, 
    -0.20685156f, -1.08686399f, 0.88703150f, 0.78725541f, -0.48328847f, 0.49622473f, 0.23116818f, -0.40982759f, 
    -0.30200341f, -0.12476545f, 0.12586725f, 0.89712286f, 0.69787455f, -0.36609361f, 0.69448155f, 0.45767915f, 
    -0.13963905f, -0.03392457f, -0.26586375f, 0.63879675f, -0.48691282f, 0.72659206f, -0.60105026f, -0.96842229f, 
    -0.62469149f, 0.64848381f, 0.58455253f, -0.03859260f, 0.22985086f, 0.80816805f, -0.84767359f, 0.88218105f, 
    -0.54698277f, 0.13572173f, -0.63939559f, -0.31244877f, 0.21922910f, -0.21994603f, -0.05365215f, 0.23858535f, 
    0.62927550f, 0.83265752f, 0.70902717f, 0.30119362f, 0.50901914f, 0.45057479f, -0.62786269f, -0.95601827f, 
    -0.71597880f, 0.51985544f, 0.76948494f, 0.09177898f, -0.47394809f, -0.36386332f, -0.05139765f, 1.13994277f, 
    0.66235054f, -1.05688715f, 0.51568699f, -0.15994982f, -0.65209156f, -0.04275773f, 0.15907276f, 0.70240742f, 
    0.29589054f, -1.28690326f, 0.10968530f, -0.49785271f, 0.82141745f, 0.35008481f, 0.26764610f, 0.00243546f, 
    0.19936545f, -0.44778770f, 0.74028641f, 0.51784068f, 0.80652815f, -0.18314803f, -0.07882428f, -0.09711414f, 
    -0.48896593f, 0.36581784f, 0.49524677f, 0.74561143f, 0.73008764f, 0.06394599f, -0.68032271f, 0.57591093f, 
    0.45030931f, 0.58435518f, -0.58755904f, 0.32971299f, 0.37842155f, -0.39044076f, -0.86927605f, -0.10587499f, 
    -0.62594700f, -0.14931065f, -0.11487299f, -0.48335588f, -1.17966473f, 0.72422886f, -0.43102345f, 0.45571098f, 
    -0.53705227f, -0.03929873f, 0.20258765f, -0.17387280f, -0.25975415f, 0.56493509f, -0.66004866f, 0.35195071f, 
    0.50881666f, -0.95474648f, -0.54366219f, -0.45048460f, -0.00392549f, 0.41755345f, 0.25504956f, 0.76717758f, 
    0.67800009f, 0.33470973f, -0.39227095f, 0.56334162f, 0.01335841f, 0.18306454f, 0.12863837f, 0.13426593f, 
    0.53715861f, 0.91326642f, 0.94837731f, 0.07611673f, -0.12376139f, -0.38256535f, 0.32446212f, -0.16543777f, 
    0.02746715f, 0.65443724f, -0.32015812f, -0.15666746f, -0.77966535f, -0.42765129f, 0.52973384f, -0.50174004f, 
    0.11316804f, 0.23820044f, 0.44155371f, 0.02594437f, -0.76321650f, 0.17463727f, -0.49840149f, -0.27775672f, 
    0.32095155f, 0.72217625f, 0.30058217f, -0.84852862f, 1.06975365f, -0.70568728f, 0.72179300f, 0.09568042f, 
    -0.02964943f, -0.06689737f, 0.38493958f, 1.11263800f, 0.90495163f, 0.29368973f, -0.35835087f, -0.57225722f, 
    -0.38166106f, -0.49456832f, 0.38008487f, -0.23041670f, 0.78552663f, 0.48792002f, 0.91047901f, -0.86613524f, 
    0.01289865f, -0.48317075f, 0.41081908f, -0.05243818f, -0.18825287f, 0.88425183f, -0.63079196f, 0.56744075f, 
    -0.39371082f, 0.36616069f, 0.74021274f, -0.48695484f, -0.34145254f, -0.49940100f, -0.84183258f, 0.01499329f, 
    -0.92385447f, -0.01807035f, -0.35096309f, -0.59442872f, -0.02060703f, 0.12028062f, 0.24349368f, -0.27348241f, 
    1.11535954f, -0.79302788f, -0.23765874f, -0.40551409f, -0.83766192f, 0.31179807f, -0.21041971f, -0.00196411f, 
    0.57451415f, 0.72567362f, -0.95660609f, 0.74031067f, 0.23403765f, 0.52146184f, -0.06101588f, -0.37001696f, 
    -0.10277198f, -0.38427120f, 0.85987216f, 0.77979887f, 0.58413887f, 0.60250974f, -0.50514054f, -0.22302231f, 
    0.24786042f, -0.20176929f, -0.57711339f, -0.17166372f, -0.96068060f, -0.80999953f, 0.65852690f, 0.81499809f, 
    -0.05727790f, -0.31477678f, 0.26133257f, -0.77530831f, -0.77542174f, -0.47935015f, 0.39813173f, 0.05717551f, 
    -0.30191129f, -0.28290978f, 0.63285005f, 0.01490108f, -0.61255002f, 0.15846983f, -0.82367587f, 0.78064287f, 
    -0.48572335f, -0.06900438f, -0.37485409f, 0.12608501f, 0.12833808f, -0.36400342f, -0.69784391f, -0.45398998f, 
    -0.45491460f, 0.00470049f, 0.59738970f, 0.46888849f, -0.57707620f, 0.53344768f, 0.34410167f, 0.35579571f, 
    0.49436635f, -0.38965949f, -0.66729474f, -0.29175913f, 0.40219036f, 0.77595425f, 0.06961849f, -0.65812624f, 
    0.14785135f, -0.82089043f, -0.09636515f, 1.04246473f, 0.18447603f, 0.31207725f, 0.29582065f, -0.42265365f, 
    -0.43931594f, 0.91372138f, 0.53833687f, -0.71736622f, 0.67461491f, 0.41038576f, 0.28396201f, 0.32669461f, 
    0.25598010f, 1.09912646f, -1.03021228f, -0.26472175f, 0.12027016f, -0.48522204f, 0.51824605f, -0.15434226f, 
    0.29362193f, -0.25193831f, -0.86669964f, 1.00703216f, -0.29023698f, -0.06153759f, 0.75668758f, 0.32357001f, 
    -0.42746955f, 0.34005222f, 0.40976557f, -0.25840464f, -0.70945060f, 0.16702153f, -0.65634632f, -0.82993442f, 
    -0.65740502f, -0.27456447f, 0.00180171f, 0.08018640f, 0.39851555f, 0.39903748f, 0.56341743f, 0.05263216f, 
    -0.02595994f, 0.81791580f, -0.20505108f, -0.66142797f, 0.01229486f, -0.14916269f, 0.85816264f, 0.72145104f, 
    -1.18538129f, 0.32522899f, -0.40510809f, 0.00522543f, 0.22520444f, -0.02235673f, -0.99622154f, -0.78423804f, 
    0.41304845f, 0.67432153f, -0.23095566f, 0.31106582f, 0.13821563f, 0.22144721f, -0.12425877f, -0.44820970f, 
    -1.06119740f, -0.14709035f, 0.43834561f, 0.72343570f, 0.81655663f, -0.30594644f, 0.12538455f, -0.64774013f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01170421f, 0.18641424f, 0.16938181f, -0.06821921f, 0.13698450f, 0.04404338f, -0.00772468f, 0.14948253f, 
    0.10853548f, 0.18530244f, 0.12564464f, 0.08104825f, 0.14830804f, 0.21970510f, -0.06433059f, 0.11804646f, 
    0.16772841f, 0.01661221f, 0.21761663f, 0.18888685f, -0.06776041f, 0.13991091f, 0.05819521f, 0.14962085f, 
    0.14989455f, 0.23400798f, 0.35872936f, 0.08680825f, -0.13539296f, -0.10463808f, 0.15824673f, -0.04660176f, 
    0.18444170f, 0.14571954f, -0.03715917f, 0.02204152f, 0.16714449f, 0.18085761f, 0.37546498f, 0.02239155f, 
    0.22062704f, -0.02094509f, -0.00359920f, -0.04640571f, 0.05854559f, 0.12884127f, 0.03608450f, -0.06213144f, 
    0.11197786f, 0.19647656f, 0.03571492f, 0.04370936f, -0.18990396f, 0.06620668f, 0.03512761f, 0.01104381f, 
    -0.01760573f, -0.04236644f, 0.22536336f, 0.30196190f, 0.29028216f, 0.25496572f, 0.20432205f, 0.04849378f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11545601f, -0.26778033f, 0.03629451f, -0.15717572f, 0.05633822f, 0.00862022f, 0.05725738f, -0.06013852f, 
    -0.00538411f, 0.04800263f, -0.07449300f, 0.04691997f, 0.04632408f, 0.03964268f, 0.04110321f, 0.07668981f, 
    -0.02232311f, 0.04258618f, -0.09949660f, 0.07084597f, -0.45086485f, -0.10424334f, -0.13083546f, 0.05561829f, 
    -0.09574026f, -0.02763379f, -0.06788132f, 0.01227680f, 0.02017759f, -0.00151819f, 0.02101762f, -0.09834572f, 
    -0.11674111f, -0.00027951f, 0.11933841f, -0.04891972f, -0.05638312f, -0.00156668f, 0.05369762f, -0.09401368f, 
    -0.08923348f, 0.09093445f, 0.13055874f, -0.00421302f, -0.32616416f, -0.00115655f, 0.02584071f, 0.03335986f, 
    0.05427836f, 0.03387992f, 0.00304622f, 0.01712847f, -0.01738285f, 0.02601665f, 0.02172172f, -0.01942878f, 
    -0.00922273f, 0.03145131f, -0.07608179f, -0.03747763f, 0.29478061f, 0.18680026f, -0.14322136f, -0.23607345f, 
    0.02273109f, -0.18935148f, -0.22476427f, -0.09508888f, 0.10366107f, 0.02760701f, -0.04223386f, -0.00022549f, 
    -0.01616246f, 0.00348397f, 0.03709818f, 0.03832712f, 0.00985518f, 0.04430804f, 0.10543295f, 0.11920440f, 
    -0.09115797f, 0.04646290f, 0.07753100f, -0.05533333f, 0.00622502f, -0.06176494f, -0.16789725f, 0.06345951f, 
    -0.06144709f, 0.03403036f, -0.00520082f, 0.02190802f, 0.00198161f, 0.04030109f, -0.06169819f, -0.04903673f, 
    -0.01183896f, 0.04568187f, -0.09529430f, 0.00648892f, 0.02841119f, 0.16633859f, 0.19817153f, -0.10647692f, 
    -0.24285945f, 0.08145954f, 0.09358433f, 0.02485477f, 0.02506024f, -0.01058014f, -0.01704997f, -0.07853257f, 
    -0.02222201f, 0.05606141f, -0.00566921f, 0.08256371f, 0.07045440f, -0.02693907f, 0.04088274f, 0.02466590f, 
    0.48748851f, 0.10658769f, 0.10911904f, -0.14916532f, -0.08797327f, -0.00068433f, 0.00686005f, 0.00002265f, 
    -0.06811935f, 0.01516527f, 0.07897612f, 0.00218517f, -0.10863655f, 0.03505947f, 0.03296539f, -0.05414047f, 
    -0.01159657f, 0.03104094f, 0.02334465f, 0.04021761f, 0.07231694f, -0.13295382f, 0.12033813f, 0.12353200f, 
    0.33868903f, -0.08751444f, -0.02469147f, -0.02627181f, 0.10267029f, -0.04095277f, -0.02158492f, 0.00404224f, 
    0.08858256f, -0.07298801f, -0.09345751f, 0.04396369f, 0.06688544f, -0.00055577f, -0.00900741f, -0.00589685f, 
    -0.00411330f, 0.09459975f, 0.09737819f, -0.18210112f, 0.16328122f, -0.08603106f, -0.00340211f, -0.02272379f, 
    0.00754458f, -0.01481535f, -0.04627620f, -0.01643703f, -0.07489727f, -0.01156044f, -0.05141638f, -0.06090171f, 
    0.04024145f, 0.08034474f, -0.07820725f, 0.05014991f, -0.26368842f, 0.12178150f, -0.13006702f, 0.10769391f, 
    -0.28602931f, 0.01515215f, 0.05169589f, -0.05058385f, 0.09466200f, -0.00901480f, 0.08754322f, -0.04694740f, 
    -0.10547633f, -0.00508045f, -0.00672104f, -0.01907614f, -0.00703956f, -0.08349133f, 0.06160184f, 0.03218831f, 
    -0.13341382f, -0.48593619f, 0.00779952f, 0.04945533f, -0.23040657f, -0.07876374f, -0.02945216f, 0.00899856f, 
    -0.00600481f, 0.03045588f, -0.02109145f, -0.05650282f, 0.07724580f, -0.07294594f, 0.04685900f, 0.05366936f, 
    -0.00432447f, -0.03719397f, -0.05044268f, -0.04161030f, -0.16710719f, -0.07885506f, -0.14648356f, 0.05727825f, 
    -0.22335953f, -0.00179407f, 0.01174799f, -0.15561454f, 0.06504022f, -0.00180159f, 0.05957427f, 0.00395605f, 
    0.00394414f, -0.01697647f, 0.02377028f, 0.01706013f, -0.10297574f, 0.07242154f, -0.01394003f, -0.01725640f, 
    0.13846405f, 0.02988151f, 0.04009932f, -0.03617669f, 0.00709591f, -0.15223403f, -0.03562758f, -0.03615160f, 
    -0.00452578f, 0.02586497f, -0.07589795f, -0.02535326f, 0.06346582f, -0.04433687f, 0.06156047f, -0.04539042f, 
    -0.00870832f, -0.02328555f, 0.00421638f, -0.00421440f, -0.15184106f, -0.18702210f, 0.07736219f, -0.02694217f, 
    -0.06157975f, 0.01124686f, -0.08162039f, -0.03192244f, -0.08158922f, 0.03239139f, -0.03772925f, 0.04974032f, 
    0.05007396f, 0.01852905f, 0.05538406f, -0.01756884f, -0.00469096f, -0.04152112f, -0.02742569f, -0.06479619f, 
    0.23546550f, 0.08221469f, 0.14264594f, -0.20522076f, 0.28208309f, -0.19702072f, -0.02873339f, -0.01552528f, 
    0.04099924f, 0.03168406f, -0.01968311f, -0.03574133f, 0.06179099f, -0.08649375f, 0.08977083f, -0.04454171f, 
    0.07261650f, 0.00945697f, 0.03877537f, 0.01288403f, -0.09271482f, -0.29837069f, 0.10912329f, 0.07680698f, 
    -0.02290425f, 0.03141579f, -0.00979183f, 0.04390219f, 0.06906910f, -0.02905912f, -0.02594179f, -0.04199781f, 
    0.00814277f, 0.06927988f, -0.06122182f, -0.08202460f, -0.03767271f, -0.04467243f, -0.00219240f, -0.06112851f, 
    0.23258728f, -0.13405520f, 0.01678536f, 0.02879823f, -0.17922071f, -0.05195908f, -0.12432320f, 0.02413639f, 
    -0.00186540f, 0.01005969f, -0.06153966f, 0.02999402f, -0.00661709f, 0.03278478f, 0.03678641f, 0.02046018f, 
    -0.05208623f, 0.13218494f, 0.01587805f, 0.03990730f, 0.20971619f, -0.16191682f, 0.01115972f, 0.04792473f, 
    -0.40596098f, -0.01751512f, 0.02860438f, 0.03681031f, -0.03142409f, 0.03836344f, -0.12993756f, 0.09808675f, 
    -0.08971671f, 0.07829648f, 0.01944033f, -0.02502165f, -0.11657281f, 0.11439038f, -0.00571671f, 0.03462424f, 
    0.10839660f, -0.14710553f, 0.13227075f, 0.18453190f, -0.03114477f, 0.04477546f, 0.00794953f, -0.05151659f, 
    0.00517631f, -0.05705240f, -0.02773952f, 0.00630555f, -0.00620893f, -0.01312258f, 0.04838672f, 0.03333992f, 
    -0.04896477f, -0.00792465f, 0.06429454f, -0.02302436f, -0.27123100f, -0.01151879f, -0.07882706f, 0.02771242f, 
    -0.30814484f, 0.06798071f, -0.05468878f, -0.01717954f, 0.06847897f, -0.03542550f, -0.00316570f, 0.06193540f, 
    -0.06935781f, -0.01282937f, -0.02674266f, -0.03170372f, -0.02338488f, -0.03370392f, -0.06529024f, 0.01456396f, 
    -0.12481139f, -0.58355314f, 0.11554322f, 0.21199256f, 0.01446657f, 0.02616083f, -0.01916942f, 0.02446806f, 
    0.04467620f, -0.00096711f, -0.03526365f, -0.06490204f, -0.00047787f, -0.02722513f, 0.06719689f, 0.07627714f, 
    0.04911719f, 0.08280504f, 0.00821080f, -0.04794376f, 0.08074124f, -0.00835030f, 0.11876809f, -0.12756203f, 
    0.13328183f, -0.09003306f, -0.02785147f, 0.13876951f, -0.00519851f, -0.06193230f, -0.03913546f, 0.04965890f, 
    -0.07662661f, -0.00733028f, 0.07684107f, -0.02765588f, 0.07056260f, -0.01389106f, -0.00318825f, -0.00673109f, 
    -0.16091035f, -0.01616898f, 0.01561206f, 0.10892414f, -0.06282756f, -0.11361049f, -0.05617568f, -0.14086418f, 
    -0.11049016f, 0.06572584f, 0.01985392f, 0.07720727f, 0.11633389f, 0.05073517f, 0.01345756f, -0.06257337f, 
    0.06591450f, -0.05547505f, 0.00427178f, -0.14830695f, -0.15043032f, -0.03658430f, 0.00693006f, -0.00388640f, 
    0.06478450f, 0.00764980f, -0.01074235f, -0.09088701f, 0.06125636f, 0.05859350f, 0.05729268f, 0.05830757f, 
    -0.08636331f, -0.02220651f, -0.00665829f, -0.05882354f, -0.00572021f, 0.00590517f, -0.01008998f, -0.13113599f, 
    0.04361008f, 0.11132218f, -0.05080642f, -0.01877832f, 0.24575384f, -0.06371136f, -0.07821955f, -0.05435669f, 
    -0.01977256f, -0.01329545f, 0.00860391f, -0.01288758f, 0.06382302f, -0.00175880f, 0.03489633f, 0.00792557f, 
    -0.00811498f, -0.04520319f, -0.00476784f, -0.04369937f, -0.02619796f, 0.03986588f, 0.12043954f, 0.12927464f, 
    0.18661903f, -0.04899653f, -0.02937291f, -0.02597416f, 0.04036678f, 0.04466226f, 0.03492748f, 0.00120539f, 
    -0.03626980f, -0.00857593f, -0.04425571f, 0.11414763f, -0.00354126f, -0.03992236f, 0.10392076f, 0.02109461f, 
    -0.05015147f, -0.00942773f, 0.02819034f, -0.01158096f, 0.21565753f, -0.09470090f, -0.07546346f, -0.03433639f, 
    -0.03209167f, -0.01557007f, 0.02486512f, -0.01695043f, 0.04905703f, -0.08498385f, -0.02718534f, 0.07184187f, 
    0.03310261f, -0.07954333f, -0.01377509f, 0.01155472f, 0.19151495f, -0.20760100f, 0.06560536f, 0.08724605f, 
    -0.21734579f, -0.08576382f, -0.00609585f, 0.02459783f, -0.11315847f, -0.04555899f, -0.07753225f, 0.02691467f, 
    0.03835623f, -0.00482138f, -0.05379853f, -0.03042891f, -0.04906162f, 0.02288707f, 0.05639751f, 0.03392013f, 
    0.21020062f, -0.05362637f, 0.08665970f, 0.01491748f, 0.08208866f, -0.05089449f, -0.02632387f, 0.05902482f, 
    0.04551771f, -0.06791510f, 0.00001659f, 0.09977963f, -0.03822729f, 0.08194483f, 0.01320716f, 0.10790259f, 
    0.00973994f, -0.00874907f, -0.15877923f, -0.01253097f, -0.02224879f, 0.15499090f, 0.02562677f, -0.08719072f, 
    -0.03934697f, 0.02981256f, 0.01913894f, 0.03436318f, -0.03006883f, -0.03330141f, 0.00977515f, 0.01063291f, 
    0.01443275f, 0.11461670f, 0.09001226f, 0.06542303f, -0.04007550f, 0.04625089f, 0.02857509f, -0.01170605f, 
    0.06106081f, 0.11409472f, 0.02095475f, -0.07413918f, -0.32704937f, 0.00415113f, 0.03558947f, 0.02777451f, 
    -0.02497035f, -0.08101775f, 0.02084099f, -0.02724974f, 0.01514678f, 0.04163025f, -0.01688530f, -0.01971021f, 
    0.02768808f, 0.07134719f, -0.04034778f, -0.00750616f, -0.00826974f, -0.04599124f, 0.08882602f, -0.23491025f, 
    0.22467886f, -0.14196953f, -0.01596221f, -0.01456205f, 0.06007276f, -0.02774027f, -0.01866839f, 0.02836745f, 
    0.05858228f, 0.05838691f, -0.07733411f, 0.09447075f, -0.04628013f, 0.04446905f, -0.00854364f, -0.00125869f, 
    -0.18199801f, 0.07487416f, -0.06972518f, 0.01946872f, -0.18783396f, -0.02106344f, -0.07735499f, 0.02391496f, 
    -0.08596317f, -0.03275901f, 0.00024479f, -0.01730070f, -0.12696736f, -0.03782732f, 0.05599127f, -0.08188003f, 
    -0.01952712f, -0.05487458f, -0.03120814f, 0.05194474f, 0.10741423f, -0.04674770f, 0.06921939f, 0.04108866f, 
    0.03013597f, -0.11303855f, -0.10152036f, 0.05654333f, -0.08044209f, -0.02672030f, -0.07953923f, -0.00493151f, 
    -0.08861917f, 0.06043528f, 0.00314392f, -0.02051913f, 0.01555833f, 0.05806324f, -0.08784638f, -0.07055655f, 
    -0.00938981f, 0.12793849f, 0.04968164f, -0.07448155f, 0.12490609f, -0.09068462f, -0.02205112f, 0.01905812f, 
    -0.00373783f, 0.04252609f, -0.00514911f, -0.03213228f, 0.02802876f, 0.02105678f, -0.05091640f, -0.00900096f, 
    -0.03026970f, -0.13070172f, -0.01229542f, 0.06616352f, 0.04677285f, -0.07493185f, 0.04577813f, 0.06050933f, 
    0.10622178f, 0.03756121f, 0.03902390f, -0.06363070f, -0.03013973f, 0.01690501f, 0.07936154f, -0.01878203f, 
    0.02540578f, -0.08546526f, -0.00009132f, -0.03973547f, 0.02281043f, -0.04093563f, 0.08435699f, -0.10362864f, 
    0.19899926f, -0.16401529f, 0.12774090f, 0.01626792f, -0.08117624f, -0.02967027f, -0.09162296f, -0.01398663f, 
    0.01428794f, 0.01241495f, 0.07755643f, 0.06531792f, 0.03985173f, 0.04006156f, 0.02122769f, -0.03875967f, 
    -0.05076246f, 0.00621371f, -0.07042373f, -0.13434534f, 0.07893002f, -0.16653392f, 0.14736307f, 0.04924764f, 
    -0.04459810f, 0.07363143f, -0.00907870f, 0.00366775f, -0.05425959f, 0.03193100f, -0.18269171f, -0.03055783f, 
    -0.04332441f, 0.07995094f, 0.03886031f, 0.04930383f, 0.00119617f, 0.05538271f, -0.03564920f, -0.13354261f, 
    -0.10220953f, 0.05467285f, 0.02851506f, -0.03626124f, 0.09590843f, -0.09332934f, -0.09394000f, -0.01376665f, 
    -0.02274294f, 0.02303965f, -0.00129340f, -0.06995723f, -0.07741541f, -0.00708630f, -0.02613498f, -0.01833251f, 
    0.00190704f, -0.05543761f, -0.03921659f, 0.07315733f, -0.15156056f, 0.02083013f, 0.17416197f, 0.12037396f, 
    -0.02703617f, -0.00640477f, -0.17369096f, 0.06756005f, -0.02984889f, 0.00938127f, 0.06382221f, -0.00598600f, 
    0.04073467f, 0.04822423f, -0.06412859f, -0.01810415f, -0.03508942f, -0.04198556f, -0.10459286f, -0.03182890f, 
    0.03674908f, 0.08285573f, 0.08623621f, -0.02020113f, 0.03994707f, -0.12101896f, -0.03357624f, 0.02619009f, 
    0.03936528f, -0.00619971f, 0.03466165f, -0.01762259f, 0.06945989f, -0.00320517f, -0.01600214f, 0.07588258f, 
    0.00619639f, 0.06269323f, -0.10636985f, -0.11729027f, 0.02042219f, -0.07873153f, 0.06134541f, -0.11267836f, 
    0.05871654f, -0.01786461f, 0.00692085f, -0.04469517f, 0.04540570f, 0.02284796f, -0.03161905f, -0.05769247f, 
    -0.00288631f, -0.00695411f, 0.00532532f, -0.13403654f, 0.04398372f, 0.00948932f, 0.04553296f, -0.05263774f, 
    0.39581963f, -0.02196833f, -0.03116171f, 0.17988673f, -0.30134627f, -0.11715174f, -0.01177603f, 0.11021622f, 
    -0.03115901f, -0.01106313f, -0.00173570f, 0.00848943f, -0.02289997f, -0.02884950f, 0.07833923f, -0.16420928f, 
    0.00464501f, 0.00900961f, -0.02729640f, 0.02775086f, 0.26930991f, 0.04612851f, 0.11833886f, -0.18815048f, 
    0.15904011f, -0.03838708f, -0.11504404f, -0.09162895f, 0.04162738f, 0.07473051f, -0.06505627f, -0.02125928f, 
    0.02001715f, -0.00753948f, -0.01382211f, -0.03723158f, 0.02572476f, 0.03184938f, 0.09506183f, 0.02012036f, 
    0.18673475f, 0.12623757f, -0.10416661f, -0.02569125f, 0.00132286f, -0.21821494f, -0.15317792f, -0.11420659f, 
    0.01567233f, 0.05352571f, 0.01962804f, 0.02047328f, -0.09086631f, -0.01587049f, 0.04214247f, -0.03236815f, 
    0.00048348f, 0.03953931f, 0.02979355f, 0.05984788f, 0.15626425f, 0.02571548f, -0.15334365f, 0.07186512f, 
    -0.04566990f, -0.09664090f, -0.02443987f, 0.00085865f, 0.02645239f, -0.06161847f, 0.04178892f, 0.02808502f, 
    0.12055609f, -0.05846287f, 0.00119757f, 0.02825521f, -0.00256904f, -0.04495710f, 0.03562343f, 0.04437685f, 
    0.20972578f, -0.40625930f, -0.20372804f, 0.00163303f, -0.13973087f, 0.05418163f, -0.08546125f, -0.07646459f, 
    -0.09293266f, 0.08442107f, 0.13996579f, -0.01946794f, -0.10032834f, -0.02312069f, -0.00805311f, 0.04324529f, 
    0.04206007f, 0.08263588f, -0.00754459f, -0.06450789f, 0.05223327f, -0.03635085f, 0.19066910f, -0.02688203f, 
    0.12557361f, -0.05860716f, -0.00322515f, 0.10012318f, -0.03933666f, 0.07256299f, 0.15910819f, 0.07836931f, 
    0.00921309f, 0.00821333f, 0.03181309f, 0.07334545f, -0.03209948f, 0.12975463f, -0.04867621f, -0.11491074f, 
    0.09297413f, -0.06114704f, 0.10146633f, -0.05642787f, 0.09170884f, -0.10686313f, 0.01323347f, 0.05568442f, 
    0.04706572f, -0.12117658f, -0.04139168f, 0.01639759f, 0.04689284f, -0.02007356f, 0.01099768f, 0.03890388f, 
    0.01935234f, 0.02287071f, -0.09214216f, -0.01882122f, -0.05788589f, 0.04206119f, 0.18312970f, -0.00731677f, 
    0.06451862f, -0.06453152f, -0.08690921f, 0.06737423f, -0.03342707f, 0.04683296f, 0.00515526f, 0.05720558f, 
    -0.00595139f, 0.02161555f, -0.05239717f, -0.01227752f, -0.00401268f, 0.02138041f, -0.06478962f, -0.04845370f, 
    -0.27186054f, 0.36734006f, -0.12135420f, -0.20591015f, -0.11857379f, 0.04999613f, 0.01009927f, -0.09568227f, 
    0.09465154f, -0.05989566f, 0.03718964f, -0.01890719f, 0.03262655f, 0.10908294f, -0.06171664f, -0.02939269f, 
    -0.01135737f, 0.03373633f, -0.00706610f, -0.07351867f, -0.20667888f, -0.10758465f, -0.06613818f, -0.11364207f, 
    -0.20768484f, 0.08264182f, -0.06719620f, 0.06103360f, 0.00272934f, 0.04920091f, -0.01023976f, -0.09670237f, 
    0.00365812f, -0.12132928f, 0.05449719f, 0.03951471f, -0.03754803f, -0.01341348f, -0.05243453f, 0.02433466f, 
    0.38799402f, -0.25785208f, 0.00976635f, 0.06190131f, -0.05753569f, 0.06349277f, -0.07804123f, 0.02681164f, 
    -0.03489696f, -0.01389399f, 0.08866002f, -0.01747029f, -0.09528208f, 0.16061263f, -0.03096534f, 0.10005527f, 
    0.03439027f, -0.02943662f, -0.07655798f, -0.00865070f, -0.33621311f, 0.03591099f, -0.11542150f, 0.03789755f, 
    -0.16820912f, 0.01844993f, 0.06386308f, -0.02565129f, -0.00749464f, 0.03525339f, -0.00160527f, -0.09398887f, 
    -0.02071702f, 0.02459028f, -0.00540314f, -0.04549925f, -0.04797279f, 0.01130340f, 0.01146908f, -0.08422305f, 
    -0.02487661f, -0.00308806f, 0.02663859f, 0.01835630f, 0.01421341f, -0.02706043f, -0.02087210f, -0.06703433f, 
    -0.05188742f, -0.05103920f, 0.00129023f, -0.00111399f, 0.07691651f, -0.04581524f, -0.02385855f, 0.00511427f, 
    -0.02654689f, -0.00929575f, 0.08746769f, -0.02089099f, 0.13915104f, 0.23131879f, 0.07964328f, -0.20350716f, 
    -0.10917850f, 0.11658707f, -0.00038097f, -0.10441072f, 0.03981866f, 0.00356439f, -0.06857302f, -0.06640659f, 
    -0.06808782f, -0.00672332f, 0.13934998f, 0.04844700f, 0.09239010f, 0.02917084f, 0.03272549f, -0.08095036f, 
    -0.18298274f, -0.02055879f, 0.06291391f, 0.00187090f, 0.21027415f, 0.04184724f, -0.07287855f, -0.00532071f, 
    -0.06799459f, -0.04307720f, -0.03661307f, -0.11051012f, 0.08035866f, 0.02124183f, 0.01904489f, -0.02429554f, 
    -0.04047558f, 0.00832323f, -0.04384961f, -0.11239533f, 0.23480923f, -0.30860028f, 0.11687794f, 0.05001909f, 
    -0.28316563f, 0.00500594f, 0.11680191f, -0.12882800f, 0.03485996f, 0.00721833f, -0.16293684f, 0.05008851f, 
    -0.01394780f, 0.00803637f, 0.09450617f, 0.04986217f, -0.00583980f, -0.00515849f, 0.02308365f, 0.00027530f, 
    0.26646963f, 0.08015250f, 0.01145261f, -0.13844290f, 0.08065397f, 0.10674138f, -0.02152910f, 0.03809160f, 
    0.01152152f, -0.02067383f, 0.06442476f, -0.12682563f, -0.06105754f, -0.01245999f, 0.06979717f, -0.05449942f, 
    -0.02907117f, 0.04721500f, 0.03055066f, 0.03513377f, -0.02824952f, -0.28171608f, -0.00546859f, 0.07537114f, 
    -0.08769662f, 0.01798552f, -0.00977980f, -0.00477846f, 0.03208795f, -0.00247187f, -0.07739331f, -0.01244809f, 
    -0.08795294f, 0.02919009f, -0.00847601f, -0.00384341f, -0.00902063f, -0.01093430f, 0.03417917f, -0.05495735f, 
    0.00920217f, 0.00777365f, 0.00716131f, 0.01604697f, 0.06842768f, -0.09021837f, -0.07398430f, -0.03327578f, 
    -0.02121544f, 0.01478729f, 0.02277020f, 0.03881406f, 0.03529553f, -0.07951614f, 0.03187916f, 0.07722965f, 
    0.05951132f, -0.12872303f, -0.02482403f, 0.07170529f, -0.00979735f, 0.01146570f, -0.05681901f, -0.02940406f, 
    0.07968981f, -0.09152219f, -0.00786186f, -0.06816930f, -0.06722459f, 0.00593149f, -0.03423574f, 0.02039016f, 
    -0.04705874f, -0.08399402f, 0.04696004f, -0.02567784f, 0.01011614f, 0.03053227f, 0.02980887f, -0.04663188f, 
    -0.17748585f, -0.00627401f, 0.10864225f, -0.03621409f, -0.16634922f, 0.06076391f, 0.02993439f, 0.02159450f, 
    0.02668621f, 0.02538002f, 0.01254946f, -0.01494681f, 0.01850205f, -0.07822077f, -0.04560857f, -0.01771201f, 
    0.00518136f, -0.08487536f, 0.02534566f, -0.00857335f, -0.05616217f, 0.17702188f, 0.07569125f, -0.09913811f, 
    -0.25259870f, 0.03832902f, 0.03648038f, -0.03014763f, 0.04976787f, 0.00958299f, 0.06906325f, -0.04260399f, 
    0.07484028f, 0.01029695f, -0.07156499f, 0.05114643f, 0.01417272f, -0.04992366f, 0.02549894f, 0.05141429f, 
    0.05641001f, 0.03020757f, 0.15919888f, 0.12831043f, 0.11389365f, -0.04792218f, -0.11864273f, -0.01313480f, 
    -0.02599045f, -0.01806407f, -0.00376418f, -0.00754840f, 0.04408693f, 0.04028547f, -0.08201578f, 0.01681720f, 
    0.06116301f, 0.02294159f, 0.06726581f, -0.02478946f, 0.29716247f, -0.02947778f, -0.09550233f, 0.05441941f, 
    0.01147148f, -0.01475474f, 0.08105794f, 0.05621259f, 0.09678004f, 0.14504334f, 0.00089307f, -0.05377223f, 
    0.08051720f, 0.07225990f, -0.00822355f, 0.17585537f, 0.02730129f, 0.05376392f, -0.16964890f, -0.03918280f, 
    0.11930242f, -0.07265615f, -0.11857624f, 0.02077464f, -0.07508016f, 0.00678809f, 0.01684303f, -0.03074884f, 
    -0.03281019f, 0.04698365f, 0.10167193f, 0.07836118f, -0.13077736f, -0.04082324f, 0.02986123f, -0.01870845f, 
    0.04716554f, -0.01966230f, -0.03483041f, 0.03977385f, 0.29103607f, 0.00309211f, -0.04635363f, 0.18925385f, 
    -0.02779045f, 0.00708571f, -0.13964330f, 0.00698149f, -0.00522336f, -0.00772534f, -0.02350078f, -0.00771481f, 
    0.01900649f, 0.08702654f, -0.03476126f, 0.15170944f, 0.08072638f, -0.03608089f, -0.11024333f, -0.04859657f, 
    0.00736530f, -0.03937259f, 0.16030219f, -0.07177147f, 0.17021304f, -0.05018120f, 0.03717051f, -0.04113500f, 
    -0.03770693f, 0.01639779f, -0.01155031f, -0.01206092f, 0.02229762f, -0.02761280f, -0.01291848f, -0.00957684f, 
    -0.02689032f, -0.05273773f, 0.03847262f, 0.05960701f, 0.01985419f, 0.08560503f, -0.12025456f, 0.01402547f, 
    -0.16245668f, 0.02070952f, 0.00285952f, -0.08061603f, -0.06857514f, 0.03392097f, -0.00726316f, 0.09701318f, 
    -0.07988948f, -0.02347725f, 0.04459867f, 0.07620451f, -0.01534520f, 0.00304215f, -0.01646806f, 0.01838977f, 
    -0.38593894f, -0.03319536f, -0.19498113f, -0.07155921f, 0.01002232f, 0.02055915f, 0.01680564f, -0.03121388f, 
    0.05827102f, 0.07084276f, -0.03329092f, -0.00390932f, 0.03586711f, -0.03494547f, 0.02499266f, -0.02588046f, 
    -0.03413945f, -0.01982171f, -0.00940952f, -0.11616489f, 0.27270296f, -0.56117070f, 0.13996552f, -0.24710669f, 
    -0.17065470f, 0.00768918f, -0.07670482f, -0.05893299f, -0.02669367f, -0.02234399f, -0.03861383f, -0.02020283f, 
    -0.10784956f, 0.04881739f, 0.01673196f, -0.11906395f, -0.03941895f, -0.14334345f, 0.01650299f, 0.00333381f, 
    0.06812759f, 0.08387268f, 0.00050899f, 0.00381122f, 0.13058311f, -0.02949476f, -0.00073309f, 0.02511946f, 
    0.02035777f, 0.02612903f, 0.01673288f, 0.01251734f, 0.10373998f, 0.00211001f, 0.05347547f, -0.01292155f, 
    -0.01370152f, -0.03924264f, -0.00139542f, -0.05985361f, 0.00606274f, 0.01734104f, -0.04899438f, 0.10234481f, 
    -0.24800916f, -0.10053813f, -0.03976678f, -0.02144065f, -0.01115369f, 0.04751008f, -0.01329309f, -0.02404695f, 
    -0.04966304f, -0.00654381f, 0.00111330f, 0.00339369f, 0.02306267f, 0.01249602f, -0.10672678f, -0.08365516f, 
    -0.18643023f, -0.13129872f, 0.07127637f, -0.00144112f, -0.03105890f, 0.05385474f, 0.05256692f, -0.01504196f, 
    0.04309065f, -0.01354359f, -0.15034033f, -0.07733541f, 0.01608320f, 0.05820516f, -0.09811783f, -0.07610796f, 
    0.05179669f, -0.01851924f, -0.11325790f, 0.01575002f, 0.00582731f, 0.12207913f, 0.00043703f, 0.05769957f, 
    -0.27631921f, -0.09556700f, -0.11213917f, 0.06873799f, 0.06261484f, 0.03775208f, -0.02951119f, 0.00202463f, 
    -0.05280874f, 0.04330728f, 0.00079226f, 0.01462083f, 0.09542834f, -0.10020045f, 0.05435330f, -0.03392016f, 
    -0.06440263f, 0.13104697f, 0.04343872f, 0.07124455f, 0.03869234f, 0.01143021f, -0.05486132f, 0.04262787f, 
    0.02668928f, 0.00426922f, 0.04285674f, 0.00457986f, -0.04546736f, 0.06559055f, -0.04731767f, 0.00227924f, 
    -0.05994720f, -0.00379435f, -0.04186475f, -0.00626012f, -0.19375132f, 0.03843008f, -0.08684602f, 0.01395717f, 
    0.03038984f, 0.09643029f, -0.03396177f, 0.04316897f, -0.04910686f, 0.05437034f, -0.04113248f, -0.02202570f, 
    -0.06002068f, -0.01985082f, -0.00074918f, 0.02742882f, -0.03054672f, 0.00831359f, -0.04155581f, 0.09530469f, 
    0.10853954f, -0.17910196f, 0.03138335f, -0.02326695f, 0.02696897f, -0.07013027f, -0.09459161f, -0.01641469f, 
    0.04458403f, -0.08251874f, 0.08247580f, -0.01684343f, -0.07526916f, 0.13028829f, -0.05080108f, -0.04298519f, 
    -0.07041229f, -0.03565422f, -0.02742025f, -0.11241610f, -0.12163036f, -0.10539187f, -0.03665033f, -0.17470704f, 
    -0.00138964f, -0.05499896f, 0.00961817f, 0.04482427f, -0.03528833f, -0.03318980f, -0.18922988f, -0.05749473f, 
    -0.02027469f, -0.02554582f, 0.04072263f, -0.06771942f, -0.02350682f, -0.05828151f, -0.04695316f, -0.12544186f, 
    0.09026948f, 0.13936970f, 0.07762807f, -0.00507792f, -0.12274883f, -0.07563933f, -0.00511892f, 0.05217046f, 
    -0.01291114f, 0.08462756f, 0.11201449f, -0.04123012f, 0.01286994f, -0.06819670f, 0.03725151f, -0.00358171f, 
    -0.01021995f, -0.08496947f, -0.01383309f, 0.08399741f, 0.12096749f, 0.10837508f, 0.15617765f, -0.04323948f, 
    -0.24096236f, -0.03468138f, -0.01992068f, 0.00841110f, 0.01915343f, 0.09509160f, 0.06285968f, -0.01097052f, 
    0.12221004f, -0.03506675f, 0.05342067f, -0.00090489f, 0.08360443f, -0.02746031f, 0.06239137f, 0.08179597f, 
    0.20644867f, -0.22606468f, -0.01407983f, -0.19647264f, 0.00232701f, -0.00595475f, 0.02322172f, 0.07372020f, 
    -0.03115093f, -0.00330809f, -0.02554126f, 0.03348362f, 0.00473630f, -0.04010690f, -0.08367769f, -0.08189296f, 
    -0.07449589f, -0.03626229f, -0.06266529f, -0.01472249f, 0.18692759f, 0.02951064f, -0.14066559f, 0.13659576f, 
    -0.19015278f, -0.07974977f, 0.05459094f, 0.03193767f, 0.02402728f, 0.06700544f, -0.01017572f, -0.05131526f, 
    -0.02771423f, 0.07240876f, 0.01858536f, 0.06833015f, 0.10078795f, 0.00801990f, -0.02083371f, -0.06869058f, 
    -0.16271965f, 0.04421468f, -0.09977987f, -0.18948622f, -0.22718376f, 0.03275741f, 0.05682012f, 0.00097950f, 
    0.04822614f, -0.01701150f, -0.01599917f, 0.04765359f, -0.00446910f, 0.13726179f, -0.06029347f, -0.11838790f, 
    -0.04497148f, -0.19388635f, -0.07485007f, -0.14086911f, 0.07483697f, 0.10784123f, 0.09964544f, 0.08187192f, 
    0.14549625f, -0.02665314f, 0.04374879f, -0.03930308f, 0.01859501f, -0.05549663f, 0.02829851f, 0.04351453f, 
    0.01107920f, 0.01814938f, 0.01584586f, 0.00503977f, 0.04145034f, 0.06452969f, 0.04946029f, 0.01919050f, 
    -0.10297845f, -0.02548822f, -0.02881090f, -0.07792810f, -0.04520308f, 0.14294460f, -0.02737270f, -0.16610982f, 
    0.16874324f, -0.11125077f, 0.00564779f, -0.08590708f, -0.11855170f, 0.05063608f, -0.03039832f, -0.02459630f, 
    -0.07472266f, 0.01712849f, 0.00535080f, 0.10211886f, 0.32616490f, -0.13290815f, -0.09147427f, -0.05557761f, 
    -0.04292930f, -0.05183427f, -0.10884887f, -0.01068199f, -0.02493481f, 0.06049416f, 0.02961897f, 0.04244520f, 
    0.08135454f, -0.01972348f, 0.14397690f, -0.00930829f, -0.05066131f, -0.05270929f, -0.12507020f, 0.11009303f, 
    0.07407776f, 0.22723988f, -0.07194103f, 0.01040555f, 0.09284860f, 0.07286078f, -0.00022735f, 0.06699365f, 
    0.01579625f, 0.05747192f, -0.02343218f, -0.01603191f, -0.03360061f, 0.01789282f, -0.04727438f, 0.02982522f, 
    0.02252312f, 0.04736525f, -0.04889357f, 0.02608060f, -0.16098414f, 0.12173804f, -0.16317269f, -0.16892284f, 
    0.01516078f, -0.00329176f, 0.13803408f, 0.01747547f, -0.02919491f, -0.03497180f, -0.07124162f, -0.01176736f, 
    0.04689005f, -0.09341148f, -0.02275760f, 0.04492078f, -0.08350042f, 0.09554999f, -0.08599354f, -0.05411851f, 
    0.02099031f, 0.19706988f, -0.02298058f, -0.03183193f, 0.14192353f, 0.02250945f, 0.02963968f, 0.02544211f, 
    0.05067897f, 0.02218103f, -0.00801921f, 0.00622261f, 0.02980442f, 0.07038831f, -0.01162086f, 0.02739631f, 
    0.00863853f, 0.09797913f, -0.05049774f, 0.00172235f, -0.17680037f, -0.11499256f, 0.07906553f, -0.01426519f, 
    -0.15876177f, 0.05550513f, 0.03671976f, -0.00170496f, 0.07630223f, -0.07967092f, 0.05763938f, 0.07999764f, 
    0.06268038f, 0.04079038f, -0.04098945f, 0.02582053f, -0.03776411f, -0.15295611f, -0.04803940f, -0.01156405f, 
    -0.20969798f, -0.24913514f, -0.00697166f, -0.07747933f, 0.17654662f, -0.11336343f, -0.12220999f, -0.03806599f, 
    0.00219065f, -0.04761840f, -0.02266513f, -0.03703692f, -0.00980115f, -0.01388663f, -0.03419401f, -0.07691028f, 
    -0.00025831f, 0.06666110f, 0.10403089f, -0.13492525f, -0.06413653f, 0.06578831f, 0.02855574f, -0.01996711f, 
    -0.08656498f, -0.13269523f, 0.04619684f, -0.01667204f, 0.06669863f, 0.06997184f, -0.14206475f, -0.01138553f, 
    -0.06025152f, -0.10839275f, -0.08161423f, 0.04277354f, 0.01190696f, -0.05493258f, -0.05097214f, 0.02899601f, 
    0.15467952f, -0.00178100f, -0.17608862f, 0.02592199f, -0.21282068f, 0.01164440f, -0.01619881f, -0.01759371f, 
    -0.05956293f, 0.07846642f, 0.03148015f, 0.12133371f, -0.02063291f, -0.04993496f, 0.06258908f, 0.02201856f, 
    -0.02364749f, -0.06898005f, 0.00265744f, 0.00422773f, 0.16908619f, -0.34331197f, 0.09592523f, -0.24303845f, 
    0.01655743f, 0.03751386f, -0.19431943f, 0.01698568f, 0.07339850f, -0.06984192f, -0.11123084f, -0.02961451f, 
    -0.01323942f, -0.08762126f, 0.10344949f, -0.09811700f, -0.01121055f, -0.14588965f, 0.00513424f, -0.12538362f, 
    0.08909430f, -0.23968762f, -0.02515396f, 0.00170466f, -0.05769509f, -0.08199561f, 0.03320615f, 0.05625272f, 
    -0.01885330f, 0.04199420f, 0.09204299f, 0.03544435f, -0.00619924f, 0.02570106f, -0.00351905f, 0.11746030f, 
    -0.06294931f, 0.01600628f, 0.00127747f, -0.01434508f, -0.02231422f, 0.07893757f, 0.04121127f, 0.02412917f, 
    0.09769560f, 0.02990990f, -0.02356946f, 0.03345209f, -0.07903361f, 0.03230328f, -0.04260597f, 0.00894489f, 
    0.01537897f, 0.07660213f, -0.00788812f, 0.12811083f, -0.05072441f, 0.03559465f, 0.07656807f, 0.06760076f, 
    -0.07494296f, 0.12192329f, 0.09811282f, 0.13840543f, 0.07107853f, -0.06706225f, -0.03596072f, 0.00895013f, 
    0.00598605f, 0.00838742f, -0.07215325f, 0.03802925f, 0.03712025f, 0.00326599f, -0.03969853f, -0.08383090f, 
    0.04248271f, 0.03604975f, -0.02325925f, 0.02907692f, 0.15090242f, -0.05209155f, -0.36038437f, -0.27802041f, 
    -0.02570385f, -0.05941210f, -0.08732037f, 0.05580061f, 0.10769195f, 0.04027859f, 0.01170694f, -0.05287463f, 
    0.06720082f, 0.04640232f, -0.07753813f, -0.03792401f, -0.04242942f, 0.04701307f, 0.02210290f, -0.00089529f, 
    -0.26046482f, 0.01273224f, -0.16921239f, -0.07606786f, 0.09356476f, 0.13562980f, 0.03001771f, 0.01469948f, 
    -0.05736842f, 0.02946424f, 0.03393547f, 0.02673790f, -0.04989301f, -0.08772264f, -0.01276577f, 0.01302066f, 
    -0.01667107f, -0.05428854f, 0.10617861f, 0.04508003f, -0.07698479f, 0.01828139f, 0.01566951f, -0.08555932f, 
    -0.00188418f, -0.12836528f, -0.00019594f, 0.05269761f, -0.04993327f, -0.00780917f, 0.12060706f, 0.04271079f, 
    0.13088939f, -0.01823298f, 0.02086730f, -0.04316183f, 0.01134140f, -0.15035945f, 0.05033071f, 0.02431744f, 
    0.16711496f, 0.03076349f, 0.04424976f, 0.04149531f, 0.14159620f, -0.00112567f, -0.03958049f, 0.06271049f, 
    -0.03022877f, 0.03943045f, -0.01328727f, 0.02933402f, 0.07051751f, 0.03116223f, 0.04438872f, 0.00606240f, 
    0.01089858f, 0.06399056f, 0.04383251f, 0.04478372f, 0.15343958f, 0.11649304f, 0.04710118f, -0.08276994f, 
    0.21070755f, -0.17056184f, 0.01932012f, 0.00628850f, -0.04439653f, 0.10968664f, -0.05906438f, 0.02725437f, 
    -0.01291189f, -0.01211525f, -0.04873027f, -0.06378712f, -0.02987503f, 0.00428377f, 0.04926405f, 0.16019492f, 
    -0.11078729f, -0.10970875f, -0.03959876f, -0.18673727f, 0.08490206f, 0.04953292f, -0.02154841f, 0.07527196f, 
    -0.05366571f, -0.03506119f, -0.05332387f, -0.01860701f, -0.06881783f, 0.04594928f, -0.01828051f, -0.07021262f, 
    -0.01874271f, -0.09373125f, 0.01265428f, 0.07624782f, 0.04170047f, 0.06214173f, -0.02833854f, -0.12897153f, 
    0.02837060f, -0.02132389f, -0.01517073f, 0.00209765f, -0.02793825f, 0.00205055f, -0.00468293f, -0.08129396f, 
    0.00796647f, 0.00427581f, 0.11555426f, -0.01451435f, -0.04839145f, 0.07619610f, -0.09114801f, 0.05561821f, 
    -0.36220187f, -0.01535675f, 0.00195025f, -0.04861362f, 0.05300163f, -0.00039608f, -0.10880540f, -0.08647855f, 
    -0.04122022f, 0.00865505f, 0.12311412f, 0.03687702f, -0.05116203f, -0.06375075f, -0.05519263f, -0.06441385f, 
    -0.09867451f, 0.00454831f, -0.00144076f, -0.01540431f, 0.22614539f, -0.06119210f, -0.02778454f, 0.08395350f, 
    0.08658178f, 0.04300264f, -0.09793103f, 0.03260168f, 0.00821301f, -0.02966749f, -0.03295715f, -0.07014962f, 
    -0.03441752f, -0.00788859f, -0.01540697f, 0.09124345f, -0.02930387f, -0.08025283f, -0.08085006f, -0.02110357f, 
    0.09055893f, 0.00596784f, -0.10964435f, 0.08712148f, 0.04042881f, 0.05322957f, -0.08172792f, 0.03492509f, 
    0.02164862f, -0.05901973f, 0.05554720f, -0.00374501f, -0.00456985f, 0.08353262f, -0.04676494f, 0.04998695f, 
    0.07910451f, -0.02794093f, -0.04022866f, -0.03851869f, 0.13497454f, -0.05258639f, 0.09112704f, 0.03711610f, 
    0.02599278f, -0.01260675f, -0.02470845f, 0.01696833f, -0.04789850f, 0.04325808f, 0.04141044f, 0.07374997f, 
    -0.10952367f, -0.04587710f, -0.15710838f, 0.00513125f, -0.08571798f, 0.07906964f, 0.05120433f, -0.07835328f, 
    -0.13181560f, 0.19080906f, -0.01991778f, -0.03575592f, 0.07020601f, 0.14181876f, -0.03651862f, 0.18622968f, 
    0.05265779f, 0.07681236f, 0.01169154f, -0.13198884f, 0.04127179f, 0.00948140f, 0.09294733f, 0.00476775f, 
    0.05822499f, -0.16053267f, -0.09762799f, -0.16424076f, -0.18253562f, -0.16438422f, -0.28580901f, -0.29802233f, 
    0.09961255f, 0.00753707f, -0.01343136f, 0.03208064f, -0.04841641f, 0.01027835f, 0.04204920f, -0.03545098f, 
    0.08170652f, -0.00337256f, 0.07808769f, -0.08096273f, -0.01299207f, -0.17712903f, -0.04153951f, -0.01810307f, 
    0.03793250f, -0.21886145f, 0.10088298f, -0.02566512f, 0.07307686f, -0.01986555f, -0.06208506f, -0.11513624f, 
    -0.03265111f, -0.00195151f, 0.03384870f, 0.00364338f, -0.06597934f, 0.07449929f, -0.01637243f, -0.06841478f, 
    0.04660798f, 0.03402236f, 0.04439084f, 0.01283597f, -0.04249906f, 0.15310074f, 0.09496785f, -0.01478435f, 
    0.22914304f, -0.09086172f, 0.03930120f, 0.01416281f, -0.06026268f, 0.07642312f, -0.00507446f, -0.00660745f, 
    0.07624435f, -0.06014429f, -0.02004105f, -0.00286776f, -0.00651353f, 0.00593509f, 0.04260297f, 0.00900822f, 
    0.30890214f, -0.03931588f, -0.05321659f, -0.03928365f, -0.18390973f, -0.00283226f, 0.06165985f, -0.06539714f, 
    0.02655156f, 0.01454732f, -0.00853665f, -0.05879927f, 0.05532083f, -0.01797174f, 0.13815878f, 0.03182364f, 
    -0.08262115f, 0.07686658f, -0.05037280f, 0.06080379f, 0.23635632f, 0.06118792f, -0.07613199f, 0.01982832f, 
    -0.09028868f, -0.01268982f, -0.04442907f, -0.02629807f, -0.02035625f, 0.18092526f, 0.00013466f, -0.07586876f, 
    0.07509368f, 0.09893616f, -0.08582448f, -0.03958249f, 0.16164877f, 0.00235390f, -0.04214210f, 0.16815327f, 
    -0.38420734f, 0.00012530f, -0.09793808f, -0.23302127f, 0.06679154f, -0.00962814f, -0.18153831f, 0.04646764f, 
    -0.04433392f, -0.05104230f, 0.11807586f, -0.00280416f, -0.00208025f, -0.15710920f, -0.03400267f, -0.10999727f, 
    -0.03541366f, -0.04628760f, -0.10949878f, 0.00611828f, 0.15025248f, 0.04638927f, -0.01595596f, 0.00698942f, 
    -0.01540863f, 0.01247642f, -0.00749955f, 0.00289978f, -0.00123956f, 0.06928079f, 0.05356871f, 0.01328390f, 
    -0.04095209f, -0.00497690f, -0.00047989f, 0.09661797f, -0.01671018f, 0.02324069f, 0.02563838f, 0.09729363f, 
    -0.19869481f, 0.00660682f, 0.07935111f, 0.01184514f, -0.02542600f, -0.00896130f, -0.04963282f, 0.01694020f, 
    0.02709055f, -0.02590775f, 0.01511241f, 0.00091692f, 0.02707371f, 0.00675122f, -0.05162806f, -0.03252731f, 
    0.01328383f, -0.05063248f, -0.04302270f, 0.05478740f, 0.07912932f, -0.05255337f, -0.20066077f, -0.06470001f, 
    -0.01651499f, -0.00989578f, 0.02759871f, -0.04181946f, -0.01122378f, 0.13563162f, 0.11139652f, -0.04349255f, 
    -0.08030482f, -0.00734773f, 0.02101643f, 0.05959478f, 0.10740224f, 0.03540853f, -0.08692048f, 0.07891825f, 
    -0.11097658f, 0.15876682f, -0.07406755f, -0.15790243f, 0.02558484f, -0.08001080f, 0.05722474f, -0.00142692f, 
    -0.04252596f, -0.05690684f, 0.03919753f, 0.02382953f, -0.01213310f, -0.03100813f, -0.03913116f, 0.01007765f, 
    -0.02845156f, 0.07441404f, -0.04616955f, 0.16038421f, 0.10451379f, -0.21084705f, 0.11935579f, -0.10128579f, 
    0.03800125f, -0.03384599f, 0.11474770f, 0.08128617f, -0.00464065f, -0.01957939f, 0.03798396f, 0.00379214f, 
    0.03940805f, 0.04092840f, -0.09025113f, 0.09703929f, -0.08184694f, 0.01395553f, -0.04098140f, -0.08875727f, 
    -0.22007707f, 0.14776915f, -0.06194824f, -0.13812611f, 0.03756486f, 0.02343514f, 0.04079467f, -0.06486496f, 
    -0.01846850f, -0.01817105f, -0.00384306f, 0.00789322f, 0.04460649f, -0.03713082f, 0.04927843f, -0.03707044f, 
    0.00330454f, 0.07105198f, 0.02637768f, -0.06256182f, -0.19356047f, -0.04530776f, 0.05478412f, -0.05935214f, 
    -0.11453770f, -0.05379461f, 0.04652148f, 0.04117047f, 0.02449173f, -0.00346973f, -0.04197954f, -0.03142151f, 
    0.06241100f, -0.01034434f, 0.02205752f, -0.05640369f, -0.01046274f, -0.08981492f, -0.11003051f, -0.03054750f, 
    0.03759135f, 0.14542280f, 0.01307236f, 0.12220853f, 0.08961334f, 0.00465439f, -0.01146911f, 0.03957617f, 
    0.02956941f, 0.07890482f, -0.01202853f, 0.03888952f, 0.03293835f, -0.00605967f, -0.02257505f, 0.06299622f, 
    -0.04620149f, 0.14516304f, 0.08257853f, -0.06145446f, -0.06809148f, 0.08552039f, -0.19656719f, -0.06702897f, 
    -0.03583992f, 0.04207702f, 0.02168898f, 0.05246373f, 0.00995352f, 0.07494634f, 0.01988173f, -0.03854912f, 
    0.04536762f, 0.10173196f, -0.03375875f, -0.03771735f, 0.04693981f, -0.01156369f, -0.09170378f, 0.04916995f, 
    0.04726892f, 0.10182547f, -0.15987456f, 0.09561224f, -0.29593319f, 0.02327624f, -0.00707413f, -0.00610816f, 
    -0.02162293f, 0.04796843f, 0.01682212f, -0.01971012f, -0.00451916f, 0.06832872f, 0.01188282f, 0.03860096f, 
    0.13484162f, 0.02160716f, -0.04868627f, 0.03708990f, 0.13506429f, -0.04512804f, -0.05000284f, 0.05701425f, 
    -0.18698105f, 0.03810075f, 0.04677833f, -0.02621138f, -0.02506988f, 0.01899471f, 0.05207093f, 0.13045335f, 
    -0.00885646f, -0.02546683f, -0.02586417f, 0.04008427f, 0.05520139f, 0.02657567f, -0.02098525f, 0.04730284f, 
    -0.17745161f, 0.09457219f, 0.04827684f, -0.04311903f, -0.04546077f, 0.04357062f, -0.10854028f, 0.09481090f, 
    0.03174546f, 0.03954484f, -0.12290875f, 0.04685229f, 0.02644694f, -0.04908407f, 0.05334673f, -0.05345959f, 
    0.00348590f, -0.03021567f, -0.04993729f, 0.00510890f, 0.39534202f, -0.31468451f, 0.01608430f, 0.05224970f, 
    -0.32192111f, -0.08791650f, 0.01535710f, -0.01571429f, -0.06416849f, -0.01725470f, -0.04620759f, 0.01568840f, 
    -0.04050084f, -0.05806385f, -0.01271482f, -0.00331049f, -0.09734881f, 0.00707151f, 0.07128455f, 0.04913677f, 
    0.13839518f, -0.12783390f, 0.05031858f, -0.06184379f, 0.10044352f, -0.02797800f, -0.08735095f, 0.00269960f, 
    0.06535670f, -0.02989623f, 0.07130253f, 0.00242282f, -0.01289934f, -0.01924468f, -0.00263878f, 0.04609187f, 
    -0.05206024f, -0.02079254f, 0.05185894f, -0.01406307f, -0.25322738f, 0.29215351f, -0.05175660f, -0.23349662f, 
    0.13994424f, 0.03087442f, 0.11495967f, 0.11183379f, 0.03499856f, -0.10871079f, -0.08181200f, 0.11283296f, 
    -0.07938421f, -0.07494687f, -0.02669540f, -0.02113997f, 0.01137133f, 0.02282581f, 0.01678383f, 0.07902570f, 
    0.12529354f, -0.16809715f, 0.02435724f, -0.04779651f, -0.07070498f, 0.05881899f, 0.10116415f, 0.05762047f, 
    0.01196789f, -0.01485578f, -0.00646777f, 0.03550644f, -0.02424070f, -0.03407265f, -0.01231275f, 0.00170874f, 
    -0.13828665f, -0.01725269f, -0.07822875f, -0.00469704f, 0.24140878f, -0.03455051f, 0.10235398f, 0.10697598f, 
    0.23173672f, -0.11116706f, -0.09214269f, -0.03732583f, 0.09399720f, 0.04538216f, 0.07112300f, 0.00182312f, 
    -0.05980499f, -0.05271646f, 0.03579513f, 0.00472992f, -0.09071716f, -0.09538827f, -0.03792698f, -0.02653854f, 
    0.34279281f, -0.24042343f, 0.03012554f, -0.08163883f, 0.06486929f, 0.07291346f, -0.05494776f, -0.16281888f, 
    0.09236303f, 0.09011696f, 0.02283318f, 0.03650739f, -0.00657873f, 0.06449866f, 0.04478426f, -0.00326449f, 
    -0.03804050f, 0.01026680f, -0.01176354f, -0.00455310f, 0.07615424f, -0.29523125f, -0.01261138f, -0.13702342f, 
    -0.14062433f, 0.02226123f, -0.19618876f, 0.07338460f, 0.05768837f, 0.09815755f, -0.02787041f, 0.04242032f, 
    -0.00931287f, 0.00806987f, -0.07160966f, 0.00200416f, -0.07635800f, 0.05266897f, 0.02471422f, -0.02384452f, 
    0.08969332f, -0.03996483f, -0.03136674f, -0.08501615f, -0.07357156f, 0.04150296f, 0.04885463f, 0.05671202f, 
    -0.02240304f, -0.06369370f, -0.01653900f, 0.03894086f, -0.00631890f, 0.00459262f, -0.02192333f, -0.04151369f, 
    -0.02865833f, 0.01646802f, -0.07523224f, 0.00779957f, 0.23181577f, -0.04825880f, -0.08675005f, 0.09777958f, 
    0.01870034f, -0.06622329f, 0.02291426f, 0.01112609f, 0.04873182f, 0.02202683f, 0.02941898f, 0.03309629f, 
    0.04594273f, 0.00988388f, 0.00178513f, 0.05943625f, -0.07759430f, -0.02958674f, 0.07552079f, 0.01103671f, 
    0.23994707f, -0.22780310f, 0.02061255f, -0.03707000f, -0.19654477f, -0.00784868f, 0.03663986f, -0.03267322f, 
    0.02516708f, -0.02969862f, 0.02078332f, 0.03565641f, 0.03752526f, 0.01565125f, -0.03000976f, 0.05335451f, 
    0.05343511f, 0.01854928f, 0.02396241f, -0.04099063f, 0.12230632f, -0.16270754f, -0.12772234f, 0.02572156f, 
    0.03513581f, -0.17396852f, -0.12073941f, -0.12157766f, -0.03177548f, -0.02022521f, -0.01218166f, -0.02953623f, 
    0.02297230f, -0.02180247f, 0.00721709f, -0.01965690f, 0.00764646f, -0.01872327f, 0.04070980f, -0.00295431f, 
    -0.18386997f, 0.06253415f, 0.05411579f, -0.01655017f, 0.08176484f, -0.06683245f, -0.06231534f, -0.02729487f, 
    0.06561556f, -0.03221932f, -0.01383728f, 0.02263344f, 0.04323891f, 0.03938796f, 0.01212624f, -0.04148909f, 
    -0.01729870f, -0.05375020f, -0.04019338f, -0.04231967f, 0.21076468f, -0.02017329f, 0.04492598f, -0.03700403f, 
    0.01067182f, -0.02234508f, 0.00748551f, -0.11440656f, 0.06260511f, 0.01068123f, -0.03290415f, 0.02181666f, 
    0.01492644f, -0.00544836f, 0.01084325f, -0.03101038f, 0.03475627f, -0.02436961f, 0.06363907f, 0.01535331f, 
    0.07772478f, -0.09024137f, -0.00191173f, -0.16035552f, -0.03546246f, 0.03929935f, -0.05647211f, 0.16506822f, 
    0.05390537f, 0.07125015f, -0.01372352f, 0.01005761f, 0.06578270f, -0.05544139f, -0.04972892f, -0.01418532f, 
    -0.00842197f, 0.07361341f, -0.00104581f, -0.08317950f, -0.08403541f, -0.10827544f, -0.05147443f, -0.11556333f, 
    -0.27791092f, 0.00287812f, -0.00267543f, -0.05337629f, 0.02275116f, 0.02763935f, 0.09900369f, 0.07834975f, 
    -0.04119156f, -0.03512114f, -0.05244660f, -0.07444131f, -0.00714309f, 0.08089913f, -0.01707340f, -0.05920924f, 
    -0.39015338f, 0.03682913f, -0.09341512f, -0.10788195f, 0.04398137f, 0.05063130f, 0.07520686f, 0.02496849f, 
    0.04327999f, -0.06014878f, -0.02690103f, -0.00335227f, 0.02895233f, -0.06452923f, 0.00872304f, -0.07527718f, 
    0.01127319f, -0.02047450f, -0.10291043f, -0.01763628f, -0.52156794f, 0.15033004f, 0.03217449f, -0.03549139f, 
    0.05960435f, -0.03773779f, 0.05437380f, -0.04360181f, 0.02834729f, -0.01745658f, 0.04162963f, -0.05234835f, 
    0.00210910f, -0.08364574f, 0.09443665f, 0.02798996f, 0.03952578f, -0.09959076f, -0.01657211f, 0.03076678f, 
    -0.17913030f, 0.00340733f, -0.14755110f, -0.11337443f, -0.10326172f, 0.01891425f, -0.03214964f, -0.00365164f, 
    0.03412266f, -0.02519073f, 0.01863202f, -0.00542831f, -0.05614728f, -0.02973965f, -0.07067654f, -0.02444339f, 
    0.04652911f, 0.04105758f, 0.02664382f, 0.01444154f, 0.13417473f, -0.23906235f, 0.06472672f, -0.01867387f, 
    0.00531880f, -0.11159122f, -0.00025522f, -0.00376955f, 0.00804569f, 0.02239950f, 0.04506612f, -0.03824884f, 
    -0.01821811f, -0.06992626f, 0.05820955f, 0.09465554f, -0.06545588f, -0.01134545f, 0.01323037f, 0.04402360f, 
    -0.25417185f, -0.28355724f, -0.05259839f, -0.13428289f, -0.32317919f, -0.01113612f, 0.10406357f, -0.03508361f, 
    -0.03955511f, 0.03910311f, 0.01386385f, 0.05299214f, 0.07525128f, -0.03578838f, -0.07455084f, 0.05800834f, 
    -0.05363612f, 0.14236923f, -0.00625387f, -0.10311481f, 0.07708430f, 0.00747983f, 0.06381574f, -0.12238576f, 
    0.05488101f, 0.06153917f, -0.02638541f, 0.06176047f, 0.06113264f, 0.02205257f, -0.02445029f, 0.00633826f, 
    0.04819356f, 0.04519638f, -0.03211583f, -0.04661213f, -0.03949118f, -0.01571167f, -0.10824735f, -0.03136309f, 
    0.04602529f, -0.00747204f, 0.06463939f, 0.13650770f, -0.09208155f, -0.10474762f, 0.06428402f, 0.04728108f, 
    -0.06593428f, 0.04302184f, -0.02788347f, 0.06408663f, 0.04585126f, 0.06155169f, -0.02680922f, 0.04198861f, 
    -0.08579440f, -0.03319506f, -0.03964521f, -0.08751754f, 0.09280264f, 0.12108846f, -0.00258638f, -0.17050281f, 
    -0.09464243f, 0.07079949f, 0.02134359f, 0.04085663f, -0.06764613f, -0.00694890f, -0.05952632f, -0.07017384f, 
    0.00909849f, -0.07274295f, 0.03053369f, 0.03973107f, -0.02801269f, 0.03651732f, 0.02652789f, -0.04258609f, 
    0.08143762f, 0.05599480f, -0.20804262f, 0.00205513f, 0.00767447f, -0.00373161f, 0.07186089f, 0.07657000f, 
    -0.01119759f, -0.04704728f, -0.04967304f, -0.00149760f, 0.01635569f, -0.01957126f, 0.00900888f, -0.00582263f, 
    0.03526495f, -0.04942061f, -0.06669108f, 0.01466128f, 0.16766165f, 0.06387728f, -0.26164970f, -0.04107653f, 
    -0.05265764f, -0.03284488f, 0.02348460f, 0.05927037f, 0.01651136f, -0.02558280f, -0.02738987f, 0.03208475f, 
    -0.00668000f, -0.02413529f, 0.03978680f, -0.04636722f, 0.03422796f, -0.06632003f, -0.01520038f, 0.00702582f, 
    0.03832144f, 0.06996533f, -0.13530608f, -0.04881753f, -0.04964225f, -0.00058499f, 0.03044260f, 0.06649902f, 
    0.02112980f, -0.03373014f, -0.05744330f, -0.00434002f, 0.00487968f, 0.04381628f, -0.02932050f, -0.06913789f, 
    -0.04406549f, -0.06304727f, -0.07401837f, -0.00245101f, -0.13000628f, 0.13482563f, 0.05262914f, -0.08389436f, 
    0.01024837f, 0.00433668f, 0.13892215f, -0.00501390f, 0.00227638f, -0.01638362f, 0.03832582f, -0.03737315f, 
    0.04153354f, -0.06145167f, -0.06764960f, 0.04883416f, -0.00272861f, 0.01469444f, 0.05756250f, -0.06081126f, 
    0.05984738f, -0.01765254f, 0.02327749f, -0.03296291f, -0.10495640f, 0.04465725f, -0.07990570f, 0.01897700f, 
    -0.04850713f, 0.03936133f, -0.08858824f, -0.09086979f, -0.01612431f, 0.04316130f, -0.03472181f, -0.02652626f, 
    -0.02340176f, 0.01204338f, -0.06489403f, -0.02147710f, 0.23198394f, 0.05564116f, 0.18814695f, -0.04172541f, 
    0.10662882f, -0.05550732f, -0.07177321f, -0.01804657f, 0.02231006f, -0.07838011f, -0.02568532f, -0.03894791f, 
    0.00411570f, -0.01957938f, -0.03821014f, 0.01738973f, -0.09058551f, 0.02200121f, 0.03826355f, -0.00364361f, 
    0.12986933f, -0.12483224f, 0.10456086f, 0.11928844f, 0.23241231f, -0.10912812f, -0.03261314f, -0.10239788f, 
    0.02731824f, 0.06655546f, 0.10238132f, 0.01384254f, -0.07208396f, 0.03688822f, 0.01641695f, -0.05142178f, 
    -0.05969974f, -0.01649298f, -0.06375445f, 0.02725188f, -0.00445910f, -0.23476733f, 0.08727465f, -0.22086731f, 
    -0.18573602f, 0.09247042f, -0.14994401f, 0.12026877f, -0.07208562f, -0.01942120f, -0.08679394f, 0.04581275f, 
    0.04156605f, -0.07375393f, -0.04083451f, 0.09190793f, -0.03606598f, 0.06817138f, -0.01036463f, 0.00815809f, 
    0.29381371f, 0.03525411f, 0.02055189f, -0.00373527f, -0.02868272f, -0.04478646f, -0.04567565f, -0.01053718f, 
    0.01965166f, 0.00100554f, 0.01350769f, 0.00173379f, 0.00909252f, -0.01680483f, -0.03832371f, 0.03847216f, 
    -0.01003542f, -0.01800194f, 0.06897347f, 0.08911019f, 0.05070700f, 0.10815367f, 0.08934194f, -0.01337825f, 
    -0.01524275f, 0.00897449f, 0.04551146f, -0.00660280f, -0.03429720f, 0.02755205f, -0.04598412f, 0.00247241f, 
    0.04837771f, 0.05509691f, -0.03179372f, -0.04643928f, 0.00713433f, -0.01888771f, -0.02309052f, 0.00155968f, 
    -0.10985963f, 0.10754490f, 0.07489273f, -0.05572682f, 0.06904516f, 0.00250779f, 0.07592139f, 0.07715516f, 
    -0.00305922f, -0.07020234f, 0.01721216f, -0.00187691f, 0.07161511f, 0.02855218f, -0.01311274f, 0.02709309f, 
    -0.01686983f, -0.08743042f, -0.02102641f, -0.00948530f, -0.00736961f, -0.05660709f, -0.07081865f, -0.17792016f, 
    -0.08766820f, 0.01756430f, 0.03153705f, 0.01217377f, -0.03580329f, -0.00195728f, -0.08454342f, -0.03577279f, 
    -0.03691081f, -0.00372514f, 0.03264993f, 0.08236147f, -0.01927464f, 0.02951529f, 0.01711322f, -0.10362585f, 
    -0.00263435f, 0.11005837f, -0.03096319f, -0.04948573f, 0.00458944f, -0.06868515f, -0.04413485f, -0.01630412f, 
    -0.03819346f, -0.03305804f, -0.08010848f, -0.03209113f, -0.03615183f, -0.01102054f, -0.02033559f, 0.01044491f, 
    0.04152873f, 0.03798328f, 0.02632129f, 0.04756085f, -0.32062277f, -0.15216307f, 0.09439552f, -0.13913855f, 
    -0.12505488f, 0.05735456f, 0.01975306f, -0.08771846f, -0.06844503f, 0.02412927f, -0.08580911f, -0.01124595f, 
    -0.02860649f, -0.03405000f, -0.00336310f, 0.02694909f, -0.00337909f, 0.03062409f, -0.12455976f, -0.01651502f, 
    -0.03497172f, 0.06527577f, 0.02468192f, -0.01892692f, 0.01518157f, -0.03698436f, 0.03116553f, 0.05812386f, 
    -0.00944359f, -0.07040934f, -0.01478013f, 0.03343730f, -0.00558622f, 0.00846793f, -0.00689092f, -0.03757917f, 
    -0.06857353f, -0.03943325f, -0.03447371f, 0.02046333f, 0.00642596f, -0.20765910f, 0.04789963f, 0.01882539f, 
    -0.03108552f, -0.03221904f, 0.09966213f, 0.00744179f, 0.04691768f, 0.05710239f, -0.00408024f, 0.06242683f, 
    -0.04535440f, -0.01777310f, 0.05330230f, -0.02165842f, -0.08412204f, -0.00147982f, -0.05188616f, -0.03606810f, 
    -0.04193265f, 0.01430810f, -0.06507963f, -0.02914317f, -0.00904819f, 0.01371615f, -0.02571329f, 0.09378212f, 
    -0.03210364f, -0.03293383f, -0.04022967f, 0.02304513f, 0.02087389f, -0.00705257f, 0.02008424f, 0.06429299f, 
    -0.03310792f, 0.01843095f, -0.09767548f, 0.02904531f, -0.01712164f, 0.14978766f, -0.01574083f, -0.10585085f, 
    -0.08476392f, 0.02577262f, 0.11515635f, 0.05378341f, -0.07937961f, 0.00624113f, -0.00134559f, -0.02029387f, 
    -0.00861427f, -0.02984062f, -0.00211634f, 0.01983828f, 0.03324472f, -0.04119245f, -0.11617054f, -0.06251986f, 
    0.20773919f, 0.10715181f, -0.04869898f, -0.12526590f, -0.10015807f, -0.04533817f, 0.05909085f, 0.09285418f, 
    0.05185974f, -0.05380462f, 0.01645042f, 0.02120994f, -0.02416446f, 0.00445008f, -0.05313223f, 0.00189102f, 
    0.04786412f, -0.01661611f, 0.09044186f, -0.06208454f, -0.13929655f, 0.11932392f, 0.03286017f, -0.14035706f, 
    0.06210801f, 0.03529865f, 0.07877144f, 0.09378728f, 0.00383999f, -0.05028791f, -0.04078141f, 0.08778247f, 
    0.02789928f, -0.05969182f, -0.02044722f, 0.03997710f, 0.05397235f, 0.04187246f, -0.03840592f, -0.00225892f, 
    -0.10312036f, 0.17844234f, -0.07175893f, -0.02946374f, 0.05779824f, 0.00010682f, 0.10142636f, 0.01953169f, 
    -0.01476846f, -0.13010345f, -0.04624688f, -0.00940813f, -0.12780398f, -0.04716680f, 0.00220243f, 0.01785846f, 
    0.05664401f, -0.02544135f, -0.02596064f, 0.01447707f, -0.01506134f, 0.11240362f, -0.14688323f, -0.02353744f, 
    0.00704344f, 0.02230906f, -0.08540886f, 0.04713966f, 0.07969467f, -0.00099211f, -0.04374169f, 0.05746199f, 
    -0.01884586f, 0.00196837f, 0.01142409f, -0.12938046f, -0.01252130f, -0.03679668f, -0.01439235f, 0.02749191f, 
    -0.29406756f, -0.29809669f, -0.07260507f, -0.24891213f, -0.21282925f, 0.12510164f, -0.14649776f, -0.15104848f, 
    -0.00475746f, -0.01417170f, -0.04379680f, 0.04555587f, -0.08617387f, -0.07346578f, 0.00900096f, -0.09041986f, 
    -0.06900645f, 0.08799867f, 0.03277931f, 0.02733840f, -0.09654172f, -0.12169923f, -0.15696742f, -0.22261538f, 
    -0.10988973f, 0.07966191f, -0.05055920f, 0.11752345f, -0.06936795f, -0.06501062f, -0.08742253f, 0.00957575f, 
    -0.10868960f, -0.09335814f, -0.04387780f, 0.02412503f, -0.06750569f, 0.18358395f, 0.00201140f, -0.03181228f, 
    0.08327165f, -0.01000850f, -0.03590030f, 0.03620253f, -0.04960934f, 0.05589404f, -0.08063656f, 0.01459694f, 
    0.01998762f, 0.04435364f, -0.00005379f, -0.05817556f, 0.07363475f, 0.02996567f, -0.01422789f, -0.02789970f, 
    -0.01178845f, 0.02714474f, -0.03890991f, -0.06235405f, 0.13298441f, -0.13148858f, -0.02996542f, -0.01126601f, 
    -0.02266162f, -0.00157213f, 0.02126298f, 0.04806577f, 0.03009904f, 0.04205217f, -0.00433565f, 0.01212338f, 
    -0.02108994f, -0.00476417f, 0.03636526f, -0.04461068f, -0.06665151f, -0.05873736f, -0.06190927f, -0.04066887f, 
    0.26482263f, 0.06649642f, -0.11169383f, 0.25605303f, -0.02931997f, -0.10273987f, 0.05665257f, -0.02944100f, 
    0.00758343f, 0.03934170f, -0.03793319f, 0.04552895f, 0.06910324f, 0.00903204f, -0.05261889f, -0.03332336f, 
    -0.07519612f, -0.06371591f, 0.03731299f, 0.04165707f, 0.19670935f, -0.24925968f, 0.19149898f, -0.07269067f, 
    0.14689334f, -0.11824598f, -0.10803363f, -0.09822620f, 0.05863914f, 0.02053710f, -0.01707792f, 0.02699743f, 
    -0.04117721f, -0.01337506f, 0.05092670f, -0.05741359f, 0.04636080f, 0.08322930f, 0.04333133f, -0.07767292f, 
    -0.07945592f, 0.07241549f, 0.12888366f, -0.00521286f, 0.08003101f, 0.03960885f, -0.07931924f, -0.10121558f, 
    0.02813409f, 0.03753480f, -0.10962101f, -0.03047673f, -0.09245025f, 0.02025013f, 0.00792035f, 0.09040699f, 
    0.02783404f, 0.04010292f, 0.01190242f, 0.08665469f, 0.24718215f, -0.01695456f, -0.03240272f, 0.11831535f, 
    -0.11014965f, -0.13396250f, -0.02324942f, -0.02927990f, -0.07497934f, 0.07737558f, 0.01941703f, 0.01049076f, 
    0.04226980f, -0.01352034f, 0.00491202f, 0.01070737f, -0.04628566f, 0.01691410f, 0.04242050f, 0.02572635f, 
    0.01945470f, 0.05529119f, 0.07496117f, 0.00695340f, -0.01520307f, 0.04515973f, 0.08675822f, 0.07227141f, 
    -0.03543713f, -0.06537727f, 0.01614923f, 0.05877732f, 0.04925368f, -0.07948957f, -0.01644440f, 0.01439290f, 
    0.03987086f, -0.04352183f, -0.00676981f, -0.04129435f, 0.17768852f, 0.04047640f, 0.15776695f, 0.00023676f, 
    -0.01984537f, -0.06547676f, 0.00716657f, -0.05659704f, -0.04953242f, 0.03014313f, -0.04423186f, -0.06483989f, 
    0.10111149f, -0.03794792f, -0.10580814f, 0.01022023f, -0.06997424f, -0.06932507f, 0.07189677f, 0.03511781f, 
    0.19444817f, 0.09789845f, -0.13550904f, -0.01569859f, -0.07591783f, 0.02171915f, 0.06797787f, 0.06878182f, 
    -0.05343829f, -0.02883555f, -0.06264955f, -0.00099241f, 0.05634691f, 0.02017388f, 0.02923857f, 0.04347494f, 
    -0.02910966f, -0.11294852f, 0.02520104f, -0.00604477f, -0.05067697f, 0.14170949f, -0.05676053f, -0.04994798f, 
    -0.10805164f, 0.06944060f, 0.01479183f, 0.08400278f, 0.10386801f, 0.07627477f, 0.00621663f, -0.01730697f, 
    0.00270608f, -0.00717034f, -0.06682457f, -0.00290237f, 0.02021615f, 0.04330073f, 0.12079842f, 0.03910769f, 
    0.09641352f, 0.06466869f, -0.07050741f, -0.06839249f, 0.01575195f, -0.02716437f, -0.00785966f, 0.01152376f, 
    -0.04102829f, -0.02423819f, -0.02474195f, 0.00198323f, 0.04706309f, 0.02024954f, 0.00405238f, -0.02081852f, 
    -0.00503427f, -0.03442984f, -0.02114468f, 0.01331504f, -0.02395605f, -0.08481531f, -0.10988283f, -0.05401731f, 
    -0.21021129f, 0.00960985f, 0.03223184f, -0.10273870f, 0.02499996f, -0.01178088f, 0.01987433f, 0.04104044f, 
    0.01522624f, -0.03964151f, -0.03934714f, -0.00875221f, 0.00384052f, 0.05464095f, -0.02457654f, -0.03990579f, 
    -0.17306840f, 0.07016657f, -0.07521375f, -0.00061337f, -0.00908315f, 0.06397941f, -0.04900965f, -0.01241126f, 
    0.03763964f, -0.01690743f, 0.01005362f, 0.01204902f, 0.02020784f, -0.02618012f, 0.00057139f, -0.14005180f, 
    0.00915619f, -0.04991401f, -0.11354830f, 0.01830764f, 0.16284133f, 0.12241512f, -0.19453131f, -0.03671649f, 
    -0.05677262f, 0.01835293f, 0.10184022f, -0.03333966f, -0.07197879f, -0.04325008f, -0.02001700f, -0.04262387f, 
    -0.01035886f, -0.04165835f, -0.00155823f, 0.06316070f, 0.05084823f, -0.03047727f, -0.02321261f, -0.03534551f, 
    0.10228038f, 0.00997491f, 0.10029614f, 0.04141083f, 0.13139059f, -0.10060232f, -0.04909797f, -0.08346140f, 
    0.02524677f, -0.00146169f, -0.02770046f, 0.00111972f, -0.05328311f, -0.10153101f, 0.06623518f, 0.01231414f, 
    0.01615022f, -0.02970163f, 0.07409435f, 0.00986474f, 0.14464931f, 0.08286583f, 0.10652001f, 0.10303661f, 
    0.16746584f, -0.07152168f, -0.07989211f, -0.02213133f, 0.02877244f, 0.08091184f, 0.02201487f, -0.02876491f, 
    -0.01559291f, -0.02834828f, 0.04075687f, -0.04486111f, -0.08001605f, -0.03628780f, -0.06304242f, 0.04351367f, 
    0.17960159f, -0.10063837f, -0.14494722f, 0.04232980f, 0.04124039f, -0.08973520f, -0.00909343f, 0.00912577f, 
    -0.02883636f, -0.06989434f, 0.01602694f, -0.01558197f, -0.02671302f, -0.01046842f, 0.03327819f, -0.02541090f, 
    0.05368770f, -0.02400286f, -0.05912429f, 0.02245933f, 0.04174348f, 0.02207518f, -0.04660213f, -0.03008000f, 
    -0.00108200f, -0.04233924f, -0.09295222f, 0.01638256f, -0.05410877f, -0.02034907f, -0.06508394f, -0.00932065f, 
    -0.01478268f, -0.08786498f, 0.08930465f, -0.02846792f, 0.06590737f, 0.07387748f, 0.03697529f, -0.05050149f, 
    -0.08350062f, -0.00119682f, 0.03593987f, 0.07868434f, -0.04783943f, -0.01570332f, -0.14660865f, 0.02482059f, 
    -0.03199694f, -0.03323161f, -0.00186797f, -0.03178946f, 0.02090461f, -0.00695149f, 0.02483849f, 0.01586294f, 
    -0.01357598f, -0.00359824f, 0.04774679f, 0.05488628f, -0.35582837f, -0.39369348f, -0.40144229f, 0.09904639f, 
    0.14491500f, -0.09852482f, 0.04494584f, 0.10338829f, 0.01352273f, -0.09591887f, -0.02032186f, 0.00073662f, 
    -0.05455377f, -0.10917877f, 0.00034298f, -0.02378814f, -0.04724293f, 0.01579450f, -0.02613842f, -0.03897013f, 
    0.30863813f, -0.19940077f, -0.08722023f, 0.13395405f, 0.00657111f, -0.00928778f, -0.08927178f, -0.02816717f, 
    0.04806303f, -0.08151952f, -0.08240297f, 0.02832549f, -0.08121152f, 0.04566408f, -0.03516952f, -0.00420333f, 
    0.04155812f, 0.04478787f, -0.02240689f, -0.04474740f, 0.06489643f, -0.11839941f, 0.02406679f, -0.10891718f, 
    -0.13428113f, -0.04314953f, -0.15487476f, 0.03164555f, 0.01098830f, -0.01795251f, -0.05074967f, -0.04035181f, 
    0.01782583f, -0.06321009f, 0.01223784f, 0.03185539f, -0.00191796f, -0.00112316f, 0.05275414f, 0.05034947f, 
    0.13650198f, 0.20309995f, -0.00655068f, 0.03519580f, 0.00077024f, -0.00772050f, -0.02665930f, 0.03217354f, 
    0.05419677f, 0.00707203f, -0.03389847f, -0.04472755f, -0.06074965f, 0.04474749f, -0.06736054f, -0.01483335f, 
    -0.02253331f, 0.00874886f, 0.04369066f, 0.03623328f, -0.01319788f, -0.03692907f, 0.14458118f, 0.01527011f, 
    -0.05457280f, -0.05709356f, 0.04520876f, -0.06314142f, -0.02046119f, 0.05746774f, -0.04748315f, -0.00790567f, 
    0.00712397f, 0.02540861f, 0.00130097f, 0.01860959f, 0.00747926f, -0.04737861f, -0.04750632f, 0.05716044f, 
    0.28265178f, -0.19610585f, -0.14739218f, 0.02094522f, 0.05550364f, -0.04363094f, -0.00351935f, -0.02581150f, 
    0.02605172f, -0.01502809f, -0.02830087f, 0.02965620f, -0.09461184f, 0.05805491f, -0.04875691f, -0.01216814f, 
    0.00958003f, 0.01884015f, 0.01652581f, 0.00139416f, 0.21703023f, -0.04037900f, 0.13731374f, -0.02368820f, 
    0.00276361f, -0.02273934f, -0.07341831f, -0.04658197f, -0.03594281f, -0.03474210f, -0.00323223f, -0.03944584f, 
    0.01358704f, -0.03027007f, 0.04059679f, 0.00649482f, 0.05321717f, 0.01161483f, 0.01310060f, 0.02952272f, 
    -0.00357722f, 0.09318551f, 0.06841131f, 0.12039055f, 0.03866386f, -0.02148783f, -0.04185663f, -0.07320023f, 
    -0.05823079f, -0.05335842f, 0.04212227f, -0.02127367f, -0.01268664f, 0.01836254f, -0.05253896f, 0.01461796f, 
    -0.04204177f, 0.02213704f, 0.08426522f, -0.01532131f, 0.19825025f, -0.05806440f, 0.09833828f, 0.00678332f, 
    -0.01174017f, -0.12932576f, -0.08243690f, -0.02376573f, -0.07312535f, -0.01886079f, -0.02590116f, -0.09479630f, 
    0.04790691f, 0.01432271f, 0.00288595f, -0.07314302f, 0.01170587f, -0.00395939f, 0.03680605f, -0.03313582f, 
    -0.00191109f, -0.16194536f, -0.09628242f, 0.08483884f, 0.14123940f, -0.01745966f, 0.10540222f, 0.01108040f, 
    -0.03316935f, -0.01488440f, -0.01420325f, 0.06137717f, 0.01695227f, -0.07136129f, 0.02450599f, -0.02107577f, 
    -0.02850895f, -0.01497470f, 0.03975828f, -0.10739899f, 0.14541912f, 0.11429372f, -0.02167850f, 0.05234902f, 
    0.03415437f, 0.04422284f, -0.02459490f, 0.00594501f, 0.06637237f, 0.01791062f, -0.01719947f, 0.07130495f, 
    -0.03781767f, -0.00804850f, -0.00939299f, -0.05236927f, -0.03093581f, -0.01253291f, -0.03250661f, -0.04422858f, 
    0.05965273f, -0.23477659f, -0.20811749f, -0.01056762f, 0.13247617f, -0.07662793f, 0.10973983f, -0.02587256f, 
    0.03280892f, 0.07452732f, 0.08988387f, 0.03952261f, 0.05042684f, -0.07290831f, -0.00734756f, -0.03301281f, 
    -0.02919094f, -0.02356742f, -0.00902507f, -0.03410425f, 0.16012180f, 0.07440859f, 0.08740900f, 0.07000730f, 
    0.00092888f, -0.02561552f, -0.01236609f, 0.01187457f, -0.07795650f, -0.02649006f, -0.02966189f, -0.01377694f, 
    0.00582978f, 0.00401629f, -0.01579748f, 0.05495869f, -0.06496312f, 0.09590310f, 0.05836445f, 0.07212873f, 
    -0.10753437f, -0.23863475f, -0.20726196f, 0.06841972f, 0.02175836f, -0.04152195f, 0.04694051f, -0.00860363f, 
    -0.00290218f, -0.01485756f, 0.04634952f, -0.01854268f, -0.04683728f, 0.01098262f, -0.08681074f, 0.01227738f, 
    0.08346809f, 0.05487134f, 0.03679538f, -0.05280966f, 0.01786501f, -0.13202144f, -0.23555502f, -0.00537835f, 
    -0.01785901f, -0.05364864f, 0.09093007f, -0.04846809f, -0.00177262f, -0.02964495f, 0.03504203f, 0.06365505f, 
    -0.04788493f, -0.04607599f, 0.00446194f, 0.00527252f, 0.03368094f, -0.01689178f, 0.02647637f, -0.10451939f, 
    0.01035102f, 0.04340255f, 0.16011660f, 0.02528539f, 0.07439303f, -0.02138769f, 0.11092842f, 0.02545746f, 
    -0.02943631f, 0.09144125f, 0.06728171f, 0.03827182f, -0.09458927f, 0.00049344f, -0.02678734f, 0.05980831f, 
    0.03043769f, 0.01613409f, 0.05191528f, 0.02452953f, 0.13728878f, -0.01717035f, 0.06785820f, 0.04539980f, 
    0.02590630f, -0.00648291f, -0.07312380f, -0.05517262f, -0.01573181f, -0.00290045f, 0.01841635f, 0.01567510f, 
    0.01791071f, -0.05041575f, 0.01213797f, -0.11568050f, 0.01284079f, -0.04048058f, 0.03876759f, -0.01618571f, 
    0.18030174f, 0.18978322f, 0.11595983f, 0.22206029f, 0.03098364f, -0.02280528f, 0.05901111f, -0.02818204f, 
    -0.06877939f, 0.04842743f, -0.06966113f, -0.00100027f, -0.02566681f, -0.19820963f, -0.10877316f, -0.02576322f, 
    0.02356018f, 0.09707721f, 0.05785095f, 0.03457176f, -0.45330936f, -0.18137518f, -0.04430055f, -0.12621416f, 
    -0.15970023f, -0.09067731f, -0.10109870f, -0.10533296f, 0.01864249f, 0.01256305f, -0.03068176f, -0.06719840f, 
    0.10941630f, 0.00094935f, -0.02079013f, 0.01219609f, -0.03012789f, -0.06509429f, 0.01228738f, 0.03622333f, 
    -0.06773302f, 0.01108947f, 0.11620385f, 0.12108044f, 0.07084804f, 0.06351793f, 0.10129181f, -0.02439090f, 
    -0.11978297f, -0.04796721f, -0.09289479f, -0.01096469f, 0.00987164f, -0.04824138f, 0.10682202f, -0.01783327f, 
    0.07589404f, -0.03145877f, 0.01772046f, -0.14136614f, -0.01802801f, 0.01528347f, 0.03465839f, -0.04676811f, 
    0.02803307f, -0.05942828f, 0.03033914f, 0.01601860f, -0.00635460f, 0.03699847f, -0.08076597f, 0.02840833f, 
    0.04202956f, -0.02931706f, -0.06000786f, 0.02632412f, -0.04064757f, 0.04036668f, 0.04575323f, -0.00668333f, 
    -0.34691617f, -0.01675933f, -0.05573433f, 0.02028985f, 0.08894651f, -0.01153829f, 0.01852716f, 0.01234316f, 
    -0.00643172f, -0.06413224f, -0.05077149f, -0.00372393f, 0.01050432f, 0.01760490f, 0.02271463f, -0.01364990f, 
    -0.07036569f, -0.07052476f, 0.02529128f, -0.00098704f, -0.24121723f, 0.15518895f, -0.01024430f, -0.02708805f, 
    0.03659953f, -0.00090997f, -0.04080297f, -0.04495801f, 0.00567804f, -0.00348863f, -0.02704976f, -0.00123313f, 
    0.00609470f, 0.07492790f, -0.06819387f, -0.02699009f, 0.02204514f, -0.10979628f, 0.05394970f, 0.00106639f, 
    -0.35780066f, -0.03584878f, 0.00309278f, -0.08472277f, 0.00832187f, -0.03647888f, -0.03950428f, -0.02322318f, 
    0.00557658f, -0.06226014f, -0.04840256f, 0.01365626f, 0.04287783f, 0.01880279f, 0.04788766f, -0.03395103f, 
    -0.03973280f, -0.06102566f, 0.03379798f, 0.05643366f, -0.01245175f, 0.04291204f, -0.05072728f, 0.22184657f, 
    0.12436715f, 0.03886898f, 0.10336301f, 0.07728676f, 0.06756929f, 0.04647614f, -0.03093285f, 0.05149198f, 
    -0.01339773f, -0.13714117f, -0.05766476f, -0.01504231f, -0.08526384f, 0.06402883f, 0.07221992f, -0.07710516f, 
    0.09843591f, 0.12232736f, -0.11776776f, 0.12906207f, -0.04836640f, -0.05104164f, 0.01200294f, -0.00063121f, 
    0.06765190f, 0.05681241f, 0.03627270f, 0.00963102f, -0.02781384f, 0.07496835f, 0.00026094f, -0.04858468f, 
    0.02267430f, -0.00468126f, -0.05620197f, 0.05142771f, -0.17303182f, -0.10999999f, 0.02107619f, -0.12024928f, 
    -0.19175935f, -0.05198505f, -0.06753132f, -0.00793000f, -0.08640183f, -0.10136227f, 0.02826819f, -0.04507481f, 
    -0.00244257f, 0.03494732f, 0.04249175f, 0.08106375f, 0.02655300f, -0.07780836f, 0.05106492f, 0.03662707f, 
    -0.04157151f, -0.02797904f, -0.08975878f, -0.03617096f, -0.10084954f, -0.04273441f, -0.11400736f, 0.07748920f, 
    -0.02667512f, 0.04395026f, -0.05418172f, 0.00160887f, 0.06178455f, -0.01850528f, 0.02307436f, -0.02046539f, 
    -0.01401068f, 0.03911999f, 0.05012940f, 0.03061978f, 0.12376776f, -0.03247632f, 0.03466685f, 0.06840884f, 
    -0.04811898f, 0.01162822f, -0.03419161f, -0.07595702f, 0.03678270f, 0.02483178f, -0.06409076f, 0.02140149f, 
    -0.07896060f, 0.04456734f, 0.05334119f, -0.05436092f, -0.01741368f, 0.01852258f, -0.08081650f, 0.00501735f, 
    -0.06229560f, -0.02304863f, 0.00142965f, 0.04940720f, 0.01685967f, 0.03761982f, -0.03487401f, -0.05867928f, 
    -0.00642467f, -0.05395005f, -0.02905402f, 0.09114072f, -0.02250801f, 0.01719195f, 0.07339668f, 0.01623340f, 
    0.05711338f, 0.02166077f, -0.05718123f, -0.01910055f, 0.18372993f, -0.00241961f, -0.07843943f, 0.06515990f, 
    -0.08102883f, 0.01311133f, -0.02618642f, -0.02323624f, 0.01998570f, -0.10341761f, 0.05389018f, 0.00021737f, 
    -0.02345669f, 0.04278103f, -0.04711961f, 0.00396807f, 0.03752657f, -0.04621550f, 0.01839712f, -0.04876917f, 
    -0.22129373f, -0.40336835f, -0.21870577f, 0.13407959f, 0.12625657f, 0.00233579f, -0.03139460f, 0.02903380f, 
    -0.02339356f, -0.05867952f, -0.08190773f, 0.02710044f, -0.06422887f, -0.08027355f, 0.04926620f, -0.03164019f, 
    -0.06850979f, -0.04007072f, 0.00138974f, -0.06512225f, 0.04198837f, 0.04950621f, 0.14421071f, -0.04206232f, 
    0.15582448f, 0.05618292f, 0.15459836f, -0.01328064f, -0.05471326f, 0.12520626f, -0.00376676f, -0.01525937f, 
    0.06820989f, -0.07161722f, -0.04158678f, 0.02204653f, 0.02947362f, 0.06641608f, 0.05089543f, 0.04078778f, 
    0.22523075f, 0.19943425f, -0.08161318f, -0.01792774f, 0.01177716f, 0.00151940f, -0.03711033f, 0.03625019f, 
    0.03985186f, -0.00230247f, -0.00210155f, -0.05187974f, -0.04569731f, 0.02056095f, 0.03446523f, -0.04228262f, 
    -0.05599326f, 0.02750190f, 0.00143915f, -0.04357571f, 0.03966523f, 0.05019826f, 0.00513319f, 0.13723822f, 
    0.04378745f, 0.13111894f, 0.10396954f, -0.05671016f, -0.00877625f, -0.04061950f, -0.01893695f, 0.03253945f, 
    -0.09550594f, 0.02122031f, -0.04478866f, 0.04576437f, 0.03030029f, 0.02743023f, 0.00070975f, -0.02923515f, 
    -0.07349849f, -0.37764916f, -0.17266813f, 0.02391450f, 0.00590705f, -0.04422758f, -0.00695447f, 0.04250508f, 
    -0.03235535f, -0.05578663f, -0.02450918f, 0.02855164f, -0.06028168f, -0.00749559f, 0.01584052f, 0.01254443f, 
    0.01034652f, 0.01264636f, 0.01706831f, 0.01652934f, -0.00590169f, -0.46464372f, -0.20164731f, 0.10894436f, 
    -0.07250297f, -0.01443765f, -0.07424235f, 0.05554979f, 0.02193465f, -0.07076783f, 0.00425293f, -0.06893078f, 
    -0.04399893f, -0.01797781f, -0.07128666f, 0.05698714f, 0.01820350f, 0.05888061f, -0.02776542f, -0.01659854f, 
    0.20684950f, 0.16629514f, -0.12051897f, 0.05805885f, 0.03198094f, 0.05080732f, 0.07578517f, 0.00805314f, 
    -0.01110008f, 0.02402926f, 0.06069361f, -0.04365490f, -0.00295475f, -0.03990774f, -0.03281585f, 0.00624450f, 
    -0.00277037f, 0.05660634f, -0.02643663f, -0.05416226f, -0.08037931f, 0.00219139f, 0.02584134f, 0.00784611f, 
    0.07044639f, -0.04718294f, 0.05480682f, 0.05211508f, 0.01586207f, -0.00916933f, 0.02546494f, 0.04608513f, 
    -0.05680434f, -0.00746616f, -0.08320640f, 0.09359155f, -0.08018259f, 0.11422108f, -0.04085251f, 0.03434464f, 
    -0.28539222f, 0.31506839f, -0.10884234f, 0.12812023f, -0.01843887f, 0.03978266f, -0.05140741f, 0.02206907f, 
    0.05872452f, -0.11266912f, -0.08884184f, -0.02989841f, -0.06031063f, 0.03076144f, 0.01750437f, 0.05586346f, 
    -0.00329099f, -0.03070556f, 0.03289083f, 0.05147959f, -0.11849358f, -0.26450899f, -0.18415126f, 0.02032957f, 
    0.21222647f, -0.00277069f, 0.05043796f, 0.02350046f, -0.03010129f, -0.05024959f, 0.07781805f, 0.01835489f, 
    -0.06751286f, -0.00025202f, 0.01223321f, 0.05237373f, 0.00897789f, 0.03836648f, -0.03689259f, -0.00797655f, 
    -0.40323359f, -0.04692235f, -0.21681377f, 0.13132754f, 0.17544729f, 0.00986864f, 0.08928975f, 0.04354179f, 
    0.05008774f, 0.00516413f, -0.06131019f, 0.01607333f, 0.03413091f, -0.15854673f, 0.01122408f, -0.02091714f, 
    0.03370586f, 0.01085084f, 0.01944156f, -0.02955614f, -0.08591448f, -0.07077963f, -0.00498535f, -0.02137838f, 
    -0.05376963f, 0.06298246f, 0.03285383f, -0.01685206f, 0.01111249f, -0.04068708f, -0.07416586f, 0.04459879f, 
    0.02149248f, 0.02484230f, -0.01112251f, -0.05153324f, -0.00598075f, -0.05082592f, 0.03347699f, 0.08954701f, 
    0.18157451f, 0.18895784f, -0.05554615f, -0.02483021f, -0.00054582f, -0.07478502f, 0.02269767f, -0.04444756f, 
    -0.01157524f, -0.03246149f, -0.04614386f, -0.05551763f, -0.03492695f, 0.00498896f, 0.09056997f, -0.00061386f, 
    -0.03607142f, 0.12170133f, 0.00954116f, 0.04372115f, 0.40439093f, 0.28758663f, -0.00728462f, 0.02383159f, 
    0.05254159f, 0.03646483f, 0.09936184f, 0.06694818f, -0.00389592f, 0.04439703f, -0.03391389f, -0.05586244f, 
    0.00328364f, -0.03404783f, -0.04646437f, -0.01135771f, -0.00868732f, 0.06355095f, 0.03657693f, 0.07598446f, 
    -0.03027341f, 0.00701401f, -0.04559229f, -0.00659757f, -0.07364690f, -0.05271277f, 0.02215732f, 0.02332056f, 
    0.00483251f, 0.06227842f, 0.00251563f, -0.05289380f, 0.00985483f, 0.01640425f, -0.01960989f, 0.00186302f, 
    -0.00164656f, 0.01582085f, 0.00488043f, 0.04325931f, 0.21705733f, -0.06399725f, -0.07247806f, 0.03843506f, 
    -0.08320510f, -0.06614653f, -0.06264377f, -0.07442171f, 0.01971665f, -0.06587496f, -0.04417070f, -0.00597399f, 
    -0.02920959f, 0.00702769f, -0.05569171f, -0.02313467f, 0.02465351f, -0.03264507f, 0.05702529f, -0.00747185f, 
    -0.05299179f, -0.01206911f, -0.04131272f, -0.04653879f, -0.10417876f, -0.09634916f, -0.09171838f, 0.10653288f, 
    -0.09156536f, -0.01102218f, -0.06569122f, 0.03232553f, -0.09611055f, -0.00986864f, 0.02221687f, 0.02057580f, 
    -0.03600125f, 0.09452012f, 0.09968568f, -0.00388735f, -0.05445308f, 0.05822543f, -0.09607052f, -0.05762827f, 
    -0.01524366f, -0.06952231f, -0.10021899f, -0.07702964f, 0.06984787f, -0.02809202f, -0.07562218f, -0.05199560f, 
    0.06282511f, 0.02559810f, 0.04251703f, -0.06053228f, -0.07317868f, 0.06544398f, -0.02944401f, 0.04643452f, 
    0.16345116f, 0.13755514f, -0.16808362f, 0.06651689f, 0.00637909f, -0.04517165f, -0.03146954f, -0.01238487f, 
    0.10199898f, 0.00761116f, -0.05923534f, -0.02295850f, -0.07132935f, 0.05841903f, 0.09779458f, -0.00739892f, 
    -0.02563043f, 0.06196592f, 0.00739852f, -0.01664933f, 0.07369097f, -0.11106610f, 0.02809215f, 0.02051987f, 
    -0.01815424f, -0.01295729f, 0.01297703f, -0.02182327f, -0.05877835f, -0.01039459f, -0.08253056f, -0.02541250f, 
    -0.00723426f, 0.01670370f, 0.06881236f, -0.00218488f, 0.02780902f, 0.07333878f, -0.09267970f, 0.05231846f, 
    -0.08394484f, -0.15978229f, -0.08426040f, 0.17286733f, 0.09586419f, 0.02635310f, 0.02699768f, 0.07712118f, 
    0.02828448f, 0.01554062f, -0.08516674f, 0.03819889f, -0.05318726f, -0.09461980f, -0.00897841f, -0.03295964f, 
    -0.05283836f, -0.01686863f, -0.02703699f, -0.11753389f, -0.20524831f, 0.15572752f, -0.04116178f, -0.09401661f, 
    -0.05026653f, -0.05384597f, -0.04970809f, 0.14997481f, -0.00580349f, -0.04691151f, -0.07840502f, 0.03858671f, 
    -0.07211986f, 0.09538957f, -0.02227785f, 0.01283973f, 0.05915000f, -0.11060412f, 0.11177341f, -0.00536938f, 
    -0.32759842f, 0.04814663f, 0.02481872f, -0.08794611f, -0.04076288f, 0.01785530f, -0.01430426f, -0.03761366f, 
    0.05544844f, -0.09123576f, -0.01753699f, 0.01115110f, -0.07327538f, 0.01850008f, 0.02199597f, -0.06184204f, 
    0.06347136f, -0.14534123f, 0.03452770f, -0.02396854f, 0.06885205f, 0.09202533f, 0.11863833f, 0.17946716f, 
    0.02725293f, -0.02602506f, 0.11293481f, -0.00209560f, 0.04946961f, -0.03835507f, -0.01041973f, 0.03161654f, 
    -0.08815201f, -0.01145353f, -0.03697778f, 0.00118389f, -0.02270078f, -0.00524731f, -0.00949892f, -0.03533622f, 
    -0.05035803f, 0.19396789f, 0.01115733f, -0.05356582f, -0.10428796f, -0.08264873f, -0.00053970f, -0.00766767f, 
    0.07482935f, 0.02495269f, -0.00982557f, -0.00317005f, -0.06336536f, 0.02898813f, -0.03802027f, -0.00898245f, 
    -0.03235250f, -0.07764032f, 0.05036474f, 0.04402942f, 0.06285696f, 0.15955983f, 0.09468162f, 0.16121027f, 
    0.04980342f, 0.02097928f, 0.00661142f, -0.01482936f, -0.08080760f, 0.01060283f, 0.01532537f, -0.03080248f, 
    -0.05305038f, -0.03200913f, -0.06393030f, 0.02469798f, 0.01238136f, 0.05182272f, 0.06485637f, 0.00742649f, 
    -0.07724627f, -0.30719703f, -0.02198237f, -0.04749891f, 0.01545935f, -0.04749561f, -0.03530908f, -0.01598711f, 
    -0.06522790f, -0.04326509f, -0.02135240f, 0.04340804f, 0.06064323f, 0.04187704f, -0.01152569f, 0.05712434f, 
    0.00831451f, -0.03968784f, 0.01939573f, 0.04775027f, -0.27279812f, 0.21368660f, -0.07184445f, 0.09430867f, 
    0.14298731f, 0.05076015f, 0.06349184f, 0.02687948f, 0.01411204f, 0.01801481f, -0.01435546f, 0.00547739f, 
    -0.01661087f, -0.03153508f, -0.06059535f, -0.00061443f, 0.03767836f, -0.03742964f, 0.04113730f, -0.00450358f, 
    0.06484189f, -0.05715397f, 0.03431247f, -0.10887413f, -0.05374355f, -0.01621529f, -0.06864225f, -0.04718168f, 
    0.04100156f, 0.00374690f, 0.03264458f, -0.01759628f, 0.08820219f, 0.04880730f, -0.01486476f, -0.02429451f, 
    0.01470183f, -0.04766991f, 0.02199636f, -0.04663436f, 0.03671056f, -0.11454116f, 0.05174658f, -0.16222906f, 
    -0.14498241f, -0.00584064f, -0.10876320f, 0.04407609f, -0.00144720f, 0.01729268f, -0.05909498f, -0.00347727f, 
    0.05826275f, -0.06918607f, 0.01830038f, 0.02685757f, -0.00337685f, -0.02012133f, 0.03010357f, 0.09622077f, 
    0.04336782f, 0.03609281f, -0.03966056f, -0.02977240f, -0.04882303f, -0.16697100f, -0.00511132f, -0.12904668f, 
    -0.08540168f, 0.01144140f, 0.00027832f, -0.01474477f, 0.02143577f, 0.01520156f, 0.04827764f, -0.15282705f, 
    -0.01343748f, 0.01398985f, 0.02963920f, -0.09555290f, 0.06509723f, 0.05774101f, -0.16800970f, 0.03649542f, 
    0.02620268f, 0.14392439f, 0.02758805f, 0.03758227f, 0.09419621f, -0.02138184f, -0.02265767f, 0.07915351f, 
    0.06185330f, -0.08062688f, 0.00529972f, -0.05400812f, -0.09131794f, 0.10242842f, -0.05213746f, -0.01415617f, 
    -0.35335070f, 0.06953331f, 0.05783233f, 0.00612460f, 0.06987946f, -0.04869036f, -0.03368235f, -0.07783499f, 
    0.02978481f, -0.07021515f, -0.02780887f, -0.04434925f, 0.00538520f, 0.06400197f, 0.09775155f, -0.05645347f, 
    0.06844123f, 0.03954178f, 0.05292818f, -0.04753260f, -0.20660751f, -0.43013915f, 0.15385062f, 0.14462116f, 
    0.03979092f, -0.07347105f, 0.03025854f, -0.02566944f, 0.00228651f, 0.06559524f, 0.13137104f, 0.03420472f, 
    -0.00759153f, -0.11346120f, -0.01923997f, -0.07588584f, 0.02327497f, -0.05424931f, 0.09135901f, 0.06867057f, 
    -0.19285585f, 0.16947278f, -0.05300603f, -0.11972266f, -0.05625051f, -0.00716560f, 0.00844728f, -0.08142036f, 
    0.03576039f, -0.00244451f, -0.01808310f, -0.00560143f, 0.00748362f, 0.10500924f, 0.04668115f, -0.06763014f, 
    0.04205558f, -0.00364799f, -0.06936641f, 0.03044545f, -0.32955903f, -0.04488816f, -0.14164782f, 0.06001873f, 
    0.16530003f, 0.02416386f, 0.01655505f, 0.02491676f, 0.06753962f, 0.04185556f, 0.02259045f, -0.07851736f, 
    0.02338897f, 0.07229265f, 0.01416021f, -0.02902141f, 0.08517632f, 0.04555820f, 0.04276544f, -0.03680185f, 
    -0.28262463f, 0.00726605f, 0.06184791f, -0.12014403f, -0.13477747f, 0.06310017f, -0.03061344f, -0.01813131f, 
    -0.00706306f, -0.01575571f, -0.02813356f, 0.06551817f, -0.03722984f, 0.02496992f, 0.05046279f, 0.01594339f, 
    0.04225099f, 0.04932634f, 0.06476113f, 0.02428415f, 0.21437651f, 0.22985518f, -0.07907189f, -0.02400723f, 
    -0.39218953f, -0.00344171f, -0.03982321f, 0.03358301f, 0.04433404f, 0.03714531f, -0.07364440f, 0.01577450f, 
    0.06501018f, 0.02907153f, 0.06143414f, -0.04960339f, 0.00490836f, 0.07191296f, -0.08155438f, 0.01359163f, 
    -0.12149642f, 0.07467276f, 0.07331938f, 0.01738487f, -0.02852669f, -0.02616063f, -0.01065698f, 0.05421741f, 
    0.07426526f, -0.01203800f, 0.04918594f, 0.02166362f, -0.03946386f, -0.02224482f, -0.01499158f, -0.00923421f, 
    0.06073996f, 0.01644664f, -0.00241477f, 0.01447847f, -0.23944722f, -0.08164811f, -0.05106951f, -0.02281708f, 
    0.14214672f, 0.04723758f, -0.00666836f, -0.02473875f, 0.05774299f, 0.09648379f, -0.05235646f, 0.03166564f, 
    0.01152226f, 0.06093499f, -0.06877211f, -0.02963008f, 0.08107467f, -0.01209600f, 0.04322670f, -0.07809485f, 
    -0.02002922f, 0.06831677f, -0.03344545f, 0.08577791f, 0.05930892f, -0.00158112f, 0.04842064f, 0.02993710f, 
    0.05500901f, 0.04676793f, -0.07174288f, 0.16770710f, 0.06554375f, -0.00876500f, 0.00845402f, -0.03547186f, 
    -0.05099423f, -0.02967608f, 0.04414833f, -0.00543783f, -0.01736089f, -0.05369665f, 0.02730865f, -0.02372509f, 
    0.31028336f, 0.04474216f, 0.03521916f, -0.09375884f, 0.08589365f, 0.09633411f, 0.03036774f, -0.00746459f, 
    -0.04363685f, -0.02747934f, 0.00139340f, -0.01060546f, -0.02332348f, 0.00685619f, 0.05087512f, -0.01778247f, 
    -0.03181306f, -0.20983845f, 0.10657192f, -0.02251883f, -0.02037389f, -0.11964812f, -0.01116803f, 0.02008589f, 
    -0.08316383f, 0.04044785f, 0.05250190f, 0.01770130f, -0.11468905f, -0.04432889f, 0.00532489f, -0.01782644f, 
    0.02244799f, -0.02846811f, -0.00843278f, 0.04344811f, 0.09877198f, 0.11957218f, 0.02896450f, -0.28050750f, 
    -0.09703663f, -0.02949783f, 0.05165065f, 0.00927621f, 0.07197816f, -0.08326320f, 0.02559827f, -0.09826373f, 
    0.00285529f, 0.04474403f, 0.03393754f, 0.01236873f, 0.05245044f, -0.02890106f, -0.02914217f, 0.00896464f, 
    0.00206293f, -0.28127742f, 0.01918232f, 0.02444610f, -0.17485400f, -0.18572485f, -0.05051924f, 0.07025550f, 
    -0.10444507f, 0.02484511f, -0.05499414f, 0.04093942f, -0.02986224f, -0.09927532f, -0.02296022f, 0.08086094f, 
    0.01552446f, 0.06103682f, -0.04935640f, 0.06239563f, 0.04427160f, -0.11868151f, 0.03413827f, 0.11040916f, 
    -0.00154091f, -0.01987291f, 0.03474385f, -0.00077050f, -0.01188952f, -0.04610309f, 0.15089417f, 0.06751372f, 
    -0.01730173f, -0.04099019f, 0.04145751f, 0.02344440f, 0.00139780f, -0.05252166f, 0.07339059f, 0.09113654f, 
    -0.03267818f, 0.14729601f, 0.14386511f, 0.00571021f, -0.01759744f, 0.19962691f, 0.06621914f, 0.01135765f, 
    -0.03245798f, -0.02566427f, 0.09636424f, 0.01376136f, -0.04351260f, 0.00174458f, -0.09514738f, -0.02506359f, 
    0.02943545f, 0.02850815f, -0.05868287f, 0.01160886f, -0.14618702f, 0.08824273f, 0.07176410f, -0.22809616f, 
    -0.04614471f, 0.14092894f, -0.04503951f, 0.02610624f, -0.08421305f, -0.07209720f, 0.03257249f, -0.04072946f, 
    -0.09661435f, -0.05434784f, -0.11171881f, 0.01923124f, -0.08291809f, -0.15216729f, -0.06276850f, -0.05886931f, 
    -0.04064923f, 0.11731076f, -0.02347661f, 0.11034188f, -0.06597047f, -0.04810075f, -0.03288882f, 0.01323783f, 
    0.02483653f, 0.00270912f, -0.00339251f, -0.00355595f, 0.02012263f, -0.00381584f, 0.02407068f, 0.03198127f, 
    -0.01873906f, 0.08652691f, 0.06749279f, 0.10573192f, -0.34784049f, 0.02228903f, -0.04878079f, -0.01679749f, 
    0.04732123f, 0.05386093f, -0.03057377f, 0.02900003f, 0.07066665f, -0.02110967f, 0.00866672f, -0.03337925f, 
    -0.05715565f, -0.03550203f, -0.01707741f, 0.01059009f, 0.03901738f, -0.01172903f, 0.04628270f, 0.00819514f, 
    -0.00643474f, -0.07224613f, -0.03142729f, 0.18840306f, 0.05034649f, 0.02712941f, 0.02934736f, 0.04538434f, 
    -0.01934034f, -0.06558295f, 0.07046429f, 0.02696430f, -0.06557951f, -0.06425747f, 0.13565290f, 0.04260442f, 
    -0.00071092f, 0.07046101f, 0.02640949f, 0.11330091f, -0.00203098f, -0.01433565f, -0.09267046f, 0.04399006f, 
    0.05884002f, -0.01300067f, 0.03252339f, 0.00143682f, 0.05882701f, 0.00179380f, 0.00731672f, -0.11105385f, 
    0.06865989f, 0.04316201f, -0.06182744f, 0.04035959f, 0.07576864f, -0.07055393f, 0.02914441f, -0.02565278f, 
    0.13377538f, -0.01661926f, -0.06299130f, 0.05834997f, -0.03249756f, -0.01453341f, -0.10538652f, 0.06081993f, 
    -0.03274941f, -0.11934195f, -0.01375910f, 0.02750298f, -0.15378101f, -0.03506007f, 0.04036154f, -0.10360219f, 
    -0.10717142f, -0.12162417f, -0.00397906f, 0.01243586f, -0.09998261f, -0.14018320f, 0.07431193f, 0.02406944f, 
    -0.03752983f, -0.00173008f, 0.01666487f, 0.02577261f, -0.06562909f, -0.23798227f, -0.00716087f, -0.02743457f, 
    -0.04072000f, -0.00274216f, -0.00544154f, -0.03014878f, -0.01236879f, -0.02565573f, 0.00513275f, -0.03950024f, 
    -0.13779984f, 0.02942559f, 0.15481891f, 0.02635028f, 0.04698441f, -0.01664189f, -0.02376375f, 0.06175451f, 
    0.03088077f, -0.00077378f, 0.03099514f, -0.00671541f, 0.02779357f, -0.11296189f, 0.01460004f, 0.10910202f, 
    -0.03926966f, -0.06330991f, 0.00586167f, 0.03106892f, 0.13789451f, 0.22632179f, 0.01497787f, -0.00881476f, 
    -0.05947181f, 0.00405159f, -0.03968550f, 0.07638107f, 0.01134479f, 0.02610754f, 0.03615438f, -0.03795358f, 
    -0.01041122f, 0.03413329f, 0.06864163f, -0.04801363f, -0.03060004f, -0.02862295f, -0.08628149f, 0.01120793f, 
    -0.06278057f, 0.11235601f, 0.04447719f, -0.00630067f, -0.01411799f, -0.02283668f, 0.01999001f, 0.05627198f, 
    0.03500732f, 0.05240054f, 0.03361405f, -0.04270167f, 0.00796189f, 0.00049807f, 0.04213063f, -0.00345935f, 
    -0.01919787f, -0.05469869f, -0.05152914f, 0.05249295f, -0.16001551f, -0.33344597f, 0.15886727f, 0.13053907f, 
    -0.01257470f, -0.02210590f, -0.06243746f, -0.04659805f, -0.12193417f, 0.02281216f, 0.03537241f, 0.02694627f, 
    -0.02112493f, -0.02367621f, 0.08560637f, -0.10314566f, -0.09864625f, 0.05765403f, -0.04376347f, 0.01228410f, 
    0.07469611f, -0.10850411f, -0.14665198f, 0.20488216f, -0.05382969f, 0.07072393f, -0.04146675f, 0.07687680f, 
    -0.00558182f, 0.02750381f, -0.05670680f, 0.02812359f, 0.09879217f, -0.10573681f, 0.03243218f, -0.02519976f, 
    -0.04787037f, -0.01955779f, 0.01122614f, 0.07013839f, -0.12866525f, 0.16060460f, -0.02002735f, 0.06326703f, 
    0.13115618f, 0.11821502f, -0.00951770f, 0.07923225f, 0.01889667f, 0.06442463f, 0.00726266f, 0.08118267f, 
    0.04259906f, 0.06471974f, 0.00918363f, 0.10630828f, 0.04216364f, 0.01664009f, -0.04163830f, -0.05966574f, 
    -0.52852571f, -0.02042086f, -0.07004279f, 0.11229609f, 0.16201760f, 0.08281037f, -0.01430981f, -0.00941860f, 
    0.10258837f, 0.10131374f, 0.01661694f, -0.01893883f, 0.05358028f, 0.10611921f, -0.00987404f, -0.01049758f, 
    0.03706396f, 0.08005533f, 0.10300872f, 0.05002323f, 0.02692002f, -0.05542710f, -0.12763891f, 0.00702318f, 
    -0.31170908f, -0.12960330f, 0.02966768f, 0.03219426f, -0.02011321f, -0.09046147f, -0.00431491f, -0.05994859f, 
    -0.01224278f, 0.00269541f, 0.04278318f, -0.08976635f, 0.08302084f, -0.03404360f, -0.00803316f, 0.05413789f, 
    -0.39158276f, 0.09298295f, -0.02398526f, -0.10734807f, -0.05275249f, -0.00832117f, 0.06055849f, -0.03908480f, 
    0.04776024f, -0.03311221f, -0.00991916f, -0.06162287f, 0.06581376f, 0.05972891f, -0.00189990f, -0.02280203f, 
    0.01279382f, 0.06747128f, 0.06463376f, -0.10687236f, 0.12315176f, 0.17560756f, -0.09877280f, -0.08576164f, 
    0.02652967f, 0.05400979f, 0.03792045f, -0.03386638f, 0.07923732f, 0.04758099f, -0.09095825f, 0.00626558f, 
    0.00457403f, -0.00071310f, -0.01931648f, -0.05937959f, 0.00602959f, -0.06894778f, -0.03659627f, 0.05884883f, 
    0.01036558f, -0.22862147f, -0.09028167f, -0.04000846f, 0.04230941f, -0.07609506f, 0.01183125f, -0.03676843f, 
    -0.05493598f, 0.00918544f, 0.11653469f, -0.00953186f, 0.05998737f, -0.06546199f, -0.06398653f, 0.08911027f, 
    -0.07684022f, -0.03226556f, -0.01748041f, 0.01667009f, 0.01967673f, 0.03273197f, 0.08039735f, 0.10356845f, 
    -0.00609343f, -0.03169679f, -0.08331819f, 0.04631628f, -0.05108174f, -0.04887178f, -0.01711703f, -0.02975828f, 
    0.05403957f, 0.04596389f, 0.06844310f, 0.05743865f, 0.01440163f, 0.03681957f, -0.07460782f, 0.02037057f, 
    0.37811729f, 0.01051974f, -0.08942661f, -0.14371927f, 0.04599250f, -0.01471468f, 0.03635881f, -0.02154150f, 
    0.06922258f, -0.05262411f, -0.00996056f, -0.08305678f, 0.11143353f, -0.04555117f, -0.02226917f, -0.03974562f, 
    0.00176060f, -0.01733745f, -0.03541818f, 0.01553106f, -0.03961811f, 0.04177158f, 0.05651314f, 0.03631432f, 
    -0.12331931f, -0.06255820f, 0.05940866f, -0.02627874f, -0.01628775f, -0.03858703f, -0.01314878f, -0.11019625f, 
    -0.01336612f, 0.07001653f, -0.08486897f, -0.06129840f, 0.03963633f, 0.06441278f, -0.00349998f, 0.09370425f, 
    0.10140298f, -0.02581808f, -0.01469009f, -0.02259596f, 0.04111683f, -0.05222460f, -0.00564680f, 0.00343587f, 
    0.04276901f, 0.00407506f, 0.01885557f, -0.00311414f, 0.06415824f, 0.00977911f, -0.06842606f, 0.05798439f, 
    -0.02280491f, -0.05661066f, -0.02400500f, 0.01394825f, 0.05731240f, 0.22029929f, -0.13912082f, -0.22183739f, 
    0.05434318f, 0.01419530f, -0.03138040f, -0.03548393f, 0.06135084f, -0.05254287f, -0.01362537f, -0.02325132f, 
    0.07127437f, 0.08611610f, -0.01452520f, -0.00189677f, 0.04873350f, 0.00200008f, -0.02642063f, 0.00983757f, 
    -0.02274827f, -0.11474211f, 0.05831436f, 0.07153331f, -0.06649962f, -0.07005383f, -0.00960838f, -0.04786814f, 
    -0.04285195f, -0.02966807f, 0.00745105f, 0.01309708f, 0.01213873f, -0.04792744f, 0.06288207f, -0.05639270f, 
    -0.00850303f, 0.03349178f, -0.02399245f, 0.05979363f, -0.10991906f, -0.15766893f, 0.07010976f, 0.16011147f, 
    -0.00903715f, -0.02099022f, -0.01439317f, -0.00192095f, -0.08121651f, -0.15496370f, 0.09722333f, 0.10565947f, 
    -0.03568083f, -0.03264124f, 0.01120065f, -0.09572044f, 0.02403876f, -0.12637307f, 0.02308692f, -0.12697460f, 
    -0.51640517f, 0.18907349f, -0.04463599f, -0.27033880f, -0.07031211f, 0.00977258f, 0.06798188f, -0.00307784f, 
    0.05654623f, 0.11096978f, -0.03968016f, -0.09989204f, 0.13514136f, 0.05990279f, 0.05643503f, -0.01587464f, 
    0.07908019f, -0.02274346f, 0.02692015f, -0.07487258f, -0.05183946f, -0.18551525f, 0.18834570f, 0.18032996f, 
    -0.05168837f, -0.17021474f, 0.04740463f, 0.08249141f, 0.00749388f, 0.02695976f, 0.10221434f, 0.03494905f, 
    0.03327204f, -0.05808034f, 0.01188129f, 0.01953706f, -0.02691561f, -0.01215109f, -0.05040058f, -0.00112850f, 
    -0.34163126f, -0.24454261f, 0.14536031f, 0.14226650f, 0.06026429f, -0.09459291f, -0.00550217f, 0.04048779f, 
    -0.02094890f, 0.06952283f, 0.10039379f, -0.03179748f, 0.01112004f, -0.12793858f, 0.04095867f, 0.02391812f, 
    -0.07247888f, -0.04991938f, 0.08624552f, 0.05552511f, -0.10960104f, 0.08345279f, 0.20291483f, -0.06424937f, 
    -0.03890509f, 0.03610448f, 0.04166570f, 0.02782154f, -0.04524350f, 0.04660194f, 0.02827634f, -0.06229783f, 
    0.07285661f, -0.02296855f, 0.05728975f, 0.06250013f, 0.03707853f, -0.01212462f, 0.04200429f, -0.01187582f, 
    0.09100322f, -0.14043993f, 0.21240616f, -0.04483434f, -0.05760632f, 0.03336616f, 0.13413043f, -0.06991310f, 
    0.12110638f, -0.00633548f, 0.06174054f, 0.03332336f, 0.08159011f, -0.00926297f, 0.02158766f, 0.01534208f, 
    -0.04840717f, 0.06031557f, -0.01870176f, 0.05231882f, -0.08475698f, -0.12349281f, 0.14196885f, -0.04991587f, 
    -0.21430659f, -0.10835633f, 0.06624097f, -0.05702762f, -0.08433480f, -0.09428805f, -0.04241579f, 0.01560934f, 
    -0.00617707f, -0.01133055f, 0.03839260f, -0.08496002f, 0.13963725f, 0.12673618f, -0.02125330f, 0.07404937f, 
    0.11882271f, -0.05980323f, -0.23280880f, 0.21089284f, -0.06646550f, 0.07522406f, -0.00303021f, 0.03724954f, 
    -0.06040044f, 0.05259360f, -0.07931071f, -0.02311703f, 0.07207970f, -0.03247310f, -0.04198552f, 0.07081718f, 
    -0.00704168f, 0.00704103f, -0.03452864f, -0.00972584f, 0.02939278f, 0.26977003f, -0.11875720f, -0.14040926f, 
    -0.05712307f, 0.01394023f, 0.00503339f, 0.01323740f, -0.01083403f, -0.00800728f, -0.01248496f, 0.05827617f, 
    -0.07800799f, -0.01718303f, 0.05946614f, 0.03104465f, 0.06703495f, -0.00276420f, 0.00179927f, 0.00591171f, 
    0.02577717f, -0.07793882f, 0.01052950f, 0.06119901f, 0.16274634f, 0.08250118f, -0.03792962f, -0.01200035f, 
    -0.03684910f, 0.06514763f, 0.04040419f, -0.05243013f, 0.01008803f, -0.00978573f, -0.00635052f, -0.03392128f, 
    0.00644858f, -0.01056683f, 0.07313108f, -0.14890406f, -0.24076182f, 0.07026969f, 0.13202013f, 0.03558631f, 
    0.07829528f, 0.08240048f, 0.03508872f, -0.08333433f, 0.11497612f, -0.02050319f, -0.01414354f, 0.04242135f, 
    -0.06435561f, 0.01536035f, -0.01050268f, -0.02408734f, -0.03627102f, 0.01568587f, 0.09738713f, 0.01023855f, 
    0.04554151f, -0.29972854f, 0.00884623f, 0.02795787f, 0.07067478f, 0.05433667f, 0.04762133f, 0.07984658f, 
    0.02315765f, 0.03017971f, 0.03361791f, -0.06108887f, 0.00693114f, -0.01585862f, 0.08173694f, 0.09451462f, 
    0.02486413f, -0.06868409f, 0.11027359f, 0.10800704f, 0.05984490f, -0.01066544f, -0.10287237f, 0.02284338f, 
    0.06171110f, 0.03795502f, -0.03590013f, 0.01353239f, 0.01665073f, 0.00422043f, 0.02622622f, -0.00480251f, 
    -0.04891581f, -0.03459347f, 0.01497677f, -0.06539837f, -0.05847125f, 0.06362549f, -0.00408196f, -0.06061517f, 
    -0.19223174f, -0.29434419f, 0.09165812f, 0.10449202f, 0.03745328f, -0.05625865f, 0.00403482f, -0.06952655f, 
    -0.10542365f, -0.02549849f, -0.00211784f, 0.03862090f, 0.01003524f, -0.01132657f, 0.08095874f, -0.09621397f, 
    -0.08577669f, 0.03365010f, -0.06552909f, -0.03799985f, -0.20934150f, -0.04411177f, 0.01960387f, -0.01701375f, 
    0.15350607f, 0.00406732f, 0.04833358f, 0.04851558f, -0.06421074f, 0.01408780f, -0.04174434f, -0.00308394f, 
    0.04017153f, 0.04163125f, -0.04457429f, -0.03158278f, -0.00737973f, 0.05659777f, -0.00860088f, -0.08461620f, 
    -0.18009897f, 0.01953312f, 0.00724033f, 0.09241443f, 0.07911789f, -0.00689830f, -0.03172354f, 0.10690975f, 
    0.01265459f, -0.03608513f, -0.05044383f, 0.00879833f, -0.15538953f, 0.09142759f, -0.05663011f, 0.00313476f, 
    0.01465505f, -0.10685223f, -0.00430927f, -0.09291849f, -0.22848548f, 0.13451341f, -0.13257508f, -0.08798905f, 
    -0.34941697f, -0.05617966f, -0.10625502f, -0.04002995f, -0.10783129f, 0.05015321f, -0.02243701f, 0.03041026f, 
    0.03391763f, -0.01367893f, -0.05810020f, 0.04700884f, -0.08540868f, -0.00674596f, -0.01628987f, -0.01672549f, 
    -0.01040829f, -0.04804769f, 0.04867506f, -0.01939813f, -0.05124506f, 0.09288917f, 0.04855162f, 0.09997130f, 
    0.03857476f, -0.00847513f, -0.01574348f, 0.01197059f, -0.04670710f, -0.04268496f, 0.10779159f, 0.01408851f, 
    0.06021477f, -0.07073022f, 0.01018540f, -0.06070630f, 0.00632085f, -0.11018857f, 0.07366935f, 0.11508253f, 
    0.03406755f, -0.04888133f, 0.04205173f, 0.00626473f, -0.02815790f, 0.01088696f, 0.06526586f, 0.04578386f, 
    -0.06370287f, 0.02410853f, 0.05590535f, -0.01798853f, 0.02852073f, 0.05968926f, 0.02204588f, 0.00111281f, 
    0.22117548f, -0.06428313f, 0.10196263f, -0.01545013f, -0.01919345f, -0.05565178f, 0.03993712f, -0.09253660f, 
    0.04518519f, -0.00907678f, -0.04762421f, -0.03480298f, 0.02307601f, 0.03153977f, -0.02011944f, -0.10953650f, 
    0.08360741f, -0.13075949f, 0.00747654f, -0.03423453f, -0.33318284f, -0.04280185f, 0.16691460f, 0.17092623f, 
    0.05492746f, -0.03266647f, -0.08665644f, 0.06196876f, -0.05296354f, -0.07715866f, 0.02022115f, 0.02256036f, 
    -0.01333484f, -0.04910258f, 0.00717639f, 0.03904566f, -0.06391829f, -0.02886844f, 0.00878236f, -0.03794590f, 
    0.10070676f, 0.07562391f, -0.04670918f, -0.18062739f, 0.16986802f, -0.00902665f, 0.06165757f, -0.00335408f, 
    0.06528769f, -0.06221082f, 0.00567243f, -0.08368160f, -0.05293194f, -0.01373638f, -0.03855849f, 0.00382614f, 
    -0.07163426f, -0.09896992f, 0.09742068f, 0.00719292f, -0.43258619f, 0.04544442f, -0.00888721f, 0.12092598f, 
    0.20576496f, 0.10347002f, 0.00880521f, 0.02009988f, -0.01340254f, 0.08521871f, -0.04649434f, -0.00926841f, 
    0.04896337f, 0.01915357f, 0.08422784f, 0.03775067f, 0.02739866f, -0.01791729f, 0.03876914f, -0.07311660f, 
    0.00891655f, 0.05307709f, 0.02353528f, 0.01018141f, -0.09794954f, 0.03041868f, -0.03052789f, -0.00140200f, 
    -0.03300053f, 0.07801300f, 0.05722353f, 0.03373927f, -0.11598416f, -0.02943144f, -0.08820722f, 0.13854973f, 
    -0.07515955f, -0.09367561f, -0.01106156f, 0.11836164f, -0.29332522f, -0.12807691f, 0.08422078f, -0.09110244f, 
    0.08793849f, 0.07339494f, -0.06924080f, -0.11881605f, -0.03314660f, -0.00328507f, -0.00350277f, 0.04334879f, 
    -0.09556684f, 0.13352956f, -0.01726154f, 0.01140810f, 0.07159661f, -0.05181586f, -0.17449261f, 0.03813323f, 
    -0.09670277f, 0.24928796f, -0.24216761f, -0.00781171f, 0.02398295f, 0.04155084f, 0.06715473f, 0.07715070f, 
    -0.06179675f, -0.07980210f, -0.06142429f, -0.03868732f, -0.01480820f, -0.08485439f, -0.08207020f, -0.04419089f, 
    0.04667711f, -0.05210916f, 0.05653455f, -0.04719713f, 0.02991124f, 0.05328826f, 0.10494624f, 0.11270020f, 
    0.14481708f, -0.08959407f, 0.04884206f, 0.07353459f, 0.02963617f, 0.02574961f, -0.04798881f, -0.13645332f, 
    0.10013542f, 0.04040045f, 0.06200918f, -0.01597790f, -0.09305312f, 0.03009432f, 0.01996630f, 0.04826548f, 
    -0.06978289f, -0.09393387f, 0.06829390f, 0.12315725f, -0.04378449f, -0.03093066f, 0.02513427f, 0.02444663f, 
    -0.02101070f, 0.04489099f, -0.01479999f, 0.03533582f, 0.00792474f, -0.06836770f, 0.03006496f, 0.00136692f, 
    0.01769620f, 0.00196716f, 0.08746152f, -0.02849652f, -0.20142859f, 0.16872708f, -0.06863180f, -0.10425515f, 
    -0.21559604f, 0.00527784f, 0.03082960f, 0.14412269f, -0.11851829f, -0.11887437f, 0.05394605f, -0.03118100f, 
    -0.06414296f, -0.08386528f, -0.04566281f, 0.06508803f, -0.01766211f, -0.00279487f, 0.04015643f, -0.00480310f, 
    -0.37220737f, -0.04560022f, -0.08790259f, -0.14010221f, -0.00012542f, -0.02212438f, 0.05175972f, 0.11907995f, 
    -0.03380697f, -0.13666047f, 0.03974007f, 0.00060597f, 0.15411063f, -0.09799001f, 0.00989531f, -0.01045425f, 
    0.03779576f, -0.13196519f, 0.02995461f, 0.01688630f, 0.03441038f, 0.02271895f, -0.09384651f, -0.06163094f, 
    0.19072889f, -0.05227658f, -0.04163284f, -0.08247788f, -0.05528810f, 0.03539544f, 0.09848116f, 0.05685831f, 
    -0.06306697f, 0.03364935f, 0.00930003f, -0.00033438f, -0.00512720f, -0.00413387f, 0.01268413f, -0.08562585f, 
    -0.00504262f, -0.12113391f, 0.05662282f, 0.11000804f, -0.11346637f, 0.02232370f, 0.01315146f, -0.00825323f, 
    -0.03607038f, 0.03717125f, -0.08800593f, -0.05330278f, 0.04446533f, -0.00781116f, -0.00423391f, 0.01192608f, 
    -0.05862669f, -0.06327736f, 0.08609065f, -0.00335294f, -0.20242685f, 0.06753223f, -0.26656383f, -0.18723305f, 
    -0.23227064f, 0.10306510f, 0.03812212f, 0.10086658f, 0.04641432f, -0.09402824f, -0.01361552f, 0.03896992f, 
    -0.06172147f, -0.02407874f, -0.07743116f, 0.02912458f, -0.10566775f, 0.04071594f, -0.06372172f, 0.01886921f, 
    -0.13515036f, -0.03267844f, -0.14505607f, 0.08834432f, 0.09337012f, 0.04976534f, -0.08780929f, 0.04680941f, 
    0.01340507f, 0.11216172f, 0.02247266f, -0.03550410f, -0.06418746f, 0.01043758f, 0.07533894f, -0.06030390f, 
    0.02976376f, -0.00565033f, -0.12017158f, 0.01146109f, -0.24177104f, -0.18280257f, -0.20432343f, -0.02476135f, 
    -0.05839432f, 0.16649818f, 0.20567985f, 0.20453359f, -0.04965521f, 0.04729369f, -0.05511058f, 0.07276379f, 
    0.03372920f, -0.03642856f, -0.11119267f, -0.03973180f, 0.02254570f, 0.02183559f, -0.10624197f, 0.06586940f, 
    0.06316885f, 0.00260385f, -0.08972207f, -0.00432400f, 0.03489352f, -0.02165866f, 0.04760986f, -0.17181952f, 
    0.02673916f, 0.05103645f, 0.01608092f, -0.01602901f, 0.09567463f, 0.01442467f, -0.02457164f, 0.04095131f, 
    0.06714889f, 0.04747951f, 0.03725054f, -0.00744518f, -0.13998131f, -0.20999429f, -0.03203629f, 0.02335498f, 
    -0.02218291f, -0.06990491f, 0.07253196f, -0.01775979f, -0.05131431f, 0.04579892f, 0.00735703f, 0.07621681f, 
    0.02401797f, 0.02092730f, 0.09630381f, -0.00919665f, 0.02611778f, -0.04225076f, 0.06891796f, -0.10603332f, 
    -0.05395104f, 0.14051250f, -0.00283188f, 0.11848050f, -0.03708585f, -0.01589341f, -0.03875520f, -0.14910993f, 
    -0.03739596f, 0.08750147f, -0.11598575f, -0.07019514f, -0.01239855f, 0.07526748f, 0.03307153f, 0.06558427f, 
    -0.02720076f, -0.03870336f, 0.03396465f, -0.00392115f, 0.00387469f, 0.05315819f, -0.03991451f, -0.02628990f, 
    0.04819277f, -0.01489443f, -0.07523141f, -0.03361804f, -0.03016381f, 0.07040115f, 0.01839573f, -0.03915602f, 
    0.08277297f, 0.10015908f, -0.00300640f, -0.02529237f, -0.12137402f, -0.05666159f, -0.07837784f, 0.02884669f, 
    -0.01802279f, -0.04773628f, -0.04375989f, 0.21169280f, 0.09490190f, -0.01200764f, -0.02430645f, -0.02307713f, 
    0.00730552f, -0.00085021f, -0.00670074f, 0.02260142f, 0.02095037f, 0.02309569f, 0.00986560f, -0.02302111f, 
    -0.02592252f, -0.02762495f, 0.00606871f, -0.12418196f, -0.37560406f, 0.00325415f, 0.02231651f, 0.33322838f, 
    -0.04443730f, -0.03816251f, 0.05124737f, -0.08329216f, 0.00218886f, 0.08489668f, 0.16472456f, -0.02190201f, 
    0.03938003f, 0.00457282f, -0.00645951f, 0.01784030f, 0.01829283f, 0.00147855f, -0.06217787f, -0.14738278f, 
    -0.04223988f, -0.06542621f, -0.05079846f, 0.01857379f, 0.10336156f, -0.00821709f, -0.02869768f, -0.04448251f, 
    0.06065407f, 0.05756734f, 0.00264687f, 0.00891250f, 0.08172237f, 0.00950619f, -0.00480236f, -0.07461860f, 
    -0.07393385f, -0.07647188f, -0.06066617f, -0.14469458f, -0.40347838f, 0.05928528f, -0.20852423f, -0.10045636f, 
    -0.03822884f, 0.07865644f, 0.01464488f, 0.01347528f, -0.06284493f, -0.04271806f, -0.02191778f, -0.00157282f, 
    0.02719547f, -0.02312706f, -0.01508516f, 0.04887076f, -0.08310463f, 0.06846106f, 0.02971837f, -0.02122159f, 
    -0.00227250f, 0.04975425f, 0.01369595f, 0.06101367f, 0.19412789f, 0.00874814f, -0.03876571f, -0.09024818f, 
    0.00663796f, 0.06981923f, -0.02180262f, 0.00978699f, 0.19376983f, 0.14847139f, 0.09055385f, 0.06512214f, 
    -0.00788951f, 0.00260218f, -0.20445898f, 0.00153955f, 0.16690153f, 0.21076483f, 0.01929395f, 0.05106987f, 
    -0.10152928f, 0.02514658f, -0.11067989f, 0.00000258f, -0.10739106f, 0.06475306f, 0.01020900f, 0.06277073f, 
    -0.05967092f, -0.01368168f, -0.04114904f, 0.06465743f, -0.07292335f, 0.12279377f, 0.09667539f, 0.04768960f, 
    0.12167180f, -0.15296540f, -0.08071395f, -0.04295459f, 0.09325854f, -0.06566848f, -0.04328267f, -0.02559220f, 
    0.07900295f, 0.07937449f, 0.05696690f, 0.05296776f, 0.02970326f, 0.05250013f, -0.08073539f, -0.05799751f, 
    0.09110032f, 0.04882295f, -0.28679973f, 0.02633053f, -0.00640706f, 0.04524674f, 0.15711759f, 0.13163029f, 
    0.05447894f, -0.08521342f, -0.09699036f, 0.09006090f, -0.02230476f, 0.14235145f, 0.06503747f, -0.10716485f, 
    -0.04317213f, 0.05008245f, -0.00178752f, -0.02061425f, 0.03236201f, -0.18858793f, 0.05069685f, 0.07378806f, 
    0.03145366f, -0.01890680f, 0.01537875f, -0.00478467f, -0.21020131f, -0.06998557f, 0.07970242f, -0.05441078f, 
    0.03218764f, -0.01718945f, 0.00088250f, 0.05712347f, 0.04114575f, 0.06982200f, 0.06367817f, -0.10376823f, 
    -0.03344005f, 0.10530539f, 0.10436948f, -0.01091404f, -0.05447420f, -0.04444334f, 0.06590670f, 0.14670283f, 
    -0.35316426f, -0.03912186f, -0.03072207f, -0.03619826f, -0.02461348f, 0.00041213f, 0.05626420f, 0.04421589f, 
    0.00911430f, 0.07903015f, -0.03176060f, -0.05432422f, -0.04998748f, 0.02793953f, -0.01345082f, -0.10206152f, 
    0.05029186f, -0.06095187f, 0.02504916f, 0.04410964f, -0.17781766f, -0.06018638f, 0.04125510f, -0.04734824f, 
    -0.03497592f, 0.00958897f, 0.03523805f, 0.07842951f, 0.03762330f, -0.00059432f, -0.01519153f, -0.06761553f, 
    -0.01116849f, 0.08737352f, 0.08355312f, 0.01905603f, 0.02341036f, 0.02670580f, -0.07015745f, 0.12547345f, 
    0.20761439f, -0.11884108f, -0.11716755f, 0.02517713f, 0.16489655f, 0.06593835f, 0.02313023f, -0.15148911f, 
    0.01668980f, 0.11876878f, 0.12065236f, 0.01630102f, 0.16095020f, -0.10372774f, -0.11408951f, -0.09458367f, 
    0.06104156f, 0.08955327f, 0.15398376f, -0.20473467f, -0.12159865f, -0.00422824f, 0.02235452f, 0.01865495f, 
    -0.03766601f, 0.08366612f, -0.00671502f, 0.00521738f, 0.01156861f, -0.08587048f, -0.15006852f, 0.10715881f, 
    0.03053968f, -0.04193804f, 0.05144743f, 0.09833816f, -0.16174302f, 0.02718344f, 0.08723431f, -0.01262543f, 
    0.02775628f, 0.05472793f, -0.05587867f, 0.01584871f, 0.06489054f, -0.15517908f, 0.13950332f, 0.02993155f, 
    0.02303893f, 0.03345301f, 0.00772732f, 0.02835567f, 0.06655263f, 0.02938234f, 0.06260189f, 0.13000000f, 
    -0.18226847f, 0.16789868f, -0.20901974f, -0.15462694f, 0.00133809f, 0.06837853f, 0.08453359f, 0.02856155f, 
    -0.08204567f, -0.11272305f, 0.02657416f, -0.03751508f, 0.00434718f, -0.10450374f, 0.00402958f, 0.02382868f, 
    0.05993756f, -0.05812445f, 0.00310727f, 0.00394000f, -0.09605584f, 0.09888083f, -0.01059094f, 0.07850757f, 
    0.10539700f, -0.10902511f, -0.08044173f, 0.11112122f, -0.04760171f, 0.12493567f, 0.09889372f, -0.08215611f, 
    -0.00837728f, -0.01830406f, -0.10997472f, -0.02525303f, -0.00067836f, -0.11347151f, 0.13298115f, 0.05913891f, 
    -0.33870319f, 0.06585332f, -0.03199759f, 0.00674403f, -0.02871856f, 0.04929934f, -0.02383122f, -0.05736740f, 
    0.01610114f, -0.14595458f, -0.01593580f, -0.01486246f, 0.01704014f, -0.03259300f, 0.02563295f, 0.02253586f, 
    0.01201262f, -0.04732707f, 0.04137324f, 0.03089730f, -0.18515715f, -0.08946227f, 0.18056022f, 0.01894480f, 
    -0.09979402f, 0.00971209f, 0.01082551f, 0.03326965f, 0.00263065f, -0.02734678f, 0.01524698f, -0.01999690f, 
    0.00675442f, -0.15240036f, 0.05308439f, -0.02407711f, 0.05357210f, 0.08787885f, 0.02936951f, 0.05722811f, 
    0.00307347f, 0.09038439f, -0.00033714f, 0.08004161f, -0.13199182f, -0.08572747f, 0.01886560f, -0.05556598f, 
    0.01697645f, 0.01901389f, -0.03821740f, -0.00192569f, -0.08647723f, 0.03300068f, 0.10156738f, -0.01880081f, 
    0.09976321f, 0.14900275f, 0.01891626f, -0.08021522f, 0.03796709f, -0.11636362f, 0.07910257f, 0.08886369f, 
    0.08789454f, 0.05150872f, 0.05224340f, 0.01077381f, 0.11086705f, -0.07567731f, -0.11780319f, 0.05042657f, 
    -0.01937860f, 0.05654486f, 0.10278478f, -0.07306377f, -0.08434971f, -0.00785772f, -0.02108928f, 0.03620766f, 
    -0.22058743f, -0.07850873f, 0.13168904f, 0.09240032f, -0.11860649f, 0.01058912f, 0.03546442f, 0.04255265f, 
    -0.05612228f, 0.10408167f, -0.01347760f, 0.04569259f, -0.03982345f, 0.00839696f, -0.06876251f, -0.01903968f, 
    0.05200937f, 0.01007478f, -0.05385941f, 0.02688513f, 0.14112793f, -0.01794169f, -0.10420753f, 0.08442971f, 
    0.10050280f, -0.03224705f, -0.07707459f, -0.00701703f, 0.12399725f, 0.01066182f, -0.01268761f, 0.08943496f, 
    -0.04119174f, -0.05926274f, -0.02542146f, 0.05937175f, -0.13556419f, -0.01780913f, 0.00951979f, -0.03965138f, 
    -0.09806338f, 0.02767849f, 0.08977954f, 0.11247621f, -0.15754266f, 0.00155387f, 0.05406440f, 0.00211594f, 
    0.05601981f, -0.00737197f, -0.03418334f, 0.03111974f, -0.02126250f, -0.01453690f, 0.06451418f, 0.03520101f, 
    0.03152785f, 0.12198014f, 0.00426157f, 0.00982991f, -0.07315240f, -0.12893380f, 0.23781642f, 0.19159155f, 
    -0.07429791f, 0.14393817f, -0.02307354f, -0.02327323f, -0.00050231f, -0.09013620f, -0.01284312f, -0.02827474f, 
    -0.02792782f, -0.07348152f, 0.09415993f, 0.03131346f, 0.03684886f, 0.01261618f, -0.01310854f, -0.06589755f, 
    -0.00563627f, 0.01043344f, 0.05830192f, 0.18513961f, -0.01951069f, 0.03038802f, -0.04388732f, 0.02592172f, 
    0.02966925f, 0.06117234f, -0.00998892f, -0.02467381f, -0.04315887f, 0.05800165f, 0.00264842f, 0.05234041f, 
    0.09927576f, -0.08762389f, 0.09360941f, 0.01533300f, 0.10851653f, 0.06248973f, 0.07036502f, 0.06443956f, 
    -0.06320334f, -0.01865304f, -0.10842529f, 0.04904537f, -0.04832715f, 0.21644810f, 0.03813032f, -0.08229616f, 
    0.06478988f, 0.05438516f, -0.04527443f, 0.04649168f, -0.05730185f, -0.14751096f, 0.07904512f, 0.06039286f, 
    -0.05529715f, 0.10437641f, 0.09560449f, 0.05224022f, -0.13870104f, -0.01269129f, -0.00107755f, -0.06904491f, 
    0.03054908f, 0.01155977f, -0.04478088f, -0.02686524f, -0.00052373f, -0.05100724f, -0.07861537f, 0.09432679f, 
    -0.16687660f, 0.04841401f, -0.00235795f, 0.09082653f, 0.01706802f, 0.09664178f, -0.02180403f, 0.03382925f, 
    0.15842330f, -0.02661827f, -0.10451125f, 0.00705864f, -0.02319688f, -0.05104036f, -0.13881235f, -0.07510240f, 
    0.09653775f, 0.06912597f, 0.13141251f, -0.07727772f, -0.07216024f, 0.06831469f, 0.01597411f, -0.03857622f, 
    0.05816883f, -0.00693243f, 0.05475313f, 0.03905889f, 0.02181476f, -0.12356083f, 0.09301817f, 0.03696208f, 
    0.07167029f, 0.07830599f, -0.11705694f, -0.07692844f, 0.08074339f, 0.02639853f, 0.16022745f, -0.04010786f, 
    0.00550588f, 0.00805017f, -0.06261266f, 0.03711161f, -0.02918208f, 0.09747548f, 0.04818713f, -0.00069081f, 
    0.02003578f, 0.00382157f, 0.06510860f, -0.05226431f, -0.01174942f, 0.04126492f, 0.00499720f, 0.00642846f, 
    0.01317309f, -0.02718790f, 0.05989522f, -0.06754930f, -0.05516583f, 0.04961823f, -0.08347747f, -0.02457946f, 
    -0.27016938f, -0.05571536f, -0.06927686f, 0.00072260f, -0.04438829f, -0.08073062f, 0.08611877f, 0.06632558f, 
    -0.00594639f, 0.04629861f, -0.04194456f, 0.16542877f, 0.07798941f, 0.07820757f, -0.04643304f, -0.13046302f, 
    0.01423614f, -0.15215233f, -0.04913716f, -0.00152395f, -0.01680742f, -0.00507379f, 0.13185759f, 0.27492526f, 
    -0.13616887f, -0.05066015f, -0.13647269f, -0.00495724f, 0.04339238f, 0.13335900f, -0.02546175f, -0.04497517f, 
    -0.11696771f, 0.07807950f, -0.10845584f, 0.00919574f, 0.03048487f, -0.28192630f, 0.00441141f, -0.00677423f, 
    0.13428663f, 0.27821892f, 0.03007315f, -0.12519830f, -0.04815823f, 0.00066504f, -0.01734025f, -0.10927680f, 
    -0.04429974f, 0.03513174f, 0.03521730f, 0.05005011f, -0.04994027f, 0.00293151f, 0.00201889f, 0.07270504f, 
    0.01293469f, -0.01666412f, 0.07130343f, -0.00522481f, -0.13493213f, -0.23429173f, 0.16816874f, 0.10458905f, 
    -0.15244015f, 0.04335264f, -0.02214270f, -0.06014546f, -0.01198648f, -0.08950448f, -0.00597895f, -0.00619596f, 
    0.00943145f, 0.01370584f, -0.02395606f, -0.03043849f, 0.00035339f, 0.06011854f, 0.05364822f, -0.00716613f, 
    -0.39207143f, -0.07999199f, -0.19847402f, -0.06724875f, 0.05445872f, 0.02411127f, 0.05518053f, 0.08623017f, 
    -0.04843769f, -0.05041687f, 0.11386350f, 0.05407179f, -0.10966415f, -0.04670908f, -0.07903210f, 0.02499323f, 
    0.10460267f, -0.03232615f, -0.07253455f, 0.05317687f, -0.54078507f, -0.09602834f, -0.26263514f, -0.10398347f, 
    -0.03015806f, 0.06827354f, 0.11856670f, 0.03907611f, -0.04297545f, -0.03289190f, -0.03050205f, 0.12362916f, 
    0.12704578f, -0.02097967f, 0.06546789f, 0.06159939f, 0.01369079f, -0.00583897f, 0.04909374f, -0.18224257f, 
    -0.22608474f, 0.04064022f, 0.10667102f, -0.27897337f, -0.18567275f, 0.04776970f, 0.20721060f, -0.02469462f, 
    -0.06185486f, 0.06062757f, -0.05830831f, 0.02447809f, 0.13351780f, -0.10421209f, -0.13553567f, -0.04372029f, 
    0.06653890f, -0.00190951f, 0.01659750f, -0.09297924f, -0.27554849f, -0.20456982f, -0.07491042f, -0.03916402f, 
    0.04666145f, 0.04018107f, 0.01258152f, -0.00953372f, 0.03735869f, -0.12240137f, -0.03983597f, 0.02527502f, 
    -0.00597480f, 0.09483658f, -0.04756681f, 0.11879767f, 0.03020425f, -0.00288834f, -0.22846809f, 0.01887658f, 
    0.11974523f, 0.05057536f, -0.07761200f, 0.04743111f, 0.04583639f, -0.11783592f, -0.09032071f, 0.08798561f, 
    0.05090553f, 0.04482772f, -0.05722944f, -0.10675372f, -0.08345886f, 0.13754696f, 0.12244441f, 0.06846138f, 
    0.08192392f, 0.00723580f, -0.03232136f, -0.02775418f, -0.21067181f, 0.02523619f, 0.06566881f, -0.13244174f, 
    -0.00082292f, 0.02898504f, -0.01863253f, 0.10347521f, 0.00590919f, -0.17959809f, 0.13915487f, 0.07614442f, 
    -0.07745158f, 0.01883606f, 0.00926177f, 0.05593095f, -0.12301663f, 0.00550376f, -0.03058093f, 0.05531301f, 
    0.12193885f, -0.05112420f, 0.00288541f, 0.12556253f, -0.21636769f, -0.04699101f, -0.10009973f, -0.05043006f, 
    0.04547859f, 0.02995928f, 0.11584361f, 0.05317894f, 0.03517029f, 0.02443995f, 0.00711433f, -0.04552924f, 
    0.03181896f, 0.06413642f, 0.02027863f, -0.01562747f, -0.13496497f, -0.15044589f, -0.06510212f, 0.04272344f, 
    0.03294025f, -0.01469259f, -0.08612877f, -0.08759740f, -0.02050359f, 0.01995759f, 0.08605650f, -0.03096059f, 
    0.03260485f, -0.03120903f, -0.03043081f, -0.12600827f, -0.10933384f, -0.10012250f, -0.14931132f, -0.00722559f, 
    -0.20786490f, -0.12926298f, 0.03314060f, 0.12596785f, 0.01029219f, -0.06438288f, 0.08251093f, -0.02295568f, 
    -0.07295372f, -0.00622199f, 0.08057808f, 0.00422053f, -0.01139632f, 0.01953767f, -0.06709045f, 0.03138735f, 
    0.00918815f, -0.02729633f, 0.04240682f, 0.07047150f, 0.06650842f, 0.05539052f, -0.05655083f, 0.02593014f, 
    0.11169195f, 0.06216465f, -0.01771923f, -0.01535593f, -0.02173280f, 0.02855415f, -0.01986858f, 0.06642591f, 
    0.11354106f, 0.05052790f, 0.09625168f, -0.01406334f, 0.03121856f, 0.00140118f, -0.11192264f, -0.01012927f, 
    0.11149205f, 0.06258792f, 0.08667984f, 0.01494608f, -0.00816059f, 0.02727301f, -0.02224717f, -0.01465177f, 
    -0.05291817f, 0.06096543f, 0.01585025f, 0.01457322f, -0.00065837f, 0.07905214f, -0.07762044f, 0.03205189f, 
    -0.02626999f, 0.10486934f, 0.02891009f, 0.08413792f, 0.17391689f, 0.00134999f, -0.02484038f, -0.01806371f, 
    -0.08614191f, -0.07292582f, -0.03384797f, 0.01640436f, 0.02858210f, 0.02059585f, -0.03082790f, 0.02207856f, 
    -0.00282542f, 0.05888897f, 0.14945610f, -0.05672777f, -0.07032785f, 0.03663037f, 0.00842166f, -0.03322299f, 
    -0.31138775f, -0.17375727f, -0.08269381f, 0.06499813f, -0.03540171f, 0.03849372f, -0.01056338f, 0.06359784f, 
    -0.03242876f, 0.04428241f, 0.06630111f, 0.04253229f, 0.05396604f, -0.01230669f, -0.07979424f, 0.07031459f, 
    0.00705419f, 0.07335685f, -0.01933893f, -0.06374623f, -0.15750138f, 0.26137713f, -0.08564854f, -0.10301872f, 
    -0.12936044f, 0.04008368f, 0.05866094f, 0.07231914f, -0.09429467f, -0.15438057f, 0.01260040f, -0.05127986f, 
    -0.10326663f, -0.03763299f, -0.05651982f, 0.03522192f, 0.02327702f, 0.02540009f, 0.06388176f, 0.02066274f, 
    -0.19810027f, -0.02064416f, -0.00355687f, 0.09344497f, 0.05945755f, 0.06657815f, 0.09797853f, 0.00891841f, 
    -0.03822305f, 0.06194131f, -0.14832568f, 0.02995742f, 0.03401078f, -0.08444133f, -0.04065694f, -0.03156696f, 
    0.05128336f, -0.05056732f, 0.01046405f, -0.08322033f, -0.34862602f, 0.01781033f, -0.03893267f, -0.07427488f, 
    0.17297482f, 0.01190375f, 0.00774552f, 0.07814129f, -0.08658218f, -0.03243843f, -0.01012358f, -0.07308537f, 
    0.02641138f, -0.04039045f, -0.03097677f, -0.05992273f, 0.02849325f, -0.06152708f, 0.11596601f, 0.10939534f, 
    0.22510141f, -0.26218146f, -0.00252703f, -0.23448037f, -0.07222609f, 0.03212336f, 0.04192420f, 0.02557009f, 
    0.03819425f, -0.08483705f, 0.02782576f, -0.01391482f, 0.06613262f, 0.02799460f, -0.05937012f, 0.06931134f, 
    -0.02640603f, 0.04369257f, -0.11385775f, 0.12446523f, -0.19752744f, 0.30421555f, 0.20177780f, 0.07703018f, 
    -0.31767109f, 0.02035528f, -0.09877401f, -0.05191975f, -0.01168107f, 0.02792831f, -0.13570870f, 0.04677731f, 
    0.01445124f, 0.01250267f, -0.10166623f, -0.02189540f, -0.05857628f, -0.12698556f, 0.02222609f, -0.08914531f, 
    0.07316478f, 0.05370077f, -0.01946878f, 0.07046313f, -0.00198884f, -0.03742581f, 0.05105010f, 0.05356411f, 
    0.04384303f, -0.00839154f, -0.02288305f, -0.01669306f, 0.00381429f, -0.04837598f, -0.01623968f, 0.04621295f, 
    0.00066103f, 0.02349251f, -0.12095610f, 0.11038955f, 0.07192367f, -0.48616448f, -0.04460878f, -0.16442405f, 
    -0.05567975f, -0.01546962f, 0.02204138f, -0.01489529f, 0.03769021f, -0.00471857f, -0.08174470f, 0.01889193f, 
    0.05254001f, 0.08947344f, 0.04532387f, -0.02219004f, 0.02315649f, -0.07600297f, -0.11564791f, -0.00551429f, 
    0.10073307f, -0.21978617f, 0.03388758f, 0.08937271f, 0.12477142f, 0.00015467f, 0.13098155f, -0.07058137f, 
    -0.05302086f, -0.05334062f, 0.03742199f, -0.00891526f, -0.12063639f, 0.02901977f, 0.08567245f, 0.01582993f, 
    0.01583321f, 0.06942631f, -0.03866086f, 0.13026434f, -0.15538923f, -0.25246072f, -0.13277487f, 0.10650038f, 
    0.22808003f, 0.01250009f, 0.05594871f, -0.00040939f, -0.04540081f, 0.00389173f, 0.00581639f, -0.07523914f, 
    0.05354718f, 0.02587813f, -0.16004060f, 0.12054090f, -0.01259370f, 0.03599492f, -0.05707831f, 0.05942106f, 
    -0.17682932f, 0.19053896f, 0.02183848f, 0.03949814f, -0.17940389f, 0.01889490f, 0.06113269f, 0.05766076f, 
    0.05207672f, 0.00790049f, -0.00326724f, 0.01323900f, -0.02553063f, 0.00395760f, 0.03584003f, 0.02242498f, 
    -0.07097993f, 0.02752116f, -0.01674184f, 0.00463786f, 0.17521264f, -0.24964984f, 0.06000794f, -0.05000578f, 
    -0.00657634f, -0.01717833f, -0.02245467f, 0.03769540f, -0.07667225f, -0.01151347f, -0.02029345f, -0.11750361f, 
    0.08776123f, 0.01992226f, 0.10439447f, 0.01229236f, 0.03132238f, 0.01148547f, 0.05674508f, 0.01358179f, 
    0.08159980f, 0.15508050f, 0.00716088f, -0.28210625f, 0.07786493f, 0.03621827f, 0.02113689f, 0.00769909f, 
    -0.02722278f, -0.14207445f, 0.08700091f, -0.08079571f, 0.02584656f, -0.04439669f, -0.05101624f, -0.09304657f, 
    -0.09803916f, 0.09393725f, 0.05613462f, -0.02188996f, -0.33925486f, -0.13478233f, -0.06847096f, -0.27335238f, 
    -0.07882291f, 0.01963736f, -0.09506531f, -0.02638432f, -0.07196486f, -0.10348867f, 0.00681210f, -0.03818670f, 
    -0.05402800f, 0.07088621f, -0.01568667f, 0.00169522f, 0.00360705f, 0.04151926f, 0.11300365f, -0.11665314f, 
    -0.09448903f, 0.08940886f, 0.02065454f, -0.02760066f, -0.04882145f, 0.05772777f, 0.01589737f, 0.01973250f, 
    0.00583787f, -0.12427688f, 0.00614305f, -0.01582688f, 0.00528826f, 0.00607416f, -0.01596012f, 0.08407189f, 
    -0.04458209f, -0.01435741f, 0.01461200f, 0.02772156f, 0.20806254f, -0.08987937f, -0.01934467f, -0.04167218f, 
    0.12333278f, -0.02032667f, 0.06047442f, 0.02397994f, -0.05206522f, -0.08141004f, 0.04643487f, 0.00078058f, 
    -0.00020761f, -0.05518803f, -0.07609595f, 0.03540477f, -0.03203582f, 0.05497611f, -0.06488606f, 0.06487200f, 
    -0.21224475f, 0.23842818f, -0.07274529f, 0.09632137f, -0.21712439f, 0.09288199f, 0.05631132f, 0.00908476f, 
    -0.02469341f, 0.00989182f, 0.03864194f, 0.06465548f, 0.00763115f, -0.06277043f, -0.01151787f, -0.02674804f, 
    0.01683922f, -0.01566814f, -0.04360887f, 0.07660496f, -0.07423808f, 0.00458180f, -0.06788599f, -0.09211493f, 
    0.01937798f, 0.04678671f, 0.04979345f, 0.00375986f, 0.00868033f, 0.04272161f, 0.00800490f, -0.05735515f, 
    -0.04371761f, -0.00642553f, -0.02613597f, 0.03011384f, 0.06190123f, 0.09067005f, 0.05956789f, -0.03164150f, 
    -0.17062180f, 0.12881741f, 0.01634501f, -0.04634192f, 0.12610413f, -0.01970953f, 0.01392604f, 0.03208955f, 
    -0.00249305f, 0.02735206f, -0.05271077f, 0.02004181f, -0.00566305f, -0.00570619f, 0.15581925f, 0.02916843f, 
    -0.09164270f, 0.01799069f, 0.10261904f, 0.04703590f, 0.08648467f, -0.10145736f, -0.09439713f, 0.02444510f, 
    0.39112476f, -0.02553877f, -0.06283710f, 0.07831044f, -0.00619215f, -0.03901304f, -0.10487803f, 0.07263679f, 
    -0.08059227f, 0.04115046f, 0.07170074f, -0.09033986f, -0.06361302f, 0.12745692f, 0.07078915f, 0.11337693f, 
    0.01819572f, 0.03242913f, -0.11962034f, -0.13751677f, 0.08471061f, -0.01479491f, 0.05679893f, -0.04802155f, 
    -0.02046283f, -0.03513623f, -0.04139618f, -0.04337139f, 0.01135784f, 0.02270148f, -0.05920395f, 0.11177345f, 
    0.01919024f, 0.03837455f, 0.07157508f, 0.06716037f, 0.25468668f, -0.01832887f, -0.03474747f, -0.16260791f, 
    0.00407250f, -0.04991381f, -0.04585090f, 0.03237174f, 0.00106270f, -0.02064858f, 0.00455951f, -0.02905967f, 
    0.07796325f, -0.05060082f, -0.06863482f, -0.00900420f, -0.00346703f, 0.09409097f, -0.09297207f, 0.10362004f, 
    -0.17907095f, -0.11411786f, -0.40405303f, -0.46056452f, -0.09213562f, -0.12488799f, 0.05783583f, 0.06293277f, 
    -0.03043466f, 0.06883842f, -0.06712274f, -0.11661676f, -0.10792042f, -0.06123064f, -0.02561305f, -0.02838622f, 
    -0.03069307f, 0.04681728f, 0.16775170f, 0.04253270f, -0.08169627f, -0.02868901f, -0.10284649f, 0.13652068f, 
    -0.08153582f, -0.01439390f, -0.02997281f, -0.04676586f, 0.10601850f, 0.03335017f, 0.00488254f, -0.00128966f, 
    0.03622143f, 0.02976912f, 0.01208819f, -0.04332509f, 0.00168176f, -0.07023328f, -0.08992794f, -0.08308517f, 
    -0.18627064f, -0.06342689f, 0.04381263f, -0.16922382f, -0.12164737f, 0.00773252f, 0.07220343f, 0.07492602f, 
    -0.00854503f, -0.06067905f, 0.05018672f, -0.15188064f, -0.00311896f, -0.05091326f, 0.08171839f, 0.15392062f, 
    -0.05089988f, 0.04610175f, 0.12653883f, 0.04972162f, -0.14467581f, 0.09909693f, -0.02558576f, 0.06677712f, 
    -0.03666462f, 0.09784030f, 0.08808237f, -0.04339347f, 0.10029961f, -0.05297764f, -0.09188647f, -0.05380445f, 
    0.03267075f, 0.01492942f, -0.07627235f, 0.03145958f, 0.03174338f, 0.05862247f, 0.03434357f, -0.09369858f, 
    -0.09893706f, 0.14910677f, 0.07516100f, 0.06461844f, -0.15569387f, 0.01775854f, -0.10330886f, 0.03258254f, 
    0.00452959f, 0.05348152f, 0.00306583f, 0.06167621f, -0.01677919f, 0.01676415f, -0.08488553f, -0.02833378f, 
    0.02751584f, -0.05794182f, 0.00785641f, -0.07253982f, 0.13506985f, -0.05756790f, 0.03216529f, -0.08379702f, 
    -0.02219140f, 0.00363408f, -0.07710157f, 0.09850318f, -0.00640296f, 0.02880770f, -0.03582397f, 0.00005442f, 
    -0.05844187f, -0.09317132f, 0.01019835f, 0.00807151f, -0.00339611f, 0.01912845f, 0.12350827f, 0.00275406f, 
    -0.01110178f, 0.09439003f, 0.05782299f, 0.02520610f, -0.14602764f, 0.06342875f, -0.12491409f, 0.02806228f, 
    -0.01863313f, 0.02483438f, 0.00293149f, 0.00380079f, -0.03091809f, 0.02786374f, -0.05525806f, 0.00047162f, 
    -0.03238785f, -0.06523274f, 0.01242758f, -0.09169000f, 0.08844110f, 0.16241017f, 0.03603689f, -0.08529945f, 
    -0.05633115f, 0.00946128f, 0.04989065f, 0.04519019f, -0.04125557f, 0.02625145f, -0.03458854f, 0.02124115f, 
    -0.12050481f, -0.00721882f, -0.07679765f, -0.02844914f, -0.09544552f, 0.13570948f, 0.04788093f, 0.04282473f, 
    -0.04305145f, 0.13409418f, -0.10479681f, 0.12421274f, -0.11809466f, -0.09394374f, 0.08160639f, -0.00657101f, 
    0.00438332f, 0.01254940f, 0.04595320f, 0.01022376f, -0.06462630f, 0.02361280f, 0.00883478f, -0.06266738f, 
    0.01128232f, 0.05750221f, -0.00645392f, -0.07600752f, 0.06402374f, -0.51321369f, -0.19547237f, 0.14406572f, 
    -0.09676348f, -0.08853114f, 0.12446456f, 0.03368704f, -0.01116592f, 0.02432292f, 0.06043283f, -0.06436072f, 
    -0.01420767f, 0.01621819f, 0.07972693f, -0.12474064f, -0.01768562f, -0.06418487f, -0.13227606f, -0.14934531f, 
    0.12905306f, -0.32202846f, -0.00470354f, -0.32706088f, 0.09651535f, -0.07213619f, 0.02879379f, -0.07118192f, 
    0.00741540f, -0.05126921f, 0.02777008f, 0.05947008f, 0.06104961f, 0.12975155f, -0.03226008f, 0.04560551f, 
    0.03954947f, -0.05491631f, -0.06772299f, 0.05498556f, 0.03743678f, -0.06732911f, -0.17020364f, 0.19137993f, 
    -0.02754257f, -0.02285816f, 0.16132315f, -0.11610720f, -0.04615754f, 0.06551229f, 0.04518725f, 0.08063465f, 
    0.00060967f, -0.00786996f, -0.01239189f, 0.03787310f, -0.00586275f, 0.08314249f, -0.11732186f, 0.01190419f, 
    0.32897019f, -0.16437058f, 0.08908537f, 0.01745068f, 0.08953123f, 0.02040464f, 0.00091210f, 0.07029895f, 
    0.02001743f, 0.06042299f, 0.02120589f, -0.08148218f, 0.12902096f, -0.01014580f, 0.01340100f, -0.00717530f, 
    -0.01497193f, -0.01630624f, -0.08544083f, 0.01422618f, 0.14491366f, 0.04036224f, -0.10301575f, 0.15164235f, 
    -0.05091621f, -0.07692530f, 0.03580828f, 0.04430678f, 0.05372110f, 0.00008634f, -0.07276101f, 0.06320816f, 
    0.04705134f, 0.01281737f, -0.00507715f, 0.03466630f, 0.01993865f, -0.02142853f, 0.04061288f, -0.06539109f, 
    -0.12113231f, 0.19357789f, -0.03163253f, 0.14166166f, -0.02301254f, -0.04229568f, -0.04643392f, 0.01027605f, 
    0.03066704f, -0.09507114f, -0.04473985f, -0.00379028f, 0.01231955f, -0.03582166f, -0.07565738f, 0.01125481f, 
    0.04702405f, -0.05363652f, -0.00579966f, -0.00950555f, -0.15877625f, 0.10842601f, -0.22703083f, 0.07605541f, 
    -0.22893700f, 0.05638891f, 0.13190569f, 0.05205155f, 0.02315337f, 0.04532605f, -0.04500140f, 0.08084612f, 
    -0.06844907f, 0.05436574f, -0.06130657f, 0.00964637f, 0.05171022f, 0.01713788f, 0.07337907f, 0.04646265f, 
    0.08185293f, 0.02630446f, 0.09194332f, 0.03350914f, 0.03665335f, -0.08544534f, -0.08660761f, -0.11427006f, 
    -0.02799374f, -0.00502163f, -0.03557658f, -0.03530819f, 0.01582118f, 0.06926373f, 0.02284717f, 0.03512416f, 
    -0.00641113f, -0.01559880f, -0.03847234f, 0.04659330f, -0.01134260f, 0.01675245f, -0.01645286f, 0.01398597f, 
    0.04850132f, 0.03946754f, 0.05223588f, 0.01647924f, -0.06728072f, 0.00611876f, -0.01776930f, -0.00590638f, 
    0.02647892f, -0.03685041f, 0.06004535f, -0.00475610f, -0.00255229f, 0.08992656f, 0.08210821f, 0.03697240f, 
    -0.13479616f, 0.19708194f, -0.02504184f, 0.08105136f, -0.04702086f, -0.08803252f, -0.03087135f, 0.02404762f, 
    0.04517683f, 0.06040743f, 0.01650501f, 0.05498514f, -0.00533699f, -0.04132247f, 0.00127164f, -0.05173318f, 
    -0.01019495f, -0.09611186f, 0.01124803f, -0.09455033f, -0.07226143f, 0.16675605f, -0.13423213f, 0.14435028f, 
    -0.08775284f, -0.08137979f, 0.00224266f, 0.05239414f, 0.08565246f, 0.06761733f, -0.02563128f, 0.00130234f, 
    -0.03675336f, 0.03057670f, -0.00449773f, 0.03860523f, -0.05388372f, -0.03421434f, -0.11707008f, 0.00361705f, 
    0.01000260f, 0.02451457f, -0.10209826f, -0.02645944f, -0.06430923f, -0.02626712f, -0.02822300f, -0.01880449f, 
    -0.01468497f, 0.03455302f, -0.03125871f, 0.03739014f, 0.01963887f, 0.04631434f, -0.00434100f, 0.03165542f, 
    -0.02625163f, 0.04680511f, 0.03557325f, -0.02028818f, -0.07026257f, 0.05496914f, 0.01909442f, -0.05756842f, 
    -0.03070474f, 0.12866606f, 0.09481920f, -0.02191393f, 0.02920948f, -0.04485482f, -0.08699322f, -0.01832773f, 
    -0.07300274f, 0.03010761f, -0.03309967f, 0.05013677f, 0.00186358f, 0.08109336f, 0.01384444f, -0.07635652f, 
    0.49036124f, -0.13920175f, 0.00198269f, 0.20338213f, 0.12372764f, 0.02641545f, 0.04741362f, 0.01003158f, 
    -0.02299546f, -0.03102623f, 0.03031662f, 0.03034931f, 0.13170896f, 0.02133570f, 0.08531685f, 0.03335242f, 
    0.03936940f, -0.04973938f, -0.06413526f, -0.11419331f, -0.16283965f, 0.18602899f, 0.04003336f, -0.03319107f, 
    -0.39867285f, -0.07136294f, 0.02903692f, 0.06336320f, 0.03242871f, 0.02778762f, 0.03726454f, -0.02070059f, 
    0.05682463f, 0.02276112f, -0.05038712f, -0.03679134f, 0.02781813f, 0.01691788f, 0.03337494f, 0.08140942f, 
    -0.02372980f, 0.26077065f, 0.23058073f, 0.00762474f, -0.27037817f, 0.03808109f, -0.04875073f, -0.01972844f, 
    0.02217842f, -0.03373907f, -0.04794092f, 0.06559031f, -0.06448746f, 0.05546922f, -0.04679809f, 0.05501769f, 
    -0.08305520f, -0.09830800f, 0.02798765f, -0.05383234f, 0.08153216f, -0.08298597f, 0.04375623f, 0.03665492f, 
    0.20062549f, 0.08635770f, 0.00367762f, -0.05855236f, -0.01487689f, -0.09489422f, -0.04643724f, 0.02876311f, 
    -0.02827826f, 0.13454336f, 0.07233542f, 0.01704818f, -0.00413788f, -0.15185520f, 0.00454386f, -0.05260345f, 
    -0.00027217f, 0.04444103f, 0.12284049f, -0.01560191f, 0.22422206f, -0.06337671f, -0.06301134f, -0.12581857f, 
    -0.09692325f, -0.08897076f, -0.05915456f, -0.02809169f, -0.09074666f, -0.00355986f, 0.08584037f, 0.01102910f, 
    -0.02776251f, 0.01614517f, 0.05597057f, 0.11405508f, -0.07600875f, 0.01660462f, -0.04196897f, 0.08662341f, 
    0.04601021f, 0.10559306f, -0.00019338f, -0.08540794f, 0.00638960f, -0.00666397f, -0.08024564f, 0.07438941f, 
    -0.07324093f, 0.05008219f, 0.01509071f, 0.01296928f, -0.08299641f, 0.10302593f, 0.03062714f, 0.03624408f, 
    -0.19505170f, -0.03861103f, -0.13163187f, 0.13451344f, 0.04596968f, -0.03923373f, 0.03612357f, -0.01320717f, 
    0.01023477f, 0.04590714f, -0.00634399f, -0.03448913f, 0.01498687f, -0.00427236f, -0.02960530f, -0.01518349f, 
    -0.01358023f, -0.00826437f, -0.08465379f, -0.01267584f, 0.09819942f, -0.06047121f, -0.04161942f, 0.11604071f, 
    0.01283541f, 0.00345867f, -0.00293214f, 0.07657275f, 0.08410941f, 0.04506334f, -0.02851383f, -0.06961456f, 
    0.00660697f, 0.03544308f, -0.03582601f, 0.00953905f, -0.00362524f, 0.03081342f, -0.07468461f, 0.04590098f, 
    -0.46713978f, -0.17192194f, 0.00448691f, -0.23031358f, 0.12533745f, 0.04965048f, -0.13267528f, 0.06770325f, 
    -0.01076975f, 0.04490047f, -0.04838509f, -0.05837544f, 0.03799194f, 0.08526922f, -0.06619149f, 0.04729545f, 
    -0.06533707f, -0.10879713f, 0.04106332f, 0.07080387f, 0.12953548f, -0.02140385f, -0.06408387f, -0.21750095f, 
    0.07826747f, -0.09290259f, 0.00299521f, -0.03072234f, -0.11212973f, -0.11072054f, 0.07074273f, 0.01288172f, 
    -0.06893867f, -0.00424362f, -0.00208928f, 0.02976092f, -0.02620678f, -0.07770287f, -0.03610763f, -0.02388412f, 
    0.07628496f, 0.03734902f, -0.01374851f, -0.04804150f, 0.13407776f, -0.22795856f, -0.05770382f, -0.08286431f, 
    0.06224307f, -0.01394178f, 0.04879827f, 0.05057450f, -0.02949841f, 0.02414041f, 0.04972790f, 0.01674954f, 
    0.03394001f, 0.02920666f, 0.00841426f, -0.01714642f, -0.28469995f, -0.04343237f, 0.07429650f, -0.18955921f, 
    0.05038440f, 0.02881551f, 0.01242808f, 0.03041349f, -0.04002566f, 0.09139764f, 0.08246210f, -0.03250493f, 
    -0.00956399f, 0.06126402f, 0.02555959f, -0.05748690f, 0.03885701f, -0.04339008f, 0.16628742f, -0.04624213f, 
    -0.03963052f, 0.11380965f, 0.06459811f, -0.02381660f, -0.04848231f, 0.05920934f, 0.06463013f, -0.03147697f, 
    0.02561818f, 0.00128952f, -0.01340829f, -0.02968905f, -0.03019992f, -0.04628890f, -0.14195059f, -0.02129532f, 
    -0.02323029f, 0.07263524f, -0.05662640f, -0.09158009f, -0.18594864f, -0.31257948f, -0.05681250f, 0.15823430f, 
    -0.04455322f, 0.04096664f, 0.07324146f, 0.03798684f, 0.08604859f, -0.06639700f, -0.01205000f, -0.05185972f, 
    0.11369188f, 0.04231090f, 0.08106154f, -0.13006656f, 0.00063126f, 0.06640056f, -0.03272052f, 0.03467515f, 
    -0.03524946f, -0.05208873f, 0.09694585f, 0.01757181f, -0.03981823f, 0.04432134f, -0.04416548f, 0.01051951f, 
    -0.02782609f, 0.00621696f, 0.02076979f, 0.00464175f, 0.00301146f, -0.08279447f, -0.01276118f, 0.00204931f, 
    0.00967254f, -0.00231210f, 0.06193630f, -0.20543566f, 0.14949834f, -0.14874998f, 0.11010712f, -0.10720565f, 
    0.30269021f, 0.13390613f, -0.00838603f, 0.10816792f, -0.01774325f, -0.05807603f, -0.04965571f, -0.05390698f, 
    -0.08073916f, -0.02519570f, 0.02743886f, -0.03647913f, 0.07374283f, 0.11827213f, 0.04981499f, -0.02176785f, 
    -0.03734799f, -0.00107819f, -0.03193727f, 0.10511322f, 0.02263089f, -0.04163109f, -0.08853180f, 0.06445090f, 
    -0.03815982f, 0.02722414f, -0.02799150f, 0.05491793f, -0.01055358f, 0.01622400f, -0.03741501f, -0.03470255f, 
    -0.07592212f, 0.05699766f, -0.04715750f, -0.01515565f, 0.00401443f, 0.05289190f, -0.13604882f, -0.15749592f, 
    -0.03064406f, 0.07475199f, 0.01121379f, 0.03532064f, -0.00013406f, -0.00473033f, 0.00316849f, -0.04903689f, 
    -0.06117995f, -0.01720575f, -0.04923149f, 0.03020892f, -0.08994801f, 0.00919219f, 0.06193905f, 0.00960292f, 
    -0.24514504f, 0.06794890f, -0.03594876f, 0.10272989f, -0.06969684f, 0.06226631f, 0.04611786f, 0.00259998f, 
    0.05243322f, -0.01139133f, 0.01392559f, -0.03031305f, -0.02414456f, 0.02903855f, 0.16342638f, 0.09917232f, 
    0.02483826f, -0.14020638f, 0.00794199f, -0.12844899f, 0.02767926f, 0.10212626f, 0.12462495f, -0.06767115f, 
    -0.08671565f, 0.12872578f, 0.02760785f, 0.04252015f, -0.02839951f, 0.02236012f, -0.05200782f, 0.01046836f, 
    -0.11126082f, 0.00205488f, -0.07558809f, -0.02330625f, 0.06171922f, 0.00511479f, 0.03277231f, -0.00466479f, 
    -0.01406114f, -0.23226701f, -0.11901376f, -0.11191047f, -0.14474736f, -0.05984989f, 0.02322440f, -0.02805993f, 
    -0.04759845f, -0.04056874f, -0.00034354f, 0.03611519f, -0.11354342f, -0.00731346f, 0.06519082f, -0.01092251f, 
    -0.03110017f, 0.01119037f, -0.01235917f, 0.07244729f, 0.06031231f, -0.37925074f, -0.03269580f, -0.09571936f, 
    0.03279310f, -0.04020946f, 0.00325454f, -0.02971509f, 0.00164200f, -0.03518262f, -0.10115203f, -0.00374088f, 
    0.05008055f, 0.05626007f, 0.09387129f, -0.02566369f, -0.02993761f, -0.01397789f, -0.14208642f, -0.02774161f, 
    -0.14857605f, 0.05169084f, -0.11939406f, -0.08630673f, -0.17462552f, 0.04294618f, 0.01677080f, -0.04322911f, 
    0.02730264f, 0.01910157f, -0.07579590f, -0.06233954f, 0.02573202f, -0.00955741f, 0.00802185f, -0.03148453f, 
    -0.05094810f, 0.06211643f, -0.02434753f, 0.04771662f, 0.10316485f, 0.06507488f, 0.18131089f, -0.01439703f, 
    0.09623269f, -0.02520726f, -0.00701172f, -0.08766957f, -0.02115702f, -0.02690551f, -0.00503628f, 0.01251077f, 
    0.00866001f, -0.01541790f, -0.05445022f, 0.02397501f, -0.02272492f, -0.04104286f, 0.13387227f, -0.03593114f, 
    0.01739013f, 0.10012592f, 0.17083640f, 0.01257280f, 0.11590879f, 0.01214453f, 0.09083970f, 0.01905214f, 
    0.04523400f, -0.00580413f, 0.01431952f, 0.04711873f, 0.01050582f, -0.01702179f, -0.07746018f, -0.00262047f, 
    -0.06608035f, -0.03094845f, 0.00360846f, -0.06251800f, -0.21230516f, -0.15139045f, -0.27755496f, -0.08967979f, 
    -0.10966147f, -0.04681717f, -0.05667232f, -0.02267275f, -0.03677674f, -0.07956147f, -0.07928115f, -0.05719838f, 
    0.02801966f, -0.02630660f, -0.01733742f, -0.03604498f, 0.00553440f, -0.01195794f, 0.00114743f, 0.02836271f, 
    -0.15470375f, 0.13499449f, -0.16048090f, -0.00403311f, -0.02728968f, -0.00804715f, -0.07418437f, -0.01521279f, 
    -0.00236252f, -0.10244925f, -0.01935788f, 0.03274214f, -0.01805233f, 0.04350355f, -0.05191746f, 0.01889613f, 
    0.00407485f, -0.00485090f, 0.00336201f, -0.02156584f, 0.00564882f, 0.08052418f, 0.16848041f, 0.10271481f, 
    0.10093939f, 0.11080907f, 0.10083749f, 0.01407827f, 0.01100970f, -0.03635430f, 0.01396127f, 0.01114941f, 
    0.07881271f, -0.01211518f, -0.04968596f, -0.02095252f, -0.01281993f, -0.03153859f, -0.00863735f, 0.00632285f, 
    -0.13422063f, 0.06173256f, 0.15600853f, 0.03009961f, 0.06191200f, 0.05786302f, -0.01869703f, 0.05948056f, 
    0.04407741f, -0.02519912f, -0.04858042f, 0.06369250f, -0.00120122f, -0.00530627f, -0.05825074f, 0.01886281f, 
    0.04446777f, 0.01686585f, 0.01261084f, -0.00667004f, -0.10500704f, 0.13691545f, -0.07022920f, -0.06345574f, 
    0.01152236f, -0.00993317f, 0.14366414f, 0.00216625f, -0.03537959f, 0.01647976f, -0.10625666f, -0.02582181f, 
    -0.08488102f, -0.02846220f, -0.03468364f, 0.00507631f, 0.02967884f, 0.05571431f, -0.00350307f, -0.03470311f, 
    -0.18150976f, 0.08559979f, -0.00779846f, 0.01711888f, -0.05959190f, -0.00262859f, -0.12940185f, -0.01585916f, 
    -0.02243172f, -0.05304162f, -0.06501369f, -0.00095348f, -0.00343590f, -0.01064293f, -0.08022942f, -0.01190959f, 
    0.00166242f, -0.02220079f, -0.02886793f, -0.05384827f, 0.08540980f, -0.09641101f, 0.14021255f, 0.07422462f, 
    0.17505322f, 0.03206514f, 0.03512525f, -0.01007507f, -0.00226786f, 0.03369672f, -0.02396715f, 0.05072473f, 
    -0.01001089f, -0.00554643f, -0.00720735f, -0.00600845f, -0.00202902f, -0.01229562f, 0.03027003f, -0.00268339f, 
    0.15874907f, 0.04313698f, 0.12909813f, 0.07758873f, 0.09609606f, -0.04909484f, 0.10011733f, -0.03424232f, 
    -0.03845644f, -0.03227734f, -0.04511308f, 0.05124659f, -0.03093714f, -0.01926664f, 0.04184340f, -0.06480814f, 
    0.00396240f, 0.03195518f, 0.01189082f, -0.08348236f, 0.11255627f, 0.03423586f, 0.15830550f, 0.17502098f, 
    0.09563766f, 0.09974655f, 0.07980723f, 0.04541429f, -0.00675623f, -0.05096422f, -0.01011678f, 0.05955193f, 
    -0.02262413f, -0.05808295f, -0.00261267f, 0.00277314f, 0.05501687f, 0.01689685f, 0.04717649f, -0.03691844f, 
    -0.07565609f, 0.01145944f, -0.19348116f, -0.06621119f, -0.01323217f, -0.03017464f, -0.01873765f, -0.00786047f, 
    -0.02829963f, -0.01258080f, -0.02627762f, -0.00235072f, 0.04031708f, -0.04502954f, 0.01675620f, -0.06253827f, 
    0.00622208f, -0.01655652f, -0.01591683f, 0.04527231f, -0.04272602f, 0.12520504f, 0.04083600f, 0.12839051f, 
    0.04364397f, 0.02822095f, -0.00936473f, 0.02582421f, 0.02035790f, 0.01799201f, -0.01378785f, -0.03583075f, 
    0.01561464f, -0.07747426f, -0.00830234f, 0.01339027f, 0.00422213f, 0.01635162f, -0.00444520f, -0.00905155f, 
    -0.22300194f, 0.11519377f, -0.09873985f, -0.10194422f, -0.04417465f, 0.10288630f, -0.02474006f, -0.08132207f, 
    -0.01795890f, -0.01225332f, 0.00095773f, 0.03558989f, 0.03771751f, -0.07803254f, -0.01017830f, 0.00341243f, 
    -0.02187316f, 0.02729559f, -0.01437747f, 0.02647054f, 0.10035943f, 0.10869167f, 0.03014842f, 0.01453904f, 
    0.11887693f, 0.01947666f, 0.02528861f, -0.07405534f, -0.03269001f, 0.00462298f, -0.00541832f, 0.02795662f, 
    -0.03006607f, -0.02294434f, -0.00945305f, -0.05320594f, -0.00626035f, -0.01561817f, 0.04095917f, -0.05036396f, 
    -0.04559680f, 0.00263199f, -0.12495300f, 0.00907174f, 0.07661952f, -0.03232867f, -0.05700122f, -0.01987153f, 
    -0.02497911f, -0.04732645f, -0.11751907f, 0.05750743f, -0.04707722f, 0.02396271f, -0.04697840f, -0.00071762f, 
    -0.06380688f, -0.03071761f, 0.01022472f, -0.04511802f, -0.12332294f, 0.02635944f, -0.18581533f, 0.00258130f, 
    0.14476718f, -0.03320296f, -0.04170386f, -0.08381170f, 0.02457865f, -0.01195962f, -0.10239128f, 0.00743739f, 
    -0.04956574f, 0.02727200f, -0.01440613f, 0.04929530f, -0.08311334f, -0.01195233f, -0.02894379f, 0.03144553f, 
    0.02828241f, 0.12397892f, -0.03363217f, 0.05514308f, 0.10330328f, -0.10777054f, -0.01557211f, -0.03392616f, 
    0.00764310f, -0.04463042f, -0.09294121f, 0.01520767f, -0.02410584f, -0.00374193f, -0.01286832f, 0.05079202f, 
    0.01600689f, -0.03060472f, -0.05920756f, -0.00075591f, 0.04096235f, 0.06319977f, 0.16701438f, 0.06715828f, 
    0.17217812f, 0.00380440f, 0.09998694f, -0.03026558f, -0.00157654f, -0.01220950f, -0.00793716f, 0.06016422f, 
    -0.02067484f, -0.01616594f, -0.00950190f, 0.02299115f, -0.00265118f, -0.00726193f, 0.02016557f, -0.02397328f, 
    0.08710891f, 0.09110286f, -0.02929450f, -0.00523301f, 0.19278428f, -0.02797829f, -0.05878655f, -0.17512968f, 
    -0.08524705f, -0.04807025f, -0.00031252f, 0.05972049f, -0.04681806f, -0.02809860f, -0.04474629f, -0.03128475f, 
    0.03453653f, 0.04768616f, 0.03578452f, 0.04474672f, -0.07644065f, -0.08609653f, 0.00034309f, -0.08993287f, 
    -0.13691244f, -0.00513756f, -0.02149813f, 0.00778164f, -0.07492443f, -0.04843765f, 0.03904478f, -0.01872741f, 
    -0.03837598f, -0.00520841f, -0.00965368f, 0.00254662f, -0.05339649f, -0.01772216f, -0.00991799f, -0.02862814f, 
    0.16927972f, -0.04124459f, -0.06452242f, -0.01524573f, 0.06446549f, -0.02528144f, -0.01010440f, -0.09654688f, 
    -0.11348447f, 0.02168984f, -0.00817187f, 0.01957476f, 0.02233787f, -0.03374805f, 0.00358616f, -0.11328683f, 
    0.04215970f, -0.06238195f, 0.02501407f, -0.00241020f, -0.15516646f, -0.04640786f, -0.04086080f, -0.02801796f, 
    0.05515103f, 0.01377838f, -0.05568357f, -0.07176257f, 0.05203035f, -0.04419031f, -0.01731735f, 0.00533657f, 
    -0.03319482f, -0.02075790f, -0.01898054f, -0.01129774f, -0.06860188f, 0.01830254f, -0.01852325f, -0.01502392f, 
    0.05849190f, -0.25383389f, -0.00169309f, -0.13967414f, -0.15313683f, 0.07044080f, -0.04440679f, -0.03861617f, 
    -0.06212442f, -0.10714413f, -0.01734959f, -0.08430432f, -0.05829909f, -0.02973246f, -0.06312285f, 0.00294625f, 
    0.06779113f, -0.03962928f, -0.01113909f, -0.01298243f, 0.13058472f, -0.31112280f, 0.11126107f, 0.03643663f, 
    -0.07926107f, -0.00470510f, 0.00743163f, -0.04533309f, -0.02953430f, -0.01429962f, 0.00222045f, -0.04272927f, 
    -0.08466207f, 0.03662223f, -0.05610098f, -0.00817206f, 0.05776342f, -0.06024240f, -0.03891707f, -0.03681748f, 
    0.08161735f, -0.27971017f, 0.00894814f, -0.04883860f, -0.09715424f, 0.00352148f, -0.01004007f, -0.03124701f, 
    -0.08003256f, -0.03477617f, 0.02390632f, -0.04951974f, -0.09230847f, -0.03348128f, -0.04930069f, -0.01604754f, 
    0.02447093f, -0.01147844f, -0.04343453f, -0.02629327f, -0.02264647f, 0.09305684f, -0.21412347f, 0.03145733f, 
    0.19078349f, -0.13221772f, -0.07130526f, -0.06776992f, -0.05152060f, -0.02535893f, -0.10750018f, 0.01923068f, 
    -0.00553889f, 0.02210351f, -0.05049530f, -0.01998504f, -0.05099677f, 0.02423703f, -0.03292494f, 0.06536163f, 
    0.20864278f, 0.15479477f, 0.04446118f, 0.03097920f, 0.01524821f, -0.02273223f, -0.00640619f, -0.00339798f, 
    0.05086225f, 0.04987305f, -0.06226345f, 0.00526941f, 0.00684710f, 0.09420146f, -0.00308090f, 0.01375250f, 
    -0.03502973f, 0.00342754f, -0.03209646f, 0.02061930f, 0.09776311f, 0.00202768f, 0.01512410f, -0.05483469f, 
    -0.05176428f, -0.03559639f, -0.03516624f, -0.03496136f, -0.04232478f, -0.10770892f, 0.07212195f, 0.00426334f, 
    0.03213605f, 0.00947322f, -0.03855549f, -0.01417585f, -0.02216350f, 0.00018047f, 0.03653795f, 0.01172643f, 
    -0.05655616f, 0.12162030f, 0.18485215f, 0.07845643f, 0.09865731f, 0.05014168f, 0.06670108f, 0.04166067f, 
    0.03327681f, -0.00923619f, -0.03764952f, 0.01143791f, 0.00065816f, 0.00846253f, -0.04461050f, -0.00308887f, 
    -0.02360704f, 0.01473196f, 0.00126059f, -0.03868713f, -0.03863586f, 0.19661815f, 0.00879079f, -0.00767616f, 
    0.08685476f, -0.02809170f, 0.06742744f, -0.08652021f, 0.02510916f, -0.01388957f, -0.06858789f, 0.02461003f, 
    -0.00974808f, 0.00721169f, -0.07464886f, 0.00457974f, 0.00127391f, 0.08384482f, -0.00622260f, 0.00408752f, 
    0.12042181f, -0.02563107f, 0.03941083f, -0.09893247f, 0.09306113f, -0.10314441f, 0.03310319f, -0.02563162f, 
    0.01828920f, -0.03558698f, 0.02087111f, 0.02219982f, -0.08697139f, 0.00329124f, -0.03460862f, -0.02616372f, 
    0.00974024f, -0.00674125f, 0.01017781f, -0.06782290f, -0.06444354f, 0.09030731f, -0.07425303f, 0.02854108f, 
    -0.05268556f, -0.00196814f, -0.08814977f, -0.03857479f, -0.00192603f, -0.03545308f, -0.05210377f, 0.00422211f, 
    -0.00740335f, -0.02996483f, -0.02485798f, -0.00532621f, -0.01478814f, -0.00034008f, 0.00014258f, -0.03471940f, 
    -0.18811502f, -0.06512462f, -0.13211417f, -0.19808795f, -0.15061417f, 0.07841294f, 0.00039655f, -0.00904051f, 
    -0.03471862f, -0.05764128f, -0.03965601f, 0.01229772f, -0.05724522f, -0.01790883f, -0.04491664f, -0.03574951f, 
    0.05190832f, -0.02110320f, -0.00171098f, 0.03860982f, -0.03439450f, -0.03300124f, -0.04654584f, 0.04348590f, 
    0.16233011f, 0.02835195f, -0.06976577f, -0.07241992f, -0.00377605f, -0.02755944f, 0.04830291f, 0.01841604f, 
    0.01730786f, -0.02339074f, -0.01146948f, -0.02559627f, -0.04018208f, -0.03555030f, 0.00053365f, -0.02360713f, 
    -0.12060801f, 0.09621609f, 0.03562499f, 0.11741523f, -0.03947365f, 0.11878045f, -0.05067968f, 0.02036080f, 
    0.02780344f, 0.00819189f, 0.02103570f, 0.01507600f, 0.01379498f, -0.06947294f, 0.01173797f, 0.02355622f, 
    -0.04570794f, 0.04351770f, -0.04839361f, -0.06816333f, 0.07087764f, 0.05518277f, -0.14132696f, 0.01908258f, 
    0.09618116f, -0.01656798f, -0.04202557f, -0.09991777f, 0.02398075f, 0.00151389f, -0.07402816f, 0.01070361f, 
    -0.02960651f, -0.01666754f, -0.03347070f, -0.01672181f, 0.01439415f, -0.00457119f, 0.01538948f, -0.08902874f, 
    -0.09491961f, -0.04730341f, -0.12727256f, -0.14376420f, -0.12365027f, 0.04061235f, -0.02584854f, -0.03137614f, 
    -0.00665461f, -0.08106598f, -0.03060562f, -0.02251028f, -0.04949192f, -0.01601693f, -0.02424650f, -0.00688290f, 
    0.01080455f, -0.01046355f, 0.00116675f, 0.00516808f, 0.06064775f, 0.03003451f, -0.08014119f, -0.13771045f, 
    -0.01905943f, 0.03691376f, -0.06338903f, -0.01275450f, -0.01632614f, -0.09525499f, -0.00155650f, 0.03955076f, 
    -0.07987469f, 0.01966392f, -0.06146656f, 0.03779920f, -0.03518263f, 0.00130994f, 0.00590236f, -0.03176925f, 
    -0.19755326f, -0.01241598f, 0.03976080f, 0.02668459f, 0.01297882f, 0.02572908f, -0.05012123f, -0.12297906f, 
    0.03763224f, -0.02233119f, -0.01151101f, -0.00072490f, 0.00210332f, 0.01279180f, -0.00425137f, -0.03700874f, 
    -0.01059611f, -0.00161233f, -0.03404048f, -0.00024928f, 0.07372028f, -0.11812533f, 0.00901591f, 0.02041733f, 
    0.01830610f, -0.03061788f, -0.00520066f, -0.10099860f, 0.03747233f, -0.04427482f, -0.02835434f, 0.03423289f, 
    -0.01385779f, -0.04064096f, 0.00977044f, -0.09736545f, -0.00074181f, -0.05639175f, 0.01505092f, -0.01298339f, 
    0.31031862f, -0.21672687f, -0.02621626f, -0.10027175f, 0.12569118f, -0.12036024f, -0.01969075f, 0.01338534f, 
    0.00621847f, -0.01530894f, -0.02997473f, -0.03088873f, -0.05785272f, 0.06121135f, 0.00375921f, -0.04839450f, 
    0.09937823f, -0.01036181f, 0.01517093f, -0.07856724f, -0.14823300f, -0.00028949f, -0.18364115f, 0.07649857f, 
    -0.01690943f, -0.03361806f, -0.09925280f, -0.02148048f, 0.02322859f, -0.03254841f, -0.10006788f, 0.04783017f, 
    -0.00655725f, -0.03145847f, -0.05779630f, -0.00609838f, 0.02025657f, -0.05018543f, 0.01567559f, 0.01762370f, 
    -0.05570257f, -0.30885100f, -0.12560192f, -0.05811424f, -0.01193658f, -0.08977347f, -0.08005552f, -0.00436446f, 
    -0.04003666f, -0.02337997f, -0.05433361f, -0.04438658f, -0.00590693f, 0.00430750f, 0.01699929f, -0.01621378f, 
    0.00850641f, 0.01965503f, -0.00109008f, -0.00030950f, 0.02038806f, -0.07919952f, -0.02283924f, -0.03927986f, 
    0.00118490f, -0.07362572f, -0.02185592f, 0.02972566f, 0.03236853f, -0.00060130f, 0.03805894f, -0.03185925f, 
    0.01822494f, -0.00329322f, 0.05091078f, 0.04724526f, -0.05044179f, -0.01364783f, -0.00502380f, -0.02066368f, 
    -0.09314389f, 0.08883920f, 0.10391869f, 0.06927978f, 0.10796400f, 0.10197689f, -0.06932633f, -0.00145914f, 
    0.05658459f, 0.05078813f, -0.01086044f, 0.02992904f, -0.02899983f, -0.07063548f, -0.06104275f, 0.08570714f, 
    -0.03376778f, 0.08726116f, 0.04308890f, 0.00920015f, -0.30064514f, 0.07106774f, 0.06351037f, 0.11467837f, 
    0.09580735f, 0.04358756f, -0.13056712f, -0.09417298f, 0.12080815f, -0.02169661f, 0.01503002f, -0.03212312f, 
    0.05561719f, -0.02894387f, -0.05504940f, 0.02997277f, -0.07213701f, 0.04954176f, 0.00512822f, 0.00269132f, 
    -0.01257447f, 0.10005151f, 0.05531267f, -0.09535459f, -0.05634573f, -0.05810167f, 0.01828952f, -0.01015028f, 
    0.00832222f, -0.02106412f, -0.00682895f, 0.04146456f, -0.01709707f, 0.01641279f, 0.00557465f, 0.01603251f, 
    -0.04189030f, -0.05064582f, -0.01974388f, 0.00930237f, -0.07877008f, 0.00750715f, -0.08834871f, -0.04985971f, 
    -0.14364432f, 0.06395946f, -0.00845686f, 0.02164077f, -0.03013809f, -0.08045948f, -0.03649369f, 0.02330020f, 
    -0.02376571f, 0.04198508f, -0.06292702f, 0.05327015f, 0.02551826f, 0.00263221f, -0.01318607f, -0.06155793f, 
    0.16338162f, -0.11870662f, 0.22310928f, -0.00917584f, 0.02102259f, 0.11244339f, 0.03523544f, 0.04484503f, 
    0.02284875f, 0.05467352f, -0.01934436f, 0.07780017f, -0.00158844f, 0.00600134f, -0.02103426f, -0.03499073f, 
    0.00138408f, -0.01531258f, 0.03386797f, 0.02591197f, 0.07300340f, 0.01489624f, 0.16530012f, 0.12490001f, 
    0.05993837f, 0.06297600f, 0.10903839f, 0.03346775f, 0.03721939f, -0.04107102f, -0.04847050f, 0.06508295f, 
    -0.02780453f, -0.03195160f, 0.02064799f, -0.06540712f, 0.04544318f, 0.02577217f, -0.00884638f, -0.02743788f, 
    0.14977229f, 0.19207899f, 0.04511978f, 0.21933033f, 0.16015108f, -0.00971180f, -0.01905120f, 0.10010692f, 
    0.04746536f, 0.07048361f, -0.04426846f, 0.05873160f, 0.02553572f, -0.00211305f, -0.04799163f, 0.01850113f, 
    0.03097608f, 0.06161402f, 0.02723946f, -0.01623978f, 0.07613849f, 0.00503985f, 0.07906892f, -0.02341962f, 
    0.04840457f, -0.04717690f, 0.00417215f, -0.05774671f, 0.01582859f, 0.02520088f, 0.04602057f, 0.06271873f, 
    0.01370719f, -0.04510029f, -0.03188547f, -0.02070116f, -0.02905649f, -0.05327532f, 0.05714943f, -0.05932365f, 
    -0.15561785f, -0.07795197f, -0.09060696f, -0.01567602f, -0.03263263f, 0.00681238f, -0.06782863f, -0.04805722f, 
    -0.04929344f, -0.05643123f, -0.05449259f, 0.00793319f, 0.02391054f, -0.02490352f, -0.00488897f, -0.08543096f, 
    -0.00091118f, 0.02712001f, 0.00705758f, 0.08812240f, 0.08654719f, 0.01053495f, 0.16446942f, 0.04926231f, 
    0.00968173f, 0.05501954f, -0.00008053f, 0.02394158f, 0.04032578f, -0.06039226f, 0.01059069f, 0.01636004f, 
    0.06126648f, 0.01446078f, -0.08128530f, 0.00632677f, -0.07141522f, -0.00672827f, 0.04422968f, -0.04026439f, 
    0.14654593f, -0.27140871f, 0.07503638f, 0.01334655f, -0.14721859f, 0.07090205f, 0.04444794f, -0.03493830f, 
    -0.02792830f, 0.02518884f, -0.01139829f, -0.03364316f, -0.05265365f, 0.01950916f, -0.06838434f, -0.01437463f, 
    0.08326466f, -0.02460381f, -0.04067488f, 0.01672497f, -0.01355308f, 0.18315721f, -0.02480476f, 0.08164439f, 
    0.08207384f, -0.05096415f, 0.03747601f, -0.09403722f, 0.03381725f, 0.00434054f, -0.10699607f, 0.01899135f, 
    -0.03292932f, -0.05349359f, -0.02263408f, -0.00291112f, -0.03086177f, 0.06625298f, -0.01634995f, 0.01339913f, 
    -0.00057120f, -0.12716694f, 0.02177972f, -0.02598034f, -0.08919392f, 0.01454684f, -0.09551901f, 0.01808958f, 
    -0.04217882f, -0.00990203f, 0.00883274f, 0.04760726f, 0.00982376f, 0.03054143f, -0.03903024f, 0.01877363f, 
    0.03010653f, -0.02673795f, -0.06928736f, 0.04467902f, 0.06109262f, 0.05143811f, -0.02093941f, 0.01261270f, 
    0.10210709f, -0.00742993f, -0.00498719f, -0.04317255f, -0.05564989f, -0.01669130f, -0.03125928f, 0.03377313f, 
    -0.02321828f, -0.00663110f, -0.04974544f, -0.02107061f, 0.02159381f, 0.01944857f, 0.01588970f, -0.01412392f, 
    -0.00645294f, -0.09764867f, -0.13714337f, -0.12921821f, -0.13358457f, -0.02831150f, -0.02084563f, -0.01975293f, 
    -0.03957362f, -0.04004430f, 0.02765619f, -0.01257633f, -0.01382261f, -0.00707588f, -0.04097973f, -0.02426095f, 
    -0.05023282f, -0.03543799f, -0.03940333f, 0.01901908f, 0.04221101f, -0.32459095f, 0.08108387f, 0.00991594f, 
    -0.06749384f, 0.02190706f, -0.03915473f, -0.05721484f, 0.00345988f, -0.01400822f, -0.00586421f, -0.00631478f, 
    -0.01526072f, -0.03563558f, -0.04616745f, 0.00526622f, 0.05474713f, -0.01832279f, 0.01967363f, -0.01243216f, 
    0.04809807f, 0.02311587f, 0.11375596f, 0.09611409f, 0.14152339f, 0.06831567f, 0.04577350f, 0.00517987f, 
    0.01080241f, 0.02837807f, -0.04929413f, 0.01489385f, 0.00510281f, -0.09168958f, 0.03796572f, -0.04259946f, 
    -0.05532067f, 0.01757593f, 0.00110052f, 0.02311807f, 0.06686452f, -0.05185666f, 0.15667775f, 0.10557002f, 
    0.03231879f, 0.02519520f, 0.11392078f, 0.00301399f, 0.04200793f, -0.07347093f, 0.04998413f, -0.01105234f, 
    0.00385486f, 0.00635626f, -0.01958583f, -0.02054543f, -0.03244622f, 0.02063534f, -0.02642145f, -0.03290279f, 
    0.02296641f, 0.17085373f, -0.07293607f, -0.02403037f, -0.05939090f, 0.09431817f, 0.01459947f, -0.04009695f, 
    0.00433210f, -0.05050833f, 0.10292300f, 0.04302835f, 0.02241910f, 0.02745372f, -0.06342369f, -0.13197058f, 
    -0.01245745f, 0.00887118f, 0.05613929f, -0.00759064f, -0.16081798f, 0.12446640f, 0.15372339f, -0.15616868f, 
    -0.12739353f, 0.04145269f, 0.00505457f, -0.01359804f, 0.02307420f, -0.08230827f, 0.00157448f, 0.03352527f, 
    0.01312131f, 0.08401410f, 0.03613468f, 0.01110058f, -0.01724044f, -0.01461027f, -0.15429094f, 0.09443057f, 
    0.00334799f, -0.08333144f, 0.10190222f, -0.03542561f, 0.03815900f, -0.04979362f, -0.04049477f, 0.02378176f, 
    -0.13150238f, 0.05643651f, 0.01972953f, -0.02803880f, -0.00558900f, -0.01162795f, 0.04505594f, -0.00730796f, 
    -0.00373195f, -0.01227534f, 0.09835122f, -0.01519795f, -0.00602773f, -0.26692766f, -0.12537092f, 0.02875844f, 
    0.19443913f, 0.14054693f, 0.13212839f, -0.03600053f, -0.05851609f, -0.03951002f, 0.03230380f, -0.00382505f, 
    -0.01371971f, 0.04334025f, -0.03435465f, -0.05384642f, 0.13479537f, 0.11674151f, 0.02199173f, -0.00747528f, 
    0.08895471f, -0.02385843f, -0.07939028f, 0.06121106f, 0.06716006f, 0.02887267f, 0.01260835f, -0.03460086f, 
    -0.01904136f, 0.02984015f, 0.06288236f, -0.04561578f, -0.01001355f, -0.01811495f, 0.09496302f, -0.02757256f, 
    -0.00904320f, 0.03182152f, 0.04842234f, 0.01422369f, 0.00379943f, -0.08754111f, 0.13258645f, 0.04527198f, 
    0.15110162f, -0.10349298f, -0.03415534f, -0.00506935f, -0.10957876f, 0.05808701f, 0.02401800f, -0.05033914f, 
    -0.09698501f, -0.08551014f, 0.02056977f, -0.00101145f, -0.01683913f, 0.02679873f, 0.06128953f, 0.01991531f, 
    0.07244430f, -0.05049269f, -0.02026833f, 0.03177473f, -0.14093535f, -0.02106884f, -0.04662852f, -0.04457587f, 
    -0.03109559f, 0.01262974f, -0.00442188f, -0.05210368f, -0.06176040f, -0.01015386f, 0.00779308f, 0.06952676f, 
    -0.00542650f, -0.05871794f, 0.00468834f, 0.01922074f, -0.01570194f, 0.14531848f, 0.04727706f, 0.06173528f, 
    -0.10160077f, -0.07132278f, -0.00176479f, -0.03043167f, -0.07807790f, -0.04521414f, 0.06340195f, 0.00280101f, 
    0.03392117f, -0.09043806f, 0.00692002f, -0.04680450f, -0.07134452f, -0.02262672f, 0.08711449f, 0.00435885f, 
    0.06034845f, -0.04210429f, -0.19538915f, 0.09172747f, 0.11708717f, 0.05282686f, 0.00012313f, -0.10027051f, 
    -0.01111151f, 0.01705672f, 0.00510680f, -0.02368171f, 0.00075114f, -0.06608626f, 0.07173327f, -0.03979297f, 
    -0.00579001f, 0.02097237f, 0.07286588f, 0.03079886f, -0.16356030f, -0.15523426f, 0.21086687f, -0.03454226f, 
    0.11043976f, -0.01995972f, 0.00628321f, 0.01128892f, -0.05296895f, -0.01741324f, 0.03954817f, 0.00257078f, 
    0.00407355f, -0.00430667f, 0.07564678f, -0.00376686f, 0.03127265f, 0.08840569f, -0.07976332f, 0.05578873f, 
    -0.13211839f, -0.02752366f, 0.03951244f, -0.19329356f, -0.12437120f, -0.03665004f, -0.00870190f, -0.01522270f, 
    -0.00341290f, -0.04168895f, 0.02453804f, -0.02527041f, -0.08103565f, 0.14039554f, 0.03057723f, 0.02270081f, 
    0.07143317f, -0.11371750f, -0.15898567f, 0.04577099f, -0.22734569f, -0.15462644f, 0.22698538f, -0.06950426f, 
    0.01504744f, -0.06246563f, 0.00772549f, 0.07078918f, -0.06724154f, -0.07193585f, 0.05167788f, -0.05003931f, 
    0.05921759f, -0.01121278f, 0.06508664f, 0.03690882f, 0.05889240f, 0.05566470f, -0.24289405f, 0.01208282f, 
    -0.08237489f, 0.05979954f, -0.07886118f, -0.05230134f, -0.01750039f, 0.05327654f, 0.02454617f, -0.02904346f, 
    0.01066752f, -0.00136879f, -0.00530941f, -0.00750987f, -0.02816750f, 0.01897494f, -0.03653822f, -0.06299943f, 
    -0.01880977f, 0.04359858f, 0.04880295f, -0.06193403f, -0.10253006f, -0.15218188f, 0.09347253f, -0.12377378f, 
    -0.15559755f, -0.08456842f, -0.02570488f, 0.05822280f, 0.02048101f, -0.02238205f, 0.08182116f, 0.03062779f, 
    0.02093265f, -0.01945455f, 0.00969635f, -0.02093933f, -0.06463695f, -0.04355556f, 0.02922233f, 0.02263976f, 
    -0.10918704f, 0.09752735f, -0.16421324f, -0.01111128f, -0.00848531f, 0.05462800f, 0.03762978f, -0.07901225f, 
    0.01115763f, -0.01799764f, 0.01753380f, 0.00655846f, -0.00289819f, 0.04447616f, 0.04792502f, -0.01474163f, 
    -0.04455946f, -0.01135677f, 0.10628606f, -0.05522549f, -0.19281007f, 0.02311261f, -0.11210865f, -0.22349158f, 
    -0.24206765f, -0.03865406f, -0.07580167f, -0.02751786f, -0.00185781f, -0.02410785f, 0.08308255f, -0.03127682f, 
    0.03821390f, -0.00256460f, 0.03900993f, -0.04671225f, 0.06202607f, -0.06492999f, -0.06705353f, 0.02555727f, 
    -0.07687695f, 0.08971986f, 0.11303823f, 0.04218343f, 0.02472224f, 0.00325788f, 0.05717825f, -0.06236469f, 
    -0.04878302f, -0.03548260f, 0.02903848f, 0.00223426f, 0.05647355f, 0.01758019f, -0.09589974f, -0.10900316f, 
    0.00247432f, 0.02838897f, -0.04992891f, -0.11706505f, -0.02195593f, 0.20312671f, 0.03504025f, 0.00519949f, 
    0.00128766f, -0.01623327f, -0.03594981f, -0.05391808f, -0.11820404f, -0.09058587f, 0.05243143f, -0.03002970f, 
    0.02888296f, 0.05617748f, -0.11757006f, -0.11611255f, 0.02935266f, 0.00927582f, -0.03679419f, -0.10247897f, 
    -0.08218400f, 0.01763101f, -0.01708741f, -0.06415293f, -0.10726683f, -0.03278484f, 0.03661855f, -0.02428283f, 
    -0.04176420f, -0.09213535f, 0.04963100f, -0.03804969f, 0.00889458f, 0.01093699f, 0.00665371f, -0.04158251f, 
    0.07710717f, -0.02080806f, -0.01245838f, -0.02309738f, -0.20253535f, -0.15707503f, 0.18970017f, -0.06173784f, 
    -0.00306688f, 0.03475657f, -0.03727199f, 0.00527564f, -0.08632117f, 0.05059604f, 0.04529528f, 0.02632145f, 
    0.02650086f, 0.00615006f, 0.00420541f, -0.05385715f, 0.01283158f, -0.01267977f, 0.03133918f, 0.01932451f, 
    -0.16657083f, -0.11030883f, 0.00837713f, -0.34135303f, -0.24643405f, -0.00850813f, -0.07472201f, -0.03895720f, 
    0.06047624f, -0.08443327f, 0.07773029f, 0.05938814f, -0.08450651f, -0.06063431f, -0.09767396f, -0.05821425f, 
    0.06071891f, -0.01223893f, -0.17425053f, -0.03384156f, 0.12900402f, 0.17669936f, -0.09952422f, 0.09357595f, 
    0.09649977f, 0.03466598f, 0.00369336f, -0.06378941f, -0.05100028f, -0.01429741f, -0.05093412f, 0.01247369f, 
    0.00692548f, -0.00810053f, 0.04785264f, -0.07308306f, 0.00580372f, 0.01606238f, 0.05733673f, -0.03147119f, 
    -0.03275467f, -0.08571173f, 0.07282999f, -0.20089392f, 0.03041332f, 0.05702512f, 0.01848193f, 0.09195051f, 
    -0.00437500f, -0.03888524f, -0.06175756f, -0.03961315f, -0.01465471f, 0.08761138f, 0.05339194f, -0.00692012f, 
    -0.08656456f, 0.06649718f, -0.11030614f, 0.05226589f, 0.04406249f, 0.12458485f, -0.23253067f, 0.00054879f, 
    -0.02685964f, -0.01184888f, 0.05232475f, -0.00088431f, -0.04679770f, -0.03504967f, -0.06113770f, 0.05130085f, 
    0.07628125f, -0.00602549f, 0.01647265f, 0.06139549f, -0.04180415f, -0.11785716f, 0.01251534f, 0.05177227f, 
    0.10827860f, -0.13365752f, -0.02776875f, 0.06385902f, 0.13342254f, 0.04482530f, 0.02014088f, -0.02427172f, 
    -0.06163946f, -0.00308113f, -0.02409506f, 0.02110204f, -0.04260378f, 0.02382183f, 0.01422783f, -0.00121414f, 
    -0.00183062f, 0.07921084f, 0.05212087f, 0.02005967f, 0.03450244f, -0.05968896f, 0.05897789f, 0.04111391f, 
    0.10887495f, 0.00082347f, -0.00105735f, -0.03910920f, -0.07031623f, 0.03465577f, -0.03794757f, 0.00405845f, 
    0.00269973f, -0.06304082f, 0.02048041f, -0.02704255f, -0.01316807f, 0.02467301f, 0.03683739f, -0.06714854f, 
    0.11731223f, -0.00114659f, -0.03304074f, 0.09229606f, 0.08228268f, 0.05706261f, 0.01570725f, -0.05525948f, 
    -0.05484099f, -0.02648075f, -0.00625420f, 0.00130839f, -0.01134572f, -0.02741361f, 0.00325601f, -0.00012579f, 
    -0.01743327f, 0.03400037f, 0.04360901f, 0.03511062f, -0.02402244f, 0.00878807f, -0.05202867f, -0.22450672f, 
    -0.05742462f, 0.05263008f, -0.00426480f, -0.04547802f, -0.03853073f, -0.08920272f, 0.03092279f, 0.05350830f, 
    -0.00640596f, 0.02130125f, -0.04839500f, 0.03419157f, 0.09213192f, -0.00673233f, -0.09169442f, 0.02669984f, 
    -0.02786998f, 0.02083956f, -0.06797159f, -0.08382093f, -0.07995681f, -0.01570044f, 0.00016917f, -0.11244757f, 
    -0.00485696f, -0.08601189f, 0.10609444f, 0.00001439f, 0.04129421f, -0.12777750f, 0.07165577f, -0.04362279f, 
    0.02288754f, -0.06500236f, 0.10256871f, -0.05050365f, 0.12571707f, -0.00959994f, 0.01338125f, 0.09989452f, 
    0.15129656f, -0.08273985f, -0.06748995f, 0.00921951f, -0.02675862f, 0.03865536f, -0.06015432f, -0.05227083f, 
    0.00482750f, 0.02098391f, -0.02539817f, 0.07545540f, 0.01541097f, -0.00339140f, 0.02622555f, 0.09012860f, 
    -0.07388859f, -0.01576440f, 0.18377829f, -0.02706561f, 0.07198542f, -0.01293740f, -0.05257897f, 0.00933807f, 
    -0.08224750f, 0.02683397f, 0.03357308f, -0.03587734f, -0.06326512f, -0.09316240f, 0.00951648f, -0.00451507f, 
    -0.01745694f, -0.01138195f, 0.03613805f, -0.00503558f, -0.05125255f, 0.08174975f, -0.17449610f, 0.02747032f, 
    -0.07531517f, -0.06610098f, 0.06735502f, -0.09249993f, -0.04497074f, 0.00032603f, 0.09179337f, 0.06685510f, 
    0.05304696f, -0.03173008f, 0.05314392f, -0.03466973f, -0.03870701f, -0.06964988f, 0.08095590f, 0.02583019f, 
    -0.02174466f, -0.00657228f, 0.07370175f, -0.06085113f, 0.08337843f, 0.03010727f, 0.01687159f, 0.03697383f, 
    -0.05610796f, -0.01349671f, 0.06909765f, -0.02474178f, 0.02629877f, -0.03733389f, 0.02212522f, 0.02947905f, 
    0.06244176f, -0.02350365f, 0.02410705f, -0.00184462f, 0.03162149f, 0.03732597f, -0.03245857f, -0.03909823f, 
    0.04715366f, 0.04124635f, -0.02306177f, -0.10178599f, 0.02672685f, -0.03763735f, 0.12925701f, 0.00928448f, 
    0.04777211f, -0.11690564f, 0.06256407f, -0.05118195f, 0.00099793f, -0.02102674f, 0.03943107f, -0.01127930f, 
    0.06306989f, 0.09969822f, -0.08521266f, -0.03432355f, 0.07959944f, 0.14255679f, -0.00502848f, -0.03796477f, 
    0.01356735f, 0.04389997f, -0.01161557f, -0.02923102f, -0.10448409f, 0.08935309f, -0.02857003f, 0.00298737f, 
    0.00870030f, 0.04006144f, 0.08275395f, -0.06890224f, -0.05498398f, -0.02023280f, -0.22679985f, -0.08484041f, 
    -0.03448758f, 0.02709701f, -0.01765572f, -0.11168516f, -0.02755642f, -0.06046458f, 0.04580370f, 0.01565343f, 
    -0.00885322f, 0.01052562f, 0.07508105f, -0.06242620f, -0.08256005f, -0.11807966f, -0.07752464f, -0.01510028f, 
    -0.16516045f, -0.04874906f, 0.05553233f, -0.07597313f, -0.18195502f, -0.00947228f, -0.05307732f, -0.12743467f, 
    0.03441173f, 0.00309794f, 0.01114936f, 0.02098143f, -0.03824009f, 0.05218184f, 0.00219343f, -0.05453453f, 
    0.00335195f, -0.08582079f, 0.02264082f, 0.02345107f, -0.11825030f, 0.00977549f, 0.01963408f, -0.05286094f, 
    -0.03875222f, -0.00512755f, -0.00100811f, -0.02500551f, -0.04173040f, -0.01170386f, 0.05563145f, 0.05680309f, 
    0.02647209f, -0.01431191f, 0.09052149f, -0.07931659f, 0.01762287f, -0.04711589f, 0.02917245f, -0.01207708f, 
    0.06220102f, 0.03662707f, 0.02343772f, -0.00662433f, 0.07860795f, 0.06807170f, 0.01381335f, -0.07304408f, 
    0.00117347f, -0.02201566f, 0.02288023f, 0.00418138f, -0.01773930f, 0.05497358f, -0.03483604f, -0.00932768f, 
    -0.00953020f, 0.04666767f, -0.00250842f, 0.00421574f, 0.19576432f, 0.07394431f, 0.04283661f, 0.03544317f, 
    0.13895200f, 0.01007039f, 0.02000034f, -0.04266036f, -0.02944626f, -0.02622826f, 0.02878767f, 0.02789010f, 
    -0.03509440f, -0.06637177f, 0.08939043f, -0.03311894f, -0.03447516f, 0.05276632f, 0.04298493f, -0.00625596f, 
    -0.10290233f, 0.03555424f, -0.15866055f, -0.09394535f, -0.08029100f, 0.03888622f, -0.01862993f, -0.01452738f, 
    0.07959826f, -0.03625409f, 0.02747043f, 0.06430045f, 0.00939323f, 0.02197123f, -0.00749380f, 0.03831019f, 
    0.00305506f, -0.07127551f, 0.03082564f, -0.10314686f, -0.02046144f, 0.01662820f, -0.13653593f, 0.02183294f, 
    -0.03119001f, -0.03545526f, -0.00521584f, -0.01154544f, -0.02938704f, 0.04064143f, 0.04594165f, 0.03573067f, 
    0.01009096f, 0.03752265f, 0.04152493f, 0.03968981f, 0.00627173f, -0.00503687f, 0.00326023f, 0.03928546f, 
    0.11786757f, -0.09881683f, -0.01846484f, -0.04663564f, 0.08378758f, -0.03806543f, 0.01598748f, -0.04804935f, 
    -0.10044327f, -0.05074127f, -0.03543230f, -0.02376750f, 0.04234713f, -0.04984538f, 0.03528579f, 0.04394917f, 
    0.03681924f, 0.04166643f, -0.00029787f, 0.06837685f, -0.08623149f, -0.16104074f, -0.14358927f, -0.03882430f, 
    0.10241861f, 0.02534364f, 0.06107207f, -0.09998970f, -0.00521622f, -0.01985284f, 0.08985247f, 0.04883183f, 
    -0.02267786f, 0.08398812f, 0.03375316f, -0.05545415f, 0.01078990f, 0.01421329f, 0.05989572f, 0.00352979f, 
    -0.04999499f, -0.19454385f, -0.17363252f, -0.00217995f, 0.15056360f, 0.12323871f, 0.09413763f, -0.00853900f, 
    -0.01161318f, -0.07557962f, 0.01808672f, 0.02357559f, 0.04340456f, -0.00136332f, -0.02881745f, -0.01581961f, 
    0.05929393f, 0.03913286f, -0.01077011f, -0.03638937f, 0.02927799f, 0.06917451f, -0.01384606f, -0.06460693f, 
    0.01164800f, -0.01170569f, 0.02879746f, -0.05663360f, -0.00912798f, -0.07265796f, 0.04214461f, -0.00120105f, 
    0.02059518f, 0.00268266f, 0.02838447f, -0.09364866f, -0.01047382f, 0.08948226f, -0.03377280f, -0.04580951f, 
    -0.15866277f, 0.02255410f, 0.01547238f, -0.09917827f, -0.21124379f, 0.01277000f, -0.00212016f, -0.11860789f, 
    0.00916223f, -0.05258034f, 0.00752511f, -0.00805997f, 0.01884512f, 0.00587130f, -0.06575163f, -0.05234309f, 
    -0.01512690f, -0.18817340f, 0.00526169f, 0.05244540f, -0.11074104f, 0.11896715f, -0.25771165f, -0.12248375f, 
    -0.11660343f, 0.08598352f, -0.09483888f, -0.16244233f, 0.02460058f, -0.01357801f, 0.05320859f, 0.06898370f, 
    0.12706716f, -0.05815320f, 0.00153060f, 0.03558196f, -0.04991310f, -0.13335149f, 0.06228174f, -0.03050846f, 
    0.07417770f, 0.08210252f, -0.02404098f, -0.00329747f, -0.01982012f, -0.08972612f, 0.02799805f, -0.07996915f, 
    0.01054602f, -0.03699080f, 0.01241045f, 0.03421735f, 0.02515225f, -0.10702093f, -0.01702779f, -0.03056949f, 
    0.01333997f, -0.00444015f, 0.10988093f, -0.08366552f, 0.10938483f, 0.07061686f, -0.12830843f, 0.02427655f, 
    0.04944069f, 0.00865517f, -0.05157926f, -0.06147176f, 0.02710899f, -0.01035450f, 0.06875969f, -0.01787756f, 
    -0.01205872f, -0.03490610f, 0.06221466f, 0.02905891f, -0.03962963f, 0.02495663f, 0.04173494f, -0.01518798f, 
    -0.10190033f, -0.02192830f, 0.13700138f, 0.00300044f, 0.05003912f, -0.13261852f, -0.00196376f, 0.06239185f, 
    -0.05416581f, 0.03367238f, -0.00952141f, -0.03307560f, 0.02740673f, 0.01901602f, -0.00725682f, -0.00989045f, 
    -0.13551465f, 0.02240257f, 0.00170783f, -0.01315540f, -0.16592823f, -0.22178563f, 0.11669115f, -0.01062485f, 
    -0.15219457f, 0.00778707f, 0.03468646f, 0.05296379f, -0.04741644f, -0.10491552f, 0.02711877f, 0.03350444f, 
    -0.03592349f, -0.01110224f, 0.02974859f, 0.04053674f, 0.00292885f, -0.07519995f, -0.05225693f, 0.03052611f, 
    -0.15049364f, -0.10507211f, 0.01221031f, -0.11575834f, -0.25943345f, 0.03357041f, -0.07855004f, -0.07294909f, 
    0.00870419f, -0.03207694f, 0.04770424f, 0.01721694f, -0.03001959f, -0.10655413f, 0.06203682f, -0.01862230f, 
    0.05148311f, -0.12506337f, 0.05617811f, -0.05299810f, -0.06339995f, -0.04721795f, 0.14296013f, -0.14216508f, 
    -0.00339562f, 0.03651380f, -0.03156317f, 0.11812835f, 0.03306839f, -0.05430009f, -0.03170012f, -0.04174639f, 
    0.04830964f, -0.02062173f, 0.02769421f, -0.07965040f, 0.01893882f, 0.04606500f, -0.15422371f, -0.03717706f, 
    0.09571414f, 0.03025027f, -0.08875229f, -0.11072022f, -0.00933031f, 0.05773068f, 0.00788931f, 0.01261272f, 
    0.05133509f, -0.01119890f, 0.02996842f, 0.01768584f, 0.01827640f, 0.03553127f, 0.01423582f, 0.08642545f, 
    0.05028962f, 0.06474862f, 0.01991265f, 0.00760890f, 0.00025387f, 0.03238646f, -0.08393376f, 0.11622778f, 
    0.08335046f, -0.12160899f, -0.06087292f, -0.09182651f, -0.05518544f, 0.02348679f, 0.00652773f, -0.02696114f, 
    -0.08472064f, 0.06956849f, 0.03431638f, 0.08994027f, -0.03082410f, -0.00589449f, 0.07734536f, 0.04199906f, 
    0.10531436f, 0.13291447f, 0.00186730f, 0.01997794f, 0.09433135f, 0.00460246f, 0.05502406f, -0.01883369f, 
    0.00392460f, -0.03346159f, -0.02354728f, 0.04283597f, 0.02453445f, 0.04394474f, -0.04266720f, 0.08561912f, 
    0.01335950f, 0.02049297f, 0.01521048f, 0.02837504f, -0.13397217f, 0.16051653f, -0.01380447f, -0.18123291f, 
    -0.05523121f, -0.01594329f, -0.01207620f, -0.06714632f, -0.04649843f, -0.06444983f, 0.09709224f, 0.02293187f, 
    0.05641580f, 0.11826833f, 0.02358647f, -0.09298663f, 0.07220925f, -0.00050885f, 0.05962639f, 0.03865374f, 
    0.07674409f, 0.08242550f, -0.03804700f, 0.15156236f, 0.06198385f, 0.01574001f, -0.00446362f, -0.10555097f, 
    -0.06355628f, 0.06661279f, -0.00877396f, -0.00833939f, 0.00082140f, 0.00941229f, -0.08418314f, 0.02068041f, 
    -0.00493809f, -0.03682470f, 0.06042863f, 0.02545123f, -0.15697363f, -0.06232934f, -0.00998945f, -0.20543480f, 
    -0.17071649f, -0.05737476f, -0.04180977f, -0.04002775f, 0.01647960f, -0.05230906f, 0.02390175f, 0.01029141f, 
    -0.00740387f, -0.01914975f, 0.00334233f, -0.04118160f, -0.00883573f, 0.00116888f, -0.10945918f, -0.02889861f, 
    0.09047294f, 0.12779883f, 0.00714362f, 0.00806952f, 0.07569563f, 0.04307190f, 0.02563797f, -0.09729555f, 
    -0.03567975f, -0.05834857f, -0.02143698f, 0.01000944f, -0.01665449f, -0.06713947f, -0.02718088f, -0.09146716f, 
    -0.02544182f, 0.09632750f, -0.03667021f, -0.01259632f, -0.05307809f, -0.07300701f, -0.12269514f, -0.00167114f, 
    0.03891258f, 0.00545394f, 0.00356805f, -0.01532021f, -0.03124747f, -0.03216122f, 0.03484623f, 0.00050078f, 
    0.03173948f, 0.03346363f, 0.02467014f, 0.01380456f, 0.00369202f, 0.01902537f, -0.00215878f, 0.05025524f, 
    -0.11153443f, -0.15425552f, 0.13406296f, 0.01166466f, 0.02954055f, -0.14904439f, 0.00034500f, 0.03202841f, 
    -0.04600067f, -0.01242341f, -0.00804800f, 0.00104840f, 0.02416586f, 0.03983828f, 0.00593575f, -0.01576899f, 
    -0.07772376f, 0.01618060f, -0.01010183f, 0.02511501f, 0.00836609f, -0.01427998f, 0.07159940f, 0.09387816f, 
    0.14023329f, -0.15045476f, -0.07415579f, 0.01130906f, -0.02844716f, 0.00381021f, 0.02838369f, -0.01436238f, 
    -0.12801620f, -0.02917536f, 0.06896204f, 0.01572871f, -0.02561295f, 0.04683974f, 0.06227489f, 0.03747905f, 
    0.11588518f, 0.02671002f, 0.02970611f, 0.02725495f, -0.16617207f, -0.04934376f, 0.01723818f, 0.10493053f, 
    0.02329457f, -0.16404086f, 0.07688377f, -0.04704772f, -0.04699113f, 0.01076123f, 0.13300757f, -0.01182341f, 
    0.01057789f, -0.05735781f, -0.09640613f, -0.05612798f, -0.15653245f, -0.26648608f, 0.09240140f, 0.11399226f, 
    -0.05302820f, -0.08887744f, 0.05312991f, -0.02958681f, -0.00606250f, 0.01097084f, 0.06581450f, -0.00910677f, 
    -0.07400043f, -0.00069351f, -0.01058966f, -0.06464247f, 0.10434259f, -0.04135912f, 0.06056518f, -0.05248416f, 
    0.04582843f, -0.14809273f, -0.04341837f, 0.00981536f, 0.10486540f, 0.07241415f, -0.01476455f, -0.04388456f, 
    -0.00156550f, 0.19121507f, -0.01693182f, -0.02340648f, 0.01712471f, 0.07642537f, 0.02238429f, 0.04859108f, 
    -0.00000747f, -0.00121981f, 0.00737539f, -0.06943951f, -0.05451557f, -0.17426959f, 0.13155116f, -0.12889591f, 
    -0.35882244f, 0.05550511f, 0.15958026f, 0.02533286f, -0.13863452f, 0.03555639f, -0.10291798f, -0.02558015f, 
    -0.12412269f, -0.06133863f, -0.00175535f, -0.16609910f, -0.05356303f, 0.04568375f, 0.07771206f, -0.09667198f, 
    -0.16390061f, 0.16578972f, 0.07838725f, -0.26748124f, 0.01601463f, 0.01068206f, 0.02744910f, -0.06070736f, 
    0.02854587f, 0.07184374f, 0.01694275f, -0.01516355f, 0.03144769f, -0.01946226f, 0.02561709f, 0.03910980f, 
    -0.02713422f, 0.01154826f, 0.02687336f, -0.06250198f, 0.07542194f, -0.03561975f, -0.12669680f, 0.05284462f, 
    0.03444624f, 0.09366820f, -0.08110411f, -0.02040477f, -0.00472376f, 0.13937949f, 0.03627635f, -0.00545166f, 
    0.03028572f, 0.03066729f, 0.00021922f, -0.03475028f, -0.04073320f, 0.00161394f, -0.02927306f, -0.01343715f, 
    0.06980380f, -0.11206282f, 0.07557305f, 0.21231250f, 0.20741515f, 0.00074093f, -0.07382961f, -0.00123665f, 
    0.00364283f, 0.02531576f, 0.03861194f, 0.02951594f, -0.05661121f, 0.01887268f, -0.10537128f, 0.00170617f, 
    -0.03473760f, 0.06118114f, -0.05289909f, 0.05642619f, -0.55376941f, 0.37878522f, 0.01611723f, 0.10001412f, 
    -0.05512313f, 0.11713275f, 0.03246127f, -0.00606142f, 0.09043834f, 0.02276437f, 0.00771914f, -0.03563589f, 
    0.06843377f, 0.03983850f, 0.13245825f, 0.10912884f, 0.01433190f, 0.08714525f, -0.13958691f, 0.03262640f, 
    0.03658150f, -0.06705719f, 0.05462549f, -0.12886870f, 0.04562406f, -0.04847564f, 0.04996710f, -0.07085799f, 
    -0.01161411f, 0.00174822f, 0.01458706f, 0.03930249f, -0.01460747f, -0.01055147f, -0.04986957f, 0.00390499f, 
    0.01200086f, -0.01315971f, -0.09618557f, -0.01697441f, 0.24222848f, -0.08117983f, -0.05034910f, 0.00106234f, 
    0.06819159f, -0.01304015f, 0.01345789f, -0.01444732f, -0.03044046f, 0.01388980f, 0.00572816f, 0.05261770f, 
    0.04261517f, -0.02610602f, 0.02327622f, 0.03168563f, 0.00645685f, -0.01213638f, 0.04679484f, 0.06448528f, 
    -0.14356631f, -0.06958000f, -0.09588598f, 0.02130372f, -0.07135788f, -0.10828755f, 0.05455850f, -0.03785682f, 
    -0.09056830f, 0.00329740f, 0.07149373f, -0.08012628f, -0.10884675f, -0.03646390f, 0.02497612f, 0.02783654f, 
    0.01953203f, -0.05844084f, 0.10767164f, 0.09166113f, 0.26471573f, -0.02238917f, -0.21587653f, 0.04070703f, 
    0.04736014f, -0.02398516f, -0.01925791f, -0.02279812f, -0.05249746f, 0.07171199f, -0.05739067f, 0.00653815f, 
    0.09604093f, 0.00826324f, 0.13423449f, 0.08098383f, -0.00588392f, 0.03477730f, -0.03583241f, 0.11435524f, 
    0.13466381f, -0.03569679f, 0.10195961f, -0.00286958f, -0.17921041f, -0.04929103f, -0.02676438f, 0.14557099f, 
    0.01988575f, 0.05713628f, 0.00066490f, 0.02463243f, -0.00440032f, -0.09989408f, -0.02256692f, -0.05366461f, 
    0.04229710f, -0.06754757f, 0.01292279f, -0.04140014f, -0.29677758f, -0.02775932f, -0.09072857f, 0.12580518f, 
    0.06083110f, 0.06579936f, -0.11849485f, 0.03005027f, -0.00669918f, 0.08951530f, -0.02462919f, 0.01033489f, 
    0.06266505f, -0.04212511f, -0.07288027f, 0.10382431f, -0.04682615f, -0.00924271f, 0.00137417f, -0.06139865f, 
    0.00937079f, -0.16695787f, 0.21679991f, 0.00519866f, -0.12524123f, 0.01630141f, 0.03119362f, 0.01142128f, 
    0.04336300f, 0.07386537f, 0.00715039f, -0.04089466f, 0.03767128f, -0.01487301f, 0.00665798f, -0.01647857f, 
    -0.00616852f, 0.04732073f, -0.06813478f, -0.10899312f, -0.15116565f, 0.00183964f, 0.03979485f, 0.05466469f, 
    0.00303572f, -0.00031777f, -0.01552519f, -0.04800535f, -0.02438791f, -0.01182937f, -0.03325138f, -0.04361976f, 
    -0.03339163f, -0.01365108f, 0.05710330f, 0.06732918f, 0.02116445f, 0.09902772f, 0.02610184f, 0.10846184f, 
    0.31980044f, -0.12318928f, -0.09328872f, -0.20454776f, -0.06984582f, -0.02733038f, 0.03194629f, -0.04509727f, 
    0.04881517f, -0.08388894f, -0.04431938f, -0.05243904f, -0.01008886f, -0.01700768f, -0.07541255f, 0.09353156f, 
    0.02125848f, -0.00604618f, -0.05512894f, 0.05620989f, 0.53549296f, -0.02901716f, -0.18723011f, -0.22232263f, 
    -0.08415265f, 0.04384436f, -0.00610891f, 0.11537529f, 0.05371876f, -0.07942860f, -0.02198916f, -0.02796428f, 
    -0.01299458f, 0.05610971f, -0.04442891f, 0.09763438f, 0.10320375f, 0.03112580f, 0.01055511f, 0.12390146f, 
    -0.00304465f, 0.07087468f, -0.07452954f, 0.00824387f, -0.21874830f, 0.01156144f, 0.00253092f, -0.03388855f, 
    0.00459814f, 0.05878562f, -0.08174771f, 0.02091403f, 0.01365239f, 0.04888359f, 0.10241324f, -0.01533797f, 
    0.06370468f, 0.02955965f, -0.01112803f, -0.01792353f, 0.22999549f, -0.19027379f, -0.04397456f, 0.02951512f, 
    0.10302184f, -0.00443753f, -0.02150235f, 0.03809179f, -0.01652494f, 0.11932270f, 0.02324791f, 0.08255360f, 
    0.01768130f, 0.07278119f, -0.00326630f, -0.03274969f, -0.04960027f, -0.00341643f, 0.06691217f, -0.04166587f, 
    0.01266007f, 0.02285572f, 0.07148560f, -0.02122633f, -0.21333526f, -0.10869681f, -0.02549931f, 0.01178494f, 
    -0.01160245f, -0.00054142f, 0.04309483f, 0.07718070f, -0.01596366f, -0.06742609f, 0.04947722f, 0.03220563f, 
    0.11687470f, -0.07053534f, 0.00363464f, 0.00987949f, -0.10889537f, -0.06865562f, 0.01979292f, -0.06857158f, 
    0.04544374f, 0.07529237f, 0.06560624f, 0.02050200f, -0.00356060f, -0.01454976f, 0.05940872f, -0.00440505f, 
    -0.04574020f, -0.03750754f, 0.01276854f, 0.03735307f, -0.03541147f, -0.04536501f, -0.10860580f, 0.04360988f, 
    0.12626645f, 0.01288043f, -0.04528417f, 0.02616551f, -0.07670010f, -0.10807712f, -0.06967526f, 0.13027394f, 
    0.07882465f, 0.12779301f, 0.10361353f, 0.01409669f, 0.15923917f, -0.03363147f, -0.04780823f, 0.07415318f, 
    0.01451808f, -0.09337626f, 0.10505587f, -0.07511961f, -0.22996853f, 0.04400695f, 0.03363414f, -0.11246665f, 
    0.02591244f, -0.04291345f, -0.06255998f, 0.01250034f, 0.07936080f, -0.05116534f, -0.00707070f, 0.08949510f, 
    -0.10368057f, 0.04743188f, -0.07473595f, 0.01788659f, 0.01108070f, 0.14792736f, 0.07111152f, 0.04316223f, 
    0.11592063f, -0.37459973f, 0.26500478f, -0.07491107f, -0.05529705f, 0.04803358f, 0.08166737f, -0.10240445f, 
    -0.05965301f, -0.05207804f, -0.06453768f, 0.01104123f, -0.05958726f, -0.03118056f, 0.00123384f, -0.07769192f, 
    0.02974174f, 0.00459610f, -0.03612895f, 0.01567441f, 0.15004842f, -0.34779721f, 0.12510228f, -0.01040086f, 
    0.07776264f, 0.01113530f, -0.00391712f, 0.00629890f, 0.00857032f, -0.04366206f, 0.04157331f, -0.02151149f, 
    0.05273629f, 0.07163367f, -0.00269484f, 0.03196206f, 0.08270615f, -0.12009618f, -0.03421542f, 0.04023601f, 
    0.14644372f, -0.26267976f, 0.15900593f, -0.00052096f, -0.01471382f, 0.06867683f, 0.04562378f, 0.02481399f, 
    -0.00023431f, -0.05730505f, -0.01171228f, 0.01566620f, -0.01540382f, -0.04060422f, 0.00552949f, 0.02454544f, 
    0.03962530f, -0.02243017f, 0.01547696f, 0.04606567f, 0.14627004f, 0.11351201f, -0.14681467f, -0.33983329f, 
    -0.28419060f, -0.01126899f, 0.04336772f, -0.03125731f, -0.06381842f, 0.02800065f, -0.01606178f, -0.02002047f, 
    -0.00190069f, -0.05083000f, -0.00201412f, -0.07341924f, 0.01996819f, -0.05249326f, 0.13589886f, 0.05699116f, 
    -0.24926628f, 0.02838570f, 0.13753937f, -0.15075447f, 0.09519009f, -0.00057664f, 0.02559097f, 0.01871539f, 
    0.04911385f, -0.08830258f, -0.00845497f, -0.02045021f, -0.00006556f, 0.06947876f, 0.07178575f, 0.04356596f, 
    0.08109830f, -0.02178468f, -0.10087482f, 0.07576824f, 0.05195203f, 0.01481009f, -0.06911856f, -0.02050662f, 
    -0.06507292f, 0.12902318f, -0.02552294f, -0.11463753f, -0.13882256f, -0.04390806f, 0.02432469f, 0.09663568f, 
    -0.05244280f, -0.07216668f, 0.04100979f, -0.09988351f, -0.02579377f, -0.04834828f, 0.03032125f, -0.03474979f, 
    -0.04852258f, -0.09004314f, -0.06534954f, 0.12156952f, 0.04846310f, 0.01965903f, -0.05865187f, -0.01198315f, 
    -0.02070791f, 0.10896730f, -0.11600089f, -0.03334584f, -0.02285652f, 0.07134271f, -0.00873273f, -0.02451612f, 
    -0.11807278f, 0.01647697f, -0.04455541f, -0.03975179f, -0.48881528f, 0.23501943f, 0.14816630f, -0.03032462f, 
    0.01134260f, 0.12309413f, 0.06743889f, 0.01226332f, 0.01879416f, 0.02110961f, -0.01628682f, -0.02590220f, 
    0.02602684f, -0.00199877f, 0.06375136f, 0.06164570f, 0.01612970f, 0.11730647f, -0.03488123f, 0.03747029f, 
    0.07517697f, -0.04520376f, -0.08671199f, 0.13940400f, -0.08802988f, 0.07205223f, 0.04923446f, -0.07024490f, 
    -0.04266069f, 0.06229840f, -0.14002937f, 0.08496165f, -0.06457695f, 0.05107857f, -0.03027316f, -0.04201803f, 
    -0.02600800f, -0.05985666f, 0.01516025f, -0.01060113f, -0.13331853f, -0.05685518f, 0.02537377f, -0.24347568f, 
    -0.07249533f, -0.11187996f, -0.02865636f, -0.00060848f, -0.03116593f, 0.01790704f, 0.10475604f, -0.10441004f, 
    0.00840552f, 0.06148064f, 0.01914808f, 0.03643952f, -0.05728628f, -0.00111362f, -0.10119733f, -0.08205813f, 
    0.19988157f, -0.14617702f, 0.18542370f, -0.12763605f, -0.19179311f, 0.03766712f, 0.01322387f, 0.04462560f, 
    0.01657063f, -0.00392291f, 0.01385573f, 0.05175176f, -0.02357464f, -0.08065228f, 0.03496686f, -0.07752603f, 
    -0.00973712f, -0.08029591f, 0.02531227f, -0.04657948f, -0.10912988f, -0.01011101f, 0.13117640f, -0.07203151f, 
    -0.14129236f, -0.12050949f, -0.02166608f, -0.02894707f, -0.06078891f, 0.01719430f, 0.07290271f, 0.03808170f, 
    0.02301183f, -0.01703563f, -0.04072996f, 0.06753995f, 0.05314153f, 0.02471201f, -0.00221658f, 0.00750092f, 
    -0.27845526f, -0.33346972f, -0.05632333f, 0.02546859f, -0.08630604f, -0.10369673f, 0.06092499f, 0.03374556f, 
    0.02374888f, 0.01782688f, -0.09415757f, -0.02403760f, 0.03379338f, 0.05141262f, 0.08710026f, 0.04936510f, 
    0.05760548f, 0.04064379f, 0.04798961f, 0.00372734f, 0.02666811f, 0.13760291f, -0.08984861f, -0.23463014f, 
    -0.01815556f, 0.02734887f, -0.00007944f, -0.08272704f, 0.01807478f, 0.03434455f, -0.02186266f, -0.02990407f, 
    -0.01140031f, -0.02541064f, 0.02198124f, 0.07749560f, 0.02904597f, 0.00816120f, -0.10521948f, 0.03386103f, 
    0.09455959f, -0.13223900f, 0.09752472f, -0.11394432f, -0.18422808f, 0.01992292f, 0.06609433f, 0.00401886f, 
    0.01495869f, -0.04948028f, -0.01535534f, -0.00329178f, 0.00581819f, 0.00620240f, -0.00377267f, -0.03608050f, 
    0.01973503f, -0.11813352f, 0.01797500f, -0.04733213f, -0.08216139f, 0.03284106f, 0.04070380f, -0.26597327f, 
    -0.02028414f, 0.11095338f, 0.05687729f, -0.12464002f, 0.03964789f, 0.00080478f, -0.07687971f, 0.02035440f, 
    0.05046877f, 0.01278579f, -0.04599060f, 0.00854746f, 0.02847066f, -0.06282949f, 0.05530937f, -0.11362728f, 
    -0.06444625f, 0.03790024f, 0.07231063f, -0.08774358f, -0.05813643f, -0.07326644f, 0.03544261f, 0.04761310f, 
    -0.00261679f, 0.05534039f, 0.01170046f, -0.07903227f, 0.04885688f, -0.05602774f, 0.00869758f, -0.04009343f, 
    0.07139069f, 0.03245176f, -0.00881895f, -0.01192989f, 0.03805231f, -0.10952038f, -0.02091661f, -0.06384911f, 
    0.00384806f, -0.06001113f, 0.00911185f, 0.01311828f, 0.12053374f, -0.05303442f, -0.05301441f, 0.03989270f, 
    -0.01421261f, -0.04198270f, -0.05637097f, 0.00788786f, -0.00768147f, 0.07519029f, 0.02220888f, 0.09442144f, 
    0.10209784f, -0.25587702f, 0.07522979f, -0.07611839f, -0.19944759f, 0.12553726f, 0.04376083f, -0.08405264f, 
    -0.07211511f, -0.04052946f, -0.07090802f, 0.04492389f, -0.09885038f, 0.12560065f, -0.05104842f, -0.03190736f, 
    0.01375628f, 0.03448944f, -0.07973698f, 0.02272850f, -0.09750520f, 0.00750806f, 0.06141905f, -0.07110599f, 
    -0.16443063f, -0.03824326f, 0.16850497f, -0.10575805f, -0.15298329f, 0.03480707f, -0.09066898f, 0.06789167f, 
    -0.04847251f, -0.06188279f, -0.03494850f, -0.04523981f, 0.00364224f, 0.01533215f, 0.00158170f, -0.02507696f, 
    -0.04900035f, -0.08612793f, 0.12858161f, -0.27394018f, -0.27319503f, 0.02817179f, 0.07364142f, -0.10500587f, 
    -0.04553899f, 0.01715200f, -0.03422729f, 0.00748996f, 0.02829238f, -0.00565535f, -0.07253519f, -0.07636885f, 
    -0.00313743f, 0.09325255f, 0.03710423f, -0.01189736f, 0.18463270f, -0.07667154f, -0.14545459f, 0.07050890f, 
    -0.15803173f, -0.00180449f, 0.02007096f, 0.02890446f, 0.03870880f, 0.00832109f, 0.03701736f, -0.04639041f, 
    0.03599168f, 0.01690452f, -0.05399151f, 0.06267133f, 0.07313074f, 0.08687650f, 0.05221342f, 0.10994803f, 
    -0.07219128f, -0.41879401f, -0.02991033f, 0.20388085f, 0.00258276f, -0.04717797f, 0.02806281f, 0.12523405f, 
    0.02725773f, -0.11133520f, -0.05307559f, 0.00686231f, -0.13647702f, -0.00319393f, -0.04112197f, 0.01054544f, 
    0.05847600f, 0.12095617f, 0.05650944f, 0.02743181f, -0.13977808f, -0.15352453f, 0.13439345f, -0.15742342f, 
    0.06615651f, -0.07658755f, 0.10473765f, 0.04103105f, 0.07730506f, -0.00807766f, -0.08457915f, -0.10325685f, 
    -0.01035316f, -0.06495165f, -0.04516329f, 0.00119861f, -0.00271548f, 0.11326129f, 0.00372013f, 0.04796832f, 
    -0.21960215f, 0.04307133f, 0.17804791f, -0.13110916f, 0.08006047f, 0.03714890f, 0.00562334f, 0.04164556f, 
    0.06423424f, -0.06475916f, 0.01997202f, 0.02445033f, 0.02566191f, 0.00732367f, 0.04336265f, -0.00343549f, 
    0.02198734f, 0.03692934f, -0.12746212f, 0.11861076f, -0.10735353f, -0.04160374f, 0.10664155f, -0.15234645f, 
    0.14588299f, 0.08030231f, 0.04680147f, -0.07745422f, -0.00995901f, -0.00609825f, -0.01384770f, -0.00255993f, 
    -0.00345934f, 0.05913924f, -0.01850935f, -0.02235343f, 0.03244181f, -0.10202141f, 0.01232148f, -0.03458803f, 
    0.17152503f, -0.20343320f, -0.06606902f, 0.13731167f, -0.16031273f, -0.05046181f, -0.00221681f, -0.01036524f, 
    0.20035970f, 0.01696180f, -0.08423174f, 0.05736229f, -0.01257430f, -0.06895284f, 0.03312473f, 0.01525674f, 
    0.05578423f, 0.02314838f, 0.00950229f, 0.01947409f, -0.24028140f, -0.24022396f, -0.00595146f, 0.23836480f, 
    0.08046057f, -0.01484084f, -0.10692602f, 0.02875880f, -0.07666238f, 0.07923873f, 0.05669309f, -0.00439385f, 
    -0.03532065f, -0.01742891f, -0.01912583f, 0.03886405f, -0.09595817f, 0.00635634f, 0.07209981f, 0.01673691f, 
    -0.41741386f, -0.30416963f, 0.15339382f, 0.09803576f, -0.15825729f, 0.03930857f, 0.01611854f, 0.03209616f, 
    0.05128296f, 0.01907564f, -0.10414863f, -0.04888989f, -0.06425826f, 0.11693214f, 0.01714319f, -0.01063603f, 
    -0.10251158f, 0.06370711f, 0.05146757f, 0.00487259f, 0.08676443f, 0.08157501f, -0.01436049f, 0.06511124f, 
    -0.03535424f, -0.07204054f, -0.10633138f, -0.03778436f, 0.10036184f, -0.06279095f, -0.07408737f, 0.06698231f, 
    -0.00421267f, -0.04211048f, 0.01543036f, 0.01092193f, -0.00968764f, -0.09968245f, 0.06393889f, 0.03082248f, 
    0.04345609f, 0.09855662f, 0.08591068f, -0.33178556f, -0.17815045f, 0.02213896f, -0.04205218f, -0.02264405f, 
    -0.06514712f, 0.04390785f, -0.01067135f, -0.01205332f, 0.02002702f, -0.14150923f, -0.04512981f, -0.00887973f, 
    -0.01707184f, -0.07095754f, 0.10935382f, 0.00631560f, -0.08992549f, -0.21012408f, 0.01027185f, 0.12681122f, 
    -0.09630550f, 0.01671307f, 0.05674782f, -0.07323964f, 0.05049044f, 0.01777209f, -0.02426341f, -0.00336873f, 
    -0.01156517f, -0.06165632f, -0.05494972f, -0.07115559f, -0.02364946f, -0.13372880f, -0.03712210f, 0.07589957f, 
    0.27918631f, -0.29769248f, 0.15076904f, 0.01523607f, -0.09150313f, 0.02094294f, 0.04072560f, -0.04435721f, 
    0.01791304f, 0.00586685f, -0.00199262f, -0.01131660f, 0.08468486f, -0.05060372f, 0.04948989f, 0.01304689f, 
    -0.02902207f, -0.04410605f, 0.01784623f, 0.14911245f, 0.28715482f, 0.00052471f, -0.21357067f, 0.20542116f, 
    -0.14404792f, -0.07518583f, -0.03733429f, 0.07282171f, -0.00708394f, -0.03664692f, -0.03130485f, -0.05171086f, 
    0.04366380f, 0.01852535f, 0.03625888f, 0.02196031f, 0.11440197f, 0.02501813f, -0.00111845f, 0.08231419f, 
    0.35904944f, -0.35168788f, 0.04092630f, 0.05502985f, -0.01269551f, -0.03826321f, -0.05810470f, 0.06179135f, 
    0.05527210f, -0.08993759f, -0.03210829f, 0.04277182f, 0.02586064f, 0.00533772f, -0.05216253f, 0.03743844f, 
    0.03540093f, -0.05384452f, -0.05029895f, 0.07697976f, -0.02866906f, -0.01253965f, -0.04343455f, -0.01333634f, 
    0.04552487f, -0.08301701f, 0.03005384f, -0.01829284f, -0.00810898f, 0.00141436f, -0.01314429f, 0.02435664f, 
    -0.01815077f, -0.01988785f, -0.00742308f, 0.06011910f, 0.07429237f, 0.01324443f, 0.04614220f, 0.06939394f, 
    0.10352855f, -0.04888983f, -0.11196586f, 0.01414798f, 0.00717292f, -0.00908067f, 0.08095699f, 0.05584498f, 
    0.03365974f, -0.15899414f, 0.10357414f, -0.01094456f, -0.04445889f, -0.02745934f, -0.07235953f, 0.05496326f, 
    -0.02164213f, -0.05020674f, -0.05729962f, 0.00133971f, 0.05414878f, -0.24495474f, 0.15176256f, -0.14230993f, 
    -0.04080086f, -0.06359618f, 0.00466923f, -0.03123849f, 0.05169325f, 0.01263139f, 0.02758146f, -0.00809353f, 
    0.07737409f, -0.06883842f, -0.08449665f, -0.06381843f, -0.00494821f, 0.00309467f, -0.03229205f, 0.06793910f, 
    0.17630377f, -0.00437049f, -0.16093136f, 0.03654901f, 0.11944821f, 0.06830154f, -0.10139817f, -0.01763318f, 
    -0.03103995f, 0.06906622f, -0.02126049f, -0.00323191f, 0.06943576f, 0.05393509f, 0.03975449f, -0.00307590f, 
    0.02234399f, -0.01228296f, 0.05037479f, -0.06105389f, 0.16508941f, -0.03337431f, -0.14161550f, -0.00223407f, 
    0.02123238f, 0.06909954f, -0.00717902f, -0.01592694f, -0.01785317f, 0.01885223f, 0.03119107f, -0.03766578f, 
    0.09221601f, 0.02657493f, 0.04364318f, -0.02233890f, -0.06538961f, 0.00621943f, 0.01585181f, 0.00371888f, 
    -0.36538887f, -0.32843217f, -0.04767753f, 0.00872469f, 0.17017058f, 0.02380161f, -0.00021643f, 0.07401045f, 
    -0.05031975f, -0.06975306f, 0.02723718f, -0.02249902f, -0.02947883f, 0.05553276f, 0.05708642f, 0.04977662f, 
    0.00172690f, 0.07651588f, 0.11849870f, 0.02647354f, 0.14644901f, 0.05201274f, 0.06923304f, 0.01747274f, 
    -0.05983032f, 0.07949884f, 0.09843937f, 0.00506753f, 0.09643336f, -0.04843707f, 0.00069048f, 0.01605340f, 
    -0.02495736f, 0.04741442f, -0.00824902f, 0.04079325f, 0.01293222f, -0.04639855f, -0.07140251f, 0.01809070f, 
    0.18107265f, 0.00584143f, -0.11043583f, 0.06411371f, 0.02663645f, -0.08854628f, -0.03202402f, -0.04517601f, 
    0.03875215f, 0.00732496f, 0.03553828f, 0.01453531f, -0.03312356f, -0.04808357f, -0.02456991f, -0.03160683f, 
    -0.02948583f, -0.05407825f, -0.04327387f, -0.00700650f, -0.71042812f, -0.32849962f, -0.04227397f, -0.21490659f, 
    -0.35728282f, 0.06357706f, 0.01706657f, -0.01524747f, -0.10562839f, -0.01977467f, 0.06211070f, 0.06468476f, 
    0.02835127f, 0.18867967f, 0.00643291f, 0.09365112f, -0.02172016f, 0.02353547f, -0.11350404f, -0.08307244f, 
    -0.33046827f, -0.11453924f, -0.10382375f, -0.09438860f, -0.05949750f, 0.05794013f, 0.04854112f, -0.00283228f, 
    -0.04627068f, 0.09189446f, 0.08156876f, -0.04774790f, 0.06592505f, 0.00316327f, 0.02760586f, 0.00103065f, 
    -0.05340854f, 0.02180221f, 0.07518335f, -0.02486627f, 0.19487190f, 0.06207642f, -0.06189058f, 0.01733231f, 
    -0.00725782f, -0.11844081f, -0.07118642f, -0.07238989f, 0.00558396f, -0.08602384f, 0.05955668f, 0.01279090f, 
    -0.05533404f, -0.03556710f, -0.03951420f, -0.11222478f, -0.00628297f, 0.02447515f, -0.05828585f, -0.02927853f, 
    0.09690624f, 0.10562968f, -0.12929839f, 0.15063237f, -0.02150087f, -0.11337172f, -0.08648895f, 0.02568108f, 
    -0.02533245f, 0.03877823f, -0.01456801f, 0.00024160f, 0.06708996f, -0.11209787f, 0.06808082f, -0.05050211f, 
    0.04473175f, -0.00506583f, -0.02050430f, -0.07217044f, -0.38236508f, -0.20190890f, 0.00023810f, -0.02263211f, 
    0.06654238f, 0.00519525f, 0.04745896f, 0.06220812f, -0.04661681f, -0.06002319f, 0.13200080f, -0.07436914f, 
    0.02630726f, -0.08609253f, 0.01057113f, 0.02055553f, -0.05129850f, -0.05429801f, 0.08435377f, -0.00577354f, 
    -0.29601139f, -0.19368877f, -0.07022293f, -0.01154707f, -0.08221284f, 0.05739987f, -0.01730470f, -0.07493500f, 
    -0.04047950f, 0.04687137f, 0.01805106f, -0.03451302f, 0.00642234f, -0.06716201f, 0.02017749f, 0.05075537f, 
    -0.05608503f, -0.03190065f, 0.01411614f, 0.00751898f, 0.05286637f, 0.02889314f, 0.00274475f, -0.06697822f, 
    0.04570653f, -0.01280171f, -0.00452009f, -0.01462910f, -0.00783209f, -0.01857968f, -0.00017825f, 0.08040755f, 
    0.01495618f, 0.00043147f, -0.03927049f, -0.03544524f, 0.04994380f, 0.00690557f, -0.09928578f, 0.06971709f, 
    0.15621296f, 0.06427523f, -0.01972818f, -0.07338794f, 0.01738561f, 0.13282938f, 0.08373937f, 0.06264057f, 
    0.01558532f, 0.02383350f, -0.02929865f, -0.02992880f, -0.03440113f, -0.00400109f, -0.00482838f, 0.04286655f, 
    0.04117083f, -0.13256627f, -0.10730276f, 0.11493166f, 0.06480695f, 0.12242959f, -0.06646029f, -0.07984467f, 
    -0.11668939f, 0.04068220f, 0.08610785f, 0.08603529f, 0.07133313f, 0.06206572f, -0.02349446f, 0.03385749f, 
    0.01527532f, -0.03036140f, -0.02774950f, 0.03440795f, -0.00783538f, -0.00496063f, -0.12402435f, 0.01261970f, 
    -0.14279151f, 0.07024726f, 0.06500138f, 0.00569602f, 0.02738580f, 0.09378940f, -0.05770722f, 0.03298249f, 
    -0.00601989f, 0.00568043f, -0.04970784f, -0.00871940f, -0.02104989f, 0.03442166f, -0.01517680f, -0.00422914f, 
    0.05693229f, 0.03149454f, 0.00046539f, 0.01791340f, 0.06532144f, 0.08246187f, -0.02639684f, 0.08255739f, 
    0.05250779f, 0.00727808f, -0.00980839f, 0.05243773f, -0.05072097f, 0.02643776f, -0.00662452f, -0.02572622f, 
    0.08296795f, 0.03485523f, -0.03118419f, -0.03707360f, 0.05426224f, 0.01964941f, 0.02766441f, 0.08645078f, 
    -0.35125458f, -0.13026625f, -0.08709207f, 0.06444506f, 0.09524643f, 0.06862596f, -0.02382034f, -0.00151944f, 
    -0.05264468f, -0.09764895f, -0.02209297f, -0.03491382f, -0.03629620f, 0.07409575f, -0.01670382f, 0.03535290f, 
    0.04420891f, 0.04579374f, -0.03405419f, 0.02933304f, 0.15611325f, 0.04382171f, 0.02886955f, 0.01086137f, 
    0.05319070f, 0.06732481f, 0.07757622f, 0.05909429f, 0.00254803f, 0.02444607f, -0.02685370f, 0.05239813f, 
    0.00623653f, 0.00552536f, -0.04723002f, 0.07065443f, 0.05264388f, -0.17320694f, -0.12910442f, -0.05230815f, 
    -0.38010445f, -0.06936244f, 0.07137965f, 0.00567229f, -0.24185844f, 0.02206000f, -0.01583783f, 0.01199488f, 
    -0.06405752f, 0.04726296f, -0.06402365f, 0.03491836f, 0.01489484f, 0.02523787f, 0.01278317f, -0.05754181f, 
    -0.06717774f, -0.05926682f, -0.02310843f, -0.03896289f, -0.36871621f, -0.07337071f, 0.17113438f, 0.08312510f, 
    -0.06706397f, 0.05734272f, -0.01139062f, -0.03745756f, -0.05184676f, 0.06170797f, -0.07390413f, 0.03657549f, 
    0.07536333f, -0.08135732f, 0.04511395f, -0.10954669f, 0.05512279f, 0.02721438f, 0.03397090f, 0.02313098f, 
    -0.21049497f, -0.15135904f, 0.10526376f, 0.03358503f, -0.11132745f, 0.04150835f, 0.00049927f, 0.00082254f, 
    -0.00110202f, 0.06594840f, 0.02856757f, 0.03924336f, 0.00853704f, -0.00661022f, 0.03303930f, -0.07653103f, 
    -0.00801432f, -0.12461735f, -0.03976868f, -0.07794218f, 0.10260292f, 0.04235207f, -0.02590510f, 0.04299027f, 
    -0.01545770f, -0.03435102f, -0.07347012f, -0.05739512f, -0.02682376f, 0.02384886f, -0.02754646f, -0.00408977f, 
    -0.03902710f, 0.02568530f, -0.02342061f, 0.03008527f, -0.00832298f, 0.04645376f, -0.04984531f, 0.01281031f, 
    0.18689834f, 0.15610765f, 0.22865954f, -0.05418858f, -0.05707735f, 0.06613509f, -0.01993064f, 0.05672408f, 
    0.03040418f, 0.03031800f, -0.07393893f, -0.09965629f, -0.06911168f, 0.04043511f, -0.09810945f, -0.06273052f, 
    -0.02877778f, -0.29397306f, -0.07159995f, -0.05604471f, -0.08655247f, -0.09492034f, -0.17873041f, -0.08372790f, 
    -0.06459023f, 0.00624775f, 0.01685563f, -0.03941269f, -0.04751122f, -0.03239534f, -0.04782702f, -0.00649749f, 
    -0.10991852f, -0.02027740f, -0.00250672f, -0.05399509f, 0.03612130f, 0.11053982f, 0.05413051f, 0.03546574f, 
    -0.03813950f, 0.17696203f, 0.06516867f, -0.06647406f, 0.12838025f, 0.07689433f, 0.02451422f, 0.02844638f, 
    0.03492527f, -0.02554655f, -0.06191536f, 0.05848050f, 0.07083469f, -0.03231762f, -0.02468688f, -0.04106693f, 
    0.09496610f, 0.07772017f, -0.03523171f, 0.10257278f, -0.01249437f, -0.05343870f, 0.05932723f, 0.06349988f, 
    -0.01998611f, 0.07460663f, 0.07703336f, -0.00856541f, 0.05005272f, -0.00106235f, 0.06079228f, 0.06378532f, 
    0.01120035f, -0.00215146f, 0.07704546f, 0.01952638f, 0.03789544f, 0.00621963f, 0.07005671f, -0.01111935f, 
    -0.37584782f, -0.13283919f, -0.20780583f, -0.07535136f, -0.12627037f, 0.01980887f, 0.01573081f, -0.04444250f, 
    -0.05206352f, 0.01836813f, 0.01184368f, 0.00449929f, -0.04387470f, 0.05554587f, -0.02584047f, 0.07258845f, 
    -0.02454716f, 0.02309434f, -0.03309716f, 0.02472843f, -0.35122615f, 0.05669077f, -0.14827146f, -0.07099480f, 
    0.07740413f, 0.02035456f, 0.04903582f, -0.05976608f, 0.02876898f, 0.01408136f, 0.02830118f, -0.01455390f, 
    -0.01992605f, -0.08969259f, 0.08500438f, 0.01868218f, -0.02304880f, 0.05667559f, -0.06849903f, 0.06192386f, 
    -0.23763941f, -0.09253042f, -0.17157945f, -0.07039637f, -0.06499863f, 0.01138189f, 0.05434979f, -0.03446034f, 
    -0.03167101f, 0.00880020f, 0.05231600f, -0.01856470f, -0.01294024f, -0.04839293f, 0.04188702f, 0.05326022f, 
    0.00436949f, 0.09381081f, 0.03264133f, 0.06809010f, 0.07519139f, 0.15821396f, 0.12043663f, -0.08888146f, 
    -0.13527973f, 0.04511564f, -0.03397309f, -0.03233008f, 0.06836555f, 0.00392893f, -0.00989213f, 0.01505243f, 
    0.05556142f, 0.00913750f, -0.00764091f, 0.01311611f, 0.10220109f, -0.06611258f, -0.06602757f, -0.02305910f, 
    -0.25215062f, -0.18895738f, -0.08802322f, -0.01387600f, 0.04107999f, 0.06249735f, 0.03877253f, -0.00094126f, 
    -0.04220784f, -0.07051124f, 0.07755291f, -0.02724033f, -0.03277437f, -0.03317371f, 0.07795896f, 0.02439934f, 
    -0.09296627f, -0.00289888f, 0.03117598f, 0.02364925f, 0.08205337f, 0.05323866f, -0.09702880f, -0.06834985f, 
    -0.05791358f, -0.04010762f, -0.02014127f, 0.00827841f, 0.05940034f, 0.06231282f, -0.07284272f, -0.04039430f, 
    -0.10192973f, -0.05541610f, -0.00701115f, -0.07135295f, 0.01997337f, 0.11107323f, 0.00867989f, 0.05261191f, 
    0.21703687f, 0.06834640f, -0.05651847f, 0.05480003f, -0.05412349f, -0.18027377f, -0.09150515f, 0.01856673f, 
    0.02894437f, -0.05268135f, 0.01019644f, 0.07132319f, -0.01479073f, -0.13316669f, -0.09370190f, -0.04602260f, 
    -0.06008732f, -0.07131018f, -0.06439354f, -0.09822543f, -0.18292511f, -0.29400140f, -0.10276974f, 0.00963988f, 
    0.12717798f, 0.03435193f, 0.03617169f, 0.02932584f, 0.00096935f, -0.05764975f, 0.08820771f, 0.00326396f, 
    -0.02056467f, 0.01092564f, 0.02441847f, 0.06455059f, -0.02539840f, -0.03297240f, 0.11565589f, 0.03241288f, 
    0.10632789f, 0.01406967f, 0.03294958f, 0.00494223f, 0.03306608f, -0.02506468f, 0.02173568f, 0.04589787f, 
    -0.01760520f, 0.00478241f, -0.02013795f, -0.00920351f, -0.02311446f, -0.03034381f, 0.01253811f, -0.00411099f, 
    0.08258638f, 0.05518671f, 0.03182782f, 0.05142050f, -0.29652402f, -0.08724688f, -0.14600150f, -0.04831460f, 
    0.03970445f, 0.05412588f, -0.00554225f, -0.07794793f, -0.03819682f, 0.02915728f, 0.04193438f, -0.01717273f, 
    -0.02514585f, -0.05954545f, 0.07032882f, -0.01181985f, -0.03997018f, 0.05333975f, 0.02407078f, 0.03783291f, 
    -0.27878937f, -0.02070955f, -0.07046470f, -0.08016334f, -0.09768169f, 0.10415686f, -0.05716652f, -0.05906238f, 
    -0.03096476f, -0.01743576f, -0.05157731f, 0.09279939f, 0.01371504f, 0.08352685f, 0.01739397f, 0.01628630f, 
    0.03989048f, 0.06284431f, 0.01802351f, 0.04968846f, -0.07759006f, -0.00394024f, 0.16338706f, 0.14636335f, 
    -0.05183914f, 0.01279482f, -0.01186477f, 0.05666244f, 0.03064381f, 0.01833663f, -0.00316801f, -0.01863471f, 
    -0.01350923f, -0.02348056f, 0.02378240f, -0.01260086f, -0.06484425f, -0.09587286f, -0.06172350f, -0.09706685f, 
    -0.01543537f, 0.01976729f, 0.01269647f, -0.02432700f, 0.09410836f, 0.01447309f, 0.01032025f, 0.02882972f, 
    0.03248882f, 0.01820827f, 0.01171657f, 0.06808254f, -0.00252028f, 0.02394954f, 0.00619714f, 0.01188478f, 
    0.02067162f, -0.02146675f, -0.02661441f, 0.04959926f, -0.02491574f, -0.01327570f, 0.05610817f, 0.01357194f, 
    0.02559749f, -0.00054150f, -0.03643360f, 0.11895442f, -0.07357722f, 0.05137575f, -0.01328153f, 0.04042029f, 
    -0.01479008f, -0.02237641f, 0.02987542f, -0.05501905f, -0.03872674f, -0.07399885f, 0.03346483f, -0.01565702f, 
    -0.30602959f, -0.05137898f, -0.05947442f, -0.08966824f, -0.00593440f, 0.06993046f, 0.01687605f, -0.04975883f, 
    -0.02507556f, 0.03624339f, -0.00539493f, 0.01895924f, 0.01529219f, 0.01987518f, 0.05922959f, -0.00279542f, 
    0.01115609f, 0.09226805f, 0.06590142f, -0.00259283f, -0.48684806f, -0.09413695f, -0.17475301f, -0.18757381f, 
    -0.18352935f, 0.07122047f, 0.07328404f, -0.06592670f, -0.09022786f, 0.07893476f, -0.03281454f, -0.09795836f, 
    0.03031688f, -0.01732383f, 0.00542511f, -0.10905669f, -0.04873834f, 0.06913354f, 0.09358114f, 0.07636742f, 
    0.03561893f, 0.05904898f, -0.01333779f, 0.02725258f, 0.03159460f, 0.08618987f, -0.00329157f, 0.05240439f, 
    -0.00211955f, -0.03103115f, 0.02821879f, 0.04170745f, 0.02576317f, 0.02626641f, 0.05881770f, -0.02254929f, 
    0.04422549f, -0.02978065f, 0.02185882f, 0.03718148f, 0.01804448f, -0.07820687f, 0.02773333f, 0.05208579f, 
    0.00093623f, 0.06536929f, 0.01727637f, -0.01723957f, 0.06357058f, 0.06086218f, 0.00358032f, 0.00435336f, 
    0.04556419f, 0.03812508f, 0.01328975f, 0.10064049f, 0.08523379f, -0.00745512f, 0.01829701f, -0.04102711f, 
    -0.18285398f, -0.17317998f, -0.00680690f, -0.08269238f, -0.05589765f, -0.04655719f, 0.03825688f, -0.02007424f, 
    0.02281272f, -0.00308983f, 0.06238753f, 0.04273907f, -0.00013477f, -0.09660104f, 0.10268931f, 0.08438772f, 
    0.01747812f, 0.03911526f, 0.01834033f, 0.14774841f, -0.34622490f, -0.24242100f, 0.07557286f, -0.04172879f, 
    -0.17680708f, 0.02199132f, -0.01661066f, 0.00008299f, -0.07470053f, 0.05168468f, 0.01359595f, -0.00301130f, 
    -0.02073013f, 0.01867357f, -0.03836530f, 0.01623610f, 0.05621594f, -0.10321781f, -0.04029068f, -0.06168534f, 
    -0.18914941f, -0.04272873f, 0.05193290f, -0.18349390f, -0.23589039f, 0.04738150f, 0.01201107f, -0.02229073f, 
    -0.04935926f, 0.04262809f, -0.00627317f, 0.06168304f, -0.00313644f, 0.15379597f, 0.03234620f, 0.04508357f, 
    -0.02149436f, -0.00885815f, -0.10973981f, -0.03066248f, -0.04275185f, -0.12987715f, 0.02091449f, 0.01843100f, 
    0.02143427f, -0.05803333f, 0.04289079f, -0.01544821f, -0.03334589f, -0.04941252f, -0.00483334f, 0.01612882f, 
    0.04034225f, -0.04871177f, 0.05267821f, -0.04642322f, 0.00104778f, 0.00435980f, -0.06365458f, 0.02817405f, 
    0.23932378f, 0.04102561f, -0.06158582f, 0.00497950f, -0.01994760f, -0.02548893f, 0.00558168f, 0.09223848f, 
    0.01996665f, 0.05456368f, -0.01676848f, -0.02800321f, 0.03561721f, -0.01858803f, 0.03935518f, -0.00381316f, 
    -0.00647400f, -0.24061741f, -0.08788498f, -0.01554395f, 0.08716647f, -0.00214360f, -0.13391441f, 0.15126017f, 
    0.00776624f, 0.07517834f, 0.00861968f, -0.02296192f, 0.06827447f, -0.06023346f, 0.02907833f, 0.06083824f, 
    0.03641525f, 0.04157831f, 0.06776075f, -0.02831084f, -0.02915374f, -0.22691344f, -0.07156174f, -0.06996288f, 
    -0.06973919f, -0.08607265f, -0.05840611f, -0.04658676f, 0.06935225f, 0.00469205f, 0.00078643f, 0.01620138f, 
    -0.04234869f, -0.04968065f, 0.00705219f, -0.00243807f, -0.04120991f, -0.00683767f, 0.04281880f, -0.01418558f, 
    0.00028812f, 0.04432338f, 0.04569843f, 0.00679635f, -0.36758354f, -0.01862567f, -0.19218643f, -0.05463822f, 
    -0.07071954f, 0.08499105f, 0.04045797f, -0.05352299f, -0.00056182f, 0.04988572f, -0.00333545f, 0.02419754f, 
    0.02464594f, -0.00869488f, 0.01804979f, -0.02175265f, -0.04270888f, 0.03024817f, 0.03157067f, 0.01626306f, 
    0.14233086f, -0.05659140f, 0.03269647f, 0.04779629f, 0.06524921f, -0.03058445f, 0.07727543f, -0.04650576f, 
    0.04647496f, -0.05964300f, -0.00124481f, 0.05511673f, 0.02051197f, -0.03944813f, 0.02514311f, -0.03657804f, 
    0.06493536f, -0.01747385f, -0.15518951f, 0.04552910f, 0.20145230f, 0.16355380f, -0.11854738f, 0.05021490f, 
    -0.07387269f, -0.01658080f, -0.07024220f, 0.12312070f, -0.07681482f, 0.02344887f, -0.00334853f, -0.02672472f, 
    -0.01806378f, -0.08795341f, -0.01144755f, 0.05853646f, 0.02915720f, 0.03090672f, -0.01480838f, 0.00196297f, 
    -0.00530405f, -0.00652391f, -0.07425082f, 0.02406147f, 0.06016183f, 0.05934490f, -0.10244184f, 0.02394156f, 
    -0.06752282f, -0.00007073f, -0.02420041f, 0.01441214f, 0.04616834f, -0.08608530f, -0.01388917f, -0.03659851f, 
    -0.06361211f, -0.03689062f, -0.01627013f, 0.02195725f, 0.03861365f, 0.04147441f, 0.00654830f, -0.04862923f, 
    0.03988298f, 0.05161468f, 0.03093141f, 0.02745924f, 0.00407506f, 0.01706440f, -0.01681675f, -0.00686793f, 
    0.00990640f, 0.02589946f, 0.00740620f, 0.01457225f, 0.08818707f, 0.03616659f, -0.01789534f, 0.06852873f, 
    0.10906092f, 0.04642485f, -0.00184210f, -0.09162770f, -0.03078652f, 0.08128118f, -0.03606738f, -0.04200471f, 
    0.04729034f, 0.03620546f, 0.00437877f, -0.00124582f, -0.00378649f, 0.10254422f, -0.02962107f, 0.10552602f, 
    0.09208828f, 0.00907683f, -0.00154722f, 0.02491371f, 0.15509298f, -0.08150922f, -0.06725956f, 0.07169197f, 
    0.00174075f, -0.12282413f, -0.04471429f, -0.06694292f, 0.04918741f, 0.06414259f, 0.02562702f, 0.05183197f, 
    -0.10195138f, 0.01276173f, 0.03998537f, -0.04227798f, 0.02325222f, -0.00365826f, -0.01559380f, -0.07179833f, 
    -0.26097339f, 0.02604145f, -0.18168826f, -0.06111563f, 0.01995964f, 0.02691622f, 0.02806564f, -0.04414349f, 
    0.04499125f, 0.06944367f, 0.01031864f, -0.03895216f, -0.01483656f, 0.01469753f, 0.01756517f, 0.05276226f, 
    0.07254232f, 0.15853240f, 0.01296221f, 0.12756371f, -0.27745509f, -0.16171344f, 0.06315310f, 0.07905253f, 
    0.12389294f, 0.08701091f, -0.02409347f, 0.00246410f, -0.02404700f, 0.03566055f, 0.02402798f, 0.00347900f, 
    0.05015023f, 0.03109860f, 0.04650624f, 0.01154320f, -0.02647569f, -0.11127838f, 0.02877545f, 0.02382314f, 
    -0.04252306f, -0.01650210f, -0.01572287f, 0.05257010f, 0.06373622f, 0.00312860f, 0.02960281f, -0.05199239f, 
    0.03803429f, 0.01190807f, 0.00150232f, 0.01679072f, 0.03821655f, -0.04013544f, 0.10476139f, 0.05868532f, 
    0.04717111f, 0.07252271f, 0.00038167f, -0.00724390f, 0.16573574f, 0.14854059f, 0.03560694f, -0.00815085f, 
    -0.00471131f, 0.02925944f, -0.01083521f, 0.03589305f, 0.03363761f, -0.00156500f, -0.05968655f, -0.00070125f, 
    0.01578870f, -0.01143916f, 0.00732107f, 0.03366764f, 0.02306668f, -0.14007978f, -0.09678768f, -0.01550867f, 
    -0.17530295f, -0.07254604f, -0.00820092f, -0.08352806f, -0.03664410f, -0.00593651f, 0.02886614f, -0.02299621f, 
    -0.00672163f, -0.01417644f, -0.03958072f, -0.01542805f, 0.00978964f, -0.03499467f, -0.00720489f, -0.08714437f, 
    0.01593785f, 0.10748162f, 0.00982431f, 0.02740266f, 0.00363793f, 0.04022245f, 0.02801354f, 0.00273733f, 
    0.03419932f, 0.03448717f, 0.00906521f, 0.00219465f, 0.00656338f, 0.07643185f, 0.03092484f, 0.04849155f, 
    -0.01838103f, 0.03846525f, 0.00410048f, 0.07752287f, 0.02152340f, 0.00929425f, -0.05284867f, -0.01742115f, 
    0.04239918f, 0.11729047f, 0.00328239f, 0.06821469f, -0.00016028f, -0.00094496f, 0.02184382f, 0.05740883f, 
    0.00678671f, 0.06622615f, -0.00217902f, 0.03298705f, 0.00430311f, 0.01939636f, 0.02257757f, -0.03398642f, 
    0.06467215f, 0.11183369f, 0.01278175f, 0.04314306f, 0.19065726f, 0.04197279f, -0.00744809f, -0.00416422f, 
    0.03897323f, -0.13594985f, -0.03211795f, -0.06653871f, 0.07589386f, -0.04077050f, -0.00582390f, 0.05439341f, 
    -0.09660586f, -0.03848088f, -0.05757673f, -0.06111146f, -0.00380208f, 0.07089289f, -0.04228690f, -0.00596430f, 
    -0.02044590f, -0.08172207f, -0.09162916f, 0.02275356f, -0.10843073f, 0.11430622f, -0.07329095f, 0.01522733f, 
    0.05620709f, 0.01764866f, 0.01764085f, -0.01175460f, 0.04578117f, -0.05742878f, -0.01341300f, -0.03495781f, 
    -0.01707009f, -0.02400927f, -0.07718222f, -0.06668989f, -0.03080839f, 0.13691965f, -0.04781668f, -0.18496251f, 
    0.00148623f, -0.04355384f, -0.03963848f, 0.05694220f, -0.18885842f, -0.08701547f, -0.02754430f, 0.01461991f, 
    0.02000201f, -0.09879230f, -0.07085644f, 0.08134444f, -0.04556413f, -0.00828916f, 0.14854130f, 0.02603114f, 
    -0.12853044f, -0.01370353f, 0.06847473f, 0.07727293f, 0.01719066f, 0.03583094f, -0.01479389f, 0.06638622f, 
    0.04377858f, -0.02980854f, -0.07515325f, -0.02841176f, 0.05249810f, -0.02392492f, 0.05425365f, -0.03967899f, 
    -0.05957055f, 0.04395463f, -0.03504962f, 0.06455410f, 0.46182826f, 0.32550001f, -0.26068306f, -0.20121878f, 
    0.02867522f, 0.00616104f, -0.08439098f, -0.05376335f, 0.02352315f, -0.00620694f, 0.10288891f, 0.04419605f, 
    -0.05108766f, 0.01367070f, 0.05393953f, 0.03824707f, -0.04021829f, -0.00464394f, -0.06451260f, 0.04718852f, 
    0.21227527f, -0.09985796f, -0.17165065f, 0.16257945f, -0.15521441f, -0.01043285f, 0.01395097f, 0.04058803f, 
    -0.03850210f, -0.04310359f, 0.06544726f, 0.02440250f, 0.00241076f, 0.06525300f, 0.00670373f, 0.03948149f, 
    0.03489195f, -0.01754777f, 0.03168172f, -0.07704704f, -0.28846776f, -0.00819056f, 0.05135123f, -0.06882212f, 
    -0.01269525f, 0.00774919f, 0.03103991f, -0.01858333f, 0.04431575f, -0.09036312f, -0.06596801f, 0.04795090f, 
    0.06782009f, 0.01372035f, -0.01584385f, -0.07365325f, -0.08137362f, -0.00848479f, -0.11336835f, 0.05890098f, 
    0.13058832f, -0.01146547f, -0.01461916f, 0.08574039f, -0.14530830f, -0.06671336f, 0.07124906f, 0.02292199f, 
    -0.01332978f, 0.00618983f, -0.10413700f, -0.03927728f, 0.03507966f, 0.07220230f, -0.07018204f, 0.05267467f, 
    -0.05000674f, 0.00079561f, -0.04354677f, -0.01106399f, -0.03957852f, 0.00956271f, -0.03640951f, 0.13088174f, 
    -0.11866975f, 0.09827770f, 0.04081251f, 0.04467471f, -0.00645198f, 0.01916943f, -0.00804990f, 0.05899375f, 
    -0.07027401f, -0.03945396f, 0.06957906f, -0.13883233f, 0.10500799f, -0.00985574f, -0.00999270f, 0.02219369f, 
    0.12072398f, 0.02849339f, -0.11429279f, 0.05392858f, -0.26729694f, 0.05272250f, -0.02377807f, 0.00671152f, 
    0.00121245f, -0.07964770f, 0.05092788f, -0.02166541f, 0.07737740f, 0.04157393f, 0.06037727f, 0.06350533f, 
    0.03948091f, -0.00111863f, 0.02387747f, 0.02494611f, -0.37936297f, 0.28185090f, 0.01639551f, -0.10294332f, 
    0.09643547f, -0.04172647f, 0.01601518f, 0.00904346f, -0.01199374f, 0.01563123f, 0.00568887f, -0.01089860f, 
    0.03557215f, -0.02618681f, 0.03373872f, -0.04784550f, -0.07024809f, -0.04871888f, -0.07464063f, -0.06334382f, 
    -0.05972191f, 0.15970348f, -0.16958500f, -0.14445980f, 0.05079544f, 0.02279330f, -0.12523043f, 0.03914710f, 
    -0.06889126f, 0.02353291f, -0.04540593f, 0.05426340f, 0.03286615f, 0.00258503f, 0.10677893f, 0.13017084f, 
    -0.04517664f, 0.02554206f, 0.05938405f, -0.13054967f, 0.09562692f, 0.25063512f, -0.03891862f, -0.15295708f, 
    -0.02051921f, -0.16672136f, -0.04989914f, -0.08785181f, -0.07559956f, -0.10372964f, 0.06002125f, -0.06179751f, 
    0.04740335f, 0.00584768f, -0.01137657f, -0.01076995f, -0.08656539f, -0.03084612f, -0.10158527f, -0.05822353f, 
    0.21775343f, 0.05123439f, -0.06221667f, -0.05243869f, -0.01337194f, 0.12315400f, 0.07473503f, 0.00002865f, 
    0.05211068f, 0.03535720f, 0.00287711f, 0.01297146f, -0.04528300f, 0.00596648f, 0.08992624f, -0.01216850f, 
    -0.03883767f, -0.02982137f, -0.02862199f, -0.00777225f, -0.02460494f, -0.06568038f, 0.03222816f, 0.19619581f, 
    0.05160214f, -0.12082251f, 0.12246892f, 0.04600502f, 0.00572279f, -0.10409471f, 0.01754107f, -0.08279178f, 
    -0.09055692f, 0.01535070f, 0.04035739f, 0.00405819f, 0.05665416f, 0.02429895f, 0.03088811f, 0.00028519f, 
    0.14421996f, 0.29334363f, -0.06677932f, 0.03646759f, -0.00449557f, 0.15150735f, 0.13070227f, -0.03070423f, 
    -0.00902585f, -0.02782076f, 0.02859492f, 0.03568957f, -0.01817044f, 0.02724942f, 0.03913933f, -0.03777873f, 
    0.04333221f, -0.07720873f, 0.02116764f, 0.11155064f, -0.01273008f, 0.14529394f, -0.15346995f, -0.04566692f, 
    0.05364566f, -0.01052057f, -0.10001583f, -0.04253338f, 0.01500089f, -0.10300793f, 0.06468192f, 0.00411151f, 
    -0.02963707f, -0.01734813f, -0.02544064f, 0.00759713f, 0.01232093f, 0.08331615f, 0.07981217f, 0.08936391f, 
    0.10870609f, -0.14789259f, -0.06804189f, -0.22056453f, 0.14337745f, -0.01660900f, -0.07135870f, 0.03869147f, 
    0.00356768f, 0.02088484f, 0.03358408f, -0.06864930f, 0.03127052f, 0.04594888f, -0.03887662f, 0.05016211f, 
    0.05080765f, -0.02156690f, 0.07281972f, -0.02982401f, -0.09272551f, -0.30705360f, 0.01399849f, -0.11045896f, 
    0.12832123f, 0.02703835f, -0.07603858f, -0.00062026f, 0.08353304f, 0.08075488f, -0.09448334f, -0.05070246f, 
    0.05194642f, 0.08571063f, -0.02432741f, 0.07497164f, 0.07483884f, 0.02391723f, 0.02882705f, -0.06056499f, 
    -0.08724672f, 0.08438133f, 0.03670187f, -0.08163936f, 0.18195805f, 0.10849027f, -0.09066696f, 0.01831281f, 
    -0.00409003f, 0.01525060f, 0.03573456f, 0.05577926f, -0.02523314f, -0.02642471f, 0.02599029f, -0.02619265f, 
    0.07301279f, 0.01238592f, 0.02111867f, 0.02222637f, -0.19095898f, 0.17344590f, 0.02405510f, -0.03667750f, 
    0.06755824f, -0.03377508f, 0.02659841f, 0.01346283f, -0.00151120f, -0.13043194f, -0.03378242f, -0.02378472f, 
    0.03238942f, -0.00250360f, 0.07513981f, -0.03755159f, -0.03435841f, -0.01249537f, -0.01748058f, 0.01457809f, 
    -0.00657375f, -0.05562036f, -0.13082874f, -0.19019772f, 0.21968499f, 0.07828175f, -0.16991213f, 0.08784392f, 
    0.07158104f, -0.06904674f, -0.00380386f, -0.05839107f, 0.01940850f, 0.00483824f, -0.08105309f, -0.03984224f, 
    -0.10466390f, -0.01522545f, 0.18194833f, 0.07716666f, -0.12044639f, -0.37207004f, -0.09626523f, -0.09432190f, 
    -0.28579181f, 0.06301530f, 0.06767508f, 0.05954208f, -0.00827802f, 0.06078778f, -0.00442850f, 0.05934980f, 
    0.03934437f, 0.00551448f, -0.02578635f, -0.05887953f, -0.07964680f, -0.06006114f, -0.12412675f, -0.02302399f, 
    -0.25335073f, 0.13574590f, -0.07923096f, -0.02773296f, 0.08180189f, 0.04233310f, 0.15839593f, 0.02950759f, 
    -0.07438504f, 0.09460852f, -0.03435626f, -0.00741760f, -0.10307844f, -0.07347768f, 0.03372592f, 0.06322276f, 
    -0.02352623f, -0.01385358f, 0.07026029f, -0.02100978f, 0.16253772f, -0.03214569f, -0.08609232f, 0.03539795f, 
    -0.03986376f, 0.03758923f, 0.01769349f, 0.00440627f, -0.02215309f, 0.03540477f, -0.02648265f, 0.08138373f, 
    0.01074704f, 0.02236630f, -0.00164764f, -0.05704454f, 0.07129644f, 0.00987514f, -0.02355050f, 0.00726592f, 
    0.33962217f, -0.00250102f, -0.13388248f, -0.04847355f, -0.11770350f, -0.11395676f, -0.03430117f, 0.00421631f, 
    0.09458055f, 0.03826927f, 0.08083292f, -0.03353391f, 0.02465575f, -0.03572021f, 0.00152370f, 0.01144431f, 
    -0.02719329f, -0.07113342f, -0.01754719f, 0.04275022f, -0.42032909f, 0.07734782f, -0.02878871f, -0.01101262f, 
    0.00226829f, -0.04665902f, -0.00135677f, -0.05296170f, 0.05129068f, 0.01643050f, 0.03222658f, -0.01016894f, 
    0.02943471f, 0.06278713f, 0.01289184f, 0.04512353f, 0.06654863f, -0.08773716f, -0.04047615f, 0.05981093f, 
    0.00785841f, -0.01091076f, -0.14468645f, -0.06267177f, -0.17655478f, -0.02559257f, -0.00938316f, -0.02841492f, 
    0.06040192f, 0.04617843f, 0.00308678f, 0.00936900f, -0.00466890f, -0.03528740f, 0.04253136f, -0.01494133f, 
    0.00729538f, -0.00998642f, -0.03748835f, -0.00205178f, 0.02094991f, 0.03808563f, -0.06640496f, -0.07135257f, 
    0.22818333f, 0.15265588f, -0.17811033f, -0.01874879f, 0.10022718f, -0.02399401f, -0.02584798f, -0.01289116f, 
    0.01847905f, -0.03304308f, 0.06591669f, 0.04842435f, -0.02800371f, 0.01914230f, -0.03322146f, 0.10903621f, 
    -0.02835697f, -0.02930636f, -0.03053396f, 0.06280624f, -0.01005207f, 0.11145554f, 0.04163756f, -0.04641889f, 
    0.04213039f, -0.03197626f, -0.01976324f, -0.06282415f, 0.10221673f, 0.07506043f, 0.01410164f, -0.05398578f, 
    -0.00807079f, 0.00626823f, -0.10753031f, -0.04986004f, -0.37731746f, -0.06680524f, -0.03012531f, -0.10455283f, 
    0.01964217f, 0.00046896f, 0.09090630f, -0.04082558f, 0.00835689f, 0.11295295f, -0.05870780f, -0.03477409f, 
    0.01889898f, -0.10355709f, -0.08545122f, -0.06573389f, -0.07481454f, -0.00686030f, -0.11020108f, -0.04628700f, 
    0.03906741f, -0.07675192f, 0.07310850f, -0.00234867f, -0.03115360f, -0.03039062f, 0.03987253f, 0.05538973f, 
    -0.07929321f, -0.12897708f, -0.06829269f, -0.11078003f, 0.02343242f, -0.01282192f, 0.00210007f, -0.08217662f, 
    -0.04214856f, 0.00140488f, -0.05922670f, 0.05985242f, 0.12173975f, 0.03348633f, -0.11371968f, 0.13041070f, 
    0.01855866f, 0.22174506f, -0.05935998f, -0.05723245f, -0.01796594f, -0.02007655f, 0.01865763f, 0.04204794f, 
    -0.02099247f, 0.03716420f, 0.04612013f, 0.01498596f, 0.00635758f, 0.05809562f, -0.17688020f, -0.01693911f, 
    -0.30642182f, 0.21785812f, -0.03406971f, 0.04934157f, 0.08369344f, 0.07403824f, 0.06776193f, 0.03597021f, 
    0.05644516f, 0.04522778f, -0.07153547f, -0.02008729f, 0.07572112f, -0.01391571f, 0.00382980f, -0.05542255f, 
    0.02573232f, 0.00616543f, -0.00214448f, -0.02996615f, -0.08214796f, -0.20171703f, -0.08779414f, 0.02200631f, 
    0.00305962f, -0.04280398f, 0.10363141f, -0.00272131f, 0.00698824f, -0.05490167f, 0.05195950f, -0.02800248f, 
    -0.07764430f, 0.06427950f, 0.02895505f, -0.03441465f, 0.00019211f, -0.07039224f, -0.03593887f, 0.02026695f, 
    0.31911784f, -0.14901605f, -0.01045956f, -0.12310281f, -0.09860897f, 0.05075728f, 0.03213954f, -0.03115293f, 
    0.04470667f, 0.05738915f, 0.09217770f, -0.06910130f, 0.01066559f, -0.04521279f, 0.08374913f, 0.01686917f, 
    -0.05840767f, 0.00951003f, 0.02412943f, 0.02465458f, 0.14632742f, 0.12343414f, -0.07027374f, -0.10494386f, 
    -0.02922002f, -0.04079075f, -0.04134950f, -0.01711216f, -0.05355316f, -0.06065300f, 0.08526727f, 0.01661859f, 
    -0.07003476f, -0.01260392f, -0.03056412f, 0.02174173f, 0.01161214f, 0.01392918f, 0.02960300f, 0.03211191f, 
    -0.14718230f, -0.09603120f, 0.00489308f, 0.06017352f, 0.11196924f, -0.09642588f, 0.03236512f, 0.01372356f, 
    -0.02949144f, -0.09930883f, 0.02963948f, 0.03235620f, -0.06138325f, 0.03230244f, 0.00688199f, 0.08823409f, 
    0.00881543f, 0.03302135f, 0.03881872f, -0.02652115f, 0.11530492f, -0.04825620f, -0.03783393f, 0.08816014f, 
    0.01690670f, 0.01637093f, -0.02418262f, 0.03094737f, 0.12065155f, 0.05755324f, 0.09082224f, 0.00730485f, 
    0.04034758f, 0.05742598f, -0.00510804f, 0.05723401f, 0.04880609f, -0.02049554f, 0.01433059f, -0.02171700f, 
    0.18296705f, -0.07623587f, -0.01948239f, -0.07849026f, -0.08316809f, 0.03462068f, 0.04572264f, -0.05323759f, 
    0.02488285f, 0.01668620f, 0.07002310f, -0.07099254f, 0.01831086f, -0.01060354f, 0.04185596f, -0.04012317f, 
    0.01371782f, -0.04159267f, 0.03780709f, -0.00427147f, 0.03932001f, -0.26853502f, -0.05161158f, 0.00441752f, 
    -0.08542705f, -0.01939371f, 0.07667071f, 0.06716271f, 0.01143541f, -0.00044176f, 0.07686935f, 0.02672675f, 
    -0.06271776f, -0.05443703f, -0.00478611f, 0.05643136f, 0.06006182f, -0.08124940f, 0.02892349f, -0.00340767f, 
    0.17076935f, -0.10411493f, -0.08634701f, 0.03663671f, 0.06621153f, -0.05479358f, 0.08209608f, -0.10517762f, 
    0.05012795f, -0.05312178f, 0.01616827f, -0.02125262f, -0.05084216f, 0.04768353f, 0.00773432f, 0.09326122f, 
    -0.02385970f, 0.01597406f, 0.04623991f, 0.01232448f, -0.01777191f, 0.07532303f, -0.14186373f, 0.00532098f, 
    -0.01888720f, 0.09490848f, -0.08645222f, -0.02546139f, -0.01076808f, -0.05721103f, -0.05545277f, 0.11239973f, 
    -0.03579679f, -0.08602899f, 0.02640995f, -0.02848044f, 0.06688518f, 0.02539536f, 0.01361248f, 0.03193051f, 
    -0.29761958f, 0.19187829f, -0.02497894f, 0.03107341f, 0.34563524f, 0.14115494f, -0.11247848f, 0.00696280f, 
    0.07192702f, 0.13902348f, -0.05502575f, 0.04423832f, 0.02597850f, 0.01720993f, -0.06644905f, -0.05516166f, 
    0.02594259f, 0.03359028f, -0.05218243f, -0.08633557f, 0.22945149f, 0.18009369f, -0.20535405f, -0.06742311f, 
    -0.08581291f, 0.07711280f, 0.07633762f, -0.03773797f, 0.00290539f, -0.05799759f, 0.09179512f, 0.04394743f, 
    -0.04095923f, -0.02137618f, -0.02361753f, 0.08443014f, -0.04869824f, 0.07469528f, -0.02125227f, 0.08713503f, 
    0.43819040f, 0.11652508f, -0.18488136f, -0.14648455f, 0.16150086f, -0.03136593f, -0.01518936f, -0.06750011f, 
    -0.01581139f, -0.02151859f, 0.10288280f, 0.00786422f, 0.01110761f, 0.04563577f, -0.05228265f, 0.02789497f, 
    -0.01092150f, -0.00717959f, -0.03689525f, 0.04748046f, -0.37389955f, 0.06547997f, -0.08602174f, -0.16328426f, 
    -0.04574142f, 0.00000223f, -0.06164583f, 0.05856286f, 0.06943862f, 0.08218874f, -0.01094600f, -0.02176061f, 
    -0.01221960f, 0.07505181f, -0.02135256f, 0.03972825f, 0.01200126f, -0.03771938f, -0.03612703f, -0.00553774f, 
    0.11014865f, 0.07208040f, -0.13701145f, -0.06621740f, -0.10621882f, -0.10386097f, -0.07707947f, -0.00034160f, 
    -0.15235610f, -0.02284010f, 0.05172327f, -0.01805497f, -0.01342811f, -0.02814591f, -0.20043118f, 0.07665987f, 
    -0.00153769f, 0.04242960f, 0.03901069f, -0.11512943f, 0.13693632f, -0.10129364f, -0.18040875f, 0.09731895f, 
    0.03497187f, -0.11214370f, 0.08887582f, -0.08868558f, 0.00903227f, -0.05770485f, 0.07000390f, -0.02167487f, 
    -0.00793160f, 0.05528057f, -0.01825760f, 0.12596290f, 0.07831510f, 0.03458620f, -0.02644086f, -0.03218065f, 
    -0.10777143f, -0.16195403f, -0.01123036f, 0.07049764f, -0.08673985f, 0.13152416f, 0.08939622f, 0.05977464f, 
    -0.00769912f, 0.04260955f, -0.05750943f, -0.00761562f, 0.04155228f, 0.04410565f, -0.06426467f, -0.06325968f, 
    -0.02448085f, -0.04977318f, -0.06068560f, -0.00637990f, 0.05626286f, -0.04489619f, -0.11271677f, 0.08304144f, 
    -0.15522793f, -0.02949235f, 0.06120490f, 0.05719864f, -0.03904609f, 0.01720386f, 0.01659648f, -0.00870320f, 
    0.02311668f, 0.00624937f, 0.02601360f, 0.04821870f, 0.04832746f, -0.07093693f, -0.03317477f, -0.00118631f, 
    -0.24126446f, 0.16496454f, 0.12510508f, 0.05606709f, -0.07790380f, -0.00112531f, -0.03497288f, -0.05636651f, 
    -0.13341002f, -0.03997435f, -0.06263572f, -0.04131282f, -0.00782910f, -0.08632965f, -0.02570648f, 0.01850577f, 
    0.05270276f, -0.07925927f, -0.03563895f, -0.06125680f, 0.17110948f, 0.07356376f, -0.03041306f, -0.01462939f, 
    0.03466285f, -0.09422622f, -0.01514857f, 0.01895416f, 0.01886088f, -0.15033610f, 0.01022751f, -0.03512819f, 
    -0.03393236f, 0.04012055f, -0.05717175f, -0.05072128f, -0.01456175f, 0.05499298f, -0.09761339f, -0.05864185f, 
    0.19920778f, -0.04952906f, -0.02775794f, 0.09897948f, 0.02080702f, -0.01158612f, 0.16774450f, -0.05129739f, 
    0.04648935f, -0.07977124f, -0.04017968f, -0.05697739f, 0.02315702f, 0.05446898f, -0.06402155f, -0.07197201f, 
    -0.02259290f, 0.02451243f, -0.12676102f, -0.13590680f, -0.15376544f, 0.16808252f, 0.05156955f, 0.09368609f, 
    0.09659982f, -0.06936956f, -0.01785134f, 0.03567259f, -0.05748291f, -0.05789947f, 0.02555349f, 0.01923977f, 
    -0.00522039f, -0.13450664f, -0.07308333f, -0.03161122f, -0.01078611f, -0.07177149f, 0.02929060f, -0.00662930f, 
    0.23850213f, 0.02478138f, -0.07020504f, 0.00878160f, 0.08559203f, 0.09239099f, 0.01958353f, -0.01697401f, 
    0.05529495f, 0.01106145f, 0.05326426f, 0.03351947f, -0.01598141f, -0.01220696f, 0.09611697f, 0.00984768f, 
    -0.10215691f, -0.01509281f, 0.07127534f, 0.10107505f, 0.02389420f, 0.05024651f, -0.02664563f, 0.01657138f, 
    -0.11944088f, -0.04676426f, -0.01526358f, 0.04955411f, -0.05006900f, -0.01986796f, -0.12622686f, -0.07170193f, 
    0.12233671f, -0.16261375f, -0.10783490f, 0.04050952f, -0.00210813f, -0.00119934f, -0.05412675f, -0.09988508f, 
    -0.06738547f, 0.00716913f, -0.08335190f, 0.01190376f, -0.03929733f, -0.08249727f, 0.07753117f, -0.02277628f, 
    0.06035021f, 0.11565565f, -0.08106162f, 0.00953883f, 0.01325592f, -0.10583977f, 0.03384056f, 0.02511083f, 
    0.02078290f, -0.03524575f, -0.00463441f, -0.00538744f, -0.17732845f, 0.09622630f, -0.04068609f, -0.10217971f, 
    0.12051450f, 0.06813555f, -0.11785436f, 0.07427131f, 0.05640354f, 0.09521408f, -0.04340613f, 0.03338006f, 
    0.04628731f, -0.00797908f, 0.05551833f, 0.02664759f, 0.08217536f, -0.01085152f, -0.03445458f, -0.01499612f, 
    -0.31126177f, 0.04267529f, -0.05041692f, 0.06451517f, -0.05415883f, 0.06183883f, -0.03958218f, -0.04461483f, 
    0.03354841f, -0.00522479f, -0.05888374f, -0.07529189f, 0.00212574f, -0.00701466f, 0.02818826f, -0.02667901f, 
    -0.00815468f, -0.01002572f, -0.11301091f, -0.07458243f, -0.08782540f, -0.02417992f, -0.06432755f, -0.06089716f, 
    0.12895006f, -0.02027330f, -0.06906945f, 0.02569805f, 0.04659500f, -0.07226375f, 0.03722854f, -0.04059751f, 
    -0.03223687f, -0.00810024f, 0.03374965f, 0.06712239f, -0.03380582f, 0.01381142f, 0.11964426f, 0.02261536f, 
    -0.18263732f, -0.08322673f, -0.02723926f, -0.15153742f, -0.16747713f, -0.02807767f, -0.02657922f, 0.04556144f, 
    0.02657974f, 0.04366974f, -0.03699682f, -0.03350333f, 0.01427907f, -0.03369551f, 0.02396773f, -0.00138006f, 
    -0.03197572f, -0.01530156f, -0.06417134f, -0.03835926f, 0.22501668f, 0.00583484f, -0.11236243f, 0.01817800f, 
    -0.01726268f, -0.08897070f, -0.04015241f, -0.02146030f, 0.02484531f, -0.01004259f, 0.06244233f, 0.00688292f, 
    0.02662964f, 0.02018128f, -0.05400535f, 0.05386677f, 0.00013205f, -0.03212694f, 0.05884586f, 0.02554219f, 
    -0.05547721f, 0.04955585f, 0.06790227f, -0.03646358f, 0.09749835f, -0.07750992f, 0.05498239f, -0.03308807f, 
    -0.00916453f, -0.08172227f, -0.02550932f, -0.00196762f, -0.01516226f, 0.01264125f, 0.03879341f, 0.02867020f, 
    -0.03124694f, 0.03283288f, -0.11140782f, -0.04130178f, -0.29977566f, 0.04224915f, -0.04647198f, -0.06653643f, 
    -0.02669512f, -0.06443922f, -0.00246815f, -0.00008157f, 0.04860640f, -0.00820657f, -0.05526258f, 0.02692576f, 
    0.00586541f, -0.05200427f, -0.07054823f, -0.06685767f, -0.08203241f, 0.01192436f, -0.05923990f, -0.04138944f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02498971f, 0.04893525f, -0.01465521f, -0.01170249f, -0.00110823f, -0.00864138f, -0.02584217f, -0.04071058f, 
    -0.03497818f, 0.03070759f, 0.05687476f, -0.01656556f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
