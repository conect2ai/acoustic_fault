#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02690886f, -0.84168679f, 0.29550993f, 0.61869508f, -0.32765168f, -0.88278693f, 0.53521645f, 0.20676219f, 
    -0.63550997f, -0.16748796f, -0.27392837f, 0.39246058f, -0.15393719f, 0.27112883f, 0.03322064f, -0.12009104f, 
    0.20819743f, -0.24826673f, 0.29715151f, -0.30042592f, -0.02526226f, 0.18208067f, -0.08151229f, 0.24277467f, 
    0.19117686f, -0.32555786f, -0.54839939f, 0.48228636f, 0.30004585f, 0.04388990f, 0.15228221f, 0.37660825f, 
    -0.16663992f, 0.63400561f, 0.64824438f, -0.25174904f, 0.12137203f, -0.00462999f, 0.05208199f, -0.53782278f, 
    -0.06559625f, 0.12736951f, -0.49518478f, 0.23065722f, 0.18298842f, -0.28787160f, 0.08372398f, -0.03601753f, 
    0.19571728f, -0.09371721f, 0.99691612f, -0.03301920f, 0.39088640f, 0.28649974f, 0.70347810f, 0.50902009f, 
    -0.38130131f, -0.10550033f, -0.55360454f, 0.24730520f, -0.02876575f, 0.39714587f, -0.37147424f, 0.27048624f, 
    0.10938756f, -0.11302533f, -0.25580192f, -0.08713064f, -0.04244147f, -0.41213301f, 0.06790617f, -0.03839888f, 
    -0.22192542f, 0.02764439f, 0.07526254f, -0.52211976f, 0.43608731f, 0.92370445f, 0.21836385f, 0.57705420f, 
    0.45098060f, 0.07633641f, 0.24448042f, 0.24673921f, 0.28175053f, -0.12417966f, 0.00521010f, -0.20895940f, 
    -0.05271737f, -0.44280857f, -0.24480130f, 0.22602011f, 0.01372961f, -0.14096409f, -0.10855930f, 0.36060479f, 
    0.16373663f, -0.25179359f, -0.16398093f, -0.27631795f, -0.97012752f, -0.99021780f, -0.41035742f, 0.35572296f, 
    0.08938362f, 0.35093129f, -0.33342829f, 0.06241382f, 0.23210049f, -0.52521414f, -0.06291351f, 0.10610940f, 
    0.11756339f, 0.27309406f, 0.01490043f, 0.11282790f, 0.03471893f, -0.20609863f, -0.02153340f, 0.22531743f, 
    -0.13009816f, 0.09499322f, 0.08047332f, 0.02226820f, -0.02097731f, 0.69101256f, 0.60520047f, 0.70843279f, 
    0.85141742f, 0.51587981f, 0.23245573f, -0.22935353f, -0.36646166f, -0.57484066f, -0.22604229f, 0.37340501f, 
    0.04262087f, -0.04329159f, 0.07370909f, -0.16697839f, 0.08370615f, 0.11578586f, 0.11971594f, 0.10776149f, 
    0.35529166f, 0.19032785f, 0.09449922f, 0.21464853f, 0.12050084f, 0.33133808f, 0.12740770f, -0.17315410f, 
    -0.60647339f, -0.69921750f, -0.55678827f, -0.63771588f, 0.74859625f, 0.58545959f, 0.11673462f, -0.25129321f, 
    -0.18501128f, -0.23019589f, 0.02249327f, 0.04596420f, -0.08165836f, -0.13602878f, 0.01721442f, -0.04244117f, 
    -0.01494352f, -0.02599427f, 0.02366269f, 0.15495226f, -0.08131666f, -0.36042735f, -0.10155077f, -0.59214115f, 
    0.20789623f, 0.40289673f, 0.32697982f, 0.55683303f, 0.28870040f, -0.34923956f, -0.91806918f, -0.24917950f, 
    -0.48038474f, -0.20077437f, 0.15126030f, 0.33754554f, 0.42468500f, -0.09965891f, 0.08438379f, 0.09124751f, 
    0.32176939f, -0.32234305f, 0.04140330f, -0.17726265f, 0.10507932f, -0.21614358f, 0.19136165f, -0.17620376f, 
    0.05639772f, 0.03385649f, -0.35448542f, -0.04930299f, 0.49539188f, -0.85651737f, -0.45525336f, -0.39465708f, 
    -0.43295237f, -0.71830535f, 0.26434502f, 0.44985616f, 0.06997851f, -0.29713720f, 0.48157907f, 0.34776735f, 
    -0.44302037f, -0.13531873f, 0.09849565f, 0.03878669f, -0.10267135f, 0.05245649f, 0.12966944f, 0.02318090f, 
    -0.14446969f, -0.62071967f, 0.19789666f, -0.15710132f, -0.63118690f, -0.56724960f, 0.56849641f, 0.61135411f, 
    0.14494386f, 0.37763813f, 0.54466736f, 0.12598439f, -0.34759682f, -0.44175231f, -0.06672291f, 0.00877256f, 
    -0.04126948f, 0.15679851f, -0.26547667f, -0.01691073f, -0.14164199f, -0.38435930f, -0.13229473f, -0.19194299f, 
    -0.35351658f, 0.02160210f, -0.64868367f, -0.92329735f, -0.43133634f, -0.32945719f, -0.32304177f, -0.30388665f, 
    0.79405016f, 0.13111068f, -0.18746932f, -0.00552601f, 0.10180795f, -0.38827670f, -0.17961127f, 0.42353776f, 
    0.48605913f, 0.04444112f, -0.19543429f, -0.40156525f, -0.36903366f, -0.36095068f, 0.21291074f, 0.05458421f, 
    0.22680125f, 0.28455836f, 0.03732267f, -0.85883814f, -0.89665294f, -0.00020340f, 0.45594314f, -0.24708152f, 
    0.56887174f, 0.95184028f, 0.34015900f, -0.43721128f, 0.40494844f, -0.39917257f, 0.09666721f, 0.19514440f, 
    0.07250157f, -0.04802562f, -0.31507817f, -0.05112372f, -0.02254231f, -0.17600398f, -0.23695880f, 0.19388576f, 
    -0.02063609f, -0.19255039f, -0.17328893f, -0.23241037f, -0.60971671f, -0.68872595f, -0.62670392f, -0.43884093f, 
    0.00399375f, 0.47789952f, 0.75799394f, 0.09930038f, 0.34128067f, 0.30594888f, -0.22191209f, -0.42357108f, 
    -0.06802235f, -0.45214042f, 0.05482256f, 0.01903469f, -0.07997398f, -0.09482000f, 0.20479225f, -0.34165007f, 
    -0.14280282f, -0.36433011f, -0.07820791f, 0.32539240f, 0.00966090f, 0.21115622f, -0.59009075f, -0.51060784f, 
    0.90038556f, 0.62750107f, -0.73115683f, 0.43988433f, 0.32179773f, -0.20489788f, 0.02167922f, 0.47941276f, 
    0.04010372f, -0.10384742f, 0.05984220f, 0.05084661f, -0.00005936f, 0.32432434f, 0.15806417f, 0.09581032f, 
    -0.48343131f, -0.16462761f, 0.12982389f, -0.34641707f, 0.44218293f, -0.25395194f, -0.44492760f, -0.03373145f, 
    -0.74226153f, -0.11943349f, 0.84861076f, -0.15351924f, 0.64698178f, 0.61288381f, 0.42414925f, 0.10710394f, 
    0.06489478f, -0.13885303f, -0.53566742f, -0.14936604f, -0.18986791f, 0.24030583f, 0.06023834f, 0.17498425f, 
    0.01412440f, 0.12420660f, 0.21743365f, -0.00625073f, -0.12300230f, -0.18769975f, 0.10624028f, -1.10432351f, 
    0.96261483f, 0.57382309f, -0.91452426f, -0.02726736f, -0.06029911f, 0.61026883f, 0.24338156f, -0.02672430f, 
    0.28511536f, -0.24080504f, 0.37863395f, 0.23089853f, -0.09922591f, 0.18278559f, 0.07047573f, -0.10874531f, 
    -0.09862418f, -0.13178444f, -0.20497397f, 0.17616431f, 0.09055001f, 0.28391197f, 0.16672461f, 0.04026950f, 
    -0.74187332f, -0.21433486f, -0.56112063f, -0.48617324f, -0.60651112f, 0.03990988f, -0.09761773f, -0.49424097f, 
    0.06320208f, 0.15997158f, 0.38460103f, 0.24823187f, -0.17980181f, -0.02470049f, -0.09659326f, -0.02250672f, 
    0.37541416f, 0.20132178f, 0.25191829f, 0.12479670f, -0.19754019f, 0.35624459f, -0.05197452f, -0.18882330f, 
    -0.32502949f, -0.05306984f, -0.66335624f, -0.21751109f, 0.23195295f, 0.09805791f, 0.15518214f, 0.49300826f, 
    0.56997091f, 0.39550281f, 0.53551853f, 0.26567137f, -0.28899044f, -0.04512348f, 0.41667801f, 0.05809584f, 
    0.13093829f, 0.13884167f, 0.19443519f, 0.13668291f, 0.04789896f, 0.09848476f, 0.05518195f, -0.23702668f, 
    -0.18096536f, 0.08492133f, 0.20309426f, -0.59961545f, 0.70341355f, 0.58856463f, -0.49609733f, -0.80619413f, 
    0.49387819f, -0.54190379f, 0.12324019f, 0.13126245f, 0.44971326f, 0.18205431f, -0.22871587f, -0.12332069f, 
    -0.21652086f, -0.30187416f, -0.21533562f, -0.15752113f, 0.06374171f, 0.27537942f, -0.10146989f, 0.18881315f, 
    0.28769457f, -0.00123980f, 0.05310224f, 0.82950670f, 0.94077915f, -0.00822884f, -0.46627563f, -0.36576715f, 
    -0.27906281f, -0.14269224f, -0.16929783f, 0.05505944f, -0.25403157f, 0.08765861f, -0.07769974f, -0.30344436f, 
    0.34675345f, -0.04752304f, -0.25211412f, 0.11827785f, -0.39866129f, -0.19668083f, -0.13480891f, -0.24102180f, 
    0.20782346f, -0.10305008f, 0.09125184f, -0.01153334f, 0.74342132f, -0.23394543f, -0.39501292f, -0.12684299f, 
    0.07106606f, 0.68911511f, 0.02948762f, 0.39577007f, 0.44504055f, -0.49481687f, 0.13953349f, 0.17759418f, 
    0.04476796f, -0.28148177f, -0.11176077f, 0.21108004f, -0.43535268f, 0.12640630f, -0.13473305f, 0.08146337f, 
    0.39407903f, 0.11730424f, 0.11540852f, 0.35122195f, -0.09535395f, -0.37341830f, -0.61358619f, -0.54111797f, 
    -0.24230903f, 0.00726944f, 0.06293183f, 0.61004275f, -0.37594125f, 0.10534893f, 0.37003484f, -0.21920361f, 
    -0.07949241f, -0.36679891f, -0.15736695f, -0.02516584f, -0.24215212f, 0.52023518f, 0.17191458f, -0.39302415f, 
    -0.04809735f, 0.27652055f, 0.05834086f, 0.41184446f, 0.01114969f, 0.30725920f, -0.13274434f, -0.69891685f, 
    -0.10756223f, 0.61944026f, 0.15484984f, -0.55151767f, -0.68751264f, -0.23602545f, -0.54563445f, -0.03916053f, 
    -0.24025400f, 0.13961805f, -0.01242503f, 0.21830976f, 0.13565001f, 0.30372101f, -0.01748480f, 0.13947320f, 
    -0.01467943f, 0.56523889f, 0.24359107f, 0.00243349f, 0.19082938f, -0.07032580f, -0.29544115f, 0.83429968f, 
    0.60681486f, 0.40078858f, 0.76848787f, 0.57629728f, -0.43247899f, 0.43998808f, 0.12792289f, 0.38095227f, 
    0.00839379f, -0.44088939f, -0.19188845f, 0.15353130f, 0.01349551f, 0.28844056f, 0.26994967f, 0.21935502f, 
    0.02825529f, -0.28233364f, 0.05319051f, 0.26990184f, 0.28942269f, 0.02380851f, 0.28649667f, 0.10078873f, 
    0.94549060f, 0.21023549f, 0.26019922f, -0.11683168f, 0.14136709f, 0.54668462f, 0.11885317f, -0.18922421f, 
    0.34928226f, 0.49161786f, 0.10754312f, 0.28685954f, 0.02512593f, 0.21395770f, -0.08906428f, 0.07517036f, 
    0.22373919f, -0.03191997f, -0.34682319f, 0.32584190f, -0.01798533f, 0.15672748f, 0.19908828f, 0.11167643f, 
    0.04118786f, -0.12105137f, -0.65140486f, -0.00503206f, 0.87752712f, -0.04400854f, -0.56719011f, 0.16168132f, 
    -0.34085387f, -0.36861661f, 0.30594981f, 0.31848669f, -0.05650042f, 0.32624045f, -0.19794954f, 0.16302338f, 
    -0.38995594f, 0.48632538f, 0.48212519f, -0.08765545f, -0.01189594f, -0.24327488f, -0.00358507f, 0.34303865f, 
    -0.34115797f, 0.34628877f, 0.11392434f, -0.78640383f, 0.14249860f, 0.18425266f, 0.11813658f, -0.84355181f, 
    0.65086824f, 0.38324130f, -0.30424404f, 0.60700411f, -0.02779467f, 0.53053552f, 0.00414095f, -0.11786605f, 
    0.18635002f, -0.46948758f, -0.35392913f, -0.16675885f, -0.10806473f, -0.22633721f, -0.08665536f, -0.22765559f, 
    -0.04203557f, -0.17093737f, -0.13372260f, 0.94731301f, 0.41282529f, 0.93968707f, -0.73801833f, -0.64845580f, 
    0.21782109f, 0.15847205f, -0.30746573f, -0.31827086f, 0.30653071f, 0.42909944f, 0.40775666f, -0.14644982f, 
    -0.15618074f, -0.15802890f, 0.04971455f, -0.05289302f, 0.09707279f, 0.03577852f, -0.05687274f, 0.13120325f, 
    0.12194646f, -0.08992766f, -0.15007585f, 0.27758074f, 0.63331968f, -0.13359225f, 0.22979201f, 0.38993099f, 
    0.67157906f, -0.14015728f, 0.43745887f, 0.33223817f, -0.39254352f, 0.43054834f, -0.12060521f, 0.04907395f, 
    0.33675241f, 0.06779003f, 0.13871317f, 0.02060827f, 0.16656375f, 0.13856888f, -0.09718761f, 0.17933449f, 
    0.27184662f, -0.13952361f, -0.27385932f, -0.08623400f, 0.15938765f, -0.00001720f, 0.50618148f, -0.06346450f, 
    -0.79588461f, -0.17872083f, -0.01501436f, -0.19822630f, -0.19797991f, -0.50925797f, -0.55912197f, -0.06664225f, 
    0.49703321f, 0.26057389f, 0.18704653f, -0.20028517f, -0.11845381f, 0.06037753f, 0.15728410f, 0.26651818f, 
    0.49157354f, 0.14691325f, -0.16704695f, -0.20880069f, -0.04793974f, 0.29125604f, -0.77921915f, -0.24106510f, 
    -0.52296883f, 0.61839342f, 0.17935260f, 0.30075714f, 0.01485686f, 0.38937393f, -0.06540296f, -0.76320332f, 
    -0.25784332f, -0.06749057f, -0.48851731f, -0.38733634f, -0.44423455f, -0.18779628f, 0.16045730f, -0.32360065f, 
    -0.17272642f, -0.32158419f, -0.22884700f, -0.00300173f, 0.12462582f, 0.10017407f, -0.10092724f, -0.26200032f, 
    0.76146591f, 0.07666396f, -0.40176672f, -0.37197548f, -0.53889507f, 0.61622089f, -0.19227412f, -0.32068947f, 
    0.20585917f, 0.29517213f, 0.10077222f, -0.40913135f, -0.23339561f, -0.04214747f, 0.07539661f, 0.07140577f, 
    0.47413212f, -0.27418751f, 0.11420819f, -0.38257277f, -0.17387098f, 0.08872084f, -0.06323552f, -0.05681215f, 
    -0.65694392f, 0.88087267f, 0.69921941f, -0.69468254f, -0.01969633f, -0.54996502f, 0.21260899f, 0.36590046f, 
    -0.00000104f, -0.21354879f, -0.00913241f, 0.27052459f, -0.33347356f, -0.07785226f, -0.05793934f, 0.23289472f, 
    -0.24586090f, 0.21675040f, 0.19266775f, 0.24029584f, -0.10325529f, 0.11399599f, -0.15375632f, -0.08799249f, 
    0.06802623f, -0.08748551f, 0.39270076f, 0.61232901f, 0.52447855f, 0.37751079f, -0.77015185f, 0.20938423f, 
    -0.29404530f, -0.34798947f, 0.25871682f, 0.47999591f, 0.22930315f, -0.26511449f, 0.17846543f, -0.13706648f, 
    0.45642531f, 0.16549350f, -0.15260118f, 0.07190991f, 0.12053362f, -0.17787936f, -0.19292685f, 0.04430699f, 
    -0.22299570f, -0.23538077f, -0.51632231f, -0.77481568f, -0.61829662f, -0.46510631f, -0.09924833f, -0.66608870f, 
    0.15368015f, -0.34427404f, -0.35763776f, 0.31373599f, 0.25918433f, 0.08726358f, 0.12740162f, 0.03971412f, 
    -0.10292414f, -0.02547191f, -0.42061314f, 0.28455898f, -0.27689248f, -0.33385029f, 0.04713285f, 0.31812933f, 
    -0.08992410f, 0.17823893f, -0.06388745f, -0.36931223f, -0.55571461f, -0.44010079f, -0.32488203f, -0.29301849f, 
    0.00937519f, 0.12182540f, 0.60322207f, 0.21559952f, 0.09788176f, 0.14102468f, -0.24124090f, 0.02034282f, 
    -0.40851548f, 0.11913393f, 0.25506535f, 0.11575490f, -0.10308728f, -0.02780839f, 0.18581297f, 0.06197423f, 
    0.12775646f, 0.38570601f, 0.44025332f, -0.12576780f, 0.52741146f, 0.18990111f, 0.27695036f, 0.38039845f, 
    0.43905234f, -0.37595850f, 0.48475799f, 0.30895063f, 0.06007341f, 0.27159441f, -0.00094043f, 0.08986907f, 
    0.17504619f, -0.01248744f, -0.33067733f, 0.60528749f, -0.21046881f, -0.28187218f, -0.07098641f, -0.02519030f, 
    -0.16291721f, -0.42271340f, -0.21135488f, 0.36514166f, -0.32484165f, 0.52219695f, 0.64591271f, 0.13916436f, 
    0.19800733f, 0.36830154f, 0.50876594f, 0.31505793f, -0.02035061f, 0.21692313f, 0.61999863f, -0.11615855f, 
    -0.27358672f, 0.27672851f, -0.59257084f, -0.12107195f, -0.34143892f, -0.38475624f, -0.25861436f, -0.15308404f, 
    -0.05107721f, -0.36385077f, -0.25832161f, 0.17612025f, -0.00725611f, -0.05421557f, -0.24596192f, 0.81846708f, 
    -0.22370866f, -0.59853709f, -0.69361836f, 0.55533540f, -0.29392156f, -0.60468817f, 0.04211376f, 0.25818583f, 
    -0.11594161f, 0.15663806f, 0.29460210f, 0.40042120f, -0.33705088f, -0.05159351f, -0.06680825f, 0.21654679f, 
    0.12683587f, -0.46298808f, -0.05320021f, 0.04895026f, 0.18293926f, -0.02339929f, 0.10454260f, 0.86596119f, 
    1.00300670f, 0.28415248f, 0.32394972f, -0.33269268f, -0.29730502f, -0.04108866f, -0.42009643f, 0.22163817f, 
    0.30749437f, -0.00033146f, 0.19309239f, 0.01001760f, 0.26815358f, -0.01296526f, -0.33011937f, -0.39371744f, 
    0.29938203f, -0.15946735f, 0.06152080f, -0.31376541f, 0.35402587f, -0.20337082f, -0.30158430f, 0.20881207f, 
    0.59800875f, 0.53888881f, -0.59197593f, -0.37255371f, -0.84287661f, 0.52639103f, 0.57814443f, 0.24429464f, 
    -0.01171561f, 0.15573876f, 0.17682363f, -0.29888824f, 0.09729936f, 0.36713821f, 0.14528266f, -0.17374432f, 
    -0.45687243f, 0.27474689f, -0.01914122f, 0.26612309f, 0.11352075f, -0.45420882f, 0.17209359f, 0.12480477f, 
    0.05171689f, -0.40866393f, -0.60808653f, -0.68416357f, -0.43173262f, -0.18181121f, -0.41211095f, -0.23464134f, 
    0.07684642f, -0.17021593f, 0.28288063f, 0.03988412f, 0.17871298f, 0.04371292f, -0.35690045f, -0.16194771f, 
    0.00149541f, 0.13030913f, 0.03510509f, -0.05073148f, -0.35673890f, -0.32723355f, -0.44921410f, 0.00484447f, 
    -0.27627602f, 0.00679044f, -0.56447893f, 0.05946200f, -0.38681147f, -0.63732702f, 0.09737823f, -0.66207242f, 
    -0.35823894f, 0.32713249f, -0.34827858f, 0.32426247f, 0.28823107f, -0.20426676f, 0.46750015f, 0.13037845f, 
    0.11857365f, 0.34314755f, 0.44119266f, 0.31387368f, 0.23433016f, -0.24201848f, -0.34984741f, -0.37685806f, 
    0.06205975f, -0.20111863f, 0.35418022f, 1.11652017f, 0.49737874f, -1.30042684f, 0.43804777f, -0.43733275f, 
    -0.47798735f, 0.48348781f, -0.03167629f, 0.17040607f, 0.26628679f, 0.26759636f, -0.05446941f, 0.30355862f, 
    -0.21224858f, 0.29956388f, 0.07688006f, -0.14477839f, 0.10113831f, -0.15911387f, 0.26627874f, -0.05844514f, 
    -0.07740143f, 0.19147758f, 0.00695130f, 0.05734786f, 0.50026453f, 0.47828853f, 0.65895069f, 0.52432644f, 
    0.25751939f, -0.72029102f, -0.50152642f, -0.45204809f, -0.08666096f, -0.02704398f, 0.34548020f, 0.19283125f, 
    0.09097113f, 0.31866997f, -0.33156702f, -0.04367037f, 0.04562806f, 0.12079708f, 0.12539257f, 0.16095750f, 
    0.22049095f, 0.16969790f, -0.10410571f, 0.20935006f, 0.26590681f, 0.49037918f, -0.76526445f, -0.08687522f, 
    0.89390963f, -0.44431227f, -0.03858373f, 0.39371070f, -0.37985152f, 0.24123162f, -0.66419441f, -0.45059842f, 
    -0.30194572f, -0.36550018f, -0.18369661f, 0.03630537f, -0.26619166f, -0.26550841f, -0.23606469f, -0.25742525f, 
    -0.05224878f, -0.28129658f, 0.50418055f, 0.08400083f, 0.11261214f, -0.41047749f, 0.68896431f, 0.02576156f, 
    -0.90864849f, -0.48646736f, 0.15580171f, -0.10002792f, -0.55852610f, -0.43630478f, -0.54565203f, 0.21487340f, 
    -0.31005934f, 0.18731701f, 0.30086347f, 0.30237541f, -0.24983515f, -0.26751718f, -0.10910358f, -0.43098596f, 
    -0.22600560f, 0.13259837f, 0.18969139f, 0.20347154f, 0.52705479f, -0.01957150f, 0.19585310f, 1.04490495f, 
    0.51296806f, -0.18209243f, -0.34867206f, 0.13843240f, -0.51902115f, -0.61514491f, 0.18676250f, -0.01811470f, 
    0.21672715f, -0.06710494f, -0.08693717f, 0.37253579f, 0.14761132f, -0.16420875f, 0.30474722f, -0.15749544f, 
    -0.36359537f, -0.12817106f, 0.55554992f, -0.23161542f, 0.09986269f, 0.13643183f, -0.34725267f, -0.04051445f, 
    0.10317384f, 0.83664513f, 0.52241099f, -0.67934304f, 0.08399340f, -0.37036663f, 0.05384827f, -0.37330049f, 
    0.23730311f, -0.34829667f, 0.19747706f, -0.29732752f, -0.26560885f, 0.28950804f, 0.01729777f, 0.01837226f, 
    -0.25487116f, 0.20688896f, 0.05694277f, 0.00483031f, 0.01698945f, 0.00442854f, -0.00347623f, 0.24034162f, 
    -0.21531601f, -0.91557348f, 0.88232058f, 0.03091726f, -0.33558673f, 0.49320531f, -0.82011932f, 0.37792388f, 
    -0.16754353f, -0.36664996f, -0.30126345f, 0.15003702f, 0.23288862f, 0.10689400f, -0.29048938f, -0.29387596f, 
    0.01629408f, 0.18666837f, -0.04818233f, 0.12041295f, -0.08591998f, -0.06734830f, 0.05800978f, 0.20334493f, 
    0.02551716f, -0.10271545f, 0.49139088f, 0.52579224f, 0.48323971f, 0.16512719f, 0.76499498f, 0.52364558f, 
    -0.53742403f, -0.56486076f, -0.37718764f, -0.51771683f, 0.17423552f, 0.21581398f, -0.05629993f, 0.24532518f, 
    -0.01291937f, 0.51013488f, -0.01304473f, -0.23166817f, 0.17209393f, 0.01976553f, -0.03948912f, -0.00455453f, 
    0.19934356f, -0.17082310f, 0.46732599f, -1.06247330f, 0.58938289f, -0.58435708f, 0.83173305f, -0.54547507f, 
    0.39417514f, 0.54984331f, -0.19040757f, 0.06260656f, -0.31252447f, 0.21118915f, -0.12456329f, -0.26356438f, 
    -0.23039141f, 0.01795047f, 0.05288270f, 0.24947910f, 0.42182988f, 0.29016015f, -0.19640817f, 0.14061666f, 
    -0.48926091f, -0.32807827f, 0.00375165f, 0.00626265f, -0.76714075f, 0.17330728f, 1.03495800f, 0.22575712f, 
    0.44512630f, 0.56426781f, 0.43964270f, 0.45541039f, 0.42617741f, -0.34089419f, -0.43370512f, -0.31384304f, 
    -0.16195270f, 0.27687547f, 0.03430524f, 0.00637779f, 0.06967004f, -0.31104746f, 0.19602175f, 0.09652317f, 
    -0.14058539f, 0.14722431f, -0.26496381f, 0.03635229f, 0.07158951f, 0.89159465f, 0.50076008f, 0.64998418f, 
    0.73319191f, 0.67780423f, 0.43869057f, 0.27129477f, -0.23750018f, -0.50579244f, -0.17501737f, 0.14696868f, 
    0.17084445f, -0.18800692f, 0.04952840f, -0.40639505f, -0.00340056f, -0.15431017f, 0.34403390f, 0.17891741f, 
    -0.13149749f, 0.07069332f, 0.50506830f, 0.17751555f, -0.12363796f, -0.11441810f, 0.43615377f, 0.04721717f, 
    0.54113865f, 0.75324023f, -0.26394674f, 0.60683197f, 0.66175628f, -0.39210811f, -0.10145401f, 0.06792440f, 
    -0.24675913f, -0.36848336f, -0.36937228f, 0.07168211f, -0.13211903f, 0.00753482f, 0.04809920f, 0.23546337f, 
    0.28434753f, 0.04540126f, -0.11274342f, 0.10096062f, -0.23992187f, -0.19953835f, 0.29828289f, -0.10200732f, 
    -0.90334833f, 0.57563704f, 0.07983923f, -0.21867995f, 0.34295696f, 0.52159250f, 0.91447443f, 0.17124547f, 
    0.13695891f, -0.22793025f, -0.03090460f, -0.12688282f, 0.08274110f, -0.35618424f, 0.19513568f, -0.26500046f, 
    -0.24508834f, -0.33087417f, 0.05283923f, -0.37528202f, -0.07957429f, 0.33992565f, -0.12108016f, -0.14360690f, 
    0.79950279f, 0.67499161f, 0.18021601f, 0.25075856f, 0.48289925f, -0.28657785f, 0.18073648f, -0.01642246f, 
    0.24520692f, 0.45695770f, -0.29725206f, -0.16285557f, -0.17691395f, -0.20960318f, -0.21288963f, -0.28228202f, 
    -0.15582819f, 0.02161115f, -0.14359222f, -0.00321946f, 0.39508876f, 0.15817755f, 0.39991468f, 0.17664516f, 
    0.36880749f, -0.79982847f, 0.37157872f, -0.54685682f, -0.47824973f, 0.36830685f, -0.47155875f, 1.00366819f, 
    0.28402308f, -0.35000354f, 0.70848370f, -0.12853156f, 0.03917593f, 0.19995329f, -0.60542470f, 0.19307981f, 
    0.04900639f, 0.06108889f, -0.08314511f, 0.34720114f, -0.06781562f, 0.16124851f, 0.05216242f, -0.10484405f, 
    -0.01028857f, 0.19950256f, 0.01646971f, 0.04244877f, 0.08824456f, 0.45551431f, -0.26235673f, -0.11750484f, 
    -0.66292930f, -0.45623875f, 0.38383189f, -0.17705859f, 0.34793079f, 0.25945845f, -0.06354859f, 0.32270524f, 
    -0.22664779f, 0.35314712f, 0.35676196f, -0.22478604f, 0.12966155f, 0.17800339f, -0.48544392f, 0.26984346f, 
    0.36654001f, 0.41403025f, -0.18062662f, 0.84553993f, 0.42803684f, 0.63367683f, -0.22926673f, -0.75401664f, 
    0.26776892f, -0.31052652f, 0.52295285f, -0.17708638f, 0.57863092f, -0.15310764f, 0.10718848f, -0.30201125f, 
    -0.17451420f, -0.42178470f, -0.03994877f, 0.01717492f, -0.10645088f, -0.20765628f, -0.06078802f, 0.04587751f, 
    0.11794866f, 0.07957193f, -0.25064641f, -0.48784554f, 0.88618124f, -0.53917134f, -0.60934561f, 0.38920683f, 
    0.18754971f, -0.00308665f, -0.06788734f, -0.39172810f, -0.19672956f, 0.00400460f, 0.04281054f, 0.26986450f, 
    -0.26011032f, -0.07056124f, 0.28263128f, -0.06083991f, 0.34608623f, 0.33364311f, 0.31912702f, 0.30781019f, 
    -0.20694400f, -0.10901005f, -0.46719772f, -0.29709679f, -0.20163691f, 0.20122814f, 0.24741161f, 0.09004561f, 
    0.79851860f, -0.40728065f, -0.29811844f, -0.21908301f, 0.45050016f, -0.33260784f, -0.46980211f, -0.42122191f, 
    -0.22208822f, 0.10002200f, 0.40713722f, -0.20726056f, -0.28526032f, -0.10325338f, 0.24764284f, -0.02324579f, 
    -0.24466325f, 0.09676208f, -0.15345730f, -0.17844181f, -0.16425450f, -0.47394440f, -0.16710217f, -0.27702194f, 
    -0.76364905f, -0.62891513f, -0.08142136f, 0.61717504f, 0.21463856f, -0.28810653f, 0.36437431f, 0.45483956f, 
    -0.44122547f, 0.25016558f, -0.08556738f, 0.05341841f, -0.14566855f, 0.18129137f, -0.07700260f, -0.01457968f, 
    0.33779094f, 0.24250628f, 0.04717703f, 0.15948175f, -0.40178058f, -0.02851928f, 0.37367296f, -0.65998054f, 
    0.85664314f, 0.53972930f, -0.57097822f, -0.17340729f, -0.04191785f, -0.18131094f, -0.11915894f, -0.31934494f, 
    -0.85602158f, -0.17465636f, 0.29607725f, -0.43168661f, 0.12994024f, 0.06933007f, -0.33299005f, 0.02507786f, 
    -0.50350261f, -0.32247710f, 0.17120911f, 0.33169410f, -0.02947387f, 0.33154637f, 0.21625893f, -0.08951037f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18874379f, 0.06673156f, 0.05966330f, 0.07039928f, 0.31418702f, 0.04960601f, 0.19705746f, 0.11582103f, 
    0.03960499f, 0.02871502f, 0.13246946f, 0.13743259f, -0.08089679f, -0.02320537f, -0.14286782f, 0.04287977f, 
    0.29701361f, 0.12077796f, 0.14566337f, 0.27329838f, 0.04138184f, -0.03871854f, -0.00223055f, 0.30028298f, 
    0.32937673f, 0.10358454f, 0.02070123f, 0.02073261f, 0.04499946f, 0.44350174f, 0.14022958f, 0.10741806f, 
    0.12080626f, 0.19505712f, 0.08716902f, 0.11353449f, 0.10054160f, 0.15538880f, 0.20525560f, 0.14210939f, 
    0.14605653f, 0.15147801f, 0.31431344f, 0.23558122f, 0.24377787f, -0.10002891f, 0.36670378f, 0.22182083f, 
    0.08792435f, 0.19546431f, 0.13907506f, -0.06316561f, 0.17264684f, -0.03438059f, 0.01802600f, 0.12109730f, 
    0.34950712f, 0.16602740f, 0.12059380f, 0.02403694f, 0.07083352f, -0.01083969f, 0.05110435f, 0.17315949f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00698971f, -0.11435762f, -0.10874943f, 0.28985551f, -0.04194413f, 0.07032456f, -0.05052399f, -0.02438644f, 
    0.02474448f, 0.09635353f, -0.01501332f, -0.03485375f, 0.03284057f, 0.02332956f, -0.13959344f, 0.17688768f, 
    -0.04928595f, -0.00382415f, -0.00017343f, 0.08727980f, -0.17198826f, 0.00504800f, -0.06437626f, -0.09631439f, 
    0.25318196f, -0.18957494f, 0.11715700f, -0.00316619f, -0.19205575f, -0.13236918f, 0.02165391f, 0.04485358f, 
    -0.19594532f, 0.02938749f, 0.04293020f, -0.09597659f, -0.25832739f, -0.03518834f, 0.12502329f, 0.07180726f, 
    -0.04567411f, -0.03929718f, 0.08144743f, -0.16794279f, -0.05911941f, 0.01088975f, 0.02710191f, 0.00822710f, 
    -0.21152003f, -0.12895924f, -0.15912151f, 0.10571193f, 0.12917002f, 0.00091600f, -0.02528748f, 0.05968098f, 
    0.04148644f, -0.03301283f, 0.03687932f, -0.15923312f, 0.18060115f, 0.05893749f, 0.02848649f, 0.09029655f, 
    -0.17872956f, -0.04233462f, -0.01967746f, 0.11071463f, -0.01418273f, -0.06821936f, -0.04649442f, -0.00672996f, 
    -0.32914051f, 0.09565520f, -0.05888421f, -0.38854977f, -0.08830233f, 0.04035811f, 0.01712154f, 0.00321159f, 
    0.00990886f, -0.00028242f, 0.02495255f, 0.10006050f, -0.23404147f, -0.09783475f, 0.15243594f, 0.12647101f, 
    0.08888074f, -0.20673509f, 0.02112144f, -0.04168269f, 0.12486645f, -0.01735491f, -0.08269698f, -0.03272817f, 
    0.02092439f, 0.02749430f, 0.05347326f, 0.02950105f, 0.07469770f, -0.08698519f, 0.01357926f, 0.12882791f, 
    -0.00595773f, -0.00628669f, 0.06849881f, -0.09749058f, 0.35745746f, 0.11568092f, 0.13165221f, -0.21589552f, 
    -0.01667538f, 0.16935235f, 0.05166774f, 0.07646367f, 0.03990953f, 0.08549685f, -0.04194898f, 0.00504397f, 
    -0.03852219f, 0.08375239f, 0.05572650f, -0.23188570f, 0.05800479f, 0.05860291f, -0.03232707f, 0.00182925f, 
    0.08068624f, 0.07254805f, -0.04476726f, 0.02091154f, 0.03036757f, 0.24565309f, 0.13044368f, -0.00789577f, 
    -0.03162041f, 0.03616250f, -0.01988662f, 0.04394362f, 0.01610137f, -0.05872244f, -0.03082387f, -0.03752835f, 
    0.19535215f, 0.20635721f, 0.15737033f, -0.20368423f, 0.14006279f, 0.04386172f, -0.03289416f, 0.05297354f, 
    -0.07917889f, -0.02132314f, -0.09848379f, 0.15891799f, 0.01266179f, 0.19630083f, -0.07537156f, 0.26036754f, 
    -0.01396109f, -0.01836541f, -0.08244141f, -0.11365790f, -0.05393873f, -0.01767793f, -0.01821616f, 0.05114516f, 
    -0.14374843f, 0.31708303f, 0.19182940f, -0.24204800f, 0.03504020f, 0.05716734f, 0.09598161f, 0.02649085f, 
    -0.07628313f, 0.06371091f, -0.03827066f, 0.13292743f, 0.20186883f, -0.03962289f, 0.03403144f, -0.15980917f, 
    0.03279446f, 0.03269932f, 0.06099122f, -0.04875666f, 0.10112365f, -0.09544585f, 0.05237675f, -0.05211100f, 
    0.18697579f, -0.27866295f, -0.01835021f, -0.02970990f, -0.07362792f, 0.00297518f, 0.09603175f, -0.04064063f, 
    -0.02196272f, 0.06723272f, 0.03213668f, -0.09834308f, -0.04322914f, 0.16421108f, -0.07508944f, -0.00719586f, 
    0.13791221f, 0.09100253f, -0.02150689f, -0.14325367f, 0.02878321f, -0.05918957f, -0.06928048f, 0.05071306f, 
    0.15094016f, -0.19082212f, -0.11233878f, 0.26582474f, -0.05534460f, -0.12345713f, -0.02084170f, -0.05643774f, 
    0.04331054f, 0.05555727f, -0.09976796f, 0.01765363f, -0.02918545f, 0.16038921f, -0.11082193f, -0.25734735f, 
    -0.10896332f, -0.03160423f, -0.02082404f, 0.02400402f, -0.03036427f, -0.05937661f, -0.06211488f, -0.01101588f, 
    0.24049754f, 0.12825699f, -0.04722536f, -0.10973521f, 0.03051453f, 0.09501889f, -0.00458680f, -0.06556869f, 
    -0.04667853f, 0.00493614f, 0.08853231f, -0.01703008f, 0.06945864f, 0.04662032f, 0.08660688f, -0.15523158f, 
    0.02712198f, 0.03425762f, -0.02682182f, 0.13653429f, 0.01131219f, 0.08910667f, -0.01428936f, 0.09782798f, 
    0.08309997f, -0.21422333f, -0.14662379f, 0.19277497f, 0.09105534f, 0.03271921f, -0.08578502f, 0.02184795f, 
    -0.02856943f, -0.17436899f, -0.03446082f, 0.01601413f, 0.13975066f, 0.04176339f, -0.13378567f, 0.16466202f, 
    -0.15447357f, -0.07025372f, 0.02075013f, 0.02189530f, -0.01963282f, 0.06115087f, -0.07703902f, -0.12020357f, 
    0.15828422f, -0.16089697f, -0.04337584f, -0.01790075f, -0.01339983f, -0.12329349f, -0.01631433f, 0.07146867f, 
    -0.04653932f, 0.11149709f, 0.00282868f, 0.01083673f, 0.04764454f, -0.08132458f, -0.22246839f, 0.23026845f, 
    -0.05085051f, -0.00663699f, -0.04635559f, -0.10259019f, -0.02504909f, 0.09519199f, -0.25027385f, 0.10666354f, 
    -0.29201564f, -0.24683900f, -0.19100556f, 0.05638713f, 0.01399450f, -0.03118102f, -0.03733591f, -0.10024832f, 
    0.08308546f, 0.03105130f, 0.07435829f, 0.14430422f, -0.25788480f, 0.18004553f, 0.17027462f, -0.27805883f, 
    -0.03156442f, -0.10398374f, 0.03979096f, -0.00315254f, -0.05547608f, 0.02467484f, -0.04990474f, 0.07242744f, 
    0.12003107f, -0.15342827f, -0.03896069f, -0.00246772f, -0.06693152f, -0.01307575f, -0.10907742f, 0.06488920f, 
    -0.08646744f, -0.04608167f, -0.03348312f, 0.01944296f, -0.37702641f, 0.22785379f, 0.17522289f, -0.27524546f, 
    -0.02259611f, 0.12249252f, -0.00008633f, -0.00371688f, -0.05406640f, -0.14125001f, -0.04455681f, 0.04291163f, 
    -0.12021929f, 0.11790957f, -0.04203218f, 0.01659347f, 0.01076002f, -0.01755218f, -0.08679194f, 0.03887178f, 
    0.03241327f, -0.04619667f, 0.11259899f, -0.05516272f, 0.01847357f, -0.04487035f, 0.01269475f, -0.09206638f, 
    -0.02918106f, 0.01673189f, 0.00902483f, -0.11477856f, -0.07994247f, 0.05830815f, 0.19538896f, -0.08114354f, 
    -0.35469314f, 0.11293553f, 0.14808683f, -0.07061679f, -0.00473396f, -0.09434696f, 0.02658636f, -0.06568725f, 
    -0.03341854f, -0.06261209f, 0.09515014f, -0.00933701f, 0.02212685f, -0.03867890f, -0.03641409f, 0.06629024f, 
    -0.04427785f, 0.02118420f, 0.04703301f, -0.02798276f, 0.04184751f, -0.00997929f, 0.03405108f, -0.09959591f, 
    -0.35256413f, -0.18038908f, -0.10496304f, 0.04270686f, 0.00432430f, -0.11637371f, -0.05903028f, 0.07725598f, 
    -0.05164286f, 0.03649042f, -0.00492355f, -0.07418585f, -0.01861049f, 0.11832245f, -0.04668624f, -0.27153677f, 
    0.05683672f, 0.06961835f, -0.03274053f, -0.05684217f, -0.00347232f, -0.01332027f, 0.01316840f, 0.04943620f, 
    0.10035276f, -0.09237817f, -0.06602016f, 0.02987315f, -0.07361566f, 0.08200756f, -0.09518681f, 0.08702142f, 
    0.05569636f, -0.04138603f, 0.15112774f, -0.15661451f, 0.09883016f, -0.03556728f, 0.06186228f, 0.05878884f, 
    -0.10743135f, 0.02603865f, -0.02261876f, 0.07690651f, -0.05922277f, 0.05853423f, 0.08522992f, -0.02605514f, 
    0.16783281f, 0.03338041f, 0.05337853f, -0.26579463f, 0.01058426f, -0.01603075f, -0.02518736f, -0.11847948f, 
    0.03057216f, 0.05905598f, -0.16211453f, -0.00911254f, 0.02418905f, -0.00875480f, -0.08320910f, -0.02720008f, 
    -0.11386757f, 0.06167062f, -0.13858725f, 0.03182320f, 0.04268177f, 0.12751091f, -0.11626202f, -0.01428703f, 
    0.01627261f, 0.05693280f, -0.09907536f, -0.31587481f, -0.15504757f, 0.07185999f, -0.03429282f, 0.01828685f, 
    -0.10913771f, 0.07868444f, -0.03479384f, 0.19226782f, -0.07757792f, -0.25288516f, 0.01892047f, -0.18688089f, 
    -0.02142744f, -0.03837499f, 0.02362032f, 0.06093258f, 0.00680615f, -0.00553779f, -0.10258467f, -0.03933160f, 
    -0.27851540f, -0.11404198f, 0.00036969f, -0.03568129f, -0.01647872f, -0.09528826f, -0.02888599f, -0.01865227f, 
    0.02627694f, 0.05288275f, -0.07288333f, -0.02193760f, -0.26972091f, 0.03710030f, 0.07983403f, 0.04803645f, 
    -0.13306761f, -0.06164800f, 0.05626438f, 0.04755756f, 0.02042053f, 0.04377478f, 0.02864377f, 0.02438954f, 
    0.08530160f, -0.00128757f, -0.01489570f, 0.10805262f, -0.06125228f, -0.13981891f, -0.06337983f, -0.00727331f, 
    -0.01230104f, -0.03683858f, -0.01502666f, 0.02873897f, -0.01433617f, -0.00654344f, -0.13910657f, 0.29873678f, 
    0.06971647f, 0.12170851f, -0.10320371f, 0.00830233f, -0.00256158f, -0.07073085f, 0.08881564f, -0.05055495f, 
    0.08540418f, -0.17636310f, 0.09062817f, -0.19464864f, 0.01662688f, 0.02539947f, 0.04708048f, 0.04018278f, 
    -0.11424761f, 0.05454166f, -0.07216899f, 0.00180910f, 0.04543810f, -0.12604178f, -0.04961967f, -0.32791555f, 
    -0.07100461f, -0.04878544f, -0.09505466f, 0.18950351f, -0.04914146f, -0.09025454f, 0.00838803f, -0.03844726f, 
    -0.16945480f, 0.13140652f, -0.03708480f, -0.27653071f, -0.23314004f, 0.04719019f, 0.01253128f, 0.01145231f, 
    0.04327425f, -0.01687167f, 0.02067670f, -0.06229490f, -0.23181494f, -0.13664547f, -0.00241841f, -0.04418202f, 
    -0.03888174f, -0.01216265f, 0.02246312f, 0.01266834f, -0.01342474f, -0.00833364f, -0.03965424f, -0.05319146f, 
    0.02743996f, -0.14744161f, 0.10516144f, -0.25194201f, -0.01378041f, -0.07530165f, -0.05233738f, 0.12693098f, 
    0.03669294f, -0.01496924f, 0.06737646f, -0.13157932f, 0.58550757f, 0.05976431f, 0.06631102f, -0.12792782f, 
    -0.03944614f, 0.05664739f, 0.00060454f, 0.07670835f, 0.09418687f, 0.01347335f, 0.02970017f, 0.05752181f, 
    -0.25425354f, 0.01686704f, 0.16042165f, 0.23157886f, -0.15763780f, -0.04911188f, 0.14493972f, 0.03961682f, 
    -0.01118725f, -0.07527737f, 0.00448616f, -0.06237681f, 0.18069240f, 0.09439721f, 0.04138947f, 0.10904936f, 
    -0.23006703f, -0.01305830f, -0.02843003f, 0.00942841f, -0.01032848f, 0.06566412f, -0.10458390f, -0.11178193f, 
    0.07304813f, 0.07104062f, 0.09353483f, 0.26915428f, -0.11512833f, -0.05205997f, 0.05810955f, -0.01150987f, 
    0.07501052f, 0.02784118f, -0.02350275f, 0.05377321f, -0.01194355f, 0.09497338f, 0.03942711f, 0.10738433f, 
    -0.10365561f, 0.02726723f, 0.04051393f, -0.02214676f, 0.06252538f, 0.02097921f, -0.05044957f, -0.09445105f, 
    0.11469596f, -0.03768522f, 0.08988938f, 0.04648939f, -0.11085148f, -0.11948907f, -0.06563406f, -0.00823284f, 
    -0.07496463f, 0.02259665f, -0.01657977f, -0.08704790f, 0.14037998f, 0.21592884f, 0.09738211f, -0.34490836f, 
    0.03668923f, 0.02284779f, -0.06928020f, -0.02018975f, -0.01719160f, -0.06920534f, -0.16023917f, 0.07482243f, 
    0.00436230f, -0.11979936f, -0.12034225f, 0.16733184f, 0.04116207f, -0.02596617f, -0.06478128f, 0.13032116f, 
    -0.02072737f, -0.06527484f, 0.04392814f, -0.02966905f, -0.00445685f, 0.00994926f, -0.07921304f, -0.02878596f, 
    -0.09560297f, -0.12577185f, 0.00944936f, -0.03360535f, -0.09954365f, -0.00826723f, 0.00188965f, 0.02744637f, 
    0.07150365f, -0.36761695f, 0.16370691f, -0.01234690f, -0.12749577f, 0.01291073f, 0.06666564f, 0.12070720f, 
    0.01145642f, -0.06038589f, -0.07571866f, 0.13755062f, 0.07137070f, 0.16285816f, -0.10396174f, 0.09246472f, 
    -0.07558369f, 0.10291816f, -0.06598518f, 0.07181275f, 0.04443679f, -0.05314394f, -0.00483008f, 0.01029639f, 
    0.25395548f, -0.12733544f, 0.05115591f, -0.27008137f, -0.02889166f, -0.10288537f, 0.11986423f, -0.10339755f, 
    0.10954756f, 0.00360376f, 0.04714464f, 0.14785221f, -0.43311393f, 0.20827253f, 0.10670311f, -0.00173007f, 
    0.15474296f, 0.13865197f, 0.03588646f, -0.03200581f, -0.02575603f, -0.16610378f, 0.03409513f, -0.03776843f, 
    -0.52773637f, -0.01774636f, -0.10698428f, 0.11193778f, -0.07030441f, -0.01904919f, 0.02951376f, -0.01117759f, 
    0.09809139f, 0.06507768f, -0.06400818f, 0.00745539f, 0.06860501f, -0.01422334f, -0.01399585f, 0.07822504f, 
    0.05360761f, -0.05192541f, -0.05719557f, -0.16998762f, 0.07255702f, -0.07602908f, 0.08820606f, 0.02472636f, 
    0.10635662f, 0.00672380f, 0.17629056f, 0.09209972f, 0.03551284f, 0.08579413f, -0.05551501f, 0.00677108f, 
    0.06850392f, -0.06577955f, -0.17665863f, 0.09006350f, 0.10603508f, 0.06097053f, 0.04113100f, 0.10612845f, 
    -0.01646539f, -0.02057004f, -0.01483549f, 0.05444781f, 0.04623460f, -0.03497130f, -0.07168172f, -0.18162158f, 
    0.05991649f, 0.20176587f, -0.06980063f, -0.08834588f, -0.04640400f, 0.01746358f, 0.05415493f, 0.07343270f, 
    -0.07030782f, 0.07458307f, 0.09590853f, 0.06200691f, 0.11743949f, -0.02940021f, 0.19478939f, 0.20707400f, 
    -0.03384596f, -0.01948854f, 0.06442987f, -0.05296907f, -0.03055616f, 0.07654765f, 0.01524790f, 0.05575649f, 
    0.13627066f, -0.14661485f, -0.09264316f, -0.19567052f, 0.06557716f, -0.24926275f, -0.00691337f, 0.06700468f, 
    -0.00456295f, -0.10367073f, 0.01695486f, -0.14306308f, -0.01349359f, -0.01364280f, -0.11841882f, -0.20657735f, 
    0.00721383f, 0.14369310f, 0.06123164f, -0.02447783f, -0.03796564f, -0.11661623f, 0.12745215f, -0.03971729f, 
    -0.24928138f, -0.05485247f, 0.05683743f, -0.05595983f, -0.01989461f, 0.04338033f, 0.13652261f, -0.04761703f, 
    0.05979057f, 0.16684005f, -0.07201131f, 0.07235492f, -0.26677594f, -0.01146160f, -0.09828594f, -0.12235758f, 
    -0.00373513f, -0.09166714f, -0.00511252f, -0.04684872f, 0.02574412f, 0.03349104f, -0.03137913f, -0.06312868f, 
    0.13640040f, -0.08122598f, -0.08802661f, 0.08216546f, -0.08028699f, 0.02384398f, -0.02999513f, 0.02631572f, 
    -0.08913907f, 0.00354309f, -0.24151404f, -0.00088437f, 0.02194528f, 0.04804002f, -0.15337072f, 0.20623636f, 
    0.00800940f, 0.04896601f, -0.05492709f, -0.05145689f, -0.08505682f, 0.00586664f, 0.04548226f, 0.00852437f, 
    0.06197140f, -0.02773321f, -0.03709576f, -0.11512802f, 0.01889659f, -0.00056130f, -0.16589819f, 0.01682015f, 
    0.04901128f, -0.01009412f, -0.05740267f, -0.04676384f, 0.16156454f, -0.31518427f, 0.04553270f, 0.19176540f, 
    -0.17945769f, 0.05289314f, -0.14170311f, 0.17472446f, 0.10717505f, 0.01888089f, 0.00564209f, 0.11396614f, 
    0.16552259f, -0.11613564f, -0.14810802f, 0.00486821f, 0.08494426f, 0.04780844f, -0.10134190f, 0.25257045f, 
    0.11057148f, 0.03096084f, -0.03867493f, -0.06962877f, -0.41936451f, 0.22975023f, -0.11435968f, -0.30443332f, 
    -0.02669915f, 0.05543130f, 0.00984597f, 0.00558014f, 0.01546379f, -0.00006205f, 0.00726846f, -0.08624042f, 
    -0.10911840f, 0.14806066f, -0.22356150f, -0.02707030f, 0.08427215f, -0.01647988f, 0.05846995f, 0.03850704f, 
    0.09616756f, 0.02229908f, 0.00075222f, 0.05848843f, 0.12161262f, -0.00231476f, -0.02710782f, 0.00038248f, 
    -0.02755452f, 0.02593680f, 0.05395612f, 0.01751710f, 0.03634841f, 0.16843268f, 0.04816473f, -0.02404498f, 
    -0.16544041f, -0.07797503f, -0.24860008f, 0.06717392f, -0.08296364f, -0.02135301f, 0.03287162f, 0.03927733f, 
    -0.00697951f, -0.00385245f, 0.03934515f, -0.09946436f, 0.13208906f, 0.00918330f, -0.02305338f, -0.07886264f, 
    -0.00133019f, -0.15055889f, 0.07130202f, 0.04885407f, -0.12133217f, 0.02016991f, 0.06318242f, 0.04300512f, 
    0.07384998f, -0.35221353f, 0.16992120f, 0.05968687f, -0.04257561f, 0.04227002f, 0.04525351f, -0.14079480f, 
    0.02649274f, 0.07492070f, -0.14764340f, 0.10102186f, 0.04817761f, -0.13077171f, -0.29758257f, -0.15593702f, 
    0.07418203f, -0.13554734f, 0.02372241f, -0.03692306f, 0.10229772f, -0.03251650f, 0.04885491f, 0.01220517f, 
    -0.37454459f, -0.10038673f, -0.05761499f, -0.06230997f, -0.15351775f, -0.02210661f, -0.02342623f, 0.09078749f, 
    -0.09595669f, 0.14692454f, 0.13426064f, 0.13123512f, 0.21454605f, 0.07613689f, -0.00169650f, 0.17638725f, 
    -0.11791092f, -0.00280560f, 0.02617254f, 0.00414919f, 0.01089543f, -0.02025536f, -0.01362515f, 0.03654907f, 
    0.23406111f, -0.03337044f, 0.16626109f, -0.06360838f, -0.04794641f, 0.03325252f, -0.08265930f, -0.05415446f, 
    -0.11484729f, -0.01123376f, 0.08173375f, -0.01038184f, -0.07003886f, -0.00615310f, -0.13488306f, 0.19913557f, 
    0.14350475f, 0.03189362f, -0.01846086f, 0.07057647f, 0.05612073f, -0.09858129f, 0.24582720f, -0.00777752f, 
    0.01755048f, -0.03567935f, 0.05112497f, 0.14056069f, -0.12196236f, 0.00036442f, -0.02005695f, 0.01759216f, 
    -0.07254019f, -0.06802954f, -0.15123986f, -0.08319291f, 0.09760983f, 0.03012273f, -0.03894718f, -0.10382305f, 
    -0.08908354f, -0.05100651f, -0.12417090f, -0.05376568f, 0.02099415f, -0.12668021f, -0.00153920f, -0.03631838f, 
    0.22925819f, 0.03311446f, 0.09547672f, 0.17038967f, -0.05741663f, 0.03013279f, -0.07232883f, 0.04096198f, 
    0.07790305f, 0.08304203f, 0.09210983f, -0.00932367f, -0.00389206f, 0.03351193f, -0.02791885f, -0.13332586f, 
    -0.02047805f, 0.06797866f, 0.02009405f, 0.01141113f, -0.05476637f, 0.10893946f, 0.09551124f, -0.00730421f, 
    -0.07529287f, 0.05431064f, -0.32803705f, 0.06157849f, 0.00137031f, 0.04206235f, -0.02376289f, 0.03671734f, 
    -0.03574189f, -0.02784604f, -0.14327519f, -0.02109410f, -0.07176574f, 0.00544427f, -0.21472737f, -0.26927108f, 
    -0.08569127f, 0.08737497f, -0.00228092f, -0.17583270f, 0.11233651f, -0.06477726f, 0.02976777f, 0.10026039f, 
    -0.15354079f, 0.09078351f, -0.24622059f, -0.24998523f, 0.17344987f, 0.10445378f, -0.01214648f, -0.00876040f, 
    -0.07407129f, 0.02439620f, -0.05210358f, 0.01760188f, -0.02724479f, -0.10529110f, -0.00918043f, 0.05678556f, 
    -0.05002192f, -0.09079508f, 0.04082459f, -0.04461905f, 0.03298417f, -0.09442350f, -0.07770163f, 0.09530658f, 
    0.20526285f, -0.02705519f, -0.06414365f, -0.02339585f, -0.02881667f, 0.06355192f, 0.09049427f, 0.11045204f, 
    -0.00365870f, -0.12851422f, -0.09349303f, -0.01191016f, 0.12804289f, -0.02280354f, -0.00772176f, -0.08783539f, 
    -0.07464690f, -0.03853029f, -0.02331617f, -0.00159018f, 0.13373631f, -0.02291500f, -0.07579201f, 0.08881567f, 
    0.18207520f, 0.13572353f, 0.10510949f, 0.13490035f, -0.01786581f, 0.01988254f, -0.09328952f, -0.06971959f, 
    0.04025294f, -0.05468656f, -0.12393896f, 0.10124741f, 0.11150752f, 0.05692633f, 0.16426311f, 0.11159842f, 
    -0.09157858f, 0.07530255f, -0.00221967f, -0.01164803f, -0.03726692f, -0.06605010f, -0.12949076f, 0.00328189f, 
    -0.28962484f, -0.03990110f, 0.03754448f, -0.28278625f, 0.06837166f, -0.09105657f, 0.03168666f, 0.08949196f, 
    0.05705523f, -0.01208725f, 0.09861424f, -0.07668492f, 0.31858897f, 0.05296700f, 0.03833246f, 0.08638454f, 
    -0.12225485f, -0.10324484f, 0.14053908f, -0.02831235f, -0.10700560f, -0.10916432f, -0.01787961f, 0.06225991f, 
    0.19696918f, -0.32019746f, 0.12309114f, -0.08760550f, 0.02993072f, -0.03512301f, 0.05313515f, 0.01556453f, 
    -0.10104127f, -0.08788711f, -0.05895602f, 0.06628562f, 0.18503451f, 0.09232327f, 0.02781792f, -0.04058058f, 
    -0.02525201f, -0.04656673f, 0.01037517f, -0.03362933f, -0.07205614f, -0.15548609f, 0.01157274f, -0.03835465f, 
    0.11391310f, 0.08126654f, 0.03248783f, -0.08774653f, 0.05642954f, 0.04798382f, -0.01002178f, 0.13998057f, 
    -0.14553392f, -0.03808942f, 0.15020712f, -0.05328001f, 0.54190785f, -0.38563713f, -0.08009292f, -0.05397608f, 
    -0.09261405f, -0.06614064f, -0.01823430f, 0.05222883f, -0.09081057f, 0.02312008f, -0.05053107f, 0.11020491f, 
    0.05854663f, -0.07954465f, 0.10147115f, 0.11069547f, -0.01406411f, 0.03764988f, 0.03934426f, 0.11101852f, 
    0.05862847f, 0.02100991f, 0.01736640f, -0.10313081f, 0.09438729f, -0.32356364f, -0.31226173f, -0.04713554f, 
    -0.11560594f, 0.01476577f, 0.03617417f, -0.13077383f, 0.02696227f, 0.12936649f, -0.10351107f, -0.00993515f, 
    0.08249561f, -0.14785780f, 0.13516428f, -0.43234548f, -0.03903908f, -0.08678507f, 0.07725808f, -0.00574308f, 
    -0.15212138f, 0.01559168f, -0.04073487f, -0.02761087f, 0.12147451f, -0.03181840f, 0.10314663f, 0.00360607f, 
    0.09320848f, -0.20959555f, 0.07870331f, -0.08027692f, -0.13715011f, 0.02266146f, -0.08475385f, 0.03576403f, 
    -0.22589108f, 0.09076899f, -0.09378362f, 0.04008131f, 0.10975570f, -0.10203672f, -0.02319583f, 0.02170856f, 
    -0.04545260f, -0.07991581f, -0.07537872f, 0.00737630f, -0.00554161f, 0.11600725f, -0.30066553f, -0.40401751f, 
    -0.05430239f, 0.03185150f, 0.00066705f, -0.03123627f, 0.07392904f, -0.01076358f, 0.08471508f, -0.01827275f, 
    0.05044721f, -0.07156642f, 0.12651923f, 0.09816344f, -0.03025486f, 0.01742519f, -0.00352297f, -0.02209604f, 
    -0.02231463f, 0.05338844f, -0.08512836f, 0.11144470f, -0.43236166f, -0.02657680f, -0.38499582f, 0.21459265f, 
    0.16563866f, -0.04154995f, -0.10745388f, 0.01049642f, -0.07897917f, 0.04440885f, -0.07168534f, 0.02283888f, 
    0.09121489f, 0.16408421f, -0.10543804f, 0.08441344f, -0.09496506f, 0.10363795f, -0.01281108f, -0.00059713f, 
    -0.02300934f, 0.20761368f, 0.02189934f, 0.02703820f, 0.22266164f, -0.08963602f, 0.22784218f, 0.10972572f, 
    -0.08698314f, -0.06328510f, 0.03116626f, -0.00418686f, -0.07346348f, 0.05201206f, 0.02943530f, 0.07301626f, 
    0.21015090f, -0.03462443f, 0.02282210f, -0.00952529f, -0.09746338f, -0.00063478f, 0.05783512f, 0.02567169f, 
    -0.09324995f, -0.01089489f, -0.07074952f, -0.13366117f, -0.08151926f, 0.05553891f, -0.04866881f, -0.03799863f, 
    0.01014852f, 0.03977185f, 0.05498277f, -0.07202710f, -0.04085714f, -0.03348335f, -0.08108187f, 0.05383788f, 
    0.26147556f, 0.07737405f, 0.07384218f, 0.14027210f, -0.10147408f, 0.10608174f, 0.09858114f, 0.08251200f, 
    0.03672243f, -0.10486545f, -0.09137474f, 0.02856012f, 0.22335975f, 0.05613955f, -0.02849476f, -0.23528154f, 
    0.09017854f, -0.01118551f, -0.07568975f, 0.06719441f, 0.07689328f, 0.06690755f, 0.10166220f, -0.03627003f, 
    -0.00502865f, -0.01631288f, -0.17501053f, 0.05209632f, 0.14122583f, -0.13343491f, 0.08832388f, -0.04025386f, 
    0.04935284f, 0.12530163f, 0.05289848f, 0.01341688f, 0.07404736f, 0.07117945f, 0.01902945f, 0.02797471f, 
    0.05939595f, -0.11099410f, -0.00120518f, 0.00213357f, 0.02965287f, -0.09160221f, 0.00575658f, -0.17063335f, 
    0.22220220f, -0.12994252f, -0.03420007f, 0.03576117f, 0.13468407f, -0.04763484f, -0.16578706f, -0.06483404f, 
    -0.03064227f, 0.05135541f, 0.10097283f, -0.03672518f, -0.20845123f, -0.19489279f, -0.12515077f, 0.22055812f, 
    -0.02489106f, -0.15055662f, -0.12783328f, -0.03597645f, 0.08501909f, -0.21626848f, -0.00606388f, -0.01425535f, 
    -0.07186116f, -0.19765173f, 0.00345408f, -0.30452886f, 0.07376927f, -0.02343003f, -0.06787252f, 0.07842700f, 
    -0.09190463f, 0.03272019f, 0.03966179f, -0.01045917f, -0.12613834f, -0.00301948f, -0.32381994f, -0.09292064f, 
    -0.10598372f, 0.04585386f, 0.06305929f, -0.06750455f, -0.00019527f, 0.09434885f, -0.05020197f, -0.02155503f, 
    0.48013008f, -0.04928276f, -0.16302101f, -0.18832526f, -0.15187138f, -0.02412122f, 0.00877575f, -0.00193745f, 
    0.00401684f, 0.01054271f, -0.08928195f, -0.04683245f, 0.23196733f, -0.07800952f, 0.01066712f, 0.07074178f, 
    -0.19250587f, -0.03964463f, 0.03235678f, 0.05482681f, -0.07276957f, 0.03095978f, -0.02786032f, -0.02741929f, 
    -0.16340172f, 0.04548576f, 0.06854489f, -0.11346670f, 0.11186545f, 0.03948250f, -0.06116425f, -0.01978339f, 
    0.00908065f, -0.00981449f, 0.11995962f, -0.07507737f, 0.17599496f, -0.15066722f, -0.03470771f, 0.08240837f, 
    -0.10434704f, -0.00356183f, 0.03813345f, -0.09233051f, -0.02772395f, 0.11178625f, -0.04052813f, 0.09230509f, 
    0.07056314f, -0.23136942f, -0.06956048f, -0.02458620f, -0.14074765f, -0.10874508f, -0.14631520f, -0.06870137f, 
    0.02496950f, -0.09584321f, -0.05791705f, -0.09277429f, -0.00560987f, 0.03072552f, -0.05622675f, 0.13159697f, 
    0.07607933f, 0.02104261f, -0.04136771f, -0.07633611f, 0.02760809f, -0.03824315f, -0.04333890f, -0.00780295f, 
    0.07869495f, 0.19678621f, -0.14064465f, 0.20122655f, -0.16505267f, -0.10005461f, 0.04577854f, 0.08493098f, 
    -0.04264453f, -0.00851507f, -0.01864356f, 0.04585417f, 0.17502765f, -0.04030104f, -0.08077858f, -0.10565934f, 
    0.00378689f, -0.03637652f, -0.04144234f, 0.00514642f, -0.10158961f, 0.00058349f, -0.12239182f, 0.00636146f, 
    0.25821537f, 0.07949769f, -0.04160950f, -0.41812891f, 0.09974522f, 0.11382362f, 0.07150880f, -0.06326885f, 
    0.06327315f, -0.01296327f, 0.04536351f, -0.31796324f, 0.25249469f, 0.11552709f, 0.13485056f, 0.14524642f, 
    -0.02045775f, 0.05647132f, 0.02614662f, 0.09975274f, -0.04793778f, -0.06920099f, 0.04199621f, -0.14984770f, 
    0.25024739f, -0.00448529f, 0.03937057f, -0.00058490f, -0.07806916f, -0.05590989f, -0.12326761f, 0.03264780f, 
    0.02565183f, -0.09876787f, 0.08730623f, -0.07594083f, 0.30164444f, 0.02070863f, 0.12669025f, -0.01738082f, 
    -0.12545045f, -0.07237836f, 0.11574762f, 0.16638146f, 0.15823112f, 0.05896835f, -0.06603023f, -0.08350284f, 
    0.20123318f, 0.09696785f, 0.13194564f, 0.26737070f, -0.11639038f, -0.05921821f, -0.05073225f, 0.07078399f, 
    0.03117262f, -0.03133069f, -0.01912598f, 0.09775899f, 0.40019867f, -0.12660523f, -0.00565118f, 0.01380781f, 
    0.10434209f, 0.00899013f, -0.11455584f, 0.03581921f, 0.05124025f, -0.05067555f, 0.07766384f, -0.03914393f, 
    -0.03768875f, -0.15955739f, -0.03354092f, 0.01587544f, -0.13664649f, 0.07564478f, 0.02703701f, -0.03144562f, 
    -0.02492313f, 0.02692577f, 0.00319274f, 0.09763280f, 0.37645561f, 0.04151465f, -0.23604682f, -0.05607186f, 
    -0.03294899f, 0.05304733f, -0.04400255f, 0.08452469f, -0.04924200f, 0.05647096f, 0.03791028f, -0.07264314f, 
    -0.00222404f, -0.24661778f, 0.11776441f, -0.17537008f, -0.10906806f, -0.10486595f, 0.03457944f, -0.05710033f, 
    -0.06500318f, -0.01589955f, -0.00514807f, -0.04855362f, 0.13483000f, 0.08546037f, 0.09706477f, 0.17546450f, 
    -0.04107367f, -0.01353681f, 0.05562134f, 0.09512994f, -0.00891944f, -0.01731044f, 0.02000734f, 0.00258993f, 
    0.06743959f, -0.00403170f, 0.01198337f, -0.01254173f, -0.08617257f, 0.09653939f, 0.03641324f, 0.08505621f, 
    -0.00316368f, 0.03001588f, -0.02214440f, 0.00122850f, -0.08149363f, -0.04743444f, -0.09814484f, -0.23350610f, 
    0.05194157f, -0.03282832f, 0.11528216f, -0.12157151f, -0.07826152f, 0.07310505f, 0.02527400f, 0.01131018f, 
    -0.20866755f, 0.11998257f, 0.05078530f, 0.08101917f, -0.01444740f, -0.03047899f, -0.02048732f, 0.01751225f, 
    0.01985425f, -0.09798216f, -0.01182985f, -0.08151732f, 0.23585749f, -0.18526709f, 0.09967980f, 0.07335795f, 
    -0.05525737f, -0.05603314f, -0.10683911f, -0.07667525f, 0.00758415f, -0.04508653f, -0.02434966f, 0.13166159f, 
    0.02664405f, -0.16045679f, -0.07412060f, -0.08589527f, -0.11797995f, 0.09527677f, -0.02229754f, -0.03262649f, 
    0.02116904f, -0.09383792f, -0.02123184f, -0.04496599f, 0.00450092f, 0.06547450f, -0.05426569f, 0.01624874f, 
    0.10815499f, 0.00476531f, 0.00342329f, -0.07262376f, -0.02431879f, 0.01788020f, 0.04000257f, -0.04683289f, 
    0.05139148f, 0.08015987f, 0.08078913f, -0.01432658f, 0.03095711f, -0.06191957f, 0.00516690f, 0.03472458f, 
    -0.05914553f, 0.00240079f, -0.07082892f, -0.07813117f, 0.45186055f, -0.16785164f, -0.04565734f, 0.10488307f, 
    -0.03260677f, -0.01031267f, -0.06002462f, -0.00057150f, -0.05660047f, 0.01910881f, -0.13277076f, 0.00599059f, 
    0.49533278f, 0.06898663f, -0.00265341f, -0.01867203f, -0.03809454f, 0.03105926f, 0.05622090f, 0.04752260f, 
    0.00172473f, -0.01095314f, 0.09540258f, -0.06845368f, -0.39496768f, -0.04099176f, 0.08408792f, -0.24269596f, 
    -0.06535885f, 0.08179821f, 0.07796993f, 0.04522999f, 0.06903265f, -0.10701481f, 0.02273297f, -0.08152839f, 
    0.18386143f, -0.07018998f, 0.12013370f, -0.02329497f, 0.04085800f, -0.02381872f, 0.08698701f, -0.00060357f, 
    -0.07752908f, -0.04180010f, -0.04923326f, 0.00847797f, -0.23977973f, 0.02323569f, -0.07333399f, -0.20208766f, 
    0.00455206f, -0.01779037f, 0.02399382f, -0.06774908f, -0.07262068f, -0.02304442f, -0.08510296f, -0.05579143f, 
    -0.33309409f, -0.22939107f, -0.07551489f, -0.03699768f, -0.05288765f, 0.02761726f, -0.12093669f, -0.03083065f, 
    0.03027221f, 0.03173535f, 0.02694152f, -0.01942981f, 0.07886685f, -0.05707638f, -0.02931126f, -0.12108299f, 
    -0.00978842f, 0.10582490f, -0.05533624f, 0.02833722f, 0.04139647f, -0.08774572f, -0.08014932f, -0.11818584f, 
    0.16544896f, -0.08869889f, -0.24755001f, -0.02470480f, 0.04437761f, 0.05531828f, 0.02553265f, -0.03604815f, 
    -0.05453920f, -0.09718576f, 0.01213421f, -0.05219371f, 0.18496877f, -0.04347375f, -0.10547154f, 0.09431110f, 
    0.00337009f, 0.05305732f, -0.02894792f, -0.06850792f, -0.08427281f, -0.16701983f, 0.02760105f, -0.04908323f, 
    0.33581883f, -0.18368004f, -0.00429922f, -0.05512518f, -0.13569343f, 0.03811151f, -0.16973333f, -0.07815257f, 
    0.01379724f, -0.06936146f, -0.05558959f, -0.00939575f, 0.13877231f, 0.06189310f, 0.12852696f, 0.24277996f, 
    -0.20646502f, 0.02542107f, -0.11830430f, 0.04470031f, 0.02087130f, -0.01815828f, 0.04761203f, 0.01353312f, 
    0.14839804f, 0.07227506f, -0.04849543f, -0.03833935f, 0.04326707f, -0.03154859f, 0.06852339f, -0.03554919f, 
    -0.08446164f, -0.04855381f, -0.03937601f, -0.13541131f, 0.20299163f, -0.08708850f, 0.06115210f, -0.13017616f, 
    0.01334752f, 0.00174424f, 0.04407506f, 0.06612388f, -0.08028006f, 0.07481351f, 0.08182350f, 0.04093328f, 
    -0.11199073f, 0.08127141f, -0.03235174f, -0.15091072f, 0.02080422f, 0.05883310f, 0.01978793f, -0.05465302f, 
    -0.09444075f, 0.12460440f, -0.06566565f, -0.00362998f, 0.06125723f, 0.05239853f, -0.04010438f, -0.12825073f, 
    0.05438189f, 0.00721568f, 0.04413368f, -0.06076797f, -0.02003448f, 0.05537212f, -0.06411959f, -0.04257144f, 
    0.07630906f, 0.14316861f, 0.08407058f, -0.04747840f, -0.06019080f, -0.07507870f, 0.09066552f, -0.02155535f, 
    -0.12541148f, -0.06084532f, -0.02236430f, -0.00763305f, 0.04305466f, -0.13002419f, -0.02587171f, 0.10924900f, 
    -0.00316778f, 0.02060885f, -0.02370310f, 0.03221855f, -0.04938591f, 0.04299255f, -0.01720646f, -0.10743061f, 
    0.03623580f, -0.07932456f, -0.09921393f, 0.06987469f, -0.00276941f, -0.08707315f, 0.07880698f, -0.02270545f, 
    -0.07910871f, 0.03447384f, -0.12979120f, 0.00190307f, 0.14892146f, -0.02233466f, -0.07264689f, -0.04002177f, 
    -0.02160178f, -0.04736083f, 0.08934852f, 0.05613513f, -0.08759695f, 0.01242010f, -0.00169099f, -0.02426935f, 
    -0.08128448f, 0.09322262f, -0.12133204f, 0.01870058f, 0.01911424f, 0.00829862f, -0.03906270f, -0.07743546f, 
    -0.02136791f, -0.02037635f, -0.00202271f, -0.01024379f, -0.32560387f, -0.20442115f, -0.11187630f, -0.09849877f, 
    -0.05148426f, 0.05297934f, -0.03938762f, 0.09088450f, -0.00354931f, 0.02744631f, 0.01672638f, -0.04175169f, 
    -0.25738329f, -0.06212007f, -0.02982947f, -0.22484663f, -0.00725360f, 0.03700392f, 0.00010282f, -0.00864353f, 
    -0.06181731f, -0.00759144f, -0.06525412f, -0.01363623f, -0.21582177f, 0.07942519f, -0.04156834f, 0.01219908f, 
    0.04858466f, 0.01394473f, 0.09661914f, -0.00262055f, -0.08338753f, 0.02376956f, 0.02223144f, -0.08592569f, 
    0.06628340f, -0.04089890f, -0.23465009f, -0.08921331f, 0.03970877f, 0.09699167f, 0.03199672f, -0.04735607f, 
    -0.02256494f, 0.02396064f, 0.01615908f, -0.04590824f, 0.19418380f, -0.10790323f, -0.17702231f, -0.09716289f, 
    0.09360224f, 0.07764933f, -0.06760024f, -0.09590579f, -0.07547031f, 0.00988678f, -0.00629568f, 0.01309911f, 
    0.07848877f, -0.03309014f, -0.01986766f, 0.03831029f, 0.03917854f, -0.02333869f, 0.00308097f, -0.09457516f, 
    -0.05351217f, -0.02123134f, -0.04258845f, -0.11575948f, 0.09056640f, 0.01681228f, -0.05762979f, -0.05768898f, 
    0.12136602f, 0.06115679f, 0.06469270f, -0.00808003f, -0.09775953f, -0.07785833f, -0.05728497f, -0.05447373f, 
    0.13769235f, -0.04808463f, 0.00097793f, 0.08112670f, -0.03370901f, 0.00332985f, 0.02322194f, -0.03432153f, 
    0.02937593f, -0.02806051f, -0.06064995f, 0.01085557f, -0.05173959f, 0.05420841f, 0.01370191f, 0.01589944f, 
    0.10032461f, 0.02045925f, -0.04312995f, -0.06646352f, 0.00177457f, 0.08685654f, -0.02875716f, 0.01185078f, 
    -0.05160195f, -0.18197958f, 0.02330727f, -0.11476024f, 0.02649534f, 0.10043731f, 0.01940005f, 0.06133467f, 
    0.03040493f, 0.04436606f, 0.01665503f, -0.08964750f, 0.13171712f, 0.03750223f, -0.05254116f, 0.03503687f, 
    -0.04862461f, -0.01903641f, -0.04370094f, 0.08339531f, -0.08885308f, 0.03060191f, -0.04415548f, -0.09146149f, 
    0.13775860f, 0.04745780f, -0.02563961f, -0.06401971f, 0.06569216f, -0.02328603f, 0.02935121f, -0.02444190f, 
    -0.16109593f, 0.04808636f, -0.02320860f, 0.03420071f, 0.18978062f, -0.01659592f, 0.01236058f, 0.05952163f, 
    0.04036888f, -0.05698048f, -0.05947777f, -0.02016773f, 0.05318278f, 0.03826523f, -0.02120256f, 0.04511429f, 
    -0.16913067f, -0.04606920f, -0.14782432f, -0.08402985f, -0.00953088f, 0.12873514f, -0.10170785f, 0.05200522f, 
    -0.05776563f, -0.09410372f, -0.01044313f, -0.10158256f, -0.02954661f, 0.02220217f, 0.06095719f, -0.12885703f, 
    -0.03430636f, -0.00649413f, 0.04555818f, 0.07527556f, -0.14000386f, -0.01600567f, 0.02111245f, -0.01288384f, 
    0.08575705f, -0.22618946f, 0.05556778f, -0.06542824f, 0.03569141f, -0.04819886f, -0.00788614f, 0.03646019f, 
    0.00221105f, -0.14489743f, -0.06822104f, -0.02398440f, -0.28298694f, 0.10166775f, -0.21316049f, -0.15297094f, 
    0.03515134f, 0.10083546f, -0.00121325f, -0.00449783f, -0.03379811f, 0.09634349f, -0.12491756f, -0.03359821f, 
    0.17795348f, 0.00623095f, 0.12759320f, 0.18049380f, -0.03010501f, -0.08850146f, 0.03049538f, 0.06940775f, 
    -0.03269983f, -0.03606627f, -0.01710581f, 0.07658356f, 0.09638643f, 0.07260431f, -0.36669046f, -0.16444379f, 
    0.00760609f, 0.00184159f, -0.02822392f, -0.02796005f, 0.03640066f, -0.10672194f, 0.10126182f, 0.01188758f, 
    -0.13010159f, 0.29587206f, 0.21449536f, -0.04451070f, -0.02554240f, 0.03623842f, 0.00015171f, -0.01138921f, 
    -0.10382631f, 0.00674590f, -0.08008206f, 0.12720908f, -0.27645692f, 0.14093347f, 0.03094196f, -0.06888501f, 
    -0.04433978f, -0.14290537f, 0.05158731f, 0.03287954f, 0.03882333f, -0.08987023f, 0.11938773f, 0.06751065f, 
    -0.22932826f, -0.17498878f, -0.21195808f, 0.26071876f, -0.02164791f, 0.12227017f, 0.01960689f, -0.13246083f, 
    0.05987097f, -0.09042977f, 0.04316325f, -0.04494215f, -0.01516153f, -0.13232704f, -0.19533721f, -0.02375221f, 
    -0.14087154f, 0.02228940f, 0.04785582f, -0.02181180f, -0.02428563f, 0.14154501f, -0.08543918f, 0.00379082f, 
    0.16769956f, 0.07020708f, -0.07704082f, 0.03219559f, -0.11357524f, -0.06412415f, -0.08616471f, 0.01523857f, 
    -0.05889095f, -0.02828851f, 0.03041196f, -0.05873337f, -0.22226439f, -0.42914543f, -0.00498150f, 0.21944314f, 
    -0.06472953f, -0.02159872f, -0.05596657f, -0.04231224f, -0.09152673f, -0.08206279f, -0.00438065f, -0.05861214f, 
    -0.06365605f, -0.06550977f, -0.05986121f, 0.04956426f, -0.03782592f, -0.02705250f, 0.09281271f, 0.02850872f, 
    -0.09129649f, 0.08389679f, -0.02375488f, 0.12164783f, 0.32949528f, -0.07413929f, 0.12588793f, 0.21278144f, 
    0.07183837f, -0.02642209f, -0.04168531f, 0.05686344f, -0.04768702f, 0.13058616f, -0.16401580f, -0.03024821f, 
    0.18995835f, 0.06673288f, 0.18270150f, 0.09981649f, 0.09488359f, 0.09588204f, 0.00334251f, 0.01966277f, 
    0.07748783f, 0.02300647f, 0.08135792f, -0.12898947f, -0.29292712f, 0.04112800f, 0.02884004f, -0.20014989f, 
    -0.05764575f, -0.00313200f, -0.06222297f, 0.02962990f, 0.05177628f, -0.08840130f, -0.03207214f, -0.04738181f, 
    0.21500146f, 0.09520089f, -0.02833077f, 0.08155163f, -0.04669502f, -0.05550046f, -0.00501680f, -0.00021321f, 
    -0.09412112f, 0.02294573f, -0.03036331f, 0.04780082f, -0.02456854f, -0.12564091f, 0.01410448f, -0.17622292f, 
    0.05071001f, 0.01406615f, 0.03068459f, 0.02769623f, -0.07026304f, -0.02553719f, -0.03064223f, 0.05042772f, 
    -0.14774370f, -0.00586780f, -0.08317623f, -0.05399498f, -0.06308661f, -0.11911315f, 0.05827146f, 0.08313771f, 
    -0.05334020f, -0.00027770f, -0.00883204f, -0.01395158f, -0.20179585f, -0.00777051f, 0.18837416f, 0.03461148f, 
    -0.07288720f, 0.09738405f, 0.16658632f, -0.04487044f, -0.08280788f, 0.03587202f, -0.07931169f, -0.04102818f, 
    -0.32792526f, 0.14973053f, -0.01554625f, 0.02746852f, -0.14246769f, -0.11106834f, 0.16506852f, -0.03431679f, 
    -0.08112455f, 0.09408316f, -0.01168674f, -0.07205488f, -0.11714928f, 0.15496744f, 0.11947571f, -0.21697050f, 
    0.06204685f, 0.02063629f, -0.00632834f, 0.00226357f, 0.08411007f, 0.03186448f, -0.06616067f, 0.00614220f, 
    -0.04731738f, 0.08607748f, -0.00931392f, -0.09875243f, -0.17227641f, 0.04657043f, -0.03684545f, 0.05079598f, 
    0.04669232f, -0.04650074f, 0.03201731f, 0.10041010f, 0.01282411f, -0.04043189f, -0.07455287f, -0.15854034f, 
    -0.06552748f, -0.08890896f, -0.00732109f, -0.09959161f, -0.03950818f, 0.01838521f, -0.05666493f, -0.03791110f, 
    -0.36088803f, 0.26838255f, -0.05485196f, 0.01268003f, 0.04990140f, 0.09849419f, -0.07113890f, 0.06935707f, 
    -0.03407751f, -0.00456493f, 0.01189069f, -0.00841346f, -0.00073325f, -0.24787837f, -0.07137970f, -0.17013566f, 
    -0.07779945f, 0.02275680f, 0.00353279f, 0.11746071f, 0.05101559f, 0.07114594f, 0.09742852f, -0.04383481f, 
    0.03035133f, 0.02151543f, -0.06525561f, -0.00743664f, -0.03229404f, 0.07842615f, 0.05878040f, -0.02458821f, 
    -0.03442449f, -0.00146074f, -0.05074762f, -0.02276213f, -0.02295907f, 0.07529245f, -0.05284192f, 0.05052173f, 
    -0.10637349f, -0.10890750f, 0.06532685f, 0.00487432f, -0.05537275f, 0.04821729f, -0.03135825f, 0.06226616f, 
    0.19622117f, 0.06964910f, 0.18053509f, 0.17411314f, 0.10270759f, 0.10725274f, -0.06031957f, -0.05259885f, 
    -0.06512645f, -0.08689062f, 0.02716422f, -0.07788985f, -0.34414080f, -0.37515405f, -0.14355300f, -0.14988269f, 
    -0.10399517f, -0.06778808f, -0.02851635f, -0.08071266f, -0.09114991f, -0.09828387f, 0.05815607f, -0.06835506f, 
    -0.33179069f, -0.13724966f, -0.20871592f, -0.13241898f, -0.08143092f, -0.05972930f, -0.09304335f, 0.08249147f, 
    -0.00214329f, -0.01189299f, -0.04996466f, -0.00516661f, -0.12812206f, -0.08954472f, 0.13344772f, -0.04965861f, 
    -0.09937023f, -0.00457441f, 0.05764307f, -0.00687893f, 0.07188095f, 0.03268529f, -0.07364900f, 0.00469057f, 
    -0.08569951f, 0.27984545f, -0.00916018f, -0.01305416f, 0.05697463f, 0.14151125f, -0.10933153f, -0.05954388f, 
    0.00055999f, -0.01204157f, 0.06260934f, 0.04412948f, -0.18460937f, 0.08357506f, -0.01880303f, 0.14298932f, 
    -0.06864464f, -0.06570491f, -0.01838906f, 0.05006031f, -0.04246069f, -0.00084553f, -0.05770784f, -0.08649857f, 
    -0.39083362f, -0.16798769f, -0.01232786f, 0.12381986f, 0.03253505f, 0.03697503f, 0.08254424f, -0.06875367f, 
    -0.01411165f, -0.07273983f, -0.10978153f, 0.02666752f, 0.10430699f, 0.03536501f, -0.00128473f, -0.10178135f, 
    0.03996693f, 0.06447611f, 0.02182497f, 0.06383260f, 0.10054962f, -0.03252832f, -0.07682744f, -0.00283997f, 
    0.05137540f, 0.01560920f, 0.08640706f, 0.08621283f, -0.09020025f, -0.08764630f, 0.01336097f, 0.05703118f, 
    -0.06439677f, 0.02017845f, 0.09570046f, 0.01153636f, -0.24527223f, 0.10191927f, 0.05063155f, -0.06907552f, 
    -0.00832143f, 0.03695478f, -0.05757606f, 0.06037153f, 0.09363143f, -0.03945868f, -0.00176125f, 0.04712254f, 
    -0.25725457f, 0.21801794f, 0.08710684f, -0.11035539f, 0.09120907f, 0.06870168f, -0.07173572f, 0.06843717f, 
    0.08004199f, -0.01043687f, 0.03316562f, 0.03757304f, -0.45803705f, 0.06774411f, 0.07681186f, 0.15268543f, 
    0.04316136f, 0.09100367f, 0.13778670f, 0.04654165f, -0.06034387f, -0.00660331f, -0.10504480f, -0.06790056f, 
    0.05860729f, 0.11271764f, 0.04471008f, 0.08940543f, -0.06813008f, -0.11307709f, -0.16292799f, 0.04079453f, 
    0.00720386f, 0.07941614f, 0.08905186f, 0.07338406f, 0.09788646f, -0.08322648f, -0.00843538f, -0.11533621f, 
    -0.10047035f, -0.08502872f, 0.01077006f, 0.04931398f, 0.00110560f, -0.08642635f, -0.01904722f, -0.02905925f, 
    -0.28624925f, -0.09769461f, 0.05403737f, 0.01252342f, -0.05534635f, -0.01035264f, 0.03323238f, 0.01915376f, 
    0.00073241f, 0.04772348f, -0.01929585f, 0.04445092f, -0.21949346f, -0.15157846f, -0.19967245f, -0.06338675f, 
    -0.06064658f, -0.10766518f, -0.03146684f, 0.05529530f, 0.12477817f, 0.03669183f, 0.05975311f, 0.08523254f, 
    0.23109329f, 0.03207195f, -0.02673801f, 0.03927623f, -0.09140553f, 0.09777722f, -0.05035013f, 0.03395955f, 
    -0.05202762f, -0.05366986f, -0.11816178f, 0.07116053f, -0.00151278f, -0.21586418f, -0.24906605f, -0.03060809f, 
    -0.13434584f, -0.02419536f, -0.03233593f, 0.03543199f, 0.01387594f, 0.02831389f, 0.03570592f, -0.00420118f, 
    -0.03565601f, -0.04446178f, -0.08276136f, 0.00069360f, -0.05089479f, -0.00561891f, -0.01284814f, 0.08025833f, 
    -0.04754328f, -0.02988970f, 0.02594577f, 0.03005049f, 0.01270937f, 0.00673597f, 0.04906889f, -0.04533000f, 
    -0.02520605f, 0.00383096f, 0.02780496f, 0.06379037f, -0.01953685f, 0.05749454f, 0.04581255f, 0.06286027f, 
    -0.04758723f, 0.04422414f, -0.03483540f, -0.03093810f, -0.08538200f, -0.07418548f, 0.05085359f, -0.08679136f, 
    0.13721471f, 0.01894910f, -0.07306810f, -0.06686895f, 0.31924617f, -0.33969676f, -0.04706554f, -0.07394309f, 
    -0.02202723f, 0.06383032f, 0.00779634f, 0.06459969f, 0.01498907f, -0.03490933f, 0.00705612f, -0.05807523f, 
    -0.16496485f, -0.07420023f, -0.12973242f, 0.19316761f, 0.03030787f, 0.05190174f, 0.06237650f, -0.04206650f, 
    -0.02823218f, 0.05818351f, 0.02256075f, -0.05984397f, 0.20264222f, -0.05764048f, 0.05769652f, -0.01670484f, 
    0.01354038f, 0.14730920f, 0.03405007f, 0.01174569f, 0.15313429f, -0.01667630f, 0.11425561f, -0.10209288f, 
    0.12713109f, 0.11281651f, 0.05875177f, 0.05181349f, 0.00300898f, 0.00501370f, -0.05272900f, 0.04091742f, 
    0.02243231f, 0.03513156f, -0.04661298f, -0.01319654f, 0.14939946f, -0.12512824f, -0.17494060f, 0.00124131f, 
    -0.00164877f, 0.06258260f, -0.04930560f, 0.11023806f, 0.14001152f, -0.03528866f, -0.05267187f, -0.03206042f, 
    0.18864499f, 0.20185839f, -0.05586320f, -0.05314952f, -0.04079697f, -0.03544490f, 0.03415668f, 0.02423135f, 
    -0.05928894f, -0.00001469f, 0.16174777f, -0.05208197f, -0.05661443f, 0.31839219f, 0.18513964f, -0.01845403f, 
    0.09133699f, 0.03763983f, 0.00649061f, 0.12362729f, 0.01255104f, 0.05613203f, -0.18522085f, 0.00798399f, 
    0.21386576f, -0.25140005f, -0.06820212f, 0.25277591f, -0.02098553f, -0.03750387f, -0.03324177f, 0.05434250f, 
    -0.02154159f, -0.08551019f, -0.11180249f, -0.10502093f, 0.00314010f, 0.22456160f, -0.17221154f, -0.07204077f, 
    0.06363343f, -0.03485489f, 0.02804289f, 0.07155522f, 0.05804900f, -0.02607429f, 0.04966550f, 0.00220335f, 
    -0.40287927f, -0.04568649f, -0.03053532f, -0.03942455f, -0.06229669f, -0.11270013f, 0.05169919f, -0.02016364f, 
    0.00314990f, -0.10334920f, 0.09416854f, 0.02749542f, -0.37747216f, -0.51013017f, 0.11328559f, 0.17010607f, 
    -0.03672921f, 0.00378205f, -0.13743700f, 0.00617403f, 0.05109290f, -0.04763530f, -0.00170118f, -0.04773440f, 
    -0.27485889f, -0.12042222f, -0.18658735f, 0.13338195f, -0.02786557f, -0.07747371f, 0.01973452f, 0.01787983f, 
    -0.06008790f, -0.04740107f, 0.11686827f, 0.02398043f, 0.07770727f, -0.18466543f, -0.00913750f, -0.10468713f, 
    -0.04802464f, -0.09851812f, -0.09489159f, -0.05053496f, -0.03904598f, 0.00907592f, 0.07577496f, -0.07385645f, 
    -0.30115232f, -0.27788457f, -0.30218041f, -0.10627615f, 0.02252820f, -0.03194974f, -0.06274008f, -0.08752153f, 
    0.00541657f, -0.00095423f, 0.06765413f, 0.10035241f, -0.26022413f, 0.13689370f, 0.08608714f, -0.01996846f, 
    0.07778987f, -0.11756618f, 0.02141301f, 0.10219388f, -0.03028274f, -0.02866479f, -0.07321814f, -0.03110917f, 
    0.07306035f, -0.07966969f, -0.06262334f, 0.12731819f, 0.09393964f, 0.06439549f, 0.05653227f, 0.08386589f, 
    0.10497987f, -0.05227702f, 0.05689711f, -0.04414525f, -0.10257227f, -0.09690470f, -0.02652747f, 0.07729091f, 
    -0.10354626f, 0.02281699f, -0.00879473f, 0.01735210f, -0.00167825f, 0.15108913f, -0.08772539f, 0.09028001f, 
    0.18044123f, 0.06841964f, 0.16226240f, 0.00163880f, -0.00629765f, 0.09970786f, 0.14470775f, -0.02638433f, 
    0.08348153f, -0.06923680f, 0.00799705f, -0.08155920f, 0.12360704f, -0.13155539f, 0.08827970f, 0.08406218f, 
    -0.02264794f, 0.08121856f, 0.12268785f, 0.05227034f, 0.03401972f, -0.02570035f, -0.02603025f, 0.09936069f, 
    0.00620354f, 0.05634563f, -0.05773596f, -0.10265174f, -0.10232038f, -0.06266945f, 0.07886159f, -0.08214751f, 
    -0.07243726f, -0.05654800f, 0.03616288f, -0.04171969f, 0.21089138f, 0.23872158f, 0.17095971f, -0.05263002f, 
    0.01482417f, -0.15042688f, 0.00713273f, 0.01566779f, 0.05051659f, -0.01738012f, 0.02253488f, -0.08509688f, 
    -0.35793924f, 0.09665406f, 0.10872252f, -0.16162632f, 0.16326721f, 0.00581685f, -0.09864319f, 0.00355950f, 
    -0.05389672f, -0.01643343f, 0.01162838f, 0.03704693f, -0.17637989f, 0.24557012f, -0.03059570f, 0.06384646f, 
    0.05620924f, 0.02442509f, -0.13829990f, 0.18372338f, -0.04446617f, 0.03056664f, -0.00622273f, -0.03654765f, 
    -0.22314663f, 0.01292570f, 0.06306685f, 0.03930016f, 0.08298079f, -0.07096741f, -0.05928911f, -0.05803435f, 
    0.10398624f, 0.02478437f, -0.03288326f, 0.00673246f, 0.16040346f, 0.24793498f, -0.10750666f, -0.00183295f, 
    -0.04533291f, 0.12991393f, 0.08398203f, 0.01843466f, 0.04469672f, 0.01685609f, 0.01911191f, 0.01044418f, 
    -0.16600242f, 0.00285639f, -0.02834714f, -0.08502613f, 0.11810476f, 0.05035001f, -0.05571320f, 0.04854072f, 
    0.13276252f, -0.10495969f, -0.09204017f, -0.06411254f, -0.16068687f, 0.11236741f, 0.16052328f, 0.02284831f, 
    -0.02936233f, 0.03578923f, -0.02385437f, 0.01754731f, 0.03893926f, -0.07952623f, -0.02209542f, -0.13149117f, 
    -0.07020907f, -0.09300129f, 0.17320150f, 0.05279990f, -0.02204038f, 0.09054100f, 0.04390681f, -0.01872124f, 
    0.02281675f, 0.00093569f, -0.03650816f, 0.03436447f, -0.20998853f, 0.18835415f, 0.16337053f, -0.02533015f, 
    -0.10391860f, 0.06274222f, -0.08948709f, -0.03767365f, 0.00555166f, -0.03854203f, -0.00128441f, -0.00946405f, 
    -0.18957989f, -0.13403127f, 0.03046173f, 0.15416469f, 0.06403564f, -0.05845019f, 0.03604238f, -0.13512474f, 
    0.06205609f, -0.08706610f, 0.06133041f, -0.00446920f, 0.01460247f, -0.12076735f, 0.08175645f, 0.21730718f, 
    0.04902991f, -0.00493211f, 0.04858039f, 0.17986511f, -0.04455554f, -0.01283054f, 0.07415837f, 0.14310209f, 
    -0.32656112f, -0.09764723f, -0.00910158f, -0.05035102f, 0.03341729f, -0.05221225f, 0.06606089f, 0.14626655f, 
    -0.00214234f, -0.26144946f, 0.00795887f, 0.05096769f, -0.63051081f, 0.11412381f, 0.06714742f, -0.02292029f, 
    0.03616031f, -0.00679448f, -0.02151001f, 0.11066295f, 0.00728076f, 0.10202843f, -0.01085775f, 0.02349196f, 
    -0.47739655f, -0.22020747f, -0.04365315f, 0.18218498f, 0.03947187f, -0.08324502f, 0.09014491f, 0.06165098f, 
    -0.04434812f, -0.01480546f, 0.01686300f, -0.01030538f, -0.15250155f, -0.12873065f, -0.10579516f, 0.01308425f, 
    0.04052687f, -0.08372271f, 0.05560862f, -0.03105227f, 0.07587303f, 0.04385096f, -0.12204918f, -0.04386916f, 
    0.09793548f, -0.08509781f, -0.20036629f, -0.02089415f, -0.12297168f, 0.05383936f, 0.08783006f, -0.14893609f, 
    -0.04163595f, -0.06867930f, 0.22244713f, 0.09746248f, 0.16014868f, 0.19040607f, -0.08101530f, 0.07637981f, 
    -0.05598446f, -0.11551669f, 0.05888481f, -0.03227424f, -0.03479505f, 0.01202951f, -0.12763019f, 0.07580107f, 
    0.26714107f, 0.11105999f, 0.15740678f, 0.03395505f, -0.00174062f, -0.00222727f, 0.12936981f, 0.07811010f, 
    -0.05044159f, 0.05855594f, 0.09301402f, 0.06228392f, -0.27221188f, -0.02856747f, 0.07449467f, 0.02252043f, 
    -0.04285111f, 0.05117433f, -0.04658110f, 0.04375923f, 0.04756594f, -0.02016266f, 0.08240133f, 0.02879456f, 
    -0.30870029f, -0.00869093f, 0.09426142f, -0.19179438f, 0.02701585f, 0.03761133f, -0.00829624f, -0.01498319f, 
    -0.03406779f, 0.01963798f, -0.05137714f, -0.15433881f, -0.00719861f, -0.25353158f, 0.08793712f, 0.02309258f, 
    -0.11113895f, 0.01161512f, 0.06007456f, 0.03698138f, 0.04153373f, -0.01564857f, 0.02852631f, 0.01435626f, 
    0.01406184f, 0.19898768f, -0.16095871f, -0.13501127f, -0.03579405f, -0.12198045f, -0.08637975f, -0.22388078f, 
    -0.07678075f, -0.08440610f, 0.13058865f, -0.00273590f, -0.33185524f, 0.06583489f, 0.08626582f, 0.03579702f, 
    -0.00557846f, -0.09224261f, 0.00278965f, 0.14703919f, -0.02880982f, -0.01953422f, 0.02217141f, 0.05960814f, 
    -0.12315403f, -0.09036306f, 0.05460569f, 0.12797828f, -0.02052562f, 0.02220664f, 0.03951296f, -0.07813207f, 
    0.10559957f, -0.00003633f, 0.01552738f, -0.03807066f, 0.20682891f, 0.05170858f, 0.08441587f, 0.12163286f, 
    -0.07636821f, -0.03842957f, -0.04567364f, 0.04441538f, 0.07994133f, 0.13353159f, -0.00764022f, 0.09011877f, 
    -0.16208293f, -0.08373322f, -0.07362932f, -0.04542079f, 0.05423900f, 0.04711836f, -0.12508953f, 0.02613827f, 
    0.02504964f, -0.05318566f, -0.06756195f, 0.00138155f, -0.33385307f, -0.10142615f, 0.06005367f, -0.02492454f, 
    0.05863180f, 0.05614473f, 0.06978958f, -0.10964497f, 0.07197819f, -0.07762907f, -0.15342756f, 0.02616545f, 
    -0.43790346f, 0.11385809f, 0.03852203f, -0.08108104f, 0.03722325f, 0.05132673f, -0.04355721f, -0.05042873f, 
    -0.08407471f, 0.10655946f, 0.06802948f, 0.10310394f, -0.22010526f, -0.26256460f, 0.09485153f, -0.33897391f, 
    -0.11679219f, 0.15733886f, -0.03248523f, 0.00272535f, 0.02974176f, -0.02182466f, -0.05381013f, -0.11485785f, 
    -0.03098821f, -0.03193919f, -0.21971633f, 0.01785283f, -0.04919571f, -0.03300005f, 0.02701432f, -0.08190230f, 
    0.04690873f, -0.02610335f, -0.01316975f, -0.07602670f, -0.07544309f, -0.10119086f, 0.05936153f, 0.04213414f, 
    0.01834238f, -0.01777467f, 0.13090430f, 0.09132018f, -0.01285685f, -0.04279320f, -0.04351346f, -0.10954685f, 
    0.11660090f, -0.24475543f, -0.09242067f, -0.20575759f, 0.03190547f, -0.00604902f, 0.07807026f, 0.00115817f, 
    0.08188366f, -0.02295611f, 0.10644702f, 0.07145744f, -0.13743803f, 0.02534915f, 0.12590672f, -0.00360207f, 
    -0.09175545f, -0.07405604f, 0.12159099f, 0.02271941f, -0.00920617f, 0.07551515f, -0.15960672f, 0.03269885f, 
    0.16217503f, 0.19294563f, 0.02950224f, -0.16643728f, -0.14900497f, -0.17159934f, 0.11202852f, -0.05481928f, 
    -0.00445864f, -0.07116506f, -0.03318265f, -0.08492134f, -0.26450920f, 0.02294343f, -0.03510675f, -0.02265156f, 
    -0.05589792f, 0.07774867f, -0.04110968f, 0.05430841f, -0.05940215f, 0.16217990f, -0.04146137f, -0.12929001f, 
    -0.12068875f, 0.01632104f, 0.05926981f, -0.02171463f, 0.14218213f, 0.08667822f, 0.13594414f, 0.08988675f, 
    0.01918434f, -0.03507248f, 0.02539211f, 0.01314673f, -0.04160027f, -0.14090845f, -0.12003359f, 0.18343693f, 
    0.10779477f, 0.08907094f, -0.09791162f, 0.01911730f, -0.05161197f, -0.00002472f, -0.01243332f, -0.06791266f, 
    -0.02793633f, 0.01995806f, -0.13932402f, 0.02663467f, -0.04088399f, -0.12611298f, 0.04095155f, 0.11119488f, 
    -0.03374939f, 0.01880097f, 0.05099709f, -0.20872307f, -0.19220892f, 0.07014725f, -0.11396662f, 0.11346707f, 
    0.02543683f, 0.07447944f, 0.04526449f, 0.10194549f, -0.13407536f, -0.00515043f, -0.00010059f, 0.03117007f, 
    0.17112280f, -0.22725576f, -0.00977390f, 0.01383461f, -0.07497771f, -0.04762310f, 0.02694273f, 0.09282064f, 
    0.05514093f, -0.05777213f, -0.05311589f, 0.02409997f, -0.35295182f, -0.14204048f, 0.09070624f, 0.04509056f, 
    -0.05207592f, -0.00439243f, 0.00174309f, 0.03114451f, 0.06729543f, -0.17294657f, 0.01608498f, 0.00139529f, 
    -0.23367363f, -0.10551221f, 0.01658200f, 0.09735967f, -0.00083157f, -0.05188373f, -0.12852818f, -0.13785951f, 
    0.00090869f, -0.03141076f, -0.04001137f, 0.01537172f, 0.06094835f, 0.00252304f, 0.13049129f, 0.22174151f, 
    0.05228119f, 0.01713540f, -0.00109089f, 0.11004478f, -0.05148916f, 0.09909894f, 0.04429032f, 0.07043026f, 
    0.22558871f, 0.00603595f, 0.04733084f, 0.23695324f, -0.02103320f, -0.10345828f, 0.12883756f, 0.08062539f, 
    0.07687486f, 0.04744769f, -0.01627753f, -0.00390606f, 0.24553746f, 0.04373615f, -0.15551946f, -0.06435171f, 
    0.02666259f, 0.02221737f, 0.02297712f, -0.19304138f, -0.03527524f, -0.13640057f, -0.02800429f, -0.12142135f, 
    -0.24011706f, -0.12571858f, 0.12798007f, 0.12804200f, -0.07939497f, -0.00690642f, -0.01632043f, -0.05764140f, 
    0.08810950f, -0.02469117f, -0.04161780f, -0.13195674f, 0.01089082f, 0.17988044f, -0.05543010f, -0.11986250f, 
    0.02930944f, 0.02137870f, -0.04713082f, -0.02159478f, -0.13992369f, -0.03773038f, 0.00460928f, 0.08963843f, 
    -0.03583882f, -0.15667959f, -0.11289117f, 0.10157006f, -0.00872658f, 0.01147281f, 0.11209992f, 0.03990285f, 
    -0.12569050f, -0.04128379f, -0.04073747f, 0.04785784f, 0.11790904f, -0.29387945f, -0.06610017f, 0.08181866f, 
    -0.19527256f, 0.07542685f, 0.08956922f, -0.15458646f, -0.03493452f, 0.13166061f, 0.04692637f, -0.11561739f, 
    -0.02296397f, -0.03952850f, 0.03342573f, -0.06951654f, 0.04269972f, -0.03655684f, 0.05569125f, -0.16872972f, 
    0.07316803f, 0.05025858f, -0.04984340f, 0.01884742f, -0.03874578f, 0.15781523f, 0.17652646f, 0.11858416f, 
    0.02418754f, -0.03403933f, 0.02387957f, -0.07612120f, 0.03038746f, -0.01449924f, 0.01430698f, 0.02854070f, 
    -0.10677990f, 0.12391352f, 0.23621009f, 0.00036859f, -0.08596455f, -0.01491940f, -0.06301542f, 0.06483484f, 
    0.04728534f, -0.12677932f, 0.04999152f, -0.11375251f, -0.05188317f, -0.07485173f, 0.14278555f, -0.28848049f, 
    0.03039343f, 0.04295868f, 0.13162509f, 0.01445283f, -0.01672702f, 0.16370431f, 0.03705069f, -0.01349428f, 
    0.28882384f, 0.24817123f, -0.24962425f, -0.22314891f, -0.00063661f, -0.08283494f, 0.09796380f, 0.12023044f, 
    0.03621541f, -0.03433454f, 0.01309994f, -0.00303263f, -0.06269566f, 0.11485274f, 0.03083419f, 0.01739494f, 
    0.01396034f, 0.02034810f, -0.05742714f, 0.07278350f, 0.00333507f, -0.08743708f, -0.05635443f, 0.03758038f, 
    -0.11779954f, 0.29924834f, -0.02578763f, -0.15677716f, -0.03938480f, 0.04634511f, -0.06720580f, 0.08851569f, 
    -0.00548383f, 0.05711655f, 0.01675883f, 0.09417107f, -0.34238860f, -0.02054078f, -0.03523998f, 0.02514098f, 
    0.06731030f, 0.09862025f, -0.13101521f, 0.17061584f, -0.02211118f, 0.08049276f, 0.03525127f, 0.05745322f, 
    0.06210464f, 0.01999432f, 0.08311407f, 0.06792907f, -0.06694432f, -0.10181919f, 0.05568749f, 0.00330821f, 
    0.06014491f, 0.00329379f, -0.08532796f, -0.02007227f, -0.30282342f, 0.06478564f, 0.01173123f, 0.10098527f, 
    -0.04259212f, -0.08752862f, -0.01051305f, -0.06264085f, 0.00751575f, -0.07149401f, -0.05267801f, -0.01448133f, 
    0.03107779f, 0.03310852f, 0.06652040f, 0.11173162f, -0.18907218f, 0.10743531f, -0.14549160f, -0.04217622f, 
    -0.00799482f, -0.06287762f, -0.14177242f, -0.05801605f, -0.21837400f, -0.17744908f, 0.18746452f, -0.06277580f, 
    -0.05382609f, 0.14107960f, -0.01743007f, 0.07482931f, 0.09211575f, 0.03600741f, 0.02534431f, 0.13208009f, 
    -0.06300610f, 0.27263203f, -0.13966107f, 0.10706276f, 0.00369839f, 0.03744146f, 0.11571397f, -0.03098709f, 
    0.07444154f, -0.14393850f, -0.02243124f, -0.05243450f, 0.21076977f, 0.02784090f, 0.00647903f, -0.02294745f, 
    0.03909020f, 0.08872791f, 0.05976092f, -0.03660174f, -0.12460110f, 0.04019511f, -0.02544666f, 0.05317258f, 
    -0.13616416f, 0.03615708f, 0.03167802f, 0.32159811f, 0.05213121f, -0.15729284f, 0.04556716f, 0.05699307f, 
    -0.01035246f, 0.05823476f, -0.00004112f, -0.07179789f, 0.15064763f, 0.09975970f, 0.04776846f, -0.20796064f, 
    0.05998114f, -0.07096151f, 0.07238845f, -0.01510282f, -0.03507163f, -0.09713800f, 0.11729705f, 0.02021870f, 
    0.02813938f, 0.04633993f, -0.10633022f, 0.08259618f, -0.01053218f, 0.02183744f, -0.11431213f, 0.14088856f, 
    -0.07774155f, -0.13401970f, 0.03886561f, -0.06302860f, -0.10838728f, 0.03456387f, -0.08775634f, -0.20140260f, 
    0.00929273f, -0.04584833f, 0.09048744f, -0.18954273f, 0.01911704f, 0.07473436f, 0.02683648f, -0.06941523f, 
    0.05626101f, -0.02699175f, 0.17583264f, 0.09298449f, -0.00530155f, 0.03146017f, -0.03014053f, 0.01253232f, 
    -0.04401882f, -0.02736272f, -0.01736211f, -0.00221087f, -0.03570486f, 0.00513535f, 0.15767609f, 0.03799441f, 
    0.13519189f, -0.09879789f, -0.13166581f, 0.03456701f, 0.05426615f, 0.06695249f, -0.03050682f, -0.05868971f, 
    -0.50338984f, -0.21717788f, -0.08525144f, -0.08057781f, 0.00312176f, 0.08059604f, 0.09606539f, -0.10914268f, 
    -0.02581193f, 0.10427709f, 0.02072942f, 0.06863868f, 0.00596836f, -0.00744990f, 0.04690152f, 0.03722956f, 
    -0.02279082f, 0.03240089f, 0.07040364f, -0.03999262f, 0.03687568f, 0.01759404f, 0.01384482f, 0.17067391f, 
    -0.05045486f, -0.16044632f, -0.29377428f, 0.18694712f, 0.16781422f, 0.16571306f, -0.08752658f, 0.00150342f, 
    0.09155387f, 0.09090831f, -0.01464985f, 0.00675908f, 0.06281264f, -0.12053481f, 0.13051346f, 0.07250215f, 
    -0.04714040f, 0.00151124f, 0.01515088f, -0.05117232f, -0.10720162f, 0.08231933f, 0.13883269f, 0.10031057f, 
    0.15611450f, -0.05717810f, 0.09437073f, 0.03709587f, -0.04733179f, -0.08834386f, -0.08141647f, 0.03855577f, 
    -0.22337678f, -0.12137172f, -0.08775236f, 0.14785194f, 0.04990700f, 0.05941011f, -0.18689963f, -0.05878190f, 
    0.08152221f, -0.10371444f, -0.15927772f, -0.32312125f, -0.04035933f, -0.08071522f, -0.11472578f, -0.02764519f, 
    -0.58996892f, -0.09706686f, -0.20568936f, -0.14993885f, 0.13839644f, 0.03666798f, 0.14785239f, 0.08216624f, 
    0.03626406f, 0.11906288f, 0.02339862f, -0.02836025f, -0.38631085f, 0.08367599f, -0.21417995f, -0.15962620f, 
    0.09406541f, -0.05262549f, -0.08643051f, 0.01535445f, -0.02412797f, -0.15981232f, 0.10589675f, -0.16682743f, 
    -0.07631854f, 0.12869538f, -0.22290611f, -0.16269480f, 0.12486601f, 0.10877825f, -0.00003677f, -0.09892983f, 
    0.16144708f, -0.04578986f, -0.04725268f, -0.04063759f, -0.14445171f, 0.13336214f, 0.08394244f, -0.38286585f, 
    0.10522562f, -0.02107977f, -0.05405363f, -0.13021417f, -0.00836374f, -0.06657913f, 0.03706564f, -0.05857148f, 
    0.13421103f, 0.19871433f, 0.13036650f, -0.24166110f, -0.04965065f, -0.00354299f, -0.15846683f, -0.06340357f, 
    0.06289472f, -0.00981224f, -0.13313042f, -0.14073700f, -0.38153210f, -0.25239286f, 0.04844807f, 0.05835544f, 
    0.01567649f, 0.00591942f, -0.02763378f, -0.04139579f, 0.01757663f, 0.00767997f, 0.04869679f, 0.02902395f, 
    -0.31513730f, -0.19346321f, 0.00474281f, 0.10777172f, 0.13800219f, -0.02173947f, -0.13542470f, 0.07937530f, 
    0.03100201f, -0.00970312f, -0.00545852f, 0.08042552f, -0.20729187f, 0.16447489f, -0.09186311f, -0.01171433f, 
    -0.00738745f, -0.05307461f, -0.16571492f, -0.08546247f, 0.03809059f, -0.07494315f, -0.00890361f, 0.10674143f, 
    -0.23342806f, -0.09313847f, 0.04452091f, 0.08164104f, -0.01720836f, 0.02066918f, 0.04821325f, 0.08399574f, 
    0.03988099f, -0.09451328f, 0.03250183f, 0.04068874f, 0.05372671f, 0.01347196f, 0.01599130f, 0.09588356f, 
    0.04722207f, 0.07013728f, -0.01891265f, 0.06831837f, -0.13474660f, -0.11897548f, -0.00253769f, -0.08016901f, 
    0.03193044f, 0.05782050f, -0.04596375f, -0.09877025f, 0.02481470f, -0.09841441f, -0.04553970f, 0.11178546f, 
    0.08653275f, -0.05796131f, -0.04049445f, -0.05003983f, -0.01292769f, -0.04425478f, -0.01108799f, 0.04894636f, 
    0.06152700f, 0.23323232f, 0.03100239f, 0.01913730f, 0.11924756f, -0.16518055f, -0.14584532f, -0.20229310f, 
    0.07569200f, -0.05844550f, -0.06992951f, -0.06763325f, 0.11478111f, -0.11602795f, 0.04810615f, -0.01728937f, 
    0.05886371f, 0.12615219f, 0.03396531f, 0.11310889f, 0.07109544f, 0.10349656f, 0.14850587f, -0.08033441f, 
    -0.01920417f, 0.07188813f, 0.02660790f, -0.03008668f, 0.09955497f, 0.00415411f, 0.04174532f, 0.04256713f, 
    0.04226056f, 0.02064620f, -0.01375704f, 0.05248249f, -0.03816029f, -0.01004089f, 0.12038597f, -0.06778200f, 
    0.05594242f, -0.05473859f, -0.11987932f, 0.04863320f, -0.12153451f, 0.09921784f, 0.20715295f, -0.28594914f, 
    -0.05563561f, 0.05728023f, 0.00921636f, 0.04810101f, 0.05009361f, -0.20673497f, 0.19725060f, -0.03556553f, 
    -0.12618764f, -0.03556281f, 0.01686148f, -0.14096002f, 0.02237320f, -0.10155223f, 0.06124813f, 0.00678701f, 
    -0.04294893f, -0.11362682f, -0.05301695f, -0.20244683f, -0.14000279f, -0.02783700f, -0.04588228f, 0.17224845f, 
    0.07125042f, -0.02713888f, 0.09987166f, 0.01209460f, 0.01060699f, -0.02543162f, 0.07883923f, 0.06479287f, 
    -0.18522020f, 0.14771985f, 0.20804277f, -0.32132107f, 0.00675682f, -0.00883055f, 0.03001388f, 0.00065185f, 
    -0.09263802f, 0.04406203f, 0.03815883f, 0.12273575f, 0.00266456f, -0.01610020f, -0.00171393f, 0.20792098f, 
    -0.07812470f, -0.10315511f, 0.01640490f, 0.01359936f, -0.09672051f, 0.11232626f, 0.02460648f, 0.12989961f, 
    -0.08721161f, 0.18895406f, 0.14253990f, -0.21103089f, 0.06612099f, 0.13761744f, 0.08144815f, -0.09660433f, 
    0.00120470f, -0.03346658f, -0.13085419f, -0.07137534f, -0.00756752f, -0.05386386f, 0.01185180f, 0.11690231f, 
    0.04659165f, -0.16629863f, -0.03629739f, 0.03129195f, -0.02489405f, 0.07961750f, -0.03073200f, 0.15696391f, 
    0.07299145f, -0.06569654f, 0.05353055f, 0.08492793f, -0.14282043f, -0.06362262f, -0.07673921f, 0.06457944f, 
    0.11308745f, 0.11437806f, 0.01556951f, 0.04976052f, 0.18876670f, 0.02375056f, -0.00992877f, -0.12347487f, 
    -0.04329440f, -0.04074552f, -0.01290249f, -0.02158054f, -0.00083126f, 0.01088236f, 0.04701081f, 0.14236899f, 
    -0.34047887f, -0.12114201f, -0.03242099f, 0.14740989f, 0.11209597f, -0.03930458f, -0.02301933f, 0.02644162f, 
    -0.03595984f, 0.06073924f, 0.05564968f, 0.00122511f, -0.20670977f, -0.11522271f, -0.09394240f, -0.03424439f, 
    0.11774485f, -0.02605904f, 0.12227410f, -0.01104126f, 0.02099805f, 0.01040185f, -0.14771880f, -0.02988525f, 
    0.07614992f, 0.01855959f, 0.06010911f, -0.04218163f, 0.05842085f, 0.01366859f, 0.07629369f, -0.07461378f, 
    -0.00585396f, -0.04805627f, -0.12822466f, 0.04240803f, 0.08020125f, 0.00019586f, 0.08599612f, -0.14948387f, 
    -0.01157269f, -0.18775965f, 0.03240581f, -0.07289369f, 0.03552607f, -0.04214298f, -0.05345133f, -0.15214589f, 
    -0.21155901f, 0.02085416f, -0.16877684f, 0.07688719f, -0.03244527f, -0.03451848f, 0.07466861f, -0.04306842f, 
    -0.03439179f, -0.18307032f, 0.07786079f, -0.03115116f, -0.01619427f, 0.06205765f, -0.01956089f, -0.01083627f, 
    0.00224388f, -0.00146732f, -0.09639401f, -0.04257440f, -0.09158100f, -0.04993090f, 0.14588831f, -0.08409195f, 
    0.21422313f, 0.19360189f, -0.09351782f, -0.05746805f, -0.03677693f, -0.05743274f, 0.06192808f, 0.02214336f, 
    0.12172770f, 0.10424960f, 0.11181210f, -0.15035890f, -0.25470915f, -0.08586903f, -0.13921052f, 0.02777816f, 
    0.12411682f, 0.09438051f, -0.02107294f, -0.08597200f, 0.12585877f, -0.02983343f, 0.03047378f, 0.07777033f, 
    -0.26671067f, -0.09664373f, -0.03247122f, -0.01646352f, 0.04227992f, 0.05374473f, -0.08523622f, -0.11967894f, 
    0.08386116f, -0.03286870f, 0.10458728f, 0.18918151f, -0.10608055f, 0.11691436f, 0.22881055f, -0.00565612f, 
    -0.11380778f, -0.03163520f, -0.06781119f, -0.04571629f, -0.08468524f, -0.01318690f, -0.00707732f, 0.05564211f, 
    0.10198607f, 0.02346643f, 0.00931426f, -0.00211883f, -0.11866083f, 0.05318514f, 0.06290817f, 0.03988291f, 
    -0.03809857f, -0.04179299f, 0.12220487f, 0.18083511f, -0.13554054f, 0.27428240f, -0.00082958f, 0.07785215f, 
    -0.08474971f, 0.00515815f, -0.06650124f, 0.06587260f, -0.11450980f, 0.06981627f, -0.15024878f, -0.24054261f, 
    -0.06381947f, -0.04252254f, 0.10047935f, 0.22842768f, -0.11405499f, -0.01745865f, 0.01010307f, 0.06032604f, 
    0.16319425f, -0.09830996f, 0.10289485f, -0.11379905f, 0.15697446f, 0.07607863f, 0.15639122f, 0.05691915f, 
    -0.05023841f, -0.05327083f, 0.01225966f, -0.09972133f, 0.02475849f, 0.02032838f, -0.02245896f, 0.09026901f, 
    0.05077800f, 0.03243813f, 0.04316124f, 0.16127293f, -0.08611617f, 0.05090514f, 0.08639105f, 0.10073655f, 
    -0.01456470f, -0.00221146f, 0.09485806f, -0.01612951f, 0.06196800f, -0.14213789f, -0.01358834f, 0.19215222f, 
    -0.00874027f, -0.06601747f, 0.10605197f, 0.01384454f, 0.11997465f, 0.01643565f, 0.00297956f, 0.18097095f, 
    -0.01101816f, 0.03809656f, 0.02975843f, 0.15400533f, -0.08809528f, 0.09526942f, 0.11425225f, -0.08750848f, 
    -0.05362175f, 0.02641078f, 0.01813462f, 0.27965373f, -0.27423882f, 0.26345018f, 0.26717299f, -0.21265881f, 
    0.07288591f, 0.09199785f, -0.07363071f, 0.04189258f, 0.20639765f, -0.18049884f, 0.07473754f, -0.08545637f, 
    -0.22358216f, 0.09300103f, 0.17113625f, 0.07747352f, 0.07728926f, 0.09205983f, 0.00871430f, -0.13840038f, 
    0.04098677f, -0.04966759f, -0.07853408f, -0.02568369f, -0.07198566f, -0.06761154f, 0.17757598f, 0.10399703f, 
    -0.07639554f, -0.01018909f, 0.00695027f, -0.01238144f, 0.13200673f, 0.08538487f, 0.08529726f, 0.13749783f, 
    -0.08302557f, 0.01839563f, -0.00475439f, 0.00455324f, 0.11949871f, 0.03729669f, -0.08822569f, 0.00549225f, 
    -0.05610674f, -0.07546149f, 0.09078358f, 0.05853374f, -0.18963176f, 0.07431176f, 0.02821080f, -0.04931172f, 
    -0.03109311f, -0.20952679f, 0.10221265f, -0.15228054f, 0.00971781f, -0.06602030f, -0.09692148f, -0.01822405f, 
    0.03881453f, -0.15203330f, 0.00579684f, -0.14758316f, 0.00004801f, 0.03063530f, -0.05873195f, 0.10412588f, 
    0.08702487f, 0.00432807f, 0.09032895f, -0.17306472f, -0.27418283f, -0.21529700f, -0.04855602f, -0.12239740f, 
    -0.07562182f, 0.16488898f, 0.04150337f, -0.02121134f, -0.01045834f, 0.07269857f, 0.06602389f, -0.07779014f, 
    -0.01145441f, 0.09224821f, -0.08413836f, -0.01278689f, -0.07929133f, -0.03722897f, -0.00161373f, -0.05654655f, 
    0.14501187f, -0.03599776f, -0.03098582f, 0.17233466f, 0.21701089f, 0.07097466f, -0.04332748f, 0.01866629f, 
    -0.01217542f, -0.24465063f, -0.05798715f, 0.01679008f, -0.01432078f, -0.01422617f, -0.03752152f, -0.05658696f, 
    -0.28273892f, -0.04381676f, -0.08622581f, -0.08130503f, -0.07396237f, -0.09129132f, -0.07618134f, -0.00600468f, 
    -0.06920338f, 0.11740366f, 0.04966273f, 0.06367612f, 0.14393815f, 0.07966253f, 0.07833261f, -0.02654759f, 
    -0.01497415f, -0.10106166f, 0.05619882f, 0.08487643f, -0.04941867f, 0.03189658f, 0.13774921f, -0.05970417f, 
    0.03465264f, -0.15682167f, -0.19026187f, -0.10653093f, 0.01348628f, 0.19038665f, -0.06865595f, 0.00258366f, 
    0.09043571f, 0.01684991f, 0.04808579f, -0.04561294f, -0.24339223f, -0.11239185f, 0.17380455f, 0.34378561f, 
    -0.05204822f, -0.08474367f, -0.02992795f, 0.12705575f, 0.00745743f, 0.12606980f, -0.21705325f, -0.11256365f, 
    0.25956175f, -0.06326596f, 0.04891127f, -0.06868324f, 0.04325757f, 0.03218048f, 0.14259143f, -0.09205978f, 
    0.04286885f, -0.00064284f, 0.11583221f, -0.03037344f, 0.20405236f, -0.08301152f, 0.03975626f, -0.02438541f, 
    -0.06812860f, 0.11541308f, 0.10384112f, -0.06941873f, -0.02051700f, -0.00330028f, 0.11113032f, 0.17071159f, 
    0.27008283f, 0.12733476f, 0.05096766f, -0.26650617f, -0.18069568f, -0.10759896f, 0.01760807f, 0.10655461f, 
    0.09928079f, 0.01790264f, 0.09479209f, 0.12012786f, 0.20307773f, 0.00584665f, 0.06050042f, -0.09717258f, 
    -0.06476028f, -0.06945902f, 0.13657224f, 0.00939589f, 0.03279212f, 0.05972471f, 0.09333996f, 0.06104808f, 
    -0.13811743f, -0.12331232f, -0.02664879f, -0.28279084f, -0.08818077f, 0.04199295f, -0.00428096f, -0.02933032f, 
    0.04119530f, -0.08961305f, -0.03246092f, -0.01104411f, 0.08465378f, 0.16874613f, 0.02641739f, -0.33146489f, 
    0.00982079f, -0.01412803f, -0.04710196f, 0.01761646f, 0.06565767f, -0.02831465f, -0.01927338f, -0.15215270f, 
    -0.20824324f, -0.14373299f, -0.09516334f, -0.05122278f, -0.00753998f, -0.11410505f, -0.00921571f, -0.12296898f, 
    0.03275052f, -0.04904021f, 0.04529665f, 0.07326317f, 0.23973423f, 0.01775392f, -0.04669140f, -0.16336641f, 
    0.05605651f, 0.07620360f, 0.08552274f, -0.00696409f, 0.05737595f, 0.00456737f, -0.02161670f, -0.12078588f, 
    -0.05372975f, 0.05487240f, -0.06731795f, -0.02679662f, -0.02649702f, 0.16326143f, -0.00121856f, 0.03220354f, 
    0.10140074f, -0.05685506f, 0.04797449f, 0.12645605f, -0.04874180f, -0.14476009f, -0.16991280f, 0.10740668f, 
    -0.05154842f, 0.03703558f, -0.01282076f, 0.03647678f, 0.05151886f, 0.02643357f, 0.08629052f, 0.03006879f, 
    0.14943746f, 0.02367491f, -0.10050111f, -0.16516934f, -0.09227256f, -0.04152386f, -0.01867658f, -0.15953456f, 
    -0.10172030f, -0.10030692f, 0.08968651f, 0.00268396f, 0.28334355f, -0.57438999f, 0.03328216f, -0.04807482f, 
    -0.03854619f, 0.01300559f, 0.05156222f, -0.00098743f, 0.09234078f, 0.03246895f, 0.09361698f, 0.17776622f, 
    0.06115525f, -0.25754908f, -0.16500610f, -0.20359150f, -0.09965888f, 0.06980934f, -0.11550197f, 0.00123810f, 
    -0.08875117f, 0.14587170f, -0.03699176f, 0.19124278f, 0.32215247f, 0.01022648f, 0.04390471f, -0.13045880f, 
    0.01004705f, 0.21332119f, 0.18222579f, 0.11970687f, 0.02009768f, 0.15312715f, 0.01443238f, 0.01932864f, 
    -0.30626205f, -0.33209005f, 0.05670635f, 0.03829212f, 0.16846640f, -0.00845184f, 0.07344203f, 0.04460594f, 
    -0.04439903f, -0.03745843f, -0.03282120f, 0.00587595f, -0.07746944f, -0.11901621f, -0.07802961f, 0.22882803f, 
    -0.03518221f, -0.06539314f, 0.00633781f, 0.03517551f, -0.04249060f, -0.03163130f, -0.13275540f, 0.00349445f, 
    -0.02411925f, 0.02746993f, -0.01487579f, -0.01034858f, -0.09241402f, 0.03562461f, 0.05878961f, -0.04246389f, 
    -0.00877408f, 0.08304986f, -0.01533814f, -0.02270339f, -0.19746831f, -0.36913791f, 0.14374770f, -0.14497399f, 
    -0.02106655f, 0.00905622f, 0.06029970f, 0.02695170f, -0.02521139f, -0.06269364f, -0.00188590f, -0.01072325f, 
    0.26963207f, -0.02499696f, 0.00609292f, -0.16066702f, -0.04850382f, -0.05129637f, 0.04678956f, -0.08904076f, 
    -0.11098720f, 0.00252586f, 0.08100931f, -0.11832464f, -0.19878352f, 0.08772521f, -0.14139214f, 0.14302382f, 
    0.05873641f, -0.00726782f, -0.09294532f, 0.01221026f, 0.15043795f, 0.12484687f, -0.07957406f, 0.03722901f, 
    -0.07297526f, 0.02593871f, -0.09637833f, 0.05865629f, -0.03936672f, 0.05200256f, 0.08388597f, 0.01802437f, 
    0.03198248f, -0.01040088f, 0.04018838f, -0.03468962f, 0.06249132f, -0.06478282f, -0.00374898f, -0.14228541f, 
    0.00462412f, -0.06177489f, -0.07889970f, -0.06437133f, -0.10707666f, 0.01333817f, 0.00780506f, 0.09201294f, 
    0.01376021f, 0.23849572f, -0.10116029f, -0.39180335f, -0.13166311f, 0.05476556f, -0.04460459f, 0.12128587f, 
    -0.09795444f, -0.13118763f, 0.05379821f, -0.13982743f, -0.23079133f, 0.17912705f, 0.11053892f, -0.15083104f, 
    0.01427092f, 0.06269389f, 0.02897894f, 0.05160176f, -0.14407396f, 0.03063190f, 0.03964897f, -0.14728382f, 
    -0.26790345f, 0.08380454f, 0.00125056f, 0.12732728f, -0.12856315f, -0.02946263f, -0.01973025f, 0.04693935f, 
    -0.01099415f, 0.01807202f, 0.02543688f, -0.03610444f, 0.18759309f, -0.08170148f, -0.12390812f, -0.14468566f, 
    -0.12930247f, -0.03958895f, 0.00001675f, 0.07113106f, 0.05265078f, 0.13434465f, -0.17273749f, 0.05556002f, 
    0.31696305f, -0.15304200f, 0.11812998f, 0.02994265f, -0.03214094f, 0.02339923f, -0.08312524f, -0.01606015f, 
    0.10325140f, -0.13463482f, 0.04518701f, 0.18984781f, -0.29852521f, 0.01457195f, -0.26700506f, 0.43068084f, 
    -0.02851623f, -0.03684283f, -0.09441888f, -0.03726472f, -0.01091508f, 0.08574327f, -0.01939298f, -0.14144297f, 
    0.26527002f, 0.04328123f, 0.27082101f, -0.05101124f, -0.12304438f, -0.08757210f, -0.13717549f, 0.06918968f, 
    -0.01653358f, -0.03785827f, 0.04457466f, -0.02780783f, -0.00107564f, -0.23977555f, -0.13794549f, 0.12065727f, 
    0.00681325f, -0.01997798f, 0.02622899f, -0.03713558f, 0.14838631f, -0.24684928f, -0.10223854f, -0.08338786f, 
    0.06159382f, -0.17476192f, 0.06609298f, 0.09759486f, -0.03190519f, -0.04849175f, 0.00069166f, 0.01880491f, 
    0.06147998f, 0.07861234f, 0.02911916f, 0.06083294f, -0.03117320f, -0.10124499f, -0.02161768f, 0.09794342f, 
    0.06409433f, -0.04265397f, -0.00494269f, 0.09293801f, -0.04318567f, -0.00444594f, -0.02475741f, -0.16082545f, 
    -0.10036073f, -0.09102248f, -0.05841897f, 0.13309887f, 0.01520854f, -0.06428216f, 0.11360990f, -0.17222494f, 
    -0.01544825f, -0.10082655f, -0.05439157f, -0.07832883f, 0.12400260f, 0.14987044f, 0.12084626f, -0.18634288f, 
    0.06066795f, 0.07448421f, 0.07090895f, -0.02288118f, -0.06245251f, -0.01851038f, -0.02269210f, -0.10448326f, 
    -0.20056744f, 0.09886830f, -0.13819872f, -0.34820274f, -0.17461827f, -0.05319405f, -0.00137968f, -0.17201588f, 
    -0.12903011f, -0.10522871f, -0.03411919f, 0.12948634f, -0.08976693f, -0.13807902f, -0.02265603f, -0.17230861f, 
    0.04916556f, 0.02065459f, -0.05478724f, -0.03403960f, 0.03991672f, -0.01718749f, 0.00998194f, -0.00541483f, 
    -0.12974584f, 0.13829844f, 0.21646532f, 0.00898309f, -0.09743021f, -0.02187273f, 0.00308799f, 0.19508347f, 
    -0.00445911f, 0.07623771f, 0.16427904f, 0.02618396f, -0.23287278f, 0.16110282f, 0.00955076f, 0.10223401f, 
    -0.01914388f, 0.04788277f, 0.10303415f, 0.06866567f, -0.02620339f, 0.03322774f, 0.05638549f, 0.18064234f, 
    0.16052039f, 0.10261824f, 0.03542173f, 0.33833525f, -0.03853990f, 0.05316961f, -0.03914727f, -0.01349016f, 
    -0.00565947f, 0.16256672f, -0.10150766f, 0.05893674f, -0.22706060f, 0.24244353f, 0.06341711f, 0.05313222f, 
    -0.05700712f, 0.02979409f, 0.01451379f, 0.16132180f, 0.07367724f, 0.08595924f, -0.13042043f, -0.04027236f, 
    -0.00433715f, 0.02481294f, -0.07231195f, 0.17864119f, 0.01183089f, 0.05073602f, -0.05913791f, -0.00325072f, 
    -0.03378050f, -0.01269290f, -0.06707082f, 0.03568692f, -0.27429387f, 0.01952017f, -0.19354221f, -0.21312883f, 
    0.00400564f, 0.05248370f, -0.11154982f, -0.05078304f, 0.00281593f, 0.08822795f, -0.05156868f, 0.08045968f, 
    -0.20617300f, -0.02120643f, -0.10799665f, -0.02087180f, 0.01435737f, 0.06143102f, -0.05963770f, -0.06515164f, 
    -0.02416532f, -0.07299735f, -0.21963593f, -0.10921609f, -0.24405171f, 0.01787747f, -0.02178982f, 0.23225898f, 
    0.10354574f, 0.03818035f, -0.07001796f, 0.02010222f, 0.00975085f, 0.04696404f, 0.04826294f, -0.06664121f, 
    -0.00200535f, 0.19111952f, 0.09300873f, -0.21430124f, 0.08571803f, 0.00687180f, 0.00994214f, -0.00798097f, 
    -0.05144479f, -0.02176603f, -0.09614215f, 0.03194824f, 0.21845256f, -0.02246010f, 0.11089557f, -0.21145338f, 
    0.18359461f, 0.02681765f, 0.00325628f, -0.05303380f, -0.00074203f, -0.10300364f, 0.08958519f, 0.10279040f, 
    0.00209126f, 0.02202288f, -0.19180566f, -0.08927983f, 0.01025664f, 0.07330028f, -0.23798807f, -0.03256115f, 
    -0.01537579f, -0.05239936f, 0.00844977f, 0.03387521f, -0.27296779f, 0.14092989f, -0.06037057f, -0.00304856f, 
    0.01547899f, 0.17605139f, -0.11599746f, 0.11695860f, -0.02318134f, -0.16021360f, 0.06779598f, -0.02841521f, 
    -0.06183105f, 0.02859530f, 0.05135433f, 0.15777709f, 0.10170932f, 0.05764870f, 0.02442340f, 0.00403737f, 
    -0.01878805f, 0.04952726f, -0.19062281f, 0.00978059f, -0.04896471f, -0.04907818f, 0.01416076f, -0.00776291f, 
    0.08432460f, 0.03936581f, 0.04192984f, 0.03654539f, -0.14283596f, -0.01956001f, -0.01626350f, -0.00588204f, 
    0.01543023f, 0.09561165f, -0.12315512f, -0.18879883f, -0.05575731f, -0.05301180f, -0.02670853f, 0.02224109f, 
    0.07232896f, -0.04902861f, -0.01568309f, -0.18368602f, 0.32332319f, -0.11621867f, 0.11586048f, 0.35679692f, 
    -0.10694983f, -0.03384011f, 0.11191060f, 0.12870492f, 0.04473426f, 0.06319005f, -0.12579380f, 0.01700947f, 
    0.19736061f, -0.19456957f, -0.10581578f, -0.03605330f, -0.01323332f, -0.01594394f, -0.05491239f, -0.00557514f, 
    -0.06688789f, -0.00536502f, -0.11873044f, -0.04124827f, 0.07673038f, 0.10886318f, 0.04382683f, -0.20064142f, 
    0.13714744f, 0.06080294f, -0.02361632f, 0.07081076f, -0.06368183f, -0.00215788f, -0.00995273f, -0.05222899f, 
    0.16499209f, -0.12316385f, 0.04865656f, -0.09821739f, -0.00559349f, -0.02406042f, 0.04565591f, -0.03458003f, 
    0.06836743f, -0.06755795f, 0.06719831f, 0.02331545f, 0.13147701f, -0.43691573f, -0.04230139f, 0.04702730f, 
    0.00148591f, 0.15193222f, 0.13845819f, 0.04813539f, 0.05684636f, -0.04994442f, 0.12017645f, 0.15549582f, 
    -0.30054766f, 0.20672470f, 0.17104846f, 0.01031897f, 0.03227329f, -0.03913918f, -0.00891433f, 0.01125603f, 
    -0.09247560f, -0.04008805f, 0.02247298f, 0.10393343f, -0.48584700f, -0.11968873f, -0.08244241f, 0.07524570f, 
    -0.01812180f, 0.05573204f, 0.09571885f, 0.03824572f, -0.02619389f, -0.10607149f, -0.11886299f, 0.03300670f, 
    -0.07121869f, 0.05387781f, 0.11422525f, -0.04946476f, -0.04194421f, 0.01542053f, 0.05730971f, -0.09429185f, 
    -0.02577773f, 0.10858686f, -0.07868190f, -0.19463676f, -0.34700850f, 0.20352139f, -0.09522804f, 0.26019922f, 
    -0.01014826f, 0.18806773f, -0.01259317f, 0.03110941f, -0.02022283f, -0.03929047f, -0.09716375f, 0.01702134f, 
    0.26435775f, 0.04972238f, -0.10779621f, -0.04795513f, -0.13108841f, 0.02325451f, -0.05330728f, 0.10418383f, 
    -0.01661984f, -0.07358959f, -0.22389464f, -0.06065112f, -0.01827347f, 0.03677541f, 0.13592976f, -0.22014698f, 
    0.00855669f, 0.02902324f, 0.00526982f, -0.02482012f, 0.03551198f, 0.08469003f, -0.09846245f, 0.14040041f, 
    -0.22547831f, -0.05893974f, -0.25511208f, -0.10749729f, -0.15031134f, -0.03434049f, 0.05321364f, -0.05706929f, 
    -0.07441860f, 0.05925879f, -0.16002080f, -0.02350921f, 0.09505454f, -0.19321918f, -0.17337056f, -0.04380284f, 
    0.00094914f, 0.10876191f, -0.08820428f, -0.03154907f, -0.02577132f, -0.00067097f, 0.10240515f, 0.09975756f, 
    0.34891784f, -0.14674628f, 0.18337068f, -0.09225401f, 0.02481982f, 0.00298816f, -0.00082999f, 0.03023813f, 
    0.02737429f, 0.05249516f, -0.05601645f, -0.01490366f, -0.03607679f, 0.05357885f, 0.02167200f, -0.09323951f, 
    0.00604902f, 0.05845199f, -0.01025548f, 0.01017446f, -0.01917660f, -0.03331965f, -0.05163952f, -0.04566456f, 
    -0.32591289f, -0.02192935f, -0.27536514f, -0.04099186f, -0.01590616f, -0.07150789f, 0.03834029f, -0.07730452f, 
    -0.14393829f, 0.03835588f, -0.05767560f, -0.13663240f, -0.13117410f, 0.04839239f, -0.02632506f, -0.14179592f, 
    0.05559544f, 0.00211163f, -0.04069296f, -0.14056091f, 0.01144050f, -0.06214882f, -0.00548412f, -0.01261251f, 
    0.06613573f, 0.11002973f, 0.14744923f, 0.10189649f, 0.08976499f, 0.00902436f, -0.02834037f, -0.06554156f, 
    -0.04923649f, 0.02961868f, -0.05987406f, -0.04530882f, -0.28903618f, -0.02422442f, -0.11978653f, -0.11066732f, 
    -0.07732732f, -0.04065840f, -0.02217432f, -0.05796820f, -0.04120405f, 0.00473599f, -0.00730585f, 0.01183509f, 
    0.17422658f, 0.09350699f, 0.19075908f, 0.05798328f, 0.03031326f, 0.00195563f, -0.02246146f, -0.07600190f, 
    -0.00649595f, -0.02641814f, -0.05761659f, -0.03579968f, -0.31069803f, -0.03892428f, 0.07215432f, 0.06534496f, 
    0.03848607f, -0.04551536f, 0.01241105f, -0.08962518f, 0.03670964f, 0.01789626f, 0.03280287f, -0.09585968f, 
    0.07283334f, -0.09404914f, -0.05374591f, 0.10177384f, -0.07228749f, -0.09540057f, -0.08176096f, -0.07203029f, 
    -0.06118064f, 0.04095355f, 0.01515209f, -0.08170426f, -0.06939626f, 0.20161253f, 0.04429409f, 0.13908571f, 
    0.08937193f, 0.00831097f, 0.01874869f, 0.01299885f, 0.02802862f, -0.04141445f, 0.03799428f, -0.06253829f, 
    0.08765814f, 0.16220704f, 0.13366053f, 0.02332086f, -0.00812270f, 0.08898178f, -0.04164700f, 0.00883404f, 
    -0.02226681f, 0.02668983f, 0.01167882f, 0.01019525f, 0.21412331f, 0.02118635f, 0.13765597f, 0.09156890f, 
    0.06210963f, 0.02435040f, 0.00729407f, 0.00983537f, -0.03329289f, 0.00635704f, -0.02599892f, 0.04952493f, 
    -0.04704501f, 0.22440459f, 0.10984161f, 0.04036805f, 0.06766051f, 0.03936142f, 0.10826733f, -0.00629172f, 
    -0.03408629f, 0.03504562f, 0.07770211f, -0.03732499f, 0.26867685f, -0.04095279f, 0.02578882f, -0.32431266f, 
    -0.08002201f, -0.03454174f, 0.01477000f, -0.05550687f, 0.04553391f, -0.04948793f, 0.04518293f, -0.09754951f, 
    -0.09791277f, -0.02765853f, 0.14274509f, 0.02451048f, 0.10409420f, 0.04343993f, 0.03611394f, -0.00013098f, 
    -0.00634181f, 0.03519626f, 0.11113207f, 0.04434774f, 0.28867719f, -0.12016498f, 0.09399015f, 0.20068777f, 
    0.07633123f, 0.03621677f, -0.04657495f, -0.06291462f, -0.01546348f, -0.06703260f, -0.00826384f, -0.01878205f, 
    0.02605471f, 0.15762782f, 0.04240669f, 0.19143793f, 0.09390652f, 0.01407570f, 0.00693227f, -0.07477554f, 
    -0.01716137f, -0.06708520f, 0.00094144f, -0.10950127f, -0.01042200f, 0.06527522f, 0.00793713f, -0.10619965f, 
    -0.13590537f, 0.02181648f, -0.06497658f, -0.09543942f, 0.00490369f, 0.00075085f, -0.02700274f, -0.01566411f, 
    0.30559397f, 0.04572525f, 0.04134453f, -0.08922981f, -0.05331184f, -0.00174188f, -0.06934660f, -0.05420867f, 
    -0.04039518f, -0.02953820f, -0.05352374f, 0.03393199f, -0.18760893f, -0.05027971f, -0.06297453f, 0.05674792f, 
    0.03060236f, 0.02863442f, -0.04755350f, 0.00164749f, -0.08063855f, -0.04277327f, 0.03941720f, -0.02166432f, 
    0.14539392f, 0.04475807f, -0.05447295f, -0.02741840f, -0.09474934f, -0.01782500f, -0.05344233f, -0.04731723f, 
    -0.03124539f, 0.01935200f, 0.02025863f, -0.09698973f, -0.17383771f, 0.14671856f, 0.21095327f, 0.12820862f, 
    0.00085132f, 0.06843312f, -0.03741552f, 0.08709931f, -0.06561656f, 0.01657401f, 0.04123290f, -0.02874707f, 
    0.13437082f, -0.00959151f, 0.04067071f, 0.01994024f, -0.01307514f, -0.03370502f, -0.00503862f, 0.02180827f, 
    0.01289569f, -0.01418230f, -0.03986028f, -0.04469198f, -0.10515228f, -0.00428892f, 0.00344004f, -0.15578851f, 
    0.02605429f, -0.01384026f, -0.09614767f, -0.07892092f, -0.01571616f, 0.03611906f, 0.03077555f, -0.01241495f, 
    -0.18957767f, 0.02716646f, 0.02864392f, -0.08434328f, -0.05278236f, 0.00870648f, -0.05544286f, -0.08051452f, 
    0.02567291f, 0.04868071f, -0.03014644f, -0.03875080f, 0.16761175f, -0.02136389f, 0.01825064f, -0.16020042f, 
    -0.11821476f, -0.00633079f, -0.02680284f, -0.11338350f, -0.15480800f, -0.01722964f, -0.01369786f, -0.08524831f, 
    0.28011268f, -0.04781071f, -0.00047157f, -0.11529395f, -0.09662043f, 0.01375112f, -0.05460550f, -0.06166285f, 
    -0.04074906f, -0.00574675f, -0.05472092f, 0.08696095f, -0.04757128f, -0.06596188f, -0.13104589f, -0.03356595f, 
    0.04332639f, -0.03373943f, -0.01873276f, -0.01275383f, 0.01147886f, -0.09065018f, -0.09591760f, -0.05574914f, 
    -0.02522324f, 0.00984803f, -0.01753852f, -0.07037872f, -0.07296515f, 0.03994210f, 0.01670472f, -0.03365175f, 
    -0.00564711f, -0.06039064f, 0.00032734f, -0.12279949f, 0.03964925f, 0.00892868f, 0.00076690f, 0.16401458f, 
    0.05926132f, -0.04860443f, -0.03741450f, 0.03774754f, -0.02918141f, -0.04597930f, -0.12586147f, -0.12941799f, 
    0.09882801f, 0.06514354f, 0.12268554f, 0.05393849f, 0.06147316f, 0.01195831f, 0.00000047f, 0.03767446f, 
    -0.05482728f, 0.01840399f, 0.06823616f, -0.11445026f, 0.15462604f, 0.11860739f, 0.11229647f, 0.12670159f, 
    0.04646403f, 0.00237377f, -0.05389501f, 0.00207007f, -0.11822124f, -0.05083125f, -0.00636205f, -0.03568884f, 
    0.23384990f, -0.20156245f, 0.13877551f, 0.12206654f, 0.10154132f, 0.00930091f, -0.03756554f, -0.07370173f, 
    -0.02376220f, -0.08458358f, -0.12922999f, -0.09572492f, -0.00666984f, -0.22762334f, -0.00499439f, -0.06231174f, 
    -0.03181006f, -0.00868117f, -0.01527444f, -0.00869205f, -0.02779110f, -0.06551295f, -0.01615119f, -0.02032658f, 
    0.10414936f, 0.16740842f, 0.20701359f, 0.11186821f, -0.04206763f, 0.06017691f, -0.03640875f, -0.05505704f, 
    0.01558742f, 0.02296308f, -0.08791551f, 0.00375750f, 0.05113349f, 0.15410611f, 0.13670914f, 0.12411650f, 
    0.11643584f, 0.01458206f, 0.10341728f, 0.02143388f, -0.08268184f, -0.01902645f, 0.03071705f, -0.02923786f, 
    0.09991100f, -0.09035262f, -0.11342832f, -0.10082980f, -0.02783943f, 0.08959337f, -0.01200334f, 0.01328323f, 
    -0.09272007f, -0.06533338f, -0.06336303f, -0.05316195f, -0.03403887f, 0.04575277f, 0.05359946f, -0.08095394f, 
    0.01991399f, -0.00937134f, -0.00912178f, -0.05465810f, 0.00631318f, -0.01897790f, -0.07743818f, -0.09526337f, 
    0.05395573f, 0.07654332f, -0.03121933f, 0.15102188f, 0.07039919f, -0.11043589f, 0.04558261f, 0.03266913f, 
    0.01110046f, 0.08478882f, -0.01942457f, -0.06348313f, -0.19993475f, -0.02762284f, -0.19497812f, -0.16407728f, 
    0.03670890f, 0.09991901f, 0.00266068f, -0.01220940f, -0.07382126f, -0.00131500f, 0.04507695f, -0.04661496f, 
    -0.21298161f, 0.10722063f, -0.04501237f, -0.10095672f, -0.06370037f, -0.00510514f, -0.00559392f, -0.03705393f, 
    0.06414954f, -0.04108150f, -0.01135887f, -0.00604420f, 0.14258827f, 0.05338436f, 0.12573698f, 0.14150442f, 
    0.07322867f, -0.00961795f, 0.01540043f, 0.01815379f, -0.02863849f, -0.02391333f, -0.06480162f, -0.08545067f, 
    0.02631302f, -0.04942260f, 0.10435055f, 0.12407652f, 0.07962148f, -0.06021030f, -0.02219198f, -0.03124650f, 
    0.00983493f, -0.08689373f, -0.15749887f, -0.05585171f, -0.22624077f, 0.15640837f, -0.01424240f, -0.24719231f, 
    -0.10757585f, 0.06500986f, -0.02725875f, -0.04057971f, -0.05165970f, -0.06397127f, 0.04753957f, -0.07826038f, 
    -0.09884994f, -0.10288687f, -0.20914638f, -0.11726144f, -0.01405509f, -0.06738577f, -0.03183595f, -0.05667817f, 
    -0.06140533f, -0.00522409f, -0.02266160f, -0.03084175f, 0.14434482f, 0.10210993f, 0.09562916f, 0.08506483f, 
    -0.06542313f, -0.07276323f, 0.02513667f, 0.06324642f, -0.06575380f, -0.01782397f, -0.04662756f, -0.04993148f, 
    -0.09837414f, 0.04238644f, -0.04465432f, 0.05518274f, -0.06650756f, -0.00628835f, -0.08346169f, -0.01229816f, 
    -0.09833501f, 0.00954477f, 0.00185360f, 0.02249849f, -0.04707416f, -0.01508668f, -0.10775881f, 0.04572590f, 
    0.04200235f, 0.05369874f, -0.08829428f, 0.03086249f, -0.11583330f, 0.04635571f, 0.04723246f, -0.08804127f, 
    -0.00775643f, -0.10160542f, 0.06805334f, 0.06674696f, -0.02545230f, 0.05322018f, -0.01225991f, -0.06406052f, 
    -0.05603379f, -0.05650671f, 0.03463155f, 0.00070625f, 0.04117298f, -0.23170598f, 0.15347616f, 0.19820583f, 
    0.03518445f, -0.03066020f, -0.07720596f, -0.07280760f, -0.05196854f, -0.09249924f, -0.05843461f, -0.03932104f, 
    -0.37001145f, 0.05342262f, -0.14648156f, 0.06664810f, -0.04098417f, -0.10180339f, -0.03033803f, 0.00877849f, 
    -0.01802831f, 0.03460864f, 0.07713048f, 0.03513476f, -0.01208912f, -0.05203580f, 0.12531365f, 0.07829484f, 
    0.05473723f, -0.06591508f, 0.05076226f, -0.03262793f, 0.01371895f, 0.04564442f, 0.10989707f, 0.00703520f, 
    0.03015420f, -0.08307707f, 0.09106889f, -0.13801306f, -0.01181214f, -0.04822939f, -0.05145795f, -0.12954015f, 
    0.03731633f, -0.01280583f, -0.03791417f, 0.03315530f, -0.10212694f, -0.01881150f, -0.12687078f, -0.02167448f, 
    -0.08882854f, 0.00491041f, 0.02840028f, -0.08145361f, -0.08395195f, -0.01794971f, 0.00932275f, -0.02978029f, 
    0.03312301f, 0.07060470f, 0.00852053f, -0.01597066f, 0.00354308f, -0.14859745f, 0.06503752f, -0.00533680f, 
    0.01250821f, -0.02353742f, -0.03603361f, 0.02266530f, 0.02990809f, -0.08363859f, -0.03267506f, -0.07855488f, 
    0.00504217f, 0.07096635f, -0.07783206f, 0.05704699f, 0.07653148f, -0.00947005f, 0.00025497f, 0.07765852f, 
    -0.06914876f, -0.08997957f, -0.06710586f, -0.16084090f, 0.03053918f, -0.06863597f, -0.09156222f, -0.02054622f, 
    -0.03309911f, 0.01089791f, -0.06546122f, 0.02381708f, 0.07935835f, -0.06126671f, 0.17896761f, 0.14329830f, 
    0.02224141f, -0.04537077f, 0.00205951f, 0.01905015f, -0.05005126f, -0.01405090f, 0.00761187f, -0.09281579f, 
    -0.00175317f, 0.03168181f, -0.06018970f, 0.08913652f, -0.09708600f, -0.06508358f, -0.08142579f, -0.07486006f, 
    -0.08728592f, -0.02931964f, -0.01820016f, -0.17136668f, -0.04781326f, -0.17534599f, -0.16322090f, -0.15124011f, 
    -0.04371253f, -0.05636782f, -0.03024415f, -0.01490441f, 0.00231617f, 0.00293710f, -0.01155525f, -0.02088564f, 
    -0.07160689f, 0.14446712f, -0.00071299f, 0.05637548f, -0.13082354f, -0.01831373f, -0.00365777f, -0.00359619f, 
    -0.08433008f, -0.01066318f, -0.08000270f, -0.19854818f, 0.11001070f, 0.03311026f, 0.07862959f, 0.11193737f, 
    -0.09787432f, 0.03722160f, 0.03674997f, -0.07952855f, -0.01286261f, -0.01073920f, -0.01023139f, -0.13883820f, 
    0.05809451f, 0.17345378f, -0.03037928f, 0.13062498f, 0.08925931f, 0.03083186f, 0.05584430f, -0.07177733f, 
    0.09179256f, 0.06014288f, 0.05382640f, -0.01679514f, 0.10695226f, -0.20067869f, 0.14405560f, 0.12975593f, 
    0.00828550f, -0.10493780f, -0.04835140f, -0.09175940f, -0.02630306f, -0.10267808f, -0.07641628f, -0.05606176f, 
    -0.00798768f, -0.16069825f, -0.08695836f, -0.17049274f, 0.10809851f, 0.01200758f, 0.04454447f, -0.02341230f, 
    0.09054030f, -0.01529193f, -0.00112994f, 0.09092626f, 0.08131121f, -0.14377655f, 0.15036477f, 0.12042135f, 
    -0.00903614f, -0.02569812f, 0.01623506f, -0.06005347f, 0.04962378f, -0.13805877f, 0.00605178f, 0.04118571f, 
    -0.18141522f, 0.08361463f, -0.03664843f, 0.19750029f, 0.00773939f, -0.04586950f, 0.02357361f, -0.11874044f, 
    0.11473575f, 0.00577883f, -0.02634383f, -0.05511560f, 0.16892943f, 0.01194831f, 0.06927659f, 0.09179579f, 
    0.07495996f, -0.07080097f, -0.08956080f, -0.00683418f, 0.07966250f, -0.04776475f, -0.03061921f, -0.12219320f, 
    -0.24671252f, -0.13793242f, 0.16374615f, -0.13764381f, 0.02506288f, -0.02302640f, -0.00850874f, -0.04052211f, 
    -0.05163091f, 0.05436598f, 0.06526498f, 0.01492332f, -0.10640018f, -0.02216309f, -0.04914538f, 0.17818917f, 
    0.11043432f, 0.08154686f, 0.03881963f, -0.06457579f, -0.00696522f, 0.04428653f, 0.04183386f, 0.07408203f, 
    -0.06952924f, 0.11800923f, -0.02169555f, -0.10917639f, 0.02163856f, 0.02631896f, -0.04423961f, 0.03752426f, 
    -0.01192716f, 0.02828143f, -0.08091598f, -0.05667730f, -0.19733256f, -0.20473765f, -0.10277984f, -0.06400837f, 
    -0.03137954f, -0.02297856f, -0.03071451f, 0.03562100f, 0.06553341f, 0.04267312f, 0.01729764f, -0.01751000f, 
    -0.15345676f, -0.02117296f, -0.30165821f, -0.29647467f, -0.07042158f, -0.01614033f, -0.10154053f, 0.05848155f, 
    0.03745519f, 0.01923834f, -0.10324333f, 0.07700972f, 0.02766068f, 0.04160987f, 0.04225058f, 0.03397717f, 
    -0.01854155f, 0.00432565f, -0.01851668f, -0.05627429f, -0.07437012f, 0.02045802f, -0.03934452f, -0.06136552f, 
    -0.14196594f, -0.05897842f, 0.17797878f, -0.14532964f, 0.05941620f, -0.02660242f, 0.04914784f, -0.12169413f, 
    -0.01637715f, 0.02892748f, -0.02634917f, -0.00275693f, 0.06438967f, -0.26150841f, 0.13439752f, 0.01777057f, 
    -0.09294342f, 0.01542476f, 0.02040293f, 0.04162290f, -0.04285212f, -0.08203023f, -0.10113311f, -0.20573474f, 
    -0.12465270f, -0.07971949f, 0.16418029f, 0.07890852f, -0.18978716f, -0.00250635f, 0.02458945f, -0.19357567f, 
    0.02271396f, -0.04510564f, -0.07363616f, -0.14259508f, -0.15990543f, 0.04547261f, -0.06265364f, -0.00662027f, 
    0.04216177f, -0.08819998f, 0.01652169f, -0.06215853f, -0.03475850f, -0.12468114f, -0.01532832f, 0.06811195f, 
    0.00158302f, 0.07747343f, -0.03127601f, 0.07005717f, -0.05974666f, -0.01868574f, -0.18625703f, -0.01223060f, 
    0.03531102f, -0.02095514f, 0.03266805f, 0.07339884f, 0.17764802f, 0.13360292f, 0.01091035f, 0.15967402f, 
    0.09530626f, 0.00250011f, 0.06977296f, -0.05422224f, 0.01065826f, -0.01926808f, -0.01466120f, -0.02891226f, 
    -0.13586874f, -0.05786389f, 0.01895852f, -0.15838146f, -0.01399225f, -0.03025582f, -0.07386232f, 0.00878867f, 
    0.01040065f, -0.01511356f, -0.01309124f, 0.11700521f, 0.11817081f, 0.01441079f, 0.11544177f, 0.10795859f, 
    -0.00128229f, -0.01439780f, -0.05814027f, 0.00058495f, -0.03516982f, 0.00409385f, -0.01037177f, -0.13431215f, 
    0.12442898f, -0.23693262f, -0.04465406f, -0.05618440f, 0.02444639f, -0.01658538f, -0.01187036f, -0.09040478f, 
    -0.03910946f, 0.06499396f, -0.00137244f, 0.09289891f, 0.10292838f, -0.07670918f, -0.22729917f, -0.05346401f, 
    0.00492404f, -0.00055556f, -0.04878290f, -0.01500950f, 0.03911536f, -0.04212438f, -0.04396111f, 0.00120890f, 
    -0.01574522f, 0.14977801f, 0.00768134f, 0.00266849f, -0.04173493f, 0.07572516f, 0.00772616f, 0.08968241f, 
    0.04074673f, 0.02837913f, -0.00883538f, 0.04744510f, -0.06115662f, 0.02497455f, 0.04045958f, -0.00285839f, 
    -0.01289739f, 0.03926220f, 0.05400431f, 0.00225876f, 0.02198788f, -0.04154288f, -0.07772173f, 0.02611216f, 
    -0.25372800f, -0.07017958f, -0.13422294f, -0.26958150f, -0.12659876f, -0.09024969f, 0.09736537f, -0.00201639f, 
    0.05253631f, 0.05638510f, -0.02884989f, -0.02775566f, 0.09254443f, -0.17162973f, 0.08647995f, 0.09385432f, 
    0.04536836f, -0.03557841f, 0.01383889f, -0.01437662f, 0.02157106f, -0.00803030f, -0.06790920f, 0.03106794f, 
    0.11442599f, 0.08009112f, 0.02562112f, 0.02512033f, 0.00371659f, 0.03909415f, 0.03972850f, -0.07278257f, 
    0.01070969f, -0.03525076f, 0.04410756f, 0.06295216f, 0.01773485f, -0.05928029f, -0.05383850f, -0.15279357f, 
    -0.07939096f, -0.08762173f, 0.07979029f, -0.09105866f, 0.00492926f, 0.08951984f, -0.03828604f, 0.09977493f, 
    0.06243559f, 0.05837522f, -0.07044294f, -0.00417203f, -0.00312303f, 0.03050049f, 0.06957341f, -0.01928046f, 
    0.08621047f, 0.10603139f, 0.02325025f, 0.02746479f, 0.32215220f, 0.22287253f, -0.35554388f, -0.09247816f, 
    0.03774654f, 0.01129286f, 0.09795211f, -0.03408466f, 0.01184302f, 0.04261560f, 0.02346414f, 0.11953492f, 
    0.13460641f, -0.00003832f, -0.04223416f, 0.13153945f, 0.01704374f, -0.08288194f, -0.06664484f, -0.03904808f, 
    0.10519640f, 0.05038764f, -0.05160512f, 0.01807663f, 0.09992152f, 0.08737037f, -0.12619467f, -0.21582150f, 
    0.01852586f, -0.07525315f, -0.11373927f, -0.05510166f, 0.01540026f, 0.05627536f, 0.09846471f, 0.06929376f, 
    -0.10140754f, -0.10460103f, 0.01637285f, -0.17770337f, -0.09842960f, -0.03797875f, 0.00854662f, -0.14364626f, 
    0.02485447f, -0.11337384f, -0.17603199f, 0.05752775f, 0.05654085f, 0.12249717f, -0.13109766f, -0.02880696f, 
    0.05003591f, -0.02966784f, 0.00325381f, -0.10048164f, -0.09661075f, -0.04320385f, -0.02020095f, 0.06108176f, 
    0.12576905f, 0.04246083f, -0.04707494f, -0.11132387f, -0.04185559f, 0.04671615f, -0.04974463f, -0.04347999f, 
    -0.11844947f, 0.11565472f, 0.03045784f, 0.08928269f, -0.03294774f, -0.00000360f, -0.08585461f, 0.12903802f, 
    0.05664240f, -0.05600467f, -0.03198028f, 0.01191570f, 0.01260211f, 0.09383043f, -0.02288256f, 0.05657618f, 
    -0.10945273f, 0.05215714f, 0.11859703f, -0.07181648f, 0.07371723f, 0.02285651f, -0.03748138f, -0.06865497f, 
    0.05040896f, -0.06412418f, 0.06557301f, 0.05587837f, -0.14726041f, 0.04990937f, 0.09460480f, 0.03510901f, 
    -0.14391853f, -0.02563057f, 0.13098665f, -0.01345766f, 0.05063194f, -0.02829243f, -0.02688712f, 0.07220302f, 
    0.08281949f, -0.03821389f, -0.04345033f, 0.09200966f, 0.01596403f, -0.05904049f, 0.02902530f, -0.06201209f, 
    -0.04285325f, -0.01330026f, -0.02683985f, 0.13221346f, 0.19625941f, 0.01014625f, -0.13287002f, 0.12259806f, 
    0.11119334f, -0.04930007f, -0.06415647f, -0.08587823f, -0.10282495f, 0.00229434f, -0.01299456f, -0.07604911f, 
    0.10516565f, 0.11990488f, -0.07583271f, -0.06221126f, 0.01138197f, -0.05296516f, 0.03079246f, 0.05351352f, 
    0.03214112f, -0.16777289f, 0.15980949f, -0.03910222f, 0.10998136f, -0.08850650f, -0.11285219f, 0.06288502f, 
    0.11643265f, 0.04976344f, -0.04490057f, -0.04626827f, -0.02794743f, 0.03172707f, 0.14215514f, -0.09660096f, 
    0.06453054f, 0.14101370f, -0.18168251f, 0.00627360f, 0.00458721f, 0.04868087f, -0.00003202f, -0.05406605f, 
    -0.05248994f, -0.03455915f, 0.06361371f, -0.03231701f, -0.20787746f, 0.03752087f, 0.02468736f, -0.09390598f, 
    0.00226761f, 0.00905800f, -0.09571356f, -0.11942597f, -0.02345238f, -0.03338085f, -0.10120033f, 0.10990078f, 
    -0.06367056f, 0.03445810f, 0.00241037f, -0.11994577f, -0.09858776f, 0.05455457f, -0.09838776f, -0.08555091f, 
    0.00397370f, -0.03591317f, 0.11903287f, 0.01011213f, -0.03879543f, 0.09613089f, -0.22309762f, -0.00751613f, 
    0.05138897f, -0.09015486f, -0.01843005f, -0.02925846f, 0.00140645f, 0.06940321f, -0.01569994f, -0.05855154f, 
    -0.07796286f, -0.16989441f, -0.09850404f, 0.01133138f, 0.10854303f, -0.02507812f, 0.00213120f, 0.03306603f, 
    0.02983340f, -0.00426426f, 0.06844048f, -0.01307853f, 0.04385778f, -0.02430451f, 0.08790283f, -0.09702821f, 
    -0.04760319f, -0.14365007f, -0.03089447f, 0.03370437f, -0.00856055f, 0.06697083f, -0.03072808f, -0.27847528f, 
    -0.12861469f, 0.12925313f, -0.06590476f, -0.15097614f, -0.00158079f, -0.00582240f, -0.03947481f, -0.00235559f, 
    0.07887506f, 0.09978680f, 0.01785846f, -0.00578354f, -0.10613261f, 0.03247934f, -0.20068014f, -0.14005993f, 
    0.03761664f, 0.02593907f, -0.05923297f, 0.01774302f, 0.03267166f, 0.07806304f, -0.01903653f, 0.00195236f, 
    0.02338393f, -0.09383114f, -0.25213972f, -0.04057550f, 0.12969171f, -0.08170433f, -0.02010725f, -0.00891624f, 
    -0.08892827f, 0.04701018f, 0.01040792f, 0.04715395f, -0.15503708f, 0.09969372f, -0.00717305f, -0.07611621f, 
    0.00944412f, -0.00523038f, 0.02661996f, -0.07375123f, 0.03404253f, -0.06034946f, -0.00538094f, 0.06175397f, 
    -0.12061418f, -0.00043679f, -0.08072866f, 0.10094152f, 0.02197863f, 0.09707938f, 0.00884560f, -0.11711556f, 
    0.05679658f, 0.05445805f, 0.00646598f, 0.06185243f, 0.06930950f, -0.19041233f, -0.13375005f, 0.00945943f, 
    -0.10554697f, -0.19116388f, -0.17396986f, -0.14252974f, -0.00714541f, -0.04654524f, 0.03172472f, 0.06970067f, 
    0.12693609f, -0.04709920f, 0.00227855f, 0.06378180f, -0.01844306f, -0.06856839f, -0.10805680f, -0.12050660f, 
    0.01602417f, -0.00030775f, 0.06456698f, -0.07250116f, 0.06298106f, 0.06266731f, -0.03974854f, 0.22700340f, 
    0.15653689f, 0.05048513f, 0.05251578f, -0.06486802f, 0.08332475f, 0.01130125f, 0.02508221f, 0.01696736f, 
    0.15458724f, -0.01902877f, -0.01497668f, 0.06317038f, 0.01106607f, -0.05901347f, -0.07002924f, -0.11107246f, 
    0.03647891f, -0.01143602f, 0.03985544f, 0.02650091f, 0.12754238f, 0.02322873f, 0.10645948f, 0.05786442f, 
    0.00742438f, -0.10902864f, 0.03617629f, -0.17500247f, -0.01114700f, -0.06297220f, -0.04856396f, 0.01199332f, 
    0.12375843f, -0.03227976f, -0.08363884f, 0.09822701f, 0.09812941f, 0.02699260f, 0.02250115f, -0.00297148f, 
    0.01326171f, 0.01225638f, 0.04381533f, -0.11977605f, 0.10501935f, 0.06412777f, 0.00847002f, 0.21433678f, 
    -0.16993754f, -0.03193921f, -0.03915085f, -0.16418660f, -0.01151492f, 0.04396834f, 0.03664219f, 0.02252289f, 
    -0.06779442f, -0.15855011f, 0.03543302f, -0.13521187f, -0.02276250f, -0.04242996f, 0.06340693f, -0.06424061f, 
    -0.06124347f, -0.01060860f, 0.01645336f, 0.16616593f, 0.20956798f, 0.14503272f, -0.25091386f, -0.09510986f, 
    0.04889573f, 0.00709032f, -0.04093298f, -0.03632735f, 0.11041539f, 0.00333797f, -0.15593049f, -0.02001691f, 
    -0.21503165f, 0.13714615f, -0.13809143f, -0.15988946f, -0.12083661f, 0.08148479f, -0.05528751f, -0.02140763f, 
    0.10116821f, 0.07029290f, 0.07121108f, 0.05877848f, 0.00172640f, -0.24697013f, 0.00017575f, 0.03548281f, 
    0.02979751f, -0.12872902f, -0.05305184f, 0.06369948f, 0.02645575f, -0.06695975f, 0.11089367f, -0.15797004f, 
    -0.08635928f, 0.13491011f, 0.07125942f, 0.17710015f, -0.05337733f, 0.09656513f, -0.16664368f, 0.01047072f, 
    -0.03901097f, -0.00441986f, 0.07272890f, 0.06145091f, -0.00626167f, -0.10774752f, 0.00692764f, -0.24898981f, 
    0.01071452f, -0.05948520f, 0.00139372f, -0.02519049f, 0.02429254f, 0.10100596f, -0.20890751f, 0.04892405f, 
    -0.08462024f, -0.08588866f, 0.02078798f, -0.04803221f, -0.06322061f, -0.08234244f, -0.03188728f, 0.01175610f, 
    -0.06258242f, -0.06223185f, 0.02149390f, 0.01449565f, -0.03823926f, -0.34070188f, 0.23149143f, -0.17730711f, 
    0.09091756f, 0.00561562f, 0.02821859f, 0.04047735f, -0.01605345f, 0.02915976f, -0.04690038f, 0.01132743f, 
    -0.12472154f, 0.28931287f, -0.34976220f, -0.20937131f, 0.05747753f, 0.04575593f, 0.08522860f, -0.07168073f, 
    -0.22571017f, 0.02181836f, 0.12243394f, -0.08779337f, -0.16052082f, 0.00076141f, 0.03019609f, -0.08287873f, 
    0.04648310f, 0.01686461f, -0.01954114f, -0.00415457f, -0.02234856f, -0.08057965f, 0.01758094f, 0.10894396f, 
    0.29102689f, -0.01187341f, -0.07956135f, 0.37195972f, 0.01857881f, -0.11315429f, -0.03833485f, 0.08085549f, 
    -0.01933136f, 0.02548631f, -0.03162801f, 0.01293087f, -0.25492653f, 0.13934906f, -0.19623670f, -0.31946823f, 
    0.13557288f, -0.06346110f, -0.08264926f, 0.04064239f, -0.05788443f, -0.07676905f, -0.04961598f, -0.13146406f, 
    -0.01040983f, -0.04093454f, -0.01760724f, 0.10466408f, 0.01253801f, 0.04743637f, -0.08812898f, 0.02801972f, 
    -0.13709433f, 0.04661483f, -0.00360036f, 0.02690844f, 0.02165703f, 0.11383691f, -0.28918383f, -0.18221892f, 
    -0.02897087f, -0.00029730f, -0.07910480f, 0.07702788f, -0.01896442f, -0.01219488f, -0.05142509f, 0.08134758f, 
    -0.18396841f, 0.03314677f, -0.12371814f, 0.00991007f, -0.12938322f, 0.00518649f, 0.03716055f, 0.06400923f, 
    0.11693042f, 0.14836501f, 0.01990275f, -0.00936680f, -0.24142659f, -0.20694166f, -0.00524400f, -0.04668527f, 
    0.04205949f, 0.01130834f, 0.07742268f, 0.09667689f, 0.07026878f, -0.03788140f, 0.08749841f, 0.01231962f, 
    0.02855324f, -0.14629778f, -0.05023822f, 0.20640729f, -0.03427272f, 0.02716378f, -0.07166889f, -0.03512441f, 
    0.01852137f, 0.06759045f, -0.01236661f, -0.06317084f, 0.14400776f, -0.04060565f, 0.02326269f, -0.12202817f, 
    0.05828424f, 0.01466410f, -0.00135798f, -0.13432114f, -0.04408611f, 0.09251484f, -0.14480862f, 0.11316693f, 
    -0.07062272f, -0.14682348f, 0.04549310f, 0.03422354f, 0.12240928f, -0.03164772f, -0.01016988f, 0.09564943f, 
    -0.01714315f, 0.00613370f, 0.07455463f, 0.09690994f, -0.19909254f, 0.07009759f, -0.02220632f, -0.01645207f, 
    -0.02451083f, -0.07227054f, -0.03187606f, 0.00425366f, -0.00605629f, 0.04988717f, 0.20018856f, -0.03051625f, 
    0.07640213f, -0.05397146f, -0.03627775f, 0.17322288f, 0.02395165f, 0.01527410f, 0.02451042f, -0.02708944f, 
    -0.09409896f, -0.06377915f, -0.00669801f, -0.19405235f, 0.30457389f, -0.40080205f, 0.25079069f, -0.12861635f, 
    0.06422107f, 0.01343751f, -0.02849228f, -0.08479219f, -0.02639880f, -0.07151825f, 0.05352118f, 0.05320440f, 
    -0.25463274f, -0.20491533f, -0.07306932f, -0.01470630f, 0.10626543f, 0.08468497f, -0.10158736f, -0.03614571f, 
    -0.05569310f, -0.06078393f, 0.02485945f, -0.13781165f, 0.21808274f, -0.03756706f, -0.03480494f, 0.00036280f, 
    0.09232900f, -0.04530432f, 0.08032989f, -0.03328589f, 0.00129807f, -0.03852889f, 0.01901072f, 0.01044243f, 
    -0.03822239f, 0.05578655f, 0.12774877f, -0.06975259f, -0.00797887f, 0.02884836f, 0.00961443f, -0.00846762f, 
    0.04387324f, 0.00835819f, -0.06028558f, 0.12205168f, -0.06087464f, 0.00432639f, 0.21530896f, 0.07409070f, 
    0.03688425f, 0.08102582f, -0.02078918f, -0.04902483f, -0.04478036f, -0.02695809f, -0.00836976f, -0.05576662f, 
    -0.03819502f, 0.11499018f, 0.08928113f, 0.18521519f, 0.10051800f, -0.00175589f, -0.01960624f, 0.10298301f, 
    -0.06448471f, 0.08568889f, 0.03047517f, -0.02284251f, -0.20945197f, -0.15699239f, -0.07281998f, 0.04693248f, 
    0.08809859f, 0.03399931f, -0.04220523f, -0.08589801f, 0.00272604f, 0.05724032f, 0.05294359f, 0.00780512f, 
    -0.11415700f, 0.02248734f, 0.13734934f, -0.03132455f, 0.09696114f, -0.07228672f, 0.00832269f, 0.03194533f, 
    -0.06252401f, -0.05109996f, -0.15098804f, -0.09567047f, -0.04562912f, -0.09191393f, -0.07623343f, -0.12075126f, 
    0.09014469f, 0.01832294f, -0.10979068f, -0.06527807f, -0.01720754f, -0.20364842f, -0.00230416f, -0.01379744f, 
    -0.02951081f, 0.26552138f, 0.03919838f, -0.02183180f, 0.09842221f, 0.09943108f, -0.03498834f, 0.01934642f, 
    0.06060324f, -0.08161779f, 0.02725216f, -0.08745747f, -0.07937655f, 0.04513136f, -0.03090805f, -0.10413899f, 
    0.04445246f, -0.06420600f, -0.01762684f, 0.00985558f, -0.04491434f, 0.00558359f, 0.03696838f, -0.04789177f, 
    -0.26393384f, -0.30825174f, 0.04858015f, -0.01733030f, 0.03602578f, 0.01003272f, 0.06676214f, 0.01053419f, 
    0.03333671f, 0.07176408f, -0.05168683f, -0.01532081f, 0.40779260f, 0.02173835f, 0.23336743f, -0.03248077f, 
    0.08740625f, -0.02444134f, 0.01577043f, 0.00368066f, -0.11282700f, 0.14404933f, 0.07425842f, 0.08638718f, 
    -0.26250923f, 0.05781547f, -0.23484640f, 0.00484064f, 0.19117010f, 0.01353616f, 0.07548924f, 0.02319570f, 
    0.01694475f, -0.06002263f, -0.01373616f, -0.05192839f, 0.01786353f, 0.00658151f, 0.06124672f, -0.11184019f, 
    0.03919612f, -0.04245247f, -0.10352314f, 0.02856100f, -0.01843637f, 0.05855821f, -0.03562666f, -0.03035753f, 
    0.09103030f, 0.09636883f, -0.10067558f, 0.28987920f, -0.03473487f, -0.01709175f, -0.11829944f, 0.08838914f, 
    -0.10923743f, 0.06432104f, 0.07068570f, 0.08585750f, 0.07605747f, -0.09492417f, 0.09083223f, 0.04099305f, 
    0.02069361f, 0.08187903f, -0.01471698f, 0.05750435f, 0.02601269f, -0.08434655f, 0.11284781f, -0.13762762f, 
    0.10222403f, -0.38261226f, 0.14528000f, 0.11421482f, 0.07387821f, 0.02601764f, -0.00380761f, 0.08785868f, 
    -0.06099778f, 0.02093026f, 0.02461493f, -0.09396393f, -0.06337605f, -0.02013320f, 0.18465261f, -0.09781128f, 
    0.04573169f, 0.00271016f, -0.08711103f, -0.03429957f, 0.17074159f, 0.00646575f, 0.02907299f, -0.16986896f, 
    -0.11888789f, -0.40219074f, -0.03864026f, 0.16150010f, -0.08187739f, 0.08539810f, -0.06873669f, -0.05688182f, 
    0.06643691f, 0.15651858f, -0.10916343f, 0.00551928f, 0.03842041f, 0.08360055f, -0.08228553f, -0.01614762f, 
    0.03309144f, -0.01048928f, -0.09380829f, 0.08026700f, -0.18835191f, -0.04962513f, 0.07404837f, -0.00828965f, 
    -0.06895221f, -0.11881752f, -0.00891610f, 0.04168655f, 0.07337273f, -0.00482830f, -0.05170338f, -0.02357523f, 
    0.09649973f, 0.05802677f, 0.00418415f, 0.05093060f, 0.02813585f, 0.06051829f, 0.06624799f, -0.16236298f, 
    0.02082513f, -0.01339409f, -0.06064316f, -0.02868264f, 0.23160830f, 0.06879440f, 0.03353562f, -0.01339979f, 
    -0.17081451f, -0.06523326f, 0.26886743f, -0.12493549f, 0.02073806f, 0.04334904f, -0.06226908f, -0.03209385f, 
    0.00179971f, -0.00001692f, -0.07901394f, 0.08893666f, -0.07444134f, 0.03744893f, 0.19353047f, -0.15058820f, 
    0.01200788f, 0.08992775f, 0.07301781f, -0.10342091f, -0.13007173f, 0.01068539f, -0.11199442f, 0.08292397f, 
    -0.28862932f, 0.11003239f, 0.33621368f, 0.08889211f, 0.07010259f, 0.03281173f, -0.00995837f, 0.01426599f, 
    0.15818970f, 0.01872665f, 0.04863530f, 0.01293173f, 0.04940443f, -0.22111577f, -0.11073664f, 0.03634975f, 
    -0.09574820f, 0.00367755f, 0.04185131f, 0.09791628f, -0.04316354f, -0.02691229f, -0.01087348f, -0.05344006f, 
    0.13694191f, -0.32491091f, -0.08830927f, -0.04013956f, -0.07714259f, -0.01002191f, -0.03313041f, 0.08625426f, 
    0.05197719f, 0.01982448f, 0.00295374f, 0.02629916f, -0.38842228f, 0.12788728f, 0.15687631f, -0.07233185f, 
    -0.05681536f, -0.04713685f, 0.06246362f, 0.02316057f, 0.06813936f, -0.05523679f, 0.03870753f, 0.08317861f, 
    -0.12311507f, 0.08186076f, 0.09491920f, -0.25862518f, 0.00717858f, -0.03621003f, -0.02265470f, -0.04937713f, 
    -0.03696958f, -0.02374746f, -0.14283480f, -0.05756110f, -0.19124262f, 0.12051812f, -0.08893139f, -0.09256953f, 
    -0.09184100f, -0.00191135f, -0.05713059f, -0.01074283f, 0.03805900f, -0.10493165f, 0.04393810f, 0.21263520f, 
    -0.18924484f, 0.17579189f, 0.06682035f, 0.14120352f, -0.05412834f, 0.03052117f, -0.09583984f, -0.11053781f, 
    -0.00419432f, -0.06664614f, 0.04517400f, 0.02712279f, -0.12468172f, 0.01514751f, 0.13204449f, 0.12944177f, 
    0.01292364f, 0.07487915f, 0.06430237f, -0.08606203f, 0.03430863f, -0.07145809f, -0.03230800f, -0.03583737f, 
    -0.01221066f, -0.28795847f, 0.12187946f, -0.16715135f, -0.08274842f, 0.03664991f, -0.11034854f, 0.01352128f, 
    -0.04822535f, -0.02080576f, 0.16479106f, -0.02710805f, 0.27177477f, -0.30904049f, -0.06588098f, -0.01098592f, 
    -0.10868107f, 0.08705036f, -0.07981770f, 0.11654583f, -0.04318674f, -0.00912502f, 0.05275795f, -0.12730584f, 
    -0.02603865f, 0.21471411f, -0.26288003f, -0.37223327f, 0.11313993f, 0.06838757f, -0.00903530f, 0.03145112f, 
    -0.10004628f, -0.00227639f, -0.04526946f, -0.16307671f, -0.00786194f, -0.10629091f, -0.13148092f, 0.20518994f, 
    -0.05338528f, 0.03421397f, 0.04554483f, -0.17298298f, -0.10388798f, -0.06965721f, -0.03582325f, -0.00349075f, 
    0.05894916f, -0.09603824f, -0.00175855f, -0.10854342f, 0.13484953f, -0.00777689f, 0.09834069f, -0.00523049f, 
    -0.02679991f, -0.03388740f, 0.02447625f, 0.06628896f, -0.33575365f, 0.24419731f, -0.34585190f, -0.25806093f, 
    0.01886569f, -0.03980831f, 0.11361055f, 0.01719483f, -0.07399625f, 0.01104537f, -0.01649509f, -0.16884363f, 
    -0.16723761f, 0.03318457f, 0.00566062f, -0.01723624f, 0.14111221f, 0.02478401f, -0.00234588f, -0.03992202f, 
    0.06626601f, 0.00018737f, -0.06472053f, -0.03935933f, 0.40238312f, 0.05634400f, 0.05022786f, -0.04592786f, 
    0.13353677f, -0.06540292f, -0.10446312f, -0.00646576f, 0.04345001f, 0.10330521f, 0.09202559f, 0.02706786f, 
    -0.09174910f, -0.00128153f, 0.00622478f, 0.00497246f, 0.02139455f, -0.05448275f, -0.09719018f, -0.14301968f, 
    -0.07015345f, -0.05000810f, -0.03231833f, 0.03242557f, 0.48013282f, -0.51696455f, -0.09705221f, -0.03294659f, 
    0.10460529f, -0.04090480f, -0.01648764f, 0.01067204f, -0.06360768f, 0.02786024f, 0.01687686f, -0.02556519f, 
    0.04637023f, 0.05955648f, 0.15417641f, -0.16212323f, 0.14224730f, 0.05423057f, -0.01111318f, 0.03957419f, 
    -0.02969085f, -0.03134140f, 0.05761613f, -0.12407231f, 0.34861001f, 0.01751526f, 0.11246435f, 0.02610643f, 
    -0.01389863f, 0.08060936f, 0.10218320f, 0.03391823f, -0.05725493f, 0.07596729f, 0.15344955f, 0.08260213f, 
    -0.12574653f, 0.10533705f, -0.01982361f, 0.05006990f, 0.08366397f, 0.00180100f, 0.08921380f, -0.03673025f, 
    -0.05360400f, -0.00571443f, 0.13775975f, -0.06897051f, 0.03006900f, 0.00935639f, -0.12781300f, 0.00430951f, 
    0.03041967f, -0.05254873f, 0.07388264f, -0.00908036f, 0.06809432f, 0.10734744f, -0.12047908f, -0.01530164f, 
    -0.33288908f, 0.01014230f, 0.24917465f, -0.01288137f, 0.09489866f, -0.01476057f, -0.05468878f, 0.06301488f, 
    0.07179403f, -0.10290043f, -0.04537974f, 0.05388782f, 0.05135917f, -0.22833127f, -0.08454324f, -0.07532454f, 
    -0.01145049f, 0.09415454f, -0.08612782f, 0.01441942f, 0.00426120f, -0.02259010f, 0.13259840f, 0.06090776f, 
    -0.01979780f, -0.00793471f, -0.06865934f, 0.04825605f, -0.00068670f, 0.09917439f, -0.01381420f, 0.04118411f, 
    0.02756231f, 0.00383079f, 0.02953748f, -0.01727957f, 0.14842623f, -0.10617799f, -0.10725251f, 0.07003007f, 
    -0.14296521f, -0.03132403f, -0.12930156f, 0.06545342f, 0.06261864f, 0.06978889f, -0.10740084f, 0.06704536f, 
    -0.19618779f, -0.27801293f, 0.15624675f, -0.12227922f, 0.02832655f, -0.01824799f, -0.05207423f, 0.06336394f, 
    0.01813439f, 0.01857074f, -0.02703316f, 0.09447570f, -0.34708798f, -0.05746756f, -0.19424561f, -0.27169767f, 
    0.15900593f, -0.08385263f, -0.15112205f, 0.02421881f, -0.00160037f, -0.08805788f, 0.11877995f, -0.00505934f, 
    0.20796126f, 0.06225630f, 0.04425490f, 0.05223812f, 0.03846581f, -0.00900364f, 0.17158760f, 0.02546579f, 
    0.01108211f, -0.01912280f, -0.03061356f, 0.11964148f, -0.21012768f, -0.05993835f, -0.12858528f, -0.29450145f, 
    0.02302934f, -0.06132336f, 0.01438553f, 0.02848482f, 0.06331214f, 0.06117178f, -0.00338161f, 0.07833645f, 
    0.22350670f, -0.04574082f, 0.14729635f, -0.12554629f, -0.07132287f, 0.01828113f, 0.07739711f, -0.08960512f, 
    -0.05381929f, -0.06045296f, -0.01798534f, -0.12868986f, 0.07055963f, 0.09921961f, -0.15477653f, -0.08671056f, 
    0.04040263f, -0.04921962f, 0.05311973f, 0.03576821f, 0.02072175f, -0.09039228f, 0.12818716f, -0.00748997f, 
    0.25316101f, 0.06369717f, -0.03971374f, 0.09394800f, 0.06356183f, -0.01075827f, 0.00488600f, 0.08857715f, 
    -0.10504573f, -0.05127379f, -0.09382309f, 0.14593112f, 0.19019829f, -0.00278363f, -0.07092013f, -0.06649881f, 
    -0.13996667f, -0.08985084f, 0.03411092f, -0.07792537f, -0.10865673f, -0.03869065f, -0.18520181f, -0.05169242f, 
    0.15002933f, -0.08185435f, -0.00261093f, 0.00135816f, -0.08583729f, 0.01063228f, 0.00060221f, -0.04765709f, 
    0.11400289f, 0.10234267f, -0.01880016f, 0.05645387f, 0.23552872f, 0.13435233f, -0.13147691f, 0.10097938f, 
    -0.23298401f, -0.16798902f, 0.01907867f, 0.00130567f, -0.04916657f, -0.18155551f, 0.00274878f, -0.22131443f, 
    0.25381449f, 0.08345806f, -0.07819988f, 0.07973374f, -0.15231296f, -0.09255706f, 0.00861548f, -0.10897636f, 
    0.04896227f, -0.02707161f, -0.11187945f, -0.21959147f, -0.12712029f, -0.17349441f, -0.19331236f, 0.20566814f, 
    -0.02902357f, -0.04275422f, -0.09000967f, 0.10901244f, -0.08841051f, -0.11987621f, -0.00832019f, 0.05899025f, 
    0.18894795f, -0.15640603f, -0.01074398f, 0.00928554f, 0.15468431f, -0.10439620f, -0.04295080f, 0.05759855f, 
    -0.06571253f, 0.01943228f, -0.06719074f, 0.06068343f, -0.24224669f, 0.10528113f, -0.14633873f, -0.02997221f, 
    -0.08054824f, 0.03478239f, -0.00652422f, 0.00638191f, 0.04134263f, 0.09911908f, -0.01098639f, -0.00898620f, 
    0.09363722f, 0.12480441f, -0.00402931f, 0.02316958f, 0.06041941f, -0.18228398f, 0.11025910f, -0.05269874f, 
    0.01449266f, 0.07848639f, 0.04566826f, 0.00783121f, 0.17150883f, -0.05008560f, -0.07310124f, -0.02933976f, 
    0.00877526f, -0.00133965f, 0.00535673f, 0.13674709f, -0.07416459f, 0.05780744f, 0.04357221f, 0.06366994f, 
    0.00205611f, 0.08403822f, 0.10742416f, -0.01143620f, 0.07787396f, -0.01595296f, 0.01593287f, -0.06237733f, 
    0.06891251f, 0.09801668f, 0.01967791f, 0.02394107f, -0.36414394f, -0.08727510f, 0.07772099f, 0.16365163f, 
    0.07669248f, 0.04886758f, 0.00697022f, -0.11548556f, -0.00256791f, -0.01003894f, -0.08866423f, 0.00842960f, 
    -0.06543604f, -0.32534730f, 0.04879140f, -0.10822620f, -0.09086090f, 0.02389305f, 0.00016365f, 0.05930526f, 
    -0.00421357f, 0.03121988f, 0.05933844f, 0.11873884f, 0.16744395f, 0.00808220f, -0.13262956f, 0.01742555f, 
    -0.17661449f, -0.02716623f, 0.04684559f, -0.03841943f, 0.08337182f, 0.04582145f, 0.07108046f, -0.05558936f, 
    0.23777346f, 0.09545777f, -0.02998693f, 0.00965394f, -0.00281020f, -0.03480984f, 0.04111689f, -0.02435178f, 
    0.02288771f, 0.08688435f, 0.00378148f, 0.16219757f, -0.43978918f, -0.29354459f, -0.13076559f, -0.08043111f, 
    0.01402626f, 0.02596458f, 0.02945493f, 0.09321281f, 0.02092789f, 0.03262148f, 0.05554328f, 0.13670586f, 
    -0.25845468f, -0.30525616f, -0.01396070f, 0.05854193f, 0.08880097f, 0.08079552f, 0.09749684f, -0.08959900f, 
    0.08543909f, 0.06292731f, 0.10697239f, 0.09604057f, 0.07700398f, 0.09636622f, -0.02472350f, 0.17854612f, 
    0.09578060f, 0.12844169f, 0.05687504f, 0.09994669f, -0.06986260f, 0.02936406f, 0.15284920f, 0.02379460f, 
    0.04588506f, -0.09711998f, -0.06644917f, -0.03345065f, 0.00588419f, 0.01502537f, -0.02247207f, 0.02393074f, 
    -0.03289607f, -0.01140442f, -0.15987583f, -0.17288497f, -0.47601995f, -0.45813832f, -0.00822812f, 0.01227714f, 
    0.07861430f, 0.03408605f, 0.03520514f, -0.00056097f, 0.06968479f, -0.06329612f, 0.01917302f, 0.12837520f, 
    -0.19305615f, -0.15592052f, -0.06654584f, -0.06741288f, -0.04072012f, -0.02009173f, -0.09743141f, 0.10682249f, 
    0.04524254f, 0.04021241f, 0.05890275f, 0.09215008f, 0.09120788f, 0.05226392f, -0.04806828f, -0.06126385f, 
    -0.01914860f, -0.00148131f, -0.00599692f, -0.02618306f, 0.01576858f, 0.07969411f, 0.03702513f, 0.04091391f, 
    0.13925903f, 0.02770556f, 0.11587560f, 0.05830680f, 0.06976457f, -0.07047434f, 0.05368173f, 0.06005431f, 
    0.02048437f, -0.11867670f, -0.12481493f, -0.05998212f, -0.08821327f, 0.00540058f, -0.07566147f, 0.10237829f, 
    0.05990233f, -0.03181676f, 0.02561098f, -0.11134031f, -0.00335828f, 0.01781429f, -0.01692377f, 0.02663083f, 
    -0.19592734f, 0.09558453f, -0.07112380f, -0.07826627f, 0.04333207f, -0.00698790f, -0.01101983f, -0.04523344f, 
    -0.00274687f, 0.08359520f, -0.06134600f, 0.10488378f, -0.05360333f, 0.05826824f, -0.09700442f, -0.12143227f, 
    0.07477872f, -0.09897352f, -0.08798618f, 0.01448185f, -0.02189193f, -0.00320128f, 0.00702723f, 0.10282429f, 
    0.19362514f, 0.07976822f, -0.07866344f, -0.13093108f, 0.05520840f, 0.00816005f, 0.17688492f, -0.06121725f, 
    -0.00939783f, -0.02023803f, 0.08520801f, -0.08579553f, 0.06744241f, -0.07563621f, 0.01349057f, 0.01311191f, 
    -0.07518487f, -0.00281511f, 0.09501441f, -0.08582235f, 0.02853844f, 0.09881683f, 0.01084927f, 0.12444416f, 
    -0.14772907f, -0.14766200f, -0.13721460f, -0.06418935f, 0.11271417f, 0.06193671f, -0.10266301f, -0.07372909f, 
    -0.00089359f, -0.07668669f, 0.04783889f, 0.02716346f, -0.24733233f, -0.15665378f, -0.17827819f, -0.01510108f, 
    0.05489106f, 0.07779493f, -0.09063706f, -0.11849713f, 0.04728889f, -0.07504553f, -0.04573086f, -0.05494332f, 
    -0.25186455f, 0.03770095f, -0.06165931f, 0.02517044f, 0.03095947f, -0.07689359f, -0.00819813f, -0.08593092f, 
    -0.07473967f, 0.02619671f, 0.20795852f, -0.11596790f, -0.55137020f, -0.23249464f, 0.07580784f, 0.05313716f, 
    0.13671243f, -0.06178863f, -0.05051954f, -0.07239591f, -0.02893490f, 0.00580963f, -0.07910536f, -0.03718151f, 
    -0.09879325f, -0.04952350f, -0.04957148f, -0.07570995f, -0.02681039f, 0.04272622f, 0.05048936f, 0.00512908f, 
    0.08055426f, 0.00345196f, -0.10491055f, -0.04955365f, 0.09352294f, 0.11435239f, 0.05270654f, -0.09273747f, 
    -0.06039654f, -0.03946346f, 0.00413131f, -0.09813032f, -0.02650539f, -0.17935722f, -0.02417444f, -0.07264453f, 
    0.06251925f, 0.21867017f, 0.09277882f, -0.11521632f, 0.06782837f, 0.12755184f, 0.01387612f, 0.04530793f, 
    -0.17541520f, 0.02928102f, 0.13514613f, 0.08920963f, -0.46977311f, -0.28350338f, 0.00824256f, 0.04796302f, 
    0.14092289f, 0.06324995f, -0.01884044f, 0.01906121f, 0.11818790f, 0.05463292f, 0.01961838f, 0.04380437f, 
    0.06292099f, 0.06804055f, 0.12315828f, -0.08538828f, 0.05755324f, 0.04475654f, 0.00134133f, 0.06061881f, 
    0.01416074f, 0.11001638f, 0.07847401f, 0.02412942f, -0.17828096f, -0.01892080f, 0.15608618f, 0.14133906f, 
    0.09086022f, -0.12891702f, 0.12614253f, -0.04477375f, -0.00520934f, 0.08118460f, -0.06534275f, 0.12253322f, 
    0.14538017f, -0.03922655f, 0.04685231f, 0.07015938f, 0.08318338f, 0.13435417f, 0.09624520f, -0.04556307f, 
    0.10839795f, 0.06529741f, 0.05522696f, -0.00395703f, -0.37044320f, -0.21715832f, 0.10730034f, -0.03807439f, 
    0.10598726f, 0.02508693f, 0.07364612f, -0.05819968f, 0.00986142f, -0.00814052f, 0.02312966f, 0.10430445f, 
    -0.28172871f, -0.05379957f, 0.05086511f, -0.04825478f, 0.13255768f, -0.04871478f, -0.03208587f, 0.02323830f, 
    0.00669390f, 0.06467989f, -0.19979103f, 0.02143046f, -0.02540223f, 0.12946455f, -0.05644257f, -0.03805572f, 
    0.05907436f, -0.03955216f, 0.12395682f, -0.05822494f, 0.01832834f, -0.00151640f, 0.09771365f, -0.01391027f, 
    -0.05139385f, -0.14461616f, -0.07141673f, -0.24020559f, 0.09667808f, 0.00684920f, 0.04802682f, 0.01313207f, 
    0.05311576f, 0.01398661f, 0.06025944f, 0.15492748f, -0.16190234f, -0.04086617f, 0.09028082f, 0.06454795f, 
    -0.12540992f, 0.03600775f, -0.19285327f, -0.06707239f, -0.11126812f, -0.04864952f, 0.00693842f, -0.00632198f, 
    -0.18816112f, -0.08480278f, -0.16420203f, -0.18892743f, 0.04010998f, 0.02506531f, -0.14252709f, 0.11377614f, 
    0.07219206f, 0.03335410f, -0.03550066f, -0.05861530f, -0.31735781f, -0.27125472f, -0.19687918f, -0.41735813f, 
    0.00604605f, -0.06703083f, -0.04614445f, -0.02246796f, 0.02046693f, -0.00564677f, 0.09394312f, -0.00592636f, 
    -0.22769140f, -0.04345171f, -0.04615854f, -0.14010201f, 0.04469815f, 0.08988437f, -0.11480338f, -0.02163683f, 
    0.12965566f, 0.01838388f, -0.07194333f, -0.08190108f, 0.06361933f, 0.09136606f, 0.05507381f, -0.02237490f, 
    -0.17574655f, 0.03307316f, 0.05415439f, 0.05164561f, 0.04045456f, -0.01953199f, -0.04586559f, -0.01849298f, 
    -0.28118712f, -0.09302489f, -0.09211775f, 0.02665753f, 0.00591417f, 0.11507187f, 0.08080417f, 0.00566257f, 
    0.08833703f, 0.10886950f, 0.07310361f, 0.05744483f, 0.09511345f, 0.09348318f, -0.00655892f, 0.04712451f, 
    -0.05270476f, 0.07207101f, -0.02177325f, 0.01282117f, -0.01852215f, 0.12343503f, 0.02976016f, 0.06127754f, 
    0.10072076f, 0.05797640f, 0.14519376f, 0.00360827f, 0.05735714f, -0.14641158f, 0.12840965f, 0.01399539f, 
    -0.01766704f, 0.12224379f, 0.09684592f, 0.14541559f, -0.47792712f, -0.18243393f, -0.05111280f, 0.14195456f, 
    0.11933947f, -0.02715219f, 0.04171489f, -0.09790523f, 0.00621046f, -0.21447173f, -0.03786756f, 0.02977511f, 
    -0.12824056f, -0.19119896f, -0.00437931f, -0.02232379f, -0.02440861f, -0.00747452f, -0.13906811f, 0.08417843f, 
    -0.02447732f, 0.07488007f, 0.05956546f, 0.07620852f, -0.26833990f, -0.07360128f, -0.02988209f, -0.06146853f, 
    0.05105124f, 0.02878500f, -0.09150819f, -0.00717282f, 0.00289676f, 0.01989627f, 0.02203228f, -0.09852298f, 
    0.03140670f, 0.07881314f, -0.06554555f, 0.02785178f, -0.02518459f, -0.02597644f, 0.02710648f, 0.03051171f, 
    0.02354544f, 0.01118962f, 0.01961664f, 0.05465767f, -0.24683847f, 0.15808442f, -0.04360481f, -0.06910103f, 
    0.11681198f, 0.04982862f, 0.02700196f, 0.09462810f, 0.11103732f, 0.06781325f, -0.09361129f, -0.01816696f, 
    -0.18928872f, 0.04272683f, -0.03736526f, 0.12155332f, -0.01080033f, -0.06362519f, 0.02612008f, -0.01648360f, 
    0.01823233f, 0.00690468f, -0.02546374f, -0.06738400f, -0.22016020f, 0.08929235f, -0.13578126f, -0.10881208f, 
    0.00744230f, 0.11491593f, 0.03177373f, 0.15497486f, -0.02548240f, -0.03428802f, -0.14804509f, -0.02395881f, 
    0.20906276f, -0.21678616f, -0.22536799f, -0.05957089f, 0.02937231f, -0.01983909f, 0.07207697f, 0.00846912f, 
    0.00988843f, 0.05301467f, -0.00518950f, 0.06124271f, -0.23611006f, -0.20237051f, -0.08404841f, -0.16709401f, 
    -0.06526243f, 0.09169602f, 0.02007128f, 0.07715642f, -0.02302663f, -0.07010613f, -0.05991072f, 0.11103901f, 
    0.28654239f, 0.07159138f, 0.12697752f, -0.10019462f, 0.00090827f, -0.05715616f, -0.06655273f, 0.02316925f, 
    0.02497112f, -0.08444282f, 0.00147227f, 0.08572225f, 0.28729916f, -0.13887160f, -0.18920994f, -0.02838765f, 
    0.07052002f, -0.06320667f, -0.04878431f, -0.06540522f, -0.02383517f, -0.03726049f, 0.00789270f, -0.05151573f, 
    -0.19411348f, 0.16708416f, 0.04989794f, -0.00188106f, 0.02289676f, 0.01070497f, -0.05559020f, -0.01979586f, 
    0.00406703f, -0.01118725f, 0.01162653f, -0.02621829f, -0.12230962f, -0.12148585f, -0.00917568f, 0.26118696f, 
    -0.09395447f, 0.05272695f, 0.13405475f, 0.05647575f, 0.07514307f, -0.05255751f, -0.03872191f, 0.05909614f, 
    -0.12318984f, 0.04001483f, -0.19628727f, -0.02830886f, 0.03656416f, 0.04091334f, -0.01588766f, 0.02045691f, 
    -0.05751936f, -0.03026505f, -0.09187825f, -0.19048624f, -0.16674758f, -0.14677308f, 0.05668639f, 0.01473531f, 
    -0.06616861f, 0.00388245f, 0.04275025f, 0.05989630f, -0.02074393f, 0.10180853f, 0.06555953f, -0.05175319f, 
    -0.05814943f, 0.12227083f, 0.12107253f, 0.03741628f, -0.04859002f, -0.00984697f, -0.06602325f, -0.07705236f, 
    0.02458141f, 0.01877864f, 0.06851875f, 0.04297628f, -0.22096458f, -0.07176393f, -0.01875483f, -0.07458955f, 
    -0.02519995f, 0.11968508f, -0.01207171f, -0.05908088f, 0.04646082f, -0.01043339f, 0.01913401f, 0.11722087f, 
    -0.01717665f, -0.18369889f, 0.03773752f, 0.05112951f, -0.04979118f, -0.00113776f, 0.04439457f, 0.00497629f, 
    -0.07034228f, -0.01642074f, 0.09335795f, 0.01288123f, -0.26563445f, 0.14354335f, 0.01460372f, -0.13191929f, 
    0.13129379f, -0.01934228f, -0.00386254f, -0.08768436f, -0.16850045f, -0.04755786f, -0.00921731f, -0.08930624f, 
    -0.02305711f, -0.04751426f, 0.00820884f, -0.06509911f, -0.05184952f, -0.04258649f, 0.04986620f, -0.02410813f, 
    -0.09504851f, -0.01950465f, -0.00329474f, -0.10379211f, -0.40971169f, 0.07894257f, -0.04365947f, 0.05118575f, 
    0.00299072f, 0.03041041f, -0.06014678f, 0.10535880f, 0.01403378f, -0.01429075f, 0.03929950f, -0.04016593f, 
    0.22272512f, -0.01564484f, -0.04339126f, -0.05264261f, -0.09316153f, -0.09620823f, -0.09589257f, -0.10249888f, 
    -0.09399980f, -0.10028551f, -0.08632621f, -0.13440213f, -0.15807493f, 0.02322741f, -0.04167448f, -0.00625421f, 
    -0.00059632f, -0.00442590f, 0.03661739f, 0.03451280f, 0.02286208f, -0.08497539f, -0.03824270f, -0.08020907f, 
    0.29682857f, 0.09811119f, -0.02699014f, 0.02903973f, 0.15300080f, 0.02215386f, -0.11917928f, 0.05715412f, 
    0.06060051f, -0.03643732f, 0.09880942f, 0.05420590f, 0.32124308f, 0.19681551f, 0.03850158f, 0.00543697f, 
    0.02614793f, 0.01314406f, 0.00448324f, -0.08190039f, 0.17990234f, 0.09738277f, 0.10278340f, 0.04776901f, 
    -0.21515322f, -0.21599600f, 0.14419493f, 0.02529910f, 0.13235016f, 0.01206498f, 0.05094701f, 0.06351870f, 
    -0.00795504f, -0.02126608f, -0.07606786f, 0.01592000f, 0.25983664f, 0.01370166f, 0.01670893f, 0.03280445f, 
    -0.13686787f, -0.07501385f, 0.03246671f, -0.10787392f, -0.09934726f, 0.01193600f, 0.08107018f, -0.10440723f, 
    -0.13821565f, 0.03766736f, 0.00623328f, 0.00087335f, 0.05985191f, -0.04932063f, -0.08061258f, 0.05265992f, 
    0.06748812f, -0.16961293f, -0.06117718f, -0.06394209f, -0.02708305f, 0.12108196f, -0.07157595f, -0.20317438f, 
    0.02194791f, 0.02441355f, -0.04576259f, 0.02227508f, -0.02224489f, -0.08260090f, -0.10214210f, -0.06912654f, 
    0.12161399f, -0.17104897f, -0.01733330f, -0.00790406f, 0.10180048f, -0.01160317f, 0.01038111f, 0.01972920f, 
    -0.05010853f, 0.01109947f, -0.03928929f, -0.00123484f, -0.11858068f, 0.14336385f, 0.02382398f, -0.02669740f, 
    0.14357308f, -0.13495955f, 0.02909965f, 0.03276493f, 0.00873974f, -0.03464331f, -0.04988344f, -0.11643777f, 
    -0.25925297f, 0.28003660f, -0.19322872f, -0.02835319f, 0.05920080f, -0.07523624f, 0.12709494f, 0.13950002f, 
    0.04962103f, 0.03470394f, 0.06515729f, 0.09116806f, 0.46552387f, -0.05398017f, -0.02649476f, -0.03761579f, 
    0.01509724f, -0.03201410f, 0.01791959f, -0.01425083f, 0.13529666f, 0.09851457f, 0.00952305f, 0.09828757f, 
    -0.28668004f, -0.00213109f, -0.24172439f, -0.02785047f, 0.08690090f, 0.06846122f, 0.07323187f, -0.06329783f, 
    -0.05659043f, -0.03443431f, -0.11954803f, 0.02348700f, -0.04954062f, -0.03886838f, -0.06037408f, 0.28558049f, 
    -0.14942464f, -0.03832692f, 0.02199880f, 0.05672475f, -0.04478784f, -0.04606311f, -0.01477280f, -0.10182712f, 
    -0.04206088f, -0.01046742f, -0.00296499f, -0.18423060f, 0.00554366f, 0.02109597f, -0.04199025f, -0.00260572f, 
    -0.04997345f, 0.02372992f, 0.08031417f, 0.06701777f, 0.23125292f, -0.00796394f, -0.01506775f, 0.06830639f, 
    -0.06709383f, 0.05498221f, -0.02030205f, 0.01620129f, 0.05121164f, 0.05670806f, 0.02898720f, -0.03039938f, 
    0.01533103f, 0.05568499f, -0.02574459f, 0.18104078f, -0.11499081f, 0.07695610f, -0.02472823f, 0.12666325f, 
    0.04099810f, -0.07020178f, 0.05077484f, -0.01345067f, 0.26603892f, 0.04854191f, -0.14724942f, -0.04681690f, 
    -0.03609702f, 0.05339807f, -0.00543009f, 0.03961089f, -0.09339132f, -0.04789883f, 0.09458620f, 0.06041722f, 
    -0.05593862f, 0.08901402f, -0.14003149f, -0.06395359f, -0.01080762f, -0.02412178f, -0.02274530f, -0.06636843f, 
    0.03087534f, -0.00836934f, 0.08089985f, -0.08215406f, -0.16189036f, 0.10703795f, 0.11792786f, -0.00188542f, 
    -0.09358151f, -0.07527778f, -0.03254861f, 0.02239871f, 0.05869032f, 0.02469451f, 0.11977179f, -0.12526807f, 
    -0.14900395f, -0.01108897f, -0.12150037f, -0.11328243f, -0.03177598f, 0.00717125f, 0.08594873f, 0.00994540f, 
    0.03389195f, 0.13255283f, -0.04905488f, -0.00670733f, -0.08469967f, -0.19749059f, -0.17292802f, -0.04986071f, 
    0.07383668f, 0.02579673f, 0.02156642f, 0.04962953f, 0.04398223f, 0.04043393f, -0.00280752f, 0.02457669f, 
    0.05984055f, -0.13093990f, -0.15993093f, 0.06375509f, 0.04700864f, 0.13929419f, -0.06471177f, -0.13492049f, 
    0.07186731f, 0.02040405f, -0.04633163f, 0.09154682f, 0.34000885f, 0.06216959f, -0.04413554f, -0.06918742f, 
    0.04316463f, -0.05509466f, -0.08000235f, 0.04613946f, 0.15077870f, 0.00797363f, 0.01949526f, 0.02768815f, 
    -0.13821334f, -0.29373726f, -0.08069815f, 0.12201697f, 0.11866546f, -0.04844338f, -0.04671980f, 0.04232192f, 
    -0.03866704f, 0.03079004f, -0.03626040f, 0.02542843f, 0.04887335f, 0.15607384f, -0.05132636f, -0.06940338f, 
    -0.12245271f, -0.08386128f, 0.02671824f, -0.11569643f, -0.02955674f, 0.04645837f, 0.06403141f, -0.01626138f, 
    -0.04777648f, 0.09446383f, -0.02119203f, 0.02183790f, -0.17901906f, -0.04807002f, 0.09625564f, -0.01480520f, 
    -0.00085975f, 0.02956559f, -0.14984329f, -0.05188885f, -0.15249689f, 0.15018208f, 0.01280185f, 0.07806917f, 
    0.14760861f, 0.03928792f, -0.04131645f, 0.10139333f, 0.03311094f, 0.08039263f, -0.02867706f, 0.01489897f, 
    0.29542649f, 0.11721135f, -0.27651003f, -0.02886397f, 0.05729379f, -0.03554884f, -0.02525262f, 0.07344550f, 
    0.11978076f, -0.02621532f, -0.06986502f, -0.02832684f, -0.16590792f, -0.31827620f, 0.17415583f, -0.05386674f, 
    0.16576728f, -0.04124919f, -0.02325737f, -0.05984497f, 0.11577819f, -0.02702973f, 0.06063243f, 0.08204252f, 
    0.11871108f, 0.12787896f, -0.22130235f, 0.02108536f, 0.13702899f, -0.19728512f, -0.02002876f, 0.08576757f, 
    0.03338162f, 0.06020624f, 0.00822018f, 0.09016798f, 0.08707079f, 0.28794503f, -0.03294981f, 0.08198123f, 
    0.08998712f, -0.10612394f, -0.09616840f, 0.01802352f, 0.08051565f, 0.05906218f, 0.04296365f, 0.04902807f, 
    0.31438828f, 0.04069404f, -0.04257876f, 0.16853072f, -0.07463459f, 0.01007046f, -0.03944699f, -0.02274373f, 
    0.08366974f, -0.00541766f, -0.01243668f, 0.06755599f, -0.17185634f, 0.04628332f, -0.08040586f, 0.16507657f, 
    -0.09262037f, -0.03364245f, -0.05472766f, 0.00480569f, -0.07743369f, -0.04436655f, 0.06709276f, -0.07308281f, 
    0.18864226f, -0.28855732f, -0.00134047f, 0.18448085f, 0.10057734f, -0.09436179f, -0.02792899f, 0.01601495f, 
    -0.11742194f, 0.03658371f, 0.02031255f, -0.06581870f, 0.07000457f, -0.20656277f, -0.09630583f, -0.12250043f, 
    -0.22687887f, -0.02951805f, -0.04575986f, -0.06047568f, -0.18909119f, 0.10668714f, -0.03745660f, 0.05552769f, 
    -0.47674704f, -0.17507724f, 0.14725311f, -0.12570238f, -0.03568004f, 0.06663844f, -0.07469726f, 0.14627180f, 
    0.00696588f, -0.00276368f, 0.07558773f, 0.03206636f, 0.23448749f, -0.18752258f, -0.34283203f, -0.03832005f, 
    0.04378524f, -0.04042771f, 0.12462828f, -0.11193925f, 0.03836952f, -0.08089152f, -0.13327757f, -0.05170024f, 
    0.12784927f, -0.36403888f, 0.07451294f, -0.11852956f, 0.01610627f, -0.02779264f, 0.10745539f, 0.00372145f, 
    -0.00820110f, 0.01226400f, -0.09739647f, -0.04737596f, -0.52376866f, 0.04309867f, -0.08928813f, -0.03805136f, 
    0.02450156f, 0.02876605f, -0.04267933f, 0.09279624f, -0.00866742f, -0.05879604f, 0.01596012f, -0.14754707f, 
    0.15249734f, 0.21372598f, -0.16223533f, -0.01703217f, 0.12574340f, 0.03865993f, -0.00928616f, 0.07856605f, 
    0.00293056f, -0.05613919f, 0.00327873f, 0.05597086f, -0.07797327f, 0.04656683f, -0.11307254f, 0.15623644f, 
    0.01472154f, -0.10533323f, 0.08266705f, 0.07219292f, -0.09874415f, 0.00815367f, 0.05565369f, -0.10552293f, 
    0.12115454f, 0.02899368f, 0.07806450f, -0.18522209f, 0.02766191f, 0.00509225f, -0.04711619f, 0.04772758f, 
    -0.05011762f, -0.05226539f, -0.04020378f, -0.04421049f, 0.16002245f, -0.05706177f, 0.04832787f, -0.21894310f, 
    0.02220179f, -0.03048972f, -0.17429474f, 0.00347420f, 0.02336807f, 0.09830695f, 0.06279169f, 0.03660072f, 
    -0.04687216f, -0.08267344f, 0.08068070f, 0.02550049f, 0.17773877f, -0.05642046f, 0.07221068f, -0.14773822f, 
    -0.06414263f, 0.00484931f, -0.10882533f, 0.04869985f, -0.17143938f, 0.11460553f, 0.07637969f, -0.15538871f, 
    -0.01749491f, 0.04620801f, 0.01390941f, -0.10061673f, 0.09257381f, 0.00257314f, 0.03012936f, -0.08949674f, 
    0.15978847f, -0.07548547f, -0.04507420f, 0.05236595f, -0.09800360f, -0.02262845f, -0.07146583f, -0.04649645f, 
    -0.04498643f, -0.06084847f, -0.15726422f, -0.12735756f, 0.09221106f, 0.04436756f, 0.07479737f, 0.22941086f, 
    -0.14770153f, 0.00479471f, -0.08802562f, -0.04862867f, -0.03217160f, -0.02621377f, 0.05599836f, 0.02003038f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03378979f, 0.01839256f, -0.04969556f, 0.03014356f, 0.03623396f, -0.02503512f, -0.03156098f, -0.08359645f, 
    -0.03574263f, 0.01941656f, 0.09407974f, 0.02946387f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
