#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35071921f, 0.01644309f, 0.95764792f, 0.24387190f, 0.55462480f, 0.34511730f, -0.44243407f, -0.21126507f, 
    -0.22734603f, -1.30874109f, -0.31435603f, 0.40474087f, 1.04864538f, 0.60009754f, 0.20523684f, 0.19741419f, 
    0.10537422f, 0.07965092f, 0.78736681f, 0.60132861f, -1.02494395f, -0.07403629f, 0.66002482f, -0.34373191f, 
    0.55987227f, 0.10189644f, 0.19911498f, -0.06909803f, 0.93839616f, -0.00386442f, 0.29382446f, -0.62321842f, 
    -1.09717941f, 0.19059119f, -0.06654140f, -0.12335054f, 0.00192170f, -0.67233235f, 0.62831664f, -0.86269325f, 
    -0.83967674f, 0.26918793f, 0.22822738f, 0.28804988f, 0.14373471f, -0.54477775f, -0.71824545f, -0.51930070f, 
    0.43227160f, 0.18880245f, -0.41557547f, 0.47626653f, 0.51185018f, -0.45816046f, 0.49644482f, 0.99100411f, 
    0.18559936f, 0.20107438f, 1.06234312f, 0.43451405f, 0.06314418f, -0.11208747f, -0.21778327f, 0.67806524f, 
    0.80776191f, 0.87744153f, -0.23769465f, -0.61510694f, 0.49822566f, -0.02034438f, 0.15823162f, 0.18775113f, 
    0.19181971f, 0.45911345f, 0.36416382f, 0.43455935f, 0.53162062f, 0.59514350f, 0.14172865f, -0.54059088f, 
    -0.40844607f, -0.58063096f, -0.82759833f, -0.78021795f, 0.61028689f, -0.62843585f, 0.12598227f, -0.35596669f, 
    -0.18633834f, 0.00005252f, 0.41858527f, 0.23899184f, 0.02299047f, -1.27406287f, 0.04260386f, -1.06809473f, 
    0.00382246f, 0.38494423f, -0.16886352f, 0.31004277f, -0.16514421f, 0.51245606f, 0.88124287f, 0.28665307f, 
    0.81265455f, 0.51214331f, -0.35167783f, 0.35924831f, 1.22401357f, 0.65722167f, 0.53464276f, 0.00587231f, 
    0.35759816f, -0.02222179f, -0.14876324f, 0.43793795f, 0.13912462f, -0.21914719f, -0.45794290f, -0.67416590f, 
    1.12495339f, 0.85517949f, 0.59827143f, -0.35263139f, -0.50278777f, 0.04391979f, 0.85167170f, 0.56521809f, 
    0.94692463f, -0.03986664f, -0.72836447f, -0.30688009f, 0.61085123f, -0.18433636f, -0.09836187f, 0.30314752f, 
    0.41040891f, 0.13936464f, 0.57127702f, -0.98714858f, 0.29129577f, -0.78168887f, -0.51820910f, -0.40591669f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21985020f, -0.06597827f, 0.05248241f, 0.28071553f, -0.10379817f, 0.11650729f, 0.01777989f, 0.34419990f, 
    0.30029353f, -0.12574111f, 0.51400429f, -0.34325829f, 0.14243627f, 0.30531427f, -0.26845813f, -0.48260614f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01911374f, -0.04928244f, -0.19014448f, 0.00381064f, 0.04521089f, -0.11470556f, -0.07875096f, 0.11767290f, 
    -0.12454268f, -0.57427937f, 0.17287382f, 0.01302211f, 0.10612199f, -0.03690700f, -0.02493864f, 0.07653766f, 
    -0.01754119f, -0.00636182f, 0.25892469f, -0.55516249f, 0.07925095f, -0.04278651f, 0.01717163f, -0.18992974f, 
    -0.21464407f, 0.04424099f, -0.00879916f, -0.02086363f, -0.28352335f, -0.11616238f, -0.17177203f, -0.03085182f, 
    0.04769280f, -0.08286180f, 0.03039648f, 0.25273171f, -0.47180063f, 0.04886046f, 0.01749917f, -0.02885369f, 
    -0.15381621f, 0.10660345f, -0.00697575f, -0.24022335f, 0.18967561f, 0.23315310f, 0.19365352f, -0.14509746f, 
    -0.03350967f, -0.05588983f, 0.26215303f, -0.07506543f, 0.21360819f, -0.11308682f, -0.01505361f, 0.22028464f, 
    -0.07102840f, -0.07443707f, -0.07251082f, 0.04519138f, 0.16538365f, 0.19984072f, -0.06638746f, 0.11733265f, 
    0.04426022f, 0.03874776f, 0.14869073f, -0.27194849f, 0.23627354f, 0.05296105f, -0.05128683f, 0.15849678f, 
    0.32351157f, 0.24132290f, -0.02600251f, 0.14569186f, 0.06956653f, 0.07423207f, -0.07857923f, 0.07862314f, 
    -0.12267280f, 0.00486168f, 0.37395525f, -0.42074791f, -0.03552091f, 0.28840274f, 0.01374016f, 0.03100848f, 
    -0.05952840f, -0.00301620f, 0.35582972f, -0.17390382f, -0.31535035f, -0.00085872f, -0.01445117f, 0.05705479f, 
    -0.04287412f, -0.00825435f, -0.10914312f, -0.17279123f, 0.19969606f, 0.23109883f, -0.12900998f, 0.12313230f, 
    -0.13501023f, -0.01516706f, 0.00654172f, -0.15700895f, -0.07397699f, -0.17614059f, 0.18500857f, 0.16002238f, 
    -0.02739455f, -0.03538034f, 0.07654908f, -0.17911546f, 0.28544816f, 0.03433879f, -0.06817201f, 0.03434174f, 
    -0.17979833f, 0.14239088f, -0.20103757f, -0.13679494f, 0.09676062f, -0.04526480f, -0.05733491f, -0.11536576f, 
    0.46934059f, 0.12051835f, 0.09248075f, 0.06498145f, 0.15754621f, -0.10872358f, -0.13642840f, 0.12135343f, 
    0.01620594f, -0.15215546f, 0.33546954f, 0.08674664f, 0.09916887f, -0.12762105f, -0.15319347f, -0.13929211f, 
    0.11683761f, -0.06999839f, -0.26615503f, 0.20107846f, 0.03117306f, -0.04358290f, -0.00956982f, -0.04406225f, 
    0.05933278f, 0.30063015f, -0.37772334f, -0.33452389f, 0.06706537f, -0.14967106f, 0.10947878f, 0.12935841f, 
    0.14034644f, -0.15716980f, -0.24567233f, -0.33267966f, -0.24978906f, -0.14518462f, 0.10326365f, -0.11081788f, 
    -0.00226521f, -0.12980109f, -0.11776029f, 0.40026125f, -0.14620139f, 0.07540946f, -0.00561814f, -0.02914881f, 
    -0.03492655f, -0.08825738f, 0.17674109f, 0.11959804f, -0.07736139f, -0.13072783f, -0.07532231f, 0.08784083f, 
    -0.21758020f, 0.00871087f, -0.05526946f, 0.03677152f, -0.09730741f, -0.03508317f, 0.10526799f, -0.24413247f, 
    -0.03492711f, 0.07404398f, -0.04821479f, -0.08839601f, 0.01933372f, -0.01357947f, -0.20309417f, 0.37112057f, 
    0.08521456f, 0.15691161f, 0.13086481f, 0.10893284f, -0.00277592f, 0.04209170f, 0.07192961f, -0.04893841f, 
    0.16480368f, 0.53540087f, 0.01710092f, 0.11704082f, -0.06489338f, 0.21857674f, 0.03585739f, 0.09267065f, 
    0.17549554f, 0.01921910f, 0.26874819f, -0.03514324f, 0.03438222f, 0.13018122f, 0.05587890f, 0.05584821f, 
    0.07183006f, -0.29403538f, -0.18955092f, -0.13644591f, -0.00749168f, 0.00577127f, 0.07595605f, -0.01516027f, 
    -0.05815742f, 0.04930297f, 0.23818344f, 0.15096253f, -0.15174501f, 0.09380045f, 0.06653038f, 0.09076002f, 
    -0.00613702f, -0.02773772f, -0.20405541f, -0.16269563f, -0.26092032f, -0.03449749f, 0.01240470f, -0.11006347f, 
    0.07326718f, 0.01824909f, -0.27464375f, 0.01952383f, -0.35435700f, 0.16440745f, 0.21538408f, -0.22770226f, 
    0.08442827f, 0.07445074f, 0.09400434f, -0.13568884f, 0.07173657f, 0.05940358f, -0.27724674f, -0.44544193f, 
    0.01004287f, -0.07459373f, -0.02422528f, -0.03576899f, -0.10101566f, 0.06852774f, -0.30901250f, 0.19628586f, 
    0.43631116f, 0.11141802f, 0.16279079f, -0.11183266f, -0.11252727f, 0.14326130f, 0.08105795f, -0.18576051f, 
    0.04951816f, 0.03749421f, -0.14805914f, 0.04915306f, 0.09363359f, 0.15090689f, -0.15600049f, -0.07485879f, 
    -0.02806463f, 0.04595539f, -0.01587961f, -0.02013945f, 0.10357832f, 0.02881773f, 0.03141439f, -0.02067871f, 
    -0.06708316f, 0.17160986f, -0.06015303f, 0.06705970f, -0.08010351f, -0.28962246f, -0.03106289f, 0.05636631f, 
    0.02377825f, 0.12039430f, -0.16295817f, -0.09087411f, -0.12341560f, -0.05489704f, 0.10820489f, 0.02777177f, 
    -0.01925881f, 0.10843439f, 0.04007150f, 0.64409322f, -0.06775372f, -0.08645011f, 0.05069827f, -0.10385935f, 
    0.01689337f, -0.06819563f, -0.06646939f, 0.01540952f, 0.19789843f, 0.34943315f, 0.12064642f, -0.32169414f, 
    -0.08195496f, -0.13489719f, -0.08002787f, 0.33906260f, 0.19285680f, -0.04923198f, 0.17652357f, 0.04656958f, 
    -0.29415390f, -0.05735708f, -0.10792335f, 0.06201365f, -0.00430141f, -0.00158278f, -0.31956649f, -0.09277126f, 
    -0.15311953f, 0.03372813f, 0.06165599f, -0.16800269f, 0.12330197f, -0.15046188f, -0.06000639f, -0.20473252f, 
    -0.50075620f, -0.00040597f, 0.05269801f, -0.13062884f, -0.03673416f, 0.01283264f, 0.04892726f, 0.09278000f, 
    -0.27902710f, -0.02851507f, -0.06498576f, 0.01804250f, 0.00306538f, -0.04487062f, 0.00049200f, -0.10604334f, 
    -0.01015427f, 0.29427320f, 0.40359074f, 0.17257677f, -0.03905340f, 0.15656528f, 0.10137530f, -0.01276438f, 
    0.01966199f, -0.12221747f, -0.13042192f, -0.04408974f, 0.30891716f, 0.16828564f, 0.07570231f, 0.20434050f, 
    -0.16402043f, -0.03186458f, -0.17092808f, -0.18817449f, 0.29879647f, -0.02720747f, 0.11838375f, 0.17141694f, 
    -0.24961570f, -0.06377220f, 0.24374206f, 0.03205254f, -0.46378762f, -0.72738326f, 0.15886788f, -0.09128360f, 
    -0.07644099f, 0.04491222f, 0.16894211f, 0.01513138f, 0.05036432f, 0.40850925f, 0.09109692f, -0.29007989f, 
    0.15623702f, 0.15148301f, -0.12972946f, 0.13137613f, 0.20992757f, -0.01100112f, -0.41437632f, -0.37940562f, 
    0.00463024f, 0.15575701f, 0.10704563f, 0.21772964f, -0.32932621f, 0.06961087f, 0.02813344f, 0.04532310f, 
    -0.41969168f, 0.12648395f, 0.08853866f, -0.06315231f, 0.12782130f, -0.20970744f, -0.18030408f, 0.15877008f, 
    0.26200324f, 0.09147817f, 0.18411578f, -0.04829307f, -0.09940622f, 0.20957783f, 0.02132856f, -0.02338218f, 
    -0.05956500f, 0.17379366f, -0.33292231f, -0.01300694f, 0.00916444f, 0.02425908f, 0.03860789f, 0.18357986f, 
    -0.01212729f, -0.10940153f, -0.08021411f, -0.11439678f, 0.04865652f, -0.20368230f, -0.15730128f, -0.04730496f, 
    -0.03207595f, -0.09775426f, 0.00667805f, 0.28086182f, 0.26153940f, 0.01518620f, -0.23408480f, 0.10374672f, 
    0.15486561f, 0.04114244f, 0.17915814f, 0.14292450f, -0.02813978f, -0.32278910f, -0.25353667f, 0.11903340f, 
    0.00578090f, 0.01834014f, 0.04552733f, 0.18707252f, -0.12320236f, -0.37406892f, -0.09858026f, 0.32193407f, 
    0.18020545f, 0.26820818f, -0.01520040f, -0.13572857f, 0.10436542f, 0.07907242f, 0.00221500f, 0.02300730f, 
    0.07533514f, 0.04694481f, -0.19718347f, 0.39348292f, 0.03532621f, 0.04261129f, -0.13590117f, -0.27068245f, 
    -0.04149278f, 0.17704788f, -0.08812390f, -0.06256941f, -0.03689604f, 0.18642157f, 0.04405411f, -0.23351115f, 
    0.08647437f, -0.05690028f, 0.09480272f, -0.08752397f, -0.01552747f, 0.20833035f, -0.01233396f, -0.05413703f, 
    0.04527649f, -0.24477032f, -0.09079341f, 0.08499815f, 0.20471169f, -0.00102852f, 0.28641558f, 0.04357145f, 
    -0.05280435f, -0.02694475f, 0.04327571f, 0.32554045f, 0.11256450f, -0.21804601f, 0.18458404f, 0.06516366f, 
    -0.22029349f, 0.12244994f, 0.20508267f, -0.23259193f, -0.35401827f, -0.11913641f, 0.25832668f, 0.08137383f, 
    -0.13331230f, 0.05615541f, -0.32454193f, -0.19958504f, -0.22097395f, 0.26142946f, 0.13302207f, 0.13442756f, 
    -0.19241321f, -0.13765363f, 0.01477578f, 0.19056866f, -0.03885107f, 0.01960210f, 0.03364053f, 0.09877554f, 
    0.41455621f, -0.17419085f, 0.21795717f, -0.03029156f, -0.18188021f, -0.00202733f, -0.12461430f, -0.10647047f, 
    0.12382636f, -0.34096900f, -0.05890634f, -0.33491266f, 0.15009573f, 0.09643521f, -0.00513026f, -0.04438059f, 
    -0.18469800f, 0.34442127f, -0.20693317f, -0.06022759f, 0.18114381f, 0.01255100f, 0.13188082f, 0.10798496f, 
    0.04419740f, -0.02508716f, -0.06935387f, -0.03558381f, -0.02246670f, 0.05537321f, -0.02256490f, 0.02537778f, 
    -0.06348380f, -0.04009014f, -0.01270493f, 0.01717767f, -0.03939072f, -0.04274694f, -0.02839502f, -0.06447352f, 
    0.02445076f, 0.04024019f, -0.07461508f, 0.07324716f, -0.00261101f, 0.03177163f, 0.02823126f, 0.04884878f, 
    -0.05262177f, 0.03104314f, 0.00894327f, 0.06355628f, -0.01618712f, -0.06668991f, 0.04369120f, -0.08792912f, 
    0.01426449f, -0.02010100f, 0.02453609f, 0.00442571f, 0.03698478f, 0.00236841f, -0.03335977f, -0.07542433f, 
    -0.07459236f, -0.03462882f, 0.05694218f, -0.03386876f, -0.07233456f, 0.00810282f, -0.00184589f, -0.07138126f, 
    -0.07909649f, 0.04303478f, 0.06540389f, -0.03499750f, -0.07676630f, -0.02447538f, 0.02346061f, 0.02051405f, 
    -0.01610769f, -0.08131818f, -0.07752781f, -0.06302422f, -0.03209797f, -0.04339735f, 0.00511594f, -0.07526129f, 
    -0.04128043f, 0.05108439f, -0.04313748f, -0.07787317f, -0.07881786f, -0.02119787f, -0.05790519f, 0.05307534f, 
    0.04587720f, -0.02457451f, -0.04688095f, -0.08715910f, -0.05859689f, 0.07374074f, 0.07494240f, 0.05505903f, 
    -0.07201914f, 0.06779924f, -0.03120243f, -0.05810006f, -0.06659235f, -0.07195938f, 0.00226115f, -0.08248777f, 
    0.05620133f, 0.02355617f, 0.06673995f, 0.01630997f, -0.01275231f, -0.02447263f, -0.05113380f, 0.05757334f, 
    -0.05616247f, -0.03666888f, -0.04912673f, 0.02767206f, -0.00091020f, 0.04924964f, 0.05771553f, 0.04808659f, 
    0.04054593f, -0.06026734f, 0.02792860f, -0.07600149f, -0.06190216f, -0.06770928f, 0.05202212f, -0.09277493f, 
    -0.05033928f, -0.04939468f, -0.05652497f, 0.05429037f, -0.05836977f, 0.03572111f, 0.02162660f, -0.06573871f, 
    0.04666102f, -0.03089845f, 0.04301127f, -0.06872806f, 0.05663830f, -0.04668627f, 0.07592995f, -0.01315941f, 
    -0.00410624f, -0.02324410f, 0.02097004f, 0.03643269f, -0.08046023f, -0.02985919f, -0.01457832f, -0.06197888f, 
    -0.00917358f, 0.04991611f, -0.01056166f, -0.03163910f, 0.03163646f, 0.06736749f, 0.06890599f, -0.06864813f, 
    0.07760756f, -0.10040186f, -0.04421400f, -0.01770990f, 0.34939224f, 0.32091069f, -0.11221159f, -0.06280634f, 
    -0.25370792f, 0.46691948f, 0.07399677f, -0.16174625f, -0.10030011f, -0.06260301f, -0.16341662f, 0.13163516f, 
    0.24658388f, -0.23899961f, 0.03184490f, -0.17509343f, 0.06134596f, 0.06412533f, 0.02622821f, 0.13578159f, 
    0.02237074f, -0.11876404f, -0.15103193f, 0.11524689f, 0.31177449f, 0.01684810f, -0.01404031f, 0.02579881f, 
    -0.05256195f, -0.06350758f, 0.08683231f, 0.02407017f, 0.26837412f, -0.22801998f, -0.04594027f, -0.01622366f, 
    -0.02227372f, -0.34682268f, -0.04972101f, 0.07409349f, -0.00555539f, 0.25761682f, -0.29676706f, -0.00649741f, 
    -0.05731997f, 0.08306335f, -0.19215269f, 0.10872484f, -0.03126598f, 0.12468936f, -0.25388232f, 0.27388006f, 
    0.13862416f, -0.22622816f, -0.18470101f, 0.19831328f, 0.02661995f, -0.01258672f, -0.09048474f, -0.20833273f, 
    0.00380248f, -0.08452900f, 0.03362933f, 0.09948964f, 0.05207780f, -0.02643809f, -0.05965101f, -0.21893427f, 
    -0.38329664f, 0.00475000f, -0.37700737f, -0.08762611f, 0.14409713f, 0.09792991f, 0.06496026f, -0.04503858f, 
    0.00418888f, 0.07619771f, -0.24352218f, 0.26625451f, 0.00576296f, -0.01117469f, 0.12051392f, -0.13332172f, 
    -0.17341390f, 0.03708029f, 0.18398575f, 0.14218377f, 0.11379550f, 0.06707988f, 0.18060285f, -0.17197356f, 
    -0.03628469f, -0.07026498f, 0.11253479f, -0.17634232f, 0.21401240f, -0.20453984f, 0.14133486f, 0.00234172f, 
    0.01532402f, -0.07547721f, -0.01965160f, 0.10948642f, -0.56817406f, 0.06205189f, -0.06933550f, 0.11211421f, 
    0.06651363f, 0.11035103f, 0.16928315f, 0.01608903f, -0.22347046f, 0.02377252f, 0.00174456f, 0.11498465f, 
    0.05372072f, 0.01572739f, -0.09260882f, -0.03132230f, 0.15891010f, 0.26287869f, -0.50835764f, 0.03077229f, 
    0.05474842f, 0.25667858f, 0.26352227f, -0.15141723f, -0.15219907f, 0.15296067f, -0.12580104f, -0.22421306f, 
    0.36321837f, 0.35497048f, 0.18893872f, 0.06059938f, 0.19606705f, 0.06064503f, -0.02885966f, -0.08561485f, 
    0.03548102f, 0.04058056f, -0.04530605f, -0.08430961f, -0.00901264f, -0.05430100f, 0.03421907f, -0.07675102f, 
    0.03648436f, -0.00306831f, -0.08224912f, -0.08300654f, -0.03025103f, -0.08951794f, -0.05944149f, 0.03131934f, 
    -0.02231601f, -0.03962117f, -0.00839897f, -0.08726184f, 0.03094632f, -0.03413200f, 0.05497630f, 0.06486760f, 
    -0.06400035f, -0.05765757f, 0.02836598f, 0.06552333f, 0.02594347f, -0.05561133f, -0.09205418f, -0.09368874f, 
    -0.01216048f, -0.09490684f, -0.08093843f, 0.02727459f, -0.07000200f, -0.07351874f, 0.07997359f, 0.05901439f, 
    0.03461932f, 0.04452590f, 0.02325786f, 0.03550177f, 0.00602435f, -0.05347224f, 0.00454197f, 0.00212917f, 
    -0.05382261f, 0.00431472f, 0.01078612f, -0.08945014f, -0.07561746f, -0.07137790f, -0.06367756f, 0.04805076f, 
    -0.04797087f, 0.04287471f, -0.04581795f, 0.02068975f, -0.08930774f, 0.06235749f, 0.04217933f, -0.04292884f, 
    0.01944453f, -0.07400857f, -0.02486834f, 0.05179420f, -0.03507484f, 0.02849227f, 0.02884999f, 0.03164692f, 
    -0.01497989f, -0.03799608f, -0.07141560f, 0.04452180f, -0.05530998f, -0.08715370f, -0.02524428f, 0.05836202f, 
    0.05386936f, 0.00241395f, -0.08525772f, 0.06301395f, -0.08229968f, -0.00171497f, 0.01892659f, -0.02209517f, 
    0.07528327f, -0.01698022f, 0.04724966f, -0.04852296f, -0.07374606f, 0.04217564f, 0.00827699f, 0.01927852f, 
    0.03411017f, -0.06607290f, -0.07732794f, -0.01333000f, -0.00022924f, 0.01169535f, -0.05940147f, -0.05438732f, 
    -0.05038413f, -0.03509982f, -0.06757482f, 0.05784771f, -0.08566592f, -0.08488675f, 0.02670547f, -0.06481057f, 
    -0.07758550f, 0.01848264f, 0.00316657f, -0.04678353f, -0.04397968f, 0.00447715f, 0.03099019f, -0.00588301f, 
    0.06941815f, 0.01251446f, -0.06763306f, 0.06665395f, -0.02121008f, -0.00414511f, -0.04635612f, -0.07812920f, 
    0.03836640f, 0.03118356f, 0.02227496f, 0.04820403f, -0.01736468f, -0.00214488f, -0.04956457f, -0.01612788f, 
    0.02922260f, 0.02182714f, -0.00098047f, 0.07149024f, -0.00922857f, -0.05466494f, 0.07141484f, -0.03384108f, 
    0.16108342f, 0.29612839f, -0.63555723f, 0.17201129f, -0.03731829f, -0.14264058f, -0.07102964f, -0.02587819f, 
    0.16091311f, -0.67728162f, -0.90758657f, 0.01392308f, 0.15912077f, -0.09477361f, 0.14623770f, -0.13488826f, 
    -0.02256918f, 0.08897242f, 0.27544263f, 0.52484685f, 0.23025420f, 0.34473065f, -0.17918435f, -0.06326044f, 
    0.02796460f, -0.07447461f, -0.06948947f, 0.18412611f, -0.00066133f, -0.29661307f, 0.03394752f, 0.14485261f, 
    0.06811979f, 0.01386986f, 0.01115738f, 0.02321122f, -0.03674303f, -0.12894621f, -0.24021855f, -0.00274386f, 
    0.09797733f, 0.06340829f, 0.15292369f, 0.11115675f, -0.03326210f, -0.13462755f, -0.41382182f, 0.07421974f, 
    0.14637059f, 0.05417144f, 0.06248692f, 0.20051534f, -0.08450792f, -0.30223593f, 0.08616870f, -0.35751745f, 
    0.19196375f, 0.12360617f, 0.00724743f, -0.20436014f, -0.00742936f, -0.11725286f, 0.07344817f, 0.09401355f, 
    0.05716671f, -0.00330375f, 0.32037479f, 0.23940098f, -0.00220533f, -0.06327088f, 0.06174593f, -0.08241569f, 
    0.23753771f, 0.06853581f, 0.07536659f, -0.03603381f, 0.20277509f, 0.08540831f, -0.10642284f, 0.05347155f, 
    0.10848860f, -0.47486970f, -0.09262612f, 0.27310514f, 0.14637236f, -0.12852053f, -0.22147137f, 0.00400262f, 
    0.10062232f, 0.05100075f, -0.11270288f, 0.16209963f, -0.40815958f, 0.24790169f, -0.02206602f, 0.23094244f, 
    -0.13463601f, 0.09726883f, 0.06626582f, 0.42584866f, -0.32924393f, 0.40761423f, -0.23336157f, 0.06495001f, 
    0.10178711f, 0.26759434f, 0.02412501f, 0.09978910f, 0.18784785f, 0.24699359f, 0.34503555f, 0.32293662f, 
    -0.22094525f, -0.09191050f, 0.02419407f, -0.04855049f, 0.09527225f, -0.23150779f, 0.15524560f, 0.27801079f, 
    -0.02428519f, 0.09397484f, -0.11326101f, 0.08858626f, -0.06908661f, 0.07741389f, 0.36569157f, 0.10830711f, 
    -0.38553312f, 0.02674879f, 0.01788098f, -0.21200114f, -0.12198472f, 0.13947007f, -0.15443484f, -0.10980430f, 
    -0.13258100f, -0.04158575f, -0.04887359f, -0.07366823f, 0.16657172f, -0.13027434f, 0.01733780f, 0.19495320f, 
    -0.29322293f, 0.31370497f, 0.17223002f, -0.13005367f, 0.01867234f, -0.23322484f, 0.13000102f, -0.09923570f, 
    0.01391844f, 0.23865259f, 0.36179355f, 0.25009826f, 0.19716397f, -0.07741105f, 0.00108141f, 0.01685690f, 
    -0.01221349f, 0.18191119f, -0.35084251f, 0.30006552f, -0.03701479f, 0.20849609f, -0.40298122f, 0.04361458f, 
    -0.09757799f, 0.14979954f, -0.16325790f, -0.34231320f, 0.05142342f, -0.29134873f, -0.50924981f, -0.01708438f, 
    0.12342802f, 0.04436341f, -0.19886057f, -0.08708414f, 0.03774989f, -0.31768683f, 0.10941808f, -0.27435735f, 
    -0.23148000f, -0.15818839f, -0.11174881f, 0.10590525f, -0.03522638f, 0.00287291f, 0.20877615f, -0.13122925f, 
    0.07799366f, 0.37166730f, 0.10815597f, 0.27239645f, 0.15992293f, -0.07323451f, 0.18675582f, -0.06437952f, 
    -0.05999406f, -0.21011566f, 0.17923874f, 0.12169108f, 0.15232150f, 0.02342558f, 0.23222342f, -0.05097343f, 
    -0.22218275f, -0.14276363f, -0.20195653f, -0.03866682f, -0.12709123f, -0.12544622f, 0.01993896f, 0.06660772f, 
    -0.18449232f, -0.05554329f, -0.12746155f, -0.19654045f, 0.11596220f, -0.02320736f, -0.21386307f, 0.07527151f, 
    0.05241567f, 0.54686576f, 0.27102956f, 0.44736126f, 0.11603191f, 0.10305813f, 0.17239371f, 0.31615195f, 
    -0.03723642f, 0.07079397f, -0.17016931f, -0.32195055f, 0.17253989f, -0.01074965f, -0.00567378f, -0.22565700f, 
    -0.17095703f, -0.04548869f, -0.03101161f, -0.10265688f, 0.14663345f, -0.14693868f, 0.12542029f, 0.19219756f, 
    0.07122087f, 0.02290314f, -0.02517357f, 0.03462499f, 0.09053962f, 0.04517797f, 0.27510068f, 0.24090561f, 
    -0.08359393f, 0.22439408f, -0.03543188f, 0.06490494f, 0.01594293f, 0.20617692f, -0.04055205f, -0.14143212f, 
    0.13581374f, 0.11653792f, 0.05093118f, 0.17174606f, 0.03909956f, 0.01758519f, -0.18501829f, 0.39813918f, 
    -0.17013706f, -0.21909468f, -0.03724511f, 0.06474689f, -0.02158174f, -0.09284814f, 0.15972939f, 0.68859065f, 
    0.00412000f, 0.30400458f, -0.00153540f, 0.03879967f, 0.16853806f, 0.09669136f, 0.04253607f, 0.16887188f, 
    0.03564715f, 0.00815479f, 0.06785037f, 0.02215931f, -0.07993033f, 0.00912420f, 0.02905559f, 0.06456611f, 
    0.01894286f, -0.02538937f, -0.06344353f, -0.05327419f, 0.06007799f, 0.00441704f, -0.04117300f, 0.01291600f, 
    0.00696397f, -0.04029592f, -0.04374353f, -0.07372122f, -0.05311456f, 0.04417055f, -0.06760004f, -0.05688682f, 
    -0.00601881f, -0.04699852f, 0.02473986f, 0.00286650f, 0.05098030f, -0.08617841f, 0.01599544f, 0.02583542f, 
    0.05431389f, -0.06011023f, 0.00394985f, -0.06312692f, 0.02523669f, -0.08030406f, 0.05255470f, -0.00098962f, 
    -0.03251753f, -0.05272524f, 0.03216866f, 0.04896542f, -0.02137381f, -0.01677736f, -0.01017930f, -0.03673662f, 
    -0.06962242f, -0.07851691f, -0.07242864f, -0.06872319f, -0.05994818f, -0.07139877f, 0.01748421f, 0.01292886f, 
    -0.01883230f, -0.09027580f, -0.07983682f, 0.04526778f, 0.07330251f, 0.06716979f, 0.03585882f, 0.05258835f, 
    0.02425460f, -0.03981394f, -0.00109614f, 0.06148427f, -0.04207446f, -0.03982466f, -0.09022082f, 0.00956738f, 
    0.04922016f, -0.02555979f, 0.00369702f, -0.04901486f, 0.02781128f, 0.04545271f, -0.08089907f, 0.04823032f, 
    -0.03581048f, -0.02268802f, 0.04153506f, 0.03275930f, -0.05638591f, -0.01258794f, -0.02114023f, 0.01481692f, 
    -0.06756224f, -0.00040676f, -0.01793083f, -0.02870399f, -0.06877635f, -0.06700388f, 0.00187221f, -0.01643303f, 
    -0.01499229f, 0.01097730f, 0.04679762f, 0.05255393f, 0.02706788f, -0.04584823f, 0.02595793f, -0.04768901f, 
    0.05473934f, -0.07938805f, 0.01259114f, 0.00318844f, -0.08979133f, 0.03129558f, -0.09037582f, -0.05127781f, 
    -0.09563126f, 0.02185609f, -0.00411855f, 0.07099981f, 0.01765649f, -0.00462757f, 0.04563526f, -0.03891318f, 
    0.06069510f, -0.01454232f, -0.05963340f, -0.08769164f, -0.04113283f, 0.05394518f, -0.04397861f, -0.04489234f, 
    0.04285954f, 0.00230274f, 0.02148203f, -0.09606884f, -0.00319062f, -0.06638515f, 0.05843299f, -0.05786440f, 
    -0.02876652f, -0.09171063f, -0.05794187f, 0.03081519f, -0.06769042f, 0.07881605f, 0.00748726f, -0.03925057f, 
    -0.03327747f, -0.03062321f, -0.03826509f, 0.04953725f, -0.09609333f, -0.50831681f, 0.22210310f, 0.12391669f, 
    -0.00863863f, -0.62515485f, 0.07894257f, -0.35607934f, 0.13411218f, 0.01245730f, -0.34011188f, 0.01774092f, 
    -0.15827936f, 0.16257249f, -0.03481212f, -0.40119451f, -0.28201541f, 0.02413482f, -0.06877562f, -0.07605643f, 
    0.18085751f, -0.01006948f, 0.02781776f, -0.13396576f, -0.11128399f, -0.16428201f, 0.11445133f, 0.10791102f, 
    0.20751785f, -0.12217270f, 0.00085248f, 0.03979175f, -0.24485424f, -0.36716095f, -0.23018695f, 0.04590282f, 
    -0.04467376f, 0.26792401f, 0.09981457f, -0.04591794f, 0.05630200f, 0.11775119f, -0.08992191f, 0.17472722f, 
    0.03913472f, -0.15808304f, 0.14190967f, 0.25894499f, -0.07328934f, 0.19794074f, 0.10519964f, 0.11576574f, 
    0.05785713f, -0.13159931f, -0.04949224f, -0.01824305f, -0.00948383f, 0.15931745f, 0.06993770f, 0.06795111f, 
    0.19043005f, 0.07756856f, 0.06330845f, -0.21456218f, 0.05391451f, -0.03286897f, 0.22771229f, 0.14456961f, 
    0.38960510f, 0.19174060f, 0.11455742f, -0.19683437f, -0.07463672f, -0.29313064f, 0.10736058f, -0.03251791f, 
    0.04638984f, -0.39101008f, 0.11610458f, -0.19287068f, 0.22889811f, 0.00565009f, 0.04576781f, 0.00116324f, 
    -0.10445086f, -0.06527060f, 0.05809670f, -0.23815447f, 0.06401329f, 0.14164340f, 0.20616630f, 0.22358564f, 
    -0.02635542f, -0.08981387f, -0.07241053f, 0.10227765f, 0.15115577f, 0.02391077f, -0.14661703f, -0.33763418f, 
    -0.18806998f, 0.16166605f, 0.00759481f, -0.19004300f, -0.18604143f, 0.03217268f, 0.05447708f, 0.03903271f, 
    0.01593904f, -0.10920480f, -0.06467552f, 0.14252858f, 0.07672782f, 0.33484218f, -0.05437038f, -0.03558421f, 
    -0.12477192f, -0.04655065f, -0.02437684f, 0.26003239f, 0.11773820f, -0.16061109f, -0.20249923f, 0.19518173f, 
    0.19448470f, -0.14543916f, -0.14906836f, -0.25610510f, -0.19373326f, 0.06816477f, 0.15871432f, 0.10181794f, 
    0.19855425f, 0.08424363f, -0.01322763f, -0.04487332f, -0.25415653f, 0.13306981f, 0.26831597f, -0.06962683f, 
    0.26076329f, 0.12754595f, -0.17122811f, 0.11337614f, -0.03382709f, 0.44825891f, 0.06492406f, 0.19795094f, 
    0.04068605f, 0.81582069f, 0.10240691f, 0.02388339f, 0.00134939f, -0.19506465f, -0.19772470f, 0.04031153f, 
    0.09881493f, -0.03896269f, 0.04613226f, -0.14916801f, -0.27666140f, -0.00941839f, -0.14241092f, -0.06382000f, 
    0.04605293f, -0.13444506f, -0.05333176f, -0.15890743f, -0.47359014f, -0.33805788f, 0.13831702f, 0.21886131f, 
    0.03637854f, -0.09277909f, 0.07380243f, 0.11868080f, 0.14358905f, 0.15625909f, -0.28650880f, -0.03149599f, 
    -0.07758160f, -0.01189291f, -0.06529882f, -0.03238041f, 0.09552845f, -0.07636791f, -0.08424694f, 0.39785656f, 
    -0.31756398f, -0.12489855f, 0.08015612f, 0.00954562f, 0.10162873f, 0.01315710f, 0.30666739f, -0.16791975f, 
    -0.01689887f, 0.02607745f, -0.04188792f, 0.11855475f, 0.08658767f, 0.14245078f, 0.06214345f, -0.45410353f, 
    0.08544575f, -0.24671847f, 0.23411629f, 0.16686255f, 0.13063040f, 0.04524510f, -0.07116816f, 0.17178886f, 
    -0.02259613f, 0.14546090f, -0.04206285f, 0.10843402f, 0.18353337f, 0.14138064f, 0.08502577f, -0.03502613f, 
    0.15282287f, -0.44691449f, 0.06017007f, 0.30251226f, 0.07715292f, 0.10180859f, -0.01012840f, -0.06534503f, 
    0.15044159f, -0.08938971f, 0.01216328f, 0.20210348f, -0.41839033f, 0.01659338f, 0.04880489f, 0.19493693f, 
    -0.01167207f, -0.00710770f, -0.19832614f, -0.19222309f, 0.32449913f, 0.17750387f, -0.04477441f, -0.19141324f, 
    0.03318225f, -0.03792501f, -0.04870038f, 0.25236362f, -0.31954333f, 0.11856106f, 0.04246516f, 0.16461578f, 
    0.06462801f, 0.26123458f, -0.11470754f, 0.02258626f, 0.09951492f, 0.34402826f, 0.35905534f, 0.40660879f, 
    0.03691388f, -0.07809649f, -0.00897191f, 0.03148580f, 0.06333175f, 0.10740133f, 0.03000529f, 0.18528515f, 
    -0.05516753f, 0.10019385f, -0.04984119f, 0.11582658f, 0.04117510f, -0.09493297f, -0.13832109f, -0.33873647f, 
    -0.41619778f, 0.01424881f, 0.09824446f, -0.02342821f, -0.03626668f, -0.34992686f, 0.01963038f, 0.05099870f, 
    -0.28879672f, 0.24136004f, -0.14568585f, 0.18888888f, -0.16412456f, 0.31121230f, -0.22617510f, 0.13972545f, 
    -0.06213983f, -0.05721480f, 0.05274362f, -0.08704247f, 0.06508607f, -0.09287763f, 0.13817507f, 0.14816912f, 
    0.05996155f, 0.05829775f, 0.02429886f, -0.13645877f, 0.19333540f, -0.00256173f, -0.17263415f, -0.17884688f, 
    0.10012528f, -0.11692385f, 0.03175431f, 0.60236651f, 0.13907564f, 0.26632246f, -0.11921933f, -0.16758128f, 
    0.03216944f, 0.05374241f, 0.00841734f, 0.10892976f, 0.07251951f, 0.03094087f, -0.00193229f, -0.08563612f, 
    -0.02083830f, -0.16305980f, 0.12138826f, 0.17490441f, -0.01641072f, -0.03132004f, 0.19787483f, 0.18863228f, 
    -0.05653030f, -0.00255997f, -0.08761849f, -0.25024748f, 0.01500872f, 0.03417406f, -0.04048030f, -0.26062351f, 
    0.05718080f, 0.31023777f, -0.04636527f, 0.12824161f, 0.18643034f, 0.12871872f, -0.08177422f, 0.39344859f, 
    -0.43819615f, -0.06496628f, -0.01385909f, 0.02978584f, 0.14522010f, 0.06440835f, -0.01886787f, -0.18487589f, 
    -0.34647736f, -0.30280632f, -0.03922993f, 0.17627895f, -0.09128527f, 0.04717889f, -0.02486707f, 0.18999274f, 
    -0.26887015f, 0.04583260f, -0.04244120f, -0.02362978f, -0.18110189f, -0.30441108f, 0.09907185f, 0.09810453f, 
    -0.04016352f, 0.01595644f, 0.09826403f, 0.25617847f, 0.08878636f, -0.19970919f, 0.05385671f, -0.27399668f, 
    0.15626612f, 0.17503883f, 0.11863943f, -0.15872042f, -0.48588476f, -0.04278983f, 0.02484003f, -0.02265699f, 
    -0.11654957f, -0.16323428f, -0.11790147f, -0.29401788f, -0.10775345f, -0.36479488f, -0.23273957f, 0.14295408f, 
    0.27294719f, 0.01241026f, 0.00976950f, 0.00650247f, -0.01083652f, -0.32951060f, 0.00761953f, 0.09385011f, 
    -0.09614692f, 0.16501608f, 0.28868800f, -0.11824433f, -0.00027719f, -0.05803455f, -0.10144775f, -0.38667592f, 
    -0.08870075f, 0.18803763f, 0.08582991f, -0.00559135f, 0.11417660f, -0.10563628f, -0.04277565f, 0.24259908f, 
    -0.16848591f, -0.26042989f, 0.20285764f, 0.14767426f, 0.35620311f, 0.05489017f, 0.11276129f, -0.26807693f, 
    -0.15276369f, -0.07623678f, -0.06564217f, 0.03401786f, 0.07654595f, 0.04317666f, -0.11673056f, -0.06194038f, 
    0.11006295f, -0.38197649f, 0.48705199f, 0.10300931f, 0.13508430f, 0.09339084f, 0.15900183f, -0.15146735f, 
    0.15509692f, 0.01053713f, 0.32776606f, -0.04300440f, 0.08627689f, 0.11014917f, 0.01881498f, 0.01854014f, 
    0.08992968f, -0.06536461f, -0.12363246f, 0.31591997f, -0.15920511f, 0.07306233f, -0.05357600f, -0.12696455f, 
    0.02954687f, 0.04014594f, -0.13499008f, -0.03328649f, -0.71505612f, -0.07647995f, 0.18661115f, -0.06058994f, 
    -0.01973446f, 0.11515387f, -0.14639758f, -0.06930780f, -0.20704189f, -0.06009366f, -0.12983988f, -0.25000647f, 
    0.03088732f, -0.12367901f, -0.16604510f, -0.15076533f, 0.09145271f, 0.04263271f, -0.11268900f, -0.00492295f, 
    -0.04068552f, -0.15061201f, 0.03475558f, 0.01115753f, 0.04046845f, -0.04409015f, 0.07711644f, 0.22334307f, 
    -0.20848839f, -0.00837591f, -0.04264813f, -0.07576329f, 0.03464513f, 0.19380702f, -0.00230122f, 0.07537609f, 
    -0.24701284f, 0.00292273f, -0.16050416f, 0.09379313f, 0.11727579f, 0.04318406f, 0.22462751f, -0.06444599f, 
    0.13116880f, 0.43376374f, 0.10225733f, 0.09586725f, 0.02526679f, 0.26325017f, 0.23425396f, 0.15599161f, 
    -0.03855749f, -0.26208752f, 0.22382347f, -0.11899244f, -0.03640625f, -0.13059589f, -0.00880588f, 0.02219139f, 
    -0.06184898f, -0.08043930f, -0.09838939f, -0.69046134f, 0.03248532f, -0.16139999f, 0.15541945f, 0.10775819f, 
    0.03711686f, 0.11022668f, 0.13946073f, -0.11698806f, 0.16101339f, -0.17955372f, -0.05660251f, -0.10875183f, 
    -0.05356305f, -0.04574190f, 0.06717528f, 0.02983040f, 0.08096153f, 0.08309545f, 0.20537437f, -0.07423770f, 
    0.15380342f, 0.34573585f, -0.05100514f, -0.06699680f, 0.05931242f, 0.05551711f, 0.43318215f, -0.68253124f, 
    0.24371725f, -0.16500586f, -0.12291666f, 0.08185038f, -0.02179863f, 0.25713956f, -0.13523091f, -0.00862271f, 
    0.10937193f, -0.14655127f, 0.19484125f, 0.06202463f, 0.27528584f, -0.10419989f, -0.24495699f, 0.21020758f, 
    -0.10481863f, 0.13683990f, 0.34688455f, -0.07648777f, -0.04304060f, -0.15292519f, 0.03836577f, 0.25174087f, 
    0.11792143f, -0.47129881f, -0.08806518f, 0.18604447f, 0.23559916f, 0.12826394f, -0.06480769f, -0.16007277f, 
    -0.26691014f, -0.07188549f, -0.30668372f, 0.14315847f, 0.25571594f, -0.13964182f, 0.16776125f, -0.10238052f, 
    -0.02718595f, -0.10985839f, 0.06589819f, 0.03617534f, -0.00125195f, -0.02062489f, 0.02965322f, 0.04265084f, 
    -0.27874753f, 0.09546759f, 0.09977850f, 0.10140484f, -0.43830049f, 0.01072238f, -0.11304589f, 0.07459505f, 
    0.08125737f, 0.14364073f, -0.15743813f, -0.03539216f, 0.34277040f, -0.22171320f, -0.62697768f, -0.47252828f, 
    -0.04462688f, 0.07456633f, 0.01030458f, 0.16739357f, -0.19407049f, -0.14685597f, 0.36245134f, 0.24258246f, 
    -0.33945069f, 0.19391437f, -0.16927274f, 0.03814717f, -0.01911958f, -0.03283226f, 0.07804428f, 0.12859109f, 
    0.28039250f, 0.26908877f, -0.17038327f, 0.06215454f, -0.17884754f, 0.01716334f, 0.12356573f, -0.07969174f, 
    0.24299824f, 0.10119738f, -0.18125813f, 0.10950673f, -0.15003121f, 0.20126244f, 0.30770612f, -0.02116443f, 
    0.03880106f, -0.14734459f, -0.01889483f, -0.37036294f, -0.08128620f, -0.09760001f, -0.04133439f, 0.08569149f, 
    -0.10263839f, -0.16769959f, 0.03692916f, -0.16102187f, -0.09025917f, -0.06387484f, 0.17493895f, 0.18645737f, 
    -0.01125445f, 0.02371627f, 0.27168944f, -0.06745944f, 0.03531455f, -0.24583758f, 0.05707112f, 0.48612803f, 
    -0.00353739f, -0.08100554f, -0.29802901f, 0.02886284f, 0.36273813f, 0.07765444f, -0.09288114f, -0.09844922f, 
    -0.05189215f, 0.05412812f, -0.13247266f, -0.08643664f, -0.11601853f, 0.33303919f, 0.08822168f, -0.55717444f, 
    0.03927315f, 0.17309238f, 0.14964345f, 0.20122510f, 0.03276211f, -0.16116861f, 0.21948448f, 0.00197148f, 
    0.18955618f, -0.31783816f, 0.07188359f, 0.13428971f, 0.02245740f, 0.05780594f, 0.18128775f, -0.12362482f, 
    -0.16383381f, 0.04728425f, -0.05491891f, -0.06270184f, -0.19508609f, 0.08398513f, 0.14873327f, -0.20507391f, 
    -0.23518984f, 0.16735981f, 0.14647153f, -0.00569865f, 0.02809642f, -0.24919632f, 0.04717503f, 0.03194736f, 
    -0.07890247f, 0.08803357f, 0.04043306f, 0.19990328f, -0.07578868f, -0.04345063f, -0.13212784f, -0.07641587f, 
    0.04625128f, 0.14454989f, 0.44711775f, -0.27029294f, 0.10756641f, 0.04448367f, 0.26495901f, 0.04258118f, 
    -0.10560600f, -0.03488221f, 0.13698801f, 0.03418191f, -0.44036260f, -0.39100724f, 0.11961243f, -0.00916281f, 
    -0.06860166f, 0.09214065f, 0.01409683f, 0.21355653f, -0.38088340f, -0.36442998f, 0.16985044f, 0.02304476f, 
    0.24445990f, 0.02947486f, -0.08661661f, 0.05001545f, 0.19454707f, 0.43250096f, -0.20866802f, 0.00870882f, 
    -0.10274065f, -0.10571715f, 0.19223104f, -0.11124332f, 0.03117456f, -0.02034396f, 0.19156750f, 0.39317313f, 
    -0.12130986f, -0.35597950f, -0.03964965f, 0.09163377f, -0.10345916f, 0.21777706f, -0.13407320f, 0.27243119f, 
    0.27524567f, -0.00778550f, -0.02342199f, -0.12516469f, 0.03225442f, 0.03833799f, -0.02854878f, 0.02026504f, 
    0.11354096f, 0.06636987f, -0.10227437f, 0.08756585f, 0.12455577f, -0.01750822f, 0.06923642f, 0.11038822f, 
    -0.07194111f, 0.16873206f, 0.06794928f, -0.28652549f, 0.04591151f, -0.11303985f, 0.19283073f, 0.11015042f, 
    0.01679095f, -0.07610208f, 0.31587946f, -0.17003012f, -0.75988853f, 0.27882048f, 0.02474741f, -0.00012897f, 
    0.20575717f, -0.09040663f, -0.03553892f, -0.48237035f, -0.12406013f, 0.11027561f, -0.08603133f, -0.02472834f, 
    0.00903584f, -0.07656849f, 0.22491768f, -0.13660531f, 0.74802446f, 0.11333194f, -0.00137226f, -0.21323366f, 
    -0.20406671f, -0.11001015f, 0.10207294f, -0.07530329f, -0.00021144f, -0.13053837f, -0.15204927f, -0.11387580f, 
    0.09490032f, -0.16321400f, -0.11259516f, 0.04898456f, -0.09086268f, 0.17252520f, 0.26476881f, 0.48126817f, 
    -0.01725711f, 0.00416440f, -0.11389851f, 0.04786406f, -0.11678863f, 0.15196735f, -0.31538945f, -0.06085926f, 
    -0.09024370f, -0.14891364f, -0.12871546f, -0.05001665f, 0.15624420f, -0.14363125f, -0.13965659f, -0.08002042f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09768788f, 0.03405077f, 0.08800679f, 0.21764576f, -0.05534258f, 0.18275435f, 0.05494481f, 0.31953576f, 
    -0.15748236f, 0.02375645f, 0.03654110f, 0.16787647f, 0.15595172f, -0.00559633f, 0.22827326f, 0.15863915f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12952514f, -0.21558532f, -0.23883483f, -0.13023907f, -0.21933568f, -0.10540175f, -0.19854951f, -0.07447294f, 
    -0.02278564f, 0.20821929f, -0.07747977f, 0.01644871f, 0.11645284f, -0.15744554f, 0.01230305f, -0.10490748f, 
    0.49549988f, -0.05075279f, 0.90079159f, -0.23285283f, 0.20653844f, 0.33319965f, 0.09499984f, -0.25209451f, 
    0.24343702f, -0.12866887f, 0.12569825f, -0.19184428f, -0.27422774f, 0.17833483f, 0.31797409f, 0.21912010f, 
    -0.51500374f, -0.02262376f, -0.32570001f, 0.12951006f, 0.03648080f, 0.32648614f, 0.04544814f, 0.38033220f, 
    -0.05860218f, 0.21062018f, -0.47652316f, 0.36246890f, 0.47510913f, -0.49616972f, -0.13891694f, 0.14104748f, 
    -0.82026207f, -0.27607319f, -0.25044256f, 0.57916218f, 0.23649608f, 0.18351421f, -0.10450719f, 0.10510413f, 
    -0.12555262f, -0.00317225f, 0.52611345f, 0.18063222f, 0.08272662f, -0.35573119f, -0.37498060f, -0.00903619f, 
    -0.38743204f, 0.62705332f, -0.33577269f, 0.24550124f, -0.01448213f, 0.02992154f, 0.00359675f, 0.59087968f, 
    0.07138103f, 0.13605258f, 0.07188374f, -0.49311116f, 0.04786105f, -0.08107833f, 0.05048187f, 0.06604310f, 
    0.10676310f, -0.09397180f, 0.01088324f, -0.06272015f, 0.21658219f, -0.01246170f, -0.19340068f, -0.26112932f, 
    -0.10767144f, -0.21793751f, -0.19989768f, -0.20614208f, 0.13809095f, 0.05312176f, 0.17181957f, -0.01250855f, 
    -0.17159034f, -0.03873748f, -0.69062978f, 0.50142324f, -0.19926117f, -0.20864756f, 0.07550646f, -0.07568756f, 
    -0.18805709f, 0.13802238f, 0.37447810f, 0.14767632f, 0.31412816f, 0.36752376f, 0.37639293f, 0.25379622f, 
    0.34972239f, 0.33491758f, 0.10277350f, 0.50068766f, 0.22842427f, 0.02387563f, 0.08545392f, 0.31029320f, 
    -0.56312245f, -0.15927097f, -0.01229844f, -0.32658255f, 0.08507688f, 0.47807175f, 0.21817070f, 0.30519086f, 
    0.47968772f, -0.29574761f, -0.27711919f, 0.25318551f, 0.18762346f, -0.55976653f, 0.04158760f, 0.19060594f, 
    0.13597481f, -0.22617245f, 0.36860245f, 0.27232388f, -0.35305938f, 0.39440641f, 0.37807626f, 0.00854566f, 
    -0.25977224f, -0.03920731f, -0.24174599f, 0.09258109f, -0.06110972f, 0.02352805f, 0.06290114f, -0.03031099f, 
    -0.19559136f, -0.16370144f, -0.23230256f, -0.10475583f, -0.00936604f, -0.22320282f, 0.20221996f, -0.21048787f, 
    -0.06700496f, -0.23136184f, -0.11990628f, -0.19422676f, 0.16849972f, -0.04508347f, -0.16381387f, -0.05535073f, 
    -0.21624884f, 0.01561754f, -0.06389930f, 0.00826012f, -0.10634890f, -0.14901760f, -0.03367649f, 0.01629994f, 
    0.51369518f, -0.21672854f, -0.17774646f, 0.38926563f, -0.06093598f, -0.20214196f, 0.10602947f, -0.23256935f, 
    -0.14232312f, -0.04004575f, 0.50782061f, 0.10244744f, -0.47877976f, 0.46735898f, 0.61896181f, 0.29609981f, 
    -0.28584453f, 0.25190175f, -0.72815597f, 0.39594117f, 0.17061593f, 0.77720827f, 0.21900418f, -0.16702126f, 
    -0.08803267f, 0.21759029f, -0.22447616f, 0.08340975f, 0.33434591f, -0.24154790f, 0.06087820f, 0.45233706f, 
    -0.31346545f, -0.13342285f, -0.58500791f, 0.30058166f, -0.16812186f, 0.04205747f, -0.09012978f, -0.25769231f, 
    0.57046604f, 0.12925424f, -0.33154216f, -0.13101718f, 0.31316292f, 0.27199575f, 0.81439632f, 0.52969056f, 
    0.65942746f, 0.34783968f, 0.09515297f, -0.20776774f, 0.17097478f, -0.34371725f, -0.07190486f, -0.13108337f, 
    0.05828339f, 0.03661587f, 0.80987889f, 0.11093001f, -0.36145324f, 0.12570278f, 0.08110398f, 0.07038457f, 
    -0.17364784f, 0.02934608f, -0.22901887f, -0.23191199f, 0.24975964f, 0.05518499f, -0.09528714f, -0.08856273f, 
    -0.07461218f, 0.13696328f, 0.20572959f, 0.01599182f, -0.09763930f, 0.07143974f, -0.23114578f, -0.16449744f, 
    -0.05757850f, 0.39771706f, 0.09305242f, 0.35491857f, 0.05974508f, 0.31010345f, -0.09581524f, -0.36255416f, 
    0.22307715f, -0.18233058f, -0.10256169f, -0.22864817f, -0.03208397f, 0.34332889f, -0.22543849f, -0.53070951f, 
    0.09615730f, -0.34191263f, 0.15124328f, -0.37978688f, 0.08854107f, 0.16343491f, -0.23109086f, -0.20716725f, 
    -0.03539350f, -0.03079266f, 0.31181380f, 0.13197879f, 0.30243024f, 0.48756528f, 0.24535434f, 0.24947236f, 
    -0.28176475f, -0.15440048f, 0.17737556f, 0.12258130f, -0.19131114f, 0.68757260f, 0.10653535f, -0.20204744f, 
    0.34966809f, 0.23071991f, -0.16736138f, 0.19741869f, 0.35667613f, -0.28636310f, -0.16737141f, 0.09058858f, 
    0.18914378f, 0.18981849f, -0.14590919f, 0.05996274f, -0.20246863f, -0.03947223f, -0.02152050f, -0.09861859f, 
    -0.12893705f, -0.13259822f, -0.24476527f, -0.21409898f, -0.07354730f, -0.10811811f, -0.22449066f, -0.13249065f, 
    -0.57038975f, -0.91635078f, 0.12719761f, 0.30327368f, -0.03349394f, -0.11845706f, 0.14408210f, 0.01641570f, 
    0.46714899f, -0.17594883f, 0.04387486f, 0.19310723f, -0.17637460f, -0.39356363f, -0.07215960f, 0.54318357f, 
    -0.33188063f, 0.34144473f, 0.19245031f, 0.28657609f, 0.06154624f, 0.44902706f, -0.19087236f, -0.31486291f, 
    0.71217018f, -0.19377802f, 0.31215864f, -0.13568614f, -0.41879541f, -0.04749760f, 0.56187385f, 0.19544911f, 
    0.20048478f, -0.29238796f, 0.23996785f, -0.24848653f, 0.09333711f, 0.31596047f, 0.18538858f, 0.25630969f, 
    -0.21727976f, -0.22705358f, 0.06939313f, 0.63292086f, -0.08392344f, -0.07130464f, -0.56657481f, 0.51919502f, 
    0.24994272f, -0.19714756f, 0.20868278f, -0.37178078f, 0.17098352f, -0.43674365f, 0.24369577f, 0.53461993f, 
    -0.32161957f, 0.04635890f, 0.61767817f, 0.15257131f, -0.29375952f, 0.22609147f, 0.13026682f, -0.03637775f, 
    0.03402954f, 0.00039974f, 0.10212120f, 0.29206997f, 0.20950270f, -0.54053438f, 0.04955119f, 0.30842957f, 
    0.44935128f, -0.11310849f, 0.62116969f, 0.08518318f, -0.33063316f, -0.32002646f, 0.72325784f, -0.19677953f, 
    0.04288027f, -0.11489617f, -0.22060387f, -0.24273421f, -0.18184535f, 0.06771609f, 0.20660050f, 0.15151735f, 
    -0.22792803f, 0.21675859f, -0.20897281f, -0.02750357f, -0.24120043f, 0.09604940f, -0.07206771f, -0.24943154f, 
    0.17411761f, 0.54201180f, 0.17704611f, 0.45693406f, -0.09623320f, 0.13522138f, 0.09208524f, 0.46804994f, 
    -0.87836879f, -0.02359143f, -0.54154932f, 0.02935476f, 0.33261397f, 0.26585355f, 0.04069097f, 0.16917121f, 
    -0.22835536f, 0.20286140f, 0.14527912f, -0.23848219f, 0.07333717f, -0.23925218f, 0.03118753f, -0.11011849f, 
    -0.25788009f, -0.01595312f, -0.25551182f, -0.02372475f, 0.04455362f, -0.08423151f, -0.27901998f, 0.15071140f, 
    -0.15591660f, -0.32741949f, 0.68985122f, -0.13295181f, -0.00297183f, -0.16651580f, 0.13576059f, 0.43017632f, 
    0.12635887f, -0.19366650f, 0.31733465f, 0.47411495f, 0.10738278f, -0.30258951f, -0.20594712f, -0.47357625f, 
    -0.24905379f, 0.01752986f, 0.30533621f, 0.23779222f, 0.13425368f, -0.11653363f, 0.13700546f, 0.37921137f, 
    0.68348932f, 0.03754940f, -0.38939798f, -0.58471394f, 0.48016843f, 0.21660975f, 0.20998393f, -0.02126977f, 
    -0.06562582f, -0.10258906f, -0.23983005f, 0.01506356f, -0.07929513f, 0.13693610f, 0.14287934f, -0.19318944f, 
    0.05052857f, -0.08078486f, 0.13600180f, -0.03086641f, -0.28331918f, 0.07667530f, -0.15927736f, -0.28969127f, 
    0.16250275f, 0.29463944f, 0.50579119f, -0.06641485f, -0.08271376f, 0.18505511f, 0.01205188f, 0.15410541f, 
    -0.02332952f, -0.24036522f, -0.46513817f, 0.11259947f, 0.78320432f, 0.52557260f, -0.44708836f, -0.30607009f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14219260f, 0.26123860f, -0.03301597f, 0.13421820f, 0.16321407f, 0.12349603f, 0.74521333f, 0.20590204f, 
    -0.08342804f, -0.21476147f, 0.10271623f, 0.17079955f, 0.41229796f, -0.36662605f, -0.18444932f, -0.05274067f, 
    -0.15311097f, 0.09921202f, 0.37365645f, -0.12370708f, 0.30982393f, -0.20068313f, -0.04283865f, 0.28502020f, 
    -0.09866163f, 0.07564584f, 0.47384426f, -0.11529090f, 0.05953976f, 0.28969300f, -0.31212175f, 0.20178121f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06344024f, 0.10709359f, -0.17163047f, 0.18208402f, -0.34577918f, -0.11290595f, 0.12499373f, -0.21377362f, 
    -0.14846465f, -0.24472688f, 0.04797608f, 0.12309755f, 0.28583038f, 0.61844712f, -0.09406193f, -0.19040795f, 
    -0.60754019f, 0.40923026f, 0.14953011f, 0.05473715f, 0.55223185f, 0.29749617f, -0.61910963f, -0.82376057f, 
    0.04930431f, 0.14117315f, -0.39851776f, 0.12737545f, -0.36377072f, 0.16258857f, -0.03563803f, -0.32207039f, 
    0.07493978f, 0.30823764f, -0.52178913f, -0.52972412f, -0.01978504f, 0.02550639f, -0.05484961f, 0.19805288f, 
    0.20879017f, -0.20839460f, -0.09931037f, 0.40308738f, 0.05972016f, -0.01474257f, 0.34513342f, 0.09348911f, 
    -0.66052538f, 0.14140123f, -0.17269343f, 0.02422880f, -0.37124994f, 0.34274244f, 0.20888729f, 0.11015706f, 
    0.01710739f, 0.08700661f, -0.20828627f, -0.15765901f, -0.59534287f, -0.27845675f, -0.01438319f, -0.61138648f, 
    0.02169289f, -0.66639340f, 0.52437818f, 0.50999218f, -0.80789214f, -0.16221456f, 0.06381961f, -0.37063238f, 
    -0.06336503f, -0.24296847f, 0.07695333f, -0.03818040f, 0.51464182f, 0.11317898f, -0.32180569f, -0.06355606f, 
    -0.66039085f, -0.09446817f, 0.20012568f, -0.07729880f, 0.49204504f, -0.25676143f, 0.62538278f, -0.40289330f, 
    -0.22795013f, -0.05927718f, 0.00726594f, 0.09923242f, -0.06018051f, -1.12513781f, -0.01080119f, -0.47570127f, 
    -0.18862827f, 0.24010344f, 0.06752636f, -0.62442845f, -0.33032981f, 0.09398061f, -0.30793491f, 0.42077968f, 
    -0.83414710f, -0.11288861f, -0.07272979f, -0.64022785f, 0.04602911f, -0.59593177f, 0.08059484f, 0.09774370f, 
    0.05043156f, 0.09693137f, 0.30502075f, 0.04920750f, -0.60094643f, -0.27103761f, -0.13207756f, 0.07519533f, 
    -0.63305134f, 0.13008396f, 0.39737368f, 0.12429150f, 0.22873662f, 0.12832136f, 0.08985184f, 0.46649909f, 
    -0.00292204f, -0.40894610f, 0.07279388f, 0.43785721f, 0.24860224f, -0.13375857f, 0.17078304f, -0.02364920f, 
    -0.04379433f, -0.03293001f, -0.03846443f, -0.17257728f, 0.24140492f, -0.26506156f, 0.03193746f, 0.00385494f, 
    0.59907520f, -0.39782634f, 0.16630183f, 0.00963268f, -0.17588721f, -0.09503062f, -0.07100902f, 0.07310880f, 
    -0.12254179f, 0.01148864f, 0.13922648f, 0.08637212f, 0.01303908f, 0.11936534f, 0.10529952f, 0.11204000f, 
    0.08812632f, 0.17024040f, -0.19301879f, -0.19209501f, 0.14004292f, 0.10427511f, 0.03696324f, -0.09085698f, 
    0.32948121f, -0.23668385f, 0.09723740f, 0.29446432f, -0.26025841f, 0.10418019f, 0.10197178f, 0.06685940f, 
    0.72161305f, -0.21969797f, -0.19080891f, 0.11178521f, -0.46900308f, 0.10063408f, -0.59594309f, 0.21294415f, 
    0.49018505f, -0.17304745f, -0.10698371f, 0.00059923f, -0.03841230f, 0.15263394f, 0.00447179f, -0.32670447f, 
    0.01457019f, 0.10445117f, 0.08568316f, -0.21546823f, 0.51773727f, -0.09351037f, -0.03702666f, 0.42127201f, 
    -0.22761616f, 0.05610974f, -0.05735221f, 0.05493949f, 0.22355907f, 0.16036190f, 0.13784407f, 0.02632123f, 
    -0.83631587f, -0.44323486f, -0.16057710f, -0.00409594f, -1.22665632f, 0.21814789f, -0.33057490f, -0.40087959f, 
    -0.15643337f, 0.09529224f, 0.43255660f, -0.09515589f, -0.50034386f, 0.15667957f, -0.11073311f, -0.10506598f, 
    0.05308930f, 0.13072936f, 0.02307200f, -0.82023883f, -0.15449540f, -0.08437168f, -0.68593067f, -1.00645101f, 
    -0.14592588f, -0.04719301f, 0.11206406f, -0.59084421f, -0.33349478f, 0.05801484f, 0.14361967f, -0.03290358f, 
    0.25063673f, -0.16149944f, 0.25657693f, 0.17023696f, 0.85659021f, 0.32535475f, 0.12883027f, -0.25924814f, 
    0.17472960f, -0.13266556f, -0.73886883f, -0.04207059f, 0.34439319f, 0.29446641f, -0.10121763f, 0.27493721f, 
    -0.12105259f, -0.08271305f, -0.44411242f, -0.27188200f, -0.65191311f, -0.10401739f, -0.07758452f, 0.11867795f, 
    0.43097988f, 0.02808252f, 0.11158017f, 0.36112434f, -0.92111439f, -0.68025613f, 0.54700196f, 0.08176582f, 
    -0.46095616f, 0.28746685f, -0.93795258f, -0.06378835f, -0.07050884f, -0.72063351f, 0.30076095f, 0.59370106f, 
    0.40327284f, -0.11496539f, -0.15568592f, 0.04172908f, 0.45301270f, -0.44025233f, -0.07624900f, -0.25553378f, 
    0.11705880f, -0.37277150f, 0.24714829f, 0.34986708f, 0.47426015f, 0.13114293f, -0.02777306f, 0.21218811f, 
    -0.05252789f, 0.11800037f, -0.05659825f, -0.28155091f, -0.00703820f, 0.15154755f, -0.72707897f, -0.20108959f, 
    -0.80303365f, -0.23806168f, -0.14953309f, -0.03680595f, 0.29048407f, -0.13923933f, -0.18041971f, -0.04190454f, 
    0.25828537f, -0.09624219f, 0.03048507f, -0.11409726f, 0.04431612f, 0.39775729f, -0.09956849f, -0.05615889f, 
    0.03355670f, 0.26414505f, 0.11898971f, -0.08328409f, -0.39287221f, -0.05966677f, -0.25865403f, -0.37339979f, 
    -0.43167624f, -0.05999785f, -0.01746345f, -0.28015009f, -0.20139630f, -1.12904513f, -0.27436736f, -0.00321601f, 
    -0.03514406f, 0.19428413f, 0.29212371f, 0.10727599f, 0.20364171f, -0.30335623f, 0.59458715f, 0.24620599f, 
    -0.37309566f, 0.03975286f, 0.07422318f, -0.03234766f, 0.57886976f, -0.11030463f, 0.08279399f, 0.20258164f, 
    -0.09850289f, -0.12316425f, -0.04263011f, -0.31728870f, -0.22569914f, 0.07536712f, 0.18959084f, 0.22648501f, 
    0.07319237f, 0.00663980f, 0.05886361f, 0.09451794f, 0.08393991f, 0.43723881f, -0.42584515f, 0.12438004f, 
    -0.77217221f, 0.45635337f, -0.07756291f, 0.13636415f, -0.48302183f, -0.62533092f, 0.22492892f, -0.05420255f, 
    -0.96377879f, 0.04373234f, 0.24406071f, 0.02448089f, -0.46189982f, 0.06725524f, -0.04021571f, 0.40828320f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02658997f, 0.04719297f, -0.30735785f, -0.24627943f, 0.28613073f, 0.20509490f, -0.19708689f, -0.63775504f, 
    -0.23993476f, -0.02643921f, 0.39198220f, -0.18971315f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
