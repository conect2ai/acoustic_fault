#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65613860f, 0.48703524f, 0.38565519f, -0.14070137f, 0.57995164f, -0.33838257f, 0.02394522f, 0.05968731f, 
    0.03252866f, -0.45233554f, 0.07300711f, -0.55624223f, 0.48666966f, 0.18780828f, -0.25769022f, -0.00350003f, 
    0.23377921f, 0.01241425f, -0.04111926f, -0.38012066f, -0.66375923f, -0.01494313f, -0.48295471f, -0.00303249f, 
    -0.37335095f, 0.23535517f, 0.22216791f, 0.05942105f, -0.11551123f, 0.39386007f, -0.18707776f, 0.03441303f, 
    0.46272597f, -0.24780874f, -0.41363382f, -0.27448675f, 0.00263572f, -0.04256155f, 0.22763027f, -0.53145105f, 
    -0.35811076f, -0.59965813f, -0.24268223f, -0.22525653f, 0.05591139f, -0.55398428f, -0.66606438f, -0.72878933f, 
    -0.16909775f, -0.14169873f, 0.36760953f, 0.01382152f, 0.06510160f, 0.19516528f, -0.22064571f, 0.63797009f, 
    -0.22303687f, -0.31583914f, -0.29893643f, -0.36216515f, 0.23933601f, 0.04182256f, -0.17376147f, 0.41167799f, 
    0.28194270f, 0.16108249f, 0.25515929f, 0.38207385f, 0.47047111f, -0.39852795f, 0.32440835f, 0.09779634f, 
    0.60452914f, 0.64368230f, 0.67036414f, -0.15659145f, -0.46481732f, -0.12987073f, 0.35525224f, 0.02029254f, 
    0.19197629f, -0.53230560f, -0.52153385f, -0.11251989f, 0.48266315f, 0.03060463f, 0.49536458f, 0.05808217f, 
    -0.28349036f, -0.09718996f, -0.37170058f, -0.25443947f, -0.26499736f, 0.12427370f, 0.55260473f, 0.06249868f, 
    -0.25756383f, -0.34884036f, -0.18385042f, 0.24233294f, -0.34119987f, -0.08768117f, -0.69396859f, 0.31582245f, 
    0.00601380f, -0.21675077f, 0.37317452f, -0.10697959f, -0.20780134f, 0.19113496f, 0.42088467f, 0.46982056f, 
    0.24465220f, 0.37599012f, 0.23167261f, -0.17878562f, 0.00871227f, 0.00596106f, -0.44308594f, 0.46638182f, 
    -0.21924534f, 0.11633059f, 0.54837406f, -0.04899020f, 0.04819230f, 0.35628316f, -0.21199691f, -0.14913255f, 
    0.30597201f, -0.18180199f, -0.30456775f, 0.42861447f, 0.25240937f, -0.01580309f, -0.19270340f, -0.37320596f, 
    -0.10005365f, 0.01357472f, 0.39107579f, -0.37681440f, -0.35689494f, -0.11943208f, -0.29759857f, -0.30348730f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12349859f, -0.01139727f, -0.14015511f, -0.33936590f, 0.12389820f, -0.21332099f, -0.03879432f, -0.05998511f, 
    -0.28921255f, 0.02341957f, -0.06333257f, -0.16012123f, -0.42525670f, -0.32439649f, 0.17952190f, -0.30042914f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01949211f, -0.09880392f, 0.10951476f, -0.00022387f, -0.08895104f, -0.05010956f, 0.12118448f, -0.06874432f, 
    -0.04687288f, 0.15665506f, 0.08658299f, 0.00348765f, -0.01965522f, -0.01492173f, -0.07259927f, -0.05270505f, 
    0.09266723f, 0.07992721f, 0.20424554f, 0.26959622f, 0.14192827f, 0.11017090f, -0.00283060f, -0.06072738f, 
    -0.04179497f, 0.11882413f, -0.02910894f, -0.18251610f, 0.01744530f, -0.03274276f, -0.07289194f, 0.02457684f, 
    0.02840116f, -0.11422352f, 0.20487088f, 0.22824125f, -0.19763654f, -0.18658318f, -0.11954420f, -0.12439806f, 
    0.07040197f, -0.06330901f, -0.04626987f, -0.11242597f, -0.02950491f, 0.14093336f, 0.31287208f, 0.02282006f, 
    0.12377565f, -0.01324316f, -0.13002567f, -0.03039475f, 0.07043352f, -0.09876001f, -0.40193698f, -0.09031415f, 
    -0.06584871f, -0.09154119f, -0.08799583f, -0.04423806f, 0.03186713f, 0.04681401f, -0.16652124f, 0.05547655f, 
    0.15354522f, -0.12274345f, -0.01267516f, 0.02570570f, -0.10878023f, 0.06329855f, 0.01895533f, -0.05168585f, 
    -0.00861090f, 0.12166356f, -0.13314317f, -0.18330115f, -0.15440311f, -0.03621147f, -0.09984744f, -0.03084501f, 
    0.02533964f, 0.16726157f, -0.03614585f, 0.12316446f, 0.11197484f, 0.12941791f, 0.06101426f, 0.05968112f, 
    -0.01466728f, -0.03027229f, 0.26011068f, 0.16651665f, 0.12018105f, 0.09496097f, 0.06407454f, 0.02257036f, 
    -0.16715395f, 0.07545305f, 0.01483826f, -0.12548847f, 0.10096056f, -0.07620855f, 0.14792368f, 0.02717049f, 
    -0.05714734f, -0.05361050f, -0.06274983f, -0.12424787f, 0.01552034f, -0.10744040f, 0.14671412f, 0.10915068f, 
    -0.06115625f, 0.08436972f, 0.07987797f, 0.10482942f, 0.01513186f, 0.04669004f, -0.02956417f, -0.21104333f, 
    -0.05366134f, -0.22954080f, -0.31138355f, 0.02520688f, 0.10265794f, 0.22236495f, 0.14271584f, -0.07614090f, 
    -0.13985834f, -0.08069482f, -0.21625121f, -0.04078966f, -0.12434161f, -0.00357062f, -0.22195393f, 0.31245294f, 
    0.09598150f, 0.09657428f, -0.05293741f, -0.06734948f, 0.03427589f, 0.00161433f, -0.01631583f, -0.07999843f, 
    -0.00894153f, -0.01103652f, -0.01994631f, 0.00787390f, -0.02475590f, -0.06964565f, -0.03927482f, -0.01556420f, 
    -0.01680217f, -0.04229382f, -0.09514186f, 0.02868416f, 0.00366657f, -0.07736100f, 0.06088280f, -0.00347223f, 
    -0.09437627f, -0.04581238f, -0.00881010f, 0.01185134f, -0.06611805f, -0.05083204f, -0.06086136f, -0.03735692f, 
    0.03922670f, 0.00466607f, -0.06340186f, -0.02251055f, 0.03074448f, -0.11296535f, -0.06831215f, -0.07171430f, 
    -0.01990440f, -0.06848712f, -0.06449131f, -0.10064520f, 0.02604743f, -0.03374986f, 0.04559100f, 0.03890454f, 
    -0.04742240f, -0.06850122f, -0.08981799f, 0.00865388f, 0.02648295f, 0.03207624f, -0.00097910f, -0.09120937f, 
    -0.07375184f, -0.04551496f, -0.10153280f, 0.00846801f, -0.04518971f, -0.01866908f, -0.09427740f, 0.04093287f, 
    0.01597831f, -0.00750268f, -0.07058711f, -0.05328412f, -0.08349342f, -0.09243302f, -0.04691787f, -0.06442554f, 
    0.03677679f, -0.04359239f, 0.01869824f, 0.01980930f, -0.06368104f, 0.04537800f, -0.04379521f, -0.04961932f, 
    -0.03469184f, 0.04385384f, 0.01934950f, -0.10041546f, -0.00775229f, -0.05472548f, 0.00962311f, -0.07672834f, 
    -0.11855389f, -0.06284869f, -0.04991946f, -0.03456813f, -0.00337986f, 0.00732811f, -0.07872539f, -0.06692836f, 
    -0.10345091f, 0.01669396f, 0.00065066f, -0.05763199f, -0.02530571f, -0.08466117f, 0.02457299f, -0.10845349f, 
    0.01895032f, -0.09417710f, -0.00866206f, 0.01513940f, 0.04100533f, 0.00292708f, -0.05185743f, 0.02539221f, 
    -0.00342988f, -0.01045359f, -0.07529741f, 0.05900981f, -0.07612697f, -0.05388482f, 0.00309881f, 0.02115401f, 
    0.03169283f, -0.10001780f, -0.07161559f, 0.00451806f, -0.00097445f, -0.02745526f, -0.04968425f, 0.00401239f, 
    0.01328483f, -0.10016208f, -0.04830429f, -0.02687502f, -0.01938336f, -0.00588615f, -0.06076988f, -0.11331415f, 
    -0.07264174f, -0.08642038f, 0.04378693f, -0.10246427f, -0.06744297f, -0.01962355f, -0.09641895f, -0.08481412f, 
    0.01498689f, -0.06496660f, 0.00222976f, 0.03783366f, -0.04552133f, -0.04829883f, -0.09641256f, 0.04390804f, 
    0.00121762f, 0.04488281f, 0.02119823f, -0.10837610f, -0.10334484f, -0.00916390f, -0.07195104f, 0.11382416f, 
    -0.00079799f, 0.00068236f, -0.05025659f, -0.28372324f, -0.02294131f, 0.09495376f, 0.02669466f, 0.03101537f, 
    -0.11116392f, -0.03690619f, -0.17074199f, -0.14703317f, -0.05261087f, -0.01397040f, 0.00640927f, 0.10181327f, 
    -0.05013068f, -0.01044665f, 0.03150197f, -0.18247287f, 0.07215401f, -0.15631180f, 0.02621497f, 0.03071445f, 
    -0.02400199f, 0.03186130f, 0.03518725f, -0.17754008f, 0.05153988f, 0.02148255f, 0.02707178f, 0.04718218f, 
    -0.11551512f, 0.04894292f, -0.10011823f, -0.00085758f, 0.09663378f, 0.10392639f, 0.29350686f, -0.00753655f, 
    0.04342987f, 0.02578418f, 0.11320632f, 0.11303037f, 0.04849689f, 0.12038942f, 0.09549757f, -0.16552322f, 
    -0.32955071f, 0.00414822f, -0.02011048f, 0.05860666f, -0.03550454f, 0.01858257f, 0.13281198f, 0.11725712f, 
    0.39349928f, -0.03179670f, -0.04818567f, -0.12501113f, -0.09689247f, -0.06469661f, 0.06402907f, 0.25390404f, 
    -0.04661626f, -0.10436265f, 0.21879701f, -0.04251822f, -0.03206775f, 0.00367533f, 0.02679870f, -0.11990681f, 
    0.08846867f, -0.09498943f, 0.42942673f, -0.11649700f, 0.10009857f, 0.03791497f, -0.09474730f, 0.01176372f, 
    0.07484767f, -0.05154415f, 0.18193337f, 0.01447022f, -0.15025276f, 0.03484260f, 0.07590237f, -0.03306527f, 
    0.13082366f, -0.02453277f, -0.13952772f, -0.10697850f, -0.25740969f, -0.06120121f, 0.12714754f, 0.07919981f, 
    0.08551334f, 0.03431971f, -0.09474788f, -0.08548634f, 0.06318997f, 0.20220801f, 0.04464128f, -0.15723006f, 
    0.21749526f, -0.15609485f, -0.07064634f, 0.01713369f, 0.09144825f, -0.79294980f, -0.00864859f, -0.29844722f, 
    0.04937214f, -0.01976067f, -0.07225575f, -0.01056805f, -0.10935006f, -0.07126122f, -0.18779238f, 0.00766974f, 
    -0.16010842f, 0.07135503f, -0.10030922f, -0.00384821f, -0.06797438f, 0.08574881f, 0.09564955f, -0.13918979f, 
    -0.08550929f, -0.23890424f, 0.02582812f, 0.05583279f, 0.06709598f, -0.01632041f, 0.08160486f, 0.00635229f, 
    0.29115430f, -0.07593001f, -0.12879024f, -0.17586681f, 0.02938807f, 0.03823810f, 0.02487048f, -0.07530736f, 
    0.06808655f, -0.02845834f, -0.03247765f, -0.33047712f, 0.08021761f, -0.08000637f, 0.12344376f, -0.06168979f, 
    -0.05086184f, 0.12775542f, -0.30867273f, 0.16506056f, -0.13660857f, 0.01849001f, -0.20646781f, -0.10816012f, 
    0.06479263f, -0.02096527f, -0.15601926f, -0.04124821f, -0.27402651f, 0.37934697f, -0.08844413f, -0.06792116f, 
    0.03067377f, 0.06282249f, 0.11160611f, 0.15314247f, -0.25036311f, -0.22594221f, 0.14584644f, 0.09511951f, 
    -0.04026965f, -0.04484193f, 0.03980876f, 0.09733357f, 0.11170121f, 0.07030383f, 0.13822749f, -0.00476608f, 
    0.07163561f, -0.04195807f, 0.12784174f, -0.09883752f, 0.06612150f, -0.03190637f, -0.13206244f, -0.17758104f, 
    -0.31768513f, -0.07672378f, 0.05042181f, -0.04347327f, 0.16946980f, -0.06327496f, 0.07729598f, 0.16426623f, 
    -0.13585185f, -0.03076281f, -0.16820745f, 0.15104456f, -0.08884676f, 0.03258454f, 0.01423203f, -0.22268789f, 
    0.26370150f, 0.19904317f, -0.02455900f, -0.01151524f, 0.10288164f, -0.01595126f, 0.06031834f, 0.06396528f, 
    -0.15142143f, 0.31562436f, 0.08235576f, 0.02708327f, 0.02031338f, 0.00513966f, 0.04534254f, 0.01017560f, 
    -0.08043733f, 0.02369307f, 0.11125585f, -0.08385674f, -0.06857209f, -0.02961240f, -0.01593241f, 0.01334255f, 
    0.00543193f, 0.09753525f, 0.17734826f, 0.11159139f, -0.18900022f, -0.10986093f, 0.14531575f, 0.14016320f, 
    -0.00570144f, -0.09968051f, -0.05491658f, -0.02740431f, 0.15995774f, 0.07772982f, -0.03470901f, 0.01436185f, 
    -0.00718741f, -0.01580586f, -0.11941738f, -0.02363354f, 0.05877949f, -0.03516052f, -0.36432797f, 0.24113894f, 
    -0.12720667f, 0.06907143f, 0.14260647f, -0.19799212f, -0.09657806f, 0.04747082f, 0.07202677f, -0.22992824f, 
    -0.08721957f, 0.02256739f, 0.12214917f, -0.03582678f, -0.12142154f, 0.02439187f, 0.03246707f, 0.01582539f, 
    0.06583834f, -0.31263000f, -0.06738527f, -0.02543388f, 0.08221371f, 0.07970953f, -0.01780023f, 0.03637237f, 
    0.01400074f, 0.21703416f, -0.06722286f, 0.08255760f, 0.02812939f, 0.03708866f, -0.01008383f, -0.07876021f, 
    0.01982996f, 0.31718591f, 0.03107693f, 0.03544830f, -0.06444096f, -0.02395495f, -0.02376305f, -0.08061728f, 
    -0.11133529f, 0.01003804f, 0.21442309f, -0.10450535f, -0.05674694f, -0.01308371f, -0.09305601f, 0.00049342f, 
    0.11566022f, 0.01136079f, 0.03538297f, 0.07039707f, 0.04624358f, -0.01880939f, -0.05140177f, -0.07961529f, 
    0.12519188f, 0.01683107f, -0.07262710f, -0.08850934f, 0.11691020f, 0.06230465f, 0.07207631f, 0.01563781f, 
    -0.19120573f, -0.14994301f, 0.09601147f, -0.07028032f, 0.14814787f, 0.12555854f, -0.22272246f, -0.01324839f, 
    -0.13817044f, 0.09466206f, -0.02817898f, 0.18490916f, 0.05945783f, -0.08373817f, 0.16389011f, 0.06953030f, 
    0.01818359f, -0.00292766f, -0.13039264f, -0.02975663f, -0.14228775f, 0.05239287f, 0.01402045f, -0.31847197f, 
    -0.07750504f, 0.16051745f, 0.15023470f, 0.04436535f, 0.01868897f, 0.02672554f, -0.17010234f, -0.13129748f, 
    0.07362043f, -0.02661983f, 0.28523728f, 0.10228924f, 0.12687844f, -0.06329535f, 0.07934634f, 0.18119530f, 
    -0.00247898f, -0.11107784f, -0.10566527f, -0.10245807f, -0.09775095f, 0.15773281f, -0.02278608f, 0.00797637f, 
    -0.05541809f, 0.04154809f, -0.14331973f, -0.09444270f, 0.27894038f, -0.08874041f, -0.03882282f, 0.09358431f, 
    0.01929778f, 0.10232456f, 0.11703738f, 0.28176939f, 0.36625040f, -0.10906325f, -0.19848204f, -0.04413696f, 
    -0.04408403f, -0.03366109f, -0.11070193f, -0.05552809f, 0.03024923f, 0.02357843f, -0.16068603f, 0.05662990f, 
    0.02693008f, 0.19776566f, 0.02896162f, -0.17036486f, -0.07287418f, 0.04106347f, -0.02807081f, -0.11752697f, 
    -0.13852136f, 0.14198506f, 0.06098999f, 0.05832918f, -0.02631002f, 0.13992341f, -0.09754667f, -0.02405700f, 
    -0.17606060f, -0.05613225f, 0.08439922f, -0.20366991f, -0.08243501f, -0.06636875f, 0.01207381f, -0.04869878f, 
    -0.23043518f, 0.10775328f, 0.00587059f, 0.14447021f, 0.09029191f, 0.02671774f, -0.03608615f, -0.11851915f, 
    -0.03005140f, 0.16553894f, 0.23759583f, -0.09926301f, 0.18894836f, 0.16518630f, 0.04169027f, -0.06612296f, 
    0.02023089f, -0.07267722f, -0.14367096f, -0.26712966f, 0.04820902f, 0.09389387f, 0.04393247f, 0.07125656f, 
    -0.02511556f, -0.05999130f, 0.07456830f, -0.06964973f, 0.01574509f, -0.19261153f, 0.04985706f, 0.00646367f, 
    -0.10596985f, 0.02239466f, 0.15796512f, -0.36871889f, -0.10877953f, -0.00923140f, 0.12862594f, -0.14858605f, 
    0.06438608f, 0.07554471f, 0.00101083f, 0.10733209f, 0.01836007f, 0.07205516f, 0.09329014f, -0.09547799f, 
    0.03069721f, 0.10052926f, -0.04851583f, -0.04079992f, 0.10633083f, -0.01802755f, -0.26549646f, 0.05194324f, 
    0.14390080f, 0.03025638f, 0.09255845f, 0.07871884f, 0.02466370f, 0.12659727f, -0.17669916f, 0.02306232f, 
    0.05422391f, -0.07116897f, 0.11320244f, -0.04624235f, -0.05066172f, 0.14491218f, -0.15432470f, 0.02689068f, 
    0.15308639f, 0.19793755f, 0.21767387f, -0.01789212f, -0.03583020f, 0.02396978f, -0.00252751f, 0.05447698f, 
    -0.19932795f, -0.07665347f, 0.35421067f, 0.07762969f, 0.06966925f, -0.13080648f, 0.05752196f, -0.00760661f, 
    0.09314475f, -0.09812310f, 0.00595395f, -0.33156875f, 0.18058670f, -0.14885889f, 0.16430998f, -0.01579907f, 
    -0.10453025f, -0.06032084f, -0.06466088f, -0.02126266f, -0.10674121f, -0.00585796f, -0.01803313f, -0.10253590f, 
    0.08731684f, -0.00734128f, -0.00131170f, -0.09886175f, -0.00254085f, -0.13236375f, 0.01357546f, -0.20953847f, 
    0.03034793f, 0.24223845f, 0.03148046f, -0.06173304f, 0.12807254f, 0.02309070f, 0.14056662f, 0.20432751f, 
    0.01897758f, 0.08667494f, -0.03738079f, 0.05663553f, -0.13842978f, -0.38591418f, -0.08982889f, 0.04562945f, 
    -0.03136141f, -0.01560809f, -0.02511701f, -0.13820501f, 0.06893473f, 0.15279053f, -0.12489879f, 0.00351128f, 
    -0.22722235f, 0.18860161f, -0.01390925f, -0.00190372f, 0.01624193f, 0.07745153f, -0.13279743f, 0.09131317f, 
    -0.04494238f, -0.21337746f, -0.17044526f, -0.05983572f, -0.14936955f, 0.01088885f, 0.00452740f, -0.04623719f, 
    -0.10871180f, 0.27356434f, 0.22850293f, -0.12787932f, 0.00193415f, 0.05055143f, -0.01134668f, -0.02424969f, 
    0.09804908f, 0.11961134f, -0.07490282f, 0.05774531f, 0.16876559f, 0.03955732f, -0.01784855f, 0.11837260f, 
    0.05397424f, -0.06253743f, -0.01946156f, -0.07237052f, -0.09006189f, 0.01700475f, 0.15773761f, -0.02126651f, 
    -0.05652381f, 0.01052538f, 0.17344454f, 0.04704561f, -0.05059147f, 0.11193955f, -0.06541923f, -0.20929365f, 
    0.08576610f, 0.01979496f, 0.02949259f, 0.06004567f, 0.15514605f, 0.00506960f, -0.03146918f, 0.03177019f, 
    0.09941505f, -0.09101903f, 0.12508820f, -0.04855027f, 0.11443858f, -0.39891183f, 0.05605110f, -0.24481241f, 
    0.17386293f, 0.10573093f, 0.02432978f, 0.12840305f, 0.03349842f, -0.11785005f, -0.08317032f, 0.23994567f, 
    0.06939260f, -0.03347909f, -0.11268204f, -0.00785614f, -0.10136877f, 0.11266565f, 0.01962979f, -0.14771439f, 
    0.02436363f, -0.10915397f, 0.14388847f, 0.03316532f, 0.00137800f, 0.10523049f, 0.15658650f, -0.05841521f, 
    0.10309776f, 0.28244615f, 0.23835967f, -0.21705090f, -0.09679089f, 0.03185693f, 0.01219497f, 0.04752406f, 
    0.01847189f, 0.05963290f, -0.00280020f, -0.12927783f, 0.14584348f, 0.08697449f, 0.09848156f, -0.11037216f, 
    -0.04844021f, 0.13261516f, 0.17011471f, 0.04219434f, -0.15762109f, 0.02753903f, 0.00989696f, 0.14107257f, 
    0.10689902f, -0.18784805f, -0.00206567f, 0.06267143f, -0.09488636f, -0.00462247f, 0.03922448f, 0.01608063f, 
    -0.04072107f, -0.08637471f, 0.14612003f, -0.02752567f, 0.00442222f, -0.23040184f, 0.16148891f, 0.03798931f, 
    0.02693098f, 0.26913264f, -0.09756710f, 0.05121511f, -0.04873135f, 0.00619646f, -0.14918704f, -0.13437124f, 
    -0.02783544f, 0.01108694f, -0.02076816f, 0.02154994f, -0.19909710f, -0.06848690f, -0.22404616f, -0.20652846f, 
    -0.12675971f, -0.20483992f, -0.10563413f, -0.06299540f, -0.12611353f, 0.03688659f, 0.06257678f, -0.42531687f, 
    0.07626999f, -0.20428696f, -0.09270415f, -0.01582470f, -0.04244757f, 0.00024032f, -0.07345393f, 0.22027323f, 
    -0.10591865f, 0.06836911f, -0.06553664f, 0.28490362f, -0.17804098f, 0.05608618f, -0.03652145f, -0.12418699f, 
    0.27147335f, -0.39410788f, 0.07121394f, 0.18244369f, 0.18628584f, 0.10517084f, 0.00111698f, -0.16879018f, 
    -0.01430245f, 0.11137361f, -0.25806352f, 0.04763919f, 0.14192359f, 0.06716558f, 0.12434844f, -0.16250564f, 
    -0.34065878f, 0.00500245f, -0.11072093f, 0.05006891f, -0.15674838f, 0.05600964f, 0.14674239f, 0.08530797f, 
    -0.06656444f, 0.13615860f, -0.16393635f, 0.04097532f, -0.07020346f, -0.15354280f, -0.13323075f, 0.00806103f, 
    0.06769478f, 0.13556726f, -0.08584492f, -0.09189375f, -0.03474653f, -0.23676443f, 0.10912364f, 0.13521419f, 
    0.13425368f, 0.11078057f, 0.12476701f, -0.11229388f, 0.08113821f, 0.15489753f, -0.07100222f, -0.16169327f, 
    0.01244166f, -0.12495723f, -0.01051649f, -0.03208664f, -0.13124298f, 0.08832823f, -0.03250656f, 0.06267456f, 
    0.02113021f, -0.08500738f, -0.14496677f, -0.12764999f, -0.09392724f, 0.06018600f, 0.14418654f, 0.09159216f, 
    -0.04114288f, 0.21467699f, -0.11220096f, 0.11227569f, -0.05073980f, 0.10844968f, -0.05695637f, 0.12414103f, 
    0.02348425f, 0.10531954f, 0.07684194f, 0.03864144f, -0.02643710f, 0.10852934f, -0.23547509f, 0.04840498f, 
    0.11465082f, -0.01442075f, 0.13288350f, -0.05769908f, -0.06531399f, 0.12484420f, 0.12096848f, -0.18523847f, 
    0.14477430f, 0.05754339f, -0.10868094f, -0.03130596f, -0.12274811f, 0.02038610f, 0.08906778f, -0.05095210f, 
    0.00934657f, -0.10583697f, -0.12185972f, 0.02619400f, 0.09954208f, 0.14371736f, -0.14890426f, -0.15858187f, 
    -0.13341023f, -0.08570425f, 0.24602647f, 0.08662856f, 0.21612759f, 0.09719609f, 0.15906736f, -0.09200238f, 
    -0.00338294f, 0.03806184f, -0.23469864f, 0.11375880f, 0.09826601f, 0.04902919f, -0.00131810f, 0.07065966f, 
    0.01075206f, 0.04505461f, -0.05936924f, 0.03851407f, 0.17711039f, 0.19258076f, -0.08267193f, -0.15690720f, 
    0.17029323f, -0.08620910f, -0.04446085f, -0.01616143f, -0.02020828f, -0.22522289f, 0.15467411f, -0.13476895f, 
    -0.02312401f, 0.10952643f, -0.00214779f, 0.16215621f, -0.01166239f, 0.07376910f, 0.02442803f, 0.02399126f, 
    0.09056261f, -0.56010121f, -0.09871729f, 0.14060399f, -0.01504345f, 0.11486989f, -0.05686143f, 0.07333028f, 
    -0.00464654f, -0.04129094f, -0.22538488f, -0.13562341f, -0.20454778f, -0.03393866f, -0.11830546f, -0.14624852f, 
    0.03425647f, -0.03285419f, -0.01243299f, 0.02505672f, 0.14474109f, -0.00409020f, -0.00403402f, 0.05143671f, 
    -0.02239973f, 0.15128936f, 0.10538430f, 0.11414668f, 0.08992357f, -0.02683903f, -0.20369188f, 0.21195079f, 
    0.02977577f, 0.22803491f, -0.09087900f, 0.16585173f, 0.15423785f, -0.61076653f, 0.05649147f, -0.02171299f, 
    -0.16434038f, 0.12483435f, 0.17871213f, -0.12858497f, -0.10094463f, -0.07439542f, 0.00177955f, -0.36568677f, 
    0.00157812f, 0.14347374f, 0.08849606f, 0.05017846f, 0.05683181f, -0.04666072f, 0.04929674f, 0.00934121f, 
    0.00958041f, 0.15086417f, -0.04090570f, -0.10170007f, -0.25494412f, 0.03303812f, 0.05693371f, 0.07901325f, 
    0.14249550f, 0.11756366f, 0.06696368f, -0.11986711f, 0.00328106f, -0.03549147f, 0.01518693f, 0.09804080f, 
    -0.01200646f, 0.24102746f, 0.03246372f, -0.18539964f, -0.02857998f, 0.03105085f, 0.03615595f, 0.12480672f, 
    0.06343463f, 0.00214057f, 0.03931630f, -0.09755510f, -0.44082832f, -0.04274134f, -0.02458848f, 0.01566799f, 
    -0.16430898f, 0.14601834f, -0.08796448f, -0.15040204f, 0.06822906f, -0.19223568f, -0.02720726f, 0.05763381f, 
    0.04387651f, -0.15577154f, -0.11535334f, -0.03079194f, -0.08273621f, -0.26323879f, -0.10780366f, 0.01994372f, 
    -0.03045517f, -0.02856983f, -0.13597447f, -0.27141547f, -0.00667271f, 0.06126492f, -0.10586830f, -0.00794296f, 
    -0.03512091f, 0.01463570f, -0.11594001f, 0.02848234f, -0.14970632f, 0.01815778f, 0.03445440f, 0.05755520f, 
    0.01341279f, 0.18465889f, -0.05164456f, 0.24076273f, -0.05619761f, 0.06840709f, 0.06602578f, -0.20085397f, 
    -0.06686589f, -0.15847656f, 0.02172860f, 0.03867225f, -0.06269834f, 0.24079280f, 0.10456982f, 0.07066003f, 
    0.02087106f, -0.13211827f, -0.18812230f, 0.10705041f, 0.10951173f, 0.08974958f, -0.06938470f, -0.05110964f, 
    0.07766833f, -0.13270542f, -0.10658260f, -0.13364990f, -0.06488521f, -0.08794662f, -0.07340027f, 0.00133361f, 
    -0.02486791f, 0.05352297f, -0.41211262f, -0.05283887f, 0.02967515f, -0.07633188f, -0.05453578f, 0.05719962f, 
    0.02945719f, 0.00434281f, -0.00825032f, 0.06184735f, 0.12076231f, -0.00936853f, 0.06919410f, -0.03605081f, 
    -0.06670199f, -0.08640070f, 0.15652414f, 0.20276703f, -0.20575368f, -0.18278854f, -0.25375986f, 0.08599645f, 
    0.09875512f, -0.00149315f, 0.02445747f, 0.00442809f, 0.09917294f, -0.17252611f, 0.03539403f, 0.55895638f, 
    -0.03134448f, 0.01998808f, -0.25541335f, -0.03401900f, 0.10811816f, 0.11528820f, -0.20560503f, -0.14628829f, 
    -0.39558822f, 0.12886497f, -0.02730365f, -0.04163383f, 0.08977214f, 0.05413466f, -0.01729612f, 0.12741412f, 
    -0.16055956f, 0.11464557f, 0.17825280f, -0.10777786f, 0.10147750f, 0.02637200f, 0.20704530f, -0.03434546f, 
    -0.09425215f, 0.05504998f, 0.03548488f, 0.13026632f, 0.14990848f, -0.04651726f, 0.00396392f, -0.00351575f, 
    -0.12563612f, 0.29990369f, 0.03091432f, 0.30098322f, -0.13869627f, -0.05545311f, -0.12003087f, -0.09147982f, 
    0.07790454f, 0.08778852f, 0.03404194f, 0.03237550f, 0.22212997f, -0.12499645f, 0.05805801f, 0.09673953f, 
    0.01724272f, 0.04301272f, -0.04244676f, 0.03450859f, 0.24592206f, -0.37913728f, 0.02195284f, 0.08386048f, 
    -0.02255380f, 0.07368009f, -0.17193274f, -0.14251740f, 0.27618805f, 0.16889954f, 0.12590124f, -0.02154488f, 
    -0.03333883f, 0.03168050f, 0.03201834f, 0.10150574f, 0.02351146f, 0.08803997f, 0.05253825f, 0.03293682f, 
    -0.00950796f, -0.17374131f, -0.08578066f, 0.02748893f, 0.04478357f, 0.12931997f, -0.09672496f, -0.06845316f, 
    0.00742033f, -0.02604544f, 0.03807827f, -0.11091856f, -0.02785995f, 0.17808898f, 0.02687192f, -0.09877721f, 
    -0.30659860f, -0.03073794f, -0.08939259f, -0.16972369f, -0.11941710f, 0.09028562f, -0.03883576f, 0.02593522f, 
    -0.10489422f, 0.15227245f, -0.05523821f, -0.02026908f, -0.20606269f, 0.11275046f, 0.09990124f, -0.04160418f, 
    -0.03995085f, -0.08283035f, 0.01909996f, 0.09341470f, -0.17338239f, -0.01567468f, 0.02589434f, -0.01114066f, 
    0.02365768f, 0.19061315f, 0.28942654f, -0.01801758f, 0.16948168f, -0.10330053f, -0.00640559f, 0.01964289f, 
    0.15938111f, -0.20916048f, 0.10625641f, 0.27910683f, -0.13285598f, -0.12390172f, -0.04534354f, 0.03427843f, 
    0.28428444f, 0.30849102f, -0.15999013f, 0.12307975f, 0.17651157f, -0.16397463f, 0.01515331f, 0.01708277f, 
    -0.04650437f, 0.06368016f, -0.00575051f, 0.06361616f, 0.06731787f, -0.12263769f, -0.12220075f, 0.23457287f, 
    0.15997782f, 0.08437005f, -0.03387859f, -0.05400952f, -0.02398479f, -0.02061695f, 0.17377904f, 0.10447094f, 
    -0.17390588f, 0.20564805f, -0.07609717f, -0.20420581f, -0.11556444f, 0.12642723f, -0.04535528f, -0.12103520f, 
    -0.24256700f, -0.07359963f, 0.02197594f, 0.27365261f, 0.10991643f, -0.06231569f, -0.03707986f, -0.13510607f, 
    -0.20667535f, -0.15097475f, -0.04325369f, -0.04534463f, 0.10400488f, -0.26803866f, -0.10666948f, -0.10505605f, 
    -0.11910582f, 0.02796640f, -0.13875791f, 0.07881625f, -0.00583081f, 0.12390120f, 0.08371547f, 0.08919212f, 
    -0.07146969f, 0.00768178f, -0.09149688f, -0.03278893f, 0.21508035f, -0.00604712f, 0.01094369f, 0.20352627f, 
    -0.17401455f, 0.17656630f, 0.03518262f, 0.09880423f, 0.11486156f, 0.17671311f, -0.07189807f, -0.03852283f, 
    0.00471620f, -0.06441267f, 0.03641815f, 0.07050645f, 0.06455439f, -0.03377487f, 0.03679677f, -0.16751136f, 
    -0.09783074f, 0.00452958f, -0.00323273f, -0.10971245f, -0.24912947f, 0.35492000f, -0.09178577f, -0.15976453f, 
    0.02284379f, -0.13551503f, 0.13597792f, -0.08983280f, -0.18202727f, -0.23349804f, 0.15074144f, 0.05870186f, 
    0.02720693f, 0.09031840f, 0.16111000f, -0.03450094f, 0.13851878f, -0.09441099f, 0.07122701f, -0.08276975f, 
    0.14860694f, 0.11973524f, 0.02511951f, -0.02968010f, -0.07163054f, 0.00964086f, 0.09751030f, 0.00276067f, 
    0.35356426f, 0.23415580f, 0.03519452f, -0.23706628f, -0.02377160f, 0.05401218f, -0.09617020f, -0.05342443f, 
    0.16847324f, -0.09936068f, -0.01669418f, 0.01057305f, -0.02316914f, 0.06343406f, 0.00868868f, -0.00492624f, 
    -0.03934970f, 0.00669673f, -0.00845191f, 0.29629233f, -0.34830573f, 0.13132091f, 0.06162542f, 0.04929037f, 
    -0.01517741f, -0.05062192f, 0.02412211f, -0.14009652f, 0.02424774f, -0.17888734f, -0.03501843f, 0.05901121f, 
    -0.01404054f, -0.06575006f, -0.02531799f, -0.00492458f, 0.15777883f, 0.03808250f, -0.01201235f, -0.03361304f, 
    -0.08552580f, -0.04652131f, 0.07524239f, -0.02524271f, -0.03719667f, 0.27806818f, 0.12084883f, -0.16714266f, 
    -0.04930792f, 0.09829183f, 0.04290658f, 0.00191914f, 0.01301306f, 0.05985892f, 0.25701475f, -0.03360175f, 
    -0.05541236f, -0.05379787f, 0.11675509f, 0.03827182f, -0.01088014f, -0.05885154f, 0.01712375f, 0.13102214f, 
    0.07243948f, 0.13688067f, -0.00985460f, -0.09210648f, -0.06956784f, -0.06734475f, -0.00522420f, 0.01867737f, 
    0.45322093f, 0.13464206f, 0.00318109f, -0.02652602f, -0.10277238f, 0.15849462f, 0.09586179f, 0.04565452f, 
    -0.11083560f, -0.46582380f, -0.07942872f, -0.07892535f, -0.10895035f, 0.03435510f, -0.07880275f, 0.07747924f, 
    -0.05287735f, -0.11131927f, -0.40414712f, -0.33339715f, -0.04281162f, 0.06688246f, -0.02553829f, 0.02951686f, 
    -0.03803705f, -0.05264918f, -0.06287868f, 0.21305838f, -0.01434028f, -0.00738137f, -0.02024225f, 0.12378662f, 
    -0.06274105f, -0.01207012f, 0.09758202f, -0.00045314f, -0.19651146f, -0.06998758f, 0.06684294f, -0.03333543f, 
    0.10998046f, -0.01406095f, 0.08903417f, 0.03433879f, -0.19113529f, -0.07661887f, -0.12740988f, 0.18313123f, 
    0.10290685f, -0.07309493f, -0.11106431f, -0.02369785f, -0.03433168f, -0.02453863f, -0.15115295f, 0.17791393f, 
    -0.00323916f, 0.06135400f, 0.00560074f, -0.06592157f, -0.04855630f, -0.10329517f, 0.16582218f, -0.18222576f, 
    -0.01583323f, -0.09813351f, 0.15832736f, 0.09702043f, -0.12705098f, -0.02261626f, -0.03961743f, -0.04680495f, 
    0.25241980f, -0.14091870f, -0.17505348f, 0.12096629f, -0.06325330f, 0.09044398f, -0.03115628f, -0.08741119f, 
    0.14258252f, -0.03151334f, -0.11128633f, -0.04168716f, -0.05609354f, 0.18885304f, -0.08550350f, -0.07371960f, 
    -0.05480768f, 0.12054877f, 0.40822670f, 0.04074815f, -0.04061351f, -0.11014117f, -0.11383701f, 0.06085688f, 
    0.18477693f, -0.00838402f, -0.16786920f, -0.33863366f, -0.12972085f, -0.28973678f, 0.08543359f, -0.06581151f, 
    0.08017402f, -0.15814404f, 0.02307520f, 0.17642049f, -0.24431011f, 0.05523035f, -0.07292925f, -0.04191567f, 
    0.05486375f, 0.19676438f, 0.02620121f, -0.06694544f, 0.08486450f, -0.06367130f, 0.13140999f, -0.04742040f, 
    0.05898979f, 0.19123009f, -0.14033924f, 0.01072601f, 0.08233026f, 0.06109468f, 0.21298626f, -0.12391974f, 
    -0.04581041f, 0.08734120f, -0.13992164f, 0.11252474f, 0.17596526f, 0.10982857f, -0.10757734f, -0.31894907f, 
    -0.01630650f, -0.07158566f, 0.06091304f, 0.02868535f, -0.03311766f, 0.34036005f, -0.01658596f, -0.00622511f, 
    0.69793642f, -0.07069702f, -0.00856845f, 0.09410191f, -0.09089290f, -0.02586472f, 0.14461412f, 0.00462377f, 
    0.03622042f, 0.01141941f, 0.09204509f, 0.08011200f, 0.08751173f, 0.19857056f, 0.03208935f, 0.03472122f, 
    0.10538067f, 0.02462129f, -0.25912309f, 0.18809780f, -0.06025717f, 0.03184918f, -0.01678603f, 0.09330071f, 
    -0.29856807f, 0.01470452f, -0.11016291f, -0.32031921f, 0.28102636f, -0.18073310f, -0.09111817f, -0.44511557f, 
    0.02815647f, -0.12152179f, -0.15539104f, -0.05578243f, -0.36345533f, -0.33298618f, 0.01633268f, 0.04193954f, 
    0.13945699f, -0.04558093f, -0.03292987f, 0.18547441f, 0.07078256f, -0.22465330f, 0.02660648f, 0.02722100f, 
    -0.04126525f, -0.03638916f, 0.00023906f, 0.03662072f, 0.12609819f, 0.08442308f, -0.07213421f, -0.03406806f, 
    -0.14760403f, 0.04389228f, 0.02813155f, -0.06831960f, 0.04129551f, 0.12125783f, -0.05914324f, -0.20807245f, 
    -0.12807430f, 0.10693643f, -0.03163917f, 0.03721588f, -0.06133500f, -0.13242440f, -0.08338892f, -0.03545920f, 
    -0.58077252f, -0.08501606f, -0.00580167f, 0.08886302f, 0.09061373f, 0.12751043f, 0.11327857f, -0.08751594f, 
    0.01584779f, 0.18799368f, 0.07179401f, 0.12583575f, -0.15431060f, -0.15541489f, 0.05123705f, 0.02556161f, 
    0.03408359f, 0.12483445f, 0.14559974f, -0.27864149f, 0.12957625f, 0.06642140f, 0.08827102f, -0.05927042f, 
    0.04450785f, 0.03256298f, 0.20566569f, -0.01088151f, -0.33837602f, -0.04139474f, -0.01993157f, -0.05827912f, 
    0.00501838f, -0.03472698f, -0.13646854f, -0.13284631f, 0.15613501f, 0.27613914f, 0.29132849f, 0.07045764f, 
    0.03260707f, 0.02816541f, -0.10946403f, 0.05515489f, -0.02267448f, -0.06087939f, -0.11485616f, 0.00317591f, 
    -0.09669448f, 0.06636959f, -0.05274540f, -0.08619289f, 0.08566220f, -0.03752208f, 0.07482775f, 0.20874745f, 
    0.01452227f, -0.04020325f, -0.01931370f, 0.01467850f, 0.13555457f, -0.10510568f, -0.03869580f, -0.44145802f, 
    -0.19464487f, -0.10762079f, 0.02093621f, 0.14443050f, 0.10256981f, 0.09368637f, -0.06320127f, 0.06304480f, 
    -0.33628780f, -0.08308850f, -0.04404780f, 0.16827676f, 0.06137574f, -0.07675347f, -0.06001879f, 0.00432101f, 
    -0.01535192f, 0.41700459f, 0.19319250f, 0.08140040f, -0.13085073f, -0.05041213f, -0.03658632f, 0.02899635f, 
    0.03829730f, -0.09834923f, 0.22284591f, 0.06999245f, -0.08638666f, -0.10968654f, -0.07374809f, 0.16293666f, 
    0.03703290f, 0.03211610f, 0.05983693f, -0.16475090f, 0.06779966f, -0.12961693f, 0.02742346f, 0.03833462f, 
    0.09341668f, 0.05347864f, 0.03174310f, -0.06455946f, -0.08451273f, 0.01272999f, -0.17772406f, 0.21505272f, 
    0.01187767f, 0.03212489f, -0.07149873f, -0.12705871f, -0.00625493f, -0.14757471f, -0.02414843f, 0.06427745f, 
    0.03269784f, -0.23072943f, -0.07856075f, -0.04460419f, 0.06875597f, -0.09883099f, -0.03764935f, 0.04013532f, 
    0.00761165f, -0.01470422f, 0.12326306f, -0.03577186f, 0.09031335f, 0.03089104f, -0.03717788f, -0.07968305f, 
    -0.17871358f, -0.10545768f, 0.04105972f, -0.07001771f, 0.07714519f, -0.12934396f, -0.03338357f, 0.03040411f, 
    -0.26118827f, -0.44318280f, -0.03227061f, 0.07956604f, 0.09728736f, -0.06195446f, -0.02375103f, -0.04200406f, 
    -0.05578948f, 0.14846897f, 0.08547426f, 0.04871767f, -0.25119287f, 0.04445202f, 0.10378481f, 0.10434594f, 
    0.07331675f, 0.06612617f, 0.24417549f, 0.09897953f, 0.09469816f, 0.10703300f, 0.06224645f, -0.09369831f, 
    -0.05039272f, 0.01277467f, -0.11146558f, -0.08809236f, -0.36460814f, 0.21368721f, -0.01430815f, 0.17425437f, 
    -0.05405489f, -0.12889294f, -0.04342601f, 0.08674464f, -0.02070315f, 0.08398860f, 0.08694860f, 0.00635172f, 
    0.06844845f, 0.02718930f, -0.07055674f, -0.07075499f, -0.07498698f, 0.14640057f, 0.13536541f, 0.05536833f, 
    -0.04109780f, -0.19347093f, -0.06837425f, -0.02522946f, 0.19593039f, -0.06534432f, 0.12608369f, -0.09482281f, 
    -0.10515580f, 0.01328184f, -0.01951792f, -0.02678696f, -0.00321217f, 0.01688693f, -0.09941199f, -0.03334783f, 
    0.01555553f, 0.00432820f, 0.02516591f, -0.20266801f, -0.11387938f, 0.06627672f, 0.12249549f, 0.03835739f, 
    -0.23857139f, -0.52729130f, 0.21255261f, 0.17623463f, 0.00239565f, 0.11370777f, -0.06554330f, -0.12632304f, 
    0.08373186f, 0.17427438f, 0.13085231f, -0.00893756f, 0.01283453f, 0.07200015f, -0.02840740f, 0.06681452f, 
    0.06784172f, 0.06755456f, 0.06425127f, 0.11248583f, 0.06908780f, 0.03193918f, 0.12369733f, -0.04975752f, 
    -0.01379159f, 0.13488761f, -0.04234260f, 0.05212957f, 0.14370584f, -0.01590882f, 0.05136839f, -0.05732839f, 
    -0.15243837f, -0.07872871f, -0.00521567f, 0.11864360f, -0.39775491f, 0.14643139f, 0.02065918f, 0.05944666f, 
    -0.29963994f, -0.00121281f, 0.04024342f, 0.09302092f, -0.09199293f, -0.04180878f, -0.08685363f, 0.02332643f, 
    0.04664931f, -0.01435610f, 0.01104863f, 0.10060266f, 0.08553756f, 0.17716761f, -0.16933945f, 0.04028714f, 
    -0.01814147f, -0.00287165f, -0.03232538f, -0.09369280f, -0.02229698f, 0.00265928f, -0.00073799f, 0.19188449f, 
    0.03595563f, 0.00414810f, -0.08660633f, 0.05402904f, 0.07494303f, -0.04006108f, -0.10200562f, -0.01232587f, 
    -0.04596437f, 0.04935871f, -0.04080380f, 0.01948762f, -0.07611667f, 0.04306289f, -0.05395732f, 0.04995028f, 
    -0.10098034f, 0.02905725f, -0.03804141f, 0.02780835f, -0.02070740f, 0.05026425f, -0.04612092f, -0.09759375f, 
    -0.03837585f, -0.06579194f, -0.03318190f, -0.04980687f, 0.01144913f, 0.01560051f, 0.05863221f, -0.01346289f, 
    -0.00220121f, -0.00302376f, -0.04061552f, -0.06436714f, 0.04251041f, -0.07364763f, -0.09989899f, -0.06934588f, 
    -0.06559189f, 0.02856750f, -0.06799783f, 0.06929110f, 0.01906775f, -0.01703697f, -0.08205046f, -0.00229050f, 
    -0.04190714f, -0.06246515f, -0.04758859f, -0.08309629f, -0.00652369f, 0.05982159f, 0.02798275f, -0.00452032f, 
    -0.09568395f, 0.02880918f, -0.01851263f, 0.04374377f, -0.03829026f, -0.05006654f, -0.00693680f, 0.02610945f, 
    -0.04284096f, -0.08258524f, -0.07743178f, -0.06212965f, -0.03079934f, -0.09202520f, -0.01528136f, 0.00185315f, 
    0.04558726f, -0.01358842f, 0.04759961f, 0.01719766f, -0.02145002f, 0.03607019f, 0.01839198f, 0.04220689f, 
    0.06769770f, -0.00952953f, -0.01506781f, 0.05638879f, 0.06057970f, -0.03832226f, -0.00081232f, -0.07426294f, 
    -0.01741113f, 0.03748317f, -0.07260344f, 0.04984390f, -0.04709851f, 0.02295740f, -0.09051678f, 0.05201671f, 
    -0.04287454f, 0.03679484f, 0.03460481f, -0.02280514f, 0.00234490f, 0.00189286f, -0.00338430f, 0.05966150f, 
    0.04255742f, -0.06716684f, -0.06224547f, 0.01449670f, 0.03551468f, -0.00530721f, -0.01194445f, -0.01342530f, 
    0.00007525f, -0.05219429f, -0.07721050f, 0.02577410f, -0.06764472f, -0.06309362f, -0.00969941f, -0.07889613f, 
    -0.06915151f, -0.09186167f, 0.06388923f, 0.01193601f, -0.09223486f, -0.08369771f, -0.04873736f, 0.05142314f, 
    -0.08215077f, -0.06624863f, -0.00671523f, -0.01910204f, -0.09619135f, -0.02292031f, 0.03375734f, 0.05129134f, 
    -0.05479685f, -0.01553019f, -0.00914673f, -0.06799562f, -0.02260251f, -0.06094318f, -0.03885725f, 0.00358565f, 
    0.00539037f, -0.05508659f, -0.01483950f, -0.04390214f, -0.09345767f, -0.04680521f, -0.07878996f, -0.03392170f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08751626f, -0.04682545f, 0.09159346f, -0.00883845f, -0.15333374f, 0.20628385f, 0.04388319f, 0.15442342f, 
    0.12105082f, 0.03729814f, -0.12890896f, 0.07641579f, -0.02193057f, 0.14317997f, 0.06699141f, -0.06442598f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25459871f, -0.00415300f, 0.09115124f, 0.08248596f, -0.30730918f, 0.10595155f, 0.06047054f, -0.06823368f, 
    0.18547970f, 0.47110862f, -0.08106325f, -0.22290370f, -0.00248497f, -0.04135423f, -0.09420287f, 0.08918239f, 
    -0.29113555f, -0.22343649f, -0.43296313f, 0.09679902f, -0.09439506f, 0.14096712f, 0.15172400f, -0.05287328f, 
    -0.26629436f, -0.02944687f, 0.06312915f, 0.07093658f, -0.22355655f, 0.33774638f, 0.16148278f, -0.22828321f, 
    0.05472387f, -0.13837177f, 0.10251378f, 0.05142045f, 0.07268025f, -0.37734643f, 0.04459444f, -0.02168931f, 
    -0.10793693f, 0.49871024f, -0.06914132f, 0.32788530f, -0.28328541f, 0.07898369f, -0.06793912f, -0.15694864f, 
    -0.08033226f, -0.07090551f, 0.31823334f, 0.63798875f, -0.02689746f, -0.03934745f, 0.17038596f, -0.13761197f, 
    -0.22842464f, 0.24642913f, 0.28673902f, -0.02124470f, -0.08064479f, -0.26555371f, -0.00778976f, 0.04434603f, 
    0.13586876f, 0.14500713f, 0.04307854f, 0.66788894f, -0.30178556f, -0.03740093f, 0.01842470f, 0.25493950f, 
    -0.24086797f, -0.18953326f, 0.36569992f, -0.22483490f, -0.20008419f, 0.09285773f, -0.24996924f, 0.20431152f, 
    0.26287970f, -0.21259487f, -0.36469543f, 0.03345003f, -0.19335787f, -0.02264412f, -0.11281072f, 0.12139927f, 
    0.40471566f, 0.27751768f, 0.24758652f, -0.49731353f, 0.25634912f, -0.00147608f, -0.15331061f, -0.02262304f, 
    0.30140552f, 0.01910922f, 0.51264936f, 0.27565321f, 0.15914491f, 0.23066236f, -0.05646297f, -0.03061657f, 
    0.50565034f, -0.35159513f, -0.24048334f, -0.08715769f, -0.15826592f, 0.07210565f, -0.24637544f, -0.20220873f, 
    0.10001055f, 0.08058614f, -0.11366846f, -0.68718404f, -0.25358704f, -0.07813982f, 0.14191358f, 0.10624088f, 
    0.00485713f, -0.07959241f, 0.31068212f, 0.15304348f, -0.27746087f, 0.17579760f, -0.06171581f, 0.18058440f, 
    -0.31141710f, -0.15200928f, -0.00345724f, 0.03034932f, -0.02353694f, 0.22497523f, -0.21654493f, 0.10200337f, 
    0.56432372f, 0.07460702f, -0.47259772f, 0.45947975f, -0.09085183f, -0.11704259f, 0.15033318f, 0.07852987f, 
    0.16687480f, -0.05017188f, -0.13147846f, -0.08416978f, -0.10678878f, -0.10761178f, -0.11405322f, -0.12389305f, 
    -0.18262121f, -0.10017926f, -0.01004392f, -0.14782894f, -0.03621560f, -0.11696181f, -0.18094319f, -0.22350928f, 
    -0.23574226f, -0.20504928f, -0.09480022f, -0.21259852f, 0.29941678f, 0.48274747f, -0.19248965f, -0.25433633f, 
    0.31997693f, -0.35471386f, -0.10994317f, 0.07922280f, 0.00387379f, 0.37107596f, -0.00009805f, 0.20977533f, 
    -0.08732081f, -0.20588084f, 0.41143796f, -0.26063663f, -0.41580975f, 0.21031682f, -0.02192757f, 0.22262773f, 
    0.03095112f, -0.29983282f, -0.19886042f, 0.25067252f, -0.08882534f, -0.08658977f, 0.15736675f, 0.10554194f, 
    0.43690649f, 0.12151112f, -0.11237549f, -0.08944733f, 0.13604304f, 0.28574133f, 0.13739321f, 0.28643885f, 
    0.11461358f, -0.11662558f, -0.10942469f, -0.46041149f, -0.27620655f, 0.09640016f, 0.24876270f, 0.20621417f, 
    -0.15186682f, -0.12965900f, 0.48907098f, 0.06985597f, -0.07516383f, 0.16898279f, 0.05125692f, -0.09480240f, 
    -0.00159508f, -0.47487456f, 0.07987343f, 0.33336464f, 0.13186812f, -0.37592500f, 0.29616681f, -0.00455561f, 
    0.12585041f, 0.18505204f, -0.32734555f, 0.46577266f, -0.03224583f, 0.11761037f, 0.43432918f, 0.19733897f, 
    -0.45990711f, -0.26267162f, 0.21327215f, -0.13309018f, 0.10850177f, -0.25017586f, -0.15951414f, 0.21985112f, 
    -0.13226816f, 0.08756027f, 0.03789449f, -0.00048577f, -0.12252399f, 0.18702359f, 0.31483015f, 0.06006119f, 
    0.27092302f, 0.09634563f, -0.03886752f, 0.28866386f, -0.23388138f, -0.23860167f, 0.13395569f, 0.09877216f, 
    -0.35761169f, 0.12245531f, -0.31343287f, 0.29314384f, 0.27437386f, 0.02157886f, 0.17791973f, -0.13007906f, 
    -0.26685598f, 0.13543677f, 0.39544758f, -0.09540397f, 0.13934954f, 0.27256370f, -0.19204687f, -0.08838892f, 
    0.06217179f, -0.06002220f, 0.30769783f, 0.16930500f, -0.11134965f, -0.09169664f, 0.25233623f, -0.27100766f, 
    -0.03987094f, -0.62024909f, 0.09330069f, 0.36045647f, 0.13352601f, -0.39942035f, 0.20687290f, 0.08208755f, 
    0.07419175f, -0.01692557f, -0.15838683f, -0.12668532f, -0.00578919f, -0.13145065f, -0.09249213f, 0.13998502f, 
    -0.06312424f, -0.16192520f, -0.04299572f, -0.08985040f, -0.17976415f, -0.02341789f, -0.18970987f, 0.00242564f, 
    -0.09256383f, -0.08953931f, 0.19795105f, 0.38898149f, -0.21244298f, -0.20032121f, -0.15107369f, 0.25385010f, 
    0.05128048f, 0.21934803f, -0.36316532f, 0.19505633f, 0.13844477f, 0.15908787f, 0.01053504f, 0.22243477f, 
    0.45814040f, -0.18545109f, -0.11384974f, -0.05226329f, 0.46057728f, 0.36407590f, -0.04719322f, -0.07591777f, 
    0.29780585f, -0.17648806f, 0.23040538f, 0.17197084f, -0.00809384f, -0.07370745f, -0.36584282f, 0.00256953f, 
    -0.19294052f, 0.04989079f, 0.42765433f, 0.00361164f, -0.33506799f, 0.27351150f, -0.04037505f, -0.19004743f, 
    0.39802071f, -0.51636547f, -0.00757722f, 0.26826793f, 0.01776549f, -0.21172535f, 0.11276634f, 0.13841937f, 
    0.43076548f, -0.12076446f, 0.08928698f, -0.20029472f, 0.20167008f, 0.29096109f, 0.31736138f, -0.24227619f, 
    0.34378240f, -0.19344801f, 0.20057650f, -0.00520345f, 0.15506636f, -0.29220071f, 0.00949555f, 0.14693394f, 
    -0.45746759f, -0.19252032f, 0.09356876f, 0.18204615f, 0.08491769f, 0.32033759f, 0.00203140f, -0.20562884f, 
    -0.39883882f, 0.09654613f, -0.13312510f, -0.07844482f, 0.10459819f, 0.37719372f, 0.25585759f, -0.07174742f, 
    0.16868311f, 0.23018113f, -0.33964095f, -0.27722105f, 0.01855269f, -0.22278540f, -0.08940084f, 0.16793685f, 
    0.31870791f, 0.23728383f, 0.31239045f, -0.06077986f, -0.00439281f, -0.09280197f, 0.07888182f, 0.14814065f, 
    -0.19884336f, 0.14690346f, 0.13824350f, 0.15188971f, -0.06874350f, -0.03998106f, -0.02194026f, -0.22124097f, 
    -0.09932076f, -0.25148618f, -0.25280407f, -0.20665340f, 0.00686023f, 0.19190158f, -0.05391070f, 0.19348890f, 
    -0.06378163f, -0.11717318f, 0.50806016f, 0.10531149f, -0.04077629f, 0.20903009f, -0.18868977f, 0.05678682f, 
    -0.22958322f, 0.37640768f, 0.31538013f, -0.18121383f, -0.30239704f, 0.17527823f, -0.18586418f, -0.00616327f, 
    -0.20836057f, -0.09709077f, 0.38912809f, 0.27177343f, -0.23799209f, -0.25359383f, 0.02020429f, 0.35807979f, 
    -0.25928444f, 0.13664433f, -0.01465719f, 0.25551555f, -0.00293973f, -0.25597471f, -0.14959511f, -0.06649814f, 
    0.20952949f, -0.18101481f, -0.05541905f, 0.38534126f, -0.11517768f, 0.02257518f, 0.16982943f, -0.03332345f, 
    0.00377626f, 0.29156691f, 0.19143026f, -0.13964047f, 0.03583763f, -0.20233649f, -0.46225092f, 0.15759481f, 
    0.24369159f, 0.16706568f, -0.21664764f, -0.18542174f, -0.16650274f, -0.19846642f, 0.03420125f, 0.23560691f, 
    -0.13907972f, -0.03360683f, 0.26598692f, -0.31272617f, 0.00539618f, 0.27893671f, 0.16855805f, -0.14157484f, 
    -0.12877412f, 0.24865264f, -0.23749039f, -0.11752281f, 0.09454680f, -0.27038053f, -0.10246502f, -0.26513872f, 
    -0.21810630f, -0.00866737f, 0.01133577f, -0.09407036f, -0.26144183f, 0.08107903f, -0.06221664f, 0.21002650f, 
    -0.47254845f, -0.25820944f, 0.11895499f, 0.12721205f, 0.01731412f, -0.04223904f, -0.04471356f, -0.04146056f, 
    0.01294490f, 0.08464330f, -0.34148198f, 0.49960783f, 0.27563995f, 0.11381332f, -0.19168058f, 0.18300135f, 
    0.04403738f, 0.17477041f, -0.36726314f, -0.09185629f, -0.00014047f, 0.24621886f, -0.32452479f, 0.24944171f, 
    -0.04530127f, -0.10493075f, -0.29422417f, 0.08962454f, -0.10891184f, 0.48120713f, 0.14929414f, -0.22231892f, 
    -0.34398028f, -0.25008497f, -0.03279050f, -0.26921403f, 0.28272283f, -0.21636561f, 0.02383825f, 0.27774799f, 
    -0.21944633f, -0.29489404f, 0.27496970f, -0.14369106f, -0.02588824f, 0.33422568f, 0.10224126f, -0.23134486f, 
    -0.20961334f, -0.15325701f, 0.34869677f, -0.06418139f, 0.13225709f, 0.01178254f, -0.21408351f, -0.00206890f, 
    -0.26811087f, 0.26843739f, 0.08226693f, 0.12931432f, 0.14591946f, -0.00105205f, 0.27343407f, 0.10455724f, 
    -0.33278066f, 0.08726715f, 0.12161886f, 0.10633841f, 0.36341593f, 0.20802505f, 0.36338204f, 0.03621376f, 
    -0.12677252f, -0.21794146f, -0.14908867f, -0.21261904f, 0.20747937f, 0.00994727f, 0.17676537f, 0.00992809f, 
    -0.13211331f, -0.08763406f, 0.29999700f, 0.02005085f, 0.07683532f, -0.27394566f, -0.44978428f, 0.03575579f, 
    -0.13611190f, 0.18065064f, -0.16572717f, 0.23535362f, 0.42716619f, 0.26093349f, 0.13534647f, 0.15824932f, 
    0.51227975f, -0.01517498f, -0.10755629f, -0.07821029f, 0.07715049f, 0.13263319f, 0.02849683f, -0.22483762f, 
    -0.43310615f, -0.03785924f, 0.15975441f, 0.19912364f, -0.35179886f, -0.14041235f, 0.29829782f, -0.18281949f, 
    0.03105854f, -0.17741397f, 0.13125080f, -0.06511768f, -0.23004125f, 0.17468865f, -0.21866688f, -0.17367809f, 
    -0.17035727f, -0.05956172f, -0.22815472f, -0.13583632f, 0.08106281f, -0.12894866f, 0.09160355f, -0.23245955f, 
    -0.46957555f, 0.09363344f, -0.21043237f, -0.11254483f, 0.16609164f, -0.29657695f, -0.12341218f, 0.05945632f, 
    0.29526430f, 0.27312279f, 0.08935995f, 0.17159066f, -0.25409669f, 0.35549408f, 0.06041155f, 0.13443942f, 
    -0.00022161f, -0.18663992f, -0.06700243f, -0.09431139f, 0.37357512f, -0.05189241f, 0.17255248f, -0.01961699f, 
    -0.34411925f, -0.27741563f, 0.11350897f, -0.22634424f, 0.28476590f, -0.04736125f, 0.27621323f, -0.12870473f, 
    -0.07489634f, -0.11564052f, -0.05013129f, -0.17418249f, -0.14145347f, 0.01322012f, 0.11949665f, -0.18862279f, 
    -0.14236301f, 0.00761878f, -0.13794784f, 0.12682199f, -0.09364768f, -0.19853359f, -0.19439781f, -0.00324437f, 
    0.06473412f, 0.18163209f, 0.16473389f, -0.26707909f, 0.04747723f, -0.15885173f, -0.01509737f, -0.27489752f, 
    -0.27744180f, -0.10705563f, 0.13029847f, 0.07508327f, -0.21464851f, -0.31781161f, -0.11753106f, -0.15473019f, 
    0.10445347f, 0.08933821f, -0.19486658f, -0.11231424f, -0.40518102f, -0.02883523f, 0.29560456f, 0.14832510f, 
    0.22826105f, -0.06658980f, 0.03768026f, 0.43646067f, 0.21356151f, -0.29824948f, -0.28467441f, 0.08267017f, 
    0.03617376f, 0.15117614f, 0.42951739f, 0.01390066f, -0.46825552f, -0.12559794f, 0.39086601f, 0.08654343f, 
    0.22670394f, -0.12348712f, -0.05811515f, -0.06928924f, 0.07817829f, -0.18693034f, -0.12768729f, -0.09442543f, 
    -0.29227039f, -0.18340279f, 0.21766001f, 0.15966658f, -0.39539850f, -0.28442574f, 0.02771351f, 0.10373817f, 
    0.06616075f, 0.02997347f, 0.03725760f, 0.17001598f, -0.01527478f, 0.17360573f, -0.10367906f, -0.07533490f, 
    -0.24552789f, 0.01364112f, -0.07218096f, 0.05535620f, -0.02165988f, -0.10291016f, 0.03458679f, -0.04078373f, 
    -0.12662593f, -0.16751471f, 0.04615846f, -0.05014816f, -0.07375002f, -0.11906525f, 0.01110691f, 0.11429748f, 
    -0.25210202f, 0.17178388f, 0.33576235f, 0.25248766f, -0.12194300f, -0.38986230f, 0.18129933f, -0.23908928f, 
    -0.42987788f, -0.44234014f, 0.38471511f, -0.31305873f, -0.16468887f, -0.05805776f, 0.24405262f, -0.05387050f, 
    0.28690135f, 0.07126436f, 0.20699342f, 0.07851005f, 0.56329912f, 0.02995659f, 0.10136499f, -0.12352950f, 
    -0.22286166f, 0.33860290f, -0.48598447f, -0.13705425f, 0.50612044f, -0.29906186f, -0.18120812f, 0.17701858f, 
    0.29564711f, -0.13662624f, 0.14885284f, 0.27878180f, 0.14814992f, 0.07018217f, 0.30640984f, 0.14751036f, 
    0.00247994f, -0.30015048f, 0.23947977f, -0.08925472f, -0.22475013f, -0.08886629f, -0.10115398f, 0.05471325f, 
    -0.30338103f, -0.19511527f, -0.18914783f, -0.03068031f, 0.35823447f, 0.16191076f, 0.17154203f, -0.30623665f, 
    -0.27898672f, 0.03380773f, 0.27723408f, -0.22055946f, 0.32569700f, -0.01984476f, 0.24442142f, -0.15313211f, 
    -0.55293447f, 0.17558870f, 0.39816210f, -0.03120440f, -0.14660141f, -0.07893198f, -0.46846572f, -0.02305585f, 
    -0.09220210f, 0.11115018f, -0.19087915f, 0.23530386f, 0.38658431f, 0.24686277f, 0.23717117f, 0.11879883f, 
    -0.58154213f, 0.19926445f, 0.25544786f, 0.03765767f, 0.16516897f, 0.08929955f, 0.34381527f, 0.06648326f, 
    -0.34342265f, 0.00773153f, -0.10479422f, 0.02380789f, -0.04294479f, -0.07757059f, 0.24625263f, -0.21825695f, 
    0.51735926f, 0.08109106f, -0.23540989f, -0.31479576f, 0.06372074f, 0.22445101f, 0.08922278f, 0.13942359f, 
    0.37618583f, -0.26250118f, 0.14961921f, 0.09702887f, 0.17818661f, -0.22032878f, -0.25511810f, -0.04319918f, 
    0.19249381f, -0.18024054f, -0.48841831f, -0.21327339f, -0.03886683f, 0.42454022f, 0.08584404f, -0.30151007f, 
    -0.10662352f, 0.06414449f, -0.12632301f, 0.13336907f, -0.29584503f, -0.25079280f, -0.00944331f, 0.03969112f, 
    -0.24486458f, -0.02094765f, -0.15655969f, 0.34507209f, 0.13315611f, -0.34690404f, -0.03848645f, 0.10572266f, 
    -0.32556653f, 0.25801671f, -0.10151085f, 0.35120600f, 0.07654368f, 0.01245049f, -0.14023022f, -0.18534918f, 
    0.02616279f, 0.19809772f, -0.15206164f, -0.44178686f, -0.23683493f, 0.03521118f, 0.44427386f, -0.03655642f, 
    0.61106616f, -0.50643986f, 0.19802691f, -0.06262326f, -0.00564538f, 0.10211077f, 0.27800044f, 0.09795260f, 
    -0.02158895f, -0.17778455f, 0.10668468f, 0.17888942f, -0.10856093f, -0.26388153f, -0.34662119f, 0.16507298f, 
    0.25525418f, 0.19789053f, 0.19938724f, -0.04379413f, -0.15056531f, 0.38521090f, -0.08706301f, 0.08764979f, 
    -0.56543195f, -0.13664226f, 0.46158764f, -0.01940962f, 0.41565320f, 0.37483847f, -0.15591636f, -0.27535287f, 
    -0.35863709f, -0.23241141f, 0.06299178f, 0.26123354f, 0.39242905f, 0.14829004f, 0.24340911f, -0.17082584f, 
    0.02382976f, -0.05978417f, -0.05589648f, 0.36522734f, -0.24683388f, 0.09704626f, 0.22743714f, 0.19364518f, 
    0.22216339f, -0.20727512f, -0.01503961f, 0.35221559f, -0.11457080f, -0.20543668f, -0.13819180f, -0.05265517f, 
    -0.22387794f, -0.13827735f, -0.11217966f, 0.40018404f, 0.45942619f, 0.05691570f, 0.38547543f, -0.13232532f, 
    -0.21902998f, -0.26975936f, 0.13396409f, 0.39879659f, 0.22753616f, -0.14914906f, -0.05750827f, -0.06385896f, 
    -0.36221030f, 0.17846884f, 0.49143547f, -0.01917767f, -0.08163574f, 0.42938024f, -0.32391474f, 0.03784692f, 
    0.24174339f, 0.37541744f, 0.02368430f, 0.21026748f, -0.06923503f, -0.13116139f, 0.10246558f, 0.01244687f, 
    0.41241270f, 0.02774588f, 0.58634764f, 0.34403634f, -0.31531835f, 0.00090706f, 0.24822085f, -0.28158697f, 
    0.09853137f, -0.21746701f, -0.19049390f, -0.23396046f, 0.03643624f, 0.22578557f, -0.14413007f, 0.12943801f, 
    -0.29298663f, -0.00636508f, -0.18165402f, 0.04222471f, 0.35369936f, 0.21972319f, -0.26485133f, -0.34963247f, 
    -0.14993103f, -0.15707606f, 0.39124218f, 0.16306959f, 0.26876915f, 0.01222757f, 0.16146791f, 0.17032963f, 
    -0.20494565f, -0.14529313f, -0.19899854f, -0.10907608f, 0.23607258f, 0.11410076f, 0.01028660f, 0.05949770f, 
    0.44583499f, -0.09466758f, 0.05692277f, -0.00832843f, 0.18360442f, -0.20774660f, -0.20616844f, 0.15522568f, 
    0.11032917f, -0.08653002f, 0.17864256f, 0.17834866f, -0.07385658f, 0.27906469f, -0.01706661f, -0.10136864f, 
    0.01618656f, 0.26433432f, -0.00840001f, -0.08859818f, -0.19477522f, -0.15455841f, 0.34296468f, 0.07209003f, 
    0.19190790f, -0.02535248f, 0.13486055f, -0.16720593f, 0.11520369f, 0.07196486f, -0.22179800f, -0.26815966f, 
    0.08559553f, -0.01631429f, 0.03658134f, -0.10435694f, -0.17010975f, -0.24971728f, -0.12206180f, 0.13470152f, 
    -0.14668784f, 0.10334828f, 0.28908589f, 0.10847154f, -0.19388634f, 0.10802989f, 0.30373868f, -0.42014652f, 
    0.28763276f, -0.28965646f, -0.10103913f, 0.15671173f, 0.37771648f, -0.21944085f, 0.14894396f, -0.12391949f, 
    -0.28873816f, -0.12964951f, -0.37516880f, -0.08275233f, -0.08983228f, 0.22953059f, 0.02298613f, 0.16360241f, 
    0.54816979f, -0.39355338f, 0.11876761f, 0.03494613f, 0.37012652f, -0.22076231f, -0.40412033f, 0.02414059f, 
    -0.12945417f, -0.14602774f, -0.22414863f, -0.12677321f, 0.14199975f, -0.31168932f, 0.00241643f, -0.20088127f, 
    0.14649291f, -0.26227424f, -0.20452432f, -0.12671870f, -0.14122133f, 0.12282711f, 0.07654875f, -0.21642333f, 
    -0.15241180f, -0.18641917f, 0.39908862f, 0.34094879f, -0.11803907f, -0.39081910f, -0.02353058f, 0.21341300f, 
    0.14264683f, 0.06213545f, 0.09502877f, 0.19791473f, -0.20410790f, -0.39503413f, 0.23904115f, -0.03369599f, 
    0.16365343f, -0.04584799f, -0.43441141f, 0.10240461f, 0.03067289f, -0.08625469f, -0.12558329f, 0.11300316f, 
    0.41214189f, 0.27270558f, 0.02118420f, -0.29295799f, 0.47288728f, 0.05815935f, -0.19401498f, 0.13691117f, 
    0.07129695f, -0.04680772f, -0.24889228f, -0.45727429f, -0.25432837f, -0.07676580f, 0.15306893f, 0.20746776f, 
    -0.24328776f, 0.08718910f, 0.11335728f, -0.29521045f, -0.07079322f, 0.40570286f, 0.07781562f, -0.02055537f, 
    0.24102262f, 0.22789440f, 0.17596197f, 0.14290641f, -0.21377458f, -0.12813777f, 0.26452941f, -0.18150339f, 
    0.08834717f, -0.21785571f, 0.14003126f, 0.15048291f, -0.08387091f, 0.19747977f, -0.26614630f, -0.21238102f, 
    -0.30661675f, 0.21400031f, 0.00928035f, -0.05676120f, 0.28430036f, -0.06370656f, -0.41655999f, -0.11086923f, 
    -0.18983217f, -0.07884589f, -0.16052142f, 0.18612193f, 0.35038653f, 0.42764294f, 0.31916782f, -0.03025934f, 
    0.05552378f, 0.11445514f, -0.16168748f, -0.05768351f, 0.37671742f, 0.06344643f, 0.32754651f, -0.12097711f, 
    0.12914748f, -0.14236212f, 0.27975383f, 0.26966169f, 0.08684549f, 0.05488676f, -0.23648502f, 0.20957412f, 
    -0.16526078f, -0.00922520f, 0.27488935f, 0.33205768f, 0.27499253f, -0.02553496f, -0.20380852f, 0.07243161f, 
    -0.29269865f, 0.18202171f, -0.05021835f, 0.17391436f, -0.31071034f, 0.18845139f, 0.11140148f, 0.22319531f, 
    0.04396213f, -0.19289494f, -0.43644002f, 0.17111421f, 0.20541027f, 0.15405749f, -0.13640006f, -0.23788209f, 
    -0.09471467f, 0.32877114f, 0.07279227f, 0.08829874f, 0.25721347f, 0.33655694f, -0.18487523f, -0.02992676f, 
    0.16114286f, 0.25784996f, 0.20380358f, -0.21887660f, -0.12220389f, -0.28580269f, -0.11667924f, 0.19193643f, 
    0.02111652f, 0.32357684f, -0.28763387f, 0.16000549f, 0.00469951f, 0.00498517f, 0.17244151f, 0.14550185f, 
    0.20909932f, -0.22073506f, 0.19105130f, -0.16544585f, -0.09566797f, 0.37794659f, -0.02168891f, 0.05578414f, 
    -0.01644391f, -0.11724783f, 0.29775771f, -0.32324433f, 0.37423164f, 0.03344541f, -0.10428956f, 0.12121440f, 
    -0.13004811f, -0.05442621f, 0.26110443f, 0.41837439f, -0.33095133f, -0.38185441f, -0.11339293f, -0.13806401f, 
    0.02384793f, 0.24258465f, -0.09001572f, 0.27491409f, 0.33034804f, 0.29387715f, -0.23010337f, -0.08010314f, 
    0.21632308f, -0.21799985f, 0.34138933f, 0.12453348f, -0.29441196f, -0.09307082f, 0.30244353f, -0.02549635f, 
    0.03001017f, 0.31241336f, 0.01414964f, -0.20235342f, -0.13239132f, -0.37431189f, 0.04081621f, -0.04435375f, 
    0.25546780f, 0.16109701f, -0.54429829f, 0.23120299f, 0.11947088f, 0.02148490f, 0.15909457f, -0.22094332f, 
    0.36852235f, -0.29278702f, 0.09239849f, 0.49528092f, 0.25259060f, 0.12278596f, -0.37939265f, -0.00271268f, 
    -0.29095042f, -0.15191381f, 0.15411775f, 0.17915852f, 0.35705322f, 0.05959025f, -0.24901687f, -0.26835155f, 
    -0.10669836f, 0.21569598f, 0.34835321f, 0.40348911f, 0.24397177f, -0.14499287f, -0.28812706f, -0.02839962f, 
    0.49373230f, -0.08652106f, -0.14807285f, -0.03759349f, -0.37735185f, -0.27233762f, 0.16514845f, 0.29861808f, 
    0.49447513f, -0.31214684f, -0.13712713f, -0.31749707f, 0.14510164f, 0.15663920f, -0.20159912f, -0.14647938f, 
    0.45180997f, 0.06372292f, 0.25244522f, -0.23642977f, -0.23621182f, 0.32481012f, -0.16881873f, 0.15582174f, 
    0.24686252f, 0.12328830f, 0.00185781f, -0.11574490f, 0.28930691f, -0.17680611f, 0.03437188f, -0.23270819f, 
    -0.00947691f, -0.12428581f, -0.07157216f, -0.18471907f, -0.06098974f, -0.12151534f, -0.35653788f, -0.01161617f, 
    -0.39190105f, 0.12077367f, 0.17017871f, 0.10357360f, 0.29037818f, 0.31028023f, 0.27368978f, -0.19097766f, 
    -0.06716012f, -0.20677410f, 0.24995501f, -0.44459948f, -0.09837300f, -0.14393769f, 0.06012534f, 0.14306992f, 
    -0.01117910f, 0.24310209f, -0.20294306f, -0.23854311f, 0.38473225f, -0.07402951f, -0.04361941f, 0.21560371f, 
    0.16040652f, 0.11690614f, 0.51221102f, -0.40564376f, -0.21651766f, 0.07441844f, -0.06369562f, 0.32742038f, 
    0.13274617f, -0.26826531f, -0.32786396f, 0.29743415f, 0.13996354f, -0.06931940f, 0.10450479f, 0.13549043f, 
    -0.23480973f, 0.20342764f, 0.13435471f, -0.55149734f, 0.25752884f, -0.03751785f, -0.06712832f, -0.28967699f, 
    -0.12205550f, -0.87338471f, 0.12291119f, -0.41899931f, 0.17527276f, 0.29445153f, 0.22978052f, 0.01458231f, 
    -0.03424081f, -0.06930247f, 0.36962506f, 0.02505955f, -0.15455379f, -0.23287345f, -0.02063902f, 0.00752625f, 
    -0.14146794f, 0.19864997f, -0.33910283f, 0.33403182f, 0.20056160f, 0.23024413f, -0.10282702f, 0.18533553f, 
    -0.24174860f, 0.12098583f, -0.50420773f, -0.01923929f, -0.03791440f, -0.32043388f, 0.24413809f, 0.03227255f, 
    0.14982264f, 0.13850026f, 0.36026159f, 0.17634901f, -0.05188489f, 0.00300192f, -0.18217207f, -0.17616339f, 
    -0.12004019f, -0.07773538f, 0.11302942f, 0.31299633f, -0.31816804f, -0.14748453f, -0.19056393f, 0.17123042f, 
    -0.17610976f, 0.15015630f, 0.33880714f, -0.11104934f, 0.00359755f, 0.12052957f, -0.24640258f, 0.19528891f, 
    -0.18577196f, -0.00648312f, 0.03663726f, 0.13452142f, 0.02120507f, -0.16169071f, 0.18067326f, -0.35880524f, 
    0.39880806f, 0.13899188f, -0.28249949f, 0.38723171f, -0.26546240f, -0.21479093f, 0.24343605f, -0.19503713f, 
    0.37636071f, 0.09232279f, -0.22828475f, -0.16256925f, 0.02048438f, 0.21956435f, -0.21615493f, -0.20694117f, 
    -0.15076947f, 0.16401926f, 0.31233409f, -0.21220061f, 0.48232672f, -0.17813751f, 0.29685527f, -0.02146093f, 
    -0.16156311f, 0.19070946f, -0.11037919f, -0.03055735f, -0.09876843f, -0.42801780f, 0.03176837f, 0.05038266f, 
    0.17347048f, 0.41582906f, -0.16161603f, 0.33112460f, 0.03808254f, -0.58498585f, 0.20968921f, 0.18223414f, 
    -0.11617296f, -0.04405778f, -0.04104984f, -0.22466217f, 0.45996523f, 0.25864390f, -0.21374728f, -0.05597477f, 
    0.22781511f, -0.11087044f, 0.09240724f, 0.25858718f, 0.13307892f, -0.06353135f, 0.30930623f, -0.23368181f, 
    -0.37522000f, -0.04028091f, -0.18160623f, -0.10661780f, 0.07584646f, 0.39054826f, -0.23850448f, -0.10636967f, 
    -0.10226563f, -0.53991598f, -0.04369725f, -0.19549449f, -0.27909833f, 0.15797545f, 0.20618071f, -0.02019665f, 
    0.30198079f, 0.21219821f, 0.21256809f, -0.03097455f, -0.13774689f, -0.18531170f, 0.02312662f, -0.23385565f, 
    0.12140146f, 0.38419417f, 0.12484587f, 0.03025905f, 0.33586547f, -0.26369992f, 0.09785990f, -0.23498745f, 
    -0.51243824f, 0.21216629f, -0.14000049f, 0.27048957f, 0.38567933f, 0.13526292f, -0.36038640f, -0.34050396f, 
    0.12338310f, -0.20713650f, -0.09764323f, -0.13028400f, 0.44442767f, 0.05854901f, 0.26069185f, 0.13223526f, 
    -0.11966830f, -0.19323742f, -0.37794721f, 0.21877198f, 0.25906584f, -0.18066582f, -0.28627813f, -0.27721351f, 
    0.20528741f, -0.17216380f, 0.12062091f, 0.49794546f, 0.29321623f, 0.38132831f, -0.01036231f, 0.12990010f, 
    -0.10110120f, 0.25307459f, 0.53888172f, 0.37709427f, -0.15458642f, -0.22832887f, -0.13274397f, -0.09156351f, 
    -0.33763260f, -0.08665889f, -0.13208525f, 0.09837847f, 0.26540175f, 0.19590476f, 0.13614069f, 0.20782261f, 
    0.35915944f, -0.17141636f, 0.02982549f, -0.10256852f, 0.34713027f, 0.16708380f, 0.12391023f, 0.03573953f, 
    0.19189970f, -0.19085029f, -0.22992107f, -0.15894949f, -0.12641205f, 0.13325976f, 0.36301333f, 0.02726397f, 
    0.15242293f, -0.14170450f, 0.27559584f, -0.12905963f, 0.02454193f, -0.10078499f, 0.03265230f, -0.23780894f, 
    -0.50321895f, 0.18709104f, 0.27172735f, -0.25170612f, 0.10292855f, 0.25803569f, 0.27427429f, 0.00319311f, 
    0.37333429f, 0.05946766f, -0.01232922f, -0.26793772f, 0.07392881f, 0.29761884f, -0.14383805f, -0.18856721f, 
    0.29535675f, 0.21214214f, 0.38799635f, -0.19607855f, 0.41532567f, -0.03992639f, -0.08400031f, 0.19313978f, 
    0.18727879f, 0.24384157f, 0.02797581f, -0.29170805f, -0.07560884f, -0.52810049f, -0.33136284f, -0.08335825f, 
    -0.77966124f, 0.03835649f, 0.42919001f, 0.24823065f, 0.33325735f, 0.11637171f, 0.33375880f, -0.13666539f, 
    -0.56794637f, 0.04215471f, -0.16054812f, 0.03937954f, -0.22362280f, 0.03421223f, 0.03986303f, 0.13155149f, 
    0.38719466f, 0.00910045f, 0.11851224f, 0.53002858f, -0.20794204f, 0.14820966f, -0.14822002f, 0.15640424f, 
    -0.18798293f, 0.15791631f, -0.10631788f, -0.19390547f, -0.31546280f, 0.06323922f, -0.01144051f, -0.05540186f, 
    -0.17110151f, -0.02326945f, -0.13100059f, -0.02885794f, 0.06375025f, 0.02832007f, -0.00816169f, -0.00816932f, 
    0.03105873f, -0.15630013f, 0.07142971f, -0.06858388f, -0.16829447f, -0.45760751f, -0.01199671f, -0.13962251f, 
    0.09784938f, 0.38183323f, 0.21315406f, 0.32212332f, 0.30890715f, -0.39685017f, -0.16002031f, 0.20416149f, 
    -0.11028241f, -0.17269495f, -0.02031136f, 0.14077377f, 0.10728536f, 0.09547907f, 0.16360343f, 0.12277703f, 
    -0.01304718f, -0.05078829f, -0.03293194f, 0.18875585f, -0.24165659f, 0.22101726f, -0.31786990f, 0.24255058f, 
    0.32424957f, -0.05773252f, -0.26393959f, 0.09755184f, -0.07305896f, -0.04804600f, 0.08694188f, 0.10970078f, 
    0.38475657f, -0.04551413f, -0.10933106f, -0.12129540f, -0.08100794f, -0.18371949f, 0.38577729f, 0.09280263f, 
    0.03959434f, 0.12875147f, 0.34621382f, -0.00961774f, -0.31416166f, -0.01368183f, -0.06552467f, 0.13123435f, 
    0.33662429f, 0.07342175f, 0.29562077f, 0.16948882f, -0.06404231f, -0.16428472f, -0.16852249f, -0.02107250f, 
    -0.33939803f, -0.10875274f, -0.64139450f, 0.37513056f, 0.13581480f, -0.33313495f, 0.20545037f, 0.18298988f, 
    -0.22712755f, 0.25047427f, 0.19805327f, 0.13782217f, 0.16199987f, -0.21457405f, -0.09522241f, 0.02459562f, 
    0.41390559f, -0.02322685f, 0.13860001f, -0.35269183f, -0.14925823f, -0.02825429f, 0.09858661f, 0.26276892f, 
    -0.18471216f, 0.05688514f, 0.34424779f, -0.41869316f, 0.08177055f, -0.06626548f, 0.05533436f, -0.04515318f, 
    0.27589270f, -0.14695705f, 0.05239844f, -0.32709488f, -0.14374481f, -0.04264978f, -0.30607575f, 0.21596499f, 
    0.02573628f, 0.14094321f, -0.03438858f, -0.17362432f, 0.24388920f, 0.43138748f, 0.12684594f, -0.05897766f, 
    -0.56020999f, 0.06542171f, 0.23736003f, 0.00860464f, 0.12890407f, -0.28218877f, -0.31335625f, 0.16617072f, 
    -0.18960288f, 0.02327386f, -0.37925285f, 0.35704681f, 0.16442175f, 0.19216989f, 0.24542041f, 0.15292342f, 
    0.11805823f, 0.01541289f, -0.06557618f, 0.00684582f, 0.17599794f, -0.34740624f, -0.32487571f, 0.06143742f, 
    -0.84418863f, -0.21296448f, 0.52699035f, -0.25310814f, -0.29015970f, -0.14928225f, 0.10501482f, 0.23729691f, 
    -0.18647131f, -0.04954254f, -0.33760509f, -0.78284895f, -0.39891392f, -0.01070400f, 0.30671781f, -0.11492063f, 
    0.40770376f, -0.09270371f, 0.07653033f, 0.31787398f, -0.14544325f, 0.33289972f, 0.05286121f, -0.23057611f, 
    0.15101601f, 0.10280533f, 0.34660840f, 0.23667085f, -0.33961907f, -0.13074632f, -0.37034625f, -0.17807353f, 
    -0.16581057f, 0.38526347f, 0.09457344f, 0.08776621f, 0.37486705f, 0.01186777f, 0.30373448f, 0.09030582f, 
    0.01830124f, 0.16862440f, -0.30844223f, -0.16210935f, 0.19430760f, -0.12398056f, 0.04114117f, -0.27440807f, 
    -0.03659898f, 0.11039917f, 0.00050780f, -0.11377257f, 0.26106966f, 0.24248853f, 0.34098563f, -0.19032167f, 
    -0.35142836f, 0.14716120f, -0.33578342f, 0.36086160f, 0.25350386f, -0.18202354f, -0.41537914f, 0.26159960f, 
    0.35228607f, 0.20138212f, -0.02760310f, 0.27637285f, -0.00430307f, 0.22921084f, 0.00953327f, -0.03028943f, 
    0.56740737f, -0.06480383f, 0.02674331f, -0.29968411f, -0.09308566f, -0.18636832f, -0.04702311f, 0.24475279f, 
    0.32277328f, -0.37603793f, 0.10787601f, -0.51254344f, 0.06550207f, -0.10336443f, 0.37480804f, 0.10835537f, 
    -0.02963039f, -0.19154245f, -0.01763770f, -0.19413088f, 0.30139583f, 0.11414171f, 0.05283917f, -0.15441981f, 
    -0.33358502f, -0.05656812f, -0.04011193f, 0.14923400f, 0.42673373f, 0.31994978f, -0.28430977f, 0.12965462f, 
    0.08762800f, -0.19528629f, -0.00073436f, -0.39441320f, -0.03283184f, 0.03114700f, -0.21858425f, 0.10417465f, 
    0.38692412f, 0.26799527f, -0.02918797f, -0.05053718f, 0.40801594f, -0.35737890f, 0.06176340f, -0.22227448f, 
    0.02854002f, -0.19945112f, -0.03805669f, 0.21307361f, -0.02060798f, 0.20047598f, -0.19528593f, 0.20977218f, 
    0.30215925f, -0.15448762f, -0.31171340f, -0.23686558f, -0.02454540f, -0.34412521f, 0.19953777f, 0.03017005f, 
    -0.42184341f, 0.16378693f, -0.02284334f, 0.07512372f, 0.29771557f, -0.09564670f, -0.07280042f, 0.12449090f, 
    0.15555757f, -0.12238131f, 0.09339606f, 0.55733353f, 0.02073753f, 0.09287341f, -0.12103688f, 0.21877015f, 
    0.31395501f, 0.06623623f, -0.21391508f, -0.47321802f, 0.20719807f, 0.09030959f, 0.00043420f, -0.00188621f, 
    -0.11509184f, 0.21307635f, 0.03905161f, -0.38073465f, -0.13570572f, 0.31225136f, 0.31166881f, -0.01277266f, 
    0.53206211f, -0.19930939f, -0.06020350f, 0.49814475f, -0.03207141f, -0.33682367f, -0.01932885f, 0.00602415f, 
    0.12517545f, -0.30565184f, 0.16998126f, -0.31663615f, 0.01249994f, 0.19161360f, 0.37605360f, -0.20758435f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03492644f, 0.25824392f, -0.15107135f, -0.13941005f, -0.03754976f, -0.20503840f, 0.27574411f, 0.38450283f, 
    0.01329991f, 0.17149299f, -0.09387431f, 0.40830955f, -0.19189869f, -0.24097764f, 0.30216464f, -0.10015887f, 
    0.04559058f, 0.16394010f, -0.01474735f, -0.09409977f, 0.41734451f, 0.31714666f, 0.14036408f, 0.11137692f, 
    -0.28538379f, -0.22553410f, -0.12130969f, 0.13514931f, 0.52251041f, -0.13060698f, -0.06905232f, 0.07871344f, 
    -0.26207349f, 0.14690125f, -0.32482719f, -0.32012805f, -0.09787763f, -0.32969916f, -0.27308953f, 0.43362361f, 
    -0.01024697f, -0.08122701f, 0.13154806f, 0.06617868f, 0.27731451f, 0.31328878f, 0.06330502f, 0.12309360f, 
    -0.34738544f, -0.16882694f, -0.08678527f, -0.06385910f, -0.48063388f, 0.07659179f, -0.13452306f, 0.13646226f, 
    -0.26634923f, 0.16850090f, 0.14411558f, 0.28995952f, 0.33924070f, -0.17585199f, 0.19198567f, -0.34598872f, 
    0.08444444f, -0.14618155f, -0.03406243f, 0.06668347f, 0.15630309f, -0.20192346f, -0.06444170f, -0.15454091f, 
    0.36890110f, 0.30593437f, 0.11598982f, -0.10897758f, -0.24132296f, 0.39286083f, -0.27645493f, -0.09955200f, 
    0.35547173f, 0.15496007f, 0.31358308f, 0.26635969f, 0.52942491f, 0.07250512f, 0.12382545f, 0.53912175f, 
    0.21045724f, -0.13244677f, 0.11156195f, 0.19824101f, 0.46183228f, 0.05848053f, -0.12019067f, 0.02755057f, 
    0.00067785f, 0.22604808f, -0.28647560f, 0.17157832f, 0.28482804f, 0.31815064f, 0.01323264f, -0.19434337f, 
    0.03908231f, -0.04520318f, 0.42741284f, -0.24813992f, 0.00194099f, 0.24481420f, -0.24719486f, 0.34357360f, 
    0.04639291f, -0.10477306f, -0.02973905f, 0.27015316f, 0.01929400f, 0.37524506f, -0.09137221f, 0.33159861f, 
    -0.05658511f, -0.15146951f, 0.15575725f, 0.21005894f, 0.18560901f, 0.40291497f, 0.16138493f, -0.15900181f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03732256f, -0.02734900f, -0.05093579f, -0.05644524f, 0.02534056f, 0.04666209f, 0.07927015f, -0.05503941f, 
    -0.00456870f, -0.01793281f, -0.07719616f, -0.08997306f, 0.04216905f, -0.08682176f, 0.00727848f, 0.05656923f, 
    0.00515370f, 0.01712626f, 0.08090719f, -0.02070321f, 0.02800413f, 0.05699157f, 0.00267303f, -0.09493107f, 
    0.05092387f, -0.02356010f, 0.00467148f, -0.10109979f, 0.06413864f, 0.05214388f, -0.05448346f, -0.09358107f, 
    0.02039023f, -0.08518612f, -0.05354336f, -0.04515174f, -0.08604254f, 0.07251880f, 0.00882497f, -0.05202356f, 
    -0.01531142f, -0.02633660f, 0.05978376f, -0.08085844f, -0.03939087f, -0.01094568f, -0.04813829f, 0.08684534f, 
    0.04333533f, -0.08981068f, -0.08933658f, 0.07824615f, 0.08486576f, -0.03494733f, 0.04730708f, 0.03836704f, 
    -0.08817080f, -0.00851048f, -0.02747044f, 0.01360506f, -0.09087446f, -0.01602989f, -0.03684076f, 0.05349124f, 
    -0.10075642f, -0.08144901f, 0.00039676f, 0.04852429f, 0.06464578f, -0.02064570f, -0.08898091f, -0.07258871f, 
    -0.10822088f, 0.04005919f, 0.08650263f, -0.07494610f, 0.02986825f, 0.01722347f, -0.10293861f, -0.04007694f, 
    -0.08266965f, -0.00700212f, -0.02978836f, 0.02933121f, -0.05685050f, -0.09445035f, -0.06134186f, 0.06229377f, 
    0.03032233f, -0.05715093f, 0.00312379f, -0.01512185f, -0.06403599f, -0.04826533f, -0.02852622f, -0.01470618f, 
    -0.06883754f, -0.02362626f, -0.00644794f, -0.07322843f, -0.04137899f, -0.03484292f, 0.05584991f, 0.00761067f, 
    0.05308758f, -0.01013249f, -0.03768346f, 0.03060249f, -0.01791202f, -0.03431360f, -0.06538464f, 0.03186312f, 
    0.00909315f, -0.02369856f, -0.10614705f, 0.08760902f, -0.08739907f, -0.04694394f, -0.05126010f, -0.08546648f, 
    0.00259785f, -0.01010463f, 0.04853690f, -0.00981469f, -0.08279388f, -0.03865591f, -0.07621960f, 0.03168828f, 
    0.24865907f, 0.01332222f, 0.05014277f, 0.11521082f, 0.04567947f, 0.20905124f, -0.02172691f, -0.04630896f, 
    -0.05851292f, -0.07298625f, -0.46680030f, 0.05581035f, 0.14372732f, -0.12129603f, 0.05495321f, 0.11295641f, 
    0.01501303f, -0.08166578f, -0.03928635f, -0.15766877f, 0.26424080f, 0.10818904f, 0.05874130f, -0.13990206f, 
    0.10656394f, 0.04940803f, 0.09962285f, 0.23010762f, 0.32448885f, 0.02291599f, 0.05962040f, 0.04625965f, 
    0.04550151f, -0.04431570f, -0.11285841f, -0.32013524f, -0.15108830f, 0.42793533f, 0.05464938f, 0.01563905f, 
    -0.11431467f, -0.05487731f, 0.05332554f, 0.18381704f, 0.10719044f, 0.07513344f, 0.02533231f, -0.15348752f, 
    -0.20241791f, 0.13763292f, -0.06479087f, -0.21252380f, -0.44016555f, 0.28135577f, 0.15919392f, 0.04518482f, 
    0.22552772f, 0.03325286f, -0.17942244f, 0.13331555f, -0.05878538f, 0.01783375f, 0.16418578f, -0.33185098f, 
    0.14645870f, 0.11607926f, 0.01567043f, -0.20010042f, 0.09595749f, 0.07251979f, -0.10230304f, 0.22969605f, 
    0.07883326f, 0.08579396f, -0.23811822f, 0.06017740f, -0.04503946f, -0.03084161f, 0.09234590f, -0.00277028f, 
    0.07801592f, 0.30080658f, -0.07996222f, 0.14479129f, 0.34624794f, 0.20473424f, -0.01864503f, 0.16705129f, 
    -0.04450880f, -0.00454962f, -0.06051651f, 0.17984249f, 0.05296901f, 0.13650714f, 0.13279574f, 0.34658876f, 
    -0.10737252f, 0.03191741f, -0.04332720f, -0.37237957f, -0.21797530f, -0.01291953f, -0.03932268f, -0.08923721f, 
    0.14928514f, -0.35279849f, 0.18054202f, 0.04286999f, 0.00247632f, 0.10002061f, 0.20421033f, 0.16745616f, 
    0.04597349f, 0.18082008f, 0.08965716f, -0.22625716f, -0.16225889f, 0.04846960f, 0.08084335f, -0.05344035f, 
    -0.07129043f, 0.17690018f, -0.09092698f, 0.22199614f, 0.03867355f, 0.16305506f, 0.08231270f, 0.04462353f, 
    0.09617437f, -0.01508149f, -0.09760484f, -0.06827722f, 0.12462210f, 0.20594178f, 0.55063266f, 0.35967737f, 
    0.03744322f, 0.02811665f, -0.27270913f, 0.23083550f, 0.17523719f, 0.08663027f, -0.03902720f, -0.11534771f, 
    -0.05046850f, 0.16126081f, -0.01512623f, -0.07127073f, 0.09667807f, 0.15455429f, 0.06893501f, 0.06315388f, 
    -0.09587836f, 0.04893890f, 0.19837353f, -0.00288016f, 0.15119396f, 0.11307605f, -0.05502485f, -0.07885675f, 
    0.22652014f, 0.12206001f, -0.04182703f, -0.23616222f, -0.01548393f, 0.46934876f, 0.08423879f, 0.10915326f, 
    0.02307304f, -0.01495488f, 0.04332408f, 0.04409373f, 0.14964987f, 0.12183680f, 0.08530123f, 0.08410572f, 
    -0.41965875f, 0.15284215f, -0.21846354f, 0.03562219f, -0.37761194f, 0.29976499f, 0.11130407f, -0.01474496f, 
    -0.26998749f, 0.10795876f, -0.06886387f, 0.00512841f, -0.25967345f, 0.12030506f, 0.44103074f, -0.34834316f, 
    -0.00563392f, -0.12102664f, 0.04861170f, -0.23959276f, 0.15941511f, 0.06398736f, -0.03366141f, -0.05585443f, 
    0.18998703f, 0.07707895f, -0.16932763f, -0.03083399f, 0.01588913f, 0.05224356f, -0.03488500f, 0.22687647f, 
    0.01725986f, 0.02828114f, 0.06341469f, -0.24333990f, 0.41757840f, 0.25198659f, 0.03588353f, 0.00748231f, 
    0.24455833f, 0.03876109f, 0.09660103f, -0.15219265f, 0.20448253f, -0.12982342f, -0.02669805f, -0.16361532f, 
    -0.08673908f, -0.33233535f, -0.21895641f, -0.19259200f, -0.25237429f, 0.17106277f, 0.06357929f, 0.27014247f, 
    0.11675807f, -0.02716693f, 0.11807290f, 0.03958790f, -0.09410717f, 0.05121055f, -0.08701797f, 0.16091944f, 
    -0.23936291f, 0.26380047f, 0.19552526f, -0.10170706f, -0.08150516f, 0.07456738f, 0.14456815f, 0.02065767f, 
    -0.02985856f, 0.02340062f, 0.07737380f, 0.09912416f, -0.00052187f, 0.07092836f, 0.07479070f, 0.06785509f, 
    0.07137121f, 0.31779888f, 0.01556119f, 0.22354290f, 0.13317388f, -0.02149281f, -0.17636690f, 0.33496132f, 
    -0.25451478f, 0.00550594f, 0.00009165f, 0.02810374f, 0.16960302f, -0.11570355f, 0.31348193f, 0.10459257f, 
    0.33429599f, -0.00394716f, -0.04751844f, -0.07170328f, 0.24115542f, -0.38163802f, 0.08736008f, 0.05880012f, 
    0.07192445f, 0.05632699f, 0.00049575f, 0.01558356f, 0.16969296f, 0.13356732f, -0.03465885f, 0.00195351f, 
    -0.01821287f, 0.13906144f, 0.00720072f, 0.10355225f, -0.33676004f, 0.14599720f, -0.00309710f, 0.24753298f, 
    0.21440075f, 0.10186850f, 0.02394226f, -0.04077240f, -0.02796131f, 0.02695388f, 0.03025057f, -0.34071571f, 
    -0.00467244f, 0.05067341f, 0.24063234f, -0.29853439f, -0.04025815f, -0.01852335f, -0.22283415f, 0.02487050f, 
    -0.00948839f, 0.02562075f, -0.07069776f, 0.14052320f, 0.26960185f, -0.30681437f, 0.00861381f, -0.05914188f, 
    0.07267649f, -0.01820392f, -0.03411714f, -0.14265402f, -0.10870673f, 0.05089033f, -0.09342672f, -0.09237506f, 
    0.05506385f, 0.18932837f, -0.19151403f, 0.18169156f, 0.19793136f, 0.24732217f, -0.17363808f, -0.07429902f, 
    0.05842540f, -0.03056433f, 0.31949788f, 0.04410240f, -0.04754544f, -0.17803462f, 0.02837002f, -0.18326822f, 
    -0.17615955f, -0.09096263f, -0.00050220f, 0.24326375f, 0.10212533f, -0.44901440f, -0.00901536f, -0.26674378f, 
    0.00926416f, -0.08911583f, -0.36036026f, -0.03678765f, 0.20913403f, -0.17673944f, 0.14829747f, -0.07543517f, 
    -0.03072723f, -0.26170486f, 0.09754127f, -0.04174853f, -0.38597548f, 0.21161242f, 0.05175020f, -0.06143205f, 
    0.21807033f, -0.05928340f, -0.05577745f, -0.01069389f, -0.29272223f, 0.22053505f, -0.29339376f, 0.19493352f, 
    0.09562770f, -0.17255080f, 0.15434231f, -0.17629535f, -0.03927122f, 0.16572163f, 0.02334973f, 0.09882654f, 
    0.01207343f, -0.09691519f, 0.03125704f, -0.12784530f, -0.45826033f, -0.23682958f, 0.22007947f, 0.05668949f, 
    0.43752980f, 0.04540771f, 0.43869635f, 0.06512030f, 0.00000713f, -0.05231708f, -0.03963524f, 0.19098350f, 
    -0.17556544f, 0.12645887f, -0.06972872f, 0.00998509f, 0.30576256f, 0.42859912f, 0.24078973f, -0.10388029f, 
    0.02582438f, -0.05010014f, -0.40518755f, 0.07179510f, 0.16155191f, -0.35081905f, 0.08256671f, 0.19339654f, 
    0.08349896f, -0.18489276f, -0.11796851f, 0.04267576f, -0.30223748f, -0.32319665f, 0.04099679f, 0.22341673f, 
    -0.12969887f, 0.02232797f, 0.12049080f, 0.22480229f, 0.25764486f, -0.00786285f, 0.07632965f, -0.09793216f, 
    0.28393391f, 0.05094204f, -0.10947461f, -0.15088333f, 0.07426324f, 0.26006296f, -0.22284576f, 0.03932245f, 
    0.47178370f, -0.06102145f, -0.14172114f, 0.18197688f, 0.21926387f, 0.01313470f, 0.03088330f, -0.10165339f, 
    0.21354686f, -0.07297636f, -0.05780267f, 0.32814386f, 0.24046113f, -0.08242088f, 0.07970025f, -0.17355005f, 
    -0.14119510f, 0.22071923f, -0.55938601f, 0.19033553f, -0.08610661f, -0.02212170f, 0.13756631f, -0.22925843f, 
    -0.17433147f, 0.12355676f, 0.18734775f, 0.06573453f, 0.25725108f, -0.01899572f, -0.31966543f, 0.07036494f, 
    0.06588851f, 0.17149121f, 0.10088883f, 0.22077718f, -0.12744756f, 0.56840903f, -0.43850434f, 0.38895333f, 
    0.12576993f, 0.14279392f, 0.18974957f, -0.55794436f, -0.04187089f, -0.29614204f, 0.19050458f, -0.41851014f, 
    -0.02317460f, -0.81826335f, 0.25664160f, -0.03419952f, 0.38166377f, 0.17150837f, 0.12405142f, 0.15805824f, 
    -0.05561370f, -0.32411072f, -0.37117141f, -0.01934516f, -0.18823753f, 0.32063514f, -0.32507581f, -0.13749622f, 
    -0.12662646f, -0.16452613f, 0.03002580f, 0.17475407f, -0.10091095f, 0.12547565f, -0.19366790f, -0.27095091f, 
    -0.02380879f, 0.03867828f, -0.02070796f, 0.04386958f, 0.01061945f, -0.07074829f, 0.01242352f, 0.06451082f, 
    -0.06972510f, -0.02430046f, -0.01363231f, 0.02461215f, -0.03244767f, -0.06965541f, -0.08802024f, 0.06097170f, 
    0.06740323f, 0.03623939f, 0.07143397f, 0.05762708f, -0.04540059f, -0.02663685f, -0.08454856f, -0.01663452f, 
    -0.02167444f, 0.00680794f, -0.04987850f, 0.01887381f, 0.00020374f, 0.05946245f, 0.06293551f, 0.00699271f, 
    -0.06460276f, 0.00975595f, 0.08749455f, -0.03002004f, -0.02191364f, 0.06814774f, -0.00191980f, -0.00233658f, 
    -0.00801235f, 0.02170253f, 0.00669109f, -0.06628896f, 0.00086165f, -0.02503262f, -0.08446934f, -0.05512143f, 
    0.01434446f, 0.04504893f, 0.03768888f, -0.05879578f, 0.00026464f, 0.04723148f, 0.05075411f, 0.02610067f, 
    -0.00057044f, -0.07166190f, -0.04270522f, -0.05106319f, 0.08549263f, -0.02268203f, 0.08335931f, -0.08658613f, 
    0.03745882f, -0.07755060f, 0.02260645f, 0.04990662f, 0.04356750f, 0.03389970f, 0.02172554f, -0.03444599f, 
    -0.05518254f, 0.08391020f, -0.06544288f, 0.04291761f, -0.06481059f, -0.06564388f, 0.06475801f, 0.07657058f, 
    -0.06524432f, -0.05843145f, -0.04178675f, -0.08531614f, -0.01730122f, -0.05417993f, -0.06193771f, -0.08791665f, 
    -0.08735911f, -0.06032738f, -0.01755557f, -0.04960180f, 0.04896955f, -0.02399090f, -0.07946976f, -0.03990592f, 
    -0.05047521f, -0.06684036f, -0.06589279f, 0.03492880f, -0.08506412f, -0.05877724f, 0.06520833f, 0.02687450f, 
    0.03839406f, 0.08688560f, -0.07149829f, 0.00404264f, 0.02432036f, 0.06541040f, -0.08578661f, 0.00160725f, 
    0.00115810f, -0.08279850f, 0.00453487f, 0.01696941f, 0.00285935f, -0.05914736f, 0.00051530f, -0.08494421f, 
    -0.05545915f, -0.02916326f, -0.05711064f, -0.03151451f, -0.03967679f, -0.02882077f, -0.05912434f, -0.06041551f, 
    -0.07272761f, 0.07391099f, 0.12547760f, 0.19090436f, 0.31360257f, -0.11616962f, 0.46126151f, -0.00234145f, 
    -0.17585491f, -0.07445483f, 0.09732221f, 0.15287916f, 0.01953094f, 0.09451916f, 0.21256573f, 0.00918267f, 
    0.02082720f, 0.18995053f, 0.03559710f, 0.10673086f, 0.11746123f, 0.41843307f, 0.07110278f, -0.03476508f, 
    -0.28342170f, 0.05009942f, -0.10923697f, 0.24789642f, 0.23531812f, -0.02457442f, 0.02694273f, 0.11881398f, 
    0.12771831f, 0.05135571f, -0.12195284f, -0.19979422f, -0.04611914f, 0.20856281f, -0.06196488f, 0.12210229f, 
    -0.05007563f, 0.05681373f, -0.00168110f, 0.12515229f, 0.16892830f, 0.11555569f, -0.06390439f, 0.48261684f, 
    -0.21936187f, 0.17454277f, -0.00430441f, -0.02073533f, -0.14278872f, 0.00529836f, 0.05019164f, 0.05611327f, 
    -0.00809050f, 0.13105258f, -0.03222852f, 0.19181949f, 0.12756655f, -0.25807944f, 0.56675351f, -0.17011274f, 
    -0.09345503f, 0.00491053f, -0.06620809f, 0.11933164f, 0.04386692f, -0.07006043f, 0.14077149f, -0.10099257f, 
    0.05550231f, 0.27114758f, -0.02391960f, 0.08491048f, 0.09626308f, -0.11315613f, -0.17932492f, -0.22601441f, 
    0.15417142f, 0.15622927f, 0.08234669f, -0.08037893f, 0.29912168f, -0.18648361f, -0.03772310f, 0.04808969f, 
    0.03986816f, 0.20592749f, 0.00958158f, 0.06176059f, 0.21346238f, -0.11518999f, -0.44471046f, -0.02662747f, 
    -0.04995376f, 0.19780886f, -0.11718762f, -0.09716422f, -0.04908627f, 0.20264769f, -0.08805516f, -0.02164126f, 
    -0.35788649f, -0.24412155f, 0.17517939f, -0.07125115f, -0.21598817f, 0.14298405f, 0.01066399f, 0.12065846f, 
    0.11471950f, -0.20868447f, -0.05119649f, 0.15396154f, -0.06344945f, 0.05476055f, 0.00240886f, -0.06634098f, 
    0.02115359f, 0.00989349f, -0.13957597f, -0.15745653f, 0.08544641f, 0.16472226f, -0.15213917f, 0.09607586f, 
    -0.05457966f, -0.01771045f, -0.05826164f, -0.10317452f, 0.05354581f, -0.09522837f, 0.04165957f, 0.09578571f, 
    0.07915153f, -0.04368375f, 0.00510230f, -0.00297662f, 0.06883931f, 0.01481300f, -0.07039083f, -0.10065793f, 
    0.02112990f, 0.01502244f, 0.07162876f, 0.04993627f, -0.09321924f, -0.04019769f, 0.04910536f, -0.10921490f, 
    -0.09522197f, 0.07668860f, -0.10485381f, -0.01850379f, 0.00815949f, 0.05680563f, 0.03873929f, 0.05969895f, 
    0.01681451f, 0.03775843f, -0.10329310f, -0.06203200f, -0.02148600f, 0.06364883f, 0.03549374f, -0.09631442f, 
    -0.07203820f, 0.08798567f, -0.08854754f, 0.00988612f, -0.02651569f, -0.10035817f, -0.01558825f, -0.03915209f, 
    0.07881467f, -0.02151728f, -0.06532378f, -0.09137701f, -0.05257432f, -0.01991061f, -0.04651614f, -0.07319915f, 
    -0.07758755f, -0.10937355f, 0.05187093f, 0.05155874f, -0.04202509f, -0.06449533f, 0.00857164f, -0.05215909f, 
    -0.05989985f, -0.04187032f, 0.03709738f, -0.07492664f, -0.09904654f, 0.07344011f, -0.07518680f, -0.05362558f, 
    -0.01179095f, 0.02753936f, -0.03766032f, 0.01225221f, -0.10038076f, -0.07289062f, 0.01905102f, 0.01680032f, 
    -0.11622746f, 0.03086136f, 0.01228794f, -0.06611889f, -0.08916035f, -0.06855072f, -0.03643450f, 0.05061394f, 
    -0.02592809f, 0.04679908f, 0.04138397f, -0.10437504f, -0.02850499f, 0.04934481f, -0.01899114f, -0.09156451f, 
    -0.05463106f, -0.06772381f, 0.00353654f, 0.01306999f, 0.01171296f, -0.01491791f, -0.01440115f, 0.01667042f, 
    -0.07130394f, -0.05347957f, -0.09752797f, 0.02653139f, 0.01554793f, 0.03844410f, 0.05728433f, -0.03705865f, 
    -0.09568391f, -0.05415533f, 0.00965902f, 0.02794524f, -0.08452987f, -0.03090078f, 0.01140090f, 0.01755189f, 
    0.01181821f, 0.04758422f, 0.02645083f, 0.02333407f, -0.04345154f, -0.03437145f, -0.08261365f, -0.07552981f, 
    -0.01444296f, 0.04785625f, 0.02407296f, -0.02790359f, 0.06006868f, 0.03626825f, -0.01615764f, 0.11534701f, 
    -0.00513523f, -0.08306151f, -0.06852970f, -0.08482359f, -0.10318288f, -0.10696867f, -0.02229568f, -0.05530670f, 
    0.06746629f, 0.03416796f, 0.01014082f, -0.13376871f, 0.04993302f, -0.04141778f, -0.00560361f, -0.10428568f, 
    0.00594493f, 0.03723414f, -0.01450320f, -0.08593111f, 0.03640704f, -0.02339535f, -0.05641046f, -0.03026569f, 
    -0.10940403f, 0.03051456f, -0.06603745f, -0.06765103f, -0.03257814f, 0.05617135f, 0.02376808f, -0.04917829f, 
    0.00583722f, -0.05444529f, -0.03955427f, -0.10245150f, -0.08626674f, 0.04183712f, -0.00857066f, 0.03297115f, 
    -0.08851294f, 0.03228533f, -0.06364752f, -0.08824344f, -0.02892535f, -0.06277569f, 0.04447126f, -0.08358232f, 
    0.01406514f, 0.05871043f, -0.08073739f, -0.10481369f, 0.06179385f, -0.13454974f, -0.02843447f, -0.09855684f, 
    -0.09785862f, 0.03336864f, 0.02551718f, -0.08185983f, 0.00868425f, 0.01448104f, 0.01474314f, -0.01145138f, 
    -0.09955608f, 0.03074388f, -0.06032489f, -0.01053183f, -0.01927531f, -0.06539591f, 0.00738020f, 0.04996112f, 
    0.00289743f, -0.12496851f, -0.07053016f, 0.03214898f, -0.02571445f, -0.13383743f, -0.02264023f, -0.12752494f, 
    0.01043367f, 0.07715210f, -0.08160366f, -0.01388805f, 0.04424112f, -0.07679017f, 0.02334785f, -0.06282789f, 
    -0.04113455f, -0.01296912f, -0.02796166f, -0.04878357f, 0.06164678f, 0.01645997f, 0.02174442f, -0.05419070f, 
    -0.09243541f, 0.04975057f, -0.02019877f, 0.07203273f, 0.02357068f, -0.04271146f, -0.08388456f, -0.06213311f, 
    0.04380971f, -0.11095772f, -0.02985662f, -0.08166637f, -0.08178066f, 0.03130294f, 0.03041772f, 0.08340519f, 
    0.00511253f, 0.04741662f, 0.06070003f, -0.06005113f, -0.05496299f, 0.04070858f, -0.08588603f, -0.08717237f, 
    -0.06344619f, -0.02061748f, -0.05662985f, -0.24116273f, -0.19996081f, 0.02068728f, 0.52957159f, -0.04197822f, 
    0.38885459f, 0.05618023f, -0.10926056f, 0.17537357f, 0.13062581f, 0.21543828f, -0.23198007f, -0.06820900f, 
    -0.19871977f, 0.17374387f, -0.05967747f, 0.07742561f, 0.09763707f, 0.33275920f, -0.01150805f, 0.11752109f, 
    0.10388152f, -0.03651918f, 0.07278035f, -0.01661510f, -0.13673052f, 0.04341972f, 0.03216817f, -0.02910572f, 
    0.19930485f, -0.00408460f, 0.24446410f, -0.10358985f, 0.32515666f, -0.13769165f, 0.04095181f, -0.12407664f, 
    0.01435978f, 0.04385621f, -0.03591900f, -0.05697997f, -0.04441277f, -0.05699135f, 0.01239916f, 0.26351917f, 
    0.00897013f, 0.02804348f, -0.06614006f, 0.35768792f, -0.26815441f, -0.00723336f, 0.04370123f, 0.03474930f, 
    -0.07445195f, 0.03878000f, 0.15396647f, -0.01223298f, -0.07639978f, 0.26837027f, 0.07687730f, 0.28000131f, 
    0.01392374f, 0.01760019f, 0.07074837f, -0.03170926f, -0.03154847f, 0.01005002f, 0.02106855f, 0.06482556f, 
    -0.03229622f, -0.03634287f, 0.25480774f, -0.13201626f, 0.03404834f, 0.14945605f, 0.11484367f, 0.21464713f, 
    -0.08762777f, -0.17000858f, -0.08352871f, -0.11365342f, 0.12911452f, 0.28572741f, 0.09264131f, 0.17280436f, 
    0.24129023f, 0.03756238f, 0.13427171f, -0.34351513f, 0.08508466f, 0.33069238f, 0.31289843f, 0.03424485f, 
    0.17406143f, -0.31539047f, 0.13366513f, 0.46384114f, -0.10354227f, 0.09372183f, 0.05551571f, 0.23583457f, 
    0.22581224f, 0.70253235f, 0.00020815f, 0.06514290f, 0.10901688f, 0.05277402f, -0.07445810f, 0.11714756f, 
    -0.14662784f, 0.09887520f, 0.16304481f, 0.20444311f, 0.66983134f, -0.14519922f, 0.31417760f, 0.12183356f, 
    0.06479325f, 0.20861989f, 0.00815206f, 0.27054757f, 0.12251374f, -0.09141697f, 0.14153843f, -0.03988975f, 
    -0.06902722f, -0.01089199f, -0.09970555f, -0.00775876f, -0.05208410f, -0.02148626f, -0.04194190f, 0.00384161f, 
    -0.04454722f, -0.00734987f, 0.06977116f, -0.03780130f, 0.02370528f, 0.01801088f, -0.09739102f, -0.09652343f, 
    0.07049476f, 0.07708101f, -0.00722816f, -0.04920806f, -0.07664946f, 0.01659325f, -0.07348947f, 0.05976024f, 
    0.02276981f, -0.04612594f, -0.02558997f, -0.03187770f, -0.07206361f, -0.09466095f, 0.08016570f, 0.05845440f, 
    -0.01185139f, 0.01486633f, -0.05590533f, 0.08098756f, -0.02299081f, -0.04413798f, 0.06088583f, 0.03248293f, 
    0.03897808f, 0.01258768f, -0.04844256f, 0.04512085f, 0.02861732f, -0.04229781f, -0.06870050f, 0.06155352f, 
    -0.08511186f, 0.07083124f, -0.05972135f, -0.07469913f, -0.06889842f, -0.04433098f, 0.02388172f, -0.07997902f, 
    -0.02743328f, -0.00213258f, -0.03781916f, -0.04652902f, -0.06093657f, -0.03346352f, -0.04478104f, -0.04243836f, 
    0.07023031f, -0.00379428f, -0.06929180f, 0.01839401f, -0.02718416f, -0.01459444f, -0.09658268f, -0.04276340f, 
    0.00875390f, 0.06091331f, -0.03756014f, -0.04124455f, -0.08270650f, 0.04384127f, 0.01644326f, 0.04491823f, 
    0.04395953f, 0.01958389f, 0.03442992f, -0.06927754f, -0.01895984f, -0.08276701f, 0.04353148f, 0.03782057f, 
    0.01853067f, -0.05535336f, 0.00850766f, -0.00300102f, -0.01997083f, -0.01098311f, 0.05850590f, 0.00148056f, 
    0.06592673f, -0.01902528f, -0.04105782f, -0.09388889f, 0.00384702f, -0.06769034f, 0.02484062f, -0.08934871f, 
    -0.04366135f, 0.03512990f, -0.07144909f, 0.03253055f, -0.02747862f, -0.04091834f, -0.05433186f, 0.07656936f, 
    0.01888586f, -0.04175299f, 0.07408808f, 0.06800634f, -0.08898231f, -0.07748457f, -0.03984685f, -0.09118745f, 
    -0.00763375f, -0.00303094f, 0.06163750f, 0.07641879f, 0.06431372f, -0.02052589f, -0.04276082f, 0.01508331f, 
    0.00900725f, -0.07630058f, -0.10270698f, 0.01403212f, -0.08284912f, 0.04396064f, 0.07987911f, 0.02801850f, 
    -0.04859762f, 0.01348326f, -0.08954343f, -0.06176469f, 0.03129595f, -0.02525988f, 0.00816067f, 0.00048514f, 
    -0.05252691f, -0.11813293f, 0.05995192f, -0.06407218f, -0.06750464f, 0.00066457f, 0.02043058f, 0.01160760f, 
    -0.08634025f, 0.06927950f, -0.01506157f, -0.00202922f, -0.03230151f, -0.06247230f, 0.08748110f, 0.04516586f, 
    0.04727485f, -0.06299219f, 0.00843592f, 0.01494848f, -0.00013188f, 0.01365674f, 0.04595891f, 0.04838428f, 
    -0.03295179f, -0.02855029f, 0.05584779f, -0.11797123f, -0.04133612f, 0.01695920f, 0.04708819f, 0.04987612f, 
    -0.04901978f, -0.04520013f, -0.06242330f, -0.04459014f, -0.01539899f, -0.01398839f, 0.02170665f, -0.09176545f, 
    0.03283872f, 0.05726503f, 0.03893760f, 0.02687145f, 0.03961407f, -0.00813653f, -0.10404471f, 0.04524458f, 
    0.02521279f, -0.08602569f, 0.06019259f, 0.02631057f, -0.01502045f, 0.02307331f, -0.10518142f, 0.06160425f, 
    -0.05355666f, -0.05848905f, 0.04981885f, 0.02665358f, -0.05879707f, 0.02355715f, 0.00903323f, -0.06191683f, 
    0.04151899f, 0.03049050f, -0.07728562f, -0.00686188f, -0.02305182f, -0.01703792f, -0.07954948f, 0.00230858f, 
    -0.08697944f, -0.03549043f, 0.01896257f, 0.00724611f, 0.05001682f, -0.07122254f, -0.03783912f, 0.01834309f, 
    0.03673450f, -0.03705873f, 0.01171620f, 0.07316621f, -0.02467326f, -0.08248206f, 0.04593946f, 0.09865100f, 
    0.03560656f, -0.03920355f, -0.02278848f, -0.06694122f, 0.02954451f, -0.05088139f, 0.04616784f, -0.02267841f, 
    -0.07722940f, -0.00576322f, -0.01191431f, 0.03458611f, -0.06619657f, -0.02434498f, 0.05192420f, 0.07031849f, 
    0.03360386f, -0.00453118f, 0.06322327f, -0.07433551f, -0.11040998f, -0.03217152f, -0.01021663f, -0.06161107f, 
    -0.10408921f, -0.10517209f, -0.36077112f, -0.14212985f, -0.22955120f, 0.10303298f, 0.24403596f, -0.03561428f, 
    0.32168916f, -0.07919689f, -0.32738262f, 0.11191393f, 0.15845469f, 0.13159637f, -0.12322533f, 0.04899512f, 
    -0.10034910f, 0.00126525f, -0.08626397f, -0.19191462f, 0.20420961f, -0.06816772f, 0.20499037f, -0.13570477f, 
    0.21616338f, -0.01899425f, -0.12050736f, -0.19069813f, 0.04948171f, 0.07443305f, -0.00204634f, -0.02194697f, 
    -0.11768533f, -0.04042945f, 0.03030350f, 0.08704501f, -0.05931224f, 0.16828212f, -0.01901513f, -0.05957920f, 
    0.03841287f, 0.10035740f, 0.10807240f, 0.12623294f, -0.05251551f, -0.01365108f, -0.05351806f, -0.30086386f, 
    -0.02927826f, 0.04130871f, 0.17655489f, -0.04845871f, -0.24152252f, 0.35056460f, -0.13261588f, 0.02588133f, 
    0.32995367f, -0.02319989f, -0.01795659f, -0.03244342f, -0.03333088f, 0.18530020f, -0.13789342f, 0.27774206f, 
    0.13030092f, 0.02469355f, -0.03555617f, 0.13703236f, 0.19562392f, -0.00326718f, 0.06059706f, 0.21634449f, 
    0.07729224f, -0.07921627f, -0.01514423f, 0.01493023f, -0.08549499f, 0.03149104f, 0.01250362f, 0.19987574f, 
    -0.16214713f, -0.08185650f, -0.04035622f, 0.38708329f, 0.00739208f, 0.17621335f, 0.05456379f, 0.02028347f, 
    0.09862504f, -0.24313065f, -0.11279718f, 0.01948349f, -0.04855855f, 0.11765926f, 0.43520215f, 0.20190500f, 
    0.21223377f, -0.24032493f, 0.22318467f, 0.25524083f, -0.01921461f, -0.20823087f, 0.19071443f, 0.09027665f, 
    0.32236502f, 0.17443904f, -0.01070700f, -0.01361042f, 0.21266422f, -0.16304860f, 0.28123143f, -0.00720177f, 
    -0.02684053f, 0.16322689f, 0.16513139f, -0.28950512f, 0.20113818f, 0.11220273f, 0.13277233f, 0.21027277f, 
    0.23477493f, 0.20986180f, 0.04823622f, 0.29712716f, 0.07486399f, -0.04926820f, 0.06397063f, 0.02408556f, 
    0.02276768f, 0.01575239f, -0.02545059f, 0.01372474f, -0.01941590f, -0.02402868f, -0.07732978f, -0.03778952f, 
    0.07691782f, 0.00334939f, -0.01590937f, -0.09801946f, -0.06851117f, -0.02904875f, 0.03539546f, 0.00870315f, 
    -0.07720265f, -0.02632507f, 0.03910901f, -0.08293018f, -0.07858624f, -0.03637746f, -0.07971308f, 0.03984706f, 
    0.01255006f, 0.03683631f, 0.03185655f, -0.01670155f, -0.01818097f, 0.04656358f, 0.05846846f, -0.03540117f, 
    -0.04121994f, -0.03889745f, -0.04996431f, 0.03639082f, -0.09842276f, -0.07143739f, 0.03117910f, 0.02007780f, 
    0.05802524f, 0.06994260f, 0.01339548f, 0.03564432f, 0.02668058f, -0.06988534f, 0.08525905f, -0.07055108f, 
    -0.02558387f, 0.04360155f, -0.05115844f, -0.09641244f, 0.03565367f, -0.04063137f, 0.05947923f, 0.01727258f, 
    0.02259791f, 0.04587396f, -0.03184133f, 0.06691892f, -0.05848159f, 0.06944089f, 0.06435375f, 0.03482443f, 
    -0.04551977f, -0.07493563f, -0.00564766f, -0.03707027f, 0.04261398f, -0.06825228f, -0.01424133f, -0.05404588f, 
    -0.05822217f, -0.03435379f, 0.07184327f, 0.03523403f, -0.08466324f, -0.07836415f, -0.04196236f, 0.01726060f, 
    -0.07743059f, 0.04223057f, -0.09879296f, -0.03087329f, -0.00459711f, -0.00325510f, -0.06469952f, -0.04942486f, 
    0.01419865f, -0.03852602f, -0.03725706f, -0.07179312f, 0.05527118f, 0.06741810f, -0.09262109f, -0.02515784f, 
    0.03090384f, 0.06057277f, -0.01345606f, -0.05971166f, 0.00731176f, 0.07949798f, 0.00548863f, -0.00518858f, 
    -0.04055096f, 0.03577396f, -0.05722207f, 0.00652192f, -0.00990129f, 0.03496393f, 0.06005353f, 0.01602144f, 
    -0.03272694f, 0.05870777f, -0.08184835f, -0.06345639f, -0.05366669f, -0.00065304f, -0.03681175f, 0.01890649f, 
    0.02671836f, -0.00481592f, 0.02188459f, 0.07183777f, -0.07481229f, 0.05811220f, -0.02323537f, -0.09916800f, 
    -0.05133370f, -0.04006223f, -0.06638485f, -0.07567912f, -0.02105742f, -0.05619023f, -0.04678027f, 0.08346868f, 
    -0.10197911f, 0.06933582f, 0.05792993f, -0.00035265f, -0.09630095f, 0.03595983f, -0.01064483f, -0.05726800f, 
    0.01944730f, 0.00101169f, 0.00280905f, 0.05176509f, 0.01333322f, -0.03837227f, -0.02266530f, 0.00222892f, 
    -0.00810341f, 0.06620873f, -0.10583922f, -0.07403208f, 0.01028987f, -0.06257280f, 0.07804257f, 0.00083941f, 
    0.04424852f, 0.00906256f, -0.00874003f, -0.04724909f, -0.10609408f, -0.03294091f, 0.06641648f, 0.03040325f, 
    0.00239491f, -0.01946292f, -0.07362960f, -0.05756648f, -0.03088306f, -0.00779991f, -0.02404810f, -0.00649890f, 
    0.03168850f, -0.01011070f, -0.10543022f, 0.02465599f, -0.04325986f, 0.04606062f, -0.00080432f, -0.05720252f, 
    -0.06581767f, -0.08410884f, 0.00684924f, -0.00806497f, -0.08732338f, 0.04614945f, -0.03251152f, -0.07759339f, 
    -0.09790599f, -0.02935160f, -0.01200169f, -0.03220933f, -0.01537985f, 0.08416877f, -0.00823444f, 0.05550007f, 
    -0.10616653f, 0.04465670f, -0.07440424f, -0.02871552f, -0.06881209f, 0.03520357f, -0.01540205f, -0.10875367f, 
    -0.09326903f, -0.07572196f, -0.01971453f, -0.05104484f, -0.04201225f, 0.02654227f, -0.02600391f, 0.05726674f, 
    -0.08916780f, 0.03272500f, -0.04914910f, 0.04590938f, 0.02167771f, 0.06440452f, -0.06161699f, -0.01662246f, 
    -0.11288187f, -0.03544055f, 0.01642335f, 0.02086611f, -0.00821952f, -0.08716491f, -0.04223926f, 0.04746350f, 
    -0.01085670f, -0.00021471f, -0.02851572f, 0.02591178f, -0.05274643f, -0.08909107f, 0.03426521f, -0.10404571f, 
    -0.09254979f, 0.01359584f, 0.00832119f, -0.00664165f, -0.07369388f, -0.00076498f, -0.07124574f, -0.03224160f, 
    0.00873415f, -0.01818017f, -0.09630737f, 0.05122441f, -0.06909815f, 0.05471465f, -0.04296047f, -0.06995753f, 
    0.04697179f, -0.08834425f, 0.02480173f, -0.20228693f, -0.11519739f, 0.08359662f, 0.40197071f, 0.19573189f, 
    0.01852256f, -0.03003650f, 0.22772336f, -0.20922938f, -0.41281492f, -0.05563489f, 0.00142366f, -0.28606156f, 
    0.23398410f, 0.00156077f, 0.03018737f, -0.19033863f, 0.03720621f, -0.04753472f, 0.08430667f, 0.06432171f, 
    0.03936872f, 0.10767903f, -0.09580812f, -0.19908623f, 0.15690495f, 0.02560095f, -0.04919146f, 0.06467646f, 
    -0.30685198f, -0.04389521f, -0.04682158f, -0.19724810f, 0.31183970f, -0.03153694f, 0.06538618f, -0.10300602f, 
    0.13233508f, 0.01803668f, 0.00517556f, -0.05312428f, -0.22014804f, -0.02353600f, -0.03422918f, -0.02047412f, 
    -0.16247727f, -0.14456742f, 0.11767154f, 0.04380270f, -0.66876751f, -0.08527718f, 0.28553194f, 0.07558724f, 
    -0.04815418f, -0.04597123f, 0.17911743f, -0.19756550f, 0.12749675f, -0.17023316f, -0.10690471f, 0.36554995f, 
    -0.11395916f, -0.21893668f, 0.00725044f, 0.10246075f, -0.23531166f, 0.02354883f, -0.44048497f, 0.13652870f, 
    0.02701437f, 0.19893607f, 0.38920432f, 0.10171304f, -0.25096023f, 0.33696136f, -0.17169842f, 0.02436439f, 
    0.21143800f, -0.18229556f, 0.21977279f, 0.31363988f, -0.07488219f, -0.07548967f, 0.16529971f, -0.04386975f, 
    -0.13961253f, 0.24569580f, 0.02762469f, 0.08849052f, 0.09881171f, 0.45896798f, 0.40722543f, 0.19496851f, 
    0.00122601f, -0.39186701f, 0.07493144f, 0.76930451f, 0.28918868f, 0.06586009f, -0.14175148f, 0.27226263f, 
    0.28950882f, 0.84797966f, -0.17563535f, 0.04868503f, 0.13853738f, -0.08197960f, -0.47684744f, -0.16777585f, 
    0.03997503f, 0.16025817f, 0.06179898f, -0.05210909f, 0.06922361f, 0.00578115f, 0.12461612f, 0.18951757f, 
    0.03294512f, -0.14837041f, 0.25958923f, -0.19591460f, -0.35642639f, -0.02500297f, 0.02097549f, -0.06440607f, 
    0.06909473f, -0.10948411f, 0.05227813f, 0.17855650f, -0.02283558f, 0.01685466f, 0.30984327f, -0.15216371f, 
    0.08444691f, 0.02442146f, -0.20087624f, 0.17951439f, -0.14302622f, 0.10155521f, 0.04873661f, 0.15673292f, 
    0.12100969f, 0.09383605f, 0.08522518f, -0.00024158f, 0.30017841f, 0.35635081f, 0.20732363f, 0.09985805f, 
    -0.21073665f, 0.01330536f, 0.22022702f, 0.24476476f, 0.42452830f, -0.31796351f, 0.01335717f, 0.01731244f, 
    -0.80507112f, -0.04203460f, 0.11523425f, -0.01295320f, 0.01752535f, 0.38342777f, 0.04342418f, -0.10870722f, 
    -0.19511031f, 0.07552528f, 0.03674207f, 0.01467284f, -0.10729389f, 0.09125465f, 0.00055544f, -0.17458872f, 
    -0.15193547f, -0.10911036f, 0.12358583f, -0.06509868f, -0.17333002f, 0.00139610f, 0.33808300f, -0.02137385f, 
    -0.12411297f, 0.02679406f, 0.16620433f, 0.06518360f, 0.17818986f, 0.28203830f, 0.06443288f, 0.00598386f, 
    0.09814724f, 0.28592107f, -0.04338110f, 0.11663555f, -0.08720715f, -0.04270974f, 0.09535831f, 0.12942773f, 
    -0.06245227f, -0.08770147f, 0.04603586f, 0.07073934f, 0.02255369f, 0.16789041f, 0.05680904f, 0.04831271f, 
    0.06705955f, 0.16098218f, -0.00375855f, 0.49455667f, -0.26443005f, 0.19370580f, -0.03829726f, 0.25261754f, 
    -0.03367716f, -0.01088445f, 0.03566490f, 0.01533062f, 0.23472905f, 0.41092491f, 0.11847447f, 0.53256619f, 
    0.03808344f, -0.25697157f, 0.11496872f, 0.27168581f, 0.00137850f, 0.19244234f, -0.15150684f, -0.01232285f, 
    0.32455644f, -0.36943263f, 0.16321468f, -0.10316940f, 0.00289652f, 0.06394584f, -0.06390399f, 0.27625170f, 
    0.04708215f, 0.00354707f, -0.13799784f, 0.01504674f, -0.65929365f, -0.19540042f, 0.02800927f, -0.05486723f, 
    0.01593741f, -0.52444267f, 0.01123237f, 0.31871518f, 0.19694453f, 0.14445075f, -0.06993886f, -0.44982293f, 
    0.13544609f, -0.00343676f, 0.20472410f, -0.04793071f, -0.09623957f, -0.00404662f, -0.11986776f, -0.22472072f, 
    0.03602961f, -0.00350726f, -0.12084126f, 0.05513520f, -0.09522454f, -0.04088697f, -0.17550343f, 0.00228670f, 
    -0.12835976f, 0.07509396f, -0.06815198f, 0.26927698f, -0.42956063f, 0.25744414f, -0.20187889f, 0.09007424f, 
    -0.05703713f, 0.00313231f, 0.08408926f, 0.36432984f, -0.12229899f, 0.00641696f, 0.06071008f, 0.22719903f, 
    0.28789619f, -0.01138895f, -0.00700639f, -0.39662629f, 0.23280323f, 0.00193585f, 0.03769683f, 0.05522112f, 
    -0.12307777f, -0.04377934f, 0.00904300f, -0.01232677f, 0.05116263f, 0.26853925f, 0.00563608f, 0.15612075f, 
    -0.54635942f, -0.08165959f, -0.10906341f, 0.25371674f, -0.34787199f, -0.12347382f, 0.23283981f, 0.16962440f, 
    0.03993063f, 0.08554231f, -0.06347660f, -0.00917436f, -0.29571927f, 0.18355685f, 0.26913574f, -0.36243397f, 
    -0.05209177f, -0.07143456f, 0.01709861f, 0.04824632f, -0.06276358f, -0.01994133f, 0.14325006f, 0.01095384f, 
    0.04956859f, 0.18791905f, 0.09266438f, -0.34482586f, 0.08748423f, -0.08072758f, 0.08500951f, -0.09949230f, 
    0.34834695f, -0.04803696f, -0.11143070f, -0.03411166f, 0.26257932f, -0.03948143f, 0.01927707f, 0.18248111f, 
    0.16949883f, 0.12163563f, 0.31701443f, -0.07914845f, 0.16367786f, 0.13436428f, -0.22036146f, 0.13217543f, 
    -0.07195996f, 0.11309561f, 0.10460156f, -0.24987736f, 0.08000789f, 0.39285994f, -0.02585179f, -0.07517877f, 
    -0.13281679f, -0.10242933f, 0.09695550f, -0.06272970f, 0.28209361f, 0.06321091f, -0.01508256f, 0.15715912f, 
    -0.04425982f, -0.07293949f, 0.16370742f, 0.22545183f, -0.38620478f, -0.05773804f, 0.08984072f, 0.02373766f, 
    -0.06912408f, 0.06585044f, 0.00993384f, 0.16309941f, -0.08136038f, 0.20002000f, -0.07285506f, 0.02349227f, 
    0.21802977f, 0.27439663f, 0.21938576f, 0.04222384f, 0.08039623f, 0.37466446f, -0.20260856f, 0.45299509f, 
    -0.28626969f, -0.08790818f, 0.04731065f, -0.08093227f, 0.05394749f, -0.20779406f, 0.06567187f, 0.03521010f, 
    0.22855769f, -0.20459186f, 0.03544972f, -0.05949408f, 0.19583876f, -0.30420494f, -0.04697788f, -0.01376346f, 
    0.23795916f, -0.06474252f, 0.27677530f, -0.07287809f, 0.20250697f, 0.19036636f, -0.00168368f, -0.05547601f, 
    0.12220352f, 0.16188771f, -0.04839953f, -0.20200042f, -0.11105876f, 0.08678834f, -0.01153406f, 0.27153638f, 
    -0.11746154f, -0.03609455f, 0.00738415f, 0.01815402f, -0.07155799f, 0.09700383f, 0.02559894f, -0.92508584f, 
    -0.55897588f, 0.07373451f, -0.12174086f, -0.25905094f, -0.08112343f, -0.04201749f, 0.17963436f, -0.05292689f, 
    -0.09881875f, 0.14353231f, -0.21158506f, 0.12265233f, 0.01250858f, 0.02434606f, -0.12491484f, -0.18844010f, 
    -0.04048638f, -0.11743916f, 0.06981540f, -0.23207033f, -0.08800839f, 0.07966660f, -0.15818684f, 0.09780234f, 
    0.12589240f, 0.06222460f, -0.12785667f, 0.20804690f, 0.15400574f, 0.25280061f, 0.06199818f, 0.04180596f, 
    0.12334316f, -0.10118454f, 0.28200480f, 0.08721089f, 0.05528940f, -0.02186072f, 0.10525157f, -0.12026621f, 
    -0.17165633f, -0.32795346f, -0.00708914f, 0.26295123f, 0.13995630f, -0.02670133f, -0.01143372f, -0.10686042f, 
    -0.13655041f, -0.26687181f, -0.24800274f, -0.47995421f, 0.17617401f, -0.24233018f, 0.02080035f, -0.16648147f, 
    0.07604333f, -0.24878035f, 0.25489110f, -0.02115435f, -0.06293513f, 0.10866192f, -0.08090889f, 0.04448917f, 
    0.01251775f, 0.16850977f, 0.10331959f, -0.14254206f, -0.77331954f, 0.33398342f, -0.25168714f, -0.00105737f, 
    0.09296048f, -0.07706892f, 0.18913943f, -0.13031204f, -0.20709209f, 0.08635518f, 0.07193701f, -0.07576702f, 
    0.24661800f, -0.08200371f, 0.21029606f, 0.05150064f, 0.23068307f, 0.40877947f, -0.28404510f, 0.15159155f, 
    -0.13519491f, -0.07555690f, -0.41067746f, -0.04596903f, 0.17383227f, -0.22710815f, 0.15967092f, 0.11442191f, 
    0.01822701f, -0.41592696f, 0.00112011f, 0.06679573f, 0.07375229f, -0.51639634f, 0.07543261f, -0.10730491f, 
    0.17613222f, 0.04954132f, 0.21319352f, 0.09361744f, 0.38613722f, 0.31837174f, -0.01186113f, -0.07014068f, 
    0.17249413f, 0.03652025f, -0.08806508f, -0.09483417f, -0.09242730f, 0.21343228f, -0.05321128f, 0.13701934f, 
    0.03590966f, 0.00572149f, -0.01795034f, 0.14575300f, 0.07892818f, 0.01725969f, -0.08464144f, -0.31792063f, 
    -0.21944015f, 0.10407748f, -0.07362228f, -0.29080185f, -0.22367553f, 0.20517832f, 0.25485244f, 0.03468214f, 
    0.14096072f, 0.15657201f, -0.30475315f, 0.04131545f, -0.07008936f, -0.06101934f, -0.16197391f, -0.31497413f, 
    0.11392432f, 0.01819620f, 0.04389097f, -0.30281678f, 0.09213154f, 0.01912556f, -0.07200002f, 0.36953065f, 
    0.08837249f, -0.01113611f, -0.16761212f, 0.09651419f, -0.03125606f, 0.13674764f, -0.04266567f, 0.15675086f, 
    0.12401836f, 0.20004842f, -0.00810528f, 0.07757143f, 0.43482247f, 0.11473750f, -0.02431734f, 0.10592529f, 
    -0.01349168f, -0.14966413f, 0.01885546f, 0.20503797f, 0.22523905f, -0.41894835f, 0.13644390f, 0.12310609f, 
    -0.14463565f, -0.09519335f, -0.09419048f, -0.22230396f, -0.18175347f, -0.15526675f, 0.02431102f, -0.13190754f, 
    0.21142375f, -0.38827670f, 0.06878732f, -0.09958945f, 0.28600660f, 0.20785402f, 0.14555301f, 0.15696600f, 
    0.12851971f, 0.14986089f, 0.12739380f, -0.39433643f, -0.06803196f, -0.10054518f, -0.13564019f, 0.03963459f, 
    0.09035811f, 0.19329199f, -0.06800517f, 0.13980116f, 0.10984037f, -0.08450561f, 0.10070101f, 0.13892102f, 
    0.06398757f, 0.03809723f, -0.03965653f, -0.05608702f, -0.06819074f, -0.10547272f, -0.07617684f, 0.00586555f, 
    -0.00520676f, -0.00525084f, -0.03179494f, 0.02082973f, -0.03764101f, -0.09466325f, -0.02183415f, -0.08886367f, 
    -0.06335152f, -0.06336930f, 0.00415083f, -0.08768570f, -0.01169870f, -0.01377558f, -0.00136512f, -0.06416661f, 
    0.05586438f, 0.06434961f, -0.02620305f, 0.00461512f, -0.02623479f, 0.00820500f, 0.07246733f, 0.01123389f, 
    0.05278943f, 0.06164794f, -0.03195522f, 0.01349124f, -0.00743292f, -0.01755606f, -0.08070606f, 0.01163936f, 
    -0.08642831f, 0.02236467f, 0.01077130f, 0.03933834f, 0.05914151f, 0.04289471f, -0.04589998f, -0.06976052f, 
    0.00835607f, -0.01994973f, -0.05561451f, -0.04247391f, 0.04624537f, -0.04307478f, -0.07842640f, -0.06554247f, 
    0.00531006f, 0.03435017f, -0.06184304f, 0.01639731f, -0.08220107f, -0.07510407f, -0.04771207f, -0.06238836f, 
    0.00119274f, -0.02432678f, -0.07290790f, -0.01470428f, 0.03723058f, 0.03289175f, -0.08580724f, -0.06362808f, 
    -0.04538773f, 0.01014804f, 0.01531968f, -0.01518746f, -0.05317336f, -0.02428479f, -0.04604310f, -0.10519586f, 
    0.02907941f, 0.03257874f, -0.00255962f, 0.03538416f, -0.06905542f, 0.03366305f, 0.04429885f, -0.03984020f, 
    -0.07902803f, 0.00708393f, -0.10807387f, -0.03533148f, 0.01916475f, 0.04197916f, 0.06491469f, -0.01343811f, 
    -0.10750361f, -0.06298532f, -0.08604734f, -0.05821856f, -0.09927363f, 0.02125302f, 0.01006498f, 0.04369124f, 
    -0.10379533f, -0.08458665f, -0.10610109f, 0.01260473f, 0.01293461f, -0.01484048f, 0.03133945f, -0.00243874f, 
    -0.09780499f, -0.07769224f, 0.01019805f, -0.05650933f, -0.06016105f, 0.05322138f, 0.05581099f, -0.07596818f, 
    -0.10783821f, -0.09566917f, -0.07081901f, -0.00918047f, -0.10965329f, 0.04140295f, -0.10690307f, -0.04092330f, 
    -0.21767849f, -0.02305058f, -0.28707123f, -0.24292514f, -0.19043431f, 0.04945034f, 0.47655392f, -0.04186413f, 
    -0.18832476f, 0.02177069f, -0.17057164f, 0.05423829f, 0.26285350f, 0.04999845f, 0.05823122f, -0.01164387f, 
    0.02457874f, -0.08061222f, 0.06968094f, -0.39023703f, 0.23459265f, -0.30542216f, 0.10613938f, 0.10158928f, 
    0.09049016f, -0.10398644f, -0.00561869f, -0.30063018f, -0.10994510f, 0.21539536f, 0.03592275f, -0.39165595f, 
    -0.05810324f, 0.16323908f, 0.09353799f, 0.19778569f, -0.02747263f, 0.25448260f, -0.00075645f, -0.20678279f, 
    0.26981974f, -0.04905609f, -0.09425339f, -0.23081081f, 0.03427152f, -0.08683525f, 0.07332303f, -0.34903452f, 
    -0.65949708f, 0.14538217f, 0.19227669f, -0.18068065f, 0.02707570f, 0.22325379f, 0.10173874f, -0.07138380f, 
    0.04328676f, -0.13817224f, 0.09935869f, -0.20689723f, -0.05225923f, 0.06046639f, 0.03005696f, 0.13736397f, 
    -0.17603366f, 0.12987097f, 0.04907440f, -0.21661685f, -0.17056587f, -0.00498391f, -0.19837146f, -0.13720554f, 
    0.13960429f, -0.07648008f, -0.06440840f, 0.12478013f, 0.12632094f, 0.02632896f, 0.00666678f, 0.16497044f, 
    -0.39166939f, -0.11337282f, -0.11947923f, 0.07180650f, 0.09113331f, 0.15830246f, 0.00702453f, 0.16357349f, 
    0.17791100f, -0.00820639f, -0.15171073f, -0.13547119f, -0.10991979f, 0.07240600f, 0.26303974f, -0.38237724f, 
    0.16114692f, -0.52311409f, -0.35231811f, 0.26655412f, -0.05743803f, -0.23039663f, 0.27578393f, 0.16269188f, 
    0.12755120f, 0.16614728f, -0.34314820f, -0.00324948f, -0.42554095f, -0.03043366f, -0.00909103f, -0.13283807f, 
    -0.10281056f, 0.31250763f, 0.09325415f, -0.16941512f, 0.00949224f, -0.07114086f, -0.01090994f, 0.17981884f, 
    -0.10136455f, 0.16057615f, 0.13701148f, -0.17932914f, 0.03181336f, -0.21123011f, 0.21413389f, -0.11394680f, 
    0.00305548f, 0.06234305f, 0.27398932f, -0.08559930f, -0.02421224f, 0.09661706f, -0.72852904f, -0.45370844f, 
    0.28744680f, -0.00782960f, 0.13463965f, 0.02498403f, 0.01048129f, -0.27982089f, -0.17212354f, 0.06211108f, 
    -0.08459365f, -0.38233230f, 0.02492716f, 0.17007597f, -0.13264270f, -0.28806973f, -0.25527444f, -0.05363483f, 
    0.28987563f, -0.06391085f, 0.12517112f, 0.14973202f, -0.10028517f, 0.14457701f, -0.09204539f, 0.13940747f, 
    0.42623979f, -0.10048347f, 0.09666996f, -0.21625823f, 0.25001541f, -0.32455185f, -0.03391877f, 0.22947483f, 
    -0.14752884f, 0.01937586f, 0.02403050f, 0.01464463f, -0.07638423f, 0.11434055f, 0.03582671f, -0.19495143f, 
    -0.50443524f, -0.13971120f, -0.31408143f, 0.21552233f, 0.06089310f, -0.33491698f, 0.34243056f, 0.12831554f, 
    -0.24157898f, 0.31441265f, -0.24291761f, 0.10280485f, -0.25538969f, 0.15735988f, -0.44458809f, -0.05813976f, 
    -0.16283207f, -0.05957359f, 0.08212984f, -0.41930681f, -0.67827260f, 0.05104538f, 0.14064604f, 0.00142815f, 
    0.03363395f, -0.06924772f, 0.29129118f, -0.13175918f, 0.23777631f, 0.16119710f, 0.13627523f, -0.31250286f, 
    0.28238004f, -0.03233024f, 0.05684252f, 0.07198258f, 0.06996994f, -0.05319963f, -0.06950761f, -0.02373166f, 
    0.03034322f, -0.29238194f, 0.17703862f, 0.08402187f, 0.05965514f, 0.15229794f, -0.25939697f, 0.12857504f, 
    0.03312967f, -0.15045315f, -0.19633888f, -0.20563646f, 0.16949870f, -0.05512118f, -0.07278963f, -0.20486356f, 
    -0.26057860f, 0.33906493f, 0.11349522f, 0.04899897f, 0.30222353f, 0.10809060f, -0.01361301f, 0.01501121f, 
    0.09144823f, -0.03040223f, 0.22773826f, 0.23555318f, 0.21978916f, -0.14280234f, -0.04340557f, 0.03648531f, 
    0.15622632f, 0.38439944f, -0.20769796f, -0.00175337f, 0.01864968f, 0.16542098f, -0.01929072f, 0.21282336f, 
    -0.04134307f, 0.23851255f, -0.21550685f, 0.17907818f, 0.21129496f, -0.46768218f, 0.43329412f, 0.36031726f, 
    0.04462772f, 0.06815923f, 0.36811376f, 0.09260012f, 0.23257710f, 0.40404740f, 0.07045655f, 0.09708133f, 
    -0.07615112f, 0.51264089f, 0.06313668f, -0.08254895f, 0.11015255f, 0.49460083f, 0.14698562f, 0.03874747f, 
    -0.26028657f, -0.05370428f, -0.04432774f, 0.03634351f, -0.12341017f, -0.03851185f, 0.08192524f, -0.14842083f, 
    -0.11970114f, 0.05370279f, 0.12284175f, 0.14034460f, -0.39637455f, 0.11021363f, -0.02921898f, -0.05250993f, 
    -0.00008431f, 0.00520444f, -0.02311455f, 0.03144023f, 0.06337288f, -0.06205350f, -0.07311707f, 0.25757110f, 
    0.54700273f, 0.18594939f, 0.12083512f, -0.36400625f, 0.06575842f, 0.05468541f, -0.33094975f, 0.00537315f, 
    0.23192854f, -0.02654349f, 0.18240605f, 0.12531456f, 0.24546394f, 0.08043297f, 0.42166382f, 0.04258854f, 
    -0.02461374f, 0.17681371f, -0.05129304f, 0.16006866f, 0.05933256f, 0.03402986f, 0.06180332f, -0.46404678f, 
    0.09187923f, 0.14610866f, -0.22056654f, 0.18169443f, 0.08706818f, -0.17357187f, 0.06564143f, 0.06243450f, 
    -0.65329826f, 0.06478877f, 0.03406890f, -0.35728502f, -0.11059429f, 0.06023408f, -0.03670770f, -0.24962282f, 
    0.21685012f, 0.26264352f, -0.11263420f, -0.08189993f, -0.05964787f, -0.01448783f, -0.12110719f, -0.05059794f, 
    0.23579462f, 0.21714196f, -0.04818027f, -0.32001674f, -0.21756400f, 0.00975147f, 0.25105298f, 0.08718875f, 
    -0.18039022f, 0.11711603f, 0.11781793f, 0.01006141f, -0.73442370f, 0.14011616f, 0.09786893f, 0.02981449f, 
    -0.19176976f, -0.00715833f, -0.21699649f, 0.03268453f, 0.36465567f, 0.09989085f, -0.09570391f, 0.02310221f, 
    -0.06271039f, -0.05365515f, 0.00318091f, -0.32684323f, 0.03816909f, 0.09382018f, -0.01352578f, 0.03691399f, 
    0.00845923f, -0.07171297f, 0.01288252f, 0.02785826f, 0.00083810f, 0.00222783f, 0.05219131f, -0.06089867f, 
    0.05081445f, -0.02874340f, -0.08637061f, -0.05600786f, -0.07875661f, 0.01333154f, 0.03283565f, -0.00183520f, 
    -0.05757735f, 0.01642966f, 0.07731433f, -0.03893987f, -0.04386335f, 0.02675064f, -0.05042605f, -0.09210452f, 
    0.00693310f, 0.04713389f, 0.02280706f, 0.00780592f, -0.03463951f, 0.00788995f, 0.03003827f, -0.00662076f, 
    0.01111045f, -0.04523003f, -0.11876359f, -0.00012021f, -0.01220850f, 0.03155826f, -0.02338048f, -0.02324220f, 
    0.00619344f, 0.03095937f, 0.07416310f, -0.02407743f, -0.07852345f, -0.01918991f, -0.01050966f, -0.07092228f, 
    0.03932194f, -0.04860083f, 0.02193985f, -0.02541075f, 0.08573260f, -0.03241505f, 0.01028334f, -0.09091734f, 
    0.06362456f, -0.09062494f, -0.05440819f, -0.07748891f, 0.04100867f, 0.02759558f, 0.02777481f, -0.10463312f, 
    -0.02877294f, 0.05795190f, -0.03065018f, 0.00204009f, -0.11347315f, -0.02365797f, -0.11388028f, 0.03468110f, 
    0.03135078f, 0.01797438f, 0.03505139f, -0.03310298f, -0.07181843f, 0.00561985f, 0.04604963f, -0.01257947f, 
    -0.10727356f, -0.10544140f, 0.03088150f, 0.02275643f, -0.03349838f, 0.04150119f, -0.04113784f, -0.05533116f, 
    -0.04602612f, 0.02469231f, -0.07491278f, 0.01341759f, -0.01311400f, -0.07062693f, 0.01272300f, -0.08265226f, 
    0.04672506f, 0.01091108f, -0.08126908f, -0.07319793f, 0.03802997f, -0.04722288f, -0.09453239f, -0.10042158f, 
    -0.06535703f, -0.07087782f, -0.04292927f, -0.00713413f, -0.07421338f, 0.00924699f, -0.06904152f, 0.05373543f, 
    -0.01114349f, 0.00335407f, 0.04138150f, -0.03748126f, -0.06063154f, 0.03553885f, -0.02558458f, -0.00194037f, 
    -0.02394958f, -0.02199183f, 0.03477076f, -0.09527709f, -0.05362732f, -0.00839289f, -0.03300600f, -0.09977883f, 
    -0.24841687f, 0.14410360f, -0.11790211f, -0.19986434f, -0.16458024f, -0.31536004f, -0.36602372f, -0.13747793f, 
    0.01975713f, 0.06622044f, 0.28204158f, 0.09358966f, -0.00507889f, 0.02090512f, 0.22907041f, -0.05896609f, 
    0.08498921f, 0.26220387f, 0.01337378f, 0.08901435f, -0.19303358f, 0.00578430f, -0.07187765f, 0.02047792f, 
    0.02929930f, -0.01705782f, -0.42020029f, 0.13075663f, -0.23105833f, -0.07509709f, -0.01974910f, 0.04970512f, 
    0.11493075f, 0.02905195f, 0.01593453f, 0.10361427f, -0.03083372f, -0.14990990f, -0.00197093f, 0.28998339f, 
    0.14503929f, 0.02641900f, -0.11207323f, 0.07863825f, -0.00768174f, 0.09517242f, 0.01026654f, 0.12453809f, 
    0.10476708f, -0.01149138f, -0.00900222f, 0.06048719f, 0.17182225f, -0.08710030f, -0.11109985f, 0.14342134f, 
    0.07753741f, -0.05477623f, -0.00111336f, 0.05885652f, 0.30323875f, -0.36814371f, -0.06534540f, 0.08963059f, 
    -0.04086998f, -0.17075379f, -0.06143327f, 0.16515408f, -0.10356644f, -0.00092022f, 0.21025243f, -0.18399650f, 
    0.11420500f, -0.03385402f, 0.12496717f, -0.00929873f, -0.04020308f, 0.00960499f, -0.04158225f, -0.10148685f, 
    0.00486155f, -0.14203578f, 0.10314621f, -0.28941762f, 0.10147860f, -0.10649782f, 0.08881175f, 0.17355117f, 
    0.06569821f, -0.18287915f, 0.09474725f, 0.08055671f, 0.02375858f, 0.03053295f, -0.21520361f, -0.08277429f, 
    0.09869307f, 0.22740960f, -0.08874730f, -0.14902630f, 0.09705077f, 0.11006116f, 0.04356575f, -0.09866117f, 
    -0.34105575f, -0.07051452f, 0.08271192f, -0.00670153f, -0.33884537f, -0.00018755f, 0.03294634f, -0.08179389f, 
    0.18435502f, -0.19633110f, -0.00329444f, 0.40467140f, -0.05308960f, 0.30137846f, -0.03252533f, 0.08654328f, 
    0.11823193f, 0.08799736f, 0.00522787f, 0.09557682f, 0.02283887f, 0.10572772f, 0.06798005f, -0.04318691f, 
    -0.07532246f, -0.10044739f, 0.05655473f, -0.02786417f, -0.02509846f, -0.04278591f, -0.07862408f, -0.04687705f, 
    0.04741172f, -0.08505712f, -0.08234718f, 0.04486808f, -0.06713550f, -0.11364936f, 0.01878072f, -0.01941198f, 
    -0.05332975f, 0.07930747f, -0.03593102f, 0.04308413f, 0.03532951f, -0.02291358f, -0.02833364f, -0.10187335f, 
    0.05302151f, 0.00351754f, 0.00558564f, -0.11167584f, 0.01594121f, 0.00617649f, 0.02052484f, -0.04228812f, 
    -0.04724905f, -0.05223019f, 0.05607813f, -0.08330373f, -0.05710612f, -0.05568447f, -0.06081308f, 0.03433980f, 
    0.05031126f, -0.02549347f, -0.05436919f, -0.02155297f, -0.07533930f, -0.00103739f, 0.06887183f, 0.08176873f, 
    -0.07668046f, -0.02008835f, -0.08491655f, -0.05514670f, 0.08038148f, 0.01967276f, 0.00820995f, -0.11102078f, 
    0.03293137f, -0.01153620f, 0.03520167f, 0.02962029f, -0.05303156f, 0.04779862f, -0.08195690f, -0.04594845f, 
    0.02484457f, -0.11283870f, 0.03361697f, -0.09262078f, -0.02927257f, 0.06105423f, -0.03518704f, -0.09694711f, 
    -0.11512596f, -0.09025726f, -0.05549064f, -0.08628473f, 0.04415977f, 0.02566854f, 0.00998748f, -0.04194208f, 
    -0.06907204f, -0.05833383f, 0.03503729f, -0.07882548f, 0.00720291f, -0.02309989f, -0.11595052f, 0.00276310f, 
    -0.10319348f, -0.05477420f, -0.07975870f, -0.10853671f, -0.05630901f, -0.07978178f, 0.02472508f, -0.01589568f, 
    0.03605636f, -0.03405698f, 0.02372806f, 0.03650566f, -0.06803095f, -0.06716387f, -0.09611485f, -0.06658579f, 
    0.04935794f, 0.02934173f, -0.03490957f, -0.04318685f, -0.08741763f, -0.10569271f, 0.07261547f, -0.03148689f, 
    0.00567450f, -0.06273577f, 0.02809819f, 0.02682359f, -0.04586207f, -0.05459240f, 0.06888856f, -0.05190363f, 
    -0.05340365f, -0.06118711f, -0.01172104f, -0.07584176f, -0.00547649f, -0.08273412f, -0.03655550f, -0.06616638f, 
    0.07027021f, 0.07042407f, -0.14282140f, 0.44921795f, 0.41529825f, -0.06811901f, 0.00763995f, -0.08770394f, 
    -0.32791948f, -0.05573203f, 0.02881041f, -0.06115516f, -0.28693441f, 0.10756347f, 0.22229096f, 0.02641700f, 
    0.33615717f, 0.08830426f, 0.00982240f, 0.05085139f, 0.06454661f, 0.30408335f, 0.03602148f, 0.03422883f, 
    -0.34128821f, 0.03519591f, 0.11246158f, 0.13697658f, 0.37011528f, -0.14114988f, 0.02160458f, 0.04029836f, 
    -0.40690389f, -0.03863818f, -0.07281682f, 0.04610116f, 0.00025814f, -1.00143218f, 0.04279929f, -0.25435939f, 
    0.11046232f, -0.10721973f, 0.07656193f, 0.18028770f, 0.08178872f, 0.14662451f, -0.05180881f, 0.41603225f, 
    -0.00909310f, 0.12020668f, 0.13203470f, -0.08344374f, 0.05001010f, -0.01706717f, 0.19427614f, 0.06583418f, 
    -0.22488007f, 0.04008278f, 0.22646545f, 0.19338240f, 0.31014177f, -0.18869795f, 0.34567854f, 0.16333845f, 
    0.01765132f, 0.01252697f, -0.06043385f, 0.33390105f, 0.18323383f, -0.04507312f, 0.06204122f, 0.06320470f, 
    -0.09374924f, 0.17253290f, -0.07016801f, 0.16186418f, -0.01045338f, 0.00224296f, -0.32912794f, 0.17060237f, 
    0.32066411f, 0.08408393f, 0.26214960f, 0.23154910f, -0.23901021f, -0.16345826f, 0.07692160f, -0.09409238f, 
    -0.10797700f, 0.32379076f, 0.07323224f, 0.12071487f, 0.25343671f, -0.06815122f, -0.13581660f, -0.10554707f, 
    -0.18908136f, 0.38846931f, 0.01489708f, 0.09100155f, 0.22376375f, 0.27455300f, -0.28895560f, -0.20604201f, 
    0.07466787f, -0.36914149f, -0.00405754f, 0.06406791f, 0.03692915f, 0.05797872f, -0.17245181f, 0.17078950f, 
    0.22286250f, -0.11490186f, -0.14663617f, -0.11808269f, -0.09500846f, -0.18112153f, 0.07221169f, -0.10900973f, 
    -0.24282847f, -0.47563952f, 0.19874820f, -0.19532506f, -0.08192006f, 0.13186313f, -0.26676437f, -0.30641380f, 
    -0.09407961f, 0.04756175f, -0.24293919f, 0.08531357f, -0.05511115f, 0.13613141f, 0.22677474f, 0.20811978f, 
    0.02087660f, 0.02714654f, -0.01860464f, -0.08086958f, 0.08363447f, 0.08657912f, 0.28146824f, -0.04237317f, 
    0.18598510f, 0.00582988f, -0.03683944f, -0.09682513f, 0.41721195f, -0.13193700f, 0.11781152f, -0.03348094f, 
    0.02795148f, -0.06016405f, -0.22524135f, -0.09682091f, 0.27451608f, -0.01113443f, 0.08536705f, 0.02186078f, 
    -0.06644844f, 0.03251421f, -0.13144757f, 0.18672253f, -0.03854591f, 0.00370310f, 0.07196677f, 0.05826762f, 
    0.24560603f, -0.04401040f, -0.05452234f, 0.08599144f, 0.01536743f, -0.14670250f, -0.05546664f, -0.04810258f, 
    0.37054539f, 0.10179600f, 0.14652441f, -0.17427886f, -0.02800809f, 0.36033514f, -0.44292256f, 0.01281243f, 
    0.29230019f, -0.06974401f, 0.04137428f, 0.15117623f, 0.27441838f, -0.18408883f, 0.03823804f, 0.20521162f, 
    0.11758553f, -0.04160665f, -0.04879938f, 0.09694658f, 0.55798644f, -0.06993865f, 0.03261448f, 0.13617794f, 
    0.02214852f, 0.01379470f, -0.13210799f, 0.34920952f, -0.13251469f, 0.09132177f, -0.24696489f, 0.13624224f, 
    -0.10461865f, -0.14787272f, 0.35009575f, -0.06234132f, 0.12971433f, 0.00494766f, -0.06719048f, -0.01330625f, 
    -0.15154049f, 0.05308057f, -0.08297014f, 0.15481719f, -0.10652719f, -0.22813812f, 0.24159727f, -0.10818817f, 
    0.22779940f, 0.21185969f, 0.05344125f, 0.30743480f, 0.10027329f, -0.07720169f, 0.05427529f, 0.13176423f, 
    0.14179848f, -0.00300970f, -0.03645554f, 0.00837349f, -0.07864562f, -0.03631331f, 0.10495606f, -0.00385894f, 
    0.14642222f, -0.07301930f, -0.06911656f, -0.20368569f, 0.16125703f, 0.29470280f, -0.10701399f, 0.11183695f, 
    0.01391376f, -0.05826065f, 0.20176478f, 0.10139910f, 0.13370490f, 0.07827315f, -0.10300944f, 0.00850364f, 
    -0.06703343f, 0.06637555f, 0.05519891f, 0.04630873f, 0.07335076f, 0.07234396f, 0.06045539f, -0.02734236f, 
    -0.04524777f, 0.05060796f, -0.02098377f, -0.02893785f, 0.06391061f, 0.06214799f, -0.05659309f, 0.00740311f, 
    -0.05259399f, -0.10094287f, 0.06025294f, 0.06796716f, 0.02003761f, -0.08294537f, -0.08276735f, 0.05098912f, 
    -0.07904425f, -0.06963290f, -0.07651606f, 0.00987566f, 0.04667235f, 0.07926311f, 0.08530131f, 0.06078818f, 
    -0.03836724f, -0.00489241f, 0.08958960f, 0.06423704f, -0.02493466f, -0.04655655f, 0.02952351f, -0.07465593f, 
    -0.03057611f, -0.00209008f, -0.03710411f, 0.04342292f, -0.09516075f, -0.04439362f, 0.07753398f, 0.01098096f, 
    -0.04186122f, 0.01764523f, -0.05626407f, 0.03593680f, -0.07705996f, -0.04993438f, -0.01970583f, -0.01495497f, 
    0.08178740f, -0.03131966f, -0.06913344f, -0.09994481f, -0.04523422f, -0.02969379f, -0.01253495f, 0.06584679f, 
    0.01079966f, 0.07966104f, 0.02072794f, 0.03731469f, -0.02870805f, 0.06390539f, 0.03220287f, -0.07688107f, 
    -0.08487556f, 0.04142948f, 0.07919432f, 0.02393539f, 0.07306192f, 0.00762725f, -0.05015123f, -0.01209515f, 
    -0.04989241f, 0.01932281f, -0.00794626f, -0.01765563f, -0.10452555f, -0.00694845f, -0.01668740f, -0.00489340f, 
    -0.04206698f, -0.05286358f, -0.08810607f, -0.01210569f, 0.03263447f, 0.01741316f, -0.02191659f, -0.04598650f, 
    0.00472843f, 0.01190724f, -0.06148156f, 0.05214018f, 0.01070787f, 0.01182559f, -0.08837835f, 0.05209963f, 
    0.00532144f, 0.02314329f, -0.09199949f, 0.00589476f, 0.07711750f, -0.05692835f, 0.01839585f, 0.01961737f, 
    -0.07657094f, -0.06258097f, 0.03011777f, 0.02828528f, -0.03957688f, -0.02115413f, -0.03753812f, -0.00394271f, 
    0.00101823f, -0.07761841f, 0.00320923f, 0.01954268f, -0.06485841f, -0.01946220f, -0.07022237f, -0.04686776f, 
    -0.48774078f, -0.26127204f, -0.04159488f, 0.15408504f, 0.04845558f, -0.10714965f, -0.18179286f, -0.20199016f, 
    -0.28895330f, 0.04648661f, -0.21301103f, -0.29261646f, -0.43603474f, -0.19232240f, 0.07412074f, -0.07157739f, 
    0.29516843f, -0.18318231f, -0.06326343f, 0.05545646f, 0.40690011f, -0.43753678f, 0.00927764f, -0.11955229f, 
    0.06618647f, 0.05225052f, -0.09140468f, -0.04115318f, 0.24864310f, -0.10853197f, -0.02692143f, 0.15341677f, 
    -0.24918582f, 0.05174786f, 0.01949572f, -0.08871990f, 0.03528764f, -0.52544713f, 0.04693292f, 0.05129592f, 
    0.18548141f, -0.02860623f, 0.09602199f, 0.12417368f, -0.40054330f, -0.13398166f, -0.05344221f, -0.01406365f, 
    0.11954461f, 0.15094692f, 0.04087899f, -0.28846684f, -0.27925578f, 0.06616458f, 0.02220006f, 0.23612326f, 
    -0.13006553f, 0.01287060f, 0.26459053f, 0.04262154f, 0.49454689f, -0.27744946f, -0.78349352f, 0.16464287f, 
    0.27385321f, -0.43863806f, -0.05839282f, -0.00487910f, 0.21479291f, 0.04677187f, 0.00307887f, 0.10004733f, 
    -0.27207235f, -0.02188946f, 0.02546811f, 0.34972429f, 0.11264283f, 0.19510908f, -0.21052757f, 0.02129814f, 
    0.14035076f, -0.44729257f, 0.39254889f, 0.53372598f, -0.10847590f, -0.27838981f, 0.01769688f, -0.17512023f, 
    -0.19941193f, -0.04064497f, -0.00271318f, 0.22839403f, 0.05783124f, 0.33670095f, 0.03943108f, 0.04770251f, 
    0.13173202f, 0.23104219f, -0.03326560f, 0.17213105f, 0.35506999f, -0.00417808f, -0.20165841f, -0.26673907f, 
    0.08085309f, -0.37034228f, 0.02785931f, -0.09065063f, 0.26905927f, 0.14426096f, -0.36235377f, 0.05346910f, 
    0.32684052f, -0.22190291f, -0.11983854f, 0.02269626f, -0.49589735f, -0.01881626f, -0.17225222f, -0.09381510f, 
    0.25288215f, 0.03179490f, 0.38012689f, -0.00572147f, -0.31699982f, 0.39792341f, -0.35351205f, -0.06743369f, 
    -0.04757730f, -0.07887468f, 0.05681966f, 0.01209831f, 0.04783473f, -0.03817892f, 0.01768844f, -0.06541215f, 
    0.03116055f, 0.05860274f, -0.00701343f, -0.03593538f, 0.00474135f, -0.06335615f, -0.09638066f, -0.11061822f, 
    0.04913295f, -0.10382887f, 0.06803510f, -0.01538366f, -0.02714087f, -0.01287569f, 0.03526113f, -0.09030658f, 
    -0.05623004f, -0.04082358f, -0.00303828f, -0.02117605f, -0.04190477f, 0.04350265f, 0.06717794f, 0.01741610f, 
    -0.00340733f, -0.00534990f, -0.07572954f, -0.01465673f, -0.02357280f, -0.08535612f, 0.05741876f, 0.05304736f, 
    -0.00769802f, 0.02959044f, 0.02211642f, -0.10931831f, -0.07156918f, -0.01351031f, -0.01093964f, -0.10532303f, 
    -0.01560419f, 0.01967097f, 0.03515356f, -0.00841563f, -0.09280293f, -0.08036853f, -0.04959130f, -0.02974955f, 
    -0.03751223f, -0.00551595f, -0.02693327f, 0.04226540f, -0.11234516f, -0.03661514f, -0.08409353f, -0.01188378f, 
    -0.01679350f, -0.03391204f, -0.05605626f, -0.00654429f, -0.03000429f, -0.06119373f, -0.02601002f, 0.03238493f, 
    -0.01249949f, -0.06704613f, -0.06300588f, -0.06655248f, -0.05797564f, -0.05803253f, 0.04715307f, 0.03762991f, 
    -0.07340907f, 0.05977208f, -0.08685724f, -0.00727121f, 0.02644428f, -0.11529826f, -0.02806551f, 0.02394036f, 
    -0.01888297f, 0.03573831f, -0.05422290f, -0.06141590f, -0.11856942f, -0.10094558f, -0.05795087f, 0.00944325f, 
    -0.02813193f, 0.00356155f, -0.02897105f, -0.00287283f, 0.04318281f, -0.01041225f, 0.02182245f, -0.11492480f, 
    -0.07039967f, -0.05551135f, -0.04238553f, -0.04983150f, 0.05483819f, -0.05356642f, -0.04495833f, -0.08232792f, 
    -0.06346975f, -0.04910718f, -0.04713640f, -0.08821289f, -0.06778624f, -0.02212944f, -0.04694004f, 0.02352723f, 
    -0.09886824f, -0.11188172f, -0.06746549f, -0.04579449f, -0.01539899f, -0.01203772f, -0.10304758f, -0.10302206f, 
    -0.05460780f, -0.10404044f, -0.06813005f, 0.03052017f, -0.03582197f, 0.02145273f, 0.06395861f, -0.03810475f, 
    -0.02297358f, 0.07106101f, 0.07891437f, -0.04290774f, 0.06774804f, -0.00434095f, -0.04452813f, -0.09269689f, 
    -0.07533076f, -0.06521516f, 0.05228842f, -0.06896006f, 0.04570805f, -0.03202778f, -0.00774553f, 0.02108169f, 
    -0.04634706f, 0.02998233f, -0.02244460f, -0.02725940f, 0.04701724f, -0.06049160f, -0.05985473f, 0.04585329f, 
    -0.01473777f, -0.00891894f, -0.01278140f, -0.05778603f, 0.02885753f, 0.02299339f, -0.05539757f, 0.02989951f, 
    -0.04435534f, -0.01272757f, 0.02263185f, -0.03314589f, -0.05481414f, -0.06532256f, -0.02459809f, -0.02338774f, 
    0.03308382f, 0.06203234f, 0.04051852f, -0.00933434f, -0.05091016f, -0.03829965f, -0.02333431f, -0.04322362f, 
    0.01349821f, -0.07261834f, 0.05127763f, 0.00065070f, 0.04544574f, -0.04712990f, -0.00336572f, 0.06596434f, 
    -0.05002844f, 0.05664007f, -0.02807495f, -0.07947721f, -0.05385136f, -0.06210190f, 0.06336141f, 0.05118617f, 
    -0.09115653f, -0.01373589f, -0.03605539f, -0.05898431f, -0.04715507f, -0.05690785f, 0.03315772f, -0.04228894f, 
    -0.00814377f, -0.07695878f, 0.04697584f, -0.03037136f, 0.06444692f, 0.03442901f, 0.03607358f, 0.02776086f, 
    0.03917774f, -0.04710098f, 0.06860491f, 0.06427369f, 0.03798312f, 0.02447111f, 0.02445182f, 0.04306821f, 
    0.02905700f, 0.05927654f, -0.05624359f, -0.02653349f, -0.06462713f, -0.06565413f, -0.00095488f, -0.04529188f, 
    0.00168458f, -0.08975570f, 0.03304625f, -0.07434832f, -0.06289843f, 0.00520991f, 0.03157021f, -0.01308599f, 
    -0.00378253f, -0.09336498f, -0.04769871f, -0.00124294f, -0.08500145f, -0.04516927f, -0.00054672f, 0.04841916f, 
    -0.04507363f, 0.01540334f, -0.00547392f, -0.09916285f, 0.07335974f, -0.06963406f, 0.03688281f, -0.03479201f, 
    -0.07692079f, 0.05705318f, -0.18603441f, -0.26847893f, -0.06126359f, 0.27133229f, 0.36952057f, 0.28212816f, 
    0.30155349f, 0.03290544f, -0.23567885f, 0.07284702f, 0.20031522f, 0.10852789f, 0.08276779f, -0.01336075f, 
    -0.09466780f, 0.27719223f, 0.02227966f, 0.08391669f, 0.18643112f, 0.11148987f, 0.12720686f, -0.13614319f, 
    0.07139342f, -0.01846780f, -0.02199839f, -0.03540117f, -0.01213672f, 0.11011668f, 0.03073177f, -0.08538327f, 
    0.20356095f, 0.09760746f, -0.10954303f, -0.05041095f, -0.05437053f, 0.00907966f, 0.01828748f, 0.10754019f, 
    0.02388491f, -0.05959622f, -0.01811103f, 0.04227166f, 0.10570394f, 0.08909590f, -0.00029600f, 0.49246803f, 
    0.05793792f, 0.05967151f, -0.21546622f, -0.03559700f, -0.18916185f, 0.39356643f, -0.26519275f, -0.00378498f, 
    0.11437558f, 0.12952863f, -0.02060134f, 0.01106437f, -0.07222754f, 0.02427628f, 0.07335471f, -0.19596685f, 
    0.03622068f, -0.07549556f, -0.03038826f, -0.10256270f, 0.25633648f, 0.05095769f, 0.10094342f, 0.14467140f, 
    0.04872542f, 0.10983127f, -0.06651013f, 0.04951878f, -0.15684468f, -0.01261530f, -0.06676806f, 0.11082996f, 
    -0.08414242f, -0.09465060f, 0.07540745f, -0.14734316f, 0.44458649f, 0.28659749f, 0.06448589f, 0.08485147f, 
    0.16282389f, 0.07914189f, 0.02279755f, -0.15623342f, -0.00100450f, -0.13097492f, 0.16810834f, -0.14373465f, 
    0.15391412f, -0.33340999f, -0.11444906f, 0.09355447f, -0.11341358f, -0.02211964f, 0.11175214f, 0.15893099f, 
    0.16725034f, 0.39455870f, 0.00190054f, -0.04414237f, -0.05562750f, 0.11433861f, -0.03338842f, 0.19334519f, 
    -0.05258822f, 0.22597460f, 0.15125172f, -0.06181760f, 0.38457212f, 0.10923458f, 0.03828757f, -0.16536738f, 
    0.24303161f, 0.25309867f, 0.08263309f, 0.23581402f, 0.23358841f, -0.00946912f, 0.03681793f, 0.20717053f, 
    0.01521023f, 0.02079354f, -0.08176475f, -0.08281571f, -0.05204345f, -0.05342802f, 0.07965911f, 0.08504312f, 
    -0.01190650f, -0.00948927f, 0.07783984f, 0.06006594f, -0.01282155f, -0.09653812f, -0.01593177f, -0.02626618f, 
    0.00821862f, 0.04361866f, 0.08825900f, 0.05085728f, 0.02722511f, -0.05292389f, -0.05047642f, -0.04430436f, 
    0.04929074f, 0.07094536f, -0.05517545f, -0.11178168f, 0.01228064f, -0.00044589f, -0.04179350f, -0.07682639f, 
    0.00850657f, 0.04432127f, 0.01152301f, -0.04307386f, -0.06880154f, 0.04779746f, -0.01245459f, -0.06636845f, 
    0.00783808f, 0.02619196f, 0.04861632f, 0.01772201f, 0.01021979f, 0.04438527f, -0.05412386f, -0.03435162f, 
    0.00196595f, -0.09525341f, -0.00208780f, -0.02139774f, -0.06342110f, -0.03019202f, 0.01480180f, 0.04848746f, 
    0.02086394f, -0.08720493f, -0.03549789f, -0.06268203f, 0.00794506f, -0.02146219f, 0.05439264f, -0.08206542f, 
    0.03745449f, -0.00066023f, -0.04203433f, 0.01694343f, -0.02349599f, 0.04027097f, -0.07323745f, -0.10995915f, 
    -0.04861958f, -0.09589051f, -0.01356632f, -0.09897528f, -0.04788371f, -0.02249643f, -0.02024490f, -0.01880527f, 
    0.03593542f, -0.03581758f, 0.04749117f, 0.01578679f, -0.00416975f, 0.02758092f, -0.03785668f, 0.04698899f, 
    -0.00351343f, -0.03512534f, 0.00588069f, 0.02576061f, -0.08801551f, -0.04914678f, 0.04988031f, -0.05682575f, 
    -0.02810992f, -0.01150583f, -0.07402266f, 0.04905760f, 0.07391485f, 0.02582024f, 0.01137739f, -0.03461519f, 
    0.04607803f, -0.04802319f, -0.02752790f, -0.04629455f, -0.07108516f, -0.00534269f, -0.07951398f, -0.00930132f, 
    -0.01240403f, 0.01022060f, -0.05163034f, -0.02924964f, -0.01577845f, -0.04445712f, 0.00556539f, -0.01070523f, 
    0.00299973f, 0.02406459f, -0.10075383f, -0.03131802f, 0.01622378f, -0.05719599f, 0.04990384f, -0.08146663f, 
    0.15400800f, 0.17207438f, 0.18955021f, 0.00855280f, -0.09057172f, -0.03109103f, -0.28363410f, 0.05151454f, 
    0.05735175f, -0.01531159f, -0.01807191f, 0.06256943f, -0.03874433f, 0.20542210f, -0.04881573f, -0.03785101f, 
    0.06547155f, 0.09474338f, -0.06145883f, 0.15003195f, -0.10921623f, -0.06188229f, -0.10393287f, 0.11385978f, 
    -0.00316957f, -0.03854283f, 0.31383359f, 0.05309316f, -0.24651116f, -0.07358276f, -0.03190544f, 0.03902901f, 
    0.14788073f, 0.11692634f, 0.22413082f, -0.06793655f, 0.33052248f, -0.38916618f, 0.03848842f, 0.09169317f, 
    0.01621349f, 0.11156324f, -0.02294761f, -0.12461572f, -0.06961139f, 0.10195112f, -0.04384338f, -0.38118374f, 
    -0.27440029f, -0.07276716f, 0.01451019f, 0.22597042f, 0.14384139f, -0.16159400f, 0.49059677f, 0.05942614f, 
    -0.32252964f, 0.18039481f, 0.23209497f, -0.06415281f, -0.06293910f, 0.29960784f, 0.05866042f, -0.00905261f, 
    -0.06725356f, 0.03197362f, -0.03667577f, -0.08168501f, -0.32273436f, -0.08943880f, -0.06188010f, -0.13297024f, 
    0.13216981f, 0.01640849f, 0.38186035f, -0.02048858f, 0.23360884f, 0.05269347f, 0.24496768f, 0.01973013f, 
    0.24852490f, -0.04705751f, 0.00133722f, 0.00249265f, -0.07961763f, 0.04178492f, 0.18545638f, 0.05843623f, 
    0.12308945f, -0.12882495f, 0.25142732f, -0.14545277f, -0.01177721f, 0.15971592f, -0.04509855f, -0.18303737f, 
    0.06104915f, -0.24936089f, -0.01378870f, 0.17515980f, 0.12530756f, 0.40230227f, 0.06250956f, 0.07914509f, 
    0.08170030f, 0.20148885f, 0.05871678f, 0.05760337f, -0.09249235f, 0.10222670f, -0.24985117f, 0.05213421f, 
    -0.15429054f, 0.07515655f, 0.18985544f, 0.29381675f, -0.56463981f, -0.05008289f, 0.09677150f, 0.07403282f, 
    0.00862030f, -0.05851680f, 0.22261073f, -0.07681961f, -0.10256498f, 0.11776088f, 0.08065614f, -0.16166794f, 
    0.11724299f, -0.33640787f, 0.15983883f, 0.22101748f, 0.20358531f, 0.20629773f, -0.27246115f, 0.10865518f, 
    -0.07757118f, 0.07554483f, -0.06473143f, -0.18038903f, -0.40185422f, -0.31992719f, 0.02071900f, -0.11958919f, 
    0.13382299f, -0.09198932f, 0.00438982f, 0.23118681f, 0.07941563f, -0.30750665f, 0.05330828f, -0.23741393f, 
    0.01537155f, -0.02841964f, -0.16574998f, 0.11779957f, 0.42917675f, -0.06857926f, -0.04369425f, 0.22212815f, 
    -0.30409190f, -0.16484083f, -0.10346016f, -0.50426775f, 0.19743493f, 0.08530828f, 0.08540349f, -0.01031293f, 
    0.05949233f, 0.00268894f, -0.03330714f, 0.09556373f, -0.02452047f, -0.05048283f, 0.03705402f, 0.42198670f, 
    0.27718985f, -0.13966453f, 0.04320720f, 0.04584891f, -0.53875756f, 0.20607032f, -0.31104788f, 0.14972362f, 
    -0.16323461f, -0.00661457f, -0.12922791f, 0.02902330f, 0.11745787f, -0.12498171f, -0.25743091f, 0.08685565f, 
    0.13419968f, -0.21014163f, 0.04240398f, 0.00814799f, 0.37454680f, 0.08104306f, -0.01441669f, 0.45508489f, 
    -0.06195774f, 0.05640955f, 0.08078369f, 0.00527061f, -0.36312547f, 0.24910539f, 0.04542559f, -0.02716425f, 
    0.40381995f, 0.13066596f, 0.23916854f, 0.24055627f, 0.18774101f, 0.00378377f, 0.00103220f, 0.18697983f, 
    -0.23460902f, 0.12931193f, 0.21743454f, 0.13087837f, 0.14186455f, 0.18712030f, 0.10277576f, 0.37887123f, 
    -0.14945033f, 0.14704545f, 0.45921573f, 0.47336608f, 0.28412259f, 0.18046552f, -0.30539542f, 0.01809017f, 
    0.09528371f, -0.03200058f, -0.00603607f, 0.01475302f, 0.39766020f, -0.09579101f, 0.01373970f, 0.02766392f, 
    0.23631956f, -0.09261300f, -0.01020429f, -0.06119391f, -0.00473457f, -0.19379245f, 0.27654445f, 0.10066327f, 
    0.19005746f, 0.31649357f, 0.00809434f, 0.32745627f, 0.00248777f, 0.06855277f, -0.23184690f, 0.34784129f, 
    -0.09493428f, 0.02667656f, -0.01287485f, 0.01379856f, 0.41954926f, 0.11751428f, 0.03898920f, 0.24685623f, 
    -0.03942553f, -0.02948520f, 0.14068493f, -0.00792505f, 0.00390007f, -0.20637825f, 0.25099111f, -0.01005260f, 
    0.25696242f, -0.04941824f, 0.06932892f, -0.06059106f, 0.16938426f, -0.20600580f, 0.08916261f, -0.07790629f, 
    0.11226477f, 0.01131727f, -0.06858312f, -0.02356492f, 0.22592533f, 0.23435359f, -0.05799649f, -0.03251974f, 
    0.03594210f, 0.17618299f, -0.25360629f, -0.03363359f, -0.14044382f, -0.01552571f, -0.07350288f, 0.13589793f, 
    0.04413867f, 0.02289811f, -0.00887305f, 0.16862462f, 0.17642802f, 0.09421559f, 0.06292621f, 0.47013140f, 
    -0.21293162f, 0.09886406f, -0.06938693f, -0.17659080f, -0.29246187f, 0.17859176f, -0.23533604f, 0.05247706f, 
    0.29108402f, 0.19661108f, -0.27982241f, 0.13966131f, 0.16804814f, -0.29593629f, -0.10761493f, 0.20094897f, 
    -0.02913489f, -0.08297542f, 0.08906374f, 0.01670144f, 0.08139049f, 0.00763446f, 0.02101910f, 0.14280339f, 
    0.03677205f, 0.10272493f, -0.01232137f, 0.21675831f, -0.21839665f, 0.01295624f, -0.24058181f, -0.00433291f, 
    0.07075668f, -0.09609324f, 0.25423843f, -0.11572520f, 0.28750861f, -0.19833983f, -0.00418286f, -0.17054419f, 
    -0.24765250f, 0.65505373f, -0.20418566f, 0.27103901f, 0.15590309f, -0.30390632f, 0.01542502f, 0.05673451f, 
    -0.05030340f, 0.26763409f, -0.13798638f, 0.23827644f, 0.24101512f, -0.18330745f, -0.08452565f, -0.15391582f, 
    0.02361029f, 0.06176746f, -0.02401558f, -0.04248757f, -0.03193076f, 0.10356168f, 0.06030744f, 0.06835876f, 
    0.23460653f, -0.03089700f, -0.01399034f, -0.25080192f, 0.38194630f, -0.06425595f, -0.19660190f, -0.00095306f, 
    0.23969744f, 0.08156274f, -0.17779203f, -0.10273892f, 0.08999346f, -0.06838550f, -0.17217159f, 0.37869006f, 
    0.09406625f, 0.39169681f, 0.20405626f, -0.22848071f, -0.26319385f, -0.04466721f, -0.00304131f, 0.36418307f, 
    0.08990670f, 0.03807265f, -0.04379175f, 0.14389329f, -0.09032758f, -0.26054990f, -0.03603940f, -0.01191990f, 
    0.11894661f, -0.20950852f, 0.08608770f, -0.09015455f, 0.15905838f, -0.46029329f, -0.04823140f, 0.10998265f, 
    -0.03317368f, 0.03538421f, 0.25923204f, -0.13071404f, 0.07332438f, 0.19653331f, 0.02241663f, 0.04778512f, 
    -0.02400961f, 0.25637189f, -0.08860610f, -0.19213457f, -0.05190806f, 0.14680809f, 0.01369679f, 0.52201217f, 
    0.05172716f, -0.00869210f, 0.01622463f, -0.00559896f, -0.21564911f, 0.17939247f, -0.05684373f, -0.67285067f, 
    -0.42558023f, -0.16582701f, 0.03803400f, -0.09713729f, -0.21268237f, -0.10219233f, -0.02695219f, 0.12381306f, 
    -0.19930379f, 0.19755051f, 0.01079497f, 0.00198394f, 0.05574577f, 0.02114509f, -0.15063073f, -0.03400523f, 
    0.10292097f, 0.00902966f, -0.05797486f, -0.29510373f, -0.19493067f, 0.05098566f, -0.16008815f, -0.23938374f, 
    0.22573611f, 0.07135734f, 0.10152510f, 0.01714394f, 0.15520209f, 0.29720005f, 0.04207877f, -0.12295528f, 
    0.27839059f, -0.14974137f, 0.21695317f, 0.13030057f, 0.18628432f, -0.12184696f, 0.04278074f, 0.01766201f, 
    0.00932591f, -0.32706627f, 0.20062596f, 0.25201496f, 0.08410855f, -0.08887934f, 0.09455799f, -0.30754349f, 
    0.05841663f, -0.26528624f, -0.56764382f, -0.13421223f, 0.22318569f, -0.05314672f, -0.03988117f, 0.00513110f, 
    0.00236037f, 0.19101594f, 0.29908502f, 0.01358382f, -0.36615968f, 0.22505957f, -0.14345190f, 0.09072758f, 
    0.02803293f, -0.10275429f, 0.12250573f, 0.16125561f, -0.34781301f, 0.26001367f, -0.23865914f, 0.29802290f, 
    0.15335625f, -0.09887099f, 0.28485507f, -0.10024653f, -0.16287865f, 0.25537771f, 0.16660395f, -0.02693915f, 
    -0.07808069f, -0.09311058f, -0.03055224f, -0.04973165f, -0.01024449f, 0.03101561f, 0.02342762f, -0.01171442f, 
    -0.09147150f, -0.07361095f, 0.06835388f, -0.01348499f, -0.01453538f, 0.03603242f, 0.02766488f, -0.12465940f, 
    -0.10089453f, -0.07867999f, -0.05479610f, 0.03927286f, -0.05029738f, -0.09758854f, -0.01737760f, -0.03577165f, 
    -0.09563107f, 0.04214321f, -0.07686765f, -0.09660532f, -0.06181350f, 0.02581859f, -0.02563183f, -0.09723008f, 
    0.04609642f, -0.01518697f, -0.05103309f, -0.03345592f, 0.00924923f, -0.02890167f, -0.07231594f, 0.00644164f, 
    -0.08528708f, 0.01533941f, -0.07772887f, 0.03801385f, -0.10987727f, -0.02681269f, -0.02289104f, 0.01198814f, 
    -0.04929209f, -0.00481434f, 0.03369632f, -0.06130915f, 0.08685922f, 0.00308494f, 0.04076984f, -0.02785790f, 
    -0.02315074f, -0.01400560f, 0.02921808f, 0.04797008f, -0.08591057f, -0.06500722f, -0.05137232f, -0.08388257f, 
    0.03373162f, -0.00883172f, -0.02800614f, 0.00905528f, -0.03098440f, 0.03752379f, 0.02941939f, -0.04299276f, 
    -0.08905173f, -0.05374951f, -0.03913275f, 0.03027735f, -0.01850341f, 0.02407847f, -0.05735827f, -0.04547232f, 
    -0.00584108f, 0.00286352f, -0.04369986f, 0.03253898f, 0.00248941f, -0.01953400f, -0.04805144f, -0.10763682f, 
    0.01248952f, 0.03002548f, -0.02075781f, -0.07591690f, 0.03110536f, -0.06601223f, -0.05250275f, -0.04928867f, 
    -0.06772886f, -0.04889504f, 0.01164926f, 0.05118588f, -0.04504937f, -0.05703604f, -0.00723250f, 0.03763593f, 
    -0.04203853f, -0.02342085f, -0.04289571f, -0.06950071f, 0.08157820f, -0.02939572f, 0.00982465f, -0.00647086f, 
    -0.01109473f, -0.12198061f, 0.02375177f, -0.05789198f, -0.06454994f, -0.09284983f, 0.00126624f, 0.04737028f, 
    -0.08812433f, -0.00015339f, 0.05894566f, -0.04797535f, -0.00540215f, 0.05221717f, -0.02442589f, 0.06370450f, 
    0.08633861f, -0.05603816f, -0.08123198f, 0.06016088f, -0.01016716f, 0.02774176f, 0.01896650f, -0.04565069f, 
    0.04592619f, -0.03487487f, 0.03700151f, 0.00001928f, -0.00622087f, -0.00287987f, -0.00443882f, -0.09808408f, 
    -0.02177298f, -0.06276914f, -0.04168403f, 0.00746025f, -0.08515095f, -0.02441121f, 0.00722016f, -0.10738493f, 
    -0.07461952f, -0.02597369f, -0.07687798f, 0.01757576f, 0.01939312f, -0.04779733f, -0.06709464f, 0.00163726f, 
    -0.00297699f, 0.01819030f, -0.05508190f, -0.01051050f, 0.03336743f, -0.01510644f, 0.07484169f, 0.04591620f, 
    -0.08518866f, 0.00560457f, 0.02878816f, -0.07579626f, -0.09639822f, 0.03668286f, 0.08146819f, -0.03283960f, 
    -0.00215315f, -0.10520554f, -0.02478335f, -0.09714969f, -0.09781630f, 0.04253300f, 0.08828624f, 0.01059190f, 
    -0.08369529f, -0.11124482f, 0.05512181f, -0.08056724f, -0.01969402f, -0.08467463f, -0.03037800f, -0.05547381f, 
    -0.04908610f, -0.01594827f, 0.06703964f, 0.02308218f, -0.10684139f, 0.01909860f, 0.00145839f, -0.09420276f, 
    -0.03976787f, -0.08322617f, -0.03707907f, -0.05458247f, -0.05863662f, -0.02116885f, -0.05265806f, -0.01121753f, 
    -0.07673546f, 0.05365397f, 0.05687943f, -0.08199093f, -0.02801892f, -0.04861613f, -0.05764727f, -0.09450767f, 
    0.05703170f, -0.00281007f, 0.04552058f, 0.00234827f, -0.07558524f, 0.06001129f, 0.06092709f, -0.01202972f, 
    -0.00451788f, -0.03488490f, -0.03822855f, -0.11334109f, 0.00741741f, -0.11458773f, -0.10912711f, 0.05034650f, 
    -0.06942248f, -0.00498890f, -0.05273573f, -0.04348980f, 0.05045924f, 0.03467496f, 0.05226889f, -0.05886860f, 
    -0.06154943f, 0.00483551f, -0.02100862f, 0.02483565f, -0.02251217f, -0.02256992f, 0.04084405f, -0.09543615f, 
    -0.04823793f, -0.02618766f, 0.04495694f, -0.09911094f, -0.10015584f, -0.11334806f, 0.05826831f, 0.05745900f, 
    0.01109989f, -0.07528728f, 0.17322356f, -0.05668413f, 0.10825409f, 0.11588782f, -0.09811488f, -0.10214392f, 
    0.21588022f, 0.02156680f, 0.01652936f, -0.14708030f, -0.23864996f, -0.44487539f, -0.04898766f, -0.07522757f, 
    0.10884268f, -0.42422166f, -0.07234323f, 0.13247170f, 0.05351713f, -0.30478790f, -0.09411710f, -0.09356445f, 
    0.08467615f, -0.09037816f, 0.24237293f, 0.04419071f, 0.08353320f, 0.12852290f, 0.02479273f, 0.13627304f, 
    0.09927978f, 0.08682887f, -0.13921046f, -0.27389002f, 0.23174551f, -0.23202895f, 0.07346926f, 0.28927210f, 
    -0.16896449f, 0.08611353f, -0.11044487f, 0.05982604f, -0.18142255f, 0.09133916f, -0.02430382f, -0.38608846f, 
    -0.24545650f, -0.10366554f, -0.18305643f, 0.07638961f, -0.16324134f, -0.08276205f, 0.30413374f, 0.11990254f, 
    -0.10787269f, 0.27619818f, -0.07702625f, 0.03793037f, 0.03132021f, 0.10223807f, -0.36403778f, 0.22174570f, 
    0.07371677f, -0.02405741f, -0.00172975f, -0.24590689f, -0.12619108f, -0.01014682f, 0.05423860f, 0.23269671f, 
    -0.06898922f, 0.11623130f, 0.32059675f, 0.08704153f, 0.14927223f, 0.26281515f, 0.06986056f, -0.09012254f, 
    0.22284147f, -0.04111722f, 0.12768213f, 0.35239980f, 0.14687589f, -0.20051467f, -0.00198531f, -0.14730716f, 
    -0.22869906f, 0.12768269f, 0.05528683f, 0.23988865f, 0.11166442f, 0.17622198f, 0.00660204f, 0.12943290f, 
    -0.00489494f, -0.30053475f, -0.20892295f, 0.31655306f, 0.27540308f, -0.02681296f, -0.11467201f, -0.09783073f, 
    0.00386636f, 0.58756316f, 0.17098597f, 0.08594754f, 0.38488090f, 0.09386092f, -0.06333765f, 0.03545102f, 
    0.09266610f, -0.20846611f, 0.10788136f, 0.08280063f, 0.15443978f, 0.03176572f, 0.03298320f, 0.11770129f, 
    0.33417526f, 0.31697643f, 0.07357100f, -0.03857636f, -0.08479887f, 0.20934530f, -0.02437702f, 0.22498481f, 
    -0.09820471f, 0.03179325f, -0.08175901f, -0.02796538f, 0.01022415f, -0.06019877f, -0.12547354f, -0.06405115f, 
    -0.11743691f, -0.00882398f, -0.12898481f, -0.06825799f, -0.03026791f, 0.04382059f, -0.02913899f, 0.02072250f, 
    -0.09807723f, -0.01149430f, -0.00254585f, 0.00438832f, 0.05724813f, -0.10979291f, 0.01314981f, -0.06164385f, 
    0.04373810f, 0.04498281f, -0.02396076f, -0.08455043f, 0.00254753f, -0.05834302f, -0.00810598f, -0.12483366f, 
    -0.05495010f, 0.01207239f, -0.14192861f, 0.04708918f, -0.08125772f, -0.06654899f, -0.04437675f, -0.01486779f, 
    -0.04866254f, 0.06301939f, 0.03174745f, 0.01023124f, -0.04092413f, -0.13072941f, 0.08189553f, -0.01223775f, 
    0.04759762f, -0.01888997f, -0.07185984f, -0.01765814f, -0.01841223f, 0.01145189f, -0.06388283f, 0.02478341f, 
    0.00289459f, 0.08122291f, 0.02603181f, -0.11921236f, -0.01235027f, -0.06697787f, 0.01022884f, -0.00647993f, 
    -0.09743339f, -0.03137559f, -0.03841813f, 0.05422910f, -0.03838157f, 0.00614104f, -0.09098160f, -0.06187509f, 
    -0.09579834f, 0.04581863f, -0.08963096f, 0.01476087f, -0.03415423f, -0.06643682f, -0.07288536f, -0.03704837f, 
    -0.10939520f, -0.04766090f, 0.02245318f, -0.00549920f, 0.00345992f, -0.08206178f, -0.00773155f, -0.02136835f, 
    0.01117026f, 0.11948377f, -0.01457444f, -0.07228026f, -0.00973294f, -0.09455612f, -0.03698451f, -0.13905039f, 
    0.02374038f, -0.02407808f, -0.08936704f, 0.03261430f, -0.06462596f, -0.09355798f, -0.09887063f, -0.06329237f, 
    -0.04938803f, -0.01329542f, -0.10186144f, 0.06497607f, -0.10746640f, -0.06955367f, -0.05233788f, -0.09240808f, 
    -0.11523555f, -0.01696320f, -0.10380408f, -0.02635485f, 0.07142994f, -0.02046829f, -0.04174155f, 0.01702318f, 
    -0.03808296f, -0.00536328f, 0.03324705f, -0.07120819f, -0.06152021f, 0.00862537f, -0.07803877f, -0.06581581f, 
    -0.01464017f, -0.21471158f, 0.28721532f, 0.05766184f, 0.06741416f, 0.14616837f, -0.08623298f, -0.01496629f, 
    0.32243651f, 0.05377724f, -0.29991466f, 0.02874688f, -0.29636446f, -0.10849243f, -0.11595477f, 0.15514198f, 
    -0.14905457f, -0.10479122f, -0.07636762f, 0.15739180f, 0.01373044f, -0.09140748f, -0.17853929f, -0.28820994f, 
    0.19307823f, 0.00574480f, 0.15083997f, 0.17293522f, 0.16082574f, -0.25033712f, -0.01607096f, 0.04227389f, 
    -0.02524392f, -0.19293080f, -0.04870894f, -0.45150080f, 0.19953212f, -0.12111774f, -0.00319696f, 0.26489553f, 
    -0.50242877f, -0.00735010f, 0.08802634f, 0.20136851f, 0.06740800f, 0.16672191f, -0.04419242f, 0.00059360f, 
    -0.18414667f, -0.14536220f, -0.34608975f, 0.19912687f, -0.21713643f, -0.11555333f, 0.14643644f, 0.08492014f, 
    -0.60401392f, 0.28683430f, -0.28066927f, 0.08361743f, -0.17759529f, 0.19756018f, -0.40205124f, -0.27898240f, 
    0.03448533f, -0.01473990f, -0.07905287f, -0.12371802f, -0.05722884f, -0.02904486f, 0.26508391f, 0.07655821f, 
    -0.09662978f, -0.03694541f, 0.06799158f, -0.16199192f, -0.02824783f, -0.05095094f, 0.22139128f, -0.30761465f, 
    0.24848910f, 0.17967808f, -0.06020265f, 0.27916074f, -0.04625271f, -0.07521463f, 0.06563010f, 0.11389963f, 
    0.06335053f, 0.03737428f, 0.05702846f, 0.24506305f, 0.31391487f, 0.18134107f, -0.12102136f, 0.55774039f, 
    -0.09534270f, 0.06613211f, 0.19386162f, -0.06924848f, -0.08048879f, 0.08223643f, -0.47356263f, -0.29710072f, 
    -0.04480932f, 0.37281993f, 0.30178186f, 0.10903082f, 0.63275456f, 0.01442983f, -0.03130790f, 0.29667392f, 
    0.15829939f, -0.28243974f, -0.20739947f, 0.10718801f, 0.18824646f, -0.23380354f, 0.28726771f, -0.24402824f, 
    0.20723939f, -0.02505927f, -0.19666544f, 0.25060138f, 0.02217478f, 0.11813530f, -0.32536516f, 0.40429968f, 
    0.15765333f, 0.00415412f, 0.06796733f, 0.22464952f, 0.12420129f, -0.08980016f, 0.12768520f, -0.13007346f, 
    -0.18542875f, -0.01001969f, -0.40815061f, 0.16175261f, -0.10402732f, -0.03921241f, 0.20197073f, 0.08761336f, 
    -0.02221753f, 0.24593377f, 0.03027980f, 0.15779006f, -0.04107495f, 0.52654690f, 0.03262847f, -0.06090889f, 
    -0.21116023f, -0.01922768f, -0.28796539f, 0.17883378f, 0.25335246f, -0.12359436f, -0.07120173f, 0.11829282f, 
    -0.15760030f, -0.21173197f, -0.08611403f, -0.26752928f, -0.07280935f, 0.05370054f, -0.03273933f, -0.01559527f, 
    -0.01248058f, -0.02964940f, 0.11427101f, 0.25760406f, 0.23320174f, 0.18433923f, -0.02613345f, 0.41954923f, 
    0.11476758f, 0.04237903f, 0.10766630f, -0.05363791f, -0.37094507f, 0.02162536f, -0.04699728f, 0.13860707f, 
    0.15647823f, -0.11609744f, -0.21652406f, 0.14198206f, 0.10622783f, -0.09606978f, 0.49073523f, -0.17365517f, 
    0.09839067f, 0.12185733f, 0.04151139f, 0.30491379f, 0.32783240f, -0.06306386f, 0.14651252f, 0.14860705f, 
    0.01578919f, 0.17484331f, -0.13924673f, -0.17399696f, -0.18195359f, -0.00075382f, 0.04165490f, -0.02566332f, 
    0.16909291f, 0.29289556f, -0.06235529f, 0.06930631f, 0.05326256f, 0.11620253f, 0.02574935f, 0.25481275f, 
    0.04569180f, -0.22226070f, 0.15987171f, 0.02930471f, 0.12968482f, 0.20331454f, -0.09815225f, 0.22427663f, 
    -0.15479717f, -0.03074615f, 0.15128557f, -0.09542751f, -0.18932131f, 0.31634855f, 0.04616613f, -0.04973419f, 
    -0.16884227f, -0.38982260f, 0.02230567f, 0.04764031f, -0.23423807f, 0.05811713f, 0.15616879f, 0.08284111f, 
    0.20453835f, -0.11289214f, -0.12083060f, -0.01367140f, -0.13625932f, -0.08344350f, 0.18881436f, -0.06561623f, 
    -0.03607600f, -0.09598657f, -0.11395491f, 0.16611606f, 0.19278541f, 0.11621519f, -0.08022851f, 0.10364607f, 
    0.00364533f, 0.03608574f, -0.08664776f, 0.01382883f, 0.05042102f, -0.04563996f, 0.26090914f, 0.29734716f, 
    -0.21753094f, 0.07320435f, -0.34066209f, 0.17163460f, -0.09443540f, 0.10295042f, 0.16189806f, 0.02007117f, 
    0.11853436f, 0.11911581f, -0.00471819f, -0.01991938f, 0.08291043f, 0.32749176f, 0.10300721f, 0.21917367f, 
    -0.20909813f, -0.04146817f, 0.03664389f, 0.11779907f, 0.31248403f, -0.19724977f, 0.00292690f, -0.00370928f, 
    -0.33032760f, -0.10223066f, -0.03529560f, -0.06630266f, 0.08777682f, -0.30101576f, 0.00284029f, -0.06711262f, 
    -0.02783635f, 0.09678878f, -0.04344012f, 0.16838498f, 0.01032618f, 0.04017673f, -0.07087930f, 0.30350107f, 
    0.79849797f, -0.07453185f, 0.09294134f, -0.10265388f, -0.31507954f, 0.09833289f, -0.21868710f, 0.07120503f, 
    -0.00448542f, -0.00138598f, 0.16875693f, 0.05235136f, 0.32462892f, 0.06095902f, 0.40856510f, -0.06714377f, 
    0.11784197f, -0.01004058f, 0.04980477f, 0.07524104f, 0.19051163f, -0.03123367f, -0.02786858f, 0.06914061f, 
    0.03554734f, 0.06284931f, 0.03276667f, 0.05697403f, -0.22498992f, 0.32084027f, -0.13889873f, 0.13019498f, 
    0.09876622f, 0.15106273f, 0.15568563f, 0.12831719f, 0.16801840f, 0.05600430f, 0.04800449f, 0.29944330f, 
    0.21405545f, -0.25684375f, 0.18076211f, -0.08289611f, 0.17109425f, -0.21995446f, -0.16505535f, -0.24951321f, 
    -0.11007413f, -0.06884135f, -0.03949665f, 0.01301610f, -0.04452500f, 0.32519996f, -0.05968898f, 0.11318414f, 
    0.04978604f, -0.13394587f, 0.09928351f, -0.02988201f, -0.54422623f, 0.14678916f, -0.37739778f, 0.07692929f, 
    0.09050700f, 0.00260908f, -0.04158556f, 0.09249511f, -0.33071372f, 0.17298716f, 0.07713268f, 0.02534410f, 
    -0.18966807f, -0.40377963f, 0.37030792f, 0.06116445f, -0.01406737f, 0.09768597f, 0.03232218f, -0.21830881f, 
    0.08041469f, 0.26565289f, -0.15209377f, -0.07866070f, -0.09568661f, 0.02725975f, -0.01243302f, -0.19751105f, 
    -0.21434061f, -0.03847523f, 0.20820497f, -0.16896681f, 0.26625860f, -0.12775420f, 0.03146207f, 0.00044168f, 
    0.11000020f, -0.04300646f, 0.08702727f, -0.35887751f, 0.15488286f, -0.06954718f, 0.20130594f, 0.15655455f, 
    0.11911930f, -0.06912305f, -0.16363043f, -0.44476074f, -0.11950798f, 0.17731380f, -0.01159115f, -0.23609805f, 
    -0.01072963f, 0.01566540f, -0.05456799f, 0.23305303f, -0.17155950f, 0.74897957f, 0.06990761f, 0.04070821f, 
    0.18176539f, -0.03984693f, 0.03065748f, -0.27084938f, -0.26108727f, -0.26706642f, -0.05443212f, -0.35091263f, 
    -0.44779107f, -0.00258411f, 0.16619979f, -0.41648334f, -0.06165810f, -0.01076644f, 0.28634146f, 0.00062781f, 
    0.23129725f, -0.13949680f, -0.04365676f, -0.17986862f, 0.02914729f, -0.13559744f, 0.11209775f, 0.42572758f, 
    0.00944134f, 0.31079498f, 0.03328577f, -0.05147569f, -0.04487603f, -0.06627031f, -0.14775024f, 0.17792359f, 
    0.07058684f, -0.06315935f, -0.07526284f, 0.04827971f, 0.12582688f, 0.15349655f, -0.11086646f, -0.06005493f, 
    -0.61760169f, 0.06069194f, -0.04080855f, 0.08106247f, -0.26815462f, -0.07439653f, 0.04648322f, -0.43509775f, 
    -0.30590585f, -0.23814756f, -0.53624207f, -0.11937303f, -0.28640673f, 0.16714559f, 0.23402572f, 0.13340263f, 
    0.25375569f, -0.42136589f, -0.16758512f, 0.26349023f, -0.00819521f, -0.44881663f, 0.41080597f, 0.08187290f, 
    0.17398530f, -0.10193916f, -0.06696913f, -0.04874047f, -0.70350367f, -0.08949887f, 0.43406895f, -0.34860542f, 
    0.16154574f, 0.04600127f, -0.07764488f, -0.39920765f, 0.19129223f, 0.02395824f, -0.04725903f, 0.30557719f, 
    0.12967917f, 0.17856038f, -0.17663124f, -0.32329491f, 0.17626606f, -0.13892275f, 0.27536383f, 0.12865323f, 
    0.03592198f, -0.06359417f, -0.03564595f, -0.00571457f, 0.04583500f, -0.09329738f, 0.05565101f, -0.05350541f, 
    0.03725038f, 0.00230663f, 0.03235826f, -0.03313737f, 0.05401954f, -0.00999088f, 0.02334429f, -0.09566175f, 
    0.03549560f, -0.02520965f, 0.05548004f, -0.02821695f, -0.07440347f, -0.06273150f, -0.06630992f, 0.00329753f, 
    -0.03114236f, -0.02448397f, 0.03895285f, -0.01581671f, 0.01854726f, 0.06303173f, -0.00330292f, -0.05071389f, 
    -0.08946645f, 0.00235836f, 0.02004264f, -0.08631719f, -0.03807486f, -0.04920681f, -0.00335886f, 0.01953193f, 
    -0.05797868f, 0.08296538f, 0.03990358f, -0.04190860f, -0.11345933f, -0.04122148f, 0.07941205f, -0.02456297f, 
    -0.02735960f, 0.02931375f, 0.06980118f, -0.05939075f, 0.03928759f, -0.00072852f, 0.06577443f, -0.06332528f, 
    0.02480381f, -0.02129059f, -0.03458933f, 0.02563065f, -0.03495673f, -0.08974558f, 0.04446226f, -0.07375434f, 
    -0.02489663f, -0.02847661f, -0.00137339f, 0.00368170f, -0.09706555f, 0.00847184f, -0.02485590f, -0.02821478f, 
    0.00601356f, 0.00232773f, -0.03454679f, 0.04457726f, 0.00565168f, -0.04901416f, 0.04203954f, -0.00580242f, 
    0.04141611f, -0.04711062f, -0.00691947f, -0.00308326f, 0.02812992f, -0.01032138f, -0.02444230f, 0.02461777f, 
    0.01326411f, -0.00149982f, -0.04779886f, -0.00733232f, 0.04517282f, 0.05261089f, -0.05854679f, -0.00653679f, 
    -0.01882555f, -0.01564938f, -0.00679859f, 0.03572377f, 0.03198018f, 0.03746733f, 0.05573035f, 0.06406528f, 
    -0.09902050f, 0.03852774f, -0.07670070f, 0.08108323f, 0.03984702f, -0.03196638f, -0.09435971f, 0.02605339f, 
    -0.03988748f, -0.08192798f, -0.05616636f, 0.05356010f, -0.00304839f, 0.06170483f, -0.01384466f, 0.05024622f, 
    -0.09910104f, -0.01770217f, -0.05405476f, 0.03656287f, 0.06966296f, 0.00373462f, -0.00854082f, 0.03675145f, 
    -0.11152218f, 0.16217782f, 0.05234762f, -0.00591556f, 0.13115139f, -0.24132870f, 0.17907801f, 0.05782532f, 
    0.00950728f, -0.01672421f, 0.37876368f, -0.05162425f, -0.02488077f, 0.21766640f, 0.08346076f, -0.06273346f, 
    0.19350353f, -0.00650096f, -0.05460370f, 0.01504997f, -0.05201949f, -0.17471935f, -0.04576792f, 0.17654474f, 
    -0.03409064f, 0.02613212f, 0.18273133f, -0.08327735f, 0.02926252f, 0.02695609f, 0.05213547f, 0.03748852f, 
    -0.00578036f, 0.16295502f, 0.18703048f, 0.37531164f, 0.16559958f, -0.04252750f, 0.00212285f, 0.05494345f, 
    0.13166590f, -0.04944727f, -0.01306015f, -0.09727627f, -0.25728074f, -0.06651254f, 0.07115880f, 0.00134900f, 
    0.03794205f, 0.16555555f, 0.19219600f, 0.02376106f, 0.31303492f, -0.19178830f, 0.20017208f, 0.07889102f, 
    -0.22559991f, 0.06081763f, 0.41612777f, -0.01306332f, 0.23735930f, 0.16641945f, -0.08130075f, 0.43391290f, 
    -0.05089897f, -0.01427771f, 0.05610502f, -0.00513329f, -0.18268351f, -0.00402502f, -0.02680217f, -0.22340776f, 
    0.02152962f, 0.03545922f, 0.29236895f, 0.12375748f, 0.26378840f, 0.13094947f, -0.05705014f, 0.09267017f, 
    0.08558384f, -0.05333960f, 0.05121553f, 0.10343608f, -0.22364335f, -0.01097149f, -0.04998942f, -0.10063237f, 
    0.00658364f, 0.76046252f, 0.04299383f, 0.00413777f, 0.07902525f, -0.20079879f, 0.01795628f, -0.18447378f, 
    0.05568596f, 0.22944409f, -0.25200924f, 0.55678630f, 0.26213586f, 0.03678021f, 0.00167063f, 0.15315753f, 
    -0.04691864f, 0.47229773f, -0.08539998f, 0.02625471f, -0.28810245f, 0.03361240f, -0.32329980f, -0.15771736f, 
    0.00794511f, -0.00306715f, 0.03797127f, 0.25272101f, 0.20058478f, -0.03277258f, -0.19683398f, 0.05759065f, 
    0.01795207f, -0.25220633f, 0.23496655f, -0.23929714f, -0.00094691f, -0.00150582f, -0.04799184f, -0.18141080f, 
    0.08499629f, -0.08689331f, -0.01393637f, -0.07463315f, -0.06086151f, -0.08236077f, 0.06078495f, -0.06952043f, 
    -0.04183377f, -0.00771692f, 0.05731803f, -0.00818519f, -0.04911533f, -0.02680703f, 0.03363699f, -0.07478098f, 
    0.01630111f, -0.09949065f, 0.02893344f, -0.01225309f, 0.00568011f, 0.00427012f, 0.06934267f, -0.09685120f, 
    -0.05896520f, -0.00231640f, -0.01363714f, -0.09496528f, -0.05908682f, 0.02971496f, 0.05702222f, -0.06186997f, 
    0.02694890f, 0.04299507f, 0.05338911f, 0.06847000f, -0.00648647f, -0.00882564f, 0.08049740f, -0.03934571f, 
    0.01920636f, 0.07745954f, -0.07709599f, 0.02011957f, -0.06350496f, 0.06146441f, -0.04145708f, 0.06766370f, 
    -0.07342620f, 0.01230032f, 0.03664589f, 0.02798766f, -0.04769779f, 0.01712522f, 0.03909430f, 0.03676233f, 
    -0.05062618f, -0.01828001f, -0.04947963f, -0.07096966f, 0.01507834f, -0.07058811f, -0.05570342f, 0.01032752f, 
    0.04146059f, -0.01699133f, -0.01484767f, 0.02473979f, -0.05977681f, -0.02163092f, 0.01710801f, -0.01403428f, 
    -0.03273558f, 0.02448701f, -0.07950573f, 0.04644601f, -0.06066792f, -0.05279898f, 0.07125156f, -0.06502275f, 
    -0.06090355f, -0.02479173f, -0.06925242f, 0.06420504f, -0.02003431f, -0.09468633f, -0.05141167f, 0.00411908f, 
    0.04499342f, 0.05033019f, 0.06257883f, 0.02910533f, -0.04061263f, 0.04710229f, -0.04212001f, 0.03152382f, 
    0.05515045f, 0.06208613f, 0.02171747f, 0.05119267f, -0.05904412f, -0.05251667f, -0.06363039f, 0.01384840f, 
    0.00255332f, 0.10670160f, -0.01057689f, 0.04666374f, -0.08897474f, -0.09053954f, 0.03409393f, -0.05778142f, 
    -0.02063975f, 0.01704001f, 0.06596090f, -0.06794666f, 0.03157350f, 0.06200246f, 0.00012786f, 0.05345291f, 
    -0.09750690f, -0.08379640f, 0.00098404f, 0.01532111f, 0.07461417f, -0.05677224f, -0.07285833f, -0.03617739f, 
    -0.21150725f, 0.13520135f, -0.26015270f, 0.00205776f, 0.11971407f, -0.23852654f, 0.23669066f, 0.42013419f, 
    -0.07063407f, -0.00351950f, -0.08040163f, 0.05222194f, 0.00161121f, 0.19079611f, 0.21442427f, 0.23118903f, 
    -0.00442312f, 0.34241098f, -0.02566091f, -0.08614203f, 0.26305345f, 0.19539410f, 0.11241501f, -0.03503960f, 
    -0.10268014f, 0.02222217f, -0.26295239f, 0.09703345f, 0.27261463f, -0.09348607f, 0.02173219f, 0.12806788f, 
    -0.18564616f, 0.11609837f, -0.14122698f, 0.11046211f, -0.37285781f, 0.09712374f, -0.08074459f, 0.09174811f, 
    0.09543367f, 0.04847407f, 0.08330959f, 0.20656395f, 0.22206290f, 0.14731820f, -0.02923461f, 0.18831886f, 
    0.28234479f, 0.21633653f, 0.00220482f, -0.17325696f, -0.06995237f, 0.20342472f, -0.50417721f, 0.05815455f, 
    0.39816329f, -0.11803024f, 0.04698268f, 0.31499299f, 0.39088002f, -0.24071035f, 0.16425002f, -0.12873147f, 
    0.18895951f, -0.00426712f, 0.04111465f, 0.31793481f, 0.51929557f, -0.01431613f, 0.14394595f, -0.16463806f, 
    -0.06335688f, 0.22986940f, -0.32311803f, 0.24500567f, -0.22158702f, -0.07375657f, -0.40615934f, -0.01372860f, 
    -0.14383470f, 0.04966816f, 0.30128241f, -0.03368715f, 0.31646389f, -0.06579649f, -0.19313389f, -0.03597079f, 
    0.04670674f, 0.09083578f, -0.23915887f, 0.21437229f, 0.06513617f, -0.32140964f, -0.31700647f, -0.16038674f, 
    0.06916702f, 0.26221606f, -0.11244237f, -0.28072554f, 0.05615798f, -0.14059141f, -0.03088183f, -0.16447689f, 
    -0.16652209f, -0.33917350f, 0.29853874f, -0.07271279f, -0.37225708f, 0.10042800f, -0.01281897f, 0.18522546f, 
    0.12019794f, -0.15217638f, -0.16238679f, -0.13320789f, -0.07280233f, 0.33391163f, -0.30909684f, -0.14191480f, 
    0.09662535f, -0.20617487f, -0.02997255f, 0.00006334f, 0.12823571f, 0.16440544f, -0.17575189f, 0.07523923f, 
    0.14295876f, -0.14455126f, 0.11865208f, -0.01111683f, 0.00415005f, 0.04802347f, 0.11952484f, -0.13156080f, 
    -0.05227498f, -0.01910363f, -0.09381613f, -0.07980115f, -0.07579283f, 0.02217359f, -0.07312305f, 0.00291399f, 
    -0.04975908f, -0.00817844f, -0.06721517f, 0.03001465f, 0.12648207f, -0.09974920f, -0.06470103f, 0.02971823f, 
    0.00232746f, -0.00934967f, 0.00108035f, 0.01513952f, -0.01621194f, -0.03808584f, 0.03395310f, -0.03349948f, 
    -0.04293236f, -0.15758643f, 0.01361657f, -0.01016963f, 0.01867193f, 0.03658032f, -0.08780241f, -0.10260508f, 
    -0.03503315f, -0.05292380f, 0.01706488f, -0.02088353f, -0.01674951f, -0.10341942f, 0.08323148f, -0.04424027f, 
    0.14265330f, -0.10287758f, 0.02181989f, -0.06829042f, 0.12864265f, -0.07079057f, 0.18234767f, 0.06099255f, 
    -0.12353238f, 0.00351180f, -0.11482291f, 0.04431512f, -0.03283055f, -0.08173672f, 0.02423884f, -0.01010942f, 
    -0.12326068f, 0.06871644f, 0.06353295f, 0.11562402f, -0.15465511f, 0.06120070f, 0.01230552f, -0.02990135f, 
    -0.01243254f, 0.06051753f, 0.04366357f, -0.06718171f, -0.08935454f, 0.01782275f, 0.01421927f, 0.01697677f, 
    0.07826544f, -0.00414558f, -0.04846240f, -0.06010950f, 0.07240835f, 0.09760317f, -0.00123062f, 0.07786248f, 
    -0.04623843f, 0.07684501f, 0.10938679f, -0.11256387f, -0.06792066f, 0.13444069f, -0.08098940f, 0.03980906f, 
    -0.04990176f, 0.01154023f, 0.12399399f, -0.01058575f, 0.02509141f, 0.08516380f, 0.00617398f, 0.00476820f, 
    0.05976095f, 0.04615843f, -0.11117227f, 0.03269555f, 0.05976914f, 0.05721489f, -0.06331837f, -0.04694987f, 
    0.02644905f, 0.06216920f, -0.08850735f, 0.02485954f, -0.12981428f, -0.06520580f, 0.04865422f, 0.05347924f, 
    -0.09288154f, -0.02079044f, 0.03023183f, 0.06823330f, 0.01137366f, -0.05257742f, 0.01460048f, -0.03510492f, 
    -0.20002422f, 0.04037094f, -0.02686929f, -0.24973673f, -0.13791329f, 0.31472072f, -0.10909980f, 0.59985340f, 
    0.08404298f, -0.06295772f, -0.41983324f, 0.07781696f, 0.08584486f, -0.15444222f, -0.06525065f, 0.02218198f, 
    -0.06262901f, -0.14578959f, 0.06694475f, -0.22618161f, 0.27489385f, -0.11384112f, 0.03463329f, -0.23265414f, 
    0.35594115f, -0.11238234f, -0.09095381f, -0.16244453f, -0.02861029f, 0.22926240f, 0.00182564f, -0.17204653f, 
    0.19236612f, 0.21570958f, -0.13363901f, -0.21337041f, -0.31728533f, -0.12766007f, 0.01019709f, 0.29552960f, 
    0.04262123f, 0.06155270f, -0.00388526f, 0.04125654f, 0.04174892f, 0.13529296f, -0.00737783f, -0.30443662f, 
    -0.18454899f, 0.11200791f, -0.16120251f, -0.24199134f, -0.03116918f, 0.32609087f, -0.36363497f, 0.02710979f, 
    0.35855103f, 0.17252932f, -0.28161561f, 0.08110552f, -0.10561501f, -0.10852883f, -0.33484834f, -0.37049502f, 
    0.13451144f, -0.23393665f, 0.07087593f, -0.09620240f, 0.17146368f, -0.03034546f, 0.00123155f, 0.10517020f, 
    0.17870477f, 0.04035870f, -0.19425911f, 0.16379265f, -0.15460078f, -0.01006209f, -0.15722431f, -0.03071956f, 
    -0.00229760f, -0.04421168f, 0.24249627f, -0.06247436f, 0.44318318f, 0.05967234f, -0.08333895f, 0.03205722f, 
    -0.02079038f, -0.43404788f, -0.21101731f, 0.25915831f, 0.02501774f, -0.12627707f, -0.04757147f, -0.18599166f, 
    0.04428810f, -0.33573815f, -0.24732172f, -0.31008276f, 0.03578620f, -0.45732003f, 0.10608927f, -0.12326912f, 
    0.18861687f, -0.11743724f, 0.23633625f, -0.06040223f, 0.05651479f, 0.02347319f, 0.01981984f, 0.08914044f, 
    0.01461386f, 0.17556976f, 0.06954004f, -0.14372507f, -0.19390726f, 0.39696074f, -0.38574296f, 0.01402651f, 
    0.02204929f, 0.15751134f, 0.01586423f, 0.18295383f, 0.02310321f, 0.07415891f, 0.07093496f, 0.06291194f, 
    0.05296332f, 0.00669808f, -0.02504104f, -0.11893598f, -0.05970550f, -0.02542930f, 0.03722541f, -0.09383536f, 
    0.01927385f, 0.02874810f, -0.07248418f, -0.04894162f, -0.01208148f, -0.13438205f, -0.04269620f, -0.04119078f, 
    -0.07202668f, 0.02655472f, 0.08363727f, -0.09596066f, -0.00985767f, -0.00570076f, -0.07628726f, -0.01904112f, 
    0.02515757f, 0.07978196f, -0.00383839f, -0.05173725f, -0.02641716f, 0.00941794f, 0.01566547f, 0.00576241f, 
    -0.03702738f, -0.03179065f, -0.04164379f, -0.00223241f, -0.05826710f, -0.14089845f, -0.00425230f, 0.00317729f, 
    -0.03112604f, -0.08291849f, 0.04495250f, -0.00631751f, -0.10288120f, 0.03037090f, -0.02020960f, 0.01736741f, 
    -0.01069759f, -0.01942587f, -0.12478849f, -0.14200369f, 0.02573945f, -0.07698209f, 0.01702733f, 0.03527798f, 
    0.02360913f, 0.02798959f, 0.03454328f, -0.05048091f, -0.01643925f, 0.05006096f, 0.01282400f, 0.02781502f, 
    -0.04028496f, -0.12912205f, 0.00053433f, -0.02210198f, 0.05912705f, -0.06818739f, -0.07293593f, -0.03853207f, 
    -0.09838144f, -0.07738680f, 0.00699250f, -0.03990957f, -0.00264002f, -0.04353977f, 0.05489357f, -0.00247615f, 
    -0.04211598f, -0.02073377f, -0.05281202f, -0.01631021f, 0.03625147f, -0.02311294f, -0.02464037f, -0.02888865f, 
    -0.12257735f, 0.01543644f, 0.04521460f, 0.02002567f, -0.09969157f, -0.08018658f, 0.01359374f, -0.08589239f, 
    -0.02078031f, -0.05094359f, -0.09152326f, 0.03684841f, -0.05089178f, 0.04474912f, -0.09871211f, 0.01576686f, 
    -0.10670703f, 0.01226055f, -0.09790099f, 0.05419744f, -0.07958370f, -0.11174427f, -0.04327614f, -0.02396903f, 
    0.02161666f, -0.10272751f, -0.03139473f, -0.11850256f, -0.04584417f, -0.04797907f, 0.02230425f, -0.08679055f, 
    0.01885006f, -0.04742558f, -0.06905454f, -0.06510823f, 0.03068436f, -0.02316195f, -0.13012612f, -0.03953894f, 
    0.20381138f, -0.03703497f, 0.15020160f, -0.09630632f, -0.08431903f, 0.18295856f, 0.39766374f, 0.09536099f, 
    0.12299540f, -0.01931260f, 0.39688933f, -0.14861150f, 0.13290016f, -0.03218642f, -0.09584406f, -0.13722916f, 
    0.06565236f, -0.11328425f, -0.01537722f, -0.11001569f, 0.00534192f, -0.27995670f, -0.00657423f, 0.08381511f, 
    0.19720353f, 0.10745428f, 0.19042817f, -0.14134179f, -0.00858553f, 0.05625883f, 0.09086314f, -0.12015013f, 
    -0.14866225f, 0.10782942f, 0.21085478f, 0.05886345f, 0.12859781f, 0.24166545f, -0.01889948f, -0.17569585f, 
    0.03240165f, 0.10218032f, -0.03988583f, -0.14204006f, -0.24974525f, -0.10605209f, -0.01838069f, -0.09816328f, 
    -0.03163003f, -0.13129051f, 0.12893327f, -0.01115534f, -0.00503343f, -0.17239076f, 0.37651634f, -0.02342831f, 
    -0.10333690f, -0.03447086f, 0.09924202f, -0.16147886f, -0.03197310f, 0.23234586f, -0.14218467f, 0.38051900f, 
    -0.09810694f, 0.10964157f, 0.01884693f, -0.12671311f, -0.18923974f, -0.08639170f, -0.19698964f, 0.14369851f, 
    0.13339953f, -0.09721443f, 0.15156929f, -0.04676900f, 0.11552993f, 0.13785991f, 0.17528446f, 0.21159899f, 
    -0.22926930f, 0.03662188f, -0.16732861f, 0.19915129f, -0.41839084f, 0.10757776f, 0.12251635f, 0.09218831f, 
    -0.12214172f, 0.39252758f, -0.10118236f, -0.08137797f, -0.03013162f, 0.44343650f, 0.42934704f, 0.24752992f, 
    0.14891954f, -0.25525767f, 0.17079566f, 0.64220387f, -0.04212055f, -0.10346752f, 0.07667753f, 0.24269649f, 
    0.33246386f, 0.47400996f, -0.18274306f, -0.04359791f, 0.18388942f, -0.13989030f, 0.00532483f, -0.21652178f, 
    -0.04491760f, 0.21422555f, 0.16547778f, -0.11737366f, 0.49652433f, 0.01441983f, 0.29782119f, 0.20279409f, 
    0.01840774f, 0.02486160f, 0.14748876f, -0.07209823f, -0.12397870f, -0.17054406f, 0.24924077f, -0.07519820f, 
    0.07765397f, -0.09441949f, -0.06021817f, -0.06951085f, 0.00160221f, -0.03960289f, 0.08622389f, 0.06361574f, 
    0.06512441f, -0.05465184f, -0.05830615f, 0.01115170f, -0.01118122f, 0.04461226f, -0.10813130f, 0.04518167f, 
    0.02674232f, -0.11480909f, -0.06834462f, -0.06261726f, -0.05149483f, 0.01994594f, -0.06013202f, -0.08274360f, 
    0.09670597f, 0.05661047f, 0.04591705f, 0.05248082f, 0.03142918f, -0.02829977f, -0.04168269f, -0.04339439f, 
    -0.04391637f, -0.11047690f, 0.01330560f, -0.03512915f, 0.00195232f, -0.02576738f, -0.00119516f, 0.00251024f, 
    -0.01440342f, -0.01860740f, -0.04761160f, -0.05956133f, -0.00166812f, -0.09473435f, 0.01012068f, 0.02659589f, 
    0.01832808f, -0.10575862f, -0.02117203f, 0.02781634f, -0.02448736f, -0.04808697f, -0.02547482f, -0.05205745f, 
    -0.03551849f, -0.01415108f, -0.11227769f, 0.05561939f, 0.00335048f, 0.01818588f, -0.03723052f, -0.03828431f, 
    -0.08389729f, -0.01483868f, 0.08638711f, -0.07393238f, 0.05083587f, 0.06900148f, -0.09601413f, 0.04650231f, 
    -0.06689771f, -0.04269033f, 0.02621335f, 0.02856439f, -0.06813972f, 0.07380611f, -0.03512106f, -0.10030775f, 
    -0.06961505f, 0.04860064f, -0.02291495f, -0.05829220f, -0.08404496f, -0.02196806f, -0.09214331f, 0.05702310f, 
    -0.02953374f, 0.07639250f, -0.06705187f, -0.02734486f, 0.04694412f, -0.08539296f, -0.08111450f, -0.08630800f, 
    0.02677119f, 0.02556621f, 0.00512045f, -0.10650197f, 0.06617589f, -0.03066532f, -0.11478141f, 0.00464749f, 
    -0.04855005f, 0.06863688f, 0.06131314f, 0.01672180f, 0.00667332f, 0.05320372f, -0.01488021f, 0.02603674f, 
    -0.00024103f, -0.09826111f, 0.01470730f, -0.08571282f, -0.08671430f, -0.09406217f, 0.08732405f, 0.02831732f, 
    0.02723559f, 0.03823585f, 0.06030905f, -0.05696712f, -0.10727340f, 0.00516360f, -0.05010444f, 0.06884254f, 
    0.08694384f, -0.18594836f, -0.03687139f, 0.03593379f, -0.12202114f, -0.03436990f, 0.46491042f, -0.37909979f, 
    0.26586431f, -0.06230253f, -0.23982103f, -0.00464097f, 0.04187305f, 0.15490557f, -0.14055957f, -0.00570860f, 
    -0.16373821f, 0.22027902f, -0.01986465f, 0.19761796f, 0.00547672f, 0.37563539f, 0.06256087f, -0.03298069f, 
    0.00094051f, -0.03617151f, -0.13690069f, 0.03910225f, -0.04202690f, -0.08525794f, -0.04074631f, 0.08962622f, 
    -0.09570446f, -0.17489433f, -0.01428293f, -0.11326330f, 0.22068407f, 0.14165284f, -0.05028532f, -0.14405370f, 
    -0.08884812f, 0.07854929f, 0.01242949f, -0.09619775f, 0.20925616f, -0.05771893f, -0.08395356f, 0.96903110f, 
    -0.02510575f, -0.02249739f, 0.00371108f, 0.37949309f, -0.32931396f, 0.00800904f, 0.07115460f, -0.10103629f, 
    0.00813258f, 0.03447440f, 0.13506944f, 0.03774295f, -0.23267268f, 0.17925183f, 0.23297927f, 0.17978530f, 
    0.00118689f, 0.03064049f, -0.00549099f, 0.27728206f, 0.15801294f, -0.04435981f, 0.09374011f, 0.19464953f, 
    -0.02668756f, 0.03083301f, 0.27918723f, -0.21551575f, -0.09843215f, -0.02270409f, 0.05717964f, 0.15144935f, 
    0.12919983f, 0.15453798f, -0.08801759f, -0.04538076f, 0.21939369f, 0.23895939f, -0.06653573f, 0.08598763f, 
    0.10684744f, 0.32718951f, 0.07228999f, -0.18537332f, -0.08520786f, 0.41419181f, 0.15628880f, 0.12328986f, 
    0.01633913f, -0.10423432f, 0.38755879f, 0.51560795f, -0.13142060f, 0.16170381f, 0.01809041f, 0.16252232f, 
    0.18584514f, 0.34083512f, -0.13762061f, -0.07094528f, 0.15956570f, -0.07836464f, -0.00238094f, -0.01554481f, 
    -0.08118095f, -0.03050957f, 0.11561884f, 0.13319184f, 0.86565703f, -0.24436961f, 0.36685506f, -0.06555691f, 
    0.02533572f, 0.41010162f, -0.02460920f, 0.31769052f, 0.26142460f, -0.10839655f, -0.10584145f, 0.19149661f, 
    0.10771909f, 0.03419682f, 0.11185773f, -0.10270189f, 0.29807293f, 0.25211063f, -0.03559776f, 0.55614996f, 
    -0.40596634f, -0.06992555f, -0.20726670f, 0.03869447f, 0.04354087f, -0.07205149f, 0.05333388f, -0.06355597f, 
    0.14819355f, 0.09771234f, -0.04598363f, -0.10045039f, 0.08745725f, -0.13766266f, 0.07267584f, -0.17657952f, 
    0.15863231f, -0.03034567f, -0.01594754f, -0.03127549f, 0.19256930f, 0.24296539f, 0.05007948f, -0.10789468f, 
    0.08388539f, 0.07317377f, -0.11113840f, -0.13735111f, -0.07436337f, 0.02959144f, 0.04471923f, 0.06495161f, 
    0.00880066f, 0.01928705f, -0.01786042f, 0.07035847f, 0.17756981f, 0.12382463f, 0.08548715f, -0.30427429f, 
    -0.08692399f, 0.04485936f, -0.14251354f, -0.11801641f, 0.08766781f, 0.13282041f, -0.03801917f, 0.03301090f, 
    -0.10113564f, 0.14588510f, -0.09078005f, -0.01185991f, 0.05036150f, -0.27237585f, 0.03695448f, -0.35457051f, 
    -0.11534017f, -0.28545105f, 0.01991836f, -0.17893593f, 0.12272999f, 0.01315633f, -0.13943027f, 0.03335443f, 
    0.19108942f, 0.19296400f, -0.30267492f, 0.13158402f, -0.24312194f, -0.04392833f, -0.10783668f, 0.10870448f, 
    0.07674612f, 0.04120823f, 0.14552164f, -0.18257920f, 0.28652507f, -0.06310542f, 0.07115173f, 0.05202221f, 
    -0.02494580f, -0.04179783f, 0.00914282f, 0.06887691f, 0.16549799f, -0.54877764f, 0.02777461f, -0.25485092f, 
    -0.16601491f, -0.24945547f, -0.03270491f, -0.33672860f, -0.08216113f, -0.00238110f, -0.06629911f, 0.07569654f, 
    0.15625769f, -0.07436921f, 0.08952378f, 0.08367211f, 0.10527396f, 0.00684159f, -0.09434684f, 0.09683156f, 
    -0.01381283f, 0.20551315f, 0.10265391f, -0.16587539f, -0.17449166f, 0.16854466f, -0.14498375f, -0.07254457f, 
    -0.13996412f, -0.00626230f, 0.10739312f, -0.11718670f, -0.24866885f, -0.09992864f, 0.01479489f, -0.00852125f, 
    0.06776132f, 0.03650627f, -0.06469467f, -0.03669519f, -0.02451050f, 0.04494354f, -0.03608007f, -0.04935838f, 
    -0.06375976f, -0.07430170f, 0.06005726f, -0.07972835f, 0.05860822f, 0.01081696f, -0.00968383f, 0.03533732f, 
    0.02694259f, -0.01750305f, 0.05116226f, 0.03877858f, -0.04398610f, 0.01906481f, 0.01441765f, -0.00227974f, 
    -0.02391544f, -0.02685547f, -0.07354413f, -0.04122079f, -0.03420620f, -0.09971017f, -0.08625291f, 0.01041349f, 
    -0.02124210f, -0.03693611f, 0.00793903f, -0.09694191f, -0.06054636f, 0.02688268f, -0.01765701f, 0.03305471f, 
    0.07232679f, 0.06406857f, -0.06138920f, -0.04892165f, -0.00337189f, -0.06289142f, -0.01512322f, 0.06431987f, 
    -0.02480482f, 0.07100774f, -0.05135169f, 0.05890315f, 0.01939173f, 0.07016184f, -0.08136115f, -0.03887250f, 
    0.03927252f, 0.00227134f, -0.02281583f, -0.08712909f, -0.08648698f, -0.06568678f, 0.02687639f, -0.06478035f, 
    -0.01197215f, -0.06066977f, 0.01792004f, -0.09671152f, -0.01728129f, -0.01482219f, -0.08395510f, 0.00766254f, 
    -0.08909845f, 0.01053322f, -0.05042592f, 0.06372774f, 0.06055413f, 0.01729154f, 0.07106030f, 0.05233544f, 
    0.07070772f, -0.03672082f, -0.08921372f, -0.01507719f, 0.02319446f, 0.05712891f, -0.07682399f, -0.08714659f, 
    -0.01371013f, -0.01498706f, -0.08559710f, -0.04332000f, -0.09938039f, -0.02016020f, 0.00856201f, 0.00776091f, 
    -0.00400759f, 0.03470827f, -0.06913057f, 0.03175064f, -0.02252360f, -0.03767906f, 0.05874203f, 0.05001441f, 
    -0.06403381f, 0.05015760f, -0.08842979f, 0.08661607f, 0.08288494f, 0.01302948f, 0.05599782f, 0.01091652f, 
    0.01523180f, -0.06186318f, -0.04104161f, -0.02299527f, 0.01195752f, 0.01787675f, -0.00284226f, 0.06998725f, 
    -0.02064119f, -0.07807203f, -0.09322703f, 0.05175662f, 0.05236768f, -0.04189395f, -0.05309679f, -0.02223544f, 
    -0.17148989f, 0.27556854f, -0.05511854f, -0.10993748f, -0.03465994f, -0.31499183f, -0.34852508f, -0.03563531f, 
    0.06138384f, 0.01208300f, 0.58549446f, 0.00656282f, 0.11574920f, 0.14984982f, 0.10921161f, 0.06799704f, 
    0.17811671f, -0.01286125f, 0.07352497f, 0.03163740f, -0.23552534f, -0.10166512f, -0.18906601f, 0.30715305f, 
    -0.14177009f, -0.05398193f, -0.02261904f, 0.03067750f, -0.18692331f, 0.07987174f, -0.00479452f, 0.10035815f, 
    0.36598557f, 0.15134312f, 0.06005915f, 0.45592842f, 0.12842356f, -0.43421113f, -0.00329278f, 0.03414259f, 
    0.19066663f, -0.10522273f, -0.10369613f, -0.04384848f, -0.21129428f, -0.08314130f, 0.00656773f, 0.38959494f, 
    0.11243282f, 0.02715601f, 0.10389981f, 0.13885784f, 0.51324415f, -0.38373324f, 0.12317753f, 0.12710662f, 
    -0.46280128f, -0.01719287f, 0.27165803f, -0.09946293f, 0.20121799f, -0.12908012f, -0.12520532f, 0.39946356f, 
    -0.16902545f, -0.07652324f, 0.01286895f, 0.13369690f, -0.10714044f, 0.02802253f, 0.02448795f, -0.06810620f, 
    0.08416956f, -0.19604254f, 0.45938623f, -0.07231655f, 0.23942395f, -0.03480526f, -0.00995441f, -0.06835110f, 
    -0.08766929f, -0.21639550f, -0.07016577f, -0.15339419f, -0.40732339f, -0.30993938f, -0.03553736f, -0.03153025f, 
    -0.01518276f, 0.81134331f, 0.05995389f, -0.03465955f, -0.03282816f, 0.08398539f, -0.12267608f, -0.22796462f, 
    0.09454194f, 0.65097445f, -0.31889531f, 0.59502602f, 0.27953359f, 0.14116937f, 0.01962871f, -0.04069688f, 
    -0.26982620f, 0.12191661f, -0.10850375f, 0.09926890f, -0.10436018f, -0.01512128f, -0.16475503f, -0.26545861f, 
    0.04054796f, -0.05917302f, 0.03974630f, 0.24105318f, 0.33578467f, -0.11018405f, -0.30254894f, 0.05898391f, 
    0.11392579f, -0.09808568f, 0.11769491f, -0.30350283f, 0.01225897f, -0.03942305f, 0.02494305f, -0.15908304f, 
    0.04991852f, 0.01736760f, -0.05252551f, -0.01324106f, 0.00733728f, -0.04158333f, -0.06004196f, 0.02684020f, 
    -0.08357398f, -0.08787018f, 0.03295909f, -0.06746466f, -0.03976395f, -0.05788118f, -0.03679162f, -0.00726068f, 
    -0.11208735f, -0.08631297f, -0.01816385f, -0.02960947f, -0.03965534f, -0.08732686f, -0.07952904f, -0.02447318f, 
    0.05894984f, 0.04219109f, -0.09268140f, 0.06773061f, -0.07838541f, 0.03496639f, 0.06845270f, 0.00073093f, 
    -0.08433638f, -0.08659395f, 0.02953735f, 0.05915008f, -0.07841048f, -0.06592537f, -0.00508826f, -0.06697122f, 
    -0.07754238f, 0.01729885f, -0.04308320f, -0.05282515f, 0.04124312f, -0.03797090f, 0.03951399f, 0.02237483f, 
    -0.09090071f, -0.08177511f, 0.01791331f, -0.08819494f, -0.12457464f, 0.05401933f, 0.04547456f, 0.02554602f, 
    -0.02248104f, -0.06934821f, 0.03685231f, 0.04221230f, -0.00994922f, -0.04019220f, -0.05910053f, 0.01165508f, 
    -0.07960289f, -0.01846953f, 0.07092555f, 0.00401218f, 0.06831967f, 0.08318782f, 0.06038668f, -0.04930842f, 
    -0.04059774f, 0.04856472f, -0.09444575f, -0.05489916f, -0.06611736f, 0.01441662f, 0.01526746f, 0.03126324f, 
    0.00303732f, 0.01995575f, 0.03512928f, -0.04153994f, -0.01874672f, -0.09535230f, -0.00230916f, -0.04036333f, 
    0.02910070f, 0.08517949f, -0.05497456f, -0.02883312f, -0.03417971f, -0.03901585f, -0.05325702f, 0.06928870f, 
    -0.01833239f, -0.01498152f, -0.01639053f, -0.03828746f, -0.01906312f, 0.04655242f, -0.03490362f, -0.11900541f, 
    0.04565744f, -0.01990249f, -0.04679277f, 0.01606703f, -0.01715697f, -0.05595089f, -0.08671099f, -0.05383238f, 
    -0.02750607f, 0.01301382f, -0.08719444f, -0.00231105f, 0.05463160f, -0.02669903f, 0.01337843f, 0.00453673f, 
    0.03047184f, 0.05597456f, -0.05004201f, -0.02463116f, -0.01055789f, -0.08004080f, -0.04899681f, -0.11158432f, 
    -0.04384478f, 0.06617305f, -0.06890848f, -0.05416802f, 0.01218127f, -0.01131931f, -0.00120430f, 0.08081780f, 
    -0.07899591f, -0.03372310f, -0.07843760f, -0.08677418f, 0.06211201f, 0.00926814f, -0.05487151f, 0.00807768f, 
    0.04694299f, 0.01284409f, -0.05395170f, -0.07237341f, 0.01749296f, -0.07994453f, -0.09249411f, 0.03594232f, 
    -0.07763135f, -0.00723910f, 0.04221502f, 0.02959084f, 0.03581280f, 0.02864499f, -0.04321466f, 0.01520816f, 
    0.00044690f, -0.07706191f, -0.06912369f, 0.00938537f, -0.08843471f, 0.09947295f, 0.02268143f, -0.05257946f, 
    -0.09837537f, 0.07753331f, -0.05976086f, -0.01845198f, 0.00195829f, -0.05301603f, -0.05357528f, 0.02669399f, 
    0.05633570f, 0.03247801f, 0.03112172f, 0.06836909f, -0.02939111f, -0.09477618f, -0.05360547f, 0.01374785f, 
    0.07125471f, 0.07048558f, -0.06810210f, 0.00826141f, -0.03125092f, -0.05579063f, -0.05107597f, 0.02300570f, 
    -0.10212636f, -0.09522384f, 0.04115414f, 0.05923597f, 0.01821569f, 0.06871213f, -0.03464363f, -0.00585841f, 
    -0.03746102f, 0.02173797f, -0.07262176f, 0.04489538f, -0.01298060f, -0.04380442f, -0.09244466f, 0.01284086f, 
    -0.00213527f, 0.02721807f, -0.02401675f, 0.05650061f, 0.04837053f, -0.07706103f, -0.09649331f, 0.03486120f, 
    -0.08951014f, -0.02088953f, 0.02788629f, -0.04128698f, -0.09045001f, -0.02134173f, 0.01937606f, -0.03669672f, 
    -0.10530393f, 0.05009264f, -0.03320668f, 0.04346268f, -0.08093191f, -0.07540062f, 0.06083684f, -0.07601083f, 
    -0.03564485f, -0.04091802f, -0.07328176f, 0.06238374f, 0.07260980f, -0.03778709f, -0.07992648f, -0.10113667f, 
    0.01920272f, 0.00211852f, 0.01415439f, -0.08904236f, -0.00195339f, 0.07309853f, -0.01840213f, 0.02114943f, 
    -0.06882879f, 0.03722070f, -0.11086100f, -0.13334300f, -0.06735795f, -0.05935950f, -0.01559730f, -0.08142424f, 
    0.21618244f, 0.06558654f, 0.20239417f, -0.02880005f, 0.01534315f, 0.24552667f, -1.05173242f, 0.08506814f, 
    0.30199495f, -0.08501549f, 0.34934410f, 0.09907232f, 0.09387802f, -0.00539993f, -0.40954712f, 0.17248146f, 
    -0.17428324f, -0.31068665f, 0.01142292f, 0.14761858f, -0.43337578f, -0.22890972f, -0.01419385f, -0.05258993f, 
    0.31422782f, -0.02594339f, 0.26872203f, -0.10497722f, -0.38603452f, 0.24711393f, -0.00152943f, 0.06294478f, 
    0.46192557f, -0.02196620f, 0.17633587f, -0.24487953f, 0.16886026f, -0.02354107f, 0.04074816f, 0.26710609f, 
    -0.08550952f, -0.00299629f, -0.00972360f, 0.02764395f, -0.04205583f, 0.12974289f, -0.06564679f, -0.31501245f, 
    -0.31396765f, -0.04500088f, -0.17247288f, 0.27694198f, 0.12844267f, 0.10752292f, 0.25045466f, -0.06259491f, 
    0.36635506f, 0.29199353f, -0.19534226f, -0.08447677f, -0.54733104f, 0.39025444f, -0.22174783f, -0.09355062f, 
    -0.18262616f, 0.09975918f, 0.08919948f, -0.12743740f, -0.38964322f, -0.04467681f, 0.02152473f, 0.03423733f, 
    0.18106706f, 0.12296309f, 0.16381627f, -0.03667932f, 0.18145481f, -0.09750972f, 0.16122970f, 0.16374350f, 
    0.16834781f, -0.02483591f, -0.07353220f, -0.17463312f, 0.24945571f, 0.22720674f, 0.04962732f, -0.03628257f, 
    0.04847416f, -0.05035108f, 0.03548629f, 0.01746603f, 0.06178205f, -0.10110193f, -0.06274446f, 0.12491821f, 
    0.12231068f, -0.02308603f, 0.15878716f, -0.33845502f, 0.19263314f, -0.11837054f, 0.01251871f, -0.06951921f, 
    0.04796481f, -0.05479337f, 0.09199972f, 0.03434602f, 0.32668817f, -0.05838509f, 0.18714498f, 0.08086052f, 
    -0.23152131f, 0.20967644f, 0.16458914f, 0.01605226f, 0.03583633f, 0.42631650f, 0.17885537f, 0.12383092f, 
    0.10117822f, 0.34040123f, -0.18183035f, 0.19269717f, -0.01593782f, -0.08838381f, 0.03853907f, 0.10693593f, 
    0.02660149f, -0.12405206f, -0.11772798f, -0.02714596f, -0.06759559f, 0.09168543f, 1.11002314f, 0.13723056f, 
    0.07898419f, 0.02663171f, 0.03120535f, 0.01749348f, 0.06926591f, 0.38309580f, 0.00611550f, -0.05519948f, 
    0.07544387f, 0.24664649f, 0.07993612f, -0.08984979f, 0.17943507f, 0.34618938f, 0.07005580f, 0.12942293f, 
    -0.15292485f, -0.06557760f, 0.18960208f, 0.03480572f, 0.15476808f, -0.06981260f, 0.08953857f, 0.00391665f, 
    -0.34304461f, 0.03004414f, 0.12645814f, 0.00615286f, 0.11459406f, 0.38738400f, 0.01081632f, -0.17315964f, 
    0.09122943f, 0.05076480f, -0.00118697f, -0.16480045f, -0.08205636f, -0.06004528f, 0.00989391f, 0.00724522f, 
    0.01955126f, -0.01465776f, 0.23731105f, 0.11884923f, -0.22534956f, 0.02012271f, 0.24773744f, 0.05034876f, 
    -0.27258098f, 0.09367931f, 0.38972658f, -0.17785774f, -0.05408359f, 0.29154181f, 0.23225689f, 0.21823850f, 
    -0.04934066f, 0.03342311f, 0.06175046f, 0.16119604f, -0.00301774f, -0.12324051f, -0.09335122f, -0.07357012f, 
    -0.00085545f, 0.07168230f, 0.04890294f, -0.02820953f, -0.01066494f, 0.03311109f, -0.09518384f, 0.31212959f, 
    -0.17850672f, -0.05595239f, -0.13381402f, 0.04782736f, -0.30364674f, 0.17800476f, 0.12204219f, -0.03614505f, 
    0.09108992f, 0.32029167f, 0.03901329f, -0.29253453f, 0.05832674f, 0.09827487f, 0.44991046f, -0.03958660f, 
    0.16715577f, -0.34889123f, 0.23020250f, 0.51613349f, -0.16435020f, 0.15408027f, -0.03895759f, 0.37280035f, 
    0.29056177f, 0.65534848f, -0.12816471f, -0.07600840f, -0.13282223f, -0.03350911f, -0.29913411f, 0.01624071f, 
    -0.22369474f, 0.18273406f, 0.10575330f, -0.07405053f, 0.38157243f, -0.17818825f, 0.18631074f, 0.06137427f, 
    -0.03411542f, -0.29783246f, 0.11476506f, -0.01559122f, 0.02443696f, -0.00731684f, 0.07369104f, -0.20449688f, 
    -0.02993227f, 0.14687821f, -0.24295080f, 0.01505905f, -0.06806186f, -0.07612782f, 0.27764601f, -0.12071749f, 
    -0.09378701f, -0.05941098f, -0.11380944f, 0.11564641f, -0.10230359f, 0.08205638f, 0.08851556f, -0.14630820f, 
    -0.09910906f, 0.20963190f, -0.07034248f, -0.05606799f, -0.03335999f, 0.39213073f, -0.04265857f, 0.23028544f, 
    -0.14546394f, 0.09042479f, -0.19991785f, -0.01758787f, -0.02686534f, -0.01952523f, -0.06964482f, 0.21499805f, 
    0.08998088f, 0.00083076f, -0.14161471f, -0.24760161f, -0.03047178f, 0.16128376f, -0.10237017f, 0.11003891f, 
    0.00454604f, -0.01041938f, 0.05987775f, -0.08039895f, -0.02225382f, 0.18367438f, -0.01554651f, -0.07254766f, 
    -0.32642019f, -0.05665544f, 0.03584732f, 0.14365932f, -0.58562297f, -0.01368534f, 0.19592652f, 0.09559406f, 
    -0.19298951f, 0.02614348f, 0.07910524f, 0.06220404f, 0.09182935f, -0.18024345f, 0.43652162f, -0.04935598f, 
    0.03851371f, -0.01587782f, -0.04964241f, 0.11408970f, 0.25124249f, 0.09515223f, -0.07379454f, -0.10450457f, 
    0.01262506f, 0.06608143f, 0.25156015f, -0.15554225f, -0.16686270f, 0.22559369f, -0.09823491f, -0.00688242f, 
    0.23975770f, -0.14414151f, -0.01297555f, -0.00173791f, 0.00089024f, -0.08519512f, 0.12596220f, -0.01497134f, 
    0.04059767f, -0.48453024f, -0.02001393f, -0.02987381f, 0.06126071f, 0.14021385f, -0.00732935f, -0.45542100f, 
    -0.06585498f, -0.05170775f, 0.10589744f, 0.02719807f, 0.04610146f, 0.32755178f, 0.03684245f, -0.02866122f, 
    -0.07262634f, -0.11165567f, 0.24425811f, -0.00692284f, -0.20263720f, -0.13425416f, 0.05036047f, -0.01063336f, 
    -0.08978957f, -0.18663926f, 0.13034837f, 0.18921591f, -0.24524073f, -0.00137685f, 0.18698080f, 0.11433309f, 
    -0.07612217f, 0.08626796f, -0.05375443f, -0.14594853f, 0.08770557f, 0.20287824f, 0.05762204f, 0.08592399f, 
    0.05600820f, -0.05103740f, 0.04652241f, -0.04213580f, 0.08307106f, -0.06327808f, -0.02360808f, -0.08734825f, 
    -0.07718917f, -0.03393256f, -0.06589384f, -0.09864920f, 0.05744826f, -0.05946508f, 0.06125542f, -0.10190918f, 
    -0.09509121f, -0.01095090f, -0.00076575f, -0.06566298f, -0.02068075f, 0.02341806f, -0.08357953f, 0.03160968f, 
    -0.05992219f, 0.01018652f, -0.03438203f, -0.01369838f, 0.07055492f, -0.04578270f, -0.03206181f, 0.00270407f, 
    -0.01431650f, 0.01405289f, -0.07120605f, 0.06783576f, 0.01450269f, -0.05487932f, -0.00095196f, -0.09000317f, 
    0.00581757f, 0.05620530f, 0.01279002f, -0.11051290f, 0.07695671f, -0.07888130f, -0.08720767f, -0.08606283f, 
    0.01614415f, -0.09846997f, -0.09437937f, -0.06196742f, -0.04265651f, -0.11849675f, 0.00469737f, 0.06709263f, 
    -0.07899261f, -0.08704595f, 0.02154393f, -0.00170258f, 0.06992852f, -0.05538342f, -0.00027462f, 0.05760915f, 
    -0.04401919f, 0.04209660f, 0.07174017f, 0.05393127f, -0.08322365f, -0.03878082f, 0.02689994f, -0.07328522f, 
    -0.09382800f, -0.09690998f, 0.04060506f, -0.11453471f, 0.00870116f, -0.06339306f, 0.03662098f, -0.07613039f, 
    -0.00113141f, 0.04807372f, 0.03596506f, 0.01697925f, -0.04460619f, 0.00850001f, -0.04728809f, -0.06231850f, 
    -0.07437220f, -0.00940188f, 0.02333658f, -0.00351419f, -0.00453191f, 0.00467185f, -0.02817985f, -0.05202011f, 
    -0.00295466f, 0.06890519f, -0.07118150f, 0.04395118f, 0.02332797f, 0.03996166f, -0.08656912f, -0.06363468f, 
    -0.06290730f, -0.03553014f, -0.04790236f, 0.01642953f, -0.00748761f, 0.01593436f, -0.02871652f, 0.04236914f, 
    0.00761280f, -0.02149579f, -0.05073791f, -0.03497068f, 0.05397106f, -0.11354034f, 0.04924690f, 0.05131730f, 
    -0.04829591f, 0.04481573f, -0.02243102f, 0.01125014f, 0.00567917f, -0.07856995f, 0.01998453f, 0.07044496f, 
    -0.04131194f, 0.31454122f, 0.14093320f, 0.04194011f, -0.11369744f, 0.13757567f, -0.54219723f, 0.13812055f, 
    -0.36279756f, 0.06657846f, -0.06375206f, 0.02235523f, -0.12897711f, -0.05073826f, -0.08636750f, -0.13366242f, 
    0.40284121f, -0.10844573f, -0.06288820f, -0.23456994f, -0.07589023f, -0.11085314f, -0.03013008f, 0.17233208f, 
    0.10234485f, -0.09742439f, 0.36030516f, -0.10318303f, 0.06852412f, 0.12434074f, 0.06018769f, 0.09442391f, 
    -0.24017519f, 0.16055669f, 0.02548680f, -0.21557055f, -0.01499263f, -0.25704190f, -0.02811652f, 0.41882575f, 
    0.03206483f, -0.01704940f, 0.01452218f, 0.09473152f, -0.16834195f, 0.09337876f, 0.02166429f, -0.69933820f, 
    -0.23018104f, -0.06192697f, 0.32448700f, 0.03504431f, -0.05354021f, -0.15028359f, 0.38403526f, 0.18654893f, 
    -0.03088878f, 0.17678072f, 0.11128695f, -0.12044550f, 0.12223279f, -0.18615392f, -0.22245570f, -0.09811845f, 
    -0.01493225f, -0.10891273f, 0.01913858f, -0.02172410f, -0.06860303f, -0.01476377f, -0.01587317f, -0.02914583f, 
    0.15298177f, 0.12422296f, 0.19460998f, 0.21491908f, 0.01045846f, 0.25437021f, -0.05665296f, 0.04200927f, 
    0.39431328f, -0.10395914f, 0.14409517f, 0.34398842f, -0.04825989f, -0.17855474f, 0.18351299f, 0.09602179f, 
    -0.24222125f, -0.40155178f, 0.10852543f, 0.39599967f, 0.13595518f, 0.03244204f, 0.14804174f, -0.11099141f, 
    0.09810838f, -0.38899660f, -0.10799119f, -0.06809422f, 0.25739428f, 0.03961705f, -0.11092879f, -0.13829732f, 
    0.16519603f, -0.20883273f, 0.21018578f, 0.06072385f, 0.30122408f, 0.02770870f, -0.20712622f, 0.04541003f, 
    0.20979413f, -0.08417448f, 0.13578106f, 0.17502856f, -0.54052842f, 0.22641613f, 0.03500555f, 0.26841968f, 
    -0.12398930f, -0.12164963f, 0.27913567f, -0.01337605f, -0.40208450f, 0.17656241f, 0.10008892f, -0.08216821f, 
    0.15701711f, 0.01894229f, -0.09115186f, 0.07307032f, 0.00877593f, 0.23231836f, -0.46270928f, 0.03041516f, 
    -0.12452373f, 0.01409971f, -0.37410226f, -0.00290927f, 0.16670384f, -0.17641528f, 0.04850587f, 0.18143922f, 
    0.03113083f, -0.09927278f, -0.04910551f, -0.17486463f, 0.17325123f, -0.16596398f, 0.19194435f, -0.21618266f, 
    0.17196372f, 0.04737088f, -0.07639965f, 0.04195853f, 0.15667701f, 0.04246601f, 0.02079691f, 0.00707712f, 
    0.07209512f, -0.10906402f, -0.16749370f, -0.10479278f, -0.26790708f, 0.41275215f, -0.04232013f, -0.00115956f, 
    -0.09366397f, 0.09293646f, 0.07942189f, 0.26127049f, 0.12648796f, 0.08122221f, 0.06233875f, -0.07412957f, 
    0.06995460f, 0.06444872f, -0.04197536f, -0.26906624f, -0.22751708f, 0.34460622f, -0.33510390f, 0.01109961f, 
    0.51946926f, -0.00007478f, -0.22605157f, 0.15067646f, 0.05793896f, -0.03317669f, -0.17604616f, -0.25530744f, 
    0.14246230f, 0.10028352f, 0.03667961f, -0.02710738f, 0.19058116f, 0.04699495f, 0.03084242f, 0.21498600f, 
    0.10871523f, 0.13161021f, -0.40253937f, 0.16664065f, -0.11466363f, 0.07606418f, -0.10692134f, -0.02910670f, 
    0.00455375f, 0.16611913f, 0.11127956f, 0.19562295f, 0.36999032f, 0.15703157f, 0.04583398f, 0.05872258f, 
    -0.00968224f, -0.17478380f, -0.17179702f, 0.30433318f, 0.00277475f, -0.27846956f, 0.03588047f, 0.14392345f, 
    -0.03291345f, -0.06949849f, -0.07046352f, -0.48022005f, 0.00709728f, -0.35407653f, 0.05955581f, -0.09737771f, 
    0.11734791f, -0.27515993f, 0.12820087f, 0.04286980f, 0.12305795f, 0.07773709f, 0.12536466f, 0.19770171f, 
    0.03980752f, 0.12903759f, 0.04413333f, -0.25576097f, -0.14428200f, 0.16089869f, -0.05032091f, 0.02159405f, 
    -0.06302259f, 0.13988250f, 0.01869812f, 0.31181711f, 0.04848905f, 0.11205522f, 0.13320783f, 0.05933219f, 
    -0.10433239f, 0.05291877f, -0.00666136f, -0.03080905f, 0.03703421f, -0.06587355f, 0.05282256f, 0.08242418f, 
    0.08676130f, -0.01457858f, -0.03503341f, -0.02203558f, -0.06237134f, -0.06245842f, -0.06253858f, -0.10971069f, 
    0.04466198f, -0.07196967f, -0.08318925f, -0.07645395f, -0.10200065f, 0.03229963f, -0.11237197f, 0.03306722f, 
    -0.05513663f, 0.07876317f, -0.01700238f, 0.03702077f, 0.03865726f, -0.02367938f, 0.08571310f, -0.02593003f, 
    -0.08000099f, -0.02945042f, -0.06796282f, -0.08536963f, -0.09187755f, 0.03342006f, -0.06822540f, -0.06910057f, 
    0.05242769f, -0.03747785f, 0.07500950f, -0.03255966f, -0.04043080f, -0.06023139f, 0.04167166f, 0.06082063f, 
    0.04021511f, -0.02961127f, -0.01263392f, -0.08614745f, 0.05432529f, -0.08708638f, -0.07505045f, 0.03014186f, 
    -0.04760877f, 0.02183508f, -0.04456261f, -0.08774702f, -0.02273604f, 0.04332503f, -0.09825028f, -0.09332401f, 
    0.04830548f, -0.01014273f, 0.06172979f, -0.06247762f, -0.05449795f, -0.02659062f, 0.03636527f, 0.02826956f, 
    -0.00264806f, -0.11574130f, -0.11704966f, 0.03769873f, 0.02161315f, 0.01183264f, -0.03843750f, 0.00365332f, 
    0.05633518f, 0.02819040f, -0.04758762f, 0.06457130f, -0.11061521f, 0.03276955f, -0.08767284f, -0.02305805f, 
    -0.07341968f, -0.01837591f, -0.03293428f, 0.01991494f, 0.01127283f, -0.03462616f, 0.05380357f, -0.07762411f, 
    0.00739250f, 0.02330968f, -0.09974807f, -0.02284285f, 0.03139615f, 0.01686841f, 0.01976723f, 0.03308245f, 
    -0.01326081f, 0.02766493f, -0.08648810f, -0.04335803f, 0.02454605f, 0.02324532f, 0.02285029f, -0.11521001f, 
    0.03744643f, 0.01608207f, 0.06781910f, 0.01948308f, -0.06866439f, -0.01930344f, 0.01648446f, 0.06338457f, 
    -0.07167821f, 0.09261117f, 0.03437486f, -0.07312481f, -0.02865920f, 0.01456267f, -0.10292711f, -0.00777527f, 
    -0.01431335f, 0.01415839f, 0.04626841f, 0.02015101f, 0.02874064f, -0.00256944f, -0.02376029f, 0.07770313f, 
    0.02553199f, -0.07775089f, 0.03939275f, 0.06873288f, -0.06186345f, 0.04667205f, 0.00020771f, -0.01821616f, 
    0.04575609f, 0.00869654f, -0.03649398f, -0.02106869f, -0.01923657f, 0.05666066f, -0.07463691f, 0.05485893f, 
    0.01113867f, 0.01872830f, 0.03089304f, -0.10086753f, 0.01636926f, 0.00529076f, 0.03246775f, -0.00840096f, 
    0.09126353f, 0.06717653f, -0.04106987f, -0.08418426f, -0.00389572f, -0.05946500f, -0.06632280f, -0.01195584f, 
    -0.05247815f, -0.00924535f, -0.04203364f, 0.02646020f, 0.02935341f, -0.05322002f, -0.07662196f, 0.09550124f, 
    0.02194049f, -0.05328586f, -0.07417792f, -0.09581313f, -0.07878885f, 0.02152910f, 0.05663997f, -0.05735641f, 
    -0.08495688f, -0.02368819f, 0.03325508f, -0.01338103f, 0.01963563f, 0.02776493f, -0.05495140f, -0.07583789f, 
    -0.01327779f, 0.00076829f, 0.00259593f, -0.02631278f, -0.01774755f, -0.02292431f, 0.06994150f, -0.01274436f, 
    -0.04555529f, -0.00389672f, 0.02084649f, -0.01967412f, -0.04179627f, -0.07950698f, 0.05480354f, 0.03959342f, 
    0.03413868f, 0.05834896f, -0.07523021f, 0.00246304f, -0.00977060f, -0.06075351f, -0.06867699f, -0.03077607f, 
    -0.03126183f, 0.07160378f, -0.00352312f, -0.02244277f, -0.02928155f, 0.01652433f, 0.03018451f, -0.02584551f, 
    -0.01945007f, -0.04864467f, -0.06576542f, -0.07272122f, 0.00181641f, -0.12282438f, -0.01388620f, -0.04220708f, 
    0.02153096f, -0.03183661f, -0.03448225f, -0.08097895f, 0.00468921f, -0.10148554f, -0.03238256f, -0.05035268f, 
    -0.05632477f, 0.01360140f, -0.03813255f, 0.04558122f, 0.07205673f, 0.05089545f, -0.01069155f, -0.03656887f, 
    -0.10182206f, 0.01773371f, 0.01837690f, -0.06107414f, -0.05044401f, 0.02053753f, 0.07442879f, -0.01560965f, 
    0.02263919f, 0.21044804f, 0.17203914f, -0.04654570f, 0.16125740f, 0.26540482f, 0.16354388f, -0.12821031f, 
    -0.00967769f, -0.05613234f, 0.24691369f, -0.12431121f, 0.13063802f, -0.24269368f, 0.04793968f, -0.08503953f, 
    0.02097898f, -0.20558551f, 0.04527998f, 0.15889382f, -0.21403952f, -0.05744826f, -0.20601670f, 0.01947259f, 
    0.33935568f, 0.04111131f, -0.05074516f, 0.01964174f, -0.35943824f, 0.38289988f, -0.03025567f, 0.13396853f, 
    0.33752853f, 0.22898979f, 0.12185032f, -0.00031650f, 0.10611153f, 0.28526038f, 0.02468499f, 0.47074306f, 
    0.23622279f, -0.06445621f, 0.02329147f, -0.27251372f, -0.31504962f, 0.03547820f, 0.03760261f, 0.02486393f, 
    -0.40175897f, 0.04634109f, 0.06425739f, 0.19203827f, -0.07701594f, -0.08813499f, 0.03561630f, 0.08725839f, 
    -0.04591559f, 0.31717032f, 0.02965159f, -0.17146116f, -0.09965744f, -0.19461538f, 0.02343904f, -0.05962355f, 
    -0.22716518f, -0.02965654f, 0.01871862f, -0.38017693f, -0.12823042f, 0.09558499f, -0.03613884f, 0.29785821f, 
    0.09308317f, -0.07097423f, 0.22714126f, -0.10691905f, 0.26914829f, -0.09651032f, -0.03213838f, -0.04336393f, 
    -0.14649265f, -0.10974195f, -0.28573468f, -0.11041646f, -0.15064207f, -0.12387345f, 0.22015193f, -0.05847572f, 
    -0.03901025f, -0.00993728f, -0.06681817f, 0.04566821f, 0.13515124f, 0.22025396f, 0.15326770f, 0.19666994f, 
    0.11731196f, -0.04092651f, -0.07860795f, 0.05209787f, -0.15547800f, -0.05793577f, 0.29946333f, 0.14724711f, 
    -0.10955591f, 0.02495118f, 0.11213902f, -0.01546667f, -0.62966889f, -0.04157423f, 0.25258943f, -0.23267035f, 
    0.30543089f, 0.16513579f, 0.20785135f, 0.33181384f, 0.36589068f, -0.09458543f, 0.14409043f, 0.32735762f, 
    0.44306788f, 0.28763101f, -0.09335107f, -0.03398403f, 0.12695998f, 0.09026133f, 0.23767406f, 0.30334774f, 
    0.17353606f, 0.01924651f, 0.47011214f, 0.17425711f, 0.15978809f, -0.07088032f, 0.04194009f, -0.52178919f, 
    -0.00663392f, 0.04237625f, 0.13015437f, 0.10393616f, 0.04066668f, 0.09681576f, 0.06625322f, 0.02678742f, 
    -0.05631961f, 0.05527779f, -0.04339468f, 0.23625645f, -0.29538402f, 0.22131123f, -0.17916374f, 0.14654656f, 
    0.01350917f, -0.01979131f, 0.22606389f, 0.29337195f, -0.13713786f, 0.06415845f, -0.05452042f, 0.10814019f, 
    0.32734814f, 0.09541145f, 0.10097980f, 0.02227350f, 0.22509223f, -0.19612151f, -0.06588399f, 0.09555276f, 
    -0.04067492f, 0.00837969f, -0.08558870f, -0.00315529f, 0.08320048f, 0.18364152f, -0.06385950f, 0.15965210f, 
    -0.53141171f, 0.02486043f, -0.14400715f, 0.35510558f, -0.05300844f, -0.46214616f, 0.01285862f, 0.19998543f, 
    -0.49898091f, 0.18742800f, -0.07046978f, 0.08920236f, -0.12265097f, 0.07770512f, 0.18293186f, -0.10163088f, 
    -0.10472620f, 0.04987666f, 0.08003096f, -0.14320678f, -0.34846592f, -0.03245373f, 0.22451252f, -0.13061821f, 
    0.03180627f, 0.06042489f, 0.31798768f, -0.11946391f, 0.32604355f, -0.22147775f, 0.07175460f, -0.15728401f, 
    0.21437743f, 0.12591551f, -0.18431585f, -0.17033093f, -0.03072196f, -0.09036034f, 0.14576274f, -0.00197895f, 
    0.15141471f, 0.03851605f, 0.28334594f, -0.01463844f, 0.11302434f, 0.27774107f, -0.22337541f, 0.19558473f, 
    -0.20874597f, -0.17161749f, -0.05467343f, -0.09836219f, 0.06015732f, 0.46203452f, -0.09033113f, 0.04210414f, 
    -0.36124650f, 0.16652998f, 0.04167124f, -0.06612034f, 0.31651545f, 0.03397496f, 0.06864147f, 0.12696245f, 
    0.19507669f, -0.01860375f, 0.12024886f, 0.40546143f, 0.12573719f, -0.40807882f, 0.29336679f, -0.08893412f, 
    0.17889483f, 0.04679933f, -0.06589583f, -0.19387871f, -0.00742919f, 0.08680659f, 0.08328256f, 0.13440871f, 
    0.27142414f, -0.01490692f, 0.16496354f, 0.12914675f, 0.15551786f, -0.06741638f, 0.15718600f, 0.30260748f, 
    -0.36691511f, 0.03570777f, 0.08860196f, 0.13409236f, 0.00577006f, 0.20451421f, 0.09633394f, -0.03562243f, 
    -0.02260309f, 0.40153071f, 0.00516839f, 0.10339578f, -0.12132789f, 0.32286337f, -0.03330961f, 0.15475354f, 
    -0.12905450f, 0.02086325f, 0.20365408f, 0.11450971f, 0.25799331f, -0.07550666f, -0.10245507f, -0.07893606f, 
    -0.23825540f, 0.07798164f, 0.12290341f, 0.01043422f, -0.02692653f, -0.30615956f, 0.01169716f, -0.05343005f, 
    -0.02727229f, 0.03306436f, -0.16774803f, -0.02456837f, 0.21432893f, 0.15708689f, -0.05541703f, 0.34419829f, 
    0.58176631f, 0.02538313f, -0.01570410f, 0.07412891f, -0.07589534f, -0.03195682f, -0.27266595f, 0.08456797f, 
    0.00969647f, -0.10115330f, 0.11517885f, 0.00198946f, -0.02899486f, -0.06155751f, 0.37812063f, -0.24713038f, 
    -0.07141929f, -0.07383831f, -0.04244002f, 0.03356992f, 0.09004077f, -0.08467056f, 0.07475890f, -0.21453926f, 
    0.14329191f, 0.13797520f, 0.00165694f, -0.05912039f, -0.13721487f, -0.00741875f, 0.14483047f, 0.15687850f, 
    0.10366608f, 0.13023025f, -0.06870404f, -0.22295085f, 0.28531530f, 0.02454676f, -0.01846259f, 0.30521861f, 
    0.24536252f, 0.20902501f, 0.20065199f, -0.09236464f, 0.08993030f, -0.65892798f, -0.27115709f, -0.23611251f, 
    -0.21224619f, 0.03099619f, 0.13721213f, 0.24446449f, -0.12893257f, 0.46321777f, 0.00148186f, 0.15900180f, 
    -0.12659372f, 0.23636857f, -0.09770851f, 0.03001410f, -0.27463949f, 0.04010326f, -0.34694880f, 0.02371028f, 
    -0.13942133f, 0.09284684f, -0.05293405f, 0.26833227f, -0.45128834f, 0.01228856f, 0.16408812f, -0.07098248f, 
    -0.29783505f, -0.16426027f, 0.09445558f, -0.00841551f, -0.05346250f, 0.06946345f, -0.01684546f, 0.00241340f, 
    -0.01773741f, -0.09115486f, -0.00605154f, -0.01556097f, -0.03183369f, 0.03816422f, -0.01533544f, -0.09317592f, 
    -0.02509464f, 0.05895848f, 0.02509629f, 0.02224906f, -0.09390166f, -0.08444733f, -0.00851156f, -0.07676403f, 
    -0.05907908f, -0.08090346f, -0.07805654f, -0.00600988f, -0.06459726f, -0.09507427f, 0.02773314f, 0.02010775f, 
    0.05687422f, -0.04131561f, 0.03110625f, -0.08126184f, 0.02276399f, 0.06765411f, -0.02264690f, -0.12372279f, 
    -0.00426375f, -0.08169089f, -0.05705432f, -0.00283433f, 0.01100687f, -0.08651225f, -0.04828339f, -0.02379676f, 
    -0.08328377f, 0.02506391f, 0.06628403f, 0.03879254f, -0.02407208f, 0.05010447f, -0.02057043f, 0.07114138f, 
    -0.09065640f, -0.07963531f, -0.00675058f, -0.02525916f, 0.00887501f, -0.04934126f, 0.03652718f, -0.01177818f, 
    0.05593673f, -0.03981036f, -0.00109106f, 0.04525802f, 0.02443088f, 0.03719126f, 0.01255845f, 0.02102627f, 
    -0.05435229f, 0.03461037f, -0.03027714f, -0.00810495f, -0.11411810f, 0.08550588f, -0.08107211f, -0.08914378f, 
    -0.08587158f, -0.03566456f, -0.09551332f, -0.02694931f, 0.02530185f, 0.03408988f, -0.10126056f, -0.02963208f, 
    -0.07686778f, -0.08320636f, 0.01596043f, -0.12642665f, -0.03730135f, -0.04077506f, -0.04561217f, 0.01195532f, 
    -0.01437600f, 0.08100585f, 0.00629925f, -0.06242927f, -0.00056049f, -0.07368831f, -0.00051518f, -0.09216326f, 
    0.05156129f, 0.07054505f, -0.08457591f, 0.01671244f, -0.07264563f, -0.09499297f, -0.01950986f, 0.01254280f, 
    -0.08661101f, -0.04402293f, -0.07348394f, -0.04659257f, -0.02491126f, 0.03659827f, -0.05624703f, 0.02853720f, 
    -0.06939316f, 0.02710564f, -0.07876530f, 0.03032060f, -0.04339491f, -0.01303550f, -0.06638380f, -0.05761155f, 
    -0.02897926f, -0.08091754f, 0.02742169f, -0.11719377f, -0.00803964f, 0.01566213f, -0.11759004f, 0.00142805f, 
    -0.36450773f, 0.08577023f, -0.42429647f, -0.12994507f, -0.30880234f, -0.42115960f, 0.61162728f, -0.03049688f, 
    0.13719887f, 0.01587630f, 0.17311233f, 0.18894000f, -0.01721403f, 0.34991169f, 0.05210622f, 0.16857356f, 
    -0.12139588f, 0.19282743f, 0.02885404f, -0.12758102f, 0.24178021f, 0.60914737f, 0.21999969f, -0.01032381f, 
    -0.35318476f, 0.03765183f, -0.31459883f, 0.01090581f, -0.13348883f, -0.38449049f, 0.06417770f, 0.24092153f, 
    0.02161503f, -0.01130938f, -0.10542346f, 0.09354190f, 0.00873118f, -0.37420821f, -0.04557599f, 0.01395788f, 
    -0.19389540f, 0.02656573f, 0.10526297f, -0.00312248f, 0.08462317f, 0.14227331f, -0.07181931f, -0.46324995f, 
    -0.14878039f, 0.05258481f, -0.12993449f, 0.15703332f, 0.05184704f, 0.24027625f, -0.15829542f, -0.14734140f, 
    0.21988577f, -0.07175878f, 0.35981017f, 0.22987708f, 0.40286174f, -0.03368389f, 0.36639091f, -0.01334978f, 
    0.19960973f, -0.16955356f, -0.01194658f, 0.39120251f, 0.31014681f, 0.05402325f, 0.08648340f, -0.26718232f, 
    -0.12532343f, 0.00820728f, 0.08936241f, 0.19493876f, -0.21851778f, -0.14042372f, -0.22718519f, 0.03041813f, 
    -0.15116623f, -0.24352030f, 0.16924283f, -0.04340143f, 0.07662941f, -0.07146139f, -0.13858412f, -0.03685683f, 
    0.16870733f, -0.44034070f, 0.07211769f, -0.10218969f, -0.14767899f, 0.24058944f, -0.22474794f, -0.18194230f, 
    0.09418450f, 0.35409871f, -0.23046218f, 0.11310119f, 0.25904271f, 0.16426401f, -0.01307285f, -0.33106691f, 
    -0.01579170f, -0.58949244f, 0.22623122f, 0.03372321f, -0.18235956f, 0.16785558f, -0.02547783f, -0.00062928f, 
    -0.19934079f, -0.43601176f, -0.12759039f, 0.21068175f, -0.44516060f, 0.20714293f, -0.24001108f, -0.20134939f, 
    0.10913051f, -0.40743476f, 0.12962076f, 0.02375660f, 0.17284018f, 0.29995587f, -0.31099743f, -0.51038146f, 
    -0.03914111f, 0.06689625f, -0.03632572f, 0.08860312f, 0.29008430f, -0.06037059f, 0.62451518f, 0.12158742f, 
    -0.33989251f, -0.06921045f, 0.29068267f, -0.02754573f, 0.06565792f, 0.22335829f, -0.06674416f, -0.14291969f, 
    0.09158838f, 0.25526077f, 0.01447613f, -0.16422208f, -0.08199862f, 0.11788705f, 0.06440686f, 0.09259149f, 
    -0.00678635f, 0.04318379f, -0.01664381f, -0.19133675f, -0.03155136f, 0.08629989f, 0.02156856f, -0.17501047f, 
    -0.10156552f, 0.15026879f, 0.06356750f, 0.08428311f, -0.20269452f, 0.26911935f, -0.05869410f, 0.06408601f, 
    0.07911658f, 0.03934735f, 0.05307853f, -0.12567313f, 0.27739170f, 0.10788969f, 0.01284634f, 0.64574683f, 
    -0.32457128f, 0.05551359f, 0.20200574f, -0.02013046f, 0.06010451f, -0.17537880f, 0.20470469f, -0.04839271f, 
    0.14146195f, 0.06424408f, 0.02131518f, -0.12524450f, 0.04684731f, -0.37646982f, 0.27489933f, 0.11119030f, 
    -0.29511946f, 0.02450699f, 0.02386697f, 0.18746153f, -0.32135564f, -0.10845260f, 0.02369803f, -0.09773163f, 
    0.03189494f, 0.14973257f, -0.10276102f, -0.02522293f, 0.04526869f, -0.29242888f, -0.15928875f, -0.06862330f, 
    -0.28986338f, 0.04707086f, -0.08204482f, -0.28762203f, -0.21598820f, -0.22114369f, 0.08783461f, -0.38497511f, 
    -0.15261814f, 0.63488287f, -0.11498766f, -0.11071715f, -0.01708183f, -0.07663083f, 0.14006729f, -0.08074086f, 
    -0.00607361f, 0.22947522f, 0.02618023f, 0.27107948f, -0.00839888f, 0.09042287f, 0.13177276f, 0.30555159f, 
    0.07724673f, 0.15924944f, -0.11356024f, 0.01528209f, -0.03579982f, -0.13174237f, -0.07596442f, -0.09425821f, 
    0.03994592f, 0.04296199f, 0.02157432f, -0.20698601f, 0.63424730f, -0.00881177f, 0.03517917f, -0.03208441f, 
    -0.02691000f, 0.11107390f, -0.13055514f, -0.36979309f, -0.05920234f, -0.24520840f, 0.12600856f, 0.23122324f, 
    0.04506564f, 0.05015319f, -0.09627500f, 0.00476520f, -0.03553785f, -0.09299348f, 0.02454214f, -0.04031720f, 
    -0.02425298f, -0.00223959f, -0.05575114f, -0.03753094f, 0.05724067f, -0.02859401f, 0.04058231f, 0.05133454f, 
    -0.06650734f, -0.08519476f, -0.05352803f, -0.02594027f, -0.01830281f, 0.03642755f, -0.09984785f, -0.00019969f, 
    0.06934775f, 0.05363883f, -0.07434002f, -0.04480787f, -0.08834162f, -0.03536744f, 0.04428833f, 0.01543071f, 
    -0.03974539f, -0.04704815f, -0.00339199f, -0.01179176f, 0.05850444f, -0.03617880f, -0.04653780f, -0.05818027f, 
    0.03598718f, 0.03656998f, -0.09832862f, -0.06615651f, 0.02189028f, -0.02657171f, 0.03523125f, -0.01542922f, 
    0.02857633f, 0.03227790f, -0.03641386f, -0.06611118f, -0.06374561f, -0.00614839f, 0.04306821f, 0.00198247f, 
    -0.03747958f, 0.05956112f, 0.05883390f, -0.06034150f, -0.01262817f, -0.02024330f, -0.05616918f, -0.05072767f, 
    -0.06280030f, -0.01451584f, -0.08385771f, 0.02891169f, -0.06575512f, -0.00350668f, -0.08992653f, 0.01777608f, 
    -0.00942207f, -0.04772222f, -0.06366201f, -0.06956069f, 0.07573678f, -0.00368235f, -0.03671231f, -0.00958057f, 
    0.08746763f, -0.01664276f, -0.07183149f, -0.03436275f, 0.03428315f, -0.08904990f, -0.00775424f, 0.06848437f, 
    -0.05854027f, -0.03864480f, 0.00313517f, -0.00720833f, -0.02302642f, -0.02503256f, -0.00397821f, 0.05104503f, 
    -0.03719880f, -0.06029391f, 0.03812422f, -0.04314733f, -0.07848935f, 0.05983183f, -0.08430170f, -0.06751296f, 
    -0.05067084f, -0.09453825f, 0.03014225f, 0.03374140f, 0.08180812f, 0.03748767f, 0.07102365f, -0.03411645f, 
    0.01659615f, 0.05422834f, -0.00417999f, -0.05635770f, 0.04937173f, 0.06884600f, -0.05998411f, 0.03587569f, 
    0.06729154f, 0.01664052f, -0.02028179f, 0.04809779f, -0.01089563f, -0.04959000f, -0.03087876f, 0.03282410f, 
    0.11686666f, -0.01417728f, -0.10183227f, 0.04935234f, -0.12497560f, -0.02847876f, -0.62466317f, 0.21726894f, 
    -0.11111413f, 0.08028258f, -0.55778259f, -0.00460922f, -0.08191333f, -0.03537007f, -0.01321276f, 0.01052497f, 
    -0.08622523f, 0.21811943f, -0.00742299f, 0.02886258f, -0.01158399f, 0.30262837f, 0.00048275f, 0.14518435f, 
    -0.08355824f, -0.04224933f, -0.18581060f, -0.00011263f, 0.10904031f, -0.08492444f, 0.03738300f, 0.12180257f, 
    -0.11016174f, -0.08548094f, 0.00343423f, -0.21691769f, -0.00898140f, 0.12650961f, 0.06037804f, 0.11294533f, 
    0.09822764f, 0.03651958f, 0.07122603f, 0.22629999f, 0.07734396f, 0.15251462f, -0.00046983f, -0.05754548f, 
    0.53553563f, -0.05854619f, -0.02516510f, 0.02445087f, -0.53717297f, 0.13493618f, -0.22614641f, 0.07993776f, 
    0.28053153f, -0.01672685f, 0.01818593f, 0.07594814f, 0.01917134f, -0.07529747f, 0.38492197f, -0.32780632f, 
    0.17406036f, -0.02049292f, 0.03109557f, 0.18511838f, 0.60842013f, 0.00452208f, -0.09377133f, 0.11106388f, 
    0.13972385f, 0.07868668f, -0.06637473f, -0.10915807f, -0.17132936f, 0.07117996f, -0.05358326f, -0.05031962f, 
    0.16751124f, 0.05711130f, 0.12259933f, 0.21200553f, 0.19105369f, 0.07876079f, 0.11632534f, 0.29407510f, 
    0.15994704f, -0.38888115f, 0.16655444f, 0.13303669f, -0.10406832f, -0.14562939f, -0.06182973f, -0.11833024f, 
    -0.09573039f, -0.00601703f, 0.16254406f, -0.19669552f, -0.11009613f, 0.15643260f, -0.05066895f, -0.05789844f, 
    0.12455393f, -0.21581888f, 0.24444470f, 0.05289974f, -0.24339424f, -0.13423695f, 0.08004553f, -0.00325366f, 
    -0.00849008f, -0.07172459f, 0.08519576f, 0.05869639f, -0.56120944f, 0.31510729f, 0.06098327f, 0.08374584f, 
    -0.09915494f, -0.04707786f, 0.06455229f, 0.07234865f, -0.03214227f, 0.05194761f, 0.11936647f, 0.13569289f, 
    0.06914088f, -0.05902348f, -0.06708495f, 0.04148593f, 0.05349132f, -0.00977457f, -0.04873936f, 0.04910104f, 
    0.03695645f, -0.03312378f, -0.01981118f, -0.07350794f, -0.10055345f, -0.01540191f, -0.01046630f, 0.07161761f, 
    -0.02407286f, 0.06018098f, -0.01520149f, -0.03434173f, 0.01816577f, -0.07896404f, -0.02456797f, 0.00438578f, 
    -0.00179782f, 0.00551539f, -0.00625164f, 0.00774474f, -0.06269243f, -0.02422724f, -0.04745895f, -0.04640691f, 
    -0.09857906f, -0.02961045f, -0.00990905f, 0.00773347f, 0.02106711f, -0.07877441f, -0.03863759f, -0.08147547f, 
    0.06235005f, -0.07627150f, -0.03697451f, -0.07921757f, -0.02601833f, -0.09865035f, 0.05944762f, 0.07173366f, 
    -0.05808733f, 0.01477977f, -0.08283610f, -0.00179198f, -0.01623863f, -0.01473393f, -0.05532105f, -0.02182883f, 
    -0.10201269f, 0.01366951f, 0.00047996f, 0.06225113f, -0.03299743f, -0.09858488f, -0.08327824f, -0.00967907f, 
    -0.02728521f, -0.09872578f, -0.06586418f, -0.04006019f, -0.02379476f, -0.06387910f, 0.02137944f, 0.02285231f, 
    -0.03770417f, -0.06912817f, -0.01587645f, -0.00798991f, -0.05664867f, 0.06563639f, -0.04840496f, -0.07516670f, 
    -0.05235302f, 0.02672257f, 0.06245524f, 0.06378096f, 0.00669415f, -0.00626129f, -0.05551701f, 0.01644177f, 
    0.03689580f, 0.03194864f, -0.10460000f, -0.06522494f, -0.01694370f, 0.04043199f, -0.01391082f, -0.06741730f, 
    -0.08871564f, 0.03582938f, 0.04007382f, 0.00209824f, -0.00885873f, 0.04889455f, -0.08967160f, -0.03667553f, 
    0.05476244f, -0.08265982f, -0.03403868f, -0.03952720f, -0.07832110f, -0.00464926f, -0.03741010f, -0.05704971f, 
    -0.06461248f, 0.02115963f, 0.06439447f, -0.04757184f, 0.05749654f, -0.01304221f, -0.01826067f, -0.06989013f, 
    0.04410543f, -0.01554441f, 0.01418920f, 0.03017407f, 0.00665798f, -0.06266542f, -0.02149242f, -0.05986774f, 
    -0.01999496f, 0.34784034f, 0.18857001f, 0.01719945f, -0.11145027f, -0.22195634f, -0.28405243f, 0.15075354f, 
    -0.11676791f, -0.01553846f, 0.26446161f, -0.08216333f, -0.00488632f, -0.13150141f, 0.05290734f, -0.02856834f, 
    0.20070274f, -0.04431576f, 0.01488372f, -0.03635373f, 0.14814708f, -0.18433660f, 0.04851117f, 0.08980349f, 
    -0.12747563f, 0.00369350f, 0.14502777f, -0.09055153f, -0.02994416f, -0.04213594f, 0.04264887f, 0.09429073f, 
    0.03071565f, 0.15057276f, 0.03273627f, 0.03692799f, -0.03515754f, 0.07375503f, -0.01268450f, 0.20789938f, 
    0.01241607f, 0.01422294f, -0.01371612f, 0.01100308f, -0.23041040f, 0.00364594f, -0.05750364f, -0.25796959f, 
    -0.28180656f, 0.10670586f, 0.15720645f, -0.04314272f, -0.11217046f, -0.14865981f, 0.03242760f, 0.06080834f, 
    -0.01697025f, -0.01451340f, 0.10212383f, 0.05005743f, 0.21247567f, -0.09400300f, -0.22807774f, 0.28493178f, 
    -0.13762136f, -0.00801970f, -0.00150802f, -0.15500383f, -0.26281920f, 0.03365390f, -0.05895978f, -0.29002887f, 
    0.10316553f, 0.08646136f, 0.08110436f, 0.20429713f, 0.24459903f, 0.18577251f, -0.07746584f, -0.05856449f, 
    0.10965072f, -0.12672138f, 0.31618112f, 0.12856865f, -0.20266539f, -0.33155248f, 0.09051387f, -0.30048269f, 
    -0.12465144f, 0.21432745f, -0.04192670f, 0.25537753f, 0.02750709f, -0.15691485f, -0.16558921f, -0.21087532f, 
    0.09582097f, 0.18979129f, -0.49874729f, -0.17344542f, 0.27818123f, -0.08109981f, -0.03671912f, -0.18598403f, 
    -0.19948269f, 0.05467154f, 0.19892715f, 0.00503402f, -0.39301875f, 0.18145576f, -0.10643592f, -0.07352927f, 
    0.12957886f, -0.29278246f, -0.09579453f, 0.21106714f, 0.02654043f, 0.24435821f, -0.33355671f, 0.19437423f, 
    0.01860976f, -0.12796830f, 0.23840012f, -0.49251935f, -0.23228493f, 0.26765171f, 0.03702479f, -0.07123291f, 
    -0.00998990f, 0.09051457f, -0.06814849f, -0.20583126f, -0.34049925f, -0.03644631f, 0.26374397f, -0.60978466f, 
    0.23005396f, 0.04543044f, 0.02435713f, 0.06629286f, 0.10827851f, -0.03047815f, -0.09192558f, 0.03700608f, 
    -0.26223043f, 0.01192508f, -0.07105101f, 0.23688903f, -0.14406502f, 0.31651777f, -0.03169731f, 0.04081526f, 
    -0.04939239f, -0.05464928f, -0.19043647f, -0.02286423f, -0.31975999f, 0.02788143f, -0.09817895f, 0.20311138f, 
    0.26926771f, 0.08559269f, 0.06717683f, -0.03790584f, 0.27987888f, 0.07411796f, 0.05146248f, 0.13774782f, 
    -0.05482902f, 0.02696333f, -0.00450625f, -0.03164419f, 0.01836401f, -0.02018978f, -0.01818415f, -0.29829457f, 
    -0.37876958f, -0.12290776f, -0.11312630f, 0.24620210f, -0.36190742f, -0.12385427f, 0.28653231f, -0.01060451f, 
    -0.10802203f, 0.01286006f, -0.07971135f, -0.05112720f, -0.20465353f, -0.02923853f, 0.19206247f, 0.00804877f, 
    -0.05024047f, -0.01296091f, -0.02189524f, -0.03847369f, -0.14593071f, -0.02201584f, 0.00314267f, 0.12797834f, 
    0.13119762f, -0.08723658f, 0.45915312f, -0.29333347f, 0.13917230f, 0.07998896f, 0.01569354f, -0.06056977f, 
    -0.05149375f, 0.04467283f, -0.21723378f, -0.22939631f, -0.01030907f, -0.01722565f, 0.17790148f, 0.05796086f, 
    0.13067241f, -0.41866383f, 0.05957722f, -0.15775873f, -0.15474035f, 0.37945163f, 0.02809063f, 0.06128788f, 
    -0.00572895f, -0.05418784f, -0.08763861f, 0.04380672f, -0.00008743f, 0.25470570f, 0.18539813f, -0.08655255f, 
    -0.23817036f, -0.09162369f, 0.08299469f, -0.09300003f, -0.26835158f, 0.03460253f, 0.21442142f, -0.19887564f, 
    -0.05165950f, -0.09550708f, 0.16676062f, 0.27360880f, -0.16277076f, -0.04870524f, 0.16745019f, 0.16455843f, 
    0.08950649f, 0.12467593f, 0.00257793f, 0.00374648f, 0.23932055f, 0.17379814f, 0.08640664f, 0.11343332f, 
    -0.02546087f, 0.13238581f, -0.22784826f, -0.07182339f, -0.54728466f, 0.00986142f, -0.26684055f, 0.24877629f, 
    0.25964320f, 0.01062189f, -0.09231008f, 0.03307375f, -0.01846883f, 0.13320462f, -0.17587569f, 0.06048149f, 
    -0.00075354f, 0.16030997f, -0.08313870f, -0.18535976f, 0.03543119f, -0.10670604f, 0.12396132f, 0.10767841f, 
    0.04241243f, 0.08641991f, -0.07475474f, -0.28805706f, -0.31550574f, -0.11730952f, -0.01565145f, 0.04236855f, 
    -0.10209773f, -0.07643051f, 0.15917571f, -0.03807752f, 0.05071039f, -0.12277431f, -0.03658143f, 0.20120369f, 
    0.09055330f, -0.04312453f, 0.03639784f, -0.03809511f, -0.07104912f, 0.04206458f, -0.08828072f, -0.48035219f, 
    0.26884201f, -0.14620750f, 0.08343442f, 0.17947775f, 0.09534249f, 0.04552757f, -0.05874532f, -0.03001460f, 
    0.44898024f, -0.11934727f, 0.26255414f, -0.04043398f, 0.11792044f, 0.30638221f, 0.02809874f, 0.19336121f, 
    0.07016118f, 0.20658173f, 0.05395261f, 0.16444835f, 0.04911160f, 0.00839146f, -0.12963168f, -0.12535837f, 
    0.05456371f, 0.03745951f, 0.01567049f, 0.17956848f, -0.15531199f, 0.18022129f, 0.02160854f, 0.14873652f, 
    -0.12049726f, -0.01797286f, 0.28309426f, 0.12749511f, -0.06181731f, 0.20333627f, 0.06675978f, 0.21482386f, 
    0.15839523f, -0.73511261f, 0.11653623f, 0.05174013f, -0.33417207f, -0.18840900f, 0.21420251f, -0.14234771f, 
    0.27293700f, -0.15345421f, 0.08182611f, -0.14290817f, 0.16053084f, -0.05462993f, 0.12799862f, 0.03939223f, 
    0.22547215f, 0.02149705f, 0.05094969f, 0.03731400f, 0.04584327f, -0.13946949f, 0.04701574f, -0.05412232f, 
    -0.10738187f, -0.16214927f, 0.07100231f, 0.10918285f, -0.28838065f, 0.47749633f, 0.01607400f, 0.24652049f, 
    0.03355857f, 0.15736267f, 0.11221491f, 0.17916320f, -0.00278847f, 0.03739939f, 0.05108759f, -0.16936339f, 
    -0.04163186f, -0.08454053f, 0.01127263f, 0.00962402f, 0.01807503f, 0.01637249f, 0.06114161f, -0.07974228f, 
    -0.06709298f, -0.06436051f, -0.05748784f, -0.05944160f, 0.00506873f, 0.00185036f, -0.02818111f, -0.02768108f, 
    -0.00957630f, -0.00217730f, 0.01640445f, 0.03801875f, 0.00124035f, 0.03124397f, 0.07532039f, -0.05648684f, 
    0.01041777f, 0.06729213f, -0.02116900f, -0.00260585f, 0.01889607f, -0.00182096f, -0.04827469f, 0.07797132f, 
    0.00504048f, 0.04080911f, 0.08654654f, 0.06179186f, -0.04361040f, 0.01165433f, -0.06405974f, -0.04893393f, 
    -0.05244391f, -0.03423909f, 0.08213666f, -0.03026464f, -0.04012335f, -0.01947983f, -0.06575327f, -0.05925571f, 
    -0.04099798f, 0.03806315f, 0.01284938f, -0.06393182f, -0.00593317f, -0.02653764f, -0.03392353f, -0.05536456f, 
    0.02920831f, -0.09697907f, -0.08390401f, -0.09045149f, 0.01172363f, 0.00609174f, -0.01162928f, 0.00065100f, 
    0.00480119f, 0.03149809f, -0.08090407f, -0.05238063f, 0.03429291f, -0.03293689f, -0.04523388f, 0.02229306f, 
    0.05363186f, -0.04925761f, -0.01705215f, 0.02821880f, -0.00962903f, -0.03389843f, -0.06451999f, 0.01239049f, 
    0.07370584f, -0.07011228f, -0.02222511f, -0.07334463f, -0.00772655f, 0.01460713f, -0.07797072f, 0.07630068f, 
    -0.01821740f, -0.06721505f, 0.07127167f, -0.00747439f, -0.05497311f, 0.08691113f, -0.01477179f, -0.08132914f, 
    -0.03141393f, 0.06103108f, -0.03942141f, -0.05046777f, 0.07291956f, 0.01044152f, 0.00850878f, -0.03111172f, 
    0.00918608f, -0.00176111f, -0.01021044f, 0.04459909f, 0.03753104f, 0.05302236f, 0.00541383f, 0.02500141f, 
    -0.07507212f, -0.08762483f, -0.05499722f, -0.05283856f, -0.06684998f, -0.02636636f, -0.02256790f, -0.06138615f, 
    0.05194889f, -0.06996070f, 0.07392512f, -0.07680717f, 0.04874032f, -0.06916685f, -0.01377461f, -0.05429757f, 
    0.31394914f, 0.02077575f, 0.34865201f, 0.20557551f, 0.37322697f, 0.23677741f, -0.06934434f, -0.02019374f, 
    -0.30448782f, -0.04942830f, -0.51478720f, -0.26363090f, -0.14874992f, -0.23070286f, 0.07918362f, 0.00067668f, 
    0.17571937f, -0.12359183f, 0.03119658f, 0.24657685f, -0.03496607f, -0.01327649f, -0.09675908f, -0.16787338f, 
    -0.08077475f, 0.11194491f, 0.11672473f, 0.11261495f, 0.20456596f, 0.04147489f, 0.06715258f, 0.09116875f, 
    -0.13150267f, -0.10031780f, -0.16926682f, -0.08794889f, 0.06187413f, -0.08173875f, 0.00588813f, -0.04865513f, 
    -0.00033766f, -0.07114363f, -0.06126001f, 0.13755655f, 0.17205301f, 0.15186937f, 0.03549001f, 0.39740664f, 
    -0.10669543f, 0.11024516f, -0.16640669f, -0.18123348f, 0.00615507f, -0.09001357f, -0.04643583f, 0.15996857f, 
    -0.34064046f, 0.06833973f, -0.36817151f, 0.09500112f, 0.07141786f, -0.38732341f, 0.24490774f, 0.18689875f, 
    -0.08799785f, -0.08959395f, 0.01267206f, 0.15518101f, 0.17410782f, -0.07017716f, 0.07690196f, 0.27372867f, 
    -0.01592418f, 0.14965628f, 0.07939747f, 0.03898968f, 0.12915777f, 0.12842704f, -0.12740637f, -0.04808001f, 
    0.31698203f, 0.07961119f, 0.20630912f, 0.00939169f, 0.05638649f, -0.10632752f, 0.01905841f, -0.19111469f, 
    -0.23835775f, -0.33463493f, 0.19957310f, 0.22299822f, 0.24822088f, -0.00099866f, -0.10606930f, -0.06093783f, 
    -0.47061217f, 0.21687073f, 0.18940857f, 0.15192863f, 0.17846689f, 0.19753489f, -0.24933688f, 0.03715323f, 
    -0.14681089f, 0.08807348f, -0.00341140f, -0.08552046f, 0.42129338f, -0.01341947f, -0.02488870f, -0.02339005f, 
    0.27825195f, 0.02254117f, -0.08925802f, -0.22712812f, 0.72576743f, -0.30687225f, 0.21876238f, -0.15088694f, 
    -0.14064494f, -0.09090082f, -0.13960327f, -0.05078047f, -0.13122477f, -0.10745555f, -0.20462592f, 0.15356080f, 
    -0.24480480f, -0.04395443f, -0.07383107f, 0.24326520f, -0.19390504f, -0.13494274f, -0.32660866f, -0.25442636f, 
    -0.00513497f, -0.04071815f, -0.21719725f, -0.03619277f, -0.36171579f, 0.34972233f, 0.02269171f, 0.11806551f, 
    0.01908902f, 0.18931884f, -0.02313158f, 0.02117643f, 0.05986166f, 0.27947506f, 0.16628979f, -0.05047855f, 
    0.02117262f, -0.01312155f, -0.12621604f, 0.14397678f, -0.00898016f, -0.42243436f, 0.02199840f, 0.29151309f, 
    -0.50181913f, -0.19279085f, 0.17489779f, -0.03286203f, 0.23385277f, -0.17239685f, 0.04592139f, -0.23749751f, 
    -0.02110190f, 0.01925922f, 0.04527051f, 0.28029746f, -0.05988560f, 0.04349183f, 0.00440340f, -0.24701136f, 
    0.07098889f, -0.06193591f, 0.13927524f, 0.13804965f, 0.13722679f, -0.01586611f, 0.22052723f, 0.18957826f, 
    0.20711887f, -0.21416597f, 0.35190064f, 0.07687476f, 0.39991337f, 0.07521410f, -0.27728105f, 0.11579091f, 
    0.08608834f, 0.04516411f, 0.00099905f, 0.46922088f, -0.02113683f, 0.01607008f, 0.13565689f, -0.07743227f, 
    -0.19956426f, 0.11218634f, 0.02398653f, 0.35329282f, 0.09731918f, -0.02941521f, 0.19337194f, -0.09376699f, 
    0.11885871f, -0.08860178f, 0.12859589f, 0.38151947f, -0.34254101f, -0.13771172f, 0.08722924f, -0.00164342f, 
    0.06017908f, -0.02024085f, 0.08578764f, 0.15482743f, -0.16390608f, 0.69877851f, 0.07712571f, 0.59018344f, 
    0.11415037f, -0.12026589f, 0.35782138f, -0.01592585f, 0.22342606f, 0.03639182f, -0.18777201f, -0.31867886f, 
    0.11608467f, -0.38008520f, 0.10004459f, 0.01118273f, 0.37719366f, -0.06581188f, -0.01548475f, 0.11132713f, 
    0.27566260f, -0.24242948f, -0.19403070f, 0.03081239f, -0.50886196f, 0.14180887f, 0.06577795f, -0.03786025f, 
    -0.12489513f, -0.25156263f, 0.09021115f, 0.21913798f, -0.13115150f, 0.12358571f, -0.21537001f, -0.58117586f, 
    -0.69539469f, 0.00138090f, -0.19877653f, -0.29493859f, -0.12114127f, 0.20280726f, 0.10402079f, -0.19882569f, 
    -0.00848024f, -0.02820021f, -0.32008925f, 0.17544040f, -0.19003524f, -0.16949096f, 0.00579986f, -0.16644233f, 
    -0.03023641f, -0.25416374f, -0.04543248f, 0.10614794f, -0.14945462f, 0.08762100f, -0.14539455f, 0.03878930f, 
    -0.05517880f, -0.02481139f, -0.10770920f, 0.04657168f, -0.13149086f, 0.05648174f, -0.06952012f, 0.22533296f, 
    0.21086018f, 0.08679018f, -0.08127443f, -0.25767037f, 0.23093975f, -1.00095022f, -0.08625749f, 0.16589575f, 
    0.08368345f, 0.01683320f, -0.11370738f, -0.06643521f, -0.02027767f, 0.13375837f, -0.08246096f, 0.10630523f, 
    -0.55084169f, -0.16225998f, -0.11098647f, 0.32842582f, -0.16750807f, 0.02621335f, -0.09927097f, 0.04676376f, 
    -0.11901534f, 0.20219104f, 0.04738325f, -0.04117734f, 0.01039014f, -0.16772857f, 0.03310586f, -0.25528097f, 
    0.03280893f, -0.32394400f, 0.01990305f, -0.18883894f, 0.12139773f, 0.02748063f, 0.12392359f, 0.23266892f, 
    0.08485979f, -0.01793298f, 0.29088837f, -0.12449239f, -0.07212558f, 0.06512995f, -0.10027475f, 0.05274782f, 
    0.23945768f, -0.28798014f, -0.00878520f, 0.12412566f, 0.44381809f, 0.14606468f, 0.05813584f, 0.39411086f, 
    0.30664209f, -0.23759510f, 0.29097518f, 0.10643894f, 0.27281556f, 0.13446140f, -0.08926512f, -0.13695575f, 
    0.03054690f, -0.15327428f, -0.27776325f, -0.28417280f, -0.02994078f, 0.24841218f, -0.09620462f, 0.00809802f, 
    -0.10065414f, -0.14705695f, 0.07958485f, 0.02335793f, 0.21866734f, 0.03925741f, -0.18297222f, 0.19318630f, 
    0.04296380f, 0.03893937f, 0.09607060f, 0.33854133f, -0.26477167f, -0.02361260f, 0.02905439f, -0.00591655f, 
    0.14722803f, 0.20590258f, 0.10111678f, 0.26881698f, 0.16749763f, 0.24120641f, -0.01863649f, -0.09531192f, 
    0.08097372f, -0.05594648f, 0.05529943f, -0.04719618f, 0.00228694f, 0.06470504f, 0.01485426f, -0.01779556f, 
    -0.03413913f, 0.04045302f, -0.04030997f, 0.02443540f, 0.01066572f, -0.03775932f, 0.02389302f, -0.03978817f, 
    -0.03013816f, 0.02165642f, -0.04754822f, -0.04008276f, -0.05626532f, -0.08914408f, -0.06356883f, 0.06160195f, 
    0.03237234f, 0.02710375f, -0.04742583f, 0.04281651f, -0.06153842f, -0.08329733f, 0.05046925f, -0.00000345f, 
    0.02111235f, -0.02778682f, -0.00621515f, -0.05408726f, 0.02762889f, -0.03668607f, 0.06245655f, -0.09167490f, 
    0.05843354f, -0.00026049f, 0.01326559f, 0.04161287f, -0.05364626f, 0.06184182f, 0.01119544f, 0.04761423f, 
    -0.03924471f, 0.05687973f, 0.01685650f, -0.00335142f, -0.05605869f, 0.00711454f, -0.08083203f, -0.08044399f, 
    -0.08449504f, 0.01123085f, -0.07962942f, 0.01648154f, -0.00117149f, 0.08204560f, -0.06077250f, 0.05288394f, 
    -0.07151198f, -0.00891475f, -0.00884315f, 0.04858057f, 0.02100288f, 0.08109435f, -0.01154432f, 0.07999399f, 
    -0.07672505f, -0.01471456f, 0.00831169f, 0.02474047f, 0.05177731f, -0.08358520f, 0.05920757f, -0.01028099f, 
    -0.08473691f, 0.03009723f, -0.08177772f, 0.00155069f, -0.08741223f, -0.05884796f, -0.00018747f, 0.07563297f, 
    -0.00594503f, -0.01050455f, -0.06915347f, 0.02710704f, 0.00399401f, 0.05009681f, -0.09120812f, 0.02383175f, 
    -0.00459288f, -0.04307489f, 0.04200958f, 0.04963668f, -0.05356153f, 0.06114973f, 0.07089408f, -0.02467351f, 
    0.00813913f, 0.07260059f, -0.06589968f, 0.00781119f, 0.04991941f, -0.03479569f, -0.05311883f, -0.08377745f, 
    -0.05998309f, -0.08357728f, -0.03763554f, -0.03396264f, -0.09770594f, -0.03904201f, -0.06992765f, -0.09669016f, 
    -0.03967980f, -0.09428596f, 0.01192812f, -0.05647588f, -0.06514489f, -0.08290995f, -0.05363862f, 0.01873017f, 
    -0.06693450f, -0.01701329f, -0.02213960f, -0.00959371f, -0.16394427f, -0.02889175f, -0.01615365f, -0.01360264f, 
    -0.01960228f, 0.01372328f, 0.06046181f, 0.02786849f, -0.10251264f, 0.07775691f, -0.01581411f, -0.04928929f, 
    -0.00352474f, -0.00414577f, 0.01739941f, 0.07568026f, -0.02519093f, -0.07865380f, -0.11629228f, 0.02104406f, 
    -0.05278205f, 0.05201552f, -0.08758652f, -0.10748870f, 0.05363422f, -0.02276486f, -0.04345621f, 0.07484512f, 
    0.07361782f, -0.09734207f, -0.00529489f, 0.07325803f, 0.01861421f, -0.01547473f, -0.04612390f, -0.09491199f, 
    -0.05898997f, -0.01310343f, -0.04941715f, -0.08372710f, 0.03856797f, -0.10639554f, -0.01431626f, -0.02392221f, 
    -0.03335156f, -0.01961658f, 0.02465599f, 0.07462065f, 0.08868003f, 0.04476260f, -0.00892987f, -0.07954675f, 
    -0.05677833f, -0.06240120f, 0.00002740f, -0.02144267f, -0.09012347f, 0.05848657f, 0.06388474f, -0.09506640f, 
    0.00338740f, -0.14713015f, 0.00230677f, -0.00424512f, 0.07108095f, -0.02172418f, -0.03208922f, -0.03415178f, 
    -0.06209074f, -0.11969844f, 0.06081557f, 0.04129190f, -0.10656390f, 0.05412461f, -0.00701033f, 0.03745404f, 
    0.03123039f, -0.00473724f, 0.03921121f, -0.01058247f, -0.00868323f, -0.01922769f, 0.03546789f, -0.01251234f, 
    -0.00651992f, -0.12684952f, -0.04452293f, -0.10815445f, 0.04630721f, 0.03693131f, -0.01063146f, -0.06387537f, 
    0.01465527f, 0.01481256f, -0.15948780f, -0.03698845f, 0.03144986f, -0.05004462f, -0.06048364f, -0.11416169f, 
    -0.04352679f, -0.07617981f, -0.04796959f, 0.06791259f, -0.05042889f, 0.05711078f, -0.12027433f, -0.03097873f, 
    -0.07405854f, -0.03194183f, 0.00377108f, 0.04010235f, -0.03554400f, 0.01893713f, -0.00966939f, -0.08473136f, 
    0.05782146f, 0.02150115f, 0.12002251f, 0.04810414f, -0.06742678f, -0.02686465f, 0.01519150f, -0.12747484f, 
    0.05175381f, 0.02064238f, 0.07176646f, -0.08289840f, -0.08693916f, -0.08547181f, 0.00859522f, -0.02773524f, 
    0.04422963f, 0.07868601f, 0.01602520f, 0.00769372f, -0.00395991f, 0.08327489f, 0.01937789f, 0.07420956f, 
    0.03640338f, -0.02534806f, -0.05176443f, 0.06670251f, -0.07781145f, -0.08086240f, -0.00418032f, -0.03361883f, 
    -0.04516950f, -0.07751337f, 0.06206024f, -0.07903314f, -0.04493179f, -0.00943661f, 0.00595982f, -0.07099258f, 
    -0.04121851f, -0.08078470f, 0.06010313f, 0.00095837f, -0.05941703f, 0.02844611f, -0.04647083f, 0.03768352f, 
    0.00062003f, 0.08145652f, 0.06987871f, 0.06512099f, -0.06932152f, -0.01170075f, 0.06965855f, -0.07004053f, 
    -0.07961424f, -0.00089924f, 0.06855143f, 0.08073980f, 0.04772668f, 0.08059022f, 0.05490685f, 0.02092857f, 
    -0.06903707f, -0.02185371f, -0.08871162f, -0.06205966f, 0.00994317f, -0.04551971f, -0.06901359f, 0.03477575f, 
    0.00076216f, -0.07125910f, 0.04701851f, 0.02270501f, 0.00543210f, -0.03466428f, 0.00730318f, -0.03660017f, 
    0.00131076f, -0.04641445f, -0.00151398f, -0.06447206f, -0.04532282f, 0.05028833f, -0.08514003f, 0.00153670f, 
    0.00896524f, -0.06606158f, -0.03313267f, 0.07963635f, 0.07065537f, -0.05636884f, 0.05676560f, -0.04786914f, 
    -0.06095076f, 0.06732751f, -0.05787773f, -0.08589864f, -0.05701635f, -0.00527821f, -0.00439611f, -0.06106017f, 
    -0.04729411f, -0.01222182f, -0.03372076f, 0.00290905f, 0.05280006f, 0.06153601f, -0.03141388f, -0.06440374f, 
    0.02016235f, 0.02596051f, 0.05282120f, 0.00070775f, -0.04784268f, -0.06364521f, -0.00010919f, -0.08537686f, 
    0.07632693f, 0.04826741f, -0.02965950f, -0.03693892f, 0.03008877f, -0.05338864f, 0.07005522f, -0.01550692f, 
    -0.07221319f, 0.00720742f, -0.08159491f, 0.05376604f, -0.06429784f, 0.07345589f, -0.08199713f, -0.04380462f, 
    -0.09025395f, 0.11972452f, -0.23274684f, -0.07817996f, -0.36778536f, -0.25769237f, 0.20832215f, -0.11152434f, 
    0.30653363f, 0.02136606f, 0.32210559f, 0.17617436f, -0.00097546f, 0.21443518f, -0.13748558f, -0.06861171f, 
    0.02335515f, 0.24709781f, 0.00703980f, 0.04302211f, -0.03182391f, 0.43229881f, 0.04204451f, 0.08432493f, 
    -0.15836915f, -0.06954908f, -0.21357699f, -0.06105559f, -0.39808619f, -0.03953424f, -0.08135276f, 0.25211731f, 
    -0.03050661f, -0.01503780f, 0.07049170f, -0.08754344f, 0.22537684f, -0.36296678f, 0.02300884f, 0.03277943f, 
    -0.09088938f, 0.02476422f, 0.07805061f, 0.07495182f, -0.09408234f, 0.09857221f, 0.05668812f, -0.23728554f, 
    -0.15374181f, -0.13725692f, 0.03720077f, 0.31645003f, 0.00895102f, 0.01315967f, 0.05685901f, 0.02569971f, 
    -0.07111215f, 0.04662658f, 0.45169297f, -0.04642088f, 0.21183550f, 0.14961320f, 0.20620562f, 0.33830148f, 
    -0.03076982f, 0.03674312f, 0.06261802f, 0.29624572f, -0.06966411f, -0.02432893f, -0.02291641f, -0.23223059f, 
    0.07034873f, -0.00071181f, 0.45841751f, 0.07293683f, -0.06146660f, 0.11475085f, 0.15725452f, 0.07154728f, 
    0.06731283f, -0.28665343f, 0.15669675f, -0.02844311f, -0.18143757f, -0.00167567f, 0.11990110f, 0.13805287f, 
    0.12765293f, -0.23519091f, 0.16975306f, -0.16880390f, -0.00058521f, 0.23642972f, 0.04287321f, -0.00467087f, 
    0.16053355f, 0.12947758f, 0.00980517f, 0.16326569f, 0.20561039f, 0.32290277f, 0.07269539f, -0.03219819f, 
    -0.07263632f, 0.09629516f, 0.19216752f, 0.02300056f, -0.09269943f, -0.02501171f, -0.02740383f, -0.04758424f, 
    -0.02715095f, -0.23945779f, 0.06854901f, 0.53831565f, -0.07386469f, 0.26796353f, 0.17381649f, 0.08704358f, 
    0.00819674f, -0.19129100f, 0.20597494f, 0.00541810f, 0.09047617f, 0.20128044f, -0.05129937f, -0.13949430f, 
    0.05561141f, 0.04291530f, 0.10838414f, 0.05693034f, -0.03587997f, -0.05939473f, 0.03971297f, 0.12499470f, 
    0.00110725f, 0.07105836f, -0.07840981f, -0.06361111f, -0.08253289f, 0.00728254f, 0.00108124f, -0.01179621f, 
    -0.09523106f, -0.15407756f, 0.03509242f, -0.06812379f, 0.06708391f, -0.03892897f, -0.02464122f, 0.06166462f, 
    -0.00036873f, -0.04456250f, 0.09219182f, -0.04268402f, -0.00074891f, -0.12302434f, 0.03465100f, 0.03738835f, 
    -0.11151695f, -0.10839965f, -0.05292153f, -0.09148214f, 0.01803053f, -0.05011818f, 0.06353282f, -0.01454250f, 
    -0.17024675f, -0.00880462f, -0.07863452f, -0.06177180f, 0.05125646f, -0.04142915f, -0.06060089f, 0.03602890f, 
    0.03867484f, -0.06549946f, 0.01420047f, -0.00399055f, -0.00781363f, 0.00932236f, -0.07439741f, -0.06343301f, 
    -0.00293686f, 0.01056376f, -0.11673541f, -0.07959767f, -0.06723052f, 0.01918703f, 0.02350288f, 0.04299685f, 
    0.00635190f, -0.02102438f, -0.00584829f, -0.03628388f, -0.10450859f, 0.00370317f, -0.07646835f, -0.07057580f, 
    -0.08190367f, -0.02482202f, -0.06988277f, -0.00830922f, 0.07675541f, -0.00058962f, 0.06123489f, 0.00176032f, 
    -0.12433043f, 0.03201066f, -0.10346336f, -0.01046019f, -0.10587527f, 0.03403066f, -0.15507546f, -0.06489798f, 
    -0.04403947f, -0.04522194f, -0.05585170f, -0.00217448f, -0.07448068f, 0.05793943f, 0.01121698f, -0.08499325f, 
    -0.11219093f, 0.03793181f, 0.01382703f, -0.05568815f, -0.13790338f, -0.03631280f, -0.01840562f, -0.09048492f, 
    0.06701089f, -0.06542133f, 0.03826894f, -0.07229409f, -0.00496430f, -0.04182101f, 0.05740604f, 0.07034365f, 
    -0.09149709f, -0.03308651f, -0.06080312f, -0.07469594f, -0.00276981f, -0.04778238f, -0.07903220f, -0.02064514f, 
    -0.05679007f, -0.00107444f, -0.12056661f, -0.05360376f, -0.06797531f, -0.08584607f, -0.06140881f, 0.00508309f, 
    0.03910699f, 0.08105003f, -0.08762700f, -0.01849875f, -0.09211119f, -0.04805953f, -0.11298905f, 0.05396232f, 
    0.12504837f, 0.05601806f, 0.00969966f, -0.05852984f, -0.08399668f, -0.04846032f, -0.07766390f, 0.03741217f, 
    -0.06055294f, 0.03141931f, -0.03074200f, -0.03742828f, 0.06412090f, 0.03910009f, -0.04540671f, -0.07467495f, 
    -0.03617384f, -0.03172933f, 0.04374991f, -0.01786712f, -0.00082486f, 0.03999657f, -0.02552346f, -0.07032024f, 
    -0.04788758f, -0.06298528f, -0.07596453f, -0.13298717f, -0.02215717f, -0.19031733f, -0.02732123f, -0.09979948f, 
    -0.00779207f, 0.07366095f, 0.08332406f, 0.03909549f, -0.07164233f, -0.10476641f, 0.02326962f, -0.03184073f, 
    0.05614015f, -0.13523765f, 0.04599828f, -0.11053013f, -0.02022925f, -0.06055522f, 0.08426046f, -0.02253297f, 
    -0.01239721f, -0.11134472f, -0.01140234f, -0.04878668f, -0.10187113f, 0.07269963f, -0.02257969f, 0.03239159f, 
    -0.05408664f, 0.03952642f, 0.06740912f, -0.12610205f, -0.01742848f, -0.00932418f, -0.03627055f, -0.07358776f, 
    -0.06773180f, -0.01590210f, -0.09631039f, -0.12524030f, -0.02932621f, -0.00440835f, -0.07721620f, -0.02284051f, 
    -0.10782030f, -0.09899154f, -0.02528926f, -0.05755033f, -0.00969763f, -0.06448108f, 0.06271265f, -0.08996567f, 
    -0.03485831f, -0.03935358f, 0.01139996f, -0.06607940f, -0.12737641f, 0.08336116f, -0.03168307f, -0.09446267f, 
    0.06924070f, -0.00821641f, -0.02767723f, -0.01787060f, -0.01485699f, -0.11289883f, -0.03715823f, -0.08416156f, 
    0.01440866f, -0.04519738f, -0.01967529f, -0.05320141f, 0.08778840f, -0.00606218f, 0.02804209f, -0.06187145f, 
    -0.05313633f, -0.00139771f, 0.04486135f, 0.00921241f, -0.08096584f, 0.02182989f, -0.06311451f, -0.00477091f, 
    -0.01981881f, 0.00586558f, -0.14009482f, 0.01503883f, -0.02207500f, 0.01938015f, 0.02550839f, -0.07311128f, 
    0.08012931f, 0.10104045f, -0.32028010f, -0.29673174f, -0.00189586f, 0.18198074f, -0.18834849f, 0.40045655f, 
    -0.10269058f, 0.05369877f, -0.48471990f, 0.13951117f, 0.14007753f, -0.00104789f, 0.16922100f, 0.09223563f, 
    -0.06145528f, 0.18211743f, -0.06906465f, -0.02902562f, 0.21318901f, 0.06399882f, 0.07470007f, -0.03219606f, 
    -0.08066535f, -0.02470564f, -0.23137920f, -0.07638519f, 0.18113902f, 0.17297515f, -0.03843013f, -0.00602459f, 
    0.18981859f, 0.06403385f, -0.16740900f, -0.21438815f, -0.21395943f, 0.14001448f, -0.00001185f, 0.15653506f, 
    -0.02334021f, 0.00235472f, 0.08701377f, 0.07476180f, 0.23305574f, 0.10762969f, -0.01349886f, -0.19519068f, 
    0.42368490f, -0.03006953f, -0.15685274f, -0.15266779f, -0.34367231f, 0.44705227f, -0.32507989f, -0.03257606f, 
    0.29819617f, -0.00402426f, -0.21566975f, 0.18521579f, 0.01689084f, -0.11901587f, 0.24840087f, -0.34691161f, 
    0.11493615f, -0.09198794f, 0.00421781f, -0.12882155f, 0.23485887f, -0.03496662f, -0.08684261f, 0.17296869f, 
    0.22766823f, 0.12391684f, -0.20904191f, 0.14186430f, -0.24975805f, 0.17261072f, -0.14120871f, 0.12323990f, 
    0.01484217f, 0.07590666f, 0.18686350f, -0.01684708f, 0.60871828f, 0.16431212f, -0.01878637f, 0.23223877f, 
    0.19721444f, -0.13768034f, 0.03802629f, 0.11045339f, 0.01272479f, -0.72521615f, -0.04698414f, -0.32241389f, 
    -0.06026351f, -0.09648020f, -0.24756840f, -0.48340407f, -0.16796249f, -0.13406840f, 0.09716325f, 0.02621777f, 
    0.08033125f, -0.28651160f, 0.14613736f, 0.04826980f, -0.41855660f, 0.06936224f, -0.09133230f, 0.03549918f, 
    -0.17314604f, 0.04259421f, 0.10241660f, -0.04776378f, -0.35376030f, 0.26466557f, -0.16208369f, 0.06563167f, 
    -0.11230803f, 0.20135465f, 0.02608683f, 0.14274746f, 0.15154770f, 0.06998586f, 0.05582369f, 0.17918250f, 
    0.16031022f, -0.05807529f, 0.15850294f, -0.13193308f, -0.48021165f, -0.06917279f, -0.22622810f, -0.20676316f, 
    0.32945290f, -0.05119530f, 0.12890780f, 0.03743057f, -0.17062391f, 0.01301528f, -0.27765316f, -0.15381993f, 
    0.02285593f, -0.06291576f, -0.07609487f, 0.18249810f, -0.08989260f, 0.07097675f, -0.13960548f, 0.22901884f, 
    -0.07095816f, 0.01185431f, 0.17826900f, -0.11247053f, -0.23914520f, -0.16567363f, 0.06359052f, 0.16968274f, 
    0.08518060f, -0.12078944f, 0.19530191f, -0.26369148f, 0.37146866f, -0.46847522f, 0.03973801f, 0.03346413f, 
    -0.05078752f, -0.04897369f, -0.06332652f, -0.01995292f, -0.32054779f, -0.00105161f, -0.04063651f, 0.31033432f, 
    0.27577475f, -0.30129111f, 0.01363014f, 0.56991082f, -0.32724726f, -0.17017440f, 0.11605871f, 0.06735902f, 
    -0.41499275f, -0.01369807f, 0.28675741f, -0.17399932f, -0.16067645f, 0.29809302f, -0.50824922f, 0.33817226f, 
    0.09923847f, -0.05903932f, -0.04102894f, -0.04598079f, 0.00397763f, 0.05061299f, -0.06280205f, 0.07390685f, 
    -0.11088465f, -0.08334729f, 0.52620399f, -0.25581250f, 0.12178778f, 0.17597310f, 0.07672121f, 0.00965112f, 
    0.25998175f, -0.08042218f, 0.08850547f, 0.20019573f, -0.25263098f, 0.08212493f, 0.18195787f, 0.07152350f, 
    -0.07958716f, 0.06029342f, 0.12904944f, -0.03598054f, 0.00309232f, 0.24578139f, 0.29499072f, 0.11297785f, 
    0.14346178f, -0.02189605f, 0.30654770f, 0.64213604f, 0.21783151f, 0.29980999f, -0.18521217f, 0.23100805f, 
    0.15513274f, 0.59305561f, -0.04240289f, 0.03207421f, 0.25620243f, -0.18869814f, -0.34336635f, -0.15957633f, 
    -0.06802294f, -0.23807278f, 0.02728526f, 0.24880874f, 0.26245895f, -0.04613469f, 0.45085907f, 0.21456331f, 
    0.15124501f, 0.00234931f, 0.07244550f, 0.08602209f, 0.01010600f, 0.05956983f, -0.03676446f, 0.02059994f, 
    -0.04934153f, -0.02570280f, 0.01005433f, -0.02212946f, 0.00580355f, -0.07436413f, -0.02105976f, 0.06595501f, 
    -0.02282492f, -0.01421043f, 0.08408908f, 0.04065457f, 0.04405278f, 0.00364151f, -0.07645921f, -0.05712418f, 
    0.06834780f, -0.07885203f, 0.02750008f, -0.02096888f, 0.01732143f, -0.03752462f, -0.01188742f, -0.09724081f, 
    -0.08769208f, -0.04957766f, 0.01786918f, 0.04591337f, -0.03658698f, -0.03002509f, -0.08167349f, 0.04195436f, 
    -0.07195187f, 0.03989650f, -0.02842036f, -0.03895362f, 0.02279318f, 0.00523766f, 0.01151863f, -0.02787180f, 
    -0.00630452f, 0.05668193f, 0.02270658f, -0.01502418f, -0.09356381f, -0.03862169f, 0.02929930f, -0.08457562f, 
    0.04610694f, -0.06069799f, -0.09337816f, -0.04896222f, 0.02608708f, -0.03632602f, 0.08465803f, 0.03581580f, 
    -0.05724312f, 0.00006614f, 0.06924596f, -0.00387404f, 0.07684790f, -0.02963238f, -0.03611221f, -0.09034707f, 
    0.05873687f, -0.07187757f, 0.04021573f, 0.02440700f, -0.08675508f, -0.08138672f, -0.00868009f, 0.06234806f, 
    -0.01937739f, 0.01695358f, 0.03752613f, 0.07070964f, -0.09156071f, -0.03908706f, -0.09073161f, -0.04361055f, 
    -0.06054426f, 0.02175705f, -0.06282995f, 0.04260436f, 0.07471278f, 0.03975358f, 0.04421694f, 0.01488572f, 
    -0.08792684f, 0.03793176f, -0.07953049f, -0.03791688f, -0.02785798f, 0.07729332f, -0.02344670f, -0.07622147f, 
    -0.01834832f, 0.02753882f, 0.02194153f, -0.04717183f, 0.00419137f, 0.06721016f, 0.02688715f, -0.05030660f, 
    -0.02085647f, 0.02581466f, -0.05556161f, -0.08338390f, 0.01387812f, -0.03167729f, -0.04296216f, 0.04093491f, 
    -0.03991301f, -0.06947900f, 0.03074292f, -0.02330117f, 0.02826959f, -0.08479685f, 0.00628899f, -0.04473739f, 
    0.04900223f, -0.02309323f, 0.01960912f, -0.09898435f, 0.04424649f, 0.05254540f, 0.06008596f, -0.05544139f, 
    0.09080949f, -0.01515681f, -0.10886671f, 0.10191879f, -0.26115388f, -0.05843899f, -0.04046876f, -0.07080106f, 
    0.36050019f, -0.04214209f, 0.43514210f, -0.05032165f, -0.24904324f, -0.01431080f, -0.06457353f, -0.11236393f, 
    0.18048424f, 0.04351159f, -0.03408019f, 0.08081371f, -0.09707367f, -0.31559804f, -0.13824540f, 0.09429423f, 
    0.10589141f, -0.02874122f, 0.09742563f, -0.13474266f, -0.11569012f, -0.03254257f, -0.02518484f, 0.12637810f, 
    -0.07542229f, -0.08832603f, 0.29679772f, 0.07810380f, 0.30729628f, -0.22459279f, 0.03584158f, -0.23543361f, 
    0.06623094f, -0.01992017f, -0.05831912f, -0.04689527f, -0.28456509f, -0.09525274f, 0.01544625f, 0.24765690f, 
    0.07768634f, -0.25440353f, 0.25202516f, 0.40614256f, 0.01656327f, -0.22715493f, -0.04418849f, 0.02737836f, 
    -0.17059286f, -0.09249593f, 0.39556167f, -0.13979432f, 0.05852940f, 0.47679770f, -0.64166886f, 0.54544896f, 
    -0.01558977f, 0.06019084f, 0.01667116f, -0.05661360f, -0.20205508f, -0.07880446f, -0.09307604f, 0.14229350f, 
    -0.14886534f, -0.13626719f, 0.25037929f, -0.03644198f, 0.02499010f, 0.33046710f, 0.00449943f, 0.18600586f, 
    0.03687925f, -0.15858935f, 0.08876019f, 0.21831405f, -0.52083701f, 0.09684350f, 0.14719923f, 0.03396021f, 
    -0.08140136f, 0.23106603f, 0.05652920f, -0.00589967f, -0.01908106f, 0.18566355f, 0.29175237f, 0.30405307f, 
    0.18769966f, -0.07389548f, 0.36525869f, 0.73431063f, 0.31029359f, 0.09213774f, -0.05002204f, 0.24917947f, 
    0.28996858f, 0.74421293f, -0.25616074f, 0.00912111f, 0.61748874f, -0.24331237f, -0.25427970f, -0.11930431f, 
    0.24448635f, -0.04049537f, 0.10323220f, 0.10926268f, 0.91396689f, -0.18912226f, 0.40767604f, 0.12577954f, 
    0.06612294f, -0.08810250f, 0.13532035f, 0.14467704f, 0.02287946f, -0.06591555f, -0.05657293f, 0.01669950f, 
    0.05541824f, 0.18675534f, 0.39689979f, 0.29516202f, 0.36121619f, -0.31956828f, 0.29636222f, -0.21690239f, 
    -0.10318987f, -0.00371272f, 0.75598067f, 0.02922841f, 0.03988328f, 0.09570571f, 0.23457676f, -0.07249858f, 
    0.09376147f, 0.14653647f, 0.08425181f, 0.33416390f, -0.02044501f, 0.08783098f, -0.19003896f, 0.08781306f, 
    -0.13047850f, -0.07810485f, 0.18173733f, 0.33597302f, 0.05263440f, 0.08981107f, 0.00590688f, 0.06507842f, 
    0.30986908f, 0.22833785f, 0.14753777f, 0.06261820f, 0.19894738f, -0.20847246f, -0.03730795f, 0.07616837f, 
    0.12068311f, -0.02873190f, 0.11348784f, -0.16577841f, 0.02495901f, 0.07718852f, 0.05468104f, 0.51541120f, 
    -0.19370824f, 0.11039779f, 0.12071414f, 0.23112573f, 0.15401204f, -0.43411282f, -0.16615883f, 0.27274606f, 
    -0.47902593f, 0.16861223f, 0.17912595f, -0.03632091f, 0.18857057f, -0.02865189f, 0.10238502f, 0.22001986f, 
    -0.15508391f, -0.03206375f, 0.02300601f, -0.18254034f, -0.53087008f, 0.00266390f, 0.24152556f, -0.20087256f, 
    0.00284133f, 0.02264966f, 0.24690311f, -0.10404202f, 0.33413351f, -0.14858277f, 0.00839283f, -0.05382894f, 
    0.08974285f, 0.06589320f, -0.24281496f, -0.14536935f, -0.23100398f, -0.24890642f, 0.11866191f, -0.01808523f, 
    -0.03254002f, 0.80413473f, 0.07666188f, -0.04970093f, 0.21638556f, 0.34660169f, -0.29189050f, 0.30887824f, 
    -0.10263855f, 0.59588951f, -0.11143178f, 0.35098618f, -0.05445820f, 0.38863528f, 0.02805490f, 0.22284949f, 
    -0.42105627f, 0.28268585f, 0.02225130f, 0.00308907f, -0.09632950f, 0.04757250f, -0.13735797f, 0.02017700f, 
    0.19247276f, 0.00791947f, 0.01955984f, 0.41727829f, 0.79718858f, -0.26407769f, 0.10182288f, -0.03403519f, 
    0.11070371f, -0.17590545f, -0.01163441f, -0.39813426f, -0.04341076f, 0.07734943f, 0.01953082f, -0.16645065f, 
    -0.05382849f, -0.03317456f, -0.06191393f, 0.04872630f, -0.02119214f, 0.04571036f, 0.00443150f, 0.10680737f, 
    -0.10449263f, 0.05207563f, -0.04828027f, -0.11389174f, 0.06954809f, -0.03866690f, 0.01951438f, -0.02509387f, 
    0.05065550f, -0.08730517f, 0.02723058f, 0.00862267f, 0.06908130f, -0.09880027f, 0.08004313f, -0.03678090f, 
    0.00892747f, 0.05747556f, -0.09442984f, -0.06826311f, -0.00825543f, 0.03296102f, -0.05471544f, -0.05415323f, 
    -0.02955965f, -0.10160116f, 0.02727886f, -0.07878217f, -0.06957014f, -0.00204749f, 0.02892699f, 0.01538536f, 
    -0.03923582f, -0.08719834f, -0.06566190f, -0.02717102f, -0.07370830f, -0.09355842f, 0.05403799f, 0.03433855f, 
    -0.02354747f, -0.07291059f, 0.05831401f, -0.03312685f, 0.04442228f, 0.06834366f, 0.05103481f, -0.06758382f, 
    0.05289822f, 0.02152147f, 0.01548011f, -0.04491713f, 0.05617458f, -0.00489606f, 0.04908797f, -0.02678451f, 
    -0.06920498f, -0.09436737f, -0.00973598f, 0.04534338f, -0.06899999f, -0.08835770f, 0.02152809f, -0.08891165f, 
    0.02985052f, 0.03792443f, -0.09333319f, -0.03895103f, 0.02786729f, -0.01175676f, 0.01080119f, 0.02755401f, 
    -0.00141062f, 0.00963561f, -0.01701460f, -0.03057753f, -0.07902164f, -0.07450285f, 0.01629165f, 0.03554086f, 
    -0.11464984f, 0.06609141f, -0.01250045f, 0.00218476f, 0.00477183f, 0.02532515f, -0.08679564f, -0.01537442f, 
    -0.03963434f, 0.02989308f, -0.09339224f, -0.10689018f, -0.03986323f, -0.12064834f, -0.03817641f, 0.00117406f, 
    -0.09903737f, -0.08052935f, -0.11076993f, -0.08466820f, 0.00182737f, 0.02380847f, -0.09048337f, -0.05069435f, 
    0.03312535f, -0.05509588f, 0.06300937f, -0.01495924f, -0.06412001f, 0.00802324f, -0.03438025f, 0.07174718f, 
    0.04539777f, 0.01241457f, -0.00132686f, 0.00445815f, -0.02652958f, 0.04421848f, -0.07625271f, -0.04734701f, 
    0.17106053f, 0.06834561f, -0.05882883f, 0.11616803f, 0.09274507f, -0.13389951f, -0.37887734f, -0.41044056f, 
    0.20985009f, 0.01130789f, -0.07452586f, 0.15389530f, 0.10486431f, -0.08296926f, 0.19269280f, 0.11054415f, 
    -0.10243812f, -0.18146208f, -0.05362397f, 0.11520240f, -0.41213688f, -0.02894679f, 0.05169430f, -0.00263573f, 
    -0.01963863f, -0.05220045f, -0.06053513f, 0.28450012f, -0.04961768f, 0.12104239f, 0.03461883f, 0.14379163f, 
    0.09700499f, -0.21399893f, 0.01878741f, 0.02209894f, 0.04823019f, -0.15534732f, 0.07712911f, -0.28485942f, 
    -0.08490235f, -0.03944181f, -0.03832352f, 0.13328773f, 0.33338973f, 0.15322421f, 0.01651323f, -0.07765377f, 
    0.05683794f, -0.04224853f, -0.15744454f, -0.02484509f, 0.00993592f, 0.01490854f, 0.20148656f, -0.03185932f, 
    0.23357572f, -0.20478889f, -0.27395308f, 0.10405172f, -0.17007203f, -0.02059386f, 0.17617607f, -0.00662911f, 
    0.10950086f, -0.01699626f, 0.05744063f, 0.07536201f, -0.30557862f, 0.04557789f, 0.16797510f, 0.08933602f, 
    0.04836138f, -0.03177387f, 0.00839127f, -0.13789590f, -0.20092085f, -0.15164748f, 0.12168464f, 0.04146823f, 
    -0.04994448f, 0.15567335f, -0.27577946f, 0.00651541f, 0.02932707f, 0.03212190f, -0.17229143f, 0.14818899f, 
    0.01731297f, -0.17491935f, 0.11680500f, -0.06272928f, -0.19408277f, 0.00930757f, -0.10817563f, 0.22232006f, 
    -0.22008660f, 0.02460456f, 0.16520624f, -0.30478129f, -0.44528419f, 0.12981285f, -0.00784805f, -0.06410391f, 
    -0.05328670f, -0.00207993f, -0.03934102f, -0.04384993f, 0.17566642f, -0.02046443f, 0.05444429f, -0.05726545f, 
    -0.01100121f, -0.05258882f, 0.05415149f, 0.06898267f, -0.13307030f, 0.07682896f, -0.06228968f, 0.07585293f, 
    -0.11098288f, 0.11406773f, -0.21806651f, 0.12168249f, 0.27697852f, -0.20938917f, 0.07834527f, -0.03503754f, 
    -0.00951060f, 0.23075256f, 0.02977955f, 0.21720706f, -0.01043860f, -0.35925835f, 0.84360343f, 0.25112987f, 
    0.07770650f, -0.03798871f, 0.32549357f, 0.14156958f, 0.19767104f, 0.30935401f, 0.16680819f, 0.00795965f, 
    0.02400779f, 0.42530769f, 0.02005186f, -0.10015702f, 0.17582038f, 0.30099660f, 0.09066592f, 0.26676786f, 
    -0.15597680f, -0.01936539f, 0.11841206f, -0.03037015f, 0.07439788f, -0.02812307f, -0.02954265f, -0.10717283f, 
    -0.17038527f, 0.08311210f, 0.16811644f, 0.23949902f, -0.23933542f, 0.18876380f, -0.06637002f, 0.03433342f, 
    0.16855803f, -0.03262401f, 0.06992988f, -0.04321055f, 0.02011354f, 0.03959270f, -0.00660279f, -0.15652831f, 
    -0.02398981f, 0.16919212f, 0.13382131f, -0.27789336f, 0.14070672f, -0.03764414f, -0.08329721f, -0.05005127f, 
    -0.04430385f, -0.00653227f, 0.31179699f, 0.15778004f, 0.33157390f, 0.02133850f, 0.26244599f, 0.19820134f, 
    -0.17785957f, 0.05850687f, 0.02579899f, 0.07264889f, -0.10677361f, 0.01133691f, 0.09431764f, -0.47544128f, 
    0.04074350f, 0.12878917f, 0.00271288f, 0.20074058f, 0.36135659f, 0.00818206f, -0.08942779f, -0.09179676f, 
    -0.34420794f, 0.03084764f, 0.00973802f, -0.08376390f, -0.37605023f, -0.10469924f, 0.09968244f, -0.19449969f, 
    0.12103693f, 0.33759144f, -0.11005128f, -0.05064157f, -0.01342553f, 0.05201528f, -0.04797430f, -0.07821935f, 
    0.14470619f, 0.12246200f, -0.37020701f, 0.07457328f, 0.01161967f, 0.14136004f, 0.17637275f, 0.15106066f, 
    -0.15212761f, 0.23709980f, 0.03870736f, 0.00344374f, -0.68934822f, 0.07102332f, -0.06614004f, 0.04363335f, 
    -0.16162467f, -0.06040519f, -0.11121150f, 0.16451260f, 0.45483750f, 0.00440823f, -0.15781502f, -0.00276339f, 
    -0.06601077f, -0.32040846f, 0.07505830f, -0.39792791f, -0.01764893f, 0.14520095f, 0.03848152f, -0.21919563f, 
    0.08198613f, 0.22034620f, 0.11312687f, 0.23275316f, 0.23580942f, 0.07429443f, 0.16179152f, 0.33710653f, 
    -0.49861962f, 0.06711953f, -0.25507781f, 0.04330483f, -0.08726226f, -0.12446466f, 0.38044602f, 0.11476497f, 
    0.35636121f, 0.04842028f, -0.04251162f, 0.02436287f, 0.23591357f, 0.08120106f, 0.00342958f, 0.21077341f, 
    -0.18694735f, -0.06058032f, 0.43316311f, 0.25111106f, 0.49355102f, -0.01822875f, -0.00598159f, -0.07518718f, 
    -0.36615378f, 0.21716571f, -0.10568124f, -0.07364569f, -0.08270157f, -0.15058766f, -0.08359102f, 0.29005522f, 
    -0.02819822f, 0.05466143f, -0.08934677f, 0.02469756f, 0.14695591f, 0.18216567f, -0.04164092f, -0.16978341f, 
    -0.25085881f, 0.17779024f, 0.06057199f, -0.22857293f, 0.03642473f, -0.00377333f, 0.02457536f, 0.21295184f, 
    -0.23959294f, 0.14746743f, -0.05505027f, 0.22712506f, 0.36534619f, -0.01454967f, 0.26021427f, -0.26310673f, 
    0.04946608f, -0.06001132f, 0.04546584f, -0.03018282f, 0.05611664f, 0.04920128f, 0.08172849f, -0.05952927f, 
    0.20802236f, 0.10388904f, 0.00187119f, 0.07816758f, 0.07079592f, 0.27704909f, -0.15825947f, 0.02385106f, 
    0.14884579f, 0.12426689f, 0.26593602f, 0.17801537f, 0.09584459f, -0.09525762f, 0.00995285f, 0.15928841f, 
    -0.00258248f, -0.19692369f, 0.03964372f, 0.21435720f, 0.34848028f, -0.12729463f, -0.01348184f, -0.25128353f, 
    -0.06471054f, -0.26247516f, -0.25489050f, -0.10560401f, 0.10233055f, 0.17089269f, -0.17877902f, -0.08724134f, 
    0.07708652f, -0.17418988f, 0.32616070f, 0.05841839f, -0.52037764f, 0.18696190f, -0.28362724f, 0.13615865f, 
    0.12644942f, 0.06416214f, -0.08493684f, 0.03986509f, -0.54541266f, 0.03915105f, -0.20495808f, 0.04290172f, 
    -0.13941924f, -0.44249219f, 0.25999635f, -0.08519313f, 0.02227664f, 0.15567783f, 0.09641267f, -0.17323393f, 
    0.53474969f, -0.04847917f, 0.21175966f, 0.51666027f, 0.55675733f, 0.12946658f, 0.05626095f, 0.24394065f, 
    -0.31281266f, 0.00654462f, 0.08984072f, 0.03559753f, -0.07399624f, 0.20771858f, 0.18394983f, 0.05580578f, 
    0.09918403f, 0.19951335f, -0.06238292f, -0.00341865f, -0.16466761f, 0.18189482f, 0.09832118f, 0.02967708f, 
    0.04735150f, 0.08568022f, 0.23288679f, 0.18150939f, 0.42694667f, 0.09130052f, 0.09586945f, -0.14545003f, 
    -0.09200314f, -0.11961613f, 0.13874727f, 0.09776155f, -0.05600314f, 0.22241881f, -0.00680582f, -0.19565485f, 
    0.00264297f, -0.04599379f, 0.06120934f, 0.25545931f, 0.40690666f, 0.08375172f, -0.07993544f, 0.59028947f, 
    0.25754189f, 0.15882097f, 0.08211465f, -0.01545032f, 0.06288441f, 0.04827862f, 0.19553167f, -0.02133686f, 
    0.12612212f, -0.06363332f, 0.03327784f, 0.13620153f, 0.07397752f, -0.11610692f, 0.29921371f, 0.16970043f, 
    -0.01567359f, 0.21023650f, 0.01538357f, 0.18102576f, 0.20649205f, 0.09521580f, 0.13810311f, 0.26436859f, 
    -0.03237457f, 0.11523174f, -0.07465468f, 0.10254509f, -0.05757765f, -0.13963060f, 0.10256183f, 0.16785122f, 
    0.04171806f, 0.39114895f, -0.06047566f, 0.04341020f, -0.23731227f, 0.10256791f, -0.04323404f, -0.11808519f, 
    -0.17567973f, 0.42721188f, -0.10607754f, 0.01977870f, 0.18397366f, -0.13688397f, 0.12686859f, 0.34629858f, 
    -0.08025336f, 0.22546281f, 0.63704908f, 0.15337986f, -0.15351301f, 0.13975163f, -0.11721348f, 0.18356757f, 
    0.08386280f, -0.00604283f, -0.16635418f, 0.04447204f, 0.24582732f, -0.10745483f, 0.14653552f, 0.05633592f, 
    0.20081733f, 0.17271401f, -0.08404145f, -0.22861938f, 0.38953099f, -0.24711373f, 0.25757483f, -0.03090862f, 
    -0.17615578f, -0.08592548f, -0.18423663f, 0.03817739f, 0.10015009f, -0.08780243f, -0.02357690f, 0.16301230f, 
    -0.18254471f, -0.15283424f, -0.50137329f, -0.12742124f, -0.35734949f, 0.08596452f, 0.27133828f, 0.32577649f, 
    0.14248344f, 0.08130703f, -0.32659185f, 0.06110008f, 0.06508204f, 0.28000233f, 0.02719427f, -0.03394402f, 
    0.01924405f, 0.17625217f, 0.04637318f, -0.08693344f, 0.30382702f, 0.24317884f, 0.19429754f, -0.09297352f, 
    0.18190177f, 0.08925045f, -0.18320963f, -0.13816036f, 0.15661502f, 0.00980600f, 0.06548363f, -0.04460866f, 
    -0.39078161f, -0.05983165f, 0.02878874f, 0.13889284f, -0.16750082f, -0.00615348f, 0.00347605f, -0.06594925f, 
    0.06048269f, 0.00372117f, 0.04040807f, 0.08564912f, 0.16051215f, 0.00970356f, 0.02980138f, -0.17313859f, 
    0.29719609f, 0.01916774f, 0.17230092f, 0.03440567f, -0.18340865f, 0.39907855f, -0.31462422f, 0.00951071f, 
    0.27156079f, -0.18822742f, 0.07900773f, -0.06591804f, 0.04982059f, -0.04232353f, -0.03456525f, 0.11489250f, 
    0.26155853f, 0.06374090f, 0.05480431f, 0.25453052f, 0.41105583f, -0.02384618f, -0.08840679f, 0.11163446f, 
    0.02114608f, -0.10982385f, -0.09881967f, 0.10180942f, -0.25462940f, 0.14142817f, -0.32444257f, 0.15083580f, 
    -0.20448893f, -0.14594720f, 0.19493663f, 0.24718270f, 0.06491838f, 0.25626916f, -0.00282198f, 0.09077392f, 
    -0.00421657f, -0.20663464f, -0.18412606f, 0.02962670f, -0.07867847f, -0.16924457f, 0.40154457f, -0.07594249f, 
    0.21585615f, -0.13550855f, 0.12942894f, 0.25471362f, -0.03942661f, -0.15875401f, 0.13941626f, 0.02404409f, 
    0.38727483f, 0.12716398f, 0.05354743f, 0.02050208f, 0.08526082f, -0.13266279f, 0.03488452f, 0.03786801f, 
    -0.03839375f, -0.00168286f, -0.02363325f, -0.17417312f, -0.05040237f, 0.32022339f, 0.04754672f, 0.08896445f, 
    0.02200816f, 0.02460278f, 0.10498808f, 0.36290324f, 0.09767757f, 0.01835801f, 0.03435307f, -0.01178373f, 
    -0.04033972f, -0.01978076f, -0.00107397f, 0.06634247f, -0.05028522f, 0.04883337f, 0.00386820f, 0.05981065f, 
    -0.00830098f, 0.08200328f, 0.03172303f, 0.02576845f, -0.10750099f, -0.07751807f, 0.00607156f, 0.03163628f, 
    0.07170137f, 0.06459094f, 0.00245221f, -0.04910301f, 0.02300952f, -0.04634623f, -0.10460792f, 0.03961113f, 
    0.02422164f, 0.08362591f, -0.09827643f, 0.02379883f, -0.06377541f, -0.05663491f, -0.02431956f, -0.06226934f, 
    0.00646697f, 0.05597745f, -0.01349123f, -0.01416012f, 0.05497639f, -0.06419907f, -0.04270958f, 0.03982104f, 
    -0.08127420f, -0.00645591f, -0.03168650f, 0.03894454f, -0.06111535f, -0.09621974f, -0.01419601f, -0.04848255f, 
    -0.02358616f, -0.01612773f, -0.04338314f, 0.04476447f, -0.08524189f, 0.01828011f, 0.01727357f, -0.08032390f, 
    -0.06322973f, 0.02096624f, -0.08622993f, -0.08644925f, 0.01793672f, 0.01335112f, -0.07963213f, -0.03530309f, 
    0.02612178f, 0.02988225f, -0.00393629f, -0.00139539f, -0.00832302f, 0.04615857f, -0.08143597f, -0.02025376f, 
    -0.04854614f, 0.03985443f, 0.01059596f, -0.07214779f, -0.01852119f, 0.00057594f, -0.10066531f, 0.04748663f, 
    0.00942033f, 0.03883136f, -0.04634693f, 0.01839482f, -0.01971949f, -0.07292836f, 0.03607135f, 0.02647672f, 
    -0.02042511f, -0.08068796f, 0.03205131f, 0.01175292f, -0.00041288f, 0.06049293f, 0.09912600f, -0.08892284f, 
    -0.05107597f, -0.05913266f, -0.04494428f, 0.05539887f, -0.04315481f, -0.08534527f, -0.00363034f, 0.00955242f, 
    -0.01866082f, -0.02363063f, -0.00988646f, 0.01946651f, 0.02058337f, -0.03505677f, 0.01715344f, -0.03854844f, 
    -0.04365488f, -0.06488315f, 0.05212772f, -0.10081323f, -0.08152005f, -0.00685944f, -0.06040163f, 0.01176714f, 
    -0.07327058f, -0.01079475f, 0.01373028f, -0.03466005f, 0.06284118f, 0.00133156f, -0.07409273f, -0.02866707f, 
    -0.04700853f, -0.01945433f, -0.00562633f, -0.01155673f, -0.03613235f, -0.02175621f, 0.03430788f, 0.00689947f, 
    0.01475515f, 0.01005773f, 0.00850020f, -0.08912467f, -0.08758601f, 0.00421589f, -0.03432736f, 0.04159145f, 
    0.04512311f, 0.07321445f, -0.06029866f, -0.07976478f, 0.00040747f, 0.03521235f, -0.10225081f, -0.03088094f, 
    -0.02401555f, -0.02351399f, 0.01124347f, -0.07125071f, -0.06565887f, -0.02202158f, -0.07480650f, -0.06464264f, 
    -0.01827066f, 0.00750698f, -0.04556144f, 0.07253663f, 0.03068875f, -0.05844598f, 0.07839614f, 0.06633195f, 
    -0.02298086f, 0.01758633f, 0.01116178f, 0.06911919f, -0.03493195f, -0.05563198f, 0.05507514f, 0.08015566f, 
    -0.00481475f, -0.09386114f, -0.08681887f, -0.06359007f, -0.00187919f, 0.01974609f, -0.02626489f, 0.02424006f, 
    0.01852860f, -0.03092144f, -0.07986166f, 0.02956071f, -0.05717377f, 0.02319694f, -0.08096024f, -0.06291832f, 
    0.02811585f, 0.01410352f, 0.00340909f, -0.04614934f, -0.04385557f, 0.01808279f, -0.04932308f, -0.02700005f, 
    -0.06548285f, 0.04369872f, 0.05350567f, -0.05836972f, 0.06356248f, 0.07180347f, 0.01160633f, -0.01757002f, 
    -0.03586197f, -0.09498912f, 0.01691450f, -0.02863503f, 0.01839996f, 0.04620695f, 0.00025878f, -0.07060318f, 
    -0.01663664f, -0.04130398f, -0.04680087f, -0.09759576f, -0.04056216f, 0.06536913f, 0.05266982f, -0.01281450f, 
    0.01409755f, -0.07543986f, -0.00364124f, -0.05305029f, -0.08280977f, -0.08056697f, -0.06732087f, 0.02958458f, 
    0.00811028f, 0.00926216f, -0.03360486f, 0.02241579f, 0.08076914f, 0.04630433f, -0.05516460f, 0.00622359f, 
    0.01582863f, 0.05664321f, -0.05284384f, -0.03939578f, 0.03987458f, -0.05769211f, 0.02083557f, -0.02192552f, 
    0.00214969f, 0.01488264f, 0.07177939f, 0.00270357f, 0.05498192f, 0.03086249f, 0.00473872f, -0.02313616f, 
    -0.16897213f, -0.08415587f, 0.10369598f, 0.23715268f, 0.08150548f, 0.03979378f, 0.44419208f, -0.22187972f, 
    0.61314595f, -0.03439203f, 0.24685310f, 0.10498502f, 0.03506023f, -0.26018307f, -0.11020449f, 0.15226750f, 
    -0.01879713f, -0.29246929f, -0.01747876f, 0.20473622f, 0.34973779f, -0.03054249f, -0.10518989f, -0.06395260f, 
    0.10687166f, 0.05244195f, 0.32678515f, 0.15773879f, 0.33036250f, -0.37609509f, -0.06599692f, 0.13449773f, 
    0.31064594f, 0.09009553f, -0.02628725f, -0.21708156f, -0.08522468f, -0.15617786f, -0.06161264f, 0.44471756f, 
    -0.40554276f, -0.03945842f, 0.12740546f, -0.05889030f, -0.03761659f, 0.00490809f, -0.08006162f, 0.24570183f, 
    -0.27838987f, 0.02237822f, -0.27863911f, -0.06830581f, -0.23256843f, -0.13257210f, 0.37909618f, 0.17965695f, 
    -0.72847062f, 0.35668814f, 0.04946385f, 0.14581798f, 0.13355917f, 0.46648318f, -0.50253534f, -0.17174999f, 
    0.25117663f, 0.06100948f, 0.06195675f, -0.49912959f, -0.16667186f, 0.01650936f, 0.24044541f, -0.04702304f, 
    -0.08136153f, -0.00836692f, -0.10016994f, -0.03202498f, 0.35517031f, 0.11002013f, -0.06438056f, -0.33022025f, 
    -0.00698012f, -0.01583119f, -0.08065230f, 0.31794414f, -0.43660885f, -0.20067522f, -0.14556886f, -0.23722470f, 
    -0.02315138f, -0.13859896f, 0.01367078f, 0.21035078f, 0.29151303f, 0.48399404f, -0.14947471f, 0.48538935f, 
    0.12869599f, -0.01904532f, -0.13641383f, -0.10601206f, 0.03894750f, -0.12885641f, -0.18209389f, -0.24587482f, 
    -0.06761211f, 0.16447884f, 0.40247872f, 0.08033932f, 0.29488978f, 0.18385185f, 0.00648929f, 0.27130732f, 
    0.22898081f, -0.28467941f, -0.24972503f, 0.05148954f, 0.51807916f, -0.47392410f, 0.06847065f, -0.19391064f, 
    0.41622174f, -0.34082204f, -0.10930021f, 0.14479060f, 0.28623554f, 0.34446001f, -0.13806544f, 0.11321104f, 
    -0.31175336f, 0.02355590f, 0.04122161f, 0.15882121f, -0.23624130f, -0.05915388f, -0.24283502f, -0.22150223f, 
    0.00501896f, -0.06656102f, -0.15617464f, -0.07361738f, -0.26537043f, 0.14678329f, -0.11281842f, 0.02188829f, 
    0.20401472f, -0.00670231f, 0.00822872f, -0.06551591f, 0.14209507f, 0.10566823f, 0.16575971f, 0.13163169f, 
    0.24052823f, 0.10438386f, 0.14568968f, -0.07616490f, 0.01850348f, -0.16140249f, -0.02347762f, 0.30931196f, 
    -0.16709882f, 0.11380646f, 0.27051026f, 0.01428672f, 0.23148769f, -0.17617759f, -0.05316919f, 0.17354569f, 
    0.03792104f, 0.03072193f, 0.02915625f, 0.00356483f, -0.28422859f, -0.00870072f, 0.05210287f, -0.39369527f, 
    -0.11919668f, -0.00463965f, 0.13419764f, 0.04960044f, 0.11403785f, -0.16462861f, 0.17973936f, 0.16202137f, 
    -0.02480561f, 0.07742557f, 0.15147148f, 0.08010095f, 0.25682700f, 0.03750684f, -0.39143825f, 0.24314028f, 
    0.16642964f, -0.00927809f, 0.01559365f, 0.23147531f, -0.03500232f, 0.06935431f, 0.09155089f, -0.00383293f, 
    -0.03864312f, -0.03163888f, 0.22090881f, 0.26183635f, 0.15258344f, 0.28798357f, -0.06569693f, -0.00730767f, 
    0.16179410f, -0.14163569f, 0.19654685f, 0.59556544f, -0.48868138f, -0.10697652f, 0.08588180f, -0.14573973f, 
    -0.13600008f, -0.59598082f, 0.08568493f, 0.34502804f, 0.01762946f, 0.45999041f, 0.27082172f, 0.11827985f, 
    0.24938895f, -0.06668802f, 0.08892696f, 0.04214562f, 0.49031150f, 0.01232515f, 0.03784710f, -0.21427037f, 
    0.08046560f, 0.06418899f, 0.15819959f, 0.07067960f, 0.35062996f, 0.03827871f, -0.03769726f, 0.10116202f, 
    0.26637965f, -0.18935439f, -0.02775953f, 0.05121980f, -0.03579146f, -0.04357344f, 0.16967310f, 0.16086064f, 
    0.25748718f, 0.03085660f, 0.00837619f, 0.06946742f, -0.31843272f, 0.37076059f, -0.10173804f, -0.14569287f, 
    0.27688888f, 0.16860275f, 0.05757114f, -0.08637422f, 0.02524509f, 0.41139463f, -0.19057597f, 0.48621282f, 
    -0.48993784f, -0.02190295f, 0.07621670f, -0.01658878f, 0.04033253f, -0.12477310f, 0.14422756f, 0.00570549f, 
    0.21463050f, -0.09173269f, 0.04904847f, -0.37428871f, 0.06640607f, -0.13557045f, 0.09885132f, -0.10537413f, 
    0.20863694f, 0.07935362f, 0.19222580f, -0.11165704f, 0.16874941f, 0.25002223f, -0.00404121f, -0.23031384f, 
    -0.08892369f, 0.08144054f, -0.12697499f, -0.26959613f, -0.21074083f, -0.18818042f, -0.05424333f, 0.04069933f, 
    0.08120573f, 0.11599455f, -0.08404480f, 0.00136392f, 0.14539951f, -0.01201905f, 0.03100261f, -0.52601886f, 
    -0.18265778f, 0.01393989f, 0.09118557f, -0.21125494f, -0.27127632f, 0.03922723f, -0.09736621f, -0.02149394f, 
    0.14249732f, 0.06069721f, -0.08216720f, -0.10701595f, -0.04250801f, -0.16926637f, -0.24509339f, -0.02760111f, 
    -0.07232924f, -0.07842501f, 0.06518782f, -0.20457581f, 0.02964656f, -0.01350879f, -0.11875257f, 0.10263452f, 
    0.14060405f, 0.10552570f, -0.19618368f, 0.12453599f, -0.20168006f, 0.04848999f, 0.05215361f, 0.17362529f, 
    0.08747696f, -0.04266646f, 0.06700633f, 0.06774382f, 0.18552451f, 0.01270822f, 0.14215890f, 0.13978964f, 
    -0.23341063f, 0.20178795f, -0.13293841f, 0.20719147f, 0.14660843f, -0.46586370f, 0.15517500f, -0.01844543f, 
    -0.05564643f, -0.34839782f, -0.02614831f, -0.09853709f, -0.13754649f, -0.36897266f, -0.13805005f, -0.10281205f, 
    0.26670963f, 0.02093625f, 0.06702586f, -0.03988208f, 0.17678811f, -0.05834183f, -0.14534830f, 0.01657952f, 
    0.15084302f, 0.06963641f, 0.02822001f, -0.34056076f, -0.54904139f, 0.16354758f, -0.19793539f, 0.10935158f, 
    -0.13276236f, -0.19878040f, 0.19608909f, -0.06479648f, -0.32734057f, -0.08732929f, 0.03026409f, -0.18884778f, 
    -0.04295697f, 0.23909751f, -0.13530321f, 0.04434365f, 0.03102154f, -0.09639574f, -0.06876701f, 0.01912886f, 
    -0.04861258f, 0.05447943f, 0.40682971f, -0.00172239f, 0.10655606f, -0.07555757f, 0.16971628f, -0.04292180f, 
    0.14780527f, -0.03714915f, -0.03831766f, 0.14351101f, -0.10519776f, -0.29914150f, 0.03990172f, 0.06823715f, 
    -0.00563475f, 0.03885309f, -0.21742280f, 0.03023964f, 0.00966416f, -0.01768935f, -0.00025724f, 0.03153583f, 
    0.25063238f, 0.19835439f, -0.06657278f, 0.36586392f, -0.06470772f, -0.08066718f, 0.08422229f, 0.06586103f, 
    0.22752774f, 0.05520962f, -0.13950127f, 0.02269079f, -0.13262129f, 0.03183310f, 0.08593685f, 0.12824076f, 
    0.27352431f, 0.12841144f, 0.18553631f, -0.03581763f, 0.12115244f, -0.07084712f, -0.28410906f, 0.16552994f, 
    -0.00075459f, -0.05074351f, 0.06017653f, 0.00391553f, 0.29592457f, -0.29586112f, -0.05606781f, 0.09170595f, 
    0.08647355f, -0.12677424f, 0.03203276f, 0.00352729f, 0.20334874f, -0.07074665f, 0.01825223f, 0.03538967f, 
    0.04437339f, -0.02705037f, 0.15810639f, 0.10050248f, 0.12047575f, 0.07699131f, -0.15951611f, -0.02608562f, 
    -0.07171278f, -0.14441262f, 0.30065924f, -0.09423168f, -0.14730777f, -0.28118920f, -0.07215490f, -0.02448920f, 
    -0.16845407f, 0.31870726f, 0.04856146f, 0.13027208f, -0.14621934f, -0.44875649f, -0.09331765f, -0.25053975f, 
    0.11879615f, 0.43616360f, -0.28189230f, 0.31565711f, 0.33806768f, 0.04418544f, 0.12198723f, 0.04272731f, 
    -0.23095500f, 0.02919958f, -0.05254539f, -0.04816327f, -0.24808668f, -0.00533318f, -0.04444162f, -0.17481613f, 
    0.12648690f, -0.09842265f, -0.13293554f, 0.10178863f, 0.00630008f, 0.04300747f, -0.22804312f, 0.10336229f, 
    0.11275763f, -0.26554853f, 0.13926834f, -0.19105840f, 0.07196273f, -0.00858238f, -0.02535113f, 0.03872152f, 
    0.01110752f, 0.06517776f, -0.08979036f, -0.07148055f, 0.02785299f, -0.02815551f, 0.04786360f, 0.07314809f, 
    -0.08950436f, 0.05202007f, -0.03551954f, -0.03305047f, -0.01303989f, 0.03097956f, -0.05248074f, 0.01084375f, 
    -0.09442329f, -0.01593219f, 0.05672333f, -0.00346866f, 0.04870398f, -0.03331406f, 0.01503253f, 0.05690008f, 
    -0.01544506f, -0.08209462f, -0.09465640f, 0.04057881f, -0.03153358f, -0.10136556f, -0.07867461f, -0.06686246f, 
    -0.07927217f, 0.05986888f, 0.01498441f, -0.01029608f, -0.01722870f, -0.06257094f, -0.05807857f, -0.06914630f, 
    -0.07003532f, 0.05345745f, -0.01464793f, 0.02911004f, -0.04341864f, -0.08875009f, -0.04840459f, 0.00073761f, 
    0.03564135f, -0.00386798f, -0.08737965f, -0.05190646f, 0.03609651f, -0.04840271f, 0.03754423f, -0.07165996f, 
    0.00351435f, 0.05797561f, 0.01785293f, 0.04281475f, -0.05950615f, 0.02847254f, -0.10697798f, 0.00504280f, 
    -0.06401116f, 0.01137238f, 0.02385875f, 0.00886122f, 0.05231217f, -0.04170661f, -0.02376575f, 0.05888352f, 
    -0.00583815f, -0.07414555f, -0.06492230f, -0.03740310f, -0.03624666f, 0.04381377f, -0.04567350f, -0.09224274f, 
    -0.03169650f, -0.00373612f, 0.02343906f, 0.03431823f, -0.01410445f, -0.08830705f, -0.03951418f, -0.10917868f, 
    0.02216129f, -0.04251451f, 0.01864071f, 0.03413433f, 0.00117736f, -0.03872235f, 0.02737113f, 0.01163894f, 
    -0.02185774f, -0.02663454f, -0.01320328f, -0.07801965f, 0.06814796f, 0.02933953f, 0.02283581f, -0.10203458f, 
    -0.02302204f, -0.07519954f, -0.06659569f, -0.08387089f, 0.06990963f, -0.04644806f, 0.03308788f, 0.05411492f, 
    -0.09589174f, 0.00586243f, 0.00739033f, -0.04085954f, -0.02584554f, -0.09961960f, 0.01456542f, -0.07889001f, 
    0.06247691f, 0.01660867f, -0.07147875f, -0.08007631f, -0.05921813f, 0.01999192f, -0.04664647f, -0.05260729f, 
    0.24808998f, -0.07591972f, 0.07790141f, 0.30486962f, 0.02212415f, -0.09362671f, 0.02717856f, -0.01302868f, 
    -0.03539908f, 0.05157667f, -0.20064692f, 0.08396914f, -0.11438817f, 0.29392409f, 0.09110910f, 0.12486468f, 
    -0.09515470f, 0.45999002f, 0.04565909f, 0.13556288f, -0.08063202f, 0.60216904f, 0.13369532f, 0.04429123f, 
    -0.13761322f, 0.06243507f, -0.09370882f, 0.15465677f, 0.06126860f, -0.28350279f, 0.00958224f, 0.16159733f, 
    -0.29654294f, -0.16067263f, 0.17882481f, -0.19779785f, 0.13983460f, -0.05558067f, -0.02676416f, -0.25386852f, 
    -0.05564835f, -0.05003899f, -0.00693189f, 0.19901690f, 0.18445566f, 0.05264011f, -0.03456701f, 0.56198734f, 
    0.42969969f, -0.05984524f, 0.10550059f, 0.19326399f, -0.24171060f, 0.00105577f, -0.06238806f, 0.03768579f, 
    0.15249623f, -0.07024281f, -0.01356222f, 0.10513119f, -0.00498834f, 0.08003372f, 0.39769155f, 0.08877675f, 
    0.08696418f, 0.07519556f, -0.09939178f, 0.40309867f, 0.27297658f, 0.01394597f, 0.16784127f, -0.03067377f, 
    -0.10201171f, 0.06769783f, -0.08158551f, -0.09949014f, -0.03123004f, -0.09134028f, 0.17589088f, -0.08687011f, 
    0.00201605f, 0.14189719f, 0.04486316f, -0.01561995f, -0.12885737f, 0.07779489f, -0.05487956f, 0.04673242f, 
    0.16059373f, -0.07733563f, 0.14888212f, -0.06413618f, 0.09780891f, 0.20048229f, -0.00343174f, 0.17840993f, 
    -0.08021364f, -0.12053833f, 0.37969083f, 0.06659420f, -0.11305501f, 0.37897581f, -0.02599818f, 0.03698887f, 
    -0.04729383f, -0.11489093f, 0.01732926f, -0.06405552f, -0.14760327f, -0.03395356f, -0.04816079f, 0.07050072f, 
    -0.02651770f, -0.12501715f, -0.18684308f, 0.16688928f, 0.16102879f, 0.08912797f, 0.38704854f, -0.04921932f, 
    -0.12592834f, -0.23536040f, -0.01923644f, 0.07008990f, 0.13391681f, -0.03792513f, -0.08397263f, -0.06282170f, 
    0.08403260f, 0.19278196f, 0.22442837f, 0.19039270f, 0.43245643f, 0.03073736f, 0.35200116f, -0.48694083f, 
    -0.10051941f, 0.02735308f, 0.21597677f, 0.05140447f, 0.01985283f, -0.08926672f, 0.18620339f, 0.01980663f, 
    0.21551120f, -0.06937738f, 0.06568354f, 0.10553002f, -0.00241310f, 0.30198145f, -0.13786305f, 0.02332719f, 
    -0.18369716f, -0.01285321f, 0.20293237f, 0.27970299f, 0.24240360f, 0.03268534f, 0.01393097f, 0.00843207f, 
    0.15154834f, 0.02614273f, -0.02619026f, -0.11071160f, 0.04716289f, -0.04059068f, -0.03070056f, -0.06507178f, 
    0.09024063f, 0.03518499f, -0.00692521f, 0.00088590f, 0.08405380f, 0.09884349f, -0.01088388f, 0.32522300f, 
    -0.49755141f, 0.12370689f, 0.08766937f, -0.11067885f, -0.11277843f, -0.33766660f, 0.24871784f, 0.12799834f, 
    -0.44238162f, 0.17544535f, -0.02226683f, 0.08086517f, 0.16722138f, -0.11018801f, 0.38500553f, -0.05959572f, 
    -0.06368062f, 0.01666143f, -0.00448498f, -0.13191575f, -0.15549074f, 0.12006680f, 0.17795151f, -0.10027545f, 
    0.10191374f, 0.17895655f, 0.20711115f, -0.12687571f, 0.11831576f, 0.02784146f, 0.03550581f, 0.08131959f, 
    0.17768387f, 0.18591194f, -0.00337138f, -0.04375825f, 0.08562116f, -0.12027391f, 0.04727500f, -0.00678020f, 
    -0.05402590f, 0.33267891f, 0.13703127f, -0.18732859f, 0.20787098f, 0.14562228f, -0.22087957f, 0.00417082f, 
    -0.29336876f, 0.08504173f, -0.05452634f, -0.00873037f, -0.14203106f, 0.46489882f, -0.14576915f, -0.02314050f, 
    -0.23518601f, -0.13382764f, 0.01857270f, 0.02890640f, -0.09911505f, 0.10035240f, 0.02354729f, 0.10442614f, 
    0.18545493f, -0.00064371f, 0.09159665f, 0.22238386f, -0.15942472f, -0.36035317f, -0.05281509f, 0.05142862f, 
    -0.01681803f, -0.10002959f, 0.08171710f, -0.28986770f, 0.10045166f, 0.10415164f, 0.06994287f, -0.04975047f, 
    0.04250012f, -0.08080879f, 0.03776732f, -0.05072658f, -0.02661794f, 0.02638330f, 0.02470491f, 0.02808451f, 
    -0.00836460f, 0.00022393f, 0.04844394f, -0.05869959f, -0.05676143f, 0.05075209f, 0.00323616f, -0.05405353f, 
    -0.08247045f, -0.09934497f, -0.07354112f, 0.01799146f, -0.07512855f, -0.11514868f, -0.06585784f, -0.07101045f, 
    -0.03892241f, -0.04459076f, -0.05955276f, 0.00056513f, -0.05468528f, 0.06786212f, -0.01083980f, -0.07820630f, 
    -0.09616574f, -0.03097755f, -0.11427458f, -0.04727809f, -0.09021698f, -0.00750990f, -0.03716821f, -0.05796717f, 
    -0.08380050f, -0.03487675f, -0.07241341f, -0.05069756f, -0.11581962f, 0.02389385f, -0.04505824f, -0.00482246f, 
    -0.04517184f, -0.07843786f, 0.02546447f, 0.07284955f, 0.02596288f, -0.06784696f, -0.01510387f, 0.00560187f, 
    0.03711842f, -0.00830438f, -0.02693236f, 0.03156586f, -0.03325276f, 0.04693852f, -0.07071985f, 0.07545861f, 
    -0.03288085f, -0.07648487f, -0.03890664f, -0.02331677f, 0.02758422f, 0.02959110f, -0.09200088f, -0.09504991f, 
    0.01609457f, 0.05480947f, 0.04360749f, 0.03381268f, 0.02749002f, 0.02877117f, -0.08344255f, 0.04193356f, 
    0.01644147f, -0.02901165f, -0.00162731f, -0.07398605f, 0.02654652f, 0.02383595f, 0.06154235f, 0.00677653f, 
    0.03057244f, -0.02354965f, 0.00627550f, -0.06180326f, -0.05799989f, -0.07019871f, -0.01251717f, 0.05588211f, 
    -0.06675011f, -0.05028478f, 0.06885909f, -0.07542396f, -0.00505755f, 0.06196500f, -0.11863705f, -0.07851110f, 
    -0.01479240f, 0.08658045f, -0.03551619f, 0.00285516f, -0.07374805f, 0.01396059f, -0.07295734f, -0.10817966f, 
    -0.07973489f, -0.04372542f, -0.06978113f, -0.01666965f, 0.01879125f, 0.01793003f, -0.05924674f, 0.01239366f, 
    -0.00513084f, -0.06744264f, -0.04371021f, -0.02471986f, -0.07895163f, -0.08881070f, -0.09975030f, -0.02898173f, 
    -0.00119442f, -0.10351057f, -0.06991620f, -0.05590364f, 0.01097674f, 0.05643928f, 0.00242880f, -0.02491111f, 
    -0.03909061f, -0.01732964f, -0.08358306f, -0.07246192f, -0.04192375f, -0.01001693f, -0.07474076f, -0.00261661f, 
    0.00547585f, 0.02287915f, -0.04883878f, -0.08601443f, -0.01219100f, -0.01039977f, -0.08961165f, -0.00094442f, 
    0.04216246f, 0.08674275f, -0.06729075f, -0.05237431f, -0.02573315f, 0.00131953f, 0.08271418f, -0.03231267f, 
    -0.00049523f, -0.08375971f, 0.01583392f, -0.08711101f, 0.03988479f, -0.03721230f, -0.00901714f, -0.00701674f, 
    -0.02066980f, -0.07965239f, -0.09240612f, 0.05198512f, -0.03425176f, -0.02495787f, -0.03367380f, -0.02475953f, 
    0.02648474f, 0.00286024f, -0.00995125f, 0.04991240f, -0.08842111f, -0.01903814f, -0.07268889f, -0.09468155f, 
    -0.00357725f, -0.04866402f, -0.01080476f, -0.01621493f, -0.11198871f, 0.02153675f, -0.07835665f, -0.03643027f, 
    0.04343115f, -0.01445900f, 0.00370435f, -0.02185227f, -0.04163999f, 0.05201491f, -0.03147412f, -0.00599804f, 
    0.01396571f, 0.03912570f, -0.07552654f, -0.02837980f, -0.02523442f, -0.06185243f, -0.06049402f, -0.10717841f, 
    -0.06794811f, -0.07815813f, -0.12223413f, 0.00508670f, 0.03329822f, -0.03255042f, 0.06622037f, -0.04374614f, 
    -0.10266460f, -0.07561537f, -0.11028122f, -0.06956663f, -0.08176456f, -0.09488325f, -0.07803895f, 0.06954923f, 
    -0.08682159f, -0.01572612f, 0.03375756f, 0.01259620f, -0.04367302f, 0.00037182f, 0.02609609f, -0.08578423f, 
    -0.10029102f, 0.05711520f, 0.03202394f, -0.02495039f, -0.00995166f, 0.02969368f, 0.05893735f, -0.00971292f, 
    -0.08463335f, 0.02568801f, -0.08244754f, -0.01734103f, -0.00550079f, 0.05513998f, 0.02707296f, -0.07304041f, 
    -0.04715688f, -0.05634331f, -0.03610267f, -0.06180315f, 0.00154796f, 0.03391787f, -0.02572860f, -0.01705572f, 
    -0.51532882f, 0.01467183f, -0.47822461f, -0.35706165f, -0.46119392f, -0.07779561f, 0.00605112f, -0.08821099f, 
    0.17795731f, 0.05958254f, -0.16021344f, 0.13237008f, -0.07291453f, 0.03081490f, 0.04047732f, -0.11197987f, 
    0.08554519f, 0.03580960f, 0.01570595f, 0.10503300f, 0.13836452f, -0.09734781f, 0.00066623f, 0.15568720f, 
    -0.05646254f, 0.05384910f, -0.32479379f, -0.25995734f, -0.37631115f, 0.03144043f, 0.00029190f, 0.11529247f, 
    0.00238797f, 0.09132084f, 0.05803058f, 0.15252417f, 0.25282231f, -0.20209566f, 0.06683081f, 0.22385776f, 
    0.13916989f, 0.05111310f, -0.00709911f, 0.01079469f, -0.24715452f, 0.04414467f, -0.01244781f, -0.20329161f, 
    0.42565843f, -0.10045978f, 0.07946674f, 0.18217875f, -0.13070136f, 0.19516996f, -0.27917320f, 0.03672047f, 
    -0.03538734f, 0.06129824f, 0.20687054f, 0.02884258f, 0.22354743f, -0.00573643f, -0.18255055f, -0.08486691f, 
    0.21821184f, -0.10224493f, 0.02364668f, -0.03794267f, 0.09075788f, 0.12810507f, -0.10488445f, 0.10842590f, 
    0.06976674f, 0.00172348f, 0.15470470f, 0.06958193f, -0.03316589f, 0.40381706f, -0.05324549f, 0.11157583f, 
    0.13315426f, -0.41788486f, 0.22343378f, -0.01891379f, 0.32901135f, 0.07564852f, 0.10472516f, 0.25236142f, 
    0.24970222f, -0.68850762f, 0.16390538f, 0.01830554f, -0.10589440f, -0.32622761f, 0.02725335f, -0.43843675f, 
    0.27645379f, -0.21812721f, -0.13627033f, 0.01034915f, 0.27416578f, 0.16469459f, 0.05771932f, -0.12704802f, 
    0.04875622f, -0.06279142f, -0.08282032f, 0.07461222f, -0.11035369f, -0.07133970f, -0.04166945f, -0.08817311f, 
    0.07405203f, -0.03217148f, 0.07595321f, 0.35114449f, -0.36318523f, 0.25815880f, 0.07291200f, 0.20931795f, 
    0.24139208f, 0.09276485f, 0.25747851f, 0.31004056f, 0.23769411f, 0.20581466f, 0.03412667f, -0.06227836f, 
    0.27730313f, 0.11371443f, 0.16623314f, 0.13763203f, 0.47508141f, 0.32348099f, -0.14649314f, 0.12714227f, 
    -0.33404827f, -0.05193263f, 0.16471510f, -0.07776729f, 0.12566429f, -0.04833938f, 0.19487458f, -0.03092851f, 
    0.26062402f, -0.15741087f, -0.00247556f, -0.07756407f, -0.09796279f, -0.27772492f, 0.08671858f, -0.02110152f, 
    0.20898247f, 0.01055333f, 0.28266278f, -0.00307005f, 0.33798006f, 0.19977224f, -0.02141364f, -0.15817021f, 
    0.16237339f, 0.01606470f, -0.08147180f, 0.15950005f, -0.17775546f, 0.02488540f, 0.03693575f, -0.10998768f, 
    0.13034280f, 0.07275371f, 0.05571737f, 0.12216455f, 0.11558023f, -0.04352115f, 0.00211550f, 0.22748467f, 
    -0.17674853f, 0.05686615f, 0.10012402f, -0.07951007f, 0.23201391f, 0.15139347f, 0.28772613f, -0.06366611f, 
    -0.05471060f, 0.15462254f, -0.08872755f, -0.05913069f, -0.03701787f, -0.17064725f, -0.15958978f, 0.08896124f, 
    -0.09476396f, -0.01332039f, 0.05652476f, 0.00499465f, 0.00271900f, -0.00158850f, -0.00621084f, 0.20888548f, 
    0.10308646f, -0.00657336f, -0.11320700f, 0.10693210f, -0.03494272f, -0.07097073f, 0.05747027f, 0.09747811f, 
    0.01524690f, 0.09466359f, -0.01022528f, 0.10097597f, 0.02427001f, 0.01819428f, 0.10936916f, -0.14312100f, 
    -0.22903778f, 0.63631517f, -0.06777623f, 0.10691284f, 0.14010094f, -0.08196028f, 0.12548731f, 0.00170086f, 
    -0.02568060f, 0.10611521f, 0.09037746f, 0.07405857f, -0.07257148f, -0.22392191f, -0.10738010f, -0.01995986f, 
    0.18105587f, -0.03862244f, -0.09631731f, 0.05367320f, 0.37405699f, 0.00139944f, 0.12941287f, 0.02992048f, 
    0.17316474f, 0.18228088f, 0.09015966f, -0.22947900f, 0.19239293f, -0.09167927f, -0.01838566f, 0.00298309f, 
    -0.14351191f, 0.14077598f, -0.12692669f, 0.04698675f, -0.03244976f, -0.09901150f, 0.14691244f, 0.18014048f, 
    0.03458552f, -0.13163342f, -0.21335235f, -0.03923693f, 0.11857602f, 0.24727176f, 0.49707761f, -0.09566010f, 
    0.21359973f, -0.05354740f, -0.37941408f, 0.18991044f, 0.09475762f, 0.17061672f, -0.16388589f, 0.00417673f, 
    -0.36238858f, 0.28653526f, 0.00861395f, 0.09750223f, 0.11249870f, 0.39869767f, -0.01280470f, -0.12070674f, 
    -0.05795327f, -0.04701045f, -0.12517622f, -0.08291756f, 0.07955277f, -0.01337682f, 0.01635631f, 0.04581828f, 
    0.24141949f, 0.01580110f, -0.08933786f, -0.30987701f, 0.12111855f, 0.33650824f, 0.10192300f, -0.04764051f, 
    -0.04497122f, 0.03915965f, -0.02175269f, 0.04989596f, 0.09252065f, 0.03609976f, -0.04913492f, 0.54279006f, 
    -0.54878694f, -0.06845461f, -0.26605305f, 0.13591328f, -0.43724105f, 0.16091321f, 0.11873601f, 0.03337381f, 
    0.08333803f, 0.21610491f, -0.13287313f, 0.03382938f, -0.28254944f, 0.11691226f, 0.39640805f, -0.31443879f, 
    0.00922640f, -0.00588570f, 0.07254865f, 0.13701327f, 0.10864747f, 0.01990382f, 0.04861125f, 0.09215795f, 
    0.07580777f, 0.19437571f, -0.02800368f, -0.28310573f, -0.13165006f, -0.23134528f, -0.18147470f, 0.05773652f, 
    0.05216702f, -0.02876252f, -0.01688099f, -0.28286162f, 0.44362286f, 0.24319689f, 0.02189077f, 0.00519652f, 
    0.21702403f, -0.05276768f, 0.11613520f, -0.28985289f, 0.11714111f, 0.20618778f, -0.06805972f, -0.09096526f, 
    -0.03210273f, -0.09862214f, 0.14714536f, -0.19482556f, -0.16540691f, 0.23596980f, 0.00236924f, 0.07104999f, 
    -0.02901282f, 0.09232219f, 0.02071745f, -0.03434685f, 0.04469693f, -0.01448563f, 0.14102979f, 0.15443018f, 
    -0.24506395f, -0.05542611f, 0.10716163f, 0.00407310f, 0.38537237f, 0.00574240f, 0.28779125f, -0.08903164f, 
    0.06268353f, 0.22762311f, -0.25325504f, 0.10580301f, 0.19632207f, -0.08560994f, -0.00366988f, 0.21203580f, 
    0.12752517f, 0.12348801f, 0.11416820f, 0.22349659f, 0.25355271f, -0.31331506f, 0.04943359f, -0.22426261f, 
    0.12423171f, -0.03466268f, -0.16572861f, 0.03733695f, 0.15267061f, -0.03132572f, 0.08182125f, 0.16097216f, 
    0.06987324f, -0.25736505f, 0.05184631f, -0.03037929f, 0.22492722f, -0.19984820f, -0.07333425f, 0.09763750f, 
    -0.17961520f, -0.04497650f, 0.33836204f, 0.23384532f, 0.08888731f, -0.08164784f, -0.04805868f, -0.06345784f, 
    0.23812304f, -0.02881574f, -0.01011416f, 0.09266710f, -0.32247663f, 0.20111816f, 0.00635151f, 0.04546177f, 
    -0.20537668f, -0.08309226f, 0.03016037f, -0.07697466f, -0.09322248f, 0.08656855f, -0.05234301f, 0.07277773f, 
    -0.38378763f, 0.02883840f, -0.17314476f, -0.56394225f, 0.03153346f, -0.02456637f, 0.87411749f, -0.05390945f, 
    -0.38337585f, -0.00856979f, -0.17084013f, 0.13877226f, 0.11746100f, 0.24202944f, -0.24291901f, 0.04366697f, 
    0.03824089f, 0.20770046f, 0.07327181f, -0.36513361f, -0.21903028f, -0.07814228f, 0.18296325f, -0.31105939f, 
    -0.12590444f, -0.22444707f, -0.26135352f, 0.05492897f, 0.31845245f, 0.02272110f, 0.20231518f, -0.06655844f, 
    -0.08503739f, 0.17083283f, -0.22681907f, 0.32023230f, -0.63547319f, -0.02579069f, -0.15694125f, -0.28389639f, 
    -0.15123348f, 0.14213324f, -0.12513681f, 0.02789783f, 0.18626240f, 0.50922912f, 0.27194971f, 0.08395790f, 
    -0.00262415f, 0.01272932f, -0.31959355f, 0.21377751f, -0.22876406f, -0.20495766f, 0.07465515f, -0.16947147f, 
    -0.01661621f, 0.00220254f, 0.20515630f, 0.05601769f, 0.14143413f, 0.15985283f, -0.04018164f, 0.11065677f, 
    -0.07958950f, -0.06881579f, -0.35684913f, -0.39060053f, 0.09967095f, -0.26388490f, -0.06717654f, -0.25786376f, 
    -0.06621940f, 0.14665771f, -0.21359360f, -0.14178517f, 0.01493395f, -0.01661648f, -0.01081948f, -0.06218617f, 
    -0.37510028f, -0.04362461f, -0.19648890f, -0.29061031f, -0.48316330f, -0.35813099f, 0.37503737f, 0.20973891f, 
    0.37830257f, -0.06797735f, 0.07987436f, 0.17900099f, -0.09027730f, 0.20333178f, -0.10775465f, 0.01963990f, 
    -0.26912138f, 0.37408200f, -0.05580854f, -0.03661383f, 0.15805215f, 0.59401584f, 0.10636739f, 0.07733881f, 
    -0.26748770f, -0.06240050f, -0.08987150f, 0.03803940f, -0.26750627f, -0.36660549f, -0.03344247f, 0.25887635f, 
    -0.00588292f, -0.11241080f, -0.04891684f, -0.13057159f, 0.26934677f, -0.05950151f, -0.00323208f, 0.12210152f, 
    -0.20182188f, 0.05218246f, 0.03267074f, 0.09335450f, 0.08590429f, 0.08552131f, 0.07204024f, -0.35691509f, 
    -0.09395566f, -0.09892534f, -0.27034080f, 0.18968156f, -0.25301439f, 0.13665533f, 0.10919828f, -0.06541358f, 
    -0.09005849f, -0.04925666f, 0.31714690f, 0.04702472f, 0.11175011f, 0.22773960f, 0.27142110f, 0.16080450f, 
    -0.00304955f, -0.10405146f, 0.05377202f, 0.18414694f, 0.05865891f, 0.06787468f, 0.01739019f, -0.21788026f, 
    -0.00425532f, 0.09202636f, 0.13832714f, -0.02995093f, -0.03800536f, -0.07090423f, -0.02381457f, -0.03521974f, 
    -0.08127995f, -0.16158210f, 0.03299896f, 0.12178457f, 0.09458739f, 0.04636831f, -0.04756250f, 0.12306847f, 
    0.31223589f, -0.23459040f, 0.13325904f, -0.21139789f, -0.05671029f, 0.43378833f, -0.31472102f, 0.06277195f, 
    0.10491695f, -0.14959019f, -0.34280640f, -0.17279333f, 0.05116426f, 0.14663649f, 0.14761621f, -0.17513359f, 
    -0.10041726f, -0.14120196f, 0.20322664f, 0.00075078f, -0.36666152f, 0.18055864f, -0.21602635f, 0.01391705f, 
    -0.27378803f, -0.20061137f, -0.12789524f, 0.37543014f, -0.19518068f, 0.20993300f, 0.04335784f, -0.06547519f, 
    0.07359497f, -0.28798810f, 0.16264164f, 0.19214027f, 0.03985079f, 0.14132056f, -0.03877870f, -0.37799978f, 
    0.04347268f, -0.13466664f, -0.02059998f, -0.11979788f, 0.09072440f, 0.23108968f, -0.25292176f, -0.01393523f, 
    -0.01086382f, 0.02587169f, -0.15419701f, -0.01531580f, 0.08872589f, -0.15237127f, 0.17298844f, -0.17714538f, 
    0.01117120f, -0.14979844f, -0.04516134f, 0.08491496f, -0.04012452f, -0.08422563f, -0.05495469f, -0.16087866f, 
    0.14166582f, -0.08311617f, -0.12609118f, -0.10919847f, 0.06012866f, 0.05643340f, 0.08632497f, -0.15395473f, 
    0.08992194f, -0.02044576f, -0.10750774f, -0.02854422f, 0.08692467f, -0.13096987f, 0.05797769f, -0.02542426f, 
    -0.06225820f, -0.04687587f, -0.00934716f, 0.07707948f, -0.12900952f, -0.05404971f, 0.02839216f, -0.16192600f, 
    0.03236712f, -0.11484165f, -0.09670532f, 0.01387832f, -0.10962970f, 0.12002651f, 0.00303816f, -0.06673730f, 
    -0.09508112f, -0.01845131f, -0.12390362f, -0.06590392f, -0.11898579f, -0.10144111f, -0.34825739f, -0.15411654f, 
    -0.02009558f, -0.14371590f, 0.01198255f, -0.14815801f, 0.05336695f, -0.04143147f, -0.08838250f, 0.20887606f, 
    0.10297431f, -0.11735815f, 0.01740943f, -0.10234889f, -0.18402681f, -0.02119007f, 0.12255639f, 0.02428132f, 
    -0.02122403f, -0.02050791f, 0.07388070f, -0.14585169f, 0.19161707f, 0.08386101f, -0.02307102f, 0.17821474f, 
    0.07007813f, 0.09626590f, 0.02595261f, 0.00022532f, 0.02604341f, -0.15497535f, 0.05166066f, 0.14241721f, 
    0.01243431f, -0.08610477f, 0.07375222f, -0.02680129f, 0.07823337f, -0.09992556f, -0.02489483f, -0.03643538f, 
    0.07988690f, 0.08933219f, -0.06707709f, -0.08249098f, 0.10046650f, -0.05508060f, 0.06721386f, -0.01260552f, 
    0.11888757f, 0.13161473f, 0.13225754f, 0.05847646f, -0.21840188f, -0.08656773f, -0.01593630f, -0.04056233f, 
    -0.06704308f, 0.05477424f, 0.01300747f, 0.16918707f, -0.07020928f, -0.09122575f, -0.03139075f, 0.00305647f, 
    -0.17994231f, 0.28275663f, 0.21148673f, 0.00645778f, -0.09029997f, -0.00874145f, -0.25024861f, 0.35590094f, 
    -0.16711053f, 0.06590842f, 0.31307176f, -0.06066243f, -0.23672396f, -0.04140915f, -0.20868479f, -0.18506353f, 
    0.34695414f, 0.09830122f, 0.05785355f, -0.15466429f, 0.09878237f, 0.03239286f, -0.06661897f, 0.11224371f, 
    0.06873182f, -0.09739199f, 0.24268816f, -0.13487644f, -0.28477362f, -0.01751035f, 0.05162464f, 0.00925694f, 
    0.03177235f, 0.22804545f, 0.13383275f, -0.09302238f, 0.21729217f, -0.49848634f, 0.00337324f, 0.15638213f, 
    0.03850199f, 0.01777735f, -0.12226065f, -0.13082129f, -0.36232644f, -0.07088291f, -0.07475211f, -0.30519977f, 
    -0.13219953f, -0.05976389f, 0.18322106f, 0.27189678f, -0.09981544f, -0.20661116f, 0.28109503f, 0.01827971f, 
    -0.06493762f, 0.16466753f, 0.32165736f, -0.09755634f, 0.06798532f, -0.03620327f, -0.15211625f, 0.25924420f, 
    -0.11920121f, -0.25494725f, 0.06343289f, -0.07197201f, -0.03110233f, -0.00592346f, -0.10368015f, -0.34849498f, 
    -0.02393250f, 0.05018152f, 0.43442664f, 0.06206499f, 0.24162671f, 0.19710892f, -0.01398943f, -0.05618075f, 
    0.02056786f, -0.45018715f, 0.29157689f, 0.29718527f, -0.07472269f, -0.27256873f, 0.19878159f, -0.07018890f, 
    -0.03388940f, 0.23595153f, -0.02268679f, 0.11601552f, 0.07883922f, -0.02242875f, 0.06001621f, -0.25712982f, 
    0.12336246f, 0.26201063f, -0.14259428f, 0.25369301f, 0.43084693f, 0.17247002f, -0.17478290f, 0.15601361f, 
    -0.01785014f, 0.16540302f, 0.22619720f, 0.04899564f, -0.14140657f, -0.05172377f, -0.46076468f, -0.08119041f, 
    -0.00906053f, -0.12717119f, 0.15988266f, 0.40309462f, -0.46538740f, 0.37232482f, -0.04130607f, 0.30031514f, 
    -0.02294347f, -0.07447427f, 0.31065491f, -0.25018737f, -0.43668956f, 0.18971583f, 0.12654737f, -0.08838817f, 
    -0.10142316f, 0.11404654f, -0.00194064f, -0.31626290f, -0.03112637f, 0.14743125f, -0.86194050f, 0.17151134f, 
    -0.30432782f, -0.07612041f, -0.49272531f, 0.09035194f, -0.04721497f, -0.38349795f, 0.11711009f, 0.01026061f, 
    0.05806926f, -0.06057883f, -0.01084016f, 0.15309986f, -0.06821133f, -0.19974059f, -0.10993686f, 0.17271999f, 
    -0.09233513f, -0.04099369f, -0.08386961f, 0.05179178f, 0.02886567f, 0.05391374f, 0.02176783f, 0.21798095f, 
    0.02937137f, 0.10624477f, -0.18629894f, -0.38115343f, 0.04785116f, -0.23222116f, -0.07338674f, 0.30314669f, 
    0.00647571f, 0.00947247f, 0.08202988f, 0.19589488f, -0.11619347f, 0.23437394f, 0.02547113f, -0.16562694f, 
    -0.18595052f, -0.13358438f, -0.13491684f, 0.17117232f, -0.23868297f, 0.16705038f, 0.20082563f, 0.16387138f, 
    -0.07522894f, 0.09584458f, -0.17311877f, 0.02383693f, -0.01029164f, -0.18203950f, 0.03331941f, -0.47525212f, 
    0.05152965f, -0.36511704f, -0.05989580f, -0.32121155f, 0.34776151f, 0.03987424f, -0.14306991f, 0.13766977f, 
    0.13428456f, 0.17366256f, 0.05078251f, -0.09570329f, -0.16221584f, 0.21432781f, -0.01559062f, -0.01466235f, 
    0.36805856f, -0.20718330f, 0.09501454f, -0.01180021f, 0.55684733f, -0.03424245f, 0.03640489f, 0.42465895f, 
    0.22010584f, -0.42450109f, 0.32526764f, 0.18388923f, 0.28112829f, -0.35207966f, -0.10198712f, -0.44680083f, 
    -0.12351404f, 0.00936585f, -0.29678157f, -0.23797366f, 0.09116706f, 0.21464321f, -0.09085050f, -0.12383274f, 
    -0.09168135f, -0.16059236f, 0.29761422f, -0.06874484f, -0.08351450f, 0.26949584f, -0.16427191f, 0.18957277f, 
    0.09303015f, -0.02002257f, 0.11444513f, 0.17568652f, -0.54180646f, 0.36081442f, -0.09984836f, 0.16363631f, 
    -0.03969575f, -0.04070362f, 0.24196663f, 0.20794430f, -0.07804355f, 0.16950794f, 0.04622951f, 0.05321272f, 
    -0.00525907f, 0.02625405f, 0.00881864f, 0.02441587f, -0.08070357f, -0.04761251f, 0.05564573f, -0.06823886f, 
    -0.06434853f, 0.01858415f, 0.00179236f, -0.09781405f, -0.01904942f, -0.07612233f, -0.08333036f, -0.02354625f, 
    -0.05938657f, -0.00421285f, -0.03922100f, 0.05524608f, -0.09866715f, -0.09845676f, -0.03673357f, -0.01875144f, 
    0.03182234f, 0.07694247f, -0.08778182f, 0.04533993f, -0.09114876f, -0.05298455f, -0.07940585f, -0.01541901f, 
    0.04471991f, -0.07571522f, -0.10669284f, 0.00085685f, 0.02164287f, -0.01228390f, -0.02874587f, -0.04519458f, 
    -0.00836646f, 0.07006948f, 0.03925748f, 0.01979997f, -0.05826253f, -0.07695091f, 0.07922448f, -0.05982856f, 
    0.04328772f, -0.11244679f, -0.04031990f, 0.00069214f, 0.06037877f, 0.01579773f, -0.04468681f, 0.00429094f, 
    0.01819117f, -0.07393981f, 0.00857492f, -0.04474905f, -0.05030635f, -0.03839481f, -0.07465713f, -0.06969067f, 
    -0.04300126f, -0.01422500f, -0.01914785f, -0.07809632f, -0.05761607f, 0.07263188f, 0.04067061f, -0.02380427f, 
    -0.00797166f, 0.00785949f, -0.08776195f, 0.03394448f, -0.01351525f, -0.10440502f, -0.02313908f, 0.01960737f, 
    0.00895611f, -0.08121333f, 0.04318984f, 0.03693986f, -0.07157169f, -0.07494357f, -0.01398013f, 0.04965121f, 
    0.00219157f, -0.03264757f, 0.06151076f, -0.04783129f, -0.12093074f, -0.04241522f, -0.06097576f, -0.10169894f, 
    0.01589423f, 0.07176197f, -0.09781675f, -0.11728385f, -0.07960539f, 0.00227562f, 0.01672600f, -0.07892206f, 
    0.04699110f, 0.03057807f, -0.12684132f, 0.03403210f, -0.04767802f, 0.04071215f, 0.01092418f, 0.03039829f, 
    -0.03162479f, -0.01196499f, -0.04731594f, -0.06524107f, 0.03733518f, 0.01724417f, -0.10941156f, -0.07013359f, 
    -0.05730255f, -0.08852562f, -0.05662894f, 0.02173422f, 0.03601350f, -0.10426021f, 0.04426883f, -0.00364774f, 
    0.25888336f, 0.13386837f, 0.43884727f, 0.15772624f, 0.14979935f, -0.06862032f, -0.03024545f, -0.27187058f, 
    0.06458111f, 0.05511239f, 0.44619399f, 0.17456917f, 0.09438067f, 0.10619376f, -0.14079413f, 0.12909855f, 
    0.11580104f, 0.06957694f, -0.08524072f, 0.24016719f, -0.23533203f, 0.00189245f, -0.22295555f, 0.20569320f, 
    0.09640049f, -0.02385161f, 0.42210078f, 0.18899658f, -0.07625876f, 0.11912889f, -0.01748381f, 0.11719728f, 
    0.26853454f, 0.07502690f, 0.16300297f, -0.05077032f, 0.26767430f, -0.16713347f, -0.05210356f, 0.05438820f, 
    -0.10528218f, -0.07667302f, -0.05321197f, -0.05601229f, 0.07331222f, 0.04066776f, 0.03028954f, 0.27206820f, 
    -0.46163315f, 0.01409647f, -0.01012252f, 0.34654635f, 0.08723865f, -0.30957225f, 0.21263042f, 0.22335389f, 
    -0.39521873f, 0.12543927f, 0.03432318f, -0.03286616f, -0.20658682f, 0.17182179f, 0.05192576f, 0.21976206f, 
    -0.21007282f, 0.12421406f, -0.05217560f, -0.19850355f, -0.52819985f, -0.06335872f, 0.20369370f, -0.13578033f, 
    0.15058558f, 0.08217784f, 0.37378761f, -0.19584168f, 0.36561224f, -0.06692198f, 0.29616627f, -0.06937816f, 
    0.17555390f, 0.10190040f, -0.15772361f, 0.06494012f, -0.04503220f, -0.00036010f, 0.19892648f, -0.01223330f, 
    0.17272304f, 0.34617499f, 0.18739153f, -0.02628599f, 0.15568635f, 0.38194758f, -0.09514564f, 0.22518857f, 
    -0.00707527f, 0.15747343f, 0.00719648f, 0.12036961f, 0.04425719f, 0.31180578f, 0.01438417f, 0.22939360f, 
    -0.26985157f, 0.28532541f, 0.06767279f, -0.02761629f, 0.18625744f, 0.05439894f, -0.11165042f, 0.05368835f, 
    0.11260019f, 0.13231248f, 0.09786173f, 0.38737524f, 0.10873165f, -0.26584852f, 0.27753165f, 0.07551234f, 
    0.08767317f, 0.14826171f, -0.02423864f, -0.17591740f, -0.01141840f, 0.11011539f, 0.14108199f, 0.00508046f, 
    0.34375417f, 0.08483538f, 0.08301654f, 0.00311760f, 0.05793187f, 0.07463075f, 0.46940860f, 0.19459081f, 
    -0.50709915f, -0.02288493f, 0.06431253f, -0.00384879f, 0.10201356f, 0.03481768f, -0.00364433f, -0.27233702f, 
    0.21484695f, 0.05120813f, -0.05292481f, -0.14248794f, -0.02529007f, -0.20507212f, -0.01515976f, 0.25053522f, 
    -0.04379898f, 0.00279580f, 0.50232905f, 0.01410888f, 0.08426814f, 0.22003724f, 0.06136212f, -0.21482797f, 
    -0.11082391f, 0.18789083f, 0.33998981f, -0.02169260f, 0.12140087f, 0.14348024f, -0.05282111f, -0.02708278f, 
    0.11117005f, -0.04885534f, -0.06433131f, -0.11678210f, -0.03103114f, -0.08038428f, -0.01585461f, 0.20367202f, 
    -0.14835094f, 0.02026906f, 0.21138541f, -0.02282165f, -0.08605167f, -0.20941710f, 0.33107314f, 0.11576353f, 
    -0.27522710f, -0.06895703f, 0.26830348f, -0.27729660f, -0.12626338f, 0.01570703f, 0.10806829f, 0.23140667f, 
    -0.09419996f, 0.02650561f, -0.01753632f, -0.20176214f, -0.29636914f, -0.08128452f, -0.22570620f, -0.10206518f, 
    0.20240764f, 0.07080141f, 0.28669354f, -0.10135634f, 0.05186569f, 0.23559722f, 0.17663009f, 0.24742694f, 
    0.00097678f, 0.09776491f, -0.14167592f, 0.13359538f, -0.19629872f, 0.06710038f, 0.20090735f, 0.21188673f, 
    0.01782763f, 0.56330854f, -0.06393705f, -0.10449373f, 0.05801217f, -0.18258232f, 0.44659105f, -0.20499894f, 
    0.08726965f, -0.42195085f, -0.03722659f, 0.62457085f, -0.15794215f, 0.14210597f, 0.03587971f, 0.43953001f, 
    0.23542537f, 0.69061553f, -0.17202525f, -0.03413192f, -0.09858909f, -0.03785402f, -0.52805448f, -0.10354991f, 
    -0.07219660f, 0.35283285f, 0.10521113f, 0.04820657f, 0.11282860f, -0.06213055f, 0.21303289f, 0.19244610f, 
    -0.14030731f, -0.23982486f, 0.27274770f, 0.00604746f, -0.25904277f, -0.05530210f, 0.27672035f, -0.03965143f, 
    0.07674244f, -0.04395340f, -0.09035148f, 0.01023178f, -0.08913410f, -0.10970242f, -0.04734845f, -0.02771865f, 
    -0.08750146f, 0.05498273f, -0.09686898f, 0.07126851f, -0.02600915f, -0.03163815f, -0.05220344f, 0.07234694f, 
    0.00371909f, 0.01061365f, 0.05795985f, 0.00743540f, 0.00012853f, -0.01569356f, -0.03149721f, -0.00979593f, 
    -0.12306716f, -0.01690808f, 0.01247900f, 0.03364492f, 0.00725440f, 0.01088043f, -0.05049414f, -0.08525115f, 
    -0.02361475f, -0.03186309f, 0.04190840f, 0.02103749f, -0.09368885f, -0.04736968f, -0.00007724f, 0.01122130f, 
    -0.09920923f, -0.04623402f, -0.02029490f, 0.04717719f, 0.02472204f, -0.03098371f, -0.04607106f, 0.01359676f, 
    -0.02707517f, -0.04131899f, -0.10837262f, -0.04624794f, 0.00796383f, 0.00784510f, -0.08151397f, -0.00478660f, 
    -0.05057260f, -0.10390729f, -0.09572273f, -0.08021326f, 0.03274338f, -0.03807623f, 0.00688096f, 0.07528501f, 
    -0.08088548f, -0.08548148f, 0.04531835f, 0.00622035f, 0.07158364f, 0.04189916f, 0.02054665f, 0.02626708f, 
    -0.10590856f, 0.00639521f, 0.01219014f, 0.05830194f, -0.04487687f, -0.04463607f, 0.00813221f, 0.05355017f, 
    0.05651338f, 0.04644107f, -0.09006072f, 0.02471008f, -0.03252492f, 0.01774122f, -0.07227246f, -0.01839230f, 
    0.03617594f, -0.07857604f, -0.07764211f, -0.06160344f, -0.03583912f, 0.01346625f, 0.05122378f, 0.01344431f, 
    -0.01439167f, -0.03040832f, -0.07378251f, -0.09295261f, -0.07031793f, -0.00345752f, -0.08593738f, 0.01486672f, 
    0.05843506f, 0.03733300f, -0.02201803f, 0.02437039f, -0.01066800f, -0.01584533f, 0.03734585f, -0.06074432f, 
    -0.02904949f, -0.07926819f, -0.03311053f, -0.09425989f, 0.05210521f, -0.02627733f, 0.00020840f, -0.04874370f, 
    -0.08905347f, 0.01109875f, 0.00970265f, 0.01533620f, -0.00104149f, -0.04674134f, -0.09568346f, 0.02055349f, 
    0.10655314f, -0.05063449f, -0.05474659f, 0.08968674f, -0.03749344f, 0.04442942f, -0.22673692f, 0.38744545f, 
    -0.14190872f, 0.02388365f, -0.35362595f, 0.21704356f, 0.02780317f, -0.01588178f, 0.18302801f, 0.25319210f, 
    0.04731605f, 0.26085976f, 0.04817262f, -0.18508416f, 0.38818577f, 0.27017424f, 0.19272202f, -0.04252948f, 
    -0.05893021f, 0.02884571f, -0.35231805f, 0.04768495f, 0.40140998f, 0.00986602f, 0.03851762f, 0.12543143f, 
    -0.15180145f, 0.01696688f, -0.18193346f, -0.04427043f, -0.32726330f, 0.38943869f, -0.08337224f, 0.08936496f, 
    0.08402663f, -0.02981202f, 0.03050011f, 0.37963298f, 0.35955361f, 0.05109828f, 0.01048350f, -0.42511621f, 
    0.69778150f, 0.09392575f, 0.08176361f, -0.20886773f, -0.23261704f, 0.30966386f, -0.61741745f, 0.05389092f, 
    0.58228397f, -0.01443993f, -0.19948569f, 0.26312456f, 0.27567652f, -0.23698246f, 0.16824965f, -0.38698670f, 
    0.22515994f, 0.06441095f, -0.04484254f, 0.18507901f, 0.52458465f, 0.05928479f, 0.09920892f, 0.18808451f, 
    0.05069444f, 0.20627211f, -0.46713758f, 0.23713253f, -0.17299406f, -0.06522262f, -0.01378064f, -0.10185216f, 
    -0.04818184f, 0.22853969f, 0.29285830f, 0.14445958f, 0.26153624f, 0.13613158f, 0.03787663f, 0.34551582f, 
    0.23580669f, -0.58349967f, -0.04870944f, 0.43610898f, -0.08929542f, -0.27942172f, -0.12539905f, 0.10401345f, 
    0.01529036f, -0.19872989f, 0.18431561f, -0.68995827f, -0.04476292f, -0.18421996f, 0.04555288f, -0.09145230f, 
    -0.04958585f, -0.65884346f, 0.20605198f, 0.02536034f, -0.26477647f, 0.03011939f, 0.23890993f, 0.23899260f, 
    0.06038778f, 0.06327984f, -0.18830661f, -0.18047613f, -0.50164735f, 0.28002545f, -0.08509533f, -0.03300573f, 
    -0.04486553f, -0.13018237f, -0.00670250f, 0.29065728f, -0.05917732f, 0.22771956f, 0.02070610f, -0.07747281f, 
    0.01655610f, -0.06281336f, 0.07001236f, 0.05933905f, -0.04429765f, -0.01601320f, -0.00515079f, -0.06831870f, 
    -0.08725388f, 0.02722237f, -0.02997266f, -0.06165741f, -0.03277849f, -0.04508608f, -0.10114607f, 0.03899878f, 
    -0.08020626f, -0.02784475f, -0.04218828f, -0.03306235f, 0.04312840f, 0.01028555f, -0.07882037f, -0.10308602f, 
    0.04299219f, 0.05088985f, -0.03482981f, -0.08301865f, -0.10065722f, 0.04534223f, 0.01135555f, -0.01533674f, 
    0.01635968f, 0.03096269f, -0.03417386f, 0.00561010f, -0.08309858f, -0.00572945f, 0.06652220f, -0.03154444f, 
    -0.01557772f, 0.08056196f, -0.04184246f, -0.00855005f, -0.10337653f, 0.05252493f, 0.03626435f, 0.05965732f, 
    0.04351275f, -0.06804541f, 0.05301340f, -0.00002496f, -0.02402226f, -0.04704822f, -0.00911320f, -0.09145515f, 
    -0.05310783f, 0.00486640f, -0.02455850f, 0.00196550f, 0.04455143f, 0.05544768f, 0.01003942f, -0.09296245f, 
    -0.04937781f, -0.03571182f, -0.07770714f, 0.05076610f, 0.03772464f, -0.07711752f, -0.00031408f, -0.01416702f, 
    -0.08800389f, -0.02916854f, -0.05588920f, 0.06487828f, -0.04873080f, 0.01011766f, -0.06696737f, -0.02996684f, 
    -0.08215285f, -0.04273972f, -0.07892827f, 0.01493348f, -0.05246092f, 0.04414247f, 0.00957228f, 0.06401567f, 
    0.02471253f, -0.00628942f, -0.04486806f, 0.00703757f, 0.05256085f, 0.03581583f, 0.01810537f, -0.04102933f, 
    0.06890250f, -0.00338074f, 0.01649638f, 0.06329130f, -0.05136019f, -0.05994466f, -0.06967731f, 0.00501755f, 
    0.08371627f, -0.03221248f, -0.04890126f, -0.01526065f, -0.00804104f, 0.00987998f, -0.09073211f, -0.04772935f, 
    0.03135991f, -0.05574416f, 0.02964481f, 0.04019918f, 0.08185010f, -0.08829338f, 0.01065413f, 0.01452444f, 
    0.01818141f, -0.07895787f, -0.01325043f, 0.01268217f, -0.04595486f, -0.01845940f, -0.06499625f, 0.01172074f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06434493f, 0.16245370f, 0.11596760f, 0.11328871f, 0.13394177f, -0.04377027f, 0.27907628f, -0.01883377f, 
    -0.09173630f, -0.03408988f, -0.04456371f, -0.02985603f, -0.06866060f, -0.02677351f, -0.08331762f, -0.10260433f, 
    0.22138242f, 0.09983256f, 0.01147698f, 0.10630007f, -0.09152004f, 0.06778601f, 0.00538646f, 0.12350727f, 
    -0.09050547f, 0.24166335f, -0.03510295f, 0.10181949f, 0.03567350f, -0.07872193f, -0.11856420f, -0.06873021f, 
    -0.09176371f, 0.14478073f, 0.03637709f, 0.05654528f, -0.00289895f, 0.05886373f, 0.25144616f, 0.02192800f, 
    -0.07438453f, 0.05867145f, 0.00484209f, 0.08639883f, 0.13809717f, 0.22876048f, 0.03524418f, -0.08436282f, 
    -0.01335069f, -0.02979288f, 0.20365469f, -0.05662512f, 0.16064250f, 0.04781631f, 0.00832064f, 0.04960034f, 
    -0.08608343f, -0.03853134f, -0.08583370f, -0.05692183f, -0.07604825f, 0.04488378f, -0.18349616f, 0.01458245f, 
    0.23400658f, -0.05833547f, 0.19311337f, 0.08454347f, -0.00889697f, 0.00015511f, 0.13814621f, -0.06497700f, 
    0.12294494f, -0.07158677f, 0.19583905f, -0.07227926f, 0.07562675f, 0.19706427f, -0.08847600f, 0.18401565f, 
    0.03508631f, -0.05717967f, 0.03222430f, -0.11248574f, -0.00918982f, 0.10862835f, 0.02096563f, -0.11016935f, 
    -0.08319275f, 0.05573934f, 0.07663313f, 0.04197242f, 0.26831090f, -0.10102584f, -0.07484248f, -0.11952803f, 
    0.14713517f, -0.09502087f, -0.11765146f, 0.17233710f, 0.34617105f, -0.16939403f, 0.02920723f, -0.09806074f, 
    -0.08985837f, 0.21574186f, 0.03102916f, 0.12870267f, 0.03405366f, 0.06159275f, 0.06247330f, 0.18234208f, 
    -0.11025132f, 0.07561199f, 0.18226884f, -0.17412370f, 0.12292075f, 0.08922110f, 0.10650598f, -0.02979496f, 
    0.12274552f, 0.28891754f, -0.10864830f, 0.03944187f, 0.13910922f, 0.07124271f, 0.21371837f, -0.03593634f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00203404f, -0.02152359f, 0.11279792f, 0.09088053f, -0.32312229f, -0.08729385f, 0.19163561f, -0.06456188f, 
    0.01228711f, -0.14745855f, 0.02487117f, -0.07393901f, -0.45001289f, -0.01975893f, -0.07467476f, -0.36385772f, 
    -0.07691622f, -0.04359251f, 0.09932163f, -0.02178002f, -0.05990224f, -0.42410490f, -0.01841673f, 0.11735142f, 
    -0.00498285f, 0.04919171f, -0.07019785f, 0.31308931f, -0.06033282f, -0.06589331f, -0.69649768f, -0.02926598f, 
    -0.07840610f, -0.07470188f, -0.00150013f, 0.04195448f, 0.24205969f, 0.15240757f, 0.08302733f, 0.09007673f, 
    -0.02023972f, -0.16741361f, 0.02197335f, -0.32357201f, 0.13015804f, 0.17521499f, -0.42761350f, 0.00533818f, 
    0.05475403f, 0.06586736f, 0.07606355f, 0.04517794f, -0.08908962f, 0.01217368f, -0.18712038f, -0.02546862f, 
    0.04488187f, 0.09806911f, -0.02020397f, 0.24311970f, 0.05318949f, -0.05571749f, -0.19397645f, -0.06435931f, 
    0.13362084f, 0.09027289f, 0.02084301f, -0.07865963f, -0.05404552f, 0.03163668f, -0.04446823f, 0.17083746f, 
    0.34872887f, -0.07146730f, -0.18659976f, 0.12213213f, 0.03258893f, 0.08268319f, -0.04246003f, 0.12869012f, 
    -0.14029457f, -0.38469151f, 0.04201110f, 0.42251718f, -0.40520176f, -0.23819496f, 0.02860941f, 0.00287109f, 
    -0.00223593f, -0.09541468f, -0.03412430f, -0.02618802f, 0.07417322f, -0.17331088f, -0.01949469f, -0.50949687f, 
    0.30013141f, -0.13520309f, -0.22909336f, 0.09772264f, 0.18182218f, 0.29601991f, -0.32729456f, -0.09755735f, 
    -0.01177750f, -0.71735269f, -0.45884404f, 0.07227967f, 0.10909591f, 0.03654693f, 0.18604235f, 0.19453552f, 
    -0.05962538f, 0.02092741f, -0.36000550f, 0.06112853f, 0.08805732f, -0.47742626f, -0.29968536f, -0.07266849f, 
    0.13900906f, 0.15780839f, 0.05095524f, 0.14245929f, 0.07663696f, 0.03006823f, 0.04750426f, 0.02675268f, 
    0.05704094f, 0.14715916f, 0.09623493f, -0.24463989f, 0.14427908f, -0.06392283f, 0.10538562f, -0.05935913f, 
    -0.05124731f, 0.03855718f, 0.06605660f, -0.04844522f, 0.04153996f, -0.02193915f, -0.09042023f, -0.44891271f, 
    0.17749909f, 0.10507084f, -0.45141593f, -0.02632997f, -0.02594047f, -0.07814085f, -0.28853330f, 0.01494024f, 
    -0.02888380f, -0.04867828f, 0.02406564f, 0.18040632f, -0.14315498f, -0.06226304f, -0.27570912f, -0.02705990f, 
    0.06671614f, -0.13265528f, 0.05977820f, -0.08883754f, -0.29951939f, -0.42221478f, -0.67269415f, -0.00364826f, 
    0.00563330f, -0.51307893f, -0.07352439f, 0.01359928f, 0.16606829f, 0.05066687f, 0.40703809f, 0.01110758f, 
    -0.24929331f, -0.06401657f, -0.05527011f, -0.04686544f, -0.57356101f, 0.03295008f, 0.10618553f, -0.05335848f, 
    0.10534810f, -0.13554306f, -0.10891942f, -0.24050863f, 0.01246307f, 0.02139468f, -0.11187154f, 0.07703114f, 
    0.19562432f, 0.01012628f, -0.12460572f, 0.00629799f, -0.02520596f, -0.03106240f, 0.54637361f, 0.20034730f, 
    -0.03362979f, -0.07163712f, 0.17084549f, 0.02802817f, 0.07066112f, 0.07694545f, 0.06546044f, -0.38882235f, 
    0.24220583f, -0.18448509f, 0.05876117f, -0.13327157f, 0.21888334f, 0.27211422f, -0.02247345f, -0.02953954f, 
    -0.04707259f, 0.08041015f, -0.11034106f, -0.00249350f, -0.08321009f, -0.25096676f, -0.01119674f, -0.21592376f, 
    0.19569306f, -0.06632686f, -0.00184246f, 0.04827785f, 0.06686146f, 0.11447227f, -0.05403543f, 0.04714941f, 
    -0.04665597f, 0.16672644f, 0.03595015f, -0.21891087f, -0.26339272f, 0.00744538f, 0.14670911f, 0.20691857f, 
    0.04766894f, 0.01514688f, -0.17851180f, -0.03814910f, 0.19736606f, 0.08486203f, 0.22161685f, -0.09185739f, 
    -0.23020829f, -0.08168977f, -0.03872504f, 0.09016143f, 0.15367506f, -0.09950415f, 0.03648840f, 0.01785989f, 
    -0.07825813f, 0.01302716f, -0.66468698f, 0.21103291f, 0.05506615f, -0.00819315f, 0.09132222f, 0.04589171f, 
    -0.05149030f, -0.57726461f, -0.02444899f, 0.05068134f, -0.35231838f, 0.00078076f, 0.02410331f, 0.08468287f, 
    0.07911715f, 0.00570122f, 0.11767615f, 0.03762746f, -0.06690641f, -0.13188800f, 0.23537119f, -0.32707837f, 
    0.05218707f, 0.14371896f, -0.09124427f, 0.20017993f, -0.18617323f, -0.08693051f, 0.40941966f, -0.08339574f, 
    0.03898956f, -0.68008071f, 0.06915248f, -0.00910676f, 0.06957586f, 0.12006672f, 0.09135319f, 0.04235536f, 
    -0.02717952f, 0.23547865f, 0.03329680f, 0.06155268f, 0.00992992f, -0.06545646f, 0.16815044f, 0.02457451f, 
    0.10445508f, 0.03307652f, -0.04265714f, 0.00411996f, -0.42362842f, 0.06160129f, -0.36629164f, -0.06494695f, 
    -0.41947892f, -0.36622509f, -0.07552385f, 0.21024802f, -0.04410470f, -0.01294704f, -0.37054569f, -0.50568968f, 
    -0.13550286f, -0.02605974f, 0.14002755f, 0.05226578f, -0.01860126f, 0.00900157f, -0.29540300f, 0.12530334f, 
    -0.26890764f, 0.03021162f, -0.13589835f, -0.45930114f, 0.07824477f, -0.11715158f, -0.04802462f, 0.29257280f, 
    -0.10967646f, -0.16621311f, 0.07244598f, 0.13069941f, 0.11538466f, 0.19629097f, -0.00903300f, -0.04376097f, 
    0.03951127f, -0.10080799f, -0.19498727f, -0.07900323f, -0.25375539f, -0.26252922f, -0.06370694f, -0.21533746f, 
    0.22611055f, 0.04063303f, 0.22549723f, 0.00280024f, 0.13959807f, -0.10222856f, -0.57080328f, -0.09891611f, 
    0.04074305f, 0.22370273f, 0.20366958f, -0.28889191f, 0.06803620f, -0.07316454f, -0.16369596f, 0.21032052f, 
    0.03930346f, -0.05296930f, -0.01047614f, -0.00715801f, -0.55622488f, 0.24097082f, -0.33186260f, -0.02300138f, 
    0.17651503f, 0.04672495f, -0.00835283f, 0.06130532f, -0.43447641f, 0.02515199f, -0.02355140f, 0.04244898f, 
    -0.09153190f, -0.46954870f, -0.19545555f, 0.01749077f, 0.20705509f, 0.03793466f, -0.28229290f, 0.10289981f, 
    -0.00104114f, 0.09988380f, -0.03273712f, -0.06987976f, 0.08161924f, 0.00049011f, -0.03649477f, 0.20410927f, 
    -0.69179839f, -0.42940691f, -0.10385530f, -0.40599191f, -0.02447193f, 0.03326210f, 0.04950818f, 0.19797780f, 
    0.00438983f, 0.02775552f, -0.06683522f, -0.25213698f, 0.05763974f, -0.05013689f, -0.10350374f, 0.01827775f, 
    -0.02572891f, -0.03979959f, 0.07911101f, 0.00377263f, -0.14923257f, 0.08524062f, -0.01064691f, -0.00069203f, 
    0.02648085f, 0.13481371f, -0.05533602f, -0.01581305f, -0.39284813f, -0.36661845f, 0.18407497f, -0.08889841f, 
    0.19168952f, -0.06560743f, -0.09838154f, 0.02675390f, -0.22669920f, 0.05265711f, 0.19772370f, -0.09657739f, 
    0.03724033f, -0.14927378f, 0.05139611f, 0.22932220f, -0.07116722f, -0.07790236f, -0.03575039f, 0.12516847f, 
    -0.04883372f, -0.00854910f, -0.02566791f, -0.48497558f, 0.00490230f, 0.09725767f, 0.13349049f, 0.06035995f, 
    -0.10581871f, -0.07876598f, -0.01248248f, 0.11786304f, 0.03834891f, -0.42509559f, -0.01861594f, 0.07761057f, 
    0.06942251f, 0.06963696f, 0.04685508f, 0.06903143f, -0.53165978f, -0.39061213f, -0.04776991f, -0.08095074f, 
    -0.03480918f, 0.10615881f, -0.08520599f, 0.03994673f, -0.55693531f, 0.16678686f, -0.08986107f, 0.27815250f, 
    0.22108608f, -0.02946518f, 0.04548728f, 0.15475051f, -0.33649611f, -0.03538680f, 0.06226100f, -0.01190361f, 
    0.04875687f, 0.25189546f, 0.12277806f, -0.00685810f, 0.16173953f, -0.00699981f, -0.37950116f, -0.08574558f, 
    -0.02552154f, -0.06331787f, -0.03015667f, -0.00225426f, -0.21264066f, -0.20859835f, -0.19508617f, -0.07672375f, 
    0.15932567f, -0.52873373f, 0.02411713f, 0.09134788f, 0.16546145f, -0.08511776f, -0.37247846f, -0.02711676f, 
    -0.01884363f, 0.04169216f, 0.13974224f, 0.15628438f, -0.54788005f, -0.06276926f, -0.13519011f, -0.00233110f, 
    -0.05261680f, -0.06527316f, -0.00610927f, -0.00257319f, 0.11791863f, 0.05768267f, 0.05061531f, 0.16422570f, 
    0.26720744f, -0.27941605f, 0.18977413f, 0.05480314f, -0.08104251f, 0.23791306f, -0.27791566f, 0.17005482f, 
    -0.09316090f, -0.18454830f, -0.00339578f, -0.04381399f, -0.01154489f, 0.04748276f, -0.11130071f, -0.07697967f, 
    0.05920686f, -0.03920804f, -0.04437179f, 0.09979343f, -0.21400878f, 0.01010526f, 0.23142217f, -0.03278876f, 
    -0.06725902f, -0.01236484f, 0.03638435f, 0.09823097f, -0.13699290f, 0.07194488f, 0.15753768f, 0.04470543f, 
    0.06303380f, 0.06237042f, -0.04823091f, 0.04484402f, 0.08753470f, -0.07413570f, 0.09998385f, 0.01154366f, 
    -0.38623783f, 0.09782281f, -0.10743859f, -0.23736574f, 0.03277273f, 0.04465777f, -0.15498777f, 0.15682621f, 
    0.02624437f, -0.05594938f, 0.24903192f, 0.02160160f, -0.03178602f, -0.01220390f, -0.23023176f, -0.36952242f, 
    0.08643284f, -0.02106513f, -0.05191541f, -0.08029518f, 0.05328336f, 0.00233454f, -0.00282455f, 0.04705074f, 
    -0.29035491f, 0.13498047f, -0.04665467f, -0.24927449f, -0.15318112f, -0.30700722f, -0.01648448f, -0.06887336f, 
    0.05462880f, -0.06226034f, -0.03022598f, 0.06802192f, 0.04662138f, -0.15694840f, -0.07831156f, -0.16195345f, 
    -0.31930298f, 0.05693697f, -0.36504453f, 0.20306428f, 0.20054601f, -0.05511387f, 0.08047761f, -0.05514127f, 
    0.04205059f, 0.15706861f, 0.01139415f, 0.21344936f, -0.03079678f, 0.00573841f, -0.17109624f, -0.06165921f, 
    -0.01885078f, -0.02200245f, -0.06009530f, -0.04997257f, -0.20733160f, 0.10237997f, -0.08090190f, -0.06461540f, 
    0.02052319f, -0.01172486f, 0.00292467f, -0.10742690f, 0.23303783f, -0.00151944f, 0.01735203f, 0.05604114f, 
    0.03752590f, 0.01869245f, 0.06421974f, -0.00478572f, 0.34560889f, -0.04947776f, 0.09108940f, 0.02444156f, 
    -0.04817463f, 0.10631224f, -0.07088275f, -0.08428610f, 0.14614697f, 0.04397705f, -0.05103110f, -0.14200462f, 
    -0.04012411f, -0.13447356f, -0.42170832f, -0.09672387f, -0.07519078f, 0.07850024f, -0.15979117f, 0.17551166f, 
    0.06732524f, 0.13733673f, -0.07916068f, -0.30461827f, 0.08934357f, -0.03712346f, -0.24954776f, -0.05168386f, 
    -0.07979785f, 0.20170285f, -0.04638146f, -0.25019199f, 0.06494033f, 0.04610564f, -0.07603366f, -0.02049490f, 
    0.03495270f, -0.02033519f, -0.03399654f, 0.03782240f, 0.07342888f, 0.18562223f, 0.01681088f, 0.00559021f, 
    -0.09961075f, -0.05758622f, 0.15691349f, -0.05151035f, 0.08631496f, 0.04310813f, -0.00519408f, -0.08701122f, 
    0.03784535f, -0.04742410f, -0.05552484f, -0.16757624f, 0.04273034f, -0.02644112f, -0.36848140f, 0.06018767f, 
    0.01206692f, -0.04396793f, -0.59227329f, 0.09230475f, 0.00155340f, 0.03300387f, -0.07472790f, -0.45684022f, 
    0.17237924f, -0.11705307f, 0.10488535f, 0.18328096f, -0.02489979f, 0.08230868f, 0.03936043f, -0.48246583f, 
    -0.01105646f, 0.09660303f, 0.05530671f, -0.60325259f, -0.30520210f, 0.15902866f, 0.00511287f, 0.05603115f, 
    0.02736557f, -0.02748757f, -0.04881417f, -0.01533392f, 0.25978032f, 0.20177604f, -0.04514692f, 0.34134740f, 
    -0.44745308f, -0.00153681f, -0.10766273f, 0.11120770f, -0.09328479f, -0.08930792f, 0.17978482f, -0.04291645f, 
    0.01886196f, 0.29257175f, -0.23201816f, -0.32020992f, 0.02906506f, -0.00219497f, 0.07182309f, -0.37202206f, 
    -0.01813089f, 0.07873093f, 0.11217713f, -0.31935462f, 0.14446789f, -0.25955936f, 0.25877163f, -0.17650624f, 
    -0.75435156f, 0.07720757f, -0.02169419f, -0.28108996f, -0.04340667f, 0.01345908f, 0.15907666f, 0.00259039f, 
    -0.00885269f, -0.05805848f, -0.32903349f, 0.20366684f, 0.29273751f, -0.07012571f, -0.01642698f, -0.09123147f, 
    0.04727058f, -0.31632629f, 0.06021016f, -0.02268763f, -0.09233908f, -0.06821478f, 0.03979933f, -0.63810009f, 
    -0.01673448f, -0.06384391f, 0.14820656f, -0.23680738f, -0.07144628f, -0.66683662f, -0.33012965f, 0.20520531f, 
    -0.00686508f, 0.13748777f, -0.05282415f, 0.25080162f, 0.14568990f, -0.01093402f, 0.09230947f, -0.10434199f, 
    0.02002772f, -0.25959581f, -0.04404725f, -0.10418080f, -0.47856152f, 0.01109546f, 0.06038686f, 0.02866212f, 
    0.02979812f, -0.34084091f, 0.03735734f, -0.83965832f, -0.00224054f, 0.07763435f, -0.52729064f, -0.03991721f, 
    0.00982184f, 0.05032669f, 0.20603193f, -0.10234056f, 0.04505671f, 0.06864630f, -0.49758017f, -0.00678131f, 
    -0.43170801f, -0.09004067f, 0.00128011f, 0.07256170f, 0.01393831f, 0.02401346f, 0.19853589f, -0.13680211f, 
    0.02999925f, -0.04314908f, 0.13547973f, 0.03445958f, -0.07751066f, -0.06221775f, -0.38261512f, -0.15421495f, 
    -0.09295291f, -0.01152319f, 0.26054180f, -0.43086520f, 0.03313975f, 0.09045339f, 0.07199279f, 0.22447927f, 
    -0.11127049f, 0.30050519f, -0.02076576f, -0.16252738f, 0.24682553f, -0.04375470f, -0.03843734f, 0.05127005f, 
    -0.02797342f, 0.23847096f, -0.00789142f, 0.06124531f, 0.05663853f, -0.58254570f, -0.01183327f, -0.21109359f, 
    -0.00401879f, -0.01127932f, 0.07587592f, 0.16374366f, 0.05496811f, -0.08359225f, 0.09012097f, 0.05766444f, 
    0.05573186f, -0.33667260f, 0.16269070f, 0.08506486f, 0.14003915f, -0.02603160f, 0.12288157f, -0.10923892f, 
    -0.11746775f, -0.06085913f, 0.10271554f, -0.12826253f, -0.25554642f, -0.25051877f, 0.12010111f, -0.06333412f, 
    0.14078300f, 0.01082958f, -0.12292232f, -0.26523221f, -0.48581696f, 0.05996243f, 0.19120269f, 0.07982808f, 
    0.00350377f, -0.00451082f, 0.09626880f, -0.20503481f, 0.15307528f, 0.06762755f, -0.29533863f, 0.05921721f, 
    0.01974766f, 0.14519167f, -0.01034793f, 0.05479396f, 0.18363163f, -0.03910613f, -0.06014638f, 0.15238708f, 
    0.22521721f, -0.08184842f, 0.05144125f, 0.12529656f, -0.04072643f, 0.21151403f, 0.07307243f, -0.18039848f, 
    -0.05486230f, -0.66310883f, -0.07893009f, -0.41883656f, -0.00532660f, 0.05119377f, -0.58011824f, 0.01757636f, 
    -0.06112956f, 0.15574765f, 0.03994687f, -0.13773166f, 0.34589341f, 0.19263582f, -0.49557671f, 0.07126194f, 
    -0.08589515f, 0.06977896f, -0.05264467f, 0.46083722f, -0.24565817f, -0.65902054f, 0.10141246f, 0.02024113f, 
    0.07794639f, 0.01575135f, -0.51977593f, -0.03211195f, 0.20220655f, -0.01519104f, 0.16784020f, 0.00118461f, 
    0.11953998f, 0.13038275f, 0.07077176f, 0.15672554f, 0.00719667f, -0.02867567f, 0.15372656f, 0.11299485f, 
    -0.68661916f, -0.02421235f, -0.66322941f, 0.06822300f, -0.04716546f, -0.02032699f, -0.01198466f, -0.10224995f, 
    -0.19288453f, -0.07136446f, -0.36340225f, 0.14352162f, 0.03041622f, -0.34053883f, -0.00855545f, -0.37098435f, 
    -0.34168407f, -0.17880784f, -0.02767737f, 0.26920828f, 0.17884418f, -0.73425835f, 0.03805242f, -0.05364125f, 
    0.04039362f, -0.33581549f, 0.00780643f, 0.02772582f, -0.20066200f, -0.11876233f, 0.05205060f, 0.13684765f, 
    0.05786718f, -0.05833593f, -0.18743080f, 0.05602745f, -0.79151446f, 0.20052966f, 0.03687572f, -0.06697854f, 
    -0.06274715f, 0.12294161f, -0.76330346f, 0.11762790f, -0.02969478f, -0.06366078f, -0.16033900f, -0.23735532f, 
    0.07378831f, -0.07637308f, -0.73331189f, 0.21877605f, 0.16473730f, 0.12787995f, -0.14483570f, 0.00059779f, 
    -0.21182868f, -0.75592458f, 0.03549753f, 0.00421184f, 0.06417628f, 0.03187434f, -0.09516784f, 0.06520095f, 
    -0.05237750f, 0.09974105f, -0.09283582f, -0.65832162f, -0.02375892f, 0.02460692f, -0.33364946f, 0.06408326f, 
    0.08102915f, 0.04151722f, -0.06942783f, -0.04015077f, 0.06934958f, 0.02122638f, 0.05663715f, -0.44577655f, 
    0.05832740f, 0.21666044f, -0.37829837f, -0.05628639f, 0.04631529f, 0.05576910f, 0.30499074f, -0.10887843f, 
    0.06707345f, -0.15841530f, 0.06417678f, -0.27144289f, -0.56473345f, -0.01742152f, 0.01221641f, 0.08214178f, 
    -0.07275102f, -0.10378581f, -0.05959614f, 0.11856560f, 0.11018257f, -0.52207607f, -0.33181372f, 0.02323851f, 
    0.01819716f, 0.16383941f, -0.01717207f, 0.31456137f, 0.04215186f, -0.25304094f, -0.11274233f, -0.11836074f, 
    -0.30398223f, -0.00314905f, -0.50331736f, -0.09294078f, -0.05310537f, -0.01372677f, -0.07516878f, 0.05877288f, 
    0.21285656f, -0.39672476f, 0.02750299f, -0.46326417f, 0.02260419f, -0.04854745f, 0.45993245f, -0.22608292f, 
    -0.02786173f, 0.01006779f, 0.11987957f, 0.08547100f, -0.02633289f, -0.03925895f, -0.22315860f, 0.23481959f, 
    0.02075285f, -0.04245395f, -0.77180451f, -0.16837095f, 0.03014709f, 0.12706701f, 0.03487792f, -0.17692077f, 
    0.19591321f, 0.21160869f, 0.05833128f, -0.12045201f, 0.21054643f, -0.01109345f, 0.00593715f, -0.04531936f, 
    -0.02725304f, 0.07903565f, -0.06111747f, 0.04172909f, 0.08116574f, 0.36050287f, -0.01182173f, 0.19581975f, 
    -0.12169436f, 0.03314904f, 0.19256385f, -0.44258603f, -0.35501394f, 0.07486007f, -0.13455486f, 0.03162149f, 
    -0.00408472f, 0.07145668f, 0.23660630f, -0.60332495f, -0.68775988f, -0.04470396f, 0.18143860f, -0.22500636f, 
    -0.05196881f, -0.05189592f, -0.06839609f, -0.25911468f, 0.08451580f, -0.11062354f, 0.06311753f, -0.31008294f, 
    0.03318386f, -0.07105004f, 0.04515858f, 0.29111418f, -0.40251908f, -0.03677420f, -0.02615396f, 0.01143354f, 
    0.02768036f, 0.14114226f, -0.02624007f, 0.14973207f, -0.04158256f, -0.06821407f, 0.00156433f, -0.00650846f, 
    -0.07480987f, -0.28055707f, -0.02782677f, 0.01785618f, 0.13640717f, 0.08025626f, -0.03941184f, -0.36501977f, 
    -0.15418631f, 0.02843235f, 0.15173587f, 0.27051750f, 0.05050781f, 0.05317915f, 0.08032009f, -0.46662781f, 
    0.06144794f, -0.08930519f, 0.03356794f, 0.01379730f, 0.13077666f, 0.01483790f, 0.31072915f, -0.01419585f, 
    -0.05084688f, 0.01194629f, 0.06107223f, -0.34339118f, 0.30426472f, 0.23873493f, -0.03731278f, 0.05739173f, 
    -0.03243500f, 0.08296805f, 0.02219691f, 0.05968840f, 0.02884292f, -0.10345926f, 0.24600446f, -0.08162582f, 
    -0.38881361f, -0.02173897f, 0.09282640f, -0.07588974f, 0.29625463f, 0.04860936f, -0.33631140f, 0.03077832f, 
    -0.13129148f, 0.18327466f, 0.00189468f, -0.43305829f, 0.08599358f, 0.03109126f, 0.15164506f, -0.42738539f, 
    -0.04674668f, 0.02967236f, 0.16304609f, 0.25030348f, 0.02346310f, 0.03037052f, 0.14044447f, -0.26674932f, 
    -0.26200968f, 0.03451997f, -0.17589828f, -0.01998608f, -0.04413817f, 0.13412166f, -0.00643658f, -0.12528923f, 
    0.01329358f, 0.01553076f, -0.01620863f, 0.19282822f, -0.06524083f, 0.12823893f, -0.03459197f, 0.04433558f, 
    -0.01802103f, -0.52965170f, 0.01920093f, -0.01301004f, 0.20897636f, -0.34695137f, -0.09924309f, -0.67500049f, 
    -0.78474003f, 0.04732930f, -0.05747073f, -0.33847982f, 0.02955335f, -0.00974112f, 0.10591620f, 0.00207585f, 
    -0.04175899f, -0.04235395f, 0.09221375f, 0.19944657f, 0.04432374f, 0.03890279f, -0.21529889f, -0.15802769f, 
    0.08139057f, -0.00851362f, 0.01447380f, 0.08402532f, 0.04001115f, 0.07636135f, -0.40804794f, 0.04759548f, 
    -0.15129173f, 0.23102024f, -0.02535319f, -0.41563377f, -0.38237786f, 0.03340577f, 0.18564913f, -0.04922853f, 
    -0.01101962f, -0.24524912f, 0.13122211f, -0.06588001f, -0.05051591f, -0.01226600f, -0.09251662f, -0.04785123f, 
    -0.07198944f, 0.13826899f, -0.08587093f, -0.04409624f, -0.18821216f, -0.07801127f, 0.08193567f, 0.11851194f, 
    -0.41897032f, 0.28986534f, 0.08631691f, -0.07629056f, 0.03227277f, 0.00001035f, 0.31363413f, -0.45202512f, 
    -0.01725409f, 0.11420419f, -0.02011982f, -0.56928313f, -0.20451845f, -0.00491805f, -0.16773289f, -0.04003346f, 
    -0.00638131f, 0.04231964f, -0.01662820f, 0.25882608f, -0.35971689f, -0.18441372f, 0.19756979f, 0.03232708f, 
    -0.02350974f, 0.16032575f, -0.04507966f, -0.01737758f, -0.32726926f, -0.17303552f, -0.15710160f, 0.05232769f, 
    0.05278108f, -0.02679750f, -0.49610385f, -0.03217075f, 0.09029505f, 0.03198413f, -0.04816155f, -0.01405281f, 
    0.03611024f, 0.07922216f, -0.00988630f, 0.10314743f, 0.05337347f, 0.02450584f, 0.18853952f, -0.00783575f, 
    0.12767974f, -0.05299634f, 0.12154049f, -0.32059574f, -0.04046617f, 0.05931707f, 0.17081761f, 0.27750158f, 
    0.08330020f, -0.00579701f, -0.09595947f, -0.19477889f, -0.02700859f, -0.10001286f, -0.02064459f, 0.01870972f, 
    0.15751101f, 0.05324952f, -0.08829331f, -0.15117864f, -0.15161319f, 0.27504975f, 0.04700724f, 0.04143447f, 
    -0.05439847f, 0.13652933f, -0.06572013f, -0.08418635f, -0.01408330f, 0.16250092f, 0.00403506f, -0.01765722f, 
    0.12083541f, 0.02862654f, -0.20035623f, -0.11096022f, -0.09063683f, -0.55610311f, -0.18356910f, -0.09575913f, 
    -0.08396381f, 0.14322670f, 0.03336101f, 0.01071966f, 0.00761132f, 0.00303942f, -0.26325938f, 0.12525076f, 
    0.06426168f, -0.07377113f, 0.21667381f, -0.19620651f, 0.20123705f, 0.52120966f, 0.29613858f, 0.15018249f, 
    0.21194883f, 0.28432304f, 0.04619669f, 0.23353535f, 0.07708690f, 0.04758165f, -0.68569702f, -0.09085629f, 
    -0.01828085f, -0.25962657f, -0.20212568f, -0.13527118f, -0.28933626f, 0.08372875f, -0.39461750f, 0.03825637f, 
    0.06483407f, 0.17105222f, 0.04582239f, 0.04485329f, 0.12925427f, 0.06835303f, 0.03610534f, 0.24221727f, 
    0.03456207f, -0.31761369f, -0.20758213f, -0.44150057f, 0.01687184f, -0.21849716f, -0.46811685f, -0.25578746f, 
    0.05255534f, -0.08207777f, 0.05273066f, 0.13913040f, 0.04189063f, 0.02394332f, 0.32694942f, -0.01232127f, 
    0.01260404f, -0.05387795f, -0.07614676f, 0.10588001f, 0.18550108f, -0.04165325f, -0.11085091f, 0.06386670f, 
    0.02774612f, 0.01180328f, -0.02553343f, -0.36944968f, -0.08226299f, 0.14037207f, -0.63064975f, 0.00578129f, 
    0.13315511f, 0.04447994f, -0.09583852f, -0.01784776f, -0.13182092f, -0.02840444f, 0.08452344f, 0.05091515f, 
    0.14031266f, -0.04393981f, -0.04634444f, 0.03737955f, -0.07329155f, -0.10303420f, -0.19827907f, 0.16836227f, 
    0.10594787f, 0.03616053f, -0.01888674f, -0.32563189f, 0.02537226f, -0.04090673f, -0.30822927f, -0.23549289f, 
    0.13384371f, -0.10827990f, 0.14833802f, -0.04041442f, -0.03659957f, 0.07426446f, 0.04075675f, -0.19345582f, 
    -0.13384494f, 0.15018819f, 0.02315434f, 0.03513295f, 0.20055500f, -0.06211347f, 0.01962331f, -0.06621614f, 
    -0.05705303f, 0.18778786f, -0.09699190f, -0.01389382f, -0.28467482f, 0.24692449f, -0.00809423f, 0.22762334f, 
    -0.21486259f, 0.00416299f, 0.02772302f, -0.19061075f, -0.14495711f, 0.02601577f, 0.20916162f, 0.05700641f, 
    -0.00806219f, -0.58361626f, 0.12120285f, -0.07084211f, 0.00513669f, -0.02934270f, 0.05867215f, -0.20709324f, 
    -0.05265782f, 0.05336492f, 0.17088920f, -0.13420893f, -0.13561876f, -0.66272300f, 0.16316639f, -0.21430840f, 
    0.09701512f, 0.01848986f, 0.04580160f, -0.09561864f, 0.05250298f, 0.07123516f, -0.16558503f, -0.03853429f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01687439f, 0.13528849f, -0.01895271f, -0.08482707f, 0.21569356f, 0.25190014f, -0.09600565f, -0.34118426f, 
    -0.18089803f, -0.06626838f, -0.00396212f, -0.11106057f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
