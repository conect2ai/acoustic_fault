#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78422546f, 0.40829143f, 0.65850824f, -0.03180750f, -0.70799726f, -0.02544436f, -0.49790999f, 0.41208649f, 
    -0.92290348f, -0.29038006f, -0.24557020f, 0.15965448f, 0.06477576f, 0.64451641f, 0.32636708f, -0.12842447f, 
    0.51838225f, 0.15158471f, 0.23539250f, 0.42490309f, -0.47217017f, -0.26233694f, 0.05941543f, -0.10748988f, 
    0.19837077f, 1.07261229f, 0.65351617f, -0.11572783f, 0.10409466f, 0.59928542f, 0.19334611f, 0.31375480f, 
    -0.43218911f, 0.86409277f, 0.64434618f, 0.32939717f, 0.24890848f, 0.05986891f, -0.10053107f, 0.05100158f, 
    -0.28995359f, 0.03738301f, -0.22865069f, 0.13434374f, 0.18960461f, 0.00110360f, 0.17185161f, 0.35328898f, 
    -0.02613636f, 0.05691538f, -0.98676145f, -1.13711393f, -0.90744662f, -0.36436403f, -0.26131985f, -0.67053187f, 
    0.66475254f, 0.78811508f, 0.08150061f, 0.14198416f, 0.14727789f, -0.19112796f, 0.06952141f, -0.08885716f, 
    0.09755490f, -0.01909837f, 0.24967366f, 0.22185171f, -0.12206435f, -0.11444293f, 0.13463803f, 0.05281202f, 
    -0.02197258f, 0.11027976f, 0.07063279f, -1.12398946f, 1.09202540f, 0.26943204f, 0.26045895f, 0.37628776f, 
    -0.01722558f, 0.88037473f, 0.86777073f, 0.13158795f, 0.60044718f, -0.53753525f, 0.08890749f, -0.07956591f, 
    -0.38473168f, -0.10812168f, -0.00180699f, -0.22187102f, -0.42152712f, -0.11023409f, -0.21751215f, 0.05128166f, 
    0.17582390f, 0.01771364f, 0.24083357f, 0.00833434f, -0.40001741f, 0.83076811f, 0.03581143f, -0.96092701f, 
    0.71541011f, 0.57700706f, -0.10567725f, -0.74174803f, -0.52467710f, -0.85778874f, 0.02950354f, -0.31321755f, 
    0.03492624f, 0.18639547f, -0.43475932f, -0.29001594f, -0.11371001f, 0.16282399f, -0.11028998f, -0.25160050f, 
    -0.34474975f, -0.03300950f, -0.20540980f, 0.24397506f, 0.12807807f, -0.37439951f, -0.26885164f, -0.40225205f, 
    -0.56665826f, -0.27381873f, 0.64743418f, -0.43953162f, 0.30917543f, 0.13566777f, -0.64855134f, -0.71058726f, 
    -0.11718339f, -0.08171012f, -0.05355661f, -0.30373946f, 0.19719435f, 0.08337164f, -0.15515222f, -0.13505368f, 
    -0.23662733f, -0.17655848f, -0.07023007f, 0.17824073f, 0.30781159f, 0.45783684f, 0.91365117f, 1.34168804f, 
    0.60897171f, -0.36114824f, -0.72803622f, -0.66100973f, 0.42325526f, -0.39255098f, -0.47952530f, -0.20382917f, 
    0.06657213f, 0.05359319f, -0.17643625f, 0.18471445f, 0.22895180f, -0.14730318f, -0.25865576f, -0.05592758f, 
    0.11863969f, -0.16544701f, 0.03230148f, 0.21376294f, 0.07917123f, 0.16418965f, 0.47496337f, -0.95909643f, 
    -1.13108373f, 0.07801182f, 1.10838091f, 0.70360798f, 0.76047671f, 0.85352606f, 0.11318102f, 0.20456870f, 
    -0.13667765f, -0.18932943f, 0.20082581f, -0.07867253f, 0.27019140f, 0.05007242f, 0.15536658f, 0.19827542f, 
    0.22769120f, -0.08080367f, -0.04875760f, -0.10069018f, 0.18848073f, 0.11536862f, -0.09159233f, -0.20027445f, 
    0.22213367f, 0.14676018f, -1.23227334f, -1.00306082f, -0.09749667f, 0.08564958f, 0.22359467f, 0.80918258f, 
    0.23904251f, 0.27166522f, -0.10027475f, -0.35112792f, -0.03061046f, -0.41040403f, -0.10302877f, -0.27582008f, 
    -0.05055883f, -0.09603079f, 0.34269205f, -0.20523404f, -0.26402032f, 0.13791102f, -0.22590587f, -0.10643991f, 
    -0.00340210f, -0.64883560f, -0.97752726f, -0.61298358f, -0.36009142f, -0.25134796f, -0.23436970f, -0.13716847f, 
    0.18836707f, 0.25869900f, 0.27366927f, 0.68671179f, 0.22906308f, -0.37115720f, -0.05325263f, -0.08116449f, 
    0.08289112f, 0.19470665f, -0.50543362f, 0.17925029f, 0.25714624f, -0.08497501f, -0.32855305f, -0.05620069f, 
    0.22766036f, 0.25946137f, 0.14401002f, -0.51986969f, 0.06992300f, 0.22441407f, -0.28866294f, -0.69974345f, 
    -1.18052638f, -0.26440823f, 0.26858419f, -0.78987604f, -0.42180258f, 0.25941160f, 0.29097554f, 0.05698985f, 
    -0.02353527f, -0.13599649f, -0.28939012f, -0.33308133f, 0.26034668f, -0.13322999f, -0.16090848f, -0.00691362f, 
    -0.18308409f, 0.45855582f, 0.19000627f, 0.85153753f, 0.30185601f, 0.83856767f, 0.90373725f, 0.70086968f, 
    0.69123906f, -0.41651645f, -0.20342995f, -0.58659023f, -0.68655330f, 0.47678989f, 0.12336159f, 0.01246061f, 
    0.36102673f, -0.22188698f, -0.15795077f, -0.20210984f, -0.05771674f, 0.02769356f, -0.14850624f, 0.15614437f, 
    0.37018895f, 0.23181891f, -0.18562123f, 0.21451595f, -0.30278784f, 0.51167357f, -0.04208759f, 0.80311030f, 
    0.17701449f, -0.49375731f, -0.68818676f, -0.45873389f, 0.18332353f, 0.27399868f, -0.15983605f, -0.40881345f, 
    0.33525074f, -0.29404965f, 0.08350162f, 0.29353815f, 0.08093756f, 0.33175275f, 0.56328887f, 0.51576680f, 
    0.21290846f, 0.75557917f, 0.00113142f, -0.26443568f, -0.17205492f, 1.48529243f, 0.01871151f, -0.77553374f, 
    0.89646041f, 0.63498443f, 0.68748116f, 0.27562317f, -0.05999243f, 0.54173291f, -0.07711340f, -0.63421607f, 
    -0.16591968f, -0.01979888f, 0.11846941f, -0.05900988f, 0.06442352f, -0.07723378f, 0.08055983f, 0.17582883f, 
    0.09122133f, 0.13540863f, 0.09009060f, -0.05183263f, 0.00907814f, 0.17185788f, 0.83386642f, 0.93543220f, 
    0.88619453f, 0.65042752f, -0.01746550f, -0.10904070f, -0.32706097f, -0.19258665f, 0.10222893f, 0.29556909f, 
    0.32414412f, 0.26625070f, 0.10454170f, 0.28579906f, -0.04731762f, 0.41436735f, 0.16038762f, 0.44994602f, 
    0.12177139f, -0.05858243f, -0.17335694f, -0.01777205f, 0.01421771f, 0.16935393f, -0.09090018f, 0.80233312f, 
    0.74318528f, 0.29718488f, -0.07979082f, 0.26788458f, -0.86567771f, -0.90062559f, -0.08788564f, 0.00033491f, 
    0.48512551f, -0.13012114f, -0.06360840f, -0.07546715f, -0.42907831f, -0.33318669f, -0.26828063f, -0.22353788f, 
    -0.10077363f, -0.45570633f, -0.16150378f, -0.44901064f, 0.12895656f, -0.20582110f, -0.23370115f, -0.22210781f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00275879f, 0.17626792f, 0.28141993f, 0.12226199f, 0.10464870f, 0.24603006f, 0.26787606f, 0.22299917f, 
    0.00454584f, 0.03300013f, 0.32627311f, 0.06346794f, 0.30030653f, 0.16004902f, 0.33777434f, 0.13768166f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19084404f, -0.41937599f, 0.22173753f, -0.00573497f, -0.18057038f, 0.07177441f, 0.00468471f, -0.02002839f, 
    -0.01330466f, 0.04559518f, 0.26528600f, 0.14138274f, -0.15186515f, -0.18547823f, -0.25501567f, 0.08443121f, 
    0.18351334f, -0.10847785f, 0.06195853f, 0.14216748f, 0.09722775f, -0.05388341f, -0.17719409f, -0.02839904f, 
    -0.41332820f, 0.16593714f, 0.39325413f, 0.06895167f, -0.12286935f, 0.02695913f, 0.09554417f, 0.00644642f, 
    -0.01033165f, -0.00808068f, 0.08320476f, -0.08367960f, -0.61260736f, 0.08892790f, -0.21281967f, -0.06542386f, 
    0.04317249f, 0.10363234f, -0.00893633f, 0.35515374f, -0.06953125f, -0.04265827f, -0.13219181f, -0.23224133f, 
    0.28435928f, 0.17854440f, 0.00531962f, 0.52796376f, 0.15589236f, 0.10226423f, -0.00650079f, 0.02677255f, 
    0.04732614f, -0.04854007f, 0.08052799f, 0.00510059f, 0.17811947f, 0.23667410f, 0.07526836f, 0.09782442f, 
    0.10949735f, 0.05590192f, 0.13012981f, -0.13594046f, -0.08152565f, -0.30029175f, 0.07770023f, -0.08647865f, 
    0.27917647f, -0.32254347f, -0.03087381f, 0.21051596f, -0.07508093f, -0.16644850f, 0.14303324f, -0.11489478f, 
    0.28109825f, 0.11173608f, 0.10272904f, -0.08569739f, -0.34534934f, 0.08964290f, 0.10938949f, -0.36715797f, 
    -0.09142896f, -0.01485089f, 0.01557345f, 0.31580597f, -0.10521422f, 0.01238832f, -0.03143619f, 0.07740642f, 
    -0.03735567f, 0.12539449f, -0.00363142f, 0.54115993f, 0.01896158f, 0.08479239f, -0.10884993f, -0.33957636f, 
    -0.07850696f, -0.02046820f, -0.06001903f, -0.01582956f, -0.02362816f, 0.43893528f, 0.22384797f, 0.27652889f, 
    0.08756758f, 0.12879965f, 0.13613704f, 0.02992624f, 0.08264313f, 0.03957319f, -0.15078659f, -0.07143906f, 
    0.36674523f, 0.29910910f, 0.15287217f, 0.13037030f, 0.02586022f, 0.09257311f, -0.05727924f, -0.06751190f, 
    -0.00551637f, 0.07907313f, 0.12171061f, -0.04593437f, -0.14690897f, -0.10350335f, 0.08542268f, 0.36019814f, 
    0.07738476f, -0.03994747f, 0.00639174f, 0.00269174f, 0.21517281f, -0.12387693f, 0.01645950f, 0.22381860f, 
    -0.02759483f, -0.04419550f, -0.05868256f, 0.09060781f, 0.14146550f, -0.05755239f, -0.20495091f, 0.14682999f, 
    0.30694428f, 0.04983571f, 0.03308768f, 0.05707939f, 0.27348831f, 0.10115790f, 0.01295602f, -0.12587453f, 
    0.12172641f, 0.02651366f, 0.10478748f, -0.06220016f, 0.09961908f, 0.05426096f, -0.03782316f, -0.13483641f, 
    0.01297820f, -0.32357019f, -0.23370965f, -0.13500901f, 0.08146855f, 0.00292328f, -0.03990169f, 0.01973003f, 
    -0.01341251f, -0.14446655f, 0.09475077f, 0.20627058f, 0.18508443f, -0.15507896f, -0.23316784f, 0.01373020f, 
    0.12648427f, 0.09867457f, -0.11010863f, 0.04891007f, 0.13061352f, 0.17532484f, 0.04376607f, -0.08453403f, 
    -0.20375946f, 0.16417634f, -0.29822889f, -0.25848275f, 0.01179541f, 0.10340934f, 0.00355411f, -0.01849095f, 
    -0.07333340f, 0.20912373f, 0.10943445f, 0.23558345f, 0.62249589f, -0.27139795f, -0.06961231f, -0.06413413f, 
    0.07218090f, -0.01556418f, 0.14302194f, -0.12074418f, -0.01013442f, -0.05622246f, -0.23103425f, -0.01157489f, 
    0.21473062f, 0.13503432f, -0.20670499f, 0.54172587f, 0.00465945f, 0.01511419f, -0.08484329f, 0.20073500f, 
    0.24165402f, 0.12094931f, -0.08057595f, 0.00909628f, 0.23549864f, 0.11488366f, -0.06601537f, 0.00484342f, 
    0.02902921f, 0.03834487f, 0.00608793f, -0.06880019f, 0.15911835f, -0.01397309f, -0.05080818f, -0.03609101f, 
    -0.20544679f, 0.10130889f, -0.03191262f, -0.34378600f, 0.13145716f, 0.18798429f, 0.23919618f, -0.23558098f, 
    -0.09735642f, -0.10134118f, 0.18087736f, -0.16431043f, -0.38883713f, -0.24901390f, 0.20363154f, 0.01356848f, 
    0.42284486f, 0.00963095f, -0.04558064f, 0.33159426f, 0.09187549f, -0.10518264f, 0.05089794f, -0.00540072f, 
    0.09496169f, 0.07843941f, -0.08619896f, -0.14602403f, -0.15597826f, 0.18361387f, 0.09329556f, -0.01389975f, 
    -0.07335905f, 0.12674661f, 0.06129010f, 0.17581713f, -0.31862855f, 0.70037651f, -0.22188681f, 0.07633938f, 
    0.01027405f, -0.01599236f, 0.01390190f, -0.18947315f, -0.05922330f, 0.08980780f, 0.05705299f, 0.07874023f, 
    0.55258012f, 0.07514724f, 0.31018010f, -0.29413188f, -0.00494602f, 0.05676549f, -0.23889922f, 0.16924103f, 
    -0.08307886f, -0.00253696f, -0.03450921f, -0.15514366f, -0.03013379f, -0.38086987f, 0.32206681f, 0.20439829f, 
    0.02072716f, -0.02446031f, 0.08844584f, 0.16400073f, -0.07642879f, 0.04178137f, -0.11926036f, 0.28075799f, 
    -0.18043466f, -0.06548452f, -0.00715374f, 0.21542461f, -0.06824473f, -0.13297506f, -0.05788614f, -0.03167741f, 
    -0.23995204f, 0.02231617f, -0.06518308f, 0.05949493f, -0.02946857f, 0.11741363f, 0.11809821f, 0.40267611f, 
    0.13586262f, 0.12460326f, 0.02730882f, -0.11933867f, 0.02788161f, 0.01965593f, -0.10095799f, 0.04959453f, 
    0.01269332f, -0.16865766f, -0.02299321f, 0.10090172f, -0.07106160f, -0.25961721f, 0.10175135f, 0.01045748f, 
    0.25421980f, 0.10405177f, 0.21307600f, 0.17513524f, 0.24221404f, 0.23198223f, 0.03615754f, 0.13194598f, 
    0.26490539f, -0.02008737f, -0.13777912f, 0.06255519f, -0.00003912f, 0.16849178f, 0.03443325f, -0.01469942f, 
    0.00035071f, -0.17085753f, -0.05041744f, 0.05326841f, 0.16243881f, -0.09787254f, -0.04189938f, -0.00728902f, 
    -0.06935634f, -0.11775523f, 0.29942453f, 0.23556913f, 0.25389564f, -0.46303776f, 0.08327602f, 0.05856546f, 
    -0.10197622f, -0.08635128f, -0.00772438f, -0.16607215f, 0.12732495f, -0.10728113f, 0.06480174f, -0.20488277f, 
    0.09247851f, 0.02568158f, -0.39506871f, -0.35286483f, 0.05239912f, 0.04294203f, -0.07102928f, 0.19923730f, 
    0.06575496f, 0.13047941f, 0.07566331f, 0.14575718f, -0.09367086f, 0.11349311f, -0.04787939f, -0.34372494f, 
    0.00050943f, -0.00515956f, 0.17133741f, 0.00770822f, 0.23036043f, -0.04380546f, -0.05017227f, 0.09962247f, 
    0.41444522f, 0.00614642f, -0.08092687f, 0.27329195f, -0.12159614f, -0.22581914f, -0.04533065f, 0.10511938f, 
    -0.01758656f, -0.01557800f, -0.00567294f, -0.09466879f, 0.65043664f, -0.13354546f, -0.25516358f, -0.08844953f, 
    -0.14424203f, 0.06594040f, 0.01661755f, 0.04399393f, 0.03649537f, -0.00120292f, 0.11625057f, 0.20839098f, 
    -0.08092930f, 0.00356182f, -0.15588981f, -0.13849851f, 0.09405618f, -0.04021567f, 0.14130780f, -0.19691987f, 
    0.02311812f, -0.03272656f, -0.05688218f, 0.10620984f, -0.17820430f, 0.05150009f, 0.03540819f, 0.20404245f, 
    0.25888848f, -0.11838492f, -0.15670894f, 0.04821311f, 0.06593257f, 0.08208069f, -0.14269499f, 0.02874797f, 
    -0.72686958f, -0.05400906f, 0.40547290f, -0.10272203f, 0.09695493f, 0.19343495f, -0.00612133f, -0.08417817f, 
    -0.07670770f, -0.09741450f, -0.03776392f, -0.01059720f, 0.30388337f, -0.12189413f, 0.15275533f, 0.03440836f, 
    -0.12176605f, -0.12106086f, -0.02860007f, 0.04525609f, 0.10637516f, 0.07388087f, -0.15774053f, -0.01912084f, 
    0.12762065f, 0.00604340f, 0.02637308f, 0.45475832f, -0.28242004f, -0.13967328f, -0.00319726f, 0.26697806f, 
    -0.06686112f, 0.07255150f, -0.17621222f, -0.07586753f, -0.01566966f, -0.20242104f, 0.24418761f, 0.10462622f, 
    0.10125986f, -0.10410701f, 0.13334045f, -0.03125368f, 0.06866090f, -0.07052931f, 0.04239541f, -0.03469623f, 
    0.09314428f, 0.17740917f, -0.10081047f, 0.02505980f, 0.04836020f, 0.04816696f, 0.08511077f, -0.05521078f, 
    -0.04451740f, 0.09532575f, 0.02367412f, 0.02801157f, -0.20964476f, 0.35439700f, -0.15501444f, -0.17177685f, 
    0.33666474f, -0.07829145f, -0.02839416f, -0.06421394f, 0.08877319f, -0.15547951f, 0.04356358f, 0.11318495f, 
    0.08365923f, 0.06910265f, 0.28027928f, 0.00769557f, 0.03909139f, 0.12665889f, -0.02890491f, -0.05738203f, 
    0.06943657f, 0.09447081f, 0.22125953f, 0.00760719f, -0.58965391f, 0.33240384f, 0.01430211f, -0.30115962f, 
    0.20759888f, -0.02083090f, 0.18145442f, 0.09969911f, 0.08640622f, -0.05099615f, 0.11489975f, 0.08470450f, 
    -0.45418438f, 0.07894704f, 0.15786727f, -0.12043774f, 0.19637072f, 0.20038199f, 0.04531010f, 0.05170761f, 
    -0.06969177f, -0.03942687f, 0.12578052f, 0.05702372f, -0.36753508f, -0.25077787f, 0.10521462f, -0.02973481f, 
    0.05015207f, 0.06920055f, 0.21171921f, -0.14094746f, -0.02605765f, 0.08652052f, 0.06303905f, -0.03884929f, 
    -0.16414136f, 0.18523772f, 0.02061299f, 0.42654133f, 0.00883518f, -0.03869370f, 0.14287229f, 0.14616702f, 
    0.14958614f, 0.02183256f, 0.05427675f, 0.12929653f, -0.16241477f, 0.13008280f, -0.05651778f, -0.29530329f, 
    0.07996199f, 0.08911844f, 0.02791082f, -0.00154895f, 0.25493422f, -0.03846479f, -0.11470208f, 0.00424569f, 
    -0.25242630f, 0.05221529f, -0.20727752f, -0.17321031f, 0.19879800f, 0.15853231f, 0.13904262f, 0.03788996f, 
    -0.03904147f, 0.10974879f, -0.05059944f, 0.16014226f, -0.40525401f, -0.18240951f, 0.19715704f, -0.33695698f, 
    0.12229405f, -0.03735819f, 0.00068720f, -0.04707202f, 0.12540290f, -0.10210116f, 0.02580838f, 0.17222574f, 
    -0.13127646f, 0.24870726f, 0.73367244f, 0.42968148f, -0.08442284f, -0.03615753f, 0.10515549f, 0.01496983f, 
    0.03034080f, 0.02429979f, 0.11743703f, -0.09600880f, 0.40845644f, 0.30717465f, 0.32542378f, 0.41974980f, 
    0.25573391f, 0.14001885f, 0.10904562f, 0.21764161f, -0.02098756f, -0.01514196f, -0.01163030f, 0.06694279f, 
    -0.01054921f, 0.18309140f, 0.18653253f, 0.20376042f, -0.15960054f, -0.08917305f, -0.09690274f, 0.07211597f, 
    -0.10473134f, -0.05371364f, 0.04008219f, -0.03947774f, -0.46646380f, 0.54496980f, 0.07117610f, 0.14102560f, 
    0.36419636f, 0.04288286f, 0.08686180f, -0.02347812f, -0.09067471f, 0.06524093f, 0.11508846f, -0.16485988f, 
    0.09165423f, 0.15524341f, 0.22634330f, -0.26858896f, 0.23795596f, 0.07942171f, 0.19120808f, 0.09213755f, 
    -0.03422347f, 0.08492831f, -0.08426947f, 0.13595663f, -0.14386074f, -0.04237403f, -0.34938699f, 0.00877931f, 
    0.03471602f, 0.02719163f, 0.01428966f, -0.09007705f, -0.00602576f, 0.17527971f, 0.08942833f, -0.21264073f, 
    0.46885964f, 0.11298692f, 0.21377161f, 0.37080243f, -0.12181946f, -0.12231568f, -0.12053785f, -0.21428967f, 
    0.00496838f, -0.14190491f, -0.10483253f, 0.10652115f, 0.18779919f, -0.23064472f, -0.14765586f, -0.06479420f, 
    -0.05133901f, -0.10721762f, -0.00308925f, -0.07269359f, -0.29890794f, 0.02366969f, -0.06136239f, 0.10584537f, 
    0.16860814f, 0.11152786f, 0.05800127f, -0.06102847f, -0.13946503f, 0.10503644f, 0.02654023f, -0.07834414f, 
    -0.15689826f, 0.03979038f, 0.05123879f, 0.06031981f, -0.08046433f, 0.47894588f, -0.11733972f, -0.11457691f, 
    0.15045986f, 0.00765321f, 0.15200533f, -0.04937162f, 0.05860399f, 0.05975962f, -0.00135634f, 0.04683661f, 
    -0.02448543f, -0.01797757f, -0.26769191f, -0.16935867f, -0.12618726f, 0.01274707f, 0.11949232f, 0.09764396f, 
    -0.17588194f, -0.02614442f, -0.04356433f, 0.03748469f, 0.39669308f, -0.06652763f, -0.06322721f, 0.41674292f, 
    -0.17999204f, -0.03815228f, -0.07959432f, -0.07463458f, -0.05888524f, 0.01776971f, 0.22256008f, 0.02364204f, 
    0.20254803f, 0.07555742f, 0.00857425f, -0.15403843f, -0.10377818f, -0.04133919f, -0.19232412f, 0.03291303f, 
    0.00550999f, -0.06201859f, -0.08046121f, -0.04176645f, 0.30167699f, 0.26074561f, 0.17966045f, -0.03947223f, 
    0.02726684f, 0.05553240f, 0.05027594f, 0.10474640f, -0.04239637f, -0.10622772f, 0.06932619f, -0.05665999f, 
    -0.65679651f, 0.11553828f, -0.02615931f, 0.05010220f, 0.32857671f, -0.03280757f, 0.04020150f, 0.05479819f, 
    0.03556069f, -0.14964846f, 0.02550996f, 0.01213477f, 0.56877893f, -0.18230323f, 0.02513559f, 0.21652064f, 
    -0.01551380f, 0.00804067f, 0.23048748f, 0.05644438f, -0.10058451f, 0.12284182f, 0.05897983f, 0.06944124f, 
    -0.52294427f, -0.03799280f, 0.05154382f, 0.08504519f, -0.08055242f, -0.15650173f, 0.04599554f, -0.16522971f, 
    0.10950826f, 0.02000407f, 0.16754700f, 0.14938809f, -0.23363447f, 0.09365592f, -0.15885088f, -0.04724550f, 
    0.03300841f, 0.01037845f, -0.12387139f, -0.05089842f, 0.09944249f, 0.10968763f, 0.13610026f, 0.04874916f, 
    0.66269004f, 0.10054675f, 0.23406014f, 0.29799750f, 0.05503938f, -0.01904784f, -0.13468401f, -0.14043650f, 
    0.04120550f, 0.00418151f, 0.01485251f, 0.02880750f, -0.24177569f, -0.06755078f, 0.05003413f, -0.14151262f, 
    0.17444329f, 0.04707147f, 0.04362746f, 0.13823152f, 0.24127874f, -0.01766567f, -0.03707314f, 0.09647294f, 
    -0.36913812f, -0.04352876f, -0.10444753f, 0.08952647f, 0.24689296f, 0.05172652f, -0.03513095f, 0.04480368f, 
    0.06291444f, 0.14211321f, 0.18188578f, 0.08800136f, -0.29334769f, -0.10874427f, -0.23129073f, 0.12146506f, 
    0.22973342f, 0.20776595f, 0.09168718f, -0.08233111f, 0.03947248f, 0.11762860f, -0.15384887f, -0.26397529f, 
    -0.12986742f, -0.14069115f, -0.36969873f, -0.09936494f, -0.06289085f, -0.02091394f, 0.02191324f, 0.04702436f, 
    -0.01958091f, -0.04464736f, 0.19260855f, -0.05528549f, 0.35105646f, 0.36031485f, 0.18537708f, -0.05439417f, 
    0.08741305f, -0.10234347f, -0.02365811f, -0.05202659f, -0.00902602f, 0.01924633f, 0.21681038f, 0.02979639f, 
    -0.05606907f, -0.15986437f, 0.15178892f, -0.00083401f, -0.10493142f, -0.04178951f, 0.05467603f, 0.01617074f, 
    0.05946885f, -0.08221564f, -0.10159958f, -0.19857578f, -0.03986263f, 0.33259553f, 0.03455497f, 0.05595608f, 
    0.09608366f, -0.04329752f, 0.16100977f, -0.04294976f, -0.02670094f, -0.06332675f, -0.04382453f, 0.20406184f, 
    0.60559809f, 0.60038966f, 0.18183929f, -0.14249784f, 0.05443794f, 0.09109373f, -0.09176888f, 0.12036837f, 
    0.10073079f, -0.02323435f, -0.08561294f, 0.00586801f, -0.09882812f, 0.10041746f, 0.34189987f, -0.13172959f, 
    -0.21209985f, -0.00217004f, -0.09749354f, 0.06581943f, -0.05811372f, 0.12646975f, 0.22241275f, 0.02333849f, 
    0.00086297f, 0.06395729f, -0.05801180f, -0.02974162f, 0.01057019f, 0.01207906f, -0.01433571f, -0.05185515f, 
    0.03001736f, -0.04239939f, 0.05388242f, 0.04882903f, 0.05081725f, -0.06207886f, 0.00309526f, 0.03253230f, 
    -0.08216604f, -0.02157421f, -0.00035497f, 0.00243996f, -0.02379364f, -0.05842159f, -0.07534935f, -0.02159120f, 
    0.00187184f, -0.04547566f, 0.01386291f, -0.07424001f, 0.02698376f, 0.04290368f, -0.07174812f, 0.03375407f, 
    0.03706586f, -0.03456541f, -0.04335632f, 0.00326797f, 0.00647588f, -0.03195264f, 0.03215675f, -0.07191888f, 
    -0.01542635f, -0.06179886f, 0.03764627f, 0.05793157f, -0.05409437f, 0.00292514f, 0.02069392f, 0.03838284f, 
    0.01094580f, 0.06190707f, -0.03834681f, -0.07162805f, 0.02514869f, 0.04236659f, 0.01175506f, 0.01449465f, 
    -0.07803168f, 0.04106659f, -0.02434887f, -0.02680451f, -0.03194181f, 0.02092220f, -0.01864599f, 0.01892791f, 
    0.06369133f, -0.03600434f, -0.03686494f, -0.08549079f, -0.02633141f, -0.05795582f, 0.03084671f, -0.06831187f, 
    -0.04477470f, 0.01246129f, 0.01377291f, -0.06672113f, 0.03665362f, -0.01686030f, 0.00325142f, -0.00779040f, 
    -0.02631552f, 0.00746360f, -0.00147550f, -0.07971363f, -0.03163566f, 0.02910601f, 0.04840868f, -0.08218362f, 
    -0.02898186f, 0.05818279f, 0.02971886f, -0.05341358f, 0.01921692f, -0.05568506f, -0.05748568f, 0.01382526f, 
    0.01506418f, -0.03325149f, 0.03989825f, -0.04574146f, -0.00790059f, -0.03016088f, 0.03640277f, -0.03089151f, 
    -0.07135442f, -0.06499052f, -0.08889002f, 0.07513041f, 0.02361568f, -0.01661341f, -0.02802445f, -0.03986010f, 
    0.00182794f, 0.03609278f, -0.07771710f, -0.08488633f, -0.00382002f, 0.02596201f, 0.06014112f, -0.05399115f, 
    -0.04497469f, 0.00769099f, 0.00214529f, -0.07520675f, 0.02887210f, 0.03169784f, 0.05860388f, -0.06232907f, 
    0.04086450f, -0.02535395f, -0.06257766f, 0.03683314f, -0.05339269f, 0.01981159f, 0.04164977f, -0.07212339f, 
    0.05623975f, -0.06365824f, -0.02899001f, -0.06397978f, 0.01158612f, -0.02928192f, 0.02870595f, 0.03217173f, 
    -0.07222195f, -0.00469091f, 0.02864928f, -0.03245518f, 0.00789701f, 0.05757870f, -0.00780696f, -0.01398940f, 
    0.03395499f, 0.05884011f, 0.03605928f, -0.02343968f, -0.06530724f, 0.01203929f, -0.05854557f, -0.04377093f, 
    -0.03738068f, 0.02341624f, -0.05334558f, -0.03858202f, -0.01499554f, 0.05254107f, 0.03651033f, 0.02961380f, 
    0.04612939f, -0.02547929f, 0.00159909f, -0.07061281f, -0.02829441f, 0.01178600f, 0.05342906f, -0.03970924f, 
    -0.02077546f, -0.03736687f, 0.02576512f, -0.06713536f, 0.03893717f, 0.05169260f, -0.03864993f, -0.00698281f, 
    0.01771563f, 0.01108357f, 0.02943613f, -0.01003664f, -0.03015171f, -0.06627735f, 0.00984674f, -0.05367727f, 
    0.01457832f, 0.05882823f, -0.05711345f, 0.02591122f, -0.03836202f, 0.02664050f, 0.04192989f, 0.04465785f, 
    -0.01703342f, -0.01264883f, -0.03662539f, 0.00244046f, 0.02942573f, 0.04085212f, -0.03448208f, -0.01551177f, 
    0.01883998f, -0.06391186f, -0.01108794f, -0.02876865f, 0.01541688f, -0.04144718f, 0.01397921f, -0.05626437f, 
    -0.04745793f, -0.01299510f, 0.02963636f, -0.08184554f, -0.05555176f, 0.00565477f, -0.07439213f, 0.05830867f, 
    0.05769794f, -0.03490448f, -0.01495868f, -0.01320104f, -0.03808031f, 0.03952709f, 0.05350390f, -0.07323845f, 
    -0.04154800f, 0.00305023f, -0.06423560f, -0.06267776f, -0.05948091f, -0.03508849f, 0.04482886f, -0.03921090f, 
    -0.04409233f, 0.05812938f, -0.03833555f, 0.03641777f, -0.06348116f, -0.06087578f, -0.06379081f, -0.07980703f, 
    0.01576687f, -0.02192913f, 0.01742373f, -0.05828558f, -0.01006020f, 0.02718370f, -0.03567801f, -0.08040912f, 
    -0.06271056f, -0.01728455f, -0.04406643f, -0.07206400f, -0.04278857f, -0.05719795f, 0.04224664f, 0.03048838f, 
    0.05452475f, 0.03654463f, -0.02569990f, 0.01445237f, -0.04997538f, 0.04581066f, 0.03129669f, -0.00540944f, 
    -0.08075733f, 0.02702912f, -0.07965561f, 0.03566295f, -0.01694499f, 0.05533679f, -0.07938619f, -0.02541745f, 
    0.01973984f, 0.01481635f, -0.03762836f, 0.03052834f, -0.04404056f, -0.05456769f, 0.00183708f, 0.05840882f, 
    -0.01532580f, -0.05718623f, -0.02030816f, 0.05063606f, -0.00830456f, 0.01799310f, 0.00523443f, -0.06851753f, 
    -0.04375387f, -0.03184309f, 0.05948097f, 0.00387815f, 0.00512550f, -0.05729891f, 0.04142151f, -0.04461271f, 
    0.01387999f, 0.01961676f, 0.03418621f, -0.07859793f, -0.02076512f, 0.01481001f, 0.00256407f, 0.05908576f, 
    0.04423754f, -0.06837886f, -0.06859959f, 0.02712097f, -0.04217783f, 0.00085591f, -0.02965341f, 0.05100103f, 
    -0.00804022f, 0.01541646f, -0.00116726f, 0.04232628f, -0.05294323f, 0.00120251f, -0.03529032f, 0.03193892f, 
    -0.05587793f, -0.04480777f, -0.00063466f, 0.03803838f, -0.00571585f, -0.03803338f, -0.03108301f, -0.00832475f, 
    0.00818112f, 0.03771643f, 0.04658112f, -0.07423513f, 0.03136658f, 0.03133145f, -0.03958561f, 0.04686032f, 
    -0.05878581f, -0.03018967f, 0.00146847f, 0.03189489f, -0.01366035f, 0.03262332f, -0.03033698f, 0.00965982f, 
    -0.03702450f, 0.03061240f, -0.00498201f, -0.04071967f, -0.01558515f, 0.02032397f, 0.00938842f, 0.01868173f, 
    -0.07596936f, -0.03767456f, -0.06586447f, -0.04786438f, -0.04683873f, 0.03509836f, -0.00399056f, 0.01471054f, 
    0.02194951f, -0.00778947f, 0.00394367f, 0.02861894f, -0.00110027f, -0.03217195f, -0.05371037f, -0.06909484f, 
    -0.04186214f, -0.06197178f, -0.00927280f, 0.04418312f, -0.01287034f, 0.02915007f, -0.06424743f, 0.06148037f, 
    -0.28714049f, 0.08771878f, -0.11411592f, -0.14791889f, -0.05045441f, 0.14095415f, -0.07561023f, -0.04829464f, 
    0.08829467f, 0.04876740f, 0.24038656f, 0.06758600f, -0.09811185f, -0.45135167f, -0.08295087f, 0.22127947f, 
    0.18672955f, 0.01729914f, 0.03723903f, 0.04312787f, 0.14903459f, 0.12926388f, -0.03598374f, 0.05623249f, 
    -0.17231420f, 0.03799752f, 0.02490446f, -0.06916287f, 0.08150707f, 0.04097472f, -0.16480111f, 0.06719130f, 
    0.02533021f, 0.11036984f, -0.03720175f, 0.08700233f, 0.10435069f, -0.06010232f, -0.01398075f, 0.14807975f, 
    0.07774954f, 0.10799090f, -0.08990388f, -0.03355822f, 0.00838970f, 0.11115479f, -0.22730938f, 0.05479267f, 
    -0.45135853f, 0.01861165f, -0.23465256f, -0.25493899f, 0.01996830f, -0.02948079f, 0.02417186f, -0.05848728f, 
    0.20879793f, -0.02470426f, 0.08192706f, 0.09322637f, 0.13364826f, -0.04290587f, 0.07563653f, -0.28832632f, 
    0.16996361f, 0.16043672f, 0.07725253f, 0.09428002f, 0.20277363f, -0.07461375f, 0.08159035f, 0.10258361f, 
    0.06706578f, -0.06662750f, 0.35760832f, 0.05053789f, 0.05670674f, 0.10777275f, -0.06920445f, -0.12652707f, 
    -0.03358293f, -0.02737372f, 0.03074450f, 0.25882944f, -0.07695140f, 0.48680675f, -0.24382231f, 0.20913944f, 
    0.05326643f, -0.26593000f, 0.01069441f, 0.06875725f, 0.00953894f, 0.06751757f, -0.18059133f, 0.09826853f, 
    -0.01708844f, -0.02945502f, 0.06578881f, -0.01022992f, -0.13383749f, 0.18301022f, -0.05158006f, 0.04964564f, 
    0.05835490f, 0.08349644f, -0.06331062f, -0.17264660f, -0.23889019f, -0.05347506f, 0.03116394f, -0.07993195f, 
    0.13909629f, -0.11459815f, -0.00647261f, 0.06112244f, 0.08731928f, -0.00264961f, -0.17148302f, 0.37856221f, 
    0.08808286f, 0.04074483f, 0.14217436f, -0.06632780f, 0.17522867f, 0.10606033f, -0.03872452f, 0.06764130f, 
    0.02991308f, -0.01670355f, 0.09383955f, 0.07413665f, 0.10628520f, 0.15144891f, -0.19404957f, -0.36231512f, 
    0.10025024f, -0.05028975f, -0.01825747f, 0.10259538f, 0.12568553f, 0.06934893f, 0.05023391f, -0.02723867f, 
    0.12770274f, 0.01796716f, 0.10176712f, 0.06983427f, -0.02844305f, -0.19038126f, 0.00712850f, 0.10421494f, 
    0.15807582f, 0.29923874f, -0.03416177f, 0.07081820f, -0.51574510f, 0.16481446f, -0.02658402f, 0.20642340f, 
    0.15304631f, 0.10057963f, 0.09544795f, 0.07695210f, 0.09058066f, 0.07762820f, 0.16848800f, 0.18089627f, 
    -0.16439527f, -0.05390869f, -0.09744225f, -0.23305464f, 0.17705777f, -0.14509495f, -0.18168883f, -0.05220196f, 
    -0.10558865f, 0.13148636f, 0.08220496f, 0.05949410f, 0.07375492f, -0.05506532f, 0.37944806f, -0.29079738f, 
    -0.05614858f, -0.22459786f, -0.03396748f, 0.06285637f, 0.07208057f, -0.07977404f, 0.10825798f, -0.06230871f, 
    0.00650602f, 0.01114926f, 0.01185884f, -0.07250164f, 0.00814343f, -0.05565775f, 0.01642890f, 0.01544426f, 
    -0.04227150f, 0.06071462f, -0.00686375f, 0.00737695f, -0.03579560f, 0.03891067f, -0.05930326f, -0.00920049f, 
    -0.01950491f, 0.03335460f, 0.01007470f, -0.00337522f, 0.06514227f, 0.01732217f, 0.06298590f, 0.02380546f, 
    0.01124347f, 0.06503094f, 0.02707648f, -0.04106470f, -0.06860324f, 0.05865869f, -0.05847180f, -0.05880098f, 
    -0.02514230f, -0.02022025f, 0.04028501f, 0.05824701f, -0.00346613f, 0.02732139f, -0.05331364f, 0.00352905f, 
    0.04738779f, -0.07349426f, -0.03669006f, -0.04278343f, -0.02316039f, -0.06589619f, -0.02338780f, -0.04572817f, 
    0.04679017f, -0.04367777f, -0.00307025f, -0.07402552f, -0.04940983f, -0.00367144f, 0.04850705f, 0.02023709f, 
    0.02842789f, -0.07336643f, -0.04638688f, -0.00660351f, -0.07036097f, -0.07335596f, -0.03715008f, -0.01384367f, 
    0.06006907f, -0.06745695f, 0.00074323f, 0.03630264f, -0.00594265f, -0.07300764f, 0.05360694f, -0.07610201f, 
    -0.03683411f, -0.02450471f, -0.05367593f, 0.05074051f, -0.01192026f, -0.05024922f, 0.06323767f, 0.00310168f, 
    -0.00391328f, -0.04962700f, -0.07591653f, 0.03418074f, -0.03671941f, -0.02848991f, 0.02497329f, -0.00309205f, 
    -0.01596462f, 0.00684394f, -0.00003533f, -0.03339745f, -0.05657696f, 0.02918332f, 0.02968732f, 0.00416781f, 
    -0.07092647f, 0.05592385f, -0.02599558f, 0.00055877f, 0.00225647f, -0.03505487f, -0.01826566f, 0.00144345f, 
    0.02427466f, -0.03048645f, -0.03480623f, -0.03982021f, 0.05209197f, -0.07560527f, 0.02295588f, 0.00806317f, 
    0.05551704f, -0.05047891f, -0.07729298f, 0.05940766f, 0.04372576f, -0.02589720f, 0.06079344f, 0.00442159f, 
    -0.06008906f, -0.04309264f, 0.02319870f, -0.00362625f, -0.00747414f, -0.01809118f, -0.01520753f, 0.06207469f, 
    -0.08110770f, 0.03327733f, 0.05175828f, -0.05982148f, 0.05127615f, 0.02637627f, 0.01363250f, -0.01494612f, 
    -0.00401866f, 0.00773330f, -0.06359170f, -0.07151377f, -0.02421179f, 0.01958437f, 0.00575412f, -0.03079212f, 
    -0.07580144f, -0.07710166f, 0.01523867f, 0.06781541f, 0.01858558f, 0.04662013f, 0.03317205f, -0.04663122f, 
    -0.04353576f, -0.03197270f, -0.01206392f, 0.04648231f, -0.02271627f, -0.07694472f, 0.03055966f, -0.01073540f, 
    0.00635880f, -0.07371806f, 0.01197839f, -0.00735854f, -0.02854570f, -0.01350160f, 0.01488679f, 0.00678351f, 
    -0.01133536f, 0.00898672f, -0.05720114f, -0.04767048f, -0.06020238f, -0.05090159f, -0.05098709f, -0.06633007f, 
    0.03865024f, -0.03590691f, -0.06909154f, -0.03511970f, 0.03097711f, 0.00371172f, 0.03325056f, -0.01591884f, 
    0.03035017f, 0.05397806f, 0.01849310f, -0.03663801f, 0.01804655f, -0.02407205f, -0.06095709f, -0.06909850f, 
    -0.32765463f, -0.01518755f, 0.20592031f, 0.20722322f, 0.15376739f, 0.18203795f, 0.20084609f, -0.01065701f, 
    0.02703136f, 0.14607127f, -0.06345057f, 0.01983218f, -0.05264528f, -0.38302609f, 0.00377277f, 0.36957371f, 
    0.08669987f, -0.08881693f, -0.11523101f, -0.09805590f, -0.01212966f, 0.25421122f, 0.01250848f, 0.19120324f, 
    0.09109876f, -0.02085483f, -0.16240430f, -0.43082568f, 0.01215004f, 0.10234448f, -0.03698950f, 0.08491908f, 
    0.08416232f, 0.02806761f, -0.06445557f, 0.05997120f, -0.38257453f, 0.48524895f, 0.02635538f, 0.19507816f, 
    0.14148116f, 0.05281066f, -0.15628052f, -0.08853085f, 0.05278214f, -0.03246799f, -0.14776838f, -0.11909010f, 
    0.19608702f, 0.11559023f, 0.08069045f, -0.33703372f, -0.03912302f, 0.00688405f, 0.05416561f, 0.05434863f, 
    0.25728473f, -0.04130092f, -0.04461825f, 0.12614359f, 0.06021479f, -0.23004895f, -0.03596283f, -0.40861043f, 
    -0.24247204f, 0.21004111f, 0.17375538f, -0.12563941f, 0.06084291f, 0.07228938f, 0.00737295f, -0.18037477f, 
    -0.56526762f, 0.30552518f, -0.08158308f, 0.02154531f, 0.07397576f, -0.04204888f, -0.08065231f, 0.11088170f, 
    0.14573565f, 0.04626659f, 0.04617883f, 0.04252496f, -0.06512747f, 0.05360783f, -0.17955527f, 0.00117251f, 
    -0.06066155f, 0.00034229f, -0.02391682f, 0.09861900f, -0.02917708f, 0.02108474f, 0.03048094f, 0.12005640f, 
    0.21010940f, 0.08890945f, -0.22153035f, -0.51803064f, 0.06726584f, 0.10645662f, -0.08630785f, -0.10596211f, 
    0.11216382f, -0.19822544f, -0.05062122f, -0.21166016f, 0.06608265f, 0.18169600f, 0.00469170f, -0.18235318f, 
    -0.21462031f, -0.24814811f, 0.03451791f, 0.01074281f, 0.01071189f, -0.15964143f, -0.17769510f, 0.46582201f, 
    -0.14182557f, -0.14823297f, 0.18544392f, -0.06963622f, 0.26575157f, 0.04328794f, 0.24488308f, 0.07009976f, 
    0.03215737f, 0.09437411f, 0.17801078f, 0.17565055f, 0.05843907f, -0.13821134f, 0.48117951f, 0.44429380f, 
    -0.21689591f, 0.04439052f, 0.07194056f, 0.10370128f, 0.11842402f, 0.05120992f, 0.06784311f, 0.07793732f, 
    0.14614184f, 0.12113968f, -0.06945164f, 0.16392142f, 0.34367168f, -0.11957238f, 0.02330299f, 0.19043082f, 
    -0.05083497f, 0.16619380f, 0.16169640f, 0.25055575f, 0.29587090f, -0.72462779f, 0.15028548f, 0.11675725f, 
    -0.34836170f, 0.08250969f, -0.10441729f, -0.02619137f, 0.11567999f, 0.19725201f, 0.03408401f, 0.12289872f, 
    -0.15385103f, -0.26186088f, -0.10923229f, 0.57486248f, -0.08501531f, -0.08798338f, 0.01457108f, -0.11434394f, 
    0.17886612f, 0.07240734f, 0.13179599f, 0.18630029f, -0.20683101f, 0.20527390f, 0.18384336f, 0.40893757f, 
    0.25263157f, 0.05216971f, -0.06965404f, -0.07845042f, 0.07545971f, -0.15024105f, -0.26594895f, -0.00684304f, 
    0.25197008f, 0.10475349f, -0.16000006f, -0.13069284f, 0.10028616f, 0.09492360f, 0.01428904f, 0.05342750f, 
    -0.08717843f, -0.05564531f, -0.01210959f, 0.00310764f, -0.06015688f, -0.02464185f, 0.12371952f, 0.06073141f, 
    -0.10232572f, 0.10268268f, -0.12144682f, 0.02580664f, -0.14441758f, -0.14652884f, 0.10477545f, -0.03091185f, 
    0.43911430f, 0.17829812f, 0.22392483f, 0.25292152f, -0.01192956f, -0.00295651f, -0.07845271f, 0.07844266f, 
    -0.11251416f, -0.11880038f, -0.01943139f, 0.07606995f, 0.32534456f, 0.20808932f, 0.04106971f, 0.24749893f, 
    -0.00075415f, 0.11348782f, 0.08227879f, -0.02355454f, -0.05269131f, -0.14100456f, 0.14571954f, 0.14476375f, 
    -0.02634056f, 0.28400585f, -0.15128943f, -0.55022556f, -0.07578839f, 0.06197556f, -0.10235883f, 0.16695370f, 
    0.02959935f, 0.00452791f, 0.08265853f, 0.08114617f, 0.09073664f, -0.01373575f, -0.15704259f, -0.03757897f, 
    -0.00413872f, -0.11270984f, -0.11278462f, 0.02577601f, -0.05751009f, 0.04933871f, -0.06262580f, 0.12404921f, 
    -0.41804722f, -0.00786652f, -0.00782091f, -0.39999861f, -0.15633143f, 0.05153203f, 0.18230695f, -0.05277221f, 
    -0.01524663f, 0.01729923f, 0.05256942f, -0.15938902f, 0.09475151f, -0.40834126f, -0.05094589f, 0.03701075f, 
    -0.19333600f, 0.29657030f, -0.05840903f, 0.01141211f, 0.05689882f, 0.09504737f, -0.12549740f, -0.00252754f, 
    0.02812283f, 0.07364412f, -0.06985155f, -0.03465249f, -0.14187016f, -0.13336739f, 0.19733115f, -0.02962599f, 
    0.07507227f, -0.02882386f, 0.24699374f, 0.04871603f, 0.25345951f, 0.20940112f, 0.14659069f, 0.29364675f, 
    -0.06629979f, -0.09705153f, 0.04934816f, 0.32872730f, -0.05669533f, -0.02459130f, 0.36369985f, -0.04659177f, 
    -0.02124676f, -0.17200546f, 0.08680326f, 0.19962971f, -0.04273606f, 0.15637009f, 0.00224525f, -0.01857207f, 
    0.12453394f, 0.17446809f, -0.12489050f, -0.03575722f, -0.20684753f, 0.15466213f, 0.18516231f, 0.10944600f, 
    0.06761806f, 0.12007371f, -0.14349872f, -0.07497396f, -0.09625742f, 0.13379256f, -0.00937623f, -0.15007418f, 
    -0.00026540f, -0.06456375f, -0.19932297f, 0.31634626f, 0.16477427f, 0.27265799f, -0.21099271f, -0.15240015f, 
    0.13202737f, -0.22489211f, -0.02267343f, -0.01355295f, 0.52463198f, 0.04351197f, -0.14861411f, 0.20612898f, 
    -0.12059585f, -0.04498444f, 0.02004747f, -0.05565514f, -0.04170159f, -0.03612445f, -0.01173205f, -0.13962881f, 
    -0.14215642f, -0.15158944f, 0.00930592f, 0.25898013f, -0.23840354f, -0.07420794f, -0.01708872f, 0.12046868f, 
    0.03442719f, 0.16937722f, 0.02345754f, -0.25569800f, 0.02445673f, -0.25609660f, -0.05305644f, -0.08893690f, 
    0.10523387f, -0.11814792f, 0.15141839f, 0.01917536f, -0.13027658f, 0.22780819f, -0.03071688f, 0.08914068f, 
    -0.04667018f, -0.05163926f, 0.01045202f, 0.02956107f, 0.01520605f, -0.07038885f, -0.00085946f, -0.01040854f, 
    -0.02226778f, -0.04592230f, 0.05588502f, 0.01439473f, 0.02971274f, -0.01930729f, 0.03923960f, 0.02204650f, 
    -0.04050899f, 0.03305873f, -0.07158185f, -0.00792514f, 0.04967184f, 0.05089495f, 0.03977127f, -0.06693772f, 
    0.03604014f, -0.01521493f, -0.06346004f, -0.05063223f, 0.03583499f, 0.05547351f, 0.01582976f, -0.07579801f, 
    -0.01939140f, -0.01286659f, 0.02594602f, -0.06757552f, 0.02130151f, 0.00104843f, 0.02868617f, 0.01927434f, 
    -0.06513485f, -0.05777698f, -0.02428845f, -0.06328334f, -0.01781544f, -0.00013018f, 0.02138993f, -0.06522279f, 
    -0.03877066f, -0.00023026f, -0.04573261f, -0.00814417f, -0.00268767f, -0.05698708f, -0.02609298f, -0.06286034f, 
    -0.01318269f, -0.03483361f, -0.04921488f, -0.06641941f, -0.01068526f, -0.03965669f, -0.03338360f, -0.04167447f, 
    -0.06875500f, -0.07673432f, 0.00410241f, -0.01892379f, 0.03721364f, 0.00554949f, 0.05730668f, 0.01505870f, 
    -0.01937646f, -0.01006847f, -0.03851303f, -0.04516549f, -0.00515709f, -0.02729310f, -0.02089652f, -0.00837478f, 
    -0.01899233f, -0.06355203f, -0.04425913f, -0.05570313f, -0.02511481f, 0.00279386f, 0.05903153f, -0.05568586f, 
    0.01391210f, -0.00279598f, -0.05658081f, -0.02322940f, -0.03190757f, 0.03605424f, 0.04650655f, 0.01820413f, 
    0.04209002f, -0.00610987f, -0.00687543f, -0.07646614f, 0.06041232f, -0.05401304f, 0.02488652f, 0.05449279f, 
    0.02231071f, 0.00276943f, 0.01586376f, 0.00363252f, 0.06068239f, 0.04566802f, -0.01490300f, 0.05046707f, 
    0.03656947f, 0.01395482f, 0.01525253f, 0.06368447f, -0.05923184f, 0.03832499f, -0.00274956f, 0.04340368f, 
    -0.06691661f, -0.05722321f, 0.04928697f, -0.02980278f, -0.03412445f, 0.00560712f, 0.02185075f, 0.03953324f, 
    -0.04160705f, 0.02124545f, 0.01264290f, 0.04638747f, 0.03594689f, -0.07908914f, -0.04305660f, -0.01636369f, 
    -0.06278041f, -0.01136950f, 0.01499345f, -0.04743901f, -0.05467528f, -0.04169000f, -0.05163820f, 0.00753262f, 
    0.01315086f, 0.06167075f, -0.07984875f, 0.01674884f, 0.04943582f, 0.02964053f, -0.05745098f, -0.05738213f, 
    -0.07191875f, -0.04280453f, -0.07181294f, -0.04291055f, -0.00627454f, 0.03347236f, 0.02728185f, -0.03742285f, 
    -0.01855903f, -0.04970245f, 0.03663699f, -0.06193375f, -0.01306253f, -0.01097099f, 0.06113828f, -0.07390840f, 
    0.04515366f, 0.02942516f, 0.00299902f, -0.08008389f, -0.03081047f, 0.03741832f, 0.03389348f, 0.02615990f, 
    -0.04091490f, 0.01319242f, -0.03592227f, 0.05763084f, -0.02775805f, -0.03456651f, 0.00929602f, -0.03917502f, 
    -0.06328967f, 0.03422223f, -0.01570585f, 0.01275439f, 0.00806795f, -0.00811064f, 0.04256682f, 0.03264791f, 
    -0.01512422f, -0.00076721f, -0.01413061f, 0.03423289f, -0.04736315f, -0.06684902f, 0.05651901f, -0.06922340f, 
    0.01770434f, -0.01553180f, -0.02794544f, 0.01569179f, 0.01124068f, 0.03578997f, -0.00331219f, -0.06250378f, 
    -0.04232153f, -0.02162113f, -0.00856256f, 0.04474519f, 0.00744301f, 0.05186050f, -0.04975425f, 0.04756073f, 
    0.03409248f, -0.02671830f, 0.05868589f, 0.06102318f, 0.03502125f, -0.00287352f, -0.00065063f, -0.02062360f, 
    0.01947203f, -0.07416880f, 0.06069484f, 0.00850567f, 0.03599687f, 0.01206363f, 0.01008991f, -0.05224511f, 
    0.02415911f, 0.00732971f, -0.07630198f, -0.01547819f, -0.07065187f, 0.01605256f, -0.04489801f, 0.06198274f, 
    -0.06434779f, -0.02735719f, 0.00874567f, 0.05698067f, -0.01375642f, 0.05500027f, -0.04635310f, -0.05382875f, 
    -0.06545536f, 0.05728788f, -0.00017872f, -0.03724566f, -0.07395373f, 0.00157517f, -0.05663458f, 0.01381201f, 
    0.05305650f, -0.02380398f, -0.01810044f, -0.06865086f, 0.00616360f, 0.01741212f, -0.03355009f, -0.04158495f, 
    -0.00626178f, -0.03410790f, 0.03041160f, 0.01499416f, 0.00221944f, -0.07361834f, 0.02184913f, -0.04530275f, 
    -0.04637147f, 0.01850314f, 0.03318655f, -0.02459125f, 0.02539030f, -0.06048423f, -0.03504493f, -0.05800682f, 
    -0.01257942f, -0.04018029f, -0.01075868f, -0.02807443f, -0.06262583f, -0.04165157f, -0.01378825f, -0.02039255f, 
    0.01555758f, 0.04813613f, -0.03631645f, 0.01344069f, 0.00091678f, -0.06803651f, 0.00254034f, 0.03783305f, 
    0.00425150f, -0.03877370f, 0.05938822f, 0.02438646f, -0.01619411f, -0.01873539f, 0.06346498f, -0.03455902f, 
    0.01699518f, 0.06035811f, -0.00107773f, 0.01643269f, 0.04569062f, 0.01335025f, 0.01111335f, -0.05383131f, 
    -0.01586290f, -0.06864230f, -0.01459875f, 0.01593674f, 0.03755775f, -0.03632490f, 0.05709666f, -0.06411316f, 
    -0.02451810f, -0.05678495f, -0.00201296f, 0.02715463f, -0.01489380f, 0.00933925f, 0.05077127f, -0.05802411f, 
    0.04229511f, -0.04758965f, 0.03566178f, -0.04133886f, 0.02456017f, 0.00844941f, -0.00507088f, -0.00566385f, 
    0.05160740f, -0.04044221f, 0.00080318f, -0.06627141f, -0.04077619f, 0.03186218f, 0.01704176f, 0.05242623f, 
    -0.01507986f, -0.06492642f, -0.06157553f, 0.00595613f, 0.06052969f, -0.07189742f, 0.05262460f, -0.02203588f, 
    -0.06757660f, 0.03284489f, -0.03306291f, -0.02082526f, 0.05045692f, -0.05788522f, -0.05770913f, -0.06768879f, 
    -0.04998070f, 0.00713724f, 0.00370408f, -0.01007417f, 0.00154266f, -0.06605364f, -0.07256526f, -0.01637593f, 
    -0.00072018f, 0.01898986f, -0.02340518f, 0.01197546f, -0.00672194f, -0.00887959f, 0.05929335f, -0.07349245f, 
    -0.07438155f, -0.05640834f, 0.04732206f, -0.05784429f, 0.06400591f, 0.00790460f, -0.07150838f, -0.05949136f, 
    -0.00212917f, 0.05422260f, 0.05894792f, -0.00256145f, -0.03128208f, -0.06618449f, -0.07194811f, 0.02324828f, 
    0.06290133f, -0.01147696f, -0.00026620f, -0.02108292f, -0.05710020f, -0.07257461f, -0.02349495f, -0.04858499f, 
    -0.01268676f, -0.04906308f, -0.07140499f, -0.01470977f, 0.00828226f, 0.01466892f, -0.06200647f, -0.00241728f, 
    -0.00580693f, 0.04502787f, 0.03211539f, -0.02964693f, 0.01710251f, -0.00501575f, -0.06597126f, 0.05649376f, 
    0.00961959f, -0.06678148f, 0.05347776f, 0.06025735f, -0.04861887f, 0.02906811f, -0.07748874f, -0.03641072f, 
    0.01948599f, 0.03960052f, 0.04691241f, 0.02198400f, -0.05114732f, -0.07212069f, 0.04566814f, 0.05992704f, 
    0.04421451f, -0.00244046f, -0.05461955f, 0.03889661f, -0.06159041f, -0.00127081f, -0.07054877f, -0.05600731f, 
    0.00664353f, 0.02059341f, -0.01698701f, 0.05896467f, 0.04689722f, -0.05033487f, -0.04260447f, -0.03145082f, 
    -0.00176477f, -0.06252971f, -0.06315507f, -0.00240695f, 0.03745812f, -0.00712103f, -0.06422410f, -0.07763284f, 
    0.02304167f, -0.02795971f, 0.02109016f, -0.00215571f, -0.00420609f, -0.01066052f, -0.05910540f, 0.06285137f, 
    -0.01449383f, -0.06209806f, 0.02071913f, -0.07455742f, -0.00962618f, -0.02158201f, -0.07284062f, 0.05563375f, 
    -0.05967991f, -0.02357383f, 0.01608010f, -0.01336917f, -0.06140526f, -0.00116656f, 0.03890741f, 0.05483877f, 
    -0.05305605f, -0.00271613f, -0.05997231f, -0.06506596f, 0.01537774f, 0.03203544f, -0.00301103f, -0.00632815f, 
    -0.04449891f, 0.01678299f, -0.06553102f, -0.06826475f, 0.02569170f, -0.07099864f, -0.01994107f, -0.08051760f, 
    -0.07880116f, -0.03446781f, 0.03843242f, -0.05232072f, -0.05098354f, 0.04484420f, -0.06295922f, 0.06489034f, 
    0.06156427f, 0.03740302f, -0.06854682f, -0.03876864f, 0.03201300f, -0.03142518f, -0.06191482f, 0.00596433f, 
    0.05185097f, -0.07842136f, 0.01601527f, -0.05723893f, 0.00519188f, 0.04625435f, -0.02653413f, -0.04584517f, 
    0.02666710f, 0.00684127f, 0.00143039f, -0.02955865f, -0.00284751f, -0.05139383f, 0.00118283f, 0.03490202f, 
    0.02233468f, -0.00016513f, -0.05128422f, 0.04481984f, 0.05819194f, -0.07479490f, -0.03140402f, 0.04646822f, 
    -0.03475275f, -0.00856383f, 0.02857435f, -0.04410644f, -0.06304313f, -0.00960321f, -0.03780752f, 0.00081452f, 
    -0.03392984f, -0.00463344f, -0.05354357f, 0.02788523f, -0.01436727f, -0.05937460f, 0.03900056f, -0.01482935f, 
    -0.00756346f, -0.06996074f, 0.03234764f, 0.00900942f, -0.04156421f, -0.00408859f, -0.03499765f, 0.06275757f, 
    0.04597378f, -0.07858794f, 0.05492828f, -0.02077940f, -0.02576975f, -0.04644462f, 0.05208049f, -0.07377274f, 
    -0.05392361f, 0.05068464f, -0.03112007f, 0.04350375f, 0.03304461f, 0.01448192f, 0.02728187f, -0.03220589f, 
    0.17718926f, 0.12366116f, -0.06642964f, -0.08516627f, 0.15180862f, -0.04372730f, -0.03227390f, -0.08000193f, 
    0.02463434f, -0.21216756f, -0.12458884f, -0.21363860f, -0.21695830f, 0.12943798f, -0.03947392f, 0.18888736f, 
    -0.04779579f, 0.15006690f, -0.06407970f, -0.02574522f, -0.01748794f, 0.09540484f, 0.31031027f, 0.04248886f, 
    0.30934817f, -0.44101757f, -0.07167638f, -0.01306982f, 0.15946372f, 0.05302923f, 0.06204109f, -0.03809136f, 
    -0.14684142f, -0.13571864f, -0.12903942f, -0.06707825f, 0.56966853f, -0.23096520f, 0.02794997f, -0.00561090f, 
    -0.02462587f, -0.04887642f, -0.19636002f, -0.19288369f, -0.09105428f, 0.16402431f, 0.11115936f, 0.21201554f, 
    0.06213358f, 0.02353555f, -0.27795789f, -0.33629015f, -0.02241830f, -0.07072332f, -0.01361670f, 0.06718025f, 
    -0.04711891f, 0.13269481f, -0.12342884f, 0.13295893f, -0.19955422f, -0.13357365f, -0.06377581f, -0.07675339f, 
    -0.16004379f, -0.06490728f, -0.11189199f, -0.02504314f, 0.10468357f, 0.16983236f, -0.00315361f, 0.25085664f, 
    -0.11940302f, 0.05867924f, 0.07784516f, 0.19314416f, 0.18849713f, 0.18760741f, -0.17254302f, 0.04933301f, 
    -0.08647437f, 0.01839013f, -0.16021533f, 0.18222447f, 0.75191110f, -0.33078924f, 0.07166119f, 0.41846466f, 
    -0.01337239f, -0.00912864f, -0.07200800f, 0.00144998f, 0.10248025f, -0.04855440f, -0.07556953f, 0.06956104f, 
    -0.16271234f, -0.16146681f, -0.05085889f, 0.00674530f, -0.03074067f, 0.02294393f, 0.18134120f, 0.42142498f, 
    0.12646836f, 0.06920037f, -0.01378535f, 0.01914275f, -0.00661741f, -0.40167838f, 0.12650037f, -0.19643602f, 
    0.14871411f, 0.03682295f, 0.03042847f, -0.02843280f, 0.05165999f, -0.10284244f, 0.20585525f, 0.12345761f, 
    -0.14410648f, 0.08408215f, 0.04884584f, -0.25637373f, 0.21550530f, 0.05241444f, 0.18946418f, 0.27149290f, 
    0.21983936f, 0.11283938f, -0.04948649f, 0.03247751f, -0.04514581f, 0.20620319f, -0.14083891f, -0.37879822f, 
    0.01973166f, 0.05211134f, 0.00572155f, 0.02455000f, 0.03694362f, 0.08257746f, -0.02976719f, -0.12170614f, 
    0.06729763f, 0.08911862f, 0.15754122f, 0.03859367f, -0.06205574f, 0.02725670f, 0.26175174f, 0.12520631f, 
    -0.22733165f, -0.00946364f, -0.07922597f, 0.01986827f, -0.58277261f, -0.00490463f, -0.02686776f, 0.09597702f, 
    -0.02035073f, 0.01899567f, 0.05639264f, 0.17434990f, 0.00403092f, -0.05928012f, 0.11016060f, 0.10725854f, 
    -0.08827844f, 0.09169584f, 0.17896251f, 0.07083713f, 0.11390938f, 0.08767213f, -0.06932457f, -0.14850754f, 
    -0.04502160f, 0.14773062f, -0.09464032f, -0.16232391f, -0.33548760f, 0.25828210f, 0.22584125f, -0.04225283f, 
    0.08863958f, 0.01234091f, 0.14463410f, 0.06084109f, -0.05213083f, 0.04397890f, -0.00499310f, 0.17217232f, 
    0.53608429f, -0.24861342f, 0.21123905f, -0.06818724f, -0.01189127f, 0.00177633f, -0.06184723f, -0.02463798f, 
    0.12741849f, -0.12129737f, 0.01877566f, -0.01234424f, -0.46786055f, 0.28782639f, -0.11935199f, -0.02581601f, 
    0.07239181f, 0.15664838f, -0.13692170f, 0.08881971f, 0.13868415f, -0.06333067f, 0.11492937f, -0.09312533f, 
    -0.06324592f, -0.16864240f, 0.29118398f, -0.13303135f, -0.17780735f, -0.05872088f, 0.15920918f, -0.24189326f, 
    -0.23340642f, -0.08750495f, 0.08215709f, -0.13113111f, -0.03572073f, -0.31820130f, -0.07656359f, -0.08657656f, 
    -0.01619389f, -0.07449416f, -0.06573765f, 0.10309058f, -0.10672496f, 0.05256814f, 0.10011922f, 0.18817860f, 
    0.36475602f, 0.01963765f, -0.16963767f, 0.40119419f, 0.13855886f, 0.02722917f, -0.28095660f, 0.24405564f, 
    0.05462263f, 0.12024156f, 0.17623533f, 0.08450618f, 0.18052828f, 0.20926271f, 0.03017900f, 0.15706241f, 
    -0.10775043f, -0.17211418f, 0.00881862f, -0.02614602f, -0.05151711f, -0.15603504f, 0.01042062f, 0.24582987f, 
    0.29416013f, -0.39195311f, 0.16393289f, 0.35136911f, 0.16823642f, 0.06490725f, -0.06998818f, -0.04302602f, 
    0.24190725f, -0.01742864f, 0.00837727f, -0.03436207f, 0.46413806f, -0.15079026f, 0.16853768f, 0.15582831f, 
    0.01876680f, -0.05987227f, 0.00042557f, 0.14184664f, -0.00349052f, 0.05362347f, -0.05914501f, 0.02891346f, 
    -0.32555676f, -0.22707482f, -0.09260977f, 0.46156961f, -0.21061303f, 0.00373151f, 0.06673943f, 0.13665091f, 
    -0.01975274f, 0.19540727f, 0.10896907f, 0.17603068f, -0.06806865f, 0.15282696f, 0.08365451f, -0.21970816f, 
    0.02175216f, 0.05921113f, 0.05811508f, 0.07650080f, 0.10589758f, -0.08024449f, 0.19788891f, -0.22861320f, 
    0.12961704f, 0.17157163f, 0.20896804f, -0.04896027f, -0.04363272f, 0.00145297f, 0.14124921f, 0.02625825f, 
    0.35791361f, 0.06155812f, 0.03865064f, -0.08903675f, 0.00552425f, 0.01026642f, -0.30681869f, -0.25897452f, 
    0.15354180f, 0.02911459f, -0.08302782f, 0.10485634f, 0.04673459f, -0.10746101f, 0.01028566f, -0.07439157f, 
    0.13094454f, 0.02658056f, -0.03983053f, 0.07550744f, -0.00921903f, 0.26269859f, -0.06131309f, 0.09502601f, 
    0.09230831f, -0.11110364f, -0.10925307f, -0.09740434f, -0.37399805f, 0.45787045f, -0.03556618f, -0.11291048f, 
    0.14204054f, 0.08388002f, 0.28549248f, -0.06940783f, -0.09135098f, -0.15258992f, 0.08109696f, 0.08607507f, 
    0.06403120f, -0.13970707f, 0.07753167f, -0.10138732f, 0.13205871f, 0.05807795f, -0.16799475f, -0.01230782f, 
    0.04142486f, 0.00860278f, -0.11549577f, -0.20159888f, 0.00814605f, -0.10447056f, -0.14633483f, -0.04879896f, 
    0.00923163f, 0.11983491f, -0.09101778f, 0.04390550f, -0.05960614f, 0.22306180f, 0.16998832f, 0.20347352f, 
    -0.13085434f, -0.16224204f, 0.22404258f, -0.08675076f, 0.12764382f, 0.04572565f, -0.04378451f, 0.27893919f, 
    0.10377271f, -0.04271794f, 0.02752346f, 0.07119502f, -0.42543787f, 0.07478308f, -0.09838481f, -0.37686610f, 
    0.06991527f, -0.06502763f, 0.11745822f, 0.06872160f, 0.33843127f, -0.00192543f, 0.11259720f, -0.01256869f, 
    -0.38805422f, -0.02219297f, -0.14756498f, -0.30886599f, -0.01053057f, -0.04986842f, 0.13151492f, 0.03775065f, 
    -0.07994673f, -0.03927962f, -0.07590437f, 0.20435698f, 0.03853933f, -0.18239954f, 0.15763961f, 0.10377364f, 
    -0.22296195f, -0.06396034f, 0.15906899f, -0.00836527f, -0.08375236f, -0.09643656f, -0.16162571f, 0.03597046f, 
    0.28762588f, 0.06901771f, 0.34412742f, 0.01840324f, -0.16093965f, -0.09030635f, 0.10495211f, 0.08944476f, 
    0.24241753f, 0.12521851f, -0.04821378f, 0.17077769f, 0.22644880f, 0.10883363f, -0.03828956f, 0.12697461f, 
    0.03346347f, 0.06572893f, 0.07607803f, -0.06708735f, -0.10963248f, 0.12363163f, -0.05365054f, 0.09561384f, 
    -0.77250004f, 0.12426192f, 0.32119393f, 0.07043974f, 0.11282799f, 0.15019873f, -0.01941597f, -0.01331401f, 
    -0.06905681f, 0.02907315f, 0.05074066f, -0.24325724f, -0.18955116f, -0.04825237f, 0.26618317f, 0.08761919f, 
    0.08313340f, -0.04360455f, 0.11060390f, 0.13651261f, 0.28543371f, -0.05723384f, -0.08110284f, -0.10994488f, 
    -0.18021980f, -0.01112567f, -0.19681917f, 0.17149456f, -0.03397575f, -0.01406827f, 0.01827644f, -0.06357178f, 
    -0.02258403f, -0.05949065f, -0.07742789f, 0.16186449f, -0.13560216f, -0.06649215f, -0.46157825f, -0.07779102f, 
    0.06412417f, 0.10028102f, 0.00166831f, -0.16631407f, 0.13468020f, 0.05621896f, 0.15011548f, -0.17703152f, 
    0.25956181f, -0.06643915f, 0.18099803f, 0.27269891f, 0.05492608f, 0.06773480f, 0.05820621f, 0.02421235f, 
    0.00680040f, -0.25472692f, 0.14177796f, 0.10003987f, 0.02847442f, -0.02737694f, -0.15461053f, -0.03103037f, 
    -0.01923865f, 0.07445619f, -0.07117215f, 0.19195373f, 0.02211076f, -0.19472131f, 0.05170758f, 0.16401018f, 
    0.27869362f, 0.12166748f, 0.21253863f, -0.16395906f, -0.07058999f, 0.23468281f, 0.06092832f, 0.01861664f, 
    -0.01426491f, 0.03576509f, -0.03298330f, -0.06469232f, -0.23485959f, 0.30242306f, -0.26847947f, -0.30719146f, 
    0.09888043f, 0.01081360f, 0.18736079f, -0.04307012f, -0.02414134f, -0.09786187f, 0.16444421f, 0.15075544f, 
    -0.22989613f, 0.17113253f, -0.09246890f, 0.03293051f, -0.15809973f, 0.31750920f, 0.10413060f, 0.22809121f, 
    0.04684855f, 0.07542370f, -0.04275499f, -0.13504693f, -0.21208122f, 0.07556936f, 0.08727739f, 0.34940115f, 
    0.02869136f, 0.13884105f, 0.10725253f, 0.08356543f, -0.11318249f, 0.17697126f, 0.14469926f, 0.04519618f, 
    0.07763001f, -0.03031409f, -0.12830281f, 0.00842672f, 0.13730454f, 0.05927624f, 0.12316690f, 0.16376622f, 
    -0.05326071f, 0.01116252f, 0.02401059f, 0.00880518f, 0.13511270f, -0.16161360f, -0.03382013f, 0.04538026f, 
    0.07956016f, 0.19117887f, -0.00340981f, -0.07437929f, 0.07386504f, 0.19586870f, 0.03403622f, 0.05315112f, 
    -0.09519014f, 0.24683639f, 0.35143420f, -0.03657641f, -0.16167599f, 0.04203406f, 0.03390896f, 0.08979621f, 
    -0.15851645f, 0.07075372f, 0.05432278f, 0.07324657f, -0.09159232f, 0.37421739f, -0.08815541f, 0.13016593f, 
    -0.03946385f, 0.02085779f, -0.00106625f, -0.09412052f, 0.07180487f, -0.20510644f, -0.13105154f, -0.04492521f, 
    0.14728230f, 0.31496370f, 0.28736633f, 0.05738143f, -0.05829664f, -0.02275003f, -0.09183758f, 0.16162340f, 
    0.09678654f, 0.08075198f, 0.14212622f, -0.00665639f, 0.17141309f, 0.26525655f, 0.10047891f, 0.02111480f, 
    0.22709584f, 0.16799545f, 0.07839523f, 0.06789202f, -0.17764489f, -0.14161773f, -0.07072404f, 0.04115091f, 
    -0.39315939f, 0.14841458f, -0.09116186f, -0.34245071f, -0.09614141f, 0.02992349f, 0.01497518f, -0.11021170f, 
    -0.07463028f, -0.08522750f, 0.07267638f, -0.07037497f, -0.56717253f, 0.00822057f, 0.35759169f, -0.02663450f, 
    -0.14051944f, -0.05286752f, -0.02436277f, 0.11019015f, 0.09715559f, 0.03384835f, -0.04790157f, -0.04556699f, 
    -0.07577543f, 0.44340017f, -0.15593180f, 0.10245099f, 0.01663664f, 0.10622949f, 0.24494471f, -0.18841748f, 
    -0.06943118f, 0.13104558f, 0.03752528f, -0.01611607f, -0.12416431f, 0.13011807f, 0.08414670f, 0.02225868f, 
    -0.10696043f, -0.18487236f, -0.00215167f, 0.14724237f, 0.05763390f, 0.02498472f, 0.19567947f, -0.09184410f, 
    0.33184680f, 0.01323487f, 0.28208181f, 0.19585599f, -0.02789338f, 0.03812001f, -0.17649372f, -0.18525083f, 
    0.07596339f, -0.01040140f, 0.01930350f, 0.05031204f, -0.05960824f, -0.12880611f, -0.00126178f, 0.52516359f, 
    0.08264290f, 0.09963153f, -0.12520796f, -0.11685417f, -0.01542122f, -0.07538114f, -0.10553524f, 0.06442791f, 
    -0.01187975f, 0.17700933f, -0.08346691f, 0.17681213f, 0.16982850f, 0.10562097f, -0.06663638f, -0.08118548f, 
    0.19381814f, -0.04110454f, -0.19790597f, 0.11019803f, 0.51894158f, 0.08232184f, 0.08607829f, 0.24877368f, 
    -0.08924646f, -0.04172688f, 0.09579309f, -0.05050094f, -0.02084451f, 0.07643588f, -0.00464277f, -0.20998895f, 
    -0.04026758f, -0.25962976f, -0.39498457f, 0.34630549f, -0.17934059f, 0.10566811f, 0.02826605f, 0.09310024f, 
    -0.08031096f, -0.00294489f, 0.00396694f, -0.09010339f, 0.10427343f, -0.24717298f, -0.21233402f, 0.16233021f, 
    0.10191964f, -0.00856856f, -0.06984705f, 0.01240863f, 0.14140676f, 0.28313932f, 0.03430986f, -0.01001039f, 
    0.56115931f, -0.26821569f, 0.04168745f, -0.00589833f, -0.02202078f, 0.00014798f, -0.03038759f, 0.03430771f, 
    -0.12519574f, -0.05770141f, -0.01095910f, -0.04073818f, -0.12390208f, 0.17815183f, 0.00487482f, 0.00903928f, 
    -0.09978545f, -0.11321308f, -0.00598507f, 0.08727457f, -0.12941210f, -0.07824909f, 0.06372426f, -0.04931267f, 
    0.48327827f, -0.14949544f, 0.10727265f, 0.18359846f, -0.14278844f, -0.04981486f, 0.11621119f, -0.08802726f, 
    -0.03167570f, -0.16298142f, 0.15962423f, -0.10947924f, 0.09609018f, 0.00439214f, -0.28255767f, -0.06354149f, 
    -0.14426787f, 0.03617396f, 0.09346855f, 0.21376775f, -0.10250126f, 0.15646784f, 0.21792161f, -0.08352528f, 
    0.82399052f, 0.02332027f, -0.24445184f, 0.25378880f, 0.19026080f, 0.15778917f, -0.09400463f, 0.06518790f, 
    -0.11010115f, 0.14628589f, -0.14085272f, 0.07326037f, -0.23212099f, -0.03564100f, -0.29099575f, 0.15032594f, 
    -0.23354113f, -0.18691939f, -0.04735181f, -0.09332236f, -0.05568907f, 0.05019281f, 0.09598617f, 0.09465384f, 
    -0.31660104f, -0.13283877f, 0.01241323f, 0.10041930f, 0.16245718f, -0.01980979f, 0.08034776f, 0.05077649f, 
    0.20379174f, 0.04500541f, -0.02736949f, -0.14720958f, 0.73924625f, -0.48368528f, 0.02983158f, -0.25132215f, 
    -0.23725303f, 0.10124695f, -0.17198594f, 0.11713047f, 0.08580992f, 0.04038677f, 0.02348618f, 0.00587713f, 
    0.08563198f, -0.28160724f, -0.00956456f, 0.67553627f, -0.23364592f, -0.13079402f, 0.06606993f, 0.09532517f, 
    -0.03412644f, 0.01121747f, 0.07323472f, 0.09855919f, 0.30160907f, 0.21017897f, 0.28532976f, 0.09314980f, 
    0.03565781f, 0.00205809f, 0.13797520f, 0.06362826f, -0.04972801f, -0.05917317f, 0.12386135f, -0.15756527f, 
    -0.05752933f, 0.45179710f, -0.14549345f, -0.18255708f, 0.08222800f, 0.06816947f, 0.13370763f, 0.09820838f, 
    0.12710957f, 0.16549610f, 0.00490344f, -0.09121868f, -0.25751927f, -0.01211524f, 0.08993833f, 0.07569173f, 
    0.14121684f, -0.00540458f, 0.11383919f, 0.00677452f, 0.13752717f, -0.02482368f, 0.11498873f, -0.02568006f, 
    0.13361523f, 0.24028215f, 0.05283138f, 0.04384739f, 0.19106099f, 0.20018023f, -0.06452503f, 0.03729613f, 
    -0.09045445f, -0.22393396f, -0.00198385f, -0.06798442f, -0.03807043f, -0.20579484f, 0.10921643f, -0.37415349f, 
    0.04972315f, -0.03029229f, -0.05889199f, 0.05717877f, 0.02131553f, -0.15992111f, -0.04332128f, 0.01166152f, 
    -0.16798174f, 0.00199648f, 0.25854832f, 0.18882927f, 0.03126475f, 0.16529565f, 0.09385888f, -0.02828657f, 
    0.06625087f, 0.09904025f, 0.12998007f, -0.04716561f, -0.30324775f, 0.16059886f, -0.18803798f, 0.09844261f, 
    0.15972421f, 0.20115368f, 0.19087589f, -0.07840643f, -0.03607683f, 0.05505873f, -0.15814231f, 0.15208878f, 
    -0.06893175f, -0.03994443f, 0.03872095f, -0.00359323f, 0.04723392f, -0.00747792f, -0.07566232f, 0.00743142f, 
    -0.03248383f, 0.03151891f, 0.02594358f, -0.06261799f, -0.02491822f, -0.01130979f, -0.00021204f, 0.05989559f, 
    -0.04243739f, -0.02603533f, 0.04300544f, -0.02348984f, -0.07375576f, 0.04297793f, 0.02686102f, -0.06471631f, 
    0.02483637f, 0.06101140f, 0.00204186f, 0.01263004f, 0.04168583f, -0.01604885f, -0.05838699f, -0.00805534f, 
    0.02084978f, -0.06893947f, 0.03794033f, -0.03827235f, 0.04922637f, 0.05864947f, -0.04946854f, 0.05526061f, 
    -0.02910381f, 0.03698501f, 0.02619849f, 0.03690035f, 0.04396361f, 0.04741663f, 0.03358652f, -0.02766966f, 
    0.02891160f, 0.00438109f, -0.02773641f, -0.06303746f, -0.05102690f, 0.01749527f, -0.03808124f, 0.01667040f, 
    0.04079285f, -0.01802900f, -0.00561996f, -0.04202726f, -0.04020841f, 0.04493402f, -0.04718668f, 0.05329147f, 
    0.02435546f, 0.01985266f, -0.08444260f, 0.03279698f, -0.06155861f, -0.01794773f, -0.00693746f, -0.03264557f, 
    0.01579807f, -0.07333969f, 0.04067415f, 0.01129125f, -0.06457034f, 0.02408224f, -0.03428741f, -0.01479210f, 
    0.00526082f, -0.02468731f, -0.01577780f, 0.04475027f, -0.06668931f, -0.00819387f, 0.00523253f, 0.06049952f, 
    -0.03479744f, -0.07338924f, -0.05713667f, -0.07664394f, -0.07806621f, 0.00453382f, 0.03588797f, -0.05046589f, 
    -0.06876410f, 0.02541619f, -0.03261488f, -0.00965127f, -0.04067159f, -0.00591221f, 0.05366768f, 0.04300852f, 
    -0.08115154f, -0.02218381f, 0.02798235f, -0.07053579f, -0.02099547f, 0.05552030f, 0.01899937f, -0.03156055f, 
    -0.00765194f, -0.01589304f, 0.05986505f, -0.01057976f, 0.02229125f, -0.03995595f, -0.06051021f, 0.02057126f, 
    0.04368685f, 0.02619077f, 0.02307433f, 0.05819387f, -0.01379284f, 0.05789323f, -0.06865214f, 0.02910536f, 
    0.01156999f, -0.07993181f, 0.02762179f, 0.06170701f, -0.06348921f, 0.00845522f, -0.02541400f, -0.06512730f, 
    -0.04969751f, -0.01972942f, -0.04650031f, 0.03406255f, 0.00553598f, 0.04917561f, 0.02572600f, 0.04603662f, 
    -0.02636807f, 0.00337952f, 0.02473087f, 0.00909083f, -0.06559986f, -0.07517872f, -0.07989809f, -0.08070178f, 
    -0.07843792f, -0.07423037f, 0.03796907f, 0.06396542f, 0.02790872f, 0.04839092f, -0.07144648f, 0.02299692f, 
    -0.04180938f, -0.02878379f, -0.02988965f, -0.05241789f, -0.01434834f, -0.02800463f, -0.05044380f, 0.01948958f, 
    0.02064973f, -0.05046247f, 0.01179646f, -0.03450841f, 0.03368282f, -0.07692148f, 0.02633341f, -0.05326922f, 
    -0.05813785f, -0.03449939f, -0.02591528f, 0.05624475f, -0.07014076f, 0.04992359f, -0.03477953f, 0.04123225f, 
    0.04589900f, -0.06698340f, -0.01117196f, -0.03520032f, 0.02746903f, -0.00758452f, -0.04253038f, -0.04903273f, 
    0.21241030f, -0.38435605f, 0.15761609f, -0.03208580f, -0.09310201f, -0.00091921f, 0.07577850f, -0.01433364f, 
    0.11471109f, 0.00738395f, -0.05216924f, 0.05088236f, -0.28811526f, 0.13356967f, 0.01550801f, -0.19687013f, 
    -0.11798957f, -0.17956698f, 0.01284231f, 0.16281293f, 0.04939236f, -0.16787015f, -0.22317174f, -0.16052626f, 
    -0.80136752f, -0.26975325f, 0.03230554f, -0.10582422f, 0.20544142f, 0.07695059f, 0.15690576f, 0.14725041f, 
    -0.12036794f, -0.12868151f, 0.09975129f, -0.00861610f, -0.03931760f, 0.06819154f, 0.15527540f, 0.18418179f, 
    -0.14577001f, -0.00570954f, 0.19753626f, 0.05837148f, -0.05023485f, -0.00937756f, 0.06555476f, -0.00785859f, 
    -0.05106857f, 0.12822245f, 0.09533778f, 0.12141170f, -0.20361370f, -0.07693792f, -0.06105297f, 0.06705412f, 
    0.05364743f, 0.10472315f, -0.02305513f, -0.03114017f, 0.00111246f, -0.15176655f, -0.32984543f, 0.17144793f, 
    0.16772938f, 0.11129026f, 0.06777007f, 0.02956049f, 0.02362042f, 0.04686721f, 0.24974740f, 0.20643853f, 
    -0.29616109f, -0.11174266f, 0.45020291f, 0.22302222f, 0.02805954f, -0.12721595f, -0.08395504f, -0.25283223f, 
    0.22613633f, 0.14661823f, -0.05160517f, -0.12846307f, -0.07183772f, -0.06701860f, -0.18952855f, -0.61483794f, 
    0.00326269f, 0.31657714f, -0.00669450f, 0.04635845f, 0.01827800f, -0.01583411f, -0.03038179f, 0.07908947f, 
    -0.10244193f, -0.44004861f, -0.07836755f, 0.09213158f, -0.01497785f, 0.06485698f, -0.10833033f, 0.03627696f, 
    -0.02096788f, -0.00129822f, 0.14400016f, -0.02748769f, -0.19861138f, 0.05028693f, 0.01556551f, 0.41090950f, 
    0.33834714f, 0.11038575f, 0.13853838f, 0.19158611f, -0.04427087f, 0.06373841f, 0.03970017f, -0.02425196f, 
    0.21919753f, -0.19075947f, -0.05363341f, 0.32199380f, -0.24044798f, 0.13366193f, -0.00691344f, 0.10297088f, 
    0.02771004f, 0.07737022f, 0.14858823f, 0.13824734f, -0.22397542f, 0.37632406f, 0.25845399f, 0.14125231f, 
    -0.03958158f, -0.10775305f, -0.06995112f, -0.05941205f, 0.16603227f, -0.15519723f, 0.07712223f, -0.02692422f, 
    0.08383270f, -0.21528909f, 0.30340287f, -0.08837947f, -0.10968603f, -0.02316695f, -0.00844535f, -0.16154200f, 
    0.23652096f, -0.05329183f, -0.05749005f, -0.19616044f, 0.27349368f, -0.04110195f, -0.01163436f, -0.18572617f, 
    0.14231876f, 0.08627819f, -0.03754835f, -0.08195303f, -0.04439862f, -0.09674052f, 0.03015202f, 0.06422990f, 
    -0.08479175f, 0.26565960f, 0.26436335f, -0.07605356f, -0.10211656f, 0.01414980f, -0.07284256f, 0.09227864f, 
    0.03654392f, -0.17244481f, 0.14255564f, -0.01073172f, -0.32333490f, -0.19612603f, 0.23751777f, 0.32069850f, 
    -0.29260597f, -0.08779479f, 0.15077567f, -0.07840838f, -0.01733521f, 0.04390632f, -0.03355513f, 0.16569711f, 
    0.14542985f, 0.07753914f, -0.07656213f, -0.31050271f, 0.09838922f, 0.10543189f, 0.09657570f, 0.00701187f, 
    -0.24678148f, 0.09972312f, -0.00408237f, 0.11215809f, 0.57104319f, -0.07855007f, 0.10009769f, 0.20812289f, 
    -0.05987488f, 0.06476282f, -0.09086607f, -0.05551509f, -0.23118599f, 0.14308110f, 0.03526150f, -0.02260903f, 
    0.29896247f, -0.01543475f, 0.06370574f, 0.29317901f, 0.05509562f, 0.01886875f, -0.01427223f, 0.20017557f, 
    0.24640517f, -0.07855433f, 0.00841426f, 0.04239522f, 0.57183945f, 0.32494712f, 0.01827750f, 0.29887962f, 
    -0.00434104f, 0.03450312f, 0.07135352f, -0.17991605f, 0.05733395f, 0.07800375f, 0.19295484f, -0.00404381f, 
    -0.17403674f, 0.06729223f, -0.38376683f, -0.59857601f, 0.02815535f, 0.10910816f, 0.04569718f, -0.03062392f, 
    -0.11120815f, -0.13144787f, 0.03614863f, 0.02546727f, -0.36933628f, -0.23763312f, -0.07713149f, -0.22448619f, 
    0.01481395f, -0.00796707f, 0.00416896f, 0.05040781f, 0.05494195f, 0.12814353f, -0.12463614f, -0.10171674f, 
    -0.00226113f, 0.23067559f, -0.48417160f, -0.44882798f, -0.07807422f, 0.12951708f, 0.01918612f, 0.02742045f, 
    -0.07203821f, 0.00269755f, -0.01771538f, 0.09508390f, 0.06645784f, -0.17765364f, -0.02047484f, 0.10140387f, 
    -0.18763466f, -0.00954576f, 0.03153984f, -0.20237683f, 0.01724215f, 0.01392030f, 0.06573386f, 0.17123240f, 
    0.22056539f, 0.30335101f, -0.08583724f, -0.34994474f, 0.10859036f, -0.05769681f, -0.09591345f, 0.17206104f, 
    0.14119567f, -0.09791695f, -0.01822128f, -0.09679254f, 0.01040256f, -0.20365514f, 0.25982448f, 0.13742863f, 
    -0.14076883f, 0.01349722f, 0.08206046f, 0.08449350f, -0.08099566f, -0.04473469f, 0.03790133f, 0.32104528f, 
    -0.41763291f, -0.25751343f, 0.02565383f, -0.23872213f, 0.10623611f, 0.05626221f, 0.04311812f, 0.02446943f, 
    -0.00232222f, 0.14954945f, 0.12731378f, 0.02619264f, -0.05410356f, 0.16152577f, 0.23685932f, 0.42287958f, 
    0.12802100f, 0.15652213f, -0.04445470f, 0.00497358f, 0.09709427f, 0.05165990f, -0.06048049f, -0.07242479f, 
    -0.30770028f, -0.14952393f, -0.05911836f, 0.08442802f, 0.23272027f, -0.12251391f, 0.11650617f, 0.01294638f, 
    0.03571333f, 0.02214443f, -0.00742234f, 0.10710348f, 0.56004339f, -0.20143816f, 0.13199426f, 0.28741598f, 
    -0.17420073f, -0.08757212f, -0.12614645f, 0.14054637f, 0.08154862f, 0.14059901f, -0.07923031f, -0.08960564f, 
    0.19435374f, 0.01399663f, 0.01654929f, 0.43293959f, -0.02004256f, 0.00996602f, -0.02032588f, 0.01013316f, 
    0.05366858f, -0.07429994f, 0.21901788f, -0.04036148f, -0.13976084f, -0.05054697f, 0.01537390f, -0.17518672f, 
    0.20842218f, -0.09425362f, 0.04733016f, -0.02554787f, 0.20998241f, 0.07934839f, -0.12673245f, -0.10358310f, 
    0.44140351f, -0.50819522f, 0.46284297f, -0.26781878f, 0.05214097f, -0.09950515f, 0.17262420f, -0.22343171f, 
    0.09789668f, 0.05828664f, 0.05685623f, 0.12485303f, -0.09230614f, 0.41965577f, -0.03649356f, -0.11941852f, 
    -0.00124785f, -0.10130259f, -0.09230810f, -0.02829069f, 0.03495758f, -0.16618595f, -0.10735115f, -0.12148543f, 
    -0.38103524f, -0.48168567f, -0.05094882f, -0.17291661f, 0.10793456f, 0.14308806f, 0.07519798f, -0.02497415f, 
    0.08641550f, 0.03423984f, -0.15913856f, -0.08967403f, 0.00699209f, -0.22556734f, 0.24777657f, 0.26057917f, 
    -0.01837781f, -0.04984761f, 0.07278208f, 0.03033358f, 0.08627892f, 0.04448994f, 0.00593230f, 0.01367976f, 
    0.30387425f, 0.00357339f, -0.04619078f, 0.12355778f, -0.03467640f, 0.00486024f, -0.02605629f, 0.06126167f, 
    0.01777351f, 0.01442009f, 0.09177318f, 0.03210614f, -0.09503651f, 0.08990777f, 0.03283207f, 0.17238884f, 
    0.02808659f, 0.01243540f, 0.15143074f, 0.12516631f, 0.13981508f, 0.06080096f, -0.09329202f, 0.13491935f, 
    0.01114654f, -0.17769088f, -0.14585209f, 0.40297458f, 0.17503105f, -0.11529600f, 0.03786020f, 0.04309031f, 
    -0.08481735f, 0.11372246f, 0.08019564f, 0.05498703f, -0.02385982f, 0.10979652f, 0.09533078f, 0.01331903f, 
    0.23865753f, -0.06584243f, 0.12961374f, -0.04230111f, 0.03146093f, 0.12990198f, 0.06794208f, -0.04829233f, 
    0.07797267f, -0.11390474f, 0.15668328f, -0.06111207f, -0.01188827f, 0.01611552f, -0.27896899f, 0.17264296f, 
    0.04927998f, 0.03889439f, -0.18337040f, 0.06666952f, -0.17064156f, -0.12101647f, 0.10940783f, 0.13684036f, 
    0.10321547f, 0.11015535f, 0.00862260f, -0.11035649f, -0.06005845f, 0.24950065f, -0.12258942f, 0.04751819f, 
    0.04096504f, -0.25832662f, 0.05393085f, -0.08334507f, -0.11690848f, -0.03736997f, 0.12412728f, -0.14868200f, 
    -0.06396832f, -0.13396339f, 0.31840730f, 0.23452041f, -0.06576212f, 0.20838825f, -0.12792376f, 0.26749071f, 
    -0.02684584f, 0.09308858f, 0.09042504f, 0.09156004f, 0.04482264f, -0.25242472f, 0.09016705f, 0.09022450f, 
    0.16947721f, -0.32598156f, 0.27322501f, -0.26835963f, 0.00067085f, -0.17098032f, 0.16518840f, 0.20862825f, 
    -0.05230500f, 0.12729581f, 0.19226338f, -0.11433353f, -0.02844424f, 0.56112242f, 0.03596810f, -0.30370909f, 
    -0.02026221f, 0.11503911f, -0.08275949f, -0.09604597f, -0.04663115f, -0.02685533f, 0.01788989f, 0.09065825f, 
    0.17890267f, 0.10804737f, 0.11758671f, 0.19823267f, 0.16622165f, 0.06960628f, 0.05747243f, 0.05317690f, 
    0.00229502f, -0.21921085f, 0.30926290f, 0.07163279f, -0.09558557f, -0.22746843f, -0.02209937f, 0.15891957f, 
    0.02925537f, 0.06868784f, -0.06263002f, 0.03041956f, -0.10345811f, -0.03927994f, -0.00438003f, 0.04995683f, 
    -0.04335671f, -0.06869480f, 0.02680646f, 0.05821754f, -0.03858055f, -0.06850658f, -0.07892389f, 0.05340543f, 
    -0.04521852f, 0.00285744f, -0.04403019f, -0.00198026f, 0.05269842f, -0.05005242f, -0.08185691f, -0.01606000f, 
    -0.00105020f, 0.01680070f, -0.01822058f, -0.02393965f, -0.06346928f, 0.00858395f, 0.02124356f, 0.00173435f, 
    -0.05802677f, -0.03780260f, 0.02945479f, -0.06557257f, -0.06565173f, -0.03571346f, -0.03419977f, -0.07960404f, 
    0.05275666f, 0.05950851f, 0.02328626f, -0.04364230f, 0.04213206f, 0.00260006f, -0.02243941f, -0.03876055f, 
    -0.04383397f, -0.00172791f, -0.02011781f, 0.05507075f, 0.01890139f, 0.05467940f, -0.00148219f, -0.07219017f, 
    0.00136478f, -0.06909454f, -0.05259970f, -0.07006790f, -0.02058343f, 0.05372561f, 0.04559484f, -0.02565688f, 
    -0.00461454f, -0.01912634f, 0.03626323f, 0.02217839f, -0.00168329f, -0.04800006f, 0.04009750f, -0.03262199f, 
    -0.07719695f, -0.02993524f, 0.00966851f, -0.03007529f, -0.03967062f, -0.02950753f, -0.01887494f, 0.01379515f, 
    0.00251117f, -0.00828691f, 0.00209993f, 0.04717331f, -0.04423523f, -0.03222043f, -0.01473607f, -0.01488778f, 
    0.04295230f, 0.02468239f, -0.06475309f, 0.00171176f, 0.05581984f, -0.06582296f, -0.06998932f, -0.04343358f, 
    -0.04690696f, 0.02142925f, 0.04689633f, 0.01613646f, -0.03710432f, -0.07236043f, -0.02072337f, 0.04264855f, 
    -0.01475365f, 0.05154175f, -0.06874034f, -0.05462400f, -0.03045413f, 0.00569497f, -0.07966962f, 0.02243961f, 
    -0.04820193f, 0.03071355f, -0.01977562f, -0.05125839f, -0.03237407f, 0.02504417f, -0.01801597f, -0.01350620f, 
    0.02007062f, -0.04923509f, 0.00367492f, -0.00211376f, -0.05541426f, -0.00179014f, -0.00601418f, -0.00147962f, 
    0.00853015f, -0.06296319f, 0.04283918f, 0.00497365f, -0.03220040f, 0.01618721f, -0.04404350f, -0.05590284f, 
    0.04135522f, 0.05329160f, 0.03564551f, -0.04338414f, -0.07481351f, -0.05822813f, 0.01406443f, 0.01508014f, 
    -0.04806159f, -0.04357811f, 0.04957759f, -0.04594688f, -0.01492864f, -0.04219889f, 0.02257573f, -0.04037123f, 
    0.02604765f, -0.06868498f, 0.05462324f, -0.06796169f, 0.01208280f, -0.05973548f, -0.02951245f, 0.01227440f, 
    0.01143066f, -0.06045141f, -0.05335062f, -0.06392892f, 0.05819349f, -0.03308399f, 0.05820188f, 0.01008053f, 
    -0.06140560f, 0.00924905f, 0.03332866f, -0.02478042f, -0.04922171f, 0.03419900f, 0.03496650f, -0.04995726f, 
    -0.03374309f, 0.00274712f, 0.04628959f, -0.02239158f, 0.03244472f, 0.05359506f, 0.00015579f, -0.02145077f, 
    -0.06564901f, 0.01886827f, -0.02365121f, 0.00985466f, -0.02133742f, -0.04034894f, 0.00727329f, -0.00374412f, 
    0.04726491f, 0.00786640f, -0.01618651f, 0.05817012f, 0.04758176f, -0.00037247f, -0.06115922f, 0.02477605f, 
    0.02497417f, 0.18939677f, -0.09071149f, 0.38384408f, 0.16736369f, 0.14530236f, 0.06010754f, -0.21299541f, 
    0.16027334f, 0.04128755f, -0.13538800f, -0.17849578f, -0.49116915f, 0.13653678f, 0.16500551f, 0.21794271f, 
    -0.07800569f, 0.01040362f, -0.04832835f, 0.11844698f, -0.13034095f, 0.12159497f, 0.02227546f, 0.01794021f, 
    0.38411236f, 0.04653589f, -0.00001914f, 0.03504744f, 0.15226926f, 0.19509645f, 0.00691135f, 0.07107437f, 
    -0.08630182f, -0.01390148f, 0.07548646f, -0.03301597f, 0.21894240f, -0.04571191f, 0.02382497f, -0.04945328f, 
    0.13418595f, 0.13055985f, 0.02939912f, -0.10627293f, 0.04777651f, 0.14624108f, 0.21212640f, 0.12648478f, 
    -0.06601972f, 0.18553592f, -0.22419173f, -0.33979672f, -0.10603553f, 0.04447722f, -0.01038718f, 0.19886823f, 
    -0.04330317f, 0.14032744f, -0.14497761f, 0.11403767f, 0.46278673f, 0.11349338f, 0.00567992f, 0.01707991f, 
    -0.08394316f, -0.04089728f, 0.03827208f, 0.03380130f, 0.12310705f, -0.00174258f, 0.02484610f, 0.06523187f, 
    -0.48165867f, -0.24871196f, 0.51502156f, -0.11938407f, 0.02487740f, 0.09420218f, -0.03280905f, 0.21550903f, 
    0.13959602f, -0.18124554f, -0.14577554f, 0.07518551f, 0.29508209f, -0.01157137f, -0.34381515f, -0.08644024f, 
    0.17423910f, 0.26449400f, -0.01991363f, 0.06273409f, -0.10036073f, 0.04399575f, -0.07173022f, -0.02765672f, 
    0.43060231f, -0.19053289f, 0.20100249f, -0.05128201f, -0.11874498f, 0.01872895f, 0.25259006f, 0.00836100f, 
    0.15348785f, 0.15385687f, 0.15558769f, -0.06772038f, 0.28257048f, 0.35468692f, 0.00177042f, 0.32521242f, 
    0.03805946f, -0.02033226f, -0.07014414f, 0.17537068f, 0.07178605f, -0.14338350f, 0.28318387f, -0.06464694f, 
    0.05682032f, 0.04465138f, -0.07169085f, 0.17987663f, -0.08155606f, 0.06754312f, 0.09601589f, 0.07634266f, 
    -0.01621655f, -0.06173081f, -0.13579223f, -0.08750746f, -0.15820986f, 0.26533663f, 0.07463259f, -0.73347843f, 
    -0.13716979f, -0.22902392f, 0.01161555f, 0.12573878f, -0.17246473f, 0.28210363f, 0.20064740f, -0.01826234f, 
    0.03950519f, 0.08386718f, 0.03654629f, 0.15837215f, 0.08748827f, 0.23767577f, -0.11271539f, -0.09438910f, 
    -0.04028952f, -0.10487198f, -0.11103730f, -0.04698715f, -0.06692691f, -0.02965635f, -0.30789605f, 0.30675474f, 
    -0.16248369f, 0.12975460f, 0.06794306f, 0.06958056f, -0.04115965f, 0.05348142f, 0.09008468f, 0.18154396f, 
    -0.51143569f, 0.09219311f, 0.26700190f, -0.28536496f, -0.03437295f, -0.16032986f, -0.05967741f, -0.00142863f, 
    0.16637385f, 0.35339105f, -0.13009228f, -0.18093479f, -0.28701627f, 0.10439429f, 0.35755691f, -0.28083774f, 
    -0.05895645f, 0.05499825f, 0.18678692f, 0.01182239f, -0.24802040f, -0.09820036f, -0.06922851f, 0.02769849f, 
    0.04901481f, -0.01866637f, -0.06865288f, -0.04229092f, -0.04159471f, 0.06601124f, -0.07248101f, 0.05044900f, 
    0.01106567f, -0.07083695f, -0.01305501f, -0.06914420f, -0.07256290f, -0.01999767f, -0.03889903f, 0.05671400f, 
    -0.07259878f, 0.04822645f, -0.07338012f, 0.01411540f, -0.07241614f, -0.01599622f, -0.06468546f, 0.03695359f, 
    0.03830734f, -0.03426608f, -0.02839041f, -0.03597343f, -0.05138238f, 0.00638895f, -0.01713354f, 0.05447545f, 
    0.02598258f, 0.04007496f, -0.04770014f, -0.06686958f, 0.01688260f, -0.05354698f, 0.00994885f, -0.06918553f, 
    0.00314537f, 0.05035320f, -0.01540025f, -0.07282841f, 0.00397898f, -0.00743168f, 0.06029267f, -0.06814676f, 
    0.02761933f, 0.02932237f, 0.00536562f, 0.02044533f, -0.03916144f, -0.04758525f, -0.06718694f, 0.01365679f, 
    -0.02804358f, -0.03145985f, -0.01572329f, -0.03642835f, 0.00406947f, 0.02282512f, -0.01681992f, 0.01282855f, 
    0.02400372f, -0.06634048f, 0.03336955f, 0.00392435f, 0.01849037f, -0.05801886f, -0.02908798f, -0.07149110f, 
    -0.03384172f, -0.07324392f, -0.05073763f, -0.00616916f, 0.04395184f, -0.06005912f, -0.00560932f, 0.03543574f, 
    0.06226488f, 0.00518554f, -0.02540177f, 0.00243129f, -0.06529691f, -0.05478303f, 0.05610096f, 0.00630208f, 
    0.05696016f, 0.02008646f, -0.05689204f, -0.03150598f, 0.03279264f, 0.06788450f, -0.02874305f, 0.04192062f, 
    -0.03464663f, -0.03532137f, 0.00092918f, 0.02760342f, -0.05311629f, -0.04627537f, -0.02812191f, 0.00665500f, 
    -0.00527931f, 0.05504609f, 0.01385708f, 0.01957210f, 0.03360312f, -0.04945447f, -0.02883225f, 0.01302017f, 
    -0.07313629f, -0.00832186f, -0.04382730f, -0.05578182f, -0.05383716f, 0.03057205f, -0.01185456f, 0.01541951f, 
    0.05861011f, -0.07481767f, -0.04035148f, 0.01375699f, -0.06777053f, 0.02806691f, -0.04626960f, -0.05264407f, 
    -0.06758015f, 0.01764490f, 0.05688619f, 0.04873805f, 0.02865630f, 0.05181619f, -0.06736947f, 0.06111098f, 
    0.02175035f, 0.05538897f, -0.05866192f, -0.03221787f, 0.02883776f, 0.03451113f, -0.01144288f, -0.01719244f, 
    0.01807887f, -0.07765107f, -0.01115591f, -0.07735024f, -0.01999095f, 0.00503646f, 0.00875737f, -0.07455992f, 
    0.06298257f, -0.02219058f, 0.00495620f, 0.02074268f, -0.00655160f, 0.00567332f, -0.01919116f, 0.01370929f, 
    -0.00756371f, 0.05115650f, -0.07419223f, -0.05477044f, -0.02824353f, -0.00893210f, -0.01741425f, 0.01544195f, 
    -0.02201745f, -0.00754496f, -0.06147258f, -0.01015576f, 0.05241218f, -0.00630338f, -0.06234695f, -0.00565610f, 
    0.03638657f, -0.04776748f, -0.05787832f, 0.02747058f, 0.05402106f, 0.06099030f, -0.00255167f, -0.02554404f, 
    0.00184749f, -0.01464837f, -0.00859902f, -0.03730986f, 0.05143594f, 0.01653870f, -0.00363341f, 0.00640572f, 
    -0.29770032f, 0.21043497f, 0.05198412f, -0.06939188f, -0.12907840f, 0.14989726f, -0.03004186f, 0.29275578f, 
    -0.01237865f, -0.05896365f, 0.00852192f, 0.04047535f, 0.16400559f, -0.34343788f, 0.04828983f, 0.01500381f, 
    0.10758096f, 0.13552828f, -0.02829508f, 0.03618161f, 0.08744349f, 0.04126414f, 0.12481759f, 0.14621873f, 
    -0.39294881f, 0.29794833f, -0.08825062f, -0.00503579f, -0.04591027f, -0.07354978f, 0.05441659f, 0.15626702f, 
    -0.08347892f, -0.13698256f, 0.03762512f, 0.10766413f, -0.28905392f, 0.22632173f, 0.02242271f, 0.15908571f, 
    0.08919314f, -0.02452345f, -0.02034471f, 0.26051360f, -0.09238593f, -0.06516692f, 0.05035133f, 0.13600813f, 
    0.26977447f, 0.07685961f, 0.19277258f, -0.18621075f, -0.02530168f, -0.13178384f, 0.02108900f, 0.06535342f, 
    0.16035743f, 0.01512826f, 0.00948781f, 0.04362216f, -0.01062332f, -0.28410417f, -0.16235596f, -0.26880884f, 
    -0.12831481f, -0.07378621f, -0.03529275f, -0.01259424f, -0.05668315f, 0.07446641f, 0.01128186f, 0.05790433f, 
    0.01807944f, 0.38640887f, 0.26597255f, -0.15700032f, -0.14033738f, -0.06054313f, -0.04540972f, -0.03854976f, 
    0.11784121f, 0.01539414f, 0.02363298f, -0.17822894f, -0.31262553f, -0.02034302f, 0.00037754f, 0.22786947f, 
    -0.00405073f, 0.03344949f, -0.01268435f, 0.28658846f, 0.04008853f, -0.08780791f, -0.07798041f, -0.02752771f, 
    -0.58243859f, -0.13614415f, -0.34428254f, -0.08587261f, 0.05921014f, -0.15691687f, 0.19738807f, -0.12100331f, 
    -0.04372504f, 0.02084034f, 0.10953539f, 0.20860843f, 0.02130697f, 0.17674492f, -0.35446873f, -0.22740573f, 
    -0.12531279f, -0.11865000f, 0.00947712f, 0.16570859f, 0.07311343f, -0.01170098f, 0.15026298f, -0.40997779f, 
    -0.19251089f, -0.21610880f, 0.13794719f, 0.22200625f, -0.00419694f, 0.08068617f, -0.05480220f, 0.02637638f, 
    0.25842136f, -0.03657908f, -0.07244876f, 0.01968457f, 0.38679540f, -0.08627845f, 0.33571246f, 0.17207073f, 
    -0.03316218f, 0.02318370f, -0.13227522f, 0.00740785f, 0.05533819f, 0.05096997f, 0.02661425f, -0.02372970f, 
    0.17087990f, 0.18119833f, -0.07564458f, 0.30187339f, -0.04290163f, 0.47511914f, -0.04398590f, -0.05527842f, 
    0.01588385f, -0.25059187f, -0.26809734f, -0.11867741f, 0.29058060f, -0.14152029f, -0.20505442f, 0.15883224f, 
    0.20021123f, -0.00764340f, 0.09410482f, 0.08195785f, 0.01307585f, -0.02110790f, 0.09560208f, 0.03058965f, 
    0.23996429f, 0.01964154f, -0.09798311f, 0.26551172f, -0.24710490f, -0.00184958f, -0.00071309f, 0.20927013f, 
    0.14121605f, 0.09219892f, -0.25732982f, -0.14042963f, 0.30379257f, 0.11216347f, 0.02474920f, 0.18220074f, 
    -0.09464974f, 0.08093343f, 0.11094519f, 0.12148876f, 0.18366069f, 0.28778204f, 0.08364542f, 0.13950434f, 
    -0.00870686f, -0.04222050f, -0.06428548f, -0.04532963f, -0.06674484f, 0.01765178f, 0.05939620f, -0.01637521f, 
    0.00677111f, -0.03890822f, -0.00169138f, 0.04857112f, -0.07062166f, 0.00923823f, -0.02554508f, 0.00640214f, 
    -0.06771903f, -0.06066210f, -0.06386446f, 0.05834596f, 0.05388365f, -0.04160363f, -0.03703397f, 0.06222831f, 
    -0.05473267f, -0.05033545f, -0.07504819f, -0.05931159f, 0.03141709f, -0.06691112f, 0.01453847f, 0.04332553f, 
    0.01752013f, -0.04505331f, 0.00849552f, -0.02483159f, -0.05959848f, -0.05908208f, 0.03182235f, -0.04658972f, 
    -0.02659417f, -0.04083826f, -0.06506687f, 0.02933821f, 0.05296594f, -0.00755452f, 0.03471070f, 0.01065590f, 
    -0.05404656f, -0.08294552f, 0.01029440f, 0.00366877f, 0.03424054f, -0.05199741f, -0.06129640f, 0.02768393f, 
    -0.03100606f, -0.03476698f, -0.04734753f, 0.03496221f, 0.05763856f, -0.01602280f, 0.04485650f, -0.00678596f, 
    -0.03536227f, 0.01092221f, 0.05024430f, 0.02534942f, 0.01730138f, -0.05841393f, -0.06012929f, 0.00297492f, 
    -0.06914345f, -0.07441228f, 0.03639886f, 0.02233330f, -0.01983655f, -0.02985753f, -0.05327961f, -0.02700683f, 
    0.02204009f, 0.00982896f, -0.04124241f, -0.04665320f, 0.05689040f, -0.02097163f, -0.08163683f, 0.01506290f, 
    0.03346958f, -0.02587955f, -0.01464502f, -0.01402108f, 0.05287253f, -0.03277144f, 0.00559454f, 0.00521840f, 
    -0.07215050f, -0.06327753f, 0.03210800f, 0.00528070f, -0.04431247f, -0.04891952f, 0.00328764f, 0.03978064f, 
    0.00616411f, -0.02851522f, 0.02785474f, -0.07297709f, 0.01493883f, 0.00424513f, 0.05960182f, -0.03359949f, 
    0.05277538f, -0.08091532f, -0.01696222f, -0.01824692f, 0.01308686f, 0.04157401f, 0.00688792f, -0.00776124f, 
    0.01833033f, -0.02997807f, -0.05543178f, 0.00593863f, 0.03513623f, -0.06952670f, 0.02137568f, -0.05931979f, 
    0.05021824f, 0.03956856f, -0.06435174f, 0.01000703f, 0.04002106f, 0.00847682f, -0.07703792f, -0.05636858f, 
    -0.08251455f, -0.06104479f, -0.01849956f, 0.04440191f, -0.04928383f, 0.05029167f, -0.02194981f, 0.01791040f, 
    0.03088314f, 0.01848519f, 0.00245083f, -0.04176119f, 0.03021516f, 0.02506826f, 0.03032487f, 0.03623139f, 
    0.04034562f, 0.03156690f, -0.04616114f, -0.08422535f, -0.07548728f, 0.03552875f, 0.04164134f, -0.08380981f, 
    -0.04007713f, 0.05184032f, -0.07512603f, 0.05440795f, 0.03759029f, -0.05224839f, -0.05645798f, 0.01753921f, 
    -0.07976062f, -0.04486536f, 0.02161618f, -0.02637309f, -0.06433588f, -0.04479966f, 0.00483832f, -0.01664137f, 
    -0.02187512f, 0.02276552f, -0.06881931f, 0.00837240f, 0.01468549f, 0.02018211f, 0.00617573f, 0.04299259f, 
    -0.06783103f, 0.04749035f, -0.05743468f, -0.07666182f, -0.06396463f, 0.06035810f, 0.02328234f, 0.00768899f, 
    -0.21021733f, 0.37767953f, -0.03482763f, -0.01959854f, 0.00130815f, 0.25516355f, 0.04322423f, 0.08321951f, 
    -0.00500417f, -0.09542779f, -0.04722335f, -0.04165622f, 0.29355317f, -0.03074998f, 0.10893027f, 0.05518361f, 
    -0.15744966f, 0.09317494f, -0.03487250f, -0.07424103f, -0.17713667f, -0.16368027f, -0.09390182f, 0.02315062f, 
    0.27352342f, 0.16536991f, -0.39379349f, 0.27347955f, 0.11136317f, -0.06826197f, -0.04126700f, 0.14659241f, 
    -0.00717885f, -0.11424792f, -0.06052222f, -0.09973177f, -0.09781242f, -0.02296768f, 0.10955998f, -0.04966658f, 
    0.13808285f, 0.01685644f, 0.00729355f, 0.00672553f, 0.04141664f, 0.09337388f, 0.31231961f, 0.19079015f, 
    0.21712865f, 0.04042813f, -0.20554455f, -0.32940423f, 0.03250764f, 0.11091068f, 0.12365999f, 0.01610564f, 
    -0.10690093f, 0.08263907f, 0.10939237f, 0.07731286f, -0.20831083f, -0.32624468f, -0.03460404f, 0.07321753f, 
    0.02711630f, -0.23764046f, 0.03259829f, 0.18890077f, 0.17771651f, 0.04760253f, 0.12958930f, 0.13137770f, 
    0.22682327f, 0.15750217f, 0.05690803f, -0.05041727f, -0.16326879f, 0.13268404f, -0.07259825f, 0.12800820f, 
    0.08610664f, 0.02188891f, -0.01647635f, 0.08518419f, 0.14411668f, 0.24237496f, -0.32329926f, 0.23062737f, 
    0.23597704f, 0.16142969f, -0.08334830f, -0.07951746f, -0.07252672f, 0.08036816f, 0.07064498f, 0.07250536f, 
    -0.00789521f, -0.34075096f, 0.03092456f, -0.34628704f, -0.06112066f, -0.03600212f, 0.09845422f, 0.23032582f, 
    0.04614234f, 0.12229895f, 0.16760331f, 0.22078303f, 0.30986959f, -0.05178698f, -0.24302197f, 0.02410440f, 
    -0.12029105f, 0.03883865f, -0.02279901f, 0.36467710f, -0.02786344f, -0.03895650f, 0.15900174f, -0.16034263f, 
    -0.42457387f, -0.19303301f, 0.13328911f, 0.18319792f, -0.11261752f, -0.02684214f, 0.07129098f, 0.04748793f, 
    0.18631896f, 0.01087340f, -0.23678797f, -0.05302872f, 0.37206292f, -0.02477803f, -0.03097215f, -0.22392079f, 
    0.10492461f, -0.09532723f, -0.12584315f, 0.01299763f, 0.01387368f, 0.08459292f, -0.18257052f, -0.22331081f, 
    -0.01213471f, -0.12936679f, -0.12450806f, 0.20512398f, -0.05409700f, 0.18097544f, 0.06115578f, -0.08850708f, 
    -0.00779921f, -0.24130826f, -0.05873540f, -0.02450999f, 0.16020030f, 0.11181799f, -0.34427142f, 0.26861361f, 
    0.14967708f, -0.12754309f, -0.19668972f, 0.01137758f, 0.11731181f, 0.04814668f, 0.04545089f, 0.00214808f, 
    0.18211806f, -0.02213266f, 0.15854803f, 0.05614224f, -0.08217832f, -0.28087243f, -0.00094917f, 0.08336680f, 
    -0.01781031f, 0.06722251f, -0.18498747f, -0.17857634f, 0.56218034f, -0.02981828f, 0.06363849f, -0.00555248f, 
    -0.08606321f, -0.01581592f, 0.23424302f, 0.06679940f, 0.06876663f, 0.01048236f, 0.06260949f, 0.09859673f, 
    -0.12428018f, -0.12502411f, 0.19550663f, 0.24271025f, -0.19385126f, 0.09289353f, 0.01237252f, -0.11051997f, 
    -0.00664135f, 0.08784630f, 0.05871173f, 0.11640641f, 0.17743813f, -0.28870782f, -0.02085688f, 0.09477449f, 
    0.14229676f, -0.23012608f, 0.15669200f, 0.03335838f, 0.04762294f, -0.05216033f, -0.03131005f, 0.01095049f, 
    0.12085359f, -0.07414087f, -0.27490428f, 0.13682006f, -0.02914687f, 0.01896737f, -0.01623471f, -0.05723588f, 
    0.15893218f, -0.04207736f, 0.04927691f, -0.08911850f, -0.79790717f, 0.15182447f, -0.21971069f, -0.27090579f, 
    0.05127495f, 0.17132775f, -0.05271000f, 0.29791757f, -0.00225499f, 0.16924137f, 0.08965985f, -0.12063713f, 
    0.41127643f, -0.19008641f, -0.12160079f, 0.38786635f, 0.15426998f, 0.20595759f, 0.07980779f, -0.09216157f, 
    -0.16295907f, 0.04008328f, 0.03935842f, -0.03949410f, -0.16174060f, -0.32737043f, -0.07643645f, -0.08044047f, 
    -0.04402217f, -0.04169675f, 0.13869615f, -0.09214016f, 0.00079973f, -0.02040187f, 0.14947553f, -0.12661898f, 
    0.22992514f, 0.00950257f, -0.12620096f, 0.31869465f, 0.02991825f, -0.13938706f, 0.01679169f, 0.15961772f, 
    0.29785100f, 0.17597930f, 0.06609900f, 0.05487158f, 0.29081526f, 0.12223978f, -0.29048437f, -0.34426671f, 
    -0.07375802f, -0.04503193f, -0.01992274f, 0.13097061f, -0.15824431f, 0.14199531f, 0.19909155f, 0.11345681f, 
    0.20961973f, -0.40561077f, 0.00834864f, 0.05079923f, 0.07487072f, -0.04553584f, -0.18978886f, -0.08572435f, 
    -0.02462739f, -0.18652876f, 0.02341896f, -0.08217274f, 0.23907419f, 0.13706361f, 0.13670690f, -0.04685592f, 
    -0.02174316f, 0.09136103f, -0.02511640f, -0.00620455f, -0.16736791f, 0.02082366f, -0.25227472f, 0.30849844f, 
    -0.08374856f, 0.34216511f, -0.11196052f, -0.03950845f, 0.22167653f, -0.05043075f, 0.06197701f, 0.09467026f, 
    -0.10412932f, 0.10040734f, -0.02186842f, 0.10673344f, 0.06944129f, -0.32376835f, 0.25949004f, 0.22682671f, 
    0.02180393f, -0.06957441f, 0.21851029f, 0.07675362f, 0.25288585f, 0.11259214f, 0.08395500f, 0.11114462f, 
    0.13773943f, 0.03644469f, -0.01285110f, 0.04445110f, 0.13562855f, -0.19041085f, 0.05736916f, 0.13389166f, 
    -0.05660710f, 0.02679329f, 0.30387881f, 0.14883460f, -0.04976676f, -0.53767973f, 0.22046784f, -0.16685443f, 
    0.07203321f, 0.00399555f, -0.10144350f, -0.00681465f, 0.18638399f, 0.00188789f, 0.01563699f, 0.03715040f, 
    0.07747591f, -0.16992038f, 0.12352065f, 0.12840740f, 0.19681217f, -0.01579885f, 0.08958263f, -0.16591048f, 
    0.13279243f, -0.00701609f, 0.14450990f, 0.29224327f, 0.02265108f, 0.23964581f, -0.09240852f, 0.00807619f, 
    0.16809316f, 0.09402934f, 0.08558798f, 0.07606938f, 0.18928345f, -0.08306867f, -0.26692909f, -0.04955860f, 
    -0.06680723f, 0.33071119f, -0.08812446f, 0.21817812f, 0.00978053f, -0.18837740f, -0.08551396f, 0.08344667f, 
    0.08443866f, -0.07350070f, 0.01048597f, -0.23036675f, 0.02589265f, 0.24190693f, 0.07851461f, 0.09080814f, 
    0.03090098f, 0.21033968f, 0.13118106f, 0.01837273f, 0.03485111f, 0.15133226f, 0.29723978f, 0.07485048f, 
    0.43331629f, 0.04277471f, 0.29020181f, -0.00273938f, -0.08929907f, -0.09497751f, -0.07629573f, -0.20657843f, 
    -0.04823428f, -0.02304962f, 0.13765061f, -0.10037047f, 0.16534552f, -0.14044793f, -0.09874648f, -0.17333594f, 
    0.02126418f, -0.04319194f, -0.20994277f, -0.04876354f, -0.04479622f, 0.05393752f, 0.00047949f, 0.09116517f, 
    -0.36973429f, -0.24688363f, -0.12843335f, 0.28152707f, -0.00664935f, -0.04229867f, -0.08058772f, 0.00676626f, 
    0.06536326f, 0.07961668f, 0.08236775f, 0.03395373f, 0.09361849f, 0.33801860f, 0.28926107f, 0.07298458f, 
    -0.14574327f, 0.04099751f, -0.13510993f, -0.01369853f, -0.00263848f, 0.15341371f, 0.04484278f, 0.09496442f, 
    0.64098197f, -0.00157424f, -0.11562407f, -0.05055368f, 0.16450898f, 0.12478467f, -0.11947085f, 0.09382965f, 
    -0.13936545f, -0.04035483f, 0.00865318f, 0.12160844f, 0.49766925f, -0.38052753f, 0.33138463f, 0.20624436f, 
    -0.12598689f, -0.04509811f, -0.10960340f, -0.03279216f, 0.07664407f, 0.03208435f, -0.05822996f, 0.04402888f, 
    -0.29457822f, 0.33358499f, 0.11245584f, 0.18265250f, -0.03476014f, 0.11065159f, 0.23170893f, 0.22529112f, 
    0.13252808f, -0.02800707f, 0.09714948f, -0.01534683f, 0.08089264f, 0.11996929f, 0.14870712f, -0.21287753f, 
    0.07063298f, -0.04802733f, 0.07937230f, -0.23544271f, 0.03214428f, -0.13258870f, -0.04762277f, -0.01580101f, 
    -0.11837889f, 0.13043576f, -0.28477150f, -0.41141316f, 0.21755248f, -0.07072144f, 0.13827811f, 0.21055505f, 
    0.11721999f, 0.26466569f, -0.15626742f, -0.02868473f, 0.12717021f, -0.09326612f, -0.27566338f, -0.34162456f, 
    0.12757817f, 0.11361890f, 0.03137008f, -0.11269992f, 0.08099945f, 0.19910036f, -0.08600643f, -0.08853388f, 
    -0.18077029f, 0.25687596f, -0.03563377f, -0.14005633f, 0.02969952f, -0.07050180f, 0.06591181f, -0.08920915f, 
    -0.27497295f, 0.04306546f, -0.07461467f, 0.01327340f, -0.43992838f, -0.27925932f, 0.30012208f, 0.14919233f, 
    0.03232801f, -0.09205989f, 0.06602273f, 0.02333585f, 0.02500432f, 0.00313149f, -0.10654667f, 0.11592387f, 
    0.16094989f, 0.38317883f, -0.03300788f, -0.19677928f, 0.22503394f, 0.01276082f, -0.10386428f, -0.17380941f, 
    0.00501754f, 0.03276047f, -0.16982713f, 0.09009520f, -0.13664781f, 0.61218071f, -0.11137665f, -0.30541933f, 
    0.17031984f, -0.08865000f, -0.03520526f, 0.05448803f, -0.00552752f, 0.07449883f, 0.13688932f, 0.19040300f, 
    -0.38193396f, 0.28988940f, 0.12265643f, 0.22314237f, -0.03694393f, -0.03662764f, 0.11168551f, -0.04905841f, 
    -0.01307305f, -0.02674247f, 0.05784612f, -0.10109495f, 0.41388863f, 0.11786340f, 0.27717578f, -0.10495618f, 
    -0.08415081f, -0.16662657f, 0.04922829f, -0.01821416f, -0.07932856f, 0.04986772f, -0.06142247f, -0.00984913f, 
    -0.31126449f, -0.09732289f, -0.35581926f, -0.26150417f, 0.31490001f, 0.07933804f, -0.03914250f, -0.08738675f, 
    0.36727458f, 0.07571083f, 0.01698507f, 0.19523962f, -0.19408393f, 0.14352742f, 0.24613234f, 0.08160221f, 
    0.00792329f, 0.09436339f, 0.18560320f, -0.10080642f, -0.03799206f, -0.02793754f, -0.03771073f, -0.06625799f, 
    -0.13418841f, -0.22786325f, 0.17946605f, 0.20288771f, -0.05844835f, -0.08418372f, 0.12266892f, -0.11410088f, 
    -0.01860170f, -0.13887812f, -0.14633933f, 0.03795826f, -0.20007224f, -0.16009313f, -0.12437765f, -0.07774403f, 
    0.02297315f, 0.04905820f, 0.06512162f, -0.09989626f, 0.09289003f, 0.06185815f, -0.01166972f, -0.14564607f, 
    0.40560696f, 0.49513957f, -0.24473763f, 0.10610744f, -0.13701804f, -0.16741730f, 0.03533923f, 0.11763773f, 
    -0.10201724f, -0.01874693f, -0.03924861f, 0.09861496f, -0.21472122f, -0.09586415f, 0.13791101f, -0.07726009f, 
    0.02242526f, 0.18638319f, 0.05477306f, -0.10292323f, 0.10421513f, 0.15893130f, 0.24615084f, -0.04688244f, 
    -0.00318859f, 0.14793137f, -0.17871548f, -0.52368289f, 0.39522302f, -0.00930099f, -0.06996927f, -0.12135322f, 
    0.09621952f, -0.18882555f, -0.04620540f, -0.00148293f, -0.09410969f, -0.08908766f, -0.23035172f, -0.06700963f, 
    0.09007481f, 0.14485110f, -0.03545013f, -0.15737242f, 0.03094278f, 0.11509322f, -0.09246574f, 0.19738090f, 
    -0.24465904f, -0.12788640f, -0.20059359f, -0.03034611f, 0.26375559f, -0.01376917f, 0.10324030f, -0.10167691f, 
    -0.06140124f, -0.08220562f, 0.05106985f, 0.07764112f, 0.32839799f, -0.04921909f, 0.41250506f, 0.31414843f, 
    -0.28715551f, -0.04265441f, 0.11022260f, 0.06486844f, -0.07498065f, 0.07854119f, 0.02745397f, 0.02987158f, 
    -0.14243478f, 0.02098155f, 0.01444022f, -0.23590130f, 0.10892004f, -0.11312646f, 0.19316775f, 0.10492563f, 
    -0.24416627f, 0.08925416f, 0.14188369f, -0.02501982f, 0.23618223f, -0.27988303f, 0.33556929f, -0.02896146f, 
    -0.13889688f, -0.10047679f, -0.10533485f, -0.10717110f, 0.00995184f, 0.05337542f, -0.09110658f, 0.02899709f, 
    0.47552970f, 0.38480309f, 0.11810961f, 0.28850344f, -0.11253113f, 0.07826197f, 0.19464877f, -0.03142931f, 
    0.04236134f, -0.11154075f, 0.01176246f, 0.08807959f, 0.10603813f, 0.43368086f, 0.09365575f, 0.06974022f, 
    0.15453592f, -0.03700952f, -0.08501472f, 0.00561714f, 0.06889498f, -0.10175233f, -0.16863596f, 0.07183117f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11142513f, 0.04356941f, 0.04061780f, 0.00025209f, -0.06117740f, -0.05409526f, 0.01581573f, 0.07520790f, 
    0.01114181f, 0.10656995f, -0.13407120f, -0.00283546f, -0.05656428f, -0.04133411f, 0.10135337f, 0.12549485f, 
    -0.06528062f, -0.02103206f, 0.16057283f, -0.03595915f, 0.07211685f, -0.05144235f, 0.00888764f, 0.01681385f, 
    0.08581455f, -0.02611429f, -0.04661506f, -0.06052599f, 0.10180148f, 0.25121978f, 0.01885366f, -0.00811449f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.33290902f, 0.10291830f, -0.52756608f, 0.27784914f, 0.12005774f, 0.00136622f, 0.12317891f, 0.15042853f, 
    0.14379574f, 0.20981352f, 0.19036944f, 0.04769808f, -0.15082498f, -0.02200226f, -0.21562554f, -0.68852144f, 
    0.14757568f, 0.19783899f, -1.15258825f, 0.09944858f, -0.40341651f, 0.04375120f, -0.56725413f, 0.03065444f, 
    0.12405366f, -0.05769561f, 0.46756524f, 0.13769020f, 0.25371289f, -0.41043532f, -0.02009606f, 0.30759022f, 
    -0.18105608f, 0.28030905f, -0.43027991f, -0.21050459f, -0.05856769f, -0.15232770f, 0.08807889f, -0.13963060f, 
    0.02054359f, 0.30593637f, 0.19092883f, 0.15038463f, -0.14343858f, -0.16959310f, -0.00738670f, -0.55068433f, 
    -0.71705276f, -0.23619694f, -0.06038239f, 0.15343536f, -0.07391097f, 0.24699803f, -0.02283820f, -0.15163767f, 
    0.10243841f, 0.15458128f, -0.08563526f, -0.04583624f, 0.35937926f, 0.29541636f, -0.20707472f, 0.30726433f, 
    -0.38760355f, 0.08186436f, 0.61465621f, -0.46286684f, 0.00943347f, -0.11163253f, 0.12338107f, -0.39483449f, 
    -0.10646378f, -0.41223907f, 0.35610229f, -0.04101129f, 0.07683084f, -0.01683684f, 0.22303645f, -0.36153159f, 
    0.06096556f, -0.04905333f, 0.59979987f, -0.01865242f, -0.61748338f, 0.24486437f, -0.61534369f, 0.10388631f, 
    -0.15508629f, 0.10004126f, -0.04065076f, 0.02681532f, 0.03918854f, -0.16124645f, 0.40854588f, -0.02110744f, 
    0.14077213f, -0.15968208f, -0.10261926f, 0.20103937f, -1.21600282f, 0.12010778f, -0.15399903f, -0.47457784f, 
    -0.02331273f, 0.29315138f, 0.15859425f, 0.06132988f, 0.10783596f, -0.00610550f, -0.16420530f, 0.30887848f, 
    0.40512294f, 0.33074388f, 0.35187218f, 0.09884358f, -0.66024125f, -0.23717299f, 0.07334410f, 0.04356411f, 
    -0.34672394f, -0.08159561f, 0.38169357f, -0.01245988f, 0.07974932f, 0.04779613f, -0.48381364f, -0.52734661f, 
    0.19219802f, 0.03556909f, 0.10836609f, -0.16804856f, 0.13205321f, -0.13625611f, -0.01984104f, 0.00539440f, 
    0.04704743f, -0.11427493f, 0.41928434f, -0.04868389f, 0.09166614f, 0.15358181f, -0.34270832f, -0.04542289f, 
    0.23536542f, 0.00004388f, 0.06980353f, 0.03626077f, 0.62241817f, -0.07725591f, 0.05477101f, -0.02762388f, 
    0.17610326f, 0.11748751f, 0.21472022f, -0.15049730f, 0.01520532f, -0.18959945f, -0.96630746f, -0.32148358f, 
    0.02869245f, 0.17625810f, 0.01905259f, 0.26506144f, 0.18744671f, -0.14058314f, 0.16316544f, -0.04602515f, 
    -0.03800819f, 0.05413241f, -0.84023905f, -0.13510904f, 0.09487227f, -0.11449901f, -0.29727080f, -0.41457215f, 
    0.29856628f, -0.17781235f, -0.37930959f, -0.00118804f, 0.37213880f, -0.14884998f, 0.45595455f, -0.10610861f, 
    -0.42137268f, 0.10817318f, -0.15653887f, -0.05288721f, -0.22570109f, 0.13366075f, -0.22100639f, 0.43108815f, 
    -0.34812868f, -0.85288084f, -0.23681809f, -0.22488362f, 0.22268710f, 0.03144538f, -0.09194969f, -0.24414261f, 
    -0.02785664f, 0.17132635f, -0.19161044f, -0.09297746f, 0.09903843f, 0.12316127f, 0.34773901f, 0.21575901f, 
    0.39296684f, -0.45297036f, 0.31032085f, -0.08247403f, 0.15197299f, -0.24073654f, 0.11419306f, 0.09297059f, 
    0.24271646f, 0.14949322f, 0.06049840f, 0.06912104f, -0.16449563f, -0.12346349f, 0.34994173f, 0.25509217f, 
    0.30528429f, -0.20143463f, 0.03669694f, 0.41601411f, -0.29165345f, -0.12273032f, -0.10145749f, -0.47972649f, 
    0.06045863f, -0.61295289f, 0.24912843f, -0.01184368f, 0.13590378f, 0.11596638f, -0.71251100f, 0.25863877f, 
    -0.27573490f, 0.21630765f, 0.17339785f, -0.09250883f, 0.11375444f, -0.30324134f, 0.07111857f, -0.01194296f, 
    0.37240046f, -0.02904188f, -0.99831748f, 0.04533381f, -0.59091991f, -0.28332293f, 0.22559276f, -0.27311817f, 
    0.17365855f, 0.12363547f, -0.21780065f, -0.69491953f, 0.21959318f, 0.07106178f, -0.15966700f, 0.25784820f, 
    0.14261630f, 0.15456128f, 0.08648796f, -0.10472818f, -0.02179188f, -0.02333589f, 0.13631353f, 0.07483093f, 
    -0.50510561f, 0.27221042f, -0.30575705f, -0.13575894f, -0.13531089f, 0.44933978f, 0.24914998f, -0.07592813f, 
    -0.59103894f, -0.11833818f, -0.35407239f, 0.15357016f, -0.85853446f, -0.26063180f, 0.31502017f, 0.00611061f, 
    -0.47899339f, 0.17508794f, 0.39986527f, 0.15249656f, 0.16072033f, 0.14712779f, -0.14702816f, 0.33380800f, 
    -0.10356338f, -0.95975196f, -0.19520019f, -0.08790454f, -0.10018901f, -0.10652613f, 0.41157711f, 0.39712703f, 
    0.06524011f, -0.54515755f, -0.28294364f, -0.13675937f, -0.11782205f, -0.21994877f, 0.28415263f, -0.15700825f, 
    0.17147842f, 0.11295182f, -0.34399983f, -0.00162880f, 0.42421266f, -0.49387333f, 0.11806771f, -0.51525080f, 
    0.08458160f, 0.04387892f, 0.47827351f, -0.06202633f, -0.86542457f, -0.17377812f, -0.02068814f, 0.58893931f, 
    0.03377139f, 0.49259716f, -0.34305048f, -0.15571471f, 0.15003167f, 0.05189455f, 0.15488724f, -0.16142899f, 
    0.03659529f, -0.15175831f, 0.13944797f, -0.04586071f, -0.01725936f, -0.29433554f, -0.53079206f, 0.09173593f, 
    0.45419794f, -0.12814201f, -0.52118248f, -0.07121085f, -0.58278120f, 0.37051284f, 0.07279530f, -0.41347900f, 
    0.45174232f, -0.16713579f, -0.67237997f, 0.04495117f, 0.18284111f, 0.09865514f, 0.09872054f, 0.10204814f, 
    0.02817501f, -0.30086526f, -0.64008594f, -0.16193478f, -0.15585060f, 0.02859141f, -0.32632971f, 0.31833935f, 
    -0.49810833f, -0.23776472f, -0.01116387f, -0.04051685f, -0.68014157f, -0.42979360f, -0.49093592f, -0.12033013f, 
    -0.33208907f, 0.12531154f, 0.37742561f, 0.05744977f, 0.17201553f, 0.47561356f, 0.50453621f, 0.09680539f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07094327f, 0.22057718f, -0.02857257f, 0.09974386f, -0.14820644f, -0.16107479f, -0.02561820f, 0.08151517f, 
    0.07149687f, -0.17412387f, 0.04060481f, 0.13029084f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
