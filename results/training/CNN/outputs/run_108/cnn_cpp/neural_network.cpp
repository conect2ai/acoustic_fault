#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20875204f, -1.38420713f, -0.29386178f, -1.08575666f, 0.03935511f, -0.01556578f, -0.11672936f, 0.33273858f, 
    0.73229778f, -0.68860483f, -0.31255740f, -0.60578299f, -0.87468690f, 0.01165816f, -1.11947370f, -0.77255327f, 
    -0.29964197f, -0.59194249f, -1.14962363f, -0.55548543f, -0.99768871f, -0.05583530f, 1.04092526f, 0.39131755f, 
    0.00046675f, -0.50365686f, -0.42159173f, -0.06718250f, 0.47461870f, 0.98236322f, -1.37905979f, -0.58224231f, 
    -0.73347974f, -0.08490542f, 0.67707640f, -0.21338327f, -0.30543765f, 1.61469555f, -0.50092036f, 0.45264974f, 
    -0.57023662f, -1.00337577f, 0.21155153f, 0.01900857f, -0.27906430f, -0.60419899f, -0.52571762f, 1.06089389f, 
    0.71144664f, -0.16615584f, 0.20628589f, 0.78398818f, 0.57372034f, 0.85059327f, -1.53220212f, -0.97763479f, 
    -0.71059525f, -0.04386295f, -0.73757797f, 0.82811242f, -0.03117759f, 0.35403469f, 0.25835583f, -0.99038345f, 
    -0.76648295f, 0.85865360f, 0.54064804f, -0.04118881f, -1.34982097f, 0.03957431f, 0.22688396f, -0.22075434f, 
    0.71592820f, -0.84949893f, -0.44037914f, 1.12428451f, 0.81379741f, -0.27707812f, -0.82251287f, -0.27790895f, 
    -0.26116419f, -1.01260328f, 0.25308612f, 0.51946944f, 0.89345092f, 1.33333325f, -0.11919440f, -0.28872561f, 
    -0.28085017f, -0.16870451f, 1.34012616f, 0.68684137f, 1.13178658f, 0.20855559f, 0.39552239f, 0.35925314f, 
    0.08039983f, 0.79987031f, 0.41637552f, 1.27687204f, 1.20082998f, 0.97611159f, -0.58924824f, 0.54023689f, 
    -0.71661103f, 0.04505861f, -0.40029937f, -0.08278703f, 1.00796783f, 0.07172529f, 1.09779525f, 0.59828520f, 
    -1.03919017f, 0.51617801f, -0.16164263f, -0.41582394f, -0.13903947f, 0.94013602f, 0.78600979f, 0.56284255f, 
    -0.43273398f, -1.43388784f, 0.23278046f, 0.73321521f, 0.66844553f, -0.05998708f, -0.94503874f, -1.09978878f, 
    -0.54082131f, 0.87755567f, 1.28577268f, -0.06028515f, 0.21500699f, 0.33644366f, -0.37673983f, -0.37542388f, 
    0.06745512f, 0.20209289f, 0.58904713f, 1.18169916f, 1.28977287f, 0.04174089f, -0.29054877f, 0.23807092f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03806788f, 0.62757891f, 0.15402576f, 0.36195913f, 0.02093574f, 0.11390513f, 0.06281211f, -0.06246908f, 
    0.00290748f, -0.40875825f, 0.61556065f, 0.40246749f, 0.32511720f, -0.05416923f, 0.25470462f, -0.00159360f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.24900991f, -0.58421725f, -0.16014296f, -0.10680187f, -0.12749517f, -0.07249311f, 0.12188400f, -0.27912816f, 
    0.04886208f, -0.11829139f, 0.18872125f, -0.07213710f, 0.09401242f, 0.25348124f, 0.06723670f, 0.10004056f, 
    0.09083439f, -0.11470181f, -0.30055940f, -0.23719756f, -0.65514922f, 0.15279356f, 0.10400870f, 0.25598106f, 
    0.19231677f, -0.30249807f, 0.15080398f, 0.33708143f, 0.27431613f, 0.31586501f, -0.12636995f, 0.00556183f, 
    0.01920230f, 0.04837707f, 0.21100467f, 0.41306305f, 0.05271912f, 0.04728486f, 0.27197161f, -0.06060268f, 
    0.15044604f, -0.20282942f, -0.02844043f, 0.08028565f, 0.01891183f, -0.38564834f, -0.42795658f, 0.04108390f, 
    0.16260134f, -0.15902461f, -0.12907989f, 0.02530657f, 0.04502911f, -0.11023005f, -0.73959690f, -0.42948118f, 
    -0.71646738f, 0.60356694f, 0.34362769f, 0.16056763f, 0.07628829f, 0.03476284f, 0.02698293f, -0.13873562f, 
    -0.27203834f, -0.02140395f, 0.22602968f, 0.05946269f, -0.10679062f, -0.01088343f, 0.42911461f, 0.15519914f, 
    -0.20236653f, -0.32455581f, -0.30082384f, -0.18140982f, -0.30829877f, -0.07668120f, 0.00693761f, 0.10817992f, 
    0.04114115f, 0.05496074f, 0.01617777f, 0.16380215f, 0.13328940f, -0.07486206f, -0.01068667f, 0.06082502f, 
    -0.19333093f, -0.00571709f, -0.06325706f, 0.30553892f, 0.41248673f, 0.22777037f, 0.20810366f, -0.05367668f, 
    0.27065793f, -0.01700355f, 0.10294303f, -0.39573872f, 0.57543999f, 0.72311217f, -0.11420623f, 0.13995174f, 
    -0.05384884f, -0.11314188f, 0.16474381f, 0.09734033f, -0.10126673f, 0.06509387f, 0.30665043f, 0.29506627f, 
    0.12370811f, 0.14688596f, 0.12915319f, 0.23802108f, 0.18621260f, 0.03723871f, 0.14807828f, 0.20003417f, 
    -0.37475827f, 0.09009597f, -0.13175583f, 0.01329702f, 0.22791679f, 0.04923068f, -0.31963453f, -0.19473395f, 
    -0.55744940f, 0.29821754f, 0.01210658f, 0.14410211f, -0.00209923f, -0.17208837f, -0.21629499f, 0.12706514f, 
    -0.01178660f, -0.02773918f, 0.32772142f, 0.31918487f, 0.20700449f, 0.15150024f, -0.06637812f, -0.05937638f, 
    -0.08321358f, 0.07173285f, -0.22172424f, -0.11095158f, -0.12430811f, -0.16314018f, 0.37553370f, 0.23956281f, 
    0.05098689f, -0.19602816f, 0.13607718f, -0.17163707f, -0.38021311f, 0.09568963f, -0.29702181f, 0.06860598f, 
    0.21012965f, 0.08565783f, -0.18480647f, 0.27435204f, 0.19834810f, -0.31181538f, 0.13795255f, -0.04430652f, 
    -0.20353903f, 0.15212837f, 0.33911794f, 0.15215713f, 0.22338980f, 0.25211903f, 0.23391055f, -0.00356411f, 
    -0.20157890f, 0.03218772f, -0.08262420f, 0.08579692f, 0.70872444f, -0.02797847f, 0.33703738f, -0.02654971f, 
    0.09043898f, -0.01317846f, -0.00003053f, 0.16303818f, 0.17471284f, -0.15247545f, -0.01940519f, -0.29215378f, 
    0.23797034f, 0.19735189f, 0.24918440f, -0.03614376f, -0.11291989f, -0.34693047f, 0.05380211f, 0.01712446f, 
    -0.16336685f, -0.19617622f, 0.32119304f, -0.22886723f, 0.23063944f, -0.09302475f, -0.02426333f, 0.20088035f, 
    -0.13226213f, -0.07496460f, 0.03773456f, -0.18213157f, -0.05289736f, 0.19580321f, -0.01876939f, -0.06377513f, 
    -0.09053186f, 0.05013418f, 0.07632329f, -0.02191862f, -0.32530937f, 0.10213235f, -0.06005563f, 0.14668073f, 
    -0.06206641f, 0.30697122f, 0.19627689f, 0.15108101f, 0.06112399f, 0.09155388f, 0.19197579f, -0.23878956f, 
    -0.11441673f, -0.20941217f, -0.14523797f, -0.36689296f, -0.08502880f, -0.05971748f, 0.09986681f, -0.00980880f, 
    0.09703793f, -0.01219328f, -0.06848112f, 0.41613182f, 0.07140300f, -0.02748660f, -0.13225111f, 0.07570608f, 
    0.05076854f, 0.07084111f, 0.08528202f, -0.08628618f, -0.23587918f, -0.37892127f, -0.32740358f, 0.07920761f, 
    0.19008224f, 0.15344821f, 0.03839637f, -0.00588504f, -0.04502732f, 0.17702655f, -0.34646907f, -0.11576877f, 
    0.23299840f, 0.07500932f, -0.09619970f, -0.06423848f, 0.16170391f, -0.20022558f, -0.46821794f, 0.19254673f, 
    0.18910268f, 0.09233080f, 0.00690904f, -0.22222236f, -0.33020392f, 0.10193339f, 0.19582961f, -0.78231031f, 
    0.00624229f, 0.03333138f, 0.22705300f, 0.14805713f, 0.41487190f, -0.10293416f, 0.02679696f, -0.05509846f, 
    -0.08041502f, -0.04849770f, -0.05088541f, 0.00437485f, 0.06272507f, 0.06386666f, 0.00313921f, -0.01091367f, 
    -0.06337177f, 0.06344925f, 0.03461901f, -0.03332045f, 0.05967336f, -0.03626629f, 0.07395126f, 0.00725614f, 
    -0.08005104f, -0.07088882f, -0.02186196f, 0.06314214f, -0.02235910f, -0.06092717f, 0.03551451f, -0.03713320f, 
    -0.01297380f, -0.08001273f, 0.02226288f, 0.05309307f, -0.02823182f, 0.03187462f, -0.04785420f, 0.01776681f, 
    -0.07413258f, 0.04007973f, 0.06379151f, -0.07895692f, -0.07584457f, -0.03040624f, -0.07116307f, -0.06699194f, 
    -0.06717970f, -0.06961167f, -0.07389374f, 0.06846899f, 0.03317576f, 0.04130588f, 0.01525226f, 0.06539737f, 
    0.03989520f, -0.06277751f, -0.01736760f, -0.06405579f, 0.02649828f, -0.04362215f, -0.04410423f, -0.02482522f, 
    -0.08331291f, -0.00329702f, 0.05517391f, -0.04075473f, 0.05387453f, -0.04498293f, -0.01140464f, -0.02530557f, 
    0.01420170f, -0.02739453f, -0.06137855f, -0.07481448f, 0.04693490f, -0.00227273f, -0.04334464f, 0.05391194f, 
    0.02969356f, -0.00221491f, -0.06448500f, -0.07849769f, 0.00657172f, 0.07017335f, 0.03482578f, 0.03480977f, 
    -0.05354136f, -0.07863452f, -0.07798129f, -0.01844707f, 0.07951245f, -0.02423088f, -0.05758377f, -0.01848052f, 
    0.03644477f, 0.02437435f, 0.04400646f, -0.03438741f, -0.01740254f, 0.01198530f, 0.01440925f, -0.08687031f, 
    0.02635205f, -0.04342658f, 0.00736008f, 0.00806924f, -0.06053889f, 0.05119221f, -0.00708310f, 0.03838287f, 
    0.05458348f, 0.06826775f, -0.06846200f, -0.02524252f, -0.04619543f, 0.00266564f, 0.00732819f, -0.02182964f, 
    0.06099984f, -0.03899833f, -0.03165802f, 0.04657753f, -0.07935134f, 0.00573677f, -0.01317367f, -0.07842999f, 
    -0.00002803f, -0.00285060f, 0.01360753f, 0.05485336f, -0.06753050f, 0.02022288f, -0.02486501f, -0.06951474f, 
    0.05717270f, -0.01047456f, -0.08609649f, -0.03206595f, -0.04464854f, -0.07376409f, 0.03944319f, -0.07595165f, 
    -0.04305591f, -0.00392464f, 0.00649901f, 0.05479634f, -0.04470273f, 0.03855771f, -0.07733587f, -0.07380411f, 
    0.09262078f, -0.02710414f, 0.08747945f, 0.17297544f, 0.17036875f, -0.00879440f, -0.07823416f, 0.07629571f, 
    -0.12268257f, -0.22254311f, -0.17699076f, -0.17475934f, 0.15949278f, 0.13368066f, 0.32669857f, 0.20444284f, 
    -0.02605017f, -0.10804335f, 0.26497930f, -0.04834102f, -0.32467926f, 0.16202295f, 0.12120582f, -0.09551151f, 
    -0.25193498f, -0.13762988f, -0.44000417f, -0.06654995f, 0.04534986f, -0.56053221f, 0.02573519f, 0.18039230f, 
    0.10990839f, 0.00326273f, -0.10348523f, -0.16424400f, -0.15189703f, -0.24070959f, -0.29448193f, 0.07544249f, 
    -0.18038741f, -0.04153105f, 0.20078844f, 0.08948561f, -0.11849959f, -0.50587243f, 0.24732526f, 0.17863685f, 
    -0.24566759f, 0.21662831f, -0.33752242f, 0.24018650f, 0.12799543f, 0.06640051f, -0.54367083f, 0.00783028f, 
    -0.36092982f, -0.06375367f, 0.20143792f, 0.09722073f, -0.05502155f, 0.09035064f, -0.00201413f, -0.19774270f, 
    -0.14105272f, -0.00298878f, 0.01795699f, -0.20961580f, 0.00957707f, 0.05609891f, 0.10339612f, 0.11718028f, 
    -0.03031122f, -0.16429092f, -0.55329114f, 0.04352533f, 0.13725157f, -0.01596460f, 0.01571978f, -0.03811273f, 
    0.20740986f, -0.30087596f, -0.18659630f, 0.34767157f, -0.04665492f, -0.03058892f, -0.04940237f, -0.19708037f, 
    0.03866693f, 0.07487825f, 0.37100163f, 0.18623637f, 0.11978085f, -0.06136135f, -0.03736485f, -0.20094664f, 
    0.05558248f, 0.23756599f, -0.02334612f, 0.60640812f, 0.09753159f, -0.19915570f, 0.03989514f, -0.15119074f, 
    0.11540020f, 0.06281844f, 0.12750189f, 0.21480052f, 0.23776466f, 0.04512308f, 0.29865304f, -0.09618802f, 
    -0.08355447f, -0.11048383f, -0.01240843f, 0.41753033f, 0.15690802f, 0.81208694f, 0.50612915f, 0.19340944f, 
    0.19785270f, -0.25041312f, 0.19477102f, 0.02642099f, 0.04186534f, 0.46232799f, -0.03202558f, -0.33401918f, 
    -0.36511251f, 0.15770037f, 0.27435356f, 0.24192226f, -0.00775644f, -0.14164257f, -0.23748454f, 0.03064856f, 
    0.07884040f, -0.02126115f, 0.08973027f, -0.08417585f, -0.09525198f, -0.02207810f, -0.23102000f, -0.07694817f, 
    0.31835946f, 0.06820218f, 0.30684298f, 0.15067162f, -0.03269102f, -0.29124132f, 0.00505726f, 0.22556947f, 
    0.03278606f, -0.04591629f, 0.04947713f, 0.28197831f, 0.11725315f, -0.12173118f, -0.17416701f, 0.25329390f, 
    -0.10593797f, 0.35217890f, 0.19082999f, -0.29913375f, 0.23605676f, -0.15735455f, -0.11289767f, 0.16054071f, 
    -0.15196440f, 0.00303060f, 0.37599042f, 0.29146346f, 0.26228240f, -0.25886092f, 0.08401170f, -0.05197077f, 
    -0.10701019f, 0.29610446f, 0.01331485f, -0.07838354f, 0.08551088f, 0.12412271f, -0.18020989f, 0.04357802f, 
    -0.10840847f, 0.06328300f, 0.31238666f, 0.11265253f, 0.07527617f, 0.23424378f, 0.31670728f, -0.46596202f, 
    -0.03674657f, -0.12703820f, -0.00316118f, -0.08929519f, 0.10044820f, -0.15401636f, -0.18877432f, -0.19380885f, 
    0.21881293f, -0.04450462f, -0.07630529f, 0.00254404f, -0.21657321f, -0.02834035f, 0.08728630f, 0.10274826f, 
    -0.17365499f, -0.16726130f, 0.03581124f, -0.02222076f, 0.14769915f, -0.12486219f, 0.02349451f, -0.01983598f, 
    -0.03903862f, 0.01730581f, 0.46984705f, 0.05430547f, 0.27681240f, 0.07739829f, -0.12151813f, 0.14064430f, 
    -0.04281873f, 0.11157298f, 0.14936548f, -0.16130073f, 0.22720976f, -0.12771592f, 0.10989124f, 0.18906958f, 
    0.17748649f, -0.03335302f, -0.62443501f, -0.50827724f, -0.30733767f, 0.18526040f, 0.16023906f, -0.01442583f, 
    -0.13813274f, 0.09480143f, -0.15489556f, 0.05632762f, -0.03483179f, 0.00097132f, -0.00274577f, -0.21624672f, 
    -0.00246473f, -0.00923831f, 0.04502334f, -0.10587454f, 0.24705219f, 0.13530724f, 0.06403314f, -0.14484470f, 
    -0.03330407f, 0.32313427f, -0.04644087f, -0.14979212f, -0.29561585f, -0.66257590f, -0.13156101f, -0.45310977f, 
    0.07639138f, 0.01515909f, -0.18669456f, -0.11265028f, -0.01179880f, -0.17944284f, 0.36187136f, -0.02593839f, 
    0.12140495f, 0.08910115f, -0.07071750f, -0.03123346f, -0.02683758f, 0.16705766f, 0.04004643f, 0.05799089f, 
    -0.03351111f, 0.31131008f, 0.12217227f, 0.08768485f, 0.28340697f, 0.18837237f, 0.16033249f, -0.22172096f, 
    -0.60433841f, -0.06731232f, -0.25006032f, 0.07992365f, -0.34104308f, -0.00628368f, 0.08227939f, 0.20528767f, 
    0.11468245f, -0.22475652f, 0.03810571f, 0.19673273f, -0.10073506f, 0.10541751f, 0.14714932f, -0.12275529f, 
    -0.02161707f, -0.16556959f, -0.54972506f, 0.16448554f, 0.08508546f, -0.07893514f, -0.03565694f, -0.08860767f, 
    -0.21374314f, 0.14826928f, 0.12052519f, 0.59619880f, 0.09020896f, -0.09609611f, 0.12669319f, -0.10111833f, 
    0.01587657f, -0.01794082f, 0.04775069f, -0.16422945f, 0.17399612f, -0.29741219f, 0.01447964f, 0.05521471f, 
    0.08940488f, -0.12162788f, 0.09332637f, -0.12378685f, -0.10743261f, -0.03838882f, -0.32368541f, -0.15873459f, 
    -0.18746080f, -0.01900181f, 0.12781191f, 0.04498577f, -0.18992507f, -0.23092836f, -0.20084454f, 0.48362350f, 
    -0.36381581f, 0.24197422f, -0.00032922f, -0.00936839f, 0.00370349f, -0.17900111f, 0.08118363f, 0.24774164f, 
    0.12657894f, -0.30828819f, 0.05366307f, -0.12349073f, -0.13179402f, -0.07640107f, -0.14451849f, -0.01679837f, 
    -0.24092744f, -0.40337476f, 0.08863556f, 0.18096313f, 0.18378270f, -0.10174554f, -0.11926965f, -0.24461402f, 
    0.13903682f, -0.44806433f, -0.58333248f, -0.09981291f, 0.09767870f, -0.13928147f, -0.04007461f, -0.27021182f, 
    0.07995457f, 0.06653237f, 0.25524181f, -0.15660262f, 0.35345256f, 0.12793510f, -0.20332742f, -0.00180859f, 
    0.22840244f, 0.16681151f, 0.04053438f, 0.68484390f, 0.39945206f, -0.13977848f, 0.06952924f, 0.14996994f, 
    0.17231649f, 0.06204133f, -0.11455655f, 0.12673292f, 0.21618651f, -0.01997066f, 0.12651742f, 0.25762802f, 
    0.48748648f, 0.08892832f, 0.04478285f, -0.05828387f, 0.29848763f, 0.22033523f, 0.02232102f, 0.08975726f, 
    0.12426518f, 0.05306330f, -0.08955581f, 0.02826415f, 0.11318263f, -0.06528731f, 0.06600095f, -0.02048980f, 
    0.00935748f, -0.18042803f, 0.03099252f, -0.00851023f, 0.00252025f, 0.08386652f, -0.09041493f, -0.55056131f, 
    -0.32860667f, 0.05841010f, 0.04177853f, 0.22060078f, 0.04965613f, -0.17762476f, 0.05060134f, -0.05724175f, 
    -0.05908228f, 0.01787549f, 0.01271435f, 0.06802270f, -0.03528817f, 0.01556190f, 0.00894153f, -0.00429020f, 
    -0.07407697f, 0.05344633f, 0.07408863f, -0.03477269f, -0.08029187f, -0.00344229f, 0.02830973f, -0.06953213f, 
    -0.01502432f, -0.04362584f, -0.07948438f, -0.08366605f, 0.06621823f, 0.06589863f, 0.06473905f, 0.07421861f, 
    0.02256098f, -0.00256846f, 0.01151144f, -0.01805342f, -0.00131429f, 0.00157206f, 0.00242928f, -0.02029539f, 
    0.01728201f, -0.03115357f, -0.04459351f, -0.04355550f, -0.08840730f, 0.03210975f, 0.01554275f, -0.08144546f, 
    0.01690540f, -0.03721159f, -0.03593882f, -0.00160049f, -0.01381159f, -0.07165276f, -0.02951807f, 0.06398480f, 
    0.02796686f, 0.01929391f, 0.05690625f, -0.06989931f, -0.07329519f, -0.06677391f, -0.00026534f, -0.03131827f, 
    -0.03049823f, 0.07910597f, -0.04773824f, 0.05137714f, 0.04097665f, 0.01016200f, 0.03492969f, -0.00686191f, 
    0.02068823f, -0.02175275f, 0.06013446f, 0.04871074f, 0.01607973f, -0.06347193f, 0.05102370f, 0.00611549f, 
    0.04414818f, -0.06462506f, 0.06429023f, -0.06235370f, -0.06828263f, -0.05919155f, 0.04600745f, 0.01309575f, 
    -0.02185555f, 0.06267481f, -0.06044661f, -0.07530659f, -0.00785881f, -0.06455781f, -0.00515443f, -0.02467359f, 
    0.07262512f, 0.01256188f, -0.05054484f, -0.02247824f, 0.03275762f, 0.02482092f, -0.00357623f, -0.03544403f, 
    -0.08555955f, -0.00345100f, 0.06155397f, -0.05397999f, -0.08809431f, 0.06079677f, -0.06119455f, -0.05985748f, 
    0.06940404f, 0.02382007f, -0.06299074f, -0.08521675f, -0.09009500f, -0.03893742f, -0.06492856f, -0.06606860f, 
    -0.01640303f, -0.00430524f, -0.02233341f, -0.04308378f, -0.03336537f, 0.06698167f, 0.03786304f, -0.00225243f, 
    0.06283478f, 0.06716044f, -0.06911230f, -0.02265256f, 0.05768021f, 0.00301937f, -0.04663457f, 0.00486563f, 
    -0.02871442f, 0.02577141f, -0.07497133f, 0.02719501f, -0.06478993f, -0.07731036f, -0.04147335f, -0.03022968f, 
    0.04624515f, 0.03009779f, -0.06710630f, -0.07377367f, 0.07183278f, 0.03750391f, 0.01795145f, -0.06490850f, 
    -0.73165971f, -0.76917565f, 0.08623742f, 0.06832299f, 0.19191149f, 0.03292185f, 0.00976449f, -0.09935459f, 
    0.19224353f, -0.03952226f, -0.33317649f, 0.03479777f, 0.20673347f, 0.31855670f, 0.42500785f, 0.09674004f, 
    -0.04831547f, 0.07248352f, 0.81644320f, -0.03959854f, -0.20265046f, 0.07455758f, 0.13120072f, 0.02213585f, 
    0.02465858f, -0.05905993f, -0.25825292f, -0.37909180f, 0.00199926f, -0.25613791f, -0.00668300f, 0.00875104f, 
    0.01519449f, 0.21313448f, -0.01168026f, 0.16363876f, -0.09970341f, -0.53573370f, -0.63661063f, -0.02524412f, 
    0.08209034f, -0.14772531f, 0.17813492f, 0.16161521f, -0.07036757f, -0.51254761f, 0.22204088f, -0.05280593f, 
    -0.45693660f, 0.09793332f, -0.17584312f, 0.21639323f, -0.04441344f, -0.06510670f, 0.24697152f, 0.31776407f, 
    -0.02283261f, 0.17277840f, -0.10754304f, 0.24537364f, -0.00146291f, -0.06669629f, 0.06642595f, -0.09042969f, 
    -0.45651945f, -0.16097002f, -0.09192932f, -0.08660718f, -0.07301613f, 0.07105818f, -0.24607593f, 0.31142190f, 
    0.32357979f, -0.42256373f, 0.03947253f, 0.00394290f, -0.02748333f, -0.06293546f, 0.11573680f, 0.12713711f, 
    0.12314546f, -0.54256839f, -0.07385991f, 0.21275450f, 0.10086676f, 0.12334474f, -0.23481011f, -0.01196593f, 
    0.15035184f, 0.05685851f, 0.11126587f, 0.25067008f, 0.03597107f, 0.23272651f, -0.16290791f, -0.25226626f, 
    0.03592392f, -0.06187904f, 0.34444243f, 0.32720935f, -0.09531066f, 0.04438777f, -0.03849404f, 0.04600108f, 
    0.07779941f, -0.05211069f, -0.04315166f, 0.07321038f, -0.18355784f, 0.28068069f, -0.03208483f, 0.16128685f, 
    0.05694719f, -0.18971267f, 0.02382013f, -0.12741582f, 0.09800013f, -0.60790241f, -0.00827262f, 0.18728614f, 
    0.10568391f, -0.08307152f, 0.07268850f, -0.04025892f, -0.01399057f, 0.15084715f, 0.53809583f, -0.35748821f, 
    -0.14657955f, -0.11166461f, -0.09595520f, 0.11807114f, 0.03313948f, 0.12719151f, -0.09863686f, 0.22211090f, 
    0.58890641f, 0.04942545f, 0.00910966f, 0.24940003f, -0.07533752f, 0.06888614f, 0.07597539f, 0.16872704f, 
    0.06447499f, -0.02685940f, 0.03502301f, -0.05616842f, 0.05110851f, 0.06208578f, -0.04295715f, -0.07954864f, 
    -0.07757906f, 0.00452120f, -0.07002471f, -0.08489834f, 0.07628170f, -0.08804432f, 0.02647026f, -0.06571531f, 
    -0.08676428f, -0.03780946f, 0.02237277f, -0.07314456f, 0.07162873f, -0.04424122f, -0.06772623f, -0.06432212f, 
    0.05693786f, 0.05585890f, -0.07664832f, 0.04223809f, -0.00153217f, -0.01628051f, -0.04891605f, 0.05557087f, 
    0.03841927f, -0.01045314f, -0.01742991f, -0.07687135f, -0.04094939f, 0.01614568f, -0.07750253f, 0.01308585f, 
    -0.07238785f, 0.06483012f, -0.05615506f, -0.00081399f, -0.06052199f, -0.02263870f, 0.00033990f, -0.02631025f, 
    0.04275142f, 0.07114834f, -0.05843068f, -0.06521115f, 0.02686581f, 0.06339689f, -0.07805371f, 0.06320363f, 
    -0.00232055f, 0.00881197f, -0.00427062f, -0.06025966f, -0.06499644f, -0.03967850f, -0.01054955f, -0.02447064f, 
    -0.07654166f, -0.07387517f, 0.06180290f, -0.07050001f, 0.03993469f, -0.02490137f, -0.05063700f, 0.01241679f, 
    0.00956135f, 0.04910887f, -0.04329286f, -0.04917275f, 0.00482436f, 0.02102334f, -0.06113933f, 0.04986460f, 
    -0.07029985f, 0.00271829f, 0.03935410f, 0.05458790f, -0.03033438f, 0.07316722f, 0.01680638f, -0.00999866f, 
    -0.05101090f, 0.06495228f, -0.01811878f, -0.06572673f, -0.05350446f, 0.06514596f, -0.08813058f, -0.04200016f, 
    0.00407816f, -0.08244938f, 0.04338136f, -0.02913987f, 0.06695818f, 0.02328498f, 0.02521913f, -0.01465892f, 
    0.02408124f, -0.07353771f, 0.06751195f, 0.04015767f, -0.06476876f, 0.06740107f, -0.07903987f, -0.04486661f, 
    -0.01428534f, 0.04183886f, -0.07736870f, -0.03799246f, 0.02155667f, -0.07945623f, -0.00120436f, 0.01978882f, 
    -0.00227215f, 0.05236920f, 0.03141106f, -0.01884856f, -0.06051472f, -0.01712884f, -0.03165324f, -0.08743682f, 
    -0.06577840f, 0.02896246f, 0.01235000f, -0.04464566f, 0.03318524f, -0.01241467f, 0.04580799f, 0.03141923f, 
    -0.04819933f, 0.05963990f, 0.03320068f, -0.06067131f, 0.02315652f, 0.00754916f, -0.07100618f, 0.00019778f, 
    0.27010655f, -0.03348399f, -0.29765275f, -0.25610065f, 0.08752692f, -0.26566327f, -0.15635076f, 0.05955296f, 
    -0.31153557f, -0.03317739f, 0.10277190f, 0.48543656f, 0.19428958f, -0.02063482f, -0.13084345f, -0.04269782f, 
    -0.17026971f, -0.10455699f, 0.37152374f, 0.51597810f, 0.51503175f, 0.29193553f, 0.07952239f, 0.16081108f, 
    0.21724074f, -0.06161023f, 0.33148125f, -0.27319273f, -0.27488324f, -0.06620818f, -0.26111859f, -0.26833144f, 
    -0.27287710f, -0.33228186f, 0.06716637f, -0.00807150f, -0.11283631f, 0.14682937f, 0.15826461f, -0.33462432f, 
    -0.15363118f, -0.41186687f, 0.05199941f, 0.00025377f, 0.10317428f, -0.30943781f, -0.04281915f, -0.19561060f, 
    0.17522664f, 0.10656679f, -0.10802883f, -0.29565153f, 0.16018750f, -0.08937350f, -0.22920957f, 0.42543614f, 
    0.28895938f, 0.18554437f, 0.35278785f, 0.02416423f, 0.13456723f, 0.02841450f, 0.03116546f, -0.62066686f, 
    -0.06970779f, -0.20037292f, 0.00845111f, -0.06440800f, -0.35666847f, 0.09349655f, -0.11405647f, 0.19252264f, 
    0.12660113f, 0.10662734f, -0.10033049f, -0.33951372f, -0.15792115f, -0.24002144f, 0.09217463f, 0.24541102f, 
    -0.03268644f, 0.94517940f, 0.58681542f, 0.46030939f, -0.01558409f, 0.00007481f, -0.19750641f, 0.01995369f, 
    0.17202735f, 0.15509430f, 0.04546874f, 0.31560171f, 0.08892887f, 0.08402967f, 0.01633079f, 0.08055489f, 
    0.02972802f, -0.16500714f, -0.16503738f, -0.00763914f, 0.15807062f, 0.11431784f, -0.38371748f, -0.17990996f, 
    0.11145341f, 0.06174544f, -0.01189445f, 0.22739843f, 0.25755030f, 0.22549461f, -0.48693940f, -0.10817127f, 
    -0.07020804f, 0.06140972f, 0.02139264f, 0.01528082f, -0.03453221f, -0.28138095f, -0.30545455f, -0.19536118f, 
    -0.43403569f, 0.08043697f, 0.07859908f, 0.00488167f, 0.03537254f, -0.21450101f, -0.07374346f, 0.46888781f, 
    0.37807012f, 0.34878394f, -0.08970612f, 0.17422082f, -0.09417947f, 0.04386507f, -0.01042035f, -0.03291538f, 
    0.41135150f, -0.00361656f, -0.11295269f, 0.07900355f, -0.32841367f, -0.09286951f, -0.00457633f, 0.27368113f, 
    0.61585611f, 0.05745659f, -0.17873450f, 0.10741654f, -0.07071200f, -0.31359124f, -0.09521580f, 0.05629508f, 
    0.04540587f, -0.14709046f, 0.13651797f, -0.15906787f, -0.17889655f, 0.30114770f, -0.22742981f, -0.22491053f, 
    0.15902190f, -0.20775075f, 0.15876161f, -0.08522042f, -0.42760801f, -0.20978026f, -0.03043022f, -0.05179226f, 
    -0.00534313f, -0.01484864f, -0.03114090f, 0.43846631f, 0.08385865f, 0.23392294f, 0.09789503f, -0.13267273f, 
    -0.11288843f, -0.16750801f, -0.03596060f, -0.01640302f, 0.27582082f, -0.28317925f, 0.05024114f, -0.20406613f, 
    0.17654021f, 0.15108608f, -0.11374672f, 0.06886473f, 0.07818113f, 0.22434106f, -0.17683558f, 0.08906685f, 
    -0.05845394f, 0.01467138f, 0.10472295f, -0.17082220f, 0.19472738f, 0.08151462f, -0.10667516f, -0.48412597f, 
    -0.11962699f, -0.40285277f, -0.10815684f, 0.11721057f, 0.00566771f, -0.13592423f, 0.04959000f, 0.45384383f, 
    -0.25450644f, 0.09177338f, -0.13079093f, -0.04875404f, 0.04630478f, 0.11100964f, 0.06093407f, 0.04837222f, 
    -0.00261763f, -0.42290455f, 0.04978266f, 0.10856154f, 0.02781713f, 0.01198692f, -0.00643861f, 0.11683487f, 
    0.05519417f, 0.77462232f, -0.34210250f, 0.12880255f, -0.01957980f, -0.08494716f, 0.08719811f, 0.07966393f, 
    0.05946654f, 0.08881725f, -0.46554321f, 0.27570325f, 0.08683491f, -0.28900886f, 0.07790678f, 0.01082947f, 
    0.08248712f, -0.06579044f, -0.24682941f, -0.03664164f, 0.06016770f, 0.20669772f, 0.03625069f, 0.08981801f, 
    0.04205183f, 0.08536889f, 0.02718926f, -0.05651152f, -0.44058332f, 0.23549365f, 0.22108036f, -0.04348858f, 
    0.00364310f, -0.12584251f, 0.03140516f, -0.00053177f, -0.00613877f, -0.43506369f, 0.54964161f, 0.29299423f, 
    -0.19598584f, 0.17431699f, 0.09339129f, 0.05475040f, 0.33304197f, -0.09571567f, 0.33540261f, -0.10360405f, 
    -0.05655773f, 0.01753385f, -0.08587905f, -0.04125142f, 0.00941394f, 0.05401237f, -0.02354795f, 0.19644144f, 
    -0.09602436f, -0.26677084f, 0.12371899f, -0.15765134f, 0.13319826f, -0.17860104f, -0.24522734f, -0.12732030f, 
    0.03036742f, -0.10631645f, -0.03315666f, -0.19692394f, 0.09662195f, 0.07354718f, -0.02912745f, -0.09051204f, 
    0.05360781f, 0.02985738f, -0.05007049f, 0.11126181f, 0.15204792f, 0.03290936f, -0.03226697f, 0.07429338f, 
    0.06744529f, 0.26350406f, -0.29635787f, -0.51435155f, 0.46145380f, 0.09795653f, -0.04275470f, 0.15030780f, 
    0.08932856f, 0.05346967f, 0.05631549f, -0.60568780f, 0.63823575f, -0.46396708f, 0.12876311f, 0.07316978f, 
    -0.08150809f, 0.09225544f, 0.14234139f, -0.18304530f, 0.01113606f, 0.47784567f, -0.60564131f, -0.10272377f, 
    -0.02906912f, -0.24702987f, -0.13884272f, 0.22039725f, -0.14048621f, 0.23417915f, -0.25862369f, 0.12485696f, 
    -0.23768014f, 0.02606374f, 0.06128186f, 0.10163442f, 0.10534186f, 0.26881486f, -0.32918945f, -0.36256519f, 
    0.49611828f, 0.05470534f, -0.00169802f, 0.10356852f, -0.14864637f, -0.04122700f, -0.13506486f, -0.23715946f, 
    -0.45662230f, -0.26624283f, 0.09517561f, 0.08799077f, -0.11954174f, -0.19866867f, 0.12448351f, 0.14181061f, 
    0.91756874f, -0.09254634f, 0.29113525f, -0.24031028f, -0.13678317f, 0.12873626f, -0.11025508f, -0.01004410f, 
    0.22641306f, -0.50060058f, 0.16105491f, -0.35953775f, -0.01035276f, -0.28731030f, -0.03016182f, 0.16701724f, 
    -0.14983001f, -0.03391965f, -0.00574881f, 0.35625258f, -0.03336636f, 0.12029421f, -0.14373451f, -0.15934496f, 
    0.05619771f, -0.04742379f, 0.12129623f, -0.20104727f, 0.25244728f, -0.33593521f, 0.16492267f, -0.05017902f, 
    -0.04228874f, 0.11895440f, 0.09763925f, -0.05528671f, 0.02160051f, 0.15029621f, -0.17906140f, 0.08108030f, 
    0.02502631f, 0.05046374f, -0.15888092f, 0.09002592f, -0.05759615f, 0.14091597f, 0.09600648f, -0.12100342f, 
    -0.14526428f, 0.10782684f, -0.07852013f, 0.01508696f, 0.16579495f, -0.25232399f, -0.12642871f, -0.25102723f, 
    0.42019758f, -0.01782173f, -0.13768481f, 0.08113070f, -0.05525446f, 0.03246306f, -0.09265721f, 0.12742768f, 
    -0.25371990f, 0.32616904f, 0.16089664f, 0.04868396f, 0.12553960f, -0.12311967f, -0.08372294f, 0.17465146f, 
    0.31671458f, 0.07379130f, -0.22763829f, -0.05696522f, -0.07176546f, -0.07310896f, 0.30331564f, -0.06770726f, 
    0.10331403f, -0.11557411f, 0.18045241f, -0.12606059f, 0.04167708f, 0.10419307f, 0.09459317f, -0.18151075f, 
    -0.35590175f, -0.06226401f, 0.29807279f, 0.45652640f, 0.11017248f, -0.11534764f, 0.09748869f, 0.07712701f, 
    0.11721787f, -0.00587966f, -0.01234450f, 0.10820226f, 0.21306810f, 0.04227654f, 0.14051005f, -0.08430230f, 
    0.02370250f, -0.04474273f, -0.12355774f, 0.08516823f, 0.78685492f, -0.14942048f, -0.12238543f, 0.00728723f, 
    -0.07821625f, 0.00410557f, 0.03795118f, -0.16979033f, 0.09852383f, -0.42418942f, 0.08898781f, -0.21405710f, 
    -0.00309492f, -0.21578553f, -0.31075487f, 0.16432860f, 0.14554591f, 0.10895660f, 0.07093225f, 0.36697730f, 
    0.11916470f, -0.22074956f, -0.25779215f, -0.03876443f, 0.06714772f, 0.28902552f, 0.17004943f, -0.56432867f, 
    0.01955539f, -0.19026949f, -0.05251639f, -0.02456852f, 0.04854194f, -0.22416976f, -0.20360297f, 0.09861217f, 
    0.37002847f, -0.08665238f, -0.42518979f, -0.19054797f, 0.32695469f, -0.24875912f, -0.01819792f, 0.20662992f, 
    -0.01249301f, -0.60897493f, -0.00370300f, -0.05459958f, -0.21917540f, 0.10878652f, -0.02240685f, -0.37711629f, 
    0.15315396f, -0.09641883f, -0.26899317f, -0.36542636f, 0.00911431f, 0.14551315f, -0.01892245f, 0.18827184f, 
    -0.13076915f, 0.07547992f, -0.00240029f, 0.01743986f, -1.07732975f, 0.16878629f, 0.28623235f, 0.06645808f, 
    0.27958357f, -0.20329294f, -0.00125235f, 0.15519382f, -0.29717433f, -0.33225811f, 0.17684577f, 0.09801164f, 
    0.20914297f, 0.03650633f, -0.06864603f, 0.01604921f, 0.20758429f, 0.02355059f, -0.70213336f, 0.10484823f, 
    0.15674429f, 0.16754611f, 0.06155018f, 0.09575740f, -0.10888073f, -0.00429704f, 0.15736049f, 0.01210195f, 
    0.11847100f, -0.02490835f, 0.33463827f, 0.06071198f, 0.06070942f, 0.02902986f, -0.01895207f, -0.16373412f, 
    0.27989775f, 0.35878098f, -0.08411946f, -0.02709770f, -0.30772099f, 0.04486617f, 0.12749815f, 0.18374999f, 
    0.35414883f, 0.26542902f, -0.07149778f, -0.00639118f, 0.13968554f, 0.15109985f, -0.26126766f, -0.15573370f, 
    -0.17793843f, -0.52100015f, -0.32604921f, -0.19832529f, 0.18841513f, 0.25506333f, -0.11388466f, -0.13664585f, 
    0.12605844f, 0.16350335f, 0.33499050f, 0.12413453f, 0.19010334f, -0.06147394f, 0.17935146f, -0.12007983f, 
    0.08722655f, 0.07444181f, 0.15364899f, 0.28553697f, 0.20732205f, -0.15933928f, 0.11408216f, 0.05006993f, 
    -0.07143345f, -0.25768837f, -0.08267482f, -0.31535318f, -0.01020314f, -0.46847430f, -0.39242783f, 0.07703409f, 
    0.07868180f, 0.07978559f, -0.09267217f, 0.14228588f, 0.11047557f, 0.04970676f, 0.18336035f, -0.03964612f, 
    -0.02626276f, -0.03454678f, -0.08055357f, 0.02247478f, -0.08400328f, -0.00129598f, 0.18422064f, 0.11277959f, 
    0.29672167f, -0.25377023f, -0.42033744f, -0.27213967f, 0.05338608f, 0.23113942f, 0.20371607f, 0.34955883f, 
    -0.59787351f, -0.44979346f, -0.43130362f, -0.10272484f, -0.19042683f, -0.03782015f, -0.30114162f, -0.17509821f, 
    -0.24595319f, -0.10275397f, 0.32304326f, -0.05493676f, -0.12137107f, -0.27281901f, -0.03633796f, -0.08707404f, 
    0.02622193f, 0.52617919f, -0.05450073f, -0.07635380f, 0.03967624f, 0.12422907f, 0.05272431f, -0.02450652f, 
    0.13301049f, -0.15818669f, -0.47195384f, 0.00759189f, -0.16171016f, -0.01801458f, 0.09098618f, 0.14396568f, 
    -0.27434227f, 0.10961390f, 0.09054396f, 0.06176211f, 0.16045347f, -0.05429410f, 0.09370283f, 0.28101930f, 
    0.19548590f, 0.12290664f, -0.07127750f, -0.04495320f, -0.52227259f, 0.26347941f, -0.09117523f, 0.04647021f, 
    0.24387732f, 0.00299172f, -0.01399859f, 0.03879531f, 0.22815105f, -0.86720556f, 0.27294338f, -0.02956369f, 
    -0.02563225f, 0.19291399f, 0.18335865f, -0.19057488f, 0.17104392f, 0.15391460f, 0.47726890f, 0.09032729f, 
    0.30058610f, -0.10138704f, -0.12738042f, 0.02111845f, 0.17890531f, 0.03108519f, -0.22887693f, 0.39258337f, 
    0.07540183f, 0.07411610f, -0.01289682f, -0.38511762f, 0.11817542f, -0.00241697f, -0.06931195f, 0.32720995f, 
    -0.24059662f, -0.07724519f, -0.19736460f, -0.04613341f, 0.04504321f, 0.01098122f, 0.16205646f, 0.03377162f, 
    -0.10182704f, -0.18450776f, -0.01572782f, 0.36925125f, 0.06188680f, -0.09372016f, 0.49135354f, -0.09772321f, 
    -0.24454734f, -0.46873686f, 0.42657432f, 0.27735022f, 0.17409132f, 0.18083748f, 0.19788489f, -0.25379041f, 
    0.06228350f, -0.12252891f, -0.01573195f, 0.30000910f, 0.40362129f, 0.47073036f, 0.06383210f, -0.32255748f, 
    0.01753968f, -0.04503746f, -0.19891980f, 0.07367264f, 0.54109830f, 0.34883869f, -0.16771390f, -0.02716998f, 
    -0.05595690f, -0.11267328f, -0.06516762f, 0.08072782f, 0.10910442f, -0.37982264f, -0.06353975f, 0.05083234f, 
    -0.01306433f, -0.04374621f, -0.07650504f, 0.09404435f, 0.13463801f, 0.16525948f, -0.04712659f, 0.54490519f, 
    0.13078091f, 0.06093519f, -0.12919337f, 0.04284603f, -0.23896730f, 0.13801917f, 0.12708275f, -0.05243303f, 
    0.08017366f, -0.25534594f, -0.04641685f, -0.11456205f, 0.02788027f, -0.24618816f, -0.08898653f, 0.25084820f, 
    -0.18414168f, 0.02356379f, -0.71049863f, 0.08316096f, 0.08906563f, -0.06000267f, 0.06736167f, -0.00447674f, 
    0.17553054f, 0.36310247f, 0.26228875f, -0.48751634f, 0.12390593f, 0.17401950f, -0.01234211f, -0.01080319f, 
    0.14047328f, -0.10498647f, -0.98244435f, -0.44617900f, -0.14258894f, -0.02037307f, 0.00161622f, 0.02839004f, 
    0.04884829f, 0.05024470f, 0.14333525f, -1.11738276f, -0.14220774f, -0.07483413f, 0.04015341f, 0.18733355f, 
    0.04838189f, 0.07451148f, -0.23270239f, 0.00664678f, -0.56368256f, -0.66243571f, -0.03333082f, 0.23467141f, 
    0.11103136f, 0.18451175f, -0.18141167f, 0.13741265f, 0.19926901f, -0.22291291f, -0.44074062f, -0.00201925f, 
    0.04986508f, -0.33117542f, 0.15130559f, -0.30957353f, 0.25771156f, -0.00097184f, 0.40584490f, 0.52545536f, 
    0.12827200f, -0.09546023f, 0.06845485f, 0.09855986f, 0.22856453f, 0.23104720f, 0.00573323f, -0.10188126f, 
    -0.20484108f, -0.14348383f, 0.17828636f, 0.22122070f, -0.19975261f, 0.09164856f, 0.18749179f, -0.06134716f, 
    -0.03810365f, 0.34125665f, -0.32956198f, 0.23014633f, 0.14702711f, 0.20604062f, 0.00790796f, -0.14895555f, 
    -0.02207800f, 0.02190208f, -0.06020327f, -0.21905510f, -0.04742960f, -0.12028605f, 0.08301577f, -0.14168493f, 
    0.21690339f, -0.01476576f, 0.19239958f, 0.01916670f, 0.28494570f, -0.20846210f, -0.04134249f, -0.04975624f, 
    -0.19027478f, 0.02874899f, -0.14945312f, -0.28037611f, -0.35074818f, -0.32423624f, -0.19646493f, 0.24065287f, 
    0.04115806f, 0.19179630f, -0.20303060f, 0.17909932f, -0.10508653f, -0.14417425f, -0.28047678f, -0.01307048f, 
    0.05552115f, -0.33537012f, 0.34007826f, -0.08879450f, 0.08511440f, 0.30665976f, 0.34089169f, 0.01610024f, 
    0.00473439f, -0.03069181f, 0.18978311f, 0.03430600f, 0.00779780f, 0.19935006f, 0.05093170f, -0.11218420f, 
    0.36857507f, -0.10417388f, -0.06917393f, -0.23988412f, 0.03038949f, 0.06890561f, 0.08522294f, -0.02465448f, 
    -0.43769315f, 0.06465948f, 0.01935960f, -0.19184077f, 0.09111819f, 0.42391735f, 0.03014916f, -0.05435849f, 
    -0.01238553f, 0.09626977f, 0.20336461f, -0.25541449f, 0.10291880f, -0.13675317f, -0.07540742f, 0.04930241f, 
    -0.09859748f, 0.23685043f, -0.17690641f, -0.26168203f, -0.04480437f, -0.20417725f, 0.10659982f, -0.07081832f, 
    0.24120009f, 0.12525749f, 0.42157429f, -0.03441944f, 0.14426106f, 0.43608490f, -0.13417940f, 0.06782681f, 
    -0.00564147f, 0.07482999f, 0.01081460f, -0.04261566f, -0.13173427f, -0.18176889f, 0.35906652f, 0.11376406f, 
    0.13280697f, -0.18724422f, 0.15393128f, -0.01671842f, -0.47262296f, -0.12945472f, -0.02786250f, 0.14324103f, 
    -0.06505309f, 0.14525180f, 0.14636844f, 0.09597935f, -0.33139226f, 0.24055335f, 0.07938177f, 0.11388283f, 
    0.22459739f, 0.04302202f, -0.16363543f, 0.16379978f, -0.13763766f, -0.24953111f, 0.32565457f, 0.25498179f, 
    0.47261158f, -0.13680044f, -0.06508662f, 0.04705938f, 0.12865932f, 0.03540482f, -0.07336720f, 0.35799575f, 
    0.02377613f, 0.23930684f, -0.18826778f, 0.05942215f, -0.01693453f, -0.12229234f, 0.32265571f, 0.04265027f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25595284f, 0.06495558f, -0.06487641f, 0.09769900f, 0.18620102f, 0.14249328f, -0.02677438f, 0.40470034f, 
    -0.04067699f, -0.30858487f, 0.12966289f, 0.17900072f, 0.00589065f, -0.04956311f, -0.00905793f, 0.05323524f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11769105f, -0.11634565f, -0.23192935f, 0.36589402f, 0.39082819f, -1.14292741f, 0.06370282f, 0.29366842f, 
    -0.20643021f, 0.74904245f, -0.36311877f, -0.65835613f, -0.25570109f, -0.32434136f, -0.35966137f, 0.02118139f, 
    0.01036183f, -0.63732374f, -0.18181597f, 0.28110468f, -0.05166071f, -0.15840231f, 0.04878850f, 1.15390146f, 
    -0.04016522f, 0.03250119f, 0.20583019f, -0.41065726f, 0.08090663f, -0.11854076f, -0.46653840f, -0.17078261f, 
    -0.48567060f, 0.02330393f, -0.21031335f, 0.22072934f, 0.01604049f, -0.22546993f, 0.11297552f, -0.10651749f, 
    -0.22331297f, -0.07666789f, 0.74631995f, 0.10985220f, -0.93501729f, 1.20501220f, -0.55840909f, -0.05951079f, 
    -0.21020490f, 0.56736648f, -0.24553047f, -0.57947451f, -0.01342775f, 0.17304729f, 0.12844676f, -0.55482066f, 
    -0.13254547f, -0.50711453f, 0.42575100f, 0.34359401f, 0.64876449f, 0.07261257f, 0.37705761f, -0.27621436f, 
    0.43029088f, 0.30568612f, -0.02458441f, -0.85826468f, 0.12960088f, 0.04671754f, 0.20916402f, -0.13383207f, 
    0.04602999f, 0.14318006f, -0.32131693f, 0.31314293f, -0.41689008f, -0.12103961f, 0.01682392f, 0.24470538f, 
    0.62137502f, -0.09436980f, 0.19182995f, 0.18312514f, -0.76931882f, -0.29005280f, 0.17810231f, 0.22566634f, 
    -0.12061515f, 0.25882277f, -0.04187325f, -0.52773887f, -0.50559574f, -0.53308654f, 0.19399668f, 0.00322719f, 
    0.40881908f, 0.24513850f, 0.22074912f, 0.34441966f, -0.12758072f, 0.43450910f, -0.06048214f, -0.50089425f, 
    0.20220667f, -0.08014490f, 0.64275908f, -0.31542456f, -0.19168867f, -0.10887488f, -0.26775396f, -0.53940046f, 
    -0.34202799f, -0.35333481f, -0.14544867f, -0.46803799f, 0.43763840f, -0.74830002f, -0.15447611f, -0.31535500f, 
    -0.10708187f, 0.83778268f, -0.56139350f, -0.47978708f, -0.09754215f, 0.43816552f, 0.35500416f, 0.20715785f, 
    -0.24302208f, -0.68922913f, -0.04188425f, 0.20732775f, -0.70627159f, 0.22943525f, -0.24946053f, -0.13192232f, 
    0.13090408f, 0.11889265f, -0.76178455f, 0.43338969f, 0.78903019f, -0.29460797f, -0.60110742f, 0.76208419f, 
    0.27946451f, -0.10598116f, -0.07646066f, 0.02322525f, 0.21820000f, -0.23477136f, -0.22564316f, -0.45719478f, 
    0.02881142f, 0.15418620f, -0.00436602f, 0.99862397f, -0.35389677f, -0.49025121f, -0.20323731f, 0.17653467f, 
    -0.47088549f, -0.58389390f, 0.03820417f, -0.15443872f, 0.05040023f, 0.48766947f, 0.21644416f, 0.17918453f, 
    -0.14068229f, -0.71737581f, -0.26036105f, 0.16388817f, 0.01751017f, 0.50850552f, 0.85753441f, 0.14721297f, 
    -0.38739055f, 0.67633581f, -0.15870237f, 0.19806913f, -0.03205299f, 0.77906436f, 0.06278421f, -0.31370801f, 
    -0.19166686f, -0.18542816f, 0.00554749f, -0.73653334f, 0.35272381f, -0.27574974f, -0.34492013f, 0.24105942f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.25630766f, -0.12699495f, -0.06319772f, -0.44644225f, 0.53048575f, 0.52196252f, -0.61530262f, -0.74932563f, 
    -0.62109339f, -0.20340924f, 0.71438563f, 0.06874435f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
