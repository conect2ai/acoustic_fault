#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.99140298f, 0.80128431f, 0.74343872f, -0.13975249f, 0.75274944f, 0.83904254f, -0.37195796f, 0.42503908f, 
    0.48348138f, 1.00153804f, -0.59773523f, -0.47265974f, 0.74588639f, -0.14492556f, -0.88627505f, 0.29563707f, 
    0.55177242f, 0.54580116f, 0.81894433f, -0.90651929f, 0.53814918f, -0.85743302f, 0.01163108f, 0.75059277f, 
    -0.13686067f, -0.20210975f, 0.33732760f, -0.89425755f, -0.78199875f, -0.08975065f, -0.87106782f, -1.40504706f, 
    -1.43463898f, 0.33610430f, 0.11704300f, 0.62039167f, -0.07560648f, -0.49471799f, 0.46819261f, 1.28911114f, 
    -1.07072401f, 0.16990881f, -0.10144544f, 0.20405528f, -0.06117624f, -1.37228012f, -1.31860840f, -0.85785228f, 
    0.02274332f, 0.17363697f, 0.11645052f, -0.26934373f, -0.84001380f, -1.03044605f, -1.69562268f, -1.36990714f, 
    0.85121238f, 0.89081496f, 0.10804871f, -0.57235652f, 0.09396832f, -0.11929703f, 0.57876688f, -1.38941586f, 
    -0.43569145f, 0.08555082f, 1.15086627f, 1.09867799f, -0.37161469f, 0.13333955f, -0.09632780f, -0.10038545f, 
    1.02483630f, 0.81404835f, -0.52340019f, -0.91403151f, -0.54499125f, 0.32473043f, 0.37491587f, 0.66898572f, 
    -0.25691628f, -0.50311053f, -1.58473432f, -0.27224740f, 0.23496354f, 0.64800584f, 0.62896788f, 0.24838740f, 
    -0.02445223f, 0.45147333f, -0.67766446f, 1.53603375f, 0.92775846f, -1.10914910f, 0.19560497f, -0.13596037f, 
    -0.39992350f, 0.24926731f, -0.20349832f, -0.56350303f, 1.00223565f, -0.32327887f, 0.41110894f, 0.56669021f, 
    -0.13826406f, -0.06317309f, 0.64539808f, -0.56901008f, 0.62174439f, 0.13426837f, 0.15704215f, 0.91959435f, 
    0.54425853f, 0.43263510f, 0.00468117f, 0.06157123f, 0.01000382f, 1.26816416f, 1.25114369f, -0.55472618f, 
    -0.43546158f, -0.32506502f, -0.29785097f, -0.20742010f, -0.31546044f, 0.56497401f, 0.45298797f, -1.11097646f, 
    -0.71805584f, -1.49739635f, -1.26773489f, -0.64227855f, 0.10820521f, -0.88358527f, -0.40491936f, 0.93552989f, 
    0.49881205f, -1.09244072f, -0.47480819f, 0.24369645f, 0.49852782f, -0.84942216f, -0.58254826f, -1.19326901f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19966522f, 0.39451516f, 0.67521977f, 0.26365256f, 0.15399943f, 0.03671578f, 0.43634701f, 0.34486279f, 
    0.24579974f, 0.35885170f, 0.56912810f, 0.49879780f, 0.29240039f, 0.65278667f, -0.13591577f, 0.12472677f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01792320f, -0.06569616f, 0.18773606f, 0.04014006f, 0.09143215f, 0.00434103f, -0.04178764f, 0.05633083f, 
    0.10936632f, 0.07578645f, -0.29009002f, -0.08146937f, -0.20246249f, -0.19725618f, -0.32302085f, -0.00110144f, 
    -0.05941812f, 0.04373302f, -0.08329425f, -0.05776624f, 0.16843578f, 0.12633288f, -0.15215153f, 0.18819159f, 
    0.03771158f, 0.03830692f, 0.09387881f, 0.02734238f, -0.04449205f, 0.02999412f, -0.03580385f, 0.10267875f, 
    -0.06919270f, 0.00690887f, 0.06904958f, -0.17141967f, -0.11583811f, -0.36394250f, -0.21984373f, -0.05149959f, 
    -0.93241310f, -0.49925300f, 0.12382232f, -0.16064623f, -0.15258811f, -0.20119262f, -0.10366458f, -0.03696461f, 
    -0.23034556f, -0.10964055f, -0.07496255f, -0.09301150f, -0.14246279f, -0.02107031f, -0.01053550f, 0.03751249f, 
    -0.08545721f, -0.09056141f, -0.11373843f, -0.20074573f, 0.51685315f, 0.55752629f, 0.17111667f, -0.71202689f, 
    -0.16256025f, 0.16500774f, 0.07015955f, -0.12474577f, 0.06308115f, 0.14548428f, 0.02164577f, -0.09896076f, 
    0.01630430f, 0.01066707f, -0.07191430f, -0.01705167f, -0.06236761f, -0.03181725f, -0.00601436f, -0.10300127f, 
    0.10382574f, -0.00964232f, 0.30497622f, -0.23307221f, 0.02630017f, -0.16441034f, 0.09723033f, 0.02224082f, 
    -0.14581376f, 0.03017615f, -0.18221165f, 0.10202303f, 0.00757591f, -0.27497560f, -0.03305640f, -0.10748489f, 
    -0.08988914f, -0.03697350f, -0.13748737f, 0.04636566f, 0.44069269f, 0.19306971f, 0.13072915f, -0.27262321f, 
    -0.06604917f, 0.21636461f, 0.19237274f, 0.22236587f, 0.04882237f, 0.09759025f, 0.00124269f, 0.00045528f, 
    -0.01691274f, -0.11297882f, -0.06567232f, 0.00225661f, -0.17828801f, -0.09280518f, -0.12135690f, -0.03070907f, 
    0.71986747f, 0.50231206f, -0.32419091f, -0.59825492f, 0.09252124f, 0.00201657f, 0.22154802f, 0.15919778f, 
    -0.25327423f, -0.26395625f, -0.10766835f, -0.22319832f, -0.15717378f, -0.00312500f, 0.02040563f, -0.12371950f, 
    0.09087557f, 0.11973418f, -0.06236577f, -0.06641138f, 0.26594096f, -0.18389790f, -0.68942326f, -0.08421610f, 
    -0.02071412f, 0.11596888f, 0.08429722f, 0.06694506f, 0.01798201f, 0.00227313f, -0.01893129f, 0.00137412f, 
    -0.01482392f, 0.07409366f, 0.01726832f, 0.00691274f, 0.12461784f, 0.06505126f, -0.01676797f, -0.01061490f, 
    -0.01670125f, -0.04001871f, -0.20783442f, -0.04421712f, -0.15491503f, -0.35178918f, -0.16134617f, -0.39327359f, 
    -0.00257556f, 0.01411290f, -0.07381785f, 0.15624994f, -0.02072163f, 0.00253986f, 0.14643596f, 0.01610920f, 
    -0.20334947f, -0.04930399f, -0.02547595f, 0.00311457f, 0.03929365f, 0.14918476f, -0.12390754f, 0.01666594f, 
    0.15929092f, 0.20823871f, 0.10197370f, 0.20036735f, -0.04508310f, -0.13017420f, -0.17049034f, -0.08168977f, 
    -0.22037759f, 0.05254944f, 0.04907252f, 0.03268187f, 0.07235466f, 0.06104943f, 0.06453869f, 0.02052714f, 
    -0.75766098f, -0.19661160f, 0.21811201f, 0.16718137f, -0.12407631f, 0.05613270f, -0.10597361f, -0.01094625f, 
    0.12446346f, -0.03415752f, 0.14299832f, 0.06915252f, 0.04790808f, -0.02613683f, 0.00277799f, 0.04075624f, 
    0.08955801f, 0.01639283f, -0.18754928f, -0.02282379f, -0.03078847f, -0.13992506f, -0.15033586f, 0.06300531f, 
    -0.03179260f, -0.01079419f, -0.06015173f, 0.01509745f, -0.03462274f, 0.06336041f, -0.18908079f, -0.03839741f, 
    -0.18090633f, -0.20443876f, -0.29262722f, -0.04118962f, 0.10027540f, 0.06188181f, -0.09941141f, 0.06735918f, 
    -0.05894998f, -0.07373882f, -0.00581729f, 0.13188213f, -0.01764545f, 0.11082280f, -0.00137586f, 0.07771561f, 
    0.02111132f, 0.06330952f, 0.03362739f, -0.09376685f, -0.11653796f, -0.05732089f, -0.11529694f, -0.00924349f, 
    0.05572189f, 0.01593575f, 0.07167462f, -0.03528303f, -0.51903409f, -0.47465789f, -0.09778942f, 0.02774189f, 
    -0.57306236f, 0.10962868f, -0.06643237f, -0.10579239f, -0.04662436f, -0.02988435f, 0.07153591f, 0.07429248f, 
    -0.07133776f, 0.09317715f, -0.00715213f, -0.02867432f, 0.17586772f, -0.14285548f, -0.03081740f, -0.21403717f, 
    0.42390606f, 0.41481957f, 0.37293378f, -0.66293055f, -0.12038809f, 0.16008906f, 0.16170539f, -0.05212284f, 
    -0.07055852f, -0.01738186f, -0.05880177f, -0.05391869f, -0.07677027f, -0.16832274f, -0.16335689f, -0.13070844f, 
    -0.09110018f, -0.04665091f, 0.16332558f, 0.28197208f, 0.11117697f, 0.14037718f, 0.42267093f, 0.12679951f, 
    -0.60856837f, -0.05000928f, -0.08216015f, -0.06032442f, 0.09610323f, 0.16232239f, 0.03453277f, -0.03951631f, 
    -0.08313017f, 0.05210777f, 0.01251234f, -0.09875322f, 0.02588296f, 0.08438645f, 0.23954417f, 0.11810044f, 
    0.06323171f, -0.10814828f, 0.21196948f, 0.14209436f, 0.15205379f, -0.09010241f, -0.11479097f, -0.06107423f, 
    -0.08280487f, -0.03592091f, 0.17170201f, 0.11613549f, -0.17015746f, -0.05423650f, 0.13372336f, -0.01387219f, 
    -0.08927077f, -0.04656729f, 0.01370301f, -0.00795692f, 0.26542261f, -0.02423589f, -0.20696169f, -0.03015404f, 
    -0.11467379f, 0.06496480f, -0.03435117f, 0.00190683f, 0.02894606f, -0.14871801f, 0.28510591f, 0.14614575f, 
    0.04640268f, 0.02960834f, -0.06756700f, -0.04238973f, 0.09349648f, 0.18146978f, 0.16403615f, -0.00648263f, 
    0.07293478f, 0.33020300f, 0.12155945f, 0.10423109f, 0.09966157f, -0.20776041f, 0.27444986f, -0.03475327f, 
    -0.17895354f, 0.22559518f, -0.07146726f, -0.09581216f, -0.02801130f, 0.05606850f, -0.04193804f, 0.02971829f, 
    0.22267592f, 0.19875421f, 0.05704492f, -0.05889713f, -0.46253544f, 0.17920911f, -0.36761042f, 0.30499336f, 
    -0.12626201f, -0.11164126f, 0.01338448f, -0.02644692f, 0.06093787f, -0.04685456f, -0.04969799f, -0.00880109f, 
    0.03829265f, 0.05460861f, 0.07269254f, -0.03169671f, 0.08157817f, 0.08837260f, -0.23049439f, 0.20977704f, 
    0.12151054f, 0.13344532f, -0.26065981f, -0.11760625f, 0.11827097f, 0.02170671f, 0.02812658f, -0.07304784f, 
    0.01909945f, 0.00740890f, -0.10847209f, 0.12552294f, 0.05589964f, -0.03398294f, -0.16008013f, -0.12291718f, 
    0.10581084f, 0.01545532f, -0.14304055f, 0.00271960f, 0.16848654f, 0.33930352f, 0.37588912f, -0.06231133f, 
    -0.21886607f, 0.06082095f, -0.27151754f, -0.04802372f, 0.16219021f, 0.03213662f, 0.07898805f, -0.01994500f, 
    -0.06482407f, -0.14995812f, 0.09133645f, 0.15143728f, -0.06487332f, -0.10952296f, -0.09989838f, -0.06219658f, 
    -0.21449918f, -0.09623780f, -0.00391318f, 0.04729597f, 0.25627849f, -0.02058784f, 0.01860053f, 0.33778173f, 
    0.21251598f, -0.09596028f, 0.16048680f, 0.05918130f, 0.13254125f, -0.07713172f, -0.14850099f, 0.03564841f, 
    0.03864631f, 0.04736852f, -0.05147024f, -0.08467962f, 0.41458759f, -0.10747481f, -0.16314933f, 0.00516563f, 
    -0.02949127f, -0.03829687f, -0.02328502f, -0.06207336f, 0.06802987f, -0.08253388f, 0.01063290f, -0.07805341f, 
    -0.06646950f, -0.09151145f, -0.04398046f, 0.09856750f, -0.07887946f, -0.05101277f, 0.03263270f, -0.11098737f, 
    -0.10219937f, -0.10428076f, 0.24016643f, -0.17254403f, -0.10547862f, 0.18704112f, 0.11718899f, -0.25433254f, 
    -0.03529770f, 0.00001530f, -0.01164423f, -0.10907765f, -0.11601669f, 0.22950794f, -0.03792289f, -0.05354876f, 
    0.00028004f, -0.12632143f, 0.15833029f, -0.03777163f, 0.02454549f, -0.42374739f, -0.13269420f, -0.07335734f, 
    -0.25685418f, -0.16947260f, 0.02678348f, 0.06713149f, -0.09291998f, 0.15032150f, 0.04662138f, 0.04204375f, 
    0.06387857f, 0.00911307f, -0.14502200f, -0.06182861f, 0.04598775f, 0.01054583f, -0.02394996f, 0.02684766f, 
    0.22128704f, -0.32254997f, 0.12419409f, -0.33333424f, 0.12970625f, -0.10239995f, -0.05551861f, -0.15209989f, 
    0.00584899f, -0.07853793f, -0.02240399f, 0.03034381f, 0.03727768f, 0.02200881f, 0.05235758f, -0.08082994f, 
    0.20682089f, -0.12839127f, 0.17682400f, -0.02734280f, -0.10243390f, -0.04639501f, 0.04352645f, 0.19787435f, 
    0.10170147f, -0.04901692f, -0.02391818f, -0.04378677f, -0.02161682f, -0.04603312f, 0.12265270f, 0.07788151f, 
    -0.08789612f, 0.01703762f, 0.11842534f, -0.10843303f, -0.00594576f, -0.08797999f, 0.07233276f, -0.00356173f, 
    0.43934023f, 0.06391351f, 0.17987123f, 0.11075368f, 0.17546722f, -0.02378965f, -0.00457426f, -0.02070900f, 
    0.00927197f, -0.03696184f, 0.00636950f, 0.02858769f, 0.08936763f, -0.06798884f, 0.01148193f, -0.01002721f, 
    -0.15584975f, -0.12679122f, 0.05455362f, -0.09538212f, 0.29757738f, -0.01238621f, -0.07441073f, -0.11548502f, 
    -0.18443245f, 0.05384130f, -0.23705946f, -0.20425057f, -0.05949677f, -0.00647306f, -0.12041810f, -0.01313861f, 
    0.06432453f, 0.05735690f, -0.03870745f, 0.01484184f, 0.08427660f, -0.16806108f, 0.07618347f, 0.16122073f, 
    -0.43380752f, 0.38252935f, -0.14779069f, -0.02844104f, -0.05536390f, 0.05631779f, -0.25382161f, -0.03414428f, 
    -0.40708867f, -0.07316852f, 0.01241771f, 0.06190642f, 0.04060742f, 0.06674570f, 0.14905807f, -0.00419398f, 
    -0.03761293f, -0.00192450f, -0.48328644f, -0.27114981f, 0.57149011f, 0.18725453f, 0.14970922f, 0.18526830f, 
    -0.50473654f, -0.03108818f, 0.02568738f, -0.02456743f, -0.12586176f, 0.01279331f, -0.06984549f, 0.01750912f, 
    -0.03374843f, -0.07378931f, 0.04152210f, -0.09210660f, -0.55719280f, -0.25992277f, 0.09096973f, -0.23140414f, 
    0.18009268f, -0.00613642f, -0.22987042f, 0.00179267f, 0.19557507f, -0.06896047f, 0.04602270f, 0.05630694f, 
    0.02279311f, 0.09997194f, -0.20645761f, 0.02822781f, 0.05032815f, 0.06626082f, -0.03240293f, 0.07538631f, 
    0.00139232f, 0.05188456f, 0.01503573f, -0.02904107f, -0.27149445f, 0.17588064f, -0.00538369f, -0.13734476f, 
    -0.02057057f, 0.07226753f, -0.16911173f, -0.12398776f, -0.10213552f, -0.08253504f, -0.13880652f, -0.19579148f, 
    0.00987357f, -0.07652617f, -0.09002858f, 0.03758257f, -0.12578212f, -0.16305311f, 0.17721345f, -0.11841414f, 
    -0.28374898f, 0.28724775f, -0.41853893f, 0.23754467f, 0.14048143f, -0.04041709f, 0.02585679f, 0.04878046f, 
    -0.15214676f, 0.06229066f, 0.02839402f, 0.04376470f, 0.07051395f, 0.05683879f, -0.17311679f, 0.09170206f, 
    0.00595204f, 0.13506289f, 0.06420697f, -0.02639581f, -0.53344911f, -1.24215555f, -0.62166458f, 0.05400724f, 
    -0.58112848f, 0.10116113f, -0.03140040f, -0.14361158f, -0.13690604f, -0.23010574f, -0.02085710f, 0.03039934f, 
    -0.01464845f, -0.00523666f, -0.14242136f, -0.08472276f, 0.02772475f, 0.06556246f, -0.35598764f, -0.00794425f, 
    0.10033289f, 0.22330230f, -0.57897073f, -0.18224242f, 0.02565332f, 0.19589469f, -0.13034198f, -0.07867555f, 
    0.16168164f, -0.02760368f, 0.11229352f, -0.01355515f, -0.22619294f, -0.02103330f, 0.09444691f, 0.00880392f, 
    -0.07235785f, -0.00056805f, 0.25213662f, -0.04360661f, -0.42551526f, 0.16668358f, 0.91172147f, 0.59228623f, 
    0.74212629f, -0.00089577f, -0.08180343f, 0.02714034f, 0.17701709f, 0.17523734f, -0.05036647f, 0.04670841f, 
    -0.02117253f, -0.00919211f, -0.02433143f, 0.07377925f, 0.08885670f, 0.01376148f, -0.09678904f, 0.09075144f, 
    0.59161413f, -0.00138378f, 0.50104529f, 0.75574768f, 0.20443645f, 0.12186658f, -0.15188946f, -0.28336743f, 
    0.07772769f, 0.05527765f, 0.10140587f, 0.16915411f, 0.09325293f, -0.07168584f, -0.08906027f, -0.03260757f, 
    -0.09544072f, -0.04483237f, -0.00109392f, -0.03071524f, -0.09514951f, -0.62063730f, 0.79258889f, 0.17451440f, 
    0.32040328f, 0.11931406f, -0.05277164f, 0.04826417f, 0.22552361f, -0.06787430f, -0.05433159f, 0.02961709f, 
    -0.00775646f, -0.06817289f, -0.09755341f, 0.05027030f, -0.06326044f, -0.04154755f, 0.05652219f, -0.02467840f, 
    -0.45206735f, 0.03006469f, 0.08452288f, 0.03044993f, -0.18518452f, -0.07499901f, 0.01608988f, -0.00461770f, 
    -0.33997390f, 0.06029772f, 0.07596410f, -0.00197261f, -0.11342684f, 0.14245202f, -0.09586644f, 0.12615101f, 
    0.04708762f, 0.03284391f, -0.16792704f, -0.14132777f, 0.13116005f, 0.04658371f, 0.35417137f, 0.15464550f, 
    0.29455194f, -0.08921763f, -0.00819313f, 0.10886335f, 0.03721677f, -0.19086987f, 0.07610633f, -0.07808818f, 
    0.14664486f, -0.08006969f, 0.12761030f, -0.03711355f, -0.01228227f, 0.04873116f, -0.04868196f, -0.07195988f, 
    0.21853034f, -0.07266425f, 0.04571363f, -0.65395999f, 0.19326022f, -0.02984498f, 0.05234918f, -0.11603190f, 
    0.04528552f, 0.11276256f, -0.04431291f, 0.02585938f, 0.01004908f, -0.01185736f, -0.07478340f, -0.05852641f, 
    0.15781492f, -0.16213870f, 0.09488407f, 0.05880346f, 0.39129320f, -0.24166411f, 0.01239871f, -0.12652449f, 
    0.13473417f, 0.06630519f, -0.13265420f, -0.04064551f, -0.02326093f, 0.03632799f, -0.09153600f, -0.08056279f, 
    -0.09090018f, 0.11689673f, -0.03239498f, 0.15219001f, 0.01757170f, -0.07883754f, 0.14213675f, -0.00406602f, 
    -0.09900212f, -0.05820698f, -0.12041548f, -0.14174192f, 0.06541265f, -0.02292235f, -0.10256175f, -0.05608130f, 
    0.08478711f, 0.07341830f, -0.21914119f, -0.03153384f, 0.09541748f, 0.05894040f, 0.09194302f, 0.06829689f, 
    0.06009899f, -0.00154299f, 0.13433173f, 0.00584730f, -0.43911752f, -0.14473590f, 0.34395504f, -0.22944409f, 
    0.10406707f, -0.01842335f, -0.02488089f, 0.01364186f, -0.11394461f, 0.07654797f, -0.00099352f, -0.07655172f, 
    0.01751002f, -0.04976752f, 0.03513899f, 0.02412063f, -0.21031788f, -0.28622431f, 0.03586579f, -0.06509877f, 
    -1.10092878f, -0.49066505f, -0.76162887f, 0.46000248f, -0.91861993f, 0.01620686f, -0.01215308f, -0.05146419f, 
    -0.17252542f, 0.11562888f, -0.02901826f, 0.00085817f, -0.04632463f, 0.07351685f, -0.08415813f, -0.06470802f, 
    0.01593392f, -0.01533741f, 0.05393830f, 0.17735508f, -0.05530156f, -0.48714501f, 0.17654413f, 0.12281128f, 
    -0.53435427f, -0.01031217f, -0.04190569f, 0.01707961f, -0.06167227f, 0.14893176f, 0.04582576f, 0.01813305f, 
    -0.01644814f, 0.02782713f, -0.05766945f, 0.09361435f, 0.22496498f, 0.24455079f, 0.15885326f, 0.03040460f, 
    0.20848654f, 0.34034035f, -0.07247175f, 0.04024588f, -0.64301962f, 0.18353721f, -0.20830657f, 0.00346208f, 
    -0.29372695f, -0.13665058f, -0.15096907f, -0.13248183f, 0.10750619f, 0.16303916f, -0.03349054f, 0.20900539f, 
    0.19882619f, -0.31320310f, -0.09695795f, -0.03342074f, -0.86040485f, 0.09064034f, -0.10995734f, 0.24845794f, 
    0.02156083f, 0.14819008f, 0.05694450f, 0.21389352f, -0.06697407f, 0.15294218f, -0.16364115f, 0.01322547f, 
    -0.05578713f, 0.01214577f, -0.26287556f, 0.08375292f, -0.12216932f, 0.23116288f, 0.08384568f, -0.26735148f, 
    -1.29105306f, 0.22309199f, -0.17935289f, -0.07243768f, -0.67748260f, 0.05715321f, -0.29487047f, -0.25869140f, 
    0.20889553f, -0.25173873f, 0.01783980f, 0.11222161f, -0.03560387f, -0.29676786f, -0.09281458f, 0.06090504f, 
    -0.00541160f, 0.17658469f, -0.02439420f, -0.25157565f, 0.16075364f, -0.27579224f, -0.48398846f, 0.07886538f, 
    0.37580538f, 0.10673825f, 0.15645221f, -0.01053535f, 0.12555410f, 0.20190771f, 0.09980821f, -0.05866792f, 
    -0.22555342f, -0.03367916f, -0.03565509f, -0.03401776f, -0.11990742f, 0.11483204f, -0.23093130f, 0.10175727f, 
    -1.00857782f, 1.10489583f, 0.36371973f, -0.56274480f, -0.30111071f, 0.04290249f, 0.28114149f, 0.06967993f, 
    0.08949989f, -0.28465772f, -0.20488696f, -0.11249734f, -0.42591104f, 0.04956972f, -0.06410062f, -0.20864764f, 
    -0.12199627f, 0.39712968f, -0.13543689f, -0.31802893f, 0.00646395f, 0.00220680f, -0.26996565f, -0.16580212f, 
    0.42556322f, 0.22531530f, 0.11953834f, -0.02541287f, 0.05293659f, -0.05692568f, -0.08756378f, 0.05669293f, 
    0.14662533f, 0.12295011f, 0.19051330f, -0.10280987f, 0.10002962f, 0.21224651f, -0.12151490f, 0.12546201f, 
    -0.58403730f, 0.51324791f, -0.17064400f, -0.42178646f, 0.48589823f, 0.25558826f, 0.06648897f, -0.21824585f, 
    -0.06105645f, -0.32321420f, -0.29621807f, 0.19816144f, -0.10638677f, 0.02947036f, 0.07255409f, -0.03343431f, 
    0.11353879f, -0.05033289f, 0.06476721f, -0.19151349f, 0.17699696f, 0.85370028f, -0.21838675f, -0.21388055f, 
    0.23022202f, 0.51561987f, 0.24036311f, 0.08155464f, -0.18712266f, -0.01296008f, -0.21714553f, -0.10065619f, 
    0.05802493f, -0.12756675f, 0.10113148f, -0.19702443f, -0.02291970f, -0.29247633f, 0.25872236f, 0.19475058f, 
    -0.69770986f, 0.25958008f, 0.43786478f, 0.38860932f, 0.32587153f, 0.00243570f, 0.10562676f, 0.03901310f, 
    0.06817967f, -0.14525507f, 0.06053428f, -0.00244190f, -0.09233727f, -0.10953083f, 0.17499043f, 0.07669138f, 
    -0.09276617f, 0.12904595f, -0.17603713f, -0.08349629f, -0.86312324f, 0.51105464f, 0.01697534f, -0.21431918f, 
    0.40877888f, 0.39068875f, 0.04243871f, -0.06531868f, -0.13560863f, -0.09865153f, 0.00607313f, 0.01665193f, 
    0.12652673f, -0.09969184f, -0.00766630f, 0.00273827f, 0.08763302f, -0.05939255f, 0.05808690f, 0.05230005f, 
    0.69349289f, 0.10467597f, 0.66053700f, -0.91474944f, 0.16228779f, -0.35461107f, -0.04709902f, -0.00095702f, 
    -0.14896463f, 0.09994517f, -0.04055525f, -0.22059266f, 0.29464024f, 0.19382332f, 0.17362288f, -0.10686210f, 
    -0.09183285f, -0.10175180f, 0.13976198f, 0.04726139f, -0.00955349f, 0.22895788f, -0.58445269f, 0.30181649f, 
    -0.94737768f, 0.20284039f, -0.02054337f, -0.13424051f, -0.17793655f, 0.13727660f, -0.29773292f, -0.26255858f, 
    0.14102690f, 0.02493669f, 0.01985792f, 0.03204491f, 0.06139985f, -0.30655134f, 0.07618859f, 0.03999674f, 
    -0.67351717f, -0.45759484f, -0.49524260f, 0.13162704f, -0.43551564f, 0.39733028f, 0.22290047f, 0.08970060f, 
    0.10301642f, 0.14354926f, -0.11256889f, -0.02371439f, 0.13162310f, -0.15381700f, -0.17830285f, -0.07494677f, 
    0.17093813f, -0.19275497f, -0.03096326f, -0.06680053f, -0.98716217f, -0.10174023f, 0.40124139f, 0.12266181f, 
    0.63883084f, -0.06139998f, 0.01702054f, -0.19298479f, 0.00131725f, 0.04397464f, 0.10377557f, 0.05005830f, 
    -0.00508218f, -0.12454803f, 0.07092176f, -0.09487139f, 0.06844556f, 0.15430282f, 0.01945809f, -0.10630250f, 
    -0.20485124f, -0.24689324f, -0.36298358f, 0.23579687f, 0.48804995f, -0.11236606f, 0.18009871f, -0.02555063f, 
    0.09280934f, 0.07390708f, -0.00166060f, -0.04340816f, -0.15662295f, -0.17517385f, 0.04282091f, -0.03733692f, 
    -0.04451749f, -0.03156935f, -0.17103453f, -0.05543378f, 0.20416267f, -0.22956197f, 0.12528048f, 0.03217113f, 
    0.10953015f, -0.22045033f, 0.06998064f, 0.10865404f, 0.26599413f, 0.09580703f, -0.06144778f, 0.11550435f, 
    0.23379341f, -0.09222923f, -0.05323412f, -0.14037071f, 0.08969799f, 0.01876417f, 0.02332398f, 0.07225616f, 
    0.03237616f, -0.01241268f, -0.21648756f, -0.10870824f, -0.02801943f, 0.12827973f, -0.00892491f, 0.01898566f, 
    0.08821756f, 0.07374533f, 0.02788353f, -0.26994115f, 0.05426586f, -0.08690094f, 0.09007540f, 0.08929875f, 
    -0.08057358f, 0.05201663f, -0.00427235f, 0.05860884f, 0.20666914f, 0.06004633f, 0.15521888f, -0.21828793f, 
    0.05284558f, 0.21939975f, 0.08013415f, 0.07829142f, 0.06880455f, 0.06302194f, 0.06502771f, -0.14687912f, 
    0.11552346f, 0.07010678f, 0.02078957f, 0.08100612f, -0.18859063f, -0.32743606f, -0.31268072f, -0.25985256f, 
    -0.07060128f, -0.58497781f, -0.10605270f, -0.49643207f, -0.00985214f, -0.06029181f, -0.11351376f, -0.06961890f, 
    0.12987033f, -0.20549075f, -0.08511665f, -0.15493235f, -0.06505235f, -0.11569312f, 0.00967689f, -0.17093349f, 
    -0.24251407f, -0.11195263f, -0.20126204f, 0.03923689f, 0.12057240f, 0.30074051f, 0.47897422f, 0.51300025f, 
    0.21082994f, -0.22465287f, 0.03714675f, -0.08811523f, 0.04998412f, 0.26257533f, -0.03721054f, 0.02885755f, 
    0.00875041f, 0.01339391f, 0.03171962f, -0.07039971f, -0.02387576f, -0.14751367f, -0.06188630f, -0.38564363f, 
    0.18971363f, -0.25688702f, -0.10530464f, 0.07275256f, -0.30630967f, 0.07187024f, -0.18148057f, 0.13276829f, 
    0.05437194f, 0.00325727f, 0.13536796f, -0.01885547f, -0.38670185f, 0.01966316f, -0.13636388f, 0.04512377f, 
    -0.18775670f, 0.04827999f, -0.11516631f, -0.20945691f, -0.29114917f, -0.11670862f, -0.00019187f, 0.17655203f, 
    0.18117613f, -0.24630186f, -0.01577489f, -0.08478770f, -0.24029288f, -0.20917712f, -0.00795155f, 0.08623571f, 
    -0.08415232f, 0.06537765f, -0.01877551f, 0.00109716f, 0.02923490f, -0.01229648f, 0.11110426f, 0.21145301f, 
    0.05428945f, -0.23244084f, -0.23440811f, 0.20011131f, -0.08919837f, -0.25774497f, -0.22930621f, 0.06370183f, 
    -0.22362214f, -0.05388253f, -0.22005463f, -0.07469603f, 0.03237141f, 0.11712052f, 0.05671968f, -0.09956013f, 
    -0.17882401f, 0.04896126f, -0.09409578f, -0.06449109f, -0.04694132f, -0.90407956f, 0.11241004f, 0.15396088f, 
    0.05618232f, -0.09981358f, -0.13132958f, 0.04810508f, -0.10273607f, 0.24671626f, 0.08516957f, 0.01865047f, 
    -0.00553832f, -0.11630923f, -0.05264721f, 0.04699536f, 0.07419703f, 0.06060130f, -0.11761107f, 0.00651348f, 
    -0.08772431f, -0.13491820f, -0.04291808f, -0.07291745f, 0.23247036f, 0.02002672f, 0.09846649f, 0.19529340f, 
    -0.04443897f, -0.03027509f, 0.01229029f, 0.00892400f, 0.09612205f, -0.25110677f, 0.04240408f, -0.13352545f, 
    -0.01255635f, -0.05298792f, -0.06101197f, -0.14935006f, 0.20855930f, -0.11821271f, 0.06997282f, -0.00263030f, 
    0.03994424f, -0.13274626f, -0.06184303f, 0.00721420f, 0.04523963f, -0.01223943f, 0.10124286f, -0.04063651f, 
    -0.18723935f, 0.10874379f, 0.06245242f, 0.01778742f, 0.02123382f, 0.00951526f, -0.01061943f, -0.16195203f, 
    0.61130327f, 0.00698112f, -0.70053327f, 0.71101272f, 0.11504722f, 0.17741813f, -0.02665746f, 0.06096101f, 
    -0.00300066f, 0.06231805f, 0.13517261f, -0.09441452f, -0.02123829f, -0.00097820f, 0.08916391f, 0.00801392f, 
    0.01820003f, -0.01053845f, -0.30348316f, -0.01228901f, 0.19444172f, -0.12896302f, -0.19804429f, -0.10799214f, 
    -0.15162593f, 0.08900183f, -0.10925836f, 0.05524872f, 0.11957043f, 0.11383861f, -0.12482819f, -0.25819531f, 
    -0.04885735f, -0.10249880f, -0.01385228f, -0.02450197f, -0.01066411f, 0.07503200f, -0.26830673f, 0.07042830f, 
    0.06337558f, 0.06524183f, -0.05978557f, -0.18585831f, -0.16049072f, 0.18793245f, 0.10394683f, -0.03694969f, 
    0.02351916f, 0.13985784f, 0.08191208f, 0.10778592f, -0.04342382f, 0.00638161f, -0.04361481f, 0.14831394f, 
    0.12246069f, 0.05580703f, -0.00858910f, 0.13236892f, 0.02285733f, -0.17485303f, -0.12787160f, 0.09801506f, 
    0.30719340f, -0.00887362f, 0.13954438f, 0.01244748f, 0.04084383f, -0.01956278f, 0.05895169f, 0.00289278f, 
    -0.04649714f, -0.06153644f, 0.00839967f, -0.17072621f, -0.15607278f, 0.04249119f, -0.04393385f, -0.12599240f, 
    0.17930384f, 0.05621554f, 0.40915000f, 0.20526326f, 0.12685794f, -0.08776158f, 0.22249272f, -0.05961941f, 
    0.15130624f, 0.10296366f, 0.10576735f, -0.02247527f, -0.08334354f, 0.05879014f, -0.00292019f, 0.02177940f, 
    0.08604642f, -0.14753111f, 0.04055855f, 0.07594761f, -0.74314266f, 0.31970850f, -0.59508902f, -0.42096570f, 
    -0.02016142f, 0.09744203f, 0.04607670f, -0.04195913f, 0.05331296f, 0.02144933f, 0.02040832f, -0.04465351f, 
    0.03799017f, 0.07106556f, -0.04229097f, 0.16233353f, 0.30230027f, 0.27041423f, -0.09953959f, 0.31189334f, 
    -0.25235641f, -0.16167824f, -0.31553200f, 0.15151922f, 0.07721382f, 0.15854670f, -0.05434496f, -0.21369594f, 
    0.08219656f, 0.14247397f, 0.16854356f, -0.14841039f, 0.05696833f, 0.19552180f, -0.10153151f, -0.01445234f, 
    0.08029074f, 0.13375038f, -0.02012909f, 0.02774162f, 0.00324391f, -0.04430883f, 0.10044609f, -0.18397984f, 
    0.17794637f, -0.15869546f, 0.15122092f, 0.01730528f, -0.18383421f, 0.00013466f, 0.03479090f, -0.09071801f, 
    -0.03234591f, -0.14441092f, -0.11677978f, 0.15532799f, 0.03766892f, -0.10797836f, -0.02232760f, 0.23848605f, 
    0.64846146f, -0.66279578f, 0.16426086f, 0.16603552f, 0.12154956f, 0.24029014f, -0.23227564f, -0.05581222f, 
    -0.06640939f, 0.16710947f, 0.09059533f, 0.18129049f, 0.02373516f, -0.09011295f, 0.24316722f, 0.05671988f, 
    -0.16349921f, -0.09792392f, 0.00965825f, 0.31563637f, 0.13742638f, -0.07014783f, 0.58155918f, -0.12903197f, 
    -0.33777422f, 0.21439254f, 0.12007290f, 0.10439658f, -0.08170280f, -0.22276886f, 0.09297783f, -0.06341869f, 
    0.05919917f, 0.05545714f, 0.06513667f, 0.05217581f, 0.12967354f, -0.12149321f, 0.02355235f, 0.17301184f, 
    -0.10444335f, -0.16702305f, 0.29457960f, 0.16894516f, 0.18552984f, -0.07169962f, 0.00538631f, -0.19617440f, 
    -0.15351841f, -0.03517353f, 0.22986388f, -0.13433506f, 0.27337337f, 0.18774074f, 0.12040067f, 0.08171169f, 
    -0.16264486f, 0.06922066f, 0.15381214f, 0.04881213f, -0.18446729f, 0.05321142f, -0.08535630f, 0.08093729f, 
    -0.35737363f, 0.00634504f, -0.02002251f, 0.02986678f, -0.19256076f, -0.08335371f, -0.03614566f, -0.06936736f, 
    -0.05572734f, 0.05755194f, 0.06391206f, -0.25718963f, -0.02264844f, -0.02737252f, -0.12007907f, -0.23624180f, 
    -0.38296878f, -0.33890679f, 0.22730957f, -0.34724569f, -0.67952740f, -0.03742645f, 0.01030061f, -0.13554437f, 
    0.06769875f, 0.09107181f, 0.12163138f, -0.00148630f, -0.19488457f, -0.07569413f, 0.18567152f, 0.01829522f, 
    0.03149677f, -0.05128650f, 0.09334183f, 0.19617821f, -0.93278170f, 0.56705970f, -0.43117407f, -0.47883320f, 
    -0.27936807f, -0.01249735f, -0.05027528f, 0.05155928f, -0.01288244f, -0.26096848f, 0.07300419f, 0.09983690f, 
    -0.15395683f, 0.13854963f, -0.00327964f, -0.09845735f, -0.10330266f, 0.15395692f, 0.05832987f, 0.06364813f, 
    0.50768888f, 0.05598799f, -0.47655442f, 0.08344469f, 0.09279107f, 0.09946806f, -0.20206994f, 0.07529961f, 
    -0.10262202f, 0.26224107f, -0.19196990f, 0.05227189f, -0.03094440f, -0.11662702f, -0.09030432f, 0.12258854f, 
    -0.01875331f, 0.16600801f, -0.17171557f, 0.03366902f, 0.09119511f, -0.35910901f, -0.41284767f, -0.15024346f, 
    -0.06571343f, 0.12634256f, 0.00477233f, -0.13063088f, -0.02107750f, 0.04221173f, -0.04764902f, 0.09405373f, 
    -0.11226044f, -0.12663303f, -0.19877347f, -0.10175207f, -0.03878128f, -0.01211708f, -0.06462031f, 0.15434226f, 
    -1.45318115f, 0.03730575f, -0.10497133f, 0.71987623f, -0.14836892f, 0.13074011f, -0.11320369f, -0.02916000f, 
    0.17133252f, -0.00453480f, -0.12978074f, 0.04601953f, -0.05987843f, -0.00381160f, -0.00456264f, 0.02706336f, 
    -0.26228392f, 0.26574120f, -0.09081576f, -0.17233102f, -0.28544199f, 0.30635467f, -0.30877760f, -0.17015007f, 
    0.09079019f, 0.05284198f, -0.07793316f, -0.01637544f, 0.02933600f, -0.07865990f, 0.25592998f, -0.04355226f, 
    0.17286363f, 0.10207532f, -0.03713848f, -0.06104213f, -0.14173867f, 0.26526079f, 0.21051274f, 0.02347209f, 
    -0.28879929f, -0.20996654f, -0.31474108f, -0.05923352f, 0.08094506f, 0.00695732f, 0.03658085f, -0.12356523f, 
    -0.11550809f, 0.03399762f, 0.13146657f, -0.02019290f, -0.20408680f, 0.13055101f, 0.15088162f, -0.17017232f, 
    -0.02757438f, 0.18516096f, 0.03930547f, 0.02701028f, 0.56430805f, 0.09569748f, -0.58683354f, 0.01757918f, 
    0.29224992f, -0.05256180f, 0.36541548f, 0.06314112f, -0.08680243f, 0.08938392f, 0.10413361f, -0.06925234f, 
    -0.04521304f, -0.03815684f, -0.01904457f, 0.02556894f, -0.04398984f, 0.18135273f, -0.16168751f, 0.04643507f, 
    0.43625870f, -0.00923356f, 0.40599343f, 0.27921304f, -0.38115245f, 0.01598219f, 0.18458013f, -0.03846726f, 
    0.07665621f, 0.20498295f, 0.12830693f, -0.03187065f, -0.02003471f, 0.12273235f, 0.02647241f, 0.04044950f, 
    -0.00077807f, -0.12508194f, -0.06883744f, -0.12632574f, 0.27325600f, 0.11552124f, 0.02253754f, -0.22474550f, 
    0.41856286f, 0.04535904f, 0.00513104f, -0.08048952f, -0.01800343f, -0.10960218f, 0.10740399f, 0.03728090f, 
    0.03005843f, -0.04815393f, 0.06854517f, -0.26394749f, -0.21786684f, -0.13912708f, 0.02892552f, -0.42294943f, 
    -0.12477004f, 0.00246252f, 0.01315523f, -0.14823262f, 0.07867889f, -0.08358574f, 0.04884803f, 0.00839906f, 
    -0.10704994f, 0.12678722f, -0.03775230f, 0.22565567f, -0.07119925f, 0.11098704f, -0.12993477f, -0.03067408f, 
    0.01371551f, -0.10198667f, -0.01877758f, -0.04915879f, 0.07017829f, 0.19682643f, -0.12113164f, -0.01311539f, 
    -0.05492110f, 0.00865215f, -0.08823330f, -0.08849616f, -0.16952334f, -0.23507249f, -0.06895693f, -0.16912247f, 
    -0.15819027f, 0.07153443f, 0.07699604f, -0.00196766f, -0.10319591f, 0.11940397f, -0.54439139f, -0.20189334f, 
    0.17807668f, 0.21997102f, -0.50810462f, -0.11184211f, 0.23196654f, -0.08997834f, 0.00126863f, 0.18046959f, 
    0.11371599f, 0.32559997f, 0.07427977f, -0.02391678f, -0.01702511f, 0.03021116f, -0.00007230f, -0.07460427f, 
    0.19770327f, -0.16429929f, 0.04426415f, 0.09699214f, -1.35822439f, -1.18414068f, -0.82869989f, -0.20092483f, 
    0.27105731f, -0.18708204f, -0.22346440f, -0.42721957f, -0.24423024f, -0.62988168f, -0.00953806f, -0.08720241f, 
    -0.08931732f, 0.00979260f, 0.03133986f, -0.04179252f, 0.02828097f, 0.20587076f, 0.24635769f, 0.07795967f, 
    -0.15187199f, 0.04960116f, 0.26240912f, 0.11262963f, 0.01747121f, -0.03150848f, 0.11202659f, -0.09558015f, 
    0.11193101f, 0.18853483f, 0.10370161f, -0.08494866f, 0.24324259f, 0.17968972f, 0.02980408f, 0.03039183f, 
    -0.00334990f, 0.01098248f, 0.02488944f, 0.05022740f, -0.34784496f, -0.96561712f, -0.45954254f, -0.00454058f, 
    0.51348352f, -0.17784768f, 0.02617386f, 0.06194356f, -0.17500618f, 0.19249971f, 0.02651790f, 0.02475869f, 
    0.09520308f, -0.11154805f, -0.22323366f, -0.07413820f, 0.00846404f, -0.01709983f, 0.28631377f, -0.03918610f, 
    -0.82776767f, -0.10794861f, 1.13198984f, 0.02452836f, -0.26337194f, -0.08654922f, -0.11139192f, -0.13991977f, 
    -0.11288351f, 0.12247373f, -0.05247114f, 0.15335284f, -0.03888827f, 0.15095602f, -0.00097495f, -0.04227901f, 
    0.10183442f, -0.01878033f, 0.02151445f, 0.03541685f, -0.45454526f, -0.19010125f, 0.69132465f, 0.17614414f, 
    0.16325030f, 0.00125210f, -0.08115890f, -0.01979958f, -0.11931747f, 0.05598616f, 0.03436754f, 0.19474855f, 
    0.09047177f, 0.07936304f, 0.04461401f, 0.07134002f, 0.05328685f, 0.05992979f, -0.04963687f, 0.02117168f, 
    0.57308137f, -0.03101414f, -0.68343896f, -0.37399805f, 0.06310427f, -0.00240381f, -0.05048388f, 0.26034197f, 
    0.24628910f, -0.04053578f, 0.08652914f, -0.00996597f, -0.01892732f, -0.28493565f, -0.02248845f, -0.02410776f, 
    0.00229255f, -0.06995977f, 0.10452574f, 0.10076991f, -0.51603311f, 0.72913760f, 0.64714962f, 0.09101895f, 
    0.35770720f, -0.16582745f, -0.01476420f, -0.20292649f, -0.09893566f, 0.26074597f, -0.19501419f, 0.08004534f, 
    0.08176403f, 0.14499368f, 0.19473587f, 0.00494196f, -0.05702090f, -0.08549041f, 0.10573807f, -0.01834585f, 
    -0.10426950f, -0.35590574f, -0.20943534f, -0.25388741f, 0.42730081f, -0.05667054f, 0.19395985f, 0.17450441f, 
    -0.17686540f, 0.05198264f, -0.10697625f, -0.03954842f, -0.05494753f, -0.04484262f, -0.02086927f, 0.02939425f, 
    -0.12069804f, -0.30950794f, 0.19431332f, -0.02322076f, -0.03898263f, 0.00288355f, 0.17867139f, 0.08580100f, 
    0.05326668f, 0.06922334f, -0.05256118f, 0.00817051f, -0.02358827f, 0.10137028f, 0.09143463f, 0.25863922f, 
    0.03814913f, -0.03976431f, -0.04419127f, 0.11776299f, -0.02156622f, 0.01665287f, -0.11051993f, -0.03460718f, 
    -0.06495467f, 0.06399960f, 0.03885965f, -0.12594244f, 0.00124859f, -0.02389147f, 0.01789742f, -0.07330766f, 
    -0.05166048f, 0.03393075f, -0.13365111f, -0.03735644f, -0.04704612f, -0.10570783f, -0.00803589f, -0.02434249f, 
    -0.05276920f, 0.00763679f, -0.19805524f, 0.06918244f, 0.38048267f, -0.08314234f, -0.33188552f, -0.13495056f, 
    0.21340320f, -0.01747241f, -0.03512583f, 0.30881760f, 0.11347020f, -0.21790564f, -0.04322505f, 0.00899377f, 
    -0.13418478f, -0.01897709f, 0.05168625f, 0.08724345f, -0.07844342f, 0.07095890f, -0.17092094f, 0.16402109f, 
    -1.29260993f, -1.20130610f, -1.45753193f, -0.34281456f, -0.07264616f, -0.07852440f, 0.03780856f, 0.02198277f, 
    -0.08919684f, -0.51597750f, 0.09930693f, -0.06235022f, -0.08481700f, -0.12656690f, -0.00162011f, 0.00869295f, 
    0.01840371f, 0.07914805f, 0.15486795f, 0.19869493f, -0.67400140f, 0.05212849f, 0.00397507f, -0.49827698f, 
    0.04259169f, -0.06748687f, 0.01868181f, 0.08681649f, 0.10938746f, -0.08740982f, 0.03785420f, -0.00146289f, 
    0.03050003f, 0.00618749f, -0.06820017f, 0.10063656f, 0.28763428f, 0.15380816f, 0.18241793f, -0.00116160f, 
    0.17646335f, 0.30230451f, -0.19447874f, 0.02361013f, -0.30160061f, -0.05104578f, 0.09475040f, 0.07491859f, 
    -0.10365419f, -0.11649749f, -0.42367551f, -0.04640568f, 0.15789825f, -0.12611751f, -0.30936444f, -0.02450675f, 
    -0.08516536f, 0.14445433f, -0.05231509f, -0.00445182f, -0.34394690f, 0.02136185f, 0.27619797f, -0.14840746f, 
    0.20854943f, -0.05318086f, 0.06367525f, 0.07041313f, 0.00907053f, 0.02532570f, -0.38473549f, 0.03142805f, 
    0.06480487f, 0.13566259f, 0.05675988f, -0.07251561f, -0.13758487f, -0.01696140f, 0.03237655f, -0.01945900f, 
    0.09624147f, -0.09879553f, -0.17351010f, 0.06423115f, -0.13951445f, 0.08356543f, 0.02900336f, -0.00113741f, 
    -0.35608968f, -0.06178584f, -0.02753194f, 0.10734442f, -0.04709402f, 0.03800793f, -0.04360366f, -0.17113015f, 
    -0.15239570f, 0.06522044f, -0.09309684f, 0.04201772f, -0.07681113f, -0.94765627f, 0.67378408f, 0.66506135f, 
    -0.06689923f, -0.02532582f, 0.05021548f, -0.08833570f, 0.08134130f, 0.14143570f, 0.01460111f, -0.02169804f, 
    -0.09568675f, -0.09380262f, -0.10334763f, 0.04554717f, -0.03958760f, -0.12811364f, 0.13544042f, -0.24333809f, 
    0.13263009f, 0.05247162f, 0.28199282f, -0.40166584f, 0.12234405f, -0.11419532f, 0.19334100f, -0.06545205f, 
    0.01535681f, -0.05837378f, -0.07564985f, 0.01547415f, -0.10012284f, -0.32390621f, 0.05240405f, -0.06796417f, 
    0.11659700f, 0.06461708f, -0.08022116f, -0.09879953f, 0.71978098f, -1.09944868f, -1.09370172f, -1.00795507f, 
    -0.48490936f, 0.06658933f, -0.14975935f, -0.03009884f, 0.32995909f, -0.01620726f, -0.05225103f, 0.04657675f, 
    -0.15722491f, -0.03004502f, -0.02852055f, -0.09581020f, -0.14077462f, 0.00451879f, 0.06935930f, 0.02109092f, 
    0.71611077f, -0.69782835f, 0.18649141f, -0.98928171f, 0.10062578f, -0.04766671f, 0.17957571f, -0.45790517f, 
    0.11859550f, -0.37899676f, 0.07884019f, -0.01913633f, 0.16818102f, -0.06872322f, 0.09276522f, -0.03772774f, 
    0.00126684f, -0.01305005f, 0.05377970f, -0.01824989f, 0.41203237f, 0.29648873f, -0.11311458f, -0.21868420f, 
    -0.02567109f, -0.05733011f, 0.10436372f, -0.02630232f, 0.17553422f, 0.00830687f, 0.03088827f, -0.07363407f, 
    0.12486392f, -0.00924131f, 0.04344429f, 0.00958446f, 0.07252219f, -0.06708508f, 0.05667587f, 0.07643829f, 
    -0.03313622f, 0.04781984f, -0.05494606f, 0.03869464f, 0.05936109f, 0.08706480f, 0.00967888f, 0.02456869f, 
    -0.12322374f, 0.09624183f, 0.10231432f, 0.07559311f, 0.13807042f, 0.01842686f, 0.05047832f, 0.05451161f, 
    0.15194723f, -0.01881339f, 0.03749670f, 0.06217382f, 0.28078243f, 0.12450142f, -0.27480826f, -0.17882973f, 
    -0.11259035f, 0.09162593f, 0.02182564f, -0.07643668f, 0.03124988f, -0.05456789f, 0.08577487f, -0.01797155f, 
    0.08343587f, 0.15087895f, 0.12274977f, -0.01883477f, -0.05218196f, -0.03978582f, 0.03904951f, 0.00786824f, 
    -0.04233884f, 0.33012909f, -0.43771648f, 0.04943913f, -0.61711192f, -0.01347271f, 0.07090904f, -0.11719263f, 
    -0.08499280f, -0.02406964f, -0.01865699f, 0.06462149f, 0.05931713f, -0.00931454f, -0.05214476f, -0.09204441f, 
    -0.21781905f, 0.30804983f, -0.14817593f, -0.03850705f, 0.24037445f, 0.09610666f, 0.04228816f, -0.02919503f, 
    -0.07445209f, 0.03097431f, -0.03310255f, 0.05365181f, -0.01108163f, -0.13819639f, -0.11016691f, -0.24769355f, 
    -0.08527257f, -0.43388450f, -0.15662308f, -0.01516744f, -0.03199220f, 0.01467843f, -0.08016045f, -0.03339720f, 
    0.00067967f, 0.11815340f, 0.08430469f, -0.01221352f, -0.03464834f, -0.00081780f, 0.02185845f, 0.04157783f, 
    -0.07676248f, -0.12504333f, -0.00531654f, -0.09078554f, -0.05700798f, -0.04863033f, -0.17430501f, -0.01307964f, 
    0.03013937f, -0.03763852f, 0.04297613f, 0.01094041f, -0.25215814f, 0.14580865f, 0.11086895f, 0.03366729f, 
    -0.15512720f, 0.03116233f, -0.10930533f, -0.04050118f, -0.04752667f, 0.00052885f, 0.13537090f, -0.00323710f, 
    0.01885993f, 0.04804704f, -0.07062142f, 0.15592265f, -0.17820527f, -0.21316272f, -0.04850517f, -0.02683286f, 
    -1.21185851f, -1.07203734f, -0.34682351f, 0.70447946f, 0.17775975f, 0.20768826f, -0.04489574f, 0.19096237f, 
    -0.04774320f, 0.26351273f, -0.04038390f, -0.02443402f, -0.10961882f, -0.12411839f, -0.16432242f, 0.05352836f, 
    0.12467200f, 0.01838764f, 0.07698535f, -0.17406452f, -0.30298984f, 0.39184603f, 0.03135196f, 0.38814411f, 
    0.13375816f, 0.11143521f, 0.04624236f, 0.28442702f, -0.18652815f, -0.00892653f, 0.01208496f, 0.04919656f, 
    0.09639920f, 0.09795403f, 0.02871477f, 0.15687884f, -0.04234345f, -0.15820776f, -0.11434890f, 0.03464320f, 
    0.01187311f, -0.05155861f, -0.13258339f, -0.24462709f, -0.35862321f, -0.18051250f, 0.09474961f, 0.03757673f, 
    0.05490135f, -0.09630892f, 0.08271630f, 0.03409596f, 0.10105981f, 0.04846608f, 0.08792105f, 0.08152934f, 
    0.16389216f, -0.08680417f, 0.08167282f, 0.13239121f, -0.13047379f, -0.33749512f, -0.16805382f, 0.12838054f, 
    -0.10185991f, -0.11999539f, -0.02613583f, -0.19737443f, -0.15495414f, 0.03054908f, 0.05694389f, 0.11662760f, 
    0.02880429f, 0.04467378f, 0.21409772f, -0.04157161f, 0.25810370f, 0.26713800f, 0.10669464f, 0.28144303f, 
    0.68113023f, 0.44759718f, 0.12169349f, 0.17402217f, -0.05025612f, 0.16027841f, 0.10491115f, -0.04822420f, 
    -0.11305642f, 0.12151293f, 0.18676329f, -0.04575362f, 0.07912686f, 0.24996552f, -0.03701348f, -0.14631777f, 
    -0.11365724f, 0.00763436f, 0.06327538f, -0.03658529f, 0.36603194f, -0.84337735f, -0.60097581f, -0.22075991f, 
    -0.27284405f, -0.00450080f, -0.24909042f, 0.05986072f, 0.07083444f, -0.15974292f, -0.06265991f, 0.06592941f, 
    -0.02929385f, 0.08487187f, 0.08724432f, 0.07770630f, 0.02871181f, 0.21629934f, 0.19397421f, 0.08282553f, 
    -0.16427989f, -0.18591288f, -0.20044909f, -0.03796837f, -0.03693689f, 0.06878962f, -0.07156011f, -0.03051150f, 
    0.03804863f, 0.05879630f, 0.09510639f, 0.16901502f, 0.24951267f, 0.10075919f, 0.12989222f, -0.04735375f, 
    0.23320074f, -0.17942169f, -0.02579917f, 0.16373678f, 0.18453802f, -0.13405658f, -0.93841749f, -0.55932695f, 
    0.18954706f, -0.01969662f, 0.12840891f, 0.27396509f, 0.00807780f, -0.15444328f, -0.05015422f, -0.11224174f, 
    -0.03545954f, 0.09606071f, 0.15119153f, 0.24380852f, -0.02734528f, 0.05226602f, -0.21228129f, -0.11599047f, 
    0.10286047f, -0.04997565f, -1.33277965f, -0.16723318f, -0.02877777f, 0.25649360f, -0.00790537f, 0.28731322f, 
    0.15491383f, 0.20392577f, 0.23555335f, 0.02330768f, -0.10733650f, -0.00209521f, -0.01832035f, 0.05624517f, 
    0.08797612f, 0.02377192f, -0.05018555f, 0.04803112f, -0.18394406f, -0.25911126f, -0.48179346f, 0.12839888f, 
    -0.08871452f, -0.27126005f, 0.02002316f, 0.19949667f, 0.18726407f, -0.02257424f, 0.16811091f, 0.00519644f, 
    0.14610565f, -0.13926688f, 0.07719261f, -0.09580100f, -0.03494120f, 0.00113709f, -0.08170419f, 0.03906836f, 
    -0.48037186f, 0.15498321f, 0.05338722f, 0.09237523f, 0.00076398f, 0.02539068f, -0.06401858f, -0.20603183f, 
    -0.05649300f, -0.16250291f, -0.09005369f, -0.03999537f, 0.14749330f, 0.13698296f, 0.00995678f, -0.16367075f, 
    0.02593890f, 0.16793300f, 0.18804047f, 0.08379726f, -0.03958056f, -0.49750915f, -0.44017944f, -0.03613678f, 
    0.17248183f, -0.08092237f, 0.13013822f, 0.10819295f, 0.16132267f, 0.06371969f, 0.07369735f, -0.06470291f, 
    -0.16682033f, -0.20469451f, -0.05691204f, -0.01203540f, 0.06475535f, -0.06793515f, 0.14248469f, -0.07504429f, 
    0.42200452f, 0.44392711f, 0.28523546f, 0.02919348f, -0.35947597f, 0.04608821f, 0.00964487f, -0.21412431f, 
    0.06686414f, -0.37979290f, -0.10152961f, 0.04604082f, 0.02804373f, -0.01952666f, 0.02136257f, 0.01176439f, 
    0.04866671f, -0.29856217f, -0.08589089f, -0.19090614f, 0.00006425f, -0.07395066f, 0.13695695f, -0.01369188f, 
    -0.16854909f, -0.13292414f, -0.00237565f, 0.12105013f, 0.03124049f, -0.11386922f, 0.10309584f, 0.25403243f, 
    0.08327892f, 0.07988940f, 0.15560426f, 0.01229828f, 0.00731588f, -0.11513550f, -0.00984295f, 0.18221350f, 
    -0.55636632f, 0.08663213f, 0.12618120f, -0.05835190f, -0.23349251f, -0.17154697f, -0.06544567f, -0.01339025f, 
    0.02689850f, 0.04368899f, -0.03617371f, -0.09101345f, 0.04723880f, 0.04364189f, 0.09461484f, -0.03808527f, 
    -0.13561444f, -0.03384788f, -0.06848695f, 0.06866933f, -0.82180631f, 0.06093400f, 0.15633892f, 0.36755255f, 
    -0.09368691f, 0.06240660f, 0.10105514f, -0.06027059f, -0.00500715f, -0.00610416f, -0.08790516f, -0.00185284f, 
    0.02287410f, 0.00663310f, 0.03072922f, -0.04948084f, -0.14171757f, -0.06869617f, -0.06460565f, -0.02001658f, 
    0.61554348f, -0.40913114f, -0.43322840f, -0.22061031f, -0.10648318f, -0.02935457f, -0.29041564f, 0.02236311f, 
    -0.12965919f, -0.44068307f, -0.02250055f, -0.00786578f, 0.03924390f, 0.02033964f, 0.00683143f, 0.12282051f, 
    0.04505916f, 0.15231346f, -0.13219464f, -0.16436526f, -0.50102162f, -0.37362602f, 0.63959247f, 0.35815644f, 
    0.38258293f, -0.12567602f, 0.02527174f, -0.13299145f, -0.12486084f, -0.07945387f, 0.01347235f, -0.10630578f, 
    0.01395308f, -0.12663184f, 0.02382463f, -0.27264768f, -0.14031841f, -0.32824653f, -0.44960520f, -0.34405607f, 
    -0.69282752f, 0.21454278f, 0.09573980f, 0.37867317f, 0.31924796f, 0.02652682f, -0.16169283f, -0.13287030f, 
    -0.16427632f, -0.19414282f, 0.09718572f, 0.13323900f, -0.06708970f, -0.07171265f, -0.13160101f, 0.08061013f, 
    -0.11421436f, -0.07342139f, -0.00753170f, -0.00857721f, 0.30732092f, 0.02047161f, 0.48894155f, -0.15937953f, 
    -0.17881374f, 0.01210717f, 0.02817602f, -0.11781289f, 0.19384356f, 0.07771104f, -0.06796519f, 0.00555759f, 
    0.08755779f, 0.02238921f, 0.06027701f, 0.04636745f, -0.08272915f, -0.08157124f, -0.25453645f, -0.00957763f, 
    -0.53383690f, -0.06815789f, -0.42270592f, -0.07709759f, 0.17362610f, 0.33441225f, -0.17985408f, 0.11480846f, 
    -0.07995971f, -0.30949554f, 0.03150436f, -0.08582754f, 0.03346334f, -0.06729304f, 0.08227091f, -0.05316012f, 
    0.09050164f, -0.19696957f, -0.04183752f, 0.03462590f, -0.16498740f, -0.35548353f, -0.17885458f, 0.20274599f, 
    -0.37487534f, -0.10637772f, -0.31010690f, 0.35164160f, 0.02712378f, 0.19977289f, -0.08041080f, 0.09684131f, 
    0.03376127f, -0.04201343f, -0.10396182f, 0.04558585f, -0.05736814f, 0.05576420f, 0.21760340f, -0.30857685f, 
    -0.07922069f, -0.14322482f, -0.08231809f, -0.36513117f, 0.15347393f, -0.00028129f, -0.03979237f, -0.21922430f, 
    -0.06523398f, -0.26605266f, -0.04804871f, -0.10624412f, 0.15114936f, -0.12436194f, -0.12923294f, 0.16505909f, 
    0.05236850f, -0.22346136f, -0.23850951f, 0.03703393f, 0.09866057f, 0.17428125f, 0.30770710f, 0.85708004f, 
    -1.04578733f, 0.12706454f, -0.10114588f, -0.17661352f, 0.12114699f, -0.01441291f, 0.03223553f, 0.01750859f, 
    0.09024382f, 0.03896666f, -0.06964291f, 0.12436966f, 0.20879373f, 0.11223796f, 0.08662387f, 0.13054112f, 
    -0.56182867f, -0.09990519f, -0.37511259f, 0.48374000f, -0.32111380f, -0.34698296f, 0.27774069f, -0.39456087f, 
    -0.00691168f, -0.07813680f, 0.00203122f, -0.27949256f, 0.04716406f, -0.02278623f, 0.09587844f, 0.01653833f, 
    0.06117586f, -0.04553460f, 0.02147627f, -0.10477840f, -0.16294573f, 0.14331834f, 0.22274335f, 0.43424615f, 
    -0.10665005f, -0.27158418f, 0.27987397f, -0.57480085f, -0.08170286f, 0.02194554f, 0.11075443f, -0.11516514f, 
    0.08244357f, 0.09624675f, 0.02933030f, 0.12332328f, 0.00490552f, -0.05154181f, -0.05599168f, -0.02148015f, 
    -0.27706462f, 0.23913051f, -0.19680879f, -0.14456075f, 0.00786725f, -0.13259788f, 0.18226853f, 0.38850600f, 
    0.19675623f, 0.01139729f, 0.11133297f, -0.09912895f, -0.06565778f, -0.27361676f, -0.07041078f, 0.11510862f, 
    0.26094177f, -0.38865876f, 0.02100420f, -0.18851857f, 0.15529643f, 0.13975245f, 0.37253278f, 0.51469445f, 
    -0.32624263f, 0.10853841f, -0.13516264f, -0.29760510f, -0.16328596f, -0.29830638f, 0.10472133f, 0.08568940f, 
    0.05045724f, 0.09149362f, 0.01583215f, 0.07721647f, -0.01946359f, -0.17700711f, 0.00625081f, -0.06084561f, 
    -0.57473332f, 0.18198729f, -1.13486218f, -0.04928902f, 0.04783872f, 0.11547564f, 0.04724760f, 0.25541475f, 
    -0.02911494f, 0.10504420f, 0.14815101f, -0.18523033f, 0.00285386f, -0.00709883f, -0.10891325f, 0.17760290f, 
    -0.07703109f, -0.03242063f, 0.04797971f, 0.04742899f, -0.29384565f, 0.18311417f, 0.02306693f, -0.23948652f, 
    0.32022771f, -0.12372985f, 0.07718673f, -0.08743232f, -0.28887516f, 0.01028793f, 0.04392667f, -0.00233859f, 
    -0.00402296f, 0.02497350f, 0.06636190f, 0.26386523f, 0.17479838f, -0.05420260f, -0.10547102f, 0.02687677f, 
    -0.10982803f, -0.10544083f, 0.19954169f, -0.08423430f, 0.22283189f, -0.01560736f, 0.06081580f, 0.11887826f, 
    0.07312930f, -0.14951257f, 0.07807863f, 0.07694718f, 0.12590972f, 0.14102516f, -0.11252613f, 0.20655823f, 
    0.02932220f, 0.06318022f, -0.11444256f, -0.01587137f, -0.08118636f, 0.54460937f, -0.72204936f, -0.30726007f, 
    -0.19531460f, 0.14199068f, -0.08414169f, 0.24262545f, -0.06468857f, 0.22549553f, 0.02670630f, -0.00746186f, 
    -0.17015715f, 0.05446098f, 0.03549648f, -0.11832422f, -0.04694553f, 0.13616452f, -0.01379838f, -0.00081335f, 
    -0.21132481f, -0.65999138f, -0.10231676f, -0.16910876f, -0.06343712f, 0.00876303f, -0.45803526f, -0.01115961f, 
    0.11892204f, 0.31178743f, -0.02495799f, 0.16665599f, 0.07087871f, 0.02184429f, -0.06209409f, 0.00948898f, 
    0.01019865f, 0.10940811f, 0.09498040f, 0.05467280f, 0.10046051f, -0.55550283f, -0.78827327f, -0.22776145f, 
    0.28900877f, 0.06182560f, -0.15885532f, 0.16584685f, 0.13943964f, 0.01267306f, -0.01441698f, -0.02964537f, 
    -0.10969961f, 0.05465052f, -0.02518551f, 0.20485708f, 0.30318329f, 0.24147366f, -0.06788212f, 0.39447439f, 
    0.67277890f, -0.92063522f, 0.40743020f, -0.50273460f, -0.41011462f, -0.12269062f, -0.08349267f, -0.10007964f, 
    0.07139324f, 0.04607767f, 0.09915245f, 0.03799340f, -0.19012712f, 0.11288104f, -0.03143679f, -0.20632705f, 
    -0.00122410f, 0.13664095f, 0.09530393f, -0.24764809f, -0.51500905f, 0.17495140f, -0.26969737f, 0.16866635f, 
    0.02402434f, 0.03562639f, 0.02785978f, -0.06802598f, 0.22889434f, 0.33747116f, -0.29277164f, -0.20343257f, 
    0.16910189f, -0.01253616f, 0.10293146f, -0.08690596f, 0.24980199f, -0.24941495f, 0.34152317f, 0.54133987f, 
    -0.82435668f, -0.29800075f, 0.26998973f, -0.10316911f, -0.07291971f, -0.14048889f, -0.11230187f, 0.02685736f, 
    0.62023228f, -0.04620072f, -0.21717565f, -0.17317511f, -0.03273505f, 0.04987171f, 0.10791203f, 0.13604204f, 
    -0.00214682f, 0.04273595f, 0.24044526f, -0.07045361f, -0.57648778f, 0.03813954f, -0.06791784f, -0.04739732f, 
    0.37801775f, 0.00434424f, -0.06987173f, 0.23166607f, -0.08850448f, -0.02351248f, -0.03537482f, 0.15835331f, 
    -0.01548720f, 0.14158554f, 0.02352759f, 0.21276811f, 0.03292809f, -0.13513383f, 0.15987660f, 0.10738111f, 
    -0.21053685f, 0.04586140f, -0.02856167f, 0.75303191f, 0.17001051f, 0.09252932f, -0.08445433f, 0.21539414f, 
    -0.24870880f, -0.02813332f, -0.25866216f, -0.07769930f, -0.01969741f, -0.07308941f, 0.01767562f, 0.07441153f, 
    -0.12898692f, -0.05081037f, 0.30533445f, 0.41704625f, -0.52114618f, 0.00901148f, -0.37064907f, 0.04924033f, 
    0.01398323f, -0.02025407f, -0.11808276f, -0.00798059f, 0.14076605f, 0.07781303f, -0.09452730f, 0.09333458f, 
    -0.07944045f, -0.15943372f, -0.26844573f, 0.02343225f, -0.14911172f, 0.07978882f, -0.02715188f, -0.11672626f, 
    0.24238151f, 0.35950133f, 0.17570488f, 0.21786599f, 0.43303475f, 0.24128073f, 0.04317813f, 0.12865604f, 
    -0.19087708f, 0.07604992f, -0.16963419f, 0.11508881f, 0.01404004f, -0.01360372f, -0.00013741f, 0.05579615f, 
    -0.00682865f, -0.24233413f, 0.01812497f, 0.11895282f, 0.53353584f, -0.04102973f, 0.39080533f, -0.08254845f, 
    0.10505867f, 0.28566384f, -0.13282701f, -0.09942409f, -0.10301390f, 0.01680774f, -0.11985823f, 0.24595083f, 
    -0.19220991f, -0.01949620f, -0.10747765f, -0.18846624f, 0.09454055f, -0.04490327f, -0.10478013f, -0.10249460f, 
    -0.33184227f, -0.34679186f, 0.22284047f, 0.02325765f, -0.11001382f, -0.08628753f, -0.14497051f, 0.09020649f, 
    0.15273537f, -0.18850081f, -0.25730750f, -0.06182125f, 0.20062187f, 0.06240961f, 0.20437025f, 0.06541525f, 
    0.06683966f, 0.15993914f, -0.01836541f, 0.16415337f, -0.24701284f, -0.04481466f, 0.14794952f, -0.14305763f, 
    0.01333676f, 0.13339569f, -0.10804873f, -0.35067323f, 0.13742694f, 0.06082975f, 0.02952228f, 0.04455339f, 
    -0.00197628f, -0.01819642f, -0.07216370f, -0.05568130f, -0.04531642f, -0.18840024f, 0.00282446f, 0.00552606f, 
    0.13586664f, -0.88067275f, 0.41351649f, 0.03033979f, 0.22705323f, -0.41744018f, -0.23869562f, 0.17384505f, 
    -0.06855644f, -0.08198908f, -0.04953681f, 0.13231182f, -0.08854216f, 0.02277454f, 0.04956929f, 0.07711749f, 
    -0.20493014f, -0.06537803f, -0.09383285f, -0.17995821f, 0.53161657f, -0.43303868f, 0.54063278f, 0.09480627f, 
    -0.37347144f, -0.09206028f, -0.00890790f, 0.22290617f, 0.11726464f, 0.05404259f, -0.03002018f, 0.13486899f, 
    0.05345380f, 0.00224710f, -0.08771535f, -0.06720297f, 0.02875117f, 0.24189061f, 0.00669216f, -0.07315775f, 
    -0.28134614f, -0.50704825f, -0.28458461f, 0.19411187f, -0.34796557f, 0.00699697f, -0.20558365f, -0.22242285f, 
    -0.08337424f, 0.03136640f, -0.02013515f, 0.04093672f, -0.11570746f, 0.02211745f, -0.03963273f, 0.04729842f, 
    -0.00272597f, 0.05653773f, 0.18369316f, 0.02778531f, -0.14202805f, -0.12517586f, -0.16015044f, 0.15639171f, 
    -0.29921389f, -0.07982209f, 0.04736863f, 0.17255996f, -0.02985232f, -0.08739129f, -0.16374162f, -0.07921879f, 
    0.12945676f, 0.01427411f, -0.09460967f, 0.12244868f, 0.00309072f, 0.05850784f, 0.12972826f, 0.03922816f, 
    -0.37826920f, 0.07028002f, -1.21120489f, 0.03112511f, -0.03434883f, 0.09894915f, -0.02926538f, -0.19018532f, 
    0.25512078f, -0.23680912f, -0.05756566f, 0.22085576f, 0.03107481f, 0.00704793f, 0.05105390f, 0.18045232f, 
    -0.06742591f, -0.20237982f, -0.15861414f, -0.24559586f, -0.15847793f, 0.01444739f, 0.04287316f, 0.05033356f, 
    -0.12407033f, -0.15363286f, 0.09170324f, 0.15834489f, -0.31889674f, -0.26042876f, 0.14976586f, 0.15115659f, 
    -0.23218122f, 0.13070953f, -0.08520544f, -0.11710495f, -0.22693428f, -0.34627926f, -0.75074351f, -0.32787412f, 
    -0.29710841f, -0.20687947f, -0.02277950f, -0.37976104f, 0.24031734f, 0.03373462f, 0.22972265f, 0.06968860f, 
    0.25642154f, 0.06254970f, 0.02860870f, 0.20367977f, 0.13149530f, 0.01356004f, 0.14936212f, -0.13888362f, 
    0.03546046f, -0.15469721f, -0.16941170f, -0.15475628f, -0.39682019f, 0.04891712f, -0.17727341f, 0.56262738f, 
    -0.15632124f, -0.32950720f, -0.04484953f, 0.18737634f, 0.12731659f, -0.01451647f, -0.11433568f, -0.05461315f, 
    -0.11575564f, 0.06277758f, 0.25878420f, -0.06504133f, -0.14238705f, 0.24212766f, -0.23989497f, -0.43472129f, 
    0.26055324f, -0.00870754f, 0.51003385f, 0.08696125f, -0.04396169f, 0.05415902f, 0.08851070f, 0.04033416f, 
    0.25595436f, -0.36339086f, -0.13292140f, -0.11071124f, 0.02039688f, -0.07066298f, -0.06141875f, 0.22959596f, 
    0.08503570f, 0.01076290f, 0.01146126f, -0.16547374f, 0.04540119f, -0.62351245f, -0.24185695f, -0.17333359f, 
    -0.00794691f, -0.11711834f, -0.55941337f, 0.11974005f, -0.19659273f, -0.11584037f, 0.14213651f, 0.00778786f, 
    -0.03089224f, -0.00411978f, -0.10910636f, -0.00722978f, -0.07996747f, 0.04162108f, -0.07327936f, -0.00073599f, 
    -0.40411228f, -0.08778568f, -0.01890511f, 0.46530229f, -0.47506171f, 0.17769524f, -0.13330832f, 0.38704360f, 
    0.09373621f, -0.02348445f, -0.07916898f, 0.07091819f, -0.27215257f, 0.05412452f, -0.01565623f, 0.13667542f, 
    0.11991050f, 0.16244794f, 0.18034339f, -0.08859257f, 0.13723418f, -0.29900122f, 0.13986008f, -0.30736914f, 
    -0.55380625f, -0.01111779f, 0.19881941f, 0.07449221f, 0.00036752f, -0.04027233f, -0.10825650f, -0.01752863f, 
    0.28827327f, 0.23188950f, -0.00732583f, 0.10370613f, 0.20532992f, -0.04954904f, 0.01629789f, 0.09458066f, 
    -0.71751803f, -0.58836955f, -0.42806751f, 0.67078805f, 0.00369839f, 0.22438599f, -0.25123668f, 0.12832320f, 
    -0.43780878f, 0.19350034f, 0.00389330f, -0.21578309f, -0.00140688f, 0.05611246f, -0.15956892f, 0.02256272f, 
    -0.19725309f, 0.05187973f, 0.14972331f, -0.07743449f, -1.01707315f, 0.14738125f, -0.50724024f, 0.24889047f, 
    -0.26282233f, -0.00454600f, 0.03932114f, 0.07936686f, -0.26095918f, 0.36506578f, -0.06902122f, -0.06746096f, 
    -0.02679704f, 0.01855436f, 0.01377060f, 0.02060883f, -0.05144556f, 0.02609093f, 0.19084334f, 0.11283788f, 
    0.68299001f, -0.08012792f, 0.48418292f, 0.55771548f, -0.09058763f, -0.07161900f, 0.37460783f, -0.19889848f, 
    0.28170505f, -0.18171205f, -0.18308407f, -0.04720991f, -0.03775318f, 0.10669158f, 0.04264266f, -0.17651987f, 
    -0.12275717f, 0.05964547f, -0.13410844f, 0.11176597f, -0.31807336f, -0.06258449f, -0.21966945f, 0.15299414f, 
    -0.53833675f, -0.05908360f, -0.04464206f, 0.00605735f, 0.02286931f, 0.03856727f, 0.01342401f, 0.02589818f, 
    -0.01777849f, -0.11762750f, -0.04014307f, -0.02738039f, -0.19696109f, -0.01082077f, -0.17926537f, -0.03713658f, 
    0.51683778f, -0.04858202f, 0.37388250f, -0.07135279f, 0.10140274f, 0.03153640f, -0.03473736f, -0.03050372f, 
    0.10280386f, 0.12938224f, -0.10278595f, 0.13445809f, -0.06503948f, -0.03655917f, -0.17327352f, -0.08455138f, 
    0.12300383f, 0.03182024f, -0.09054808f, 0.20877613f, -0.39543444f, -0.03151068f, -0.38486135f, -0.03103579f, 
    0.35372332f, -0.04093528f, 0.22904813f, -0.12182253f, 0.15239353f, 0.20298824f, 0.00681056f, 0.10586960f, 
    0.09715035f, 0.08988694f, 0.15107825f, 0.02332304f, -0.12761602f, -0.08295544f, -0.05815621f, -0.12242619f, 
    -0.14817795f, -0.05191310f, -0.33569324f, 0.01298153f, -0.19944265f, -0.04707637f, 0.18089436f, 0.10561932f, 
    0.02196502f, 0.04000496f, -0.22669291f, 0.00370050f, 0.00318312f, -0.03654348f, -0.13800825f, -0.00971606f, 
    0.02501072f, -0.04171111f, -0.27868849f, -0.31260914f, 0.72838271f, -0.03988738f, 0.70432693f, 0.11145783f, 
    -0.17463331f, -0.04969094f, 0.16570647f, -0.28269815f, 0.20696981f, 0.02351086f, -0.14758080f, 0.10756256f, 
    0.03904636f, -0.09100121f, -0.03156457f, 0.05604284f, 0.35355198f, 0.00865483f, 0.04479137f, -0.00995425f, 
    0.25390711f, -0.46086636f, -0.11866217f, -0.37276238f, 0.17802732f, -0.35139453f, -0.37505016f, -0.01237943f, 
    0.18117914f, -0.37002108f, -0.06303483f, -0.02147351f, 0.21921833f, -0.07796789f, -0.02303425f, 0.09933922f, 
    -0.03920297f, 0.06103728f, 0.28143615f, -0.08201016f, 0.11297221f, -0.54879063f, -0.21403530f, 0.42026228f, 
    0.23293598f, 0.01471744f, 0.14984463f, -0.14431284f, -0.02323268f, -0.17979032f, -0.14553724f, 0.10796948f, 
    -0.03624444f, -0.03781077f, 0.00713713f, 0.13935485f, -0.22654107f, 0.07925984f, 0.13884479f, 0.01134209f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30312702f, 0.16102156f, 0.07529262f, -0.10854812f, -0.11198107f, 0.01006818f, 0.05520198f, -0.16486965f, 
    0.04204724f, -0.00280230f, 0.04565546f, -0.04654578f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
