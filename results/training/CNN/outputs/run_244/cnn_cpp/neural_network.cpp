#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01590003f, 0.56673944f, 0.44526222f, -0.04874611f, -0.56067365f, -0.50963259f, -0.71243912f, -0.19480054f, 
    0.18262450f, -0.05309518f, -0.04201932f, -0.31107324f, -0.23707183f, -0.27739021f, -0.03897285f, -0.30090353f, 
    0.08580633f, -0.28460428f, -0.03031071f, 0.23579855f, 0.05086014f, 0.24747603f, -0.09660117f, -0.03794345f, 
    -0.20471624f, -0.96037585f, 0.20164432f, -0.16247031f, -0.08916965f, 0.27742606f, 0.30740628f, 0.67106628f, 
    0.14380769f, 0.05651889f, 0.15067379f, 0.37294367f, -0.20309624f, -0.17394689f, -0.25594947f, 0.28900400f, 
    -0.04242460f, -0.27602044f, -0.19034828f, -0.02676052f, 0.02184345f, -0.03928995f, 0.20896247f, 0.20209014f, 
    0.16603930f, -0.06819411f, -0.27111918f, -0.66504568f, -0.60241354f, -0.13514979f, -0.35968891f, -0.39093021f, 
    -0.00521668f, -0.03325535f, -0.11782713f, 0.08329952f, 0.60918033f, 0.17605111f, -0.14282779f, 0.19557543f, 
    0.37823948f, 0.16686606f, 0.22257592f, 0.26521140f, -0.15768155f, 0.33625573f, -0.00744912f, -0.09253310f, 
    0.15197705f, 0.06800053f, -0.25930542f, 0.13700469f, -0.91154158f, -0.49043199f, -0.18315418f, -0.01357364f, 
    0.59711045f, 0.85198849f, 0.00527875f, 0.26513067f, 0.30232644f, -0.03282862f, -0.12803935f, -0.16551903f, 
    0.17949761f, -0.12998267f, -0.04351661f, 0.11154217f, 0.18043144f, -0.00785093f, -0.20587698f, 0.14177564f, 
    -0.05712571f, -0.18627663f, -0.17662206f, -0.01791733f, -1.05528808f, 0.26878679f, 0.32141405f, 0.06478061f, 
    -0.48264000f, 0.53313822f, 0.74201161f, 0.17819801f, 0.27044386f, 0.18153258f, -0.23501912f, -0.15033701f, 
    0.09465768f, -0.06778486f, -0.07971754f, -0.04157681f, 0.06682326f, -0.09309749f, -0.14286983f, -0.18388470f, 
    -0.00273343f, -0.21318898f, -0.04257275f, -0.11445805f, 0.03220246f, 0.75457966f, 0.73326856f, 0.54641432f, 
    0.24580398f, 0.62449741f, 0.01621215f, 0.07502247f, -0.32046673f, 0.27057344f, 0.00324905f, 0.17524636f, 
    0.07666208f, 0.03504653f, -0.22632648f, -0.24313569f, -0.18923356f, -0.04680192f, 0.09142779f, -0.38275900f, 
    -0.12583739f, -0.12251424f, -0.01536845f, 0.18399358f, 0.03401110f, -0.10366750f, 0.55007827f, 0.61649424f, 
    -0.65735281f, -0.82067347f, -0.51560563f, 0.62697476f, 0.16882291f, -0.04819559f, 0.03638903f, 0.14199923f, 
    0.14558253f, 0.04903220f, -0.10574360f, 0.14971259f, 0.01258732f, 0.18603088f, 0.00301387f, -0.12057731f, 
    0.02558683f, 0.20449477f, 0.12930571f, -0.06122736f, -0.08815747f, -0.02910682f, 0.20056783f, 0.37026608f, 
    0.14403257f, 0.55153269f, 0.71688873f, 0.72366327f, -0.74008536f, -0.35389566f, -0.42266715f, -0.38729486f, 
    0.03857463f, 0.11386326f, 0.08599196f, -0.15053399f, 0.28056338f, 0.25334680f, 0.10349179f, -0.13286400f, 
    0.10850790f, 0.18318456f, 0.12568980f, 0.07116137f, 0.01163555f, 0.04326063f, -0.07588606f, -0.00851650f, 
    -0.48389161f, -0.27691299f, -0.59723204f, -0.62742305f, -0.11183035f, 0.31850147f, 0.08661132f, 0.14683960f, 
    -0.06568768f, 0.28085336f, 0.07767263f, -0.33069929f, 0.14774367f, -0.14701073f, 0.11648844f, -0.15766762f, 
    0.02803705f, -0.00267635f, 0.01448005f, -0.11885466f, 0.14262873f, -0.17831101f, 0.36438441f, 0.25251743f, 
    0.04413905f, 0.28267956f, 0.81154960f, 0.18650843f, -0.23748115f, -0.56496060f, -0.06220391f, -0.42529875f, 
    -0.41990417f, -0.60812652f, -0.34177342f, -0.02970169f, 0.19462399f, 0.14894262f, 0.42134640f, 0.01054291f, 
    0.13104540f, -0.12583813f, -0.08474015f, 0.03190378f, 0.08842673f, -0.08745543f, 0.16123284f, 0.21640156f, 
    -0.10221169f, -0.00907240f, -0.10179208f, -0.31693131f, 0.09602749f, -0.17022923f, -0.44936502f, -0.58132672f, 
    0.18425083f, -0.49587947f, -0.61348420f, -0.04652882f, -0.16157071f, 0.29987204f, -0.51552773f, -0.17721738f, 
    -0.36670458f, -0.24740101f, -0.32733747f, -0.05630801f, -0.07915325f, -0.10492866f, 0.01201057f, 0.05329105f, 
    0.09743542f, -0.06882553f, -0.11583169f, 0.87107450f, -0.43041658f, 0.38545462f, 0.41006523f, 0.59965575f, 
    0.39425278f, 0.30120587f, 0.37056997f, -0.17829442f, -0.24149816f, -0.07775842f, -0.15249795f, -0.25654966f, 
    0.20555259f, -0.04584965f, 0.10879226f, 0.31743136f, 0.17087452f, 0.36209944f, 0.04599044f, 0.07073298f, 
    0.01313290f, 0.22533417f, 0.09987151f, 0.10039466f, -0.65605772f, -0.32136756f, 0.40766975f, -0.59946048f, 
    -0.10888117f, 0.49625137f, -0.48512286f, -0.30892465f, -0.48582268f, -0.50193304f, -0.12533341f, 0.16635253f, 
    0.20665921f, 0.04496708f, 0.08732831f, -0.09376137f, 0.03667773f, -0.12769976f, -0.23643401f, 0.08755329f, 
    -0.14426495f, 0.20517507f, 0.02366032f, 0.22523327f, 0.03444536f, -0.22792096f, 0.76694578f, 0.60912710f, 
    0.24208909f, -0.08400481f, -0.50161904f, 0.83221751f, 0.00286567f, -0.15970278f, 0.37667421f, -0.28044909f, 
    0.34358045f, 0.17033295f, -0.11657306f, 0.11984858f, 0.05610525f, -0.18952185f, 0.11553975f, -0.13525388f, 
    -0.16742235f, 0.08451751f, 0.15805034f, -0.04648003f, 0.14377140f, -0.07652328f, 0.90245438f, 0.60983860f, 
    -0.39012676f, 0.59646869f, -0.32275054f, 0.22759077f, 0.31870422f, -0.48763233f, 0.15149371f, 0.02191983f, 
    0.32115653f, -0.09920254f, -0.07557610f, -0.00000387f, -0.13816568f, 0.11167057f, -0.14919306f, 0.09957799f, 
    -0.01819029f, -0.01458713f, -0.01286384f, -0.06210312f, 0.06639172f, -0.09874899f, 0.27492625f, -0.32360145f, 
    0.55188447f, -0.26439089f, 0.70438361f, 0.19162458f, 0.36268216f, 0.17459795f, 0.24259406f, 0.25629476f, 
    0.27619550f, -0.54203081f, -0.45965636f, -0.44827765f, -0.25644484f, -0.03657944f, -0.06934936f, 0.00070744f, 
    -0.19707055f, -0.06049452f, -0.06988161f, -0.14531723f, -0.10631956f, -0.22201355f, -0.18296961f, -0.34282291f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01249979f, -0.08606502f, 0.13429490f, -0.11578405f, -0.12509753f, 0.01461736f, 0.07789031f, -0.08745269f, 
    0.02413016f, 0.02011740f, 0.07142486f, -0.01059898f, 0.26915416f, 0.09975900f, 0.14626820f, -0.02706024f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16487408f, 0.08203416f, 0.15971251f, -0.05208234f, -0.07325592f, 0.00916223f, 0.13228637f, 0.08169502f, 
    -0.01379297f, -0.10555416f, 0.05157448f, 0.09054542f, -0.19355473f, 0.05980651f, -0.20746626f, 0.00625237f, 
    -0.10235376f, -0.03781514f, 0.04980286f, 0.01079953f, 0.06694105f, 0.08480861f, 0.02619154f, -0.07102912f, 
    -0.05480832f, -0.05577905f, -0.11883692f, 0.01139374f, 0.21676229f, 0.06977030f, 0.03540559f, -0.02175161f, 
    0.02983029f, 0.00501267f, -0.01359409f, 0.06806059f, 0.10084967f, -0.12590075f, -0.14451754f, 0.05047683f, 
    0.13573027f, -0.05140371f, -0.11092121f, 0.08104326f, 0.09416939f, 0.00074427f, -0.06970166f, -0.17982745f, 
    -0.56839693f, -0.06237819f, -0.02305440f, -0.09167696f, 0.05902743f, 0.05498326f, -0.03347830f, -0.11819965f, 
    0.08403990f, -0.01999064f, 0.00103512f, 0.03558487f, 0.19305521f, -0.10975307f, 0.15078706f, -0.02141197f, 
    -0.03754083f, -0.03137335f, -0.09885814f, -0.04533239f, 0.02660207f, -0.14135624f, 0.08646654f, 0.09075703f, 
    0.06278115f, -0.16546437f, 0.27981821f, -0.03584929f, -0.03657661f, 0.02929970f, -0.14439428f, 0.08571084f, 
    -0.00101641f, 0.05372385f, 0.04736941f, 0.01078035f, -0.27216542f, -0.04141553f, 0.15406801f, -0.12110054f, 
    0.03703893f, 0.05388085f, -0.00370506f, 0.06692185f, 0.20129204f, 0.05470604f, -0.06390077f, 0.08851840f, 
    -0.03984931f, -0.11878140f, 0.01276364f, -0.14522631f, -0.05138546f, -0.04633081f, 0.17663550f, 0.13231467f, 
    0.02322666f, -0.04018586f, 0.07756089f, 0.01058664f, 0.23029706f, -0.21037863f, 0.15024628f, 0.04128799f, 
    0.02911908f, 0.10666623f, 0.02858872f, -0.03703133f, 0.09167242f, -0.04206145f, 0.15030356f, 0.15624560f, 
    -0.11878064f, 0.09745150f, -0.10131700f, -0.10663054f, 0.02841949f, 0.01428823f, 0.10053567f, 0.07396875f, 
    0.09212840f, -0.06835049f, 0.00428950f, -0.12754305f, 0.37047279f, 0.20784017f, 0.01161902f, 0.04883289f, 
    0.04515946f, -0.06436302f, -0.03414711f, 0.06466728f, 0.05116447f, -0.10246624f, -0.06524652f, 0.05578845f, 
    0.00530396f, -0.05261774f, -0.09552296f, 0.09807486f, -0.05897586f, -0.03112930f, 0.02231449f, 0.09452792f, 
    0.04845087f, 0.05091446f, 0.09385780f, 0.09159276f, -0.05972055f, 0.04236406f, 0.09742068f, -0.02986529f, 
    -0.02082380f, 0.04854761f, -0.02055322f, 0.05055527f, -0.00643767f, -0.07935932f, 0.10812823f, 0.13253969f, 
    0.15518697f, 0.03163035f, 0.08208463f, -0.17220645f, 0.01975369f, -0.01173978f, -0.00646618f, -0.07982757f, 
    -0.01814366f, -0.04868181f, 0.07494354f, -0.02768245f, 0.06005699f, -0.06499337f, -0.11352304f, 0.08163119f, 
    0.16664411f, 0.04444813f, 0.03839339f, 0.06490720f, 0.10614251f, 0.11564652f, 0.05222628f, 0.02326537f, 
    -0.01538492f, -0.17380677f, -0.10355563f, -0.00813355f, -0.00925421f, 0.03063925f, -0.07257935f, -0.05223832f, 
    -0.01309084f, -0.00638893f, 0.07620638f, -0.00397128f, -0.14230031f, 0.17298959f, 0.04465451f, -0.05398263f, 
    0.00936151f, 0.07568024f, 0.05967319f, -0.12621394f, 0.07529026f, -0.05459352f, -0.00259379f, -0.04788385f, 
    0.00191267f, 0.02896364f, 0.05778532f, 0.11973172f, 0.12034974f, 0.06332211f, 0.01115842f, 0.13221222f, 
    0.02274993f, 0.13900560f, -0.11101335f, 0.06136900f, 0.00656365f, 0.35331991f, 0.23620933f, 0.01460190f, 
    0.05411421f, 0.01755477f, -0.18586205f, 0.01748716f, 0.08247238f, 0.07144174f, -0.03844744f, -0.05470021f, 
    -0.30802840f, 0.06254098f, 0.03918869f, 0.01827019f, 0.10886477f, -0.10751473f, -0.02983812f, -0.02877718f, 
    0.10106567f, -0.06959786f, -0.03670600f, 0.03789478f, 0.45790100f, 0.00389972f, 0.06214382f, 0.41892195f, 
    -0.09241080f, -0.10337010f, 0.03018484f, 0.00343957f, 0.04094290f, -0.04562572f, -0.11481801f, 0.06627549f, 
    0.20485942f, 0.02592551f, 0.05100786f, -0.13934906f, 0.06777817f, -0.05063140f, -0.21430992f, -0.02342677f, 
    -0.09640035f, 0.01722043f, 0.01106675f, 0.08305232f, 0.07551442f, -0.16325255f, -0.10010573f, 0.22645803f, 
    -0.04354586f, 0.00776015f, -0.01990933f, 0.01986290f, 0.03620053f, 0.05594985f, 0.01121470f, 0.08856773f, 
    0.09205046f, 0.00940289f, 0.05753900f, 0.12747976f, -0.00192867f, -0.11909967f, -0.03392005f, 0.12458859f, 
    0.13765496f, -0.13662755f, 0.01949256f, -0.02620340f, -0.06701162f, 0.12891023f, -0.14081463f, -0.19016920f, 
    -0.19314462f, -0.15932879f, 0.03804915f, -0.07963717f, -0.04213328f, 0.06958351f, 0.17346980f, 0.04728123f, 
    -0.09008957f, -0.28140467f, -0.11483136f, -0.07672109f, 0.06348116f, -0.03466722f, 0.04172624f, -0.01754183f, 
    0.04196316f, -0.03602801f, -0.00360315f, -0.07836735f, 0.01196388f, 0.33809373f, 0.09831537f, 0.15488270f, 
    0.02671858f, -0.01113655f, 0.01668399f, -0.02449495f, 0.10210942f, -0.01825393f, 0.05257321f, -0.07624006f, 
    -0.19564009f, -0.10925794f, 0.00634489f, -0.08003710f, -0.06464861f, 0.01354943f, 0.07541873f, -0.09245329f, 
    -0.07872359f, 0.08385738f, -0.00262691f, -0.07409549f, 0.19151139f, 0.07475098f, 0.03073682f, -0.01434046f, 
    -0.04024611f, 0.02781506f, -0.02124171f, 0.04554161f, 0.07763683f, -0.05681320f, 0.07553217f, -0.00173988f, 
    0.44212708f, 0.07536250f, 0.21870534f, -0.13712806f, -0.02615877f, 0.01213735f, -0.07221438f, -0.02205437f, 
    -0.11497910f, -0.07121616f, -0.07165840f, 0.04289498f, 0.03864958f, 0.09184520f, 0.14205854f, -0.03625396f, 
    0.10288570f, 0.08050171f, -0.06056609f, 0.00571877f, 0.08502403f, 0.03340336f, -0.05981000f, -0.11739498f, 
    -0.15093835f, -0.08114689f, 0.11137304f, -0.05048792f, -0.14236003f, 0.01082558f, 0.05639903f, -0.07594444f, 
    0.07076580f, -0.02033229f, 0.05770444f, -0.10751284f, 0.21485612f, 0.06380605f, -0.11554983f, 0.02452128f, 
    -0.00931867f, -0.08104523f, -0.14833680f, 0.00052767f, 0.04136438f, -0.10164193f, 0.20656545f, 0.05186110f, 
    -0.02373732f, -0.10480665f, 0.09643044f, -0.10466764f, -0.14540680f, 0.04510092f, 0.04395766f, 0.02281660f, 
    0.09252766f, -0.17840226f, 0.05914415f, -0.12854621f, -0.21648858f, 0.05493180f, 0.13784938f, 0.18611243f, 
    0.03823051f, -0.07757758f, 0.07853712f, 0.07767466f, -0.16733444f, -0.05860769f, 0.02347307f, 0.08712534f, 
    0.47388735f, -0.06545674f, -0.05709409f, -0.12767012f, 0.05536405f, -0.11496481f, 0.01790548f, 0.22829115f, 
    0.05077854f, 0.16301107f, -0.02158168f, 0.16279908f, -0.13650258f, 0.01045587f, 0.02942763f, -0.13805713f, 
    -0.03653853f, 0.06158530f, -0.04635900f, 0.07098453f, -0.02022059f, 0.15886700f, 0.08750133f, 0.11149019f, 
    -0.25663954f, 0.02471381f, 0.21636191f, 0.39863709f, 0.09868571f, -0.00296217f, 0.07486804f, 0.10278811f, 
    0.01840372f, -0.01998252f, 0.04585566f, -0.01596639f, -0.28711852f, 0.05833415f, 0.20688120f, 0.09773555f, 
    0.06673440f, 0.00928122f, 0.00839939f, -0.21218526f, 0.05853353f, -0.04982699f, -0.02583501f, -0.24794769f, 
    -0.06112408f, -0.03132218f, -0.06906964f, 0.15346815f, -0.04315783f, -0.06321505f, 0.01535494f, 0.15647329f, 
    -0.07006115f, -0.01512213f, -0.03293391f, 0.04265011f, -0.08998349f, -0.07703459f, 0.01952552f, -0.15558235f, 
    0.04965945f, 0.00274123f, -0.03405670f, 0.09504981f, -0.05723107f, -0.03205456f, -0.09021541f, -0.04934567f, 
    -0.10239474f, 0.12196445f, 0.26843715f, -0.13812687f, -0.05081826f, 0.04035564f, 0.03017895f, 0.03016921f, 
    0.07045555f, 0.09241986f, 0.21584448f, 0.18215889f, 0.04047614f, 0.07635730f, -0.14174421f, -0.17835960f, 
    0.20163134f, -0.01679163f, -0.06137063f, -0.00000440f, -0.05617700f, -0.07545068f, -0.02084517f, -0.03741836f, 
    0.36691776f, -0.00231484f, -0.07037978f, -0.27808315f, 0.21206143f, -0.05637890f, -0.16697423f, 0.02712554f, 
    -0.05710066f, -0.02475572f, -0.06439639f, 0.00363141f, 0.07219768f, -0.00306540f, 0.16603048f, -0.03729261f, 
    -0.03499176f, 0.04041576f, 0.00486192f, -0.00045499f, 0.02595401f, 0.03737879f, -0.08780720f, 0.05430682f, 
    -0.03530897f, 0.26997241f, 0.01721978f, -0.04859284f, -0.01946176f, 0.04548751f, 0.13930367f, -0.01693710f, 
    0.01676937f, 0.06229587f, -0.00664085f, -0.03339410f, 0.04647744f, -0.11544307f, -0.21694121f, 0.19662791f, 
    0.00844765f, 0.04775125f, 0.08088739f, 0.04680671f, 0.03948952f, -0.00621840f, 0.14237583f, 0.24547409f, 
    -0.13338837f, 0.04142849f, -0.03026724f, 0.13644435f, -0.07546566f, -0.08048560f, -0.01094924f, 0.11745296f, 
    0.00065160f, 0.01507649f, -0.02980919f, 0.06507222f, 0.10235739f, -0.31377831f, 0.08744416f, -0.07262855f, 
    0.05481921f, 0.07260969f, 0.18058562f, 0.07486940f, 0.18257985f, -0.04025161f, -0.06323493f, -0.00402047f, 
    -0.38285035f, -0.12853912f, -0.18608867f, 0.08445061f, 0.10999967f, 0.13407421f, 0.01931913f, 0.04968307f, 
    0.00969327f, 0.06330886f, -0.02929423f, 0.00746964f, -0.02734675f, -0.13115251f, -0.21550462f, -0.14152293f, 
    0.15510753f, 0.18566751f, -0.03730282f, -0.00543843f, 0.13904506f, 0.02183884f, 0.05438372f, -0.00270306f, 
    0.19267090f, -0.23405163f, 0.14321028f, 0.03410126f, -0.07113838f, 0.03199000f, 0.02927952f, -0.01764047f, 
    0.12603369f, -0.06076539f, 0.04703012f, 0.10526802f, 0.03807197f, 0.19291942f, 0.20223266f, 0.09503340f, 
    0.04498911f, -0.10517084f, 0.03776379f, 0.01361461f, 0.00791555f, -0.03419837f, 0.10520659f, 0.00544713f, 
    0.15992074f, 0.10548600f, -0.07962478f, -0.16122939f, -0.04401907f, 0.10589343f, 0.02794219f, -0.02020451f, 
    -0.03836392f, 0.00206042f, -0.00333764f, 0.10575580f, 0.33896163f, 0.19307844f, -0.01125934f, -0.14319575f, 
    -0.11649466f, -0.01871805f, -0.05527705f, 0.02393033f, -0.05888710f, 0.05964049f, 0.13566647f, 0.09670632f, 
    -0.20814101f, -0.08507045f, -0.05949278f, -0.23881592f, 0.09558673f, 0.09695456f, 0.02301868f, 0.09604074f, 
    0.09497596f, -0.01054673f, -0.01736925f, -0.03734501f, -0.14192495f, 0.34447926f, -0.10165442f, 0.04106424f, 
    -0.02916154f, 0.08458535f, 0.04384925f, 0.04149641f, -0.09983692f, 0.04628143f, -0.09196018f, 0.03716251f, 
    -0.15527160f, -0.02838838f, -0.22797586f, 0.03443351f, -0.06303995f, 0.01109638f, -0.02956087f, 0.02566819f, 
    0.03805787f, 0.09396187f, -0.05866451f, 0.05467655f, 0.21178418f, 0.16108875f, 0.19235837f, 0.16846399f, 
    -0.01303556f, -0.03011369f, 0.09409890f, 0.06868066f, -0.00076777f, 0.07534412f, 0.06556641f, 0.15422454f, 
    -0.32266691f, -0.25581747f, -0.00846783f, 0.01103676f, 0.05575112f, -0.03353579f, -0.06963619f, -0.06576673f, 
    0.01952537f, 0.06380328f, 0.03690927f, -0.00789172f, 0.22005278f, -0.02712796f, 0.01945038f, 0.08645056f, 
    -0.05834294f, 0.05528897f, 0.05241114f, -0.09858318f, 0.04063945f, 0.11108734f, 0.16559713f, 0.01263180f, 
    0.03173442f, 0.10508527f, 0.01716855f, 0.26548642f, -0.10727202f, -0.03356555f, 0.00243032f, -0.02345705f, 
    -0.08506045f, -0.10594510f, 0.04445650f, 0.01462065f, 0.14660241f, 0.21818951f, 0.18280254f, -0.00227394f, 
    -0.02297123f, -0.01513549f, -0.05647258f, -0.11632011f, -0.06751011f, 0.07205451f, -0.02570375f, -0.09213430f, 
    0.13884306f, 0.16094004f, 0.22774749f, 0.04801365f, -0.13486858f, 0.11632676f, -0.10016703f, -0.11320356f, 
    0.03933410f, -0.02252530f, 0.18805994f, 0.05395040f, 0.17097872f, -0.06401107f, 0.05501813f, -0.08112654f, 
    0.09495546f, 0.04991665f, -0.12505054f, 0.03604069f, -0.08542263f, -0.03391045f, 0.23743613f, 0.04951457f, 
    0.06400558f, -0.01078047f, 0.13751368f, 0.03978182f, -0.11477906f, 0.08064288f, 0.15130024f, -0.05371266f, 
    -0.04080163f, -0.14891969f, -0.05884581f, -0.13707994f, -0.09114338f, -0.07052545f, 0.18185273f, 0.02967088f, 
    0.12872955f, 0.01567481f, 0.23045991f, -0.02623770f, -0.11188883f, 0.07240035f, -0.00129598f, 0.06044900f, 
    0.23112412f, 0.03064142f, 0.08102499f, -0.07137434f, 0.04760816f, 0.00323791f, 0.06910080f, 0.11299895f, 
    0.07900825f, 0.15349275f, -0.01514283f, 0.07989399f, 0.11912041f, -0.01570551f, -0.11508097f, -0.13166386f, 
    -0.05700776f, 0.06345642f, -0.00751476f, 0.05155723f, 0.06706537f, 0.04345091f, -0.01821955f, -0.00213014f, 
    -0.01281111f, -0.38005400f, 0.31582490f, 0.05030179f, 0.09229492f, 0.02173387f, 0.13418548f, 0.10100481f, 
    0.03224916f, -0.01915265f, -0.05909745f, 0.02186419f, -0.09548122f, 0.11112674f, -0.04322901f, -0.03181536f, 
    -0.04934241f, -0.00865968f, 0.01861520f, 0.03251718f, 0.17084900f, -0.01595828f, -0.10941505f, -0.01018719f, 
    -0.06086866f, -0.28088149f, -0.02743524f, 0.15352632f, 0.02402716f, -0.04799215f, -0.00552627f, 0.03836830f, 
    0.00195966f, 0.14594530f, 0.07150179f, 0.09952439f, -0.00471074f, 0.03105652f, 0.17770088f, -0.19558626f, 
    0.02976684f, 0.19883625f, 0.01155410f, -0.04517983f, -0.01100247f, -0.06659553f, -0.01676390f, -0.00225440f, 
    -0.08886324f, -0.13096435f, 0.20152850f, -0.07423442f, -0.08768986f, -0.04290145f, -0.00397478f, -0.14704855f, 
    0.08369175f, 0.12322006f, 0.11669295f, 0.05941888f, 0.00348889f, 0.04039210f, -0.35982442f, -0.14327133f, 
    0.08928185f, 0.02816497f, 0.03406776f, 0.09533890f, -0.11786766f, 0.00428002f, -0.08342288f, -0.13831028f, 
    -0.16917987f, -0.02431329f, -0.10485338f, -0.17393599f, -0.02278644f, 0.05611530f, 0.07270212f, -0.02459731f, 
    0.04838162f, -0.09722180f, 0.00590261f, 0.17500447f, 0.04174579f, -0.09869903f, 0.00594528f, -0.02584884f, 
    -0.01259075f, -0.02332050f, -0.09207284f, 0.03259004f, -0.06131590f, -0.00204614f, -0.08065750f, -0.02797018f, 
    -0.14209762f, 0.02230943f, 0.19396202f, -0.17409378f, -0.02299501f, 0.00230799f, 0.06563916f, 0.10446455f, 
    -0.02115092f, 0.19563803f, -0.11143622f, -0.02628654f, -0.06917103f, -0.30828956f, 0.01695887f, 0.01468265f, 
    -0.02754924f, 0.09482532f, 0.11691878f, 0.12198916f, 0.10813939f, 0.01383002f, 0.03765593f, 0.23871297f, 
    -0.04552657f, 0.05499897f, -0.01608827f, 0.01149583f, -0.07194902f, 0.04891427f, -0.05712441f, 0.06223183f, 
    -0.03802664f, 0.04664016f, -0.02008733f, -0.03770295f, 0.06341335f, -0.05971349f, -0.06153816f, -0.03971822f, 
    -0.07181191f, 0.00545251f, -0.06531242f, -0.04054877f, -0.04796619f, -0.00562236f, -0.01967964f, -0.00717334f, 
    0.02789681f, -0.03292580f, 0.01669146f, -0.06608697f, -0.01724546f, 0.06140843f, -0.01196851f, -0.04775353f, 
    0.01516072f, 0.06105637f, 0.01501822f, -0.07048961f, 0.05798621f, 0.04108698f, -0.06748129f, -0.06145058f, 
    -0.07383387f, 0.05468464f, -0.06408895f, -0.06500498f, -0.05104645f, 0.02118646f, -0.07742707f, 0.00996431f, 
    -0.00077999f, -0.04524295f, 0.00633371f, -0.02639636f, 0.04095673f, 0.02226490f, -0.00396329f, -0.01607245f, 
    -0.00890512f, -0.05750454f, -0.06251674f, 0.02482331f, 0.02993274f, 0.03532958f, -0.07052071f, 0.03658705f, 
    0.06113856f, -0.05323561f, -0.00808616f, -0.03871188f, 0.01249051f, 0.00837761f, -0.01120521f, 0.03447889f, 
    -0.04655484f, 0.06140084f, -0.02172228f, -0.06917831f, 0.04807081f, 0.05389215f, 0.04122537f, 0.01479128f, 
    0.02722513f, -0.01316984f, -0.03503095f, 0.00812768f, 0.00478627f, -0.03829616f, -0.05097810f, 0.02787356f, 
    -0.03131166f, -0.02509955f, -0.05548048f, -0.06934188f, -0.03519379f, -0.01432584f, -0.05117952f, -0.03414764f, 
    0.06044754f, -0.03510854f, 0.00001569f, -0.02937065f, -0.06438565f, -0.05372003f, -0.04722560f, -0.02246439f, 
    0.02808554f, -0.03418025f, -0.00337710f, 0.01199926f, -0.02542814f, -0.04370348f, -0.03329302f, -0.06573731f, 
    -0.03798430f, -0.00860296f, -0.01033389f, 0.00320988f, 0.00042855f, 0.05471212f, 0.03039186f, 0.02813767f, 
    0.00769023f, -0.01170382f, -0.01212211f, -0.04636626f, -0.06655411f, 0.03943502f, -0.04773939f, 0.05233762f, 
    0.02030546f, -0.06971908f, 0.06121400f, -0.07656451f, -0.06751574f, 0.03245242f, 0.02084934f, -0.05711909f, 
    -0.01255282f, -0.03322851f, 0.01596497f, 0.02098235f, 0.06674684f, 0.02714774f, -0.00842251f, 0.01766104f, 
    0.00008738f, 0.04435179f, -0.00051587f, -0.05153389f, -0.03944930f, 0.03300135f, 0.00951475f, -0.04063363f, 
    0.05306655f, 0.02475844f, -0.04272372f, -0.05789742f, 0.01320213f, 0.01655875f, 0.05774211f, 0.00481947f, 
    -0.02942937f, 0.00774544f, 0.00181429f, 0.05101975f, 0.03282108f, -0.02704044f, -0.07455188f, -0.03886067f, 
    -0.02057233f, 0.04363676f, -0.03586762f, 0.05653203f, -0.00137547f, -0.00392454f, 0.01481235f, 0.04706656f, 
    -0.01908989f, 0.00427288f, 0.05914053f, -0.01941372f, 0.03257522f, -0.02716541f, -0.01669530f, 0.00447145f, 
    -0.03534347f, -0.06397971f, 0.05467862f, 0.00912593f, -0.03110300f, -0.06660537f, 0.02944634f, -0.00034381f, 
    0.17459975f, 0.00366755f, 0.03227049f, 0.03215657f, -0.05070949f, 0.10579909f, -0.13819924f, -0.18465608f, 
    0.08118109f, 0.16337216f, 0.10032651f, -0.03165746f, -0.01624790f, 0.15200736f, 0.15559372f, -0.01939745f, 
    0.08242016f, 0.07082209f, 0.10180172f, 0.09885777f, -0.12619404f, 0.01043413f, 0.08974845f, 0.06872493f, 
    -0.04093341f, 0.07984120f, 0.10056138f, -0.03343819f, -0.06407808f, -0.02752823f, 0.03286755f, 0.01973198f, 
    0.12867530f, -0.00420675f, -0.04330792f, 0.01022231f, -0.33603123f, 0.17041241f, 0.29586065f, 0.08835553f, 
    -0.10028977f, -0.17387906f, 0.11817374f, -0.07482506f, -0.06737155f, 0.00139958f, 0.02769702f, 0.04366174f, 
    0.10693015f, 0.35435516f, -0.00902867f, -0.07575301f, 0.09357756f, 0.07892919f, -0.00930175f, 0.14472716f, 
    -0.03175595f, 0.09881015f, -0.11647633f, -0.06648589f, -0.00825531f, -0.10247556f, -0.15078874f, -0.07101552f, 
    0.00779055f, 0.04507601f, 0.00110050f, 0.06245062f, 0.09131815f, 0.02629850f, -0.08926126f, 0.00208656f, 
    -0.01673797f, -0.18019803f, -0.07120274f, 0.04885465f, 0.06309672f, 0.05322251f, 0.12513758f, 0.09295625f, 
    0.08232123f, 0.06083472f, 0.00261274f, 0.04923574f, -0.06830917f, -0.15057641f, -0.07138304f, 0.33361298f, 
    -0.05649243f, -0.04766239f, 0.09540489f, 0.05182511f, 0.09819484f, 0.01414489f, -0.04546491f, -0.03668858f, 
    0.09357300f, -0.00416586f, -0.04087179f, 0.10397407f, 0.01918671f, -0.07912702f, 0.08268933f, 0.00153634f, 
    -0.03841348f, -0.01189118f, -0.05963850f, -0.01272116f, 0.15204550f, -0.07104987f, 0.09538706f, 0.06972730f, 
    -0.05977606f, -0.08739343f, -0.07408179f, -0.00572662f, 0.05271696f, -0.08054751f, 0.02567469f, -0.06274817f, 
    0.10819945f, -0.08398877f, 0.39524239f, 0.11423916f, 0.00074843f, 0.00199109f, 0.00675352f, -0.07133614f, 
    0.03234728f, 0.01323320f, 0.06242039f, -0.02046108f, -0.19267607f, 0.02069843f, -0.22329813f, -0.02272677f, 
    0.06048203f, 0.00055291f, 0.07539803f, 0.00286640f, -0.06497715f, 0.05327135f, 0.10249146f, -0.03686761f, 
    0.02361907f, 0.15377587f, 0.11962442f, -0.18035595f, 0.00850657f, 0.08285675f, 0.02770747f, 0.09436180f, 
    -0.08376061f, -0.06608911f, -0.02459153f, -0.03927993f, -0.40988052f, 0.10546432f, -0.03569614f, 0.03349454f, 
    0.02683485f, -0.09626963f, -0.07684559f, 0.06279524f, 0.03608904f, 0.07387186f, -0.09886642f, -0.05392110f, 
    -0.07575713f, -0.01089580f, 0.06609027f, -0.02015247f, 0.00038781f, 0.13178042f, 0.05945220f, 0.06901812f, 
    0.14098154f, 0.11146145f, 0.06270626f, 0.05233337f, -0.03415563f, -0.11089303f, -0.01802312f, -0.04902694f, 
    -0.05330322f, 0.02640644f, -0.02315234f, 0.08857524f, 0.06058327f, -0.01490901f, -0.02278783f, 0.02952642f, 
    0.03723533f, -0.06577139f, 0.01882849f, 0.07370865f, -0.17735986f, 0.22259109f, -0.14854002f, -0.14831634f, 
    -0.15616471f, 0.00922468f, 0.20719419f, 0.01636421f, 0.31050503f, 0.11506712f, -0.09657165f, -0.19023846f, 
    0.02462794f, 0.12390714f, -0.12996890f, 0.05459284f, -0.24991050f, -0.05850396f, 0.28452304f, 0.17968434f, 
    0.19732593f, -0.03757127f, 0.13630484f, -0.01642591f, -0.18419684f, 0.01317631f, 0.02911341f, 0.03018706f, 
    -0.14656299f, -0.21762794f, -0.24623337f, -0.31135243f, -0.10942265f, 0.13355516f, 0.13773337f, 0.03383477f, 
    0.09879903f, 0.07042211f, 0.27958745f, 0.08003058f, 0.01291701f, -0.05664349f, -0.06529795f, 0.07056136f, 
    0.64645040f, 0.09481351f, -0.04975991f, -0.09679567f, 0.13892828f, 0.06727556f, -0.01874707f, 0.17665818f, 
    -0.06693774f, 0.18293920f, -0.05333169f, 0.12278929f, -0.06081935f, 0.15051906f, -0.00274915f, -0.23743573f, 
    -0.10560078f, -0.08008808f, -0.19902717f, -0.00758936f, -0.00144928f, 0.05360723f, 0.03523510f, 0.12448566f, 
    0.08812281f, -0.17750452f, 0.26861709f, 0.07855105f, 0.07555397f, 0.00288243f, 0.11450148f, 0.14462286f, 
    0.03654961f, -0.10814857f, 0.07728899f, 0.10120735f, -0.03820520f, 0.08959070f, 0.18298069f, 0.18163469f, 
    -0.09015527f, -0.15874210f, -0.06717823f, -0.15217353f, 0.08164248f, -0.09569564f, 0.00706508f, -0.07438862f, 
    0.05923562f, -0.03733573f, -0.00739247f, 0.08497216f, 0.01470090f, 0.03311420f, -0.00356199f, 0.17416862f, 
    -0.03584176f, -0.00595645f, -0.07437658f, 0.19707754f, -0.08606243f, -0.14123468f, 0.09979600f, -0.12712134f, 
    -0.13818023f, 0.06422709f, -0.07659904f, -0.05811045f, 0.01939349f, -0.13766521f, 0.08904015f, -0.04121144f, 
    -0.08633167f, -0.13971920f, 0.23126625f, -0.05086496f, -0.08933938f, 0.02247182f, -0.06027296f, 0.03493145f, 
    -0.04130038f, 0.23450586f, 0.21455882f, 0.17792258f, 0.31287828f, 0.22074185f, -0.32155138f, -0.09923811f, 
    0.08996396f, -0.19820297f, -0.07135355f, -0.07635184f, -0.14231399f, -0.13924733f, 0.08340777f, 0.00939536f, 
    0.11733970f, 0.18162887f, 0.08308081f, -0.25283912f, 0.00559301f, -0.20774397f, -0.09416009f, 0.07273107f, 
    0.02111062f, 0.00079265f, -0.08902888f, 0.13250372f, 0.20619656f, -0.10557687f, 0.01442684f, 0.11997794f, 
    0.05489310f, 0.16750897f, -0.06497564f, -0.10058602f, -0.09183753f, -0.08868363f, -0.07974414f, -0.05506834f, 
    -0.00952285f, 0.15679835f, 0.03885304f, -0.03713890f, -0.01467823f, -0.00639408f, 0.03211437f, -0.01732824f, 
    0.14121737f, 0.02166072f, 0.06503012f, -0.03358566f, 0.14362468f, -0.29708466f, -0.15373541f, 0.14852634f, 
    0.01260530f, 0.17601380f, 0.01383974f, 0.10871045f, 0.05522494f, 0.04123318f, 0.20789705f, 0.25712955f, 
    0.10752210f, -0.12145830f, -0.08027600f, -0.07028101f, -0.04281283f, 0.17630015f, 0.18730953f, 0.07796974f, 
    0.13237421f, 0.06120167f, 0.14420843f, -0.15956613f, -0.15705298f, 0.14629686f, -0.00995367f, -0.05814321f, 
    -0.00153657f, 0.01288027f, 0.03984607f, 0.00039946f, 0.00421530f, -0.18701309f, 0.17910504f, -0.10337516f, 
    -0.09711321f, -0.09018195f, -0.02368464f, 0.00717408f, -0.09114401f, 0.04269269f, -0.09409034f, 0.13176270f, 
    0.00606263f, -0.02302399f, -0.13798593f, -0.12805122f, -0.16925669f, 0.03107653f, -0.00937576f, 0.07799794f, 
    0.16986433f, 0.00071216f, 0.02380881f, -0.02893405f, -0.04531258f, -0.04790825f, -0.00524853f, 0.02030133f, 
    -0.25804466f, -0.04143838f, 0.04586545f, -0.19063844f, 0.14312920f, -0.05076248f, -0.02642340f, 0.18930933f, 
    -0.02821685f, -0.03779483f, 0.01864821f, 0.06344481f, 0.19268928f, -0.02671460f, 0.12623133f, 0.00957031f, 
    0.09856357f, 0.04516107f, -0.04416149f, -0.02912559f, 0.01938871f, -0.03834743f, 0.00440658f, -0.03750653f, 
    0.03031703f, 0.14855947f, 0.24288934f, 0.25601345f, 0.07594571f, 0.06163380f, -0.11522545f, 0.11664564f, 
    -0.02175333f, -0.07039918f, 0.07345579f, -0.00069638f, -0.23675768f, -0.06487963f, 0.24790332f, 0.07482106f, 
    0.10304438f, 0.16747381f, 0.02318338f, -0.21662760f, 0.05700693f, -0.09782793f, -0.00503221f, -0.14044832f, 
    -0.12931219f, 0.04765615f, 0.08326852f, 0.09771473f, -0.00641808f, -0.00139229f, 0.01131125f, 0.07106563f, 
    -0.08663842f, -0.15271920f, 0.06326054f, 0.15916689f, 0.31671306f, -0.12848561f, -0.07765055f, 0.04667786f, 
    -0.15415275f, 0.08211175f, -0.04056495f, 0.08018550f, 0.02901972f, 0.00430777f, 0.04012221f, -0.07809522f, 
    -0.08440186f, 0.28537354f, 0.19430333f, -0.09582742f, -0.02983346f, 0.05611129f, 0.05071470f, 0.15659130f, 
    0.02332109f, 0.02623092f, 0.11848162f, 0.11457524f, 0.05303813f, 0.26628262f, -0.05704943f, -0.17088668f, 
    0.20203848f, -0.04144021f, -0.01274341f, -0.12344722f, 0.01391991f, -0.21817259f, -0.23884909f, 0.02987080f, 
    0.23297679f, -0.02084591f, 0.00382697f, -0.07609084f, 0.04224365f, -0.07884243f, -0.03617157f, 0.16288170f, 
    -0.02240190f, -0.02964341f, -0.06259412f, 0.04812570f, 0.22979942f, -0.22630639f, 0.08711375f, -0.05732813f, 
    0.06083294f, 0.06232997f, 0.02118160f, 0.09587273f, 0.01992833f, -0.05281086f, -0.03708492f, 0.03509147f, 
    0.21547015f, 0.27561438f, 0.08273879f, -0.19578247f, -0.02562065f, -0.01382873f, 0.05493758f, -0.20126715f, 
    -0.14533514f, -0.05034316f, 0.08786458f, -0.08571665f, -0.04841991f, 0.13579214f, -0.07829966f, -0.03222750f, 
    -0.09983398f, 0.07495303f, 0.11384496f, 0.09453449f, 0.11246985f, 0.08810775f, 0.12064847f, -0.04610845f, 
    0.06399195f, -0.07660393f, -0.19896613f, -0.07495507f, 0.13263917f, 0.06064827f, 0.09821476f, 0.10747907f, 
    -0.02411441f, 0.02921635f, 0.05421365f, -0.10855342f, -0.28301510f, 0.01998625f, -0.11990400f, 0.07288207f, 
    0.03112046f, -0.12471432f, 0.02305478f, -0.01505187f, -0.02932595f, -0.01086304f, 0.00348591f, -0.08317704f, 
    -0.01340694f, 0.17944364f, -0.15589184f, -0.02753009f, -0.01744224f, -0.02603026f, -0.13592662f, -0.06619317f, 
    0.04643285f, 0.12898351f, -0.00967739f, 0.05347110f, 0.05948322f, 0.00477245f, -0.24655633f, -0.02875026f, 
    -0.05855398f, -0.03352804f, -0.16425383f, 0.05675478f, 0.06585231f, -0.04212814f, -0.08046860f, 0.08418900f, 
    -0.46798059f, -0.25447783f, -0.02625063f, -0.00810755f, 0.02433259f, -0.02638456f, 0.05723972f, -0.11307447f, 
    -0.00124060f, -0.03244407f, -0.01106666f, 0.02485649f, 0.15003958f, 0.06786127f, 0.14561594f, 0.12584303f, 
    0.05817671f, -0.00180526f, -0.07133519f, -0.01432863f, -0.06824401f, -0.08703347f, 0.02877964f, 0.06920641f, 
    0.08056491f, 0.31968841f, -0.10444506f, 0.14326049f, 0.01011105f, -0.01168172f, -0.09439369f, 0.02001250f, 
    0.04445454f, 0.07223732f, -0.10558719f, -0.08571813f, -0.10001156f, -0.12199386f, 0.09742113f, -0.02142889f, 
    0.13029672f, 0.09838696f, 0.00200875f, -0.02775060f, 0.02035673f, -0.02201205f, 0.02573130f, 0.05723858f, 
    -0.01522137f, 0.14313927f, 0.00015808f, -0.15479928f, 0.02295421f, 0.01935962f, 0.08715399f, -0.09271093f, 
    -0.04760634f, -0.04696553f, 0.09385475f, -0.05136115f, 0.26922187f, -0.16613466f, -0.04041453f, 0.23509242f, 
    0.00340646f, -0.15169531f, 0.04848676f, 0.07120518f, 0.09168919f, 0.04082086f, 0.11104867f, 0.05201286f, 
    0.10732912f, 0.29996502f, -0.06616900f, 0.00543215f, 0.12088442f, 0.02511939f, -0.05092568f, 0.19662236f, 
    -0.00378035f, -0.01885736f, -0.05191008f, 0.12141486f, 0.24585915f, -0.07552608f, 0.27910671f, 0.02153179f, 
    0.00740252f, 0.14878248f, 0.03373481f, -0.12307690f, 0.07376978f, -0.05750754f, -0.03684160f, 0.12288973f, 
    0.28644681f, -0.09878825f, 0.01051289f, 0.26138094f, -0.09993525f, -0.04335281f, -0.05478564f, 0.14910561f, 
    -0.05769074f, 0.08373665f, 0.00965108f, -0.04631334f, -0.01768094f, -0.01309452f, 0.13682608f, -0.06509358f, 
    -0.01713303f, -0.03747109f, 0.06860592f, 0.07824785f, -0.04220101f, 0.00078803f, -0.01723640f, 0.08808792f, 
    0.03118663f, 0.22780690f, -0.05101203f, 0.07114707f, 0.03450947f, -0.03786407f, -0.02141230f, -0.04940430f, 
    -0.04757999f, -0.16534701f, -0.03173930f, -0.05061984f, 0.07324293f, 0.21993093f, 0.02411086f, -0.00311188f, 
    0.03240770f, -0.08134088f, -0.10589386f, 0.12228422f, 0.06831280f, 0.09200268f, 0.17034227f, -0.10936820f, 
    -0.01385505f, 0.01732532f, 0.03454496f, -0.07736096f, -0.06064454f, 0.03018025f, -0.04708141f, -0.03336822f, 
    0.03900266f, -0.07042013f, -0.04952060f, -0.03804250f, -0.07555968f, 0.04896838f, -0.00646988f, 0.05637638f, 
    0.02765859f, -0.04453303f, -0.02740043f, 0.01934756f, -0.03702414f, -0.07431003f, -0.06235612f, -0.03614156f, 
    -0.04500430f, 0.01813064f, 0.03188551f, -0.00881500f, -0.06379380f, -0.06625486f, -0.05157235f, 0.06235668f, 
    0.02541670f, 0.03767928f, -0.06342353f, -0.06456972f, -0.04387501f, -0.02115821f, 0.03021105f, -0.03465815f, 
    -0.02917006f, 0.04140384f, -0.00857052f, 0.06601106f, -0.00116771f, -0.07144287f, 0.04672667f, 0.00034249f, 
    0.00224741f, -0.05811462f, 0.03600792f, -0.06455493f, -0.05339233f, -0.02630856f, 0.00666288f, 0.03247981f, 
    0.02783396f, -0.02533664f, -0.04535828f, -0.05732967f, -0.06129540f, -0.00493398f, -0.03468083f, 0.05047921f, 
    0.00812428f, 0.02404110f, -0.03494715f, -0.01196785f, 0.04599340f, 0.05239081f, 0.01885073f, -0.00424089f, 
    -0.05647306f, -0.02934919f, -0.01452227f, -0.03997368f, -0.05864756f, 0.02121583f, -0.04084156f, 0.00673042f, 
    -0.06534586f, 0.02083512f, -0.04206051f, -0.02099312f, 0.05437650f, -0.07156014f, -0.07766203f, -0.06476247f, 
    -0.06851473f, -0.06792383f, 0.01548293f, 0.01301150f, 0.05153360f, -0.06483295f, -0.03964239f, -0.04842772f, 
    -0.05245787f, -0.00729501f, -0.04008161f, -0.01890431f, 0.02969711f, -0.03976589f, 0.01163552f, 0.00985602f, 
    -0.01116483f, 0.03385348f, 0.06608979f, -0.02405639f, 0.05311670f, 0.04818400f, -0.00705465f, -0.07453479f, 
    -0.03018430f, -0.01583854f, 0.00979915f, -0.05521337f, 0.00114705f, 0.04015893f, 0.03355753f, -0.02246856f, 
    -0.06154905f, 0.05931862f, 0.01422330f, 0.01956417f, -0.04474286f, -0.02095537f, 0.05966799f, 0.04378905f, 
    -0.03048898f, -0.06903856f, 0.02089687f, -0.01646665f, -0.01218337f, 0.04296564f, 0.00712858f, -0.03857730f, 
    -0.06665611f, 0.00611584f, 0.05653092f, 0.05914139f, 0.00573186f, -0.06019558f, -0.03064916f, -0.06802022f, 
    -0.02117852f, -0.00376046f, 0.02770027f, -0.05006790f, -0.01076161f, -0.05780338f, -0.04055862f, -0.04695119f, 
    -0.01652758f, -0.00527398f, 0.05916896f, 0.05821105f, -0.05463785f, -0.03706457f, 0.03650710f, -0.07428525f, 
    0.03478467f, 0.04505835f, -0.07258956f, 0.03656916f, -0.07104120f, 0.03425445f, -0.01053446f, -0.07422256f, 
    0.01902259f, -0.02317920f, 0.06064798f, -0.04008954f, 0.04026497f, -0.06045546f, -0.06648361f, -0.01010030f, 
    0.01447554f, -0.02671370f, 0.04379097f, -0.01109056f, 0.05770916f, 0.06306512f, 0.00501605f, -0.04500189f, 
    0.04574750f, -0.04161252f, -0.01975037f, 0.04448057f, -0.00325392f, -0.07178502f, -0.02867329f, -0.07775979f, 
    0.08134122f, 0.19418953f, 0.04314705f, 0.20476846f, 0.13209139f, 0.00591267f, -0.07429264f, 0.02800645f, 
    0.05388972f, -0.00172216f, 0.06041569f, 0.25951001f, -0.01185141f, 0.34309629f, 0.05383323f, -0.14986627f, 
    0.07699436f, 0.07469513f, 0.13457568f, -0.06868003f, 0.19519231f, 0.04221673f, -0.11025328f, 0.02340775f, 
    0.24183936f, -0.16113158f, 0.01864805f, -0.09056311f, -0.00995183f, 0.04597817f, 0.05005061f, -0.03160702f, 
    -0.01495591f, 0.02642901f, 0.01778456f, 0.17523965f, 0.30714583f, 0.00778001f, -0.08085706f, 0.03400076f, 
    -0.04807973f, 0.09922122f, 0.15332960f, 0.10057545f, -0.10170780f, -0.06289243f, 0.06993116f, -0.06036910f, 
    -0.25963241f, 0.41486421f, -0.04229715f, -0.10622855f, -0.01667081f, 0.05258765f, -0.04292766f, -0.06847624f, 
    -0.03463782f, -0.09598947f, 0.07064753f, -0.08052341f, 0.09294377f, -0.22379687f, -0.19441316f, -0.02847310f, 
    0.00825925f, 0.05427850f, 0.00035007f, -0.00168008f, 0.07936660f, 0.03091581f, 0.03648888f, -0.05366029f, 
    -0.15272672f, -0.04574659f, 0.04158225f, -0.29819292f, -0.05470672f, -0.01887889f, 0.11048613f, -0.02157286f, 
    0.07507686f, 0.14288022f, 0.10437046f, 0.01405618f, -0.00511020f, -0.04323547f, -0.07310149f, 0.32998472f, 
    0.06655358f, 0.01736330f, -0.03810504f, -0.04398904f, -0.10380936f, -0.07224632f, 0.02891254f, 0.02980937f, 
    0.24302012f, -0.01909230f, 0.04959133f, 0.05299200f, 0.05218927f, 0.04337849f, 0.07278155f, -0.00054424f, 
    0.09298497f, 0.07156375f, 0.01011313f, -0.14102371f, 0.05289103f, -0.01416434f, 0.13754997f, 0.06769288f, 
    -0.01461880f, -0.10086167f, 0.06349737f, -0.01950903f, 0.08989029f, 0.10891426f, 0.06288064f, 0.15387912f, 
    -0.03718508f, 0.27794343f, 0.25998870f, 0.19902109f, -0.05979593f, -0.03462176f, -0.04766468f, 0.09152035f, 
    0.02697119f, -0.11662322f, 0.10330478f, -0.04276185f, -0.39763099f, -0.26880571f, 0.05320521f, 0.13284704f, 
    -0.18446484f, 0.09282228f, -0.25960782f, -0.07247827f, 0.12850919f, -0.07568218f, 0.17605810f, -0.02575921f, 
    0.12198365f, 0.08694535f, -0.02113528f, 0.10192446f, 0.09962554f, 0.01717671f, 0.04231178f, 0.04448987f, 
    -0.12283517f, 0.06803197f, 0.06332095f, -0.09738801f, -0.49327365f, 0.17759320f, -0.15293658f, -0.11637650f, 
    -0.02345675f, 0.14389601f, -0.06130084f, -0.00614134f, 0.16708684f, 0.03417293f, -0.05350847f, 0.18931991f, 
    0.10664529f, -0.34167239f, -0.19765739f, 0.02095668f, -0.02117027f, -0.01636844f, -0.07785321f, 0.00102048f, 
    0.12558874f, 0.06951475f, 0.10962338f, 0.13968320f, -0.04675992f, 0.06821641f, -0.08328120f, -0.19754994f, 
    -0.01371381f, -0.03874705f, -0.06825764f, -0.15485319f, -0.07406589f, 0.05879126f, 0.03051542f, -0.04551518f, 
    0.12902947f, 0.03673590f, 0.15402880f, 0.10189682f, 0.03288511f, -0.06091741f, -0.01227344f, 0.11107617f, 
    0.14443207f, 0.18076546f, 0.03100242f, -0.06786130f, -0.37907928f, -0.13624828f, -0.05148372f, -0.01176424f, 
    0.15893905f, -0.07647427f, 0.07500424f, 0.04738883f, 0.04874291f, 0.03798812f, -0.03510706f, -0.05063521f, 
    -0.23689488f, 0.08315703f, -0.16494276f, 0.11454258f, 0.24511766f, -0.01071247f, -0.00617371f, 0.07683033f, 
    0.01186885f, 0.06418727f, -0.14951180f, -0.05662580f, -0.23748623f, -0.00160332f, -0.05433455f, 0.14688811f, 
    0.01861824f, -0.08514032f, -0.10366747f, 0.00660093f, 0.08846789f, -0.13533543f, -0.00568616f, 0.02499989f, 
    -0.35441434f, -0.14813323f, -0.07225800f, -0.09620949f, -0.03834436f, -0.07647335f, 0.03865432f, -0.03216301f, 
    -0.03011185f, 0.07166325f, -0.05598063f, 0.08589157f, 0.00649644f, 0.02140767f, -0.00080733f, -0.04264409f, 
    -0.07292815f, -0.13674374f, -0.05099003f, -0.00847350f, 0.09357895f, 0.02775607f, 0.15655261f, 0.11300498f, 
    0.06429621f, -0.17094974f, -0.32778102f, 0.33869454f, 0.05012225f, 0.18888013f, -0.12313332f, 0.03433412f, 
    0.17327741f, -0.04111312f, -0.07696878f, -0.08433489f, 0.09768181f, 0.19371983f, 0.12884845f, -0.19590662f, 
    -0.00554148f, -0.05714876f, 0.04717594f, -0.02228661f, -0.02002924f, 0.06102085f, 0.06053714f, 0.10747025f, 
    -0.19215608f, -0.13512646f, -0.05464175f, 0.18585327f, -0.02472540f, -0.06821434f, 0.08814584f, 0.00879809f, 
    0.00493295f, -0.14732599f, -0.05225836f, -0.06838367f, -0.01697436f, 0.02426348f, 0.13342685f, 0.36012453f, 
    -0.03837600f, -0.06127128f, 0.12182857f, 0.04607301f, 0.05753339f, -0.00115620f, 0.06900875f, 0.09555470f, 
    0.13769355f, -0.04860321f, -0.04102499f, 0.08656324f, 0.13552985f, 0.02015561f, 0.03074910f, 0.10964806f, 
    0.04691774f, 0.08057750f, 0.02874927f, 0.04368506f, -0.09774251f, 0.02670527f, 0.20330884f, -0.26421967f, 
    0.21147990f, -0.04772512f, 0.06533399f, -0.10984860f, 0.00374292f, -0.02727569f, -0.02442092f, 0.02334062f, 
    -0.10246344f, -0.22477581f, 0.15431646f, 0.14947660f, 0.05670487f, 0.04759721f, -0.01296391f, 0.13947259f, 
    -0.01308956f, 0.03144859f, 0.03130175f, 0.03886842f, -0.20917448f, 0.03754912f, 0.01908378f, -0.02255819f, 
    -0.03550443f, -0.08331380f, -0.07331143f, 0.13312113f, 0.17545751f, 0.13286337f, 0.07088476f, 0.04817892f, 
    -0.10179430f, 0.01017367f, 0.11720492f, -0.24763450f, -0.03966242f, 0.07641409f, -0.09550654f, -0.05298831f, 
    -0.00544628f, -0.09438656f, 0.07692808f, 0.14546128f, -0.07712074f, 0.07084607f, 0.22853051f, -0.28738993f, 
    -0.02137774f, 0.00976191f, 0.08056477f, 0.16658232f, 0.01631230f, 0.05253114f, -0.06775476f, 0.04083467f, 
    0.11579530f, -0.02813855f, 0.19668378f, 0.08517928f, 0.09511475f, 0.05535481f, -0.01005417f, -0.07398281f, 
    0.08999706f, 0.17624846f, -0.04525407f, -0.01413977f, -0.14737515f, -0.08808640f, -0.06082354f, 0.17709374f, 
    0.00766006f, -0.08426629f, 0.13156876f, 0.15712066f, -0.14907949f, 0.04009261f, 0.01806097f, 0.01185037f, 
    -0.16500974f, 0.24126373f, 0.05820605f, -0.00037200f, 0.11142761f, -0.15795684f, 0.03989733f, -0.13634400f, 
    0.03907794f, 0.08408229f, -0.06059971f, -0.00139616f, -0.18717887f, 0.13846859f, -0.04478719f, 0.07858654f, 
    -0.06781153f, -0.04893126f, 0.07856327f, -0.11239393f, 0.04613953f, 0.00009513f, 0.00429539f, 0.04212659f, 
    0.07344173f, -0.13440689f, -0.02347167f, -0.03793564f, -0.11660620f, -0.03258195f, -0.03844490f, -0.01607192f, 
    0.08422611f, 0.07058647f, -0.05429249f, 0.00741987f, -0.30574921f, -0.02255863f, -0.11794240f, -0.18232316f, 
    0.11622185f, 0.01286969f, -0.05962151f, -0.04342096f, 0.02236761f, 0.09289687f, 0.12247562f, 0.06208098f, 
    -0.04878666f, 0.08640005f, -0.19000024f, 0.33118013f, 0.10952270f, 0.10958481f, -0.03384588f, 0.08635522f, 
    0.18342383f, -0.03602828f, -0.09674104f, 0.09957172f, 0.07305840f, 0.13192870f, 0.01634164f, -0.36200821f, 
    0.04879565f, -0.06685656f, -0.05893746f, -0.03122211f, -0.06897725f, 0.04372205f, 0.05738371f, 0.03004888f, 
    -0.14229606f, 0.04547283f, -0.07519589f, 0.19226788f, -0.02722689f, 0.06791457f, 0.13790442f, -0.01428560f, 
    0.03352464f, -0.00878439f, -0.01768514f, -0.09399292f, 0.06198519f, -0.06021425f, 0.08934602f, 0.25841683f, 
    -0.01984267f, -0.12637179f, -0.02955508f, -0.08236202f, -0.12097164f, -0.09780330f, 0.01311917f, -0.08072653f, 
    0.21836889f, -0.08048082f, 0.04143785f, -0.02093221f, 0.05914830f, 0.04192441f, 0.05863426f, -0.04529434f, 
    0.08804608f, -0.02420277f, 0.05744432f, 0.08237459f, -0.03222698f, 0.13206214f, 0.05709627f, -0.09071234f, 
    0.10469496f, -0.02252144f, 0.16232863f, -0.04841238f, -0.09345396f, 0.05052678f, 0.17029919f, -0.04967562f, 
    0.06130759f, 0.03030904f, -0.04557599f, -0.00870601f, 0.03085235f, 0.13555907f, -0.02516489f, -0.03007796f, 
    0.03259993f, 0.00293071f, 0.11772339f, 0.10231545f, -0.02273021f, -0.15883750f, 0.05550269f, 0.02773157f, 
    -0.01044958f, -0.10529087f, 0.01737491f, 0.12967698f, 0.09072570f, 0.18703963f, 0.05595268f, -0.03013517f, 
    -0.42194545f, 0.16287093f, 0.17430349f, -0.03157213f, 0.08381180f, 0.02798134f, -0.00105226f, -0.02979595f, 
    0.12996322f, 0.01404417f, 0.11018717f, 0.05622560f, -0.00390400f, 0.01700662f, 0.10928535f, -0.12415615f, 
    0.02110408f, -0.04363864f, -0.03471465f, -0.02148530f, 0.00050976f, -0.09569566f, 0.00778310f, 0.09913833f, 
    0.27597460f, -0.08272964f, 0.07816045f, -0.01169804f, 0.12180936f, -0.01024113f, -0.04630164f, 0.04802165f, 
    -0.04159116f, 0.03793957f, -0.04932610f, -0.01813768f, -0.21630517f, 0.22086382f, -0.02350235f, -0.03746944f, 
    0.01922552f, -0.02091560f, 0.04035234f, -0.16569345f, -0.03527387f, 0.11633159f, -0.01135021f, 0.02918492f, 
    0.20430394f, 0.12264382f, 0.04700875f, 0.07975606f, 0.18117072f, 0.06689379f, -0.06597689f, 0.10501316f, 
    0.01858336f, 0.07821399f, 0.00056953f, 0.19664860f, 0.02683885f, 0.33640286f, -0.03429610f, 0.18813436f, 
    0.05809606f, 0.05160827f, -0.10127370f, 0.06898183f, -0.00741628f, -0.08992549f, -0.04666593f, -0.14481767f, 
    -0.56632853f, 0.23681420f, -0.07640453f, 0.00801329f, 0.05336615f, -0.02071069f, 0.07959040f, -0.08379292f, 
    -0.07909270f, 0.07065484f, 0.04027371f, -0.07928689f, 0.01623881f, -0.30006751f, 0.00274660f, 0.12594669f, 
    -0.00249150f, -0.01778772f, -0.11032939f, -0.07991102f, -0.02187487f, -0.07084324f, -0.13467504f, -0.04597145f, 
    -0.10766158f, -0.05448605f, -0.01588427f, -0.02977915f, -0.02483302f, -0.11329630f, -0.12738355f, -0.02840417f, 
    0.00944085f, -0.00398652f, -0.06822307f, -0.00949204f, -0.13587347f, -0.20163268f, 0.01398782f, 0.15573592f, 
    0.11792532f, 0.02532399f, -0.08962679f, -0.06065137f, 0.04950562f, 0.06360427f, 0.02909685f, 0.19716462f, 
    0.19834945f, -0.01141101f, 0.12437771f, 0.31283817f, 0.25342217f, -0.09729671f, 0.19569740f, 0.11922982f, 
    0.13369067f, -0.08776902f, 0.07521552f, -0.12310523f, 0.17688766f, -0.19610490f, 0.06428145f, 0.07500817f, 
    -0.07218353f, -0.15913691f, 0.07271054f, -0.07325793f, -0.02807750f, 0.09403650f, 0.15047497f, 0.01745152f, 
    0.20164841f, 0.09076815f, 0.02127763f, 0.02416658f, 0.10647931f, 0.07268263f, 0.12833008f, 0.03083717f, 
    0.04114224f, -0.14091507f, 0.02702408f, -0.16006564f, -0.03468277f, 0.09465311f, 0.00481368f, -0.00636394f, 
    -0.05205749f, -0.03329735f, 0.04744883f, -0.07242586f, 0.15154256f, 0.04156643f, 0.07118343f, -0.04180958f, 
    0.05520646f, 0.18826334f, -0.08698739f, 0.20759803f, 0.05063045f, 0.08859922f, 0.10733429f, 0.10750999f, 
    -0.05817352f, 0.07329513f, 0.02568571f, -0.01619770f, -0.23989986f, -0.02827759f, -0.10342466f, -0.14999276f, 
    -0.00686987f, 0.05584221f, -0.06164587f, 0.09965257f, 0.04578339f, -0.00903751f, 0.11633261f, 0.12429021f, 
    -0.08110676f, -0.10906880f, 0.08247609f, -0.15065420f, -0.02758845f, -0.09084051f, -0.05128125f, -0.01594478f, 
    -0.07515132f, -0.10366705f, 0.05197653f, -0.07071218f, 0.02478526f, 0.07710056f, 0.09306128f, -0.05185362f, 
    0.12777215f, -0.05819606f, -0.02611794f, 0.03080256f, 0.09963802f, 0.14260451f, -0.04252561f, -0.08164681f, 
    0.10421650f, 0.03932592f, 0.04332457f, 0.07814456f, 0.04985015f, 0.01465212f, -0.06515865f, 0.10811537f, 
    0.02458058f, -0.03514811f, -0.13122910f, 0.04226459f, -0.13761556f, -0.01073965f, -0.07459152f, -0.08892713f, 
    0.02547627f, 0.04783183f, 0.06510709f, 0.01954518f, 0.08334927f, 0.13084027f, -0.13127780f, -0.04264255f, 
    0.12405858f, -0.02202082f, -0.05331744f, -0.08302105f, 0.24486102f, -0.04732070f, -0.10725595f, -0.02631729f, 
    -0.07689990f, 0.16701804f, -0.00140859f, 0.22997718f, 0.28573474f, -0.03120744f, -0.03437264f, 0.02368115f, 
    0.02907291f, 0.10477681f, -0.00000066f, 0.00355403f, 0.03140818f, -0.12092935f, -0.06433931f, -0.11303435f, 
    -0.51393914f, 0.11487172f, -0.08930026f, -0.12440828f, -0.07763574f, 0.10475142f, -0.10348646f, -0.11660293f, 
    -0.00102199f, -0.01686942f, -0.04201340f, -0.10537748f, 0.29049736f, -0.16952817f, -0.00675298f, 0.20522492f, 
    0.10688987f, 0.03376421f, 0.03260681f, -0.14333500f, 0.05946171f, -0.11174890f, -0.07172878f, -0.01724987f, 
    0.06531926f, -0.21958885f, -0.05903283f, -0.15955935f, 0.03441296f, 0.01096696f, -0.08857375f, -0.00738182f, 
    -0.08043548f, -0.00423671f, 0.02469574f, -0.06999895f, 0.18151288f, -0.02470008f, -0.11783072f, 0.24093294f, 
    0.15748431f, -0.08634906f, -0.05602566f, 0.13494459f, -0.01354812f, 0.04474512f, 0.09053235f, 0.25982007f, 
    0.19052427f, -0.12648356f, 0.01466095f, -0.04293821f, 0.03970417f, -0.00459116f, 0.04254756f, -0.09044249f, 
    0.10736216f, -0.00240337f, 0.06910949f, -0.05113371f, 0.09631847f, 0.05743659f, -0.05429672f, 0.08650342f, 
    -0.00109688f, -0.01184949f, 0.12829866f, -0.01428929f, 0.13295327f, 0.02442346f, 0.08099291f, 0.14195356f, 
    -0.05755008f, -0.10574152f, -0.17405003f, 0.06137113f, 0.15870221f, 0.02078495f, 0.05068093f, 0.03936862f, 
    -0.04774057f, -0.08626314f, -0.08063235f, -0.23314227f, -0.12559016f, -0.06618026f, 0.20464239f, 0.15099074f, 
    -0.09088889f, -0.02127891f, -0.03126891f, 0.00091219f, 0.04856258f, 0.08296005f, 0.04691928f, 0.08191507f, 
    -0.19288862f, -0.07666219f, 0.01869351f, 0.07974104f, -0.13513272f, 0.09195530f, 0.07799374f, -0.06180179f, 
    -0.05711589f, 0.09621396f, 0.05592150f, 0.02109967f, -0.12327936f, 0.27377817f, -0.12603125f, -0.03339458f, 
    0.00901387f, 0.04732510f, -0.05788844f, -0.01296808f, 0.07617654f, -0.02414780f, 0.09367508f, -0.02518483f, 
    0.34725827f, -0.32749251f, 0.11143529f, -0.02526217f, 0.02857698f, -0.01819291f, -0.09711156f, 0.07469685f, 
    -0.00845781f, -0.09196670f, -0.03080222f, 0.06814580f, -0.05018812f, 0.10120202f, -0.03572356f, -0.17845386f, 
    0.21741590f, -0.01898573f, -0.10339717f, 0.07824974f, -0.07475951f, 0.08587772f, -0.16053861f, -0.14948606f, 
    0.02681658f, -0.04885478f, -0.03545108f, -0.00403912f, 0.00584083f, -0.01063263f, -0.01421395f, -0.04867120f, 
    -0.00427603f, 0.01657568f, 0.03590518f, -0.02593260f, 0.02736957f, -0.02699620f, 0.06140095f, -0.00667782f, 
    -0.00045910f, -0.01473329f, 0.05144355f, -0.02696126f, 0.00079347f, 0.00133418f, 0.02942876f, 0.01993017f, 
    -0.00158217f, -0.01074500f, 0.01433923f, 0.03809304f, -0.04330636f, 0.00456772f, 0.00371393f, -0.01295817f, 
    -0.05651686f, 0.05970598f, 0.04780487f, 0.02287209f, -0.07124599f, -0.05666875f, 0.02794314f, -0.00341767f, 
    -0.04803394f, -0.03070534f, -0.05438882f, -0.03968581f, -0.01257370f, -0.06900503f, 0.02317105f, 0.02199262f, 
    -0.02709415f, -0.03882056f, -0.07584611f, 0.05419607f, -0.05651898f, -0.02809229f, -0.02730955f, 0.02454159f, 
    -0.05568693f, 0.03454738f, 0.04669983f, -0.04223400f, 0.02993593f, -0.06434452f, -0.01034974f, 0.04900641f, 
    0.02168331f, 0.01510269f, 0.03917317f, 0.02219894f, -0.00112153f, -0.08046833f, 0.05634904f, 0.05264841f, 
    -0.05144636f, -0.03217864f, -0.04116366f, -0.04044097f, 0.04373937f, -0.02828271f, 0.01027022f, -0.07845761f, 
    -0.08003496f, -0.06244009f, -0.07079888f, -0.06300565f, -0.04176352f, -0.06487359f, -0.01009837f, -0.01103646f, 
    -0.01819449f, -0.01843623f, 0.03330330f, -0.04736198f, -0.03122917f, -0.06191859f, -0.01147999f, 0.02639125f, 
    0.03119322f, 0.03771206f, -0.05087523f, -0.04899462f, -0.06792457f, -0.06330011f, -0.05904911f, 0.00840538f, 
    -0.07417552f, -0.04915380f, -0.05789620f, -0.04373940f, -0.06172198f, -0.01208454f, -0.03337657f, 0.00298818f, 
    -0.02694139f, -0.02004132f, -0.00540403f, 0.03597690f, 0.01395005f, -0.05725371f, 0.00845254f, -0.01790601f, 
    -0.00919505f, -0.01009564f, 0.02999612f, -0.03129033f, 0.04569986f, -0.00371357f, -0.01628428f, 0.01680863f, 
    0.00780562f, -0.03151249f, 0.00377874f, -0.04680625f, -0.01074708f, -0.07627715f, -0.03297525f, 0.06160548f, 
    -0.05751169f, -0.05612484f, 0.03098723f, -0.04875239f, -0.01237066f, 0.00259804f, -0.01540599f, -0.06975430f, 
    -0.05502075f, -0.04686223f, -0.06879028f, -0.04963241f, 0.00163281f, -0.03458097f, -0.06687662f, 0.02129603f, 
    -0.05395328f, -0.03920827f, -0.03372730f, -0.04105715f, -0.02896699f, -0.05477199f, 0.02937610f, 0.02506204f, 
    -0.06009832f, -0.01917871f, -0.06752705f, -0.07780844f, 0.02927251f, -0.00262312f, -0.05964346f, -0.01601931f, 
    0.05213374f, -0.04336267f, -0.00634096f, -0.02036215f, 0.05643373f, 0.03510389f, 0.02409832f, -0.02521161f, 
    0.02560844f, -0.03314640f, 0.02854912f, 0.03804816f, 0.05492401f, -0.01973809f, -0.00673661f, 0.01262608f, 
    0.05127485f, -0.06050210f, -0.03475591f, -0.06557078f, 0.06072628f, -0.06093531f, -0.03978876f, -0.05739041f, 
    0.01321260f, 0.06933986f, 0.04333137f, -0.16654494f, 0.10835838f, 0.00080140f, 0.09948274f, 0.09942344f, 
    -0.01412245f, -0.01538729f, -0.01466052f, -0.01628934f, -0.11151960f, -0.27351353f, -0.11966375f, 0.12290152f, 
    -0.01073152f, 0.06430967f, -0.06591377f, -0.05193615f, -0.03184501f, 0.01433396f, -0.10040820f, -0.01550657f, 
    -0.09592701f, -0.00678552f, -0.02481061f, 0.00512058f, 0.17121398f, 0.09211571f, 0.08347724f, 0.01758691f, 
    -0.14966823f, 0.15531692f, 0.01908808f, 0.09241527f, 0.13850984f, -0.19065885f, 0.03633112f, 0.01744013f, 
    0.08737389f, 0.01996631f, -0.08492649f, 0.05947200f, 0.01260641f, 0.09534143f, 0.01678585f, 0.01163067f, 
    -0.10584681f, -0.21839750f, -0.04643445f, -0.00972716f, -0.06307000f, 0.13409540f, -0.08799378f, 0.03573789f, 
    -0.10302795f, -0.01258259f, 0.06409895f, 0.16352332f, 0.32478803f, 0.17949802f, 0.08812038f, 0.23076646f, 
    0.05980809f, 0.03071843f, -0.04814947f, -0.02430742f, 0.04716760f, 0.05013851f, 0.14145850f, 0.01975055f, 
    0.22070207f, 0.05338421f, -0.17292872f, -0.03663672f, -0.07753947f, 0.06578594f, 0.00029288f, -0.04840156f, 
    0.00416315f, -0.04727997f, -0.06335888f, 0.00723869f, 0.04374452f, 0.07137205f, 0.03224028f, -0.01824936f, 
    0.07069087f, -0.00582722f, -0.06426720f, 0.05169004f, 0.02977129f, 0.03711621f, -0.09077005f, 0.13550925f, 
    -0.00831832f, -0.12215822f, -0.00931252f, -0.09095767f, -0.09805381f, 0.08833123f, -0.07789077f, -0.10494526f, 
    -0.05027948f, -0.02037844f, 0.10551196f, 0.01857078f, 0.00248421f, 0.16382277f, -0.09865091f, -0.06317322f, 
    0.09212074f, 0.07245421f, 0.05502360f, 0.01145779f, 0.11260246f, 0.02427456f, -0.04051751f, 0.09798477f, 
    -0.04891416f, -0.09258166f, -0.21044962f, -0.18790644f, 0.02867503f, 0.05073993f, 0.10965666f, 0.03988311f, 
    0.11933253f, 0.03753726f, 0.08563260f, -0.04125365f, 0.29855129f, 0.01247838f, 0.13066387f, 0.03154182f, 
    -0.00253030f, -0.05724303f, -0.01401741f, 0.09057102f, -0.00081837f, -0.05821355f, -0.05312806f, 0.10087609f, 
    -0.11516418f, -0.06197670f, 0.04436145f, -0.06697101f, -0.14390597f, 0.01289084f, 0.14168429f, -0.14584097f, 
    0.15484357f, 0.04906704f, -0.00394709f, 0.12792467f, 0.27263641f, 0.12989868f, -0.05583479f, 0.14233570f, 
    -0.03140115f, -0.01016277f, 0.00909968f, 0.04136438f, -0.06749457f, -0.06557732f, 0.07358579f, -0.06632916f, 
    0.41981965f, -0.17516328f, 0.05905207f, 0.08183048f, 0.14710136f, -0.00269777f, -0.11096159f, -0.02229952f, 
    0.08456028f, 0.01726023f, -0.05143011f, 0.01018904f, 0.09993467f, -0.16992486f, -0.01422220f, 0.06609974f, 
    0.10038423f, -0.04556284f, 0.02083799f, 0.08161444f, -0.02409665f, 0.05046386f, -0.08114529f, -0.12035693f, 
    0.02215298f, 0.08963705f, 0.14469935f, -0.01622872f, -0.00887485f, 0.09594062f, 0.14124289f, 0.09822861f, 
    0.03181600f, 0.05855755f, 0.10023224f, -0.03071361f, -0.09548411f, 0.01583500f, -0.11131388f, 0.03786330f, 
    -0.01187986f, -0.10223090f, 0.11791364f, 0.12695178f, 0.00397056f, -0.00960411f, -0.05427275f, -0.06216747f, 
    0.00858045f, -0.01018425f, -0.08737146f, -0.15297197f, 0.02964493f, -0.09941524f, -0.03107807f, -0.03312776f, 
    0.03261144f, 0.07880668f, -0.11924961f, -0.07801156f, -0.11413904f, -0.28949308f, -0.12284282f, 0.01198105f, 
    -0.03169414f, -0.19814751f, 0.04391825f, -0.09848975f, -0.07609609f, -0.15481468f, 0.01064053f, 0.00627693f, 
    -0.20864567f, -0.08706872f, -0.19459920f, -0.07822679f, -0.10059036f, 0.01811660f, 0.06408232f, 0.05476541f, 
    -0.05313055f, 0.01079299f, 0.03104718f, 0.11066096f, -0.02118585f, 0.06326110f, -0.03452873f, -0.05693451f, 
    0.12145744f, -0.01044437f, 0.08260489f, -0.03321357f, 0.05519679f, 0.17279157f, 0.06343484f, 0.07296211f, 
    0.00097834f, -0.14371130f, -0.26044598f, 0.37871483f, 0.04580444f, 0.09110183f, 0.02465616f, -0.04075855f, 
    0.06021796f, -0.02062177f, -0.08847119f, -0.12771681f, 0.10413500f, 0.26225007f, 0.19707978f, -0.18239783f, 
    0.20450875f, 0.02089373f, -0.07630631f, -0.01285911f, -0.07734158f, 0.02878786f, 0.00305399f, 0.08270020f, 
    -0.12460609f, -0.12102551f, -0.16550270f, 0.05986255f, -0.18033798f, -0.02423089f, 0.01942013f, -0.03492091f, 
    -0.07589859f, -0.03240146f, 0.00075285f, -0.08436918f, 0.11204366f, -0.07662544f, 0.06252949f, 0.39591140f, 
    0.16239253f, -0.04495833f, 0.14690743f, 0.03407618f, 0.05030449f, -0.08219562f, 0.04971510f, 0.04014128f, 
    -0.03395798f, 0.16023231f, -0.02889262f, -0.01842005f, 0.06962142f, 0.16115148f, 0.01254576f, 0.04138358f, 
    0.12384746f, 0.01172130f, 0.16405272f, 0.11344825f, -0.36753538f, -0.00502813f, 0.25779334f, -0.28356746f, 
    0.16216403f, 0.05500982f, 0.00988027f, 0.01770798f, -0.05658005f, 0.04768215f, -0.11433540f, 0.07843854f, 
    0.12653492f, -0.12629940f, 0.05600179f, 0.15402667f, -0.01830449f, -0.00776946f, -0.07903270f, 0.10061011f, 
    0.02347858f, 0.00654019f, 0.05282466f, 0.01907545f, -0.21050400f, 0.11029206f, -0.00330129f, 0.04510928f, 
    -0.02191635f, -0.08771776f, 0.11227836f, 0.19240716f, 0.11743765f, 0.14322725f, 0.09826335f, 0.08943254f, 
    0.12988000f, -0.05476517f, 0.12933137f, -0.09878070f, 0.17281218f, 0.06030118f, -0.00684056f, 0.06154932f, 
    0.12743744f, 0.09239260f, 0.14299329f, 0.15150549f, -0.20359164f, 0.03910299f, -0.00113105f, -0.24045536f, 
    0.05445657f, 0.05602533f, 0.08306165f, 0.13422035f, -0.09573115f, 0.03887473f, 0.08049901f, -0.00723239f, 
    0.14678459f, 0.07000853f, -0.11147182f, 0.00144438f, 0.00539470f, 0.06702041f, 0.02703548f, -0.00974459f, 
    -0.00839144f, -0.18215962f, 0.17105602f, 0.09229951f, -0.18213956f, 0.11205903f, 0.01292792f, -0.08126171f, 
    0.05157870f, 0.00473793f, -0.06122370f, -0.04069613f, -0.03267121f, -0.02822683f, 0.06787995f, 0.07749254f, 
    0.14570692f, 0.17909870f, -0.00476139f, -0.03774176f, 0.03917592f, 0.08343986f, 0.08848958f, -0.01581936f, 
    0.01967755f, 0.00524837f, 0.10679969f, -0.03650193f, 0.09205868f, 0.00657626f, -0.22754975f, -0.01631334f, 
    0.03414794f, -0.09322333f, 0.08125788f, -0.07552873f, 0.03220792f, 0.13320807f, 0.03043745f, 0.03584978f, 
    -0.28707993f, -0.01253109f, 0.03297753f, 0.07187228f, 0.10176144f, 0.00712714f, 0.09020361f, 0.02426721f, 
    -0.02988974f, 0.16492137f, 0.10788046f, -0.01508169f, 0.00578079f, 0.14187601f, 0.07182054f, -0.09703649f, 
    -0.22584565f, -0.03495986f, 0.00008757f, 0.05693614f, -0.00732335f, 0.02023258f, -0.06901755f, 0.10472309f, 
    0.08897654f, -0.18450071f, 0.05607352f, -0.14115217f, 0.05323494f, 0.09981502f, 0.04932820f, 0.09527550f, 
    0.00944935f, 0.00350340f, -0.02325743f, -0.13662839f, -0.09527113f, -0.11048669f, 0.20066987f, 0.01048022f, 
    -0.04616787f, 0.05626538f, 0.07788463f, -0.02374670f, 0.17701802f, -0.05807591f, -0.17515738f, -0.02364242f, 
    0.16181563f, -0.07753607f, -0.11447664f, -0.09027246f, -0.02532708f, -0.06535317f, 0.06085833f, -0.00967207f, 
    0.06229408f, 0.12888014f, 0.06283795f, -0.00643139f, 0.10551803f, -0.31383663f, 0.15091887f, 0.10805791f, 
    -0.07070115f, 0.01890911f, -0.11099093f, 0.01359859f, 0.09149485f, -0.06885497f, 0.08835989f, 0.12769496f, 
    -0.02154734f, 0.15063478f, 0.12082022f, 0.19563912f, 0.12528217f, 0.05610585f, -0.08222643f, 0.15641983f, 
    -0.04186023f, -0.07261866f, 0.04661844f, -0.04727634f, 0.36408940f, -0.17227931f, -0.10667373f, 0.06678016f, 
    -0.06427383f, 0.12009459f, 0.07693926f, -0.00291445f, 0.09584033f, -0.02959073f, 0.03438398f, -0.11579934f, 
    0.20034081f, 0.12049227f, 0.07732478f, 0.20580338f, -0.00184456f, -0.01695845f, -0.00216124f, 0.02436140f, 
    0.04740835f, -0.01930141f, -0.04274835f, 0.10742503f, -0.29544568f, 0.03982163f, 0.11685079f, 0.08795021f, 
    0.08765821f, -0.06136759f, 0.01182000f, 0.03355540f, -0.03599194f, -0.12348042f, -0.06677753f, 0.10215195f, 
    -0.13397585f, 0.04385708f, -0.10386714f, -0.02036057f, -0.16139385f, -0.00322180f, 0.01128557f, 0.12860982f, 
    0.08006717f, -0.01237524f, -0.03202586f, 0.00360080f, -0.00707301f, -0.07525693f, -0.12584946f, 0.08190259f, 
    -0.03177669f, 0.09267379f, -0.04417509f, 0.08722751f, 0.09564573f, -0.01778186f, 0.14459597f, 0.02123733f, 
    0.09875866f, -0.10883085f, -0.01942299f, 0.09622462f, 0.04295747f, -0.00300850f, -0.23077573f, 0.07630299f, 
    0.12247320f, 0.12184180f, -0.07329535f, -0.04104501f, -0.04513912f, -0.06336571f, 0.08445223f, 0.06035850f, 
    0.11275835f, 0.05974852f, 0.05632486f, 0.16914895f, 0.02671872f, 0.10718248f, -0.01294254f, -0.02220753f, 
    0.10845645f, 0.14670992f, 0.18166457f, -0.08604538f, -0.07631306f, -0.05118642f, -0.12494392f, 0.02163985f, 
    0.03063065f, 0.01821999f, -0.09818318f, -0.03862551f, -0.07960359f, 0.07106686f, 0.27158588f, 0.12838714f, 
    -0.11057287f, 0.08609261f, 0.06096898f, -0.05332839f, -0.04378992f, -0.13011964f, -0.01098565f, 0.04303769f, 
    0.29365006f, 0.10398928f, -0.00296333f, 0.07625007f, 0.00329913f, 0.07632492f, 0.01426527f, -0.04646489f, 
    0.01819026f, -0.00033238f, -0.12623993f, -0.06384841f, 0.08395980f, -0.03328507f, -0.17143333f, 0.23452395f, 
    0.16702282f, 0.05026256f, 0.03656343f, -0.00145523f, 0.07344290f, 0.12165720f, 0.09469061f, -0.15216014f, 
    -0.14881027f, 0.22227013f, -0.28279081f, 0.03149329f, 0.04014518f, -0.10857374f, 0.08870804f, -0.12486140f, 
    0.00650499f, 0.00554885f, -0.04452615f, 0.14708248f, 0.22635543f, -0.12510754f, -0.23365030f, 0.28358391f, 
    0.10498881f, 0.05399167f, -0.01964002f, 0.09094021f, -0.14680417f, 0.06548420f, 0.13138777f, -0.00976275f, 
    -0.04589028f, 0.20250441f, 0.11632526f, 0.24971992f, 0.01166279f, 0.10113464f, -0.05504814f, 0.01147964f, 
    -0.00189276f, 0.02598050f, 0.00688465f, 0.02798721f, 0.05805286f, 0.07304578f, -0.23012920f, 0.09263798f, 
    0.06519081f, -0.05080271f, -0.05936351f, 0.00529237f, 0.07717171f, -0.03922943f, -0.08965912f, -0.07302663f, 
    0.24157007f, -0.03417976f, 0.02065703f, 0.00561613f, -0.09025972f, -0.03441402f, 0.06813467f, -0.15183085f, 
    -0.07349409f, 0.01341041f, -0.03778443f, 0.02977655f, -0.38502660f, -0.17502062f, 0.11303814f, 0.08520244f, 
    -0.05097702f, 0.01787009f, -0.00978336f, -0.05416333f, -0.04631037f, 0.02324147f, -0.03439121f, 0.08409530f, 
    -0.09273367f, -0.02959936f, 0.03237679f, -0.02991327f, -0.00371780f, 0.01796484f, -0.04731593f, -0.08947475f, 
    0.02987474f, -0.13220429f, 0.04529690f, -0.04805260f, 0.33091629f, -0.00968256f, -0.14280969f, -0.11458369f, 
    0.06149282f, 0.04690405f, 0.04380443f, -0.02842487f, 0.05990892f, 0.15121029f, 0.00175764f, -0.12096147f, 
    0.21414544f, -0.06099650f, 0.00680620f, -0.01479635f, -0.01847470f, -0.04013231f, 0.01645091f, 0.08685525f, 
    -0.12594022f, 0.21412896f, -0.01260670f, -0.01055736f, -0.11255235f, 0.09749486f, 0.10337330f, -0.21503264f, 
    0.02523559f, -0.07174262f, -0.07754226f, -0.11894917f, -0.11934894f, -0.00892319f, 0.01839196f, -0.06955011f, 
    -0.11016145f, 0.09285770f, 0.19429818f, 0.06842127f, -0.01543710f, -0.10210399f, -0.05579335f, 0.06774407f, 
    0.00686721f, -0.04395337f, -0.16523281f, 0.10115316f, 0.18134698f, -0.24398996f, -0.04399715f, 0.10638880f, 
    0.02883162f, 0.03206689f, 0.06386081f, 0.07045817f, 0.09761243f, 0.07109262f, -0.27916366f, 0.08668156f, 
    -0.06339996f, -0.08133752f, 0.00137964f, -0.00391074f, 0.20121370f, 0.06555997f, 0.05538554f, -0.02167599f, 
    0.01027066f, 0.15325494f, 0.03001618f, 0.21717077f, 0.45369995f, -0.20628634f, -0.12887114f, -0.05066934f, 
    0.02559282f, 0.04440451f, -0.08186789f, -0.01855880f, 0.09493988f, -0.02386412f, 0.08873603f, -0.06744887f, 
    0.07559356f, -0.01665338f, -0.05166669f, 0.05406837f, -0.19091313f, 0.02169866f, -0.06285115f, -0.09723946f, 
    -0.03050509f, -0.04832077f, 0.04976692f, -0.01899994f, -0.12849468f, -0.01432258f, 0.14544976f, 0.02285521f, 
    0.08623169f, 0.02450787f, 0.03996811f, -0.02066343f, 0.06179345f, -0.08836108f, 0.11094116f, 0.07038888f, 
    0.10594918f, 0.05557953f, -0.07196184f, -0.14540306f, -0.12183513f, 0.04865946f, 0.01800208f, -0.06788069f, 
    -0.02957123f, 0.05409431f, -0.03078068f, 0.06198579f, 0.30614576f, 0.18321152f, -0.02669252f, -0.16244464f, 
    -0.00090656f, -0.16856512f, -0.09036724f, 0.15544334f, -0.15071386f, 0.09239767f, 0.12272678f, 0.27795431f, 
    -0.05622305f, -0.02943506f, -0.07408746f, -0.16373709f, 0.07322201f, 0.09661741f, -0.06397613f, -0.05148136f, 
    0.05608680f, -0.00501904f, 0.05225805f, -0.05116329f, -0.18199168f, 0.25661448f, -0.09659765f, -0.12404042f, 
    0.20106621f, 0.15333617f, 0.09688560f, -0.03616406f, 0.01405054f, -0.01980273f, -0.10882100f, 0.05557794f, 
    -0.10204121f, -0.01499304f, -0.18039642f, -0.03722059f, 0.00442996f, -0.07293746f, 0.03161570f, 0.00470641f, 
    0.07379498f, 0.03507330f, -0.05284959f, -0.14122859f, -0.07887104f, 0.00593412f, 0.22751859f, 0.20314901f, 
    -0.00830427f, -0.11249177f, 0.02819131f, -0.00201604f, 0.06819965f, 0.12069899f, 0.08355336f, 0.16905868f, 
    -0.14610642f, -0.06077212f, -0.07072009f, -0.02417802f, 0.03351691f, 0.04531251f, 0.04816297f, -0.08334550f, 
    0.14850101f, 0.05991419f, 0.09847163f, 0.07121123f, 0.00597360f, 0.01467342f, -0.11301948f, 0.13959897f, 
    -0.06087003f, 0.06611393f, -0.00890465f, 0.00014528f, 0.02833594f, 0.00063700f, 0.15528017f, 0.07304358f, 
    -0.04773988f, -0.29015771f, 0.01447826f, 0.22131400f, 0.10358839f, -0.00623009f, -0.03510028f, -0.05026966f, 
    0.08486840f, -0.05557834f, -0.03946119f, 0.09304756f, 0.09204455f, 0.01652261f, 0.01551225f, -0.08031281f, 
    0.08718007f, -0.04483390f, -0.13017188f, -0.05928997f, -0.11741294f, -0.04748757f, -0.06127033f, -0.10692757f, 
    0.16953544f, -0.14072508f, 0.08166621f, -0.17510453f, 0.20214933f, 0.03932331f, -0.13519150f, -0.00726343f, 
    0.11314461f, 0.06711247f, -0.14660972f, -0.08454867f, -0.13340776f, 0.04320488f, -0.04585977f, 0.20151739f, 
    -0.02800579f, 0.04650899f, 0.05270434f, 0.07729334f, -0.06468496f, 0.25247914f, -0.09112105f, 0.01610540f, 
    0.24963745f, 0.12967625f, 0.05332705f, -0.16379680f, -0.06417482f, -0.10951703f, -0.08459099f, -0.01292061f, 
    0.02232428f, 0.14760335f, -0.05009333f, 0.09799875f, 0.23309945f, 0.18032584f, 0.09104049f, 0.18469253f, 
    -0.18915941f, -0.07623430f, 0.08160785f, 0.07067399f, 0.04191151f, -0.07143705f, -0.06500791f, -0.09122797f, 
    -0.31199619f, 0.08370034f, -0.00718277f, -0.06979009f, -0.09227693f, 0.03493569f, 0.03751418f, -0.03661130f, 
    0.03720997f, 0.02377252f, -0.06401229f, -0.05339647f, 0.03958895f, -0.22965360f, -0.14761724f, 0.21099551f, 
    0.24933538f, 0.08220412f, -0.05086305f, -0.09034677f, -0.05770147f, -0.00752303f, 0.02198594f, -0.02860193f, 
    0.04430209f, 0.13456771f, -0.24666300f, 0.08316030f, 0.08047506f, -0.01189529f, -0.14981741f, 0.04450176f, 
    0.07320110f, 0.07488693f, -0.04011627f, 0.01044685f, -0.08196928f, -0.05695596f, -0.07930257f, 0.25292560f, 
    0.14659959f, -0.14506894f, -0.02563041f, 0.08823378f, -0.06103880f, -0.06399028f, 0.01089472f, 0.09675291f, 
    0.19029956f, 0.05447221f, 0.24514396f, 0.27742904f, -0.19023092f, 0.02087384f, 0.01179583f, -0.12968707f, 
    -0.03620625f, -0.00395828f, 0.06771381f, -0.03285697f, 0.36965135f, -0.05138773f, -0.09836501f, 0.12612520f, 
    0.01361817f, -0.11995099f, -0.01504673f, -0.10821922f, 0.21617869f, -0.03657931f, 0.01281852f, 0.12612712f, 
    0.16259359f, 0.07467861f, -0.00440549f, -0.07767914f, 0.07588299f, -0.14014569f, -0.01293784f, -0.06280044f, 
    -0.03538242f, -0.04037660f, -0.11687565f, -0.02912234f, -0.25237840f, -0.19101335f, 0.10004835f, 0.05566110f, 
    0.13768253f, -0.01612858f, 0.04466728f, -0.01841255f, -0.04512003f, 0.05800007f, 0.12626068f, 0.01902452f, 
    0.14122586f, 0.11986292f, -0.09945147f, 0.04710415f, -0.16863497f, -0.06863807f, 0.15503325f, -0.04212748f, 
    0.06199034f, 0.01324460f, 0.00558707f, -0.09221491f, 0.14566350f, 0.08733197f, -0.14991149f, -0.01033976f, 
    0.04125421f, 0.03182628f, 0.03563901f, 0.18647234f, 0.05284411f, 0.07778638f, 0.03077159f, 0.05382173f, 
    0.25523746f, -0.11733242f, -0.00870037f, -0.07187747f, 0.15052730f, -0.10887962f, -0.08871586f, -0.06826352f, 
    0.03477534f, 0.05157819f, -0.01922890f, 0.03149226f, -0.12873301f, 0.00028924f, -0.09666999f, -0.20920832f, 
    0.17933117f, -0.07457869f, -0.11109140f, 0.11863660f, -0.04672021f, -0.06034547f, -0.06226930f, -0.05182776f, 
    0.05763416f, -0.06683876f, -0.05047410f, 0.03021188f, -0.03613732f, -0.07258496f, -0.07109695f, -0.00227475f, 
    -0.02001400f, 0.01417472f, 0.02122511f, 0.06361633f, -0.02957614f, 0.05630264f, 0.02254804f, -0.07341980f, 
    -0.05252039f, -0.05925368f, -0.04030951f, 0.04226317f, 0.03543513f, -0.03115137f, 0.01048895f, 0.00468238f, 
    0.00846036f, -0.01649019f, 0.01067270f, -0.07114249f, 0.05965480f, 0.05332251f, 0.00585899f, -0.05413268f, 
    -0.06829475f, 0.00582622f, 0.06244639f, -0.03220175f, -0.03986951f, -0.01678781f, -0.02333306f, -0.06713866f, 
    -0.05649748f, 0.05284148f, -0.07117567f, -0.01156581f, -0.01043094f, 0.02162077f, 0.01426414f, 0.06324995f, 
    -0.05655140f, -0.05909918f, 0.05482982f, 0.03104397f, 0.00557967f, -0.02343347f, 0.04453044f, -0.04321942f, 
    0.02898197f, 0.02995742f, 0.05193121f, 0.04562813f, 0.04396420f, -0.04868877f, 0.01092220f, -0.06454600f, 
    0.04078531f, 0.02243098f, -0.00356191f, -0.04441297f, 0.06002734f, 0.02696701f, -0.05495455f, -0.07034069f, 
    -0.00786748f, -0.00865100f, -0.04088197f, 0.00941254f, -0.02894690f, 0.01559005f, -0.00244301f, -0.07020792f, 
    0.03289182f, -0.03746384f, -0.01375885f, 0.03229659f, -0.00250767f, -0.02016859f, 0.02122795f, -0.00693862f, 
    -0.06609774f, -0.02967555f, -0.01156165f, 0.03793136f, -0.02192365f, -0.03111045f, 0.00600664f, -0.04294445f, 
    -0.04510230f, 0.03545291f, -0.02935195f, -0.01395104f, -0.07360880f, -0.05084658f, 0.04381336f, 0.04248977f, 
    0.01676314f, -0.05830324f, -0.06758591f, 0.05615521f, -0.01962561f, -0.07274871f, 0.03247450f, -0.04221530f, 
    0.03260214f, -0.06742682f, 0.02350130f, 0.03003042f, -0.02639952f, 0.05673110f, 0.00035363f, -0.03907471f, 
    0.00202549f, 0.03900174f, 0.02522660f, -0.05483253f, -0.06250045f, 0.03667322f, -0.02384684f, 0.01294891f, 
    -0.02125440f, 0.00940012f, 0.05148954f, -0.08420247f, 0.04216830f, -0.03640458f, 0.04543833f, -0.07443623f, 
    -0.02141340f, -0.05059844f, -0.07017018f, 0.02673925f, 0.00365250f, 0.02007834f, -0.03841535f, -0.01371582f, 
    -0.03138769f, -0.00627974f, 0.03762877f, -0.06733304f, -0.07859898f, -0.02509694f, 0.04485809f, -0.00209573f, 
    -0.03145466f, -0.00798709f, -0.00598778f, -0.07388137f, -0.01712788f, -0.04101836f, -0.01215437f, -0.03571119f, 
    0.04849595f, -0.07339659f, -0.07492847f, -0.02451334f, 0.04733684f, 0.00867842f, 0.05122486f, -0.01184418f, 
    0.04754863f, 0.00964748f, -0.06068867f, -0.03015570f, -0.02176036f, 0.04286384f, -0.01609843f, -0.06419767f, 
    -0.02264827f, -0.08293469f, -0.03516950f, 0.00434632f, -0.06684978f, -0.06998165f, -0.05833726f, 0.01284790f, 
    -0.00064936f, 0.00188448f, -0.02564716f, -0.06552802f, 0.03645413f, 0.02588453f, 0.04509618f, -0.02990871f, 
    0.01731893f, 0.00387552f, 0.06674337f, -0.04189278f, -0.03399261f, 0.18503173f, -0.00321646f, 0.02495254f, 
    -0.05731709f, 0.10346290f, -0.10827405f, 0.01432113f, 0.22367765f, -0.12057547f, 0.08191153f, 0.04663431f, 
    0.02877120f, 0.10111593f, -0.11069175f, 0.05701120f, 0.05563729f, 0.03376347f, -0.01173783f, 0.00921929f, 
    0.28948262f, 0.02581298f, 0.05705520f, 0.05997479f, -0.20318754f, -0.12645975f, -0.07504294f, -0.05819425f, 
    -0.00251171f, -0.04286696f, 0.05839887f, 0.00649858f, 0.35786220f, 0.14029056f, 0.01922803f, 0.07725514f, 
    0.11677826f, -0.11493523f, -0.14990906f, 0.13808951f, 0.00139772f, -0.17442735f, -0.18804245f, -0.15708655f, 
    0.14932427f, -0.03120051f, -0.03453347f, -0.11130378f, 0.02487440f, 0.08774964f, -0.06419503f, -0.09340126f, 
    0.06407728f, 0.01243498f, -0.04321704f, 0.08867110f, 0.21697403f, 0.05919063f, 0.06492440f, -0.15598440f, 
    0.35244980f, 0.03099863f, -0.04589137f, -0.04463340f, 0.03447278f, -0.06448215f, 0.01293998f, -0.00609269f, 
    0.00551362f, 0.20733781f, 0.25384364f, -0.29712495f, 0.07110370f, -0.06639012f, 0.00037840f, 0.03590175f, 
    0.10921043f, 0.12728934f, 0.05401219f, 0.20249766f, -0.22278818f, -0.21515587f, -0.55014431f, -0.22439565f, 
    0.17926337f, 0.05168393f, 0.00375157f, 0.03582736f, -0.02863562f, -0.04971407f, 0.06878599f, 0.09297717f, 
    -0.00141379f, 0.07961322f, 0.22128984f, 0.09071314f, -0.25808972f, -0.01905222f, 0.01134539f, 0.12811795f, 
    0.16687161f, -0.00585718f, 0.06283890f, -0.05446487f, -0.10848165f, -0.12473939f, -0.12407627f, -0.18198434f, 
    0.11578164f, 0.07208208f, 0.14410280f, -0.16215725f, 0.07877419f, 0.04150354f, 0.05798408f, -0.02600902f, 
    -0.02226888f, -0.20018920f, -0.01455056f, 0.06337318f, -0.14511524f, -0.09813275f, 0.13675638f, 0.13255966f, 
    0.01908743f, 0.07088531f, 0.06156970f, 0.03137893f, -0.12446626f, -0.01381675f, -0.29219478f, 0.07637379f, 
    0.09224395f, 0.03535883f, 0.10137232f, -0.12931168f, -0.09075537f, -0.01543730f, 0.01957432f, 0.15575954f, 
    -0.28952944f, 0.11706770f, 0.03611160f, 0.19175550f, -0.07869788f, -0.14325926f, 0.01394906f, 0.02666441f, 
    0.09392860f, 0.12367091f, 0.14395703f, -0.10211187f, 0.67796624f, -0.13665234f, -0.14144778f, -0.24454089f, 
    0.06216963f, 0.21335724f, -0.06215961f, 0.02533897f, 0.06310098f, -0.04196472f, 0.14852548f, 0.07813229f, 
    0.07332215f, 0.03288720f, 0.40150541f, -0.12595475f, 0.21104777f, -0.15213674f, -0.07910383f, 0.02795277f, 
    0.04146742f, 0.00319699f, -0.03552582f, 0.12815544f, -0.37100208f, -0.29114634f, -0.10774367f, -0.14259410f, 
    0.14481524f, -0.04703778f, -0.02184827f, -0.05049622f, 0.12001509f, 0.01460594f, -0.13572764f, 0.03621351f, 
    -0.02623696f, 0.04844388f, -0.04090971f, -0.04357259f, 0.02136064f, 0.06072919f, 0.05596657f, 0.00006474f, 
    -0.01504126f, -0.00025661f, -0.06423536f, 0.02615514f, 0.04919538f, -0.02486684f, 0.01311166f, -0.04079951f, 
    0.03911124f, 0.03374293f, -0.03504487f, -0.06688609f, -0.07638721f, -0.03139769f, 0.00733696f, -0.01928045f, 
    -0.03456520f, -0.00187735f, 0.03925471f, 0.03963993f, -0.06545948f, -0.08326147f, -0.02983570f, 0.01010927f, 
    -0.00518963f, 0.02573147f, -0.06425781f, -0.02939434f, 0.05448579f, 0.01730742f, 0.00885237f, -0.06104705f, 
    -0.03139276f, -0.01812633f, 0.05086084f, -0.07573306f, -0.03621965f, 0.06306152f, 0.00985008f, -0.02384719f, 
    -0.05425988f, 0.03516993f, 0.01403374f, -0.02093882f, 0.03273904f, -0.02979445f, -0.07059800f, -0.04899760f, 
    -0.01608137f, 0.03809610f, -0.02617391f, -0.00417395f, -0.05060820f, -0.02550154f, 0.01733932f, 0.02511679f, 
    -0.00410705f, -0.07126481f, 0.03645038f, 0.04273535f, 0.04963298f, 0.05356101f, 0.01254081f, -0.00964488f, 
    -0.03922641f, -0.04304381f, -0.05423708f, -0.04664010f, 0.05142292f, -0.02294316f, -0.03380970f, -0.01284331f, 
    -0.04745699f, -0.05760564f, 0.03261839f, 0.02522394f, 0.02635704f, -0.00041338f, 0.06292550f, -0.07064432f, 
    -0.08066975f, -0.07974617f, -0.01650774f, -0.05877733f, 0.00466399f, 0.02593446f, -0.02765881f, 0.03801622f, 
    0.05859494f, 0.02692373f, -0.02223618f, -0.06795722f, -0.01119903f, -0.04587037f, -0.06923250f, -0.05903440f, 
    -0.02146963f, -0.00333947f, 0.01611034f, -0.03802125f, 0.04463346f, 0.03014140f, -0.00055383f, 0.05296733f, 
    -0.02220928f, 0.04008958f, -0.01121007f, -0.03027237f, -0.06111610f, -0.04511342f, -0.05747151f, -0.03706715f, 
    -0.05940820f, 0.05201533f, 0.04369689f, -0.04765151f, 0.04425934f, -0.05020857f, -0.01887817f, 0.02209551f, 
    -0.01856874f, 0.04810289f, -0.05371595f, 0.00936984f, 0.05528499f, -0.04140542f, -0.05423873f, 0.00600368f, 
    0.03818766f, 0.03541292f, -0.07613304f, -0.03856677f, 0.00295992f, -0.02877744f, -0.03023066f, 0.00790686f, 
    -0.03597478f, 0.02316647f, -0.06332868f, 0.04031314f, -0.03370127f, 0.00627367f, -0.04845434f, -0.07393603f, 
    0.01687219f, 0.04654418f, 0.01333259f, -0.04151492f, 0.06487220f, -0.00849049f, -0.05524173f, -0.03134855f, 
    -0.02389879f, 0.02587981f, -0.02886780f, -0.07473749f, 0.03650094f, -0.06634410f, 0.01103510f, 0.01542116f, 
    0.06139923f, -0.00063292f, 0.05344353f, 0.00925677f, 0.02596672f, 0.01272467f, -0.05604789f, 0.04120733f, 
    0.00244839f, 0.00475584f, -0.00951388f, -0.05544897f, -0.07256859f, -0.02406461f, 0.06258042f, 0.03821842f, 
    0.05913325f, 0.05465068f, -0.00281509f, 0.01137084f, 0.02800301f, -0.05749393f, -0.02242075f, 0.01138230f, 
    0.02858088f, 0.04172171f, 0.19316931f, 0.13853118f, -0.03751466f, -0.06463642f, -0.04118449f, -0.01361250f, 
    -0.09293125f, 0.00170955f, -0.08086228f, -0.00568739f, -0.05097920f, 0.14924262f, -0.06839629f, -0.10566851f, 
    0.04176601f, -0.04354503f, 0.11938220f, -0.04004561f, -0.09832127f, 0.03340787f, 0.04361322f, 0.03899180f, 
    0.12100361f, -0.05110310f, 0.00084820f, 0.17189991f, 0.15420088f, 0.08723933f, -0.06573080f, 0.00785960f, 
    0.10434823f, 0.13557903f, -0.02831107f, 0.06560946f, -0.11201807f, 0.29726565f, -0.20525871f, 0.03372700f, 
    0.05402655f, 0.16940960f, 0.04702401f, -0.04807792f, -0.06271879f, -0.10671495f, -0.00180318f, 0.01933126f, 
    -0.31137162f, 0.09883143f, -0.03446479f, -0.03675615f, 0.06037414f, -0.02307744f, 0.13790360f, -0.09003850f, 
    0.08892173f, 0.08826940f, 0.05798919f, -0.04142952f, -0.45847949f, -0.34273714f, 0.01545581f, -0.08884060f, 
    -0.00637408f, -0.00142862f, -0.03128073f, 0.00388400f, 0.07053588f, -0.10009757f, -0.06981504f, 0.06347783f, 
    -0.25076351f, 0.07730593f, 0.10451303f, 0.12449919f, 0.01340269f, 0.03281370f, -0.11243774f, 0.06166125f, 
    -0.04909710f, -0.02601431f, -0.03421223f, 0.00150880f, -0.10198668f, 0.00304343f, 0.23592260f, -0.08936745f, 
    -0.06529053f, -0.03956464f, 0.00419388f, -0.09555067f, -0.15216838f, 0.09874555f, 0.07499250f, 0.01996222f, 
    -0.06931671f, 0.08816992f, -0.00052473f, 0.24213268f, 0.26061842f, -0.00679171f, 0.08623930f, 0.09015172f, 
    0.05259438f, 0.00950304f, 0.01043804f, -0.06974828f, 0.13970846f, -0.03863166f, 0.11699609f, 0.16523962f, 
    -0.23094741f, -0.11874603f, 0.07927842f, 0.07203545f, -0.08142284f, 0.07864489f, 0.07660079f, -0.05034717f, 
    0.23570597f, 0.23124795f, 0.12614463f, 0.14901063f, 0.08625142f, 0.04599234f, -0.04396309f, -0.00189562f, 
    0.08792537f, -0.00875110f, -0.13023211f, -0.17055129f, -0.22059980f, 0.18230888f, -0.01763654f, -0.06023522f, 
    -0.12474750f, -0.00992669f, 0.00226583f, -0.05136632f, 0.14914991f, 0.12017168f, 0.09305120f, 0.06381999f, 
    0.15101221f, 0.08111642f, 0.00051860f, 0.16515593f, 0.27112249f, 0.09201383f, -0.00686966f, 0.02910574f, 
    -0.04778769f, 0.03861616f, 0.11477856f, -0.05442980f, -0.33911476f, -0.34403259f, 0.04828246f, -0.06696964f, 
    -0.01537200f, 0.02270534f, 0.01432107f, 0.06086934f, 0.07558638f, 0.04827999f, -0.02860340f, 0.20459422f, 
    -0.48062792f, -0.00454288f, -0.03147126f, -0.00998543f, -0.03180284f, -0.06933350f, -0.02641228f, -0.09812877f, 
    0.00334295f, -0.10799205f, 0.04186703f, 0.07857380f, -0.00987557f, 0.21844870f, 0.10460093f, -0.14187558f, 
    -0.06349821f, 0.07371991f, 0.03073082f, -0.03668351f, -0.01214315f, 0.01362510f, 0.01456320f, -0.10127716f, 
    0.03797834f, -0.02738845f, -0.04035612f, -0.06606465f, 0.05208299f, -0.07066219f, -0.06619805f, 0.03142280f, 
    0.04839578f, -0.04503856f, -0.05468182f, -0.00471400f, 0.04316533f, 0.02044477f, 0.05235546f, 0.02190474f, 
    0.04359134f, -0.04117054f, 0.05730413f, -0.04042289f, 0.03450109f, -0.04744200f, -0.01029235f, 0.05929095f, 
    0.03785316f, 0.03516510f, -0.02853957f, -0.04819373f, 0.03666866f, 0.02615429f, 0.00493999f, -0.02725327f, 
    -0.04803125f, 0.03065437f, 0.02845815f, 0.00557660f, 0.04776781f, -0.02178346f, -0.06878816f, 0.01465333f, 
    0.02215457f, 0.06289384f, 0.02170471f, 0.02036975f, -0.03318467f, -0.05340307f, 0.04588376f, -0.07735797f, 
    -0.00785142f, 0.05169764f, 0.05191210f, -0.03607816f, -0.03196213f, -0.00007090f, -0.03698280f, 0.04264871f, 
    -0.06965520f, 0.01624326f, 0.03980596f, -0.08209018f, -0.01699018f, -0.04431329f, -0.01672050f, -0.03110755f, 
    -0.06899902f, -0.05203831f, -0.05987229f, -0.05704434f, 0.01724510f, -0.07193048f, -0.06208214f, -0.02144229f, 
    0.02968302f, 0.02243945f, 0.02354353f, -0.01532840f, 0.02500924f, -0.05311878f, -0.02309457f, -0.05797609f, 
    0.05381889f, -0.03209291f, 0.01034413f, 0.03334470f, 0.05497747f, -0.03087160f, 0.04668533f, -0.05017962f, 
    0.05020205f, 0.01481036f, -0.05511684f, -0.07781170f, -0.06594209f, 0.02505350f, -0.05800385f, 0.02437950f, 
    -0.00195469f, -0.05614296f, -0.02323184f, 0.03304841f, 0.01062935f, -0.01917603f, 0.01378625f, -0.04277937f, 
    -0.03507870f, -0.01691049f, -0.04225074f, 0.05460918f, 0.04396530f, -0.02635185f, -0.08572400f, -0.00287379f, 
    -0.05061239f, -0.02088043f, 0.00558691f, 0.03854240f, -0.05431074f, 0.05057679f, -0.06943806f, -0.00675230f, 
    -0.06379055f, -0.01129358f, -0.02334756f, -0.05397833f, -0.06156453f, -0.05083795f, 0.06448495f, -0.00239910f, 
    -0.07631159f, -0.03686116f, -0.03777654f, -0.02271801f, 0.02243480f, -0.04302204f, 0.03806430f, 0.03676040f, 
    -0.05398105f, -0.04550945f, 0.05292775f, 0.03223331f, -0.05740914f, 0.02551014f, 0.04660409f, -0.00844706f, 
    -0.00576275f, -0.04840712f, -0.03732878f, -0.04869175f, -0.01597323f, 0.04711793f, -0.05169271f, -0.01403959f, 
    -0.00225390f, -0.04107147f, -0.05881018f, 0.04640873f, -0.07567818f, -0.06756186f, 0.04207981f, -0.05215984f, 
    -0.04827207f, -0.02295341f, -0.06122323f, -0.05376286f, 0.04664284f, -0.06882046f, -0.04300639f, -0.07023866f, 
    0.01728320f, 0.05552104f, 0.03664744f, -0.01838750f, 0.05082490f, -0.06076661f, -0.05940973f, 0.03501345f, 
    0.01933533f, -0.02994051f, 0.04880572f, -0.00951291f, 0.04046756f, -0.07309452f, -0.07200117f, -0.02662060f, 
    0.00505511f, -0.05432110f, -0.05054039f, -0.00004038f, -0.08192404f, 0.04930196f, -0.01635833f, -0.03589520f, 
    -0.02347975f, 0.04485174f, -0.01386454f, 0.04884589f, -0.02968118f, -0.01382638f, -0.00506141f, 0.00660558f, 
    -0.04011286f, 0.00215493f, -0.02191881f, 0.04043224f, -0.03347909f, 0.02220303f, 0.01163318f, -0.05899105f, 
    -0.04148126f, 0.03267140f, -0.07321221f, -0.06965318f, -0.06867445f, -0.05935291f, 0.05448557f, 0.00069626f, 
    -0.06624974f, -0.01243408f, -0.01426960f, -0.05501078f, -0.06728665f, 0.05742375f, -0.04924862f, 0.02305650f, 
    -0.05303901f, 0.04230041f, -0.00447940f, 0.06008517f, 0.01811795f, -0.03198184f, -0.04366488f, -0.07560569f, 
    -0.04779307f, -0.06247697f, 0.05381934f, -0.05151255f, -0.07296826f, -0.02239645f, -0.04993626f, 0.00275092f, 
    -0.06008160f, -0.02753626f, 0.03207338f, -0.03236198f, -0.05109814f, 0.04849616f, -0.01763358f, -0.07729641f, 
    0.03670719f, 0.04402250f, 0.00431303f, 0.05959137f, -0.05929808f, 0.01012046f, -0.04529700f, -0.02634522f, 
    0.02203183f, 0.02842577f, 0.03140194f, -0.03508312f, -0.01729485f, 0.06203648f, 0.01417990f, 0.04010205f, 
    -0.04956349f, 0.04678764f, -0.05963581f, -0.01954757f, -0.00986631f, 0.02443560f, -0.06624050f, -0.02719826f, 
    0.00719739f, -0.06235118f, 0.06465368f, 0.03739758f, -0.03402046f, -0.04444680f, -0.00186629f, 0.02556627f, 
    -0.05869719f, -0.03132147f, -0.01975521f, -0.07732410f, 0.03795577f, -0.02406463f, -0.00813968f, -0.02630945f, 
    -0.03953618f, -0.00743096f, -0.07706802f, -0.02459767f, 0.05432088f, 0.02114733f, -0.01354871f, -0.05187159f, 
    0.04582166f, 0.00986894f, 0.04379031f, -0.01622386f, -0.07296128f, 0.00833498f, 0.00668996f, -0.03716466f, 
    0.03145641f, -0.05551917f, -0.02830319f, -0.00810738f, -0.02014281f, -0.02268273f, -0.00903983f, 0.01392729f, 
    -0.02149679f, -0.00496507f, -0.02316426f, -0.03976225f, 0.00584334f, 0.04607544f, -0.01297241f, -0.00776886f, 
    -0.03640826f, 0.06486910f, -0.05196328f, -0.05526878f, 0.03457997f, -0.06214032f, -0.07285890f, -0.00235178f, 
    0.06153360f, 0.06656782f, -0.06763280f, 0.00772501f, 0.02387680f, -0.07335728f, -0.03032800f, -0.07714210f, 
    0.05655769f, -0.00272418f, 0.03607388f, -0.06953053f, -0.04874274f, -0.03153205f, -0.05171183f, -0.03014099f, 
    -0.04851678f, -0.02112646f, -0.04150847f, 0.02080087f, 0.05575358f, 0.00098473f, 0.06031373f, -0.03281686f, 
    -0.01114910f, -0.07755454f, -0.02586054f, -0.03148405f, -0.06622721f, -0.00399678f, -0.00145286f, 0.05636994f, 
    0.01259124f, -0.02961716f, -0.04347647f, 0.02297168f, -0.03269426f, -0.00428409f, 0.04288558f, -0.02139371f, 
    -0.03318506f, -0.03361104f, 0.04724290f, 0.05601218f, 0.02351327f, 0.02524487f, -0.07252840f, 0.02753239f, 
    -0.04514746f, -0.00637436f, -0.06983918f, 0.04771974f, -0.06975560f, 0.04320841f, -0.03280687f, -0.03726938f, 
    -0.32957214f, 0.08316499f, -0.07480124f, -0.04686119f, -0.06512760f, -0.01847246f, 0.17205343f, 0.04139873f, 
    -0.16704974f, -0.12484106f, -0.03856228f, 0.11128617f, 0.08605243f, -0.06691214f, 0.01793734f, -0.06310869f, 
    0.07528362f, -0.01158045f, -0.12179066f, -0.09698232f, 0.07361446f, -0.04689112f, -0.03192483f, -0.08433683f, 
    0.09106533f, 0.00730381f, 0.04235960f, 0.08579143f, 0.01594468f, 0.16355571f, 0.02896048f, 0.17454909f, 
    -0.08337257f, -0.00343570f, 0.09675904f, -0.02151262f, 0.25322267f, -0.21945573f, 0.04463032f, -0.14503877f, 
    0.08862086f, 0.11290058f, -0.05721325f, 0.05998657f, 0.08763733f, 0.12274291f, -0.03259343f, 0.07658266f, 
    0.27120721f, -0.03948202f, 0.02963993f, 0.16426544f, -0.00989642f, -0.01060566f, 0.00228576f, 0.06183687f, 
    0.03016418f, -0.08703991f, 0.11564448f, 0.12440225f, 0.13441393f, 0.32230794f, 0.23925167f, 0.11177119f, 
    -0.05984963f, 0.02049834f, 0.16460359f, 0.00661395f, -0.02329483f, 0.03337841f, 0.03443316f, 0.05951587f, 
    -0.00249060f, -0.05066423f, -0.15385774f, -0.06922359f, -0.07057702f, -0.03610352f, 0.04438528f, -0.01634371f, 
    -0.09391198f, 0.01807055f, 0.06028130f, -0.10866568f, 0.27495551f, 0.21713524f, -0.13298140f, -0.14983453f, 
    -0.04664604f, 0.10845125f, -0.02840308f, -0.01330393f, -0.04351984f, 0.08978937f, -0.14351653f, 0.12204749f, 
    0.13076068f, 0.10005137f, -0.02713500f, -0.08573608f, 0.07638304f, -0.04554606f, -0.20468898f, 0.00702845f, 
    0.00970766f, -0.05227656f, 0.07315356f, 0.08899377f, -0.28454506f, 0.21396066f, -0.16433921f, -0.18048373f, 
    0.12212428f, 0.06144673f, -0.01632339f, 0.06136250f, -0.05932455f, 0.06136347f, -0.07357780f, -0.02197446f, 
    -0.04359728f, -0.06956454f, -0.32212359f, -0.13187622f, 0.07520138f, -0.02020041f, -0.09539010f, 0.05149211f, 
    0.07229383f, -0.01565690f, 0.02533400f, -0.02413846f, 0.15033728f, -0.14294299f, 0.11223092f, 0.00920572f, 
    -0.09308024f, -0.00725866f, -0.09076767f, 0.09921695f, -0.01626387f, 0.09971225f, -0.12466077f, 0.03017111f, 
    -0.13173749f, -0.07510302f, -0.10379291f, 0.03449671f, -0.05120830f, -0.01584920f, -0.04817647f, -0.13952737f, 
    0.12224922f, 0.07302718f, -0.05336294f, -0.03527305f, 0.50403798f, 0.08486031f, 0.07017564f, 0.03069860f, 
    0.10497229f, 0.12813854f, 0.14978866f, -0.08340921f, 0.03870876f, -0.14828569f, -0.02506341f, -0.04893472f, 
    0.23203146f, 0.01292958f, -0.02452082f, 0.08466595f, -0.07668675f, -0.05006450f, -0.03457088f, 0.01917826f, 
    0.03184186f, 0.08583884f, -0.07101092f, 0.07903434f, 0.03773540f, 0.10774211f, 0.00563707f, 0.02471182f, 
    0.09111966f, 0.01301655f, -0.00016377f, -0.08350763f, -0.02581589f, -0.01426180f, 0.01394996f, 0.06239824f, 
    -0.09805027f, -0.05529377f, -0.15405829f, 0.11694381f, -0.08736876f, 0.08166661f, 0.15864408f, 0.07400844f, 
    0.08606835f, -0.12080744f, 0.01194236f, 0.01874854f, -0.09361056f, 0.22375385f, -0.04623910f, -0.12261356f, 
    -0.03088137f, 0.04383123f, 0.12909266f, -0.14409801f, 0.11021756f, -0.10714398f, 0.02473320f, 0.05162930f, 
    -0.07860401f, -0.09135307f, -0.10478288f, 0.15597370f, 0.14710541f, 0.03127499f, -0.01953278f, 0.19593324f, 
    0.04440815f, 0.12616010f, -0.02794615f, 0.11789003f, -0.24585070f, -0.16171317f, -0.09988472f, -0.05848718f, 
    0.03184032f, -0.06342924f, -0.14743014f, -0.04665064f, 0.15692076f, 0.04284319f, 0.03376647f, -0.00629915f, 
    -0.28006440f, 0.05296355f, -0.09933373f, 0.04616389f, 0.07231460f, 0.08940940f, 0.08228222f, 0.15423205f, 
    -0.05450081f, -0.04983254f, 0.03138150f, -0.07068977f, 0.34954488f, 0.07355907f, 0.27601135f, 0.23779929f, 
    -0.31783646f, -0.04602662f, 0.00511917f, 0.02005455f, -0.02786030f, -0.03056129f, -0.19001064f, 0.17507616f, 
    0.26294246f, -0.25545120f, -0.12174416f, -0.21089840f, -0.01161287f, -0.03067632f, -0.01036700f, -0.10072876f, 
    -0.03644951f, 0.07104621f, 0.05547350f, -0.01291339f, 0.08545732f, 0.01419530f, 0.28542337f, 0.31054804f, 
    -0.12981588f, 0.11768039f, -0.05350237f, 0.06171092f, 0.05153470f, 0.06426936f, 0.00810645f, 0.08377150f, 
    0.04302887f, -0.10801271f, -0.03601248f, -0.14266677f, 0.09755211f, 0.02175761f, 0.00556228f, 0.18185329f, 
    0.03634204f, -0.12120996f, 0.06476613f, -0.01298723f, -0.10867032f, 0.10366161f, 0.04263250f, -0.08090512f, 
    -0.05534299f, 0.10605366f, 0.03770919f, -0.02487081f, -0.01729189f, 0.04224965f, 0.04128974f, 0.13491817f, 
    -0.21705091f, 0.01766290f, -0.03312832f, 0.01291590f, 0.18963960f, 0.12199662f, -0.04766459f, 0.11455628f, 
    0.04778797f, -0.03166354f, 0.08298849f, -0.09617736f, 0.20675480f, 0.15253863f, 0.13854653f, -0.02551552f, 
    -0.04482943f, -0.01283820f, -0.04875122f, 0.11033104f, 0.21183273f, -0.06527938f, 0.01921954f, -0.02909948f, 
    -0.11750343f, -0.16223510f, 0.15820879f, -0.13396209f, 0.02781736f, -0.02194661f, -0.04534667f, 0.01233673f, 
    -0.02611103f, -0.00758979f, 0.01473807f, 0.07743717f, -0.47743368f, 0.21919940f, 0.00734421f, 0.07371704f, 
    -0.12116504f, 0.01512391f, 0.08244531f, 0.01399336f, 0.08719634f, -0.08256835f, -0.00832399f, 0.02635155f, 
    0.43966594f, 0.00935586f, -0.05663553f, 0.00988922f, -0.15202840f, 0.04703636f, -0.01087210f, -0.02461189f, 
    -0.04757606f, -0.14637455f, 0.00484166f, 0.01932241f, 0.29053134f, -0.00584092f, 0.08286923f, 0.19080983f, 
    0.07298174f, 0.15017650f, 0.08246298f, 0.11805378f, -0.00818014f, 0.06128306f, -0.06021671f, -0.02135320f, 
    0.33886078f, 0.00488878f, 0.15889101f, 0.17803018f, 0.03046225f, 0.19809005f, 0.11249977f, 0.19350156f, 
    0.06653750f, 0.18993872f, 0.04986395f, 0.02389323f, -0.14626825f, -0.26831105f, 0.22173804f, 0.00615151f, 
    0.07340279f, 0.00705186f, 0.03226524f, 0.05852124f, -0.09695147f, -0.12120590f, 0.27049574f, 0.06095598f, 
    -0.26942146f, -0.13275892f, -0.02819514f, -0.04999434f, 0.00849716f, -0.11119958f, 0.03330636f, -0.14928181f, 
    0.00247560f, 0.09176479f, -0.15369274f, -0.16469969f, -0.14815302f, -0.18846402f, -0.27779755f, -0.11506993f, 
    0.02933692f, -0.10042408f, 0.10017651f, -0.11968397f, 0.10674910f, -0.00363158f, 0.07145010f, 0.06654442f, 
    0.06217214f, -0.08975711f, 0.14094228f, -0.13928100f, 0.05628756f, 0.00226557f, -0.05479388f, 0.01367815f, 
    0.09397056f, 0.02024593f, 0.04690917f, 0.12954405f, 0.15419979f, 0.11949507f, -0.13157408f, -0.03525788f, 
    0.23620175f, -0.04115991f, -0.10552719f, -0.14222576f, -0.04892736f, 0.00021784f, 0.14179906f, -0.07953964f, 
    0.12520544f, 0.24290504f, -0.02018868f, 0.08115537f, 0.07127351f, 0.15806016f, -0.14972895f, 0.00963806f, 
    0.09880868f, 0.13044812f, -0.01583456f, 0.05050859f, 0.16047066f, 0.05211001f, -0.11069961f, -0.27247053f, 
    0.06463105f, 0.09073442f, 0.00917224f, -0.09886694f, -0.14569393f, -0.18276563f, -0.03304486f, -0.05788641f, 
    -0.21053663f, -0.08119851f, -0.19268472f, -0.17262921f, -0.04089704f, 0.06219972f, 0.02509587f, 0.05867493f, 
    0.02730426f, 0.07689637f, 0.05756739f, 0.12705635f, 0.41977465f, 0.02848454f, 0.11346661f, 0.19289705f, 
    -0.05541601f, 0.08900321f, -0.02857338f, 0.17708354f, -0.02789083f, -0.12369558f, -0.08559396f, -0.10652201f, 
    0.11868392f, 0.21790788f, 0.09143629f, 0.11414605f, 0.00047863f, 0.06540868f, 0.09386534f, 0.13929732f, 
    0.03527505f, 0.06275572f, 0.06243033f, 0.15892059f, 0.06390516f, -0.00813199f, 0.02093035f, 0.01068750f, 
    0.12904599f, -0.08923808f, 0.06318608f, -0.15763666f, -0.01055141f, -0.11031527f, -0.12791884f, -0.07026979f, 
    -0.17992401f, -0.23607594f, 0.00802059f, 0.15385456f, -0.06955617f, 0.01916722f, -0.04332775f, 0.17081565f, 
    -0.11963327f, 0.02156218f, 0.05859856f, 0.17701557f, 0.20910664f, -0.36650693f, 0.01030151f, 0.06243467f, 
    -0.07725511f, 0.01554046f, -0.11188123f, 0.12052487f, -0.06880575f, -0.07292894f, -0.00873846f, -0.05392085f, 
    0.00578270f, 0.19824244f, 0.03847561f, -0.00660769f, 0.08366747f, 0.04578674f, -0.02610046f, -0.19121371f, 
    -0.15788986f, 0.04789163f, 0.02944960f, -0.00797879f, -0.09291108f, 0.23429520f, 0.33020025f, -0.15458493f, 
    -0.21186695f, 0.00875613f, 0.23752058f, 0.00736875f, 0.01353632f, 0.03469696f, 0.08125948f, 0.11842649f, 
    0.03326174f, -0.01309623f, 0.00152338f, 0.03555232f, -0.07264069f, 0.03664395f, 0.03526793f, -0.07513560f, 
    0.02443337f, -0.06206951f, -0.02361635f, -0.05905263f, -0.07986251f, -0.05471596f, 0.03674190f, -0.06448331f, 
    -0.02169432f, 0.02506964f, -0.07388186f, -0.06882069f, -0.03628998f, -0.07203464f, -0.01433050f, -0.05008299f, 
    0.04026349f, -0.04680116f, -0.02026154f, 0.06888297f, -0.05412987f, -0.07792034f, -0.02765297f, 0.03683148f, 
    -0.06792928f, 0.03104273f, -0.01853244f, 0.05187052f, -0.04326656f, -0.02684503f, 0.02367992f, 0.03683281f, 
    -0.07462739f, -0.07977936f, -0.03670713f, 0.03950148f, -0.00411346f, 0.04011816f, -0.06812391f, -0.06969135f, 
    0.00596120f, 0.04380926f, 0.00862607f, 0.00645404f, 0.01667033f, -0.00911951f, -0.05475130f, -0.04314799f, 
    -0.06110683f, 0.00326249f, 0.04013822f, -0.00999484f, 0.00714149f, 0.00203682f, 0.04085279f, 0.02632091f, 
    -0.05599216f, -0.04563244f, 0.04668889f, -0.01980604f, -0.00777228f, 0.04777286f, -0.03527430f, 0.03226425f, 
    -0.07607392f, 0.05480781f, 0.00822843f, -0.04869413f, 0.02482369f, 0.02895397f, -0.01676255f, -0.06615604f, 
    0.02809984f, 0.03224450f, 0.01735107f, 0.05656641f, 0.00614905f, 0.04919999f, -0.04677946f, 0.04103620f, 
    0.01647360f, -0.01982108f, -0.01104662f, -0.04288177f, 0.05128286f, 0.01369876f, 0.02814106f, -0.02368000f, 
    0.05389828f, -0.01995629f, 0.03768195f, -0.01360970f, -0.07513972f, 0.05206122f, -0.02691961f, 0.05015561f, 
    -0.04159271f, -0.02234791f, 0.01652678f, 0.04504151f, 0.07674222f, -0.03549176f, -0.03551034f, 0.01860528f, 
    -0.02532493f, 0.05300257f, -0.01787902f, -0.07652654f, 0.00757618f, 0.02274885f, -0.02225065f, 0.01851035f, 
    -0.05858070f, 0.00059963f, -0.02639348f, 0.03266453f, 0.05627687f, 0.01273862f, -0.08326438f, -0.02259879f, 
    0.02443713f, -0.04167756f, 0.03417449f, 0.05798060f, -0.04881889f, 0.00810133f, 0.00513219f, -0.06549136f, 
    -0.05829532f, -0.02892934f, -0.05874321f, -0.02136671f, 0.01227904f, -0.06305374f, 0.02126742f, 0.06957746f, 
    0.06516571f, -0.05318787f, -0.03520787f, -0.02043452f, -0.02123168f, 0.00030738f, 0.00777120f, -0.03874164f, 
    -0.08213924f, -0.06849829f, 0.02963000f, -0.04860159f, 0.03239705f, 0.05813050f, -0.04056899f, -0.06831433f, 
    -0.00005099f, 0.00995443f, 0.06342431f, -0.07217840f, -0.06337298f, -0.08650546f, -0.03427983f, -0.01262686f, 
    -0.06418010f, 0.03516197f, -0.02441183f, -0.06373458f, -0.05530847f, -0.01852863f, 0.00285525f, 0.01363348f, 
    -0.07201944f, 0.05530602f, -0.05617528f, -0.06370492f, -0.06652922f, 0.04904159f, -0.06068327f, 0.03476026f, 
    -0.04637196f, -0.05106267f, -0.08648197f, 0.00301963f, 0.06755456f, 0.05973030f, -0.02815104f, 0.02212644f, 
    -0.02483575f, 0.00465430f, 0.04459802f, -0.00019289f, 0.06284267f, -0.07453799f, -0.04812158f, -0.07371406f, 
    -0.07577938f, 0.03724049f, 0.01251056f, -0.06948573f, 0.01883135f, 0.05180162f, -0.02916954f, 0.01433669f, 
    -0.06335261f, -0.02348605f, -0.01686747f, -0.04810955f, -0.04618990f, 0.03032142f, -0.00790520f, -0.06451213f, 
    0.04270703f, -0.01833721f, -0.01796317f, -0.04667053f, 0.05923255f, -0.04700767f, -0.04962813f, -0.03519882f, 
    0.01148561f, -0.05299646f, 0.05485163f, -0.05458683f, -0.00975119f, 0.04019086f, -0.04616726f, -0.04115047f, 
    -0.05833103f, 0.06163374f, -0.06930939f, -0.07662967f, -0.04621448f, -0.00554473f, -0.06777029f, -0.03881610f, 
    -0.05965923f, -0.02098318f, 0.00126508f, -0.00770315f, -0.03327957f, -0.06488314f, 0.00731476f, 0.02392850f, 
    0.01176263f, 0.06499444f, 0.02669372f, -0.04447736f, -0.00177213f, 0.05367611f, 0.05443349f, -0.04559736f, 
    -0.03228477f, 0.00760801f, 0.00895975f, -0.01117191f, -0.01794978f, 0.05226554f, -0.04747337f, -0.05214252f, 
    -0.06464680f, -0.03687058f, -0.01949838f, -0.05500627f, 0.04187758f, -0.04719290f, 0.01844402f, -0.05886948f, 
    0.05285647f, -0.06725271f, -0.07236209f, 0.05083311f, -0.06558070f, -0.05293542f, 0.00990557f, -0.04322229f, 
    -0.07290003f, 0.04054283f, 0.02060701f, -0.05733760f, -0.04806435f, -0.07400884f, 0.03828312f, -0.04155948f, 
    -0.07127670f, 0.06130446f, 0.00462626f, -0.00817796f, 0.02874257f, 0.04444651f, -0.00099114f, 0.00781566f, 
    -0.03208626f, 0.03263061f, 0.00746554f, 0.06276517f, -0.05590757f, -0.05320715f, 0.00459838f, -0.04941364f, 
    0.02019433f, -0.00593917f, 0.05574145f, -0.04560485f, 0.01564391f, 0.02117553f, -0.00078400f, -0.01053547f, 
    0.00468555f, 0.03250381f, 0.06256756f, 0.00787895f, -0.03611298f, 0.02753770f, 0.06153166f, -0.02150356f, 
    -0.01916038f, -0.07293019f, 0.02967755f, 0.02730079f, 0.05031471f, -0.00690303f, -0.07225931f, 0.00199911f, 
    -0.06901295f, 0.03658573f, -0.04497699f, -0.05255105f, 0.03913247f, -0.02060724f, -0.07726841f, -0.01212944f, 
    0.06370477f, 0.00124787f, -0.06340087f, 0.02859529f, -0.04166849f, 0.04706668f, 0.02797101f, 0.06710167f, 
    0.06059415f, -0.07414386f, -0.01752135f, -0.03786715f, 0.01788599f, -0.02489006f, 0.05599883f, 0.01654491f, 
    -0.03657341f, -0.03476382f, 0.02307463f, -0.07041162f, 0.01529422f, -0.02143225f, -0.00546809f, -0.04939127f, 
    -0.08211876f, -0.02164908f, -0.05996940f, -0.04203714f, 0.01423784f, 0.03028565f, 0.02171388f, -0.00762431f, 
    -0.05570681f, -0.05734189f, -0.05061997f, 0.04757432f, -0.00124071f, 0.01143391f, -0.01729552f, 0.03698813f, 
    -0.07491062f, 0.04583196f, -0.06676590f, -0.06142959f, 0.05617777f, -0.04274202f, -0.06659605f, -0.03090931f, 
    0.07335626f, 0.03207099f, 0.08441240f, 0.22267802f, -0.08183330f, 0.12243733f, 0.04635515f, -0.08423632f, 
    0.08735007f, 0.01233320f, 0.14966361f, 0.09462875f, -0.10894436f, 0.03358148f, 0.07382482f, -0.04382245f, 
    0.10874087f, 0.04747409f, 0.11940228f, 0.02001927f, -0.06389038f, -0.08304141f, 0.16199160f, 0.09324711f, 
    -0.08401744f, 0.04559927f, 0.00306734f, 0.07000470f, -0.09558205f, 0.00972425f, 0.13791229f, -0.02035133f, 
    0.08410180f, -0.05963442f, -0.01176654f, -0.13896196f, -0.33130208f, 0.04240359f, -0.05956191f, -0.04521470f, 
    -0.05383483f, -0.14972548f, 0.06511396f, 0.01648606f, -0.03909328f, 0.11160099f, -0.02093750f, 0.15166120f, 
    -0.04284916f, -0.03020255f, 0.01008445f, -0.02034166f, 0.15102200f, 0.01361940f, 0.05943584f, 0.04366795f, 
    -0.01964888f, 0.09126370f, -0.01950999f, 0.00443490f, -0.08251843f, -0.03315838f, -0.02185162f, -0.09275575f, 
    -0.09699403f, -0.07302637f, -0.04563162f, -0.03741447f, 0.08970214f, 0.09219957f, 0.03429944f, -0.00485933f, 
    -0.00718609f, -0.16593646f, 0.08376431f, 0.12191787f, 0.07363468f, 0.14470975f, 0.03406028f, 0.08037399f, 
    0.08829715f, 0.00447451f, -0.10142178f, -0.03689478f, -0.02252201f, 0.12902533f, 0.18863583f, -0.03689527f, 
    -0.08345380f, 0.00112902f, 0.02898283f, 0.01489309f, 0.11667707f, -0.11165189f, 0.00784560f, -0.11550182f, 
    -0.02056641f, -0.04964110f, -0.20338793f, -0.00843206f, 0.07617184f, -0.08773209f, 0.04669442f, 0.09607408f, 
    0.03583979f, 0.02139452f, 0.05601263f, -0.07118680f, 0.03976110f, -0.16109000f, 0.20607175f, 0.09893157f, 
    -0.07664164f, 0.03469456f, -0.06609125f, -0.06611265f, -0.07241204f, -0.17150079f, 0.01502594f, -0.05952420f, 
    -0.02445677f, -0.02393676f, 0.31348172f, 0.14526352f, 0.04553651f, 0.14138144f, 0.01473046f, 0.04585739f, 
    0.05296333f, 0.07263646f, 0.11593742f, 0.02524449f, 0.08452763f, 0.06478044f, -0.10465080f, -0.08592936f, 
    0.06890861f, 0.06186613f, -0.02540246f, -0.03686873f, -0.04476479f, 0.01559830f, -0.04019893f, -0.09058378f, 
    -0.07944737f, -0.03785381f, 0.12990107f, -0.06727886f, 0.03621395f, 0.02129952f, -0.03279643f, 0.01238113f, 
    0.01869210f, -0.02418205f, 0.02859256f, 0.10873198f, -0.32304177f, -0.11245333f, 0.06713489f, 0.03640300f, 
    0.01296453f, -0.08289438f, -0.03961100f, 0.00564852f, 0.02389623f, 0.03195254f, 0.01135306f, -0.03452865f, 
    -0.32194561f, 0.20477879f, 0.09715822f, -0.04520439f, -0.01397995f, 0.13364525f, -0.02305933f, 0.01239685f, 
    0.00925676f, 0.02632739f, -0.03074396f, -0.02657228f, 0.01549562f, 0.01827749f, 0.05993573f, -0.00256591f, 
    -0.13147132f, 0.09951084f, 0.11310413f, 0.13372897f, 0.01389364f, 0.02081053f, 0.06206177f, 0.08955576f, 
    0.10294402f, 0.10973688f, 0.01762032f, -0.15778856f, -0.06739369f, 0.01263452f, 0.07497913f, -0.03469247f, 
    0.03033487f, -0.07728304f, 0.14212543f, 0.10558252f, 0.08298081f, 0.07659505f, -0.03424642f, -0.01020880f, 
    -0.07411326f, 0.00982171f, -0.10296784f, -0.05998589f, -0.09391606f, -0.00700683f, -0.03889523f, 0.01358415f, 
    0.18417361f, 0.01378577f, -0.09379921f, -0.09483770f, 0.01928816f, 0.07865678f, 0.07117225f, -0.01415638f, 
    -0.03370344f, -0.00064911f, 0.05991593f, 0.03382099f, 0.23527119f, -0.23858927f, 0.01900890f, 0.01109946f, 
    0.00908792f, -0.11845417f, 0.13020138f, 0.05805672f, 0.00537431f, 0.15418509f, 0.14204453f, 0.01421047f, 
    -0.12917064f, -0.02164374f, -0.05727497f, -0.09623551f, -0.00169634f, 0.10390977f, -0.07263763f, 0.16422413f, 
    -0.09332576f, -0.01574188f, 0.11675195f, 0.06502838f, 0.30771473f, 0.08672813f, 0.06874502f, 0.08647476f, 
    -0.25095239f, 0.05620687f, -0.06574966f, 0.02439992f, 0.06051814f, 0.06281367f, -0.00219334f, 0.13898925f, 
    0.07305150f, -0.31318051f, 0.03645932f, -0.11767307f, -0.09683657f, 0.00042811f, 0.11075211f, -0.00847254f, 
    -0.04582668f, 0.03179980f, 0.00581217f, 0.00621905f, -0.08837316f, 0.01347744f, 0.07917796f, 0.25729662f, 
    -0.00754159f, -0.00427960f, 0.07254520f, 0.08388902f, 0.14529407f, -0.05789834f, -0.19094999f, -0.03996455f, 
    0.33128577f, -0.14015208f, 0.02648272f, -0.12951961f, -0.07950117f, -0.06591579f, -0.01032879f, 0.02599827f, 
    0.04285774f, 0.11088047f, -0.01844519f, 0.05797067f, 0.03715331f, -0.07149360f, 0.09192055f, -0.16755857f, 
    -0.01419062f, 0.10741669f, 0.01383761f, -0.02582727f, 0.09102841f, -0.06622776f, 0.09369079f, 0.08462156f, 
    -0.12518130f, 0.05009000f, 0.01156840f, -0.03995905f, 0.11746055f, 0.09114265f, -0.04500405f, 0.02868160f, 
    0.05861480f, -0.01275580f, 0.02883436f, 0.02445369f, 0.17963363f, -0.22318891f, -0.08738005f, -0.03951323f, 
    0.00226491f, 0.00350274f, -0.07514956f, 0.10824639f, -0.01828085f, -0.06667885f, -0.05052675f, -0.07600409f, 
    0.10070866f, 0.10412238f, 0.01171569f, -0.12743577f, -0.07557452f, 0.06670032f, 0.13183443f, -0.06798086f, 
    0.06414914f, 0.08050207f, -0.07988438f, 0.10278827f, -0.29896319f, 0.27147272f, 0.03502911f, 0.07894460f, 
    -0.02441973f, 0.02063611f, -0.00294079f, -0.05373495f, -0.03474076f, -0.11405104f, 0.06189348f, 0.05880344f, 
    0.47155288f, -0.24847694f, -0.18524688f, 0.12844764f, 0.05040057f, 0.05788194f, 0.03445733f, 0.06499434f, 
    0.15859334f, 0.14726734f, -0.06379840f, 0.02237850f, -0.00320744f, -0.27839386f, -0.30272737f, 0.18181476f, 
    0.09219228f, 0.04886050f, -0.08937217f, 0.04797612f, 0.08807155f, 0.03321382f, 0.13358879f, 0.03236463f, 
    0.29429069f, -0.11614250f, -0.00692828f, 0.01362471f, 0.00334709f, -0.01626067f, -0.00055135f, 0.01492539f, 
    0.06428877f, 0.17772976f, -0.01423742f, -0.05033920f, -0.03994649f, -0.20321153f, 0.15669581f, -0.02210726f, 
    0.11087915f, 0.10355474f, 0.18458171f, 0.07569563f, 0.02661061f, 0.00063516f, 0.06523006f, 0.03357028f, 
    -0.37356666f, 0.14293204f, 0.04179146f, 0.00549496f, 0.00650776f, -0.01040674f, -0.06345328f, -0.05525436f, 
    0.06348413f, 0.05107989f, -0.11348326f, -0.18944205f, -0.30524987f, 0.28843188f, 0.03715651f, -0.03335268f, 
    0.14083204f, 0.11937559f, 0.02951386f, -0.01183209f, 0.08070537f, 0.01391570f, -0.01856382f, 0.00779383f, 
    0.11821254f, -0.09864498f, 0.17354457f, 0.14213517f, 0.07786737f, -0.02906039f, 0.05261509f, 0.01496351f, 
    0.05889929f, 0.05070537f, 0.02093531f, 0.16193809f, -0.01441632f, 0.12433478f, -0.04271962f, -0.03161241f, 
    0.07148989f, -0.00519350f, -0.06190104f, -0.06787591f, -0.02991584f, -0.09044296f, 0.01052367f, -0.13080357f, 
    0.18641560f, 0.33171698f, 0.04994078f, 0.03953604f, 0.11022373f, 0.09904072f, -0.00559468f, 0.01604773f, 
    0.03126747f, -0.05625809f, -0.08034824f, 0.08144888f, 0.15140285f, -0.11982554f, -0.19927439f, -0.29489189f, 
    -0.06898644f, -0.07667764f, 0.04662984f, 0.00033472f, 0.05244232f, -0.02554832f, 0.01293226f, 0.02662757f, 
    -0.28816280f, 0.03906682f, 0.07218149f, -0.05869630f, 0.04909465f, 0.09964299f, 0.08273900f, 0.05173498f, 
    0.01769787f, 0.00089224f, 0.09153090f, -0.02761828f, 0.25083417f, 0.09996153f, -0.10605707f, 0.05981783f, 
    -0.14081414f, -0.01844236f, -0.06185043f, -0.03595033f, -0.13801678f, -0.04016168f, 0.02524242f, -0.07115928f, 
    0.14251910f, -0.05140837f, 0.01233877f, 0.14147700f, -0.07855090f, -0.11595497f, 0.10486718f, -0.00066524f, 
    -0.03214823f, 0.10566353f, 0.00296435f, 0.09626161f, 0.28459463f, 0.26432270f, -0.07039955f, 0.12600809f, 
    0.09066098f, -0.09295496f, 0.06179978f, -0.07636490f, -0.01322480f, -0.00313257f, -0.00461431f, -0.04499826f, 
    -0.15540178f, -0.17242038f, 0.00487289f, 0.04492263f, -0.01232799f, -0.00635493f, 0.00128304f, 0.06492210f, 
    -0.00661759f, -0.11015448f, 0.06175426f, 0.12308968f, 0.49364501f, -0.41791770f, 0.07864935f, -0.05071919f, 
    0.07388017f, 0.00323207f, -0.08237046f, 0.04417678f, -0.09764330f, 0.09270070f, 0.04466211f, -0.00057111f, 
    -0.21550611f, 0.39912716f, 0.16560388f, 0.05626695f, -0.09544118f, -0.03407429f, -0.01545548f, -0.02730629f, 
    -0.15401670f, -0.02881779f, -0.02155725f, -0.04876525f, 0.07149876f, 0.16748534f, 0.24064296f, -0.05894341f, 
    -0.01006124f, -0.06544617f, 0.04994449f, -0.14110129f, 0.04177458f, 0.05822521f, -0.02868871f, 0.07274127f, 
    -0.10693873f, -0.06804604f, -0.19289961f, 0.03170132f, 0.05401742f, -0.00810858f, 0.07365502f, 0.01565940f, 
    0.10493381f, 0.15684879f, -0.03789342f, -0.12485846f, -0.03611477f, 0.20569494f, 0.08716113f, 0.05335770f, 
    0.05153591f, -0.02939299f, -0.04716477f, 0.00108706f, -0.07697601f, -0.13237016f, 0.00655944f, 0.16109090f, 
    -0.16688220f, 0.16472174f, 0.10822479f, -0.00350669f, -0.13530424f, -0.05135974f, 0.12619847f, 0.13980305f, 
    0.07146496f, 0.08666514f, 0.09662513f, 0.07776450f, -0.34819528f, 0.19375180f, 0.25132471f, -0.01647091f, 
    -0.17355230f, -0.06466903f, 0.07812471f, -0.02691498f, -0.03006187f, 0.05252328f, 0.01822576f, 0.11999179f, 
    0.28411013f, 0.06509306f, 0.06681265f, 0.10681932f, 0.10021724f, -0.07742541f, -0.14795782f, 0.18319577f, 
    0.07241541f, 0.08847883f, -0.09481559f, -0.04769282f, -0.18778613f, -0.07425808f, -0.00644894f, 0.00510978f, 
    -0.05417313f, -0.08485020f, -0.10142700f, -0.02007444f, 0.04355545f, 0.10203362f, -0.00935211f, 0.09123490f, 
    0.04602293f, 0.15870337f, -0.22933750f, 0.09559961f, 0.06162030f, 0.08812138f, -0.00993429f, -0.09379078f, 
    0.05295330f, -0.06099224f, 0.01695460f, 0.05894861f, -0.13940251f, -0.25815317f, 0.01892601f, 0.28679639f, 
    -0.05598129f, -0.00792464f, -0.01450806f, -0.04528867f, 0.02926181f, 0.00388941f, 0.02476609f, -0.02351234f, 
    -0.06915133f, 0.20500256f, 0.06056850f, 0.06165884f, 0.02037611f, 0.00557933f, 0.12624809f, -0.04435664f, 
    -0.03824379f, -0.01523139f, -0.06422879f, -0.06268526f, -0.09359667f, -0.01749201f, -0.06146675f, -0.11923206f, 
    0.03974468f, 0.01723102f, -0.01339444f, -0.12758072f, 0.08348052f, 0.06395923f, 0.10381044f, 0.00100970f, 
    0.03938164f, -0.02449996f, 0.22769803f, -0.03944714f, -0.02152188f, 0.17377183f, 0.04050765f, -0.13584760f, 
    0.06223480f, 0.12866299f, -0.05981122f, 0.10083812f, -0.00489386f, -0.05612907f, -0.08488151f, 0.06559001f, 
    -0.16711965f, -0.02594917f, 0.02935586f, 0.03077265f, 0.12130097f, 0.08656232f, 0.13334586f, 0.07410313f, 
    0.00643583f, 0.07073175f, 0.17656663f, -0.28535497f, 0.09125001f, -0.01038610f, -0.05888153f, -0.06063082f, 
    -0.03202049f, -0.04105378f, 0.01537913f, -0.07906175f, -0.34927955f, 0.11423936f, 0.02622314f, 0.15112108f, 
    0.05002875f, -0.14867692f, 0.02001556f, -0.04753085f, 0.06981691f, 0.07282174f, -0.15470645f, 0.05591134f, 
    -0.08547354f, 0.09198996f, -0.17630067f, 0.12941845f, -0.08821502f, 0.21482772f, 0.01821999f, 0.03074486f, 
    0.14686339f, -0.07032128f, -0.06321183f, -0.05194604f, 0.19261339f, 0.02063779f, 0.06285790f, 0.21903290f, 
    -0.15545417f, -0.00441307f, -0.10476493f, 0.06740601f, 0.10220250f, -0.08314653f, 0.08422659f, 0.03130409f, 
    0.00113357f, -0.00656301f, -0.03328826f, -0.02355914f, 0.03995937f, 0.02691748f, -0.00105178f, 0.00561495f, 
    -0.04310353f, -0.02326698f, 0.03877072f, 0.05761335f, 0.03796689f, -0.04938106f, 0.03504547f, 0.00215018f, 
    0.01318555f, -0.04773413f, -0.05154841f, -0.02690919f, 0.03479997f, -0.07572364f, -0.05154454f, -0.03683304f, 
    -0.05555607f, -0.02764651f, 0.02026315f, 0.04297796f, 0.02312080f, 0.04644627f, -0.03954978f, -0.03191698f, 
    0.00696432f, -0.03411718f, 0.01519837f, 0.01846251f, 0.05084217f, -0.03713620f, 0.01345519f, 0.00274313f, 
    0.03462276f, -0.07286078f, 0.00772030f, -0.02004440f, -0.01961990f, -0.01028098f, 0.01864951f, -0.00356133f, 
    0.03079184f, -0.05389009f, 0.02441037f, 0.02605982f, -0.07206740f, -0.05782608f, 0.00159625f, 0.01277610f, 
    0.05208478f, 0.02956798f, -0.04189583f, -0.04706614f, 0.01089850f, 0.05495751f, -0.07417900f, 0.04331056f, 
    0.05656441f, -0.05049324f, -0.00321756f, 0.06126949f, -0.04798415f, 0.05859113f, -0.03028614f, -0.05634087f, 
    -0.07055774f, 0.03278244f, -0.03839071f, 0.02507409f, -0.04452471f, -0.01224755f, 0.00474543f, -0.08302610f, 
    0.05155403f, -0.03245589f, 0.02275546f, 0.04348656f, -0.03323063f, -0.05800489f, 0.01884398f, -0.03056964f, 
    0.01708660f, -0.07056177f, 0.05931670f, 0.02280136f, -0.03778940f, 0.02197263f, 0.05204472f, -0.02013269f, 
    -0.03993038f, 0.02550495f, 0.03196930f, -0.08398277f, -0.04352017f, -0.05324072f, -0.08254979f, -0.07303729f, 
    0.00091548f, -0.07439449f, -0.02555903f, -0.03461947f, -0.07584755f, -0.05236828f, 0.03208537f, 0.01228504f, 
    -0.02165431f, -0.01487965f, 0.02278870f, -0.05767034f, 0.04398845f, -0.00658180f, -0.07935556f, 0.01803356f, 
    0.04561624f, 0.03431740f, -0.02576474f, -0.05011066f, 0.00035667f, -0.08078844f, 0.02755662f, -0.05051750f, 
    -0.05729040f, -0.03271842f, -0.05812495f, 0.05276581f, -0.05339980f, -0.01585619f, -0.08101884f, 0.00899931f, 
    -0.05007865f, 0.06394748f, -0.03986793f, -0.08098467f, 0.05978188f, 0.05804725f, -0.05992237f, -0.04917210f, 
    0.04748373f, 0.04715891f, -0.04156778f, 0.05860962f, 0.02861211f, 0.05486002f, -0.05781343f, -0.04751575f, 
    -0.04023243f, 0.02223151f, -0.08060753f, 0.03100794f, 0.03794453f, -0.07521265f, 0.04072744f, -0.04088371f, 
    -0.02279352f, -0.07788903f, -0.06305394f, 0.04806929f, 0.00867599f, 0.05226455f, -0.02733495f, -0.02607475f, 
    0.05873948f, -0.04834566f, -0.02563617f, -0.01015397f, -0.07081712f, -0.00300223f, -0.03375870f, -0.04627275f, 
    0.02631286f, -0.00637913f, -0.08490843f, -0.05960122f, -0.06857681f, -0.07956995f, -0.02888105f, 0.00580036f, 
    -0.00475649f, -0.01307759f, -0.00671233f, -0.02810644f, 0.04091727f, -0.05080005f, 0.02868678f, 0.04724107f, 
    0.41663018f, -0.00719818f, -0.06833874f, 0.05164072f, 0.02642986f, -0.00762673f, -0.23509960f, -0.02239608f, 
    0.02280126f, 0.09176332f, 0.11470456f, 0.04317746f, -0.02546223f, 0.09683076f, 0.16303471f, -0.23528956f, 
    -0.04348419f, 0.06921133f, -0.00193254f, 0.01592191f, 0.01246420f, 0.01346795f, 0.18031535f, -0.00046233f, 
    0.09372111f, -0.05201551f, -0.05222123f, -0.11928783f, -0.03329542f, 0.06116777f, 0.06899911f, -0.08263475f, 
    0.10345505f, -0.13293335f, -0.06192911f, -0.15282853f, 0.04665192f, 0.03471573f, -0.08217765f, -0.02127751f, 
    0.17757323f, 0.04337550f, 0.21216933f, -0.08957551f, 0.00359120f, -0.04398611f, -0.06799721f, -0.00380598f, 
    -0.22962038f, 0.11078573f, 0.04009210f, -0.02022223f, 0.16469350f, 0.10208566f, -0.01998704f, 0.07178783f, 
    -0.00000187f, 0.07074131f, 0.04513939f, 0.10556532f, 0.34175572f, -0.04024300f, -0.23172717f, 0.03943893f, 
    -0.13497618f, -0.03717015f, -0.11619031f, -0.00193237f, 0.08719579f, -0.04837437f, -0.02401455f, -0.05840011f, 
    -0.09289096f, -0.06935411f, 0.36779171f, -0.19463152f, 0.04554627f, -0.06768003f, 0.08921397f, 0.15927348f, 
    -0.12101535f, 0.05691870f, 0.09534076f, 0.06255700f, -0.09931021f, -0.29413584f, -0.10159075f, 0.23608769f, 
    0.01821376f, -0.05985088f, 0.06527671f, 0.04414633f, 0.06308993f, -0.04956700f, -0.07559621f, -0.02398111f, 
    0.17953502f, 0.00882943f, 0.07140247f, -0.01681861f, 0.03108324f, -0.00509897f, 0.04426437f, 0.07267737f, 
    0.11113631f, 0.12288546f, 0.05232534f, 0.08788119f, 0.27080220f, -0.24105917f, 0.03539519f, -0.05530137f, 
    -0.13158403f, 0.06017213f, -0.12766999f, 0.07163638f, 0.04746152f, -0.08451611f, 0.05542300f, 0.01775196f, 
    0.07717207f, 0.24628825f, 0.25017497f, 0.12391744f, -0.13234708f, -0.07048996f, -0.10315920f, -0.02745388f, 
    0.03836391f, 0.06106263f, 0.00066538f, 0.00180320f, 0.11336702f, -0.11384960f, -0.20246533f, 0.13173828f, 
    -0.17390190f, -0.00883603f, -0.07049860f, -0.07356702f, 0.01024133f, -0.05851579f, 0.02098940f, -0.05069764f, 
    0.03215963f, 0.06035420f, -0.00579620f, 0.15328848f, 0.07937820f, -0.03217691f, 0.01979543f, 0.13253959f, 
    -0.01733296f, -0.13973118f, -0.05352140f, -0.01012253f, 0.06783800f, -0.01817336f, -0.00917197f, -0.02728382f, 
    -0.04481469f, 0.03184804f, -0.10475449f, -0.00776196f, -0.06389118f, 0.03834575f, -0.10711075f, 0.07693143f, 
    0.14102778f, 0.01186066f, -0.08321197f, -0.02543779f, -0.09860004f, -0.14549749f, -0.10502043f, -0.04692698f, 
    -0.02994174f, 0.11076108f, -0.06089425f, -0.02735205f, -0.03543522f, 0.06325167f, -0.04832803f, 0.07669123f, 
    -0.07288748f, -0.01225513f, 0.01698355f, -0.01308553f, 0.01661400f, 0.17568389f, 0.08069440f, 0.15398543f, 
    -0.04467951f, 0.06159429f, 0.24062815f, -0.15344195f, -0.00198697f, -0.10244045f, 0.10509345f, 0.01884344f, 
    -0.07780423f, -0.08841767f, 0.00027238f, 0.00392764f, 0.02589498f, -0.29826671f, -0.17928265f, 0.11320726f, 
    0.01918483f, -0.07426585f, 0.02358124f, 0.05245451f, 0.06528430f, 0.01065639f, -0.16563192f, -0.03364964f, 
    -0.07720938f, 0.00064165f, -0.08243780f, 0.14755477f, 0.12789927f, 0.17721014f, 0.03330138f, -0.12714288f, 
    -0.05390822f, 0.04356526f, -0.03364435f, 0.00397066f, 0.33091009f, -0.04074506f, -0.24433485f, -0.05926279f, 
    0.15213676f, 0.05085007f, -0.20648117f, 0.07502943f, 0.02467180f, -0.02932083f, -0.01907498f, -0.10430893f, 
    -0.01088154f, -0.19300121f, 0.01799783f, 0.01998093f, -0.01603246f, 0.08376532f, 0.04053607f, -0.19907404f, 
    0.15581340f, -0.07951768f, 0.10011674f, 0.14995402f, -0.10795741f, 0.06821640f, 0.18994486f, 0.01269378f, 
    0.27088684f, 0.02926311f, -0.00417619f, 0.04628910f, 0.01913142f, -0.10575620f, 0.09008056f, -0.01557168f, 
    -0.00674930f, 0.27695370f, 0.14167489f, -0.00012144f, -0.05562491f, 0.04670519f, -0.14922072f, -0.03618162f, 
    0.02823782f, -0.02503228f, 0.07860672f, 0.01413890f, -0.03042465f, 0.06682736f, -0.01515365f, -0.45849645f, 
    -0.00463640f, -0.05437598f, -0.03115446f, 0.04781589f, -0.04931840f, 0.12087300f, 0.04309007f, 0.18254682f, 
    -0.18208319f, 0.00090115f, 0.13228464f, -0.09509443f, -0.01093389f, 0.07902551f, 0.01444063f, -0.06929432f, 
    0.03426421f, 0.04370590f, 0.05842746f, 0.01532107f, -0.03177872f, 0.03591248f, -0.10782845f, -0.02961673f, 
    0.09534899f, 0.06241911f, 0.10051499f, -0.02312276f, -0.02787235f, 0.03510511f, -0.10176282f, 0.09064167f, 
    0.04714030f, -0.05180977f, -0.33154723f, -0.03647691f, -0.00892325f, -0.04678504f, 0.11441607f, 0.07700057f, 
    0.05324483f, -0.00168018f, 0.05882779f, -0.03626933f, 0.25425452f, 0.09912342f, 0.01265509f, 0.00017795f, 
    0.15096349f, -0.09426103f, -0.02425432f, -0.03182843f, -0.04661779f, -0.02178208f, 0.01671317f, 0.05777178f, 
    -0.05057780f, -0.00512724f, -0.14031473f, 0.16741394f, 0.04119443f, -0.04045857f, 0.07300763f, -0.06121118f, 
    0.18485920f, 0.10316058f, 0.11452723f, 0.11603194f, 0.56504327f, -0.23472518f, -0.00522713f, -0.00073739f, 
    -0.02115896f, 0.12783687f, -0.02140966f, 0.04347673f, 0.02277783f, -0.09527108f, 0.06075660f, 0.05764206f, 
    -0.16287310f, 0.10364604f, 0.07907964f, 0.04693272f, 0.05718760f, -0.15341233f, -0.00510348f, 0.01721341f, 
    -0.06849524f, 0.02058505f, 0.05851915f, 0.03670275f, -0.05320496f, 0.10046273f, 0.07277329f, -0.01365466f, 
    0.06648578f, -0.16462982f, -0.05963361f, -0.02457837f, 0.04250570f, 0.03933496f, -0.06806870f, -0.02445676f, 
    -0.01912812f, -0.03782964f, -0.17415707f, -0.05594630f, 0.04848571f, 0.06290274f, 0.10534849f, 0.12575480f, 
    0.03252314f, -0.07954113f, 0.12041871f, 0.05319015f, -0.02966628f, 0.31638843f, -0.01133054f, -0.10221336f, 
    -0.13030101f, -0.04066373f, -0.03326768f, -0.01592322f, 0.06155083f, 0.07279760f, -0.06094575f, -0.10384488f, 
    0.30877417f, 0.00819037f, -0.14029147f, -0.01704034f, -0.05888109f, 0.03355980f, -0.01947410f, 0.17221735f, 
    -0.02599824f, 0.01470893f, 0.10634743f, 0.09845959f, 0.05574311f, -0.16813572f, 0.18064252f, 0.03005382f, 
    0.06380597f, -0.09664001f, 0.03136740f, 0.05785589f, -0.01022795f, 0.07859187f, 0.08166400f, 0.02064118f, 
    -0.26797903f, 0.26963222f, -0.07099521f, -0.04095358f, 0.05525805f, 0.06354774f, -0.10274994f, 0.10173015f, 
    -0.03617149f, -0.06763098f, 0.05857438f, -0.13816148f, 0.36519989f, -0.13316330f, -0.07550679f, 0.27220634f, 
    -0.14026643f, -0.01018578f, 0.01160252f, 0.00657990f, -0.04229129f, -0.01188708f, 0.00341235f, 0.13372661f, 
    0.07372410f, -0.09551849f, 0.02183101f, -0.09178574f, -0.09808952f, -0.12731421f, -0.06162203f, 0.04298418f, 
    -0.09882709f, -0.02495928f, -0.04977116f, -0.02799081f, -0.09084536f, -0.20307605f, 0.12649906f, 0.43832687f, 
    0.16291824f, 0.05567057f, 0.00279535f, -0.01006228f, 0.02621615f, -0.05123023f, 0.01732230f, 0.03742412f, 
    0.35229045f, 0.02548549f, 0.04018627f, 0.02092291f, -0.08233863f, -0.06635867f, 0.00649815f, -0.05908730f, 
    -0.02316954f, 0.04673486f, 0.03342748f, -0.04007755f, 0.14983875f, -0.18775295f, -0.02857374f, -0.07083759f, 
    -0.01912078f, -0.02024710f, 0.02049437f, 0.14373338f, 0.15617730f, 0.01100849f, 0.11291561f, 0.05821190f, 
    -0.04665053f, 0.09951629f, 0.00150936f, -0.01725765f, 0.05930379f, 0.02795188f, -0.14791834f, 0.07208356f, 
    0.05777585f, -0.00727280f, -0.01230885f, -0.13940752f, -0.21258600f, -0.12425911f, 0.12048662f, 0.06318478f, 
    -0.00062305f, 0.07396729f, -0.04625421f, 0.13130611f, 0.03210999f, 0.01507433f, 0.02052113f, -0.00457030f, 
    0.08940817f, -0.01702420f, 0.03637843f, -0.07994299f, -0.09288564f, 0.06591642f, 0.09724041f, 0.10547796f, 
    -0.09829908f, 0.05334806f, -0.03917467f, -0.00124806f, -0.32975525f, 0.35384312f, 0.04409429f, 0.14297529f, 
    -0.00133724f, 0.02438736f, -0.01476815f, 0.02253923f, 0.01961081f, -0.07467111f, 0.01463015f, 0.04160691f, 
    0.51139331f, -0.24369405f, -0.07429106f, 0.08425768f, 0.08062652f, 0.07948361f, -0.05244792f, -0.01871309f, 
    -0.01809402f, 0.03506179f, 0.03787902f, 0.01766466f, -0.03616856f, -0.01982775f, -0.22450222f, 0.09327132f, 
    0.01348843f, 0.12810478f, -0.03814511f, 0.14845294f, 0.05292477f, 0.11771958f, 0.13187638f, 0.00993318f, 
    -0.01602870f, -0.12451577f, 0.10877888f, 0.04936779f, -0.02486606f, -0.02839422f, -0.06218550f, -0.06462762f, 
    0.02611408f, 0.10078660f, -0.06979951f, -0.10162561f, -0.01272395f, -0.16099657f, -0.00375854f, 0.15126115f, 
    0.07990840f, -0.07843399f, 0.11936792f, 0.07791805f, 0.02867661f, -0.17818289f, 0.05168530f, 0.05960489f, 
    -0.41962689f, 0.06421678f, 0.05127709f, 0.00312997f, 0.02760857f, 0.07189886f, -0.04038676f, -0.01897018f, 
    0.10831269f, 0.01130444f, -0.05621857f, -0.08919713f, -0.26883075f, 0.20914176f, 0.05598246f, 0.04448447f, 
    0.00629332f, 0.08608399f, -0.02393139f, 0.01547906f, 0.04352896f, -0.04024656f, 0.05580818f, 0.06383530f, 
    0.23499250f, -0.12958676f, 0.11523942f, 0.00937901f, -0.04173304f, -0.05513027f, -0.00640441f, -0.02159619f, 
    -0.00779947f, 0.03769162f, 0.02544030f, 0.09934101f, -0.23726527f, 0.03748223f, -0.02806993f, -0.12541753f, 
    0.11812733f, -0.03163771f, -0.08781382f, -0.03860274f, -0.03888692f, 0.08901431f, 0.01140488f, 0.04339131f, 
    -0.09020809f, 0.42246804f, -0.07627848f, 0.19834976f, 0.08465526f, 0.05516980f, 0.01567513f, 0.04646489f, 
    0.02343169f, -0.02406383f, -0.05006881f, 0.11247749f, -0.07325736f, 0.05664325f, 0.13408345f, -0.37936074f, 
    -0.01861743f, -0.05495666f, -0.01150835f, -0.04451378f, 0.02424104f, 0.04769463f, 0.02496449f, -0.01804055f, 
    -0.29165310f, 0.14688998f, -0.00912454f, 0.05968278f, 0.05197179f, 0.12481771f, 0.09808972f, -0.00054753f, 
    -0.02282205f, -0.06736213f, -0.06413017f, 0.02748909f, 0.05722701f, 0.02593340f, -0.00588448f, 0.03880115f, 
    0.00756023f, -0.07767586f, -0.00233006f, 0.02289651f, -0.10774671f, -0.10849082f, 0.01853361f, -0.14890938f, 
    0.14671281f, -0.01224044f, 0.05536691f, -0.02137875f, -0.08523364f, -0.00530688f, 0.12919767f, 0.00207671f, 
    0.00467606f, 0.09581332f, 0.04331688f, 0.28221986f, 0.17650917f, 0.18933901f, 0.00089319f, -0.07534656f, 
    0.01985876f, -0.09964535f, 0.12185420f, -0.02220896f, -0.00099542f, 0.00629129f, 0.13066283f, 0.02030883f, 
    0.05549097f, 0.11089654f, -0.04668007f, -0.17537627f, 0.16171826f, -0.06596322f, 0.01032343f, 0.08102533f, 
    0.07791256f, -0.09997932f, 0.04788129f, 0.10927822f, 0.20338018f, -0.28785908f, 0.06847497f, 0.07052694f, 
    0.07715592f, -0.00892842f, -0.10703321f, 0.09388176f, -0.05564266f, 0.15751828f, 0.06313068f, 0.03433698f, 
    -0.36145681f, 0.34507117f, 0.12092355f, 0.01671549f, 0.02550382f, 0.09839682f, 0.04648250f, -0.14546593f, 
    0.09203143f, -0.02538413f, 0.09092166f, -0.00994213f, 0.11180932f, 0.10256658f, 0.19593264f, 0.03800766f, 
    -0.01444603f, -0.08672410f, -0.07372195f, -0.03443721f, 0.05298441f, -0.11700601f, 0.06740277f, 0.06095308f, 
    -0.06161926f, -0.04431917f, -0.02356250f, 0.03176028f, 0.04298672f, 0.03320738f, -0.04092468f, 0.00804050f, 
    0.02915893f, 0.01971307f, -0.02650645f, 0.05009897f, -0.00122619f, 0.05398802f, -0.06008654f, -0.01820080f, 
    -0.05919977f, -0.00077952f, 0.03841453f, -0.01312768f, 0.07072871f, 0.01789659f, 0.00791895f, -0.00982310f, 
    -0.06945376f, -0.05829557f, 0.03450707f, 0.05553559f, 0.01480186f, -0.01936434f, -0.01192280f, -0.03271586f, 
    -0.06433625f, -0.06203558f, 0.05166387f, -0.00053324f, -0.04376521f, -0.03857874f, 0.01282656f, -0.06812190f, 
    0.00550700f, -0.03794916f, -0.06696589f, 0.03553731f, 0.00028721f, -0.04393307f, 0.04602452f, 0.00030093f, 
    0.04585762f, -0.05640471f, -0.03142825f, -0.01577760f, 0.05626924f, -0.00133377f, 0.06891896f, 0.02078867f, 
    -0.04590463f, -0.03441910f, -0.06276680f, 0.01275177f, -0.06542563f, 0.01900286f, -0.06389931f, -0.03714151f, 
    -0.02011773f, -0.03881903f, 0.02046798f, -0.00316319f, -0.00569394f, 0.00295295f, -0.06263622f, -0.04610315f, 
    0.02767325f, -0.07650521f, -0.07123263f, -0.04561737f, -0.05853457f, -0.03990614f, -0.07176080f, -0.00587136f, 
    -0.04166743f, -0.05290995f, -0.05067679f, -0.02295369f, -0.01915163f, 0.03676286f, -0.02585811f, -0.02847086f, 
    -0.00015114f, -0.03536239f, -0.03393704f, 0.03625740f, -0.04554007f, -0.00636172f, -0.04268008f, 0.03446153f, 
    0.01663744f, 0.05259492f, 0.05125605f, -0.07801234f, -0.03193228f, 0.01188285f, 0.00982789f, -0.00702606f, 
    0.01337631f, -0.04129403f, 0.00871093f, 0.03962444f, -0.02144096f, 0.02992771f, 0.02997059f, 0.06699440f, 
    0.02515918f, -0.05128372f, 0.02776097f, -0.06866473f, 0.03768043f, 0.01048583f, -0.05901686f, -0.04671176f, 
    -0.05234292f, -0.00577881f, 0.05551810f, -0.07009971f, 0.04270457f, 0.06509328f, 0.03054239f, 0.05807035f, 
    0.06569641f, -0.02120574f, 0.06253541f, 0.02115605f, 0.04186881f, -0.03846781f, 0.00277065f, -0.06222823f, 
    0.05093460f, -0.00810792f, -0.02370921f, 0.03300658f, -0.01035242f, 0.05139985f, -0.06443086f, -0.07088176f, 
    0.04923185f, 0.02852907f, -0.02605736f, -0.04475594f, -0.03511573f, -0.04561557f, 0.04541010f, -0.03622891f, 
    -0.03723858f, -0.01685564f, 0.01695725f, -0.04660244f, 0.00434954f, -0.06836850f, 0.00558791f, -0.03755216f, 
    -0.03963616f, 0.05790912f, -0.02997508f, -0.02183441f, 0.05331630f, -0.03633897f, 0.06221730f, -0.07364614f, 
    -0.07380691f, 0.06508263f, -0.01208298f, -0.06646034f, 0.01735632f, 0.03691535f, -0.04955125f, 0.00852677f, 
    -0.06489064f, -0.06882428f, -0.06820250f, -0.00790410f, -0.03156002f, -0.02159107f, -0.00354130f, 0.01068769f, 
    0.01228213f, 0.03630343f, -0.02962852f, -0.01070190f, 0.01286265f, -0.05792461f, -0.06304911f, 0.01390721f, 
    -0.04281455f, -0.00894236f, -0.04258003f, 0.02770008f, 0.04472849f, -0.05511032f, -0.04870715f, -0.04435908f, 
    0.00654036f, -0.03257218f, 0.03674606f, 0.05183663f, 0.03843067f, -0.05994571f, 0.03088804f, 0.00778769f, 
    0.00285975f, -0.00096616f, 0.03776512f, -0.04986539f, 0.01832251f, -0.05800084f, -0.01967133f, 0.01453862f, 
    -0.05565400f, 0.02097553f, -0.06781219f, 0.01188054f, 0.00844949f, 0.00023001f, -0.00831797f, 0.03757328f, 
    0.01584936f, -0.05443626f, -0.04056993f, -0.05071371f, 0.03913315f, 0.02923889f, -0.03329292f, 0.00765261f, 
    0.02311950f, 0.03805443f, -0.05292124f, -0.02870748f, 0.01257280f, 0.04790543f, -0.03275276f, 0.02463686f, 
    -0.03608881f, 0.00803039f, 0.03482281f, 0.06493057f, -0.03920769f, -0.03588823f, -0.03321440f, 0.00005710f, 
    0.05944372f, 0.03310769f, -0.03602413f, 0.04260874f, -0.07911362f, -0.05483541f, -0.00724076f, -0.03065209f, 
    -0.04634062f, 0.04815634f, -0.03928381f, -0.04914666f, -0.04436550f, 0.04973982f, 0.06947640f, -0.06870489f, 
    0.05148156f, -0.04588407f, -0.06215585f, -0.02233566f, 0.03085885f, -0.04722136f, 0.06914175f, -0.05402605f, 
    0.03786571f, 0.02015465f, -0.03528644f, -0.05708157f, -0.01373729f, -0.04551785f, -0.03680215f, -0.06297116f, 
    -0.02565458f, -0.02337719f, 0.01200914f, -0.04330898f, -0.00784231f, -0.04914360f, 0.02083377f, -0.03216739f, 
    -0.01410831f, -0.02783768f, 0.05497936f, -0.06937619f, 0.00934111f, 0.03441339f, -0.04299743f, -0.04444610f, 
    0.02315687f, 0.05806884f, -0.00338225f, -0.04357992f, -0.05141087f, 0.05861238f, 0.04911896f, -0.05710929f, 
    -0.04322489f, 0.05279303f, 0.02196251f, -0.03011859f, 0.03583673f, 0.00604310f, -0.01156843f, 0.06613464f, 
    0.03079333f, -0.05204709f, 0.06285758f, 0.05705920f, -0.04451222f, -0.01060177f, 0.03602143f, 0.02888805f, 
    0.06893646f, 0.05360475f, -0.05875950f, -0.05119561f, -0.02575363f, 0.01051411f, -0.03526594f, 0.02814740f, 
    0.02779263f, -0.05869939f, -0.04895673f, -0.06094207f, -0.07220787f, -0.03596539f, -0.02268299f, 0.05591402f, 
    0.00510695f, -0.03228488f, 0.05249593f, 0.00329562f, -0.04189344f, 0.00283453f, -0.04407272f, -0.04385253f, 
    -0.05556347f, 0.03285978f, -0.02382007f, -0.00523526f, -0.05474574f, 0.03074377f, -0.02562944f, -0.02896186f, 
    -0.07911035f, -0.05230921f, 0.01500381f, -0.01354585f, -0.03224640f, -0.02637155f, -0.03086769f, 0.04672050f, 
    -0.05832460f, 0.05274585f, -0.04234904f, -0.03428931f, 0.02717540f, 0.01868357f, -0.04737573f, 0.01410099f, 
    -0.00535131f, -0.06885929f, 0.07014520f, 0.05939148f, 0.00043486f, 0.00798525f, -0.01711504f, 0.04265304f, 
    0.01790571f, -0.07487113f, 0.01905488f, 0.01027010f, 0.03865267f, 0.03824819f, 0.01201357f, -0.06867166f, 
    -0.05343853f, -0.00709262f, 0.09634010f, -0.01811082f, -0.04191439f, 0.07314078f, 0.05402867f, -0.11550717f, 
    -0.19354001f, -0.09381079f, 0.01179628f, -0.00488591f, 0.13019435f, 0.10781089f, -0.13341966f, -0.03034550f, 
    -0.10568323f, -0.15095721f, -0.15131828f, 0.03886134f, -0.02756773f, -0.06901549f, 0.04635926f, -0.02495524f, 
    0.39918590f, 0.04698317f, 0.12044807f, -0.13612968f, -0.15107132f, -0.01008473f, -0.03275581f, 0.00197839f, 
    -0.04498560f, -0.18768165f, 0.13790907f, -0.00902299f, -0.02853527f, 0.06806058f, 0.04603551f, 0.08675723f, 
    -0.16883650f, -0.05286640f, 0.02235506f, 0.09594871f, -0.07076567f, -0.04228877f, -0.03757643f, -0.09855382f, 
    0.20776466f, 0.03800671f, -0.09040249f, -0.15335664f, -0.04856393f, -0.04989998f, 0.00531923f, 0.12954926f, 
    -0.08801180f, -0.04502096f, -0.01811906f, -0.00340601f, -0.39464813f, -0.04837693f, -0.10031258f, -0.18144824f, 
    -0.00642119f, 0.06855018f, -0.14012329f, 0.01595644f, -0.06190804f, -0.02663037f, 0.02127554f, -0.06027437f, 
    -0.28612310f, -0.06546465f, 0.18055221f, 0.12947662f, -0.12161517f, -0.05902323f, 0.08345750f, 0.02108484f, 
    0.04765044f, -0.14231779f, 0.04621194f, -0.11224103f, -0.36136627f, -0.02669379f, 0.02295679f, -0.01016843f, 
    0.11651998f, -0.06329605f, 0.02754475f, -0.16120599f, 0.02949955f, -0.13401356f, -0.09340457f, -0.19993870f, 
    0.09873259f, 0.09851471f, 0.11063123f, 0.15870073f, -0.17944221f, -0.13420399f, -0.08361308f, -0.04606874f, 
    -0.09308077f, 0.01371833f, -0.06541120f, 0.05957083f, -0.03952131f, -0.27857211f, 0.00875168f, 0.04236371f, 
    0.02236107f, -0.02910025f, -0.14547947f, 0.00230352f, 0.01383218f, -0.09259675f, -0.11075255f, 0.01598031f, 
    0.16635373f, 0.15483634f, 0.28841871f, -0.16510685f, 0.05384338f, 0.02171912f, -0.00360194f, -0.08499239f, 
    -0.10519715f, 0.04468374f, 0.07349089f, 0.09991618f, -0.25389218f, -0.12426385f, -0.21027130f, -0.23124576f, 
    0.06448458f, 0.03245406f, -0.07282171f, 0.04032219f, -0.09736805f, -0.05704828f, 0.00446269f, -0.12654290f, 
    0.44080523f, 0.18256566f, -0.14335649f, -0.06486734f, 0.08095071f, -0.06574134f, -0.07620542f, 0.11027323f, 
    -0.05122839f, 0.08082036f, -0.05202998f, -0.00281792f, -0.06811732f, -0.02437625f, 0.00904511f, -0.06031351f, 
    0.05757752f, 0.07676031f, 0.01045806f, -0.04269762f, -0.14436583f, -0.03613624f, -0.04018312f, -0.00427462f, 
    -0.21224372f, -0.07540286f, -0.04549756f, -0.17815624f, 0.05385856f, -0.09905940f, 0.07131845f, -0.08264273f, 
    -0.02607360f, 0.08850522f, 0.00731898f, -0.10237198f, -0.17238164f, -0.19919634f, -0.20549901f, -0.04247843f, 
    -0.01030814f, 0.00288579f, -0.05856344f, 0.00436172f, 0.03737943f, -0.06644829f, 0.15277858f, 0.12142557f, 
    0.14869916f, -0.16249666f, -0.12522806f, 0.12923789f, -0.04702481f, 0.07808820f, 0.01110024f, -0.12050910f, 
    0.04245897f, 0.00891385f, -0.00460568f, -0.05155776f, -0.08309536f, 0.35658765f, 0.17052232f, -0.20312586f, 
    0.10067492f, 0.12158110f, 0.01282928f, -0.19733912f, 0.00598821f, -0.08965325f, 0.19547331f, 0.00622866f, 
    0.14139624f, 0.03022496f, 0.05047637f, 0.11644983f, -0.00484133f, 0.09403176f, -0.03831753f, 0.16728160f, 
    -0.01426232f, -0.15482508f, -0.08055016f, -0.11179402f, -0.25150576f, 0.27861986f, 0.12712628f, 0.00813679f, 
    0.09148088f, 0.04360973f, -0.00372844f, 0.04774218f, -0.00299045f, 0.11320502f, -0.02902308f, 0.10074369f, 
    -0.02999384f, 0.13118331f, 0.14594333f, 0.00835509f, 0.22385310f, -0.04312001f, 0.05002028f, 0.06675159f, 
    0.04148825f, 0.09482487f, -0.00173225f, -0.09403124f, 0.25388160f, -0.06400362f, 0.01164662f, 0.06597340f, 
    -0.30853069f, -0.08330467f, -0.06955454f, -0.04635405f, -0.03450666f, -0.07993804f, -0.18407227f, -0.00901726f, 
    -0.02352561f, 0.01262575f, 0.17979160f, -0.21179011f, 0.00709900f, -0.21948981f, -0.04694993f, 0.01510757f, 
    -0.14057855f, -0.01688868f, 0.09966840f, -0.08965863f, -0.07951045f, -0.37399369f, -0.01634903f, 0.34798202f, 
    -0.06577677f, 0.09851308f, 0.00166255f, -0.08385134f, -0.02416704f, -0.11302771f, -0.09149845f, -0.19513322f, 
    0.13582112f, 0.05235075f, 0.01782419f, 0.11535317f, 0.17971663f, -0.09785841f, 0.04009955f, 0.19123505f, 
    -0.03335908f, -0.02127256f, 0.02621243f, 0.01677027f, -0.01756188f, -0.01082265f, 0.01082535f, -0.14863527f, 
    -0.14512412f, -0.06870361f, 0.00638609f, 0.03314605f, -0.08861063f, -0.03981083f, 0.05809116f, -0.04081964f, 
    0.02193687f, 0.04756463f, 0.19739223f, 0.16714640f, -0.03693736f, 0.02930867f, -0.10301048f, 0.01684107f, 
    -0.03808103f, -0.05076684f, -0.05312125f, -0.08027647f, 0.06772771f, 0.11004215f, -0.24727885f, 0.07443354f, 
    -0.13389096f, -0.02901669f, -0.10714194f, -0.03206960f, 0.03761927f, -0.17263654f, 0.00392431f, -0.07032088f, 
    -0.10819357f, 0.04984539f, 0.06315678f, -0.05334077f, 0.08243048f, -0.09749010f, -0.06997292f, 0.08316154f, 
    -0.22057620f, -0.00322941f, -0.11428416f, -0.10735225f, -0.02927010f, 0.00074458f, 0.11556201f, -0.06615087f, 
    -0.00342230f, 0.07684850f, -0.04238198f, -0.03070862f, -0.02565662f, -0.11766524f, -0.17504936f, -0.05267913f, 
    0.21754146f, 0.10739472f, -0.20389725f, -0.04778318f, -0.21174771f, -0.04529331f, -0.09741990f, -0.04418320f, 
    -0.14759973f, -0.07232516f, -0.12055977f, -0.16559714f, 0.09530236f, 0.08976282f, 0.07711837f, 0.12064544f, 
    -0.07032920f, 0.16835855f, 0.00194379f, -0.05137341f, 0.04276797f, 0.08240900f, -0.00264503f, 0.05442277f, 
    -0.05158633f, -0.07222016f, -0.05856355f, -0.20849483f, 0.08988950f, 0.05261935f, 0.02969280f, -0.01482339f, 
    0.15548033f, 0.05971354f, -0.01852782f, -0.15721714f, 0.03488947f, 0.01512991f, -0.18797503f, 0.08105652f, 
    0.02438765f, 0.00571597f, -0.07045785f, -0.03555853f, 0.06428004f, 0.04117590f, -0.00861308f, -0.09459980f, 
    0.30032206f, 0.13272993f, -0.03595732f, -0.12109672f, 0.02116430f, -0.03234328f, 0.05263867f, 0.06525581f, 
    -0.08434502f, 0.19743107f, 0.03773515f, 0.22618254f, 0.05249866f, -0.05152245f, 0.20789585f, 0.10655408f, 
    -0.11810432f, 0.01585314f, 0.12801690f, 0.05513415f, -0.00609771f, -0.14217043f, 0.00345326f, -0.07331497f, 
    0.11961641f, -0.02766584f, -0.19671464f, -0.00435310f, -0.08884758f, 0.02888127f, -0.09054907f, 0.04468890f, 
    -0.04547022f, -0.09749202f, -0.05654090f, -0.00596833f, 0.03559964f, -0.02761139f, -0.03086181f, 0.28830808f, 
    0.10111984f, 0.07782106f, -0.00722461f, -0.07884474f, 0.01786644f, 0.03849063f, 0.05379659f, -0.00047453f, 
    0.11073719f, -0.09005563f, -0.26865754f, 0.08783440f, 0.02578195f, 0.04247622f, -0.02416104f, -0.13651954f, 
    0.04917060f, -0.08367453f, -0.01909028f, -0.04839965f, -0.07132649f, 0.00901743f, 0.05606082f, 0.12800330f, 
    0.06896222f, -0.02200653f, -0.06484117f, 0.16549088f, -0.11776639f, -0.07737025f, -0.01566636f, 0.16586562f, 
    0.08951302f, 0.00669068f, -0.01616149f, 0.09635847f, -0.17578463f, 0.11006490f, 0.01479725f, -0.12048612f, 
    -0.09150568f, -0.01451840f, 0.03582829f, 0.04236086f, -0.04799065f, 0.07724673f, -0.20325410f, -0.09930078f, 
    0.10956952f, 0.04908086f, 0.11792117f, -0.05369303f, 0.23004489f, -0.00279784f, -0.00947557f, 0.10102893f, 
    -0.01661158f, -0.15431297f, -0.25445572f, -0.21203789f, 0.17758590f, 0.12175253f, 0.16066577f, -0.16938806f, 
    0.11162700f, -0.03029131f, -0.04784501f, -0.07721919f, -0.24104813f, -0.09501070f, 0.23604567f, -0.07539602f, 
    -0.01588351f, -0.02517672f, -0.03715308f, 0.07393111f, -0.06045045f, 0.02640480f, 0.03136707f, 0.08131908f, 
    0.00272966f, 0.05701334f, -0.05987292f, -0.12020778f, -0.09650888f, 0.11100780f, 0.10450375f, -0.11729025f, 
    0.14014550f, 0.14626981f, 0.05950715f, -0.02090535f, -0.02599400f, 0.36245805f, -0.06975493f, 0.17743286f, 
    -0.02524533f, -0.07959520f, 0.10962097f, 0.01854340f, 0.07168278f, -0.05449013f, 0.02659754f, -0.11872656f, 
    0.43627387f, -0.24446838f, -0.01223988f, 0.05436623f, 0.23354606f, 0.02230185f, -0.07748774f, 0.07449983f, 
    0.24791673f, 0.07061080f, -0.08302265f, -0.00612515f, 0.05380239f, -0.11284137f, -0.02151369f, -0.12760790f, 
    0.14172530f, -0.09329869f, -0.14189963f, 0.05524828f, -0.07056114f, -0.02618100f, -0.03125709f, -0.08369110f, 
    -0.02692399f, -0.03628710f, 0.03196314f, -0.02334566f, 0.03189664f, -0.04077897f, 0.02603145f, 0.04184672f, 
    -0.02921408f, -0.00092483f, -0.05986473f, -0.04996360f, -0.00545596f, 0.00151452f, 0.04743278f, 0.01479796f, 
    -0.01022024f, 0.02176075f, 0.01942490f, 0.01491945f, -0.02571352f, 0.02933984f, -0.03787296f, -0.05864244f, 
    -0.05033594f, -0.00081423f, -0.02909137f, -0.05160911f, 0.06486326f, 0.01781950f, -0.02241757f, 0.00922869f, 
    -0.01934274f, -0.05812407f, 0.03012909f, -0.01604507f, -0.05536287f, 0.03615818f, -0.04898950f, 0.05608528f, 
    -0.06262345f, 0.00443088f, -0.04090288f, -0.01080720f, 0.01780085f, -0.01492592f, 0.05876896f, 0.02197069f, 
    -0.01545583f, -0.05908077f, 0.00624590f, -0.03974615f, -0.03131118f, -0.05234949f, 0.00476835f, 0.03644174f, 
    0.00819715f, -0.07308741f, 0.03589793f, -0.05266889f, -0.01318419f, -0.01186429f, 0.04827339f, -0.06249369f, 
    -0.06674200f, 0.06023183f, -0.00713658f, 0.04613093f, -0.06525640f, -0.01703713f, 0.06340980f, -0.02565684f, 
    0.03170275f, -0.01459040f, -0.03886679f, 0.05098490f, -0.02334143f, -0.02490267f, -0.03381154f, -0.07039231f, 
    -0.01144374f, -0.07060129f, -0.02889244f, -0.04696478f, -0.05029854f, 0.01178321f, -0.07705901f, -0.00546393f, 
    0.05234171f, -0.05969076f, -0.01234649f, -0.01752106f, -0.02075975f, -0.02506110f, -0.00063596f, -0.03361197f, 
    -0.04879357f, -0.00185093f, 0.04289599f, 0.00306473f, 0.02316336f, 0.05601534f, -0.04501281f, -0.04771342f, 
    -0.04926181f, 0.02665484f, 0.00914881f, 0.06330723f, -0.03809198f, 0.00689108f, -0.06123611f, 0.01935579f, 
    0.03228602f, 0.04832643f, 0.06088766f, -0.06844747f, 0.00392226f, -0.04147275f, 0.04336204f, 0.03065113f, 
    -0.04697132f, -0.03725407f, 0.02364984f, -0.04765935f, -0.06370096f, 0.01982502f, -0.02567607f, -0.05560898f, 
    -0.05327047f, 0.04575960f, -0.06227376f, 0.02445253f, -0.00451249f, -0.01615182f, -0.04876557f, 0.04251868f, 
    -0.01811186f, -0.04728742f, 0.00657591f, 0.05589738f, 0.01163693f, -0.02472718f, -0.04782246f, -0.04607592f, 
    -0.01384678f, -0.02716955f, -0.01490009f, -0.04268708f, -0.04257089f, -0.05995078f, -0.04176898f, -0.03826667f, 
    0.02987299f, 0.00655744f, -0.02453891f, 0.03783767f, -0.05239414f, -0.03889712f, 0.04638112f, -0.05696425f, 
    0.00364374f, -0.07595091f, 0.06294858f, 0.04267972f, -0.05769944f, 0.02304802f, -0.03761960f, 0.04807446f, 
    -0.04764914f, 0.03742625f, -0.02654918f, 0.02509434f, -0.02592437f, -0.04225528f, -0.05595084f, 0.03755746f, 
    -0.07628142f, 0.02186107f, -0.01759821f, -0.00428496f, 0.04511709f, 0.04243082f, -0.05294914f, -0.05520394f, 
    -0.01132371f, -0.01839447f, 0.00370101f, 0.01589637f, 0.02013697f, 0.03850391f, -0.03706710f, 0.02641392f, 
    -0.04745810f, 0.18546280f, -0.12615545f, 0.10985781f, 0.00083339f, -0.02894175f, 0.01395149f, 0.01418538f, 
    0.04677286f, -0.09138075f, 0.17074476f, 0.10415301f, -0.21677555f, -0.14786407f, 0.08743197f, -0.01178981f, 
    0.06947054f, -0.03792067f, 0.05214512f, 0.08183731f, 0.04736980f, 0.00082003f, 0.06627341f, -0.00391753f, 
    -0.03721588f, 0.17156932f, -0.15903147f, -0.06371989f, 0.03036544f, -0.04776503f, -0.07907426f, -0.08451162f, 
    -0.02054282f, 0.01533430f, 0.06019223f, 0.01492674f, 0.08535266f, -0.21145511f, -0.16926038f, -0.11088809f, 
    0.04110831f, 0.00465629f, -0.03848622f, -0.13048510f, 0.00488462f, 0.01998412f, 0.04094667f, 0.07024591f, 
    -0.13309605f, -0.10125861f, -0.09579537f, 0.08353921f, -0.07251951f, 0.03937112f, -0.02681501f, -0.10339101f, 
    -0.06250794f, -0.01180231f, 0.08433890f, 0.02135828f, 0.15173107f, 0.24344072f, 0.00528862f, -0.03518699f, 
    -0.20471196f, -0.05580148f, 0.12089712f, 0.03002699f, -0.00485747f, 0.12740637f, 0.08495703f, 0.01700047f, 
    0.22555239f, -0.19539917f, -0.24914449f, -0.08514176f, -0.02356903f, 0.15416636f, 0.16090456f, 0.07607888f, 
    0.02454016f, 0.02468015f, -0.02591914f, -0.09476709f, 0.27016905f, 0.16345644f, -0.08473796f, -0.10740737f, 
    -0.01679423f, 0.03157462f, -0.07025193f, 0.06119014f, 0.03103550f, -0.06721511f, -0.10388250f, 0.12240439f, 
    0.15084395f, 0.01284442f, -0.09821358f, -0.30731320f, -0.13295978f, 0.02751470f, -0.13983782f, -0.03378299f, 
    -0.01631638f, 0.02237224f, -0.06268789f, -0.07454779f, 0.08333298f, -0.00003134f, 0.07174776f, 0.18340486f, 
    0.03699392f, 0.02324908f, -0.03756104f, 0.18583527f, 0.03887845f, -0.02182132f, 0.06994708f, 0.17127521f, 
    0.01390187f, 0.06335128f, -0.15024045f, 0.22883634f, 0.08182584f, 0.04146314f, -0.06146231f, 0.01812973f, 
    -0.02952147f, 0.03038238f, -0.01839005f, -0.05209613f, 0.17738576f, -0.21248800f, 0.27192941f, 0.05094051f, 
    -0.04968594f, 0.06305455f, 0.07828899f, -0.02530344f, 0.05047541f, 0.12122331f, -0.05073515f, 0.07203542f, 
    -0.12251761f, -0.15440600f, 0.20212743f, 0.20862111f, -0.14784275f, 0.04768663f, 0.01632268f, -0.05967554f, 
    0.10078815f, -0.05174940f, -0.05247732f, 0.00572545f, -0.13654894f, 0.14281726f, -0.01209885f, -0.00775202f, 
    -0.00404021f, -0.10096003f, 0.06040477f, 0.05344168f, -0.03698500f, 0.04024967f, 0.01228314f, 0.06603235f, 
    0.16091667f, -0.03401938f, -0.02879731f, 0.15561692f, -0.07438041f, 0.01473638f, 0.01122732f, 0.16675076f, 
    0.02337426f, 0.08559857f, 0.01156970f, -0.01234561f, -0.09158789f, 0.09820046f, -0.00990427f, -0.05357463f, 
    -0.03204907f, 0.00759335f, -0.03706955f, 0.04601602f, -0.05135547f, -0.03601816f, 0.09831332f, 0.00775342f, 
    -0.07241657f, 0.04357729f, -0.06254863f, -0.01757439f, 0.22642730f, 0.03957316f, -0.00190506f, 0.09225446f, 
    0.06143009f, -0.03153921f, -0.02061744f, -0.03386226f, -0.05362363f, 0.12636442f, -0.22812209f, 0.08671258f, 
    -0.10047396f, -0.19331232f, -0.07793549f, 0.01851064f, 0.02969425f, 0.10181473f, -0.25503415f, -0.03128860f, 
    0.17071345f, 0.03047753f, -0.04481345f, -0.27167201f, 0.05852880f, -0.04277579f, 0.03864717f, 0.07090990f, 
    -0.04632271f, 0.24601243f, 0.17658381f, 0.21220021f, 0.33925718f, -0.17544851f, -0.08593651f, 0.07183388f, 
    -0.16723220f, -0.03778901f, -0.00864655f, -0.01367929f, 0.00935131f, -0.03834558f, 0.08231247f, -0.04164321f, 
    -0.23293725f, 0.06818958f, -0.09258512f, -0.09882766f, -0.18828627f, -0.02803970f, -0.18844865f, -0.01237794f, 
    0.07969567f, -0.03439580f, -0.02134157f, 0.00894930f, -0.08590122f, -0.04901334f, 0.05913661f, 0.14624177f, 
    0.12747636f, 0.08129180f, -0.09533969f, -0.18930045f, 0.04734711f, -0.04984688f, 0.05381659f, -0.02401462f, 
    -0.17035857f, 0.03428069f, -0.26527682f, 0.06018756f, -0.00881400f, 0.10104456f, -0.06654467f, -0.05058620f, 
    0.10564598f, 0.07759298f, -0.10979956f, -0.08880772f, -0.12586564f, 0.06092184f, -0.07674671f, 0.01563247f, 
    0.13489011f, 0.02387014f, -0.05225539f, 0.03996650f, -0.01542654f, 0.05654412f, 0.02995712f, 0.24138415f, 
    0.15979743f, 0.01987753f, 0.01828760f, 0.01240038f, -0.18394916f, 0.03121722f, 0.04566003f, -0.23603804f, 
    -0.03505283f, 0.08704042f, 0.00156716f, -0.08444548f, 0.10627171f, -0.05705127f, -0.06942301f, -0.00904012f, 
    0.19045506f, 0.01934272f, 0.02567218f, -0.01946224f, 0.12765458f, 0.09499406f, 0.20956096f, 0.15501085f, 
    0.06364251f, 0.07448165f, -0.04639082f, -0.07239798f, -0.00394641f, 0.09607001f, 0.01578912f, 0.09816997f, 
    0.01375291f, -0.09029130f, 0.06627069f, -0.04589655f, -0.25057507f, -0.22684799f, 0.24133597f, 0.04365971f, 
    -0.01320091f, -0.03244924f, -0.02440558f, -0.00601081f, 0.04006663f, 0.10291083f, 0.12132391f, 0.04754843f, 
    0.32618657f, 0.19069666f, -0.11047659f, -0.06487038f, -0.04954729f, 0.09379464f, 0.06545777f, 0.07144387f, 
    0.18677002f, 0.18821798f, 0.11271527f, -0.03388891f, -0.29201597f, 0.25524426f, -0.06847417f, 0.05961779f, 
    0.12015647f, 0.05213466f, -0.04857759f, 0.09952909f, 0.14706023f, 0.06488474f, -0.07065172f, -0.02249434f, 
    0.17190222f, -0.27970597f, -0.03864164f, 0.08361313f, 0.23417850f, 0.08097260f, -0.01949038f, -0.00555480f, 
    0.22088376f, -0.02452947f, 0.01340182f, 0.09622060f, -0.07315812f, -0.02750202f, -0.06748990f, -0.06690440f, 
    0.01847079f, -0.06093332f, -0.20762382f, 0.09630788f, -0.03793609f, -0.09613627f, -0.02383987f, -0.08299842f, 
    0.14898677f, 0.06059624f, -0.17694026f, -0.11900862f, 0.13174334f, -0.01704486f, -0.09844466f, 0.05768682f, 
    0.06324703f, -0.00581821f, -0.00255351f, 0.03709130f, 0.10589162f, 0.13133837f, -0.04868075f, -0.03973947f, 
    -0.09922869f, 0.04053055f, -0.04951327f, -0.04342380f, 0.04384057f, 0.14423953f, -0.06487998f, 0.05429225f, 
    0.19781297f, -0.01201813f, -0.00607669f, -0.15550527f, -0.07904164f, -0.06203334f, 0.03183573f, 0.00423171f, 
    -0.00137329f, -0.01113545f, 0.07446016f, 0.12013597f, 0.19957578f, -0.11285568f, 0.06520358f, -0.04736931f, 
    -0.04093790f, -0.00297783f, 0.05347032f, 0.08169344f, -0.09241423f, 0.08846506f, 0.00287241f, -0.01985366f, 
    -0.24113727f, 0.08128802f, 0.01872684f, -0.02632467f, 0.04573217f, 0.12600386f, -0.00309493f, 0.09133335f, 
    -0.04936834f, 0.04619863f, 0.06597743f, -0.02537820f, 0.26260865f, -0.18660541f, -0.16432540f, 0.11567431f, 
    -0.00171894f, 0.07269035f, -0.04333727f, 0.00033279f, -0.00360542f, 0.04577645f, 0.02689672f, 0.04371402f, 
    -0.06244856f, 0.11029924f, 0.08424345f, -0.30659682f, -0.05299625f, -0.07787385f, 0.05500257f, 0.10668673f, 
    -0.04851769f, -0.00403612f, 0.09561761f, 0.05764672f, -0.25968662f, -0.23993327f, 0.01539121f, 0.42499706f, 
    0.05350355f, 0.03853588f, 0.03342436f, 0.01227947f, 0.06438418f, 0.01684625f, -0.01833627f, -0.12060240f, 
    0.21350004f, -0.00620963f, 0.10214317f, -0.22478624f, -0.05355055f, 0.00799354f, 0.05321654f, 0.03229742f, 
    -0.00381985f, 0.00833593f, 0.02727628f, -0.10310181f, 0.18531775f, -0.14429466f, 0.00384727f, -0.15939596f, 
    -0.02091354f, 0.07608947f, 0.01011705f, 0.11940075f, 0.18718387f, 0.07011873f, -0.00730797f, 0.05314187f, 
    -0.13891417f, 0.20684585f, 0.06609178f, 0.05982716f, 0.04635101f, 0.07364908f, -0.07193719f, -0.01487179f, 
    0.09001470f, -0.01258414f, -0.06908422f, -0.07330527f, 0.06243813f, -0.13230121f, -0.04176646f, 0.25721100f, 
    -0.23188004f, -0.04073258f, -0.07751723f, 0.05931612f, 0.06560791f, -0.10273198f, 0.05921820f, -0.05803882f, 
    0.13777064f, 0.13744760f, 0.03486968f, -0.08241750f, -0.07423520f, 0.00615664f, 0.13750508f, 0.00335343f, 
    0.03543911f, 0.07477689f, -0.05980526f, -0.02070858f, -0.21471275f, 0.19818880f, -0.02736470f, 0.07701427f, 
    0.03019753f, 0.04484762f, 0.00723002f, -0.01805338f, -0.04782704f, -0.06187331f, 0.02499735f, 0.06111259f, 
    0.29823291f, -0.14266509f, -0.13365883f, 0.14707476f, 0.01698996f, 0.05316315f, -0.02709267f, 0.07501233f, 
    0.02627087f, 0.05869805f, 0.08210589f, -0.09478366f, 0.01793000f, -0.01002772f, -0.17415898f, 0.27183694f, 
    -0.05879724f, -0.04200629f, -0.13019377f, 0.04728765f, 0.04811108f, 0.07912186f, 0.08115137f, 0.03449939f, 
    -0.16564746f, 0.01927711f, 0.00808840f, 0.05328769f, -0.03343453f, -0.03485534f, 0.17746110f, 0.07669672f, 
    -0.05399046f, -0.09690858f, -0.02669486f, 0.06327123f, 0.06662650f, 0.22398780f, -0.04543705f, -0.16459699f, 
    0.03784116f, -0.10691896f, 0.12979557f, -0.12508509f, 0.07035752f, -0.01093858f, -0.13255072f, -0.11425597f, 
    0.06568598f, -0.25688466f, -0.05735598f, 0.22539249f, -0.03291303f, 0.04386835f, -0.09891750f, 0.22264189f, 
    0.09553814f, 0.06945109f, 0.08542443f, 0.16615933f, 0.18356103f, 0.08487894f, -0.21422631f, -0.02540488f, 
    0.17568637f, 0.16787443f, -0.15305385f, 0.02047973f, 0.12076220f, -0.03261493f, -0.10042981f, -0.05944954f, 
    -0.33603960f, 0.17413622f, -0.00639924f, -0.09272601f, 0.01871368f, 0.09427264f, 0.12174582f, -0.18470277f, 
    0.00931636f, -0.10458437f, 0.00349883f, -0.03465784f, -0.01055039f, -0.10403759f, 0.13353080f, -0.00806133f, 
    0.05822381f, -0.02501780f, 0.14323221f, 0.05880181f, -0.04975825f, -0.10102795f, -0.06980804f, 0.01986356f, 
    -0.05691540f, 0.17387411f, 0.31326145f, -0.25792241f, 0.02195137f, -0.07865310f, -0.14082246f, 0.08542652f, 
    -0.00704525f, 0.10098562f, 0.10237709f, 0.02196719f, -0.13174777f, -0.12498628f, 0.08280940f, 0.04997458f, 
    0.06700623f, 0.03259172f, -0.05285697f, -0.09310134f, -0.11999368f, 0.05739732f, 0.01570262f, 0.02568143f, 
    -0.10309536f, 0.01131524f, 0.01334744f, 0.08019175f, 0.08128615f, -0.03741891f, 0.04390160f, 0.13464199f, 
    0.12337476f, -0.04901710f, 0.05138847f, -0.02849032f, -0.24379872f, 0.16770492f, 0.01897851f, -0.10899680f, 
    -0.02355048f, 0.07067569f, 0.17141451f, 0.09558131f, -0.06568144f, 0.04087218f, 0.02937910f, 0.04500261f, 
    -0.23305783f, 0.20388177f, 0.03779979f, 0.10702647f, -0.01273517f, -0.08659290f, -0.08820534f, 0.18269359f, 
    0.02318603f, -0.00258255f, 0.05763765f, -0.00889680f, -0.02531086f, 0.11321403f, -0.01847880f, 0.15997225f, 
    -0.02709646f, -0.00561743f, 0.03774197f, -0.01486330f, 0.05481632f, 0.02788659f, 0.10472829f, 0.09358199f, 
    0.06937001f, -0.06403889f, 0.06627015f, 0.10879416f, 0.07784893f, -0.04079632f, 0.01632840f, 0.06443426f, 
    0.04521561f, 0.03517599f, 0.04976750f, 0.00073892f, -0.05913849f, -0.09040733f, -0.00069952f, -0.04920705f, 
    0.06039878f, 0.14111888f, 0.04935611f, -0.06272206f, 0.10029219f, -0.13150094f, 0.09314201f, 0.13067769f, 
    -0.10083205f, -0.04865989f, -0.05343302f, 0.02373266f, 0.05099269f, -0.02101400f, 0.11621175f, -0.06707333f, 
    -0.03823807f, -0.09859883f, -0.07054127f, 0.00491863f, -0.00248947f, 0.11661629f, -0.04701451f, 0.08010717f, 
    -0.00044937f, 0.09931740f, 0.03431110f, -0.11801849f, -0.02549492f, 0.05001399f, -0.04583086f, -0.15524270f, 
    -0.08880945f, -0.00860516f, -0.08746013f, -0.19916393f, -0.02795387f, 0.03049160f, 0.17418408f, 0.10783864f, 
    0.02808274f, -0.08128144f, 0.09038325f, -0.04538884f, 0.18641180f, 0.11676962f, -0.25603053f, 0.11736692f, 
    -0.12271763f, -0.04069218f, -0.17571911f, -0.07728703f, 0.04558612f, -0.02390846f, 0.02264566f, -0.08074037f, 
    -0.01861777f, -0.09753854f, -0.04452051f, -0.11586037f, -0.19889197f, 0.04929218f, -0.00154351f, 0.04051380f, 
    0.04124540f, -0.01913625f, 0.07868667f, 0.03822922f, 0.00358287f, -0.17629571f, -0.04396434f, 0.09186681f, 
    0.07031573f, 0.03210110f, 0.02675662f, 0.14457062f, -0.07821362f, 0.00498165f, 0.06784435f, 0.08089397f, 
    0.23757531f, -0.17483141f, -0.00768572f, -0.08470205f, 0.01543770f, -0.05004703f, 0.08213999f, 0.22371243f, 
    -0.02478735f, -0.01420129f, 0.12104055f, 0.08224797f, 0.03357182f, 0.11438395f, 0.09849477f, -0.07741228f, 
    -0.01214988f, 0.11559894f, -0.03414698f, 0.07415966f, 0.01338665f, 0.00334559f, 0.02038301f, 0.00658427f, 
    -0.10300542f, 0.28684461f, 0.20742410f, 0.18738823f, -0.00958631f, -0.09451261f, 0.06569918f, 0.01404655f, 
    -0.05086951f, 0.00379650f, 0.02588258f, -0.00369883f, -0.37194866f, -0.08224112f, 0.25855133f, 0.05497994f, 
    0.07035148f, 0.07990066f, 0.05504096f, -0.14560243f, -0.00113054f, -0.00902357f, 0.03792360f, -0.26963925f, 
    -0.03239403f, 0.06668040f, 0.09283756f, -0.02826395f, -0.05602159f, 0.04308612f, 0.03975574f, -0.04736729f, 
    -0.02908740f, 0.09167354f, -0.02646491f, 0.10257900f, -0.02925889f, -0.09827116f, 0.01218238f, -0.11640573f, 
    0.10054607f, 0.12217196f, -0.10340630f, 0.16002253f, 0.06008434f, -0.04147793f, -0.04197485f, 0.03344183f, 
    -0.13479888f, 0.23656866f, 0.09120908f, -0.21987753f, 0.01416253f, 0.05881527f, 0.04366200f, -0.01867089f, 
    -0.02339465f, 0.06558958f, 0.04235251f, 0.17917070f, 0.09564428f, -0.04541805f, -0.06604224f, -0.12028135f, 
    0.04689187f, 0.08395775f, -0.04168300f, 0.10154796f, -0.08509229f, -0.09166759f, -0.04754595f, -0.05422439f, 
    0.35662803f, 0.02642958f, -0.08818808f, -0.22838977f, 0.02026188f, -0.07204704f, -0.03023815f, 0.12550551f, 
    0.02447690f, 0.01090903f, -0.06284226f, 0.09295931f, 0.05022486f, 0.00275775f, 0.17553255f, 0.12083602f, 
    0.05098582f, 0.09195790f, 0.13409214f, -0.09387104f, -0.09317773f, -0.08037791f, -0.06329136f, 0.09189639f, 
    0.18335193f, 0.13305321f, -0.22415100f, 0.07427211f, 0.05895556f, -0.05105730f, 0.11926387f, -0.04347944f, 
    0.05872053f, -0.03779779f, -0.03111890f, 0.04809529f, 0.05316681f, -0.08994964f, -0.30268881f, 0.28199711f, 
    -0.06587896f, 0.01695776f, 0.01027718f, 0.02589845f, 0.08759833f, -0.01394805f, 0.19770181f, 0.08130182f, 
    0.02142460f, 0.01530706f, -0.06320392f, 0.03969252f, 0.02506111f, 0.01620450f, -0.06803712f, 0.05065500f, 
    -0.04354016f, -0.02893970f, -0.07923888f, -0.02408828f, -0.00089358f, -0.05804701f, -0.05497966f, 0.02302004f, 
    0.02759757f, 0.02827244f, -0.02510715f, -0.03898156f, 0.02718872f, -0.02540111f, 0.00573620f, 0.01131643f, 
    -0.05305947f, 0.05500431f, -0.05291606f, 0.06322561f, 0.06162107f, -0.02606875f, 0.03238769f, -0.09232290f, 
    0.05556566f, -0.05243861f, 0.04263543f, 0.00302587f, -0.03491698f, 0.03715244f, 0.02472756f, -0.00838566f, 
    -0.09138728f, -0.00716020f, -0.05144035f, -0.02349629f, -0.00173859f, -0.08990716f, -0.00314506f, 0.05671610f, 
    -0.02972002f, -0.02223943f, -0.07451229f, -0.00644151f, -0.02713021f, -0.00965890f, 0.04355843f, 0.00818795f, 
    -0.04746534f, 0.02311365f, -0.05419233f, -0.03084545f, -0.07476056f, 0.04949946f, -0.06014619f, -0.06896777f, 
    -0.00112340f, -0.04475955f, -0.03346757f, -0.06389111f, 0.03443159f, 0.01539037f, -0.06439476f, 0.04816025f, 
    -0.07025356f, -0.01605278f, 0.03239669f, -0.06355566f, -0.00397418f, -0.02927225f, -0.05509873f, -0.04439251f, 
    -0.04696143f, -0.00219736f, -0.03179587f, -0.00416530f, -0.05866826f, -0.02551353f, -0.07304925f, -0.00129977f, 
    0.04988800f, -0.07144081f, 0.05663417f, 0.06620937f, 0.02393274f, 0.05013992f, -0.03955607f, -0.04613727f, 
    -0.04015574f, 0.05965006f, -0.02634818f, -0.02840880f, -0.07230530f, -0.00629705f, 0.06412360f, 0.02677464f, 
    0.06689993f, 0.04357076f, -0.07549604f, -0.06047120f, -0.02692694f, -0.05350570f, 0.04499627f, -0.06390757f, 
    -0.04179398f, 0.02515697f, -0.06479438f, 0.01078145f, -0.01892594f, -0.07415908f, -0.08726855f, -0.05559440f, 
    0.00779844f, -0.06403714f, -0.02600932f, 0.04228498f, -0.02148837f, 0.05517988f, -0.02433141f, -0.00427984f, 
    0.03683225f, 0.00952514f, 0.06681049f, 0.02015041f, -0.09226370f, -0.07211507f, 0.02976809f, 0.03713551f, 
    -0.07694126f, -0.01670784f, 0.06815696f, 0.00222731f, -0.02844471f, -0.03610412f, -0.03905560f, -0.05231343f, 
    0.02463700f, 0.04792460f, -0.08066131f, 0.02937572f, -0.04649428f, -0.00479741f, 0.04940845f, -0.03888632f, 
    0.01822974f, 0.00872219f, -0.07583285f, -0.06103059f, 0.01067562f, -0.02331858f, 0.01907626f, 0.03460100f, 
    -0.07586145f, 0.00555004f, 0.03294458f, 0.05399463f, -0.07103844f, 0.05841467f, 0.05113104f, -0.01661160f, 
    0.01499629f, -0.07872352f, -0.05671890f, -0.06687625f, 0.08187621f, 0.03459692f, -0.06741988f, 0.03308121f, 
    0.06833175f, -0.04602636f, -0.06793049f, 0.00909392f, 0.07712574f, -0.01465478f, -0.08348404f, -0.08582956f, 
    0.03452541f, 0.01273974f, 0.03841440f, 0.05614606f, -0.07593042f, 0.01666662f, -0.02663987f, -0.07854527f, 
    -0.13785878f, 0.16089936f, -0.16463532f, 0.12551166f, 0.05304056f, 0.06836108f, -0.03590770f, 0.13817486f, 
    0.03459901f, 0.08443840f, 0.00731544f, 0.04226124f, 0.13453011f, -0.11550649f, 0.17094703f, -0.00260872f, 
    0.11527322f, -0.01363397f, -0.04538599f, 0.16874999f, 0.00276081f, 0.07917663f, 0.03843345f, 0.01886829f, 
    0.21343540f, 0.05137365f, 0.03064825f, -0.12097440f, -0.12461440f, 0.00596840f, -0.12785324f, -0.07768989f, 
    -0.08742066f, -0.08041398f, 0.10112189f, -0.14624092f, 0.13739775f, -0.11802640f, 0.07331379f, -0.10579536f, 
    -0.09591131f, 0.07497762f, 0.05273600f, 0.00876248f, -0.08010177f, 0.10381626f, 0.02166308f, 0.09968748f, 
    0.29065442f, 0.08984238f, 0.11460250f, 0.09773239f, -0.04258748f, 0.05648658f, -0.02077588f, 0.02362693f, 
    0.00448524f, -0.02014103f, 0.01244177f, -0.12070438f, -0.07167097f, 0.21657315f, -0.04758691f, 0.11661413f, 
    -0.01412104f, -0.06825395f, 0.09619296f, 0.03022362f, -0.00022063f, 0.18542071f, 0.07866308f, -0.05635482f, 
    0.04402981f, 0.01950412f, -0.10438450f, -0.01828110f, -0.00367404f, 0.06972289f, 0.08234056f, -0.07777528f, 
    -0.11167520f, 0.03985615f, -0.00530826f, 0.03468971f, 0.41269597f, 0.04668139f, -0.19059676f, -0.02732977f, 
    -0.00071095f, 0.01322590f, -0.01498452f, 0.01111201f, -0.07292379f, -0.04343971f, -0.00524061f, -0.06501693f, 
    0.11060950f, 0.23637611f, 0.07177193f, -0.00269119f, -0.05674849f, 0.09841939f, -0.21441385f, -0.09546692f, 
    -0.02193774f, -0.00786758f, -0.07224332f, 0.08743303f, 0.06227816f, 0.21735960f, -0.16914824f, 0.09769411f, 
    0.12458789f, 0.02213394f, -0.18678916f, 0.08846048f, -0.01605623f, -0.00575291f, -0.08597151f, -0.03854904f, 
    0.11191599f, 0.04577114f, -0.02629616f, 0.17355216f, 0.01838082f, 0.01072837f, -0.13458896f, 0.06314476f, 
    -0.08302936f, 0.06391920f, -0.07811289f, 0.13038179f, -0.29075623f, -0.33863500f, 0.24664618f, -0.02127969f, 
    -0.11450684f, 0.08732550f, -0.08573766f, -0.02187617f, -0.08684144f, 0.01077878f, -0.08870735f, -0.01732297f, 
    0.07253579f, 0.04359431f, 0.11959100f, 0.20009121f, -0.03655389f, 0.01617537f, 0.03017706f, -0.08882177f, 
    0.02913346f, -0.05080140f, -0.05493103f, -0.05498329f, 0.31948885f, 0.04166998f, -0.06659692f, -0.00694247f, 
    0.15055868f, 0.07715802f, -0.02625171f, -0.16656585f, -0.12933871f, 0.08398654f, 0.02016069f, -0.01764543f, 
    0.10243327f, -0.03811263f, -0.09511244f, 0.12026131f, -0.03952227f, -0.03303173f, -0.01142529f, 0.03650795f, 
    -0.07374339f, 0.17611325f, -0.00986350f, 0.01706399f, -0.13862926f, 0.06791537f, -0.01676876f, -0.14178258f, 
    -0.03061221f, -0.12051809f, 0.02339119f, -0.16575636f, -0.03372644f, 0.00880248f, 0.13397990f, 0.06307736f, 
    -0.05488181f, -0.02242592f, -0.02358643f, 0.04822734f, 0.01481558f, 0.00369945f, -0.00079028f, -0.00874282f, 
    0.01631421f, -0.02397708f, 0.05089582f, 0.02971321f, -0.00369648f, 0.01491246f, 0.00212623f, -0.05507854f, 
    -0.03933702f, 0.04040529f, -0.04571166f, 0.06260537f, -0.05384821f, -0.01701799f, 0.01112403f, -0.05390387f, 
    0.04197437f, 0.05405422f, -0.00724721f, -0.04929597f, -0.00970414f, -0.07070380f, -0.07360231f, 0.01163519f, 
    -0.06591380f, -0.04631897f, 0.00653303f, 0.04475131f, 0.01577832f, -0.02749492f, -0.06967700f, -0.03091658f, 
    -0.01551345f, -0.05164296f, -0.02169233f, 0.05441877f, -0.07111792f, -0.03596525f, 0.02056254f, -0.03896822f, 
    -0.02619437f, 0.04041610f, -0.04549865f, -0.00680050f, 0.01162907f, -0.01622098f, -0.06117562f, 0.03531868f, 
    -0.05687173f, 0.00423006f, -0.03465291f, -0.04413262f, -0.07229632f, 0.03017007f, 0.04640423f, 0.03249179f, 
    -0.07039467f, -0.02198970f, -0.03071908f, 0.01804196f, -0.01161541f, 0.04368488f, 0.01585085f, -0.04546637f, 
    -0.02331061f, -0.03279231f, -0.02001937f, 0.01006730f, -0.02040656f, 0.03308569f, -0.03047684f, -0.00898293f, 
    -0.03938951f, -0.03435669f, -0.02622752f, -0.01387192f, 0.06032722f, 0.02208333f, 0.05432025f, -0.03254480f, 
    0.06207995f, -0.05158450f, -0.05668250f, 0.00203130f, -0.06490961f, -0.06804558f, -0.03709619f, -0.01380402f, 
    -0.02866331f, 0.03480380f, 0.03273248f, -0.07593555f, 0.05219143f, -0.01546700f, -0.04311660f, -0.06321945f, 
    0.04798382f, -0.01319089f, -0.05363120f, -0.07040632f, -0.06088186f, -0.07377510f, -0.01013162f, 0.00611747f, 
    -0.04562554f, -0.07185709f, -0.00482812f, 0.02275908f, -0.04491513f, 0.03513338f, -0.06012313f, -0.06258268f, 
    -0.05364313f, -0.04586890f, 0.00442222f, 0.03901706f, -0.06211323f, 0.03697857f, -0.04088261f, -0.02151380f, 
    0.06034736f, 0.05443963f, 0.03489966f, 0.04484628f, -0.04282694f, -0.02455554f, -0.07035600f, -0.03457205f, 
    -0.04844477f, -0.04152481f, -0.07425820f, 0.05868544f, -0.03592303f, 0.01332072f, 0.02647737f, 0.04512953f, 
    0.02648430f, -0.07468430f, 0.05894556f, 0.05976006f, -0.02329365f, -0.00247679f, -0.04150733f, -0.02124098f, 
    -0.07405674f, 0.04911010f, 0.01196943f, -0.04383131f, -0.01955510f, -0.06776065f, -0.05263188f, -0.04156640f, 
    -0.06040606f, 0.00591994f, 0.00353652f, 0.05396336f, -0.07419152f, -0.04260845f, -0.07498541f, -0.07135715f, 
    0.03276054f, -0.00928176f, -0.02068627f, -0.01024454f, -0.06657635f, 0.00084310f, -0.05585712f, -0.02546882f, 
    -0.00213333f, 0.05811849f, -0.02107982f, 0.05484924f, 0.00595312f, -0.05696043f, -0.02878173f, -0.01237035f, 
    0.02546190f, 0.00604765f, -0.07379355f, -0.05693876f, 0.03325925f, 0.03527017f, -0.07155736f, 0.00441653f, 
    0.33397737f, -0.06054087f, -0.09746861f, 0.02472650f, 0.14539452f, 0.13159390f, -0.10502804f, 0.06355027f, 
    0.11875028f, 0.16660482f, 0.07378467f, 0.00891664f, -0.13621369f, 0.29995540f, 0.04142512f, -0.09277911f, 
    0.02060698f, 0.03343813f, 0.02720437f, -0.01629837f, 0.01556611f, 0.07274356f, 0.00295228f, -0.05313271f, 
    0.29281971f, -0.01903822f, 0.11330687f, -0.12756740f, -0.06551430f, -0.16694139f, -0.19239299f, 0.03572368f, 
    -0.03694491f, -0.01034117f, 0.03499049f, 0.03129186f, -0.06742814f, 0.05917325f, 0.19898924f, 0.12780271f, 
    -0.02136479f, -0.07275517f, 0.09696937f, -0.04878351f, -0.11436857f, -0.09460260f, -0.04838083f, 0.01674401f, 
    -0.33618477f, 0.20842031f, -0.12144387f, -0.02547946f, 0.06233242f, 0.11140151f, -0.00232142f, 0.03266813f, 
    -0.06044129f, 0.04872837f, -0.05614726f, -0.02925367f, 0.31056923f, -0.06423669f, -0.19445369f, 0.10493841f, 
    0.00616971f, -0.01600992f, -0.04218684f, -0.04745398f, -0.06467080f, 0.07150815f, -0.07356787f, 0.01040661f, 
    -0.05714147f, 0.08085694f, 0.00939866f, 0.06984867f, -0.01726242f, -0.11165148f, -0.10673601f, 0.07823558f, 
    -0.05560863f, 0.00622259f, 0.02219961f, -0.07654682f, -0.07277109f, -0.16003689f, -0.07914470f, 0.31039655f, 
    0.13186756f, 0.07690270f, 0.02558103f, 0.02247781f, -0.01972642f, -0.01523060f, 0.06087355f, -0.13666034f, 
    0.08432856f, 0.05551571f, 0.19180608f, 0.16540229f, -0.01966641f, -0.18044671f, 0.06671070f, -0.03258068f, 
    -0.06239324f, -0.03214371f, -0.00823098f, 0.00197716f, 0.27361080f, -0.12260449f, -0.02344147f, 0.29369691f, 
    -0.00829385f, -0.15266056f, 0.05181742f, 0.09112392f, 0.06668771f, 0.10286739f, 0.00536522f, 0.08113492f, 
    0.15905410f, 0.16974115f, 0.14919910f, 0.10732731f, 0.06159798f, -0.01357313f, -0.14588633f, 0.06924060f, 
    -0.02817503f, -0.10369740f, 0.07880929f, -0.06773419f, -0.34339347f, -0.16193336f, 0.20942450f, -0.09961735f, 
    0.06722227f, 0.06459071f, -0.06320240f, -0.08187538f, 0.00322681f, 0.00098633f, -0.07045420f, -0.02113244f, 
    0.24353769f, 0.06645805f, 0.08059297f, 0.14898120f, 0.00726129f, -0.07004617f, 0.07906110f, 0.11517593f, 
    -0.06691193f, -0.02210981f, 0.00402719f, -0.14090338f, 0.01597619f, 0.13099898f, -0.02417599f, -0.10053205f, 
    0.02826554f, 0.08377579f, 0.04907126f, 0.06064590f, 0.06020562f, -0.02137694f, -0.07582434f, 0.06720591f, 
    0.33385029f, 0.00510875f, -0.07275600f, -0.22421625f, 0.04079182f, -0.09071903f, -0.00001770f, 0.05188416f, 
    -0.06148279f, 0.10289104f, 0.03795964f, 0.05679425f, -0.16700141f, 0.16025376f, -0.01798017f, -0.19422209f, 
    0.03483637f, 0.06687406f, 0.07356355f, 0.03873019f, -0.01736704f, 0.09136587f, 0.13296451f, -0.10046852f, 
    -0.05653212f, -0.03568664f, 0.27147284f, -0.06336043f, -0.10183863f, 0.04633755f, -0.02078176f, -0.18354481f, 
    -0.05160621f, -0.06726528f, 0.08255254f, 0.04924496f, 0.25284600f, 0.06721239f, -0.11390997f, 0.03685066f, 
    -0.04175223f, -0.04977161f, -0.12432758f, 0.02501476f, -0.06161871f, -0.10592486f, 0.18025912f, 0.07637676f, 
    0.03849300f, -0.07904297f, 0.14212638f, 0.03852812f, -0.07262966f, 0.00480458f, 0.18759635f, 0.03357526f, 
    0.01372140f, -0.01493096f, 0.08183055f, -0.03296242f, -0.15208119f, 0.06738678f, 0.09701868f, 0.09018557f, 
    -0.07014195f, -0.04309928f, 0.09558224f, 0.10210394f, 0.02182322f, -0.00167056f, 0.09933135f, 0.05262088f, 
    0.28371564f, 0.17214189f, -0.05953615f, -0.10637977f, 0.03956740f, 0.01197666f, 0.00411550f, 0.15859208f, 
    0.10151427f, 0.09966593f, 0.04195292f, 0.08468815f, -0.37072390f, -0.10044131f, -0.01011509f, -0.35675019f, 
    0.06722558f, 0.15106310f, -0.07601074f, -0.00001207f, -0.06246818f, 0.00665310f, -0.00074200f, 0.03620817f, 
    -0.25078967f, -0.06669886f, 0.34275657f, 0.32357496f, 0.10105942f, 0.06309945f, 0.07583424f, 0.10668924f, 
    0.12328337f, -0.00170182f, -0.02720137f, 0.00146513f, -0.31892204f, 0.09224823f, 0.15582177f, -0.20581217f, 
    -0.09856841f, -0.02847089f, -0.01213282f, -0.10927988f, 0.08076847f, 0.05793548f, -0.06268094f, -0.14448147f, 
    -0.06235877f, -0.05068728f, -0.09224048f, 0.19975728f, 0.04750655f, 0.04234755f, 0.06093348f, 0.09356327f, 
    0.08523435f, 0.09706240f, 0.00653129f, 0.11653835f, -0.15691712f, -0.22038071f, 0.25641122f, -0.02922003f, 
    0.01232296f, 0.12927559f, 0.00855595f, -0.03436889f, -0.06406681f, -0.00531695f, -0.01488787f, -0.03425788f, 
    -0.01279652f, 0.01934401f, 0.28545940f, -0.02848756f, -0.00058828f, 0.10050123f, 0.14027564f, -0.04890431f, 
    -0.00393709f, 0.04895058f, 0.09257011f, 0.18531410f, 0.07520296f, 0.09897062f, -0.22864014f, -0.22436836f, 
    0.12362336f, -0.02950124f, 0.05343753f, 0.01551260f, -0.01668359f, -0.01836143f, -0.02891711f, -0.12821528f, 
    0.16683488f, 0.22269601f, -0.11992036f, -0.07721278f, 0.16027342f, 0.01800176f, 0.02393016f, 0.08275340f, 
    -0.02449729f, -0.06908949f, -0.01924540f, 0.12272441f, -0.12207508f, -0.06528594f, 0.14620620f, -0.00989799f, 
    0.04702325f, 0.09341128f, -0.00217897f, 0.09757645f, -0.02314346f, -0.01058829f, 0.02476417f, -0.02304208f, 
    -0.48497149f, 0.18362772f, 0.09104089f, -0.22328103f, 0.02111752f, 0.12676510f, 0.15050711f, -0.00283567f, 
    0.13499130f, 0.02044073f, -0.00895634f, 0.00743095f, 0.01155666f, -0.12717597f, -0.06471406f, 0.04513516f, 
    -0.00898248f, 0.06215447f, 0.10334140f, -0.00496353f, 0.07448446f, -0.13973475f, 0.12009023f, 0.15206568f, 
    0.23987004f, 0.12624402f, 0.00374006f, 0.04422349f, 0.00560373f, 0.07407212f, -0.01563645f, 0.00899998f, 
    0.00288108f, -0.05605892f, 0.25247386f, -0.03640084f, -0.09094484f, -0.00359578f, 0.03768937f, 0.00983440f, 
    -0.02308242f, -0.03221439f, -0.00443974f, 0.18581533f, -0.07044427f, 0.00947984f, 0.17276962f, -0.01391498f, 
    0.16862057f, 0.12371892f, 0.12090434f, -0.13864017f, -0.09483150f, -0.14291614f, -0.05665072f, -0.15668647f, 
    -0.05546220f, -0.07311271f, 0.02605366f, -0.15572889f, 0.10672123f, -0.00647619f, -0.18914039f, 0.02791720f, 
    0.07761312f, -0.04312602f, 0.07594033f, -0.03760273f, -0.09357829f, -0.01353835f, -0.09185766f, 0.07338790f, 
    -0.28080484f, -0.10072611f, 0.02800545f, 0.01683934f, -0.02258303f, 0.04262668f, 0.09114280f, -0.00985556f, 
    0.04209412f, 0.00702133f, 0.03588003f, -0.01690476f, -0.20721048f, -0.06729723f, -0.17863384f, -0.17922656f, 
    0.12874579f, -0.00844204f, -0.03392100f, -0.04091507f, 0.03260083f, 0.06443577f, 0.05978583f, 0.02649582f, 
    -0.04796206f, -0.01309590f, 0.15131533f, 0.20887248f, 0.15274766f, 0.06280978f, 0.01319939f, 0.14353274f, 
    0.03506682f, 0.04622833f, 0.00313487f, -0.19876033f, -0.18252294f, 0.04696955f, -0.02773706f, -0.14043070f, 
    0.02795341f, 0.14948992f, 0.10337893f, -0.01752451f, 0.05854649f, -0.10239910f, -0.07379483f, -0.11657343f, 
    0.01347143f, 0.03732811f, 0.07201783f, 0.09824617f, -0.02095891f, -0.04430952f, -0.04428112f, -0.09315389f, 
    -0.02005125f, 0.05024593f, 0.03189081f, -0.00685768f, 0.39138946f, -0.31288859f, 0.10531319f, 0.40206459f, 
    0.01194687f, -0.01804517f, -0.12342139f, 0.10730450f, -0.06467824f, -0.10036219f, 0.10645449f, 0.00611569f, 
    0.27003071f, 0.22457717f, 0.15975884f, 0.09694020f, 0.02058363f, -0.04123304f, -0.00319082f, 0.00936059f, 
    -0.05704326f, 0.00155758f, 0.13453813f, 0.09402873f, -0.08030691f, -0.12756468f, -0.06502692f, -0.11160415f, 
    0.11956632f, 0.07943594f, 0.08134011f, -0.11304370f, -0.12035456f, 0.05054740f, -0.05610571f, 0.07291619f, 
    0.33914077f, 0.12983918f, -0.03288506f, 0.29603371f, 0.05284920f, 0.06602847f, 0.02031834f, 0.04362893f, 
    -0.03453257f, -0.02895856f, 0.02432225f, 0.10087771f, 0.12998790f, -0.28523755f, -0.03363094f, -0.03854890f, 
    0.10907675f, 0.02340383f, 0.01809819f, 0.08841959f, 0.01067911f, 0.06025841f, -0.10893238f, 0.11868761f, 
    -0.33307442f, 0.04213245f, 0.02135136f, -0.09103096f, 0.04975288f, 0.02722104f, 0.13356645f, -0.05487962f, 
    0.00103939f, 0.17900623f, 0.00472174f, 0.02836882f, -0.26304618f, 0.00787272f, -0.03408000f, -0.12396359f, 
    0.01760421f, 0.06505914f, 0.00931918f, 0.12869136f, 0.14525191f, -0.04774959f, 0.18236741f, 0.08238513f, 
    0.06587985f, -0.05564075f, -0.01141231f, -0.05090708f, -0.03299326f, -0.00888817f, 0.05734891f, 0.00136977f, 
    -0.07905263f, 0.00095397f, -0.04761105f, 0.01051777f, 0.04818708f, -0.00501735f, 0.03670326f, 0.04277504f, 
    0.01145428f, -0.02517918f, -0.01205127f, -0.04054546f, 0.03447578f, -0.04422748f, 0.06234502f, -0.04243444f, 
    0.03106745f, -0.03053610f, -0.07069097f, -0.05927798f, -0.07549627f, -0.06927583f, -0.01473037f, 0.00834873f, 
    -0.03829916f, 0.03399906f, -0.00687243f, 0.00388295f, -0.01323073f, -0.05405124f, -0.06956392f, 0.01281416f, 
    -0.01820558f, -0.06045949f, 0.01258359f, -0.02599924f, 0.00538694f, 0.06279828f, 0.02379090f, 0.05519559f, 
    0.00405842f, 0.05764102f, -0.02916451f, -0.06469378f, 0.03456873f, 0.04274113f, -0.03541768f, 0.03154644f, 
    0.00405833f, 0.02914638f, 0.00651116f, -0.05376570f, 0.00060279f, 0.02473455f, -0.05246807f, 0.05708635f, 
    -0.06426253f, 0.01612215f, -0.06806862f, 0.00698342f, 0.00336308f, -0.00404351f, 0.02739806f, 0.04949908f, 
    -0.07278943f, -0.06499650f, 0.00488017f, 0.02659906f, -0.00099347f, -0.07315735f, -0.02043982f, 0.05066236f, 
    -0.07111212f, 0.04367961f, 0.03783520f, 0.01984982f, 0.02420014f, -0.06488936f, -0.03426246f, 0.03382275f, 
    -0.05506095f, -0.06356607f, 0.01693999f, -0.06547670f, -0.05667739f, 0.00011715f, -0.03169601f, -0.05515337f, 
    -0.05248604f, 0.01328696f, 0.00680081f, -0.02985222f, -0.06323414f, 0.03839691f, 0.04529543f, 0.05951522f, 
    0.01685382f, 0.05220151f, 0.04204090f, 0.04394079f, -0.07146551f, 0.00546882f, -0.00902783f, -0.06131118f, 
    0.00745258f, 0.00547848f, 0.00601378f, 0.04305600f, -0.04485898f, -0.07585175f, 0.00166907f, -0.01302133f, 
    0.06686670f, 0.06288356f, 0.00570945f, -0.03740177f, -0.04783754f, -0.06835919f, -0.05102212f, -0.01389505f, 
    -0.04798530f, -0.00578615f, 0.03047142f, -0.06017386f, 0.04468001f, -0.01450677f, 0.05032742f, 0.04000434f, 
    0.04467328f, 0.06027780f, 0.04900642f, -0.07240770f, 0.00092224f, -0.02768143f, 0.03751983f, -0.01815836f, 
    -0.06242297f, -0.06824545f, 0.04273848f, -0.00021071f, -0.03005804f, -0.03979985f, 0.03897027f, -0.06550373f, 
    0.05008528f, -0.05331916f, -0.01988303f, 0.03056988f, -0.07671058f, 0.01194263f, 0.03752474f, 0.05892218f, 
    0.01110838f, 0.03899980f, -0.03645035f, -0.03273307f, -0.00394581f, 0.03522019f, 0.03881559f, -0.00548548f, 
    -0.05272522f, 0.03633074f, -0.06784806f, -0.06114127f, -0.03140921f, 0.00038890f, 0.02809841f, -0.00613148f, 
    0.02693674f, 0.00980562f, 0.02325799f, 0.01383075f, 0.05932228f, -0.04644213f, -0.05409549f, -0.05008304f, 
    -0.04410833f, -0.07685158f, -0.02930995f, 0.01204282f, -0.07743375f, -0.05637782f, -0.05552318f, -0.03499625f, 
    -0.03749452f, -0.04601591f, -0.03022182f, -0.01341986f, -0.04616786f, 0.03155199f, -0.04294020f, 0.03640483f, 
    -0.05906524f, -0.07110315f, -0.03733052f, -0.06631873f, 0.06521404f, 0.06269348f, -0.00391276f, -0.04079512f, 
    0.02423549f, 0.05249530f, 0.05824000f, -0.06301938f, -0.03748819f, 0.05732723f, -0.05102604f, 0.03528525f, 
    -0.00222923f, -0.07541957f, 0.02915458f, 0.01333117f, -0.07229127f, -0.01801910f, -0.06135879f, 0.05306856f, 
    -0.00994909f, -0.02319976f, -0.03715239f, 0.04704129f, -0.04045544f, -0.07205182f, -0.02342281f, 0.00231729f, 
    0.03639781f, 0.05321654f, -0.01635130f, -0.06454969f, -0.05164605f, -0.04590566f, -0.01828654f, -0.02232457f, 
    0.01224688f, -0.06288259f, -0.02241389f, 0.01686572f, -0.03913770f, -0.02777608f, 0.00968314f, 0.03722950f, 
    0.02770963f, 0.01216198f, -0.04298685f, -0.00987427f, 0.00568768f, 0.02175220f, -0.04492519f, -0.01761853f, 
    0.03040643f, -0.03913496f, -0.05936042f, -0.02722929f, 0.06330433f, 0.01903133f, 0.06214775f, -0.01077392f, 
    0.00247491f, -0.01818720f, -0.03072597f, 0.05351838f, 0.05887439f, -0.07524741f, -0.04491860f, -0.04008665f, 
    -0.07581919f, -0.06697533f, -0.05834810f, 0.06173153f, -0.03781429f, 0.04437955f, -0.03558111f, 0.04250631f, 
    0.04152919f, -0.02621685f, 0.06279156f, 0.00213319f, -0.03026610f, -0.06138480f, 0.01331682f, -0.00210604f, 
    0.06221614f, -0.01021869f, 0.03788078f, -0.02592493f, 0.03868328f, -0.04780801f, -0.06631942f, 0.03641757f, 
    -0.07130453f, 0.04192218f, 0.01285168f, -0.05969170f, 0.05154771f, 0.04088445f, 0.00554330f, 0.00051507f, 
    -0.07240228f, -0.06314390f, -0.01698395f, 0.05426794f, -0.00580981f, 0.04011444f, -0.06500575f, 0.06313208f, 
    -0.01939547f, -0.05617039f, -0.04781094f, -0.01405400f, -0.04097220f, -0.06134639f, 0.06146633f, 0.01373607f, 
    0.01298563f, -0.07449311f, -0.07360181f, -0.01618990f, -0.03221055f, 0.02633417f, 0.05799011f, -0.06629772f, 
    -0.01197365f, 0.03958438f, -0.02623918f, 0.00471319f, -0.01871364f, -0.05595584f, 0.00201055f, -0.01330744f, 
    -0.03641784f, 0.02763348f, -0.01648948f, 0.04384717f, 0.00634459f, -0.03411729f, -0.07716153f, -0.01711982f, 
    -0.03062292f, 0.04630244f, -0.06903213f, -0.07450039f, -0.01111615f, -0.00597234f, -0.02672355f, -0.06580413f, 
    0.03350134f, -0.00803968f, 0.03496956f, -0.07711785f, 0.05741753f, -0.00697398f, 0.03514716f, 0.02149001f, 
    -0.02058660f, 0.00225091f, 0.02898609f, 0.01785601f, -0.05750408f, 0.04106788f, -0.06681652f, -0.00057520f, 
    0.03479570f, 0.05718750f, 0.00955181f, 0.01793437f, -0.06780611f, -0.03223708f, -0.03814794f, 0.01702855f, 
    -0.02754022f, 0.00397245f, -0.00286702f, -0.04838247f, 0.06419431f, -0.05569759f, -0.05492963f, -0.05004892f, 
    -0.13640876f, 0.12462123f, 0.05217052f, 0.01571231f, 0.03611809f, 0.01946655f, 0.00756527f, 0.00118860f, 
    0.22360094f, 0.13199411f, -0.02013797f, 0.00835913f, 0.11351057f, 0.15573321f, -0.00358131f, 0.08619079f, 
    0.01774373f, -0.09541307f, 0.14832085f, 0.01149216f, 0.03725887f, 0.05067808f, 0.03477734f, 0.03424958f, 
    -0.10374394f, -0.14654061f, -0.02764557f, -0.16680402f, -0.01739902f, -0.16694812f, 0.08939657f, -0.00183270f, 
    0.04605608f, 0.04971837f, -0.03342149f, -0.02931123f, -0.21746190f, 0.02389881f, 0.19041711f, 0.09308683f, 
    -0.20609677f, -0.26072165f, 0.06568690f, -0.10105117f, -0.07322329f, -0.03835381f, 0.06195179f, 0.03279025f, 
    0.37655762f, 0.19326870f, 0.00542204f, -0.14197840f, -0.03057363f, 0.03412296f, -0.04837054f, 0.26389948f, 
    0.00731453f, -0.03097824f, -0.02700575f, -0.08672632f, -0.07730734f, -0.24975418f, -0.18293253f, -0.04994356f, 
    0.11585934f, 0.04289110f, -0.08172116f, -0.01109783f, 0.11795222f, 0.15693085f, 0.04148864f, 0.09089275f, 
    0.09095812f, -0.06407956f, -0.11320324f, 0.21711980f, 0.01769880f, 0.06867077f, 0.20810801f, -0.07083203f, 
    0.07435463f, -0.11687914f, -0.09927095f, 0.05642924f, -0.12267177f, 0.18568288f, 0.06741928f, 0.23701456f, 
    -0.01407202f, -0.05503774f, -0.02287622f, 0.05333101f, -0.05664212f, 0.03149484f, 0.05785984f, -0.02620895f, 
    -0.01021403f, -0.06633167f, -0.11981491f, 0.04822676f, -0.05352957f, 0.03765497f, 0.01200015f, -0.03968241f, 
    0.02912293f, -0.08322708f, -0.05873402f, -0.00423096f, -0.10873917f, 0.07044585f, 0.15012178f, -0.05646025f, 
    0.00420572f, -0.01350286f, 0.01621253f, -0.11369900f, 0.11688917f, -0.05179563f, 0.06996715f, 0.03945217f, 
    -0.21229985f, 0.04256611f, 0.12285466f, -0.19655363f, -0.01526108f, 0.09887359f, 0.09518424f, -0.07593160f, 
    0.10300492f, 0.02380636f, 0.09153264f, 0.14720839f, -0.39203650f, 0.00175893f, 0.07006117f, -0.02394219f, 
    0.08539685f, 0.02387804f, -0.03557778f, 0.10637624f, -0.00362978f, -0.02434442f, 0.04693178f, 0.01072759f, 
    0.03402187f, 0.04037329f, -0.01061549f, -0.31067875f, 0.05965644f, 0.02443236f, -0.03878249f, -0.01016373f, 
    0.08359673f, -0.06439556f, 0.09700859f, 0.00380754f, -0.56150782f, 0.08307221f, -0.05255152f, 0.15271260f, 
    -0.10362257f, -0.02603211f, -0.04497131f, 0.08149412f, 0.03382686f, 0.17410789f, 0.01926684f, -0.04641332f, 
    0.06234301f, -0.20578122f, 0.01770669f, -0.02875417f, 0.11588255f, 0.22383931f, 0.03701884f, 0.01198896f, 
    0.10043783f, 0.05803810f, 0.10493074f, 0.12947600f, -0.08712730f, -0.17356302f, 0.01525050f, 0.01287827f, 
    -0.03470740f, 0.06897996f, -0.03183520f, 0.06130331f, -0.07487161f, -0.03481570f, -0.05481658f, 0.07807931f, 
    -0.18165828f, 0.06681085f, -0.16721180f, 0.10051559f, -0.07371536f, 0.00352492f, 0.04032349f, 0.04556941f, 
    -0.03791769f, 0.01450624f, 0.04735390f, -0.08350360f, 0.05573573f, 0.22882745f, 0.13085532f, -0.05214589f, 
    0.04794919f, -0.05423202f, 0.03085298f, 0.07025102f, -0.02926512f, -0.13674539f, 0.05311240f, 0.07678902f, 
    -0.18476759f, -0.01722643f, -0.02491442f, 0.10597524f, -0.14758599f, -0.05824524f, 0.03948263f, 0.01709703f, 
    0.09029604f, -0.00951578f, 0.07488751f, 0.05165756f, -0.30050412f, -0.07193293f, -0.04849055f, -0.17901281f, 
    0.01565892f, 0.04394857f, 0.05656252f, 0.04132463f, -0.02179034f, 0.06072946f, -0.00665668f, 0.07386626f, 
    0.24222268f, 0.09323045f, 0.03957710f, 0.10122319f, 0.03291560f, -0.04911755f, 0.05038028f, 0.11049338f, 
    0.02838701f, 0.01087740f, -0.01699267f, 0.02336502f, -0.12283612f, 0.08451862f, 0.04685657f, -0.04594415f, 
    -0.21317448f, -0.05496358f, -0.00658390f, 0.07601485f, 0.00674088f, 0.11369517f, 0.00210981f, 0.00689557f, 
    0.17601654f, 0.04013677f, -0.08321343f, -0.03579007f, 0.02940654f, -0.02551913f, 0.15281293f, 0.02547709f, 
    0.03456543f, -0.02616911f, -0.02979541f, 0.05425414f, -0.05932669f, 0.04024425f, 0.26388371f, 0.12169645f, 
    -0.18652506f, 0.05807433f, -0.00940484f, -0.07753041f, 0.07527263f, -0.07060888f, -0.00932387f, -0.18017249f, 
    -0.08359945f, 0.08454326f, -0.15225975f, -0.27034867f, 0.05250854f, 0.02986159f, 0.07394315f, 0.09254367f, 
    -0.03941505f, 0.04640503f, -0.04904962f, 0.00186491f, -0.14134231f, -0.04182793f, 0.12360229f, -0.09558684f, 
    -0.08781739f, -0.02273049f, -0.08796844f, 0.08898638f, -0.08520590f, 0.00568046f, -0.01203700f, -0.05570331f, 
    -0.10867959f, 0.12953264f, 0.21450478f, 0.10310967f, 0.02249702f, 0.13198784f, -0.09636103f, 0.00771635f, 
    0.06766414f, 0.03586859f, -0.03918656f, 0.08750837f, 0.20675863f, 0.08580300f, -0.01141618f, 0.05503651f, 
    -0.08457367f, 0.01022877f, 0.02868270f, 0.09689623f, 0.12736130f, 0.04525654f, 0.14589348f, -0.06251941f, 
    0.03303207f, -0.01177743f, 0.29810384f, -0.26435128f, 0.06764486f, 0.07996178f, -0.06418994f, 0.00551754f, 
    -0.04772993f, 0.01664740f, 0.01375079f, 0.04971063f, -0.55177927f, 0.02417346f, 0.06620581f, 0.02764156f, 
    -0.03877671f, -0.04307458f, 0.03969317f, -0.03306348f, 0.04846071f, 0.05124796f, -0.11604658f, 0.02897713f, 
    -0.10337933f, 0.14538723f, -0.11389268f, 0.11126193f, -0.11529174f, 0.25075623f, -0.00195561f, 0.09042562f, 
    0.08646812f, -0.02165504f, -0.07953227f, -0.03998213f, 0.24157199f, -0.01570793f, 0.04179050f, 0.28714699f, 
    -0.09834947f, 0.08095380f, 0.06770959f, -0.02617472f, 0.00217545f, 0.02170503f, 0.13824303f, 0.05023355f, 
    0.04082485f, -0.05978820f, 0.04478575f, 0.00246861f, -0.02664603f, 0.06669776f, -0.03214246f, -0.04964310f, 
    -0.00389062f, 0.03616769f, 0.02156308f, -0.07531081f, -0.05976353f, -0.02067687f, -0.03121450f, -0.06679513f, 
    -0.03129079f, 0.01714038f, -0.03197070f, 0.00878738f, -0.03091055f, -0.05596229f, 0.04630684f, -0.06662745f, 
    0.01230597f, -0.00156679f, -0.00023058f, -0.01760778f, 0.03878762f, 0.02776624f, -0.00657043f, -0.00432428f, 
    0.03387042f, -0.01411476f, 0.01169959f, 0.01771408f, -0.06265891f, -0.04072349f, -0.05950043f, 0.03246571f, 
    0.05662025f, -0.04553655f, -0.02987057f, 0.06129107f, -0.02378298f, 0.03946777f, 0.00130565f, -0.08128455f, 
    -0.05984478f, 0.01031090f, -0.02332886f, 0.02351037f, 0.00828098f, 0.01913331f, -0.05867418f, -0.03834976f, 
    -0.03655626f, 0.00838053f, 0.00510212f, -0.05912043f, 0.02391037f, -0.04218904f, 0.00714387f, 0.02710754f, 
    0.04619605f, -0.00792387f, -0.03920762f, 0.06737550f, -0.06356963f, -0.00971354f, 0.04691292f, -0.00277957f, 
    0.02988460f, -0.01944967f, 0.05556394f, -0.04568069f, 0.02252744f, 0.01900929f, 0.00838412f, -0.06902381f, 
    0.03360556f, 0.06277355f, -0.02210212f, -0.06016709f, -0.05902878f, -0.03497135f, -0.07261024f, 0.04452902f, 
    -0.04369442f, -0.05692295f, -0.01346962f, -0.07345369f, -0.01870190f, 0.06236654f, -0.05991086f, -0.06880535f, 
    -0.03896362f, -0.06121568f, -0.00229758f, -0.00947869f, 0.03276551f, -0.02823742f, 0.02784844f, -0.04416206f, 
    -0.04940838f, 0.03081214f, -0.06228971f, -0.00838910f, -0.06808008f, 0.00417597f, 0.02280094f, 0.04553135f, 
    -0.00802606f, -0.02074048f, -0.04555232f, 0.03249297f, 0.01315958f, -0.05664651f, -0.02054277f, -0.06970491f, 
    0.05445712f, 0.01996947f, -0.06994485f, 0.04747270f, 0.04144182f, -0.04423600f, 0.02741445f, 0.04436463f, 
    -0.05051113f, -0.07819501f, -0.03710829f, 0.01810441f, -0.06034441f, -0.08389386f, -0.05314166f, -0.04104320f, 
    -0.00025729f, -0.02785635f, 0.04051940f, 0.05713101f, -0.07619489f, -0.06322600f, -0.02298154f, 0.05587896f, 
    -0.04274708f, -0.01566645f, 0.04630319f, 0.00704223f, -0.00003113f, -0.05656217f, 0.03181776f, 0.02235768f, 
    0.02540882f, -0.07758795f, 0.01933450f, -0.01839397f, 0.06103776f, -0.07324005f, -0.05051268f, 0.03813895f, 
    0.04609422f, -0.03126303f, -0.01540562f, 0.02259544f, -0.00049024f, 0.04027410f, 0.02443420f, -0.04740056f, 
    0.01543377f, -0.06705926f, -0.00208609f, 0.03506038f, 0.02794550f, -0.01009298f, -0.02803001f, -0.05757414f, 
    0.05986784f, -0.07925617f, 0.01353697f, 0.04636666f, 0.02735492f, -0.01559815f, -0.01984788f, 0.03310852f, 
    0.04593887f, -0.05502927f, -0.04815641f, 0.02356931f, 0.04301195f, -0.02235426f, 0.02894189f, -0.07936078f, 
    0.02814030f, 0.04564068f, -0.06979632f, -0.04580264f, 0.01932281f, -0.02114418f, -0.05475526f, -0.02901734f, 
    -0.02489735f, -0.05020264f, 0.01990806f, 0.01107991f, -0.00879446f, -0.07680265f, 0.01841685f, -0.02064742f, 
    -0.04459775f, 0.03198725f, 0.00469651f, -0.06111250f, -0.05053804f, -0.03685577f, 0.04734658f, 0.02597530f, 
    0.02294776f, -0.02503866f, 0.04885527f, -0.07554097f, -0.05644015f, -0.01019807f, -0.05905064f, -0.03980663f, 
    -0.00364509f, -0.05072850f, 0.04504213f, 0.00538224f, -0.01487608f, -0.06688325f, -0.05894823f, -0.06389409f, 
    0.01570951f, 0.04267662f, 0.00162424f, -0.05716899f, 0.01251958f, -0.05017172f, 0.00772138f, -0.00928341f, 
    -0.07525922f, -0.05215988f, -0.00711010f, -0.06324161f, -0.03250585f, 0.00426694f, -0.04695584f, -0.04209915f, 
    0.00583737f, -0.05750295f, 0.04421426f, -0.02199847f, -0.06620965f, -0.04964856f, -0.06958529f, -0.00084024f, 
    -0.00470100f, -0.00802135f, -0.01114041f, -0.06893172f, -0.03043959f, -0.06427684f, 0.03246441f, -0.00099858f, 
    -0.01616447f, 0.03848556f, -0.01512633f, -0.07375479f, 0.03521613f, 0.01165879f, -0.01306775f, 0.01911278f, 
    -0.04425842f, 0.03899665f, 0.00987280f, -0.02210397f, -0.01604651f, -0.03577090f, -0.04972620f, -0.02653175f, 
    0.01107350f, 0.01852392f, 0.01521527f, 0.05012549f, -0.07548186f, -0.01424426f, 0.02499011f, 0.02227979f, 
    0.00188189f, 0.00126770f, 0.04288953f, -0.06836261f, -0.03234957f, 0.06146202f, -0.01835889f, -0.04797066f, 
    -0.05248396f, -0.00644750f, 0.01164008f, -0.02217350f, 0.00313234f, 0.02163335f, 0.01205443f, 0.05165655f, 
    0.02106867f, 0.05929987f, 0.04043153f, -0.04559378f, 0.06218539f, 0.00161109f, 0.01989343f, 0.00879406f, 
    0.01503115f, 0.04214383f, 0.04288058f, -0.05187537f, 0.04019971f, -0.02746584f, -0.06011305f, 0.02385213f, 
    0.03234533f, 0.02121622f, -0.03527157f, -0.05754016f, -0.00102777f, 0.01447012f, -0.00256617f, -0.04688455f, 
    0.05009482f, 0.02697644f, 0.05680057f, 0.03220553f, -0.01890193f, 0.02164070f, 0.01633562f, -0.03881640f, 
    -0.01119003f, -0.06070169f, -0.03055678f, -0.00893242f, -0.05093919f, -0.03649815f, 0.05606937f, -0.00789830f, 
    -0.04960155f, -0.06897715f, -0.07513691f, 0.06017549f, -0.02798289f, 0.04711632f, -0.01101175f, -0.00594337f, 
    0.05226202f, -0.02242492f, -0.03606689f, -0.05998525f, -0.04888276f, -0.03583361f, 0.05722982f, 0.04705037f, 
    -0.03212329f, -0.04479524f, -0.02363252f, -0.04437839f, 0.02893967f, 0.05574153f, -0.06177879f, -0.04623143f, 
    -0.02750735f, -0.04288985f, -0.02135408f, 0.00601079f, 0.03700834f, 0.01231530f, -0.02680870f, -0.05971964f, 
    0.05106193f, 0.04631806f, -0.02554049f, 0.05475652f, 0.05762399f, -0.05121191f, 0.06063280f, 0.06601591f, 
    -0.07177934f, 0.01835473f, -0.06346622f, -0.03586389f, 0.02426865f, -0.05186045f, 0.04730457f, -0.05283943f, 
    0.01967425f, 0.04045147f, -0.00388674f, 0.04776152f, 0.01886664f, -0.03055766f, 0.02765866f, 0.05400433f, 
    -0.02439295f, 0.01610130f, -0.03210539f, -0.07697261f, 0.02456675f, -0.04604981f, -0.03741228f, -0.05805227f, 
    0.04731590f, -0.04312047f, -0.05480250f, 0.01129808f, -0.03089934f, 0.02242801f, 0.00218067f, -0.03227844f, 
    -0.03299523f, 0.05748876f, 0.06410541f, -0.03524717f, 0.00024590f, -0.07562172f, -0.00267975f, -0.04190186f, 
    0.00840047f, -0.05968396f, 0.03462363f, -0.05567340f, -0.00401007f, 0.00422127f, -0.01124084f, -0.00442151f, 
    0.02609685f, -0.00110736f, 0.05974035f, -0.02123549f, -0.04248977f, 0.04743515f, -0.00385193f, 0.01476141f, 
    -0.04380715f, 0.03008460f, -0.01769107f, -0.00722170f, 0.06339498f, 0.05265656f, -0.05513811f, 0.04397099f, 
    0.04948034f, -0.07367489f, 0.05539266f, 0.03112188f, -0.01196366f, -0.00497181f, -0.03435799f, -0.02845966f, 
    0.00219056f, -0.03191797f, -0.02523297f, 0.00036678f, -0.02125338f, -0.07308097f, 0.01053248f, 0.03391838f, 
    -0.03750427f, -0.00093891f, -0.00151099f, 0.01851186f, -0.05092883f, -0.04867011f, 0.04387083f, 0.01022128f, 
    -0.07948560f, -0.00159282f, 0.04108652f, 0.05622656f, -0.06116226f, -0.00331986f, -0.04859472f, 0.04398715f, 
    -0.06902471f, -0.04926927f, -0.00524986f, 0.00364559f, -0.07157476f, -0.01748799f, -0.05672457f, -0.03480507f, 
    -0.07678690f, -0.05943080f, -0.00960739f, -0.06832996f, -0.07654525f, -0.01453924f, -0.06526029f, 0.03112054f, 
    0.02754286f, -0.04222233f, -0.07071050f, 0.01946409f, -0.02197107f, -0.04699984f, -0.07062859f, 0.03567189f, 
    -0.02220241f, 0.06292538f, -0.07115457f, -0.05936019f, 0.01454404f, 0.01256040f, -0.00594693f, 0.05437262f, 
    0.03850759f, 0.05589319f, 0.02405865f, 0.01728519f, -0.02557281f, -0.05849805f, -0.06512103f, -0.01799620f, 
    0.04305784f, 0.02939800f, 0.01112785f, 0.01648730f, -0.00967119f, -0.06329155f, -0.07029067f, 0.05508221f, 
    -0.05283716f, 0.02574426f, 0.04103398f, -0.04263649f, -0.06534904f, -0.05424713f, -0.06503822f, -0.00777855f, 
    0.04979870f, 0.03407015f, -0.07724367f, 0.00489586f, 0.04928144f, -0.01933019f, -0.05643357f, 0.01192364f, 
    -0.00903479f, -0.05477001f, 0.03665131f, 0.01836479f, 0.01127744f, 0.06537197f, -0.06861967f, 0.01729429f, 
    -0.04766962f, -0.08412217f, 0.00737398f, 0.05132334f, 0.02682771f, 0.04974787f, -0.05068715f, -0.02734609f, 
    0.00387269f, 0.05270435f, -0.02438320f, 0.00112941f, -0.01071697f, 0.03616162f, -0.02812592f, 0.04928502f, 
    -0.02610679f, -0.01171430f, -0.08090708f, 0.04249085f, 0.01292070f, 0.00169919f, -0.04075824f, -0.00774316f, 
    -0.03547671f, -0.05147444f, 0.00291147f, 0.00805044f, 0.00415985f, 0.02768850f, 0.01723306f, 0.04615020f, 
    0.02029936f, -0.02318650f, -0.07799660f, 0.03074164f, -0.03151401f, -0.04750488f, 0.00564769f, 0.05985221f, 
    -0.05748620f, 0.03029171f, 0.04342502f, -0.03542786f, 0.02168104f, -0.00328285f, 0.04572845f, -0.06070347f, 
    -0.07772754f, -0.06809365f, 0.01869064f, -0.02141093f, -0.05117643f, 0.01342189f, 0.01421969f, 0.04260483f, 
    0.02818421f, -0.02275987f, -0.00149983f, -0.02393873f, -0.07718943f, -0.06061928f, -0.07119709f, 0.05409179f, 
    0.04416185f, -0.05553746f, -0.04406591f, -0.00093866f, -0.01001329f, 0.05265187f, 0.04286713f, -0.02760243f, 
    -0.07596114f, 0.00480983f, -0.01879025f, -0.06079584f, 0.05688069f, -0.04405519f, 0.02685861f, 0.03154097f, 
    -0.03169994f, -0.00705606f, 0.04429964f, 0.02867994f, -0.06164266f, 0.06952509f, -0.01204548f, -0.05705399f, 
    0.02744618f, -0.01241644f, 0.03664337f, -0.02268105f, -0.07276097f, 0.04656367f, 0.01054122f, -0.00637067f, 
    0.02079256f, 0.05865243f, -0.00683775f, -0.01718516f, 0.02198320f, 0.02506633f, -0.02950224f, -0.00401808f, 
    0.01765343f, -0.06401527f, 0.06183942f, 0.02994508f, 0.02325906f, 0.05340530f, -0.03252998f, 0.04784974f, 
    0.04582927f, 0.04566599f, -0.03615027f, 0.05100169f, 0.06193720f, 0.03185857f, -0.05392266f, 0.03592559f, 
    -0.05028896f, -0.06119477f, -0.06089294f, 0.02018197f, -0.05371603f, -0.06421264f, -0.07441623f, -0.03880198f, 
    0.03201306f, 0.03890095f, -0.04437861f, 0.01929931f, 0.00929031f, 0.05670807f, -0.04885727f, -0.00763080f, 
    0.02981916f, -0.04130530f, 0.03819408f, -0.05233644f, -0.03494353f, -0.05170039f, 0.00910450f, -0.03104555f, 
    -0.02974747f, 0.05222261f, -0.01058067f, 0.05198978f, -0.06434094f, -0.05963708f, -0.06183849f, 0.00224195f, 
    -0.05680160f, 0.04529660f, 0.06257042f, -0.02099156f, 0.01997872f, 0.03288009f, 0.03075898f, -0.01219466f, 
    -0.04534676f, -0.03358931f, -0.03639500f, -0.03838359f, -0.04632223f, 0.05404798f, -0.05620145f, -0.05826499f, 
    0.01567441f, -0.02370169f, -0.07359954f, 0.02062733f, 0.02186503f, -0.00327446f, 0.01856637f, -0.02696205f, 
    -0.00795085f, 0.01769199f, 0.04958797f, -0.01857970f, -0.05637319f, -0.07641102f, -0.07595509f, -0.05212857f, 
    -0.05762591f, -0.06420773f, 0.05828577f, 0.00352474f, -0.04331343f, 0.03220290f, -0.06318486f, 0.00746501f, 
    0.03727943f, -0.05279470f, -0.07234610f, -0.04065535f, -0.00138982f, -0.04225349f, 0.03253277f, 0.00906028f, 
    -0.07009209f, 0.02487764f, 0.04357865f, -0.06124671f, -0.05791689f, 0.02594660f, -0.01328046f, 0.01532182f, 
    0.02663100f, -0.05661281f, -0.01523776f, 0.02460215f, -0.05555929f, 0.01032520f, -0.05777542f, 0.00018939f, 
    -0.02899518f, -0.01124391f, 0.02955064f, 0.07945336f, -0.12764081f, 0.07832969f, 0.10639472f, -0.00692329f, 
    -0.06307644f, -0.12524264f, 0.17327379f, 0.08590583f, 0.09105297f, 0.30447108f, 0.03829827f, -0.27918729f, 
    0.10507765f, 0.07547727f, 0.11847458f, -0.07599753f, 0.04888064f, -0.05514562f, 0.12086168f, 0.04794887f, 
    -0.02934464f, -0.16793084f, -0.09721460f, 0.11866693f, 0.05679049f, 0.00880496f, 0.08124960f, 0.03945749f, 
    0.10780457f, -0.05553758f, -0.00305266f, 0.01144377f, -0.06889275f, 0.00310010f, -0.23134969f, -0.12136669f, 
    0.17319559f, 0.01588080f, -0.01704550f, -0.03975948f, -0.05998747f, 0.06140463f, 0.05657879f, 0.05759863f, 
    -0.19482702f, 0.13983998f, -0.02098663f, -0.03078991f, 0.12979226f, -0.06116422f, 0.05979912f, 0.07964513f, 
    0.06086638f, -0.00944698f, 0.02984197f, 0.01524581f, -0.06872742f, -0.14165850f, 0.18711303f, -0.16461369f, 
    -0.08231995f, -0.03098760f, 0.01601352f, 0.03370575f, 0.07393628f, -0.06331854f, -0.16572508f, 0.08171322f, 
    0.00336241f, -0.17282063f, 0.28663063f, -0.07587990f, 0.02678222f, 0.02074292f, 0.09146021f, 0.11465012f, 
    -0.01338165f, 0.00851569f, 0.06852261f, -0.07248260f, -0.27305612f, -0.00012917f, 0.30465019f, 0.13298221f, 
    -0.13075447f, 0.00037130f, -0.01474083f, -0.05435229f, 0.00180274f, -0.07782614f, -0.05289052f, 0.01445788f, 
    -0.04268687f, -0.10104609f, -0.05486238f, -0.14281982f, 0.14280665f, -0.06541322f, 0.01965522f, 0.09351230f, 
    0.04758285f, -0.00383298f, -0.03809841f, 0.05140628f, -0.00470905f, -0.05619686f, 0.21811850f, -0.04337778f, 
    -0.08154383f, 0.14503874f, -0.01709188f, 0.11478883f, -0.10175574f, -0.08930864f, -0.05327611f, 0.05912146f, 
    -0.22091974f, 0.23635080f, 0.17456089f, 0.13770591f, -0.07418605f, 0.00712177f, -0.08468514f, 0.00255234f, 
    0.02995333f, 0.05682030f, 0.05677664f, -0.03118366f, 0.25417858f, 0.17273428f, -0.05999694f, 0.01411526f, 
    -0.00232108f, -0.01525430f, 0.08906920f, -0.00691797f, 0.07355965f, -0.09396373f, 0.05866194f, 0.06022640f, 
    0.06920652f, 0.06445228f, 0.10146271f, 0.01611326f, 0.14224516f, 0.05853140f, -0.13199639f, 0.11592358f, 
    -0.03533326f, 0.01572738f, -0.00021402f, 0.06991369f, -0.34064162f, -0.06729855f, 0.16547725f, 0.09537865f, 
    0.05780804f, 0.06024845f, -0.01173769f, 0.08393280f, -0.03246518f, -0.11955902f, 0.04015895f, 0.08797007f, 
    -0.15350571f, 0.12946914f, -0.08139654f, 0.00759441f, -0.10141481f, 0.09236343f, 0.01855216f, -0.04942128f, 
    -0.00831297f, -0.16846843f, -0.00504886f, 0.06744356f, 0.07464630f, 0.05963624f, 0.07073751f, 0.25899211f, 
    -0.10896818f, 0.15559706f, 0.07554556f, 0.00204185f, -0.05062601f, -0.02010171f, 0.04903145f, 0.14692295f, 
    -0.00292041f, -0.08692373f, -0.10268232f, 0.02055148f, -0.01691734f, -0.10148951f, 0.05405142f, 0.04138314f, 
    -0.08297326f, 0.07355674f, -0.10107736f, 0.00492777f, -0.01087006f, -0.02905014f, 0.01955059f, 0.05611314f, 
    -0.02961322f, -0.06336424f, -0.01025458f, -0.00428830f, -0.03967027f, 0.03061279f, -0.02547857f, 0.01518393f, 
    0.02440339f, 0.05292547f, -0.02041431f, 0.05359831f, -0.06938575f, -0.05090609f, 0.03921524f, -0.06437805f, 
    -0.03315993f, 0.01961163f, -0.07105335f, 0.04549434f, 0.00433132f, -0.04466155f, 0.01817150f, 0.00655049f, 
    -0.00430325f, -0.00453106f, -0.02242159f, -0.00674964f, -0.05112103f, -0.02982763f, 0.05180462f, -0.07648297f, 
    -0.06048336f, -0.06993681f, 0.02237995f, 0.03282851f, 0.01285246f, -0.07771236f, 0.01551257f, -0.07464632f, 
    -0.01233752f, 0.00255434f, -0.02282343f, -0.08580254f, -0.06771646f, 0.05922061f, 0.07533356f, -0.02499921f, 
    0.04378778f, -0.02620075f, -0.06444066f, -0.07280135f, -0.09694809f, -0.00482761f, -0.06052047f, 0.00160770f, 
    -0.03992555f, -0.01958173f, -0.05996308f, -0.05796734f, -0.02189763f, -0.00291077f, -0.04344961f, 0.04274835f, 
    -0.06661195f, 0.04745574f, 0.06583567f, 0.06398219f, -0.00016422f, -0.04287627f, -0.01897017f, -0.06350563f, 
    0.01406017f, 0.01253191f, -0.06241073f, 0.02761152f, 0.03353618f, 0.04826146f, 0.02397704f, -0.02184807f, 
    -0.00178051f, -0.10161105f, -0.06245420f, -0.00128674f, -0.01349009f, 0.01625247f, -0.04451211f, -0.08851197f, 
    -0.09327003f, -0.04137718f, 0.00156723f, -0.03905489f, -0.03004680f, 0.01004204f, -0.03335555f, 0.02043639f, 
    0.03047305f, -0.02379537f, -0.05838848f, -0.04049280f, 0.00368421f, -0.07883769f, -0.01119834f, 0.03124193f, 
    -0.05238113f, 0.01407611f, -0.03872979f, 0.02644041f, -0.08152507f, -0.03869075f, 0.04999020f, -0.03723461f, 
    -0.03160397f, -0.08753810f, 0.03293067f, -0.02276132f, -0.01083692f, 0.03695075f, -0.02473501f, -0.00546795f, 
    -0.04327166f, -0.05656446f, 0.00027000f, 0.05210302f, -0.05025292f, -0.03638130f, 0.03367959f, 0.02275407f, 
    0.01617036f, -0.05379423f, -0.07343864f, 0.01776305f, -0.05863122f, -0.03981513f, -0.00621336f, -0.03488871f, 
    -0.05699606f, -0.05419087f, -0.04314471f, -0.06657597f, 0.00570105f, 0.03865309f, 0.04619056f, -0.00930587f, 
    0.04425380f, 0.04112820f, -0.05140655f, 0.02568282f, -0.07655511f, -0.00383031f, -0.05488791f, -0.09399952f, 
    -0.05678542f, 0.04596188f, -0.04884889f, 0.06583667f, -0.05784871f, 0.00851099f, 0.04365986f, 0.03007789f, 
    -0.06395832f, -0.03250041f, 0.01912862f, -0.06848910f, -0.04198867f, -0.01145219f, 0.04937472f, -0.08485311f, 
    0.05363017f, -0.00036977f, -0.02486057f, 0.03532317f, -0.03707167f, 0.04807156f, 0.01896003f, -0.06555510f, 
    -0.25443199f, 0.07413618f, -0.17012540f, 0.16335508f, 0.02196752f, -0.07929340f, 0.09991657f, 0.18537523f, 
    -0.01598482f, -0.03882851f, 0.07351540f, -0.05060774f, -0.03884653f, 0.04103687f, -0.01620277f, -0.12156123f, 
    -0.03774501f, -0.08731391f, 0.12908770f, -0.10930654f, 0.10634188f, 0.01600328f, -0.05445371f, -0.05651159f, 
    0.08688273f, -0.14265478f, -0.18852460f, 0.07406621f, 0.11619347f, -0.09669030f, -0.15806308f, 0.23370516f, 
    0.07830602f, 0.07833999f, 0.06149559f, 0.22765221f, -0.04830783f, -0.14284904f, -0.16115597f, -0.14855622f, 
    -0.05182270f, -0.07554461f, -0.13174593f, 0.01954310f, 0.00959568f, -0.01412937f, -0.01350294f, 0.04161612f, 
    -0.16265485f, 0.03085675f, -0.10139545f, 0.00617513f, -0.05033177f, 0.07730794f, 0.06955928f, -0.09011376f, 
    -0.06767399f, -0.11600827f, 0.01634388f, 0.00018112f, 0.13650773f, 0.20390713f, 0.20216066f, 0.26361135f, 
    -0.03918705f, -0.11253574f, 0.06749268f, -0.07319067f, -0.01911019f, 0.10266818f, 0.03763580f, 0.04328755f, 
    0.05226952f, -0.11738670f, -0.14667858f, 0.04755456f, -0.06916001f, 0.01066814f, -0.06792902f, -0.16701026f, 
    0.00773452f, 0.07123858f, 0.04272242f, -0.15095869f, 0.31486359f, 0.16728596f, 0.08938555f, 0.13477466f, 
    0.05240083f, 0.06583212f, -0.09173116f, -0.07536852f, -0.16966453f, 0.02608164f, 0.01230897f, 0.10567004f, 
    0.02429888f, 0.00752107f, -0.08391354f, 0.02189238f, 0.11516261f, -0.02446834f, -0.06353498f, -0.04128300f, 
    -0.03262808f, -0.03528421f, 0.10295426f, -0.09532752f, -0.16422313f, 0.17941971f, -0.05885718f, 0.20321660f, 
    0.00694622f, -0.10543901f, 0.13571940f, 0.14719610f, -0.02548943f, 0.10936070f, 0.02030377f, 0.07587019f, 
    -0.06314197f, 0.00922714f, -0.10849190f, 0.06851800f, 0.03978116f, 0.03764125f, -0.04437002f, 0.20924614f, 
    -0.00314142f, -0.05736860f, -0.08010694f, -0.10709316f, -0.17676003f, 0.01184183f, 0.36142409f, -0.04083088f, 
    0.01049312f, -0.03852228f, -0.01971625f, -0.04203340f, 0.10490829f, 0.09033802f, -0.03223431f, 0.08656829f, 
    0.03690234f, -0.20514511f, 0.09755526f, 0.15736960f, -0.00382093f, 0.03593684f, -0.13020651f, 0.03506519f, 
    0.01325311f, 0.13130119f, -0.02419306f, -0.04522639f, -0.22355007f, 0.27810732f, 0.03453984f, -0.09440049f, 
    -0.07169644f, -0.01352029f, 0.13783358f, 0.00819944f, 0.00870796f, 0.01208033f, 0.00238699f, 0.02249282f, 
    0.23010743f, -0.10096649f, -0.00230198f, 0.10154877f, -0.04476393f, 0.00814781f, 0.01819272f, -0.01964783f, 
    -0.04246799f, -0.10544083f, -0.04890012f, 0.00218850f, 0.12531753f, 0.29262131f, 0.08912247f, -0.14279072f, 
    0.09188773f, 0.13378873f, 0.03477888f, -0.02353784f, -0.04201293f, 0.05748276f, 0.02582469f, -0.05281082f, 
    0.38951576f, 0.07250277f, 0.11406300f, 0.14423224f, 0.19862187f, 0.06239120f, -0.18870535f, 0.00618681f, 
    0.10644035f, 0.01673481f, 0.05816665f, 0.05449395f, -0.26207495f, 0.10539304f, 0.16109186f, -0.04490387f, 
    0.04928131f, 0.00742350f, 0.16553347f, 0.09772187f, -0.05999338f, 0.15037221f, 0.03840129f, -0.06158118f, 
    0.01994960f, 0.14415458f, 0.10098675f, -0.13054255f, 0.07304788f, -0.09310593f, -0.09835378f, -0.15463881f, 
    0.01740489f, 0.01623804f, 0.00906634f, -0.01273750f, 0.17786953f, 0.19638580f, -0.11398342f, -0.04134032f, 
    0.01185695f, -0.04215891f, 0.19435965f, -0.10138664f, -0.12720875f, -0.05851720f, -0.05443715f, -0.01883834f, 
    -0.41287515f, 0.21753165f, -0.00292358f, -0.10946640f, -0.04802923f, 0.12120365f, -0.01644547f, -0.23668401f, 
    -0.04858540f, -0.04340649f, 0.00186767f, -0.07523220f, -0.04151158f, -0.30684930f, -0.24617130f, 0.05776449f, 
    0.12868547f, 0.01422435f, -0.01729535f, -0.08059025f, 0.04019670f, 0.07044307f, -0.03402648f, -0.06261330f, 
    -0.02958730f, 0.00709273f, -0.14648379f, 0.04480246f, -0.01397675f, 0.17600712f, 0.01471519f, 0.13255566f, 
    0.03847778f, 0.12250608f, -0.07235916f, 0.09446268f, 0.11295245f, -0.08349109f, -0.16533221f, 0.02972079f, 
    0.01047172f, -0.10203278f, -0.09193120f, 0.09063456f, -0.04231145f, 0.06214041f, 0.12359598f, 0.10114055f, 
    0.13975801f, 0.07511493f, -0.00005644f, 0.09684091f, 0.11979068f, 0.05095250f, 0.07333414f, 0.00154816f, 
    0.04418571f, 0.05617159f, 0.06983854f, -0.00874090f, 0.39241803f, -0.13289639f, 0.00794681f, 0.36588904f, 
    -0.08491842f, -0.06442363f, 0.00272390f, 0.00791639f, -0.02068485f, 0.05292227f, 0.08211890f, 0.03587733f, 
    0.21580884f, 0.22393678f, 0.09378334f, 0.24099067f, -0.00436671f, -0.08978390f, 0.02477028f, 0.06241491f, 
    -0.02644246f, -0.02749505f, 0.05452062f, -0.15330864f, -0.34359434f, -0.13385302f, 0.04433450f, 0.05813886f, 
    -0.10161950f, 0.05283429f, 0.04958110f, -0.11574674f, 0.05479500f, -0.01267154f, -0.03598952f, 0.08636779f, 
    0.06917495f, 0.15042475f, 0.04981738f, 0.24645355f, 0.05634722f, 0.15589346f, 0.03640608f, 0.14428942f, 
    0.08082219f, -0.07051544f, 0.12307946f, 0.06719613f, -0.30230296f, -0.21839805f, -0.06977969f, -0.05405465f, 
    0.00186934f, 0.01404422f, -0.14698218f, 0.03660557f, 0.03402323f, 0.19647239f, 0.01131028f, -0.00239106f, 
    -0.33485296f, -0.12398817f, 0.10977994f, -0.00599872f, 0.09121994f, 0.04715777f, -0.04868768f, -0.04040791f, 
    0.04910003f, 0.01289425f, -0.04625078f, -0.00885654f, -0.17589968f, 0.22624919f, 0.07004045f, -0.27024323f, 
    -0.02121414f, -0.12802804f, -0.03109986f, -0.04382890f, -0.14615953f, -0.08871731f, -0.10245095f, -0.10532406f, 
    -0.10419767f, -0.17504883f, -0.03158496f, -0.00730128f, -0.00980541f, -0.05912675f, 0.09376016f, -0.00046764f, 
    -0.00923546f, 0.22273447f, 0.07210328f, -0.01701453f, -0.11928295f, 0.20524935f, -0.16652255f, -0.23765533f, 
    -0.06660631f, -0.13176896f, -0.09523810f, -0.09147836f, 0.18355247f, 0.01508038f, -0.17514135f, 0.05161304f, 
    -0.03224759f, -0.45967856f, -0.29262200f, -0.00874883f, 0.07898118f, 0.07768346f, -0.08449787f, 0.09520925f, 
    0.06112859f, 0.08160544f, 0.08759678f, 0.16725266f, 0.04678027f, -0.09613231f, -0.23955397f, -0.18875666f, 
    -0.02412297f, 0.00019539f, -0.27292067f, 0.16529272f, 0.16870818f, 0.03441628f, -0.25459126f, -0.05758376f, 
    -0.52146691f, 0.13584505f, -0.26634198f, -0.12998903f, 0.06132782f, -0.08631960f, -0.07149544f, -0.01727862f, 
    -0.00046906f, -0.06494260f, 0.00623874f, 0.10118289f, 0.36964199f, 0.23578960f, 0.23417668f, 0.07832237f, 
    0.16482937f, 0.11128319f, 0.03844056f, -0.12767099f, 0.07866564f, 0.00209716f, 0.02634022f, 0.06765246f, 
    -0.00863958f, 0.12260119f, 0.18437113f, -0.23538946f, -0.04476688f, -0.15969451f, -0.09178784f, 0.12320496f, 
    -0.14982408f, 0.12510408f, 0.12324830f, 0.05131295f, -0.17134626f, -0.07679074f, 0.01780633f, 0.14299653f, 
    0.07771736f, 0.14781830f, -0.06510120f, -0.03031876f, 0.11010521f, 0.22961232f, 0.11261947f, 0.26369241f, 
    -0.27317184f, -0.23194695f, 0.06460895f, 0.02763240f, -0.13621603f, -0.34018087f, 0.15247966f, 0.04658983f, 
    0.08284529f, -0.02190283f, 0.01614854f, -0.00281525f, -0.41662455f, -0.16918476f, -0.18220986f, -0.05860579f, 
    -0.02608442f, 0.11833692f, 0.05110599f, 0.01335824f, 0.14414605f, 0.21755993f, 0.04953881f, 0.17238924f, 
    -0.59420907f, -0.32878309f, -0.24649872f, -0.02429360f, -0.01120268f, -0.13589065f, -0.01047709f, 0.04602200f, 
    0.00122945f, -0.12030716f, -0.15359131f, -0.21646605f, 0.09252842f, 0.06760611f, -0.02354525f, 0.17684691f, 
    -0.07568012f, -0.07186409f, 0.05753317f, -0.17684650f, 0.32000375f, 0.03477803f, 0.06798348f, 0.25913283f, 
    -0.28150123f, -0.02980866f, -0.15484461f, 0.10430894f, -0.12086190f, -0.08997753f, -0.00544483f, -0.02408707f, 
    0.07431423f, -0.04507437f, 0.19959314f, -0.02146495f, 0.31451097f, 0.08345573f, -0.05532024f, -0.15897116f, 
    0.09694415f, 0.11605296f, -0.00353341f, 0.11650924f, 0.13378601f, -0.04790437f, 0.15209530f, 0.16281967f, 
    0.29382855f, 0.08677261f, 0.18174005f, -0.18401892f, 0.01192237f, -0.00425552f, 0.14267880f, 0.11401840f, 
    -0.11778322f, 0.16070858f, 0.02482846f, 0.17387168f, -0.10532276f, -0.05800118f, -0.28438345f, -0.16116530f, 
    0.20905207f, -0.19668294f, 0.00205495f, -0.23718117f, 0.10631413f, 0.14258534f, 0.09456785f, 0.07947651f, 
    -0.11737998f, 0.10144161f, 0.00742609f, 0.18601988f, 0.01209654f, -0.05563188f, -0.13036048f, -0.16314508f, 
    -0.17754789f, -0.03855185f, -0.07934631f, 0.10538282f, 0.28798196f, 0.16614084f, 0.11807401f, -0.09367438f, 
    0.03851394f, 0.09273856f, -0.13598004f, -0.04980740f, 0.03393602f, 0.05652825f, 0.03650137f, 0.01759358f, 
    0.27236268f, -0.00296547f, 0.11832550f, 0.07338840f, -0.12523906f, 0.12433828f, 0.03443385f, 0.06952569f, 
    0.01978430f, -0.02190011f, 0.17924376f, 0.02634955f, 0.17241083f, 0.25483879f, 0.14103287f, 0.03299843f, 
    -0.09041903f, 0.16607563f, 0.16405524f, 0.12727843f, -0.05271951f, 0.08551509f, 0.09958739f, 0.01026207f, 
    0.36961994f, 0.22041538f, 0.13969867f, 0.12338777f, 0.03928495f, -0.06310590f, 0.08415984f, -0.04467744f, 
    0.09386816f, 0.00070131f, -0.04894844f, -0.07336354f, -0.32137641f, -0.03852839f, 0.00057477f, -0.14430426f, 
    0.04731337f, 0.05076535f, 0.09006473f, 0.04139243f, -0.07044455f, -0.12192625f, -0.05581804f, -0.05636819f, 
    -0.17724432f, -0.02447995f, 0.20115149f, -0.25738293f, -0.07805839f, -0.10697322f, 0.01480428f, -0.02275958f, 
    0.04399444f, 0.00733595f, 0.18562526f, 0.13563998f, 0.01101266f, 0.05061971f, -0.18686904f, 0.05366528f, 
    -0.05853003f, -0.02550984f, 0.04271461f, -0.06451362f, -0.07084789f, -0.03218931f, -0.00603875f, -0.00810115f, 
    0.07579987f, 0.23553462f, 0.13109609f, 0.11205325f, 0.16173311f, 0.05684178f, -0.00883707f, 0.06243543f, 
    0.13828699f, 0.06518076f, -0.02688048f, 0.08652619f, -0.30278412f, 0.17910680f, -0.03818322f, -0.21455170f, 
    0.01356606f, -0.02473594f, -0.08190735f, 0.01486290f, -0.13280745f, -0.00100663f, -0.08855781f, -0.14784065f, 
    0.06616971f, -0.09096085f, 0.14688548f, 0.17513803f, -0.05058944f, -0.04899001f, 0.09155074f, -0.11387359f, 
    -0.00445103f, 0.02155865f, -0.08687550f, -0.00603259f, -0.13410975f, -0.14852889f, -0.13678914f, 0.14292835f, 
    -0.14033814f, -0.02625646f, 0.02292253f, -0.02754924f, 0.01231103f, 0.05948372f, 0.09204141f, -0.00275244f, 
    0.06284690f, 0.21461253f, -0.01071174f, 0.02972709f, 0.16046779f, 0.01283362f, 0.08119547f, -0.02935730f, 
    -0.04299045f, 0.04314961f, -0.07066946f, -0.12649646f, 0.09208092f, 0.09007896f, -0.08140806f, -0.11246220f, 
    0.13130037f, 0.09966983f, 0.04109227f, -0.15665966f, 0.02045624f, 0.05373870f, -0.02766563f, 0.01386287f, 
    -0.31404790f, -0.12078727f, -0.07550531f, 0.02806600f, -0.10204445f, -0.00745078f, 0.04154251f, 0.02615315f, 
    -0.00217091f, 0.04766933f, -0.00573306f, -0.03487519f, -0.01081320f, -0.06069844f, -0.02851658f, 0.00406838f, 
    0.00611575f, 0.03357412f, 0.01363098f, -0.21436183f, 0.00275255f, 0.04001633f, -0.09947082f, 0.00969908f, 
    -0.20053658f, 0.06093235f, 0.26568988f, -0.04135466f, -0.00330208f, -0.05468876f, 0.13726917f, 0.03731148f, 
    -0.06160928f, 0.11232768f, -0.10446738f, -0.00851144f, 0.21785749f, -0.05303689f, -0.26067895f, 0.10139070f, 
    -0.01886674f, -0.08457059f, -0.03300063f, -0.02256092f, 0.00128725f, 0.02093623f, -0.04426345f, -0.09008858f, 
    0.07761643f, -0.09549849f, 0.06542308f, -0.03675411f, -0.02340423f, 0.08908758f, -0.00636662f, -0.06527747f, 
    -0.01364874f, -0.12828602f, 0.13919207f, 0.02420430f, 0.11718260f, -0.13823619f, -0.00273704f, 0.11787733f, 
    -0.04340426f, 0.04365929f, 0.05383920f, 0.02223661f, -0.02602128f, -0.10698985f, -0.00772240f, -0.07093204f, 
    0.42210662f, -0.02109845f, -0.17432787f, -0.11878118f, -0.12245811f, -0.12077443f, 0.06248475f, 0.09073026f, 
    -0.01259721f, 0.01335024f, 0.05304526f, 0.03636086f, -0.22293021f, 0.00803360f, 0.11904999f, -0.16005729f, 
    0.26796880f, 0.03939497f, 0.05099736f, -0.06305622f, -0.05089187f, 0.07790773f, 0.12090181f, -0.02431325f, 
    -0.26661023f, 0.12641665f, 0.13884540f, 0.37513295f, -0.04754568f, 0.00889416f, 0.08914088f, -0.03032869f, 
    0.03242768f, -0.07402953f, 0.12180981f, -0.07820620f, -0.04299982f, 0.29094350f, 0.06883764f, -0.22626080f, 
    0.14786392f, 0.07419626f, -0.05332490f, -0.05779003f, -0.01762560f, 0.03490430f, -0.01284654f, -0.12035512f, 
    -0.07572002f, -0.02754186f, 0.04482050f, 0.26017886f, -0.14295059f, -0.01115616f, -0.11266134f, -0.12048481f, 
    0.00195372f, -0.08204732f, 0.00103033f, 0.03376710f, -0.20386276f, 0.03029858f, -0.06928733f, 0.05145724f, 
    0.12500270f, 0.09648852f, 0.08866856f, -0.01746210f, 0.05836277f, 0.02328188f, -0.14588214f, 0.02449180f, 
    -0.00149684f, 0.13947415f, -0.03123531f, -0.28203106f, 0.03357437f, 0.03020708f, 0.11822572f, 0.02950532f, 
    0.06063319f, 0.09156691f, 0.10535228f, 0.10036387f, -0.32192424f, -0.04740068f, 0.14376323f, -0.21506630f, 
    0.21515340f, 0.00643440f, 0.01598252f, 0.05810178f, -0.05898457f, 0.12626913f, -0.06802245f, -0.00030035f, 
    0.38489953f, 0.07029056f, -0.31307122f, -0.12441675f, 0.13039017f, 0.03539823f, 0.02396014f, 0.00100644f, 
    0.15688057f, 0.11631122f, 0.05054050f, 0.02348713f, 0.19780067f, 0.03572130f, 0.06447792f, 0.02136856f, 
    0.00373190f, 0.08316516f, 0.02043842f, -0.02790216f, 0.06853031f, 0.01654938f, -0.03323482f, 0.00895835f, 
    -0.20516834f, -0.01123695f, 0.11952195f, -0.07535630f, 0.16088563f, 0.09428555f, 0.05654336f, -0.08553758f, 
    0.11388441f, 0.08473273f, 0.05570403f, 0.06536699f, -0.07593902f, -0.14355701f, -0.24596362f, -0.05681663f, 
    -0.02138167f, -0.05299345f, -0.02968814f, 0.03966885f, 0.04197792f, -0.03995400f, 0.00346419f, 0.13211940f, 
    -0.05111652f, -0.05760510f, 0.04277641f, -0.02378753f, -0.00896679f, 0.06393346f, -0.04911340f, 0.02801031f, 
    -0.05225761f, -0.02984210f, 0.00739805f, -0.06698887f, -0.00245248f, -0.03703035f, 0.04380515f, -0.07117997f, 
    0.04149457f, -0.02772373f, 0.01316093f, -0.05080594f, -0.03487855f, 0.06792832f, 0.04291491f, -0.04883553f, 
    -0.04440526f, 0.05054073f, 0.05843665f, -0.01602471f, -0.03205917f, -0.06753565f, 0.05872286f, -0.06523596f, 
    -0.01265805f, 0.03688579f, 0.01073441f, -0.07051546f, -0.06155708f, -0.06911482f, 0.06734516f, -0.05031984f, 
    -0.06909125f, 0.05854823f, -0.05174305f, -0.02930420f, -0.00266629f, -0.00104564f, -0.05054487f, -0.06292722f, 
    0.00702708f, 0.01494601f, -0.00418011f, 0.06723221f, -0.01338270f, -0.01407322f, 0.05924192f, -0.02845972f, 
    0.05465575f, -0.01461131f, -0.03476108f, 0.01786235f, -0.00110798f, -0.04536710f, -0.06992126f, -0.03978783f, 
    0.07027908f, 0.04119777f, 0.00469581f, -0.01972749f, -0.00422679f, 0.07188863f, -0.00018131f, -0.05444830f, 
    -0.03016974f, 0.06923380f, -0.01135028f, -0.02755146f, -0.06977526f, 0.06039770f, 0.04191516f, 0.01745418f, 
    -0.01225182f, 0.02591962f, -0.04639950f, -0.04474007f, -0.05087144f, -0.05384899f, -0.00311185f, -0.01111529f, 
    -0.04257397f, -0.05647102f, 0.00597610f, 0.00932175f, -0.03557736f, 0.04788293f, 0.07214733f, -0.00403829f, 
    -0.05037013f, -0.01098921f, 0.04391935f, -0.04442137f, -0.04272025f, -0.02850286f, -0.05478304f, 0.06399264f, 
    -0.07144745f, 0.04366994f, 0.01760637f, -0.02536142f, 0.03737463f, -0.07093177f, 0.06579643f, -0.02175330f, 
    -0.02046886f, 0.03468533f, -0.01395714f, 0.01289019f, -0.05752867f, -0.01386988f, 0.01902618f, -0.03422285f, 
    -0.03762212f, -0.00297384f, -0.01683944f, -0.02146436f, 0.04841332f, 0.06819937f, 0.04759138f, -0.07072074f, 
    0.03226682f, -0.06445790f, -0.05424701f, -0.05837098f, -0.00630626f, -0.05796431f, 0.03216347f, 0.02076451f, 
    -0.07138365f, -0.06258775f, 0.03324525f, -0.05711248f, 0.04747182f, -0.04693332f, -0.02508290f, -0.01379857f, 
    0.02739508f, -0.00266159f, 0.05483437f, 0.06697898f, -0.06605703f, -0.05741154f, -0.03923255f, -0.04479602f, 
    0.02023729f, -0.02936224f, -0.04980036f, 0.04807766f, 0.02451036f, -0.04890636f, 0.04637830f, 0.00542439f, 
    -0.05515006f, 0.00706010f, -0.06943975f, 0.02703704f, 0.03449385f, 0.04709641f, 0.02638181f, -0.06676059f, 
    -0.00945350f, -0.03307623f, 0.05650599f, -0.02003588f, -0.01017763f, -0.00742252f, -0.06574412f, -0.04268934f, 
    -0.03394509f, -0.04881261f, 0.03257956f, 0.07012624f, -0.04997180f, 0.02670492f, -0.02553958f, 0.07158851f, 
    -0.04545896f, -0.05716809f, 0.04018673f, -0.02598876f, -0.04218739f, -0.04952700f, -0.06602261f, -0.06233370f, 
    0.04116185f, 0.07350722f, -0.04918981f, 0.24908431f, 0.15310173f, -0.02746367f, -0.09960956f, 0.10365516f, 
    0.19995733f, 0.10651451f, -0.03227398f, 0.04168615f, -0.17160293f, -0.12794685f, 0.30972490f, -0.10455909f, 
    -0.01369738f, 0.09639981f, 0.19624925f, 0.11830588f, 0.09426691f, 0.16590169f, -0.06473868f, 0.04644876f, 
    -0.14082322f, -0.00010550f, -0.14096618f, 0.00004398f, 0.04979677f, -0.04746293f, -0.06590881f, -0.04059087f, 
    0.07112128f, 0.08982132f, -0.00766671f, 0.00603498f, -0.11704648f, -0.18332936f, -0.02791710f, -0.14221485f, 
    0.02394321f, 0.06958643f, -0.04182875f, -0.06700443f, 0.00431715f, -0.03435812f, -0.03273747f, -0.01294663f, 
    -0.19139796f, 0.04872411f, -0.02645809f, 0.02618287f, 0.06104013f, 0.20528744f, -0.12992144f, -0.05247009f, 
    -0.02392028f, -0.02420714f, -0.03388829f, -0.14452697f, 0.38980529f, -0.06275787f, -0.13099670f, 0.28314841f, 
    -0.05444521f, -0.12242565f, 0.09310696f, -0.02889784f, 0.11949815f, 0.11927408f, -0.04609970f, -0.05814866f, 
    0.22697507f, -0.11446406f, -0.24507096f, -0.26584718f, -0.00436711f, 0.00063746f, 0.07719419f, -0.07302903f, 
    0.03183074f, 0.11244377f, -0.04392550f, 0.08423573f, 0.34973967f, 0.04326842f, -0.16594501f, 0.20296112f, 
    0.05157806f, -0.03550239f, -0.06566370f, 0.16857801f, -0.10079462f, 0.03288665f, 0.14856963f, 0.07818748f, 
    -0.09254139f, -0.10302913f, -0.01634770f, -0.17159371f, -0.00726527f, 0.12082374f, -0.04339614f, -0.02933210f, 
    0.07976191f, -0.01201439f, 0.04232711f, -0.05197159f, 0.22858268f, 0.21822281f, -0.06994617f, 0.09002535f, 
    -0.04100059f, 0.01595806f, 0.07956072f, 0.05059290f, 0.09844603f, -0.04762100f, 0.03154397f, 0.07040709f, 
    -0.13386109f, -0.02825263f, -0.01449067f, 0.14165460f, -0.01956705f, -0.00997849f, -0.00647784f, 0.05319169f, 
    -0.02987848f, 0.00923521f, -0.03855178f, -0.06440725f, -0.13954294f, 0.02647288f, 0.16531953f, 0.17322306f, 
    -0.14871968f, -0.04870410f, 0.03654426f, -0.03433775f, 0.10031847f, -0.02209903f, -0.02607259f, 0.11141101f, 
    -0.38563344f, -0.14984871f, 0.19825663f, 0.16773722f, -0.02769445f, 0.12276787f, 0.02214379f, -0.00755172f, 
    0.01400582f, -0.02318276f, 0.06068502f, -0.04412639f, -0.16473153f, 0.07599509f, -0.00042109f, -0.02974361f, 
    -0.01216188f, 0.00173106f, -0.10026754f, -0.06030064f, 0.02690035f, 0.10274722f, 0.03076094f, -0.00472840f, 
    0.31219590f, -0.17600538f, -0.00378092f, 0.15667209f, -0.06853463f, 0.00324159f, -0.01594335f, 0.03115788f, 
    -0.04219471f, -0.02563186f, 0.01318006f, -0.00195870f, 0.03150832f, 0.14847222f, 0.13513042f, -0.12034658f, 
    0.07968148f, -0.03645345f, -0.00032642f, -0.02802019f, -0.06696825f, 0.07462741f, -0.01125599f, -0.07495175f, 
    -0.03499188f, 0.00097301f, -0.00158996f, -0.01042258f, 0.01602183f, -0.04824460f, -0.05500204f, -0.04988099f, 
    -0.02068151f, 0.04595618f, -0.00391903f, -0.05509802f, 0.02741985f, 0.01825896f, -0.02521286f, 0.01500382f, 
    0.02051776f, 0.04586121f, -0.02704795f, -0.06993216f, 0.04790205f, -0.01900483f, 0.00954844f, 0.01617881f, 
    0.04108549f, -0.04910020f, -0.02566048f, -0.04461504f, -0.01375222f, 0.00002047f, -0.03725413f, -0.01995944f, 
    -0.01680638f, -0.05531823f, -0.04956461f, -0.05383800f, 0.02270148f, 0.05919491f, -0.04940211f, -0.05630331f, 
    0.06248185f, -0.03667336f, -0.05041056f, 0.05729407f, 0.00349719f, 0.04135456f, 0.01922923f, 0.02840439f, 
    -0.01009187f, 0.04712567f, -0.01789747f, -0.00469750f, 0.06188057f, 0.03218877f, 0.04112306f, -0.01941529f, 
    0.01595379f, -0.02082596f, 0.02933223f, -0.02814435f, -0.01731653f, -0.07444712f, -0.07219175f, 0.04547014f, 
    -0.00666198f, -0.03038590f, -0.00358460f, -0.06888369f, -0.04153217f, 0.04445473f, 0.02993990f, -0.07395079f, 
    0.03001305f, -0.03080806f, -0.05829700f, 0.01920512f, -0.04956953f, -0.00550029f, -0.00357689f, -0.03323612f, 
    0.02061689f, 0.03203009f, 0.01273288f, -0.00025682f, -0.05339690f, -0.01260758f, -0.03061063f, 0.01082438f, 
    -0.04664421f, -0.07081922f, 0.03042224f, -0.06544372f, -0.01567198f, -0.02298208f, -0.05467503f, 0.00421897f, 
    -0.00233611f, -0.00071467f, -0.06062991f, 0.01816232f, 0.05237953f, 0.02476642f, -0.07698659f, 0.01945336f, 
    -0.04849779f, -0.00485141f, -0.03208563f, -0.04072626f, 0.03594280f, 0.06134909f, -0.01849302f, 0.04210577f, 
    -0.06096522f, -0.07551911f, -0.02681109f, -0.07136109f, 0.02853340f, -0.07314986f, -0.00144791f, -0.05483698f, 
    0.04474493f, -0.02270706f, 0.02999649f, 0.02252192f, -0.00708093f, 0.06062777f, 0.00450953f, 0.01544113f, 
    -0.00373859f, 0.03159415f, 0.01396042f, -0.02565857f, -0.05652035f, -0.04568015f, 0.02687414f, 0.03546979f, 
    0.06183693f, -0.01701899f, -0.02675627f, 0.03611919f, -0.01655463f, -0.04999141f, -0.07576673f, 0.05013541f, 
    0.01241050f, 0.04311142f, -0.06891266f, 0.02105944f, 0.04938230f, 0.00739765f, -0.05521090f, 0.01492590f, 
    0.04380901f, -0.04729414f, -0.00989796f, -0.05098441f, -0.04288699f, -0.08100356f, 0.01488231f, 0.02399503f, 
    -0.06679598f, 0.04922061f, 0.00017694f, 0.04925903f, 0.03375332f, -0.03746197f, -0.01280950f, -0.00802805f, 
    0.03387638f, -0.02017626f, 0.00586536f, -0.02308586f, -0.03995112f, 0.05277632f, -0.05282433f, 0.00992331f, 
    -0.01105929f, -0.06994858f, 0.00970880f, -0.05809346f, 0.03911585f, -0.05360769f, -0.06631264f, -0.07816401f, 
    -0.01827397f, -0.04216880f, -0.03934965f, 0.04525162f, -0.02628177f, -0.06768031f, 0.02387059f, -0.05054150f, 
    -0.16056940f, 0.08680341f, -0.03951025f, -0.15172563f, -0.13024069f, 0.04956166f, 0.18816954f, 0.10590427f, 
    -0.09408459f, -0.11082839f, 0.20645866f, 0.04077942f, -0.02279106f, 0.06166054f, -0.13361056f, -0.10119110f, 
    0.03551077f, -0.13012813f, -0.04348109f, -0.06822269f, -0.03211012f, -0.05969471f, -0.01928064f, -0.04494936f, 
    -0.00286318f, -0.09844910f, -0.09863198f, 0.09992064f, -0.07695071f, 0.17475790f, 0.09357951f, 0.19670951f, 
    0.03588511f, -0.02702628f, 0.01507159f, -0.04216612f, -0.09670661f, -0.18382387f, -0.03141454f, -0.02907867f, 
    0.13920742f, -0.10892609f, -0.06040291f, 0.00871871f, -0.02173406f, 0.10545799f, 0.00885635f, 0.04633118f, 
    0.04832572f, -0.18457487f, -0.13135855f, -0.08572089f, 0.00130473f, -0.06714714f, 0.05219995f, 0.16845576f, 
    0.03988881f, -0.00511002f, 0.02408991f, 0.05277625f, 0.20648257f, 0.25586858f, 0.18735904f, -0.01230131f, 
    -0.19042718f, 0.03125340f, -0.04518317f, 0.02821358f, -0.05588642f, 0.07183977f, 0.00198849f, 0.15283731f, 
    0.00440067f, -0.13622278f, 0.12476311f, 0.07667726f, -0.04441646f, -0.07694959f, 0.01741042f, -0.02792903f, 
    -0.06311438f, 0.04369282f, 0.00972101f, -0.18423146f, -0.13501993f, 0.06049350f, 0.28374594f, 0.08601665f, 
    0.05414450f, 0.16778997f, 0.10369101f, -0.01808973f, 0.03280747f, 0.01931518f, -0.06844470f, -0.10852636f, 
    0.05351545f, 0.01684342f, -0.06838465f, -0.04787706f, -0.12265518f, 0.02044805f, -0.01184572f, -0.01414028f, 
    -0.04927492f, 0.03710721f, 0.03006904f, 0.06110832f, -0.18105873f, -0.01185043f, 0.05739873f, -0.07183471f, 
    0.06448788f, 0.14597780f, -0.04646082f, 0.03503022f, -0.00041411f, 0.04175758f, -0.09098207f, 0.09759758f, 
    -0.23099521f, 0.08585603f, -0.02495815f, -0.13820662f, 0.11034205f, 0.11372826f, -0.08015867f, 0.08506982f, 
    -0.00309828f, 0.00875589f, 0.14993437f, 0.04832875f, 0.22724523f, 0.07702143f, 0.02109706f, -0.20893095f, 
    0.15028882f, 0.05179611f, -0.02422295f, 0.13231896f, -0.07568921f, -0.10133073f, -0.05730926f, 0.02480962f, 
    0.25893643f, 0.02367014f, 0.00626234f, -0.11604058f, 0.04329922f, -0.09372643f, -0.05670749f, 0.07975305f, 
    -0.00833241f, -0.00518974f, -0.05878440f, 0.00361534f, -0.07327450f, 0.20353961f, 0.20984586f, -0.00544286f, 
    -0.00572043f, -0.01342798f, 0.17033289f, -0.00243218f, 0.05275114f, -0.14541043f, -0.09644160f, 0.08012309f, 
    0.33861730f, 0.11016869f, -0.09428720f, -0.10992031f, 0.04862827f, -0.03686226f, 0.04794572f, 0.06496239f, 
    0.01603648f, -0.07586057f, -0.00947549f, 0.02746887f, 0.08160507f, -0.09672331f, -0.21907912f, 0.16766176f, 
    0.02024247f, 0.09861176f, 0.07301436f, 0.13236652f, 0.05152037f, 0.11549459f, 0.18389878f, 0.05997097f, 
    0.05735303f, 0.07363259f, -0.05907634f, -0.01456946f, -0.08031456f, 0.00982238f, 0.05031120f, -0.15114063f, 
    -0.20002379f, -0.18745524f, 0.07747471f, 0.13982141f, 0.00764629f, -0.00137801f, -0.12797356f, -0.13394302f, 
    0.00477583f, 0.02763596f, -0.14267115f, -0.11520780f, -0.05181517f, 0.03385669f, 0.03406766f, 0.09252201f, 
    0.24509926f, 0.18473890f, -0.04263596f, 0.12569793f, -0.01731889f, 0.20779262f, 0.08923058f, 0.04316813f, 
    -0.03204356f, -0.08687296f, 0.07264477f, 0.03045777f, 0.14582767f, 0.02605046f, -0.15946858f, -0.01615897f, 
    0.14760856f, 0.00274003f, 0.10858411f, 0.05610952f, 0.00503097f, 0.12023130f, 0.02263449f, -0.02476689f, 
    -0.08982434f, -0.02360314f, -0.01860556f, 0.14643623f, 0.09181886f, 0.02090085f, 0.12615076f, -0.02091637f, 
    -0.11355916f, 0.14301609f, 0.09749223f, 0.03996033f, -0.09274123f, 0.18280251f, 0.07849263f, -0.17314717f, 
    -0.11545120f, -0.04109657f, 0.04375321f, 0.02387851f, -0.02539613f, -0.12801398f, -0.00344812f, 0.04307698f, 
    -0.05312939f, -0.12468754f, 0.28298375f, -0.12878481f, -0.09251729f, 0.04379840f, 0.00950779f, 0.14626737f, 
    0.09329593f, 0.05032399f, 0.12083670f, -0.17580751f, -0.11330847f, 0.01096755f, 0.21767664f, -0.03376680f, 
    -0.10277511f, 0.04492743f, 0.01190218f, -0.02615949f, 0.12594192f, -0.06012845f, -0.18464504f, 0.05228341f, 
    0.25168210f, -0.02401559f, -0.12992290f, -0.09245235f, -0.01341562f, -0.02820874f, 0.10158470f, -0.02389938f, 
    0.10775642f, 0.03093540f, 0.04802379f, 0.06490753f, -0.15223393f, -0.30967170f, 0.20138945f, -0.08110086f, 
    -0.03487602f, 0.00065233f, 0.02645762f, 0.05927707f, 0.02330167f, -0.06135026f, 0.03299361f, 0.01731823f, 
    -0.03687364f, 0.02605135f, 0.09726745f, 0.07303046f, 0.18001758f, 0.04246855f, 0.05014980f, 0.06025623f, 
    -0.00291581f, -0.03528852f, -0.02140159f, 0.01656625f, 0.47041109f, -0.09684082f, -0.12282449f, -0.00988956f, 
    -0.02202832f, 0.02795665f, 0.03030141f, 0.03860757f, 0.00993107f, 0.04514414f, 0.04760911f, -0.02380178f, 
    0.19754402f, 0.15331580f, -0.02321514f, 0.11312822f, 0.00849756f, 0.05822168f, 0.09984051f, -0.03281299f, 
    0.06090157f, 0.08132838f, -0.00189330f, 0.06227947f, -0.15728274f, 0.08485284f, 0.06930321f, -0.01869252f, 
    0.06100041f, -0.03962245f, -0.00111752f, -0.02015245f, 0.01506253f, -0.11974294f, -0.06946618f, 0.10843341f, 
    -0.15974052f, -0.00513427f, -0.06986254f, 0.01677221f, -0.17230949f, 0.00259044f, 0.03357919f, 0.03256234f, 
    -0.00415512f, -0.07678064f, -0.12491082f, -0.01621536f, 0.08823639f, -0.11121323f, -0.11767167f, 0.18250775f, 
    -0.03478132f, 0.11965106f, -0.00181425f, 0.02653823f, 0.04822126f, -0.08076255f, 0.01876775f, 0.05887149f, 
    0.06378732f, 0.09113485f, 0.18423884f, -0.18270236f, 0.02524530f, 0.04054908f, 0.13601057f, 0.10532583f, 
    0.16226663f, 0.15288858f, 0.08405680f, -0.13044807f, 0.00034957f, -0.28140205f, -0.10725532f, 0.27750686f, 
    -0.10013897f, -0.05086453f, -0.07222617f, 0.19957410f, -0.01552100f, -0.00028231f, 0.06278440f, -0.03770556f, 
    -0.26558068f, 0.10524775f, -0.06963649f, -0.09081595f, -0.03977802f, -0.07078097f, 0.04975205f, -0.12107703f, 
    0.00299008f, 0.01698122f, -0.11179356f, -0.20155998f, -0.10618193f, -0.25233382f, 0.04981519f, 0.17008449f, 
    -0.05163209f, -0.12969507f, 0.01211462f, 0.02568623f, -0.01993485f, -0.07298791f, 0.00921267f, 0.01058281f, 
    0.18655077f, -0.37985149f, -0.12418808f, -0.05539624f, -0.10021032f, -0.03458771f, -0.03954488f, 0.10782296f, 
    0.05159830f, 0.07642414f, -0.01380118f, 0.15335199f, -0.07819089f, 0.14139782f, 0.00774805f, -0.13948169f, 
    0.16975199f, 0.04686951f, -0.06091604f, -0.03856839f, 0.05070336f, 0.18907183f, 0.17915195f, 0.06101350f, 
    -0.02445260f, 0.07697376f, -0.16943023f, 0.51705676f, 0.00649390f, 0.07272208f, 0.06770387f, -0.06992699f, 
    0.15263681f, -0.08219738f, -0.15488064f, 0.03632052f, -0.08939581f, 0.27075762f, 0.13894555f, -0.26599061f, 
    0.13183312f, -0.02596722f, -0.00172197f, 0.00025739f, 0.09394373f, 0.04185370f, 0.05518309f, 0.00472683f, 
    -0.25293872f, -0.02168335f, -0.05112828f, 0.00430033f, -0.27526036f, -0.02837406f, -0.02642456f, -0.15711281f, 
    -0.03853243f, 0.04576675f, 0.00398225f, 0.06813506f, 0.16362295f, -0.06183307f, 0.04824659f, 0.12884040f, 
    0.21366481f, 0.02305510f, -0.05524801f, -0.00607098f, 0.04875463f, -0.09770677f, 0.05536763f, 0.04668936f, 
    0.11371551f, 0.06291153f, -0.13813554f, -0.24062110f, -0.05612448f, 0.08775888f, 0.08980829f, -0.06724816f, 
    0.12305257f, 0.06380168f, 0.11304072f, 0.15889123f, -0.01379821f, 0.03324045f, 0.09466328f, -0.21163677f, 
    0.26090306f, -0.06753565f, 0.09129618f, -0.00393044f, -0.22381669f, -0.07772718f, -0.10442091f, 0.08850790f, 
    0.19407548f, -0.02924676f, -0.10749863f, -0.16399321f, -0.09173480f, -0.01831948f, 0.08364200f, 0.06207512f, 
    0.19172516f, -0.01982381f, 0.00569515f, 0.17867103f, 0.27881807f, -0.07978915f, 0.04482533f, 0.14916353f, 
    0.03700150f, -0.09140734f, -0.04291772f, 0.14690636f, -0.05240871f, 0.06410816f, 0.10673575f, -0.06968405f, 
    0.03148725f, 0.14991617f, 0.12441562f, -0.04696511f, 0.25091046f, 0.00656514f, 0.04537521f, -0.02953444f, 
    0.06352646f, 0.11947364f, 0.14888580f, 0.01534361f, -0.03690519f, -0.12026361f, -0.06406512f, 0.01003964f, 
    -0.06632144f, 0.00038769f, -0.04669134f, 0.18173654f, 0.07121985f, -0.10299969f, 0.08767147f, 0.06301351f, 
    0.21720213f, -0.05897244f, 0.13889974f, 0.01652233f, 0.07490183f, 0.01696453f, -0.14556263f, 0.16540612f, 
    0.15022305f, 0.09437977f, -0.13469444f, -0.08005488f, -0.20340325f, -0.02683688f, 0.00991610f, 0.06407426f, 
    -0.04927211f, -0.02901229f, 0.18501690f, 0.16321130f, 0.06052428f, 0.17683896f, -0.11673184f, 0.04434963f, 
    -0.31404158f, -0.04954498f, 0.05656855f, -0.11589003f, 0.14091143f, -0.05517728f, -0.06034923f, -0.19818619f, 
    -0.04155897f, 0.21569456f, -0.12926328f, -0.00342468f, 0.06994305f, 0.13726650f, -0.13129686f, 0.08282869f, 
    0.00190006f, -0.03984531f, -0.05167980f, -0.02568416f, 0.05538704f, -0.18203749f, -0.01474338f, -0.02302826f, 
    -0.22960682f, -0.06452800f, 0.05605888f, -0.00738769f, -0.09332823f, 0.01781808f, -0.07685237f, -0.07655543f, 
    -0.00649515f, -0.07137266f, 0.03697593f, -0.07301624f, 0.08013023f, -0.28326246f, -0.17734483f, 0.05633635f, 
    0.22862996f, 0.02565272f, -0.01114323f, -0.09258552f, 0.04831788f, -0.09019929f, -0.01339526f, -0.06492221f, 
    0.09735543f, 0.35262963f, -0.17340930f, -0.01320390f, 0.07234788f, 0.11869529f, -0.15836012f, -0.06624740f, 
    0.06239263f, 0.05886165f, 0.00834937f, 0.14726429f, -0.01252852f, -0.02244739f, -0.03678722f, -0.05393642f, 
    0.03496737f, -0.03475881f, -0.12593000f, 0.02478875f, -0.07526194f, 0.11609259f, 0.13462444f, 0.11549418f, 
    -0.15484902f, 0.08176757f, 0.13490660f, -0.01921277f, 0.03268276f, 0.06026038f, 0.10304430f, 0.03179916f, 
    0.15040946f, -0.08750132f, 0.10740195f, -0.13059157f, 0.36759847f, 0.04304377f, -0.01507996f, 0.14269723f, 
    0.02650609f, -0.04281970f, 0.07507025f, -0.04698672f, 0.04558001f, 0.09540946f, 0.00229736f, 0.00115551f, 
    0.08163930f, 0.11469287f, -0.10246597f, 0.03342653f, -0.10918055f, -0.10561757f, 0.06745218f, 0.00376647f, 
    -0.02341626f, 0.00828540f, -0.09491048f, -0.09803529f, -0.15155929f, 0.09535669f, 0.20118444f, 0.06623784f, 
    -0.02066898f, 0.00042956f, 0.11829548f, -0.08106912f, 0.12557553f, 0.01900566f, 0.15439452f, 0.09976748f, 
    -0.05446320f, 0.03252532f, 0.04112041f, 0.14395264f, 0.06695500f, -0.07454690f, 0.09374080f, 0.03869687f, 
    0.08956137f, -0.04955956f, 0.15137830f, 0.06055681f, 0.02716310f, -0.18749940f, -0.13040660f, -0.07162038f, 
    0.01138759f, 0.07931344f, 0.03000928f, 0.09593239f, 0.04879723f, 0.15115088f, 0.04892959f, 0.04480026f, 
    -0.09225656f, -0.01100097f, 0.10249724f, 0.01668620f, 0.13791361f, -0.01482940f, 0.04843896f, -0.09075680f, 
    -0.04280147f, -0.06107189f, 0.12234982f, 0.02284140f, -0.02002192f, 0.08157592f, 0.14834398f, -0.11044259f, 
    -0.01271495f, -0.11778057f, -0.06770410f, 0.00901966f, -0.09645817f, 0.01547532f, -0.06834456f, -0.16236176f, 
    -0.04639343f, 0.17860328f, 0.09366570f, 0.23258877f, 0.04265437f, 0.17558941f, -0.17461139f, -0.09999608f, 
    -0.12466643f, 0.00541019f, 0.01489398f, 0.22971052f, 0.17207320f, 0.31580532f, -0.08554223f, -0.37715140f, 
    -0.02431423f, 0.01957642f, 0.11404097f, 0.01208024f, 0.11918338f, -0.00882278f, 0.05627447f, 0.11852624f, 
    0.41054809f, -0.22196300f, 0.00544116f, 0.05499116f, -0.04728337f, 0.08233474f, 0.03929166f, 0.05825648f, 
    0.11211450f, -0.14703266f, 0.02769055f, 0.14228879f, 0.13463311f, -0.13779995f, -0.01191250f, -0.11735065f, 
    0.01209470f, -0.00458971f, 0.10037443f, 0.12231629f, 0.08410221f, -0.00597460f, -0.08857227f, -0.03051635f, 
    0.10047895f, 0.41141233f, -0.08978774f, -0.07022948f, -0.04328744f, 0.10112399f, -0.09136955f, 0.05385904f, 
    0.04191403f, -0.02426429f, -0.04251818f, -0.04091389f, 0.13257137f, -0.24509454f, 0.02109898f, -0.03847729f, 
    -0.09352671f, 0.05112091f, 0.11947505f, 0.01886363f, -0.04754022f, -0.05819960f, -0.01842408f, 0.09517880f, 
    0.00158625f, -0.19087179f, 0.25324532f, -0.44685021f, -0.06425621f, -0.10831095f, 0.11583556f, -0.06666975f, 
    0.07149401f, -0.00187035f, 0.03256298f, 0.07895005f, 0.02754749f, -0.10311196f, 0.11754719f, 0.35870185f, 
    -0.06482596f, 0.08144827f, -0.07069049f, -0.05353567f, -0.16515045f, 0.03598068f, 0.07774764f, -0.04382733f, 
    0.25863889f, 0.01957327f, 0.09963524f, 0.03640139f, 0.01605561f, 0.04051411f, 0.09715841f, 0.11266702f, 
    0.11181723f, 0.07521398f, 0.02734244f, 0.01877698f, -0.24547060f, 0.10644542f, 0.11334269f, -0.03576505f, 
    -0.14188501f, 0.13886479f, 0.10516263f, 0.06122356f, -0.01060503f, -0.05071389f, 0.01762206f, 0.07938598f, 
    -0.09835668f, 0.19322029f, 0.32137877f, 0.15653509f, 0.06299407f, 0.02376457f, -0.14226177f, 0.13891365f, 
    0.04916491f, 0.11975338f, 0.00367165f, -0.06896460f, -0.26019931f, 0.01478220f, -0.09872640f, 0.05237349f, 
    -0.15980047f, -0.01749164f, -0.15611936f, -0.06151541f, 0.03105000f, -0.15650815f, -0.00650618f, 0.02834384f, 
    -0.04451722f, 0.08987055f, 0.05424434f, -0.00664924f, 0.20915002f, 0.02004492f, 0.00407157f, -0.00809570f, 
    0.06019772f, -0.00406071f, 0.07051940f, 0.05757274f, -0.40758651f, 0.15888034f, -0.25812903f, 0.03353425f, 
    -0.01504847f, 0.26916045f, -0.09659205f, -0.08191554f, -0.10441536f, -0.09760961f, -0.01729396f, 0.17707431f, 
    0.09798910f, -0.37100586f, -0.16136129f, -0.04335787f, -0.09314842f, -0.03641330f, 0.07239342f, -0.04958170f, 
    0.11075768f, -0.03336232f, 0.07931148f, 0.02708957f, 0.14810926f, 0.00533126f, -0.08426548f, -0.08819497f, 
    0.02227565f, 0.05908618f, -0.08390195f, -0.11785158f, -0.05020685f, 0.12582938f, 0.02132104f, 0.10918704f, 
    -0.13246264f, 0.08742312f, 0.12226378f, 0.16623120f, -0.11964171f, 0.09127027f, 0.02855659f, -0.16685750f, 
    -0.25300160f, -0.13396685f, -0.02543454f, 0.15689148f, 0.11891430f, -0.02887509f, -0.11964959f, 0.01696909f, 
    0.03799570f, -0.07186353f, -0.01014971f, -0.05742253f, -0.20023203f, 0.00362494f, 0.09704797f, 0.12173650f, 
    0.04504878f, 0.17121132f, 0.03472625f, 0.17041397f, 0.12486200f, 0.08919892f, 0.17495462f, 0.04301030f, 
    0.00046902f, -0.01245661f, 0.02219889f, 0.13744999f, 0.03418709f, 0.11920025f, -0.06872182f, -0.07486140f, 
    -0.08515928f, -0.05716544f, -0.02641187f, 0.04700506f, 0.01992324f, 0.01260149f, 0.00357227f, 0.10695631f, 
    0.13996969f, 0.06750208f, -0.02671952f, 0.06439627f, 0.03565840f, -0.08481805f, 0.16920948f, -0.06996994f, 
    -0.01977780f, 0.08637086f, 0.03983272f, 0.00470671f, -0.32132655f, 0.22857913f, 0.24550062f, -0.29639369f, 
    -0.03999668f, -0.05781361f, 0.07226751f, 0.00441138f, -0.02695240f, -0.04511623f, 0.02558743f, 0.09285726f, 
    -0.10751252f, -0.27556378f, -0.06362825f, 0.09095179f, 0.05183483f, 0.10192075f, 0.07980134f, 0.01023544f, 
    0.01286093f, -0.02551601f, -0.06826492f, -0.14842130f, 0.07891034f, 0.18356630f, 0.08623683f, -0.30881667f, 
    -0.18224043f, 0.01114517f, -0.03401447f, -0.01979974f, 0.06650303f, -0.00058038f, -0.06561317f, 0.07883628f, 
    0.01824515f, 0.01529084f, -0.07789686f, 0.16927712f, 0.08240830f, 0.00033001f, -0.06182928f, -0.01025222f, 
    -0.04284478f, 0.05174302f, -0.04204824f, 0.05379810f, -0.30415982f, -0.12615530f, 0.25590810f, 0.04079299f, 
    0.06196411f, -0.03230334f, 0.00645170f, -0.03271780f, -0.14809613f, -0.06877425f, 0.06058651f, 0.04864911f, 
    0.09889028f, -0.10941052f, -0.02487720f, 0.07655616f, 0.16904542f, 0.02015874f, 0.08510358f, 0.09943800f, 
    -0.06938671f, 0.02500110f, 0.02076009f, -0.03374531f, 0.26392251f, -0.03545203f, -0.11468211f, -0.15376215f, 
    0.09389446f, 0.05447210f, 0.03913739f, -0.03060647f, 0.06114379f, 0.10436823f, 0.08016109f, -0.07479107f, 
    0.13153760f, 0.15352589f, -0.00116602f, 0.01961056f, 0.05521984f, 0.06262110f, 0.02183509f, -0.08339573f, 
    0.01433223f, 0.05736924f, 0.05540387f, 0.00695805f, -0.07308143f, -0.04024076f, 0.10010391f, -0.07875801f, 
    0.02397752f, -0.05943981f, 0.09003320f, -0.01487291f, 0.06384369f, -0.06639725f, 0.10290400f, -0.03612501f, 
    -0.44139960f, 0.05480860f, 0.14929003f, -0.09851296f, -0.05085561f, 0.06073103f, 0.11792575f, 0.00306582f, 
    0.13354564f, -0.03883971f, 0.01766840f, 0.01425252f, 0.12055766f, 0.02250439f, 0.02355623f, -0.05515128f, 
    -0.00065255f, 0.13413297f, -0.06117869f, 0.03918626f, 0.06364103f, -0.17690516f, 0.01316444f, 0.10383290f, 
    0.23323227f, -0.00280871f, 0.16945416f, 0.06513868f, -0.06569566f, -0.08049286f, -0.08540343f, 0.00275864f, 
    0.03251128f, -0.16645800f, -0.11144913f, 0.04057519f, -0.03592563f, -0.09699146f, 0.08932624f, -0.18111001f, 
    -0.09509636f, 0.10049577f, 0.13408025f, 0.03324658f, 0.15962255f, 0.10075004f, 0.02961843f, 0.07196534f, 
    -0.27770266f, -0.13800631f, -0.09653416f, 0.15634459f, 0.22292234f, 0.11390868f, 0.06248526f, -0.02109402f, 
    -0.07454628f, -0.02342875f, -0.08716470f, 0.04643382f, 0.09435534f, -0.05248112f, -0.15895252f, -0.04996110f, 
    0.20172380f, 0.10414282f, -0.06998656f, 0.02963240f, 0.09251782f, 0.03937593f, -0.05671879f, -0.12686223f, 
    -0.50131726f, 0.03573072f, 0.03720155f, -0.03693977f, 0.08597891f, 0.13143739f, -0.03966158f, -0.07847784f, 
    0.09156945f, -0.00494084f, 0.06124749f, 0.04311044f, 0.32967848f, -0.13116780f, 0.03543961f, 0.21940091f, 
    0.00081417f, 0.05071345f, 0.02515790f, 0.05187124f, 0.12819397f, -0.11340497f, -0.00957842f, -0.09258918f, 
    0.18628885f, -0.13181864f, 0.18133752f, -0.27328211f, -0.02440112f, 0.04025131f, -0.04047994f, 0.01249958f, 
    -0.09580752f, 0.09467375f, 0.14730188f, 0.14166439f, 0.18392800f, -0.13860558f, -0.03490824f, 0.18657039f, 
    -0.08704015f, -0.00305340f, -0.10326764f, 0.12766527f, 0.08801247f, 0.13131158f, 0.06111920f, 0.33946791f, 
    -0.02539633f, -0.17126155f, -0.08888409f, -0.11796418f, 0.12505862f, -0.03086264f, 0.14321269f, 0.11902452f, 
    0.02812027f, -0.03811375f, 0.04895592f, 0.05569584f, 0.04510352f, 0.14902532f, -0.02928960f, -0.06917597f, 
    -0.13767615f, 0.14873351f, 0.13652362f, -0.20992677f, 0.04105147f, 0.10630929f, 0.04368677f, 0.10212161f, 
    -0.14128119f, -0.19664639f, -0.05587178f, 0.04418446f, 0.04393106f, -0.02344430f, -0.01643774f, 0.10946696f, 
    -0.10524292f, -0.05366594f, -0.05232653f, -0.19399410f, 0.28455213f, 0.29585284f, -0.01965525f, 0.28110871f, 
    0.02234067f, -0.07648931f, -0.00258842f, -0.03327463f, 0.13425881f, -0.06658842f, -0.04972339f, 0.11168705f, 
    -0.41122895f, -0.12143602f, -0.04921381f, 0.12090653f, -0.05732169f, 0.11040810f, 0.06442111f, -0.01080978f, 
    -0.14833656f, 0.01127547f, 0.10016003f, 0.07322589f, 0.21173154f, -0.08564322f, -0.03634760f, 0.03634306f, 
    0.03192719f, -0.02000985f, -0.02808244f, 0.07354297f, 0.01347370f, 0.00995228f, 0.10240063f, 0.06611468f, 
    0.29578996f, -0.08838492f, 0.18330754f, -0.01352869f, -0.16292483f, -0.16351826f, -0.02754166f, 0.00916572f, 
    0.04451992f, -0.10019223f, 0.01311746f, 0.03083351f, 0.08731537f, -0.02774457f, 0.08615945f, 0.04324438f, 
    0.06211459f, -0.00299694f, 0.01047841f, 0.00141811f, 0.03611071f, 0.03824900f, -0.22310351f, -0.09226906f, 
    0.11117766f, 0.01661379f, 0.03278130f, -0.05293931f, -0.13796322f, 0.10333976f, 0.12310252f, -0.04972776f, 
    0.10198668f, 0.07038312f, 0.01720046f, 0.07169488f, -0.30371806f, -0.09125870f, -0.29315662f, -0.01690075f, 
    -0.02502829f, -0.01293486f, 0.09062252f, 0.00922689f, -0.09687557f, 0.10964705f, 0.12700650f, 0.01892592f, 
    0.01432509f, -0.05683203f, -0.13050541f, -0.03438628f, 0.15113001f, -0.02347857f, 0.01613871f, 0.02365077f, 
    -0.01141004f, -0.04329312f, -0.04457039f, 0.01214521f, -0.13662715f, -0.24699399f, -0.08387750f, -0.06346686f, 
    0.09925211f, 0.00090083f, 0.08946564f, 0.12062833f, -0.00830088f, 0.02812637f, -0.05633613f, -0.12349066f, 
    -0.33999309f, -0.15902768f, -0.28577861f, -0.01992748f, 0.01987521f, 0.02999325f, 0.10359839f, 0.14352462f, 
    -0.18142211f, 0.12003296f, 0.07889331f, 0.05595455f, 0.30716744f, 0.17113262f, 0.14414251f, 0.14124517f, 
    -0.08656479f, -0.00337878f, 0.06522702f, 0.02813680f, -0.04110192f, 0.13353044f, 0.05676141f, 0.03505947f, 
    0.00754575f, -0.39582050f, -0.20376657f, 0.27463475f, 0.04196839f, -0.01933874f, 0.08684392f, -0.10974512f, 
    -0.06025494f, 0.02490318f, 0.07031117f, -0.26836884f, 0.10629002f, 0.11365155f, 0.10258292f, 0.03182897f, 
    0.08128199f, -0.00581664f, -0.00149015f, -0.01100776f, 0.17507111f, 0.06826852f, -0.09780597f, 0.16366217f, 
    -0.03231857f, -0.33127129f, -0.22163625f, 0.12958984f, 0.02981898f, -0.11712592f, 0.02992393f, 0.00231194f, 
    -0.17167817f, -0.08886085f, -0.02485840f, -0.02650105f, 0.07186801f, -0.07703193f, -0.06757971f, 0.17171831f, 
    -0.06126609f, -0.05121386f, 0.17854549f, 0.01085665f, 0.14615759f, -0.00191009f, 0.09294222f, 0.06624272f, 
    0.05531325f, -0.26916581f, -0.14794716f, -0.03358065f, 0.16599932f, 0.08799110f, 0.03110565f, -0.02506419f, 
    0.00141533f, -0.08587610f, 0.03537009f, -0.06727477f, 0.07871132f, 0.13457185f, 0.15579908f, -0.25314468f, 
    0.17881735f, 0.08154023f, -0.01205893f, -0.04063629f, 0.10562121f, 0.04373568f, -0.06634679f, 0.09171005f, 
    0.05898417f, -0.23085350f, -0.25544065f, 0.08430135f, -0.12691976f, 0.12237805f, -0.01938118f, -0.02603631f, 
    0.04029174f, -0.03689920f, 0.00397226f, 0.02978923f, 0.09900685f, 0.32212231f, -0.00808126f, -0.10069017f, 
    -0.00063380f, 0.07542609f, 0.06248560f, 0.11906450f, 0.01685474f, 0.06210773f, -0.01570953f, 0.03925715f, 
    0.26845926f, -0.02187976f, 0.30104318f, -0.16887923f, 0.04611556f, -0.06946889f, -0.04151861f, -0.11661500f, 
    0.00121929f, -0.00635079f, 0.13676208f, 0.00279527f, 0.11003659f, -0.14151013f, -0.11369561f, -0.12616371f, 
    0.13057165f, 0.12179895f, -0.07434580f, 0.19846834f, 0.05028050f, 0.12285504f, -0.04043726f, 0.08797070f, 
    0.07868673f, -0.17627218f, 0.15400909f, 0.08629758f, -0.01326269f, 0.11756606f, 0.03448297f, 0.03724965f, 
    0.10926615f, 0.19125898f, -0.09101937f, -0.06616084f, 0.06259575f, 0.14074555f, 0.04399751f, 0.09988035f, 
    -0.03932046f, 0.01348521f, 0.11432012f, 0.02686869f, -0.00870953f, -0.06435266f, 0.01019485f, -0.02282754f, 
    -0.15705471f, -0.00592924f, 0.06607308f, -0.08119321f, 0.04882750f, -0.12279010f, -0.09829195f, -0.05644310f, 
    0.08718710f, 0.09913452f, -0.10210625f, 0.01483260f, -0.25874069f, 0.30546686f, 0.22435203f, 0.20737062f, 
    -0.13166244f, -0.04231454f, 0.06467905f, -0.02835045f, 0.01451078f, -0.13657683f, -0.03492347f, -0.00837462f, 
    0.15244164f, 0.09741378f, -0.04371276f, -0.03927107f, 0.01841818f, -0.02915405f, 0.05836266f, 0.09534276f, 
    0.00894418f, 0.01468119f, -0.10802665f, 0.07381420f, -0.20765829f, -0.18390112f, -0.12590405f, -0.03050238f, 
    0.22804527f, 0.06421210f, 0.01559905f, -0.05991695f, -0.00373078f, -0.00040289f, 0.01422933f, -0.02834887f, 
    -0.04944006f, 0.23510705f, -0.06427908f, 0.27505028f, 0.05251719f, 0.02982933f, -0.02184127f, -0.00521117f, 
    0.10304548f, -0.04992704f, -0.05818317f, 0.09930509f, -0.08057993f, 0.02200515f, -0.01228548f, -0.00048407f, 
    0.14331257f, 0.03338838f, -0.05986435f, 0.02074304f, 0.02904592f, 0.01503628f, 0.17688057f, 0.02348114f, 
    -0.28518513f, -0.01022517f, 0.09475902f, 0.36114407f, -0.00395085f, -0.03028154f, 0.09323560f, 0.09999333f, 
    -0.06387396f, -0.06260868f, -0.03771336f, -0.10895725f, -0.04572231f, -0.08143207f, -0.02624507f, 0.19308051f, 
    0.03718363f, -0.08532429f, 0.05096250f, -0.10171591f, -0.00342045f, 0.05331553f, -0.00952437f, -0.08017327f, 
    0.10356273f, -0.01317584f, 0.25102746f, -0.03647709f, -0.03333883f, 0.00374174f, 0.09435320f, -0.07442549f, 
    0.09518972f, 0.00888410f, 0.09618454f, 0.13056770f, -0.27758351f, 0.26082855f, 0.05597536f, -0.18459295f, 
    0.17931855f, 0.02144630f, -0.01933560f, -0.02123670f, -0.02302000f, -0.00645021f, -0.00120412f, -0.02420003f, 
    0.01424792f, 0.11800265f, 0.00117321f, -0.08491655f, 0.14877495f, -0.00095485f, -0.10402542f, 0.10946313f, 
    -0.00066193f, -0.11723371f, 0.06040310f, 0.01953707f, 0.07466063f, -0.21477604f, -0.04440191f, -0.05443224f, 
    -0.00307088f, -0.03791030f, 0.00926883f, 0.11881343f, 0.00746117f, 0.15267152f, 0.03139413f, 0.04554820f, 
    -0.17392567f, 0.20993675f, 0.23652484f, -0.12575813f, 0.14729503f, 0.12243780f, 0.08107818f, -0.05374241f, 
    0.00991585f, -0.04383692f, 0.10966317f, -0.01175054f, -0.00385552f, 0.05902668f, 0.04422677f, -0.07285144f, 
    0.02268491f, -0.05786736f, -0.04417432f, 0.02090854f, 0.00497111f, -0.04811766f, -0.03965907f, 0.07595601f, 
    -0.15113552f, -0.17926219f, 0.05187306f, -0.20564342f, 0.05887379f, -0.00493328f, 0.02988546f, 0.00867370f, 
    -0.08687273f, -0.13376731f, -0.02926833f, 0.01680905f, 0.25810152f, -0.10973573f, -0.27991608f, 0.13719006f, 
    -0.01210104f, -0.04454430f, -0.16295044f, -0.09990601f, 0.05167706f, 0.03745420f, -0.08852112f, 0.04041094f, 
    0.01184455f, 0.04127762f, -0.08071362f, 0.01739628f, 0.09516371f, 0.08771862f, 0.05352884f, -0.06127852f, 
    -0.07839446f, -0.01236215f, 0.07543346f, 0.15160790f, 0.41741601f, 0.16127276f, 0.05421358f, 0.00970733f, 
    -0.02878353f, 0.07907858f, 0.00341002f, 0.15761542f, -0.00449053f, 0.03108068f, -0.00312979f, -0.04045845f, 
    0.24217477f, -0.00303825f, -0.03688634f, 0.01955456f, -0.03267837f, 0.01513484f, 0.11523148f, -0.06426796f, 
    0.05236878f, 0.01921099f, 0.01810180f, 0.04811701f, -0.23321380f, 0.10323063f, 0.17868330f, 0.14829797f, 
    0.12432445f, 0.02398137f, 0.00417144f, 0.06257246f, 0.01716645f, -0.13980946f, 0.00684417f, 0.03000635f, 
    -0.10408639f, 0.14238651f, 0.09317935f, 0.00781067f, -0.04262719f, 0.07808525f, 0.01664274f, 0.10316642f, 
    0.07190748f, -0.03512118f, 0.01585401f, 0.03821079f, -0.17310844f, -0.05087932f, 0.03403062f, -0.27816355f, 
    -0.03210507f, -0.08966533f, -0.04445648f, 0.09387451f, 0.10473963f, 0.12418128f, -0.01903695f, 0.09488566f, 
    0.01602511f, 0.02400338f, 0.07508066f, -0.13670342f, -0.04414264f, 0.08315258f, 0.02606474f, -0.04891026f, 
    -0.01945670f, -0.01669488f, 0.02352099f, 0.02900450f, -0.20382404f, -0.08081239f, -0.13623618f, -0.22067055f, 
    0.10907354f, 0.09013288f, 0.00358997f, -0.06954920f, -0.01787835f, -0.03443815f, 0.04568342f, 0.00314518f, 
    -0.02223288f, -0.23238707f, -0.34667209f, -0.26576117f, 0.06472704f, 0.06471690f, 0.18129803f, 0.11903821f, 
    0.05991639f, 0.00447288f, 0.01780659f, 0.08438575f, 0.40318117f, 0.09930332f, -0.08895162f, 0.06878789f, 
    -0.01155943f, -0.07735503f, 0.03854859f, 0.04858328f, -0.01090522f, 0.11216073f, 0.05205323f, -0.03416833f, 
    -0.01026504f, 0.07938952f, -0.25881997f, -0.23993452f, -0.05910704f, 0.04208216f, 0.03382051f, -0.10019714f, 
    0.08596005f, 0.06916994f, 0.08450674f, 0.08893485f, 0.33963484f, 0.11918952f, -0.03740833f, 0.12140325f, 
    -0.02716396f, 0.15231313f, -0.00450179f, -0.04032548f, 0.09925237f, -0.09062972f, 0.16419284f, -0.02005055f, 
    -0.13916217f, 0.07000405f, -0.00979715f, 0.16351552f, 0.16551727f, -0.00745373f, -0.03880756f, -0.08483328f, 
    0.10850911f, -0.01619176f, -0.10167331f, 0.00248792f, 0.21692148f, -0.07933664f, -0.05358315f, 0.27196550f, 
    0.20798357f, -0.10005294f, -0.14714485f, 0.12985092f, 0.10064981f, -0.08766834f, -0.08226349f, 0.01618887f, 
    0.02652931f, 0.02891333f, 0.01902394f, -0.04659854f, -0.00661839f, -0.03203936f, -0.02903284f, 0.04656095f, 
    0.04945655f, 0.00702293f, -0.02401894f, -0.04936738f, 0.00315544f, -0.02206423f, 0.06840986f, 0.00760393f, 
    -0.03314210f, 0.03205794f, -0.01906986f, 0.03602447f, -0.06663949f, -0.00579099f, -0.02346533f, -0.02862889f, 
    0.02184990f, 0.04665199f, -0.00044789f, -0.00382923f, -0.04622920f, -0.06822553f, 0.03941917f, -0.07207607f, 
    0.00755606f, -0.03491403f, 0.05254483f, -0.01071541f, -0.06107957f, 0.02531808f, -0.04755162f, -0.04323769f, 
    0.04593771f, 0.02102589f, -0.07083607f, 0.01157864f, -0.05824713f, 0.04887047f, -0.01206671f, 0.05127304f, 
    0.04585926f, 0.04998215f, -0.01472922f, 0.00783108f, -0.01645228f, 0.00158134f, -0.01167603f, 0.05796166f, 
    -0.00683050f, -0.06687422f, -0.05103166f, 0.00041824f, 0.01114742f, -0.03207405f, -0.05251599f, 0.02688743f, 
    0.04905757f, -0.03397778f, -0.02512134f, 0.02909366f, 0.01576136f, -0.00589950f, -0.00236531f, -0.04689913f, 
    -0.05988380f, -0.00169957f, 0.01105504f, 0.02233434f, -0.01016390f, -0.06858942f, 0.05173960f, -0.06133517f, 
    -0.04907666f, 0.00243589f, 0.01759550f, 0.06001439f, -0.04908016f, -0.06924099f, -0.07898173f, 0.02856326f, 
    0.05822499f, 0.03902321f, -0.05227230f, 0.05915590f, -0.03436738f, 0.04507472f, 0.02477512f, -0.04688573f, 
    0.04916048f, -0.06605372f, -0.07479371f, -0.08172989f, -0.06557390f, 0.02040569f, -0.07173879f, 0.05999413f, 
    -0.04945185f, -0.00290624f, -0.01894134f, -0.06799721f, 0.02006913f, -0.02307669f, 0.00118778f, -0.04315491f, 
    -0.00653438f, -0.04268268f, 0.00367864f, 0.01435583f, -0.02337020f, -0.06904200f, -0.04268503f, -0.03040457f, 
    -0.05370159f, 0.05172686f, -0.00857678f, -0.02856933f, -0.05678641f, -0.02146132f, -0.00683820f, -0.07582361f, 
    0.03204684f, 0.05047049f, 0.05323464f, -0.08420907f, 0.01725991f, 0.00375049f, 0.03313555f, 0.05386305f, 
    0.00421129f, 0.06419927f, -0.05668078f, -0.07524668f, -0.03492552f, -0.01060008f, -0.03186549f, 0.03183951f, 
    0.05759726f, -0.00608125f, -0.01853676f, -0.00946214f, 0.06273772f, 0.00702388f, -0.06491654f, 0.04192264f, 
    -0.04676467f, 0.05979973f, -0.01243858f, 0.03813588f, 0.01376643f, 0.02597268f, 0.01926887f, 0.05759508f, 
    -0.06251987f, -0.05950844f, 0.01069502f, 0.05240574f, -0.01861138f, -0.02572879f, -0.07046006f, 0.04777414f, 
    -0.00774630f, -0.05412627f, -0.01751795f, 0.04241167f, -0.02522509f, -0.03062342f, 0.01333129f, -0.03021760f, 
    -0.07414605f, -0.00027660f, -0.03855276f, 0.06084158f, -0.08092561f, 0.04885497f, -0.08061426f, 0.00724349f, 
    -0.05402401f, -0.01020780f, -0.06984998f, 0.02044212f, 0.05939034f, -0.03097477f, 0.01049509f, 0.03600755f, 
    -0.01179960f, -0.03127706f, -0.03891102f, 0.00425595f, 0.04079958f, 0.00003520f, -0.04172280f, -0.02835488f, 
    -0.02568282f, 0.02386530f, -0.00476976f, -0.01336973f, -0.04334109f, 0.05678492f, 0.00752370f, 0.02363665f, 
    -0.04375664f, 0.00307620f, 0.00198451f, -0.06566241f, 0.06620118f, -0.00860724f, -0.06040860f, -0.05205232f, 
    -0.02260971f, -0.03807671f, 0.00575132f, -0.03638435f, -0.03597244f, 0.05685774f, 0.05221320f, -0.04746898f, 
    -0.02777158f, 0.05478942f, -0.00895284f, -0.03447470f, -0.04625114f, -0.05979915f, 0.03490573f, 0.06783896f, 
    -0.06380764f, -0.03505702f, 0.04564080f, -0.06566074f, -0.01584295f, -0.05751032f, -0.06349362f, 0.07011617f, 
    0.00189118f, -0.03496906f, -0.06349301f, 0.06031106f, 0.04135676f, -0.07152180f, 0.03563502f, 0.00698861f, 
    0.01182339f, -0.00023589f, -0.04026208f, 0.00363718f, -0.07211618f, -0.01807788f, -0.01727749f, 0.02800173f, 
    -0.00193973f, -0.02828064f, 0.06202559f, -0.01418388f, -0.07060321f, -0.05521993f, -0.03292631f, 0.02674053f, 
    0.06176151f, -0.05049086f, -0.02397648f, -0.02983662f, 0.01369619f, -0.04469087f, -0.00951754f, -0.04673696f, 
    0.00383815f, -0.05618707f, 0.00213975f, -0.02540008f, -0.00282421f, -0.01860333f, 0.00397023f, -0.06807418f, 
    -0.02771129f, -0.03511228f, 0.04041625f, 0.03046425f, 0.01702266f, 0.00523619f, 0.04571089f, -0.01638371f, 
    0.03307304f, -0.01535620f, 0.07127526f, 0.05403274f, 0.01190488f, -0.05715603f, 0.00364564f, 0.06925545f, 
    0.01033890f, -0.06816275f, 0.02363275f, 0.02578334f, 0.03152595f, -0.04541413f, -0.04433109f, -0.00835955f, 
    -0.00044931f, 0.05175881f, 0.03360907f, -0.03966496f, 0.01001179f, -0.02539625f, 0.00474247f, -0.03885034f, 
    -0.01965953f, -0.05924262f, -0.04991343f, -0.02033640f, -0.00082760f, 0.01428013f, 0.03855460f, 0.04708168f, 
    -0.01321201f, 0.04344091f, -0.04142970f, 0.06857869f, -0.01018110f, 0.04505406f, -0.00504532f, 0.04577780f, 
    -0.05575076f, -0.06128034f, -0.02828461f, -0.03884186f, -0.05065406f, -0.03697238f, -0.02177862f, 0.07055403f, 
    -0.07018409f, 0.05735300f, -0.04724133f, 0.00728279f, -0.05475578f, -0.05085386f, -0.04478741f, -0.05984036f, 
    0.00634682f, 0.04721513f, 0.04668459f, 0.03869330f, -0.07163690f, 0.01702922f, -0.01261830f, 0.00177848f, 
    -0.04499787f, 0.06571236f, -0.06834850f, 0.04055201f, 0.05020759f, -0.04840718f, -0.06598984f, 0.04247170f, 
    0.00330153f, 0.04169483f, -0.00607106f, -0.02941522f, 0.03186870f, -0.00120781f, -0.04199077f, 0.06221318f, 
    0.01441971f, -0.02393381f, 0.05074383f, -0.01915211f, -0.03816781f, -0.02253300f, -0.03460137f, -0.04863744f, 
    0.00535493f, -0.02472921f, -0.00684602f, 0.00933982f, 0.03773415f, -0.05020897f, 0.03704150f, -0.01568838f, 
    -0.02460790f, 0.18648210f, -0.10219583f, -0.13133195f, -0.13240092f, -0.02591456f, 0.02144839f, -0.08678491f, 
    -0.09385507f, -0.16459017f, 0.08757567f, 0.07086626f, 0.08398717f, -0.08763770f, 0.14705960f, -0.07611132f, 
    -0.03060455f, 0.11680105f, -0.14637133f, -0.09433571f, -0.00544059f, 0.08021271f, 0.14737731f, -0.05368929f, 
    0.13097535f, -0.00070132f, 0.02362284f, 0.12492021f, -0.02232931f, 0.07288355f, 0.09194154f, 0.00652101f, 
    0.00118309f, -0.15512803f, 0.01550097f, 0.01382050f, 0.10111575f, -0.30602521f, 0.03201679f, -0.06293614f, 
    -0.01181227f, -0.06286155f, 0.06196423f, 0.04989464f, 0.00132894f, 0.07421731f, -0.03567352f, 0.01986928f, 
    0.16419467f, 0.02807254f, -0.06446877f, 0.12266745f, -0.03708974f, 0.01833780f, -0.10808749f, 0.13165143f, 
    -0.09882436f, 0.08015437f, 0.06131931f, -0.03117697f, 0.26795289f, 0.31540671f, 0.14125684f, -0.03599592f, 
    -0.20923871f, 0.06870763f, 0.03755838f, 0.06061835f, -0.00456318f, 0.03999483f, 0.02824256f, 0.07391957f, 
    0.19641031f, -0.34713417f, 0.11480127f, -0.13279507f, -0.06110209f, -0.13374226f, 0.21703441f, -0.05393358f, 
    -0.08484341f, 0.01999665f, 0.09769445f, -0.13017972f, 0.21120849f, 0.06647645f, -0.20748895f, 0.14694405f, 
    0.06040920f, 0.03325134f, 0.05547191f, 0.05921101f, 0.02340632f, -0.07872972f, -0.08460972f, 0.09382699f, 
    0.24548936f, -0.11807762f, -0.03927634f, -0.06959944f, -0.06485121f, -0.01976248f, -0.13765238f, 0.04084859f, 
    0.02396580f, 0.08232428f, -0.03409332f, 0.11751936f, -0.11920676f, 0.03952900f, -0.12551896f, -0.20250520f, 
    0.03809348f, 0.10359211f, 0.00301298f, 0.08707965f, -0.05655119f, -0.08867255f, -0.03924406f, 0.08184454f, 
    0.03141387f, -0.19310409f, -0.09404988f, 0.06233196f, 0.06231397f, 0.00033697f, -0.05422657f, 0.02621962f, 
    -0.03741675f, 0.05369956f, 0.09250633f, -0.08859887f, 0.08874786f, -0.08662849f, -0.08507727f, -0.02185645f, 
    0.06120348f, -0.07793152f, -0.06892951f, 0.10424332f, -0.08389390f, 0.00101819f, -0.14652857f, -0.04813898f, 
    -0.11436673f, -0.08223416f, 0.00176131f, 0.10026523f, -0.12213536f, 0.10755217f, 0.03122018f, 0.02618732f, 
    0.05961596f, 0.02931271f, -0.02969818f, 0.10219511f, 0.30661777f, 0.27643150f, 0.07655931f, 0.05310256f, 
    0.05994183f, -0.01952071f, 0.04368974f, -0.04923892f, -0.02080808f, -0.08936886f, -0.01842968f, -0.06243091f, 
    0.22312300f, -0.14981881f, 0.06295571f, -0.02383468f, -0.01288783f, -0.10154013f, -0.03525848f, 0.12432990f, 
    0.01507780f, 0.11939219f, -0.07264717f, 0.06649308f, 0.06121306f, -0.13725097f, -0.07630891f, 0.00704609f, 
    0.09756815f, 0.10232872f, 0.12799494f, 0.07078505f, -0.01651997f, -0.00834141f, 0.08313634f, -0.01939552f, 
    -0.04000752f, 0.01608104f, -0.17914611f, -0.17817542f, 0.10345810f, -0.07491826f, 0.08249446f, 0.20387551f, 
    -0.09583847f, -0.13590488f, -0.02051334f, -0.04515155f, -0.06367677f, -0.04860247f, -0.15285841f, 0.10513726f, 
    -0.05187344f, -0.07644424f, -0.13577123f, -0.02674924f, 0.10924015f, 0.00811909f, -0.18727556f, -0.05320614f, 
    0.11788033f, 0.11257297f, -0.07308695f, -0.05853936f, 0.04364759f, 0.07487233f, 0.00220491f, -0.00582253f, 
    -0.05578174f, 0.02788748f, 0.11950932f, 0.16517608f, 0.39117292f, -0.17916687f, -0.18377738f, 0.03217244f, 
    0.04384451f, 0.02534149f, -0.12250067f, 0.05127794f, -0.01971983f, 0.09909236f, 0.01657173f, -0.01627873f, 
    -0.37385327f, -0.19032952f, -0.02299445f, 0.01707448f, 0.02273679f, -0.03727822f, -0.05680270f, -0.17633562f, 
    0.03386625f, -0.04916819f, 0.05781437f, -0.03249475f, 0.11888786f, -0.00029310f, 0.05395831f, 0.16982564f, 
    0.05555565f, -0.02761009f, 0.01107545f, -0.06157310f, -0.10501424f, -0.11349817f, 0.03038658f, 0.03798739f, 
    -0.01561169f, 0.25254884f, -0.06172828f, -0.11516941f, -0.10988579f, -0.09157602f, -0.16370833f, 0.08596209f, 
    -0.04410701f, 0.05584108f, 0.07447547f, -0.05520703f, -0.14616941f, -0.09458289f, 0.01921927f, -0.01707103f, 
    0.11529851f, 0.04969933f, -0.07324397f, 0.07190602f, -0.05928809f, 0.06161899f, 0.01943600f, 0.09802265f, 
    0.12950753f, 0.12461038f, 0.11648548f, -0.11204705f, -0.10771681f, -0.00384955f, -0.00982885f, -0.12774193f, 
    0.03947238f, -0.02295781f, 0.02997612f, -0.01540903f, 0.16996445f, -0.13728961f, -0.13077049f, 0.00182929f, 
    0.05018629f, -0.06208408f, 0.06675497f, 0.05293444f, 0.05842302f, 0.02957126f, 0.08694045f, 0.15684623f, 
    -0.00025955f, 0.25670561f, -0.24015491f, -0.05102374f, 0.03578820f, 0.07851142f, -0.02441099f, 0.04061687f, 
    -0.02170512f, -0.04783425f, -0.11749721f, 0.02337571f, 0.15906061f, -0.09642164f, 0.18892248f, 0.04310456f, 
    0.03182983f, 0.07623453f, -0.02822543f, -0.04816022f, 0.05552784f, 0.03033159f, -0.00944338f, 0.05012468f, 
    0.20470634f, -0.01695206f, -0.03046687f, 0.07160585f, -0.03447105f, 0.01092178f, 0.07001034f, -0.01286334f, 
    0.01680234f, 0.18469693f, -0.02522084f, 0.02543497f, 0.06774912f, 0.10751373f, -0.04037704f, 0.00196383f, 
    0.09095956f, 0.03966798f, 0.00044923f, -0.02168084f, 0.01326755f, -0.09982507f, 0.02627472f, 0.13949247f, 
    0.24875933f, -0.04646791f, -0.11716246f, 0.07629775f, 0.08285860f, -0.03677551f, -0.01358997f, -0.04417767f, 
    -0.00065652f, -0.08094008f, 0.04585852f, 0.03504290f, 0.10394914f, 0.08275032f, -0.07948586f, 0.13240609f, 
    0.12378843f, -0.05030114f, -0.05486839f, 0.07876702f, 0.08439578f, 0.02408616f, -0.01794875f, -0.08846509f, 
    -0.27740228f, 0.02985158f, -0.01384367f, 0.11331797f, 0.04894564f, -0.09602086f, 0.02002903f, -0.00838006f, 
    -0.18424155f, 0.01991135f, -0.11300336f, 0.09931017f, 0.29412815f, -0.10615235f, 0.09051617f, -0.04631406f, 
    -0.02108886f, -0.04571718f, 0.03662287f, -0.03768424f, 0.13535684f, -0.03908055f, -0.14530525f, 0.02932123f, 
    -0.04167686f, -0.04825285f, -0.12042073f, 0.09541144f, -0.02436398f, 0.05592830f, -0.00727075f, 0.03422399f, 
    0.01748119f, -0.06687246f, 0.16434015f, 0.17960492f, 0.30933493f, -0.00413807f, -0.06418948f, -0.25926408f, 
    0.00216562f, 0.06683406f, -0.06458817f, 0.01095203f, 0.07601654f, 0.08866533f, 0.06371602f, 0.08516511f, 
    0.51211679f, 0.07497948f, 0.14905809f, 0.12799484f, -0.05899029f, 0.08377096f, -0.03691778f, -0.06087984f, 
    0.02513948f, -0.12674752f, 0.05382035f, 0.00749144f, -0.18134300f, 0.20281039f, 0.22789699f, -0.03671629f, 
    -0.00427714f, -0.07203908f, 0.16463023f, -0.02406614f, 0.02241152f, -0.03545382f, 0.02555701f, -0.02614896f, 
    0.01386053f, 0.12121625f, 0.04381673f, -0.22441293f, -0.08332222f, 0.06696114f, 0.06565541f, -0.09903694f, 
    -0.08912373f, 0.00628252f, 0.03439588f, 0.08461115f, 0.33552796f, 0.20667224f, -0.10340181f, -0.25527230f, 
    -0.07059462f, -0.10757945f, 0.02063661f, 0.03566813f, -0.12017531f, 0.04124931f, 0.06507389f, 0.09663034f, 
    -0.02346608f, 0.07988654f, -0.11296568f, -0.23452985f, 0.11434089f, 0.09156273f, -0.11080673f, 0.02307617f, 
    0.12781328f, -0.00345306f, 0.06009053f, 0.06604434f, -0.36647660f, 0.27355516f, 0.02097926f, -0.16364123f, 
    0.14002511f, 0.10382649f, -0.00236420f, -0.03488491f, -0.15176775f, 0.04469316f, -0.09522301f, 0.05903413f, 
    -0.17735536f, -0.03840684f, -0.15873419f, 0.01036604f, -0.06638051f, -0.10041762f, 0.03666657f, 0.04259605f, 
    0.01577614f, 0.10425967f, 0.00263511f, 0.09226405f, 0.08800102f, -0.03686368f, 0.06518862f, 0.16857606f, 
    -0.17046483f, -0.00456768f, 0.06126659f, -0.01019188f, -0.00498536f, 0.11830305f, 0.04933605f, 0.06898925f, 
    -0.16416292f, -0.00838207f, -0.07303529f, -0.01805986f, 0.05285574f, -0.06273821f, 0.04253152f, -0.19416112f, 
    0.07478078f, 0.06624955f, 0.05114347f, -0.03699677f, 0.14381923f, 0.05962009f, -0.02897562f, 0.08324120f, 
    0.06867537f, 0.09495220f, -0.02151841f, -0.06815917f, 0.01371374f, 0.02574980f, 0.11198452f, 0.01102949f, 
    -0.16442393f, 0.05235029f, -0.09589092f, 0.21545927f, 0.01512016f, 0.06601667f, -0.00055552f, 0.10947613f, 
    0.07343198f, -0.05759901f, -0.01137180f, 0.07834251f, 0.16728310f, 0.02043027f, 0.02861059f, 0.15480204f, 
    0.00393990f, -0.08948267f, -0.00698274f, -0.13161166f, -0.02095790f, -0.03943675f, -0.08578750f, -0.00641528f, 
    0.00892399f, 0.02197922f, 0.14123428f, 0.23113652f, -0.10419931f, 0.03286852f, -0.05223445f, -0.09815829f, 
    -0.02324517f, 0.04050535f, -0.07890513f, 0.15983136f, 0.01719313f, 0.07808042f, 0.01782812f, -0.23038392f, 
    0.13810705f, 0.02531324f, 0.23367713f, 0.01585112f, 0.07665411f, -0.07776452f, 0.01059291f, 0.15650974f, 
    -0.18742923f, -0.01649230f, 0.05657870f, 0.17535020f, 0.15633620f, 0.00212058f, 0.13521689f, 0.04094365f, 
    0.07357278f, 0.04100336f, -0.05436604f, 0.11218832f, -0.21358681f, 0.17050913f, -0.01802341f, -0.14549179f, 
    -0.03423291f, 0.04349159f, 0.01281814f, 0.02621081f, 0.03823298f, -0.00361232f, -0.04865111f, 0.06355817f, 
    -0.12541690f, 0.17444229f, -0.01654077f, -0.01955749f, 0.07569524f, 0.05000317f, 0.03765896f, -0.08625866f, 
    0.06072673f, 0.01227935f, 0.02675272f, -0.04793783f, -0.14866802f, -0.17865917f, 0.13118957f, -0.06757659f, 
    -0.10862543f, -0.00627999f, -0.02455964f, 0.04598660f, 0.04616138f, -0.00654875f, -0.10216285f, -0.03452844f, 
    -0.03826112f, -0.24898541f, -0.07622864f, -0.19348235f, 0.00330590f, 0.14539079f, 0.01917700f, -0.08141737f, 
    -0.00706046f, -0.00680808f, 0.01230650f, 0.02440103f, 0.10290401f, 0.05261571f, 0.09515809f, 0.03908464f, 
    -0.10302811f, -0.11958326f, -0.05401877f, 0.08434179f, -0.00302597f, -0.01081102f, 0.09476773f, 0.20190549f, 
    -0.02442748f, -0.18042183f, -0.13512412f, 0.09034297f, 0.25729766f, -0.05210833f, 0.14672333f, 0.10040566f, 
    0.05108426f, -0.00252629f, -0.01190807f, -0.05921316f, -0.29356802f, 0.03558650f, 0.28514177f, 0.03933218f, 
    -0.06914466f, 0.01657609f, 0.08380604f, -0.12348439f, -0.11769833f, -0.06558052f, 0.11552476f, -0.00217233f, 
    0.01412116f, -0.17118759f, 0.15511656f, 0.19952148f, 0.12881044f, -0.05689838f, 0.00610843f, 0.01357788f, 
    0.07264179f, 0.04056736f, -0.04174763f, -0.11761839f, 0.05205767f, 0.19418488f, -0.02443836f, 0.09534246f, 
    -0.13800697f, -0.04181654f, 0.08201642f, -0.07661084f, 0.19375917f, 0.15575805f, 0.09328485f, 0.02127218f, 
    -0.17828991f, 0.09260119f, 0.11154231f, 0.00546275f, 0.13828963f, 0.09313869f, -0.02098314f, -0.00385335f, 
    -0.04194281f, 0.00756913f, 0.13575311f, 0.10410111f, -0.40263683f, -0.10478432f, -0.05702093f, -0.03284793f, 
    -0.06109677f, 0.02698448f, 0.01028559f, -0.01212910f, 0.07541915f, 0.11930666f, 0.12277170f, 0.03973036f, 
    -0.40590435f, 0.00458747f, 0.17364289f, 0.02708304f, -0.16788395f, 0.07134993f, 0.05971466f, 0.02600668f, 
    0.00999843f, -0.08256000f, -0.03189741f, 0.06967694f, 0.21907687f, 0.11105850f, 0.26495618f, -0.04199747f, 
    0.01251970f, 0.02977642f, 0.04909753f, -0.03861961f, 0.03191091f, 0.01489783f, -0.17094973f, 0.00665430f, 
    -0.06911611f, 0.15286179f, -0.17229424f, 0.03506681f, -0.00712167f, 0.05192708f, 0.04690061f, 0.00872909f, 
    -0.06235819f, -0.06641215f, 0.14061019f, 0.10329679f, -0.12761249f, -0.04077714f, 0.03852636f, -0.04022190f, 
    0.05732049f, 0.09296299f, 0.05369840f, 0.00940032f, -0.05701324f, 0.07653677f, -0.00760604f, 0.08873226f, 
    0.06027674f, -0.01541397f, -0.17667614f, 0.06452243f, -0.02744950f, 0.06521085f, -0.02376987f, 0.04859639f, 
    -0.05880401f, -0.04921751f, 0.05487114f, 0.00592627f, 0.03208394f, -0.26070049f, -0.13101484f, -0.23974106f, 
    0.06562738f, -0.06973965f, -0.01988368f, 0.03108504f, 0.06967498f, 0.05598759f, 0.03798983f, 0.01199534f, 
    -0.26677695f, 0.00776252f, -0.02339600f, 0.01686975f, 0.03238642f, 0.10937908f, -0.04444219f, 0.05224406f, 
    -0.10698824f, 0.07280696f, 0.00845704f, 0.01897023f, 0.41162875f, 0.27307442f, 0.09065370f, 0.12971012f, 
    -0.21146205f, -0.00860773f, 0.03847869f, 0.08340750f, 0.07752079f, 0.00218452f, -0.00490302f, 0.09177475f, 
    0.24021673f, -0.19641952f, -0.07570071f, -0.24942526f, -0.02551758f, -0.02658433f, 0.11869208f, 0.05463189f, 
    -0.11019576f, -0.01672330f, -0.00230372f, -0.05140363f, 0.15406524f, 0.05924333f, 0.08373001f, 0.09000243f, 
    -0.09441962f, 0.05281339f, 0.01453149f, -0.02950948f, 0.03969254f, -0.05813382f, -0.21656574f, -0.02390016f, 
    0.23676257f, -0.07807126f, -0.14678787f, -0.31414703f, -0.07363559f, -0.06464650f, -0.00421780f, -0.06610539f, 
    0.04048041f, 0.07752338f, 0.02521072f, 0.08266506f, 0.04767635f, 0.07243064f, 0.06118980f, 0.03008348f, 
    -0.04450294f, 0.06761607f, 0.00411595f, 0.05335397f, 0.03846052f, -0.00810747f, 0.04360441f, 0.13270923f, 
    -0.07334922f, 0.11324888f, -0.10919516f, 0.10486778f, 0.18571304f, 0.11693241f, -0.11133964f, 0.13093631f, 
    0.04854873f, -0.01077735f, 0.00678200f, -0.05237416f, 0.25901487f, -0.11393023f, 0.10533655f, 0.01071051f, 
    -0.13846560f, -0.04955871f, -0.05489476f, 0.03912272f, 0.00538747f, 0.00276753f, -0.06427058f, 0.09132063f, 
    -0.03043905f, -0.10084251f, 0.11910070f, 0.09775663f, -0.15009597f, 0.07743751f, -0.02841810f, 0.05535863f, 
    0.09187934f, 0.09330274f, -0.05010302f, 0.04223968f, -0.22137520f, 0.19708943f, 0.10918916f, 0.03794403f, 
    -0.03138966f, -0.07841342f, 0.05396834f, -0.01665341f, -0.03048158f, -0.04692340f, -0.06510098f, 0.02542982f, 
    0.35770628f, -0.02375143f, -0.03481266f, 0.04108458f, -0.18063137f, 0.00998678f, -0.12324929f, 0.03145384f, 
    -0.04661967f, 0.00728426f, -0.03400050f, 0.00069830f, 0.06118913f, -0.03011527f, -0.08602698f, 0.10210725f, 
    0.10353467f, 0.06612202f, 0.01463086f, 0.06039270f, -0.07165996f, 0.04646017f, 0.00107183f, 0.07611503f, 
    0.23742676f, 0.14865747f, 0.07222645f, -0.00500659f, -0.07644588f, 0.10480618f, 0.06324638f, 0.09370434f, 
    0.06996628f, 0.05671698f, 0.20704840f, -0.00480631f, -0.23051816f, -0.21894106f, 0.02864684f, 0.00464062f, 
    -0.01300210f, 0.06871253f, -0.04777182f, 0.05510176f, -0.10651719f, 0.00474926f, 0.15577842f, -0.05440520f, 
    -0.11415866f, -0.02574943f, -0.14166297f, -0.02619066f, 0.06593338f, -0.02949345f, -0.04072405f, -0.04269588f, 
    -0.10634732f, -0.08332121f, -0.05689762f, -0.18282048f, -0.00477843f, -0.29160035f, -0.28167620f, -0.09379216f, 
    0.18830885f, -0.09574905f, 0.01848555f, -0.05577288f, 0.03367701f, 0.01362519f, -0.01177924f, 0.06617863f, 
    -0.35642752f, -0.20069353f, -0.02448728f, -0.10058074f, -0.06343210f, 0.04994745f, -0.03296312f, -0.01466408f, 
    -0.06403188f, 0.03289773f, 0.05923261f, 0.16733968f, 0.26583076f, 0.26355010f, -0.03107651f, 0.03110532f, 
    0.10511609f, -0.00284904f, -0.04165588f, 0.01222699f, 0.01058563f, 0.10627856f, 0.03814158f, 0.03233142f, 
    0.20345262f, -0.12007988f, 0.05567209f, 0.18549447f, 0.04346031f, 0.09310574f, 0.02381402f, -0.00997505f, 
    -0.03375429f, 0.10456730f, -0.10735324f, -0.09365235f, 0.04585213f, 0.17283629f, 0.01283847f, -0.24785735f, 
    0.10273595f, 0.11229454f, 0.05948118f, 0.01664983f, 0.05685261f, -0.05679315f, -0.12445600f, 0.00048027f, 
    -0.04485856f, -0.18352136f, -0.10871918f, -0.00912497f, -0.13543519f, -0.05167038f, -0.03723618f, -0.02513277f, 
    0.00156818f, -0.02082108f, -0.02910097f, 0.13716273f, 0.25101826f, -0.04318414f, 0.06896973f, 0.14509274f, 
    0.05576155f, 0.13195242f, -0.04802338f, 0.06118126f, 0.03681168f, -0.10917228f, 0.07685529f, -0.03951257f, 
    0.07511764f, 0.00086735f, -0.16375250f, 0.01129451f, 0.01824320f, -0.00005763f, -0.05589275f, 0.04248407f, 
    0.10989854f, 0.00142454f, 0.07817502f, -0.00705855f, 0.15814190f, -0.03968397f, 0.16702880f, -0.18250141f, 
    0.27789122f, 0.05464988f, 0.12914005f, -0.04106208f, -0.16589719f, 0.02522855f, -0.12283887f, 0.01574495f, 
    -0.09813101f, -0.15988909f, -0.10636412f, 0.21413258f, -0.20690799f, -0.00061382f, 0.09219280f, 0.13829635f, 
    0.07133094f, -0.03837345f, 0.05892066f, 0.09936357f, 0.33262825f, -0.23235412f, 0.13533899f, 0.06159771f, 
    0.02024560f, -0.02383971f, 0.06959775f, 0.10885398f, -0.10287761f, 0.00391954f, 0.01210693f, 0.04713086f, 
    0.16288854f, 0.18365753f, 0.20698881f, -0.13232002f, 0.05725687f, -0.04449555f, 0.08880946f, 0.03124722f, 
    0.01410475f, 0.08039459f, 0.02950304f, 0.08515297f, -0.11351078f, 0.00779832f, 0.02531279f, -0.21264173f, 
    0.11408102f, 0.02744185f, 0.20351250f, 0.10605069f, -0.05870554f, -0.01478409f, 0.02996041f, 0.00088478f, 
    -0.21457651f, -0.02728476f, 0.12591428f, 0.14577726f, -0.13346258f, 0.05974919f, 0.01722141f, -0.09159389f, 
    0.02177775f, 0.14609353f, 0.06536581f, 0.08459702f, 0.19176219f, -0.05528285f, 0.12521078f, -0.08632174f, 
    0.00747431f, 0.07476633f, -0.00448010f, -0.05252425f, 0.06213480f, -0.02366746f, 0.07423899f, 0.13657284f, 
    -0.17701545f, -0.10684041f, 0.07113231f, 0.10742339f, 0.03988649f, 0.01857839f, 0.07206575f, 0.17309128f, 
    0.09161343f, -0.10802326f, 0.02299386f, 0.00566668f, -0.21345928f, -0.07851922f, 0.31978518f, 0.03797216f, 
    -0.00005167f, -0.04352511f, 0.05207940f, 0.01607302f, 0.00186586f, 0.00772333f, 0.07204719f, 0.05892214f, 
    0.45871934f, 0.10117212f, 0.05830867f, 0.07006992f, -0.02604361f, 0.08312709f, 0.02677183f, 0.14008857f, 
    -0.02542284f, 0.04455557f, 0.01507433f, 0.05082402f, 0.10726051f, 0.07188711f, 0.07864863f, 0.16134399f, 
    0.00904776f, -0.03961898f, 0.12670663f, 0.07944185f, 0.06960934f, 0.11003420f, 0.01156236f, -0.08343066f, 
    0.23382926f, -0.25796989f, -0.13592769f, -0.11049099f, 0.09273221f, -0.03744722f, 0.02235590f, -0.08983395f, 
    -0.12227350f, -0.00561436f, 0.02102206f, 0.17446405f, 0.26979813f, 0.11226157f, -0.03370496f, 0.27449018f, 
    -0.12363183f, -0.00637736f, -0.05409389f, 0.03277189f, 0.02933891f, 0.00355744f, -0.02318070f, 0.03177681f, 
    -0.12908950f, -0.06328046f, -0.00250452f, 0.03062540f, 0.10174406f, -0.01227177f, -0.05796171f, 0.07671760f, 
    -0.07908303f, -0.10267716f, -0.01106504f, 0.07315984f, -0.28339171f, 0.36221993f, 0.02127755f, -0.15592338f, 
    -0.00686868f, 0.11691971f, -0.03119719f, -0.13037284f, -0.01807017f, -0.06669920f, -0.02595924f, -0.02305699f, 
    -0.19913304f, -0.24769112f, 0.06020780f, -0.10653862f, -0.08304626f, -0.04110065f, 0.04085025f, -0.11803337f, 
    0.09635127f, -0.00073123f, 0.06017020f, -0.06688313f, -0.04364660f, 0.21018435f, -0.06966876f, 0.00416435f, 
    -0.03877250f, -0.05699358f, 0.04761514f, 0.11269159f, 0.00426544f, 0.01584989f, -0.05556928f, 0.01775924f, 
    -0.37694824f, -0.06845673f, 0.09386970f, -0.29247594f, -0.00290490f, 0.04850955f, -0.02449366f, -0.06817426f, 
    0.00253615f, -0.03601132f, 0.12545006f, -0.01840437f, -0.06440037f, 0.10622667f, -0.03014140f, 0.01021735f, 
    -0.03035172f, -0.05780703f, -0.07288953f, -0.07283414f, 0.07868569f, 0.07641169f, 0.08405686f, -0.16396406f, 
    0.24087062f, 0.03794293f, 0.10033657f, 0.07169175f, -0.05056757f, 0.03281383f, -0.04365694f, 0.07745805f, 
    -0.02416393f, 0.03771324f, 0.05979411f, 0.02854611f, 0.13206168f, -0.15987079f, 0.07877757f, -0.03560432f, 
    0.03375566f, 0.17118254f, 0.06046268f, 0.00404771f, -0.06266404f, 0.11047690f, -0.12598260f, 0.01884477f, 
    0.02240643f, -0.00555972f, 0.03333164f, -0.06592426f, 0.02028012f, 0.02892844f, -0.00234382f, -0.02365773f, 
    -0.05090376f, 0.01110381f, -0.05664837f, -0.04051080f, -0.00760896f, 0.04710461f, -0.04190401f, -0.01248958f, 
    0.05286241f, -0.04692081f, -0.03734106f, -0.04594329f, 0.02363787f, -0.05777117f, -0.05116897f, -0.00878057f, 
    -0.01417172f, -0.07336199f, 0.00047516f, -0.05975531f, 0.00418149f, 0.04372244f, 0.01462163f, 0.03260697f, 
    0.00385430f, 0.05337835f, -0.01967663f, -0.04409659f, -0.03667371f, -0.06938234f, -0.02382535f, -0.07272550f, 
    -0.07357569f, -0.04810692f, 0.00092322f, 0.01190685f, -0.01848278f, -0.06930490f, -0.01988394f, 0.02298988f, 
    0.03547710f, 0.04652060f, -0.02091319f, -0.00375060f, 0.00068174f, -0.01973678f, 0.01608975f, 0.03677372f, 
    -0.04423892f, 0.00893176f, 0.00992370f, 0.05594693f, 0.06078403f, -0.02804266f, -0.05637898f, 0.04716898f, 
    0.00099209f, -0.03361222f, -0.05793402f, -0.00665468f, -0.02570435f, -0.06198162f, 0.00760678f, -0.00231307f, 
    0.02500178f, -0.07721962f, 0.02043453f, -0.01824892f, -0.01338702f, -0.03385290f, -0.02556891f, -0.06727716f, 
    0.01746964f, -0.01242912f, -0.07131231f, 0.04495784f, 0.01599062f, -0.00625938f, -0.03682531f, 0.00172605f, 
    0.05130928f, 0.04531104f, -0.00600292f, 0.00097818f, -0.01498037f, -0.06901303f, -0.01777526f, -0.05784244f, 
    -0.03658808f, -0.06125864f, 0.02518450f, -0.04629940f, 0.03598962f, 0.06543696f, 0.06421304f, -0.00923059f, 
    0.04161892f, -0.02848160f, -0.03589910f, -0.00502222f, 0.00356234f, 0.04190505f, -0.04757329f, -0.03590011f, 
    -0.05518175f, 0.06251169f, 0.04377247f, -0.03198075f, -0.01106256f, 0.05152730f, -0.03035670f, -0.05690463f, 
    0.03824216f, -0.02782631f, 0.02831305f, -0.00391730f, 0.03097092f, -0.01493456f, 0.02880270f, 0.00550199f, 
    -0.00379830f, -0.01382474f, -0.07071626f, -0.01889769f, -0.03324373f, 0.00404682f, -0.06701992f, -0.00800005f, 
    -0.00152346f, -0.04114114f, 0.02531494f, -0.01449689f, 0.04454692f, -0.05725085f, -0.05894087f, -0.05706513f, 
    0.03706155f, -0.00517228f, -0.00492638f, 0.06153141f, 0.01408517f, -0.04888491f, -0.05329251f, 0.00583021f, 
    -0.00397674f, 0.06119195f, -0.04197500f, 0.01552824f, 0.00852195f, 0.05874098f, -0.01009126f, 0.03856219f, 
    -0.02429109f, -0.02795550f, -0.02300121f, 0.03657844f, -0.03811576f, -0.05582280f, -0.03624271f, -0.05313893f, 
    -0.03738024f, 0.02607416f, -0.00402003f, -0.04203525f, 0.02661268f, -0.05364802f, -0.01450081f, -0.04737053f, 
    -0.05445597f, 0.05193496f, -0.04267080f, -0.05888789f, -0.04554951f, 0.03595599f, 0.04814560f, -0.04323082f, 
    0.01248151f, -0.04501510f, 0.02924197f, -0.06316421f, -0.00252240f, -0.03561380f, -0.04617934f, -0.00980100f, 
    0.00398827f, -0.23199746f, -0.22761019f, -0.27131501f, 0.08679876f, 0.21722408f, 0.04439036f, -0.07772388f, 
    0.08881234f, -0.02111323f, -0.01390283f, -0.06467061f, 0.05637256f, 0.11470478f, -0.10300460f, 0.12915035f, 
    0.05206555f, 0.00751291f, -0.05379947f, -0.13798790f, -0.03479985f, 0.07271268f, 0.08181912f, -0.12230127f, 
    0.11576526f, -0.02604469f, 0.06459132f, -0.09130846f, 0.02589189f, 0.05295593f, -0.00557553f, 0.07398105f, 
    0.02886888f, 0.07055485f, -0.00249420f, 0.12481327f, 0.22219747f, 0.09373353f, 0.19822177f, 0.13154097f, 
    0.02481090f, -0.10256362f, 0.00660124f, 0.18009517f, 0.02531406f, -0.14677037f, -0.00569043f, -0.07717055f, 
    -0.03214031f, 0.10742678f, -0.08142256f, -0.06619459f, 0.01770180f, -0.08657672f, -0.05549802f, 0.03252874f, 
    -0.01470291f, 0.01656985f, 0.05553805f, 0.00311465f, 0.19627181f, -0.03903708f, 0.13020059f, 0.37528002f, 
    0.06362364f, -0.01650203f, -0.11546376f, -0.09600763f, -0.07278056f, -0.07767704f, -0.00892662f, 0.00440439f, 
    0.11277772f, -0.01229565f, 0.09118311f, -0.01054387f, 0.06436771f, -0.20828222f, -0.09594086f, 0.00215771f, 
    -0.01433110f, -0.11155972f, 0.03002569f, -0.08242582f, -0.23437260f, -0.31365889f, -0.10908969f, 0.32519838f, 
    0.12030397f, 0.08802679f, -0.05421345f, -0.05084736f, 0.16308109f, 0.04535671f, 0.09271479f, 0.04687832f, 
    0.13877869f, -0.06045700f, 0.04297848f, 0.14716077f, -0.12284393f, -0.15053375f, 0.08428865f, -0.03345971f, 
    -0.01080585f, -0.09451263f, -0.06578100f, 0.01558768f, -0.03128723f, -0.13646019f, -0.27290073f, -0.24039093f, 
    0.10281252f, -0.06030077f, 0.13879654f, -0.20984514f, 0.05458589f, -0.00713865f, 0.17791843f, 0.00364810f, 
    -0.26072073f, -0.03222878f, -0.17805453f, -0.29900709f, 0.11690073f, -0.00737326f, 0.16299735f, -0.03683797f, 
    -0.00945455f, -0.02053918f, 0.11981222f, -0.02777928f, -0.17641751f, 0.18705820f, 0.18733756f, 0.04436090f, 
    0.19245228f, 0.08848737f, -0.04495184f, -0.04713601f, 0.02913732f, -0.12793307f, -0.02099199f, -0.01299262f, 
    0.02147032f, 0.08522695f, -0.25669706f, -0.23951423f, -0.01887621f, -0.01686365f, -0.03241334f, 0.04708778f, 
    -0.08027769f, 0.18294157f, -0.02377417f, 0.05067479f, 0.30299810f, 0.14511120f, -0.05598196f, 0.08813746f, 
    -0.11099281f, -0.01767522f, 0.06167349f, 0.07434417f, -0.03484409f, -0.00784802f, -0.05009650f, -0.13840534f, 
    0.47773522f, -0.06814593f, 0.15970066f, -0.11173972f, 0.26054969f, -0.08705921f, -0.04005577f, -0.13868353f, 
    -0.00735334f, -0.04479651f, 0.09598200f, -0.03069025f, 0.10301957f, 0.03383706f, -0.06416674f, 0.21629040f, 
    0.20784453f, 0.02116000f, -0.10307871f, 0.04712764f, 0.11784048f, -0.03976187f, -0.02931749f, -0.00900289f, 
    -0.05656192f, -0.06901228f, 0.03329821f, 0.00646848f, 0.01580335f, 0.05282825f, 0.01234484f, 0.02011612f, 
    0.00489458f, 0.04498953f, -0.02726334f, 0.05927750f, 0.00323717f, 0.02235184f, 0.04069825f, -0.00556678f, 
    0.03976786f, 0.02708262f, 0.04838375f, 0.03518041f, 0.00943829f, 0.00939969f, 0.00419649f, 0.05973797f, 
    -0.04528531f, 0.01081715f, 0.04909394f, -0.02607182f, -0.07472569f, 0.04734735f, 0.05753867f, -0.05447987f, 
    0.05817203f, -0.03112622f, 0.05586935f, 0.03906241f, -0.01190284f, -0.05487352f, 0.00075454f, -0.02322275f, 
    -0.00381325f, -0.07076314f, -0.02678982f, -0.05565707f, -0.04605675f, 0.00734830f, -0.07740305f, -0.06630983f, 
    -0.05067168f, -0.06808180f, -0.04227430f, -0.04817143f, 0.04138140f, -0.02397741f, 0.00493082f, -0.05254103f, 
    -0.01215169f, 0.04232811f, -0.01948826f, -0.00938079f, -0.05148823f, 0.04432800f, 0.04378929f, 0.03014997f, 
    0.00619997f, -0.03718298f, -0.05220905f, 0.03964792f, 0.00184316f, 0.00014693f, 0.04856881f, -0.04875499f, 
    -0.01561527f, 0.03403741f, 0.02828310f, -0.01253558f, 0.01479037f, 0.00707181f, 0.01134566f, -0.07725752f, 
    0.02736188f, -0.06577237f, -0.05120470f, -0.07059476f, 0.01716005f, -0.06160493f, -0.07109721f, 0.03823724f, 
    0.02476078f, 0.00182106f, 0.05886370f, 0.03746838f, 0.02868967f, 0.02075328f, 0.03121368f, -0.08101668f, 
    0.00347698f, -0.07753133f, -0.07589754f, 0.00575054f, -0.06593330f, -0.00011162f, 0.01072292f, -0.01428530f, 
    -0.03379044f, 0.03129492f, -0.04528715f, -0.03413284f, -0.07620555f, 0.05380079f, -0.00210272f, -0.02136594f, 
    -0.06539040f, -0.01181397f, -0.03529759f, 0.05872692f, -0.00324178f, -0.02831833f, -0.06586047f, -0.01940976f, 
    -0.07937027f, -0.07914667f, -0.00340218f, 0.06092262f, -0.06324816f, -0.01488784f, -0.07327524f, -0.03901726f, 
    0.01836956f, 0.01605060f, -0.05088693f, -0.03660081f, -0.06732107f, 0.06216417f, 0.00469118f, 0.05111464f, 
    -0.01641872f, -0.06155258f, -0.04999430f, -0.01579012f, 0.00447600f, 0.03319016f, 0.05146767f, 0.03705680f, 
    -0.04605291f, 0.00635206f, -0.05466885f, 0.06095247f, 0.04357240f, 0.01449861f, -0.04431884f, 0.02329333f, 
    -0.07396931f, -0.04384355f, -0.00189320f, -0.07807205f, -0.08063363f, -0.01123724f, 0.01568194f, 0.00051635f, 
    0.03074130f, -0.03892314f, 0.05629101f, -0.04129318f, -0.02552274f, -0.06459281f, -0.02605077f, -0.04008081f, 
    -0.03261207f, -0.03056283f, -0.05823819f, -0.04195753f, -0.00831206f, 0.05228978f, 0.03390466f, 0.03347017f, 
    -0.01547045f, -0.05844989f, 0.01850142f, 0.00314485f, -0.07364904f, 0.00997366f, -0.07414223f, -0.06505474f, 
    0.05768599f, -0.03761179f, 0.03401095f, -0.02468305f, 0.03784679f, -0.05588294f, -0.05682342f, -0.07893072f, 
    -0.05647720f, -0.02106365f, -0.03506505f, -0.06392134f, -0.04694253f, -0.03348975f, 0.01691813f, 0.06296544f, 
    -0.03861733f, -0.06206470f, -0.05432009f, -0.06760632f, -0.06765240f, 0.03588305f, 0.01034976f, 0.04444802f, 
    0.02178998f, -0.04249416f, -0.04207659f, -0.01191175f, -0.01357427f, -0.07099541f, -0.06055385f, 0.05957763f, 
    -0.03360800f, -0.04106728f, 0.02049154f, -0.07360182f, -0.02628399f, -0.06996389f, -0.06502784f, 0.04562084f, 
    0.03124131f, -0.02219178f, -0.03594875f, 0.01587939f, 0.01012066f, 0.05751062f, -0.04050276f, -0.00210633f, 
    -0.07441168f, -0.03408592f, 0.00378439f, -0.04001772f, 0.05801980f, 0.00166790f, -0.00630073f, -0.02796351f, 
    -0.03534549f, -0.01335357f, -0.05564242f, -0.07420639f, 0.05248386f, 0.04292032f, -0.01631060f, 0.04992252f, 
    -0.06387515f, -0.03504650f, 0.04001804f, 0.02353745f, -0.02302395f, 0.03655204f, 0.02830071f, -0.03449205f, 
    -0.00608322f, 0.05354290f, 0.04870375f, 0.06339630f, -0.03713750f, 0.05590074f, -0.07023852f, -0.07214815f, 
    0.03901430f, 0.00342347f, -0.02581679f, 0.00255338f, 0.00401980f, 0.00657810f, -0.03466972f, 0.05080273f, 
    -0.02626954f, 0.02275995f, 0.03405787f, -0.05916069f, -0.02974244f, 0.04100243f, -0.00772193f, -0.01748290f, 
    -0.02856443f, -0.07608493f, -0.02983251f, -0.00023205f, -0.00312046f, -0.06539592f, -0.06207073f, -0.05260476f, 
    -0.01226363f, -0.06359840f, 0.03463487f, 0.01852183f, -0.05979677f, -0.05091487f, 0.01310424f, 0.00444189f, 
    -0.00766109f, -0.03258701f, -0.02820398f, 0.01589109f, -0.00328392f, 0.03080111f, -0.02574369f, 0.06172739f, 
    0.01592189f, -0.07437699f, 0.02170241f, 0.02895738f, -0.05196539f, 0.04264694f, 0.06251290f, -0.05019226f, 
    0.05921712f, -0.00288862f, 0.06529509f, -0.05557191f, 0.04312127f, -0.03257129f, 0.05262162f, 0.00906781f, 
    -0.04301418f, -0.05897087f, -0.03959435f, 0.01928637f, 0.04592296f, 0.05541665f, -0.07257676f, -0.01223203f, 
    -0.00640609f, -0.00441979f, -0.07133678f, -0.01776126f, 0.05373167f, 0.02656868f, 0.04709681f, 0.02626066f, 
    -0.05751573f, -0.07721931f, -0.01250931f, 0.00081199f, -0.01728735f, 0.06240136f, -0.03932217f, -0.04770225f, 
    -0.00750655f, -0.05218114f, 0.05975686f, 0.04690846f, 0.05012853f, -0.00232468f, -0.06520206f, -0.05676741f, 
    0.00186786f, 0.00782571f, 0.06585103f, -0.04692680f, 0.00832332f, -0.00881107f, -0.07246114f, 0.02683943f, 
    -0.07545070f, 0.04977668f, -0.07233153f, 0.05444388f, -0.03227048f, -0.07311880f, 0.05903331f, -0.06643161f, 
    -0.06167340f, 0.00123193f, 0.05995302f, 0.02101733f, -0.00100119f, 0.04177421f, -0.03005524f, -0.00327095f, 
    -0.04117302f, -0.05288209f, -0.01494830f, 0.06328459f, 0.02318168f, 0.00494530f, 0.01864293f, -0.05096629f, 
    -0.03457869f, 0.04778683f, 0.00625270f, -0.02063379f, 0.02114739f, 0.02404131f, -0.07510336f, -0.02241399f, 
    0.03215495f, -0.03018149f, -0.06425583f, -0.05032252f, 0.06140451f, -0.07059714f, 0.05616783f, -0.02792861f, 
    -0.00518021f, 0.01157474f, 0.02987139f, 0.02165816f, -0.00271999f, 0.04776103f, -0.06323242f, -0.04921079f, 
    -0.05100787f, 0.03117519f, -0.00794935f, -0.04713877f, -0.05853486f, 0.04082523f, -0.02900978f, -0.00914157f, 
    0.00916049f, -0.07144251f, -0.00845212f, 0.02542521f, -0.04258910f, 0.03744781f, 0.01151711f, 0.06327451f, 
    0.01931220f, -0.04805741f, -0.02234681f, -0.03691089f, -0.06186116f, -0.01738150f, 0.00571307f, -0.00264230f, 
    0.03632134f, -0.01786064f, -0.01484247f, -0.02215023f, -0.06568934f, -0.01783179f, -0.07093921f, -0.04328328f, 
    -0.01401153f, 0.03865882f, -0.04195617f, -0.04999782f, 0.01249303f, -0.07493171f, 0.00464740f, -0.08009268f, 
    -0.02005152f, -0.05362240f, -0.03312448f, -0.01035033f, -0.01735120f, -0.08045679f, -0.05217553f, 0.06581023f, 
    -0.00363364f, -0.01121782f, 0.01673489f, -0.06076724f, 0.02934661f, -0.03666507f, 0.05625376f, -0.07270849f, 
    -0.04935949f, -0.00952025f, 0.01343865f, -0.05427616f, -0.02377594f, -0.01099243f, 0.02165474f, -0.00042285f, 
    -0.01695902f, 0.03564973f, -0.04391780f, 0.05882549f, -0.07210062f, -0.03838236f, -0.04696894f, 0.00437639f, 
    0.03868170f, -0.05280669f, -0.02411314f, -0.07206547f, -0.06661108f, -0.01980043f, -0.01500888f, -0.03607306f, 
    0.00485690f, 0.00015635f, -0.01105946f, 0.03749697f, 0.03689815f, 0.03142334f, 0.02874940f, -0.01175286f, 
    0.02222308f, 0.05473916f, 0.00571414f, 0.02690399f, -0.03989715f, -0.07317095f, -0.02054484f, 0.00279488f, 
    -0.02539339f, -0.05193795f, 0.03306251f, -0.03580401f, -0.01995134f, 0.05537084f, 0.05968783f, 0.03199567f, 
    0.04964400f, 0.04856966f, 0.01048928f, -0.07153645f, 0.05794921f, -0.05484977f, 0.04403828f, 0.05300790f, 
    0.04334561f, 0.00290242f, 0.01085369f, 0.04048727f, 0.01778676f, 0.00250263f, -0.03405700f, 0.02426192f, 
    -0.01922380f, -0.01876379f, -0.01074041f, 0.00390796f, 0.00214202f, -0.01578732f, -0.00485502f, 0.01497547f, 
    -0.06546989f, -0.01342828f, 0.02779908f, 0.04795354f, 0.05687958f, 0.02249097f, -0.04719410f, -0.02414813f, 
    0.03703572f, 0.04677952f, -0.02986602f, 0.00654765f, -0.02885217f, -0.02204333f, 0.02759706f, 0.00001173f, 
    -0.02265778f, -0.06828904f, 0.06341833f, 0.00587227f, -0.02086316f, 0.02071325f, -0.00093434f, -0.05856550f, 
    -0.07571804f, -0.04167657f, -0.06746835f, 0.00819974f, -0.02907214f, -0.04717029f, 0.03268772f, 0.03960187f, 
    0.04851060f, -0.05797390f, -0.07743858f, -0.04057955f, -0.07744442f, 0.04125774f, -0.06257670f, -0.01567116f, 
    -0.25363940f, 0.08813579f, 0.19139077f, 0.09577967f, 0.07517964f, -0.14145119f, -0.05197770f, 0.10254119f, 
    0.06700076f, 0.13295215f, -0.07694884f, -0.05440808f, 0.09317742f, 0.13298988f, -0.00767674f, 0.12708148f, 
    -0.02544135f, -0.19148415f, -0.00093351f, 0.00981697f, 0.16120227f, 0.00067909f, -0.13221894f, 0.00367527f, 
    -0.08036637f, -0.05994896f, 0.06199697f, -0.08223233f, -0.04942134f, 0.00419653f, 0.00507097f, 0.00716564f, 
    0.02626373f, 0.06229908f, -0.09210437f, 0.07464240f, 0.07472466f, -0.12475660f, -0.01923632f, 0.08816556f, 
    -0.23384860f, -0.05884745f, 0.06778638f, 0.04469976f, 0.01358758f, -0.17748131f, -0.00566513f, 0.10047054f, 
    0.09206681f, 0.15940483f, 0.00799526f, -0.07582791f, -0.13084519f, 0.03092016f, -0.09112557f, -0.02451827f, 
    0.06780247f, 0.03360286f, -0.02845674f, -0.18405102f, -0.32838389f, -0.30051655f, -0.09671478f, -0.06160757f, 
    0.14958487f, 0.01861327f, 0.11832296f, 0.00167624f, 0.16063949f, 0.20661522f, 0.01331169f, -0.00772854f, 
    -0.07459584f, 0.05515499f, -0.06208405f, 0.16799362f, 0.01505552f, 0.08036295f, 0.07695748f, -0.01987690f, 
    0.08112090f, -0.00158053f, 0.03492739f, 0.07474364f, 0.09725654f, 0.21696307f, 0.02278883f, 0.07851575f, 
    0.16978784f, -0.03830837f, -0.11782540f, 0.05628343f, -0.06392036f, 0.10168086f, 0.21230470f, -0.01429525f, 
    -0.02648822f, 0.13796058f, 0.01807335f, -0.07842980f, -0.02176932f, 0.00922347f, -0.04830506f, -0.08341823f, 
    0.07426783f, 0.03940197f, 0.03297567f, -0.06842221f, -0.03657974f, 0.13033241f, 0.08276074f, -0.01157801f, 
    0.10696428f, 0.07652203f, -0.01528891f, 0.03339426f, -0.05728440f, 0.10525290f, -0.03867654f, -0.00690827f, 
    0.00166795f, 0.24019544f, 0.07920588f, 0.00500198f, -0.19075795f, -0.06856956f, 0.03869770f, 0.09400873f, 
    0.01214124f, -0.00941595f, -0.07169433f, 0.13784896f, -0.43090683f, -0.14809898f, 0.17751069f, 0.07229526f, 
    -0.07335439f, 0.14031558f, -0.03720951f, -0.05322555f, 0.08689072f, 0.13628817f, 0.17724451f, 0.08804565f, 
    0.21957675f, 0.11935254f, 0.06391960f, -0.06500401f, 0.07367320f, 0.01979899f, -0.06608631f, 0.01934203f, 
    0.08137237f, -0.05769372f, 0.05445585f, -0.01200105f, -0.44853047f, -0.02046886f, -0.17115417f, 0.04092821f, 
    0.02911021f, 0.08601084f, -0.07501809f, 0.02733016f, 0.05879731f, 0.18822168f, 0.09004789f, 0.12121531f, 
    -0.27096370f, -0.23461612f, -0.17655292f, 0.02022100f, 0.06367962f, 0.21403916f, 0.15516198f, 0.00191688f, 
    0.14699514f, -0.02246909f, 0.11498772f, 0.12768534f, -0.19117083f, -0.03413418f, -0.12279028f, -0.01326479f, 
    -0.08323885f, -0.12633520f, -0.15315922f, 0.00134436f, 0.00890793f, -0.01991136f, -0.10345501f, -0.08895602f, 
    0.11898738f, 0.11596865f, 0.18364757f, -0.17351344f, 0.01727542f, 0.06058937f, -0.00795343f, -0.01681948f, 
    0.07243982f, 0.06291123f, 0.00874337f, -0.04943512f, 0.03450591f, -0.25672978f, -0.24721998f, 0.19264412f, 
    -0.01487003f, -0.06991366f, -0.08995915f, 0.14577521f, -0.16746958f, 0.04313654f, 0.02018673f, -0.01760261f, 
    -0.07609551f, 0.17074041f, 0.06962087f, -0.03566387f, 0.06928133f, -0.01240901f, 0.00619823f, -0.07776357f, 
    -0.03638072f, 0.04794054f, -0.05043834f, -0.04610234f, 0.12923226f, 0.11315709f, -0.13501516f, 0.10132065f, 
    0.02213057f, -0.01145212f, 0.10977099f, -0.00453994f, -0.00155701f, -0.08956599f, 0.02706268f, 0.03857299f, 
    -0.09541870f, -0.09153125f, -0.11347499f, -0.03656332f, -0.01838903f, -0.03632364f, 0.04159546f, -0.02625811f, 
    0.09134647f, 0.06991664f, -0.02423321f, 0.13171583f, -0.26339114f, 0.02644438f, 0.01968118f, -0.19681500f, 
    0.20676567f, 0.08816641f, -0.09114017f, -0.08015663f, -0.04378322f, 0.06706189f, 0.08195227f, 0.04610756f, 
    -0.11117602f, 0.00724455f, -0.05393020f, 0.39531934f, 0.04759024f, 0.07912642f, 0.03519683f, 0.03786576f, 
    0.14939515f, -0.08807136f, -0.06262100f, -0.08449277f, -0.12926395f, 0.16239458f, -0.04385348f, -0.49681556f, 
    0.03150827f, -0.09290309f, -0.05117507f, 0.01116504f, 0.03285434f, 0.07217100f, -0.01187513f, 0.13325384f, 
    -0.14442870f, -0.10771833f, -0.00703453f, 0.26452720f, -0.12391985f, -0.01719535f, 0.10787096f, -0.04496057f, 
    0.01140501f, 0.12068681f, 0.03256731f, 0.07235134f, 0.11716241f, -0.26629636f, 0.01241899f, 0.27857226f, 
    0.15279219f, -0.11932023f, -0.05463284f, -0.09889437f, -0.07225652f, -0.03474598f, 0.11721877f, 0.04983571f, 
    0.29038280f, -0.05275426f, 0.03537948f, -0.06007615f, 0.06881455f, 0.14067219f, 0.08508409f, -0.05040744f, 
    0.03384422f, 0.10398205f, 0.02404864f, 0.11274458f, 0.07783623f, -0.08185677f, -0.13913140f, -0.14892121f, 
    0.27023822f, 0.00107823f, 0.07625709f, -0.02101748f, -0.07312040f, 0.11217593f, -0.06327567f, -0.05515659f, 
    0.20099437f, 0.13793001f, -0.21402939f, 0.16898568f, 0.06342465f, 0.05933408f, -0.00650458f, 0.09250291f, 
    0.12862846f, 0.13710155f, 0.01078882f, 0.09454443f, 0.19270068f, -0.14677235f, -0.01369521f, -0.07592992f, 
    0.05663260f, 0.01826888f, 0.02031538f, 0.16312066f, 0.01988883f, 0.06696641f, 0.05633291f, -0.04645245f, 
    -0.44032413f, 0.04529506f, 0.24590851f, -0.09784701f, 0.16778778f, 0.00109460f, 0.10453022f, -0.11930726f, 
    0.14931150f, 0.05288111f, 0.02318043f, 0.01514452f, -0.09092735f, -0.11901693f, 0.01508489f, -0.10775457f, 
    0.03685677f, 0.00188610f, -0.08171050f, 0.17453460f, 0.13243257f, -0.13488998f, 0.06437009f, 0.11526712f, 
    0.02850872f, 0.04625867f, -0.05495359f, -0.06859190f, 0.00240666f, 0.04694346f, 0.03377892f, 0.03239987f, 
    0.02121175f, 0.01237135f, 0.05798895f, 0.00792569f, -0.05250246f, 0.03085013f, 0.01127319f, 0.06453384f, 
    0.01674978f, -0.01773935f, 0.01379167f, 0.00320014f, -0.01870888f, -0.00680514f, -0.06554767f, -0.05970969f, 
    0.03793884f, -0.02632797f, 0.03130628f, -0.05929986f, -0.04122060f, 0.02746332f, -0.03504401f, 0.05502192f, 
    -0.04611512f, 0.01619839f, -0.06798621f, 0.01315821f, 0.04094713f, -0.06470514f, 0.04492225f, 0.04897036f, 
    -0.06986551f, -0.02930732f, -0.03745919f, 0.04752077f, -0.04167049f, 0.04329661f, -0.07298753f, -0.03161466f, 
    -0.06476736f, 0.04702428f, 0.05647581f, 0.05715868f, -0.05443733f, -0.02496697f, 0.02079822f, -0.07146148f, 
    0.01614759f, 0.05889361f, 0.04777087f, -0.05254501f, -0.07350652f, -0.06194651f, -0.00879990f, -0.03998370f, 
    -0.02113583f, 0.04582954f, -0.04597097f, 0.03511128f, -0.02750881f, 0.00294231f, 0.01255954f, -0.02211794f, 
    -0.06271669f, 0.05884436f, 0.02064509f, -0.05722139f, -0.00588177f, -0.08042636f, 0.00709041f, 0.03761958f, 
    0.02335190f, -0.04551049f, 0.05876739f, -0.06592246f, 0.04941532f, -0.05509610f, -0.05672254f, 0.05638113f, 
    -0.02329109f, 0.00954329f, 0.03791965f, -0.02028904f, -0.00896200f, -0.07577830f, 0.01448936f, 0.01031764f, 
    0.04620963f, 0.03535324f, -0.05197915f, 0.04432769f, -0.07475119f, -0.03748401f, 0.04747640f, 0.00520005f, 
    -0.04040046f, -0.00427590f, 0.01919015f, 0.04452023f, 0.01283150f, -0.06254619f, -0.04819997f, -0.06113271f, 
    -0.06246766f, -0.00561151f, 0.02108035f, -0.02625888f, 0.03393886f, 0.03608601f, 0.01693655f, 0.05854705f, 
    -0.06258018f, 0.02951561f, 0.05622916f, -0.02592790f, -0.07630416f, 0.04179743f, -0.02687715f, -0.05767813f, 
    -0.02736548f, -0.05086199f, 0.04118823f, 0.03202144f, 0.02812089f, 0.00619485f, -0.03947779f, 0.03531763f, 
    -0.07475751f, -0.07183844f, -0.04143056f, 0.02412646f, -0.04901841f, -0.02425437f, -0.04147587f, 0.04675540f, 
    0.01222014f, -0.05860009f, 0.05632332f, -0.06851212f, -0.02044954f, -0.06263989f, -0.06177266f, -0.05281684f, 
    -0.03441771f, 0.00182990f, -0.02656664f, -0.05499537f, 0.01874219f, 0.02723897f, 0.00618520f, -0.08074561f, 
    -0.04864259f, -0.00006182f, -0.03848535f, -0.00838958f, -0.05554884f, 0.02407516f, -0.05991923f, -0.05742238f, 
    -0.07069021f, -0.05103325f, 0.05693701f, -0.01414888f, 0.04176774f, -0.06667884f, 0.04069023f, -0.02120341f, 
    -0.02159922f, -0.00618493f, 0.04253172f, -0.05700830f, 0.03422821f, -0.07667259f, -0.03189800f, -0.06623264f, 
    -0.04612891f, 0.00647207f, -0.02572249f, 0.01519944f, 0.01969675f, -0.07861245f, -0.06230173f, -0.06376381f, 
    0.06392322f, -0.07463890f, 0.02846725f, 0.02828010f, -0.00443626f, -0.00482083f, 0.00712396f, -0.03888738f, 
    0.01777058f, -0.01751193f, 0.05570871f, 0.02301485f, -0.01861847f, -0.01867714f, -0.03690855f, 0.00954528f, 
    -0.01448634f, 0.04056538f, 0.00539934f, -0.04227937f, -0.02215205f, 0.02796185f, 0.00348861f, -0.04112186f, 
    -0.03415038f, 0.05586253f, -0.02654776f, 0.05949817f, -0.04958896f, -0.04874641f, 0.04979690f, -0.04929833f, 
    -0.05395645f, -0.07164007f, -0.02291616f, 0.06228966f, -0.02755756f, 0.01414185f, -0.02401167f, -0.02305628f, 
    -0.00677038f, 0.05534522f, 0.01169031f, -0.06142950f, -0.01364136f, 0.01239385f, 0.00521060f, -0.07286502f, 
    -0.04596502f, 0.02759985f, 0.02619648f, 0.03856228f, -0.07917943f, -0.01190152f, 0.05660508f, -0.01734704f, 
    -0.01644320f, -0.03934880f, -0.05391970f, 0.03209715f, 0.00429722f, 0.02829348f, 0.01366876f, -0.05263632f, 
    -0.03283190f, 0.00804114f, -0.03715693f, 0.04947598f, -0.04180293f, 0.03456594f, -0.06252032f, -0.06072763f, 
    -0.03063407f, -0.06462750f, 0.03894363f, -0.06424998f, -0.06462020f, 0.04928309f, -0.07023545f, 0.02379044f, 
    -0.06169993f, 0.05237298f, -0.01345880f, 0.01889411f, -0.03167401f, -0.06152376f, -0.06110808f, 0.03260776f, 
    0.01830486f, 0.01277886f, 0.03430231f, 0.05417567f, 0.01062428f, -0.07563454f, 0.02215907f, -0.04456360f, 
    -0.03800718f, -0.04729984f, 0.01812430f, 0.02905840f, -0.03850364f, -0.00632017f, -0.06961060f, -0.06254394f, 
    -0.00612973f, -0.01482001f, 0.04390601f, -0.01117597f, 0.06421418f, -0.02952443f, 0.00211166f, -0.02190919f, 
    0.02685184f, 0.03098408f, 0.00708698f, -0.03791909f, 0.02441506f, -0.04463567f, 0.00067993f, -0.00310511f, 
    -0.04880058f, -0.00877022f, 0.05286722f, 0.02839732f, -0.07185927f, -0.03364868f, -0.03508332f, 0.02162803f, 
    -0.06722543f, -0.03921608f, -0.06825291f, -0.00337308f, -0.06336085f, -0.03070579f, -0.05268960f, 0.03529381f, 
    -0.07436523f, 0.04288258f, -0.03174978f, -0.02568373f, -0.03666426f, -0.00802931f, 0.03550060f, 0.05109297f, 
    0.00311262f, -0.03613166f, -0.05441706f, -0.00453723f, 0.04861718f, 0.05152418f, 0.04487738f, 0.02134283f, 
    0.01781223f, 0.00491184f, 0.03335836f, 0.04509734f, -0.02957402f, -0.05259189f, -0.07259817f, -0.00604099f, 
    -0.07595383f, 0.05329454f, 0.04754488f, -0.03642464f, -0.00718285f, -0.05908152f, -0.05054526f, 0.02945628f, 
    0.04240371f, -0.02481790f, 0.01941568f, 0.01662207f, -0.04021931f, -0.07560275f, 0.01766130f, -0.03875013f, 
    0.00199002f, 0.00638917f, 0.00819048f, 0.04657073f, -0.02814361f, -0.06255120f, -0.03008784f, 0.01945465f, 
    0.01020615f, 0.00751373f, 0.06508192f, -0.06611927f, -0.06219588f, 0.05666500f, -0.00562607f, -0.00861334f, 
    0.12192387f, 0.06093789f, 0.21360606f, -0.02887445f, -0.04003810f, -0.03175122f, 0.01175589f, 0.00981670f, 
    0.02605143f, 0.02772203f, -0.00373172f, -0.01133172f, 0.15525535f, 0.01813864f, -0.00011226f, 0.02312680f, 
    -0.03800011f, 0.01135692f, -0.02434979f, 0.04428016f, 0.07849915f, -0.03299680f, -0.11207881f, 0.02459171f, 
    -0.04946640f, -0.15319465f, 0.11159188f, -0.11453232f, 0.02179899f, -0.03740111f, 0.00988562f, -0.10704754f, 
    0.02873685f, 0.01210384f, 0.01920695f, 0.04576006f, 0.26083204f, -0.15212204f, 0.03169275f, 0.14573385f, 
    -0.02231294f, -0.16444366f, 0.12442760f, 0.06729427f, -0.10139691f, -0.15109640f, 0.06298488f, -0.16773392f, 
    0.08807477f, 0.06138353f, -0.03327378f, -0.18013081f, -0.09109139f, 0.07289825f, -0.11924955f, 0.00793646f, 
    0.02080126f, -0.01071067f, 0.04604762f, 0.05183623f, 0.10400497f, -0.22853044f, -0.22090508f, -0.06579908f, 
    0.36596188f, 0.19097409f, -0.02388645f, 0.06027291f, 0.06790856f, -0.04845199f, 0.10211836f, 0.00719721f, 
    -0.13754030f, 0.13550736f, 0.22737055f, 0.08073147f, 0.02831030f, 0.01022954f, 0.08599053f, 0.02778374f, 
    0.05872717f, -0.06606729f, 0.04147284f, 0.18205956f, -0.25024745f, -0.02955290f, -0.04658702f, 0.11046895f, 
    0.24002174f, 0.08704041f, -0.01745675f, 0.13509306f, -0.07622626f, -0.05879135f, 0.19774511f, -0.06387924f, 
    -0.07559019f, -0.00531455f, 0.14268342f, 0.03260138f, -0.14140061f, 0.01226948f, -0.04533574f, -0.03730511f, 
    -0.02459782f, 0.05977300f, 0.02854628f, -0.02333242f, 0.12481108f, 0.01592009f, 0.10448988f, -0.07599496f, 
    0.15780978f, 0.11169806f, 0.05698293f, -0.09148595f, 0.02033370f, -0.02759529f, -0.08961868f, -0.02858330f, 
    -0.21322042f, 0.24903159f, 0.19634955f, -0.09564630f, -0.15639631f, -0.08063767f, 0.06899651f, 0.01272719f, 
    0.12088194f, 0.01798257f, 0.07909471f, -0.02677208f, -0.30799985f, 0.07400132f, -0.14184438f, 0.08305096f, 
    0.01848249f, 0.06419300f, 0.02419018f, 0.04734032f, -0.03123717f, -0.02257228f, 0.03803355f, 0.06653064f, 
    0.05734763f, 0.04671440f, -0.07326376f, -0.10234324f, 0.01537975f, -0.10658750f, 0.10912529f, 0.09065625f, 
    0.05050260f, -0.04171460f, 0.00226332f, -0.00596481f, -0.04301521f, -0.03177233f, -0.09378552f, -0.00332242f, 
    0.06048299f, 0.05255525f, -0.05744659f, 0.02841498f, 0.09889891f, 0.10839696f, 0.05433709f, 0.19300002f, 
    0.19097450f, -0.20260410f, 0.08280297f, -0.13473797f, 0.29477197f, 0.09302123f, 0.10470205f, -0.05328860f, 
    -0.02970312f, 0.00098390f, 0.08842122f, 0.10520265f, -0.25840271f, -0.25261721f, -0.21826914f, -0.08891623f, 
    -0.05010875f, -0.11566336f, -0.04546732f, 0.06462505f, 0.08809883f, 0.06082098f, -0.03265048f, 0.05481589f, 
    -0.08436979f, -0.07539693f, -0.23224965f, 0.00150505f, 0.02874082f, -0.00522888f, 0.04210945f, 0.05071819f, 
    0.05016371f, -0.04535370f, -0.04524117f, 0.07315210f, 0.04966911f, -0.10069601f, 0.17255808f, -0.01332374f, 
    0.03401595f, 0.13404261f, -0.03017747f, -0.08695135f, 0.04539090f, 0.07609104f, 0.13601761f, -0.02201862f, 
    0.01599214f, -0.00086807f, -0.07992573f, 0.15216935f, -0.01117597f, 0.08607347f, 0.05726711f, 0.13727055f, 
    -0.05388894f, 0.01429963f, 0.01296256f, 0.03787401f, 0.01837167f, -0.11838790f, 0.15351352f, -0.05936745f, 
    0.11235470f, 0.19977036f, -0.11412062f, 0.01166457f, 0.12453090f, 0.09864911f, 0.03149243f, -0.03116075f, 
    0.16632247f, -0.02365683f, 0.17963164f, 0.12346772f, 0.13915987f, 0.07735649f, -0.06044098f, 0.04481330f, 
    -0.04438574f, -0.01230067f, 0.10883713f, -0.04540547f, 0.48369992f, 0.23410696f, 0.13935709f, 0.31457967f, 
    -0.13547537f, -0.03026428f, 0.18620865f, 0.03746219f, 0.06251638f, 0.02776429f, 0.02561230f, -0.01213079f, 
    0.32523340f, -0.13182341f, 0.00907975f, -0.31036159f, -0.04279916f, -0.12141518f, -0.01804930f, -0.06242666f, 
    -0.17978661f, -0.01088483f, 0.05099763f, -0.03513806f, 0.37429500f, -0.05693690f, -0.18965670f, 0.28872457f, 
    -0.04354619f, 0.04904446f, -0.04174994f, 0.00118462f, -0.03598427f, 0.01317561f, -0.00325125f, 0.09958479f, 
    0.07390282f, 0.08081175f, 0.09127927f, -0.08339608f, 0.09402253f, 0.11009485f, -0.07407088f, 0.06785480f, 
    0.00242548f, 0.04362589f, 0.05646079f, 0.13727477f, -0.09872673f, 0.22022288f, -0.24300613f, -0.29370242f, 
    -0.02881372f, 0.16089742f, 0.04141818f, 0.05988768f, 0.07365189f, 0.01831008f, 0.01116144f, -0.02129780f, 
    -0.14929198f, -0.23890272f, -0.21298659f, -0.08214180f, -0.06849557f, -0.13545907f, 0.00479033f, -0.05999104f, 
    -0.06990764f, -0.00456167f, -0.03473741f, -0.05401796f, 0.15511823f, 0.03861087f, 0.07416908f, 0.10647558f, 
    -0.03692609f, 0.01663411f, -0.06312503f, 0.07785483f, 0.09269153f, -0.04999798f, -0.09710052f, 0.06204999f, 
    -0.24402490f, -0.10255665f, 0.09653872f, -0.00787799f, -0.17019434f, 0.01811119f, 0.00186702f, -0.08963887f, 
    -0.07765936f, 0.00966477f, -0.04806561f, -0.08427314f, 0.43441164f, 0.18963598f, 0.02812921f, 0.01247815f, 
    0.00053094f, 0.02557113f, 0.12493783f, -0.16616304f, 0.03465247f, -0.08994851f, 0.03150580f, -0.08232356f, 
    0.54542994f, -0.02215696f, -0.09354290f, 0.08961855f, -0.13294707f, -0.09837093f, -0.09961510f, 0.07657704f, 
    -0.12174436f, 0.05934328f, 0.01743646f, -0.01207694f, 0.04916809f, 0.04964104f, 0.02307112f, 0.13511819f, 
    0.02803197f, 0.01692699f, 0.05790508f, -0.12787566f, -0.04549086f, 0.15581016f, -0.00080726f, -0.06402936f, 
    -0.04645841f, 0.09013137f, 0.12274388f, 0.16461395f, -0.11167728f, -0.02801664f, -0.06301962f, -0.10647466f, 
    -0.11213668f, -0.04596625f, -0.08821986f, 0.16227636f, 0.24236912f, -0.17246562f, 0.29206023f, -0.08348455f, 
    0.03824096f, 0.11495484f, 0.04398422f, -0.03539662f, -0.00557149f, 0.05629857f, 0.02009334f, 0.00951163f, 
    0.01280470f, 0.02624437f, 0.09536645f, 0.24426600f, 0.02118343f, 0.17174134f, 0.01548200f, 0.06839607f, 
    -0.05985243f, -0.09220309f, 0.07287978f, -0.02854454f, 0.05003411f, 0.10763960f, 0.06582340f, -0.14480075f, 
    -0.01806123f, 0.11504509f, -0.03580824f, -0.04259804f, -0.00549037f, 0.05851416f, 0.03873412f, 0.09179514f, 
    0.46924588f, 0.01059705f, 0.17265598f, 0.20769206f, 0.04334380f, -0.00107495f, 0.07018472f, -0.05258173f, 
    0.09957886f, -0.05664209f, 0.03788787f, 0.00252270f, -0.06913573f, 0.18056495f, 0.01883439f, 0.02313123f, 
    0.01296714f, -0.05512450f, 0.09970734f, 0.01890654f, -0.01588784f, 0.04943465f, 0.10056048f, -0.03122589f, 
    0.15982014f, -0.16684188f, -0.03669926f, -0.21999250f, -0.05245077f, 0.00005687f, 0.13986486f, -0.06190712f, 
    -0.09633090f, 0.07124134f, 0.12216330f, 0.08652571f, 0.52554190f, 0.13298360f, -0.18702601f, -0.18056326f, 
    -0.08557618f, -0.01075119f, -0.07360857f, 0.06714556f, -0.03247172f, -0.01023822f, 0.03313041f, 0.19168098f, 
    -0.05296750f, 0.01686205f, -0.02681286f, -0.01053793f, 0.12799448f, 0.14188084f, -0.11980787f, 0.10063744f, 
    -0.00480133f, 0.03015333f, 0.08214475f, 0.04985319f, -0.24896993f, 0.39654851f, -0.04687929f, -0.07945995f, 
    0.07655284f, 0.07609329f, -0.09295794f, 0.02422051f, -0.10061035f, 0.03217911f, -0.17608158f, -0.10390117f, 
    0.04206688f, -0.19809796f, -0.03711803f, 0.09922052f, -0.07025106f, -0.08380328f, 0.03084399f, -0.02902598f, 
    0.00567875f, 0.04922016f, -0.06834918f, -0.04252812f, 0.07259789f, 0.08349464f, -0.03876249f, 0.01826183f, 
    -0.12196298f, -0.15299115f, -0.05068501f, 0.04818432f, 0.05226592f, 0.13081446f, -0.04851810f, 0.04300891f, 
    -0.35594061f, -0.12410130f, -0.04451004f, 0.13134666f, 0.03005695f, 0.09096394f, 0.00821550f, -0.17041586f, 
    -0.02933271f, 0.04914778f, 0.06515200f, 0.01433896f, 0.49932459f, -0.05052339f, -0.06484744f, 0.01847519f, 
    0.08937426f, 0.08388355f, 0.03826480f, -0.02535640f, -0.01288699f, 0.06073524f, 0.04200781f, -0.09774295f, 
    -0.22676064f, 0.03591286f, 0.18195660f, 0.09486263f, -0.09544166f, -0.10134558f, 0.05309931f, 0.13226502f, 
    -0.09374589f, 0.11449164f, -0.11597320f, -0.03625754f, 0.03301225f, 0.13668190f, 0.22708932f, -0.15466610f, 
    0.05052813f, -0.01535972f, -0.01310159f, -0.15975626f, 0.02827079f, 0.03100458f, -0.01643999f, 0.05102625f, 
    0.19493088f, 0.04882082f, 0.23900311f, 0.05089293f, -0.15612923f, 0.05331352f, 0.17865169f, -0.04675614f, 
    0.00228758f, 0.11569708f, -0.02319171f, -0.02585453f, -0.30375415f, -0.32313612f, -0.18025109f, -0.54330677f, 
    0.14038733f, 0.20625649f, 0.06828503f, -0.04905134f, -0.03683899f, 0.04280432f, -0.04266663f, 0.01944266f, 
    0.11536425f, 0.40513822f, 0.26312196f, 0.17322958f, 0.12169420f, 0.11570291f, -0.01677722f, 0.03600710f, 
    0.03176646f, 0.03010196f, 0.11199801f, 0.00543334f, -0.79861748f, -0.17450845f, 0.03968541f, 0.06145840f, 
    0.10635494f, 0.15207061f, -0.10505154f, 0.05248099f, 0.10582624f, 0.08665700f, -0.03120614f, 0.09243698f, 
    -0.13046414f, -0.26213041f, -0.28694814f, -0.41082832f, 0.03425163f, 0.12398347f, 0.00341710f, 0.16801286f, 
    -0.12961632f, 0.14378497f, -0.17068292f, 0.05240263f, 0.16826254f, -0.07274368f, 0.01530379f, -0.23843178f, 
    -0.09275484f, -0.06618796f, -0.07156680f, -0.11759107f, 0.04918228f, 0.04994076f, -0.14336522f, -0.08428336f, 
    0.16700596f, -0.25408095f, -0.13216220f, 0.06693353f, -0.11249500f, 0.07159346f, -0.01860448f, -0.14904197f, 
    -0.06400748f, 0.16903637f, 0.03245569f, -0.03273846f, 0.11121044f, 0.23735581f, 0.20706554f, -0.18755704f, 
    -0.00127239f, 0.02619586f, -0.00881528f, 0.01287605f, 0.05471462f, 0.01185211f, 0.06070742f, 0.13904507f, 
    -0.11704136f, -0.08570699f, 0.14220597f, 0.20405239f, 0.14533010f, -0.06181499f, 0.10151970f, 0.07472210f, 
    -0.09174225f, -0.09139951f, 0.10283508f, -0.00030648f, 0.03113257f, -0.06452321f, 0.14603680f, 0.27207807f, 
    -0.09705044f, -0.05769286f, -0.01953709f, 0.10647293f, -0.03998649f, 0.09745083f, 0.00174538f, -0.07059402f, 
    0.27336642f, -0.02806682f, 0.35574558f, 0.19503778f, 0.10781357f, 0.13212574f, 0.04798912f, -0.09342255f, 
    -0.02460413f, -0.05934244f, 0.00956355f, -0.06769522f, 0.16004592f, -0.06526657f, -0.49242556f, -0.52694976f, 
    0.09499050f, -0.01379381f, 0.01004194f, -0.06612629f, 0.23042007f, -0.04256947f, -0.10005642f, 0.09532741f, 
    0.00536117f, 0.12373065f, 0.41166711f, 0.12605864f, 0.14958879f, 0.02763420f, -0.10613786f, 0.08430825f, 
    -0.06830400f, -0.01428211f, 0.00069293f, 0.01896310f, -0.34636402f, 0.00969643f, -0.11889839f, -0.28599665f, 
    0.07264645f, 0.01300593f, -0.12342140f, 0.02462612f, 0.20222957f, -0.10032143f, -0.22608793f, 0.07096788f, 
    0.02323839f, -0.16106278f, -0.10188795f, -0.26773641f, -0.03636772f, 0.02855339f, 0.00927545f, -0.04283600f, 
    0.12316059f, 0.10781340f, 0.02674641f, 0.00351313f, -0.02118242f, -0.20429689f, 0.00943770f, -0.48758548f, 
    0.08116002f, 0.08474897f, 0.10077039f, 0.01748477f, -0.11579914f, -0.04458478f, -0.02123327f, 0.03754065f, 
    0.28123629f, 0.20859480f, 0.27434656f, 0.03900028f, 0.06202926f, 0.01379997f, -0.09330133f, -0.08037709f, 
    -0.08429916f, 0.02182498f, -0.01602799f, 0.10010154f, 0.18118307f, -0.15466575f, -0.05669849f, 0.09031207f, 
    0.06803052f, 0.11380558f, -0.12253729f, 0.04569044f, -0.12872708f, 0.03779905f, 0.07894667f, -0.00456517f, 
    0.33610886f, 0.13429028f, 0.13681032f, -0.08988264f, 0.01498382f, 0.03274484f, 0.07143444f, -0.16255495f, 
    -0.04060361f, -0.13155651f, 0.12274167f, -0.00528840f, 0.38433045f, 0.03541991f, -0.05289735f, 0.03533521f, 
    -0.00592844f, 0.09452582f, 0.15076731f, 0.11237270f, -0.16157782f, -0.01305122f, 0.04382726f, -0.13903037f, 
    -0.11656151f, 0.17927516f, -0.04839381f, -0.00515984f, -0.02077283f, 0.05411239f, -0.00068418f, -0.05167537f, 
    0.03643506f, 0.01524976f, 0.00995587f, 0.06050621f, -0.25686768f, -0.13662677f, -0.26968461f, -0.27231207f, 
    0.15843783f, 0.07500032f, 0.03358785f, -0.00430901f, -0.02665113f, -0.03872471f, 0.11635065f, -0.08767734f, 
    -0.15197197f, -0.05478687f, 0.21053974f, 0.05514904f, 0.10380181f, 0.09333587f, 0.07613505f, 0.14424251f, 
    0.11799665f, -0.02824754f, 0.00033768f, -0.01005548f, -0.02625419f, 0.07413730f, -0.14292812f, -0.26713425f, 
    -0.00541816f, -0.10316754f, 0.07254835f, 0.13939644f, -0.05045862f, -0.14010707f, -0.13308875f, 0.05022082f, 
    0.23040482f, -0.01153571f, 0.08669193f, 0.17325290f, -0.09388722f, 0.04293488f, 0.02179409f, -0.02411597f, 
    0.04694482f, 0.11895416f, -0.02504404f, -0.02160214f, 0.21716589f, -0.09271710f, 0.09378013f, 0.05761563f, 
    0.04824844f, 0.04346402f, -0.07131500f, -0.08153210f, 0.08298432f, -0.03594069f, 0.05784536f, -0.00377869f, 
    0.25317407f, 0.09174959f, 0.14898740f, 0.07361005f, -0.08151534f, 0.00129231f, 0.01330850f, -0.05287388f, 
    -0.00366968f, 0.03745655f, -0.02650522f, 0.06041842f, -0.10726377f, -0.35147700f, -0.30433822f, -0.05818022f, 
    0.02614951f, 0.07060742f, 0.02240692f, -0.01474378f, -0.16674235f, -0.03875031f, 0.00285082f, -0.09294262f, 
    0.27385828f, 0.24158417f, -0.22033121f, 0.25504979f, 0.01934675f, -0.03393431f, 0.19922708f, -0.02709860f, 
    0.08799722f, 0.04364692f, -0.06067683f, 0.01134924f, 0.19648571f, -0.17622206f, -0.10836572f, -0.09761474f, 
    0.10377176f, 0.12515184f, 0.00251303f, 0.06275466f, -0.03451993f, 0.06864151f, 0.01309344f, 0.11593281f, 
    -0.40060300f, -0.14281790f, 0.07332082f, -0.18326733f, 0.04971048f, -0.05410140f, 0.06673444f, -0.01437388f, 
    0.12289280f, 0.13699223f, 0.07607268f, 0.07893048f, -0.27244413f, -0.17444833f, -0.08447207f, -0.06743005f, 
    0.04753068f, -0.07917481f, -0.05952980f, 0.00634135f, 0.06456354f, -0.04953293f, 0.02314047f, 0.08678298f, 
    -0.20944349f, -0.01222347f, 0.06831478f, -0.17660239f, -0.02708980f, -0.07341721f, 0.01159065f, 0.00658736f, 
    -0.00659314f, 0.01882192f, -0.08263841f, -0.05416350f, 0.20380199f, 0.06484352f, -0.24643949f, -0.04322822f, 
    -0.10294763f, -0.07443999f, -0.11235717f, -0.05000151f, 0.00731811f, -0.03338601f, -0.16812605f, -0.00721221f, 
    -0.00263716f, -0.07804694f, 0.06348512f, 0.00093461f, -0.02973440f, 0.07963977f, 0.14728080f, 0.08285974f, 
    -0.04856352f, -0.02809080f, 0.14034605f, 0.17930880f, 0.08534916f, -0.18920684f, 0.15488841f, 0.03492403f, 
    -0.07901227f, -0.07494098f, -0.00499752f, 0.10784961f, -0.00386022f, -0.10090980f, 0.10143060f, -0.02036575f, 
    0.34901029f, 0.06176140f, -0.04225910f, -0.11108908f, -0.04793495f, 0.05571821f, -0.05055751f, 0.17377517f, 
    -0.01726511f, 0.01990949f, 0.01302369f, -0.05776458f, -0.02657278f, -0.14842919f, 0.05077595f, 0.07095920f, 
    0.13430461f, 0.03963652f, 0.03862452f, 0.02653912f, 0.02943785f, 0.05188946f, -0.05991481f, 0.07470402f, 
    -0.06343375f, 0.02266880f, -0.01501884f, 0.00460249f, -0.06070885f, -0.09001518f, 0.06217699f, -0.01665077f, 
    0.03813798f, -0.05622402f, 0.09584761f, 0.00451680f, -0.09710119f, 0.06271143f, 0.07302197f, 0.17818104f, 
    0.12093075f, 0.01493639f, -0.05879633f, 0.02443542f, 0.04858598f, 0.05014879f, 0.10451717f, 0.03675591f, 
    -0.03257172f, -0.05093797f, -0.00395908f, 0.02885683f, -0.04371629f, -0.05140383f, -0.04437538f, -0.12909108f, 
    0.00832382f, -0.04674222f, -0.07749364f, 0.00741812f, -0.25893337f, 0.13295506f, -0.10374838f, -0.26659146f, 
    0.14858787f, 0.12933233f, 0.03083435f, -0.08648375f, 0.03263113f, -0.00330933f, -0.06877275f, -0.05907712f, 
    -0.18796693f, -0.01386696f, -0.05579545f, -0.20522928f, 0.07569242f, 0.11302319f, 0.04943471f, -0.05600756f, 
    0.08346378f, 0.02786460f, 0.11416984f, 0.02752562f, -0.19412145f, -0.03632494f, 0.04089889f, -0.04928185f, 
    0.05865251f, -0.08635223f, -0.06350163f, 0.15551119f, -0.03620349f, -0.04379538f, 0.04257091f, 0.02005797f, 
    0.09434560f, 0.06895959f, -0.01613619f, -0.27218994f, 0.03872904f, -0.04929484f, -0.04183505f, -0.10411597f, 
    0.05833372f, -0.02861384f, -0.01977463f, -0.00072463f, -0.10207083f, 0.26496688f, -0.09448701f, 0.08237812f, 
    -0.14496917f, -0.00167364f, 0.04905311f, 0.01790495f, -0.04058353f, -0.04894072f, -0.00967261f, -0.13463795f, 
    0.26572180f, -0.25974298f, -0.05869458f, -0.05638872f, 0.13219593f, 0.08272354f, -0.00362877f, -0.03485178f, 
    0.00333102f, -0.01015039f, 0.00353892f, -0.05884996f, 0.17432617f, -0.27458715f, -0.20994523f, 0.02780598f, 
    -0.03637060f, 0.05682118f, -0.01514858f, -0.00480010f, 0.01767122f, -0.05054819f, -0.09807024f, 0.00769192f, 
    -0.12584592f, -0.09317095f, -0.02045027f, -0.04664022f, -0.10566744f, -0.08055822f, 0.02134664f, -0.08382237f, 
    -0.04513549f, -0.07279012f, -0.09103658f, 0.11889321f, 0.02786855f, 0.03053798f, 0.00023361f, -0.06812615f, 
    -0.00815069f, 0.02934676f, -0.01330074f, -0.17004001f, 0.10183265f, -0.02869929f, -0.05684423f, 0.03005252f, 
    -0.08030988f, -0.06972031f, -0.05226711f, 0.18262036f, 0.08843922f, 0.16819847f, 0.04185611f, 0.16435955f, 
    0.07350048f, 0.00108494f, 0.07983772f, 0.16708918f, 0.14815444f, 0.08763225f, -0.07223434f, -0.09443632f, 
    0.17366928f, 0.12580822f, -0.07860912f, 0.01254590f, 0.16300020f, 0.11556003f, -0.00555867f, -0.05517484f, 
    -0.00519511f, -0.02373095f, 0.11862222f, 0.04332230f, 0.09474365f, 0.01659328f, 0.08964267f, -0.09047748f, 
    0.10922635f, 0.00998927f, 0.06318875f, -0.05307785f, 0.11719630f, 0.00897718f, 0.18434753f, 0.11318012f, 
    -0.07262108f, -0.08191865f, -0.04296025f, -0.03235165f, 0.03386816f, -0.13175881f, -0.01068501f, -0.08583155f, 
    0.13463174f, 0.06841386f, 0.29894641f, -0.37459475f, -0.06335127f, -0.03129529f, -0.08007673f, 0.05145976f, 
    0.00940344f, 0.04787280f, 0.05253011f, 0.02043767f, -0.06628758f, -0.14416564f, 0.17224050f, 0.12803550f, 
    -0.11693412f, -0.12853795f, -0.06732502f, 0.05528390f, 0.13008524f, 0.04843928f, 0.01308585f, 0.02340646f, 
    0.04852490f, -0.10914212f, -0.04287120f, -0.08867701f, 0.22942360f, 0.07854863f, 0.08585921f, 0.18621737f, 
    0.16658360f, 0.01505422f, 0.06853893f, -0.00544499f, -0.18112110f, 0.06691497f, -0.03446507f, -0.32637572f, 
    -0.10920560f, 0.14543067f, 0.10572357f, -0.02255678f, -0.07117072f, 0.02291388f, 0.00100870f, -0.04382802f, 
    -0.18382449f, -0.10310809f, -0.06956193f, 0.03427347f, -0.05493975f, -0.12058015f, 0.04528959f, 0.06299125f, 
    0.00131266f, 0.06617559f, -0.03747826f, -0.13810027f, 0.41059130f, 0.26105821f, -0.16366361f, 0.20458858f, 
    -0.05129193f, -0.13779011f, 0.00475196f, 0.00053636f, 0.09358358f, 0.02457105f, 0.04928949f, 0.06172610f, 
    -0.19099376f, 0.00438229f, 0.04656138f, -0.09218059f, 0.11896107f, -0.04522964f, 0.04873471f, -0.06880547f, 
    -0.01286301f, 0.07234637f, -0.01248709f, 0.06388090f, 0.11462785f, 0.01299148f, 0.07306937f, 0.13116753f, 
    0.00193919f, 0.05218234f, -0.00482319f, -0.10225062f, 0.09414404f, -0.08511559f, 0.08332462f, 0.06977814f, 
    0.05864574f, 0.10640179f, -0.09401245f, 0.10361601f, -0.12965930f, -0.06045777f, 0.04425903f, -0.00392019f, 
    -0.04124643f, -0.14774345f, -0.06971876f, 0.03243778f, 0.18164194f, 0.00439469f, 0.10901678f, 0.22214586f, 
    -0.04132349f, 0.01776684f, -0.05426024f, -0.12915666f, 0.00614889f, 0.07025325f, -0.11225407f, -0.02482303f, 
    -0.07521500f, -0.02717028f, -0.04996217f, -0.12669326f, 0.03303059f, -0.06585765f, -0.13984607f, -0.05540783f, 
    -0.07595842f, -0.22116879f, 0.11148839f, 0.09828863f, -0.09695769f, -0.16339606f, -0.12721665f, 0.07039067f, 
    0.13393299f, 0.02665607f, -0.06240315f, 0.18368720f, -0.23631375f, 0.17164923f, 0.05490945f, 0.01389254f, 
    -0.05041020f, 0.17203127f, -0.05799403f, 0.13470161f, -0.02318698f, -0.01108385f, 0.05151407f, -0.05829097f, 
    -0.27189475f, -0.07460879f, -0.02855997f, -0.20599216f, -0.02926048f, -0.08267248f, 0.04376025f, -0.02644476f, 
    0.10778556f, 0.05420267f, 0.28060448f, 0.01137078f, -0.05474048f, 0.06734356f, -0.07939371f, 0.02620746f, 
    0.02211907f, -0.21357182f, -0.09743082f, -0.19712532f, 0.13638404f, 0.08614052f, 0.14800151f, -0.08993538f, 
    -0.13171616f, 0.07510364f, 0.03171362f, -0.06407399f, 0.18994632f, 0.16822557f, -0.07357498f, 0.09559861f, 
    0.03257376f, 0.11651574f, -0.14918019f, -0.10451028f, 0.07352993f, 0.12646094f, 0.06819785f, 0.05286538f, 
    0.09264293f, 0.01355467f, 0.21730238f, -0.07035216f, 0.18459532f, 0.15492511f, 0.13626720f, 0.01998581f, 
    -0.21732584f, -0.14328696f, 0.06365229f, 0.11604249f, 0.12819509f, 0.06445546f, 0.17286026f, 0.28451928f, 
    0.00679564f, -0.17998873f, -0.14918755f, -0.03817726f, 0.17355505f, 0.01494296f, -0.14854112f, -0.01123738f, 
    0.07133857f, -0.04868977f, 0.10790478f, -0.14381646f, -0.03357232f, 0.11113025f, -0.04637215f, -0.04221705f, 
    -0.27319446f, 0.06418610f, -0.06243797f, -0.13674277f, 0.09974028f, 0.05011567f, 0.00962778f, -0.00087338f, 
    -0.07503922f, 0.03392495f, -0.17892197f, 0.12613685f, 0.07283372f, 0.10298374f, 0.08731119f, 0.08897512f, 
    -0.09973736f, -0.04546650f, -0.01877478f, 0.04736742f, -0.10784411f, -0.06759868f, -0.14705485f, -0.21584085f, 
    0.03272946f, -0.03397064f, 0.05232089f, 0.00713192f, 0.29783162f, -0.04360051f, 0.10178482f, -0.09810668f, 
    0.01994319f, 0.05639189f, 0.03508172f, 0.06123339f, 0.03006625f, 0.12946674f, 0.02229447f, 0.09939969f, 
    -0.06110890f, -0.11672593f, 0.05493435f, 0.06962436f, -0.49796307f, 0.07668327f, 0.07561015f, 0.04417058f, 
    -0.06353935f, -0.02811974f, -0.01814288f, -0.03516944f, -0.05335789f, 0.06351747f, -0.01884539f, -0.05217984f, 
    0.15415952f, 0.09674266f, -0.16947924f, -0.09678414f, -0.16115589f, 0.03530680f, 0.07534503f, -0.11131147f, 
    0.10807867f, -0.09149660f, 0.13710950f, 0.10293059f, -0.01649914f, 0.18436228f, -0.02768890f, 0.13680747f, 
    0.25145614f, -0.02352073f, 0.02678244f, 0.01206730f, 0.06661662f, -0.23413929f, -0.37025249f, -0.05615036f, 
    0.18976356f, -0.04751401f, -0.25329405f, -0.11378098f, -0.04216086f, 0.18772262f, 0.03352362f, 0.02187785f, 
    0.09639446f, 0.18755426f, 0.25059208f, -0.22328414f, -0.07297857f, 0.04283669f, 0.01227103f, -0.11323122f, 
    -0.16651228f, -0.03421219f, 0.09561715f, 0.10278942f, 0.24987546f, -0.07945216f, -0.09959631f, 0.04103873f, 
    -0.10752718f, 0.07953192f, -0.21771778f, -0.03001862f, -0.10984283f, 0.09453032f, 0.08894826f, -0.05021676f, 
    0.21992381f, -0.08417191f, 0.04956000f, -0.05140194f, -0.02405512f, 0.10122586f, 0.02390663f, 0.05923511f, 
    -0.01180174f, -0.19469102f, 0.02923532f, -0.06923443f, 0.15664972f, -0.18394552f, 0.14570171f, 0.16108194f, 
    0.12784697f, 0.03240502f, 0.10967319f, 0.00603646f, -0.01863807f, 0.02577312f, -0.05136409f, 0.04402879f, 
    0.10256030f, -0.03455251f, 0.01326207f, 0.01528986f, -0.01136037f, 0.09297100f, 0.06941753f, 0.13705376f, 
    0.00142046f, 0.13392416f, 0.05025971f, 0.14435270f, 0.14592139f, 0.07656539f, -0.02545450f, -0.12434959f, 
    -0.01710706f, 0.05419907f, 0.03851594f, 0.01621718f, -0.09127222f, -0.01927940f, 0.00194776f, -0.03610369f, 
    -0.02312915f, -0.33035371f, 0.24014983f, 0.02988786f, -0.04310479f, -0.15131070f, 0.10007347f, -0.01779985f, 
    -0.02391247f, -0.03316977f, 0.12348446f, -0.00966618f, 0.03422648f, 0.16290995f, 0.00840032f, 0.00934299f, 
    0.12202520f, 0.08905870f, 0.09345450f, 0.07493962f, 0.08527451f, -0.08957651f, -0.11890307f, 0.01557681f, 
    0.17418069f, -0.22741944f, -0.03970758f, 0.14396964f, -0.03885286f, -0.08789440f, -0.08804140f, 0.01539546f, 
    0.01266931f, 0.02558743f, -0.00689263f, 0.19235308f, -0.00004404f, -0.13749841f, -0.04851435f, -0.22492117f, 
    0.00029210f, 0.15242817f, 0.06667575f, -0.04647161f, -0.07461251f, -0.07573740f, -0.02590988f, -0.00954137f, 
    0.07074493f, -0.15132102f, -0.01748257f, -0.15776458f, 0.09257857f, 0.11148708f, 0.07133428f, 0.01344567f, 
    -0.01822112f, 0.07794821f, 0.06547425f, 0.06344455f, 0.06392157f, -0.08885495f, -0.14907138f, -0.11061466f, 
    0.12003082f, -0.01421416f, -0.04987447f, 0.12276716f, -0.17183974f, -0.07986400f, -0.16517176f, -0.04014755f, 
    0.01649834f, 0.10106575f, -0.26841575f, -0.06380734f, -0.04049014f, -0.00231076f, 0.04987814f, -0.04125952f, 
    0.00966482f, 0.03834913f, -0.09844851f, 0.02550312f, 0.40926850f, 0.02686190f, 0.08062156f, -0.09120891f, 
    -0.02326474f, 0.13144700f, -0.01593041f, 0.06495991f, -0.03707811f, -0.07812774f, -0.04990822f, -0.03294533f, 
    0.15491253f, -0.03965218f, 0.10979846f, -0.14895503f, 0.07951743f, -0.14607635f, 0.05493347f, 0.05883636f, 
    -0.08779213f, 0.14599587f, 0.04201450f, 0.05902470f, 0.01400910f, -0.24938083f, -0.07180867f, 0.06555380f, 
    0.03719619f, 0.11448960f, 0.03572752f, 0.01055970f, 0.10526402f, -0.05108849f, -0.01818192f, 0.08452804f, 
    0.01769654f, 0.13520668f, 0.12658618f, -0.09775083f, -0.04623545f, -0.05530216f, 0.04087745f, -0.01119839f, 
    -0.02394946f, -0.06528763f, 0.00376103f, 0.10538002f, 0.14586264f, -0.48878443f, -0.17771663f, 0.19769691f, 
    -0.01294326f, 0.00577396f, -0.07442255f, 0.10718279f, -0.09279517f, 0.15421738f, 0.04469038f, 0.12004864f, 
    -0.06408197f, 0.15042086f, 0.00721643f, -0.04092348f, 0.04994079f, 0.09035847f, 0.06048388f, -0.17485370f, 
    -0.15740648f, 0.00676800f, -0.04502707f, -0.03151770f, 0.21772912f, -0.30097207f, -0.03998661f, -0.05536100f, 
    0.00347322f, -0.03341557f, 0.03006910f, -0.01847484f, 0.02027100f, 0.14312764f, 0.04187695f, 0.02120107f, 
    0.18773620f, -0.32558149f, -0.12111401f, 0.09447444f, -0.06030810f, 0.11336797f, -0.06551686f, 0.01046420f, 
    -0.03956383f, 0.08410065f, -0.00424110f, 0.13772736f, -0.01710023f, 0.24004613f, 0.07915875f, -0.08342699f, 
    0.06697457f, 0.01840168f, -0.01431822f, -0.01343216f, 0.06207453f, 0.13112503f, 0.11558312f, -0.04269697f, 
    0.09430317f, -0.18661897f, -0.00362195f, 0.09328808f, 0.04980297f, 0.12046130f, 0.06664570f, -0.11376870f, 
    0.04886472f, -0.00121796f, -0.05307926f, 0.00947904f, 0.21708676f, 0.23244110f, 0.00756751f, -0.21668485f, 
    -0.09467702f, -0.13943814f, -0.03425878f, 0.21837151f, 0.13934743f, 0.00602008f, -0.15543208f, 0.24885917f, 
    0.14512821f, -0.10642038f, -0.07121108f, -0.09573872f, -0.16014649f, 0.10603145f, -0.16124190f, -0.09360381f, 
    -0.00568385f, 0.13576508f, 0.06432792f, 0.06532867f, 0.00065543f, 0.09596088f, -0.00078829f, -0.08359805f, 
    0.16329058f, 0.12213781f, -0.07268976f, -0.09576703f, 0.00496436f, -0.00556945f, 0.06500156f, 0.04672702f, 
    0.01237589f, -0.23825678f, -0.17706788f, -0.08852751f, 0.12167855f, 0.03504168f, 0.08395938f, -0.05594603f, 
    0.10128666f, 0.08543839f, 0.00197374f, -0.07220781f, 0.27631640f, -0.12637216f, -0.09746794f, -0.13951407f, 
    0.07275456f, -0.06703810f, 0.00599136f, 0.05220520f, -0.17764366f, 0.08459174f, -0.02029607f, -0.03206120f, 
    -0.13067104f, 0.02034207f, -0.05346475f, 0.06508540f, -0.18458042f, 0.04330758f, 0.15406878f, -0.17139465f, 
    0.21235934f, 0.09747285f, 0.03401545f, 0.15418774f, 0.36141437f, 0.10946716f, -0.00262422f, 0.07202503f, 
    0.06698740f, -0.07145584f, -0.07830860f, 0.03970424f, 0.00287035f, 0.01738055f, 0.09392138f, -0.05322989f, 
    -0.05977460f, -0.09669341f, 0.21733332f, -0.00189145f, 0.09432929f, -0.07472600f, -0.06045984f, 0.09316101f, 
    0.08535171f, 0.10725199f, 0.03042921f, 0.09736533f, -0.03870803f, -0.28383732f, -0.04422688f, 0.00106820f, 
    0.05855239f, -0.02177628f, 0.00447267f, 0.09229526f, -0.05862688f, -0.09891078f, -0.03129301f, 0.03918601f, 
    0.04346184f, -0.18574451f, -0.15894632f, 0.09260692f, 0.06660465f, 0.09399521f, 0.02725221f, 0.04251661f, 
    0.16265556f, 0.18297796f, 0.03198388f, -0.01406000f, -0.19213828f, -0.21503563f, 0.08797283f, 0.12512235f, 
    -0.00312268f, -0.00067026f, 0.23670065f, 0.15093243f, -0.09054818f, -0.05415539f, 0.10870312f, -0.05165076f, 
    -0.38473660f, 0.25887799f, -0.05881003f, 0.03672684f, 0.01122451f, -0.16071241f, -0.03858707f, 0.01441385f, 
    -0.01051676f, 0.10528532f, -0.10910121f, -0.02355010f, -0.31347111f, 0.12327300f, -0.05395600f, -0.02428470f, 
    -0.01956852f, -0.05026273f, -0.10426921f, -0.06042206f, 0.06148154f, 0.06475451f, 0.04619388f, 0.13177177f, 
    -0.07483596f, -0.14030047f, -0.00862289f, 0.04989901f, -0.03632231f, -0.06126203f, -0.03907561f, -0.03047600f, 
    -0.06872768f, -0.01841463f, -0.00142665f, 0.08821446f, 0.06012910f, 0.19292457f, 0.00616712f, 0.19543272f, 
    -0.04795580f, -0.00209395f, -0.06302480f, -0.07776907f, 0.06575332f, 0.15413369f, 0.08592014f, -0.00335209f, 
    0.23401807f, 0.07948875f, -0.34642452f, 0.17853653f, 0.09249184f, 0.10502470f, -0.04352641f, -0.02130518f, 
    0.13113734f, 0.06128903f, -0.13167344f, -0.03949643f, 0.29021418f, 0.10265276f, 0.04993980f, -0.04494023f, 
    -0.00026750f, -0.05712223f, 0.01015334f, 0.01857401f, 0.00082915f, -0.00165555f, -0.05342115f, 0.08800136f, 
    -0.12165185f, 0.03149802f, -0.12572661f, 0.02010734f, 0.00726514f, 0.03022187f, 0.10027645f, -0.00402211f, 
    -0.07487067f, -0.03792705f, -0.06189748f, -0.06067326f, 0.10036617f, 0.09883939f, -0.03775639f, 0.27853024f, 
    -0.00262459f, -0.17425849f, 0.00645946f, -0.02796986f, 0.00514669f, 0.02083846f, 0.04651362f, 0.05409243f, 
    0.11763421f, -0.20000310f, -0.09398171f, 0.05001255f, 0.04403466f, -0.01630885f, 0.01587114f, 0.06942513f, 
    -0.04243013f, 0.00371470f, -0.02606358f, -0.01014021f, 0.13269930f, 0.09203534f, 0.23626463f, -0.00899460f, 
    0.02096975f, 0.01236384f, 0.08812365f, -0.11434584f, 0.07406604f, 0.05566491f, 0.02199569f, 0.03682927f, 
    -0.21043642f, -0.15195791f, 0.15104938f, 0.05722846f, -0.14768761f, 0.03388318f, 0.00582331f, -0.01748564f, 
    -0.00656622f, 0.00987369f, -0.02300049f, -0.03490626f, -0.05295735f, 0.04289674f, 0.05246530f, 0.04801865f, 
    -0.02655439f, -0.13688259f, -0.06701390f, 0.05576762f, 0.04279511f, 0.09624576f, 0.02762198f, -0.03042641f, 
    0.02735076f, 0.14685193f, 0.21763384f, 0.07873563f, -0.00759789f, 0.14098404f, -0.07120796f, -0.06959478f, 
    -0.00368947f, -0.02621309f, 0.11385541f, -0.01179898f, 0.14532737f, 0.14057887f, 0.21890348f, -0.17673859f, 
    0.00410584f, -0.05958162f, -0.04514232f, 0.08364931f, -0.10937673f, 0.05090573f, -0.05908115f, 0.00829810f, 
    -0.27713028f, 0.15474142f, 0.09919368f, -0.00204400f, 0.07334516f, -0.08226144f, -0.04435570f, -0.01456303f, 
    -0.02204374f, -0.03327809f, -0.13771927f, 0.16663313f, 0.28286117f, 0.09731961f, -0.17864214f, 0.02304512f, 
    0.03172161f, -0.15424216f, -0.03225024f, 0.04767909f, 0.01463261f, 0.11604333f, -0.14691015f, 0.09253897f, 
    0.17873485f, 0.06080076f, -0.01245670f, -0.16552126f, -0.01581000f, 0.03905455f, 0.20222224f, 0.05769818f, 
    0.13828856f, 0.09064464f, 0.10562059f, 0.27919725f, 0.60747576f, -0.04848297f, -0.21591054f, -0.12652153f, 
    -0.08657083f, 0.09295388f, -0.02372618f, 0.14005177f, 0.00689951f, 0.00442510f, 0.07566722f, 0.03224986f, 
    0.23798223f, 0.08912615f, -0.02834061f, -0.05045139f, 0.01361068f, -0.06794826f, -0.06117915f, -0.07685085f, 
    0.07018363f, -0.08315479f, -0.02813592f, -0.01706154f, -0.34451273f, -0.14636813f, -0.00533677f, 0.01536383f, 
    0.02052951f, 0.02206975f, -0.02189792f, -0.17235141f, 0.06395003f, -0.09716838f, -0.00279766f, 0.04545581f, 
    -0.07045498f, 0.10505057f, -0.03406147f, -0.32206985f, -0.09814905f, 0.12705129f, -0.01225197f, 0.05888461f, 
    0.00599117f, 0.01341759f, 0.01395150f, 0.01966362f, -0.06024090f, 0.04377183f, -0.07667066f, 0.02806271f, 
    -0.00250096f, -0.16496675f, -0.03993388f, 0.10536590f, -0.15203176f, 0.06780422f, -0.04517818f, 0.03679546f, 
    0.22112492f, 0.18141024f, 0.00287822f, -0.18961453f, -0.00492019f, 0.13314855f, 0.04462691f, -0.19709885f, 
    0.08774043f, 0.14688484f, 0.07923853f, -0.05655055f, -0.22473688f, 0.08366585f, -0.02389408f, -0.07358609f, 
    0.26240709f, 0.13751295f, -0.03366348f, -0.02750707f, 0.03806645f, 0.01967540f, -0.11434268f, 0.08916034f, 
    0.05869919f, 0.03092459f, -0.01604355f, 0.08294258f, 0.04214283f, 0.00660907f, 0.04554702f, -0.10597545f, 
    0.08404752f, 0.03781844f, -0.06402019f, -0.03720171f, -0.00380046f, -0.17569992f, 0.07831185f, 0.24518514f, 
    -0.07212655f, 0.06390805f, -0.00978502f, -0.03016849f, -0.04126413f, 0.04322456f, 0.11549377f, 0.09871489f, 
    -0.01428523f, 0.14585173f, 0.05829122f, -0.00181261f, 0.05855750f, 0.16390978f, 0.14386566f, -0.04271691f, 
    0.18834722f, 0.11675748f, 0.06988522f, -0.00446714f, -0.17421447f, 0.07400727f, -0.18173185f, 0.04245921f, 
    0.13514523f, 0.03863861f, -0.00926857f, -0.09224360f, 0.08471184f, 0.06488343f, 0.04522138f, 0.07601251f, 
    -0.28079566f, -0.26835069f, -0.22499555f, 0.32017112f, 0.07698329f, 0.15448765f, 0.00968942f, -0.05340591f, 
    0.23126708f, -0.02479237f, 0.03589180f, -0.00738090f, 0.03307688f, -0.03421829f, -0.24723341f, 0.01051661f, 
    0.09348474f, -0.09146688f, -0.21913631f, -0.01396102f, -0.11212160f, -0.11841480f, -0.01135966f, 0.02935974f, 
    -0.04891889f, 0.02164903f, -0.02675185f, 0.04562879f, 0.00755724f, -0.05541741f, 0.03904827f, 0.04302054f, 
    -0.00956677f, -0.01987470f, -0.03597959f, -0.06228132f, 0.03271341f, -0.01525485f, 0.01699097f, -0.05030117f, 
    0.02097667f, 0.01855182f, -0.02243137f, -0.06940310f, 0.03373718f, -0.04796016f, 0.04654939f, -0.03243332f, 
    -0.00907519f, 0.02545113f, -0.00340216f, -0.07262165f, -0.00916136f, -0.03474782f, -0.04586882f, -0.06740872f, 
    -0.05831907f, 0.03930721f, -0.05061755f, 0.04745747f, -0.06705724f, -0.07975218f, 0.01662508f, 0.04872868f, 
    0.05891121f, -0.02092180f, -0.05452200f, -0.05721780f, -0.03361513f, -0.03598580f, 0.01531714f, 0.00937562f, 
    0.02652912f, -0.00586174f, -0.02145142f, -0.05660315f, -0.04452356f, 0.05738541f, 0.04446832f, -0.03458342f, 
    -0.01995463f, 0.02160177f, -0.05741690f, -0.04154212f, 0.00097153f, -0.02512066f, 0.01300131f, -0.05951520f, 
    -0.01922147f, -0.01621469f, 0.00032009f, 0.00788989f, -0.05173378f, 0.01773497f, 0.01334333f, 0.01762706f, 
    0.01289132f, 0.05172902f, 0.01245002f, -0.06056558f, 0.00457878f, -0.06516775f, -0.00876432f, 0.01329812f, 
    -0.05217281f, -0.06057173f, -0.07938760f, 0.02214468f, -0.03310717f, 0.04921848f, 0.03479030f, -0.02751268f, 
    -0.06000393f, 0.00557147f, -0.03724234f, 0.02102968f, 0.06094941f, 0.02230887f, -0.07427078f, 0.01146551f, 
    0.06541265f, -0.05455484f, -0.01479534f, 0.01994379f, 0.04493041f, -0.04827584f, 0.05640985f, -0.08322291f, 
    0.04308818f, 0.05383311f, 0.05994493f, -0.05125479f, 0.01505641f, 0.01993859f, -0.00942486f, 0.02522608f, 
    -0.03849529f, 0.01847017f, 0.04788252f, -0.02892050f, 0.03546782f, -0.00271906f, -0.01089489f, -0.01561933f, 
    -0.07000554f, -0.03714173f, 0.00692916f, -0.02242023f, 0.02872796f, -0.06864617f, -0.00891909f, 0.05872286f, 
    0.04724084f, -0.02788106f, -0.07728530f, 0.05151431f, 0.03413685f, -0.04656934f, -0.04949051f, -0.01101107f, 
    -0.06925245f, -0.06513502f, 0.03482077f, -0.04443511f, -0.07057901f, -0.04681470f, -0.00707645f, 0.00228988f, 
    -0.05825825f, -0.06259684f, 0.05420957f, 0.01736297f, -0.04232812f, 0.02835237f, -0.07896303f, 0.03490794f, 
    0.06249891f, -0.02841459f, 0.00623067f, -0.04944496f, -0.04906150f, -0.00102657f, -0.03423740f, 0.03605496f, 
    0.03236738f, -0.04580601f, -0.03904371f, -0.02390461f, -0.05074566f, -0.00681117f, -0.04934251f, 0.02871712f, 
    -0.06199168f, 0.01491688f, 0.00767845f, 0.06506377f, -0.01633119f, -0.05272616f, 0.00171679f, 0.03464498f, 
    -0.06573023f, 0.04067301f, -0.02395002f, 0.04082650f, 0.02229897f, -0.04484062f, -0.06367458f, -0.07910974f, 
    0.00056957f, 0.00842326f, 0.02424132f, -0.05653888f, 0.03581234f, 0.05998855f, -0.04307236f, 0.03134183f, 
    0.13022768f, 0.13099320f, -0.15941945f, 0.22767377f, 0.08365338f, 0.16119693f, -0.02926599f, -0.06111067f, 
    -0.13220410f, 0.14880602f, 0.18771790f, 0.20260243f, 0.23975435f, 0.03875788f, 0.41951311f, -0.32171866f, 
    0.11099804f, 0.06655217f, 0.09023425f, -0.00499396f, -0.11166093f, -0.10214402f, 0.23850967f, 0.06220550f, 
    0.06358835f, -0.08258531f, 0.03906836f, 0.00378132f, -0.19571058f, -0.06230674f, -0.07658853f, -0.07010797f, 
    -0.04958472f, -0.15677090f, -0.12372326f, -0.34594414f, -0.13166757f, 0.01053211f, 0.13288589f, -0.13747598f, 
    -0.01533360f, 0.05580791f, 0.29584229f, -0.09781036f, -0.01038124f, -0.00990554f, 0.01854135f, 0.01315204f, 
    0.72495723f, 0.05247252f, 0.10840426f, -0.12700400f, 0.03691615f, 0.03714015f, -0.04674738f, 0.29998147f, 
    -0.09347823f, 0.02078346f, -0.06715852f, -0.06672933f, 0.18455936f, 0.09340079f, -0.20433438f, -0.05078303f, 
    0.05306214f, -0.11051265f, -0.08997745f, 0.03093129f, 0.02949341f, 0.14578412f, 0.01248380f, -0.13023464f, 
    0.10331704f, -0.03046502f, 0.01207819f, -0.22650163f, 0.11990409f, -0.00898304f, 0.14665130f, 0.07898886f, 
    0.01530237f, 0.06636407f, 0.00500511f, 0.09217940f, 0.28377211f, 0.07442166f, 0.00553488f, 0.22910237f, 
    0.00776535f, -0.00690004f, -0.00291306f, -0.18357091f, -0.11123646f, -0.16722363f, 0.02042289f, -0.11606955f, 
    0.17803781f, 0.23056790f, 0.01129430f, -0.11018948f, -0.00698970f, 0.09583721f, -0.07402816f, -0.00426458f, 
    0.01476193f, -0.00451011f, -0.06987559f, 0.12406442f, 0.07517314f, 0.18888356f, 0.11169228f, -0.04383952f, 
    0.06128887f, 0.03611583f, -0.20157847f, 0.04482767f, -0.02041572f, -0.14952742f, -0.12090805f, -0.03872011f, 
    0.13928081f, 0.16081125f, 0.32025534f, 0.09799514f, 0.03368525f, 0.01675266f, -0.28946331f, 0.04385222f, 
    -0.05228550f, 0.17460115f, 0.09527592f, 0.20834868f, -0.18999264f, -0.04086192f, -0.04331201f, 0.04513267f, 
    -0.11154602f, -0.10198142f, -0.03901219f, -0.09924557f, -0.10991240f, -0.14214870f, -0.05413955f, -0.01292095f, 
    -0.09815864f, 0.03912411f, 0.34336975f, 0.04187396f, -0.03227327f, -0.12364843f, -0.09738639f, 0.02360068f, 
    -0.14405942f, 0.14172083f, 0.00028303f, 0.07916613f, 0.00256798f, -0.05544190f, -0.06141602f, 0.15948084f, 
    0.10638367f, 0.09860000f, -0.15548623f, -0.08577531f, -0.05802639f, -0.01142289f, -0.29167318f, -0.07306977f, 
    0.26270583f, 0.23063485f, -0.15416721f, 0.04058341f, 0.02281036f, 0.00583156f, -0.06855287f, -0.07310107f, 
    -0.03028531f, 0.09136896f, 0.03859521f, -0.09727777f, -0.02843083f, 0.10079166f, 0.06129034f, -0.09239934f, 
    -0.14016333f, 0.02365368f, 0.03276563f, 0.04629613f, -0.17829655f, 0.01542060f, 0.14104454f, 0.22410457f, 
    -0.03106884f, -0.08670220f, -0.37276998f, 0.03129293f, 0.00474612f, -0.00711373f, 0.15835612f, 0.09129068f, 
    0.00078744f, -0.06649162f, 0.09591665f, -0.02016731f, -0.23148227f, 0.22188875f, -0.04153248f, -0.00740206f, 
    -0.03378936f, -0.05392018f, 0.12399866f, -0.02607974f, 0.10669537f, -0.01864129f, -0.07444724f, 0.03688907f, 
    -0.12721603f, 0.05024210f, -0.15538159f, 0.13233447f, 0.03019946f, -0.05110131f, 0.01181256f, 0.03333260f, 
    0.10356884f, 0.08903778f, 0.05740621f, 0.03699914f, 0.00223415f, -0.12586445f, -0.23950334f, -0.17515481f, 
    0.11485986f, -0.01696052f, -0.07332195f, -0.01914597f, 0.11113153f, 0.10565511f, -0.05142687f, 0.08932832f, 
    -0.38977620f, -0.05513233f, -0.05123018f, 0.02683475f, 0.10092811f, -0.04553767f, -0.05052942f, -0.04339512f, 
    -0.09182956f, 0.01284922f, 0.10463039f, -0.07568897f, 0.22463177f, 0.11066464f, 0.08664636f, 0.00299912f, 
    -0.18142474f, -0.04882691f, 0.07706717f, 0.00500680f, -0.03697201f, -0.09658732f, -0.06058492f, 0.07982525f, 
    0.12460524f, 0.08334738f, 0.01416468f, -0.11306049f, 0.01935294f, 0.00324599f, -0.08168446f, -0.01157841f, 
    0.01382843f, -0.00059841f, -0.07122329f, -0.09280159f, -0.03293303f, -0.10985751f, 0.26975578f, 0.18527105f, 
    -0.07987533f, -0.00819688f, -0.01202605f, -0.01619123f, 0.05131108f, 0.02251119f, -0.03626335f, -0.06094537f, 
    0.04814526f, -0.00684250f, -0.06372216f, -0.30990100f, 0.13366245f, 0.02639813f, 0.07812201f, 0.01331429f, 
    -0.02869408f, -0.02872141f, -0.01111630f, -0.10754106f, 0.05397706f, -0.07528330f, 0.04626634f, 0.08002052f, 
    -0.05949542f, -0.11459287f, -0.04743478f, 0.06060482f, 0.06097880f, -0.06143886f, 0.11978071f, 0.16102538f, 
    -0.18053804f, 0.23336646f, 0.03730318f, 0.10616213f, 0.13200146f, 0.05234433f, -0.09112102f, 0.16926487f, 
    -0.02062664f, 0.03756965f, -0.04697128f, 0.01716572f, 0.41074178f, 0.04640653f, 0.13288514f, 0.09940820f, 
    -0.06087077f, 0.12937097f, -0.00579917f, -0.03763141f, 0.18867677f, -0.03645610f, -0.00235083f, 0.00093422f, 
    0.11554468f, -0.06453960f, 0.26430839f, 0.05653249f, -0.01704202f, -0.07944205f, -0.02349134f, 0.04945817f, 
    0.02543007f, 0.00368720f, 0.04945074f, 0.07929961f, -0.33390436f, 0.05055671f, 0.17479832f, 0.10232612f, 
    0.05217489f, 0.00215422f, 0.05415266f, -0.06153386f, 0.05652833f, -0.16645715f, 0.00341396f, 0.10511724f, 
    0.08104846f, 0.06831094f, -0.14562659f, 0.19099933f, -0.08343985f, 0.11775970f, -0.00442887f, 0.07059371f, 
    -0.01820535f, -0.18615173f, -0.05021450f, -0.01941667f, 0.23540269f, 0.21564782f, 0.02181170f, 0.25719512f, 
    -0.05637965f, -0.01775240f, 0.06558159f, 0.07098269f, 0.04467174f, 0.03982379f, 0.16868749f, -0.02939767f, 
    -0.12557031f, -0.30111697f, -0.17240663f, -0.28135857f, 0.06384113f, 0.11898695f, -0.09878437f, -0.12369652f, 
    0.12659308f, 0.14847204f, -0.06484192f, -0.02391106f, 0.19267212f, 0.40168151f, -0.05228557f, 0.09150127f, 
    0.00611108f, -0.05118928f, -0.13239072f, -0.13595954f, -0.00281487f, 0.00230743f, 0.02889190f, 0.06275129f, 
    -0.14216828f, -0.12768517f, -0.04940619f, -0.24151675f, -0.22811535f, -0.07114695f, 0.01526444f, 0.09004402f, 
    0.13200128f, 0.05110373f, -0.03468215f, -0.07789495f, 0.04844590f, 0.33928612f, 0.30416897f, 0.18883654f, 
    -0.12261735f, -0.07643747f, 0.14823066f, 0.13419858f, 0.02949111f, -0.09802500f, 0.14876886f, -0.12709366f, 
    0.35776910f, 0.27149004f, 0.06674780f, 0.03021455f, 0.12035592f, -0.21967386f, -0.09144020f, 0.15027794f, 
    0.03372882f, -0.00393729f, 0.04316200f, -0.05649981f, 0.16912261f, -0.20508307f, 0.12585780f, 0.29979226f, 
    0.16210237f, 0.12416916f, -0.11709961f, 0.05855736f, -0.00196054f, -0.06728335f, -0.08653507f, -0.09617689f, 
    -0.08319476f, 0.14686339f, 0.20196123f, -0.02924803f, 0.03177641f, -0.06782389f, -0.09495991f, 0.01212652f, 
    0.03631229f, -0.00540949f, -0.01476541f, 0.12032428f, -0.31773973f, -0.26624385f, -0.09601518f, 0.44613785f, 
    0.03273359f, 0.00965878f, 0.04356976f, -0.03700535f, 0.11540240f, -0.07792994f, 0.20440949f, -0.06180318f, 
    -0.08515921f, 0.11314955f, 0.05485258f, 0.01466045f, -0.02751143f, -0.07357964f, -0.02901359f, 0.02902551f, 
    -0.03948244f, -0.03276431f, 0.02900890f, -0.03592130f, -0.27056956f, -0.07691953f, -0.07263480f, -0.28359208f, 
    0.03094951f, -0.06917290f, 0.03233108f, -0.07036711f, 0.09590007f, 0.00491724f, 0.03518487f, -0.12398760f, 
    -0.34949520f, -0.12916422f, -0.02991422f, -0.33471319f, -0.01476755f, -0.16020590f, 0.05149304f, 0.00844459f, 
    0.08314088f, 0.00484596f, -0.01060663f, 0.15280576f, -0.03000782f, 0.37485868f, 0.04563892f, 0.16681375f, 
    0.04586147f, -0.00077049f, -0.02979090f, -0.05782125f, -0.07562768f, -0.12096731f, 0.18252219f, -0.08404887f, 
    -0.02655097f, -0.00067947f, -0.25374463f, -0.55733538f, 0.03327556f, -0.11803835f, 0.03048518f, -0.07167792f, 
    -0.13815549f, 0.09515802f, 0.00183280f, -0.04895235f, 0.16118404f, 0.09417150f, 0.04931124f, 0.09229700f, 
    -0.01991650f, 0.10544851f, -0.10722777f, -0.02828458f, 0.09478508f, 0.06911308f, -0.06707080f, 0.04252206f, 
    0.11642540f, 0.13270870f, 0.26057419f, 0.09557875f, 0.22996733f, 0.11002316f, -0.03736871f, 0.00072255f, 
    -0.13422215f, 0.05293937f, 0.12453306f, -0.01683913f, 0.08911175f, 0.00748921f, 0.04377950f, 0.29108271f, 
    0.00983758f, 0.00449053f, -0.12223992f, 0.01818554f, 0.03065292f, -0.08715530f, -0.01198608f, 0.05240676f, 
    -0.09513550f, 0.02625860f, -0.19243489f, -0.10378782f, 0.03055897f, 0.10380494f, 0.10172059f, 0.00684168f, 
    0.05396472f, 0.11110017f, 0.08648972f, -0.09848294f, 0.03706864f, 0.00890627f, -0.15900239f, 0.21240079f, 
    -0.07910527f, -0.10619209f, -0.12108791f, 0.09763086f, -0.14294253f, -0.07070769f, 0.09036625f, -0.05765710f, 
    -0.01361811f, 0.20554271f, 0.13105117f, -0.09864390f, -0.20925415f, 0.06840520f, -0.04692903f, -0.00865709f, 
    0.01484123f, 0.04981210f, 0.10571574f, 0.01288176f, -0.31036431f, -0.01067643f, 0.23538023f, 0.09530222f, 
    -0.22190249f, -0.13255101f, -0.03234027f, 0.00988783f, -0.03605006f, 0.14179990f, 0.06940411f, 0.07566879f, 
    0.38958687f, -0.13797364f, 0.00985316f, 0.09667515f, 0.09541848f, -0.03619273f, -0.06300898f, 0.06316657f, 
    -0.08558419f, 0.08295609f, 0.01622597f, 0.11555982f, -0.16311170f, 0.25560272f, 0.08962759f, 0.02300969f, 
    -0.03533262f, -0.06545494f, -0.08116674f, -0.05603011f, -0.10265061f, 0.13665476f, -0.01783723f, -0.00208390f, 
    -0.02066801f, 0.28769702f, -0.27243152f, 0.24109772f, 0.07365700f, -0.00705977f, -0.04329878f, 0.00368991f, 
    0.12355662f, 0.01110685f, -0.03372137f, -0.08111864f, -0.01418923f, 0.01229170f, 0.06073663f, 0.05187873f, 
    0.08430157f, 0.07645326f, -0.01577697f, -0.11959681f, -0.03202282f, 0.00280369f, -0.10621858f, -0.13755447f, 
    -0.08891477f, 0.21217102f, 0.03586820f, 0.09865726f, -0.18158481f, -0.03798911f, -0.07169388f, -0.10516383f, 
    -0.14211063f, 0.08825264f, -0.11466777f, 0.04166223f, -0.05045912f, -0.13731468f, -0.02002084f, 0.05920507f, 
    0.09986333f, -0.17935699f, -0.11376218f, -0.06810538f, 0.04045355f, 0.14496377f, 0.07854245f, -0.04948117f, 
    0.14667301f, 0.01156107f, 0.17124170f, -0.06724045f, 0.13065682f, 0.11711299f, -0.01078130f, 0.02601161f, 
    -0.05412797f, 0.10265163f, 0.04563996f, 0.25252521f, 0.01587989f, -0.07474843f, 0.07721458f, -0.15423450f, 
    -0.01556326f, 0.01920218f, 0.03579430f, -0.05176499f, -0.06928872f, -0.07085278f, 0.00784759f, -0.00944118f, 
    0.31309354f, 0.05134090f, 0.01915893f, -0.19953820f, -0.05741789f, 0.04027745f, -0.05538721f, -0.05997661f, 
    0.09278750f, 0.08420336f, -0.04778930f, 0.02813997f, 0.03737291f, 0.10632882f, -0.00333459f, 0.07007195f, 
    -0.01302302f, -0.09913440f, -0.03775929f, -0.04826302f, -0.09126827f, 0.02174651f, -0.15023562f, -0.06600536f, 
    0.03327141f, 0.21460590f, -0.05451766f, -0.03886295f, -0.00396497f, 0.16123801f, 0.02660782f, -0.08365515f, 
    0.05094434f, 0.11699157f, 0.06028385f, -0.05357838f, 0.05930703f, 0.01760224f, -0.12315122f, 0.08676987f, 
    -0.12357593f, 0.03748600f, -0.02835404f, 0.11475090f, 0.03075655f, 0.01106062f, 0.17952682f, 0.11595830f, 
    0.02898111f, -0.13063720f, 0.03852895f, 0.26527882f, 0.02301409f, 0.08274565f, -0.00179721f, -0.06487908f, 
    0.13347034f, 0.15461010f, -0.01645972f, 0.01521169f, -0.11820197f, 0.06362978f, 0.08195920f, -0.15355986f, 
    -0.04319083f, -0.00329256f, 0.20005198f, -0.14212792f, -0.06310364f, -0.03922512f, 0.13503021f, 0.08473738f, 
    -0.14177933f, 0.07187971f, 0.00409489f, 0.05596754f, 0.12199435f, -0.02551108f, -0.04112545f, 0.20091441f, 
    0.11728390f, 0.02329847f, -0.10550734f, -0.06246175f, -0.65366417f, 0.27126658f, 0.16231005f, 0.06505353f, 
    0.01685035f, -0.07825132f, -0.12964889f, -0.00073402f, 0.10364826f, -0.01160679f, -0.06021137f, 0.08448240f, 
    -0.19402827f, 0.14797570f, 0.02672919f, 0.06297426f, 0.00131603f, -0.03686979f, 0.05826172f, -0.00330094f, 
    0.03932501f, 0.05111653f, -0.04244018f, 0.03758353f, -0.06022888f, -0.15362136f, 0.06004006f, 0.05290615f, 
    -0.08674718f, 0.00423383f, -0.01289174f, -0.03713471f, -0.02452721f, -0.03458076f, -0.02020309f, -0.06234223f, 
    -0.01297292f, -0.03468296f, -0.14050204f, 0.02225317f, -0.04236104f, 0.00372593f, -0.12054922f, -0.11702389f, 
    0.03285906f, 0.01853332f, -0.06803284f, 0.01231436f, 0.02035214f, -0.03212810f, 0.09135705f, 0.12938222f, 
    -0.05470660f, 0.08826037f, -0.07486057f, -0.12281918f, 0.05958001f, -0.00414714f, 0.02546910f, -0.02085057f, 
    -0.17234658f, -0.06254870f, -0.03014876f, 0.28532237f, 0.14638539f, 0.03036248f, 0.16789100f, 0.09977239f, 
    0.06734164f, -0.11334580f, 0.04753483f, -0.15000664f, -0.09250373f, 0.08701781f, 0.10571313f, 0.13163780f, 
    -0.14910781f, -0.12719837f, 0.12160767f, -0.08531329f, -0.10758243f, 0.02289122f, 0.10526374f, -0.02767175f, 
    0.17142372f, -0.10967445f, 0.21489856f, 0.13706443f, 0.01603561f, 0.00713371f, -0.02114365f, -0.00333361f, 
    -0.05513595f, 0.06666849f, -0.02231334f, -0.02048494f, -0.05199623f, 0.26064828f, 0.00877185f, -0.04101349f, 
    0.02707506f, -0.08935607f, 0.03002705f, -0.14367229f, 0.06887195f, 0.03514076f, 0.08673099f, 0.03247930f, 
    -0.12240727f, -0.00868435f, 0.07722574f, -0.00228094f, 0.11739074f, -0.00734242f, -0.07533114f, 0.01224372f, 
    -0.07385056f, 0.00585844f, 0.04474592f, -0.08657972f, -0.27073592f, -0.10790834f, -0.02690985f, -0.09117687f, 
    -0.04161046f, -0.12652482f, -0.00749768f, 0.01859601f, 0.05184112f, 0.02723691f, 0.00308195f, -0.03110682f, 
    -0.29714674f, 0.11961096f, 0.20848882f, -0.15114914f, -0.07086201f, -0.01084299f, -0.06662843f, -0.02619372f, 
    0.00016019f, -0.03515853f, 0.04761693f, -0.00605726f, 0.18708651f, 0.13869154f, 0.25354418f, -0.02232901f, 
    0.02427862f, 0.04978633f, 0.04299644f, 0.04501285f, 0.00689292f, -0.05157474f, -0.04340256f, 0.03495914f, 
    0.34456986f, 0.02735981f, 0.12650347f, -0.10433770f, 0.13052846f, 0.12359414f, -0.16338901f, 0.06920718f, 
    0.05652100f, 0.02124173f, 0.09054416f, -0.13549472f, -0.00307803f, -0.10364981f, -0.08136597f, 0.24937886f, 
    -0.04349313f, 0.01312997f, -0.07698289f, 0.11524901f, -0.11536023f, 0.05839706f, 0.11457556f, -0.08499938f, 
    -0.01333263f, 0.09266863f, 0.10131729f, -0.15498295f, -0.03787129f, 0.02205993f, -0.00855664f, -0.19048060f, 
    -0.05807744f, -0.09183218f, -0.00818813f, -0.25138661f, 0.03584456f, 0.14648373f, 0.05271302f, 0.06294828f, 
    0.03097868f, 0.03453301f, 0.02787051f, 0.05805107f, -0.00663848f, 0.01516394f, -0.01407037f, 0.04376858f, 
    0.05140023f, -0.19970483f, 0.10036830f, -0.04397349f, 0.03222828f, 0.01106229f, 0.00409647f, -0.04269603f, 
    0.01837034f, 0.04771068f, -0.00874123f, 0.07221156f, -0.13430861f, 0.13001908f, -0.08024643f, -0.06151886f, 
    0.19321373f, 0.08988923f, -0.13944153f, -0.00665943f, 0.02784001f, -0.04918565f, 0.13210748f, -0.11633211f, 
    -0.14085147f, 0.46390626f, 0.15626365f, 0.17473722f, 0.11197135f, 0.08981565f, -0.12607285f, 0.12964776f, 
    0.09181809f, 0.02293527f, 0.03552205f, 0.07737230f, -0.14155719f, -0.11972474f, -0.17593706f, -0.24213152f, 
    0.07042897f, 0.01293675f, 0.09297859f, -0.09052172f, -0.02269256f, -0.01359699f, 0.05649799f, -0.06487366f, 
    -0.05551741f, 0.14929229f, 0.22371519f, 0.07441332f, -0.16268435f, 0.12682927f, -0.03612544f, -0.10676214f, 
    -0.01368366f, -0.03219144f, -0.02225933f, 0.07060485f, 0.40801573f, -0.11317182f, -0.19256671f, 0.14674808f, 
    0.12610768f, 0.02126865f, -0.12817723f, 0.07359951f, 0.06226290f, -0.05756741f, -0.05104025f, -0.04811192f, 
    0.19818556f, 0.20012578f, 0.07523632f, -0.02524789f, -0.11219129f, -0.06469929f, -0.05405667f, 0.02132242f, 
    0.01782412f, -0.01634873f, 0.02284595f, 0.16790915f, 0.07772987f, -0.03367497f, -0.07912714f, -0.06141901f, 
    0.11815598f, 0.05142769f, 0.07683426f, -0.11293072f, -0.14414860f, -0.01587025f, -0.07244214f, -0.01102230f, 
    0.13929190f, 0.06666782f, -0.11871122f, 0.21026348f, -0.03522940f, -0.01381542f, 0.02689917f, 0.07541540f, 
    0.04414180f, 0.04347004f, -0.10163845f, 0.06006365f, 0.59118295f, -0.31489030f, 0.04696891f, 0.03119707f, 
    0.09466939f, -0.00551701f, -0.00663226f, 0.03244989f, -0.04415025f, 0.03186965f, 0.00007990f, 0.11989633f, 
    -0.24858983f, 0.21831153f, -0.01390301f, -0.05836045f, 0.12030966f, -0.12226257f, 0.05871616f, -0.16665600f, 
    -0.06063863f, 0.08658610f, 0.01284792f, -0.08081123f, -0.13920635f, 0.05537182f, 0.04172666f, -0.01325899f, 
    0.01275685f, -0.16484419f, -0.06661183f, -0.04128226f, 0.11569086f, 0.03790898f, 0.09991655f, 0.06226556f, 
    -0.04695836f, -0.00838991f, 0.04590150f, -0.06529607f, -0.01120505f, 0.00158986f, 0.03996088f, -0.03649655f, 
    -0.05201906f, -0.01618546f, 0.03720824f, -0.01315270f, 0.03721108f, -0.07075479f, 0.02501137f, -0.01070543f, 
    0.00139767f, 0.00457167f, -0.06924181f, -0.06776924f, 0.03569129f, -0.07361985f, -0.07478303f, -0.01396837f, 
    0.05441916f, 0.03244343f, 0.02840398f, -0.04991868f, -0.03617332f, -0.02872857f, -0.01424043f, -0.07204629f, 
    -0.00349383f, -0.02189847f, 0.01477010f, -0.06583291f, 0.04163448f, -0.07567845f, -0.02524522f, -0.02760695f, 
    -0.06480612f, 0.04276899f, 0.00637814f, -0.04114687f, 0.02617719f, 0.04346086f, 0.02797637f, -0.05889476f, 
    -0.03432019f, -0.02897817f, 0.05079113f, 0.00794249f, 0.00929107f, -0.00741234f, -0.01634303f, -0.05000302f, 
    -0.04641720f, -0.01773015f, 0.00252695f, 0.02984606f, -0.06284487f, -0.00451633f, -0.02483276f, 0.00135468f, 
    -0.06760248f, 0.03655097f, -0.03724157f, -0.00027726f, 0.01708329f, 0.04449951f, -0.01545887f, -0.04411963f, 
    0.00750183f, 0.04905784f, -0.07680897f, -0.06681751f, -0.00712323f, -0.06927800f, -0.00216639f, -0.03000595f, 
    -0.06436997f, -0.01738361f, -0.00455754f, 0.01793949f, 0.05683723f, -0.06987841f, -0.06213887f, 0.02451762f, 
    0.00485119f, -0.02023052f, -0.05894979f, -0.02004682f, -0.04586660f, -0.05697405f, -0.04499357f, -0.05195765f, 
    0.01052145f, 0.04788626f, -0.06752767f, -0.03061076f, -0.07575623f, 0.01073547f, 0.04691204f, 0.06260511f, 
    -0.04992815f, 0.02939445f, 0.03211612f, -0.05077917f, -0.05830435f, -0.01778986f, 0.02945389f, -0.06987374f, 
    -0.05566474f, -0.05765500f, -0.04387484f, -0.03607827f, 0.03606328f, 0.00195996f, 0.02338639f, -0.02189722f, 
    -0.05712927f, 0.00585643f, 0.01619083f, 0.04381536f, -0.03643649f, -0.00685485f, 0.01855843f, -0.07329933f, 
    0.05686174f, 0.02896635f, -0.07649447f, -0.00903025f, -0.00832333f, 0.00409681f, 0.03278874f, 0.04281823f, 
    -0.02994912f, -0.06270967f, -0.01440366f, 0.00680493f, -0.02822327f, 0.03936158f, 0.03970836f, -0.02703078f, 
    -0.01197263f, -0.02191397f, -0.03383519f, -0.03041349f, -0.05774280f, -0.00076106f, 0.03243293f, -0.00190718f, 
    -0.00629822f, -0.01415544f, -0.02508778f, 0.02741273f, 0.04242504f, 0.01587175f, 0.01111028f, 0.06068465f, 
    -0.01858138f, -0.04975936f, 0.05423816f, -0.02214631f, 0.06084701f, 0.01866788f, 0.01617572f, -0.05014459f, 
    -0.08009806f, -0.07841039f, 0.04584345f, -0.06760646f, 0.05571230f, -0.05946720f, -0.01615736f, 0.05021519f, 
    0.00353228f, 0.02536610f, -0.06754406f, 0.01077387f, -0.03143296f, 0.06062684f, 0.00952080f, -0.02094467f, 
    0.00468132f, 0.02570695f, -0.01506854f, -0.02603366f, -0.02492475f, -0.01196768f, -0.06446669f, 0.05021119f, 
    0.01513557f, -0.01024986f, -0.03828510f, -0.04933092f, -0.03965564f, 0.03287902f, 0.01781610f, 0.00793499f, 
    0.04338303f, 0.06011641f, 0.02421569f, -0.05119121f, 0.05652719f, 0.03234699f, 0.05646022f, 0.02525740f, 
    -0.05152713f, -0.03979991f, -0.07301870f, -0.04254425f, -0.00702349f, 0.04281684f, -0.02623249f, 0.00838252f, 
    -0.02048432f, -0.01712652f, 0.02110771f, -0.04044649f, 0.04977494f, -0.02863679f, 0.05672148f, -0.04671451f, 
    -0.00055222f, 0.05733779f, 0.02113932f, 0.04399214f, -0.03847300f, 0.06358621f, 0.00258457f, 0.00493160f, 
    -0.00616193f, -0.00202146f, -0.03331902f, -0.04159629f, 0.01371931f, 0.05855186f, -0.00767596f, -0.07213156f, 
    -0.00876260f, 0.05007435f, -0.01870554f, -0.07546359f, 0.00820105f, -0.04452149f, -0.02358148f, 0.03282493f, 
    0.02020000f, -0.07147282f, 0.03898451f, -0.01759528f, -0.00295595f, -0.04878045f, 0.06191108f, 0.01144579f, 
    0.00988259f, 0.06513119f, 0.05639441f, 0.03942109f, -0.06568521f, 0.00854922f, -0.01056375f, 0.05486196f, 
    0.01007491f, -0.07521798f, -0.01781207f, 0.00717614f, 0.00736132f, 0.03008926f, -0.02486182f, -0.04427067f, 
    -0.03997262f, -0.01356812f, 0.04063612f, -0.01172516f, 0.02528345f, -0.02581318f, -0.05212167f, 0.05818628f, 
    0.03062347f, -0.05769482f, -0.02238191f, -0.02075408f, 0.06189702f, 0.05611380f, 0.03544971f, 0.05744864f, 
    0.06311462f, -0.01518255f, -0.04600417f, 0.00291327f, -0.03443443f, 0.02554436f, 0.04219056f, -0.01902494f, 
    -0.03898917f, -0.05738955f, 0.06317197f, -0.07691133f, 0.02460844f, -0.03435486f, -0.05357907f, 0.00700292f, 
    -0.06774309f, 0.01727118f, 0.05365333f, -0.01298148f, 0.02654735f, -0.05595733f, -0.05505826f, -0.04785956f, 
    -0.02439176f, -0.05804241f, 0.00878737f, -0.04842494f, 0.02405808f, 0.04308808f, 0.00036697f, 0.01490924f, 
    0.01507595f, -0.06306277f, -0.02573818f, 0.02770946f, 0.01091300f, 0.04218955f, -0.05997567f, -0.07322735f, 
    -0.06767802f, -0.02012407f, -0.01511679f, -0.03533084f, -0.01481473f, -0.01162433f, -0.06664307f, -0.04071468f, 
    -0.02239583f, -0.05907048f, -0.07564680f, -0.05329131f, -0.01312037f, 0.00392131f, -0.06552771f, -0.06184671f, 
    -0.07401942f, -0.03960098f, 0.01839237f, -0.07535205f, -0.05113740f, -0.00666235f, 0.03061658f, -0.00128614f, 
    0.03022343f, 0.05705032f, -0.06940449f, -0.06855889f, 0.04300968f, 0.02716682f, -0.00009390f, -0.05137769f, 
    -0.00073667f, -0.02532423f, 0.02777269f, -0.06653254f, -0.07534926f, -0.03733766f, 0.03570211f, -0.07418982f, 
    -0.06239410f, -0.00779235f, -0.07676027f, 0.04539663f, -0.02204796f, -0.00161328f, 0.02719409f, 0.03257989f, 
    -0.07493909f, -0.05642239f, -0.00138702f, 0.04388467f, -0.05134673f, -0.06567164f, -0.01684682f, -0.01288680f, 
    0.03293550f, -0.07451351f, 0.04434818f, 0.03478054f, -0.06635745f, -0.04952727f, -0.03058781f, 0.03511309f, 
    -0.05267626f, -0.03704383f, 0.05813009f, -0.00437242f, -0.06186637f, 0.04818982f, -0.06258692f, 0.04991572f, 
    -0.02628886f, 0.00701670f, 0.01513317f, -0.05644388f, 0.03835830f, 0.02603324f, -0.03904421f, 0.05852088f, 
    -0.03383892f, -0.06617393f, 0.06388322f, -0.07870582f, 0.01772759f, 0.02204819f, 0.00502961f, -0.03272745f, 
    0.02728834f, -0.03093280f, 0.02213115f, -0.02951691f, -0.02859758f, 0.05422532f, -0.05442752f, -0.07135294f, 
    -0.03605302f, -0.06994152f, 0.00346587f, -0.00358515f, 0.00489890f, 0.00519492f, -0.02186327f, -0.03724279f, 
    -0.07257605f, 0.01935176f, 0.04926056f, -0.08064708f, -0.04508748f, 0.06517597f, -0.03365138f, -0.05461037f, 
    0.05998957f, 0.00949870f, 0.06166058f, 0.02923410f, 0.00950671f, -0.06218896f, 0.00654607f, 0.05596719f, 
    0.02077846f, 0.03567128f, -0.04823432f, -0.02672121f, -0.04550547f, 0.04266813f, -0.03897748f, 0.03040771f, 
    0.02220445f, -0.00308100f, -0.04503979f, -0.07326058f, 0.03316337f, -0.05562172f, 0.06123370f, -0.04764011f, 
    -0.06335248f, -0.00226951f, -0.05873027f, 0.03735494f, -0.03475222f, -0.08241086f, -0.06846222f, -0.06386102f, 
    -0.02571044f, 0.03016757f, -0.05643297f, 0.06025582f, -0.07383370f, -0.00924931f, -0.05526556f, -0.00108752f, 
    0.00568290f, -0.01651996f, -0.02368991f, -0.07968140f, 0.02695983f, -0.02604132f, -0.06299060f, -0.03689123f, 
    -0.01620825f, -0.06658850f, -0.03653578f, -0.04589507f, 0.04240347f, 0.05688283f, -0.03218463f, -0.03255898f, 
    -0.00716006f, 0.01766370f, 0.01475969f, 0.05776037f, -0.04838531f, -0.07243344f, -0.01957353f, -0.03503200f, 
    0.01972995f, -0.03170462f, 0.04719345f, -0.03085748f, -0.05306041f, -0.06032605f, -0.04155845f, 0.03558835f, 
    0.05698498f, -0.02734217f, -0.01171608f, -0.06594149f, 0.02963371f, -0.03692078f, 0.01018411f, 0.03270199f, 
    -0.02573586f, -0.05860198f, -0.07464596f, 0.06169667f, -0.03251652f, -0.04190622f, 0.06034740f, -0.08084987f, 
    -0.06309740f, -0.02643191f, 0.05423229f, -0.07950256f, -0.06227360f, -0.01042606f, -0.06275310f, -0.04232079f, 
    -0.01485973f, -0.05782479f, -0.01502660f, -0.00670423f, -0.07287670f, 0.04070850f, -0.04660176f, 0.03430646f, 
    -0.00554839f, -0.06988918f, 0.01582389f, 0.02142558f, -0.07732526f, -0.07219631f, -0.00330249f, 0.00719442f, 
    -0.06782342f, -0.08018173f, 0.03891159f, 0.03541617f, -0.02342012f, 0.06137512f, -0.05528014f, -0.03563381f, 
    -0.02941570f, -0.01421161f, -0.03039444f, -0.06231083f, -0.00080820f, 0.05289774f, -0.02661553f, -0.07908816f, 
    -0.01059350f, -0.04377791f, -0.05699218f, -0.07885789f, -0.00737511f, 0.03216550f, -0.04358428f, 0.02901896f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11549976f, 0.02825050f, -0.00575319f, 0.01219516f, 0.06241488f, -0.07410262f, 0.06657124f, 0.01921750f, 
    -0.01327966f, 0.08621147f, -0.06076282f, 0.10627545f, 0.14542274f, 0.15758693f, 0.06493839f, 0.02376995f, 
    0.04848594f, -0.00994640f, 0.08319263f, 0.04762539f, -0.06800839f, 0.09372669f, 0.09684842f, 0.03895683f, 
    0.11895833f, -0.02303107f, 0.06307003f, 0.02046195f, -0.00684402f, -0.06215207f, 0.06544425f, 0.09955888f, 
    -0.05633047f, -0.04363489f, 0.04632719f, 0.09189267f, -0.01831805f, -0.08131837f, -0.02336522f, -0.11898826f, 
    0.10704985f, -0.03589009f, 0.06713760f, -0.07722914f, -0.00028518f, 0.03225756f, -0.17996900f, 0.05541692f, 
    -0.01848437f, -0.03652917f, 0.13513325f, -0.02248931f, 0.06220276f, 0.03575940f, 0.01628676f, 0.00677568f, 
    -0.00998191f, 0.04950936f, 0.13166022f, -0.00478592f, 0.00007476f, 0.05596333f, 0.15119018f, -0.03847126f, 
    0.05812059f, -0.04855581f, 0.03614250f, -0.04632540f, 0.06019828f, -0.04443306f, 0.02015402f, 0.14259887f, 
    0.10452405f, -0.03777990f, 0.03291434f, -0.05826479f, -0.03202394f, 0.00423287f, 0.04369283f, -0.02341836f, 
    0.02604248f, 0.11473504f, -0.01836829f, 0.10019090f, 0.07580151f, 0.14760096f, 0.05612135f, -0.01574758f, 
    0.03422201f, -0.05024580f, -0.09337555f, -0.03168477f, 0.04818174f, 0.03619030f, 0.01084585f, 0.05151246f, 
    -0.11188801f, -0.05665221f, -0.04337217f, -0.04016986f, -0.06660711f, 0.03167281f, 0.17631605f, 0.08503759f, 
    0.03844509f, -0.03179568f, 0.01775923f, -0.09568593f, -0.11671267f, 0.01197507f, 0.06404214f, 0.04055434f, 
    0.01642594f, 0.02135646f, 0.03954200f, 0.10021719f, -0.01691943f, 0.13566540f, -0.00797792f, -0.09904334f, 
    -0.04263105f, -0.06278527f, -0.03647178f, -0.05485365f, -0.04322057f, -0.00745272f, -0.06597456f, -0.04598348f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16530810f, 0.03409579f, -0.13258182f, 0.09903062f, 0.08022900f, 0.06997527f, 0.09774686f, 0.21907802f, 
    -0.22278348f, -0.28283131f, -0.06808013f, 0.05751078f, -0.37887716f, -0.15982728f, -0.24401432f, -0.02909558f, 
    -0.02360277f, -0.00026238f, -0.29479623f, 0.05416262f, 0.01462921f, 0.05187799f, -0.37368223f, 0.04808022f, 
    -0.17236745f, -0.04195866f, -0.21865107f, -0.05409373f, 0.02714996f, 0.05441090f, 0.12919787f, -0.00849145f, 
    -0.09315469f, -0.05013326f, 0.06422727f, 0.11903397f, 0.03362647f, 0.17908260f, 0.05684495f, 0.09900441f, 
    -0.17933279f, 0.01877084f, -0.10096768f, 0.02865769f, -0.04573171f, -0.26139823f, 0.15269113f, -0.02979093f, 
    0.04227484f, 0.07549949f, -0.26647851f, 0.08973741f, -0.02041028f, -0.11175217f, -0.03084006f, 0.11075179f, 
    0.03960967f, -0.17545916f, -0.13571098f, -0.31489214f, 0.04926255f, 0.06700949f, 0.04157890f, 0.21139680f, 
    -0.08215100f, 0.03785399f, 0.05976406f, -0.09247447f, 0.05048997f, -0.00671644f, -0.03438325f, -0.15334710f, 
    -0.43610737f, 0.16900209f, -0.40443239f, -0.08212957f, 0.18901226f, 0.07781328f, -0.05785042f, 0.07667943f, 
    -0.29786843f, -0.21412922f, 0.19451080f, 0.01499180f, 0.13610567f, -0.40465784f, -0.18898526f, -0.06197316f, 
    0.06589920f, -0.00958078f, 0.12765288f, -0.18476757f, 0.20362775f, 0.15308438f, 0.14847788f, -0.19239450f, 
    0.19797520f, -0.02402544f, -0.27044120f, -0.02160075f, 0.05424931f, -0.07371610f, -0.05145422f, -0.37459791f, 
    -0.09346947f, 0.05484629f, -0.14876279f, 0.20205389f, 0.23238952f, -0.01104192f, -0.24112485f, 0.00125512f, 
    0.15731592f, 0.19309150f, -0.05917328f, 0.01738212f, -0.03019747f, 0.14887387f, -0.03103917f, 0.42290258f, 
    0.04987609f, -0.01998051f, -0.13253039f, -0.00085677f, -0.29626971f, 0.03692247f, -0.08561415f, 0.01738304f, 
    0.17567462f, 0.13304849f, -0.28289333f, 0.05942032f, -0.14696477f, 0.00124407f, -0.23561819f, -0.26357070f, 
    -0.07426261f, 0.06103469f, -0.08654003f, 0.04849597f, -0.20567314f, -0.31032687f, 0.13712539f, 0.21326311f, 
    -0.07105833f, 0.10441846f, -0.18285118f, 0.10608573f, -0.18058750f, 0.08763562f, -0.03261185f, -0.09628715f, 
    -0.06635764f, -0.05696006f, -0.17857634f, 0.02957283f, 0.02871061f, 0.14605656f, 0.19473676f, -0.44758660f, 
    -0.03105049f, -0.06924217f, -0.09427624f, 0.24868494f, -0.16906464f, -0.17124732f, 0.01739133f, 0.03141819f, 
    0.04761183f, 0.16810903f, -0.31703272f, 0.05288547f, 0.01432049f, -0.07636584f, 0.11917023f, 0.01198774f, 
    0.00436837f, 0.09936284f, 0.05311665f, 0.12758340f, 0.14595123f, -0.01641376f, 0.01375514f, -0.03605977f, 
    0.00109745f, -0.05827574f, -0.27744150f, -0.18685199f, 0.03041945f, 0.03997878f, -0.21525800f, -0.05692695f, 
    -0.00613757f, -0.08849038f, 0.02243460f, -0.03723133f, 0.04153634f, 0.04299245f, 0.15470633f, -0.23489249f, 
    0.39770395f, -0.00864560f, -0.23278579f, 0.01350053f, 0.05210714f, -0.01962713f, 0.11735322f, 0.18550278f, 
    -0.31134081f, -0.16054103f, 0.10373814f, -0.01506456f, 0.23083012f, 0.19871546f, -0.34697667f, 0.09959670f, 
    -0.03501850f, 0.03186175f, 0.15374659f, 0.22472423f, 0.08001576f, -0.00086996f, 0.24009673f, -0.05769802f, 
    -0.05186875f, -0.06874559f, 0.12594672f, -0.02993993f, 0.03798088f, -0.06949381f, -0.22445145f, -0.23285620f, 
    0.02040626f, 0.04786689f, -0.16434227f, 0.16773658f, 0.00600284f, -0.27063784f, -0.03171208f, 0.00491321f, 
    0.18542770f, 0.17000027f, 0.02184297f, 0.01135022f, -0.09263633f, 0.16043329f, 0.07046068f, -0.66723466f, 
    0.15385464f, -0.11960202f, -0.21713707f, -0.20056641f, -0.20331790f, 0.07204323f, -0.05091855f, -0.03276123f, 
    -0.26820758f, 0.05083586f, 0.25776663f, -0.09296590f, 0.11001406f, 0.01962380f, -0.07526910f, 0.23022662f, 
    0.06851804f, -0.44691268f, -0.07490652f, 0.02519789f, -0.34374329f, -0.19809407f, -0.17829388f, -0.04856681f, 
    -0.01492643f, -0.00346615f, 0.04635993f, -0.40185097f, 0.25113189f, 0.01688389f, -0.08038600f, 0.03584879f, 
    0.11192424f, -0.01381326f, -0.26941124f, 0.02953014f, 0.01632930f, 0.23749976f, -0.06688473f, -0.25652516f, 
    -0.03242214f, 0.06541426f, -0.16930646f, -0.03651936f, -0.22747600f, -0.14857817f, -0.08417210f, -0.18046540f, 
    -0.04381858f, 0.06281406f, -0.21103953f, 0.06430142f, -0.04317706f, 0.26051182f, 0.03288107f, 0.13202558f, 
    -0.04817786f, -0.37210798f, -0.12105989f, -0.15282241f, 0.02356066f, 0.12840343f, 0.03513310f, 0.24113286f, 
    -0.09131598f, 0.14458328f, 0.02021979f, -0.14331248f, 0.03992072f, -0.03240361f, 0.16889778f, -0.20994690f, 
    0.01537200f, 0.01056901f, -0.02019498f, 0.06167748f, -0.17758274f, -0.11602271f, 0.12657943f, -0.30383816f, 
    -0.03229786f, 0.21972868f, 0.35505629f, -0.06565281f, -0.17095667f, -0.06086104f, 0.13779466f, -0.32303300f, 
    -0.01807337f, -0.31502780f, 0.14903285f, -0.01990765f, -0.15334217f, 0.01742850f, 0.15622960f, -0.03341192f, 
    -0.05505662f, 0.04414047f, 0.19099393f, -0.17272297f, 0.06622133f, -0.24464391f, -0.18668957f, -0.11924447f, 
    0.21355559f, -0.05353363f, 0.21281783f, -0.03102155f, 0.05679790f, -0.03078405f, 0.11352418f, -0.11232484f, 
    -0.00347874f, 0.03850267f, 0.15795457f, 0.17844774f, 0.20392598f, -0.18141590f, -0.02476939f, 0.22419371f, 
    -0.06651934f, -0.24215204f, 0.27700919f, -0.03600709f, -0.30302215f, -0.11274608f, -0.05419280f, 0.25210238f, 
    -0.52685624f, 0.18190707f, 0.03834679f, -0.13587287f, -0.10044928f, 0.00283602f, 0.04521841f, 0.02244156f, 
    0.06993127f, -0.43477690f, 0.17172891f, -0.38724059f, -0.14471823f, 0.07772406f, 0.07122958f, -0.05375384f, 
    0.27544329f, 0.24689046f, -0.04692718f, 0.26086888f, -0.11495328f, -0.08949903f, 0.03105742f, -0.06297853f, 
    -0.01605335f, -0.23972091f, 0.14113924f, 0.18487217f, -0.09354959f, -0.19850406f, 0.00633433f, -0.00528769f, 
    -0.38061765f, 0.06066249f, 0.07680819f, 0.02166651f, -0.06351156f, -0.43413454f, 0.01965416f, 0.08658424f, 
    0.01446382f, -0.01810616f, 0.07546973f, 0.19452572f, -0.28177136f, 0.08182421f, 0.04410164f, 0.21101852f, 
    -0.49305275f, 0.29849309f, -0.10203264f, 0.07215531f, -0.06402361f, 0.19556527f, 0.09219760f, -0.17475930f, 
    -0.02734373f, 0.05756568f, 0.13763840f, 0.30414900f, 0.14752239f, 0.33597001f, -0.01550061f, 0.03413884f, 
    -0.06229522f, 0.27764961f, -0.02095408f, 0.17682052f, -0.04402149f, -0.01710615f, 0.12290371f, 0.17640331f, 
    0.06657888f, -0.03477844f, 0.04827278f, -0.05237470f, 0.17419097f, -0.06349763f, 0.08629920f, 0.12213223f, 
    -0.23309989f, -0.10202181f, -0.01226857f, -0.06264063f, -0.00725401f, -0.01617924f, 0.15668477f, 0.01739307f, 
    -0.07089863f, 0.01251226f, 0.15556942f, -0.18295826f, -0.46115375f, -0.29984456f, -0.00420045f, -0.63056302f, 
    -0.03936397f, 0.06513777f, -0.31136599f, 0.16819137f, -0.33322862f, -0.22336532f, 0.10058797f, -0.05801033f, 
    -0.41020021f, -0.04131316f, -0.41974166f, -0.04620408f, 0.04877884f, 0.02386136f, 0.24665628f, -0.12232169f, 
    0.03015831f, 0.07089683f, 0.17272574f, -0.29156217f, -0.61200047f, -0.20242314f, -0.03058227f, -0.04529141f, 
    -0.23243514f, -0.02924360f, -0.25654685f, -0.46372315f, -0.22521400f, 0.00860188f, 0.00191837f, 0.18112282f, 
    0.25123999f, -0.21248952f, 0.02682476f, -0.15073706f, 0.04281600f, -0.08070552f, -0.06666093f, 0.06067007f, 
    0.10784393f, 0.13031994f, 0.21754898f, -0.18817420f, 0.11097961f, -0.08521228f, 0.18710601f, 0.26271242f, 
    0.18378876f, -0.04710989f, 0.06054219f, -0.14700779f, 0.17390816f, 0.09682940f, 0.10221479f, -0.15265970f, 
    -0.06041276f, -0.07231985f, 0.03844761f, 0.09706222f, -0.27770844f, -0.24762747f, -0.11599721f, -0.01538065f, 
    -0.46446493f, -0.04499529f, 0.08935896f, 0.06333949f, 0.00447283f, -0.23358940f, 0.20259607f, -0.07900873f, 
    0.07190628f, 0.01479903f, 0.19806781f, 0.08350049f, -0.04000681f, 0.21086702f, 0.05656934f, -0.08808343f, 
    -0.25116941f, 0.07402734f, 0.11102573f, -0.03600183f, -0.06710328f, 0.05484595f, 0.15207474f, -0.01070954f, 
    -0.01796917f, -0.14955223f, -0.12298035f, -0.03379619f, -0.03960044f, 0.07759777f, 0.02545163f, -0.43159777f, 
    -0.00292761f, -0.01561367f, 0.15268274f, -0.05383585f, -0.08687751f, -0.05710124f, 0.22004101f, 0.17375928f, 
    0.04224845f, -0.01699267f, -0.01499574f, -0.00816865f, 0.14494519f, 0.04464661f, -0.07296570f, -0.13320071f, 
    -0.25569174f, -0.15947737f, -0.07604452f, -0.06537198f, -0.18970132f, -0.07462642f, 0.16332257f, 0.08080124f, 
    -0.03083409f, -0.14796877f, 0.02082760f, 0.09952222f, -0.02540941f, 0.15507782f, 0.18134205f, -0.04331562f, 
    -0.05842008f, -0.01064518f, -0.05080849f, -0.16498327f, -0.26533020f, 0.17665085f, 0.00983349f, -0.07247654f, 
    0.07932347f, -0.01361714f, 0.34474838f, -0.07288961f, -0.00198004f, 0.03385590f, -0.08352185f, 0.01943619f, 
    -0.00299784f, -0.01813910f, -0.09164670f, -0.12650196f, -0.18722862f, 0.63068646f, -0.22615150f, 0.05709533f, 
    0.02959662f, -0.02909909f, 0.00556295f, -0.12491294f, 0.02330295f, -0.37749326f, -0.00636559f, -0.08081489f, 
    0.06256683f, 0.35537636f, 0.07952138f, 0.32185546f, -0.21896686f, -0.08800656f, -0.01789800f, -0.05929369f, 
    0.08859216f, 0.10970061f, -0.31221157f, 0.18589644f, -0.17943750f, -0.09371672f, -0.15095116f, -0.51439738f, 
    0.04378410f, 0.10492618f, 0.04683427f, -0.04296627f, 0.28605482f, 0.09917694f, 0.10075311f, 0.14664714f, 
    -0.04073720f, 0.00038753f, 0.16176140f, -0.04353728f, 0.02406258f, 0.11293736f, -0.06104685f, -0.03854140f, 
    0.30675966f, -0.02230545f, 0.17795388f, -0.03431421f, 0.00288194f, -0.02937503f, 0.13153131f, 0.33535835f, 
    -0.04920689f, -0.03186459f, 0.06467852f, -0.35032901f, 0.15003312f, -0.16731898f, -0.09948652f, -0.19973552f, 
    0.11576525f, -0.17313236f, 0.07118420f, 0.08021086f, -0.02387729f, -0.54427737f, -0.08317900f, -0.13166934f, 
    -0.04393114f, 0.10185429f, -0.13199478f, -0.27987677f, 0.17924972f, -0.30016014f, 0.01438669f, -0.02969422f, 
    0.07755283f, -0.04148895f, -0.20819494f, -0.07431325f, 0.03382592f, -0.03987546f, -0.03943150f, -0.04274433f, 
    -0.07387672f, 0.01468993f, 0.06040527f, 0.07319408f, 0.03046611f, -0.02520951f, 0.28010204f, 0.17910609f, 
    0.36000508f, -0.21660639f, -0.14233680f, 0.03855674f, 0.26175433f, -0.07865050f, -0.10014855f, -0.15830231f, 
    -0.09950718f, 0.22994798f, -0.10609496f, 0.02652767f, 0.19666788f, 0.06576502f, 0.10790090f, -0.14219008f, 
    -0.06025704f, -0.04725177f, -0.11894235f, -0.05381345f, 0.05330880f, 0.22188424f, 0.04035665f, 0.11437594f, 
    0.01334722f, -0.06547140f, -0.18133508f, -0.06341052f, 0.04947271f, -0.07307374f, 0.14399472f, -0.04881927f, 
    -0.06406981f, -0.02070092f, -0.00522308f, 0.00153555f, 0.12005915f, -0.41729891f, -0.34096670f, -0.12886293f, 
    0.02337639f, -0.30901310f, -0.31986877f, -0.06620593f, 0.17450993f, -0.15314154f, 0.03592035f, -0.04685570f, 
    0.07088141f, -0.29091349f, -0.39363459f, 0.26964524f, -0.16751768f, 0.00796854f, 0.00374785f, -0.08712694f, 
    -0.09630027f, -0.22981562f, 0.14092243f, 0.12197055f, -0.07688804f, -0.08076353f, -0.17232105f, -0.01529634f, 
    -0.08040413f, 0.12266528f, -0.03579513f, -0.65808785f, 0.11687168f, 0.15852249f, -0.47661754f, -0.26994035f, 
    0.04800038f, 0.11262395f, 0.24606903f, 0.06612521f, -0.06229983f, 0.09163941f, -0.23310073f, 0.03996737f, 
    -0.57368362f, -0.00210256f, -0.34872377f, -0.03016789f, -0.00187586f, 0.21478787f, 0.00313724f, 0.06852148f, 
    0.02240026f, -0.04970813f, 0.07710281f, 0.05802588f, -0.02445755f, 0.11850278f, 0.04747378f, -0.42793247f, 
    0.09090955f, -0.18546626f, 0.15382934f, -0.00058630f, 0.03201702f, 0.03153665f, -0.28898108f, 0.10790541f, 
    0.05750886f, 0.25991184f, 0.09066595f, -0.24301213f, -0.33079165f, 0.17302217f, 0.00738540f, 0.24776796f, 
    -0.08024695f, -0.27483296f, -0.00756358f, -0.01367089f, -0.04376737f, -0.08268237f, 0.03600087f, 0.13221803f, 
    -0.05220359f, -0.01431231f, -0.08577151f, 0.02599793f, -0.09681621f, 0.04154908f, 0.13100131f, -0.33655247f, 
    -0.81096870f, -0.23536722f, 0.24591593f, 0.04368521f, -0.15874411f, -0.05454971f, 0.21252896f, 0.08659648f, 
    0.26717827f, -0.24472988f, -0.59980738f, 0.18403178f, -0.27318835f, 0.19149105f, -0.05434839f, 0.10091754f, 
    -0.04563072f, 0.01205464f, 0.11395182f, 0.06794506f, 0.19044821f, -0.13444893f, 0.13504991f, 0.16312860f, 
    -0.01071582f, 0.04544689f, -0.44844148f, 0.03081284f, 0.05041491f, -0.02017600f, 0.11839410f, 0.15514430f, 
    -0.06255706f, 0.04470057f, -0.25654277f, -0.02876306f, 0.07295206f, -0.28167877f, -0.18192236f, 0.06937035f, 
    -0.18241177f, 0.31324771f, 0.02103093f, 0.28570417f, 0.17626686f, 0.08865900f, -0.02863119f, -0.01054293f, 
    0.06193204f, -0.66477895f, 0.38040680f, -0.25263029f, -0.01443348f, 0.04681644f, -0.06534991f, -0.09026060f, 
    -0.44432613f, 0.08496191f, -0.02281744f, -0.27166480f, -0.15856434f, -0.07073697f, 0.11022546f, 0.04954996f, 
    -0.02001161f, 0.09779836f, 0.04138703f, 0.05047594f, 0.00679266f, 0.15781187f, 0.21270698f, -0.19026414f, 
    0.03719791f, -0.35576779f, -0.22450159f, 0.11714815f, 0.21467897f, -0.25772184f, 0.08076692f, 0.01530574f, 
    0.17217065f, -0.01705603f, 0.18551500f, 0.03143131f, -0.04360174f, 0.03022364f, -0.31667855f, 0.03441970f, 
    0.04866961f, 0.00147484f, 0.10115208f, -0.50935173f, 0.20366180f, 0.15076454f, -0.06588238f, 0.09992970f, 
    -0.13148554f, -0.15673149f, 0.20270647f, 0.03919297f, -0.00300789f, 0.14080980f, 0.20624043f, -0.22417934f, 
    0.02084265f, -0.04338773f, -0.12747446f, -0.09988574f, -0.08888145f, -0.17325675f, -0.00328129f, 0.20093432f, 
    -0.04242675f, 0.19966160f, 0.00399792f, 0.16270056f, 0.05352078f, 0.06760854f, -0.34085292f, -0.04580467f, 
    -0.05398284f, 0.06524625f, -0.03594207f, -0.07912338f, -0.08233935f, 0.00647535f, -0.09294214f, 0.20200832f, 
    0.07727736f, 0.24899906f, -0.20038447f, -0.04888273f, -0.19378366f, 0.02263655f, -0.35262522f, 0.09390488f, 
    -0.27602252f, -0.03797569f, -0.00876809f, 0.14880301f, -0.41200009f, -0.27287370f, 0.16668649f, 0.03538160f, 
    0.07085704f, -0.07646509f, -0.12550992f, -0.08953725f, 0.00427846f, 0.08211794f, -0.23443793f, -0.25339144f, 
    -0.23479864f, 0.04469902f, 0.15484047f, 0.06688493f, -0.04629247f, -0.04431897f, -0.09713376f, 0.12755409f, 
    0.05357705f, -0.03075126f, -0.33021280f, -0.07215469f, 0.10563420f, 0.30011517f, 0.14745790f, -0.29226452f, 
    -0.14193434f, -0.37280518f, -0.18690223f, -0.32545999f, 0.08284994f, -0.04647601f, 0.02509188f, 0.12408827f, 
    -0.06888545f, 0.23486555f, 0.20361914f, 0.25791290f, 0.23050272f, 0.02615890f, 0.07607964f, 0.00206196f, 
    -0.01122171f, 0.13917302f, -0.03001884f, 0.06847914f, -0.40944007f, 0.05689099f, -0.12374883f, -0.29669085f, 
    0.07659110f, 0.11375855f, 0.01839434f, -0.19383468f, -0.12536792f, 0.05486818f, -0.00762341f, 0.11016741f, 
    0.06021537f, 0.19364333f, -0.21033010f, -0.34674269f, 0.23728088f, 0.15214796f, 0.24835137f, 0.01018164f, 
    0.08259546f, 0.03952100f, -0.26961327f, -0.01098127f, 0.02825824f, -0.10616336f, -0.09671488f, -0.02695631f, 
    -0.05733560f, -0.00406048f, -0.35483274f, -0.10199617f, 0.17735544f, 0.21302243f, -0.04213862f, -0.13143757f, 
    0.14290683f, -0.00464381f, 0.27505705f, -0.00424236f, -0.02343881f, -0.19635168f, -0.10586421f, 0.17117557f, 
    -0.04188736f, -0.29862612f, 0.16278493f, 0.16766454f, -0.03900958f, 0.11351265f, 0.09646690f, -0.12880078f, 
    0.01708524f, -0.05193971f, -0.35974696f, -0.38508746f, -0.05169755f, 0.04034685f, 0.04638192f, -0.16104050f, 
    0.02565322f, 0.05972845f, -0.02588976f, -0.07308041f, -0.47816125f, 0.03578875f, -0.16345899f, -0.09731016f, 
    -0.18591972f, -0.11219802f, -0.00148065f, 0.06422457f, 0.06624857f, 0.03122264f, -0.19731085f, -0.34386998f, 
    0.11583654f, 0.29642907f, -0.50594741f, -0.36219761f, 0.06600401f, -0.26513326f, 0.17150381f, 0.18300638f, 
    0.00610592f, -0.08257020f, -0.31457725f, 0.21666735f, -0.00820081f, -0.34328386f, -0.29329410f, -0.24726315f, 
    -0.02863734f, 0.06161118f, 0.27111116f, 0.07334480f, -0.08451030f, 0.07981908f, 0.09524667f, -0.02610989f, 
    -0.04746946f, 0.01656864f, 0.11740113f, 0.08817308f, -0.14260548f, -0.37746915f, -0.20129196f, 0.17474084f, 
    0.09200796f, -0.07441387f, -0.19605571f, 0.00955184f, 0.10784099f, 0.09349428f, -0.05917830f, -0.24408384f, 
    -0.08041931f, 0.29655576f, 0.13865264f, 0.00850008f, 0.21368417f, -0.03189277f, 0.01224758f, -0.01167494f, 
    0.18047620f, -0.11029610f, 0.23206608f, 0.02454764f, 0.20670591f, 0.07390471f, -0.17373201f, 0.28995100f, 
    0.23319548f, -0.07062984f, -0.01864512f, -0.26473287f, -0.22363403f, 0.05775069f, -0.06625157f, -0.36151865f, 
    0.07414750f, -0.02935696f, -0.15491891f, 0.02286684f, -0.32727504f, -0.04512693f, -0.37131086f, -0.08676842f, 
    0.30884615f, 0.00624972f, 0.18402977f, 0.01517513f, 0.00119078f, -0.03961407f, -0.23207526f, 0.21217133f, 
    -0.07319215f, -0.06108038f, 0.09879635f, -0.12506957f, 0.26435268f, -0.31867802f, -0.05270999f, 0.12826875f, 
    0.30437750f, -0.44980946f, 0.26600677f, -0.02670621f, 0.02947976f, 0.07834894f, -0.00131367f, -0.59136730f, 
    -0.06042564f, -0.27243826f, -0.61110663f, -0.10325403f, 0.09358677f, 0.20803146f, -0.02554383f, -0.19675678f, 
    0.02636474f, -0.30684313f, 0.22176446f, 0.13664955f, -0.02692227f, 0.06549025f, -0.18873812f, -0.06627703f, 
    0.06245725f, 0.05902744f, 0.04599463f, 0.03554447f, 0.13792370f, 0.00160348f, -0.52861100f, -0.08304542f, 
    0.21094610f, 0.02684444f, 0.12795718f, -0.03446551f, -0.59206271f, -0.00881331f, 0.05758874f, 0.16959442f, 
    0.09528081f, -0.05162358f, -0.11907930f, 0.07070564f, 0.09994882f, -0.16960445f, 0.04887470f, 0.17247334f, 
    0.01828481f, 0.07665735f, -0.04876436f, -0.07265163f, 0.03152450f, -0.04662739f, -0.18398011f, 0.14036992f, 
    -0.11967345f, 0.01950270f, -0.12671511f, 0.00611049f, 0.03258779f, -0.04733271f, -0.30315387f, 0.21476950f, 
    -0.06092122f, 0.06720699f, 0.16564479f, -0.11627005f, 0.07464883f, -0.64052552f, 0.22981788f, -0.07614469f, 
    0.15101431f, -0.09329107f, 0.18551950f, 0.11976351f, -0.19410531f, -0.14172652f, 0.01971921f, -0.12576529f, 
    -0.12678869f, 0.01759328f, -0.12957126f, -0.11239611f, 0.30425027f, 0.05012545f, 0.06750197f, -0.00522260f, 
    -0.08616146f, -0.47500950f, -0.05014256f, -0.31661040f, 0.02770623f, -0.07815799f, 0.08766347f, -0.16796942f, 
    -0.46531963f, -0.24793246f, 0.02172716f, 0.25232187f, 0.01487916f, 0.16079184f, 0.13234694f, 0.15522164f, 
    0.06353267f, -0.11496808f, 0.09842047f, 0.01255630f, -0.04813747f, 0.21386041f, 0.10328616f, 0.04841411f, 
    -0.00908896f, 0.02936611f, 0.14567271f, -0.05778443f, -0.08087187f, -0.18020251f, -0.28192890f, -0.46650901f, 
    -0.04296358f, 0.02493140f, 0.04640254f, 0.07326467f, -0.44629616f, -0.04579639f, 0.02085068f, -0.13788916f, 
    -0.01965400f, -0.02507166f, -0.02017667f, -0.07543450f, -0.10100216f, 0.14039375f, -0.27395111f, 0.07073587f, 
    0.03062185f, -0.04780431f, 0.28614494f, 0.07187005f, 0.06752639f, -0.10646316f, 0.06586936f, -0.03419133f, 
    0.06158276f, -0.08058006f, 0.15067180f, 0.02792990f, 0.00416254f, -0.08015831f, 0.27978078f, -0.08380619f, 
    0.07165119f, 0.02818922f, 0.06670750f, -0.00349664f, 0.00648050f, -0.00615461f, -0.11233692f, 0.18508068f, 
    -0.22860615f, 0.22052558f, 0.28116888f, 0.07145417f, -0.17789181f, 0.05256671f, -0.26321089f, 0.09380634f, 
    -0.07818279f, 0.02667544f, 0.16917562f, 0.15531269f, -0.28742126f, -0.23594512f, 0.09061040f, 0.17536061f, 
    0.01061935f, -0.08477222f, -0.22687617f, -0.04544283f, 0.18243802f, 0.21833280f, -0.21469869f, -0.31076446f, 
    -0.12708457f, 0.04451860f, -0.17575034f, -0.01971495f, -0.08415516f, 0.04107471f, 0.39391783f, 0.19008242f, 
    0.01645927f, -0.01165506f, 0.21174343f, -0.55359346f, -0.08315805f, 0.13752355f, 0.27870148f, 0.13941267f, 
    -0.11847468f, -0.21089356f, -0.07002448f, 0.08513480f, -0.23619843f, 0.39754301f, -0.04809839f, -0.31412840f, 
    -0.24970455f, 0.11842364f, -0.18498059f, -0.04583525f, -0.11481401f, -0.01593849f, 0.00219416f, 0.07201626f, 
    0.06519302f, 0.04017149f, -0.26547146f, -0.24317998f, 0.15309651f, 0.05281783f, 0.13337407f, -0.12488621f, 
    0.02774610f, -0.01366884f, 0.01062000f, 0.02331561f, 0.10052207f, 0.04149315f, 0.03581621f, 0.24883060f, 
    0.06635685f, 0.11523011f, 0.18674278f, 0.03567291f, 0.26151162f, -0.07498848f, 0.26647428f, 0.06260424f, 
    0.04409049f, -0.00412392f, -0.36542800f, -0.07675099f, -0.00590921f, -0.17632690f, -0.13705091f, 0.27160099f, 
    0.02983195f, -0.09484177f, 0.03154664f, 0.19457307f, 0.01045872f, -0.32345369f, 0.05074656f, 0.20679964f, 
    -0.13397108f, 0.14257021f, -0.27469140f, 0.00549193f, 0.08232849f, -0.12538601f, -0.07492193f, 0.13745563f, 
    -0.03526000f, 0.20599684f, 0.07603090f, 0.08932198f, -0.47946972f, -0.24426195f, 0.02562495f, 0.17257552f, 
    0.07497600f, 0.25739825f, -0.27042049f, 0.14178151f, -0.00968828f, -0.06771682f, -0.01055843f, -0.37516001f, 
    -0.04511371f, -0.04567444f, 0.01207526f, -0.08114710f, -0.25308633f, -0.00854137f, -0.15310593f, 0.20793413f, 
    -0.54132736f, -0.33044952f, -0.23666148f, 0.02460626f, 0.25057194f, -0.02308773f, -0.19290608f, -0.16791269f, 
    0.12605478f, 0.10009073f, -0.17626107f, -0.23465832f, 0.14001945f, 0.24006772f, -0.00958834f, -0.28460920f, 
    -0.07879160f, 0.06044250f, 0.21637017f, -0.01891047f, -0.45069051f, -0.27911147f, 0.13195063f, 0.31774691f, 
    -0.06332999f, -0.07567669f, 0.01661335f, -0.04058604f, -0.00996816f, 0.02490864f, -0.16420144f, 0.10756105f, 
    -0.02050060f, 0.04054831f, 0.11572278f, 0.02705826f, -0.09457842f, -0.18315901f, 0.14204016f, -0.11352167f, 
    -0.38481385f, 0.31991696f, 0.21908195f, 0.21171366f, 0.09401805f, -0.31737509f, 0.07098144f, 0.03594334f, 
    -0.18547133f, -0.28056809f, -0.14644465f, -0.20425420f, 0.18136883f, 0.05455325f, 0.01624288f, -0.04711153f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07788574f, 0.03159272f, 0.02966621f, 0.01879917f, 0.09239689f, 0.02503385f, -0.01817982f, -0.13277280f, 
    -0.07444781f, -0.01964357f, 0.13326742f, 0.05917241f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
