#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.04075003f, 0.30110073f, 1.11607361f, -0.14138973f, 0.24036358f, -0.05752423f, 0.43297327f, 0.20615657f, 
    -0.00064258f, -0.68031281f, -1.17045391f, -0.60511237f, 0.19013041f, -0.77288747f, -0.22887434f, -0.19760917f, 
    -0.01556096f, -0.01938230f, 0.58698130f, 0.87926781f, -1.01761067f, 0.10634769f, 0.33331680f, -0.09227600f, 
    0.60740560f, -0.08657549f, -0.26598197f, -0.51800597f, -0.68314201f, -0.41801503f, -0.26727483f, 0.95323145f, 
    -0.45900559f, -0.16249344f, -0.34417102f, -0.55344009f, -0.66599947f, 1.05277801f, -0.37806076f, -0.02771633f, 
    -0.40793779f, -0.94040716f, -0.13904074f, 0.19689924f, -0.07806751f, 0.39456168f, -0.77142042f, -0.65428835f, 
    -0.80547506f, -0.48442414f, -0.62546402f, 0.09805163f, -0.06418899f, 0.38593963f, -1.00920558f, -0.16329458f, 
    -0.24319707f, 0.38428450f, 0.65441197f, 0.54778999f, 0.14913943f, -0.65470535f, -0.30732369f, -0.15343492f, 
    0.52552295f, 0.17001970f, -0.87198085f, 0.41547537f, 0.70221448f, 0.16067944f, 0.05782431f, 0.68459129f, 
    0.71776998f, 0.14637217f, 0.49348390f, -0.58426553f, -1.09347761f, -0.38808197f, 0.02041362f, 0.47264153f, 
    0.07251766f, -0.60502017f, 0.76732600f, -0.13852629f, 0.02658342f, -0.11815435f, -0.24044403f, 0.65905792f, 
    0.01536350f, -0.55632335f, -0.04551601f, 0.21585345f, 1.07676923f, 0.83713025f, -0.22159031f, 0.06314471f, 
    0.30795813f, 0.12589884f, 0.11627692f, -0.62022471f, -0.68615800f, -0.72616500f, 0.80598783f, 0.58614951f, 
    0.74072945f, 0.11186500f, 0.00544401f, 0.16775313f, 0.87820172f, 0.15208362f, 0.43951094f, 0.91016179f, 
    0.35576674f, -0.25369149f, -0.27622223f, 0.04124826f, 0.19803956f, 0.10823301f, 0.27740076f, 0.61745226f, 
    0.46412551f, 0.87148732f, 0.67737985f, -0.50398654f, 0.20980351f, 0.14095737f, 0.56334186f, 0.98072660f, 
    0.86125916f, -0.53723913f, 0.33565968f, -0.20767938f, -0.44202608f, -0.04340160f, -0.19716910f, -0.68299651f, 
    -0.06403178f, 0.36835590f, 0.68542022f, 1.22871780f, -0.56970227f, 0.17542344f, 0.28591350f, -0.20052414f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02759069f, 0.04278934f, 0.13450617f, -0.36743838f, 0.17601995f, 0.59847784f, 0.25613931f, -0.42795876f, 
    0.08375716f, -0.09272995f, 0.26300490f, -0.20398644f, 0.19393823f, 0.32831922f, 0.27280244f, -0.04230521f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.33354908f, -0.45452952f, 0.18875837f, 0.20931336f, -0.03636667f, -0.16993625f, -0.02891554f, 0.08447552f, 
    -0.22992133f, -0.33446652f, 0.38534787f, -0.15037745f, 0.07278214f, -0.02120143f, 0.05318826f, 0.11176936f, 
    0.03952825f, -0.23196085f, 0.01775474f, -0.10560757f, -0.09076715f, -0.04774063f, -0.25545111f, -0.11942869f, 
    0.06469420f, 0.13311180f, 0.14306505f, -0.18420221f, -0.20357086f, -0.25060910f, -0.10074469f, 0.13386117f, 
    -0.03847783f, -0.22501728f, -0.05815123f, -0.19786184f, 0.16347638f, -0.32374832f, -0.22979245f, -0.07991505f, 
    0.01623463f, 0.09785594f, -0.12914456f, -0.07045577f, 0.12051870f, 0.08694135f, -0.03686248f, 0.03291384f, 
    -0.02873968f, 0.12100984f, 0.15834035f, 0.13207746f, -0.03564509f, 0.22551282f, 0.11158723f, 0.13712765f, 
    -0.00004047f, 0.08784179f, 0.16878498f, 0.14455444f, 0.08934459f, -0.13276753f, -0.00694014f, -0.45076361f, 
    0.19530503f, -0.00253196f, -0.19927420f, -0.15740716f, -0.00229336f, 0.05239565f, -0.02711714f, -0.00810136f, 
    -0.12017474f, -0.63647050f, 0.15023413f, 0.04285026f, -0.15082136f, -0.14320004f, 0.06243742f, 0.02870819f, 
    0.21257412f, 0.18929896f, 0.02483031f, -0.11076763f, 0.05938773f, 0.03096090f, 0.04671768f, 0.22033398f, 
    0.12587669f, 0.06866936f, -0.22827625f, 0.11118588f, 0.01415062f, 0.10353055f, 0.08428158f, -0.17729416f, 
    0.01106571f, -0.07131943f, -0.05773401f, 0.14637932f, 0.39123544f, 0.06671916f, -0.07341267f, 0.07025839f, 
    -0.18165746f, -0.01037803f, 0.25264233f, 0.00818852f, -0.21184868f, -0.14223275f, 0.00381525f, 0.01880972f, 
    0.18973725f, 0.01080070f, 0.02030068f, -0.09764978f, 0.13241853f, 0.17853382f, 0.30037019f, 0.12881818f, 
    0.10436587f, 0.06998707f, -0.07937439f, 0.12850200f, 0.04174609f, 0.14023374f, -0.27839905f, 0.10197695f, 
    0.25757831f, 0.01261398f, -0.08454967f, -0.12457319f, 0.09243760f, 0.00991888f, 0.10695519f, -0.29977998f, 
    0.10619150f, -0.11587258f, -0.16451821f, 0.17253864f, 0.01259643f, 0.17371745f, 0.12621728f, -0.07882787f, 
    0.18399881f, 0.30918983f, 0.26259628f, 0.01079077f, 0.09231651f, 0.14366861f, -0.01001301f, -0.12623948f, 
    0.04783997f, -0.52343309f, -0.22353935f, -0.35612234f, 0.29636568f, 0.06239434f, 0.07670739f, -0.05228664f, 
    -0.02614822f, -0.02334546f, -0.28119710f, 0.08818381f, 0.42670470f, -0.06146558f, -0.15534356f, -0.30061048f, 
    0.06310637f, 0.09562944f, 0.08762024f, 0.02794078f, 0.08264507f, -0.73368847f, -0.08294026f, 0.07948072f, 
    0.06058745f, -0.15767770f, -0.00938066f, -0.22577786f, -0.08919440f, -0.00129058f, 0.09745648f, 0.07228596f, 
    -0.12061612f, -0.17038172f, -0.09655049f, 0.05453818f, 0.33510730f, -0.20261817f, 0.03371612f, 0.28350753f, 
    0.07765602f, -0.08140966f, 0.03218056f, -0.04966904f, 0.21207695f, 0.31569105f, 0.08620112f, 0.24750200f, 
    -0.50908989f, 0.10659917f, 0.20694956f, 0.07618903f, 0.26110318f, -0.12000839f, 0.04590469f, -0.12641689f, 
    -0.11155321f, -0.24540479f, -0.05846484f, -0.02937920f, 0.06183470f, 0.08399735f, -0.18479927f, 0.04974309f, 
    0.22889850f, 0.27809146f, -0.09860501f, -0.47520602f, -0.04426054f, -0.17820551f, 0.07671566f, 0.18010250f, 
    0.15300372f, -0.31036317f, -0.11289231f, -0.05959414f, 0.02506070f, -0.22570109f, -0.20924763f, 0.16487478f, 
    0.04258087f, 0.14921221f, 0.16119160f, -0.44863945f, 0.03967122f, 0.06346795f, -0.10686453f, 0.14381854f, 
    -0.02600293f, 0.00598743f, -0.14491434f, -0.22010964f, -0.05068928f, -0.42948276f, 0.43679577f, 0.39985430f, 
    0.37141573f, -0.31244457f, -0.09557507f, -0.42693526f, -0.17003603f, 0.29222897f, 0.09575853f, 0.01193557f, 
    0.00688138f, 0.00147527f, 0.19053400f, -0.05086859f, 0.05192206f, 0.30752319f, 0.15647945f, 0.28255820f, 
    0.35674340f, 0.19799364f, 0.16566722f, 0.02677849f, 0.17751375f, -0.10272343f, -0.19302513f, 0.21898746f, 
    0.32578275f, 0.05499789f, 0.03274446f, 0.05726898f, 0.04984018f, 0.14832266f, 0.08920356f, -0.38186809f, 
    -0.31208268f, 0.08590970f, 0.19666116f, 0.02471675f, -0.04563352f, 0.17467478f, -0.12863165f, -0.32668135f, 
    0.00325552f, -0.07973139f, 0.03154783f, -0.08784828f, 0.00419739f, 0.01058546f, 0.00996332f, -0.07325685f, 
    0.05680285f, 0.03233643f, 0.03909691f, 0.04884249f, -0.00472455f, -0.02965420f, -0.04994208f, 0.04094200f, 
    0.06465432f, -0.07863030f, -0.08087607f, -0.03327473f, -0.02533870f, 0.00739688f, 0.00011371f, 0.03441584f, 
    -0.08163527f, 0.00185020f, -0.07663631f, 0.03253287f, -0.08781862f, -0.07570969f, 0.03183899f, -0.08019570f, 
    -0.01830219f, -0.04522950f, 0.07085517f, -0.03074740f, 0.00650399f, -0.05907083f, -0.03426947f, -0.02060553f, 
    -0.02810230f, -0.06675232f, -0.02113000f, 0.05810925f, -0.06065359f, -0.00474515f, 0.00703474f, -0.08192098f, 
    0.05445336f, -0.05124110f, -0.01284047f, 0.04546950f, 0.02305029f, -0.02255311f, -0.02725595f, -0.05032991f, 
    0.03622735f, 0.07328958f, -0.04690451f, -0.05924765f, -0.08813437f, -0.04762464f, -0.02294403f, 0.07802624f, 
    -0.03017893f, -0.01342315f, 0.04644182f, -0.05093354f, -0.05781865f, -0.09085876f, 0.02748545f, -0.03049094f, 
    -0.07700022f, 0.00384501f, 0.03852194f, -0.02397571f, 0.05891408f, 0.02727850f, 0.05924289f, 0.03615578f, 
    0.00642340f, 0.01892607f, -0.02650956f, 0.04932667f, 0.02155097f, 0.03695314f, 0.02786655f, -0.02878758f, 
    -0.05545775f, 0.03233175f, -0.05590089f, 0.03686003f, 0.03266082f, -0.05954532f, 0.02459669f, 0.03033756f, 
    0.04650701f, 0.02914555f, -0.02654836f, -0.01892503f, -0.07050651f, -0.08703401f, -0.02691445f, 0.04979076f, 
    -0.04413497f, -0.09466904f, 0.04362779f, -0.01988751f, -0.08958431f, 0.00609862f, -0.04706309f, 0.02602620f, 
    -0.06870516f, -0.07392331f, -0.06165086f, 0.02956352f, 0.04010252f, -0.03158705f, -0.00021588f, 0.04377622f, 
    -0.06779433f, 0.00791765f, 0.01876582f, -0.05938554f, -0.00110238f, -0.08275176f, 0.06456472f, 0.01248416f, 
    -0.07217795f, -0.00783736f, -0.02888633f, 0.04797101f, -0.05665337f, 0.03565716f, -0.01493689f, -0.01494012f, 
    -0.03895919f, -0.07669745f, 0.02660504f, 0.00563945f, -0.04911909f, -0.02277624f, 0.00807337f, -0.00353892f, 
    0.36334491f, 0.29529575f, 0.28998414f, 0.01498445f, -0.23278064f, -0.05767255f, 0.11910781f, 0.10079090f, 
    -0.15745319f, -0.23060763f, 0.09878687f, -0.29317957f, 0.07454424f, -0.04584106f, -0.01357651f, 0.05839986f, 
    -0.11834756f, 0.19504900f, 0.31384489f, -0.34626985f, 0.63652360f, 0.04060077f, -0.20520218f, 0.04460319f, 
    0.01573148f, -0.04210131f, 0.08041637f, 0.02473560f, -0.28459406f, -0.24755701f, -0.07300742f, 0.10161009f, 
    0.17069407f, 0.02215718f, 0.20521407f, -0.04425735f, -0.34762761f, 0.16238162f, -0.17214061f, -0.04149796f, 
    0.29301235f, 0.06917641f, -0.03708319f, -0.07392319f, 0.10668695f, 0.27556768f, -0.31783444f, -0.53657556f, 
    0.05226207f, 0.22356968f, 0.11250395f, -0.06189415f, -0.25557432f, -0.06226139f, -0.44021297f, -0.23163393f, 
    -0.15964738f, -0.03040136f, 0.08917584f, 0.08488066f, 0.08118824f, 0.02155711f, 0.17560521f, -0.10810883f, 
    0.16993578f, 0.12122791f, -0.21890552f, -0.07593001f, 0.05977623f, 0.03751715f, -0.20468959f, 0.08998564f, 
    0.04810516f, 0.21474412f, -0.06755604f, 0.02826742f, 0.01156468f, 0.06345752f, 0.12792322f, -0.13403484f, 
    0.17512195f, -0.29332182f, -0.14966395f, -0.12974396f, -0.02267451f, 0.17147423f, -0.07148489f, 0.09227128f, 
    -0.03604607f, -0.05558859f, 0.42289647f, -0.10617658f, 0.24281284f, 0.04606897f, -0.09768070f, 0.37077537f, 
    0.12940492f, -0.05782676f, -0.11696849f, -0.10538124f, -0.32168245f, -0.00453929f, -0.16042171f, 0.05298033f, 
    0.02498546f, 0.00677658f, -0.07301723f, -0.20060472f, -0.02317389f, 0.21741995f, -0.26331496f, -0.00558625f, 
    0.10543166f, -0.15958521f, -0.04737030f, 0.07841500f, 0.06947400f, 0.08454999f, -0.14346835f, -0.10380023f, 
    0.02583857f, 0.00031186f, -0.14312945f, -0.09904239f, -0.02501381f, 0.01301319f, 0.37323025f, 0.28853279f, 
    0.25541720f, 0.11631049f, 0.00990780f, 0.06218797f, -0.16502889f, 0.14765398f, 0.05692736f, -0.50383586f, 
    -0.32250485f, -0.29504713f, 0.10166337f, 0.12815741f, -0.05722442f, 0.05687345f, -0.22067103f, 0.15076651f, 
    -0.01410485f, 0.03570425f, -0.05825381f, -0.06218345f, -0.11632293f, 0.13782836f, 0.06092310f, -0.12573764f, 
    0.13409710f, 0.12341227f, 0.18946448f, 0.23589361f, 0.30668417f, 0.00219348f, 0.20630109f, 0.00129293f, 
    0.33007118f, -0.01837661f, -0.46334234f, 0.19259389f, -0.20110327f, -0.39851132f, -0.27493790f, -0.07192612f, 
    -0.05000384f, -0.02787373f, -0.16553769f, -0.00243036f, 0.58416480f, 0.24484479f, 0.07444713f, -0.03402194f, 
    0.02957238f, 0.15003429f, -0.11524125f, 0.04319941f, -0.07039988f, -0.26083443f, 0.15898475f, 0.07224368f, 
    -0.26239577f, 0.03356318f, 0.02889451f, -0.20443061f, -0.13867129f, 0.23823069f, 0.07668021f, 0.12644576f, 
    -0.14876524f, -0.01279437f, -0.01167931f, -0.18031591f, -0.05242205f, -0.25340945f, 0.04183875f, -0.01697819f, 
    0.07703117f, 0.25525364f, 0.16879226f, -0.13138683f, -0.10410047f, 0.09804477f, 0.00452856f, -0.42355871f, 
    0.06399941f, 0.25928566f, 0.12278696f, 0.08882759f, -0.11165330f, -0.11806813f, 0.00976626f, 0.01496751f, 
    0.10597480f, -0.49923337f, 0.25945950f, -0.29516920f, -0.18088454f, 0.18144102f, -0.24338476f, -0.06720270f, 
    0.19917813f, 0.07466689f, -0.10286163f, -0.08776326f, 0.09126746f, -0.08550745f, -0.03906068f, -0.11485088f, 
    0.19756296f, -0.04441763f, -0.36620256f, 0.00928369f, -0.09030353f, 0.22137955f, -0.02324343f, 0.03964492f, 
    0.05050551f, -0.05258493f, 0.19466366f, 0.10902020f, 0.09778105f, -0.27675986f, 0.10420117f, 0.32702157f, 
    0.03548615f, 0.16787693f, 0.15597433f, 0.11165422f, 0.21450037f, 0.14243446f, 0.01814669f, -0.07377867f, 
    -0.04296093f, 0.05813077f, 0.10307913f, 0.10081702f, -0.02453967f, -0.16789521f, -0.17253920f, -0.01181926f, 
    0.10435113f, 0.09793678f, -0.17081235f, 0.21367836f, -0.05912353f, 0.14967498f, -0.11769752f, 0.05364711f, 
    0.07578176f, -0.13299912f, -0.04044417f, 0.28490171f, -0.19187564f, 0.01598476f, -0.01839127f, 0.38942528f, 
    0.54730660f, 0.13860360f, -0.15418001f, -0.07450151f, 0.02404091f, 0.03099692f, 0.06392982f, 0.00863149f, 
    -0.61734772f, 0.23474994f, 0.18861684f, -0.02434302f, 0.16425516f, -0.27503651f, -0.15898840f, -0.07708400f, 
    -0.00394886f, -0.18744601f, -0.19646540f, 0.25646469f, 0.18957296f, 0.04354037f, -0.09532398f, 0.17227826f, 
    -0.00277483f, -0.06887120f, -0.27752763f, -0.34260181f, -0.09335672f, 0.00641947f, -0.11397475f, -0.08992680f, 
    -0.05500317f, -0.00877880f, 0.01840574f, -0.16108589f, -0.37712732f, 0.30666199f, 0.18946545f, -0.21871601f, 
    0.01610460f, 0.02769745f, -0.10634607f, 0.01571979f, 0.23457654f, 0.05987858f, -0.13651083f, -0.00424360f, 
    0.23354855f, 0.03712951f, 0.00020502f, -0.08674204f, 0.09200802f, 0.03484816f, -0.05439931f, 0.16188374f, 
    -0.12932715f, -0.00042319f, 0.14454710f, -0.10277342f, -0.05431365f, -0.04572998f, 0.20495175f, -0.06431530f, 
    -0.04445612f, 0.19663301f, 0.12790582f, 0.05426224f, -0.09717494f, -0.08615204f, 0.15818183f, -0.22857323f, 
    -0.25337592f, -0.22884725f, -0.04021797f, -0.12327067f, -0.04181668f, -0.09761715f, 0.08522490f, 0.19893578f, 
    -0.38551459f, -0.12231416f, 0.30900717f, -0.19890893f, 0.10656989f, -0.37275103f, 0.10963105f, 0.05710257f, 
    0.01148143f, 0.23178868f, 0.08732298f, 0.07257593f, -0.19219127f, 0.10069130f, -0.08334292f, 0.00608465f, 
    0.23504387f, 0.25711668f, 0.21566443f, -0.10897209f, -0.38797045f, 0.01322353f, 0.06398082f, 0.05244710f, 
    -0.04630728f, -0.07050500f, 0.08801015f, 0.25065061f, -0.00505354f, -0.18019342f, 0.01214748f, 0.09660009f, 
    0.01193822f, -0.08742929f, 0.02953205f, -0.09601841f, -0.19851986f, -0.00069338f, -0.21000426f, -0.03149866f, 
    -0.02107468f, 0.10722674f, 0.10738835f, 0.00963325f, 0.12294326f, 0.01516340f, -0.10110379f, -0.01920156f, 
    0.28043965f, 0.07370670f, 0.20564122f, 0.33786353f, 0.13961968f, -0.13094814f, 0.04468370f, 0.44138464f, 
    0.49837300f, 0.11634403f, 0.21228930f, -0.04868552f, 0.22193773f, 0.11302541f, -0.05240431f, -0.41551590f, 
    -0.26146835f, -0.31848311f, 0.04815525f, -0.10158239f, -0.03487945f, 0.29981747f, -0.01499739f, -0.09825003f, 
    0.00145406f, -0.06894579f, 0.01334179f, 0.05561630f, -0.01456809f, -0.06985047f, -0.00352518f, -0.05321373f, 
    0.01262253f, 0.03871169f, -0.03677643f, -0.01357148f, -0.08271345f, -0.06421340f, -0.07332939f, -0.07771002f, 
    -0.00030920f, 0.02494445f, 0.04037882f, -0.07076536f, -0.05466670f, 0.07557305f, -0.02742594f, 0.02700656f, 
    0.05575021f, 0.05865033f, -0.00248907f, 0.08229202f, -0.03465936f, 0.00430887f, -0.00105632f, 0.00912538f, 
    -0.06863498f, 0.07964149f, -0.08042988f, -0.00938117f, 0.00462757f, -0.08037873f, 0.01953040f, 0.00120607f, 
    -0.06201797f, -0.05008477f, -0.00616768f, 0.02772330f, 0.06328564f, 0.02711720f, -0.06284975f, -0.04798105f, 
    -0.00170274f, -0.00007782f, 0.01216601f, -0.05669311f, 0.00269889f, -0.07042288f, -0.04234522f, 0.06125266f, 
    0.06486253f, -0.04489801f, -0.06245342f, -0.03908713f, 0.04052819f, 0.00976845f, -0.06268951f, 0.06751873f, 
    0.01659842f, 0.05752018f, 0.06559047f, 0.05279664f, -0.03362024f, -0.07481816f, -0.06088983f, 0.05804899f, 
    0.01270657f, 0.01552018f, -0.02639720f, -0.01667561f, 0.03577366f, -0.05882224f, -0.06954166f, -0.02887712f, 
    0.06477031f, -0.07922756f, -0.03969648f, -0.04036214f, -0.00592424f, -0.02502587f, -0.06033127f, 0.04000548f, 
    -0.05654632f, -0.07752549f, -0.03937647f, 0.05020035f, -0.07380420f, 0.07212138f, -0.02360359f, -0.07397394f, 
    0.01746788f, 0.05940606f, 0.00845054f, -0.06405070f, -0.01125354f, -0.04035118f, -0.02459330f, -0.02591367f, 
    0.04893423f, -0.04133744f, 0.00626742f, -0.04083055f, -0.03272489f, 0.02461256f, -0.03557834f, -0.00059531f, 
    0.06133132f, -0.05128038f, -0.04131738f, -0.01547329f, -0.02432299f, -0.00109152f, 0.07244794f, 0.02243528f, 
    0.06307691f, -0.01462680f, -0.07602532f, 0.00922129f, 0.00417215f, -0.02731549f, 0.07028924f, -0.01611067f, 
    -0.01983132f, -0.01472170f, -0.04598683f, -0.06654289f, 0.01883602f, -0.02145353f, -0.07381718f, -0.08170800f, 
    0.07148196f, -0.00794796f, 0.04667252f, -0.04360527f, 0.06186241f, -0.05352147f, -0.03450121f, -0.05941942f, 
    -0.09887370f, 0.24958794f, 0.04118940f, 0.01881188f, 0.02347491f, 0.05341666f, 0.07993307f, -0.11216332f, 
    0.28285810f, 0.10756671f, 0.17605709f, 0.40235153f, -0.00565429f, -0.04753631f, 0.10428771f, 0.21909121f, 
    -0.00821450f, 0.23378764f, 0.04166504f, 0.12364693f, -0.35698923f, -0.11608065f, -0.03854129f, -0.06509359f, 
    -0.01656374f, 0.07625992f, 0.05619970f, -0.14110163f, -0.06972495f, -0.17640728f, 0.17055723f, 0.14390390f, 
    0.03698901f, -0.16098812f, -0.31140342f, 0.09760541f, -0.42669201f, -0.10659742f, -0.49830785f, 0.18996565f, 
    0.28778321f, -0.12157342f, 0.00849528f, -0.00293495f, 0.07669292f, -0.18121320f, 0.36150154f, 0.03218154f, 
    0.10761512f, -0.15890262f, 0.14542890f, -0.09306206f, 0.02815443f, -0.06197948f, 0.27061123f, -0.29274029f, 
    0.19513156f, -0.02941602f, -0.04083923f, -0.30762494f, 0.09404202f, 0.03880285f, -0.02970857f, 0.35694578f, 
    -0.00500836f, -0.21077248f, -0.22497380f, 0.06779529f, -0.07764861f, 0.07871782f, -0.25659612f, 0.26194331f, 
    -0.07958147f, 0.13932112f, -0.44113633f, 0.16653845f, 0.14680244f, -0.00933457f, 0.05460606f, 0.07303593f, 
    0.07048190f, -0.18838571f, -0.26769975f, -0.27233359f, 0.05281545f, 0.20465162f, -0.23478708f, 0.21939285f, 
    -0.06757030f, 0.19877546f, 0.26531672f, 0.47539216f, 0.03007368f, -0.06115565f, 0.07521650f, -0.05201393f, 
    0.00208706f, -0.04031050f, 0.02891839f, -0.00382980f, 0.20669106f, 0.38998845f, -0.18039244f, 0.14771281f, 
    0.04548999f, -0.10620166f, -0.14874725f, -0.07441887f, -0.11534685f, 0.08675119f, 0.11844209f, 0.12463917f, 
    0.00963237f, -0.09405122f, 0.07028981f, 0.00227423f, 0.35742378f, 0.39553320f, 0.05417683f, -0.03320990f, 
    0.01232476f, -0.22830947f, -0.03801347f, 0.14900786f, 0.19139861f, 0.13272499f, -0.34322411f, -0.08805460f, 
    -0.09213699f, 0.20155972f, 0.01141903f, 0.15451686f, -0.04311653f, 0.10647711f, -0.16406839f, -0.09187437f, 
    -0.30328393f, -0.19782148f, -0.02944536f, -0.02474279f, 0.12160132f, 0.16838783f, 0.07624663f, 0.05231160f, 
    -0.71573263f, -0.42783180f, 0.29474872f, 0.20260325f, 0.16294552f, 0.08949076f, -0.05435175f, 0.02748538f, 
    -0.04421294f, 0.25488105f, -0.04174738f, -0.04349977f, 0.13169841f, -0.07180654f, -0.11687116f, -0.10231959f, 
    0.03603516f, 0.01186808f, -0.01685210f, -0.03614279f, -0.09794537f, -0.18936436f, 0.00233332f, -0.09172036f, 
    -0.15275472f, 0.15523776f, -0.01321201f, -0.17371131f, 0.25509301f, 0.25818130f, 0.08080956f, -0.07524911f, 
    0.15445270f, -0.02505306f, -0.10879523f, -0.24476622f, 0.55553043f, -0.01190404f, 0.09524641f, 0.06357497f, 
    -0.07886320f, -0.08055726f, -0.05348473f, 0.02024719f, 0.00179001f, 0.23420797f, 0.29299027f, -0.15800145f, 
    -0.18451574f, -0.09264503f, -0.06878932f, 0.11328100f, 0.07859445f, 0.08192895f, -0.03710362f, -0.08359980f, 
    0.01290053f, 0.07718457f, -0.12516932f, -0.11468260f, 0.09772114f, 0.11369558f, 0.03466292f, -0.29017287f, 
    -0.28296712f, -0.16861877f, -0.07317346f, -0.17408752f, 0.00234631f, -0.06844746f, 0.09283245f, -0.06166703f, 
    0.11361564f, -0.35760212f, 0.01073930f, -0.02653076f, -0.07720514f, -0.00327173f, 0.02743242f, -0.05817861f, 
    -0.13101512f, 0.27835953f, -0.02826531f, -0.01455427f, 0.17558870f, 0.10401685f, -0.09834176f, 0.23926196f, 
    -0.02316622f, -0.16559273f, 0.10723808f, -0.35785544f, -0.17996252f, 0.16845727f, -0.17220700f, 0.20693965f, 
    -0.09725448f, -0.04063329f, -0.09814629f, 0.16110137f, 0.11933603f, -0.04231643f, 0.13764900f, -0.01670919f, 
    0.17675981f, -0.05142530f, 0.21923363f, 0.15840441f, -0.17299940f, 0.26032224f, -0.16686228f, -0.00810321f, 
    -0.00149021f, -0.01796583f, 0.07126912f, 0.25147080f, 0.04977889f, -0.07508270f, 0.07752265f, -0.11647223f, 
    -0.07875609f, 0.12800696f, -0.00444347f, -0.03026914f, 0.10852290f, -0.02967292f, -0.13203609f, -0.61929220f, 
    -0.24190746f, 0.15493579f, 0.18629293f, 0.16476184f, -0.10615338f, -0.17990218f, 0.01205973f, 0.24916260f, 
    0.01223113f, -0.27942526f, 0.05595483f, -0.10927666f, -0.09146637f, 0.06060384f, 0.13707493f, 0.22811018f, 
    0.11378803f, 0.07189623f, -0.19690305f, 0.11316703f, 0.14207655f, -0.10589069f, -0.07016905f, -0.19346151f, 
    0.02607516f, -0.46618471f, -0.11168195f, 0.22370622f, 0.18904799f, -0.12240024f, -0.04045658f, -0.00131217f, 
    0.05062055f, -0.05328396f, -0.32295465f, 0.46572724f, 0.19432460f, -0.16724484f, -0.15622357f, -0.08982310f, 
    0.02367262f, 0.27203032f, -0.03806810f, -0.13010234f, -0.18345354f, 0.32468998f, 0.00451753f, 0.11377238f, 
    0.13684280f, -0.09862422f, 0.00574493f, 0.21492800f, -0.15534513f, -0.06823567f, -0.43265951f, -0.03748277f, 
    -0.03361830f, 0.02195924f, -0.03951370f, 0.13472258f, 0.03431346f, 0.17092100f, 0.15300211f, -0.02392938f, 
    0.01473460f, 0.18918093f, -0.08161419f, -0.05450327f, -0.01748309f, 0.04350192f, -0.27038106f, 0.16806529f, 
    0.12927188f, 0.03232110f, -0.12701596f, 0.28934669f, 0.00845935f, 0.13656574f, 0.09493729f, -0.16894580f, 
    -0.02574300f, 0.17507994f, -0.08715180f, -0.03289699f, 0.07536570f, -0.03135965f, 0.08733147f, -0.04603677f, 
    0.00838501f, 0.11791934f, -0.39941290f, 0.15978865f, -0.16313429f, -0.17965727f, 0.09491435f, 0.18014310f, 
    -0.11660042f, -0.19955233f, 0.22037739f, 0.03265701f, -0.10382302f, 0.03776764f, -0.06726416f, 0.02905769f, 
    -0.04004405f, 0.28680906f, -0.02656675f, -0.28561836f, -0.29257131f, -0.05707937f, 0.21423702f, 0.03265586f, 
    -0.05614373f, -0.09623685f, -0.10271140f, 0.09750284f, -0.14023072f, 0.57577318f, -0.10511740f, 0.13461806f, 
    0.07728817f, -0.08787989f, -0.12764071f, 0.09917959f, 0.53164387f, -0.03678001f, -0.17361423f, 0.11142007f, 
    0.06488912f, 0.12458663f, 0.04289229f, 0.03246510f, -0.18436877f, -0.13512266f, 0.07681146f, -0.07295413f, 
    0.08391061f, 0.15226398f, 0.09140783f, 0.17616841f, -0.05730514f, 0.11099134f, -0.06571353f, 0.47304726f, 
    -0.30233476f, -0.00343975f, 0.09790519f, -0.02239636f, -0.16276701f, 0.11510215f, -0.05588214f, 0.31419164f, 
    0.15732564f, -0.15781994f, 0.08312779f, -0.27585131f, 0.05925000f, 0.04180750f, 0.00083811f, -0.22178021f, 
    0.46070191f, -0.11923147f, 0.20469932f, 0.18739662f, -0.14137471f, 0.07288114f, 0.08593104f, 0.33731559f, 
    0.08987817f, 0.30563083f, 0.23461741f, -0.20995058f, -0.08140873f, -0.00926176f, 0.02344926f, 0.18525207f, 
    0.06025181f, 0.11634290f, 0.13455257f, 0.04644891f, 0.11541724f, 0.22571516f, 0.13510793f, -0.22304636f, 
    0.18891640f, 0.01828290f, 0.00915424f, -0.50245935f, -0.14099209f, -0.29956710f, 0.00837003f, -0.20137998f, 
    0.11573216f, -0.34592566f, 0.10873437f, 0.17500055f, -0.02208730f, 0.03397346f, -0.10657187f, 0.02867624f, 
    0.01688190f, -0.26190788f, 0.15477307f, -0.14078324f, 0.03857475f, -0.08531758f, 0.33220378f, -0.21353620f, 
    0.32626799f, -0.01801603f, -0.10387065f, 0.21137005f, 0.21052712f, 0.02504549f, -0.43730313f, 0.14851001f, 
    0.23492891f, 0.07328536f, 0.00101332f, -0.02476277f, -0.06577840f, 0.17927688f, 0.04379526f, -0.58722615f, 
    -0.06372492f, -0.17461616f, -0.28369850f, 0.22512053f, 0.16221955f, 0.10579180f, -0.12244756f, -0.34516495f, 
    0.12581040f, -0.14449139f, -0.21437488f, 0.10691279f, 0.03795190f, 0.01301884f, 0.35657582f, 0.10910682f, 
    -0.28519249f, 0.09074953f, 0.04646641f, -0.06491895f, -0.38347888f, -0.11968955f, 0.00326216f, 0.00457250f, 
    0.23296255f, 0.14964785f, 0.20247914f, -0.29574221f, -0.03401241f, 0.07258274f, 0.11618813f, 0.13041313f, 
    0.05551342f, 0.06715207f, -0.10884649f, 0.02615062f, -0.04633642f, 0.04965220f, 0.10703644f, 0.12909804f, 
    0.02080647f, -0.09223907f, -0.30570993f, 0.00250202f, 0.08483401f, -0.31108469f, -0.08500826f, 0.23202641f, 
    0.03198927f, 0.05360091f, -0.04939408f, 0.25278723f, -0.07475137f, -0.56668049f, -0.25441882f, -0.23383589f, 
    0.30480263f, 0.24434909f, 0.21713075f, 0.07195073f, 0.18159392f, -0.08912741f, 0.93834996f, 0.21549885f, 
    -0.23434561f, 0.02491998f, 0.02980977f, -0.09853449f, 0.03156566f, -0.06130457f, 0.19754429f, 0.00924231f, 
    -0.22286612f, -0.03583268f, 0.02995327f, 0.06876615f, -0.10991991f, -0.13608022f, 0.11265404f, 0.05012905f, 
    0.14568856f, 0.09010208f, -0.11068245f, 0.30680710f, -0.05591947f, 0.04314479f, -0.00927364f, 0.14134684f, 
    0.11493520f, 0.12768622f, -0.13400480f, 0.28930774f, -0.37033075f, -0.11203783f, 0.03865141f, 0.05962140f, 
    0.15580121f, 0.13260423f, -0.08599473f, -0.11154868f, -0.60775876f, 0.02236783f, 0.03960323f, 0.25542992f, 
    -0.03324063f, -0.20319965f, 0.00858192f, -0.64757079f, 0.23355144f, 0.02825452f, 0.05968292f, 0.06164718f, 
    0.01363573f, 0.18257460f, -0.06240093f, -0.04144457f, -0.18307845f, -0.48247752f, -0.55369467f, 0.05781340f, 
    0.03473474f, 0.03369226f, 0.06410859f, 0.12031586f, -0.27030712f, -0.39164180f, 0.34813440f, -0.22864917f, 
    0.07934449f, 0.08913761f, 0.15276276f, 0.04850404f, -0.02929377f, -0.13381884f, 0.05089165f, -0.12530176f, 
    0.09212264f, -0.21747306f, 0.11260386f, -0.17514840f, -0.00693919f, 0.02172663f, -0.09402961f, 0.21192658f, 
    -0.00619903f, 0.02716649f, -0.07963931f, -0.08885535f, -0.07941554f, -0.15311781f, -0.04818657f, 0.01175376f, 
    0.42217949f, -0.01581097f, -0.03207054f, -0.01413943f, 0.10090315f, -0.03005730f, 0.17916656f, -0.19605477f, 
    0.06575474f, -0.03185524f, -0.01706949f, -0.29119778f, -0.09462400f, -0.03660316f, -0.24694501f, 0.00984582f, 
    -0.10153583f, 0.03825471f, 0.31314841f, 0.04524352f, 0.19595167f, 0.12951834f, 0.15875079f, -0.07330550f, 
    -0.00645612f, -0.06590007f, 0.02882234f, 0.08570283f, 0.10145813f, 0.52801138f, -0.35452142f, -0.31710714f, 
    -0.07114520f, 0.00750279f, 0.11632961f, 0.15681520f, 0.18793137f, 0.10288844f, 0.08390141f, -0.08961812f, 
    -0.00337781f, 0.07035831f, 0.00001354f, 0.18645993f, -0.05195753f, 0.46280423f, 0.18681210f, 0.37006968f, 
    -0.19147031f, -0.06996827f, 0.05288806f, 0.10542393f, 0.13463585f, -0.19096674f, 0.09899740f, -0.22192313f, 
    -0.01992272f, 0.19759884f, 0.09494627f, 0.04643638f, 0.01249350f, 0.07135590f, -0.13241845f, 0.02701174f, 
    -0.08109152f, 0.12638183f, -0.16993137f, -0.05923958f, 0.02324137f, 0.11194792f, -0.04064040f, 0.03464701f, 
    -0.28102124f, 0.00499632f, 0.12450806f, 0.11258029f, 0.12673660f, 0.25767466f, 0.06762768f, -0.17617805f, 
    0.04828215f, 0.08006718f, -0.49838266f, 0.13810463f, -0.17546763f, -0.04376224f, 0.06193132f, -0.08553938f, 
    -0.18064752f, 0.09886438f, 0.16306821f, -0.13736333f, 0.19255753f, -0.06885398f, -0.07011004f, 0.07292140f, 
    -0.26013026f, -0.00696360f, -0.20824900f, -0.18824704f, 0.11162934f, 0.37106180f, -0.28921685f, -0.09733346f, 
    0.08622842f, -0.20908409f, 0.08700576f, 0.26248288f, 0.54190379f, 0.07025836f, 0.17739819f, -0.14248680f, 
    -0.09393146f, -0.00762229f, 0.13220601f, 0.08559483f, 0.08262860f, 0.24965546f, -0.09623891f, 0.24949761f, 
    0.06924435f, -0.01697406f, -0.05914968f, 0.11457571f, 0.20652655f, 0.05737810f, 0.13274695f, 0.13758820f, 
    -0.25518522f, -0.27940035f, 0.25527021f, -0.01470604f, 0.03327375f, 0.23857166f, 0.13430165f, -0.31764746f, 
    0.20618558f, -0.13741033f, -0.03064207f, -0.05013286f, -0.06806552f, 0.01471223f, -0.12553032f, -0.30088928f, 
    0.07849054f, -0.29014510f, 0.18538018f, 0.14348583f, 0.17592649f, -0.28402513f, 0.00527463f, 0.07097892f, 
    -0.19123156f, 0.67406523f, 0.20093046f, -0.03078275f, 0.04926757f, -0.19837022f, 0.18195172f, -0.08893040f, 
    0.02508525f, -0.03685921f, -0.03419705f, -0.09991663f, -0.07770818f, 0.06228392f, -0.04817493f, 0.14412932f, 
    -0.05720639f, -0.00181998f, -0.28152826f, 0.18804708f, -0.04765338f, 0.07310531f, -0.06142134f, 0.03457309f, 
    -0.05706771f, 0.00894320f, -0.01741141f, 0.14504343f, -0.54431295f, 0.04768352f, -0.09505334f, -0.07084949f, 
    -0.05986907f, 0.26457343f, -0.02059140f, 0.02168410f, -0.04577805f, -0.43350133f, -0.05048888f, 0.02553989f, 
    0.10642935f, 0.05391500f, 0.22373249f, 0.04970044f, -0.15057863f, -0.29508051f, 0.12786148f, 0.16370158f, 
    0.23567161f, 0.30620113f, 0.01921336f, 0.03868487f, -0.06755767f, -0.17529993f, -0.07861397f, 0.24592850f, 
    -0.12291107f, 0.04474080f, -0.02024834f, -0.06493409f, 0.10655053f, -0.07565953f, 0.07081879f, -0.13686964f, 
    -0.09195293f, 0.00360602f, 0.06783202f, -0.03190602f, -0.07898935f, -0.03501619f, -0.07419785f, 0.03331006f, 
    -0.05524102f, 0.03935282f, 0.00537588f, 0.01584314f, 0.02105799f, -0.07613659f, -0.08812723f, 0.03813726f, 
    0.02296442f, -0.03205729f, 0.03537076f, 0.01171493f, 0.05145768f, -0.03844281f, 0.01921337f, 0.05419141f, 
    -0.08106653f, 0.01441477f, -0.08933380f, -0.01264815f, 0.04478798f, 0.00762023f, 0.00169010f, 0.04616367f, 
    -0.06362330f, -0.01377477f, 0.01832411f, 0.01903301f, -0.00730335f, -0.06355447f, -0.05750931f, 0.02544309f, 
    -0.07096301f, -0.06279086f, -0.06830061f, -0.02948528f, 0.01947724f, 0.05478429f, 0.00492663f, 0.04744389f, 
    -0.00982574f, 0.01312671f, 0.01278800f, 0.01532334f, 0.01381734f, 0.07118743f, -0.06566393f, -0.02522960f, 
    0.00365638f, -0.06763432f, 0.05279271f, -0.04453962f, 0.03717064f, 0.02645712f, 0.02449688f, -0.04581117f, 
    0.01326600f, -0.04168767f, -0.03917686f, -0.05777205f, -0.06024043f, 0.05584696f, -0.06742834f, 0.07227787f, 
    -0.03689997f, -0.04341749f, -0.05475207f, -0.01274545f, 0.01199124f, 0.03099624f, -0.06634207f, 0.02580670f, 
    -0.03646382f, -0.08207016f, -0.07804498f, 0.02869138f, -0.07845547f, 0.00158222f, -0.06064049f, 0.05713081f, 
    -0.01005722f, -0.01020073f, -0.03513374f, 0.04434170f, -0.07897254f, -0.02182619f, -0.02727812f, -0.04119060f, 
    -0.06583311f, 0.03529898f, -0.06572159f, 0.04789715f, 0.05982547f, -0.08299711f, 0.03834624f, -0.00581962f, 
    -0.00964137f, 0.01938666f, -0.00988462f, 0.06671361f, -0.08064269f, -0.01175535f, -0.03615346f, -0.07689165f, 
    -0.01302124f, -0.07875533f, -0.08907531f, 0.06434112f, 0.03771997f, 0.06970740f, -0.00700829f, -0.01638021f, 
    -0.00355643f, -0.07427283f, -0.01227812f, -0.02286227f, 0.01739367f, -0.03040314f, 0.01515356f, -0.02377568f, 
    -0.02188599f, 0.01507215f, -0.04656361f, 0.02333965f, 0.07063267f, 0.00302324f, -0.06337129f, 0.06871933f, 
    0.04029547f, -0.08722960f, 0.05994160f, 0.03872634f, -0.02841084f, -0.00460638f, -0.06902218f, 0.04897432f, 
    0.46052876f, -0.07360028f, -0.10031720f, -0.10616548f, -0.22117417f, -0.11245799f, 0.12045515f, -0.01576299f, 
    0.11852346f, 0.08120022f, 0.15553626f, 0.16470976f, 0.05990905f, -0.02311982f, -0.02850165f, 0.12234288f, 
    0.20623024f, -0.01815283f, 0.10458929f, 0.03000215f, -0.04757927f, 0.01705992f, 0.10860221f, 0.15286577f, 
    -0.12035634f, 0.05301249f, 0.15305091f, -0.00700299f, -0.20649604f, -0.38844016f, -0.05598174f, 0.11840929f, 
    0.07089278f, 0.10751239f, -0.12119825f, -0.14279982f, -0.31071287f, -0.42408776f, -0.30936056f, 0.21911275f, 
    0.02451200f, -0.02247577f, 0.09223630f, 0.11552574f, -0.05652802f, -0.40827623f, -0.11354654f, 0.18561888f, 
    0.16080254f, 0.14482744f, 0.23529033f, 0.04438696f, 0.01329676f, 0.07846493f, 0.17680196f, 0.19967698f, 
    -0.07159946f, 0.00228270f, -0.06019834f, 0.02463486f, 0.11658524f, 0.13593376f, 0.01220997f, -0.03084265f, 
    -0.27307072f, -0.53388160f, -0.13551949f, -0.46521401f, -0.27260473f, -0.10251809f, -0.00104680f, 0.06265716f, 
    -0.09877677f, 0.00663127f, 0.19148234f, -0.19630828f, -0.16960546f, -0.11488587f, -0.09132657f, 0.12908235f, 
    0.19578260f, -0.31211677f, -0.28115487f, -0.11198744f, -0.16864806f, 0.24003750f, 0.25737149f, 0.11332038f, 
    -0.19419041f, -0.09211606f, -0.28233275f, 0.26144812f, 0.27640751f, 0.06695697f, 0.09046683f, -0.17924693f, 
    -0.09754262f, 0.12597430f, -0.07917075f, 0.16119991f, -0.09782454f, -0.43925762f, 0.03407498f, 0.07728928f, 
    0.15108179f, -0.02339896f, -0.21949668f, -0.11914957f, 0.16138543f, -0.08672047f, 0.03552086f, -0.19160865f, 
    0.00941471f, 0.01360015f, 0.06310871f, 0.17024425f, 0.14931858f, 0.42370325f, 0.21617344f, 0.25446290f, 
    -0.14090784f, 0.00604814f, -0.30268529f, 0.07470788f, 0.19466683f, -0.07875960f, 0.23991783f, -0.03122533f, 
    0.11440606f, -0.25783738f, -0.09218579f, 0.13629971f, 0.10283818f, 0.05136986f, 0.11908673f, -0.19525278f, 
    0.16502178f, 0.23577356f, -0.00657623f, 0.07875314f, -0.12792410f, -0.09975909f, 0.04523558f, 0.06830902f, 
    -0.85508287f, 0.02715899f, 0.02460223f, 0.17078024f, 0.13664144f, 0.01100355f, -0.02618848f, 0.09445473f, 
    0.00090945f, -0.35897449f, -0.01978308f, 0.02139251f, -0.24715336f, 0.01092251f, 0.09284905f, 0.03354878f, 
    0.21553123f, 0.02468876f, 0.07909423f, -0.13289542f, -0.09246887f, -0.13081402f, 0.02855184f, -0.05516414f, 
    0.02183404f, 0.00437508f, 0.04247957f, -0.11165378f, -0.32404646f, -0.11767362f, -0.04625710f, -0.02855784f, 
    -0.05015480f, 0.02261993f, -0.09769764f, -0.25154752f, 0.26448587f, -0.26332203f, -0.09258548f, 0.07651629f, 
    0.00990422f, 0.03005978f, -0.08144820f, 0.03725512f, 0.08179019f, 0.31502840f, -0.17272744f, 0.07496773f, 
    0.01509706f, 0.16010107f, 0.05820466f, -0.01077192f, -0.07830127f, -0.11649907f, 0.44438007f, 0.17892581f, 
    -0.16508015f, -0.06498161f, 0.09003331f, 0.03857367f, 0.09083083f, -0.05827354f, -0.00454494f, -0.27184179f, 
    -0.04605009f, -0.36036915f, -0.14933892f, -0.18054126f, 0.04213429f, 0.31126118f, -0.03228775f, 0.07155926f, 
    -0.27964503f, 0.45727533f, 0.16908267f, 0.17809172f, -0.02495497f, -0.07958460f, -0.13051577f, 0.03207891f, 
    0.09078351f, 0.18434586f, -0.01313928f, -0.01120042f, 0.21074313f, -0.06654832f, 0.21932140f, 0.05721232f, 
    0.08619542f, -0.05043276f, -0.50227118f, -0.01287708f, -0.16897896f, 0.19242087f, 0.20594174f, -0.06299286f, 
    0.01546756f, -0.15155776f, 0.32621542f, 0.53024745f, 0.23955853f, 0.03145877f, -0.18428019f, -0.04421577f, 
    0.02720900f, 0.15279599f, 0.01018475f, 0.14520700f, -0.81797600f, -0.70476002f, 0.04293776f, -0.03232381f, 
    0.19766788f, 0.03936969f, 0.06498716f, 0.04287765f, 0.06213516f, -0.05003599f, -0.06876545f, 0.10477238f, 
    0.00546724f, 0.05764959f, -0.03514599f, 0.03546643f, -0.00781508f, 0.30490899f, 0.29347646f, 0.06693943f, 
    -0.18876047f, 0.14521629f, 0.13936955f, 0.16382618f, -0.30034107f, -0.10446215f, -0.22920628f, 0.38740870f, 
    -0.18394454f, -0.11841378f, -0.08535486f, -0.00268956f, 0.01220547f, 0.05557368f, 0.11159758f, -0.00828144f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.28181443f, 0.17171787f, 0.00734761f, 0.17199793f, -0.14966112f, 0.15308382f, -0.02213655f, 0.18797491f, 
    -0.07641849f, -0.05795856f, 0.25118867f, -0.03688712f, -0.04654200f, -0.09127235f, 0.25271514f, 0.29127076f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14589682f, -0.09711951f, 0.00305263f, -0.03850219f, -0.01577897f, -0.66029608f, 0.01422250f, -0.15192243f, 
    0.53609532f, 0.42408961f, 0.03881519f, 0.15298924f, 0.15931575f, 0.15563039f, -0.61324912f, 0.76063275f, 
    -0.16218334f, 0.00840198f, -0.23938462f, -0.72716516f, 0.23025200f, -0.64339131f, 0.13487515f, -0.12601593f, 
    -0.01436124f, 0.01828276f, 0.47432464f, -0.12602173f, 0.15619650f, 0.05670142f, 0.32629570f, 0.01526851f, 
    0.20212278f, -0.12306881f, -0.15042523f, -0.08545468f, -0.16630694f, -0.47116041f, 0.09236521f, -0.22695893f, 
    -0.08759971f, -0.14368412f, 0.65827096f, 0.16923445f, 0.16753100f, 0.18890744f, -0.28809565f, -0.02987016f, 
    0.00830024f, 0.10302879f, 0.22360541f, 0.23491320f, 0.13712065f, -0.04471165f, -0.16377124f, -0.18681985f, 
    -0.01814764f, 0.11002941f, 0.29499283f, -0.32009819f, 0.05709027f, -0.07744757f, -0.65084630f, 0.57463956f, 
    -0.21902889f, -0.00435886f, -0.06482023f, -0.18249877f, -0.31405070f, -0.04798918f, -0.22929955f, -0.09736180f, 
    0.23185249f, 0.53374439f, 0.18530715f, 0.17216754f, -0.30600151f, 0.00133393f, -0.06777502f, 0.01744017f, 
    0.26681179f, -0.28549758f, 0.09127858f, -0.07164189f, 0.45308831f, -0.09383852f, -0.19023517f, 0.27275610f, 
    0.04331300f, -0.46308103f, -0.31174877f, 0.65146440f, 0.25638843f, -0.24557906f, 0.33060634f, 0.86618412f, 
    -0.22843648f, 0.23250496f, -0.22751829f, 0.16357641f, 0.22264403f, -0.16693501f, -0.08358723f, 0.40663600f, 
    -0.66425002f, -0.78101784f, 0.28657967f, -0.04514595f, 0.02645862f, -0.09169769f, 0.48901957f, 0.29462457f, 
    -0.17757908f, 0.23976347f, -0.17339712f, -0.47009191f, 0.58227694f, 0.38558319f, 0.08925962f, -0.21151932f, 
    0.66327399f, 0.22256453f, -0.14060834f, -0.58504486f, 0.04006153f, -0.07311359f, -0.38595641f, 0.20671158f, 
    0.23460087f, -0.27949789f, -0.08866740f, -0.07599694f, -0.36805171f, -0.11048621f, -0.14972845f, 0.20213228f, 
    0.39388928f, 0.76380062f, 0.17525181f, 0.42204201f, 0.30364984f, -0.16188110f, -0.32589710f, -0.18050890f, 
    0.23724370f, 0.07377096f, 0.10825499f, -0.30755106f, -0.27719876f, 0.19304077f, -0.15403357f, -0.36508599f, 
    0.64756382f, 0.09935500f, -0.13940606f, -0.45217329f, 0.26677531f, 0.05027192f, 0.36540386f, 0.11340378f, 
    -0.20709461f, 0.37948877f, 0.04287992f, 0.54947877f, -0.17238414f, 0.36671960f, -0.18507686f, 0.07042478f, 
    -0.05562748f, -0.13498780f, 0.16013817f, -0.24573095f, 0.31818834f, -0.02353795f, 0.09479849f, -0.13498594f, 
    0.12643260f, 0.47975984f, -0.16467698f, 0.17468390f, 0.82870919f, 0.14455450f, 0.02703705f, -0.16597077f, 
    0.38299468f, -0.08981146f, 0.05472599f, -0.34029830f, -0.25583595f, 0.25465444f, 0.49567053f, -0.60030687f, 
    -0.42116040f, -0.06572521f, -0.17905411f, -0.42007157f, 0.08853049f, -0.09830038f, -0.01396742f, 0.13030384f, 
    -0.31394926f, 0.08455747f, -0.19058730f, 0.34384111f, 0.39978129f, -0.00830528f, 0.44474849f, 0.19420801f, 
    -0.00664945f, 0.27287099f, -0.15804078f, -0.18692045f, 0.70253503f, -0.10839292f, 0.20968118f, 0.48615119f, 
    -0.19562574f, 0.46919793f, -0.56995916f, 0.06841891f, -0.32210284f, -0.21446601f, 0.33827895f, -0.48243451f, 
    -0.65450954f, 0.31690311f, -0.14182548f, 0.17561248f, 0.10783305f, -0.33488742f, -0.19853851f, -0.09026602f, 
    0.23654279f, 0.55323255f, 0.05852659f, -0.02966726f, 0.48366997f, -0.10126862f, -0.53042841f, 0.02297707f, 
    -0.06089596f, 0.30840555f, -0.14365239f, 0.51157802f, -0.15898612f, 0.43473667f, -0.14483905f, 0.58453953f, 
    -0.37791747f, -0.09448007f, 0.22272556f, -0.45701700f, -0.08537780f, -0.09216689f, 0.31433401f, -0.46669769f, 
    -0.18963188f, 0.02382231f, -0.10611600f, 0.03614727f, 0.07111169f, -0.00196337f, -0.00095516f, 0.03053958f, 
    -0.25176990f, -0.18717331f, -0.18560325f, -0.07842594f, -0.16046695f, -0.23829246f, 0.07597539f, -0.09790783f, 
    -0.07460070f, -0.18771173f, 0.01123474f, 0.03582086f, 0.15156797f, -0.00003901f, -0.23838553f, -0.03839424f, 
    0.05123333f, 0.14062223f, -0.21934533f, -0.19980679f, -0.12587634f, 0.17083448f, 0.04799433f, -0.11594595f, 
    0.38961041f, 0.12479168f, -0.05150994f, -0.77475017f, 0.29843426f, 0.64473206f, -0.04940104f, -0.26157936f, 
    0.05522819f, 0.21333921f, -0.08258288f, -0.16406757f, 0.27223992f, -0.15234013f, 0.33963349f, -0.12586884f, 
    0.38680622f, 0.02232902f, -0.22395109f, -0.40812004f, 0.36680636f, 0.45584458f, -0.15926141f, -0.24417579f, 
    0.43075365f, 0.06220372f, 0.36239782f, -0.14264484f, 0.46031418f, -0.23005812f, -0.28971887f, 0.00833994f, 
    -0.16209894f, 0.53980887f, -0.20292176f, 0.39284241f, -0.35712457f, 0.41705346f, 0.22765034f, -0.07360154f, 
    -0.51132238f, 0.15162355f, 0.55948502f, -0.41697326f, 0.61505371f, 0.16402838f, 0.08819047f, -0.50762200f, 
    1.02436066f, -0.15978417f, -0.07484741f, 0.10051703f, 0.04463701f, -0.34581926f, -0.01474145f, 0.30640760f, 
    0.04750212f, -0.17164552f, -0.01161276f, 0.64037657f, -0.19460757f, 0.03790152f, -0.00935103f, -0.26547688f, 
    0.28635642f, 0.33429953f, -0.16291599f, -0.17911918f, 0.13033207f, -0.45383573f, 0.22382951f, 0.33476031f, 
    -0.29992729f, -0.53806883f, 0.29634368f, 0.12880331f, -0.40621236f, 0.11362141f, 0.33939791f, 0.36133003f, 
    0.11337651f, -0.53074157f, 0.06257612f, -0.64817321f, 0.21091935f, 0.13107245f, -0.11851710f, 0.11534673f, 
    0.39190608f, -0.04808266f, -0.18364900f, -0.50390571f, -0.02550398f, -0.12210677f, 0.28227836f, 0.12125703f, 
    -0.36376458f, -0.03078128f, 0.22450733f, -0.04280738f, -0.33621016f, -0.01544059f, 0.15913090f, 0.63449717f, 
    -0.07941249f, 0.40491456f, -0.06824695f, -0.17425159f, -0.42934257f, 0.19965099f, 0.56976116f, 0.41495878f, 
    -0.07632557f, 0.00981409f, -0.15826257f, -0.20835750f, -0.09342957f, -0.05615998f, -0.06733045f, -0.13919939f, 
    -0.23187983f, 0.09603766f, -0.03394258f, 0.14984123f, -0.14981927f, 0.10276413f, -0.17099205f, 0.11946578f, 
    0.14229049f, 0.04879408f, -0.21397984f, 0.04429701f, -0.03155478f, 0.01937343f, 0.15221176f, 0.00563817f, 
    0.05517965f, 0.19401547f, -0.24696927f, -0.19297859f, -0.10615402f, -0.07052611f, -0.06930927f, -0.22347158f, 
    -0.14256108f, -0.10430107f, -0.09251034f, 0.27160311f, 0.19221616f, 0.33736622f, 0.09567675f, -0.38918936f, 
    0.99932158f, 0.55941683f, 0.07930014f, 0.00610146f, 0.44046435f, 0.05675475f, -0.43059984f, -0.13325170f, 
    0.67552906f, -0.21776283f, 0.08100080f, -0.32694596f, 0.14167410f, -0.03382817f, 0.18979597f, 0.45609614f, 
    0.53344452f, 0.51920205f, -0.16435093f, 0.51587486f, -0.00062505f, 0.15029894f, -0.01752455f, -0.32759848f, 
    -0.62838942f, 0.06786509f, -0.06217188f, -0.31295571f, 0.02030149f, -0.12723137f, 0.12236130f, -0.08684555f, 
    0.06556839f, 0.55624104f, 0.32233596f, 0.26746920f, 0.30041912f, 0.24154077f, -0.25604355f, -0.26052201f, 
    0.46110889f, -0.53753418f, 0.15442280f, -0.06370813f, -0.47619489f, 0.28133968f, 0.11347830f, 0.31586674f, 
    -0.02828873f, 0.03471603f, 0.20160966f, 0.29331443f, 0.34414136f, 0.00917731f, -0.08927920f, 0.71861881f, 
    0.23972408f, 0.03411423f, 0.09628153f, -0.17310928f, -0.40743014f, 0.57418370f, -0.04036143f, -0.03111789f, 
    -0.28865650f, 0.17896089f, -0.07514537f, -0.10795629f, 0.26013130f, -0.25061429f, 0.18486153f, 0.67398268f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05418456f, -0.03134831f, 0.12601294f, 0.27068523f, 0.01848315f, -0.19014485f, 0.40821594f, -0.28644630f, 
    -0.24464494f, 0.00404429f, -0.00182937f, -0.04909300f, -0.05921234f, 0.11841980f, -0.07885353f, 0.62651318f, 
    -0.10365796f, -0.23001623f, 0.19607863f, 0.26559612f, 0.18808320f, -0.13710250f, 0.44251001f, -0.09786833f, 
    0.67391056f, 0.18429764f, -0.21201111f, 0.07595060f, 0.29305428f, -0.23224109f, 0.17133132f, 0.41154200f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.42114624f, 0.75984943f, -0.36818081f, -0.60600787f, -0.58494014f, 0.05095635f, -0.02297940f, -0.93025869f, 
    -0.52448159f, 0.51476693f, -0.08759902f, 0.18245190f, 0.26335701f, 0.38026384f, -0.15902720f, -0.15476902f, 
    -0.13023131f, 0.03452058f, 0.60484916f, 0.11300041f, -0.06398834f, -0.30808523f, 0.06509616f, 0.20699808f, 
    0.15171789f, 0.08579206f, -0.07466315f, -0.27326789f, 0.08128921f, -0.13774739f, -0.30162039f, 0.20800698f, 
    -0.53352034f, -0.35815382f, 0.67921567f, -0.69146353f, 0.12222962f, 0.46601546f, 0.29976377f, 0.13114145f, 
    -0.69028455f, -0.55725169f, 0.12677364f, 0.08467188f, 0.20144963f, 0.06708373f, -0.45920670f, 0.19069727f, 
    -0.19430028f, -0.04177676f, 0.04072438f, -0.29276711f, -0.08362528f, 0.00863523f, 0.13564271f, 0.01094255f, 
    0.10625976f, -0.13810702f, 0.02792148f, -0.42080098f, -0.03458562f, -0.68682623f, 0.07100201f, -0.11613464f, 
    0.32710126f, 0.09473385f, -0.01271182f, 0.35777411f, -0.10373679f, 0.10725065f, 0.15072928f, -0.79469168f, 
    0.10810500f, -1.66899502f, 0.00176193f, -1.24769366f, 0.49990809f, 0.07571877f, 0.27002281f, 0.02000212f, 
    0.01121482f, 0.15067331f, -0.80353725f, -0.74592537f, 0.17934696f, -0.54974335f, -0.04639724f, -0.07378875f, 
    0.42257780f, 0.01500604f, -0.07402928f, -0.48838711f, -0.19515771f, 0.02041064f, 0.26026610f, 0.26999134f, 
    0.39458612f, -0.18942034f, 0.30919904f, 0.07049332f, -0.11654040f, 0.06159765f, -0.48195782f, 0.13848019f, 
    0.34754005f, 0.54870069f, -0.06325466f, -0.33099163f, 0.17117576f, -0.88023341f, 0.39506099f, -0.69418377f, 
    0.02460095f, -0.06438207f, 0.08950649f, 0.27084792f, -0.25368690f, -0.09087394f, -0.62834108f, -0.16316296f, 
    -0.85807061f, 0.02909264f, 0.00441615f, 0.32994089f, 0.05802540f, 0.16382752f, 0.05894611f, -0.02998132f, 
    -0.86864096f, -1.06605136f, -0.65318346f, 0.02607070f, -0.40704450f, -0.50328290f, -0.29842591f, 0.39704320f, 
    0.22882961f, -0.02970972f, 0.07096536f, -0.13383648f, -0.31355873f, -0.26725450f, -0.10280275f, 0.21603005f, 
    0.02281883f, 0.02538531f, 0.44058710f, 0.23819046f, 0.34120423f, 0.31396222f, -0.53665245f, -0.79091775f, 
    -0.31490755f, -0.11790071f, -0.15093166f, 0.02021176f, 0.19476306f, 0.00800079f, 0.18097925f, 0.08154949f, 
    -0.20844130f, -0.28150484f, 0.17455302f, 0.02722107f, -0.36313415f, -0.19328968f, 0.26066411f, 0.41663635f, 
    -0.45555282f, 0.07765394f, -0.01331678f, 0.43158811f, -0.27069372f, 0.27931756f, 0.07107311f, 0.30840299f, 
    0.03504679f, 0.12688909f, -0.02690217f, -0.03338387f, 0.00545922f, 0.04589704f, 0.21940345f, -0.61848289f, 
    0.12164593f, 0.10796990f, 0.05622323f, -0.47032747f, -0.44422102f, -0.38569444f, -0.50457233f, -0.13583006f, 
    -0.19305055f, -0.93396384f, -0.44880223f, 0.29169428f, -0.04073672f, -0.34982401f, 0.11366386f, -1.50274599f, 
    -0.45328921f, -0.47736007f, 0.46889961f, 0.19123442f, -0.74512327f, -0.49800926f, 0.24683845f, 0.22141060f, 
    -0.06778739f, -0.08386747f, -0.45667484f, -0.04302684f, 0.52920985f, -0.31409627f, -0.08507770f, 0.07102726f, 
    -0.30855507f, 0.08438552f, 0.03397777f, 0.28327599f, -0.67716932f, -0.28873923f, -0.25491855f, 0.06844655f, 
    0.26082405f, 0.19128132f, -0.45444420f, -0.08144740f, -0.28174809f, 0.17360549f, -0.72572857f, 0.22686997f, 
    0.16085866f, -0.17767859f, -0.33975422f, 0.29953271f, 0.18341064f, 0.55469900f, 0.45016161f, -0.66255558f, 
    -0.19009244f, -0.10125519f, -0.00414436f, 0.05044609f, -0.82056868f, 0.27696317f, -0.80369538f, 0.58357811f, 
    -0.67277998f, -0.16695349f, -0.01300509f, 0.37529936f, 0.47337568f, 0.30090567f, -0.62240082f, -0.69858366f, 
    0.03988646f, -0.49885330f, 0.02843095f, -0.40895471f, -0.20742188f, 0.07176509f, -0.02667593f, -1.33691347f, 
    0.29837862f, -0.70514405f, -0.29023829f, -0.20251411f, -0.89182198f, 0.10206255f, -0.66883373f, 0.09679240f, 
    -0.06052570f, -0.16710816f, -0.78658783f, -0.43750590f, -0.54332441f, 0.85399753f, 0.33844060f, -0.30657372f, 
    0.15998678f, 0.03378294f, 0.15893734f, -0.46722993f, 0.69783968f, -0.41070300f, 0.13569278f, -0.46713269f, 
    0.03869674f, -0.37661380f, -1.03025484f, -0.11398449f, 0.52182841f, -0.83940494f, -0.05910800f, 0.16071938f, 
    0.09288487f, 0.13486551f, 0.06925332f, 0.08596339f, -0.04837681f, -0.09643745f, 0.28614742f, 0.32174161f, 
    -0.16231932f, -0.00172598f, -0.20939614f, -0.03638936f, 0.24394234f, -0.89945686f, -0.07422913f, -1.26053393f, 
    0.55580866f, -0.11470191f, -0.00047409f, 0.11070842f, -0.09305397f, 0.26297051f, -0.22943734f, -0.20428906f, 
    0.34224322f, -0.05504784f, -0.41450900f, 0.48054671f, 0.33528662f, 0.51667500f, -0.08650484f, -0.09423716f, 
    -0.03109553f, -0.65285248f, -0.23387119f, -0.62794846f, -0.42134172f, -1.10133934f, -0.22131008f, -0.40360394f, 
    -0.15833125f, -0.02117945f, 0.03952536f, 0.24514608f, -0.71992284f, -0.10484380f, -0.14227177f, -0.37779534f, 
    0.25747940f, 0.11359750f, -0.16316129f, 0.06491517f, 0.06645466f, -0.36718020f, 0.52892315f, 0.14649169f, 
    -0.04059173f, 0.52972120f, 1.05868208f, 0.14212954f, 0.44931081f, 0.00851589f, 0.18133740f, -0.68172300f, 
    0.01891419f, -0.23750070f, -0.13921894f, -0.09311029f, -0.05635912f, -0.68307102f, 0.05050933f, -0.31535980f, 
    -0.16157281f, 0.10003853f, -0.20697843f, 0.35844418f, 0.21781011f, -0.23714684f, 0.21035232f, 0.13321583f, 
    -0.68565297f, 0.11515380f, -0.07967345f, -0.03781774f, -0.37617254f, 0.44046110f, -0.03351533f, -0.24641442f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04516606f, 0.01895551f, -0.01982746f, -0.18732007f, -0.02320797f, 0.13170378f, 0.06042237f, -0.54978704f, 
    -0.32973543f, 0.34516859f, 0.14081575f, -0.03740712f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
