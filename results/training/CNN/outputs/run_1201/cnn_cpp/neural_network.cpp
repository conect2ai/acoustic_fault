#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28195709f, 0.19403914f, -0.02158485f, -1.07557619f, -0.21522655f, -0.28278583f, -0.00070473f, -0.34245348f, 
    0.61881787f, 1.21126223f, -0.01757981f, -0.20128061f, -0.56264430f, 0.30569294f, 0.13603991f, 0.09067182f, 
    0.17979537f, 0.29968998f, -0.93127573f, 0.61301517f, -0.59328961f, -0.62699723f, 0.27525735f, 0.37868127f, 
    0.08030637f, 0.65230632f, 0.28198066f, 0.42533365f, 0.39732805f, 0.73950082f, -0.62495553f, -0.32174245f, 
    0.23088095f, 0.09223548f, 0.20936079f, 0.01642602f, 0.86404896f, -1.09176981f, -0.69378251f, 0.55171806f, 
    0.08108389f, 0.08008219f, -0.11409181f, 0.00693943f, -0.34691557f, -0.25290331f, -0.59810477f, -0.01802362f, 
    0.11235023f, -0.60548848f, -0.66887057f, -0.40188473f, -0.04583831f, -0.28531411f, -0.28179395f, 0.58539057f, 
    0.61531597f, -0.44768596f, 0.57862163f, 0.23213696f, 0.66958934f, -0.13372770f, -0.22710478f, -0.55351317f, 
    -0.50639302f, -0.27638918f, 0.11474001f, -0.78669739f, -0.37633774f, -0.29809478f, 0.41307160f, 0.12227269f, 
    0.02937431f, 0.23466195f, 0.19080652f, 0.66481626f, 0.38727239f, 0.32204661f, 0.15094528f, 0.32861626f, 
    0.13753839f, -0.88640755f, 0.56297189f, 0.36672091f, 0.06430449f, -0.78594118f, -0.81248730f, -0.05783753f, 
    -0.03251906f, 0.15209477f, -0.95455891f, -0.16974418f, -0.14170510f, -0.05481942f, -0.00473252f, -0.02835527f, 
    -0.28563726f, -0.19982000f, -0.38771948f, -0.19469264f, 0.17153850f, -0.30870140f, -0.42723182f, -0.32689711f, 
    -0.63660669f, 0.89706939f, 0.33841333f, 0.34454611f, -0.39885214f, 1.07864189f, -0.64135778f, -0.14156577f, 
    0.53885573f, -0.20225811f, 0.06894391f, -0.34369162f, 0.29753867f, -0.17129861f, -0.33818009f, -0.01744860f, 
    0.83749026f, 0.30879265f, 0.05704812f, -0.40793326f, -0.56811196f, -0.20700182f, -0.74471533f, -0.15586230f, 
    -0.97486281f, 0.74850297f, 0.55648518f, 0.41601086f, 0.17960541f, 0.38113174f, 0.06322589f, 0.40344921f, 
    0.79146290f, -0.24622969f, 0.53919578f, -0.33184335f, -0.39157063f, -0.00228283f, 0.17918710f, 0.01360602f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23767692f, 0.31663856f, 0.42796141f, 0.46587056f, -0.30176842f, 0.41170117f, 0.12787087f, -0.40701661f, 
    -0.23258933f, 0.31741160f, -0.33116615f, -0.33177409f, 0.40644646f, 0.24323116f, -0.12968656f, 0.07029233f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.38595831f, 0.41142902f, 0.23821412f, 0.06401370f, -0.06663706f, 0.22168730f, -0.13353422f, -0.14580372f, 
    -0.11035342f, -0.10946909f, -0.28081405f, -0.07991058f, -0.14996713f, -0.14780214f, 0.20175928f, 0.14251569f, 
    0.16241619f, 0.21663733f, 0.10688898f, 0.24315928f, 0.11447436f, -0.06606855f, -0.32313734f, -0.12284986f, 
    0.00587471f, 0.24020714f, 0.17124040f, -0.16550152f, -0.00648012f, -0.26583740f, 0.13520625f, 0.07028589f, 
    -0.21215041f, -0.07782590f, 0.18604024f, 0.03989765f, -0.21235120f, 0.15403785f, 0.25119346f, -0.11258401f, 
    -0.14049233f, 0.10732932f, -0.11195663f, -0.13398027f, -0.07365531f, -0.16241212f, 0.17221694f, 0.24017893f, 
    -0.05984927f, 0.04242002f, 0.09062948f, 0.13193683f, -0.19578901f, -0.14450203f, 0.24892703f, 0.06187357f, 
    -0.15661748f, 0.07565109f, 0.03067287f, 0.01591064f, 0.11426567f, 0.12208074f, -0.28078780f, -0.18319029f, 
    0.11880959f, 0.35272932f, -0.03543779f, 0.22377782f, 0.03414239f, 0.11854179f, -0.19761513f, -0.02188004f, 
    0.21482806f, 0.07993587f, 0.02030141f, -0.09657989f, -0.14697962f, -0.19985522f, 0.18736932f, 0.19344220f, 
    0.10326852f, 0.31095520f, 0.01237439f, 0.10448641f, 0.06967047f, 0.19686109f, -0.05660924f, -0.17747676f, 
    0.17984204f, -0.08136611f, 0.15552500f, -0.33043575f, 0.26855949f, -0.08326505f, -0.11769120f, 0.04715223f, 
    0.38654783f, 0.14680485f, 0.06930097f, 0.40329555f, 0.31802931f, 0.21705595f, 0.19423175f, 0.15609917f, 
    0.12177933f, 0.13583013f, 0.10985745f, 0.08138711f, 0.31022632f, 0.25774205f, -0.24091201f, -0.16078927f, 
    0.26274216f, 0.00321117f, 0.00223220f, 0.30380380f, -0.24778505f, -0.03918767f, -0.06070138f, 0.01360281f, 
    -0.00051154f, -0.13958924f, 0.03087284f, -0.14117235f, -0.45429587f, -0.05905013f, 0.35805553f, 0.36722749f, 
    0.48969552f, 0.15491135f, -0.06192641f, -0.15974222f, -0.08903800f, -0.02959817f, 0.04110303f, 0.05897747f, 
    -0.04565732f, 0.07390522f, 0.10820195f, -0.00139796f, -0.14195022f, 0.18713704f, 0.00335884f, 0.22714508f, 
    -0.01477600f, 0.39330626f, 0.42930144f, 0.13602379f, -0.07106793f, -0.08553971f, -0.12800260f, -0.07441057f, 
    -0.12353040f, -0.05806737f, -0.31905565f, -0.33038282f, -0.23015781f, -0.28612673f, 0.24861501f, 0.29995361f, 
    0.10482965f, 0.08313672f, 0.10388520f, 0.08500924f, -0.00517123f, -0.08758377f, -0.07850506f, 0.11416575f, 
    0.22619380f, 0.09170230f, -0.12179825f, -0.43721601f, -0.41200295f, -0.08947314f, 0.07503584f, 0.09119547f, 
    -0.14609581f, 0.12609804f, -0.09570647f, -0.02431976f, 0.05140100f, -0.31206819f, -0.17241833f, 0.03412554f, 
    0.11579135f, -0.10469386f, 0.09833384f, -0.07270673f, -0.15780742f, 0.17512798f, 0.19316024f, 0.28896078f, 
    -0.01224246f, 0.16576916f, 0.03774776f, 0.09664391f, -0.10786375f, 0.07568970f, -0.06625354f, 0.16002552f, 
    0.14871353f, 0.22477350f, -0.07756142f, -0.16026974f, 0.23130305f, -0.09289324f, 0.30466855f, 0.29849637f, 
    0.35100839f, 0.50176644f, -0.01201432f, 0.03185072f, -0.10279196f, 0.09954318f, -0.09702206f, 0.11004153f, 
    0.13384095f, 0.07923895f, -0.27585942f, -0.06451595f, 0.15630007f, 0.05895534f, -0.04932144f, 0.13522001f, 
    0.00843590f, 0.01624870f, 0.05200462f, 0.09193059f, 0.04497468f, -0.01195521f, -0.11359399f, -0.03522320f, 
    0.03038595f, 0.02369119f, 0.03770002f, -0.19503361f, 0.01026026f, -0.03823145f, 0.01088866f, 0.16902064f, 
    0.36349699f, -0.09557027f, 0.04977920f, 0.24428044f, 0.36248761f, -0.12410767f, -0.06031320f, -0.11731097f, 
    0.06373027f, 0.00972613f, -0.01641619f, -0.34973386f, -0.09896595f, -0.15773983f, -0.45091349f, -0.11834439f, 
    0.15992680f, 0.00348153f, 0.16276985f, 0.16560203f, 0.21699032f, 0.09787171f, 0.00530059f, -0.12538537f, 
    -0.14530112f, 0.10510971f, 0.01072230f, -0.01763268f, 0.24619895f, 0.23691954f, -0.17190270f, -0.25384855f, 
    -0.23468243f, -0.01274463f, 0.02341397f, 0.09859566f, -0.00842746f, 0.02601166f, 0.06776423f, -0.00215059f, 
    -0.15044473f, -0.08249322f, 0.21019919f, 0.03162107f, -0.00192570f, -0.07286520f, 0.13118561f, 0.18934584f, 
    0.01351633f, 0.20170687f, 0.01272602f, -0.08284201f, -0.20592164f, 0.15649433f, -0.11113840f, 0.04291440f, 
    0.05429394f, 0.37578031f, 0.23695207f, -0.11586948f, -0.15255889f, 0.03364173f, -0.08154225f, 0.03120051f, 
    0.13824739f, 0.24229425f, -0.23784000f, -0.30106780f, -0.14621992f, -0.04123234f, 0.00630606f, -0.02021760f, 
    0.05772569f, 0.08408550f, 0.01471342f, 0.22877325f, -0.35242188f, 0.06083188f, 0.00423388f, 0.09086170f, 
    -0.00797529f, 0.08771893f, 0.05247170f, 0.13045055f, 0.74820191f, -0.03222701f, -0.09022593f, 0.07792617f, 
    -0.04581265f, 0.14038312f, 0.12333699f, 0.00747072f, -0.20785686f, 0.24064957f, 0.20899548f, -0.16944350f, 
    0.03969402f, -0.00664608f, -0.04598428f, -0.01883173f, -0.14623378f, -0.03979085f, -0.32123962f, -0.47688964f, 
    0.22917733f, -0.18413335f, 0.31013799f, -0.19151150f, 0.04446895f, 0.02728944f, 0.02056775f, 0.07829233f, 
    0.34434503f, 0.13252053f, -0.25224543f, 0.06850260f, -0.02279532f, 0.02269912f, -0.16231695f, 0.06481186f, 
    -0.31142026f, -0.73737043f, -0.47495404f, -0.12223604f, -0.08233915f, 0.17111742f, -0.06026931f, 0.12967470f, 
    0.01430548f, -0.22601095f, 0.06663694f, -0.20268278f, -0.04562142f, -0.04889893f, -0.19649056f, -0.17677733f, 
    -0.02444467f, 0.16661456f, 0.07128158f, 0.22681294f, 0.45569462f, 0.08873398f, 0.11467188f, 0.02352462f, 
    0.12979753f, 0.01281516f, -0.17075142f, 0.22322878f, 0.21320991f, 0.03419401f, 0.03440125f, -0.00573129f, 
    -0.25621387f, 0.07533742f, 0.13031662f, -0.12629984f, -0.46009064f, -0.56939024f, -0.30855054f, 0.05675558f, 
    -0.33423057f, -0.18113971f, 0.12266390f, -0.05098518f, 0.08059821f, 0.21273035f, 0.03922769f, 0.25631097f, 
    -0.08597527f, -0.06355583f, 0.14124869f, 0.16795036f, 0.08023874f, 0.06844696f, -0.01093811f, -0.05215960f, 
    -0.41103867f, -0.03303101f, -0.09949087f, 0.16241883f, -0.04730952f, 0.03823450f, -0.06936076f, -0.47916463f, 
    -1.02675319f, -0.33383134f, 0.09859775f, -0.27527413f, -0.13774842f, -0.20565836f, 0.10433231f, -0.09043100f, 
    -0.26149902f, -0.55625129f, -0.11304072f, -0.11734806f, -0.00450866f, -0.01921864f, -0.06782242f, -0.09490462f, 
    0.00599847f, 0.42565393f, 0.16589710f, 0.06900056f, 0.00135202f, 0.10324724f, 0.01006727f, 0.02703722f, 
    0.05890446f, -0.00115208f, 0.11140504f, 0.03144446f, 0.37629747f, 0.17490652f, 0.03790671f, 0.03561413f, 
    0.19431512f, 0.14088617f, 0.03105225f, 0.33573857f, 0.09607746f, -0.03440076f, -0.00704416f, 0.10871624f, 
    0.19114372f, -0.05145401f, 0.08870808f, 0.06158696f, -0.54251999f, 0.15461530f, -0.06110125f, -0.18700132f, 
    -0.07987918f, 0.03861845f, -0.02829431f, -0.09272975f, 0.21954623f, 0.21969670f, 0.09711958f, 0.05635629f, 
    -0.06065167f, -0.03941170f, -0.08951801f, 0.04984775f, 0.05773843f, 0.02241805f, 0.18903469f, 0.08658220f, 
    -0.07565204f, 0.04159239f, -0.14985088f, -0.16743298f, -0.11296906f, 0.07280888f, 0.07712492f, -0.15251516f, 
    -0.02811227f, -0.19784787f, 0.00463348f, -0.17440654f, -0.21693222f, -0.08773923f, -0.13427907f, 0.04875367f, 
    -0.15392344f, -0.16710991f, -0.13617712f, -0.08647142f, 0.18934818f, 0.09362783f, 0.11113685f, -0.03935193f, 
    0.00235520f, -0.49214289f, -0.28284529f, -0.10690394f, -0.04109755f, 0.01836215f, 0.14137974f, 0.26429844f, 
    0.02695929f, 0.08651145f, 0.01077250f, 0.12167019f, 0.39818165f, -0.13875020f, -0.07055103f, -0.12379511f, 
    -0.27543545f, 0.05394648f, 0.13143989f, -0.81429994f, -0.39797977f, -0.48186046f, -0.29091713f, 0.13437733f, 
    -0.24160780f, 0.02678536f, 0.19644076f, -0.15874834f, 0.12781626f, -0.23741296f, -0.00779684f, 0.04414243f, 
    -0.10808201f, 0.29427007f, -0.13406886f, 0.07390972f, 0.12660496f, 0.11981256f, 0.05932245f, 0.20718643f, 
    0.05951547f, 0.12852740f, -0.03359337f, 0.06198673f, -0.02496117f, 0.08054410f, -0.60786861f, 0.01211621f, 
    0.20161948f, -0.01092511f, 0.13159068f, -0.10587452f, -0.06280339f, 0.00722311f, -0.01936661f, -0.02637761f, 
    0.03977080f, -0.02936433f, -0.03983665f, -0.13718462f, 0.04763343f, 0.12916186f, 0.06786909f, 0.11055166f, 
    0.04303305f, -0.00253883f, 0.01440054f, -0.06845611f, 0.04557942f, -0.01459604f, -0.03925889f, 0.00401835f, 
    -0.07168880f, -0.05721331f, -0.00204083f, -0.07400274f, -0.05976387f, -0.01467218f, 0.02479793f, 0.00792453f, 
    0.00277286f, -0.04145835f, 0.02007612f, -0.06035334f, -0.04563049f, 0.05168716f, 0.00693524f, -0.02532201f, 
    0.07371423f, 0.00686996f, 0.06604744f, 0.06730603f, -0.05282832f, -0.08140101f, 0.00287696f, -0.01473348f, 
    -0.04013638f, -0.06796520f, -0.04514609f, -0.04104041f, -0.01321792f, -0.06682354f, 0.05816353f, -0.06669443f, 
    -0.06224182f, 0.02815456f, -0.01661012f, 0.06636988f, -0.06613242f, -0.00334000f, 0.07270637f, 0.07306086f, 
    0.02834351f, -0.05413591f, 0.01639527f, 0.03155676f, 0.04672184f, -0.03691833f, -0.01400612f, -0.08195569f, 
    0.03562283f, 0.01778353f, -0.03920582f, -0.06947149f, -0.06638943f, -0.06033135f, -0.07749421f, -0.05494827f, 
    -0.01744450f, 0.01055246f, -0.07693557f, 0.01245014f, -0.02759479f, 0.02381381f, 0.00313471f, -0.00356748f, 
    -0.07750415f, -0.05655833f, 0.01521396f, -0.02117178f, 0.05931120f, 0.07916781f, -0.01557071f, -0.03818680f, 
    -0.05283711f, -0.08010486f, -0.06287999f, 0.01158937f, -0.06201497f, -0.03056605f, 0.03125590f, 0.02867999f, 
    0.04322856f, 0.01942938f, 0.03845236f, -0.08745754f, -0.05266019f, 0.07164685f, 0.03434549f, -0.06894444f, 
    -0.06455567f, -0.05799462f, 0.00573564f, -0.03997511f, 0.06566113f, -0.01185064f, -0.02474930f, 0.02562714f, 
    0.07378402f, -0.03480014f, 0.01488733f, -0.08412720f, 0.06526804f, -0.05629069f, 0.02843104f, -0.08955359f, 
    -0.04029592f, 0.03184373f, -0.01218804f, -0.06902895f, -0.08528331f, -0.04260872f, 0.02631371f, 0.00135060f, 
    -0.01837888f, -0.00897757f, -0.04106914f, -0.05326746f, -0.05415699f, -0.00354228f, 0.06743978f, -0.08833902f, 
    -0.00212618f, -0.07331459f, -0.04843271f, -0.05805574f, 0.00242926f, -0.06945011f, 0.00400503f, -0.03463583f, 
    -0.00989413f, -0.03688284f, -0.03865231f, 0.04157703f, -0.02931910f, -0.03078222f, -0.06156911f, -0.07615172f, 
    0.05250404f, -0.04205297f, 0.02476406f, 0.01265885f, -0.06270292f, -0.05638538f, 0.00864908f, -0.00737412f, 
    -0.00239948f, -0.04636994f, -0.04357731f, -0.08359911f, -0.08574580f, -0.04970166f, -0.01330701f, -0.04856647f, 
    -0.08233232f, -0.01255653f, -0.00402292f, 0.03080737f, 0.01092267f, 0.03836185f, -0.07051480f, -0.07647503f, 
    -0.05014228f, 0.01157893f, 0.06100736f, -0.08603086f, 0.02909634f, -0.02737019f, 0.03569992f, 0.05606382f, 
    0.02109634f, -0.06240954f, 0.03501309f, 0.00230573f, 0.00994715f, -0.07913774f, 0.01791794f, -0.08850995f, 
    0.02287737f, 0.04797975f, -0.06800979f, -0.06115601f, -0.06553826f, -0.06867260f, 0.05798538f, 0.02034889f, 
    -0.09217118f, 0.04000876f, -0.08623060f, -0.09840120f, -0.05735067f, -0.05224377f, -0.04996171f, 0.04822908f, 
    -0.09074981f, 0.05888342f, 0.04144015f, -0.08798173f, 0.06331158f, -0.03957562f, 0.02479826f, -0.05634461f, 
    0.04417603f, -0.05979739f, -0.01640768f, 0.05565652f, 0.04856550f, -0.04497465f, -0.05850720f, -0.08041953f, 
    0.03222147f, -0.05779479f, 0.07280820f, -0.00839744f, 0.04990483f, 0.03700173f, -0.06599118f, -0.04221397f, 
    -0.04416536f, -0.02800893f, 0.04972491f, 0.06755808f, 0.06132647f, -0.05208967f, -0.01063550f, 0.07783426f, 
    -0.04345642f, 0.01736352f, 0.03292807f, 0.01284451f, 0.07864393f, 0.05936328f, -0.00806545f, 0.05163688f, 
    -0.08217155f, 0.02872539f, -0.07389689f, -0.00244025f, 0.02650117f, 0.04688704f, 0.08016635f, -0.02013612f, 
    -0.03873497f, -0.03046007f, 0.03806331f, 0.00902514f, -0.03219288f, 0.03687234f, 0.02726936f, 0.02478714f, 
    -0.04170655f, -0.05219836f, -0.01083754f, -0.01453964f, 0.01725385f, -0.03186048f, 0.02556079f, 0.03365038f, 
    0.00706869f, -0.03900177f, 0.04547262f, -0.08973566f, -0.07340711f, 0.03713967f, 0.00778353f, 0.02688107f, 
    -0.07815786f, -0.02930832f, -0.00714801f, -0.07179355f, -0.05441118f, 0.07167950f, -0.00362959f, 0.05496546f, 
    -0.07259919f, 0.06912629f, -0.00028113f, -0.04594020f, -0.00123901f, -0.07908957f, 0.04121890f, -0.04872097f, 
    -0.27881730f, 0.23417573f, -0.58926719f, 0.10247176f, -0.00088448f, -0.10879307f, -0.25161585f, -0.07570861f, 
    -0.10183305f, 0.41784129f, -0.05440074f, 0.10955477f, 0.15190890f, 0.01645295f, 0.36270159f, -0.10992948f, 
    0.08771330f, -0.21585722f, 0.22715414f, 0.15372668f, -0.31327376f, 0.13950765f, -0.03391457f, 0.02889600f, 
    0.03863051f, -0.03887590f, -0.02393539f, 0.16218852f, 0.07093225f, -0.08408362f, 0.02160096f, 0.02267160f, 
    -0.13013579f, 0.06706975f, 0.09604862f, -0.18328916f, -0.02504273f, -0.60968894f, -0.18428996f, 0.15996981f, 
    -0.00324314f, 0.38184899f, -0.06632909f, 0.16377662f, 0.14226592f, -0.18654324f, -0.30264077f, 0.67594427f, 
    -0.09404729f, 0.00764153f, -0.04854282f, -0.09731445f, 0.03457535f, 0.01874734f, -0.07116900f, 0.31703258f, 
    0.16142485f, -0.25901535f, -0.11733439f, 0.09305330f, -0.15827227f, -0.00729872f, -0.10428987f, -0.08546196f, 
    -0.23934385f, 0.34542918f, 0.02840955f, 0.14532918f, -0.16027559f, 0.11173717f, 0.02599987f, 0.15070347f, 
    -0.11034204f, 0.07321768f, 0.20335846f, 0.02942335f, -0.00304639f, 0.13940594f, -0.06668851f, -0.05338471f, 
    -0.11040166f, -0.65075666f, -0.22597998f, 0.09217460f, -0.13766006f, -0.03229545f, -0.02457074f, -0.11428225f, 
    -0.04019859f, -0.02466984f, 0.34936759f, -0.13287653f, -0.44690603f, -0.10885690f, 0.02149504f, 0.01489263f, 
    0.18282163f, 0.13062969f, 0.04960885f, -0.34174788f, -0.15588035f, 0.34474453f, -0.04982666f, 0.10569353f, 
    -0.00648489f, -0.12365267f, 0.03817314f, 0.01595216f, 0.05927471f, 0.08353359f, 0.23277998f, 0.09034486f, 
    -0.00467333f, 0.35993153f, -0.06331555f, -0.00988746f, -0.07270051f, 0.02816684f, -0.22739278f, 0.15212657f, 
    0.05400566f, 0.01202475f, -0.20729950f, -0.14841977f, -0.08094171f, 0.05523343f, 0.38788694f, -0.07797596f, 
    -0.39787450f, -0.02048472f, -0.12934686f, -0.00876360f, -0.18378061f, 0.14360532f, 0.01688443f, 0.31265315f, 
    0.21869738f, 0.09159666f, 0.03131807f, 0.02836601f, -0.13244915f, 0.09013583f, 0.07484893f, 0.03985827f, 
    0.07061984f, -0.02965165f, -0.16818491f, -0.06107489f, 0.09722402f, 0.10830286f, 0.08708734f, 0.00330372f, 
    0.06385387f, -0.25822085f, 0.09042616f, 0.15510656f, 0.17181543f, -0.11181664f, -0.01412657f, -0.10414285f, 
    0.02380388f, 0.03293900f, 0.11903451f, -0.01759077f, -0.16366081f, -0.05481592f, -0.23339060f, 0.10848751f, 
    0.26371995f, 0.01681967f, 0.04970240f, 0.05994759f, 0.10187919f, 0.12037104f, 0.08170613f, 0.05925829f, 
    0.21986783f, 0.19417055f, 0.10544617f, 0.05991082f, 0.18602350f, -0.15367298f, -0.30335319f, 0.02688844f, 
    0.06381086f, 0.12476751f, -0.05237631f, 0.04074153f, -0.06731577f, -0.16840225f, -0.13800818f, -0.25959903f, 
    -0.06886862f, -0.11426748f, 0.10794672f, -0.08216495f, 0.04056797f, 0.11439915f, 0.17334060f, 0.24786237f, 
    0.24772215f, -0.18354152f, 0.11487025f, -0.06652351f, 0.10295645f, 0.07554204f, -0.11514742f, 0.35702169f, 
    0.25043678f, 0.08769917f, -0.05318184f, -0.19950968f, 0.00023867f, -0.12370844f, -0.12034918f, 0.05910429f, 
    0.09208486f, 0.24862625f, 0.32748696f, -0.32519048f, -0.25231898f, -0.19492276f, 0.09601267f, 0.04698595f, 
    0.02943582f, -0.06088608f, -0.10058168f, 0.17902701f, 0.09159166f, 0.01125925f, -0.01755377f, 0.04423936f, 
    0.11269303f, 0.01389541f, 0.59671283f, 0.05299710f, -0.25474292f, 0.05109950f, -0.11578774f, -0.09785886f, 
    0.09958462f, 0.10561583f, -0.20251618f, 0.13664743f, 0.28443697f, 0.14990176f, -0.02205128f, -0.24319580f, 
    0.13554536f, -0.07411980f, 0.15286350f, 0.19282325f, 0.13206950f, 0.06983133f, -0.10938121f, 0.03244034f, 
    -0.04039936f, -0.05233391f, 0.06389834f, -0.15546222f, -0.14678471f, 0.09218135f, -0.02763465f, -0.09345894f, 
    -0.22382848f, 0.09729784f, -0.16885889f, 0.10063905f, -0.27986738f, -0.09675375f, 0.49877042f, -0.24637356f, 
    -0.37081188f, -0.26710808f, 0.10551703f, -0.12651120f, -0.08436409f, 0.01060690f, 0.04864968f, 0.01031868f, 
    0.14883453f, 0.09089676f, -0.15273367f, -0.06230248f, 0.03559539f, -0.05693174f, -0.11425572f, 0.07659942f, 
    -0.00090513f, 0.14927179f, 0.25884661f, -0.02229119f, -0.01863712f, -0.10901888f, 0.04892699f, 0.17083426f, 
    0.11964417f, -0.06349052f, -0.15814655f, -0.11342712f, 0.00736701f, -0.01270022f, 0.08128037f, -0.01985221f, 
    0.05826280f, 0.05095252f, -0.22723721f, -0.27131110f, -0.00639677f, -0.10914271f, -0.04515877f, 0.10459783f, 
    0.00145380f, 0.17996064f, -0.06769002f, -0.33511829f, 0.03678415f, -0.26734945f, 0.14449246f, -0.01866196f, 
    0.08494599f, -0.24864133f, 0.05359130f, -0.00819731f, 0.16866130f, -0.39611965f, -0.60802370f, 0.04833197f, 
    -0.03114457f, 0.08076813f, 0.12621073f, 0.04217243f, -0.25625122f, 0.12977575f, 0.15579002f, -0.08049687f, 
    -0.08135821f, 0.10743190f, 0.22669378f, -0.04227722f, -0.08236671f, -0.04248757f, -0.29594147f, -0.17620760f, 
    0.00591361f, -0.05055509f, -0.09945230f, -0.08870720f, 0.05509811f, 0.14133434f, -0.20747720f, 0.13965334f, 
    0.30792242f, 0.33781901f, -0.35850075f, -0.14664371f, -0.03079258f, 0.11947192f, 0.20159781f, 0.25014272f, 
    -0.38201907f, -0.21038000f, -0.29149687f, -0.26575440f, 0.07598978f, 0.04914282f, 0.19099768f, 0.16400364f, 
    0.12946470f, -0.11928568f, 0.14268367f, 0.00404756f, -0.05427000f, 0.00316704f, 0.29521453f, -0.04163660f, 
    0.06328057f, 0.19741519f, -0.08941270f, 0.05943793f, -0.02781961f, -0.27323854f, -0.19464849f, 0.11599569f, 
    0.19341896f, -0.18679301f, -0.28407758f, 0.09849066f, -0.03466748f, 0.38987869f, -0.03709998f, -0.10416602f, 
    -0.07023789f, -0.02150230f, 0.02735222f, 0.25171930f, -0.23281215f, 0.01127220f, -0.12305881f, 0.05766480f, 
    0.15631637f, 0.03024788f, -0.00211661f, 0.16474082f, 0.10174420f, -0.02150864f, 0.04650506f, 0.12121799f, 
    -0.04880086f, -0.07444344f, -0.00106098f, 0.08075546f, 0.14124352f, -0.14980604f, -0.35608810f, -0.57399273f, 
    -0.31060895f, 0.13740161f, 0.04807265f, -0.08603565f, -0.07147875f, -0.18776016f, 0.10209662f, 0.10608708f, 
    -0.69151163f, -0.34818420f, 0.12229649f, -0.02254884f, -0.27095306f, -0.05010735f, 0.11820094f, 0.09391663f, 
    0.02120109f, 0.07767588f, 0.29737389f, 0.07549678f, 0.01318004f, -0.06728667f, 0.01194694f, 0.10417720f, 
    -0.13035642f, -0.02824241f, 0.02898118f, 0.09431976f, 0.08546228f, 0.28360626f, -0.11583330f, 0.06894869f, 
    -0.14419363f, -0.13027886f, -0.10093426f, -0.07611627f, -0.00956892f, 0.03264883f, 0.12442799f, 0.12434478f, 
    -0.09674490f, 0.05778655f, -0.12827350f, 0.08323247f, 0.17399897f, -0.22153337f, -0.06157060f, 0.05604023f, 
    0.03144727f, -0.10673325f, 0.06001936f, 0.06117032f, -0.38756984f, -0.18347815f, 0.23191068f, -0.12960468f, 
    0.20391810f, 0.18710683f, 0.06033297f, 0.28513396f, 0.27685028f, 0.06761013f, 0.16842824f, 0.17780590f, 
    0.16658984f, -0.02796925f, 0.03138408f, 0.21658418f, 0.38341671f, 0.27247050f, 0.06767768f, 0.18275081f, 
    0.27487037f, -0.13003530f, 0.21375839f, 0.16056453f, 0.16650113f, 0.08065818f, 0.01670862f, -0.04580591f, 
    -0.28419808f, 0.07699290f, 0.33261219f, 0.02679757f, 0.14940982f, 0.00574731f, 0.07578182f, 0.00056575f, 
    -0.04656157f, -0.29072070f, -0.10288934f, 0.03944807f, 0.03324237f, 0.03448918f, -0.09899204f, -0.06963964f, 
    -0.22287479f, 0.24534306f, 0.24133858f, 0.01237213f, 0.35016155f, -0.11761849f, 0.13838698f, 0.03652281f, 
    0.00505337f, 0.00829989f, -0.05822356f, -0.05171021f, -0.18653573f, -0.10174088f, -0.06110701f, -0.04831953f, 
    -0.09243266f, 0.10490538f, 0.16982232f, 0.12262193f, -0.22425796f, -0.13650042f, 0.25501359f, 0.28356817f, 
    -0.11358717f, -0.27364710f, -0.12518740f, -0.35844862f, 0.27002704f, -0.03538142f, 0.27252364f, 0.10377575f, 
    0.18318745f, 0.16790353f, 0.09863903f, 0.30154833f, 0.13966587f, 0.14943382f, -0.02651117f, 0.04680260f, 
    0.17003222f, 0.22091180f, 0.14520304f, 0.26443961f, 0.35732067f, 0.24847338f, 0.01128000f, -0.44751847f, 
    0.10096806f, 0.05762307f, -0.06928422f, 0.08760728f, 0.03088039f, -0.01009648f, -0.09685450f, 0.19656111f, 
    0.11450375f, 0.04019836f, -0.15371332f, 0.03566353f, 0.25664499f, -0.04597962f, 0.03155190f, 0.15348473f, 
    0.21844316f, -0.11847669f, -0.05118141f, -0.20573954f, -0.09613571f, 0.10986296f, -0.10377646f, 0.10756516f, 
    0.08031415f, -0.23729596f, 0.18412358f, -0.09193382f, -0.07207165f, 0.03475105f, -0.06472764f, 0.11569665f, 
    0.02206644f, 0.04929025f, 0.30818927f, -0.50682235f, -0.24485190f, -0.00617651f, -0.02282390f, 0.17512213f, 
    0.05538229f, -0.09856676f, -0.01821127f, -0.24054393f, 0.26579273f, 0.06051520f, -0.14911151f, 0.15939350f, 
    -0.07016554f, 0.18450128f, 0.05832283f, 0.02677739f, 0.19680063f, 0.13292694f, -0.16596662f, -0.05944792f, 
    0.21030696f, 0.02091759f, -0.01319377f, 0.11986116f, -0.05588343f, 0.00657388f, 0.07098161f, -0.19846624f, 
    0.11744190f, -0.07810619f, 0.17478211f, 0.17702720f, 0.04260279f, 0.00603077f, 0.24921791f, 0.49103135f, 
    -0.24372162f, -0.15062585f, -0.09773381f, -0.10495152f, 0.08520600f, 0.14110453f, 0.09155855f, 0.10736322f, 
    0.09680993f, -0.30068487f, 0.24842572f, -0.08735736f, -0.08724614f, 0.13318026f, -0.18312567f, 0.16452955f, 
    0.09834532f, 0.20603259f, 0.37263086f, -0.25437236f, -0.12115123f, 0.04924221f, 0.07244529f, 0.18965439f, 
    0.05654834f, 0.31004888f, 0.08408262f, 0.29104379f, -0.17800851f, -0.08951656f, -0.05885749f, 0.07295844f, 
    -0.03224538f, 0.14942080f, 0.47330275f, 0.07338429f, -0.23939820f, 0.11425817f, -0.02356723f, -0.04914454f, 
    -0.12644483f, 0.15929098f, -0.26692119f, 0.17845617f, -0.12293480f, 0.12372853f, -0.24599373f, -0.07164404f, 
    -0.04685939f, 0.03754194f, -0.04891348f, -0.02188431f, 0.02542032f, -0.41492769f, -0.35585433f, 0.03321515f, 
    -0.01120177f, -0.13465331f, -0.10987109f, 0.09313045f, 0.02118829f, 0.17797165f, 0.00151060f, -0.25773796f, 
    -0.19319263f, -0.10036377f, 0.13620339f, -0.05727128f, 0.01990138f, 0.02595609f, -0.30851075f, -0.48299077f, 
    -0.45414019f, -0.10092963f, 0.19596802f, 0.04299725f, 0.01888523f, 0.00943510f, 0.19854659f, -1.07266784f, 
    -0.26456034f, 0.05636542f, 0.07040155f, -0.06773338f, -0.01180399f, 0.23732060f, -0.01677725f, -0.17336690f, 
    -0.06616700f, -0.56153768f, -0.44893205f, -0.14820805f, 0.17753068f, -0.06337714f, 0.10990024f, -0.00973532f, 
    -0.08029233f, 0.41529858f, -0.16845325f, -0.19666137f, 0.05547841f, -0.12852965f, 0.06982350f, 0.09771881f, 
    0.18189271f, 0.02720790f, 0.18485773f, 0.34364307f, -0.34582406f, 0.17525825f, 0.01443973f, 0.05373258f, 
    0.06012881f, 0.04668521f, -0.06065337f, 0.00822962f, -0.50286084f, -0.08917453f, 0.16049510f, 0.10291700f, 
    0.06117138f, -0.08956911f, -0.01590346f, 0.19752656f, -0.44287843f, -0.50663161f, -0.57096457f, 0.00250611f, 
    -0.08275531f, 0.06892931f, 0.02837569f, -0.26955009f, -0.18409050f, -0.55187589f, -0.62166959f, -0.09622232f, 
    0.05606167f, 0.08175384f, -0.11078802f, 0.08395349f, 0.10480335f, 0.07730312f, -0.24558623f, -0.04271284f, 
    0.19511960f, -0.10281061f, -0.02143002f, -0.00892949f, 0.04760045f, 0.13447061f, 0.10145287f, 0.08682891f, 
    0.71749574f, 0.52434367f, -0.16019790f, 0.06254457f, -0.11073145f, 0.01657893f, 0.11098754f, 0.09497970f, 
    0.00516712f, 0.09212748f, 0.05515265f, -0.17882982f, -0.21933499f, 0.04607292f, 0.11191614f, 0.03092364f, 
    0.16296233f, -0.79311395f, -0.53079236f, -0.11930886f, -0.14716014f, 0.03584648f, -0.08843126f, 0.13251473f, 
    -0.06301064f, 0.14005880f, 0.73547477f, 0.18464307f, 0.06557179f, -0.14429736f, 0.12848991f, -0.29447445f, 
    0.03984318f, 0.01928773f, 0.03809814f, 0.22121233f, 0.32714498f, -0.14451431f, -0.01013363f, 0.19460845f, 
    0.00374117f, 0.11764889f, -0.19519073f, -0.01283443f, 0.06156716f, -0.00948824f, -0.13339931f, 0.08752770f, 
    0.19439547f, 0.12911130f, 0.04851030f, 0.17016825f, -0.05575557f, 0.16588373f, -0.07377482f, 0.01001648f, 
    -0.18038248f, -0.26088265f, -0.05969419f, -0.04374305f, 0.22179218f, 0.29091647f, 0.40786099f, 0.26845995f, 
    -0.10061871f, -0.08115832f, -0.10810438f, -0.11983131f, 0.16243061f, 0.02035492f, -0.03589822f, 0.14397950f, 
    -0.21129119f, -0.05278125f, 0.05792933f, 0.01539374f, 0.17586812f, -0.09905434f, -0.05237319f, 0.12435084f, 
    -0.08111313f, -0.03030028f, -0.02853027f, 0.04689495f, 0.02587346f, -0.00498951f, -0.09397760f, 0.05831907f, 
    0.05458907f, -0.08661347f, 0.02716666f, -0.04983712f, 0.05618755f, -0.00902584f, -0.08815687f, -0.08605227f, 
    -0.01728337f, 0.03250860f, -0.09035617f, -0.07655116f, 0.03791402f, -0.09758987f, 0.02129720f, -0.09063232f, 
    -0.04282668f, 0.00577539f, -0.02227715f, -0.10363223f, 0.05310257f, -0.00276910f, -0.07402861f, 0.04762403f, 
    -0.10111529f, -0.00042363f, -0.07588377f, -0.04941615f, -0.07061179f, 0.01836194f, -0.05064311f, -0.07029086f, 
    -0.06462858f, -0.04399223f, 0.06252538f, -0.07694970f, -0.06572743f, -0.05390058f, -0.04505701f, -0.00650523f, 
    0.07414202f, -0.05096220f, -0.01777293f, -0.08725569f, 0.03842643f, -0.05580449f, -0.04233477f, 0.04759518f, 
    0.03532484f, -0.04493491f, -0.04264214f, -0.06543841f, -0.00564546f, -0.01461893f, -0.09345420f, -0.03271525f, 
    0.05511691f, -0.00192569f, -0.07465693f, 0.00130455f, -0.05787719f, -0.03727837f, -0.03748989f, 0.00157918f, 
    0.02291950f, 0.02996084f, -0.03449758f, -0.03630746f, -0.00527625f, -0.00240400f, -0.10204843f, 0.02676841f, 
    -0.03767850f, 0.07779197f, -0.05979062f, -0.08770253f, -0.06136036f, 0.01752745f, -0.07979158f, -0.02792123f, 
    -0.08458891f, -0.01226658f, 0.08786523f, 0.02380170f, 0.05898812f, -0.03533631f, -0.00527296f, -0.05074550f, 
    -0.08217794f, 0.08170382f, 0.04350867f, -0.04870206f, -0.00290982f, -0.02169525f, 0.01453165f, -0.03354234f, 
    0.01724422f, -0.05938292f, 0.03938648f, 0.06350302f, 0.03931474f, -0.05795834f, -0.01395873f, 0.00704191f, 
    -0.02569114f, 0.01927876f, 0.00969490f, -0.08192892f, -0.06545713f, -0.06030982f, 0.01889627f, -0.02227652f, 
    -0.04500764f, -0.07449449f, -0.07592622f, 0.05750018f, -0.06430777f, 0.05275867f, -0.02312703f, 0.01122374f, 
    -0.00573042f, 0.00297920f, 0.02206670f, -0.05368834f, -0.04253405f, 0.00329043f, -0.04454774f, -0.03378387f, 
    0.00703745f, -0.06243784f, 0.04049799f, -0.07396535f, -0.03037104f, 0.00405971f, 0.01189709f, 0.03703255f, 
    0.16508099f, -0.01756179f, 0.04838917f, 0.22454894f, 0.32635698f, 0.03000183f, 0.06953219f, 0.12621242f, 
    0.07536516f, 0.20491655f, -0.07923435f, 0.14438394f, 0.14188536f, 0.16651350f, 0.04905981f, -0.05425391f, 
    -0.08442023f, 0.19975764f, 0.23102228f, 0.21376248f, 0.27841178f, -0.00228279f, -0.11667800f, -0.08187030f, 
    0.21510489f, 0.18815896f, 0.25367117f, -0.15919654f, 0.16180223f, 0.02376995f, 0.13234234f, 0.14358118f, 
    0.22455163f, 0.06844053f, 0.13636771f, 0.11305948f, -0.06481436f, -0.04063950f, 0.17220637f, 0.05470256f, 
    0.07799959f, -0.13371409f, -0.30669543f, -0.02306110f, 0.02261173f, 0.16996761f, -0.03068861f, 0.03683475f, 
    0.18095426f, 0.08501395f, -0.03125319f, -0.00603075f, -0.22462364f, -0.01436996f, -0.02903951f, -0.20612970f, 
    -0.04702658f, -0.03578612f, -0.14920391f, 0.12425169f, 0.10011435f, -0.08142716f, -0.02038302f, -0.16067015f, 
    -0.08176316f, 0.01722759f, -0.00720884f, 0.10893492f, 0.02894424f, -0.01810225f, 0.02996830f, -0.05293370f, 
    -0.04503756f, -0.07979529f, 0.02232482f, 0.26759449f, 0.30014035f, 0.11474524f, -0.16066784f, 0.10953688f, 
    0.12044884f, -0.00494562f, 0.11318218f, -0.04888655f, 0.25015622f, -0.07055591f, 0.25006840f, 0.14542702f, 
    0.05887749f, -0.04084909f, -0.39954287f, -0.25334382f, 0.25268668f, 0.00177255f, 0.02420560f, -0.12438077f, 
    -0.31424704f, -0.04851612f, -0.19456191f, -0.22283863f, 0.12712796f, -0.26841733f, -0.33317804f, -0.32876787f, 
    0.02569195f, 0.11030187f, 0.49007645f, 0.12643364f, 0.21988703f, 0.35790244f, 0.14515720f, 0.09229655f, 
    -0.11097574f, 0.22920375f, 0.06207571f, 0.21034303f, -0.17972344f, 0.00503462f, -0.01899660f, -0.22435249f, 
    0.12837258f, -0.16713116f, 0.08029680f, -0.09456603f, -0.43789643f, -0.44615099f, -0.13242950f, 0.13101079f, 
    -0.07139491f, 0.24472289f, -0.09227962f, -0.04496549f, -0.00672187f, -0.12379555f, -0.01267666f, -0.21849935f, 
    0.16978042f, -0.05555056f, 0.30400649f, 0.05909609f, 0.16505964f, 0.06835297f, 0.23306699f, 0.07302620f, 
    0.48369911f, -0.35163605f, -0.11607029f, -0.07889394f, 0.01038148f, -0.17481963f, 0.07358356f, 0.03230680f, 
    0.02589432f, 0.55192292f, 0.12044828f, -0.16035897f, -0.02235542f, -0.03743709f, -0.02921993f, 0.11173555f, 
    0.25986928f, -0.11037115f, 0.09108823f, -0.17328054f, -0.36436275f, -0.09570088f, -0.05977755f, 0.02183432f, 
    0.02363200f, 0.09828874f, 0.07466881f, 0.32467401f, -0.07938571f, 0.11242019f, 0.09176188f, -0.03120775f, 
    0.04391954f, 0.01824838f, -0.03382876f, -0.09150013f, -0.48343331f, 0.05941198f, -0.01591686f, -0.16773443f, 
    0.25532949f, 0.15051571f, -0.05851372f, 0.03512566f, 0.00014828f, 0.01729207f, 0.24305223f, 0.34035674f, 
    0.11298615f, -0.05054161f, -0.02164611f, 0.05010036f, 0.19462632f, 0.08837386f, -0.06278985f, -0.04710419f, 
    -0.26358053f, 0.07282995f, -0.04175264f, -0.09700350f, -0.07314026f, 0.08639217f, -0.12722689f, -0.21539301f, 
    0.05380487f, -0.06026481f, 0.12011769f, -0.09632800f, -0.27051005f, 0.16596694f, -0.18263055f, -0.02035489f, 
    -0.03127078f, 0.18942498f, -0.15661988f, -0.18446331f, -0.06147903f, 0.01486220f, 0.31957126f, -0.09271913f, 
    0.26135319f, -0.14541219f, 0.02611514f, 0.48951891f, 0.12217364f, 0.01430140f, -0.11079246f, -0.08656336f, 
    0.12218657f, -0.00876994f, 0.09908958f, 0.24735722f, 0.18714413f, 0.04854365f, -0.18638198f, 0.19560768f, 
    -0.05330206f, -0.19842650f, -0.12898907f, -0.07005667f, 0.12751739f, 0.10303061f, 0.06236047f, 0.05351936f, 
    -0.14352138f, 0.15814668f, -0.08243937f, -0.15724744f, -0.00877810f, -0.14241472f, -0.58922553f, 0.17555292f, 
    0.02248037f, -0.18981354f, 0.13057552f, -0.09496853f, 0.16628803f, -0.13253972f, 0.22051165f, -0.00136550f, 
    0.00011625f, -0.25461000f, 0.09099907f, 0.00970079f, 0.17373034f, 0.16370580f, -0.24121723f, 0.00095335f, 
    -0.29998755f, 0.14119408f, -0.12830363f, 0.06631298f, -0.21026720f, 0.09767924f, 0.13970433f, -0.03370393f, 
    -0.24642237f, -0.45215452f, -0.05198312f, 0.13466680f, 0.05001273f, 0.05179060f, 0.00406399f, -0.17737140f, 
    -0.21469991f, 0.28331557f, -0.16207878f, 0.02608724f, 0.02520023f, 0.14265369f, 0.08908497f, 0.10049798f, 
    -0.01816870f, 0.15530723f, -0.02421229f, -0.04327433f, -0.02142098f, -0.07910252f, 0.18793036f, 0.03771966f, 
    0.01682756f, 0.11731064f, -0.14161462f, -0.36242104f, -0.18028195f, 0.11570195f, 0.34511998f, -0.00685079f, 
    0.26599488f, 0.08722075f, 0.06381986f, 0.05855387f, 0.29464591f, 0.40037644f, -0.01402162f, -0.05724970f, 
    -0.05523958f, 0.11291789f, 0.14229460f, 0.19836289f, 0.08331252f, -0.30304074f, -0.59822595f, -0.26758108f, 
    -0.11121518f, 0.03265281f, -0.05732010f, -0.10224917f, -0.11358766f, -0.06529245f, -0.15754864f, 0.04391778f, 
    -0.00607887f, 0.09400059f, -0.13984713f, 0.07794336f, -0.10033550f, -0.06169865f, 0.04817173f, 0.02963997f, 
    0.21535721f, -0.09856264f, -0.21103646f, -0.29098418f, -0.00154279f, -0.08102361f, -0.00189781f, 0.25524512f, 
    0.19375171f, 0.32575053f, 0.01801497f, -0.01803487f, -0.32889679f, -0.08045076f, 0.03547399f, -0.16393432f, 
    -0.04410418f, 0.12168660f, 0.12190983f, -0.09019233f, 0.00669234f, -0.11050507f, 0.08338239f, 0.08400531f, 
    0.03853163f, -0.43500966f, -0.10942204f, 0.31661305f, 0.20991260f, 0.06120781f, 0.09559135f, 0.09140310f, 
    0.22948253f, 0.11719686f, -0.34566101f, 0.01267528f, -0.15849636f, -0.17081517f, -0.09776459f, -0.01449587f, 
    -0.08121558f, 0.16443619f, -0.02447855f, -0.32290280f, 0.08170731f, 0.33189639f, 0.07178158f, -0.00521343f, 
    -0.07921749f, 0.27921224f, 0.03577429f, 0.29581749f, -0.02482666f, -0.03567704f, 0.03809438f, 0.03921095f, 
    -0.08659687f, 0.21243778f, -0.14150891f, 0.04369551f, -0.06886920f, -0.27637354f, -0.09504261f, 0.27538773f, 
    -0.01586141f, 0.17405672f, -0.35315931f, -0.10622168f, -0.07539639f, -0.11913884f, -0.14230962f, -0.71042436f, 
    -0.30871937f, -0.11820339f, 0.00346124f, -0.27756837f, -0.17302036f, -0.22686869f, 0.00983194f, 0.00351779f, 
    -0.20841755f, 0.06835058f, 0.07738274f, -0.20661697f, 0.12288495f, 0.16453272f, 0.08039028f, 0.20010778f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10994099f, 0.05930315f, 0.02569724f, 0.20070992f, -0.05790597f, -0.02391037f, -0.01507994f, 0.10654984f, 
    0.15004385f, 0.29182339f, 0.12180670f, 0.05498428f, -0.01491933f, 0.21255991f, 0.37954512f, 0.09615967f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44328576f, -0.22806686f, -0.57037473f, -0.25711221f, -0.13912752f, -0.07756173f, 0.10803588f, -0.02219227f, 
    0.12378494f, -0.06868662f, -0.37368450f, -0.01169321f, -0.01571067f, 0.30818471f, -0.97044599f, -0.26230732f, 
    0.06990636f, -0.21300890f, 0.49652919f, -0.33990732f, -0.07182842f, -0.15495297f, 0.49673513f, 0.48733300f, 
    -0.25615376f, 0.05476828f, 0.12647268f, 0.25265869f, -0.01821097f, -0.16341902f, 0.36236459f, 0.43913248f, 
    0.16983896f, -0.12853807f, -0.06985752f, 0.12386862f, -0.17504869f, -0.17006165f, 0.46485394f, 0.28617290f, 
    -0.25806567f, -0.18427829f, 1.18622839f, 0.39713222f, 0.10060589f, 0.04774401f, 0.32599911f, -0.04886391f, 
    -0.24821010f, 0.24412461f, 0.11369771f, 0.56990486f, 0.20463467f, 0.23323022f, -0.01345394f, -0.55498749f, 
    -0.54234976f, 0.37094411f, -0.89744455f, 0.32187009f, 0.16760062f, -0.17544681f, 0.33082625f, -0.36958629f, 
    0.29955572f, 0.27099508f, -0.76340115f, 0.25081143f, 0.17084324f, -0.14406985f, -0.04633406f, -0.41306809f, 
    -0.31164899f, 0.15558340f, -0.00355481f, -0.46529129f, 0.01642758f, 0.05783814f, -0.20102455f, 0.00929278f, 
    -0.25768268f, -0.04440893f, -0.15186156f, 0.35184100f, -0.18685932f, 0.02235328f, 0.46590018f, -0.22202829f, 
    -0.05405988f, 0.21811630f, -0.35710719f, -0.15875606f, 0.14805295f, 0.22459230f, 1.01269794f, 0.22871500f, 
    -0.03935445f, -0.20340681f, 0.36659634f, 0.33034116f, 0.08878822f, -0.16869815f, 0.02564952f, -0.02273391f, 
    -0.20639482f, 0.00668110f, 0.29113215f, -0.31048813f, -0.03233804f, 0.20289639f, 0.10307660f, 0.38632962f, 
    -0.35551977f, -0.77915967f, -0.05374753f, 0.30689713f, 0.20816967f, -0.01620605f, 0.51435840f, 0.00969481f, 
    -0.15393156f, -0.32007676f, -0.08531104f, -0.05668847f, -0.07864761f, 0.21335030f, -0.07536636f, 0.07913402f, 
    -0.05181860f, 0.29441383f, -0.55363542f, 0.30009437f, 0.20896095f, -0.19947621f, -0.96233267f, -0.20964459f, 
    -0.46473727f, 0.34214881f, 0.48339820f, -0.68665117f, -0.09737331f, -0.14747392f, 0.26110175f, -0.22964646f, 
    0.20606177f, 0.30853996f, -0.25289589f, -0.20690204f, -0.04610017f, 0.12047744f, -0.35539645f, -0.37232500f, 
    0.14567797f, 0.34930709f, -0.18677588f, 0.23176801f, -0.08514243f, 0.02461219f, -0.01602679f, -0.51782161f, 
    -0.33005708f, 0.15896630f, 0.34061921f, -0.71265393f, 0.10259481f, -0.03311556f, 0.22602238f, 0.05296154f, 
    0.53202659f, 0.05107499f, -0.17146599f, 0.05999018f, 0.10893676f, 0.11708638f, 0.64396983f, -0.35071281f, 
    -0.20324230f, 0.09997477f, 0.50487649f, -0.28608599f, -0.04864246f, -0.15872271f, 0.20037951f, 0.40963760f, 
    0.15213144f, 0.04214764f, 0.03053910f, -0.11496831f, -0.15888789f, 0.13346545f, -0.51066250f, -0.53836155f, 
    0.03862862f, 0.25056937f, 0.14511992f, -0.50224692f, 0.17320405f, -0.23105480f, 0.21379963f, 0.24359839f, 
    -0.02190150f, 0.34336466f, 0.36163566f, -0.18110302f, 0.20250332f, -0.55712491f, -0.02432947f, -0.33966959f, 
    0.28190607f, 0.38008574f, 0.53260785f, -0.22686721f, 0.05830033f, 0.14158189f, -0.38168237f, 0.09043308f, 
    0.13063544f, 0.02800113f, 0.23440090f, -0.53261137f, 0.25295842f, 0.01241192f, 0.12260675f, 0.50051987f, 
    0.32208657f, -0.36523008f, -0.33188620f, 0.02526682f, -0.20687281f, -0.16960777f, -0.19897856f, -0.15293752f, 
    -0.25115901f, 0.11056045f, 0.04496587f, -0.26906350f, 0.20103206f, 0.42225745f, 0.01392337f, -0.28698951f, 
    0.10236625f, -0.36235103f, -0.31060413f, 0.27967411f, -0.13508333f, 0.14704905f, -0.38266233f, -0.08316696f, 
    -0.35236233f, 0.18043169f, 0.28679070f, -0.40489775f, 0.10217347f, 0.26424643f, 0.43306440f, -0.09876400f, 
    -0.00024687f, 0.49319908f, 0.62350512f, -0.09152732f, 0.01701704f, -0.11316834f, 0.13058202f, 0.06909037f, 
    0.44869709f, 0.05686750f, -0.80269682f, 0.21039833f, 0.10379862f, 0.00415292f, -0.56456298f, 0.37235436f, 
    0.08001310f, -0.06572608f, -0.08697948f, 0.17348689f, 0.21975061f, -0.06755409f, -0.07399751f, 0.15172224f, 
    -0.20060879f, -0.27262667f, 0.18339196f, -0.08720380f, 0.06350867f, -0.19679496f, 0.02158938f, 0.10192275f, 
    0.24413812f, -0.07199305f, -0.26728359f, -0.44138443f, -0.20149852f, -0.13168451f, 0.04246040f, 0.11277754f, 
    -0.34385923f, 0.32565677f, -0.37472874f, 0.50799710f, 0.21257205f, -0.33291179f, 0.15435222f, -0.29538473f, 
    0.27511913f, 0.21547112f, -0.71045387f, -0.08449114f, 0.17574564f, 0.06788246f, -0.08245125f, 0.17396976f, 
    0.16169067f, -0.12003551f, 0.06692643f, 0.15800717f, 0.05326499f, -0.21382268f, 0.36170536f, -0.09466625f, 
    -0.20645422f, 0.03338460f, -0.25211135f, -0.06580067f, -0.04984270f, 0.07163448f, 0.19676469f, -0.17262599f, 
    -0.24300960f, -0.09948866f, 0.21907365f, 0.20859116f, -0.02535259f, -0.21600933f, 0.16681527f, -0.02646326f, 
    0.30336437f, 0.44681045f, -0.38091427f, 0.15598029f, -0.20042834f, -0.24507204f, 0.59565443f, -0.38480422f, 
    0.14237244f, 0.24652719f, -0.64377934f, -0.33886141f, 0.14401978f, -0.20557180f, 0.58361971f, 0.48123723f, 
    -0.00579622f, -0.02321893f, -0.23059103f, -0.07145667f, -0.19933131f, -0.21883965f, -0.20233554f, -0.14648333f, 
    -0.17895406f, -0.20850217f, -0.03229296f, -0.15609139f, 0.12055612f, 0.18189310f, -0.03851686f, -0.15713403f, 
    -0.11698830f, 0.17020357f, -0.11639284f, 0.39690351f, 0.21781459f, -0.04096442f, -0.19850516f, -0.51378691f, 
    0.16341962f, 0.16903044f, -0.52034479f, -0.28853619f, 0.18741468f, 0.35205695f, -0.33929610f, 0.36800793f, 
    0.28411520f, 0.46986914f, 0.52472723f, -0.32198825f, -0.20958747f, -0.20261677f, -0.48321456f, 0.15376455f, 
    0.21126774f, 0.20794764f, 0.02986445f, -0.31612188f, -0.19539505f, -0.05801767f, 0.00731963f, -0.22032017f, 
    0.07497101f, -0.15219688f, 0.20124434f, -0.20326085f, -0.08841268f, 0.10752401f, 0.18581547f, -0.13683143f, 
    -0.14702326f, -0.22417136f, -0.08278213f, -0.27966863f, 0.14600408f, 0.08672745f, -0.12164019f, -0.16266952f, 
    0.01762067f, -0.10033122f, -0.15863253f, -0.15947138f, 0.03495028f, 0.17307261f, 0.20024647f, -0.19585966f, 
    0.17890324f, -0.13814174f, -0.14797169f, -0.20707092f, 0.00514945f, 0.13117032f, -0.08708110f, -0.07113570f, 
    0.12434218f, -0.18439682f, 0.58735067f, -0.06150430f, -0.12252790f, 0.17249410f, -0.18705335f, 0.08918075f, 
    0.45229495f, -0.04657398f, -0.32004231f, -0.19269487f, -0.21909134f, 0.23957901f, -0.25568730f, 0.42230228f, 
    0.07965121f, 0.06637128f, 0.67717618f, -0.29650766f, 0.14013022f, -0.24209574f, -0.25006449f, 0.30815318f, 
    0.57610339f, -0.14642657f, 0.35433891f, 0.04730789f, -0.21682370f, 0.13612083f, 0.43091339f, 0.30954039f, 
    -0.30927798f, -0.06364515f, -0.26762518f, 0.34346506f, -0.12171656f, 0.02510742f, -0.29055700f, -0.29512504f, 
    0.29342896f, 0.21001312f, 0.59953499f, 0.05712163f, -0.15529744f, 0.30853596f, 0.47083586f, 0.09351123f, 
    0.12816371f, 0.38354674f, 0.34356174f, 0.15710077f, 0.03679501f, 0.04114266f, 0.39977476f, -0.20215468f, 
    0.83960545f, -0.18467346f, -0.46060437f, -0.37017614f, 0.03002365f, 0.34933561f, -0.10495988f, 0.58186430f, 
    -0.27087897f, -0.24721001f, 0.55960715f, 0.17756771f, 0.04992813f, -0.22484235f, -0.13531791f, -0.03600078f, 
    -0.20450905f, 0.32598138f, 0.07264385f, 0.67732823f, -0.02819745f, -0.00855980f, -0.00993698f, -0.43166441f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04039084f, -0.06101958f, -0.31544733f, 0.37219977f, -0.26138976f, 0.23138873f, 0.46072245f, 0.11588083f, 
    0.23466682f, 0.36260194f, 0.37519777f, -0.10956356f, -0.17014636f, 0.29843524f, 0.43991780f, 0.50862676f, 
    -0.06192157f, -0.10725447f, 0.31250972f, 0.18156430f, 0.06713656f, 0.29248506f, -0.07358476f, 0.50333601f, 
    0.47597039f, -0.18276452f, -0.05377879f, 0.07602474f, 0.00126670f, 0.04093032f, -0.19773139f, 0.08406816f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06721678f, 0.01269974f, 0.06478491f, 0.06016680f, -0.10352478f, 0.01801408f, -0.14948685f, 0.03215618f, 
    -0.19955008f, -0.06991465f, -0.13191596f, 0.09383953f, -0.10385565f, -0.07858364f, 0.13694623f, 0.14502123f, 
    0.03340825f, 0.17467313f, -0.16528393f, -0.01174784f, -0.06930219f, -0.06155232f, 0.10894421f, 0.09304110f, 
    -0.14313748f, -0.09101993f, -0.05121072f, -0.07660913f, -0.16628127f, -0.10472345f, -0.07310688f, -0.10283619f, 
    -0.01770094f, -0.15314837f, 0.14708979f, 0.75130981f, 0.04175959f, 0.31225222f, 0.17198312f, -0.57031250f, 
    0.47802386f, 0.10853730f, -0.01262673f, 0.42475799f, -0.25913078f, -0.36837763f, 0.10492015f, 0.33599275f, 
    -0.48239964f, 0.09989655f, 0.24164401f, 0.00136396f, 0.09423684f, 0.13969414f, 0.16895992f, 0.18586108f, 
    -0.08276351f, 0.09121434f, -0.13558127f, -0.04505233f, -0.19860448f, 0.33044064f, -0.36384645f, 0.47535306f, 
    -0.11800622f, 0.07050369f, -0.25602221f, -0.10126442f, -0.02123985f, 0.32840532f, -0.10085111f, 0.36450824f, 
    -0.68127561f, -0.05059538f, 0.24784379f, -0.04911856f, -0.35676807f, 0.25556380f, -0.16659385f, 0.02017680f, 
    0.45657420f, -0.04480270f, 0.01486740f, -0.37262836f, 0.05142799f, 0.17891222f, -0.04428137f, 0.28860757f, 
    -0.03594179f, -0.08711001f, -0.17005432f, 0.08811537f, 0.01854216f, 0.06529058f, 0.49545696f, -0.47824648f, 
    0.27803946f, -0.07485574f, 0.03377635f, -0.55850106f, 0.35555235f, -0.21874100f, 0.01695650f, 0.40354455f, 
    0.27653027f, 0.44425645f, 0.02359970f, -0.12099772f, 0.65997022f, 0.30004823f, 0.13845228f, 0.30632386f, 
    0.06768982f, -0.06605160f, 0.19198009f, 0.49513304f, -0.03593697f, 0.03194763f, -0.14695762f, 0.07337118f, 
    0.63382304f, 0.05412820f, -0.07195158f, 0.05798971f, 0.28086555f, -0.02189242f, -0.03831992f, -0.12225445f, 
    -0.39351389f, 0.19586803f, 0.24892551f, -0.57273555f, -0.14551580f, 0.25679785f, 0.35785607f, -0.05612218f, 
    -0.21812066f, -0.17193240f, 0.40369803f, -0.15122089f, 0.56456763f, 0.47644228f, -0.29934338f, 0.06322315f, 
    -0.12425518f, -0.10317079f, -0.18540235f, 0.43268457f, -0.08011028f, 0.24777575f, -0.04147134f, -0.39004529f, 
    0.28588155f, -0.05928773f, 0.16599359f, -0.11613391f, 0.37574175f, 0.14981312f, 0.25411400f, -0.25269815f, 
    0.14279115f, -0.17570159f, -0.52471685f, 0.56376183f, 0.05311531f, 0.10242051f, 0.21403755f, 0.25060451f, 
    -0.40772927f, 0.06012461f, 0.36485860f, 0.10358493f, -0.59536499f, -0.03560742f, 0.31696853f, 0.33034268f, 
    -0.05871163f, -0.03264510f, 0.16261114f, -0.41109827f, 0.03652028f, 0.05988436f, -0.08201879f, 0.45014131f, 
    -0.10239383f, -0.00158079f, -0.06211333f, -0.01137788f, -0.15139560f, 0.19013113f, -0.12889172f, -0.01907260f, 
    0.26806751f, -0.14618838f, 0.20450950f, -0.24771975f, 0.46264446f, 0.16292079f, 0.10593719f, -0.44014224f, 
    0.46113768f, 0.03523842f, -0.36589739f, -0.04895408f, -0.06929664f, -0.01788330f, 0.15747997f, 0.23721451f, 
    -0.32612517f, 0.15440682f, -0.11903846f, -0.10924635f, -0.14154503f, 0.29965061f, -0.15253262f, 0.35073569f, 
    -0.26792958f, 0.09764934f, -0.00235760f, 0.23621812f, -0.21351705f, 0.24490416f, 0.28590050f, -0.04954715f, 
    -0.43666193f, -0.03080705f, 0.01816133f, -0.53073686f, -0.04999591f, 0.31142184f, 0.21138725f, -0.44988656f, 
    -0.60686785f, -0.02143594f, 0.40675834f, -0.04731929f, -0.44565868f, 0.00177148f, 0.14102793f, 0.10857768f, 
    -0.15958197f, -0.00911043f, -0.13032320f, -0.21660672f, 0.11911057f, 0.09855423f, 0.13055082f, -0.17951871f, 
    0.00465892f, -0.11077870f, -0.16029267f, 0.17146304f, 0.43861049f, 0.29113501f, 0.22698255f, -0.19217615f, 
    -0.01436432f, -0.02754590f, -0.24826242f, -0.77974749f, -0.14430474f, -0.10798939f, -0.05650894f, 0.51948214f, 
    -0.46789390f, 0.19936796f, 0.35627729f, 0.00421752f, 0.33380115f, 0.47167766f, -0.34305754f, -0.26650184f, 
    0.25999039f, 0.08862370f, -0.16389868f, -0.09559073f, -0.14846787f, 0.17194372f, -0.14257771f, 0.25840792f, 
    0.45196941f, 0.00207735f, -0.17017370f, 0.32180732f, 0.47022983f, 0.03063139f, 0.19015618f, -0.04750065f, 
    0.37164932f, -0.20725608f, -0.46572822f, -0.11089595f, 0.43527699f, -0.15616831f, -0.17599189f, -0.18322346f, 
    0.30607140f, 0.30481747f, -0.14765279f, -0.67765605f, 0.61007953f, 0.25063086f, 0.08796262f, 0.04703052f, 
    0.27445403f, 0.13110709f, 0.28805691f, 0.81395662f, -0.01437410f, 0.30916503f, -0.08077800f, 0.17821677f, 
    0.29488826f, -0.09700858f, 0.12521860f, -0.01615688f, -0.25918996f, -0.29366663f, 0.24175146f, -0.29816416f, 
    -0.39729181f, 0.23174636f, -0.11378821f, -0.15622586f, -0.10657680f, 0.23177235f, 0.13849236f, 0.54012078f, 
    -0.67370111f, 0.06673495f, 0.38662848f, -0.58254927f, -0.16720654f, -0.11728258f, 0.00927064f, 0.08962392f, 
    -0.12350459f, 0.06386590f, 0.18399413f, -0.03877717f, 0.00368491f, 0.11923315f, 0.07955460f, 0.01709282f, 
    0.05296731f, 0.10812057f, 0.09464743f, 0.15310772f, 0.12264806f, 0.07646503f, -0.06536482f, 0.00989252f, 
    -0.40447322f, -0.12323000f, 0.01785962f, -0.53114969f, 0.05135526f, 0.38241890f, 0.36067063f, 0.73075628f, 
    -0.16659379f, -0.22372575f, 0.19620036f, 0.46445975f, -0.72346264f, 0.13337772f, 0.05314209f, 0.41878700f, 
    -0.15954706f, -0.09554649f, -0.73469257f, 0.01286524f, 0.03233574f, -0.02290993f, -0.16698918f, 0.36894026f, 
    -0.10457132f, 0.00343770f, 0.11826696f, 0.29220319f, 0.07726643f, 0.08571450f, 0.44871804f, -0.44664177f, 
    -0.28882998f, -0.09249089f, 0.18227535f, -0.32109904f, 0.10968268f, 0.19279900f, -0.27418709f, -1.20068836f, 
    0.20529589f, 0.21835636f, 0.46071330f, -0.44695714f, -0.03330407f, -0.15705881f, 0.08704122f, 0.20250440f, 
    -0.32848740f, 0.13859119f, 0.18213177f, 0.61197948f, 0.04549346f, 0.14201619f, -0.16701351f, -0.41321391f, 
    0.23587848f, 0.03655421f, 0.12331585f, -0.11486363f, 0.05604549f, 0.15547092f, -0.04547232f, -0.06784242f, 
    0.30061543f, -0.47649267f, -0.24331351f, 0.25491676f, 0.34216806f, 0.02360006f, -0.43789127f, -0.21465437f, 
    0.25959229f, 0.36683181f, -0.02244875f, -0.58378220f, 0.03724286f, -0.02230591f, -0.07566027f, -0.35166857f, 
    0.33186975f, -0.01586715f, 0.23430935f, 0.61993384f, 0.06249437f, 0.10204237f, -0.02197050f, 0.41139388f, 
    0.20008601f, 0.10988756f, 0.04426989f, -0.09603632f, -0.34594297f, 0.13813595f, 0.07163725f, 0.21224904f, 
    -0.46894571f, 0.14655299f, -0.00527890f, 0.64040339f, 0.13096222f, 0.25221151f, 0.26043212f, -0.07943099f, 
    -0.35719854f, 0.02145773f, 0.18226072f, -0.08846720f, 0.12478945f, -0.41497600f, -0.04605603f, -0.03581410f, 
    -0.08524261f, -0.13215153f, 0.29554009f, 0.15100183f, -0.10164845f, 0.34439209f, -0.15967348f, 0.01977769f, 
    -0.57678640f, 0.08738855f, 0.17828719f, -0.25315315f, -0.35792440f, 0.09450421f, -0.04784946f, 0.28370565f, 
    0.32921267f, -0.24622558f, -0.18813257f, 0.59041399f, 0.08147468f, 0.07714988f, -0.01741775f, 0.73003113f, 
    -0.15509667f, 0.08429579f, -0.17551906f, 0.05280914f, -0.27324530f, -0.10190707f, -0.02802378f, -0.18632773f, 
    0.52003145f, -0.11484100f, -0.00236120f, -0.08821914f, -0.03885266f, 0.22380041f, 0.04585796f, 0.62514865f, 
    -0.15559562f, -0.03183568f, 0.08382473f, 0.35747001f, -0.22519106f, -0.05168278f, 0.47315601f, 0.28588679f, 
    -0.26978981f, -0.03050189f, -0.15825216f, -0.23482195f, 0.03979604f, 0.30368707f, 0.41679269f, 0.31278515f, 
    0.25655612f, -0.28045270f, -0.10228536f, 0.57193208f, -0.67907035f, 0.32417735f, 0.17668203f, 0.26662007f, 
    -0.24821012f, -0.05083004f, -0.82477742f, -0.09946411f, -0.00859877f, 0.06122712f, -0.06240621f, 0.42275196f, 
    -0.08125760f, 0.02106318f, -0.17703746f, 0.07043006f, 0.08001859f, 0.32925078f, 0.41739243f, -0.58368987f, 
    -0.36500111f, 0.34376869f, 0.08966507f, 0.61137027f, -0.05220204f, 0.30271256f, -0.05867129f, 0.00173709f, 
    -0.31950110f, -0.14544165f, 0.56292313f, -0.56300354f, 0.31847155f, -0.14181931f, -0.15117629f, -0.20302953f, 
    0.18705733f, -0.00086289f, 0.22973585f, 0.51419902f, -0.01883519f, 0.45772925f, 0.01894787f, -0.05574087f, 
    -0.08759085f, 0.08494329f, -0.15175992f, -0.17477313f, -0.16072343f, -0.10101421f, 0.29761335f, 0.02349313f, 
    -0.19317569f, -0.07607649f, 0.12913160f, -0.03541031f, 0.13174383f, -0.10288025f, 0.11043707f, -0.08589709f, 
    -0.14864580f, -0.03101599f, -0.02705749f, -0.02686274f, -0.04015639f, 0.05524140f, -0.06017611f, -0.00706727f, 
    -0.02746687f, -0.07473871f, -0.04010549f, 0.05232455f, 0.06738012f, -0.10772510f, 0.03610128f, -0.12898998f, 
    -0.06763954f, 0.13199192f, 0.01632419f, -0.10887425f, 0.13964488f, -0.17001773f, -0.07098455f, -0.16015217f, 
    0.20394552f, -0.15412106f, -0.02809520f, -0.17945109f, -0.32207116f, 0.07475477f, 0.08399318f, -0.01077814f, 
    -0.65259981f, 0.20738414f, 0.28740135f, -0.34918022f, -0.47522938f, -0.06057931f, 0.27124539f, 0.42347750f, 
    -0.13722770f, -0.10146372f, -0.19258238f, -0.01777056f, -0.01311943f, -0.24755056f, 0.07737387f, 0.11580490f, 
    0.01996893f, -0.11703766f, -0.02432978f, 0.13983648f, 0.31271058f, 0.36609945f, 0.08948631f, 0.11265847f, 
    -0.04163965f, -0.18820447f, -0.25599167f, -0.43424881f, 0.23977432f, -0.01957056f, 0.35084754f, 0.73562264f, 
    -0.06623925f, -0.06667022f, -0.09174751f, 0.08228087f, -0.40956807f, 0.62631369f, 0.14559545f, 0.07201602f, 
    0.11649281f, -0.07393004f, -0.37525988f, -0.35362542f, -0.01509152f, 0.24574456f, 0.08951527f, 0.31637004f, 
    0.24071099f, -0.08783658f, -0.13136423f, 0.28744259f, 0.21120930f, -0.00366432f, 0.51608664f, -0.28029856f, 
    -0.30446318f, 0.27531078f, 0.04519066f, 0.85108399f, -0.34185359f, 0.18607002f, -0.01651747f, 0.32950255f, 
    -0.05519354f, 0.11190634f, 0.42362836f, 0.08279587f, -0.05145295f, -0.25220585f, -0.10146469f, -0.23950298f, 
    0.32339486f, 0.13719010f, 0.29603982f, -0.24085481f, 0.02798006f, 0.00065790f, 0.14310069f, 0.02350273f, 
    0.12077759f, 0.07654934f, 0.18091591f, 0.09111886f, 0.39256421f, 0.05267562f, -0.00152984f, 0.39088452f, 
    -0.48570728f, -0.68426013f, -0.44504321f, 0.36895534f, 0.38176075f, 0.08038991f, -0.36511886f, -0.04871372f, 
    0.94951326f, 0.38420892f, -0.40113679f, -1.07961893f, 0.27375007f, 0.37290725f, -0.18028365f, -0.04942912f, 
    0.18101966f, 0.06145579f, 0.34789559f, 0.41341230f, 0.02138512f, 0.29752702f, 0.06574668f, -0.10334188f, 
    0.17582324f, 0.00868777f, -0.00722903f, -0.32928640f, -0.09284490f, -0.10236453f, -0.10586810f, -0.14299414f, 
    -0.32133198f, -0.07444512f, -0.23819779f, 0.90170503f, 0.08422127f, 0.25332451f, 0.21612720f, 0.27676755f, 
    0.82708108f, 0.15335883f, 0.08085425f, 0.72987264f, 0.01680592f, -0.15844809f, 0.14235589f, 0.53504807f, 
    -0.75270247f, 0.12642008f, 0.17347202f, -0.17586645f, -0.17714861f, 0.12595536f, -0.09697607f, 0.14581497f, 
    -0.08770802f, 0.14433885f, -0.18429747f, -0.43474072f, -0.40562502f, 0.05335343f, -0.47151801f, 0.53984374f, 
    -0.13698584f, -0.04007965f, -0.21004893f, -0.03037834f, -0.21611103f, 0.11197086f, -0.21000893f, -0.08830667f, 
    -0.03907048f, 0.10120943f, 0.04353343f, 0.14168642f, -0.06100580f, -0.04711569f, -0.11696488f, -0.00403987f, 
    -0.23347579f, -0.10815589f, 0.03851013f, 0.09868816f, -0.00700958f, 0.10263649f, 0.10426740f, -0.12371714f, 
    -0.09916916f, 0.13477720f, 0.15154298f, -0.16310762f, 0.01646638f, -0.06499359f, 0.02733651f, 0.01785736f, 
    -0.02245000f, -0.91556996f, -0.30184034f, 0.67503238f, 0.07316290f, -0.01744695f, 0.01305264f, 0.33058107f, 
    0.30302352f, 0.20151955f, 0.09549786f, 0.21463846f, -0.48506510f, -0.20505995f, -0.04189864f, 0.09793971f, 
    0.36993936f, -0.06861060f, -0.51866490f, 0.36221069f, -0.00136134f, 0.06468403f, 0.05263676f, 0.59386384f, 
    -0.14205682f, -0.10176712f, 0.05434987f, -0.20108654f, -0.01534765f, 0.29114726f, 0.39637581f, 0.12734307f, 
    -0.02332749f, -0.32566506f, -0.12506853f, 1.04790843f, 0.07342341f, 0.20085348f, 0.36953026f, -0.45625141f, 
    0.70734924f, 0.08391325f, -0.23512802f, 0.06589437f, -0.35009682f, -0.22975579f, 0.31092706f, 0.32469422f, 
    -0.26505607f, 0.14699119f, -0.09262542f, -0.58523208f, -0.14698680f, -0.10294078f, -0.13911021f, 0.63446373f, 
    0.12660879f, -0.12215093f, -0.04435962f, 0.07631724f, -0.42884257f, 0.30515000f, -0.37180039f, 0.31006223f, 
    -0.22623716f, -0.12132187f, 0.04495985f, -1.07283449f, 0.01060024f, -0.11099243f, -0.37350118f, 0.11044615f, 
    -0.07862090f, 0.17528063f, 0.12098309f, 0.11272235f, 0.49553803f, 0.20973538f, -1.03414834f, -0.70750809f, 
    0.28506589f, -0.03013868f, -0.20689660f, 0.01025428f, 0.11496161f, 0.03071337f, 0.07336324f, -0.51001078f, 
    0.24098483f, 0.00909711f, 0.15325476f, -0.01157595f, 0.14100148f, 0.13383593f, 0.19792426f, -0.20398153f, 
    -0.08690963f, -0.13137780f, -0.17274190f, 0.11633030f, 0.05191177f, -0.02937507f, -0.02484092f, 0.04612136f, 
    0.05041739f, -0.05830837f, -0.11841781f, -0.01256506f, 0.02722663f, -0.05934404f, -0.17229265f, -0.11434381f, 
    -0.05721229f, 0.10408825f, -0.16082361f, -0.00061584f, 0.06014494f, -0.10277352f, -0.14504568f, -0.11555046f, 
    -0.04857091f, -0.14707431f, 0.10283803f, -0.09283546f, 0.11830951f, 0.08658174f, 0.14409052f, 0.05811694f, 
    -0.14736508f, 0.00743987f, -0.05577216f, 0.02766858f, -0.05147299f, -0.07775529f, 0.07628968f, -0.17298330f, 
    0.08523378f, -0.10844381f, -0.15608366f, -0.09783129f, -0.05858790f, -0.02176474f, -0.17527676f, -0.04171187f, 
    -0.01686645f, -0.02066399f, 0.08907062f, 0.14503521f, -0.06137611f, -0.01034024f, -0.05779269f, -0.05284532f, 
    0.10307941f, -0.04424218f, 0.16950344f, 0.00090787f, -0.05197131f, -0.03790953f, 0.08617690f, -0.08941696f, 
    -0.00460332f, -0.25906140f, -0.06626268f, -0.29947445f, 0.40354121f, 0.29342183f, -0.05764751f, -0.69831657f, 
    0.04838613f, 0.22469322f, 0.08926995f, -0.63742322f, -0.02092197f, -0.07999931f, 0.36974019f, 0.38613790f, 
    -0.44689402f, 0.11020856f, 0.37957403f, 0.48320064f, 0.06761912f, 0.34116554f, -0.09645085f, -0.01470364f, 
    -0.15044504f, -0.02233880f, -0.15060675f, -0.21361041f, -0.16188996f, 0.16704857f, 0.15513542f, -0.38243520f, 
    -0.56714916f, 0.12326412f, -0.24133924f, 0.44543016f, -0.31798050f, 0.18568549f, -0.19622248f, 0.90125722f, 
    -0.23595242f, 0.37371492f, 0.55235761f, -0.03702454f, 0.02696741f, 0.13509130f, -0.40777642f, -0.20698221f, 
    0.53806090f, 0.06325386f, 0.20683689f, -0.17126982f, 0.12441767f, 0.20813148f, 0.10664145f, -0.12184624f, 
    0.32987052f, -0.09018879f, 0.05250740f, -0.00606827f, 0.02659026f, 0.05858438f, 0.18201549f, 0.34456068f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17785503f, 0.31807205f, 0.00919713f, 0.38154775f, 0.23277222f, 0.55289531f, -0.12820023f, 0.11947156f, 
    0.25071463f, 0.35914829f, 0.21010111f, 0.09294594f, 0.19301298f, -0.07454742f, 0.22452050f, -0.07838973f, 
    -0.00751170f, -0.13829270f, -0.18373775f, 0.46492597f, 0.15078576f, 0.23194812f, 0.16675302f, 0.41946229f, 
    -0.17588812f, -0.05839010f, 0.61580443f, -0.35036585f, -0.05886201f, -0.12512340f, 0.00648783f, 0.06910409f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02452121f, 0.05256620f, -0.10789037f, 0.14709310f, 0.25092185f, 0.05548577f, -0.77473801f, -0.03399665f, 
    0.23780811f, 0.03531824f, -0.47781840f, -0.49950781f, -0.27541625f, -0.13606001f, -0.67647994f, -0.15202965f, 
    -0.20067538f, -0.12149489f, -0.01325414f, -0.54203159f, 0.12283231f, 0.09515207f, 0.07200907f, 0.18349724f, 
    0.11957733f, 0.09268618f, 0.44575348f, 0.58384764f, 0.04218302f, -0.06588982f, -0.92295122f, 0.26804397f, 
    -0.11546618f, -0.25674921f, 0.29458159f, -0.10399615f, 0.14674342f, 0.04486805f, -0.34056470f, 0.26312575f, 
    0.29195485f, -0.08216976f, 0.25124964f, 0.23479237f, -0.24570651f, -0.35134292f, -0.04723948f, 0.09778433f, 
    0.12339444f, -0.01392666f, -0.13126205f, 0.33839136f, 0.26845878f, 0.14545739f, -0.34963909f, -0.61890620f, 
    -0.09505405f, -0.18985352f, -0.27982682f, -1.36333489f, 0.01486283f, 0.12610491f, -0.34985876f, 0.26998749f, 
    0.01548654f, 0.09569454f, -0.84464037f, 0.01868896f, -0.80472195f, -0.00895756f, 0.15830325f, -1.19156575f, 
    -0.84740126f, 0.06309399f, -0.66407162f, -0.08275776f, -0.06142466f, 0.04937667f, -0.53875721f, 0.02909303f, 
    0.16017266f, -0.57315344f, 0.12550248f, -0.14788428f, -0.16065268f, -0.04153495f, 0.36946374f, 0.28882316f, 
    0.01910226f, 0.61813545f, 0.48153007f, -0.13813792f, -0.14443839f, -0.09828313f, -0.07781405f, -0.37522158f, 
    0.09248381f, -0.03101407f, -0.44960177f, 0.31597552f, 0.28996283f, -0.30099863f, -0.08744106f, -0.23170243f, 
    0.22085010f, 0.25617602f, -0.18455473f, -0.44019687f, 0.32752299f, -0.00000071f, -1.34442544f, -1.17031372f, 
    -0.34487560f, -0.02026195f, -0.01006441f, -0.01930761f, 0.00233837f, -0.27795053f, 0.24743821f, 0.35266870f, 
    0.01878892f, -0.67548734f, -0.06878375f, -0.01558420f, 0.17270637f, 0.00148098f, 0.05031967f, -0.08338498f, 
    -0.17551240f, -0.55229259f, -0.05529636f, 0.10439645f, -0.09383773f, -0.60278302f, -0.02439102f, -0.33665529f, 
    0.05483134f, 0.20459208f, -0.11995235f, -0.49198067f, 0.09216712f, 0.30119500f, -0.25341776f, 0.36958942f, 
    -0.39526862f, 0.16870898f, 0.14276344f, -0.40055847f, 0.10333718f, -0.00143861f, 0.49803254f, -0.72517765f, 
    0.12392190f, -0.07449701f, -0.63530189f, -0.20830536f, 0.09795649f, -0.12951230f, 0.04656719f, 0.14802305f, 
    0.06842671f, -0.05352217f, 0.08906782f, -0.02187447f, 0.04900672f, -0.19157463f, -0.02180213f, 0.41428334f, 
    0.03433925f, -0.06615406f, 0.06010868f, 0.26564872f, 0.29957166f, 0.06824463f, -0.33736387f, -0.12156281f, 
    0.16468027f, 0.04295681f, 0.10546133f, 0.08627240f, 0.08662868f, 0.02232295f, -0.04564350f, -0.42635545f, 
    -0.02190293f, 0.31615266f, -0.50689596f, 0.17560335f, 0.10342129f, 0.08743377f, 0.05392693f, 0.08275348f, 
    0.10894666f, 0.34746507f, -0.43458787f, -0.94826633f, -0.71853989f, 0.11467686f, 0.20708317f, -0.46666497f, 
    -0.18612118f, -0.93806481f, -0.10856369f, -0.53816551f, -0.38128087f, -0.02097793f, 0.40282732f, 0.38398927f, 
    -0.57891655f, 0.11442298f, 0.17078485f, 0.07451773f, -1.24549949f, 0.05586746f, -0.11745771f, 0.35190800f, 
    0.08166096f, 0.72693956f, 0.25836799f, -0.11274185f, -0.05024941f, -0.18481825f, 0.01724958f, -0.08831640f, 
    -0.05302958f, -0.12619258f, 0.18216445f, -0.24042699f, 0.52057731f, -0.48777747f, -0.20096907f, 0.36593187f, 
    -0.06256071f, -0.70267814f, 0.12027335f, -0.53993988f, 0.55683488f, -0.63811147f, 0.28099346f, -0.28139338f, 
    -0.76371586f, 0.24479979f, -0.02035928f, -0.22608204f, -0.62636209f, 0.22736394f, -0.47170866f, -0.00322467f, 
    -0.12998478f, -0.22834213f, -0.93345404f, 0.17330399f, 0.07413547f, -0.03974348f, 0.04725349f, 0.16730233f, 
    0.04649265f, -0.02964639f, -0.56921232f, 0.17056359f, 0.13876364f, -0.05040346f, 0.38483331f, 0.32473427f, 
    -0.37006634f, -0.57227856f, 0.03600901f, 0.38815901f, 0.26573983f, -0.80804116f, -0.21478778f, -0.57662851f, 
    0.51962835f, -0.60849410f, -0.02302746f, 0.45670655f, 0.05956495f, -0.47126788f, -0.76726687f, 0.03988560f, 
    -0.08507670f, -0.53794414f, 0.25134125f, 0.06449927f, -0.00107688f, -0.00762033f, 0.24600375f, -1.12435222f, 
    -0.19672254f, 0.07228379f, -0.39939305f, -0.13781132f, -0.29958928f, 0.26591542f, -0.23589940f, 0.09340762f, 
    -0.33628941f, 0.22333333f, 0.20978130f, -0.38988099f, 0.37596369f, -0.00648358f, 0.14110716f, -0.38862887f, 
    -0.63559395f, 0.07148106f, 0.15296684f, 0.08180076f, -0.53405142f, 0.10154320f, -0.00944228f, 0.40358046f, 
    -0.17327742f, -0.32027489f, 0.27237085f, -0.13739678f, 0.07126807f, -0.15045717f, 0.15893525f, 0.34604272f, 
    -0.00728220f, -0.44453746f, 0.34022304f, 0.03581559f, -0.57914430f, 0.24223305f, 0.13064267f, -0.20478317f, 
    0.23279119f, 0.43715551f, -0.38460055f, -0.05527092f, -0.37046191f, 0.15367763f, -0.37955576f, 0.63902003f, 
    0.03620420f, -0.56146270f, 0.15765047f, 0.01070634f, 0.19810580f, -0.78851420f, -0.40253246f, -0.39015627f, 
    -0.08567829f, 0.28649312f, 0.03129233f, -1.06066132f, 0.14541613f, -0.06054831f, 0.18902026f, -0.40029824f, 
    -0.08604199f, -0.07900017f, 0.06871905f, -0.52244782f, 0.13456169f, 0.04430159f, 0.34168455f, 0.04693027f, 
    -0.98455149f, 0.11806148f, 0.06190483f, 0.35272169f, -0.12548496f, -0.31232280f, 0.33612317f, 0.08987794f, 
    0.46985295f, 0.13003272f, -0.08900493f, -0.37279028f, -0.06902719f, -0.41081151f, 0.10238170f, 0.07034194f, 
    0.04051671f, -0.20872083f, 0.03321345f, -0.10930303f, -0.08130410f, 0.04841938f, 0.23990701f, -0.39648908f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23219228f, 0.47048849f, 0.05661951f, 0.11851062f, 0.06933887f, -0.46889931f, -0.08214322f, 0.22758642f, 
    0.13185790f, 0.39478776f, -0.21167907f, -0.28261536f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
