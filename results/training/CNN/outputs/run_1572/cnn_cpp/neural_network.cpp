#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.17170274f, -0.84398597f, -0.83095646f, -0.54208696f, 0.30769169f, 0.28932205f, 0.25296688f, -0.13412677f, 
    0.58264291f, -0.26020536f, -0.01915919f, 0.28468794f, -0.26710635f, 0.05033273f, -0.23430090f, -0.34545889f, 
    0.23480509f, -0.05130669f, 0.19926645f, 0.04842549f, -0.00552132f, -0.21173649f, -0.31294227f, 0.40055647f, 
    0.22786345f, 0.44876429f, -0.10602593f, 0.16230221f, 0.02506736f, -0.08244598f, 0.66358840f, 0.30733591f, 
    -0.62570924f, -0.17695099f, 0.39103445f, 0.33981359f, -0.08384707f, -0.39942321f, -0.38396466f, 0.57984805f, 
    -0.18589742f, 0.13987333f, 0.06210089f, 0.19624069f, -0.20194566f, 0.12311340f, 0.34182802f, 0.29439431f, 
    -0.15801688f, -0.06981564f, 0.64405948f, 0.28733456f, -0.82081324f, -0.56282955f, 0.48508754f, -0.12693892f, 
    0.42374021f, 0.13989425f, -0.70078540f, -0.73650777f, -0.39680430f, -0.28711593f, -0.18697210f, -0.18979146f, 
    0.20903507f, -0.04738708f, -0.22191149f, 0.23297207f, 0.41978970f, -0.09264626f, -0.13350068f, -0.30982921f, 
    -0.03505249f, -0.48941669f, -0.43315187f, -0.49188620f, -0.79524440f, 0.46070552f, 0.97252434f, 0.54152763f, 
    -0.03259199f, -0.26665300f, -0.47054616f, -0.21560787f, -0.08063447f, -0.39702046f, 0.04629534f, -0.47960380f, 
    -0.22135215f, -0.35161129f, 0.06303988f, 0.05335875f, 0.10297301f, 0.42210943f, 0.10309213f, -0.09646112f, 
    0.11053947f, -0.03515763f, -0.02628171f, -0.00832540f, 0.73461449f, 0.29570380f, 0.47228435f, 0.48589495f, 
    0.50366187f, -0.31775159f, -0.27608663f, 0.17923784f, -0.04701560f, -0.06711920f, 0.01447176f, 0.00761284f, 
    0.30284724f, 0.05390167f, -0.32930982f, -0.19320711f, 0.10964367f, 0.04851661f, -0.07974362f, 0.20005555f, 
    -0.15767595f, 0.12830409f, -0.07520012f, -0.02325086f, 0.04856877f, -1.26974368f, 0.29057467f, -0.62727213f, 
    -0.11017722f, 0.81204367f, 0.39762199f, 0.32373932f, 0.42555210f, 0.31192446f, 0.15129183f, 0.01863367f, 
    0.02213431f, 0.06643210f, 0.01798954f, 0.16997832f, 0.10045210f, -0.16619085f, -0.12741186f, -0.15363988f, 
    -0.31133908f, 0.00203584f, 0.51636410f, -0.27567691f, -0.12969543f, 0.26341596f, -1.10487783f, -0.58773780f, 
    -0.29704273f, -0.74733436f, -0.57675314f, 0.19394682f, 0.41314244f, -0.51660448f, -0.40119386f, 0.71568686f, 
    0.04408811f, -0.42405316f, -0.42566168f, -0.23061828f, -0.21573660f, -0.14424089f, 0.06865447f, -0.26224077f, 
    -0.14589562f, -0.32683745f, -0.16332787f, -0.37684509f, 0.12386132f, -0.16664270f, -0.03941274f, -1.23012292f, 
    -0.41526562f, -0.15664239f, -0.54538292f, -0.09559826f, 1.05163777f, -0.43744472f, -0.53476453f, 0.29099438f, 
    0.42258140f, -0.41933295f, -0.43766531f, -0.40268344f, -0.40743083f, -0.24764852f, 0.21632275f, 0.17555588f, 
    -0.12648493f, -0.00613022f, 0.01395293f, -0.00894656f, 0.04001409f, -0.08950017f, -0.04692785f, -0.07765540f, 
    -0.41816962f, -0.15178785f, -0.19890609f, -0.60788757f, -0.55618352f, 0.77632016f, 0.19675487f, -0.38994101f, 
    -0.18478049f, -0.27091545f, -0.04956645f, 0.85293955f, -0.14587307f, -0.01820179f, -0.24464926f, -0.56451583f, 
    -0.34990868f, -0.16441371f, -0.04246224f, -0.03946560f, 0.26545310f, 0.49355438f, 0.33862701f, 0.35722718f, 
    0.10911003f, 0.50729173f, 0.59780657f, 0.50205433f, 0.22078957f, 0.32106885f, 0.20486258f, -0.42139605f, 
    -0.08554847f, -0.58428842f, -0.61571413f, 0.02918744f, -0.23751324f, 0.13010497f, -0.03920180f, -0.10655430f, 
    -0.01721738f, 0.25850129f, 0.12543158f, -0.18494853f, 0.00216000f, 0.14642058f, 0.02894546f, -0.30688694f, 
    0.11951239f, -0.32064244f, -0.45813692f, -0.17958896f, -0.72863746f, -0.54463613f, -0.47816435f, -0.37844083f, 
    -0.11791328f, -0.30681905f, -0.39545515f, -0.00927875f, 0.15163587f, 0.38564324f, 0.36240891f, 0.09042273f, 
    -0.01319822f, 0.28797331f, 0.10060725f, -0.03277238f, -0.04499968f, -0.43288895f, -0.23829301f, -0.05465908f, 
    -0.01656866f, -0.16535535f, -0.19766103f, -0.16439058f, -0.88563722f, -0.51181167f, -0.42382982f, 0.16333210f, 
    0.47572452f, 0.12936692f, -0.45563051f, -0.00937493f, 0.58169222f, -0.20879897f, -0.07681173f, 0.42983076f, 
    -0.24903230f, 0.32948217f, -0.29273370f, -0.33597222f, 0.27348971f, 0.11789439f, 0.21056320f, 0.01708065f, 
    -0.18815947f, -0.27991262f, 0.32458651f, 0.40768588f, -0.34274882f, -0.73760903f, 0.04627046f, 0.52538913f, 
    0.17233032f, 0.35022062f, 0.67053407f, 0.15004355f, -0.40264845f, -0.50819778f, -0.25379911f, -0.17203005f, 
    0.53411192f, -0.04151447f, -0.12393549f, -0.31507608f, 0.31458133f, 0.17731109f, -0.17218088f, -0.07508983f, 
    0.17442456f, -0.20326728f, -0.37636048f, 0.38525811f, 0.16997334f, -1.05832124f, -0.51019263f, 0.31526238f, 
    0.47308093f, 0.83549494f, 0.25094956f, 0.14627813f, 0.49342731f, -0.14684904f, -0.07232299f, -0.29889336f, 
    -0.32829085f, -0.29972631f, 0.26000527f, 0.02437462f, 0.21922104f, -0.17467356f, -0.12904394f, 0.14482239f, 
    -0.03111468f, -0.30286476f, 0.05911028f, -0.06851533f, 0.06526583f, 0.17899542f, 0.83093542f, -0.53979146f, 
    -0.00966928f, 0.00875022f, -0.59777510f, -0.52187020f, -0.59528422f, -0.13456765f, -0.26316282f, -0.53492069f, 
    0.39342928f, -0.39688981f, 0.17591529f, 0.40936893f, -0.43606922f, 0.09937891f, -0.22213665f, -0.10243748f, 
    -0.22693305f, -0.58709544f, -0.50888246f, 0.06011027f, -0.10634574f, -0.37521082f, -0.35500872f, -0.33596617f, 
    0.56066263f, 0.66943437f, -0.77060980f, -0.67886424f, -0.48783723f, -0.11215154f, 0.14797238f, 0.50199860f, 
    -0.18635285f, 0.02038403f, -0.19245370f, 0.18905331f, 0.29872933f, -0.23458605f, 0.14756796f, 0.29594094f, 
    -0.06364726f, -0.32639900f, -0.19438855f, 0.12140129f, -0.05270978f, -0.33482414f, -0.51156926f, -0.56868041f, 
    0.69504690f, 0.29363966f, 0.28017294f, -0.17377581f, 0.20809995f, -0.07403956f, 0.16972364f, -0.12057474f, 
    -0.28171504f, 0.00923611f, -0.04953372f, -0.25572464f, 0.23230854f, -0.00995302f, -0.57663870f, -0.30089542f, 
    -0.41946557f, 0.10603569f, 0.12256349f, 0.02098176f, 0.06336684f, 0.26118845f, 0.17894395f, 0.04100164f, 
    0.36809540f, 0.98937690f, -0.83895463f, -0.62221104f, -0.29020169f, 0.20604233f, 0.13279162f, 0.48377264f, 
    0.65499586f, -0.21379943f, 0.07048602f, -0.31612986f, -0.37899855f, -0.11882829f, -0.23580229f, 0.32581735f, 
    -0.08670230f, -0.29376736f, 0.01622952f, 0.15865511f, -0.47062483f, 0.48074061f, -0.06934951f, -0.22512211f, 
    -0.06377254f, -0.10952965f, 0.02550394f, 0.10285492f, 0.45083529f, 0.38234541f, -0.15392968f, 0.00912578f, 
    0.46142954f, 0.25074098f, -0.24053340f, 0.41769439f, 0.02530183f, 0.26113003f, -0.09324774f, -0.53591180f, 
    -0.35541716f, 0.08736244f, 0.12291141f, 0.26746327f, -0.00765079f, 0.05497551f, 0.16524601f, -0.38090137f, 
    -0.08160729f, -0.26671806f, -0.29210231f, -0.80972111f, 0.17299986f, 0.44731209f, -0.47616625f, -0.48721591f, 
    -0.27183756f, 0.19850326f, 0.64297086f, 0.32463834f, 0.14104787f, -0.25810724f, 0.19969693f, -0.15942033f, 
    -0.17184260f, 0.03369735f, 0.17788322f, 0.39510134f, -0.08692649f, 0.21369016f, 0.29350436f, 0.00734171f, 
    -0.05731492f, 0.04125892f, -0.09990094f, 0.10571498f, -0.17706098f, 0.29117104f, -0.11032569f, -0.06472427f, 
    -0.51934183f, -0.11092177f, -0.29655471f, 0.20258543f, 0.00422694f, 0.24336439f, -0.16927503f, 0.28879759f, 
    -0.17805669f, 0.15232448f, -0.01238142f, -0.15288727f, -0.34019282f, 0.29576394f, -0.15281825f, -0.48375714f, 
    0.22444591f, 0.15520912f, 0.32574239f, 0.44198856f, 0.45048124f, 0.61257982f, 1.33055437f, 0.57148165f, 
    -0.89503551f, -0.09843481f, -0.63965452f, 0.06367263f, -0.24356572f, -0.40355670f, -0.04535572f, -0.08627801f, 
    0.29087386f, 0.24048255f, 0.18601848f, 0.21852022f, 0.15999413f, -0.34540182f, -0.27322572f, 0.16369493f, 
    -0.14944229f, 0.07610684f, 0.44389936f, 0.02711911f, -0.12706037f, 0.01628104f, -0.65724248f, 0.08594912f, 
    -0.40872025f, -0.13685964f, 0.36294276f, 0.34458709f, 0.58061898f, 0.46335313f, 0.30387819f, 0.34369862f, 
    0.03728288f, 0.25986853f, 0.25455824f, 0.10637653f, -0.35884839f, -0.21097548f, 0.04990522f, -0.14555724f, 
    -0.42515802f, 0.14582953f, 0.05847010f, 0.09858035f, 0.07519720f, -0.23714280f, 0.02400730f, -0.73092729f, 
    -0.43427211f, 0.13445222f, 0.33653489f, 0.16100857f, -0.40367690f, -0.40077251f, -0.62983268f, -0.63846087f, 
    -0.32103789f, 0.18892543f, 0.15504713f, -0.00964351f, -0.55411184f, -0.22485426f, 0.00640370f, 0.01914688f, 
    0.03553775f, 0.19571656f, 0.30142945f, 0.26554453f, -0.25944811f, 0.18414268f, 0.20926613f, 0.54104120f, 
    -0.12935841f, 0.43335724f, 0.19160312f, 0.43340653f, 0.51228172f, -0.48671055f, -0.37339681f, -0.24108684f, 
    0.14025633f, 0.60419726f, 0.45984271f, 0.10675634f, -0.11744578f, 0.09485059f, -0.28301266f, -0.27647111f, 
    -0.10608447f, 0.00163271f, -0.06730435f, -0.17424516f, -0.24962835f, 0.18886973f, -0.00331552f, -0.26538980f, 
    -0.59240830f, 0.15465795f, -0.03387038f, 0.42562863f, 0.08712979f, 0.46566746f, -0.65800500f, -0.25954342f, 
    0.33247250f, 0.62445503f, 0.29669452f, 0.21229835f, 0.35015029f, 0.22637084f, 0.12009101f, -0.35760838f, 
    0.20944677f, -0.30990574f, 0.08309384f, -0.02740890f, -0.49101776f, -0.25398353f, 0.06448695f, -0.09956907f, 
    0.11381618f, 0.31334031f, 0.36753979f, 0.08230632f, 0.14642417f, 0.42510796f, 0.25113472f, 0.11006010f, 
    0.32919365f, 0.10820402f, 0.40174469f, 0.02970320f, -0.40881714f, -0.27464604f, -0.23747419f, 0.10253656f, 
    0.28023776f, 0.15850911f, -0.09659927f, -0.07549182f, -0.23924139f, -0.35826346f, -0.39953357f, -0.33881363f, 
    -0.01458076f, -0.17563081f, 0.08603261f, 0.62559795f, 0.43386400f, 0.33168897f, 0.04178892f, 0.01304136f, 
    0.15292531f, 0.25323385f, -0.06404603f, 0.07888866f, 0.02588267f, 0.17475718f, 0.14833544f, 0.18884428f, 
    -0.10776906f, -0.07296661f, -0.14767627f, 0.06387016f, 0.12243017f, 0.11479977f, -0.05937691f, 0.06596131f, 
    0.31753936f, 0.11034618f, -0.16327387f, -0.26541555f, -0.55016160f, -0.77691460f, -0.70023793f, -0.69724959f, 
    -0.44847101f, 0.34923181f, 0.22759399f, 0.67254651f, 0.38290501f, 0.30609930f, 0.06980615f, 0.25793415f, 
    0.36083999f, 0.22062302f, -0.06464650f, -0.14731210f, -0.26691261f, -0.15537137f, -0.14081573f, 0.15981817f, 
    -0.31610209f, -0.16905391f, 0.09914874f, -0.21135165f, -0.28121531f, 0.40305176f, 0.42146626f, 0.18929851f, 
    -0.08193914f, -0.06026064f, 0.37226751f, -0.76952040f, -0.22270684f, 0.52603483f, 0.00753780f, 0.37200761f, 
    -0.24896616f, -0.09540661f, 0.00319399f, 0.21398568f, 0.10374448f, 0.30676371f, 0.19942567f, -0.07568915f, 
    0.01312793f, -0.16217442f, -0.04057971f, -0.25348306f, 0.34639958f, -0.19500285f, 0.18330224f, 0.32775420f, 
    0.26627731f, -0.29115862f, -0.27660173f, -0.11196704f, -0.38555366f, -0.08007212f, -0.22991660f, -1.04166293f, 
    -0.05089059f, 1.02873385f, -0.49619383f, 0.49280098f, -0.35426134f, 0.17798421f, -0.12268589f, -0.17984110f, 
    -0.24842796f, -0.44497961f, 0.00016315f, -0.24879792f, 0.16550283f, -0.04371107f, -0.23174945f, -0.43076015f, 
    -0.43682036f, -0.46949181f, -0.31551304f, 0.16687037f, -0.06961595f, -0.70624495f, -0.78948313f, -0.64390099f, 
    -0.49683094f, -0.04085542f, -0.21222106f, 0.31617901f, 0.68516850f, -0.46703652f, 0.11334795f, -0.49829903f, 
    -0.35980162f, -0.30543578f, -0.52046937f, -0.28762203f, 0.12812547f, -0.00162430f, -0.07132468f, 0.32057333f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43447345f, 0.05332037f, -0.10130654f, -0.05729707f, -0.36474210f, 0.25578114f, -0.18925375f, -0.17619431f, 
    -0.03571020f, -0.04717890f, 0.01751485f, 0.33584473f, 0.34613743f, 0.33242568f, 0.08005191f, 0.08966018f, 
    0.12578851f, 0.21080415f, 0.15814464f, 0.23268610f, 0.02732612f, 0.15569401f, 0.10172593f, 0.02556169f, 
    0.03478954f, 0.09489502f, 0.40782592f, -0.12228417f, 0.14154461f, 0.02669706f, 0.15325141f, -0.13651447f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02112865f, 0.30458674f, -0.29488310f, 0.48763424f, 0.12072448f, 0.24258187f, -0.20164295f, 0.40213904f, 
    0.08358645f, 0.03849583f, 0.03770044f, -0.14301655f, -0.09502301f, 0.22377144f, -0.18779688f, 0.22706304f, 
    0.01948206f, -0.12862891f, 0.15764396f, -0.07849951f, -0.15927459f, 0.03163997f, -0.05585040f, -0.00127537f, 
    0.01134637f, -0.01678415f, 0.03816460f, 0.07477838f, -0.00042543f, 0.17630382f, -0.02057509f, -0.13535716f, 
    0.03011891f, 0.09611551f, 0.02681107f, 0.06128401f, 0.00890255f, -0.19364360f, -0.32113221f, -0.11882529f, 
    -0.01399597f, 0.06245209f, 0.01899574f, -0.02034907f, 0.06303100f, -0.08924685f, -0.13500094f, -0.07834376f, 
    0.07867610f, 0.07154658f, 0.03808845f, 0.02050304f, -0.21679911f, -0.01754037f, -0.14511591f, 0.10083482f, 
    -0.13289717f, 0.05567898f, -0.08864132f, -0.15809359f, -0.29739180f, -0.14117168f, 0.17443681f, -0.03717875f, 
    -0.15441969f, -0.00623827f, 0.03531753f, 0.09329712f, 0.18931246f, -0.00388484f, 0.15355939f, 0.06718332f, 
    0.17411573f, 0.22409026f, -0.09620266f, -0.05185549f, 0.05106536f, -0.05937235f, 0.13305463f, -0.12003877f, 
    -0.14976329f, 0.04709429f, 0.02677188f, -0.02274820f, 0.14303106f, 0.17646268f, -0.21548764f, 0.16617709f, 
    0.06431359f, 0.00869540f, 0.08883172f, -0.03524334f, -0.08275802f, 0.10602987f, 0.12311859f, -0.15844794f, 
    0.35980368f, 0.20687851f, 0.14598002f, 0.10545388f, 0.01985041f, -0.06564931f, 0.02147949f, 0.07106048f, 
    -0.15679988f, -0.14702120f, -0.09772300f, 0.09289475f, 0.24943058f, 0.02852787f, 0.00989924f, 0.13404487f, 
    -0.07389995f, -0.02502423f, -0.05146550f, -0.07260936f, 0.01140981f, 0.08434152f, -0.06091852f, -0.01647696f, 
    0.09525725f, 0.06287235f, 0.08105691f, -0.01287926f, -0.02964705f, 0.11942184f, -0.12576964f, -0.02970406f, 
    0.09684068f, 0.06982636f, -0.03797966f, -0.06826199f, -0.17967209f, 0.54953027f, -0.00671235f, 0.20542645f, 
    0.00771895f, -0.03214071f, 0.03863262f, 0.23332427f, 0.05453225f, -0.04393550f, 0.04792367f, -0.15173049f, 
    -0.16359922f, -0.20733199f, 0.16431089f, 0.04235712f, 0.17314059f, 0.03881696f, 0.11169730f, 0.02504937f, 
    0.23849694f, 0.05536198f, 0.16070481f, 0.21655597f, -0.03331503f, -0.26155362f, 0.25005877f, -0.00156146f, 
    -0.00234412f, -0.04692137f, 0.15432210f, -0.06529341f, 0.05477450f, 0.20363753f, 0.06622633f, 0.22643194f, 
    0.06517081f, 0.11500137f, 0.03454593f, -0.12042207f, 0.08452836f, 0.13354048f, -0.00937353f, 0.03652493f, 
    -0.06716738f, 0.10069986f, -0.01265826f, 0.21486993f, 0.17644811f, -0.18130864f, 0.27438587f, -0.23665173f, 
    0.04593196f, -0.05370218f, 0.07623189f, 0.01546150f, -0.05632890f, -0.07942963f, 0.00452385f, 0.05943627f, 
    0.10460341f, 0.01898824f, -0.08515808f, -0.02142190f, -0.10032195f, 0.07133609f, -0.05488162f, 0.08227725f, 
    -0.06095696f, -0.04497067f, -0.10756086f, -0.04018332f, -0.00429787f, 0.29050818f, -0.06548332f, 0.01649164f, 
    -0.13078858f, 0.12822555f, -0.14615887f, 0.01913948f, 0.18957596f, 0.08142408f, 0.06030685f, 0.19287945f, 
    0.02737147f, -0.02225282f, 0.03523495f, -0.13734889f, 0.01173718f, -0.01683795f, -0.03554984f, 0.02379437f, 
    0.04988043f, 0.05479449f, 0.03363176f, 0.11042498f, -0.12937541f, -0.32966593f, 0.28456628f, -0.08468615f, 
    0.03932950f, 0.09036598f, 0.14372997f, 0.08191247f, -0.09267054f, 0.09301528f, 0.08504333f, -0.16438067f, 
    -0.04469908f, -0.04020688f, -0.00090027f, -0.09074022f, 0.06232807f, -0.00085915f, 0.03998894f, 0.16379321f, 
    -0.23137720f, -0.04420533f, -0.09855422f, -0.24794383f, 0.57743204f, -0.56593680f, -0.12592667f, -0.00416921f, 
    0.01160884f, 0.08289764f, 0.06855905f, 0.01401773f, -0.15996400f, 0.08126574f, -0.02199481f, -0.06274486f, 
    -0.10885447f, -0.08196631f, 0.13107726f, -0.15401840f, -0.07221531f, 0.02234911f, -0.04466995f, 0.06593806f, 
    0.09696245f, 0.08174113f, 0.09473779f, 0.03935865f, 0.14012265f, 0.04256618f, -0.07582188f, -0.03635849f, 
    -0.09602654f, -0.10689782f, 0.17542604f, -0.07059912f, -0.09593803f, 0.00169584f, -0.04394063f, -0.05591523f, 
    -0.03438474f, 0.22361510f, -0.18418470f, 0.05959621f, -0.18851441f, -0.08010333f, 0.01118453f, -0.03211862f, 
    -0.00829780f, 0.00745212f, -0.16004965f, 0.00816331f, 0.08523429f, 0.15418236f, -0.00974761f, -0.15933532f, 
    -0.08932412f, 0.10158654f, -0.02007401f, 0.08532459f, -0.20644817f, -0.00663949f, -0.06276853f, 0.05327749f, 
    0.00269239f, 0.02853242f, 0.23945014f, -0.08226317f, -0.04055962f, -0.01663490f, -0.00589997f, -0.04946447f, 
    0.06317618f, 0.02244744f, -0.03919632f, 0.14168869f, 0.14566560f, -0.02080849f, -0.16695274f, -0.05090341f, 
    -0.12265864f, -0.07737476f, 0.00911045f, -0.06435248f, -0.26834682f, -0.00092969f, -0.05795131f, -0.12622896f, 
    -0.00272763f, 0.15258278f, 0.15284735f, -0.11452175f, -0.09415034f, 0.10921997f, -0.04948976f, 0.07815328f, 
    0.00900433f, 0.00639229f, -0.03344730f, -0.02221057f, 0.17540893f, -0.02382335f, -0.05956727f, 0.16387990f, 
    -0.03453081f, -0.04803123f, 0.07985300f, -0.00321819f, -0.02718166f, 0.02375692f, -0.04574898f, -0.07409991f, 
    0.08779898f, -0.32365716f, 0.45113495f, -0.11893259f, 0.12832928f, 0.26444966f, -0.10316578f, -0.00535053f, 
    0.03116903f, 0.16859575f, 0.03038846f, -0.00151732f, 0.18545462f, 0.23305793f, -0.07021984f, 0.16912933f, 
    0.14043640f, -0.14370857f, -0.04268869f, -0.24399923f, -0.03723492f, 0.10456220f, -0.05199174f, 0.03748064f, 
    -0.02117826f, 0.02293172f, 0.03359194f, -0.00287980f, -0.03386004f, -0.04326824f, -0.03215380f, 0.03236390f, 
    0.03562070f, 0.03965842f, 0.02717469f, 0.01091073f, -0.01237323f, 0.02487712f, 0.02167660f, 0.00893835f, 
    -0.02813363f, -0.02197660f, -0.01770440f, 0.01878072f, 0.03453650f, -0.04648922f, 0.04194310f, -0.03170866f, 
    -0.03785082f, 0.02675559f, -0.01990019f, -0.03792182f, 0.04064720f, -0.04286583f, -0.00271370f, -0.02999593f, 
    -0.03671533f, -0.03772634f, -0.00837309f, 0.03598219f, 0.04363635f, 0.03179505f, 0.03274491f, 0.00570485f, 
    -0.02600028f, 0.01870653f, -0.04185664f, -0.03987425f, -0.00534504f, 0.03452243f, -0.00861021f, 0.03844207f, 
    0.02232973f, 0.00197673f, -0.03067305f, 0.01443946f, 0.03330684f, 0.00732173f, -0.03050116f, 0.02604518f, 
    -0.00067381f, -0.01733465f, 0.03759529f, 0.01315106f, 0.03157134f, -0.00240224f, 0.02980608f, 0.01569939f, 
    0.01281450f, -0.04421046f, 0.02390413f, -0.01694892f, -0.02241221f, 0.01221613f, 0.02079418f, 0.03493645f, 
    -0.02246707f, -0.00470840f, 0.02481744f, 0.02196397f, 0.04629064f, 0.01374548f, 0.00518092f, -0.05268651f, 
    -0.02928747f, 0.01891434f, -0.02496030f, 0.01464755f, 0.02421753f, -0.02178043f, -0.00256530f, -0.04259627f, 
    0.01911367f, 0.02883277f, 0.00463603f, 0.03524828f, -0.01459513f, 0.01953446f, -0.01031142f, 0.03053564f, 
    0.01446513f, -0.03298520f, -0.03104831f, 0.01286986f, 0.02697518f, 0.00792891f, 0.01215189f, 0.00639869f, 
    -0.03651198f, 0.00974202f, -0.05012085f, -0.00891905f, -0.00955837f, -0.03187587f, 0.02284133f, -0.04695038f, 
    -0.04303267f, 0.02978332f, 0.02141219f, -0.01033048f, -0.00165312f, 0.00299081f, -0.04956202f, 0.01207944f, 
    0.01134136f, -0.01207203f, -0.04377636f, 0.00447673f, 0.04392145f, 0.00817230f, -0.03182158f, -0.00614119f, 
    -0.04426100f, -0.03586292f, 0.04482442f, 0.01459391f, 0.02276994f, 0.04089430f, -0.03338552f, -0.00458667f, 
    0.02692178f, -0.05416261f, 0.00445473f, 0.02569302f, -0.04779073f, -0.05878425f, 0.02018046f, -0.00961273f, 
    -0.02456577f, -0.03573748f, 0.02350687f, -0.00875331f, 0.03585052f, 0.01072784f, -0.03494645f, 0.03596524f, 
    -0.05837595f, -0.05659865f, 0.01602864f, -0.02107166f, 0.02070848f, -0.02094741f, 0.03391716f, -0.04496761f, 
    0.00053932f, 0.00002160f, -0.02065754f, 0.02763438f, -0.02820939f, -0.01255367f, -0.00277381f, 0.03487891f, 
    -0.05126991f, 0.00501128f, -0.01459253f, -0.05269164f, -0.01204464f, 0.04086485f, 0.00397072f, -0.01520197f, 
    -0.05213246f, -0.05165135f, 0.03474213f, 0.03510431f, -0.05031078f, -0.02505105f, -0.01535884f, -0.04982827f, 
    -0.00898882f, 0.00835272f, -0.03596229f, -0.05098014f, 0.00618481f, 0.00579270f, 0.01758219f, -0.03882436f, 
    -0.04734703f, 0.00712528f, -0.02980721f, -0.04185540f, -0.04816558f, 0.02816733f, -0.04259949f, -0.04090821f, 
    -0.00208684f, -0.00324983f, 0.03884049f, -0.00144328f, 0.01145963f, -0.03678934f, -0.03805717f, 0.00345955f, 
    -0.02524322f, 0.01630454f, -0.00831515f, -0.03383407f, -0.02604067f, 0.01502406f, -0.01444315f, -0.02763746f, 
    0.00005172f, -0.03881390f, -0.03869466f, -0.04820095f, 0.02398412f, -0.02301104f, -0.02611115f, 0.03086633f, 
    -0.01296068f, 0.03991288f, -0.03076707f, 0.01248221f, 0.03956014f, -0.02092023f, -0.05630674f, -0.01191074f, 
    0.01752519f, -0.02701302f, 0.02790524f, 0.03619430f, 0.00788835f, 0.01558240f, -0.03160373f, 0.03446908f, 
    0.01186941f, 0.02912191f, -0.01687811f, -0.02984590f, 0.02741990f, -0.06086060f, -0.01059522f, -0.00138504f, 
    -0.02083893f, -0.03792381f, -0.00660205f, 0.04156406f, -0.02271618f, -0.02352753f, -0.04527307f, -0.03035986f, 
    -0.05715816f, 0.02229457f, 0.01600433f, 0.02141984f, -0.03032922f, 0.02348848f, 0.02133672f, -0.00704891f, 
    0.00475104f, -0.05006868f, 0.02396510f, -0.04951953f, -0.00814589f, -0.01805982f, -0.05794449f, -0.04258383f, 
    -0.02084559f, -0.05655616f, -0.05434786f, -0.02945639f, -0.01994710f, 0.03695183f, -0.04440426f, 0.04087624f, 
    0.00764286f, -0.04806462f, -0.00660916f, 0.04214090f, -0.00793554f, -0.01671649f, 0.02210379f, -0.04951337f, 
    0.01751168f, -0.01659171f, -0.00996141f, -0.02833355f, -0.00147822f, -0.03212211f, -0.01646829f, 0.01119500f, 
    -0.00296266f, -0.04350573f, -0.00093794f, -0.01110477f, 0.02827342f, -0.05406759f, -0.04590091f, -0.00165680f, 
    0.01694014f, -0.00533770f, -0.04305741f, -0.02811706f, -0.00370693f, -0.02459158f, 0.02873677f, -0.05957645f, 
    -0.05738465f, 0.03241222f, -0.00837937f, -0.04849378f, 0.02778810f, -0.02492472f, -0.03717158f, -0.00833511f, 
    -0.00838176f, -0.05621253f, -0.02485421f, -0.05201102f, -0.01928657f, -0.02346602f, -0.01097478f, 0.01913111f, 
    -0.03912059f, -0.01223644f, -0.03008552f, 0.02254348f, 0.03377833f, -0.01141999f, -0.02811472f, -0.03660280f, 
    0.04036217f, 0.01085575f, -0.00817334f, 0.01487944f, -0.05676351f, 0.00098474f, 0.02781616f, -0.03773263f, 
    0.02471350f, -0.01280734f, 0.02451191f, 0.03247049f, -0.02292908f, -0.02017006f, 0.02450503f, -0.03089620f, 
    -0.02321288f, -0.05096390f, 0.03798622f, -0.02132763f, -0.05385999f, 0.03945898f, -0.01005614f, -0.02662806f, 
    0.00801457f, 0.00635686f, -0.05062089f, 0.03429592f, -0.05739496f, -0.01162659f, 0.01703493f, -0.04992968f, 
    0.01760475f, 0.01198197f, -0.02300117f, -0.00301540f, -0.04021179f, -0.00463556f, 0.04126682f, 0.03838063f, 
    0.00022246f, 0.03515135f, -0.00105479f, -0.00505086f, 0.01654323f, 0.03510486f, -0.02916832f, -0.03094821f, 
    0.00439207f, -0.02175648f, 0.00126556f, -0.02055164f, 0.01016280f, 0.01257091f, 0.03499526f, -0.00560698f, 
    0.00731383f, 0.02490238f, -0.00335233f, -0.04227227f, -0.05431850f, -0.01034606f, 0.00284129f, 0.01185881f, 
    0.02729399f, -0.03719475f, 0.02404942f, -0.04528349f, 0.00875598f, -0.04227035f, -0.04386552f, 0.01541592f, 
    -0.01998948f, -0.03877944f, 0.03452423f, -0.04621551f, 0.00139057f, 0.01812451f, -0.03290781f, 0.02085083f, 
    -0.01918739f, -0.03283541f, 0.00486745f, -0.04510037f, 0.04438868f, -0.00617828f, -0.00131751f, 0.01692636f, 
    0.01713673f, -0.04703075f, 0.02478346f, -0.04457765f, -0.02881324f, -0.00172930f, -0.00543061f, -0.01648045f, 
    0.03946827f, -0.05437628f, -0.05412918f, -0.03622032f, -0.03330181f, 0.02223162f, 0.01870231f, 0.02502546f, 
    -0.00886737f, 0.00171651f, -0.00953474f, -0.03118236f, 0.01210861f, -0.02130584f, 0.02891965f, -0.02759151f, 
    -0.01741641f, -0.03025598f, 0.02964362f, -0.01067645f, 0.03221614f, 0.03822814f, -0.03993864f, -0.02467090f, 
    0.01234797f, 0.01613251f, -0.02946059f, -0.03696360f, -0.05539121f, -0.02395614f, -0.00005750f, -0.02504071f, 
    0.01252990f, 0.02783795f, -0.00491560f, 0.00185113f, 0.03744648f, 0.02465528f, -0.04568542f, -0.03572788f, 
    -0.04358605f, -0.04390744f, 0.00546192f, 0.03394154f, 0.04452792f, -0.05325954f, 0.04486969f, 0.01928671f, 
    0.01348230f, 0.01979857f, -0.04085666f, -0.03613536f, 0.02299185f, -0.02892121f, -0.01765503f, -0.00415804f, 
    0.03923851f, -0.02373027f, 0.02422300f, 0.00948803f, 0.02783134f, -0.02175491f, -0.05225561f, -0.01790859f, 
    0.03360299f, 0.03464795f, 0.00219547f, 0.01893385f, -0.01883371f, 0.00760177f, 0.04551238f, -0.00763934f, 
    0.01872327f, -0.00777752f, -0.00200435f, -0.04390860f, -0.02453875f, -0.00517594f, 0.03278480f, 0.02016239f, 
    0.02554259f, -0.03245473f, 0.03615331f, 0.02079565f, -0.03664001f, -0.03972423f, 0.00544232f, -0.05581282f, 
    -0.05552551f, -0.04913135f, 0.03962241f, -0.00305840f, 0.02295020f, 0.01367064f, 0.00998367f, 0.01250251f, 
    0.01828222f, -0.04577179f, 0.02570556f, 0.04250811f, 0.01306398f, 0.01323686f, -0.02989918f, -0.04494877f, 
    -0.02042535f, -0.04561224f, 0.02678158f, -0.04415498f, -0.05187932f, -0.03376855f, 0.00417657f, 0.02249547f, 
    -0.01062644f, -0.01699717f, -0.01248192f, -0.02719324f, -0.01777972f, 0.00719232f, -0.01814380f, 0.03460133f, 
    -0.02865502f, -0.00138838f, -0.00084809f, 0.03821066f, 0.00111214f, -0.00636402f, 0.00543472f, -0.01868508f, 
    -0.03115377f, -0.00985131f, 0.00107647f, 0.04108742f, -0.03188610f, 0.00047590f, -0.01268758f, -0.02681018f, 
    0.02331205f, 0.01046182f, -0.00465660f, 0.03160354f, -0.00174130f, 0.04238966f, 0.01575874f, 0.02398052f, 
    -0.03711553f, -0.03617705f, -0.05265131f, -0.01203352f, -0.00118346f, 0.01546117f, -0.01732555f, 0.03140253f, 
    0.00309113f, -0.00439767f, -0.05386264f, -0.02030803f, -0.00163649f, -0.05588255f, -0.05324333f, 0.03012944f, 
    0.02785172f, 0.03227685f, -0.04733048f, -0.01270846f, -0.00343198f, -0.01721627f, -0.00269860f, 0.02525903f, 
    -0.01356284f, 0.00642264f, -0.00912537f, -0.02946424f, 0.00862488f, -0.01583110f, 0.02111616f, -0.05292584f, 
    -0.05530426f, -0.04298864f, 0.00179339f, -0.03758710f, 0.02437722f, 0.03946545f, -0.05238944f, 0.01192336f, 
    -0.03831348f, -0.04959238f, 0.00042295f, -0.04017894f, -0.04409082f, 0.00055655f, -0.03219881f, 0.01197303f, 
    -0.02078404f, -0.03366816f, -0.00062432f, 0.00155765f, 0.02761554f, 0.00878591f, -0.02851089f, 0.02056828f, 
    -0.03679450f, -0.01018218f, -0.02044907f, -0.03735605f, -0.04150914f, -0.05645842f, -0.02122980f, -0.02829780f, 
    -0.05170738f, -0.04936838f, 0.04206134f, -0.04536420f, 0.03727212f, 0.02754551f, 0.00282634f, -0.00965498f, 
    -0.02818917f, 0.03648822f, 0.03291671f, -0.00016672f, -0.01925767f, -0.00131330f, -0.00591766f, -0.01262838f, 
    -0.02804620f, 0.03508691f, 0.00657512f, -0.02420457f, 0.04211181f, -0.02829989f, 0.00041899f, 0.04773695f, 
    0.02652130f, -0.01345947f, -0.03334483f, -0.04598296f, -0.04707143f, 0.00656799f, -0.04215070f, -0.00886743f, 
    0.02842552f, -0.04765156f, 0.02512106f, 0.01240450f, -0.00550549f, -0.01415601f, -0.03172075f, 0.01549915f, 
    0.01132016f, -0.02954998f, 0.00720323f, -0.03183543f, -0.03270232f, -0.02070762f, 0.02562020f, 0.02690102f, 
    0.03452843f, -0.02632080f, -0.00011446f, -0.04294923f, 0.02965459f, -0.04563628f, -0.02247806f, -0.05005103f, 
    -0.02912143f, -0.04959578f, -0.02693120f, -0.04016421f, -0.03517801f, -0.03096195f, 0.03238045f, -0.05663175f, 
    -0.03196075f, 0.00147037f, -0.04289832f, 0.03022363f, -0.04987840f, 0.01839378f, -0.04810097f, -0.00481995f, 
    -0.04438191f, 0.02985333f, 0.03171779f, 0.01821721f, 0.01025509f, -0.04383329f, 0.03320740f, -0.02394462f, 
    -0.03450004f, 0.01624912f, 0.04469864f, 0.04080588f, 0.04047531f, -0.04746640f, 0.00993882f, -0.04680236f, 
    -0.04753132f, 0.00587227f, 0.02067875f, 0.00208965f, -0.03572805f, -0.03991194f, -0.00097331f, 0.00420914f, 
    0.02660172f, -0.01608728f, -0.04076551f, 0.03135239f, -0.03560696f, 0.03276207f, 0.02487571f, 0.00951912f, 
    -0.02090760f, 0.00717487f, -0.02734100f, 0.03675409f, -0.02291095f, -0.02394422f, -0.00345234f, -0.02812878f, 
    -0.02790156f, -0.00816599f, 0.01116609f, 0.00828979f, -0.01443491f, 0.04574016f, 0.00141613f, 0.00063000f, 
    -0.02293188f, 0.00197770f, -0.03166889f, 0.01032748f, -0.04236409f, -0.00535131f, -0.03784037f, -0.03143817f, 
    -0.01873765f, -0.00090715f, -0.01789003f, 0.02536613f, -0.03463675f, -0.01261269f, -0.02927407f, -0.04153475f, 
    0.04269922f, -0.04320002f, 0.01378229f, 0.04402573f, 0.00039176f, 0.03820258f, -0.04477897f, -0.01105595f, 
    -0.00903428f, 0.04810978f, -0.01470817f, -0.01121906f, -0.04498478f, -0.03917836f, -0.01519629f, -0.01111451f, 
    -0.02576572f, -0.02122058f, 0.02813574f, 0.00378663f, 0.03175908f, -0.02006717f, -0.02679981f, -0.05086324f, 
    -0.03279519f, -0.03690657f, -0.04120117f, 0.04469515f, -0.01556418f, -0.03081844f, 0.00880807f, 0.04252632f, 
    0.02112559f, 0.01160593f, 0.03537371f, 0.00804424f, -0.02936039f, -0.02735889f, -0.00160277f, -0.05542066f, 
    -0.05155673f, -0.00357451f, -0.04215389f, 0.00744090f, -0.04208812f, -0.00497547f, 0.00923936f, 0.00413209f, 
    -0.05408971f, 0.03350472f, 0.01686497f, -0.03145112f, 0.02905031f, -0.05473761f, 0.00374042f, -0.03163653f, 
    -0.03733217f, -0.02236336f, 0.01785561f, -0.00249319f, -0.02390522f, 0.01361123f, 0.01410106f, -0.03508776f, 
    0.02053877f, -0.01993750f, -0.04541008f, -0.01260839f, 0.03780435f, -0.02692132f, -0.03139673f, -0.01771761f, 
    -0.04093382f, -0.02348897f, -0.02523104f, 0.04466383f, 0.03125344f, 0.00096128f, 0.03270951f, 0.01391801f, 
    -0.00758660f, 0.02228302f, -0.01990310f, 0.03248626f, -0.00833755f, -0.03804255f, 0.02700242f, -0.03068701f, 
    0.01557992f, 0.04740867f, -0.04626608f, 0.01395410f, 0.04170250f, -0.00063682f, -0.01460878f, -0.03336120f, 
    -0.01835521f, -0.05437693f, -0.04272437f, -0.00803956f, 0.00809465f, -0.00715279f, -0.01489635f, 0.00389049f, 
    -0.01189476f, -0.02241424f, 0.02478780f, 0.02495220f, 0.00141650f, 0.03152619f, 0.03968483f, 0.02175402f, 
    -0.05397721f, 0.03785155f, 0.02369758f, 0.02230575f, -0.03229422f, 0.03385345f, -0.00198468f, -0.00264344f, 
    -0.05566436f, -0.04782184f, 0.02309136f, 0.03305780f, -0.00844108f, -0.05627548f, -0.05536841f, -0.00681780f, 
    0.01351947f, -0.05258101f, -0.02659566f, 0.02951500f, -0.04378642f, -0.05487975f, -0.05611934f, -0.02398740f, 
    0.00324337f, 0.04368158f, -0.02311262f, 0.03520498f, 0.02402850f, -0.05050628f, 0.00544285f, -0.04998111f, 
    -0.05476912f, -0.00004981f, -0.02895764f, -0.00019550f, 0.03918144f, -0.01034405f, -0.01560239f, 0.01148098f, 
    -0.02697130f, -0.03619199f, 0.02216798f, 0.00888768f, -0.04555907f, -0.02066712f, -0.03261445f, 0.00257629f, 
    -0.05215231f, 0.00393142f, 0.01768912f, 0.03423816f, 0.03987071f, -0.00092900f, 0.00433271f, 0.02174945f, 
    0.04163251f, 0.03947220f, -0.02306456f, 0.04513776f, 0.04477284f, -0.04003670f, -0.02333250f, 0.04278974f, 
    0.01176603f, -0.00273699f, -0.03472636f, -0.05118595f, -0.03067718f, 0.03560993f, 0.00557185f, -0.00212479f, 
    -0.01474576f, -0.01321980f, -0.02633235f, -0.04619073f, -0.01925787f, -0.04909096f, 0.04122132f, -0.04498247f, 
    0.00757329f, -0.02165112f, 0.02766520f, -0.02255953f, 0.02410122f, 0.02678780f, 0.03877368f, -0.01053090f, 
    0.02399007f, -0.02422717f, -0.02245043f, -0.04780346f, -0.02512018f, -0.01210078f, -0.00024285f, -0.04802046f, 
    -0.04734496f, -0.01178515f, -0.03055963f, 0.01780292f, 0.04409743f, -0.03591778f, -0.05219912f, 0.00565455f, 
    -0.02124743f, -0.00532391f, -0.04621611f, -0.01133511f, 0.03278034f, -0.05109527f, -0.05570659f, 0.02447326f, 
    -0.05649505f, 0.02598485f, 0.04423746f, -0.04759205f, 0.01401504f, 0.00190132f, -0.04276951f, 0.00472952f, 
    -0.03545946f, -0.00294230f, -0.00238916f, 0.01444448f, -0.00819461f, 0.03718696f, -0.03799576f, 0.01713969f, 
    -0.02044175f, 0.00028072f, 0.03140891f, 0.01762331f, 0.00860847f, -0.03389841f, -0.01716441f, 0.02851232f, 
    -0.01489198f, 0.01032348f, -0.04830338f, -0.02660040f, -0.01641731f, 0.04457977f, 0.03937672f, 0.03333256f, 
    -0.04917091f, 0.03547416f, -0.01115080f, 0.01509730f, 0.00751040f, 0.01331667f, 0.00168462f, -0.02458388f, 
    -0.05581583f, -0.02309158f, -0.03471550f, 0.01206263f, -0.00413876f, -0.02163417f, -0.00041652f, -0.03017101f, 
    -0.05532806f, 0.00915923f, -0.04276772f, -0.05024906f, 0.02892843f, 0.01748912f, -0.04482828f, -0.05309157f, 
    -0.02842699f, 0.02621403f, 0.03717947f, -0.02728501f, -0.05134626f, -0.02120363f, -0.01243831f, 0.04254621f, 
    0.03563661f, -0.04420137f, -0.04550126f, 0.03935757f, -0.01009619f, -0.02912940f, 0.03554813f, -0.05296142f, 
    -0.02520763f, -0.02034098f, -0.00559211f, 0.04453397f, -0.00078840f, -0.04839234f, 0.00959838f, 0.04139246f, 
    0.02979413f, 0.00555532f, 0.01812665f, -0.02481458f, 0.02245556f, 0.01246209f, -0.05578491f, 0.03471489f, 
    -0.04190452f, -0.03438343f, -0.03342764f, 0.00646921f, -0.01371096f, 0.02465969f, 0.01579924f, 0.02778543f, 
    -0.03557226f, 0.02962321f, 0.00488683f, 0.02526550f, -0.00616319f, -0.03377805f, -0.05083312f, 0.04420612f, 
    -0.03223112f, -0.01861604f, -0.03198658f, -0.00303619f, 0.01198770f, 0.01268564f, -0.02717627f, -0.05255410f, 
    -0.01319561f, -0.01302118f, -0.02211626f, 0.02153662f, -0.00261865f, -0.04337448f, -0.00142547f, 0.04514209f, 
    0.02348785f, -0.04657042f, -0.03507538f, 0.03380706f, 0.04571102f, -0.05572212f, 0.03964682f, -0.00186222f, 
    -0.04210938f, -0.02217138f, 0.04473924f, -0.04789187f, 0.03219610f, -0.04831604f, 0.02351264f, 0.03490980f, 
    -0.04205580f, -0.04256111f, 0.01395595f, 0.03495742f, -0.03954832f, -0.02255851f, -0.00272983f, 0.03582433f, 
    -0.01264112f, 0.04203927f, -0.03099657f, 0.01622950f, 0.02655529f, -0.03998287f, -0.00594851f, -0.04748141f, 
    -0.02124895f, 0.09384265f, 0.41980404f, 0.17880714f, 0.00343328f, 0.20975734f, 0.03333588f, 0.31045172f, 
    -0.13577113f, 0.02799287f, 0.07909700f, -0.06876615f, -0.08343924f, 0.10599047f, -0.10694530f, -0.05809256f, 
    0.07068244f, 0.08703224f, 0.05483466f, -0.02416353f, -0.09812596f, -0.01267268f, 0.02897735f, -0.06064807f, 
    -0.16609599f, 0.05241815f, 0.32771698f, -0.11037261f, 0.04724187f, 0.10516196f, -0.09253760f, -0.08416101f, 
    0.00056057f, 0.19118530f, 0.15612003f, 0.15367304f, -0.57648468f, -0.30775264f, -0.22860949f, 0.25699586f, 
    0.08310819f, 0.08679230f, -0.01301625f, 0.08132060f, -0.03974112f, -0.03419631f, 0.01813161f, -0.05884866f, 
    0.18971494f, 0.20620379f, 0.05758471f, -0.26396167f, -0.19783024f, -0.03872658f, -0.06650442f, 0.16493362f, 
    -0.00669775f, -0.02206892f, -0.06412201f, -0.14180270f, -0.05634238f, -0.18061598f, -0.04839973f, 0.27777094f, 
    0.03024248f, -0.07414515f, -0.18811463f, 0.10717890f, 0.17881848f, -0.03251759f, 0.12456308f, -0.01021394f, 
    -0.02243108f, -0.02565213f, 0.12276778f, 0.15889442f, -0.10612451f, -0.15679985f, -0.02044349f, -0.07645260f, 
    0.01483684f, 0.15504014f, -0.03786309f, 0.05381648f, -0.09414441f, -0.20198213f, 0.05782712f, 0.59846091f, 
    0.11814222f, -0.01847505f, 0.12933341f, 0.00688713f, 0.10019774f, 0.04169377f, -0.02861464f, -0.00535062f, 
    0.03857364f, 0.08350150f, 0.17198509f, -0.03568844f, -0.03276437f, -0.04211718f, 0.00300763f, 0.10451880f, 
    -0.02659713f, -0.07389756f, -0.15773754f, 0.03548182f, 0.30446315f, 0.32270119f, 0.09923309f, -0.25970870f, 
    -0.15064715f, -0.17510721f, 0.10336578f, 0.03701155f, -0.05828029f, -0.05349681f, -0.03406814f, -0.05345006f, 
    -0.16703565f, -0.17001538f, 0.09848413f, 0.14391217f, -0.10367053f, -0.15528622f, -0.08568440f, -0.14282690f, 
    0.14449394f, 0.12387212f, 0.05011228f, -0.01105147f, -0.00001269f, 0.12815225f, 0.12833779f, 0.19555162f, 
    0.06995589f, 0.07110033f, 0.05063839f, 0.21897075f, -0.14938353f, 0.07348374f, 0.05378344f, -0.10034559f, 
    -0.12339609f, 0.00717280f, 0.01657368f, 0.08183295f, 0.28578383f, 0.07706305f, 0.06272174f, 0.01877409f, 
    0.04770344f, 0.21336740f, 0.14167514f, -0.13061509f, -0.18398434f, -0.13028485f, -0.11124195f, 0.35332596f, 
    0.22484291f, 0.05045548f, -0.05157306f, -0.11444028f, 0.18070483f, 0.18570931f, 0.09682865f, 0.13957803f, 
    -0.40028283f, -0.07087188f, 0.14180604f, 0.22024490f, 0.18185468f, 0.05772822f, -0.06741277f, 0.04471226f, 
    0.10377870f, -0.05777792f, 0.14539570f, 0.21657567f, 0.10582744f, 0.03363007f, -0.11542276f, -0.05832867f, 
    0.06155751f, -0.13969657f, 0.20257518f, -0.18440872f, 0.13458470f, 0.08976591f, 0.16306672f, 0.24416491f, 
    0.20487958f, 0.01509730f, 0.27281615f, -0.19777995f, -0.06958917f, 0.00435112f, -0.05015048f, 0.05984708f, 
    -0.06257911f, -0.10176539f, -0.09219465f, -0.18253472f, -0.18141507f, -0.07346376f, 0.30572262f, 0.20160949f, 
    0.04555304f, 0.04118696f, 0.00280010f, -0.05821995f, -0.08619579f, -0.02922969f, 0.17568120f, 0.02810908f, 
    -0.04337581f, 0.09682521f, -0.03801186f, -0.15383358f, 0.00601195f, 0.03160302f, 0.06899884f, 0.05076813f, 
    0.20539920f, 0.01840616f, 0.12650821f, 0.08011307f, 0.11242091f, 0.08200911f, -0.00997044f, -0.05886999f, 
    -0.08735193f, -0.00505086f, 0.17118560f, 0.05605642f, 0.07216012f, 0.06554477f, 0.06447081f, 0.03021763f, 
    0.05992170f, 0.02017622f, -0.04498786f, -0.04777283f, 0.06955963f, 0.14285290f, 0.03905022f, 0.10904480f, 
    -0.11456300f, -0.00186089f, 0.02917329f, -0.08094308f, 0.21360883f, -0.13194345f, 0.32289070f, -0.12760611f, 
    -0.00909377f, 0.10994242f, -0.13756083f, -0.02440178f, -0.04511379f, -0.09230370f, -0.10484215f, 0.02327276f, 
    0.05549910f, 0.07518170f, -0.14610058f, -0.16094045f, -0.07873479f, 0.01298167f, -0.08205450f, 0.11379910f, 
    -0.04188012f, -0.03630462f, 0.04959222f, -0.04710144f, -0.29851115f, -0.23076586f, -0.07435353f, 0.13218822f, 
    -0.12487881f, -0.01363783f, -0.16764724f, 0.09146360f, -0.08083442f, 0.00336692f, -0.11786978f, -0.07125756f, 
    0.19220521f, -0.06725001f, -0.02479156f, -0.01727839f, -0.11755940f, 0.07755428f, 0.00114336f, -0.14213505f, 
    0.10485134f, -0.12509261f, -0.06167540f, 0.03912745f, 0.05577892f, 0.00165975f, 0.05070707f, -0.08769495f, 
    -0.08420780f, -0.00536575f, -0.08843718f, 0.00745128f, -0.11303485f, 0.10115228f, 0.01244266f, -0.09363995f, 
    0.04074573f, -0.00376326f, -0.04509592f, 0.02963407f, 0.03893331f, -0.10498155f, -0.02747598f, -0.07110824f, 
    0.11889022f, 0.05297238f, -0.07256132f, 0.08918614f, 0.01507908f, 0.02668766f, 0.13470274f, -0.16970739f, 
    -0.14236881f, -0.02649170f, 0.04971258f, -0.06237489f, -0.05290686f, -0.01635066f, 0.05487267f, -0.07695149f, 
    0.05498806f, 0.20138669f, 0.17210481f, 0.04815571f, -0.11929487f, -0.09317507f, 0.05265376f, -0.00086881f, 
    -0.01755766f, 0.04544454f, -0.04692471f, -0.01309289f, 0.14552636f, -0.02581584f, 0.05358024f, 0.07613634f, 
    -0.00085403f, 0.01606219f, 0.09050485f, -0.00640858f, -0.04909866f, 0.08775778f, -0.03371170f, 0.10202672f, 
    -0.10171132f, -0.16829796f, 0.11648519f, 0.14966103f, 0.09098231f, 0.14384432f, -0.04511382f, -0.14729886f, 
    0.03543540f, -0.13566932f, 0.13665806f, 0.12294969f, -0.29807118f, -0.26467401f, 0.14968224f, 0.34145731f, 
    -0.10459895f, -0.16952647f, -0.12737699f, 0.00925094f, 0.07603063f, 0.10409342f, 0.02325454f, -0.05731543f, 
    -0.08520734f, 0.34901416f, 0.01715710f, 0.49202070f, 0.14783585f, 0.07163814f, 0.04036007f, 0.14849913f, 
    0.01265824f, -0.05866975f, 0.04583609f, -0.05689387f, -0.27458745f, 0.10459978f, -0.02108437f, 0.19316265f, 
    0.06958591f, 0.08763068f, 0.01397591f, -0.05000142f, -0.07401688f, 0.02994830f, 0.04605005f, 0.18659839f, 
    -0.01615672f, -0.18890508f, 0.19570091f, 0.17150360f, -0.07593978f, 0.17330056f, -0.17262563f, -0.03230962f, 
    0.10570548f, 0.11584312f, 0.06779987f, -0.10857372f, -0.05029240f, 0.60456353f, -0.24587710f, 0.24583416f, 
    -0.11304086f, -0.14666288f, 0.04663097f, -0.04966577f, -0.02756784f, -0.18758370f, -0.14326724f, -0.00593224f, 
    -0.01060952f, 0.25153217f, 0.24612696f, 0.02639027f, -0.18004702f, -0.05889835f, -0.04074612f, 0.02361515f, 
    -0.04165723f, 0.04158729f, 0.00200738f, -0.14648056f, -0.04249823f, -0.13549612f, -0.26036805f, -0.09504197f, 
    0.05289265f, 0.10752699f, -0.07825561f, 0.15357289f, -0.03757553f, 0.06264079f, -0.03432723f, 0.08745853f, 
    0.07798610f, -0.09706410f, 0.17431267f, 0.40028253f, -0.10069424f, 0.01405464f, 0.00962405f, -0.25062159f, 
    -0.10790728f, -0.03356288f, -0.00074866f, 0.05637465f, 0.40725431f, 0.08117281f, -0.08824299f, 0.43584749f, 
    0.17231879f, -0.11242705f, 0.17146580f, -0.08091500f, -0.09111255f, 0.17330728f, -0.02286984f, -0.00251095f, 
    0.08493809f, -0.13006474f, -0.04609967f, 0.41893768f, 0.00801431f, -0.03717566f, 0.06128979f, 0.06118106f, 
    -0.18036547f, 0.00773726f, -0.17926228f, 0.03495211f, -0.29110846f, 0.41465783f, 0.35238221f, 0.15453136f, 
    -0.12960711f, -0.16041005f, -0.04711862f, -0.01603265f, 0.06022269f, 0.06107237f, -0.08710705f, -0.10206542f, 
    0.07254078f, -0.32742068f, -0.10469722f, 0.22805202f, 0.05557818f, -0.00517358f, -0.00819982f, -0.05378720f, 
    -0.02041883f, 0.08508956f, -0.07783121f, 0.00926924f, -0.00692488f, 0.17691274f, -0.11953305f, 0.48486075f, 
    0.14118615f, -0.03082201f, 0.13661149f, 0.14279823f, 0.08714949f, -0.14578013f, 0.14090306f, -0.26660469f, 
    -0.03947351f, 0.31496516f, -0.17261882f, 0.08448114f, 0.17289621f, -0.07025920f, 0.11146431f, 0.11461189f, 
    -0.01236135f, 0.05975559f, 0.12752205f, 0.08187049f, 0.03374693f, 0.22976133f, -0.06736489f, -0.14436403f, 
    0.18746538f, -0.02477865f, 0.01327554f, -0.06271879f, 0.02983582f, 0.00453429f, 0.04511913f, 0.22893922f, 
    -0.39380217f, -0.05567931f, -0.06400647f, -0.10090256f, 0.08593459f, 0.06089603f, -0.11349066f, 0.01626307f, 
    0.08796284f, 0.00145468f, 0.31446186f, 0.17538922f, 0.28876817f, -0.22211534f, 0.19915745f, -0.16480201f, 
    0.11328340f, -0.04076553f, 0.01349745f, 0.05140037f, 0.02241419f, 0.10569523f, 0.05319107f, 0.20622057f, 
    -0.09967764f, 0.14455670f, 0.23442434f, 0.07029301f, -0.11226656f, -0.01884275f, -0.01128588f, 0.09127220f, 
    -0.10308490f, -0.09398178f, 0.14344276f, -0.06967332f, -0.10727713f, 0.35917464f, 0.16604644f, 0.28081468f, 
    -0.20873727f, 0.26994604f, -0.03265768f, -0.06856178f, 0.02964622f, -0.08136590f, 0.00439107f, -0.06904214f, 
    -0.03057016f, 0.01407691f, -0.13708152f, -0.26198420f, -0.07078364f, -0.03416833f, -0.10942636f, 0.04290218f, 
    0.09111401f, 0.22713768f, 0.07526415f, 0.11521517f, 0.51092142f, 0.05935901f, 0.16234362f, -0.02173418f, 
    0.17108816f, 0.12357161f, 0.06169635f, 0.16215135f, -0.02261718f, 0.06717350f, 0.13374811f, -0.01193634f, 
    -0.08899140f, -0.01567070f, -0.02924463f, 0.03843528f, 0.24049035f, 0.04260664f, -0.04423181f, 0.06645048f, 
    -0.03783607f, 0.04610995f, 0.14758529f, -0.02930537f, -0.10613679f, -0.20016824f, 0.46061471f, -0.09196571f, 
    0.13858508f, 0.05593161f, -0.27466261f, -0.01218167f, -0.18042314f, 0.07617773f, 0.03864483f, 0.05220245f, 
    -0.17800154f, -0.16203052f, -0.09194347f, -0.20386417f, -0.02344043f, 0.12104215f, 0.04300272f, 0.05319108f, 
    0.06808361f, 0.15899405f, -0.07698648f, 0.02085373f, 0.09767772f, -0.03559890f, -0.35418141f, 0.03504890f, 
    -0.06988668f, -0.03118779f, -0.06378685f, -0.05591100f, -0.11063515f, 0.00806666f, 0.00161467f, -0.06088796f, 
    0.01232171f, 0.33773834f, -0.19065365f, -0.12228018f, -0.14310578f, -0.12930669f, -0.10355475f, -0.21294123f, 
    -0.13676976f, -0.02683340f, -0.21157333f, 0.17582789f, 0.29951286f, 0.17392240f, -0.12438884f, -0.21604964f, 
    -0.02213108f, -0.01197213f, -0.04690290f, 0.08163793f, -0.12409657f, -0.01568520f, 0.11204609f, 0.23517652f, 
    -0.13212004f, 0.08230639f, -0.05979738f, -0.14903988f, 0.01153725f, -0.03824051f, -0.02901504f, -0.04405025f, 
    -0.01406037f, -0.07723285f, 0.07701654f, -0.05041875f, -0.16682735f, 0.15554850f, 0.18339001f, -0.09481306f, 
    -0.08127618f, -0.05910553f, -0.08983582f, -0.06055185f, -0.08435833f, 0.09573124f, -0.09041949f, 0.04914756f, 
    -0.08453134f, 0.08422235f, 0.15273868f, 0.25384703f, -0.05150947f, 0.06678870f, 0.11502991f, 0.12588823f, 
    -0.02372426f, 0.12819411f, -0.01942435f, -0.14448839f, -0.04653875f, 0.09171508f, 0.08691409f, 0.03961492f, 
    0.04663847f, -0.05839260f, 0.06076521f, 0.02611316f, 0.04003911f, 0.17260329f, -0.09025219f, 0.02273959f, 
    -0.00725488f, -0.24852161f, 0.17743964f, -0.18652403f, 0.20022450f, 0.24644004f, -0.02914231f, -0.01164519f, 
    0.02048532f, 0.03339664f, 0.08814874f, 0.16836922f, -0.02306144f, -0.32624316f, -0.34063944f, 0.09016599f, 
    0.03508849f, -0.07289478f, -0.15373498f, -0.07496276f, -0.03065557f, 0.06396125f, 0.03535142f, -0.07911985f, 
    -0.02691219f, -0.05048390f, 0.01348879f, 0.01849775f, -0.03915137f, -0.02767717f, 0.02197243f, 0.01447952f, 
    -0.02656015f, 0.00494019f, -0.03016062f, -0.05713947f, -0.00312445f, 0.04364537f, -0.00294900f, 0.02658988f, 
    -0.02371793f, -0.01726160f, -0.03722135f, -0.05653048f, -0.03308009f, -0.00241818f, 0.00576748f, 0.00890762f, 
    0.01225798f, -0.01997228f, -0.03424999f, 0.02508197f, -0.03934290f, -0.04533612f, -0.04301166f, -0.01901666f, 
    0.00021943f, -0.01379100f, 0.00972800f, 0.02782102f, -0.03486742f, -0.04830694f, -0.00905303f, 0.00013121f, 
    -0.03501818f, -0.01084421f, 0.01304441f, 0.03269755f, -0.04878232f, 0.01271161f, -0.02080204f, 0.03776944f, 
    -0.02252425f, -0.02497848f, -0.05844812f, 0.02226640f, -0.02452522f, -0.05090251f, -0.01201854f, -0.01190458f, 
    -0.04111406f, -0.04651485f, 0.02141515f, -0.02048404f, 0.03566769f, -0.02356971f, -0.00574926f, -0.01485004f, 
    0.02056477f, 0.02313364f, 0.00849250f, -0.04222143f, 0.00980505f, 0.03336717f, -0.02137486f, 0.00858549f, 
    -0.04451822f, -0.02224184f, -0.01560493f, 0.01075281f, 0.01500996f, -0.03331164f, 0.03890613f, -0.02991730f, 
    -0.04571838f, 0.03474507f, 0.01740960f, -0.02251000f, 0.01873962f, 0.01487071f, 0.02518695f, 0.03581414f, 
    0.02536711f, -0.00603967f, -0.01183687f, 0.02208378f, -0.02229403f, -0.03268211f, 0.01450112f, -0.02725243f, 
    0.02469090f, -0.02024598f, -0.01273709f, -0.00110077f, 0.04918516f, -0.00851255f, -0.03333870f, -0.01351226f, 
    -0.02533933f, 0.02639187f, -0.01301311f, -0.01341598f, 0.04513975f, 0.01838987f, -0.00956026f, -0.00067699f, 
    0.01797910f, -0.03898657f, -0.03653628f, 0.04169055f, 0.03721507f, 0.03775251f, -0.00422468f, -0.00831175f, 
    0.02656008f, -0.02434660f, -0.02882326f, 0.04452103f, -0.05185491f, 0.03131186f, -0.05692327f, -0.02763910f, 
    -0.02591996f, -0.01290383f, 0.02927667f, 0.01101669f, -0.02300073f, -0.02852218f, 0.00850280f, 0.01003808f, 
    -0.05199566f, 0.03144841f, -0.03776604f, 0.04203217f, -0.04926386f, -0.02445000f, 0.04281648f, -0.03903934f, 
    -0.01516705f, -0.01492993f, -0.04861455f, -0.04860721f, -0.01653392f, -0.02914523f, 0.03967450f, 0.00233590f, 
    0.03540606f, -0.04079212f, 0.02970676f, -0.05048974f, -0.03952079f, -0.01760191f, -0.02439647f, -0.05603887f, 
    -0.05465902f, -0.04497888f, -0.02393152f, -0.00495038f, -0.00333738f, -0.02779080f, -0.04178274f, -0.02590929f, 
    -0.01472502f, -0.02819953f, 0.02264401f, 0.00312702f, -0.00648052f, -0.01726800f, -0.02253113f, -0.01448909f, 
    -0.04985166f, -0.05344405f, -0.01048242f, 0.03320073f, -0.00681856f, -0.00178250f, 0.01657343f, 0.03616353f, 
    0.01439352f, 0.02133801f, 0.02054633f, 0.03680133f, 0.01166066f, -0.00867140f, 0.01620272f, -0.05076831f, 
    0.03718741f, -0.03567700f, 0.02398633f, -0.05362846f, -0.04100263f, 0.04110748f, 0.03927264f, -0.04016518f, 
    -0.04959591f, -0.05496113f, -0.04731471f, -0.00254200f, 0.02713699f, 0.02064052f, -0.03764255f, 0.01019509f, 
    -0.01018297f, -0.03504464f, 0.00672221f, -0.01941860f, 0.01336413f, -0.02101038f, 0.01332105f, -0.02399338f, 
    -0.00141418f, 0.01114654f, -0.03862607f, -0.01500600f, 0.00218533f, 0.03654938f, 0.01646225f, -0.01615593f, 
    -0.02733956f, 0.01614419f, 0.01694597f, 0.01242655f, 0.01778506f, 0.00360479f, -0.00084580f, -0.04380260f, 
    -0.01033822f, -0.00457537f, 0.00033197f, 0.01371175f, -0.04319163f, 0.00821959f, 0.02071620f, 0.02074706f, 
    0.00531833f, -0.00394763f, -0.00218321f, 0.00850657f, -0.00645287f, -0.00244788f, -0.05543924f, -0.00797401f, 
    -0.03471258f, -0.03797393f, 0.04350411f, 0.03188458f, -0.03659480f, 0.01522035f, 0.04229079f, -0.05275428f, 
    0.01482927f, 0.04175043f, -0.03602178f, 0.01720246f, 0.01682268f, -0.02233689f, 0.01827170f, 0.03916198f, 
    0.03613387f, 0.01468328f, 0.01932721f, -0.05595960f, 0.00854993f, -0.00780556f, 0.03529783f, -0.02887205f, 
    0.00067858f, -0.01935703f, -0.04645468f, -0.03495837f, 0.02293453f, -0.04624341f, -0.01286945f, -0.02195168f, 
    -0.04005844f, 0.00745976f, -0.04755738f, -0.02676204f, 0.01266553f, 0.03860991f, -0.03186984f, 0.01820504f, 
    0.03918412f, -0.04331543f, 0.02249086f, -0.03913186f, -0.00376707f, 0.03138926f, 0.04323996f, 0.01573268f, 
    0.00016421f, -0.00449183f, -0.01340286f, 0.02775755f, 0.04192982f, -0.02670935f, 0.00815792f, 0.02009739f, 
    -0.05660180f, 0.04399055f, -0.03860326f, -0.02189401f, 0.01572990f, -0.04142335f, -0.04093986f, 0.04521663f, 
    -0.02634944f, -0.00226069f, -0.01059195f, 0.01479950f, -0.05032593f, -0.02740706f, -0.03142066f, 0.02897684f, 
    -0.02119701f, 0.03181155f, -0.01541177f, -0.03012001f, 0.04100307f, -0.04045120f, -0.03448153f, -0.03883676f, 
    -0.00995100f, -0.01924008f, 0.01499941f, 0.02423227f, 0.02409198f, 0.02451674f, 0.04122255f, -0.01706056f, 
    0.00102012f, 0.02268707f, 0.01809043f, 0.00746491f, -0.01509628f, 0.02553479f, 0.03205176f, 0.00157663f, 
    0.01522933f, -0.04367230f, 0.02810427f, 0.00093286f, -0.00656490f, 0.02840355f, 0.04295139f, 0.01818087f, 
    -0.04266658f, 0.03039111f, -0.00136503f, -0.01738952f, 0.00456610f, -0.00684453f, -0.04460532f, -0.02201960f, 
    -0.03498287f, -0.03126696f, 0.02369352f, -0.01854091f, -0.01238311f, 0.01306052f, -0.00820915f, 0.02063125f, 
    0.01298810f, 0.01979339f, -0.00881122f, -0.02816826f, 0.04397488f, 0.02293133f, 0.02720634f, 0.02981558f, 
    -0.05144324f, 0.00322613f, -0.03956636f, -0.00276403f, -0.04216423f, -0.01784338f, -0.04134245f, 0.01925391f, 
    0.33999458f, 0.04488301f, -0.11420343f, -0.05040549f, 0.03369871f, 0.00144420f, -0.18735124f, 0.10846764f, 
    0.12971850f, 0.29051101f, 0.08177768f, -0.01610780f, 0.08087695f, -0.02124566f, 0.29255804f, -0.03393303f, 
    -0.16682439f, -0.19906026f, -0.05046451f, 0.06660052f, -0.07429937f, 0.19394600f, -0.02837004f, 0.08700871f, 
    0.08870851f, -0.02604973f, -0.21914302f, -0.02523056f, 0.13305317f, 0.08338414f, 0.10691572f, 0.06696444f, 
    0.04062131f, -0.02088725f, -0.06114409f, -0.05906526f, 0.62666136f, 0.15372713f, 0.30356875f, -0.54500908f, 
    -0.01752844f, 0.06597473f, 0.02992019f, -0.16123495f, -0.07451157f, 0.04453225f, -0.05686729f, -0.06110929f, 
    -0.20834894f, -0.07164054f, -0.13129318f, 0.23526238f, 0.07520319f, -0.06925702f, -0.05851812f, -0.07623576f, 
    -0.17924809f, -0.09430765f, -0.01893525f, -0.08745826f, 0.28392673f, 0.20943919f, 0.02819356f, -0.20098765f, 
    -0.33287239f, 0.09119780f, 0.30246446f, -0.23282218f, 0.07111052f, 0.17737778f, 0.09567185f, 0.04686409f, 
    0.27817500f, 0.10673828f, -0.08352299f, -0.16718645f, 0.17210507f, 0.17832902f, 0.10960457f, 0.25603327f, 
    0.02600672f, -0.13992551f, -0.05492401f, -0.16759785f, 0.17568798f, 0.32717639f, -0.11842502f, -0.24268986f, 
    -0.07423925f, 0.11141230f, -0.12325831f, 0.01150701f, -0.00487308f, 0.05000132f, 0.05573240f, -0.20058401f, 
    0.22748239f, 0.01171798f, 0.05619366f, -0.12164970f, 0.03299592f, 0.18347366f, 0.19248982f, 0.11485285f, 
    -0.09918321f, -0.01064604f, 0.12207903f, -0.15534316f, -0.28509298f, -0.16008148f, -0.19955319f, 0.21696764f, 
    0.04980089f, -0.03487324f, 0.04477493f, -0.06458677f, -0.10310978f, -0.13891201f, -0.07224629f, -0.11175361f, 
    0.21951081f, 0.06976023f, -0.03040567f, 0.03479223f, 0.12704627f, 0.09460042f, 0.03086799f, 0.14663479f, 
    -0.20679268f, -0.14359830f, -0.12774262f, -0.00551065f, 0.20011732f, 0.09946094f, -0.07833394f, -0.06968027f, 
    -0.12045467f, 0.13494383f, -0.04404470f, -0.01845391f, 0.02355347f, -0.03811829f, 0.14093898f, -0.01954578f, 
    0.20074071f, -0.25824586f, 0.16401657f, 0.03046259f, -0.30249798f, 0.06855296f, -0.04670766f, 0.11450942f, 
    0.28948331f, 0.09631358f, 0.21396410f, 0.15458168f, 0.37391874f, -0.02710809f, 0.25893742f, -0.10811643f, 
    -0.36632639f, -0.09676640f, 0.03215710f, -0.06955312f, 0.16126679f, 0.25831178f, -0.04125238f, 0.07101988f, 
    0.33420277f, 0.17380631f, -0.08451082f, -0.00310663f, 0.11889650f, -0.00914817f, 0.06921737f, 0.14691590f, 
    -0.12772778f, 0.05993749f, -0.16085705f, -0.11841144f, -0.22132225f, -0.00815724f, -0.02097123f, 0.13864738f, 
    -0.04931333f, 0.00105797f, -0.01899097f, 0.27859071f, 0.04853685f, -0.25204346f, -0.19654813f, -0.15037102f, 
    -0.11553671f, -0.01881253f, -0.16560312f, 0.21218541f, -0.14521778f, -0.00819919f, 0.03674446f, 0.04701999f, 
    0.07948027f, 0.09391461f, 0.01017090f, 0.24084495f, 0.07276233f, 0.01176446f, -0.03554172f, -0.02368119f, 
    -0.06183574f, -0.07706022f, -0.07270449f, 0.04360771f, 0.31926280f, 0.22251385f, -0.14771952f, 0.06817860f, 
    -0.11204484f, -0.07166828f, 0.17415859f, 0.06557378f, -0.10816101f, -0.11298538f, -0.23380323f, -0.03656622f, 
    0.02953908f, -0.14019474f, 0.00456509f, -0.07900528f, -0.31160536f, -0.27428481f, 0.07627112f, -0.10200154f, 
    -0.06067640f, 0.06408223f, 0.10652452f, 0.13708381f, -0.02591479f, 0.02279343f, -0.02567909f, -0.19789954f, 
    -0.21134995f, 0.00956691f, 0.15282854f, -0.02417447f, -0.02979465f, 0.27257919f, -0.15393147f, -0.01691195f, 
    -0.03026964f, -0.10814028f, 0.14378098f, 0.21380220f, -0.49146295f, 0.12666282f, -0.09764086f, 0.13795404f, 
    -0.04048381f, -0.06296458f, 0.28184664f, -0.08429557f, -0.03065226f, 0.09041836f, -0.00170448f, 0.06377552f, 
    0.32190216f, 0.03372269f, 0.10733192f, 0.02218964f, -0.16650957f, -0.13134004f, 0.07228906f, -0.24453963f, 
    0.14095314f, -0.04146171f, 0.06751686f, -0.05737684f, 0.28251424f, 0.13603346f, 0.16919491f, -0.19367780f, 
    0.02244001f, 0.02216241f, 0.15987721f, 0.14622995f, 0.05965014f, -0.00990276f, 0.18266480f, 0.10940678f, 
    -0.03945400f, 0.26186270f, 0.12104435f, -0.04258521f, -0.02450417f, -0.02134374f, 0.11354599f, -0.06098742f, 
    -0.11984454f, 0.11554550f, -0.04782998f, -0.10254353f, -0.10851003f, 0.22049946f, -0.15252155f, -0.13154987f, 
    -0.02789059f, -0.00922659f, 0.10221888f, -0.09179185f, 0.06568824f, -0.17150809f, 0.10059229f, 0.18428211f, 
    -0.15042454f, 0.11384837f, 0.10250791f, -0.10208785f, -0.07272935f, -0.03284352f, -0.01809270f, -0.02154392f, 
    0.04988811f, 0.00004776f, -0.00678195f, 0.03525085f, -0.25645310f, 0.00464663f, -0.04894314f, 0.05889374f, 
    0.06753442f, -0.18819940f, -0.01396407f, -0.01793396f, -0.12896532f, -0.12501720f, -0.04361054f, 0.06170385f, 
    0.18851617f, -0.28292981f, -0.21961406f, -0.15119866f, -0.00092965f, 0.01772784f, 0.05451623f, 0.04102037f, 
    0.06659794f, -0.04643117f, -0.04273390f, -0.07666256f, -0.33626106f, -0.02162419f, -0.19617872f, -0.08291855f, 
    0.16932493f, 0.02415001f, -0.01933150f, -0.10343117f, -0.08988439f, -0.06295677f, -0.02389427f, -0.01229169f, 
    0.13098846f, 0.37027588f, 0.12611447f, 0.18686068f, 0.10421744f, -0.13097721f, -0.02309638f, 0.25961640f, 
    -0.05435143f, 0.16402310f, -0.12581243f, -0.02755909f, 0.32002944f, 0.41501430f, -0.07416095f, -0.23610596f, 
    -0.03110607f, 0.14023264f, 0.22970341f, 0.10851697f, 0.05659410f, 0.10797306f, 0.02505522f, 0.10896337f, 
    -0.01923806f, 0.03346966f, 0.35897639f, -0.22473210f, 0.03813281f, 0.31286415f, 0.11034587f, 0.13814932f, 
    0.10166157f, -0.06281311f, 0.14803900f, 0.24253386f, -0.25814691f, -0.03043090f, -0.06710182f, -0.02956224f, 
    0.00899385f, 0.02592092f, -0.13115013f, 0.13037325f, 0.20895138f, 0.05655551f, -0.05979719f, 0.00073821f, 
    -0.18378735f, -0.02897140f, 0.09239893f, -0.30844110f, 0.07582407f, 0.06860056f, 0.13887000f, 0.02224811f, 
    -0.10687806f, -0.03970842f, 0.02799321f, -0.23553586f, 0.19209787f, -0.09047356f, 0.31082553f, -0.11557157f, 
    -0.04895739f, -0.13025950f, -0.01499786f, -0.06633890f, 0.00024016f, 0.08018620f, -0.02392392f, -0.01322999f, 
    -0.30008715f, -0.00283338f, 0.04753597f, -0.01429019f, -0.13605258f, -0.10211296f, -0.12387724f, -0.03952222f, 
    -0.12226902f, -0.18260334f, -0.10700524f, -0.10066832f, -0.42173165f, -0.11182623f, 0.09608687f, -0.03878924f, 
    -0.10090772f, -0.17344189f, -0.04778517f, 0.14582121f, 0.25000864f, 0.04520653f, 0.07696407f, 0.13317889f, 
    -0.34210223f, 0.23132932f, 0.09737892f, 0.00289471f, -0.09369347f, 0.03079556f, 0.13154078f, 0.26348671f, 
    0.11398187f, -0.10843741f, -0.04699634f, -0.08640800f, -0.72884506f, -0.30430502f, 0.30446607f, 0.23990536f, 
    0.02859721f, -0.09722051f, 0.12959625f, 0.10643978f, 0.03207559f, -0.18228078f, -0.02745670f, 0.04291325f, 
    -0.17750020f, 0.01750516f, 0.02972527f, -0.19651936f, -0.09517118f, 0.17169409f, 0.07097737f, -0.14691095f, 
    0.31721663f, 0.01863709f, 0.01402056f, -0.22031206f, -0.21921876f, 0.06699591f, -0.05689665f, -0.28167230f, 
    0.01243344f, -0.12128199f, -0.06981903f, 0.11400817f, -0.13846543f, -0.13362136f, 0.00339648f, -0.24526364f, 
    0.11025035f, 0.13593572f, 0.08200185f, -0.06745289f, -0.05076479f, 0.02257997f, 0.13139054f, 0.00618816f, 
    0.01045430f, -0.12229431f, -0.03037570f, 0.00667418f, 0.17307816f, -0.18983576f, 0.30217806f, 0.21157250f, 
    -0.01930655f, 0.13264997f, 0.00583219f, 0.11498789f, -0.10800024f, 0.12038260f, -0.12942195f, 0.17637092f, 
    0.46591690f, -0.14655851f, 0.01858187f, 0.17587817f, -0.10297486f, 0.04912260f, -0.07281475f, 0.22291373f, 
    0.04605808f, 0.09763215f, 0.00662201f, -0.03472789f, 0.09314831f, -0.29289693f, 0.19653405f, 0.23261169f, 
    0.08113948f, -0.03530657f, 0.02469131f, 0.08495660f, 0.08751147f, 0.10152541f, -0.06417482f, 0.02170329f, 
    0.12954332f, 0.08021094f, 0.05090157f, 0.06281056f, 0.14691776f, 0.16655049f, -0.03190408f, -0.20708627f, 
    0.17136799f, -0.11642472f, 0.09314830f, -0.04481277f, -0.24417271f, 0.14918277f, -0.21098040f, 0.11982536f, 
    0.23678832f, 0.15091965f, 0.08017904f, -0.01513627f, 0.06870517f, 0.04189559f, -0.02079397f, -0.01821936f, 
    0.10355179f, 0.05760834f, 0.15757683f, -0.17270753f, -0.17244194f, -0.11427171f, -0.04332170f, -0.09151985f, 
    0.08796348f, -0.05755994f, -0.24218324f, 0.12865376f, -0.19244829f, -0.31836334f, 0.31148523f, -0.22165668f, 
    0.00627600f, -0.09117359f, -0.02331622f, 0.21414123f, 0.12796287f, 0.22421636f, 0.29991019f, 0.07935191f, 
    0.08907574f, -0.11851647f, -0.42738357f, -0.00134912f, 0.05107798f, -0.20533065f, -0.09272985f, 0.02007653f, 
    -0.08551253f, -0.02484792f, 0.12384570f, -0.00398983f, -0.10740100f, 0.19539480f, -0.25951400f, 0.13409600f, 
    -0.04221767f, 0.02204411f, 0.07342971f, 0.17467862f, -0.03497301f, -0.00456434f, 0.00866368f, 0.16276830f, 
    -0.08592593f, -0.08016213f, -0.18112384f, -0.13398562f, -0.00987470f, 0.02722952f, -0.23451510f, -0.04543357f, 
    0.08308217f, -0.05932895f, -0.00097020f, 0.15637207f, -0.35079306f, 0.04530297f, -0.10799314f, 0.01233983f, 
    0.04466894f, -0.07280313f, -0.05323749f, -0.02440458f, 0.07058006f, 0.13389550f, -0.09830791f, 0.02763258f, 
    -0.22732557f, -0.27766547f, -0.15250269f, 0.24904071f, -0.08757836f, -0.08901185f, -0.16370775f, -0.04388377f, 
    0.06297756f, 0.02115141f, 0.19656099f, 0.08528966f, 0.05055290f, 0.04773389f, 0.25500861f, 0.02294913f, 
    0.07602368f, 0.15882052f, 0.10106656f, 0.06492985f, 0.14112328f, 0.00167216f, 0.04704432f, 0.00517722f, 
    -0.06180143f, -0.16424157f, -0.03164781f, 0.07364593f, 0.11164547f, -0.12010222f, -0.02493924f, 0.00997761f, 
    -0.05701846f, 0.00615406f, 0.22032210f, -0.05773591f, 0.25431532f, -0.22398229f, -0.12126209f, 0.31658188f, 
    0.05266859f, -0.19768579f, 0.10722924f, 0.04496758f, 0.11540144f, -0.08493016f, 0.14205839f, 0.06836011f, 
    -0.00806682f, -0.21970023f, 0.03897076f, 0.04785044f, -0.00976244f, 0.03696644f, -0.03494458f, 0.09010415f, 
    0.07934675f, 0.05531871f, -0.03902521f, 0.11058658f, -0.43018210f, -0.14672147f, 0.03597633f, -0.12737381f, 
    -0.01404345f, -0.10044407f, -0.15261391f, 0.01632417f, 0.10612098f, -0.15097231f, -0.06013000f, -0.01244731f, 
    0.13186014f, 0.06119348f, 0.13288225f, 0.07064527f, -0.03908337f, -0.08477547f, -0.00202544f, 0.09448708f, 
    0.07590876f, -0.00942817f, 0.13455814f, 0.00032656f, -0.41052979f, -0.03542860f, -0.05822716f, -0.19126934f, 
    0.11304005f, -0.10552693f, -0.05646480f, 0.02921351f, 0.13376148f, -0.03953259f, 0.11334457f, 0.01178914f, 
    0.03061479f, 0.26803383f, -0.00594335f, 0.10167373f, 0.26381058f, 0.01587573f, 0.02461418f, -0.20273429f, 
    0.01162743f, 0.07509679f, 0.06505657f, 0.21910478f, -0.09056821f, -0.08254507f, 0.17096141f, -0.19170131f, 
    0.10149880f, 0.15450035f, 0.18394463f, -0.04023984f, 0.13835956f, -0.06187533f, 0.01371488f, 0.07667915f, 
    0.38528889f, -0.41921881f, 0.02095315f, 0.01265571f, 0.07338393f, -0.03370505f, 0.06888317f, -0.24160977f, 
    -0.04742628f, -0.11941185f, -0.03294682f, -0.03541444f, 0.07782257f, -0.41003811f, -0.18385854f, -0.20307468f, 
    0.05816697f, 0.14748588f, 0.03054865f, 0.00673317f, 0.03832946f, -0.23509818f, 0.04824210f, -0.12455015f, 
    0.21060543f, 0.17052041f, 0.14459017f, 0.28808030f, 0.15793630f, -0.05071472f, 0.05921539f, 0.15125473f, 
    0.02564492f, -0.00143496f, 0.03437090f, 0.36251834f, 0.46390313f, -0.39076930f, 0.32580903f, -0.19310115f, 
    -0.06172551f, 0.07020485f, -0.01222868f, 0.16444901f, 0.01451601f, -0.01900773f, -0.03074158f, -0.02389135f, 
    -0.07595031f, -0.33355266f, -0.25475711f, -0.21417402f, 0.15244374f, 0.01278571f, 0.00500762f, -0.05925437f, 
    0.11643499f, 0.04155579f, 0.01129348f, -0.01081127f, 0.03119094f, -0.00326883f, -0.17022820f, 0.12629744f, 
    0.05516011f, -0.10077712f, -0.15231311f, 0.04316212f, -0.06433434f, -0.01186095f, 0.06865102f, -0.02830532f, 
    0.45846382f, 0.05806863f, 0.05331364f, 0.04996374f, 0.24541484f, 0.11852608f, -0.10585263f, -0.18664190f, 
    0.04923160f, 0.05288415f, 0.11189439f, 0.13666983f, 0.55834132f, 0.37283057f, 0.19514516f, -0.25735027f, 
    -0.01306121f, 0.23817778f, 0.13037345f, 0.11284482f, 0.00590511f, -0.06596475f, 0.04428985f, 0.08643671f, 
    0.21967046f, 0.17500925f, 0.03837527f, 0.20337270f, 0.05563344f, 0.20577416f, -0.01997026f, 0.04753295f, 
    -0.02639025f, -0.00418351f, -0.04194265f, 0.15796229f, -0.07824086f, -0.17228389f, -0.36015528f, -0.26762921f, 
    0.04218035f, -0.02280026f, -0.00314239f, 0.07437050f, 0.03320846f, 0.05796202f, -0.05018224f, 0.01334441f, 
    0.19940494f, 0.24606405f, 0.21140338f, 0.34243941f, 0.07813573f, 0.08001524f, 0.03699167f, 0.00332358f, 
    0.08189777f, 0.10045151f, 0.09602971f, 0.07323314f, 0.38742456f, -0.03245525f, -0.10603401f, -0.13847303f, 
    0.12074709f, -0.00363135f, 0.13861524f, -0.02439052f, -0.05472936f, -0.07728077f, -0.07356475f, -0.00466876f, 
    -0.20697671f, -0.11563198f, -0.12479559f, -0.27217457f, 0.11444060f, -0.14183103f, 0.09698153f, -0.02580907f, 
    -0.03862400f, -0.05035830f, -0.26224512f, -0.03624994f, -0.19190007f, -0.05145975f, -0.29142380f, -0.05637528f, 
    0.11241603f, 0.04057023f, -0.07066632f, 0.04010369f, 0.01431526f, -0.07353005f, 0.10560787f, -0.06596836f, 
    0.34499663f, 0.30894080f, 0.36013046f, 0.01378271f, 0.04189902f, 0.05860776f, 0.12272251f, 0.13195549f, 
    0.05632522f, 0.16404375f, 0.15837935f, 0.16548823f, -0.12841347f, -0.00951324f, 0.08315573f, 0.12853451f, 
    -0.01966968f, 0.06608142f, -0.13851242f, -0.01845940f, 0.07486822f, 0.16327572f, 0.17617463f, 0.35581714f, 
    -0.39418396f, -0.34910437f, -0.18684804f, 0.03916227f, 0.20787309f, -0.05623028f, 0.00001752f, 0.00590023f, 
    -0.05296519f, -0.07038725f, -0.12738076f, -0.18595867f, 0.20665407f, -0.35921049f, -0.15495896f, -0.02245059f, 
    -0.00710932f, 0.04014665f, -0.00059330f, -0.08481511f, -0.05239035f, -0.04171275f, -0.01463020f, 0.06724820f, 
    -0.29654700f, -0.16603367f, -0.21443914f, -0.05398828f, -0.01691389f, 0.08436167f, 0.01389826f, -0.07957184f, 
    -0.22538635f, 0.05215844f, -0.00228198f, 0.18144307f, -0.24639781f, 0.01237653f, -0.07875690f, -0.04709939f, 
    0.02200356f, -0.01923528f, -0.06467271f, -0.06189198f, 0.01273736f, -0.02791164f, -0.12883423f, -0.09332047f, 
    0.01393337f, 0.00676169f, -0.06638495f, 0.11181091f, 0.17398818f, -0.08732624f, 0.03824405f, 0.01770596f, 
    -0.00459313f, 0.03098751f, -0.19929159f, -0.11845628f, -0.08261389f, 0.11047849f, -0.37477013f, -0.00819302f, 
    0.00840334f, 0.05584543f, 0.01932664f, -0.00609549f, 0.18175504f, -0.00876678f, 0.08321460f, -0.02744173f, 
    -0.11456661f, -0.22752348f, -0.28665826f, -0.12911440f, 0.09255107f, 0.00402664f, -0.03207434f, -0.02902902f, 
    0.00043642f, 0.08667205f, -0.03842605f, 0.00482279f, 0.34456518f, 0.31108645f, 0.25495067f, 0.23652248f, 
    -0.18390909f, -0.16588119f, -0.11838523f, -0.00169123f, -0.01420318f, 0.04519686f, -0.14379472f, -0.09525211f, 
    -0.09312332f, -0.25681356f, -0.09371194f, -0.06005923f, 0.03466101f, -0.01819328f, -0.05373713f, -0.13712215f, 
    0.04178086f, 0.02473313f, 0.02674009f, 0.02046670f, -0.66971731f, -0.27280188f, -0.12062895f, -0.09336446f, 
    0.07322066f, -0.01100861f, -0.06255322f, -0.03212222f, 0.00177645f, 0.05279560f, -0.09433216f, -0.05556397f, 
    -0.18074967f, -0.37209025f, -0.28639862f, -0.25185516f, 0.03712953f, 0.04140048f, -0.03138429f, -0.01903223f, 
    -0.23160522f, 0.01820298f, -0.04360393f, 0.05582481f, -0.06839306f, -0.13814677f, -0.39214584f, -0.10113683f, 
    0.13156508f, 0.17498811f, -0.00500244f, -0.11384228f, 0.05246150f, 0.10458411f, 0.00677593f, 0.03543674f, 
    0.10565884f, -0.04289398f, -0.18216111f, 0.04422975f, 0.11105748f, 0.04652860f, -0.05965283f, -0.02344263f, 
    -0.01180969f, -0.04624606f, 0.05215340f, 0.15548117f, -0.01351811f, -0.24062224f, -0.09100298f, -0.22688144f, 
    -0.12183084f, 0.06799705f, 0.00270144f, -0.04005571f, -0.01230551f, -0.12141754f, 0.12240227f, -0.04327990f, 
    0.22391859f, 0.18390612f, -0.29766843f, 0.11018641f, -0.06951918f, -0.02249643f, 0.05668874f, 0.21041161f, 
    0.01421635f, 0.00115572f, -0.22787157f, -0.11714969f, 0.30489168f, 0.11950786f, 0.37551418f, 0.27361283f, 
    -0.04724539f, -0.02263340f, 0.10863799f, 0.28921738f, -0.06360373f, -0.08547732f, 0.00547687f, -0.04187438f, 
    0.01321880f, 0.03415391f, 0.01670165f, -0.04336558f, 0.03862660f, -0.03533258f, 0.04134252f, -0.05390130f, 
    0.04088360f, -0.03806164f, -0.01324575f, 0.02552396f, 0.01901214f, -0.04165598f, 0.00979017f, -0.00629605f, 
    -0.03470041f, -0.03113052f, -0.02049347f, 0.03950627f, -0.01108054f, 0.01598359f, 0.01954265f, -0.00382335f, 
    0.01469489f, -0.02553964f, -0.03458146f, 0.01562381f, -0.00455003f, 0.00781613f, 0.02830394f, 0.03445595f, 
    -0.01846835f, -0.05446516f, -0.04602721f, -0.04920701f, 0.00789172f, -0.00323102f, 0.00655385f, -0.00335208f, 
    -0.00792693f, -0.04531927f, 0.01831849f, -0.01998669f, -0.05438738f, -0.00528599f, -0.00547314f, 0.01770606f, 
    -0.00765936f, -0.02975878f, 0.01220935f, 0.03436070f, 0.00640858f, -0.00199427f, 0.03181507f, -0.03559091f, 
    -0.04306050f, -0.00685958f, 0.00599334f, -0.04581728f, 0.03526742f, 0.00274114f, 0.03933059f, -0.01486775f, 
    -0.00626784f, -0.01814269f, 0.03772489f, -0.04437127f, -0.05177237f, -0.00437778f, -0.00414421f, 0.04498495f, 
    0.04259338f, 0.00475206f, 0.02079473f, 0.02828958f, 0.02507784f, 0.00135549f, 0.04068591f, 0.02600639f, 
    -0.00794190f, -0.05540007f, -0.04096566f, 0.00898331f, 0.03011278f, 0.01816052f, 0.01775877f, -0.02299899f, 
    -0.04709382f, -0.00264482f, -0.04987471f, 0.04205937f, -0.04390622f, -0.04837548f, 0.01404628f, 0.00977076f, 
    0.03717080f, -0.01215181f, 0.03879660f, -0.04794584f, -0.02698313f, -0.00070800f, 0.03366081f, 0.01774493f, 
    -0.04275094f, 0.00196930f, -0.01518454f, 0.03214518f, 0.00187413f, 0.00927920f, 0.03565511f, 0.02886160f, 
    -0.01501041f, 0.02391290f, -0.04181441f, 0.02455267f, -0.01708599f, -0.02404077f, 0.00391860f, 0.00425813f, 
    -0.03039268f, 0.01569669f, 0.00354763f, 0.02502747f, -0.03814515f, 0.01118934f, -0.00201565f, 0.02231480f, 
    -0.03544914f, 0.01833334f, -0.04800289f, -0.02680786f, -0.02856191f, -0.02517158f, -0.02403561f, 0.02444241f, 
    -0.05349359f, -0.01010333f, 0.03205711f, -0.00363842f, 0.01399428f, -0.00987819f, 0.03600591f, 0.00846739f, 
    -0.02689650f, -0.01872269f, 0.01436424f, -0.02551976f, 0.02573630f, -0.02106902f, 0.04357332f, -0.01056577f, 
    -0.01804177f, -0.01110759f, -0.03029522f, -0.03078524f, -0.02716063f, -0.03220586f, -0.00290722f, -0.05100265f, 
    0.02901996f, -0.03241809f, -0.04543177f, -0.00483058f, -0.02147844f, 0.01578486f, -0.04177599f, -0.04390940f, 
    0.00910218f, 0.04539118f, -0.01784644f, 0.01718708f, 0.04286144f, -0.04252544f, -0.04946459f, 0.01401401f, 
    0.02482279f, 0.01055324f, 0.04046532f, 0.01510672f, 0.04230802f, -0.00515835f, -0.04236370f, 0.03300766f, 
    0.00874834f, -0.02526553f, -0.00867895f, -0.01376383f, 0.02436069f, 0.01301882f, -0.05320165f, -0.03883993f, 
    0.02798500f, -0.02313741f, 0.04561969f, 0.03728968f, 0.00842323f, 0.02712087f, 0.01262024f, 0.00616786f, 
    0.01383945f, -0.02613655f, -0.04479071f, -0.05246912f, -0.02509285f, 0.01753561f, -0.04740354f, -0.03978119f, 
    -0.01908436f, -0.01988124f, 0.00158748f, -0.02275627f, -0.01139897f, 0.01037098f, -0.00049472f, -0.04590778f, 
    -0.04034597f, -0.05028613f, -0.02402743f, -0.03457959f, -0.01659271f, 0.04587177f, -0.01466971f, 0.04292913f, 
    -0.04476260f, 0.00795788f, -0.04433163f, -0.05247517f, 0.02164570f, -0.02215813f, 0.02533281f, 0.00961656f, 
    -0.05331887f, -0.01084532f, -0.00437443f, 0.01303005f, 0.01165341f, -0.02743394f, 0.04285896f, 0.02117289f, 
    0.03154854f, 0.01176944f, -0.02805097f, -0.05482284f, -0.00636073f, -0.03622148f, -0.02407115f, -0.04357516f, 
    -0.00194460f, -0.03101305f, -0.03416190f, 0.03512207f, 0.01204402f, -0.02879933f, -0.03249355f, -0.00725423f, 
    -0.01278207f, -0.00785959f, -0.03369590f, 0.01111372f, 0.04113156f, 0.01803284f, 0.01881664f, 0.04077688f, 
    -0.03083454f, -0.04658353f, 0.04646214f, -0.04304585f, -0.03209283f, 0.00482256f, 0.00022936f, 0.02137467f, 
    0.04740985f, 0.03413429f, -0.01724498f, 0.02430945f, 0.02288423f, -0.03531697f, 0.03444341f, -0.03791448f, 
    -0.04631250f, -0.02936654f, -0.01493668f, -0.01189467f, -0.04724325f, -0.02869334f, -0.00013696f, 0.01147279f, 
    -0.02354020f, 0.03317064f, -0.00523877f, 0.00271574f, 0.04363924f, -0.01841502f, -0.01971598f, 0.02819262f, 
    -0.04990352f, 0.04325288f, -0.05429939f, -0.03807744f, -0.01899531f, -0.02429077f, -0.03543708f, 0.02355101f, 
    -0.00320229f, 0.01727951f, 0.03276624f, -0.01233608f, -0.01436003f, -0.00178844f, 0.03150097f, -0.00908476f, 
    -0.01875881f, -0.00650425f, 0.03448867f, 0.02743186f, -0.05425031f, -0.03874915f, 0.02839581f, -0.00468689f, 
    -0.01671633f, 0.02811375f, -0.01305841f, 0.02839188f, -0.04723783f, -0.04845804f, 0.03879115f, -0.03684236f, 
    0.02253272f, -0.03603932f, -0.02671652f, 0.02945174f, -0.05448059f, 0.02898808f, 0.01160587f, 0.03917604f, 
    -0.04476569f, 0.03137311f, -0.01289296f, 0.02705290f, 0.02294549f, 0.01125436f, -0.00377412f, -0.05015854f, 
    -0.01424156f, -0.04780779f, -0.01249449f, 0.03524720f, 0.05240920f, -0.02652545f, -0.01354626f, -0.02690851f, 
    0.04346725f, -0.04812250f, 0.01134972f, -0.04084836f, -0.00866755f, -0.03901974f, 0.01376594f, -0.01432855f, 
    0.02508182f, 0.02276221f, -0.00626021f, -0.00380882f, 0.02703933f, 0.02681726f, -0.02481087f, -0.01055904f, 
    -0.04805541f, -0.01686025f, -0.02791727f, -0.04535689f, 0.02746912f, 0.01926814f, -0.00029025f, -0.02038412f, 
    -0.01781006f, -0.02388380f, -0.00255334f, -0.03876222f, 0.01902408f, 0.03824699f, -0.00861852f, 0.03513560f, 
    -0.31148189f, 0.36720341f, 0.10546731f, -0.14287864f, 0.10199112f, 0.06529652f, -0.22124070f, 0.21857218f, 
    0.06014758f, 0.04771451f, 0.05443982f, -0.01138388f, -0.02290200f, -0.00521752f, -0.20943724f, 0.04166821f, 
    0.18976668f, -0.14664428f, -0.05315565f, -0.00017048f, 0.06236320f, 0.07033912f, -0.19350563f, -0.03497404f, 
    -0.13126560f, -0.01422371f, 0.01883554f, -0.05669995f, 0.00480316f, 0.03638467f, 0.13037030f, 0.06816058f, 
    0.14214469f, -0.00107496f, 0.12731932f, 0.05859319f, 0.02107894f, -0.18674785f, 0.25751042f, 0.48267469f, 
    -0.09662036f, 0.13157038f, -0.06007833f, 0.06741186f, -0.01752806f, -0.01129125f, -0.00563834f, 0.03036388f, 
    -0.25601679f, -0.48829740f, -0.20929945f, 0.21662420f, -0.01411464f, 0.16288973f, 0.09908544f, 0.10390174f, 
    0.10310147f, -0.06746102f, -0.08230975f, -0.06906027f, 0.01338333f, 0.16612664f, 0.61657751f, 0.02351184f, 
    0.04373889f, -0.04562734f, 0.09646957f, 0.02098387f, 0.27327320f, -0.03679282f, 0.18317896f, 0.12815167f, 
    -0.39535850f, 0.01349397f, -0.03227896f, 0.00338231f, 0.08786206f, 0.09279664f, 0.20597447f, 0.11275627f, 
    -0.07376919f, 0.01736957f, 0.04718536f, 0.18754005f, -0.49262857f, -0.36930776f, -0.25367358f, -0.05281902f, 
    -0.07168283f, 0.09234591f, 0.01945329f, -0.12669194f, -0.13882713f, -0.17111856f, 0.05906740f, 0.16115886f, 
    0.07318551f, 0.25841486f, 0.19743149f, -0.14612333f, 0.06455158f, -0.12055258f, 0.02460323f, -0.34212190f, 
    0.04198774f, 0.05194750f, 0.03222028f, -0.07703841f, 0.04964046f, -0.42724714f, 0.03386617f, 0.47701699f, 
    0.04705314f, 0.32298896f, 0.08854475f, -0.02624902f, -0.03946890f, -0.21457627f, -0.02859018f, -0.06997652f, 
    0.10599972f, 0.23382814f, 0.17182671f, 0.04288963f, 0.14924113f, 0.05696506f, 0.12809147f, 0.02370022f, 
    -0.03078890f, 0.00658282f, -0.04989874f, 0.09032386f, -0.20929654f, 0.24772289f, 0.31590667f, 0.06900299f, 
    0.01489536f, -0.00548626f, -0.04442754f, -0.01718652f, -0.18029267f, 0.13892657f, -0.21525876f, 0.13873820f, 
    -0.08126294f, 0.14345822f, -0.10895701f, -0.11412860f, 0.12780717f, -0.03423893f, -0.25319493f, 0.09600502f, 
    -0.14985143f, 0.21900412f, -0.14103192f, 0.06037816f, -0.06542774f, 0.11673060f, 0.34858036f, 0.12196463f, 
    0.02127672f, 0.04676611f, 0.02905053f, -0.00606127f, -0.09754500f, -0.01333626f, 0.03362332f, -0.05951066f, 
    0.30664784f, 0.20353286f, 0.18058455f, 0.11582574f, -0.00746394f, 0.13194948f, 0.12155709f, 0.00009299f, 
    0.00029685f, 0.26081824f, 0.05907158f, 0.07262037f, 0.24447320f, 0.16683282f, -0.16510965f, -0.00469713f, 
    -0.06524988f, 0.02609285f, -0.01521826f, -0.07478761f, 0.03664394f, 0.06115019f, -0.03497025f, 0.14572780f, 
    -0.08238170f, -0.15715957f, -0.34912795f, 0.07284465f, 0.06951487f, 0.05296260f, 0.09458421f, -0.07415703f, 
    0.08744130f, -0.07975455f, -0.18944481f, -0.02688762f, -0.15153906f, 0.10417613f, -0.08143013f, -0.31736785f, 
    0.09460300f, -0.05641612f, -0.07152449f, 0.17559555f, 0.19242083f, 0.15867943f, 0.15248258f, 0.16030318f, 
    0.13985990f, -0.18451267f, -0.06545720f, -0.02920656f, 0.07474680f, -0.16599463f, 0.02958789f, 0.01395395f, 
    0.13702150f, 0.07799149f, 0.02506599f, 0.04480374f, 0.08447852f, -0.07266915f, -0.03360472f, 0.09036266f, 
    0.08893470f, -0.02057639f, 0.10963925f, 0.09227942f, -0.04188778f, 0.03187132f, 0.11920512f, 0.10363731f, 
    0.12411419f, 0.15606894f, -0.14599800f, -0.02296469f, -0.25239474f, -0.06359340f, 0.03541916f, -0.05681004f, 
    -0.01135138f, 0.07254867f, -0.15717711f, -0.12500502f, 0.15526174f, -0.03673660f, -0.45721152f, 0.09517680f, 
    0.02861864f, 0.17412823f, 0.25730529f, -0.06533996f, -0.05766319f, -0.03388730f, -0.15032229f, -0.26811847f, 
    -0.07325801f, 0.07714050f, 0.40812203f, 0.11111978f, 0.06086915f, -0.08559460f, -0.08818971f, 0.01168242f, 
    0.08065037f, -0.00997430f, 0.18624114f, 0.14490227f, -0.07348913f, -0.10729898f, 0.14740369f, 0.18795510f, 
    0.22034048f, 0.25184557f, 0.16827475f, -0.04449956f, -0.06202399f, -0.01934736f, -0.02715076f, -0.04857635f, 
    -0.11964534f, -0.18188994f, -0.10844940f, 0.23703897f, -0.02011690f, -0.06151440f, 0.05204611f, 0.01183149f, 
    -0.00950444f, 0.08293747f, 0.08752176f, 0.10892294f, -0.18113098f, -0.11408386f, -0.14636742f, 0.22744772f, 
    -0.06236308f, -0.11760068f, 0.02812363f, 0.04983768f, -0.07157861f, -0.07510742f, 0.03879195f, 0.05036713f, 
    -0.01719785f, 0.22382791f, -0.00175289f, 0.00706923f, -0.07765534f, -0.04016307f, -0.04135761f, 0.12728848f, 
    0.14045885f, 0.15042891f, 0.07808606f, 0.15977354f, 0.00403581f, -0.34777272f, -0.28300178f, -0.01181306f, 
    0.02985455f, 0.08962633f, 0.03444323f, -0.04995159f, 0.04185756f, -0.10335854f, -0.09434516f, -0.06958084f, 
    -0.16077712f, 0.33423474f, 0.39358243f, 0.14290930f, 0.03051598f, -0.13514225f, -0.13060169f, 0.06208650f, 
    0.12559025f, 0.00157023f, 0.06826500f, 0.21039304f, -0.00034501f, -0.13164926f, -0.37246236f, 0.04130858f, 
    -0.02299669f, 0.07439914f, 0.03055376f, 0.03205288f, 0.17520268f, 0.05241589f, 0.12131879f, 0.00381355f, 
    0.15931398f, 0.23521748f, 0.28383768f, 0.11857753f, 0.21392864f, 0.09942833f, 0.12600313f, -0.18775883f, 
    -0.11256460f, 0.04636399f, 0.21174122f, 0.01370707f, 0.00669741f, 0.22633931f, -0.03372310f, -0.04974071f, 
    0.15044944f, 0.10351326f, -0.01871240f, -0.03476037f, 0.02517679f, -0.03029644f, -0.08985209f, 0.10162057f, 
    0.01009043f, 0.06000204f, -0.06000654f, 0.34379464f, 0.12731417f, 0.07022873f, 0.17639025f, 0.00373424f, 
    0.02895496f, 0.10064368f, 0.10294402f, 0.09223268f, -0.21393073f, 0.08620663f, 0.00924456f, -0.10241448f, 
    -0.22241399f, -0.04413479f, 0.09639239f, -0.05119475f, -0.00904398f, 0.09596265f, 0.07752370f, 0.03837820f, 
    0.33913347f, 0.16071808f, 0.05945140f, 0.17127648f, -0.04533252f, 0.08926690f, -0.08076115f, 0.03203110f, 
    0.12665340f, 0.12049840f, -0.07446320f, 0.03700565f, -0.22215697f, 0.60147023f, -0.26295406f, -0.00750711f, 
    0.04485846f, -0.05451651f, 0.11450282f, 0.01298353f, 0.06256077f, -0.06625408f, 0.00814193f, -0.08083477f, 
    0.11967593f, 0.26264349f, 0.11646272f, -0.27594110f, -0.18222243f, -0.25265864f, -0.16292900f, -0.01936493f, 
    -0.08315836f, 0.03865986f, 0.01157310f, -0.08709158f, 0.20418651f, 0.02713818f, -0.38137516f, -0.11429042f, 
    -0.00482205f, 0.13114902f, 0.10414943f, -0.07064585f, -0.18932788f, 0.06655738f, 0.03465943f, 0.08674853f, 
    0.25618410f, -0.02614947f, 0.05358611f, -0.02762529f, 0.08708584f, 0.12649205f, -0.06487934f, 0.04121858f, 
    0.02178435f, -0.01788819f, -0.02869868f, -0.01487750f, 0.36834455f, 0.41789949f, 0.19841686f, 0.12125433f, 
    0.14664449f, 0.11185793f, 0.02135886f, 0.14267926f, -0.03913834f, 0.05282452f, -0.10589021f, -0.02470429f, 
    0.01981680f, -0.04277506f, -0.01824594f, 0.15036127f, -0.04155857f, 0.14964592f, 0.28043237f, 0.38854006f, 
    -0.07401744f, 0.06676496f, -0.02859697f, 0.07034441f, -0.10806587f, 0.30811375f, -0.00176627f, -0.24632272f, 
    -0.24357249f, -0.31072414f, -0.00193735f, -0.01573135f, -0.04777974f, 0.03166204f, 0.03532077f, 0.03314469f, 
    0.02128921f, -0.18943098f, -0.18152981f, 0.05920587f, 0.11976502f, 0.02499112f, -0.01365559f, 0.01067113f, 
    0.03081441f, -0.00149311f, -0.00835989f, 0.04629279f, -0.04603854f, 0.02368076f, -0.08859089f, 0.08823149f, 
    0.20803677f, 0.10278947f, -0.01480189f, -0.02607780f, 0.18005368f, -0.03060611f, 0.16248661f, -0.14940098f, 
    0.00101547f, 0.42687282f, 0.05388043f, 0.20683838f, 0.06397240f, 0.03903224f, 0.10119900f, 0.01714289f, 
    0.04899972f, 0.10176151f, 0.36215487f, 0.16128978f, 0.08274723f, 0.24909683f, -0.14674398f, -0.07908042f, 
    0.00750247f, 0.00526472f, 0.05968948f, -0.06874203f, 0.19716910f, 0.03128901f, -0.03355532f, 0.12162317f, 
    -0.21469054f, -0.15300471f, -0.07412650f, 0.05596825f, 0.10502848f, 0.07374711f, 0.03798427f, 0.22412932f, 
    -0.07346735f, 0.02647193f, -0.00101685f, 0.00376725f, 0.02455612f, -0.09977627f, 0.25383681f, 0.00420688f, 
    -0.02017231f, -0.01655919f, 0.10940131f, 0.14157371f, -0.01778053f, 0.08344766f, -0.05807720f, -0.09941965f, 
    0.05972138f, 0.04716614f, 0.13304108f, -0.20976402f, -0.12770349f, -0.08878729f, -0.01849673f, 0.09470482f, 
    0.01117769f, 0.02058162f, 0.19950441f, -0.07537808f, 0.15745613f, 0.46807247f, 0.02281999f, 0.52380717f, 
    -0.08638155f, -0.02550073f, -0.01157239f, -0.03037849f, -0.03597277f, -0.00915077f, -0.06432018f, -0.12990810f, 
    -0.02679088f, 0.17228180f, 0.11953733f, -0.09137598f, -0.05860850f, -0.02690056f, -0.19836892f, 0.02893742f, 
    0.05450661f, -0.04570051f, 0.06325088f, -0.01774156f, 0.25188631f, 0.02275385f, 0.17471935f, -0.08472129f, 
    0.21770398f, 0.25217292f, 0.06509773f, 0.01719321f, 0.06747659f, 0.06497177f, 0.00256351f, 0.04854756f, 
    0.00691829f, -0.10788552f, 0.12819786f, -0.03360458f, 0.05980943f, 0.20531400f, 0.01221076f, 0.00155101f, 
    0.01049404f, 0.16017149f, 0.23447777f, 0.13845682f, -0.24287178f, -0.02756485f, 0.44858181f, -0.11880159f, 
    0.00277582f, -0.14074425f, -0.16562070f, 0.07176264f, -0.05105575f, 0.02387786f, -0.02427388f, 0.07522275f, 
    0.10876919f, -0.03288221f, -0.29725581f, -0.16805913f, 0.01654006f, 0.00644393f, 0.04634359f, -0.02052047f, 
    -0.08363762f, -0.00118251f, -0.03405485f, -0.04956418f, -0.01739381f, 0.00437790f, -0.08568637f, 0.01925909f, 
    0.06810946f, -0.07812911f, -0.06455594f, 0.18260951f, -0.02925438f, -0.01862701f, 0.03951717f, -0.04274483f, 
    -0.00565063f, 0.34620622f, 0.24627969f, -0.26368925f, -0.08362579f, 0.03519716f, -0.01655886f, 0.06243918f, 
    -0.00243092f, -0.16075720f, -0.27535027f, -0.11647546f, 0.16670512f, 0.11470277f, 0.15444688f, -0.22273514f, 
    -0.05117562f, -0.00086097f, -0.00060092f, -0.08308067f, -0.09324479f, 0.03856671f, -0.02945370f, -0.00077755f, 
    -0.00606788f, 0.00760498f, 0.00704777f, 0.01646961f, -0.02575444f, -0.10019264f, -0.02534159f, -0.15521242f, 
    -0.00385226f, -0.13259138f, 0.01174664f, -0.18637215f, -0.15256171f, 0.02532938f, 0.20433308f, -0.03974836f, 
    -0.26022941f, -0.23598334f, -0.24649319f, 0.04624201f, -0.09799968f, 0.01808982f, -0.01235170f, -0.09860360f, 
    0.16797818f, -0.25601298f, -0.12143503f, -0.02673379f, 0.09735804f, 0.00496465f, 0.04450757f, -0.04709792f, 
    -0.01477251f, 0.21817328f, 0.05047306f, -0.09426818f, -0.09311600f, 0.07586990f, 0.08496781f, -0.10360544f, 
    -0.09870617f, -0.10129768f, -0.08587395f, -0.00531684f, -0.04550731f, 0.03479886f, -0.02223785f, 0.03012495f, 
    -0.03033912f, -0.06693527f, 0.10963392f, -0.04472347f, -0.07532375f, 0.04766700f, 0.01893847f, 0.28460231f, 
    -0.04300075f, -0.02232755f, -0.01402442f, 0.12719356f, 0.02187783f, -0.02308593f, -0.11665197f, 0.06372458f, 
    0.01402825f, 0.00485284f, 0.07210995f, 0.01457782f, -0.02696935f, 0.07720150f, 0.03653513f, -0.13744153f, 
    0.04123073f, 0.14499898f, -0.70310587f, -0.02452181f, 0.07865132f, 0.20769800f, 0.08364189f, -0.31439832f, 
    0.10864264f, 0.00847104f, -0.00155066f, -0.22916967f, 0.04901677f, -0.13317272f, -0.29469046f, -0.02004564f, 
    -0.03203356f, 0.03113571f, 0.14236483f, -0.03979007f, 0.02055923f, -0.12319074f, -0.00838163f, -0.12024811f, 
    0.18426414f, 0.10598185f, 0.05778382f, 0.03325804f, -0.06431296f, -0.23665528f, 0.13471450f, 0.10717454f, 
    -0.10909592f, -0.22968318f, -0.16460860f, -0.18984197f, 0.10099608f, 0.24516577f, 0.10960158f, -0.10626788f, 
    -0.20534419f, -0.30803615f, 0.10115743f, 0.00329796f, 0.02810430f, 0.05073171f, 0.01535912f, 0.00513683f, 
    -0.00268385f, -0.08135746f, 0.25621900f, 0.03008571f, 0.02884362f, -0.01906505f, -0.03888445f, -0.00301379f, 
    0.02191052f, 0.03625029f, 0.06555279f, 0.14351021f, -0.18682902f, -0.18267816f, -0.05979655f, 0.08533453f, 
    0.05650339f, 0.01161185f, -0.04212856f, 0.23402254f, 0.00412707f, -0.13642904f, -0.14540511f, -0.12057167f, 
    0.27992666f, 0.23425485f, 0.19651920f, 0.02142219f, 0.05965805f, -0.01835031f, -0.00475675f, 0.22994393f, 
    0.06192806f, -0.10028539f, -0.09534620f, 0.18768385f, 0.06576455f, 0.31905305f, 0.51627153f, -0.36212686f, 
    0.01624027f, 0.14739268f, 0.09735876f, 0.33823311f, 0.03435667f, 0.02104591f, -0.02300068f, 0.25873384f, 
    -0.03229015f, 0.10539746f, -0.18363526f, -0.12531659f, 0.27855968f, 0.22693603f, 0.09315664f, -0.06979374f, 
    -0.02305305f, -0.14564438f, -0.07207251f, -0.03336627f, 0.15388742f, 0.04890945f, -0.05202130f, -0.18109575f, 
    0.01746770f, -0.13935986f, -0.25126445f, 0.10963055f, -0.07543649f, 0.01863322f, 0.09758240f, 0.09876589f, 
    0.22022082f, 0.08221789f, -0.20171389f, -0.22822995f, -0.05073848f, 0.18601769f, 0.12929371f, 0.04249760f, 
    0.03996585f, -0.19177449f, -0.00518915f, 0.08880275f, -0.13300906f, 0.24133058f, -0.00549991f, -0.09141913f, 
    0.15012753f, 0.11240505f, 0.06007967f, -0.12755026f, 0.09607892f, 0.14294718f, -0.12207621f, -0.09860106f, 
    0.07186102f, -0.06167201f, 0.10984482f, -0.23026423f, 0.00618936f, -0.12310113f, 0.08696011f, -0.23289101f, 
    0.20806280f, -0.01156747f, 0.01559771f, -0.09900253f, -0.10095316f, -0.00469832f, -0.02665257f, -0.18393084f, 
    0.01622233f, 0.03498507f, 0.04659253f, 0.02849554f, -0.02241536f, 0.06881816f, 0.07943143f, -0.09908830f, 
    0.31902009f, 0.02732616f, 0.29767972f, -0.00941013f, -0.29149267f, 0.16841748f, 0.05973775f, -0.20919801f, 
    0.01970179f, 0.00955235f, 0.03356491f, 0.18591990f, -0.11717922f, -0.43510288f, 0.20392877f, 0.03223052f, 
    0.05670271f, 0.16025089f, -0.13237688f, -0.07664153f, 0.13560703f, 0.26208457f, 0.25796118f, 0.27434954f, 
    0.19707198f, 0.12814423f, -0.04229717f, -0.12268601f, 0.11940464f, 0.00376185f, -0.01665474f, 0.01381665f, 
    -0.14447649f, -0.14475575f, 0.02930886f, 0.00436410f, 0.42794403f, 0.24027973f, -0.05014197f, 0.17408709f, 
    0.02560265f, 0.08363520f, -0.02854067f, -0.06061010f, 0.11157530f, -0.03183361f, 0.05388895f, -0.02956307f, 
    0.09171402f, -0.06148432f, -0.14283454f, 0.08878089f, 0.08459602f, -0.01792331f, 0.19149102f, 0.02575100f, 
    -0.03350041f, -0.09346262f, 0.04435277f, -0.06401064f, -0.05080800f, -0.05093943f, -0.04735098f, 0.06235216f, 
    0.07989286f, 0.04108049f, -0.10514681f, -0.20803683f, -0.04695353f, 0.06350058f, -0.17255627f, 0.20175254f, 
    -0.08013144f, -0.11860541f, 0.11087552f, 0.15045185f, 0.01950290f, -0.03889995f, -0.16467899f, -0.08147509f, 
    -0.16774105f, -0.17693344f, -0.21040845f, -0.20371325f, 0.21508303f, -0.42860883f, -0.11897941f, 0.21135207f, 
    0.01177605f, -0.09364318f, -0.19454663f, -0.04780430f, 0.07455733f, -0.05228707f, 0.11506921f, -0.10134266f, 
    -0.00316657f, -0.28797212f, -0.27314374f, 0.18412681f, -0.04635580f, -0.04902744f, 0.03402973f, 0.13836710f, 
    -0.06420082f, -0.08206411f, -0.06124947f, -0.04248331f, 0.31448525f, 0.62797946f, 0.07685474f, -0.08892282f, 
    0.37406364f, 0.19066310f, 0.25867456f, 0.18939890f, 0.07868605f, 0.00033808f, -0.16504031f, 0.01626656f, 
    -0.13196476f, -0.06537538f, 0.28561312f, 0.08081143f, 0.12335649f, -0.02247576f, -0.07775319f, 0.27573168f, 
    0.21674202f, -0.04119929f, 0.19512948f, -0.11387951f, -0.17289908f, -0.20672157f, 0.33837959f, 0.15119416f, 
    -0.05133551f, 0.11913035f, -0.06904507f, 0.14098620f, 0.04001735f, 0.05963177f, -0.04109799f, -0.12785386f, 
    0.15799233f, -0.22004905f, 0.03831241f, 0.12537155f, 0.01237370f, 0.08807169f, 0.01216667f, 0.08586598f, 
    0.09741419f, 0.38083798f, -0.06287327f, -0.09397732f, 0.13110603f, -0.11075827f, 0.01041070f, 0.12150092f, 
    0.01217508f, 0.00775050f, -0.07233058f, -0.05906024f, -0.03935191f, -0.10218646f, 0.09084464f, -0.01328235f, 
    -0.06720244f, -0.10479317f, -0.25024408f, 0.19085373f, 0.01578805f, 0.21513048f, 0.17982878f, 0.03189331f, 
    0.19918343f, 0.19556080f, 0.16611187f, -0.10884767f, -0.12162890f, -0.12465198f, 0.35196871f, -0.10141769f, 
    -0.04281207f, 0.11308055f, -0.19397302f, 0.10599794f, 0.02438810f, -0.05510841f, 0.05752964f, 0.01370580f, 
    0.14689411f, -0.20053197f, -0.17186965f, -0.00647395f, -0.11458170f, 0.12460904f, 0.10840920f, -0.06059321f, 
    -0.06677093f, -0.07065814f, -0.23251905f, 0.03341803f, 0.32317260f, -0.01901452f, 0.25707859f, 0.10362830f, 
    0.42897567f, 0.20588088f, 0.14529952f, 0.05108532f, -0.03459941f, -0.25474024f, -0.13785166f, -0.09777322f, 
    -0.00145482f, -0.04581538f, -0.01638945f, -0.04888780f, 0.03463852f, -0.04474724f, -0.05160008f, -0.03563156f, 
    -0.03431210f, 0.00657466f, 0.02180105f, -0.03967892f, 0.04542758f, 0.03359412f, -0.00699225f, -0.02410657f, 
    0.04080649f, -0.03392530f, -0.02403780f, 0.02324007f, -0.02664453f, 0.03897903f, -0.02093630f, -0.04478754f, 
    0.02723143f, -0.00311811f, 0.04403324f, -0.03386277f, -0.00114067f, 0.00890261f, 0.00889388f, 0.04332434f, 
    0.00951369f, 0.04461098f, -0.03542348f, 0.01223245f, -0.04823510f, 0.01441403f, -0.00445886f, 0.02207236f, 
    -0.04901184f, -0.03733403f, 0.03436165f, 0.00901588f, -0.03866452f, -0.03739639f, 0.00066173f, -0.04428669f, 
    -0.04040784f, 0.00701285f, -0.04514433f, 0.04340994f, -0.01449624f, 0.04080503f, 0.02955050f, -0.03157183f, 
    -0.03083634f, 0.00241994f, 0.02802923f, -0.02838419f, -0.01991843f, 0.01964446f, -0.04087395f, -0.03262478f, 
    -0.04765958f, 0.04674719f, 0.00330935f, 0.03230515f, 0.04165584f, 0.01995467f, 0.03762473f, -0.01857061f, 
    -0.01187730f, -0.03573436f, -0.00788182f, -0.02756720f, 0.00663465f, 0.03372962f, -0.02856118f, 0.01554839f, 
    -0.05992253f, -0.02863116f, -0.04408833f, 0.00433120f, -0.04400885f, 0.01453819f, -0.04105591f, 0.00931054f, 
    0.04669340f, 0.03449880f, -0.04579004f, -0.03423914f, -0.03795828f, -0.03154504f, -0.00408328f, -0.02351673f, 
    -0.05287699f, -0.00858653f, -0.06349715f, -0.02034215f, -0.05614772f, -0.00016783f, -0.05004881f, -0.00565116f, 
    -0.00188509f, -0.02240963f, -0.05050441f, -0.05156807f, 0.03978677f, 0.02513267f, -0.00940659f, 0.04110631f, 
    -0.04997053f, 0.01618582f, -0.00288295f, 0.03457613f, -0.03447341f, -0.03516484f, 0.02259406f, -0.03803037f, 
    -0.04777944f, 0.02845656f, 0.00789572f, -0.04759203f, -0.02349433f, -0.02471587f, 0.03042870f, -0.04135240f, 
    -0.05630326f, -0.01852320f, -0.02135458f, -0.02331113f, 0.04031588f, -0.01622660f, -0.03955296f, -0.00337791f, 
    0.01980005f, 0.03542285f, -0.03079439f, 0.04092326f, 0.01378755f, -0.05306954f, 0.04195176f, 0.00368318f, 
    0.04346994f, -0.01542965f, -0.00248331f, 0.01052209f, 0.00099273f, 0.03268063f, -0.01579025f, -0.02154614f, 
    0.04705361f, -0.00150167f, -0.03732796f, 0.03969208f, 0.03669884f, -0.02237157f, -0.04699771f, -0.02344581f, 
    -0.02379026f, -0.02826776f, 0.03089989f, -0.01757147f, -0.05134217f, -0.03684428f, -0.02620969f, 0.04343849f, 
    0.01660862f, 0.01198696f, -0.03524021f, 0.02238442f, -0.04490903f, -0.04354721f, 0.04228524f, 0.02189184f, 
    -0.01722704f, -0.02952917f, -0.04248055f, -0.04493657f, -0.01383929f, -0.03062920f, -0.00188049f, -0.05363215f, 
    0.02896162f, -0.04425706f, -0.04719129f, 0.03548618f, -0.04200641f, 0.03678831f, -0.02175140f, 0.04626829f, 
    0.01581156f, 0.04078546f, -0.03756379f, 0.03405111f, -0.00165857f, -0.03719300f, -0.00409438f, 0.03041228f, 
    0.01112334f, 0.01360214f, 0.02503045f, 0.00429401f, -0.00726354f, 0.01993308f, 0.00480963f, -0.00814655f, 
    -0.04189927f, -0.01396440f, 0.01567476f, 0.02380807f, 0.01643909f, -0.02569436f, -0.04835512f, 0.01918898f, 
    0.03987147f, 0.02739832f, -0.05068790f, 0.00932745f, 0.02025056f, 0.05038724f, 0.01578498f, 0.02479770f, 
    -0.03225148f, -0.02352221f, 0.00866226f, 0.01440958f, -0.02222807f, -0.04411668f, -0.01872124f, 0.04912654f, 
    -0.04166412f, -0.00527257f, -0.03512903f, -0.03772287f, -0.04438356f, 0.00539870f, -0.01838120f, 0.03720444f, 
    -0.00555839f, 0.01457822f, 0.01278578f, -0.05051394f, -0.02779974f, -0.02263834f, -0.00607799f, 0.03617708f, 
    -0.02191290f, -0.05247948f, -0.03905662f, 0.01526938f, -0.03575721f, 0.02986062f, 0.00116443f, -0.03371907f, 
    -0.04204487f, -0.00072076f, -0.04403251f, -0.02366197f, 0.04688768f, 0.01015197f, -0.03748835f, -0.03480310f, 
    0.02199162f, -0.00792008f, -0.04960784f, -0.05199220f, -0.03086447f, 0.02968301f, -0.01641857f, -0.04293480f, 
    0.03251073f, 0.04480759f, -0.00590615f, -0.03743886f, 0.01921268f, -0.00184406f, -0.05256902f, 0.00391448f, 
    -0.01220413f, -0.05683401f, -0.05216397f, 0.01808358f, 0.01059374f, -0.02750536f, 0.04389062f, -0.03476683f, 
    0.01192901f, -0.00961380f, 0.00123093f, -0.01177345f, -0.00901971f, 0.01133466f, -0.04255322f, 0.03172164f, 
    0.03503669f, -0.00633421f, 0.04581416f, 0.02530783f, 0.02136666f, -0.02849216f, 0.01011096f, -0.02719353f, 
    0.04929889f, 0.01379016f, 0.01821232f, 0.04578394f, 0.02034858f, 0.02409806f, -0.05295400f, 0.03111162f, 
    0.00207166f, -0.05389652f, 0.01736426f, 0.01101251f, -0.04933911f, -0.03567740f, 0.01705502f, -0.01769523f, 
    0.00016067f, -0.05680565f, 0.03156329f, -0.04070063f, 0.04969909f, 0.01606854f, 0.03403479f, 0.03869109f, 
    -0.01020475f, -0.04545960f, -0.05547030f, 0.03845831f, -0.00392082f, -0.02227268f, -0.06213450f, -0.01435334f, 
    0.01689497f, -0.02524850f, -0.03320803f, -0.04879977f, 0.04244814f, 0.03706121f, 0.05122993f, 0.02199978f, 
    -0.03380177f, 0.00506683f, -0.03228994f, 0.00808536f, -0.00511340f, -0.03066207f, -0.04657058f, -0.00941232f, 
    -0.03155002f, 0.02504887f, -0.03645219f, 0.01720328f, 0.01869058f, -0.00609295f, -0.02264023f, -0.03378182f, 
    -0.00353268f, 0.00065187f, 0.03777568f, -0.02751571f, 0.02991563f, -0.03938762f, 0.04388348f, 0.03726672f, 
    -0.03233252f, -0.03734581f, 0.02749074f, 0.00567890f, 0.04208391f, 0.04016119f, -0.01332830f, 0.02030428f, 
    -0.01035904f, -0.02364038f, 0.04379647f, 0.00492652f, -0.03961977f, -0.01572367f, 0.03997937f, -0.00157251f, 
    0.45977446f, 0.00724048f, 0.04958346f, -0.17175983f, 0.04011448f, -0.22541434f, 0.19799264f, -0.26743755f, 
    0.06407736f, 0.04113887f, 0.21449086f, 0.23343982f, -0.03601383f, -0.39463001f, 0.06588534f, -0.18398169f, 
    -0.10084385f, 0.10194825f, -0.26193255f, 0.12200211f, 0.28678980f, 0.13500884f, 0.03776918f, 0.03657953f, 
    0.36560687f, -0.11300816f, -0.03902795f, -0.16258432f, 0.14953378f, -0.11913917f, 0.07159897f, 0.07680131f, 
    0.01423467f, 0.00251319f, -0.10042733f, -0.08477508f, -0.19749263f, 0.50475991f, -0.06932937f, -0.24815987f, 
    -0.12090906f, -0.11158185f, 0.11811003f, 0.13339293f, 0.05062132f, -0.05765231f, -0.13518815f, -0.08793376f, 
    -0.25528896f, -0.14044610f, -0.03590223f, 0.22330543f, -0.01791629f, -0.06191795f, 0.12241349f, -0.22519538f, 
    -0.04326686f, -0.14757752f, 0.05063840f, 0.03742141f, -0.10663157f, 0.24887100f, 0.01957125f, 0.49539593f, 
    0.10522899f, -0.07550579f, -0.08684865f, -0.23708470f, -0.17477126f, 0.08204001f, -0.03111531f, 0.20782019f, 
    0.31638971f, 0.07913434f, 0.32099378f, 0.03174192f, 0.19552353f, 0.26432675f, -0.02529503f, 0.07203284f, 
    0.03296534f, -0.03288331f, 0.06912241f, -0.10776573f, 0.18388575f, 0.39160073f, 0.22662002f, -0.11631311f, 
    0.12507921f, 0.08661345f, -0.12288943f, -0.12612194f, 0.09732629f, 0.00494877f, 0.02119195f, 0.02525608f, 
    0.05055790f, -0.04396354f, -0.12533608f, -0.23753598f, 0.03162021f, 0.17565048f, 0.15716569f, 0.21711570f, 
    -0.05208708f, 0.18425249f, 0.04734282f, -0.06568144f, -0.32859305f, -0.10426872f, -0.06606694f, -0.14162765f, 
    -0.08689768f, -0.13572523f, -0.03308180f, 0.06606751f, -0.04536367f, -0.11255424f, -0.03190925f, -0.09146798f, 
    0.06882713f, 0.07628466f, -0.03152394f, -0.03949490f, 0.11104293f, -0.04672460f, 0.13169155f, 0.11876766f, 
    -0.13661002f, -0.00735000f, 0.03202454f, 0.11206762f, 0.21744771f, -0.30529925f, 0.03967934f, -0.09651320f, 
    0.07592086f, 0.03000678f, 0.07231124f, -0.04443438f, 0.00875426f, -0.01431703f, 0.20637718f, 0.20456520f, 
    0.15630673f, 0.04482486f, -0.00727144f, 0.13888024f, -0.03522230f, -0.00147928f, -0.03252227f, 0.14081517f, 
    0.12422495f, -0.01221623f, 0.14030261f, 0.03363244f, -0.17972825f, 0.40033984f, 0.08469786f, 0.31154326f, 
    -0.04243378f, 0.01426855f, -0.00107940f, 0.11489599f, 0.17990817f, -0.16382301f, -0.05112875f, -0.05228702f, 
    -0.01183582f, -0.06262693f, -0.08674581f, -0.07910426f, 0.01676002f, -0.03326137f, 0.13878293f, 0.14170977f, 
    0.03325958f, 0.04331692f, 0.01410897f, -0.14359848f, -0.21034917f, 0.08362354f, -0.17676502f, 0.06916796f, 
    -0.01551368f, -0.00522375f, -0.04209223f, 0.13078773f, 0.06586591f, 0.05526528f, -0.04686187f, 0.09785542f, 
    -0.19862556f, -0.17763101f, -0.07724287f, 0.10938066f, -0.01039465f, -0.07966474f, -0.01517629f, -0.03353585f, 
    0.06328109f, 0.05831953f, 0.08669719f, 0.09434306f, 0.50218540f, -0.10738970f, 0.12054962f, 0.12956749f, 
    0.04651461f, -0.10159362f, -0.06435557f, -0.08520887f, 0.09917447f, 0.00051518f, -0.06738452f, -0.18048994f, 
    -0.12501384f, -0.13977209f, 0.00073807f, -0.08701362f, -0.13648288f, 0.02846410f, -0.21310465f, -0.00978711f, 
    0.08817343f, -0.00687294f, -0.01301460f, -0.04327579f, -0.07105265f, 0.20621856f, -0.15568912f, -0.05415191f, 
    0.18463556f, 0.18169808f, -0.14986211f, -0.04180508f, 0.09341886f, 0.02344469f, 0.05164232f, 0.22705606f, 
    -0.03550202f, -0.15970026f, 0.13776077f, -0.12510143f, 0.09940265f, 0.17419043f, 0.01279199f, -0.22388899f, 
    0.35169467f, 0.18885821f, 0.05384898f, 0.21545443f, -0.37648246f, 0.23856959f, 0.03429424f, -0.21521480f, 
    0.10637222f, -0.14928158f, -0.12651204f, -0.04252394f, 0.16291036f, 0.04646121f, 0.04369216f, 0.13060367f, 
    -0.03302738f, -0.11287834f, -0.02593175f, 0.17815700f, 0.10176259f, -0.17665409f, -0.13774604f, -0.21181980f, 
    0.03035467f, 0.04681861f, 0.08485567f, 0.15621342f, 0.01117455f, 0.10719900f, 0.02303155f, -0.26052061f, 
    0.04958474f, 0.11429647f, 0.06975836f, 0.24880309f, 0.05854223f, 0.06561520f, 0.10417472f, 0.06750492f, 
    -0.13030483f, 0.08611000f, 0.10895513f, 0.07239790f, 0.08064554f, -0.00754315f, -0.03477893f, -0.04541643f, 
    -0.01606265f, -0.15632783f, -0.02292066f, -0.16661151f, -0.13743335f, 0.03862846f, -0.01185417f, 0.26767543f, 
    -0.11293814f, -0.11030196f, -0.01234751f, -0.12032762f, 0.29323879f, 0.05679125f, -0.03593772f, 0.12532906f, 
    0.05485508f, 0.16537480f, -0.04504639f, 0.06295168f, 0.00387340f, -0.04678517f, 0.03457056f, -0.15526846f, 
    -0.05383357f, -0.01776897f, 0.02626106f, -0.15703855f, -0.27685049f, -0.08832017f, 0.03106179f, 0.03258746f, 
    0.04078161f, 0.01742473f, -0.08197024f, -0.05982189f, 0.21918061f, 0.12631670f, 0.11718904f, 0.13632740f, 
    0.09931464f, -0.01484571f, -0.13041300f, 0.09312151f, 0.06718288f, -0.11890196f, -0.03255694f, -0.29594246f, 
    -0.02307239f, 0.10459304f, 0.19048294f, -0.00229083f, -0.35048243f, 0.02653751f, -0.09235432f, -0.14269647f, 
    -0.07696598f, 0.03052043f, 0.07522871f, -0.04385711f, 0.09603062f, 0.16664657f, 0.15760989f, 0.05959610f, 
    0.14605720f, 0.04488396f, -0.34809899f, -0.10167121f, -0.07099947f, -0.07289473f, 0.23301096f, 0.16769019f, 
    0.01569245f, -0.05446408f, -0.18343358f, 0.01556032f, 0.05518052f, -0.01471071f, -0.02860246f, -0.16532882f, 
    0.02165157f, 0.23480855f, 0.39448616f, 0.18099354f, -0.02401206f, -0.06481179f, 0.03343898f, -0.17580611f, 
    -0.15639742f, 0.10584299f, 0.26623440f, -0.02082733f, 0.31665638f, -0.15330055f, 0.29426745f, 0.13506813f, 
    0.23015194f, 0.13860464f, 0.03508967f, 0.22052470f, -0.10598278f, -0.15437791f, 0.01518523f, -0.05038606f, 
    -0.13893048f, 0.13912110f, -0.17348270f, 0.02614047f, 0.00710150f, -0.05851743f, 0.08354267f, 0.08671937f, 
    -0.31013834f, -0.38055182f, -0.13817804f, 0.13879345f, -0.00849637f, 0.18858777f, 0.20083304f, 0.02303184f, 
    0.26157299f, 0.09678968f, 0.18552376f, 0.24941650f, 0.45913824f, 0.03983112f, -0.15043604f, -0.11654676f, 
    0.26891994f, -0.09791341f, -0.03395086f, -0.09602518f, 0.02929473f, 0.04665683f, 0.10470919f, 0.04874658f, 
    -0.07626837f, -0.08291738f, -0.08382118f, -0.19388063f, -0.02844137f, 0.13306065f, 0.07598904f, -0.13516806f, 
    -0.13267086f, -0.07110248f, -0.21719828f, -0.05854555f, -0.18317457f, 0.02306046f, 0.11573719f, -0.21048208f, 
    -0.04102306f, -0.24401733f, -0.00815101f, -0.05521251f, 0.02940882f, 0.37076056f, 0.13210827f, 0.05272596f, 
    -0.44755000f, -0.17902619f, -0.03729232f, -0.11359976f, -0.13176252f, 0.29544142f, -0.20041022f, 0.08549301f, 
    0.01428251f, -0.03120525f, 0.15565617f, 0.09286631f, -0.25627187f, -0.20103255f, -0.08160997f, 0.04767288f, 
    -0.02995281f, 0.02751690f, -0.14296782f, 0.16353935f, 0.03297619f, 0.01628846f, 0.17920244f, 0.20010826f, 
    -0.56251580f, -0.26633504f, 0.05332423f, 0.00861111f, -0.02114990f, 0.02481629f, -0.09462393f, -0.03125869f, 
    0.02591153f, 0.10466611f, 0.03482280f, -0.04110976f, -0.25505087f, 0.00565698f, 0.15410651f, -0.04153293f, 
    0.08282037f, 0.12009878f, -0.03365855f, -0.05760820f, -0.17880146f, -0.05960315f, -0.03919750f, -0.10194045f, 
    -0.43228582f, -0.16430789f, -0.09689600f, -0.30741277f, -0.04316143f, -0.00773210f, -0.02772292f, 0.19690962f, 
    -0.07197719f, -0.01103169f, -0.05427815f, -0.13495581f, 0.23862150f, -0.16962954f, 0.38746259f, 0.09191715f, 
    0.00922664f, -0.00257097f, 0.17629494f, 0.31856719f, 0.05427032f, -0.09682479f, -0.12501995f, 0.07068620f, 
    -0.14539087f, 0.20929632f, 0.02561421f, 0.02897759f, 0.01907089f, 0.02528178f, 0.12260620f, 0.05401013f, 
    0.05439885f, 0.27745953f, -0.14266437f, 0.23693560f, 0.13992009f, 0.11185329f, -0.11306253f, -0.04780975f, 
    -0.03377381f, -0.13963538f, -0.02867525f, -0.00787609f, 0.04025524f, 0.18165287f, 0.30337927f, 0.11446045f, 
    0.19248146f, -0.07547304f, -0.28989530f, -0.26658022f, 0.19382231f, 0.13518485f, 0.03773048f, 0.09005496f, 
    0.22155187f, 0.08778178f, -0.00960273f, 0.07962550f, 0.10606574f, 0.21887568f, 0.03366662f, 0.00425600f, 
    0.07900608f, 0.19039783f, 0.22999212f, 0.13234310f, 0.18929186f, 0.18151353f, 0.05196428f, -0.02924232f, 
    -0.15816575f, -0.06232915f, 0.11577899f, -0.20503640f, -0.03049454f, -0.08319141f, -0.01890333f, -0.09285868f, 
    -0.10698449f, 0.06396757f, 0.00816527f, 0.07201399f, -0.21763331f, -0.09989972f, 0.10266328f, -0.12188318f, 
    -0.05102764f, -0.04785267f, 0.11338709f, 0.00714516f, 0.13529879f, 0.32325497f, 0.37684736f, 0.22234908f, 
    -0.11465208f, 0.12587933f, 0.00403993f, 0.04040937f, -0.04029788f, -0.02011948f, 0.05994650f, 0.01625451f, 
    0.14536853f, 0.47705492f, 0.05531832f, -0.08380341f, -0.11005793f, 0.05158542f, -0.08391547f, 0.22578962f, 
    0.24645522f, 0.12845413f, 0.24715681f, 0.11418439f, 0.09972717f, -0.08873237f, -0.06903969f, 0.03829410f, 
    -0.06012945f, -0.14141746f, -0.27542758f, -0.12824140f, 0.12020233f, -0.38963789f, -0.07077894f, 0.08152435f, 
    0.10959236f, 0.03683902f, -0.03517284f, 0.01955296f, -0.00905114f, 0.17399503f, -0.08799965f, -0.10040865f, 
    0.13532281f, -0.01462911f, 0.06132679f, 0.00569149f, -0.14010078f, -0.07170612f, -0.05655324f, 0.04371318f, 
    -0.24711204f, -0.02904629f, 0.19010569f, -0.03779966f, -0.02925272f, -0.09447190f, -0.12735252f, -0.08492468f, 
    0.21768497f, 0.37012267f, 0.10789475f, 0.15422212f, -0.07399032f, -0.20631930f, -0.45774269f, -0.21356310f, 
    -0.02221547f, -0.13624907f, -0.07519588f, -0.11544874f, 0.03635829f, -0.04758263f, 0.06134303f, 0.02842168f, 
    0.23974457f, 0.02966025f, -0.19217975f, -0.10740808f, 0.01146937f, 0.10163962f, 0.04130347f, 0.04742161f, 
    -0.22200467f, 0.08693794f, 0.00440578f, -0.09959670f, 0.46453634f, -0.04669465f, -0.32788545f, -0.05863428f, 
    0.09735478f, -0.08455423f, 0.06966230f, -0.00132708f, 0.04820778f, 0.06641803f, 0.07524239f, -0.04170950f, 
    0.10451837f, 0.13701852f, 0.15130603f, -0.03817207f, -0.10730211f, -0.02070767f, 0.00295103f, 0.02195667f, 
    0.12312213f, -0.00244253f, 0.28980735f, 0.25907528f, -0.03356479f, -0.02501526f, -0.04489865f, -0.10490182f, 
    -0.11588690f, -0.04654082f, -0.05148120f, 0.00315743f, -0.25722444f, 0.00356255f, -0.11810771f, -0.02825966f, 
    -0.18756464f, 0.25111559f, 0.20957342f, 0.14103316f, -0.07777951f, 0.03650697f, 0.01238243f, 0.20436059f, 
    0.03867591f, 0.25353345f, 0.03146573f, 0.22723882f, 0.03689173f, -0.14187069f, -0.05176951f, -0.08234657f, 
    -0.02906681f, 0.03087215f, 0.02401103f, 0.09966816f, 0.12088738f, -0.02081289f, -0.00897186f, -0.18771224f, 
    -0.16465557f, -0.13969365f, -0.10555866f, -0.20938684f, 0.24817631f, 0.29923302f, -0.00380360f, 0.21724109f, 
    0.14664778f, 0.03791663f, 0.09459110f, 0.27129889f, -0.23153515f, -0.48707461f, -0.18738981f, -0.50800312f, 
    -0.10515114f, -0.08256565f, -0.19567738f, -0.01474563f, 0.01077868f, 0.03883612f, 0.07433251f, 0.14645877f, 
    0.01733765f, -0.05550189f, -0.00917399f, -0.05394273f, -0.04958350f, -0.02703189f, -0.05063430f, -0.00239455f, 
    -0.02617712f, 0.00909333f, -0.04564531f, 0.02349526f, -0.05433265f, -0.02255198f, 0.01768065f, -0.04327480f, 
    0.00973929f, -0.01333731f, 0.02884089f, 0.03007270f, -0.05204562f, 0.03731946f, -0.04112224f, -0.02082579f, 
    0.02336378f, -0.02204743f, -0.04304945f, 0.00439116f, -0.00655404f, 0.02111428f, 0.02098481f, 0.04459869f, 
    0.03485980f, 0.01833439f, 0.04518477f, -0.00654512f, -0.05000144f, 0.05100402f, -0.03027483f, -0.01425704f, 
    0.04700178f, 0.02277666f, 0.01142024f, -0.03755910f, 0.01694407f, 0.00520969f, -0.04513385f, -0.03400704f, 
    -0.00403709f, 0.03328554f, 0.01542255f, -0.00148604f, 0.00544500f, -0.01678655f, 0.00986694f, 0.00560974f, 
    -0.04154401f, -0.01653448f, -0.04615245f, -0.03048816f, -0.04265446f, 0.00750247f, -0.04188100f, -0.03369534f, 
    -0.02752169f, 0.00158653f, -0.03894430f, -0.02210804f, 0.01289509f, 0.03699237f, 0.00298664f, -0.02441574f, 
    -0.00436904f, -0.03956542f, -0.01228589f, 0.03085396f, -0.00051067f, -0.04088762f, 0.03032346f, -0.03171180f, 
    0.01706209f, -0.04646952f, -0.01046526f, 0.03161880f, 0.02571583f, -0.04643735f, 0.03820089f, -0.01116800f, 
    0.03831033f, 0.01198734f, -0.00807234f, -0.02620766f, 0.01984823f, 0.05076211f, -0.00779575f, -0.01328782f, 
    0.03507864f, -0.02092508f, 0.01441503f, -0.02829265f, -0.00661470f, 0.03534098f, -0.02882981f, 0.00774253f, 
    0.00602059f, 0.00250257f, 0.03537541f, 0.03638525f, -0.05542837f, 0.01012254f, -0.02059608f, -0.04635862f, 
    -0.00839806f, 0.04137426f, -0.00917839f, -0.04695838f, -0.03872716f, -0.00220961f, 0.00405879f, 0.01022273f, 
    0.00002979f, 0.00213162f, 0.01018445f, -0.04882567f, -0.00033252f, -0.04682545f, -0.03741615f, -0.01716229f, 
    -0.00607520f, -0.00306966f, -0.02762110f, 0.01986013f, -0.01359576f, 0.00659118f, 0.00046585f, 0.00312917f, 
    -0.02610973f, -0.03442750f, 0.04520158f, -0.03342383f, 0.03019795f, -0.01544171f, -0.04054084f, -0.00266031f, 
    0.02166734f, -0.02070470f, -0.01006044f, 0.01189494f, -0.00161987f, 0.01792640f, -0.05111692f, -0.01670238f, 
    -0.04443668f, -0.03244313f, -0.02760804f, -0.04421562f, 0.00709195f, -0.03277012f, -0.03633722f, 0.04416083f, 
    0.00306267f, 0.01072499f, -0.04442819f, -0.03711757f, 0.02484805f, -0.04197198f, -0.03745884f, -0.01942135f, 
    0.01788017f, -0.03471146f, 0.03961822f, -0.04099514f, -0.04139607f, -0.00443034f, -0.01893885f, -0.01377047f, 
    -0.05080133f, -0.01395009f, 0.00407340f, -0.04011745f, 0.02612930f, 0.02715417f, -0.04097172f, -0.00112376f, 
    0.02476878f, -0.03209301f, 0.00998335f, -0.01269791f, 0.03154880f, 0.00609075f, -0.04648738f, 0.00060936f, 
    0.01089640f, 0.04251538f, -0.01757087f, -0.04410455f, 0.01432977f, -0.03915749f, -0.04300591f, -0.01532501f, 
    0.01012799f, 0.00002055f, -0.04444883f, -0.05515114f, -0.00631426f, -0.05615669f, 0.02998766f, 0.01188687f, 
    0.02977918f, -0.05140607f, 0.01204312f, 0.03770874f, -0.00617253f, 0.03508427f, -0.01168464f, 0.00928848f, 
    -0.04399629f, -0.00850689f, 0.02799755f, 0.04181778f, 0.01907670f, -0.03593889f, -0.00978693f, 0.00000290f, 
    -0.03565344f, 0.01274732f, -0.04460081f, -0.01282241f, -0.04373632f, 0.02892168f, -0.01769485f, -0.02938990f, 
    0.00411398f, -0.01632302f, 0.04172255f, 0.03750530f, -0.00041389f, 0.03494012f, -0.01561309f, -0.04898492f, 
    -0.04554826f, -0.04906007f, 0.04078230f, 0.02057066f, -0.05149475f, 0.01877724f, 0.01236728f, -0.00157951f, 
    -0.04204404f, -0.04906749f, -0.02796821f, 0.03844764f, 0.02230591f, -0.01768910f, 0.02103962f, 0.03485075f, 
    -0.03869481f, 0.02641096f, -0.02136569f, -0.04001976f, -0.02486517f, 0.03488392f, -0.00870998f, 0.03882657f, 
    -0.00619271f, 0.02071578f, 0.00592205f, 0.02444432f, -0.05359504f, 0.01854189f, -0.00098711f, 0.00426468f, 
    -0.03647745f, 0.04577789f, -0.05558376f, -0.03628100f, -0.00753183f, -0.03511146f, -0.05187169f, -0.04934315f, 
    0.02596960f, -0.00103637f, -0.02225746f, 0.02484149f, -0.04222868f, 0.02078680f, -0.01994631f, 0.03676501f, 
    -0.01288407f, 0.00794561f, -0.04676892f, -0.04005117f, 0.01386929f, 0.01051644f, -0.03653855f, 0.03920272f, 
    -0.03559268f, -0.00554719f, -0.03012955f, -0.00522664f, 0.02560000f, 0.04042177f, 0.00167870f, 0.04136153f, 
    0.03089275f, -0.00640674f, -0.01220173f, 0.02744113f, -0.01311283f, 0.03425837f, 0.02156743f, 0.00378668f, 
    0.00441712f, -0.05148543f, -0.03443292f, -0.03948581f, -0.05434983f, -0.04329243f, 0.00090827f, -0.03566508f, 
    0.04010224f, 0.00239477f, -0.02347185f, -0.01809959f, -0.01203615f, -0.00136658f, -0.01437941f, -0.04057545f, 
    -0.04235353f, -0.00299956f, -0.00694757f, 0.03923611f, -0.00511023f, 0.01186244f, -0.03657094f, -0.04893625f, 
    -0.03194330f, -0.03748414f, 0.02542667f, -0.04177028f, 0.02965079f, -0.02694199f, -0.03110692f, -0.04190549f, 
    -0.01700597f, -0.04244225f, -0.04155736f, 0.04426926f, -0.02273135f, 0.03591387f, 0.00152746f, -0.00039855f, 
    -0.03901989f, 0.03900108f, -0.02264439f, -0.03830711f, 0.04352742f, -0.01270981f, -0.02091415f, -0.02405998f, 
    -0.03972465f, 0.03506549f, -0.05266224f, 0.01556506f, -0.00142370f, -0.02587305f, 0.00940156f, -0.00718105f, 
    0.01020637f, -0.00710814f, 0.02026998f, 0.04177252f, -0.04413670f, 0.00946634f, 0.02346266f, -0.04578598f, 
    -0.00690660f, -0.00805090f, 0.01672503f, -0.02016556f, -0.03036862f, -0.03392385f, -0.03137466f, -0.03075073f, 
    -0.00676584f, 0.04356823f, -0.01032275f, -0.03114405f, 0.01456636f, 0.03409062f, -0.00941149f, -0.05354336f, 
    0.02340091f, -0.04246804f, -0.00786943f, 0.01648472f, -0.00262095f, 0.00105326f, -0.03622421f, 0.04198518f, 
    0.03061360f, 0.02721865f, -0.01681611f, 0.03821062f, -0.01171032f, -0.03324337f, -0.03843794f, 0.03071945f, 
    0.01867227f, 0.04427572f, -0.00176419f, -0.01303284f, -0.03620336f, 0.02460333f, 0.00028478f, -0.03521050f, 
    -0.00032419f, -0.03223398f, -0.03583960f, -0.03599358f, -0.04351631f, 0.03649928f, -0.04686186f, 0.03094487f, 
    0.03276722f, 0.01416585f, 0.00118836f, -0.00747315f, -0.01612727f, 0.00817230f, -0.02015175f, 0.03530982f, 
    0.01987025f, -0.01824529f, 0.04849561f, 0.00748000f, -0.02461535f, -0.00962313f, -0.00309079f, -0.02398289f, 
    -0.02995302f, 0.03838348f, -0.00759096f, -0.02519582f, -0.04989441f, 0.03873022f, -0.00322130f, 0.01752442f, 
    0.02636535f, -0.04917563f, 0.01541145f, 0.00348746f, -0.04272796f, -0.00944892f, 0.03862971f, -0.00106680f, 
    -0.03600191f, -0.03951294f, 0.02657064f, -0.03947656f, 0.01611234f, -0.00523685f, -0.03603349f, 0.04426493f, 
    -0.01088316f, -0.00514618f, -0.00365967f, -0.05051188f, -0.00646837f, -0.00674834f, -0.05051905f, -0.01536925f, 
    0.03922984f, 0.04231858f, -0.02495909f, -0.01787310f, -0.01843838f, -0.03645540f, -0.03793967f, -0.04077939f, 
    -0.02790046f, 0.04123068f, 0.03983891f, 0.02272417f, 0.00742605f, -0.01453768f, 0.01438820f, -0.01525649f, 
    -0.03337236f, -0.02826067f, -0.02239920f, -0.02404048f, 0.04225969f, 0.02634620f, -0.03219993f, -0.01401912f, 
    -0.01502448f, -0.03499398f, -0.03322375f, 0.00458210f, -0.04016379f, -0.03624678f, -0.01460558f, 0.00412144f, 
    -0.01189798f, 0.02556027f, 0.02282166f, 0.02033981f, -0.01576378f, -0.02184422f, -0.05094094f, -0.00994332f, 
    0.03133481f, -0.01991920f, 0.02769302f, 0.00475963f, -0.01648234f, -0.01515451f, -0.03557011f, -0.05099430f, 
    0.02809177f, -0.05157903f, 0.01221182f, -0.01633790f, 0.04246331f, -0.04966787f, 0.01149596f, 0.01799083f, 
    0.01800326f, 0.01760161f, -0.01810307f, 0.01538281f, -0.04611452f, -0.03396552f, -0.04334622f, -0.00849543f, 
    -0.00938041f, -0.01067808f, -0.02457159f, -0.00060755f, -0.05590112f, -0.02745612f, 0.00942124f, -0.05612598f, 
    0.02259859f, -0.04689203f, 0.01456246f, -0.03160246f, 0.00598847f, -0.01919357f, -0.02927558f, -0.02461384f, 
    -0.03153016f, -0.04887388f, -0.05350543f, 0.03772049f, 0.01127689f, -0.04546726f, -0.03613359f, 0.03658652f, 
    -0.03916604f, 0.02225208f, 0.03223356f, 0.00522129f, 0.00268093f, -0.03690024f, -0.00960352f, -0.03197275f, 
    -0.00001757f, -0.00056536f, 0.02716991f, -0.03225894f, 0.01966533f, -0.03860868f, 0.03223428f, 0.02664505f, 
    0.00573805f, -0.05404121f, 0.01193531f, 0.01437524f, -0.00286180f, -0.01689781f, -0.01661133f, -0.04837343f, 
    -0.05571476f, 0.01382499f, -0.05536908f, -0.02270850f, 0.00310639f, -0.03794994f, 0.04057821f, 0.03849733f, 
    0.02259709f, -0.03793046f, -0.03420493f, -0.00176721f, -0.03922934f, -0.03961218f, -0.01869519f, 0.01454492f, 
    0.02861390f, -0.00339635f, 0.00616677f, -0.04590772f, 0.01871612f, 0.01967213f, -0.02747900f, -0.03553962f, 
    -0.00476592f, -0.00484293f, 0.03961165f, -0.04450503f, -0.04645737f, -0.03636111f, 0.02850658f, -0.03332078f, 
    0.02111083f, -0.05287922f, 0.01186375f, -0.00181370f, 0.02070520f, -0.04799308f, -0.04941623f, -0.01089036f, 
    -0.01190638f, 0.02545231f, 0.00533112f, -0.01248877f, 0.01091614f, -0.04042025f, -0.00566423f, 0.03573010f, 
    -0.04746584f, -0.01522689f, -0.04055265f, -0.05104487f, -0.02967672f, -0.02552110f, -0.04332253f, -0.03399187f, 
    0.01664220f, -0.04098577f, -0.00640192f, -0.02261459f, 0.04285682f, 0.03802708f, -0.03906253f, -0.02144117f, 
    -0.04996105f, 0.04569926f, -0.00225971f, 0.01388260f, 0.01879705f, 0.02956738f, 0.00673276f, 0.01623752f, 
    -0.01391847f, -0.01083778f, -0.04609553f, -0.02540866f, -0.04557690f, -0.01530988f, 0.04054757f, -0.03133791f, 
    -0.02350113f, -0.01501686f, 0.00222283f, -0.00343674f, -0.03019592f, -0.00222659f, 0.01157470f, 0.03169335f, 
    0.02755305f, 0.00081326f, 0.03698377f, 0.00026889f, 0.04962054f, -0.04538506f, -0.05045125f, -0.01516382f, 
    0.02760300f, -0.03599220f, -0.03424393f, 0.03925809f, 0.00926281f, -0.03155776f, 0.03341831f, -0.01783086f, 
    0.02358429f, -0.02019278f, 0.03159147f, -0.00386593f, -0.00475010f, 0.01462169f, 0.04413974f, 0.00618325f, 
    -0.01839712f, 0.04603189f, 0.04155522f, -0.02336260f, -0.03747310f, 0.01790513f, -0.01514186f, 0.01242370f, 
    -0.02910182f, -0.04776679f, 0.02765283f, 0.00006360f, -0.00685099f, -0.03846451f, -0.03708645f, -0.05035138f, 
    0.02283739f, -0.04887747f, -0.00327629f, -0.03862373f, 0.02463705f, -0.03723474f, -0.00493965f, -0.00373158f, 
    -0.02469173f, 0.01463534f, -0.01919822f, 0.02226784f, 0.01108793f, 0.00988706f, -0.00987643f, 0.03169855f, 
    -0.02922245f, 0.04483776f, 0.02836332f, -0.01476340f, -0.01032485f, -0.00529019f, 0.03865380f, 0.02770603f, 
    -0.00368253f, -0.00079438f, -0.03110863f, -0.01855441f, -0.04732283f, -0.05240561f, -0.04147410f, -0.03154053f, 
    -0.00080983f, -0.03027691f, 0.03693959f, -0.04584778f, 0.00687313f, -0.00967711f, 0.00714504f, -0.00269620f, 
    0.02678293f, 0.01403301f, -0.04960636f, 0.03050959f, 0.02592477f, 0.01183212f, -0.03165472f, 0.01557928f, 
    -0.04376689f, -0.02666346f, 0.00262449f, 0.02384326f, -0.01536436f, 0.01029808f, -0.05232037f, 0.00942518f, 
    0.52807951f, -0.16027634f, 0.10481960f, 0.17242521f, 0.06912327f, 0.03735492f, -0.09059168f, 0.18522780f, 
    -0.01116129f, -0.00221607f, 0.12165538f, 0.12221024f, -0.06596967f, 0.07179719f, -0.09635209f, 0.06563316f, 
    0.04215620f, -0.00369240f, -0.10484394f, -0.04059308f, -0.07489651f, 0.15113692f, -0.01242496f, 0.08143371f, 
    0.15408823f, -0.06343032f, 0.12772612f, -0.26249599f, 0.02170313f, 0.33059800f, -0.06945944f, 0.09770074f, 
    0.06460880f, 0.06513499f, -0.07278053f, 0.01058063f, -0.21884483f, -0.36527595f, -0.03642727f, -0.10710052f, 
    0.04385188f, 0.13538048f, 0.09992433f, 0.05404167f, -0.00142109f, -0.04761709f, -0.03974045f, -0.01120527f, 
    0.14690767f, 0.03889058f, -0.04733147f, 0.02580123f, 0.06159903f, 0.10349894f, -0.00435797f, -0.06681035f, 
    -0.11725138f, -0.06595912f, -0.12150453f, -0.16939573f, -0.32159886f, 0.10288971f, 0.19710004f, 0.19138891f, 
    -0.07299754f, -0.06175769f, -0.14231648f, -0.05421094f, -0.03065712f, 0.04979355f, 0.12679142f, 0.16912630f, 
    -0.01391291f, -0.00275893f, -0.23753729f, -0.12253989f, 0.04783791f, -0.03134388f, 0.14393677f, -0.22935538f, 
    0.09699917f, 0.03296518f, 0.05640441f, 0.05182165f, -0.09988054f, -0.00011734f, -0.45597115f, 0.03069193f, 
    0.07215106f, -0.11633784f, 0.14626323f, -0.27466333f, 0.07536475f, -0.00783673f, 0.07767586f, -0.03420549f, 
    0.05388799f, 0.00817258f, 0.21030124f, 0.18595454f, -0.04336541f, 0.08554880f, -0.11223174f, -0.03476945f, 
    -0.04537021f, 0.13362315f, 0.06662250f, 0.02021681f, 0.18827298f, -0.01978040f, -0.04392477f, 0.06159219f, 
    0.01221632f, 0.05820329f, 0.04836103f, -0.11972748f, -0.11073767f, -0.05917663f, -0.10626075f, -0.07256272f, 
    -0.13164201f, 0.02093510f, 0.28461629f, 0.09661508f, -0.08181512f, -0.12987202f, -0.18237755f, 0.10398222f, 
    0.00385241f, 0.06977844f, 0.00562550f, -0.05475513f, -0.05180980f, 0.08137071f, -0.14269635f, -0.00982789f, 
    0.17722267f, -0.04875351f, -0.06225482f, -0.02675816f, 0.07083909f, -0.09128170f, 0.06897762f, 0.10576630f, 
    -0.19488990f, -0.14945987f, 0.17193559f, 0.17555247f, 0.07085967f, 0.09319123f, -0.01643776f, 0.02206120f, 
    0.33442536f, -0.01909486f, 0.07246343f, 0.08358736f, -0.24983731f, 0.06668852f, 0.19031793f, 0.21366856f, 
    -0.13125411f, -0.06444451f, -0.08652066f, -0.00522287f, 0.24224977f, -0.04491490f, -0.04373103f, 0.08104882f, 
    0.21005994f, 0.13793890f, 0.09829252f, 0.18457477f, 0.07979876f, -0.07286843f, 0.07400786f, 0.40653172f, 
    0.05013543f, 0.07245146f, 0.00350051f, 0.07584853f, 0.06572300f, 0.00116101f, 0.00093842f, -0.20521791f, 
    0.11017496f, -0.13189128f, 0.03226440f, 0.11127533f, -0.18169387f, -0.09389353f, -0.03344208f, -0.03070501f, 
    0.12854162f, -0.06771752f, -0.01362160f, 0.14052498f, -0.10244470f, -0.00286217f, -0.06740587f, -0.03729253f, 
    -0.01972641f, -0.01626861f, -0.03891418f, -0.03421289f, 0.22101961f, -0.11161492f, 0.06207101f, -0.16997759f, 
    -0.04839589f, -0.01445134f, -0.07268992f, 0.15130639f, -0.08129462f, -0.10298833f, -0.06649026f, 0.05349181f, 
    -0.21087758f, -0.20354141f, -0.01676840f, -0.12093290f, -0.14835541f, -0.01274919f, -0.07580565f, -0.05076480f, 
    0.00916342f, -0.06043650f, -0.06748162f, -0.00637475f, -0.29855973f, -0.12906396f, -0.06974007f, -0.19613130f, 
    0.04936949f, -0.10896749f, -0.01721785f, 0.21687542f, 0.11720447f, -0.03842730f, 0.03060653f, -0.21023187f, 
    -0.10254332f, 0.00796669f, -0.07366016f, -0.10464884f, 0.13855349f, 0.00201388f, 0.01937168f, 0.07656834f, 
    0.04112135f, 0.13023666f, 0.02512243f, 0.02780162f, 0.23117073f, 0.15383291f, 0.01908284f, -0.23742887f, 
    0.02878838f, 0.06178051f, 0.03209905f, 0.08093227f, -0.10206567f, 0.00698065f, 0.02925207f, 0.02187578f, 
    -0.21663900f, -0.02130340f, 0.05330038f, -0.11520306f, -0.08232237f, -0.04758312f, -0.10589432f, -0.04090559f, 
    -0.01566090f, 0.13047974f, 0.05198117f, 0.06497070f, -0.09983037f, -0.21456034f, 0.00554719f, 0.13028230f, 
    -0.26452485f, -0.07219265f, 0.07382362f, -0.02864349f, 0.00090663f, -0.02776450f, 0.07893778f, 0.00150811f, 
    -0.04700020f, 0.20564343f, -0.10809392f, 0.10177141f, -0.03329019f, -0.03610392f, 0.02993802f, -0.10288253f, 
    -0.06372458f, 0.02643156f, -0.11117776f, -0.00913747f, 0.02954257f, 0.16388592f, 0.00644804f, 0.06718607f, 
    -0.05026335f, -0.05234183f, 0.03896581f, -0.05505976f, 0.11525036f, 0.01843458f, 0.00385892f, 0.10275455f, 
    -0.01051824f, 0.11414575f, 0.03471000f, -0.07080729f, -0.05399952f, -0.03349416f, -0.14433034f, -0.03405126f, 
    -0.07424653f, -0.05559701f, -0.14414693f, 0.13405597f, 0.03739746f, 0.09305730f, -0.12056344f, -0.00883714f, 
    0.00213889f, -0.03440734f, -0.00456698f, -0.10561064f, -0.08275834f, 0.15777211f, -0.09201776f, -0.03229209f, 
    -0.03094795f, -0.15897401f, 0.11354765f, -0.30109900f, 0.04169308f, -0.03774256f, -0.11210585f, -0.03029470f, 
    -0.02056613f, -0.03211477f, -0.06939832f, -0.09384152f, -0.01412360f, -0.01631614f, -0.23446910f, 0.01232789f, 
    0.00163481f, -0.04368196f, 0.07672265f, -0.13625406f, -0.13905206f, 0.10771983f, -0.04183306f, -0.05674308f, 
    0.23241046f, 0.08091469f, 0.28583696f, 0.26249126f, 0.05618737f, 0.03476584f, 0.03242404f, 0.11799845f, 
    0.01780995f, 0.01573814f, 0.05386135f, 0.05369753f, -0.01154700f, 0.16605870f, -0.03126474f, 0.30494213f, 
    -0.14930351f, -0.07816063f, 0.15077582f, 0.13216512f, 0.13448964f, 0.13801493f, 0.07083630f, 0.13269882f, 
    -0.19952878f, -0.48069105f, 0.29282969f, -0.46652469f, -0.09637309f, 0.11320172f, -0.10201208f, 0.27265823f, 
    -0.21024136f, -0.01166152f, -0.01953512f, -0.01615414f, -0.11973864f, -0.00112138f, 0.07330684f, -0.23287290f, 
    -0.06855895f, -0.08347235f, 0.02845596f, -0.15811002f, -0.21963979f, 0.00372682f, -0.11726789f, 0.04057391f, 
    -0.16941558f, 0.29478559f, 0.05066497f, -0.05369125f, 0.13200039f, 0.03580113f, 0.17766948f, 0.22234155f, 
    0.20905015f, 0.07831230f, 0.12038902f, 0.15670654f, 0.31146604f, -0.27404171f, 0.55085242f, 0.29364952f, 
    0.14288045f, 0.11744382f, -0.04000587f, -0.08508099f, 0.10194185f, 0.01615694f, 0.11634158f, 0.13375904f, 
    0.00901842f, -0.14441790f, -0.15183257f, -0.15473576f, 0.28881171f, 0.07655328f, 0.07488466f, 0.29287294f, 
    0.03807879f, -0.05879734f, -0.02585678f, 0.05409046f, 0.21497433f, 0.22809866f, 0.00127202f, -0.01240952f, 
    -0.07987264f, 0.06853691f, -0.14878713f, 0.01366803f, 0.11470383f, -0.01939552f, 0.04642557f, -0.07927999f, 
    -0.32591456f, 0.04951843f, -0.20574574f, 0.05918436f, -0.00709946f, -0.11120731f, 0.07861153f, 0.25903088f, 
    0.23210819f, 0.04640687f, 0.01552036f, 0.11981817f, -0.30599937f, -0.37183976f, 0.07798706f, 0.11647701f, 
    -0.17755093f, 0.03063273f, -0.00494685f, -0.00073650f, 0.11759648f, -0.09793643f, -0.03484126f, 0.24712767f, 
    0.10658094f, 0.06050729f, 0.12207779f, -0.00804693f, 0.03350213f, 0.18824659f, 0.00937703f, -0.25106236f, 
    0.14269803f, -0.10982428f, 0.05156607f, -0.15727621f, 0.20576389f, -0.01357319f, 0.04159208f, 0.05802878f, 
    0.10048851f, 0.03383001f, 0.08405285f, 0.31595328f, -0.11052309f, 0.00410224f, 0.01449452f, -0.16105695f, 
    0.13115621f, 0.18629399f, 0.13836978f, 0.03038765f, -0.06605621f, -0.18102722f, 0.15498482f, 0.01870767f, 
    0.08367822f, -0.03591598f, -0.01497146f, 0.12508494f, 0.13058618f, -0.08861948f, 0.11046485f, -0.25344503f, 
    0.08833057f, -0.02063434f, -0.17424566f, -0.15515377f, -0.08532538f, 0.02281133f, -0.29281446f, -0.00394449f, 
    0.12962438f, -0.03770573f, -0.09728355f, -0.08577462f, 0.05395137f, -0.02257286f, -0.25349757f, 0.15810983f, 
    -0.26323807f, 0.16571648f, -0.19398724f, -0.15986477f, 0.15555841f, -0.04226988f, 0.02003690f, 0.01899411f, 
    0.05763202f, 0.05879579f, -0.17208396f, -0.11978421f, 0.00109145f, -0.02946603f, -0.00137290f, -0.07691392f, 
    0.13224067f, -0.08094310f, 0.36236918f, 0.47379535f, -0.07723780f, -0.05070718f, -0.06599803f, 0.11353035f, 
    0.01887730f, 0.06878381f, 0.14469765f, -0.00717442f, -0.13738193f, 0.29382029f, -0.21760911f, 0.19156118f, 
    0.00845266f, 0.04954714f, 0.02824257f, -0.25803229f, 0.25252816f, -0.09966984f, -0.03127700f, 0.21644785f, 
    -0.08576028f, -0.03015229f, 0.10573149f, 0.03982629f, 0.10469396f, 0.03441463f, -0.09258441f, -0.10240084f, 
    -0.03025171f, -0.17642635f, -0.30581808f, -0.12480079f, -0.33801126f, -0.26265940f, 0.00499505f, -0.08026104f, 
    0.15184055f, -0.20008594f, 0.12967181f, 0.08999442f, 0.02102135f, 0.01522907f, 0.13937289f, 0.18456140f, 
    -0.18426605f, -0.16103160f, -0.08461429f, -0.01032871f, -0.00505578f, -0.06291062f, 0.20090435f, 0.01230565f, 
    0.17696825f, 0.04028143f, 0.04891731f, 0.02134447f, -0.02205111f, 0.06228228f, -0.14663708f, -0.15913267f, 
    -0.09085033f, -0.03717061f, 0.14697672f, 0.13988714f, -0.08569573f, -0.07047380f, 0.03864440f, 0.09382165f, 
    0.05302087f, 0.25082240f, -0.06606846f, 0.13059804f, -0.08852520f, 0.09440821f, 0.00021440f, -0.11639569f, 
    -0.12434956f, -0.25168839f, -0.21847092f, -0.08196274f, -0.47807351f, 0.48632249f, -0.12454832f, 0.22474985f, 
    0.08545481f, 0.13350479f, -0.00032800f, -0.18190713f, 0.04346748f, 0.01847814f, 0.02417926f, -0.08279072f, 
    0.10409509f, 0.24562682f, -0.27743161f, 0.06791111f, -0.00568262f, 0.05796390f, -0.09499621f, -0.06247956f, 
    -0.00600795f, -0.02028979f, 0.13383420f, -0.01824495f, 0.13113159f, -0.03228304f, 0.28302127f, 0.18604960f, 
    0.03470156f, 0.05606335f, -0.03072841f, 0.08717202f, -0.00390449f, -0.12070117f, -0.02063831f, -0.18609430f, 
    0.08033577f, -0.25255707f, 0.06633765f, 0.05699162f, 0.03590225f, 0.01722430f, 0.01830549f, -0.29040092f, 
    0.12517858f, 0.06360324f, 0.22383471f, 0.24036425f, -0.14493702f, -0.22473675f, 0.00151639f, 0.25263470f, 
    0.02054098f, -0.11314071f, -0.01921705f, -0.06441595f, -0.03877701f, 0.03163744f, 0.19586112f, -0.15644257f, 
    -0.03340526f, -0.12570675f, -0.27782500f, 0.05588543f, 0.00182128f, -0.06761435f, 0.01574117f, 0.09456650f, 
    0.09797698f, 0.15856260f, -0.00590490f, 0.19350271f, -0.26477382f, -0.03119527f, -0.12100136f, -0.18615445f, 
    0.20726889f, 0.18039073f, 0.10321753f, -0.02396920f, 0.08747532f, -0.13722110f, 0.03481690f, 0.04005099f, 
    0.18079986f, -0.12316324f, 0.14118432f, 0.02981371f, 0.16689757f, -0.22043696f, -0.07258838f, 0.06939132f, 
    0.16836795f, -0.03027422f, 0.11191162f, 0.08676219f, 0.03631528f, -0.18917936f, -0.20854190f, 0.01672217f, 
    0.04912780f, 0.12095828f, -0.17391112f, 0.01135139f, 0.06410892f, -0.02664516f, -0.01881775f, -0.02249955f, 
    0.06592832f, 0.51412529f, 0.15031381f, 0.62640500f, 0.01436879f, -0.10703067f, 0.04327386f, -0.05967708f, 
    0.02679724f, -0.11406181f, 0.09431889f, -0.10892577f, 0.10567327f, 0.22288117f, 0.22293548f, -0.05315460f, 
    -0.09870034f, 0.08647977f, -0.04100756f, 0.16741173f, 0.18754283f, -0.06302054f, -0.01364334f, -0.00070606f, 
    0.02085228f, 0.29766637f, 0.00551217f, 0.02171139f, -0.14725325f, 0.16182940f, -0.11319463f, 0.20605958f, 
    -0.02157195f, -0.07120118f, -0.06860650f, -0.21943258f, -0.10485328f, -0.00437699f, -0.13224441f, -0.12049041f, 
    0.12210215f, -0.03455083f, -0.05234871f, 0.01673423f, 0.18651007f, 0.13296847f, -0.07136843f, 0.02724108f, 
    0.24109514f, 0.35678887f, 0.06001820f, -0.17868888f, 0.01288813f, 0.06089795f, 0.03949833f, 0.12685718f, 
    0.05883668f, -0.08060064f, 0.12549727f, -0.06484753f, -0.36221623f, 0.01651072f, 0.30312392f, 0.20028286f, 
    -0.17152818f, -0.00267377f, -0.04553882f, 0.00953199f, 0.01014768f, -0.04283777f, -0.02346677f, -0.01405520f, 
    -0.30968407f, -0.32705608f, -0.12669942f, -0.12881958f, -0.23519798f, -0.09155552f, -0.07525222f, 0.02824862f, 
    0.10059778f, -0.01866865f, 0.11130642f, 0.04802203f, -0.03297186f, 0.00588877f, 0.04690193f, 0.10693339f, 
    0.02004025f, 0.20313486f, 0.07859994f, 0.12732950f, 0.22505061f, -0.06967386f, 0.18878201f, 0.20743494f, 
    0.04607794f, 0.19709407f, 0.16878602f, 0.08213090f, -0.00683297f, -0.07290024f, 0.06494170f, 0.04032207f, 
    0.06649673f, 0.10761577f, 0.03289049f, -0.07233585f, -0.26925036f, -0.23013294f, 0.02651223f, 0.21774526f, 
    0.01690914f, 0.04060297f, -0.00014455f, -0.06928920f, -0.13156858f, 0.00982217f, -0.03356627f, 0.07103411f, 
    0.43848518f, 0.39656743f, 0.22604781f, 0.09288485f, -0.10949519f, -0.10413814f, 0.06499746f, 0.11217124f, 
    0.11375968f, 0.11680696f, -0.08044317f, -0.04150293f, 0.35555601f, 0.01935711f, -0.35004407f, 0.00049030f, 
    -0.17479910f, -0.17472997f, 0.00050864f, 0.00112092f, 0.08667253f, -0.02510952f, -0.01010955f, -0.02502124f, 
    0.44032472f, 0.25525630f, 0.36088192f, 0.35309088f, 0.12781692f, -0.07164453f, 0.09889463f, -0.04907994f, 
    0.13575636f, 0.01473571f, 0.01521306f, 0.17166753f, -0.16486329f, 0.20275581f, 0.05665310f, 0.05981479f, 
    0.11713652f, 0.15140592f, 0.00841195f, -0.11721524f, -0.05373651f, 0.14579608f, 0.05816466f, -0.15367815f, 
    0.09852876f, 0.03870513f, -0.09688317f, -0.08467234f, 0.14074273f, -0.11631233f, -0.07628367f, 0.26471829f, 
    -0.04722976f, 0.16049980f, 0.14339873f, 0.05968342f, -0.36080119f, -0.05777478f, 0.24513696f, 0.07886759f, 
    0.06763171f, 0.04273348f, -0.01921465f, 0.06493099f, -0.01050204f, -0.12720527f, -0.14380804f, -0.04308173f, 
    -0.17036183f, 0.18120828f, 0.20391762f, 0.36636418f, -0.04094796f, 0.02512154f, 0.06629670f, 0.02799102f, 
    -0.09166809f, 0.05293390f, 0.03102016f, 0.02794015f, 0.14703408f, 0.06280690f, -0.05174689f, 0.12861767f, 
    0.09197833f, -0.05104765f, -0.08831528f, -0.07015076f, -0.00460633f, -0.23968035f, -0.16942264f, 0.18274958f, 
    0.02737661f, -0.21994473f, -0.20114267f, 0.11159369f, -0.05068708f, -0.01576147f, -0.01723524f, 0.01000576f, 
    0.12760039f, -0.07562429f, -0.06024948f, -0.06983974f, 0.06002968f, 0.16349268f, 0.00293826f, 0.08876751f, 
    0.01077722f, 0.03004656f, -0.04543179f, 0.01721712f, -0.00648004f, -0.22294454f, -0.12990288f, -0.09659603f, 
    0.02455945f, -0.26943535f, -0.11345445f, -0.21436663f, 0.04183320f, -0.08561762f, -0.05816168f, 0.07242202f, 
    0.08686030f, -0.20045370f, -0.04056809f, 0.02568661f, 0.38783076f, 0.11314578f, 0.10100076f, -0.12455720f, 
    0.11435510f, 0.08796114f, 0.19217403f, 0.09685907f, -0.09757774f, 0.15880351f, -0.00515614f, 0.18849491f, 
    -0.00886941f, 0.19523647f, 0.18026650f, 0.06553729f, -0.17280442f, 0.16116023f, 0.10703050f, 0.01097136f, 
    0.04826138f, 0.13807540f, 0.16405992f, -0.03927180f, 0.02955584f, -0.39386410f, -0.05485712f, 0.07284438f, 
    -0.06290250f, -0.05004342f, 0.08235650f, 0.08794713f, 0.08902433f, -0.06356458f, 0.05187280f, -0.04714868f, 
    0.03098251f, -0.13087696f, -0.22511345f, 0.02725781f, 0.12458139f, 0.07135382f, 0.05950756f, 0.06758284f, 
    -0.01684466f, -0.09274358f, 0.16998854f, 0.09661603f, -0.14127485f, 0.12503174f, 0.50792313f, 0.24758136f, 
    -0.01984998f, 0.24607207f, 0.13522433f, 0.24889335f, -0.00131463f, 0.07924002f, -0.06508893f, -0.04095123f, 
    -0.49464741f, -0.21650325f, 0.03550704f, 0.02525961f, -0.14155622f, -0.18916345f, -0.16257015f, -0.16058597f, 
    0.05402650f, -0.08532543f, 0.02006578f, 0.35005751f, -0.76447213f, -0.27696949f, 0.21446177f, 0.22037160f, 
    -0.29239044f, -0.01900081f, -0.03213365f, -0.13938639f, -0.08232144f, -0.02702871f, 0.00837704f, 0.12208162f, 
    -0.29171604f, -0.32174528f, -0.32190114f, -0.06916557f, -0.05780067f, -0.04691732f, -0.03914627f, -0.07229643f, 
    0.07014097f, 0.07102104f, -0.25777397f, -0.05119408f, -0.12230044f, -0.36637121f, -0.21933432f, -0.08721981f, 
    -0.06213651f, -0.05625680f, -0.09817422f, -0.03702531f, 0.12306203f, -0.04448921f, 0.10829059f, 0.06697816f, 
    0.09715325f, 0.16065694f, 0.10170755f, 0.20798302f, 0.14966927f, -0.07298767f, 0.05595276f, -0.11112037f, 
    0.09106867f, 0.01932186f, -0.22949517f, -0.21926945f, -0.19637653f, -0.05638465f, -0.06811291f, -0.00260884f, 
    -0.04445441f, -0.04660650f, -0.07577191f, 0.00528817f, 0.07972687f, 0.05497533f, 0.06789421f, 0.20649058f, 
    0.31571329f, 0.32126030f, 0.17007250f, 0.19076623f, 0.00452594f, -0.10803260f, 0.17364988f, -0.12210750f, 
    -0.11327982f, -0.02030258f, 0.11154840f, 0.13530253f, 0.02802857f, 0.30546796f, 0.29077277f, 0.33923447f, 
    0.02379302f, 0.15960820f, 0.11856552f, 0.07168747f, 0.19333521f, 0.01877289f, 0.02967120f, -0.01857147f, 
    0.49087012f, 0.01209508f, -0.00576867f, -0.00525501f, 0.07715251f, -0.14636622f, 0.28769308f, -0.09849111f, 
    0.10240111f, 0.20906171f, 0.10848268f, 0.07473756f, 0.34420130f, -0.09558221f, 0.12325917f, -0.01073849f, 
    0.00406463f, 0.16285348f, -0.10375992f, 0.16759187f, 0.21360841f, 0.12298093f, 0.08982659f, -0.03179629f, 
    0.13644448f, 0.01754212f, 0.03054069f, 0.02219637f, 0.17228079f, -0.14060041f, 0.04536824f, -0.05608483f, 
    -0.15005496f, -0.05644820f, 0.00485402f, 0.04254251f, 0.18895060f, -0.23475853f, -0.14407067f, -0.51584762f, 
    0.02424251f, 0.02781760f, -0.06823554f, 0.10749314f, -0.03136357f, 0.00811859f, -0.10457093f, -0.09323440f, 
    -0.08563595f, 0.07232980f, -0.01886798f, 0.03647836f, -0.08361747f, -0.12229410f, -0.04196119f, -0.22185619f, 
    -0.11988221f, 0.03709643f, -0.03917079f, -0.03246441f, -0.05203220f, 0.02411901f, 0.06186339f, 0.15521282f, 
    -0.13198850f, -0.16189818f, 0.07009359f, -0.20287754f, 0.04882970f, 0.14130870f, 0.03134725f, 0.11751378f, 
    0.27691925f, 0.09612292f, 0.17176940f, -0.23194034f, 0.09482524f, 0.07140406f, -0.04496775f, 0.21888532f, 
    0.11607903f, 0.07868502f, -0.01500450f, -0.05699906f, 0.13393456f, 0.19899987f, 0.05990520f, -0.13127303f, 
    -0.00154953f, -0.07835186f, -0.08945359f, 0.17735150f, 0.10638885f, 0.01238133f, 0.02334286f, -0.11953621f, 
    -0.12347480f, -0.03322104f, 0.11855303f, -0.20558482f, 0.07402053f, 0.02474721f, 0.15024145f, 0.33559257f, 
    -0.07751827f, -0.00446262f, 0.00737122f, 0.10449496f, 0.06034380f, 0.21108906f, -0.05160095f, -0.12294237f, 
    -0.04085565f, -0.13663532f, -0.06823821f, -0.16036876f, -0.01463089f, -0.05888062f, 0.01093713f, 0.05457062f, 
    -0.19495860f, 0.09523270f, 0.12552716f, -0.01562547f, 0.04478798f, 0.17547043f, -0.04422879f, 0.13580319f, 
    0.00861415f, -0.04483202f, 0.10577387f, 0.00527018f, 0.01067726f, -0.17621091f, -0.03690017f, -0.11943205f, 
    -0.11451588f, 0.12274962f, 0.19211176f, 0.20046851f, 0.15318528f, 0.05356960f, 0.19445577f, 0.11519911f, 
    0.07365858f, -0.31314445f, 0.35451657f, 0.17115837f, -0.11735950f, 0.16545491f, 0.16037215f, -0.11525363f, 
    0.38035074f, 0.03315628f, 0.15744543f, 0.22989979f, 0.09088110f, -0.12283571f, 0.14484268f, 0.31309101f, 
    -0.22136845f, -0.09004872f, 0.03222086f, 0.04067595f, 0.19059233f, 0.22672361f, -0.02086944f, -0.03703491f, 
    0.09295408f, 0.17101891f, -0.18083274f, -0.23201898f, 0.08461445f, 0.03838479f, 0.21574388f, 0.00342798f, 
    0.08343925f, -0.03258121f, -0.23597020f, 0.02767651f, -0.25978181f, 0.11781964f, -0.07165084f, -0.02970099f, 
    -0.05870394f, 0.04048884f, 0.03042317f, 0.20637925f, -0.09186985f, 0.09963034f, -0.02781217f, -0.26628965f, 
    0.22173147f, 0.11311876f, 0.03793069f, -0.05970291f, -0.11413208f, -0.07677174f, -0.03681719f, 0.01520833f, 
    -0.01554268f, 0.13591391f, 0.04047344f, 0.06832816f, 0.44399458f, -0.13332914f, 0.13660292f, 0.02053495f, 
    -0.15855287f, -0.13681503f, -0.16130942f, -0.06832132f, 0.11857210f, 0.12594688f, -0.06282903f, -0.10304098f, 
    0.13835894f, 0.08952931f, 0.15074080f, 0.03304866f, -0.18209743f, 0.00053705f, -0.21072051f, -0.19159579f, 
    0.02390426f, -0.24024823f, 0.04534316f, -0.10813411f, -0.52917415f, 0.02458950f, -0.04829815f, 0.01919919f, 
    0.03489938f, 0.12621310f, 0.10217930f, 0.02495775f, 0.06809019f, 0.03683860f, -0.04990565f, -0.15625300f, 
    -0.13461399f, -0.18231851f, 0.12665883f, -0.12599830f, 0.10681984f, 0.11563655f, 0.08130868f, -0.05266488f, 
    0.01634565f, -0.03033598f, 0.10395833f, 0.06635325f, 0.20155826f, -0.06572288f, -0.03918044f, -0.05644434f, 
    -0.14805950f, -0.20830920f, 0.10072740f, -0.03771728f, 0.06277041f, 0.08879206f, -0.05868072f, 0.03351983f, 
    0.06365081f, -0.07960841f, 0.05894399f, -0.08169723f, -0.14272644f, -0.18948179f, -0.07051147f, -0.11393593f, 
    0.15200253f, 0.11910199f, 0.03377688f, 0.15797907f, -0.13761891f, 0.00147638f, -0.03134621f, 0.02697144f, 
    0.00582057f, -0.06347769f, -0.03984662f, 0.06933352f, 0.02684544f, 0.01076529f, 0.01364900f, 0.11436028f, 
    0.13454664f, 0.02357845f, 0.08675648f, -0.02136753f, -0.03665273f, -0.04700360f, 0.02748194f, 0.01495561f, 
    -0.00040307f, -0.07243795f, -0.02834531f, -0.29184243f, 0.02070880f, 0.12219371f, 0.03294573f, -0.13468567f, 
    -0.03744416f, -0.04984311f, -0.11553388f, -0.12920924f, 0.15543135f, 0.00609975f, -0.13445742f, 0.03555922f, 
    0.15514638f, 0.05573663f, 0.27599630f, 0.02063764f, -0.11595415f, -0.04589943f, -0.01746681f, -0.25030586f, 
    0.07738335f, -0.06307518f, -0.13871984f, -0.14701505f, 0.18852279f, 0.07995707f, 0.00196218f, 0.04016189f, 
    0.06382715f, -0.11108574f, 0.01253324f, 0.01064972f, 0.03185825f, 0.04338215f, 0.07555479f, 0.08269102f, 
    -0.09777752f, 0.03272323f, -0.32076350f, -0.25081095f, -0.08179166f, 0.11151441f, 0.00538748f, 0.02349505f, 
    0.05991384f, 0.05797578f, 0.14448431f, 0.04072276f, -0.09610584f, 0.04376556f, 0.08854395f, -0.03810435f, 
    0.04004473f, -0.04827632f, 0.11604232f, -0.06059728f, 0.05208869f, 0.03188078f, 0.04578480f, -0.03116196f, 
    -0.09743878f, -0.04490733f, -0.11951287f, -0.22866189f, -0.13385773f, -0.11950592f, 0.06359437f, 0.24850000f, 
    0.00273381f, -0.00527734f, -0.10284068f, 0.05358345f, -0.12645344f, -0.02169590f, 0.18436773f, 0.03273160f, 
    -0.09062854f, -0.09715106f, 0.20784886f, 0.12725776f, -0.11039196f, 0.08625230f, 0.07302735f, 0.06208744f, 
    0.00957021f, -0.05636815f, -0.00428370f, -0.00607065f, -0.00833220f, -0.00515478f, 0.03175216f, -0.03198548f, 
    -0.00559888f, -0.04540351f, 0.02355476f, -0.03925505f, 0.03226936f, 0.04604222f, -0.04799338f, -0.01173398f, 
    0.02255514f, 0.03438931f, -0.04446746f, -0.01173499f, -0.03822158f, 0.01752051f, -0.04945214f, -0.00480995f, 
    0.02634926f, -0.05450192f, 0.03929274f, -0.00988532f, 0.01296960f, -0.00451245f, 0.01598394f, -0.01952312f, 
    -0.02786747f, 0.00913858f, -0.05530566f, -0.01188728f, 0.01152086f, -0.04684006f, -0.00439155f, 0.01747785f, 
    0.02420758f, 0.01744274f, 0.00714514f, -0.02337337f, -0.03266926f, -0.04573280f, -0.01577276f, -0.04730755f, 
    -0.04877613f, -0.01317813f, 0.04251201f, 0.03624038f, 0.00683701f, 0.05075618f, -0.02171971f, -0.03591604f, 
    -0.02189283f, -0.02708502f, 0.02255441f, 0.03122365f, 0.00252557f, 0.01466226f, -0.01643303f, -0.04070880f, 
    -0.00565318f, -0.01943439f, -0.03008854f, -0.04096809f, -0.02611114f, 0.01950672f, -0.00891399f, 0.03638289f, 
    -0.03229402f, 0.00641953f, -0.04461819f, 0.01294556f, 0.00551414f, -0.00855870f, -0.01676175f, 0.00604739f, 
    -0.03658011f, 0.03257342f, -0.00411257f, -0.00621706f, -0.04642065f, 0.03385075f, 0.03318571f, -0.04072368f, 
    0.03730033f, -0.04576670f, 0.01927973f, -0.04825338f, -0.00808312f, -0.03694336f, 0.02356774f, 0.03330148f, 
    -0.01254073f, -0.04816841f, 0.00883482f, -0.00408938f, -0.00600637f, -0.03039189f, -0.00793588f, 0.02887909f, 
    -0.04124121f, 0.03395768f, 0.02626494f, 0.02515824f, -0.04622098f, -0.02901984f, -0.00765611f, 0.01197910f, 
    0.03105510f, -0.02197192f, 0.02574843f, 0.04075150f, 0.02707918f, 0.04517817f, -0.03208994f, -0.05394194f, 
    0.02621884f, -0.04255923f, -0.05531849f, -0.00084304f, 0.00168895f, 0.01130915f, 0.01150680f, 0.01532079f, 
    -0.02611577f, 0.01617041f, -0.03437507f, -0.02331954f, 0.01147014f, 0.03945855f, -0.02401632f, 0.03949913f, 
    -0.00578283f, 0.03112973f, -0.03683531f, 0.00862718f, -0.02547876f, -0.02826546f, -0.00162103f, 0.03800013f, 
    -0.04302154f, 0.00967622f, 0.05072621f, -0.04405349f, -0.01128151f, 0.00396764f, 0.01128400f, -0.00207872f, 
    -0.03109000f, -0.02627025f, 0.00815168f, -0.01362895f, 0.02627794f, -0.05046170f, -0.00245739f, -0.05669445f, 
    -0.03600923f, -0.04594652f, -0.05166906f, -0.02743993f, -0.02494754f, 0.01321135f, -0.01624056f, -0.04023484f, 
    0.02219488f, -0.05036139f, 0.00972869f, 0.04309083f, -0.01345041f, -0.00430206f, 0.00994740f, -0.00981516f, 
    -0.02950566f, -0.02865461f, 0.00387366f, -0.03162385f, -0.03743745f, -0.03340042f, -0.05168581f, 0.02780195f, 
    0.02695744f, 0.01796992f, -0.05129083f, 0.00441991f, 0.02431615f, -0.04637104f, 0.04251746f, 0.00504982f, 
    -0.01563582f, 0.04070315f, 0.00796743f, -0.00811178f, 0.00166632f, -0.03828168f, 0.02992086f, 0.02313485f, 
    -0.05039074f, -0.02618120f, -0.03831155f, -0.04378608f, -0.01107022f, -0.03695979f, 0.01597692f, 0.00964242f, 
    -0.00052486f, -0.04751442f, 0.01937866f, -0.02468874f, 0.01526985f, 0.01548947f, -0.04956150f, -0.05354582f, 
    0.05092014f, 0.04851180f, -0.00375598f, 0.01561130f, 0.00488946f, 0.01526751f, -0.00970248f, 0.01017436f, 
    -0.04247617f, -0.03213969f, 0.00479390f, 0.02902401f, 0.04405615f, 0.00392890f, -0.02983124f, -0.00938421f, 
    0.03596132f, 0.04006762f, -0.00345216f, 0.02181984f, -0.00565915f, -0.00584779f, -0.01598880f, -0.04150113f, 
    0.01899729f, 0.02148588f, -0.04386039f, 0.00079457f, -0.01401390f, -0.03357813f, 0.01825611f, 0.01124213f, 
    0.00071217f, -0.03833504f, 0.03271330f, 0.00164366f, 0.03323060f, -0.02225819f, 0.01393832f, 0.03353186f, 
    -0.00269065f, 0.03902163f, -0.05560033f, -0.00552249f, -0.03215886f, -0.01950870f, 0.02358963f, 0.03592958f, 
    -0.03333980f, -0.05554000f, -0.03436223f, -0.01820687f, 0.01845549f, -0.04450581f, -0.02225387f, -0.04441982f, 
    -0.04930717f, -0.04561653f, 0.00567382f, 0.01912468f, 0.04147152f, -0.02096098f, -0.02374794f, -0.03207218f, 
    -0.02784458f, 0.01573102f, 0.00446609f, -0.00767875f, -0.05391464f, -0.05168036f, -0.04259254f, 0.00470021f, 
    0.01213816f, 0.01350188f, -0.01205826f, -0.01749515f, -0.04923173f, 0.03072689f, -0.02741146f, -0.04626371f, 
    0.00590469f, 0.02978461f, -0.02672900f, -0.03269145f, -0.04629373f, -0.01267561f, -0.02220271f, 0.01453280f, 
    0.04949410f, 0.01630845f, -0.01718690f, 0.02951957f, -0.04062404f, -0.01831813f, 0.04449408f, 0.04493853f, 
    -0.04403355f, -0.04568027f, -0.04950026f, 0.00468397f, 0.01229130f, -0.04279585f, -0.00446225f, 0.00212499f, 
    0.03417535f, 0.00153000f, -0.00451845f, 0.01272407f, 0.04743660f, -0.02311591f, 0.01141970f, -0.03975527f, 
    0.01618348f, 0.04465207f, -0.01458897f, -0.00400784f, 0.04312428f, -0.04746193f, 0.01693811f, 0.01750979f, 
    0.04086377f, 0.01357759f, -0.05544726f, 0.00379298f, -0.05264913f, -0.03675932f, -0.01619812f, -0.03823752f, 
    0.01245556f, -0.00447162f, 0.04162739f, 0.00673375f, 0.02642237f, 0.00742633f, -0.01781621f, 0.00793866f, 
    -0.01633562f, -0.01178505f, -0.02224444f, 0.03744427f, -0.02058521f, -0.05525252f, 0.01049951f, -0.04116891f, 
    -0.05536941f, 0.04004056f, 0.00799796f, -0.00626808f, 0.03654127f, -0.04333911f, -0.01236677f, -0.04880057f, 
    -0.01017666f, -0.00860167f, -0.01269154f, -0.00555231f, -0.01198842f, -0.01444262f, -0.01917911f, 0.02471786f, 
    0.01334212f, -0.02930280f, 0.01001609f, -0.03788862f, -0.02830139f, -0.00560980f, -0.02215283f, 0.00220119f, 
    0.27340189f, 0.15495530f, -0.13601846f, 0.19538572f, 0.10208168f, 0.19995905f, -0.03564934f, 0.14182638f, 
    0.09397984f, -0.10132889f, 0.01456570f, -0.16073281f, -0.03590401f, 0.05533037f, -0.16860616f, 0.13439770f, 
    0.07372554f, 0.09223597f, 0.02252676f, -0.02858154f, 0.01741104f, -0.13693289f, -0.03459464f, -0.09454191f, 
    0.12866950f, 0.01904798f, 0.08294854f, -0.03326131f, 0.04162060f, 0.13762648f, -0.06389820f, 0.04015691f, 
    0.13694344f, 0.14406629f, 0.06844204f, 0.10296506f, -0.08502598f, -0.02248997f, -0.20216134f, -0.30899060f, 
    -0.00425928f, 0.09030133f, -0.02373859f, 0.02017361f, -0.04053162f, 0.01224643f, -0.05049550f, -0.01108868f, 
    0.16754051f, 0.22834478f, 0.21531472f, -0.01224105f, -0.10667549f, -0.00419424f, -0.05881267f, 0.05078782f, 
    -0.11135887f, -0.05357747f, -0.04165092f, -0.02175821f, -0.41361180f, -0.18364052f, -0.10093394f, 0.21037462f, 
    -0.05592299f, -0.03212550f, -0.12502569f, 0.19380893f, 0.05526967f, -0.06284674f, 0.00858106f, 0.04822134f, 
    0.14121620f, 0.21598023f, 0.08018316f, 0.08540127f, -0.07525486f, 0.00115545f, 0.05688896f, -0.12435523f, 
    0.10672699f, 0.15618747f, 0.18907265f, 0.08882143f, -0.12569387f, 0.11533324f, 0.29917201f, 0.25535262f, 
    0.11204927f, -0.05023666f, 0.05553254f, 0.08064380f, -0.03507397f, 0.03974712f, 0.02415559f, 0.02861977f, 
    -0.13372380f, -0.07940969f, -0.22471520f, -0.03388254f, 0.00732808f, -0.03137228f, -0.00667139f, 0.09879941f, 
    -0.12288826f, -0.04820182f, -0.29616976f, -0.07174537f, 0.22319162f, 0.27443370f, 0.12622932f, -0.06454816f, 
    0.03018689f, -0.10707128f, -0.08613297f, -0.02658042f, -0.04887647f, 0.09842934f, -0.07600699f, 0.06863166f, 
    0.00976749f, 0.00599372f, 0.04358949f, 0.04469711f, -0.04861622f, 0.05881920f, -0.10993071f, -0.10061336f, 
    0.31335697f, 0.03086827f, 0.05634405f, 0.06291353f, -0.19884020f, 0.24958111f, -0.09798163f, 0.24174187f, 
    0.04374159f, 0.03381968f, 0.11805291f, 0.06449214f, -0.03595747f, 0.06160166f, -0.03535965f, -0.09531886f, 
    -0.03637531f, -0.17621136f, 0.24495174f, 0.04649241f, 0.19671665f, -0.08890902f, 0.22131053f, -0.07377507f, 
    0.28199244f, -0.00279844f, 0.20951714f, 0.01822301f, -0.14566125f, -0.18613537f, 0.08118384f, 0.09658948f, 
    0.11581096f, 0.02832224f, 0.04971359f, -0.06578810f, 0.05111955f, 0.09934260f, 0.16355337f, 0.24362625f, 
    0.03015552f, -0.14223720f, 0.22277449f, -0.22949825f, 0.08710823f, 0.11604723f, -0.02714661f, -0.10190116f, 
    0.16944812f, 0.01872061f, 0.28376409f, 0.29568425f, -0.02496958f, -0.39428633f, 0.16713689f, -0.21345481f, 
    0.11697411f, 0.07767095f, -0.05152486f, -0.05417820f, 0.04073153f, 0.08008848f, 0.23004639f, 0.05760533f, 
    0.18994203f, 0.24022476f, 0.11735440f, -0.08574039f, 0.04622783f, -0.00570764f, -0.04869334f, 0.01603498f, 
    -0.13652384f, -0.09940671f, -0.02987010f, -0.11624222f, 0.19744860f, -0.04449294f, 0.11006837f, 0.07226548f, 
    -0.09446198f, 0.10313574f, -0.06216710f, -0.05436602f, -0.01219436f, 0.13337442f, 0.01718902f, -0.09133762f, 
    0.11324996f, -0.03657190f, -0.09602608f, 0.03389036f, -0.03103765f, 0.01960354f, 0.06705838f, -0.03898375f, 
    0.09975170f, 0.00103986f, 0.10390992f, 0.20153882f, -0.08139415f, -0.00300462f, 0.03941205f, -0.01346255f, 
    0.11782636f, -0.02921571f, 0.01011900f, 0.03340577f, -0.04516567f, -0.07786777f, -0.09230410f, -0.01383920f, 
    -0.15859948f, -0.21105474f, -0.03337627f, -0.00189583f, 0.24444634f, -0.04165164f, -0.12739195f, 0.00992934f, 
    -0.20460570f, -0.14771087f, -0.19254944f, -0.14383034f, 0.36984324f, -0.22994627f, -0.01062047f, -0.05702019f, 
    -0.00286650f, -0.01010276f, -0.21375245f, 0.01522336f, -0.07305764f, -0.10796129f, -0.00882659f, 0.04413763f, 
    -0.15739605f, -0.15561415f, -0.13008255f, 0.09526361f, -0.01003352f, 0.02110654f, 0.03389882f, 0.09381400f, 
    -0.00646129f, 0.04156498f, -0.00504725f, 0.00425014f, 0.07308798f, 0.29568312f, -0.01368371f, -0.12188154f, 
    -0.07940016f, -0.03789367f, 0.00928901f, 0.02753875f, -0.05990069f, 0.02605154f, -0.11521021f, -0.07205696f, 
    0.03868842f, 0.20896599f, 0.01311576f, 0.20090567f, 0.03183774f, -0.06706697f, -0.10411151f, 0.01363398f, 
    -0.08382966f, -0.14694057f, 0.05460537f, 0.08523717f, 0.29261336f, 0.06904406f, 0.21482724f, 0.13037418f, 
    -0.06495198f, 0.06085134f, -0.06353395f, 0.03109571f, -0.08407672f, 0.01848467f, -0.00282524f, -0.02696015f, 
    0.11129307f, -0.10898425f, 0.04337607f, 0.04643303f, -0.01139224f, -0.01017827f, -0.00319769f, -0.01807967f, 
    -0.02944423f, 0.25451696f, -0.07142946f, 0.09516522f, 0.06708005f, 0.05647822f, 0.12592342f, 0.10262997f, 
    -0.02262533f, -0.04178080f, -0.02785620f, -0.01834535f, -0.12127603f, -0.13060023f, -0.04090427f, -0.01526262f, 
    -0.07145286f, -0.04399522f, -0.11258435f, -0.06609958f, -0.14069352f, 0.05642757f, 0.18204442f, 0.06793865f, 
    0.00561020f, 0.02321759f, 0.08792443f, -0.05399414f, -0.01088694f, -0.01823618f, 0.10367461f, 0.10799848f, 
    0.05230807f, -0.02269751f, -0.05433505f, 0.06975707f, 0.05488275f, 0.15335770f, -0.02885338f, -0.06718719f, 
    0.08304874f, -0.50132573f, -0.06925647f, -0.18727937f, -0.09032514f, 0.14430448f, -0.04193726f, 0.03169407f, 
    -0.03053502f, 0.00605503f, 0.01188883f, 0.24235067f, -0.01964579f, -0.30462387f, 0.23104231f, 0.14928867f, 
    0.08000797f, -0.12743294f, -0.03016575f, -0.24272226f, 0.11112718f, -0.11122819f, 0.01731705f, -0.03362740f, 
    -0.14329500f, -0.47066215f, -0.08063918f, 0.02819951f, 0.02112514f, -0.10733993f, 0.10015430f, -0.07410353f, 
    -0.19569376f, 0.07907151f, -0.00725199f, -0.21388195f, 0.01247992f, -0.22897223f, 0.12582876f, -0.27824020f, 
    -0.20572077f, -0.06608839f, 0.18477425f, -0.38588196f, -0.20716700f, -0.22861673f, -0.03938341f, 0.01099841f, 
    -0.00356445f, 0.10857586f, 0.07269508f, 0.24525528f, 0.04347200f, 0.07673744f, 0.14964283f, 0.21181208f, 
    0.15297507f, 0.13812760f, 0.11034613f, 0.20318419f, 0.34287757f, 0.28833339f, 0.01446046f, 0.01314879f, 
    0.05136946f, -0.01029051f, 0.16205522f, -0.05534422f, -0.03859784f, -0.06152210f, -0.05954103f, 0.05713301f, 
    0.25862291f, 0.15498441f, -0.03219172f, -0.08530734f, 0.14084081f, -0.05120886f, -0.02033105f, 0.21620239f, 
    0.15754235f, -0.03671606f, -0.11985171f, -0.11098444f, 0.39998665f, 0.15238927f, -0.01104055f, 0.13518126f, 
    -0.00262138f, 0.09346139f, -0.10750843f, -0.28505018f, -0.13639715f, -0.11159921f, 0.03686052f, -0.14073336f, 
    0.20457742f, 0.02773799f, -0.00358177f, 0.12254201f, 0.06012998f, 0.00573549f, -0.03207057f, 0.06364569f, 
    0.08918164f, 0.02811092f, 0.12048777f, 0.20415279f, 0.46188575f, 0.26136538f, 0.14672616f, -0.08945446f, 
    -0.21360618f, 0.18273661f, 0.10233644f, 0.09275905f, 0.14710666f, 0.05301981f, 0.05745881f, 0.14534250f, 
    0.22342335f, -0.01512994f, -0.28865120f, 0.04650947f, 0.06682406f, 0.13907495f, -0.02196267f, 0.23692669f, 
    -0.07194957f, -0.07627461f, -0.20881166f, -0.15261064f, 0.22520699f, 0.24611567f, 0.11158654f, 0.01656905f, 
    0.08570304f, -0.08464298f, -0.01830802f, 0.12794924f, -0.08370629f, 0.14191270f, -0.03304227f, 0.00172751f, 
    0.26432136f, 0.10422637f, -0.10117602f, 0.04817772f, -0.01379037f, 0.01014742f, 0.11186970f, 0.01952468f, 
    0.01062517f, 0.12967870f, 0.02240526f, 0.12718287f, 0.20955405f, 0.03270879f, -0.15776941f, -0.16755559f, 
    -0.04740727f, -0.01509411f, -0.00113340f, -0.27582461f, 0.01507088f, -0.18353118f, -0.11004622f, -0.23306330f, 
    0.04268548f, 0.01433713f, -0.19936676f, -0.07461181f, 0.11775775f, -0.11121669f, -0.07583266f, 0.05275619f, 
    -0.10172082f, 0.06658781f, -0.18393932f, -0.14209828f, 0.13547462f, 0.08203608f, -0.16251260f, 0.02377315f, 
    -0.04719346f, -0.03142412f, -0.02571193f, -0.00272418f, -0.07994843f, -0.11074747f, 0.19493617f, 0.02212135f, 
    -0.02629598f, 0.01028253f, 0.18233874f, 0.03102610f, -0.13377267f, -0.02877550f, 0.12596662f, 0.14395757f, 
    -0.13538772f, 0.23945242f, 0.23700383f, 0.07111542f, 0.04652846f, 0.02849548f, 0.16242325f, 0.12431554f, 
    -0.19046527f, -0.10165762f, -0.06476082f, -0.00994657f, 0.21673669f, 0.03508772f, 0.21046075f, 0.38946593f, 
    -0.12104908f, -0.00503225f, 0.15633160f, 0.12637752f, 0.11668543f, -0.00514265f, -0.37591496f, -0.08332065f, 
    -0.21992539f, -0.43552646f, -0.08169015f, -0.53947353f, -0.19222455f, -0.05478407f, -0.13453051f, 0.39940387f, 
    0.10634782f, -0.02164637f, 0.31659967f, -0.29672617f, -0.01403996f, 0.00373243f, 0.05926364f, 0.29258946f, 
    -0.15185782f, 0.15750517f, 0.06928224f, 0.06863725f, -0.11839484f, 0.18771909f, 0.30570310f, 0.03073887f, 
    0.37627098f, 0.28705779f, 0.11793409f, 0.19634089f, 0.21463820f, -0.00976626f, 0.16208132f, -0.35088614f, 
    0.05328874f, 0.07173668f, 0.02004858f, -0.09352180f, -0.03467556f, 0.08208677f, 0.04363566f, -0.00485736f, 
    0.17949016f, 0.13996425f, -0.00694397f, 0.22948417f, 0.01691835f, 0.06780020f, 0.06839344f, -0.09551502f, 
    -0.26732937f, -0.20881288f, -0.39321485f, -0.38448384f, -0.18291685f, 0.37327832f, 0.23124744f, 0.16726235f, 
    0.11739859f, 0.18013808f, -0.21433368f, -0.21379592f, -0.01607028f, -0.32581711f, 0.00708137f, -0.09853616f, 
    0.31233510f, 0.20528036f, -0.26285070f, 0.07072847f, 0.09294070f, 0.04353774f, 0.00810519f, -0.20789252f, 
    -0.00450868f, 0.03799636f, -0.12417332f, 0.01536476f, 0.21533619f, 0.17266895f, -0.20898269f, -0.24243593f, 
    0.00175979f, -0.08856629f, 0.03903803f, 0.02366171f, -0.32001483f, -0.33252266f, -0.09184901f, -0.33813626f, 
    0.07631835f, -0.05138474f, 0.22167906f, 0.02119105f, -0.27992484f, 0.04748414f, -0.07686087f, -0.17884590f, 
    0.01779919f, 0.11391603f, 0.07531529f, 0.40935960f, 0.02898476f, -0.09730058f, -0.02943013f, 0.07324350f, 
    0.09156623f, -0.08415526f, -0.28533310f, -0.19283162f, -0.22257821f, -0.05648023f, 0.10252563f, -0.16573596f, 
    -0.10583480f, -0.08200269f, -0.11928269f, 0.17378466f, -0.07667705f, -0.24849921f, -0.02111189f, -0.02137313f, 
    0.01128424f, 0.20195323f, 0.24177237f, 0.12456795f, -0.08632405f, 0.07193765f, 0.00135495f, -0.14143761f, 
    0.08601835f, 0.02609828f, -0.08455360f, -0.06461320f, 0.10623337f, -0.14688721f, 0.04458971f, 0.00855025f, 
    0.36913532f, -0.01518076f, 0.03937204f, 0.10369502f, 0.06797082f, -0.06899790f, -0.13206108f, -0.13558936f, 
    0.12892979f, 0.11111522f, 0.04797615f, 0.24003403f, 0.12979035f, -0.22638543f, 0.09109066f, -0.06654175f, 
    -0.05552179f, 0.06931801f, -0.08117650f, 0.10937412f, 0.05370007f, 0.05856081f, -0.25331941f, 0.02894264f, 
    0.05112863f, 0.15160319f, -0.06810827f, 0.16802974f, 0.03319421f, 0.16017695f, 0.12250036f, 0.22624801f, 
    0.14616133f, 0.01209901f, -0.02453621f, -0.10144193f, 0.22498487f, 0.07393036f, -0.07551045f, -0.04509928f, 
    -0.11598114f, 0.08524338f, -0.04983209f, 0.27305114f, -0.11228506f, -0.02548671f, 0.09516922f, -0.17835881f, 
    0.24318542f, -0.19545670f, 0.19691928f, -0.19120160f, -0.00317818f, 0.11017050f, 0.05613264f, -0.11072677f, 
    0.16744918f, 0.04727660f, -0.11044320f, 0.20746081f, 0.01288452f, 0.12686989f, 0.14757991f, -0.10509854f, 
    0.12469477f, 0.11599357f, 0.02400522f, 0.11167616f, 0.18921496f, 0.30415791f, -0.01351949f, 0.04444052f, 
    0.06036569f, 0.40099841f, -0.01740272f, 0.05136605f, -0.08025470f, -0.04809500f, 0.06790433f, 0.05345776f, 
    -0.22896495f, -0.05064568f, 0.03337131f, -0.05454779f, 0.07108730f, -0.17236641f, 0.55589253f, -0.21851465f, 
    -0.18262789f, -0.00891707f, -0.10044557f, -0.02958085f, -0.08336087f, 0.01361096f, -0.09818356f, 0.02936650f, 
    0.18824627f, 0.18322754f, 0.20388009f, 0.16403870f, -0.10239451f, -0.11018135f, -0.13778029f, -0.11488550f, 
    0.04734028f, 0.00573325f, 0.03248293f, -0.04294350f, 0.54181641f, 0.21440434f, -0.12186145f, -0.23243058f, 
    -0.02971217f, -0.07423265f, -0.01431434f, -0.11085510f, 0.12758267f, -0.07724383f, 0.01949384f, 0.02860086f, 
    -0.03833974f, -0.15118685f, -0.10518987f, 0.01372679f, 0.04330121f, -0.08852419f, 0.00326390f, 0.03534258f, 
    -0.03326293f, -0.15417324f, -0.08863685f, 0.01210840f, -0.14613795f, -0.22672114f, 0.05175308f, -0.06142047f, 
    0.04350773f, -0.00141366f, 0.02863397f, 0.05381889f, -0.11734529f, -0.17242827f, -0.17010739f, -0.15494402f, 
    -0.16630037f, -0.06057975f, 0.06665453f, 0.10965110f, 0.01533302f, 0.17482054f, 0.43029746f, 0.14203033f, 
    0.09902071f, 0.16116305f, 0.28140911f, -0.07227539f, 0.15461189f, 0.27598247f, 0.07145476f, 0.25285658f, 
    -0.12436501f, -0.13723248f, 0.00008135f, -0.05532794f, 0.00764870f, -0.03043071f, 0.00343685f, -0.05654383f, 
    -0.19418262f, -0.19525120f, 0.05171928f, 0.16113381f, 0.01228646f, 0.11650544f, -0.02646899f, -0.00751818f, 
    0.01711781f, -0.07393561f, -0.03271569f, -0.09080314f, 0.07408836f, -0.29201743f, -0.12286253f, -0.13967499f, 
    -0.18036577f, 0.12066427f, -0.02669646f, 0.04809235f, 0.07425860f, 0.02909672f, 0.02694068f, -0.08970577f, 
    0.31868953f, 0.03152381f, -0.04151227f, 0.02892864f, 0.04480097f, 0.18391670f, -0.00705195f, 0.01917179f, 
    0.12848130f, -0.05457832f, 0.11549187f, -0.13044879f, 0.22122842f, -0.15831630f, -0.02216180f, 0.03866502f, 
    -0.05469995f, -0.03250214f, -0.06192097f, -0.02898896f, -0.06900465f, 0.10918925f, -0.18980633f, 0.07789899f, 
    0.14186653f, 0.03156767f, 0.02259399f, 0.31539187f, 0.17298345f, 0.25711465f, -0.01068383f, 0.01746285f, 
    -0.08313508f, -0.05402406f, -0.11803436f, -0.08033486f, -0.22003883f, -0.19780700f, -0.17246832f, 0.09195521f, 
    0.04839980f, 0.04704206f, 0.00438016f, -0.00453389f, -0.13234922f, -0.13430397f, -0.02461503f, -0.09519836f, 
    0.19699463f, 0.28849819f, 0.05563109f, 0.22166330f, -0.09347175f, -0.04848843f, 0.03384751f, -0.03526744f, 
    0.04312641f, 0.01485367f, 0.03896231f, 0.05262217f, -0.01054545f, 0.06522311f, 0.18412352f, -0.16212003f, 
    0.03238077f, 0.10577553f, 0.02360262f, 0.06377266f, 0.14786868f, 0.01330900f, -0.02780410f, -0.08136448f, 
    0.14753431f, 0.16135281f, 0.10302368f, 0.05080646f, -0.02620919f, -0.06386885f, -0.06290843f, -0.01538472f, 
    -0.16760872f, -0.16400561f, 0.14131899f, 0.01335828f, -0.04119920f, -0.04367118f, -0.14185007f, -0.01261405f, 
    -0.11773031f, -0.27276951f, -0.08994798f, 0.02434502f, -0.14484674f, -0.04575175f, -0.12960663f, -0.10347412f, 
    -0.00378045f, 0.07567348f, -0.01026753f, -0.10498790f, -0.03910039f, 0.30391037f, -0.01410153f, -0.03001988f, 
    -0.03635253f, 0.01357564f, 0.23465584f, 0.06702285f, -0.07893654f, 0.22288361f, 0.09069171f, 0.20442833f, 
    0.04866348f, 0.03497254f, 0.07338099f, 0.11947002f, 0.01202057f, 0.09112648f, 0.01510940f, -0.02322966f, 
    0.31434309f, 0.03054264f, -0.11993951f, -0.13599806f, -0.02806812f, 0.05255480f, -0.00137724f, -0.09916584f, 
    -0.02026586f, -0.09177089f, 0.07270949f, 0.04173739f, -0.13557808f, -0.14021330f, 0.34672129f, 0.18810444f, 
    -0.09632678f, 0.11341343f, 0.00034810f, 0.14266744f, -0.01896874f, -0.08421995f, -0.01274249f, 0.12407473f, 
    0.18503933f, 0.06681091f, 0.14312948f, -0.06401436f, -0.05027226f, -0.05350260f, -0.03768813f, -0.04034664f, 
    0.03934786f, 0.21195385f, 0.13251342f, -0.02097440f, 0.22452614f, 0.18865968f, 0.18156140f, -0.11738743f, 
    0.06829362f, -0.06596849f, -0.02566875f, -0.07702648f, 0.16941963f, -0.01787682f, 0.12795733f, 0.22627082f, 
    0.08814050f, 0.01325339f, 0.23047693f, -0.02332584f, 0.01133302f, -0.03639963f, -0.06041138f, -0.03975236f, 
    0.12490715f, -0.03897624f, -0.07954698f, -0.03203232f, -0.00019049f, 0.21273018f, 0.11696383f, 0.08079053f, 
    0.01508756f, 0.01003906f, -0.06222761f, -0.03539098f, 0.10944150f, 0.20480579f, 0.00732757f, 0.03826671f, 
    -0.11831482f, -0.65985459f, -0.42291608f, -0.33203545f, -0.05978554f, -0.05451344f, -0.03834863f, 0.11388751f, 
    0.26340592f, -0.08209465f, -0.09750456f, -0.19072853f, -0.06175424f, 0.07733986f, 0.12344755f, 0.01910422f, 
    0.15090431f, -0.02892483f, -0.02962128f, 0.01230708f, 0.17039868f, 0.04650752f, 0.23950090f, -0.01033948f, 
    0.02147163f, 0.41878027f, 0.06607582f, 0.36882052f, 0.14269215f, -0.20667382f, -0.01319379f, -0.04734459f, 
    -0.11018957f, -0.03436341f, 0.19885133f, -0.00686740f, -0.08185077f, 0.02258773f, 0.32587504f, 0.32556742f, 
    0.06112657f, 0.19415440f, 0.11234219f, 0.06955644f, -0.06496660f, 0.11688963f, 0.01317123f, 0.08913162f, 
    0.30345714f, 0.14778109f, 0.21520683f, 0.18181516f, 0.18143231f, -0.05826128f, 0.06861195f, 0.11913970f, 
    -0.16430593f, 0.01963070f, 0.11359587f, -0.00060619f, 0.06425902f, 0.05305060f, -0.05542772f, -0.00638877f, 
    0.03378250f, 0.12558936f, 0.02024810f, -0.01698219f, -0.08507784f, -0.11001682f, 0.05455128f, -0.04012955f, 
    0.07964668f, 0.01016298f, 0.29842183f, 0.02957886f, 0.14720446f, 0.01006983f, -0.14985283f, 0.03492946f, 
    -0.02584120f, 0.04204350f, 0.08857485f, 0.21759379f, -0.64105213f, -0.36406690f, -0.37794301f, 0.11176715f, 
    0.02989531f, 0.15810484f, -0.09064485f, 0.08908381f, 0.01820256f, -0.04380972f, 0.07313267f, -0.05844608f, 
    0.22243829f, 0.14579885f, 0.12773828f, -0.12701674f, -0.03970343f, -0.06250574f, -0.02110915f, 0.05239466f, 
    -0.11047891f, -0.02969533f, -0.05544553f, 0.07928340f, -0.19405062f, 0.08187547f, 0.12581044f, 0.50685114f, 
    0.11433393f, -0.14709896f, -0.18598363f, -0.02571448f, -0.05882834f, -0.01067910f, 0.06317249f, 0.00163964f, 
    -0.00330507f, -0.16200548f, 0.07279416f, 0.04943869f, 0.01595969f, -0.07959121f, -0.11754356f, -0.15519053f, 
    0.05671001f, 0.13150296f, 0.08500600f, 0.04947691f, 0.00605033f, -0.05010008f, -0.11186399f, 0.26381978f, 
    0.11281267f, -0.03612151f, 0.02974756f, -0.05035319f, -0.05503420f, -0.00909978f, 0.02583064f, -0.00048722f, 
    -0.22525156f, -0.01142151f, 0.01887562f, 0.04795363f, -0.10019869f, -0.28768328f, -0.11613874f, 0.21183188f, 
    -0.25913474f, 0.01282694f, -0.39229757f, 0.06391580f, 0.43968290f, 0.29320452f, 0.15385981f, -0.15174764f, 
    -0.15203996f, -0.10135220f, 0.05859011f, -0.09851556f, -0.08190707f, 0.00851704f, -0.01925336f, 0.11709315f, 
    -0.28397885f, -0.13849401f, 0.11737394f, 0.05270987f, -0.00844825f, -0.09716734f, -0.13468426f, -0.03421326f, 
    0.19319881f, 0.05164477f, 0.08067221f, -0.05383898f, -0.15725113f, 0.23904438f, 0.06660971f, 0.04159325f, 
    0.03636737f, -0.11838826f, 0.06718247f, 0.11295412f, -0.16264926f, 0.03150379f, -0.01681746f, -0.03588619f, 
    -0.18537603f, 0.09390379f, 0.27857971f, 0.14284180f, 0.22434483f, 0.02756838f, 0.22417279f, -0.12916076f, 
    0.30852553f, 0.05171230f, 0.12542926f, 0.12763891f, -0.39444825f, 0.04978806f, -0.01355709f, 0.35189626f, 
    0.00326451f, 0.11977965f, -0.08428511f, -0.04520880f, 0.22664127f, 0.11400741f, 0.31598160f, 0.05186294f, 
    -0.22615568f, -0.08237656f, 0.06470471f, 0.06765950f, 0.11958397f, 0.05710297f, 0.05150893f, 0.15180282f, 
    0.17829847f, -0.00525855f, 0.20434900f, 0.15783024f, 0.06930511f, -0.06017683f, 0.02077470f, -0.20005248f, 
    0.13397861f, 0.09847140f, 0.13816890f, -0.09991905f, 0.10432993f, 0.17881508f, 0.21733445f, 0.25120959f, 
    0.30871430f, 0.28099844f, 0.25968087f, -0.02369383f, -0.10637415f, -0.05831751f, -0.09685837f, 0.00147284f, 
    -0.14685318f, -0.06453201f, -0.04556138f, -0.09909052f, 0.32118520f, -0.02365601f, 0.12187086f, -0.01823292f, 
    -0.02471704f, 0.00866793f, 0.05565163f, 0.02891820f, -0.07925028f, -0.02882343f, 0.10311164f, 0.02302060f, 
    0.02942058f, -0.04034548f, 0.06723698f, 0.03198884f, -0.11000529f, 0.07292049f, 0.12723471f, -0.00922760f, 
    0.29949147f, 0.20928669f, 0.05122620f, 0.23958957f, -0.14526255f, 0.08803747f, -0.04040489f, -0.08104867f, 
    -0.05570824f, -0.05324339f, -0.04938077f, -0.15630876f, -0.01013429f, -0.13199292f, -0.12777922f, 0.04192107f, 
    -0.01930499f, 0.04953060f, 0.06477093f, 0.04441582f, -0.00610184f, -0.16193059f, 0.04015872f, -0.06777155f, 
    -0.13640361f, -0.08985716f, -0.27850571f, -0.13501972f, 0.43552479f, 0.15105745f, 0.06228557f, -0.18113782f, 
    0.08037396f, 0.04959799f, -0.07690077f, 0.00547101f, -0.09829030f, -0.21685593f, -0.04840385f, 0.05401164f, 
    -0.06119977f, 0.06424209f, 0.08005357f, -0.05747602f, 0.00689075f, 0.02428803f, -0.04012468f, -0.00127296f, 
    -0.00826832f, 0.01496652f, -0.07693318f, 0.07200086f, -0.29342702f, -0.20694017f, -0.03915529f, 0.04071217f, 
    -0.23869048f, -0.01179068f, -0.14133261f, -0.05489593f, -0.11396878f, 0.02551006f, -0.18755409f, -0.05131143f, 
    0.07049495f, -0.05518994f, -0.08127902f, 0.18050875f, -0.02834228f, 0.17932102f, -0.03215677f, -0.03061241f, 
    0.09405591f, -0.07792947f, 0.17001386f, 0.24239865f, 0.17533584f, 0.09774844f, 0.21641429f, 0.08759685f, 
    -0.14213879f, 0.02124349f, -0.01099303f, -0.05166647f, -0.04085258f, 0.17014959f, -0.11359031f, -0.08261517f, 
    0.32035396f, 0.21395022f, 0.01519241f, 0.07205843f, -0.07664208f, -0.09211572f, 0.03919433f, 0.00566128f, 
    0.12300186f, 0.49422076f, 0.16397847f, 0.15533717f, 0.14718555f, 0.06321795f, 0.10020033f, 0.02077582f, 
    -0.02970651f, 0.05567189f, -0.05128613f, -0.04194083f, -0.02069364f, 0.04187698f, 0.02239081f, 0.02316944f, 
    -0.01861928f, 0.22881156f, 0.13008723f, -0.21799572f, -0.12563850f, -0.06765270f, 0.04442231f, 0.02586120f, 
    -0.08780431f, -0.03362225f, 0.08900744f, 0.12013666f, 0.09204840f, -0.07515796f, 0.09919374f, 0.07665394f, 
    0.02593258f, 0.06259359f, 0.07318522f, -0.01290292f, -0.03953508f, 0.10860290f, -0.01195139f, 0.05628389f, 
    -0.09723558f, -0.35821712f, -0.07281037f, -0.05660256f, -0.04257759f, 0.11519961f, 0.07087117f, 0.05659579f, 
    -0.01477393f, -0.15302067f, -0.01082304f, 0.16680859f, -0.27353030f, -0.28600931f, 0.15412402f, 0.29627767f, 
    -0.08874436f, -0.13966592f, -0.07965654f, 0.05292793f, 0.01793317f, -0.02772250f, -0.01210037f, -0.07306437f, 
    -0.04641603f, -0.00950299f, 0.01059254f, -0.01090906f, -0.01042825f, -0.02085226f, 0.01257089f, 0.00734406f, 
    0.01560074f, 0.03978061f, -0.03497313f, -0.04201932f, 0.04029136f, 0.00385404f, 0.02508623f, -0.00901080f, 
    0.02405979f, -0.02402547f, -0.04012965f, 0.02801537f, 0.04057211f, -0.05131577f, -0.00178758f, 0.02604832f, 
    -0.03850269f, -0.01125622f, 0.00335363f, 0.01831387f, -0.03860924f, 0.02948049f, 0.01562972f, -0.05354175f, 
    0.00277516f, 0.02733091f, -0.00082186f, -0.02939776f, 0.03672014f, 0.04454425f, 0.00210223f, 0.03610111f, 
    0.02642919f, -0.00093863f, 0.04385044f, 0.03436993f, 0.02677966f, -0.05372455f, -0.05288364f, -0.04269227f, 
    -0.03453214f, 0.01494384f, -0.03182867f, -0.03856124f, -0.02985726f, -0.04363425f, -0.00207053f, 0.01764296f, 
    -0.01434106f, -0.01858805f, -0.01862822f, 0.03386591f, -0.05393038f, 0.02861622f, -0.00465150f, 0.00097731f, 
    -0.00498385f, -0.03985868f, -0.04179772f, -0.03867445f, -0.03187286f, -0.04242535f, -0.03438287f, 0.00074846f, 
    0.00980069f, -0.00228654f, 0.02296426f, -0.02401220f, 0.01220979f, -0.01767603f, -0.00744011f, -0.02118685f, 
    -0.02113169f, 0.00277586f, 0.02020226f, -0.00181185f, -0.05660554f, -0.01347444f, 0.04099938f, -0.00601664f, 
    -0.02246728f, -0.03234900f, -0.05043421f, -0.01917666f, 0.00474461f, 0.00119253f, -0.05412057f, 0.00025024f, 
    -0.02451010f, 0.02540956f, 0.03908834f, -0.05285704f, -0.04661512f, 0.00839672f, -0.02638485f, 0.04560499f, 
    -0.00328941f, -0.02012818f, 0.01391006f, 0.02747300f, 0.03061781f, -0.04974054f, -0.01966936f, -0.01628024f, 
    0.01872994f, -0.03475914f, -0.01018747f, -0.04150405f, -0.03188182f, -0.00746095f, 0.04275876f, 0.00735904f, 
    -0.01624785f, -0.03297965f, 0.00182667f, -0.02379687f, -0.02358589f, -0.04559970f, -0.04128251f, 0.03652566f, 
    -0.05350129f, 0.00144233f, -0.00032960f, -0.03882686f, 0.01809527f, -0.01175153f, -0.05326264f, 0.04274042f, 
    0.02936190f, 0.03784112f, -0.03307079f, -0.03546791f, 0.01720068f, -0.03708873f, -0.04760962f, 0.03947902f, 
    -0.05083188f, 0.01190129f, -0.03361817f, -0.03162769f, -0.00650556f, -0.02731859f, 0.00310015f, -0.00768868f, 
    -0.01254049f, 0.02614789f, -0.00263280f, 0.02196227f, 0.02132581f, 0.02449987f, -0.03699289f, 0.03985912f, 
    -0.04704789f, 0.04080747f, -0.05127992f, -0.04327635f, 0.02044931f, -0.03861520f, 0.03956604f, -0.02402069f, 
    0.03016004f, -0.05430561f, -0.00658463f, 0.00203606f, 0.02946407f, 0.03036669f, 0.01877241f, 0.02589547f, 
    0.01813422f, -0.03789844f, -0.03397285f, 0.03286302f, -0.03484821f, -0.03568196f, -0.01394660f, 0.03511293f, 
    0.04494137f, -0.02877773f, -0.00393704f, 0.02961099f, -0.03926125f, -0.01372508f, -0.00213663f, 0.03760408f, 
    0.01076122f, -0.02773638f, -0.04879152f, -0.04261668f, 0.02735792f, -0.01647610f, 0.04179271f, 0.00262453f, 
    -0.04742683f, 0.01505923f, -0.05118547f, -0.04984281f, 0.00858310f, 0.00817093f, -0.01945656f, -0.00627008f, 
    -0.03680965f, -0.04867543f, 0.02651515f, 0.02410787f, -0.04365565f, 0.03860504f, 0.04207820f, -0.04610027f, 
    -0.02900693f, -0.03154258f, 0.00661611f, 0.04359217f, -0.05132531f, 0.01339413f, -0.00766650f, -0.04604793f, 
    0.02831129f, -0.04945346f, -0.00613211f, 0.02386753f, -0.02878500f, 0.02498216f, -0.04173233f, -0.02981850f, 
    0.04501684f, 0.03777790f, 0.04024826f, -0.01314303f, -0.01559112f, -0.03450294f, -0.02102074f, -0.02356281f, 
    -0.01421218f, 0.03449038f, 0.04448708f, 0.01744098f, 0.02074445f, 0.03160635f, 0.00835654f, -0.01842661f, 
    0.01552079f, 0.01602271f, 0.02819531f, 0.02168203f, 0.04054045f, 0.01411148f, 0.02094788f, 0.02781771f, 
    -0.00506249f, -0.04505105f, -0.04463937f, 0.01017864f, -0.04952057f, -0.03397938f, -0.05161203f, -0.02142995f, 
    -0.01626562f, 0.03442476f, -0.04759830f, -0.04693259f, -0.01041642f, -0.01215552f, -0.00162101f, -0.05085356f, 
    0.01043125f, -0.00793075f, 0.04481675f, 0.03084914f, -0.05358768f, -0.01188019f, 0.03086609f, -0.02768917f, 
    0.04454276f, 0.02645815f, 0.01737751f, -0.01547234f, -0.00929623f, 0.03424592f, -0.04713076f, 0.00083924f, 
    -0.05171910f, 0.03652668f, 0.00675572f, -0.03225016f, -0.03750660f, -0.04028838f, -0.05524339f, 0.00900801f, 
    0.00566514f, -0.00964646f, -0.04587082f, -0.05066063f, -0.00604271f, 0.02017578f, -0.02661142f, 0.01328280f, 
    -0.03246955f, -0.01663583f, 0.01440971f, -0.03280914f, -0.04322714f, -0.03457090f, -0.00066903f, 0.01445333f, 
    -0.03389702f, -0.03724182f, 0.01104958f, -0.00354256f, -0.00261855f, -0.04223703f, 0.00458095f, -0.02408392f, 
    0.00649134f, -0.03318860f, -0.03541591f, 0.02269339f, -0.05174175f, 0.01810449f, 0.02391342f, -0.03265955f, 
    0.01599640f, -0.01902528f, -0.00984705f, -0.05046836f, -0.04262479f, 0.00962112f, 0.02258696f, -0.04362467f, 
    0.01005731f, -0.03687876f, -0.00850881f, -0.05426905f, -0.03726690f, 0.00790708f, 0.04487987f, 0.00750985f, 
    0.04286917f, 0.02090921f, -0.01723975f, 0.01408625f, 0.00104287f, -0.01263079f, -0.04495598f, 0.02565390f, 
    -0.02593829f, -0.00928762f, 0.00740775f, 0.01301156f, 0.02883455f, 0.01586949f, -0.01961288f, -0.01491748f, 
    0.01250770f, 0.03507239f, -0.00767513f, -0.02905929f, -0.03491142f, 0.01319515f, -0.05594912f, -0.00495809f, 
    -0.01702167f, -0.04198015f, 0.03415687f, 0.03969037f, -0.01801145f, -0.00937684f, -0.02995642f, -0.00819595f, 
    -0.00688144f, -0.03369435f, -0.02557435f, 0.00562374f, -0.01245765f, -0.01911105f, 0.02709895f, -0.03199766f, 
    -0.20237881f, 0.35286424f, 0.41473252f, 0.21279016f, 0.04699667f, -0.23054090f, 0.08215492f, -0.03939350f, 
    -0.01121719f, -0.04399485f, 0.00802288f, 0.05204784f, 0.06808729f, -0.35727301f, 0.11914948f, -0.33298960f, 
    0.08919937f, 0.05274921f, -0.25559428f, -0.08512608f, -0.12285634f, -0.14472674f, 0.02123072f, -0.05707347f, 
    -0.15637065f, 0.03321430f, 0.09652214f, 0.26783350f, 0.08567466f, -0.05344729f, 0.05510837f, 0.01239167f, 
    0.19445862f, -0.01320054f, 0.24681953f, 0.27966225f, -0.36494008f, 0.05804710f, -0.25394353f, 0.52975529f, 
    0.01491347f, 0.16797806f, -0.14575885f, 0.12996522f, 0.03823454f, 0.03084949f, 0.10336745f, 0.04095813f, 
    -0.53055412f, -0.31387705f, -0.27792680f, -0.10744707f, -0.18060285f, -0.13720499f, 0.03494203f, -0.15544543f, 
    0.01926539f, -0.09202822f, 0.05190655f, -0.12970538f, 0.73733151f, 0.16823776f, 0.02894157f, -0.05315049f, 
    0.14390522f, -0.14035822f, -0.08326911f, -0.08254911f, -0.00893808f, 0.09421112f, 0.02732479f, -0.08921310f, 
    -0.12636936f, -0.28346214f, 0.17087951f, 0.32955891f, -0.00107527f, -0.14264260f, -0.09503856f, -0.03706285f, 
    0.02071846f, 0.02026290f, 0.12006630f, 0.17667237f, 0.13190316f, -0.36402521f, -0.21294731f, 0.24969491f, 
    -0.02123468f, -0.01301847f, -0.05447933f, 0.06570626f, 0.06734344f, 0.11931223f, 0.09744592f, 0.06996223f, 
    -0.15239282f, -0.03037552f, 0.22577477f, 0.21427687f, 0.04423883f, -0.18723637f, 0.01994887f, 0.01820151f, 
    -0.15208282f, -0.01020089f, -0.01102183f, 0.17341867f, -0.15843205f, 0.01316756f, 0.29582918f, 0.20021911f, 
    -0.02630872f, -0.18527529f, -0.06513233f, -0.10320032f, 0.04006191f, -0.19123773f, -0.08547484f, 0.00361753f, 
    -0.08936763f, -0.21316718f, 0.05145497f, 0.16544499f, -0.04067513f, -0.08329639f, 0.13572000f, -0.05835120f, 
    0.00860066f, 0.03871747f, -0.02421032f, 0.05122487f, 0.00093214f, 0.02203582f, 0.11167074f, 0.31978956f, 
    0.02618390f, -0.02566484f, 0.08928134f, 0.07725585f, -0.06056857f, -0.14869049f, 0.06571984f, -0.14715725f, 
    -0.24393758f, 0.47828874f, -0.10337604f, -0.11999018f, 0.06340788f, -0.02259139f, 0.16768877f, -0.03821834f, 
    -0.15043698f, 0.24269064f, -0.00145479f, -0.05034173f, -0.14966734f, 0.48605102f, -0.28836474f, -0.03315272f, 
    0.01803919f, 0.05905599f, -0.14676273f, 0.11611640f, 0.00031824f, 0.20870884f, 0.22834745f, -0.08438326f, 
    -0.33809152f, 0.06524339f, -0.10660139f, 0.09385689f, 0.01068487f, 0.07968592f, 0.00092521f, -0.09790786f, 
    0.18252996f, 0.16189612f, 0.21471600f, 0.03612486f, 0.43588737f, 0.24715143f, -0.09226421f, 0.17580870f, 
    -0.11973138f, -0.00236594f, 0.07071426f, -0.11642830f, 0.06325064f, 0.22098812f, 0.10140350f, 0.29439190f, 
    -0.29685414f, -0.05610369f, 0.03832801f, -0.12949474f, 0.01871652f, 0.00277886f, -0.00101580f, 0.07736889f, 
    -0.27315125f, -0.20195462f, 0.08373392f, -0.35863325f, -0.09503812f, 0.33016768f, 0.12526186f, 0.06539413f, 
    0.08946070f, 0.12394581f, 0.12471479f, -0.12450593f, 0.14026526f, 0.07089976f, 0.04343107f, 0.02055826f, 
    0.15089802f, 0.15346035f, 0.11193778f, -0.14503586f, 0.06334446f, 0.11590008f, 0.16294940f, -0.07602434f, 
    0.21424860f, 0.20161930f, -0.14589705f, 0.11250649f, 0.83456022f, 0.23812918f, -0.01655010f, 0.28562248f, 
    -0.02260580f, 0.04977147f, 0.02632683f, -0.12118790f, 0.00422532f, 0.03376104f, -0.00584400f, 0.15398450f, 
    0.01100093f, 0.18674847f, -0.14559597f, 0.13576667f, -0.24576695f, -0.12220749f, 0.16075230f, -0.13652016f, 
    0.11772638f, -0.17572618f, 0.01231599f, -0.22691645f, -0.12784792f, 0.14933075f, 0.19248113f, -0.01825011f, 
    0.12894386f, 0.08450861f, -0.14780134f, 0.06241868f, -0.00701927f, -0.28806019f, -0.09443666f, -0.12771802f, 
    0.42886269f, 0.10028965f, 0.26012084f, -0.16188362f, 0.08065639f, 0.00408941f, 0.00389293f, 0.01230366f, 
    0.11558897f, 0.04262490f, -0.15920801f, 0.14399663f, -0.38307360f, -0.32588515f, -0.18066704f, 0.20499788f, 
    0.06160278f, 0.07292701f, -0.03192297f, 0.05052556f, -0.28844282f, 0.06460205f, -0.12757069f, -0.09426817f, 
    0.16430920f, -0.23512533f, -0.16136134f, -0.12385015f, -0.21836257f, 0.08587962f, -0.06861846f, -0.20304014f, 
    0.12625942f, 0.01604833f, 0.04756660f, 0.26991630f, -0.27791175f, -0.18068469f, -0.21727978f, -0.38369381f, 
    -0.25200802f, -0.14197171f, -0.20076755f, -0.11446960f, -0.02786786f, 0.05727826f, 0.02489076f, -0.06970367f, 
    0.01136544f, 0.29620737f, -0.11174069f, -0.07010972f, 0.00364909f, -0.11274772f, -0.02471922f, 0.00325709f, 
    0.08912133f, 0.14158911f, 0.14991385f, 0.01787525f, -0.16098237f, -0.36716896f, -0.06929035f, -0.38065445f, 
    -0.11766016f, -0.09009836f, -0.02199526f, -0.13253012f, 0.04967890f, -0.02765812f, -0.07489450f, 0.02109867f, 
    -0.00828482f, 0.45555770f, 0.33753410f, 0.40597209f, -0.00549646f, -0.07159050f, 0.01067855f, -0.00129619f, 
    0.06888808f, 0.08790669f, -0.10394330f, 0.16445817f, -0.02132605f, -0.13026482f, -0.07213493f, -0.28159329f, 
    -0.10545622f, -0.09297417f, 0.13254592f, -0.15445806f, 0.07461428f, -0.02055537f, 0.01293521f, 0.10827274f, 
    -0.13274896f, 0.02677544f, -0.00741682f, 0.03597683f, 0.16106805f, -0.01630913f, 0.22681376f, -0.02711934f, 
    0.07081244f, -0.11309713f, 0.17371817f, -0.02582203f, -0.19285896f, -0.32289702f, -0.11175767f, 0.26172292f, 
    -0.01142248f, 0.07279991f, -0.19153905f, 0.14129524f, 0.01756272f, 0.06840232f, 0.00225937f, -0.07986210f, 
    -0.28396276f, 0.00951104f, -0.04417236f, 0.16022040f, 0.05884039f, 0.06494714f, 0.26970962f, 0.01395944f, 
    0.04933348f, 0.00055418f, 0.11178629f, 0.25515479f, -0.37753007f, 0.02638552f, -0.09897259f, -0.03552901f, 
    -0.04318967f, 0.06780861f, -0.05481968f, -0.05180892f, 0.14737871f, 0.12486072f, 0.13699624f, 0.13791341f, 
    0.10171541f, 0.08140375f, 0.02134559f, 0.29857296f, -0.19153160f, 0.03445978f, -0.02151003f, 0.11135833f, 
    0.12996681f, 0.05142159f, -0.06120810f, -0.04640261f, -0.22475454f, 0.57247084f, 0.16267350f, 0.21335971f, 
    0.15570603f, -0.17476682f, 0.03933948f, -0.07019220f, -0.08255103f, 0.00888728f, -0.00508685f, 0.02404679f, 
    0.21980080f, 0.02030818f, 0.25315204f, -0.17976606f, -0.06217785f, -0.01050769f, 0.00275059f, -0.06872227f, 
    -0.01455551f, 0.01260923f, -0.08737603f, -0.06780878f, 0.10925158f, 0.09396841f, -0.17857733f, -0.56684792f, 
    0.05845769f, -0.02783171f, 0.06204863f, 0.01236058f, -0.01018709f, 0.16656923f, 0.17957982f, 0.23612143f, 
    -0.17335682f, -0.21175553f, -0.07604730f, -0.03672435f, 0.00597202f, 0.08844765f, 0.10800720f, 0.01639288f, 
    -0.01536689f, 0.02086115f, -0.01290941f, 0.09561104f, -0.03524690f, 0.02510902f, 0.19165795f, -0.12574579f, 
    0.17588890f, 0.04748123f, 0.10956828f, 0.11925867f, -0.07355420f, -0.00488252f, 0.05638884f, 0.19429532f, 
    -0.27671811f, -0.20264795f, -0.09032260f, 0.15570541f, -0.08619604f, 0.08149744f, 0.09395237f, -0.07333215f, 
    0.20439889f, 0.20887502f, 0.12581392f, -0.21722274f, -0.33464855f, -0.14140901f, 0.13790955f, -0.02668842f, 
    -0.23577860f, -0.02334680f, -0.10623522f, -0.00108046f, -0.13285346f, -0.03789881f, -0.02873405f, -0.04561339f, 
    -0.17276321f, -0.20480427f, -0.21732169f, -0.07688148f, 0.15396698f, 0.04274837f, 0.09310310f, 0.03682791f, 
    -0.03312146f, -0.13855691f, -0.11631833f, -0.22448319f, -0.34595305f, -0.09988450f, 0.00787980f, 0.04869903f, 
    0.19355823f, -0.00667046f, 0.13467774f, 0.12225246f, 0.19676298f, 0.01829371f, -0.05974828f, 0.02491354f, 
    -0.14648224f, 0.81117713f, -0.10916924f, 0.05261756f, 0.03494226f, -0.03785458f, -0.03275774f, 0.04268744f, 
    -0.06307447f, 0.05499790f, 0.06773439f, 0.15504906f, -0.01840393f, 0.32598570f, -0.19305080f, -0.45629379f, 
    0.09942915f, -0.03258040f, 0.03629556f, -0.11352835f, 0.01155357f, -0.15835394f, 0.04109670f, 0.18270709f, 
    -0.02578738f, -0.15593944f, -0.06245103f, 0.18458067f, 0.11653482f, 0.16727521f, 0.02628963f, 0.10620397f, 
    0.01315138f, -0.02276455f, -0.02698447f, -0.03054976f, 0.22386734f, -0.12630010f, 0.17232580f, 0.04229501f, 
    0.10885435f, 0.21178666f, 0.14584221f, 0.13391910f, -0.08924679f, 0.24459885f, -0.07331327f, -0.24912165f, 
    0.01505543f, 0.12769057f, 0.03003954f, -0.08717161f, -0.09978522f, -0.04661664f, -0.05826961f, -0.14973211f, 
    0.01696074f, 0.10697832f, 0.12720828f, 0.10662848f, -0.04064301f, 0.45353916f, 0.01313534f, 0.24880981f, 
    -0.06066085f, -0.01702942f, 0.04224148f, 0.05498294f, -0.04808392f, 0.11236558f, 0.28876230f, -0.00661878f, 
    0.06141345f, 0.22900012f, -0.18229951f, -0.02906314f, 0.02559925f, -0.11774409f, -0.05318458f, -0.05654240f, 
    -0.25151658f, 0.10540106f, 0.02739975f, -0.05164881f, 0.35975420f, -0.14042120f, -0.04080451f, 0.06781473f, 
    0.24622297f, 0.09723637f, 0.10679994f, 0.05827286f, 0.03939934f, -0.06900654f, 0.00308444f, 0.26611081f, 
    -0.01801917f, -0.16500638f, -0.12161364f, -0.04760326f, 0.11842923f, -0.14144726f, -0.17035507f, -0.07856173f, 
    0.12496460f, 0.19582848f, 0.17145276f, 0.13062689f, -0.26424941f, 0.18484837f, 0.25611377f, -0.13296163f, 
    0.00325179f, -0.07236095f, -0.01975632f, 0.21005906f, -0.13008790f, 0.03577125f, 0.10595679f, 0.13378218f, 
    -0.25800955f, -0.00828817f, -0.15236780f, -0.21931680f, -0.02681279f, 0.05190855f, -0.07074329f, -0.05816527f, 
    0.07190497f, 0.11781973f, 0.12128312f, 0.13591234f, -0.06146831f, 0.02042275f, 0.06542481f, 0.15306848f, 
    0.14369953f, 0.04629794f, 0.08239913f, 0.05236522f, 0.09579508f, -0.01468465f, -0.05921590f, -0.01462563f, 
    0.22723453f, 0.27234724f, 0.06796122f, -0.25750130f, -0.03478291f, -0.09932273f, -0.08984603f, 0.10434823f, 
    -0.11840204f, 0.00237988f, -0.02739099f, -0.16514175f, 0.42111379f, 0.02309852f, 0.00885869f, -0.03103742f, 
    0.00835122f, -0.11680335f, 0.06885908f, 0.00787711f, 0.08156975f, 0.09606047f, 0.07218274f, 0.06034521f, 
    0.10150800f, 0.00395265f, 0.01772845f, -0.17110693f, -0.11246476f, -0.11246900f, -0.06141772f, 0.05300557f, 
    -0.10149767f, -0.18613431f, 0.13832350f, -0.09192897f, -0.10194819f, 0.00786561f, 0.06463054f, 0.03766586f, 
    -0.17624953f, -0.04176369f, -0.08292893f, 0.07593805f, -0.11516647f, 0.03036946f, -0.10070439f, -0.06684804f, 
    -0.07915806f, -0.37101057f, -0.08193026f, -0.08248794f, 0.02568205f, 0.07541407f, -0.10712194f, 0.07534513f, 
    0.08104637f, 0.14023028f, -0.00561300f, -0.03808010f, 0.02237769f, -0.08560582f, 0.08944750f, -0.04207509f, 
    -0.22434244f, 0.01575181f, -0.12389243f, 0.02736078f, 0.11104940f, 0.01810133f, 0.08372968f, -0.02053638f, 
    0.00876842f, 0.11858962f, 0.26407877f, 0.11052665f, 0.06111510f, 0.10624518f, -0.01305423f, 0.06165323f, 
    -0.00022643f, 0.09933420f, 0.17233537f, -0.00541254f, -0.03694494f, -0.19389935f, -0.11661889f, -0.06198802f, 
    0.12883921f, 0.08926179f, 0.05002389f, -0.07734656f, -0.00621172f, -0.12801093f, -0.07541366f, 0.02131541f, 
    0.13839139f, 0.08393499f, 0.49286330f, -0.32689294f, -0.02353929f, -0.11209747f, -0.04305749f, 0.15262911f, 
    0.05306403f, 0.25467938f, 0.07818346f, 0.01342515f, 0.37039718f, -0.16799644f, 0.01784577f, -0.07142187f, 
    0.10198826f, -0.02732457f, -0.05235261f, 0.02635551f, 0.01943167f, -0.01838090f, -0.05176313f, -0.12097554f, 
    -0.09575402f, -0.11660788f, -0.07000467f, -0.41682500f, 0.13983105f, -0.08736389f, 0.18986587f, 0.09279461f, 
    -0.08866191f, 0.03354389f, 0.07419458f, -0.04488585f, -0.08518481f, -0.64556915f, 0.03741390f, 0.00195083f, 
    0.09212036f, 0.23251396f, -0.12114092f, 0.04405054f, -0.02953816f, 0.01935496f, 0.05003964f, -0.07347624f, 
    -0.09182418f, -0.14800546f, -0.22019123f, 0.25535366f, 0.13883263f, -0.00914161f, 0.13382266f, -0.05077194f, 
    0.02375457f, -0.13488692f, -0.12145407f, 0.02645760f, 0.03638113f, 0.14355275f, 0.52431363f, 0.53634101f, 
    0.04689783f, -0.08258811f, 0.02086315f, -0.14959066f, 0.17166926f, -0.01840496f, -0.01249187f, 0.03800458f, 
    0.01946784f, 0.17470165f, 0.18972315f, -0.16977593f, -0.04465267f, 0.01390013f, 0.06050009f, 0.40400964f, 
    0.06023201f, 0.06402269f, -0.00254010f, -0.18071090f, -0.26041326f, -0.02847280f, 0.02389046f, 0.07370677f, 
    -0.14466129f, 0.05799671f, -0.07227097f, 0.09062894f, 0.17165059f, -0.06324600f, 0.09611801f, -0.05738977f, 
    0.08772460f, 0.17016745f, 0.21452552f, -0.53811681f, -0.00063997f, -0.12269137f, 0.03053565f, -0.00834458f, 
    0.10403251f, -0.05132875f, -0.02366943f, -0.03356073f, 0.14968321f, -0.22421575f, -0.23973277f, 0.07979374f, 
    0.21474102f, 0.23476993f, 0.21145838f, -0.02386399f, -0.00388164f, -0.10695767f, -0.03652813f, 0.06459279f, 
    -0.08784548f, 0.30519778f, 0.24616775f, -0.15628651f, 0.00325411f, -0.01048151f, 0.12267852f, 0.13477018f, 
    0.01122272f, 0.13250346f, 0.07164401f, 0.05709706f, 0.19466715f, -0.12156540f, 0.31274617f, -0.22395685f, 
    -0.17487405f, -0.02262761f, -0.14161119f, 0.01877972f, -0.00308165f, 0.17365941f, -0.06002578f, 0.17768465f, 
    0.23601729f, -0.46927458f, 0.16406050f, -0.03841419f, -0.02486672f, 0.07545403f, -0.00719942f, 0.14612696f, 
    0.29661459f, 0.13595898f, -0.04136029f, -0.04037806f, -0.01159805f, -0.23119633f, 0.33424157f, 0.61329597f, 
    -0.10911944f, -0.02828514f, -0.04792023f, 0.06169755f, 0.06636360f, 0.05391319f, -0.04245801f, -0.05479570f, 
    0.26956895f, 0.21550991f, 0.02550427f, -0.12541512f, -0.12129546f, -0.15522897f, 0.07896391f, -0.15680519f, 
    0.09331632f, 0.00610857f, -0.30153593f, -0.14481057f, -0.23887895f, 0.52565491f, -0.37266809f, -0.05843415f, 
    -0.10805136f, -0.09106986f, 0.06968331f, -0.01202411f, 0.09012973f, -0.02930743f, 0.07872913f, 0.06119509f, 
    0.00784673f, -0.17248428f, -0.09780598f, 0.03441546f, 0.17247443f, 0.08927865f, 0.05818572f, -0.03703123f, 
    -0.04886142f, -0.05854292f, -0.14090756f, -0.03516477f, 0.20086405f, -0.50896454f, 0.12217324f, -0.19564597f, 
    0.11400200f, -0.06765038f, 0.02542347f, -0.02280477f, -0.00837462f, 0.05175433f, -0.01162586f, 0.14728233f, 
    0.22222099f, 0.04130371f, 0.07551757f, 0.21068178f, -0.00164848f, 0.01244143f, -0.10038920f, 0.01349528f, 
    0.13274570f, -0.07478220f, 0.13324997f, -0.00016237f, -0.40915269f, 0.10893792f, -0.18329927f, -0.00175724f, 
    -0.14876735f, 0.10698660f, 0.02366731f, 0.00460240f, 0.05750648f, 0.09428481f, 0.12554699f, -0.04500316f, 
    -0.05311143f, -0.09039424f, 0.01355414f, -0.10040779f, -0.13492039f, 0.13617983f, 0.02538903f, 0.00884985f, 
    0.09953356f, -0.05844518f, -0.17901513f, 0.03754005f, 0.33180794f, 0.11911298f, -0.45899105f, 0.00118328f, 
    0.09882664f, 0.02249407f, 0.36650079f, -0.07551856f, 0.17417037f, -0.05124171f, -0.17908566f, 0.09752485f, 
    0.22447035f, 0.33864081f, 0.37572780f, 0.38010645f, -0.00398407f, -0.14421530f, -0.07458143f, -0.15890479f, 
    -0.02188333f, 0.01575165f, 0.11411450f, 0.06563089f, -0.23814434f, -0.29471496f, 0.09641919f, -0.22144119f, 
    0.11559817f, 0.09737428f, 0.04341777f, 0.05107734f, 0.00001057f, -0.00684593f, 0.14165162f, -0.03257221f, 
    0.01220889f, -0.24406502f, 0.07332107f, 0.29502308f, 0.08706379f, 0.09149550f, 0.11134467f, 0.00860841f, 
    0.01564111f, -0.15458216f, 0.04221464f, 0.07422671f, -0.15555057f, 0.02541794f, 0.16998765f, 0.36175913f, 
    0.04830367f, -0.09682918f, -0.02575620f, -0.01928497f, 0.04086187f, -0.10889711f, -0.01171326f, -0.08993735f, 
    0.28479627f, 0.20756194f, 0.22409540f, 0.38395923f, 0.00656943f, -0.04084862f, -0.05986933f, -0.04784364f, 
    0.02344628f, 0.00690736f, -0.02532681f, 0.12763585f, 0.20882995f, -0.14677288f, -0.10638589f, 0.06314555f, 
    0.13627087f, -0.01284611f, 0.06121118f, 0.03712264f, 0.11274751f, -0.10549064f, 0.04065868f, 0.04116230f, 
    0.14744578f, 0.60354465f, 0.17337611f, -0.00973595f, -0.10374746f, -0.22670536f, -0.11418061f, -0.19857275f, 
    0.09403835f, -0.04286204f, 0.17838642f, 0.08017599f, 0.01117211f, -0.03185626f, -0.11714643f, 0.05035400f, 
    0.05521622f, -0.00302363f, 0.17165907f, -0.10269844f, 0.00899686f, -0.01815225f, -0.02316032f, 0.04362499f, 
    -0.00270460f, 0.13503873f, -0.14948732f, 0.00432277f, 0.04719982f, -0.02391730f, 0.16587776f, 0.02237681f, 
    0.06468637f, 0.04067217f, -0.05565355f, -0.12845488f, -0.10108980f, 0.18419673f, 0.22368258f, -0.15781656f, 
    -0.01991295f, 0.05047832f, 0.17453726f, 0.10787529f, -0.00809859f, 0.08655290f, -0.05782662f, -0.06015673f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03336906f, -0.00723838f, 0.01091945f, 0.00349115f, 0.09585351f, 0.08161063f, -0.01135003f, 0.11281638f, 
    0.21348615f, -0.05172484f, 0.00927914f, 0.07887992f, 0.03125350f, -0.06322229f, -0.05076903f, 0.10207349f, 
    0.26383972f, -0.02793252f, -0.05335863f, 0.07430584f, 0.00659093f, 0.00725926f, 0.13449913f, -0.00010733f, 
    0.10480431f, -0.17844880f, 0.09359307f, 0.17217867f, -0.04490288f, -0.00656087f, 0.06981141f, 0.18798459f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.22359382f, 0.11470386f, -0.14205761f, -0.13889082f, -0.57653940f, 0.01826186f, -0.13732341f, 0.39644963f, 
    -0.32058769f, 0.16787140f, 0.10461092f, 0.00947841f, 0.01123690f, 0.27734411f, 0.11382681f, 0.13843884f, 
    -0.27894408f, 0.14569712f, -0.10075531f, -0.21201135f, 0.01057658f, -0.06314477f, -0.14756626f, -0.02682408f, 
    -0.02342846f, 0.43169028f, -0.52077043f, -0.54606956f, 0.00916649f, -0.63503271f, -0.37269515f, -0.08762347f, 
    0.19389027f, 0.07579026f, -0.05025762f, -0.13170303f, 0.00715676f, -0.06760824f, -0.17175542f, 0.04217513f, 
    -0.32251883f, 0.21705094f, -0.13662678f, -0.34006330f, 0.12773275f, 0.20880535f, -0.16789567f, 0.22936219f, 
    -0.28444517f, -0.14789675f, 0.04865171f, 0.23634769f, -0.92142761f, 0.10855447f, 0.43095276f, 0.13857681f, 
    0.21459903f, -0.61076087f, 0.12544081f, 0.34952137f, 0.11928001f, -0.36227903f, -0.25414467f, -0.03364960f, 
    -0.19132861f, -0.05787249f, 0.08720440f, -0.16635625f, 0.21696444f, 0.40620801f, 0.09977128f, -0.32125089f, 
    0.51005280f, -0.81263751f, 0.10219409f, -0.16942035f, 0.19028758f, 0.15875648f, 0.11589288f, 0.24705018f, 
    -0.20527755f, -0.06141961f, 0.11204081f, -0.49075022f, -0.21578249f, 0.04787133f, -0.13987526f, -0.15176786f, 
    0.09167974f, -0.14127475f, -0.49123344f, -0.04047734f, -0.13719551f, 0.49996093f, -0.30505964f, 0.19335188f, 
    -0.17385690f, 0.14757729f, -0.00523848f, 0.11332688f, -0.14262788f, 0.28048208f, -0.11374039f, -0.16799586f, 
    -0.57359159f, 0.07269625f, 0.05593977f, 0.03077896f, 0.18075539f, 0.06678982f, -0.15564190f, 0.10479625f, 
    -0.23068658f, 0.13147961f, -0.06557071f, -0.05566739f, -0.03379685f, 0.12153505f, -0.55135083f, -0.09729156f, 
    -0.16971935f, 0.15611567f, -0.05080139f, -0.02445114f, -0.01437204f, 0.52208900f, 0.43902230f, -0.48796576f, 
    0.10443904f, -0.08505511f, 0.10200719f, -0.10723914f, 0.02072010f, -0.02452462f, 0.05025079f, -0.00220320f, 
    0.10111175f, 0.14864728f, -0.05427878f, 0.28076196f, -0.59203440f, 0.07575142f, 0.05123855f, -0.31311443f, 
    -0.72383016f, -0.02401605f, -0.16489291f, 0.03963823f, 0.36496615f, 0.24578899f, -0.40793517f, 0.08173557f, 
    -0.05829116f, 0.02948135f, 0.22127584f, -0.11561467f, 0.12605624f, 0.09447817f, -0.54912299f, 0.05576519f, 
    -0.21252677f, 0.13570516f, 0.15484312f, -0.07631000f, -0.36850065f, -0.50314218f, -0.00740774f, 0.18741101f, 
    0.53985608f, -0.07991666f, -0.06752273f, 0.20730688f, -0.23391286f, 0.14615685f, -0.16689433f, 0.21421069f, 
    -0.02961912f, 0.12514092f, -0.04706122f, 0.09695615f, 0.30349892f, 0.21271993f, -0.01415398f, -0.09111263f, 
    -0.04297295f, -0.54891968f, 0.14139666f, -0.32559621f, -0.13163076f, -0.65233600f, 0.30646098f, 0.05934830f, 
    0.27848512f, 0.06241188f, 0.11092253f, 0.07513174f, 0.02745715f, 0.06883044f, -0.17580533f, -0.49678358f, 
    -0.12978218f, -0.73453039f, -0.07561303f, 0.32845080f, -0.47958165f, -0.00958019f, 0.09294443f, -0.55160946f, 
    0.26843694f, -0.14238153f, -0.06587083f, -0.06210094f, -0.30123493f, -0.70356041f, 0.04035924f, -0.13261516f, 
    -0.07656890f, -0.27471131f, -0.47820303f, 0.07654407f, 0.09120387f, 0.34036714f, 0.15011695f, 0.27516681f, 
    -0.39462155f, -0.12673515f, -0.10850032f, -0.01739924f, 0.08289316f, -0.61984783f, -0.15239291f, 0.10097855f, 
    -0.29930511f, -0.50547481f, -0.11542078f, -0.51533508f, 0.32030952f, -0.00739972f, -0.12042008f, -0.44283780f, 
    -0.09987003f, 0.10245731f, -0.17932761f, -0.38836986f, 0.43119088f, -0.47800776f, 0.26244086f, 0.08691139f, 
    -0.18264385f, 0.44983077f, 0.28879502f, -0.15668158f, -0.08587361f, 0.22593360f, 0.21267112f, 0.03372309f, 
    -0.11290511f, -0.13786837f, 0.14352383f, -0.11107688f, -0.25821519f, 0.39352924f, -0.09877635f, 0.37157980f, 
    0.25607485f, -0.09073427f, -0.03818417f, -0.60199147f, 0.21024793f, -0.33576095f, 0.00777324f, 0.10120635f, 
    0.44112763f, 0.08149613f, 0.14537333f, 0.13127211f, -0.41315088f, -0.70990634f, 0.12763149f, 0.14893126f, 
    -0.10778594f, -0.27519482f, 0.09927779f, -0.27613917f, -0.16142994f, -0.28855598f, 0.30749872f, -0.24326934f, 
    -0.47046944f, 0.10850925f, -0.05625772f, -0.05417880f, 0.08830574f, -0.42281598f, -0.12041947f, -0.15478940f, 
    -0.00952120f, 0.16796085f, 0.05828387f, 0.02515603f, -0.43834588f, -0.52732551f, -0.11848997f, 0.43570796f, 
    0.08390331f, 0.09268537f, -0.17144114f, 0.18540847f, 0.41533887f, -0.08396342f, 0.02604016f, -0.17453443f, 
    -0.39385083f, 0.25108773f, -0.37650484f, 0.21128134f, -0.03218233f, 0.14674461f, -0.61434603f, 0.37312531f, 
    0.46884716f, -0.14025803f, -0.12270571f, 0.13349591f, 0.10930374f, 0.15311448f, 0.00403955f, 0.42476854f, 
    -0.33249691f, -0.67122626f, 0.01918516f, 0.21415582f, 0.24040030f, -0.69271541f, -0.05744402f, -0.15492569f, 
    -0.38414940f, 0.02495198f, 0.01266397f, 0.34454292f, -0.17238928f, 0.36359060f, -0.04264338f, -0.14925939f, 
    -0.55866212f, -0.64582646f, -0.04262803f, -0.16054848f, -0.15956441f, 0.04580237f, -0.07538284f, -0.09418500f, 
    0.35984966f, -0.14383544f, -0.09526779f, 0.08567457f, 0.43591318f, 0.32899758f, 0.00313050f, -0.63264120f, 
    0.01225614f, -0.28929478f, 0.05948636f, -0.26901463f, 0.26804113f, -0.00026321f, 0.16725804f, -0.64077711f, 
    -0.09295806f, -0.01789463f, -0.13278984f, 0.15587367f, 0.11139075f, -0.04685981f, -0.33983675f, 0.15338416f, 
    0.31525311f, 0.15338576f, -0.21879207f, 0.31322354f, -0.09039544f, -0.65941775f, 0.34370929f, -0.24522109f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.30345288f, 0.29220468f, 0.10763638f, -0.12515356f, -0.11267646f, 0.08747374f, 0.09876043f, -0.31253409f, 
    0.23140143f, -0.17364998f, -0.14237504f, -0.11167466f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
