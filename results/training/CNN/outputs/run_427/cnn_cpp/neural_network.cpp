#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17923461f, 0.33636537f, 0.43310398f, -0.22166826f, -0.38579541f, -0.18130946f, -0.31900898f, -0.54301298f, 
    -0.39525202f, 0.14322565f, 0.19581063f, -0.23775971f, -0.23094063f, -0.07956521f, -0.00021404f, 0.10603031f, 
    -0.47561389f, -0.06745431f, 0.03106802f, -0.16838348f, -0.10488364f, 0.20792507f, 0.27179664f, -0.19102299f, 
    0.16598415f, 0.42090085f, 0.54525423f, 0.27542138f, 0.41837183f, 0.46595874f, -0.51092350f, -0.38623944f, 
    0.21030529f, -0.19600624f, 0.25195459f, 0.10233784f, 0.13489306f, 0.12240398f, 0.07268604f, 0.13860761f, 
    -0.26152253f, 0.13150071f, -0.03463519f, 0.09654634f, 0.14232011f, 0.27642500f, 0.18471360f, -0.03541398f, 
    0.05671661f, 0.03622028f, -0.85184479f, 0.79704690f, -0.22116074f, -0.65778083f, 0.19107491f, 0.31998873f, 
    -0.21714082f, -0.07081556f, 0.35024515f, -0.28709534f, -0.04257863f, 0.14422618f, -0.29611772f, 0.04248965f, 
    0.04703249f, 0.05036829f, -0.00307775f, -0.00177915f, -0.29200482f, -0.27320948f, 0.06848384f, 0.07299328f, 
    0.08591028f, -0.03494244f, 0.06869408f, -0.45465243f, -0.75387269f, -0.66515744f, 0.09067746f, -0.11198931f, 
    0.09663063f, 0.38521767f, 0.25049251f, 0.27497211f, 0.35569388f, -0.24542511f, 0.26609510f, -0.20035326f, 
    0.17840178f, -0.36269665f, 0.03712219f, 0.45246559f, 0.13321096f, -0.32240722f, -0.06618514f, -0.15096648f, 
    -0.11215078f, -0.48266619f, 0.13575672f, 0.11772202f, -0.19367017f, -0.43993840f, -0.33392715f, -0.36745429f, 
    -0.20953332f, -0.10988997f, -0.57210135f, -0.12198321f, -0.00393737f, -0.31419015f, -0.29041785f, 0.00883626f, 
    0.08408269f, -0.11580528f, -0.37285995f, 0.12957801f, 0.15691316f, 0.02703994f, 0.00187557f, 0.35384113f, 
    0.01779242f, -0.13832413f, -0.13196644f, 0.24754922f, -0.26169413f, -0.05216439f, -0.26560652f, -0.19390728f, 
    0.32855779f, -0.03546910f, -0.44898009f, -0.14174967f, 0.18987490f, -0.51762515f, -0.33162755f, -0.13793227f, 
    0.00611624f, 0.20556998f, 0.29528859f, -0.09077481f, -0.04954755f, -0.03235332f, 0.20272540f, -0.00324074f, 
    0.04604201f, -0.07744328f, 0.22025494f, -0.17159730f, 0.29719159f, -0.08857017f, -0.15524060f, -0.53662652f, 
    -0.44536856f, -0.42426276f, -0.05885225f, -0.08284255f, -0.23229964f, -0.04286671f, -0.13517801f, -0.03124673f, 
    0.00501152f, -0.10400359f, -0.09967066f, -0.03688740f, -0.03158860f, 0.16888677f, 0.11293361f, 0.16149665f, 
    0.08324555f, -0.22773008f, -0.25736973f, -0.38780218f, 0.18347825f, 0.26665357f, 0.15548362f, 0.63303542f, 
    -0.10438427f, -0.39210626f, 0.43730327f, -0.12055200f, 0.22507021f, 0.16307044f, -0.37933090f, 0.21941929f, 
    0.34577245f, -0.06957144f, -0.12866436f, -0.03464729f, -0.02267894f, 0.02622630f, 0.12227361f, 0.06732133f, 
    -0.00755372f, 0.12157042f, 0.26622829f, 0.15534341f, -0.11461110f, 0.36176923f, -0.33826607f, -0.35602677f, 
    0.29205015f, 0.44250280f, -0.09743986f, -0.73939610f, 0.48540354f, -0.08932485f, 0.38979781f, 0.18063042f, 
    -0.28256848f, 0.28748825f, 0.30003360f, -0.16033857f, 0.12702586f, -0.11549206f, -0.11803796f, -0.15986036f, 
    0.25258964f, 0.11290200f, 0.12984310f, -0.26554129f, 0.26861033f, 0.13848217f, 0.23354700f, 0.02386366f, 
    -0.06335082f, -0.68530738f, 0.01257224f, -0.03263186f, -0.40645614f, -0.38001266f, 0.54497492f, 0.66671354f, 
    -0.10903753f, 0.33982226f, 0.47485805f, 0.24887736f, 0.02180097f, -0.02150262f, -0.32094607f, -0.05128269f, 
    0.04837814f, 0.11156116f, 0.16733521f, -0.04636215f, 0.03508651f, -0.19503990f, 0.12259348f, -0.15159340f, 
    0.19115478f, -0.13266860f, 0.50205570f, -0.28762925f, -0.46334672f, -0.27405432f, 0.07801730f, -0.29927579f, 
    0.51594931f, 0.18210007f, -0.14462799f, 0.28587541f, 0.11814351f, 0.33094245f, -0.16639180f, -0.07990501f, 
    0.24796546f, -0.32583779f, -0.29026031f, -0.34447750f, 0.10102316f, 0.04541110f, -0.04628036f, 0.34102997f, 
    -0.20781134f, -0.21517493f, -0.16825286f, 0.15223755f, -0.18513617f, -0.04043088f, 0.51675743f, 0.49509004f, 
    -0.57607442f, 0.22947896f, -0.29297522f, 0.53169304f, -0.35444164f, 0.22219393f, -0.01184914f, -0.19555220f, 
    -0.07951682f, 0.12315824f, 0.19291084f, -0.00814952f, -0.09524579f, 0.08998322f, 0.20128228f, 0.18619733f, 
    0.10623121f, -0.04776432f, -0.07482523f, 0.11082037f, 0.35478196f, 0.52478904f, 0.43790874f, 0.41948164f, 
    0.22197588f, 0.18661626f, 0.16779555f, -0.03437358f, -0.08536976f, 0.10558131f, -0.01953325f, 0.19674551f, 
    -0.23593545f, 0.21946514f, 0.21868040f, -0.08919518f, -0.00850942f, 0.08413586f, 0.15529889f, -0.07692997f, 
    -0.23622136f, 0.06723034f, -0.29206973f, -0.06298711f, 0.29638994f, 0.19447951f, 0.55960059f, 0.35582563f, 
    0.57975322f, 0.53498882f, 0.23785099f, -0.18358019f, 0.26339889f, -0.22871804f, 0.03112768f, -0.09061836f, 
    0.13029931f, 0.00626909f, -0.03330800f, -0.09390594f, 0.14489454f, 0.01032717f, -0.05003438f, 0.20904186f, 
    0.24777351f, -0.14183776f, -0.35900468f, -0.02360487f, -0.09473245f, -0.07507355f, 0.75252098f, 0.11499385f, 
    -0.48478964f, 0.18838583f, -0.34758526f, -0.04460954f, 0.09727805f, -0.04974212f, 0.40241900f, 0.18059921f, 
    -0.30383506f, 0.15019046f, -0.21072075f, 0.22170211f, 0.25058627f, -0.10930765f, -0.01110587f, 0.04752832f, 
    -0.14370506f, -0.15460853f, 0.16295122f, -0.04152229f, -0.16704471f, -0.12553449f, 0.05089293f, 0.66506332f, 
    -0.38729814f, 0.32777348f, 0.33414125f, 0.41237095f, 0.16921033f, -0.16998559f, 0.39117283f, -0.27136099f, 
    -0.38257927f, -0.19032896f, -0.16504396f, -0.13734946f, 0.52650642f, -0.09845722f, 0.30167544f, -0.05240094f, 
    0.33249745f, 0.00609317f, -0.38897276f, 0.00842576f, -0.28959289f, 0.01300185f, -0.07679238f, 0.05926333f, 
    -0.02892699f, -0.66229820f, -0.09052391f, 0.43755689f, -0.42293441f, -0.34322068f, 0.34957364f, 0.42547128f, 
    -0.01870150f, -0.11689407f, 0.25929916f, -0.25428629f, -0.34344184f, -0.03821860f, -0.10506664f, -0.27618656f, 
    -0.12596844f, 0.25487530f, 0.14431649f, -0.18412904f, -0.12989655f, -0.12634254f, 0.29788345f, 0.25707746f, 
    0.09820101f, -0.24830528f, -0.01278207f, -0.44697610f, -0.57317424f, 0.25874478f, -0.14105259f, 0.70923668f, 
    0.33117157f, -0.26199496f, -0.14114884f, -0.21683910f, -0.09895044f, -0.03703373f, 0.08791206f, -0.03735146f, 
    -0.00901102f, -0.07411791f, 0.18063296f, 0.17843521f, -0.02060962f, 0.05302592f, -0.17700978f, -0.21225938f, 
    -0.20185791f, 0.11106121f, -0.45805880f, 0.19281539f, -0.07198671f, -0.39157936f, 0.07540426f, 0.01040840f, 
    -0.02520940f, -0.46611539f, -0.12981606f, 0.25397474f, 0.04116151f, -0.24415277f, -0.37714565f, 0.18776749f, 
    -0.15948077f, -0.18322498f, -0.10604983f, -0.47444686f, 0.12531386f, 0.13354577f, -0.05603959f, 0.34986356f, 
    -0.08570161f, 0.17069362f, -0.29167330f, -0.18175620f, -0.23029974f, -0.45409250f, -0.58115077f, 0.11300230f, 
    -0.14890026f, 0.35026419f, 0.42975080f, 0.05472847f, 0.19276778f, -0.09532635f, -0.12176225f, -0.00290341f, 
    0.17780232f, -0.02110158f, 0.16581154f, -0.20533414f, -0.40091676f, 0.28947574f, 0.15385798f, 0.28926879f, 
    0.09458201f, 0.44703382f, -0.06754585f, 0.25408447f, -0.11233598f, -0.06246410f, -0.13907471f, -0.27797320f, 
    0.54467648f, 0.15252776f, -0.21461146f, -0.47759244f, 0.20206177f, -0.69151545f, -0.18962924f, -0.06254493f, 
    0.28119376f, 0.17834871f, -0.09598112f, -0.14621691f, 0.04295137f, -0.18552659f, -0.20686811f, 0.17393194f, 
    -0.37062705f, -0.16553558f, -0.14535856f, 0.30847833f, 0.28650647f, 0.61432630f, -0.13429047f, 0.33775559f, 
    0.41615814f, -0.04615240f, 0.32573608f, 0.33185661f, 0.02337742f, -0.14825238f, 0.29104280f, -0.14282556f, 
    0.27387995f, 0.23548339f, -0.02680388f, -0.28337142f, -0.08583696f, 0.09749250f, 0.07772645f, 0.08845620f, 
    -0.01658674f, -0.07210359f, 0.09476463f, 0.02604905f, -0.12793894f, -0.25618172f, 0.31234968f, -0.10716074f, 
    -0.23124631f, -0.55911261f, 0.16794915f, -0.44314399f, 0.39841554f, 0.07267430f, 0.13641690f, -0.45087770f, 
    0.01316961f, -0.27953202f, -0.09351800f, 0.02986067f, -0.47931606f, -0.10090748f, -0.08398569f, -0.21957274f, 
    -0.00386882f, 0.09871285f, -0.08312396f, -0.27770972f, 0.03894357f, -0.23225670f, -0.34486970f, 0.32874689f, 
    0.75748241f, 0.33908632f, -0.14996088f, -0.00201803f, -0.47626358f, -0.61211574f, -0.28698197f, -0.37296206f, 
    -0.28736484f, 0.18802594f, 0.38599357f, -0.02112137f, -0.04233025f, 0.29430702f, -0.12035593f, 0.07711490f, 
    -0.00472096f, -0.12581868f, 0.29532439f, 0.24724385f, 0.04639220f, -0.17660260f, 0.07739515f, 0.18508749f, 
    -0.31004557f, 0.43772873f, -0.45694664f, -0.41574815f, -0.61718875f, 0.59236139f, -0.22088863f, -0.16722539f, 
    -0.07219388f, 0.22174191f, -0.30305219f, 0.05523155f, -0.08485057f, 0.11307003f, 0.00150716f, 0.07603382f, 
    0.22421391f, 0.37842652f, 0.26146004f, 0.08500123f, 0.18048854f, -0.12294251f, -0.12452612f, -0.18374690f, 
    0.01779195f, -0.12642874f, 0.75311428f, 0.26318705f, -0.40114963f, -0.11031172f, -0.52050871f, -0.14649312f, 
    -0.56353319f, -0.29240450f, 0.20534743f, -0.15479012f, 0.11806688f, 0.17330043f, -0.01622272f, 0.14171873f, 
    -0.39904752f, -0.16937277f, 0.02672955f, -0.28437302f, -0.37458405f, 0.32777411f, -0.18181306f, -0.25569174f, 
    -0.10221579f, -0.09533271f, -0.12149955f, 0.14023809f, 0.09453339f, -0.44656828f, -0.33350164f, 0.06501227f, 
    0.30488506f, 0.12306941f, -0.23056433f, 0.16264813f, -0.01675619f, 0.06109762f, -0.27627671f, 0.23585132f, 
    -0.26110840f, 0.30419281f, 0.17518447f, 0.22199456f, 0.05439026f, -0.33328378f, -0.37940028f, -0.06055892f, 
    0.07656090f, -0.17738315f, 0.23255832f, 0.61113852f, -0.37111360f, -0.34771466f, 0.45428857f, 0.30961987f, 
    -0.65080333f, -0.34141624f, 0.13142319f, -0.00397102f, 0.12082146f, -0.01406734f, -0.16081178f, -0.04914639f, 
    -0.15518390f, -0.02208292f, 0.07206570f, 0.04730026f, -0.29232916f, -0.16639522f, 0.17191118f, -0.23139994f, 
    -0.08807129f, 0.24202493f, -0.24577032f, -0.02467435f, 0.83208972f, 0.16516057f, -0.27804500f, 0.52793205f, 
    0.68841594f, 0.03457947f, 0.17085581f, 0.25218123f, 0.45785332f, -0.45220131f, -0.29023597f, -0.27359056f, 
    -0.28557351f, -0.30519491f, -0.15038605f, 0.07245353f, 0.08816091f, 0.17757520f, -0.24957280f, -0.08607446f, 
    0.22644670f, 0.00619179f, 0.13528237f, -0.00915874f, 0.16389456f, 0.69230527f, 0.58075696f, 0.25578639f, 
    0.29967335f, -0.05026923f, -0.04735962f, 0.03450374f, -0.44050476f, 0.36211345f, -0.34963363f, -0.08222385f, 
    -0.15780327f, 0.05919109f, 0.30728436f, -0.43642130f, -0.12997265f, -0.21364361f, 0.04601464f, -0.06493166f, 
    0.00648634f, 0.26912841f, 0.25959480f, 0.11017765f, 0.09245460f, 0.10297541f, 0.32263845f, 0.41254711f, 
    0.70053071f, 0.30368158f, -0.32399914f, -0.02198626f, -0.45714113f, 0.22659588f, 0.13932993f, 0.52026480f, 
    0.36383218f, -0.26421508f, -0.00573958f, 0.22061858f, -0.32450685f, -0.08266275f, 0.34004021f, 0.08464612f, 
    -0.20699532f, -0.19254678f, -0.03795875f, 0.02427738f, 0.37659258f, -0.15232031f, -0.20713916f, 0.17106582f, 
    0.27920911f, 0.41842476f, 0.63760346f, 0.36047366f, -0.53747940f, 0.44594598f, -0.11041139f, -0.49738380f, 
    0.30283269f, 0.35110798f, -0.06784096f, -0.14559740f, 0.01819126f, -0.07505115f, -0.24968232f, -0.17449068f, 
    0.16317612f, 0.06675459f, -0.10219830f, 0.11095210f, 0.11678788f, 0.22718813f, 0.05124614f, 0.08262289f, 
    0.66565794f, 0.30110610f, -0.53191859f, -0.27423126f, 0.24256401f, -0.00272719f, 0.31736091f, 0.37748584f, 
    0.16971046f, 0.48881698f, 0.15633991f, -0.04360497f, 0.09347553f, -0.40304142f, 0.20613796f, 0.07305049f, 
    -0.01835735f, -0.02404615f, -0.31118813f, 0.08573679f, -0.08744302f, -0.09395485f, 0.13142426f, 0.17848860f, 
    -0.23372926f, -0.37542048f, -0.21616913f, -0.12242784f, 0.09134143f, 0.07154648f, -0.49311358f, -0.45934787f, 
    -0.29927695f, -0.29230195f, -0.29220888f, -0.28276092f, 0.19689111f, -0.03911098f, -0.14873095f, -0.29455313f, 
    0.01191778f, -0.10087656f, -0.33800486f, 0.06836292f, -0.01852043f, -0.26414305f, -0.00012195f, 0.05223624f, 
    0.34910402f, 0.37443060f, 0.02164397f, -0.31393960f, -0.42664790f, -0.61045533f, -0.16782950f, 0.31114087f, 
    -0.35195264f, -0.52177507f, -0.28240070f, -0.35722378f, -0.41395721f, 0.24058592f, 0.35405076f, 0.24092637f, 
    0.21730591f, 0.10662636f, 0.25606889f, -0.23194815f, 0.08567991f, 0.21613663f, 0.16792378f, -0.00821930f, 
    0.18528487f, 0.00227358f, -0.10665914f, -0.63258958f, -0.02556844f, -0.41593289f, -0.42627183f, -0.27772060f, 
    0.57046002f, 0.17000197f, -0.01930732f, 0.42563456f, 0.55168474f, -0.07243903f, -0.48039973f, 0.02823357f, 
    -0.21358012f, 0.21522725f, -0.02262799f, -0.12850656f, 0.11473458f, 0.11173345f, 0.02450266f, -0.03731000f, 
    -0.28078979f, 0.14331204f, 0.03697784f, 0.21265516f, -0.80619538f, 0.00858091f, 0.06360372f, -0.05992242f, 
    0.16164926f, 0.49419317f, 0.57944435f, 0.22722627f, -0.04713305f, 0.35484636f, -0.22411278f, -0.20760815f, 
    0.34434921f, 0.03648994f, 0.30221063f, -0.02648087f, 0.10393184f, -0.23054200f, 0.31862375f, 0.18105863f, 
    0.32473406f, -0.12129143f, -0.16732411f, 0.09085465f, -0.09370096f, -0.86344534f, 0.36941439f, -0.32956573f, 
    -0.47295949f, -0.23104246f, 0.30718741f, 0.29741684f, 0.22272487f, 0.22792661f, 0.30502272f, -0.05696145f, 
    0.07783966f, 0.19353354f, 0.09378465f, -0.10643321f, 0.12532544f, -0.06385917f, 0.06587720f, 0.00931069f, 
    -0.50487667f, 0.08764397f, 0.03038684f, 0.18567394f, -0.00383338f, 0.08180869f, 0.28047693f, 0.92145813f, 
    0.26931155f, -0.13618165f, -0.37302905f, 0.17976634f, 0.24956736f, 0.18577923f, -0.39721462f, 0.33306447f, 
    0.00023890f, 0.31200078f, -0.12518944f, -0.22473019f, -0.27484435f, -0.02654741f, -0.18972199f, -0.04324563f, 
    -0.08691277f, -0.12065788f, -0.15260160f, -0.11366662f, -0.14201996f, -0.17394871f, -0.16559471f, -0.46666101f, 
    0.13498370f, -0.04019468f, 0.17819138f, 0.10968378f, 0.40268207f, 0.64257234f, -0.50003856f, -0.27636296f, 
    0.00266864f, -0.08711354f, 0.43256819f, 0.26698440f, 0.31805342f, 0.00151783f, 0.13574199f, 0.13281545f, 
    -0.22227372f, 0.15444499f, 0.40171191f, -0.08720572f, -0.00666739f, 0.19727382f, 0.07975467f, -0.05003016f, 
    -0.37001422f, -0.06492127f, -0.23073062f, -0.16754214f, -0.09031691f, -0.28251821f, -0.02064966f, -0.02689133f, 
    0.03082591f, -0.35246944f, 0.30551586f, 0.08624259f, -0.20396633f, 0.24604154f, -0.12889937f, 0.27284020f, 
    -0.15888093f, 0.04249377f, 0.42624345f, 0.21061035f, 0.02593143f, -0.04929832f, 0.25701571f, -0.17776079f, 
    0.35291564f, 0.04848512f, 0.05559517f, 0.45248199f, -0.16234489f, -0.42998630f, -0.50650948f, 0.04852292f, 
    -0.35533711f, -0.22603831f, -0.14170565f, 0.35817876f, 0.49401414f, -0.17355645f, -0.07607317f, -0.17547175f, 
    -0.02332817f, -0.12044403f, -0.25175720f, -0.20648514f, -0.09684572f, -0.01362160f, 0.16087574f, 0.21771353f, 
    0.22423817f, -0.07143585f, -0.54493099f, -0.18229197f, -0.10488432f, 0.40274796f, 0.08343516f, 0.41038555f, 
    0.30574653f, 0.30032909f, 0.30538383f, 0.39118993f, 0.14761332f, 0.12790009f, 0.24513537f, -0.19323415f, 
    -0.02814598f, -0.12204989f, -0.25708944f, -0.05312188f, -0.13824606f, 0.32812667f, 0.30540922f, 0.02595244f, 
    -0.20503934f, 0.10585257f, -0.47011024f, -1.00972891f, 0.68958437f, 0.30928233f, -0.08422396f, -0.51318914f, 
    0.37754765f, 0.59700471f, -0.58065212f, 0.20864439f, -0.06455580f, -0.00235001f, 0.02693549f, 0.37067905f, 
    -0.09782186f, 0.04956025f, -0.02952765f, -0.11219463f, 0.11375103f, -0.20307955f, -0.17872970f, -0.14448011f, 
    -0.15948679f, -0.10018773f, 0.10344758f, -0.01997952f, -0.07252259f, -0.13678080f, 0.11828335f, 0.14337525f, 
    -0.07833510f, -0.58038449f, -0.26618728f, -0.22509539f, -0.30492374f, 0.12904973f, -0.34676903f, 0.26934585f, 
    -0.35774654f, 0.01267637f, -0.15422904f, -0.22649385f, 0.14888111f, 0.09213251f, 0.05102898f, 0.06820136f, 
    0.10877947f, -0.03827616f, -0.08579294f, -0.17476292f, -0.14053239f, -0.09831948f, -0.31385636f, -0.25978991f, 
    -0.18127875f, 0.63945252f, -0.48409647f, 0.14526458f, 0.53754854f, -0.45632634f, -0.16160963f, -0.32529178f, 
    -0.04180069f, 0.16955221f, -0.07430530f, 0.18594758f, 0.17647652f, -0.31076893f, -0.04856828f, -0.13980931f, 
    0.13812910f, -0.03972487f, 0.03537418f, -0.02145461f, 0.16771257f, 0.22413749f, 0.05364999f, -0.23003443f, 
    0.13887671f, 0.17885080f, 0.18112190f, -0.52983373f, -0.54626429f, 0.27864900f, -0.14255016f, -0.37965739f, 
    0.23706357f, -0.17512958f, -0.12458272f, 0.26466712f, 0.01013305f, -0.07983558f, -0.21558224f, 0.03234407f, 
    -0.17978302f, 0.22084707f, -0.26281041f, -0.01274693f, 0.31550017f, -0.13907887f, -0.18336070f, 0.15497455f, 
    0.14214680f, 0.51007134f, 0.48784652f, 0.31992397f, 0.23953058f, -0.19689332f, -0.11325673f, 0.25728062f, 
    0.34378687f, 0.13446639f, 0.11253140f, -0.09343261f, -0.15294333f, -0.02353260f, 0.02554392f, -0.08127785f, 
    0.23036297f, 0.05482369f, -0.14301541f, 0.25157019f, 0.16663772f, -0.01496326f, 0.20442893f, 0.44277725f, 
    0.55054516f, 0.39297664f, 0.17320359f, 0.25140744f, 0.37594360f, 0.46469861f, -0.26912251f, -0.55392969f, 
    -0.38623959f, -0.41408929f, -0.16443299f, 0.05719658f, 0.13648002f, -0.02661174f, 0.16012938f, -0.07629564f, 
    0.01640902f, 0.06014955f, 0.31241280f, 0.07893835f, -0.01173189f, 0.21991308f, -0.21340685f, -0.03217572f, 
    0.05572847f, 0.80473566f, 0.18693383f, 0.70616400f, -0.44802752f, -0.07363978f, 0.05339327f, 0.15669863f, 
    0.12100478f, -0.07080395f, -0.27801180f, 0.00217441f, 0.40251935f, -0.28095102f, 0.33457172f, 0.03370322f, 
    -0.05283967f, -0.08136241f, -0.25826633f, -0.13642500f, -0.07477217f, -0.03604291f, 0.23109010f, 0.14145908f, 
    0.14953580f, -0.09486761f, 0.27245030f, 0.55529165f, 0.34707597f, -0.04131072f, 0.32871851f, 0.06059746f, 
    0.12079336f, 0.45762831f, -0.31111953f, -0.24230601f, -0.17331129f, -0.26154396f, -0.11034085f, 0.11921834f, 
    0.12431451f, 0.18839264f, 0.07068244f, -0.13690065f, 0.15363745f, -0.20801190f, -0.04672772f, -0.11064599f, 
    0.25472969f, -0.11528621f, 0.32395729f, 0.72140777f, 0.17218606f, 0.06711164f, -0.29615933f, -0.37985474f, 
    0.18933363f, 0.48383495f, 0.00012541f, 0.29549527f, 0.60768449f, -0.13724327f, 0.13028264f, -0.37031540f, 
    -0.16554524f, -0.23074308f, 0.01509649f, 0.13923593f, 0.02675648f, -0.21559948f, 0.09631644f, -0.08142592f, 
    -0.10072415f, -0.19465937f, -0.09928068f, 0.29305378f, -0.40217534f, -0.23994634f, -0.35671002f, 0.16463134f, 
    -0.10795103f, -0.54372370f, 0.37794030f, -0.21941304f, -0.39054230f, -0.11262334f, 0.33224311f, 0.24295703f, 
    0.28145149f, 0.06693638f, 0.18867943f, 0.08161342f, 0.22416903f, 0.15800211f, 0.23852274f, 0.01932909f, 
    0.08579201f, 0.28004891f, -0.36314473f, 0.09258591f, 0.12650767f, -0.20675482f, -0.52786410f, 0.60829818f, 
    0.47591162f, -0.29176861f, -0.46445039f, -0.19294159f, 0.60544634f, 0.13096897f, -0.19393107f, 0.05728150f, 
    0.04696356f, -0.02739200f, -0.12361069f, 0.01917269f, 0.26151016f, 0.13638024f, -0.01854557f, -0.18628857f, 
    -0.24690837f, 0.13161349f, 0.17314029f, 0.01778576f, 0.09813576f, -0.05603529f, -0.28086755f, -0.06619317f, 
    0.49318838f, 0.15563303f, -0.00864687f, 0.43214861f, 0.57339776f, 0.37734127f, 0.40124354f, 0.23000778f, 
    -0.51590127f, -0.37389660f, -0.46575552f, -0.11176752f, 0.04087913f, -0.19112727f, -0.22570838f, -0.14941391f, 
    -0.00545728f, -0.23328659f, 0.14634520f, -0.07648866f, -0.11480784f, -0.09825598f, 0.04052959f, 0.88087708f, 
    0.44303748f, -0.10546111f, 0.23063447f, 0.46167222f, -0.15901564f, -0.43466559f, -0.34181207f, -0.33143225f, 
    -0.01161596f, 0.10726751f, -0.04268866f, 0.14529704f, -0.03997440f, 0.17351450f, 0.06301267f, -0.25358745f, 
    0.22353603f, 0.25776899f, 0.07587600f, 0.03045018f, -0.07714545f, 0.03149752f, -0.11259307f, -0.15483971f, 
    -0.23881729f, -0.56171083f, -0.26604709f, 0.34000385f, -0.10786194f, -0.08281104f, 0.37341011f, 0.42861074f, 
    -0.34526846f, -0.25550699f, -0.22211471f, -0.06236336f, 0.26909772f, -0.22821222f, -0.25546372f, -0.30095452f, 
    -0.28815275f, -0.25727585f, -0.11167350f, -0.34605563f, -0.16183089f, 0.16195758f, 0.03594880f, -0.21272992f, 
    0.16768260f, -0.22320443f, -0.58116961f, -0.38792962f, -0.13355877f, 0.35569677f, 0.25268802f, 0.33137572f, 
    -0.07242426f, 0.06419631f, 0.47733644f, 0.07618479f, -0.24409813f, 0.16258852f, -0.13610545f, -0.09151012f, 
    -0.32763857f, -0.03046714f, -0.19561504f, 0.15128127f, -0.42717749f, -0.00686931f, -0.25793710f, -0.09821399f, 
    -0.18708371f, 0.03643560f, 0.03482364f, -0.44564411f, 0.05148270f, 0.29780421f, -0.05701083f, 0.52120405f, 
    0.71809173f, -0.45430866f, 0.27879468f, 0.16694111f, 0.14954585f, 0.21818082f, -0.33700749f, 0.19733070f, 
    0.17773943f, -0.04785882f, -0.26870543f, -0.25806057f, -0.09488755f, 0.11995209f, 0.02805603f, 0.15506655f, 
    0.10395594f, 0.03083107f, 0.22265983f, -0.20847698f, 0.30016524f, -0.15341446f, 0.41872463f, 0.08951250f, 
    0.26063302f, -0.37648767f, -0.09079055f, -0.17188664f, -0.38649699f, -0.15651730f, -0.00849538f, 0.22140573f, 
    0.14461456f, -0.36906713f, -0.16676314f, 0.14109792f, 0.20332915f, 0.06792095f, -0.17094463f, -0.19084693f, 
    -0.23692384f, -0.24185841f, -0.34603167f, -0.31813744f, 0.25920615f, -0.27518624f, 0.30711943f, 0.58174872f, 
    -0.22245786f, 0.24336295f, -0.88695306f, -0.35912237f, -0.13198014f, 0.28906810f, 0.31265610f, 0.14461732f, 
    -0.08611260f, 0.00155315f, -0.11796454f, -0.06168213f, 0.22889732f, -0.15386596f, -0.15456928f, 0.19995327f, 
    0.14483526f, 0.09696422f, 0.12207653f, 0.07145887f, 0.06866071f, -0.11973520f, 0.07602555f, -0.20052214f, 
    -0.24070275f, 0.54886109f, 0.19107214f, 0.05941803f, -0.07836694f, 0.07253482f, -0.00435075f, 0.14062577f, 
    -0.29091007f, -0.34426859f, -0.00226558f, 0.32264864f, -0.12165904f, -0.07519373f, -0.37288240f, 0.23800287f, 
    0.30627593f, -0.34466672f, 0.11263113f, 0.22606997f, -0.21703127f, -0.47803533f, 0.29524559f, -0.27514255f, 
    -0.07981928f, -0.56121594f, -0.32390788f, 0.03498060f, -0.45643017f, -0.52231842f, 0.03277758f, 0.13193172f, 
    0.08940928f, 0.09070450f, 0.28047106f, -0.28030333f, 0.20232211f, -0.33707628f, -0.17684922f, 0.20851064f, 
    0.24709250f, 0.20462193f, 0.04459441f, 0.31224319f, -0.21058802f, -0.11021145f, 0.00543588f, -0.23222147f, 
    -0.55006611f, -0.56258053f, -0.48650476f, -0.38512602f, -0.31096768f, -0.15873654f, 0.18036868f, -0.07175519f, 
    0.26957372f, -0.02269898f, 0.01466442f, 0.27808967f, 0.11042053f, 0.26886952f, 0.00557334f, -0.09412657f, 
    -0.12669180f, -0.05381491f, -0.09557338f, 0.12750307f, -0.02572365f, 0.02126602f, -0.14092004f, 0.04490058f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20271218f, 0.04343044f, 0.02956510f, 0.01702604f, 0.13936649f, 0.07054358f, 0.10825223f, 0.16968122f, 
    0.08486474f, 0.19284792f, 0.22793564f, -0.07561468f, 0.26530868f, 0.05744108f, 0.13132279f, 0.00739656f, 
    0.09423035f, 0.17722331f, 0.15289070f, 0.00460812f, 0.19608882f, 0.18234807f, -0.00257118f, 0.09869748f, 
    -0.01364723f, 0.04505160f, -0.09071413f, 0.08166314f, 0.01568846f, 0.24710873f, 0.09415247f, 0.00497690f, 
    0.06843294f, 0.19682764f, 0.16360340f, 0.02008033f, 0.15228365f, -0.10257816f, 0.11427815f, 0.02714838f, 
    0.24776803f, -0.00203438f, 0.24711730f, 0.05592680f, 0.15070136f, 0.06589159f, -0.02450485f, 0.29253623f, 
    -0.03304380f, 0.10134670f, 0.00400869f, 0.10565313f, 0.04922538f, 0.07500313f, -0.06568275f, 0.12510924f, 
    -0.11474653f, 0.18567197f, 0.06322594f, 0.04262659f, 0.14622860f, -0.01233712f, 0.18128169f, -0.05099314f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01923555f, -0.02941387f, -0.01915926f, 0.02522344f, -0.01890150f, 0.03401394f, 0.00998996f, 0.02191903f, 
    0.01775372f, -0.00233489f, -0.02153946f, -0.03276038f, 0.00542462f, 0.00968057f, -0.00452843f, -0.03363083f, 
    -0.01478159f, 0.01557062f, 0.01176329f, -0.03546069f, -0.00849328f, -0.01337862f, -0.03602701f, 0.02371016f, 
    -0.02725220f, 0.00525085f, 0.00569504f, -0.03992139f, 0.01689214f, 0.02054410f, -0.00518324f, -0.00778765f, 
    0.02726372f, 0.00106975f, 0.03298020f, 0.03514063f, 0.01649526f, -0.03165564f, -0.00772694f, -0.03179892f, 
    0.02101606f, -0.01059815f, 0.02146285f, 0.01493680f, -0.01416394f, -0.00821359f, 0.03439617f, 0.00750260f, 
    -0.01961951f, 0.02740896f, -0.02836235f, -0.00444901f, -0.01973945f, 0.03680595f, -0.01020829f, -0.02880297f, 
    -0.01353523f, 0.01871045f, -0.03209156f, -0.03744228f, -0.02526527f, 0.01571329f, -0.03632756f, -0.02584948f, 
    0.03080487f, 0.00307755f, -0.01338870f, -0.03128073f, -0.00225605f, 0.02433333f, 0.02657731f, -0.03383548f, 
    0.01709852f, -0.00996186f, -0.00522413f, 0.02725074f, 0.00435408f, -0.03833209f, -0.01106410f, 0.02737260f, 
    0.02070273f, 0.01167247f, 0.01478051f, -0.00882659f, -0.00758377f, 0.00486474f, -0.02355937f, -0.00976021f, 
    0.03165626f, 0.01938420f, 0.01746562f, -0.01928574f, -0.01115802f, -0.00520229f, 0.01372930f, -0.02450195f, 
    0.01028952f, -0.02206133f, -0.01792196f, -0.01594466f, -0.02891955f, 0.00995631f, -0.01737507f, -0.01106373f, 
    -0.00739042f, 0.00129929f, -0.02557599f, -0.02061498f, -0.04129295f, -0.00730729f, -0.00288319f, -0.00938805f, 
    0.02889056f, 0.01362796f, -0.02360214f, -0.04002977f, -0.02688402f, -0.01649684f, -0.00413645f, -0.00846895f, 
    -0.02020610f, 0.03530657f, 0.03444677f, -0.03462331f, -0.00884508f, -0.01090240f, 0.02873890f, -0.01444698f, 
    -0.00530515f, -0.02992874f, 0.01142947f, -0.00562061f, 0.03081130f, -0.01311110f, 0.02519184f, -0.02618922f, 
    0.03035127f, 0.00487144f, -0.02808041f, 0.03121896f, 0.03210518f, 0.01171048f, -0.00282955f, 0.02451150f, 
    -0.00357590f, -0.01008332f, 0.00969534f, -0.02950092f, 0.02418172f, -0.00145298f, -0.03784539f, 0.02244599f, 
    -0.00228128f, -0.01814291f, -0.03023838f, -0.03317307f, 0.04214521f, -0.01406895f, 0.03451825f, 0.01576800f, 
    -0.00108966f, -0.00641623f, 0.00622236f, -0.02252598f, 0.01162874f, 0.00930788f, 0.00489541f, -0.02748565f, 
    -0.04241799f, -0.02783053f, 0.03565039f, 0.01003275f, -0.00984671f, -0.02189698f, -0.03212614f, 0.00866628f, 
    0.02746234f, -0.02086394f, 0.02768231f, -0.02076947f, 0.01525713f, -0.01185266f, -0.02932179f, -0.02172996f, 
    0.02216409f, 0.02918899f, 0.01827873f, -0.03087941f, -0.00769054f, -0.02465373f, 0.01413888f, -0.03166485f, 
    0.02969782f, -0.01504719f, -0.00536678f, -0.02920298f, 0.02215443f, 0.01298057f, -0.02524113f, -0.03419586f, 
    0.02277251f, 0.03234877f, -0.02016059f, -0.02440225f, 0.00011775f, -0.00468653f, 0.01717851f, -0.00015748f, 
    0.02745569f, -0.00211360f, 0.00825065f, -0.02686897f, 0.01783879f, -0.01474906f, 0.01184762f, 0.01160687f, 
    -0.03937525f, -0.03640367f, -0.01242245f, -0.01290695f, 0.03027816f, -0.02579201f, 0.02677060f, -0.03584792f, 
    0.01982336f, -0.01167417f, 0.02143419f, -0.02537759f, -0.03135937f, 0.01270082f, -0.04337597f, 0.00872061f, 
    0.03780710f, 0.00454162f, 0.00065061f, -0.00661387f, 0.01778058f, -0.01126338f, -0.00313891f, -0.02134548f, 
    -0.03865396f, -0.00027372f, -0.00525240f, -0.01729186f, 0.01919265f, -0.01298994f, -0.00974324f, -0.02175883f, 
    -0.03074624f, 0.01853838f, 0.01899833f, -0.01183515f, 0.01223692f, -0.03085400f, -0.03427658f, 0.01467665f, 
    -0.02860164f, -0.02788711f, 0.02770598f, -0.02256083f, 0.02172014f, 0.03086445f, -0.01888981f, 0.00603575f, 
    0.00107362f, 0.00526426f, -0.02303069f, -0.00808639f, -0.03550871f, -0.01966615f, -0.02565635f, -0.00155982f, 
    -0.01231764f, -0.01809856f, -0.00354692f, -0.01839489f, -0.00459165f, -0.02618327f, 0.01676448f, -0.04138679f, 
    -0.02406046f, 0.01587330f, -0.01177142f, -0.00068929f, -0.03713280f, -0.03877285f, -0.03837376f, 0.01489825f, 
    -0.01441794f, -0.03914132f, -0.03695730f, -0.00817441f, 0.01365337f, -0.02479278f, -0.00836780f, -0.02914375f, 
    -0.02295384f, 0.00255041f, -0.02720956f, -0.02198119f, 0.00002247f, -0.02711886f, 0.03525313f, 0.02747918f, 
    -0.00667794f, -0.00309008f, -0.00193482f, -0.01817872f, -0.03386828f, -0.01460571f, 0.00381707f, -0.00834966f, 
    0.01796531f, -0.01510980f, -0.02442534f, -0.01363100f, 0.01856034f, 0.02449709f, -0.02711368f, -0.02720506f, 
    -0.03025000f, -0.00372604f, 0.03849373f, 0.01622879f, -0.00299993f, 0.00347458f, -0.00245282f, -0.03967338f, 
    -0.04031770f, 0.00661730f, 0.01559501f, 0.00220121f, -0.00537118f, -0.00890277f, 0.00344218f, 0.02808518f, 
    0.01420538f, -0.00236391f, 0.02459541f, 0.01378800f, 0.01457557f, -0.00544877f, -0.00743848f, 0.02707742f, 
    -0.01123493f, 0.01529020f, 0.02766418f, 0.01940969f, 0.02390800f, -0.01769515f, 0.00781359f, -0.03881206f, 
    0.01637349f, -0.02174512f, -0.00503318f, 0.03181443f, -0.00234083f, -0.02569401f, -0.04125757f, -0.01496033f, 
    -0.03494432f, 0.03963668f, 0.00308834f, 0.02058204f, -0.03559947f, -0.01286701f, 0.00696349f, -0.01554744f, 
    0.00858607f, 0.00337747f, -0.00220494f, -0.00919682f, -0.00040362f, -0.01750319f, -0.01190870f, 0.00364285f, 
    -0.02618603f, 0.01664461f, -0.03001343f, -0.02333502f, -0.03318691f, 0.00522721f, 0.01483837f, -0.03126627f, 
    -0.00488189f, -0.02982792f, 0.02305960f, -0.00062380f, -0.03069159f, 0.00094949f, -0.01935321f, 0.00425280f, 
    -0.03543880f, 0.00897619f, 0.03892636f, 0.01102516f, 0.01708501f, 0.01431842f, 0.04168835f, 0.01013146f, 
    0.01702877f, -0.02322823f, -0.00724043f, -0.01406921f, -0.01114613f, -0.00509593f, 0.02892760f, 0.02714830f, 
    -0.00059422f, 0.01856591f, -0.01607829f, 0.01115709f, 0.00665271f, 0.02210635f, -0.02150619f, -0.01873155f, 
    -0.00442912f, -0.02571113f, 0.03690795f, 0.01233153f, 0.02940884f, -0.03451790f, 0.02452012f, -0.00178151f, 
    0.00543172f, 0.02801302f, -0.01256268f, -0.03242479f, 0.00663022f, -0.00920636f, -0.04344640f, -0.01447046f, 
    0.00997834f, -0.04094137f, -0.02442572f, 0.01389917f, 0.00987296f, -0.02922970f, -0.03150482f, -0.01872343f, 
    -0.02676422f, -0.00422496f, -0.00670309f, 0.02078193f, -0.03519925f, -0.02459113f, -0.02677718f, -0.01512345f, 
    -0.02662731f, 0.01848872f, 0.00929084f, 0.01914897f, -0.00078537f, 0.02082961f, 0.02104436f, 0.00756053f, 
    -0.00986281f, -0.01772915f, -0.04110414f, -0.03644286f, 0.01243807f, -0.01221349f, -0.01866008f, 0.01007889f, 
    0.01947851f, -0.02873682f, 0.00921731f, -0.01801282f, -0.02323294f, 0.02781697f, -0.01168444f, -0.00415791f, 
    -0.00263074f, 0.03351480f, -0.03691930f, -0.01137051f, -0.03278539f, -0.00480584f, 0.02875095f, -0.00840816f, 
    -0.01525099f, -0.03885938f, 0.01454376f, -0.01841274f, 0.01583983f, 0.00683778f, -0.01125177f, 0.01193922f, 
    0.00219822f, -0.02869054f, 0.01741138f, 0.00001201f, 0.02284767f, 0.02803154f, 0.01929972f, -0.01539349f, 
    0.02882962f, 0.02029991f, -0.00097028f, 0.00014159f, -0.00621386f, -0.00429846f, 0.00322097f, 0.01984759f, 
    0.03319217f, 0.01332043f, -0.00706124f, -0.02511359f, -0.02556929f, -0.00661412f, 0.00769250f, 0.01343026f, 
    0.01476443f, -0.02920104f, 0.01156401f, 0.02339213f, -0.01107008f, 0.00291118f, 0.01132329f, -0.00615006f, 
    -0.01787835f, -0.02747194f, 0.00260067f, -0.00346415f, 0.03359713f, 0.01619804f, 0.02067654f, 0.02290567f, 
    -0.02498308f, 0.00230425f, 0.02641699f, -0.01800226f, -0.02691932f, -0.02710855f, -0.00290975f, -0.01249483f, 
    -0.02727616f, -0.01913487f, -0.02629950f, -0.02426108f, 0.01548860f, -0.01991278f, -0.03440510f, -0.00267063f, 
    -0.02498451f, 0.02081472f, -0.01943520f, 0.02032620f, -0.02203182f, -0.02036661f, 0.00576814f, -0.02677733f, 
    -0.02421026f, 0.01362824f, 0.00205734f, 0.02248517f, -0.00607513f, 0.02393616f, 0.01826778f, -0.04231197f, 
    -0.02227728f, 0.02354045f, 0.00482645f, -0.00225759f, -0.00936289f, 0.02304547f, 0.00563537f, -0.01055616f, 
    0.03534402f, -0.00112855f, -0.00786857f, 0.03184972f, -0.00109551f, -0.00636712f, -0.02127524f, -0.00471870f, 
    0.00491886f, 0.02801074f, 0.01211241f, 0.00400681f, -0.01148547f, -0.02545025f, -0.00864429f, 0.01050676f, 
    0.01967613f, -0.03024445f, 0.01110485f, 0.02125008f, -0.03909703f, 0.02841639f, -0.01846889f, 0.02499281f, 
    0.00597143f, -0.02069268f, -0.02384353f, -0.01607097f, 0.02876061f, 0.00315542f, 0.01256403f, 0.00347896f, 
    0.02225151f, 0.00921871f, 0.01809269f, -0.02653693f, 0.02691324f, -0.00152212f, 0.02350229f, -0.02158586f, 
    -0.02847708f, -0.02769551f, -0.00368727f, -0.01345092f, -0.02933196f, -0.02580150f, -0.02423710f, 0.02643025f, 
    -0.03621646f, -0.02632592f, 0.01399280f, -0.00329470f, 0.01487731f, -0.02435114f, 0.02249010f, 0.00909803f, 
    0.02335889f, -0.02192357f, 0.00466079f, -0.03503837f, 0.01120271f, -0.03333972f, -0.01234947f, -0.00070039f, 
    -0.01463375f, 0.00654147f, 0.01175741f, -0.03366164f, -0.02688831f, -0.02638946f, 0.00601080f, -0.00182743f, 
    -0.02339023f, 0.00456577f, -0.02154285f, 0.00789608f, -0.02223826f, -0.00361821f, -0.00112330f, -0.00740928f, 
    -0.01349835f, 0.02812818f, -0.03216874f, -0.01106394f, 0.02552877f, -0.03685983f, -0.00655060f, -0.02843031f, 
    0.03421857f, -0.01367963f, -0.01749079f, -0.00166027f, 0.01700887f, -0.02940162f, -0.01613229f, 0.01249103f, 
    -0.01640609f, -0.02024452f, 0.02840135f, -0.00563062f, -0.01228676f, 0.01044886f, 0.02154971f, -0.02375318f, 
    0.02407914f, -0.02198975f, 0.00751578f, 0.01483394f, -0.02202652f, -0.01260831f, 0.00105830f, -0.02537657f, 
    -0.00860054f, -0.01370110f, -0.00295352f, -0.02387419f, -0.00413560f, 0.00864657f, -0.02582838f, -0.03436439f, 
    -0.04387984f, 0.00290375f, 0.01447081f, -0.03095130f, 0.02066200f, 0.02757706f, 0.02870589f, 0.01529208f, 
    0.01940760f, -0.01435776f, 0.02654668f, -0.04157175f, -0.00359674f, 0.00509946f, -0.02656847f, 0.02612496f, 
    0.01968801f, 0.02216938f, -0.03053445f, -0.04004904f, 0.02248864f, -0.00165598f, -0.00418715f, -0.01713259f, 
    0.02084665f, 0.02216912f, -0.04023602f, 0.00316991f, 0.01248071f, -0.00098646f, 0.00956872f, -0.02061152f, 
    -0.03901412f, -0.04313335f, 0.02731612f, -0.00909777f, -0.00576316f, -0.01169008f, 0.00751765f, 0.01970361f, 
    0.02634713f, -0.00256687f, 0.00327128f, -0.00916498f, 0.02391154f, 0.00433964f, -0.02263951f, 0.00439694f, 
    0.00201776f, -0.02088704f, 0.00461480f, 0.02563066f, -0.01583160f, -0.03314280f, 0.03582479f, -0.04160754f, 
    -0.02907087f, 0.02254679f, 0.00700747f, -0.03715026f, 0.00015940f, -0.02954202f, 0.01257261f, 0.00979168f, 
    0.00158166f, 0.01459312f, -0.02422503f, -0.01748199f, -0.01671824f, 0.00765444f, 0.02721159f, -0.01109536f, 
    0.01711489f, -0.02288154f, -0.01610765f, -0.01343432f, 0.00360033f, -0.02360003f, 0.00327118f, -0.02634331f, 
    -0.00298937f, -0.00404024f, -0.01698963f, -0.02426376f, -0.03168389f, 0.02648521f, 0.02153963f, -0.01774278f, 
    0.01340119f, -0.01932660f, 0.00807614f, 0.00516290f, -0.03203595f, -0.02633905f, 0.02920768f, -0.04267232f, 
    0.01409540f, -0.00400549f, -0.02376713f, -0.02074658f, 0.00382485f, 0.02829638f, 0.01368614f, 0.00005852f, 
    -0.03651230f, -0.01743130f, -0.00992834f, -0.02399142f, 0.02903023f, 0.03114128f, -0.02408930f, -0.01872442f, 
    -0.03212474f, -0.01464379f, -0.03365455f, 0.01539435f, -0.03702358f, 0.02422000f, -0.01946434f, -0.00819222f, 
    -0.00668682f, 0.01255459f, -0.02903782f, 0.00426328f, -0.00041387f, 0.00576836f, 0.01546596f, 0.01030877f, 
    -0.01216100f, 0.02711616f, -0.00055458f, -0.03270594f, -0.03382770f, -0.04122906f, -0.03260832f, -0.02542818f, 
    -0.01595949f, -0.03808333f, -0.03374111f, 0.00864894f, 0.00488323f, -0.03567110f, -0.02235305f, -0.00998107f, 
    -0.00112826f, -0.03748880f, -0.03618659f, 0.01234251f, 0.00295806f, -0.01681633f, -0.03915947f, 0.00212081f, 
    -0.00042429f, 0.00077233f, 0.02950273f, -0.02426265f, -0.03654310f, -0.03232575f, -0.04122118f, 0.02640239f, 
    -0.02494219f, 0.01162095f, -0.02258813f, -0.00408314f, 0.00113707f, -0.03688136f, -0.01855373f, 0.01721491f, 
    -0.01332610f, 0.01781351f, -0.03657116f, 0.01164289f, 0.02075631f, -0.04117243f, -0.01971820f, -0.03835675f, 
    0.02954223f, 0.02383069f, -0.03090123f, -0.04162680f, -0.03145820f, -0.00283359f, 0.00626120f, 0.01675856f, 
    -0.00776067f, 0.00390616f, -0.02278106f, 0.01508902f, -0.02673124f, 0.02765488f, 0.02183621f, -0.01670151f, 
    0.03044845f, -0.03468640f, 0.02889546f, 0.01120381f, -0.02348394f, 0.02132265f, -0.02555243f, -0.00168936f, 
    -0.03819588f, -0.01320961f, -0.01403725f, 0.00424979f, -0.00200409f, 0.00276461f, -0.00894359f, -0.03692674f, 
    0.01095970f, -0.02171216f, 0.02479907f, -0.00058308f, -0.00702729f, -0.01574796f, 0.00129523f, 0.02496927f, 
    0.00009268f, -0.00328270f, 0.01751394f, -0.03974612f, -0.01364189f, 0.01288191f, 0.00922606f, -0.00766876f, 
    -0.00205951f, -0.02515315f, 0.00902289f, 0.01906470f, -0.00323138f, -0.00343154f, -0.02189850f, -0.02875127f, 
    -0.03526673f, 0.00924206f, -0.01943680f, -0.02482160f, 0.02673509f, 0.00927906f, 0.00109873f, 0.02727691f, 
    -0.03243010f, 0.02652987f, -0.03781508f, -0.02933140f, 0.00846087f, -0.00024281f, 0.01312500f, -0.03447927f, 
    -0.00560817f, -0.00915872f, -0.04198859f, -0.00493362f, 0.01170253f, -0.00659428f, 0.00362796f, 0.02409204f, 
    -0.02481239f, -0.02522128f, -0.01299274f, 0.00114368f, -0.00057242f, 0.02782836f, -0.03012702f, 0.00916605f, 
    -0.02490443f, 0.01238373f, 0.02639289f, -0.00480600f, 0.00958217f, -0.01569461f, 0.01268122f, 0.01276691f, 
    -0.03972948f, 0.00332001f, -0.02645203f, -0.02715822f, -0.03364320f, -0.04135438f, 0.00553297f, 0.02021031f, 
    -0.03769442f, 0.01870114f, -0.03814677f, 0.02078852f, 0.02528007f, 0.01855483f, 0.00088763f, -0.02265662f, 
    0.02727616f, -0.03603243f, -0.02315088f, -0.03548406f, -0.00579801f, 0.01144049f, -0.03309391f, -0.03272568f, 
    -0.01490306f, 0.01481551f, 0.01023671f, -0.02788829f, -0.02781654f, 0.02796819f, 0.01963868f, -0.01541189f, 
    -0.01933347f, -0.00204981f, -0.03391067f, -0.00960833f, -0.02229887f, -0.03580997f, -0.03690871f, -0.02384481f, 
    0.01176339f, -0.01981778f, -0.01993452f, -0.02973125f, -0.01932454f, -0.02737492f, 0.01788545f, -0.01398849f, 
    0.02931806f, -0.02897797f, -0.01319624f, -0.02427994f, -0.03291206f, 0.00051035f, 0.01211075f, 0.00808791f, 
    0.02314554f, -0.01737580f, 0.02147697f, 0.02529028f, 0.01917308f, 0.02977998f, -0.03750871f, 0.02595539f, 
    -0.00983726f, -0.02407549f, -0.03651211f, -0.03322963f, -0.00999456f, -0.01442878f, -0.01404977f, 0.00319759f, 
    0.02198027f, -0.02591185f, 0.01879016f, 0.01798729f, 0.01111306f, 0.00476657f, 0.00011923f, -0.00910501f, 
    -0.01178415f, 0.00876736f, 0.01553545f, -0.00835337f, 0.02251306f, -0.01308123f, 0.01006788f, -0.00886785f, 
    0.00319234f, -0.00820930f, -0.01921702f, -0.00748580f, -0.02460093f, -0.03373126f, -0.03173456f, -0.00553475f, 
    -0.00175907f, 0.02065337f, -0.01033566f, 0.02850769f, -0.00217882f, -0.03729754f, 0.02068232f, 0.01369590f, 
    0.00931099f, -0.01902591f, -0.01604207f, -0.03955437f, 0.01363569f, 0.02494963f, -0.02419171f, 0.02662152f, 
    0.00231439f, -0.03834984f, -0.00753622f, -0.01099048f, 0.00294597f, 0.00480727f, 0.02609058f, -0.03783390f, 
    -0.00650867f, -0.00611413f, 0.01561926f, -0.00917594f, 0.00388681f, -0.02092643f, 0.01009171f, 0.02388542f, 
    -0.01876407f, -0.03604108f, 0.01430160f, 0.02619412f, 0.02011131f, 0.00480341f, 0.01809221f, -0.03994117f, 
    -0.01996046f, -0.02526576f, -0.01170336f, -0.03949590f, -0.03909320f, 0.02115823f, 0.00657480f, -0.02631464f, 
    0.01419183f, 0.01997367f, -0.00456299f, -0.04012164f, -0.01418328f, 0.01795296f, -0.00344549f, -0.00790244f, 
    -0.02230194f, 0.01420959f, 0.01673409f, 0.00511925f, -0.02337611f, -0.02994969f, -0.01312488f, 0.00936037f, 
    0.01189459f, -0.03071957f, -0.02172745f, -0.02088223f, -0.02680768f, 0.00424456f, -0.01707607f, 0.00217600f, 
    0.02862117f, 0.02847509f, -0.00975164f, -0.02281323f, 0.00286707f, 0.01188674f, -0.02523036f, -0.00161259f, 
    -0.00363511f, 0.00475740f, 0.00713934f, -0.01346992f, 0.03025619f, 0.01778971f, -0.03936299f, -0.03094893f, 
    -0.02986975f, 0.01252408f, -0.01837282f, -0.03911391f, -0.03453301f, -0.00708588f, 0.02038639f, -0.03138594f, 
    0.00943333f, -0.02363821f, 0.00112842f, -0.01644624f, -0.01661510f, 0.01713643f, -0.01625399f, 0.00316115f, 
    -0.03066137f, -0.01894500f, 0.01865111f, 0.02910224f, -0.02908618f, 0.01391701f, 0.03361593f, -0.01668447f, 
    0.02657190f, 0.00078384f, 0.00125477f, 0.02079994f, 0.01426054f, 0.01988745f, 0.02301486f, -0.01879944f, 
    -0.03796224f, 0.01922339f, -0.00848872f, 0.00659079f, -0.00151783f, 0.00196759f, 0.00600989f, -0.01737644f, 
    0.01911326f, -0.03516440f, 0.01560498f, -0.02125011f, 0.01319913f, -0.00267939f, 0.02111216f, 0.02114272f, 
    -0.02741923f, 0.02427294f, -0.01352382f, -0.01121796f, -0.00096553f, -0.03596740f, -0.03431026f, -0.03986431f, 
    -0.00929196f, -0.03921958f, 0.01144852f, 0.01030601f, -0.00355380f, -0.00712304f, -0.01171337f, -0.03754814f, 
    -0.02459050f, 0.00876257f, 0.02287317f, 0.02413310f, -0.01730767f, -0.01944535f, 0.02441700f, -0.00019432f, 
    0.02194711f, -0.03975612f, -0.03093696f, 0.00507288f, 0.01216025f, -0.02585359f, 0.00989616f, 0.02876193f, 
    -0.00399860f, -0.00702877f, 0.02939071f, -0.00641082f, 0.01222142f, -0.00267257f, 0.00629545f, -0.03967426f, 
    -0.02913222f, 0.02673478f, -0.02872700f, -0.01106198f, 0.00792687f, 0.02916811f, -0.04065624f, -0.03537076f, 
    -0.01538100f, -0.03459482f, -0.03236428f, 0.01116815f, 0.02864179f, -0.00919877f, -0.00305555f, 0.00323561f, 
    0.00223822f, -0.03485378f, -0.03060601f, 0.00468619f, 0.01415128f, -0.01931188f, -0.03387871f, 0.02811500f, 
    -0.00453550f, -0.03745407f, 0.02799874f, -0.02165797f, -0.03925959f, -0.03538323f, -0.03211891f, 0.02161720f, 
    -0.01564694f, 0.02217176f, -0.00980211f, 0.02317174f, -0.00426960f, -0.00635881f, -0.00137005f, -0.03618284f, 
    -0.02482996f, -0.03163688f, 0.02024196f, 0.01933057f, -0.00674215f, -0.02603507f, 0.00038576f, -0.01781273f, 
    0.00105008f, -0.03210194f, 0.01603598f, -0.01697760f, -0.02999654f, -0.01466290f, -0.01760000f, 0.02516703f, 
    0.00739105f, -0.02665944f, -0.03919588f, -0.01607724f, -0.00876392f, 0.01567639f, -0.03843978f, -0.01979155f, 
    -0.03107638f, 0.01130658f, -0.02151995f, 0.02714070f, -0.03959760f, -0.03290905f, 0.01529801f, -0.00337631f, 
    -0.01277958f, -0.03432141f, 0.02867725f, -0.02390883f, -0.01177990f, -0.03634124f, 0.00604821f, -0.03067433f, 
    0.02155011f, -0.03947454f, 0.00141149f, -0.03124781f, 0.02460852f, -0.00111872f, -0.01391475f, -0.03129385f, 
    0.02161155f, -0.01364890f, -0.02790865f, -0.01216329f, -0.03145147f, -0.00412482f, -0.02310240f, 0.02493883f, 
    -0.02464521f, -0.03275060f, -0.02084964f, 0.01705402f, 0.00738785f, -0.03032232f, 0.01820264f, -0.01706870f, 
    0.01207624f, -0.02064282f, 0.00008498f, 0.01315767f, -0.04018850f, 0.00316750f, -0.00028205f, -0.02270786f, 
    0.01835854f, 0.02507323f, 0.03339286f, 0.00215440f, -0.02642985f, -0.03108969f, 0.02380051f, -0.03142720f, 
    -0.01035119f, 0.00756410f, -0.00266062f, 0.01323782f, -0.03313263f, 0.02660015f, -0.02524852f, 0.02404249f, 
    -0.03344115f, -0.02072931f, -0.00764960f, -0.02505571f, 0.00803854f, 0.03030246f, -0.01699142f, -0.03619638f, 
    0.01858860f, -0.03033656f, -0.03285537f, -0.04038868f, -0.01370492f, 0.01334936f, -0.02363307f, -0.02769476f, 
    0.01887574f, -0.02834712f, -0.00827976f, -0.03906273f, -0.02177035f, -0.03000629f, -0.03019482f, -0.03990801f, 
    -0.03540062f, -0.01303066f, -0.04050923f, 0.00416816f, 0.02871273f, -0.03230624f, -0.03573370f, 0.01024785f, 
    -0.01141237f, 0.02813373f, -0.02283316f, -0.01513981f, -0.02084566f, 0.02585036f, -0.01317055f, -0.01474947f, 
    -0.03448487f, 0.01069542f, -0.00057570f, -0.00020723f, 0.00492936f, 0.01626053f, -0.00208196f, -0.03206998f, 
    -0.01526938f, 0.02562902f, 0.00656453f, 0.02316034f, 0.02005288f, 0.04093297f, -0.02934594f, -0.00519272f, 
    0.00372645f, 0.00006347f, -0.00966223f, -0.00000965f, 0.01384239f, -0.00127917f, 0.01882587f, 0.00334148f, 
    -0.00928699f, 0.02549262f, 0.02626989f, 0.01915035f, -0.02642239f, 0.02945850f, -0.00679080f, -0.03307191f, 
    0.02382989f, -0.01012966f, 0.01597171f, -0.02498491f, 0.00584489f, 0.01234715f, 0.01231654f, 0.00455054f, 
    0.01468303f, -0.03171818f, -0.01781579f, -0.02606304f, -0.01860901f, 0.00581283f, 0.02090463f, 0.00855746f, 
    0.00307568f, -0.01870240f, -0.01726753f, 0.02316041f, -0.04047908f, -0.01959287f, -0.02022697f, 0.00872703f, 
    0.02001303f, -0.03013052f, 0.01480124f, -0.01910990f, -0.01481871f, -0.01903506f, 0.01146939f, 0.00159625f, 
    -0.00832978f, 0.00541251f, -0.03359860f, -0.03704682f, -0.01847632f, 0.01644697f, -0.00901642f, -0.02840818f, 
    -0.00105267f, -0.02985612f, -0.00828540f, 0.00694024f, -0.04150611f, 0.00755579f, -0.01862410f, 0.01269326f, 
    0.02922489f, 0.00415240f, -0.04057109f, -0.00303618f, -0.03857955f, -0.02522342f, 0.01118389f, 0.02265378f, 
    -0.01942986f, -0.01597779f, 0.01034863f, 0.01531708f, -0.03799221f, 0.00906593f, -0.00769811f, -0.03728501f, 
    -0.00553034f, -0.02778040f, -0.03532103f, -0.03522677f, 0.01950067f, -0.03525724f, 0.00688275f, -0.02258115f, 
    -0.00985654f, -0.03223894f, 0.02687328f, -0.03379886f, -0.00705927f, 0.01707892f, -0.02304208f, 0.00982267f, 
    -0.03938918f, 0.01597274f, -0.00991613f, 0.01239229f, -0.03579715f, 0.00314334f, -0.01669203f, -0.04097876f, 
    -0.01179750f, 0.00232856f, 0.00019949f, 0.01897585f, 0.02009897f, 0.00691339f, 0.02246653f, 0.00744008f, 
    0.00329982f, 0.02431938f, -0.02642809f, -0.02260993f, -0.01619106f, -0.00649708f, 0.01785948f, -0.00722462f, 
    0.22186275f, 0.07564852f, -0.13043706f, 0.28208923f, -0.05020713f, -0.01349700f, 0.03789362f, 0.01546292f, 
    0.06474975f, 0.04337808f, -0.03977747f, -0.03484460f, 0.02810974f, 0.18751961f, 0.03592847f, -0.07339057f, 
    0.01002333f, 0.01199524f, -0.03080347f, 0.13259967f, 0.07140289f, 0.08150742f, 0.09485238f, 0.09995525f, 
    -0.11682807f, -0.04359145f, 0.16186550f, 0.30840465f, 0.08391993f, -0.01532853f, -0.01194966f, -0.02153847f, 
    0.02663805f, 0.01885527f, -0.03807903f, 0.05327901f, -0.10013445f, 0.17344248f, -0.02463305f, -0.24040519f, 
    0.09755446f, 0.12604047f, 0.11317800f, -0.09423409f, -0.14001463f, -0.11004304f, 0.04307649f, 0.02887818f, 
    0.21334985f, 0.08766668f, -0.02310800f, 0.18711714f, -0.04375614f, -0.01379421f, 0.01970763f, -0.05123808f, 
    -0.04015239f, -0.05448585f, 0.03206537f, -0.00381216f, 0.02960141f, -0.01115746f, 0.18780893f, 0.08696470f, 
    0.07843951f, 0.01482543f, -0.10528821f, 0.04454998f, 0.02600115f, -0.08443908f, 0.11165710f, 0.03340863f, 
    0.07058981f, 0.16438596f, 0.00297786f, 0.02375283f, 0.03115086f, 0.01732834f, 0.02245465f, -0.11982580f, 
    0.05623407f, 0.03005080f, -0.05498361f, -0.06743760f, 0.04954070f, 0.00375058f, -0.04269991f, -0.07302868f, 
    0.08279654f, -0.14310288f, -0.04378919f, 0.02464687f, 0.02119366f, 0.02951770f, -0.02418618f, -0.08836696f, 
    0.00742113f, -0.02764908f, 0.00736991f, 0.21089652f, 0.03482275f, -0.02958220f, 0.18760870f, 0.00280735f, 
    0.13982144f, -0.00627727f, 0.08561130f, -0.03875594f, -0.25113171f, 0.02342072f, -0.15777396f, 0.05644073f, 
    0.08201660f, -0.02680578f, -0.01883667f, -0.10300411f, 0.00478255f, -0.04789938f, -0.00857984f, -0.02132558f, 
    0.02936422f, -0.11803600f, 0.06394996f, -0.00508612f, -0.04583886f, -0.06734210f, -0.03426629f, 0.03223804f, 
    0.07998304f, 0.00399284f, -0.02837612f, -0.00826932f, 0.15325885f, 0.08821008f, 0.10602867f, -0.20068520f, 
    0.03238362f, -0.07856297f, -0.02586917f, 0.14154246f, -0.06590828f, 0.00475798f, 0.02008197f, -0.02832605f, 
    0.12359928f, -0.00247131f, 0.04066137f, -0.04620964f, -0.02950124f, 0.04902671f, 0.05372644f, -0.10909688f, 
    0.04772820f, 0.05693133f, 0.13537161f, 0.05926170f, 0.00391288f, -0.02116168f, 0.14677557f, -0.28894031f, 
    -0.05298894f, 0.03133735f, -0.08723828f, -0.04859244f, -0.06179677f, 0.11447931f, 0.08898788f, 0.08429446f, 
    0.01966046f, -0.02748699f, -0.11083355f, 0.07436607f, -0.06113993f, 0.00656913f, -0.03417185f, -0.02512701f, 
    -0.01862317f, -0.01189210f, 0.10263722f, -0.03057977f, -0.07320917f, -0.05408366f, 0.18622531f, -0.00529706f, 
    0.06590719f, 0.02799412f, -0.08889929f, -0.08399595f, 0.03532956f, -0.18607739f, 0.18233174f, 0.10834992f, 
    -0.02843015f, 0.14526261f, -0.01792019f, -0.19170491f, 0.10883310f, -0.00549309f, 0.09672394f, 0.00386597f, 
    -0.02620539f, -0.00402706f, -0.08489314f, -0.07622846f, 0.05027913f, -0.10172391f, -0.00407215f, 0.15922122f, 
    0.06776892f, 0.09843650f, 0.02356182f, -0.09150843f, 0.05450616f, 0.00801955f, 0.02577022f, 0.07663468f, 
    0.11421745f, 0.09764365f, 0.02939401f, 0.19882801f, 0.09600503f, -0.07712125f, 0.14166319f, 0.04558414f, 
    -0.09080320f, 0.05453198f, -0.12943046f, -0.00752055f, -0.13130374f, 0.06697103f, -0.06637149f, -0.12157794f, 
    0.10747149f, 0.06677052f, 0.06807984f, -0.07908589f, 0.16118105f, 0.00032632f, 0.00220324f, -0.03070506f, 
    0.14296657f, 0.06699724f, 0.01244417f, 0.17865939f, -0.02515120f, 0.00911189f, -0.00214228f, -0.00100039f, 
    -0.08636402f, -0.01136382f, -0.02929506f, 0.12916499f, 0.00097158f, -0.12276060f, 0.12891851f, -0.11739292f, 
    0.09705084f, -0.08221593f, -0.07572728f, -0.02749962f, 0.07058959f, -0.07559218f, 0.00963802f, -0.00601862f, 
    0.21324946f, -0.11915430f, 0.00459221f, 0.13172847f, 0.07358448f, 0.02143908f, -0.00913713f, -0.06535601f, 
    0.02882607f, 0.12944438f, -0.00402960f, 0.07765582f, 0.10275334f, 0.09284908f, -0.09265142f, 0.42058527f, 
    0.02870523f, -0.03330272f, -0.04798967f, 0.04876359f, -0.00917062f, 0.09039274f, -0.00799026f, 0.12650619f, 
    0.13487068f, -0.05517327f, -0.27704498f, 0.32099149f, 0.14987759f, 0.18567291f, -0.09387615f, -0.00763071f, 
    0.06163624f, 0.03188412f, 0.05611555f, -0.09879926f, 0.16108505f, 0.22993907f, -0.07773558f, 0.34872657f, 
    0.06083497f, -0.15215036f, -0.10207080f, -0.00061458f, -0.03925109f, 0.03723489f, 0.02637743f, 0.05296160f, 
    0.01976016f, 0.00666326f, -0.16410868f, 0.21229208f, -0.07483984f, 0.08405945f, 0.01588133f, -0.20268598f, 
    0.03945293f, -0.07040498f, -0.00124213f, -0.00191914f, -0.04538872f, 0.18227795f, -0.07933942f, -0.12974559f, 
    -0.00151239f, -0.08748095f, 0.00529465f, 0.03722166f, 0.19694947f, 0.02415122f, -0.04772359f, 0.08903076f, 
    0.15501529f, -0.17293467f, 0.20094661f, -0.24055812f, -0.05194635f, 0.02829712f, 0.00998894f, -0.01924152f, 
    0.07056019f, -0.08197638f, 0.00622911f, 0.11025061f, 0.09846150f, 0.01297636f, -0.00987812f, 0.16032079f, 
    -0.00095927f, -0.00176125f, -0.02907375f, -0.00201778f, 0.05649760f, 0.07806375f, 0.09294099f, -0.03056200f, 
    0.11771768f, -0.09837774f, -0.12836139f, -0.01903785f, 0.15633743f, -0.09767888f, -0.03143414f, -0.02064473f, 
    0.04565078f, -0.11660404f, 0.05935696f, 0.07555105f, 0.11435384f, 0.00803421f, -0.01972285f, -0.22850265f, 
    -0.02356678f, 0.02533111f, 0.02884531f, 0.05428275f, 0.08415777f, -0.00583740f, 0.03129092f, 0.04547701f, 
    -0.05361438f, -0.14002946f, -0.00910966f, -0.16481671f, 0.10172399f, -0.07220681f, 0.13842380f, -0.09707803f, 
    -0.03881163f, -0.00163822f, -0.09803258f, -0.00415393f, 0.17721198f, 0.05720588f, 0.02955321f, 0.12091643f, 
    0.02289586f, 0.01617949f, 0.12625928f, -0.07915387f, 0.01919479f, 0.01480316f, 0.06248820f, 0.05996537f, 
    0.34643877f, -0.00763416f, -0.04894809f, 0.19920801f, 0.02205482f, 0.03005403f, 0.01865631f, -0.04733215f, 
    0.07772971f, 0.14425144f, 0.06929050f, 0.00769285f, -0.13074122f, -0.06121818f, -0.19502097f, 0.03415483f, 
    0.02757808f, 0.06098247f, 0.04286163f, -0.00862646f, -0.05414775f, 0.01366283f, -0.04391626f, -0.11159877f, 
    -0.37361541f, 0.04032971f, -0.01690004f, 0.03216225f, 0.01499350f, 0.08009768f, 0.05533910f, 0.02621837f, 
    -0.00334223f, 0.07175149f, 0.05472245f, 0.04723058f, -0.34835941f, -0.07652847f, -0.09594068f, -0.07165875f, 
    -0.01658622f, 0.08521724f, 0.15400068f, -0.00663664f, -0.03449815f, -0.09307856f, 0.02156626f, 0.10328048f, 
    -0.16158016f, 0.03969898f, -0.10305391f, 0.15900625f, 0.09441435f, -0.00010444f, -0.17715342f, 0.01091677f, 
    0.08580513f, -0.02606650f, 0.11111788f, -0.03335489f, -0.14673913f, -0.11537811f, 0.03081881f, 0.02316778f, 
    -0.02183036f, 0.05919530f, 0.20184138f, 0.00482295f, -0.06650254f, -0.03902037f, 0.15513028f, 0.12365883f, 
    0.02478345f, 0.05566372f, 0.13956398f, 0.03149568f, 0.06493924f, 0.06179183f, -0.08728560f, -0.08338668f, 
    -0.00649361f, 0.07755705f, -0.03866563f, 0.10179773f, 0.18776000f, -0.07237060f, 0.00445524f, 0.13859405f, 
    0.09681402f, -0.07152969f, 0.08094772f, 0.00783500f, -0.07677210f, 0.00732094f, -0.16991244f, 0.01442480f, 
    -0.20158513f, -0.08849936f, -0.02945676f, -0.26288748f, 0.01940663f, -0.02367538f, -0.00904721f, 0.09393197f, 
    0.08711720f, 0.01854831f, 0.02742312f, 0.01437937f, -0.37835819f, -0.07841785f, -0.06643426f, 0.21973903f, 
    0.03375976f, -0.05703369f, -0.04154628f, -0.05014635f, -0.02727928f, 0.02149073f, 0.03704133f, -0.04967809f, 
    0.19265601f, 0.21399139f, -0.05543517f, -0.07595648f, 0.05760876f, -0.00447487f, -0.03841586f, 0.16202666f, 
    0.01316383f, 0.04986178f, -0.05823060f, 0.00189738f, -0.18585096f, 0.10369644f, 0.37676784f, -0.11252763f, 
    0.02618080f, 0.03728965f, 0.12016889f, -0.01034704f, -0.07703212f, 0.00229350f, 0.04678105f, 0.04111434f, 
    -0.01742147f, -0.07411042f, -0.00343613f, 0.01010976f, 0.04291090f, -0.01982492f, 0.00359238f, -0.00793908f, 
    -0.07065610f, -0.10580818f, 0.09994755f, 0.05917557f, 0.10226759f, -0.04973020f, -0.03305335f, -0.10419587f, 
    -0.00956014f, 0.07060988f, 0.01404386f, 0.13379632f, 0.10432266f, 0.04882422f, 0.10645389f, 0.09503119f, 
    0.20950468f, -0.12668279f, 0.05633667f, 0.27569816f, -0.04956881f, 0.03757583f, -0.02187984f, -0.11555953f, 
    0.06587985f, -0.00064211f, 0.16703030f, 0.06014615f, -0.22907655f, -0.07344143f, 0.13242036f, 0.24429518f, 
    -0.03630735f, -0.01366397f, 0.17882912f, 0.00920882f, 0.08943794f, -0.03587620f, -0.04984035f, -0.05569356f, 
    0.06278805f, 0.13414168f, 0.12305660f, 0.19343117f, -0.02369248f, 0.01506850f, 0.09521008f, -0.13472967f, 
    0.12367731f, -0.00938817f, 0.04017729f, 0.04203781f, -0.02539820f, -0.10362536f, -0.16224574f, -0.03384762f, 
    -0.05622881f, 0.07676620f, -0.07487798f, -0.09404562f, -0.03487360f, -0.10596158f, 0.02929204f, 0.01787594f, 
    -0.16305469f, 0.12223796f, 0.15742445f, 0.06367532f, 0.09546340f, -0.01396115f, -0.06939765f, 0.02858840f, 
    -0.10553625f, 0.02062558f, 0.11717869f, 0.06304870f, -0.29602823f, -0.01070847f, -0.14609013f, -0.20242050f, 
    0.10495596f, 0.00441846f, -0.01345391f, 0.19803202f, -0.04892655f, -0.01104226f, 0.04283600f, 0.06358474f, 
    -0.05470670f, 0.01472444f, -0.21469358f, -0.22522591f, -0.04252612f, 0.04076280f, -0.08087579f, 0.00873465f, 
    -0.02318545f, -0.12618050f, -0.12450650f, -0.13190398f, 0.14862868f, -0.02212848f, -0.05712555f, 0.18187305f, 
    0.03273907f, -0.10327671f, -0.01401676f, -0.08166396f, 0.09508310f, -0.04013411f, 0.01456917f, 0.15354723f, 
    -0.12356145f, -0.11794511f, 0.06126847f, -0.17145291f, 0.10321873f, 0.03925770f, 0.08200607f, -0.09339422f, 
    0.09980130f, -0.20447475f, 0.14534731f, -0.11980878f, -0.03040336f, -0.08132458f, -0.12533814f, -0.14963959f, 
    -0.13512565f, 0.02142164f, -0.02416834f, -0.02445924f, 0.03852420f, -0.07714150f, 0.03590976f, 0.00589703f, 
    -0.09561650f, -0.07857173f, -0.07335210f, -0.03343277f, -0.09632429f, 0.02397951f, 0.06801672f, 0.06408072f, 
    0.00939241f, -0.01951536f, -0.02565971f, -0.06975472f, 0.11916614f, 0.05653791f, 0.12962000f, 0.03964277f, 
    -0.02587208f, 0.02065105f, 0.02120318f, -0.14976585f, 0.01642129f, 0.04306668f, 0.18478492f, 0.00261045f, 
    0.22054656f, -0.11261976f, -0.02774485f, 0.20924464f, 0.09943865f, -0.04188291f, -0.04892437f, 0.04219896f, 
    0.11928201f, 0.02154037f, -0.01356237f, 0.16794753f, 0.03245263f, -0.03824156f, 0.03954937f, 0.01361564f, 
    0.06081889f, -0.16826582f, 0.08490148f, 0.06718382f, -0.02165305f, 0.17497176f, -0.08850136f, 0.00675233f, 
    0.08458138f, -0.07430258f, -0.17119946f, 0.28248471f, 0.06175942f, -0.09801351f, -0.04215670f, 0.07277644f, 
    0.05287766f, 0.05569351f, 0.08463078f, -0.00355367f, -0.10794481f, 0.18715042f, -0.05966996f, 0.07310109f, 
    0.14191748f, 0.17488858f, 0.02417316f, -0.14904590f, 0.02843467f, -0.02030645f, 0.07313289f, -0.06387487f, 
    -0.15881412f, -0.00809783f, 0.07528910f, -0.08709824f, 0.02360780f, 0.02264088f, 0.08964863f, 0.05287644f, 
    -0.04213036f, 0.02957504f, 0.03891078f, 0.08650002f, 0.18365188f, 0.17766251f, 0.20510709f, 0.04199543f, 
    0.05957902f, -0.03500696f, 0.02005649f, 0.05726625f, 0.00986495f, 0.03885721f, 0.02356504f, 0.08868815f, 
    -0.26853988f, -0.20650660f, 0.02818348f, -0.07757842f, -0.03349876f, 0.10752215f, -0.02591168f, 0.03675689f, 
    0.10521558f, 0.05530885f, -0.00243934f, 0.08110292f, 0.04937844f, -0.04422728f, -0.12381516f, -0.00233875f, 
    0.04709674f, 0.07446729f, -0.09102616f, -0.01779725f, 0.15158606f, 0.00950174f, -0.13148104f, -0.01023132f, 
    -0.24094538f, -0.15223536f, -0.04702419f, -0.18927629f, -0.01944332f, 0.00411672f, 0.06576090f, -0.01964158f, 
    0.07606274f, 0.03927161f, -0.00847459f, 0.08156326f, -0.16901527f, 0.01272608f, -0.24629220f, -0.05371720f, 
    -0.01958560f, 0.02003429f, 0.00787731f, 0.01045843f, 0.01734499f, 0.11855488f, 0.10987877f, 0.08436484f, 
    -0.13722646f, -0.12725002f, -0.01503591f, -0.09519356f, -0.00177670f, -0.02260609f, 0.00318330f, -0.02332282f, 
    -0.02107208f, -0.01130226f, 0.00219515f, 0.13667087f, 0.15480757f, -0.10616393f, 0.11646341f, 0.05224687f, 
    -0.03216251f, 0.04451092f, 0.04940997f, 0.08015433f, 0.03441467f, 0.13963816f, 0.03545295f, 0.10377553f, 
    0.17001182f, 0.10225621f, -0.02128085f, -0.02445988f, 0.01601207f, -0.00176854f, 0.03380837f, 0.06841896f, 
    0.02924933f, 0.07306363f, 0.05223630f, 0.01849317f, 0.09913627f, -0.25316778f, -0.04062966f, 0.01537262f, 
    0.00874496f, 0.02286605f, 0.02783286f, 0.01308730f, 0.00015628f, 0.04848019f, -0.04195172f, 0.02481236f, 
    0.03273218f, -0.00214239f, 0.01743375f, 0.06052572f, 0.07617509f, 0.08260760f, 0.10528125f, 0.08913903f, 
    0.02528526f, 0.00290440f, 0.01288666f, -0.00140075f, 0.11519619f, -0.10447076f, -0.09105562f, 0.19818236f, 
    0.02925508f, 0.07288373f, -0.06579836f, 0.03815553f, 0.04213698f, 0.13327457f, -0.06771856f, 0.05950821f, 
    0.22991903f, 0.17965895f, 0.14197542f, 0.09327408f, 0.09631551f, 0.12601011f, 0.00926686f, 0.01553135f, 
    0.00281966f, -0.00739657f, 0.00895624f, 0.01241616f, 0.17435542f, 0.16830297f, 0.16311578f, 0.15724529f, 
    0.07391486f, -0.00702442f, -0.04041323f, -0.01220658f, 0.03938041f, 0.01755218f, 0.02980010f, 0.09500557f, 
    0.06877489f, 0.05169337f, 0.04775204f, 0.01160636f, 0.04540209f, 0.02404525f, -0.00670570f, 0.09419553f, 
    0.04343107f, -0.05878970f, -0.02030146f, 0.02086248f, 0.11538351f, 0.14494215f, -0.10541793f, -0.00627811f, 
    0.13317485f, -0.01033006f, -0.04302980f, -0.00028638f, 0.16214927f, 0.06027633f, 0.03875903f, 0.03364085f, 
    -0.03384535f, -0.01724654f, -0.11271837f, 0.08358353f, -0.04306391f, 0.00569055f, -0.05393300f, 0.03309371f, 
    0.00971504f, -0.05475293f, 0.07693464f, 0.14328925f, 0.04790062f, 0.06735826f, -0.19352473f, -0.12995398f, 
    0.07606556f, 0.04396889f, -0.07176134f, 0.12485577f, 0.01600104f, 0.03830576f, 0.00145393f, -0.01054325f, 
    -0.04188507f, -0.15123986f, -0.03996116f, -0.10207818f, -0.01459842f, -0.04403594f, 0.01165077f, 0.03079971f, 
    0.05928373f, 0.02182211f, 0.03226408f, 0.00199652f, 0.03639087f, -0.00353936f, -0.08938746f, -0.09258420f, 
    0.00323261f, -0.01216757f, -0.09904274f, 0.02427035f, -0.01358056f, -0.01523678f, -0.09071389f, 0.08525910f, 
    -0.21284795f, -0.12189978f, -0.01455654f, -0.06973921f, -0.01642780f, 0.05242661f, -0.00276848f, 0.04023574f, 
    0.01886102f, 0.03999809f, 0.03502544f, 0.04766480f, 0.27375567f, 0.11214018f, 0.16005510f, 0.12704602f, 
    0.02944516f, 0.08641563f, 0.03849742f, -0.03753132f, 0.04037440f, -0.00487649f, 0.08042101f, -0.04269399f, 
    -0.10995869f, -0.04733903f, -0.13355027f, 0.05625242f, 0.05068703f, 0.03163693f, 0.03927872f, -0.02152290f, 
    0.00888503f, 0.03417872f, -0.05074744f, -0.00434994f, 0.08691369f, 0.13547984f, 0.08802259f, -0.08236612f, 
    -0.02687376f, 0.04731313f, 0.01341166f, 0.02837323f, -0.00553277f, -0.00612265f, 0.08413291f, 0.12080501f, 
    -0.13126218f, -0.07231699f, 0.15222053f, -0.16406181f, 0.01661871f, -0.01659590f, -0.01107404f, 0.02496177f, 
    0.11495800f, -0.05639293f, -0.00367916f, -0.07469133f, -0.00073005f, 0.04989525f, 0.00683199f, -0.17245147f, 
    -0.03469727f, 0.05180955f, 0.09086331f, 0.08299434f, -0.01850326f, -0.05508477f, 0.03913181f, 0.00996428f, 
    -0.06742132f, 0.08045533f, -0.11846780f, -0.13818249f, 0.01493950f, 0.03697978f, 0.03251271f, 0.05854737f, 
    -0.08080249f, -0.02113582f, 0.01618017f, -0.04538321f, -0.03762968f, -0.07747655f, 0.01565650f, 0.08260358f, 
    0.00374705f, -0.00790733f, -0.01274019f, -0.02219687f, -0.05509974f, 0.10591063f, 0.05881827f, 0.09190953f, 
    -0.10145847f, 0.15032966f, 0.02394099f, 0.24639922f, 0.08602446f, -0.02491911f, 0.03149675f, 0.08123691f, 
    0.07855239f, 0.05459074f, 0.03231984f, -0.05583635f, 0.06348620f, -0.02927852f, 0.15235665f, 0.12656544f, 
    0.04760044f, 0.04052580f, 0.06764218f, -0.01112743f, 0.01257726f, -0.02932880f, 0.00616295f, -0.01865325f, 
    0.14059649f, 0.27528277f, 0.21671636f, 0.03821173f, -0.01629286f, 0.01146371f, 0.09777360f, -0.01457426f, 
    0.03096272f, -0.04621141f, 0.07302537f, -0.03518195f, 0.32969144f, 0.17883396f, -0.01278790f, 0.10344473f, 
    0.01034611f, 0.04553902f, 0.05336342f, 0.00147111f, 0.07165163f, 0.06335405f, 0.05921820f, 0.08883037f, 
    0.18175420f, 0.14774966f, 0.13936065f, 0.06155867f, 0.06535175f, -0.01788786f, 0.00420356f, 0.13437335f, 
    0.05248397f, 0.04700787f, 0.08116957f, 0.10172516f, -0.19314258f, -0.04797483f, -0.13347429f, -0.09192050f, 
    0.01244314f, -0.00480940f, -0.01218166f, 0.05461741f, -0.07698952f, 0.08280423f, 0.08527755f, 0.03887815f, 
    -0.27668121f, -0.09490262f, 0.01073435f, -0.14472426f, 0.03973378f, -0.03411618f, 0.01961814f, 0.01391423f, 
    0.10006338f, 0.02446423f, 0.05154688f, 0.02438887f, 0.11550746f, -0.05778343f, 0.05688798f, -0.03442904f, 
    0.00354110f, 0.06057674f, -0.03513985f, 0.03964734f, 0.02181715f, 0.02277812f, -0.02814818f, 0.04260540f, 
    0.24133310f, -0.02189076f, 0.01549997f, 0.02086194f, 0.04956526f, 0.01141446f, -0.00384027f, 0.00814185f, 
    -0.05732182f, 0.01792505f, -0.02047133f, -0.01840634f, 0.08770629f, -0.19066845f, -0.06334665f, 0.04307108f, 
    0.00142384f, 0.12747811f, -0.09779740f, 0.04892303f, 0.05432400f, -0.00641894f, 0.04018097f, 0.04617476f, 
    0.34307155f, 0.26380643f, 0.09812216f, -0.01879240f, 0.04657371f, -0.04878321f, 0.06741668f, -0.07087432f, 
    0.00212727f, 0.05853082f, 0.07542737f, 0.04798019f, 0.02866007f, 0.11595979f, -0.04109612f, 0.00712500f, 
    -0.02014932f, 0.01661287f, -0.05075139f, -0.04988798f, 0.02471654f, -0.03890384f, 0.06115388f, -0.07366259f, 
    -0.07291745f, -0.08979091f, -0.05677342f, 0.07487179f, 0.01245195f, 0.08243393f, 0.00033908f, 0.06616250f, 
    0.05687713f, -0.01093333f, -0.06235588f, 0.10066570f, -0.03048871f, 0.01735537f, -0.06476915f, -0.05598395f, 
    0.00327156f, 0.05811452f, -0.03847728f, 0.08240965f, 0.10307662f, -0.02143370f, 0.05203308f, 0.00710783f, 
    0.17009307f, 0.06413016f, 0.02345558f, 0.11000231f, 0.06840402f, 0.03792176f, 0.06349172f, 0.04295871f, 
    0.01636220f, -0.08005928f, -0.01170248f, 0.02269300f, -0.00749102f, -0.15130110f, 0.08719603f, -0.01198379f, 
    -0.03493125f, 0.04301967f, 0.05688017f, 0.02564468f, 0.05240990f, -0.04675727f, 0.09721968f, 0.00157979f, 
    -0.11001504f, -0.06843092f, -0.11950125f, -0.12789002f, -0.00871739f, 0.01827920f, 0.03676428f, 0.05408286f, 
    -0.01934750f, 0.02523493f, 0.03193337f, -0.00410218f, -0.02820987f, 0.06130111f, -0.16034348f, -0.14649387f, 
    0.09942250f, 0.00908027f, -0.04585946f, -0.03063714f, -0.00096817f, 0.00433181f, -0.00861991f, 0.10358497f, 
    -0.17682095f, 0.08053831f, -0.00352149f, -0.06366467f, 0.04794978f, 0.05022513f, -0.01889927f, 0.09735494f, 
    -0.02950115f, 0.11757634f, 0.06134610f, 0.12478833f, 0.23896809f, 0.10193654f, 0.13465491f, 0.15419361f, 
    0.02988797f, 0.08166046f, 0.05404085f, 0.06431101f, 0.03302264f, 0.03410778f, 0.09807386f, 0.01269938f, 
    0.06707817f, 0.01145003f, 0.14502190f, -0.03372944f, -0.02140880f, 0.04503870f, 0.04035835f, -0.01074167f, 
    0.02585716f, 0.04683366f, 0.06246257f, -0.01411636f, 0.22547202f, 0.27650729f, 0.06955882f, 0.04015483f, 
    0.03136156f, -0.02302207f, 0.04977890f, -0.00658568f, 0.01356702f, -0.02081460f, -0.05907192f, -0.00092556f, 
    0.11418032f, 0.23049688f, 0.05464888f, 0.07526612f, 0.07604526f, 0.17507581f, -0.00963869f, 0.00962194f, 
    0.03702546f, 0.12846042f, -0.03771719f, 0.08425069f, 0.29879180f, 0.08109113f, 0.14152001f, 0.06030643f, 
    0.02250378f, -0.03335765f, 0.06930135f, 0.07556121f, 0.02544134f, -0.00985424f, 0.01844374f, 0.06487076f, 
    0.11481233f, -0.06830623f, -0.14132614f, 0.04199602f, -0.00060661f, 0.04369726f, 0.03240829f, 0.03471340f, 
    0.12299051f, 0.04268137f, 0.06121684f, -0.00267937f, -0.13932957f, 0.04920144f, -0.05611593f, 0.08517305f, 
    0.01366775f, -0.00045828f, -0.02205460f, 0.00710954f, 0.09126970f, 0.02762515f, -0.03537484f, 0.07061629f, 
    0.27499160f, 0.06553251f, 0.05547301f, 0.03004711f, 0.11092134f, 0.05578801f, 0.02282935f, 0.01516015f, 
    0.07717177f, 0.13422813f, 0.00719797f, -0.02745122f, 0.12186818f, 0.09578675f, 0.10575297f, 0.04577601f, 
    -0.01358612f, 0.01580090f, 0.07255581f, -0.00540063f, 0.01010195f, 0.10177201f, -0.01392338f, 0.07879040f, 
    -0.12589444f, 0.01155830f, -0.23831320f, 0.16811700f, -0.04075614f, 0.00224271f, 0.03218308f, -0.01878410f, 
    -0.00901972f, 0.00829581f, 0.05914413f, -0.10813721f, 0.11095205f, -0.03728284f, 0.02161926f, -0.01891226f, 
    0.10395398f, 0.04923351f, -0.04439537f, 0.06591401f, 0.07032724f, 0.05093071f, -0.01622669f, 0.02685957f, 
    0.18855332f, -0.16974741f, 0.02608617f, 0.00315833f, 0.17300174f, 0.04925724f, 0.00992336f, 0.02112748f, 
    -0.02847191f, 0.03529130f, 0.06070635f, 0.02962337f, -0.10379462f, -0.01885421f, -0.02811387f, -0.16776855f, 
    0.09709088f, -0.02736425f, -0.08539063f, -0.00643327f, -0.02625041f, -0.01196442f, 0.01859357f, 0.01984558f, 
    -0.16762875f, 0.15946753f, 0.26650113f, -0.06102600f, -0.04574029f, 0.05246737f, 0.05076888f, 0.00272611f, 
    0.10687068f, -0.04079457f, 0.17620805f, -0.03422683f, 0.05251806f, 0.05811797f, 0.15740463f, 0.01309062f, 
    -0.01270536f, -0.02538073f, -0.01319016f, 0.06140946f, -0.02822175f, 0.07656031f, 0.06391731f, 0.02090969f, 
    -0.04665563f, -0.11015377f, 0.07258701f, 0.05323187f, 0.01053228f, 0.01415967f, 0.01275855f, 0.04658902f, 
    0.02192043f, -0.01189902f, 0.03638325f, 0.03488914f, -0.10192917f, -0.10924787f, -0.08515844f, -0.08034956f, 
    0.01358093f, -0.00144493f, -0.02410550f, 0.11648894f, -0.01691044f, -0.00028073f, -0.02039354f, 0.02071470f, 
    0.00325087f, 0.00811476f, 0.02842506f, -0.03750299f, 0.00035338f, 0.00538556f, -0.02724700f, 0.01114225f, 
    -0.03815262f, 0.01548100f, 0.00680874f, -0.01171400f, 0.02415256f, 0.01486244f, -0.03631317f, -0.00957155f, 
    0.00936251f, 0.01043929f, 0.02431313f, -0.03451859f, -0.00463734f, -0.01195495f, -0.01649331f, 0.01520781f, 
    -0.03574074f, 0.02712065f, -0.00629665f, -0.00726751f, -0.02904849f, 0.00942616f, -0.01276163f, -0.00619402f, 
    0.01852434f, -0.03269354f, 0.00063419f, -0.02246162f, -0.01405425f, 0.00482516f, -0.01868538f, 0.01469087f, 
    -0.01592204f, 0.02881220f, 0.01589060f, -0.01411137f, 0.01052895f, 0.01825259f, 0.01644572f, -0.00115704f, 
    -0.00613509f, -0.02685040f, 0.01003045f, -0.02245666f, 0.02357819f, 0.03245905f, 0.02457049f, -0.00446174f, 
    -0.03591154f, -0.00362447f, 0.01111445f, 0.02987545f, -0.03709331f, 0.02810893f, 0.00607892f, -0.03149668f, 
    -0.01088031f, -0.01492006f, 0.00192212f, 0.01967134f, 0.02358685f, 0.00941252f, 0.02274235f, 0.01305233f, 
    0.02586779f, -0.02987227f, -0.01073224f, 0.01573229f, 0.01504414f, -0.02827155f, -0.03982530f, -0.00403303f, 
    -0.03791919f, -0.00866240f, -0.04195728f, -0.02533397f, 0.01786262f, -0.01760034f, 0.00443966f, -0.01370804f, 
    0.01668422f, 0.00672330f, -0.01938825f, -0.01859070f, 0.02279736f, -0.01391141f, -0.01684464f, -0.01807132f, 
    -0.03317301f, 0.01837931f, -0.03127522f, -0.03984151f, -0.00758031f, -0.00181715f, 0.02532880f, 0.00638415f, 
    -0.03020628f, 0.02399340f, 0.00219112f, -0.01878302f, -0.03537419f, 0.01828076f, -0.01080608f, -0.02879681f, 
    -0.02636072f, -0.01689289f, -0.00930068f, 0.01452214f, -0.00605001f, 0.00010301f, -0.02563163f, 0.02227236f, 
    0.01974431f, -0.02103242f, 0.00234343f, -0.03814096f, 0.00318678f, -0.02801202f, -0.01029056f, -0.03201740f, 
    0.01633929f, -0.04215978f, 0.02124602f, -0.01733488f, -0.02041721f, 0.00296337f, 0.00073198f, 0.01255195f, 
    0.00748164f, -0.00388476f, -0.03532301f, 0.01184620f, 0.01885006f, -0.02443107f, -0.01706343f, -0.00166917f, 
    0.02193474f, -0.00663064f, -0.03855985f, 0.02130974f, 0.00958370f, -0.00436570f, -0.03146427f, -0.01280713f, 
    -0.01913214f, -0.03649477f, -0.03003069f, 0.02283049f, -0.00807508f, -0.03931710f, -0.02235398f, 0.00911310f, 
    -0.01709003f, -0.01175502f, -0.02371722f, 0.01751187f, -0.03497771f, 0.02324315f, -0.04121695f, 0.01916554f, 
    0.01538411f, -0.01474343f, -0.00751366f, 0.02424800f, 0.01502438f, -0.02538629f, -0.02975463f, -0.02283157f, 
    -0.00835791f, -0.04288286f, 0.02673645f, -0.00749642f, 0.00315989f, -0.01975215f, 0.03324480f, -0.03518512f, 
    0.00680806f, 0.01734155f, -0.03997290f, -0.03436314f, -0.00845795f, 0.02426819f, -0.03875177f, -0.00983524f, 
    0.01341130f, 0.02480853f, -0.01054277f, 0.01158947f, -0.00225823f, -0.03074767f, -0.02945239f, 0.02163663f, 
    -0.00326330f, 0.00830081f, 0.00790015f, -0.00594544f, -0.03802052f, -0.02421550f, -0.02839034f, -0.00934575f, 
    0.00064780f, -0.02917294f, 0.02782804f, -0.02271499f, 0.02168480f, 0.01004006f, -0.02092449f, 0.00808969f, 
    -0.03188823f, 0.00744230f, 0.00123073f, -0.02282491f, -0.02079462f, 0.01414823f, 0.00776246f, -0.00095041f, 
    -0.03477309f, 0.00865686f, 0.00745613f, 0.01362966f, 0.01173158f, 0.01339914f, -0.02230875f, 0.00116535f, 
    0.02335982f, -0.02435088f, -0.00157309f, -0.01775027f, -0.01791467f, -0.02534247f, 0.01017702f, 0.02091711f, 
    -0.02552865f, 0.00491005f, 0.02083814f, -0.01753728f, -0.00332204f, 0.00887895f, -0.03041294f, -0.00356975f, 
    -0.03088720f, -0.00599431f, 0.02032404f, -0.00472876f, 0.02350456f, -0.00051499f, 0.00861789f, -0.04076058f, 
    -0.01299247f, -0.03772926f, -0.02285580f, 0.01331702f, -0.01389206f, 0.01451839f, -0.02812169f, -0.01943612f, 
    0.00551087f, -0.00839136f, -0.03918558f, 0.00938927f, -0.04057651f, -0.00579538f, -0.00625398f, -0.03505224f, 
    -0.03470032f, 0.02030193f, 0.01566967f, 0.00494351f, 0.00287963f, -0.02749112f, -0.02152358f, -0.00197547f, 
    -0.02088284f, 0.01524666f, 0.02053134f, 0.02500943f, 0.00121991f, -0.00420842f, 0.01573515f, -0.00254331f, 
    0.01679808f, -0.02377689f, 0.01796344f, 0.03369879f, 0.03789878f, -0.03420894f, -0.00751988f, 0.01008000f, 
    -0.03544699f, -0.01131818f, 0.00681920f, -0.03862745f, -0.01225661f, 0.01715631f, -0.00378441f, -0.00459359f, 
    0.01485694f, -0.01332193f, -0.03519928f, -0.00315126f, -0.02584062f, -0.03205961f, -0.01359808f, 0.00566838f, 
    -0.00115687f, -0.02381435f, -0.03514045f, -0.00637839f, -0.00459537f, -0.00898150f, -0.03152657f, -0.01168332f, 
    -0.02548539f, 0.00858579f, -0.01235831f, -0.00294600f, -0.00489787f, 0.01390658f, -0.02776682f, -0.02390225f, 
    0.02975779f, 0.02062302f, -0.00204451f, -0.01320979f, 0.00281289f, -0.02912884f, -0.00440391f, -0.01354734f, 
    0.01841415f, 0.01544011f, -0.01566220f, 0.02638575f, 0.02415092f, -0.03277167f, 0.01335192f, 0.02793565f, 
    0.01901235f, 0.02782913f, -0.02204290f, -0.02831735f, -0.01098663f, -0.02863664f, 0.01871563f, -0.03850254f, 
    -0.01077649f, 0.02090633f, -0.02749644f, 0.01315414f, 0.00555311f, -0.02713075f, -0.01238813f, -0.00520774f, 
    -0.01992892f, 0.00978845f, -0.00704186f, 0.00195677f, 0.01988559f, -0.02473525f, 0.02424285f, 0.01006165f, 
    -0.04396613f, 0.02756501f, 0.00418931f, 0.02464456f, -0.01257510f, 0.00056136f, -0.03549301f, -0.02399738f, 
    0.01283331f, 0.00939277f, 0.01127699f, 0.01077664f, -0.00196233f, -0.04025811f, -0.00233594f, 0.00732376f, 
    -0.03322042f, -0.02276981f, 0.01732621f, 0.00423856f, 0.00070025f, -0.02158040f, -0.02591421f, 0.01145077f, 
    -0.02349602f, 0.00811543f, 0.02097793f, -0.03349158f, 0.01643973f, 0.00181000f, -0.00408104f, -0.00176700f, 
    -0.02128786f, -0.04107188f, -0.04018913f, -0.01068965f, -0.00077459f, 0.00055750f, 0.02005250f, -0.00255075f, 
    0.04014011f, -0.02222465f, 0.01680217f, 0.00803713f, 0.01778866f, -0.00129839f, -0.01517043f, -0.00806218f, 
    0.01076951f, -0.00604887f, -0.02985793f, 0.00436867f, 0.00509695f, 0.02227608f, 0.00530315f, 0.01502601f, 
    0.02042550f, -0.00128031f, 0.01331324f, 0.00475503f, -0.01609066f, 0.02788484f, 0.02255543f, 0.01880687f, 
    0.01704259f, -0.03506041f, 0.01627318f, 0.00163734f, 0.00430436f, 0.01803010f, -0.03147215f, 0.01035979f, 
    0.02672498f, -0.03314178f, -0.04376862f, -0.02831381f, -0.02294591f, 0.01458994f, 0.02703932f, 0.02247180f, 
    -0.03039254f, 0.00978037f, -0.01752843f, -0.00807594f, 0.02061955f, -0.01946677f, 0.00907429f, -0.02181757f, 
    0.01730138f, -0.01094294f, -0.01951182f, -0.03654438f, 0.03010339f, 0.02293346f, -0.00146832f, 0.01850964f, 
    -0.03316186f, 0.01447152f, -0.04103356f, 0.01231969f, 0.02201315f, 0.00190930f, 0.00897402f, -0.01361880f, 
    -0.02253609f, 0.00737496f, -0.00722363f, 0.02176313f, 0.00030477f, 0.02037771f, 0.01559447f, 0.02514789f, 
    -0.04008676f, 0.02344267f, -0.02262861f, -0.01846989f, -0.02453132f, -0.02969390f, -0.03939764f, -0.02704101f, 
    -0.02898493f, 0.02669360f, 0.01498920f, -0.02600567f, -0.01199249f, -0.02258971f, -0.02795963f, 0.01868290f, 
    0.02652213f, -0.01671005f, 0.00052974f, 0.00357387f, 0.02049358f, -0.00385685f, -0.01712012f, 0.02132135f, 
    0.01637957f, -0.02254397f, -0.01262983f, -0.00686380f, -0.01405035f, -0.00700054f, 0.02253574f, -0.04166773f, 
    -0.03593146f, 0.00241804f, -0.02804690f, -0.00270945f, 0.02001459f, -0.01452609f, -0.01668118f, 0.02148994f, 
    0.02757972f, -0.01732606f, -0.00424252f, -0.00572856f, 0.00839294f, -0.03626600f, 0.02120669f, -0.00427775f, 
    0.00473562f, -0.03523016f, -0.02390576f, 0.02410508f, 0.02819080f, 0.02611209f, 0.02146743f, -0.00140954f, 
    0.02670810f, -0.02450361f, -0.00417519f, -0.00661535f, -0.01102020f, -0.00461494f, 0.00684259f, 0.02718656f, 
    0.02136133f, 0.01598280f, 0.02467575f, 0.02683486f, 0.00077322f, 0.00488640f, -0.04225107f, -0.01961624f, 
    0.02380304f, -0.02752747f, 0.02893542f, 0.02716888f, -0.00031672f, 0.03060531f, 0.00782957f, -0.04069165f, 
    -0.04297609f, -0.01045247f, -0.02903503f, 0.01107629f, -0.02333858f, -0.02393296f, -0.00134781f, -0.03416999f, 
    -0.00323191f, -0.00038612f, -0.03261658f, -0.03115620f, -0.03945741f, -0.02774448f, -0.01581938f, -0.01487280f, 
    0.02585652f, 0.00562332f, -0.03294089f, -0.03663319f, 0.00318453f, -0.02580138f, 0.01262160f, 0.00300613f, 
    0.02657734f, 0.01696994f, 0.01638179f, -0.02557810f, 0.02115437f, 0.00029047f, -0.04035377f, 0.02775535f, 
    0.00770058f, 0.02843928f, -0.03257184f, 0.00988284f, -0.02871189f, -0.00468809f, -0.00296628f, -0.00474339f, 
    0.01084821f, 0.00261694f, 0.00444300f, -0.01751954f, -0.00092043f, -0.00523696f, -0.02699741f, 0.00367886f, 
    -0.04184015f, -0.02844433f, -0.02979511f, 0.02378833f, -0.03089704f, -0.00754812f, 0.02417200f, -0.01543216f, 
    -0.00869971f, -0.01647617f, -0.02338694f, -0.00301854f, 0.02064149f, 0.00132303f, 0.02259225f, -0.02615002f, 
    -0.00788721f, -0.01153138f, -0.01596252f, 0.00354518f, 0.00889541f, 0.01664397f, -0.00634307f, -0.00019248f, 
    0.00768345f, -0.03900093f, 0.02178397f, -0.01534937f, 0.02795818f, 0.00197149f, 0.01574327f, -0.03793847f, 
    -0.00367386f, 0.00292814f, 0.02292729f, 0.00741701f, -0.02009146f, 0.00052805f, -0.02296253f, 0.00400014f, 
    -0.00206662f, -0.02850828f, -0.01954764f, 0.01559141f, -0.02262672f, -0.03715620f, -0.03568448f, -0.01957720f, 
    -0.01053319f, -0.02561093f, 0.00929535f, -0.00091008f, -0.02980692f, 0.00338382f, -0.01947228f, 0.01288876f, 
    -0.00944781f, -0.02010736f, -0.02848731f, -0.02606010f, 0.01905276f, -0.00029614f, -0.02646239f, -0.03599883f, 
    -0.01077432f, 0.00963695f, -0.01888054f, 0.01236509f, 0.02789111f, 0.01648447f, -0.01269559f, 0.03405910f, 
    -0.03670481f, 0.01560733f, -0.00619984f, 0.01464426f, -0.00346791f, 0.01130755f, 0.00793809f, -0.03200381f, 
    -0.00686080f, -0.01272666f, 0.02346883f, -0.00957615f, -0.03308965f, 0.01488783f, -0.02838488f, 0.01317512f, 
    0.01522704f, -0.01187536f, 0.00831624f, 0.02019159f, 0.02001995f, 0.00414646f, -0.00745007f, -0.00701339f, 
    0.00702926f, -0.03975189f, -0.02434301f, 0.01689471f, 0.00541032f, 0.01701557f, -0.01041637f, -0.01165278f, 
    0.01057864f, -0.02208813f, 0.00177565f, -0.00846330f, 0.00278818f, -0.00897729f, -0.01381909f, -0.00119127f, 
    -0.00026094f, -0.04048731f, 0.02036281f, 0.01832284f, -0.00414472f, -0.04127305f, 0.00642942f, -0.02986616f, 
    0.02179665f, 0.01595747f, -0.03958717f, -0.00571523f, 0.00999915f, -0.01396007f, -0.00126977f, -0.03337073f, 
    0.02424973f, -0.00348578f, 0.03318323f, 0.01622666f, 0.01214400f, -0.00979211f, 0.01925427f, -0.01430236f, 
    0.01564214f, -0.03501865f, 0.00785564f, 0.01299888f, 0.00417056f, -0.00177450f, 0.02144811f, -0.01477000f, 
    0.00921005f, 0.03023945f, -0.01958843f, 0.01713750f, 0.00703750f, -0.02027708f, 0.03900879f, -0.01743788f, 
    -0.03550433f, 0.00909778f, -0.00649264f, -0.02873520f, -0.03579215f, -0.00974446f, -0.01062022f, 0.01314040f, 
    0.01735127f, -0.03246396f, -0.02359412f, -0.00891459f, 0.00619229f, 0.00992443f, -0.01077746f, 0.01425041f, 
    -0.02555113f, 0.02669023f, 0.02703817f, -0.00233457f, 0.02655849f, -0.03862958f, 0.03703044f, 0.00187473f, 
    0.02832486f, -0.03764990f, -0.00534979f, 0.01051809f, -0.00323149f, 0.01529902f, 0.03470831f, -0.00481667f, 
    0.00718231f, -0.01949001f, -0.01328778f, 0.01718356f, 0.01034286f, 0.02381740f, 0.02341034f, -0.02356656f, 
    -0.01335591f, -0.00317788f, 0.01702108f, 0.01142514f, -0.03123803f, -0.02452106f, -0.00033762f, -0.01111629f, 
    -0.02420351f, -0.02000046f, -0.02474166f, -0.01902466f, -0.02636722f, -0.02958571f, 0.01328875f, -0.00501315f, 
    -0.00486891f, 0.02759947f, 0.02288779f, -0.00466463f, -0.00212743f, 0.02210562f, -0.02129548f, 0.01014322f, 
    -0.03536816f, -0.01467395f, 0.00591719f, 0.02741825f, -0.02539344f, 0.00376693f, -0.03054915f, -0.02239973f, 
    0.02497073f, -0.00218255f, -0.01870729f, -0.02035017f, -0.01898900f, 0.00648867f, -0.00958273f, -0.01072899f, 
    -0.01958827f, 0.01449206f, -0.02660218f, 0.02515236f, 0.01604955f, 0.01036030f, -0.00306876f, -0.03727540f, 
    -0.02544765f, 0.02498604f, -0.01776514f, -0.04103423f, 0.03590728f, 0.03144171f, 0.01427647f, -0.01774266f, 
    0.03412946f, -0.02679144f, 0.00385198f, -0.01421087f, -0.01338631f, -0.03292717f, 0.01847754f, -0.00676800f, 
    0.00754146f, -0.02692638f, 0.03230323f, 0.01710819f, -0.00575110f, -0.00471353f, -0.01146191f, 0.02171574f, 
    0.01956140f, 0.00125839f, 0.02474304f, 0.00915942f, -0.02590415f, 0.00969797f, 0.01882946f, 0.00480688f, 
    0.03671147f, 0.01226059f, -0.01355231f, 0.02977886f, -0.03415843f, -0.00633612f, -0.01131739f, -0.03434848f, 
    -0.01842911f, 0.00717875f, 0.01409243f, -0.02482176f, -0.03342360f, 0.02838164f, -0.00269543f, -0.00201744f, 
    -0.03149483f, -0.00515322f, 0.03445138f, 0.03551274f, 0.01006688f, 0.01544813f, 0.00065352f, -0.02449034f, 
    -0.01479732f, 0.00642247f, -0.03052950f, -0.00007211f, -0.03621895f, 0.02692824f, -0.02095119f, 0.01572338f, 
    0.01799604f, 0.01017813f, -0.01409194f, -0.04137248f, -0.01598885f, -0.00473167f, -0.01303020f, 0.01205007f, 
    -0.00679323f, 0.02203658f, 0.01093185f, -0.01535499f, 0.02483960f, -0.03246152f, 0.02114592f, -0.03005768f, 
    0.02302438f, -0.01969334f, -0.00584764f, -0.00756055f, -0.02685276f, 0.00405583f, -0.02957707f, 0.01107123f, 
    -0.00625499f, -0.02596779f, -0.03121978f, -0.02769840f, 0.00963198f, -0.01701142f, 0.01982149f, -0.02999646f, 
    -0.02391999f, -0.01665969f, 0.01264708f, 0.02461384f, 0.03742953f, 0.01003382f, -0.02640782f, -0.00343536f, 
    -0.00595672f, -0.01560333f, 0.01480169f, -0.00253891f, 0.01314875f, -0.00038858f, 0.02915936f, -0.03323228f, 
    -0.00056337f, 0.01898850f, -0.02003576f, -0.02934420f, 0.03006210f, 0.02130958f, 0.03179847f, 0.02809097f, 
    0.00310208f, 0.01746232f, 0.00368719f, -0.00965628f, -0.00025099f, 0.00233269f, 0.00956873f, -0.02887879f, 
    -0.01422455f, 0.02530936f, -0.02627526f, -0.00516519f, -0.00822900f, 0.00263588f, -0.00470553f, -0.03786925f, 
    -0.03421838f, 0.01226262f, 0.00046486f, -0.02413337f, -0.02387506f, 0.01810399f, 0.00801278f, -0.02900333f, 
    0.01468870f, -0.01440340f, 0.03044963f, -0.00099504f, -0.00136385f, -0.00802492f, -0.02106397f, -0.03879011f, 
    -0.03443617f, -0.03252718f, 0.01494097f, 0.02401660f, 0.01462111f, 0.01227558f, -0.02690547f, 0.00358597f, 
    -0.01767526f, 0.01880067f, -0.02292472f, -0.00363090f, 0.01739982f, -0.02542432f, 0.00324898f, 0.00431472f, 
    0.01525480f, -0.00667843f, 0.01078309f, 0.02946886f, 0.02112679f, 0.03300166f, 0.01518981f, 0.01099462f, 
    -0.02589402f, -0.02451325f, -0.03291134f, -0.00541180f, -0.00225218f, 0.00077364f, -0.00214088f, -0.00321779f, 
    -0.00387192f, -0.00774601f, 0.02654484f, -0.02729273f, 0.00262226f, -0.01634270f, 0.00488117f, 0.00613636f, 
    0.02684413f, -0.00335119f, -0.01522871f, -0.01005427f, 0.01436886f, -0.01241386f, -0.02838100f, 0.03011881f, 
    0.03589137f, 0.01759256f, -0.03156556f, -0.02880303f, -0.00521484f, 0.00822740f, -0.00529110f, 0.00933889f, 
    0.00279353f, -0.00693047f, 0.00753438f, 0.03195707f, 0.03460363f, -0.01148256f, -0.03289124f, 0.00491153f, 
    -0.01535218f, -0.03324825f, 0.00118058f, -0.02823039f, 0.01918937f, -0.01326401f, 0.00782468f, -0.01207711f, 
    -0.02480461f, -0.03003990f, 0.02700618f, -0.00519501f, 0.00583218f, -0.00037858f, -0.01564209f, 0.01757262f, 
    -0.00857342f, 0.02831696f, 0.03315159f, 0.00528534f, 0.01296818f, -0.00106770f, -0.01714172f, -0.01770900f, 
    0.01115445f, 0.00436404f, -0.00306545f, -0.01502302f, 0.01867718f, 0.01466084f, 0.02145095f, 0.02588057f, 
    0.00506143f, -0.00467228f, -0.02520332f, 0.01951691f, -0.01586881f, 0.01004499f, 0.01384490f, -0.00056267f, 
    -0.02144324f, -0.01241876f, -0.03973590f, 0.00903276f, -0.00176094f, -0.03969858f, 0.02994498f, 0.01809247f, 
    0.03080811f, -0.04510257f, -0.02152959f, -0.00524164f, 0.03832690f, -0.02835402f, -0.01998820f, 0.03139203f, 
    0.02773132f, -0.03343840f, -0.03462546f, 0.01475617f, -0.02354328f, -0.00492737f, -0.00870798f, -0.03609017f, 
    -0.02796313f, 0.01670927f, -0.02782710f, -0.01243683f, 0.00529591f, -0.02041979f, 0.01755893f, 0.00727542f, 
    -0.01992548f, 0.00477433f, -0.00541878f, 0.01852578f, -0.02238571f, -0.03222239f, -0.03277807f, 0.01831825f, 
    -0.03322018f, -0.04007394f, 0.04054802f, 0.00021266f, 0.03452072f, 0.02654992f, -0.00518694f, -0.01745514f, 
    -0.00045380f, 0.02186741f, -0.02827795f, 0.02613410f, 0.01947081f, -0.00976526f, -0.00519427f, -0.01339456f, 
    0.00252788f, -0.01547326f, 0.01139686f, 0.02402954f, -0.02420254f, -0.00572038f, 0.02858167f, -0.00810246f, 
    -0.01204406f, -0.02749379f, -0.03097759f, 0.02648650f, -0.01914355f, -0.01115583f, -0.01211995f, -0.02524048f, 
    0.02273917f, 0.00080480f, -0.02955737f, -0.01054307f, 0.02300690f, -0.00068107f, 0.02675399f, -0.03901406f, 
    -0.03699550f, -0.02829772f, 0.00835300f, 0.03036308f, 0.00019028f, 0.02245280f, -0.00175376f, -0.03080594f, 
    0.01472567f, 0.02611932f, -0.02844333f, -0.02983632f, 0.01054705f, -0.00748755f, -0.02386424f, -0.00205189f, 
    -0.01532609f, -0.03959551f, 0.02992277f, -0.03450488f, -0.02464438f, -0.03075248f, -0.03995853f, -0.00168018f, 
    -0.03556103f, 0.01645089f, 0.00003978f, 0.02632741f, 0.00308055f, 0.02835166f, 0.00454353f, 0.02751231f, 
    -0.00938126f, 0.00825997f, -0.01650712f, 0.02487737f, 0.01738803f, -0.01752694f, 0.01764156f, -0.01002965f, 
    0.00075962f, 0.00618357f, -0.02135317f, 0.01327929f, -0.00338157f, 0.02072655f, -0.01793529f, 0.00716575f, 
    0.00690146f, -0.03029844f, -0.02299741f, 0.02384851f, -0.02902118f, 0.02618775f, -0.00721904f, -0.01660946f, 
    -0.01764897f, -0.00582797f, -0.00634655f, 0.01448678f, 0.00306550f, -0.02131956f, -0.01926570f, -0.03850104f, 
    0.02832154f, 0.00387519f, -0.01828607f, 0.02668016f, 0.02424898f, 0.03029446f, -0.02337039f, -0.03669368f, 
    -0.02891293f, 0.02123355f, 0.02210759f, -0.03648199f, -0.01101961f, -0.02491642f, -0.03185698f, 0.03158434f, 
    -0.02576337f, -0.01427564f, -0.00789353f, -0.00634509f, -0.02383350f, -0.03633042f, -0.00292844f, 0.02888253f, 
    -0.01515119f, -0.03344174f, -0.03070433f, -0.00728558f, -0.03622812f, -0.00349877f, 0.02497955f, 0.00096028f, 
    0.00521828f, -0.00953828f, 0.01788856f, -0.03918613f, 0.00397309f, -0.01620029f, -0.02768384f, 0.03119421f, 
    -0.01369902f, -0.00165660f, -0.03662591f, -0.03619326f, 0.00610043f, 0.01850024f, 0.00014542f, 0.01252904f, 
    0.02199556f, 0.00040523f, 0.03433366f, 0.00158483f, -0.00503009f, -0.02229718f, -0.03431248f, 0.01046362f, 
    -0.01455208f, -0.00724258f, -0.01621607f, 0.00633109f, 0.03555269f, -0.01429042f, 0.00895157f, 0.01703341f, 
    -0.03702470f, -0.03020743f, 0.00347715f, -0.01037284f, 0.02179624f, -0.02576998f, -0.01223674f, -0.01487789f, 
    0.01763421f, -0.00948982f, 0.01086858f, -0.00834411f, 0.03303334f, -0.00621689f, 0.02645076f, -0.00641323f, 
    -0.00128014f, -0.00589286f, 0.00871558f, -0.00014728f, -0.02902003f, -0.02709145f, -0.03907498f, 0.00632837f, 
    -0.01986820f, 0.02716502f, 0.01504999f, -0.03152817f, -0.03755768f, -0.02055932f, 0.01520624f, -0.01846972f, 
    0.01911223f, 0.02311429f, 0.04214893f, -0.02186069f, -0.03869921f, -0.03471784f, -0.01958357f, -0.03813623f, 
    -0.02048647f, -0.01710216f, 0.02444495f, -0.03579542f, -0.03094107f, -0.03235805f, -0.01409382f, -0.02232356f, 
    0.02850412f, -0.03049730f, 0.01783810f, -0.02103645f, 0.03637211f, 0.03255064f, -0.03325939f, -0.01941145f, 
    0.02262491f, -0.01345462f, -0.00177611f, -0.03322646f, -0.02456813f, 0.00672934f, -0.01144343f, 0.01261970f, 
    0.02812514f, -0.02529118f, -0.01781461f, -0.02656384f, 0.02330987f, 0.01546096f, 0.02307791f, -0.01435573f, 
    0.02735852f, -0.01220351f, -0.03944835f, -0.00761414f, -0.02031775f, -0.03615391f, 0.01198782f, 0.02648493f, 
    -0.02960960f, -0.03058878f, 0.03373251f, 0.02441076f, 0.01755418f, 0.02815579f, -0.02819954f, 0.00180792f, 
    0.00059648f, -0.01784847f, -0.01439919f, 0.01098694f, -0.00920779f, -0.02227357f, -0.03900567f, 0.03603341f, 
    -0.01297555f, -0.00274330f, 0.01104801f, -0.01576673f, -0.02229722f, 0.02504856f, 0.02455575f, 0.01789248f, 
    -0.04289491f, 0.04257716f, -0.00264567f, 0.01807596f, -0.00516962f, 0.00206434f, 0.01047207f, 0.02397133f, 
    -0.01618544f, -0.02224767f, 0.00829301f, 0.00351807f, -0.02452639f, 0.03957478f, -0.00721556f, 0.01509525f, 
    -0.01981454f, 0.00350670f, -0.02286623f, -0.02498133f, 0.02341722f, -0.03185958f, -0.00430917f, 0.00117280f, 
    0.00705953f, -0.01479162f, -0.01911434f, -0.01114786f, 0.03462891f, 0.03352997f, 0.01510147f, 0.03882461f, 
    0.01692026f, 0.02074563f, -0.01356053f, -0.02261816f, -0.01124622f, 0.01117721f, -0.02126078f, 0.00188259f, 
    0.01523124f, 0.00302711f, -0.02664440f, 0.01532453f, -0.03861419f, 0.02903067f, -0.03724284f, -0.02654352f, 
    -0.02143830f, 0.00127076f, 0.01894758f, 0.01050280f, -0.02299422f, -0.02844322f, 0.02407528f, -0.03559286f, 
    -0.03319198f, -0.00257778f, -0.01359468f, 0.02940211f, -0.02578414f, 0.00944240f, 0.01693691f, 0.03475102f, 
    0.03013693f, -0.02564268f, -0.03078082f, -0.00776958f, -0.02396623f, -0.03050665f, 0.03140767f, -0.01026048f, 
    -0.02243742f, 0.01824988f, 0.01171448f, -0.01871548f, 0.03019671f, 0.01063282f, -0.03639546f, -0.03052290f, 
    0.03602649f, -0.00699037f, 0.00246356f, -0.02838880f, 0.01051872f, -0.00709606f, 0.01848149f, -0.03349356f, 
    -0.04435031f, -0.00497306f, -0.01455595f, -0.03374524f, 0.00099067f, 0.02912420f, 0.02259521f, 0.01693900f, 
    -0.03766184f, 0.01486092f, 0.00091631f, 0.03461751f, 0.01327167f, 0.02403934f, -0.01013900f, 0.01453898f, 
    -0.02109249f, -0.00429556f, 0.03748878f, 0.01026891f, -0.00578301f, -0.03671480f, -0.02879113f, -0.01175356f, 
    0.01679737f, 0.03368233f, -0.02355609f, -0.02526139f, 0.01610111f, 0.01040891f, -0.03197291f, 0.01142810f, 
    -0.20167576f, -0.03934934f, 0.02871206f, 0.02862417f, -0.04019214f, -0.08757448f, 0.01340843f, 0.02992223f, 
    -0.04275197f, 0.01494805f, -0.07110939f, -0.02490311f, -0.06624144f, -0.13402335f, 0.16867709f, 0.19600210f, 
    -0.10378088f, -0.05249261f, 0.00298528f, 0.00939817f, -0.01123090f, 0.07471254f, 0.01596709f, 0.09272687f, 
    0.10705413f, -0.00582481f, -0.08986241f, -0.00972646f, -0.03201292f, -0.00843960f, 0.07206411f, -0.06427696f, 
    0.03820651f, 0.00695356f, 0.03373061f, 0.03584514f, -0.01629157f, 0.05591152f, -0.09519243f, 0.11854456f, 
    0.15416060f, 0.07072926f, 0.02923055f, 0.04517512f, -0.02882748f, 0.03960677f, 0.07252274f, 0.04133175f, 
    0.11466768f, -0.11443026f, 0.06003689f, 0.21052743f, 0.03152778f, -0.02457874f, 0.02682808f, 0.03767833f, 
    0.05002419f, 0.05965466f, 0.06812083f, 0.05695957f, -0.02498399f, -0.16106831f, 0.13415341f, 0.08657891f, 
    -0.03143609f, -0.07434545f, -0.08427478f, 0.07806776f, -0.05855398f, 0.07711934f, 0.09085625f, 0.11726399f, 
    0.04715059f, -0.05167121f, -0.00082633f, 0.10856841f, 0.17750759f, 0.07767763f, 0.06398612f, 0.07625242f, 
    0.05967644f, 0.02397620f, 0.05200566f, -0.01435325f, 0.10287780f, 0.10961308f, -0.05033525f, 0.03513111f, 
    0.04658149f, -0.05602445f, 0.07042714f, -0.02017143f, -0.01691887f, 0.01982209f, -0.01982884f, -0.10639963f, 
    0.08035132f, -0.00188012f, -0.03118991f, -0.10904427f, -0.07872216f, -0.05231287f, 0.07171224f, 0.08630084f, 
    0.09220471f, -0.06755783f, -0.00671083f, -0.05934509f, -0.27345905f, 0.15857278f, -0.08187278f, 0.06415551f, 
    0.13300097f, -0.05132375f, -0.03530335f, -0.11495802f, 0.04082866f, 0.00045471f, 0.08796111f, 0.01943720f, 
    0.10634692f, -0.13135819f, 0.14387783f, 0.03926350f, -0.01270649f, -0.01692355f, -0.05335025f, -0.06549975f, 
    -0.04520279f, -0.01153568f, -0.07271796f, -0.07769105f, 0.03054618f, -0.02809397f, 0.05370516f, -0.04643415f, 
    0.03745877f, -0.04581149f, 0.03158719f, 0.00405987f, 0.01250879f, 0.05127283f, 0.02278253f, -0.00091868f, 
    -0.00376433f, 0.09639253f, 0.14336991f, 0.05303481f, -0.00444056f, 0.10108221f, 0.03615606f, -0.00360073f, 
    0.03329743f, -0.05876623f, 0.01327311f, 0.00912688f, 0.04033044f, 0.06782608f, 0.05133313f, -0.06378434f, 
    0.06561827f, 0.11400564f, 0.03211793f, 0.04559949f, -0.06444538f, 0.01786378f, -0.02257334f, 0.07807680f, 
    0.21087499f, -0.00980879f, -0.08456329f, 0.05509082f, -0.05242578f, 0.02436908f, -0.00634884f, -0.11316353f, 
    -0.08848482f, -0.00887770f, 0.04040614f, 0.03380184f, 0.12495127f, 0.12080490f, 0.03936653f, 0.03664114f, 
    0.12050237f, 0.05256149f, -0.00641886f, -0.03387380f, 0.05090981f, -0.04913044f, 0.04831968f, 0.11024646f, 
    -0.22806531f, -0.01597421f, -0.07899269f, -0.03522721f, -0.03542421f, 0.08540627f, -0.00509983f, -0.03240647f, 
    -0.07191823f, -0.03125031f, -0.14859650f, -0.06226678f, 0.17495134f, -0.13801326f, 0.01944756f, 0.08176398f, 
    0.10353942f, 0.05935344f, -0.07179984f, -0.07110511f, 0.07689039f, 0.07800994f, 0.04878930f, 0.03913146f, 
    0.17057301f, 0.04214062f, -0.09124666f, 0.09286033f, 0.01556989f, -0.07785621f, 0.08507854f, 0.06105339f, 
    -0.01091015f, 0.02966932f, -0.10122345f, -0.02404279f, -0.01076700f, -0.18046568f, -0.00609034f, -0.07152700f, 
    0.07913157f, 0.08404303f, -0.05925382f, -0.07337417f, 0.05376904f, -0.00999257f, -0.01548694f, -0.09667519f, 
    0.07666123f, 0.06596711f, -0.13641855f, -0.09503616f, -0.02216798f, -0.03978603f, -0.06415664f, 0.03245810f, 
    -0.10488991f, -0.12972844f, -0.03250421f, 0.07046857f, 0.06257159f, 0.12692894f, 0.18684183f, 0.00176515f, 
    0.13560398f, -0.06117752f, -0.04726624f, 0.04597217f, 0.07865512f, -0.09263465f, 0.02660030f, 0.07473391f, 
    0.36158922f, -0.15516402f, 0.10937994f, 0.00231784f, 0.05426222f, 0.00069395f, 0.03490146f, -0.12535980f, 
    0.00227587f, 0.04212369f, -0.04980748f, 0.05810962f, -0.30574733f, -0.21017005f, 0.03553927f, 0.27713296f, 
    -0.11337101f, -0.00451209f, -0.04899487f, -0.07878090f, -0.02782814f, 0.05417852f, 0.00472712f, 0.09641486f, 
    -0.10129325f, -0.15973580f, 0.01016295f, 0.15855782f, 0.17004445f, 0.14139371f, 0.04480974f, 0.16632459f, 
    0.05440407f, 0.16027766f, 0.08560360f, 0.01292103f, -0.21676950f, -0.11948552f, 0.08973727f, 0.22508678f, 
    0.03300661f, -0.07912095f, -0.03925014f, -0.04036630f, -0.06073256f, -0.02797613f, 0.05591065f, 0.05200214f, 
    0.05206797f, -0.02144568f, -0.03603314f, 0.12139056f, 0.02846175f, 0.07336692f, -0.07634232f, -0.04196757f, 
    0.05224743f, -0.07315020f, -0.00648987f, 0.04908719f, 0.06940953f, -0.03546769f, -0.07277027f, -0.01543816f, 
    0.03252278f, 0.03482552f, 0.00499466f, -0.06952022f, 0.01298180f, 0.06055511f, -0.13731910f, 0.05791039f, 
    0.42824370f, -0.05166743f, 0.06007796f, 0.04884747f, -0.02653778f, 0.03153655f, 0.04332769f, -0.06372244f, 
    0.07431394f, 0.01490961f, -0.04768605f, 0.09648520f, -0.05119776f, 0.08669556f, 0.10941780f, 0.18686552f, 
    -0.01661434f, 0.04560805f, 0.06735290f, 0.06037365f, 0.06275871f, 0.01764918f, -0.00195913f, -0.00782024f, 
    -0.06201533f, 0.00214298f, 0.02402938f, 0.06715322f, 0.04569623f, -0.08478326f, -0.00425589f, -0.07685545f, 
    0.07528988f, -0.10932448f, 0.01782437f, 0.01995693f, -0.24230625f, 0.00951692f, 0.15383343f, -0.04242669f, 
    -0.16042288f, 0.03349419f, 0.03061084f, 0.05669098f, 0.06954313f, -0.03725504f, 0.01326340f, -0.03742282f, 
    0.28125769f, -0.09615358f, 0.01034557f, -0.07006859f, -0.04791588f, -0.00284779f, 0.02102275f, -0.08588392f, 
    -0.05238410f, 0.00862006f, -0.16543821f, 0.02132831f, 0.19044930f, -0.09374984f, 0.05494385f, 0.07096207f, 
    -0.00228967f, 0.04297464f, 0.16229722f, 0.03149013f, -0.05048133f, 0.05286469f, 0.04488412f, 0.04244157f, 
    0.10607473f, -0.03279433f, 0.06261115f, 0.25839609f, -0.09460194f, 0.01933571f, 0.13515581f, 0.02601906f, 
    0.11046093f, 0.06211004f, 0.01944898f, -0.02456797f, -0.19432060f, -0.05583794f, -0.01622068f, 0.13908352f, 
    0.11163143f, -0.02750628f, 0.00594762f, 0.00037749f, -0.00449096f, 0.00235264f, 0.06090812f, 0.04287247f, 
    -0.31124729f, 0.16773397f, -0.12792933f, 0.02140840f, 0.12894915f, 0.08185136f, 0.04925186f, -0.05157292f, 
    -0.02433875f, 0.13285717f, 0.00616207f, 0.04222415f, -0.09876713f, -0.13553450f, -0.06480411f, -0.02577777f, 
    0.02085894f, 0.07997549f, 0.11721463f, -0.01820381f, 0.11345754f, -0.02400366f, 0.03287024f, 0.09815751f, 
    -0.18569207f, -0.14438821f, 0.01748528f, 0.12624542f, 0.10660696f, 0.08158230f, 0.02094265f, 0.03757110f, 
    0.07810308f, -0.06143481f, 0.00862539f, 0.01631938f, -0.28319275f, 0.06305365f, -0.00815720f, -0.07926402f, 
    -0.00397887f, 0.05105361f, 0.14726017f, -0.05130843f, -0.01382134f, 0.04143475f, 0.00636511f, 0.04086304f, 
    0.09571688f, 0.04187918f, -0.06352392f, -0.00242246f, 0.09692907f, -0.01006880f, -0.07084671f, 0.03442389f, 
    0.04078616f, 0.07366975f, -0.00295449f, 0.07719541f, -0.13631053f, -0.22151326f, 0.05648040f, 0.05139129f, 
    -0.04481525f, -0.07316534f, 0.13646647f, -0.01236582f, -0.11865415f, -0.00801457f, -0.14476490f, 0.07812586f, 
    -0.14974314f, 0.08865735f, 0.10269325f, -0.04956679f, 0.12236233f, 0.06998793f, -0.09409136f, -0.02859413f, 
    -0.01020626f, -0.03489653f, 0.03532122f, -0.01505616f, -0.60791630f, -0.02760906f, 0.07165928f, 0.01985757f, 
    0.13677236f, 0.01784762f, -0.00557143f, -0.10986830f, -0.03241053f, 0.01313327f, 0.02787864f, -0.03317627f, 
    0.03970631f, -0.08576188f, -0.11380669f, -0.03846477f, 0.05300615f, 0.04707277f, -0.03992580f, 0.08245309f, 
    0.01222394f, -0.03952980f, 0.04019260f, -0.01503597f, -0.04551910f, -0.15006581f, 0.00739767f, -0.23483045f, 
    -0.02230481f, 0.01886218f, 0.08291310f, 0.03788982f, -0.09388579f, -0.01922164f, -0.01573740f, 0.01955845f, 
    -0.17230700f, -0.16902377f, -0.01154470f, 0.11044377f, 0.00895582f, -0.09111046f, -0.02280714f, -0.09418399f, 
    -0.04911350f, -0.00899428f, 0.07320149f, 0.12030888f, 0.04125207f, 0.13744351f, 0.02094352f, 0.10379217f, 
    0.02926205f, 0.06132560f, 0.04477309f, 0.14034289f, 0.13361110f, 0.05206688f, 0.05959782f, 0.07339194f, 
    0.02144695f, 0.12095211f, 0.13718319f, 0.04979670f, -0.01791955f, 0.10879228f, -0.02808888f, 0.02386523f, 
    -0.10316248f, -0.02261358f, 0.13124892f, 0.09472984f, -0.17847551f, -0.07175521f, 0.28493631f, 0.10061788f, 
    0.05994762f, 0.02856814f, 0.03022528f, 0.01229668f, 0.02877593f, 0.01073314f, -0.05185401f, -0.08294369f, 
    0.25503430f, 0.24960107f, 0.16139202f, 0.22946005f, -0.01653317f, 0.02182733f, 0.07769458f, 0.02296286f, 
    0.02513658f, -0.00967792f, 0.04682697f, 0.04001870f, 0.00913081f, -0.00084328f, 0.01040971f, 0.07362706f, 
    0.04995425f, -0.03721614f, -0.07210424f, -0.01260056f, 0.04594538f, -0.08084504f, -0.05303650f, -0.04468343f, 
    -0.11065462f, -0.08305816f, 0.11964435f, 0.03250890f, -0.00395414f, 0.02961713f, -0.12225676f, 0.04542497f, 
    0.01871114f, 0.02909477f, 0.03298527f, 0.04455108f, -0.13826889f, -0.16309094f, -0.21072473f, -0.12376400f, 
    -0.01465330f, -0.02031786f, -0.01089992f, 0.11886592f, -0.10715631f, 0.01208086f, -0.05404662f, -0.01732826f, 
    0.07650755f, 0.22175840f, 0.02056647f, 0.07805994f, 0.13985574f, -0.04507989f, 0.04591898f, 0.02237938f, 
    0.09590438f, -0.02571435f, -0.10698865f, -0.11410037f, -0.09385307f, -0.08486579f, 0.05528229f, 0.09226920f, 
    -0.02193983f, -0.00733767f, 0.04919604f, -0.01206518f, 0.02071548f, -0.00822986f, -0.01644075f, 0.11514566f, 
    -0.19479623f, -0.07481559f, -0.07804876f, -0.21906127f, 0.02412789f, -0.00623125f, 0.03278323f, -0.01236327f, 
    -0.02682336f, -0.09062956f, 0.04155725f, -0.02526405f, -0.13048644f, 0.04956330f, -0.20921353f, -0.11434912f, 
    0.02912972f, -0.01098594f, 0.05369991f, -0.00923085f, 0.02884278f, 0.01225122f, -0.02757185f, -0.07289161f, 
    -0.30456606f, 0.21909179f, -0.00885230f, -0.06111863f, 0.00909099f, 0.01672153f, 0.03901286f, 0.03377961f, 
    -0.08408666f, -0.06253912f, -0.16290957f, -0.02231015f, 0.00286625f, 0.06737103f, -0.01919367f, -0.05557532f, 
    0.05182084f, -0.02609065f, 0.03728608f, -0.06263383f, -0.06339112f, -0.07004528f, 0.11541437f, 0.03665560f, 
    -0.11193922f, 0.06368522f, 0.04841611f, 0.11103137f, -0.05513962f, 0.07748220f, -0.03865616f, -0.02600107f, 
    0.08880733f, -0.10322317f, -0.02326030f, 0.07174665f, 0.13193546f, 0.04025554f, -0.17289746f, -0.03348182f, 
    0.05298077f, -0.15769294f, -0.00393281f, -0.06976581f, -0.03638326f, 0.05026655f, -0.12002267f, 0.04011485f, 
    0.03549640f, -0.23053150f, -0.08890605f, 0.18242478f, -0.05406681f, -0.02433335f, 0.05322389f, 0.14400028f, 
    -0.00583634f, -0.00571168f, 0.01445742f, 0.00363384f, 0.09231927f, -0.03743589f, 0.09379315f, 0.15186708f, 
    0.09389976f, 0.05092471f, 0.03971181f, 0.05764263f, -0.02807485f, -0.07620063f, 0.02038986f, -0.02059229f, 
    -0.02968210f, -0.01609203f, 0.00536640f, -0.01169845f, -0.02470708f, -0.04050740f, 0.03000094f, 0.00298566f, 
    -0.00888893f, -0.04014649f, -0.00144534f, -0.02646821f, 0.00528456f, -0.03914461f, -0.03125881f, -0.03580829f, 
    -0.00609482f, 0.01539428f, 0.02153166f, 0.01278876f, -0.02896797f, -0.01958089f, -0.02133398f, -0.00161774f, 
    0.00701793f, 0.01769935f, -0.01781621f, -0.02732137f, -0.01918359f, 0.01928290f, -0.00200214f, -0.03165248f, 
    0.01262564f, -0.00778012f, -0.01845710f, -0.02968948f, -0.03794042f, -0.02465017f, -0.00791609f, 0.00889681f, 
    0.01801872f, 0.01877125f, -0.02836902f, -0.00067518f, 0.01506383f, 0.02029895f, 0.01117432f, 0.01542344f, 
    -0.01056440f, -0.02222041f, -0.01685819f, -0.03170029f, -0.03201913f, 0.00241779f, -0.02603519f, -0.01357682f, 
    -0.04008581f, -0.02209458f, 0.01819672f, 0.02094849f, 0.00680050f, -0.00236902f, -0.01973683f, -0.01206144f, 
    0.01276893f, -0.01487965f, -0.02710007f, -0.03725525f, -0.01754578f, 0.00533115f, 0.01327738f, 0.01553264f, 
    0.01434848f, -0.02693542f, 0.01997740f, 0.00411408f, 0.00358762f, -0.01643455f, -0.02391279f, 0.00853251f, 
    -0.01521595f, 0.00725341f, 0.01002717f, -0.04104722f, -0.03480687f, -0.02786119f, -0.01991966f, -0.01325175f, 
    -0.01359860f, 0.00581267f, 0.00036935f, -0.00050332f, 0.02244199f, -0.00758779f, 0.01157317f, 0.02899018f, 
    -0.01781844f, 0.02413281f, -0.03675937f, -0.03627186f, -0.02851124f, 0.00602349f, -0.00908904f, -0.01694168f, 
    -0.00083793f, 0.00369116f, -0.01344733f, 0.01122458f, 0.01415343f, -0.00428909f, -0.03932606f, -0.02208688f, 
    -0.01416196f, 0.02219919f, 0.00718947f, -0.00368646f, 0.00364321f, -0.00211406f, 0.00569220f, -0.01532814f, 
    -0.01387538f, -0.02149264f, 0.00540038f, -0.00908044f, -0.03471088f, -0.02196434f, 0.00330382f, 0.02723071f, 
    -0.03660639f, -0.01259520f, -0.02821989f, 0.00276661f, 0.00181957f, 0.02600468f, -0.03739377f, 0.01959873f, 
    -0.03994383f, 0.00874279f, -0.02039318f, 0.00097227f, 0.01655676f, 0.01181420f, 0.00108806f, -0.02327933f, 
    -0.02776217f, 0.00770921f, -0.03988772f, -0.01342321f, -0.02694811f, 0.00418412f, 0.00757600f, -0.03357400f, 
    -0.00871901f, 0.01639345f, -0.00988117f, -0.02968676f, -0.01123002f, -0.00521682f, 0.02388240f, -0.01138228f, 
    -0.00161235f, -0.03358175f, 0.01704321f, 0.01193096f, -0.01487051f, -0.02096933f, -0.00144704f, -0.02063932f, 
    0.02793392f, 0.01383566f, -0.02123928f, -0.02451263f, -0.01509253f, -0.00421688f, -0.04040980f, -0.02866353f, 
    0.00022721f, -0.00609524f, 0.00453626f, 0.00978379f, 0.00867448f, -0.04020527f, -0.03053622f, -0.01727725f, 
    -0.01648510f, 0.00256406f, -0.02244006f, 0.00483604f, -0.02566361f, 0.00622945f, -0.01663611f, 0.01127715f, 
    -0.02228415f, 0.00065644f, 0.01096532f, -0.03733682f, -0.04107909f, -0.03063217f, -0.02056725f, 0.01064613f, 
    -0.00810140f, -0.03582528f, 0.00741007f, -0.04122801f, -0.00385637f, 0.02297600f, -0.01866269f, -0.02258807f, 
    0.02438061f, -0.00704411f, -0.03705731f, -0.03685297f, -0.01226730f, 0.02975716f, 0.00322654f, -0.02056089f, 
    0.00932703f, -0.02941830f, 0.01898552f, 0.00911508f, -0.01472691f, 0.01447997f, -0.01450530f, -0.01527050f, 
    -0.02537871f, -0.01362681f, 0.00443177f, 0.02666679f, 0.00969324f, -0.02994941f, 0.01268529f, -0.01863456f, 
    -0.01715714f, 0.00149737f, 0.01177463f, 0.01817600f, -0.03474004f, -0.01372916f, -0.00066453f, 0.00718311f, 
    -0.02842714f, 0.01047700f, 0.02821027f, -0.02662662f, 0.01674243f, -0.03562576f, 0.02423754f, 0.01533983f, 
    -0.00103731f, -0.02360161f, 0.01939487f, 0.01050795f, -0.02943441f, -0.03309675f, -0.00080832f, 0.02523305f, 
    -0.01602978f, -0.00941482f, -0.02699281f, 0.01466609f, 0.02641581f, -0.00914175f, 0.01312154f, 0.03007780f, 
    -0.00421242f, 0.00630740f, -0.03570151f, 0.01154453f, 0.01690705f, -0.00183851f, -0.01390477f, -0.02797984f, 
    -0.01073443f, 0.02655380f, 0.00916179f, 0.02768344f, -0.02092724f, 0.00011350f, -0.01568945f, -0.02310700f, 
    0.02083587f, 0.01288773f, 0.01203058f, -0.03117419f, 0.01714152f, 0.02624285f, 0.01144596f, 0.00496000f, 
    0.00485514f, -0.01189150f, -0.03665126f, 0.01682437f, 0.02843334f, -0.00739316f, -0.03054212f, 0.00455304f, 
    -0.03215249f, -0.00769650f, -0.03642579f, 0.01512793f, 0.02551528f, -0.00078856f, -0.00090155f, -0.03489132f, 
    -0.01623398f, -0.02718914f, 0.01471116f, 0.01258123f, 0.01594450f, 0.01446872f, -0.00957945f, -0.01034773f, 
    -0.00441585f, -0.04185681f, -0.01986066f, -0.03152214f, 0.01100517f, -0.04100760f, 0.00898200f, 0.01377004f, 
    -0.00011685f, -0.00456429f, -0.03841162f, -0.03376112f, -0.02311499f, -0.02450351f, 0.02944503f, -0.02818493f, 
    0.02051463f, 0.02346628f, -0.02244775f, -0.02728409f, 0.00809027f, -0.01730918f, -0.03652897f, 0.00790696f, 
    0.02759882f, 0.02820673f, 0.01590292f, -0.03321711f, 0.01272021f, -0.01083192f, -0.03634441f, 0.00274587f, 
    0.00797260f, -0.03712249f, 0.02204826f, -0.01025614f, -0.02566288f, -0.02576890f, 0.01227214f, 0.00254642f, 
    0.00869926f, 0.01600572f, -0.00271052f, -0.01593059f, -0.02488831f, 0.01996702f, 0.02408616f, -0.04028159f, 
    -0.03879632f, 0.00474504f, 0.01255770f, -0.01220592f, -0.02977826f, -0.01683238f, 0.00911360f, 0.01247879f, 
    0.00270355f, -0.02450365f, 0.01038562f, 0.02192754f, -0.00448677f, -0.03676521f, -0.00884450f, 0.01800525f, 
    0.02067719f, 0.01136432f, 0.00168037f, 0.01171762f, 0.02800944f, 0.00661519f, -0.00572345f, 0.00146399f, 
    0.00349816f, 0.02216831f, -0.01880626f, 0.00293323f, -0.03671250f, 0.02552300f, -0.03643002f, -0.01002356f, 
    -0.00999114f, -0.00203927f, 0.01950447f, 0.02289524f, -0.04188132f, -0.03809292f, -0.02644193f, -0.03931688f, 
    -0.01603365f, 0.02289055f, -0.00851878f, 0.02269896f, -0.03669125f, 0.01906711f, 0.01105524f, -0.01952034f, 
    -0.00414405f, 0.02551177f, 0.00315035f, -0.03822092f, -0.00861217f, -0.00959882f, 0.00318380f, 0.01093842f, 
    0.01374168f, 0.01537907f, -0.03484420f, -0.02115935f, -0.00603429f, -0.03710021f, -0.01256797f, -0.03884687f, 
    -0.03208666f, -0.00974367f, -0.03293572f, 0.02953587f, -0.03441818f, 0.01680975f, 0.01800168f, -0.02787850f, 
    0.01998650f, -0.01067884f, 0.00030737f, 0.01820257f, -0.03564529f, -0.04167344f, -0.02594684f, 0.00690446f, 
    -0.00649174f, -0.01301072f, -0.01826560f, -0.01007454f, 0.01494968f, -0.02419905f, 0.00379332f, -0.03548884f, 
    -0.03130604f, 0.00899282f, -0.01679641f, -0.01788171f, -0.02092291f, -0.00558566f, -0.02693294f, -0.02959948f, 
    0.00489450f, 0.02953288f, -0.00758616f, 0.00811636f, -0.03532597f, -0.03433619f, -0.01942730f, -0.02312685f, 
    0.01655407f, -0.00183025f, 0.00969950f, -0.01702576f, -0.00220479f, 0.02515442f, -0.01309717f, -0.02808389f, 
    -0.02927518f, 0.00817999f, 0.01037381f, 0.00598684f, -0.01130914f, -0.03413940f, -0.03022701f, -0.03433564f, 
    -0.04198444f, 0.00109759f, -0.00592823f, -0.01439009f, 0.00333263f, 0.02390357f, -0.02636609f, 0.00276197f, 
    0.02871315f, -0.03954352f, -0.03060073f, 0.02546689f, -0.01169757f, 0.02684923f, -0.03939630f, 0.02527904f, 
    0.01604402f, 0.00407941f, -0.03377927f, 0.00535730f, 0.01900283f, -0.03779093f, 0.00788759f, -0.02993396f, 
    -0.01012825f, -0.03326765f, -0.02494849f, -0.03564937f, -0.00607191f, -0.00814926f, -0.02386258f, -0.04000130f, 
    0.02744135f, -0.01439263f, 0.01616585f, -0.03585740f, -0.01784320f, 0.02714196f, 0.02472421f, 0.02231272f, 
    0.01051544f, -0.03729910f, -0.00394477f, 0.02879501f, -0.03857739f, 0.02831020f, -0.03465448f, -0.01442683f, 
    0.02905356f, 0.02909832f, 0.01461779f, 0.01361611f, 0.02778212f, -0.02003871f, 0.00117914f, 0.02186506f, 
    0.00332368f, -0.02079520f, -0.01964002f, 0.02547950f, -0.01633333f, 0.01781305f, -0.00428915f, -0.02411801f, 
    0.00379848f, 0.01455057f, -0.00717180f, 0.00287910f, 0.02722070f, 0.01774164f, -0.00626025f, 0.01725318f, 
    -0.03933205f, -0.02063404f, 0.00863408f, 0.00147811f, -0.00398607f, -0.00095879f, 0.01259557f, -0.01877872f, 
    -0.01163708f, -0.00532732f, -0.03086565f, 0.01845794f, 0.02442252f, -0.00315235f, 0.01100350f, 0.02433788f, 
    -0.03242470f, -0.00774975f, -0.04163077f, -0.00011490f, -0.02802893f, 0.02518008f, -0.00339076f, -0.03249775f, 
    0.01058542f, -0.04088210f, 0.01087335f, -0.02471681f, -0.02658444f, -0.00302684f, 0.00523138f, 0.02149111f, 
    -0.03996802f, -0.01746199f, -0.00589246f, -0.03027953f, -0.00378918f, -0.03774671f, 0.02113461f, 0.00788011f, 
    -0.02667926f, -0.03561814f, 0.01748921f, 0.00221037f, 0.01728707f, 0.02545518f, 0.02256989f, -0.02463314f, 
    -0.01664418f, -0.03900211f, -0.04197672f, -0.00750977f, -0.01500225f, -0.00472246f, -0.00191438f, -0.03502997f, 
    0.02017409f, 0.02736237f, 0.02792364f, 0.02334504f, -0.00920479f, 0.01504080f, -0.00083870f, -0.00999055f, 
    -0.01690393f, -0.01610956f, 0.00067467f, -0.03928987f, -0.03848886f, -0.03400612f, 0.01822769f, -0.02925894f, 
    -0.01503992f, -0.01539829f, 0.01774817f, 0.01511628f, 0.00635830f, 0.01107062f, -0.03696411f, -0.03965112f, 
    -0.01984791f, -0.00021211f, 0.01413302f, -0.04122392f, 0.02026094f, -0.02201757f, -0.00725418f, -0.00069254f, 
    -0.01770389f, -0.01171815f, 0.00531286f, -0.02666134f, -0.01549463f, -0.00445693f, 0.00874396f, -0.02233834f, 
    0.01748686f, -0.03968283f, -0.02750956f, -0.04174989f, -0.02478581f, -0.03056658f, 0.01686910f, 0.01603813f, 
    -0.01507387f, -0.04177135f, 0.02158910f, -0.02828234f, 0.02003220f, -0.03889309f, 0.00575946f, -0.03297757f, 
    -0.03576932f, -0.02604862f, -0.03862257f, -0.03610233f, -0.03169168f, 0.02286296f, 0.01002577f, 0.02257190f, 
    0.01631241f, -0.03795001f, -0.01811229f, -0.01362458f, -0.04205123f, 0.01275629f, -0.02178206f, -0.00142729f, 
    -0.02826141f, -0.03518272f, 0.01364801f, -0.02101686f, -0.01898702f, -0.03466310f, 0.01393108f, -0.01391984f, 
    -0.02002176f, 0.02054395f, -0.04101550f, -0.00732091f, 0.00105533f, 0.00804169f, -0.02021059f, 0.02358854f, 
    0.02299553f, -0.02101429f, 0.01229671f, 0.01228464f, 0.02216532f, 0.00425540f, -0.02801976f, -0.00374757f, 
    -0.03007882f, -0.03650783f, 0.02336801f, -0.00664638f, -0.00165440f, -0.04057986f, -0.02907842f, -0.02295176f, 
    -0.01150799f, 0.01438019f, -0.00679375f, -0.00486614f, -0.01873809f, 0.02841763f, 0.00695325f, -0.03475704f, 
    0.00508227f, 0.00962127f, 0.02566114f, 0.02062114f, 0.00982200f, 0.01962402f, -0.04018622f, 0.02429515f, 
    -0.00547423f, 0.02514099f, 0.02184703f, 0.00521308f, -0.03523658f, -0.00222294f, -0.02070195f, 0.00609325f, 
    -0.00015647f, -0.01675844f, -0.00429562f, 0.02335880f, 0.02112168f, -0.03932934f, -0.02941150f, -0.03316747f, 
    -0.00914190f, 0.01674613f, -0.00649222f, -0.01715447f, -0.00740923f, 0.01123306f, -0.02337790f, -0.02812516f, 
    0.01928063f, 0.02615500f, -0.00400765f, -0.02237454f, 0.02529381f, 0.00383831f, 0.01759931f, -0.02944927f, 
    -0.03161356f, 0.02830157f, -0.01614574f, -0.00539184f, 0.02664779f, -0.02820550f, 0.00947910f, 0.02012036f, 
    -0.07844460f, 0.03195233f, -0.09369223f, -0.08390386f, 0.14632656f, 0.13956591f, 0.14050668f, 0.06271868f, 
    -0.01071129f, -0.04068694f, 0.00468402f, 0.06050312f, -0.03805696f, 0.09868988f, 0.00102623f, 0.04335107f, 
    0.21215676f, -0.00896164f, 0.02250941f, 0.03273390f, 0.02804292f, 0.07219363f, 0.01122584f, 0.00159427f, 
    -0.16743580f, 0.19215266f, -0.16040646f, -0.07915366f, 0.02005974f, 0.05883801f, -0.07240828f, 0.04202450f, 
    0.02979800f, 0.06751832f, -0.11829130f, 0.10624620f, 0.12189054f, 0.00464160f, 0.11910196f, -0.03775680f, 
    -0.19203219f, -0.01150269f, -0.02924275f, -0.03247843f, 0.04988332f, -0.14723012f, -0.04092444f, 0.07874843f, 
    -0.03714184f, 0.04783458f, 0.06627701f, -0.13895290f, -0.10584446f, -0.04440040f, 0.07437802f, 0.05865373f, 
    0.04136544f, -0.03182494f, 0.04693630f, 0.09606384f, -0.03486406f, -0.12412238f, -0.06020006f, -0.09125789f, 
    0.06347049f, 0.04711198f, 0.06820100f, 0.03356784f, 0.07451733f, 0.02659084f, 0.09867641f, 0.01835006f, 
    -0.04399730f, 0.11058869f, 0.05331997f, -0.18746807f, -0.10273765f, -0.03257240f, -0.04242579f, -0.07299271f, 
    0.00677719f, -0.05342695f, 0.05731884f, 0.02440851f, 0.14076987f, -0.18290971f, 0.04444332f, 0.02861566f, 
    -0.01816146f, -0.05955868f, 0.03846315f, -0.05259783f, 0.07085545f, 0.18558705f, 0.01019961f, -0.06144153f, 
    0.19246937f, 0.17660435f, -0.09092910f, 0.14971481f, 0.00420580f, 0.05471589f, 0.08697677f, 0.06964023f, 
    0.08558435f, 0.14022177f, 0.09642685f, -0.00099525f, -0.03631225f, -0.00025397f, -0.06421199f, 0.07636283f, 
    -0.11598956f, -0.13259447f, 0.02577113f, 0.02150339f, -0.01902815f, 0.02819407f, -0.01850866f, 0.09251875f, 
    0.28788003f, -0.02342570f, 0.05248737f, 0.06768452f, -0.07082415f, 0.04461380f, 0.02516697f, 0.14097233f, 
    0.11012562f, 0.04318656f, -0.02817659f, 0.01702359f, 0.00250380f, -0.15604007f, -0.12572198f, 0.15637684f, 
    0.03237028f, 0.00051724f, -0.03616306f, 0.13627817f, -0.12045143f, 0.03723951f, 0.02255157f, 0.06650047f, 
    0.02915751f, 0.05443502f, 0.02330456f, 0.11591223f, 0.09797098f, 0.06541446f, -0.05895964f, -0.03910779f, 
    0.00348097f, 0.05098751f, 0.07490384f, 0.00897483f, -0.05570638f, -0.07797432f, 0.07947650f, 0.12061779f, 
    0.14186884f, -0.07387343f, -0.08331148f, -0.07993090f, -0.13641959f, 0.03408847f, -0.02607263f, 0.05543168f, 
    -0.03791749f, 0.00645716f, 0.01639064f, -0.04153700f, -0.03981014f, 0.04885818f, -0.04006615f, 0.10414693f, 
    0.08576906f, -0.07937928f, 0.04947948f, 0.01791141f, -0.33686012f, -0.08052211f, 0.17036647f, 0.07338669f, 
    0.10434125f, 0.07202685f, -0.03796747f, 0.04736732f, 0.05749351f, -0.13275942f, 0.05613687f, 0.01206311f, 
    0.25874388f, -0.17029317f, 0.08483739f, -0.00709899f, -0.05583304f, -0.09775805f, 0.01247503f, -0.03392212f, 
    -0.00717395f, 0.00563317f, 0.04797474f, 0.07151080f, 0.16470096f, -0.03403127f, -0.03426930f, -0.10471439f, 
    0.00741022f, 0.00592186f, -0.03184148f, 0.06759363f, -0.02366727f, -0.01591782f, 0.10139483f, 0.00003981f, 
    0.04007773f, 0.14415018f, -0.10771326f, -0.04963556f, -0.00456535f, -0.10681866f, 0.02025950f, 0.01371748f, 
    0.09735975f, 0.09339240f, -0.00437064f, -0.03981034f, 0.12794614f, 0.02576944f, 0.08060225f, 0.04596331f, 
    -0.03117115f, 0.04238538f, 0.03649481f, -0.06349079f, 0.05243933f, -0.00866777f, -0.01116024f, 0.07257957f, 
    -0.05509340f, -0.15649149f, -0.02764660f, 0.04731811f, 0.02701404f, 0.10406626f, -0.01782667f, 0.10570123f, 
    -0.04861740f, 0.09154714f, 0.02433539f, 0.00674751f, 0.10712133f, -0.10312880f, 0.15429163f, 0.14819536f, 
    0.07264397f, -0.00922070f, -0.02836077f, -0.06407957f, 0.06433775f, -0.04754378f, 0.01131054f, -0.06145112f, 
    0.11567473f, -0.23961106f, -0.08474692f, -0.07753431f, 0.13168953f, 0.00577186f, 0.10671948f, 0.02165891f, 
    -0.07347497f, 0.05180635f, -0.03922773f, 0.07202882f, -0.07442421f, -0.03266281f, -0.20265014f, -0.05451734f, 
    0.18772963f, 0.00682325f, -0.00987944f, 0.11519156f, 0.05092935f, 0.13443828f, 0.05472310f, 0.05080122f, 
    -0.27216917f, 0.20620292f, -0.16792424f, -0.07799838f, -0.00783444f, -0.01397445f, -0.04156082f, 0.08071578f, 
    0.02304041f, 0.03096391f, 0.01265195f, -0.04281274f, 0.12580357f, 0.17353642f, -0.12524223f, -0.15287846f, 
    0.03451222f, 0.04563709f, -0.02530649f, 0.09847024f, 0.02806451f, -0.00674113f, 0.02369815f, -0.03046186f, 
    -0.15083984f, 0.16020067f, -0.22191040f, 0.01291055f, -0.03468566f, 0.05321939f, -0.08985939f, -0.09142599f, 
    -0.07062142f, -0.08616386f, 0.06953043f, -0.03522130f, -0.00054065f, 0.02658444f, -0.05036441f, -0.12198475f, 
    0.02390553f, -0.05021014f, 0.08705270f, -0.04239412f, 0.02302788f, 0.04941522f, -0.04504423f, 0.07552440f, 
    -0.13260858f, -0.19791384f, 0.22259437f, 0.11010305f, -0.06066851f, 0.01626754f, 0.05795656f, 0.09173833f, 
    0.05854067f, 0.02864496f, 0.00865640f, 0.01777458f, -0.04363353f, -0.26596636f, 0.06383945f, 0.16817060f, 
    0.04725294f, 0.06689612f, 0.04744383f, 0.08334560f, 0.00886387f, 0.04821597f, 0.15745214f, -0.06853518f, 
    -0.03953019f, -0.00792016f, 0.07767243f, 0.10974731f, 0.17725645f, -0.09046987f, 0.04259698f, -0.03947931f, 
    -0.12108649f, -0.12640536f, 0.02930447f, 0.00628367f, 0.07504597f, 0.06292199f, -0.06435644f, 0.06226177f, 
    0.10548153f, 0.10182733f, 0.05104140f, 0.09283888f, 0.11116904f, -0.03422688f, 0.12680134f, 0.01814251f, 
    0.11959697f, 0.03449887f, -0.03207317f, 0.16451170f, 0.03325340f, -0.01337314f, -0.00694486f, -0.06051787f, 
    0.01153813f, -0.00470497f, 0.00687424f, -0.01215424f, 0.12432000f, 0.09106295f, -0.17001149f, -0.24948792f, 
    0.08609965f, 0.04446923f, 0.07648668f, 0.06528802f, -0.05086874f, -0.03709511f, 0.00542608f, 0.00924059f, 
    0.17546311f, 0.10236327f, -0.00360214f, -0.14061129f, -0.08462885f, -0.03406389f, 0.06462203f, -0.03130985f, 
    0.01313583f, 0.18352365f, 0.02565384f, -0.05934284f, -0.15956676f, 0.06099055f, 0.03890893f, -0.01207151f, 
    -0.12606236f, -0.02171956f, -0.03133120f, 0.02448920f, -0.01551759f, 0.07174698f, -0.08112989f, -0.06472930f, 
    0.11206423f, 0.08330852f, -0.00580401f, 0.14410606f, 0.02786653f, -0.13352492f, -0.01485754f, 0.01068209f, 
    -0.02384602f, 0.10203639f, 0.08175948f, 0.03592978f, -0.22680539f, 0.08795728f, -0.04931071f, 0.06814895f, 
    -0.10359631f, -0.00652823f, 0.01645220f, 0.07344692f, -0.02621798f, -0.02727896f, 0.10817974f, 0.03878482f, 
    0.02588584f, 0.19602443f, -0.11220495f, 0.01960087f, 0.14159265f, -0.07675524f, -0.12099240f, -0.08518550f, 
    -0.11617823f, 0.00216362f, -0.02642084f, 0.06770866f, 0.16017140f, -0.04127824f, -0.14164141f, -0.00024120f, 
    -0.01566110f, -0.08089156f, 0.06711461f, -0.03138925f, -0.04900445f, -0.02932638f, 0.06240225f, 0.04073738f, 
    0.05859204f, -0.01012314f, 0.05667247f, -0.09768294f, 0.05954977f, 0.00293950f, 0.00978882f, -0.01382540f, 
    0.01943487f, 0.06314358f, -0.02568891f, 0.19927093f, 0.16645035f, 0.11915782f, -0.17144714f, -0.19488448f, 
    0.11387745f, 0.06638739f, 0.05909778f, 0.06247017f, 0.03903648f, -0.06117579f, -0.08161706f, 0.00699016f, 
    0.19743453f, 0.00579645f, 0.08756219f, 0.14611806f, -0.04070551f, -0.15754132f, 0.02512223f, 0.06930342f, 
    0.05082631f, -0.03275764f, -0.04078564f, 0.10633240f, -0.20202683f, -0.08311985f, -0.18552648f, -0.01934904f, 
    0.02590596f, -0.00057836f, -0.04599844f, 0.07378202f, 0.02554872f, -0.07475384f, 0.14043827f, 0.00798448f, 
    -0.13882162f, 0.02683258f, -0.10213406f, -0.13625462f, 0.02573290f, 0.02673688f, 0.04579223f, 0.04708080f, 
    0.07733324f, 0.02048468f, 0.05734239f, 0.01637613f, 0.06609534f, -0.07497779f, 0.19185026f, -0.10728047f, 
    0.00406798f, 0.03377170f, 0.07531442f, -0.04353113f, 0.07326926f, 0.10975332f, -0.07769917f, 0.01263876f, 
    -0.13922593f, 0.10426260f, -0.02748506f, -0.12191398f, 0.16273695f, -0.01398248f, 0.05765317f, 0.04932165f, 
    -0.08894090f, 0.01791930f, 0.03318705f, 0.15066512f, 0.09942213f, -0.03436821f, 0.12455332f, 0.02695900f, 
    0.06671935f, 0.07437573f, 0.05269974f, 0.06528941f, 0.05371689f, -0.01469195f, 0.08773819f, -0.04207999f, 
    -0.19921428f, -0.25743002f, -0.00164711f, 0.16767804f, 0.09029602f, 0.10668669f, -0.04994261f, -0.01913822f, 
    0.07009441f, 0.04548702f, 0.12625624f, -0.10381064f, -0.10580160f, 0.03471534f, -0.03159013f, 0.14603278f, 
    0.11946293f, -0.10220424f, 0.10580143f, -0.02335628f, 0.05157033f, 0.03819222f, -0.10766578f, -0.02671253f, 
    -0.05889103f, 0.18346526f, 0.09488219f, 0.07192215f, 0.15591274f, 0.12252927f, -0.04255374f, -0.05889231f, 
    0.07755347f, -0.02277075f, -0.07362071f, 0.06977127f, 0.11937701f, 0.06087877f, -0.07860874f, 0.01933445f, 
    0.01355865f, 0.04415631f, 0.01729239f, -0.01981870f, -0.04369949f, -0.20934448f, -0.02720090f, 0.10081367f, 
    0.29248405f, 0.00666233f, 0.02570920f, -0.08582713f, -0.02914794f, 0.03235910f, -0.01529494f, 0.02690083f, 
    -0.00354924f, 0.16583750f, 0.11976907f, -0.04208399f, -0.10816658f, 0.01120788f, 0.02410322f, -0.15265290f, 
    -0.02733170f, 0.03717503f, 0.01785353f, -0.01208666f, -0.11366779f, 0.00336229f, -0.03327201f, 0.19217040f, 
    0.29700771f, -0.02871898f, -0.12392692f, -0.08946861f, -0.03576785f, 0.07647419f, -0.07803842f, 0.03104608f, 
    0.07479171f, 0.04089513f, -0.01937782f, -0.18240371f, -0.18113901f, -0.19330190f, -0.05291569f, 0.09356704f, 
    0.18920290f, 0.00869147f, 0.08138972f, -0.02275102f, 0.03627937f, 0.04656755f, -0.01490061f, 0.01250711f, 
    0.30692199f, -0.22762512f, 0.10723640f, 0.02168028f, 0.00790848f, -0.08230518f, 0.06684206f, -0.00324527f, 
    0.03962979f, -0.19102916f, -0.00726149f, -0.17357649f, 0.27551162f, 0.00670178f, 0.07071505f, 0.07163217f, 
    -0.09112786f, -0.02780102f, -0.06409059f, 0.05330981f, 0.06806950f, -0.09198765f, 0.02660381f, -0.05065015f, 
    0.39829513f, -0.13927682f, -0.03672991f, 0.02612673f, -0.03454395f, -0.00367358f, -0.01668336f, 0.01878025f, 
    0.00015144f, -0.04044731f, 0.02569829f, 0.08709339f, -0.05974386f, -0.11146608f, -0.01170843f, 0.09900831f, 
    0.05679223f, -0.10956491f, -0.10504219f, 0.02649633f, -0.10472567f, 0.01659131f, 0.13284227f, -0.08168052f, 
    -0.20409331f, -0.02755130f, 0.14538592f, 0.06577338f, 0.11767820f, 0.07501397f, 0.09685294f, -0.01187817f, 
    0.00894265f, 0.11063979f, 0.08706400f, -0.03386496f, -0.04780055f, 0.13558863f, 0.03235712f, 0.14604366f, 
    -0.08095742f, -0.19170180f, -0.01559743f, 0.00525577f, 0.04776307f, 0.13321319f, -0.04086563f, -0.03687079f, 
    0.07482475f, 0.06998313f, -0.07418956f, 0.03293328f, -0.00300138f, 0.12053270f, -0.14701736f, 0.06131742f, 
    0.07594462f, 0.09279928f, 0.18803780f, 0.05290185f, 0.12663563f, 0.16541001f, 0.15905820f, -0.06743010f, 
    -0.09207588f, 0.07575779f, -0.04308879f, -0.11067207f, -0.04436630f, -0.01158472f, 0.01672313f, 0.02803906f, 
    0.33861274f, -0.11632749f, 0.05460760f, -0.03856701f, -0.04705764f, -0.02349692f, 0.07037325f, -0.02203719f, 
    0.16394791f, 0.09313936f, 0.13633737f, 0.17893896f, 0.20054840f, 0.18560968f, -0.09270583f, 0.03897134f, 
    0.08880828f, -0.04545216f, 0.06356026f, 0.01645463f, 0.10720462f, 0.02657054f, -0.07297763f, -0.03844394f, 
    -0.12509705f, -0.00446276f, -0.17700693f, 0.14553636f, 0.06151509f, 0.15829606f, -0.01086073f, 0.11328161f, 
    0.06218424f, 0.00606933f, 0.12236072f, 0.10156243f, 0.02089166f, 0.04118265f, 0.15683174f, 0.13965832f, 
    -0.03310487f, 0.00666628f, 0.04551459f, 0.08859458f, -0.00980067f, 0.00683621f, -0.09447797f, 0.01961017f, 
    -0.04022205f, 0.08999493f, -0.10999161f, -0.03112483f, -0.02081580f, 0.05770709f, -0.08606143f, -0.00166454f, 
    0.06485567f, 0.01832358f, -0.04434152f, -0.05405417f, -0.18105488f, 0.13559087f, -0.15145601f, -0.08632929f, 
    0.04300817f, 0.06808114f, 0.01287220f, -0.08634878f, 0.03531137f, 0.00507204f, -0.09383514f, -0.01034185f, 
    0.02475474f, 0.11690947f, 0.03937306f, 0.11015612f, -0.00869475f, -0.03990903f, 0.02097575f, -0.05396501f, 
    -0.09047931f, 0.00101753f, 0.08611276f, 0.05370857f, 0.02894074f, 0.08357508f, 0.15413696f, 0.04399581f, 
    0.08841661f, 0.07599927f, 0.07010744f, -0.00579987f, -0.02085932f, 0.03697051f, 0.00576810f, 0.10804690f, 
    0.29051957f, -0.07465640f, -0.09701744f, 0.29722977f, 0.11421555f, 0.06057735f, 0.11233748f, -0.02826861f, 
    -0.05618555f, 0.15656756f, 0.07552820f, 0.08979018f, 0.11378890f, -0.21289481f, 0.10256861f, 0.06334159f, 
    -0.00134260f, 0.10051850f, 0.12428880f, 0.20557979f, -0.09387303f, 0.01565882f, -0.01442846f, -0.03210621f, 
    -0.11117429f, 0.25544214f, -0.05796676f, 0.07266635f, 0.13331394f, 0.16483746f, 0.12856539f, 0.10234742f, 
    0.12138206f, 0.09496562f, 0.13928132f, 0.03087287f, -0.01069824f, -0.06176668f, -0.04345198f, 0.08562438f, 
    -0.11853320f, -0.01687903f, -0.10963792f, 0.09009257f, 0.07630916f, 0.06768728f, -0.01861626f, 0.13133234f, 
    0.31000856f, 0.12541348f, 0.02790858f, 0.00217267f, 0.14479339f, 0.01334527f, -0.01685671f, -0.02464994f, 
    0.05637195f, 0.07295431f, 0.01732987f, 0.05551465f, 0.13855904f, 0.06764452f, -0.11080217f, 0.15216281f, 
    0.14628984f, -0.07958207f, -0.06473645f, -0.00461684f, 0.08391849f, 0.08242740f, 0.08469493f, 0.01573570f, 
    -0.14733481f, 0.32844689f, 0.09162625f, 0.00807076f, 0.08576067f, 0.07187130f, 0.10823555f, 0.08479141f, 
    0.17799653f, 0.07461106f, -0.01818855f, 0.06277507f, 0.03849248f, 0.10390618f, -0.03669966f, -0.06025846f, 
    0.08176800f, -0.07708279f, 0.01567694f, 0.00932459f, 0.01577730f, 0.16350541f, 0.01917730f, 0.03917962f, 
    -0.24167827f, 0.12202009f, 0.03107521f, 0.11773954f, 0.01752430f, -0.03226079f, 0.00021340f, 0.09679421f, 
    -0.10263290f, 0.04780147f, 0.15089947f, 0.07438508f, -0.04459789f, 0.09179313f, -0.01593374f, 0.17625211f, 
    0.00333861f, 0.02076584f, 0.06332360f, 0.03364309f, -0.03479417f, -0.07737254f, 0.10565110f, -0.01802370f, 
    -0.12349182f, -0.17725095f, 0.06599150f, 0.05990103f, 0.00891736f, 0.08194125f, -0.14231279f, 0.04854331f, 
    0.08807660f, -0.01876999f, 0.04985180f, 0.11051899f, -0.10887594f, 0.19519475f, 0.13050877f, 0.35101041f, 
    0.12993897f, -0.01890038f, -0.10505054f, 0.09208245f, -0.10668557f, -0.03017580f, 0.09477599f, 0.02756173f, 
    -0.07653749f, 0.02034830f, -0.00272949f, 0.20361178f, 0.02190932f, 0.00160299f, -0.03154875f, 0.11831634f, 
    0.08298323f, 0.15069562f, 0.07908329f, 0.05881159f, 0.01795305f, 0.11729550f, 0.02626643f, -0.12802687f, 
    0.16241081f, 0.16437541f, 0.06976205f, 0.06504244f, 0.05673632f, 0.07944670f, 0.03078405f, -0.02536891f, 
    -0.24947235f, 0.04868926f, -0.09513792f, 0.08405716f, 0.02333615f, 0.10062860f, 0.09129449f, 0.03686197f, 
    0.11292427f, 0.07514433f, 0.18151452f, -0.00699412f, 0.31995004f, 0.16728939f, 0.00810961f, 0.01313506f, 
    0.01859418f, 0.02117233f, 0.00231041f, 0.02815107f, 0.14200123f, 0.07594904f, 0.01727046f, -0.06869718f, 
    -0.02839089f, -0.09012484f, 0.16021903f, -0.00430014f, -0.11951166f, 0.06390755f, 0.03680751f, -0.19923271f, 
    -0.09702646f, -0.05956570f, -0.10118542f, -0.05817348f, 0.29199350f, -0.00635063f, -0.08558922f, -0.09800987f, 
    -0.07137028f, 0.14321376f, 0.01554821f, 0.09578067f, 0.19846173f, 0.06379939f, 0.10088760f, 0.08331183f, 
    0.03629329f, -0.07420135f, 0.07823841f, 0.09868591f, -0.05398253f, -0.09820807f, 0.09255486f, 0.03708388f, 
    -0.09672374f, 0.10651797f, 0.07163335f, -0.06189049f, -0.30209047f, 0.22674499f, 0.01959678f, -0.02821748f, 
    0.11854006f, -0.08383659f, 0.05608799f, 0.06718130f, 0.13380106f, 0.08190161f, 0.10174866f, 0.15857865f, 
    -0.19925286f, 0.22065639f, 0.03466579f, 0.04492493f, 0.25110370f, -0.11541152f, -0.02576120f, -0.00204533f, 
    0.14568526f, 0.06619424f, 0.09086358f, 0.10577322f, 0.32703984f, 0.13667665f, 0.11035768f, -0.03686691f, 
    0.07968440f, 0.10464890f, 0.03939186f, -0.11405890f, 0.09046920f, 0.01580097f, 0.04843685f, 0.05158124f, 
    0.42849302f, 0.10350484f, 0.17222129f, -0.19121973f, -0.03756435f, 0.16019543f, -0.08306105f, 0.10625922f, 
    0.04525396f, 0.08182812f, 0.09737816f, 0.04813187f, 0.42016512f, 0.11825950f, -0.25045377f, 0.06191898f, 
    0.14613430f, -0.03941811f, -0.02397125f, 0.00874319f, 0.03971089f, 0.06974167f, 0.07084697f, 0.07941277f, 
    0.05112489f, 0.10212237f, -0.01444097f, 0.26186919f, 0.20648776f, -0.00726265f, 0.09205370f, 0.13498579f, 
    0.12405063f, 0.07135414f, 0.15093587f, 0.04504829f, -0.16649531f, 0.05595788f, -0.09228092f, -0.15345772f, 
    0.08646773f, -0.00163880f, -0.10966968f, 0.04521410f, 0.00744308f, 0.05594533f, 0.06867381f, 0.12041757f, 
    -0.04155816f, 0.07646335f, -0.04252513f, -0.01268068f, 0.01134357f, 0.00198631f, -0.06205248f, -0.04901379f, 
    0.11412509f, -0.08405392f, -0.09346274f, 0.00740453f, -0.06260287f, -0.23434485f, 0.16163987f, 0.12889342f, 
    -0.04293526f, 0.08761697f, 0.01965370f, 0.11901855f, -0.05149340f, 0.03197942f, -0.00024665f, 0.07642587f, 
    0.14401315f, -0.12835522f, 0.10140524f, 0.07170451f, -0.10304101f, 0.03355129f, 0.02402861f, 0.15708584f, 
    -0.07936300f, -0.12908751f, 0.00544304f, 0.03477536f, 0.01307945f, -0.00812143f, 0.03584775f, 0.23405838f, 
    0.06077527f, 0.00647491f, -0.04263546f, 0.06033839f, -0.06285422f, 0.04604360f, 0.04017157f, 0.02464280f, 
    0.42610461f, -0.00719395f, 0.08373947f, -0.11588669f, 0.07538518f, 0.04074423f, 0.06142658f, -0.05639147f, 
    0.08103323f, 0.13057353f, 0.15478507f, 0.03434609f, 0.18524016f, 0.15091884f, -0.05367765f, 0.03296217f, 
    0.01855408f, -0.02193861f, -0.10332105f, 0.06673139f, 0.01895678f, -0.12082066f, -0.04807855f, 0.02293228f, 
    0.06615899f, -0.07116891f, 0.04460811f, 0.09722333f, 0.04638661f, 0.06241182f, -0.02865756f, -0.09076405f, 
    -0.00871983f, -0.09342856f, -0.06755728f, -0.04163807f, 0.38398421f, -0.02351504f, -0.00067695f, -0.16799976f, 
    0.02686669f, -0.01275606f, -0.09460950f, -0.04207104f, 0.07673162f, 0.07156697f, 0.16947798f, -0.00892786f, 
    0.06727016f, -0.03490875f, 0.02724810f, 0.14068741f, 0.06330917f, 0.08549692f, 0.11379040f, 0.17208797f, 
    -0.01484380f, 0.04640893f, -0.02576226f, 0.13837889f, 0.16960067f, -0.15469459f, -0.13862646f, -0.07132488f, 
    -0.04910919f, 0.07490321f, 0.03004565f, 0.11650852f, 0.04530768f, 0.03570083f, 0.00096610f, 0.05801443f, 
    -0.07793568f, -0.15567030f, -0.00426374f, -0.09355645f, -0.09977484f, 0.06146212f, 0.03466074f, -0.03296699f, 
    0.16158624f, 0.04814068f, -0.01350398f, 0.09503973f, -0.17218250f, 0.14120188f, -0.10151707f, 0.21269715f, 
    0.04107007f, -0.05967623f, -0.05751858f, 0.03029658f, 0.00248325f, -0.06121577f, 0.07151224f, 0.09819601f, 
    -0.08778413f, 0.04921444f, -0.05610229f, -0.12383928f, 0.07689881f, -0.05840475f, 0.00259016f, 0.13822439f, 
    0.14911017f, 0.09575498f, 0.01958912f, -0.12261676f, 0.32780296f, -0.00788279f, 0.12603238f, -0.10989328f, 
    0.11711726f, -0.02787930f, 0.02855943f, 0.04866634f, 0.01514341f, 0.03945110f, -0.06722939f, 0.05231151f, 
    0.03008383f, 0.11704436f, -0.00890365f, 0.18340784f, 0.07740512f, -0.01261964f, -0.01247546f, -0.07717487f, 
    0.16604832f, 0.07263006f, -0.02999605f, -0.01282493f, 0.36252585f, 0.04606006f, -0.06027964f, -0.02024969f, 
    0.01960305f, 0.03762190f, -0.02005772f, -0.08873729f, 0.10967260f, -0.00864252f, 0.10644930f, 0.12015906f, 
    0.17319591f, -0.04015918f, -0.09186572f, -0.01047168f, 0.17360097f, 0.07651620f, -0.04206167f, -0.00507436f, 
    0.06583261f, 0.05963883f, 0.10143521f, 0.03116426f, 0.07900342f, 0.11085808f, 0.15270291f, -0.01582958f, 
    0.01067778f, 0.03599294f, 0.24184482f, 0.12996656f, 0.11508508f, 0.09611505f, 0.06307355f, 0.08538739f, 
    0.15941659f, 0.03540027f, -0.08560349f, -0.04659508f, 0.07715493f, -0.03959202f, -0.01139967f, -0.09150483f, 
    0.08219622f, -0.00847120f, 0.05443754f, -0.00933177f, -0.02595435f, 0.33638105f, 0.10867102f, -0.11672506f, 
    -0.00235467f, 0.10395435f, -0.05932162f, 0.03365003f, 0.08576811f, 0.07069869f, 0.10407832f, 0.05714987f, 
    -0.03381065f, -0.11077206f, 0.00281452f, -0.13936052f, 0.02163373f, 0.08099014f, 0.01896215f, 0.13818078f, 
    -0.02621456f, 0.16614936f, 0.15522721f, 0.19455662f, 0.04816167f, 0.32539061f, -0.09742586f, 0.14703314f, 
    0.12071060f, -0.07470510f, 0.01126021f, -0.05777481f, 0.10981398f, 0.02543718f, 0.03448480f, 0.01092731f, 
    -0.24440101f, 0.06132739f, -0.09245477f, 0.13164434f, 0.02534970f, -0.03819958f, 0.01125772f, 0.09655453f, 
    0.07026876f, 0.06663983f, 0.06573860f, 0.06594055f, 0.04277086f, -0.07318451f, 0.10920849f, 0.12577109f, 
    0.16834007f, 0.03779197f, 0.14055318f, 0.08658435f, 0.07629281f, 0.07016925f, 0.10114887f, 0.07068954f, 
    0.19059105f, -0.10557576f, 0.13073412f, -0.00144849f, 0.17980985f, 0.08113071f, 0.00373260f, 0.06407512f, 
    -0.01120764f, 0.04823536f, 0.05295105f, 0.12083318f, -0.16395855f, 0.02670375f, -0.02725332f, -0.02733598f, 
    -0.02332524f, -0.04778449f, 0.01870670f, 0.04317585f, -0.06276989f, 0.11774483f, 0.04274562f, -0.00708205f, 
    0.09477243f, -0.11758919f, 0.26182896f, -0.19863933f, 0.09105725f, -0.07481799f, -0.01190493f, 0.15859757f, 
    0.02446461f, 0.07910274f, 0.02070580f, 0.05691436f, -0.00274832f, -0.11380640f, 0.01434260f, 0.22654453f, 
    0.09711812f, 0.13250284f, -0.00636414f, 0.15870008f, 0.02743514f, 0.03536411f, 0.14456567f, 0.14360705f, 
    0.08640999f, 0.14017662f, 0.07085445f, -0.05769669f, 0.16330859f, 0.06622561f, 0.01586781f, -0.10954338f, 
    0.04106397f, 0.06074124f, -0.05273250f, 0.03519041f, -0.05621504f, 0.11918356f, -0.04482955f, 0.01143608f, 
    -0.03250959f, 0.00372203f, -0.00548476f, 0.02864303f, 0.06395982f, 0.07671635f, -0.01331943f, 0.00666672f, 
    -0.01847667f, 0.03700315f, 0.11470058f, 0.02711353f, 0.02145965f, 0.03270176f, -0.06055976f, 0.03368974f, 
    0.10232673f, 0.00688822f, 0.04158206f, 0.00075432f, -0.15160730f, 0.15506560f, -0.07570424f, -0.06779572f, 
    0.02985377f, 0.10139239f, 0.03800023f, -0.05942506f, 0.04824904f, 0.01358674f, -0.01868206f, -0.04268968f, 
    0.20531042f, 0.10543784f, -0.22289439f, -0.04049135f, -0.01804127f, -0.09214291f, 0.00979098f, -0.05130524f, 
    -0.10920483f, -0.00022980f, -0.00860124f, 0.03413197f, 0.18625051f, 0.03733914f, 0.03726802f, 0.07771634f, 
    -0.12287025f, -0.10760548f, -0.01496774f, 0.11730482f, -0.12102838f, 0.00300461f, 0.09137423f, 0.00333224f, 
    0.05562510f, 0.07242884f, -0.02599399f, 0.00393410f, -0.02777500f, 0.02381287f, -0.08171749f, -0.00329239f, 
    0.01232416f, 0.02303276f, 0.02245290f, 0.00837554f, 0.31589225f, -0.03499663f, -0.00478691f, -0.01675191f, 
    0.01948435f, 0.05537765f, 0.01540597f, -0.06694022f, 0.06324681f, 0.00036410f, -0.03341267f, -0.06900830f, 
    -0.03796847f, -0.09049986f, -0.07900543f, 0.02552711f, -0.12459047f, -0.04219839f, -0.04946456f, 0.02369694f, 
    -0.05991425f, 0.00915243f, 0.00722236f, -0.03929980f, -0.09317682f, -0.11487498f, 0.04903222f, 0.00900551f, 
    -0.00167156f, 0.06709660f, 0.05789726f, 0.00614774f, 0.03494281f, -0.03049181f, -0.01353741f, 0.01653501f, 
    -0.08324409f, -0.02522968f, 0.08237714f, 0.21039164f, 0.06358738f, -0.01188809f, 0.00713990f, 0.03662803f, 
    -0.02812079f, 0.10917021f, -0.06979902f, 0.09273698f, 0.23553839f, 0.19173715f, 0.03918868f, 0.08963745f, 
    -0.05096631f, 0.01481026f, 0.06414899f, 0.06994653f, -0.02660158f, 0.04855374f, 0.03109217f, 0.02124764f, 
    0.12096158f, -0.01455540f, 0.05344611f, -0.03972751f, 0.00762079f, 0.02120844f, 0.10036057f, 0.05073622f, 
    0.00743969f, -0.00430261f, 0.02151950f, 0.06940346f, 0.04902836f, 0.12054111f, 0.01116284f, 0.01275494f, 
    0.09853584f, -0.01111890f, 0.01431281f, 0.03241745f, -0.00661601f, -0.15265165f, 0.04293213f, 0.05696009f, 
    -0.24669816f, -0.02002949f, -0.01324399f, -0.06694225f, 0.01886871f, -0.04040465f, -0.05215165f, -0.01221209f, 
    0.08042818f, 0.01498194f, -0.04714414f, -0.00283380f, -0.11086616f, 0.04138893f, -0.07806743f, -0.06205815f, 
    0.01903251f, -0.04369868f, -0.03359782f, -0.02913640f, -0.00047752f, -0.08898821f, 0.00436089f, -0.08767000f, 
    -0.21848813f, 0.03095705f, 0.04547941f, 0.08959432f, 0.09162741f, 0.06511313f, 0.06072456f, 0.00121423f, 
    0.02533081f, 0.02013042f, -0.02776993f, -0.02305741f, -0.25274324f, 0.00406959f, 0.02566560f, -0.08555670f, 
    -0.00175063f, -0.05353548f, -0.01528937f, 0.09928704f, -0.11231402f, 0.09214145f, -0.10807508f, -0.06975110f, 
    0.26639095f, -0.15029499f, 0.09332167f, -0.01136878f, -0.00342389f, -0.04332934f, 0.04347114f, 0.02685010f, 
    -0.02298676f, 0.12393447f, 0.09275511f, 0.02448207f, 0.02448649f, -0.01907275f, 0.04825312f, 0.08740265f, 
    -0.07513153f, -0.05462166f, 0.02057388f, 0.08587217f, -0.11484843f, -0.02646212f, -0.01978777f, 0.01014124f, 
    0.08216716f, 0.04047039f, -0.11100376f, 0.05127310f, 0.01300691f, 0.09921488f, -0.10377181f, -0.02349011f, 
    0.12844943f, 0.02901397f, -0.00315807f, 0.07302923f, 0.16255146f, 0.04838602f, 0.05305775f, 0.25418991f, 
    -0.12072635f, -0.06302878f, -0.02194123f, -0.00303047f, 0.00976048f, -0.03946286f, 0.02038470f, 0.09752182f, 
    0.17517914f, 0.03004415f, -0.10057695f, 0.04139691f, 0.07439987f, 0.04780678f, 0.02588707f, 0.04207040f, 
    0.01049756f, 0.04831949f, 0.03948134f, -0.04073578f, -0.23373511f, -0.08837492f, 0.02650182f, -0.08103575f, 
    0.02651764f, 0.07508982f, 0.01993850f, -0.06684915f, -0.01505573f, 0.02782609f, -0.03081968f, -0.00736080f, 
    -0.07330785f, -0.07602924f, 0.06579120f, -0.13858804f, 0.04333346f, 0.02153724f, 0.06545159f, 0.07373106f, 
    -0.06048013f, -0.06476390f, -0.01728205f, 0.06220419f, -0.17494114f, -0.03334329f, -0.03233766f, -0.07535143f, 
    0.11114232f, 0.02211506f, 0.00439347f, -0.02038584f, 0.06773242f, 0.04625991f, -0.05775640f, -0.04598859f, 
    -0.00841468f, 0.07543152f, -0.09576329f, 0.14541434f, -0.15945776f, -0.04603937f, 0.13441293f, -0.02895669f, 
    -0.08416609f, -0.04097402f, -0.03003016f, 0.00832908f, -0.00686494f, -0.03752340f, -0.02595636f, -0.02315964f, 
    0.06025436f, 0.03217699f, -0.01314295f, -0.01818023f, 0.05540075f, 0.07004897f, -0.06365819f, -0.08528392f, 
    0.09939228f, 0.00000573f, 0.08318847f, 0.12481250f, 0.08569014f, -0.05570845f, 0.00248485f, 0.04885021f, 
    -0.00053253f, 0.03931943f, 0.02857510f, 0.03514158f, 0.04604952f, 0.03936474f, -0.09259014f, -0.06230712f, 
    0.02512390f, 0.01026406f, 0.10908296f, -0.00466358f, 0.04719466f, 0.00915269f, -0.02503091f, 0.03876548f, 
    -0.10230831f, -0.04088495f, -0.04168989f, -0.08571301f, 0.06238321f, -0.06431335f, 0.07659673f, -0.00557089f, 
    -0.05793456f, 0.02053001f, 0.00323382f, 0.09553656f, -0.24188967f, -0.00218388f, 0.10853836f, -0.11619733f, 
    0.05702697f, 0.03935265f, -0.02427885f, -0.05976117f, 0.06278708f, 0.08007097f, 0.13331541f, 0.06280527f, 
    -0.18011378f, 0.01756432f, 0.00509260f, 0.06264968f, -0.02060914f, 0.16303182f, -0.06014915f, -0.06565432f, 
    -0.07837494f, 0.08748621f, 0.03123121f, 0.07069316f, -0.07196277f, -0.03689399f, 0.00711485f, -0.06473556f, 
    0.08837428f, 0.09333064f, -0.06465377f, -0.04182214f, 0.01757209f, 0.00996852f, 0.03063488f, 0.04729110f, 
    -0.09571425f, -0.06339584f, -0.10730740f, 0.06766363f, 0.00325325f, -0.00512299f, 0.03348368f, 0.01478395f, 
    0.04919130f, -0.00778076f, 0.07036734f, -0.05149685f, 0.21721686f, 0.01554984f, -0.07021840f, -0.05222867f, 
    0.00628444f, -0.04030405f, -0.03286508f, -0.07500859f, 0.06004405f, -0.01544394f, 0.03725598f, 0.05078293f, 
    0.06794644f, 0.04814986f, -0.07795929f, -0.07901139f, -0.02444489f, 0.02454267f, -0.04444939f, 0.03563026f, 
    -0.14905606f, -0.02477521f, -0.00023214f, 0.01760030f, 0.06308582f, 0.15752795f, -0.02001215f, 0.15997706f, 
    -0.04886175f, -0.09257118f, 0.04639052f, 0.00733271f, -0.02790207f, -0.04285037f, 0.05397223f, 0.06316367f, 
    0.24472533f, 0.07971572f, -0.01751511f, 0.05303852f, -0.03119257f, -0.08006009f, 0.03405237f, 0.08746876f, 
    0.00000936f, 0.02148031f, 0.05333456f, 0.06031356f, 0.20066051f, 0.21522988f, -0.02349041f, 0.15600583f, 
    -0.08582714f, -0.10283577f, 0.05318036f, 0.03254784f, -0.08541574f, 0.04312287f, -0.02999304f, -0.03434101f, 
    -0.25154120f, -0.13872270f, -0.00243703f, -0.07017840f, -0.04315286f, 0.07374322f, 0.04730713f, 0.02450028f, 
    -0.02316473f, -0.05704377f, 0.01327561f, -0.06158134f, 0.23662783f, -0.01319050f, -0.05845771f, 0.03413453f, 
    -0.00560141f, 0.02925868f, 0.01749345f, -0.01363966f, -0.00500532f, 0.06962483f, -0.00383394f, -0.02187136f, 
    0.05302240f, -0.09033374f, 0.01114910f, -0.00961307f, -0.00957552f, -0.03055545f, -0.03100403f, -0.05915706f, 
    -0.01137534f, 0.01487564f, -0.00759290f, 0.01201704f, -0.00357121f, 0.07528228f, 0.11105622f, -0.17490953f, 
    0.05671588f, 0.06908021f, -0.00387720f, 0.02020243f, -0.02211268f, -0.00675753f, 0.00568071f, -0.05307147f, 
    0.25229189f, 0.03555548f, 0.08625809f, 0.03461256f, -0.11836606f, -0.01260347f, 0.01958529f, 0.03271586f, 
    -0.07227681f, 0.08541454f, 0.03098442f, 0.05690763f, 0.16224101f, 0.18021232f, -0.25634128f, -0.02643720f, 
    0.06891952f, 0.05238485f, -0.01066105f, 0.05579045f, 0.02927736f, 0.12453327f, -0.00508218f, -0.03576094f, 
    0.04407925f, 0.07040680f, 0.01369667f, 0.04967675f, 0.00170029f, 0.00514496f, -0.01275270f, -0.02562590f, 
    0.03396915f, -0.01085298f, 0.05351521f, 0.03239175f, 0.38217136f, -0.14318885f, 0.04080931f, 0.21138118f, 
    -0.05435488f, -0.12117833f, 0.01976991f, -0.03618252f, 0.09195665f, 0.11714959f, -0.03726152f, -0.03911743f, 
    0.15266711f, 0.11052599f, -0.04490807f, -0.06316766f, -0.01956093f, -0.01900343f, 0.06300084f, -0.05768435f, 
    -0.00063119f, 0.03186563f, -0.10053460f, -0.03237286f, -0.10754913f, 0.07189598f, 0.04414382f, -0.11417165f, 
    0.05485522f, 0.00933325f, -0.04689487f, -0.07696204f, 0.01108817f, -0.01244534f, 0.01614233f, 0.01460710f, 
    -0.33844012f, 0.02249856f, 0.01500020f, -0.07695542f, 0.10220871f, -0.05653344f, -0.04529263f, -0.05080638f, 
    0.07532241f, 0.01891769f, -0.07044228f, -0.00968422f, -0.34730566f, -0.03202051f, -0.02455661f, -0.02178328f, 
    0.11085520f, -0.01209379f, 0.02989766f, 0.01799213f, 0.02171477f, 0.11302084f, 0.06991223f, 0.06008203f, 
    -0.23082836f, -0.10675462f, 0.01354271f, -0.04415673f, 0.11245608f, -0.13856588f, -0.03118333f, 0.00903391f, 
    -0.02042752f, -0.04133815f, -0.10657509f, -0.05871125f, -0.27507731f, -0.01995599f, 0.09400033f, 0.07688508f, 
    -0.06780820f, 0.08295206f, 0.09862286f, 0.00414197f, 0.03423492f, -0.04098761f, -0.01646963f, -0.00190400f, 
    0.20817825f, -0.04405781f, -0.01691031f, -0.10825055f, -0.02362133f, 0.02032183f, 0.01931309f, 0.08243918f, 
    -0.04820726f, 0.05715214f, -0.05129803f, -0.06456195f, 0.30355603f, 0.07371636f, 0.02731669f, -0.07911304f, 
    -0.08121111f, 0.08704229f, 0.04604571f, -0.05289188f, -0.03743114f, 0.08649828f, 0.04210233f, -0.03729704f, 
    0.11331034f, 0.07952188f, -0.02792177f, -0.06810634f, -0.07670253f, 0.04590909f, -0.02809133f, 0.08831281f, 
    -0.03473468f, -0.05750149f, 0.04305908f, 0.07579909f, -0.24655592f, -0.08366563f, 0.02817080f, -0.02995748f, 
    0.14550500f, 0.02727377f, 0.02062285f, 0.00931819f, 0.04287447f, 0.05764006f, -0.00357134f, -0.01429031f, 
    0.33465037f, -0.12249280f, 0.16202544f, -0.03850188f, -0.02864714f, -0.02147100f, -0.01005767f, 0.03764972f, 
    0.01458427f, 0.06954084f, -0.09546231f, 0.07859979f, 0.06792145f, 0.01708497f, 0.10951395f, 0.04479031f, 
    -0.10164919f, -0.06563965f, 0.07094318f, 0.05267474f, -0.00901092f, -0.02312243f, 0.01893479f, 0.06977807f, 
    0.25294530f, 0.02265362f, 0.08711754f, -0.07125717f, -0.05764120f, -0.03738552f, -0.08220730f, 0.00264618f, 
    0.11567742f, 0.01200026f, 0.03391653f, 0.07009614f, -0.01525114f, 0.05567916f, -0.01191339f, 0.13551350f, 
    -0.03741284f, -0.01916499f, 0.05387805f, 0.05554356f, -0.01485597f, 0.00236240f, -0.07897416f, -0.07130993f, 
    -0.06201709f, -0.02429089f, 0.03033504f, 0.04662153f, 0.01756572f, 0.03571381f, -0.04041200f, -0.01992428f, 
    -0.01028245f, 0.09029704f, -0.07980721f, -0.00106159f, -0.02332280f, -0.01115930f, -0.14550526f, 0.07853719f, 
    0.05028471f, 0.02722418f, 0.01727988f, 0.05626203f, 0.11614110f, -0.04375075f, -0.01157778f, 0.07124015f, 
    -0.16855724f, -0.02452832f, -0.00291290f, -0.13143708f, -0.00114457f, 0.11518221f, 0.02450020f, -0.01630111f, 
    0.00198760f, 0.05617347f, -0.02325802f, 0.02266631f, 0.15158331f, 0.01963387f, -0.02390927f, -0.00268128f, 
    -0.15413925f, -0.03204619f, -0.02020854f, -0.06731872f, -0.00009843f, 0.00024224f, -0.02753228f, -0.01180145f, 
    -0.03178720f, -0.03511444f, 0.02386312f, -0.01914957f, -0.03118277f, -0.02413310f, -0.01677622f, -0.00982233f, 
    0.02041676f, -0.00944576f, 0.02067730f, -0.00771976f, -0.02261474f, 0.00375985f, -0.03905720f, -0.02773503f, 
    0.00620220f, -0.00601403f, -0.03260489f, -0.00303160f, -0.03564169f, 0.02063467f, 0.02057169f, 0.01862314f, 
    -0.04095901f, -0.03968329f, -0.03127548f, 0.02150225f, -0.04195303f, 0.02693260f, -0.01053352f, -0.01373674f, 
    0.01871367f, 0.02041795f, 0.02347226f, 0.00829330f, 0.00512146f, -0.03165090f, -0.03811893f, -0.03418908f, 
    0.00950372f, 0.02191802f, -0.03668797f, -0.03480053f, -0.03915026f, 0.00376393f, -0.01420547f, 0.01328469f, 
    0.01843673f, 0.01074622f, -0.03409488f, 0.01495508f, -0.02438620f, -0.02289428f, 0.00004518f, 0.00398352f, 
    -0.03037387f, -0.00907681f, -0.03426055f, 0.01802635f, -0.00579272f, -0.03231379f, -0.03353518f, 0.00653621f, 
    -0.01604952f, -0.03268946f, 0.01119780f, 0.02149210f, 0.02665776f, -0.00286501f, -0.00245993f, -0.02697331f, 
    0.00757809f, -0.01173221f, -0.02723148f, 0.02402421f, 0.00471028f, 0.01928192f, -0.03699860f, -0.03682158f, 
    0.01064871f, 0.00476485f, -0.01437979f, 0.01801619f, 0.01481293f, 0.02273898f, 0.00364166f, 0.00075296f, 
    0.01225050f, -0.03375826f, -0.00534674f, 0.02322752f, -0.00764650f, 0.02984660f, -0.03557365f, 0.02529522f, 
    0.00896799f, -0.03644369f, -0.03085720f, -0.00745118f, -0.01961876f, -0.00296061f, 0.02644975f, 0.02184568f, 
    -0.02527363f, -0.01596670f, 0.02140502f, -0.03804044f, -0.00950916f, -0.02907922f, 0.01407243f, 0.00241922f, 
    -0.01843930f, -0.00833739f, 0.00105591f, 0.00090415f, -0.02614955f, -0.03782008f, 0.00772560f, -0.02439818f, 
    0.02021281f, -0.03842364f, -0.02419216f, 0.02339474f, -0.01824331f, -0.01259793f, -0.01072449f, 0.01764570f, 
    -0.02556870f, 0.01212670f, -0.00477813f, -0.03681282f, 0.00226681f, 0.02400558f, -0.02359769f, 0.02262037f, 
    -0.03946739f, -0.01006219f, -0.02365421f, -0.03343761f, -0.03067113f, -0.03113352f, 0.01967339f, -0.00268512f, 
    -0.03137720f, -0.02734095f, -0.03625739f, -0.02867275f, -0.01497868f, -0.01058443f, 0.01398622f, -0.04020338f, 
    -0.01390477f, 0.01549511f, -0.00916885f, 0.02186184f, 0.00094046f, 0.01088597f, -0.03429448f, -0.01479181f, 
    -0.03266159f, 0.02435164f, 0.01296178f, 0.01336053f, -0.02247395f, 0.01542041f, 0.02879291f, 0.02377685f, 
    0.02062609f, -0.04191583f, -0.02359398f, -0.01613090f, 0.01047398f, 0.01141612f, 0.01046006f, -0.03712901f, 
    -0.02319908f, 0.02690993f, 0.01086276f, -0.03254426f, -0.03822273f, 0.01470156f, -0.01786099f, 0.00489522f, 
    0.02736414f, -0.03049820f, 0.02680126f, 0.01735576f, -0.02308744f, -0.03451834f, -0.03891297f, 0.01838261f, 
    0.01574520f, -0.00616346f, -0.00944118f, 0.02451992f, -0.03080513f, 0.01162294f, -0.00871184f, -0.00001324f, 
    -0.03476128f, -0.00231717f, -0.01076762f, -0.02980377f, -0.03276465f, 0.02513047f, 0.02781284f, 0.02334259f, 
    0.00926615f, -0.00104101f, 0.00022953f, 0.01208077f, -0.03504432f, -0.01057412f, 0.01408109f, 0.01639679f, 
    -0.03109703f, -0.01358853f, -0.03720485f, -0.01053358f, -0.01931424f, -0.02378200f, -0.01828464f, -0.03671991f, 
    -0.03133563f, -0.02582147f, -0.00875823f, -0.00031415f, -0.03172904f, -0.01228042f, 0.01618415f, -0.03413595f, 
    0.01129301f, 0.01900294f, -0.00042201f, -0.01849636f, -0.00868730f, 0.02869540f, -0.01972994f, 0.02971770f, 
    -0.03163934f, 0.00183606f, -0.02502526f, -0.00536496f, -0.03216279f, -0.02787950f, 0.02138462f, -0.03914500f, 
    -0.03584894f, 0.00762754f, -0.01148832f, -0.03718632f, 0.00289053f, -0.03620783f, -0.02402018f, -0.03925648f, 
    0.02758646f, -0.01511287f, 0.01899062f, -0.02180197f, -0.01528770f, -0.03867704f, -0.00544491f, 0.02556531f, 
    0.01937812f, -0.04051417f, 0.02895305f, 0.02953232f, -0.04119027f, 0.02792427f, -0.02511815f, 0.00894398f, 
    0.00325602f, 0.01992805f, -0.03300104f, 0.01336681f, 0.02327589f, 0.01169094f, 0.02566795f, 0.01836929f, 
    -0.02157470f, 0.00447084f, -0.03664285f, -0.00582789f, 0.00979700f, -0.02061494f, -0.02405474f, -0.02146937f, 
    0.02076719f, -0.01826312f, -0.00375435f, 0.00367202f, 0.00905579f, 0.02661195f, 0.00132794f, -0.01454440f, 
    -0.02236335f, 0.01575929f, 0.00313623f, -0.00660122f, -0.02865904f, 0.02499902f, -0.00540625f, 0.00092692f, 
    0.02396362f, 0.01905135f, -0.00016293f, 0.00433637f, -0.03740295f, -0.01403610f, -0.00724548f, -0.03349404f, 
    -0.03034661f, 0.00770587f, -0.03097551f, -0.00607646f, 0.00604495f, 0.01855187f, 0.00675108f, -0.03117632f, 
    -0.01078182f, -0.03140423f, 0.00738647f, -0.01256719f, 0.02510761f, -0.02943861f, -0.02856841f, 0.01000209f, 
    -0.00071412f, 0.01847513f, 0.01854035f, -0.00891010f, -0.01247146f, -0.00276183f, -0.01442864f, 0.01884306f, 
    0.00793992f, 0.00946350f, -0.02725775f, -0.04207814f, -0.01936112f, 0.00170470f, -0.03184124f, 0.00205873f, 
    -0.01939821f, 0.01032274f, -0.00430019f, 0.00445402f, -0.01656073f, -0.03558774f, 0.02696307f, -0.03708386f, 
    0.02462435f, -0.03561956f, -0.04006800f, 0.00192846f, 0.02634258f, -0.02715529f, 0.01494945f, -0.00883900f, 
    -0.03503992f, -0.03373718f, -0.01113953f, 0.01870633f, -0.00230353f, 0.00526515f, -0.03376123f, -0.02301746f, 
    -0.00609761f, 0.01471016f, -0.01269475f, -0.02406116f, -0.04137856f, 0.00091155f, 0.00353683f, 0.00916774f, 
    -0.00733828f, 0.00613173f, 0.00551837f, -0.03276561f, -0.01220941f, -0.00938801f, -0.00435278f, -0.02270476f, 
    -0.00416478f, 0.01896412f, 0.00291120f, -0.03420306f, -0.00641833f, 0.01052227f, -0.04099551f, 0.01251639f, 
    -0.03486647f, -0.03106849f, -0.01519131f, -0.03150621f, 0.00738862f, 0.00011610f, 0.02917554f, 0.01134006f, 
    0.00272920f, 0.02698518f, 0.01485428f, -0.00199049f, 0.02135049f, -0.00798865f, 0.01139883f, 0.00991516f, 
    0.00370497f, -0.00716951f, 0.01691471f, 0.01379268f, -0.03673343f, 0.01983602f, -0.00491349f, -0.02131525f, 
    -0.03730194f, -0.02384592f, -0.01939385f, -0.01446934f, 0.02128624f, -0.01216164f, 0.00577395f, -0.01701277f, 
    0.02640095f, -0.02564558f, -0.00374752f, 0.00608876f, 0.02677846f, 0.01945323f, 0.02278579f, 0.00679869f, 
    0.00750875f, 0.01775174f, 0.00279019f, -0.02213441f, -0.00428658f, -0.03114561f, 0.01144631f, -0.02511953f, 
    0.00793756f, -0.00124436f, -0.02398205f, 0.02509943f, 0.02538327f, 0.01142316f, 0.00007123f, 0.00625030f, 
    -0.03284720f, 0.00466656f, 0.01605592f, -0.01937662f, -0.02597310f, -0.00591867f, 0.01305805f, 0.01371501f, 
    -0.00079452f, -0.01446847f, -0.03889098f, -0.00498363f, 0.01054734f, 0.00627575f, -0.01613240f, 0.02110418f, 
    -0.03644713f, -0.01997988f, -0.03145924f, -0.02540811f, 0.01128562f, 0.00975227f, -0.00454673f, 0.01172790f, 
    -0.02655733f, 0.00854450f, -0.00991924f, 0.01455473f, -0.03966255f, -0.02413099f, 0.02530890f, -0.03234614f, 
    -0.00371878f, 0.02278758f, 0.01297226f, -0.02515765f, -0.03840014f, -0.02919070f, 0.00443004f, -0.01199890f, 
    0.01058126f, -0.02800969f, -0.00419874f, 0.01899450f, 0.02582030f, 0.00069546f, 0.02277555f, -0.01018472f, 
    0.01693897f, -0.00454164f, 0.02039788f, 0.01881543f, -0.03161619f, -0.00819766f, 0.00133430f, 0.01146967f, 
    0.01189894f, -0.00042059f, 0.00342869f, -0.00094133f, -0.00855252f, -0.03033725f, 0.01322199f, 0.00861529f, 
    0.00679124f, 0.01781451f, -0.01283521f, -0.03602346f, -0.01912232f, -0.00990663f, -0.00367741f, 0.02789383f, 
    -0.00710740f, -0.01687746f, -0.01313567f, 0.00558770f, -0.00538289f, -0.01200802f, -0.02309317f, 0.00881756f, 
    -0.00372740f, 0.02846869f, 0.00469819f, -0.01501779f, -0.00762248f, -0.01068498f, -0.02640466f, -0.00442403f, 
    0.02755885f, -0.04072053f, -0.02897306f, 0.01422762f, 0.01386784f, -0.00477214f, -0.03395495f, -0.00246175f, 
    -0.00879621f, -0.00887664f, 0.00883031f, -0.03289646f, -0.00235194f, -0.03765431f, -0.03818673f, 0.01454328f, 
    -0.04042716f, -0.02756260f, -0.00904635f, 0.01428072f, 0.02854595f, 0.02377418f, -0.02989850f, -0.00136327f, 
    -0.01904952f, -0.04048739f, 0.00216066f, -0.01097346f, 0.02197203f, 0.00941114f, -0.00395345f, -0.01800864f, 
    0.00757985f, -0.01332675f, -0.02081909f, 0.01648286f, -0.00086424f, -0.02348699f, 0.01238716f, -0.01014993f, 
    -0.00187107f, -0.01098630f, -0.02746442f, -0.02915489f, -0.02593238f, 0.01225496f, -0.00403194f, 0.02845070f, 
    -0.01053230f, 0.00230347f, -0.03539839f, -0.00651722f, 0.00667684f, -0.00060574f, 0.02488601f, 0.02091997f, 
    0.00966766f, -0.01395496f, -0.01369486f, -0.04179353f, -0.00923944f, 0.00649551f, -0.00849107f, 0.01279615f, 
    0.01809989f, 0.02438913f, 0.01210716f, 0.01111223f, -0.03123878f, -0.01980551f, -0.00713776f, 0.03004744f, 
    0.00762310f, -0.00857971f, 0.02728542f, 0.01854520f, 0.00318822f, -0.03392952f, -0.04130699f, 0.01926450f, 
    -0.00638280f, -0.02907654f, 0.01747129f, -0.00802129f, 0.00698189f, 0.01192380f, 0.00234239f, 0.01788568f, 
    -0.00298559f, 0.02546311f, 0.01288740f, 0.00083931f, 0.02986163f, -0.02184726f, 0.03652757f, -0.03168190f, 
    0.01178657f, -0.03323078f, -0.00329336f, -0.04136760f, -0.00588994f, 0.00373999f, 0.02697819f, -0.00584032f, 
    -0.01361534f, 0.02247136f, 0.01737210f, 0.02959488f, -0.03666428f, -0.01846135f, -0.00794035f, -0.01427325f, 
    -0.00950258f, -0.00338878f, -0.00277202f, 0.01513225f, -0.00668623f, 0.02391755f, -0.02922930f, 0.02190325f, 
    -0.01334250f, -0.03637520f, -0.00438093f, 0.01415452f, -0.02764663f, -0.00744128f, 0.00552376f, -0.00158248f, 
    -0.00539018f, -0.02548018f, -0.01612432f, 0.00606172f, 0.01247629f, -0.00970052f, 0.02693441f, -0.02197250f, 
    -0.01321337f, 0.02139052f, 0.01300697f, 0.02324963f, -0.04155129f, 0.01930011f, -0.03935119f, -0.01842323f, 
    0.01181633f, -0.01273678f, -0.04021397f, -0.00390571f, -0.00011692f, -0.00284335f, 0.02388692f, -0.03599857f, 
    -0.02355918f, -0.00252324f, -0.02746528f, -0.01837565f, -0.03265656f, -0.03089678f, -0.02342441f, -0.00259037f, 
    -0.02464676f, -0.00798905f, -0.02988860f, 0.02451586f, -0.01580609f, -0.00227551f, -0.02010155f, 0.01655784f, 
    0.01412342f, -0.03480022f, -0.03962174f, -0.03724238f, -0.01556933f, -0.03462951f, 0.00818686f, -0.04179658f, 
    -0.00676739f, 0.02749382f, -0.03002305f, 0.02422094f, -0.03946710f, 0.02304610f, -0.01906181f, 0.03001077f, 
    -0.00803522f, -0.01146626f, 0.00533004f, -0.02191880f, 0.01202912f, -0.00360638f, -0.01240903f, -0.01244611f, 
    -0.02992623f, -0.01410168f, -0.01545404f, -0.02053235f, -0.00113552f, 0.01292080f, -0.00175333f, -0.03299798f, 
    0.01734354f, -0.02475518f, 0.01725485f, -0.00859664f, -0.02666791f, 0.02309178f, -0.03518990f, -0.01752325f, 
    -0.01282251f, 0.00883587f, -0.01817210f, -0.02043512f, -0.02736689f, -0.01441548f, -0.03814222f, 0.02413662f, 
    -0.03327378f, 0.02169966f, 0.00524949f, 0.01666712f, 0.01382793f, -0.01100198f, -0.02174014f, -0.03589066f, 
    0.00287560f, -0.03439264f, 0.00636793f, 0.01952728f, -0.03165110f, 0.00670011f, -0.01377872f, 0.02401366f, 
    0.01235690f, -0.03783688f, 0.03473379f, -0.00862532f, -0.02856109f, -0.00311938f, 0.01803392f, -0.03724585f, 
    0.02194324f, -0.03189565f, -0.04164978f, 0.00208388f, 0.00423298f, -0.03449147f, -0.02135296f, -0.01024465f, 
    -0.00986362f, -0.03181173f, -0.02818435f, 0.03048639f, -0.02957463f, -0.01910327f, -0.00527171f, -0.02952586f, 
    0.01538054f, 0.01345564f, 0.00704454f, -0.00981054f, 0.00480294f, -0.03128665f, -0.00550193f, -0.02365718f, 
    -0.03193706f, -0.02774406f, -0.03922089f, 0.02141023f, -0.03240412f, 0.02965533f, 0.01232209f, -0.00828557f, 
    0.02027082f, 0.03578923f, 0.03457472f, 0.00521272f, -0.01825456f, 0.03285002f, 0.01602584f, 0.00437206f, 
    -0.03214705f, -0.01472496f, -0.03776560f, 0.02036369f, -0.02272165f, 0.02874392f, 0.02258917f, 0.00460387f, 
    -0.03266320f, 0.02625825f, -0.03160475f, 0.01437097f, -0.01411464f, -0.03080376f, -0.03721220f, -0.01235032f, 
    -0.00204297f, -0.00277058f, -0.02269262f, 0.02420839f, 0.02727735f, 0.03079032f, -0.00991857f, -0.00285739f, 
    0.02192861f, 0.02325079f, 0.01497146f, -0.03050985f, 0.00512301f, 0.00785695f, -0.00542590f, 0.00649896f, 
    -0.03545542f, 0.03161456f, -0.00490813f, -0.01881417f, 0.00547730f, 0.00244842f, -0.04038142f, -0.00839323f, 
    0.02663627f, 0.02607731f, 0.03295805f, -0.01512336f, 0.00384798f, -0.00408254f, -0.00569582f, -0.01062512f, 
    0.03590229f, 0.02294371f, 0.01516993f, -0.03083928f, -0.01962679f, 0.02408915f, -0.03490604f, 0.02618073f, 
    0.01839205f, -0.03771306f, -0.02421461f, -0.03754530f, 0.02340323f, 0.00987167f, -0.02688335f, 0.00637361f, 
    -0.01435678f, -0.04012378f, 0.01800520f, -0.00951272f, 0.02265994f, -0.00217022f, -0.01619421f, 0.00472203f, 
    -0.01551261f, -0.00270253f, -0.03527258f, 0.02643577f, -0.03441628f, 0.01952807f, 0.01544516f, 0.00087470f, 
    -0.03783110f, -0.00831234f, -0.01180598f, -0.02829569f, 0.00675716f, 0.00620041f, 0.01319551f, -0.03055236f, 
    -0.00966738f, -0.01477199f, -0.03871325f, 0.01379196f, -0.00040342f, -0.03777609f, -0.03487933f, 0.00798158f, 
    -0.02455346f, 0.01840632f, -0.01135171f, -0.00858079f, -0.00813926f, 0.03332902f, -0.02908755f, -0.01587254f, 
    0.00434019f, 0.02221673f, 0.02179810f, -0.02104388f, -0.03450493f, 0.00605585f, -0.00136681f, -0.00698346f, 
    0.02240297f, -0.02937526f, 0.02499794f, 0.03557314f, -0.01137628f, -0.02778701f, 0.00844314f, 0.01099003f, 
    0.00948892f, 0.01748435f, -0.00239642f, -0.00715375f, -0.03116447f, 0.00040676f, -0.00441009f, 0.01978317f, 
    -0.02730060f, -0.00413292f, -0.00667451f, -0.03312308f, -0.03605160f, -0.02265743f, -0.01340652f, -0.04412133f, 
    -0.01447521f, -0.02655259f, 0.00270562f, -0.02439805f, 0.02403474f, -0.01086574f, 0.00196755f, -0.01122548f, 
    0.02683428f, -0.02219780f, 0.01076907f, 0.01310927f, 0.00542686f, 0.00971278f, 0.01220460f, -0.03998147f, 
    -0.00273232f, -0.03280791f, 0.00781935f, 0.01992182f, -0.00286070f, 0.02962796f, -0.02071617f, -0.00840861f, 
    0.00985303f, 0.01231434f, 0.00432961f, -0.01809552f, 0.00958320f, -0.03904560f, -0.01438020f, -0.00806086f, 
    -0.01193789f, 0.01472066f, -0.01946737f, -0.02878288f, -0.03232390f, -0.01495033f, -0.02499231f, -0.03615331f, 
    -0.02762160f, -0.00960753f, -0.01414288f, -0.01128299f, 0.00838365f, 0.00110708f, -0.00880939f, -0.01439018f, 
    -0.02067562f, -0.02667603f, -0.01571742f, 0.03108195f, 0.00877823f, 0.02137193f, -0.00236508f, -0.01047693f, 
    0.02186365f, -0.02714884f, 0.00241023f, 0.03501862f, -0.01498624f, -0.00827511f, -0.00125244f, -0.04089979f, 
    0.00524326f, 0.01577479f, 0.02207930f, 0.03222020f, 0.01131848f, -0.01073000f, 0.00171217f, -0.01441650f, 
    0.00460867f, -0.00375675f, -0.03195377f, -0.02307818f, -0.01763555f, 0.01364246f, 0.02382957f, -0.03557774f, 
    0.01842651f, -0.02903131f, 0.02205097f, -0.02062840f, 0.00978825f, 0.01230123f, 0.02813356f, -0.03749081f, 
    -0.02986582f, -0.02749025f, 0.03261799f, 0.03219020f, -0.00478742f, -0.02468665f, -0.03885516f, -0.00562167f, 
    -0.02389119f, -0.03881903f, -0.01224398f, 0.01478077f, -0.02277958f, -0.00816572f, -0.02215847f, 0.01384529f, 
    -0.01988683f, 0.01152280f, -0.01735924f, -0.00389726f, 0.00778082f, -0.01782756f, 0.00607236f, -0.00287141f, 
    -0.04531359f, 0.00821884f, 0.03160844f, -0.02486908f, 0.02942963f, -0.01013514f, -0.03090021f, 0.02178124f, 
    0.01402293f, -0.01024232f, -0.02390101f, -0.02587007f, -0.00732552f, -0.00891155f, -0.00254858f, 0.01100310f, 
    -0.03941246f, 0.00534114f, -0.02855630f, -0.01945737f, -0.01106231f, -0.02739803f, 0.01322675f, -0.01228077f, 
    -0.01274258f, -0.01260105f, 0.01574921f, 0.02634703f, 0.00685311f, 0.01538670f, 0.01880191f, 0.01335125f, 
    -0.01738500f, 0.00895561f, -0.01553947f, 0.02782894f, -0.03292304f, 0.02662755f, -0.03595065f, -0.01580728f, 
    -0.00680607f, -0.00946734f, -0.02516929f, -0.00049815f, 0.00244533f, 0.02157393f, 0.01966689f, -0.00428264f, 
    -0.01967045f, -0.00073579f, 0.00407431f, -0.03376655f, -0.00875077f, 0.02047030f, -0.00194803f, 0.02813580f, 
    0.01943878f, -0.03692652f, 0.02546414f, -0.02716139f, -0.02437504f, 0.01721465f, -0.01224169f, 0.00116107f, 
    -0.01639530f, -0.01470252f, 0.01083714f, 0.00470617f, -0.01165044f, -0.04565203f, 0.00375875f, -0.03728021f, 
    0.01631980f, -0.01114197f, -0.01829306f, 0.01242497f, -0.01212879f, 0.01708053f, -0.01350983f, -0.00049558f, 
    -0.00301592f, 0.01590424f, 0.02220936f, -0.00427460f, -0.01175333f, 0.00709975f, -0.00998733f, -0.00982337f, 
    0.00357794f, -0.01707421f, -0.01502028f, 0.00127335f, -0.02543819f, -0.01094946f, -0.00785331f, 0.03001776f, 
    -0.01104367f, -0.00416504f, 0.01412659f, -0.02191420f, -0.02839946f, 0.02348058f, -0.02709598f, -0.03742187f, 
    0.01171343f, 0.01423984f, -0.03726489f, 0.01521805f, 0.01430758f, -0.04423158f, -0.02254550f, -0.01976958f, 
    -0.02085081f, 0.01508904f, 0.01376875f, -0.03291788f, -0.02550993f, 0.00305125f, 0.01280127f, 0.02671059f, 
    0.01428806f, -0.01126729f, 0.03139400f, -0.02484397f, -0.01526617f, -0.00787778f, -0.00311560f, -0.02187704f, 
    -0.02013069f, 0.01213256f, -0.03020055f, -0.03592872f, -0.03648397f, 0.02613608f, -0.00049124f, 0.00465941f, 
    -0.01309267f, 0.00654362f, 0.01441608f, 0.01771909f, -0.02013839f, 0.02652298f, 0.01929882f, 0.00723561f, 
    -0.00960668f, -0.01811716f, -0.03147725f, 0.02440483f, -0.00099112f, -0.02469480f, -0.03760284f, 0.02017927f, 
    0.01833150f, 0.00230559f, -0.00808190f, -0.01909119f, 0.00614115f, -0.02830637f, 0.00523169f, 0.02748673f, 
    0.00908446f, -0.01047787f, 0.02175692f, 0.00526904f, 0.02298377f, -0.01841629f, 0.01270394f, -0.03531802f, 
    -0.00051399f, 0.02065594f, -0.01558606f, 0.02153505f, 0.02204418f, -0.01405459f, -0.01840607f, -0.00885560f, 
    0.00459483f, -0.03609937f, 0.01529244f, -0.03534244f, 0.02089624f, 0.00486257f, 0.00672761f, -0.01698636f, 
    -0.00108413f, 0.01690565f, -0.02852405f, 0.00743968f, -0.00990877f, 0.00720561f, -0.03185698f, 0.00709319f, 
    0.02649757f, -0.04323304f, -0.01607053f, 0.01810871f, -0.01590188f, 0.00280845f, 0.00122092f, 0.02101501f, 
    0.01239989f, 0.03124146f, -0.01908031f, -0.03837727f, 0.01090295f, -0.01893021f, 0.01632570f, 0.02425661f, 
    -0.02772432f, -0.01121941f, -0.02174838f, 0.02038833f, -0.00828866f, 0.00975802f, 0.02750028f, 0.01841795f, 
    0.01967192f, 0.01895544f, -0.01186892f, -0.01043597f, -0.01507473f, -0.02560273f, -0.00067756f, 0.01963622f, 
    -0.00363620f, -0.00189780f, -0.02301085f, -0.01554128f, 0.03122591f, -0.03931502f, 0.02811801f, 0.01138232f, 
    -0.03908722f, 0.00926336f, 0.01827008f, 0.02554350f, 0.01106317f, 0.02291651f, 0.00723810f, -0.01003546f, 
    0.01975172f, 0.01052599f, 0.01143606f, 0.01545260f, 0.00934771f, -0.00746480f, 0.02284277f, -0.01955754f, 
    0.01660066f, 0.03027775f, 0.00647487f, 0.00253277f, -0.01079823f, 0.03690676f, -0.02375760f, -0.03395063f, 
    -0.03743271f, 0.00762909f, 0.03386160f, -0.00294799f, -0.02126225f, 0.00751211f, -0.01305398f, 0.01043673f, 
    0.01789263f, -0.01827907f, 0.01796412f, -0.03758553f, 0.02642064f, -0.03090006f, -0.00121169f, -0.03458064f, 
    -0.03173542f, 0.03043858f, 0.01368255f, -0.01637734f, -0.04735354f, -0.03821182f, 0.01883330f, -0.03717656f, 
    -0.03877037f, 0.00046281f, -0.00761156f, 0.02388813f, -0.00916740f, 0.03354378f, -0.03494574f, 0.00458237f, 
    0.00316877f, 0.01512683f, -0.00893205f, 0.00018595f, -0.01108904f, 0.00283630f, -0.02140308f, -0.03183151f, 
    0.02747235f, 0.02293850f, 0.02970119f, -0.03513071f, 0.00596941f, 0.02695149f, 0.02057766f, 0.00516899f, 
    -0.04077317f, 0.02507118f, 0.00858712f, -0.02206876f, 0.01787194f, 0.03496950f, -0.00423123f, 0.02370133f, 
    0.02043868f, -0.01674989f, 0.03133788f, 0.03294628f, 0.03171714f, -0.02695605f, -0.00096187f, -0.01746759f, 
    0.02238603f, -0.02113342f, 0.02907040f, 0.02520550f, -0.01304046f, 0.01053812f, 0.02337362f, -0.03595851f, 
    0.00902822f, -0.03850713f, -0.02193959f, -0.01283979f, -0.01025579f, -0.02671332f, -0.02816857f, 0.01077260f, 
    -0.02754524f, -0.02353393f, 0.00279719f, -0.01933337f, 0.02666462f, -0.02199879f, -0.03137748f, -0.01750931f, 
    -0.01683148f, 0.00948592f, -0.01684363f, -0.03650615f, -0.00783003f, 0.00299057f, -0.01690068f, -0.02137138f, 
    0.02860107f, -0.01154845f, 0.00752279f, -0.00536058f, -0.01065684f, -0.03488306f, 0.01068459f, 0.02524902f, 
    0.00299951f, 0.01890499f, 0.00257307f, -0.02856220f, -0.02905765f, -0.03917890f, 0.02613157f, -0.03384848f, 
    -0.04251883f, -0.00690090f, 0.03634651f, 0.03091404f, -0.00214262f, -0.01317167f, -0.02740931f, -0.02017947f, 
    0.02137282f, -0.01148214f, 0.00005612f, 0.01352243f, 0.00832652f, 0.00024824f, 0.00365716f, -0.03429224f, 
    -0.00929177f, -0.01843300f, -0.01493034f, -0.02171859f, -0.00652455f, -0.01879578f, -0.02250898f, -0.01008993f, 
    -0.03332669f, -0.01227939f, -0.00277307f, -0.03604685f, -0.02665793f, 0.01363856f, -0.00708111f, 0.02845058f, 
    -0.02342698f, -0.01384550f, -0.02478057f, 0.03559586f, 0.01329221f, 0.00353160f, -0.00588853f, -0.00539230f, 
    0.01051649f, 0.01912124f, 0.00458767f, 0.00478274f, -0.00850595f, 0.01579404f, -0.03060664f, -0.03501945f, 
    -0.00786850f, 0.02043788f, -0.03423743f, 0.02899266f, -0.00905321f, -0.02973161f, -0.02459395f, -0.03748012f, 
    -0.04007309f, -0.01908125f, 0.02039516f, 0.01628227f, 0.02452683f, 0.00215581f, -0.00780167f, -0.01221878f, 
    -0.00813087f, -0.01917839f, -0.02727457f, -0.02585786f, -0.00265458f, -0.02402151f, 0.03067918f, -0.01918864f, 
    0.01993626f, 0.02224705f, -0.04391998f, -0.03458466f, 0.00242874f, -0.00450561f, -0.00940532f, -0.01821230f, 
    -0.02934561f, 0.01905540f, -0.00447979f, -0.03379264f, -0.01399277f, 0.00686401f, -0.02941381f, -0.03010868f, 
    -0.00153710f, -0.01798177f, 0.03378892f, 0.01778816f, -0.00284332f, 0.00491873f, -0.01771444f, -0.03847991f, 
    -0.02111376f, 0.01658114f, -0.03076085f, -0.00827118f, -0.00298858f, 0.00556583f, 0.01455910f, 0.00466624f, 
    -0.34831116f, 0.08723952f, -0.00712582f, -0.06608674f, 0.06175186f, 0.00860028f, 0.03849955f, 0.04166310f, 
    -0.14536490f, 0.01658034f, -0.03891102f, -0.01405413f, 0.05946314f, -0.02238938f, 0.29393584f, 0.11918427f, 
    -0.01940856f, -0.06692793f, -0.04884140f, 0.03316770f, 0.02168761f, 0.03343201f, 0.07700277f, 0.09634938f, 
    -0.04147619f, -0.09135483f, 0.08811363f, -0.15711975f, -0.02972614f, -0.02218396f, 0.00838749f, -0.00750051f, 
    -0.00381667f, 0.04714147f, 0.03531109f, -0.00070770f, -0.10416844f, -0.11946192f, -0.14818177f, -0.11607520f, 
    0.12017370f, 0.10969860f, -0.05137184f, 0.05849916f, 0.14015767f, 0.03602277f, 0.00494391f, 0.05299991f, 
    -0.12555508f, -0.07744331f, 0.00630581f, -0.18269166f, 0.03200296f, -0.00636286f, 0.11774170f, 0.04598676f, 
    0.08750568f, 0.00566061f, 0.09087196f, 0.12837754f, -0.04463648f, -0.01978713f, -0.03317605f, 0.04203450f, 
    -0.01794601f, -0.08339173f, -0.05150573f, 0.05781772f, -0.06542289f, 0.05848806f, 0.14374791f, 0.08671899f, 
    -0.11119565f, -0.03468481f, -0.05732380f, -0.18021743f, 0.02859548f, 0.04120507f, -0.00708485f, 0.03181215f, 
    0.14593235f, 0.04328763f, -0.05630872f, 0.00652309f, 0.03887251f, 0.02853683f, 0.00112829f, 0.07535700f, 
    -0.00802300f, -0.00447053f, -0.04191224f, 0.03648805f, -0.02364945f, 0.08293434f, 0.02600987f, 0.00535185f, 
    -0.03854761f, 0.12104531f, -0.00486917f, -0.29115221f, -0.06276363f, 0.01558336f, -0.08115038f, 0.09827720f, 
    0.11550493f, -0.08568111f, 0.00770429f, -0.07253524f, -0.01272749f, -0.06850179f, -0.09312839f, 0.00729639f, 
    0.01599562f, -0.00286929f, 0.02145219f, -0.09505785f, 0.07822263f, 0.06051547f, 0.03626990f, 0.03821265f, 
    0.08207286f, -0.15283366f, -0.01179514f, -0.02908503f, -0.03777121f, -0.04547482f, -0.05942858f, -0.04060528f, 
    -0.02953609f, -0.08213603f, -0.01092227f, 0.04358414f, 0.17243449f, 0.10033090f, 0.04016960f, 0.13456000f, 
    0.09662582f, 0.06555521f, 0.05195521f, 0.00117095f, 0.04053346f, 0.08715506f, 0.05710177f, -0.04329316f, 
    0.02766290f, 0.13573112f, 0.08731236f, 0.08680033f, -0.02435257f, 0.00083603f, 0.04631039f, 0.02575464f, 
    0.01933067f, 0.00871936f, -0.02363065f, 0.00994173f, 0.12563477f, 0.22832702f, 0.22591300f, 0.02897898f, 
    -0.02632059f, 0.01561981f, 0.06451093f, 0.01154662f, 0.07188775f, -0.03173557f, -0.01662213f, 0.11698721f, 
    0.09747507f, -0.19970234f, -0.03722678f, 0.05829958f, 0.02269640f, -0.02638933f, -0.06855428f, 0.02067786f, 
    -0.14827427f, -0.02661319f, 0.08430948f, 0.02591025f, 0.17245772f, 0.12236796f, -0.01530207f, 0.08836349f, 
    0.02054758f, 0.09307062f, -0.03202157f, 0.01962707f, 0.14747040f, -0.01998895f, 0.02545799f, 0.05333174f, 
    0.02839215f, -0.06036820f, -0.08454506f, -0.06091662f, 0.02114085f, -0.01688737f, 0.03419137f, -0.02285159f, 
    0.07594465f, -0.04739474f, -0.06445924f, 0.15512446f, 0.04072094f, -0.01467248f, -0.12383319f, -0.17553787f, 
    0.03637304f, 0.10989126f, -0.06618443f, 0.01781973f, 0.15655847f, 0.06263422f, -0.02096317f, 0.10899060f, 
    0.03398269f, 0.07481086f, 0.02213933f, -0.11035690f, -0.01222732f, -0.03644560f, 0.13284776f, -0.01212127f, 
    -0.03737431f, 0.06235021f, 0.08822228f, 0.02508149f, 0.07911051f, -0.12623157f, -0.13087745f, -0.28425485f, 
    -0.05547085f, 0.07776064f, 0.06039399f, -0.02675415f, 0.10221643f, 0.01481257f, -0.04029290f, -0.03534284f, 
    -0.11780693f, 0.01859783f, 0.00005918f, -0.18633287f, -0.00419613f, 0.05661808f, -0.00262307f, -0.02654616f, 
    0.03946913f, -0.01175907f, -0.07362289f, -0.02518493f, 0.26634741f, 0.09635023f, 0.10207614f, 0.23470742f, 
    -0.05949551f, -0.00899308f, 0.00299426f, -0.03802405f, 0.00159084f, -0.01598063f, 0.04019959f, -0.01357626f, 
    0.08734936f, 0.07063908f, 0.00631434f, -0.03376036f, -0.00363147f, 0.02149558f, -0.04896076f, 0.00208398f, 
    0.02551402f, -0.04296525f, -0.03040855f, 0.05545617f, -0.14007550f, 0.08041213f, 0.14554551f, -0.04086858f, 
    -0.01328527f, -0.01788740f, 0.00194895f, -0.01330625f, -0.00006929f, -0.05691560f, 0.07216411f, 0.13979669f, 
    0.04726055f, -0.00980116f, -0.05377165f, 0.00644475f, 0.10864847f, -0.05296936f, -0.01027706f, 0.14737386f, 
    0.16359584f, 0.06259561f, 0.05940887f, -0.01427401f, -0.32339782f, 0.03971557f, 0.07041458f, 0.06227365f, 
    0.04617490f, -0.04074904f, 0.00306128f, 0.02483142f, -0.12786947f, -0.03829283f, 0.00311316f, 0.02946844f, 
    -0.05231656f, 0.05270086f, -0.22342144f, -0.14184012f, 0.04767805f, 0.16097011f, 0.03844383f, 0.01892177f, 
    0.06879605f, -0.01119901f, -0.04987260f, -0.01138757f, 0.16585946f, -0.15325628f, 0.15363300f, 0.13669309f, 
    -0.05636410f, 0.08870730f, -0.06785926f, 0.02878768f, -0.14445882f, 0.06700448f, 0.03532093f, -0.04595161f, 
    0.13523678f, 0.02686780f, 0.04600908f, 0.18589255f, -0.10796598f, 0.01987102f, 0.00551145f, 0.04379452f, 
    -0.02014059f, 0.02938401f, -0.03653440f, -0.05244647f, -0.15126775f, -0.02028426f, 0.11264855f, 0.17248523f, 
    0.07511343f, 0.00994133f, -0.00815125f, 0.10152380f, 0.02861759f, 0.00007393f, -0.00255472f, 0.01076355f, 
    -0.20829384f, 0.11565872f, 0.02126131f, 0.15026803f, 0.06846895f, -0.08359425f, 0.12154670f, -0.05940860f, 
    0.01947220f, -0.00108536f, -0.00191999f, -0.02815032f, 0.04307859f, 0.17528450f, 0.15479901f, 0.07579710f, 
    -0.09640400f, -0.03990463f, -0.00670244f, 0.03640423f, 0.02215541f, 0.08258419f, -0.00113195f, 0.06366527f, 
    0.07815241f, -0.02662425f, 0.14631751f, -0.14150801f, -0.04968076f, 0.02592314f, -0.07309233f, 0.02144660f, 
    -0.00847268f, 0.00069335f, -0.02909519f, 0.05973857f, -0.10303441f, -0.06633202f, 0.03680791f, 0.08382729f, 
    -0.10336052f, 0.03691886f, 0.12772791f, 0.01326450f, -0.04535043f, 0.03666321f, 0.05431085f, -0.06242775f, 
    -0.12130547f, -0.09996882f, 0.06447938f, -0.12870917f, 0.01822427f, 0.03490806f, 0.16069444f, -0.05168418f, 
    0.01242562f, 0.04217928f, 0.09443741f, -0.04639594f, 0.12442149f, 0.02709781f, -0.09830199f, -0.12974346f, 
    0.04803111f, 0.08007576f, -0.03101344f, -0.05245539f, 0.09205198f, 0.03275606f, 0.01824085f, 0.07095747f, 
    -0.00261161f, -0.04433434f, -0.14643864f, -0.00116378f, 0.13762401f, 0.02992904f, -0.06594356f, -0.03314608f, 
    0.05063300f, 0.10998741f, -0.02988755f, -0.04415756f, 0.09257882f, -0.14160882f, -0.11275315f, -0.12888469f, 
    -0.02925095f, 0.07287441f, -0.05239208f, -0.03611821f, 0.04841091f, 0.02067431f, 0.00206773f, -0.00068490f, 
    -0.14055605f, 0.21978724f, 0.01979402f, 0.17559470f, 0.01273179f, -0.00910283f, 0.04522970f, -0.05172172f, 
    0.03405276f, -0.00370585f, -0.03349691f, 0.02148291f, -0.21296710f, -0.00454322f, -0.01019243f, -0.01376993f, 
    0.03263441f, 0.12723903f, 0.07329206f, -0.07720958f, 0.12767386f, 0.06488331f, 0.01373861f, -0.02881139f, 
    -0.02761811f, 0.08919334f, -0.14004241f, -0.04820650f, 0.00085322f, 0.04091905f, 0.06473386f, 0.14279243f, 
    0.06406139f, 0.04010298f, 0.05898680f, 0.06664997f, -0.28794816f, 0.01824904f, -0.06430918f, 0.08432430f, 
    0.01267134f, 0.01994132f, 0.06756828f, -0.00215895f, -0.06074835f, 0.00776340f, -0.03489980f, 0.05578314f, 
    0.04224976f, -0.00544898f, -0.02480874f, 0.01374638f, 0.02549235f, 0.01755252f, -0.02862218f, -0.03497513f, 
    0.01431764f, -0.02606949f, 0.02290006f, -0.06367975f, -0.02027457f, -0.08300660f, 0.19096403f, 0.02427632f, 
    0.03371245f, 0.07341417f, 0.10533793f, -0.05698379f, -0.02141334f, 0.01451169f, -0.00435125f, 0.02330247f, 
    0.00765064f, 0.02369350f, -0.04308709f, -0.01233992f, 0.04343318f, 0.01910124f, 0.06245948f, 0.03458508f, 
    -0.06545899f, 0.01882190f, 0.07218029f, -0.00773915f, -0.04226662f, -0.00191774f, -0.03994932f, -0.27171323f, 
    0.01114972f, 0.09616144f, 0.03243642f, -0.02585490f, -0.00879731f, -0.05850745f, 0.00526380f, 0.01987150f, 
    -0.12817697f, 0.03207454f, 0.07383902f, 0.00968414f, 0.00890303f, 0.07205278f, 0.00112240f, 0.04133905f, 
    -0.14448147f, -0.05800563f, 0.01067865f, 0.18752432f, -0.01062795f, 0.10024290f, 0.07785597f, 0.21634242f, 
    -0.01322867f, 0.02168852f, 0.00894109f, -0.00311017f, 0.05334248f, 0.08963369f, 0.03088037f, 0.03121473f, 
    0.16173540f, 0.08958442f, 0.05536801f, -0.17326052f, -0.06147536f, 0.04771687f, 0.05477995f, 0.08892287f, 
    -0.08809561f, 0.01628548f, 0.08367804f, 0.04386569f, -0.07887059f, 0.19717145f, 0.07793196f, 0.08957332f, 
    0.02061319f, 0.03534533f, -0.02924089f, 0.01623767f, -0.02026638f, 0.02317528f, -0.03456515f, 0.01773013f, 
    0.00014820f, 0.26506925f, 0.05975391f, 0.09407713f, 0.00869233f, 0.06639767f, 0.01187025f, 0.08710010f, 
    0.01437333f, 0.09021174f, -0.02803715f, 0.10407525f, 0.12251742f, 0.00334745f, 0.02962494f, 0.08644624f, 
    0.10714784f, -0.04056106f, -0.14989872f, -0.05778459f, -0.03757219f, 0.01210652f, 0.02998250f, 0.01562036f, 
    -0.11122258f, -0.04428416f, -0.03776640f, 0.08258948f, -0.00129867f, 0.04399976f, 0.12068239f, 0.04533797f, 
    0.06757267f, 0.03689374f, -0.02672706f, 0.02764475f, -0.14358884f, -0.30265486f, -0.03390871f, 0.19532463f, 
    0.10075792f, -0.08967258f, 0.03934705f, -0.03560198f, -0.02310356f, -0.01631958f, -0.00760608f, 0.01415221f, 
    0.22227351f, -0.01743659f, 0.01006702f, 0.19752456f, 0.14033873f, 0.00826388f, 0.03004233f, -0.03884289f, 
    0.03743821f, 0.01217647f, -0.01388002f, -0.00287965f, 0.15687050f, 0.01180675f, 0.17420033f, -0.08553041f, 
    -0.11913445f, 0.03204546f, 0.07049269f, 0.08175039f, 0.03464301f, 0.08488763f, -0.01310490f, 0.10218052f, 
    -0.09387466f, 0.07573350f, -0.10291994f, -0.04308213f, 0.02401571f, 0.02620808f, 0.09318456f, -0.08555088f, 
    -0.03951250f, -0.01767863f, 0.07465429f, 0.03644852f, -0.06878158f, 0.02443659f, -0.02456177f, -0.11102276f, 
    0.01992559f, 0.03499421f, -0.09221565f, -0.01783124f, 0.03089276f, -0.01736175f, -0.04371713f, 0.03696985f, 
    -0.09025379f, -0.05302282f, -0.08375835f, 0.02953679f, -0.00874409f, -0.02875826f, 0.06966539f, 0.03904887f, 
    0.00733875f, 0.01990455f, 0.03641604f, -0.00034991f, 0.09828692f, 0.01609541f, 0.03728069f, -0.08989835f, 
    0.07905677f, -0.00650500f, -0.02524815f, -0.03255623f, 0.05537521f, -0.05157788f, -0.01185947f, 0.10315007f, 
    -0.15121424f, 0.21198401f, 0.08509113f, 0.05671543f, -0.08092858f, 0.04177735f, 0.08915686f, -0.09555627f, 
    0.02948038f, -0.11623946f, 0.10229115f, -0.00022303f, 0.05602685f, 0.08573955f, 0.14975257f, -0.12080031f, 
    -0.08102813f, -0.03774049f, -0.03483526f, -0.04068351f, -0.01311149f, 0.11218137f, -0.03667320f, -0.03627972f, 
    -0.02751089f, -0.14121655f, 0.04645243f, 0.08247129f, 0.01370096f, -0.00443469f, 0.08729230f, 0.08123469f, 
    0.04472062f, -0.07126415f, -0.00794833f, 0.02108726f, -0.06806998f, -0.15729842f, 0.00864934f, -0.10460857f, 
    0.07617252f, -0.00328132f, 0.01601866f, 0.09168344f, -0.05750240f, -0.06138183f, 0.02491220f, 0.02896913f, 
    0.02813027f, 0.00823705f, -0.00311393f, -0.03355911f, 0.00044581f, -0.03827347f, -0.02218554f, 0.02732601f, 
    0.02316419f, 0.00464669f, -0.00631568f, 0.02562515f, -0.00700887f, -0.03178278f, -0.02818405f, -0.01317599f, 
    0.01853935f, -0.03243559f, -0.01523822f, -0.01386970f, -0.01253709f, -0.01573614f, 0.02359682f, 0.02467269f, 
    0.00601666f, -0.01193697f, 0.00148204f, -0.00863260f, -0.03227074f, 0.02611748f, -0.03811665f, -0.00257799f, 
    0.00541787f, 0.01582613f, 0.02723614f, -0.01909725f, -0.03056291f, -0.01401941f, 0.01550133f, 0.02831979f, 
    0.01291082f, 0.02232490f, 0.03156049f, -0.03011047f, -0.01650731f, 0.01422953f, -0.02339161f, 0.00713810f, 
    -0.03012061f, -0.01316016f, -0.02716557f, 0.01906236f, 0.00615789f, 0.02083991f, -0.00398400f, 0.01036642f, 
    -0.01275984f, -0.03095093f, 0.01602198f, -0.03915456f, -0.01664170f, -0.03068345f, -0.01333230f, 0.03351030f, 
    -0.02809905f, 0.03274479f, 0.02851434f, -0.00661140f, 0.00982491f, -0.01338329f, -0.02096454f, 0.01516033f, 
    0.01106167f, -0.02978797f, 0.01772499f, 0.00771551f, -0.01188556f, -0.02551368f, 0.02771249f, -0.00496944f, 
    -0.03592278f, -0.03260740f, 0.02109358f, -0.02131002f, 0.00910916f, -0.00542505f, -0.00259976f, -0.02322381f, 
    -0.01868953f, 0.01671005f, -0.02075927f, 0.03300846f, -0.01671325f, -0.00966181f, 0.01819420f, -0.01523833f, 
    0.03181043f, 0.00837584f, 0.02619081f, 0.00810214f, -0.03481995f, 0.02789088f, -0.01470363f, -0.02497206f, 
    -0.00288124f, -0.01811233f, 0.00626842f, 0.02673222f, 0.02126469f, -0.00126884f, 0.00296701f, 0.00127025f, 
    -0.03308584f, 0.02533157f, -0.02828459f, -0.02268133f, 0.00195665f, -0.03760540f, -0.01894853f, 0.01081614f, 
    -0.01997079f, 0.02916026f, -0.00833091f, -0.02742662f, -0.00663531f, 0.02248784f, -0.03705149f, -0.01884845f, 
    -0.03011143f, -0.00947668f, 0.01415743f, 0.01820172f, 0.00243588f, 0.00907085f, -0.00168834f, 0.00826224f, 
    -0.01816072f, 0.01019718f, 0.00845793f, 0.02231497f, -0.01303487f, -0.02228092f, -0.01906829f, -0.01645116f, 
    0.02091413f, -0.02557307f, 0.01190685f, 0.02055952f, -0.00657735f, -0.02465317f, -0.02594364f, 0.01881520f, 
    0.00039901f, 0.03025718f, 0.03022728f, -0.03209885f, 0.00114525f, -0.01965211f, 0.00221370f, 0.03202963f, 
    -0.01670414f, 0.03256340f, -0.00003664f, 0.01990039f, -0.04000892f, 0.00178369f, 0.00178003f, -0.01035932f, 
    0.00351326f, 0.01692954f, -0.00506639f, -0.00215063f, -0.03117254f, -0.03125307f, -0.01874308f, 0.00229920f, 
    0.01887389f, 0.02513709f, -0.02002046f, 0.00498715f, -0.01118419f, -0.00766596f, -0.01497041f, 0.01891161f, 
    -0.00374089f, 0.00762411f, -0.00632104f, -0.03738319f, -0.02024905f, 0.00401917f, 0.01420029f, 0.01835841f, 
    -0.01058680f, 0.00274207f, 0.01092365f, 0.02641479f, -0.00980419f, -0.01017000f, -0.02319153f, 0.01256866f, 
    0.02529286f, -0.01097712f, 0.02970705f, -0.00968791f, -0.03099816f, -0.01117901f, -0.02409854f, 0.00365782f, 
    -0.00522563f, -0.03424216f, 0.02005925f, -0.03972025f, 0.01764356f, -0.01797726f, 0.02642404f, 0.01165231f, 
    0.01995267f, 0.00836287f, 0.02800129f, -0.00967524f, 0.02949033f, -0.02616389f, -0.01635840f, 0.01970586f, 
    0.01663799f, -0.02391471f, -0.02182120f, -0.02567962f, 0.00087221f, -0.02732037f, -0.03512820f, -0.03724165f, 
    -0.03810698f, -0.00334402f, -0.03768133f, 0.01146804f, -0.01790605f, -0.00494970f, -0.01470938f, -0.01534699f, 
    -0.04019363f, -0.03472408f, 0.01116802f, -0.00621776f, 0.02715598f, -0.03618655f, 0.02087381f, -0.03829014f, 
    -0.02579203f, -0.03387330f, 0.02290956f, 0.01337013f, -0.00355880f, 0.02129593f, 0.02764316f, -0.00834211f, 
    0.02484489f, 0.01755611f, 0.00973600f, 0.00297201f, -0.03497563f, -0.03850014f, 0.01610988f, -0.01954123f, 
    -0.00592786f, -0.04152013f, -0.01039583f, 0.00078902f, -0.01965825f, -0.03302853f, 0.01722415f, 0.02777197f, 
    0.00299793f, -0.03913446f, -0.02122989f, 0.02406670f, -0.01442834f, -0.02737912f, 0.02697548f, 0.00727018f, 
    0.00359066f, -0.01739540f, 0.01216199f, 0.02254568f, -0.00194456f, -0.03825098f, 0.02103334f, 0.03081485f, 
    -0.01743353f, 0.00952573f, -0.03110239f, 0.00312693f, 0.00567675f, 0.01355326f, 0.03142160f, -0.00658293f, 
    0.01911267f, -0.02598520f, 0.02505435f, 0.03009387f, 0.01601676f, -0.01062966f, 0.00893546f, -0.03257322f, 
    -0.01106090f, -0.02117895f, 0.01342156f, 0.00093042f, 0.00038546f, 0.02193715f, -0.00885429f, 0.00780295f, 
    0.01204331f, 0.02565194f, -0.02094429f, -0.01304691f, 0.00691066f, -0.00260820f, 0.02027777f, -0.03067780f, 
    -0.01553342f, 0.00605414f, -0.03928658f, 0.01071302f, -0.00439294f, 0.00964304f, -0.00164912f, 0.02618264f, 
    0.00123963f, 0.01732811f, 0.02115350f, 0.02683827f, -0.03252646f, -0.00706229f, 0.01670450f, -0.02889988f, 
    -0.01999492f, 0.02518149f, 0.00636822f, 0.00982067f, 0.01794260f, 0.02576506f, -0.03096155f, 0.01185472f, 
    -0.01034797f, 0.01145342f, -0.00627659f, -0.00040645f, 0.00116836f, 0.02314502f, 0.01312864f, -0.01779260f, 
    -0.00574591f, 0.02501960f, -0.01093460f, -0.00196963f, -0.03951320f, -0.01723831f, 0.01580858f, 0.02731210f, 
    -0.01151270f, -0.00919959f, 0.03156480f, 0.01969561f, -0.02619019f, 0.02255322f, -0.00836003f, -0.02323184f, 
    -0.00645297f, 0.01006323f, 0.02379245f, 0.03259091f, -0.00607667f, 0.00426582f, -0.02149235f, -0.02667450f, 
    -0.03215989f, -0.01632458f, -0.03734941f, -0.00929426f, -0.02592720f, -0.03379904f, 0.01826847f, -0.00476599f, 
    0.02103215f, -0.00679016f, 0.02507016f, 0.00513170f, -0.03670491f, 0.02823128f, 0.02309481f, 0.02526328f, 
    -0.02184307f, -0.03187874f, 0.02465049f, -0.01535820f, -0.02098547f, 0.00343212f, -0.01052585f, -0.00575186f, 
    0.00467089f, -0.03546780f, -0.02344633f, -0.02398274f, 0.02941963f, -0.00411847f, -0.02278153f, 0.00442439f, 
    -0.02820295f, -0.02938115f, -0.01288028f, -0.02263408f, 0.01113438f, -0.04067253f, -0.00172701f, -0.01058705f, 
    0.02051878f, 0.01681245f, -0.01043899f, -0.01141599f, -0.00221596f, 0.00271348f, 0.02490652f, -0.01386200f, 
    0.02394267f, -0.02729080f, -0.00334778f, 0.02024130f, 0.00847136f, -0.00915772f, -0.03673329f, -0.03730688f, 
    -0.00044243f, 0.03024299f, 0.00096259f, -0.00078804f, 0.01024675f, -0.01232310f, 0.02292515f, 0.02118571f, 
    -0.01490927f, 0.02438998f, 0.02830198f, -0.01121057f, 0.02021509f, 0.03340827f, 0.02023081f, -0.01731036f, 
    -0.01656640f, -0.00041864f, -0.03692579f, 0.03179660f, -0.00354915f, -0.03562856f, 0.00106010f, 0.01676435f, 
    -0.01421423f, 0.00236806f, -0.02567197f, -0.01100389f, -0.01752564f, -0.01177949f, 0.02199849f, 0.00275965f, 
    0.02281243f, -0.04242938f, -0.01372746f, -0.00942709f, -0.00304573f, -0.02309359f, 0.01154083f, 0.02489273f, 
    0.00943476f, -0.00987965f, 0.03312150f, 0.01301633f, 0.01605489f, -0.02409917f, -0.02032305f, -0.02539878f, 
    -0.00183608f, -0.01729020f, -0.00370574f, -0.01828917f, -0.03536576f, 0.02539943f, -0.02046173f, 0.01132820f, 
    -0.00043022f, -0.00745498f, -0.02315222f, 0.00822728f, 0.00161854f, -0.02218450f, -0.02734280f, -0.03766124f, 
    0.01888941f, -0.00412896f, -0.00087435f, -0.01354677f, 0.00487891f, -0.00669134f, -0.00709550f, -0.02272177f, 
    -0.03382171f, -0.01968188f, -0.02876764f, 0.01326391f, -0.03389895f, 0.02375487f, -0.01871712f, -0.01988297f, 
    0.01094790f, 0.03063794f, 0.01486532f, -0.02309169f, -0.02525645f, -0.01642767f, 0.02278742f, -0.02115373f, 
    -0.00881250f, 0.02641380f, 0.00007425f, -0.00277228f, -0.01240576f, -0.03806990f, -0.01759117f, 0.00117942f, 
    0.00476553f, 0.02327160f, -0.03913400f, -0.01088847f, -0.01621613f, -0.01261404f, 0.02854094f, -0.02614512f, 
    -0.02536518f, -0.00830618f, -0.00768024f, 0.02762146f, -0.03411707f, 0.03115336f, -0.01561154f, -0.00695900f, 
    0.00520988f, -0.02676230f, 0.00491719f, 0.01837451f, 0.00612840f, 0.02238108f, -0.00569813f, 0.02628899f, 
    -0.03176908f, -0.03037810f, 0.01565249f, -0.01787421f, 0.02561041f, 0.01816433f, 0.03091610f, -0.01462405f, 
    -0.00035757f, -0.01234614f, -0.03004741f, -0.02212327f, -0.03116563f, 0.03290196f, -0.00662298f, -0.01438365f, 
    -0.03260056f, -0.03669662f, -0.02962270f, 0.00358440f, 0.02170002f, -0.03973018f, -0.00619586f, -0.02102197f, 
    0.02057988f, -0.00625576f, 0.03064391f, -0.02256508f, -0.02054518f, -0.01172836f, -0.01514911f, 0.01988951f, 
    0.01246944f, 0.01816051f, 0.03026458f, 0.02160016f, 0.02528686f, 0.01569880f, 0.03529565f, -0.02329976f, 
    -0.00747312f, 0.00452723f, 0.02201806f, -0.02385493f, 0.02527270f, -0.00304481f, -0.01779507f, 0.03148754f, 
    0.01521731f, 0.00681476f, 0.01220528f, 0.01534089f, 0.01091994f, 0.00442852f, -0.00379490f, -0.02127897f, 
    -0.03103946f, -0.01503651f, -0.01298092f, 0.02273506f, -0.01222056f, -0.02295264f, 0.00337838f, 0.00640695f, 
    0.00534907f, -0.00195326f, 0.02120603f, -0.01717914f, -0.00195999f, -0.02995721f, -0.01933291f, 0.01668193f, 
    0.02465250f, 0.00922866f, 0.02277656f, -0.00947683f, 0.01461261f, -0.00784539f, -0.01589485f, -0.01779708f, 
    -0.03252976f, -0.02676971f, -0.00424510f, 0.03226742f, -0.02200158f, -0.02713308f, -0.00225122f, 0.02365294f, 
    -0.00811338f, 0.02168554f, -0.02722010f, -0.01075368f, -0.00932916f, -0.01136418f, -0.00843471f, 0.02848715f, 
    -0.00650678f, -0.00019938f, -0.03308477f, -0.00344932f, 0.01840897f, -0.03353376f, -0.02921059f, -0.00321855f, 
    -0.03462978f, 0.03421776f, 0.00980093f, 0.00564891f, -0.00148132f, 0.00149737f, -0.03047702f, -0.00587125f, 
    0.02416057f, -0.03608735f, -0.03539010f, 0.03321012f, 0.02958515f, 0.01938793f, -0.01752573f, -0.00383291f, 
    0.01109685f, 0.02082481f, -0.01849554f, 0.01052379f, -0.00661336f, -0.00593903f, 0.02547215f, 0.00546843f, 
    0.01565289f, 0.01771805f, -0.01602849f, -0.00002532f, -0.01545229f, 0.02617457f, -0.03807110f, -0.03425276f, 
    0.02713860f, 0.01858889f, -0.00366475f, -0.02027132f, -0.01413270f, -0.00620609f, -0.01916658f, -0.01022368f, 
    -0.00819119f, -0.00519942f, 0.02840678f, -0.01804231f, -0.01638195f, 0.00971228f, 0.03301974f, -0.03726243f, 
    -0.00539256f, 0.02370759f, -0.04134016f, -0.02541502f, 0.00347304f, 0.02821937f, -0.02298886f, -0.00394330f, 
    -0.03631835f, 0.03068541f, -0.02452188f, 0.02912385f, 0.00254893f, 0.01839964f, -0.00217533f, -0.00360891f, 
    -0.03489264f, -0.02755812f, -0.03891756f, 0.00818192f, -0.01335878f, 0.01265435f, 0.01688769f, 0.01112560f, 
    -0.03820518f, 0.01754692f, -0.02162924f, 0.01085187f, 0.00477051f, 0.01176797f, -0.02372666f, -0.01280013f, 
    -0.02751125f, -0.01151995f, 0.01021548f, -0.02491720f, -0.00158032f, 0.00048084f, 0.01740200f, -0.02895829f, 
    -0.00014367f, -0.03677136f, 0.02116708f, -0.01508495f, 0.00719341f, 0.02900026f, -0.03308775f, -0.02009398f, 
    -0.03530704f, 0.02087293f, -0.01272504f, -0.01182027f, 0.00862439f, 0.02746090f, -0.01257351f, 0.02491060f, 
    -0.00759359f, 0.01410661f, 0.00524051f, -0.01724010f, 0.01326010f, -0.02764955f, -0.01463204f, 0.03019038f, 
    -0.01780447f, -0.03409471f, -0.01584589f, -0.02276283f, -0.02164834f, 0.03016477f, 0.02928627f, -0.00335420f, 
    0.00156254f, 0.00492282f, 0.02363509f, -0.01416748f, 0.02981822f, -0.01583541f, 0.01161352f, 0.01578652f, 
    -0.01269662f, 0.03786436f, -0.01132551f, -0.02452381f, 0.01503661f, 0.02919722f, 0.01328281f, 0.02575335f, 
    -0.03351308f, -0.01549003f, -0.01757428f, -0.01864297f, -0.03845812f, -0.00001618f, 0.01826825f, -0.02030372f, 
    -0.02880831f, -0.02109920f, 0.02265141f, -0.00891640f, 0.02937719f, 0.02934017f, -0.02062150f, -0.00862155f, 
    0.01644239f, 0.02533968f, -0.02171540f, -0.02427147f, -0.00468578f, 0.02818206f, -0.03743311f, -0.03601066f, 
    -0.01173479f, -0.01294727f, -0.00298076f, -0.01564547f, -0.01275334f, -0.03152682f, -0.01090404f, 0.02153363f, 
    -0.00457889f, -0.00246309f, 0.01477007f, -0.02350848f, -0.03786476f, 0.02219440f, -0.01281500f, -0.00952417f, 
    0.01013266f, -0.02095037f, 0.00998293f, -0.02306315f, 0.02901450f, -0.01382715f, 0.02635207f, -0.01064038f, 
    -0.01307212f, 0.01126450f, 0.01530461f, 0.00881212f, -0.02214537f, 0.00548017f, 0.02172573f, 0.02460890f, 
    -0.03763673f, -0.02958595f, -0.02993314f, -0.00962097f, -0.02007969f, -0.02423181f, -0.01866644f, -0.03544868f, 
    0.00111412f, 0.01875050f, 0.02118328f, 0.02797014f, -0.01270133f, -0.02032941f, -0.03131901f, 0.00453148f, 
    0.02783626f, -0.03907783f, -0.01500032f, -0.02595318f, 0.00624988f, -0.01698024f, 0.02234062f, -0.03239888f, 
    -0.02749139f, -0.00666500f, -0.01975156f, 0.00685003f, -0.03251491f, 0.00482033f, -0.04213376f, -0.03926808f, 
    -0.00987523f, 0.01882890f, -0.00026653f, -0.02587318f, 0.00786390f, -0.02074861f, -0.02919446f, 0.01665226f, 
    -0.00557303f, -0.01437260f, -0.01155335f, -0.02916691f, -0.01756828f, -0.03506799f, -0.02968243f, -0.01659630f, 
    -0.02135766f, -0.00621432f, 0.01426259f, 0.01292290f, -0.01904820f, 0.00000633f, -0.00995605f, -0.00564262f, 
    0.01299435f, 0.02276802f, -0.03490521f, -0.01500675f, -0.02767373f, 0.02765801f, -0.01172656f, 0.00160276f, 
    -0.04152223f, 0.02874759f, -0.03931412f, 0.00510667f, -0.00335199f, -0.00437423f, -0.03480535f, -0.03436838f, 
    0.01407491f, -0.03836600f, 0.02886183f, 0.01135966f, 0.01724656f, -0.03622152f, 0.02064978f, 0.01797378f, 
    0.01278706f, -0.00544215f, -0.01384410f, 0.00540105f, 0.01524215f, -0.00961739f, -0.02635708f, -0.03904719f, 
    -0.03644886f, 0.00586253f, -0.00753877f, -0.01035034f, 0.00726687f, -0.02147730f, 0.00544760f, 0.00059040f, 
    0.00519294f, 0.00258774f, -0.00905058f, -0.02386159f, 0.02567603f, -0.00263455f, -0.03071449f, 0.02173158f, 
    -0.03941822f, -0.03885773f, -0.02277378f, -0.02758388f, 0.01816629f, -0.03217705f, 0.01481819f, -0.01204446f, 
    -0.03202476f, -0.04154179f, -0.00766787f, -0.00948557f, 0.02779717f, -0.02456344f, -0.03251648f, 0.01716011f, 
    0.00802859f, -0.02224205f, 0.01933250f, -0.00008191f, -0.01834361f, 0.01909153f, -0.03681318f, -0.01667713f, 
    -0.02621448f, -0.02772653f, 0.00822448f, -0.03204880f, 0.00503022f, 0.02756636f, 0.03413512f, 0.01105586f, 
    0.02323386f, 0.00331845f, -0.03482013f, 0.02973251f, 0.01497608f, 0.00236498f, -0.01392255f, -0.03593784f, 
    0.01453793f, -0.03474598f, 0.01011285f, 0.02719733f, -0.01857185f, 0.02685951f, -0.01421154f, 0.01614995f, 
    -0.04111033f, 0.00386008f, -0.03479665f, -0.02509533f, -0.02255998f, -0.00299056f, 0.01006971f, 0.00135475f, 
    -0.03805733f, 0.02084801f, -0.03373485f, 0.00053915f, -0.02328416f, -0.00832905f, -0.00248767f, 0.02636583f, 
    0.02016275f, -0.00946263f, -0.00304240f, 0.01209737f, 0.00351144f, 0.00011039f, -0.02948846f, -0.00821126f, 
    -0.02369466f, -0.02382517f, 0.03173960f, -0.00546058f, -0.02663409f, -0.04086888f, -0.03583566f, -0.02460741f, 
    0.01592867f, 0.01647787f, 0.02429091f, -0.03431007f, -0.01279542f, -0.02637943f, 0.02930617f, 0.01222979f, 
    0.00204648f, -0.00273585f, -0.02075755f, 0.00797145f, -0.03878061f, 0.01998267f, -0.02816909f, -0.03162219f, 
    0.01617200f, 0.00097762f, 0.01560560f, 0.02065832f, 0.01680749f, -0.01754231f, 0.03002714f, -0.03234464f, 
    -0.01245934f, -0.01102896f, 0.00144107f, -0.01951735f, -0.01485573f, -0.00689234f, 0.02195245f, -0.03116019f, 
    -0.03558557f, -0.03821653f, 0.01032594f, -0.03365665f, 0.00683876f, 0.03161384f, -0.03254313f, 0.01303227f, 
    0.01116118f, -0.01325181f, 0.00655263f, -0.01867667f, -0.01790624f, -0.00478980f, 0.00290635f, -0.01801415f, 
    0.00776674f, -0.02702800f, -0.00356212f, -0.03215574f, 0.02220336f, 0.00974138f, -0.02756262f, -0.00068585f, 
    -0.00288840f, -0.01889002f, -0.01097418f, -0.04110241f, 0.01890058f, 0.01816884f, 0.01663042f, 0.02880038f, 
    0.02250500f, 0.01079496f, 0.01515592f, -0.02892671f, 0.01288786f, -0.00606925f, 0.01570335f, 0.00649745f, 
    0.02045347f, 0.01689194f, -0.00314594f, -0.02794648f, -0.01647620f, -0.02918662f, 0.01488853f, 0.02137234f, 
    0.01028900f, 0.02999439f, -0.00865721f, -0.01027280f, -0.02792352f, -0.00552499f, -0.00325082f, 0.02755223f, 
    -0.03276555f, 0.02080250f, -0.02275325f, -0.01588054f, 0.00896070f, -0.01790068f, 0.00368570f, 0.03112172f, 
    -0.02542066f, -0.02962515f, -0.03920455f, -0.00011691f, -0.00758503f, -0.02777451f, -0.00140139f, -0.01111299f, 
    0.02627268f, -0.03848293f, 0.02454483f, -0.00365532f, -0.01917679f, -0.02034124f, -0.02277890f, 0.03094161f, 
    0.01946910f, -0.03379700f, 0.02478477f, -0.00669612f, -0.00909568f, 0.00875619f, 0.01342599f, -0.03037233f, 
    0.00514458f, 0.02037447f, -0.00036294f, -0.02215165f, -0.02291988f, -0.02162465f, -0.01393962f, -0.02002663f, 
    -0.01625591f, -0.00696524f, 0.00055156f, 0.00049626f, 0.01441428f, 0.02205440f, -0.02988236f, -0.01915963f, 
    0.00395635f, -0.03367029f, -0.02688214f, 0.01205852f, 0.03010188f, -0.02506332f, 0.01425419f, 0.01444736f, 
    -0.04094399f, -0.02332504f, 0.01984068f, -0.02166046f, 0.00872343f, -0.03278640f, 0.02295283f, -0.01469336f, 
    -0.00698040f, -0.02462437f, 0.01323780f, 0.01766749f, 0.01890601f, 0.03081315f, -0.01667133f, 0.01455825f, 
    -0.02607870f, 0.02252021f, -0.03069867f, 0.02904836f, 0.01398437f, -0.02039658f, -0.02271459f, -0.03024771f, 
    -0.02522785f, 0.03419850f, -0.02776579f, 0.03249489f, -0.03173449f, -0.02653361f, -0.01378178f, -0.01213144f, 
    -0.00409916f, 0.02442041f, -0.02038850f, -0.02941462f, -0.01703136f, -0.00250540f, 0.01903768f, -0.00200755f, 
    0.02066286f, 0.02425991f, -0.03068016f, -0.00044452f, -0.01819455f, -0.01395368f, -0.02735804f, 0.00357180f, 
    -0.03903333f, -0.02523412f, -0.01403348f, 0.02953728f, 0.00967408f, 0.00405047f, 0.02695272f, 0.00553790f, 
    0.00417434f, -0.03137009f, 0.02853305f, -0.01030655f, -0.00090193f, 0.00062593f, 0.00751403f, -0.03459021f, 
    -0.00773678f, -0.01235312f, 0.00566723f, -0.01068747f, -0.01156440f, -0.03394016f, -0.02286586f, -0.03119286f, 
    0.01849839f, 0.02405022f, -0.00137145f, 0.00081967f, -0.01056775f, 0.02864742f, -0.00212147f, 0.02812218f, 
    -0.03107020f, 0.00522129f, -0.02814140f, 0.02372050f, 0.00320524f, -0.03188082f, 0.00015352f, -0.01220135f, 
    -0.00219411f, -0.02401355f, -0.01118259f, -0.03536108f, 0.03715849f, -0.00466286f, 0.01176469f, -0.01087326f, 
    0.00387992f, -0.02473658f, 0.02497219f, -0.03208518f, -0.03927310f, -0.00427085f, -0.03027686f, 0.01194013f, 
    -0.01825765f, -0.03299334f, -0.00678829f, 0.01576656f, -0.01362378f, -0.02148975f, -0.01191516f, -0.01030231f, 
    0.00970640f, -0.03850366f, -0.02709994f, 0.00024845f, -0.03437587f, -0.01850335f, -0.00745547f, 0.02716430f, 
    0.02876602f, 0.02675324f, -0.01172508f, 0.02464686f, 0.02259356f, 0.03779160f, -0.01518999f, 0.03000636f, 
    0.00070463f, -0.00056253f, 0.01913366f, -0.00869572f, 0.03093714f, 0.01407573f, -0.03310381f, 0.02241553f, 
    -0.00849162f, 0.03028638f, -0.02795511f, -0.00462183f, 0.01831642f, -0.02623209f, -0.03835180f, -0.03236618f, 
    -0.02289374f, -0.04204872f, 0.01035826f, -0.02991140f, 0.01469321f, -0.00128753f, 0.02778192f, -0.00956864f, 
    -0.02596386f, -0.00672217f, 0.03102741f, 0.01516785f, -0.02628631f, 0.03013393f, 0.02264028f, 0.01334383f, 
    0.01815841f, 0.00828545f, -0.03012818f, 0.02506342f, -0.01298457f, -0.01716132f, 0.02890627f, 0.01203737f, 
    -0.00772970f, 0.00614311f, 0.02070656f, 0.00751298f, -0.00373293f, -0.00550436f, 0.01842477f, -0.02545080f, 
    -0.04060588f, -0.00858367f, 0.00360098f, 0.01606693f, -0.03943233f, 0.00414696f, 0.01089577f, -0.02028204f, 
    0.01092830f, -0.02427575f, -0.00920462f, 0.01768227f, -0.01611758f, 0.01854720f, -0.00675032f, -0.00029282f, 
    -0.02888440f, -0.03831423f, 0.00939575f, -0.01239247f, -0.01740819f, 0.02707304f, 0.02379191f, -0.01747007f, 
    -0.01257573f, 0.03970997f, 0.03545481f, -0.01089827f, -0.01070833f, 0.03016620f, -0.02060534f, -0.03033488f, 
    -0.03789676f, -0.03773192f, -0.03981601f, -0.00852001f, 0.01641062f, -0.01955116f, -0.04115924f, 0.00184349f, 
    0.01076771f, -0.01439568f, -0.02801617f, -0.00828588f, -0.02470885f, -0.02783208f, -0.00649653f, -0.01904571f, 
    -0.04207876f, 0.01877991f, -0.01468479f, 0.00615080f, 0.01106234f, 0.01037984f, -0.01211980f, -0.01585149f, 
    0.01119018f, 0.00427565f, -0.00232997f, 0.00057668f, 0.04156857f, -0.02522649f, -0.03533303f, 0.01168715f, 
    0.01491137f, -0.01395042f, -0.02326229f, -0.00630037f, 0.01565021f, 0.03088203f, -0.01496703f, 0.01702841f, 
    -0.02366998f, -0.04107990f, -0.01299774f, -0.02229257f, 0.00667979f, -0.00685129f, -0.00278437f, -0.02755447f, 
    0.03280341f, 0.00080140f, -0.01899104f, -0.03739529f, 0.01071078f, 0.02889286f, 0.02298213f, 0.01970411f, 
    -0.02403925f, -0.02987809f, 0.01307904f, -0.02625858f, -0.00147153f, 0.00196583f, 0.03349502f, -0.01806832f, 
    0.02788732f, -0.02807635f, 0.01979389f, 0.02157947f, -0.01181400f, -0.04011934f, 0.03045448f, -0.03335856f, 
    0.02593942f, 0.03023729f, -0.03686165f, -0.00352466f, -0.01844861f, -0.00681181f, 0.02489337f, 0.01511697f, 
    0.01582698f, 0.02227587f, 0.02265826f, 0.00493857f, -0.01201258f, 0.00930649f, 0.03038578f, -0.02636626f, 
    0.02132670f, 0.00554803f, 0.02411161f, -0.00998402f, -0.01411441f, -0.03213791f, -0.04119953f, -0.01591875f, 
    0.01678336f, 0.00693792f, -0.02661376f, 0.02400040f, 0.01299727f, 0.01069821f, 0.00610945f, 0.02679160f, 
    -0.02447678f, 0.02353327f, -0.00968750f, 0.00830650f, -0.03823764f, -0.02541475f, -0.00602730f, -0.03842857f, 
    0.02415984f, 0.01124853f, -0.03035299f, 0.00293836f, 0.02759475f, -0.01193920f, 0.02645291f, 0.01236723f, 
    -0.01116459f, 0.02927742f, 0.01549936f, -0.02861794f, -0.01380087f, -0.01665548f, 0.02548536f, 0.02041448f, 
    -0.02143713f, -0.03261786f, -0.02237038f, -0.00982640f, 0.03013061f, -0.02900857f, -0.02636012f, -0.01237937f, 
    -0.02380316f, -0.01719899f, 0.01429548f, -0.03493164f, -0.00007822f, 0.00183064f, 0.01081034f, -0.00774935f, 
    0.01710704f, -0.01516221f, -0.01182484f, 0.00143141f, 0.01096597f, -0.01408193f, -0.01826381f, -0.01398593f, 
    0.05074351f, 0.00265516f, 0.02999624f, -0.01259558f, 0.05393432f, -0.04634653f, -0.04448634f, -0.02380509f, 
    0.05684480f, 0.02844721f, 0.01662927f, 0.01449789f, -0.19309236f, -0.01124468f, -0.11296178f, 0.12147030f, 
    -0.03533218f, 0.02359538f, -0.01346587f, -0.09412099f, 0.05792775f, 0.04226192f, -0.03127105f, -0.03767258f, 
    0.33601159f, 0.28795177f, -0.34923601f, -0.13485317f, 0.01028390f, -0.12923209f, 0.04860824f, -0.05528507f, 
    -0.07399199f, -0.02214411f, 0.04416586f, 0.06940690f, 0.15081096f, 0.01312444f, 0.20282312f, 0.23693636f, 
    -0.00667794f, -0.04789578f, -0.00523016f, 0.20139803f, -0.08668139f, 0.00796442f, 0.10431064f, -0.01063132f, 
    0.13872321f, 0.16218354f, 0.11738795f, 0.17607196f, 0.09517712f, 0.07929220f, -0.03743390f, 0.02433167f, 
    0.00161989f, 0.00067798f, 0.00013298f, 0.04175987f, 0.21623109f, -0.08666605f, 0.03551098f, 0.00349198f, 
    -0.02849966f, -0.01502459f, -0.00108436f, -0.06341884f, 0.09314740f, -0.04332661f, -0.08176339f, -0.03463711f, 
    0.06380415f, 0.06207873f, 0.08523159f, 0.12914653f, 0.03628682f, -0.00095279f, 0.03463909f, 0.07509399f, 
    -0.03209509f, 0.00923152f, 0.01098115f, -0.06862919f, -0.09849901f, -0.01171138f, 0.02730848f, 0.02323550f, 
    0.04362676f, 0.03998912f, 0.07684651f, -0.04504460f, 0.01462824f, -0.00458526f, -0.01852847f, -0.05753983f, 
    -0.05148182f, -0.04927726f, -0.02738742f, 0.04124765f, -0.00837908f, -0.00096790f, -0.03136878f, -0.00549359f, 
    -0.06678365f, 0.03849613f, -0.07188405f, 0.02335828f, 0.13630514f, 0.30029941f, 0.11992016f, 0.09361997f, 
    0.05113236f, 0.02047599f, 0.05726362f, 0.09531542f, 0.00054517f, 0.03048159f, 0.04978697f, 0.08486661f, 
    0.14251724f, -0.00567187f, 0.12589023f, -0.03456677f, 0.03293150f, 0.01798882f, 0.08531974f, -0.04384495f, 
    -0.01375395f, 0.02603509f, -0.01721629f, 0.04336474f, -0.04170094f, -0.02897061f, 0.04677447f, 0.02799965f, 
    0.02291360f, -0.07420902f, 0.02644596f, 0.04173792f, -0.00275576f, -0.09036219f, 0.04049636f, 0.06180458f, 
    -0.21311162f, -0.06592490f, -0.00516799f, -0.03818198f, 0.01598927f, -0.06832822f, -0.07635028f, 0.00220998f, 
    0.11569463f, 0.01075851f, -0.06088952f, -0.02284760f, -0.04609126f, 0.00332066f, -0.23654751f, 0.01077525f, 
    0.01189795f, -0.01634643f, -0.04087102f, 0.01112046f, 0.02019836f, -0.00640069f, -0.01161767f, -0.12040243f, 
    -0.10998066f, 0.02222490f, -0.03787451f, 0.08871584f, 0.07805905f, 0.04396928f, 0.06011924f, 0.00814016f, 
    0.01564060f, 0.04820280f, 0.03022116f, 0.03075690f, -0.16827478f, 0.04332090f, 0.08248802f, -0.00296210f, 
    -0.03798888f, -0.00021370f, 0.04297795f, 0.07063028f, -0.09408101f, 0.11812351f, -0.12481985f, -0.09943132f, 
    0.12594551f, -0.09463305f, 0.10793371f, 0.00960227f, -0.03844923f, 0.06613567f, -0.03166457f, -0.00527092f, 
    -0.04071379f, 0.17022426f, 0.10455717f, 0.00084896f, 0.07418443f, 0.02855234f, 0.17175674f, 0.10518212f, 
    0.01107770f, -0.04955627f, 0.00740947f, -0.00145934f, -0.05329994f, -0.02868258f, 0.01082498f, 0.00739720f, 
    0.12917638f, 0.11077348f, -0.01179328f, 0.12971663f, 0.04467243f, 0.07748324f, -0.07000046f, 0.01507349f, 
    0.06403908f, -0.00942682f, -0.00207897f, 0.05147560f, 0.13138355f, 0.04667199f, 0.08799130f, 0.25068444f, 
    -0.06624493f, -0.02432519f, 0.01112112f, 0.02865637f, -0.05072053f, -0.04360297f, 0.09900610f, 0.01743628f, 
    0.14575340f, 0.09746980f, -0.07633824f, -0.07015228f, 0.07327150f, 0.00303132f, 0.03376297f, 0.03477525f, 
    -0.01746316f, -0.02624492f, 0.01275731f, -0.06694158f, -0.26709884f, 0.00691443f, -0.09149956f, -0.08387744f, 
    -0.02132734f, 0.02277871f, 0.01517556f, -0.04683614f, -0.02643302f, 0.01427017f, -0.00162971f, 0.07922056f, 
    0.07596581f, 0.01039988f, 0.17835234f, -0.13617194f, -0.04635396f, 0.03274164f, 0.05977245f, 0.05322845f, 
    0.00866557f, -0.04652937f, 0.04890363f, 0.04976909f, -0.20503217f, -0.17059539f, 0.02067432f, -0.09554350f, 
    0.04888800f, 0.01271720f, -0.03588529f, -0.05658136f, 0.05248833f, 0.05833404f, -0.02544568f, -0.10131560f, 
    0.06969395f, 0.16841476f, -0.04414264f, 0.22496334f, -0.03240934f, -0.01660249f, 0.22986962f, 0.02245685f, 
    -0.10506278f, 0.11966243f, 0.01458725f, 0.02312134f, -0.05747724f, -0.16741022f, -0.02143341f, 0.02388616f, 
    0.00303658f, 0.06954581f, -0.00108260f, -0.00803711f, 0.12768278f, 0.03913787f, -0.05317322f, 0.01612451f, 
    0.09854808f, 0.03437994f, 0.15352139f, 0.14304630f, 0.14472026f, 0.00830632f, 0.06993615f, 0.06698236f, 
    -0.02217184f, 0.00951655f, 0.06978226f, 0.03046234f, 0.05815256f, 0.03004787f, -0.04151473f, 0.01825277f, 
    0.08779807f, 0.00389740f, 0.02020823f, -0.04684996f, -0.04066303f, 0.05743598f, 0.03390998f, 0.00359601f, 
    0.19023101f, -0.06795931f, -0.11201970f, -0.03734213f, 0.00309589f, -0.00784818f, 0.04062866f, -0.01666364f, 
    -0.02683927f, 0.06577767f, 0.09094731f, 0.13299792f, -0.05224616f, 0.05571090f, 0.04273539f, -0.07288411f, 
    -0.07411487f, -0.01162746f, -0.05665313f, -0.00003586f, 0.08171192f, 0.07382567f, 0.10035282f, 0.08056524f, 
    -0.25470409f, -0.09647103f, 0.00255175f, 0.02057892f, -0.01200484f, 0.12028024f, -0.11119442f, -0.04950972f, 
    -0.06971010f, 0.13311452f, 0.04659858f, 0.02422997f, -0.25404683f, -0.08938673f, -0.00649880f, 0.08004095f, 
    -0.02580835f, 0.06272587f, -0.01345972f, -0.00564415f, 0.00855939f, 0.00986609f, 0.04819595f, 0.02895078f, 
    0.02433195f, -0.19829664f, -0.13271679f, 0.03262036f, -0.06779978f, 0.00483047f, 0.03085187f, 0.00169730f, 
    0.04231541f, -0.05746580f, -0.00650167f, -0.04856944f, 0.22583836f, 0.02387219f, 0.05375227f, -0.02646150f, 
    0.08067621f, 0.04590286f, -0.02381773f, 0.00648890f, 0.03886863f, -0.00345116f, -0.05263545f, 0.00839442f, 
    0.11311990f, 0.15809873f, 0.01057905f, 0.08304352f, -0.04074879f, 0.07000523f, 0.00880857f, 0.04092767f, 
    -0.11140308f, -0.05831074f, -0.02374988f, 0.04142388f, -0.02601360f, 0.14957193f, 0.09036756f, 0.25430775f, 
    0.04632559f, -0.04757778f, 0.04040235f, 0.08251444f, -0.03429082f, 0.00977900f, 0.07941636f, 0.04218788f, 
    0.08872787f, 0.17349604f, -0.04749394f, 0.05559868f, -0.04424886f, -0.06587288f, 0.06512900f, 0.05746995f, 
    0.02482515f, 0.02235043f, -0.00617797f, 0.04334998f, 0.17142223f, 0.27143568f, -0.01141268f, 0.17914726f, 
    0.05349694f, -0.10435349f, 0.04664763f, 0.06112610f, 0.02771533f, 0.12440366f, 0.06849423f, -0.02149389f, 
    -0.28982094f, -0.20958786f, 0.00394255f, -0.08239017f, -0.04532875f, 0.11505155f, 0.06009757f, 0.04924354f, 
    -0.00349186f, -0.03487093f, -0.00074123f, -0.03430059f, 0.04529063f, -0.01280190f, -0.12522842f, -0.03261634f, 
    -0.01145218f, -0.00458004f, 0.03087150f, -0.01758082f, -0.02216643f, 0.08439726f, -0.02837352f, -0.04187372f, 
    0.15766262f, 0.08305757f, 0.09756704f, -0.00738491f, 0.05610921f, -0.04901404f, -0.03277057f, -0.00210898f, 
    -0.02253404f, -0.03349790f, 0.09082358f, -0.05317010f, -0.00220940f, -0.05251250f, 0.04162023f, -0.12849101f, 
    0.03143816f, 0.05193816f, 0.01879508f, -0.04999485f, -0.03699206f, 0.06451443f, 0.06219976f, -0.03184329f, 
    0.07587025f, 0.06419266f, 0.09722929f, 0.09388078f, -0.04259732f, 0.06237652f, -0.01574493f, 0.03145636f, 
    -0.05499235f, 0.07000308f, 0.03836623f, 0.02540472f, 0.03006112f, 0.23842637f, -0.25752917f, -0.09556268f, 
    0.13132158f, 0.08565304f, 0.08369032f, 0.03954630f, 0.01554716f, 0.11662930f, -0.01890195f, 0.00154475f, 
    0.07274481f, -0.07059295f, 0.09019169f, 0.13411999f, -0.01013156f, 0.07820571f, 0.00383571f, -0.04380555f, 
    0.07416742f, -0.00317781f, 0.06606719f, 0.09376744f, 0.28189901f, -0.12420084f, 0.02297259f, 0.25733900f, 
    -0.01977723f, -0.02671290f, 0.02649183f, -0.01386121f, 0.06457955f, 0.06707489f, -0.00976085f, 0.04913821f, 
    0.13642773f, 0.05595251f, -0.07346975f, 0.07658418f, 0.03495589f, -0.07163433f, -0.01749960f, -0.08306967f, 
    0.06148338f, 0.04902971f, -0.05463518f, -0.04081231f, -0.16513096f, 0.02465246f, -0.00583642f, -0.06728326f, 
    0.01038518f, -0.03475696f, -0.07995175f, -0.04242416f, 0.00107736f, -0.00995763f, -0.04580508f, -0.00193651f, 
    -0.27285367f, 0.11449356f, 0.02450546f, -0.08376469f, 0.04799780f, -0.08009692f, -0.07070323f, -0.01712569f, 
    0.07503666f, -0.00913079f, -0.04680997f, 0.04635262f, -0.21348378f, -0.14915113f, -0.06334434f, -0.17939010f, 
    0.09190361f, -0.00210146f, -0.05454239f, -0.07318701f, 0.00547055f, 0.10627085f, 0.08968434f, 0.01685492f, 
    0.04017523f, -0.02717085f, -0.06865293f, -0.03604396f, -0.02103282f, -0.13512976f, -0.01050165f, -0.02892981f, 
    -0.06577791f, -0.05881156f, 0.01786224f, -0.03038766f, -0.29384178f, -0.00140637f, 0.06674913f, 0.00780359f, 
    -0.01067637f, 0.02582131f, 0.14048126f, 0.00621072f, 0.03487691f, 0.02789826f, -0.01993449f, -0.01567882f, 
    0.12998566f, -0.00585857f, 0.11872272f, -0.07586028f, -0.03992085f, 0.07699707f, -0.07052011f, -0.00460540f, 
    -0.02056766f, 0.00575378f, -0.10668877f, -0.01430255f, 0.23983487f, 0.03495045f, 0.02485991f, -0.13315532f, 
    -0.04582440f, 0.07112302f, 0.04202557f, -0.05186849f, -0.09638961f, 0.14660767f, 0.05887058f, -0.02134290f, 
    0.03712479f, 0.06577216f, -0.08541380f, 0.03160066f, 0.00132228f, 0.03276674f, 0.03603705f, 0.12435223f, 
    0.01840398f, 0.00757175f, 0.05531640f, 0.08041253f, -0.21766302f, -0.05092883f, 0.06277991f, 0.00347746f, 
    0.03047348f, -0.04336692f, -0.03461045f, -0.04467959f, 0.07096628f, 0.00870796f, 0.03981435f, -0.04181589f, 
    0.19614737f, -0.02899234f, 0.25503483f, -0.07110066f, -0.00612680f, 0.03995099f, -0.03755673f, 0.04001706f, 
    -0.01098933f, 0.03417248f, -0.06274050f, 0.18072693f, -0.01950198f, 0.07508305f, 0.08723192f, 0.10007847f, 
    -0.02133984f, -0.04023054f, 0.05307932f, 0.05478294f, 0.00333456f, 0.01685418f, 0.02388771f, 0.03229975f, 
    0.14677042f, 0.11589334f, 0.14332139f, -0.06958464f, -0.09091264f, 0.01302639f, -0.02336801f, 0.01521779f, 
    0.04542992f, 0.01445520f, -0.01846909f, 0.08092641f, -0.01417700f, 0.12281979f, 0.00635270f, 0.09618833f, 
    0.02957809f, -0.02561424f, 0.04463136f, 0.09630678f, -0.00109805f, -0.04557468f, -0.01418005f, -0.04977565f, 
    -0.12175169f, -0.07561793f, -0.01592597f, 0.07252625f, 0.01147688f, 0.02988275f, -0.06504007f, -0.00409208f, 
    -0.02480634f, 0.03966548f, -0.04729074f, -0.03353327f, 0.08461728f, 0.00578306f, -0.15239498f, 0.08220429f, 
    0.03007839f, 0.00680937f, 0.02222732f, 0.05584880f, 0.10873516f, -0.04679884f, -0.04367513f, 0.11033290f, 
    -0.00177154f, 0.01860185f, 0.02203498f, -0.11833183f, -0.07277431f, 0.09063837f, 0.05447353f, 0.01046903f, 
    -0.01522212f, 0.02967479f, -0.04224763f, 0.05846891f, 0.27025399f, 0.14655164f, 0.12958558f, 0.09684291f, 
    -0.07548423f, -0.05424913f, 0.05118300f, -0.00433395f, 0.03350590f, 0.03633585f, -0.04863492f, 0.01055876f, 
    -0.01381320f, 0.00281596f, 0.02586869f, -0.01590221f, 0.00851712f, -0.00717096f, 0.02137991f, 0.03333826f, 
    0.02765110f, -0.03523147f, 0.01011902f, -0.01047948f, -0.01877500f, 0.00632734f, 0.00155665f, 0.03037564f, 
    -0.00559713f, -0.02469827f, 0.02336869f, 0.02029032f, 0.02271746f, -0.01252800f, 0.02843761f, -0.00419588f, 
    -0.01493268f, 0.01299684f, 0.01769528f, -0.01208563f, -0.00586555f, -0.01662301f, 0.01986827f, -0.03549284f, 
    0.00000475f, 0.02382971f, 0.01228330f, -0.03453738f, 0.01359912f, 0.01266637f, 0.02617095f, -0.01655289f, 
    -0.01345498f, -0.02332211f, 0.00063817f, -0.01837437f, -0.03201057f, -0.01694244f, 0.01931710f, 0.00490787f, 
    -0.00769700f, -0.02900801f, 0.02459352f, -0.04304906f, 0.01080192f, -0.03656899f, -0.02523466f, 0.01859560f, 
    -0.02993844f, -0.02339990f, 0.02642945f, 0.00114364f, 0.00688019f, -0.00521106f, -0.03158185f, -0.02686906f, 
    -0.02507672f, 0.02676070f, 0.00612620f, 0.02299579f, 0.01507832f, -0.02902404f, 0.02781606f, 0.03541864f, 
    0.01909944f, -0.02370941f, 0.02992677f, -0.00635851f, -0.04195742f, 0.02848011f, 0.01736453f, 0.02881644f, 
    0.02509311f, 0.01333016f, 0.03229983f, -0.03084500f, -0.01805105f, -0.03756586f, -0.00651807f, 0.00766573f, 
    -0.03515647f, 0.00504291f, -0.02738855f, -0.03992062f, -0.00638775f, 0.03205564f, 0.00472801f, -0.02111126f, 
    -0.00619097f, 0.02691033f, -0.01450291f, -0.02339909f, 0.01522007f, 0.00725697f, 0.02419432f, 0.01720244f, 
    0.02639027f, -0.02966124f, -0.04283790f, -0.00669656f, -0.02405312f, -0.00997614f, -0.01252789f, 0.00850377f, 
    -0.02804456f, -0.02567728f, -0.01851800f, 0.00643348f, 0.02414428f, -0.02891898f, -0.03313986f, 0.01497274f, 
    -0.03277066f, 0.01581778f, 0.03004198f, 0.02155976f, -0.02515755f, -0.02579947f, -0.00333616f, -0.02341711f, 
    -0.00463308f, 0.00681936f, -0.03188651f, -0.00186256f, 0.00614507f, -0.03076045f, -0.04638764f, 0.03701218f, 
    0.00175890f, -0.00144743f, 0.01530620f, 0.00831136f, -0.02538175f, -0.02957191f, 0.02236294f, 0.03615500f, 
    -0.01249166f, -0.00217935f, -0.03135161f, 0.02651358f, -0.01417108f, -0.01356468f, 0.00381522f, -0.00960257f, 
    0.02633351f, 0.01691922f, -0.00214455f, 0.02758702f, -0.02176665f, 0.00937458f, 0.01454960f, -0.03998866f, 
    -0.02976919f, -0.03065791f, -0.00313875f, 0.01056049f, 0.00838205f, 0.02876432f, 0.00688553f, -0.01297588f, 
    0.01830683f, -0.03566518f, 0.00877384f, 0.01235680f, 0.00703967f, -0.00027216f, 0.00099078f, -0.01830942f, 
    0.01746931f, -0.03256171f, -0.01641032f, 0.01195960f, -0.02921103f, -0.00325059f, -0.02846396f, 0.01217953f, 
    -0.01571033f, 0.02060545f, -0.03218509f, 0.01592398f, 0.02260862f, 0.02581942f, 0.00272007f, 0.00222962f, 
    -0.01549982f, -0.02770183f, 0.00846603f, -0.01741134f, 0.02241585f, -0.01696816f, -0.03150344f, 0.00436749f, 
    0.01873553f, -0.00069207f, 0.03038806f, -0.00930009f, -0.00941629f, 0.00540828f, 0.00838209f, -0.04177859f, 
    0.01699055f, 0.02498836f, 0.00041828f, 0.01748292f, -0.02988921f, -0.01338827f, -0.01049835f, -0.01178657f, 
    0.00207823f, -0.01656420f, -0.03703419f, 0.00159337f, -0.03252389f, 0.03185638f, -0.04042096f, 0.00000645f, 
    -0.00352007f, 0.01674372f, 0.01904020f, -0.03477586f, -0.02507471f, 0.02194836f, -0.03616733f, -0.01591481f, 
    0.01631097f, 0.02895215f, -0.02994802f, -0.02171393f, -0.01042982f, -0.02369327f, -0.00465189f, 0.02349314f, 
    -0.01919037f, 0.02204838f, 0.02707081f, -0.03415869f, 0.02649604f, 0.02710846f, -0.00533174f, -0.02609915f, 
    0.01121020f, -0.02462872f, 0.02759116f, -0.03563092f, -0.02304363f, 0.00275390f, -0.01940200f, -0.01150023f, 
    0.01944453f, 0.00443029f, -0.02639478f, -0.03733107f, 0.01649964f, -0.02902951f, 0.01628717f, -0.00201450f, 
    -0.00255858f, 0.00521256f, -0.01723759f, 0.01620729f, 0.03011142f, -0.02631694f, -0.03472559f, -0.00652363f, 
    0.02890155f, 0.02820765f, -0.02580362f, 0.00798546f, 0.00420387f, -0.02215219f, 0.02525163f, -0.01147131f, 
    0.01671859f, 0.01851187f, -0.01301236f, -0.00928462f, -0.00549290f, 0.02844924f, 0.01038724f, 0.01614606f, 
    -0.01277656f, -0.00769047f, 0.02140370f, -0.00063081f, -0.02639067f, -0.03350182f, 0.01800194f, -0.01572226f, 
    -0.02324927f, 0.04033019f, 0.02297715f, -0.01506789f, -0.00254639f, -0.00634235f, -0.02719975f, -0.01137620f, 
    0.02138182f, -0.00459528f, -0.01645030f, -0.02028928f, -0.03234532f, -0.00511623f, 0.01278264f, -0.03738367f, 
    -0.00694830f, -0.02217212f, 0.00265271f, -0.03721571f, 0.01082276f, -0.02999429f, -0.00176283f, 0.01938849f, 
    0.01235493f, -0.01322435f, -0.01059063f, -0.00163643f, -0.00700797f, 0.02878786f, -0.02829953f, 0.02927196f, 
    0.01661719f, 0.01913481f, -0.01926748f, -0.01143292f, -0.00052188f, 0.00424431f, -0.03035359f, 0.00276045f, 
    0.00494824f, -0.00848968f, -0.02442187f, 0.02890077f, -0.02698595f, 0.02497930f, -0.00632973f, 0.01173420f, 
    -0.02256903f, -0.00382471f, 0.00572278f, 0.01740951f, 0.00736012f, 0.01576470f, 0.01248036f, 0.02414583f, 
    0.01910534f, 0.02044988f, -0.00358002f, -0.03093072f, -0.02097804f, -0.01365231f, 0.01523492f, -0.03030203f, 
    0.02881233f, -0.02978106f, -0.03181221f, -0.03040641f, 0.00966071f, 0.01031033f, -0.02494350f, -0.02048622f, 
    0.01073911f, -0.01637358f, -0.01258082f, 0.02438677f, -0.00077840f, 0.00854845f, 0.01899951f, 0.01170107f, 
    0.02346570f, -0.00450807f, 0.03001991f, 0.01462037f, 0.01724057f, 0.01666634f, 0.02935017f, 0.00499488f, 
    0.01008552f, -0.00273796f, -0.02810692f, -0.02953350f, -0.03657535f, -0.02209917f, 0.00225117f, -0.04262521f, 
    0.00140049f, -0.02485371f, 0.00595111f, -0.00392768f, -0.01679996f, -0.01321523f, -0.03537774f, 0.02511411f, 
    -0.01383526f, 0.02716117f, -0.00640237f, -0.01568779f, -0.02929904f, 0.01554854f, -0.02021212f, 0.02379286f, 
    0.00685567f, 0.01592833f, 0.02481357f, 0.02005707f, 0.01937453f, -0.01351965f, -0.01368385f, -0.01441694f, 
    0.00614555f, -0.02192548f, -0.02386446f, 0.01179965f, -0.02824407f, 0.00256242f, -0.01689046f, -0.00538346f, 
    -0.02121110f, 0.00632560f, 0.02991467f, -0.03403862f, -0.03365726f, 0.02227748f, 0.02546393f, 0.00991245f, 
    -0.03390695f, -0.03798928f, -0.03321080f, 0.00535431f, -0.03335930f, -0.02682176f, -0.01723009f, 0.02246699f, 
    0.03070381f, 0.02251534f, -0.00837168f, 0.03233742f, -0.03307473f, 0.02278007f, 0.02064344f, 0.02916713f, 
    -0.01465551f, -0.01920956f, 0.02836443f, 0.02426647f, -0.01367174f, -0.03191582f, 0.00074505f, -0.03135176f, 
    0.02613311f, 0.00077211f, 0.02779327f, 0.03322458f, 0.02005790f, 0.02806414f, 0.00439109f, 0.01977149f, 
    0.00163143f, -0.01248366f, -0.00555244f, 0.01216528f, 0.00040102f, 0.02785222f, -0.02287391f, 0.00898066f, 
    0.02778824f, -0.03944173f, -0.00114795f, 0.02073541f, -0.00305679f, 0.01809047f, -0.03345903f, -0.03190922f, 
    -0.02204688f, -0.01810463f, -0.04166131f, -0.00513833f, 0.02437038f, 0.02879504f, -0.00550658f, -0.01113355f, 
    0.02212539f, 0.01249760f, -0.01996467f, 0.02486154f, -0.01033106f, -0.03255982f, -0.01176811f, -0.02402872f, 
    0.00325411f, 0.00603951f, 0.02577284f, -0.03676566f, 0.02891442f, -0.03040264f, 0.02976895f, -0.03118715f, 
    -0.02672756f, 0.02411450f, -0.03211617f, 0.00046268f, 0.02018898f, 0.02861233f, 0.00190503f, -0.03285508f, 
    -0.01935035f, -0.00028665f, 0.01117716f, 0.02646564f, -0.03150897f, -0.01259548f, -0.01955867f, 0.00638677f, 
    -0.04062294f, -0.02876969f, -0.01554431f, -0.01457134f, 0.02844403f, 0.03067529f, 0.02892320f, 0.01287134f, 
    -0.03217237f, 0.01395591f, 0.01978438f, -0.00079151f, 0.02905426f, -0.00042136f, 0.02653474f, -0.03047375f, 
    -0.03259937f, -0.00165312f, -0.03030489f, 0.01859991f, -0.02668320f, 0.03080441f, -0.00968791f, -0.03140559f, 
    -0.03725661f, 0.01616642f, 0.01477425f, 0.00871967f, -0.02760544f, 0.02002678f, 0.01502962f, 0.02576350f, 
    0.02367244f, -0.01251068f, -0.02088660f, 0.01250060f, 0.02785309f, -0.01903955f, -0.02348117f, -0.00473362f, 
    -0.01200118f, 0.02448242f, -0.03301037f, -0.00872273f, -0.03958923f, -0.02928342f, -0.03058837f, 0.00212484f, 
    -0.00609528f, -0.02804028f, 0.02464910f, -0.00866827f, -0.01446419f, 0.01065950f, -0.03412724f, -0.00417477f, 
    -0.02515479f, -0.01789474f, -0.04175146f, -0.01742199f, -0.03174003f, -0.00297472f, 0.00474175f, -0.00847418f, 
    0.02076680f, -0.01579685f, 0.01435580f, -0.00566381f, -0.00532566f, -0.02680629f, -0.03017596f, 0.00476006f, 
    -0.01711581f, 0.00070705f, -0.02467832f, 0.01600804f, -0.01647389f, -0.00718890f, -0.01221307f, -0.03159580f, 
    -0.01856907f, 0.00816310f, 0.02509913f, -0.01526974f, -0.01395150f, -0.03516793f, -0.01263318f, 0.00019935f, 
    0.02481870f, -0.00401234f, -0.00815554f, -0.01975746f, -0.02458568f, -0.01504028f, -0.00934486f, -0.02273257f, 
    0.01198315f, 0.00612980f, -0.00377520f, -0.03664363f, -0.00952849f, -0.02938101f, -0.01424125f, -0.01802948f, 
    -0.03861339f, 0.00534041f, -0.03197034f, 0.02989821f, -0.02698214f, 0.02757277f, 0.01477680f, -0.03240278f, 
    -0.02747882f, -0.02123153f, -0.02006610f, 0.02092225f, -0.00305350f, -0.00472414f, 0.02853005f, 0.00012657f, 
    0.02665864f, -0.00640261f, 0.02139373f, 0.02378435f, -0.02147876f, 0.00336720f, -0.02380630f, -0.04116448f, 
    0.00371804f, 0.03696838f, -0.00019907f, 0.02417070f, -0.00154172f, -0.03208428f, -0.00730049f, 0.02078543f, 
    0.01375172f, 0.03032353f, -0.02798733f, 0.00090436f, -0.00080768f, -0.00992867f, 0.01813432f, 0.00107385f, 
    -0.00327290f, -0.00437382f, 0.01242360f, 0.01004859f, -0.02834877f, -0.01454899f, 0.00158562f, -0.02535943f, 
    -0.02952864f, 0.00325371f, -0.02974169f, -0.02715782f, 0.01040288f, -0.01027550f, 0.03146973f, 0.01116861f, 
    -0.02202069f, 0.02440636f, -0.04176144f, -0.00453455f, 0.03271073f, 0.02614820f, -0.02509068f, -0.00946128f, 
    -0.00043280f, 0.00282542f, -0.02416106f, -0.03624752f, 0.02036945f, -0.01891875f, 0.01412175f, -0.00375709f, 
    -0.02263362f, -0.02221946f, 0.01225825f, 0.01789058f, -0.01184619f, 0.00627619f, -0.00225704f, 0.01272485f, 
    -0.02486200f, 0.01497759f, -0.01321715f, 0.02917305f, 0.03114406f, 0.02783165f, -0.02712412f, 0.00334658f, 
    0.00975832f, -0.01563278f, 0.02141941f, 0.02535079f, -0.03741623f, 0.01035028f, -0.02684781f, 0.00914268f, 
    -0.00517964f, -0.00339511f, -0.01033023f, -0.01324495f, 0.00191867f, -0.01505125f, -0.00634330f, -0.01409279f, 
    -0.01831155f, -0.01756484f, -0.03559733f, -0.02176785f, 0.00233293f, -0.02895339f, 0.02777671f, -0.01138845f, 
    -0.01458671f, -0.02510457f, -0.02374345f, 0.02265012f, -0.03857567f, -0.02215132f, -0.00014864f, -0.01113028f, 
    0.03318173f, 0.00216242f, -0.01533785f, -0.00140392f, 0.00936236f, 0.02557166f, 0.00374496f, -0.03107874f, 
    -0.01236893f, -0.01686601f, 0.01899662f, -0.01975725f, 0.02528224f, -0.02905693f, -0.02791028f, -0.04003431f, 
    0.00671229f, -0.02241935f, 0.02779393f, -0.01128677f, -0.01649466f, -0.03447605f, 0.01562890f, 0.01930933f, 
    0.02080203f, -0.02749752f, -0.02883411f, -0.01731616f, -0.01270669f, -0.01394765f, 0.02418661f, 0.02575365f, 
    -0.01011307f, -0.02501669f, -0.02157264f, 0.01956491f, -0.02892241f, -0.03189054f, 0.00752475f, -0.00845367f, 
    -0.01550702f, -0.02407346f, -0.03229351f, 0.00424703f, 0.01991614f, 0.01500598f, 0.00371588f, -0.01067538f, 
    0.00198997f, -0.00766213f, -0.03983788f, -0.04430952f, 0.01993797f, 0.02485240f, 0.00527183f, -0.02388546f, 
    -0.02314246f, -0.03361547f, -0.00347627f, -0.01347723f, -0.00680011f, 0.01770516f, 0.00128483f, -0.02966812f, 
    0.00704667f, -0.03880007f, -0.00929618f, 0.00621316f, 0.02748002f, 0.02373186f, -0.03498976f, -0.03905445f, 
    0.02050588f, -0.02738136f, 0.01277052f, -0.03600711f, 0.02901444f, -0.03160689f, -0.00093242f, 0.00311121f, 
    0.02212012f, -0.00807647f, -0.02898895f, 0.01272519f, -0.00160000f, 0.02695910f, -0.00782348f, -0.02750519f, 
    -0.01684989f, 0.02645387f, -0.01950123f, 0.01543282f, 0.00016452f, -0.01453688f, -0.01119602f, 0.01514006f, 
    -0.02773373f, 0.00946725f, 0.01019202f, -0.01402862f, 0.00281721f, -0.02088290f, -0.01059059f, -0.03228706f, 
    -0.00071323f, -0.02994481f, -0.02597443f, -0.02389785f, -0.03908117f, 0.02655341f, 0.02482454f, -0.00005600f, 
    -0.03323453f, 0.01535510f, 0.01842588f, 0.01122592f, -0.02420049f, -0.03437603f, 0.00735316f, -0.00091897f, 
    -0.02812864f, -0.01887167f, 0.00033574f, 0.02158748f, -0.04288895f, 0.00126629f, -0.01301501f, -0.01019230f, 
    -0.04071658f, -0.02188496f, 0.02004200f, -0.02316459f, 0.02489313f, -0.01627085f, 0.00233585f, -0.02543321f, 
    -0.01726744f, -0.03672381f, 0.00418212f, -0.00940703f, -0.02569849f, 0.02407588f, -0.00292446f, 0.01312688f, 
    0.01354285f, -0.03362834f, -0.04353176f, -0.01710379f, 0.02096548f, -0.01484185f, -0.02800908f, -0.01410750f, 
    -0.04295227f, -0.02470061f, -0.02040500f, 0.00758689f, 0.01574532f, 0.01665432f, -0.02740829f, -0.00236862f, 
    0.00923443f, -0.01160432f, -0.01872913f, -0.01587776f, -0.04186247f, 0.01419147f, -0.01109263f, 0.02855997f, 
    0.02697619f, -0.03631230f, 0.00191258f, -0.01086473f, -0.01552936f, -0.04126291f, 0.01802250f, 0.00074146f, 
    -0.00862208f, -0.00881649f, 0.00098051f, -0.00028099f, 0.00889385f, 0.00038559f, 0.01153064f, -0.01554601f, 
    -0.00123124f, 0.01247596f, -0.01619573f, 0.02661811f, 0.00125390f, 0.00795900f, -0.00684212f, -0.02783379f, 
    0.01496999f, -0.02497884f, -0.02955846f, -0.00676648f, -0.01184116f, -0.02500886f, 0.02786520f, 0.00371107f, 
    -0.04309946f, -0.01109386f, -0.02397982f, -0.04071345f, -0.01771614f, 0.00706155f, -0.03172229f, -0.01008982f, 
    -0.00407090f, -0.00463303f, -0.03732654f, -0.00950267f, -0.00117439f, -0.04031840f, -0.03987220f, -0.01642165f, 
    0.02563663f, 0.01204400f, -0.00940048f, -0.00242480f, -0.03173822f, -0.01346974f, -0.04020257f, -0.01544601f, 
    -0.03130741f, 0.00934845f, -0.01057273f, -0.03079299f, -0.01279961f, -0.02483910f, 0.02096291f, 0.00845393f, 
    0.02448514f, 0.02685337f, -0.02231054f, 0.00880712f, -0.04111689f, -0.04224052f, -0.00984738f, 0.00124096f, 
    -0.01243614f, 0.02440606f, 0.02255665f, -0.00206099f, 0.00346266f, -0.02862215f, 0.00590851f, 0.01792671f, 
    -0.01978292f, -0.01560869f, -0.03841499f, -0.00005143f, -0.02888422f, -0.03403914f, -0.00767258f, -0.00517849f, 
    -0.01271186f, 0.00557395f, -0.02302774f, 0.01810267f, 0.01563828f, -0.04144853f, 0.00764582f, -0.00539812f, 
    0.01748040f, 0.01531692f, -0.01383714f, -0.01453299f, -0.00430780f, 0.01955235f, 0.02438351f, -0.04165849f, 
    0.02586085f, -0.03529436f, -0.03706427f, 0.01012149f, -0.02243146f, -0.00651373f, -0.01575300f, -0.02267911f, 
    -0.03038349f, 0.00940572f, 0.01835464f, 0.01889211f, -0.00574337f, 0.02059757f, 0.01136020f, 0.01754909f, 
    0.00687114f, 0.01156292f, -0.01310856f, 0.02398651f, -0.01981624f, -0.01836331f, -0.01426532f, -0.00207473f, 
    0.00601652f, -0.03144731f, 0.02303565f, -0.02860202f, -0.01623607f, -0.03317419f, -0.02590311f, -0.01779491f, 
    -0.02971826f, 0.00186135f, -0.01849530f, -0.02094388f, -0.00438338f, -0.00822022f, 0.00630211f, -0.01034999f, 
    0.00809992f, 0.00885699f, -0.01702333f, 0.00950753f, -0.00545082f, 0.00719850f, 0.00156199f, -0.02916340f, 
    -0.03811648f, 0.02188337f, 0.01714576f, -0.01585699f, -0.02298257f, -0.01784311f, -0.01246577f, 0.00450329f, 
    0.01326671f, -0.02359004f, 0.00140172f, -0.01284045f, 0.01349628f, 0.02237094f, -0.00402650f, -0.04009485f, 
    -0.03384196f, -0.01550085f, 0.02083139f, 0.00096330f, -0.03361177f, 0.00967449f, -0.02319949f, 0.02644530f, 
    0.00354794f, -0.02608552f, -0.00202704f, 0.00133093f, -0.01273460f, 0.02155470f, 0.01699281f, -0.00601159f, 
    -0.04385560f, 0.02485080f, -0.00453365f, 0.00268060f, -0.03691802f, 0.00025928f, -0.00586053f, -0.01641848f, 
    -0.02681256f, -0.01878095f, 0.00065549f, -0.01106397f, -0.03092474f, -0.03596610f, -0.02430649f, -0.04006075f, 
    -0.04067920f, -0.02842431f, -0.03934024f, 0.00006336f, 0.00513456f, 0.00021169f, -0.01900106f, 0.00247656f, 
    -0.00225643f, 0.02024621f, -0.00644139f, -0.03958743f, 0.01310443f, 0.01613538f, 0.02633549f, 0.02763602f, 
    0.00782150f, 0.02482597f, 0.00262107f, -0.03306560f, -0.01070268f, -0.01507068f, 0.02006080f, -0.01945436f, 
    0.00281354f, -0.00902436f, -0.04171054f, -0.03930643f, -0.02227702f, -0.00463385f, 0.01535060f, 0.02670810f, 
    -0.00445598f, -0.01714569f, -0.00496846f, -0.01311166f, -0.02246230f, 0.00707884f, -0.03957667f, 0.00694459f, 
    -0.01730486f, 0.01140299f, 0.01684329f, -0.03754707f, -0.01222883f, -0.03628936f, -0.03444912f, 0.01420509f, 
    -0.04033870f, -0.03722716f, 0.02699131f, -0.04178327f, -0.03569507f, -0.03990003f, -0.01363786f, 0.00214190f, 
    -0.03125477f, 0.01344453f, 0.00555233f, -0.02924336f, 0.02060337f, -0.03371959f, 0.02752215f, -0.00629065f, 
    0.02409869f, 0.01853924f, -0.02068924f, -0.01559540f, -0.04328524f, -0.00274348f, 0.02167918f, -0.03221503f, 
    -0.01683258f, -0.01501293f, 0.01271321f, 0.00846676f, -0.00253503f, 0.02656386f, 0.00384029f, -0.02398067f, 
    0.01867675f, -0.02658377f, 0.01479379f, -0.00086748f, -0.03193719f, 0.01862604f, -0.03369176f, -0.01142619f, 
    0.02550580f, -0.02366171f, -0.04058777f, 0.02327086f, 0.00631212f, -0.02200705f, 0.00714248f, 0.00108393f, 
    0.02060411f, -0.02751241f, -0.01493199f, -0.01842811f, -0.02508879f, 0.02490315f, 0.01852337f, -0.00464945f, 
    -0.04167566f, 0.00588422f, -0.00013035f, -0.00528080f, -0.02999543f, -0.00191342f, 0.00890659f, -0.01486853f, 
    -0.01509326f, -0.01121111f, -0.01447828f, -0.02201966f, -0.03290156f, -0.04393014f, -0.02566596f, -0.01518197f, 
    -0.01967977f, 0.00193795f, 0.02479208f, -0.00921736f, 0.00455559f, -0.00108914f, -0.01327103f, 0.00399417f, 
    -0.04172228f, -0.03724265f, 0.00512072f, -0.01306660f, 0.00496682f, -0.04217206f, -0.02407649f, -0.02184149f, 
    0.00795599f, -0.01508428f, 0.01202731f, 0.00401629f, 0.02645643f, -0.02729021f, -0.00188751f, 0.01865929f, 
    -0.03872341f, 0.01934543f, -0.01336774f, -0.02686910f, 0.00203369f, -0.01328217f, 0.01941094f, -0.03546531f, 
    0.01360460f, 0.02506388f, -0.00656922f, -0.00962097f, -0.01787786f, 0.00121142f, 0.00515025f, 0.02028157f, 
    -0.02405792f, 0.02657313f, -0.02757063f, -0.03206396f, 0.01998501f, -0.01277697f, -0.00079959f, -0.03026331f, 
    -0.02663736f, 0.01520082f, -0.01266350f, 0.01977902f, 0.00084995f, -0.03222629f, -0.01747185f, -0.01451320f, 
    -0.01620929f, -0.04239696f, 0.02346050f, -0.00591077f, 0.00622010f, -0.03413444f, -0.03788671f, -0.03846597f, 
    0.01052955f, -0.03227013f, -0.01286825f, 0.02469872f, -0.00990095f, -0.03321872f, 0.01673588f, 0.00410666f, 
    0.00534415f, 0.02170885f, 0.02764991f, 0.01156669f, -0.02455043f, -0.01008620f, -0.01020388f, -0.00067148f, 
    -0.00228149f, -0.02780799f, 0.01829077f, 0.02213483f, -0.01246660f, -0.01743911f, -0.01433923f, 0.00356156f, 
    0.00702491f, -0.01044241f, -0.03569538f, 0.02564698f, 0.00453990f, -0.00928604f, -0.03208161f, -0.04151932f, 
    -0.03531127f, 0.02815818f, 0.01258431f, -0.01467396f, -0.03805368f, -0.01788145f, 0.00264012f, -0.02418594f, 
    -0.02774681f, -0.04158785f, 0.01086495f, -0.01814090f, -0.04156975f, -0.02623690f, -0.04076155f, -0.02438887f, 
    -0.01867374f, -0.00821397f, -0.01747278f, -0.03066013f, -0.04040108f, -0.04202842f, -0.00428612f, -0.03762497f, 
    -0.01765867f, -0.01488272f, -0.00686662f, -0.01380386f, -0.02641831f, 0.01712622f, -0.01139618f, -0.01622980f, 
    -0.01815762f, -0.02652135f, -0.01735663f, -0.01882403f, -0.00600847f, -0.01269754f, -0.03363273f, -0.00271038f, 
    0.02757704f, 0.02457400f, -0.00589853f, -0.02415534f, 0.00740957f, -0.03728300f, -0.03563509f, -0.02785531f, 
    0.01111245f, -0.03671946f, -0.02188980f, -0.02830027f, 0.01136226f, -0.03943435f, -0.02671360f, 0.00888520f, 
    0.00549424f, 0.01970797f, -0.02433657f, -0.01710639f, 0.02205019f, 0.00348777f, 0.00385477f, -0.00389320f, 
    -0.00494461f, -0.03607331f, 0.01425943f, 0.01094077f, 0.00534364f, -0.00308616f, -0.00983507f, 0.01512135f, 
    -0.02847272f, -0.02382912f, -0.02301418f, 0.00718207f, 0.01718400f, -0.03029730f, -0.02807062f, -0.02374325f, 
    -0.03520631f, -0.00168603f, 0.01736286f, 0.01411576f, -0.00690284f, 0.02455122f, 0.01388033f, 0.01108693f, 
    -0.02069875f, -0.01105725f, 0.01264148f, -0.00313296f, 0.00096166f, 0.00563993f, 0.02057597f, 0.00691396f, 
    0.01065883f, -0.00807000f, -0.00574328f, 0.00798382f, -0.01627743f, -0.03832373f, 0.02449788f, -0.01824113f, 
    -0.03704514f, 0.00147209f, -0.01559770f, -0.01920437f, -0.00518568f, 0.02341842f, -0.02680721f, -0.01726811f, 
    -0.02109080f, -0.02830597f, -0.00125446f, -0.01446719f, 0.02456611f, -0.01176134f, -0.03466693f, 0.00295631f, 
    0.01715864f, -0.02583956f, 0.00611692f, -0.02285328f, -0.00319756f, 0.01914191f, 0.00471364f, -0.03013270f, 
    0.00552108f, -0.02773525f, -0.01618946f, -0.02297977f, 0.02304479f, 0.02553686f, 0.01042525f, -0.00170873f, 
    0.00701917f, -0.00792090f, -0.02496694f, 0.02777175f, -0.02071069f, -0.03528617f, -0.00956759f, -0.02114202f, 
    -0.01307477f, -0.02934137f, -0.00042938f, 0.00637438f, -0.01083217f, -0.03155091f, -0.02869470f, -0.03013072f, 
    0.02178593f, -0.01574198f, 0.01726977f, -0.03787231f, -0.04028371f, -0.02322331f, -0.03880650f, -0.02177953f, 
    -0.01142023f, -0.00029039f, 0.00908571f, -0.00490607f, -0.00297594f, -0.02774471f, 0.01091206f, -0.03352515f, 
    -0.01989740f, -0.02762389f, -0.02957668f, 0.02013538f, -0.01096147f, -0.02169306f, -0.00712084f, 0.00966016f, 
    -0.01907083f, -0.03075777f, -0.01819033f, -0.00343582f, 0.02585553f, -0.00450150f, -0.02722141f, -0.00299100f, 
    -0.00408677f, -0.00014763f, -0.03331468f, -0.00646029f, 0.01025860f, -0.00184697f, -0.03211414f, 0.01692490f, 
    -0.03822895f, -0.02994479f, 0.00288706f, -0.02231541f, -0.03044379f, 0.01123800f, -0.00189933f, -0.01890681f, 
    0.00015550f, -0.02846336f, -0.01584475f, -0.03635630f, 0.02112434f, -0.02798734f, 0.02664545f, -0.03551924f, 
    -0.02167393f, 0.01884283f, 0.01897769f, -0.04144813f, -0.01146325f, -0.03888785f, -0.02240431f, -0.01669338f, 
    -0.00815057f, 0.00103374f, 0.01838191f, -0.00280303f, 0.01222998f, -0.01941929f, -0.01207193f, 0.03286039f, 
    -0.01640968f, 0.02837447f, 0.02524774f, 0.01395238f, -0.00756746f, -0.03601554f, 0.01817024f, 0.00617688f, 
    -0.01848096f, -0.02438596f, -0.03090475f, 0.02133588f, -0.02625409f, -0.01703074f, 0.00120553f, -0.00996100f, 
    0.02368199f, -0.02113593f, 0.03303245f, -0.00955090f, 0.01675124f, 0.01549152f, 0.01671778f, -0.02648531f, 
    -0.03557160f, 0.02644243f, 0.02818765f, -0.00776149f, -0.04107804f, -0.02982374f, -0.01699794f, -0.00786805f, 
    0.03202792f, 0.02934804f, -0.03137961f, -0.02780691f, 0.01257262f, 0.00266687f, -0.03969407f, 0.00417111f, 
    -0.02100233f, 0.01368387f, -0.01406917f, 0.01606803f, -0.02750033f, 0.00352012f, 0.01530595f, -0.00188976f, 
    -0.01120813f, -0.01515349f, -0.00736101f, -0.01416440f, -0.02982970f, 0.02764444f, 0.00033734f, -0.01819324f, 
    -0.00983857f, 0.00750693f, -0.01807800f, 0.02990655f, -0.03342159f, 0.00722564f, -0.03892696f, 0.01331518f, 
    0.00635610f, 0.02842624f, -0.01955250f, -0.02952978f, 0.02808284f, 0.01814383f, -0.03531103f, 0.02445471f, 
    0.02798444f, 0.01513624f, 0.02650472f, -0.00624787f, -0.04689023f, 0.00652899f, 0.00089298f, 0.00819904f, 
    0.01848922f, 0.02798523f, 0.01889981f, 0.02332667f, -0.02421113f, 0.02713914f, 0.03387251f, 0.03427051f, 
    -0.01211414f, 0.00007633f, -0.03945315f, 0.02507354f, 0.02622786f, -0.02208102f, -0.02405759f, 0.01712000f, 
    -0.02088575f, 0.00560970f, -0.01306906f, -0.02393747f, -0.02807855f, 0.02889248f, -0.03809046f, -0.00602668f, 
    -0.04755566f, 0.00725431f, 0.00051751f, -0.02772425f, 0.00631740f, 0.00091242f, 0.01614499f, 0.02236707f, 
    0.02601800f, 0.02988072f, -0.02967720f, 0.02121270f, -0.03622823f, 0.02043957f, 0.00000367f, -0.04394680f, 
    -0.01773087f, -0.02999748f, -0.02252995f, 0.02732118f, -0.00797107f, -0.00554986f, -0.02208961f, 0.02549270f, 
    -0.04234320f, -0.03812334f, -0.03912951f, -0.00925570f, 0.02453511f, -0.03162500f, -0.00886345f, 0.01472839f, 
    -0.00661321f, -0.01976437f, 0.02376127f, 0.02912047f, -0.03747628f, -0.03853722f, -0.02207634f, -0.02527223f, 
    -0.00952089f, 0.01438665f, -0.01362368f, 0.00265157f, -0.01160105f, -0.00694962f, -0.01297670f, 0.02039959f, 
    0.02365415f, 0.01600240f, -0.03608097f, -0.03561224f, -0.04058240f, -0.03886677f, -0.02578268f, -0.03185739f, 
    -0.02463527f, -0.02067913f, 0.00775041f, 0.00388526f, 0.00000228f, 0.00656818f, -0.02480907f, 0.00874735f, 
    -0.02849064f, -0.00378954f, -0.03915099f, 0.01835081f, 0.00899522f, -0.00324195f, -0.01274604f, -0.03420682f, 
    -0.01842478f, 0.00840566f, -0.00013327f, 0.01533477f, -0.03606872f, -0.03751010f, 0.01820303f, 0.02547647f, 
    0.00738888f, -0.01653339f, 0.02235348f, -0.03136278f, -0.01956616f, -0.03299685f, 0.03416171f, 0.03743650f, 
    -0.01058640f, 0.01884676f, -0.01344865f, -0.00529455f, 0.01931287f, 0.02248262f, -0.00364219f, -0.02111910f, 
    0.00599442f, 0.02091531f, -0.00535094f, -0.01008910f, -0.03206383f, 0.00097127f, 0.00236607f, 0.00949483f, 
    -0.01463532f, -0.02767332f, -0.00816755f, 0.02984863f, -0.00828206f, 0.01051328f, 0.01865671f, 0.00364990f, 
    0.00030034f, -0.02934845f, 0.01831746f, -0.01788770f, 0.00502496f, 0.00828352f, -0.02328209f, 0.02382670f, 
    -0.01489925f, -0.01391732f, -0.03632372f, -0.00602573f, 0.01005587f, -0.04149738f, 0.03711354f, 0.02592903f, 
    0.02840157f, -0.01382890f, -0.02406365f, -0.01629720f, 0.01338872f, -0.00870344f, 0.00909975f, -0.03219868f, 
    0.03352737f, 0.02090363f, -0.01766161f, 0.01250964f, -0.00812070f, -0.01984413f, -0.01862065f, 0.00419611f, 
    -0.00152362f, -0.01296768f, 0.02632692f, -0.00408577f, -0.02891618f, -0.00510480f, -0.00260960f, -0.04006016f, 
    0.01493810f, 0.01411340f, 0.00753308f, 0.00217669f, -0.01121370f, 0.00469602f, -0.03555010f, -0.03244001f, 
    -0.01835797f, -0.02217393f, 0.03354229f, -0.01061139f, -0.00298464f, 0.01713593f, -0.01233973f, 0.02070421f, 
    -0.01096187f, -0.03717389f, 0.01416923f, 0.00634409f, 0.02696859f, -0.01402303f, 0.01627156f, -0.02927200f, 
    0.00556777f, -0.00323968f, -0.00533950f, -0.03555570f, 0.00632580f, -0.03316514f, -0.04089078f, -0.01888724f, 
    -0.02156940f, -0.00994893f, -0.00709570f, -0.02596007f, -0.01793269f, -0.00304267f, 0.00811587f, 0.01682867f, 
    0.00502965f, -0.04274190f, 0.01737068f, 0.00707368f, -0.00041842f, -0.02484056f, -0.00085226f, -0.01016093f, 
    -0.02758216f, -0.03048765f, 0.00775460f, -0.04567207f, -0.01042015f, 0.00904797f, 0.02853556f, -0.04787216f, 
    -0.02032726f, 0.00240275f, 0.01835699f, 0.02890470f, 0.01831464f, -0.00777677f, 0.01308765f, -0.02017793f, 
    0.01965944f, 0.02984981f, -0.00806173f, -0.04383333f, -0.02531359f, 0.01120960f, 0.01302715f, 0.02893458f, 
    0.01139951f, -0.02427770f, -0.00896976f, -0.00690408f, -0.01204054f, -0.02392175f, 0.00587528f, 0.01838607f, 
    -0.01506755f, 0.00275041f, 0.02329337f, -0.01879992f, -0.02597086f, -0.00836152f, -0.02778537f, 0.02582803f, 
    -0.03003833f, 0.02539914f, 0.03420758f, 0.00616222f, -0.00952182f, 0.01470211f, -0.02781871f, 0.02530378f, 
    0.00107576f, 0.03752859f, -0.02911143f, 0.00931395f, -0.01360662f, -0.03096943f, -0.01400773f, -0.00471809f, 
    0.03277889f, 0.00383497f, 0.02381870f, 0.01965206f, -0.01910720f, -0.01604114f, -0.03612478f, 0.00112867f, 
    -0.02257984f, -0.01578182f, 0.02632639f, -0.01561231f, 0.02484571f, 0.03286052f, -0.03083935f, -0.03060905f, 
    -0.01411584f, 0.02110197f, 0.01707018f, 0.01227132f, -0.02395120f, 0.01289173f, -0.03675415f, -0.00385616f, 
    -0.03290699f, -0.01730961f, -0.04422789f, 0.00958399f, -0.01500860f, -0.00086649f, 0.00258508f, 0.01490041f, 
    0.01060665f, 0.03536911f, 0.00096981f, 0.01142218f, -0.01394547f, -0.00678400f, -0.03881078f, 0.01565079f, 
    -0.03791049f, -0.01837304f, -0.00625319f, 0.02178546f, 0.00006413f, -0.00284254f, 0.00892850f, 0.00083778f, 
    0.00589914f, -0.02268222f, -0.02985397f, -0.02605409f, 0.00178682f, -0.00449311f, -0.02877865f, -0.01697174f, 
    -0.00209973f, 0.02441705f, -0.00078770f, 0.02803475f, 0.01546062f, 0.01225546f, 0.00057237f, -0.00487540f, 
    -0.03442606f, 0.02414764f, -0.01407751f, -0.01127619f, -0.04101739f, 0.01734832f, -0.00509570f, -0.00637770f, 
    0.01083000f, -0.01413623f, -0.02164042f, 0.00267384f, 0.00445080f, -0.00727226f, -0.00513835f, -0.03162049f, 
    0.00946139f, -0.01063572f, 0.00360216f, -0.02933334f, 0.00553294f, 0.00129887f, -0.03341358f, -0.00025100f, 
    0.00422300f, -0.00106813f, -0.03859749f, 0.02475806f, 0.02842175f, 0.00094292f, -0.02589047f, -0.03386692f, 
    -0.02997329f, -0.01576152f, -0.03086043f, -0.02693626f, 0.00438092f, 0.01649931f, -0.02457563f, 0.00165826f, 
    0.01845695f, -0.01306212f, 0.00481463f, -0.00795443f, -0.03723836f, 0.01524279f, -0.01487279f, 0.00416991f, 
    0.02779731f, -0.00144018f, 0.03203847f, -0.00709479f, -0.00464411f, 0.01449083f, 0.00846874f, -0.00856703f, 
    -0.00619770f, -0.02605584f, -0.03733939f, -0.03274217f, 0.01561663f, 0.02021982f, -0.03259656f, -0.03438446f, 
    -0.01079331f, -0.02759732f, -0.03407405f, 0.02064064f, -0.00185285f, -0.02541955f, -0.03952932f, -0.00135101f, 
    -0.01139478f, 0.01334432f, 0.01886005f, -0.03644206f, 0.00747724f, 0.01153790f, -0.01023418f, -0.02282625f, 
    -0.01926382f, 0.00610442f, -0.02693160f, -0.02847952f, -0.01702287f, -0.00883923f, 0.00289259f, -0.00152946f, 
    0.01204590f, 0.02201854f, 0.03274418f, -0.01664765f, -0.01617099f, -0.00751944f, 0.02460686f, 0.02221903f, 
    -0.02968940f, -0.01015884f, -0.03655157f, 0.03036728f, -0.03644583f, -0.03017779f, 0.00233996f, 0.01602515f, 
    0.00567792f, 0.00895963f, -0.00121139f, -0.02332588f, -0.01559477f, 0.00925156f, 0.02781150f, -0.01877250f, 
    -0.01627204f, -0.00215360f, 0.01505780f, -0.01580682f, 0.02766542f, -0.02505500f, -0.03098842f, 0.02472582f, 
    -0.00668255f, -0.02947074f, -0.02368438f, -0.03440997f, 0.02447048f, -0.01139512f, 0.01580851f, -0.02648874f, 
    -0.01925204f, 0.02891889f, 0.01983905f, -0.00927853f, -0.00359932f, 0.00046076f, 0.00110803f, 0.00137953f, 
    -0.03403126f, -0.02988788f, -0.02825541f, -0.01110131f, 0.02287204f, -0.00611896f, 0.01306499f, 0.02220576f, 
    0.02461394f, 0.03567381f, 0.01201270f, 0.01316751f, -0.01908466f, -0.01959116f, 0.00152639f, -0.02402924f, 
    -0.01743282f, 0.02324920f, -0.02351507f, -0.01493851f, -0.02598113f, 0.01209863f, 0.01562363f, 0.00128962f, 
    0.01093314f, -0.03185837f, -0.02927715f, -0.02644703f, -0.00990605f, 0.02603600f, -0.01177184f, -0.00585471f, 
    0.03110684f, -0.00221041f, -0.00682572f, 0.02069139f, -0.02743249f, 0.01810014f, -0.03757093f, 0.01433021f, 
    -0.00185503f, 0.02567514f, 0.03697208f, -0.00592535f, 0.00133809f, -0.02575142f, -0.02035251f, 0.01965854f, 
    -0.03615944f, -0.02890432f, -0.00681452f, -0.03283802f, -0.00555634f, 0.01696057f, -0.02076920f, 0.00346824f, 
    -0.00952972f, 0.02096814f, 0.01223932f, 0.01454034f, -0.01477883f, 0.03014797f, 0.03177805f, 0.02440685f, 
    0.02748861f, -0.02569945f, 0.01139945f, 0.02362593f, 0.00839347f, -0.03512602f, 0.02165713f, 0.00717060f, 
    -0.04281585f, -0.03020788f, -0.00576730f, 0.01938242f, 0.02815653f, -0.04273967f, -0.03559667f, 0.00960807f, 
    0.01229945f, -0.03627588f, 0.00079388f, 0.00612496f, 0.01117616f, 0.02207362f, 0.01716541f, 0.02540177f, 
    0.01393527f, -0.03878240f, 0.03094643f, 0.02968765f, 0.01646021f, -0.00926138f, -0.01079384f, -0.01910160f, 
    -0.04719859f, -0.02061145f, -0.02170356f, -0.03939564f, -0.01088548f, 0.00730528f, -0.03084294f, 0.00171588f, 
    0.02524608f, -0.01108612f, -0.03653961f, -0.02301111f, -0.03631732f, -0.01405086f, 0.00967252f, -0.01035769f, 
    -0.03797828f, -0.01438529f, -0.02992505f, 0.00156641f, 0.01967706f, 0.01155646f, 0.02172373f, -0.00877597f, 
    0.02211801f, -0.02972968f, 0.00559385f, 0.00444969f, -0.00006904f, 0.00384247f, 0.01561360f, -0.01954164f, 
    -0.03006380f, 0.02485221f, 0.04023321f, -0.03280453f, -0.02432713f, -0.03795591f, -0.01434849f, -0.00465602f, 
    0.00579712f, -0.02172827f, -0.03274981f, -0.02797570f, 0.00515909f, 0.01035651f, -0.01851423f, -0.02561612f, 
    0.01593683f, 0.02450209f, 0.00030835f, -0.00867957f, -0.02599845f, -0.02196377f, 0.03626714f, -0.02594864f, 
    0.00446503f, -0.00960153f, 0.03209801f, -0.01613504f, -0.01680568f, 0.01427032f, -0.03671807f, -0.02833784f, 
    0.02246189f, -0.01594183f, 0.02151184f, 0.02002241f, -0.03807097f, 0.00944118f, 0.03490102f, -0.00176613f, 
    0.00266965f, 0.01313487f, -0.02274691f, -0.03461869f, 0.03580047f, 0.02757341f, 0.01374304f, -0.01770769f, 
    -0.04060419f, 0.02694755f, -0.00620743f, -0.02349301f, -0.01344892f, -0.03317080f, -0.01866058f, -0.00950824f, 
    0.01828708f, -0.00678397f, 0.02306299f, -0.04573751f, -0.01699281f, -0.02717068f, -0.04647392f, -0.00888261f, 
    -0.09571871f, -0.04522936f, -0.07723782f, -0.19585893f, 0.08073807f, -0.03198111f, 0.02954924f, 0.05817868f, 
    -0.10774880f, -0.03879640f, 0.05109143f, 0.02102894f, 0.13742755f, -0.26739588f, -0.04379862f, 0.45183581f, 
    -0.06455965f, -0.05618796f, -0.00806267f, -0.02907837f, 0.09395096f, -0.03593545f, -0.00606115f, -0.05950147f, 
    0.33433798f, 0.25876790f, -0.05158157f, -0.33913472f, -0.06397745f, -0.00875188f, 0.07759669f, 0.00253577f, 
    0.09481718f, 0.01170416f, -0.04180927f, -0.05917903f, 0.01738230f, 0.06283756f, -0.09465088f, 0.20460629f, 
    0.02909367f, -0.04462094f, -0.07580294f, 0.09261270f, 0.07275238f, 0.07734017f, 0.08042178f, -0.09186519f, 
    -0.11613107f, -0.13032363f, 0.14154421f, -0.06822643f, 0.00263593f, 0.01487815f, 0.10615753f, 0.00730819f, 
    0.01728496f, 0.00531153f, 0.02127900f, 0.10072283f, -0.14878355f, -0.10400775f, 0.06985915f, 0.12051574f, 
    -0.02717669f, -0.08039595f, -0.02397673f, -0.00682928f, 0.01689251f, -0.05067630f, -0.03566571f, 0.01326987f, 
    0.07136358f, -0.02998681f, 0.03872249f, 0.07273366f, 0.02555797f, -0.05791601f, 0.04221388f, 0.11582769f, 
    0.05579888f, 0.01176841f, 0.07373489f, 0.01382909f, 0.29556596f, -0.06675877f, 0.08854769f, 0.21419938f, 
    0.05454624f, -0.09376518f, 0.03500327f, -0.06550721f, 0.03119208f, 0.03283998f, 0.00543655f, 0.10098863f, 
    0.07292407f, 0.11848019f, -0.07591088f, -0.36381486f, 0.04001412f, 0.05763388f, -0.02756100f, -0.08643074f, 
    0.08426563f, -0.14056078f, -0.04637344f, -0.04397669f, 0.01334779f, 0.02088014f, 0.08004452f, -0.02530647f, 
    -0.11973485f, -0.03511079f, -0.08518985f, 0.04706185f, -0.01926720f, -0.04499570f, 0.04680562f, 0.04509342f, 
    0.05101376f, 0.03255009f, -0.07773924f, 0.04841461f, 0.06556202f, 0.03033184f, -0.04559982f, -0.05948682f, 
    -0.02244877f, -0.03636174f, -0.00651028f, 0.05951301f, -0.00608802f, 0.00446277f, 0.07935096f, 0.27585745f, 
    0.00804531f, 0.01983137f, 0.08158643f, 0.02384301f, -0.00567260f, 0.10443930f, -0.00234228f, -0.03267574f, 
    0.19176055f, -0.18448231f, -0.09195858f, 0.19336823f, -0.10605411f, -0.08402482f, 0.06739748f, 0.06217762f, 
    0.02685282f, -0.05194155f, 0.08643389f, -0.02658182f, 0.19157623f, -0.18033227f, 0.01298870f, 0.43112767f, 
    -0.01879716f, -0.02190594f, 0.05119695f, 0.04063565f, 0.01559676f, -0.02572114f, 0.01191184f, 0.00750300f, 
    0.36317629f, -0.24473922f, 0.04015071f, -0.12397435f, -0.01936723f, -0.11206006f, -0.08062723f, 0.00989346f, 
    -0.00587702f, 0.04311619f, 0.03989344f, 0.08292654f, -0.00458977f, 0.00552721f, 0.10542534f, 0.31916597f, 
    0.11670849f, 0.06092998f, 0.05827551f, 0.02753392f, 0.13339679f, -0.01343991f, -0.04144752f, -0.00705590f, 
    -0.24693613f, -0.07487972f, -0.10033727f, 0.09635963f, -0.09959803f, 0.07057080f, 0.04157398f, 0.06062267f, 
    -0.02051340f, -0.05850167f, -0.09292400f, 0.10028630f, -0.19334231f, 0.16541786f, 0.02657838f, -0.17325784f, 
    0.04361017f, -0.01756185f, 0.08927560f, 0.09438766f, 0.05102829f, 0.06724569f, -0.02211792f, 0.05081557f, 
    0.21534988f, 0.14141352f, -0.03307973f, -0.08109609f, -0.08651129f, -0.07870470f, -0.05742307f, 0.04089335f, 
    -0.00272294f, 0.03635069f, 0.04388158f, -0.03786249f, 0.05905532f, 0.04011968f, -0.09772867f, -0.11340822f, 
    -0.00869482f, 0.01602415f, 0.13012642f, 0.03232011f, -0.02340043f, 0.03102258f, 0.02409906f, -0.00731541f, 
    -0.16571376f, -0.10924452f, 0.20148361f, -0.11415680f, 0.04019027f, 0.00846543f, -0.00445536f, -0.02279018f, 
    -0.04369463f, -0.06338369f, -0.01929691f, -0.07154047f, 0.18564332f, 0.06177830f, -0.04806062f, 0.21816242f, 
    -0.08260087f, -0.01337335f, -0.01752717f, 0.08138528f, -0.07573152f, 0.04520788f, 0.04390381f, -0.02366935f, 
    -0.12055507f, 0.19712338f, 0.01071021f, -0.16708966f, -0.04605999f, -0.15147053f, -0.02314256f, 0.14353387f, 
    0.07030509f, -0.07099327f, 0.03353452f, -0.00107929f, 0.01712107f, -0.11701453f, 0.02565243f, -0.03863487f, 
    -0.02479955f, 0.02044220f, -0.01118589f, -0.00507422f, 0.06055446f, 0.02042466f, 0.03791964f, -0.05177279f, 
    0.12566304f, 0.04242721f, 0.08443109f, -0.28163221f, 0.02078973f, -0.05668753f, 0.07005651f, 0.22507745f, 
    0.10302642f, 0.07762203f, -0.01552063f, 0.02161767f, -0.12977037f, 0.13291609f, -0.02260802f, -0.06974325f, 
    -0.15948181f, 0.03708428f, 0.01473302f, 0.02880200f, 0.12073742f, 0.03021620f, 0.04397861f, 0.08267111f, 
    -0.00086844f, 0.05807531f, -0.01928689f, -0.31698602f, 0.00684202f, 0.06496571f, 0.06242285f, 0.05631595f, 
    -0.00061714f, 0.00045827f, -0.01234035f, -0.06215083f, 0.26275912f, -0.21821900f, 0.12080131f, 0.23430267f, 
    -0.00509910f, 0.03264619f, -0.07094707f, 0.00302928f, -0.06946460f, 0.07005600f, -0.01342947f, -0.01651159f, 
    0.30031934f, -0.21097179f, 0.03138367f, 0.35809344f, -0.05884064f, 0.00267657f, -0.02674381f, -0.02144717f, 
    0.09897261f, 0.13779081f, 0.04309658f, -0.08772801f, 0.38184446f, -0.15616606f, -0.14207102f, 0.22071366f, 
    -0.08982200f, -0.13532133f, -0.05709691f, 0.06939456f, 0.04109860f, -0.01837320f, -0.02610044f, -0.01998306f, 
    -0.12397105f, -0.16736346f, -0.09474040f, 0.10426131f, -0.08642743f, -0.05094587f, 0.05397983f, -0.02746556f, 
    -0.06205588f, 0.04168653f, -0.05454999f, -0.11380207f, -0.28046468f, -0.06010872f, 0.06019675f, 0.53180963f, 
    -0.13759845f, 0.01641081f, 0.04575045f, 0.04189145f, 0.07104373f, 0.02497487f, 0.09889766f, -0.02532226f, 
    0.34132302f, -0.13964435f, 0.02482563f, 0.00808668f, -0.01841708f, 0.06599227f, -0.09074449f, -0.02821335f, 
    -0.08550338f, -0.03639485f, 0.03647624f, 0.11635719f, -0.16308773f, -0.00292628f, 0.11018335f, 0.01224284f, 
    0.01198239f, -0.00637738f, 0.01574139f, 0.07250702f, -0.03357831f, 0.03652406f, -0.05226120f, -0.12834194f, 
    0.00468219f, -0.04539895f, 0.10657053f, -0.09328577f, -0.04958113f, -0.01217539f, 0.17040037f, 0.01221501f, 
    -0.04046774f, -0.01102892f, -0.05946824f, -0.01541806f, 0.04795532f, 0.08956560f, 0.07710245f, -0.04589591f, 
    0.04009392f, -0.00414273f, -0.08321918f, 0.01587603f, 0.04462945f, -0.00787515f, -0.00442313f, 0.01721890f, 
    -0.09508283f, 0.11077552f, -0.03315863f, -0.01189661f, -0.00600995f, -0.00348898f, -0.11727329f, 0.00642633f, 
    0.03932737f, 0.05053868f, -0.06773607f, -0.09479509f, 0.06350734f, 0.20874365f, -0.03902407f, -0.16111837f, 
    0.02493806f, 0.05441736f, -0.11320085f, 0.04152590f, 0.06293187f, 0.01679327f, 0.00575885f, -0.12511158f, 
    0.04724574f, 0.04388770f, -0.04371238f, -0.08420150f, -0.02041239f, 0.05856932f, -0.01147673f, 0.02656663f, 
    0.05616883f, 0.12220024f, 0.00247762f, 0.08630873f, -0.11112345f, 0.11597173f, -0.00510362f, -0.06579954f, 
    0.03778248f, -0.04136250f, -0.08099797f, -0.06894181f, -0.09168595f, 0.00007644f, -0.07684475f, 0.01214364f, 
    -0.02208839f, 0.23444502f, 0.02610487f, -0.14953169f, -0.04771455f, -0.06649613f, 0.02906753f, 0.19892310f, 
    0.01603671f, -0.02329980f, 0.03757282f, -0.00219066f, -0.21616974f, 0.06891746f, -0.15502661f, 0.02864061f, 
    -0.02995909f, 0.04121607f, 0.06007077f, 0.01218465f, 0.10800009f, 0.11259659f, 0.07634091f, -0.05293620f, 
    -0.08318675f, 0.12325332f, -0.00428362f, 0.17773373f, 0.14849304f, 0.02231060f, -0.03923186f, -0.05382924f, 
    0.01180992f, -0.07485363f, 0.04505252f, -0.05731646f, 0.03572457f, 0.04078444f, 0.13133526f, -0.17969486f, 
    -0.00111534f, 0.13152093f, 0.02831076f, 0.01029922f, 0.01863050f, -0.00014486f, 0.05793734f, 0.08451564f, 
    -0.22709247f, 0.11001674f, -0.01773869f, 0.09630161f, -0.01584967f, 0.05637158f, -0.12176919f, -0.06123679f, 
    0.03146111f, -0.05114419f, 0.05123596f, 0.03604860f, -0.22933716f, 0.11936817f, -0.06971297f, -0.08115464f, 
    0.01569902f, 0.03665072f, -0.00214856f, -0.01151672f, -0.01318015f, -0.11398371f, -0.06737699f, 0.08137278f, 
    -0.14010990f, -0.06947759f, 0.01937858f, 0.15208267f, 0.03499243f, 0.02330379f, -0.04334595f, 0.04007265f, 
    -0.04982532f, -0.05707515f, 0.07318271f, -0.01728487f, -0.03827835f, -0.16481526f, -0.07719661f, 0.34819072f, 
    -0.13290203f, -0.03732149f, 0.01544485f, -0.00958133f, 0.01674160f, -0.01067176f, -0.07791049f, -0.06611723f, 
    0.23076493f, -0.10128044f, 0.09616341f, 0.18682469f, -0.02172978f, 0.00332687f, -0.05140115f, 0.07657677f, 
    -0.04158647f, -0.08188139f, 0.02509611f, 0.04369046f, 0.16783738f, 0.09320487f, -0.05058732f, -0.19348741f, 
    0.03250836f, -0.05962224f, -0.06274090f, -0.01432583f, -0.02101230f, 0.01026834f, 0.01119462f, -0.06809798f, 
    0.07888292f, 0.04540360f, 0.00980634f, -0.03573091f, 0.01599526f, -0.03583425f, -0.03833080f, 0.05039622f, 
    0.03023219f, -0.00150182f, 0.10328552f, 0.03019233f, 0.16321485f, 0.03325510f, 0.01314190f, -0.16021770f, 
    0.01350816f, -0.05040083f, -0.05692040f, -0.05327002f, -0.05911737f, 0.09276729f, 0.00199551f, 0.07850253f, 
    -0.17093113f, 0.10793285f, -0.00383076f, -0.02489324f, 0.03295128f, 0.01373417f, 0.03627323f, -0.03529976f, 
    -0.01661395f, -0.04854442f, -0.11147691f, 0.02051380f, -0.37233227f, -0.14649399f, 0.02148894f, 0.14404173f, 
    -0.14389001f, -0.06925991f, -0.05050517f, -0.06295721f, -0.07450675f, -0.00256922f, -0.05316662f, 0.04947180f, 
    -0.00120782f, -0.05997134f, 0.04712676f, 0.18490174f, 0.01706007f, 0.04902401f, 0.18905881f, 0.10636223f, 
    0.06424329f, 0.10425701f, 0.09569645f, -0.12818164f, 0.38176247f, -0.09521385f, 0.04218598f, 0.17910558f, 
    -0.06048179f, 0.00975383f, -0.01782628f, -0.01301364f, 0.03799145f, 0.02627639f, 0.01619078f, 0.01037643f, 
    -0.17417580f, 0.11583307f, -0.10426784f, -0.03922052f, 0.00964643f, 0.02788255f, 0.03185371f, 0.04075992f, 
    -0.03382946f, -0.10610811f, -0.00519111f, 0.10031217f, 0.07095522f, 0.14043151f, -0.01866993f, 0.09126651f, 
    0.10062029f, -0.00824584f, -0.08164470f, 0.10383176f, 0.05523041f, 0.02970562f, -0.07914401f, -0.04621867f, 
    0.03487227f, -0.02851869f, -0.07607832f, 0.05335473f, 0.01867852f, 0.04855040f, -0.00658901f, 0.02164491f, 
    -0.20268114f, -0.00308292f, 0.06285348f, 0.03872737f, 0.05368628f, -0.04731272f, -0.10982104f, 0.12291501f, 
    0.13208346f, -0.00860360f, -0.00097622f, 0.05757158f, 0.04007349f, -0.05776275f, -0.02395189f, 0.00682636f, 
    -0.07487120f, -0.02304451f, -0.04071556f, 0.23896991f, 0.04653051f, 0.07062551f, 0.14170724f, 0.01573258f, 
    -0.01556206f, 0.05604959f, 0.06449324f, -0.07993628f, 0.03412209f, 0.08984400f, 0.16801351f, 0.01568838f, 
    -0.06518197f, -0.02993199f, -0.03514847f, 0.00677347f, 0.01594938f, -0.01965193f, 0.04568914f, -0.05036020f, 
    0.06642255f, -0.01640365f, 0.18397214f, -0.06431922f, 0.01165195f, 0.09384678f, -0.03041416f, 0.11020458f, 
    0.02208694f, -0.09942045f, 0.00236834f, 0.12922722f, 0.13310140f, -0.06105202f, 0.03819020f, 0.05333132f, 
    0.01484602f, -0.11089803f, -0.01708844f, 0.07592055f, -0.07247342f, 0.00970657f, -0.02136141f, 0.07330437f, 
    0.02356079f, -0.02296518f, -0.02229390f, -0.02313366f, 0.02553665f, -0.03409360f, -0.00120236f, -0.00200613f, 
    0.00083412f, 0.03014648f, -0.00025248f, -0.02702764f, 0.01005727f, -0.02075752f, -0.03825552f, -0.02171274f, 
    0.01370695f, 0.02316128f, 0.01443380f, -0.00827503f, 0.02420872f, 0.01366795f, -0.00039572f, 0.01192815f, 
    0.02713042f, 0.00083400f, -0.00937003f, -0.01555342f, -0.00966910f, -0.03226823f, 0.01422666f, -0.01425732f, 
    -0.00785449f, -0.03191796f, -0.03701555f, 0.01934788f, 0.01110286f, -0.02226158f, 0.00761728f, 0.01115104f, 
    0.02415118f, -0.02741834f, 0.00606495f, -0.00021110f, -0.01840955f, -0.00827584f, -0.00443444f, -0.01792243f, 
    -0.02674678f, -0.01002557f, -0.00472143f, -0.01334253f, -0.04086870f, 0.02288346f, -0.00892289f, -0.03260230f, 
    0.00243684f, -0.02896016f, 0.02322438f, -0.00543322f, 0.00918104f, 0.00620546f, 0.00325528f, -0.01023116f, 
    0.02173596f, 0.00313970f, -0.03341252f, 0.01149611f, -0.01785527f, -0.00489997f, 0.00316558f, 0.02411065f, 
    0.01058634f, 0.02695631f, -0.02318990f, -0.01715481f, 0.00046332f, -0.00986505f, -0.03608859f, 0.02265039f, 
    0.01532215f, 0.00153158f, -0.04407092f, -0.03538673f, -0.02484768f, 0.02956226f, 0.01470650f, 0.00505480f, 
    0.01269382f, -0.03883604f, 0.01957382f, -0.00252809f, 0.00655215f, 0.01529307f, -0.00955338f, -0.01787346f, 
    0.00111489f, 0.00192610f, 0.01470414f, 0.01557236f, 0.01140877f, -0.03594154f, -0.02414819f, 0.00843579f, 
    -0.02137522f, 0.01359609f, -0.02164887f, -0.03798271f, -0.03905536f, 0.00601446f, 0.00806012f, -0.01356761f, 
    0.00428135f, 0.01653369f, -0.00090087f, -0.01904101f, 0.00832321f, -0.01630982f, 0.00382279f, -0.02406024f, 
    0.00705652f, -0.04297610f, 0.02682019f, 0.02401487f, -0.03447064f, 0.01513434f, 0.01887044f, -0.00802558f, 
    -0.02941469f, -0.03456748f, -0.03597129f, -0.01221731f, 0.01948842f, 0.02488158f, -0.00171390f, -0.01036027f, 
    -0.01894954f, 0.01078818f, -0.00960740f, -0.00665863f, 0.00661691f, -0.03371158f, -0.01659856f, 0.03456521f, 
    -0.00250818f, -0.01636828f, -0.04059136f, -0.03843143f, 0.02016714f, -0.01192393f, -0.01064477f, -0.02788935f, 
    0.02192760f, -0.03513253f, 0.01993969f, -0.04247098f, -0.00715160f, -0.04579883f, -0.01186412f, -0.03496385f, 
    0.01655110f, -0.01220789f, 0.01062902f, 0.00692821f, 0.00091955f, -0.02418554f, -0.01343496f, 0.00593008f, 
    -0.01361988f, -0.01648486f, -0.04293971f, 0.01103024f, 0.02977067f, -0.02784729f, 0.02377097f, 0.02364526f, 
    -0.02539913f, -0.00474885f, 0.00018503f, 0.03253706f, -0.00415614f, 0.00767858f, -0.02215865f, -0.00844527f, 
    -0.00368645f, 0.01089603f, -0.01264150f, 0.02093899f, -0.03839348f, 0.01399185f, 0.02061587f, -0.02603669f, 
    0.00819479f, -0.01683385f, 0.01991183f, 0.00903977f, -0.02665525f, 0.02972635f, 0.01686110f, 0.03056638f, 
    -0.02212226f, -0.00159890f, -0.00760067f, 0.01396693f, 0.01697888f, 0.00590112f, -0.01524548f, -0.03260903f, 
    -0.01779883f, -0.01466848f, -0.02900096f, -0.02755609f, 0.00932475f, 0.02572425f, 0.00477452f, 0.01513688f, 
    0.01873920f, -0.02473495f, -0.00858194f, -0.03520130f, -0.02766610f, -0.01619422f, -0.03074174f, -0.04063835f, 
    -0.02034314f, -0.02527304f, 0.01094103f, -0.02616809f, -0.00468699f, 0.00965509f, -0.00534544f, -0.00395027f, 
    0.03702601f, -0.02322141f, -0.01089587f, -0.01025534f, -0.02166971f, 0.00029982f, -0.00783112f, 0.00896648f, 
    -0.02171227f, -0.00508611f, 0.00987469f, -0.04551147f, -0.02740017f, 0.01468430f, 0.00933062f, -0.04374058f, 
    0.02315911f, 0.00042876f, -0.04334827f, -0.00973546f, -0.01035006f, -0.03901401f, -0.01175962f, -0.01444881f, 
    -0.03007213f, -0.03005530f, -0.02699737f, -0.03085374f, 0.01503249f, -0.01220918f, 0.00133053f, 0.00518640f, 
    -0.00170193f, 0.00847062f, -0.03274239f, -0.04155573f, 0.00360932f, 0.00550559f, 0.01917062f, -0.02703355f, 
    -0.02013219f, 0.02386820f, -0.02658135f, -0.02852746f, 0.01099670f, 0.02163545f, -0.00184975f, -0.03932121f, 
    -0.00745531f, -0.04069981f, 0.01524260f, -0.00554326f, -0.00585746f, 0.01701216f, -0.01977581f, -0.00648788f, 
    -0.00984132f, -0.00659984f, -0.00017019f, -0.01336143f, 0.01857621f, 0.02256324f, 0.02867066f, 0.01777119f, 
    -0.00244764f, 0.01932946f, 0.00269975f, -0.02972439f, 0.01017451f, -0.02301352f, 0.00254583f, 0.00974120f, 
    0.01295757f, -0.01077444f, -0.00190679f, 0.00250195f, -0.03292985f, -0.02997963f, -0.00653852f, 0.02566243f, 
    0.02846524f, -0.03967278f, -0.03551618f, -0.01644462f, 0.00489106f, -0.02953462f, -0.02756562f, -0.01421035f, 
    -0.02433519f, 0.02371167f, -0.01510253f, 0.02347176f, -0.03441228f, -0.04103990f, 0.03468167f, -0.02254255f, 
    -0.00226304f, -0.01793753f, -0.01860791f, -0.01682363f, -0.01665662f, -0.03329888f, -0.03964068f, 0.01108418f, 
    -0.00285622f, 0.02131361f, 0.01421364f, -0.03249855f, 0.01371132f, -0.02417676f, 0.02113750f, -0.04060026f, 
    -0.02326978f, -0.02070742f, 0.02306017f, 0.01307281f, -0.01603873f, 0.02548804f, -0.03136069f, -0.00152432f, 
    0.00419201f, 0.03041028f, 0.00225090f, -0.01348173f, -0.01864740f, 0.01478200f, -0.02498935f, -0.04289695f, 
    -0.04401355f, 0.02154578f, 0.02445016f, 0.00752067f, -0.02709478f, 0.04125402f, 0.03009305f, -0.00048920f, 
    -0.03583045f, -0.02967597f, -0.01404648f, 0.01326385f, 0.00239721f, -0.03783441f, -0.00161347f, -0.01490253f, 
    0.00548667f, 0.01417159f, 0.00991087f, 0.02221556f, -0.00282853f, -0.03260867f, 0.00447002f, 0.01800303f, 
    -0.02817315f, -0.00360954f, 0.01724024f, -0.02640560f, 0.01781310f, -0.01197481f, -0.03734827f, 0.02016321f, 
    0.01746598f, -0.02687615f, 0.00258732f, 0.01759563f, 0.02593031f, -0.01675813f, 0.02084040f, -0.02059263f, 
    -0.02306710f, -0.02774347f, 0.00787780f, -0.02014710f, -0.01248003f, -0.03163926f, 0.01332682f, -0.04526270f, 
    -0.02625966f, -0.01555614f, 0.02966968f, 0.02130381f, -0.00810826f, -0.01687426f, -0.02375535f, 0.00966206f, 
    -0.01393873f, 0.01094505f, -0.00092321f, -0.03008383f, -0.03717553f, -0.03689691f, -0.03096862f, 0.00588407f, 
    0.00453573f, 0.00970762f, -0.02222379f, 0.01266412f, 0.00897938f, -0.00934579f, 0.02581201f, 0.00168168f, 
    -0.03777042f, 0.02299002f, -0.02128832f, -0.02707710f, 0.00024260f, 0.00309904f, -0.01571809f, -0.03309365f, 
    -0.04068576f, -0.03394493f, 0.00361752f, -0.02391510f, 0.02634321f, -0.02334449f, 0.01680620f, -0.02561068f, 
    0.01456177f, 0.00352430f, -0.01246683f, -0.02221013f, -0.02896791f, -0.00182962f, 0.00544976f, -0.03623486f, 
    -0.01407226f, -0.02901058f, -0.00989329f, -0.04080203f, 0.02436829f, 0.00572389f, -0.00838607f, 0.01376007f, 
    0.02367431f, -0.03879467f, -0.02769425f, -0.02499560f, 0.01428241f, 0.01540597f, -0.01395824f, -0.02559929f, 
    0.01945313f, 0.03417097f, -0.02059453f, -0.00012125f, 0.02361484f, -0.02882324f, -0.01729346f, -0.01379181f, 
    -0.02373755f, -0.03095748f, 0.00983564f, 0.00291318f, -0.03109748f, -0.03889203f, 0.01649223f, -0.03459002f, 
    -0.03147878f, -0.04143820f, 0.02573957f, 0.01628009f, -0.01980558f, -0.02174949f, -0.01986103f, 0.01244734f, 
    -0.01047599f, 0.00162294f, -0.03336346f, -0.03750333f, -0.04055745f, -0.01237748f, 0.02046605f, 0.01593442f, 
    0.00340734f, -0.00268425f, 0.02435187f, 0.02856983f, -0.04153854f, -0.00270977f, -0.00747458f, 0.02047536f, 
    0.01143592f, -0.01761679f, 0.02295627f, 0.00342777f, -0.01931168f, 0.00164198f, -0.02347536f, 0.00486790f, 
    0.03062111f, 0.02564584f, 0.00960518f, -0.02049631f, -0.03563856f, -0.03168111f, -0.02541670f, -0.00220483f, 
    -0.03486459f, -0.03449839f, -0.01854097f, -0.02368932f, -0.03621588f, -0.00980907f, 0.00823587f, -0.01156965f, 
    0.02160455f, -0.03225563f, 0.02758602f, -0.03265191f, -0.00549888f, -0.03009738f, -0.01737792f, 0.01038911f, 
    0.02625886f, 0.01964876f, 0.00709798f, -0.01961838f, 0.00193369f, -0.02603207f, -0.04674671f, 0.01121340f, 
    -0.02511263f, 0.02677969f, -0.00581593f, 0.02123305f, 0.00552789f, 0.02276602f, 0.01592103f, 0.02379763f, 
    -0.00600997f, -0.03567350f, -0.01799073f, -0.03212504f, -0.00677368f, 0.01359995f, 0.02368899f, -0.03726162f, 
    -0.03528523f, 0.00839289f, 0.01581830f, 0.01998585f, -0.01014970f, -0.03856117f, 0.02047376f, -0.03133336f, 
    -0.00320443f, -0.02358975f, -0.00797181f, 0.01507254f, -0.02921927f, 0.02105031f, 0.01240701f, -0.01836225f, 
    0.00645262f, 0.00931554f, -0.03588465f, -0.00117249f, 0.01940425f, 0.01570497f, -0.02387307f, 0.00118174f, 
    -0.01394927f, -0.01174932f, -0.00465259f, -0.02608920f, -0.03638922f, -0.00378630f, -0.03484321f, 0.02442917f, 
    -0.01941049f, 0.02489662f, 0.00357275f, -0.02589286f, -0.00136729f, -0.03108810f, -0.02820849f, 0.00487889f, 
    0.01207313f, 0.00376441f, 0.00117065f, 0.01250744f, -0.01000785f, 0.02415823f, -0.02250339f, 0.00908606f, 
    0.02531893f, 0.00691772f, 0.00246245f, -0.00032615f, -0.03635183f, -0.03560602f, 0.03178981f, -0.01227365f, 
    0.00230322f, -0.01672823f, 0.03026306f, -0.01179694f, 0.00274129f, -0.01623433f, -0.04596318f, 0.00851670f, 
    -0.01122707f, -0.01856273f, -0.04396962f, -0.01371555f, 0.01144982f, 0.00158411f, -0.00680830f, -0.01186700f, 
    -0.01358476f, 0.01586368f, -0.00547658f, 0.01568180f, -0.02919161f, 0.01766486f, 0.01492404f, 0.02146726f, 
    -0.00007213f, -0.01174967f, -0.00825699f, -0.03623291f, -0.02014585f, -0.00938488f, 0.00788987f, 0.01083348f, 
    -0.04375898f, -0.01147432f, -0.02283682f, 0.00791603f, -0.04025854f, 0.03036560f, -0.03305961f, -0.00061895f, 
    0.00264966f, 0.02127167f, 0.00350332f, -0.00756077f, -0.01200810f, -0.02193756f, 0.01265464f, 0.01157301f, 
    0.00204231f, 0.00895080f, 0.01930571f, -0.01765534f, 0.01003193f, 0.02902398f, 0.02295609f, -0.01569816f, 
    -0.00642415f, 0.01140090f, 0.02153563f, -0.01433575f, -0.03437130f, -0.02778334f, -0.03729040f, 0.01544649f, 
    -0.03470027f, -0.01739731f, -0.00194418f, 0.01186779f, -0.01217552f, 0.01363972f, -0.02720833f, 0.01652315f, 
    -0.02052750f, 0.02600189f, 0.02837757f, 0.00384986f, 0.00394047f, 0.02419161f, 0.00484958f, 0.00941359f, 
    -0.01275841f, -0.03191940f, -0.02192780f, 0.00235964f, -0.03050522f, -0.00240672f, -0.03512326f, 0.02095250f, 
    -0.01385770f, -0.03758807f, 0.02178203f, -0.03310988f, 0.00751763f, -0.01168230f, -0.03715893f, -0.01692613f, 
    0.03343529f, 0.01707227f, 0.00444576f, -0.02430520f, -0.00586203f, 0.00379272f, -0.02215183f, -0.03978084f, 
    0.00537934f, -0.03261533f, -0.04031983f, -0.03375934f, 0.02698475f, -0.02131288f, -0.03259288f, 0.02412659f, 
    -0.02804576f, -0.02971365f, 0.00414616f, -0.00617764f, -0.00777209f, -0.00889648f, 0.02950775f, -0.00261640f, 
    0.00575994f, -0.02379444f, -0.03767286f, 0.00356757f, -0.02813981f, -0.03831531f, -0.01117403f, 0.00140006f, 
    -0.02309629f, 0.01844669f, -0.02983603f, -0.01215928f, 0.02316971f, -0.02210811f, -0.03136552f, 0.02184954f, 
    -0.01450884f, 0.02404767f, 0.00386177f, -0.02727232f, -0.00671397f, -0.03358047f, 0.02270969f, -0.02615428f, 
    0.00251296f, 0.01925051f, -0.00625578f, 0.01210320f, -0.03644259f, -0.00238718f, -0.00239692f, -0.02579111f, 
    -0.01977408f, -0.01573106f, 0.01979128f, -0.01986830f, -0.03006125f, -0.03351087f, -0.00273712f, 0.00576103f, 
    0.01528461f, 0.01836573f, -0.03919930f, 0.02522429f, 0.00189939f, 0.00208707f, 0.00496980f, -0.03144035f, 
    -0.00663308f, -0.03174783f, 0.00019848f, 0.01600190f, 0.02225444f, 0.02853620f, 0.00847172f, -0.02025971f, 
    -0.01607244f, 0.00049796f, -0.00026329f, -0.03143124f, -0.01137106f, 0.01349056f, 0.00263020f, 0.01029218f, 
    0.01960875f, 0.00046309f, 0.01602044f, 0.01501817f, -0.00009587f, 0.01686467f, -0.01791134f, -0.01677009f, 
    -0.01395583f, -0.02218461f, -0.00555390f, 0.02098419f, 0.00022822f, 0.00087066f, 0.01458499f, -0.02084784f, 
    0.01721383f, 0.01952164f, -0.03290455f, 0.02501733f, 0.01135256f, 0.00811370f, -0.01765856f, 0.00851101f, 
    0.00758462f, 0.02732831f, -0.02582700f, 0.01521319f, 0.01322405f, 0.01356159f, -0.02788565f, -0.01523346f, 
    0.02634073f, -0.00754873f, 0.00014873f, 0.02367357f, -0.01899110f, -0.04160431f, -0.03704574f, -0.00275630f, 
    0.01293860f, 0.00107642f, 0.01362004f, -0.00428217f, 0.01682855f, -0.01177158f, -0.03803783f, 0.01057412f, 
    -0.02645435f, -0.01313257f, -0.03934829f, 0.00922559f, -0.01666256f, 0.01578335f, 0.01200759f, -0.02928394f, 
    -0.03430666f, 0.02661843f, -0.00786782f, -0.02354458f, -0.03500810f, -0.04217152f, -0.03044404f, 0.02561151f, 
    0.00731086f, -0.01779941f, -0.01675029f, -0.02681755f, 0.01172571f, -0.01335885f, -0.00936509f, -0.02855092f, 
    0.02351802f, -0.00273077f, -0.04198517f, 0.02775992f, 0.00961886f, 0.02551383f, -0.02627540f, 0.00307358f, 
    -0.01132583f, -0.01001745f, -0.01681551f, 0.02252647f, -0.02352603f, 0.02393611f, -0.03628963f, 0.01666231f, 
    0.00322098f, -0.01442799f, -0.02311546f, -0.02219109f, -0.01343603f, -0.02446632f, 0.01042408f, -0.00240625f, 
    -0.01866996f, -0.02357947f, 0.02340240f, 0.01558230f, -0.01013659f, 0.01910662f, -0.01470144f, -0.00567650f, 
    -0.02844718f, -0.02286936f, -0.01110885f, 0.00654933f, 0.00844174f, 0.02236423f, -0.00408918f, 0.02053660f, 
    -0.01757300f, -0.00344703f, -0.00429670f, -0.00692581f, -0.02754681f, -0.02133429f, -0.04277090f, 0.01607300f, 
    -0.01590349f, -0.00487570f, 0.00838768f, -0.01034623f, 0.02773649f, -0.00299413f, 0.02660506f, -0.01098007f, 
    0.01640141f, -0.03373418f, -0.00002241f, -0.01201612f, 0.00312221f, -0.00393346f, -0.03790467f, 0.02056001f, 
    0.00641783f, -0.01105979f, -0.01684603f, -0.04345143f, -0.01378171f, -0.00750951f, 0.02124979f, -0.04389998f, 
    0.03268088f, -0.04023743f, 0.01305379f, -0.02605793f, -0.02335114f, -0.01546247f, -0.02251013f, -0.00120357f, 
    0.01953629f, -0.04133311f, 0.03365200f, -0.02413588f, -0.02303412f, -0.00119067f, -0.01566191f, 0.02142153f, 
    -0.02042178f, -0.01897338f, -0.03013591f, 0.00404424f, -0.00182774f, -0.01295380f, 0.02395059f, -0.04253866f, 
    -0.00553005f, -0.01932753f, -0.03340282f, -0.01680575f, 0.01522413f, 0.02098458f, -0.00346794f, -0.01204051f, 
    -0.00497535f, 0.00813651f, -0.00665718f, -0.02039835f, 0.00113874f, -0.02386465f, -0.02650903f, 0.00263234f, 
    -0.01254560f, 0.00403674f, 0.02422722f, 0.02181603f, -0.00041171f, -0.02104518f, 0.01099521f, 0.00855117f, 
    0.00161043f, -0.03097310f, -0.03339706f, -0.01944526f, 0.01408053f, -0.03338591f, -0.01026733f, -0.00283578f, 
    0.01211156f, -0.04053703f, -0.04204117f, 0.02023673f, 0.01120424f, 0.00504909f, -0.02873865f, -0.00572309f, 
    0.02686647f, -0.02435248f, 0.01286580f, -0.04058653f, 0.01484891f, -0.03231439f, 0.02221119f, 0.01251287f, 
    0.01075092f, -0.01700784f, 0.01143413f, -0.01735129f, -0.04428343f, 0.02350965f, 0.01014585f, 0.01959989f, 
    -0.02222228f, 0.00342120f, 0.02503355f, -0.00487352f, -0.00264734f, -0.03263446f, -0.00676162f, 0.01278893f, 
    0.01031581f, 0.02448624f, 0.00050884f, 0.02756790f, -0.00941297f, -0.03880828f, -0.02480808f, -0.00964797f, 
    -0.02602451f, -0.01370097f, 0.02512915f, -0.03238666f, -0.00518677f, -0.03005770f, -0.00850132f, -0.00130343f, 
    -0.01528642f, 0.00022652f, 0.02633944f, -0.00884368f, 0.01719991f, -0.00707790f, -0.02845467f, -0.03130231f, 
    -0.00702429f, 0.03923978f, -0.03605639f, -0.03223914f, 0.00178362f, -0.00055268f, -0.03897144f, 0.00298336f, 
    -0.03507802f, 0.00101549f, 0.01086206f, 0.01710409f, 0.01516167f, -0.02052635f, 0.01356907f, -0.02943332f, 
    0.02487779f, -0.00364639f, 0.01191636f, -0.02528257f, -0.00507386f, -0.01518354f, -0.00817669f, 0.01649922f, 
    -0.04225170f, 0.00163520f, 0.02087979f, -0.02536730f, -0.02114929f, -0.02098859f, 0.00374606f, -0.00090391f, 
    -0.03836470f, -0.00849887f, -0.01965453f, 0.02205620f, -0.01746145f, -0.00298940f, 0.02290690f, 0.02403816f, 
    -0.01489487f, 0.02381567f, -0.02750189f, -0.01391582f, 0.01462585f, -0.00277541f, -0.00023826f, -0.03259869f, 
    -0.00655081f, -0.03218210f, -0.01887238f, 0.02285774f, 0.00750942f, -0.02451733f, -0.01700618f, -0.00317209f, 
    0.02264588f, 0.00822312f, -0.01677970f, -0.03825279f, -0.01000924f, -0.02996204f, -0.04231792f, -0.00166608f, 
    0.00035972f, -0.03189735f, -0.01416370f, 0.00599500f, -0.02463240f, 0.02389833f, 0.01485896f, -0.02002467f, 
    -0.01392466f, -0.03807307f, 0.00844666f, 0.02651618f, 0.00951687f, -0.03333501f, 0.02103415f, 0.01738069f, 
    -0.02381462f, -0.01518497f, 0.01891271f, 0.01744001f, 0.00387386f, -0.02689080f, -0.02414209f, -0.00812486f, 
    -0.02888115f, 0.03342343f, -0.02388101f, -0.00582040f, 0.01827487f, -0.01791212f, -0.04027963f, 0.00609400f, 
    0.00162679f, 0.01202284f, -0.04155977f, -0.03379614f, -0.02750949f, -0.03392529f, 0.01721886f, -0.01172251f, 
    0.02779727f, 0.03497015f, -0.03756762f, 0.00375050f, -0.02179922f, -0.03473225f, -0.02292084f, -0.01448751f, 
    0.00344066f, -0.02224928f, -0.01668631f, -0.03788523f, 0.00724115f, 0.02516112f, 0.02377759f, -0.03703548f, 
    -0.02034963f, -0.00137957f, -0.00505610f, 0.00167911f, -0.01485830f, -0.02583828f, -0.01380313f, 0.00136366f, 
    0.01198986f, -0.00453147f, -0.02366354f, 0.00413309f, -0.00425451f, 0.02115415f, -0.03569078f, -0.00468844f, 
    -0.03372080f, 0.01091198f, 0.01710814f, -0.02305644f, 0.00926007f, 0.01546932f, 0.02518325f, 0.02070339f, 
    -0.03276593f, 0.03415065f, -0.00291069f, -0.01189025f, -0.03837769f, -0.04114721f, 0.02704709f, -0.01936525f, 
    0.01869286f, 0.02591745f, -0.03098264f, 0.00514150f, -0.02473808f, -0.02320781f, 0.01711962f, -0.00035834f, 
    -0.04363297f, -0.00422491f, 0.01353617f, -0.02622127f, -0.03675286f, 0.00942487f, 0.01624087f, -0.01245466f, 
    0.00866378f, -0.02611302f, -0.00211781f, -0.04319344f, 0.02128523f, 0.00941939f, 0.01125704f, -0.03867478f, 
    -0.00989686f, 0.00520009f, -0.01947143f, 0.01838676f, -0.04239080f, 0.01976977f, -0.00168635f, -0.03338992f, 
    -0.01629451f, -0.04385727f, 0.02014240f, -0.01282141f, -0.02848214f, 0.01351170f, 0.00781027f, -0.00836767f, 
    0.00857860f, 0.01699435f, 0.01132257f, -0.01076624f, -0.02753445f, 0.00015147f, -0.02826316f, -0.03747635f, 
    0.00613477f, 0.03076888f, -0.00387621f, -0.02288059f, -0.04087736f, 0.02361063f, -0.00728796f, -0.00969198f, 
    -0.00419423f, -0.01168131f, -0.00558551f, -0.03109592f, -0.00641110f, -0.02949723f, -0.01179161f, -0.04008981f, 
    -0.04115229f, -0.02563034f, -0.01163548f, -0.01578151f, -0.00991194f, -0.00761734f, 0.00258796f, 0.00765300f, 
    -0.02522987f, 0.00323909f, -0.00157116f, -0.00466229f, -0.03552589f, 0.01455547f, -0.01375599f, -0.03928861f, 
    -0.01611173f, 0.01376035f, -0.00291983f, -0.02092136f, 0.01882552f, -0.01765095f, -0.02634956f, 0.00839057f, 
    0.00782315f, -0.00227819f, 0.01682135f, -0.03676284f, 0.01357265f, 0.02111425f, -0.03423332f, -0.04037271f, 
    -0.00757753f, 0.02600952f, 0.01348435f, -0.04214193f, -0.01583805f, 0.00386078f, -0.00589565f, -0.00791070f, 
    -0.00521924f, -0.00994302f, 0.01490176f, 0.00132799f, 0.01018990f, -0.02723747f, 0.02796769f, 0.02584811f, 
    0.02313844f, 0.01146346f, -0.03076765f, -0.00162368f, -0.03949302f, -0.01712621f, 0.00877823f, -0.03376945f, 
    -0.02912317f, 0.00345512f, 0.01303503f, -0.00644161f, 0.00700757f, -0.00232950f, 0.02172224f, -0.03997279f, 
    -0.01884738f, -0.02795594f, -0.02863588f, -0.03512513f, 0.01730769f, -0.02558815f, -0.03619299f, 0.00759763f, 
    -0.03996244f, 0.02415249f, 0.01008031f, -0.02854800f, -0.02065234f, 0.01688866f, -0.00016704f, -0.00828959f, 
    -0.00372493f, -0.02428358f, -0.04297657f, -0.01049435f, -0.02657448f, 0.02439937f, 0.02118797f, 0.00342148f, 
    0.02328192f, 0.01649424f, -0.02485485f, -0.01609968f, 0.00398238f, -0.00551951f, -0.00682907f, -0.00844670f, 
    -0.01452788f, -0.01702811f, 0.01993978f, -0.04063651f, -0.01912162f, 0.02489438f, 0.00431157f, -0.00839392f, 
    0.01006859f, 0.00490718f, 0.01261483f, 0.00728723f, -0.04089366f, -0.02737273f, 0.00043744f, -0.00037223f, 
    -0.02883827f, -0.04398834f, 0.02026102f, -0.03212698f, -0.03134465f, -0.03762851f, 0.02248967f, -0.02372061f, 
    0.01601004f, -0.02476699f, -0.02296082f, 0.01808623f, -0.04113868f, -0.01773484f, 0.01727235f, 0.00810587f, 
    -0.02403435f, -0.02215918f, -0.01096678f, 0.00545215f, -0.02393190f, -0.03552882f, -0.01622542f, 0.00739281f, 
    -0.01765792f, -0.03583564f, 0.00964984f, 0.02797725f, 0.00059696f, 0.00006029f, 0.01999387f, 0.02578926f, 
    0.00338969f, -0.01089151f, -0.04203007f, 0.00172831f, 0.02063510f, -0.00847837f, 0.00132813f, -0.00608826f, 
    -0.03744169f, -0.00282966f, -0.00054121f, -0.01946379f, 0.01412422f, -0.01656301f, -0.03046242f, 0.02568931f, 
    -0.02309757f, -0.01224434f, 0.02231617f, -0.02852454f, 0.00025022f, 0.02213738f, 0.02381804f, -0.03969977f, 
    -0.04072338f, -0.04265242f, 0.00910610f, -0.02153899f, -0.03921506f, -0.01764092f, -0.00512644f, -0.03819676f, 
    0.02786029f, -0.04338066f, -0.03458203f, -0.00936664f, -0.00134273f, -0.01091882f, -0.02883139f, -0.00075379f, 
    0.02526287f, 0.02101175f, -0.01090238f, 0.00616569f, -0.00825022f, -0.01966327f, -0.02417135f, -0.02619554f, 
    -0.00140979f, 0.00323843f, -0.00284214f, -0.02453479f, -0.04312553f, -0.01701328f, 0.00533475f, -0.03284970f, 
    0.00910752f, 0.02486774f, -0.03383610f, 0.01945236f, -0.01920827f, -0.00125600f, -0.01340025f, -0.01716930f, 
    -0.03558413f, 0.02301151f, -0.03256256f, -0.01942190f, 0.02537847f, -0.02062606f, 0.00822948f, -0.01936980f, 
    -0.03439748f, -0.00211467f, 0.00088897f, -0.00871624f, -0.04359113f, 0.01090241f, 0.00568459f, -0.00261839f, 
    -0.01050399f, -0.01721956f, -0.00877015f, 0.01792541f, 0.01870451f, 0.01674201f, 0.00580363f, 0.01523931f, 
    -0.03151156f, 0.01437805f, -0.01060252f, -0.02843785f, -0.01037094f, -0.02800924f, -0.03563813f, 0.01612984f, 
    -0.00930176f, 0.01891755f, 0.01428231f, 0.01032547f, -0.04200410f, -0.00554126f, 0.01165304f, -0.02867921f, 
    0.00664705f, -0.04291254f, -0.02573904f, 0.01610164f, -0.00753935f, -0.03575034f, 0.01523094f, 0.00893042f, 
    0.24954467f, 0.08868791f, -0.05383833f, 0.24284883f, 0.06178482f, 0.05961166f, -0.05607586f, 0.00270071f, 
    0.11804599f, 0.07366949f, 0.04666654f, -0.05025272f, -0.00376917f, 0.09592374f, -0.08794003f, -0.27415422f, 
    0.16649696f, 0.14511186f, -0.02518685f, 0.03646242f, 0.00464998f, -0.02605844f, -0.04509667f, -0.10869983f, 
    0.12493094f, 0.03553361f, 0.26465592f, 0.30374756f, 0.06373148f, -0.00892653f, -0.03115983f, 0.04648527f, 
    -0.05283994f, 0.01826791f, 0.02818492f, -0.03057682f, -0.04040179f, 0.08740328f, 0.08970433f, -0.24108459f, 
    -0.06698895f, -0.00434029f, 0.18065314f, -0.09329861f, -0.09357118f, 0.04950240f, 0.02042016f, 0.04300805f, 
    0.16370061f, 0.24802905f, -0.12875579f, 0.02678357f, -0.05486263f, -0.05982086f, -0.05554107f, 0.01291329f, 
    -0.05893583f, -0.04583707f, -0.02599512f, -0.01142762f, 0.09613127f, 0.13656162f, 0.21746613f, -0.01168846f, 
    0.12997444f, 0.08501669f, 0.09706946f, -0.01666043f, 0.08174192f, -0.15816966f, -0.06558283f, -0.00103226f, 
    0.11206865f, 0.13890706f, -0.07971357f, -0.16153046f, -0.15562998f, -0.00185834f, -0.03650117f, -0.08511672f, 
    0.01370077f, 0.00657510f, -0.03481276f, 0.01139150f, -0.09122182f, 0.00849427f, -0.03432058f, -0.12072966f, 
    -0.01673259f, 0.05828215f, -0.04630091f, 0.01318564f, 0.03999181f, -0.05724069f, 0.02902445f, 0.00973714f, 
    -0.11803092f, -0.05684742f, 0.09627290f, 0.31415468f, 0.10066082f, 0.07172102f, 0.09716217f, 0.02917311f, 
    -0.00493918f, 0.11625068f, 0.07231765f, 0.04028870f, -0.04010091f, -0.02034272f, -0.03468403f, -0.02300069f, 
    -0.05505458f, 0.09221748f, 0.02116408f, 0.02378361f, 0.00022439f, -0.02102511f, -0.04448822f, -0.02086856f, 
    -0.04430860f, 0.07281353f, -0.07823041f, 0.06826705f, -0.03198684f, 0.02231565f, 0.00411812f, 0.10577665f, 
    0.08635782f, 0.06009706f, 0.11691569f, 0.10404976f, 0.07678956f, 0.23876871f, 0.16534729f, -0.22675890f, 
    0.05930081f, 0.07508495f, 0.06100792f, -0.02254785f, -0.08983985f, -0.12140997f, 0.12547296f, -0.05202816f, 
    -0.09775008f, -0.08282997f, -0.12246130f, -0.03602082f, 0.02107749f, -0.03252421f, 0.02627869f, 0.02547552f, 
    0.05865904f, -0.00958888f, 0.04465919f, -0.00774248f, -0.15330693f, -0.08179664f, 0.15251079f, -0.18181826f, 
    0.00281456f, -0.01768378f, -0.00954237f, 0.04767954f, -0.01295856f, 0.02958494f, 0.04879156f, -0.02300522f, 
    -0.10979655f, 0.01564738f, 0.09434607f, 0.09678099f, 0.01266524f, 0.08298787f, 0.05145201f, 0.06163299f, 
    0.07936526f, 0.03594353f, 0.03687008f, -0.05459378f, -0.08031698f, -0.23607749f, 0.18898372f, -0.12421209f, 
    -0.06766904f, 0.05117059f, 0.04838751f, 0.01179462f, -0.04823368f, -0.09877171f, 0.07074169f, 0.02791898f, 
    0.26008037f, 0.04897928f, 0.15634780f, -0.16026716f, 0.12500547f, -0.04583860f, 0.10328677f, 0.06132686f, 
    0.05027180f, 0.09737790f, -0.01565019f, -0.02204231f, -0.09284014f, -0.06741937f, 0.02102605f, 0.08306463f, 
    -0.03340092f, 0.01321812f, 0.12242728f, -0.04085046f, -0.04811579f, 0.02734660f, -0.02248434f, 0.05915881f, 
    -0.02186976f, 0.14134336f, 0.03834500f, 0.04918614f, 0.01045521f, 0.08467137f, 0.10101492f, 0.03743580f, 
    -0.05346360f, -0.04120509f, 0.05483418f, 0.05620550f, -0.03764404f, 0.11826158f, 0.01179901f, 0.07070631f, 
    0.04628383f, -0.02645948f, 0.11199190f, 0.03092623f, 0.02517703f, -0.04530346f, 0.07214054f, -0.08141096f, 
    0.26210493f, 0.05355882f, 0.07706338f, 0.24266268f, -0.00490920f, -0.09439186f, 0.06108987f, -0.00578602f, 
    0.07809991f, 0.12473889f, 0.03312839f, 0.06925348f, -0.11719681f, -0.25497326f, -0.06011009f, -0.09451681f, 
    0.04715242f, -0.00816491f, 0.00011951f, -0.03184742f, -0.00470160f, 0.07609309f, -0.00156110f, -0.00310960f, 
    -0.04268690f, 0.09413625f, -0.06816997f, 0.17003439f, 0.05888736f, -0.01504585f, 0.00604575f, 0.09409707f, 
    0.06814548f, 0.12005474f, 0.14026998f, 0.06264479f, 0.22003512f, 0.09150039f, -0.15165477f, 0.14920855f, 
    0.14985192f, 0.03927592f, 0.01768667f, 0.12446844f, -0.00772954f, -0.02188005f, -0.11320696f, -0.05873818f, 
    0.20009096f, 0.09592886f, -0.19201830f, 0.19313045f, -0.18093376f, 0.01884515f, -0.06573238f, -0.12285601f, 
    -0.02856148f, -0.13186228f, 0.01998742f, 0.08079008f, 0.17249008f, 0.11105728f, -0.03365166f, 0.21859103f, 
    0.16149998f, -0.00855653f, -0.05546472f, -0.00738133f, 0.01490570f, 0.15127715f, -0.00053234f, 0.06222352f, 
    0.00521871f, -0.06970063f, -0.06581195f, 0.18486860f, -0.12250195f, -0.00580268f, 0.02546262f, -0.01350318f, 
    0.07660799f, 0.02024870f, -0.02090834f, -0.01226689f, 0.04365625f, 0.22714821f, 0.06526235f, -0.16103598f, 
    0.00916549f, 0.01485785f, 0.07907570f, 0.07961336f, 0.11304213f, -0.05607314f, 0.08717208f, -0.02452324f, 
    -0.30472958f, -0.00425035f, 0.14400496f, -0.25582850f, 0.00879615f, 0.06365959f, 0.03547108f, -0.05310081f, 
    -0.03251303f, -0.05200675f, 0.07920693f, -0.01064793f, -0.01905222f, -0.04249003f, -0.14967754f, -0.06343963f, 
    0.12606217f, 0.08918525f, -0.04893314f, 0.00418103f, 0.00478101f, 0.06177777f, 0.07148694f, 0.08075954f, 
    0.13688590f, -0.07299218f, -0.08006895f, 0.07982374f, 0.12857637f, 0.13648947f, 0.03186402f, 0.06403827f, 
    0.10241242f, 0.06563088f, 0.03568985f, 0.13250710f, 0.02357844f, -0.11047480f, 0.00815888f, -0.21397924f, 
    0.20943929f, 0.00758017f, -0.02231798f, 0.03023837f, 0.02829727f, 0.06607734f, 0.01905514f, 0.01425835f, 
    -0.45073697f, 0.10051913f, -0.08051684f, 0.04330021f, 0.12792826f, -0.00772019f, 0.05563373f, -0.04412230f, 
    0.02711003f, 0.00456873f, 0.16986576f, -0.03640545f, 0.06089574f, 0.17361885f, 0.04160701f, 0.05280321f, 
    0.03022099f, 0.01161042f, 0.00506766f, -0.03316374f, 0.11215314f, -0.03681904f, 0.05164958f, 0.06193792f, 
    0.35121825f, -0.02293590f, -0.10435336f, 0.01092544f, 0.03838154f, 0.04448396f, -0.15047982f, -0.05948330f, 
    -0.03394034f, -0.04608088f, 0.03432404f, -0.00420383f, -0.01783164f, 0.01945479f, -0.06123088f, -0.16295776f, 
    -0.14088322f, 0.05387760f, 0.06028482f, -0.08348513f, -0.04292402f, -0.00918225f, -0.04011155f, -0.03711884f, 
    -0.06800158f, -0.17464176f, 0.07628798f, -0.00530511f, -0.08025201f, 0.01952711f, 0.02753693f, 0.08194496f, 
    0.04645954f, -0.09437203f, 0.07978404f, 0.08339829f, -0.17456672f, 0.07963198f, 0.06820404f, -0.01723683f, 
    -0.09897780f, -0.06227535f, 0.10011309f, -0.08637447f, -0.11417106f, 0.00130527f, -0.10703883f, -0.00982707f, 
    -0.09075305f, 0.02539904f, -0.06043088f, 0.16905190f, -0.05732576f, 0.01786912f, -0.13521582f, 0.09875982f, 
    0.09240459f, 0.04859906f, 0.07129179f, 0.02704980f, 0.23569056f, -0.13550143f, 0.11350316f, 0.16781399f, 
    0.09316102f, 0.01129911f, 0.04862015f, 0.08490407f, -0.04301057f, 0.00782651f, -0.01832136f, 0.03865794f, 
    -0.05572719f, 0.09524605f, 0.07478522f, 0.06187977f, -0.02097418f, -0.02509814f, 0.03162256f, -0.14888605f, 
    -0.03041730f, 0.01509240f, 0.02513131f, -0.10440005f, 0.16326657f, 0.16539162f, -0.06433812f, 0.12985899f, 
    0.14620481f, 0.02925090f, -0.06934995f, 0.01867731f, -0.05139536f, 0.03043437f, -0.01622417f, 0.03295532f, 
    0.05595706f, -0.10619467f, -0.02925996f, -0.07185131f, -0.12461946f, -0.03213358f, 0.08097165f, 0.01760516f, 
    0.07147774f, 0.09293322f, 0.07100447f, 0.05132895f, 0.40307027f, 0.06550290f, -0.02316478f, 0.18532737f, 
    -0.07349627f, -0.09075029f, -0.06395636f, 0.11749332f, 0.03238474f, 0.14767715f, -0.01968742f, 0.01988413f, 
    0.13135836f, 0.27702186f, 0.11617939f, -0.02358162f, 0.10568569f, -0.03067737f, 0.08305418f, 0.01673727f, 
    -0.00306067f, 0.04387666f, -0.04875033f, 0.11852661f, 0.03301649f, 0.14829804f, 0.32410115f, 0.15765212f, 
    -0.02561382f, -0.05130740f, 0.00327711f, -0.01506573f, 0.03660414f, -0.02186145f, 0.06410997f, -0.02504607f, 
    0.21250893f, 0.01379051f, 0.07766323f, -0.09986484f, 0.03550845f, 0.09454940f, 0.07446255f, 0.04736828f, 
    0.05852745f, -0.06325559f, -0.01228752f, -0.09361827f, -0.06867540f, -0.09913196f, -0.03456485f, -0.16996570f, 
    0.06970253f, -0.02540767f, -0.00568856f, -0.02927493f, -0.04244473f, -0.02338057f, 0.03582487f, 0.00755896f, 
    0.11475554f, -0.17775418f, -0.13272461f, 0.18658507f, 0.01967507f, 0.02539591f, 0.01278767f, 0.01517941f, 
    0.06681429f, -0.02068178f, 0.00494089f, 0.01352550f, -0.07897016f, -0.08512647f, -0.13996069f, 0.14561036f, 
    -0.02776412f, 0.07501089f, 0.06118342f, 0.08802411f, 0.05259994f, 0.03353750f, 0.11174592f, 0.03381079f, 
    -0.26676592f, -0.26502594f, 0.04661410f, 0.00050050f, 0.03113859f, -0.03894497f, 0.06176196f, -0.00136195f, 
    0.11263445f, -0.00716014f, -0.00118137f, 0.01235046f, -0.22970505f, -0.03302875f, -0.18668744f, 0.12911595f, 
    -0.00136207f, 0.13109522f, -0.08159841f, 0.02826932f, 0.04477277f, 0.07182935f, 0.06492107f, 0.02142094f, 
    -0.13362879f, 0.19952983f, 0.05995423f, 0.02602629f, 0.04267604f, -0.04692328f, 0.09279364f, -0.00488227f, 
    -0.08353870f, -0.06764473f, -0.04170851f, 0.02440525f, 0.19458093f, 0.10939078f, 0.18787539f, -0.09062643f, 
    0.12002916f, 0.05191346f, 0.00946379f, 0.02505752f, 0.02047338f, 0.00343395f, 0.00603796f, -0.00908729f, 
    -0.22970119f, -0.18128672f, -0.09149461f, -0.17716132f, -0.11828949f, -0.03992990f, -0.08738177f, -0.03536169f, 
    -0.06227630f, -0.08814494f, 0.05261014f, 0.06853081f, 0.10116727f, 0.08796991f, -0.08666888f, -0.03962148f, 
    0.07493724f, 0.18934980f, -0.01948940f, 0.06371557f, 0.01086529f, -0.10412694f, 0.03353080f, -0.03158607f, 
    0.27494949f, -0.11969818f, 0.26490784f, -0.04654140f, 0.09498977f, -0.06634814f, 0.06596988f, -0.05272711f, 
    0.12789282f, 0.08313334f, 0.11687015f, 0.13016742f, 0.07282826f, -0.01287653f, 0.04724566f, 0.03226344f, 
    -0.13776095f, 0.04177418f, 0.04193785f, -0.05043615f, 0.03204643f, -0.03592506f, 0.05990164f, 0.13223103f, 
    0.07579385f, -0.06027095f, -0.05763140f, 0.05209654f, 0.00425801f, -0.05313503f, -0.01979422f, -0.04029671f, 
    0.08770158f, 0.01104262f, 0.13238950f, -0.07557750f, 0.27896646f, 0.00688632f, 0.11522925f, 0.22320147f, 
    -0.09866829f, 0.02457252f, 0.12456755f, 0.03664044f, 0.11503477f, 0.07221957f, -0.02907721f, 0.06195448f, 
    0.33903238f, -0.11078747f, -0.15442213f, 0.05755094f, 0.14314543f, -0.06359696f, 0.00235901f, 0.10512815f, 
    -0.02798762f, 0.07400642f, -0.10827137f, -0.00373421f, -0.08313697f, -0.04308087f, 0.04541993f, 0.05765978f, 
    0.03430085f, 0.00899333f, 0.05986344f, 0.05445443f, 0.13632108f, -0.02773652f, 0.11445478f, 0.05628595f, 
    0.16313818f, 0.23124589f, -0.12082075f, 0.02970646f, 0.07670690f, 0.02931491f, -0.01980218f, -0.03159651f, 
    0.06438041f, 0.04532845f, 0.00094977f, 0.02075347f, -0.01235723f, 0.10844188f, -0.07048365f, -0.09324883f, 
    -0.06128239f, 0.01107823f, 0.04537109f, -0.15504950f, 0.09654886f, 0.10327617f, 0.11619519f, 0.04981736f, 
    -0.17827508f, 0.20919006f, 0.06443739f, -0.05816031f, 0.04301186f, 0.05809444f, 0.02389678f, 0.07085319f, 
    -0.12971076f, -0.03149905f, -0.04397581f, 0.03131912f, 0.16011710f, 0.27412385f, 0.19571801f, -0.08293644f, 
    -0.05475225f, -0.08724786f, -0.01448874f, 0.04145932f, -0.01113151f, 0.00999364f, 0.09195103f, 0.12537864f, 
    -0.26215237f, -0.13075426f, 0.08535700f, -0.18500154f, 0.08078150f, -0.01193728f, 0.02460620f, 0.00200179f, 
    0.02035355f, 0.06649452f, -0.02839280f, -0.01654154f, 0.04944559f, -0.07477329f, -0.18426380f, -0.10490154f, 
    0.16337727f, 0.09893864f, -0.10417489f, 0.02379010f, 0.20912704f, -0.00467713f, -0.05045556f, -0.02787557f, 
    -0.13908593f, -0.01887560f, 0.13999438f, -0.16654842f, 0.04438730f, 0.08435157f, 0.15035295f, -0.01387994f, 
    0.10175138f, 0.03668034f, 0.01581588f, 0.05500471f, 0.17780983f, 0.13987517f, -0.20439743f, 0.13148563f, 
    -0.01816816f, 0.01152701f, 0.01193144f, 0.02634043f, 0.01943750f, 0.11347245f, 0.11093780f, 0.04270399f, 
    -0.06874397f, -0.01484843f, 0.00590352f, -0.04340114f, 0.07531314f, 0.08449948f, 0.00206781f, -0.04243812f, 
    -0.03605026f, 0.00770948f, -0.04180490f, 0.00268383f, 0.07014423f, -0.23692362f, -0.02410257f, 0.10404201f, 
    -0.03192540f, 0.02585284f, -0.04822724f, 0.13232622f, 0.01121766f, 0.09897413f, 0.02962228f, 0.05876251f, 
    -0.09367859f, 0.10541913f, 0.08634081f, -0.28860590f, 0.00843071f, -0.06182666f, -0.05760055f, 0.01733331f, 
    0.08992689f, -0.04027721f, 0.04585855f, 0.00117105f, 0.29535478f, -0.11143842f, -0.06890628f, -0.04171901f, 
    -0.01547329f, 0.04764464f, 0.03074236f, -0.01186642f, 0.00111958f, 0.12543026f, 0.05404427f, 0.01099762f, 
    0.13525905f, -0.18681894f, 0.09115181f, -0.12010464f, 0.00795177f, -0.06375088f, 0.14699306f, 0.08696740f, 
    -0.00695169f, -0.02858912f, -0.05336494f, 0.02830137f, 0.34764424f, -0.00215008f, -0.07954007f, 0.19582404f, 
    0.02974508f, 0.06524467f, -0.06371736f, 0.06976185f, 0.10155076f, 0.06257340f, 0.00418402f, 0.02584133f, 
    0.06662162f, 0.01382308f, 0.04765218f, -0.06325714f, -0.04968264f, -0.00543138f, 0.08039808f, 0.02897651f, 
    -0.00043196f, 0.06876629f, -0.04382569f, 0.03876012f, 0.09014670f, 0.10412768f, 0.17399600f, -0.04629030f, 
    -0.06663620f, 0.00215883f, 0.01908291f, -0.04278737f, 0.07787846f, 0.01564069f, 0.01768693f, 0.15417898f, 
    0.01973577f, -0.25781739f, -0.04986988f, 0.04346181f, 0.01257512f, -0.02393186f, -0.08633769f, 0.01928384f, 
    -0.03254608f, -0.06926417f, 0.05684882f, 0.01982244f, -0.01831278f, 0.07728111f, -0.02669209f, 0.02887883f, 
    -0.02180715f, 0.03652710f, -0.09959006f, 0.04727269f, 0.10267203f, 0.06596760f, 0.00911067f, -0.03528129f, 
    0.19658329f, 0.03135404f, -0.01754076f, 0.03148765f, -0.04549359f, 0.03660346f, -0.00379340f, -0.02579028f, 
    0.13751335f, 0.00741493f, 0.02512538f, 0.22522053f, 0.15635374f, 0.12626554f, -0.11713738f, -0.19412254f, 
    0.11014417f, 0.11168893f, -0.09314012f, 0.12938914f, 0.06179739f, 0.07162774f, -0.06638235f, 0.07564967f, 
    0.02789324f, 0.01011506f, 0.02236239f, -0.03536753f, 0.05763837f, 0.00850412f, 0.13361204f, -0.06826445f, 
    0.03287264f, 0.09604065f, 0.06302609f, 0.00139545f, 0.18636462f, -0.02045187f, -0.04769286f, -0.18279251f, 
    -0.01930902f, 0.05476585f, 0.04394855f, -0.01626716f, 0.10444295f, -0.00346603f, -0.05937659f, 0.12888767f, 
    -0.08878874f, -0.04883926f, 0.04588321f, -0.20934819f, 0.01623782f, 0.10940596f, 0.01600227f, -0.02853935f, 
    -0.01333964f, 0.01999205f, -0.01687464f, -0.06892262f, 0.12313608f, 0.00160999f, 0.06482327f, 0.16517493f, 
    -0.15842900f, -0.03653555f, 0.03605092f, -0.06647798f, -0.00364497f, 0.04224721f, 0.05567842f, -0.01395549f, 
    -0.02398872f, 0.03767072f, -0.04855978f, -0.11951574f, 0.00380156f, 0.04618804f, -0.05829096f, 0.03134255f, 
    -0.04834507f, -0.05169402f, -0.10155155f, -0.00771646f, 0.01905093f, 0.33439809f, 0.21710089f, -0.10726258f, 
    -0.00094875f, -0.04228114f, 0.01474872f, 0.02706694f, -0.01610656f, 0.00202071f, 0.09266831f, 0.24469034f, 
    0.15364201f, 0.08981676f, -0.02735599f, 0.04332872f, 0.17753796f, -0.04716290f, -0.02490395f, 0.06254294f, 
    0.12551709f, -0.03397492f, -0.00381185f, -0.09085523f, -0.14334315f, 0.26209363f, 0.00133224f, -0.15867122f, 
    0.01156233f, -0.00487530f, 0.00285898f, 0.00022987f, -0.11327989f, -0.02377412f, -0.01320748f, -0.08644316f, 
    -0.02222708f, 0.19378209f, -0.22473308f, -0.13912371f, 0.02632427f, 0.07962880f, 0.08611102f, -0.01373220f, 
    -0.02633655f, 0.05708966f, -0.07114318f, -0.07001451f, 0.24324547f, -0.21669793f, 0.16266014f, 0.12680756f, 
    -0.08251749f, 0.00546126f, -0.02346946f, 0.03062755f, -0.13766041f, 0.00063439f, 0.01909812f, -0.02309590f, 
    0.03423981f, 0.01291061f, 0.01266341f, 0.19605057f, -0.07317479f, -0.03484985f, 0.00044589f, 0.09357729f, 
    0.01915942f, 0.03110105f, 0.00378598f, -0.06744284f, -0.14152288f, -0.02002033f, 0.13729273f, 0.02086356f, 
    0.04938224f, -0.03887029f, 0.02809072f, 0.12117773f, -0.03844444f, 0.02653447f, -0.03032242f, 0.07208610f, 
    -0.21394639f, 0.19818203f, -0.02266148f, 0.07883681f, -0.01289314f, -0.08921779f, 0.10144830f, -0.06105992f, 
    -0.03846772f, -0.02044050f, 0.02422677f, -0.03467182f, 0.30475575f, 0.28831911f, -0.00103670f, 0.06721065f, 
    -0.08755245f, 0.03614866f, -0.01160304f, -0.05877697f, 0.03025776f, 0.09728017f, 0.06150604f, 0.11116984f, 
    0.02735335f, -0.09482984f, 0.14738788f, -0.17302369f, -0.00107974f, -0.02070948f, 0.00747697f, 0.13265458f, 
    0.02204137f, 0.02916993f, 0.03621167f, 0.11092298f, 0.02138123f, 0.10502939f, 0.00211279f, 0.10729875f, 
    -0.06777520f, 0.02132133f, 0.06685678f, 0.00992673f, -0.05698092f, 0.05468683f, 0.04612480f, -0.07989091f, 
    -0.16315252f, -0.06907536f, 0.08582558f, -0.18112725f, 0.10714106f, -0.02914117f, 0.18232070f, -0.02494333f, 
    -0.02728279f, -0.00668987f, 0.06651222f, 0.03419462f, 0.40207627f, 0.04613701f, -0.13923112f, -0.07204536f, 
    0.03561246f, 0.05564372f, -0.01648750f, -0.04194041f, 0.01900537f, 0.06877647f, 0.01645194f, 0.06632509f, 
    0.16408570f, -0.05382502f, -0.05790194f, 0.05619476f, 0.13986686f, 0.08178115f, -0.05587615f, -0.01490534f, 
    0.03786123f, 0.12926134f, -0.00675079f, 0.00786252f, 0.16512881f, -0.06090303f, -0.11829341f, -0.05987263f, 
    0.01627216f, 0.10044537f, -0.06276280f, 0.00023998f, 0.00512700f, -0.00120603f, -0.02520643f, -0.02557275f, 
    -0.08116353f, 0.25657824f, -0.04272876f, -0.09015074f, 0.00501566f, -0.11086657f, 0.01780843f, -0.13879380f, 
    -0.02293552f, -0.06129380f, -0.04281569f, -0.01143855f, -0.09537756f, -0.07939889f, -0.08748903f, -0.07184087f, 
    -0.04635143f, 0.17149889f, -0.01258647f, -0.14314047f, 0.05524685f, 0.03604222f, 0.14728566f, -0.04027316f, 
    0.02189074f, 0.10318509f, -0.06112854f, 0.03920322f, 0.01419802f, 0.07819797f, 0.10793898f, 0.20914504f, 
    -0.05509476f, 0.02165052f, -0.04427447f, 0.12245172f, -0.23054941f, 0.05219391f, 0.02888108f, 0.04074385f, 
    0.00000286f, 0.08842900f, -0.00162249f, 0.06182859f, 0.03795130f, -0.02626638f, -0.00923986f, -0.10496777f, 
    0.15579790f, -0.05744088f, -0.09126260f, 0.00840850f, 0.00575943f, 0.02276134f, 0.01900616f, 0.02955226f, 
    0.01278067f, -0.06374856f, 0.04155666f, -0.00484978f, 0.11427938f, -0.02949491f, 0.11883271f, 0.00613304f, 
    -0.00532347f, 0.10891768f, 0.05305083f, -0.02940283f, -0.00096864f, -0.05800781f, 0.04769517f, -0.02309020f, 
    0.22604987f, 0.08667211f, -0.03564342f, 0.07591950f, -0.05452383f, -0.07589352f, 0.06309149f, 0.04493588f, 
    -0.11328240f, 0.02458174f, 0.01467151f, -0.02852834f, 0.12620576f, 0.04977309f, -0.03027648f, -0.17740029f, 
    0.05247495f, 0.10809264f, -0.06734234f, -0.00682138f, 0.05889184f, -0.01507606f, 0.08689261f, 0.02680562f, 
    -0.04009252f, 0.22827856f, 0.09525211f, 0.07518799f, 0.00356742f, 0.05759001f, 0.01148075f, 0.08097036f, 
    -0.13524929f, -0.01020634f, -0.10588275f, 0.26673219f, 0.00769782f, 0.03301710f, 0.01134490f, 0.09745072f, 
    -0.10258724f, 0.00254148f, 0.02137189f, 0.02967586f, -0.00886367f, 0.07459972f, 0.13737129f, 0.06321336f, 
    0.12878545f, 0.00307877f, 0.17323065f, -0.27043000f, -0.13240182f, -0.12051439f, 0.04947663f, -0.03812321f, 
    -0.01179444f, 0.05167893f, 0.07176309f, 0.02521507f, -0.14136286f, 0.21513224f, -0.07388882f, -0.03076313f, 
    -0.05044275f, -0.04524864f, -0.01912591f, 0.01720544f, -0.05413046f, 0.05431662f, -0.13064125f, 0.03802918f, 
    -0.10165200f, 0.24137785f, 0.01495926f, -0.05306304f, -0.01639578f, 0.04029081f, -0.00971082f, 0.05331706f, 
    0.05003270f, 0.09291320f, -0.02649951f, 0.05842356f, 0.14200304f, -0.04857956f, 0.05266830f, -0.09158517f, 
    0.04548934f, -0.09835017f, -0.04925834f, -0.08126350f, -0.00529836f, 0.00879149f, 0.12915820f, 0.03303692f, 
    0.23403929f, -0.02546889f, -0.11285145f, 0.10375323f, 0.01127931f, 0.11000604f, 0.11728156f, 0.06273968f, 
    0.00931334f, 0.00428809f, 0.04818706f, -0.00866404f, -0.18137093f, -0.12481479f, -0.08396102f, 0.29815263f, 
    0.06490875f, 0.00763114f, 0.05044465f, -0.05470388f, 0.08156732f, 0.03820991f, -0.03785871f, 0.04126369f, 
    0.34226817f, 0.06195651f, -0.05153733f, 0.12429328f, 0.05042475f, 0.03475269f, 0.05229307f, -0.01936049f, 
    0.02030212f, 0.05657406f, -0.03926051f, -0.00028229f, 0.19405739f, 0.04439517f, 0.19358838f, -0.13505831f, 
    -0.10102588f, -0.10022083f, 0.04766613f, 0.10766528f, 0.00616429f, 0.10844925f, -0.05706348f, 0.10144877f, 
    0.01473936f, 0.16987266f, -0.16901188f, 0.12506980f, -0.03431159f, 0.12873004f, 0.06951946f, -0.09675262f, 
    0.01399260f, 0.02103544f, 0.05313323f, -0.13981616f, 0.10194734f, -0.08822848f, 0.06145805f, -0.05115111f, 
    0.05889360f, 0.03974538f, -0.10627455f, 0.09765954f, -0.00750274f, 0.04336797f, -0.12651305f, 0.12016527f, 
    0.22188094f, -0.26502705f, 0.00972336f, 0.03713382f, -0.01838022f, 0.01727667f, 0.04914210f, 0.07841889f, 
    0.08725083f, 0.11540554f, 0.13136432f, 0.06481265f, -0.06314246f, 0.05929987f, 0.11222164f, -0.19252947f, 
    0.11375716f, -0.03260244f, -0.11454950f, -0.07988146f, 0.09694495f, 0.00766789f, 0.02002025f, 0.04837263f, 
    -0.13675466f, 0.25266466f, 0.16658612f, 0.07255894f, -0.11498981f, 0.02345402f, 0.08524212f, -0.06144093f, 
    0.04688551f, -0.04122202f, 0.15133543f, 0.03993102f, -0.00674866f, 0.05208180f, 0.24764559f, -0.12627538f, 
    -0.04152780f, 0.02404582f, 0.04762258f, -0.01000861f, -0.11861058f, 0.19408053f, -0.12483952f, -0.06722897f, 
    -0.09717749f, -0.12166215f, 0.15923636f, 0.08094269f, 0.09564335f, 0.00437540f, 0.11738050f, 0.09615525f, 
    0.01310727f, 0.01353287f, -0.00399499f, -0.05483149f, -0.03006796f, -0.08732130f, -0.05850073f, -0.05067174f, 
    0.13275976f, 0.04753070f, 0.05110843f, 0.06000421f, -0.01410183f, -0.13672872f, -0.02820472f, 0.03946659f, 
    -0.00106404f, 0.00011957f, 0.00469090f, -0.02061297f, 0.01475359f, 0.02604236f, 0.01179887f, -0.00396174f, 
    -0.01612303f, -0.00510125f, 0.01708062f, -0.00391647f, -0.04042348f, -0.03304767f, -0.03044575f, -0.00053568f, 
    -0.00447730f, 0.02878200f, -0.00160650f, -0.00151401f, 0.00814239f, -0.03995906f, -0.02916340f, -0.04097308f, 
    -0.03090784f, 0.01271701f, -0.02575582f, -0.03343974f, -0.00359559f, -0.01108058f, -0.01801896f, 0.00306191f, 
    0.01885308f, -0.00858103f, -0.03084350f, -0.00422468f, -0.00021830f, 0.02407716f, 0.01636518f, -0.02798091f, 
    -0.02294518f, -0.01642876f, -0.00786082f, 0.01190799f, 0.02769490f, -0.01240286f, 0.00899568f, -0.03293006f, 
    -0.01706729f, -0.03724780f, -0.00547202f, -0.02207762f, -0.02394034f, -0.01073369f, -0.02444265f, 0.01414679f, 
    0.02817119f, 0.00004267f, -0.00520953f, -0.03096431f, 0.00305526f, 0.01892361f, -0.03867548f, 0.00201122f, 
    -0.00746262f, 0.02096909f, -0.00248577f, -0.00362553f, 0.02569749f, 0.01194517f, -0.03778732f, 0.00246068f, 
    0.02003770f, -0.00705042f, 0.02559385f, -0.01304348f, -0.02654574f, -0.03613165f, -0.00447305f, -0.01809321f, 
    -0.03577779f, 0.01117063f, -0.00360370f, 0.03101524f, -0.00084513f, 0.00904754f, -0.03533619f, -0.02433838f, 
    -0.03113763f, -0.03616366f, -0.03699542f, -0.03132920f, -0.00499392f, 0.01215673f, -0.02964580f, -0.02420663f, 
    0.02687086f, -0.03865412f, 0.03216846f, 0.01196196f, -0.00283667f, 0.01980770f, -0.02197687f, 0.01525632f, 
    -0.00572916f, 0.00111851f, -0.00954653f, 0.02109368f, -0.04139570f, 0.02128230f, -0.00715157f, 0.02508588f, 
    0.02084640f, -0.02132516f, -0.01726746f, -0.03360492f, -0.00209524f, -0.01609899f, 0.02266754f, -0.01392918f, 
    -0.03104370f, -0.03826021f, -0.02788125f, -0.01479877f, -0.03674551f, 0.00458260f, -0.01665628f, 0.02473835f, 
    -0.02252908f, -0.00997753f, 0.02940368f, -0.01625854f, -0.03435148f, -0.02746723f, -0.01178958f, -0.02591400f, 
    -0.02992772f, -0.04212711f, 0.00835938f, 0.02477800f, -0.02536828f, -0.03269613f, -0.00268290f, -0.02415744f, 
    -0.03526901f, -0.02576233f, -0.02465095f, -0.01690008f, -0.02922411f, 0.02638317f, -0.04121974f, -0.01859456f, 
    0.02848097f, 0.03267759f, 0.02529027f, -0.01130938f, -0.01395487f, 0.02119301f, -0.01118548f, -0.02525679f, 
    -0.00776009f, -0.00404904f, -0.01439124f, -0.03746291f, 0.00323799f, -0.03633697f, -0.03490917f, -0.02586379f, 
    -0.02520672f, -0.02219981f, -0.00759681f, 0.02750425f, 0.00341728f, 0.01033227f, -0.02891443f, -0.03454690f, 
    0.02361884f, -0.00030129f, 0.00884068f, 0.00860812f, -0.00328506f, 0.02326385f, -0.01114919f, 0.02336300f, 
    -0.00187759f, 0.00828974f, 0.01194868f, -0.02745556f, 0.02145040f, -0.00496618f, 0.00738605f, -0.02066324f, 
    0.02091826f, 0.01799957f, 0.02445584f, -0.01970581f, 0.01075542f, -0.02330032f, -0.00601824f, -0.03036910f, 
    -0.00280862f, -0.01715676f, -0.02751074f, 0.02497338f, -0.02130756f, -0.03535679f, -0.01950600f, 0.01799893f, 
    -0.01355999f, 0.00145463f, -0.02211374f, -0.01768625f, -0.02605819f, -0.04078795f, 0.01968743f, -0.03703826f, 
    -0.01146630f, -0.03492672f, 0.00511079f, 0.00427119f, 0.00680871f, -0.02825712f, -0.01224591f, -0.01617469f, 
    -0.01380477f, -0.03385620f, -0.03771320f, 0.00538820f, -0.00748955f, -0.02767922f, -0.02638443f, 0.00331147f, 
    -0.02566354f, 0.01531992f, 0.03614310f, 0.00219291f, 0.01716446f, 0.00077424f, -0.01036101f, -0.03088866f, 
    -0.00446056f, 0.01076025f, -0.01429786f, -0.00010019f, 0.01751401f, -0.01580007f, 0.01043450f, -0.03199493f, 
    -0.04183183f, 0.00316077f, 0.00693051f, 0.02321520f, -0.02067611f, 0.02948653f, -0.02963344f, -0.02343820f, 
    -0.02966307f, 0.01187209f, -0.01304251f, 0.00483076f, -0.01504253f, -0.01540083f, 0.01675345f, 0.00470838f, 
    -0.02309599f, -0.00383851f, -0.01265471f, -0.00198326f, 0.01564284f, 0.00790851f, -0.02590425f, 0.00630789f, 
    0.00108994f, -0.02879279f, -0.01068339f, -0.02291364f, -0.02035698f, -0.03788291f, 0.00469407f, 0.00701724f, 
    0.00616185f, -0.01146916f, 0.00603039f, 0.00295306f, -0.00010843f, 0.02718838f, -0.00053991f, 0.00303457f, 
    -0.00110260f, 0.02846475f, 0.00969681f, 0.01216389f, 0.04115126f, 0.01749763f, 0.01766718f, -0.00411434f, 
    0.00022610f, -0.03801266f, 0.02158302f, 0.01387505f, -0.02580148f, 0.00621622f, -0.01777375f, 0.01615554f, 
    0.01585604f, -0.00079935f, 0.00820825f, 0.02457973f, 0.00178053f, -0.01963779f, 0.00781184f, 0.00424272f, 
    -0.03456204f, 0.01222711f, -0.01230605f, -0.01544595f, -0.02082735f, -0.00580244f, 0.00379975f, -0.00388839f, 
    -0.02311132f, -0.01671489f, -0.03964032f, -0.03022233f, 0.01992189f, -0.02526192f, -0.00952214f, -0.00050282f, 
    0.02370218f, 0.01854924f, -0.01839199f, 0.02206362f, -0.01424476f, -0.01234270f, 0.01434065f, -0.03852069f, 
    -0.00459146f, -0.01912924f, -0.02977653f, -0.00871661f, -0.03004059f, 0.00959477f, -0.00566235f, -0.01086092f, 
    -0.03995528f, 0.02696218f, -0.03874038f, -0.00034268f, 0.00583702f, -0.01776301f, 0.01045621f, -0.01590538f, 
    0.02034897f, 0.02777648f, 0.03140138f, -0.01531116f, -0.03617268f, -0.00880305f, -0.04300348f, 0.03741340f, 
    -0.00122641f, -0.03531915f, 0.01556731f, 0.00640066f, -0.01061121f, 0.01293076f, 0.00561413f, 0.01468568f, 
    -0.00744010f, -0.03917135f, 0.02573607f, 0.01845304f, -0.03178361f, -0.02675113f, -0.03805785f, -0.02609958f, 
    -0.03874535f, -0.00225384f, 0.02900266f, -0.04012428f, -0.01181004f, -0.00460793f, 0.00055442f, 0.00295005f, 
    0.02014640f, -0.03833916f, 0.02182486f, 0.01335013f, 0.02449941f, -0.03449164f, -0.03476780f, -0.01757269f, 
    0.01903816f, 0.02294116f, -0.02893183f, 0.02293928f, 0.01047909f, 0.01097306f, -0.00183531f, 0.00085231f, 
    0.01286948f, 0.01211654f, -0.03374011f, 0.02458568f, 0.00388843f, -0.02343058f, 0.01108779f, 0.00492049f, 
    0.00996818f, 0.00836629f, -0.02491599f, -0.00681095f, -0.00803909f, -0.00121601f, -0.01046655f, 0.00312670f, 
    0.02281542f, -0.02825757f, -0.01902938f, 0.00703741f, -0.00212164f, -0.00177664f, 0.00397557f, 0.01176871f, 
    0.00926546f, -0.02324506f, -0.01113857f, 0.00819661f, 0.00734531f, 0.01606121f, -0.00306713f, -0.04045453f, 
    0.01707969f, -0.02689728f, -0.03517434f, -0.00179536f, 0.02424080f, -0.00304377f, 0.00220945f, 0.00613074f, 
    0.01726145f, -0.03238129f, -0.02615495f, 0.01487299f, 0.02801868f, 0.01350699f, -0.00597363f, -0.02342300f, 
    -0.02903158f, -0.02819908f, 0.00113417f, -0.02566200f, 0.02222722f, 0.00197649f, 0.03105997f, 0.00970146f, 
    -0.03331956f, -0.01687325f, 0.01295662f, -0.00719679f, 0.01691867f, -0.01659240f, -0.03000144f, 0.01749100f, 
    0.01589271f, 0.01132524f, -0.00800076f, -0.04312525f, 0.02654761f, -0.00414385f, 0.00731815f, -0.03195121f, 
    -0.01558648f, 0.02973493f, -0.02088699f, 0.03094943f, 0.01285535f, -0.01653963f, -0.01988867f, 0.01851251f, 
    0.00054500f, -0.00087131f, -0.01168741f, -0.01615639f, -0.00783788f, -0.03448587f, 0.02615063f, 0.00286414f, 
    -0.01014399f, 0.01130348f, 0.01255564f, -0.03191279f, -0.02252638f, 0.00536911f, 0.02416130f, -0.02902541f, 
    -0.03093437f, -0.00965442f, -0.00210381f, -0.01486400f, -0.04230878f, 0.02475645f, 0.01196337f, 0.01557621f, 
    -0.02835743f, 0.01585590f, -0.02065532f, -0.01054379f, -0.03494469f, 0.00923906f, -0.04122212f, -0.01884011f, 
    -0.04115534f, -0.01098286f, -0.01956000f, 0.02852425f, 0.00501276f, -0.02475843f, -0.00291870f, -0.03343518f, 
    0.01794814f, -0.02017819f, 0.01788986f, -0.03662720f, -0.02759005f, -0.00590717f, 0.00697279f, -0.00125005f, 
    -0.00466992f, 0.02315614f, -0.01932502f, 0.02882059f, -0.01501146f, -0.00642227f, 0.00141936f, -0.03200467f, 
    0.02817147f, 0.00109249f, 0.00901996f, -0.00085021f, -0.03216006f, -0.02246423f, -0.01938956f, -0.00773284f, 
    0.02580528f, -0.03437029f, -0.02103560f, 0.01016496f, 0.00911735f, -0.03524454f, -0.03863841f, 0.00466945f, 
    -0.00339708f, 0.02710630f, 0.01027480f, 0.03731763f, -0.01988585f, -0.03234854f, 0.02709395f, -0.01474986f, 
    0.01376737f, -0.01677988f, 0.03492860f, 0.01599606f, 0.01892653f, -0.00321619f, -0.01323563f, 0.00951937f, 
    0.00008605f, -0.00247807f, 0.00142913f, -0.01550639f, 0.02475201f, -0.02669101f, 0.01934699f, -0.00570324f, 
    -0.03058285f, 0.02422242f, -0.00879148f, -0.03667720f, 0.01916922f, -0.01164018f, -0.00605455f, -0.01424322f, 
    0.00766633f, 0.01144586f, -0.03879588f, -0.03825654f, 0.00062297f, -0.01043803f, -0.03282779f, -0.03782638f, 
    -0.04044858f, 0.01310259f, 0.00089700f, 0.01019117f, -0.02301484f, -0.01921788f, -0.02754343f, 0.02634000f, 
    -0.03548168f, -0.00078894f, 0.02878113f, -0.01723728f, 0.01845095f, -0.01882895f, 0.02155268f, -0.03875280f, 
    0.01933895f, -0.00866732f, -0.02404304f, 0.01098018f, -0.03184235f, 0.02452224f, -0.02581709f, 0.00791459f, 
    -0.03991172f, -0.01603217f, -0.04047535f, 0.02709861f, -0.03433326f, 0.00108075f, -0.02142777f, 0.00538263f, 
    -0.03071827f, 0.01174420f, 0.02726492f, 0.02400984f, -0.02341568f, -0.03984477f, -0.02813770f, -0.02758848f, 
    0.01138362f, -0.03310218f, -0.00124227f, -0.03970887f, -0.02698389f, -0.01161337f, -0.00276945f, 0.00535051f, 
    -0.00339617f, 0.01422225f, 0.02115623f, -0.00251699f, -0.03406769f, -0.03830327f, -0.00507183f, -0.03636189f, 
    0.01249700f, -0.01943811f, -0.01669375f, -0.02523251f, -0.01347006f, -0.00019592f, 0.02733019f, -0.00913083f, 
    0.02633245f, 0.00155651f, 0.03617847f, 0.01591779f, -0.04214628f, -0.01404641f, -0.01439360f, -0.00361493f, 
    0.00415702f, -0.03567714f, -0.02407748f, 0.02124686f, -0.01399551f, -0.02546861f, 0.00899353f, 0.00403020f, 
    0.00907743f, -0.02407599f, -0.02915935f, -0.00226921f, -0.01891981f, 0.00838276f, -0.00222002f, -0.02079790f, 
    0.02945159f, -0.00131262f, 0.00478293f, 0.00029207f, -0.00965264f, -0.01205139f, 0.01125369f, -0.01646451f, 
    -0.02108783f, 0.01351206f, -0.02039275f, 0.00639603f, -0.02000689f, 0.02256154f, 0.00116629f, 0.00581306f, 
    0.01069390f, 0.00340961f, 0.02177109f, -0.03040101f, -0.04080601f, -0.02139322f, 0.01004955f, -0.00513532f, 
    0.02295235f, -0.01095333f, -0.02190208f, -0.03305209f, 0.00288080f, -0.00227214f, -0.03095273f, -0.03584497f, 
    -0.00098662f, 0.02193659f, -0.01438043f, 0.03258841f, -0.01053559f, -0.00049393f, 0.01160574f, 0.00580865f, 
    -0.03482013f, -0.00240808f, -0.01869151f, 0.01584967f, -0.01882742f, -0.01083675f, -0.00368872f, -0.03921368f, 
    -0.01426438f, 0.00480641f, 0.01482827f, -0.01563206f, 0.00815070f, -0.02545140f, -0.02672664f, -0.00489675f, 
    0.01772592f, 0.02119880f, -0.02492610f, 0.00943757f, -0.02321034f, 0.01013557f, -0.02812070f, 0.00569397f, 
    -0.03600473f, -0.00268196f, -0.02627147f, 0.01290726f, -0.02173002f, 0.00840202f, -0.00053592f, -0.00203467f, 
    -0.03884003f, 0.00673373f, -0.00331746f, 0.00426171f, 0.02869923f, -0.02811784f, -0.03878446f, -0.01115671f, 
    0.02738976f, 0.02101332f, -0.03856903f, -0.02019662f, 0.00440907f, 0.01419669f, -0.00556387f, -0.01554382f, 
    0.08002628f, 0.00182177f, 0.16994165f, 0.06417625f, -0.03034386f, -0.05566029f, -0.02369278f, 0.00572533f, 
    0.06401236f, -0.00537622f, 0.00851552f, 0.05951778f, -0.10281320f, -0.23779127f, -0.04356400f, 0.18622006f, 
    -0.11413990f, 0.00485002f, 0.02996417f, -0.06453940f, -0.03843674f, -0.00489236f, -0.00053452f, 0.06639700f, 
    0.29341054f, 0.12838233f, -0.01414250f, -0.08745398f, -0.04911318f, -0.00260511f, 0.06693766f, -0.05133158f, 
    -0.04681230f, -0.02114618f, 0.02719126f, 0.04045363f, 0.16117805f, 0.22381620f, -0.14282572f, 0.20576565f, 
    0.08303186f, -0.09048870f, 0.06843139f, 0.08539977f, -0.07868104f, 0.09394073f, 0.08545365f, -0.07057479f, 
    0.32437623f, -0.07850824f, 0.17301436f, 0.32213998f, 0.06762853f, 0.03876143f, -0.02915810f, 0.00089538f, 
    0.00319532f, 0.04543196f, 0.03608582f, -0.02211796f, 0.22650768f, -0.01604759f, 0.15495782f, 0.16229026f, 
    0.02457790f, 0.03641691f, -0.08629074f, 0.05529646f, -0.00880403f, 0.02402915f, -0.04920353f, 0.10937779f, 
    0.26758438f, -0.04281809f, 0.11231402f, 0.39141589f, 0.18097988f, 0.03033997f, 0.07323902f, 0.19931877f, 
    0.01895431f, 0.05587417f, 0.10350981f, -0.07811923f, 0.08968214f, 0.05708353f, -0.04148960f, 0.16898291f, 
    0.15657197f, -0.05269935f, 0.07898892f, -0.04856525f, 0.10807428f, -0.05796375f, 0.01943730f, 0.00144998f, 
    -0.10329989f, -0.12401418f, 0.02848892f, -0.11660285f, -0.06084890f, -0.00021320f, -0.05341581f, -0.02314870f, 
    0.06037243f, -0.01163850f, -0.08193233f, -0.00631229f, -0.06411325f, 0.28819862f, 0.07077851f, -0.04369837f, 
    0.12245709f, -0.02360951f, 0.01262457f, 0.03895406f, 0.06865439f, 0.00316744f, 0.08829237f, -0.02818657f, 
    0.06602627f, -0.10929692f, 0.11864369f, 0.06252351f, 0.07431965f, -0.03113763f, 0.01397735f, -0.13042937f, 
    -0.09724522f, 0.08848377f, -0.02277990f, -0.07015523f, -0.12309416f, -0.00219148f, 0.10893717f, 0.01123337f, 
    0.07588430f, -0.12540871f, 0.13117446f, 0.05424651f, 0.07559687f, -0.00418001f, 0.03601793f, -0.00101686f, 
    -0.20408809f, -0.11919686f, -0.02303074f, -0.10081273f, -0.08995229f, 0.00887663f, 0.00080390f, -0.04835882f, 
    0.02149014f, -0.00656853f, 0.07344104f, 0.07848940f, -0.05524499f, -0.12098131f, -0.19762684f, -0.14655441f, 
    0.03230030f, 0.06973219f, -0.00193544f, 0.02677281f, -0.00675595f, -0.01735425f, 0.01099850f, -0.02915148f, 
    0.15385801f, -0.13513832f, 0.05436438f, 0.05971950f, 0.07319144f, 0.01610726f, 0.11539447f, -0.12123912f, 
    -0.00358389f, 0.03525212f, 0.01209770f, 0.07295068f, 0.02645345f, -0.00776489f, 0.05659521f, 0.10839653f, 
    0.05008121f, -0.07636027f, 0.05504813f, 0.03221294f, 0.01938541f, -0.02675364f, 0.06977193f, 0.02315685f, 
    -0.21848145f, 0.13011059f, -0.03974146f, 0.08852854f, -0.02666224f, 0.11229976f, -0.04880288f, 0.08715437f, 
    -0.04156832f, 0.05566839f, -0.05366357f, -0.06758105f, 0.14885564f, 0.06666955f, 0.20036329f, 0.10342237f, 
    0.07090879f, -0.04422911f, 0.07740232f, 0.03582649f, 0.06276630f, 0.12081474f, 0.03117810f, 0.03139640f, 
    0.23769385f, 0.09524567f, 0.07139183f, 0.21111102f, 0.02770679f, 0.00868435f, -0.04826822f, 0.03771939f, 
    0.01745909f, 0.05492062f, -0.05570778f, 0.06351244f, 0.15755032f, -0.09379436f, -0.07879715f, 0.01722641f, 
    0.02444573f, 0.01799717f, 0.05849027f, -0.00805177f, -0.03537837f, 0.10518169f, 0.03790139f, -0.01319246f, 
    0.20615767f, 0.19125202f, -0.01866509f, 0.09219795f, 0.13427322f, -0.02524743f, 0.02862573f, 0.10388847f, 
    -0.01270605f, -0.11373078f, 0.03283821f, 0.07170878f, -0.24516420f, 0.02698767f, -0.10228623f, -0.04607606f, 
    0.10423936f, -0.01223964f, -0.02316851f, 0.05259699f, 0.04910665f, 0.01509575f, -0.02046893f, 0.10591941f, 
    0.23554590f, 0.09473774f, 0.25479776f, 0.00127630f, -0.05908518f, 0.01819126f, 0.08049463f, -0.00384965f, 
    0.00380631f, 0.01370867f, -0.01576588f, -0.00677717f, -0.13962592f, -0.14046909f, 0.08724434f, 0.12265766f, 
    -0.07880474f, 0.01150637f, -0.02579676f, -0.11519150f, -0.03338120f, 0.10081322f, 0.01724735f, 0.00997125f, 
    0.09293105f, -0.06393638f, 0.17765379f, -0.04646285f, 0.10968961f, 0.13389714f, 0.06986923f, 0.05747942f, 
    -0.02732267f, 0.18786302f, -0.00538515f, 0.08427636f, -0.07588732f, -0.04031529f, 0.10405009f, 0.18840149f, 
    -0.06059539f, 0.10769995f, -0.01858962f, -0.07403585f, -0.01292646f, 0.00948562f, -0.04111825f, 0.00750978f, 
    0.13308913f, -0.01788514f, 0.22068287f, 0.02835262f, 0.01045643f, 0.03778956f, -0.00585791f, 0.04280259f, 
    0.09056914f, 0.03746532f, 0.05788877f, 0.04123784f, 0.10634823f, -0.11274280f, -0.10212665f, 0.19389437f, 
    0.15298146f, -0.00390478f, 0.01308661f, -0.05317485f, 0.05494733f, 0.00709610f, -0.02976340f, 0.02550190f, 
    0.28293023f, -0.23292884f, -0.10983632f, -0.11090887f, 0.06534639f, 0.03841644f, 0.00623386f, -0.06732228f, 
    0.05159903f, 0.05844228f, 0.04435250f, 0.11023486f, 0.02088321f, 0.00219067f, 0.01852281f, -0.01966474f, 
    -0.11120076f, 0.01042326f, 0.00690982f, -0.04452920f, 0.04910443f, 0.05493664f, -0.10112186f, 0.00251055f, 
    -0.14862397f, -0.17083919f, -0.10975784f, 0.06232037f, 0.00233176f, 0.05877875f, -0.11186445f, -0.03328115f, 
    0.07994392f, 0.01837837f, 0.02809145f, 0.04138383f, -0.44226477f, -0.11474965f, 0.03418839f, -0.00269233f, 
    -0.12932338f, 0.05667641f, -0.02151190f, 0.02365402f, -0.01495600f, -0.00549320f, -0.05432351f, -0.06124639f, 
    0.23432314f, -0.21329767f, -0.13917595f, -0.09897225f, -0.04145217f, 0.09413713f, 0.05649460f, -0.08650685f, 
    -0.03904733f, -0.06854428f, -0.06334335f, 0.02164293f, 0.34223199f, 0.04186974f, 0.17624697f, 0.20670675f, 
    0.01304336f, 0.03036942f, 0.02969187f, 0.04240993f, 0.02257864f, 0.00052702f, -0.01758059f, 0.07749427f, 
    0.16960865f, 0.04693075f, 0.08367417f, 0.24846795f, -0.00809352f, 0.04297927f, 0.05271027f, 0.07753344f, 
    0.04606597f, 0.03864681f, -0.02571644f, 0.10985932f, 0.02579957f, 0.07099859f, -0.01531234f, 0.01981684f, 
    0.11449424f, -0.07683732f, 0.05188020f, 0.10388026f, 0.09567849f, 0.00490617f, 0.12572871f, -0.03426706f, 
    -0.16259973f, 0.27996442f, 0.00069779f, -0.10065819f, 0.04072870f, 0.06780832f, 0.05797570f, 0.06929988f, 
    0.04222811f, -0.00873888f, 0.01227338f, 0.08204992f, 0.09233845f, 0.14187305f, -0.06892548f, -0.13994470f, 
    0.06177981f, 0.00668660f, 0.04892067f, 0.08245425f, 0.14869477f, 0.06709582f, 0.04676491f, -0.03410382f, 
    -0.29288623f, -0.37147456f, 0.04050537f, -0.09241325f, -0.06645273f, 0.14718412f, 0.00624716f, 0.07085465f, 
    0.07532303f, 0.03905685f, 0.00493238f, 0.04226257f, -0.21123451f, 0.11738640f, 0.03457530f, -0.03790255f, 
    -0.00002001f, 0.03323840f, 0.03472871f, 0.13521241f, -0.03290681f, 0.08270786f, -0.01803938f, 0.07027788f, 
    0.18670315f, 0.10363790f, 0.10095593f, 0.00020979f, 0.06098695f, -0.08605736f, -0.03242873f, 0.08200109f, 
    0.04990041f, 0.07108878f, 0.01601847f, 0.02660782f, -0.20650528f, -0.01449791f, 0.17654371f, 0.11848015f, 
    -0.05042640f, -0.08909006f, 0.11399237f, 0.05131800f, 0.01792492f, 0.04511533f, 0.00599864f, -0.00969553f, 
    -0.16590738f, 0.17664942f, -0.00166680f, -0.14237699f, 0.12002038f, 0.06320286f, -0.03599122f, 0.01281270f, 
    0.03433846f, 0.02597654f, 0.07491679f, -0.05123831f, -0.34723115f, 0.23783147f, 0.00810022f, -0.05431721f, 
    0.11384484f, 0.02668982f, 0.04135991f, 0.05245353f, -0.04988008f, 0.02382014f, -0.03679878f, -0.01304192f, 
    0.09907943f, 0.06261055f, 0.09481683f, 0.29825464f, 0.01753435f, 0.08712652f, -0.07669380f, 0.06534279f, 
    0.06343197f, 0.03445128f, 0.00276329f, 0.02123472f, 0.06446478f, 0.06475487f, -0.04902596f, 0.15653776f, 
    -0.02937418f, -0.06081379f, 0.03429606f, 0.14065771f, -0.01516083f, 0.05375619f, 0.01404199f, 0.08785906f, 
    0.14617918f, 0.00162378f, -0.00425162f, 0.22235498f, 0.00593648f, -0.07024671f, -0.01137783f, -0.09120436f, 
    0.11675519f, 0.04099394f, 0.00564739f, -0.01864822f, -0.08506595f, -0.05979190f, -0.08314811f, 0.01353085f, 
    0.00372614f, -0.00350136f, -0.01020231f, 0.04085227f, 0.08974727f, 0.08042294f, 0.03997657f, 0.08287238f, 
    0.05536938f, 0.01493068f, 0.08912934f, -0.00416065f, 0.09664936f, 0.01178080f, -0.05056686f, -0.00391699f, 
    -0.01582766f, -0.05538757f, -0.00547053f, 0.11515313f, -0.15824935f, -0.12197445f, 0.20570228f, -0.12170552f, 
    -0.04475203f, -0.00130032f, 0.02690200f, -0.01741604f, -0.02321314f, 0.05446389f, -0.01467449f, 0.00497315f, 
    0.06446913f, -0.13602880f, 0.05988438f, -0.11090251f, -0.13404301f, -0.08986701f, 0.07058844f, -0.01332903f, 
    -0.06506745f, -0.06480526f, 0.09659965f, 0.05861895f, -0.14374511f, -0.14768253f, 0.04945089f, -0.13609366f, 
    0.07031612f, 0.05124147f, 0.12965311f, 0.00212988f, 0.02185346f, 0.09982928f, -0.05567313f, 0.02147057f, 
    -0.17312776f, 0.05277181f, 0.18982239f, 0.02617404f, -0.01112130f, 0.01910147f, -0.12041704f, 0.03360591f, 
    -0.01982491f, 0.10862479f, 0.00473271f, 0.07443570f, -0.11619961f, 0.10595447f, -0.20032297f, 0.05318509f, 
    -0.11552019f, 0.06906995f, 0.03252614f, 0.09873028f, -0.04487766f, 0.16361974f, 0.06481934f, -0.03455599f, 
    -0.27040869f, 0.12770379f, -0.04042289f, -0.08350716f, 0.08811092f, 0.01975098f, 0.13533348f, 0.10365394f, 
    0.06827246f, 0.02365861f, -0.00658911f, -0.03311127f, 0.02856318f, -0.19668339f, 0.04800664f, 0.10620660f, 
    0.04344201f, -0.02055431f, -0.05214486f, -0.06243129f, 0.01924425f, -0.03072563f, 0.02134590f, 0.04251240f, 
    -0.08442977f, 0.26083568f, -0.01949622f, -0.09438066f, 0.00837326f, 0.07248993f, -0.05347376f, 0.19502766f, 
    -0.03188482f, 0.04324666f, -0.06114988f, -0.00291715f, 0.04920308f, 0.15785484f, -0.12865415f, 0.04526019f, 
    0.07379583f, -0.04740414f, 0.09234622f, 0.08401600f, 0.00098280f, 0.03986120f, 0.06598605f, -0.07872701f, 
    -0.33527210f, 0.22743726f, -0.02856704f, -0.19506837f, 0.07963269f, 0.05410162f, 0.09018284f, 0.13603923f, 
    0.01426755f, -0.06007135f, -0.02084578f, -0.03884626f, 0.07388750f, 0.09450689f, -0.03957319f, 0.08869174f, 
    0.08467362f, 0.05696530f, 0.12001781f, 0.02548600f, -0.04119994f, -0.00201554f, -0.03327871f, 0.03548203f, 
    0.21926931f, -0.11734933f, -0.04320490f, 0.18971281f, 0.18934606f, 0.08486350f, -0.01765413f, 0.05851812f, 
    0.02802813f, 0.02241055f, 0.02063619f, 0.07049898f, 0.18788439f, -0.04265964f, -0.11172376f, -0.09876470f, 
    0.15306967f, -0.02780634f, 0.10457358f, -0.02337869f, 0.06938104f, -0.13725080f, -0.00549060f, 0.09648467f, 
    0.08408730f, -0.09285871f, 0.08892910f, 0.04233579f, -0.01758917f, 0.01423136f, 0.05408173f, 0.08229981f, 
    0.03496992f, 0.00929306f, 0.00679753f, 0.07785939f, 0.27753726f, 0.00557721f, -0.03349736f, 0.21772949f, 
    0.06137080f, 0.00741107f, 0.07222412f, 0.02064082f, 0.02957820f, 0.05139706f, -0.12066348f, 0.03237076f, 
    -0.12132268f, 0.01427568f, -0.01863330f, 0.07651288f, -0.00451322f, 0.05802557f, -0.11195714f, 0.03869095f, 
    -0.00988417f, 0.02722126f, 0.05528335f, -0.12230124f, 0.07423315f, 0.11751011f, 0.11282392f, 0.08723366f, 
    -0.09077799f, 0.03374147f, -0.04761474f, -0.01778557f, 0.04472749f, -0.05987196f, -0.00159714f, -0.04744311f, 
    0.50298756f, 0.07312748f, 0.10080002f, -0.12397809f, -0.00835196f, -0.10645843f, 0.13170297f, -0.04526583f, 
    -0.03862789f, 0.08568475f, 0.01830441f, -0.08646019f, 0.00451855f, 0.07712495f, -0.21482578f, -0.01987430f, 
    -0.05309461f, -0.03396512f, 0.07813068f, 0.07402702f, -0.04471709f, 0.10361559f, 0.12188093f, -0.00883206f, 
    -0.14747460f, -0.05754223f, -0.12792191f, -0.10821278f, -0.07329498f, 0.00915865f, -0.05266089f, -0.02905707f, 
    0.08198796f, -0.01060775f, 0.07426192f, 0.04029300f, 0.04636882f, 0.16241375f, 0.10631055f, 0.10027359f, 
    0.01113713f, -0.04918678f, -0.06756020f, -0.08298770f, 0.04725584f, -0.08822794f, -0.06833506f, -0.03850340f, 
    0.00711655f, -0.09400817f, -0.30763021f, -0.11703963f, -0.09855448f, -0.05158424f, -0.04546472f, -0.00133801f, 
    0.06707109f, 0.10072622f, -0.07259773f, -0.00518039f, 0.13150449f, -0.15324832f, 0.02274706f, 0.01602915f, 
    0.05685812f, 0.03564924f, -0.01593637f, 0.08763697f, -0.00823474f, -0.09337416f, -0.07164843f, 0.04885391f, 
    -0.23122449f, 0.06136887f, 0.15722714f, -0.13716839f, 0.11473252f, -0.04396175f, -0.06455467f, -0.04209061f, 
    0.03988927f, -0.10056280f, -0.14395966f, -0.01046401f, 0.21979959f, 0.04398341f, 0.04168058f, -0.05558546f, 
    -0.13466939f, 0.05130083f, -0.00361063f, -0.02315165f, -0.02083059f, 0.06353129f, 0.02549311f, -0.03229045f, 
    -0.04912724f, -0.05057639f, 0.01379094f, -0.06665803f, 0.04423290f, -0.04923018f, -0.03240365f, -0.01745177f, 
    -0.00277819f, -0.08181609f, 0.12747222f, 0.03069807f, 0.34179106f, 0.38558030f, 0.11396094f, -0.10309978f, 
    0.10190129f, 0.09112274f, 0.05316796f, -0.06936004f, -0.00402740f, -0.10002635f, 0.05913604f, -0.07243840f, 
    0.06188536f, -0.02860384f, 0.05027643f, 0.02292459f, -0.08928569f, -0.07314366f, 0.09669737f, 0.16149062f, 
    0.04407992f, 0.01916248f, -0.03934068f, 0.00593363f, 0.13607003f, 0.05334719f, 0.18183634f, 0.00300539f, 
    -0.09963334f, 0.09633536f, 0.15584680f, 0.05925348f, 0.05582134f, -0.05345338f, 0.04520939f, -0.07328294f, 
    0.11539770f, -0.26792225f, 0.02002347f, 0.01940842f, 0.03731986f, -0.02341837f, -0.00610310f, -0.01514798f, 
    -0.10147089f, 0.01315985f, 0.04715502f, 0.00928961f, -0.07885145f, -0.05660718f, 0.18972473f, 0.00577972f, 
    0.06391706f, -0.02052785f, 0.05514413f, 0.08916324f, -0.05420507f, 0.01018975f, -0.10700373f, -0.00494813f, 
    -0.02388157f, -0.14005926f, -0.00452566f, -0.14852168f, 0.08897527f, 0.02537187f, 0.05827821f, 0.06058720f, 
    -0.00603667f, 0.11085165f, 0.00188788f, 0.15106162f, -0.33766392f, 0.10049225f, -0.06864543f, -0.01166528f, 
    0.07445076f, -0.04741891f, 0.12509802f, 0.06776898f, 0.03256518f, -0.02432653f, -0.06574592f, 0.13158897f, 
    0.18603671f, 0.11695462f, -0.08199073f, -0.04223615f, -0.04764217f, 0.09709288f, 0.15475309f, 0.00644034f, 
    -0.02180339f, 0.04917584f, 0.08003455f, 0.12763813f, 0.00026749f, 0.07488029f, -0.28363013f, -0.01338395f, 
    -0.07806444f, -0.03593782f, 0.16222544f, 0.00320189f, 0.02819154f, -0.12669489f, 0.05456906f, -0.02823601f, 
    0.11913586f, 0.06894184f, 0.04862097f, -0.04821375f, 0.04408193f, -0.08499401f, 0.02851713f, -0.12488522f, 
    0.08980419f, -0.05023948f, 0.01090590f, -0.06987706f, -0.03279812f, 0.01371789f, 0.07012791f, 0.03799884f, 
    -0.08025611f, -0.01724883f, 0.02354623f, 0.01426325f, -0.11066370f, 0.08056185f, -0.01475389f, 0.01462171f, 
    -0.24296872f, 0.28170753f, 0.01612927f, -0.14925663f, 0.02009562f, -0.11645544f, 0.03840447f, 0.12794954f, 
    0.04106003f, -0.07804947f, 0.06126343f, 0.06378666f, -0.13718563f, 0.04790046f, 0.09476180f, 0.24709833f, 
    0.05666116f, -0.02085943f, 0.11887437f, 0.01212947f, 0.09841499f, -0.15257272f, -0.06672059f, -0.00281084f, 
    0.42613310f, 0.00834370f, -0.14522737f, 0.23574904f, -0.07293522f, -0.06364425f, 0.00776896f, 0.05580322f, 
    0.10725603f, 0.01049503f, 0.00939654f, 0.01603741f, -0.31510475f, 0.18554769f, 0.00458394f, 0.14253443f, 
    0.06998043f, 0.00998878f, -0.06565776f, -0.00469343f, 0.00688934f, 0.12556121f, -0.07589983f, 0.11011485f, 
    0.06842319f, -0.16617337f, -0.11463463f, -0.00227467f, -0.05396355f, -0.04869759f, 0.07835530f, 0.00239078f, 
    0.05050914f, 0.06532834f, -0.04541444f, -0.00560596f, 0.35507691f, -0.06496513f, 0.03939361f, -0.02898755f, 
    -0.02017043f, 0.05190599f, 0.03696975f, 0.08811874f, 0.06141024f, 0.00436885f, 0.05828531f, -0.04561632f, 
    0.21071202f, -0.05374014f, -0.05930724f, -0.08284594f, 0.01571362f, -0.02752542f, 0.08796562f, 0.04596067f, 
    -0.01075370f, 0.00289230f, 0.01821861f, -0.04585547f, 0.12828557f, 0.14846370f, -0.10527299f, 0.04485431f, 
    0.06765704f, -0.06490562f, -0.10774220f, 0.07997876f, 0.01195659f, 0.04367302f, -0.00418078f, 0.11918164f, 
    -0.18117771f, -0.03600695f, -0.17616229f, 0.14948219f, -0.06472143f, 0.15844075f, 0.06626145f, 0.03236591f, 
    0.05820700f, 0.15319017f, -0.05175832f, 0.02124659f, 0.00283026f, 0.07186999f, 0.20826328f, 0.16384202f, 
    0.01148199f, 0.05017635f, 0.04276125f, 0.03571025f, 0.01349811f, 0.09119003f, -0.01622011f, 0.06638190f, 
    -0.07355785f, -0.17749757f, 0.01733608f, -0.13067967f, 0.02069341f, 0.04822328f, 0.06307134f, 0.07072794f, 
    -0.03960642f, -0.01454230f, 0.10716892f, 0.02361748f, -0.18969639f, 0.03379599f, -0.00698029f, 0.13278258f, 
    -0.07371283f, -0.01634627f, -0.06837475f, -0.01611038f, 0.05105135f, 0.07272249f, 0.06718300f, -0.03926944f, 
    0.07720441f, -0.26332003f, 0.01147615f, -0.13010134f, -0.00900628f, -0.02411214f, -0.04742070f, 0.00674328f, 
    -0.09645338f, -0.17184432f, 0.08209293f, 0.00333382f, 0.27674505f, 0.14820628f, -0.18439464f, 0.05216212f, 
    -0.09960835f, 0.04418603f, -0.06446973f, 0.01968053f, -0.10517658f, -0.03715443f, 0.01492820f, 0.01224529f, 
    0.03718064f, -0.00726274f, -0.08759683f, 0.05069727f, -0.01388114f, 0.10323624f, -0.00552113f, 0.11028700f, 
    0.04177866f, 0.00941041f, -0.05649265f, 0.00427386f, 0.20948291f, 0.24770620f, -0.12718187f, -0.11972782f, 
    -0.13863276f, -0.07434700f, 0.00089570f, -0.04109633f, -0.09390989f, 0.07750807f, -0.15421057f, -0.14911279f, 
    -0.20453122f, 0.02099902f, 0.03493981f, 0.05583152f, -0.09352256f, 0.02577920f, 0.11845063f, 0.17161286f, 
    0.06631543f, -0.05330374f, 0.01718128f, -0.01379482f, 0.02811520f, -0.08516848f, 0.16777150f, 0.12276576f, 
    0.10564229f, 0.10953691f, -0.00473107f, -0.06394996f, -0.02531751f, -0.00257009f, -0.03863949f, -0.03215101f, 
    -0.09571452f, 0.15004770f, -0.04343975f, -0.00418371f, -0.08226265f, -0.11044161f, 0.08083076f, 0.04876957f, 
    -0.04488601f, -0.03858609f, 0.09722476f, -0.12655339f, -0.37997559f, 0.04836967f, 0.03172757f, 0.08887903f, 
    0.03290428f, 0.06605051f, 0.01550173f, -0.03629076f, -0.06013608f, 0.07328936f, 0.00199571f, -0.07006820f, 
    -0.00014327f, 0.03035058f, -0.08848393f, -0.09290914f, -0.08413013f, 0.08603158f, -0.04861021f, 0.01112553f, 
    0.01801886f, -0.03165163f, 0.06393404f, -0.09411641f, 0.38925570f, 0.13228919f, 0.00979211f, -0.07016685f, 
    -0.07776421f, 0.15558711f, 0.03519311f, -0.00868084f, 0.03588488f, 0.12432788f, -0.07147668f, 0.00007558f, 
    0.03047826f, 0.27619690f, 0.00008397f, 0.10588939f, 0.06664963f, 0.05515583f, 0.00804498f, -0.05694059f, 
    -0.07958122f, 0.00765151f, 0.00212685f, 0.07699591f, -0.05410194f, 0.17159913f, -0.01601575f, 0.01151176f, 
    0.02998865f, -0.01100858f, -0.01128340f, -0.09421480f, 0.02830286f, -0.03884280f, 0.10712072f, 0.05048600f, 
    -0.05486892f, 0.07161595f, -0.03389654f, 0.03571487f, 0.02618913f, 0.16171765f, 0.02792517f, 0.02787352f, 
    -0.06611907f, -0.22391887f, -0.02334059f, -0.04980827f, 0.03765722f, 0.02806281f, 0.03029037f, 0.16133226f, 
    -0.11647709f, -0.05367808f, -0.03823114f, -0.02703686f, 0.07098971f, -0.01862915f, -0.04614451f, 0.04554858f, 
    0.23898561f, -0.06445264f, 0.21408381f, 0.07117771f, -0.02524194f, -0.00228436f, 0.03518582f, 0.04022202f, 
    -0.00937780f, -0.10991390f, 0.01544111f, 0.06560737f, -0.25856301f, 0.11415927f, -0.05348681f, -0.01078179f, 
    0.02149161f, -0.02281794f, 0.01882273f, 0.09927841f, 0.05193326f, 0.05635181f, 0.08421609f, -0.03751815f, 
    -0.21388087f, 0.07374875f, 0.01866758f, 0.01142292f, 0.05327036f, -0.15528987f, 0.06281475f, 0.07041686f, 
    0.02518468f, 0.04320158f, 0.05897152f, 0.01276825f, -0.20192958f, -0.10079022f, 0.13316154f, 0.08453229f, 
    0.03921848f, -0.07512455f, -0.04689923f, -0.01674315f, -0.04602958f, 0.09565171f, 0.09451547f, -0.09541998f, 
    -0.09212545f, 0.10584077f, 0.00116674f, 0.08422521f, 0.08280365f, -0.00537392f, 0.08882313f, 0.00551283f, 
    -0.09195958f, -0.21805401f, -0.17382146f, -0.08475065f, -0.06489200f, -0.30377465f, -0.01466659f, 0.00453599f, 
    -0.04666666f, 0.00461416f, 0.06537762f, -0.08206840f, 0.05296131f, 0.01999492f, -0.03429939f, -0.14541177f, 
    -0.03950483f, -0.08947384f, 0.00497074f, 0.12010841f, -0.04638899f, 0.06926219f, 0.14382088f, 0.18354197f, 
    -0.05367252f, -0.08865787f, 0.03444962f, 0.07577577f, 0.43446952f, -0.01188379f, 0.15410152f, -0.02257530f, 
    0.02489720f, 0.07224052f, -0.00059384f, 0.06059292f, 0.06992888f, -0.04351906f, 0.02838420f, 0.04668090f, 
    -0.15649629f, -0.00923302f, -0.05726172f, -0.15605614f, 0.00856347f, 0.04966367f, 0.03922111f, -0.11552370f, 
    0.05218309f, 0.10262179f, 0.08854611f, 0.17047067f, -0.04986965f, -0.04400117f, -0.02568724f, -0.03507451f, 
    -0.03865701f, 0.02118694f, 0.01782065f, 0.00934823f, -0.00400617f, -0.03987413f, -0.07839421f, 0.19771238f, 
    0.05286955f, -0.15804179f, -0.00666555f, 0.05397033f, -0.03562007f, 0.00924592f, -0.05887541f, 0.08252873f, 
    -0.04148759f, -0.07425944f, 0.18688443f, -0.11290457f, 0.18688539f, 0.11368302f, 0.05952951f, 0.07128947f, 
    -0.02476476f, 0.10032747f, 0.01577990f, -0.03251915f, 0.16948363f, 0.03141198f, -0.11474279f, 0.12130058f, 
    0.03404108f, -0.14101119f, -0.12949756f, 0.22450532f, -0.00703578f, 0.02360827f, -0.03842181f, -0.02148519f, 
    0.00142859f, -0.02099111f, -0.05756860f, -0.01011027f, 0.01184520f, -0.07133745f, 0.03428970f, -0.08901338f, 
    0.01481725f, 0.08541717f, 0.06760783f, 0.08852766f, 0.07116745f, -0.07723868f, -0.00065888f, 0.03974376f, 
    -0.09673627f, -0.18222196f, 0.09496573f, -0.01077237f, 0.08276026f, -0.00189007f, 0.12889123f, 0.11200996f, 
    0.04301256f, -0.08247711f, -0.06623083f, 0.01389458f, 0.07476813f, -0.21704230f, -0.19650395f, -0.09357870f, 
    -0.05603831f, -0.12644508f, -0.04747658f, 0.07673202f, 0.00233706f, -0.06646425f, 0.05959727f, 0.01362889f, 
    0.00480430f, 0.00616197f, 0.20201385f, 0.17849907f, 0.01373508f, -0.02163081f, -0.09006148f, -0.00208306f, 
    0.09676979f, 0.04259132f, 0.08487103f, 0.01472572f, -0.06994350f, -0.17269024f, 0.04187731f, -0.06933357f, 
    -0.06021693f, 0.09085132f, 0.03362780f, -0.04047874f, -0.03241864f, -0.01792094f, 0.00231251f, -0.00790804f, 
    0.27951992f, -0.18759443f, 0.19659068f, 0.21406883f, -0.00254244f, -0.01221173f, 0.03630982f, 0.08070657f, 
    -0.00990487f, -0.04460914f, 0.09830653f, -0.00258842f, -0.14484352f, 0.01052103f, -0.10308296f, -0.00404261f, 
    0.12324092f, 0.05312779f, 0.17519759f, 0.03833189f, -0.00177182f, 0.17593539f, 0.07536566f, 0.08494031f, 
    0.13298458f, -0.06805542f, -0.07337311f, 0.15643670f, 0.10269544f, 0.01453082f, -0.05205166f, 0.05360866f, 
    -0.00170232f, 0.04751760f, 0.02966608f, -0.02284081f, 0.13752517f, 0.08045470f, 0.17924438f, 0.03645158f, 
    0.07163586f, 0.01014849f, 0.01215856f, 0.07802826f, 0.00981919f, 0.03477221f, -0.07873394f, 0.08143386f, 
    0.04621349f, -0.09042041f, -0.08507156f, 0.14304401f, 0.10314190f, 0.04389078f, 0.12089346f, 0.11810251f, 
    0.07303569f, 0.05666241f, -0.00321609f, 0.02499129f, -0.17962585f, 0.28604618f, 0.01734357f, 0.02043020f, 
    0.11274442f, 0.16454515f, 0.03854261f, 0.02800157f, 0.01886471f, -0.08779541f, 0.05902976f, 0.05582438f, 
    -0.15178604f, -0.14832187f, 0.13583124f, 0.06147646f, -0.01398575f, 0.04513414f, -0.03195797f, 0.06574637f, 
    0.00947491f, 0.00380005f, -0.02327068f, 0.04720515f, -0.09965964f, -0.02686139f, 0.01793844f, -0.12731281f, 
    0.17911457f, 0.12963797f, 0.04471818f, 0.05451735f, 0.06858464f, 0.03209499f, 0.06021034f, -0.00482654f, 
    -0.26235783f, 0.08702299f, -0.04549042f, 0.02865126f, 0.05294655f, 0.02486744f, 0.02123221f, -0.03351125f, 
    -0.04624104f, 0.04172041f, 0.10094017f, 0.02842852f, -0.07704590f, 0.22034498f, 0.21180393f, -0.15252718f, 
    0.03265769f, 0.06141880f, 0.13149425f, -0.11483712f, 0.09462391f, -0.02626661f, 0.10907388f, 0.00383877f, 
    -0.14961913f, 0.06759477f, 0.03201658f, -0.08528809f, 0.02637165f, 0.01398402f, -0.01036724f, 0.08116234f, 
    0.06133181f, -0.00558012f, -0.02647041f, 0.03226744f, -0.06447013f, 0.12301912f, -0.00258097f, -0.10918383f, 
    -0.02607067f, 0.06781835f, 0.09162270f, 0.03929490f, 0.11854281f, -0.02550778f, 0.02823183f, -0.03332556f, 
    -0.05270743f, 0.03784868f, 0.12459464f, 0.15324242f, 0.08430888f, 0.09486860f, 0.17810903f, -0.04534570f, 
    0.04095216f, 0.11275887f, 0.08539908f, 0.07054387f, 0.38773373f, 0.12897757f, -0.04480971f, -0.07240655f, 
    -0.03464156f, -0.03981062f, 0.08706020f, 0.03541885f, 0.02731567f, 0.10730592f, 0.02780866f, 0.10526914f, 
    -0.05043894f, 0.15833250f, -0.02001971f, 0.02199927f, 0.17387390f, 0.09202740f, 0.04084397f, 0.10594027f, 
    0.05467249f, 0.06939866f, -0.00408690f, 0.00248965f, -0.13012932f, -0.12086941f, 0.07054333f, 0.20536853f, 
    0.01238990f, 0.05428611f, 0.08155311f, -0.01447573f, 0.08974439f, 0.01982082f, -0.01004774f, 0.07406873f, 
    -0.01381875f, -0.05880038f, 0.14516759f, 0.09083447f, 0.08210481f, 0.16394286f, 0.08459786f, 0.02402130f, 
    -0.02076081f, -0.04791131f, 0.04596813f, 0.12450708f, -0.09623364f, -0.11845423f, -0.08686931f, 0.00449623f, 
    0.04252058f, 0.01878269f, -0.00015025f, 0.11695353f, -0.03517570f, 0.00212592f, 0.05804295f, -0.07944448f, 
    0.22010288f, 0.20103408f, -0.04083001f, 0.07895635f, 0.02271283f, -0.05200588f, 0.00436990f, 0.00330513f, 
    0.12158714f, -0.03890500f, 0.07000588f, 0.09071659f, -0.17848004f, 0.09835202f, -0.08391843f, -0.16419737f, 
    0.04620587f, 0.10499279f, 0.07614972f, 0.06732158f, 0.05985823f, 0.07592683f, -0.01525263f, 0.07775113f, 
    -0.00168814f, 0.12580295f, 0.12618327f, 0.28324050f, -0.05921971f, 0.08763529f, 0.02032801f, 0.04805747f, 
    0.12984201f, -0.00303055f, 0.09174423f, 0.00730721f, 0.09116860f, -0.03447251f, 0.13016801f, 0.15139945f, 
    -0.08173008f, 0.07491831f, 0.01580152f, -0.06711580f, -0.04511928f, -0.08912577f, -0.06850178f, -0.01316429f, 
    0.05843661f, -0.18930618f, 0.14920846f, 0.05123631f, -0.05696742f, 0.08089708f, 0.04600198f, -0.03378220f, 
    -0.02962799f, 0.00621328f, -0.01886959f, 0.13633996f, -0.01767666f, -0.23534012f, 0.20941916f, 0.23477668f, 
    0.02511008f, 0.03040591f, 0.06196740f, -0.00074003f, -0.03547560f, 0.10205575f, -0.01108028f, 0.10026583f, 
    0.08635145f, -0.22878687f, 0.27421904f, 0.08717482f, -0.02458395f, 0.02267544f, 0.02271074f, 0.15237157f, 
    0.08765665f, 0.08159455f, 0.01097214f, 0.14524363f, -0.05814144f, 0.04791721f, 0.10336721f, 0.07865317f, 
    0.07401178f, 0.08461735f, 0.02215864f, -0.02015071f, 0.05505466f, -0.06128240f, 0.11818852f, 0.04945239f, 
    0.07840320f, 0.23034018f, -0.11395087f, -0.17262483f, 0.07979459f, 0.04340501f, -0.01337733f, -0.09272874f, 
    0.01232252f, -0.04907676f, 0.06025362f, 0.05589144f, -0.05470041f, 0.14555846f, 0.04084676f, -0.10074818f, 
    0.02365884f, 0.07543103f, 0.00237243f, -0.05750577f, 0.03726767f, 0.00892715f, -0.03502706f, 0.05187349f, 
    0.07818099f, 0.04386695f, 0.04577718f, 0.01480457f, -0.00692650f, 0.14672969f, -0.00174231f, 0.05822971f, 
    0.17588721f, 0.11006158f, 0.02400412f, 0.11051222f, -0.22466756f, -0.08426680f, 0.16154152f, -0.15660335f, 
    0.06325428f, -0.05913337f, -0.05844149f, -0.00449073f, 0.00994855f, 0.03317238f, -0.06905582f, -0.01062548f, 
    -0.17584638f, 0.11313757f, -0.07311570f, -0.03665025f, 0.08240198f, 0.07412432f, 0.01615687f, 0.01041332f, 
    0.11434581f, 0.04748535f, 0.07563093f, 0.02969141f, 0.02284678f, -0.02601834f, 0.17449844f, 0.22162725f, 
    -0.02389211f, 0.02406237f, 0.03809933f, 0.05165758f, 0.05767447f, 0.00971791f, 0.05326176f, 0.10530096f, 
    -0.03117676f, -0.13898887f, -0.03504868f, 0.23145093f, 0.07994779f, 0.06848441f, -0.10628282f, 0.05689797f, 
    0.07619157f, -0.05503974f, 0.00161195f, 0.05178608f, -0.02749364f, -0.11715736f, -0.00803938f, -0.10361209f, 
    0.10330905f, 0.08952706f, 0.13982731f, 0.03957922f, 0.04784596f, -0.07778424f, 0.09994116f, 0.07175145f, 
    -0.04089420f, -0.05045262f, 0.03146712f, -0.12649938f, 0.06562934f, 0.11192471f, 0.11062724f, 0.10946333f, 
    0.06062850f, -0.08927043f, 0.01350693f, 0.04290527f, 0.10357132f, -0.13017252f, 0.07037536f, -0.10765184f, 
    0.03671319f, 0.00656859f, 0.08396640f, 0.01052955f, 0.02516828f, 0.06446579f, -0.06451921f, 0.12245618f, 
    -0.03529291f, -0.18540740f, 0.17624874f, 0.11540864f, -0.06615127f, 0.14634714f, 0.08454619f, 0.15482602f, 
    0.13936915f, 0.03522421f, 0.04039407f, 0.08915863f, -0.02647999f, 0.10238127f, 0.09254652f, 0.08917169f, 
    0.07530960f, 0.05063809f, 0.01656959f, 0.22144714f, 0.12727635f, 0.04651195f, 0.00492208f, -0.01564162f, 
    -0.00869843f, -0.03768644f, 0.04100535f, 0.05518181f, 0.01474984f, -0.02095122f, 0.07264461f, 0.00801853f, 
    0.04478884f, 0.00764553f, 0.12139487f, -0.14150189f, -0.10047384f, 0.00443855f, 0.20621277f, 0.14487346f, 
    -0.04609351f, -0.04770998f, -0.03660980f, 0.01494618f, -0.03003441f, 0.07841656f, 0.06396734f, 0.12330536f, 
    -0.08115546f, 0.07785491f, -0.06153966f, -0.16065186f, 0.02073829f, 0.09406380f, 0.03281903f, 0.00913800f, 
    0.00642966f, 0.02756794f, 0.04667522f, -0.02770571f, 0.17346622f, 0.13494772f, 0.14113574f, 0.11418268f, 
    0.05263406f, 0.02145704f, 0.04256312f, 0.06674574f, 0.05158154f, 0.12155254f, -0.10177293f, 0.00729910f, 
    0.09349425f, 0.05507949f, 0.25589859f, 0.10096369f, 0.04336648f, 0.04314924f, 0.03780064f, 0.01445147f, 
    -0.01441369f, 0.02943010f, 0.01430478f, 0.08718414f, 0.07473174f, -0.02398933f, -0.09530126f, 0.17140758f, 
    0.04778858f, -0.05236375f, 0.06724166f, 0.17025755f, 0.00813147f, 0.00940006f, 0.08976145f, 0.01039776f, 
    0.24621466f, -0.07761340f, 0.09745406f, 0.06760077f, -0.10886154f, 0.03703699f, 0.04340063f, -0.01898975f, 
    0.18937975f, 0.01294161f, 0.02516367f, -0.05966453f, -0.09697764f, 0.11356851f, -0.05150614f, -0.10663052f, 
    0.11802314f, -0.07232537f, -0.01611348f, -0.09234723f, 0.00662996f, 0.07628570f, -0.00412956f, 0.02089746f, 
    0.13482845f, 0.27322423f, -0.04573843f, -0.00617931f, -0.00007406f, 0.06578331f, 0.07300282f, 0.06294373f, 
    -0.06998254f, -0.00469714f, -0.03804267f, 0.12529826f, -0.03487199f, -0.02467492f, 0.16547070f, -0.04616517f, 
    -0.00988172f, 0.16473804f, -0.02130915f, 0.03394410f, -0.00174753f, 0.02937808f, 0.10476595f, 0.08851858f, 
    0.02823352f, -0.19702585f, 0.06573398f, -0.04884093f, -0.01545768f, -0.02593224f, 0.04747038f, 0.06930889f, 
    0.02819955f, 0.00127633f, 0.07327028f, -0.03205086f, -0.15346956f, -0.03133580f, 0.07991543f, 0.08562820f, 
    0.08157881f, 0.11480109f, 0.03599885f, 0.09549043f, 0.13963337f, 0.18256634f, 0.06602678f, 0.04325112f, 
    -0.27628016f, -0.03950328f, -0.00041688f, 0.02990543f, 0.08206534f, -0.00168686f, 0.01576447f, -0.00029711f, 
    0.03139473f, -0.01443018f, -0.06435287f, 0.06359132f, 0.30120781f, 0.12510185f, 0.03549941f, 0.09504147f, 
    0.15993078f, -0.00517002f, 0.04275320f, 0.06173888f, 0.06299312f, 0.07302533f, 0.00910294f, -0.08087845f, 
    -0.23990089f, -0.00314177f, 0.09326229f, -0.07645937f, 0.12517515f, 0.00743619f, -0.00399044f, -0.04768818f, 
    0.03292106f, -0.04142148f, 0.06166187f, 0.20377295f, 0.02814351f, 0.06995445f, 0.11591547f, -0.04189332f, 
    -0.04546350f, 0.12078322f, -0.03099447f, 0.00824911f, 0.01734472f, -0.08102974f, 0.04287225f, -0.00971631f, 
    -0.09875029f, 0.11253132f, -0.06035273f, -0.01168995f, 0.04311290f, 0.06314121f, 0.00738814f, 0.16884509f, 
    -0.03554270f, 0.24843778f, 0.03463662f, 0.21869309f, -0.16594642f, 0.03723695f, -0.09629651f, -0.00691917f, 
    0.06940847f, 0.05056432f, 0.15371291f, -0.03266829f, 0.00923120f, 0.09180583f, 0.14726457f, 0.09225720f, 
    -0.39258930f, 0.25888336f, 0.02674674f, -0.07697556f, 0.10772156f, 0.01141729f, 0.07798192f, -0.00029380f, 
    0.16950886f, 0.00326645f, 0.05915697f, -0.07086903f, 0.17769322f, 0.09472355f, 0.01391749f, 0.13334621f, 
    -0.04889923f, 0.13342892f, 0.16584770f, 0.11495435f, 0.06295618f, 0.12762108f, -0.08417121f, 0.20009381f, 
    0.28871554f, 0.01601768f, -0.08399128f, -0.06024191f, 0.07223511f, 0.04675786f, -0.02514052f, 0.05958922f, 
    0.05637089f, -0.02006377f, -0.05435149f, 0.01547346f, 0.04441307f, -0.07496995f, -0.14844456f, -0.08084735f, 
    0.16607614f, 0.15248010f, 0.02549819f, 0.03261064f, 0.11351631f, -0.11342494f, 0.15791486f, 0.11675446f, 
    0.02467983f, -0.01188646f, -0.00548663f, 0.01442982f, 0.04434219f, -0.00621321f, 0.10289492f, 0.01140913f, 
    -0.02385737f, -0.02513331f, -0.05661997f, 0.03347279f, -0.08794117f, -0.20670107f, -0.18177921f, 0.02226276f, 
    0.10024650f, -0.00498574f, 0.05934605f, 0.04898351f, 0.00604958f, 0.02802848f, 0.01783640f, 0.01005865f, 
    -0.01094244f, 0.01280052f, -0.03407860f, -0.01494481f, -0.01982300f, -0.03160855f, 0.02291947f, -0.03645407f, 
    0.02772574f, -0.03699533f, -0.03192485f, -0.03149044f, 0.01613102f, -0.02374993f, -0.04048036f, 0.00845190f, 
    -0.02170008f, -0.03670109f, 0.01723916f, -0.00611050f, 0.02309071f, -0.01369006f, 0.00333355f, -0.00208705f, 
    0.00650715f, -0.02698126f, 0.02518019f, 0.02151080f, -0.04301102f, 0.01481375f, -0.00037437f, 0.01883322f, 
    -0.04210271f, -0.02800507f, -0.00334347f, -0.00799363f, -0.03235927f, 0.01506796f, -0.01616362f, -0.03860408f, 
    0.02764013f, -0.00057766f, -0.03972235f, -0.03134127f, -0.02097386f, -0.02040444f, -0.00393816f, -0.00511586f, 
    -0.02398353f, 0.00368277f, -0.01219897f, -0.02581422f, 0.00191628f, -0.00037626f, -0.02664401f, -0.02970765f, 
    -0.00557640f, -0.00292942f, 0.01220545f, -0.01444340f, 0.00507556f, 0.00183949f, -0.03484391f, -0.01242082f, 
    0.01293578f, -0.03891893f, -0.00133853f, -0.00277538f, 0.00758029f, 0.00702929f, 0.00551802f, -0.00430607f, 
    -0.02662386f, 0.01698924f, 0.02570419f, -0.00512686f, -0.02289061f, -0.04373135f, -0.03596434f, -0.00900847f, 
    -0.03605312f, -0.01222199f, 0.00121433f, -0.00808142f, 0.00396079f, -0.02671324f, -0.01619629f, -0.01180552f, 
    0.02267711f, 0.00170772f, -0.01771352f, -0.03448499f, -0.03642487f, 0.01545494f, -0.02688386f, -0.00291290f, 
    -0.03159575f, -0.00752617f, 0.00896586f, 0.02680166f, 0.01978432f, -0.02743499f, 0.02785365f, 0.02588128f, 
    -0.03172458f, 0.00080444f, -0.00325099f, 0.00755388f, 0.01114175f, -0.00328615f, -0.04141721f, 0.01813542f, 
    -0.03987262f, -0.03560148f, 0.02683806f, 0.00078626f, -0.01703310f, -0.03184637f, -0.01331683f, 0.02625455f, 
    0.01244687f, -0.00163237f, -0.00677883f, 0.02069412f, -0.03008643f, -0.02434138f, 0.02701619f, 0.00894464f, 
    -0.04099265f, -0.02110539f, -0.00157680f, 0.00516712f, -0.01864933f, -0.00587367f, 0.00729212f, 0.00097004f, 
    -0.03668865f, 0.00724753f, -0.02655448f, -0.01239612f, -0.00976681f, -0.02967068f, -0.00551485f, -0.03392180f, 
    -0.02624317f, -0.03872457f, 0.00845870f, -0.02804270f, -0.03509847f, 0.01837964f, 0.02304793f, -0.00822335f, 
    -0.00714927f, -0.03715450f, -0.02634354f, -0.02739761f, 0.00765152f, 0.02397578f, -0.00918275f, 0.00650560f, 
    0.01665490f, -0.03961733f, -0.02676799f, -0.03102390f, 0.02156348f, -0.01152700f, -0.00235402f, -0.01656316f, 
    0.02526188f, 0.01227389f, 0.02684624f, -0.02828630f, -0.04153972f, -0.00188363f, -0.02259334f, 0.02759188f, 
    -0.01043835f, 0.00657704f, 0.01288577f, -0.03267373f, -0.00119100f, 0.02381220f, -0.01856813f, -0.00303386f, 
    -0.00333420f, 0.02353006f, 0.01553188f, 0.01404666f, -0.01534877f, 0.00006384f, -0.04422776f, -0.01257385f, 
    -0.01501856f, 0.01681505f, 0.02081207f, 0.02404336f, 0.02436361f, -0.02466057f, -0.03858709f, -0.02349981f, 
    0.00731139f, -0.03075591f, -0.02658097f, -0.03198844f, 0.02742645f, -0.02477840f, -0.03456761f, -0.03127417f, 
    -0.00919966f, -0.03293378f, 0.00252620f, -0.01615400f, -0.00296139f, -0.00778119f, -0.01531937f, -0.00296410f, 
    0.01034256f, 0.01785732f, -0.00136524f, -0.00137219f, 0.00593094f, -0.00369669f, 0.00310431f, -0.01964769f, 
    0.00819031f, 0.01903847f, -0.00838000f, -0.00988301f, 0.01482319f, -0.03547857f, 0.01879763f, -0.02973855f, 
    0.00229487f, -0.00649388f, 0.01001262f, 0.01178053f, 0.02629343f, -0.01449356f, -0.03847497f, -0.02780580f, 
    -0.00818570f, -0.04346761f, 0.00495965f, -0.03314386f, -0.00892872f, -0.02893765f, -0.00342390f, -0.00808410f, 
    0.00655736f, -0.01858644f, 0.02711893f, 0.00657943f, -0.04021890f, -0.03568690f, -0.01847303f, -0.03380406f, 
    -0.03208520f, 0.02111128f, 0.02565882f, -0.02569389f, -0.00630709f, -0.00055632f, -0.02305104f, -0.03007400f, 
    0.01798427f, -0.02797347f, -0.02061751f, -0.00191001f, -0.02024479f, -0.02831584f, -0.00991568f, -0.02164947f, 
    0.02598017f, -0.00522283f, -0.00151332f, -0.00537721f, -0.03996267f, -0.03462671f, -0.01632093f, -0.03542347f, 
    -0.00011075f, 0.00621225f, -0.01974741f, 0.01490093f, -0.03669944f, 0.02060235f, 0.00693623f, -0.01904292f, 
    -0.03057101f, 0.02517278f, -0.03835072f, 0.00613894f, 0.00818738f, -0.01575654f, 0.00629671f, -0.04180367f, 
    -0.00228845f, 0.02060752f, 0.00167996f, 0.00664134f, -0.00576835f, 0.00080602f, 0.00859377f, -0.02561737f, 
    0.00803989f, -0.03620457f, -0.00524988f, -0.03453202f, 0.02659137f, -0.03593679f, -0.02290390f, -0.01606422f, 
    -0.00444323f, -0.03302507f, -0.00217678f, -0.00663057f, -0.02414738f, -0.00758677f, 0.02147965f, -0.02247400f, 
    0.02231256f, -0.03800371f, 0.00637350f, -0.02886993f, -0.00640253f, -0.02327197f, -0.00734762f, 0.01176393f, 
    0.00486708f, 0.00376460f, -0.02522960f, -0.01658740f, 0.02494613f, -0.00603533f, 0.02268392f, 0.01640303f, 
    -0.02483067f, 0.01764142f, -0.03356513f, 0.02055143f, 0.00178599f, -0.00249132f, -0.00985541f, -0.02333701f, 
    -0.04127729f, 0.01703345f, 0.00948906f, 0.02252747f, -0.01684445f, 0.01419903f, 0.01217784f, 0.01732533f, 
    -0.00012444f, 0.01506596f, -0.01853796f, -0.00050560f, 0.01056793f, -0.02335032f, 0.02425664f, -0.03017512f, 
    -0.02955516f, 0.01020351f, 0.00352831f, 0.00595792f, 0.02665830f, 0.00984994f, -0.03295975f, -0.00559868f, 
    0.02349513f, -0.00631057f, -0.02638940f, -0.01207652f, -0.03010159f, -0.00407566f, -0.00869653f, -0.00891180f, 
    -0.02550099f, -0.04257040f, 0.00635117f, -0.02391212f, 0.02645890f, -0.00558161f, 0.01165198f, -0.02045735f, 
    0.02236967f, 0.01391086f, 0.01153831f, -0.04263765f, -0.01961257f, -0.02638717f, -0.02185520f, 0.00445221f, 
    0.01202135f, 0.00719748f, -0.02323204f, -0.02189117f, 0.00606962f, 0.01964942f, -0.00052593f, 0.02744341f, 
    0.00598919f, -0.03146433f, -0.00149786f, -0.02646224f, -0.00271650f, 0.00277542f, 0.02424660f, -0.03267555f, 
    -0.03512475f, 0.00644581f, 0.01376515f, -0.00706997f, 0.00161262f, 0.01925212f, -0.00282971f, 0.01039961f, 
    -0.01775020f, 0.01590100f, -0.03364554f, -0.00455621f, 0.02343267f, 0.01892668f, -0.02711015f, -0.02702087f, 
    0.00227218f, 0.00685785f, 0.02560870f, -0.00914815f, 0.01269756f, 0.00812558f, -0.03741479f, 0.00575667f, 
    -0.02821927f, 0.02059744f, -0.04362161f, -0.00840233f, -0.00176742f, -0.03555569f, -0.03106734f, 0.01765697f, 
    0.01634609f, -0.03929764f, 0.01543229f, -0.02816437f, -0.04225207f, 0.00588482f, -0.02614481f, -0.02348751f, 
    -0.02213463f, -0.04034423f, 0.02071457f, 0.01183513f, -0.00151354f, 0.00502265f, -0.00629130f, 0.00220460f, 
    -0.00206123f, -0.00183566f, -0.02382628f, -0.01118415f, 0.02489023f, -0.00147286f, 0.00623342f, 0.02360614f, 
    0.00788839f, 0.02782100f, 0.01185989f, -0.01706121f, -0.01533511f, -0.01027814f, 0.01747379f, -0.03987090f, 
    -0.01966228f, 0.00384253f, 0.02715013f, 0.00308458f, 0.02280460f, 0.00797499f, -0.00281314f, 0.00880682f, 
    0.01103760f, -0.02735014f, 0.01577222f, -0.01757819f, 0.00993227f, 0.00314791f, 0.00531439f, 0.02247018f, 
    -0.03132658f, -0.00952008f, -0.04060928f, 0.00336965f, -0.03249678f, 0.00620812f, 0.02363855f, 0.01438440f, 
    -0.00192269f, 0.01345080f, 0.02783503f, -0.03531216f, -0.04067842f, 0.02059757f, -0.01910280f, 0.01093391f, 
    -0.01233947f, -0.00935646f, 0.00185517f, -0.03919319f, -0.02963181f, 0.02462259f, 0.00146794f, -0.01341709f, 
    -0.01149634f, -0.00388320f, 0.01077685f, -0.02106941f, 0.00494457f, -0.00679481f, -0.02988719f, 0.02250546f, 
    0.00679767f, -0.02766415f, -0.03468846f, -0.04110459f, -0.02609434f, -0.01975794f, -0.01225199f, -0.02842828f, 
    0.00631912f, -0.00889398f, -0.02763348f, 0.02466804f, -0.02096137f, -0.00328304f, -0.03454844f, 0.01788577f, 
    -0.04228500f, -0.01190066f, -0.00239272f, -0.00715150f, -0.03357067f, 0.01268945f, -0.01236079f, -0.02892862f, 
    -0.03136280f, -0.01261010f, -0.03885030f, -0.02186606f, 0.00111238f, -0.01451226f, -0.01505594f, -0.02404073f, 
    -0.04329257f, 0.00301292f, -0.03490400f, 0.00449929f, -0.01288298f, -0.00201017f, -0.01228834f, 0.00854449f, 
    -0.04168814f, 0.01928246f, 0.00545616f, -0.03984395f, -0.04300839f, -0.02101796f, -0.03189993f, 0.01411787f, 
    -0.02537772f, -0.01171154f, 0.00296755f, -0.03412310f, -0.02060567f, -0.03052091f, -0.00092268f, -0.00374681f, 
    -0.04161113f, 0.00394674f, 0.00676396f, -0.01271718f, -0.02611552f, -0.03417682f, 0.01662565f, -0.02558509f, 
    0.01313961f, -0.02919341f, -0.00594688f, 0.02483077f, -0.04360975f, -0.02111168f, 0.00578686f, -0.01536548f, 
    -0.01074846f, 0.01055964f, 0.01180691f, -0.02765380f, 0.01578561f, 0.00578841f, -0.04104078f, -0.02962082f, 
    -0.03538920f, -0.04305367f, -0.02216885f, -0.01972401f, -0.01960434f, 0.02832167f, 0.01116650f, -0.03415269f, 
    -0.03793435f, -0.02704916f, -0.02568151f, 0.00197873f, 0.00111681f, -0.00655029f, 0.02744443f, -0.03869431f, 
    -0.02656581f, -0.03261047f, -0.00863912f, 0.00701241f, -0.00360223f, -0.01688799f, 0.02683123f, 0.02458331f, 
    -0.02246307f, -0.01765684f, -0.03860955f, 0.00742682f, -0.00966031f, -0.03989951f, -0.02782170f, -0.00318022f, 
    -0.02953423f, 0.02032061f, 0.00513265f, -0.02300370f, 0.00932360f, -0.00089225f, -0.01331333f, 0.02380440f, 
    -0.04241491f, 0.02086494f, 0.02126071f, 0.02399371f, 0.00073672f, -0.02781452f, -0.00715038f, -0.02606150f, 
    0.03002410f, 0.00410598f, 0.01062948f, -0.00391528f, -0.01506466f, -0.02492237f, -0.01281922f, 0.00319118f, 
    -0.01785512f, -0.03098104f, -0.00165950f, 0.00695363f, 0.02531929f, 0.00166580f, -0.01299297f, -0.00144250f, 
    -0.03777136f, 0.02288129f, -0.03373079f, -0.00617542f, -0.03779448f, -0.01198206f, -0.04010349f, -0.01015543f, 
    -0.03200067f, -0.03595346f, -0.03191698f, -0.01875502f, -0.02867136f, 0.00402751f, -0.02815056f, -0.01371558f, 
    -0.00482206f, -0.03496252f, -0.01312797f, 0.00185197f, 0.02669752f, -0.03224486f, 0.02622915f, -0.03074323f, 
    -0.00398462f, -0.01568889f, -0.03503888f, -0.02329815f, 0.01757880f, -0.02368041f, 0.00177476f, 0.00904088f, 
    0.01304520f, -0.02930954f, 0.00560617f, 0.02566156f, 0.00770664f, -0.02106581f, -0.03144689f, -0.01098725f, 
    -0.02256241f, 0.02800804f, 0.00854079f, -0.02006750f, -0.00377378f, 0.02404535f, 0.02444986f, -0.01235587f, 
    -0.00971916f, -0.01060677f, -0.00489653f, 0.01783127f, -0.01443174f, -0.03721089f, -0.00197305f, 0.01484769f, 
    -0.03577574f, -0.02457101f, 0.00319401f, 0.02485119f, 0.00120135f, -0.02960503f, -0.04233021f, -0.02030626f, 
    -0.00274236f, 0.02116214f, -0.01669043f, 0.02358689f, -0.04236887f, -0.01752646f, 0.01276240f, 0.00608096f, 
    0.02014890f, 0.00646897f, 0.02277232f, 0.00230931f, 0.01583307f, 0.01037132f, -0.00045509f, 0.00355249f, 
    0.00981127f, 0.02706690f, -0.01062433f, -0.01227652f, -0.01915244f, 0.00172426f, -0.01622326f, 0.01686746f, 
    -0.00831241f, -0.02221919f, 0.00984113f, 0.02456024f, 0.01719691f, 0.00293549f, 0.00864239f, -0.01213988f, 
    -0.03790918f, 0.00890470f, -0.02465087f, -0.03584573f, 0.00703155f, -0.00263428f, 0.00904172f, -0.00300849f, 
    0.09180652f, 0.06414517f, 0.01968620f, -0.00840554f, 0.04763842f, 0.06151512f, 0.12172976f, 0.05436115f, 
    -0.04761307f, -0.06984797f, -0.03919596f, 0.05242450f, 0.04777177f, 0.08669684f, -0.09208658f, 0.05174407f, 
    0.07645627f, -0.01433660f, 0.05343362f, 0.04625389f, 0.11099358f, 0.02707372f, 0.11909537f, 0.15538798f, 
    -0.29165053f, -0.12509172f, 0.07250575f, -0.03491038f, -0.03846397f, 0.14264970f, -0.07068299f, -0.03846244f, 
    0.04095272f, 0.06636566f, -0.06535683f, 0.03537494f, 0.27321926f, 0.28664735f, -0.16408357f, -0.02602803f, 
    -0.05056171f, -0.04183768f, -0.07456919f, -0.07362681f, -0.00203384f, -0.13941689f, -0.07743078f, -0.04599130f, 
    0.05477152f, -0.10346298f, 0.06654198f, -0.04069920f, -0.10286003f, 0.05932311f, 0.03946408f, -0.09509213f, 
    -0.01525748f, 0.01277534f, 0.02194963f, 0.07072926f, 0.01419778f, -0.03847944f, -0.09758208f, 0.05823966f, 
    0.05108003f, 0.06760157f, -0.04669043f, 0.06118829f, 0.05472055f, 0.03443118f, 0.08252524f, 0.09551662f, 
    0.06217153f, -0.06293891f, 0.07579619f, 0.01620628f, 0.00560074f, -0.03423297f, 0.02145280f, -0.03499702f, 
    -0.06465063f, -0.03939551f, 0.05171094f, -0.04789664f, 0.15537134f, -0.26389119f, 0.03994866f, 0.06712580f, 
    0.10313003f, -0.19078788f, 0.02580724f, -0.06790761f, 0.11570551f, 0.09578672f, -0.01821048f, -0.03623389f, 
    0.10566899f, 0.07487963f, -0.00225954f, 0.04693514f, -0.02817574f, 0.07156656f, 0.09031359f, -0.05302025f, 
    0.10493212f, 0.08775565f, 0.14966935f, 0.02895106f, -0.05612775f, 0.03713708f, -0.11528008f, -0.08006633f, 
    -0.10572762f, -0.14166379f, -0.02083667f, -0.00936380f, 0.00922473f, -0.00612184f, -0.07289571f, -0.01473762f, 
    0.15677805f, -0.11751520f, -0.02229060f, 0.03612104f, -0.01764339f, 0.00541610f, 0.06370208f, 0.10620514f, 
    0.03919569f, 0.10817201f, -0.07336882f, -0.11427951f, -0.05131013f, -0.12122230f, -0.02750835f, 0.14564297f, 
    0.02198076f, -0.08536052f, -0.04980468f, 0.18525164f, 0.10278723f, 0.11735934f, -0.04012884f, 0.09012157f, 
    0.05046181f, -0.12459891f, -0.02034331f, -0.03714902f, 0.02007578f, 0.17120701f, -0.00230605f, -0.13254738f, 
    0.03898918f, 0.09634914f, 0.13122231f, 0.12128181f, -0.07472748f, -0.20401020f, 0.03744754f, -0.01856567f, 
    0.09947453f, -0.04376963f, -0.16548812f, -0.05325628f, -0.07466769f, 0.11416811f, 0.02223687f, 0.14933746f, 
    0.02901875f, -0.10532401f, 0.00803448f, -0.07492576f, 0.03652189f, -0.08296689f, -0.07264896f, -0.00067378f, 
    0.11798760f, -0.05073155f, 0.03506283f, 0.07544865f, -0.29092231f, -0.07189174f, 0.05994772f, 0.14583322f, 
    0.12516809f, 0.01435467f, -0.09677194f, -0.00376743f, 0.07789275f, -0.11879839f, 0.11900823f, -0.05131885f, 
    -0.13966171f, 0.07620212f, -0.07046248f, 0.07772539f, -0.08038488f, -0.00823004f, 0.03147101f, 0.02744780f, 
    0.01497617f, -0.05402817f, -0.07125483f, -0.05986086f, 0.28322625f, 0.09961286f, -0.08847249f, -0.14693496f, 
    -0.01937903f, 0.00626344f, -0.04432954f, 0.04592310f, -0.01669868f, 0.13047592f, 0.02687608f, -0.09758480f, 
    0.06707329f, -0.00638914f, -0.04681499f, 0.08018490f, 0.02312067f, -0.16543806f, 0.01659773f, 0.00390003f, 
    0.09616292f, 0.13835877f, -0.11047759f, -0.06213193f, 0.20609599f, 0.04269784f, -0.07318880f, -0.16280904f, 
    -0.04019067f, -0.00459860f, 0.04742215f, -0.01927311f, 0.04135216f, 0.16744539f, -0.09894527f, 0.08826647f, 
    -0.02869756f, -0.08639163f, 0.11230347f, 0.26109645f, 0.03874536f, 0.10763129f, 0.03026676f, 0.13476361f, 
    -0.09931680f, 0.02633636f, -0.03895443f, 0.10019809f, 0.00256983f, -0.16335188f, 0.11738274f, 0.05709111f, 
    0.11963110f, -0.06329945f, -0.03892358f, -0.04428709f, 0.11006084f, -0.02004788f, 0.06515884f, -0.05417438f, 
    0.11515664f, -0.04672788f, -0.03605116f, 0.01498159f, 0.05248628f, 0.02496083f, 0.01559089f, -0.02826519f, 
    -0.01053535f, 0.07203671f, -0.17946480f, -0.06912943f, 0.19189776f, 0.15113728f, -0.02134641f, 0.02129749f, 
    0.05584123f, 0.02971536f, -0.07264274f, 0.06052008f, -0.07324483f, 0.11300574f, 0.10822318f, 0.14342877f, 
    -0.11377717f, -0.07829850f, -0.06299627f, -0.24960329f, 0.02765478f, 0.16505547f, -0.11733439f, 0.06395051f, 
    0.06578626f, 0.09437522f, 0.06141063f, -0.08595149f, 0.18905659f, 0.21980305f, -0.02219952f, -0.01615238f, 
    -0.04220463f, -0.01141662f, 0.02200479f, 0.05570100f, -0.04457856f, -0.08170027f, 0.01250314f, -0.10823133f, 
    -0.09740051f, 0.13734600f, -0.14532503f, -0.04671080f, -0.09134039f, 0.09130660f, -0.07821909f, -0.05912912f, 
    -0.01531348f, -0.08000431f, 0.06252880f, -0.09422702f, -0.08947314f, -0.16899435f, -0.07759872f, 0.10516929f, 
    0.01563795f, -0.06371248f, 0.05809753f, -0.03955020f, 0.12235968f, 0.04446475f, -0.10751321f, 0.08816674f, 
    -0.13836980f, -0.27475742f, 0.06538218f, 0.01834201f, -0.00308981f, 0.01468109f, -0.01113481f, 0.03647643f, 
    0.10470102f, -0.01532143f, 0.01701743f, 0.00594531f, 0.12816791f, -0.21028732f, 0.08315802f, 0.03715839f, 
    -0.02203304f, 0.02742773f, 0.06523341f, 0.05795503f, 0.08710193f, 0.05479665f, -0.00931590f, -0.03072700f, 
    0.04986985f, 0.00186670f, -0.04486025f, 0.08887167f, 0.12000632f, -0.12128497f, 0.02965550f, -0.11918700f, 
    -0.03424582f, -0.14108795f, 0.08312187f, -0.03627091f, 0.04302999f, 0.05526836f, -0.18219548f, 0.03989169f, 
    -0.06620897f, 0.04139126f, -0.00111037f, -0.00015738f, 0.07080362f, -0.06205079f, 0.03931680f, 0.05268427f, 
    0.31904560f, -0.11808255f, -0.05701481f, -0.08401693f, 0.00485756f, -0.00295412f, 0.14077784f, -0.10684574f, 
    -0.04674704f, -0.06147560f, -0.07583427f, 0.02687007f, 0.14410628f, 0.11751914f, -0.08878191f, 0.03949154f, 
    0.04842784f, -0.01358112f, 0.08975331f, 0.05344941f, -0.08372290f, -0.01367657f, 0.03070992f, 0.03588530f, 
    0.10064858f, -0.06231147f, -0.02141158f, -0.04199822f, 0.01644819f, -0.01162880f, 0.11860439f, 0.01847363f, 
    0.09232830f, 0.25342405f, 0.02892697f, 0.00035042f, 0.06915062f, -0.03489256f, -0.04717523f, -0.08659323f, 
    -0.04642818f, -0.01649526f, 0.03723494f, -0.01948063f, 0.04710472f, -0.01681696f, -0.06537987f, -0.15275970f, 
    -0.08748228f, 0.25356758f, 0.07013544f, -0.04323203f, 0.04263920f, 0.02230683f, -0.02321760f, -0.01741088f, 
    -0.00352304f, 0.13129421f, 0.04496224f, 0.02974918f, -0.13942486f, 0.11735567f, -0.12767529f, -0.11232653f, 
    -0.11207447f, 0.10909838f, -0.02496321f, 0.08786238f, 0.11694461f, -0.06871796f, 0.09761570f, 0.02311453f, 
    -0.06806152f, -0.02530323f, -0.13513297f, -0.15796538f, 0.08603473f, -0.01425040f, -0.22095898f, -0.15670970f, 
    -0.04798968f, 0.01407615f, 0.05051414f, 0.00170253f, -0.07380386f, 0.04213571f, -0.06286188f, -0.08583128f, 
    -0.09182506f, -0.06240769f, 0.10337331f, -0.01065999f, -0.11678077f, 0.02751667f, 0.19486600f, 0.13957129f, 
    0.12125433f, -0.04195672f, 0.11291907f, -0.10569472f, 0.04809446f, 0.04994719f, 0.00484472f, 0.05922617f, 
    0.02583467f, 0.11334487f, -0.12403481f, 0.25218004f, 0.08765803f, 0.11888247f, 0.05170710f, -0.00479664f, 
    0.06051473f, -0.02352527f, 0.11037258f, 0.11635304f, 0.14094548f, -0.04377156f, -0.07569025f, -0.04927098f, 
    0.07915597f, 0.11098704f, -0.04289892f, -0.02631504f, 0.06082217f, -0.10825048f, 0.02789905f, 0.13390876f, 
    0.01678286f, -0.02691460f, -0.05374630f, 0.03942017f, -0.54323769f, -0.06076604f, -0.08875199f, 0.00967371f, 
    -0.02024867f, -0.03773881f, -0.06570161f, -0.03250101f, -0.00825073f, -0.13904528f, 0.16273580f, -0.00619287f, 
    -0.03126353f, 0.10128804f, -0.12875114f, 0.03489914f, 0.00982696f, -0.03996858f, -0.05725329f, 0.06573361f, 
    0.03742244f, 0.03415307f, 0.01353501f, -0.05152532f, -0.03991409f, 0.15537012f, 0.02498760f, -0.07331304f, 
    0.05049354f, -0.03654312f, 0.06028067f, 0.09997036f, -0.03622047f, 0.05847542f, -0.10815518f, 0.03038711f, 
    -0.00019846f, 0.10988529f, 0.00695498f, -0.00851099f, 0.10384493f, 0.02784690f, -0.00482853f, 0.05493064f, 
    0.01864637f, 0.01805145f, 0.10672127f, 0.14795220f, 0.09260186f, -0.17794588f, -0.03721697f, 0.05486108f, 
    0.01072384f, 0.11208539f, 0.02658476f, 0.10774414f, 0.11943110f, 0.10060719f, 0.15338592f, 0.10206581f, 
    0.09261853f, -0.28609353f, 0.09477436f, 0.11251667f, 0.06768711f, 0.05692561f, -0.02482762f, -0.05679593f, 
    0.03240893f, 0.11577366f, 0.10186777f, 0.01104772f, -0.06459671f, 0.06020263f, 0.07679273f, 0.03892552f, 
    -0.04730009f, -0.02364110f, 0.13351662f, 0.03633818f, 0.07641550f, 0.00341512f, -0.17437528f, -0.00858395f, 
    -0.08119127f, 0.07525163f, 0.04412154f, -0.00970978f, -0.04261882f, 0.07585560f, 0.03191875f, -0.07561313f, 
    0.08823064f, 0.03327832f, 0.04835443f, 0.06968980f, 0.19841909f, -0.14573215f, -0.11233409f, -0.13130696f, 
    0.02436070f, 0.07115194f, 0.02063760f, -0.13397361f, -0.01606515f, -0.15167999f, -0.02112988f, 0.13857813f, 
    0.02943406f, 0.12422112f, -0.04794732f, -0.05582657f, -0.06947842f, 0.05054539f, -0.04971738f, 0.09826043f, 
    -0.05288143f, 0.23023894f, 0.17252000f, 0.06980655f, -0.47847763f, 0.23409671f, -0.16372271f, 0.05360178f, 
    -0.02736091f, 0.08953090f, -0.01644713f, 0.09582543f, 0.07024378f, 0.03113839f, 0.01678844f, 0.16529806f, 
    0.01398767f, 0.06087381f, -0.17734046f, -0.15405829f, -0.01725582f, 0.00368062f, -0.03154419f, -0.04433756f, 
    0.03105322f, 0.06662739f, -0.11645752f, -0.24970116f, 0.08331706f, -0.20692053f, -0.07576848f, 0.18538642f, 
    0.16941659f, -0.10207498f, 0.08499993f, -0.07594240f, 0.04083007f, 0.08535881f, 0.05853719f, 0.07801703f, 
    -0.07291171f, 0.06301235f, -0.17133190f, 0.11781904f, -0.05656089f, -0.05546381f, 0.08406055f, 0.01023563f, 
    0.03232745f, -0.19768229f, -0.02293308f, -0.26188046f, 0.28590831f, 0.04525758f, -0.09616349f, 0.03415671f, 
    -0.04293365f, -0.03527268f, -0.05300847f, 0.09374272f, 0.03592745f, -0.07277492f, -0.04489463f, -0.13443795f, 
    0.13180600f, -0.08089682f, -0.03410758f, -0.01373413f, 0.05628059f, 0.02634872f, 0.09540758f, 0.07000051f, 
    0.01973062f, 0.00790335f, 0.01130573f, 0.07070628f, -0.12381969f, -0.07776679f, -0.07137308f, -0.04224071f, 
    0.07535597f, -0.00892674f, -0.11910287f, 0.00684316f, -0.10623699f, -0.00188882f, 0.14978340f, -0.07979094f, 
    0.10133785f, -0.08041651f, 0.16231954f, 0.22238888f, 0.21378489f, 0.02164862f, 0.07442936f, -0.00030156f, 
    0.03287038f, 0.06374902f, 0.20580225f, 0.12671025f, 0.11092211f, 0.02925555f, 0.19218716f, 0.04511889f, 
    0.08306244f, -0.12571362f, 0.09131595f, -0.03228751f, 0.01931834f, 0.09458531f, -0.10316662f, -0.02145172f, 
    0.04462619f, -0.08609786f, 0.01086177f, 0.07158934f, 0.00818583f, 0.02421833f, -0.07952274f, 0.03685897f, 
    0.07282904f, 0.13486274f, 0.16395301f, 0.05560940f, 0.03116675f, -0.00111110f, -0.05382886f, -0.06903235f, 
    -0.02041370f, 0.09194717f, -0.02776726f, -0.05389028f, -0.00906288f, 0.01293735f, -0.11503526f, -0.01095140f, 
    0.03840834f, 0.00845448f, -0.01304333f, -0.02903201f, -0.01927278f, 0.00343919f, -0.02546209f, -0.00421550f, 
    -0.02741799f, 0.02049468f, 0.03705733f, 0.02925377f, 0.02863708f, 0.01347968f, 0.02431302f, 0.02323950f, 
    0.01025436f, -0.02845306f, -0.01262065f, 0.00195313f, 0.00163803f, -0.00111614f, -0.02200633f, 0.00326199f, 
    0.00908170f, -0.03599480f, -0.01189448f, 0.02200533f, 0.01625756f, -0.00046078f, 0.00833748f, 0.02581309f, 
    -0.00819129f, 0.01937463f, 0.02379624f, 0.01462486f, 0.01799197f, 0.01588567f, -0.02937309f, -0.03090011f, 
    -0.02596452f, 0.02391054f, -0.00757658f, 0.00884429f, 0.00647062f, -0.03271183f, 0.00614968f, -0.03228521f, 
    0.00064918f, -0.00396617f, 0.01750337f, 0.02864397f, 0.03498813f, 0.01634682f, -0.00601343f, -0.00055599f, 
    -0.03619388f, 0.00706156f, 0.02241391f, -0.03167586f, -0.02508662f, -0.02117130f, 0.01181828f, -0.02617488f, 
    -0.03720799f, 0.02150973f, 0.02173418f, -0.00939860f, -0.01716284f, 0.00086561f, 0.00739391f, -0.01888211f, 
    0.03907575f, -0.01341534f, -0.02026101f, -0.00179020f, -0.02681484f, -0.03434373f, -0.00362147f, 0.01894947f, 
    0.01047224f, -0.01815036f, -0.00802042f, 0.01273965f, 0.01124605f, 0.01547435f, -0.03321913f, 0.00765333f, 
    -0.03533950f, 0.03896189f, 0.01976951f, 0.01751701f, -0.03758773f, 0.00300099f, -0.02277625f, -0.03773209f, 
    -0.00717492f, -0.01410758f, -0.03065130f, -0.02883171f, 0.02502872f, 0.02117770f, 0.02248250f, -0.02681874f, 
    0.01786989f, -0.03733658f, -0.02608300f, 0.00467799f, 0.00117665f, 0.02268691f, 0.02954807f, -0.01866803f, 
    0.03096411f, 0.03546664f, -0.02069238f, -0.00944060f, -0.01723044f, 0.00165674f, -0.01204338f, -0.01461588f, 
    0.01293865f, -0.03044628f, 0.02748099f, -0.00228595f, 0.00311327f, -0.02158608f, -0.03287219f, 0.03086990f, 
    -0.01882037f, 0.01818096f, -0.02731858f, -0.00588190f, 0.00754043f, 0.00815835f, -0.02083083f, -0.00531688f, 
    0.03050270f, -0.02011091f, 0.01077402f, 0.01707975f, 0.02775285f, -0.02750615f, -0.03749401f, -0.02931465f, 
    -0.03909076f, -0.04505582f, -0.00883802f, -0.03831578f, 0.01247368f, -0.01987779f, 0.01668387f, 0.01323111f, 
    -0.01627604f, -0.01017376f, -0.03850557f, 0.02387211f, 0.01735627f, -0.02721655f, -0.02905515f, 0.02377781f, 
    -0.01598969f, -0.01774529f, -0.02233987f, -0.03090860f, 0.01372176f, -0.02518758f, -0.04059318f, -0.04775188f, 
    0.00145585f, -0.00895939f, -0.00193027f, 0.03424916f, -0.01288456f, -0.00657918f, -0.01949064f, -0.00599118f, 
    -0.01532339f, -0.03455146f, -0.01358666f, 0.02352504f, -0.02662301f, 0.00059732f, -0.01013999f, 0.02825669f, 
    -0.02521212f, -0.00375175f, -0.00512802f, -0.00115628f, 0.00076698f, 0.03964180f, 0.02492499f, 0.02512240f, 
    0.01565892f, -0.01075530f, 0.01148588f, -0.02814241f, 0.00027223f, -0.01541151f, -0.00252141f, 0.02381306f, 
    -0.01340434f, 0.00390124f, -0.01392316f, -0.01158512f, -0.03112352f, -0.04188512f, -0.01018543f, -0.01230218f, 
    -0.01416091f, 0.02336483f, -0.00550303f, -0.02167757f, 0.00599298f, -0.03334650f, -0.01337296f, -0.02178544f, 
    0.01101724f, 0.02533125f, 0.00604420f, 0.03623639f, 0.01176869f, 0.00089079f, 0.01969920f, -0.02981306f, 
    0.00690683f, 0.02392580f, -0.01967825f, 0.01481532f, -0.02044814f, 0.02673654f, -0.02998082f, -0.04499670f, 
    0.02984850f, 0.00256879f, -0.01593162f, -0.00966749f, -0.02072413f, 0.00893197f, -0.00976136f, 0.00620710f, 
    0.01430048f, -0.02283570f, -0.00015623f, 0.01661895f, -0.02506057f, -0.03297572f, -0.03783498f, -0.03151102f, 
    0.00564904f, -0.02970127f, -0.01504135f, -0.01890974f, 0.00228815f, 0.01687375f, -0.02147156f, 0.01797164f, 
    -0.02798275f, -0.01092224f, -0.00039344f, 0.02608461f, 0.02548820f, -0.00770466f, -0.00019370f, -0.00048894f, 
    0.00505431f, 0.02236643f, 0.01361843f, 0.02196871f, 0.02961400f, 0.01560749f, -0.02026325f, -0.02582345f, 
    -0.03481891f, 0.01151559f, 0.01462202f, -0.02297684f, 0.00891716f, 0.02756114f, 0.03355708f, -0.00323768f, 
    0.00427796f, -0.04043619f, -0.04196023f, 0.01178981f, -0.02157281f, 0.01328811f, -0.01270867f, -0.02504926f, 
    -0.00224387f, -0.03300244f, -0.01263954f, -0.02559559f, -0.00426721f, 0.01654435f, 0.01989204f, -0.04392019f, 
    -0.02403256f, -0.02979257f, 0.00627915f, -0.02990765f, 0.01407324f, 0.00876220f, 0.02334964f, 0.00309176f, 
    0.01819135f, -0.04321586f, 0.00587076f, -0.00590442f, -0.00552211f, -0.00593291f, -0.02942226f, -0.00639598f, 
    0.03021024f, -0.01448235f, -0.00191294f, -0.02742049f, 0.03345524f, -0.00749408f, -0.02554786f, 0.00356209f, 
    0.00554118f, 0.00638914f, -0.03008934f, 0.00928651f, 0.03115141f, 0.03854364f, -0.02773337f, -0.02748774f, 
    0.01752233f, 0.01172945f, -0.00489854f, -0.01805492f, -0.01488602f, -0.03039705f, 0.01705175f, 0.00803462f, 
    0.00842284f, 0.02218213f, -0.00061040f, 0.01836026f, -0.00060395f, -0.01658317f, -0.02289430f, -0.04057492f, 
    0.00997876f, 0.01326279f, 0.02902065f, -0.02155983f, -0.02556607f, -0.00217491f, -0.03642478f, -0.00450138f, 
    0.00097865f, -0.01029628f, 0.00165432f, 0.01798643f, 0.01013026f, 0.01741895f, 0.00301233f, 0.02527384f, 
    -0.00685588f, -0.03858651f, 0.01758478f, -0.03974434f, 0.02894980f, -0.03201998f, 0.01882626f, 0.00161723f, 
    0.03575358f, -0.00531015f, -0.02615266f, -0.00249322f, -0.00448965f, 0.01507544f, -0.01119942f, -0.02917758f, 
    -0.01609939f, -0.02751851f, -0.00627891f, -0.01896480f, -0.02780391f, 0.02722260f, -0.01769349f, -0.02697881f, 
    -0.03555274f, -0.02305513f, -0.04481927f, 0.00382191f, 0.02572277f, 0.01374094f, -0.00229961f, -0.04157285f, 
    -0.01142922f, -0.00697065f, -0.00264737f, 0.00190465f, -0.03053276f, 0.01212179f, 0.00737612f, 0.03804221f, 
    0.00368579f, 0.00018221f, 0.00782545f, -0.01202696f, -0.01800025f, -0.02377986f, 0.02824059f, -0.02412449f, 
    -0.02637529f, 0.00798126f, 0.01899653f, 0.00158053f, -0.01540468f, -0.00589999f, -0.02707365f, -0.03277281f, 
    -0.00286476f, -0.02502547f, 0.00860881f, 0.02293155f, -0.03729404f, -0.01579004f, 0.02143450f, -0.02128802f, 
    0.01068836f, -0.02742951f, 0.02423917f, 0.03152224f, -0.02689113f, -0.02190867f, -0.00420927f, -0.02306544f, 
    0.01119044f, 0.00663687f, -0.02696725f, -0.01291631f, 0.01101058f, -0.00778175f, -0.00301838f, -0.01801537f, 
    -0.03436335f, -0.00178653f, 0.00162010f, 0.02651685f, 0.02011723f, -0.00953085f, 0.00904619f, -0.00696833f, 
    -0.02309030f, 0.01082664f, 0.02958376f, -0.02489683f, 0.01661952f, 0.02852233f, -0.00004705f, 0.01045640f, 
    -0.03349131f, -0.01190801f, -0.02878934f, -0.03247665f, 0.01146081f, -0.02476688f, -0.00499199f, -0.03699099f, 
    0.03418935f, -0.02607650f, 0.03120960f, 0.02647477f, -0.02876568f, -0.01486190f, -0.03251840f, 0.01028819f, 
    0.03294475f, -0.01686637f, 0.00449525f, -0.01938758f, 0.00334739f, -0.00577008f, -0.03915958f, -0.03362027f, 
    0.00281142f, 0.01079928f, -0.02131794f, -0.00459331f, 0.02141211f, -0.00047052f, 0.00442679f, -0.02893487f, 
    -0.00917799f, -0.01994121f, 0.02402788f, -0.00196357f, 0.00961187f, 0.01238897f, 0.02897168f, 0.01254018f, 
    -0.03507617f, 0.00838754f, -0.01703601f, -0.02739104f, -0.02784805f, -0.00483461f, -0.02218061f, 0.02748814f, 
    -0.01370079f, -0.02258612f, 0.02427537f, -0.02066178f, -0.00228909f, 0.02479002f, -0.02428194f, -0.00720792f, 
    -0.01315429f, 0.01060941f, 0.00970040f, -0.02631206f, 0.01871261f, -0.01408857f, 0.00624400f, -0.03934049f, 
    0.03117781f, 0.00284336f, -0.00115809f, -0.01149322f, 0.01541382f, 0.02735494f, -0.01523775f, -0.00493992f, 
    0.00298454f, 0.02753211f, 0.03849397f, -0.01079917f, -0.01204325f, -0.00937938f, 0.00491077f, -0.02744254f, 
    0.02963668f, -0.00526663f, -0.02237613f, -0.03628829f, -0.01635247f, -0.02313263f, -0.03919930f, -0.02666212f, 
    0.01687877f, -0.02238611f, 0.00528803f, 0.00834351f, 0.01645465f, -0.01968836f, -0.00705079f, -0.00943778f, 
    -0.01202570f, -0.02524488f, -0.00942291f, -0.01889785f, 0.02093548f, 0.03238678f, -0.02675822f, -0.00992401f, 
    -0.01564995f, 0.00061557f, 0.03053282f, 0.00794175f, 0.02001284f, 0.01158128f, 0.01446953f, 0.00452907f, 
    -0.00648109f, -0.00605099f, 0.01314203f, 0.01463956f, -0.01854294f, -0.02879911f, -0.03534258f, 0.01032667f, 
    0.03246843f, 0.00401387f, -0.01400420f, -0.00314987f, 0.00226161f, 0.02747560f, 0.00820924f, -0.02214438f, 
    -0.00763072f, 0.00376200f, 0.00176189f, -0.01850838f, -0.01162680f, -0.02460941f, 0.01252166f, -0.04374552f, 
    -0.00513497f, 0.00364054f, 0.00959213f, 0.00437750f, 0.01757742f, 0.00079144f, 0.03300585f, -0.00898066f, 
    0.01215444f, 0.00981470f, -0.03323718f, 0.00323321f, 0.02254112f, -0.01086999f, -0.01201276f, 0.02091925f, 
    0.03583096f, 0.00195672f, 0.03397606f, 0.01517292f, 0.01486696f, 0.02079391f, -0.02852876f, 0.03740318f, 
    0.00957443f, 0.01184285f, -0.01394295f, -0.03825143f, -0.01038301f, 0.00629045f, -0.01598955f, 0.00172312f, 
    -0.02563790f, 0.00023907f, 0.02935456f, -0.02997472f, -0.02480810f, 0.00896594f, 0.01043894f, -0.00837235f, 
    -0.02795692f, -0.04918144f, -0.03379297f, -0.02240023f, 0.02256657f, -0.02491755f, -0.00550854f, -0.04083749f, 
    0.02889281f, -0.02041681f, 0.01569841f, -0.02652693f, 0.03207210f, -0.02097923f, -0.01699493f, -0.00680644f, 
    -0.00388328f, -0.03555248f, 0.00502905f, -0.04577575f, 0.01103535f, -0.02091260f, -0.03130902f, 0.02338494f, 
    -0.03002016f, 0.01140715f, -0.02399459f, -0.03831093f, -0.00090137f, 0.01015893f, -0.00936278f, 0.03520797f, 
    -0.02219142f, 0.00796982f, -0.03747997f, 0.01606211f, -0.00364308f, -0.03957833f, 0.00461495f, -0.01958634f, 
    0.00251879f, -0.02884405f, -0.02907714f, -0.01705797f, 0.01904899f, -0.01823125f, 0.02749443f, 0.00836375f, 
    0.00337448f, 0.00075621f, -0.00270369f, -0.01315753f, -0.02653724f, 0.02975513f, 0.00250345f, 0.01411592f, 
    0.03380312f, 0.00450315f, -0.03752285f, -0.02608155f, -0.01840647f, 0.01471993f, -0.02905687f, 0.00564923f, 
    -0.00107145f, 0.01972905f, -0.00470641f, 0.02433711f, -0.02052860f, -0.03499214f, 0.01731901f, -0.02413943f, 
    0.00915276f, 0.00119371f, -0.00165870f, -0.00130231f, -0.02320373f, 0.00247585f, -0.03241773f, -0.01047998f, 
    0.00140814f, 0.03585055f, -0.00248309f, -0.02430331f, -0.01152362f, 0.00368885f, 0.00009251f, -0.02262882f, 
    0.02720235f, 0.00614805f, 0.00323390f, -0.03175049f, 0.02255688f, -0.04336498f, -0.02717730f, 0.00314594f, 
    -0.02479936f, 0.01656363f, 0.02842575f, -0.01832775f, 0.00163954f, 0.01576753f, -0.00156090f, 0.01923080f, 
    -0.03548934f, 0.00213784f, -0.00750146f, -0.00241264f, -0.01675067f, -0.01464095f, 0.00072610f, 0.01773959f, 
    0.01800538f, -0.00386166f, -0.01104711f, 0.02691110f, 0.02509376f, -0.02015523f, -0.03130007f, -0.02423739f, 
    -0.00775720f, 0.02091844f, 0.01009310f, 0.00896134f, -0.03442709f, -0.01628030f, 0.02920461f, -0.00529685f, 
    0.02770671f, 0.00288321f, 0.01882070f, -0.00411099f, -0.02039328f, 0.02721618f, -0.00516830f, 0.03325760f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03757449f, -0.00658334f, 0.08733809f, 0.06064280f, -0.02556132f, -0.01128881f, 0.01283280f, 0.00306189f, 
    0.08615553f, 0.09283918f, -0.00323030f, -0.01505701f, -0.01543731f, 0.00847057f, 0.02828989f, 0.02428508f, 
    -0.02442442f, -0.03140171f, 0.02204777f, 0.01005017f, -0.01611152f, -0.00008447f, 0.00663715f, 0.01660621f, 
    0.02827119f, -0.03197919f, 0.06588056f, -0.01186020f, 0.03439758f, -0.03509048f, 0.09014481f, -0.02130272f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07716957f, 0.12567079f, -0.03082604f, -0.12396836f, 0.08877355f, 0.15939704f, 0.04280497f, 0.13643649f, 
    0.02331229f, -0.12378716f, -0.13612314f, 0.03610059f, 0.06163745f, -0.10171316f, 0.16306745f, -0.02897887f, 
    -0.12034392f, -0.14775443f, 0.02623664f, -0.14329888f, -0.00096917f, 0.10655002f, 0.12499537f, -0.12262071f, 
    0.04047463f, -0.00543540f, 0.00118667f, -0.06277765f, 0.14815892f, 0.13564122f, 0.12854347f, -0.04162185f, 
    0.07783882f, -0.10228248f, -0.04709655f, -0.12926692f, -0.03125235f, -0.10702632f, 0.15644570f, 0.10228783f, 
    -0.02252133f, -0.14893925f, -0.06740028f, 0.00053270f, 0.15045542f, -0.10315786f, 0.07932452f, -0.05522746f, 
    -0.04356417f, -0.04064055f, -0.16894250f, 0.07863051f, -0.15937231f, -0.02544989f, 0.14627251f, -0.12587205f, 
    -0.01182817f, -0.03890615f, -0.14086549f, -0.17211910f, 0.08482390f, 0.02210067f, -0.16976026f, 0.13128085f, 
    0.14960831f, 0.10882301f, 0.36128587f, -0.03231649f, -0.03958122f, 0.00576401f, 0.50598878f, -0.10429962f, 
    -0.24571714f, -0.04037591f, -0.09738703f, -0.13740548f, -0.03217592f, 0.07026302f, 0.10086231f, 0.06575498f, 
    0.08427556f, -0.13465160f, -0.10171733f, 0.15361066f, 0.07598032f, 0.16860840f, 0.11328498f, -0.15635636f, 
    -0.22949782f, -0.09834920f, 0.21900800f, 0.24319933f, 0.22072503f, -0.08090508f, 0.14879046f, 0.06710127f, 
    -0.03230077f, 0.13933896f, -0.04189458f, -0.00193196f, 0.04243048f, 0.05943180f, 0.07606941f, 0.07206120f, 
    -0.20668626f, 0.03314261f, -0.16791882f, 0.07357925f, 0.04971988f, 0.02016796f, -0.08897242f, 0.02052476f, 
    -0.22679986f, 0.02082602f, 0.02635249f, 0.13405134f, -0.34535220f, -0.08804774f, 0.02811776f, 0.07182594f, 
    0.06346220f, -0.06257898f, 0.23895930f, -0.15679133f, 0.31927958f, -0.07841815f, 0.42367283f, -0.15632373f, 
    -0.08823144f, 0.04596468f, 0.09872787f, -0.25957149f, -0.10566293f, -0.14937030f, 0.18912570f, 0.11050497f, 
    -0.20953394f, 0.17741534f, -0.08103736f, 0.08954753f, -0.12687413f, -0.21033072f, 0.00463969f, -0.00182378f, 
    0.39334965f, -0.00016669f, 0.09217729f, -0.13358372f, -0.26873702f, 0.06458174f, -0.15056571f, -0.18211886f, 
    -0.06666222f, 0.10670319f, 0.21926208f, -0.20938526f, 0.20814791f, -0.17140178f, -0.46468043f, 0.00399177f, 
    0.02555456f, 0.02116745f, 0.08609097f, -0.11975375f, -0.08678763f, -0.01921944f, 0.14589837f, 0.03674278f, 
    0.29489622f, 0.04238869f, -0.03359051f, -0.00512750f, -0.14611638f, -0.04065432f, 0.01344128f, 0.15708686f, 
    0.22136758f, 0.11428430f, -0.11364291f, 0.02482023f, 0.51972145f, -0.15859893f, -0.06859785f, -0.01330415f, 
    -0.34637687f, 0.14505465f, 0.06274898f, 0.18186398f, -0.02612003f, 0.13956366f, -0.16388983f, -0.17072238f, 
    -0.11339141f, -0.01904106f, 0.00308188f, 0.21752807f, -0.16785133f, -0.00301691f, 0.07149323f, 0.08972547f, 
    -0.20990354f, -0.01348143f, -0.47003391f, 0.10045314f, 0.04426926f, 0.37052637f, 0.14635514f, -0.01046699f, 
    -0.26603493f, 0.16989627f, -0.13781618f, 0.01531328f, 0.20519710f, 0.06535351f, 0.02625530f, -0.14484656f, 
    0.39447322f, -0.05122643f, -0.06843091f, -0.15207237f, 0.23691027f, -0.16802946f, -0.05643009f, 0.10587309f, 
    -0.00662948f, 0.15739323f, 0.09981322f, 0.09555946f, -0.02700504f, -0.05469713f, -0.16627932f, 0.15294971f, 
    -0.15156302f, -0.17957452f, -0.05932308f, 0.06660524f, 0.01041739f, 0.05651342f, -0.12000245f, 0.12657830f, 
    0.18086243f, 0.16440117f, 0.08387804f, 0.02767432f, 0.03747425f, -0.03773145f, 0.12627368f, -0.13002466f, 
    0.03740783f, 0.01187138f, 0.01211156f, -0.13900547f, -0.01412134f, 0.07758585f, -0.10137052f, -0.02360556f, 
    0.07921173f, 0.05207745f, -0.27281749f, 0.00942132f, -0.02897246f, -0.10560815f, -0.18367936f, 0.07575653f, 
    -0.18721548f, 0.19864711f, 0.36370388f, -0.05066770f, -0.15730309f, -0.20437834f, -0.04052352f, 0.12885825f, 
    0.25463200f, -0.08332314f, -0.15280443f, 0.15929802f, -0.22359726f, -0.11200321f, 0.07228292f, 0.10309552f, 
    0.02927915f, -0.13939992f, -0.02488239f, 0.00580788f, 0.22154221f, 0.03790430f, -0.27864105f, 0.13909271f, 
    -0.03581578f, -0.16140312f, 0.37532324f, -0.12485926f, 0.08728217f, -0.10269210f, 0.23400500f, 0.09069161f, 
    0.23244897f, -0.03756216f, -0.18140383f, -0.14383374f, 0.06482055f, 0.05120009f, 0.17156324f, 0.11668638f, 
    0.04772263f, -0.07260713f, 0.02670524f, 0.12359758f, 0.09478472f, -0.06607039f, 0.12664224f, 0.21749042f, 
    -0.23994350f, -0.15147747f, 0.26986322f, -0.06992306f, 0.03821927f, -0.05891560f, 0.41710648f, 0.07109133f, 
    0.03393839f, 0.14390975f, 0.21118596f, -0.03564717f, 0.06524006f, -0.08566437f, -0.14283219f, -0.14710717f, 
    -0.02416388f, 0.23005754f, 0.38751158f, -0.01249441f, -0.04724880f, -0.40331578f, -0.14909646f, -0.01057364f, 
    0.20024733f, 0.06317547f, -0.12431124f, -0.02148772f, -0.33050966f, 0.10857200f, -0.11683700f, 0.15465343f, 
    0.07664436f, 0.00770931f, 0.01537243f, 0.30679315f, -0.11005989f, 0.01226572f, 0.00875843f, -0.06400413f, 
    0.11308351f, 0.07093914f, -0.10056377f, -0.11788076f, 0.13927677f, 0.02899486f, -0.26267898f, 0.09899727f, 
    -0.03642330f, 0.07736503f, 0.15544571f, -0.11671361f, 0.10020086f, -0.00245066f, -0.12527025f, -0.08015500f, 
    0.18237913f, 0.02035604f, 0.05876989f, 0.04000268f, -0.08981344f, -0.03493687f, -0.13557039f, 0.38126746f, 
    -0.06237123f, 0.09581991f, -0.04607342f, 0.27239367f, 0.27503997f, -0.07032303f, -0.36401913f, 0.08477452f, 
    0.04347038f, -0.14813913f, -0.52914315f, 0.07405160f, -0.10225900f, 0.01902943f, -0.37209803f, 0.02843431f, 
    -0.32781482f, -0.03115998f, 0.14491795f, -0.10274402f, -0.16350229f, 0.00322502f, 0.11477391f, 0.04045775f, 
    0.21219827f, -0.06868633f, -0.14406182f, 0.00728347f, 0.37322390f, 0.14000319f, 0.16162612f, -0.13199188f, 
    0.07072712f, 0.09676000f, 0.25620893f, 0.20824549f, 0.22891918f, -0.12246571f, -0.11335154f, -0.09139654f, 
    -0.02295869f, -0.08276929f, -0.02919522f, 0.09612262f, 0.07373740f, 0.12664118f, -0.06517301f, -0.15378836f, 
    -0.16144590f, 0.00210539f, -0.16655239f, 0.01259682f, -0.01501386f, -0.09829699f, -0.14794631f, -0.17140488f, 
    -0.10534884f, 0.13583712f, -0.03264237f, 0.00134799f, 0.08413837f, -0.11615743f, -0.16366130f, -0.07234181f, 
    -0.11030085f, -0.00321491f, -0.00780499f, 0.10161018f, -0.15040182f, 0.12646924f, -0.13128203f, -0.09428529f, 
    -0.03861235f, -0.10668896f, 0.14114177f, 0.06601001f, -0.11780345f, 0.06233483f, -0.30561683f, -0.09837367f, 
    -0.03919239f, 0.34196171f, -0.22909462f, 0.16856566f, 0.17647053f, -0.13859068f, 0.06270790f, 0.06141617f, 
    -0.20586334f, 0.12778690f, 0.13835311f, 0.10559014f, 0.10052554f, 0.16341591f, -0.09909134f, 0.37221399f, 
    -0.20477767f, 0.05237749f, -0.26622486f, 0.14985710f, 0.05200972f, -0.08190703f, -0.12925145f, 0.12736247f, 
    -0.12489576f, 0.16875261f, -0.10498738f, 0.03790998f, 0.08493540f, -0.12967302f, -0.02190728f, -0.01736922f, 
    0.13013481f, -0.06817141f, -0.08461426f, 0.02992797f, -0.09108663f, -0.18175006f, -0.12975037f, -0.00667631f, 
    0.03991329f, 0.15452568f, 0.02063819f, -0.06380239f, -0.09416972f, -0.15091069f, 0.07325861f, -0.17690167f, 
    0.01986459f, 0.07613877f, 0.06418183f, -0.05182496f, 0.02497995f, 0.06508241f, -0.16664173f, 0.01146814f, 
    0.04087338f, 0.04038673f, 0.13342056f, 0.09272844f, 0.07306034f, 0.16785127f, 0.48792166f, -0.07939862f, 
    -0.07008290f, -0.24424873f, -0.14825621f, -0.01985274f, -0.05594387f, 0.35155517f, -0.08747827f, -0.14998500f, 
    -0.09266837f, 0.01003340f, 0.14756104f, 0.03445242f, -0.01061111f, 0.14177988f, -0.15803075f, 0.04886866f, 
    0.00929417f, -0.09441435f, 0.14089289f, 0.41329932f, 0.24115393f, -0.02914752f, -0.31102982f, 0.12970081f, 
    0.16475794f, -0.17454140f, -0.08091237f, 0.23787200f, 0.02602137f, 0.02643337f, 0.22489332f, 0.00809041f, 
    -0.25839096f, 0.14789204f, -0.38274357f, 0.12897336f, 0.04656641f, 0.35208580f, -0.09939121f, 0.11313193f, 
    -0.11186309f, 0.08025975f, 0.00285548f, -0.15291196f, 0.31739414f, -0.12651241f, 0.17124687f, -0.28791222f, 
    0.29095355f, -0.11308862f, 0.02707673f, 0.38211703f, -0.01846467f, 0.12434787f, -0.18285310f, -0.11125535f, 
    0.10130861f, -0.03939149f, -0.22902955f, 0.28503120f, -0.05186696f, 0.09671649f, -0.12961011f, -0.11060029f, 
    0.17764109f, 0.34470960f, -0.05464565f, -0.04867367f, -0.15387307f, -0.16027184f, 0.09812824f, 0.11893906f, 
    0.05689088f, -0.16740607f, 0.07913038f, 0.03247939f, -0.10478605f, 0.12382111f, 0.04382675f, -0.17921768f, 
    -0.23417348f, -0.12025832f, 0.05760881f, -0.61391997f, 0.00514632f, -0.09838980f, 0.18444946f, 0.12275525f, 
    0.09958795f, -0.09722199f, -0.03782870f, -0.11943623f, -0.18081316f, 0.04899852f, 0.06516220f, 0.08262232f, 
    -0.20134419f, 0.17774566f, 0.08513319f, 0.05747902f, -0.16514756f, 0.04148598f, 0.03159021f, 0.02947932f, 
    0.12385850f, -0.11893808f, 0.07812484f, -0.11801777f, -0.32649061f, -0.09401651f, 0.05929750f, 0.22396564f, 
    -0.22289237f, -0.06102297f, 0.17278479f, -0.09857909f, 0.35197684f, 0.04795639f, -0.39065000f, 0.01544015f, 
    0.03456722f, -0.05154191f, -0.13794856f, 0.24981545f, 0.12934519f, 0.01108330f, -0.25850514f, 0.01352558f, 
    -0.06432305f, 0.24403697f, -0.27789575f, 0.06412122f, -0.01916263f, -0.20717235f, -0.14241625f, -0.17326272f, 
    -0.32755631f, -0.13130714f, 0.17417970f, 0.05047011f, 0.36665958f, 0.03276458f, -0.06297921f, -0.00012773f, 
    -0.13339239f, -0.07927113f, 0.02055438f, 0.29566476f, 0.21870813f, 0.06122987f, -0.00410041f, 0.17648207f, 
    -0.02649696f, -0.10031819f, -0.26493746f, 0.22876042f, 0.08259492f, -0.16787733f, 0.21351770f, -0.08401877f, 
    0.27829391f, 0.02449134f, 0.17717601f, 0.11715662f, -0.14328989f, 0.24712017f, 0.12980728f, 0.02227370f, 
    0.25842237f, 0.08197619f, 0.15016292f, 0.03726647f, 0.41547388f, 0.13872175f, 0.00923585f, -0.34174833f, 
    0.18776229f, -0.02113908f, -0.11992239f, 0.06789262f, -0.26613382f, 0.14162953f, 0.13583407f, 0.00837267f, 
    0.02085704f, 0.01309675f, 0.02647167f, -0.06502260f, -0.11924304f, 0.09362464f, -0.08299919f, -0.00966217f, 
    -0.30763826f, 0.06924011f, -0.35532779f, -0.15740056f, 0.12924558f, 0.10200397f, 0.02378651f, 0.16616412f, 
    0.00654047f, 0.12180355f, 0.10831310f, -0.04372269f, 0.69398892f, -0.08945795f, 0.09214346f, -0.17908642f, 
    0.13754334f, -0.12818390f, 0.25185072f, 0.32767606f, -0.09158999f, -0.04253548f, 0.29658312f, 0.09677549f, 
    -0.10285941f, 0.15798019f, -0.00710266f, -0.16030170f, 0.09697324f, 0.14831239f, 0.31412074f, 0.11862858f, 
    -0.23580045f, 0.11647701f, 0.07922151f, 0.03856529f, 0.04100434f, -0.09953210f, 0.15988934f, -0.15165228f, 
    0.31024429f, 0.02339840f, -0.14530906f, -0.07939415f, -0.00557442f, -0.12169456f, 0.06962965f, -0.07487609f, 
    -0.21660201f, 0.03958270f, 0.16725630f, -0.31622845f, 0.23092127f, -0.03610459f, -0.38975921f, 0.13053572f, 
    0.11678238f, -0.08157253f, -0.45143339f, 0.16261435f, 0.11092555f, 0.16040471f, -0.12501988f, -0.16299701f, 
    0.11354656f, 0.06606790f, 0.41386634f, -0.02091067f, -0.04477066f, 0.04640326f, -0.07116797f, 0.12024570f, 
    0.20217153f, -0.07021598f, 0.11545518f, -0.13467418f, 0.02176897f, -0.10020333f, -0.13197957f, -0.38265008f, 
    -0.03650582f, 0.09547725f, -0.01536594f, 0.18270026f, 0.04095243f, -0.03642358f, 0.11918585f, -0.10018496f, 
    0.07799429f, 0.01803291f, 0.20773396f, -0.21154568f, 0.06256463f, -0.06459034f, -0.11257890f, 0.09528736f, 
    -0.12545863f, -0.05042775f, 0.40018961f, 0.04200461f, -0.12294973f, -0.02041110f, 0.12981756f, -0.04828459f, 
    0.13588077f, 0.14380723f, -0.14139014f, 0.09552062f, -0.14492790f, -0.13461149f, 0.01591089f, 0.28566426f, 
    0.10999899f, -0.03271865f, -0.01147610f, 0.33251560f, 0.19755584f, 0.15005253f, 0.04355844f, -0.07553194f, 
    -0.01550707f, -0.05772453f, 0.04272389f, -0.00865909f, 0.08083991f, -0.14688724f, -0.11626117f, 0.14620630f, 
    -0.13781933f, -0.02893927f, -0.04442164f, 0.10412021f, 0.02633830f, 0.06486961f, 0.09611566f, -0.05017747f, 
    0.04150898f, -0.15283369f, -0.10441626f, 0.06655134f, 0.04933630f, 0.09692588f, 0.12010164f, -0.16561766f, 
    -0.18097468f, 0.10680731f, -0.15990728f, -0.00019549f, 0.06555654f, 0.03470531f, -0.16813427f, 0.17888452f, 
    0.02972272f, 0.08020916f, -0.12722494f, 0.27024725f, 0.08597884f, -0.12149404f, -0.30594119f, -0.14567260f, 
    0.23524250f, 0.06112484f, 0.19837247f, -0.02048865f, 0.09877206f, 0.36411992f, 0.12327009f, 0.09248687f, 
    0.14245474f, -0.05518434f, 0.15697747f, 0.07305422f, -0.11088384f, 0.07681741f, 0.16875467f, 0.08624680f, 
    0.44079280f, -0.17519751f, -0.00445184f, 0.19638222f, -0.09529547f, 0.05489640f, -0.04866004f, -0.11921141f, 
    -0.10206710f, -0.08724589f, 0.40802464f, 0.26042560f, -0.04428182f, -0.11727568f, 0.06587848f, -0.08153393f, 
    0.30545679f, 0.26541427f, -0.18509921f, -0.07755684f, -0.04306317f, 0.05823348f, 0.08071158f, 0.16323717f, 
    -0.20321442f, 0.01064266f, -0.12348854f, -0.04506398f, -0.15346327f, -0.14736851f, -0.02408046f, 0.05689562f, 
    0.25006747f, -0.04182144f, 0.04263979f, -0.31107682f, -0.12390658f, -0.11485968f, 0.60616457f, -0.13779461f, 
    -0.18334362f, 0.10772044f, 0.20056003f, -0.33851737f, 0.13742258f, -0.04647414f, 0.02279756f, 0.09227455f, 
    0.15833305f, -0.21682063f, 0.30080605f, -0.13330163f, 0.07138912f, -0.32783917f, -0.11076725f, 0.07456599f, 
    0.39812511f, 0.11693137f, -0.10979193f, -0.17243621f, 0.12556532f, 0.05670637f, -0.06640963f, 0.30264053f, 
    -0.03617852f, -0.00251901f, 0.34814224f, -0.16023487f, 0.06208997f, -0.14442709f, 0.15873383f, -0.10625926f, 
    0.09878790f, -0.09241387f, 0.01142128f, 0.05574451f, 0.07471478f, -0.09187809f, 0.13482274f, 0.14465246f, 
    0.09545299f, -0.04605494f, -0.10110757f, 0.01009797f, 0.03775949f, 0.12704787f, -0.03920224f, 0.13779135f, 
    -0.19321251f, 0.01651820f, 0.11154584f, 0.11643514f, -0.15416393f, -0.13785408f, 0.08275188f, -0.12159108f, 
    -0.19658954f, 0.06019732f, 0.00522331f, 0.06199560f, -0.16595750f, -0.12220010f, -0.09655354f, 0.12666947f, 
    -0.03178343f, -0.08478680f, -0.10572394f, -0.19894215f, 0.00865186f, -0.08146445f, -0.03414790f, 0.09432953f, 
    0.33254784f, 0.06790667f, 0.38113832f, 0.11561529f, 0.12113842f, -0.18166299f, 0.07882785f, -0.15026605f, 
    0.34754032f, 0.16818370f, 0.15806115f, 0.07120185f, 0.30949491f, -0.16437861f, -0.13125876f, 0.07125181f, 
    -0.25327855f, 0.08592992f, 0.30148846f, -0.05958120f, -0.10579830f, 0.15587558f, 0.17448163f, -0.02061669f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15409456f, 0.09581709f, 0.08304020f, -0.10348944f, -0.08046035f, -0.01977909f, 0.22267428f, -0.17100824f, 
    -0.14577670f, -0.12700535f, 0.16063514f, 0.06214266f, 0.02415531f, 0.05264412f, -0.08473454f, -0.13406977f, 
    0.07080560f, 0.12757505f, 0.11146754f, 0.02788031f, 0.02814222f, 0.14837986f, -0.17932829f, -0.10727818f, 
    -0.06353059f, -0.03306510f, 0.12627202f, 0.12432528f, 0.04586815f, 0.10014893f, -0.05843890f, 0.05052270f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04675082f, 0.15465042f, -0.10219362f, 0.00707987f, -0.30036330f, -0.20550971f, 0.21892117f, -0.09037572f, 
    -0.20342679f, -0.25434920f, -0.40690947f, -0.01835245f, 0.37998623f, -0.00249739f, -0.07024226f, -0.00899228f, 
    0.02023204f, 0.20660020f, -0.58631170f, -0.09492645f, 0.00790041f, 0.07403366f, 0.46437344f, -0.42727229f, 
    -0.11021841f, -0.01254098f, 0.03578950f, 0.15969416f, -0.29810268f, -0.14122003f, -0.07863501f, -0.36977410f, 
    0.08656941f, 0.01340912f, 0.02101362f, -0.00986392f, -0.17460147f, 0.15615727f, 0.28714705f, -0.00202629f, 
    -0.59141004f, 0.01418984f, -0.42266926f, -0.68554676f, -0.31288376f, 0.16332462f, -0.33123174f, 0.12234270f, 
    0.08529997f, 0.19970536f, -0.08998622f, -0.51259375f, -0.07887558f, 0.33650103f, 0.16469452f, -0.07585289f, 
    -0.03989031f, -0.49032393f, -0.03381917f, 0.00828033f, 0.16522792f, 0.15105242f, 0.15366842f, 0.07962947f, 
    0.07296119f, -0.01720569f, -0.18302408f, -0.15689847f, -0.35759342f, -0.22444685f, -0.39212650f, 0.04167571f, 
    0.33163801f, -0.56060332f, 0.39032269f, -0.09553485f, 0.13758430f, 0.07036385f, -0.19548967f, 0.02737083f, 
    -0.21803750f, -0.04153878f, 0.03145076f, -0.30187804f, 0.02982214f, 0.06032020f, -0.22827239f, -0.48323655f, 
    0.46631241f, 0.04666049f, 0.17021488f, 0.29762450f, -0.09386832f, -0.39021689f, -0.05789198f, 0.00620081f, 
    -0.10692889f, -0.09438217f, 0.06290334f, -0.01055803f, -0.53391987f, 0.43183121f, -0.66960609f, -0.06339253f, 
    0.02006830f, 0.11578346f, -0.15951832f, 0.28782454f, 0.19070946f, 0.00728209f, 0.07155371f, 0.12392515f, 
    0.19478168f, -0.41995692f, -0.67231756f, -0.03257479f, 0.07122720f, -0.47513828f, 0.14634995f, -0.11479814f, 
    -0.39614159f, 0.23123503f, 0.06725001f, -0.25600505f, -0.38634986f, 0.24636631f, -0.07063466f, 0.23423390f, 
    0.06574312f, 0.15742944f, 0.32017234f, -0.03204772f, 0.31502208f, 0.12173478f, -0.15251315f, 0.06761271f, 
    0.01888607f, -0.13888191f, -0.17398001f, -0.13707122f, 0.01320802f, 0.01661683f, -0.20496972f, -0.02738656f, 
    0.26941136f, 0.09979176f, -0.19973280f, 0.13282132f, 0.00485740f, 0.18804820f, 0.07671963f, 0.31754434f, 
    0.20079470f, 0.02597007f, -0.10736866f, -0.26289022f, -0.31659538f, -0.09109943f, -0.13508227f, -0.07225162f, 
    -0.14244145f, 0.09070852f, 0.29691386f, 0.38387063f, -0.82916731f, -0.32656550f, 0.11498442f, -0.10831311f, 
    -0.40883043f, 0.16473325f, -0.24947481f, -0.28661633f, -0.32154471f, -0.11768184f, -0.17578736f, -0.02605513f, 
    0.29475975f, -0.01388080f, -0.03109258f, -0.07424373f, 0.00432696f, -0.25081909f, -0.21810111f, -0.22148611f, 
    -0.45706677f, 0.06583547f, 0.02161969f, -0.09712301f, 0.18576264f, -0.16499081f, -0.11758044f, -0.40388840f, 
    -0.14110236f, 0.13290222f, -0.11441656f, -0.05680994f, -0.66486043f, -0.14458990f, 0.03418899f, -0.13333519f, 
    0.06892668f, -0.22109084f, 0.05872994f, 0.28963345f, -0.20287545f, 0.12891847f, 0.26323286f, -0.14889210f, 
    0.22102468f, 0.01848449f, -0.57219958f, 0.24422216f, -0.04036392f, -0.32768717f, -0.76909345f, -0.48971102f, 
    -0.35259315f, 0.30817482f, -0.09335642f, 0.29250413f, -0.13428076f, -0.48800445f, 0.17039706f, -0.41717067f, 
    0.09015978f, 0.14510944f, -0.01035122f, -0.17291951f, 0.42726901f, 0.10978629f, -0.40026936f, -0.17539638f, 
    0.21049991f, 0.05920641f, 0.16462721f, 0.10082915f, -0.26756343f, 0.16177161f, -0.25208715f, 0.00688221f, 
    0.02960221f, -0.47348037f, 0.20134860f, 0.24487931f, -0.51546085f, 0.20087369f, -0.81869137f, 0.36717772f, 
    0.08208986f, 0.05630101f, 0.11336979f, -0.30164993f, -0.29634646f, 0.26063514f, 0.05505968f, -0.05183953f, 
    -0.14804000f, 0.12418088f, -0.36323100f, -0.49464226f, -0.58547091f, 0.36199987f, -0.04897854f, 0.11646545f, 
    -0.26724726f, -0.05117444f, -0.22197819f, -0.19272511f, -0.64177972f, 0.12210026f, 0.44577888f, -0.13550986f, 
    -0.51785266f, -0.15714520f, 0.44029656f, -0.31355700f, 0.06350410f, 0.23328659f, -0.31893241f, -0.07847350f, 
    -0.25160453f, -0.33789867f, 0.16485080f, 0.13293253f, 0.25755963f, -0.17137903f, -0.18197641f, 0.15545543f, 
    0.00264661f, 0.14889179f, -0.09373499f, 0.31925225f, 0.03704017f, -0.70419431f, 0.14280994f, -0.14057650f, 
    0.34881982f, -0.30906764f, -0.28558964f, 0.03651213f, 0.17787601f, -0.01502384f, 0.06028162f, -0.02820333f, 
    -0.07763832f, -0.12632041f, 0.46061161f, 0.29302546f, 0.13520689f, -0.30653185f, -0.59698230f, 0.18797283f, 
    0.23359904f, -0.15912135f, 0.04305382f, -0.17056051f, -0.15129343f, -0.19231863f, -0.01780378f, -0.24873993f, 
    0.17394032f, -0.17828014f, 0.08361843f, 0.26389796f, -0.25177768f, -0.38011995f, -0.64538699f, 0.04879248f, 
    -0.03624201f, 0.07427775f, 0.13929991f, -0.08146290f, -0.17177831f, 0.14789329f, -0.51972800f, 0.00767842f, 
    -0.27001017f, -0.47232851f, -0.15500373f, -0.01827545f, -0.26613545f, 0.06055715f, -0.40524334f, -0.18666536f, 
    0.25138319f, 0.30689067f, -0.15258589f, 0.04138456f, 0.15888838f, 0.29628587f, 0.10517765f, 0.11057565f, 
    0.01058415f, -0.02059394f, 0.09421354f, 0.17510974f, -0.40641052f, -0.14479133f, -0.38385549f, 0.12150740f, 
    0.10745291f, 0.05936804f, 0.33605549f, -0.04687485f, -0.35866374f, -0.10284721f, 0.56340313f, 0.14637321f, 
    -0.32514817f, -0.22033766f, 0.11687204f, 0.04792728f, 0.22555485f, -0.63756758f, 0.08182249f, -0.21635191f, 
    -0.41196215f, -0.08035744f, 0.02297798f, -0.26948655f, 0.05744197f, -0.08804184f, 0.08118409f, -0.14390574f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23376796f, -0.16038887f, -0.01520704f, -0.08542892f, -0.13123830f, -0.01385354f, 0.17338929f, 0.05018347f, 
    0.01922648f, 0.13303214f, 0.07578127f, -0.15530482f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
