#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.88936001f, 0.25750774f, -0.07218596f, -0.14348835f, -0.54300916f, 0.02098061f, -0.00889010f, -0.08429737f, 
    -0.08252832f, -0.15017810f, 0.21126264f, 0.00408669f, -0.08452774f, -0.24014823f, -0.15455946f, -0.21637428f, 
    0.03288775f, 0.06204005f, 0.06792265f, -0.17513594f, -0.37659511f, 0.07969189f, -0.02375424f, -0.20868711f, 
    -0.73338622f, -0.81214499f, 0.16836414f, -0.03480843f, -0.09156328f, -0.29925609f, 0.12738346f, -0.16310327f, 
    -0.72019351f, -0.58068866f, 0.14378296f, -0.14220768f, -0.18749425f, -0.16947924f, -0.29581657f, -0.05235040f, 
    0.29955113f, -0.42797345f, 0.10991143f, -0.22497955f, -0.27813685f, 0.04484095f, -0.03016424f, -0.17768215f, 
    -0.26333794f, 0.24303657f, 0.29826453f, -0.20117478f, -0.22191182f, -0.28138697f, -0.35652706f, -0.12112115f, 
    -0.34564570f, -0.37013528f, -0.71674901f, -0.53502101f, -0.22568679f, -0.17199692f, -0.07796942f, 0.40715498f, 
    -0.17741604f, -0.21444824f, -0.51787591f, -0.30067676f, 0.23667361f, -0.49040219f, -0.28478581f, -0.52132279f, 
    -0.27299750f, 0.30826369f, 0.18471818f, -0.40764037f, 0.47597617f, -0.41440204f, -0.50742483f, 0.07623351f, 
    -0.06634799f, -0.07491377f, 0.53376061f, 0.12222609f, 0.15247491f, -0.26670000f, -0.22918378f, 0.33331636f, 
    -0.06926166f, -0.13932663f, 0.35151657f, 0.01868334f, -0.22650170f, -0.29667336f, -0.09184845f, -0.01149424f, 
    -0.06824917f, -0.34588784f, -0.21780936f, -0.48820537f, -0.08001065f, -0.68670928f, -0.23145972f, -0.22384475f, 
    -0.52985436f, 0.21429887f, -0.17144951f, 0.50374460f, 0.62383932f, 0.34661534f, 0.35503054f, 0.35352701f, 
    -0.27289343f, -0.08696931f, -0.17648314f, 0.19068001f, 0.30652541f, 0.18174446f, -0.48944050f, -0.33137113f, 
    0.13934267f, 0.09849076f, 0.13856016f, -0.16873956f, 0.02867625f, 0.65397000f, -0.00300789f, -0.25034997f, 
    0.01704085f, -0.38116315f, 0.33584443f, -0.20541725f, -0.21440606f, -0.38543081f, -0.37178996f, -0.10679245f, 
    0.27968973f, -0.07826241f, -0.22635558f, -0.21998145f, 0.22401200f, 0.49885511f, 0.29290500f, -0.48050919f, 
    0.01847233f, -0.46245077f, -0.03924616f, -0.00324862f, 0.36528766f, 0.25643447f, -1.11971807f, -0.74280733f, 
    -0.84839058f, -0.15438287f, 0.80480957f, -0.07136396f, 0.00385133f, 0.11936560f, 0.63287640f, 0.06547632f, 
    0.40353173f, 0.09129687f, -0.20400602f, 0.11793822f, 0.11237874f, -0.00738264f, -0.06185560f, -0.17508653f, 
    -0.09359556f, -0.17131077f, -0.36303648f, 0.34140962f, 0.41741931f, 0.07319095f, 0.03473538f, -0.84465629f, 
    -0.08362329f, -0.13534702f, -0.35785747f, -0.68162996f, 0.37205952f, 0.14649786f, -0.06717952f, -0.27455157f, 
    0.27945003f, -0.28160906f, -0.29140294f, -0.18470231f, -0.41425940f, -0.04276942f, 0.22412893f, 0.20556077f, 
    -0.00109275f, -0.06531546f, -0.01874920f, -0.02463911f, -0.00899828f, -0.09660067f, -0.29239145f, -0.07474797f, 
    -0.99961138f, -0.23005514f, -0.45168743f, -0.97448367f, -0.67249978f, 0.40816030f, 0.04219775f, 0.01839205f, 
    0.07417917f, 0.50148726f, -0.17189464f, -0.32237232f, -0.20499611f, -0.24185146f, -0.17067243f, 0.30922535f, 
    0.20036983f, -0.12827063f, 0.17906515f, 0.17516537f, -0.06506070f, 0.05310129f, 0.01560725f, -0.14641091f, 
    -0.26166248f, -0.22586955f, -0.18345360f, -0.35166702f, -0.29066142f, -0.29040897f, -0.61577827f, -0.55249953f, 
    -0.31262365f, -0.43077657f, -0.50808847f, 0.25145322f, 0.25061285f, 0.35125232f, 0.40117297f, 0.14746952f, 
    0.03496425f, 0.07190160f, 0.03236845f, -0.16155128f, 0.22865905f, 0.09934843f, 0.37062007f, -0.02696093f, 
    -0.15716304f, 0.30912650f, -1.09837723f, 0.64257312f, 0.76459235f, -0.16427495f, -0.74998456f, 0.21037075f, 
    0.30900815f, -0.22961208f, -0.01164658f, -0.50103098f, -0.24584658f, 0.41152263f, 0.05131013f, -0.42822412f, 
    -0.35982254f, 0.63048357f, -0.17911077f, -0.18607624f, -0.16966887f, -0.31867924f, -0.06526408f, 0.06026796f, 
    -0.08200134f, -0.17028834f, 0.23364109f, -0.73062521f, -0.02413508f, -0.22200592f, -0.38061759f, 0.09489470f, 
    0.07098407f, -0.39707512f, 1.06466734f, -0.54634112f, -0.28065339f, -0.34680188f, -0.07741046f, -0.14631128f, 
    -0.04910351f, -0.02927608f, 0.10502895f, -0.16915637f, -0.16533339f, 0.28887370f, 0.15638527f, 0.19856884f, 
    0.10117999f, -0.07203643f, -0.00348422f, -0.22447327f, -1.02952623f, 0.56241512f, 0.42685854f, -0.09212377f, 
    0.18964623f, -0.17668650f, -0.50366384f, 0.12612562f, 0.29845795f, 0.31573761f, -0.48158991f, 0.28976524f, 
    -0.43507236f, 0.06192001f, 0.18241730f, -0.01377170f, 0.01066657f, -0.13116297f, 0.13685778f, 0.24786189f, 
    -0.24279433f, 0.26419950f, 0.01812881f, -0.02679954f, -0.28473341f, -1.35547709f, -0.24028395f, 0.23343995f, 
    -0.03019857f, -0.25000572f, -0.07057825f, -0.37308457f, -0.32966971f, 0.14654669f, 0.59492207f, 0.47447664f, 
    0.04255453f, 0.41025242f, -0.22751606f, 0.16195220f, -0.18484508f, -0.33680624f, -0.10407579f, 0.31726325f, 
    -0.02906441f, 0.17736092f, 0.34744334f, 0.17244580f, 0.05257674f, -0.23137291f, -0.12072131f, 0.84020489f, 
    0.44737500f, -0.54654902f, -0.58082557f, -0.45422238f, -0.24507932f, -0.24125947f, 0.38415051f, 0.55326009f, 
    0.10963768f, 0.18891716f, -0.34515727f, -0.47159109f, -0.37611338f, 0.46415961f, -0.23603737f, -0.16537824f, 
    0.12036937f, -0.01839308f, -0.03422683f, 0.09738936f, -0.02381818f, -0.28850141f, -0.37280425f, -0.86617595f, 
    -0.81818175f, 0.32098952f, 0.68655014f, -0.16316381f, 0.14918010f, -0.46391800f, 0.34405595f, -0.39337799f, 
    -0.37637103f, -0.06526453f, -0.12380471f, 0.17600901f, 0.41001531f, 0.22969204f, -0.31721380f, 0.41407245f, 
    -0.30790943f, -0.41207117f, 0.40265575f, 0.23057479f, 0.09563216f, -0.19238152f, -0.37466300f, 0.22205390f, 
    0.08428203f, 0.67964858f, -0.25506952f, -0.14559284f, -0.43156478f, -0.61288553f, -0.40014169f, 0.20323521f, 
    -0.42484495f, -0.46884093f, 0.09839088f, 0.09064151f, 0.28766224f, -0.21036063f, 0.13623010f, -0.28925285f, 
    0.22014056f, -0.02398316f, 0.20524997f, 0.07727371f, -0.14650570f, -0.03422728f, -0.05103864f, -0.31972903f, 
    -0.28631413f, -0.59989005f, 0.53454119f, 0.57884490f, -0.28581086f, 0.37894279f, -0.71921974f, -0.43407410f, 
    0.33418012f, 0.32340899f, 0.01863312f, -0.12743255f, -0.40872911f, 0.42339811f, -0.13182515f, 0.11014410f, 
    0.21685642f, 0.12767866f, -0.11010414f, -0.20312914f, -0.31522572f, -0.00861685f, -0.07479169f, 0.03928574f, 
    0.37014687f, -0.11866599f, 0.65470088f, 0.27068743f, 0.00242720f, -0.54363918f, -0.84942031f, 0.47784764f, 
    -0.06165136f, 0.36472169f, -0.37151033f, -0.37126386f, 0.29317343f, -0.50536233f, 0.51931900f, -0.31196418f, 
    0.13513370f, 0.01267830f, 0.01747932f, 0.11729886f, 0.11679742f, -0.07207495f, -0.38761100f, -0.20492426f, 
    0.09578118f, 0.34368172f, 0.20120227f, 0.40767783f, 0.30283594f, 0.10796696f, -0.29999539f, -0.05825325f, 
    0.28041261f, -0.06108763f, -0.20865111f, 0.16003491f, 0.16883783f, -0.30563709f, 0.61642581f, -0.06610558f, 
    -0.00494081f, -0.01754956f, -0.07516782f, -0.07597768f, 0.10111547f, 0.01012203f, -0.09541409f, -0.02457528f, 
    0.16459180f, 0.26245433f, -0.32854554f, 0.06140941f, 0.55810523f, 0.10860674f, -0.04413588f, 0.17449039f, 
    -0.56179398f, -0.59399629f, -0.35342550f, 0.40163574f, 0.28535703f, 0.04428102f, -0.26427004f, 0.54698002f, 
    -0.30401123f, 0.27707821f, 0.00919695f, -0.12851171f, 0.08007241f, -0.19402516f, -0.25975287f, -0.08505590f, 
    -0.06330183f, -0.18585792f, 0.11579640f, -0.11556627f, -0.01984908f, 0.80509818f, -0.40433642f, -0.70945132f, 
    -0.79966491f, -0.89070404f, 0.10578561f, 0.11449780f, 0.32243618f, 0.34711498f, 0.40961784f, -0.26353705f, 
    -0.09992245f, 0.29958326f, 0.07607662f, 0.20707953f, 0.20003785f, -0.35708827f, 0.03229271f, 0.03469427f, 
    -0.28324389f, -0.04818029f, -0.03013930f, -0.17462935f, -0.14737256f, -0.12183946f, -0.11686196f, 0.16196737f, 
    0.27753469f, -0.08674408f, 0.13060211f, -0.07128568f, -0.41688719f, -0.32997501f, -0.23461066f, -0.22889297f, 
    0.30821416f, -0.07986534f, 0.08905769f, 0.38096935f, 0.14161876f, 0.02857317f, -0.47738424f, -0.19495903f, 
    -0.41458586f, 0.06744514f, -0.09392443f, 0.30329594f, 0.21648064f, 0.32864422f, 0.27914041f, 0.38149053f, 
    0.24448143f, 0.22997935f, 0.05345755f, -0.02471625f, 0.17549594f, 0.05728706f, -0.25387985f, -0.25636381f, 
    -0.14544190f, 0.24624825f, 0.19761550f, 0.33316353f, -0.14348564f, -0.16568387f, 0.26394972f, 0.07964195f, 
    0.11790316f, 0.33091983f, 0.07098971f, 0.14602937f, -0.15228944f, -0.23982716f, 0.12088770f, 0.24900967f, 
    -0.77982730f, -0.32612252f, -0.22466034f, -0.40618789f, -0.28473979f, 0.69140875f, 0.44071788f, -0.04556461f, 
    0.56275856f, 0.19194441f, 0.41158089f, -0.15185016f, -0.23720534f, 0.12143111f, -0.25297797f, -0.46493700f, 
    -0.04215847f, 0.16929960f, 0.05914240f, 0.14038749f, -0.05098647f, 0.09421901f, 0.12673983f, -0.04200624f, 
    -0.18695284f, 0.24881893f, -0.08865511f, 0.16262299f, -0.17299235f, 0.01459838f, 0.41892874f, -0.11196451f, 
    0.27689195f, -0.26782495f, -0.01059453f, 0.11338436f, 0.24111873f, 0.00734352f, -0.06121141f, 0.02641964f, 
    -0.09181909f, 0.02589999f, 0.18213829f, 0.02188132f, -0.02774140f, -0.12949252f, 0.20791993f, -0.24396883f, 
    0.24245137f, 0.06922721f, -0.22768836f, -0.45939851f, 0.31004173f, 0.25894818f, -0.68405592f, -0.68209350f, 
    -0.50460285f, -0.22647153f, 0.33572403f, -0.19539283f, 0.25926143f, -0.20815153f, -0.09120003f, 0.39186886f, 
    -0.24935067f, 0.16798525f, -0.10905883f, 0.26501948f, -0.09967617f, -0.21425593f, 0.17987721f, -0.41652998f, 
    -0.49253172f, -0.22132546f, 0.47012851f, 0.00501787f, -0.14801095f, 0.14982784f, 0.14336842f, 0.31608379f, 
    0.34821948f, 0.09122895f, -0.06913468f, 0.22229472f, 0.10437694f, 0.27518013f, 0.16695045f, -0.35803181f, 
    -0.29677168f, 0.10442231f, -0.34114334f, -0.34004736f, 0.08615562f, 0.14839207f, 0.20287204f, 0.28098312f, 
    0.03367192f, -0.26564220f, 0.06372646f, -0.17844476f, -0.29283261f, 0.42516136f, -0.14865686f, 0.17967768f, 
    -0.16242300f, -0.30715328f, 0.12469748f, 0.38350296f, 0.08452783f, -0.26772204f, -0.13994622f, -0.40185714f, 
    -0.21797343f, 0.11250792f, 0.04437491f, -0.19429058f, -0.28711116f, 0.11197798f, 0.27556008f, 0.31408131f, 
    -0.30098376f, 0.07569693f, -0.38950643f, -0.08040980f, -0.42945522f, -0.39220405f, -1.18024302f, -0.16705380f, 
    0.31919825f, 0.67043000f, -0.76164490f, -0.26923293f, 0.13854288f, 0.59276813f, 0.40243611f, 0.01366428f, 
    0.09402475f, -0.20489421f, 0.11751494f, 0.01718718f, -0.03046695f, -0.17275749f, 0.07509425f, 0.17172992f, 
    0.15911339f, -0.47105739f, -0.18264957f, -0.23398064f, -0.36153921f, 0.53268194f, -0.57460326f, -0.20412816f, 
    0.01995201f, -0.66106999f, -0.42926940f, -0.13256058f, -0.00332563f, -0.51459521f, -0.16819277f, 0.23865135f, 
    -0.08570474f, 0.06647874f, 0.29121739f, 0.15653719f, 0.14107104f, -0.06877146f, -0.11034141f, -0.39869586f, 
    -0.51050061f, -0.41114178f, -0.10225458f, 0.09537061f, 0.06175208f, -0.10462654f, 0.34587827f, -1.23324025f, 
    -0.48891324f, 0.13346900f, -0.16585401f, -0.16171807f, 0.77104294f, 0.22049788f, -0.52634931f, -0.05063917f, 
    0.49331123f, -0.23907283f, -0.43723154f, -0.13758886f, -0.34955961f, -0.47122079f, 0.17001739f, 0.25794449f, 
    -0.38066247f, 0.21498333f, 0.04771362f, -0.12930593f, -0.32347891f, -0.06558252f, 0.02800892f, 0.08259255f, 
    -0.52604204f, -0.03358609f, -0.09882522f, -0.86187780f, -0.67989701f, 0.00442781f, 0.18068756f, 0.17151487f, 
    0.45539197f, 0.12138054f, 0.14613688f, -0.02265640f, 0.17817384f, -0.10308979f, -0.03779616f, -0.43201551f, 
    -0.44763547f, -0.12964104f, -0.26230624f, -0.00921507f, -0.23850435f, 0.61300766f, 0.70118868f, 0.06057522f, 
    -0.10885300f, -0.42724803f, -0.40410480f, -0.05756447f, -0.47495741f, -0.36817780f, 0.22008300f, -0.23758306f, 
    -0.13574412f, -0.30340838f, -0.23816346f, 0.01793346f, 0.25557989f, 0.27223927f, -0.00965476f, 0.03851927f, 
    -0.04993643f, 0.01572113f, 0.23193583f, 0.07975049f, 0.25416613f, -0.26292384f, -0.25632334f, -0.08808405f, 
    -0.34268224f, -0.61014456f, -0.63974905f, -0.54982489f, -0.04665428f, 0.16784543f, 0.52173543f, 0.47708780f, 
    0.16944028f, 0.32974419f, 0.03501613f, -0.39293107f, -0.19654223f, -0.18010710f, 0.08117313f, -0.29385436f, 
    -0.16467980f, 0.07296145f, -0.13596193f, -0.32654932f, 0.26049328f, -0.31643510f, 0.20649447f, 0.25500047f, 
    0.18507956f, 0.07695334f, 0.28279966f, 0.42450291f, -0.49457899f, -0.35495290f, -0.02693417f, -0.54985613f, 
    -0.27518079f, -0.07101426f, -0.33382574f, -0.16586255f, -0.46611723f, 0.19488311f, -0.10263596f, -0.00673445f, 
    -0.15714543f, -0.26478606f, -0.09038528f, -0.14457293f, -0.08476631f, 0.04943520f, 0.15112475f, 0.06888022f, 
    0.28816256f, 0.18794459f, 0.37236324f, 0.22613619f, 0.22668536f, -0.28023690f, 0.04670867f, 0.35615790f, 
    -0.03365837f, 0.38044697f, -0.21887414f, -0.04010692f, 0.11929566f, 0.19543467f, 0.01750835f, 0.03392337f, 
    -0.04028452f, -0.03515382f, -0.17832549f, 0.25324738f, 0.04697030f, 0.14805593f, -0.31067511f, -0.25794184f, 
    0.23960419f, 0.46726489f, 0.27959034f, -0.37769228f, -0.35823458f, -0.47999209f, 0.11076876f, 0.47064805f, 
    -0.19050373f, 0.09974714f, 0.33492926f, 0.14966509f, -0.50317919f, -0.02728048f, 0.39780208f, 0.43011200f, 
    -0.39597446f, 0.00717357f, -0.03812483f, -0.39786345f, 0.04879555f, -0.26767743f, 0.21290629f, 0.41340312f, 
    0.25440490f, -0.03381726f, -0.01840668f, -0.28982693f, -0.10366905f, -0.24039195f, -0.55812734f, -0.49290586f, 
    -0.08736422f, -0.06214362f, 0.39106843f, -0.25663924f, -0.09223788f, -0.23113602f, 0.29264313f, 0.21925814f, 
    -0.31446764f, -0.23188880f, -0.28598922f, -0.25605649f, -0.00480632f, 0.39505041f, -0.22319497f, 0.23492564f, 
    0.21813720f, 0.02907530f, -0.12185147f, -0.32697457f, 0.12102978f, 0.17403407f, 0.49432126f, -0.19130144f, 
    -0.45674947f, -0.30090380f, 0.07281614f, -0.24521421f, -0.60751593f, -0.22324248f, 0.17599803f, -0.39774919f, 
    -0.43132663f, 0.05479152f, -0.16367234f, 0.04929660f, -0.42488700f, -0.18058248f, 0.33577102f, 0.08715022f, 
    0.19610687f, 0.19884101f, 0.19909035f, 0.17887415f, -0.13791528f, -0.19829904f, -0.26981142f, 0.39895758f, 
    0.79600030f, 0.27978954f, 0.08466323f, 0.00569068f, -0.27141911f, 0.21499673f, 0.09800597f, -0.41371968f, 
    -0.09278160f, 0.10492656f, 0.31506261f, -0.19055504f, 0.29964104f, -0.16339524f, -0.16262901f, -0.14283304f, 
    -0.31550476f, 0.05565009f, 0.00753558f, 0.17985630f, 0.02670475f, -0.09791259f, 0.15374498f, 0.11493143f, 
    -0.11524283f, 0.48140910f, 0.15669894f, -0.00718119f, -0.18603416f, 0.22886209f, 0.37278086f, 0.15411974f, 
    -0.15085770f, 0.02126485f, -0.12625679f, -0.09629040f, -0.03508130f, -0.08744650f, -0.19229986f, -0.27905223f, 
    0.03860244f, -0.02510192f, 0.24993585f, 0.03638445f, -0.02628794f, -0.15708159f, -0.18040177f, -0.32183889f, 
    -0.49843112f, -0.56407928f, 0.23033509f, 0.02211236f, -0.68149394f, -0.76317340f, -0.20952176f, 0.01479598f, 
    0.15900950f, -0.00912621f, -0.07879168f, 0.35713053f, 0.06172422f, -0.11876611f, -0.35375237f, -0.22134268f, 
    -0.08830746f, -0.15817772f, -0.54890364f, 0.18532315f, 0.39324096f, -0.41137338f, 0.29651740f, -0.23883323f, 
    -0.03718534f, 0.11683798f, 0.42768282f, -0.09431554f, -0.38792238f, 0.52606207f, 1.08396912f, 0.79660487f, 
    -0.18734458f, -0.41158399f, -0.58969671f, -0.41639382f, -0.33845532f, -0.09743018f, -0.08309374f, 0.11971903f, 
    0.20506285f, 0.10211612f, -0.25817317f, 0.00413540f, 0.31245467f, -0.01549667f, -0.18684922f, 0.12587236f, 
    -0.09899576f, -0.02803545f, 0.34452546f, -0.04504862f, 0.13508216f, 0.40884319f, 0.06707205f, -0.27331036f, 
    -0.15537620f, -0.08319629f, 0.04374536f, 0.50404012f, -0.43663085f, -0.07334875f, 0.08284704f, -0.06678439f, 
    -0.05422084f, -0.11133560f, 0.19303600f, 0.23722318f, 0.21536040f, -0.37585077f, 0.03873161f, -0.03714128f, 
    0.18080629f, 0.44621459f, -0.06568467f, -0.32279852f, -0.08953245f, 0.28426903f, -0.43029431f, 0.25831029f, 
    0.17114592f, 0.11532053f, -0.34185627f, 0.23290451f, 0.10981290f, 0.10737175f, -0.16877078f, -0.21159747f, 
    -0.31118357f, 0.45842910f, -0.39796332f, 0.18494943f, -0.09921373f, -0.10893074f, 0.32390109f, -0.08081891f, 
    -0.03004250f, 0.30091354f, -0.23490246f, -0.29681104f, -0.25009233f, -0.03798989f, 0.61889297f, -0.60215127f, 
    0.10687355f, 0.15566191f, 0.15004410f, 0.23578492f, 0.26837879f, 0.31564400f, -0.36787057f, -0.32731614f, 
    -0.32635060f, -0.03131980f, 0.50219452f, -0.52045190f, 0.20867836f, 0.27808434f, 0.03565364f, -0.21834411f, 
    -0.24264032f, -0.30082843f, -0.07146122f, -0.09346139f, -0.08823588f, 0.17346194f, -0.22186510f, 0.77191174f, 
    -0.76358986f, -0.14262848f, -0.55173504f, -0.50661701f, -0.26623508f, -0.65104151f, 0.10458455f, 0.39648336f, 
    0.56176722f, -0.10629036f, 0.14587158f, 0.20227255f, -0.06981501f, 0.29400480f, -0.26641148f, -0.05802311f, 
    0.11057685f, 0.14342181f, -0.39028433f, 0.17888111f, -0.20037901f, -0.08534441f, 0.05055076f, -0.11419982f, 
    -0.28354555f, -0.16036917f, -0.28133866f, 0.08800922f, -0.58334053f, -0.15688485f, -0.15659548f, -0.57778847f, 
    -0.40559942f, -0.23801224f, -0.25437188f, -0.00062375f, -0.13228273f, -0.42914093f, -0.16239311f, -0.16547365f, 
    -0.29850417f, -0.21015659f, -0.25002709f, -0.07800237f, -0.31245336f, -0.33894148f, -0.15946415f, -0.25479454f, 
    -0.03371985f, -0.44217283f, -0.74170792f, -0.18021807f, 0.43289259f, -0.01796036f, -0.16545521f, -0.68710262f, 
    -0.58805192f, 0.21709105f, -0.33806530f, 0.12395912f, 0.30027565f, 0.08365688f, 0.28350437f, 0.22494908f, 
    -0.03273072f, 0.07471050f, -0.15593913f, -0.33307749f, -0.13216957f, 0.09449125f, 0.43534279f, -0.05274031f, 
    0.17450716f, 0.33801231f, -1.04648149f, -0.97044277f, 0.03987575f, 0.95803344f, 0.91451126f, 0.35217938f, 
    0.04489866f, -0.82421911f, -0.67973948f, -0.53505790f, -0.36730298f, -0.14053383f, -0.33971027f, 0.29061550f, 
    -0.55795580f, -0.26922336f, -0.07017391f, 0.03401116f, 0.01985967f, 0.31425169f, 0.07386395f, -0.06151631f, 
    -0.14975318f, -0.11971758f, -0.42212090f, -0.49382403f, -0.19835110f, 0.16957045f, 0.22456336f, 0.47502372f, 
    0.15896583f, 0.47284165f, 0.30853841f, -0.29095989f, -0.37958565f, -0.04909785f, -0.27193391f, -0.16719666f, 
    0.16914302f, -0.07698052f, -0.31077778f, 0.34344831f, -0.07082390f, 0.27936754f, -0.13350418f, 0.41376722f, 
    -0.16199209f, -0.02722130f, -0.25493178f, -0.18181545f, 0.32684737f, -0.43841299f, -0.49103045f, 0.48727825f, 
    -0.08085293f, 0.48066652f, 0.29649264f, -0.28243780f, -0.23088759f, 0.46902037f, 0.52791035f, -0.38644993f, 
    -0.26120472f, 0.00995576f, 0.57579356f, -0.46429345f, -0.06630927f, 0.18079688f, 0.19060035f, -0.05610642f, 
    -0.06201977f, 0.10287388f, 0.14068773f, -0.05030928f, -0.21191473f, 0.40230852f, 0.29354241f, 0.22872461f, 
    -0.03234408f, -0.16933984f, 0.06511657f, 0.25060591f, -0.07154585f, -0.20958099f, 0.49241450f, -0.01340697f, 
    0.24579662f, -0.28427407f, -0.40287024f, 0.03188622f, -0.08550327f, -0.11879809f, 0.07377686f, 0.00753875f, 
    0.02222353f, 0.19333056f, -0.26990631f, -0.04942483f, -0.27241623f, -0.25980479f, -0.28247273f, -0.52151370f, 
    -0.72065598f, -0.56377995f, -0.60254365f, 0.65691757f, 0.19893754f, 0.32168302f, -0.19345391f, -0.04204727f, 
    -0.01591053f, -0.16409002f, 0.07937749f, 0.07624263f, 0.16508853f, -0.26237807f, 0.15572295f, -0.05012434f, 
    -0.25837418f, -0.15933110f, -0.28181118f, -0.23710111f, 0.09438216f, -0.21770969f, -0.13177834f, -0.19789086f, 
    0.25693339f, 0.14143692f, -0.00088306f, 0.25532559f, -0.04874415f, -0.49186540f, 0.14967476f, 0.14125463f, 
    -0.08509997f, 0.24698915f, 0.08762339f, -0.23371731f, -0.26529709f, 0.03189598f, -0.20335904f, 0.09672775f, 
    -0.13544101f, -0.21176730f, -0.11994770f, 0.24802922f, -0.01446871f, 0.24225768f, 0.53633040f, 0.15278485f, 
    0.48323372f, 0.46633425f, -0.05174514f, 0.43441796f, 0.27606723f, -0.66270876f, -0.71328241f, 0.17983626f, 
    -0.08148357f, -0.33815047f, 0.15876932f, 0.31043983f, 0.32334533f, 0.06060785f, -0.33125192f, 0.11229412f, 
    0.36002150f, -0.26477662f, -0.00867527f, -0.41154274f, 0.09242617f, -0.18803525f, 0.07220321f, -0.03872446f, 
    -0.02411013f, -0.03608321f, -0.31133273f, -0.33217347f, -0.19990656f, -0.25831366f, -0.04296201f, -0.17011927f, 
    -0.61906713f, -0.42496184f, -0.64166319f, 0.02862255f, -0.01323980f, 0.01416113f, 0.52887839f, -0.28207511f, 
    -0.23172849f, -0.02547705f, -0.18229164f, 0.16146925f, -0.15850894f, -0.34971151f, 0.00907969f, 0.09901285f, 
    0.21820100f, 0.06187617f, 0.97117066f, -0.27198061f, -0.74278188f, -0.74638134f, -0.79168874f, 0.56021124f, 
    0.45139083f, 0.16060357f, 0.22906859f, 0.13288580f, 0.04090120f, 0.24111706f, -0.27333277f, 0.02759676f, 
    0.04516514f, 0.09739553f, -0.17144252f, -0.19230422f, 0.15411036f, -0.02918781f, 0.28125641f, -0.02150382f, 
    -0.21466665f, 0.07526710f, 0.02411640f, -0.11759505f, -0.13773720f, -0.49272448f, -0.59714776f, -0.57370311f, 
    0.40596917f, 0.30870321f, 0.38731432f, -0.33588493f, -0.23246503f, 0.07256062f, -0.21036008f, -0.08913090f, 
    -0.04156605f, -0.02900454f, -0.21769725f, -0.06117785f, 0.06137902f, 0.20724124f, -0.27122566f, -0.09686494f, 
    -0.21467350f, 0.07771810f, -0.50171673f, -0.34398323f, -0.02066141f, 0.09078122f, -0.13070300f, 0.16082725f, 
    0.40673682f, 0.13730316f, 0.38949874f, 0.16970935f, 0.01854001f, 0.28175172f, 0.14342248f, 0.35144699f, 
    0.01923693f, -0.32525578f, -0.19342113f, -0.20388928f, 0.06120085f, -0.13218544f, -0.18734182f, -0.08238661f, 
    0.11562150f, -0.06714790f, 0.25343829f, 0.00078840f, -0.10934956f, 0.32318771f, -0.19645056f, -0.41401604f, 
    -0.44384888f, -0.59968740f, -0.70347184f, -0.50491238f, -0.03312882f, 0.26117399f, 0.36730152f, 0.23335147f, 
    0.30223706f, 0.12767529f, -0.20425996f, -0.22092007f, 0.00393285f, -0.17480665f, 0.03483304f, -0.17521025f, 
    -0.20348175f, -0.11461133f, -0.36084732f, -0.20754002f, -0.23950413f, 0.08580235f, -0.90832812f, 0.66135514f, 
    0.95179147f, -0.79693121f, -0.71505135f, -0.43413061f, 0.32769075f, 0.15047464f, -0.04906010f, 0.00753901f, 
    0.19922796f, 0.44597343f, -0.31883538f, 0.14274667f, -0.23536743f, -0.13674830f, -0.11885720f, -0.14726469f, 
    -0.39430264f, -0.38149604f, -0.11101214f, 0.04167016f, 0.21935488f, 0.08231215f, 0.29113954f, -0.07450918f, 
    0.72773886f, 0.69462055f, -0.66448593f, -0.59809339f, -0.15414141f, -0.10794614f, -0.16922571f, 0.35177484f, 
    -0.36784992f, -0.54530573f, -0.33230808f, 0.03073235f, 0.19213475f, 0.10026560f, 0.49929228f, 0.12505534f, 
    0.10860459f, -0.26528186f, -0.26741365f, 0.08835138f, -0.30598122f, -0.30418742f, -0.35687548f, -0.17656603f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17763092f, 0.27211490f, -0.25286758f, 0.04901559f, 0.03076524f, 0.12079437f, 0.20659496f, -0.37766603f, 
    -0.32816273f, -0.03586062f, 0.34798676f, 0.02039937f, 0.28952181f, 0.25566179f, 0.18265627f, 0.08664849f, 
    0.24854107f, 0.19054319f, 0.17076823f, 0.19190282f, 0.23325613f, 0.07359200f, 0.17726806f, -0.06615999f, 
    0.03940670f, 0.02395116f, 0.18012710f, -0.14446197f, 0.01800446f, 0.22058633f, -0.19405231f, 0.01054614f, 
    -0.03688680f, -0.28588033f, -0.16656849f, 0.10361527f, -0.04262375f, 0.16651134f, -0.34939095f, -0.06376614f, 
    0.18066293f, 0.04743443f, -0.04739650f, 0.21267465f, 0.21792594f, 0.16568775f, 0.35538682f, 0.31605920f, 
    -0.29354227f, 0.11601336f, -0.16336322f, -0.05913803f, 0.11040058f, -0.01100189f, 0.04702415f, 0.12648627f, 
    0.09999330f, -0.24353175f, 0.20080072f, -0.00181801f, 0.01589247f, 0.10066164f, 0.29302615f, 0.25607643f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01174226f, -0.03352729f, -0.00286834f, 0.02042460f, -0.01042613f, 0.01937385f, -0.01658184f, -0.02984831f, 
    0.00897897f, 0.00937517f, 0.01979552f, 0.00230647f, -0.01518614f, -0.03006903f, -0.00640625f, 0.00334597f, 
    0.00245487f, 0.01645693f, 0.02499127f, -0.00816921f, -0.00901239f, 0.01455155f, 0.00134205f, -0.01882959f, 
    0.00038259f, -0.03026176f, -0.03342498f, -0.02182152f, -0.00998429f, 0.00994302f, -0.00662864f, -0.04162946f, 
    -0.02348393f, 0.02666028f, 0.02499978f, 0.01615859f, -0.00927423f, 0.02608350f, 0.01078186f, -0.03333000f, 
    0.02374363f, -0.01107860f, 0.02334374f, -0.01878307f, 0.00641264f, -0.00007697f, 0.00899862f, 0.02388100f, 
    0.02598612f, 0.01875387f, 0.01061483f, -0.00316925f, -0.00837361f, -0.03505740f, 0.01381775f, -0.00582876f, 
    -0.03672534f, -0.00613814f, 0.01528484f, -0.03533772f, -0.00653749f, -0.03816080f, 0.02696202f, -0.01728953f, 
    -0.03694407f, -0.02984744f, -0.02725549f, 0.00530435f, -0.00974532f, -0.01681192f, -0.02808475f, -0.00791676f, 
    -0.04263559f, -0.01952091f, 0.01547356f, -0.01701017f, 0.00219541f, 0.01729584f, 0.01587714f, 0.02072388f, 
    -0.03156658f, 0.02406516f, -0.04126253f, -0.00538040f, -0.00245374f, -0.03128896f, 0.02012704f, -0.02990847f, 
    -0.03198463f, -0.01176731f, 0.00333078f, -0.00710253f, -0.02523136f, 0.02514910f, -0.01781503f, -0.01585013f, 
    -0.00853410f, 0.00526468f, 0.00032171f, 0.02924164f, -0.04136408f, -0.00116985f, 0.01875798f, -0.01234059f, 
    0.01592535f, -0.02355081f, -0.00712113f, 0.02594795f, -0.03968836f, -0.03853550f, -0.00547546f, -0.01414247f, 
    -0.03835237f, 0.01780882f, -0.03487861f, -0.03349208f, -0.03003713f, -0.02680334f, 0.01381456f, 0.01153525f, 
    -0.01327104f, -0.00123501f, -0.02479835f, -0.01115939f, -0.03493677f, -0.02501255f, -0.00809466f, 0.00822365f, 
    -0.04115725f, -0.02689140f, -0.02734065f, 0.00930300f, 0.01911204f, 0.00610835f, 0.01430302f, 0.02101919f, 
    -0.01289079f, -0.02396232f, 0.01343219f, 0.00550099f, -0.00097721f, 0.03053679f, -0.02821826f, -0.00221100f, 
    -0.03822640f, -0.01826150f, -0.03500991f, 0.02310247f, -0.04124924f, 0.01179700f, -0.03493925f, 0.01574201f, 
    0.02490625f, -0.02292478f, -0.01179251f, -0.02937424f, -0.01642217f, -0.03160135f, 0.01106323f, -0.00598300f, 
    0.02755611f, 0.00912458f, 0.02465079f, 0.01584347f, -0.00485628f, -0.00670083f, 0.01042497f, -0.02038845f, 
    -0.02659453f, 0.01774395f, -0.02831691f, -0.00771068f, 0.01167585f, 0.02198282f, -0.01782998f, -0.03137979f, 
    0.02782180f, -0.00555561f, -0.03641872f, -0.01681967f, 0.01927515f, -0.02595965f, -0.04144657f, 0.00126390f, 
    -0.02853518f, -0.02261434f, 0.01501181f, -0.00635617f, 0.00729736f, -0.03762748f, 0.02729102f, 0.02035357f, 
    -0.00917225f, 0.00985270f, -0.03161302f, -0.00307818f, -0.01024018f, 0.02674338f, 0.00723681f, -0.01980769f, 
    -0.02466083f, -0.01773163f, -0.01670038f, 0.01534348f, -0.00145286f, 0.02427472f, -0.00947099f, 0.00482049f, 
    -0.01842109f, -0.03881086f, -0.02837993f, -0.02235502f, -0.00203689f, -0.01706272f, 0.01725495f, -0.02779814f, 
    -0.00067673f, 0.01352892f, 0.02205519f, 0.00297656f, -0.00033766f, -0.02494691f, -0.00354808f, -0.04101613f, 
    0.02749469f, 0.01319200f, -0.04373983f, 0.00912570f, 0.00952595f, -0.01854142f, 0.00820694f, -0.00830497f, 
    0.01927874f, 0.01673150f, 0.00470373f, 0.02154776f, 0.00378479f, -0.04165623f, -0.01762306f, -0.03193324f, 
    0.02053425f, -0.00607994f, 0.01454135f, -0.01234287f, -0.04014708f, 0.01201854f, -0.03377178f, -0.01343407f, 
    -0.01256862f, 0.00890353f, -0.03175260f, 0.01345325f, -0.01695859f, 0.01998514f, -0.04012558f, -0.02788606f, 
    -0.03488947f, 0.03824675f, -0.02999995f, 0.02654827f, -0.04098044f, -0.02523645f, 0.02123942f, -0.00903881f, 
    -0.00826824f, -0.01942192f, 0.00970561f, -0.03059968f, 0.01418962f, 0.01538752f, -0.01425030f, -0.00753760f, 
    0.00436285f, 0.01086845f, -0.02435299f, 0.02514751f, -0.02246417f, -0.03550478f, -0.01231401f, -0.00460887f, 
    0.00782762f, -0.01331980f, -0.02252972f, -0.01375630f, 0.02382868f, 0.00927456f, -0.00594945f, -0.01020713f, 
    -0.01980506f, -0.01123005f, 0.01536332f, 0.01034226f, -0.00021791f, 0.01736054f, 0.01609476f, -0.01606365f, 
    0.01380296f, -0.00726429f, 0.01022207f, -0.04195130f, -0.03746539f, 0.00567907f, -0.01773497f, 0.00496513f, 
    0.01675410f, -0.00754615f, 0.00978101f, -0.03644881f, -0.01962530f, -0.02880052f, -0.00728360f, -0.02236281f, 
    -0.02347947f, 0.02682470f, -0.04019312f, 0.03166832f, 0.00969005f, -0.02364003f, -0.01867940f, -0.01575662f, 
    0.01067965f, -0.04044700f, -0.02464556f, 0.01503827f, -0.03106817f, -0.02951114f, -0.04185625f, -0.02956825f, 
    -0.01801684f, -0.04248585f, 0.01908385f, -0.02165682f, -0.01479593f, -0.02403353f, -0.03902920f, 0.02877959f, 
    -0.01601109f, -0.00734556f, -0.01141174f, -0.04051409f, -0.02919390f, 0.00982094f, 0.01890847f, -0.03369766f, 
    -0.02763034f, 0.00897450f, 0.00598085f, -0.02918607f, 0.01383689f, 0.00971103f, 0.01742087f, 0.03359373f, 
    0.02523998f, -0.00602642f, 0.00144634f, -0.01725462f, -0.01468935f, -0.01327394f, -0.00508957f, -0.01096022f, 
    -0.01354796f, -0.01675979f, -0.00532228f, 0.03792267f, 0.01027039f, 0.01870140f, 0.01957775f, 0.02478226f, 
    0.00643662f, 0.01020522f, 0.02219518f, 0.00249961f, 0.01225003f, 0.02528292f, -0.01568529f, -0.03291840f, 
    -0.02952555f, 0.01062186f, -0.03856122f, -0.01200493f, 0.00011832f, 0.03192871f, 0.02817380f, -0.00943320f, 
    0.00993664f, -0.01154051f, -0.03949603f, 0.01566174f, -0.00531298f, 0.02912428f, -0.00563219f, 0.01207261f, 
    -0.01543730f, -0.02655604f, 0.01975078f, -0.01092256f, 0.00589876f, 0.01680083f, 0.03217774f, -0.01247404f, 
    -0.00189013f, -0.00669704f, -0.02853727f, 0.03932688f, 0.03182582f, -0.02708500f, -0.00048723f, -0.03374191f, 
    -0.04370445f, -0.02495760f, 0.02564782f, 0.00467373f, 0.01962727f, 0.00871306f, 0.02036715f, 0.03151612f, 
    -0.02210550f, 0.03406816f, -0.01446565f, -0.02328293f, 0.01215645f, -0.00332586f, 0.02399444f, 0.01890811f, 
    -0.01139548f, 0.00830583f, -0.02774377f, 0.00804743f, 0.00623963f, -0.00893776f, 0.03137175f, -0.00633659f, 
    -0.00681154f, 0.01693433f, 0.01401974f, -0.03733493f, 0.02032912f, -0.04139259f, -0.00018008f, 0.02158127f, 
    0.01410347f, 0.01402918f, 0.00467872f, -0.00377288f, 0.02506844f, -0.00053510f, -0.00368518f, -0.02461878f, 
    -0.00437752f, 0.01727487f, -0.03869418f, 0.00433730f, -0.02999102f, 0.01529013f, 0.02219300f, 0.01502288f, 
    0.01570173f, -0.01357431f, 0.00248600f, -0.03536084f, 0.01532614f, -0.00025873f, 0.03192705f, -0.02349947f, 
    0.01985052f, 0.00669672f, -0.01958046f, -0.01706278f, 0.00384035f, 0.02539437f, 0.00958154f, 0.01137164f, 
    0.02553673f, -0.03550215f, -0.03291457f, -0.00569785f, -0.00463201f, -0.01012641f, 0.01312825f, -0.01442606f, 
    0.00843403f, -0.01459070f, 0.00742284f, -0.02468751f, -0.03095882f, -0.04302360f, -0.01623724f, 0.02387422f, 
    0.00628002f, -0.02904188f, -0.01339851f, 0.02384841f, -0.03743336f, -0.02603869f, 0.01458976f, -0.00495088f, 
    -0.00522283f, -0.02650491f, -0.03338554f, 0.00321900f, -0.01899772f, 0.01108214f, 0.00261437f, -0.03822567f, 
    0.02358915f, -0.00436582f, -0.01677711f, -0.01004246f, -0.01566204f, 0.01265457f, 0.00759301f, 0.02763320f, 
    0.00972924f, 0.01055181f, 0.02925210f, -0.02147858f, 0.01682672f, -0.03881555f, -0.02312463f, -0.01312589f, 
    -0.03371574f, 0.00146895f, 0.03158466f, -0.01325124f, 0.00974294f, -0.01192128f, -0.02791826f, -0.02522302f, 
    0.02171385f, 0.01536686f, -0.03934699f, 0.01138580f, -0.01465113f, 0.01656479f, 0.01340534f, 0.00323800f, 
    0.01850989f, -0.02806091f, 0.02035096f, 0.02755625f, 0.02377036f, 0.02589486f, 0.00652677f, 0.00883828f, 
    0.00342953f, 0.00887830f, 0.01332137f, -0.03871004f, -0.01053356f, -0.02210485f, 0.03102976f, 0.00378124f, 
    0.01318701f, -0.03210144f, -0.01000063f, -0.01100977f, -0.01904853f, -0.01165983f, -0.00791102f, -0.03100482f, 
    -0.01341745f, 0.01424557f, -0.03286667f, -0.00756594f, -0.02743378f, -0.00665671f, 0.01313639f, 0.00943506f, 
    -0.03296411f, 0.01967820f, -0.00870887f, 0.00688140f, 0.00555681f, 0.00538467f, 0.00093704f, -0.03113133f, 
    0.00526148f, -0.02588354f, 0.01918878f, 0.01189279f, -0.01880153f, 0.02475648f, 0.01134922f, 0.01573413f, 
    0.01602726f, 0.00167339f, -0.03862264f, -0.01394777f, -0.01019059f, 0.00597166f, -0.03810435f, 0.01262635f, 
    -0.02143828f, 0.00985504f, -0.02066300f, -0.00815139f, 0.00766538f, -0.01554800f, 0.03439807f, 0.03621115f, 
    -0.00568736f, -0.00499402f, 0.00943701f, 0.01161394f, 0.02222291f, -0.03802205f, -0.03325072f, 0.01748434f, 
    0.01972739f, -0.00078798f, -0.01919062f, -0.01358428f, -0.02982087f, -0.00322874f, -0.02307201f, 0.01304338f, 
    0.00890933f, -0.03915703f, -0.03941419f, -0.02934206f, -0.00852621f, -0.03565128f, 0.01747813f, 0.00841246f, 
    0.00022938f, 0.02856541f, 0.01743335f, 0.01138144f, -0.00252007f, 0.02387447f, 0.02452220f, -0.00872237f, 
    0.00970690f, -0.01471839f, -0.03688678f, -0.03637149f, -0.01270178f, 0.00730515f, -0.01023235f, 0.01040091f, 
    0.02795742f, -0.03723853f, 0.02309269f, -0.00621356f, 0.01109086f, 0.00692341f, -0.00281020f, -0.02717797f, 
    -0.01477027f, 0.01822901f, 0.00458884f, 0.02633933f, 0.00917907f, -0.01877311f, 0.01252452f, -0.03294816f, 
    -0.03147726f, -0.03159643f, 0.00182673f, -0.00866319f, -0.01644370f, -0.04101354f, -0.04295253f, 0.02247041f, 
    -0.00889090f, -0.04530779f, 0.01805818f, 0.02153813f, -0.00051923f, 0.02954941f, -0.02175867f, 0.00008899f, 
    -0.00555525f, 0.02708542f, 0.00302596f, 0.02395600f, -0.04262376f, -0.01884337f, -0.01001460f, -0.02450352f, 
    -0.00899954f, -0.01821337f, 0.02360750f, 0.00781271f, -0.00936654f, 0.04086495f, -0.01529926f, 0.02010982f, 
    -0.03794722f, -0.01083593f, 0.02855041f, 0.01234100f, -0.03028162f, 0.02572793f, -0.01895899f, -0.02742144f, 
    0.02531066f, 0.02669687f, -0.01093102f, -0.00470060f, -0.00008630f, 0.00384271f, 0.02576208f, -0.04012649f, 
    0.01704446f, -0.01633641f, -0.03976030f, 0.00565698f, 0.00599269f, -0.00860628f, 0.02506245f, 0.02227026f, 
    -0.01279796f, -0.02540443f, -0.03221464f, -0.01626312f, -0.01110253f, 0.01021614f, 0.01627099f, -0.01963236f, 
    -0.02771025f, -0.00832224f, 0.02258880f, -0.04237686f, -0.02479369f, -0.00434205f, -0.02836507f, 0.03047357f, 
    -0.03303633f, 0.02261362f, 0.03434207f, -0.04117374f, 0.01880532f, -0.01135852f, -0.01900860f, -0.04185589f, 
    -0.02532387f, 0.00030461f, 0.00960186f, -0.03790000f, 0.00697274f, 0.00155532f, -0.02495576f, 0.01178701f, 
    -0.01376107f, -0.01909890f, -0.00285910f, 0.01041626f, 0.02351779f, 0.00925919f, 0.01617589f, 0.00934470f, 
    -0.01220904f, 0.00060877f, -0.04576330f, 0.00366166f, -0.00772630f, -0.01404205f, -0.00226381f, -0.03370450f, 
    -0.02902641f, -0.03021444f, 0.00975098f, 0.00954703f, -0.01205348f, -0.02046586f, -0.03343543f, 0.02687902f, 
    0.02738618f, -0.03258966f, 0.32503527f, 0.18448494f, -0.13138920f, -0.08601705f, -0.16761138f, 0.11133764f, 
    -0.14471048f, 0.18152292f, -0.15380643f, -0.00181182f, 0.05457927f, 0.07405213f, 0.07684603f, 0.10428005f, 
    0.10505838f, 0.13673927f, 0.00923222f, 0.00358029f, 0.03027344f, 0.08091371f, 0.18516210f, 0.10458995f, 
    0.16349050f, -0.26492193f, 0.05616203f, 0.01746944f, 0.05998418f, 0.16872142f, 0.10984214f, -0.12808184f, 
    0.16485001f, -0.11175587f, 0.15349486f, 0.14589594f, -0.05626135f, -0.22504333f, 0.05217016f, -0.02309978f, 
    0.02447302f, 0.04944619f, 0.03724022f, 0.07015894f, -0.21836950f, -0.10790399f, 0.00246126f, -0.07274465f, 
    -0.36365280f, -0.15217720f, -0.09696750f, -0.10397459f, -0.11557237f, -0.01421082f, -0.00585048f, 0.03819060f, 
    -0.04221242f, 0.14211588f, 0.15832518f, 0.13662992f, 0.11645421f, -0.01341037f, -0.00674358f, 0.12705749f, 
    -0.14525415f, 0.08476056f, 0.10288367f, -0.02587344f, 0.05659494f, 0.07247193f, -0.14099020f, 0.17519252f, 
    -0.35017020f, -0.15905194f, -0.29185185f, -0.18400450f, -0.09517775f, 0.17276882f, 0.16597962f, 0.24576637f, 
    -0.14014283f, 0.12802367f, 0.12303606f, 0.16241132f, 0.29687768f, 0.17789628f, 0.16937101f, 0.13950697f, 
    0.21926770f, 0.07639897f, -0.08160388f, -0.12244524f, -0.14535207f, 0.03118928f, -0.01167575f, 0.02110220f, 
    0.38997674f, 0.16673109f, -0.01612971f, 0.03441012f, 0.17683303f, 0.15549307f, -0.11884538f, -0.30297238f, 
    -0.29761279f, -0.04739292f, -0.11458797f, -0.15089694f, -0.23447497f, -0.28865451f, -0.18066172f, -0.09191546f, 
    -0.03873070f, -0.00532396f, -0.05619150f, -0.10889158f, -0.29573381f, -0.07314667f, -0.11396763f, -0.06084923f, 
    0.05641879f, 0.00058526f, 0.30198011f, 0.01880034f, 0.02169177f, 0.16319577f, 0.03710014f, 0.17904386f, 
    -0.01246637f, 0.15586743f, 0.07803681f, 0.30895823f, 0.16088982f, -0.10363091f, 0.04772133f, 0.11845835f, 
    0.05615917f, 0.19716898f, 0.12720485f, -0.06171456f, -0.19686502f, -0.04407386f, -0.04984957f, -0.08834699f, 
    -0.03086170f, 0.36817086f, 0.21232277f, -0.29702720f, 0.13550241f, 0.16082503f, -0.03188786f, 0.28548065f, 
    0.14322916f, 0.14326151f, 0.10103866f, 0.13114348f, -0.25652772f, -0.18931174f, -0.00122176f, 0.02084228f, 
    0.09626445f, 0.12114710f, 0.17477471f, 0.24690643f, -0.28416032f, 0.06647144f, -0.11069140f, -0.05005624f, 
    0.12313610f, 0.21425836f, 0.62917113f, 0.10334985f, -0.06123283f, 0.08077325f, 0.01046286f, 0.32450530f, 
    0.14938590f, 0.12494516f, -0.05889487f, 0.06356370f, -0.47740093f, 0.22900011f, 0.14487746f, -0.07805705f, 
    0.18824233f, 0.04531895f, 0.27475289f, 0.10258687f, 0.09288215f, -0.14950459f, 0.06047343f, -0.04846037f, 
    -0.10671156f, -0.35746926f, 0.16787073f, -0.05686909f, -0.11963037f, 0.14790840f, 0.00667206f, 0.03452008f, 
    0.00467336f, 0.11926849f, -0.02022394f, 0.26695234f, 0.30801362f, -0.03361857f, 0.17158808f, -0.23530006f, 
    0.22288731f, -0.19247389f, 0.06146418f, 0.05446962f, -0.09516106f, 0.14197071f, 0.08566678f, 0.11111166f, 
    0.07347862f, -0.36348858f, 0.11368229f, 0.15835311f, 0.02745411f, -0.00038190f, 0.00869813f, 0.03714021f, 
    0.37526461f, 0.20453760f, -0.10074171f, -0.14772207f, 0.07261234f, 0.10894591f, 0.12190083f, 0.05939626f, 
    0.00127470f, -0.00597606f, -0.08045603f, 0.07787215f, -0.13052632f, 0.15917845f, 0.00563290f, 0.07277884f, 
    0.24860251f, 0.27936432f, 0.19438535f, -0.14318767f, -0.02809270f, 0.09434881f, 0.06917819f, 0.10448349f, 
    -0.01902440f, 0.02247269f, -0.04425250f, 0.22253291f, 0.14443600f, -0.17258030f, -0.13313156f, 0.03549207f, 
    -0.01271380f, 0.04580979f, -0.00053270f, 0.07418837f, 0.11711365f, -0.02360640f, 0.07224827f, 0.07475626f, 
    0.15738171f, -0.18844935f, -0.22963835f, -0.16500859f, 0.11422900f, -0.03956731f, -0.03153322f, -0.09866010f, 
    -0.13804370f, 0.01487183f, 0.04015696f, 0.10331845f, -0.02135972f, -0.04700572f, 0.03345161f, -0.02818869f, 
    0.01482052f, 0.11779619f, -0.02465618f, 0.04465139f, 0.03803923f, -0.08417102f, 0.03276083f, -0.05283933f, 
    -0.07613806f, -0.20341292f, -0.24743660f, -0.05979995f, -0.04656171f, 0.02911092f, -0.02503323f, 0.05629979f, 
    -0.01875316f, 0.19592391f, 0.01039648f, -0.02812708f, 0.04321964f, 0.00592281f, 0.02763137f, 0.02813014f, 
    -0.07417669f, -0.10073764f, -0.00402048f, 0.00312255f, 0.15861146f, 0.21514246f, 0.12170574f, 0.07708109f, 
    -0.07449436f, -0.05947484f, 0.03795642f, -0.12011634f, 0.23461176f, -0.01869662f, 0.00191324f, -0.01076974f, 
    0.05716305f, -0.05541420f, 0.15279184f, 0.00939886f, 0.25149482f, 0.18819359f, 0.01877311f, 0.07812226f, 
    -0.14201604f, -0.05931266f, 0.03920618f, -0.07416511f, 0.17097028f, -0.00630950f, 0.00811580f, 0.05486437f, 
    0.20353186f, -0.07121021f, 0.20465752f, -0.12091380f, -0.09991726f, -0.05215539f, 0.01973215f, 0.07204147f, 
    -0.07501911f, 0.01490421f, 0.15190078f, -0.26366833f, -0.34497774f, 0.48197496f, -0.48698640f, -0.27312198f, 
    0.12688588f, 0.02139748f, 0.22825693f, -0.12044195f, 0.28291312f, 0.11901658f, 0.11043993f, 0.13610289f, 
    -0.05321443f, -0.12058555f, 0.08696430f, 0.03092338f, 0.13985214f, 0.12237193f, 0.00426687f, 0.19696234f, 
    -0.00998323f, 0.08786213f, -0.05695857f, 0.01011749f, 0.39494929f, 0.29980782f, 0.02682890f, -0.04889615f, 
    0.24521606f, 0.12380306f, 0.03945232f, -0.16116840f, 0.12674537f, -0.00542204f, 0.04892446f, 0.13216740f, 
    -0.11292810f, -0.03078879f, 0.08861913f, 0.14139646f, 0.02105636f, 0.15360011f, -0.02505093f, 0.16449204f, 
    -0.11222744f, 0.37366512f, -0.09050068f, -0.02550592f, -0.17864850f, -0.06109035f, -0.08559147f, 0.01343256f, 
    0.06000474f, 0.11505120f, 0.27984244f, 0.17992610f, 0.00419252f, -0.04217222f, -0.02583065f, -0.13865075f, 
    -0.22933853f, -0.04027800f, -0.04919170f, 0.04110784f, -0.12797473f, -0.05433559f, -0.04223702f, -0.24157783f, 
    -0.00651050f, 0.06918728f, 0.16568832f, 0.26217216f, -0.04393207f, -0.00545939f, -0.13466664f, 0.07639316f, 
    -0.04356228f, -0.04491601f, 0.06028503f, -0.06035996f, -0.22950836f, -0.12791756f, -0.02251755f, -0.02900667f, 
    -0.07837447f, 0.14940952f, 0.08607738f, 0.11790172f, -0.09183848f, 0.00073357f, -0.00796915f, -0.03619687f, 
    -0.19867848f, 0.06281621f, 0.10760571f, 0.26554587f, 0.04646529f, 0.08241043f, 0.00820619f, -0.15409581f, 
    -0.09310286f, 0.17870077f, 0.12309637f, 0.13823363f, 0.15226737f, -0.02716030f, 0.30608577f, -0.15541874f, 
    0.21701297f, 0.30519518f, -0.13706608f, -0.21373804f, 0.05691095f, 0.06862988f, 0.18308960f, -0.05045626f, 
    -0.08600578f, -0.18528467f, -0.09471438f, 0.02641104f, 0.09243643f, -0.00636392f, -0.04643062f, -0.04587216f, 
    -0.10079178f, 0.04386711f, 0.07493334f, -0.08093785f, -0.20590879f, -0.12000731f, -0.12125456f, -0.07731371f, 
    0.23417605f, 0.28342029f, 0.12579329f, 0.10205408f, -0.06274132f, -0.10928033f, -0.02399028f, -0.00692433f, 
    -0.04087904f, -0.00022569f, 0.07144721f, 0.06889172f, -0.01473119f, 0.00986471f, -0.03185576f, -0.02275787f, 
    -0.16678566f, -0.00068252f, -0.12876239f, 0.01915697f, 0.01522303f, 0.03876374f, -0.02645526f, -0.00988809f, 
    0.13765292f, 0.09653545f, 0.09969584f, 0.10026981f, 0.14955212f, 0.06171865f, 0.04706055f, 0.09955838f, 
    -0.02081443f, -0.07522851f, 0.03822967f, -0.10919558f, 0.09188983f, 0.75669909f, -0.26872855f, 0.09874269f, 
    -0.12729517f, -0.10885005f, -0.03028675f, -0.27051368f, -0.06191201f, 0.00358144f, 0.03097710f, 0.01619549f, 
    0.01556143f, -0.10032373f, 0.12752572f, 0.06861312f, 0.12367833f, 0.07462323f, 0.03833635f, 0.23800169f, 
    -0.18328507f, 0.01182333f, 0.03980872f, 0.12087378f, 0.13653104f, 0.41712111f, 0.10912928f, 0.24570763f, 
    -0.15208901f, -0.04935425f, -0.11325189f, 0.04885117f, 0.05891922f, 0.13703139f, 0.06483836f, -0.02909635f, 
    0.34445271f, 0.27560219f, 0.06579492f, 0.29413286f, -0.07072773f, -0.06746809f, 0.06525125f, 0.06503629f, 
    0.07483903f, 0.27895433f, -0.05246595f, 0.10295001f, 0.04169466f, -0.09542398f, -0.07443810f, 0.08820552f, 
    -0.07658413f, 0.10695043f, 0.09379037f, 0.08135075f, 0.21552582f, 0.21176034f, 0.16864578f, 0.14629097f, 
    0.08417644f, 0.02627539f, 0.00690061f, -0.05170346f, 0.15283428f, 0.07397693f, -0.03963627f, -0.10680222f, 
    0.04699975f, 0.05420535f, 0.02602901f, 0.15286195f, -0.36564738f, -0.01931301f, -0.33449957f, -0.07417390f, 
    0.12689622f, -0.05294671f, 0.07069021f, 0.12534779f, -0.21449015f, -0.06151794f, -0.10552138f, -0.11952918f, 
    -0.05831464f, 0.33839956f, -0.42272109f, 0.01782206f, 0.06590229f, -0.05817337f, 0.23912470f, -0.08761606f, 
    0.17634693f, -0.00890658f, 0.01271432f, 0.12071740f, 0.30502126f, 0.30690899f, -0.08426274f, -0.01095773f, 
    -0.11019892f, -0.10474793f, 0.06264801f, -0.02584740f, 0.19830781f, -0.02534144f, 0.04665523f, 0.11892092f, 
    -0.10988689f, 0.17169626f, -0.09063461f, 0.11062223f, -0.04394965f, 0.04816068f, 0.03218482f, 0.00855577f, 
    0.26977602f, 0.11081964f, 0.38843930f, 0.09283706f, 0.09001903f, 0.23354140f, 0.21535026f, 0.09702015f, 
    -0.21616843f, -0.04277080f, -0.15394564f, -0.03199194f, -0.07273459f, 0.09169374f, 0.01338321f, 0.01286400f, 
    -0.11022566f, 0.00795746f, 0.03631506f, 0.07064703f, 0.18441047f, 0.19223635f, 0.14404912f, 0.04315836f, 
    0.06113846f, 0.08691862f, 0.00918605f, -0.00068536f, -0.01222812f, 0.11213102f, 0.10782979f, 0.04063390f, 
    0.24127032f, -0.16233964f, -0.10108984f, -0.10677170f, -0.09681993f, 0.01782157f, 0.06403033f, 0.06166023f, 
    0.01747157f, 0.14759727f, 0.28601876f, 0.04759553f, -0.02250005f, 0.13513483f, 0.08704845f, -0.12402774f, 
    -0.13075794f, 0.08942393f, -0.01666739f, 0.17298505f, 0.15634716f, -0.08422815f, -0.04561066f, 0.15907800f, 
    0.03840453f, -0.09091087f, 0.03870228f, -0.30868435f, -0.07072067f, -0.13114050f, 0.01808059f, 0.07468951f, 
    0.35280597f, -0.02561168f, -0.05653184f, 0.12958418f, -0.03888472f, 0.05190490f, 0.07702869f, -0.05229152f, 
    0.14985503f, 0.01145106f, 0.11527426f, 0.01547533f, 0.11997335f, -0.13754696f, 0.00510997f, 0.23748101f, 
    0.09755738f, 0.26408711f, 0.13061950f, -0.00700907f, 0.08061660f, 0.06020233f, -0.00133364f, -0.00269054f, 
    0.08284434f, 0.14358141f, 0.18659964f, 0.07707503f, -0.13479617f, -0.01001585f, -0.05615626f, -0.04044513f, 
    0.09332545f, 0.14546964f, 0.10803191f, 0.47183114f, -0.00188948f, -0.05985851f, -0.09356949f, 0.06791440f, 
    0.16825405f, 0.12151373f, -0.01007574f, 0.09952235f, 0.16127679f, -0.03482901f, -0.02472171f, 0.11987127f, 
    0.39183825f, -0.35530698f, 0.13237022f, -0.08927777f, 0.05693539f, 0.08812965f, 0.09305415f, 0.23785125f, 
    0.26970705f, 0.25469345f, 0.10039010f, 0.23020172f, 0.25091827f, -0.27362290f, 0.60143894f, -0.04301701f, 
    0.16901127f, 0.24373542f, 0.08127417f, 0.35908198f, 0.11239058f, 0.11468223f, 0.12839764f, -0.06166173f, 
    0.02242634f, -0.01929005f, -0.01896189f, -0.03645060f, -0.02519807f, -0.00558372f, -0.03624773f, 0.02558574f, 
    0.00922092f, -0.01972499f, 0.02544756f, -0.02246799f, -0.02047490f, -0.02935786f, 0.01071879f, -0.04065645f, 
    -0.01705278f, -0.01963024f, 0.00746762f, 0.02904371f, -0.00175586f, -0.01114922f, -0.01263466f, 0.01994332f, 
    0.02234753f, 0.00670703f, -0.02981167f, 0.02844656f, 0.00585025f, -0.01377483f, -0.00526809f, -0.03201707f, 
    -0.02539119f, 0.02925033f, -0.01764651f, 0.00167708f, -0.00511124f, 0.01634117f, -0.03251693f, -0.02285074f, 
    0.02853442f, -0.00872632f, -0.00267636f, -0.02873442f, -0.03322660f, -0.02191656f, -0.04100062f, -0.02460752f, 
    0.00570292f, 0.00136778f, -0.02357167f, -0.02892223f, 0.00406921f, -0.01126151f, 0.02084847f, -0.03823991f, 
    -0.02861270f, 0.00938335f, -0.02945100f, -0.02720860f, 0.02513365f, -0.03368741f, 0.00875291f, -0.01051382f, 
    0.01039166f, -0.03082879f, -0.01175444f, -0.02652293f, -0.00032486f, 0.00181244f, 0.01318196f, -0.00666910f, 
    0.02216217f, -0.02806627f, -0.00003058f, 0.02204744f, 0.01536502f, 0.00733000f, 0.00759961f, -0.03574875f, 
    0.00445156f, -0.01387508f, -0.01649601f, -0.03594226f, -0.03669871f, 0.01532346f, -0.03433840f, -0.01335391f, 
    -0.01381385f, -0.01058200f, -0.01297864f, 0.00365707f, 0.00429733f, -0.03328814f, -0.00063473f, -0.00015253f, 
    0.00718797f, -0.01457025f, 0.02827755f, -0.03571933f, 0.01495239f, -0.01136624f, 0.02372878f, -0.03646443f, 
    0.02230036f, -0.03412294f, -0.00290683f, -0.02871501f, 0.02931659f, -0.03479286f, -0.00470626f, 0.03095005f, 
    -0.01015963f, -0.02259104f, -0.02852039f, -0.02618594f, 0.02214097f, 0.02581082f, -0.03988664f, 0.02363449f, 
    -0.04054346f, -0.01288207f, -0.01012537f, 0.02603960f, 0.02395371f, 0.02226358f, -0.03968475f, -0.03377747f, 
    -0.03133762f, -0.00904916f, -0.02928490f, 0.00780770f, -0.01211409f, -0.01862868f, -0.01276350f, 0.01947313f, 
    0.01771334f, -0.03173951f, 0.02699341f, -0.04192032f, -0.01696884f, -0.00784141f, -0.01806318f, -0.00268106f, 
    -0.01933901f, 0.01137203f, 0.00167021f, -0.03920880f, -0.02846875f, -0.01944227f, -0.01227257f, 0.00246094f, 
    0.02168045f, 0.01975223f, 0.02739317f, -0.00036051f, 0.02134254f, -0.00517616f, -0.03509130f, -0.00179761f, 
    -0.01105988f, 0.00381070f, 0.01957054f, -0.01843799f, 0.01065171f, -0.02562339f, 0.01405905f, -0.03934832f, 
    0.00193042f, -0.03683272f, -0.00881819f, -0.03746940f, -0.00453986f, 0.02446417f, 0.00412684f, 0.01677504f, 
    0.02666740f, -0.03541158f, -0.04196199f, 0.01995473f, 0.01665902f, 0.01879649f, -0.03452138f, -0.01453968f, 
    -0.02948909f, 0.01356932f, -0.03144573f, 0.02496062f, -0.02440750f, -0.02670763f, 0.02992390f, 0.00938651f, 
    0.02883471f, -0.01665906f, 0.02415875f, -0.02697050f, -0.01790316f, -0.00909024f, 0.01034615f, -0.00449810f, 
    -0.01634846f, -0.02581015f, -0.01276033f, -0.02671048f, 0.01477999f, 0.02258188f, -0.02521406f, -0.03899432f, 
    -0.03452176f, -0.01908919f, -0.00517024f, -0.01670106f, -0.01253652f, -0.00465714f, -0.00558220f, 0.00959379f, 
    0.00036071f, -0.03081593f, -0.02018833f, -0.01986583f, -0.03469625f, -0.00493615f, 0.00405985f, -0.02913793f, 
    -0.03603908f, 0.01352570f, -0.00938632f, -0.04151371f, 0.02654782f, 0.01238823f, -0.02139566f, 0.00863263f, 
    0.02998854f, -0.00063761f, -0.02080543f, -0.00936841f, 0.01791644f, -0.03542768f, 0.00313382f, -0.03016061f, 
    -0.04136601f, 0.02842093f, 0.02032806f, -0.01441387f, 0.01779430f, 0.02354382f, -0.00768762f, -0.01810312f, 
    -0.03102031f, -0.01532011f, -0.02126237f, -0.02693515f, 0.02641260f, -0.01751811f, -0.01096531f, 0.03509621f, 
    -0.01870067f, 0.00408631f, -0.03887515f, 0.00618596f, 0.02566615f, -0.02493791f, 0.01706501f, 0.00269706f, 
    0.02077600f, -0.02532697f, 0.02509070f, 0.01300345f, -0.04111744f, -0.03704345f, -0.03065851f, 0.01700114f, 
    -0.03216470f, 0.02635168f, 0.00754131f, 0.02702847f, 0.02320541f, -0.03797163f, -0.01826655f, -0.03667088f, 
    -0.00259910f, -0.02636824f, -0.03005891f, 0.01863444f, -0.01608987f, 0.00500648f, 0.02006643f, 0.01937106f, 
    -0.02350658f, 0.01806260f, -0.00914370f, 0.02537816f, 0.02695503f, -0.02549567f, -0.03985966f, 0.01483695f, 
    -0.01163856f, -0.00562694f, 0.01528395f, 0.01296340f, 0.02441112f, -0.00049124f, -0.02455168f, 0.02350887f, 
    -0.02185321f, -0.00824259f, -0.01757550f, -0.00765586f, 0.00039278f, -0.00927240f, 0.02822623f, -0.01412949f, 
    0.02390730f, 0.00217062f, -0.01372131f, -0.04199041f, 0.00087843f, -0.01798410f, -0.03817991f, 0.01825350f, 
    0.00546617f, -0.02598777f, -0.03836226f, 0.01593326f, -0.00252220f, -0.00824909f, -0.02003052f, -0.03538193f, 
    0.02384624f, 0.02322262f, -0.00371885f, -0.02633153f, -0.00893124f, 0.01383644f, 0.02602482f, 0.02325882f, 
    0.00030911f, -0.02432419f, -0.02076975f, 0.00077714f, 0.01599199f, 0.01517578f, -0.00025060f, -0.01100248f, 
    -0.04057448f, 0.02677952f, -0.03235006f, 0.02532599f, -0.02730145f, -0.00266260f, 0.02683245f, -0.00712222f, 
    -0.01878262f, 0.00819255f, -0.00407901f, -0.02966285f, 0.01155151f, -0.02495576f, 0.01053075f, -0.01610732f, 
    0.02066591f, -0.00873166f, -0.03798609f, 0.01550686f, -0.00565228f, 0.00418387f, -0.03358427f, -0.02513341f, 
    -0.00127952f, -0.04189439f, 0.02461130f, -0.03973885f, 0.01253422f, 0.01838130f, 0.00387405f, 0.00989307f, 
    0.02808043f, -0.00781124f, 0.00443696f, -0.03019062f, 0.01118467f, 0.00356005f, 0.02770321f, -0.03877698f, 
    -0.01012570f, -0.00720072f, 0.02714626f, 0.02755479f, -0.03712964f, -0.00370935f, 0.01781770f, 0.00513543f, 
    -0.01852776f, -0.00469730f, 0.02528781f, 0.01386421f, -0.01067438f, 0.01291490f, -0.01068079f, 0.01554660f, 
    -0.00086740f, -0.01723995f, -0.02355795f, -0.00334611f, 0.02277511f, 0.01321398f, -0.00225400f, 0.01487861f, 
    0.02379875f, 0.02761968f, -0.00714459f, -0.01012436f, 0.02083232f, -0.02739782f, -0.00095712f, -0.03284949f, 
    -0.02843617f, 0.01359328f, -0.04006196f, 0.00533232f, -0.04102232f, -0.01614764f, -0.01097984f, -0.00031721f, 
    -0.02672354f, 0.02981090f, -0.01346859f, -0.03251581f, 0.02657105f, 0.02353753f, -0.03135003f, 0.01888729f, 
    0.02172511f, -0.00082513f, -0.01647142f, -0.01341857f, -0.03559362f, -0.03469625f, 0.00062192f, 0.01670479f, 
    -0.01833108f, 0.02694909f, -0.01263026f, 0.03544379f, 0.01561069f, -0.00189966f, -0.02668040f, -0.03259951f, 
    0.02100859f, -0.03422194f, 0.00262048f, -0.03565452f, 0.00606794f, -0.00348045f, -0.03486501f, -0.03169858f, 
    0.01733807f, -0.03341060f, 0.01072180f, -0.04049902f, -0.00461697f, -0.02158479f, -0.02567921f, 0.02307096f, 
    0.02584063f, 0.02956550f, 0.02038479f, -0.01908250f, 0.01338779f, -0.01040188f, -0.00932298f, 0.01927981f, 
    -0.02604438f, -0.01828270f, -0.02813741f, 0.00496244f, -0.00909602f, 0.01879831f, -0.01650894f, 0.01239329f, 
    -0.01705515f, -0.01389316f, 0.00962197f, -0.03497913f, -0.00649642f, 0.00249849f, 0.01512927f, -0.00588398f, 
    -0.03860785f, 0.01275364f, -0.02925889f, -0.03372918f, -0.02232555f, 0.02002352f, -0.02773934f, 0.01015629f, 
    0.01032070f, 0.01869125f, -0.00185263f, -0.02140808f, -0.01659832f, 0.00197754f, 0.01966379f, 0.01598921f, 
    0.02973451f, 0.00960409f, 0.02014711f, -0.00550614f, -0.03498602f, 0.00251492f, -0.00770441f, -0.03060743f, 
    0.00315998f, -0.02728726f, -0.00872138f, -0.03044680f, -0.03068059f, -0.02594109f, -0.03852040f, 0.00812790f, 
    0.01572730f, 0.00539120f, -0.00103648f, 0.02780210f, -0.01571846f, -0.00418764f, 0.00091388f, -0.01918423f, 
    -0.01462428f, 0.01427602f, 0.01332134f, -0.03074210f, -0.00690776f, 0.02672546f, -0.00258079f, 0.00302517f, 
    -0.03782428f, -0.04010674f, 0.01722985f, -0.00805565f, -0.01491818f, 0.00795278f, -0.01173092f, -0.01040323f, 
    -0.03272045f, 0.00005758f, 0.02910425f, -0.03953939f, -0.01468161f, 0.00725739f, 0.02094664f, -0.03790362f, 
    0.00034606f, 0.00146555f, -0.02018914f, 0.02444402f, -0.02762580f, -0.01101660f, 0.01917372f, -0.03899479f, 
    -0.02773315f, -0.01731620f, -0.00967048f, -0.00074920f, -0.00759750f, 0.02794576f, -0.02704507f, -0.03271814f, 
    -0.01746473f, -0.01997364f, -0.01478214f, 0.01760559f, 0.02206113f, -0.01122157f, -0.00196586f, 0.02211180f, 
    -0.03321604f, -0.00781108f, 0.01152758f, -0.00613683f, 0.02822798f, 0.02884757f, 0.02666488f, 0.00274142f, 
    0.01950911f, 0.02347279f, 0.00244027f, -0.04124079f, -0.00019155f, 0.02887596f, 0.02500648f, 0.02060907f, 
    0.02699826f, 0.00408838f, -0.01734017f, -0.03836252f, -0.00200312f, -0.02069336f, 0.00364133f, -0.02265906f, 
    -0.04119316f, 0.00162819f, -0.03172640f, 0.00635637f, -0.01726637f, -0.02851483f, -0.03921244f, 0.00980118f, 
    -0.03603016f, 0.01356170f, 0.01370093f, -0.03181934f, 0.01701942f, 0.01119788f, -0.02221405f, 0.02071200f, 
    0.02093765f, -0.00140790f, 0.00327767f, 0.02616463f, 0.02073556f, -0.03208234f, -0.03032052f, 0.01343428f, 
    0.00822269f, 0.00147202f, 0.00116912f, -0.02309560f, -0.01756774f, -0.03067574f, -0.03138292f, 0.01597364f, 
    -0.02500960f, 0.00352160f, -0.01856771f, -0.03522112f, -0.02722734f, -0.01881346f, 0.00882525f, -0.01239466f, 
    -0.00878507f, -0.02612824f, 0.01769873f, 0.02205569f, 0.02025381f, -0.03829098f, -0.02589787f, 0.00466180f, 
    -0.02462175f, 0.00788366f, 0.02996543f, 0.00880172f, 0.01578514f, 0.02320582f, 0.01021000f, -0.02388089f, 
    0.02312306f, 0.00840862f, 0.02918460f, -0.01986514f, -0.02851548f, -0.03352059f, -0.03353280f, -0.03871923f, 
    -0.03453557f, -0.02396083f, 0.02233479f, -0.03238008f, -0.01196115f, -0.00063837f, -0.01492509f, 0.01134312f, 
    -0.03874497f, 0.02949015f, -0.03028302f, -0.00023579f, 0.01080259f, -0.00000155f, 0.00062963f, 0.02234793f, 
    0.02306320f, 0.00765973f, -0.03659029f, 0.01689548f, -0.03928265f, -0.00453515f, -0.00075319f, -0.00188106f, 
    0.03276261f, -0.02235473f, -0.00262184f, -0.02748273f, -0.01808387f, -0.03194815f, -0.00379040f, 0.02014563f, 
    0.02854971f, -0.01585641f, 0.01055539f, 0.01228113f, 0.02460540f, 0.00567851f, -0.03390834f, -0.02543786f, 
    0.03364468f, 0.00683805f, 0.00778367f, -0.00935939f, -0.01785182f, -0.03267361f, -0.02076673f, -0.00942740f, 
    -0.04103624f, -0.03731259f, -0.02340987f, -0.00946667f, 0.01411825f, -0.00204375f, 0.00080947f, 0.01429412f, 
    -0.01820763f, 0.02653873f, 0.02886382f, 0.01542764f, -0.00235227f, -0.00256404f, -0.02876852f, -0.03524627f, 
    0.02121856f, -0.02186606f, -0.02848835f, -0.01332455f, 0.02120160f, -0.02712392f, -0.00684421f, -0.03900060f, 
    -0.03592877f, -0.00048461f, -0.03318909f, -0.02674141f, -0.03066490f, -0.00073905f, -0.03430549f, -0.02194975f, 
    0.01018764f, 0.00867260f, -0.02416181f, -0.02172708f, 0.00991775f, 0.00902489f, -0.03948765f, -0.00786163f, 
    -0.01756891f, 0.00646087f, 0.00655585f, 0.01701998f, -0.02183043f, 0.01382090f, -0.00765834f, -0.00124565f, 
    -0.03071341f, -0.00051279f, -0.04099459f, 0.00869769f, 0.02885168f, 0.01980435f, -0.02781814f, 0.00970668f, 
    -0.00613521f, -0.01719367f, -0.01250672f, 0.01922517f, 0.02014506f, -0.04056632f, -0.04078289f, -0.00661477f, 
    -0.00281310f, 0.02295185f, -0.03196724f, -0.01405359f, 0.02515527f, -0.02961203f, -0.01858650f, 0.01617661f, 
    0.02193831f, -0.00407994f, 0.01515470f, -0.04295166f, -0.00472485f, 0.00504916f, -0.03029004f, -0.00962559f, 
    0.02119805f, 0.00536865f, -0.03355409f, 0.00658919f, -0.01790944f, -0.00262567f, -0.00145809f, -0.02791803f, 
    -0.02467654f, -0.02506659f, -0.02741681f, -0.01589063f, 0.00246798f, -0.00579230f, 0.00768501f, -0.04219117f, 
    -0.00494790f, 0.01272915f, -0.00651424f, -0.03169637f, -0.00457936f, 0.02223359f, -0.01910638f, -0.02754523f, 
    0.01078356f, -0.02517401f, -0.01200321f, -0.00770769f, 0.01194589f, -0.02939001f, -0.00941212f, -0.01346477f, 
    -0.01381499f, -0.00683305f, -0.02333502f, -0.02976751f, -0.02153622f, -0.02673192f, 0.02461876f, -0.04048907f, 
    -0.00927352f, -0.00244327f, 0.00270376f, -0.00647510f, -0.01490911f, -0.03358923f, 0.00625593f, -0.01864700f, 
    0.00610356f, -0.01608737f, -0.00100598f, -0.01488945f, -0.01573963f, -0.00105247f, 0.00653511f, -0.02027399f, 
    -0.00739208f, 0.00495575f, -0.03657905f, 0.01242470f, 0.01876567f, -0.01837551f, -0.02085212f, -0.00856941f, 
    -0.00842887f, -0.04201686f, 0.02709660f, 0.01058971f, -0.00328090f, -0.00711974f, -0.04126437f, 0.01729843f, 
    0.02609896f, -0.02327164f, -0.01297837f, -0.02176353f, -0.03383503f, 0.00511227f, -0.03065287f, 0.00479595f, 
    -0.00578963f, 0.02095199f, -0.04202940f, -0.02647790f, -0.03710704f, -0.03025337f, -0.03844298f, -0.01941199f, 
    -0.00236376f, 0.02613315f, 0.00621571f, 0.01683402f, -0.03655012f, 0.02074349f, -0.04412942f, -0.00901539f, 
    0.02013407f, -0.03688902f, 0.01102278f, 0.02093684f, -0.02977153f, -0.00117420f, 0.00762477f, -0.01167547f, 
    0.00512600f, -0.00583462f, -0.03556225f, -0.02904784f, -0.01673009f, 0.00259664f, 0.01736599f, -0.00341310f, 
    0.00114483f, -0.03423930f, -0.03863838f, -0.00326152f, -0.00869092f, 0.02133679f, -0.04525528f, 0.00496996f, 
    -0.02813806f, -0.03385719f, 0.01692373f, -0.02901856f, 0.02205487f, -0.03393490f, -0.03016571f, -0.03180071f, 
    -0.00473756f, -0.01973211f, -0.01969313f, -0.02373146f, 0.00044836f, -0.00389694f, -0.02028032f, -0.02676888f, 
    0.01779817f, -0.00027333f, 0.02405674f, 0.00183107f, -0.02230067f, 0.02037530f, -0.03911442f, -0.03490777f, 
    -0.03190299f, 0.01033736f, -0.03289931f, -0.03000788f, -0.01630439f, 0.01176961f, -0.01949534f, -0.02055186f, 
    -0.00108463f, 0.00899443f, -0.00934226f, -0.02493723f, -0.04228858f, -0.01678344f, -0.01191370f, 0.02276889f, 
    -0.03050711f, 0.00293745f, 0.02380616f, -0.01331177f, -0.01956143f, 0.02452125f, 0.00901260f, 0.03304395f, 
    0.02363532f, -0.02705356f, -0.02137165f, -0.03441143f, 0.01478161f, 0.01317251f, -0.03121199f, -0.00322108f, 
    -0.03236067f, -0.03955956f, -0.01699956f, -0.02062513f, 0.01905045f, -0.02496293f, -0.02386484f, -0.04300176f, 
    -0.02424857f, -0.00416739f, 0.00516459f, 0.00679896f, 0.00115411f, 0.01458436f, -0.00901616f, 0.01383944f, 
    -0.03758667f, 0.01781655f, -0.01816794f, 0.00545800f, -0.02496202f, -0.00269657f, -0.03083468f, 0.01627907f, 
    0.01184129f, -0.03526082f, -0.00729436f, -0.01061785f, -0.01740033f, -0.00988361f, 0.02780640f, 0.00021488f, 
    -0.01368065f, 0.01145312f, -0.03368473f, 0.00533317f, 0.01819003f, 0.01856064f, 0.00115945f, -0.02584410f, 
    0.01837443f, -0.01417495f, 0.00139698f, -0.00380655f, 0.00475194f, -0.03128297f, -0.03998212f, -0.03625140f, 
    0.00794815f, -0.02503581f, -0.02633554f, 0.00036429f, 0.00915092f, 0.02370915f, 0.02175012f, -0.02304872f, 
    -0.02161686f, 0.02122070f, 0.00320619f, 0.00882969f, -0.03230473f, 0.01442052f, -0.03258349f, -0.00159981f, 
    -0.00657201f, 0.02233176f, -0.02330649f, -0.02238333f, -0.03351644f, 0.02414759f, 0.00270524f, 0.01107426f, 
    -0.02093186f, 0.00211678f, 0.02851466f, -0.03789840f, -0.01968624f, 0.00461949f, 0.00805973f, -0.02209078f, 
    0.02477812f, 0.02481247f, 0.01696629f, 0.00623914f, 0.01343174f, -0.01245771f, -0.03911870f, 0.01419887f, 
    -0.00397692f, -0.01427109f, -0.03812473f, 0.00347478f, 0.02536791f, 0.00182339f, -0.02207072f, 0.02194846f, 
    -0.00329109f, -0.00697565f, 0.00911893f, -0.00015060f, -0.02715822f, 0.02521192f, 0.01454165f, -0.00617101f, 
    -0.00433832f, -0.00691302f, -0.01903560f, -0.03229024f, -0.00550702f, -0.02352540f, 0.00412777f, 0.01350630f, 
    0.00947550f, -0.00922139f, 0.01309703f, 0.01523106f, -0.01745007f, 0.02035473f, -0.01622817f, 0.00528891f, 
    -0.01209515f, 0.00847275f, 0.02267774f, -0.03867015f, -0.00633934f, 0.02187317f, -0.01104015f, 0.00456929f, 
    -0.03114528f, -0.04007600f, -0.03246547f, 0.00214943f, -0.03515078f, 0.00006223f, -0.01254932f, 0.02462695f, 
    0.02494127f, -0.00019131f, -0.01748364f, 0.02623695f, 0.01867071f, 0.02390343f, 0.01766690f, 0.01304603f, 
    -0.03178958f, -0.01189234f, 0.01390566f, -0.02545983f, -0.01614147f, -0.01142485f, -0.00830808f, 0.02601282f, 
    -0.04024360f, -0.03161998f, 0.03984772f, 0.02167976f, 0.00844556f, -0.00308503f, -0.03134225f, 0.02344480f, 
    -0.00201811f, -0.02925713f, 0.02504336f, 0.00162964f, -0.01211486f, -0.01911329f, -0.04003972f, -0.00848998f, 
    0.00872727f, -0.02029159f, 0.01816519f, -0.00150976f, -0.03373925f, 0.02981622f, -0.00756196f, -0.03860039f, 
    0.01869464f, 0.00122055f, 0.00228845f, 0.02278622f, 0.01221532f, 0.01177930f, -0.00396789f, -0.01883311f, 
    -0.04175755f, -0.02018636f, 0.00602722f, -0.00232244f, 0.01068795f, 0.02769998f, -0.01027224f, -0.01870338f, 
    0.00842749f, -0.00625855f, -0.00073068f, -0.01472674f, -0.00558406f, 0.00094016f, 0.02773216f, 0.02582015f, 
    -0.03346039f, -0.01186772f, 0.02491413f, 0.01119773f, -0.02048755f, -0.02398211f, -0.02562851f, -0.02322879f, 
    0.00214657f, -0.02915965f, 0.00737133f, -0.02608078f, -0.04086588f, -0.04035104f, -0.03134255f, 0.02061029f, 
    0.00671122f, 0.01712056f, -0.02865713f, -0.00057993f, 0.02301479f, 0.00128976f, -0.03576306f, 0.01026017f, 
    0.02491961f, -0.00426376f, 0.01886424f, -0.03474871f, 0.00552423f, -0.00436903f, 0.01913082f, 0.01105081f, 
    -0.00082694f, 0.00033978f, -0.02221344f, -0.00213364f, 0.02054966f, -0.01478472f, -0.01578476f, -0.02400957f, 
    0.00921277f, -0.03658990f, 0.01786610f, -0.02081247f, -0.00182018f, 0.00719469f, 0.01528795f, 0.02585433f, 
    -0.01586280f, -0.01616275f, -0.02042791f, 0.00612335f, 0.00524162f, -0.03421623f, -0.00411453f, 0.00070270f, 
    -0.01797830f, -0.00045840f, -0.00140488f, -0.02144603f, -0.00400019f, -0.02414474f, -0.00813830f, -0.04083860f, 
    0.02262077f, -0.02285153f, -0.01172798f, -0.01222458f, -0.02837044f, 0.01438479f, 0.01342728f, -0.02869085f, 
    0.01144060f, 0.02148744f, -0.01631936f, -0.01320960f, -0.03636720f, -0.03562100f, -0.03250922f, 0.03244544f, 
    -0.04507044f, 0.02037079f, -0.00937993f, 0.00330415f, -0.03999716f, -0.03133259f, -0.03044482f, -0.01325585f, 
    -0.00331410f, -0.01194224f, -0.01435503f, -0.00094941f, 0.00300735f, 0.02484224f, 0.00527079f, 0.01384335f, 
    0.01382596f, 0.00727683f, -0.00915424f, -0.00859019f, -0.01273181f, 0.01405375f, -0.00437431f, 0.02766231f, 
    0.00924983f, 0.02312440f, -0.01678712f, -0.03781330f, -0.00218892f, 0.00564086f, -0.02473104f, -0.03341056f, 
    -0.04166561f, 0.02164353f, -0.01958713f, -0.01712707f, 0.01953366f, -0.03209160f, 0.01190573f, -0.04324508f, 
    0.02642797f, 0.01228554f, -0.00399951f, 0.01700272f, -0.03885986f, -0.01357659f, 0.01520282f, 0.00262491f, 
    0.01368125f, -0.02833758f, 0.01494465f, -0.00269709f, 0.01852029f, 0.01245631f, -0.01916834f, -0.01680931f, 
    -0.02438861f, -0.01604661f, -0.00157413f, 0.01237755f, -0.02245242f, -0.03940318f, 0.01239067f, -0.03388205f, 
    0.01750905f, 0.00407936f, -0.04086018f, 0.00712919f, -0.02386305f, 0.02429162f, -0.02169132f, 0.01026135f, 
    -0.01189048f, 0.01267452f, -0.02457891f, -0.00007199f, -0.02868652f, 0.00551144f, 0.01443809f, -0.03099644f, 
    -0.01692800f, 0.01125351f, 0.00998189f, -0.00566204f, -0.01554175f, -0.02689402f, 0.00763397f, -0.03139160f, 
    -0.01926587f, -0.01889316f, -0.03744178f, -0.03879446f, 0.00045800f, -0.02144555f, -0.02110493f, -0.01826743f, 
    -0.03801775f, -0.01140601f, 0.02009779f, 0.01069850f, -0.00016198f, 0.00140474f, -0.01806078f, -0.01076840f, 
    0.01569841f, 0.00008173f, -0.01735384f, -0.04262812f, -0.04093670f, 0.01876587f, -0.01085572f, 0.01927339f, 
    -0.00321116f, -0.03756030f, -0.04229211f, -0.04020496f, -0.02754979f, -0.01445981f, -0.03607982f, 0.01058787f, 
    -0.00308291f, -0.03892430f, -0.03918263f, -0.03161293f, -0.02614942f, 0.01929510f, 0.01552975f, -0.01793514f, 
    -0.03581201f, -0.00407588f, -0.00694018f, -0.03313119f, 0.01657055f, 0.01882482f, -0.00189290f, 0.01772006f, 
    -0.01205122f, 0.02467087f, 0.03226054f, -0.00515617f, 0.01112543f, 0.01000144f, 0.02544130f, -0.03301881f, 
    -0.01619967f, -0.01144970f, 0.02124277f, 0.02608983f, -0.00338345f, -0.03706751f, 0.02437310f, -0.03315891f, 
    -0.01583911f, -0.00449627f, -0.01199346f, -0.01602415f, 0.02404662f, -0.00198105f, -0.00896100f, -0.00322335f, 
    0.02167381f, 0.02061320f, 0.01636274f, -0.01903633f, -0.03050702f, -0.03897976f, -0.04380473f, -0.00246059f, 
    -0.02169103f, 0.00159707f, 0.01541533f, 0.00790314f, -0.04368616f, 0.00785991f, 0.00492832f, -0.00936245f, 
    -0.04299327f, -0.03569847f, 0.00391832f, -0.03121836f, -0.04102274f, 0.01887318f, 0.00632199f, -0.00270894f, 
    -0.01582721f, -0.00264327f, -0.00770778f, -0.02461723f, 0.01808481f, -0.00549291f, 0.02067292f, 0.00333954f, 
    -0.01061852f, -0.01967426f, -0.01614559f, 0.01184605f, -0.02463163f, 0.00371232f, 0.02002366f, -0.02934858f, 
    -0.00993062f, -0.00829066f, -0.02597039f, 0.00263907f, -0.02686640f, -0.03353681f, -0.00783894f, -0.00502966f, 
    -0.02954279f, -0.01119660f, -0.03674909f, -0.01594842f, -0.01260922f, -0.03647032f, 0.00251495f, 0.02163440f, 
    0.02066174f, -0.00708743f, -0.01166763f, 0.02521867f, -0.00250595f, -0.00608122f, -0.03229512f, 0.01059502f, 
    -0.00921720f, 0.00659204f, -0.01197010f, 0.00542569f, 0.02040719f, -0.02256361f, 0.00217907f, -0.00225123f, 
    0.02585651f, 0.00652722f, 0.00239960f, -0.04358011f, -0.02570450f, 0.01765671f, 0.00656075f, -0.01072462f, 
    -0.02971475f, 0.00248109f, -0.01860712f, -0.01420946f, -0.03362958f, -0.03488204f, 0.02758437f, 0.02202566f, 
    -0.00656391f, 0.02665093f, -0.03563315f, -0.03924613f, -0.00190036f, 0.00703351f, -0.00621705f, 0.02028673f, 
    -0.01294206f, -0.01722484f, -0.00788612f, 0.02205678f, -0.03121433f, 0.00509405f, 0.00121677f, 0.00518588f, 
    -0.00331942f, 0.00867635f, 0.01455751f, 0.00822851f, -0.02302062f, -0.04088626f, -0.01220984f, 0.02428609f, 
    -0.03270049f, -0.00645121f, -0.03704435f, -0.02888672f, -0.00306508f, 0.01266455f, 0.01260742f, -0.02501282f, 
    0.00237565f, -0.00220395f, 0.02024006f, -0.03499104f, -0.02086844f, 0.00912582f, 0.02373808f, -0.00245664f, 
    -0.04128749f, -0.00739690f, 0.03647219f, -0.02513466f, -0.04344593f, -0.02391738f, 0.00937595f, -0.01955760f, 
    0.02024280f, 0.01184243f, -0.01068488f, -0.01444235f, -0.03543219f, -0.02413659f, 0.02193554f, -0.03105641f, 
    0.03116366f, 0.02904764f, -0.00138236f, 0.02842565f, -0.03896556f, -0.04134860f, -0.03081153f, -0.02974650f, 
    -0.01568955f, -0.02326825f, 0.00148241f, 0.03528952f, -0.03258152f, -0.03502886f, -0.01605810f, 0.03520016f, 
    0.01351934f, 0.01466087f, 0.00707347f, 0.02901529f, -0.01353781f, -0.01539300f, 0.01681878f, -0.01399678f, 
    -0.04092557f, -0.03142733f, 0.02796872f, -0.03484296f, -0.02673484f, -0.02318684f, -0.01528528f, -0.00543716f, 
    0.00152298f, -0.02767556f, -0.02534215f, 0.00372244f, -0.03786980f, -0.02777101f, -0.04090129f, -0.03494648f, 
    0.00132835f, 0.00963278f, -0.00434549f, -0.02110333f, -0.00909186f, 0.00833831f, 0.02259810f, 0.01648032f, 
    0.01226207f, -0.01598274f, 0.00833926f, 0.02213208f, -0.03051582f, 0.03001543f, 0.01097088f, 0.02121061f, 
    0.00185028f, 0.00154310f, -0.00325361f, 0.02054769f, -0.00306896f, 0.03660361f, 0.01183218f, 0.02065219f, 
    0.00366784f, 0.02100061f, 0.01908334f, 0.02595856f, -0.02044368f, 0.01116437f, 0.03024508f, 0.03110405f, 
    -0.00469840f, 0.01212687f, 0.02895961f, 0.02015696f, -0.03428582f, 0.02296576f, -0.03535530f, 0.03123207f, 
    -0.03551418f, 0.02405201f, 0.00118594f, -0.01478181f, 0.01893777f, 0.00026976f, 0.00947074f, -0.02977041f, 
    0.01585026f, -0.00149800f, -0.00441422f, 0.00909702f, 0.00218439f, -0.03928677f, -0.01945455f, -0.03447351f, 
    -0.00731402f, 0.00549646f, -0.03040429f, -0.00283529f, 0.01945047f, -0.00872851f, -0.01559506f, -0.03219104f, 
    0.01204236f, -0.03321346f, -0.02367978f, 0.02090631f, -0.03004903f, -0.01904631f, -0.00977429f, 0.00335243f, 
    -0.00579491f, -0.02152494f, -0.02066402f, 0.01779424f, -0.02641029f, 0.01889895f, 0.03576173f, -0.00616649f, 
    -0.02476105f, -0.03843232f, -0.01097432f, -0.03193476f, 0.00915375f, 0.02309016f, -0.04222978f, 0.02029005f, 
    -0.01735777f, 0.00737918f, 0.01356741f, 0.00474163f, -0.03042607f, 0.00562541f, 0.03169507f, 0.00438158f, 
    -0.03008503f, -0.03096524f, -0.01818258f, 0.01134829f, 0.02913080f, -0.00787908f, -0.03640672f, -0.00675820f, 
    -0.02423533f, -0.01587581f, -0.02387682f, -0.00571227f, -0.02831871f, -0.01302327f, 0.00909903f, 0.01381339f, 
    0.01271650f, -0.02050415f, 0.02559036f, -0.02350433f, 0.01326371f, -0.02696486f, -0.01353072f, 0.00044364f, 
    0.00175915f, -0.03684305f, 0.02145866f, -0.01666139f, 0.01181156f, -0.00075386f, -0.03012961f, 0.02009617f, 
    -0.00049096f, -0.03174939f, -0.00907267f, -0.01445035f, -0.03029938f, -0.03868237f, -0.03643338f, -0.01902873f, 
    -0.01598463f, 0.01725260f, 0.03722521f, -0.04055561f, 0.01314321f, -0.00566032f, -0.02661442f, -0.01508159f, 
    -0.00614630f, -0.02869124f, -0.02481905f, 0.02820629f, 0.01349862f, -0.01354162f, -0.00982759f, -0.00843500f, 
    -0.00253167f, -0.02416759f, -0.03359883f, -0.01683752f, -0.01550671f, -0.00971687f, -0.02508272f, -0.02268963f, 
    -0.02920751f, 0.02842104f, 0.03159787f, -0.03463610f, 0.00391686f, -0.02071053f, -0.00418909f, 0.02702305f, 
    0.02220064f, -0.03088973f, -0.01150691f, -0.00984001f, -0.03658082f, 0.01047652f, -0.01761395f, -0.00596107f, 
    -0.02111883f, 0.01141008f, 0.02209928f, 0.00631783f, -0.02291657f, -0.01444782f, -0.03299635f, -0.01744409f, 
    0.03227910f, 0.02982054f, -0.00614899f, 0.00624530f, -0.03453030f, -0.01889150f, -0.02042378f, -0.00016289f, 
    -0.04406453f, -0.01298570f, 0.01451847f, -0.03078498f, -0.03381612f, -0.02712568f, -0.03714497f, 0.00261403f, 
    -0.01173433f, 0.02404008f, 0.00226449f, 0.00033235f, 0.02057779f, 0.00311062f, -0.03203200f, -0.02388104f, 
    0.00881587f, 0.03281906f, 0.01204243f, 0.00747156f, -0.02904950f, 0.02890466f, -0.00121029f, -0.04274689f, 
    -0.04306191f, -0.01150277f, 0.01407684f, 0.01660761f, -0.02799755f, 0.00561060f, 0.00537732f, 0.01309854f, 
    0.00925682f, -0.02257565f, 0.02889063f, 0.00273571f, -0.02876663f, -0.00003538f, -0.03213242f, -0.02927688f, 
    0.03645878f, 0.01838703f, -0.00374786f, -0.00955726f, 0.01561695f, -0.03098031f, 0.00088754f, 0.00468105f, 
    0.00997111f, 0.00345607f, -0.02067125f, 0.01951904f, 0.00013772f, -0.02401620f, 0.00000811f, 0.02846989f, 
    0.00546918f, 0.01908430f, -0.02169756f, 0.00245180f, -0.03579539f, -0.03360157f, 0.02156993f, 0.02148339f, 
    -0.03451725f, 0.02164324f, -0.01914120f, 0.02688325f, 0.01332664f, -0.03174543f, -0.03169338f, -0.00830489f, 
    -0.01120993f, 0.00659241f, 0.02286123f, 0.01115219f, 0.00079848f, 0.00256476f, -0.03704421f, 0.00057276f, 
    0.01597658f, -0.04018173f, -0.01764191f, -0.01160786f, 0.00218142f, 0.00840519f, -0.00024297f, -0.04001482f, 
    0.03126929f, -0.03632363f, 0.03300632f, -0.03941999f, -0.02667765f, -0.01833713f, -0.00095833f, -0.00229446f, 
    0.02556667f, 0.00644599f, 0.00138869f, 0.00514854f, -0.03674050f, 0.00896980f, 0.04065272f, 0.00793801f, 
    0.02790927f, -0.02905886f, -0.01621234f, -0.02747980f, -0.00647341f, -0.02661293f, -0.03499624f, -0.03376787f, 
    0.01295758f, 0.04134731f, 0.00076039f, -0.02068316f, -0.04216004f, 0.00101786f, 0.00640944f, 0.01522126f, 
    -0.01158893f, 0.00078431f, -0.01570291f, -0.03133120f, 0.00390031f, 0.00723084f, 0.01782060f, -0.00360094f, 
    0.02597382f, -0.00312881f, 0.00353758f, 0.01601140f, -0.00475620f, 0.01607504f, 0.00059586f, -0.02149121f, 
    0.01949739f, -0.00137243f, 0.02387195f, 0.00983112f, 0.02611125f, -0.00786039f, 0.01028319f, -0.04574186f, 
    0.00130114f, -0.00068643f, 0.02376232f, -0.01028508f, 0.01886266f, 0.00890577f, -0.00971252f, 0.01125226f, 
    0.00518044f, 0.01568824f, -0.01970914f, -0.02087674f, 0.02735950f, 0.02398767f, 0.02830702f, 0.00452531f, 
    0.02020751f, -0.03491889f, 0.03060770f, 0.02231119f, 0.02241914f, 0.01861758f, -0.00848635f, -0.02586807f, 
    0.02088737f, -0.00386066f, -0.01788361f, -0.01691667f, -0.01882133f, 0.00430887f, 0.02682513f, 0.01683210f, 
    0.01861182f, -0.00894385f, -0.01862938f, -0.00607036f, -0.04488051f, -0.02004754f, -0.02841677f, -0.04305374f, 
    0.01598402f, 0.00074871f, -0.00538013f, -0.01496756f, -0.02646582f, -0.03089428f, -0.00446527f, -0.03868449f, 
    -0.03535577f, -0.00690465f, -0.00817605f, 0.01328747f, -0.02605925f, 0.02124995f, 0.00195227f, -0.00448878f, 
    0.02797721f, 0.00155945f, -0.01534641f, -0.00298299f, 0.02567518f, -0.02000329f, -0.02690060f, 0.01532653f, 
    0.01570856f, 0.03010385f, -0.01162667f, -0.01775447f, 0.02358731f, -0.00061890f, -0.01641116f, -0.02228690f, 
    -0.01972564f, 0.02601674f, -0.01855457f, -0.00980002f, -0.00055276f, -0.01188950f, -0.00345730f, 0.01181269f, 
    0.00738229f, 0.00581473f, 0.02398445f, -0.00249691f, -0.01274208f, -0.01796511f, -0.00751436f, -0.03293250f, 
    -0.02209562f, 0.01958164f, 0.02254169f, 0.01630785f, 0.02314477f, 0.01847032f, -0.03663370f, -0.02953141f, 
    0.00617449f, -0.00069263f, -0.01452792f, -0.04042369f, 0.00967808f, -0.00154649f, -0.02688935f, 0.00239211f, 
    0.01117190f, 0.01843762f, 0.01367014f, 0.02222372f, 0.01901958f, 0.01028547f, 0.00526065f, -0.01949793f, 
    -0.03483269f, -0.01425851f, -0.00068890f, -0.01973405f, -0.01835728f, 0.00883432f, -0.00639865f, -0.02190839f, 
    0.02281621f, -0.01311035f, -0.03337767f, -0.03224863f, -0.01978152f, -0.02465072f, 0.02451816f, -0.01914377f, 
    0.00177593f, 0.00354654f, -0.03476786f, 0.01649889f, 0.01779347f, -0.02461314f, -0.00489608f, 0.00143120f, 
    0.00946133f, -0.02004343f, -0.00397320f, -0.00435932f, -0.01324251f, -0.00354056f, 0.00979087f, 0.00062447f, 
    -0.00830949f, -0.01303970f, -0.01832339f, 0.02189588f, -0.03348645f, 0.00241537f, 0.01649682f, -0.04075405f, 
    -0.03641926f, -0.00564456f, 0.02256002f, -0.03294108f, -0.03410632f, 0.01151771f, -0.03727802f, -0.03422091f, 
    -0.03609084f, -0.01094418f, -0.01738073f, 0.01192772f, 0.01851077f, 0.01885793f, -0.01091274f, 0.01699310f, 
    0.01027676f, -0.00126641f, -0.01308319f, -0.03269180f, -0.00404048f, -0.03141463f, -0.02287304f, -0.01826591f, 
    0.02106840f, 0.00615217f, 0.00956038f, 0.02594649f, -0.03621721f, 0.01354236f, -0.01501917f, 0.00132266f, 
    -0.01994644f, 0.00999883f, -0.00104358f, 0.03608098f, -0.00980441f, -0.01581636f, -0.02682326f, 0.00673024f, 
    -0.01917458f, -0.02910948f, -0.01874411f, 0.01555601f, -0.01407437f, -0.00986301f, -0.03961730f, -0.01669477f, 
    -0.02764210f, 0.02481299f, 0.01773397f, 0.00313451f, -0.02082766f, 0.00867006f, -0.01116633f, -0.01001465f, 
    0.00613542f, -0.01058791f, -0.02427126f, 0.03113973f, -0.03563351f, 0.04349324f, -0.00116953f, -0.00054769f, 
    -0.00102450f, 0.03019337f, -0.00722288f, -0.01921535f, -0.03724087f, 0.01517785f, 0.00356553f, -0.00191700f, 
    -0.02314825f, 0.00073474f, -0.00176488f, -0.01733945f, -0.01773600f, -0.03128998f, 0.01926921f, 0.00665581f, 
    -0.03796864f, -0.00578074f, -0.02130598f, 0.00430822f, -0.00513878f, 0.00346526f, 0.03075439f, 0.01559802f, 
    0.00384649f, -0.00048337f, -0.01459451f, 0.01156147f, 0.02160335f, 0.02907469f, 0.00039998f, -0.01917168f, 
    -0.02734816f, -0.02810410f, 0.02275599f, -0.02274756f, 0.03367790f, 0.03435341f, -0.02055218f, -0.02672640f, 
    -0.00931099f, 0.01757523f, 0.04014693f, 0.02475991f, 0.00138860f, -0.03013675f, -0.04414018f, 0.00497874f, 
    -0.02076191f, 0.00929162f, 0.00841290f, -0.00022789f, 0.00782305f, 0.02759333f, -0.03229120f, 0.02857505f, 
    -0.02517445f, 0.00924471f, 0.02575166f, -0.03094006f, -0.00217506f, 0.01760424f, 0.01909150f, -0.01222399f, 
    0.03210302f, -0.00816636f, -0.00464096f, 0.01389395f, -0.02115432f, 0.00765214f, -0.00518965f, 0.01255373f, 
    0.02034688f, -0.03802726f, -0.03756434f, 0.02399693f, 0.02961621f, -0.01230426f, 0.02729556f, -0.02962167f, 
    -0.03692679f, -0.00119877f, 0.03126547f, 0.01453309f, 0.00321751f, 0.01179169f, 0.02885344f, -0.03583926f, 
    -0.01436133f, -0.03383904f, -0.02715838f, -0.02521291f, -0.02825890f, -0.02349595f, -0.00636591f, 0.02826877f, 
    -0.03362612f, -0.03194532f, -0.01412636f, -0.00043122f, -0.00658505f, 0.01810522f, 0.02461544f, -0.01325028f, 
    0.00944514f, 0.02867922f, -0.03247691f, 0.00684759f, 0.03494928f, -0.02531227f, -0.01156047f, -0.03552264f, 
    -0.04119822f, 0.00300037f, -0.02671071f, 0.02677827f, -0.03839722f, -0.03852564f, 0.00029668f, -0.04015382f, 
    0.00412370f, 0.01185329f, -0.03668815f, -0.03424704f, -0.01072416f, 0.03576354f, 0.01056523f, 0.01840928f, 
    -0.03134722f, 0.02108751f, -0.03706858f, -0.00259514f, -0.01456100f, 0.00434840f, -0.00117440f, 0.01344263f, 
    -0.00844176f, 0.00322016f, 0.02636999f, 0.03273165f, 0.01929386f, 0.01134797f, 0.02697320f, -0.00715152f, 
    -0.04682487f, 0.00342436f, -0.03520345f, -0.01342494f, 0.03031116f, 0.02964521f, 0.02612839f, 0.01208160f, 
    -0.03382644f, -0.00126394f, 0.01581827f, 0.00796502f, 0.02469576f, -0.00987515f, -0.00002750f, -0.00176809f, 
    -0.14198789f, 0.12009450f, -0.10023607f, 0.28856727f, 0.04384879f, 0.08399550f, -0.01983546f, 0.01040467f, 
    -0.05157009f, -0.07967594f, -0.24236190f, -0.39571163f, 0.17262925f, 0.08620688f, 0.16765390f, -0.00039554f, 
    0.12280451f, -0.04508232f, 0.09384731f, 0.19583741f, -0.08509347f, -0.01459983f, 0.11867983f, 0.20209518f, 
    -0.01735117f, 0.16963349f, -0.00017985f, 0.08200421f, 0.04733995f, 0.06849609f, -0.15912503f, -0.07770931f, 
    0.12960988f, 0.04681979f, 0.08479314f, 0.06395897f, 0.02651415f, -0.17071983f, -0.21067090f, -0.00210925f, 
    0.01247234f, 0.06660101f, 0.03368987f, -0.05305163f, -0.02084314f, -0.19765139f, -0.03947233f, -0.26387754f, 
    -0.32849759f, 0.01555962f, -0.42494667f, -0.05687102f, 0.08885259f, 0.01750997f, 0.06972174f, -0.09230978f, 
    0.05411725f, -0.39401555f, 0.07500351f, 0.18171622f, -0.08591731f, -0.13271594f, 0.15871690f, 0.19726799f, 
    0.15009430f, 0.16580917f, -0.10642532f, 0.20129585f, 0.00747696f, -0.03869626f, 0.16911726f, -0.11601239f, 
    -0.24025419f, -0.12208045f, -0.22304827f, -0.08496886f, -0.14338830f, -0.08589916f, 0.15631473f, 0.00238204f, 
    0.38954484f, -0.06877082f, -0.29082751f, 0.05426559f, -0.08483934f, -0.07796217f, 0.11356979f, 0.14625582f, 
    -0.11982387f, -0.14307663f, -0.00634309f, -0.05128423f, -0.14559589f, -0.05299946f, 0.07164518f, 0.05769575f, 
    -0.15852258f, -0.00347660f, 0.05172291f, 0.12210065f, 0.09361342f, -0.20576103f, 0.07940790f, 0.12793414f, 
    -0.10200523f, -0.04698911f, -0.11200418f, -0.03505143f, 0.00239238f, -0.11453266f, -0.07090704f, 0.02306575f, 
    0.09074941f, 0.18850695f, 0.00099726f, 0.09117156f, -0.01366881f, 0.02418851f, -0.07713982f, -0.02672975f, 
    0.75718921f, 0.04640588f, 0.07381830f, 0.15406801f, 0.23952672f, 0.07638016f, 0.08415548f, 0.13987577f, 
    -0.12405100f, -0.02657392f, 0.25023219f, 0.26499471f, 0.23714110f, 0.12918520f, 0.19278818f, 0.19892165f, 
    0.01910109f, -0.02202038f, 0.08663169f, 0.24008982f, 0.00698225f, 0.07771597f, -0.01176261f, -0.12137651f, 
    0.03614391f, -0.25173923f, 0.26628393f, 0.09666587f, -0.00574920f, -0.21009527f, 0.06927916f, 0.09470769f, 
    -0.07074412f, 0.05520056f, -0.04468516f, 0.20542476f, -0.20973507f, -0.06189039f, 0.06906669f, -0.21939671f, 
    0.09811653f, -0.05734021f, -0.07669455f, 0.16805433f, 0.10150153f, 0.16907848f, 0.01399077f, -0.13594003f, 
    0.10911027f, 0.09601644f, -0.07245436f, 0.23755580f, 0.08296493f, -0.27896366f, -0.03193126f, 0.29066011f, 
    -0.13847350f, 0.26071879f, -0.12743819f, 0.12126842f, 0.59507054f, 0.35660344f, -0.01351921f, 0.31440768f, 
    -0.10272976f, 0.14201443f, -0.05507309f, 0.28298727f, 0.15400787f, 0.17332314f, -0.11383542f, 0.05045641f, 
    0.05939073f, -0.08412571f, 0.12602642f, 0.23981033f, 0.16670860f, 0.03753780f, -0.05969790f, -0.00366839f, 
    0.08052616f, 0.09312186f, -0.02968291f, -0.19102459f, 0.09632749f, -0.12019775f, 0.25761902f, 0.07455597f, 
    0.18030600f, 0.07538527f, 0.03546517f, -0.06787302f, -0.03725420f, 0.14573260f, 0.10957107f, 0.09538733f, 
    -0.10768685f, 0.00742456f, -0.00538430f, 0.12678875f, 0.08086707f, 0.14170136f, -0.45823687f, -0.00945512f, 
    -0.02069306f, -0.14543381f, 0.14551952f, 0.04087715f, -0.09161755f, 0.10056672f, 0.01780029f, 0.10110224f, 
    -0.02453370f, -0.04449004f, 0.01671016f, 0.01679777f, 0.09430898f, 0.07891177f, 0.08474231f, 0.15528044f, 
    -0.02771932f, 0.07426225f, 0.33521774f, 0.42704126f, 0.06487522f, -0.00167341f, -0.00954128f, -0.01060567f, 
    -0.08175374f, 0.09236712f, 0.14202094f, -0.02670907f, -0.22629975f, -0.20710486f, -0.13114104f, 0.06262981f, 
    0.08512896f, -0.01645489f, 0.08857302f, -0.02145250f, -0.06315999f, 0.02146027f, -0.27465048f, -0.17328182f, 
    -0.01966410f, -0.06431987f, -0.02380313f, -0.03777453f, -0.06762622f, 0.13504942f, -0.01222236f, -0.21043164f, 
    0.00317986f, 0.02529520f, 0.02963624f, 0.12385499f, 0.00932730f, -0.02829935f, -0.00864728f, 0.09105210f, 
    0.00616214f, 0.04523941f, 0.04973529f, 0.21230106f, 0.01302017f, 0.06057667f, -0.02524382f, -0.09734098f, 
    -0.36607355f, 0.05772529f, -0.02566643f, -0.12766802f, 0.00121449f, 0.03528556f, 0.14132795f, -0.13972975f, 
    0.23786303f, 0.02534183f, -0.06852745f, -0.12717061f, -0.03672206f, -0.04726660f, -0.02000363f, 0.08435512f, 
    -0.01922206f, 0.06893660f, 0.04148871f, 0.07163694f, 0.05652093f, 0.00498103f, 0.03339588f, -0.07341119f, 
    0.26505938f, 0.08627172f, 0.16237843f, 0.40202898f, 0.05678219f, 0.37820089f, -0.14197925f, 0.10619811f, 
    -0.07411700f, 0.00729016f, -0.00118172f, 0.06742009f, -0.06260391f, 0.10463721f, 0.08187164f, -0.01283073f, 
    -0.02567482f, -0.06437311f, -0.01767607f, 0.13552611f, 0.01224849f, -0.05035638f, -0.03953470f, 0.19412695f, 
    0.18652557f, -0.01911265f, -0.14567058f, -0.09384173f, 0.02228068f, -0.05544106f, 0.12220588f, -0.01380351f, 
    0.06440645f, 0.07888850f, -0.36367777f, -0.36475700f, -0.09157090f, -0.17718486f, -0.06851909f, 0.01165835f, 
    -0.02081119f, -0.03703762f, -0.04517333f, 0.27966088f, -0.09988410f, -0.13651451f, 0.04585292f, 0.00136200f, 
    0.12672113f, -0.05286804f, 0.05183182f, 0.14541647f, 0.03430653f, 0.10771557f, 0.10848422f, -0.03979423f, 
    0.16164693f, 0.00500159f, -0.08944098f, 0.05066224f, -0.50580442f, -0.22119328f, 0.17385682f, 0.04903156f, 
    0.02660125f, -0.12315927f, 0.10956883f, 0.01425221f, -0.14400300f, -0.00422695f, 0.28320086f, 0.17159615f, 
    0.13613449f, 0.03571133f, 0.00674965f, 0.09528522f, -0.08814687f, 0.09195597f, 0.05885372f, -0.10207521f, 
    0.35714018f, 0.11977116f, -0.11211824f, -0.05267937f, 0.02488678f, -0.10285441f, -0.10548178f, -0.05319058f, 
    0.11108696f, -0.02097222f, -0.00446077f, 0.00888186f, -0.20277299f, 0.01114944f, -0.17987557f, -0.36082098f, 
    -0.12508596f, -0.15893877f, -0.10338221f, -0.08182288f, -0.09956341f, -0.01606200f, -0.09820261f, -0.20474033f, 
    0.12408608f, 0.15773927f, 0.13018264f, 0.29211035f, -0.08107121f, -0.05174167f, 0.03869257f, 0.25415856f, 
    0.02156197f, 0.27250743f, 0.18417296f, -0.01099372f, 0.06256030f, 0.07222423f, 0.07119749f, 0.10964368f, 
    -0.13220929f, 0.28659484f, -0.03600080f, 0.21177824f, -0.00394084f, 0.02748714f, 0.07991281f, -0.13799319f, 
    -0.01894030f, 0.06383644f, 0.19925834f, 0.00658081f, -0.16722995f, -0.05452486f, -0.01163257f, 0.02878720f, 
    0.05715582f, -0.22757408f, 0.28586474f, -0.03726389f, 0.00935185f, 0.17183569f, -0.16653880f, -0.00637942f, 
    -0.21871686f, -0.18170269f, 0.08902422f, 0.22382131f, -0.00877209f, -0.02410923f, -0.18562666f, -0.15828204f, 
    -0.12083501f, -0.06171535f, -0.03358034f, 0.13874890f, 0.08715987f, -0.07432518f, 0.28747052f, 0.35652810f, 
    0.24177936f, 0.39021137f, -0.04258372f, 0.22107153f, -0.03170833f, 0.01501345f, 0.05385834f, 0.04170791f, 
    -0.17543295f, 0.09993291f, 0.06841401f, 0.16626617f, 0.04913234f, 0.05894157f, -0.01963225f, 0.03256549f, 
    0.10464744f, -0.06749839f, -0.04577054f, 0.13122636f, -0.05184386f, -0.02415893f, -0.14071403f, -0.00160046f, 
    -0.02277533f, -0.02509524f, 0.01905541f, -0.05037674f, 0.01759997f, -0.25274435f, -0.33522168f, -0.56884027f, 
    -0.02472578f, 0.10444836f, 0.07044087f, 0.23241799f, -0.04924357f, 0.17920376f, -0.02986892f, 0.07893521f, 
    0.07154367f, -0.03809246f, 0.08401876f, 0.31074920f, 0.10765904f, 0.35618141f, 0.27718973f, 0.17780553f, 
    -0.01934657f, 0.06768782f, -0.01416323f, 0.00831135f, -0.00077067f, -0.02347611f, 0.02366399f, -0.01349982f, 
    -0.03344874f, -0.12509465f, 0.14480908f, 0.17113923f, 0.28715488f, -0.16616303f, -0.06646412f, -0.16261531f, 
    0.01236100f, -0.00159081f, 0.11408985f, 0.14178061f, 0.11796001f, -0.07247301f, 0.18595850f, 0.07662974f, 
    -0.00610994f, -0.05953281f, 0.01016628f, 0.05822910f, -0.13430394f, 0.04741033f, 0.13908379f, -0.08172628f, 
    0.06831916f, -0.30495280f, 0.14348203f, -0.12347523f, 0.01889140f, 0.04211126f, -0.09241582f, 0.04728097f, 
    0.07926045f, -0.25507319f, -0.12305123f, -0.08955551f, -0.02768005f, -0.13464022f, -0.07923266f, 0.15894327f, 
    -0.00334350f, -0.03136946f, -0.01669618f, 0.19520716f, 0.06365567f, -0.07822967f, 0.05714598f, -0.06090130f, 
    -0.01570391f, -0.04019030f, 0.11386356f, 0.14230503f, -0.00494264f, 0.04990245f, -0.00420718f, -0.14513271f, 
    0.03734623f, 0.04682438f, -0.13330042f, -0.09133125f, 0.11261481f, -0.09238750f, -0.18925469f, -0.11176156f, 
    0.04300375f, 0.25739703f, 0.02435486f, -0.12883072f, 0.12660623f, 0.01692719f, -0.06241672f, 0.00821060f, 
    0.03550307f, 0.62182963f, 0.00641706f, 0.11085272f, 0.02052138f, -0.00758126f, 0.16355886f, -0.07961439f, 
    0.06691024f, -0.03447520f, -0.03589914f, 0.03886212f, 0.00917653f, 0.18874766f, 0.00825239f, -0.22417559f, 
    -0.02838766f, -0.02094680f, 0.09545910f, 0.06378178f, 0.07169775f, -0.10380632f, -0.05413495f, -0.02343656f, 
    -0.11256549f, 0.11070873f, 0.09751563f, -0.02273099f, 0.04088396f, 0.05729244f, 0.07236221f, -0.01229010f, 
    -0.09695671f, 0.33164418f, -0.20482999f, 0.10871655f, -0.11446935f, 0.08215670f, 0.05928022f, 0.09547614f, 
    0.03728453f, -0.05493531f, -0.02116045f, 0.02771568f, 0.05856854f, -0.03674247f, -0.09108777f, 0.05752423f, 
    -0.17590624f, 0.03278842f, -0.10226554f, 0.19308320f, -0.05787373f, 0.02243002f, 0.12790048f, 0.08123432f, 
    -0.12270805f, -0.11076181f, -0.14693150f, -0.21118142f, -0.05477353f, 0.00715832f, 0.06358675f, -0.10845514f, 
    -0.13918906f, -0.09737659f, -0.05339391f, -0.03978963f, 0.05130760f, 0.01403833f, 0.05753952f, 0.12893353f, 
    0.06585525f, 0.16209969f, 0.43706444f, 0.34782991f, 0.04971042f, -0.09546437f, 0.06050805f, -0.06425245f, 
    -0.00891706f, -0.03370625f, -0.02971554f, -0.05183625f, -0.03719096f, 0.37017822f, 0.07900095f, -0.02473777f, 
    0.07611267f, 0.16642871f, 0.16705792f, -0.19576713f, 0.02531085f, 0.07482146f, 0.02065020f, 0.04263837f, 
    -0.41076791f, -0.07536215f, 0.09470896f, -0.06210003f, 0.03361320f, 0.07959406f, 0.08192284f, 0.01113935f, 
    0.10709205f, -0.07362004f, -0.12044129f, 0.08819363f, 0.03746716f, 0.10244202f, -0.15837455f, 0.05637117f, 
    -0.03800353f, 0.05369976f, 0.24686763f, 0.14211249f, -0.20876901f, -0.11397789f, -0.09610770f, -0.20500080f, 
    -0.07782344f, 0.15725720f, -0.14667593f, 0.13987064f, -0.06251518f, -0.02396465f, 0.00931664f, 0.03032994f, 
    -0.02213252f, -0.12326664f, 0.23805647f, 0.15397805f, 0.11473859f, -0.04245429f, -0.03494871f, 0.32705960f, 
    0.05689728f, 0.00703203f, -0.06590790f, 0.05104055f, 0.00229846f, -0.21288338f, -0.09986927f, 0.04581140f, 
    0.56159806f, 0.27284360f, 0.15148339f, 0.07177314f, 0.01709834f, -0.04374352f, -0.02355091f, 0.11818891f, 
    0.05434338f, 0.16633214f, -0.06972433f, 0.32957610f, 0.10257146f, -0.10121083f, -0.01920560f, 0.35058689f, 
    -0.03173531f, -0.04049106f, -0.20706350f, 0.11269628f, -0.12108040f, -0.18715291f, -0.19897960f, -0.03635053f, 
    0.14770684f, 0.16221678f, -0.09845417f, -0.11975008f, 0.01769527f, -0.01031509f, 0.21503943f, -0.11884379f, 
    0.24480315f, 0.11005590f, 0.11914496f, 0.14559506f, -0.10831932f, -0.26841235f, -0.09938336f, 0.04988443f, 
    0.10114884f, -0.00352048f, 0.03150472f, 0.03184331f, 0.01626471f, -0.03195057f, -0.01444582f, 0.09524728f, 
    -0.19797064f, 0.04304509f, -0.04463122f, -0.07083171f, 0.06828085f, 0.05585455f, -0.13083389f, -0.13615157f, 
    0.01822209f, 0.04389608f, -0.05145732f, 0.00497395f, 0.32790437f, 0.27725047f, 0.02226913f, -0.00897781f, 
    -0.02374796f, -0.02520349f, 0.05104361f, 0.02597859f, 0.16035692f, 0.19182506f, 0.02312466f, 0.19340959f, 
    0.19407496f, 0.65801293f, -0.08301502f, 0.11531116f, 0.04604550f, 0.01954002f, 0.06465916f, -0.15400049f, 
    0.21031474f, 0.01979547f, -0.07762836f, 0.06377511f, -0.04479517f, -0.04061761f, 0.07766201f, -0.04728295f, 
    0.04160866f, 0.10043238f, 0.10061529f, -0.03094607f, -0.06496566f, -0.00141257f, 0.07153343f, -0.12750150f, 
    -0.22271205f, 0.24594936f, 0.28349614f, 0.21760406f, -0.08547067f, -0.14204185f, -0.16719490f, 0.14198937f, 
    0.04972307f, 0.05475476f, -0.01090740f, -0.05632576f, -0.31846839f, -0.30498919f, 0.05866022f, 0.17032570f, 
    -0.08475861f, -0.08317339f, 0.06668409f, 0.00036568f, -0.02844073f, -0.03667567f, 0.01222661f, 0.08876679f, 
    -0.42860517f, -0.06863210f, 0.22719997f, 0.30254382f, -0.08106901f, -0.22161195f, -0.00658128f, 0.19294646f, 
    0.02750089f, -0.04665972f, -0.03094996f, 0.05964595f, -0.18385866f, -0.14545819f, 0.06403681f, 0.08669300f, 
    0.00599149f, 0.01105671f, -0.02611542f, 0.04532172f, 0.11289515f, -0.06321668f, -0.02499508f, -0.04538271f, 
    0.20599578f, -0.28049725f, -0.05260088f, 0.09441973f, 0.27433273f, 0.02528072f, 0.11620913f, -0.10719450f, 
    -0.00093017f, -0.10851470f, -0.01401557f, -0.00566612f, -0.24587519f, -0.16904953f, 0.09910439f, 0.14335524f, 
    -0.16673540f, -0.12447122f, -0.16636877f, -0.00970909f, 0.07040114f, 0.05657687f, -0.12090305f, -0.08392435f, 
    0.10396839f, -0.10359938f, -0.32370612f, 0.49402937f, -0.13648203f, 0.09742311f, -0.12959228f, -0.01924527f, 
    0.26211426f, -0.08818856f, 0.14416210f, -0.01410692f, -0.30984840f, 0.25430688f, 0.09967773f, 0.24857622f, 
    0.09766401f, -0.00009931f, -0.03264529f, -0.05638513f, 0.05077382f, -0.05382527f, 0.04164689f, -0.00196371f, 
    0.49865431f, -0.03649960f, -0.52299857f, 0.14921817f, 0.05131931f, -0.04130686f, 0.01123690f, 0.06545965f, 
    0.14874299f, 0.12349729f, 0.18591350f, 0.01124735f, 0.01839453f, -0.20258400f, -0.00529401f, 0.36616299f, 
    -0.17172219f, 0.17700796f, -0.20335273f, -0.15349381f, -0.31018648f, 0.16847265f, -0.03307124f, 0.04448846f, 
    0.04393740f, 0.13704477f, 0.04152451f, 0.03124862f, 0.05977837f, 0.17078175f, 0.15547314f, -0.06127088f, 
    0.12277932f, -0.03009307f, 0.19495727f, -0.03118434f, -0.24429311f, -0.07039730f, -0.47628507f, 0.19035202f, 
    -0.11709765f, 0.21923475f, 0.03618609f, -0.03403948f, -0.09461440f, -0.13614596f, 0.04264097f, -0.06448745f, 
    0.00080207f, 0.25069514f, -0.03776350f, -0.02117735f, 0.14185517f, -0.19141290f, -0.11224752f, -0.01852711f, 
    -0.11234687f, 0.07794269f, 0.10100985f, 0.06564108f, -0.04087467f, -0.06558105f, -0.17619608f, -0.17127946f, 
    0.06848069f, -0.02990318f, 0.06414331f, 0.01032409f, 0.09242912f, -0.12843809f, 0.02332303f, 0.03164214f, 
    -0.05500379f, 0.26611981f, -0.14619188f, 0.03987041f, -0.02791100f, 0.02353541f, -0.08889811f, -0.02115556f, 
    -0.02947417f, 0.01492143f, 0.19345386f, 0.16590580f, 0.22345574f, 0.56645745f, -0.09686054f, 0.03525780f, 
    -0.01716916f, -0.02539569f, 0.06875154f, -0.00045150f, 0.14965285f, 0.09805635f, -0.04827051f, 0.14595167f, 
    0.00721415f, 0.02697649f, -0.00431059f, 0.07492684f, 0.08338004f, 0.06360357f, 0.13449936f, 0.10437684f, 
    -0.06688501f, -0.11152712f, -0.04550288f, -0.13892606f, -0.08535164f, -0.28463298f, -0.19620150f, -0.04891810f, 
    0.25436646f, 0.08708991f, 0.10542241f, 0.00533618f, 0.11980099f, 0.05681933f, -0.11418810f, -0.10730164f, 
    -0.24534293f, 0.44139209f, 0.45466706f, 0.09975561f, 0.02344120f, -0.09679250f, 0.00686527f, -0.23028594f, 
    0.07114411f, -0.03581792f, 0.11831625f, 0.16654517f, -0.04248125f, -0.12562095f, -0.03285562f, 0.01111408f, 
    0.02098569f, -0.01468887f, 0.04463251f, 0.05628038f, -0.00973159f, -0.04009122f, 0.02985170f, -0.10106300f, 
    -0.09425061f, 0.11597825f, -0.10693196f, 0.16250859f, -0.13112643f, 0.20640354f, -0.10153733f, -0.22651440f, 
    -0.02799838f, 0.08217428f, -0.00908111f, 0.08763597f, -0.06408338f, -0.04215103f, -0.21073422f, 0.12686829f, 
    0.05820382f, -0.04103897f, 0.00922455f, 0.02015639f, -0.11825734f, -0.16983299f, -0.12975012f, 0.09171429f, 
    -0.13076502f, 0.13092530f, -0.19549485f, -0.05438852f, -0.03469007f, -0.03450977f, 0.18537776f, 0.03275561f, 
    0.06613203f, 0.09381466f, -0.04184595f, -0.00524425f, -0.33101940f, -0.05974647f, 0.04493508f, 0.27427101f, 
    -0.35122642f, 0.04745885f, -0.01223565f, 0.33026525f, -0.01812349f, 0.00974753f, 0.08813628f, -0.02720637f, 
    -0.11357951f, -0.01657454f, -0.04943253f, 0.09661383f, -0.01538721f, 0.01263219f, 0.09649217f, -0.05421410f, 
    -0.00535506f, -0.04781064f, 0.05020371f, 0.05489694f, -0.41738981f, -0.45061699f, 0.27713993f, 0.32916000f, 
    0.00968153f, -0.05939149f, 0.05945024f, 0.05203836f, -0.16142453f, 0.01141831f, 0.12647958f, -0.06607914f, 
    0.11254621f, 0.32272473f, 0.10004152f, 0.14365289f, -0.00074798f, -0.15243068f, -0.08103851f, 0.00804489f, 
    0.20055495f, -0.25701493f, 0.02131190f, 0.01562562f, -0.04778954f, -0.08085410f, 0.01633294f, 0.09385110f, 
    0.00803052f, -0.12569258f, -0.12294263f, -0.02713008f, -0.02103126f, 0.17908996f, -0.02004907f, 0.18118818f, 
    -0.15979806f, -0.15731263f, 0.09088510f, 0.07488491f, -0.10282706f, -0.09873995f, -0.15243684f, -0.07878748f, 
    -0.09341667f, 0.05270988f, -0.12078094f, 0.04475285f, -0.18061894f, -0.04062150f, 0.13959734f, 0.10336493f, 
    0.00687843f, 0.00705779f, -0.06301796f, -0.08000824f, 0.05092893f, -0.05203699f, -0.04980556f, -0.08005425f, 
    0.00599452f, -0.01600651f, -0.36094463f, -0.16687992f, -0.02319326f, 0.06607524f, -0.09261625f, -0.05366642f, 
    0.15420835f, -0.13234663f, 0.01670293f, 0.00096180f, 0.04460952f, -0.23322287f, -0.03041138f, 0.05955810f, 
    0.13596472f, -0.08571365f, 0.12232342f, 0.06754070f, 0.02096656f, 0.18780285f, -0.06027217f, 0.12354814f, 
    -0.39618173f, -0.30227762f, -0.05088799f, 0.46405673f, -0.07801518f, -0.00660440f, -0.09304500f, 0.06694245f, 
    -0.18005176f, 0.00098417f, -0.01706185f, 0.01522662f, -0.29082796f, -0.10826247f, -0.00754504f, 0.13324919f, 
    -0.08385212f, 0.07546199f, -0.01359086f, -0.06542883f, 0.07399553f, -0.05679774f, 0.07367037f, 0.02582324f, 
    -0.07283804f, -0.24443790f, -0.20907138f, -0.06386271f, 0.09669789f, 0.05356093f, 0.00074931f, 0.01633561f, 
    -0.00949398f, 0.01054090f, -0.13486077f, 0.00861172f, -0.01200598f, -0.01797811f, -0.05109775f, -0.13891245f, 
    0.04360277f, -0.04178480f, 0.13983686f, -0.02237900f, 0.10800053f, 0.06681684f, 0.18694156f, 0.08328523f, 
    -0.16113579f, -0.02597380f, 0.18851225f, 0.06294694f, -0.04141657f, 0.04578644f, 0.10636692f, 0.06751640f, 
    0.02770480f, 0.04241335f, -0.06720915f, -0.10603783f, -0.58636111f, -0.35497901f, -0.03454834f, 0.44493079f, 
    0.22238240f, 0.16497210f, 0.02029183f, 0.06702452f, -0.09795042f, -0.04648762f, -0.00999322f, 0.08004723f, 
    0.22963217f, -0.05720670f, -0.01881778f, -0.11041120f, 0.08749981f, -0.08108598f, 0.18620142f, -0.06235022f, 
    0.22787197f, -0.02722338f, 0.10831887f, 0.00216539f, -0.05777614f, 0.10686027f, -0.06330892f, -0.18585762f, 
    -0.00424686f, -0.00586340f, 0.00704266f, 0.03731140f, 0.04479672f, -0.02739486f, -0.08025672f, 0.28595194f, 
    0.01162847f, -0.05828052f, 0.09292097f, -0.33077085f, 0.01937180f, 0.07299732f, -0.04564844f, 0.07875109f, 
    0.09004705f, 0.09642683f, 0.13884048f, 0.27747396f, 0.11177187f, 0.38026646f, -0.10998770f, 0.07246322f, 
    -0.03416429f, 0.02105560f, -0.01032024f, 0.16570076f, 0.14475144f, 0.04582585f, -0.00721947f, -0.06407613f, 
    -0.19141954f, -0.17275494f, -0.08169314f, 0.01799634f, 0.07551351f, 0.10517004f, 0.07493533f, -0.04457276f, 
    0.01274326f, 0.01520208f, 0.03736164f, 0.00874379f, -0.09550946f, -0.16250567f, 0.02901173f, 0.19399869f, 
    -0.03958766f, 0.04678302f, -0.03014398f, -0.19814548f, -0.11181533f, -0.09811406f, -0.05338981f, -0.04055054f, 
    -0.27887204f, -0.29147646f, 0.17720006f, 0.23255293f, 0.02889438f, 0.10930678f, -0.19426593f, -0.19622359f, 
    -0.04629614f, 0.07118513f, -0.04516647f, 0.06677805f, -0.17319866f, -0.28168178f, 0.06573918f, -0.10695338f, 
    0.08057659f, -0.08170506f, -0.01869016f, 0.05486865f, 0.06425218f, 0.18357256f, -0.07513661f, -0.01879228f, 
    -0.02628910f, -0.07240784f, 0.11014106f, -0.02876657f, -0.01027866f, 0.01533578f, -0.06397866f, -0.00457731f, 
    -0.13398892f, 0.06620467f, -0.20920537f, -0.07877588f, 0.16047265f, -0.10405877f, -0.19474028f, -0.28773093f, 
    0.08431983f, -0.11444066f, 0.03452395f, 0.04499087f, 0.05334662f, 0.09686622f, 0.01219375f, 0.19987966f, 
    -0.13535127f, 0.27370334f, 0.33975035f, 0.18188594f, -0.00710964f, -0.02119923f, 0.03545380f, 0.07613069f, 
    0.14319944f, 0.10527066f, 0.05998731f, 0.16405150f, -0.08666564f, -0.14649932f, -0.24312074f, -0.07454153f, 
    -0.07522629f, -0.03122852f, 0.03708877f, 0.02258464f, -0.00013918f, -0.14689399f, -0.11156065f, -0.16006139f, 
    -0.13181947f, -0.29403111f, -0.11524716f, -0.22932258f, 0.04678225f, 0.13315845f, 0.15292302f, 0.07032824f, 
    0.00922858f, -0.03795904f, 0.00868137f, -0.10766133f, -0.30099604f, 0.06044962f, 0.07753736f, -0.06031146f, 
    -0.06567886f, 0.02377158f, -0.00794363f, -0.05337236f, 0.04309219f, 0.02926433f, -0.05115148f, -0.05166924f, 
    0.34061873f, 0.68151224f, 0.20431422f, 0.04098326f, 0.05509665f, -0.02125833f, -0.07064971f, 0.11589883f, 
    0.20654124f, 0.09385577f, -0.06476112f, 0.03440531f, -0.09981781f, 0.13450043f, 0.29836899f, 0.05157173f, 
    0.03600466f, -0.07995255f, 0.14372680f, 0.05857583f, 0.09765054f, 0.08602866f, 0.08039564f, 0.08219968f, 
    -0.08762498f, -0.39936143f, -0.17237464f, -0.05333266f, -0.00293591f, -0.14799438f, -0.07199708f, 0.04065445f, 
    -0.04016160f, -0.02535778f, -0.01125035f, 0.00905800f, 0.17800471f, 0.23619112f, -0.06471854f, 0.19145954f, 
    -0.09876378f, 0.08476336f, 0.11323009f, 0.07732841f, 0.13077310f, 0.06060658f, -0.01326469f, 0.05752307f, 
    0.17958061f, 0.23909147f, 0.07239365f, -0.10915796f, 0.12301555f, -0.13453697f, -0.00465774f, -0.13696018f, 
    0.04458759f, -0.14705545f, 0.16970707f, 0.02521767f, 0.20908992f, 0.11217134f, -0.26845035f, -0.01811651f, 
    -0.00329723f, -0.10465947f, -0.03875585f, -0.08581769f, -0.01263013f, 0.00310969f, -0.01503695f, 0.20361418f, 
    0.20819797f, 0.05117286f, -0.00988518f, -0.06949663f, -0.00484671f, -0.00642806f, 0.07443053f, 0.09091494f, 
    0.12815230f, -0.10706217f, 0.04100392f, 0.02257155f, -0.07457487f, 0.07629261f, 0.21009809f, 0.10977916f, 
    0.16601487f, 0.10752042f, -0.10802440f, 0.15347667f, 0.00711274f, -0.06148858f, -0.02067710f, 0.11046720f, 
    0.08807279f, 0.35821208f, 0.23929103f, 0.19928268f, 0.13566884f, 0.04116808f, 0.18514302f, 0.24778593f, 
    -0.09720105f, 0.06268074f, -0.03174577f, 0.06567552f, -0.08896078f, -0.09342630f, -0.08428683f, 0.07715300f, 
    0.05069876f, -0.00523671f, -0.06742116f, -0.13466787f, 0.10848080f, -0.06392092f, -0.08035482f, 0.05689572f, 
    0.43239772f, -0.43562460f, 0.09505625f, -0.29655701f, 0.03433253f, -0.03350046f, -0.10206596f, 0.02920091f, 
    0.07108597f, -0.05883535f, -0.00527741f, 0.06626451f, 0.27772757f, 0.18814537f, -0.08447075f, -0.13565044f, 
    0.26078036f, -0.00571078f, -0.04253901f, 0.20516618f, -0.02700555f, -0.07549860f, -0.00456818f, -0.06738911f, 
    0.35859323f, -0.09613201f, 0.10095154f, 0.14847320f, 0.15079354f, -0.04677835f, 0.11673767f, -0.11682277f, 
    0.11632387f, -0.03584787f, -0.02417479f, -0.02181018f, -0.17516683f, 0.11565796f, -0.03763618f, -0.11940564f, 
    -0.02727010f, -0.13888864f, -0.03555071f, 0.13155821f, 0.03186988f, -0.06055310f, 0.03127778f, 0.10734352f, 
    -0.06066188f, 0.15643993f, 0.02173739f, -0.01706522f, -0.02602087f, -0.11646046f, -0.04282634f, 0.03772871f, 
    0.06406456f, -0.11546651f, -0.01427105f, 0.11422669f, 0.35750455f, 0.38837001f, 0.23657598f, 0.26543498f, 
    0.19591054f, 0.05175017f, 0.17158316f, 0.16914916f, 0.03828456f, -0.04406210f, -0.02260526f, -0.01707280f, 
    -0.33103451f, 0.17173640f, -0.18821056f, 0.16233034f, 0.17603418f, 0.05128280f, 0.10434623f, 0.11065479f, 
    -0.09318186f, -0.04638612f, 0.01194604f, 0.10024243f, -0.16184475f, 0.39593595f, -0.10961725f, -0.01860907f, 
    0.18254039f, -0.00334886f, -0.03563155f, -0.03316052f, -0.02002774f, -0.01833059f, -0.01676159f, 0.11877485f, 
    -0.18905923f, -0.21216634f, -0.04465616f, 0.07226392f, 0.03521197f, -0.16305676f, -0.06047187f, -0.23515163f, 
    -0.06615555f, -0.08887126f, -0.08906398f, 0.05521980f, 0.11540987f, 0.06286029f, -0.15299039f, -0.05047879f, 
    0.06094008f, 0.18951669f, 0.03138148f, 0.11508039f, 0.04503220f, 0.01706509f, 0.05500156f, -0.14452825f, 
    -0.21654040f, -0.00050475f, -0.00619877f, 0.01780901f, -0.03132825f, -0.03794088f, 0.14108056f, 0.09457508f, 
    0.04753208f, -0.07793406f, 0.10331699f, 0.08911537f, 0.36876470f, -0.07174425f, -0.04917437f, 0.05824053f, 
    -0.04680867f, 0.01772813f, -0.04272125f, 0.12483834f, 0.15121330f, 0.02109306f, -0.02187195f, -0.06439765f, 
    0.04621275f, 0.33485776f, -0.07111020f, 0.16855209f, 0.15077899f, -0.07677644f, 0.01301762f, 0.10528225f, 
    0.04149958f, -0.03250762f, 0.02070404f, 0.01388204f, -0.60840827f, 0.16103798f, -0.14072725f, 0.21049818f, 
    0.02917998f, 0.04378708f, -0.10005326f, -0.18133894f, 0.02454512f, -0.02810669f, -0.01894272f, -0.14445208f, 
    0.04808185f, 0.25731835f, -0.35025856f, -0.27855313f, -0.09360103f, 0.06802621f, 0.16545816f, 0.06725524f, 
    -0.06191407f, -0.00446015f, -0.12913665f, 0.06434675f, 0.00189383f, -0.17133476f, -0.18525313f, -0.12388897f, 
    0.06795283f, -0.07936487f, 0.02110562f, -0.08345849f, 0.13418390f, -0.05408633f, -0.03398525f, -0.05426482f, 
    0.04398279f, -0.15065193f, -0.09727880f, 0.07099111f, -0.06380495f, -0.06776147f, -0.03932140f, -0.02476692f, 
    0.04408844f, 0.07197125f, -0.06303895f, -0.06873939f, -0.02785015f, -0.34387276f, 0.11894232f, -0.15933342f, 
    0.05562764f, -0.03110010f, -0.04715282f, -0.11339764f, 0.01023570f, 0.04763780f, 0.07747490f, -0.01503810f, 
    -0.19281249f, 0.22521749f, 0.15916485f, 0.25903991f, -0.02519718f, 0.11091373f, 0.05643512f, 0.19594812f, 
    -0.04129155f, -0.22021861f, -0.13954134f, -0.16223359f, -0.10350262f, 0.10014732f, -0.14604375f, -0.04823880f, 
    0.10862943f, 0.02433043f, 0.10185529f, 0.02967267f, 0.16893542f, 0.13538067f, -0.04014977f, 0.05499258f, 
    0.40017810f, 0.02238724f, -0.16374928f, -0.13360474f, -0.04091539f, 0.05272418f, -0.01407466f, 0.04626094f, 
    0.03602012f, -0.07464948f, -0.01297231f, 0.02027631f, 0.01486999f, -0.01847493f, -0.10435099f, -0.14488569f, 
    -0.00039785f, -0.08128955f, -0.12424478f, -0.13022883f, 0.02589872f, -0.04388325f, -0.06048714f, 0.04406663f, 
    -0.04261910f, 0.01536941f, 0.24335539f, 0.38249066f, -0.00329631f, 0.15627241f, -0.01826661f, 0.03393062f, 
    -0.05059422f, -0.03340595f, 0.01460804f, -0.00405962f, 0.26502544f, -0.10182037f, 0.06539439f, -0.15877461f, 
    0.03303513f, 0.01884995f, -0.16798860f, 0.01540639f, -0.07221174f, -0.00752678f, -0.06164381f, 0.02306775f, 
    -0.14892073f, 0.10042252f, -0.17142074f, 0.10668118f, 0.02134849f, -0.00813615f, -0.06833754f, -0.00812564f, 
    -0.00134929f, 0.01686282f, 0.09370698f, 0.18667433f, -0.02940852f, -0.40071005f, 0.28546953f, 0.09680171f, 
    -0.03188690f, 0.02865069f, -0.17833598f, -0.18875244f, -0.00137343f, -0.03782513f, -0.07959358f, 0.14020172f, 
    0.03164087f, 0.19508074f, -0.01741619f, 0.26041678f, 0.11448959f, 0.21694531f, -0.03506624f, 0.16250382f, 
    0.15356521f, -0.01543752f, 0.05365633f, -0.01178466f, -0.17807724f, -0.12785088f, -0.11130177f, -0.04934671f, 
    -0.16681300f, 0.00657026f, -0.07398394f, 0.07232456f, 0.01298716f, -0.07928945f, -0.10967299f, 0.13646391f, 
    -0.00965271f, 0.00601131f, -0.22259514f, -0.11958908f, 0.14732648f, 0.04934373f, 0.06541318f, -0.06779463f, 
    0.13556761f, 0.07795997f, 0.14217921f, -0.02729723f, -0.01412481f, 0.06719230f, 0.15148851f, -0.04922559f, 
    0.08462400f, 0.18349187f, -0.05075596f, 0.04546075f, 0.08216323f, 0.06695086f, 0.09090788f, 0.01851825f, 
    0.02647138f, 0.12281010f, 0.07574292f, 0.07828522f, 0.04665015f, 0.18180715f, 0.03158410f, 0.04751907f, 
    0.05474211f, -0.04704436f, -0.23909561f, -0.07155153f, 0.15580656f, 0.15806989f, 0.32725048f, 0.18432637f, 
    0.07817224f, 0.09254443f, 0.06737091f, 0.12089650f, 0.03706296f, 0.01243169f, 0.01748335f, -0.04802455f, 
    0.39950812f, -0.08311196f, 0.16157918f, -0.09394133f, 0.00984139f, -0.01863119f, -0.08798654f, 0.09692498f, 
    -0.05339383f, -0.12241936f, 0.03358888f, -0.02032285f, -0.10215458f, -0.00175601f, -0.12489808f, 0.08475745f, 
    -0.02366982f, -0.03266853f, -0.05787486f, 0.03306258f, -0.11339618f, 0.04150443f, -0.03980584f, 0.04322395f, 
    -0.07504634f, 0.01992748f, 0.16930929f, 0.04443846f, 0.10952780f, -0.07027107f, -0.27563694f, -0.03810034f, 
    0.01702063f, 0.00489925f, -0.07856660f, 0.03525326f, 0.08338337f, 0.32643136f, 0.29403475f, 0.25644532f, 
    0.17008898f, -0.03950568f, -0.14552201f, 0.10338539f, -0.03320055f, -0.06957848f, 0.05386800f, 0.09403986f, 
    0.11468713f, -0.02766307f, -0.22303616f, -0.08493056f, -0.00560764f, -0.02846519f, -0.02758428f, -0.00920383f, 
    0.07790886f, -0.09592719f, -0.11536652f, -0.10752602f, 0.11541239f, 0.06343012f, -0.02571910f, 0.03893857f, 
    -0.00547780f, -0.00650172f, 0.10854917f, 0.00487552f, 0.00437390f, -0.07588285f, 0.17734018f, 0.11459483f, 
    0.08805270f, -0.00937335f, 0.03462159f, -0.18430099f, -0.10724825f, -0.00613384f, 0.05845176f, -0.06247450f, 
    -0.03765314f, 0.03810083f, -0.02758915f, 0.06101412f, 0.34390268f, -0.41904634f, 0.45808151f, -0.19118068f, 
    0.02732282f, 0.02076792f, 0.15743901f, 0.16265135f, -0.04178711f, -0.10593432f, -0.04019477f, -0.14627530f, 
    -0.00051196f, 0.23283812f, -0.25126544f, 0.02950705f, -0.02507295f, 0.05038993f, 0.03052071f, 0.00798079f, 
    0.03334419f, 0.00597490f, -0.05032187f, 0.02230649f, 0.17740183f, -0.20023455f, -0.11888077f, -0.00220931f, 
    0.03278720f, 0.00810747f, 0.03121508f, -0.12000173f, 0.00772338f, 0.07420924f, -0.02460028f, 0.01014923f, 
    0.28498533f, -0.19184192f, 0.08500845f, 0.14240834f, 0.04691477f, -0.02160755f, 0.08146593f, -0.12360276f, 
    -0.03946768f, -0.09150159f, -0.04462282f, -0.07103341f, -0.16525626f, -0.31273991f, 0.28018951f, -0.21661393f, 
    -0.03588221f, 0.02675705f, -0.07247063f, -0.26382765f, 0.00524288f, -0.06253792f, 0.06585169f, -0.06095225f, 
    0.06052672f, 0.15084621f, 0.30370918f, 0.16474341f, -0.04858295f, 0.04336095f, 0.11892094f, 0.34772679f, 
    0.04824438f, -0.02494281f, 0.08634536f, 0.11954665f, 0.20171422f, 0.00433594f, 0.36597112f, 0.18535490f, 
    0.05838709f, 0.15312457f, 0.14196809f, 0.13484202f, 0.08147258f, -0.08882128f, -0.01350976f, -0.02935557f, 
    -0.04194112f, -0.38819230f, 0.55764294f, -0.38681725f, -0.02572772f, 0.01176153f, 0.01937491f, 0.35368401f, 
    0.03470426f, 0.02770858f, 0.02376263f, -0.10341688f, -0.02321503f, -0.03577532f, 0.15419935f, 0.23540120f, 
    0.03099660f, -0.00285190f, -0.13944477f, 0.05681757f, 0.11827929f, 0.03321095f, 0.00069311f, -0.08581688f, 
    0.42897704f, -0.43265611f, 0.08812921f, -0.43917808f, -0.01601619f, -0.01670421f, -0.13693130f, -0.05316997f, 
    -0.05117295f, 0.02146085f, 0.05062697f, -0.16538627f, 0.16155691f, -0.16827823f, -0.01924592f, 0.00082419f, 
    0.09956004f, 0.02550303f, 0.03406575f, 0.00760519f, 0.25762641f, -0.00798826f, 0.10489230f, 0.03904746f, 
    0.16801836f, -0.04623683f, -0.04839421f, -0.15347292f, 0.07246613f, -0.02901726f, -0.03330461f, 0.11210247f, 
    0.16398525f, -0.09029341f, -0.04580566f, -0.01858059f, -0.03740951f, -0.03690670f, -0.03092734f, 0.11401226f, 
    0.04833184f, 0.02692524f, 0.10008521f, -0.07315483f, -0.07038704f, -0.05316775f, -0.15585926f, -0.15177457f, 
    -0.05989687f, 0.01132477f, 0.09710061f, 0.16832620f, 0.11722077f, -0.01857537f, -0.03611500f, -0.06179956f, 
    0.12113076f, -0.15286671f, -0.04403582f, -0.03040503f, -0.00659460f, 0.24597630f, 0.38390017f, 0.18662165f, 
    0.00652324f, 0.04619414f, 0.10910635f, 0.25630981f, -0.02406230f, -0.01328579f, -0.00369376f, -0.05180171f, 
    -0.00057510f, -0.47121185f, -0.12139519f, -0.43274996f, 0.05722399f, -0.09773242f, 0.07592057f, -0.06368253f, 
    0.07017908f, 0.02127884f, 0.06518963f, -0.04817047f, -0.08217154f, 0.22847858f, 0.04292243f, -0.12453605f, 
    0.07686596f, -0.03783352f, -0.00911922f, 0.05937836f, 0.06332180f, -0.06751567f, 0.04554317f, 0.09716841f, 
    0.24687776f, 0.07777210f, 0.00484963f, 0.10269261f, 0.11553166f, -0.05353663f, -0.05108083f, -0.05492132f, 
    0.03737685f, -0.14837076f, -0.09556482f, -0.11628783f, -0.13571194f, -0.01969465f, 0.38112468f, 0.11911657f, 
    -0.09099655f, 0.10907756f, -0.00593268f, 0.12381637f, 0.14594327f, 0.00438451f, 0.13859227f, 0.08079829f, 
    -0.49727044f, 0.24237742f, -0.19314726f, 0.41642216f, -0.00395841f, 0.09875882f, -0.11409730f, -0.03457466f, 
    -0.11749117f, -0.03625578f, -0.01912611f, 0.06117802f, -0.18477972f, 0.28096378f, -0.31263575f, 0.20994742f, 
    0.05533080f, -0.02818304f, 0.09243220f, -0.06430513f, -0.01262840f, 0.01034002f, -0.01800900f, 0.23810080f, 
    0.02223913f, -0.04831273f, -0.00609391f, -0.04872320f, -0.02692986f, -0.04289380f, -0.04353141f, -0.04005896f, 
    0.01708361f, -0.04511619f, -0.01559159f, 0.02134578f, -0.00120007f, 0.02087195f, -0.04310247f, -0.00657990f, 
    0.00057183f, -0.00647474f, -0.01470495f, -0.02092608f, -0.02201567f, -0.01235880f, 0.00434121f, 0.01723012f, 
    0.01575340f, 0.02423053f, 0.02660858f, -0.00165698f, -0.02751750f, 0.01475070f, 0.00955241f, -0.01833609f, 
    0.00547795f, 0.02116499f, -0.01556650f, -0.04145641f, -0.02688902f, -0.00354225f, 0.01597931f, 0.01343436f, 
    0.02180313f, -0.01154272f, -0.00019477f, -0.01547584f, 0.00519559f, -0.00537782f, -0.01388724f, 0.01175510f, 
    -0.00741637f, -0.01050654f, -0.04423054f, 0.00320483f, 0.00651306f, 0.01282541f, 0.01284982f, -0.02246962f, 
    -0.03727595f, -0.03743044f, -0.01583538f, -0.02946698f, 0.01066184f, -0.00493116f, 0.01488087f, -0.00828265f, 
    0.00412406f, -0.03781642f, 0.01464545f, 0.01599663f, -0.03665301f, -0.02983961f, -0.01749079f, -0.00274223f, 
    -0.03879871f, -0.01318608f, -0.00430538f, 0.01797368f, -0.01275751f, -0.00217875f, -0.00720703f, 0.00811675f, 
    0.00696594f, -0.01344901f, -0.02496092f, -0.02726781f, -0.02572097f, -0.04172469f, -0.00148248f, 0.00409317f, 
    -0.01612956f, 0.00806821f, 0.01242880f, -0.00698483f, -0.00856123f, -0.02861426f, -0.00880764f, -0.03442719f, 
    -0.02090815f, 0.01647679f, -0.02156838f, -0.00665266f, -0.00448360f, -0.01499893f, 0.02014119f, 0.02318802f, 
    0.02494195f, 0.01381288f, -0.03741882f, -0.03102919f, -0.02686876f, 0.01270175f, -0.00807746f, 0.01655303f, 
    0.01832607f, 0.00443501f, -0.02984896f, 0.02175673f, -0.02218908f, 0.00006762f, -0.03860997f, 0.00882820f, 
    -0.02654597f, -0.00740916f, -0.01506539f, -0.00647637f, 0.01511909f, -0.02333979f, -0.00512824f, -0.04804399f, 
    -0.03642055f, -0.02382912f, 0.02449285f, -0.03038552f, 0.02896624f, -0.01792086f, 0.01192158f, 0.02966996f, 
    0.01802063f, -0.02347488f, -0.02672620f, -0.01333407f, 0.00707640f, -0.00931529f, 0.01957893f, -0.01521941f, 
    0.00688254f, 0.01443090f, -0.02914330f, 0.01498505f, -0.03529536f, -0.00911992f, -0.03036294f, -0.02405476f, 
    -0.01340573f, 0.02945560f, -0.01156634f, -0.02029501f, -0.03898384f, 0.00274745f, 0.02779055f, -0.03082117f, 
    -0.02451753f, -0.02911616f, -0.00868722f, 0.01546876f, -0.02991486f, 0.01144050f, 0.02196131f, -0.00630949f, 
    -0.00114770f, -0.01372373f, -0.02834818f, -0.01685485f, -0.02137985f, 0.00982132f, -0.01261347f, 0.02069060f, 
    0.00887677f, 0.00009780f, -0.02077700f, 0.01731220f, -0.03557507f, -0.00417100f, 0.02290085f, 0.02539996f, 
    -0.00308330f, 0.01077177f, 0.01126792f, 0.00970143f, 0.02122781f, -0.01487113f, -0.02089588f, -0.00429632f, 
    0.01941828f, 0.00037683f, -0.02967547f, 0.01290748f, 0.01279459f, -0.03001512f, 0.00995554f, 0.00634771f, 
    -0.00511366f, 0.01530884f, 0.01905513f, -0.01468499f, -0.01869585f, 0.00210396f, -0.02528289f, 0.01929410f, 
    0.02276398f, -0.00902794f, 0.01377267f, -0.03497840f, 0.00472114f, -0.03664861f, 0.02704044f, 0.00114150f, 
    0.01406457f, 0.01271908f, -0.00512913f, -0.01297455f, -0.02299276f, 0.01989052f, -0.02617985f, -0.00351773f, 
    -0.03751223f, 0.01503137f, 0.00974444f, 0.02227888f, 0.01860972f, -0.02119799f, -0.03456051f, 0.02317831f, 
    -0.03483357f, 0.01078669f, 0.02682025f, -0.02768634f, 0.01883646f, 0.00676707f, -0.01884767f, 0.02554405f, 
    -0.00068839f, -0.04061295f, 0.01962570f, 0.01845036f, -0.01406937f, -0.02367429f, -0.03025705f, -0.02711139f, 
    0.01404920f, -0.01598356f, -0.01546719f, 0.00388882f, -0.02594299f, 0.00115504f, -0.00823899f, -0.01045548f, 
    -0.02484411f, -0.01891205f, -0.00844975f, -0.02349967f, -0.03560071f, 0.01238034f, -0.01778007f, -0.02480576f, 
    0.00099449f, 0.00621538f, 0.00142357f, -0.02034499f, -0.01291031f, 0.00090985f, -0.00600261f, -0.00074423f, 
    -0.03972155f, -0.00809801f, 0.00720333f, -0.00766103f, 0.01967075f, -0.01761039f, -0.03682677f, 0.01336778f, 
    0.02569316f, 0.02909052f, 0.01377303f, -0.01855569f, -0.02157046f, 0.01860509f, 0.02195308f, 0.00308838f, 
    -0.01549802f, -0.03132169f, -0.00148493f, 0.01072050f, -0.02707785f, 0.01296348f, -0.03261011f, 0.00492146f, 
    0.02109399f, -0.04621950f, -0.01283890f, -0.01683136f, 0.01105445f, -0.00530317f, -0.00007798f, -0.00076189f, 
    -0.00229492f, 0.01155506f, -0.00899464f, 0.01038699f, -0.00686609f, -0.02409952f, 0.01188804f, -0.00260074f, 
    -0.04035264f, -0.01572297f, -0.02376813f, 0.01480565f, -0.00531017f, -0.04400084f, 0.01119868f, -0.02287969f, 
    0.02408333f, -0.00853127f, -0.03122571f, -0.03005543f, 0.00554876f, -0.01199195f, -0.02553199f, -0.01281193f, 
    0.00686962f, -0.03650038f, -0.01748536f, -0.04059954f, -0.00158742f, -0.00247876f, -0.02227030f, -0.02971377f, 
    -0.03993551f, -0.03366948f, -0.03038595f, -0.01692606f, -0.00822389f, -0.02124338f, 0.00451644f, -0.04159654f, 
    -0.02458280f, -0.01751971f, -0.02180776f, 0.00816907f, -0.01277490f, 0.03560483f, 0.02658544f, 0.01605141f, 
    -0.02893458f, -0.03256584f, -0.04162056f, 0.01694007f, 0.02045910f, -0.01574972f, 0.00131462f, -0.02474299f, 
    -0.01640182f, -0.02569323f, -0.03501658f, 0.02726547f, 0.00466707f, -0.00732912f, 0.01834315f, -0.02038830f, 
    -0.00056636f, -0.01041826f, 0.01648320f, 0.01515821f, 0.01418990f, -0.03042983f, -0.02488079f, -0.02536573f, 
    -0.03627401f, 0.02398782f, -0.03278476f, -0.03001003f, 0.00223366f, -0.02419331f, 0.01222316f, -0.04018309f, 
    0.02185176f, -0.01672567f, -0.00926199f, -0.00741540f, -0.00692269f, -0.01537974f, 0.01477089f, 0.01046100f, 
    0.00437412f, -0.00038142f, 0.02120372f, 0.01933397f, -0.03175717f, 0.00807682f, 0.02312956f, 0.01878279f, 
    0.00669501f, 0.01012907f, -0.00797367f, 0.02422067f, -0.03106897f, -0.02154171f, -0.02201551f, -0.00058626f, 
    -0.04331056f, 0.01543766f, 0.03173712f, 0.01748873f, -0.01356651f, -0.01144567f, -0.01245790f, 0.00274267f, 
    -0.00912225f, -0.03819890f, -0.03246667f, 0.00064819f, -0.00139789f, -0.01294458f, -0.02371353f, 0.03606644f, 
    0.00576655f, -0.01154764f, -0.01381020f, 0.00833787f, -0.00342807f, -0.00215821f, -0.03979336f, -0.01001857f, 
    -0.05230552f, -0.00717798f, -0.01838143f, 0.00648624f, -0.00572067f, -0.01192433f, 0.00448135f, -0.01222680f, 
    -0.04029427f, 0.00052365f, 0.01490612f, 0.03086144f, 0.01180799f, -0.02659941f, 0.00139833f, 0.00419809f, 
    -0.01359379f, 0.00605304f, -0.01090036f, -0.01650937f, -0.03374989f, 0.02389913f, -0.02207292f, -0.02124170f, 
    -0.00121049f, -0.00823377f, -0.01987359f, 0.01789537f, 0.00812729f, 0.00614235f, 0.01899839f, 0.01529432f, 
    0.02877682f, 0.01406507f, 0.01505899f, 0.00016530f, -0.02945792f, -0.00394234f, 0.02751652f, -0.00303356f, 
    -0.00980211f, 0.01829883f, 0.01470796f, 0.02081772f, -0.00794455f, -0.01178299f, -0.04027233f, 0.00575584f, 
    -0.01100583f, 0.00632425f, -0.01297605f, -0.01722790f, -0.00285167f, 0.00230387f, 0.01827883f, 0.00990882f, 
    -0.00252109f, 0.00047801f, -0.02292097f, -0.02206959f, -0.00053459f, -0.03669101f, 0.01962144f, -0.03209402f, 
    0.01452017f, 0.01929702f, -0.02905621f, 0.02604425f, -0.03987671f, -0.02840637f, 0.01025897f, 0.02160388f, 
    -0.00878916f, 0.00783881f, 0.02823990f, -0.03314408f, 0.03001419f, -0.03087802f, -0.04453833f, -0.01964652f, 
    0.01749881f, -0.00046886f, -0.03723570f, -0.03143060f, 0.00365530f, 0.03148200f, 0.01154139f, -0.00242144f, 
    -0.01925169f, -0.03151662f, 0.02341688f, -0.02646587f, 0.01202380f, -0.03739518f, -0.00013514f, -0.03785680f, 
    0.01800293f, -0.00225055f, -0.03753222f, -0.01057257f, -0.02983243f, 0.00815486f, 0.00734937f, 0.02564417f, 
    -0.01964932f, 0.02713352f, -0.01711608f, -0.03691681f, -0.02312035f, 0.02280932f, -0.00221493f, -0.01031205f, 
    0.02740307f, 0.00041032f, 0.00919514f, -0.03549898f, 0.01827170f, -0.03640499f, -0.02348431f, -0.02900471f, 
    -0.00085912f, 0.02044411f, 0.00173074f, -0.00856670f, -0.00763925f, -0.02731129f, -0.04729459f, -0.03819376f, 
    -0.02841452f, 0.00407955f, 0.02193465f, -0.00145938f, -0.01316071f, -0.02955054f, -0.00526409f, -0.04546344f, 
    -0.00680580f, 0.01497872f, -0.02208114f, 0.00885178f, -0.00276045f, 0.02760844f, -0.01089388f, 0.01294778f, 
    -0.04403222f, -0.03887083f, -0.03450335f, 0.02278540f, -0.00739987f, 0.01552220f, -0.02458193f, 0.02027580f, 
    -0.01398933f, 0.01563580f, -0.04066434f, 0.01781310f, -0.00326760f, 0.01613787f, -0.00675038f, 0.01920285f, 
    -0.01695396f, -0.00271908f, -0.02012901f, -0.03571269f, 0.00672167f, -0.00857482f, -0.02614126f, -0.00626138f, 
    -0.04709476f, 0.00394463f, 0.00276462f, -0.00222679f, -0.02530594f, 0.01160632f, 0.00303053f, -0.04237859f, 
    -0.02625779f, -0.02565012f, -0.02925123f, 0.01201374f, 0.01169116f, 0.00498582f, 0.01654424f, 0.00405401f, 
    -0.04556768f, -0.02562566f, -0.02432781f, 0.02481933f, -0.03234562f, -0.01903350f, -0.00480291f, 0.01514875f, 
    0.00619016f, -0.02515077f, -0.00076499f, -0.03011597f, -0.01732587f, 0.00653203f, 0.02653317f, -0.02088100f, 
    0.00992406f, -0.00857242f, -0.04123611f, 0.01809763f, -0.01660186f, 0.00138908f, -0.00719685f, -0.02617709f, 
    -0.03460329f, -0.02817847f, -0.02390005f, -0.04131693f, 0.01066567f, -0.02895652f, -0.01602700f, -0.00561663f, 
    -0.04094129f, -0.02971314f, -0.02811224f, -0.00942849f, -0.04182762f, -0.03743814f, -0.04850753f, 0.01393091f, 
    -0.04353511f, -0.02820324f, -0.02181380f, -0.02068225f, -0.01443881f, 0.01793695f, 0.01387900f, -0.01854130f, 
    0.00654942f, 0.01716552f, -0.00998188f, 0.00397144f, 0.00436757f, 0.02977521f, 0.01503205f, 0.02291095f, 
    0.00258208f, 0.02385707f, -0.02955796f, -0.03039573f, 0.01859414f, -0.04170942f, 0.00659432f, 0.02921888f, 
    -0.01209707f, 0.01194321f, -0.00272488f, -0.00022671f, -0.01452887f, -0.01657986f, -0.03477473f, 0.00910393f, 
    -0.02516732f, -0.01844088f, -0.04959853f, -0.02454595f, -0.01731531f, 0.01644683f, 0.01969579f, 0.01279669f, 
    0.01308056f, 0.02028809f, -0.03695769f, -0.01981493f, -0.01250944f, 0.00371046f, -0.00169670f, -0.00542655f, 
    0.02040201f, -0.01680393f, -0.00841404f, -0.00312782f, 0.02467552f, 0.00981187f, 0.01666938f, -0.00503826f, 
    0.00499997f, -0.01575130f, -0.00327523f, -0.03975044f, -0.02256021f, 0.00922635f, 0.02545253f, -0.00861924f, 
    0.01420226f, 0.01096045f, 0.02024809f, -0.00121792f, 0.01422230f, -0.01305958f, -0.04120248f, -0.01445486f, 
    -0.02328940f, -0.00757048f, 0.03328751f, 0.02905761f, 0.02198956f, -0.02164621f, -0.02656948f, 0.02602627f, 
    0.00687395f, -0.00870302f, -0.03601049f, 0.01244736f, -0.00160131f, -0.00320543f, -0.01833079f, 0.00820681f, 
    0.02461357f, 0.02370555f, 0.01428921f, 0.00270898f, -0.00896460f, -0.02252859f, 0.03161234f, -0.03261920f, 
    -0.02903672f, 0.00705282f, 0.01608536f, -0.01168816f, -0.04069019f, -0.02261323f, -0.03456737f, -0.02512923f, 
    -0.03854340f, -0.00566933f, -0.02086126f, 0.01150542f, -0.03928995f, -0.02041578f, 0.02530200f, -0.02401618f, 
    0.45563957f, -0.09000980f, 0.08140279f, -0.23859173f, -0.08617156f, 0.00484253f, 0.02449822f, 0.11994286f, 
    0.06967160f, 0.12324390f, 0.13594271f, 0.15420029f, -0.45999488f, -0.35327858f, -0.22218932f, -0.13720152f, 
    0.19398844f, 0.18208957f, 0.01930342f, -0.09528714f, 0.04864599f, -0.00822749f, -0.03027122f, -0.13469344f, 
    0.30438259f, -0.06945892f, -0.21499906f, 0.02567933f, 0.17280738f, 0.07371400f, 0.15314765f, 0.17176951f, 
    -0.05134065f, -0.00235974f, -0.14421175f, 0.01798886f, -0.03643046f, 0.08470774f, 0.07098708f, -0.22584367f, 
    -0.05929163f, -0.04727320f, -0.00837020f, 0.09995346f, -0.01883042f, -0.03117370f, -0.04457847f, 0.13755330f, 
    0.31804180f, -0.25887561f, 0.10131407f, -0.08824638f, -0.12101920f, -0.06380673f, -0.18347722f, 0.12493316f, 
    -0.01338738f, 0.11941535f, 0.08972049f, -0.28443775f, 0.08356571f, -0.12117050f, -0.10167879f, -0.10996895f, 
    -0.03653412f, -0.07065574f, 0.02066720f, -0.08412333f, 0.09731723f, 0.02559841f, -0.02531700f, 0.08313110f, 
    -0.01835102f, -0.10771371f, 0.27117357f, -0.02457192f, -0.09608771f, -0.06767301f, -0.20165049f, 0.00495690f, 
    -0.17224668f, -0.14753880f, 0.26296577f, -0.05983112f, -0.25427619f, -0.23422401f, -0.38005948f, -0.26812795f, 
    0.17944562f, -0.01990771f, -0.01679452f, 0.04679008f, -0.01815494f, -0.04222807f, -0.07452348f, -0.15802997f, 
    -0.19013870f, -0.45092958f, -0.09334013f, -0.27423933f, -0.05420079f, -0.03147922f, -0.13326252f, -0.05123335f, 
    -0.05725326f, -0.03489818f, -0.00493378f, -0.06758055f, -0.22006927f, 0.06618029f, -0.15299325f, -0.32072958f, 
    0.13823020f, -0.04658214f, -0.03525376f, -0.01521500f, -0.07441349f, -0.08192379f, 0.02256609f, 0.01839807f, 
    -0.93550414f, -0.24904867f, -0.05252698f, -0.14923765f, 0.08032453f, -0.09056022f, 0.04727323f, -0.26111796f, 
    0.13002698f, 0.06976788f, -0.15625627f, -0.11863517f, -0.22428127f, 0.05926661f, -0.16788854f, -0.30528191f, 
    0.06409957f, 0.00211661f, -0.15062803f, -0.16553859f, -0.01420790f, -0.07218035f, -0.01300017f, 0.06345224f, 
    -0.12370021f, -0.03256606f, 0.08186475f, 0.13941076f, -0.15538588f, 0.14599960f, -0.06971877f, 0.16900042f, 
    0.34552225f, -0.04628115f, 0.21702354f, -0.09342705f, -0.14212498f, -0.07982527f, -0.11655656f, -0.08116486f, 
    -0.08863740f, 0.10262045f, 0.09285337f, 0.23294130f, -0.01736811f, -0.02531408f, 0.08371510f, 0.00971613f, 
    0.05700105f, -0.15584496f, -0.06225911f, -0.05154226f, -0.01311580f, 0.09236056f, 0.02746946f, -0.27029559f, 
    0.22553883f, 0.05748216f, 0.13134490f, -0.10311814f, -0.21152428f, -0.17905748f, -0.05602728f, -0.10990644f, 
    0.07812376f, 0.03380674f, -0.04765703f, -0.12903056f, -0.13250154f, -0.17294163f, 0.05620510f, 0.08146407f, 
    -0.02415691f, 0.06017996f, -0.00549268f, -0.14823809f, -0.10681649f, -0.02735987f, 0.15486419f, 0.02002370f, 
    0.02319328f, -0.06318107f, -0.02075898f, 0.10775322f, -0.08996059f, 0.21149187f, 0.14030832f, 0.12733071f, 
    -0.12228263f, 0.10153325f, 0.02207430f, 0.04973816f, -0.00919989f, -0.13153535f, -0.06599539f, 0.00554040f, 
    0.20593545f, 0.05398503f, -0.09277800f, -0.07757706f, 0.02389265f, -0.02542712f, 0.36369315f, 0.09276819f, 
    0.21957694f, 0.28619075f, -0.05423040f, -0.10076900f, 0.22083408f, 0.08759173f, 0.08181494f, 0.11533702f, 
    0.03898530f, 0.05740101f, 0.04562934f, 0.04776753f, 0.04474207f, -0.02082680f, -0.01596179f, -0.02919617f, 
    0.19278798f, 0.05481584f, -0.09425979f, -0.01571069f, -0.06435634f, 0.08777883f, 0.09824412f, 0.04436124f, 
    0.05309545f, 0.00457319f, 0.09123933f, -0.11620370f, 0.22493607f, 0.05465104f, -0.14905736f, -0.26350936f, 
    -0.05566709f, -0.13537621f, 0.05287797f, 0.19255339f, 0.16775051f, -0.09014293f, 0.03953588f, 0.04271769f, 
    0.24572086f, 0.22768083f, 0.07556064f, 0.10631098f, 0.00318603f, -0.00109224f, 0.24271144f, 0.31949946f, 
    -0.02784096f, -0.07505754f, 0.00370507f, -0.03692032f, 0.09443525f, -0.01482804f, 0.03833791f, -0.00091279f, 
    0.18116505f, 0.02493482f, 0.03401260f, -0.09439141f, 0.09323248f, 0.00237119f, 0.00575999f, 0.07581491f, 
    0.11507380f, -0.08484004f, -0.04195694f, -0.21146822f, -0.14971136f, -0.05729816f, -0.19383755f, 0.16845782f, 
    -0.08197740f, -0.06501698f, 0.10062525f, 0.08445850f, 0.14729969f, 0.12377734f, 0.01228475f, 0.05347765f, 
    0.01836028f, -0.02208380f, 0.00972342f, -0.07050871f, 0.01409523f, 0.06093584f, -0.02701397f, 0.09312069f, 
    -0.06781906f, 0.11738279f, 0.06794620f, -0.18754022f, 0.16026329f, -0.06851719f, 0.13459095f, -0.11226644f, 
    0.05803703f, -0.03486217f, -0.08436354f, -0.04605967f, 0.43533912f, 0.23502667f, 0.03604579f, 0.14378929f, 
    0.03065612f, 0.06329603f, 0.02447806f, -0.11048807f, 0.34666947f, 0.06623170f, 0.12588480f, 0.05253118f, 
    -0.11067106f, 0.12567161f, 0.05897057f, 0.11259423f, -0.02917738f, -0.04391567f, -0.01412773f, 0.09603767f, 
    0.02240732f, 0.08577476f, 0.39045009f, 0.22025065f, -0.24629143f, -0.18442804f, 0.16902272f, 0.04264868f, 
    -0.11854877f, 0.06585089f, 0.05037109f, -0.00552690f, 0.10916933f, -0.10491420f, 0.02026060f, 0.14834785f, 
    -0.42110154f, 0.12994714f, -0.15382700f, -0.36559355f, 0.00342254f, -0.13903981f, 0.00644307f, -0.01300745f, 
    -0.01913725f, 0.01219320f, 0.07235315f, -0.08057538f, 0.19260140f, -0.16117240f, -0.16788837f, -0.04291939f, 
    -0.13308291f, 0.07241712f, -0.14946081f, 0.03104251f, 0.05592066f, -0.07410015f, -0.22018835f, -0.07061564f, 
    -0.17304094f, -0.39206991f, -0.18929562f, -0.09246811f, -0.16229971f, -0.29509285f, 0.15701465f, 0.28608525f, 
    -0.13098273f, 0.03142082f, 0.08128357f, -0.13540357f, -0.16116223f, -0.03705698f, -0.00144579f, -0.22781251f, 
    -0.13351370f, 0.07766159f, -0.13881584f, -0.10069435f, 0.29962739f, -0.06148539f, -0.06937609f, 0.11341723f, 
    -0.02858700f, -0.01500073f, 0.20344789f, 0.26786152f, 0.06872348f, 0.16651544f, 0.02401824f, 0.09220687f, 
    0.00739967f, -0.05130424f, -0.04545753f, -0.01492994f, -0.02405970f, -0.23980510f, -0.22070873f, -0.13290502f, 
    -0.01534802f, -0.19869752f, -0.10728654f, -0.08199871f, 0.00120597f, 0.00803368f, -0.05713309f, -0.01012957f, 
    0.36858350f, -0.01700087f, 0.18980730f, 0.08976910f, -0.02720913f, 0.02187456f, -0.07936539f, 0.12838268f, 
    0.04249394f, -0.12218518f, 0.00814259f, -0.07737257f, 0.07061171f, -0.01240502f, 0.11165130f, 0.08815994f, 
    -0.02724315f, 0.17397115f, -0.05084558f, 0.23339333f, 0.06813478f, 0.05569283f, 0.15001619f, 0.23379473f, 
    -0.28300464f, -0.28565595f, -0.02832450f, 0.04058588f, -0.03999915f, -0.15657118f, 0.00073954f, 0.09824921f, 
    0.00770930f, 0.01687142f, 0.02248842f, 0.08363122f, -0.15944010f, 0.00575850f, -0.13067776f, -0.10045703f, 
    -0.02532595f, -0.30681580f, -0.09440245f, -0.16753939f, -0.01380424f, 0.01259105f, -0.00531641f, 0.00739818f, 
    0.55872577f, 0.24732515f, 0.11023411f, 0.16841981f, -0.01960635f, -0.05672308f, 0.00962598f, -0.00125657f, 
    0.05274637f, 0.04880546f, -0.01584190f, -0.02007258f, 0.15001296f, 0.02994100f, 0.11398386f, 0.05046040f, 
    -0.03422872f, 0.03141763f, 0.08576102f, 0.06270664f, 0.16385299f, 0.10544569f, 0.26580352f, 0.35972729f, 
    -0.05999942f, -0.31407538f, -0.21292898f, -0.27319106f, 0.13342173f, -0.18690263f, 0.11284909f, -0.00717770f, 
    -0.00281957f, 0.06184337f, -0.10114351f, -0.22458912f, 0.31906325f, -0.11072550f, 0.14879720f, 0.34756851f, 
    -0.02047645f, 0.06704604f, -0.01123461f, 0.06052423f, -0.04222350f, -0.03545145f, -0.02822006f, 0.07223014f, 
    0.23237018f, 0.18484457f, -0.03339149f, -0.08612696f, -0.07109562f, 0.17871185f, 0.12711768f, 0.13166074f, 
    0.05098773f, -0.02694026f, -0.02331410f, -0.04588497f, 0.12900749f, 0.17076755f, 0.06689624f, 0.09750722f, 
    0.00469829f, 0.00396706f, 0.13512315f, -0.04947855f, 0.30846134f, 0.02800627f, -0.02346124f, 0.23219660f, 
    0.26981202f, 0.28965408f, 0.24160142f, 0.04010634f, -0.00081922f, -0.04787391f, 0.07005981f, 0.02529909f, 
    0.03673469f, 0.25375170f, 0.23361315f, -0.00273905f, 0.04253039f, -0.07450803f, -0.03301709f, -0.22479247f, 
    -0.04795038f, 0.03982259f, 0.08265526f, -0.03246095f, 0.06943642f, 0.09861687f, -0.04544887f, -0.06871528f, 
    0.16521150f, -0.13706778f, -0.17308089f, 0.04786436f, 0.06417044f, 0.04699903f, 0.18195851f, 0.17476360f, 
    0.00784153f, 0.05074341f, 0.16188265f, 0.06153928f, -0.14877377f, 0.04576404f, -0.04368922f, -0.11930116f, 
    0.07578526f, -0.07771327f, -0.09971283f, 0.00940249f, -0.03438523f, -0.08071533f, 0.05164167f, -0.04697552f, 
    -0.03435657f, -0.72037506f, 0.02740824f, 0.08385118f, 0.00928261f, 0.15706246f, -0.22795863f, 0.10699072f, 
    0.00198008f, 0.07706929f, 0.05416702f, -0.01023501f, -0.03772489f, 0.08026239f, 0.22360449f, 0.30733639f, 
    0.05419522f, 0.06659609f, -0.05354662f, -0.07681315f, 0.40230161f, 0.09583431f, 0.03475421f, 0.10995625f, 
    0.24253786f, 0.06136560f, -0.03308990f, 0.16485330f, -0.01824599f, -0.02212893f, -0.04898979f, 0.00392743f, 
    0.06722417f, 0.00478397f, 0.12685905f, -0.16377924f, 0.46745571f, 0.07135291f, 0.00053346f, 0.12778483f, 
    -0.04224306f, 0.05119473f, 0.06061301f, 0.03103602f, 0.24950866f, 0.11619487f, 0.09984785f, 0.05884333f, 
    -0.12799546f, -0.24209961f, -0.17670406f, -0.34279135f, -0.17880005f, -0.15384661f, -0.14097166f, -0.00107879f, 
    0.14002581f, 0.02868688f, -0.00491918f, 0.11475939f, 0.04898460f, 0.08169723f, 0.05797489f, 0.22112510f, 
    -0.10166051f, 0.14311719f, 0.02401311f, 0.01005077f, -0.05496699f, -0.07722889f, -0.06205484f, -0.10479098f, 
    0.22761528f, 0.04556985f, 0.10681399f, -0.01670623f, 0.04542675f, -0.01099667f, 0.05556819f, 0.09094208f, 
    -0.03138486f, -0.02944070f, 0.01341654f, 0.02407757f, 0.28791934f, -0.22891697f, -0.15914464f, 0.00544790f, 
    -0.04978200f, -0.14175008f, -0.19766633f, 0.03868532f, -0.03148211f, 0.03022995f, -0.07088796f, 0.01332542f, 
    0.41543463f, -0.05504534f, -0.21325897f, -0.07321285f, -0.01463681f, -0.15113001f, 0.02595177f, 0.15185197f, 
    0.06593458f, 0.09350063f, 0.05941553f, -0.10436863f, -0.16578321f, -0.11022000f, 0.00283928f, -0.24828248f, 
    -0.07466665f, -0.05491325f, -0.05687500f, -0.10098051f, 0.16633816f, 0.05725637f, 0.07103796f, 0.12544522f, 
    0.48151395f, 0.18213940f, 0.12842137f, 0.07596830f, 0.05183702f, 0.00461794f, -0.03477598f, 0.05178583f, 
    0.09835501f, 0.12136200f, -0.04761075f, 0.06535950f, -0.14117400f, 0.02663529f, 0.19881617f, -0.12059139f, 
    -0.00698997f, 0.03110964f, 0.08533167f, -0.01478428f, 0.20576850f, 0.19441497f, 0.04350330f, -0.02655737f, 
    -0.65107650f, -0.25053662f, 0.15248157f, 0.09509183f, -0.21886005f, 0.05314202f, 0.26454949f, -0.05093770f, 
    0.09103351f, -0.08098828f, 0.09067035f, -0.26823655f, 0.07397180f, 0.23981032f, -0.12669995f, -0.22167385f, 
    0.02844693f, 0.06865276f, 0.27087563f, 0.04537263f, 0.19351377f, 0.06874536f, 0.07152072f, 0.10167073f, 
    0.02793720f, -0.03307964f, -0.02733381f, 0.00955388f, -0.01506474f, 0.00163260f, 0.01580319f, -0.02733675f, 
    -0.03444958f, 0.00493038f, -0.03663556f, -0.01570519f, -0.02375908f, -0.00289554f, 0.02557480f, -0.00285197f, 
    -0.00150342f, 0.02788904f, 0.01544720f, 0.00880479f, -0.00234441f, -0.02049031f, -0.01730502f, -0.00709927f, 
    0.00440246f, -0.01850206f, 0.01709210f, -0.01741383f, -0.01337480f, -0.02259105f, -0.03258192f, 0.03197487f, 
    -0.02932595f, -0.00887121f, 0.01577326f, -0.00704039f, 0.01053174f, -0.03736934f, 0.02103603f, -0.02617811f, 
    -0.01672342f, 0.00333461f, -0.01918435f, 0.02401149f, -0.00113809f, 0.02875247f, -0.02547301f, -0.02248987f, 
    -0.01840415f, 0.02362950f, -0.03966000f, 0.01454354f, 0.00648011f, -0.00628591f, -0.04055317f, -0.02529034f, 
    0.02091523f, -0.00340539f, -0.01376705f, 0.00428720f, 0.00940908f, -0.02701420f, -0.02522931f, 0.00185229f, 
    -0.02519040f, -0.00172339f, 0.00020143f, 0.00583372f, -0.02634672f, -0.00991965f, 0.02167582f, -0.02201751f, 
    -0.03563715f, -0.00180070f, -0.02209548f, -0.01175511f, -0.00746143f, -0.03402014f, 0.01342237f, -0.04120878f, 
    -0.03294792f, -0.03436822f, -0.02248386f, -0.02216995f, -0.01182324f, 0.02907280f, -0.00407333f, 0.01312404f, 
    -0.03992550f, 0.02912396f, -0.03566269f, -0.03208746f, -0.03931801f, -0.03363924f, 0.02326925f, -0.01810995f, 
    -0.01053402f, -0.03059366f, -0.01215270f, -0.02937356f, -0.01088390f, -0.03527493f, -0.00999210f, -0.02945760f, 
    0.02136565f, -0.00530676f, 0.02933324f, 0.02192807f, -0.01414087f, 0.02036743f, -0.00211162f, 0.02015410f, 
    -0.01458056f, -0.03440114f, 0.00793498f, -0.00325889f, -0.00159734f, -0.03954116f, -0.02141653f, -0.02834381f, 
    0.02499152f, -0.02664714f, -0.01039066f, 0.01796021f, -0.00875585f, -0.04310955f, 0.00276153f, 0.00253598f, 
    -0.00604480f, -0.03297186f, 0.00563335f, -0.02198691f, -0.01946790f, -0.03391492f, -0.01903634f, -0.04024652f, 
    0.01307928f, 0.01713590f, -0.02870793f, -0.00081754f, -0.01294868f, -0.01368134f, 0.00939515f, 0.02681594f, 
    0.01843611f, 0.01971142f, -0.00091770f, 0.02194681f, -0.01123431f, -0.01299065f, 0.01153172f, 0.01585734f, 
    -0.00239212f, -0.03943374f, 0.02822793f, -0.01760874f, -0.01460747f, -0.03260599f, 0.01274135f, 0.00475478f, 
    0.02948176f, -0.01481715f, -0.03443346f, 0.00726809f, -0.01040179f, 0.02705241f, -0.01202602f, -0.03860915f, 
    0.02671745f, -0.01890201f, -0.03348689f, 0.00646531f, -0.02670418f, 0.02352868f, 0.00689103f, -0.02624469f, 
    -0.04205974f, -0.03945944f, 0.02071219f, -0.01233475f, 0.01433837f, 0.00112173f, 0.00903269f, 0.01018793f, 
    -0.01941887f, -0.03368765f, 0.02620114f, 0.00889814f, -0.01107145f, -0.00569555f, 0.02003896f, -0.00283054f, 
    -0.00656263f, 0.02717865f, -0.04015740f, -0.01649448f, -0.03703088f, -0.00729627f, 0.01127666f, -0.01265365f, 
    -0.01268570f, -0.01078569f, 0.00612526f, -0.01348125f, -0.01061066f, -0.03478968f, -0.00556561f, 0.02439240f, 
    -0.03180264f, -0.03393176f, -0.01876887f, 0.00081444f, 0.02953158f, -0.00684130f, 0.00057165f, -0.03283824f, 
    -0.01300576f, -0.01006531f, 0.02418030f, -0.01159047f, -0.03343777f, 0.01412073f, -0.01904170f, -0.04163022f, 
    -0.00867978f, 0.02262950f, -0.03618935f, -0.02111603f, 0.01717146f, -0.02421298f, -0.03874484f, -0.01886674f, 
    0.00704346f, 0.02624781f, -0.00592875f, -0.00693888f, -0.04014489f, 0.01519812f, -0.01927138f, 0.03062308f, 
    -0.03386370f, -0.04076225f, -0.03371790f, -0.02763954f, -0.02791103f, 0.00861074f, -0.00768482f, -0.00911853f, 
    -0.00134039f, -0.01614713f, 0.01332785f, 0.02032548f, -0.01062731f, -0.01630630f, -0.03384195f, -0.02712249f, 
    0.02755860f, -0.01676838f, -0.02160106f, -0.03487888f, 0.00822118f, -0.01303919f, -0.03588013f, -0.00923422f, 
    -0.02517603f, 0.01530877f, -0.00173049f, 0.00013267f, -0.00485730f, -0.02928953f, -0.02090560f, -0.02766131f, 
    -0.01472332f, -0.01605183f, -0.04152791f, 0.01376213f, -0.02495961f, 0.01391960f, 0.03012006f, -0.00622859f, 
    -0.00842876f, -0.00733427f, -0.01083575f, -0.03684947f, -0.03730824f, -0.02140566f, 0.01892325f, 0.01338608f, 
    0.00742629f, -0.00689225f, 0.01557970f, -0.01885528f, -0.01902557f, 0.01404827f, -0.02671883f, -0.03762550f, 
    0.03773850f, -0.00608568f, 0.01087225f, -0.03497965f, -0.03804109f, -0.02616579f, -0.00640157f, -0.00251181f, 
    -0.02050988f, -0.02497689f, 0.01898555f, 0.02724781f, -0.03759454f, 0.00050193f, -0.04106297f, 0.00635100f, 
    -0.03910090f, 0.02886534f, -0.00599145f, 0.00985904f, 0.00763953f, -0.00632132f, -0.01030562f, -0.02069895f, 
    -0.00522980f, -0.01353011f, 0.00404005f, -0.00231025f, -0.03345208f, -0.03230702f, -0.03901172f, -0.02588351f, 
    0.00457532f, -0.01082055f, -0.03202239f, -0.00253407f, -0.01835508f, 0.01269499f, 0.01480648f, -0.02164029f, 
    0.00633327f, 0.02390192f, 0.01115522f, 0.00450649f, -0.02477655f, -0.02796881f, -0.02486852f, 0.02379720f, 
    0.02741683f, -0.02501717f, 0.02075257f, -0.00081963f, 0.00853933f, 0.00153176f, 0.00892604f, 0.01190509f, 
    0.01222895f, 0.01778756f, 0.01533937f, 0.02827352f, -0.02062527f, 0.00506564f, -0.00204560f, 0.02003961f, 
    -0.00183577f, 0.02883857f, -0.00807254f, -0.01920383f, 0.01235734f, -0.01539582f, 0.00085349f, 0.00110592f, 
    0.03151412f, -0.04215606f, -0.01946471f, -0.03146746f, -0.01124554f, -0.01060198f, -0.03380330f, 0.01625436f, 
    0.00651982f, -0.02915679f, 0.02273975f, 0.02769774f, -0.00357172f, -0.03285540f, 0.00268224f, -0.04175301f, 
    0.01990283f, -0.03857106f, -0.00417597f, -0.01958893f, 0.00323320f, -0.00736184f, -0.01341601f, -0.00583659f, 
    0.01259099f, 0.00811529f, -0.02219889f, -0.01878410f, -0.00344376f, -0.00173698f, -0.01863533f, -0.03937961f, 
    -0.02765825f, 0.01603303f, -0.03244359f, 0.01112671f, -0.01121122f, 0.02099749f, -0.00742410f, 0.01907321f, 
    -0.02753020f, -0.03798399f, 0.01131657f, -0.00018403f, 0.02752318f, 0.01197965f, -0.00737184f, -0.02515726f, 
    0.02164243f, -0.01864460f, 0.02726915f, 0.00997157f, -0.01156126f, -0.02524404f, -0.03206624f, 0.01187720f, 
    -0.03529046f, -0.02053683f, -0.00702834f, -0.03082914f, -0.02288918f, -0.03105641f, 0.01949063f, -0.03767718f, 
    0.02591288f, -0.03857836f, -0.00821878f, -0.01866732f, 0.01561649f, 0.00033581f, 0.01037658f, -0.02770994f, 
    0.01319014f, -0.02951169f, -0.00302865f, -0.01428992f, -0.03817257f, -0.01690373f, 0.02273613f, -0.00171562f, 
    0.03012950f, -0.01152241f, 0.01268012f, 0.02340707f, -0.03509296f, 0.01033520f, 0.00006466f, 0.02589540f, 
    0.03436623f, 0.01492303f, -0.00497131f, -0.02426478f, 0.01516871f, -0.03625758f, 0.01501820f, 0.00091201f, 
    -0.01211230f, -0.03631541f, -0.01105102f, 0.02705796f, 0.00718124f, 0.01115313f, -0.00104013f, -0.03739777f, 
    0.01388080f, 0.02717635f, 0.00771399f, 0.01608371f, -0.01608096f, -0.03255362f, 0.00908985f, -0.00827981f, 
    -0.02744718f, 0.00372034f, -0.01835097f, 0.01932408f, -0.00139559f, -0.01699177f, 0.02526957f, 0.00800271f, 
    -0.03142946f, -0.01083383f, 0.01099056f, -0.01485641f, 0.02442522f, -0.01280291f, -0.00973210f, -0.01908006f, 
    -0.00538082f, -0.03404422f, 0.02761265f, 0.02666268f, 0.02095788f, -0.01200519f, -0.00466095f, -0.00058441f, 
    0.00812000f, -0.01325583f, -0.03888426f, 0.01878879f, 0.02266963f, -0.00403953f, 0.02104487f, 0.00373094f, 
    0.00972783f, -0.01419947f, -0.03237118f, 0.00057463f, 0.01852335f, 0.00102181f, 0.01009209f, -0.01173811f, 
    -0.01991244f, 0.01024516f, 0.01896422f, -0.00322862f, -0.03158382f, -0.01222772f, -0.01608775f, 0.02647908f, 
    -0.01250733f, -0.03850549f, -0.00342912f, -0.02575362f, 0.02549541f, 0.02826917f, -0.02853969f, 0.02741665f, 
    -0.04138402f, -0.01404253f, -0.03879848f, -0.02647811f, -0.03926572f, -0.03315276f, 0.00284748f, -0.00885425f, 
    -0.00515256f, -0.01481517f, -0.00680454f, 0.01443972f, 0.00124439f, -0.01655233f, 0.03004780f, 0.00402493f, 
    0.00919119f, -0.02407245f, 0.00618049f, -0.01670400f, -0.00742150f, -0.01651800f, 0.01245036f, -0.02064020f, 
    -0.03234269f, -0.03399734f, 0.03035228f, -0.00048924f, 0.02020674f, -0.03956303f, 0.02592937f, -0.02442363f, 
    0.00240090f, -0.00142846f, -0.02697737f, 0.02428030f, -0.00518510f, -0.01633330f, -0.03158243f, -0.01441900f, 
    0.00836315f, -0.00733658f, 0.02670044f, -0.00561379f, -0.02540383f, 0.02989491f, -0.01207953f, 0.03314758f, 
    -0.01042937f, -0.03999691f, -0.00620055f, -0.01083755f, -0.01194758f, -0.04095377f, 0.02724074f, -0.01272399f, 
    0.02641962f, -0.01368604f, -0.01437182f, 0.00607124f, 0.02987085f, 0.00994296f, -0.00354924f, 0.01724706f, 
    0.02829244f, -0.03664710f, -0.00709170f, -0.01144988f, 0.01274967f, 0.00872354f, -0.02867424f, 0.01873087f, 
    -0.01457743f, 0.01867945f, 0.02453254f, -0.00568805f, -0.02814930f, -0.00240792f, -0.02340605f, -0.00812375f, 
    -0.01152234f, -0.02193994f, -0.00744196f, -0.00680971f, 0.01930399f, 0.00775834f, 0.02283262f, -0.00699813f, 
    -0.00718596f, 0.02810135f, -0.02325281f, 0.02016870f, -0.01841668f, 0.02267796f, -0.03792748f, -0.02716415f, 
    -0.03612670f, -0.00034402f, 0.02381692f, -0.00725303f, -0.02121240f, 0.01739086f, -0.03420189f, 0.02854200f, 
    -0.01420678f, -0.03454097f, 0.00184087f, 0.02492516f, 0.01828376f, -0.03236274f, -0.02053206f, 0.00633119f, 
    -0.01953099f, -0.03444758f, -0.02221034f, -0.01105335f, -0.04109927f, -0.02895472f, -0.01343109f, 0.00430898f, 
    0.00335093f, 0.02834213f, -0.02911267f, -0.00299243f, 0.01226134f, -0.01061617f, -0.00554797f, 0.01879622f, 
    -0.01653456f, 0.02016621f, -0.00887234f, 0.02234784f, 0.02224867f, 0.00822215f, -0.03051288f, 0.02730546f, 
    -0.00478837f, -0.00116379f, -0.01894098f, 0.02840635f, -0.01520000f, -0.00516209f, -0.03283136f, -0.00733611f, 
    0.02567985f, -0.01181980f, 0.01522248f, 0.00070902f, -0.01886002f, 0.02142467f, -0.02311017f, -0.03319396f, 
    -0.02647692f, -0.00696799f, 0.00527963f, -0.00583526f, -0.01672331f, -0.02946803f, -0.02018656f, 0.00255024f, 
    0.00827540f, 0.00177798f, -0.00518497f, 0.01149826f, -0.00044193f, -0.03782427f, 0.02866033f, 0.02156740f, 
    -0.03797665f, 0.00105827f, 0.01329740f, 0.00969143f, -0.01309908f, -0.02080258f, -0.02469536f, 0.01559384f, 
    0.01062841f, 0.01762518f, -0.03078661f, -0.01682188f, -0.00254698f, 0.00492163f, -0.03855016f, 0.00986223f, 
    -0.02876639f, 0.01869620f, -0.02477949f, 0.02049418f, 0.00628268f, -0.00665671f, 0.03076817f, 0.02702127f, 
    -0.02160702f, -0.01487831f, 0.00006246f, -0.01076262f, -0.01425050f, -0.00202139f, 0.01130997f, 0.00518425f, 
    0.01773337f, -0.02445160f, -0.00836347f, 0.03272335f, 0.03034116f, -0.01227025f, -0.02295331f, 0.00899383f, 
    -0.02100229f, 0.02799661f, -0.03417403f, -0.02868425f, -0.02903322f, -0.00111659f, 0.00617406f, -0.03269018f, 
    -0.02412363f, -0.00549015f, -0.02765025f, 0.00339617f, -0.01754607f, -0.04116803f, -0.01700554f, 0.02596007f, 
    -0.01719473f, 0.01144491f, -0.02908508f, -0.03401433f, 0.01911263f, -0.01033414f, -0.03228344f, 0.02958566f, 
    -0.38316134f, 0.04916248f, 0.01290538f, 0.02187265f, -0.02215961f, -0.11407224f, 0.01920798f, -0.04985059f, 
    0.11122502f, 0.19387390f, -0.16692412f, 0.03175830f, 0.07973858f, -0.06222349f, 0.05681626f, 0.00050162f, 
    0.16129416f, 0.07670829f, 0.00420491f, 0.03630419f, -0.06988187f, -0.02626533f, -0.05737757f, -0.01054312f, 
    -0.10731068f, -0.10517752f, 0.04810331f, 0.04546894f, 0.02350925f, 0.09768746f, 0.15359819f, 0.06894122f, 
    -0.04185008f, -0.05416560f, -0.00875196f, -0.08544832f, 0.20209433f, -0.06341530f, -0.27014440f, 0.21428834f, 
    0.04335208f, -0.05130838f, 0.15821643f, 0.00292371f, -0.02681685f, -0.01052098f, -0.02027893f, 0.05993123f, 
    0.03182779f, -0.11599854f, 0.01058193f, -0.26275003f, -0.07788650f, 0.04764099f, 0.06401282f, 0.11441469f, 
    0.04139074f, 0.05875709f, 0.01901890f, 0.09144130f, -0.15056421f, -0.10597385f, -0.05773024f, 0.02846910f, 
    -0.16370438f, 0.02367519f, -0.02034230f, -0.00307777f, -0.10752936f, 0.08199116f, 0.03125949f, 0.10250894f, 
    0.57035512f, 0.00588456f, -0.34120598f, -0.23563047f, 0.02262647f, -0.12235454f, 0.08093148f, 0.08793599f, 
    -0.01971579f, 0.12406763f, 0.02845284f, 0.01897713f, 0.21756646f, -0.05911308f, 0.15489340f, 0.15920772f, 
    0.12531073f, 0.06168726f, -0.05354864f, 0.13637227f, 0.01321632f, 0.05081034f, -0.07670722f, -0.04857134f, 
    0.39573124f, 0.04910064f, 0.11169916f, 0.25850227f, 0.05023577f, 0.11591207f, 0.04950452f, 0.04639785f, 
    0.01495020f, -0.00805915f, -0.00679843f, 0.04014601f, -0.02828215f, -0.24876125f, -0.31133759f, 0.07331127f, 
    0.10117753f, 0.14767818f, 0.05677152f, 0.03775252f, -0.04890068f, 0.09407318f, 0.00142662f, -0.01157312f, 
    0.42721134f, 0.21546969f, -0.00024308f, 0.12181656f, -0.01314674f, 0.01218853f, -0.11406711f, 0.07218802f, 
    -0.15153022f, 0.04186418f, 0.04063715f, 0.00771860f, 0.16036698f, 0.02227275f, -0.36360261f, 0.13876054f, 
    0.06746788f, 0.00913112f, 0.06361119f, 0.12223349f, 0.01771265f, -0.03981528f, 0.05460568f, 0.01923426f, 
    0.43611193f, 0.35178855f, 0.00322719f, -0.07520182f, -0.03950872f, -0.08790312f, -0.15192384f, -0.02761732f, 
    -0.11978603f, 0.08874005f, 0.08243851f, -0.03837292f, 0.73965764f, -0.23043546f, 0.10941441f, -0.21095365f, 
    0.12868951f, -0.03994790f, -0.23377866f, 0.11175908f, -0.02910859f, -0.10511016f, 0.07187157f, 0.00535192f, 
    0.08548566f, 0.13441029f, 0.21910858f, -0.05225470f, -0.10193592f, 0.11683364f, -0.04370371f, 0.09811474f, 
    0.11556514f, -0.09464905f, -0.17931491f, 0.19344144f, 0.18268092f, 0.23617703f, -0.04757028f, -0.11605135f, 
    0.01830705f, -0.00518874f, 0.02575832f, 0.05119060f, -0.01584426f, 0.15740730f, -0.00622864f, -0.10202545f, 
    -0.27326086f, -0.17930567f, -0.16846283f, 0.09070235f, 0.15674584f, 0.13086712f, 0.07250477f, -0.07346619f, 
    -0.02835228f, -0.01149376f, 0.05221004f, 0.10024831f, 0.13381447f, 0.04714278f, 0.02341800f, 0.15705614f, 
    -0.27238965f, -0.06406276f, -0.05742870f, -0.13525654f, 0.07515707f, -0.02472117f, -0.03407865f, -0.01964452f, 
    -0.14725208f, -0.05665707f, -0.29717267f, 0.15351820f, -0.03416413f, 0.00779010f, 0.11906049f, -0.10141721f, 
    0.06225243f, 0.07499702f, 0.06461468f, 0.08708380f, -0.06152922f, -0.04272489f, 0.08220695f, -0.10278072f, 
    -0.01781971f, -0.18316038f, -0.12926249f, -0.01781396f, 0.06231803f, -0.06621440f, 0.00870442f, 0.14809965f, 
    -0.19929768f, 0.20229632f, -0.08375484f, -0.22106732f, -0.12642778f, -0.04335593f, -0.07328265f, -0.20836166f, 
    -0.01565400f, -0.02755349f, -0.06941560f, -0.07118948f, -0.34424219f, 0.00412971f, -0.23846607f, 0.37671056f, 
    -0.11587432f, 0.13950002f, 0.09148678f, -0.02384471f, 0.05307563f, 0.10568369f, 0.13816983f, 0.02758440f, 
    -0.14468381f, 0.10816944f, -0.00969294f, -0.03230707f, 0.02743223f, -0.11331435f, -0.08068258f, 0.05936170f, 
    -0.03628391f, 0.04054720f, 0.04464421f, -0.04395896f, -0.16224118f, 0.12354359f, 0.00110090f, -0.03752354f, 
    0.00197830f, -0.09977511f, -0.03277469f, -0.03219521f, -0.06313403f, 0.09378754f, 0.13596559f, 0.03032261f, 
    0.43564111f, -0.17876667f, -0.06847370f, -0.19838090f, 0.09499525f, 0.01052867f, 0.03422621f, 0.15165986f, 
    0.12901613f, 0.09604343f, 0.02695650f, -0.06008837f, 0.00189869f, -0.04312149f, 0.10508002f, -0.09365888f, 
    -0.03161109f, -0.09416845f, -0.01409433f, 0.00212761f, -0.01226978f, -0.09900608f, 0.01907491f, -0.01559737f, 
    -0.04992666f, -0.01436357f, 0.06053159f, -0.03728440f, 0.02201968f, 0.18104038f, -0.15549098f, 0.13860470f, 
    -0.06264174f, 0.02974675f, -0.06505755f, -0.01388496f, 0.15673272f, -0.04263807f, 0.10204451f, -0.26648310f, 
    0.06191527f, -0.07313051f, -0.03168169f, 0.11679050f, -0.01445577f, 0.11290082f, -0.00630892f, -0.08544249f, 
    -0.00101169f, -0.08863651f, 0.07389276f, -0.00655225f, -0.04783238f, -0.12358629f, 0.00301603f, -0.08569357f, 
    -0.05364462f, -0.05602994f, -0.03811599f, -0.04963330f, -0.05896789f, 0.10703988f, -0.32572597f, -0.41938481f, 
    -0.05059252f, 0.22503679f, -0.00332846f, -0.05504767f, -0.08691470f, -0.11308358f, -0.07791655f, -0.09697960f, 
    0.24807790f, -0.14023653f, 0.07977055f, 0.19977437f, 0.12377284f, 0.25397837f, -0.02672480f, 0.14025377f, 
    -0.01610245f, 0.02250678f, -0.07063527f, 0.02591055f, 0.32347888f, 0.09741891f, 0.12511630f, -0.15403919f, 
    0.14004672f, 0.06065569f, -0.12724155f, 0.22114624f, -0.02878163f, 0.01916396f, 0.04161435f, -0.01638107f, 
    0.16786760f, -0.06441575f, 0.03807206f, 0.21022519f, 0.12016851f, 0.11964153f, 0.09868533f, 0.05274934f, 
    -0.05322944f, 0.14566901f, 0.05248344f, 0.05525139f, -0.08622848f, -0.02922127f, -0.08890760f, 0.07350145f, 
    0.32770279f, 0.13096687f, 0.19493724f, 0.04710833f, 0.03891419f, 0.05890959f, 0.05970345f, 0.01775691f, 
    0.32895386f, 0.28600037f, -0.17691129f, -0.26016796f, 0.06002762f, 0.03747990f, 0.16930942f, 0.17455769f, 
    0.13846961f, 0.02504901f, 0.25448951f, 0.00269389f, -0.24954367f, 0.02035837f, -0.09766370f, 0.08381546f, 
    -0.01637183f, 0.01852951f, 0.15982160f, -0.09317067f, -0.07942070f, 0.00262179f, 0.06804322f, 0.02526539f, 
    0.00004292f, -0.05252988f, 0.16953446f, -0.13098226f, -0.06249249f, -0.06103639f, -0.01441185f, -0.02895749f, 
    0.07589123f, 0.01374221f, 0.09203517f, 0.12755007f, 0.23671575f, 0.18280789f, 0.02270084f, -0.20721023f, 
    -0.01427676f, 0.08921384f, -0.14321731f, 0.13837454f, 0.08981179f, 0.06774231f, 0.26578280f, -0.26123017f, 
    0.18501183f, 0.21159810f, -0.18803452f, -0.16269290f, 0.04143123f, 0.00028122f, -0.02398664f, 0.10108653f, 
    0.02353959f, -0.02847943f, -0.06363634f, -0.09289049f, -0.01215451f, 0.03051766f, -0.16788661f, 0.03618376f, 
    0.05223426f, 0.10321031f, -0.06776495f, 0.12137125f, -0.07154351f, 0.01075932f, -0.06175177f, 0.06658151f, 
    -0.24098220f, 0.06793150f, 0.03016229f, -0.01771618f, 0.06038055f, -0.11250097f, -0.21700341f, 0.04707576f, 
    0.13141878f, 0.03766356f, 0.14212482f, -0.12940469f, 0.05662743f, 0.13417529f, 0.05748742f, 0.10441178f, 
    0.01420675f, -0.10225804f, -0.05112816f, -0.10101797f, 0.07698494f, -0.02093808f, 0.09300618f, 0.00225069f, 
    0.02907509f, 0.11336561f, -0.04923641f, 0.25499550f, -0.04611352f, 0.03316966f, -0.03798162f, -0.11714485f, 
    0.09328267f, -0.06007823f, 0.06331506f, -0.05566316f, -0.13084567f, 0.28998840f, 0.02788456f, 0.12565526f, 
    -0.31573525f, -0.15488349f, -0.09431931f, -0.09342150f, 0.00323789f, 0.02919423f, 0.10676490f, -0.03879419f, 
    -0.12505460f, -0.09096518f, -0.06114380f, 0.27428961f, 0.02362521f, -0.05787025f, 0.09238265f, -0.08616366f, 
    0.04859361f, 0.07275748f, -0.07529362f, 0.08957773f, 0.00048344f, 0.19967704f, -0.08708943f, 0.12346388f, 
    0.00301327f, -0.05664090f, -0.11826319f, -0.06695501f, -0.05779175f, 0.11468439f, 0.05709747f, -0.19380137f, 
    0.01345564f, 0.22290176f, -0.18812940f, 0.20569894f, -0.02168388f, 0.01300066f, 0.01579358f, -0.18314219f, 
    0.06200216f, 0.05429550f, -0.03070538f, -0.18754922f, -0.42818365f, -0.00717070f, -0.28358644f, 0.00121882f, 
    -0.12828271f, 0.06109370f, -0.01230512f, 0.03346495f, -0.11063231f, -0.02519038f, 0.11059614f, 0.02342411f, 
    -0.06089642f, -0.01858898f, 0.03528607f, -0.02024413f, 0.11596296f, -0.00391239f, -0.01602992f, 0.11603990f, 
    -0.05844564f, -0.14550678f, -0.03818959f, -0.05807052f, 0.01217547f, -0.04409229f, -0.09762764f, -0.13239576f, 
    -0.09333783f, 0.01748157f, -0.07340999f, 0.12447844f, -0.02983385f, 0.15843427f, -0.03323828f, -0.00861330f, 
    0.00969935f, 0.46591291f, -0.30484423f, -0.00570491f, 0.04210185f, -0.04955141f, 0.09064108f, 0.11973868f, 
    -0.07386354f, 0.07084943f, -0.04902113f, -0.06575366f, 0.36840215f, 0.20446923f, -0.06157853f, -0.05136725f, 
    -0.14473553f, -0.13429521f, 0.06103855f, -0.06539614f, -0.21334623f, 0.07592899f, 0.05920408f, 0.07855347f, 
    0.11697394f, -0.11446853f, 0.10305444f, -0.36275074f, -0.08574989f, 0.10180657f, -0.21042974f, -0.03909152f, 
    0.08385131f, -0.02593382f, -0.05978845f, -0.06306843f, 0.01547376f, 0.07687569f, 0.18172227f, 0.00336956f, 
    0.05977815f, -0.07633436f, -0.13718051f, -0.05677970f, 0.08919492f, 0.12498122f, 0.01146889f, -0.06500001f, 
    0.07499630f, -0.15366568f, 0.00348842f, 0.14136091f, 0.06620117f, 0.01939303f, 0.11264811f, 0.04436573f, 
    0.01294659f, 0.11139815f, 0.06386707f, 0.02321027f, 0.01670066f, 0.02039041f, 0.23001139f, -0.00590111f, 
    -0.03625347f, -0.08929070f, 0.07852519f, -0.05372991f, 0.02517498f, 0.01133885f, -0.01725571f, 0.15018182f, 
    -0.64475983f, -0.33101416f, 0.02566664f, 0.28275040f, -0.09289003f, 0.07337923f, 0.06261013f, -0.11490114f, 
    0.05593406f, -0.00473134f, -0.10204429f, 0.07817800f, -0.05629462f, -0.22646488f, -0.06645016f, 0.09867918f, 
    0.07769218f, 0.00082110f, 0.12099719f, 0.02319595f, -0.04000847f, -0.01395028f, -0.03448435f, -0.02879832f, 
    -0.09216071f, 0.14491016f, -0.04653163f, 0.25326350f, -0.20174448f, -0.02488021f, 0.07471287f, -0.13426539f, 
    0.06168936f, 0.05723045f, 0.03196966f, -0.00518676f, 0.08124273f, -0.07331727f, -0.03406251f, 0.17825918f, 
    0.04045058f, -0.03771244f, -0.02820497f, -0.02548276f, -0.04366852f, 0.00354559f, -0.01182339f, -0.02368182f, 
    0.17005455f, 0.01047693f, 0.21032624f, -0.07755746f, -0.00154580f, -0.12398972f, 0.11480163f, -0.11213572f, 
    0.08204806f, -0.04134466f, -0.05953087f, -0.08008591f, -0.10008883f, -0.00485201f, -0.17526996f, 0.12212719f, 
    -0.01484181f, 0.13003263f, -0.00803766f, -0.02900085f, 0.08358607f, 0.00950848f, 0.02862424f, 0.03914721f, 
    0.52847964f, 0.04222242f, -0.03454292f, 0.31343436f, 0.01494197f, 0.01568222f, -0.21970940f, -0.08724969f, 
    -0.15807056f, -0.12122452f, 0.06272574f, -0.05439387f, 0.03331064f, 0.03023018f, 0.09098237f, 0.19235215f, 
    -0.24793956f, 0.06202058f, -0.05322490f, 0.06695778f, 0.00331540f, 0.05339633f, 0.00612097f, -0.01785394f, 
    -0.02292897f, -0.04295698f, 0.01087211f, 0.00416553f, -0.00485957f, -0.00007824f, 0.02464650f, -0.02467757f, 
    0.00553431f, -0.02980645f, 0.01315914f, 0.02730386f, 0.03223920f, 0.01309745f, 0.02274305f, -0.01539752f, 
    -0.00304178f, 0.01796051f, -0.03881593f, -0.01013554f, 0.02729916f, 0.00958424f, -0.02659779f, 0.01644780f, 
    -0.01865780f, -0.01822240f, -0.02967642f, -0.00075434f, -0.01463515f, 0.02309683f, -0.02425810f, -0.00362793f, 
    0.01586721f, 0.01376169f, -0.02465144f, 0.02614119f, 0.02837465f, 0.00268259f, -0.00950811f, 0.00939675f, 
    0.02378146f, 0.02690294f, -0.03213983f, -0.00879495f, -0.02582290f, -0.03643882f, 0.00482888f, -0.00289950f, 
    -0.03451381f, -0.04104709f, 0.00592249f, 0.01893671f, 0.03362050f, -0.03202230f, 0.02157450f, 0.02082694f, 
    0.01215770f, 0.01374955f, -0.03928740f, -0.03263877f, 0.02280828f, -0.00958264f, 0.00835782f, -0.00670570f, 
    0.02203277f, 0.01470304f, 0.00968395f, -0.03001832f, -0.02660218f, 0.01260675f, -0.04405507f, -0.02495717f, 
    0.02252186f, 0.02581879f, 0.00579600f, -0.03236904f, 0.02389906f, -0.03520098f, 0.02477971f, -0.00857332f, 
    -0.00714307f, 0.02642046f, 0.01490682f, 0.02260566f, 0.03698341f, 0.03450188f, -0.01812748f, -0.00886954f, 
    0.01464591f, 0.01850665f, -0.03240256f, -0.01889385f, 0.02662019f, 0.00871841f, -0.01850114f, 0.03163630f, 
    0.01207436f, -0.00469564f, 0.00030224f, 0.03537414f, -0.01437355f, -0.00461850f, 0.01180037f, -0.02613458f, 
    0.01310716f, -0.00039794f, 0.00985334f, -0.03277429f, 0.01654297f, -0.01775058f, -0.03147783f, 0.01279504f, 
    -0.03647105f, 0.02342254f, -0.02072459f, -0.02428286f, -0.01424105f, -0.00267432f, 0.02212267f, -0.03853217f, 
    -0.00504510f, 0.03645407f, 0.02330861f, -0.01120088f, 0.01041701f, 0.00934679f, -0.02342184f, -0.03734516f, 
    0.02274819f, -0.02424774f, -0.03928997f, 0.00097191f, 0.02505237f, 0.04195473f, 0.01246917f, 0.01900056f, 
    -0.03868446f, -0.01099559f, 0.00893741f, -0.01356144f, -0.00101155f, 0.02144473f, 0.02669968f, -0.00542608f, 
    -0.02146565f, -0.02500343f, -0.01745822f, 0.00011913f, 0.02631595f, -0.00683240f, 0.01535702f, -0.02344003f, 
    -0.04216706f, -0.01229195f, -0.04061495f, -0.04272795f, 0.00528655f, 0.01579801f, -0.02439993f, -0.00820092f, 
    0.01373179f, -0.03830454f, -0.00213252f, -0.02602509f, 0.02537045f, -0.04234609f, -0.00867060f, -0.03251098f, 
    0.02226930f, -0.00733114f, -0.02101589f, 0.00030475f, -0.02316751f, 0.01737522f, -0.00333600f, -0.03548152f, 
    -0.00747365f, -0.00537805f, -0.03384042f, -0.00512233f, 0.02002517f, 0.00596305f, 0.01950325f, 0.01503445f, 
    0.02104755f, 0.00531728f, -0.02470660f, 0.01099279f, 0.02028634f, -0.03022718f, -0.01694051f, 0.01976748f, 
    0.01993409f, 0.00348674f, -0.03879268f, -0.00843552f, -0.00314239f, 0.00104477f, 0.03133823f, -0.02620813f, 
    0.00748291f, -0.00489395f, -0.01658466f, 0.00254566f, -0.04042755f, -0.04334526f, 0.00448157f, 0.01195068f, 
    -0.02491399f, 0.01218159f, 0.00450655f, -0.00022496f, 0.01598333f, -0.00954456f, -0.04042774f, 0.01159116f, 
    0.00905967f, -0.01292431f, -0.03232519f, -0.03313414f, -0.01394099f, 0.02523452f, 0.02188380f, 0.00390506f, 
    -0.01206410f, -0.01901254f, -0.03438516f, 0.00502502f, -0.03733659f, -0.02160374f, -0.01345822f, 0.00559604f, 
    0.02205649f, -0.04047948f, -0.04191870f, 0.00951077f, -0.03087809f, 0.00270633f, -0.02335410f, 0.00756010f, 
    -0.04217377f, -0.00928533f, -0.02948077f, 0.01521408f, 0.02566101f, 0.00907040f, 0.01775623f, -0.02024795f, 
    0.00727109f, 0.02484949f, 0.02135409f, -0.02370213f, -0.04278072f, -0.00677857f, -0.02720321f, 0.01956479f, 
    -0.03524005f, 0.00254951f, 0.00693005f, -0.03952549f, 0.01356237f, -0.03255691f, -0.03010037f, 0.01743051f, 
    -0.02984878f, 0.01959329f, 0.01956798f, 0.01236576f, 0.00104262f, 0.00689591f, -0.03902665f, 0.00078148f, 
    -0.00264101f, -0.00416654f, -0.03888009f, -0.01648662f, -0.01797750f, -0.02950574f, -0.00595821f, -0.00596504f, 
    0.00764402f, -0.01117316f, 0.00501553f, 0.01573655f, -0.01807572f, -0.00717285f, 0.00298852f, -0.03507493f, 
    -0.02386810f, 0.02629039f, -0.01780367f, 0.01105871f, -0.03632844f, 0.02475344f, 0.02776446f, 0.00292833f, 
    -0.01662015f, 0.01861968f, 0.00477376f, 0.02709894f, -0.02594366f, 0.02559046f, -0.02852898f, -0.04507045f, 
    0.00184926f, 0.02500027f, -0.04253320f, -0.02912703f, -0.02104360f, -0.04296891f, -0.03716503f, 0.00514577f, 
    0.00206207f, -0.01498830f, -0.00389463f, 0.01091190f, -0.03898489f, 0.00925182f, 0.00306165f, 0.01780304f, 
    0.02877982f, 0.00971288f, -0.00914543f, 0.03018079f, 0.01681967f, -0.02817205f, -0.01417545f, 0.00789462f, 
    -0.02337348f, -0.00614603f, 0.02388594f, -0.00593349f, 0.00588472f, 0.00659453f, 0.01673645f, -0.00445083f, 
    0.00240982f, -0.00099388f, -0.02896412f, 0.02324947f, 0.02824242f, -0.04374170f, -0.03720724f, 0.02668241f, 
    0.02772686f, -0.00827427f, -0.00251829f, -0.03590881f, 0.02272425f, -0.03277409f, -0.00987391f, -0.03851159f, 
    0.00045233f, -0.00623246f, -0.01273507f, 0.01998204f, -0.03774661f, -0.02771185f, -0.02270477f, 0.03066335f, 
    0.04377019f, 0.00070542f, 0.01631686f, 0.04159098f, 0.00241951f, -0.04069259f, -0.01575491f, 0.01033394f, 
    -0.03766764f, -0.03499239f, -0.00916588f, 0.02896995f, -0.02447905f, 0.01020808f, 0.01764404f, 0.01571934f, 
    0.01480860f, -0.02277645f, 0.01296790f, -0.00679662f, 0.01285014f, -0.02635938f, 0.02100276f, 0.01783150f, 
    0.00274241f, -0.00919633f, 0.00451149f, -0.01290897f, -0.03406372f, -0.02723009f, -0.03025148f, 0.01002188f, 
    0.02164424f, 0.00099213f, -0.00702748f, 0.01714918f, 0.03215393f, -0.02965234f, -0.03120870f, 0.02078457f, 
    0.00181304f, -0.01096819f, -0.02062164f, 0.02293008f, 0.01842902f, -0.03269231f, 0.02854975f, -0.03884367f, 
    0.01351603f, -0.01365624f, -0.01746452f, -0.02991810f, 0.00752839f, 0.02321575f, -0.00313505f, 0.00699065f, 
    0.00565038f, 0.03748371f, -0.00499842f, -0.00894424f, 0.02814122f, 0.01625455f, 0.02938470f, 0.02200508f, 
    0.00722395f, 0.00210595f, -0.03081171f, -0.00016935f, 0.01314577f, 0.01545327f, 0.00755568f, -0.03269928f, 
    -0.00352659f, -0.04417221f, -0.02907956f, 0.01358134f, -0.03713827f, 0.01983980f, 0.01416360f, -0.02131328f, 
    -0.00432566f, -0.02782036f, -0.02431997f, 0.02114703f, 0.01040265f, -0.01270940f, -0.04180920f, 0.02446941f, 
    -0.00338419f, -0.03168422f, -0.01767624f, -0.00923434f, 0.00084275f, 0.02443921f, 0.01510553f, -0.03396685f, 
    0.02149792f, 0.00448818f, -0.02624044f, 0.02081832f, -0.00911390f, -0.03885084f, -0.02998393f, 0.01985192f, 
    0.03036389f, -0.00531666f, 0.02845534f, 0.00828443f, 0.02670000f, -0.01520740f, -0.01810374f, -0.00842161f, 
    -0.00895215f, -0.03577738f, 0.01937885f, -0.03154089f, 0.00901576f, 0.02894365f, -0.02097924f, -0.02832493f, 
    -0.01169754f, 0.01914018f, 0.00653029f, 0.01794659f, 0.00067043f, 0.01262582f, -0.02390024f, 0.02465400f, 
    0.00368257f, -0.01936798f, -0.01890654f, 0.01398261f, -0.00814849f, -0.04255664f, -0.00419077f, -0.02734169f, 
    -0.03364746f, 0.02287084f, -0.01729897f, 0.03187145f, 0.00533639f, 0.00293878f, -0.03383411f, 0.01890094f, 
    0.02444718f, -0.01857313f, 0.02500202f, 0.02019462f, 0.00951937f, -0.00630384f, -0.02445550f, -0.03426982f, 
    0.03292254f, -0.00723908f, -0.03491770f, 0.00952003f, -0.03283692f, -0.00508792f, -0.02019010f, 0.00808641f, 
    -0.00710461f, -0.04525132f, 0.02823508f, -0.03062598f, 0.01067064f, 0.02584297f, -0.03505998f, -0.00544636f, 
    -0.01534722f, 0.01312461f, 0.00896822f, -0.02659614f, 0.01715153f, 0.02068196f, -0.00941591f, 0.00477480f, 
    0.00351169f, 0.01738163f, 0.02202174f, -0.00398481f, -0.00148214f, 0.01621681f, 0.02151695f, -0.00913012f, 
    -0.01973619f, 0.01607230f, -0.03646047f, 0.01969608f, 0.02635256f, -0.03186386f, -0.03996549f, -0.04011805f, 
    -0.02522103f, 0.00097830f, 0.00796742f, 0.01315496f, -0.03282856f, -0.02736054f, -0.03919695f, 0.01473186f, 
    -0.03087298f, -0.04225868f, 0.00716884f, -0.03512294f, -0.01733474f, -0.03396017f, -0.00506266f, 0.01602359f, 
    -0.01101424f, -0.04294847f, -0.00186359f, -0.01938857f, -0.03568240f, -0.00491685f, -0.00644960f, -0.01506479f, 
    0.02452793f, 0.01096060f, 0.01038769f, -0.02729293f, -0.02871902f, 0.02379088f, 0.01563618f, -0.00130413f, 
    0.03620488f, 0.00748118f, -0.02971361f, -0.00699897f, 0.00096098f, 0.02168998f, 0.01075688f, -0.00909052f, 
    -0.02823368f, -0.02173940f, -0.00407364f, -0.04271695f, 0.02590747f, -0.00187335f, -0.02815903f, 0.00119797f, 
    0.01969579f, -0.00300168f, -0.00914607f, 0.00676620f, -0.03362138f, -0.01659098f, 0.02905332f, -0.00662383f, 
    0.01686660f, 0.00876369f, -0.00486956f, 0.03040382f, 0.02397137f, 0.01934610f, 0.02242979f, -0.01835007f, 
    -0.01300633f, 0.02283820f, 0.00905758f, 0.02935193f, -0.01745415f, -0.03484413f, 0.01154677f, -0.00365104f, 
    -0.01335717f, -0.02385402f, -0.03371406f, 0.02510367f, -0.02751050f, -0.00851814f, 0.03112331f, -0.00193030f, 
    -0.03049025f, 0.01573006f, 0.01483359f, 0.00287702f, 0.01617010f, 0.00869315f, 0.01908238f, -0.00665635f, 
    -0.02505785f, -0.00053001f, 0.00729724f, -0.00438991f, -0.00327287f, -0.00119289f, 0.02348470f, 0.02318927f, 
    0.02626373f, 0.02881708f, -0.02876426f, -0.02666838f, -0.03895265f, -0.03395054f, 0.00938087f, 0.02850891f, 
    -0.01938414f, -0.00934370f, 0.01722650f, 0.01140402f, -0.03480483f, 0.01065347f, -0.02648797f, 0.00118173f, 
    0.02034234f, 0.02335472f, -0.03745409f, 0.00386082f, 0.01341634f, -0.03710800f, 0.01390719f, -0.01373860f, 
    -0.00214756f, -0.04366315f, -0.00250181f, 0.00186961f, -0.01472044f, -0.03657434f, -0.03922153f, 0.02736786f, 
    -0.00428070f, 0.02602869f, -0.01954584f, 0.02041343f, 0.02623373f, 0.03366315f, -0.00042020f, 0.01769962f, 
    -0.00907960f, 0.01668047f, -0.03270848f, -0.03613836f, -0.02506974f, -0.01057946f, 0.02701591f, -0.02517036f, 
    0.02438243f, 0.00112470f, 0.02009827f, 0.02440031f, -0.01163021f, 0.00794347f, 0.01645517f, -0.01655993f, 
    -0.04069920f, 0.01980495f, -0.00367512f, -0.00038016f, 0.03633882f, 0.03737935f, 0.03017869f, -0.01797984f, 
    0.00184510f, -0.01742228f, -0.02427360f, -0.02828410f, -0.02600868f, -0.01443177f, 0.01581829f, 0.02755465f, 
    -0.01872691f, -0.01867833f, -0.03628692f, 0.02511520f, -0.01101071f, -0.00365053f, -0.03339581f, 0.03320857f, 
    0.01261594f, 0.00165754f, 0.02594749f, 0.00619651f, 0.00054162f, -0.02513355f, -0.01869684f, 0.00390602f, 
    -0.03948807f, -0.00315899f, 0.00287529f, -0.03483374f, -0.00291302f, 0.01417417f, -0.02264412f, -0.03419219f, 
    -0.00764017f, 0.01487788f, -0.02731116f, 0.02758358f, -0.04270383f, -0.00565819f, -0.03700304f, 0.00636292f, 
    -0.03679459f, 0.02136886f, -0.01338651f, 0.00753568f, -0.00213154f, -0.01725860f, -0.04324844f, 0.02062685f, 
    0.02619305f, -0.01226898f, -0.03826959f, -0.04361321f, -0.02553250f, -0.01747731f, -0.03504033f, 0.00877612f, 
    -0.01532272f, -0.01788315f, -0.03237736f, -0.00531227f, -0.03056703f, -0.02635966f, -0.03301644f, 0.00800978f, 
    -0.01605774f, -0.00005738f, -0.01537645f, -0.03371053f, 0.02796883f, 0.00884138f, 0.02163490f, -0.03250569f, 
    0.01059859f, -0.02442049f, 0.01093222f, -0.01107758f, -0.03721416f, 0.00461190f, 0.01128779f, 0.02484392f, 
    -0.01664466f, 0.01751012f, 0.02723665f, -0.00344625f, 0.00875409f, 0.01442230f, -0.02919410f, 0.02513384f, 
    0.00256282f, -0.03821741f, -0.00669233f, 0.00353644f, -0.02470520f, -0.00503898f, -0.01452623f, 0.00403048f, 
    -0.02352137f, -0.00681843f, 0.02464541f, 0.02357169f, 0.00755158f, -0.01678338f, -0.04107017f, -0.00003401f, 
    -0.04264570f, -0.03943966f, -0.00476417f, -0.03518751f, 0.00508435f, -0.03674366f, -0.01739053f, -0.03236253f, 
    0.01614224f, 0.00899383f, -0.01822995f, 0.02124667f, -0.00544012f, -0.03229130f, -0.02829951f, -0.00328488f, 
    -0.04183356f, -0.01945462f, -0.00684759f, 0.02169299f, 0.00189877f, -0.02772537f, 0.00281801f, 0.01303044f, 
    0.02288444f, -0.03645032f, -0.03154376f, -0.00006331f, 0.01386106f, 0.02908718f, 0.02020098f, -0.03327716f, 
    0.01219439f, -0.01856085f, 0.02538921f, -0.04091274f, -0.01329536f, -0.00931127f, -0.04196653f, -0.01456985f, 
    -0.02552336f, 0.00306192f, -0.01190725f, -0.01332991f, -0.03309865f, -0.01952309f, -0.00659241f, -0.03012617f, 
    -0.04015142f, 0.00262538f, 0.02265898f, -0.01763916f, -0.02053330f, 0.00552606f, -0.01771143f, -0.01763535f, 
    -0.01392437f, -0.01024846f, -0.02369458f, -0.02647578f, 0.00464431f, 0.01187200f, -0.01272513f, 0.00599804f, 
    0.00227586f, 0.00373487f, -0.01974959f, 0.01251884f, 0.00642971f, -0.01975903f, -0.02786327f, -0.02931406f, 
    0.02559043f, -0.00517261f, -0.00079340f, -0.01686951f, 0.00370756f, -0.03744531f, -0.00149364f, -0.00083732f, 
    0.01901559f, -0.02005033f, 0.01501239f, -0.02210295f, -0.03811552f, -0.01952162f, -0.01936038f, 0.03412078f, 
    -0.03111781f, -0.04185469f, -0.03858487f, 0.02789184f, -0.03685045f, 0.02843800f, -0.01168639f, -0.01554257f, 
    0.00746046f, -0.03622920f, -0.00670671f, -0.00539610f, -0.01018959f, -0.02697611f, -0.00328100f, 0.01131016f, 
    0.00813986f, -0.03189131f, 0.01979411f, 0.01435039f, 0.01234808f, -0.02126304f, -0.01923187f, 0.01079500f, 
    -0.04247354f, -0.01309451f, -0.01520854f, 0.00437437f, -0.03631565f, -0.03813260f, -0.01135756f, 0.00007670f, 
    0.00314635f, 0.02029794f, 0.00854952f, -0.00931234f, -0.04241889f, -0.03796024f, 0.01914473f, 0.01452532f, 
    0.02210863f, 0.00953753f, -0.00627785f, 0.02283304f, -0.00019400f, -0.01170322f, -0.00627373f, 0.00613706f, 
    0.01147640f, -0.00812098f, -0.02879957f, 0.01107449f, -0.01880360f, 0.00951793f, -0.02588480f, -0.04359027f, 
    -0.00101977f, -0.00248948f, 0.00231143f, 0.01922639f, -0.02678593f, 0.00295161f, 0.01637941f, -0.02391853f, 
    -0.02671244f, -0.01995859f, -0.00165649f, 0.02084432f, 0.02724122f, -0.03233611f, -0.04023360f, 0.00595185f, 
    0.00069207f, -0.01841857f, 0.00740217f, 0.00054802f, 0.01524592f, -0.01934902f, 0.00897011f, -0.03888728f, 
    -0.01868776f, -0.00237809f, -0.01938001f, -0.04335373f, -0.01484428f, 0.02253117f, -0.03065111f, -0.01506454f, 
    0.00158905f, 0.02560418f, 0.00924964f, 0.00859590f, -0.03330820f, 0.00018606f, 0.01182558f, 0.02380804f, 
    0.00514342f, -0.02014116f, -0.00006162f, -0.00460524f, 0.02046900f, -0.00288233f, -0.02400018f, -0.03337112f, 
    0.00628640f, 0.00517510f, -0.01083337f, 0.00003808f, -0.03566078f, 0.02871851f, -0.02244747f, 0.02725997f, 
    0.00298835f, -0.03277543f, 0.02077078f, 0.01886112f, 0.01299200f, -0.00851781f, 0.01268175f, -0.04152345f, 
    0.01092989f, -0.00932524f, -0.00366162f, -0.00549812f, 0.02724102f, -0.00667705f, -0.01640542f, 0.00948666f, 
    0.01767430f, -0.03030473f, -0.00236957f, 0.00211491f, -0.00523095f, 0.00318130f, -0.03301055f, -0.01238948f, 
    0.01687238f, 0.01063997f, -0.00589550f, -0.00840468f, 0.02805442f, -0.02415771f, -0.04071160f, -0.02616934f, 
    0.00429112f, -0.00072861f, 0.01620903f, -0.03163011f, -0.02717200f, -0.00615220f, -0.01005936f, 0.00794706f, 
    -0.01455461f, 0.02479118f, -0.01130987f, -0.02713561f, 0.02528622f, -0.02984309f, -0.03248184f, -0.00611478f, 
    -0.02359606f, 0.02134918f, 0.02334127f, 0.01397862f, 0.00792263f, -0.02178275f, 0.01650212f, 0.00675320f, 
    -0.00950946f, -0.00884770f, 0.00765184f, 0.01954548f, 0.01848760f, 0.01737320f, -0.00803756f, -0.00866639f, 
    -0.02119676f, -0.02235254f, 0.00786356f, 0.00935573f, -0.01490232f, -0.02424575f, 0.02050975f, -0.02207294f, 
    -0.01622970f, -0.02781488f, -0.03437036f, 0.00515265f, -0.00636409f, -0.03855359f, 0.00289180f, 0.00827491f, 
    -0.00146456f, -0.02863529f, 0.02550268f, -0.03708876f, -0.01378005f, -0.00435513f, 0.01443994f, -0.01714838f, 
    -0.00788908f, -0.01982632f, -0.01461956f, 0.02839240f, -0.01842950f, -0.03426968f, 0.01444408f, 0.01347132f, 
    -0.00951200f, 0.02426891f, 0.01022886f, 0.02683915f, -0.00110262f, -0.01214741f, 0.02446419f, -0.01572539f, 
    -0.00244644f, -0.04118917f, -0.02311504f, 0.01185295f, -0.01482784f, 0.01913115f, 0.00765254f, -0.02072622f, 
    0.01672006f, -0.00560811f, -0.01620565f, -0.00487467f, 0.00087492f, 0.01507801f, -0.01052338f, -0.03816540f, 
    -0.00897224f, -0.01360572f, 0.00891798f, -0.02140580f, -0.03534814f, -0.00640606f, 0.00424666f, 0.00341528f, 
    -0.02484178f, -0.03244551f, -0.01792249f, -0.00095962f, 0.01529953f, 0.00162195f, -0.01507574f, -0.00107138f, 
    -0.01383583f, 0.01241601f, 0.01497398f, -0.04119974f, 0.00074796f, 0.01275513f, 0.01066910f, 0.00303896f, 
    -0.01607805f, 0.01700123f, -0.00232283f, -0.01746417f, -0.04233208f, 0.00805811f, -0.04299895f, 0.03123853f, 
    -0.03384879f, -0.03780951f, 0.00277634f, -0.03755345f, 0.02469097f, -0.03038220f, 0.03007272f, -0.02919070f, 
    0.02830295f, 0.00267419f, 0.00323933f, -0.03223885f, 0.01136238f, -0.02709524f, -0.03225943f, -0.01576267f, 
    0.00013033f, 0.01407366f, -0.02718303f, 0.02164879f, -0.03807652f, -0.02715963f, 0.02310993f, -0.00083841f, 
    0.01403954f, -0.03329169f, 0.00641919f, -0.03279470f, -0.03204592f, 0.00790188f, -0.00937523f, 0.01775980f, 
    0.00193863f, -0.02168274f, -0.01641740f, 0.02852149f, 0.02026951f, 0.00867060f, -0.01554519f, -0.00605764f, 
    -0.00312526f, -0.01640633f, -0.01772649f, 0.01442453f, 0.01090275f, -0.02875742f, -0.03821531f, 0.02497300f, 
    -0.00271697f, -0.01821696f, -0.01541352f, 0.00628384f, -0.03821667f, -0.01344066f, 0.00568096f, -0.03221804f, 
    0.00896748f, -0.02889510f, -0.01516055f, -0.00059350f, 0.02250166f, -0.02700465f, -0.00987021f, 0.02280521f, 
    0.00767825f, -0.03899102f, -0.00669829f, 0.01254085f, -0.02348113f, 0.03221654f, -0.00292845f, 0.01325530f, 
    -0.02404217f, -0.03667102f, -0.01112153f, -0.02102943f, -0.03169582f, -0.00076831f, 0.02338117f, -0.01946347f, 
    -0.03147989f, 0.02913595f, -0.00598536f, -0.00539350f, 0.00109734f, 0.02598886f, 0.02503099f, -0.01919695f, 
    -0.00591572f, 0.00121889f, 0.00994656f, -0.03916302f, 0.02078943f, 0.00518069f, -0.02879647f, -0.00183137f, 
    -0.02826706f, 0.02890641f, -0.02019221f, 0.00128613f, -0.04135508f, 0.02796332f, 0.01688538f, -0.02287746f, 
    0.02296286f, 0.02603216f, 0.01777142f, 0.01041572f, 0.01861831f, 0.02913582f, -0.01459733f, 0.02019974f, 
    -0.02479302f, 0.01247736f, 0.01930964f, -0.00898819f, -0.03565313f, -0.00305050f, 0.00696752f, -0.00664052f, 
    -0.02640291f, -0.00203547f, 0.02671544f, -0.03323716f, 0.02331452f, -0.00234078f, -0.00414150f, -0.04045581f, 
    -0.02815650f, -0.03489235f, -0.00599671f, 0.00649382f, -0.01517333f, -0.00915744f, 0.02637334f, 0.00854991f, 
    0.00337470f, 0.00940612f, 0.01744228f, -0.04103270f, -0.03890837f, -0.00395864f, 0.02343423f, -0.02671904f, 
    0.02497025f, -0.03857454f, -0.00593528f, -0.00124292f, -0.00389768f, 0.00811359f, 0.02918061f, 0.02721085f, 
    -0.00175107f, -0.02378034f, 0.00569567f, -0.02126017f, -0.02659619f, -0.02017810f, -0.02864330f, 0.02329395f, 
    -0.02109486f, -0.03681772f, -0.02673078f, -0.01334932f, -0.01794895f, -0.02943611f, -0.03585374f, 0.02139349f, 
    -0.02847705f, -0.02086529f, 0.00355878f, -0.03212243f, 0.00894200f, -0.02168004f, 0.01551967f, 0.01215418f, 
    0.03286539f, -0.00726871f, -0.01799080f, -0.03985520f, 0.01054975f, 0.00550635f, -0.02401226f, -0.02549106f, 
    -0.01684271f, -0.00399591f, -0.01606539f, -0.00396889f, 0.00256671f, -0.03826113f, -0.01869490f, -0.01512702f, 
    -0.03920751f, -0.04269609f, 0.00633978f, -0.00445444f, -0.03095230f, -0.02253237f, -0.03305862f, -0.02818345f, 
    -0.00652076f, -0.00465036f, 0.02387298f, -0.01756614f, 0.00303844f, -0.00121079f, -0.01361932f, -0.00462320f, 
    -0.01120395f, 0.01519862f, 0.01555517f, -0.03087917f, 0.01322982f, 0.01996689f, 0.01755408f, -0.02769339f, 
    0.00009297f, -0.00219419f, 0.02080772f, 0.01985884f, -0.00564300f, 0.02711877f, -0.02626460f, -0.01956660f, 
    -0.02388874f, 0.02141546f, -0.04085582f, 0.01653155f, -0.01402035f, -0.00758636f, 0.02937985f, -0.00824348f, 
    0.00866388f, 0.02552541f, -0.02430036f, -0.03017212f, 0.02559227f, 0.01464015f, 0.02274825f, -0.03106084f, 
    0.02458102f, 0.02706381f, 0.00019384f, 0.00951771f, -0.02148919f, -0.03703988f, -0.01248402f, 0.01297340f, 
    0.02159494f, 0.00910013f, 0.01152351f, -0.03347453f, -0.03855373f, -0.02130903f, 0.00847373f, -0.02549412f, 
    0.01813643f, -0.00964111f, -0.02837847f, -0.04036980f, -0.03408657f, 0.00221157f, -0.04223681f, 0.00421405f, 
    0.01316524f, -0.00249942f, 0.02577748f, -0.00497696f, -0.03873634f, 0.02623132f, 0.00617771f, -0.02188425f, 
    0.01758081f, -0.02621086f, -0.03237422f, 0.01011511f, -0.01859342f, 0.02612525f, -0.01421863f, -0.00549753f, 
    -0.01875969f, -0.02679524f, 0.01884336f, -0.03366063f, -0.02025862f, 0.00746643f, -0.02657961f, 0.04313627f, 
    -0.01684273f, -0.02766794f, 0.02710921f, -0.02335681f, 0.00047544f, 0.02146137f, 0.00111183f, -0.02525645f, 
    0.01612346f, -0.02348430f, -0.02290087f, 0.01946777f, 0.00409019f, -0.00168581f, -0.01521220f, -0.03011770f, 
    -0.00268184f, 0.02836034f, 0.00062956f, -0.04095049f, 0.01425697f, -0.04086902f, -0.00621350f, 0.02852385f, 
    0.01910749f, 0.00550224f, -0.02115057f, 0.00485108f, 0.01511021f, -0.03533398f, 0.01271024f, 0.00264030f, 
    -0.02617834f, 0.01347797f, -0.04105490f, 0.01308333f, -0.00934281f, -0.00040175f, -0.02565002f, 0.00981265f, 
    -0.01167340f, -0.01123645f, -0.00299753f, -0.01628272f, -0.00694161f, 0.02347364f, -0.02946377f, -0.01371332f, 
    -0.01002566f, -0.00800931f, -0.03971583f, -0.03725722f, -0.02433227f, -0.02039931f, -0.02344894f, 0.02478407f, 
    -0.01921079f, 0.00556774f, 0.00474085f, -0.04144983f, -0.03647567f, 0.02415143f, 0.00488166f, -0.01293007f, 
    0.00279907f, -0.00883411f, -0.03516090f, 0.00217062f, -0.00641422f, -0.03137612f, -0.02678939f, -0.00731839f, 
    0.01111137f, -0.02203833f, 0.01721451f, 0.00542537f, 0.02864472f, -0.04041153f, -0.03943505f, -0.00905617f, 
    0.02505756f, -0.03923983f, 0.00173937f, 0.02461429f, -0.02256183f, -0.01226196f, -0.02201638f, -0.02814712f, 
    -0.04172013f, -0.01975890f, -0.03317291f, 0.02501815f, 0.00084550f, 0.01685735f, -0.01924084f, -0.03012160f, 
    0.02184986f, -0.03072923f, -0.01148986f, -0.00211235f, -0.03143996f, -0.04086541f, 0.00810753f, -0.04568018f, 
    0.01472539f, -0.02897786f, -0.03069015f, -0.02181809f, -0.00722010f, 0.01380861f, -0.03671723f, 0.01478991f, 
    -0.00716749f, 0.01314199f, -0.00875047f, -0.01926119f, -0.02132103f, -0.02795458f, -0.02411877f, -0.01054652f, 
    0.01108084f, 0.00775966f, -0.03138505f, 0.02000796f, 0.00485095f, -0.00948814f, -0.03537124f, -0.03579650f, 
    0.01769346f, 0.01674328f, -0.03194540f, 0.02484607f, 0.00243414f, 0.00422371f, 0.01708408f, -0.00717504f, 
    0.00068879f, 0.02593550f, 0.00267765f, -0.03366931f, -0.02161323f, 0.01097291f, -0.00478541f, 0.00087529f, 
    0.00103495f, -0.01498581f, -0.01708722f, -0.03107107f, -0.01529927f, -0.00426762f, 0.01077539f, -0.01751951f, 
    0.01157658f, 0.00861803f, -0.01847390f, 0.00821486f, 0.00696382f, -0.01591516f, 0.00514539f, 0.01012679f, 
    -0.03724172f, 0.02748826f, -0.03078783f, -0.03081542f, 0.00123026f, 0.01044078f, 0.02411734f, 0.01117080f, 
    -0.02844675f, 0.01787006f, -0.00529394f, 0.02405185f, 0.02387263f, -0.03831773f, 0.00592487f, 0.01437970f, 
    0.02027420f, 0.00464946f, -0.00020788f, 0.02871243f, 0.00824314f, 0.02480743f, -0.02361208f, 0.00099317f, 
    0.02139774f, -0.02407563f, -0.02479062f, -0.01488946f, 0.03303593f, 0.02802285f, -0.00600079f, -0.00961609f, 
    0.02012312f, 0.03536392f, 0.03703213f, -0.01278260f, 0.00832818f, 0.02016139f, 0.01839680f, -0.02742357f, 
    -0.01097471f, -0.01569726f, 0.03535742f, -0.02086642f, 0.02098057f, 0.01238968f, 0.00060757f, -0.01421287f, 
    0.00286297f, -0.03556124f, 0.03239045f, 0.01760757f, 0.00352491f, 0.02009846f, -0.02105644f, 0.03097591f, 
    -0.01622264f, 0.01970826f, 0.02188383f, -0.02866310f, 0.02918037f, 0.01469677f, -0.04427578f, 0.01697077f, 
    -0.00650094f, 0.01541279f, -0.02731141f, 0.02532998f, 0.02053517f, -0.01386415f, -0.02606482f, -0.01754829f, 
    0.00508433f, -0.02306157f, 0.00459084f, -0.02548203f, 0.00632311f, 0.02152892f, 0.01707141f, 0.01760960f, 
    0.00781129f, -0.02716737f, -0.00518988f, -0.01234972f, -0.03749688f, 0.01650964f, 0.01190592f, 0.00686399f, 
    -0.03019756f, -0.00153625f, 0.01278011f, -0.00983796f, -0.03748187f, 0.01559601f, 0.01556651f, 0.02656576f, 
    -0.03666396f, 0.00652291f, -0.02909483f, 0.02049668f, -0.03027322f, -0.01187405f, 0.03347242f, -0.01737576f, 
    -0.00541066f, 0.01677627f, 0.02258570f, -0.03030708f, 0.01334251f, -0.03093491f, 0.00335048f, 0.02595524f, 
    0.00535617f, -0.00426517f, -0.02583301f, 0.02789608f, 0.00235332f, 0.02758623f, -0.01148292f, 0.00569568f, 
    -0.01197994f, 0.03082223f, -0.03674602f, 0.01338773f, -0.02580819f, -0.01845517f, -0.02124910f, -0.03069426f, 
    -0.03216685f, -0.00724436f, -0.00029068f, 0.02435440f, -0.02567701f, 0.02789634f, 0.02049867f, 0.03460839f, 
    0.02673692f, -0.01153286f, 0.02987150f, -0.00301932f, -0.02100700f, 0.00585093f, -0.01767853f, 0.01065834f, 
    0.01337812f, -0.02869127f, -0.02608844f, 0.01212874f, -0.01576124f, -0.02555668f, -0.00973116f, -0.03436774f, 
    0.01157064f, 0.03286200f, 0.03410127f, 0.01534250f, 0.02671586f, 0.03047453f, 0.01265969f, 0.03619565f, 
    -0.03909613f, 0.02890579f, -0.01824907f, -0.03442829f, -0.02718703f, -0.03079494f, -0.00671325f, 0.02336296f, 
    -0.00126415f, -0.00454952f, 0.01061835f, -0.01003364f, -0.02457284f, 0.01171394f, -0.03790419f, -0.03492205f, 
    -0.03047753f, -0.03381187f, 0.01400869f, 0.03177555f, -0.01539266f, 0.00395035f, -0.02506688f, -0.03731781f, 
    0.00322160f, -0.03287145f, -0.02724209f, -0.00119501f, -0.00942562f, -0.02166259f, 0.00803367f, -0.00230047f, 
    0.00832491f, -0.02051472f, -0.00331085f, 0.00599375f, 0.01876055f, 0.01865323f, -0.00793198f, -0.02737159f, 
    0.01619074f, -0.02703984f, -0.02394750f, 0.03046862f, -0.00122153f, -0.02201244f, 0.02965720f, -0.02315905f, 
    0.02311829f, -0.01866568f, 0.01693479f, 0.02146804f, 0.00938046f, 0.00058659f, -0.02981929f, -0.04241433f, 
    -0.03460951f, -0.02339601f, -0.00714922f, -0.03781094f, 0.00452480f, 0.01178361f, -0.00105254f, -0.02261298f, 
    0.02371411f, -0.01554512f, -0.02405856f, 0.00889988f, -0.00214573f, -0.02531340f, 0.00933072f, 0.03526295f, 
    0.02598447f, 0.00500693f, 0.00608047f, 0.03020786f, 0.02060995f, -0.02683463f, -0.01644578f, -0.02280105f, 
    0.01130076f, 0.01492255f, -0.01637486f, 0.01595843f, 0.01594404f, 0.01382230f, -0.01763376f, -0.01171865f, 
    0.01888469f, -0.01264114f, 0.01867018f, 0.03059137f, -0.00837012f, -0.01571299f, -0.02049375f, -0.00855626f, 
    0.02748909f, -0.02444234f, 0.02896571f, -0.03058368f, 0.02581059f, -0.02973427f, 0.01645027f, -0.01970712f, 
    0.00422590f, 0.02698822f, -0.02809113f, -0.00566855f, 0.01306771f, -0.02947485f, -0.02784937f, -0.00487368f, 
    0.01874756f, -0.02280571f, -0.01931915f, -0.02698462f, 0.00877237f, -0.03651081f, 0.01810769f, -0.04303845f, 
    0.02413901f, -0.01929061f, 0.02971093f, -0.02754762f, 0.00520894f, 0.00931205f, -0.03503903f, -0.00239397f, 
    -0.01010075f, -0.03333393f, -0.03903387f, -0.02490148f, 0.01472750f, -0.01701860f, -0.02850348f, -0.02134516f, 
    0.00193355f, 0.01927985f, 0.02441150f, -0.00037225f, 0.01115390f, -0.02887915f, -0.00866225f, -0.03039043f, 
    0.02049275f, 0.00174083f, 0.02625885f, 0.02752694f, -0.00191966f, 0.01453345f, 0.02638327f, 0.02621725f, 
    -0.01334685f, 0.01922905f, -0.04264326f, 0.01880679f, 0.03334470f, 0.01219473f, 0.01120402f, -0.03614253f, 
    -0.02979010f, -0.01720201f, -0.02257001f, -0.02158293f, 0.03230724f, 0.00319203f, -0.00919748f, 0.02567382f, 
    0.02252826f, -0.02627300f, -0.02987131f, 0.01825348f, 0.02674218f, 0.03268261f, -0.02420647f, -0.01001090f, 
    -0.02164650f, 0.02919672f, 0.01206417f, -0.01032170f, 0.01915399f, -0.03355932f, 0.02346860f, -0.01787446f, 
    -0.01806423f, 0.03332158f, -0.03079263f, -0.03714798f, -0.03569357f, 0.01738319f, -0.00799926f, -0.03196910f, 
    0.01510716f, -0.00675915f, -0.03869746f, -0.02630166f, 0.01606520f, 0.01463906f, -0.03695020f, -0.00059903f, 
    -0.02029790f, 0.00789917f, 0.02389383f, -0.00608735f, 0.00431678f, -0.00893116f, 0.02708999f, 0.00583749f, 
    0.02337701f, -0.03790155f, -0.03802093f, 0.00957313f, -0.00979564f, 0.00158671f, -0.01652931f, -0.00716385f, 
    -0.00339187f, -0.02867207f, 0.03568661f, 0.00369096f, -0.02375076f, 0.01551761f, -0.01327990f, 0.00372326f, 
    0.00311594f, 0.01753427f, -0.03282869f, -0.02327182f, -0.03938512f, -0.00095936f, 0.01041941f, -0.02928837f, 
    -0.03176091f, 0.01928986f, 0.02337941f, 0.02841038f, -0.04307759f, -0.00738905f, -0.00894914f, -0.03068739f, 
    -0.01945759f, -0.03426428f, -0.03385621f, -0.00067253f, 0.01154069f, -0.00314957f, -0.02195891f, -0.00856640f, 
    0.03219086f, -0.01123315f, -0.00724214f, 0.00045768f, -0.04065137f, -0.01615898f, -0.01825684f, 0.01897150f, 
    0.02345766f, -0.04725332f, -0.03061352f, 0.00304301f, 0.02019820f, 0.01523930f, -0.01092399f, -0.00637417f, 
    0.00807790f, -0.01078871f, 0.00365268f, 0.00831803f, -0.00564221f, -0.00536360f, -0.03361648f, -0.01818176f, 
    0.00576079f, -0.00203759f, -0.04141060f, 0.02566013f, -0.03872075f, -0.01525735f, -0.00270820f, -0.01647119f, 
    0.01731443f, 0.00956239f, -0.01672203f, -0.01641445f, -0.00467211f, -0.03374801f, 0.00439410f, -0.02232582f, 
    -0.03202177f, 0.01891723f, -0.01167871f, 0.03222260f, 0.00197565f, 0.02755871f, -0.01690596f, -0.02826622f, 
    -0.03069744f, -0.02258709f, 0.00518209f, -0.01376593f, -0.03230380f, 0.00978534f, 0.02419297f, -0.00975757f, 
    -0.01588295f, -0.03944533f, 0.00167734f, 0.01860689f, 0.03194103f, -0.00271955f, 0.02128365f, 0.02241154f, 
    -0.02202134f, -0.03020345f, -0.01129557f, 0.02834566f, -0.01306855f, 0.00772669f, -0.03400027f, -0.02473263f, 
    -0.00912286f, -0.00024696f, 0.01039260f, -0.00410408f, -0.02194097f, 0.01349849f, 0.01195469f, 0.02492590f, 
    0.00553089f, -0.01683147f, -0.02786717f, 0.02409373f, -0.01820746f, 0.01564503f, 0.00000645f, 0.01850723f, 
    0.00665801f, -0.00848334f, 0.00295703f, -0.03013288f, -0.02852597f, -0.01652885f, 0.02070869f, -0.01735293f, 
    -0.01771887f, -0.04358862f, 0.01055575f, -0.01983350f, -0.01736986f, -0.01088477f, -0.03309092f, -0.01093505f, 
    -0.02239836f, 0.03846719f, -0.03361432f, -0.03279721f, -0.00045095f, -0.00237717f, -0.01740954f, 0.01376620f, 
    -0.00079763f, -0.03359029f, -0.03462400f, 0.02112589f, -0.00478711f, 0.01468078f, -0.01948079f, -0.02707275f, 
    -0.02730556f, -0.02840138f, 0.00772935f, 0.01725217f, -0.03159504f, -0.02921689f, 0.00726108f, 0.00835018f, 
    -0.01100846f, 0.01304327f, -0.02640433f, 0.01189747f, -0.02582249f, 0.03094845f, -0.01598338f, 0.00407055f, 
    0.02223080f, -0.04054149f, -0.00811288f, 0.01500482f, -0.02275902f, 0.02132124f, -0.03336940f, 0.02777130f, 
    -0.02250389f, 0.00815033f, 0.02517959f, 0.01320535f, -0.03006327f, 0.02031082f, -0.00943137f, -0.01072857f, 
    -0.00596334f, 0.00530009f, 0.02371192f, -0.00570688f, 0.03147439f, -0.02888609f, 0.03126754f, 0.01758541f, 
    -0.00110062f, -0.03104378f, -0.02982076f, -0.00489225f, -0.04438756f, 0.02461513f, -0.01055598f, -0.00383990f, 
    0.01755841f, -0.00566935f, 0.00499081f, -0.03136204f, -0.01880261f, 0.01963726f, -0.02406335f, -0.03338940f, 
    -0.01892658f, -0.00580680f, 0.03149226f, 0.00433956f, -0.01935920f, 0.03195886f, -0.02742385f, 0.02973984f, 
    0.00710511f, -0.02935136f, -0.03968573f, -0.03231036f, 0.00404274f, -0.00848223f, -0.01453286f, -0.02120588f, 
    0.00823820f, -0.00386452f, -0.02497844f, 0.01038264f, 0.03056827f, 0.00903983f, -0.02942340f, -0.01941893f, 
    0.02855428f, 0.00533640f, -0.03589955f, -0.02521597f, -0.03260059f, -0.03113317f, 0.00941325f, 0.01280077f, 
    0.02728070f, -0.02529695f, -0.02093920f, -0.04182621f, 0.02081146f, 0.01835702f, 0.03436320f, -0.01119711f, 
    -0.02965875f, -0.03009360f, -0.03770368f, 0.02738861f, 0.02479337f, -0.01454420f, 0.02227431f, -0.03361461f, 
    0.00762636f, -0.02539817f, -0.03406724f, 0.01818292f, 0.01093144f, -0.02592718f, 0.00719520f, 0.02303843f, 
    0.01872163f, -0.03696758f, 0.01051552f, -0.03077322f, -0.04933856f, -0.00614319f, 0.02242413f, 0.00422191f, 
    0.02872698f, -0.00799483f, -0.02315093f, 0.03137396f, 0.03003686f, -0.02308493f, 0.00207334f, -0.01856025f, 
    -0.01875575f, 0.00600293f, -0.02146650f, -0.00021039f, -0.01385172f, 0.01397956f, -0.00127652f, -0.00284156f, 
    -0.01186910f, 0.00426207f, -0.03386252f, -0.00784442f, 0.01304318f, -0.01886875f, -0.01798950f, 0.01415176f, 
    0.00921810f, -0.03314726f, 0.02531918f, -0.00522477f, -0.00936940f, 0.01719264f, -0.03540486f, -0.02454020f, 
    0.01164500f, -0.02144946f, -0.03860526f, 0.00924807f, 0.01853648f, 0.02426201f, 0.02988375f, -0.01707670f, 
    -0.34860420f, 0.02961000f, 0.15522708f, 0.02202353f, -0.04088610f, 0.02981575f, 0.15310733f, -0.06952220f, 
    0.27738217f, 0.20819171f, 0.12910207f, 0.36522830f, 0.01042364f, -0.22464000f, 0.01340891f, 0.08847906f, 
    0.08578013f, -0.06004955f, -0.02607798f, -0.09354170f, -0.03887344f, 0.14076176f, -0.01225918f, -0.02583678f, 
    -0.17507039f, -0.07236286f, 0.10146669f, -0.02537725f, -0.00275535f, 0.04823064f, 0.07558808f, 0.04856918f, 
    0.00842297f, -0.01278404f, 0.09060738f, -0.03571619f, 0.29587075f, 0.03582264f, -0.05707105f, 0.28629768f, 
    -0.04137483f, -0.01412734f, 0.13091497f, -0.07527632f, 0.09795825f, 0.19102891f, 0.14834659f, 0.37948990f, 
    0.17985235f, 0.38566923f, 0.35044709f, 0.23484693f, -0.13504937f, 0.06753907f, 0.15065172f, -0.17805760f, 
    0.06105034f, 0.27612862f, -0.10157494f, 0.14881513f, -0.21231475f, -0.00654743f, 0.11969969f, -0.01473795f, 
    -0.02942861f, -0.06098855f, 0.01631237f, -0.01749832f, -0.15073515f, 0.04425609f, -0.16256140f, -0.17491981f, 
    0.20165847f, 0.15715198f, 0.36701131f, 0.31975171f, 0.17013492f, -0.24350049f, -0.09327576f, 0.03036484f, 
    -0.02759338f, 0.04118930f, -0.08107022f, -0.17750022f, -0.00961242f, -0.23703574f, -0.05708785f, 0.13056932f, 
    0.00902809f, -0.04263391f, 0.02581085f, -0.01384877f, 0.13058825f, 0.07480238f, 0.02355723f, 0.24190541f, 
    0.10696328f, -0.06140478f, 0.17909291f, 0.32715887f, -0.05686085f, 0.01217907f, 0.01788759f, 0.00578233f, 
    0.15070374f, -0.03497283f, 0.10901553f, 0.24026473f, -0.05791732f, -0.08661562f, -0.24086922f, -0.07615906f, 
    0.00830504f, -0.06263853f, -0.02750139f, 0.08648448f, 0.17205262f, -0.02577255f, -0.00801814f, -0.16714701f, 
    0.04098681f, 0.00799354f, -0.08382202f, 0.10129168f, 0.04875154f, -0.12336301f, 0.00672082f, -0.12324172f, 
    -0.09394485f, 0.07984558f, -0.17231718f, -0.01353125f, -0.07565240f, -0.13060252f, -0.44532466f, -0.08304427f, 
    0.08661713f, -0.05618268f, 0.03212111f, 0.00736939f, 0.11952792f, -0.21024314f, 0.01427987f, 0.05149845f, 
    0.51613176f, 0.28519252f, -0.37596741f, 0.02910306f, 0.06291856f, 0.06865383f, -0.02382332f, -0.19335794f, 
    0.10557590f, -0.09880280f, 0.17700779f, 0.11180340f, 0.38554394f, -0.06058541f, 0.02634419f, 0.13841020f, 
    0.02137169f, -0.05129694f, -0.13449328f, -0.08651236f, 0.23416950f, -0.21720012f, -0.21323669f, -0.06359366f, 
    0.20252849f, 0.02475396f, -0.04534922f, -0.04484402f, -0.07462186f, 0.22419344f, -0.03732440f, -0.02532253f, 
    0.16929515f, 0.07841669f, 0.15430735f, 0.27481955f, 0.08947811f, 0.11130819f, -0.19381258f, -0.01693088f, 
    -0.07489954f, -0.06341173f, -0.04533811f, -0.00019091f, 0.06886718f, 0.15242228f, -0.13004771f, -0.07004553f, 
    -0.14057332f, 0.05862778f, -0.15129049f, -0.01940743f, 0.00543918f, 0.11997031f, 0.06439704f, 0.02616102f, 
    0.19236924f, 0.06961441f, 0.09974975f, 0.14018825f, -0.04851236f, 0.18081307f, -0.44374844f, 0.14074579f, 
    -0.07446028f, -0.16193704f, -0.01127120f, -0.18660252f, -0.08715437f, -0.20968841f, -0.24070095f, -0.25310755f, 
    -0.34166014f, 0.25479352f, -0.28538737f, -0.33948362f, -0.04535522f, -0.08667120f, 0.09323210f, 0.04273851f, 
    -0.07118828f, -0.06198958f, 0.01513243f, -0.08379702f, -0.05482543f, -0.11240530f, 0.00960873f, -0.31209859f, 
    0.14816652f, -0.03295125f, -0.15334684f, -0.06627866f, -0.06459577f, -0.28577077f, -0.28564477f, -0.00766543f, 
    -0.12168052f, 0.24792489f, -0.26813176f, -0.14950675f, -0.18006250f, -0.04833986f, -0.06318942f, -0.24353355f, 
    -0.02681040f, 0.02805904f, -0.04076381f, 0.05282773f, -0.18794367f, 0.47671869f, 0.13832673f, 0.42359239f, 
    -0.17810996f, 0.17136326f, 0.11372778f, -0.19210555f, 0.00822946f, 0.16297789f, 0.17549805f, 0.11273421f, 
    -0.17381600f, -0.00992461f, -0.08169486f, 0.00253224f, 0.19381951f, 0.00025808f, -0.11343111f, 0.11237647f, 
    -0.12176459f, -0.20211028f, -0.08975716f, -0.34403902f, -0.41717863f, 0.01223661f, 0.07317486f, -0.17042470f, 
    -0.04643388f, -0.15406471f, 0.01559574f, 0.07344184f, -0.11403535f, -0.08835933f, -0.09755407f, -0.29639900f, 
    0.09234071f, -0.02751283f, 0.27889141f, 0.17469878f, 0.00867356f, 0.05214483f, -0.08961551f, 0.06302576f, 
    0.13146015f, 0.01648006f, 0.13903625f, 0.12454586f, -0.14160086f, -0.07582438f, 0.03524052f, -0.21752377f, 
    -0.01232686f, -0.17228831f, -0.15767297f, -0.05190202f, -0.15869315f, -0.12831864f, -0.08237727f, -0.13475859f, 
    -0.06895805f, -0.04860149f, -0.07878453f, -0.04665896f, -0.10464506f, -0.12742187f, 0.00422504f, 0.02992765f, 
    0.11946926f, 0.22750363f, 0.12546971f, 0.03807503f, 0.10042198f, -0.08605777f, 0.07026839f, -0.00198910f, 
    -0.06687099f, 0.00400513f, -0.02780470f, -0.07623091f, -0.01040265f, 0.10528717f, -0.00375735f, 0.18414626f, 
    -0.04676164f, 0.03015620f, -0.08336691f, 0.07132684f, 0.11007133f, -0.04711479f, 0.07933659f, 0.06887534f, 
    0.12339225f, 0.07570527f, 0.16172636f, 0.26742810f, 0.16036974f, -0.00199736f, -0.06191297f, -0.02071214f, 
    0.10340705f, -0.07824016f, 0.08686899f, -0.11746696f, 0.07636620f, 0.10057466f, 0.15842114f, -0.01553760f, 
    0.05608379f, -0.02018286f, -0.02910573f, 0.08161861f, -0.05970493f, 0.07307391f, -0.11514920f, -0.00224472f, 
    0.08071888f, 0.10909975f, -0.17609179f, 0.01838206f, -0.04395807f, -0.02572299f, 0.07370446f, 0.13321778f, 
    -0.00711700f, 0.00614287f, -0.11821098f, 0.05270019f, 0.03449963f, 0.00779781f, 0.16121253f, 0.10803728f, 
    -0.00430619f, 0.22689202f, 0.08378538f, 0.20744121f, 0.01734734f, -0.07123269f, -0.07494896f, -0.08886334f, 
    -0.10965426f, 0.02816657f, -0.14337130f, -0.06599865f, -0.09035634f, -0.11598600f, -0.06844622f, 0.09458038f, 
    0.14384247f, 0.23452319f, 0.12691614f, 0.01982871f, 0.21023558f, 0.25787428f, 0.07881907f, 0.26436040f, 
    -0.16744460f, 0.15172826f, -0.12730600f, 0.01007101f, 0.10809371f, -0.02929305f, -0.12526412f, 0.17602473f, 
    -0.15225302f, -0.08235954f, 0.09650385f, -0.38490197f, -0.23295122f, -0.07055128f, -0.08611809f, -0.09672798f, 
    -0.02084717f, -0.03328571f, 0.11628897f, 0.03649848f, -0.10161058f, -0.12370124f, -0.02596616f, -0.21820293f, 
    0.02426465f, -0.15698738f, 0.04364336f, -0.25094351f, 0.11720628f, 0.10348605f, -0.07287187f, 0.03375417f, 
    0.05959586f, -0.11320672f, -0.02159936f, 0.13305502f, 0.05875135f, -0.16236907f, 0.09612191f, -0.15643369f, 
    -0.12820955f, 0.12692043f, -0.07787866f, 0.13854110f, 0.04271200f, 0.02409946f, 0.18360212f, -0.03496583f, 
    0.06278683f, 0.15077478f, -0.11007461f, -0.03036840f, 0.04622662f, -0.02256075f, -0.10331257f, 0.08730312f, 
    -0.04249154f, -0.00855741f, 0.02468552f, 0.00997132f, -0.13056891f, 0.11016746f, -0.27455100f, -0.15270565f, 
    0.06830578f, -0.01144036f, 0.04542439f, 0.01321174f, 0.07329112f, -0.00139436f, 0.03132791f, 0.08671363f, 
    -0.18344216f, 0.00922279f, 0.03377429f, -0.20533547f, 0.26356998f, 0.09937539f, 0.06056218f, -0.11994570f, 
    -0.12332157f, -0.15365875f, 0.02703902f, -0.14076684f, 0.01512171f, -0.04759328f, 0.14175396f, -0.06250317f, 
    0.04347336f, -0.04378962f, 0.25742814f, 0.03625247f, 0.09433579f, 0.29975009f, 0.30231118f, 0.31572223f, 
    0.03595735f, -0.03105696f, -0.02443623f, 0.15618667f, -0.01612528f, -0.01156041f, -0.04906922f, -0.08796579f, 
    -0.14719455f, -0.05398049f, 0.16432105f, -0.13536909f, 0.01030121f, 0.11325329f, 0.09972219f, 0.41971490f, 
    0.05946278f, -0.07422745f, 0.12403441f, -0.08206478f, -0.26962528f, -0.18645033f, -0.23991540f, -0.19147357f, 
    -0.17949231f, 0.08419593f, -0.11737268f, -0.02697798f, 0.06815793f, 0.02175958f, 0.14346676f, -0.00700198f, 
    0.08060589f, -0.04856241f, -0.21683213f, 0.09386424f, -0.11843944f, 0.21871576f, -0.26543769f, -0.03092008f, 
    0.08285057f, 0.04687853f, 0.12379735f, 0.03929809f, 0.08860940f, 0.21039781f, -0.06728859f, 0.01350483f, 
    -0.20134215f, 0.39918327f, -0.24355884f, 0.09589702f, 0.06711267f, -0.00388157f, 0.04714821f, -0.17498018f, 
    0.05789338f, 0.13344224f, 0.11035431f, 0.06514449f, -0.08522259f, 0.28901085f, 0.02110889f, 0.00846000f, 
    -0.00938809f, 0.03097232f, 0.12890565f, -0.33098632f, -0.11119875f, -0.00038616f, -0.05102943f, 0.15019993f, 
    -0.12840998f, -0.18512943f, -0.07328886f, -0.01179862f, -0.01524814f, -0.09726421f, -0.01050799f, 0.12436876f, 
    0.00214894f, 0.07175051f, 0.03802497f, 0.04324015f, 0.00190231f, -0.21816486f, -0.11852165f, -0.01232205f, 
    -0.13028310f, -0.13491946f, -0.01445796f, 0.09262335f, -0.06284379f, 0.03759501f, -0.17330374f, -0.18214977f, 
    -0.20275304f, 0.19877061f, -0.20885737f, 0.12035888f, 0.13686772f, 0.14523444f, -0.08838002f, 0.03569324f, 
    0.02416324f, 0.13529126f, -0.05558321f, 0.04208647f, 0.14159083f, 0.22185104f, -0.08229429f, 0.19167815f, 
    0.06443399f, 0.06895001f, -0.02794115f, 0.14131412f, 0.02719040f, 0.07925270f, -0.00752957f, 0.21293032f, 
    0.20335653f, -0.43505636f, 0.28523883f, -0.29949510f, -0.20602399f, 0.00221242f, -0.28205720f, -0.16776669f, 
    0.10758770f, -0.18766724f, 0.07878441f, 0.04208053f, -0.18870641f, -0.24532738f, 0.11607610f, -0.19229342f, 
    0.01362738f, 0.09920199f, 0.04350588f, 0.04636360f, 0.11133686f, 0.11626922f, 0.02871995f, 0.15959883f, 
    -0.06194913f, 0.06646055f, 0.34680262f, 0.14556271f, 0.00693097f, 0.03446257f, 0.16874598f, 0.00163348f, 
    0.09516266f, 0.06726730f, 0.03403997f, 0.18235120f, -0.14755583f, -0.08782914f, -0.14546284f, 0.05933230f, 
    0.15545587f, -0.04954940f, 0.16147190f, -0.15995888f, -0.23587692f, -0.24908113f, -0.41407493f, -0.25451592f, 
    -0.36028397f, -0.25134894f, -0.03785900f, 0.34953395f, -0.09552521f, 0.09377797f, 0.11764351f, 0.05248744f, 
    0.03215539f, -0.15416044f, 0.02595340f, -0.10632238f, -0.19070831f, -0.32140994f, -0.09944786f, -0.00916792f, 
    -0.09348424f, 0.06888267f, -0.01601112f, 0.16787076f, -0.00527335f, -0.06197295f, -0.08503816f, -0.18860820f, 
    -0.22761175f, 0.45719954f, 0.20948583f, 0.21603066f, -0.05082366f, -0.05937913f, -0.04327886f, -0.08995637f, 
    -0.12723154f, 0.01202152f, 0.02778218f, 0.10055054f, -0.06750744f, -0.01226946f, 0.15546514f, 0.08310033f, 
    0.00352985f, 0.12910956f, 0.05894681f, -0.03860278f, 0.05214861f, -0.00381402f, 0.24943103f, 0.18435478f, 
    0.09722582f, -0.10438296f, 0.06489613f, -0.05020677f, -0.00720565f, -0.06585445f, -0.02012487f, -0.27001807f, 
    -0.01049708f, 0.04229321f, -0.04010349f, 0.05897734f, 0.07278465f, 0.24404263f, 0.07393850f, 0.12112208f, 
    -0.03325047f, -0.00334059f, 0.01220666f, -0.18271922f, 0.02830442f, 0.25073138f, 0.10040314f, 0.14666133f, 
    0.05196775f, 0.30303106f, -0.20677724f, 0.16886939f, 0.12780042f, -0.04798324f, -0.18677430f, -0.19831306f, 
    -0.14487697f, -0.15377778f, -0.05420829f, -0.15686621f, 0.00767773f, -0.02754839f, -0.03137913f, -0.06712830f, 
    -0.07237660f, 0.06983680f, 0.06602938f, -0.01366591f, -0.00092072f, 0.22112741f, 0.16258588f, 0.21221274f, 
    -0.03528280f, 0.02687539f, -0.00748653f, 0.00445479f, 0.00280595f, -0.02724832f, 0.00351970f, -0.01533796f, 
    0.01066427f, 0.00691993f, -0.03185925f, 0.03287531f, 0.00420629f, 0.02580377f, 0.01891745f, -0.03498992f, 
    -0.03613298f, -0.02237754f, -0.02246730f, -0.01097493f, -0.02434102f, 0.01343390f, -0.00734144f, -0.01170316f, 
    0.02093790f, 0.03789707f, 0.02494207f, -0.02115878f, -0.03066896f, -0.00285532f, -0.00492960f, -0.02163291f, 
    0.03192963f, 0.02854851f, 0.01774194f, -0.01529848f, -0.03702297f, -0.01458212f, 0.02459794f, 0.02740163f, 
    0.02937457f, -0.02332985f, -0.01961198f, -0.03262118f, 0.02349016f, 0.01799788f, 0.01320131f, 0.01314608f, 
    0.01169740f, 0.00181460f, -0.00854690f, 0.00413229f, 0.00260709f, -0.03483522f, 0.00074022f, -0.03194505f, 
    0.01102287f, 0.00737229f, -0.02208931f, -0.02258756f, 0.02721299f, 0.02864170f, 0.00455873f, 0.00696764f, 
    -0.00386060f, -0.02428605f, 0.01153798f, -0.01931302f, 0.01472556f, -0.00299991f, 0.00701383f, 0.00982703f, 
    0.02539974f, 0.00700862f, -0.00997777f, -0.01338708f, -0.01216483f, -0.02847162f, 0.00923870f, 0.01721820f, 
    0.02971807f, -0.01449985f, -0.03449747f, -0.01222979f, -0.03033510f, 0.03319512f, -0.02332950f, -0.01334818f, 
    -0.03494510f, -0.00936842f, 0.01789797f, -0.03648448f, -0.00765370f, -0.01030025f, 0.03426088f, 0.04123001f, 
    0.03136410f, -0.00794570f, -0.01647103f, 0.00962473f, -0.03020554f, 0.00413526f, -0.01299606f, 0.03296113f, 
    0.02985374f, 0.00926227f, -0.01510977f, -0.02657825f, -0.01878023f, -0.03848201f, 0.00549944f, -0.03355489f, 
    -0.01942057f, 0.00020798f, -0.02127008f, 0.03033051f, -0.01005452f, -0.00854373f, -0.02041281f, -0.01305462f, 
    -0.00109568f, -0.01656710f, 0.00589770f, -0.02739503f, -0.01283191f, -0.01260302f, -0.01580287f, -0.00953104f, 
    -0.03335387f, 0.00658331f, -0.01546355f, 0.02802099f, 0.02147300f, 0.00527325f, 0.03396739f, 0.02790166f, 
    -0.04207054f, 0.02624861f, -0.01728392f, -0.01028687f, -0.01997662f, -0.01480274f, -0.02643293f, 0.02996508f, 
    0.02779778f, -0.01379126f, -0.02294196f, 0.01276217f, -0.03590961f, 0.02346759f, -0.00229744f, 0.01464174f, 
    -0.01547765f, 0.00173563f, -0.02321699f, -0.00456997f, -0.03329292f, -0.02248400f, -0.01426373f, 0.01399664f, 
    -0.01555912f, -0.00693107f, 0.02131835f, 0.00478900f, 0.01924475f, -0.03504227f, 0.00885043f, 0.00051731f, 
    -0.01412474f, 0.01636414f, -0.00259889f, 0.01338648f, -0.01410741f, -0.00624248f, 0.00550775f, -0.02068409f, 
    -0.01278571f, -0.01284322f, -0.01810923f, 0.01060471f, 0.01643839f, -0.02237608f, -0.02271019f, 0.01184732f, 
    0.00954824f, 0.01087740f, -0.01749350f, 0.02422386f, -0.03167164f, -0.00514387f, -0.03517221f, -0.03775715f, 
    0.02276374f, -0.01189068f, 0.00749518f, -0.02814871f, -0.02801722f, -0.03748071f, 0.00191087f, 0.00028002f, 
    -0.01452632f, 0.02417175f, 0.01175998f, 0.02716184f, -0.03357989f, -0.00806538f, -0.02615528f, 0.02745354f, 
    -0.00009323f, 0.03020850f, -0.01594038f, 0.00496953f, 0.00418194f, 0.01353268f, 0.03159124f, 0.03219047f, 
    0.00610138f, -0.00456232f, 0.03210901f, 0.03558163f, -0.02238806f, 0.00932768f, -0.03074871f, 0.02921690f, 
    -0.01177439f, -0.03654810f, -0.02180422f, 0.00959946f, -0.02813449f, 0.00340091f, 0.01466319f, 0.00450780f, 
    0.01232191f, 0.00411213f, -0.00903251f, 0.00740317f, -0.01705799f, -0.00123490f, -0.01749739f, 0.01349888f, 
    -0.03572931f, -0.01315675f, 0.00386338f, -0.01126690f, -0.01958856f, -0.02615017f, 0.00195692f, -0.01558535f, 
    0.01299035f, 0.01658166f, -0.03746705f, -0.00232314f, 0.02406253f, -0.00095167f, -0.01964318f, -0.03094072f, 
    0.02955930f, -0.02809984f, 0.03488721f, 0.00681510f, 0.01459404f, -0.03408941f, -0.02228732f, -0.02795965f, 
    -0.00305547f, -0.00051575f, -0.02443860f, -0.00950324f, -0.01233396f, -0.01901701f, -0.02941934f, 0.03188685f, 
    0.01279736f, 0.03143847f, 0.04138118f, -0.02420043f, 0.00839801f, -0.01154041f, 0.02976367f, 0.00076311f, 
    0.00619684f, -0.03007554f, -0.01493113f, -0.03880823f, 0.03287793f, 0.01413743f, -0.03207190f, -0.00759892f, 
    0.03629816f, 0.04097694f, -0.02208976f, -0.02314248f, -0.02467247f, -0.02574827f, 0.02608466f, 0.01720412f, 
    0.01772760f, 0.01836943f, 0.02112841f, -0.01142865f, 0.02302683f, -0.02112474f, -0.00013717f, 0.02066588f, 
    -0.03394251f, -0.02269124f, 0.02827679f, 0.00897393f, -0.01285515f, -0.01369325f, -0.02670514f, 0.00205818f, 
    0.01598364f, 0.01615125f, -0.01207428f, 0.03394172f, -0.02640519f, -0.01029998f, -0.03176003f, 0.02265843f, 
    -0.02675540f, 0.00936803f, 0.02156780f, -0.00030242f, -0.01486261f, 0.00377678f, -0.00755231f, 0.00153482f, 
    -0.00359591f, -0.00343170f, 0.01301482f, 0.00410272f, 0.00048391f, -0.00239064f, 0.00332957f, 0.00685104f, 
    0.00616803f, 0.00576028f, -0.00767280f, -0.02938382f, 0.01155027f, 0.01716013f, -0.03256845f, -0.01445748f, 
    -0.00967697f, 0.01283927f, 0.03273411f, 0.00504614f, -0.01417976f, 0.01403238f, -0.03247602f, 0.00398138f, 
    -0.00618084f, -0.03351138f, -0.01718634f, -0.00030574f, -0.00169599f, 0.00998127f, -0.01847363f, -0.03542227f, 
    0.02567608f, 0.01902799f, -0.02538378f, -0.03099804f, 0.01713421f, -0.00819928f, 0.04271488f, -0.01394519f, 
    -0.02298696f, -0.00182686f, 0.02896840f, 0.02383825f, 0.02292883f, -0.00265255f, 0.02954433f, -0.00501319f, 
    -0.00922603f, 0.02007341f, 0.00633857f, -0.02635599f, -0.01609416f, -0.00931054f, -0.01959864f, -0.02619768f, 
    0.01984571f, -0.00163283f, -0.00108254f, -0.02781515f, 0.00860411f, 0.00456192f, 0.02140931f, -0.00053034f, 
    0.03103779f, 0.01213956f, -0.01333716f, 0.01234820f, 0.04087089f, -0.02225616f, 0.02568383f, -0.00344338f, 
    -0.03428776f, -0.03794806f, 0.03388887f, -0.00072354f, 0.01793339f, -0.01105245f, -0.01932739f, -0.00004891f, 
    -0.03768197f, -0.01055748f, 0.02414714f, 0.03217379f, 0.02338157f, -0.00910649f, 0.02324793f, 0.01984883f, 
    -0.01554930f, -0.01089731f, 0.00963486f, -0.03397958f, -0.00372365f, -0.01036702f, 0.01086386f, -0.01508218f, 
    -0.03203781f, 0.02014501f, -0.01957395f, 0.00293201f, -0.00915540f, 0.03306275f, -0.02768335f, 0.01035987f, 
    -0.02426822f, 0.02240476f, -0.02839439f, 0.00675933f, -0.00621100f, 0.01311682f, -0.02427216f, 0.00869720f, 
    -0.04218286f, -0.03213893f, -0.01692685f, -0.00417465f, 0.01522091f, -0.00261759f, 0.00358605f, -0.00307268f, 
    0.00228400f, -0.02782111f, -0.02612286f, 0.00035347f, 0.00419746f, -0.03949030f, 0.03071726f, 0.02669374f, 
    0.02986486f, -0.02260732f, -0.00884374f, 0.01977358f, -0.01260125f, -0.03459736f, 0.00005477f, -0.01505400f, 
    -0.00772217f, -0.02503610f, -0.01082127f, -0.00741856f, 0.01262211f, -0.02214533f, -0.02308451f, -0.02831166f, 
    -0.00436518f, -0.02389500f, -0.01871633f, 0.00157906f, -0.00959311f, -0.03790652f, 0.00490248f, 0.00306902f, 
    -0.02925483f, -0.02634712f, 0.03096593f, -0.02758481f, -0.01181328f, -0.01226874f, -0.01408771f, -0.03611958f, 
    -0.02747936f, -0.00120414f, -0.03281140f, -0.00005976f, -0.00601483f, -0.00660596f, 0.03809908f, 0.03277742f, 
    0.02376554f, 0.00328510f, 0.02403720f, 0.01337313f, -0.02800568f, 0.00904384f, -0.00539718f, -0.02782476f, 
    -0.03793738f, -0.02287126f, -0.03220490f, -0.02281940f, -0.03830898f, 0.00603597f, 0.01852302f, 0.01066467f, 
    -0.00064805f, -0.01143785f, 0.02693981f, -0.02920310f, 0.00290794f, 0.02757299f, -0.03041439f, 0.00291392f, 
    -0.02469140f, 0.00152312f, -0.01878512f, -0.02667589f, -0.03157965f, -0.02645827f, -0.03246317f, -0.02736607f, 
    -0.00446846f, -0.00497091f, -0.00330322f, -0.03764746f, -0.02340744f, -0.01744537f, 0.02487807f, -0.03703026f, 
    -0.03233909f, -0.00289673f, 0.01255251f, 0.01411478f, 0.00587069f, 0.00508281f, 0.02822249f, -0.02553575f, 
    0.02933182f, -0.01720517f, 0.01779014f, -0.02004176f, -0.01382214f, -0.01986263f, -0.03607822f, -0.00050690f, 
    0.01810647f, -0.02464094f, 0.02279579f, -0.02275860f, -0.01905817f, 0.02002317f, 0.02865770f, 0.00428413f, 
    -0.01958986f, 0.01607237f, 0.01520991f, 0.01652747f, 0.02508031f, -0.02538555f, -0.02950060f, 0.01076005f, 
    0.00773077f, -0.00474898f, 0.02550586f, -0.00168966f, -0.01859164f, 0.01141263f, -0.01013360f, 0.01240199f, 
    0.00089294f, -0.02602359f, 0.01886515f, 0.01690447f, -0.02243127f, -0.01816890f, -0.03097026f, 0.01004561f, 
    -0.02284684f, -0.01939524f, -0.02770871f, -0.00288574f, 0.03231030f, 0.03121832f, -0.02648850f, 0.01328903f, 
    -0.02647719f, 0.01462021f, 0.02357037f, -0.01118561f, -0.01337301f, -0.00223739f, 0.02703760f, 0.01276256f, 
    0.00476389f, 0.03672578f, -0.00674001f, -0.02156917f, 0.02696506f, 0.01947839f, -0.03757987f, -0.02101633f, 
    -0.02639252f, 0.00581331f, -0.00515985f, 0.00809952f, -0.01077690f, -0.00499738f, -0.00855975f, -0.04130957f, 
    -0.03708098f, 0.00944366f, 0.02456256f, 0.02046932f, -0.01273969f, -0.02557725f, 0.03240810f, -0.00864026f, 
    -0.02563470f, 0.01470349f, 0.01817190f, 0.01911654f, -0.01591653f, 0.02041492f, -0.03490205f, 0.00859856f, 
    -0.03629323f, -0.01583524f, -0.03914294f, 0.01563283f, -0.04167552f, -0.00220779f, 0.01997338f, -0.01645772f, 
    0.03666215f, -0.03928956f, 0.02175153f, -0.03418612f, 0.01224822f, -0.01088037f, -0.01617340f, -0.00370702f, 
    0.04184032f, -0.02288858f, -0.03461452f, 0.04364860f, 0.03341162f, -0.03667210f, 0.00631950f, 0.00476899f, 
    0.02189337f, 0.01280258f, 0.03091237f, -0.00356979f, -0.00488969f, 0.01812958f, -0.00880016f, -0.03767489f, 
    -0.03953838f, -0.00994665f, 0.00113489f, -0.03784586f, 0.02632867f, -0.03079423f, -0.00647954f, -0.00576868f, 
    0.00893580f, 0.02990176f, 0.03039306f, -0.03476815f, -0.00767020f, 0.01653717f, 0.00353310f, -0.01610346f, 
    -0.04238211f, 0.00721009f, -0.00369070f, 0.00852327f, -0.04253606f, -0.00414644f, 0.03097004f, 0.00425320f, 
    0.03071701f, -0.01687603f, 0.01291200f, -0.00841166f, 0.04191748f, 0.00559525f, 0.00231783f, 0.03681920f, 
    -0.01336776f, 0.02612813f, -0.01721818f, 0.03188088f, -0.00520850f, -0.02686636f, -0.02687381f, 0.03176287f, 
    -0.00197448f, -0.00610766f, 0.01283423f, -0.03705446f, 0.01831765f, 0.00017971f, 0.03704851f, 0.01421795f, 
    0.00974928f, 0.02133584f, -0.01499189f, -0.02716345f, -0.00075170f, -0.01650951f, -0.01806842f, -0.00274683f, 
    -0.00068267f, 0.00347643f, 0.00897465f, -0.03185326f, 0.02005923f, 0.02930937f, -0.02612565f, -0.02101170f, 
    0.02363584f, 0.01602676f, 0.01380269f, 0.01541940f, -0.00242025f, -0.02966645f, -0.01857623f, -0.03815779f, 
    -0.01068334f, 0.01950909f, 0.02758598f, 0.02222861f, -0.01816971f, 0.00299781f, 0.03012552f, -0.03887295f, 
    0.02213078f, -0.00802783f, 0.03584569f, 0.01525564f, -0.00750551f, -0.00056124f, -0.00348145f, 0.01506508f, 
    0.02729109f, -0.02373890f, -0.02318490f, 0.00698661f, -0.01450625f, -0.02801331f, -0.02825899f, 0.01148935f, 
    0.03011595f, -0.02634136f, 0.01986055f, -0.00897956f, -0.00961128f, 0.00382825f, -0.00127401f, 0.00091920f, 
    -0.03717048f, 0.00150625f, -0.02327978f, 0.03700865f, -0.02729204f, -0.01971416f, -0.05401272f, -0.04222802f, 
    0.01318299f, -0.00787859f, 0.00030980f, -0.01942423f, -0.02715882f, -0.00374517f, 0.01410105f, 0.01968414f, 
    -0.03991865f, 0.01950055f, -0.02528181f, -0.01834986f, -0.02435789f, 0.00079662f, -0.00403753f, -0.01443402f, 
    0.01348990f, -0.02767934f, 0.00340694f, -0.03073914f, -0.03654480f, -0.01442471f, -0.03467186f, -0.01570675f, 
    -0.03738066f, -0.04533374f, -0.00588596f, -0.03031413f, 0.00569558f, 0.00495454f, 0.01670922f, -0.03151598f, 
    0.00081430f, -0.03061738f, -0.04104588f, 0.00443399f, -0.03316814f, 0.00187770f, -0.03487195f, 0.00977906f, 
    -0.02980150f, -0.00623675f, -0.02753547f, -0.01343081f, 0.02490105f, -0.01052189f, 0.00268045f, 0.00399079f, 
    -0.04315951f, -0.02315933f, 0.00781405f, 0.02979151f, -0.02989048f, -0.04642978f, -0.01670045f, -0.02505487f, 
    -0.01912332f, -0.03617947f, 0.02663851f, 0.01989171f, -0.01195720f, -0.00761405f, 0.00351126f, 0.00250577f, 
    0.01531588f, 0.01996910f, -0.02140329f, -0.01909963f, -0.02908439f, -0.00458617f, 0.02248865f, -0.01965665f, 
    -0.01090378f, -0.00673455f, 0.01889730f, 0.00030327f, -0.03954631f, 0.00153250f, -0.00478710f, 0.02184708f, 
    0.02244707f, -0.02917559f, -0.00048252f, 0.02866095f, 0.01527263f, 0.01270600f, -0.03570018f, 0.01626567f, 
    -0.00260319f, 0.01846099f, -0.02252915f, -0.03636884f, 0.00765314f, -0.02246961f, 0.01733300f, 0.01599453f, 
    0.00744720f, 0.00507326f, -0.00370984f, -0.00986356f, 0.01162473f, 0.01615296f, 0.02346535f, -0.01267768f, 
    -0.00936476f, -0.01350838f, 0.02274962f, -0.03056244f, 0.00078743f, -0.00003156f, -0.03820609f, 0.01769386f, 
    -0.03988404f, -0.00026076f, 0.01305903f, -0.02221311f, -0.03742633f, -0.02002017f, 0.00059002f, 0.01634508f, 
    -0.01040885f, -0.01521551f, -0.03681030f, 0.01136079f, 0.03366052f, 0.00027555f, -0.04094701f, -0.00327193f, 
    -0.03771111f, -0.00920046f, -0.00267901f, -0.02447616f, -0.01405756f, -0.02588908f, -0.01839639f, 0.02717089f, 
    -0.01115720f, -0.03636253f, -0.00954846f, -0.02276478f, -0.02841938f, 0.01897470f, -0.02343706f, -0.03755855f, 
    -0.03415237f, 0.00324984f, -0.01838573f, -0.00782236f, -0.02574905f, -0.03879817f, -0.04881286f, 0.00939641f, 
    0.02028093f, -0.02463286f, 0.02989035f, 0.00048025f, 0.00310599f, -0.01841710f, -0.00137071f, -0.03352241f, 
    -0.03256120f, 0.01173504f, -0.00635506f, 0.02267378f, -0.01789581f, -0.04729351f, -0.02098886f, -0.00316493f, 
    -0.01839010f, 0.02076407f, 0.01902059f, -0.03336348f, -0.00475941f, 0.01330356f, 0.02402838f, -0.01384435f, 
    -0.00165554f, -0.01436879f, 0.03014585f, -0.01122124f, -0.02704456f, -0.01067692f, -0.00580974f, 0.00049570f, 
    -0.03687176f, 0.00112566f, -0.02627800f, -0.01945285f, -0.01086319f, -0.01183878f, 0.01988425f, -0.02903937f, 
    -0.02847633f, -0.00527936f, -0.00331928f, -0.02300598f, 0.02008093f, -0.00436930f, -0.04480729f, -0.01259532f, 
    -0.02767019f, 0.02304334f, -0.04084588f, 0.00074603f, -0.04751301f, -0.03942606f, 0.01235698f, -0.04580874f, 
    0.00744827f, -0.00704897f, -0.01826556f, 0.02896053f, -0.01281311f, -0.03350490f, 0.01843233f, -0.04300467f, 
    -0.03394478f, 0.01197656f, -0.04855759f, -0.03224772f, -0.03104911f, -0.00661633f, -0.04303670f, -0.00841904f, 
    -0.00773346f, -0.02399803f, -0.03765006f, -0.03264344f, -0.00041838f, 0.02131950f, -0.01502400f, -0.04159114f, 
    -0.01777913f, 0.01188078f, -0.02796455f, -0.03403645f, -0.04130984f, -0.04900764f, -0.02305722f, -0.04074767f, 
    -0.02565650f, -0.01873117f, -0.02994497f, -0.02713772f, -0.03742838f, -0.00861616f, -0.02144345f, -0.04276864f, 
    -0.00564829f, -0.03022213f, -0.02218040f, 0.01369509f, -0.02530869f, -0.00882522f, -0.01656732f, -0.02002049f, 
    -0.00626458f, -0.00782962f, -0.01832036f, -0.04074558f, 0.00472717f, -0.01932591f, -0.00334977f, -0.03922555f, 
    -0.00652978f, -0.02391421f, -0.00858909f, -0.04179668f, 0.01235375f, -0.02957712f, -0.01653496f, 0.00976484f, 
    -0.03483636f, 0.01359415f, 0.01527676f, -0.03617348f, 0.00003858f, 0.02424791f, -0.02079116f, -0.02819695f, 
    -0.00954817f, 0.00132039f, 0.01915676f, -0.03651079f, -0.03696664f, -0.03540469f, -0.00299150f, -0.01541235f, 
    -0.02502102f, -0.01084973f, -0.02060333f, 0.01042186f, -0.00582504f, 0.01596423f, 0.02028812f, -0.00908861f, 
    -0.04474465f, 0.00825200f, -0.04466000f, -0.00526840f, 0.02013045f, 0.01148805f, -0.03719641f, -0.02471066f, 
    -0.00686054f, 0.02289427f, -0.03755650f, -0.02129856f, -0.02110593f, -0.01187185f, -0.02253400f, -0.00436033f, 
    -0.03885723f, 0.00920166f, 0.02243399f, -0.03433686f, -0.00052879f, -0.03123696f, -0.03834559f, -0.04143831f, 
    -0.03905334f, -0.02534171f, -0.00091325f, -0.00669733f, -0.01721758f, -0.03806308f, 0.01084893f, -0.04229013f, 
    0.00338851f, -0.01806999f, -0.02102715f, -0.01695694f, 0.01768906f, 0.00149073f, -0.00401628f, -0.03336411f, 
    0.00713205f, 0.00385012f, 0.02674756f, -0.00744738f, -0.04548067f, -0.00913756f, -0.00802384f, -0.01335706f, 
    -0.00729662f, 0.02256789f, -0.05182908f, 0.00962556f, 0.00317361f, 0.02376804f, -0.02440502f, -0.00663584f, 
    0.02170248f, 0.02749952f, 0.02588550f, -0.03064957f, 0.02569979f, 0.02697199f, 0.01495195f, 0.02625602f, 
    -0.00040339f, -0.01397671f, -0.01419970f, -0.01045689f, -0.04203366f, -0.03315262f, 0.00542809f, -0.00663305f, 
    0.02645108f, 0.01119977f, 0.02851525f, 0.00097357f, -0.03533375f, -0.01025387f, 0.01817219f, 0.01614904f, 
    0.00713397f, 0.00612776f, 0.02000340f, 0.01113529f, -0.00608776f, -0.04047593f, -0.03023158f, -0.02837062f, 
    -0.00714034f, -0.04347817f, 0.02280437f, -0.00224551f, 0.01594438f, 0.01557556f, -0.03583323f, 0.01957488f, 
    -0.03942087f, -0.01938736f, 0.01750871f, -0.03694405f, -0.01820911f, -0.02268404f, -0.01840218f, 0.00162262f, 
    -0.03656851f, -0.00899757f, -0.01179169f, -0.00369608f, 0.02561840f, -0.01281778f, -0.01910781f, 0.00565366f, 
    0.00984435f, -0.02603563f, -0.05299609f, -0.01557825f, 0.01290238f, 0.00640940f, -0.02635189f, -0.03872891f, 
    0.00903942f, -0.01157659f, -0.02848656f, 0.02891137f, -0.00453927f, -0.02991883f, -0.02649010f, -0.01418441f, 
    0.00223686f, -0.02327849f, -0.04275393f, -0.02736217f, 0.00567997f, 0.02951003f, -0.02308187f, -0.00484216f, 
    -0.01423967f, 0.00578554f, -0.00843663f, 0.02429597f, 0.01607782f, -0.04339864f, -0.01790829f, -0.02466930f, 
    -0.05144598f, -0.02353050f, 0.01701595f, 0.02323716f, 0.02252511f, -0.00756410f, -0.00192372f, -0.01234511f, 
    0.02624224f, -0.00174629f, 0.00426589f, 0.00934766f, 0.00798568f, -0.01753739f, 0.00323661f, -0.03026708f, 
    -0.03310947f, -0.00287620f, -0.03296346f, 0.02191570f, -0.02062642f, -0.03818996f, 0.02830433f, 0.01485558f, 
    -0.00399057f, 0.00196252f, 0.00458126f, -0.02085389f, 0.01012880f, -0.01601421f, -0.00989833f, 0.02579838f, 
    -0.02700609f, 0.00203010f, -0.01749136f, -0.02967549f, -0.00922876f, -0.04790599f, -0.01058307f, -0.02612078f, 
    0.00378908f, -0.04436433f, -0.05018560f, -0.04357099f, -0.03572121f, -0.03270780f, -0.02927542f, -0.01945928f, 
    0.00529925f, 0.01478921f, -0.04701538f, 0.02703346f, 0.02637395f, -0.02053288f, -0.02758896f, 0.00193312f, 
    -0.03790294f, -0.00039179f, -0.01313933f, -0.00601451f, -0.02007614f, 0.02013345f, -0.00014636f, -0.00876953f, 
    0.01123820f, -0.02716978f, 0.01167858f, 0.01155551f, 0.03806122f, 0.01622440f, -0.01485936f, -0.02234796f, 
    -0.02609765f, 0.02329243f, -0.01170608f, 0.00426856f, -0.02398162f, -0.03767481f, -0.00507970f, -0.02338195f, 
    0.00832817f, -0.01222204f, 0.00466301f, -0.01332953f, -0.01123763f, -0.02393590f, -0.03670388f, -0.00216043f, 
    -0.03415157f, -0.02308161f, 0.00524306f, -0.02636408f, 0.01554123f, -0.04008325f, 0.03506287f, -0.01884340f, 
    -0.03087079f, -0.05170745f, -0.02913358f, -0.04737416f, -0.00493524f, -0.01071252f, 0.00638554f, -0.03357496f, 
    0.01945117f, 0.00805910f, -0.03166486f, 0.02846548f, -0.02656189f, 0.00771634f, 0.00479433f, 0.00923610f, 
    -0.04220755f, -0.02665120f, -0.02586942f, 0.00737516f, -0.00112595f, -0.02140916f, 0.02094598f, -0.02266265f, 
    0.00840890f, -0.04381149f, -0.03166057f, -0.02624853f, 0.03254947f, 0.00697225f, -0.02187201f, 0.01731451f, 
    -0.02546687f, -0.02508511f, 0.00290996f, -0.02847435f, 0.01664427f, -0.04060295f, 0.01932693f, -0.00190529f, 
    -0.01823965f, -0.02956741f, -0.02577911f, -0.01291853f, -0.02595584f, -0.03952105f, 0.00988222f, 0.00847894f, 
    -0.00921671f, 0.03171539f, -0.00105428f, -0.01544671f, -0.02366493f, -0.00263630f, -0.04758434f, -0.05012412f, 
    -0.02328796f, -0.02077774f, 0.01788578f, -0.00985616f, 0.02342415f, -0.01029778f, 0.02909264f, 0.02023952f, 
    -0.00101277f, 0.02591345f, -0.00414793f, 0.00007905f, -0.02770098f, -0.03252890f, -0.02360643f, -0.00971686f, 
    0.01043796f, 0.01056247f, 0.01764411f, -0.03421292f, 0.00171199f, 0.01803968f, -0.04378442f, -0.03838693f, 
    -0.04574329f, -0.02499302f, -0.03660701f, 0.01336034f, 0.00320363f, 0.01179913f, -0.04641875f, 0.00980343f, 
    -0.00180817f, -0.01633097f, 0.01737979f, -0.02396556f, -0.05054264f, 0.01171379f, -0.01635355f, -0.00077982f, 
    0.00282858f, 0.00761303f, 0.01297043f, -0.04031988f, -0.02586581f, 0.00436151f, -0.02382291f, 0.01285575f, 
    -0.01294279f, -0.01641295f, 0.02459111f, -0.01710560f, -0.03023194f, -0.03884773f, -0.01542594f, -0.01882415f, 
    -0.03592401f, -0.02600273f, -0.00819051f, -0.00326603f, -0.02747583f, -0.00042757f, -0.02210394f, -0.04512558f, 
    0.03026020f, 0.01033243f, -0.01980167f, -0.04454065f, -0.05135449f, -0.02763969f, 0.01817907f, 0.01929661f, 
    -0.00986751f, -0.01925694f, -0.01723221f, -0.01967888f, -0.04238927f, -0.02716501f, -0.03364591f, -0.02252565f, 
    -0.05506570f, -0.00094046f, -0.03741888f, 0.01871732f, -0.01244317f, -0.03126203f, -0.02243512f, -0.01554783f, 
    0.00432541f, -0.01886415f, 0.01414440f, 0.02752304f, -0.00042366f, -0.01254393f, 0.02574532f, 0.01609711f, 
    0.01102160f, 0.00777832f, -0.01479771f, -0.01467558f, 0.02636876f, 0.01060626f, 0.01625128f, -0.01452008f, 
    0.02531905f, -0.04509988f, 0.01972249f, -0.04308736f, 0.02313158f, 0.01228861f, 0.02158321f, 0.00098536f, 
    -0.00043698f, -0.03286057f, -0.00333223f, -0.00063461f, -0.02707915f, -0.03803729f, -0.03481868f, 0.00488161f, 
    -0.04260934f, -0.02802099f, -0.03693293f, -0.03740279f, -0.02573748f, 0.00938390f, -0.03646559f, -0.00555315f, 
    -0.01222942f, -0.04592577f, 0.02727786f, -0.00279005f, 0.01488632f, -0.02374382f, 0.01677054f, -0.00393354f, 
    0.02681836f, 0.02357895f, -0.02423802f, -0.03311285f, -0.00336699f, -0.02399791f, 0.00278045f, -0.02279709f, 
    -0.04328778f, -0.04485592f, -0.04568510f, -0.01659967f, -0.02402395f, -0.02798660f, 0.02962745f, -0.02757909f, 
    -0.00886973f, -0.04689462f, -0.00382672f, 0.01482595f, -0.03393243f, 0.02876850f, -0.01555653f, -0.04797186f, 
    0.01045626f, -0.01466111f, -0.02899885f, -0.01072778f, -0.04643276f, 0.00342961f, 0.00443528f, -0.00106103f, 
    0.07691067f, -0.14223848f, -0.01054352f, -0.00700283f, -0.14214210f, 0.01344777f, -0.00275308f, 0.13821384f, 
    -0.06487709f, 0.03858755f, -0.03937416f, 0.20110816f, 0.17975749f, 0.21085881f, -0.12616231f, -0.00130376f, 
    -0.10012214f, 0.21473862f, 0.00520610f, 0.07979199f, 0.15062569f, -0.03589660f, -0.00893446f, -0.01098629f, 
    0.20476307f, 0.12269008f, 0.04391821f, 0.00196928f, 0.03027747f, 0.15768301f, -0.01089256f, 0.15447329f, 
    0.01032946f, 0.02699218f, 0.01464354f, -0.20963797f, -0.24415268f, 0.08634176f, 0.30521283f, 0.05577922f, 
    0.02027578f, -0.08499113f, -0.06754121f, -0.06261182f, 0.08601636f, 0.13530056f, -0.01880519f, 0.17891990f, 
    0.09865797f, 0.35924920f, 0.13257620f, -0.13274692f, -0.13965257f, -0.14574778f, -0.09503700f, 0.02148111f, 
    -0.03367813f, 0.01185384f, -0.01817333f, 0.13212030f, 0.27322057f, -0.11181123f, -0.08038283f, 0.01581572f, 
    0.08964474f, 0.09819713f, 0.10350268f, 0.23062982f, -0.02820053f, 0.14934687f, 0.09990701f, 0.02282660f, 
    -0.10422454f, 0.44320583f, 0.36848506f, 0.38992557f, 0.18303321f, -0.03267549f, 0.02987099f, -0.32060516f, 
    -0.11283122f, -0.23116575f, -0.06750874f, 0.11121178f, 0.16781497f, 0.27534625f, 0.10377502f, -0.02682171f, 
    -0.05080668f, 0.15211642f, -0.05315655f, 0.06801283f, 0.06842969f, 0.01211027f, -0.04609130f, -0.14920147f, 
    0.16032140f, 0.32702130f, 0.19447888f, -0.12298257f, -0.16490960f, -0.04138039f, -0.05869881f, -0.06811266f, 
    -0.01460267f, 0.01626168f, 0.03846132f, -0.11692975f, 0.29874015f, 0.52414745f, 0.14453594f, -0.07092728f, 
    -0.08407807f, -0.13475683f, 0.04448798f, -0.07807469f, 0.03511876f, 0.09693432f, 0.04044867f, -0.04254154f, 
    0.15600422f, 0.17513379f, -0.06303432f, -0.22165965f, -0.21042600f, 0.13012041f, 0.15382308f, 0.19341476f, 
    0.08088790f, -0.17589208f, -0.05784273f, -0.04689629f, 0.05152885f, -0.00717436f, 0.41567132f, 0.05834903f, 
    -0.12560742f, 0.08674972f, -0.17655921f, 0.14936419f, -0.05616087f, 0.03517190f, -0.05889332f, 0.01019855f, 
    -0.59713417f, -0.08072416f, 0.00352206f, 0.13501300f, -0.02524323f, -0.02310794f, 0.27799720f, -0.00819366f, 
    0.01941204f, -0.02026808f, -0.11743868f, 0.00974471f, -0.05195048f, 0.52278978f, 0.06427443f, -0.02850890f, 
    -0.04925034f, -0.08430577f, 0.00222218f, -0.05073733f, -0.09469659f, -0.11529294f, -0.07556827f, 0.06675564f, 
    -0.32701412f, 0.03731176f, 0.07673393f, -0.34075707f, 0.05651746f, -0.03752990f, 0.16836813f, -0.20568742f, 
    0.04989700f, -0.09151635f, 0.08204810f, 0.27510014f, 0.00474043f, 0.05504521f, 0.11851920f, -0.14983153f, 
    -0.08221892f, 0.14103171f, 0.05284299f, 0.11936793f, 0.17577651f, -0.11916277f, 0.09395199f, -0.08410351f, 
    0.04894264f, 0.10713875f, 0.19413857f, -0.08556408f, 0.19729929f, -0.06709290f, 0.08424346f, -0.03511811f, 
    -0.12369778f, 0.03501179f, -0.00491369f, 0.07006966f, -0.40140703f, -0.12016416f, 0.13928963f, 0.04469770f, 
    0.20540278f, -0.04270589f, 0.21326894f, -0.02085852f, 0.04971091f, -0.08970159f, -0.15738648f, 0.01032703f, 
    0.14215896f, -0.29199988f, 0.26093796f, -0.12275766f, -0.03815996f, 0.03687343f, 0.09758715f, 0.02074080f, 
    -0.12658890f, 0.17099631f, 0.02280505f, 0.09337224f, 0.17440739f, 0.00175760f, -0.16918238f, 0.04195652f, 
    0.06312571f, -0.01166760f, 0.10285665f, -0.03040086f, -0.07935561f, 0.08777093f, -0.04572612f, -0.10473098f, 
    -0.19771509f, -0.21513066f, 0.29586664f, 0.08439275f, -0.07763690f, 0.13041720f, -0.05400112f, 0.01953059f, 
    0.05490585f, -0.02698828f, 0.01238586f, 0.22041094f, -0.08655047f, 0.09699663f, 0.29537308f, -0.30307528f, 
    -0.04076167f, -0.19855495f, -0.10297361f, -0.01570083f, 0.04157503f, 0.15857157f, 0.03213631f, 0.00784942f, 
    0.24441274f, 0.14860070f, -0.12112860f, -0.04468581f, 0.01123954f, 0.01000241f, 0.14576013f, 0.24264799f, 
    -0.03689430f, -0.13001293f, -0.12782066f, -0.09368183f, -0.00048969f, -0.02320551f, 0.06395175f, -0.03135326f, 
    -0.02141842f, 0.07359920f, 0.01603903f, 0.00807643f, 0.12134529f, -0.05609249f, 0.06351951f, -0.03191924f, 
    0.41458857f, 0.41691974f, 0.14453591f, 0.14327961f, -0.07644664f, -0.09779137f, -0.07807253f, 0.00870036f, 
    -0.07943565f, -0.10113946f, -0.00960125f, -0.02393161f, 0.09869420f, 0.00547413f, 0.01672363f, 0.11324340f, 
    -0.01925834f, 0.11334239f, 0.04404350f, -0.05511083f, -0.02091245f, 0.08114514f, 0.01906621f, -0.05345800f, 
    -0.10320730f, 0.53113097f, 0.06527960f, -0.14210288f, 0.06061988f, -0.17855538f, -0.09806748f, 0.18862860f, 
    0.00990811f, 0.08704666f, 0.11673009f, -0.09846518f, -0.00377582f, -0.06891001f, -0.00903443f, 0.21570471f, 
    -0.15368375f, 0.04366554f, -0.05838267f, 0.01156751f, 0.06231715f, -0.05680696f, -0.10318768f, 0.15085427f, 
    -0.08056979f, -0.11556166f, 0.08662380f, -0.02988032f, -0.00963185f, 0.12027117f, 0.00021637f, -0.07144546f, 
    0.14767101f, 0.01193366f, 0.06955524f, 0.25635815f, -0.42847860f, 0.31584743f, 0.23480771f, 0.11150458f, 
    0.18574356f, 0.08502407f, -0.07816352f, -0.22952688f, -0.12775788f, 0.04881104f, -0.16306211f, -0.05326511f, 
    0.27890825f, 0.28162366f, 0.22186992f, 0.02642236f, -0.14588228f, -0.00544719f, 0.00966934f, -0.03138574f, 
    -0.04889797f, -0.14634538f, 0.02166098f, -0.02877710f, 0.19967453f, 0.22109930f, -0.24542581f, 0.03976284f, 
    -0.03567383f, 0.14804377f, 0.11006878f, -0.13607526f, 0.14751470f, -0.09298950f, -0.11357180f, -0.10619616f, 
    0.16346513f, 0.19659819f, 0.08531075f, -0.43014950f, -0.03870934f, -0.17233467f, 0.07638900f, 0.00077279f, 
    -0.20151417f, -0.23837003f, -0.18884781f, 0.02412152f, 0.21201359f, 0.11324777f, 0.12858228f, -0.13261302f, 
    -0.05749628f, -0.11720832f, -0.00920738f, 0.15363975f, -0.05408824f, 0.15359935f, 0.09283017f, 0.06268951f, 
    -0.02473155f, 0.06001127f, 0.22594072f, 0.50161487f, 0.08093048f, 0.17770283f, -0.00657590f, -0.07969771f, 
    -0.00115526f, -0.15073431f, -0.12447020f, -0.09620930f, 0.21362141f, 0.22732784f, 0.07160372f, -0.22284709f, 
    -0.02119006f, 0.03064998f, -0.12693000f, 0.44446275f, -0.07105773f, -0.05501898f, 0.00900006f, -0.01861799f, 
    -0.01900123f, 0.02487765f, -0.13940607f, 0.36330321f, 0.02362594f, -0.03604894f, 0.00491327f, 0.12606351f, 
    -0.10535811f, 0.00216291f, 0.13669670f, 0.13750580f, -0.09164868f, -0.09402147f, -0.12405381f, 0.16025595f, 
    -0.10415462f, 0.06003683f, 0.09788645f, -0.15788871f, 0.19206400f, 0.05413200f, -0.13753901f, 0.13561785f, 
    -0.13887332f, 0.09498291f, -0.01716904f, 0.07756923f, 0.11211615f, 0.31235400f, 0.19796479f, -0.18721496f, 
    0.10504771f, -0.00144875f, 0.06943663f, -0.22804564f, -0.05778147f, -0.02551395f, 0.28122842f, -0.14564151f, 
    0.04063838f, -0.01625800f, -0.06952957f, 0.19774295f, 0.01251406f, 0.01020796f, -0.00688097f, -0.10938179f, 
    0.22812653f, -0.15211196f, 0.02978349f, 0.07572683f, -0.12091681f, 0.03719761f, 0.03764503f, 0.13296521f, 
    -0.09990048f, -0.02706938f, -0.06971071f, 0.02629532f, 0.03696538f, -0.15279913f, 0.01488123f, 0.03242866f, 
    -0.04237043f, -0.01136078f, 0.04451646f, 0.05955663f, 0.04364223f, 0.03290894f, 0.10797906f, 0.25094369f, 
    0.20203951f, 0.20253675f, 0.21399237f, -0.37176093f, -0.01036988f, 0.15090682f, 0.02907862f, -0.06180811f, 
    -0.13304740f, -0.11351004f, -0.19644605f, -0.12321009f, -0.00695774f, 0.00085793f, -0.04805165f, -0.00941842f, 
    0.01260513f, 0.06443087f, 0.09634473f, 0.27099761f, -0.06016829f, -0.10406832f, -0.04029530f, -0.11940777f, 
    0.05852228f, -0.22675034f, -0.10253764f, -0.02587048f, -0.08527794f, 0.09528721f, -0.03403628f, 0.12375817f, 
    -0.01517305f, 0.12084516f, -0.15208729f, -0.04777435f, -0.13295174f, -0.10938256f, 0.17244895f, 0.00254721f, 
    -0.03790011f, 0.05158349f, 0.00399891f, 0.10555826f, 0.18083367f, -0.08924833f, 0.02591714f, 0.11443406f, 
    0.11580018f, -0.09601512f, 0.22801907f, -0.08276154f, -0.01941902f, -0.03520706f, -0.02334156f, 0.10328284f, 
    0.10833278f, 0.03135447f, 0.11397715f, 0.24368523f, -0.32118350f, 0.29077426f, 0.30395114f, -0.23899511f, 
    -0.07127699f, -0.02432377f, -0.15759556f, -0.09720023f, 0.07846780f, 0.00482658f, 0.09610799f, 0.10042397f, 
    0.21308729f, 0.25145471f, 0.01735584f, -0.05872757f, 0.12602144f, 0.29409194f, 0.09211889f, 0.23663995f, 
    -0.01383757f, 0.04905257f, 0.01816740f, 0.01649738f, 0.11086710f, 0.52798015f, 0.04489893f, -0.02514526f, 
    -0.08082872f, -0.05632579f, 0.05398026f, 0.09172390f, -0.00371548f, -0.08111433f, 0.05030447f, -0.04673568f, 
    0.28226784f, -0.22917372f, 0.09000918f, -0.24338926f, 0.12361840f, 0.23352340f, -0.00759106f, 0.19225956f, 
    0.13302436f, -0.10935716f, -0.04088920f, -0.05542467f, 0.02858250f, -0.37874973f, 0.27963519f, 0.24364041f, 
    -0.06364494f, 0.07672966f, -0.13901833f, 0.06431050f, 0.23596916f, -0.03745086f, 0.03867466f, 0.21772543f, 
    0.15422229f, 0.25079763f, 0.09425907f, 0.24639867f, -0.19321290f, -0.19842306f, -0.03483021f, -0.16056289f, 
    -0.00612424f, 0.02662599f, -0.09104728f, -0.11550110f, 0.00371819f, -0.05182693f, -0.10500754f, -0.11030082f, 
    -0.08342315f, 0.05934565f, 0.05508741f, 0.03510791f, 0.19429302f, 0.05969642f, 0.10056862f, 0.05108784f, 
    0.56600934f, 0.11848167f, 0.10474262f, 0.06290889f, -0.02250627f, -0.02658370f, -0.28127745f, 0.08920006f, 
    -0.05808069f, 0.11066381f, 0.03918755f, -0.14352594f, -0.20210811f, -0.15623322f, 0.05076611f, 0.11968226f, 
    0.05298949f, 0.06530669f, 0.11756788f, 0.01700349f, -0.03209089f, -0.08904838f, -0.12327359f, -0.06952104f, 
    -0.31157753f, 0.23248670f, -0.03579279f, 0.25093406f, 0.01418277f, 0.22664340f, -0.03957982f, -0.03545303f, 
    -0.03884327f, -0.15706462f, -0.02989238f, 0.02737970f, 0.18937397f, 0.22589257f, 0.03381512f, -0.09846865f, 
    -0.15665965f, -0.07732270f, 0.07289781f, 0.37857276f, 0.06442241f, 0.03854811f, 0.05913126f, -0.09308437f, 
    0.15241285f, -0.11799480f, 0.17423531f, -0.44008613f, -0.20080413f, -0.13340347f, -0.03099406f, 0.01045374f, 
    -0.07025256f, 0.00147004f, -0.03647406f, -0.07620660f, 0.35406938f, 0.02857932f, 0.15305002f, -0.12083980f, 
    0.06255968f, -0.02913009f, -0.17244199f, 0.12765311f, 0.02939948f, 0.03530788f, -0.07982620f, 0.01093266f, 
    -0.11842673f, -0.06767540f, 0.05872364f, 0.09732100f, -0.04328992f, 0.07168891f, -0.05723067f, -0.02027678f, 
    0.03573984f, -0.07922866f, -0.03547152f, -0.00093193f, -0.10901560f, 0.25291908f, 0.41490698f, -0.29072109f, 
    0.10825852f, 0.03384257f, -0.01579463f, -0.10186086f, -0.03696577f, -0.02992573f, 0.13602369f, 0.13235429f, 
    0.04274576f, -0.09263163f, 0.26553893f, -0.55391067f, -0.02123441f, 0.04613592f, 0.12499836f, 0.02164283f, 
    -0.09802923f, -0.10397441f, -0.07750781f, -0.09003884f, 0.05111234f, 0.12071814f, -0.24442244f, -0.05331697f, 
    0.21475339f, -0.25737667f, 0.08591193f, 0.03993116f, 0.13242945f, 0.08056896f, 0.05026956f, 0.04815840f, 
    -0.01220697f, 0.03739645f, 0.00936847f, -0.02277896f, -0.03898478f, 0.00193783f, -0.02858197f, 0.00467933f, 
    0.02771376f, -0.02021593f, -0.01618841f, 0.03326668f, -0.02820043f, 0.02156040f, 0.00123060f, 0.00214183f, 
    -0.00721943f, 0.02631401f, 0.01244886f, -0.00251302f, 0.00400160f, 0.00256317f, 0.01062013f, -0.00861523f, 
    0.00377865f, -0.01367244f, 0.01349300f, 0.01674588f, -0.02728199f, 0.01742446f, -0.01167636f, -0.00887042f, 
    -0.00161133f, -0.00071345f, -0.00421097f, -0.00513078f, -0.01968754f, -0.01902414f, 0.01415448f, -0.00252520f, 
    -0.00272248f, -0.02770579f, -0.02995852f, 0.01690051f, 0.00808292f, 0.00754086f, 0.01203959f, -0.01064979f, 
    0.02432666f, -0.01861388f, -0.04135766f, -0.00497666f, 0.00286181f, 0.01086655f, -0.03853440f, -0.02635054f, 
    -0.00178590f, 0.01214466f, 0.00791376f, 0.00042476f, 0.02121178f, -0.01747419f, -0.00839989f, 0.01934169f, 
    -0.01983282f, 0.02363158f, -0.01873526f, -0.01820882f, -0.00209061f, 0.01199812f, -0.04350773f, -0.00928347f, 
    0.01177606f, 0.01736582f, -0.02620679f, -0.01682637f, 0.01348545f, 0.02510926f, -0.00007816f, -0.03455711f, 
    0.03036122f, 0.00608182f, -0.00695130f, 0.01623775f, 0.02072551f, 0.01168350f, -0.01379560f, -0.01394963f, 
    0.03117147f, 0.02644939f, -0.01435190f, -0.03226084f, -0.03775176f, 0.02969169f, -0.02134734f, 0.01439135f, 
    0.02134174f, -0.03910966f, -0.02836534f, -0.04599092f, -0.01720701f, 0.00440443f, 0.01135902f, 0.04037299f, 
    -0.01490248f, 0.03194517f, -0.02762618f, 0.02038573f, 0.04254782f, -0.02333419f, 0.00113337f, -0.01018792f, 
    -0.03574130f, -0.01948044f, -0.01370706f, -0.02491201f, 0.03001490f, -0.03217961f, -0.03318856f, 0.01207538f, 
    0.02564068f, 0.01334142f, -0.00331960f, 0.03101088f, 0.02809294f, -0.02396787f, -0.00836242f, 0.02388564f, 
    -0.03762385f, -0.03928147f, -0.02263520f, -0.00566982f, -0.00991227f, 0.00850723f, 0.02563539f, 0.02059669f, 
    -0.00104063f, -0.03659314f, 0.01094880f, -0.02712575f, 0.00480997f, -0.04373218f, 0.01828109f, -0.03355170f, 
    0.00263337f, -0.03082136f, 0.00746652f, -0.04077488f, 0.01360350f, -0.01055813f, 0.00821381f, -0.04062409f, 
    -0.03053163f, -0.00960368f, -0.04122393f, -0.00254335f, 0.00119303f, -0.01474713f, -0.02154838f, 0.00024355f, 
    0.01046010f, 0.02959813f, -0.01646142f, -0.00893291f, -0.02343761f, 0.00351192f, 0.01598349f, -0.03260119f, 
    0.00011254f, 0.02904673f, -0.03460488f, -0.00910685f, 0.01401595f, -0.00615033f, -0.02186042f, 0.01048483f, 
    -0.02436571f, -0.03206121f, 0.01819396f, 0.00110698f, 0.03639716f, -0.01690483f, -0.01707548f, -0.03345113f, 
    -0.00863331f, -0.02500009f, -0.03605734f, 0.01849990f, 0.02335209f, -0.00183409f, 0.00289187f, -0.02388976f, 
    0.00705171f, -0.00534332f, -0.02510368f, 0.01061801f, -0.04263071f, -0.02089643f, 0.03268025f, -0.03322047f, 
    -0.01577951f, -0.01878576f, -0.03541842f, -0.00432955f, 0.00668029f, 0.01601306f, -0.03072565f, 0.01296273f, 
    0.02238110f, 0.02475397f, -0.03500485f, -0.02233254f, 0.01400214f, -0.00131995f, -0.02591616f, -0.00035004f, 
    0.01378737f, -0.00408000f, 0.00924711f, 0.00744727f, 0.01501229f, 0.00857770f, 0.01075216f, -0.03301710f, 
    -0.02232613f, 0.00058951f, 0.02816851f, -0.02734453f, -0.01543824f, 0.01748578f, -0.02403316f, -0.03419438f, 
    0.01416542f, -0.01781524f, -0.02119081f, 0.00559297f, -0.01529301f, 0.01090171f, -0.00242829f, -0.02238975f, 
    0.03042227f, -0.03912066f, -0.01944584f, -0.02289720f, -0.04128095f, -0.00952410f, -0.01799218f, 0.02625965f, 
    0.01679492f, 0.00183580f, -0.00570756f, 0.03075691f, 0.00523441f, 0.01927136f, 0.01648558f, 0.01615631f, 
    -0.02978377f, -0.00438452f, -0.02313092f, -0.03544429f, -0.01158529f, -0.01493398f, -0.02138295f, -0.02335233f, 
    0.00180339f, 0.03470273f, 0.00328141f, -0.01482284f, -0.02772496f, -0.01572124f, 0.02036187f, -0.03134790f, 
    0.00283503f, -0.02219695f, -0.02455250f, -0.00964511f, -0.04110407f, -0.02797749f, -0.01452996f, -0.04364879f, 
    -0.01475483f, -0.01504160f, 0.02731406f, -0.02165342f, 0.00571586f, -0.01813271f, 0.01454049f, 0.01617805f, 
    -0.00176364f, 0.00901803f, -0.03299693f, -0.01011250f, 0.00598526f, -0.02671189f, -0.01828009f, -0.02803550f, 
    -0.01878415f, 0.02164823f, 0.03305762f, -0.01444998f, 0.00704874f, -0.02862687f, -0.00420429f, -0.04080435f, 
    0.01491228f, 0.01122893f, -0.00023849f, 0.02267308f, 0.03090075f, 0.01026996f, -0.00561625f, -0.01534950f, 
    -0.02226098f, -0.00574205f, 0.03769495f, 0.01896340f, 0.01447939f, -0.00106187f, 0.01548068f, 0.01531616f, 
    0.01100505f, 0.01169609f, -0.03039534f, -0.00863998f, 0.02168236f, -0.01357523f, -0.03486975f, -0.03136635f, 
    -0.00532366f, 0.00797466f, 0.01777631f, -0.03863027f, 0.01482587f, -0.01449668f, -0.01943422f, -0.02345045f, 
    0.00056895f, 0.02597133f, 0.00541884f, -0.00188158f, 0.01580786f, 0.03308551f, 0.02105122f, 0.00777460f, 
    0.00701263f, 0.00876753f, 0.00978342f, 0.00274155f, -0.03763418f, -0.04684806f, -0.02233655f, 0.03305304f, 
    -0.00839537f, 0.02591598f, -0.03749698f, -0.03016711f, -0.01730665f, 0.00445441f, 0.00960917f, 0.02569673f, 
    -0.03462639f, -0.00729588f, 0.01843260f, 0.02001514f, -0.01079564f, -0.03935367f, -0.04371553f, -0.01672663f, 
    0.01074785f, 0.01789596f, 0.00176661f, 0.02488173f, -0.00016877f, 0.00642556f, -0.01378411f, -0.03450648f, 
    -0.00752795f, 0.00487314f, 0.02835387f, -0.00550567f, -0.00180778f, -0.01303803f, -0.02661169f, 0.02353640f, 
    -0.01096785f, -0.00813006f, 0.00977114f, -0.00616934f, 0.01666918f, -0.01974465f, -0.02797748f, 0.00774574f, 
    0.01341828f, -0.03813303f, -0.03907182f, 0.01291907f, 0.01782857f, -0.01608397f, 0.01152539f, 0.01937621f, 
    0.02416393f, -0.01489106f, -0.01810382f, 0.01824328f, -0.01782591f, -0.02123810f, -0.02861398f, 0.01271692f, 
    -0.03586897f, -0.02290881f, 0.00923870f, -0.00086451f, 0.02674508f, 0.02504145f, 0.02834135f, -0.02564564f, 
    -0.00814218f, -0.03944387f, 0.01594239f, -0.02285109f, 0.03326958f, 0.03461236f, 0.00678882f, -0.01324302f, 
    -0.01160152f, -0.02069178f, -0.01021508f, 0.03856610f, 0.02383940f, 0.01084173f, -0.00366122f, -0.03340173f, 
    -0.00013464f, 0.02398901f, 0.02461566f, 0.02507366f, 0.02529065f, 0.02655625f, -0.03819495f, 0.01488534f, 
    0.01546261f, -0.01315452f, 0.00289675f, -0.03683412f, -0.01776063f, 0.00575434f, 0.01649399f, 0.00961781f, 
    -0.00065388f, 0.00730324f, -0.00523353f, -0.01668409f, -0.03441600f, 0.00940395f, 0.00558612f, 0.02096519f, 
    0.01710621f, -0.00303899f, 0.00131384f, 0.02015946f, 0.01454747f, -0.02047897f, 0.01140300f, 0.00798650f, 
    -0.03187180f, -0.00312856f, 0.01906725f, -0.01224446f, 0.03349502f, -0.00644377f, 0.01527572f, -0.02688155f, 
    -0.01103766f, 0.01697448f, -0.00903303f, 0.00891252f, -0.03817737f, -0.01462434f, 0.01572682f, -0.00462167f, 
    -0.01889815f, 0.00998019f, -0.01600272f, -0.01814757f, 0.00669753f, -0.00069499f, 0.00004693f, -0.04319832f, 
    0.00826914f, 0.00087308f, -0.03542478f, 0.01550897f, 0.01494284f, 0.00283298f, -0.02679716f, 0.01971706f, 
    0.02337987f, -0.03455144f, 0.02771681f, -0.02488480f, 0.00583087f, -0.03771096f, -0.02792987f, 0.02984498f, 
    0.00587217f, 0.00330882f, 0.01235372f, 0.01167372f, 0.00140469f, -0.02296350f, -0.04006543f, 0.02178028f, 
    -0.01190363f, -0.00453147f, -0.01484151f, 0.00951480f, 0.02072751f, -0.00354459f, -0.02106780f, -0.02809421f, 
    -0.03013042f, -0.04389602f, 0.01037645f, 0.01355998f, -0.00947543f, 0.01203383f, -0.01258945f, 0.00004487f, 
    -0.02147284f, -0.00985914f, -0.01160479f, 0.01217204f, -0.02768632f, 0.01197064f, 0.01951656f, -0.02765481f, 
    -0.00005765f, -0.03463434f, -0.00304659f, 0.00042944f, 0.00197679f, 0.00993506f, -0.01167561f, -0.03515767f, 
    0.01752730f, 0.02054232f, -0.03103866f, -0.04186124f, 0.00491397f, 0.00388323f, 0.00810639f, -0.03230947f, 
    -0.02813079f, -0.00305703f, 0.02063289f, -0.02627024f, 0.00953210f, -0.01027816f, -0.04203875f, -0.02393748f, 
    0.00330554f, 0.00164074f, -0.03652585f, 0.02544712f, 0.02072947f, -0.03064984f, 0.02387304f, 0.02663357f, 
    -0.00682048f, -0.02775039f, -0.00847082f, -0.02667767f, -0.01361012f, -0.01751023f, -0.02130957f, -0.02827265f, 
    0.02241640f, 0.02793621f, -0.01867484f, 0.00880876f, 0.02706556f, -0.00844923f, 0.00591375f, 0.01113986f, 
    -0.02996701f, -0.03582878f, -0.01416690f, -0.00303109f, 0.03111584f, 0.01018832f, -0.00721141f, 0.03553737f, 
    -0.03869981f, 0.02209662f, 0.00092393f, 0.03391004f, 0.02576526f, -0.00587239f, 0.00931852f, -0.01009817f, 
    -0.04621181f, 0.00393627f, -0.00772467f, 0.03580697f, 0.02909110f, -0.02852808f, 0.00030143f, 0.00434675f, 
    -0.01334519f, 0.01692022f, -0.01540491f, -0.03955921f, -0.02098549f, -0.01644313f, -0.03468674f, 0.02549960f, 
    -0.01506598f, 0.01012040f, 0.00886439f, 0.00347849f, 0.00693353f, -0.01626149f, -0.01713393f, 0.01751410f, 
    0.02240245f, -0.04142464f, -0.02858377f, 0.01197863f, 0.01171712f, -0.01119129f, 0.02139827f, 0.02413070f, 
    0.00861603f, -0.03466066f, 0.00342748f, -0.03684753f, -0.00987865f, 0.03822668f, -0.01482152f, 0.01570755f, 
    -0.04250479f, -0.03720605f, 0.03276170f, -0.02619006f, -0.01935804f, 0.02388803f, -0.01684230f, -0.00891684f, 
    -0.03378933f, -0.00903558f, 0.00807177f, -0.02978116f, -0.00182998f, 0.00275270f, -0.00557684f, 0.03411084f, 
    0.01895550f, 0.01362212f, 0.01716721f, -0.01512941f, -0.02709871f, 0.01161630f, -0.04426734f, -0.00405762f, 
    0.00196593f, 0.00161401f, 0.01116842f, -0.01313042f, -0.00638102f, 0.00997235f, 0.01356496f, 0.00836313f, 
    -0.01465559f, 0.01458260f, 0.03516846f, -0.01708058f, -0.03434928f, -0.02434202f, 0.00258705f, 0.02718586f, 
    0.00784862f, -0.03035226f, -0.00942934f, 0.00103364f, -0.00946902f, -0.01454853f, 0.00736697f, 0.03619081f, 
    0.01220110f, -0.00253566f, -0.02295976f, -0.01623044f, -0.00194765f, -0.01429606f, -0.01817223f, -0.00484976f, 
    -0.03440977f, -0.02993262f, -0.02986627f, -0.00865168f, -0.04177818f, -0.03582437f, 0.03082717f, -0.00843830f, 
    0.03000709f, -0.03965152f, 0.00897830f, -0.03310734f, -0.04496912f, -0.01436967f, -0.00966694f, 0.01355234f, 
    0.01760917f, 0.03539975f, -0.00170466f, -0.02364778f, -0.00784058f, 0.02208861f, 0.00403945f, -0.00027551f, 
    0.02763959f, 0.00374846f, -0.04324828f, -0.03800233f, 0.00129014f, 0.00537237f, -0.02640305f, 0.01338112f, 
    -0.02613572f, -0.00315234f, -0.01755070f, 0.03910562f, 0.00953450f, -0.04403036f, -0.01556081f, 0.03170008f, 
    -0.00426112f, -0.01022311f, -0.01141550f, 0.01826615f, -0.00007724f, 0.01130720f, 0.02039141f, 0.02244921f, 
    0.02334760f, -0.03105098f, -0.02213253f, -0.01697233f, 0.03002150f, 0.00320649f, 0.02806569f, -0.03572199f, 
    -0.01084471f, -0.00487761f, -0.01537396f, -0.01116212f, 0.01296689f, 0.01351384f, 0.02383127f, -0.02069372f, 
    0.02359918f, 0.03145656f, 0.01075033f, 0.01349069f, -0.02226908f, 0.00369624f, 0.02195079f, -0.00012597f, 
    -0.31410515f, 0.18938011f, 0.30413947f, 0.13303308f, -0.11007131f, -0.03304490f, -0.08719753f, -0.02660682f, 
    0.25627702f, 0.09325588f, 0.12123514f, 0.03848499f, -0.03479963f, -0.24136628f, 0.10932124f, 0.23201676f, 
    -0.05714935f, -0.08616214f, -0.10935271f, -0.11283628f, 0.05056584f, 0.00545650f, -0.04131619f, -0.01200906f, 
    -0.12538055f, -0.18789490f, 0.16852567f, 0.16117600f, -0.16525690f, 0.20136325f, 0.14876191f, 0.10226547f, 
    0.11270519f, 0.07550228f, 0.09991092f, -0.07137548f, 0.15343849f, -0.08342529f, -0.06966115f, 0.05075937f, 
    -0.05543051f, -0.03493938f, -0.06809007f, -0.07061497f, -0.11650554f, -0.03799506f, -0.01237330f, 0.05375035f, 
    -0.08054777f, 0.12026609f, 0.09384594f, 0.00355597f, -0.07184395f, -0.05560269f, 0.13425326f, 0.04938338f, 
    0.01754606f, 0.03810011f, -0.09086384f, 0.17847587f, -0.16309761f, 0.11890530f, 0.30240968f, 0.35258627f, 
    -0.12010431f, -0.14349623f, 0.08024207f, -0.04253900f, -0.05344086f, 0.01379780f, -0.13966981f, -0.00726981f, 
    0.29984891f, -0.07766136f, -0.15385763f, 0.09148150f, 0.09583160f, -0.01637959f, 0.03522078f, 0.06974209f, 
    -0.01885714f, 0.20860264f, 0.06973699f, 0.09350599f, 0.05212992f, -0.19609194f, 0.09586181f, 0.25296468f, 
    -0.09374855f, -0.05108270f, -0.12320620f, -0.18575609f, -0.00326166f, 0.00281193f, -0.08799978f, -0.03870241f, 
    0.28561801f, 0.06450784f, 0.11835141f, 0.34146124f, -0.07436679f, -0.13175882f, -0.03206607f, -0.25762287f, 
    0.00254416f, -0.04375725f, -0.04178246f, -0.00320004f, -0.26351008f, -0.29512358f, 0.12574732f, 0.15618296f, 
    0.07424404f, 0.06568370f, -0.06419468f, 0.03495518f, 0.00478873f, 0.01683130f, -0.05432836f, -0.03540975f, 
    0.19677256f, -0.22081828f, 0.04671156f, 0.17418401f, -0.02664751f, -0.04363573f, -0.01291802f, -0.00025628f, 
    -0.07913364f, 0.00796333f, 0.05859416f, 0.03050485f, 0.01067364f, -0.12785617f, 0.06926346f, 0.17581406f, 
    -0.01093900f, -0.16725563f, -0.15660213f, -0.05810935f, 0.07662692f, -0.15339901f, -0.09374002f, -0.05917821f, 
    0.78124613f, 0.11785629f, -0.23547742f, -0.33590975f, 0.18218844f, 0.05343173f, 0.02027118f, -0.11727025f, 
    -0.14026052f, 0.00971495f, 0.08494342f, 0.08101617f, 0.54049206f, -0.08725286f, -0.13199700f, 0.09391261f, 
    0.16700698f, -0.02918042f, 0.15031911f, -0.17768466f, -0.00092759f, -0.02048655f, 0.05407684f, -0.00469665f, 
    0.37502244f, 0.22916493f, 0.25164941f, -0.12388100f, 0.00026464f, 0.07533659f, 0.03064974f, -0.02627718f, 
    0.01702766f, -0.05401491f, 0.05522060f, 0.17432624f, -0.15249220f, 0.28031391f, -0.06056141f, 0.11396431f, 
    0.09784845f, -0.05064429f, -0.03521143f, 0.00722089f, 0.09131091f, 0.08345605f, -0.01610274f, -0.03459958f, 
    -0.15839319f, -0.06784879f, 0.09423380f, 0.06148183f, 0.07929464f, 0.00665577f, -0.15695710f, -0.13388497f, 
    0.00545986f, -0.11742911f, -0.02788025f, 0.08046172f, 0.49372336f, 0.01297858f, -0.10918308f, -0.10035972f, 
    0.08788587f, -0.12135415f, -0.00867503f, -0.05237049f, 0.07744501f, 0.06401164f, 0.13124464f, -0.08435628f, 
    -0.26736516f, 0.18140483f, 0.28901830f, 0.12964030f, -0.11195232f, -0.08427928f, 0.20948763f, 0.12071982f, 
    -0.02571946f, 0.00577309f, -0.02797294f, -0.09333012f, -0.04249250f, 0.06019010f, 0.12443953f, -0.02806108f, 
    0.06090864f, 0.05582920f, -0.04675941f, -0.01827354f, 0.03789528f, 0.11914016f, 0.01556987f, 0.09428053f, 
    -0.18454622f, 0.01470085f, 0.05503786f, -0.08489892f, 0.05982330f, 0.03986258f, -0.06346480f, -0.19865911f, 
    -0.01583270f, -0.11333756f, -0.03258012f, 0.05415346f, -0.40059739f, 0.07876325f, 0.16486886f, 0.06246709f, 
    -0.09141541f, 0.13827866f, -0.06090056f, 0.02656543f, -0.12824360f, -0.07626561f, 0.13444863f, 0.02425134f, 
    -0.03745288f, 0.00514580f, 0.01870907f, 0.04042827f, 0.17380971f, 0.00862269f, -0.07511716f, 0.14685601f, 
    0.05574420f, 0.04462926f, 0.08156506f, 0.03324790f, -0.05444220f, 0.13157949f, 0.09701777f, -0.15886429f, 
    0.08922455f, 0.12237835f, 0.22634216f, 0.11222210f, 0.02590155f, 0.02966774f, 0.08684690f, 0.03905378f, 
    0.28780130f, -0.08670777f, 0.08452126f, 0.11099624f, 0.13178626f, -0.02969665f, 0.07495616f, 0.03083877f, 
    -0.01060206f, -0.05010485f, -0.04718333f, -0.03184256f, -0.10969155f, -0.00756231f, -0.05066634f, -0.12359488f, 
    0.02879935f, -0.04048755f, 0.11403377f, 0.01696857f, 0.05054664f, 0.13988894f, 0.11068549f, 0.08126222f, 
    -0.14462961f, -0.05585893f, 0.03296413f, 0.23103552f, -0.10778787f, -0.12475667f, -0.14057240f, -0.12221866f, 
    0.05015806f, 0.06550810f, -0.02683581f, -0.10315554f, 0.08873841f, -0.02452919f, -0.05275881f, -0.23401175f, 
    -0.05057389f, -0.01669045f, 0.03944650f, -0.01194366f, -0.04876110f, 0.10157049f, -0.13498169f, -0.01579403f, 
    0.17090403f, -0.02316345f, -0.10844602f, -0.04614237f, -0.01240431f, 0.01589463f, 0.06703409f, 0.01939032f, 
    0.02801863f, 0.16467023f, 0.10681195f, -0.04887164f, -0.16839874f, -0.08569983f, -0.39190513f, -0.07703616f, 
    0.18135077f, 0.13154377f, -0.21363632f, -0.18865535f, 0.14586234f, 0.08461668f, 0.15160052f, -0.01975216f, 
    -0.08665301f, -0.06886871f, 0.05437645f, 0.36009464f, 0.06448878f, 0.12814584f, -0.09102451f, -0.00513709f, 
    0.14201874f, 0.13689703f, -0.07281128f, -0.01982764f, -0.07791518f, -0.00023559f, -0.09255140f, 0.20460975f, 
    0.09605228f, 0.11251158f, -0.08685380f, -0.20283791f, -0.01213438f, -0.11423644f, 0.06091839f, 0.05083606f, 
    0.13774487f, 0.00133710f, 0.07629721f, 0.19336981f, 0.04632541f, -0.03590657f, 0.17197149f, 0.03970029f, 
    -0.15328252f, 0.20567375f, -0.03497355f, 0.03404839f, -0.16378528f, -0.10382684f, -0.04793635f, 0.14409335f, 
    0.18909572f, -0.03727533f, 0.14682776f, 0.07888391f, -0.05983643f, -0.01482009f, -0.15783773f, -0.02403666f, 
    -0.02904053f, 0.17851944f, -0.20279752f, -0.01128048f, 0.28298888f, 0.04192515f, -0.08826335f, 0.03711646f, 
    0.09186154f, -0.14055763f, 0.14606686f, -0.07361059f, -0.17935187f, -0.06181291f, 0.09099117f, 0.24560103f, 
    -0.10826416f, -0.11890767f, -0.08790402f, 0.02657967f, -0.03009128f, -0.02223830f, 0.01544025f, 0.01485713f, 
    -0.14858031f, 0.03241346f, 0.16581789f, -0.01865136f, 0.00867564f, -0.03940176f, 0.06925101f, -0.01468583f, 
    0.02306842f, -0.01592594f, 0.06673373f, 0.17647082f, 0.07913557f, 0.00524634f, -0.05809164f, -0.11824446f, 
    -0.06136736f, -0.02891336f, 0.03234468f, -0.06392599f, -0.11549488f, -0.06748369f, 0.19452375f, -0.05743491f, 
    -0.11399234f, -0.03326854f, -0.08241523f, 0.05226722f, -0.06699142f, 0.11408730f, -0.07167766f, -0.01951805f, 
    0.02411925f, 0.00851819f, -0.08839745f, -0.13181487f, -0.12745991f, 0.08292042f, -0.00628969f, 0.24958427f, 
    -0.14963128f, -0.11626853f, -0.22491834f, -0.12403915f, 0.09598784f, -0.08421098f, -0.17185321f, -0.09924579f, 
    -0.11214919f, 0.25459725f, 0.28984973f, -0.21994697f, -0.03069812f, 0.03213368f, 0.00504594f, 0.02837711f, 
    0.07427108f, -0.00697640f, 0.15929998f, -0.07233406f, 0.07437498f, 0.14509866f, 0.09737192f, -0.05145679f, 
    -0.04750086f, -0.08172429f, -0.12540646f, -0.01592245f, 0.01477406f, -0.02535512f, 0.11988611f, 0.09881195f, 
    0.16489834f, 0.03112594f, 0.14292058f, 0.23565619f, -0.06844506f, -0.01046786f, -0.10067106f, 0.02109531f, 
    -0.04080563f, -0.05785682f, 0.11736206f, -0.09480541f, 0.15060787f, 0.46789649f, -0.17319161f, 0.09033214f, 
    -0.06939263f, -0.24305545f, 0.14966215f, -0.05536062f, -0.02150134f, 0.01304439f, 0.03645859f, -0.12858768f, 
    -0.16812466f, 0.03571270f, 0.10189392f, 0.01448365f, -0.11235029f, 0.18927832f, -0.09258404f, 0.15926893f, 
    0.01993035f, -0.00344891f, -0.02878674f, 0.16545621f, -0.02222752f, 0.35450342f, -0.24608876f, -0.09446132f, 
    -0.01472299f, -0.00580892f, -0.06549305f, 0.02068237f, -0.07949231f, 0.03706548f, 0.05060146f, -0.10857171f, 
    -0.18956611f, 0.35347590f, -0.22145671f, -0.01752310f, 0.01263239f, 0.00638278f, 0.00686821f, 0.01860699f, 
    -0.13474879f, -0.04855248f, -0.07008762f, -0.07661233f, -0.51310152f, 0.01879569f, 0.02163982f, 0.02004216f, 
    0.07507540f, -0.03229030f, -0.03335124f, -0.04126334f, -0.18015341f, 0.02132994f, 0.06108467f, -0.03630589f, 
    -0.18762960f, -0.24013284f, -0.01553842f, 0.13891886f, 0.06880710f, 0.09201759f, -0.03835620f, -0.04784618f, 
    0.10055333f, 0.11905006f, 0.05707976f, 0.05093259f, -0.10707149f, -0.09159981f, -0.10223079f, 0.22470908f, 
    0.09014158f, -0.09164930f, -0.09156789f, 0.22781472f, -0.06177954f, 0.10756174f, -0.01071070f, 0.01815251f, 
    -0.53294373f, 0.13130233f, -0.23782693f, 0.15247828f, -0.07379685f, 0.12590429f, -0.06364693f, -0.02466734f, 
    0.01582068f, 0.05453142f, -0.07937781f, -0.04943681f, -0.05674333f, 0.27355209f, -0.04111287f, -0.12395170f, 
    0.02326351f, 0.03940776f, 0.05801433f, -0.09004709f, 0.15135103f, -0.14046635f, 0.14654416f, -0.05285993f, 
    -0.14816107f, 0.06419386f, 0.02452876f, -0.16020307f, 0.00734910f, 0.05672199f, 0.03878384f, -0.07470286f, 
    0.03467274f, -0.01042094f, 0.22293115f, 0.12545070f, -0.08140707f, 0.14788896f, 0.16871689f, -0.15477344f, 
    -0.04513714f, -0.01671949f, -0.14742228f, 0.00190977f, -0.03812372f, 0.11059049f, -0.09821063f, 0.05349024f, 
    -0.18577819f, -0.03051208f, 0.30773789f, 0.29158321f, -0.01816010f, -0.08562471f, 0.14374708f, 0.18680161f, 
    -0.01447051f, 0.07197624f, 0.03892196f, 0.00164627f, 0.04524789f, 0.00615072f, 0.00580275f, -0.08292632f, 
    0.25487930f, -0.10756849f, 0.07309789f, -0.00651647f, -0.00106540f, 0.08291537f, -0.02738259f, 0.01110425f, 
    0.12317725f, -0.06942274f, 0.13781549f, 0.42422101f, -0.10784355f, 0.16122520f, 0.01668693f, -0.03284257f, 
    0.03329732f, 0.04029891f, 0.06863648f, 0.03252067f, -0.15665084f, -0.22153616f, 0.09938417f, 0.28121260f, 
    -0.17850314f, -0.03164291f, -0.08410192f, 0.12045796f, -0.03490789f, -0.03884147f, -0.09281414f, -0.10152288f, 
    -0.26640347f, 0.17419696f, 0.30477777f, 0.14950624f, -0.09762871f, 0.08925325f, 0.16852893f, 0.09784625f, 
    -0.03700041f, -0.03141781f, 0.07970960f, 0.13337278f, -0.01926933f, -0.04140807f, 0.18783802f, 0.28053895f, 
    0.04751250f, -0.08131428f, 0.01652917f, -0.13127936f, 0.01144324f, -0.02420674f, 0.02954625f, 0.01433438f, 
    -0.03489483f, 0.06255883f, 0.06094091f, -0.12193377f, -0.00136028f, 0.00071253f, 0.01108592f, -0.08140858f, 
    -0.03384171f, -0.02771962f, -0.14220633f, -0.07732821f, -0.18952821f, 0.05634899f, -0.00923588f, 0.18988875f, 
    0.12088624f, 0.20688763f, 0.01154473f, -0.20634466f, 0.06827134f, 0.08284874f, 0.06331961f, 0.04562448f, 
    0.26501849f, 0.16730401f, -0.06679302f, 0.12337640f, 0.21384773f, 0.05470918f, -0.05710652f, -0.01436015f, 
    -0.08354291f, -0.09307808f, 0.15692963f, 0.22100276f, 0.29862323f, 0.03363647f, 0.26842305f, -0.05457693f, 
    -0.03053615f, -0.01336478f, 0.11196007f, -0.06205479f, 0.06843363f, 0.19381182f, -0.01140267f, 0.02851125f, 
    -0.11105008f, -0.09665298f, -0.05974210f, 0.35334772f, -0.06734762f, -0.00161379f, 0.03969079f, -0.06443947f, 
    0.08403536f, 0.12161781f, 0.05514390f, 0.15401691f, 0.13545872f, 0.13411449f, -0.11399736f, 0.00798204f, 
    -0.20435192f, -0.09349740f, 0.00332877f, -0.18856871f, 0.00319370f, 0.05198771f, 0.07487158f, -0.06319690f, 
    -0.08650517f, 0.08869074f, 0.01779532f, 0.40219957f, -0.07389568f, -0.03542291f, -0.08420296f, 0.12739344f, 
    0.00837791f, 0.05973227f, 0.04382248f, -0.00639284f, -0.00081693f, -0.11868583f, -0.01445882f, -0.16458485f, 
    0.04508251f, 0.10964779f, -0.02488683f, 0.10793825f, 0.09506453f, -0.00900880f, 0.11326746f, 0.28957915f, 
    0.06591577f, -0.28032640f, 0.13271588f, 0.07593640f, 0.24714239f, 0.07349049f, 0.19582260f, 0.03964187f, 
    -0.05972219f, 0.06687937f, -0.03313439f, -0.01827709f, -0.03637345f, 0.11056938f, 0.15014727f, 0.36071306f, 
    -0.06062162f, -0.12626429f, -0.01296406f, 0.00588034f, -0.20030022f, 0.08957709f, -0.14342269f, -0.38310531f, 
    0.26499555f, 0.01536408f, 0.08409119f, -0.08548789f, 0.23099345f, 0.08857802f, -0.17251125f, -0.14126617f, 
    0.08140395f, -0.19557279f, 0.01254289f, -0.10948933f, 0.00623210f, -0.06949562f, -0.14186724f, -0.02011734f, 
    -0.00864667f, 0.12243504f, 0.28208116f, 0.08647083f, 0.07159084f, 0.04633341f, 0.11645532f, 0.19411775f, 
    0.16052046f, -0.28148493f, -0.09592755f, -0.08399390f, 0.17797551f, 0.13700204f, 0.18127491f, 0.21172677f, 
    0.15526024f, 0.09823286f, 0.15483932f, 0.29094422f, 0.34481177f, 0.11174924f, 0.27201763f, -0.00047951f, 
    0.16993731f, 0.13231060f, 0.02510142f, 0.20825639f, 0.17319983f, -0.06468055f, -0.07134625f, -0.26140377f, 
    0.18144894f, -0.02474536f, -0.06817793f, -0.05159172f, 0.02009339f, -0.17120068f, -0.13850380f, -0.23553777f, 
    -0.07924964f, -0.07200093f, 0.01917627f, -0.16860701f, 0.44872975f, -0.01456468f, 0.27094391f, -0.23402032f, 
    0.09345780f, 0.11134972f, -0.14101255f, 0.00979337f, 0.14522518f, -0.14124590f, 0.04379006f, -0.07780883f, 
    0.18051454f, -0.10998861f, -0.09946329f, -0.29140237f, -0.18268342f, 0.16580710f, 0.11108847f, -0.10878842f, 
    0.08906042f, -0.22591648f, -0.14938466f, 0.02186313f, 0.12049324f, 0.29197979f, 0.05433134f, -0.26407456f, 
    0.04748487f, -0.15509647f, 0.00596296f, -0.26475632f, 0.23227639f, -0.08082645f, -0.17660719f, -0.14216502f, 
    0.16600227f, -0.20230491f, -0.28977969f, 0.13464750f, -0.04661446f, -0.12276829f, 0.10972887f, -0.09086563f, 
    -0.01982076f, -0.06976712f, 0.19049394f, 0.15663828f, 0.39349556f, -0.06405521f, 0.10026914f, -0.18049896f, 
    -0.01883942f, -0.02165913f, -0.18016659f, 0.22774325f, 0.05686794f, -0.30718425f, -0.09154920f, 0.01285424f, 
    0.26063961f, 0.16235933f, 0.26522225f, 0.15380390f, -0.03492285f, -0.08468270f, -0.17161326f, 0.24984649f, 
    0.24060524f, 0.01713548f, -0.02333132f, 0.01214344f, 0.20557360f, -0.19720349f, 0.34715730f, -0.34229532f, 
    -0.11182426f, 0.06455718f, -0.18862002f, -0.08836108f, -0.08552714f, -0.29351518f, -0.07950822f, -0.16712403f, 
    -0.18214518f, 0.14792289f, 0.12873681f, 0.17048118f, -0.04264930f, 0.15215765f, -0.19927655f, 0.06273521f, 
    -0.09863563f, -0.02168765f, 0.06075262f, -0.11305621f, 0.11503909f, -0.05337226f, -0.31353596f, 0.19086231f, 
    -0.00030571f, 0.21362986f, -0.19789742f, -0.28321567f, -0.06050343f, -0.22117956f, -0.13536401f, -0.24815913f, 
    0.02557856f, -0.48451459f, 0.25372741f, 0.07235537f, -0.03696544f, -0.06722101f, -0.05000409f, 0.08352319f, 
    -0.04440388f, 0.10645501f, 0.07385816f, 0.00293012f, -0.56166828f, -0.41189852f, 0.02355897f, 0.14427909f, 
    0.00880853f, -0.05356333f, 0.00431781f, 0.17259644f, 0.00747785f, -0.05944014f, -0.01009040f, 0.13865064f, 
    0.13249180f, 0.08854161f, 0.17237870f, 0.05064211f, 0.06564307f, 0.13269998f, -0.13961937f, 0.08156853f, 
    -0.09560534f, -0.09502167f, -0.14436464f, -0.19218807f, 0.42564771f, 0.21266299f, 0.25326568f, 0.18404713f, 
    -0.03127807f, 0.00964050f, -0.04062698f, -0.06292587f, 0.08948077f, 0.06652839f, -0.22163157f, -0.21892962f, 
    0.06405071f, -0.22298160f, -0.02857084f, 0.15321034f, 0.06713925f, 0.23393475f, 0.06027507f, 0.09555469f, 
    0.06127227f, -0.01917550f, 0.06411337f, 0.10264903f, 0.03072439f, 0.10522462f, -0.22765142f, -0.10235143f, 
    0.10023811f, 0.05670689f, 0.07590988f, -0.20198828f, 0.06282238f, -0.04819662f, -0.09280038f, -0.24456050f, 
    0.33251765f, -0.05558755f, 0.33349919f, 0.18662535f, -0.05331722f, -0.07309582f, 0.13655449f, 0.22837712f, 
    -0.00480156f, 0.05834606f, 0.00119697f, -0.01708494f, -0.29366615f, -0.11565422f, -0.13964514f, -0.02105016f, 
    0.00401215f, 0.08752038f, 0.10979856f, -0.02148558f, -0.04049700f, 0.07087426f, 0.03690036f, 0.24121149f, 
    0.20785604f, -0.01575605f, -0.05714163f, 0.18041025f, 0.03798202f, 0.14661446f, -0.04080101f, 0.11935847f, 
    0.26086456f, 0.09809270f, -0.01744805f, 0.22802290f, 0.06960497f, -0.12864426f, 0.28199163f, -0.16280778f, 
    0.32780063f, 0.01149038f, -0.12726440f, 0.00671149f, -0.15597813f, 0.14017393f, -0.02202785f, -0.23159729f, 
    0.23878698f, 0.24398829f, -0.08500346f, 0.05989644f, -0.03606436f, -0.11469407f, 0.22701728f, -0.15088683f, 
    0.04267891f, 0.06017533f, -0.03204209f, 0.09782665f, -0.32740110f, 0.04413508f, -0.28035513f, -0.09224115f, 
    0.28227597f, 0.02323390f, 0.11912738f, -0.03787360f, -0.15212291f, 0.15099779f, 0.25733712f, -0.08868513f, 
    0.43002477f, -0.22605586f, 0.11664819f, 0.12103642f, -0.01162605f, -0.02074893f, 0.03609792f, 0.03414386f, 
    0.13161062f, -0.04345178f, -0.08984488f, 0.03179581f, 0.19681829f, 0.12303911f, 0.06787793f, 0.25764057f, 
    0.17944779f, -0.06057163f, 0.18043162f, 0.00273536f, 0.07377730f, 0.08425260f, -0.04975632f, 0.31155577f, 
    0.08722499f, 0.20854989f, 0.08183473f, -0.30313194f, 0.44692868f, 0.23859289f, -0.28636569f, -0.09596651f, 
    -0.36562291f, -0.24858260f, -0.04700596f, -0.17234135f, 0.13105987f, -0.00062655f, 0.09629276f, 0.17325546f, 
    0.08015202f, 0.08264218f, -0.00280198f, 0.16367809f, -0.00826596f, -0.04142975f, -0.03766419f, -0.21550249f, 
    -0.14122956f, -0.19916469f, 0.03012865f, -0.05737625f, 0.16322860f, 0.27539310f, 0.19399118f, -0.16330291f, 
    -0.01997252f, 0.09619173f, -0.09188017f, -0.11638659f, -0.25683022f, -0.10254642f, 0.00411470f, 0.11600167f, 
    -0.18091729f, -0.12937362f, 0.12843813f, -0.24507703f, 0.21548073f, -0.15590125f, -0.01541176f, -0.15618233f, 
    0.08038453f, 0.07323398f, -0.00292570f, -0.10259010f, 0.13421853f, -0.03952620f, -0.17768726f, -0.08693580f, 
    -0.16114403f, 0.04679076f, 0.17589913f, 0.02464874f, 0.37941250f, 0.08859253f, 0.25406814f, 0.20281371f, 
    0.10040534f, -0.00074938f, -0.09429779f, 0.20410192f, 0.02314223f, 0.01792136f, 0.06704661f, -0.18528147f, 
    -0.07552163f, -0.04174234f, -0.02967773f, 0.09985069f, 0.01386326f, 0.11367911f, 0.04853297f, -0.18830185f, 
    -0.13303781f, -0.13532273f, -0.17096089f, -0.14462852f, -0.08422747f, -0.07143615f, -0.17421754f, 0.20609036f, 
    0.00739692f, 0.19036710f, 0.04423121f, 0.03942611f, 0.22887243f, 0.06721853f, 0.05721622f, 0.22506662f, 
    -0.09593657f, 0.00538166f, -0.33453608f, 0.23185502f, -0.00745876f, -0.22869296f, -0.07629661f, 0.07311220f, 
    -0.09565040f, 0.01123282f, 0.12601238f, 0.08788264f, 0.25324732f, 0.22530378f, 0.45677510f, 0.18531139f, 
    0.18361653f, -0.12172948f, -0.09086221f, -0.08540384f, -0.13764055f, -0.01349865f, -0.17491372f, 0.05266399f, 
    -0.03238918f, 0.04189496f, 0.00548525f, -0.18925774f, -0.01000814f, 0.09145669f, -0.02756591f, -0.19039594f, 
    0.09853116f, -0.21993656f, -0.02492763f, -0.27043906f, -0.06330843f, -0.00822018f, 0.11054917f, -0.20822559f, 
    0.07465699f, -0.06678302f, 0.24040088f, 0.07174917f, 0.09398463f, 0.04650605f, -0.09762003f, 0.03232906f, 
    -0.47286427f, 0.18583497f, -0.09887629f, -0.33792421f, 0.00927638f, -0.00187285f, -0.02473193f, 0.03104767f, 
    -0.16028592f, 0.07062884f, -0.11100640f, 0.06706948f, -0.35912156f, -0.22825253f, 0.00411089f, 0.01289153f, 
    0.03595990f, -0.08522446f, 0.09029646f, -0.15865141f, -0.04352838f, -0.02569240f, -0.23258430f, 0.12936519f, 
    0.03587892f, 0.10606697f, -0.02100934f, 0.27369231f, 0.04934978f, 0.05659213f, 0.07558777f, -0.11247668f, 
    0.06625728f, 0.13859066f, 0.11896625f, 0.07091187f, 0.34742722f, 0.12103595f, 0.20382936f, -0.07272266f, 
    0.08630269f, 0.09219225f, 0.02895498f, -0.00172832f, 0.10985860f, -0.03752231f, -0.21092170f, -0.18212800f, 
    0.24199146f, 0.14924896f, 0.19122551f, 0.28324801f, 0.18393444f, 0.28096393f, -0.09425758f, -0.02141903f, 
    -0.05561285f, -0.03269213f, 0.07581586f, 0.18237430f, -0.22530586f, 0.11356234f, -0.10097843f, -0.04764744f, 
    0.10415754f, 0.27182472f, 0.09287453f, -0.11864599f, -0.14168863f, 0.06652447f, 0.16861314f, 0.31737509f, 
    -0.31639510f, 0.09434137f, -0.53603417f, -0.02284710f, 0.05124244f, -0.20369896f, 0.14555000f, -0.16551228f, 
    0.06852767f, 0.02427079f, -0.17892025f, 0.02591944f, -0.20057660f, -0.16782559f, -0.26442918f, 0.17460409f, 
    -0.08944043f, 0.01688927f, 0.24612612f, -0.07101740f, 0.14504258f, -0.11467988f, 0.05619753f, 0.27079690f, 
    -0.01929779f, -0.07051797f, -0.22006632f, 0.13309327f, 0.04088131f, 0.06563065f, -0.02757541f, 0.02641204f, 
    -0.09581427f, 0.03401133f, -0.01933599f, 0.17360662f, 0.04036317f, -0.05045013f, 0.00806160f, -0.15411106f, 
    0.07012871f, 0.05288928f, -0.23189211f, -0.11924528f, -0.18166117f, -0.16043776f, -0.39209080f, -0.31547999f, 
    0.68533611f, 0.15783162f, 0.42383042f, 0.01217774f, -0.08139925f, 0.02785643f, -0.14490369f, 0.01319690f, 
    -0.02866572f, 0.01059394f, -0.02633099f, -0.08029332f, 0.21866246f, 0.10850603f, -0.06260210f, 0.20816554f, 
    0.02378648f, 0.23247097f, -0.06314556f, 0.28977871f, 0.02158869f, -0.02767695f, -0.07833119f, -0.03086805f, 
    -0.70588732f, -0.34093451f, -0.36431527f, 0.14113407f, 0.04022284f, 0.18970257f, -0.15677691f, -0.02665958f, 
    -0.01017922f, -0.02211636f, -0.06562866f, -0.02649310f, 0.03002045f, -0.01372865f, -0.08794539f, 0.20349991f, 
    0.11051378f, 0.01586968f, 0.00777749f, 0.08216950f, -0.03756531f, 0.09367015f, 0.14481314f, 0.17781499f, 
    -0.12617132f, 0.14719643f, -0.34258160f, 0.03213234f, 0.17547283f, 0.20707703f, 0.04372188f, -0.01882173f, 
    -0.19513671f, 0.02630858f, -0.02005726f, 0.04445885f, -0.02488814f, -0.12890041f, 0.14357640f, 0.08605526f, 
    0.08769695f, 0.09168632f, 0.15417227f, -0.04155173f, -0.14546403f, 0.22022636f, 0.25766557f, 0.05598096f, 
    0.00739743f, 0.23155494f, 0.16490754f, 0.18347976f, -0.04550579f, 0.05280988f, 0.12313587f, -0.18753739f, 
    -0.18074650f, -0.07546922f, -0.23541087f, -0.18023933f, 0.26277360f, 0.03966634f, 0.19399479f, 0.02799273f, 
    -0.27389169f, 0.00157163f, 0.05127042f, -0.04024415f, 0.09351213f, 0.08994833f, 0.19002560f, 0.04965977f, 
    -0.00482413f, 0.02585646f, 0.00907931f, 0.00693179f, 0.02266612f, -0.01248459f, 0.01927388f, -0.01861899f, 
    0.02085206f, -0.01619906f, -0.02929774f, 0.00481156f, -0.00152397f, -0.02099749f, 0.02830018f, 0.00837791f, 
    0.01315040f, -0.03163703f, -0.03937276f, -0.01186937f, 0.02363321f, -0.02741958f, 0.02509003f, 0.00005687f, 
    -0.03726655f, -0.03817301f, -0.01470262f, -0.04071024f, -0.01277434f, -0.02790771f, -0.00413964f, -0.03622374f, 
    -0.02872371f, -0.02812771f, 0.01122873f, 0.02020582f, -0.02698789f, -0.00048960f, 0.01960815f, -0.01517907f, 
    -0.01828952f, -0.02115187f, -0.00016665f, 0.02376547f, -0.02714635f, -0.03577831f, 0.02744838f, 0.01747956f, 
    -0.01774427f, 0.01426701f, -0.04072874f, 0.02239288f, 0.02124115f, -0.00079108f, -0.00039355f, -0.03117110f, 
    0.02054467f, 0.01405077f, -0.01530731f, -0.02566211f, -0.00992534f, 0.03003374f, -0.00679693f, -0.01009059f, 
    -0.03191583f, -0.00827623f, -0.00034243f, 0.00642972f, 0.01796936f, 0.02842400f, 0.00137977f, -0.03099692f, 
    0.02881931f, -0.01801573f, 0.01422988f, -0.00168578f, 0.00396190f, 0.00484360f, -0.01739144f, 0.01565127f, 
    -0.00624169f, -0.02308977f, 0.01311751f, -0.03834001f, 0.00647967f, 0.01347236f, -0.02622249f, 0.00414485f, 
    -0.02985971f, -0.03636580f, -0.01715333f, -0.03076527f, -0.01565351f, -0.00397931f, -0.00423985f, -0.04057552f, 
    -0.00981562f, 0.02406128f, 0.01346120f, 0.02764447f, 0.01575063f, -0.03012881f, 0.02071703f, -0.00168694f, 
    -0.02238973f, 0.02751102f, -0.01069062f, 0.00602623f, 0.01883825f, -0.02588134f, 0.01740925f, -0.00901562f, 
    -0.02635325f, -0.03280199f, -0.00327099f, 0.02348693f, -0.04055212f, -0.00183663f, 0.02541892f, -0.03544943f, 
    0.02895783f, 0.01655072f, 0.02805107f, -0.03426404f, 0.00888005f, 0.01881896f, -0.01220616f, 0.01401145f, 
    0.00288664f, -0.01772038f, -0.02892348f, -0.04170697f, -0.00244566f, -0.00478921f, -0.03776849f, 0.01498666f, 
    -0.01086681f, -0.00100314f, -0.02398605f, 0.01724537f, 0.01010786f, 0.01217288f, -0.00525798f, -0.00571594f, 
    -0.00202990f, -0.02055536f, 0.01891092f, -0.04188451f, -0.00100607f, 0.01647755f, -0.02396931f, 0.00999066f, 
    -0.00031477f, -0.03631511f, -0.00450415f, 0.02582878f, -0.02072399f, 0.00055932f, 0.01766447f, -0.00677839f, 
    -0.03259073f, -0.02007326f, -0.03947482f, 0.01428640f, -0.02558349f, 0.01647173f, -0.04074151f, 0.00466928f, 
    -0.00451708f, -0.00462770f, -0.02558610f, -0.03551544f, 0.02416219f, -0.03224404f, -0.01351757f, 0.00858536f, 
    -0.00857743f, -0.01990744f, 0.01310822f, -0.02081698f, -0.00901052f, 0.01936184f, -0.01261895f, 0.02711704f, 
    0.02458598f, -0.04033090f, -0.00368128f, 0.01244746f, -0.01718542f, -0.03905325f, -0.01146573f, 0.02617222f, 
    -0.01493369f, 0.01945834f, 0.01314256f, -0.00151599f, -0.04077363f, 0.02839247f, -0.03929141f, -0.02766054f, 
    -0.03922935f, -0.01961939f, -0.02941259f, -0.01567852f, 0.01214265f, -0.02600964f, -0.01174977f, 0.01995294f, 
    -0.01031007f, -0.02470828f, 0.02478832f, 0.00395020f, -0.01147979f, -0.03662452f, -0.03646338f, 0.02204890f, 
    0.00222400f, 0.02408729f, 0.00009942f, -0.03257333f, 0.02653275f, 0.01404377f, -0.00163195f, -0.00005893f, 
    0.01245313f, -0.02295861f, 0.01701507f, 0.02336184f, 0.00288906f, -0.00738084f, -0.04056962f, -0.02217097f, 
    0.02342330f, -0.00879131f, 0.02993659f, -0.03373780f, -0.03368628f, 0.00414473f, -0.01840762f, -0.01246304f, 
    -0.00842714f, 0.00637921f, -0.02493148f, -0.04097337f, -0.02822765f, -0.02291476f, -0.03620946f, 0.01985587f, 
    0.01641001f, 0.00452276f, -0.03057491f, -0.02999298f, 0.02959925f, -0.01382945f, -0.00614466f, -0.03195214f, 
    0.00155915f, -0.03554117f, 0.01804266f, 0.02687565f, 0.02343998f, 0.02294890f, 0.00334518f, -0.02217096f, 
    0.01929604f, -0.03736634f, -0.03442456f, -0.00329376f, -0.03855368f, -0.00677874f, -0.03715564f, -0.01548052f, 
    -0.03866163f, 0.00098697f, -0.03943453f, -0.02769873f, 0.00453416f, 0.01837496f, 0.00123602f, -0.03686922f, 
    -0.01337931f, 0.01546003f, -0.02807561f, -0.03028452f, -0.03147878f, -0.00163715f, -0.03358684f, -0.03415326f, 
    0.02006636f, -0.02957102f, 0.00666267f, -0.02678861f, 0.01824679f, -0.02825546f, -0.03375155f, 0.00770768f, 
    0.01665635f, 0.01831490f, 0.01241454f, 0.02916225f, -0.00124757f, 0.02328684f, 0.01683600f, -0.01683854f, 
    -0.02075285f, -0.03700862f, -0.02864466f, -0.00286448f, -0.02581624f, 0.02528796f, -0.02779339f, 0.02964211f, 
    -0.03737713f, 0.02568419f, -0.00387417f, 0.01130136f, -0.02116969f, 0.01354332f, 0.02401598f, -0.00378627f, 
    0.02107105f, -0.02710693f, 0.00085541f, 0.02930320f, -0.03813814f, -0.02459334f, -0.02954688f, 0.01401962f, 
    0.00694630f, -0.00180086f, -0.02631841f, 0.00171530f, 0.01953720f, -0.01770503f, -0.02582900f, -0.01915971f, 
    0.00306019f, 0.00337501f, 0.02898584f, -0.02866185f, -0.00597216f, -0.02830417f, 0.01536563f, -0.01456329f, 
    0.01148082f, -0.03000178f, -0.04148103f, 0.01870768f, 0.01681228f, -0.00067161f, 0.01582272f, -0.02386370f, 
    -0.01627142f, 0.01950859f, 0.01104015f, -0.03803540f, -0.01451442f, 0.00280454f, 0.01517564f, 0.00708689f, 
    -0.00967740f, 0.01310890f, -0.00989768f, 0.00993064f, -0.00780507f, -0.01134795f, 0.00922600f, -0.02190757f, 
    0.00686365f, -0.03465069f, -0.03079827f, 0.01573760f, 0.02639693f, 0.02035015f, -0.01395716f, 0.02658270f, 
    0.01714506f, -0.00439444f, -0.01584985f, -0.03613518f, -0.02180146f, -0.00690994f, 0.01690654f, -0.02299345f, 
    -0.02530264f, 0.02374546f, 0.00058978f, -0.03013517f, -0.00698310f, -0.04173587f, -0.01767994f, 0.02253506f, 
    -0.02694837f, -0.03876472f, -0.02072778f, 0.00740225f, 0.01546941f, -0.01425547f, -0.01551280f, 0.01582203f, 
    -0.01862057f, 0.00803568f, -0.01931797f, -0.02825567f, 0.01267098f, -0.00619521f, -0.00179288f, 0.02600083f, 
    -0.03548438f, 0.02043903f, 0.02241501f, 0.01876455f, 0.02648601f, -0.00704533f, -0.01539994f, -0.02336675f, 
    -0.02070059f, -0.03536057f, -0.04007087f, -0.02193182f, -0.04155129f, -0.00760781f, -0.02625828f, -0.02068857f, 
    0.02635552f, -0.03646227f, 0.00751509f, -0.00377384f, -0.03612716f, 0.00096880f, 0.02088379f, 0.01943694f, 
    0.02493289f, 0.03002522f, -0.02241585f, -0.01919357f, -0.01657166f, 0.02016800f, 0.00800299f, -0.03507516f, 
    -0.01694207f, 0.02678045f, -0.01776015f, -0.00343068f, 0.00748233f, -0.00608672f, -0.04043768f, 0.01195922f, 
    0.01917529f, -0.01737013f, -0.02681159f, 0.02398402f, -0.03273465f, 0.00717765f, -0.02241030f, 0.01668003f, 
    0.01650476f, -0.03665825f, -0.03330582f, 0.01326755f, 0.02988657f, 0.00825788f, -0.01251205f, 0.01582588f, 
    0.00470853f, 0.00505360f, -0.02120183f, 0.01355626f, 0.00294572f, -0.00547752f, -0.03285133f, -0.01070732f, 
    -0.00341743f, 0.01831838f, 0.01321156f, -0.02183412f, -0.00360684f, 0.01177285f, 0.02802328f, -0.00013330f, 
    0.02978675f, 0.01871285f, -0.01324069f, -0.03077655f, -0.02476679f, 0.02615027f, -0.01559398f, -0.01871923f, 
    -0.02790290f, 0.02811471f, -0.03978144f, -0.01648376f, -0.00756875f, -0.01623769f, 0.01336411f, 0.02497561f, 
    0.00333636f, 0.03006423f, -0.02683222f, -0.01513965f, -0.03249220f, 0.01575549f, -0.04115250f, 0.01381722f, 
    0.01836167f, -0.02799917f, 0.00791648f, -0.02238050f, -0.00044379f, -0.01279193f, 0.01674401f, -0.03965225f, 
    -0.03045867f, -0.02702267f, -0.00346280f, -0.02718305f, -0.01701876f, -0.00502079f, 0.00095140f, -0.02937477f, 
    -0.01598838f, -0.04076099f, -0.03500619f, -0.02269259f, -0.00600810f, -0.02412911f, 0.02446513f, -0.02265160f, 
    -0.02695109f, 0.02422613f, -0.01581208f, 0.01471621f, -0.00089905f, -0.03439957f, -0.00823596f, 0.02561999f, 
    -0.00451557f, -0.01184348f, -0.02712984f, 0.00160999f, 0.00830422f, -0.01486198f, 0.01966980f, 0.00052720f, 
    -0.01713612f, -0.02819865f, -0.02572651f, 0.01924601f, -0.03303722f, -0.03946226f, -0.01452480f, 0.00010536f, 
    -0.00902278f, -0.01704090f, -0.02834562f, -0.03086906f, -0.03335211f, -0.01765917f, -0.00779125f, -0.00733601f, 
    -0.02893413f, 0.02196536f, -0.03440361f, -0.03628350f, 0.01186033f, -0.00995398f, 0.02472334f, -0.00233482f, 
    -0.03221420f, -0.00829653f, -0.00770795f, 0.00294084f, -0.04143600f, 0.01675681f, -0.03989108f, -0.00411189f, 
    0.00819836f, -0.00857022f, 0.01202805f, -0.02936753f, 0.02451060f, 0.00758289f, 0.00149825f, -0.02842735f, 
    0.01861368f, -0.01621064f, -0.02777362f, 0.01246473f, 0.02040612f, -0.03542545f, 0.00931582f, 0.02162215f, 
    -0.03184885f, -0.04152440f, 0.01718023f, -0.00036747f, 0.02626296f, -0.03049639f, 0.02647632f, 0.01335284f, 
    0.02077022f, -0.00936901f, -0.01286713f, -0.03415756f, -0.02711561f, -0.02874692f, 0.02780868f, -0.02970676f, 
    -0.03453242f, -0.00825918f, 0.01963307f, -0.01977499f, 0.02404631f, 0.01539611f, -0.02820312f, -0.00251807f, 
    -0.00064467f, 0.02430036f, 0.00380579f, 0.02480399f, -0.02148261f, 0.02567530f, 0.01097910f, -0.00048513f, 
    -0.00240647f, -0.03331320f, -0.02855714f, -0.00269728f, -0.01853455f, 0.02183860f, 0.00723762f, 0.01987610f, 
    0.02931303f, -0.01860720f, -0.03934329f, -0.02772781f, -0.00497628f, -0.02212928f, 0.02659860f, -0.03022294f, 
    -0.01400810f, -0.03302107f, 0.00652394f, -0.01566485f, 0.02327652f, 0.02705776f, 0.01547210f, -0.03334551f, 
    0.00324406f, 0.00017441f, 0.02809432f, 0.01212811f, -0.04152804f, -0.01718397f, 0.00420146f, 0.01753923f, 
    -0.00617970f, -0.01213631f, 0.00387053f, -0.02610227f, -0.03554684f, -0.02914844f, -0.01405329f, -0.02929843f, 
    0.00800898f, 0.00940815f, -0.00833370f, 0.02043514f, -0.01948529f, 0.00918945f, 0.00703220f, 0.01486513f, 
    -0.01943000f, -0.01761775f, 0.01179681f, -0.03064647f, 0.02485375f, -0.00096438f, -0.00439830f, 0.01069620f, 
    -0.01981179f, 0.02182915f, 0.02814689f, -0.01493606f, -0.00980612f, 0.00198661f, 0.00041725f, -0.03360051f, 
    0.00643882f, 0.01185367f, -0.01028860f, 0.01512599f, -0.02418710f, -0.02233718f, -0.03508078f, 0.02298676f, 
    -0.03573538f, 0.00429269f, -0.03792708f, -0.04006580f, 0.01289757f, 0.01687196f, 0.02233602f, -0.02163373f, 
    -0.00492356f, 0.00523812f, -0.00784491f, -0.03703237f, -0.03953321f, 0.02175127f, -0.04102865f, 0.02949990f, 
    0.02296283f, 0.02695183f, -0.01675595f, -0.00482395f, 0.00318148f, 0.00305363f, -0.01519067f, 0.01887622f, 
    -0.03887180f, -0.02095087f, 0.01208885f, 0.02384432f, -0.03430813f, 0.01287128f, 0.02652432f, -0.00440131f, 
    -0.03602618f, 0.01322049f, -0.03619574f, -0.04049522f, -0.01412285f, -0.02000915f, 0.01895070f, 0.01385005f, 
    0.00334874f, 0.00217752f, 0.00984650f, 0.01456568f, -0.00039794f, 0.01800193f, -0.02857593f, -0.04001661f, 
    -0.00590967f, -0.02259233f, -0.02303858f, -0.02826182f, -0.00364770f, 0.00643528f, -0.00064805f, -0.04028507f, 
    0.00603552f, -0.03045016f, 0.01331175f, 0.00467244f, -0.00321916f, -0.01284879f, -0.01075480f, -0.02977012f, 
    0.01781362f, 0.01649637f, 0.01779541f, 0.02227544f, 0.00853586f, -0.01038847f, 0.01475970f, 0.01156355f, 
    0.09205368f, -0.05620447f, -0.25700867f, -0.27988851f, 0.01886601f, -0.00091761f, -0.14485522f, -0.04101009f, 
    -0.02389027f, -0.15317094f, 0.12996230f, 0.04025678f, 0.08318505f, 0.31165707f, 0.15584081f, 0.04576887f, 
    0.17107491f, 0.06059813f, -0.02037192f, 0.24779201f, -0.01709759f, -0.00018318f, -0.05970475f, -0.04653278f, 
    0.25569254f, 0.22941378f, 0.13753723f, -0.01810955f, 0.19345766f, -0.09882312f, 0.00269344f, 0.03251133f, 
    -0.11945600f, -0.07174843f, -0.02083536f, 0.06920892f, -0.23980868f, -0.16386659f, 0.09307636f, 0.01221203f, 
    0.09674095f, 0.03167287f, -0.04686791f, -0.03107839f, 0.12155644f, 0.01234597f, 0.12640934f, -0.06657348f, 
    0.16121440f, -0.21272990f, -0.01777627f, -0.11402305f, 0.02953888f, 0.02209572f, -0.06295301f, 0.06226758f, 
    -0.20432028f, 0.01298039f, 0.02854082f, -0.24098571f, 0.35905772f, 0.17125505f, -0.33320138f, -0.25449413f, 
    0.19894263f, -0.06921098f, -0.02139443f, 0.03023970f, 0.09433932f, -0.09047870f, -0.09362073f, 0.06402354f, 
    0.01226100f, 0.00653376f, 0.04257009f, 0.06093455f, -0.07455488f, 0.05910191f, 0.12534828f, 0.07882313f, 
    0.11029248f, -0.10942156f, -0.06631923f, -0.03158818f, 0.14855860f, 0.42172542f, 0.20348687f, 0.01700154f, 
    0.12240510f, 0.12868698f, 0.02460530f, 0.03899822f, -0.04943645f, -0.09992985f, -0.05284736f, -0.02463693f, 
    0.07728323f, 0.41091341f, 0.07901227f, -0.05999722f, 0.10646315f, 0.23867601f, -0.00191731f, 0.04161683f, 
    -0.07792123f, -0.12545431f, -0.06648106f, -0.13641205f, 0.29685658f, 0.14506172f, 0.10651337f, 0.10894111f, 
    -0.16749051f, -0.16815329f, 0.05481289f, -0.07755764f, 0.00015555f, 0.00283105f, 0.03835640f, 0.11130799f, 
    -0.25828171f, 0.35005516f, -0.01796640f, 0.08147527f, 0.12522624f, -0.00297560f, 0.04388135f, 0.12636973f, 
    0.02553607f, 0.05956263f, -0.12696512f, -0.07595941f, -0.03443211f, 0.22872607f, -0.02733233f, -0.00990278f, 
    0.04150861f, 0.13778906f, 0.10127642f, -0.07704718f, -0.09202661f, -0.03460168f, 0.01008249f, 0.04991221f, 
    -0.60281259f, -0.11069953f, -0.01370911f, 0.15785569f, 0.10467929f, -0.15389082f, -0.14473070f, 0.15295878f, 
    0.01535008f, 0.10099453f, -0.03567353f, 0.04288847f, -0.17826949f, 0.13280779f, -0.00072257f, 0.11120126f, 
    -0.05154349f, 0.19563566f, 0.12114946f, 0.25791925f, -0.02742881f, 0.00409118f, 0.01281421f, -0.00528863f, 
    -0.20179991f, 0.04219221f, 0.07142729f, -0.07503501f, 0.09165792f, -0.02930325f, -0.20016237f, 0.12407582f, 
    0.08318288f, 0.00138630f, -0.02927138f, -0.08398711f, 0.08770213f, -0.19239382f, 0.12293379f, -0.04991980f, 
    -0.04485765f, -0.05409170f, 0.29211909f, -0.23289227f, 0.10932832f, -0.11927672f, -0.08396626f, 0.00592162f, 
    0.09821210f, 0.17310570f, -0.13939340f, -0.02478199f, -0.01963047f, -0.09685434f, -0.07315482f, -0.05447105f, 
    -0.15841319f, -0.04095224f, 0.12217139f, 0.07718751f, -0.46207851f, -0.07168584f, 0.02138618f, 0.04747413f, 
    0.09426440f, -0.01882299f, -0.08812509f, -0.00760772f, 0.07919846f, 0.12652597f, 0.07741118f, -0.01080351f, 
    0.17030442f, 0.04694961f, -0.15243639f, -0.25096175f, 0.12847859f, 0.11276001f, 0.05093981f, -0.19594285f, 
    0.01282331f, 0.00282819f, -0.05955522f, 0.06878081f, -0.06536360f, -0.20487200f, -0.20556493f, -0.14397071f, 
    0.03694506f, 0.03487370f, 0.00115181f, 0.06358090f, -0.02480110f, 0.06601109f, -0.00053626f, 0.04747250f, 
    0.15001133f, -0.20877628f, -0.19758566f, 0.01713945f, 0.00364709f, 0.00504146f, 0.04739768f, 0.00105226f, 
    0.09297820f, 0.04825328f, -0.23165406f, 0.16841163f, 0.26212674f, -0.27687183f, -0.01121474f, -0.01228172f, 
    0.08754010f, 0.10926659f, -0.08863693f, -0.13986211f, 0.06062727f, 0.00414314f, 0.10303999f, -0.03047525f, 
    0.03063112f, 0.19260389f, 0.14297427f, 0.15032987f, -0.02291711f, -0.08242032f, -0.02897942f, 0.00668953f, 
    0.03656431f, -0.07623338f, -0.05674847f, 0.03768821f, 0.01084783f, 0.00920271f, -0.04107113f, -0.03080961f, 
    -0.08083875f, -0.15069172f, 0.04619217f, -0.03134789f, -0.00197658f, 0.04479474f, 0.03027265f, 0.11798672f, 
    0.05949352f, 0.18387717f, -0.10056783f, -0.06837844f, -0.01866083f, 0.05323353f, -0.01684616f, 0.07524501f, 
    -0.06070958f, 0.04131972f, -0.06698642f, -0.01445554f, -0.02327878f, -0.02898390f, -0.17454499f, -0.13424939f, 
    0.06801920f, 0.00634088f, -0.01861086f, -0.02413659f, -0.01775917f, -0.03078461f, 0.02346963f, 0.09864399f, 
    0.13347156f, -0.03497772f, 0.21444121f, -0.08754933f, 0.13964166f, -0.00859514f, 0.06415451f, 0.12292334f, 
    -0.03388948f, -0.22274895f, -0.04104066f, 0.00650077f, -0.00190453f, -0.11785242f, -0.39896992f, -0.02877167f, 
    0.05033665f, -0.00011349f, -0.08214228f, 0.03952925f, 0.00404927f, 0.06845919f, 0.09934504f, -0.02823477f, 
    -0.09754188f, -0.01975689f, 0.01442686f, 0.00896751f, -0.02308690f, -0.07121848f, -0.27251956f, -0.11813036f, 
    -0.13808148f, -0.01681905f, 0.19339247f, 0.09826303f, 0.17808603f, -0.11795339f, 0.16973482f, 0.08021083f, 
    -0.11013146f, 0.08407213f, 0.18259162f, -0.07992108f, -0.01190286f, -0.07306458f, -0.14989154f, 0.22130550f, 
    0.12174266f, 0.09475812f, 0.16784108f, 0.16692513f, 0.05915354f, 0.06914449f, 0.02635869f, 0.08241797f, 
    0.00406781f, -0.05724714f, -0.01404956f, -0.12229323f, 0.36384380f, 0.26785800f, 0.25841960f, -0.02614591f, 
    -0.13499683f, -0.09687677f, 0.08231722f, 0.14231668f, 0.02778858f, -0.10636557f, -0.13767561f, 0.06340914f, 
    -0.11203692f, 0.10583671f, 0.00220370f, 0.01473187f, 0.02370978f, 0.10968556f, -0.02453764f, -0.11042350f, 
    -0.00906393f, 0.03235067f, 0.06004799f, -0.13221613f, 0.08958503f, 0.11271132f, 0.08253779f, -0.00191718f, 
    -0.00883509f, 0.27404773f, -0.09591366f, -0.08606082f, 0.03999035f, -0.08465284f, 0.06704038f, -0.03454761f, 
    0.11418646f, 0.15862110f, 0.28593409f, 0.05705895f, -0.08733466f, 0.09367371f, 0.18733035f, 0.06737677f, 
    0.09632946f, 0.07012915f, -0.21924658f, -0.18304479f, 0.22513930f, 0.22639202f, 0.15905467f, -0.06630984f, 
    0.02834106f, 0.09367670f, 0.17809504f, 0.02252403f, 0.01862709f, 0.02803728f, 0.01314932f, -0.00160698f, 
    0.11969138f, -0.17933522f, 0.14101408f, -0.39152983f, -0.03738003f, -0.04309278f, -0.08731279f, 0.08797517f, 
    0.00179822f, 0.03338141f, -0.00102709f, -0.01338082f, -0.06209550f, 0.02658254f, -0.06939022f, -0.03302490f, 
    0.08938409f, -0.00351086f, -0.16207735f, 0.18884429f, -0.21156043f, -0.04397402f, 0.16034152f, 0.00826601f, 
    0.23359905f, 0.25353289f, 0.16538274f, -0.19510721f, 0.12750064f, -0.02176212f, -0.00481890f, 0.17649880f, 
    0.07407019f, -0.03051763f, -0.09735034f, -0.02630420f, 0.25197852f, 0.21334681f, 0.03865535f, -0.07284602f, 
    -0.03510740f, -0.04590121f, 0.20744886f, 0.06993794f, -0.03148988f, 0.00406952f, -0.04346097f, 0.07301039f, 
    -0.05350754f, -0.22985344f, -0.43858007f, -0.20865743f, -0.04492424f, -0.13066937f, -0.01494521f, -0.02399071f, 
    -0.01325886f, 0.02645154f, 0.03103911f, 0.07017446f, -0.15143737f, -0.08803336f, -0.19813724f, -0.11128341f, 
    -0.01283002f, -0.04295620f, -0.03937290f, -0.06616022f, -0.14873551f, -0.20827602f, 0.00038221f, -0.04663374f, 
    0.04904975f, 0.23011674f, 0.03782856f, -0.09331277f, 0.14848503f, 0.00649505f, -0.14801550f, -0.09671504f, 
    0.00559073f, -0.03413663f, -0.10187352f, -0.09903679f, 0.01248966f, -0.17613772f, 0.15791717f, -0.54913425f, 
    -0.15862338f, -0.22261444f, 0.00470293f, 0.04150386f, 0.09132870f, 0.03693032f, 0.05168166f, 0.02384075f, 
    -0.02838389f, 0.00007071f, -0.18447366f, 0.02371079f, 0.01169798f, -0.15529414f, -0.18284047f, -0.01947163f, 
    -0.01049818f, 0.04783076f, 0.08518416f, -0.05556760f, 0.09344085f, -0.34239951f, -0.19655976f, -0.08843444f, 
    -0.02280491f, 0.02090777f, -0.04555346f, -0.19991583f, 0.13539158f, 0.11805850f, -0.07097725f, -0.01630699f, 
    0.32473937f, -0.63536364f, 0.01396970f, 0.01353575f, -0.03904719f, -0.02582194f, 0.05580453f, -0.16945840f, 
    0.08466113f, 0.12497081f, -0.07506739f, -0.16577192f, 0.16235755f, -0.28706995f, 0.07137631f, 0.00350250f, 
    0.07767388f, 0.07879546f, -0.01593087f, -0.10073048f, 0.12847927f, -0.13538866f, 0.10027074f, -0.12127923f, 
    0.27619618f, 0.40108049f, 0.25535083f, -0.01033863f, -0.09287360f, -0.22267775f, 0.02697947f, 0.21867630f, 
    -0.01709998f, -0.03083874f, -0.09943032f, 0.14836982f, 0.17522341f, 0.10591697f, 0.31176317f, 0.06923808f, 
    -0.07399485f, -0.09723253f, 0.07365441f, 0.04456283f, 0.13634440f, -0.05965926f, 0.05567411f, -0.01459755f, 
    0.53986669f, -0.17244290f, 0.52293634f, -0.34778073f, -0.18630633f, -0.24574754f, 0.32039866f, 0.24214973f, 
    0.01405733f, -0.02558457f, -0.04106336f, -0.09853770f, -0.20667233f, -0.34081015f, -0.11822850f, 0.12230793f, 
    -0.00447555f, -0.13774526f, -0.05389521f, -0.01250693f, -0.09478707f, 0.09894717f, -0.04581041f, -0.09805509f, 
    0.11758611f, -0.23912245f, -0.22511464f, -0.03560747f, 0.03832888f, -0.00072869f, 0.00473114f, 0.14519115f, 
    0.05163448f, -0.02499115f, 0.13255201f, -0.09553101f, -0.10311349f, -0.27974620f, -0.31897581f, -0.07285652f, 
    0.03470949f, -0.01520865f, -0.06966742f, 0.03859797f, 0.06279369f, -0.00509911f, 0.22229405f, -0.10602260f, 
    0.27447554f, 0.21771708f, 0.12088013f, -0.10304725f, 0.08720536f, 0.14272483f, -0.09719343f, -0.20849510f, 
    0.20568991f, -0.15488783f, -0.08580691f, 0.05856729f, -0.05255786f, 0.04514216f, 0.06717083f, 0.10380848f, 
    -0.07637728f, 0.01314614f, -0.03612763f, 0.03945427f, 0.02699069f, 0.07340566f, 0.01886477f, 0.02545057f, 
    -0.06432243f, 0.00223748f, -0.06260362f, -0.20379969f, -0.05871269f, -0.30721465f, -0.17461857f, -0.12320112f, 
    0.04150189f, -0.02780932f, 0.05493654f, 0.13210851f, 0.19518894f, 0.13102460f, 0.22157708f, 0.02410011f, 
    0.12763855f, -0.12732679f, 0.10433611f, 0.00884099f, -0.00453894f, -0.04480755f, -0.00714445f, 0.05552732f, 
    0.30911312f, -0.27763519f, -0.24778236f, -0.12131155f, 0.06733608f, -0.07040115f, -0.01717475f, -0.08689568f, 
    -0.01935645f, -0.15621072f, 0.03153555f, -0.07738739f, 0.08970111f, 0.30060989f, 0.09753670f, -0.12024456f, 
    0.10366765f, 0.09971504f, -0.16492356f, -0.04402432f, 0.05829079f, 0.02338180f, 0.14675225f, 0.06990153f, 
    0.04848642f, -0.20523892f, -0.42877182f, -0.14232185f, 0.01902889f, -0.00015865f, 0.00985119f, 0.09931523f, 
    0.04873120f, 0.11465687f, 0.03745271f, -0.22711444f, 0.18836190f, -0.03081048f, 0.07396541f, 0.02938737f, 
    -0.03553121f, -0.00358186f, -0.00767538f, 0.19890571f, 0.21224348f, 0.05667333f, -0.00693461f, -0.02552200f, 
    -0.35458747f, -0.20680945f, -0.12291090f, 0.27901191f, -0.00738997f, -0.00120841f, -0.03258330f, -0.05244433f, 
    0.00902956f, -0.06763133f, -0.13191570f, -0.11499364f, -0.25485218f, -0.21806958f, 0.01893693f, 0.07749753f, 
    0.13062811f, 0.03272704f, -0.06236563f, 0.07188045f, 0.10514186f, 0.03828991f, 0.07176474f, 0.00324011f, 
    0.07486554f, 0.09871818f, -0.13457850f, -0.08365416f, 0.17455155f, 0.26963815f, 0.05289797f, 0.06628613f, 
    0.14815369f, -0.05994214f, 0.17007770f, -0.13741794f, -0.07116898f, 0.12083547f, 0.14920337f, -0.10297468f, 
    0.01091713f, -0.05126136f, 0.09413536f, 0.05486572f, 0.02964779f, 0.01048102f, 0.01574224f, -0.04903088f, 
    -0.06930241f, 0.20662627f, -0.02261049f, -0.16407174f, 0.04187834f, -0.09138726f, 0.10038809f, -0.00971929f, 
    0.00754955f, 0.13191672f, 0.09079361f, 0.13885021f, 0.02544576f, 0.23683734f, -0.00522323f, -0.08904824f, 
    0.02699433f, 0.07089585f, -0.05158000f, -0.06124571f, 0.13826422f, 0.04184864f, 0.21421556f, -0.20228708f, 
    0.21494390f, -0.05545681f, -0.04411918f, 0.24525903f, 0.02437138f, -0.01598551f, 0.03666883f, -0.14760692f, 
    0.17045142f, -0.00379767f, 0.11877458f, -0.04417138f, -0.21596043f, 0.09955008f, 0.06779265f, 0.03627723f, 
    0.28418374f, 0.10867764f, 0.01133390f, 0.13082130f, 0.00791941f, -0.17814548f, 0.16464792f, -0.10902581f, 
    0.04059058f, -0.17354977f, 0.38624209f, 0.23518573f, 0.00423431f, -0.11277322f, -0.03950878f, -0.09196599f, 
    0.07789098f, -0.12063687f, -0.05835411f, -0.08754811f, -0.35003486f, 0.00517243f, -0.21418113f, -0.22238876f, 
    -0.07213394f, -0.05887295f, 0.12928674f, 0.11039733f, -0.02681638f, -0.07183322f, 0.06025425f, 0.03233081f, 
    -0.49390426f, -0.20455198f, -0.16792022f, -0.29491040f, 0.02585327f, -0.03212464f, 0.14512599f, 0.22503151f, 
    0.01168064f, -0.15622243f, 0.00432913f, 0.03175799f, 0.01068159f, 0.02275560f, 0.07955556f, -0.06301347f, 
    0.12083109f, 0.03769414f, 0.01060278f, 0.08510495f, -0.13289291f, -0.11623980f, -0.07249818f, -0.03041843f, 
    -0.41181695f, 0.10462332f, -0.12454670f, 0.02977859f, 0.18126692f, 0.06759526f, 0.04008746f, -0.01089808f, 
    0.13640434f, -0.05833418f, -0.07488570f, 0.11466400f, -0.10587016f, 0.20946915f, -0.17580342f, -0.15682106f, 
    0.20831512f, -0.02912458f, 0.28412864f, 0.06597999f, 0.08731481f, -0.00069603f, 0.03112460f, -0.01349861f, 
    0.06939986f, -0.12941080f, 0.02604121f, 0.02767692f, 0.01176108f, 0.07783116f, 0.04094859f, 0.03973425f, 
    0.21484526f, 0.07563238f, -0.03574065f, 0.02843203f, 0.17732710f, -0.24184552f, -0.00551452f, 0.23520036f, 
    -0.05580908f, 0.09523823f, -0.01012994f, 0.00586405f, 0.19153546f, -0.00980755f, 0.00907805f, -0.09232850f, 
    -0.13804787f, 0.10071089f, -0.21659949f, 0.34515080f, 0.09564844f, -0.08361875f, 0.02011575f, 0.03465715f, 
    0.01639459f, 0.24111159f, -0.01631821f, 0.02068073f, 0.44001931f, 0.02267304f, -0.11001616f, 0.26081693f, 
    0.23346075f, 0.09222385f, -0.01203141f, 0.03330822f, 0.04511105f, 0.09016822f, -0.18627287f, 0.13741715f, 
    0.00680459f, 0.14812672f, -0.10717115f, 0.01986684f, 0.04458829f, 0.12047885f, 0.00083042f, 0.24667363f, 
    0.15453850f, 0.17783383f, 0.07858016f, -0.13957679f, -0.00043740f, 0.02925424f, -0.18100649f, 0.06043056f, 
    0.15067540f, 0.04631128f, -0.01410878f, 0.06164708f, -0.08533122f, 0.00988801f, 0.11453291f, -0.02366037f, 
    -0.14241667f, 0.17053480f, -0.08907953f, -0.16835171f, -0.00412415f, 0.15907536f, 0.17331421f, 0.29808444f, 
    0.09854533f, -0.24996004f, 0.05034507f, 0.07888284f, -0.28923303f, -0.16840170f, -0.08008869f, -0.01017008f, 
    -0.04781680f, 0.03828339f, 0.01692962f, 0.03691937f, 0.18929715f, -0.03801793f, 0.04458790f, 0.01532191f, 
    0.29066664f, 0.14646488f, -0.15376735f, 0.54476821f, 0.17630862f, -0.09226882f, 0.09880390f, 0.11738459f, 
    0.18477513f, 0.15225780f, 0.12259553f, 0.04499082f, 0.10558407f, -0.08890969f, 0.11413627f, -0.19112766f, 
    -0.02197951f, -0.05003949f, 0.02834594f, 0.11703676f, 0.04698772f, 0.22049439f, 0.16168375f, -0.02204002f, 
    0.19158848f, 0.05827612f, 0.20517962f, -0.20162264f, -0.01291509f, 0.16069938f, 0.07413241f, -0.17385143f, 
    0.00581856f, 0.01229478f, -0.07310159f, -0.05669377f, -0.24347873f, -0.08744755f, -0.04407656f, -0.00766056f, 
    0.18946858f, 0.03362513f, 0.14017832f, 0.16036946f, 0.00180192f, 0.13051668f, -0.03932637f, -0.00392053f, 
    -0.50114304f, -0.15779185f, 0.01274413f, 0.20884326f, -0.11753900f, -0.03828125f, -0.04727898f, -0.04278086f, 
    0.14098383f, 0.07641697f, 0.19068046f, 0.20373856f, -0.20881718f, -0.05383672f, -0.10506238f, -0.13471805f, 
    -0.07851256f, -0.01096353f, -0.06248822f, 0.04930101f, 0.10650833f, 0.00861187f, 0.06676767f, 0.10239861f, 
    0.18355095f, -0.17189595f, -0.07295285f, 0.22283579f, 0.13538893f, 0.09827305f, 0.27153450f, 0.08845266f, 
    0.02109596f, -0.08054751f, 0.08502653f, 0.07129490f, -0.26013401f, 0.02103434f, 0.14468201f, -0.19306418f, 
    -0.08193058f, -0.04515514f, -0.02412937f, 0.00291758f, 0.15815301f, 0.08243519f, 0.10557556f, 0.07000979f, 
    0.17091683f, 0.15194091f, -0.05465420f, 0.12323272f, 0.09778321f, 0.07601467f, -0.02369258f, 0.19054046f, 
    0.18386176f, 0.20039268f, -0.04182900f, 0.05515257f, 0.95760638f, -0.57073319f, 0.36234453f, 0.33946729f, 
    0.38311493f, -0.04149597f, -0.00234737f, 0.09261199f, 0.13882460f, 0.02963476f, 0.27151334f, 0.20289522f, 
    -0.29145178f, -0.08100425f, -0.18866020f, -0.28277880f, -0.09659164f, -0.16113779f, -0.00034991f, -0.01204520f, 
    0.07043716f, -0.02029748f, 0.00561071f, -0.00570957f, -0.62039727f, -0.09484029f, -0.00040850f, 0.06828663f, 
    -0.01243429f, -0.10217145f, -0.03849032f, 0.05623623f, -0.02701319f, -0.01682841f, 0.03939447f, 0.25904974f, 
    -0.29097793f, -0.10744064f, -0.16070317f, -0.04520690f, -0.06711422f, -0.00048362f, 0.13018674f, -0.14418136f, 
    0.09034660f, 0.09171339f, 0.24538898f, -0.09603526f, -0.08864272f, -0.09047797f, -0.08942045f, -0.19792616f, 
    -0.10758667f, 0.00588424f, -0.25478369f, -0.07323512f, 0.09970109f, -0.02948825f, -0.06180238f, -0.14016320f, 
    -0.10385613f, -0.02573502f, -0.03257562f, -0.15884341f, 0.00755527f, -0.03790538f, -0.04836691f, -0.04358673f, 
    -0.12522769f, -0.11814500f, -0.02845530f, 0.12238360f, 0.05752346f, -0.12734438f, 0.04033005f, -0.09391750f, 
    0.10941797f, 0.12915213f, 0.06988283f, -0.01670425f, 0.07807364f, 0.05766975f, -0.02697073f, -0.00092259f, 
    -0.19003358f, -0.10108452f, -0.08113913f, -0.05796169f, -0.02286787f, -0.10811514f, 0.02064400f, -0.16857611f, 
    0.05743617f, 0.02475957f, 0.01901868f, -0.04655563f, -0.39280954f, -0.18107122f, 0.07415724f, -0.10822681f, 
    0.10026579f, -0.14661330f, -0.03664877f, 0.10242925f, 0.13746567f, 0.14993846f, 0.06426019f, 0.22095506f, 
    0.00591625f, -0.21839562f, 0.31791532f, 0.19206832f, 0.06835245f, -0.06363482f, -0.04598705f, 0.13015029f, 
    0.01723850f, -0.03590398f, 0.03342919f, 0.27595127f, 0.08568854f, -0.04630491f, -0.01157548f, 0.05556733f, 
    0.23238352f, -0.04016446f, 0.15911138f, 0.11851358f, -0.06940392f, -0.01728748f, -0.00150596f, 0.13816966f, 
    -0.13395999f, -0.14178620f, 0.01914924f, -0.09317379f, 0.04949173f, 0.07929473f, 0.06893698f, -0.00422779f, 
    0.06791946f, -0.00897901f, -0.14204165f, 0.00891041f, -0.31110212f, -0.17294461f, -0.04891519f, -0.13702664f, 
    0.01913426f, -0.01849625f, 0.01079618f, 0.01744760f, 0.09306120f, 0.19946682f, -0.04093843f, -0.15578552f, 
    -0.11311675f, -0.21638557f, -0.03261749f, -0.14085424f, 0.06862689f, -0.02723599f, 0.15891916f, -0.00101292f, 
    -0.03234149f, 0.05393993f, 0.18710518f, 0.27520010f, 0.59194738f, -0.44127664f, 0.34449944f, -0.32262087f, 
    0.15203983f, 0.20932248f, 0.13388193f, 0.01476235f, -0.03862327f, -0.04632431f, -0.03169357f, -0.09372801f, 
    -0.24720015f, 0.05585035f, -0.10762250f, -0.06762725f, 0.14067437f, 0.02828312f, -0.01500381f, 0.03025174f, 
    0.00428936f, -0.01572449f, 0.05615726f, 0.03632284f, 0.19373515f, -0.22480428f, -0.00801041f, 0.07304832f, 
    0.13572712f, -0.00343253f, 0.04594608f, -0.04939671f, -0.05237023f, 0.05850225f, 0.03101532f, -0.00794674f, 
    -0.13638784f, -0.04889999f, 0.05397809f, 0.03641150f, 0.08314729f, -0.05434620f, -0.02820608f, -0.03889399f, 
    0.08634366f, -0.04068036f, 0.09057975f, 0.08207406f, 0.44315010f, -0.12220301f, 0.12803560f, 0.08822337f, 
    0.16626106f, -0.09101051f, 0.14450535f, 0.02292508f, 0.11166506f, 0.05314724f, 0.06662692f, -0.00555806f, 
    -0.08236953f, -0.00543052f, 0.08147114f, -0.04532934f, -0.04504550f, -0.04574823f, 0.08337469f, -0.07164553f, 
    0.13325889f, 0.07820691f, 0.06391566f, -0.10367715f, 0.25165060f, -0.23286189f, 0.11664969f, -0.12786891f, 
    0.21861821f, 0.18345429f, 0.04719480f, -0.12662327f, 0.04450517f, -0.14914972f, -0.07371911f, -0.01643595f, 
    0.08531299f, 0.03846321f, 0.26272058f, -0.03783677f, 0.05047182f, -0.08706202f, 0.12706050f, 0.06391683f, 
    -0.00121587f, -0.01868319f, 0.14300296f, 0.01276164f, -0.21746567f, 0.21984178f, 0.01438843f, -0.15693259f, 
    -0.05414745f, -0.01284743f, -0.17060423f, -0.08932152f, -0.07542419f, 0.16473222f, 0.01140222f, 0.01148164f, 
    -0.00640137f, -0.26556101f, 0.04093662f, -0.08088465f, 0.13864368f, -0.07456508f, 0.08894701f, 0.06370120f, 
    -0.00416113f, 0.03211382f, -0.07133336f, 0.13925323f, -0.33192655f, -0.19609016f, -0.13008972f, 0.03191044f, 
    -0.00281767f, -0.01475255f, 0.03591880f, 0.05930074f, -0.00923013f, -0.05538449f, 0.02333921f, 0.07886874f, 
    -0.22343697f, 0.01431291f, -0.29008749f, -0.27669019f, -0.07130570f, -0.13316500f, -0.06097627f, 0.17695042f, 
    -0.05221252f, -0.19348194f, 0.00547667f, 0.15917468f, -0.00501703f, -0.09265106f, -0.26522684f, -0.15554793f, 
    -0.16174991f, 0.20051667f, -0.09337376f, 0.02986188f, 0.04742777f, -0.02146562f, 0.04289067f, -0.11668388f, 
    0.54011911f, 0.04730329f, -0.01265446f, 0.06332980f, 0.35956645f, 0.08571079f, 0.05146970f, 0.07621051f, 
    0.01639251f, -0.16372043f, 0.00969854f, -0.18506806f, -0.16354838f, 0.10473238f, -0.05340924f, -0.30414280f, 
    0.02257827f, 0.11180527f, 0.04016619f, -0.06251542f, -0.00296621f, -0.00617619f, -0.05183360f, 0.08197223f, 
    -0.42549658f, -0.21435978f, 0.14546002f, -0.26030195f, -0.02443328f, -0.00180047f, 0.05312040f, 0.00283505f, 
    0.10729069f, 0.07387599f, 0.08180816f, 0.00479761f, -0.08985677f, 0.18052609f, -0.15196095f, -0.29079935f, 
    -0.07830276f, 0.01874493f, 0.10655392f, 0.20305230f, -0.07432197f, -0.01119554f, 0.10445468f, -0.04758408f, 
    -0.17062993f, 0.02334997f, -0.21194759f, 0.03152582f, -0.09634411f, -0.07383215f, -0.12139580f, 0.00959644f, 
    -0.02204721f, 0.03365513f, 0.19783436f, 0.07716799f, 0.11273083f, -0.05988647f, 0.04442769f, -0.05968070f, 
    -0.00203096f, -0.12703076f, 0.11219930f, 0.08401405f, -0.10701526f, 0.04595721f, -0.03964334f, -0.01782539f, 
    -0.41584247f, 0.33898926f, -0.21100914f, 0.18101728f, -0.07597174f, 0.06483413f, 0.12150624f, 0.09127016f, 
    0.07407708f, 0.30336833f, -0.08807867f, 0.17778768f, -0.29894370f, 0.20897691f, -0.12245294f, 0.14623371f, 
    0.17647943f, 0.10907079f, 0.08026177f, 0.12295797f, 0.02460315f, 0.06418888f, 0.10090376f, 0.10307661f, 
    0.02473288f, -0.00157450f, 0.01378623f, -0.01947170f, -0.00057740f, -0.04566800f, -0.01791287f, -0.03332363f, 
    -0.02387795f, 0.01183565f, -0.03419782f, 0.02252240f, 0.02242997f, -0.01795054f, 0.00849635f, 0.02450361f, 
    0.00100837f, 0.00913421f, -0.04168409f, -0.00086194f, -0.01927453f, -0.04437348f, -0.04259855f, -0.01480053f, 
    -0.02583291f, 0.00403887f, -0.00609326f, -0.00861839f, 0.00273215f, 0.01900184f, -0.03697519f, -0.00752342f, 
    0.01023448f, 0.00822969f, 0.02111937f, 0.00990046f, 0.01034309f, 0.00510442f, 0.03821088f, -0.01990876f, 
    -0.02635065f, -0.02931720f, -0.01767410f, -0.00502600f, 0.01418528f, -0.00277937f, 0.01961671f, -0.03606718f, 
    -0.02436607f, -0.01872181f, -0.01835611f, 0.03225189f, 0.00066354f, -0.02195051f, 0.02972175f, -0.01256618f, 
    -0.03916338f, -0.00384178f, 0.00033977f, -0.01600408f, 0.02421169f, 0.00562036f, -0.00650029f, -0.02045485f, 
    -0.02437172f, -0.02961105f, 0.01807005f, -0.02239948f, 0.02323677f, 0.01294466f, -0.03125674f, 0.02298932f, 
    -0.02144016f, 0.01833780f, 0.02630449f, -0.00869227f, -0.04194917f, 0.01096205f, 0.00144429f, 0.00792281f, 
    0.02150708f, -0.01310723f, -0.01955419f, -0.03976413f, -0.02468528f, -0.03456884f, -0.02653636f, 0.00787285f, 
    0.00108380f, 0.00190149f, -0.00684832f, 0.00704364f, 0.00186204f, 0.00399494f, 0.01903781f, -0.04378776f, 
    0.01929488f, -0.00511892f, -0.00757669f, 0.02178144f, 0.00475541f, -0.01335746f, -0.01156649f, -0.03027875f, 
    0.01664862f, -0.03583132f, -0.03709447f, -0.01066260f, -0.00485869f, -0.01814955f, -0.03144460f, 0.00219181f, 
    -0.00933863f, -0.02064380f, 0.00276578f, -0.01156346f, 0.00538464f, 0.00967527f, -0.01946343f, -0.00373827f, 
    -0.00306747f, -0.02545906f, 0.00696370f, 0.02382080f, 0.00127019f, 0.01077919f, -0.00649934f, 0.01289945f, 
    0.00410303f, 0.01794503f, 0.01111385f, 0.02545469f, -0.02768730f, 0.01605886f, -0.02960908f, -0.03417708f, 
    0.01682824f, 0.01323030f, -0.02844139f, 0.01700668f, -0.01216569f, 0.01218783f, -0.03938507f, -0.02899284f, 
    -0.01235440f, -0.01494702f, 0.00541941f, -0.01703749f, -0.00419307f, -0.01106723f, -0.02245827f, -0.01998759f, 
    0.01424477f, -0.01755058f, 0.01059359f, 0.02393111f, -0.02502755f, -0.02411383f, 0.01196638f, -0.00328672f, 
    -0.00173045f, 0.01582677f, 0.01947841f, 0.02121805f, -0.02375870f, -0.00636041f, 0.02879780f, -0.00958003f, 
    0.02511603f, 0.01717847f, -0.01528517f, -0.01147385f, 0.00696950f, 0.00579356f, 0.02646790f, 0.01555775f, 
    0.00738955f, -0.03933247f, 0.00939057f, 0.02822580f, -0.02306541f, 0.01097511f, 0.01784940f, -0.00183268f, 
    0.01320756f, -0.03795568f, 0.00229151f, -0.01896400f, 0.02763102f, 0.01365320f, 0.00997347f, -0.01232740f, 
    -0.03008796f, -0.03737522f, 0.01722711f, 0.01422655f, 0.02570159f, -0.02683468f, -0.00893170f, -0.00449936f, 
    0.02840609f, -0.00499529f, -0.00682327f, 0.00770426f, 0.00834428f, 0.01967887f, -0.02302809f, 0.00096552f, 
    -0.00168873f, 0.00595923f, -0.01442725f, -0.01870026f, 0.02213892f, -0.02520649f, -0.03598485f, 0.02061025f, 
    0.02338180f, -0.03077691f, -0.02361949f, 0.01947171f, 0.01971764f, -0.03654334f, 0.02994541f, -0.00958035f, 
    0.01400159f, -0.01100603f, 0.02286719f, 0.02225093f, -0.02342341f, -0.03308345f, 0.02529889f, -0.01358431f, 
    -0.01761094f, 0.00496633f, -0.01443114f, -0.00621685f, 0.01068341f, 0.01259652f, -0.01532331f, -0.02593298f, 
    -0.03637595f, 0.02462551f, 0.01769423f, 0.01175187f, 0.01072510f, -0.02203233f, 0.00015539f, -0.01653939f, 
    0.00539088f, 0.01247755f, 0.03088386f, -0.00028312f, -0.03355454f, 0.04709247f, -0.01638239f, -0.01494054f, 
    -0.04163994f, 0.00380285f, -0.04255016f, -0.02976162f, -0.00658484f, 0.03216730f, -0.01069713f, -0.00214338f, 
    0.03208809f, 0.02534427f, 0.03050677f, -0.01337734f, 0.02949314f, -0.00752892f, -0.02391505f, -0.04868651f, 
    -0.01680079f, -0.03509196f, -0.03257947f, -0.00155807f, 0.02951541f, -0.02970065f, -0.03282369f, 0.01388839f, 
    0.02512733f, -0.00020840f, -0.01561437f, -0.00579093f, -0.02404471f, 0.02128355f, 0.00540722f, 0.01424022f, 
    -0.03447840f, 0.01816366f, 0.02556058f, 0.02561612f, -0.00596902f, 0.02184758f, -0.00755060f, -0.00249123f, 
    -0.01095782f, 0.00893409f, -0.03000993f, 0.02694233f, 0.01618353f, -0.00934094f, -0.02329934f, -0.02687614f, 
    -0.02095051f, 0.00011021f, 0.02801934f, -0.00579993f, -0.03491243f, 0.01765252f, -0.00384262f, 0.02646206f, 
    -0.01612373f, 0.01831426f, -0.02145903f, 0.01688563f, 0.00689491f, -0.00585977f, -0.00979205f, -0.02647160f, 
    0.02120331f, -0.01692629f, 0.02796669f, 0.00120109f, -0.00241796f, 0.01288646f, 0.02204446f, 0.02799252f, 
    0.02254045f, -0.01815851f, 0.01787270f, 0.01695847f, -0.03225375f, 0.00342969f, -0.00182517f, -0.02727962f, 
    0.00307978f, -0.03931191f, 0.02662687f, 0.02155095f, -0.04214036f, -0.02216214f, 0.01370588f, -0.00985511f, 
    0.00606312f, -0.00646175f, -0.02146599f, 0.01207766f, -0.02001287f, -0.00910276f, 0.00716636f, -0.02554858f, 
    -0.00323738f, -0.00068462f, -0.04843016f, 0.00160700f, 0.01610783f, 0.00356297f, 0.02578343f, -0.03839947f, 
    -0.04448639f, 0.01721640f, -0.01354120f, -0.00890067f, -0.03148844f, 0.00860685f, 0.00129749f, -0.01194953f, 
    -0.00356787f, -0.02563172f, 0.01155461f, -0.04911123f, -0.00406825f, 0.01837822f, 0.00390112f, 0.00272183f, 
    0.00553949f, -0.01808158f, -0.03221981f, -0.03389610f, -0.02313737f, -0.03271201f, 0.03057718f, 0.01446360f, 
    -0.02396481f, 0.00117046f, -0.01945356f, 0.00201267f, -0.01468318f, -0.00482253f, -0.02743129f, 0.01247804f, 
    -0.00962590f, -0.03054708f, -0.01138940f, -0.00464823f, -0.00281127f, 0.02201404f, 0.00687278f, -0.01186834f, 
    0.00916814f, -0.04708737f, 0.00141377f, -0.02062877f, 0.01071865f, -0.03351812f, 0.00053591f, -0.00335034f, 
    0.01887685f, 0.01451669f, -0.00157547f, -0.02938248f, 0.00684755f, -0.03210462f, 0.02136148f, -0.04042763f, 
    0.01888265f, -0.04909776f, -0.00104404f, -0.00431875f, 0.00067947f, -0.02145430f, 0.01616843f, -0.02071949f, 
    -0.02312253f, -0.00612457f, -0.01231222f, -0.00301174f, -0.02391386f, -0.03295985f, -0.00150285f, -0.00146637f, 
    -0.03863170f, 0.00806134f, -0.05139566f, -0.02784755f, -0.00912669f, 0.01333780f, 0.01932656f, 0.00469605f, 
    0.02133810f, -0.00052880f, 0.03657293f, -0.00768051f, -0.00383145f, -0.01078533f, -0.02738709f, -0.02527596f, 
    -0.00199588f, 0.00178025f, -0.01101429f, -0.02707272f, 0.01307741f, -0.00322486f, 0.00693566f, 0.01190436f, 
    0.02147385f, -0.04481465f, -0.04226578f, 0.02231248f, -0.03954681f, -0.01812514f, 0.01316271f, -0.04594607f, 
    -0.00939046f, 0.01345921f, 0.02425150f, 0.00866693f, -0.02709243f, -0.03820049f, 0.00012972f, 0.00814514f, 
    -0.01260282f, 0.03286857f, -0.02984136f, -0.03240817f, -0.03696469f, 0.01566123f, 0.01731863f, -0.00075648f, 
    -0.02301394f, 0.02371540f, -0.03498369f, 0.02269327f, 0.00823501f, 0.01984071f, -0.02792144f, 0.02863687f, 
    0.01300643f, 0.02038513f, 0.00364639f, 0.00647298f, -0.01459276f, -0.02329945f, -0.03625231f, -0.03286504f, 
    0.00770625f, 0.02900192f, -0.01001051f, 0.01770861f, 0.02043971f, -0.00936894f, -0.02236950f, 0.02781943f, 
    0.02713841f, -0.00148674f, -0.01648480f, 0.01724072f, -0.01214489f, 0.01762919f, -0.04171306f, -0.01871039f, 
    -0.01509561f, 0.00287316f, -0.01378360f, -0.03418512f, -0.03427051f, 0.03057337f, -0.02034459f, -0.02530964f, 
    -0.02998622f, 0.02847652f, -0.00363705f, 0.02491877f, -0.00110817f, -0.02723174f, 0.03298058f, -0.00038530f, 
    0.00073387f, -0.02407401f, -0.00788583f, -0.03722393f, -0.00417003f, 0.01867467f, 0.01066622f, 0.03342323f, 
    -0.00628048f, 0.02572098f, -0.00495789f, -0.03551815f, -0.02114614f, -0.00511117f, -0.02039328f, -0.04476850f, 
    -0.03998971f, 0.02062853f, 0.01066080f, 0.00446482f, 0.02548107f, -0.03639171f, -0.03607186f, -0.00990079f, 
    0.01565911f, -0.01514793f, 0.00953045f, -0.00582915f, -0.01307775f, 0.00652415f, -0.01944902f, 0.00976443f, 
    0.02293524f, 0.01560662f, 0.01827708f, -0.02270748f, 0.02066556f, -0.01119761f, 0.01662574f, -0.00315786f, 
    -0.00580885f, -0.01822573f, 0.03257686f, -0.03051431f, 0.00520133f, -0.01373581f, -0.03459505f, 0.00002287f, 
    -0.02515573f, -0.03458399f, -0.00168087f, -0.01477172f, 0.00130234f, 0.00388433f, -0.00333918f, 0.01338803f, 
    -0.00958290f, -0.02247956f, -0.00537519f, -0.02989855f, -0.02693859f, -0.01276014f, -0.03570720f, 0.02050359f, 
    0.01876381f, -0.02755759f, -0.02453842f, -0.02960578f, 0.00575602f, 0.01241208f, 0.00607096f, 0.01586107f, 
    0.00194330f, 0.00359817f, -0.05016748f, -0.03141895f, 0.02287555f, 0.02134268f, 0.00534713f, -0.00529363f, 
    -0.03482737f, 0.00296288f, -0.03182748f, 0.01083979f, -0.00008539f, -0.00453872f, -0.01340413f, -0.00950097f, 
    0.01979861f, -0.00180399f, -0.02101563f, 0.01307445f, 0.00576461f, -0.02836814f, -0.01640015f, 0.01927447f, 
    -0.02070094f, 0.02649653f, 0.00173396f, 0.03097842f, 0.01389673f, -0.02598619f, 0.00400501f, 0.00024792f, 
    0.02481765f, 0.02777874f, 0.02349923f, -0.03869035f, -0.01131143f, -0.01257146f, -0.04496791f, 0.00409104f, 
    0.00335617f, 0.00638297f, 0.00950105f, -0.02273179f, 0.00968220f, 0.01896391f, -0.02251966f, 0.02574465f, 
    -0.04224651f, -0.01681014f, 0.02861026f, 0.03165169f, 0.00895507f, 0.02009751f, -0.00097057f, -0.04041883f, 
    0.01987854f, -0.01760614f, -0.01357253f, 0.02652939f, -0.00311325f, 0.00049273f, 0.01064408f, 0.01919710f, 
    0.01843119f, -0.00695834f, 0.02127358f, 0.00663781f, 0.01833138f, -0.01519048f, -0.03192537f, -0.02996831f, 
    -0.00694460f, 0.01452094f, -0.02767304f, 0.01928643f, 0.02937373f, 0.02880204f, 0.01115710f, 0.02093599f, 
    -0.01716598f, 0.02372797f, -0.03036541f, 0.03054758f, -0.00816029f, -0.03065001f, -0.03401404f, -0.02134685f, 
    -0.00944330f, -0.00396279f, -0.03396251f, 0.00173074f, -0.04121231f, -0.03899061f, 0.00223260f, -0.04537107f, 
    0.02887267f, 0.00403132f, -0.02688900f, -0.00868057f, 0.02341851f, -0.00102362f, -0.03970979f, 0.03030309f, 
    0.02080877f, 0.03467679f, -0.01279239f, 0.00763550f, -0.01015527f, -0.02655580f, 0.01903827f, 0.01606022f, 
    0.01967549f, -0.01759947f, -0.03756212f, -0.02634177f, -0.04403838f, 0.01395253f, 0.01274263f, 0.02335354f, 
    -0.04674574f, 0.01569344f, -0.00026036f, 0.00317189f, 0.01451043f, -0.03035690f, 0.00149399f, 0.01901308f, 
    0.01151425f, -0.00500904f, -0.00149187f, -0.02347680f, 0.01162170f, -0.00197773f, 0.00043769f, -0.01442797f, 
    0.01862007f, -0.03426020f, -0.02850016f, -0.02555100f, 0.00238494f, 0.02259806f, -0.02074008f, -0.03741401f, 
    -0.03232379f, -0.01108800f, 0.00240750f, -0.00211404f, -0.01813192f, -0.00527789f, 0.00073885f, -0.00738273f, 
    -0.02713158f, -0.03768549f, 0.00648170f, 0.02643920f, 0.02600878f, 0.00880211f, -0.01203173f, -0.00336279f, 
    -0.01288568f, -0.01462222f, 0.02648904f, -0.01873149f, 0.02409875f, 0.02508067f, 0.01467522f, -0.00568356f, 
    0.28868204f, 0.02553766f, 0.12400156f, 0.01479837f, -0.07666394f, -0.07191472f, 0.12871251f, 0.08735022f, 
    0.10021454f, 0.08010527f, 0.31729007f, 0.21579625f, -0.25762537f, -0.26768187f, -0.03594843f, 0.21122718f, 
    -0.07456561f, -0.04540282f, 0.12578075f, -0.04156723f, 0.05640654f, -0.00169460f, 0.09467614f, -0.00079052f, 
    -0.14981394f, -0.20391516f, 0.10109267f, -0.00513885f, -0.07283779f, -0.00822118f, -0.01432986f, 0.11236879f, 
    -0.13652921f, 0.05181429f, -0.07496671f, 0.06127619f, 0.16672754f, 0.09909001f, -0.03630974f, -0.28953853f, 
    -0.20601544f, -0.01178413f, -0.03134490f, 0.23001063f, 0.13234940f, 0.15503894f, 0.11832359f, 0.27072829f, 
    -0.02812831f, -0.11172089f, 0.01772913f, 0.21749781f, -0.27185193f, 0.00285118f, 0.17172299f, 0.01937188f, 
    0.04955156f, -0.05710587f, 0.06952442f, -0.09915926f, 0.05622846f, 0.07558062f, 0.38755560f, 0.21632299f, 
    -0.05426745f, -0.05604597f, -0.04821392f, 0.03906512f, -0.06744567f, -0.13206787f, -0.10346808f, -0.18627210f, 
    -0.20374513f, -0.14864732f, 0.09548774f, 0.22406206f, -0.12988693f, -0.10889691f, -0.28872246f, 0.24604887f, 
    0.05160623f, -0.07975407f, 0.10716128f, -0.11543804f, -0.04667584f, -0.11507174f, -0.06507152f, -0.00715988f, 
    0.00459442f, 0.12088034f, 0.10035694f, 0.04333834f, -0.03863409f, 0.00093870f, 0.01870723f, 0.03660314f, 
    -0.04404970f, -0.14469299f, 0.03768831f, -0.15964921f, 0.07206056f, 0.11168700f, 0.01440862f, 0.00853316f, 
    -0.02759791f, 0.00011386f, -0.00764885f, -0.04218191f, -0.29628092f, -0.12804700f, 0.17949449f, -0.04202236f, 
    -0.09991886f, -0.08797662f, -0.12328253f, -0.20613296f, 0.02298768f, -0.15229462f, -0.18877679f, -0.20070997f, 
    -0.34419784f, -0.21080244f, 0.40375617f, 0.04353366f, 0.03958799f, -0.00517067f, 0.01789455f, -0.09684435f, 
    0.03898212f, 0.14229093f, 0.04712648f, 0.04591627f, -0.14983831f, -0.15170266f, 0.45099631f, -0.16607493f, 
    0.10592930f, -0.08681569f, -0.02194061f, -0.07433974f, -0.15721853f, 0.00529792f, -0.15409441f, -0.02880785f, 
    0.09400224f, -0.06717845f, -0.22581865f, -0.02414921f, 0.09522036f, 0.22712599f, 0.20221668f, -0.01232445f, 
    0.09346980f, -0.01343103f, 0.05538952f, 0.08630967f, -0.18395419f, -0.04302232f, 0.19565074f, 0.35007983f, 
    -0.09082134f, 0.11421221f, 0.05641870f, -0.26702309f, 0.04818505f, 0.03839754f, -0.17901087f, -0.06441463f, 
    0.40683970f, -0.22884381f, 0.01605398f, 0.07539438f, 0.07649503f, 0.16414943f, 0.19422674f, -0.11486930f, 
    0.08593510f, 0.14368679f, 0.28741077f, 0.07025314f, -0.50052941f, -0.15167718f, 0.19038293f, 0.07518088f, 
    0.34397647f, 0.02819771f, -0.01151946f, -0.05161030f, -0.12055635f, -0.11654941f, -0.03107909f, 0.03208646f, 
    -0.03302959f, -0.05400936f, 0.16987398f, -0.13813357f, -0.00278485f, 0.03621100f, 0.02494697f, 0.04518111f, 
    0.14324954f, 0.08194450f, -0.08401313f, 0.10174056f, 0.19936308f, -0.09238760f, -0.16686977f, -0.26241878f, 
    -0.08851591f, 0.16776647f, -0.03567873f, 0.14060487f, -0.23090714f, -0.06261402f, -0.09487925f, -0.07830822f, 
    0.15546195f, 0.28055039f, 0.49401939f, 0.07589605f, -0.01522555f, -0.06107690f, -0.01472367f, 0.25158522f, 
    0.03911117f, 0.08733240f, -0.02282184f, -0.04567008f, 0.26672536f, 0.08490170f, 0.06545592f, 0.02322823f, 
    0.02136004f, 0.13804059f, 0.01673681f, 0.03675423f, -0.17151855f, -0.00813513f, -0.02978219f, -0.15989977f, 
    0.38005877f, -0.11042578f, -0.00108101f, 0.08974986f, -0.00248424f, -0.00813546f, 0.16419622f, 0.11431451f, 
    -0.11221511f, 0.02983543f, 0.23494288f, 0.20301697f, 0.36812651f, 0.28188172f, -0.18870357f, -0.12773094f, 
    -0.20078011f, 0.03180857f, 0.07259530f, 0.18751767f, -0.04718500f, -0.02665985f, -0.00083829f, 0.03318721f, 
    0.13203239f, 0.06162171f, 0.03009941f, -0.02499404f, -0.02704448f, -0.06346047f, -0.10380898f, -0.06874317f, 
    -0.01728762f, -0.04484833f, 0.06563640f, 0.11154293f, 0.19165182f, -0.04920970f, 0.11499821f, -0.20242754f, 
    -0.04609288f, -0.00785700f, -0.11959911f, -0.06123749f, -0.13780949f, -0.17164828f, -0.14037211f, -0.03881806f, 
    -0.00226964f, -0.10024976f, 0.07847748f, -0.06711312f, -0.09728036f, -0.07865754f, -0.02307041f, -0.04476320f, 
    -0.00377287f, 0.01510323f, 0.08710384f, 0.10945712f, 0.10203781f, 0.05358360f, -0.01359746f, -0.08763677f, 
    -0.06203314f, 0.05400259f, 0.15504053f, 0.04693305f, -0.19036968f, 0.05096763f, -0.11758593f, -0.15775755f, 
    -0.39577150f, -0.26365277f, -0.11117226f, 0.03868748f, 0.10664783f, -0.27192068f, 0.27557337f, -0.12215782f, 
    0.14133020f, 0.06755468f, -0.01062703f, 0.12907982f, -0.00058161f, 0.10688610f, -0.07091162f, 0.01458485f, 
    -0.02092700f, 0.05258685f, 0.18211633f, -0.11975539f, 0.02854836f, -0.04188944f, -0.02520483f, 0.05321209f, 
    0.05719274f, 0.12872045f, 0.05455163f, -0.11786291f, -0.03810264f, 0.01904191f, 0.20827959f, 0.11490482f, 
    0.03405125f, 0.15773569f, 0.27740213f, 0.23242334f, -0.07805850f, 0.18290460f, -0.22835389f, 0.04298793f, 
    0.04181013f, -0.12039495f, 0.17987448f, 0.23302536f, 0.09135937f, 0.23014757f, 0.17160684f, 0.07447883f, 
    -0.30681103f, -0.01066108f, 0.02207605f, -0.15647258f, -0.05943720f, -0.17887652f, 0.02962311f, -0.05926716f, 
    -0.03532654f, -0.01248256f, 0.00893075f, -0.01160261f, 0.19389477f, 0.09248397f, 0.11360061f, 0.21908797f, 
    0.00110573f, 0.07362971f, 0.09358920f, 0.15983687f, -0.00152434f, 0.08803606f, 0.12218975f, 0.09315406f, 
    -0.11853499f, -0.19780506f, 0.03387786f, -0.01513701f, -0.18989925f, -0.04338052f, -0.00568769f, 0.08176548f, 
    -0.10233907f, -0.08880217f, -0.04644392f, 0.05412253f, -0.23723134f, -0.02248221f, 0.03506724f, 0.06680314f, 
    -0.10178809f, 0.02236329f, 0.08238282f, 0.05103523f, 0.11117374f, -0.00125277f, -0.07864216f, 0.10343819f, 
    -0.25027841f, -0.22359115f, -0.03032788f, -0.01729231f, 0.16230845f, -0.10441630f, -0.23246711f, 0.04312588f, 
    -0.02592141f, -0.10094784f, 0.02994384f, -0.18153566f, -0.10043661f, -0.11949814f, -0.07328194f, -0.17191052f, 
    -0.10578886f, -0.14318709f, -0.03246878f, 0.06987552f, -0.15279932f, -0.13283835f, -0.18091324f, -0.14341290f, 
    -0.04370786f, 0.07803902f, -0.12012472f, 0.03580887f, -0.02914413f, 0.06643192f, 0.02576486f, -0.01310339f, 
    0.17796853f, -0.01967103f, 0.10889532f, -0.09866353f, 0.03789758f, -0.04391956f, -0.00201925f, -0.13276090f, 
    -0.06166188f, -0.00330173f, 0.02314611f, -0.02698178f, 0.07914825f, -0.02158941f, -0.02270568f, 0.17843796f, 
    -0.26764375f, -0.13240996f, -0.05726424f, 0.26347417f, -0.09691989f, -0.05559183f, 0.00931051f, 0.21769349f, 
    -0.11668924f, -0.00980130f, 0.02863661f, -0.06239863f, -0.20434085f, -0.03548135f, 0.01443732f, -0.00763544f, 
    -0.12030838f, -0.23659791f, 0.04433680f, -0.09921328f, 0.01473595f, 0.01487851f, -0.09688799f, -0.06862329f, 
    0.33626932f, 0.20335354f, 0.23533097f, -0.11839819f, -0.03127387f, -0.16294330f, 0.09411097f, -0.03906493f, 
    -0.27816236f, 0.01068931f, -0.00648911f, 0.02045201f, 0.01039076f, 0.05654012f, 0.01894036f, -0.01241139f, 
    -0.05831892f, 0.01963994f, 0.00846960f, 0.06531191f, 0.11966261f, 0.08132365f, 0.18589005f, 0.32886088f, 
    -0.14839137f, -0.07580145f, -0.08957130f, -0.12418228f, 0.13917004f, -0.15270220f, -0.00196201f, 0.17300148f, 
    -0.16480714f, 0.00857865f, -0.08152663f, -0.02952952f, 0.02364124f, 0.06267760f, -0.25347111f, -0.09555550f, 
    0.02944737f, 0.13391766f, -0.21032532f, -0.05633095f, -0.08777418f, -0.07375708f, -0.14433248f, -0.02264351f, 
    0.34132114f, 0.17560413f, 0.12855868f, -0.12898429f, -0.09976081f, -0.04123801f, 0.07763649f, -0.00896731f, 
    -0.04096009f, -0.13491580f, -0.08279540f, -0.07825425f, 0.01179077f, 0.10663259f, 0.05898434f, -0.09914549f, 
    -0.10666464f, -0.00766617f, 0.13877274f, 0.09689889f, 0.02437528f, 0.00642393f, 0.06746643f, 0.20806913f, 
    -0.00845370f, 0.26484796f, -0.00557487f, -0.12674317f, -0.05465578f, -0.07814506f, 0.10392661f, 0.22364126f, 
    0.01278582f, 0.15758434f, 0.21042895f, 0.17920500f, 0.15071025f, 0.11760368f, -0.17864090f, 0.14653294f, 
    -0.10944768f, -0.00177955f, 0.22446726f, 0.03112696f, 0.00028758f, 0.06209913f, -0.15229328f, -0.09250872f, 
    -0.15820469f, -0.20913239f, -0.03249132f, 0.15379994f, 0.05880857f, -0.03446599f, -0.02210736f, -0.05523828f, 
    -0.04778706f, -0.00232827f, -0.02863944f, 0.01082402f, -0.54295087f, -0.09312291f, -0.03164372f, 0.15391597f, 
    -0.04696184f, -0.21127734f, -0.22023030f, -0.05015922f, -0.12145787f, -0.10772162f, -0.10255045f, -0.10088107f, 
    -0.64526635f, -0.32024872f, -0.08267269f, 0.34371117f, 0.04228322f, 0.29669997f, -0.06945095f, 0.14289925f, 
    -0.00137911f, 0.00926821f, 0.08600489f, 0.02263277f, -0.24357364f, 0.07515664f, 0.03274181f, -0.02539063f, 
    0.14276020f, 0.20259760f, -0.02057987f, -0.04774830f, 0.24652143f, 0.14024726f, 0.27302495f, 0.13173342f, 
    -0.24640268f, 0.13718008f, -0.29207480f, 0.12639414f, -0.10445710f, -0.02597493f, 0.28059778f, -0.02117218f, 
    0.14843832f, -0.17218567f, 0.22940379f, 0.06241748f, 0.20625423f, 0.02836194f, -0.13066533f, -0.03775189f, 
    -0.05899694f, -0.00904812f, 0.07235698f, -0.10279702f, -0.07517560f, 0.06908688f, 0.01614726f, 0.04735794f, 
    -0.19611315f, 0.17020309f, 0.15991616f, -0.00433162f, -0.22185017f, -0.19780543f, 0.08702840f, 0.19877084f, 
    -0.02383013f, 0.08542702f, -0.00375490f, 0.08748621f, 0.08777018f, -0.00214370f, -0.15974247f, -0.11086054f, 
    0.03880234f, 0.03182777f, -0.16118020f, -0.04346035f, -0.13451570f, -0.13599992f, -0.12277368f, -0.25758210f, 
    0.62111443f, 0.02711927f, -0.05220902f, -0.32106420f, -0.06569135f, 0.10695388f, 0.05172716f, 0.26109105f, 
    -0.13203752f, 0.00147774f, 0.03724979f, -0.00224406f, -0.06751265f, -0.20191230f, 0.00940196f, 0.06483024f, 
    0.00035646f, -0.00993072f, -0.14886586f, -0.01607361f, -0.07942910f, -0.05487965f, -0.17977507f, -0.05657096f, 
    0.26429608f, 0.05850406f, -0.17875381f, 0.11842716f, -0.00319427f, -0.04017802f, 0.17722400f, 0.14667091f, 
    -0.01398095f, -0.10258339f, 0.09293894f, 0.00705632f, -0.21435331f, 0.01386436f, 0.12272702f, 0.06054584f, 
    -0.10312957f, 0.00324443f, 0.21839266f, 0.12929006f, 0.03084846f, 0.12145454f, 0.10624541f, 0.19395025f, 
    0.06058121f, 0.09808351f, -0.10713036f, -0.06596291f, 0.04682532f, 0.06191881f, -0.09473146f, 0.05361782f, 
    0.08904986f, 0.11943444f, -0.01416200f, -0.19954987f, -0.09751525f, -0.13845667f, -0.19246066f, 0.05185597f, 
    0.00809882f, 0.00564929f, 0.23172367f, -0.00724858f, 0.04769455f, 0.14953414f, 0.16490829f, 0.04062405f, 
    -0.08926876f, -0.15198651f, 0.18907756f, -0.06419927f, 0.01281342f, 0.03990087f, 0.16100635f, -0.14102201f, 
    -0.11089937f, 0.01355839f, 0.09106480f, 0.01417041f, 0.27726671f, 0.05647696f, 0.40586010f, -0.12921178f, 
    -0.03007990f, 0.11294810f, 0.34619281f, 0.04191934f, 0.16166651f, 0.11469636f, 0.02699317f, 0.25091070f, 
    -0.01182737f, -0.02372755f, -0.01719274f, -0.01309587f, 0.03216493f, -0.02982092f, 0.00732413f, 0.00342681f, 
    -0.00054830f, -0.03006224f, -0.00981629f, -0.01659029f, -0.04000652f, 0.01879238f, 0.01282082f, 0.00851512f, 
    -0.00822150f, -0.00857831f, -0.03736697f, 0.03030464f, -0.03203968f, -0.01160700f, -0.03765702f, 0.00692559f, 
    -0.02730192f, -0.00080503f, 0.01452368f, -0.01015628f, -0.01123369f, 0.01050376f, -0.01279462f, 0.02451591f, 
    -0.02772124f, 0.01763294f, -0.03672457f, 0.01214566f, -0.00726827f, 0.00791680f, 0.02625459f, 0.01368812f, 
    0.00443237f, 0.01385531f, -0.00325810f, -0.01929245f, -0.03315945f, 0.00605203f, -0.02042566f, 0.00319443f, 
    0.02538893f, 0.02580797f, 0.01093393f, -0.02131446f, -0.01978898f, -0.03567296f, -0.01878124f, 0.01767506f, 
    0.01131473f, 0.00276195f, -0.03378867f, 0.01355560f, 0.02654440f, 0.01938254f, -0.03430049f, -0.02256523f, 
    0.01738578f, -0.01126011f, -0.03222270f, -0.02601270f, 0.01566160f, -0.01721239f, 0.02827955f, -0.01307366f, 
    -0.04209217f, 0.00733327f, 0.01522449f, -0.00550208f, -0.03002060f, 0.00856769f, -0.01083215f, -0.02966620f, 
    0.01047488f, 0.01306452f, -0.03852648f, -0.03360654f, 0.01226534f, 0.00746713f, -0.02509883f, -0.00963435f, 
    -0.03402263f, 0.00970775f, 0.00941813f, -0.01769261f, 0.00215131f, 0.02538980f, 0.02428278f, -0.00132399f, 
    -0.01189639f, -0.01803497f, 0.00443280f, -0.00453781f, -0.03226076f, -0.00134601f, 0.02604438f, 0.01955943f, 
    0.01739177f, -0.03946014f, 0.02384672f, -0.01390574f, 0.01847082f, -0.03462442f, -0.00755715f, -0.01119382f, 
    0.00072419f, -0.02379639f, -0.01090480f, -0.03025898f, 0.01174191f, 0.00283830f, -0.02856149f, 0.01338020f, 
    -0.00038283f, 0.00590605f, -0.01454774f, 0.03027998f, -0.00713380f, -0.01842324f, 0.02820548f, 0.00587098f, 
    -0.00395516f, 0.00136129f, -0.03430043f, 0.01776127f, -0.00587808f, 0.02478422f, 0.00575350f, 0.00408250f, 
    -0.00719907f, -0.02406015f, -0.03317122f, 0.02408068f, -0.02503859f, 0.01303409f, -0.01405303f, -0.00446153f, 
    -0.00224763f, -0.02394026f, -0.02783440f, -0.03728375f, -0.03601219f, -0.02971606f, -0.04015325f, -0.00422990f, 
    -0.03598667f, 0.00229397f, 0.00016914f, -0.04094883f, 0.01003604f, -0.00887953f, -0.03570629f, 0.03184451f, 
    -0.00452999f, -0.03668354f, -0.02233821f, -0.01032418f, 0.00937084f, 0.01833374f, -0.03852431f, -0.03080938f, 
    -0.00740234f, 0.00848544f, -0.00910759f, -0.03589318f, -0.01252160f, -0.03116668f, 0.02570815f, 0.00676733f, 
    -0.00652410f, 0.02114569f, 0.02808165f, -0.00891143f, -0.03108522f, 0.02723077f, 0.01834847f, -0.00116683f, 
    -0.00109662f, -0.03526240f, -0.03152487f, -0.03386857f, -0.01200457f, 0.01700468f, -0.01377397f, 0.02110486f, 
    -0.04240158f, -0.01461502f, 0.02641234f, -0.02196383f, 0.01176779f, 0.00907207f, -0.00399233f, -0.02261081f, 
    0.00684328f, -0.01766124f, -0.01704880f, -0.00764513f, 0.00722931f, 0.02960349f, -0.01661443f, 0.00156965f, 
    -0.01895373f, -0.04560876f, -0.02749635f, -0.01782846f, -0.02452249f, -0.03626613f, 0.00967094f, -0.00198556f, 
    0.02389217f, 0.02462386f, 0.01143146f, 0.01096463f, 0.01363342f, -0.02917906f, -0.00149981f, -0.03530426f, 
    0.01821795f, 0.00293329f, 0.00743915f, 0.01689266f, -0.03143770f, -0.03288347f, 0.00039175f, 0.02061316f, 
    0.00390864f, -0.02215888f, 0.00880555f, 0.00382637f, 0.00650860f, 0.00234715f, -0.03344440f, 0.01992003f, 
    -0.01727130f, -0.00866497f, 0.02764056f, 0.00186323f, 0.00555020f, -0.04137600f, 0.01657424f, 0.02416214f, 
    -0.01631965f, -0.00109445f, -0.02638504f, -0.01122185f, -0.03831447f, 0.01225162f, -0.01944812f, 0.01115530f, 
    0.01205803f, -0.01142717f, -0.03790455f, 0.00380036f, 0.01635316f, -0.02069092f, -0.02444135f, 0.01275999f, 
    -0.02112626f, -0.00515213f, -0.00719777f, -0.04352323f, 0.01765668f, 0.02948097f, -0.02983208f, -0.02789664f, 
    0.00697745f, 0.01787477f, -0.02378096f, -0.01169321f, 0.01179308f, 0.01268294f, -0.03371543f, 0.01488796f, 
    -0.01221445f, 0.02064836f, -0.02126777f, -0.00128407f, -0.02071158f, -0.02999531f, -0.03504494f, -0.02707300f, 
    -0.01633657f, 0.02524519f, 0.02309067f, 0.01248759f, -0.00794119f, -0.03961324f, 0.03326962f, -0.00412210f, 
    -0.01343747f, 0.02120033f, -0.02778181f, 0.02548107f, -0.02314257f, 0.00981200f, -0.02939728f, -0.03775623f, 
    0.01926511f, 0.00785660f, -0.01643704f, 0.01713378f, 0.00498303f, 0.02995248f, 0.01857341f, 0.01907921f, 
    -0.02243802f, 0.03074648f, 0.01876383f, 0.01191773f, 0.02314538f, 0.01500757f, -0.03746529f, 0.00552988f, 
    -0.03590279f, 0.00604947f, -0.01728373f, -0.00966987f, -0.00930881f, -0.02947484f, -0.03815619f, -0.01241467f, 
    -0.00181224f, 0.00333340f, 0.00394952f, 0.01024915f, -0.02418765f, -0.02215511f, -0.02494144f, -0.04438394f, 
    -0.00943250f, -0.00746509f, 0.00322514f, -0.03791135f, -0.01608592f, 0.00758834f, -0.02193783f, 0.01492748f, 
    -0.02300426f, -0.04010040f, -0.03166681f, -0.04219047f, -0.02930833f, -0.02694676f, 0.02670235f, -0.01419920f, 
    -0.02811077f, -0.02324140f, -0.02299779f, -0.03372558f, -0.01102254f, -0.00091934f, -0.04287813f, 0.00119155f, 
    0.01239602f, -0.02346440f, -0.02400795f, -0.01914266f, 0.00819301f, -0.00940534f, -0.01171673f, -0.01768630f, 
    -0.00976317f, 0.02127694f, -0.02466301f, 0.02279146f, -0.00367612f, 0.01744358f, -0.00975518f, 0.01648841f, 
    0.02932806f, 0.00755962f, -0.00331005f, 0.02119615f, -0.02503627f, 0.01116206f, -0.00311413f, 0.02712062f, 
    -0.00233261f, 0.00292623f, -0.02593890f, 0.01429042f, -0.02206647f, -0.00186732f, -0.03147484f, 0.01958859f, 
    -0.00220044f, 0.02781090f, 0.00390635f, -0.01797644f, -0.02724102f, 0.02333588f, 0.00144047f, -0.00775750f, 
    0.01077554f, -0.02240693f, -0.02962796f, -0.01781381f, -0.03959663f, 0.02315288f, 0.01940993f, -0.00659715f, 
    -0.00901059f, -0.01626772f, -0.01021785f, 0.02297608f, -0.00187134f, -0.00903847f, 0.02054511f, 0.00116553f, 
    0.00969179f, 0.02691265f, -0.01162982f, -0.02013848f, 0.00007090f, -0.00066673f, 0.02724786f, -0.03423279f, 
    -0.03104290f, -0.00340587f, 0.02748115f, 0.01858924f, -0.02493201f, 0.02215062f, -0.03157246f, -0.02761361f, 
    0.01923591f, 0.02040952f, -0.04371757f, 0.02584573f, -0.01085871f, 0.02413296f, -0.02262212f, 0.00744837f, 
    -0.02032709f, -0.03429436f, -0.02411176f, -0.02551286f, -0.04141311f, 0.01570245f, 0.00558981f, 0.02639258f, 
    -0.01571642f, 0.01264174f, 0.02391720f, -0.01567306f, -0.04373805f, 0.01113044f, -0.01452138f, 0.01703780f, 
    -0.01776780f, -0.03898394f, 0.00805300f, 0.00677342f, 0.01223639f, 0.00579315f, -0.04992168f, -0.03800930f, 
    0.03171351f, 0.01225421f, -0.00239320f, -0.03712562f, 0.01381875f, -0.01123176f, 0.00925268f, 0.02310583f, 
    -0.01227572f, 0.02030800f, 0.01826448f, 0.02444815f, 0.01430188f, -0.02140062f, -0.00462492f, -0.03351356f, 
    -0.01408550f, -0.02438412f, 0.02849898f, -0.02486452f, 0.00524296f, -0.02666776f, 0.00622255f, -0.01974103f, 
    0.01304338f, -0.03780225f, 0.01210862f, -0.01634033f, -0.02866844f, -0.00401788f, -0.01203814f, 0.01227427f, 
    0.00157156f, 0.01886339f, -0.00341225f, 0.02255137f, -0.04397624f, -0.04166868f, -0.03864819f, -0.02681861f, 
    -0.03002792f, 0.02019962f, 0.01348314f, 0.03138817f, -0.03893228f, -0.03494012f, -0.02296874f, 0.00370060f, 
    0.02922376f, -0.02684208f, -0.01296958f, 0.02725461f, 0.01619374f, -0.02527061f, 0.00194249f, -0.00665920f, 
    -0.01667728f, 0.00939629f, -0.01436269f, -0.02929861f, -0.03952767f, -0.01439389f, 0.00348828f, 0.00032129f, 
    -0.02295810f, -0.01186224f, -0.02048533f, -0.04099044f, -0.04538785f, 0.02477815f, -0.04269877f, -0.00814427f, 
    -0.01491728f, 0.03148620f, 0.01381275f, 0.01933972f, -0.03975050f, -0.01939478f, -0.00783364f, -0.01826617f, 
    0.01307977f, -0.01367457f, 0.02077299f, 0.00839742f, -0.03475162f, -0.04214353f, -0.00791574f, 0.01259652f, 
    -0.00012783f, 0.02892846f, 0.00188943f, 0.02763840f, 0.02504617f, 0.00151605f, -0.02684399f, 0.01712305f, 
    0.02937726f, -0.00384405f, -0.01674107f, -0.03057498f, -0.04320191f, 0.03285972f, -0.01099956f, -0.02989229f, 
    -0.02651377f, -0.01167926f, 0.00443032f, 0.02087161f, 0.01707822f, -0.01942454f, -0.03518996f, -0.02616051f, 
    0.01916325f, -0.01961428f, -0.04167170f, 0.00225876f, 0.00712752f, 0.01488322f, 0.02174403f, 0.01959311f, 
    0.00735425f, 0.02625776f, -0.01571999f, 0.01418568f, -0.02283084f, -0.00670425f, 0.00427281f, 0.01723589f, 
    -0.01383882f, -0.00669530f, 0.01001540f, -0.01172544f, -0.00434287f, -0.03141375f, 0.00934290f, -0.03624098f, 
    -0.01018182f, -0.04179445f, -0.00966659f, -0.00220285f, -0.03453346f, -0.00846155f, -0.03399257f, -0.02430297f, 
    -0.02323425f, -0.01347664f, -0.02122579f, -0.01491618f, 0.02264345f, 0.01395127f, 0.01220754f, -0.01612345f, 
    -0.01397914f, -0.02444666f, -0.00758532f, -0.01148861f, 0.00258883f, -0.01979433f, 0.00232957f, 0.01303824f, 
    0.01277485f, -0.01360822f, 0.01074513f, 0.00517164f, 0.00080058f, 0.02432543f, 0.01525513f, -0.00225693f, 
    0.00640977f, -0.01672054f, -0.01257641f, 0.02451013f, -0.00371122f, -0.03558565f, 0.01522147f, -0.01003465f, 
    -0.04204967f, 0.00997159f, -0.03397048f, -0.01251800f, -0.03936750f, 0.00817768f, -0.02893261f, -0.02647715f, 
    -0.00711241f, 0.02428795f, 0.01264933f, 0.00514674f, -0.04046656f, -0.00035348f, 0.00784470f, 0.02450487f, 
    -0.00380610f, 0.00565242f, -0.03448046f, 0.02632930f, -0.03210890f, -0.01842126f, -0.02800220f, 0.00002042f, 
    -0.02517479f, 0.00402832f, -0.01850461f, -0.02973443f, 0.00752908f, 0.02190945f, -0.01039194f, 0.02587429f, 
    -0.00461875f, 0.02081033f, 0.01468739f, 0.01505351f, -0.03245663f, 0.02199443f, 0.01691273f, 0.00170079f, 
    -0.01251807f, -0.02476940f, -0.03107907f, -0.00671082f, 0.00445845f, 0.02023215f, 0.02120332f, -0.00508710f, 
    -0.04007569f, 0.00806248f, -0.04094244f, -0.00580023f, 0.03105984f, 0.02215738f, -0.00934302f, 0.01692976f, 
    -0.03166838f, -0.01292474f, -0.03068018f, -0.01305573f, -0.02370377f, 0.00565885f, 0.02567157f, 0.02073511f, 
    -0.01198441f, 0.01032924f, -0.01498295f, -0.02321404f, -0.02402448f, -0.01707545f, 0.00393992f, -0.01990759f, 
    0.01861394f, -0.01754103f, -0.00317695f, -0.02531018f, -0.01410397f, 0.01881009f, -0.01321225f, 0.02393513f, 
    -0.03855797f, 0.00393260f, 0.03112327f, -0.02003874f, -0.03972164f, 0.00612362f, 0.00687731f, -0.02902763f, 
    -0.01350202f, -0.01123005f, 0.02403068f, -0.02031576f, 0.00061349f, -0.01669416f, 0.01082515f, -0.01823879f, 
    -0.03366601f, 0.00791752f, -0.01334841f, -0.00342177f, 0.02237717f, 0.00903045f, 0.02572273f, -0.01852625f, 
    -0.00511444f, -0.02599309f, -0.01950330f, 0.02061195f, 0.02280144f, -0.03598993f, -0.02392130f, 0.02698115f, 
    0.02577559f, -0.01515402f, -0.02696436f, 0.00142131f, 0.02408100f, -0.02146100f, 0.00855817f, -0.01722490f, 
    -0.00030254f, 0.02359055f, -0.01958961f, 0.00741826f, -0.03779231f, -0.01754550f, -0.00921703f, -0.01041090f, 
    -0.01203864f, 0.03033228f, 0.03126287f, 0.03274483f, -0.01822984f, -0.00602106f, 0.00217007f, -0.00296832f, 
    0.02648628f, -0.01175627f, -0.02458849f, 0.02331404f, -0.04012276f, 0.02485853f, 0.00520287f, 0.02392210f, 
    -0.00330400f, -0.01769185f, 0.02190742f, -0.02425598f, -0.02649601f, -0.01154509f, 0.02281220f, 0.00553859f, 
    -0.00508638f, 0.01663443f, -0.03706534f, -0.02695155f, -0.01210815f, 0.01343965f, 0.03384644f, 0.02674637f, 
    0.02148444f, 0.02084888f, 0.02707406f, -0.01047696f, 0.02788044f, 0.00118184f, 0.02793138f, 0.00715254f, 
    -0.02036419f, -0.03251999f, 0.00140273f, -0.00654163f, 0.00789617f, 0.00616864f, -0.02123355f, 0.02789008f, 
    -0.01318059f, 0.03351390f, 0.02193876f, 0.00484461f, 0.02306191f, -0.01834001f, -0.02152304f, -0.03453651f, 
    -0.03489439f, -0.02131680f, 0.00943829f, 0.01484549f, -0.01557075f, 0.02419880f, -0.01605422f, 0.01001582f, 
    -0.00365700f, 0.00108077f, -0.00467075f, 0.03003192f, -0.04322483f, -0.01087076f, -0.02401151f, 0.01525099f, 
    0.01320056f, -0.03995103f, 0.01996565f, -0.02635226f, 0.02282473f, -0.04076622f, 0.00485658f, 0.01423844f, 
    0.00474397f, -0.03671609f, -0.01533444f, 0.01194633f, -0.00169688f, 0.00241494f, -0.00353238f, -0.02492319f, 
    0.01318720f, -0.00941629f, -0.02135588f, 0.01185928f, 0.00513096f, 0.01178675f, -0.02762656f, -0.03824707f, 
    -0.03690476f, -0.00009885f, 0.01068935f, 0.01238379f, -0.02519942f, -0.03650680f, 0.02910835f, -0.01340129f, 
    0.00515888f, 0.02453557f, -0.03828118f, -0.02157588f, -0.00967236f, -0.01499308f, -0.03016951f, 0.01524874f, 
    -0.03396210f, -0.00169734f, -0.03233398f, 0.01181508f, -0.03565018f, -0.01975203f, -0.03629423f, -0.04182960f, 
    0.01631247f, 0.01970214f, 0.01329200f, 0.02548750f, -0.03776496f, 0.01902922f, -0.02586896f, -0.02925697f, 
    -0.00296235f, 0.00185574f, -0.03166104f, -0.02251186f, -0.02510078f, 0.00226059f, 0.03036827f, -0.04580615f, 
    0.00514027f, -0.03331695f, -0.02477694f, -0.00761452f, -0.00267975f, 0.01095614f, -0.04563701f, -0.01325448f, 
    -0.02211567f, -0.00252808f, 0.02223420f, -0.01758747f, 0.02491573f, -0.01934351f, -0.02340520f, -0.00239387f, 
    -0.02406724f, 0.01162838f, 0.02586838f, -0.04039281f, -0.03688424f, 0.01783470f, -0.01410498f, -0.00039871f, 
    -0.02450778f, 0.00629091f, -0.00388080f, 0.00088873f, 0.01716981f, 0.01501762f, -0.02180248f, -0.02556709f, 
    -0.01426078f, 0.02221758f, 0.02312791f, -0.02061890f, -0.00707091f, -0.01314425f, 0.00625733f, 0.00640640f, 
    -0.00706453f, 0.02156058f, 0.00425565f, 0.01483856f, -0.03753413f, 0.01331049f, -0.03373648f, -0.03413983f, 
    0.02855932f, -0.02508991f, -0.01323709f, 0.00856687f, -0.03318375f, -0.00786738f, -0.00750808f, 0.00930846f, 
    0.01501171f, -0.04442495f, -0.02226637f, -0.00199992f, -0.02251102f, 0.01738860f, 0.01151733f, 0.00203512f, 
    -0.03237894f, 0.00497689f, 0.00994876f, -0.02135762f, 0.02265434f, -0.01106875f, 0.02819654f, 0.01847028f, 
    -0.01494756f, -0.03597593f, -0.02869040f, 0.01048049f, -0.01500961f, -0.01702822f, -0.00012392f, -0.00546874f, 
    0.01301838f, -0.00007581f, -0.03413735f, -0.01105622f, 0.00545942f, 0.02499331f, -0.02026754f, -0.02099029f, 
    0.00536538f, -0.00284401f, 0.00848746f, -0.01650014f, 0.02414055f, 0.01666957f, -0.01903784f, 0.02287642f, 
    -0.01853737f, -0.01742154f, 0.02396258f, -0.03302950f, -0.01756532f, -0.00840974f, -0.03444497f, 0.01731452f, 
    -0.03215041f, -0.03530544f, 0.00696937f, -0.03205737f, 0.01169054f, -0.03162272f, -0.03661690f, 0.01059239f, 
    -0.00195336f, 0.01015458f, -0.00602367f, -0.03173807f, 0.03088570f, 0.02406932f, -0.03526515f, -0.01239498f, 
    0.01770231f, -0.00986435f, -0.01936078f, -0.00033419f, -0.01855671f, 0.00964091f, -0.02015606f, -0.03877724f, 
    0.00424907f, 0.01293702f, 0.03281054f, -0.02517907f, -0.00421623f, -0.02059494f, -0.00796571f, 0.02222976f, 
    -0.01033319f, -0.02900452f, -0.00698859f, 0.00619966f, 0.02712603f, 0.01600896f, -0.02736110f, -0.01708805f, 
    -0.02354661f, 0.02231151f, 0.02374375f, -0.03915166f, -0.03354947f, 0.01606742f, -0.02713463f, 0.02947768f, 
    -0.00173081f, 0.01772472f, -0.01534150f, -0.00370956f, 0.01595894f, -0.00310652f, 0.02427466f, -0.03467043f, 
    -0.03311198f, 0.02859989f, 0.02121163f, 0.00850805f, 0.02919168f, -0.01786397f, 0.02934656f, 0.01064156f, 
    0.01968735f, 0.01095739f, -0.02778913f, -0.02119537f, 0.01537766f, 0.00970701f, 0.00244747f, 0.01710124f, 
    0.01739690f, -0.02800534f, 0.01886258f, -0.04464224f, -0.00325903f, 0.01045435f, 0.01740627f, -0.02836532f, 
    -0.01628684f, -0.01236951f, -0.02334756f, -0.02712727f, -0.01671291f, -0.02268563f, -0.03474091f, -0.01642131f, 
    0.01577629f, 0.01822408f, -0.01382641f, 0.02449559f, 0.01080850f, -0.03595755f, -0.01052656f, 0.00486515f, 
    -0.03723045f, -0.03496690f, 0.02846032f, -0.01781009f, 0.02445408f, -0.03299939f, -0.00876585f, -0.02917331f, 
    -0.02168190f, 0.01551964f, 0.01442292f, 0.01261201f, -0.00725742f, -0.01350835f, 0.00055538f, -0.01186798f, 
    -0.00585153f, -0.00820681f, -0.03892419f, 0.01004019f, 0.01721414f, -0.03273156f, 0.01941368f, -0.02417032f, 
    -0.04337338f, -0.03850948f, -0.04078225f, -0.01427296f, 0.01246348f, 0.00127039f, 0.02331430f, -0.01041394f, 
    0.01994327f, 0.00220901f, 0.01717977f, -0.02933717f, 0.00027988f, 0.02429524f, 0.03193076f, 0.01108345f, 
    0.01962342f, -0.00925578f, -0.03807181f, 0.02757783f, -0.01072706f, -0.03799584f, 0.02218457f, 0.01440251f, 
    0.01039178f, -0.01536701f, 0.02405655f, -0.00751827f, -0.02928947f, -0.01031828f, -0.03693904f, -0.03717752f, 
    -0.04568350f, -0.00126676f, 0.01884434f, -0.02605959f, 0.01866635f, -0.00173606f, 0.00877936f, -0.03561940f, 
    -0.02729088f, -0.03470446f, 0.00250202f, 0.00345992f, -0.02124182f, 0.02263035f, 0.00489181f, 0.02760170f, 
    -0.00969549f, 0.01180297f, 0.00789037f, 0.02393824f, -0.03981064f, 0.02919081f, 0.02599941f, -0.01346537f, 
    -0.04400542f, -0.02130784f, 0.02559479f, -0.04114596f, -0.02424346f, -0.01219133f, -0.03572842f, -0.00820556f, 
    -0.04165968f, 0.00772182f, 0.00058229f, -0.00294091f, 0.02180672f, -0.01656359f, 0.01674513f, 0.00463917f, 
    0.01200103f, 0.00592499f, -0.01321990f, 0.00391490f, -0.04154747f, 0.01302586f, -0.03110650f, -0.01183767f, 
    -0.00758317f, -0.01754100f, 0.00514904f, 0.02656537f, 0.02685072f, 0.01217920f, -0.03285387f, 0.02513968f, 
    -0.01974160f, 0.00608771f, 0.01746061f, -0.03122212f, 0.00542893f, 0.00564443f, 0.02049502f, 0.02803200f, 
    -0.03301853f, -0.03161699f, -0.02635496f, -0.00323456f, 0.02749625f, -0.02795178f, -0.00758132f, -0.00849964f, 
    -0.03045415f, 0.01162389f, -0.00711095f, 0.01304445f, -0.00589351f, 0.00742423f, 0.02792591f, 0.02020869f, 
    0.02979989f, 0.02032215f, 0.02041555f, 0.02038820f, 0.00145051f, -0.03844812f, -0.00855239f, 0.01637005f, 
    -0.03391006f, -0.00985229f, -0.00193272f, -0.01996311f, 0.00908434f, -0.03941767f, -0.00048106f, -0.03484652f, 
    -0.00398944f, -0.04056819f, -0.03967213f, 0.01500290f, 0.03350912f, 0.00943645f, 0.03279009f, 0.03026640f, 
    -0.03406450f, 0.02829039f, -0.03900128f, -0.00154549f, 0.01230312f, 0.01788201f, 0.02308136f, 0.01256112f, 
    -0.04365207f, -0.01825790f, -0.00025470f, -0.02272073f, -0.02214766f, 0.02900959f, -0.01497858f, -0.02040582f, 
    -0.02992272f, -0.00289114f, -0.02217715f, 0.01181038f, -0.01672336f, 0.02314601f, 0.01568519f, 0.00588107f, 
    0.03151364f, -0.01950799f, -0.04306936f, -0.00077686f, 0.01359068f, -0.03628399f, -0.03118158f, -0.01025058f, 
    0.01186496f, 0.02162528f, -0.03321441f, -0.02056877f, -0.03224596f, 0.01075411f, -0.03075237f, 0.02687285f, 
    0.02001212f, -0.02408036f, -0.03211768f, -0.01035116f, -0.00431380f, -0.02244512f, 0.02627374f, 0.00893037f, 
    -0.02916052f, -0.02242593f, 0.01937007f, -0.01172448f, 0.02313541f, -0.00950553f, -0.01321707f, -0.00050304f, 
    -0.00522284f, -0.00544955f, 0.02009207f, 0.01047148f, -0.03556674f, 0.00418089f, -0.03599530f, 0.00864838f, 
    -0.02683668f, 0.02247911f, 0.00828054f, 0.03398632f, -0.00024058f, 0.00530570f, -0.04276649f, 0.00921111f, 
    -0.01642382f, -0.00947656f, 0.01616841f, -0.01233831f, -0.02378483f, -0.03363492f, -0.01830141f, -0.01247758f, 
    -0.04528421f, 0.00287319f, 0.03462857f, 0.01966379f, 0.02285152f, -0.00043639f, -0.01528906f, -0.03850834f, 
    0.01004547f, -0.00017889f, 0.01166139f, -0.01281770f, -0.03004212f, -0.01402965f, -0.00806272f, -0.01437130f, 
    0.00018280f, 0.01772895f, -0.00521159f, 0.01535551f, -0.01272701f, -0.01731018f, 0.01893353f, 0.00526480f, 
    0.01686791f, -0.04648991f, 0.01771807f, -0.01746559f, 0.03149726f, -0.00692932f, -0.02151687f, -0.03149565f, 
    -0.01693466f, -0.00986364f, 0.02930142f, -0.02203207f, -0.02395535f, 0.00412119f, 0.01245544f, -0.00312001f, 
    -0.02955760f, 0.00793817f, 0.02535769f, -0.02831407f, -0.02780292f, 0.00055230f, -0.01704381f, 0.03583553f, 
    -0.00503182f, -0.01315664f, -0.01694520f, 0.00774573f, -0.03588260f, -0.02021050f, 0.00936659f, -0.04430293f, 
    -0.03987039f, 0.00651091f, 0.00965456f, 0.01783424f, 0.01621992f, 0.01951838f, 0.01546818f, 0.04213232f, 
    -0.02478985f, 0.02609932f, 0.02785078f, -0.00168799f, -0.03916904f, 0.00701729f, -0.01072470f, 0.01354417f, 
    -0.04354521f, -0.01231342f, 0.03259239f, -0.03943362f, 0.00969845f, 0.01005439f, 0.02393567f, -0.00674506f, 
    0.00390555f, 0.01657665f, -0.00076077f, -0.03480896f, 0.00993790f, 0.01922455f, -0.02411807f, 0.01489747f, 
    -0.01857767f, 0.01281373f, 0.02695172f, -0.00322544f, 0.00799282f, 0.01205004f, -0.03428734f, -0.00933711f, 
    -0.01774607f, 0.02268254f, -0.01490102f, 0.02969717f, 0.02046102f, -0.01102160f, 0.01431126f, 0.03301968f, 
    0.00946411f, -0.04231381f, 0.00925965f, 0.01356748f, -0.04409170f, -0.02005047f, -0.00205811f, -0.00721661f, 
    -0.00751029f, 0.02327735f, -0.03694167f, 0.01800563f, 0.01577248f, -0.02387623f, -0.02933029f, -0.01071911f, 
    -0.01317063f, -0.02011740f, 0.00504090f, -0.02357407f, -0.04163932f, -0.01753133f, 0.01568531f, -0.01006002f, 
    -0.01473292f, 0.01688861f, 0.01472327f, -0.03160021f, -0.04066476f, -0.01528640f, -0.01667137f, 0.00394330f, 
    0.02607125f, -0.01250211f, -0.01213756f, 0.02079100f, 0.02085163f, -0.02323431f, 0.03078144f, -0.01014041f, 
    0.01347595f, -0.00113600f, -0.01396598f, -0.01958812f, -0.02266656f, 0.00291697f, 0.01102045f, 0.02079112f, 
    0.00429148f, -0.04456872f, -0.01540349f, 0.02148158f, 0.01947281f, -0.01323015f, 0.02254026f, 0.03038732f, 
    -0.01473733f, -0.01059135f, 0.02672297f, -0.01092001f, -0.02803124f, -0.01369882f, 0.02536394f, -0.00908416f, 
    -0.01330647f, 0.01948638f, 0.02317132f, -0.02583877f, -0.01505246f, -0.01811656f, 0.00882222f, -0.00745178f, 
    0.00358699f, -0.01675178f, -0.00084593f, 0.02591518f, 0.02598661f, 0.00324084f, -0.03693701f, 0.02508558f, 
    -0.00576490f, 0.02800685f, -0.02503776f, 0.03250380f, 0.01597334f, 0.00393215f, 0.02605022f, 0.02412294f, 
    -0.01878846f, -0.00713391f, -0.02898934f, -0.02448667f, -0.02139811f, -0.02441762f, -0.02932026f, -0.00882289f, 
    -0.02842062f, -0.02003668f, -0.02612154f, -0.00679843f, 0.00018328f, -0.03610192f, 0.01746081f, -0.02750190f, 
    -0.04146224f, 0.02017093f, -0.01169519f, 0.00995324f, -0.00654227f, 0.00887862f, -0.00711661f, -0.03972216f, 
    -0.01584488f, -0.01804925f, 0.01734874f, 0.01544217f, -0.02090311f, -0.00865109f, -0.00272478f, 0.02357777f, 
    0.03940416f, -0.00268072f, -0.03278841f, -0.02211474f, 0.02739739f, -0.04371126f, -0.00072159f, -0.03628131f, 
    -0.03286957f, 0.01483340f, 0.01269866f, 0.00971789f, 0.02739621f, -0.02019500f, 0.01737494f, -0.00190331f, 
    -0.02193681f, -0.01482822f, 0.01993027f, -0.01420632f, -0.01741301f, 0.01412522f, 0.02124778f, -0.01291497f, 
    -0.02429268f, 0.02798371f, -0.01668466f, 0.02203203f, -0.00099932f, -0.01087198f, -0.00311244f, 0.02742094f, 
    -0.01162915f, 0.01274376f, -0.00273373f, -0.02272869f, -0.00142960f, 0.00793822f, -0.03031153f, 0.02578122f, 
    -0.04117150f, -0.02735524f, -0.02347946f, -0.01489871f, -0.02326252f, -0.00514298f, -0.03973602f, -0.04129185f, 
    -0.01113622f, 0.00263457f, 0.02317135f, -0.03716623f, 0.01323803f, -0.02174148f, -0.00410969f, -0.01605303f, 
    0.01879741f, -0.04115501f, 0.01903110f, 0.02642149f, 0.00571024f, 0.00097540f, 0.02403208f, -0.02985622f, 
    0.00723852f, 0.01510307f, 0.01027600f, 0.00438932f, -0.00815615f, -0.02031606f, -0.04020922f, 0.02896973f, 
    -0.03411405f, 0.01848902f, -0.01678804f, 0.01806129f, -0.00534090f, 0.01791597f, -0.01758608f, 0.02740447f, 
    -0.03551690f, 0.02241148f, 0.02130343f, -0.01820072f, -0.02255551f, -0.02420252f, -0.01566076f, 0.02080766f, 
    0.03018718f, 0.02174453f, 0.00713172f, 0.02825396f, 0.00735145f, 0.01637496f, -0.03806536f, -0.00775498f, 
    -0.02635779f, -0.02307780f, -0.03798600f, -0.01559394f, -0.03093431f, -0.02363523f, 0.02797268f, -0.00779447f, 
    0.01856386f, 0.03269361f, 0.00407142f, 0.02592435f, -0.03065263f, 0.00908502f, 0.01921449f, 0.00644349f, 
    -0.00875789f, -0.00372185f, -0.00889614f, 0.00816652f, -0.01205221f, -0.01116451f, 0.03156352f, 0.01824580f, 
    -0.03792145f, 0.03718540f, 0.00021851f, -0.04044991f, 0.00677157f, -0.01200749f, 0.00406429f, -0.03175702f, 
    -0.00464495f, -0.02906564f, 0.02416595f, -0.02791608f, -0.00962331f, 0.03338328f, -0.02357995f, 0.02549209f, 
    -0.04043953f, -0.01452067f, 0.01566978f, 0.03205219f, -0.00437812f, 0.02427038f, 0.02823558f, -0.02149074f, 
    -0.00170724f, -0.01485247f, -0.02755275f, -0.03152093f, -0.02553766f, -0.03343002f, 0.02758288f, 0.01577109f, 
    -0.00523221f, 0.02051481f, -0.00848503f, -0.02312387f, 0.00889039f, -0.00556298f, -0.00537353f, 0.01679743f, 
    -0.00821058f, -0.03990598f, -0.01474947f, -0.01377698f, 0.02822462f, 0.01188546f, -0.01987505f, -0.01959829f, 
    0.01238697f, -0.01089288f, -0.01180418f, 0.00911548f, -0.00691293f, -0.00998861f, 0.01640821f, -0.03350727f, 
    -0.04460468f, 0.00605546f, -0.04101429f, 0.00920886f, 0.00842717f, 0.01662791f, 0.03185110f, -0.01886880f, 
    0.01923016f, 0.02554773f, -0.00810695f, -0.02793373f, -0.02436825f, -0.00265442f, -0.01538925f, -0.00525854f, 
    0.00897530f, -0.04114107f, -0.04041659f, 0.03780307f, -0.03459466f, 0.02428351f, -0.03624746f, 0.02505308f, 
    0.03463424f, -0.01647116f, -0.00578071f, 0.00450835f, 0.02073944f, 0.01261837f, 0.00622538f, -0.02811971f, 
    -0.00898310f, 0.03763478f, -0.04070264f, -0.01283774f, -0.02350437f, -0.01902501f, 0.00460809f, -0.00885324f, 
    0.01660939f, -0.00914300f, 0.01426200f, 0.02238858f, 0.03449165f, 0.02229785f, -0.01253345f, 0.02330260f, 
    0.00464608f, 0.02323767f, -0.00538194f, -0.04599616f, 0.01395818f, -0.00318808f, 0.02462375f, 0.01247545f, 
    0.02204896f, 0.00815120f, 0.02430899f, -0.02734766f, -0.04138961f, -0.03396546f, 0.01487146f, 0.01809005f, 
    -0.02427653f, -0.04214261f, 0.01034436f, -0.01703898f, -0.00898291f, -0.03564050f, -0.00399507f, -0.03727767f, 
    0.01722935f, -0.02810739f, -0.01837277f, -0.03044628f, 0.02343232f, -0.02286775f, -0.04008172f, -0.03415069f, 
    -0.04280953f, -0.02623044f, -0.00183568f, -0.01584508f, 0.00679433f, 0.01714338f, -0.00344291f, -0.03092049f, 
    -0.03041377f, -0.01013387f, 0.00580477f, 0.02531691f, 0.01875930f, -0.01326363f, 0.01681258f, -0.02851905f, 
    -0.03509842f, -0.01120862f, 0.02331075f, -0.00680235f, -0.04262564f, 0.02739924f, 0.00142654f, 0.03168844f, 
    -0.03850678f, -0.03660982f, -0.01922010f, -0.03195380f, -0.00291320f, 0.02139240f, -0.01720886f, 0.00465894f, 
    0.00597772f, -0.00472761f, 0.01087095f, 0.00928833f, -0.01934950f, -0.00664014f, 0.03007571f, -0.01811605f, 
    -0.02201295f, -0.04032221f, -0.02926102f, -0.03895532f, -0.02286911f, -0.01600991f, -0.03451107f, 0.00224162f, 
    -0.02796348f, -0.03247067f, 0.02068119f, -0.03577664f, -0.02193362f, 0.01189840f, -0.04392893f, 0.02431230f, 
    0.02180924f, -0.03042073f, -0.01037486f, -0.01831916f, -0.03147282f, 0.02864830f, 0.02110023f, -0.03686039f, 
    -0.02813006f, -0.01881456f, 0.01925251f, -0.01854415f, 0.01508137f, -0.01583499f, 0.01670169f, 0.00511656f, 
    0.01895079f, 0.00858231f, -0.01885727f, -0.02447149f, 0.01135298f, -0.01631423f, -0.02809589f, -0.02501041f, 
    0.03011167f, 0.01881469f, -0.01932304f, 0.02767919f, -0.03175970f, -0.00865400f, 0.02393598f, 0.00217613f, 
    -0.03945772f, -0.00342468f, 0.00106480f, -0.02550462f, -0.00429878f, 0.01351576f, -0.02557357f, -0.03260801f, 
    -0.03185356f, 0.01658346f, -0.02258452f, 0.00576766f, 0.00013674f, -0.01251991f, -0.00445474f, 0.00976306f, 
    -0.01555607f, 0.01530624f, 0.01397670f, -0.00670423f, -0.01576446f, -0.01103566f, 0.01130280f, -0.03590049f, 
    0.03336725f, 0.00898250f, 0.01454955f, 0.00819133f, -0.00430675f, -0.01877200f, 0.00325210f, -0.00944868f, 
    -0.03048310f, -0.01351777f, 0.03608416f, -0.00382284f, -0.04177871f, 0.03033133f, 0.02564014f, -0.02383168f, 
    -0.00699416f, 0.02727013f, -0.00073949f, 0.00024674f, -0.03216279f, 0.01123908f, 0.01329071f, -0.00195086f, 
    -0.00716517f, -0.01835502f, 0.02973579f, 0.01641335f, -0.02606506f, 0.01364064f, -0.03573911f, -0.03762636f, 
    -0.02519866f, 0.00356201f, -0.02001273f, -0.00114739f, 0.01947362f, -0.00707450f, -0.01682896f, -0.01497148f, 
    0.00044315f, -0.02585517f, -0.00692346f, -0.02666214f, 0.03145247f, -0.00006965f, -0.01249699f, 0.02031510f, 
    -0.02429959f, 0.01004361f, -0.00916456f, -0.01164189f, 0.01108240f, -0.01518865f, 0.00715583f, -0.03141247f, 
    -0.00207451f, -0.03266835f, -0.00287972f, 0.00504852f, 0.02239215f, 0.03257708f, 0.00957089f, 0.00307143f, 
    -0.03735379f, -0.02735922f, 0.01694460f, 0.00314297f, 0.00743847f, -0.01224745f, -0.04022751f, 0.00583253f, 
    0.01170964f, -0.00495971f, 0.00733665f, -0.02411592f, 0.03947107f, -0.01499475f, 0.01460917f, -0.00527564f, 
    -0.00871339f, -0.00343826f, 0.00972110f, 0.02108602f, 0.00476428f, -0.02051917f, -0.02477258f, -0.01899628f, 
    0.02682923f, -0.02405086f, 0.02415437f, 0.01560713f, -0.00796998f, -0.04247784f, 0.01698984f, -0.02695021f, 
    -0.00194366f, -0.03267256f, -0.03249850f, -0.01838336f, 0.01223204f, 0.02883275f, 0.00689308f, -0.00254891f, 
    -0.04223106f, -0.00141371f, -0.04264676f, 0.00683265f, 0.01429829f, -0.04072287f, -0.03546378f, 0.01796632f, 
    -0.00378539f, -0.03222942f, 0.00189655f, -0.02433329f, 0.00242860f, 0.01590886f, 0.02901189f, -0.00029148f, 
    0.01495940f, -0.03537817f, -0.01981900f, 0.01237523f, 0.02562172f, 0.00473154f, 0.02220283f, -0.04027687f, 
    0.02939330f, -0.03833628f, 0.02436280f, -0.03593997f, 0.01316458f, -0.00090555f, -0.01153359f, -0.04162630f, 
    -0.00899656f, 0.01225806f, -0.03439308f, -0.01737552f, -0.03785170f, -0.03160206f, 0.01492659f, -0.00740836f, 
    0.00459930f, 0.01343027f, 0.00108235f, -0.01802663f, 0.01081843f, -0.04175462f, 0.01564964f, -0.02964241f, 
    -0.01129760f, 0.00129695f, -0.02811741f, -0.01680078f, -0.01474334f, -0.00889873f, -0.02276785f, 0.00010379f, 
    0.02429474f, -0.01913561f, -0.02199608f, 0.00521748f, -0.04224405f, 0.02574566f, 0.02173684f, -0.04089251f, 
    0.01723000f, 0.01789184f, -0.04368908f, -0.01805211f, -0.01876670f, 0.01843766f, -0.01885144f, 0.02759729f, 
    0.01290775f, -0.02650926f, -0.00935967f, -0.04241604f, -0.01556076f, -0.03294532f, 0.02477101f, 0.01103458f, 
    0.02222966f, -0.02479948f, -0.03479040f, -0.02476202f, -0.01081791f, 0.01731105f, 0.01299206f, 0.01398378f, 
    0.01232168f, -0.00756299f, -0.01517390f, 0.01450848f, 0.00581532f, -0.01256252f, -0.01416001f, 0.00215510f, 
    -0.02123857f, 0.00487594f, 0.01896105f, -0.01592053f, -0.01106060f, 0.00926762f, -0.02224921f, -0.01276823f, 
    0.00175195f, -0.00540455f, 0.01045898f, -0.01459299f, -0.00997308f, 0.02050849f, -0.03123479f, -0.02732125f, 
    -0.00873284f, 0.01935055f, 0.01810720f, -0.01695837f, -0.00025627f, -0.00819645f, -0.03574248f, 0.01813793f, 
    0.01750010f, 0.02496320f, 0.01319338f, -0.04403459f, -0.01364352f, 0.00789875f, 0.00083732f, -0.01598893f, 
    0.02119085f, -0.01516796f, -0.03522694f, 0.02391580f, -0.00664388f, -0.01117833f, -0.02591657f, 0.02438528f, 
    0.02155420f, -0.04136730f, -0.01991266f, -0.02068044f, -0.00748398f, 0.01669064f, 0.00684782f, -0.01924398f, 
    0.00708935f, 0.00739797f, -0.03177244f, 0.02302869f, -0.00447999f, 0.00646503f, -0.01493672f, -0.04214220f, 
    0.03120747f, -0.02560670f, 0.02365467f, 0.01392235f, 0.03210743f, 0.01744770f, -0.00655506f, 0.02390780f, 
    0.01315661f, 0.00176339f, -0.00181245f, 0.02744862f, 0.00507778f, -0.00507428f, -0.03815969f, -0.02532324f, 
    0.01621580f, 0.02666915f, 0.00506613f, -0.02701466f, -0.03497333f, -0.01747828f, 0.00468704f, 0.01987511f, 
    -0.03702488f, -0.00007389f, -0.00234462f, 0.02635441f, -0.02562428f, -0.00362987f, -0.02460928f, 0.01202685f, 
    0.02756736f, -0.03572700f, 0.00445361f, -0.01097695f, 0.02083034f, 0.01507519f, 0.00304054f, 0.00864442f, 
    -0.02795023f, -0.01512847f, 0.01048264f, 0.02528834f, 0.01278588f, -0.03787310f, 0.01687891f, -0.01931081f, 
    -0.02370364f, 0.00912287f, 0.02746912f, -0.02435816f, -0.01254945f, -0.01126018f, 0.00830466f, -0.03067381f, 
    0.02211374f, 0.00237062f, -0.02767389f, -0.03882279f, -0.01221633f, -0.01525279f, -0.02236539f, 0.00915577f, 
    0.02307710f, -0.03231360f, 0.00559050f, 0.01839920f, -0.03748886f, -0.00367698f, -0.01218473f, -0.01889699f, 
    0.00483392f, -0.00680847f, -0.03858680f, -0.02856634f, -0.04008531f, 0.02654172f, 0.00467899f, -0.00568168f, 
    -0.03752686f, -0.03003652f, -0.00499207f, -0.02478611f, 0.01664615f, 0.00771835f, 0.02606324f, -0.04227388f, 
    -0.02336134f, 0.02810273f, -0.01085230f, -0.02406797f, -0.00822622f, -0.01564539f, 0.00069567f, -0.03719642f, 
    -0.01066356f, -0.03636670f, 0.02311316f, -0.03021499f, -0.03184446f, -0.04107837f, -0.00472671f, -0.01340335f, 
    0.00282708f, 0.01495074f, -0.01939853f, -0.04182101f, 0.01997738f, -0.02937891f, 0.02801936f, -0.00111273f, 
    -0.02922242f, -0.00368900f, -0.02857122f, -0.03410814f, -0.00913667f, -0.00705226f, -0.01480057f, -0.01441627f, 
    -0.02545946f, 0.00287552f, 0.03421102f, -0.00622938f, -0.01988790f, -0.03569130f, 0.00474566f, -0.01576428f, 
    -0.01796447f, 0.02112115f, 0.01553135f, -0.02755781f, -0.03213089f, -0.02497722f, -0.01122175f, -0.01655791f, 
    -0.02263058f, -0.03019629f, -0.03503407f, 0.02583344f, 0.03199454f, -0.02744998f, -0.00045320f, -0.00261132f, 
    0.00314564f, -0.03601187f, -0.02392913f, -0.02632109f, 0.01497954f, 0.03354876f, -0.02767627f, -0.01568390f, 
    -0.00776678f, 0.00433583f, 0.03080906f, -0.00852888f, 0.02522985f, 0.02339642f, -0.03020518f, 0.02553683f, 
    -0.02481234f, 0.02304255f, -0.00438897f, 0.00380227f, 0.00537272f, 0.01695149f, -0.00343587f, -0.03730230f, 
    -0.02372942f, -0.03444313f, -0.01612723f, -0.00454461f, 0.01395920f, -0.00684863f, 0.00878212f, -0.03441320f, 
    -0.01716787f, -0.01437944f, 0.00523978f, -0.01620696f, -0.03015934f, -0.02606026f, -0.01185003f, 0.00551185f, 
    0.02891626f, 0.00256825f, 0.03311118f, -0.02198554f, -0.00536855f, -0.02181483f, -0.00275520f, 0.00476870f, 
    -0.01918734f, -0.02465307f, -0.02216683f, -0.01459746f, -0.01342209f, 0.00213689f, 0.03455713f, 0.01703020f, 
    -0.01437180f, -0.00230392f, 0.03065219f, -0.02246752f, 0.03203846f, -0.01072894f, -0.03575113f, 0.03588574f, 
    -0.02088733f, 0.02287772f, 0.01841187f, 0.03534096f, -0.00228075f, 0.03096027f, -0.01035234f, -0.00790900f, 
    0.03367156f, -0.02444215f, 0.03003119f, -0.00593648f, -0.02400462f, 0.02187278f, -0.00869999f, -0.02778255f, 
    0.00108282f, 0.01250941f, -0.03882271f, -0.03577976f, -0.00077972f, 0.02494755f, 0.01594898f, 0.02124484f, 
    -0.03480803f, 0.00191548f, -0.00731690f, 0.02490017f, -0.03097980f, 0.03072786f, 0.01788724f, -0.00877466f, 
    0.00702226f, 0.02009183f, -0.00680848f, -0.03566315f, 0.00288129f, -0.01837851f, -0.01231799f, 0.02425757f, 
    -0.01760032f, 0.00936306f, -0.02833312f, -0.00550807f, -0.01693019f, 0.01627536f, 0.03182934f, -0.00818984f, 
    0.00040419f, -0.03053649f, -0.03431772f, 0.01115659f, 0.01951179f, -0.04066649f, -0.00491330f, 0.01693578f, 
    -0.03811982f, -0.03764396f, 0.00259386f, 0.01891292f, -0.04120069f, 0.02071610f, 0.00160024f, -0.00983074f, 
    0.03005043f, -0.01070815f, -0.00211716f, -0.03034523f, -0.03695250f, 0.01168180f, -0.00001319f, -0.03727689f, 
    0.01967494f, -0.00786584f, 0.03258950f, -0.01869682f, 0.03354805f, 0.00193031f, -0.00664952f, -0.02725234f, 
    -0.01095556f, -0.01651136f, -0.01293474f, -0.01360532f, 0.02778618f, 0.03158152f, 0.01413807f, -0.02982028f, 
    0.03432731f, 0.02530212f, 0.01008404f, 0.00668721f, -0.01139278f, -0.04112079f, 0.00331937f, -0.00535791f, 
    0.02071629f, 0.00279197f, -0.00162515f, -0.01148881f, -0.01802569f, 0.01991419f, -0.01371383f, 0.02021276f, 
    0.01193384f, -0.00289295f, 0.02528984f, 0.02501298f, 0.00603051f, -0.03580859f, 0.00712071f, 0.01850077f, 
    -0.02877661f, 0.01493006f, 0.02442295f, -0.02578300f, -0.02490803f, -0.00258640f, 0.00923818f, -0.04095551f, 
    0.01081771f, -0.03851964f, 0.00464223f, 0.01385572f, -0.03916794f, 0.02057106f, 0.00488678f, -0.02111484f, 
    0.02626722f, 0.02919196f, 0.00883447f, -0.02942834f, -0.02774895f, 0.01018805f, 0.00793647f, 0.03029229f, 
    0.00055725f, 0.01411349f, -0.02283638f, 0.02225213f, -0.02129486f, 0.02731453f, 0.02448835f, -0.01646699f, 
    -0.00670761f, -0.02641828f, -0.00769984f, 0.01356720f, 0.01380556f, 0.03001762f, -0.02534917f, 0.01988882f, 
    -0.03437123f, -0.03370358f, 0.02663394f, -0.03056145f, 0.00502457f, -0.03907417f, -0.00312608f, -0.00662086f, 
    -0.03005700f, -0.00556248f, 0.02560247f, 0.01006776f, -0.00876613f, -0.00937363f, -0.00193953f, 0.00441910f, 
    -0.00052434f, -0.01956220f, -0.00154010f, 0.01140041f, 0.00229281f, 0.00408815f, -0.03217521f, -0.00988597f, 
    -0.01334605f, -0.01804031f, 0.03070397f, -0.03656097f, 0.00779722f, -0.00029630f, 0.00311491f, -0.03720818f, 
    0.03083275f, -0.02572310f, -0.03095853f, -0.00489679f, -0.03580604f, -0.03903190f, -0.01120582f, -0.02528133f, 
    0.00887920f, -0.01510761f, -0.00053031f, -0.01046251f, -0.00753299f, -0.01530845f, -0.02855995f, 0.00958393f, 
    -0.02826186f, 0.00148822f, 0.01656440f, 0.00700867f, 0.02291856f, -0.01372971f, -0.01821954f, 0.01035340f, 
    -0.00677014f, 0.00557421f, 0.01882435f, -0.00178497f, -0.00558849f, 0.02849527f, 0.00484082f, -0.01316789f, 
    -0.01905581f, 0.03190687f, 0.01146482f, -0.03341610f, -0.02400087f, 0.00357061f, 0.00794024f, -0.02294915f, 
    -0.00781657f, 0.03401308f, -0.00852011f, 0.00555871f, -0.02919520f, -0.02395630f, -0.00746472f, 0.00396257f, 
    -0.01885032f, -0.00835306f, -0.03783676f, -0.01754015f, -0.02310801f, 0.02311921f, 0.00962270f, 0.02297751f, 
    -0.01380827f, -0.00355461f, 0.03345002f, 0.01135202f, 0.01444750f, -0.00017726f, -0.02313896f, -0.01845428f, 
    -0.03953514f, -0.02162718f, -0.02103962f, -0.01245786f, 0.03204218f, 0.02503103f, -0.03528978f, 0.00326083f, 
    0.02387684f, -0.03160979f, 0.02470811f, -0.03506113f, -0.00010899f, 0.00742183f, -0.01482430f, -0.03379434f, 
    -0.01643337f, 0.02498208f, -0.01934415f, 0.03227612f, -0.00878207f, 0.02349502f, -0.02664351f, 0.03125544f, 
    0.00868777f, -0.00219618f, 0.02669766f, -0.02468730f, -0.00224699f, 0.01094189f, -0.03653295f, 0.01847925f, 
    0.00296419f, 0.02656270f, -0.03128209f, -0.02001205f, -0.00404679f, -0.02503734f, 0.03083562f, 0.00461278f, 
    -0.00694559f, -0.03216026f, -0.01161988f, -0.01318268f, -0.02670778f, 0.03073044f, -0.01873815f, 0.02824616f, 
    -0.02342487f, -0.01480038f, -0.01189580f, -0.02267596f, -0.01825167f, -0.03242354f, -0.00140220f, -0.02293558f, 
    -0.02498038f, -0.01607553f, 0.02460760f, 0.01777325f, 0.01101834f, 0.00632557f, -0.01153603f, 0.00951103f, 
    0.01510244f, -0.02794788f, -0.03311516f, -0.00209795f, -0.04054449f, -0.00699485f, 0.01349458f, -0.01801725f, 
    -0.00964293f, -0.03453169f, -0.01455057f, 0.01100553f, -0.02989513f, -0.02251186f, -0.03338273f, -0.01417233f, 
    0.01210482f, -0.01554893f, 0.02551596f, -0.01301510f, -0.03283742f, -0.01563882f, 0.01936406f, 0.00792228f, 
    0.00641043f, -0.00104915f, 0.01536607f, 0.01870954f, -0.00460966f, 0.02230671f, 0.00372083f, -0.02608479f, 
    -0.03727183f, -0.03420898f, -0.01398224f, -0.02141945f, 0.01550062f, 0.02838391f, -0.02635203f, 0.00192911f, 
    -0.00235516f, 0.01261296f, 0.00566687f, -0.00046974f, -0.04041386f, -0.01262075f, 0.00781534f, 0.02971689f, 
    -0.01811577f, 0.03392385f, -0.01993761f, 0.01798509f, 0.02897022f, -0.03536539f, 0.02537605f, -0.02300014f, 
    -0.01063953f, -0.01368047f, -0.02372839f, -0.00703313f, -0.01031974f, 0.01630335f, 0.03569255f, 0.01811557f, 
    -0.00862879f, -0.03504325f, -0.00508408f, 0.01803663f, -0.01866031f, -0.01927338f, 0.02841438f, -0.00636400f, 
    -0.02815725f, 0.02709464f, 0.02743233f, 0.00667090f, -0.00116741f, -0.00464062f, -0.00436143f, 0.02896606f, 
    -0.03793252f, 0.00145252f, -0.02931076f, 0.01782246f, -0.00095954f, 0.01418453f, -0.01809178f, 0.02126583f, 
    0.02184585f, -0.01079853f, -0.03149727f, 0.01465347f, -0.01809114f, -0.00953390f, -0.02911405f, 0.01639473f, 
    -0.01195894f, 0.00989876f, -0.00841973f, -0.03112922f, -0.02856533f, 0.00170963f, -0.02100120f, -0.02946234f, 
    -0.03019923f, -0.01644633f, -0.03173703f, -0.00109795f, -0.02772185f, -0.01670468f, 0.01727398f, -0.02615351f, 
    -0.03273011f, -0.01166037f, -0.00660979f, 0.01950860f, -0.01875241f, -0.02460614f, -0.01485563f, -0.01195818f, 
    0.01250396f, -0.03997713f, 0.01902551f, 0.00114858f, -0.03750107f, -0.01315812f, 0.02144943f, -0.00624664f, 
    0.02483342f, 0.02280173f, 0.00052034f, -0.02513938f, -0.02607664f, 0.00632211f, -0.00804870f, -0.00278250f, 
    0.02062381f, 0.02832115f, -0.01797709f, -0.01438444f, -0.00530439f, -0.03096816f, -0.01637362f, 0.00449934f, 
    0.01794848f, -0.00913095f, -0.03228292f, 0.01919498f, 0.02554153f, -0.00259502f, -0.00212007f, -0.01579591f, 
    -0.00052598f, 0.01267883f, -0.02983042f, -0.00560299f, -0.02619867f, 0.02741155f, -0.00030033f, 0.00234166f, 
    -0.01631186f, 0.02660921f, -0.04005365f, 0.00484054f, -0.02238240f, -0.03671681f, 0.02798996f, -0.01236025f, 
    -0.02325620f, -0.00730564f, 0.02731579f, 0.00906813f, -0.00108001f, 0.03521622f, 0.03249059f, -0.02309449f, 
    -0.02213432f, -0.01586611f, -0.00931467f, 0.02689742f, -0.00876930f, -0.01295617f, -0.03365422f, -0.03753423f, 
    -0.00906591f, 0.00718843f, 0.01624344f, 0.00336058f, -0.03844535f, -0.03680728f, -0.01170272f, -0.02685473f, 
    0.03026139f, -0.01809708f, 0.01727700f, 0.02127093f, -0.02379314f, 0.01968439f, -0.01915312f, -0.00208779f, 
    0.02065222f, 0.02395534f, 0.03287200f, 0.00578478f, -0.01742675f, -0.00228914f, 0.01681919f, -0.02745137f, 
    -0.00183427f, 0.01849871f, -0.02842995f, 0.01146755f, -0.01968682f, 0.00023831f, -0.01939265f, -0.01252027f, 
    0.00493148f, 0.00463136f, 0.02631928f, -0.03486763f, -0.04029677f, -0.01795533f, -0.02832341f, -0.03796154f, 
    -0.02891598f, -0.02786227f, -0.01106901f, 0.01767681f, 0.02618851f, -0.01826071f, -0.02721342f, -0.03783511f, 
    -0.03589555f, -0.02722902f, -0.00218908f, -0.01303740f, -0.03461773f, 0.02276617f, -0.00976261f, 0.01847943f, 
    -0.01602861f, -0.00383190f, -0.00340167f, 0.02853922f, 0.02171882f, 0.01938670f, -0.03512101f, -0.01910270f, 
    -0.02522973f, -0.00504353f, -0.03379916f, -0.03472357f, 0.01719684f, 0.00559625f, -0.00012132f, -0.03725685f, 
    -0.03109593f, -0.02064933f, -0.03467642f, -0.03275956f, -0.03926014f, -0.03266524f, 0.02743872f, -0.00400535f, 
    0.03062179f, 0.01123125f, 0.02518651f, -0.02110788f, -0.01581223f, 0.01183475f, 0.01248225f, -0.02502907f, 
    0.01973879f, 0.01780818f, -0.04023487f, -0.03860872f, -0.03111117f, -0.02123586f, -0.00762005f, 0.02713238f, 
    -0.03473385f, -0.01209383f, -0.03250246f, 0.01436883f, 0.02337129f, 0.00618699f, 0.00253713f, -0.01016144f, 
    -0.01944585f, 0.01467405f, 0.00651480f, -0.02255706f, -0.03229354f, 0.00848635f, -0.00300585f, 0.00297094f, 
    0.01975556f, -0.00088923f, -0.03390317f, 0.00563165f, -0.02962344f, -0.02244205f, 0.03079801f, 0.03016103f, 
    0.00342336f, 0.03445501f, -0.00772136f, -0.03035266f, -0.01939230f, -0.00444061f, -0.00731053f, -0.01882625f, 
    -0.03332512f, -0.01722752f, -0.01174780f, 0.02759540f, -0.01797419f, 0.02101703f, -0.02424389f, 0.00540495f, 
    -0.01326698f, -0.03235007f, 0.00986994f, 0.00498463f, -0.02113362f, -0.02364342f, 0.02832360f, 0.03170688f, 
    0.03079923f, -0.03008555f, -0.03397757f, -0.02106452f, 0.03322538f, -0.02000905f, 0.02098157f, 0.02837084f, 
    0.02459257f, -0.02224222f, -0.01794276f, 0.02636734f, 0.02621256f, -0.00290228f, -0.00786645f, 0.00309561f, 
    -0.02454799f, -0.00707934f, -0.03509486f, 0.00519442f, 0.03337115f, -0.00173436f, 0.02876549f, -0.02708374f, 
    -0.02833979f, 0.00676013f, 0.01180580f, -0.02248635f, 0.02170503f, -0.02096359f, 0.01194751f, -0.02200026f, 
    0.02127207f, -0.03448144f, -0.03586205f, -0.00820617f, -0.00690917f, -0.02932714f, 0.00046373f, -0.03482326f, 
    0.00505984f, -0.03856471f, 0.01341180f, 0.02539766f, -0.01014057f, -0.03619380f, 0.00011954f, 0.01474571f, 
    -0.03337627f, -0.03424107f, -0.02672914f, 0.00831179f, -0.03319605f, -0.02477528f, -0.02041082f, -0.03024432f, 
    -0.00869589f, 0.03386033f, -0.03180365f, -0.02893131f, 0.03336370f, -0.01834167f, 0.00316339f, -0.00596053f, 
    -0.02422995f, -0.00513118f, -0.03853519f, -0.03457632f, 0.00174837f, -0.02777881f, -0.01697858f, -0.01900795f, 
    0.02793804f, -0.02443750f, -0.00639770f, -0.02554342f, -0.02356438f, -0.02596053f, 0.00860890f, -0.02040515f, 
    -0.02843244f, 0.01072238f, 0.01694770f, -0.03618972f, 0.03040000f, 0.00453368f, -0.02571958f, 0.00450301f, 
    0.02562193f, -0.01705684f, -0.04009229f, -0.00974416f, -0.01340307f, -0.03030244f, 0.00549890f, -0.00194723f, 
    0.02918543f, 0.03054160f, -0.04094143f, 0.01933390f, -0.03857255f, 0.01171287f, -0.02715718f, 0.01801614f, 
    0.00896001f, -0.00854643f, -0.02345011f, -0.03149265f, 0.00939189f, 0.00862243f, 0.00555754f, 0.01023172f, 
    -0.03976668f, -0.00449224f, -0.01732247f, -0.02336002f, -0.00227155f, 0.02521929f, -0.00994206f, 0.00668383f, 
    -0.00964758f, -0.00096937f, -0.03355272f, -0.00812972f, 0.01438347f, -0.00639951f, 0.00325336f, -0.03267651f, 
    -0.01570062f, 0.01203030f, -0.00994957f, -0.00180741f, -0.03599149f, 0.01370560f, -0.02681454f, -0.01120738f, 
    -0.01445950f, 0.01448325f, 0.02701571f, 0.00034400f, -0.02390222f, 0.00186715f, 0.00140482f, -0.00447222f, 
    0.01313040f, 0.02572907f, -0.00014914f, -0.03689944f, 0.01209154f, -0.01576953f, -0.01729798f, 0.02026954f, 
    -0.04065090f, -0.02415563f, -0.02774620f, 0.01324844f, 0.02749356f, 0.00773039f, -0.04007457f, -0.03575461f, 
    -0.02968810f, -0.00324613f, -0.04001643f, -0.03716194f, 0.02476429f, -0.00336031f, -0.03213578f, 0.01316895f, 
    -0.01380494f, 0.03352416f, 0.02970959f, -0.00190195f, -0.01423570f, 0.00945757f, 0.01852529f, 0.00615264f, 
    -0.01218401f, 0.00284499f, 0.00445677f, 0.01205252f, -0.01824793f, -0.03763089f, -0.02639277f, 0.01287541f, 
    0.02642566f, 0.01407498f, -0.01935155f, -0.00772738f, 0.02842426f, -0.00077936f, 0.01149876f, -0.03453296f, 
    -0.03274472f, -0.02924615f, -0.00721318f, -0.00191671f, -0.03613235f, -0.03327771f, -0.02995239f, 0.02525009f, 
    0.02188077f, -0.02044364f, -0.03549187f, 0.02297784f, 0.00797996f, -0.02818374f, -0.04096920f, -0.01776415f, 
    -0.02886607f, 0.00837317f, 0.01332881f, 0.01640696f, -0.02714713f, -0.00899602f, 0.00506126f, -0.01914752f, 
    -0.02086169f, -0.03355084f, -0.02496769f, 0.02997584f, 0.01742250f, 0.02378280f, 0.02921706f, -0.01628144f, 
    -0.01224007f, -0.00707791f, 0.00398330f, -0.03830466f, -0.02297927f, 0.00407793f, 0.01779518f, -0.00624174f, 
    -0.03380716f, -0.00075727f, 0.01929005f, -0.02158134f, -0.01070826f, -0.03208351f, 0.01559802f, 0.02183080f, 
    0.01202635f, 0.00142893f, -0.01133793f, 0.01882178f, -0.03418801f, 0.01211914f, 0.03546945f, -0.03711366f, 
    -0.00934842f, 0.01443714f, -0.01418951f, 0.01652766f, 0.02759859f, 0.00847409f, -0.03211974f, 0.00374042f, 
    0.01829256f, -0.02893667f, 0.02603691f, 0.00430040f, -0.03617641f, 0.01679865f, 0.01535871f, -0.00784423f, 
    0.02997235f, -0.01841873f, 0.02706618f, -0.01239506f, -0.02392297f, -0.00220157f, -0.01852730f, 0.00412043f, 
    -0.03387352f, -0.03838958f, -0.01552691f, -0.04040639f, 0.00958471f, 0.00312403f, -0.02536287f, 0.00594494f, 
    -0.02069678f, 0.01386738f, 0.00140117f, -0.01084119f, -0.03585813f, -0.01870384f, -0.00430579f, 0.00931576f, 
    -0.02246501f, 0.01100217f, 0.02415286f, -0.00251879f, 0.02450838f, -0.03469435f, 0.01643428f, 0.00887995f, 
    -0.02043748f, 0.02059786f, 0.00259612f, 0.02201119f, -0.02653860f, -0.00487939f, -0.02395842f, -0.02189904f, 
    0.00731236f, 0.01290735f, 0.02583264f, -0.02645476f, -0.02666281f, -0.03893307f, 0.00510760f, -0.00000399f, 
    -0.03746991f, -0.03940137f, 0.02816894f, -0.01466683f, -0.02879148f, 0.02704480f, 0.00683027f, 0.01087028f, 
    0.00166427f, 0.02207600f, 0.02761833f, 0.01502095f, 0.01730894f, -0.01867793f, 0.02144831f, -0.01709179f, 
    -0.00061516f, 0.02146736f, 0.01048645f, -0.00931883f, -0.02261497f, 0.02999897f, 0.00452457f, -0.01274937f, 
    -0.01376032f, 0.02290246f, -0.00209631f, -0.00814184f, -0.03194671f, 0.01377934f, -0.02198909f, -0.00666795f, 
    -0.03334175f, 0.00989769f, -0.02550565f, -0.00378109f, -0.02800545f, 0.00258914f, 0.02370679f, 0.02954381f, 
    0.02173838f, -0.02223681f, -0.01671266f, 0.00657438f, -0.01634337f, -0.01272324f, -0.00708352f, -0.03056053f, 
    -0.00161494f, 0.00944383f, 0.00758374f, -0.03839946f, 0.00942457f, -0.03550417f, -0.01079980f, 0.02744061f, 
    0.01906596f, 0.01415883f, -0.00665702f, -0.04074748f, -0.02379987f, 0.01303281f, -0.01664010f, 0.00615397f, 
    -0.03216908f, -0.03372598f, 0.00680607f, -0.03697739f, 0.02827330f, -0.01862188f, -0.00391884f, 0.01122861f, 
    0.00480613f, 0.01771258f, -0.02290376f, 0.00471023f, -0.01742632f, 0.03877045f, -0.00832018f, 0.00751524f, 
    0.02399009f, 0.03112287f, -0.00089036f, 0.00423227f, 0.00004295f, 0.01563274f, -0.02090451f, -0.02447024f, 
    0.00423775f, 0.01085880f, 0.01509737f, 0.00675935f, -0.01518621f, 0.03133497f, -0.02374335f, -0.00467639f, 
    -0.01236331f, 0.01472815f, 0.00151380f, -0.04014729f, -0.04018440f, -0.01749701f, -0.00465486f, -0.00932072f, 
    -0.03605779f, 0.00771723f, -0.03116478f, -0.01325538f, 0.00022388f, 0.01716541f, -0.00498489f, -0.03803719f, 
    0.03874228f, 0.02776074f, -0.03264433f, -0.03299642f, 0.03512448f, -0.02780352f, -0.02861509f, 0.02866886f, 
    0.02687313f, -0.03413349f, -0.02045337f, -0.01926149f, -0.00743616f, -0.04041204f, -0.01802568f, -0.03274962f, 
    -0.00773652f, -0.01692973f, -0.01776810f, -0.01097695f, 0.02061462f, -0.01538301f, 0.00517807f, 0.02151982f, 
    -0.01827967f, -0.00556984f, -0.02337623f, -0.01277387f, 0.00517595f, 0.01298048f, -0.03569844f, 0.01439503f, 
    -0.03662012f, -0.01440369f, 0.02056772f, 0.02602376f, -0.02238791f, -0.00651176f, -0.01445787f, 0.01720412f, 
    0.00353272f, -0.00986019f, 0.00909806f, 0.03514003f, 0.02417406f, 0.01672014f, 0.02060703f, 0.00723713f, 
    -0.01133622f, -0.03321149f, 0.02814357f, -0.03807595f, -0.03132052f, 0.00946434f, -0.01477665f, -0.01344157f, 
    0.01050054f, 0.00916405f, -0.00534374f, 0.00646045f, -0.03600230f, 0.00611248f, -0.01837593f, 0.01077042f, 
    -0.03217504f, 0.00622242f, 0.00774918f, 0.02765945f, -0.04150539f, 0.04162528f, -0.01354680f, -0.00807561f, 
    -0.01347036f, -0.00713753f, -0.03278014f, 0.01657614f, -0.01957842f, 0.03960217f, -0.02381665f, -0.00666681f, 
    -0.02177436f, -0.02203910f, 0.02840194f, -0.00542879f, 0.01518537f, 0.00402716f, 0.01137599f, 0.00580492f, 
    -0.02551439f, 0.00478262f, -0.02748397f, -0.02944677f, -0.01070655f, 0.02054366f, 0.00101509f, -0.02402647f, 
    0.00149440f, 0.00923250f, 0.02312818f, -0.03043359f, -0.02513569f, 0.01925535f, -0.00377507f, -0.02770510f, 
    0.02230158f, 0.00154662f, -0.00002348f, -0.00167348f, 0.00479080f, -0.02103158f, 0.02190645f, 0.01576211f, 
    -0.00652838f, 0.00037537f, -0.00282517f, 0.00798141f, -0.00569866f, 0.00312014f, -0.00996409f, 0.01334648f, 
    0.01042056f, 0.01950106f, -0.02736022f, -0.02342521f, -0.01823990f, 0.00192461f, 0.02966927f, 0.02712798f, 
    -0.03306728f, -0.02962630f, 0.02021333f, 0.01315628f, -0.02601386f, -0.03237615f, 0.02464083f, 0.03514171f, 
    -0.02722180f, -0.01505541f, -0.00368781f, 0.01484487f, 0.01776736f, -0.01147024f, 0.03676774f, -0.03187902f, 
    0.02836684f, -0.01364903f, -0.02255829f, -0.02353258f, 0.01927102f, 0.00941353f, 0.02354826f, -0.02946985f, 
    -0.02028536f, -0.00778226f, -0.04057623f, 0.02352886f, 0.02386433f, 0.00281866f, 0.00883942f, -0.02544332f, 
    0.00135936f, 0.02530020f, 0.00054045f, -0.02053813f, 0.01660955f, 0.02513479f, 0.02093777f, -0.02639490f, 
    -0.04139942f, 0.01561865f, -0.00555993f, -0.02031717f, 0.02279174f, -0.01256531f, 0.02658086f, -0.00930656f, 
    0.00660737f, 0.02510795f, -0.02041130f, -0.03295427f, -0.03486374f, 0.00908751f, -0.00307967f, 0.02177742f, 
    0.00873598f, 0.00692575f, -0.01278342f, -0.00092213f, -0.01617691f, 0.02624409f, 0.02633747f, -0.01849618f, 
    -0.03456994f, 0.01124444f, -0.01790815f, -0.03852079f, -0.02513452f, 0.03682392f, -0.00862244f, 0.00631463f, 
    -0.02902781f, 0.00108574f, 0.01662043f, 0.02347971f, 0.02405892f, -0.02600360f, -0.00794030f, -0.02547269f, 
    -0.01518170f, 0.01069955f, 0.03036123f, 0.00184991f, -0.02944148f, -0.02631231f, 0.00655062f, 0.02077973f, 
    -0.01263149f, -0.00184251f, -0.00364950f, 0.01700198f, 0.01563443f, -0.01965387f, 0.02344064f, -0.02542109f, 
    -0.01397556f, -0.01527498f, 0.01477069f, -0.02761094f, -0.02197845f, -0.02354410f, -0.00628750f, 0.02781486f, 
    -0.01389028f, 0.01336849f, -0.03576898f, 0.01774849f, -0.02400022f, -0.02406236f, 0.01177515f, 0.02966527f, 
    -0.02400984f, -0.03868948f, -0.02542474f, 0.00456175f, -0.02468325f, -0.03611997f, 0.01758962f, 0.02536114f, 
    0.00785984f, 0.01083976f, -0.01456856f, 0.00814709f, -0.01056197f, 0.01044351f, -0.01473970f, 0.02640821f, 
    -0.02178958f, 0.00130534f, -0.03736839f, -0.02170594f, 0.00995518f, 0.00927597f, 0.02623027f, 0.01922027f, 
    -0.03171444f, -0.02332293f, 0.00137188f, 0.01358747f, -0.01323987f, 0.02950423f, -0.01297737f, -0.00948497f, 
    -0.02849836f, 0.02767642f, -0.00971788f, 0.00992163f, 0.02820763f, 0.01561649f, -0.00015795f, -0.03935628f, 
    -0.00246807f, -0.00106393f, -0.03233801f, -0.00181061f, 0.01197420f, 0.01410854f, -0.03974581f, 0.01583798f, 
    0.00131134f, 0.01529694f, -0.01836329f, -0.03196294f, 0.01589904f, 0.02611026f, -0.01921190f, -0.00399724f, 
    0.01795183f, 0.00769226f, 0.00998719f, -0.00656117f, -0.00418936f, -0.02640893f, 0.01282395f, 0.02245499f, 
    0.00563738f, -0.03105005f, 0.02247190f, 0.02695978f, -0.02963236f, -0.03493090f, -0.04113638f, -0.01629649f, 
    -0.02156477f, 0.02734881f, 0.00529806f, -0.03221532f, -0.01696543f, 0.01555859f, -0.01200344f, 0.01870855f, 
    0.02569525f, -0.02980218f, 0.00681850f, -0.02528003f, 0.00519522f, 0.01068636f, -0.01869256f, -0.00567633f, 
    -0.03538850f, -0.04004063f, -0.01164329f, -0.03987954f, 0.01265850f, -0.01433476f, -0.02301730f, 0.01393523f, 
    -0.02139925f, 0.02707101f, -0.01456752f, -0.02294581f, 0.02339848f, -0.01574241f, 0.02902215f, -0.02506281f, 
    0.02322636f, -0.04141667f, 0.01185158f, -0.00413213f, 0.02248265f, 0.02914223f, -0.02584881f, -0.02660518f, 
    -0.02324861f, 0.00410721f, -0.03896507f, 0.03007486f, -0.02091498f, 0.01582812f, -0.02809544f, -0.03887601f, 
    0.00708168f, 0.00063745f, -0.04090718f, -0.04065931f, -0.00091684f, -0.00517323f, 0.01680639f, 0.00123694f, 
    -0.00295487f, -0.00294499f, 0.00078335f, 0.01504181f, 0.00237779f, 0.02763475f, -0.02331384f, -0.03115102f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01465950f, 0.17686893f, -0.02252441f, -0.00785044f, 0.01535346f, 0.11290031f, 0.12249729f, 0.04250261f, 
    0.02582152f, 0.11720104f, -0.01890549f, -0.02879949f, 0.02369658f, 0.02155725f, -0.03655143f, -0.02804101f, 
    -0.02482320f, 0.00552711f, 0.07601515f, -0.03433191f, 0.04119859f, -0.16565509f, 0.00218713f, -0.04994994f, 
    0.10098886f, 0.02447268f, -0.03047839f, -0.01868855f, -0.02842406f, -0.02341954f, -0.02981047f, -0.02570548f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05354216f, -0.01459411f, 0.08920843f, 0.16872768f, 0.08189141f, -0.00955672f, -0.51699579f, -0.09324788f, 
    -0.11555389f, -0.01426921f, -0.05899192f, 0.18499979f, 0.17813161f, 0.07351393f, -0.02794041f, -0.00528593f, 
    0.00874954f, 0.07248016f, 0.32040444f, -0.05003886f, -0.83641416f, 0.25388062f, 0.01810137f, 0.25721306f, 
    -0.32043302f, -0.11292052f, -0.62211066f, -0.14013723f, -0.05189955f, -0.01483069f, -0.11870541f, -0.02890693f, 
    0.10067186f, 0.37266088f, -0.17782570f, 0.16328675f, -0.11725403f, -0.08512697f, -0.30650905f, 0.19762196f, 
    -0.02599084f, 0.25610682f, -0.10188758f, -0.03721910f, 0.13218290f, 0.14532565f, -0.04197666f, -0.52128959f, 
    0.04613537f, 0.03610808f, 0.13748647f, -0.04134785f, -0.12111887f, -0.67655051f, -0.10656511f, 0.22763091f, 
    -0.41616383f, 0.00403282f, -0.03870869f, -0.09799195f, -0.04231146f, -0.02260145f, 0.01411695f, -0.02931386f, 
    0.12451958f, -0.13326997f, -0.04259580f, 0.15920055f, 0.04760279f, 0.20132856f, 0.32044601f, -0.36484826f, 
    0.00631782f, -0.28877234f, 0.04339192f, 0.17549925f, -0.09180038f, -0.12657522f, 0.00792411f, 0.50994802f, 
    0.16006523f, -0.18015127f, 0.07610345f, -0.08035868f, 0.27921459f, -0.70689791f, -0.12191431f, -0.05489970f, 
    -0.11363516f, 0.14444207f, -0.21601634f, -0.08693140f, 0.01710662f, -0.08185672f, 0.12017390f, -0.08128174f, 
    -0.09104400f, 0.08425418f, 0.05299374f, -0.17099676f, 0.14600009f, 0.04665691f, -0.20581837f, -0.09847009f, 
    -0.09010399f, -0.62050027f, 0.03541745f, 0.36661229f, -0.17012128f, 0.08024859f, -0.17852670f, 0.25208950f, 
    0.16743058f, 0.03026273f, -0.15026318f, 0.12472046f, 0.30549249f, 0.24064183f, -0.15228270f, -0.14744008f, 
    -0.45982948f, 0.11100264f, -0.27178374f, 0.06476223f, -0.09022566f, 0.09711802f, -0.15517029f, 0.03242207f, 
    0.05895582f, -0.33905572f, -0.11328677f, -0.15192135f, 0.08217851f, 0.10338235f, 0.30588016f, 0.23650180f, 
    0.09008545f, 0.13373615f, -0.07125153f, -0.20081821f, 0.10676919f, 0.17476802f, 0.16808848f, -0.04963914f, 
    0.14838575f, 0.02996371f, 0.14043395f, 0.01184786f, -0.02636647f, 0.26587275f, -0.11085727f, 0.00977498f, 
    -0.14116131f, 0.02439884f, -0.26987177f, -0.05722804f, -0.00395372f, -0.01998789f, -0.04606930f, -0.00192131f, 
    0.11978110f, -0.03205706f, -0.00443517f, 0.06215420f, -0.12178658f, 0.27080202f, -0.06489611f, 0.31250453f, 
    0.05093422f, -0.04852521f, 0.03522237f, -0.24604782f, 0.12846547f, 0.03392895f, -0.01396380f, -0.65276861f, 
    -0.10272265f, -0.14886190f, -0.06144404f, 0.13612746f, -0.54742587f, -0.08192930f, -0.05651199f, 0.08889368f, 
    0.50568116f, -0.03275800f, -0.53228480f, 0.09980483f, 0.01616403f, -0.14574361f, -0.02531720f, 0.17010921f, 
    -0.04771365f, 0.05526477f, -0.03010654f, -0.06019140f, 0.02877729f, -0.26535439f, 0.49443388f, -0.72371054f, 
    0.08079476f, 0.29824358f, 0.03777262f, -0.36719146f, -0.04240001f, 0.02473071f, -0.17116807f, 0.15795559f, 
    0.05986394f, 0.00907370f, -0.37124938f, -0.05771306f, -0.31046057f, -0.31303713f, -0.09447428f, -0.50448948f, 
    0.06279907f, 0.07236986f, 0.37569863f, -0.03510853f, 0.02740431f, 0.03117096f, 0.15593050f, -0.03785050f, 
    -0.07622292f, -0.20175660f, 0.10535303f, -0.06368904f, 0.00975420f, -0.07101015f, -0.48602930f, 0.45638916f, 
    -0.07341263f, 0.16390345f, 0.14436002f, 0.37498343f, -0.02529841f, 0.08115770f, 0.00633076f, 0.23960213f, 
    -0.07020912f, 0.05642902f, -0.62269318f, 0.08954359f, 0.23975004f, -0.16216283f, -0.06306283f, -0.28492138f, 
    0.03626412f, -0.07429411f, 0.01484414f, -0.09240043f, 0.05799370f, -0.13832763f, -0.00249345f, 0.04608055f, 
    0.07696703f, 0.34525982f, -0.06333096f, 0.04744222f, -0.04132283f, 0.16006228f, -0.75184667f, -0.66809380f, 
    -0.03558572f, -0.34268451f, -0.08571469f, 0.12676850f, -0.15027021f, 0.10477038f, -0.00439634f, -0.09703608f, 
    0.00168635f, 0.13034597f, -0.69818640f, -0.13937782f, 0.17696041f, -0.46223372f, -0.01834286f, -0.28975537f, 
    0.25232384f, -0.04392230f, -0.40591007f, -0.05355485f, -0.15655383f, 0.11918891f, -0.07179365f, -0.01828275f, 
    -0.07675078f, -0.36244848f, -0.02740760f, 0.08751746f, 0.09075203f, -0.35705155f, 0.06275497f, 0.28758416f, 
    -0.12043373f, 0.20070961f, -0.04694139f, -0.53906864f, 0.14726098f, 0.00561382f, 0.10699971f, 0.32606125f, 
    -0.09067693f, 0.02818111f, 0.43405661f, -0.08450719f, -0.14619865f, -0.19837809f, -0.16667329f, -0.41842759f, 
    0.28341624f, 0.01763426f, -0.02764219f, 0.09663416f, -0.06522128f, 0.15109579f, 0.15286672f, 0.16073325f, 
    -0.06584357f, 0.23988865f, 0.10311680f, 0.01930000f, 0.13378115f, 0.17792560f, 0.15160164f, -0.56108570f, 
    0.11136524f, -0.58536863f, -0.05880245f, 0.15636559f, 0.11727194f, -0.02891925f, 0.13561070f, -0.89777440f, 
    0.00065864f, -0.01481044f, 0.34775907f, -0.04469346f, 0.13725163f, -0.30088937f, 0.00908750f, -0.49962419f, 
    -0.40331757f, 0.11908138f, -0.00011941f, 0.10301755f, 0.04007660f, 0.01332367f, -0.01890442f, 0.13358918f, 
    -0.13192889f, 0.15949170f, 0.00598282f, -0.10385850f, 0.13742246f, -0.08996183f, -0.46478319f, -0.45481008f, 
    0.10804312f, 0.01020321f, 0.02629877f, -0.78723472f, -0.14060327f, -0.15062724f, -0.18302998f, -0.47918966f, 
    -0.01941474f, 0.07971881f, -0.00446129f, 0.14495666f, 0.15081383f, 0.32099181f, -0.09862740f, -0.23071902f, 
    0.25653908f, 0.12235153f, 0.42011058f, -0.02039780f, 0.09977981f, -0.03842190f, 0.11826196f, -0.09897600f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11841916f, 0.03007993f, 0.72613573f, -0.25289175f, -0.21669769f, 0.04306185f, 0.09915126f, -0.22569512f, 
    0.17870210f, -0.29501319f, -0.26489702f, -0.25911501f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
