#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.92160469f, -0.38866356f, -0.80151069f, -0.25748456f, 1.44875932f, -1.10480607f, -0.19396420f, -0.32858634f, 
    -0.13064405f, 0.88878995f, 1.19374406f, -0.91144848f, 0.89555353f, -0.78708780f, -0.34831184f, -0.25325233f, 
    -0.20829554f, 0.05239114f, -1.28964162f, -0.26359192f, -0.96605325f, -0.30441940f, 1.22856891f, 1.23022473f, 
    -0.37302497f, 0.13235237f, -0.33458215f, 0.27297834f, -0.23538864f, -0.18523316f, 0.91021258f, 0.66750240f, 
    1.00714791f, 0.03897521f, -0.01329642f, 0.90820336f, 0.11300498f, 0.18592308f, 0.78734493f, 1.03887284f, 
    1.25035143f, -0.27794850f, -0.36127961f, -0.45168906f, 0.23180704f, -1.08514369f, -1.16544402f, -0.71026415f, 
    0.61303127f, 0.94682658f, 1.06836069f, 0.39910018f, -0.70916426f, 0.09542205f, 0.93399692f, 1.11458206f, 
    1.19425070f, -0.25775489f, -0.62870377f, 0.03193634f, -0.20872112f, -0.02824442f, 0.58956903f, -0.31930369f, 
    -1.49284279f, -0.98761606f, -0.48745304f, -0.65630656f, 0.42555293f, -0.37932763f, 0.29870108f, 0.46310830f, 
    -1.10777593f, -1.17166460f, -0.91502780f, -0.38413879f, -0.15925793f, -0.38766155f, 0.13882259f, 0.36641330f, 
    -0.54528290f, -1.40094101f, 0.59430653f, 0.55504930f, -0.39178118f, -0.10148899f, -0.65663099f, -0.48523140f, 
    -0.24400054f, -0.99258631f, -0.06882815f, 0.15775846f, -0.11216288f, -1.20136619f, -0.94435161f, -1.24459302f, 
    -0.61784756f, 0.65525591f, 0.04884325f, -0.75504094f, 0.86854136f, 0.10909405f, 0.95502108f, -0.31931245f, 
    0.60150784f, 0.72655386f, 0.36230338f, 0.62649709f, 0.87909293f, 0.51876521f, 1.08118391f, -0.51918203f, 
    -0.02049753f, -0.53372562f, 0.41406313f, 1.03785110f, 0.08949748f, 0.92955232f, 1.05239463f, 0.96545625f, 
    0.47287697f, 0.32651612f, 1.17121983f, -0.40542918f, -0.15297705f, -0.28014582f, 0.98616934f, 1.28156829f, 
    0.73431653f, -0.92623436f, -0.13582364f, -0.47595477f, 0.21285038f, -0.41845164f, -0.30429205f, 1.16562605f, 
    -0.09023901f, 1.37072325f, 1.16171420f, -0.39555797f, 0.04890769f, 0.44516876f, -0.03950763f, -0.17785543f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06843643f, -0.09594224f, 0.25986260f, 0.46301857f, 0.43933916f, 0.28910273f, -0.09949452f, -0.34588858f, 
    -0.00808198f, 0.33142415f, 0.66267854f, -0.37144893f, 0.19784063f, 0.57963896f, -0.06485581f, 0.17910394f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02497657f, 0.15377714f, 0.09028465f, -0.05866912f, -0.07501459f, 0.21925862f, -0.05731778f, 0.06519025f, 
    0.32772845f, 0.18267150f, 0.21027297f, 0.07170551f, 0.24664403f, -0.03541464f, 0.03900357f, 0.13650261f, 
    0.09814784f, -0.16049324f, -0.14444730f, 0.46045724f, 0.01387129f, 0.25034237f, 0.00447923f, 0.09274888f, 
    -0.12552537f, -0.02641504f, -0.02353226f, -0.20274937f, -0.07572475f, -0.36064500f, -0.09426597f, 0.05949649f, 
    -0.19136429f, 0.11413416f, -0.12244215f, -0.22273880f, -0.22283781f, -0.23555894f, 0.26204461f, 0.25555217f, 
    -0.06413728f, 0.13862844f, -0.03347111f, 0.25232697f, -0.10372225f, -0.29094818f, -0.07143050f, 0.16931884f, 
    -0.00595483f, 0.07821000f, 0.03568831f, -0.06076846f, -0.12942836f, 0.00839151f, 0.55096883f, 0.12086220f, 
    0.09200415f, -0.01092947f, -0.00771426f, 0.06171600f, 0.15398489f, 0.08160024f, -0.02165041f, 0.03740458f, 
    0.04273576f, -0.46473470f, -0.08651908f, -0.11094149f, -0.13642032f, 0.47585666f, 0.23438409f, -0.05919967f, 
    -0.23834407f, -0.07593762f, -0.17756064f, -0.35978943f, 0.01052356f, -0.01701477f, -0.19410591f, 0.25777525f, 
    0.04402218f, 0.02259674f, 0.24198928f, -0.10117131f, -0.19781482f, -0.09113570f, -0.01497900f, -0.12830353f, 
    -0.04943856f, 0.00960317f, -0.29060027f, 0.02161506f, -0.15845509f, 0.04617774f, 0.00855659f, -0.16976663f, 
    0.11401302f, 0.03834478f, 0.05907266f, -0.06183757f, -0.08749259f, -0.22493808f, -0.08369256f, 0.03953550f, 
    0.45600304f, 0.10196861f, -0.12084916f, -0.03155014f, 0.52318376f, -0.07263584f, 0.05674487f, 0.02291531f, 
    0.16896999f, 0.02625492f, -0.05307258f, -0.05336414f, -0.00477468f, -0.38178447f, -0.20646779f, -0.35645083f, 
    0.04690181f, 0.34911638f, 0.10366344f, -0.02637117f, 0.00625999f, -0.15019687f, 0.66752768f, 0.39255035f, 
    -0.08124755f, -0.05876806f, -0.12874991f, 0.03366660f, 0.01011618f, 0.27193210f, -0.02333095f, 0.05179661f, 
    -0.48948660f, -0.14824936f, 0.08580469f, 0.25827086f, 0.05276858f, -0.07981148f, 0.15893286f, -0.31844899f, 
    -0.24076447f, 0.13717639f, 0.14027159f, -0.17960671f, -0.29615659f, -0.05028923f, -0.23755722f, -0.07288200f, 
    0.02055473f, -0.03237015f, 0.17995153f, -0.14461710f, -0.04248279f, -0.20566449f, -0.04475552f, -0.18620141f, 
    0.12602901f, 0.14332667f, 0.36740005f, -0.10149533f, 0.34737536f, -0.00829451f, 0.03930977f, 0.17699149f, 
    -0.04754506f, 0.17346875f, 0.04119109f, -0.07497509f, -0.26159933f, -0.33759031f, 0.05727422f, 0.12354467f, 
    -0.11002885f, 0.01291281f, 0.10356969f, -0.04252045f, -0.06205587f, 0.07145190f, -0.14091183f, 0.06470330f, 
    -0.33588085f, -0.22109944f, 0.15111925f, 0.07978260f, -0.11321820f, -0.05437188f, 0.09199215f, 0.39053270f, 
    0.18168800f, 0.04691949f, 0.09984991f, 0.20495726f, -0.05272026f, 0.18206830f, -0.18576387f, 0.11027908f, 
    0.11811393f, 0.00436319f, 0.20763406f, 0.10075805f, -0.03998485f, 0.05412804f, 0.02261812f, 0.23449600f, 
    0.12287733f, 0.59966004f, -0.32308552f, 0.21530405f, 0.00772392f, -0.08810025f, 0.10563777f, -0.08616333f, 
    -0.10155760f, -0.08380425f, 0.49708417f, 0.18757424f, 0.02859131f, 0.10565700f, 0.21325858f, 0.05522274f, 
    0.11582288f, 0.58021504f, -0.03024248f, -0.10954176f, 0.15062968f, -0.07707412f, -0.05462767f, 0.18219177f, 
    0.14988159f, 0.13642734f, -0.02755550f, -0.15631369f, -0.57376099f, -0.09324943f, -0.11381277f, -0.45728293f, 
    -0.01251875f, -0.04319077f, 0.00679796f, 0.30712348f, 0.34058595f, 0.16370207f, 0.24436240f, -0.02443874f, 
    0.08338151f, -0.08091892f, -0.14856140f, 0.02824439f, 0.00137532f, -0.05253728f, 0.02631762f, -0.03769660f, 
    0.10660261f, -0.08997753f, -0.19186212f, -0.24950306f, -0.10876113f, 0.34188232f, -0.43546709f, 0.17528348f, 
    -0.12748410f, -0.12817787f, -0.01585488f, 0.19942746f, 0.16562751f, -0.28328523f, -0.53909004f, -0.46627977f, 
    0.24210817f, 0.25706744f, 0.12941390f, -0.05374961f, -0.11099821f, -0.18872668f, -0.09122038f, 0.23744307f, 
    0.03868789f, 0.06057904f, -0.18449984f, -0.10691211f, -0.02197989f, -0.13643609f, 0.00152849f, -0.31406343f, 
    0.53234285f, -0.00266531f, -0.37895748f, -0.12874690f, 0.00536079f, 0.17651582f, -0.08768928f, -0.15102567f, 
    -0.45516920f, -0.00453544f, -0.88155603f, -0.02566043f, -0.06544728f, -0.02181756f, -0.07928608f, 0.02738634f, 
    0.04322688f, 0.03806667f, -0.02243142f, 0.56036419f, -0.44069564f, 0.19105202f, -0.04543604f, -0.14906821f, 
    0.16456209f, 0.09343811f, 0.00505232f, -0.34934264f, 0.00373812f, -0.19340836f, -0.09451081f, -0.09438068f, 
    -0.05890343f, 0.01709468f, -0.10325371f, 0.10799430f, -0.04567701f, 0.09349581f, 0.51388681f, -0.24859270f, 
    0.13639860f, -0.21641397f, -0.01287508f, 0.04143729f, 0.28110531f, 0.00581587f, 0.65684342f, -0.22790632f, 
    0.04863859f, 0.14633085f, -0.12179401f, -0.04842867f, -0.11121219f, -0.21931930f, 0.43255442f, 0.48875681f, 
    -0.04726332f, 0.11831474f, -0.31339496f, 0.05906666f, -0.07574686f, -0.09575975f, 0.15403631f, -0.25885096f, 
    -0.01820873f, -0.10315165f, 0.03427634f, -0.13028416f, -0.05321658f, 0.15119140f, 0.13273948f, 0.20886447f, 
    -0.10423300f, 0.01042274f, -0.21642190f, -0.14326565f, 0.06751271f, 0.32653195f, 0.11383542f, 0.12151904f, 
    -0.06215029f, -0.44789335f, -0.10414733f, -0.06778010f, 0.02240134f, 0.03795035f, 0.01858635f, 0.24931069f, 
    0.16465442f, -0.04474209f, -0.23293918f, -0.38239127f, 0.09031861f, 0.03252328f, -0.02186138f, 0.12583637f, 
    0.06268660f, 0.03680534f, 0.13296108f, -0.34445050f, -0.45276874f, -0.34176892f, 0.07147500f, 0.20720947f, 
    -0.12021358f, 0.05528044f, 0.08942173f, -0.05578117f, 0.36210594f, -0.17943166f, -0.11657527f, -0.11498655f, 
    -0.01664399f, 0.03847700f, 0.18613829f, 0.08823359f, 0.15302545f, 0.17681833f, 0.22784492f, -0.05559845f, 
    0.12156753f, 0.02760252f, 0.06358249f, -0.01230204f, 0.09455112f, -0.02888810f, 0.57257158f, 0.27085796f, 
    -0.34939203f, 0.03148454f, -0.04654619f, 0.04534286f, -0.00241895f, -0.06408912f, 0.06916141f, -0.11653054f, 
    -0.42914104f, 0.50438845f, 0.09749938f, 0.15717250f, 0.04625387f, -0.13278346f, 0.14890721f, -0.01105336f, 
    -0.10910848f, -0.45073557f, -0.45918873f, 0.06296992f, 0.22083206f, 0.21643589f, 0.01814325f, -0.09427217f, 
    -0.29966480f, -0.40211141f, -0.25685456f, 0.36086342f, -0.15490927f, 0.19951884f, 0.04492348f, 0.01568349f, 
    0.00349770f, -0.00653001f, 0.38394281f, -0.67808259f, -0.47440824f, 0.32333711f, 0.13566308f, 0.00252645f, 
    0.02064972f, -0.14485955f, -0.24730250f, -0.09182655f, 0.06428112f, 0.74181771f, 0.18322907f, -0.00016175f, 
    -0.00452319f, 0.29231244f, -0.13879265f, -0.13222933f, -0.09572221f, -0.12931262f, 0.27663064f, 0.08433536f, 
    -0.04119589f, 0.17751290f, 0.23506023f, 0.08563288f, -0.11946879f, 0.34018084f, -0.30577821f, -0.46949494f, 
    0.29343233f, -0.02707200f, 0.20401026f, 0.13728295f, -0.21678014f, -0.00902738f, 0.26388273f, 0.21645030f, 
    0.30793118f, -0.24608111f, -0.10605826f, -0.09043439f, -0.08632284f, 0.19204330f, 0.00124286f, -0.38513252f, 
    -0.04044717f, -0.28792369f, -0.14695844f, 0.42394540f, -0.28155038f, -0.03852994f, 0.32470056f, -0.10924041f, 
    -0.29853263f, 0.13517785f, 0.00723069f, 0.00530556f, 0.28523570f, 0.05093341f, 0.02961422f, 0.02796596f, 
    -0.29609695f, -0.12787901f, -0.26501608f, 0.07811318f, 0.04420212f, 0.15219772f, -0.30314866f, 0.02922192f, 
    0.10322542f, -0.07627480f, -0.04417622f, 0.13710487f, -0.08739912f, -0.16025788f, 0.35813925f, 0.34036410f, 
    -0.14422844f, 0.36773315f, 0.39276114f, -0.32303122f, -0.42736626f, -0.10171538f, -0.19930194f, 0.23563948f, 
    -0.08442564f, 0.03974976f, -0.17103638f, -0.11729795f, 0.38740316f, 0.21700300f, 0.11185617f, -0.17690405f, 
    0.00612959f, 0.06735574f, 0.03510109f, 0.03791487f, -0.03189198f, 0.15968467f, 0.24192269f, 0.11441178f, 
    0.32758892f, -0.06880485f, 0.34427869f, 0.14913300f, 0.21048731f, -0.17794342f, -0.14697000f, 0.31767952f, 
    0.10580634f, -0.06111999f, -0.04430569f, -0.04110273f, -0.03606435f, 0.22322212f, -0.14355876f, 0.30176437f, 
    0.08262980f, 0.20096211f, -0.16602425f, -0.00753710f, -0.00737536f, 0.15143709f, -0.15699932f, 0.01527254f, 
    -0.11277961f, -0.56982791f, -0.55022115f, 0.09425925f, 0.13222654f, 0.33162442f, 0.18341048f, -0.08079210f, 
    -0.10946574f, -0.21860054f, -0.78143287f, 0.00376496f, -0.08601650f, 0.26935881f, 0.02549308f, -0.27155027f, 
    0.13759547f, 0.03604691f, 0.74764103f, 0.19841923f, -0.18332575f, -0.05897212f, 0.11106096f, 0.04315067f, 
    0.16761535f, 0.10773257f, -0.05078369f, 0.08452556f, 0.42945847f, 0.28281626f, -0.13992982f, -0.17510906f, 
    0.14668950f, 0.19992141f, -0.08269171f, 0.16810994f, 0.24019057f, -0.31596214f, 0.40950587f, -0.04404258f, 
    0.08120698f, -0.05656865f, 0.13663512f, 0.31547275f, 0.21081592f, 0.61640698f, 0.47732455f, 0.23069574f, 
    -0.25482476f, -0.18087012f, -0.17065933f, 0.07692381f, 0.06461245f, 0.27292174f, -0.40148529f, 0.14846699f, 
    -0.23329295f, 0.11159220f, 0.03389856f, -0.00700046f, -0.11013032f, -0.07703253f, 0.27884647f, -0.05387084f, 
    -0.08491333f, 0.21708086f, -0.12251629f, 0.04073622f, -0.09469313f, -0.01055809f, 0.18447299f, 0.20383076f, 
    0.05656174f, -0.35978898f, 0.54615366f, -0.07725140f, 0.28914049f, 0.08460947f, 0.04300715f, 0.00343619f, 
    -0.03841158f, 0.25409067f, -0.13766685f, -1.34152472f, -0.12076098f, 0.16819091f, 0.14670217f, -0.10028512f, 
    0.17010020f, -0.08230572f, -0.47441161f, 0.10596072f, -0.53882474f, 0.04536166f, 0.16904552f, 0.27722153f, 
    -0.21672899f, 0.21755970f, -0.00977228f, 0.49564555f, 0.67418456f, -0.30225956f, 0.04569886f, -0.02026661f, 
    0.02218900f, -0.28903201f, -0.06848585f, 0.07247239f, -0.06647595f, 0.29331601f, -0.01337050f, 0.15662137f, 
    0.16094808f, 0.03985320f, -0.09390781f, 0.04376350f, -0.12796549f, -0.11285925f, 0.02410712f, -0.17833093f, 
    0.21608040f, -0.19639252f, 0.02761407f, 0.02862567f, -0.04012949f, 0.35647202f, 0.08589659f, 0.02755208f, 
    -0.04828157f, -0.01681864f, -0.02783569f, 0.35320857f, -0.22340120f, -0.15069225f, -0.11995026f, -0.58407158f, 
    -0.01652548f, 0.44926280f, -0.11377832f, 0.08295795f, -0.18130815f, 0.01550205f, 0.01379323f, 0.23722504f, 
    -0.21597135f, -0.00937801f, 0.00679558f, -0.08774951f, 0.01744640f, -0.01819432f, -0.05156186f, -0.05395735f, 
    0.05997500f, 0.52307379f, -0.17897671f, 0.10115743f, 0.21953440f, 0.16012430f, 0.11785042f, -0.00304576f, 
    0.00602270f, 0.11702293f, -0.35263428f, -0.21078329f, 0.06365344f, -0.12651569f, 0.00474924f, 0.02796163f, 
    -0.12563238f, -0.05629722f, -0.13138156f, -0.53768498f, -0.10066657f, 0.16578650f, -0.03981860f, -0.06391504f, 
    -0.09900871f, -0.10617264f, -0.18277845f, 0.11356521f, -0.42183819f, -0.14290139f, -0.16364409f, 0.06846995f, 
    0.09603941f, -0.04859773f, 0.00643603f, 0.01004796f, -0.04096950f, -0.62025964f, -0.03266269f, -0.24166182f, 
    -0.20933613f, -0.13376305f, 0.13800396f, -0.06247293f, 0.13872303f, -0.03464853f, 0.69579339f, -0.01987525f, 
    0.02252953f, 0.02085335f, -0.06388459f, 0.01926426f, 0.17500789f, 0.10633720f, 0.09583090f, -0.05547455f, 
    0.42399436f, -0.30597940f, -0.10610837f, -0.08549447f, 0.21044058f, -0.05098569f, 0.14624397f, -0.05419705f, 
    0.36828521f, 0.11796948f, -0.39604264f, -0.27921057f, -0.17614557f, -0.01754182f, 0.09672790f, -0.03265973f, 
    -0.21627066f, -0.22210926f, -0.14202425f, -0.04720758f, 0.08886174f, 0.18756118f, -0.19703619f, -0.20474251f, 
    -0.03311205f, 0.04653160f, -0.09632844f, 0.02417823f, -0.26535311f, 0.43870637f, 0.09081461f, 0.03793102f, 
    0.07682201f, -0.11239806f, -0.06329716f, -0.44944593f, 0.22718412f, -0.06337283f, 0.12192480f, 0.23091382f, 
    0.09322119f, -0.02200098f, 0.07574192f, -0.03517128f, 0.37806666f, 0.01513633f, 0.07132637f, -0.06116959f, 
    -0.24221982f, -0.06016957f, 0.16661271f, -0.00637286f, -0.12572369f, 0.24019915f, -0.13812868f, 0.22280429f, 
    0.15833871f, -0.14758669f, 0.07584777f, -0.14555021f, 0.13046476f, -0.11183468f, 0.84672147f, 0.37894848f, 
    -0.04408598f, 0.10737863f, 0.12769631f, -0.04615740f, 0.17468238f, -0.08886646f, 0.04188202f, 0.07632198f, 
    0.08806237f, 0.19760068f, -0.09036454f, 0.02251939f, 0.19164491f, 0.02217740f, 0.19144554f, -0.17435664f, 
    0.41883546f, 0.21181582f, -0.12979962f, 0.22864047f, -0.04187275f, -0.05479088f, -0.03686069f, 0.08618701f, 
    0.05693255f, -0.27604753f, -0.26036614f, 0.08979409f, -0.03642356f, -0.18288322f, -0.07620392f, -0.00458831f, 
    0.17959674f, -0.12548475f, -0.06784400f, -0.01516064f, -0.16211228f, -0.07179781f, 0.01115657f, 0.08892700f, 
    -0.05504667f, -0.06313831f, 0.06145209f, 0.16987558f, -0.09821377f, -0.27736288f, 0.23349579f, 0.23802486f, 
    -0.02947029f, -0.00686597f, 0.03365952f, -0.32833365f, 0.05786790f, -0.00588751f, 0.22182779f, -0.07401570f, 
    0.13706516f, 0.25860590f, 0.17728037f, 0.29924846f, -0.02497888f, 0.56055272f, -0.09075253f, -0.32422948f, 
    -0.02987583f, -0.23509125f, -0.07313946f, 0.16220148f, 0.16017018f, 0.19735362f, 0.05877485f, -0.18164656f, 
    -0.07386539f, -0.28026390f, -0.02530486f, -0.17691462f, 0.04160357f, -0.19835414f, -0.15092131f, 0.18047197f, 
    -0.09883792f, 0.24547796f, -0.22869036f, 0.27191946f, -0.10733321f, -0.18060733f, -0.18643163f, 0.04636979f, 
    -0.02844897f, -0.33448255f, 0.16859408f, -0.00916737f, -0.13896763f, 0.23479126f, 0.08061495f, 0.03186642f, 
    0.42788500f, -0.01343249f, -0.03317792f, -0.17087388f, 0.05923007f, -0.00244086f, -0.17107965f, 0.23296961f, 
    0.25917354f, -0.21116406f, -0.23218262f, 0.13676079f, 0.16898012f, -0.07134815f, 0.03083812f, 0.02071765f, 
    0.17905574f, -0.08274192f, 0.18072544f, 0.15921770f, -0.15799493f, -0.05345131f, -0.20730372f, 0.29480252f, 
    -0.20878676f, 0.01401321f, -0.09817217f, -0.30453831f, -0.14166431f, -0.01929032f, -0.13366258f, -0.13589320f, 
    -0.11726953f, 0.02549623f, -0.09011928f, 0.00079400f, 0.26286185f, -0.29187274f, 0.02937470f, 0.48026231f, 
    -0.17764308f, 0.06158381f, 0.00723667f, 0.00266157f, -0.10518457f, -0.14524308f, -0.08479743f, -0.34135038f, 
    0.27857938f, -0.04992807f, 0.29220995f, -0.04386320f, 0.02217137f, -0.16308782f, -0.11650658f, 0.37989050f, 
    0.23297444f, -0.01580637f, -0.23034601f, 0.02243862f, 0.25238702f, 0.20941934f, -0.03807582f, 0.05835826f, 
    0.06221852f, -0.07968849f, -0.01916266f, -0.03270934f, 0.04220089f, 0.04541619f, -0.02024954f, 0.03250723f, 
    -0.01009951f, -0.03048482f, -0.08145786f, -0.06929471f, -0.01879223f, 0.00771493f, -0.01237546f, -0.06344436f, 
    -0.03870161f, 0.01967580f, -0.05776247f, 0.05393219f, -0.06304726f, -0.01934505f, 0.03167257f, -0.06687989f, 
    0.06825362f, 0.06340038f, -0.06149686f, 0.07167464f, -0.06715833f, -0.04660132f, -0.01812770f, 0.00825815f, 
    0.04933895f, 0.01492414f, 0.00808851f, 0.02556017f, 0.04020959f, -0.00847260f, 0.00645789f, -0.07448390f, 
    0.00082971f, -0.04122623f, 0.02815447f, -0.03313795f, -0.01812682f, -0.00503786f, -0.00347228f, -0.05376360f, 
    0.06567398f, -0.01260034f, -0.03893400f, -0.07209740f, -0.00445399f, -0.01240076f, 0.04178553f, -0.03392857f, 
    0.00426075f, -0.09516346f, -0.06429984f, -0.05642543f, -0.03885295f, 0.01471042f, 0.05827416f, -0.01620634f, 
    -0.07301280f, 0.04196059f, 0.06948872f, 0.02600381f, 0.05926896f, -0.05542808f, -0.02378086f, 0.02026078f, 
    -0.03622560f, 0.08149392f, 0.06417331f, 0.00444718f, 0.00979964f, -0.05575424f, 0.02604342f, -0.05220955f, 
    -0.07186431f, -0.05776074f, -0.08398692f, -0.05743197f, -0.04617340f, 0.00213351f, 0.06294051f, 0.01617103f, 
    0.05575781f, -0.09512928f, -0.01385005f, -0.03338994f, 0.00140207f, 0.03295324f, -0.07263031f, -0.03661066f, 
    -0.07835153f, -0.06677119f, -0.02086102f, -0.03964589f, -0.00078673f, -0.07037311f, -0.03746530f, 0.05340853f, 
    -0.02883641f, -0.05250021f, -0.06114130f, 0.04737022f, 0.03965510f, 0.05240865f, -0.02754905f, -0.01682394f, 
    -0.05800986f, -0.00745467f, -0.02910155f, 0.05056743f, -0.04052404f, 0.05515142f, -0.02444425f, -0.05546939f, 
    0.05492694f, 0.06309818f, -0.00198823f, -0.07169922f, -0.09508868f, 0.03203364f, -0.03223072f, 0.05607726f, 
    -0.02173918f, 0.04741470f, -0.05879653f, -0.03566348f, -0.08672985f, 0.01112600f, 0.05910839f, 0.03837696f, 
    0.03986206f, 0.05136199f, -0.00685740f, -0.03296895f, -0.03504881f, -0.09158950f, -0.00393157f, 0.00836037f, 
    0.02631671f, 0.17541721f, 0.31841755f, 0.22921771f, -0.03905377f, -0.11954672f, -0.18257613f, -0.21773927f, 
    -0.55553502f, 0.38104710f, 0.28186795f, 0.19798870f, 0.07533901f, -0.08564709f, -0.12997404f, -0.08032942f, 
    0.07795168f, -0.10691188f, -0.02516551f, -0.13050628f, -0.12088057f, 0.17189892f, 0.14474455f, -0.22110808f, 
    0.15635607f, 0.11841355f, 0.11815568f, -0.14640701f, -0.08557016f, 0.07487331f, 0.12743284f, 0.12811756f, 
    -0.16917385f, 0.22675264f, -0.18809189f, -0.06532949f, -0.11372210f, -0.09556387f, -0.41380483f, -0.14774530f, 
    -0.05374142f, -0.19955692f, 0.08514060f, -0.00920264f, -0.05195843f, 0.19459404f, 0.13872588f, 0.01145970f, 
    0.10241790f, 0.11719928f, -0.15151651f, 0.20939152f, 0.28519544f, 0.21123195f, -0.10084222f, -0.03789233f, 
    -0.11390778f, -0.09496709f, -0.05321183f, 0.08338652f, -0.12945166f, -0.01676250f, 0.35794035f, 0.43653581f, 
    0.45592582f, 0.13017067f, -0.33177927f, -0.05035282f, 0.08353626f, -0.03110342f, 0.13248673f, -0.19823888f, 
    0.18924277f, 0.27028793f, 0.26288763f, 0.17312573f, 0.27495131f, 0.02476641f, 0.15943371f, 0.21400921f, 
    0.07012182f, -0.17041945f, 0.10478316f, 0.05687724f, 0.18670750f, 0.12047812f, 0.15486862f, -0.38633934f, 
    0.23719049f, -0.16691229f, -0.18681099f, -0.35273457f, -0.07166693f, -0.27275756f, -0.16018543f, 0.30321643f, 
    -0.21850960f, -0.25681344f, -0.31918854f, -0.40768510f, -0.02946121f, 0.02444069f, 0.32120746f, 0.07462736f, 
    -0.00560475f, 0.01854259f, -0.17923562f, 0.13535422f, 0.08114447f, -0.16996963f, 0.17490000f, -0.17616867f, 
    -0.17855442f, 0.17832549f, 0.03757391f, -0.16760446f, 0.10547611f, -0.28828612f, -0.10319740f, -0.09737071f, 
    0.21424888f, 0.09978615f, -0.01511605f, 0.13021746f, 0.17169431f, 0.36670777f, 0.13995887f, -0.14911480f, 
    0.02094965f, 0.15859838f, -0.23539995f, 0.26786861f, -0.16132531f, 0.01989150f, -0.05649963f, 0.12003714f, 
    -0.25147256f, -0.01559859f, 0.06052957f, 0.04462484f, -0.02271943f, 0.12701876f, -0.08470528f, 0.16444726f, 
    -0.40868384f, 0.16901261f, 0.10430119f, 0.02182833f, -0.04075713f, 0.16312110f, 0.08497917f, 0.00252666f, 
    0.00493655f, -0.29994011f, 0.16002332f, 0.19822250f, 0.22159934f, 0.16033494f, -0.19400680f, -0.05376959f, 
    0.04084929f, -0.16842967f, 0.57475287f, -0.26788855f, 0.26045671f, 0.26662469f, 0.15160559f, -0.01809020f, 
    -0.01067756f, 0.11925103f, -0.02441736f, 0.20225781f, 0.01590540f, -0.00570985f, -0.02157127f, 0.35164708f, 
    -0.24275081f, 0.21199368f, 0.05527744f, 0.00128316f, -0.15215479f, 0.10896346f, -0.52300853f, 0.00142807f, 
    -0.07466586f, -0.08313454f, 0.27170080f, 0.07376531f, -0.09010802f, 0.25119919f, -0.00193412f, -0.01036197f, 
    0.17000760f, -0.10488152f, -0.08369344f, 0.29120180f, -0.09967259f, -0.13256469f, -0.69098067f, 0.26889023f, 
    -0.55692172f, 0.21631578f, 0.10326482f, -0.01401729f, -0.10388271f, -0.10216438f, -0.00709960f, 0.00673878f, 
    0.25221896f, 0.13387007f, 0.13564998f, -0.14447910f, -0.34465355f, -0.14907564f, 0.41349047f, 0.00517289f, 
    0.04376253f, -0.00249497f, 0.62543350f, 0.15871035f, -0.02113143f, 0.26277891f, -0.29903311f, -0.07048935f, 
    -0.02346858f, 0.04468200f, 0.11889053f, -0.34454131f, 0.10450879f, -0.31198293f, 0.11532778f, -0.03088771f, 
    -0.00591526f, -0.17021130f, 0.27353248f, 0.04456389f, -0.19907032f, 0.01608635f, -0.08733004f, -0.02479700f, 
    -0.21092620f, 0.13969989f, 0.08393064f, -0.19502462f, -0.02276990f, -0.12860316f, -0.20000067f, 0.03392266f, 
    0.07209343f, 0.11030954f, 0.05194046f, 0.19222291f, -0.22486433f, 0.32921815f, -0.57427233f, 0.17033978f, 
    0.07962191f, -0.06461481f, 0.03688322f, -0.11906140f, 0.21058854f, -0.07922256f, -0.60096389f, 0.12135649f, 
    -0.21984981f, 0.14366873f, -0.05904613f, -0.18273622f, -0.09883335f, -0.13036087f, -0.31739655f, 0.53814292f, 
    0.29037946f, 0.05510226f, -0.01289248f, 0.04115946f, -0.09287358f, -0.04531574f, 0.08659660f, -0.34929335f, 
    0.04549944f, -0.23438670f, 0.00597008f, -0.06393038f, 0.00042482f, -0.22140321f, -0.10976822f, 0.12518296f, 
    -0.29545096f, -0.39006439f, -0.13150072f, -0.00651855f, -0.09170102f, 0.15063223f, 0.21659666f, -0.11339405f, 
    0.00321693f, -0.11776414f, 0.35666567f, -0.64889026f, -0.10944404f, 0.15213871f, -0.12030959f, -0.01910897f, 
    -0.17464598f, 0.20897736f, -0.06919280f, 0.22725789f, 0.18308517f, -0.38043073f, -0.00528783f, -0.10398602f, 
    -0.12421014f, -0.05355157f, 0.11883630f, 0.41419137f, -0.03352328f, 0.28528145f, -0.00214610f, -0.07498391f, 
    0.12839065f, -0.06897128f, -0.00464757f, 0.14852877f, 0.16552475f, -0.10916231f, -0.63950694f, -0.15943442f, 
    -0.16393338f, 0.38097635f, 0.18086310f, -0.00960021f, 0.18184458f, 0.23027287f, -0.15417933f, 0.74796146f, 
    -0.20270365f, 0.05941263f, -0.13346080f, -0.12128384f, -0.04812795f, -0.02795104f, -0.18055899f, 0.05695947f, 
    -0.21815513f, 0.33752328f, 0.05540373f, 0.07782523f, 0.14877312f, -0.28140029f, -0.07099852f, -0.45200762f, 
    0.18628266f, 0.19538528f, -0.13914564f, -0.22124353f, -0.11587007f, -0.00254555f, 0.04724786f, 0.03001025f, 
    -0.45459431f, -0.11463115f, 0.46368384f, 0.30762666f, 0.15606207f, -0.19803256f, -0.08442404f, 0.08970025f, 
    -0.00092074f, -0.50815523f, 0.33342338f, -0.31416097f, 0.06687532f, 0.17439243f, 0.00249061f, 0.15663202f, 
    0.09201749f, 0.28764898f, -0.15900910f, 0.18510410f, -0.56019467f, 0.26893583f, -0.06137394f, -0.07417636f, 
    0.30759725f, 0.01422269f, -0.01919257f, -0.01098900f, 0.31824493f, -0.10630709f, -0.17691314f, -0.32438529f, 
    -0.30161628f, 0.20670037f, 0.10243051f, 0.29815584f, 0.53833777f, 0.03954554f, -0.36628485f, 0.17154025f, 
    0.27136675f, -0.08011144f, -0.02972637f, 0.34382004f, -0.16491322f, -0.28242236f, 0.00086090f, -0.03427161f, 
    0.12404146f, 0.13162597f, -0.13723232f, 0.01615161f, 0.26477340f, 0.12174016f, -0.40920129f, 0.24835807f, 
    -0.71501213f, 0.17351612f, 0.05384048f, 0.04133286f, -0.18000515f, 0.15682465f, 0.03293570f, 0.05340493f, 
    -0.08462108f, -0.08900863f, -0.17319489f, 0.18228737f, -0.03863862f, 0.20020719f, 0.18385744f, -0.19268441f, 
    -0.06209394f, -0.01460395f, 0.04736314f, 0.01199144f, 0.00040243f, -0.08233665f, -0.07608880f, 0.04588173f, 
    -0.07665978f, -0.06112011f, -0.05851033f, -0.02248952f, 0.01018148f, 0.03946360f, -0.01670366f, 0.06509147f, 
    0.04038355f, -0.04836592f, 0.06939352f, -0.03137877f, -0.01087387f, 0.05877190f, -0.01137893f, -0.06460680f, 
    -0.01664422f, 0.04481609f, -0.02585857f, 0.01750125f, -0.01746559f, -0.09472255f, 0.05936734f, 0.05955565f, 
    -0.05014111f, -0.05507491f, -0.05612859f, 0.01306856f, -0.01308064f, -0.07037578f, 0.05437378f, -0.03706410f, 
    -0.01265779f, -0.05032548f, -0.07128603f, 0.02959022f, -0.02247024f, -0.03715403f, -0.06557884f, -0.02219131f, 
    0.03323092f, -0.03766254f, -0.05752228f, -0.08370530f, 0.00554741f, -0.00608423f, -0.03870749f, 0.01967302f, 
    -0.00254028f, 0.05354946f, -0.05364201f, -0.00915475f, 0.02452099f, -0.02802349f, 0.04199108f, -0.03837690f, 
    0.06951505f, -0.08014360f, -0.00127249f, 0.02076556f, 0.00650702f, -0.02063839f, 0.00854819f, -0.04110740f, 
    -0.03628440f, -0.00106905f, 0.06457302f, 0.00169402f, -0.01617938f, 0.01501737f, 0.02324081f, 0.04547608f, 
    0.05860903f, -0.01451753f, -0.02236608f, -0.02393257f, 0.00406284f, -0.02615722f, -0.02561043f, -0.01127486f, 
    0.02484799f, -0.00111138f, 0.04797704f, -0.03592179f, -0.01062649f, -0.08903239f, -0.08359987f, -0.05433450f, 
    0.05932461f, -0.05664622f, -0.03798442f, 0.01189202f, 0.02818793f, -0.08660318f, 0.05844382f, 0.01440243f, 
    0.04451768f, -0.04132960f, 0.06297000f, -0.00618806f, -0.09011659f, 0.00256178f, 0.05434035f, 0.05514355f, 
    -0.04867769f, -0.06244900f, 0.07018672f, 0.02761621f, -0.07128531f, 0.01323435f, 0.01838319f, -0.08526893f, 
    -0.01352312f, 0.06269705f, 0.02946164f, 0.06467022f, -0.07202491f, -0.04255699f, 0.05655496f, 0.05126728f, 
    -0.04545970f, -0.05532850f, -0.05279144f, 0.04002107f, -0.07672999f, -0.06078915f, -0.00167770f, 0.02374375f, 
    0.01409547f, 0.05173809f, -0.01229146f, -0.00543205f, -0.07455123f, -0.05763853f, 0.06212353f, -0.00276621f, 
    -0.11957847f, -0.08489269f, -0.43081176f, -0.09303745f, 0.00035703f, -0.04509375f, 0.13757773f, 0.03634236f, 
    -0.08831698f, -0.21784550f, -0.36642775f, -0.06938830f, 0.00323330f, -0.03751944f, 0.24318276f, -0.23428130f, 
    0.11952030f, 0.00638978f, -0.09414525f, 0.07707322f, 0.31260487f, -0.02154206f, 0.07394527f, -0.07840720f, 
    -0.10652856f, 0.02430887f, 0.18726811f, 0.46430519f, 0.12332306f, -0.07393904f, 0.16538200f, 0.06806697f, 
    -0.11279376f, 0.16276954f, 0.18558808f, -0.05346217f, -0.09138880f, 0.04008767f, -0.06902038f, 0.01129419f, 
    0.13067858f, -0.16129813f, 0.11271968f, 0.07547224f, -0.02374551f, 0.37672415f, 0.41604152f, 0.10115025f, 
    -0.06339760f, -0.04590934f, 0.01858395f, -0.09297290f, 0.12886572f, -0.15264392f, -0.41244578f, -0.37828642f, 
    0.10563687f, 0.02513678f, -0.23808937f, -0.06878827f, -0.05968161f, 0.08815698f, -0.03947959f, -0.39036244f, 
    0.27068996f, -0.40283057f, 0.29255852f, 0.07978687f, 0.29868332f, 0.07662010f, 0.22445652f, -0.13830081f, 
    -0.02540386f, 0.16264586f, -0.06079586f, 0.28484285f, -0.38238448f, -0.05675967f, 0.15941848f, -0.03695548f, 
    -0.05604388f, -0.32113388f, 0.11531667f, -0.11940669f, -0.05963524f, 0.18467501f, -0.12601660f, 0.22983773f, 
    0.03355803f, 0.00140811f, 0.31972426f, -0.31711823f, 0.23735420f, -0.07627253f, 0.19689883f, 0.12709641f, 
    -0.07805964f, -0.09810588f, 0.19829300f, -0.19398870f, -0.00946986f, 0.04294523f, 0.25131649f, 0.00463820f, 
    -0.10613424f, 0.16969213f, -0.04099449f, -0.12787190f, -0.67470556f, -0.57503670f, -0.14636096f, 0.12212743f, 
    -0.02742066f, 0.08890488f, 0.11684211f, -0.14725284f, 0.28091094f, 0.04094061f, 0.17515419f, 0.31954315f, 
    -0.03106507f, 0.01890611f, -0.26056421f, 0.13715363f, -0.05704992f, 0.08452661f, -0.56294686f, 0.04313617f, 
    0.24181996f, 0.06564348f, -0.07883872f, -0.13370430f, 0.06119054f, -0.15655124f, 0.04654755f, -0.30586892f, 
    -0.02534489f, 0.10761596f, 0.04497415f, 0.16130523f, 0.04905344f, -0.11671270f, 0.06538723f, -0.05186202f, 
    -0.40657657f, -0.02144444f, 0.33699051f, -0.16913618f, 0.03439190f, 0.16491871f, -0.05073344f, 0.19614109f, 
    -0.40940204f, 0.77264136f, -0.08723078f, -0.17245777f, 0.04384253f, 0.11141589f, -0.07785445f, 0.05103120f, 
    -0.00091516f, -0.04177571f, 0.30313364f, 0.34529862f, 0.08637329f, -0.25499287f, -0.30236232f, -0.14533646f, 
    0.13278449f, 0.18181331f, 0.08626751f, 0.21762879f, -0.18819521f, 0.01160559f, -0.02377855f, 0.00257657f, 
    0.06388995f, 0.33359796f, 0.32749414f, 0.06686395f, -0.26227525f, -0.41900679f, 0.02165180f, -0.20418973f, 
    -0.00795793f, -0.04684894f, 0.08097082f, 0.21580935f, 0.13142996f, 0.47690746f, 0.27807373f, -0.23110884f, 
    0.00726158f, 0.03931739f, -0.11841781f, -0.22382408f, 0.19035518f, 0.24264878f, -0.68903255f, -0.67370349f, 
    -0.01964901f, 0.03913916f, 0.06103150f, 0.30191085f, 0.12259267f, -0.22004685f, 0.11365440f, -0.00664947f, 
    -0.04811049f, -0.54599136f, -0.01354474f, -0.36470786f, -0.12113731f, -0.12658854f, 0.23764041f, 0.12652327f, 
    -0.59338939f, 0.24778168f, -0.23002367f, -0.20011669f, -0.10601095f, -0.20584522f, -0.09348696f, 0.03729167f, 
    -0.13206142f, 0.43903175f, 0.16905789f, 0.28807345f, 0.09257989f, -0.22842018f, 0.08211432f, -0.18497813f, 
    -0.15468107f, -0.02002650f, 0.23929952f, 0.45249128f, 0.33860347f, 0.46988505f, -0.06590494f, 0.09896985f, 
    0.15697442f, -0.03312640f, 0.05400403f, 0.28996074f, -0.05147885f, -0.20643392f, -0.18650030f, -0.00357294f, 
    -0.16722810f, 0.02392304f, -0.06304122f, -0.04120608f, 0.39091706f, -0.19809398f, 0.33182350f, -0.06070137f, 
    0.04981827f, 0.14432134f, -0.02740699f, -0.02382800f, -0.12911344f, -1.18675637f, -0.15114488f, 0.33762386f, 
    0.02113195f, 0.18584527f, 0.23811176f, 0.04495186f, -0.15423597f, -0.14283200f, 0.11544119f, -0.25548995f, 
    0.10154052f, 0.09962983f, 0.19770974f, 0.04827230f, 0.04891451f, -0.04671353f, -0.05354087f, -1.12114227f, 
    -0.68701130f, -0.29692674f, 0.11168178f, 0.19445163f, 0.13695201f, 0.03770979f, -0.05497803f, 0.30614203f, 
    -0.10291836f, 0.03343496f, 0.18251525f, 0.13881506f, -0.19300082f, -0.18646541f, -0.09303542f, -0.03148703f, 
    0.22350152f, 0.70524198f, 0.31416595f, -0.11350135f, 0.00496313f, -0.14637002f, 0.02345879f, -0.01388465f, 
    0.03642737f, -0.06462029f, -0.19347936f, -0.09128670f, 0.37088689f, 0.14784069f, -0.07484149f, 0.35517380f, 
    -0.03607318f, 0.08301829f, 0.08120023f, -0.11129645f, 0.11200076f, 0.01981413f, 0.10289741f, -0.13343447f, 
    -0.13517836f, -0.00382147f, -0.19565858f, -0.20543349f, -0.13409831f, 0.21324752f, -0.04994031f, 0.19393341f, 
    -0.20082135f, 0.39808363f, -0.00919941f, 0.04297656f, 0.03933338f, -0.05517593f, -0.06105737f, 0.23388696f, 
    0.11247773f, 0.14582650f, -0.03084471f, -0.03030736f, 0.21566477f, 0.22433326f, -0.36315963f, 0.49152294f, 
    -0.37930417f, 0.19639853f, -0.20380333f, -0.10749659f, -0.10538128f, -0.16093653f, 0.10072840f, 0.44131777f, 
    -0.45593661f, 0.21758716f, 0.12768888f, 0.09413520f, 0.13186483f, 0.12680714f, -0.31908491f, -0.23783840f, 
    -0.14016719f, -0.51487488f, 0.39477241f, 0.44158193f, 0.19212241f, -0.35096550f, -0.25957423f, -0.14358884f, 
    0.26388511f, -0.12246925f, -0.06066458f, 0.39498928f, -0.10598136f, -0.21771073f, 0.45835367f, 0.16719832f, 
    -0.19396970f, -0.09414938f, 0.17879312f, 0.01147028f, -0.34200761f, 0.01716118f, 0.16536734f, -0.11752941f, 
    0.13298266f, -0.08190637f, 0.04300125f, -0.21338500f, 0.01702250f, 0.00356144f, 0.23999684f, 0.19616181f, 
    0.13304029f, -0.16687448f, 0.04675109f, -0.28840348f, -0.19527365f, 0.08019017f, -0.27010447f, -0.12213661f, 
    0.02332289f, -0.02324690f, 0.02179542f, -0.07871290f, 0.21985923f, -0.16331458f, 0.06024681f, 0.11185412f, 
    0.13558652f, 0.04295114f, 0.12731737f, -0.17301798f, 0.03186646f, -0.20033439f, -0.12902930f, -0.04446725f, 
    0.15407167f, -0.10051964f, -0.13102263f, -0.22567938f, 0.11383270f, -0.06264329f, -0.07770471f, -0.09562676f, 
    -0.19147949f, -0.32836843f, -0.07617141f, 0.08367278f, 0.29094979f, -0.08275196f, -0.04156360f, -0.15210529f, 
    -0.87167424f, -0.13030690f, -0.01921703f, 0.17923558f, -0.03271515f, 0.00430244f, 0.00790026f, -0.21923879f, 
    -0.20696151f, -0.22356486f, -0.19013248f, 0.24681073f, -0.06050321f, -0.19199352f, 0.07835834f, -0.07834170f, 
    -0.18624017f, 0.04738891f, -0.46075451f, -0.01704485f, -0.13773222f, 0.12507305f, 0.30961317f, 0.32971892f, 
    0.06124734f, -0.20659553f, 0.11823557f, 0.57691747f, 0.17080112f, -0.05030124f, 0.28042668f, -0.15727964f, 
    -0.04980491f, -0.04463675f, 0.10766039f, -0.04531080f, -0.10640177f, 0.03923094f, -0.08427168f, 0.09873600f, 
    0.24843250f, -0.16030365f, 0.09738636f, 0.10761224f, 0.02541731f, -0.23542430f, -0.24869135f, -0.50832355f, 
    0.05709334f, -0.11560099f, 0.03113012f, 0.22427216f, 0.08004881f, 0.06328695f, 0.10285134f, -0.07286872f, 
    0.42748293f, 0.10113769f, 0.04038601f, -0.03709647f, 0.07434729f, -0.08852293f, 0.01096492f, -0.19233036f, 
    -0.32199901f, 0.03785080f, 0.27604777f, -0.03177472f, -0.19085351f, 0.11425778f, -0.02060720f, 0.20031504f, 
    -0.37316823f, 0.33802161f, -0.00611338f, 0.38757452f, -0.03038073f, -0.01085113f, 0.01039790f, -0.00606837f, 
    -0.14590171f, 0.35762602f, -0.04371366f, -0.09775241f, -0.16863687f, 0.08046854f, 0.14878273f, 0.25941306f, 
    0.02182375f, 0.29026130f, 0.46349585f, 0.01123403f, 0.01932687f, -0.15220232f, 0.20095111f, 0.10306027f, 
    0.04462438f, 0.13507618f, 0.24847092f, -0.22795071f, -0.14370316f, -0.21891205f, -0.07531172f, 0.13514896f, 
    -0.01473543f, -0.26848245f, -0.22485195f, -0.01726597f, -0.23676796f, 0.18107033f, 0.31214699f, -0.02605036f, 
    0.03464077f, -0.16576171f, -0.20880644f, 0.09414762f, 0.17252779f, 0.23383948f, 0.31963241f, 0.22773504f, 
    0.32413822f, 0.21786402f, 0.31135315f, 0.14810033f, 0.00623770f, 0.00057452f, -0.32905856f, 0.12609169f, 
    0.42884225f, -0.39464694f, 0.19125080f, -0.17533080f, -0.09281797f, -0.04910980f, -0.02864230f, -0.44863871f, 
    0.20656089f, 0.12786770f, 0.05977862f, 0.17884904f, -0.31722653f, 0.11912680f, -0.10083690f, 0.29687965f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06846173f, -0.35261178f, 0.02106965f, 0.18336253f, 0.22729757f, -0.08438409f, 0.20329943f, -0.01406391f, 
    -0.07541861f, -0.01555744f, 0.25999144f, -0.02501801f, 0.30561817f, -0.03010602f, -0.05335128f, 0.26313704f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24903080f, -0.10775787f, 1.00123727f, -0.01896573f, -0.07355829f, -1.14719236f, 0.34502259f, -0.11181519f, 
    -0.24599361f, 0.18772648f, -0.22594357f, 0.14556940f, 0.06103394f, -0.35525307f, 0.31810594f, -0.15833476f, 
    -0.86404550f, -0.26892585f, 0.48458740f, 0.31433174f, 0.34640086f, -0.20191093f, 0.30227101f, -0.04433282f, 
    0.21289471f, 0.13326702f, -0.27971938f, -0.14818588f, 0.09341505f, -0.58284205f, -0.53435200f, -0.15685475f, 
    -0.04769383f, 0.19176424f, -0.31528324f, -0.07333678f, 0.80112958f, 0.17228745f, -0.18177494f, -0.01501653f, 
    -1.06806672f, 0.10580295f, 0.10163091f, -0.17619260f, -0.88899297f, -0.13717906f, 0.01338815f, -0.41217977f, 
    0.30263323f, 0.15202795f, -0.39560619f, -0.64242935f, -0.12667887f, -0.26915422f, 0.18336231f, 0.15008837f, 
    -0.09548915f, -0.15078799f, -0.12080163f, 0.17499445f, -0.27539703f, 1.18639958f, -0.20792918f, -0.21631362f, 
    0.24204907f, 0.36410561f, -0.76814473f, -0.32435307f, -0.16330697f, -0.45080718f, 0.18358882f, -0.01438365f, 
    -0.28727371f, 0.09272748f, 0.00832756f, 0.13898285f, 0.30339864f, -0.38457534f, 0.09625944f, 0.73162729f, 
    -0.16830106f, -0.47122347f, 0.19746922f, 0.46596524f, -0.24049167f, -0.69373751f, -0.49355060f, 0.07812545f, 
    0.42835066f, -0.21802789f, -0.43126839f, -0.12811014f, 0.01290346f, -0.52780175f, -0.21254836f, 0.51215488f, 
    0.02317822f, -0.01990268f, -0.04118256f, 0.43332741f, -0.52724761f, 0.83357632f, 0.28570130f, -0.16775468f, 
    -0.44813356f, -0.48989931f, -0.44547758f, -0.20190237f, -0.06682032f, -0.13954721f, 0.05963333f, 0.29157653f, 
    -0.32052019f, 1.14839911f, -0.17798172f, -0.46255749f, -0.01380002f, -0.46710062f, -0.66162455f, 0.10124981f, 
    0.35205308f, 0.31363514f, -0.24542837f, 0.21552293f, 0.00803540f, -0.22004752f, 0.46962550f, -0.10271541f, 
    -0.61010396f, 0.50204682f, 0.07372203f, -0.32060397f, 0.04730980f, 0.42639619f, -0.57424694f, -0.06436139f, 
    0.44249713f, -0.68723577f, 0.88401341f, -0.11486799f, 0.75162315f, -0.43028405f, -0.94535393f, -0.16426149f, 
    0.03312148f, -0.30821368f, -0.58825898f, 0.43141595f, -0.27286574f, -0.44353566f, 0.52425671f, 0.10141790f, 
    -0.11678059f, -0.10485938f, 0.37263188f, -0.12882787f, -0.62213218f, -0.55374044f, 0.71299058f, 0.10407051f, 
    -0.33388215f, -1.02161503f, -0.18050045f, -0.60139763f, 0.27589303f, 0.33325222f, -0.23095036f, 0.05187441f, 
    -0.00567354f, 1.02092791f, 0.04711610f, 0.09986714f, 0.80218017f, 0.29291475f, -0.54348934f, -0.22965379f, 
    0.88529706f, -0.67945898f, 0.31566280f, -0.45120499f, -0.21317583f, 0.71523243f, -0.00549129f, 0.15766823f, 
    0.39368281f, -0.97905385f, -0.04879570f, 0.11853790f, 0.02771862f, 0.15376936f, 0.31820521f, -0.43563011f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00427422f, -0.33561635f, 0.35585144f, -0.15067419f, 0.23859899f, 0.29447231f, -0.28554586f, -1.15640104f, 
    0.05135390f, 0.40671277f, 0.57126677f, 0.00757285f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
