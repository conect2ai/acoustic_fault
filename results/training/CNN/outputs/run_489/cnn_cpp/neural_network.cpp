#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65794814f, -0.69628471f, -0.87165910f, -0.87522608f, 0.30197930f, 0.38428971f, 0.72190660f, -0.51733631f, 
    0.40001190f, 0.02905443f, -0.06463796f, -0.07636388f, -0.03061926f, 0.04312584f, -0.28560588f, 0.03118321f, 
    0.01156700f, -0.20729952f, -0.01921145f, -0.10879481f, -0.02721023f, 0.14602217f, 0.12756021f, 0.06506382f, 
    -0.06975918f, 1.01924086f, 0.54469216f, 0.34390217f, 0.14252347f, 0.54531235f, -0.36052778f, 0.46753442f, 
    -0.16097805f, 0.43582940f, 0.47459000f, 0.29863235f, 0.41317371f, 0.13845584f, -0.37394163f, -0.19960614f, 
    -0.41678655f, -0.44858909f, 0.00780132f, -0.20206416f, -0.45886359f, -0.34517980f, 0.05118638f, 0.10418151f, 
    -0.02111804f, -0.18881828f, 0.95720327f, 0.83989823f, 0.10370442f, -0.34556469f, 0.56711024f, -0.18059437f, 
    -0.07924987f, -0.45117483f, 0.52670658f, 0.21387330f, 0.22292517f, -0.04754396f, -0.09793291f, 0.50536996f, 
    -0.12824047f, 0.04447328f, 0.28396213f, -0.27254155f, -0.31692502f, -0.12581509f, 0.42647642f, 0.32612929f, 
    0.22189556f, 0.55593383f, -0.10743468f, 0.56309193f, -0.07006371f, -0.11884275f, 0.61559463f, 0.35859200f, 
    -0.68698913f, -0.78702480f, -0.25654092f, -0.21770366f, -0.45092627f, -0.36185229f, -0.13771786f, 0.17829011f, 
    0.11669146f, 0.06006607f, -0.23564614f, 0.27626818f, 0.29174641f, 0.32500011f, 0.68296111f, 0.31379098f, 
    -0.16859519f, -0.17971107f, 0.65189916f, -0.38988867f, 0.33333519f, 0.30858669f, -0.87421882f, -0.47450224f, 
    -0.16089624f, 0.25777474f, -0.83034456f, -0.10881602f, -0.50588608f, -0.56200039f, -0.16337071f, 0.59123278f, 
    0.52163261f, 0.54006320f, -0.22939852f, 0.24769813f, 0.16958530f, -0.12017929f, -0.21685794f, 0.69982404f, 
    -0.29570085f, -0.00677695f, 0.18359169f, 0.07487797f, 0.12051513f, -0.09592551f, -0.89719313f, 0.08372155f, 
    -0.55027175f, 0.05203173f, -0.07733271f, -0.28644553f, 0.81550533f, 0.68457311f, -0.10657820f, -0.46752137f, 
    -0.39329663f, -0.40317750f, 0.04984768f, 0.21066470f, 0.54420948f, -0.18533269f, -0.52241874f, 0.00644238f, 
    0.25987232f, 0.06729891f, -0.27573121f, -0.01693320f, -0.38451922f, -0.22135581f, -0.44692615f, -0.06273923f, 
    0.50636578f, -0.28478459f, -0.76553428f, -0.14994626f, -0.50884038f, -0.68764597f, -0.70937121f, 0.27261704f, 
    -0.11024000f, 0.19144188f, -0.61750782f, 0.06986041f, -0.22302842f, -0.53247184f, -0.55117625f, 0.00138611f, 
    -0.53280169f, -0.38509578f, 0.01200414f, 0.37925684f, -0.23424618f, 0.38798574f, 0.23236227f, 0.04339480f, 
    -0.61566776f, -0.48309562f, 0.93536246f, 0.76362479f, 0.51893687f, 0.61910212f, -0.02028510f, 0.57024157f, 
    0.16458826f, -0.53484493f, -0.43351933f, -0.24270616f, 0.28999990f, -0.07000947f, 0.03724626f, 0.09539089f, 
    0.11929522f, -0.09041589f, -0.05744386f, -0.11643693f, -0.03395984f, -0.31739092f, -0.53822297f, -0.39273536f, 
    0.68594050f, 0.66640419f, -0.58587325f, -0.37380102f, -0.44652432f, 0.76629233f, -0.67996162f, 0.06822694f, 
    -0.42663434f, 0.32523268f, 0.51553786f, 0.22402908f, 0.39013916f, 0.36831400f, -0.09225576f, -0.21735212f, 
    -0.35037166f, -0.01964340f, 0.07615089f, -0.32745865f, 0.46278250f, 0.74120128f, -0.09456901f, 0.21444416f, 
    -0.21725783f, -0.90276879f, 1.06536412f, 0.45397785f, 0.37011513f, 0.06810138f, 0.72534186f, -0.34889629f, 
    -1.03245807f, 0.37174207f, -0.69566005f, 0.10757697f, 0.08621660f, 0.29646274f, 0.21550767f, -0.01568176f, 
    0.01608012f, 0.13441096f, 0.20487906f, 0.08330677f, 0.21231298f, -0.19686961f, -0.47696674f, -0.08713510f, 
    -0.02498406f, -0.00812152f, 1.13716376f, 0.26503563f, 0.29112834f, 1.21660328f, 0.96852255f, -0.37026897f, 
    0.45174479f, 0.46139660f, 0.26618743f, 0.32952753f, -0.10663517f, -0.05433611f, 0.15143141f, -0.06187525f, 
    0.03827537f, 0.18334697f, -0.01245113f, 0.16307066f, 0.23341109f, 0.05400618f, 0.23994936f, -0.19307436f, 
    -0.06915476f, 0.16927467f, -0.03572727f, 0.87703532f, 0.50782084f, 0.70682347f, 0.28198624f, -0.40882277f, 
    0.35547012f, -0.54866296f, -0.02943441f, 0.04364111f, 0.99540979f, 0.20770632f, 0.13708909f, -0.19226922f, 
    -0.19209367f, -0.07528349f, 0.12836875f, 0.02420051f, 0.09323673f, -0.38418078f, 0.30758944f, 0.22706126f, 
    -0.27269056f, 0.24915789f, -0.28372234f, 0.15684979f, -0.48214334f, -1.62725866f, -0.46181223f, 0.77482301f, 
    0.71516454f, 0.53854382f, 0.82537746f, -0.03714752f, 0.13150154f, -0.33763024f, -0.00757145f, 0.54592824f, 
    -0.37575388f, 0.31314281f, 0.17224362f, 0.07075121f, -0.20587102f, -0.32685506f, -0.06747346f, -0.24061085f, 
    0.09006532f, 0.13485262f, 0.05846050f, 0.12630601f, -0.27802908f, 1.18898880f, -0.38636643f, -1.16061282f, 
    0.34454775f, 0.84352964f, 0.28887895f, -0.30217329f, 0.00562785f, 0.15766375f, 0.58477277f, -0.28991118f, 
    0.17634794f, -0.18884715f, 0.15476678f, 0.32228020f, -0.45735338f, -0.37678063f, -0.15335806f, -0.30153021f, 
    -0.43185604f, -0.13123086f, -0.07006623f, 0.33755013f, 0.04486774f, -0.00421311f, -0.14696772f, 0.12294213f, 
    -0.50237381f, -0.84097332f, -0.30047423f, 0.51858920f, -0.18975025f, -0.04208375f, 0.14887340f, 0.65018040f, 
    -0.22129053f, 0.00571156f, 0.31271669f, -0.60896015f, -0.43538520f, -0.24091718f, 0.65330839f, -0.12431300f, 
    0.25733218f, -0.14386238f, -0.39104027f, -0.52892810f, -0.15388125f, -0.26141500f, 0.06550433f, 0.06369115f, 
    -0.97246379f, 0.76715797f, 0.88901031f, -0.32015687f, 0.63063198f, 0.75815189f, 0.67716283f, 0.23386626f, 
    -0.00303988f, 0.07603371f, -0.37534496f, -0.17395869f, -0.12706922f, -0.38984010f, 0.19802359f, -0.37567180f, 
    -0.02205333f, -0.31585079f, -0.33594209f, -0.50949174f, 0.15789513f, 0.03614773f, 0.46738756f, 0.08134937f, 
    -0.82702756f, -0.23259935f, 0.55643821f, 0.18825285f, 0.27599958f, -0.77977043f, -0.13915963f, 0.18303795f, 
    0.25869787f, 0.13425304f, -0.33491802f, -0.00866078f, 0.21983717f, 0.34514683f, 0.13755782f, 0.62686205f, 
    -0.19527034f, 0.27794895f, -0.35252073f, -0.09385815f, -0.58901244f, 0.17438099f, -0.04896339f, -0.21551085f, 
    -0.18471526f, -1.21765828f, 1.33839440f, 0.40962213f, -1.17752433f, 0.57349128f, -0.15337646f, 0.35862744f, 
    -0.11181552f, -0.22298419f, -0.77888811f, -0.04439921f, -0.05877242f, -0.45708415f, -0.10650533f, -0.41782853f, 
    -0.29323167f, -0.28293714f, -0.21899134f, -0.31653184f, -0.16551651f, -0.16585876f, -0.04943267f, 0.08193935f, 
    0.03099467f, 0.08509940f, -0.66736174f, -1.27311039f, -0.97293127f, -0.39223862f, -0.08198357f, -1.09018421f, 
    0.67641598f, 0.62344545f, -0.59943992f, 0.17718197f, 0.48559666f, -0.07498781f, -0.06814104f, -0.22934860f, 
    0.24732541f, -0.16171972f, 0.32179081f, 0.08209370f, -0.36514953f, -0.14359178f, 0.20088552f, -0.21110429f, 
    -0.00953029f, 0.24445862f, 0.17512952f, 0.88819402f, 0.52266735f, -0.71320397f, -1.13162029f, -0.98874491f, 
    -0.45671123f, -0.27632535f, -0.18121076f, -0.36603028f, -0.15594414f, 0.23427047f, 0.07703807f, 0.40269229f, 
    -0.02523655f, 0.18826243f, -0.07014132f, 0.11084662f, -0.23355021f, 0.19179997f, 0.28604895f, 0.38476375f, 
    0.10433281f, 0.24776511f, 0.02433239f, 0.05611436f, 0.65894634f, 0.78318560f, 0.54478943f, 0.89106321f, 
    0.58765256f, 0.72157526f, -0.02112466f, -0.69468224f, -0.39207351f, -0.37492812f, 0.14601696f, -0.12250347f, 
    -0.33075631f, 0.43591806f, -0.20564730f, 0.20247960f, 0.02952145f, 0.20776634f, -0.04421999f, 0.08610651f, 
    0.05415687f, 0.00975462f, 0.19766922f, 0.19028637f, 0.42636067f, -0.75112069f, -0.16196583f, 0.51116604f, 
    0.03126207f, -0.63023984f, -0.57524818f, 0.08463947f, -0.23756087f, -0.92270535f, -0.69008583f, -0.01059904f, 
    0.44548538f, 0.12230565f, 0.07363512f, -0.15669085f, -0.20193523f, 0.01455554f, -0.18550666f, 0.08518267f, 
    0.31108084f, -0.06828909f, 0.24465275f, 0.32400167f, 0.47453356f, 0.32325140f, 0.98234993f, -0.27400410f, 
    0.99986345f, 0.84578323f, 0.41145399f, 0.16685882f, -0.65067446f, -0.59038669f, -0.71868992f, -0.05154696f, 
    0.29628244f, 0.49542066f, -0.34869552f, 0.31235132f, 0.05972955f, -0.14583391f, -0.36823869f, -0.07099458f, 
    0.06924810f, -0.18440792f, -0.20866026f, 0.14227664f, 0.10619357f, 0.12797944f, -0.00668712f, 1.07772267f, 
    1.04594612f, 0.83693480f, -0.26839438f, -0.88362759f, -0.89006364f, 0.53869498f, -0.27190426f, 0.01825660f, 
    0.35856658f, 0.01466658f, -0.09078236f, -0.13508932f, 0.07920785f, 0.35645750f, 0.17627504f, -0.02760370f, 
    -0.06832829f, 0.29936028f, -0.05637701f, -0.14187884f, 0.04819341f, -0.22347802f, -0.15606304f, 0.34760472f, 
    -0.71183467f, -0.57091802f, -0.50878936f, -0.32423559f, -0.42738026f, 0.66903007f, 1.35571826f, 0.27968124f, 
    0.34842184f, 0.61874795f, -0.17630471f, -0.17961931f, -0.07651166f, -0.35020009f, 0.00408766f, -0.20709641f, 
    -0.12399819f, -0.18458492f, -0.02821495f, 0.01301890f, -0.02643501f, -0.29143417f, 0.20526214f, -0.23981021f, 
    -0.02304055f, -0.68982375f, -0.92967182f, -0.74487454f, -0.32703814f, -0.31981260f, 0.42919853f, 0.42476687f, 
    -0.52665406f, 0.63655019f, 0.65033954f, -0.22881800f, -0.20317434f, -0.02470668f, 0.30089965f, 0.23189184f, 
    -0.25288627f, 0.33937019f, 0.16614640f, 0.08750004f, -0.22758685f, 0.11650801f, -0.01921799f, -0.24939543f, 
    0.37561572f, 0.38836911f, 0.22288653f, 0.48583508f, 0.14772628f, -0.26278687f, 1.12479186f, 0.45151654f, 
    -0.68072242f, -1.11207008f, 0.19837892f, -0.03218126f, 0.42651168f, 0.53558677f, 0.19871424f, 0.14031847f, 
    0.44198644f, -0.16015315f, -0.25323850f, 0.23534901f, 0.28718528f, 0.23910269f, 0.32647339f, -0.00063821f, 
    -0.15678717f, -0.34848803f, 0.11425865f, 0.19145562f, 0.23870558f, 0.48231125f, 0.42396712f, 0.70737392f, 
    -0.12035163f, 0.47833046f, 0.01610192f, -0.95671499f, 0.62312162f, -0.51850587f, -0.45329449f, 0.40413034f, 
    -0.17217597f, -0.19287710f, -0.18500386f, -0.07352018f, 0.14896011f, 0.17110820f, -0.11999971f, 0.55735266f, 
    0.09840464f, 0.06594277f, 0.14035322f, 0.07499764f, -0.60634452f, -0.05235419f, -0.88539857f, -0.95282543f, 
    -0.08510488f, -0.48319328f, 0.54525036f, 0.61715972f, 0.47868687f, 0.41597229f, -0.33536556f, -0.04322894f, 
    0.20245104f, -0.26469749f, -0.65778536f, 0.19329859f, 0.08549462f, 0.41218019f, 0.14940685f, -0.07219845f, 
    -0.24419217f, 0.02549744f, -0.52675766f, -0.25537631f, 0.08856111f, -0.21761696f, -0.46219146f, 0.13966407f, 
    0.43832543f, 1.00707674f, -0.59862173f, -0.18244286f, -0.81724626f, -0.99715066f, 0.02395649f, 0.40375572f, 
    0.63526380f, 0.04347462f, 0.01946282f, 0.10524742f, 0.28651202f, 0.13509148f, -0.04927799f, -0.07085017f, 
    -0.17827317f, 0.03419254f, 0.15670130f, 0.16918556f, 0.11682968f, -0.25398180f, -0.64337409f, 0.27201894f, 
    0.51273412f, -0.32525253f, 0.16346060f, 0.10142286f, -0.53056252f, -0.34163058f, -0.31164923f, -0.33155897f, 
    -0.59759098f, -0.24275188f, 0.48267734f, -0.34023699f, -0.27166754f, -0.69759560f, -0.21455646f, 0.34388599f, 
    -0.01062292f, -0.74517268f, 0.04860468f, -0.05818721f, -0.04525524f, 0.09684607f, -0.04734125f, 0.20233914f, 
    0.78677487f, 0.72181386f, -0.04395630f, 0.88054895f, 1.09215140f, 0.24400333f, 0.51841056f, -0.61703110f, 
    -0.37805897f, 0.39646384f, -0.06554819f, 0.25152490f, 0.12676685f, -0.34542859f, -0.14238191f, 0.10008758f, 
    -0.04384694f, -0.06619308f, -0.13550536f, -0.11516217f, 0.02063584f, 0.11521065f, -0.34014696f, -0.07703304f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33438405f, 0.15573941f, 0.01025114f, 0.29182059f, 0.27712631f, 0.06524431f, -0.01719169f, 0.31616566f, 
    -0.02436155f, -0.13836877f, 0.12011643f, 0.27816382f, 0.41754031f, 0.14592960f, 0.03211359f, 0.02340370f, 
    0.24692795f, 0.16930673f, 0.21940985f, 0.13824724f, -0.01507606f, 0.03908549f, 0.19493327f, 0.30747983f, 
    0.14356647f, 0.18869984f, 0.07875841f, 0.29069591f, 0.14176893f, 0.27911115f, -0.04565217f, 0.13709390f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14826037f, 0.21655218f, 0.10761971f, -0.27531600f, -0.06971353f, 0.05660634f, 0.16004747f, -0.11121777f, 
    -0.19464524f, 0.11860899f, -0.01268901f, -0.09880707f, 0.11190685f, 0.00779645f, -0.04402624f, 0.04870748f, 
    -0.17906526f, -0.24977992f, -0.05789674f, 0.01021546f, 0.03007170f, 0.04398310f, 0.09110070f, -0.12567931f, 
    0.08247209f, -0.01324633f, 0.08533342f, -0.32691944f, -0.09843370f, -0.00244966f, 0.00817950f, 0.05288342f, 
    0.17501652f, 0.07087522f, 0.10269625f, -0.14854673f, 0.30025378f, -0.07578282f, 0.03534962f, 0.19756885f, 
    -0.05504997f, 0.10661679f, -0.07272064f, -0.01172685f, 0.01162906f, -0.30114982f, -0.08938534f, 0.01245321f, 
    -0.01691295f, -0.05204479f, 0.17093682f, -0.18458316f, -0.01360419f, 0.01084609f, -0.01648056f, 0.02388781f, 
    0.07825053f, 0.00399232f, -0.15082678f, -0.11489053f, 0.15269013f, 0.05930141f, -0.06433448f, 0.01278857f, 
    -0.04914430f, 0.03167612f, 0.05719050f, 0.13193376f, 0.22560462f, -0.13320014f, 0.04376997f, 0.03862093f, 
    -0.61364716f, -0.00443637f, 0.11759946f, 0.14861050f, -0.14222220f, 0.08668828f, -0.03905868f, -0.04906687f, 
    -0.03803298f, 0.17936464f, -0.03271664f, 0.11822445f, -0.08362813f, 0.15019616f, 0.03680207f, 0.37045261f, 
    -0.03104686f, 0.06073049f, -0.05132350f, -0.21246329f, 0.06261997f, -0.07753799f, -0.08797776f, -0.03551305f, 
    0.06982347f, -0.22574571f, -0.00633226f, -0.27137595f, -0.08283488f, 0.12529647f, 0.04966919f, -0.16034521f, 
    -0.03644718f, -0.07171283f, -0.00300009f, 0.17008261f, -0.28299537f, 0.14269647f, 0.03289884f, -0.10885250f, 
    -0.18129928f, -0.25883105f, 0.11469733f, -0.05702244f, 0.09031788f, 0.07467771f, -0.11771248f, 0.13685848f, 
    0.18954043f, -0.04864595f, -0.16934191f, 0.37649190f, -0.18331249f, 0.07829339f, -0.03153899f, 0.05231000f, 
    -0.02150396f, -0.00789673f, 0.17764205f, -0.00647435f, 0.14643383f, -0.09275433f, -0.06155765f, 0.05916021f, 
    -0.16473736f, -0.20783965f, 0.01681344f, 0.02663438f, 0.02223934f, 0.07117427f, -0.01608128f, -0.02534076f, 
    -0.41714486f, 0.16162707f, -0.03005424f, 0.10052592f, 0.08327505f, 0.04816375f, -0.15936814f, -0.05537896f, 
    0.00778536f, -0.01055928f, 0.10791063f, -0.13272329f, 0.36086908f, -0.20041376f, 0.29599553f, 0.21085595f, 
    -0.12793021f, 0.10027215f, 0.02324191f, 0.08876972f, -0.34923697f, 0.13736257f, -0.05333727f, -0.16072249f, 
    0.28182900f, -0.00783279f, -0.10284862f, -0.29253060f, 0.06742731f, 0.06825916f, -0.05212145f, 0.11980660f, 
    -0.03821452f, 0.07275906f, -0.03697567f, -0.09162816f, 0.01445492f, 0.10906596f, -0.07566777f, 0.30919567f, 
    -0.14691262f, 0.21495177f, 0.07728622f, -0.08628014f, -0.05211353f, -0.06196355f, -0.09595639f, -0.26625052f, 
    -0.12377479f, -0.19616520f, -0.12601656f, 0.14896220f, 0.05680174f, -0.01139839f, -0.00821828f, 0.12812942f, 
    0.00197147f, 0.07807945f, -0.13426463f, -0.04980143f, -0.28041950f, 0.06971639f, 0.25693563f, -0.31000128f, 
    -0.02121633f, -0.10607808f, 0.04941201f, -0.05305546f, 0.04718720f, -0.17111212f, 0.09150118f, -0.09693216f, 
    -0.78509313f, 0.14751512f, -0.06576589f, -0.04980711f, 0.04027826f, -0.05763111f, -0.13830358f, 0.05447376f, 
    -0.02104961f, 0.02030051f, -0.00689895f, 0.11883202f, -0.73460013f, 0.08729105f, 0.12018748f, -0.28257895f, 
    0.02212021f, -0.01544949f, 0.06316304f, 0.01807685f, -0.13328293f, -0.18378983f, 0.11678768f, 0.05810184f, 
    0.03477134f, 0.06462006f, 0.03071761f, 0.18363754f, -0.12479614f, -0.20043486f, 0.04418894f, 0.11382930f, 
    -0.02063838f, 0.13998950f, -0.04263625f, -0.14804417f, -0.50442207f, 0.10059030f, -0.04989350f, 0.17529589f, 
    0.12851316f, 0.14005128f, -0.01230098f, 0.13751978f, 0.10626970f, -0.01803581f, -0.02557380f, -0.11441984f, 
    0.27824935f, -0.20614854f, -0.12264179f, 0.11783187f, -0.23779224f, -0.20824590f, 0.09276042f, 0.11138440f, 
    -0.04974411f, 0.05753134f, -0.05974398f, -0.06247460f, -0.12624539f, 0.16580938f, -0.09711101f, -0.15686303f, 
    -0.15775706f, 0.03629380f, -0.00449572f, 0.04441039f, 0.04445442f, -0.02691976f, -0.04484886f, -0.10410073f, 
    0.34993052f, 0.29274592f, 0.13466412f, -0.33534712f, 0.04687531f, 0.12345801f, 0.13430083f, 0.05391609f, 
    -0.01468417f, 0.00223493f, -0.03360051f, 0.19125339f, 0.19107042f, 0.06586894f, -0.09935443f, -0.12695408f, 
    0.07146056f, 0.02998214f, -0.05423756f, 0.00978813f, 0.09805796f, -0.01892401f, -0.09797678f, 0.17144009f, 
    -0.12682427f, -0.12928346f, 0.30623639f, -0.21931948f, -0.17996603f, 0.09818653f, -0.01212776f, -0.12843357f, 
    0.07404298f, 0.04937215f, 0.11409254f, 0.04898845f, 0.00934679f, 0.03295832f, 0.10574380f, 0.16985163f, 
    0.00615602f, -0.05412119f, -0.15307564f, -0.05565898f, -0.00163749f, -0.02063440f, -0.09990995f, 0.01637403f, 
    0.23241086f, 0.37794322f, -0.22809637f, -0.64994532f, 0.18554699f, 0.09060819f, 0.03857736f, 0.00557560f, 
    -0.05348816f, -0.11840029f, -0.02800069f, 0.01552184f, -0.03791476f, -0.18915595f, 0.03037077f, 0.20132415f, 
    -0.01941257f, -0.04264695f, -0.11257496f, 0.01518822f, -0.09055245f, 0.03678503f, 0.02055697f, -0.00753307f, 
    -0.45529166f, 0.08424640f, 0.23769735f, 0.08648992f, -0.04685875f, -0.01243514f, 0.08595558f, -0.12341040f, 
    0.01807952f, 0.04553347f, -0.13538532f, 0.09956260f, -0.20912808f, -0.18322742f, 0.16381401f, -0.21913791f, 
    -0.27186581f, 0.05514413f, 0.06781437f, 0.02484271f, 0.00820068f, 0.03349711f, 0.13241448f, -0.06910747f, 
    0.32810658f, -0.53141481f, -0.01093163f, -0.26088211f, 0.04474166f, 0.02367180f, -0.15264228f, 0.06521829f, 
    0.02066371f, 0.04428633f, -0.10746532f, -0.05764343f, 0.21500801f, 0.10143110f, 0.16240084f, 0.30368435f, 
    -0.17197347f, -0.01908951f, 0.16473559f, -0.02726696f, 0.01645681f, -0.15320382f, -0.08663018f, -0.04389436f, 
    0.11366313f, 0.08131115f, 0.11206836f, 0.04735810f, -0.10691420f, -0.06065385f, 0.07649653f, -0.03502120f, 
    -0.05550233f, -0.15024054f, -0.10708297f, 0.14018160f, -0.08693189f, -0.06280227f, -0.12245929f, 0.06056994f, 
    -0.01337699f, 0.00074375f, 0.03364357f, -0.01050297f, 0.05006546f, 0.09409910f, 0.04217244f, 0.17524253f, 
    0.05552468f, -0.45333385f, 0.05371269f, -0.29426473f, -0.02757995f, -0.02164131f, 0.27738485f, 0.04292610f, 
    -0.03990473f, 0.10776207f, 0.08219650f, -0.04813476f, -0.13301846f, -0.13270710f, 0.09398938f, -0.19745828f, 
    0.06749994f, -0.05145247f, -0.02960001f, -0.04191590f, -0.06258149f, 0.26001295f, -0.13000384f, -0.16597496f, 
    -0.20569350f, 0.04936473f, -0.26338959f, -0.16506884f, -0.04383927f, 0.11088356f, 0.03309414f, 0.14440104f, 
    -0.10830227f, -0.18474172f, -0.15570384f, -0.15973145f, 0.30291238f, -0.20647018f, -0.20674515f, 0.07371144f, 
    0.14775804f, 0.08059659f, -0.15595755f, 0.13479991f, -0.01749998f, 0.33214027f, 0.17027795f, -0.33931535f, 
    0.16341005f, -0.10511765f, 0.08816710f, -0.16325733f, -0.00304320f, -0.15010175f, -0.00172271f, 0.06966341f, 
    0.02818508f, 0.05815977f, -0.14068222f, -0.06223651f, -0.18746072f, -0.19202846f, -0.07117678f, 0.10239720f, 
    0.02180416f, 0.16211671f, -0.08705812f, -0.10975619f, 0.07117654f, 0.01750783f, 0.03246643f, 0.01369844f, 
    0.30249262f, 0.03968796f, 0.06509850f, 0.30910882f, -0.14630148f, 0.02643773f, -0.01207926f, 0.01371776f, 
    0.14080007f, -0.02727633f, -0.10283007f, 0.06449191f, 0.15755484f, 0.10096079f, 0.16472001f, 0.02732207f, 
    -0.12778960f, -0.10729680f, 0.06006497f, 0.03216278f, -0.06494445f, 0.04663530f, 0.04236757f, 0.01332227f, 
    0.47763512f, -0.27041423f, -0.28492704f, 0.00501139f, -0.05953299f, 0.16617076f, 0.07203665f, -0.02379649f, 
    -0.12364703f, 0.00531373f, -0.16143377f, 0.11054359f, 0.15062009f, -0.34362900f, 0.18102808f, -0.23248117f, 
    -0.00647101f, -0.04638833f, -0.17522743f, -0.07519878f, 0.01940325f, -0.13735272f, -0.22885990f, 0.05319469f, 
    -0.01018277f, -0.05447285f, 0.20610943f, -0.10791428f, 0.17114450f, -0.25988746f, 0.13934998f, 0.02439309f, 
    -0.01792980f, -0.25805858f, 0.04092899f, -0.09624404f, -0.18075322f, 0.14588872f, 0.09677698f, 0.18205698f, 
    -0.06233359f, 0.05036457f, 0.09636582f, -0.02632097f, 0.07317141f, 0.07187602f, 0.03442289f, 0.05775451f, 
    -0.21695714f, 0.20214823f, -0.12021656f, -0.10391321f, -0.01726505f, -0.00180959f, -0.11072084f, -0.27747118f, 
    -0.02524173f, -0.07850811f, -0.03003969f, 0.09365573f, -0.47169396f, 0.10006471f, -0.55504888f, -0.57818264f, 
    -0.09891286f, 0.11575653f, 0.06061409f, 0.00434683f, -0.06978118f, 0.06967461f, -0.14667933f, 0.07459859f, 
    0.39733839f, -0.19143195f, -0.10868791f, 0.08331265f, 0.01051638f, 0.14514640f, -0.04239021f, 0.07324170f, 
    0.07504833f, -0.10332914f, 0.08493365f, 0.05596507f, 0.43760458f, -0.20527478f, 0.05884479f, -0.38203350f, 
    0.04369938f, 0.16264352f, 0.05742791f, 0.17734632f, -0.15920560f, 0.20715013f, 0.06603638f, -0.00295726f, 
    0.13273779f, -0.14809607f, 0.17363757f, 0.07286925f, -0.12977390f, 0.11287166f, 0.02577244f, -0.00322608f, 
    -0.02157396f, 0.07809313f, -0.03407831f, 0.03787353f, -0.14312415f, -0.07511890f, -0.16430962f, -0.01732042f, 
    -0.08729181f, -0.02057252f, -0.08860313f, -0.01810833f, -0.01992748f, 0.16266467f, 0.07217798f, -0.08032180f, 
    -0.10059506f, 0.13930626f, 0.18540148f, 0.09273287f, 0.06729520f, 0.02243633f, -0.00159651f, -0.01437500f, 
    -0.05863936f, -0.04025169f, 0.00727155f, 0.04817439f, 0.36350402f, 0.07961256f, -0.25149819f, -0.09537938f, 
    0.00883814f, -0.24034762f, -0.01101516f, -0.00269191f, -0.02453508f, -0.04633703f, -0.07156054f, 0.06562563f, 
    0.02351811f, -0.11904583f, -0.12823200f, -0.08004088f, 0.07812171f, -0.06681080f, -0.11443206f, -0.10467080f, 
    0.07716358f, 0.14471029f, -0.03173757f, -0.00387899f, 0.13799222f, 0.02829362f, -0.08454697f, -0.13696973f, 
    0.12406410f, -0.00136759f, 0.07384814f, 0.11873387f, 0.01723469f, 0.06255969f, 0.08505774f, -0.00809545f, 
    -0.28352013f, -0.14236356f, 0.12131372f, -0.03735390f, -0.22467868f, -0.22089711f, -0.12290750f, 0.10230906f, 
    -0.14290147f, 0.03734408f, 0.04371133f, -0.04184277f, 0.25434652f, 0.10249647f, -0.04294014f, 0.30604231f, 
    -0.12551324f, 0.12767963f, -0.05019023f, 0.17642210f, 0.14583881f, 0.17090280f, 0.01119255f, -0.01087307f, 
    -0.00925096f, -0.23809691f, -0.00990479f, -0.43264961f, 0.16368800f, -0.05864786f, -0.13303439f, -0.03395896f, 
    0.16808882f, -0.10384515f, 0.06972031f, -0.01144399f, -0.22064717f, -0.22492960f, 0.03723734f, -0.11450147f, 
    0.02891872f, -0.03460290f, 0.03568007f, 0.06189647f, 0.04594081f, 0.00979950f, -0.01391138f, 0.05383074f, 
    0.08450708f, -0.23821945f, -0.26508737f, -0.19650252f, -0.12729189f, -0.03774212f, -0.01976754f, 0.01733805f, 
    -0.06963890f, -0.18345271f, 0.04291577f, -0.12547620f, 0.38694128f, 0.09925966f, 0.09924911f, -0.00373191f, 
    -0.15515155f, 0.10621090f, 0.01347399f, -0.05179473f, -0.11156629f, -0.12452549f, -0.08408684f, 0.00309854f, 
    -0.01776881f, -0.08356024f, 0.10634775f, 0.04087102f, -0.18553947f, -0.07654545f, -0.00065449f, -0.07410438f, 
    -0.05314095f, -0.13127965f, -0.01293928f, 0.09530728f, 0.25008860f, 0.15146771f, 0.03065358f, -0.06926621f, 
    0.07125927f, 0.01888007f, 0.03404086f, 0.03732809f, -0.11157864f, 0.18203405f, 0.10288071f, 0.07032806f, 
    0.05036129f, -0.02209986f, 0.13087779f, -0.11164211f, 0.15322596f, -0.04025485f, 0.05577109f, -0.10648835f, 
    0.03935667f, 0.01086850f, 0.14553928f, -0.06502862f, -0.25285596f, -0.03948952f, -0.31008643f, -0.12352174f, 
    0.01800198f, 0.16167173f, -0.08474804f, 0.00447087f, -0.14563553f, -0.22311431f, -0.10890704f, -0.01771062f, 
    -0.73767823f, 0.17740154f, -0.13175336f, -0.27910289f, -0.01681579f, -0.04322096f, 0.02999302f, -0.01778978f, 
    -0.20754482f, 0.03423542f, -0.12617742f, -0.15955228f, -0.10800555f, 0.11722258f, -0.22854821f, 0.20475438f, 
    -0.00040853f, 0.09130447f, 0.00845380f, 0.04230901f, -0.03252742f, -0.06305125f, 0.05965612f, 0.01171373f, 
    -0.09274761f, -0.25274256f, -0.02386105f, -0.46285155f, -0.00361042f, 0.00778874f, -0.09170360f, -0.07318972f, 
    0.12552331f, 0.08464356f, 0.02063147f, 0.00120506f, -0.16659778f, -0.31324294f, 0.04822549f, -0.07886212f, 
    0.05970305f, 0.06166240f, -0.02876376f, 0.03404623f, 0.04229514f, 0.06020136f, -0.14879510f, 0.08368755f, 
    -0.09995090f, 0.22235800f, 0.08287187f, -0.19125691f, 0.01570566f, -0.07627392f, 0.08752061f, -0.00950589f, 
    -0.06752948f, -0.10858388f, -0.10543513f, -0.00653425f, 0.42726690f, 0.03945785f, -0.08746803f, 0.02892344f, 
    0.13199955f, 0.05653054f, 0.14374301f, -0.02972028f, -0.29863402f, -0.07587217f, -0.05198282f, 0.05134346f, 
    0.10397170f, 0.15552095f, -0.10950945f, -0.00327838f, 0.22245260f, 0.02449551f, -0.00102771f, 0.00747103f, 
    -0.10295210f, -0.09484666f, 0.03121326f, -0.04023538f, -0.10816582f, 0.03941789f, 0.11539825f, -0.13922802f, 
    -0.00562287f, 0.13107665f, 0.04023397f, 0.10278916f, -0.06037379f, -0.05072528f, -0.12978840f, -0.05865216f, 
    0.35243785f, -0.47945622f, 0.10045774f, -0.02962418f, -0.14875288f, 0.06474243f, 0.00187867f, -0.05839590f, 
    0.14012958f, -0.07507437f, -0.04069258f, -0.02799468f, 0.04078130f, -0.03771451f, 0.08367254f, -0.00229774f, 
    -0.00995225f, 0.15601814f, -0.03125134f, 0.06160154f, 0.05321255f, 0.11429133f, 0.04536501f, -0.08749006f, 
    -0.04920295f, 0.05439546f, 0.22095752f, 0.06865451f, -0.01822851f, -0.07956057f, 0.19154552f, 0.02079969f, 
    -0.04741991f, 0.17931381f, -0.02572176f, -0.04987677f, -0.10035350f, -0.17128661f, -0.05642950f, -0.13400625f, 
    -0.06579468f, 0.02835081f, -0.12383330f, 0.12077540f, 0.03181780f, 0.22041818f, 0.00345933f, -0.03820655f, 
    0.31483635f, -0.20964821f, -0.28500724f, -0.02709834f, -0.22166993f, 0.11487111f, -0.05021570f, -0.07608023f, 
    -0.03507574f, 0.11418284f, -0.06645717f, -0.07856676f, 0.40391025f, -0.20660760f, -0.51378912f, -0.19592895f, 
    0.07090599f, 0.05692340f, -0.01159913f, -0.13378394f, -0.02777077f, 0.11654482f, 0.04273533f, 0.02351147f, 
    0.78397113f, -0.12041288f, -0.06876535f, 0.18134321f, -0.23519050f, -0.03726891f, -0.11828605f, -0.02465643f, 
    -0.01396351f, 0.01750781f, 0.14563701f, -0.07381999f, -0.45687211f, -0.10607683f, -0.01901846f, -0.35304901f, 
    -0.12257005f, -0.10096227f, 0.07317043f, -0.06592067f, -0.08801339f, -0.04366617f, -0.00123918f, -0.08820026f, 
    0.20155150f, -0.19238339f, 0.01566406f, 0.07537162f, 0.19919474f, -0.07291545f, 0.05739143f, -0.04970580f, 
    0.03719079f, 0.07740046f, -0.03276730f, 0.04795155f, 0.21157402f, -0.00296779f, -0.47816354f, -0.43146938f, 
    -0.20996347f, -0.10207871f, -0.14555997f, 0.01350188f, 0.07149605f, 0.03215395f, -0.12453952f, -0.14160304f, 
    -0.21985404f, 0.02932600f, 0.00848599f, -0.06443676f, -0.00581602f, 0.21273012f, -0.04655275f, -0.05685572f, 
    0.01582805f, 0.01414584f, -0.03781669f, -0.13849616f, -0.16380638f, 0.08996696f, -0.02441901f, -0.17361158f, 
    -0.05163989f, 0.16569893f, -0.03143172f, 0.03207608f, -0.23176558f, -0.02648437f, -0.08751487f, -0.04727240f, 
    0.50290710f, 0.12012549f, 0.28270772f, 0.25664157f, -0.13695574f, -0.17548943f, -0.02575221f, 0.16393627f, 
    0.05730835f, 0.04653968f, -0.02388612f, -0.07672450f, 0.42347595f, -0.05762701f, 0.27558583f, 0.21821901f, 
    -0.15576352f, -0.15794268f, -0.04706459f, 0.00619837f, -0.10329075f, -0.02362404f, 0.00330308f, -0.02586514f, 
    0.00605384f, -0.19424459f, 0.02821870f, -0.00424590f, 0.08921989f, 0.00592167f, 0.13337114f, -0.17006478f, 
    0.00814168f, -0.01813496f, 0.10125761f, -0.12536141f, -0.10267078f, -0.18344176f, 0.11187589f, -0.04640017f, 
    0.11605315f, -0.00373014f, 0.00322127f, -0.16962740f, 0.12516980f, 0.09310735f, -0.12474370f, 0.13062194f, 
    0.12937200f, 0.17072611f, -0.27157596f, 0.31983531f, -0.09700521f, -0.21975482f, 0.03947920f, 0.14437558f, 
    -0.03495290f, 0.00855270f, -0.06501547f, -0.08575008f, 0.47120097f, -0.32674634f, 0.01326535f, -0.06625770f, 
    0.01905739f, 0.03309277f, -0.10899299f, -0.14309996f, -0.16510823f, -0.18205117f, 0.10437370f, -0.24876381f, 
    0.08172476f, -0.08620971f, -0.10384560f, -0.03481857f, -0.04485945f, 0.02818875f, 0.02218866f, -0.04256761f, 
    -0.06924317f, 0.27089879f, -0.15340766f, 0.10102078f, -0.02375051f, -0.13596921f, 0.15246108f, 0.12768236f, 
    0.10306925f, -0.00708904f, 0.00719195f, -0.07260085f, -0.06930158f, -0.01442526f, -0.09169615f, 0.15133974f, 
    0.09471370f, 0.09371588f, 0.00010281f, 0.09416841f, 0.00808970f, -0.02243623f, 0.12305853f, -0.02112812f, 
    -0.16243890f, 0.04339586f, 0.11605238f, 0.16322857f, -0.49725935f, -0.42070213f, -0.32829645f, -0.08668108f, 
    -0.06254106f, 0.10665002f, -0.12600163f, -0.01247700f, -0.03029693f, 0.13311127f, -0.05944879f, 0.14263836f, 
    -0.07998417f, -0.41393903f, -0.07609052f, -0.25895080f, -0.14651550f, -0.06434015f, 0.02908383f, -0.14767122f, 
    -0.10922416f, -0.00953006f, -0.04482067f, 0.07513078f, 0.07511909f, -0.17083663f, 0.13229305f, 0.14245732f, 
    0.04089288f, 0.04877071f, 0.07599463f, -0.08514924f, -0.06217202f, -0.09016839f, -0.02643660f, -0.04860200f, 
    0.25447950f, -0.12000374f, 0.02020856f, 0.24708417f, 0.03646854f, 0.02231772f, -0.08704675f, 0.23297161f, 
    0.02762721f, -0.12891716f, -0.08798201f, -0.15564507f, 0.06257801f, -0.18983515f, 0.11209585f, 0.03548251f, 
    -0.02755837f, 0.06885087f, -0.00432876f, -0.07499512f, -0.05681177f, 0.19662249f, 0.10533389f, -0.11311591f, 
    0.17060094f, 0.25093058f, 0.16762915f, 0.00293215f, 0.11127381f, -0.08411539f, -0.01372824f, 0.05751301f, 
    0.03954623f, 0.05050685f, 0.04814183f, 0.06233123f, 0.00139800f, -0.06368699f, -0.08723017f, 0.04006954f, 
    -0.08876464f, -0.03270086f, 0.09417938f, -0.13273723f, 0.09965754f, 0.00971912f, 0.02295161f, -0.03652117f, 
    0.19286726f, -0.03123794f, -0.23939943f, 0.19258182f, -0.08395869f, 0.11034250f, -0.15401688f, -0.00344469f, 
    -0.00402144f, -0.01281517f, -0.07338160f, -0.01976480f, 0.79030132f, 0.11257797f, -0.18258624f, 0.13683307f, 
    0.26435390f, -0.03930318f, 0.11886146f, 0.21620592f, -0.05440940f, 0.07812743f, -0.11552550f, -0.18853392f, 
    -0.67311209f, -0.31331378f, -0.02187280f, -0.11625683f, -0.11787459f, -0.01305128f, 0.10173625f, -0.18486686f, 
    -0.07698550f, 0.03661849f, -0.02680487f, 0.04933975f, -0.30204737f, -0.29086626f, -0.41574907f, 0.31143445f, 
    -0.19327070f, 0.06041922f, 0.11625624f, 0.00146931f, 0.04428548f, 0.06261753f, 0.00727470f, 0.01325072f, 
    0.16275796f, 0.06649578f, -0.01622610f, 0.05196094f, -0.03008576f, 0.03158606f, 0.04146729f, -0.03960209f, 
    -0.08470485f, -0.02973091f, 0.05418200f, 0.05933544f, 0.26644251f, 0.19933026f, 0.03727922f, 0.14785185f, 
    0.09289186f, 0.19662842f, -0.17139305f, -0.06770963f, 0.09513476f, 0.02435696f, 0.01572130f, -0.10653915f, 
    -0.13171045f, 0.06727519f, -0.07579786f, -0.14776109f, -0.05958426f, 0.07135233f, 0.07759258f, 0.01827302f, 
    0.04011447f, 0.07987527f, -0.11767048f, 0.14974023f, -0.15567742f, -0.19330508f, -0.04641929f, -0.15350135f, 
    -0.07192337f, -0.06363667f, -0.07684094f, 0.05407433f, 0.02648492f, -0.00609631f, 0.05643690f, -0.23436624f, 
    -0.05950787f, 0.05086957f, 0.22501557f, 0.19478968f, -0.01015403f, 0.05985354f, 0.01247484f, -0.02262337f, 
    -0.00477043f, 0.01632663f, -0.00063901f, 0.04285871f, 0.25563285f, 0.32708144f, 0.20167361f, -0.04221876f, 
    0.00554953f, 0.07811993f, 0.08650359f, 0.10354947f, -0.01717027f, 0.04968708f, -0.02244876f, -0.01724980f, 
    0.21089436f, -0.12568425f, 0.09256984f, 0.07140802f, -0.08866533f, -0.21945681f, -0.00919593f, -0.03682134f, 
    -0.12873286f, 0.01474112f, -0.14569198f, 0.03761459f, 0.08405428f, -0.34921575f, -0.11304516f, -0.03395022f, 
    -0.12864047f, 0.06131601f, 0.01500473f, 0.12817234f, 0.06002253f, 0.10258847f, -0.14405079f, -0.03139007f, 
    0.25488335f, -0.29502958f, -0.06591602f, 0.24377713f, -0.13052681f, 0.07089647f, 0.01206931f, 0.01668817f, 
    -0.00746615f, -0.20348862f, -0.03018461f, -0.12055220f, -0.04062821f, 0.36638537f, 0.24901649f, -0.00291582f, 
    0.00205957f, -0.15629287f, -0.09760807f, 0.05894538f, 0.02384851f, -0.10223978f, -0.06822120f, 0.01596626f, 
    -0.42296126f, -0.45112196f, -0.15968457f, 0.29956239f, 0.05319547f, 0.19877408f, 0.06700806f, 0.02296494f, 
    0.10078332f, -0.05740145f, -0.01461193f, -0.14693794f, -0.55367267f, -0.07263825f, -0.31963956f, -0.02998665f, 
    -0.15190199f, -0.11242689f, -0.00217001f, 0.08879837f, 0.01957333f, 0.02240664f, 0.13723433f, -0.00088595f, 
    -0.26188487f, -0.02438436f, -0.06146056f, -0.19645225f, -0.01002787f, -0.08878721f, 0.02579486f, -0.06388186f, 
    -0.22254393f, -0.07926210f, 0.05330526f, -0.10629135f, 0.03161824f, 0.06561822f, -0.04163710f, -0.15184669f, 
    -0.20282783f, -0.19465837f, 0.01793417f, -0.05542589f, -0.00586939f, -0.21424383f, 0.03747813f, 0.05064280f, 
    0.50026870f, 0.06287123f, 0.22228076f, 0.19973907f, 0.09599203f, 0.17814167f, 0.13670841f, -0.18991791f, 
    -0.02887409f, 0.02550425f, -0.08704305f, -0.13033542f, -0.76246858f, -0.53301650f, 0.16406253f, 0.11024575f, 
    -0.09798754f, -0.02246189f, -0.03583699f, -0.09403452f, 0.02996466f, -0.13005303f, -0.10725193f, 0.06020615f, 
    -0.20256475f, 0.09818857f, -0.11639158f, -0.16108441f, -0.16939512f, -0.08382241f, 0.11269194f, -0.04471155f, 
    -0.11784572f, 0.02769016f, 0.05416139f, 0.10511110f, -0.20509653f, 0.18640241f, 0.24014562f, 0.20069140f, 
    0.11247625f, 0.16161118f, -0.04729874f, -0.04885716f, 0.01697653f, 0.02585167f, -0.16906863f, -0.03258777f, 
    0.21046369f, 0.02219995f, 0.01150653f, 0.09277436f, -0.04781625f, 0.06553528f, -0.01717484f, 0.05497376f, 
    -0.06493995f, 0.07105482f, -0.18702632f, 0.07906266f, -0.02384400f, -0.55762953f, 0.19775091f, 0.15055315f, 
    -0.19615026f, -0.11339242f, -0.07830123f, 0.01032379f, 0.14588769f, -0.15371373f, -0.09964974f, 0.01230599f, 
    -0.42631230f, -0.01099630f, 0.14796856f, 0.08465628f, 0.05332633f, -0.01004307f, 0.01141078f, 0.09241289f, 
    0.01128708f, -0.11117399f, 0.06340013f, -0.01515193f, -0.16550666f, -0.24649662f, 0.04926968f, -0.07612605f, 
    -0.12142583f, 0.11871307f, -0.00593822f, 0.15446673f, 0.00968632f, 0.11861952f, -0.18025212f, 0.00260702f, 
    0.03808323f, -0.09874236f, -0.13764894f, 0.14636014f, -0.11367022f, -0.04980691f, -0.20351219f, 0.08233791f, 
    0.14331767f, 0.19306603f, -0.20214620f, -0.00000626f, -0.01479381f, -0.01868811f, 0.12210036f, 0.19392267f, 
    -0.12541665f, 0.03172765f, -0.00659626f, -0.13070342f, 0.06324750f, -0.00887485f, 0.04834241f, -0.15859981f, 
    0.15493691f, 0.07020973f, -0.09644462f, 0.34079024f, -0.14112115f, 0.02468619f, 0.15432268f, 0.00946279f, 
    -0.02942795f, 0.10534739f, 0.20405571f, -0.09724449f, -0.03775528f, -0.12916636f, -0.00550228f, 0.15733345f, 
    -0.20568395f, -0.03132475f, 0.05536473f, -0.10678276f, 0.02755666f, -0.23058532f, 0.01557914f, 0.05907071f, 
    0.08185223f, -0.15345548f, 0.25547814f, -0.15731002f, 0.01683639f, -0.09046301f, -0.01437786f, 0.08478158f, 
    0.08851913f, -0.01868783f, 0.08125181f, 0.16767144f, 0.04510295f, 0.26242188f, -0.29097810f, -0.06638676f, 
    -0.01556324f, 0.21351475f, 0.12860112f, 0.13272347f, -0.03235773f, -0.08292709f, 0.12924470f, 0.11908843f, 
    -0.22105277f, -0.29616833f, -0.26045346f, -0.02221077f, 0.07128952f, -0.11766203f, -0.07211822f, -0.07512647f, 
    -0.20522989f, -0.09678655f, -0.04329561f, 0.01587327f, -0.36714324f, 0.33259353f, -0.02432176f, -0.41223648f, 
    -0.02641148f, 0.21875961f, 0.03367318f, 0.07376882f, -0.03944720f, -0.12822701f, -0.12905730f, -0.22524047f, 
    0.23167402f, -0.04226492f, -0.03235618f, 0.06150733f, 0.05666364f, -0.05473015f, 0.12581213f, 0.06540998f, 
    0.05365205f, 0.09933970f, 0.00497121f, -0.19700326f, -0.25918677f, -0.31552669f, -0.00186089f, -0.11668484f, 
    -0.02433445f, 0.10005167f, -0.09473409f, -0.05474225f, -0.03173866f, -0.00979930f, -0.05634014f, -0.01394230f, 
    -0.56275266f, 0.21873599f, -0.09592868f, -0.25910795f, 0.01833907f, -0.07243394f, 0.03325520f, -0.06182000f, 
    0.20029758f, -0.01772403f, -0.04335437f, -0.02014355f, 0.23170321f, -0.02696994f, -0.23289084f, 0.15928572f, 
    0.08084237f, -0.09764118f, 0.06165222f, -0.05037897f, -0.21236315f, -0.09474949f, -0.07219668f, 0.08114100f, 
    0.00805598f, -0.26121482f, 0.11677439f, 0.28210840f, 0.01154329f, -0.11409222f, 0.02767984f, -0.06517478f, 
    -0.07716291f, 0.18741550f, 0.24279873f, 0.06772301f, -0.38049030f, 0.13456187f, 0.12363527f, -0.14375871f, 
    -0.05989039f, -0.04993904f, -0.00056163f, 0.17446156f, 0.02409316f, -0.08408494f, 0.06605586f, 0.06500117f, 
    0.09584624f, 0.16896895f, 0.14580373f, 0.12697513f, 0.06053283f, 0.10752298f, 0.05399115f, 0.04060435f, 
    0.07215421f, -0.04633890f, -0.05027410f, 0.04350834f, 0.43516493f, 0.50118655f, 0.02446699f, -0.08104569f, 
    -0.02044144f, -0.14344549f, 0.12315903f, -0.18921944f, -0.01811648f, -0.03803687f, -0.01744612f, -0.01879279f, 
    -0.55485570f, 0.07586616f, -0.10755730f, -0.03629972f, 0.02451536f, -0.06099508f, 0.21745715f, 0.25916591f, 
    -0.07336173f, -0.09229388f, -0.02128108f, -0.00472041f, 0.08415563f, -0.24454083f, -0.03635479f, 0.08422957f, 
    -0.14875254f, -0.08274111f, 0.12635942f, -0.08819353f, 0.12340645f, 0.06789722f, -0.09844293f, -0.11183992f, 
    0.11357786f, 0.31632122f, 0.21314374f, -0.00617838f, -0.01912716f, 0.04224477f, 0.03237996f, 0.04323901f, 
    -0.05702799f, 0.00232684f, 0.07423104f, -0.05567900f, -0.19630779f, -0.35490817f, 0.12703498f, -0.16730075f, 
    0.00555679f, -0.06318799f, 0.09908523f, 0.17223252f, -0.16848643f, -0.01456332f, 0.01325053f, 0.06442957f, 
    -0.41713816f, -0.02290540f, 0.26252082f, 0.02074190f, 0.09978750f, 0.10050622f, -0.16833736f, -0.00326056f, 
    0.12620820f, 0.02560434f, -0.02568495f, 0.00067286f, -0.35756019f, -0.21288414f, 0.10084324f, -0.18776980f, 
    -0.02962071f, 0.02853649f, 0.07196855f, -0.12784833f, 0.17424972f, 0.02811476f, 0.08953364f, -0.18589410f, 
    -0.72092223f, 0.01052442f, 0.08118153f, 0.22514544f, 0.03839614f, 0.09551902f, 0.13774218f, -0.02023018f, 
    -0.06644988f, 0.03673517f, 0.10763951f, 0.10194210f, -0.28886309f, 0.07780955f, 0.03168568f, 0.25769922f, 
    0.08139320f, -0.05327594f, -0.11365280f, 0.12123947f, -0.04010273f, -0.12045845f, -0.02251246f, 0.02108813f, 
    -0.32172617f, -0.21006052f, -0.28067264f, 0.07599059f, 0.08292687f, 0.02771099f, -0.09431704f, -0.04441186f, 
    -0.03107947f, -0.23786321f, -0.06069916f, 0.03494232f, -0.02832417f, 0.36325622f, -0.04547307f, 0.18147975f, 
    -0.13395476f, -0.07056560f, -0.13503213f, -0.10084847f, 0.10637759f, -0.22152671f, 0.07349395f, 0.08224591f, 
    -0.16440454f, -0.07297030f, 0.11323147f, 0.27155831f, -0.08120418f, -0.03841222f, 0.12195686f, 0.03229628f, 
    -0.02910496f, 0.10975483f, -0.01301343f, 0.05877329f, -0.41617951f, -0.10828961f, 0.25589705f, 0.17811875f, 
    0.09057133f, -0.16097267f, -0.20653823f, -0.15300772f, 0.19644901f, 0.15126476f, -0.15648198f, 0.03782334f, 
    0.16182755f, 0.17208301f, 0.07892304f, -0.09522324f, -0.14533316f, 0.02443630f, -0.00216672f, 0.14383700f, 
    -0.09588605f, 0.04458965f, -0.20611197f, 0.08603146f, 0.03772642f, 0.35331392f, -0.29795820f, 0.07332053f, 
    0.03725964f, 0.06078933f, -0.01314576f, 0.19663110f, -0.00938696f, -0.12750012f, 0.19266507f, -0.00813070f, 
    0.01851746f, -0.37618071f, -0.27121031f, -0.08214491f, 0.03180064f, 0.10496883f, 0.04877611f, -0.02516993f, 
    0.20239179f, -0.04778639f, -0.13127552f, 0.00646644f, 0.15394595f, -0.12681334f, 0.03250993f, -0.09392621f, 
    0.09912587f, -0.22464983f, 0.02453270f, -0.02389160f, 0.10383384f, -0.33206758f, 0.00534226f, -0.18599582f, 
    -0.00257111f, 0.03275896f, -0.07224230f, -0.03628763f, -0.13956958f, -0.15215014f, 0.06459802f, 0.00955683f, 
    0.02132710f, -0.09948782f, -0.05199644f, -0.00567094f, 0.16494451f, -0.22884962f, -0.07281982f, -0.22047298f, 
    -0.01488088f, -0.26001412f, 0.00113523f, 0.06977753f, -0.17598443f, 0.13863246f, 0.23717965f, 0.16887645f, 
    -0.23531590f, 0.05286058f, 0.23422794f, 0.12692350f, -0.10957573f, -0.12871888f, -0.13612700f, -0.16625203f, 
    0.01066092f, -0.09080779f, 0.14884244f, 0.24384536f, 0.06335528f, 0.05476493f, -0.16192080f, 0.08308271f, 
    0.07491595f, 0.00927347f, 0.06389548f, -0.26138234f, -0.04322521f, 0.10621506f, -0.42915660f, -0.02458450f, 
    -0.07117677f, 0.05996123f, -0.18080544f, 0.31885457f, 0.09641270f, 0.05875893f, 0.08225730f, 0.04916809f, 
    -0.03218740f, -0.06968896f, -0.00905923f, -0.32801753f, -0.19044442f, 0.36586136f, 0.22759320f, -0.19436719f, 
    -0.00464045f, -0.26766622f, -0.10774598f, -0.19302318f, 0.06987569f, -0.12272450f, 0.01976936f, -0.02242253f, 
    -0.20392120f, 0.19800143f, 0.05646177f, 0.19051161f, -0.00837181f, -0.02713073f, -0.06616759f, 0.05233833f, 
    0.18039027f, -0.15867256f, 0.11278868f, -0.20736785f, -0.19379811f, -0.21220659f, 0.32413006f, -0.02008087f, 
    -0.20911446f, -0.07609594f, -0.09957562f, -0.09512816f, -0.07073893f, 0.12506329f, 0.08955950f, 0.16271824f, 
    -0.01624672f, 0.07662872f, 0.19974582f, -0.37515113f, 0.16940641f, -0.03758228f, 0.02943258f, -0.04945749f, 
    0.13415968f, -0.03014270f, 0.01124626f, 0.06481921f, 0.21781400f, 0.02658282f, -0.11079258f, 0.12567216f, 
    0.11242140f, 0.00803314f, -0.12692623f, 0.02918628f, 0.03638082f, 0.05800540f, -0.06159463f, 0.02810980f, 
    -0.72987556f, 0.24678965f, -0.13171238f, -0.35260952f, 0.01865691f, 0.02918803f, -0.02746787f, 0.00775083f, 
    0.00061541f, 0.11365778f, 0.04029053f, -0.01221102f, -0.18367799f, -0.15002483f, -0.12022135f, -0.25177440f, 
    -0.16228949f, -0.23070489f, -0.05494361f, -0.02611590f, 0.06703058f, -0.01702056f, 0.15794036f, -0.08831578f, 
    0.01113638f, 0.00272722f, -0.06909536f, -0.22822377f, 0.01975503f, 0.08489246f, -0.18330021f, -0.22738895f, 
    -0.00936320f, -0.32482189f, -0.01730877f, -0.11902419f, -0.11751997f, 0.15618539f, 0.08113170f, 0.11773593f, 
    -0.01907631f, -0.12931156f, 0.01465092f, 0.06488829f, 0.03000718f, -0.09938034f, -0.18397541f, -0.07708387f, 
    0.27106223f, 0.12249220f, -0.09348980f, 0.08511350f, -0.09284629f, 0.02393746f, 0.00162271f, -0.07471617f, 
    0.08725248f, 0.07256934f, 0.18345052f, -0.09680007f, -0.03733384f, -0.25196460f, 0.27479842f, 0.48041141f, 
    -0.06386049f, -0.06334194f, 0.02461151f, 0.12134188f, 0.05419543f, 0.06336387f, -0.16669700f, -0.04303253f, 
    -0.87764829f, -0.21032754f, -0.19246218f, -0.25517792f, 0.17990994f, 0.03061590f, 0.08987290f, 0.10370588f, 
    0.11923204f, 0.04911435f, -0.20423909f, 0.08802563f, 0.02710140f, 0.06405345f, 0.12396823f, 0.14621447f, 
    -0.00974389f, -0.24819884f, -0.00903433f, -0.04902044f, 0.03468370f, -0.01102870f, 0.00108363f, -0.06027132f, 
    0.09091459f, 0.05148635f, 0.04693994f, 0.19373655f, -0.11376183f, 0.07998604f, 0.07984842f, -0.11042547f, 
    -0.01128069f, -0.04070687f, -0.00887905f, 0.37121916f, -0.12977532f, -0.06310347f, -0.04117880f, 0.20375271f, 
    0.10702433f, 0.04117658f, 0.15241425f, -0.02387024f, 0.05482483f, 0.01762321f, 0.09169358f, 0.20263527f, 
    0.09573676f, 0.04240501f, 0.09340367f, 0.30185711f, -0.15116450f, 0.02361591f, -0.05844166f, 0.01794343f, 
    -0.01098014f, -0.07651708f, 0.12033205f, 0.12121169f, 0.14054027f, 0.03592124f, 0.07810993f, 0.00144734f, 
    -0.09751110f, 0.02036145f, 0.02319375f, 0.06037313f, -0.14258549f, 0.06909078f, 0.16455577f, 0.17957155f, 
    -0.24688402f, 0.16923748f, -0.17609717f, -0.17603205f, 0.01780539f, 0.05566788f, -0.08070985f, -0.07216260f, 
    -0.00407753f, -0.13539621f, -0.00561356f, -0.17976820f, -0.39620113f, -0.03263710f, -0.25818786f, 0.00494377f, 
    0.13743103f, 0.25376964f, 0.06934839f, -0.19073941f, 0.13434292f, -0.03005170f, 0.06605347f, -0.14390349f, 
    0.13566612f, 0.01715062f, -0.18938032f, -0.16575864f, -0.00687232f, 0.11198357f, 0.05792052f, 0.08106600f, 
    -0.15616712f, 0.21138345f, 0.00719235f, 0.13606158f, -0.05205116f, 0.01843105f, 0.20592377f, -0.42159688f, 
    0.03907154f, -0.08613353f, 0.09996416f, 0.03284509f, -0.07379799f, 0.05348401f, 0.08820564f, -0.31225172f, 
    0.18307227f, -0.41281834f, -0.24860987f, 0.04464139f, 0.08992874f, 0.21761973f, -0.27407342f, -0.13521439f, 
    -0.03557170f, -0.04694522f, -0.00576482f, 0.01952019f, 0.12957174f, 0.19909671f, 0.12032263f, -0.15112275f, 
    -0.02366049f, 0.02839190f, 0.16247131f, 0.06980793f, -0.04469832f, 0.04155672f, 0.17007391f, 0.25176138f, 
    -0.02777436f, -0.00722679f, 0.03257747f, 0.33294958f, 0.12692557f, -0.03914982f, 0.19037190f, 0.03368706f, 
    -0.02964677f, -0.19836126f, 0.18463674f, -0.35591093f, -0.24989411f, 0.01984098f, 0.37516886f, 0.32535803f, 
    0.00027688f, -0.03221676f, 0.05696864f, -0.10956258f, 0.14230780f, 0.04802522f, -0.01905618f, 0.14090362f, 
    0.04054664f, 0.09440042f, -0.06655081f, -0.10841437f, 0.13783430f, -0.03523360f, -0.07439077f, -0.09063204f, 
    0.03767660f, 0.13012129f, 0.14698769f, 0.05371607f, -0.28732726f, 0.30869970f, 0.19091019f, 0.20086463f, 
    0.01715266f, 0.11433206f, -0.03909070f, 0.12378781f, -0.19503057f, 0.07440798f, 0.14666720f, 0.30457875f, 
    -0.56209940f, 0.26561540f, 0.07961530f, 0.15054461f, 0.09238173f, 0.05582806f, -0.26890612f, 0.03915519f, 
    -0.23427963f, 0.15740630f, 0.11948894f, -0.03591504f, 0.00483095f, 0.18823437f, 0.11937744f, -0.26651078f, 
    0.00647142f, 0.12331942f, 0.05849870f, 0.05563822f, -0.09039940f, -0.08961656f, -0.12003272f, -0.10498696f, 
    0.26298171f, -0.09128855f, -0.04685936f, 0.04772837f, 0.09232835f, 0.04611456f, -0.24304295f, -0.07325483f, 
    0.14169039f, -0.16991326f, -0.08566322f, -0.03673978f, -0.34734619f, -0.15552008f, 0.00059282f, -0.07355618f, 
    0.02096602f, 0.04179262f, 0.12976073f, 0.11503796f, -0.01861936f, -0.07482328f, 0.14604031f, 0.21080893f, 
    -0.16215295f, -0.22546637f, -0.28040695f, -0.09817928f, 0.02818692f, -0.11529808f, 0.07811475f, -0.15068316f, 
    -0.20789795f, 0.12262379f, 0.09215980f, 0.17967223f, -0.15914221f, -0.39331734f, 0.02895220f, -0.08683579f, 
    -0.03847384f, 0.05267251f, -0.01919204f, 0.10851143f, 0.03098583f, -0.11583108f, -0.04953663f, 0.08462922f, 
    0.22634630f, 0.18805467f, -0.17140587f, 0.28424737f, -0.19078933f, 0.23017560f, -0.13435097f, 0.10603973f, 
    -0.04660078f, 0.08681555f, -0.07199128f, -0.07676981f, 0.55985188f, -0.01925495f, 0.21018021f, 0.10741617f, 
    -0.03090307f, -0.07255827f, 0.10188872f, -0.03054245f, 0.15350761f, 0.01387739f, -0.21306005f, 0.05049285f, 
    0.15060788f, 0.16866341f, 0.26534316f, -0.38932982f, -0.29565307f, -0.01221493f, 0.00994039f, 0.14174780f, 
    -0.11763549f, 0.09632485f, 0.03984536f, -0.06602734f, -0.23534611f, 0.45880049f, 0.14789779f, 0.24262345f, 
    -0.08111892f, 0.13439102f, 0.02711586f, -0.00187462f, -0.00233917f, 0.00973572f, 0.15787727f, -0.05938873f, 
    0.55256987f, -0.33185607f, 0.08086336f, 0.04542314f, 0.08968038f, 0.01860396f, 0.04869598f, 0.07642030f, 
    0.07650226f, 0.02192341f, 0.04354232f, -0.15833791f, -0.08056405f, -0.07424091f, 0.10049131f, -0.31895819f, 
    -0.03343549f, 0.05058992f, 0.21566448f, 0.03330537f, 0.19097103f, -0.04905169f, -0.08476406f, 0.15758801f, 
    -0.29837415f, 0.15549120f, -0.41183344f, 0.18914592f, 0.19554614f, 0.14863157f, 0.02491751f, -0.11910696f, 
    0.10110447f, 0.19801292f, -0.03123636f, 0.12518732f, 0.27989209f, -0.55195069f, 0.12396719f, -0.23460595f, 
    0.08658317f, 0.03819342f, 0.18411513f, -0.04781059f, -0.12303969f, 0.04826492f, 0.28397432f, 0.23704585f, 
    -0.05854167f, -0.11709050f, 0.11849418f, -0.28794959f, 0.05261918f, -0.01489761f, 0.11566280f, 0.11083316f, 
    -0.07684552f, 0.15797131f, 0.03702011f, -0.10316952f, -0.00185098f, -0.40222132f, 0.02066479f, 0.06544366f, 
    0.08961141f, -0.01585814f, -0.00354370f, 0.06100149f, -0.01937908f, -0.01539987f, -0.03461324f, 0.15898420f, 
    -0.06073742f, 0.04777735f, -0.06131012f, -0.20351058f, 0.01048320f, -0.01401756f, 0.08944283f, -0.08479596f, 
    -0.06346524f, 0.00112503f, 0.09532921f, -0.03349489f, -0.22465999f, -0.40064311f, -0.38627261f, 0.37658420f, 
    0.21120970f, 0.13177846f, -0.02307335f, 0.09807064f, 0.01479117f, -0.17362009f, 0.04803126f, -0.01151876f, 
    -0.04285566f, 0.08647957f, 0.01169165f, -0.40291905f, -0.05278436f, -0.07608263f, -0.02918238f, 0.06899504f, 
    0.06149611f, -0.07996817f, 0.01637236f, -0.23372310f, 0.05421305f, -0.52066255f, -0.12798230f, -0.29928017f, 
    -0.06715007f, 0.08676307f, 0.00354554f, 0.04183492f, -0.06691851f, -0.16372430f, -0.05553511f, -0.16166726f, 
    0.24091621f, 0.15109289f, -0.01628486f, -0.53563416f, -0.01880296f, -0.09894660f, 0.06824046f, -0.04259752f, 
    -0.12138441f, 0.03821956f, -0.08638279f, -0.05615110f, -0.30070472f, 0.12110901f, 0.26546472f, 0.31838331f, 
    0.00232435f, -0.02524997f, 0.01936116f, -0.06497142f, 0.09066213f, -0.05632908f, -0.11883124f, -0.13867866f, 
    -0.01343807f, -0.57318985f, -0.20352578f, 0.03718565f, -0.06821687f, -0.01910511f, -0.05338154f, -0.10891575f, 
    0.02898215f, 0.04667551f, 0.05544870f, 0.29839814f, 0.04982439f, 0.05223925f, -0.00518589f, -0.38226172f, 
    -0.23184721f, 0.05323530f, -0.08740927f, -0.08638046f, -0.14824110f, 0.13847546f, -0.03785613f, 0.00070848f, 
    -0.11293919f, 0.07837660f, 0.20027381f, -0.05677512f, 0.06657510f, 0.00948373f, -0.03699099f, -0.05405677f, 
    0.11667475f, -0.19464108f, -0.19749016f, 0.09883615f, 0.03965673f, -0.13719527f, -0.01609210f, -0.25474983f, 
    0.13567694f, 0.05605188f, -0.03480293f, -0.03026598f, -0.13186958f, -0.03180043f, -0.05874474f, 0.05866750f, 
    -0.65513283f, -0.43468565f, -0.20740712f, 0.04773794f, 0.11254836f, -0.10761119f, 0.21329436f, -0.15160356f, 
    0.16364586f, 0.06300034f, -0.06642839f, 0.13463762f, 0.20697764f, 0.08938529f, -0.35780618f, -0.22828494f, 
    0.03649085f, 0.07958301f, 0.01807202f, 0.00067028f, -0.17365330f, -0.21568042f, -0.11745188f, -0.27662411f, 
    0.12735999f, 0.04203089f, -0.17337973f, -0.28504315f, -0.00999077f, -0.11153990f, -0.18674125f, -0.02732318f, 
    -0.05080096f, 0.15222578f, 0.03178787f, 0.27509135f, -0.00353878f, -0.03179747f, -0.14032301f, 0.00505739f, 
    -0.24587125f, -0.11472225f, 0.04062610f, 0.12895036f, 0.09716161f, 0.03956802f, 0.01458373f, -0.05378821f, 
    0.02970736f, 0.19993749f, -0.02531872f, 0.19055478f, -0.02358785f, 0.02823293f, 0.03074607f, 0.03995383f, 
    0.06169024f, 0.07581553f, -0.06078454f, 0.01001561f, -0.19280224f, -0.09318540f, -0.16293421f, -0.08732211f, 
    0.03182787f, 0.08622598f, -0.03375830f, -0.09123593f, -0.04069512f, -0.07033784f, 0.00444729f, -0.00418542f, 
    -0.43225297f, 0.01507220f, -0.20065089f, -0.23897871f, 0.12497486f, 0.00876323f, -0.02240238f, -0.00620235f, 
    -0.05802983f, 0.11677090f, 0.12450513f, 0.05664987f, 0.10227789f, 0.04548569f, -0.09115501f, -0.03127679f, 
    -0.09421033f, -0.00215117f, -0.11934533f, -0.05659768f, 0.01932214f, -0.10332824f, -0.05381756f, -0.11532774f, 
    0.03691009f, 0.32156929f, -0.04567739f, 0.19398810f, -0.02003634f, -0.12786469f, -0.15371165f, 0.05634052f, 
    -0.09646568f, 0.02659147f, -0.01925859f, -0.07455671f, 0.21465036f, 0.09228236f, -0.02270182f, 0.19574594f, 
    0.01530671f, -0.00094636f, -0.00722906f, 0.10515720f, -0.01427990f, -0.12721470f, 0.06140890f, 0.05965421f, 
    0.28037694f, 0.08732955f, 0.13823745f, 0.29052484f, 0.12660685f, -0.04567603f, 0.05325494f, -0.10906316f, 
    -0.16043158f, 0.11940681f, -0.04981428f, -0.08427666f, -0.09574413f, 0.09695549f, 0.10456430f, -0.29844505f, 
    -0.23725045f, 0.02744811f, 0.04464236f, -0.09439741f, -0.11483372f, -0.02235989f, -0.03767949f, 0.05196098f, 
    -0.36130983f, 0.05964400f, 0.00855411f, -0.13583304f, -0.10791274f, -0.10898100f, 0.06887174f, -0.04947795f, 
    -0.14976151f, 0.04752456f, 0.00806815f, 0.03472436f, -0.51912576f, 0.30452192f, -0.03881243f, 0.18953185f, 
    0.07082087f, -0.11223214f, 0.06351750f, 0.06917503f, -0.03275705f, 0.05117138f, 0.13372156f, -0.14590374f, 
    0.08439425f, 0.22436793f, -0.11918996f, -0.13229559f, -0.05724334f, 0.10531382f, 0.07376926f, -0.03955877f, 
    -0.04817365f, -0.12543191f, -0.08168132f, -0.16457801f, -0.40160584f, -0.13344483f, -0.11793751f, -0.36713162f, 
    -0.02196739f, -0.02564722f, -0.02161913f, -0.05381544f, 0.05906905f, -0.01842871f, -0.06811570f, -0.06602820f, 
    -0.05321650f, -0.15738253f, 0.19721429f, -0.18446015f, -0.01991692f, 0.03880700f, -0.02817422f, 0.03118046f, 
    -0.11718787f, 0.06776252f, -0.14789528f, -0.00009678f, -0.18398002f, 0.17571934f, -0.21069200f, -0.00207237f, 
    -0.08425678f, 0.06916232f, -0.07670382f, 0.02618000f, -0.11664048f, 0.04822756f, -0.12147684f, -0.09377082f, 
    0.02194693f, 0.17382322f, -0.05076945f, 0.15258805f, -0.01256705f, -0.02610257f, -0.00228440f, 0.02908341f, 
    -0.00954130f, 0.02770159f, -0.10871369f, -0.08697278f, 0.10234920f, 0.06386182f, -0.10894644f, -0.14009397f, 
    -0.06525330f, -0.04999946f, -0.06561160f, 0.02189121f, -0.03495408f, -0.03942265f, -0.00766621f, -0.00500219f, 
    0.06906724f, -0.31175217f, -0.01850319f, -0.18821022f, 0.09658363f, -0.04147900f, -0.02791126f, -0.03704441f, 
    -0.18360032f, 0.00835633f, -0.02035077f, -0.08551478f, 0.11048265f, -0.06607649f, 0.38224360f, 0.37557632f, 
    0.02273514f, -0.06938816f, -0.07935794f, 0.02916098f, -0.11838102f, -0.05157873f, 0.05519124f, -0.07381886f, 
    0.36305252f, 0.16368552f, 0.35578758f, 0.10487082f, 0.12471350f, 0.03814467f, -0.00309348f, -0.11624280f, 
    -0.07794651f, 0.04208837f, 0.07564522f, -0.11961759f, -0.02335078f, 0.24243227f, -0.09025372f, 0.15116726f, 
    -0.04635454f, -0.22806941f, -0.20229870f, -0.13708442f, -0.00533032f, -0.10224488f, 0.00621188f, -0.06672768f, 
    -0.58269495f, 0.14118066f, 0.01341374f, -0.10420570f, -0.16511428f, -0.12817365f, 0.02761989f, -0.03661627f, 
    -0.02619586f, 0.10666789f, -0.02138438f, -0.06116491f, 0.29800817f, -0.08819889f, 0.22325841f, 0.18470509f, 
    0.03008648f, -0.09816097f, -0.03336001f, -0.07489002f, -0.06982751f, 0.01433134f, -0.13191533f, -0.10757633f, 
    0.00091852f, 0.03875160f, -0.35408133f, 0.01564277f, -0.09724827f, -0.13130045f, -0.10134917f, -0.07402259f, 
    -0.10882761f, 0.09077520f, -0.07909752f, -0.06171039f, 0.00109366f, -0.23253432f, -0.26595202f, -0.21064517f, 
    0.05587306f, 0.00677418f, 0.06452335f, -0.03241621f, -0.05652224f, -0.09137664f, 0.01738998f, -0.01190032f, 
    -0.01302682f, 0.23380709f, 0.13497175f, 0.12256114f, 0.09418154f, 0.04287562f, 0.12807453f, -0.00831431f, 
    0.05735667f, -0.00313094f, 0.01147672f, -0.05805301f, -0.27262712f, 0.27387360f, 0.16387987f, 0.15478881f, 
    0.14038727f, 0.11360944f, -0.09141865f, -0.03219384f, -0.10624854f, -0.13651344f, 0.03462018f, -0.10590921f, 
    -0.39451316f, 0.12214319f, -0.36733210f, 0.09029866f, -0.04376864f, -0.07154172f, -0.02846983f, -0.00836748f, 
    0.00467936f, -0.08259472f, 0.03660138f, -0.02864989f, 0.08652205f, -0.31291458f, -0.00524719f, -0.24819717f, 
    -0.03575873f, -0.04111674f, -0.03666212f, -0.08664642f, -0.11616950f, 0.02747732f, -0.01776343f, 0.05427936f, 
    0.18653658f, 0.15296212f, 0.19853292f, 0.25135469f, 0.18751679f, 0.04660589f, 0.02200944f, -0.10701271f, 
    -0.04217461f, 0.09962369f, -0.04325282f, -0.06316955f, -0.07021691f, -0.28419232f, 0.00696678f, -0.03268281f, 
    -0.19293109f, -0.05099685f, -0.01445938f, -0.01330487f, 0.10695576f, 0.02819063f, 0.02154005f, -0.04512457f, 
    0.01641393f, 0.05025874f, 0.00235015f, 0.11167921f, 0.04628913f, -0.07014462f, -0.00040573f, -0.05389034f, 
    -0.01205764f, 0.13527608f, -0.06626128f, -0.02925153f, -0.18229870f, 0.12578653f, 0.03668722f, -0.01786052f, 
    -0.01340002f, -0.03788025f, 0.04038690f, 0.01826600f, 0.03162161f, 0.05850365f, 0.00259478f, -0.07646134f, 
    -0.14247879f, 0.23650260f, 0.01915490f, 0.07626073f, -0.17362408f, 0.01678285f, -0.10051893f, 0.03370428f, 
    0.02925024f, -0.13672486f, -0.04375150f, -0.01635929f, 0.19277717f, -0.00159789f, -0.17428719f, 0.10997993f, 
    0.19003367f, -0.02329580f, 0.01057752f, -0.08574557f, -0.11283407f, 0.04193928f, -0.04348304f, 0.00822353f, 
    0.05310021f, -0.07854026f, -0.17107633f, 0.15839104f, 0.12708426f, -0.01326630f, 0.03131009f, 0.08584288f, 
    0.04474509f, -0.15932581f, 0.18448137f, 0.03998544f, -0.37676015f, -0.34043667f, -0.24099335f, -0.06277721f, 
    -0.04751838f, -0.14319114f, 0.06788930f, 0.00846446f, 0.05433677f, 0.09166778f, 0.09042908f, -0.05564621f, 
    -0.09672308f, 0.11774707f, -0.28605065f, -0.30462593f, 0.03206441f, -0.02877988f, -0.16188005f, -0.08986817f, 
    0.16726571f, 0.04249873f, 0.17616050f, 0.11377271f, -0.32253495f, -0.01219670f, 0.11055942f, -0.07512730f, 
    -0.00788023f, 0.10335383f, -0.13786876f, -0.04445635f, -0.12424071f, -0.03353985f, -0.14738448f, -0.08112157f, 
    -0.11629549f, -0.32553327f, -0.24284773f, -0.38396409f, 0.03240232f, -0.07212278f, 0.07754955f, 0.03959947f, 
    0.01294958f, -0.23338282f, 0.01595636f, -0.18892351f, 0.11543988f, 0.02242157f, 0.29440987f, 0.10628641f, 
    0.08411483f, -0.17620730f, -0.03446577f, 0.00478097f, -0.01576351f, -0.06244743f, 0.06512957f, -0.13801983f, 
    0.08740726f, 0.28416130f, -0.13045280f, 0.03759231f, -0.16509333f, -0.07742485f, 0.05863786f, 0.17110312f, 
    0.14565864f, 0.07705601f, 0.10508064f, 0.02333238f, 0.24127573f, -0.46934199f, -0.27683905f, -0.08723325f, 
    0.17261016f, -0.05015297f, -0.23515655f, -0.01123859f, 0.18542524f, 0.08993100f, 0.08684563f, -0.01994690f, 
    0.29630125f, -0.13292605f, 0.06071338f, 0.27396333f, 0.04607958f, -0.10277771f, -0.03176194f, 0.00125460f, 
    -0.10842888f, -0.07740147f, 0.09765290f, 0.06308128f, 0.08499205f, -0.06032580f, -0.15467408f, 0.04594798f, 
    0.07468399f, -0.01476151f, -0.05728795f, 0.00358191f, -0.04670471f, -0.01855785f, -0.07044152f, 0.04910491f, 
    -0.18452118f, -0.06854872f, 0.01376349f, 0.02988738f, -0.18931781f, -0.09576657f, 0.03676321f, 0.07427678f, 
    0.00898357f, 0.00351092f, -0.14717576f, -0.00051451f, -0.07851347f, 0.13193683f, 0.11464510f, 0.00141454f, 
    0.05921399f, -0.07535408f, -0.00535571f, 0.00001568f, -0.02712572f, 0.06060798f, -0.05185857f, -0.14836422f, 
    -0.11288705f, 0.22680008f, -0.03382039f, 0.15428680f, -0.07880700f, 0.06200126f, -0.28460202f, -0.13358349f, 
    -0.03354039f, -0.26644811f, -0.01811093f, 0.21687600f, 0.26361161f, -0.12663724f, 0.16596714f, 0.01340211f, 
    0.00293883f, -0.11411861f, -0.07297129f, -0.31718209f, -0.01791176f, -0.09516018f, -0.19709131f, -0.08530787f, 
    -0.02983819f, -0.37039652f, 0.15367717f, -0.05190868f, 0.09386261f, -0.06559473f, -0.06160070f, -0.07100536f, 
    0.09433890f, -0.02106156f, -0.01094982f, -0.05283387f, -0.00336243f, -0.01120242f, -0.22708285f, -0.27765834f, 
    0.11980639f, -0.07458460f, -0.20566429f, -0.01623038f, 0.04254130f, -0.02052439f, -0.05590204f, -0.02011439f, 
    -0.20666824f, 0.00316286f, 0.11633895f, -0.18267888f, 0.00025659f, 0.05072561f, -0.07878712f, -0.13221133f, 
    0.01554887f, 0.01025181f, -0.13588427f, 0.19891724f, -0.00712800f, 0.55280304f, -0.25714573f, -0.32376236f, 
    -0.00602073f, -0.10380780f, -0.13271874f, 0.01787464f, 0.15661997f, 0.03628891f, -0.02309214f, 0.10922708f, 
    -0.07266594f, -0.08404493f, -0.03368952f, 0.30253637f, 0.07207478f, 0.07814836f, -0.08273167f, -0.04335069f, 
    0.05539376f, 0.02886148f, 0.21981595f, 0.04739814f, 0.01610849f, -0.18708876f, -0.02494528f, -0.33731645f, 
    0.02012684f, 0.03117257f, 0.20575924f, -0.19619067f, -0.01657826f, 0.00906376f, 0.00762554f, 0.13584609f, 
    -0.37363163f, 0.00071676f, -0.06341843f, 0.15837602f, 0.01464742f, 0.03091470f, 0.01344834f, -0.18375571f, 
    0.14854637f, 0.04178212f, 0.10712878f, -0.06765161f, 0.26073778f, -0.09904461f, -0.30679756f, 0.06113839f, 
    0.12842880f, 0.07921916f, -0.04378265f, -0.03268048f, -0.03314057f, 0.05624162f, 0.05967383f, 0.08178069f, 
    0.13014582f, -0.00365433f, 0.12603779f, 0.11514776f, -0.18241510f, -0.10420694f, 0.04873927f, 0.00613374f, 
    -0.06022103f, -0.08375349f, -0.16194560f, -0.09154839f, -0.16708325f, -0.08661144f, 0.31213516f, 0.13860188f, 
    -0.04379106f, 0.15598002f, -0.06940596f, -0.06526762f, 0.01967619f, 0.04178417f, 0.00794770f, -0.19445197f, 
    0.07682912f, -0.10171522f, -0.15878306f, -0.05993188f, -0.01863745f, 0.04065144f, -0.02573085f, -0.01896488f, 
    0.16083354f, 0.12473249f, 0.10892702f, 0.11301018f, 0.26399222f, -0.02251593f, -0.20495915f, 0.27706727f, 
    0.01960898f, -0.07624718f, 0.06886566f, 0.01709043f, -0.00781497f, 0.01177164f, -0.03792277f, -0.06681135f, 
    -0.21801682f, 0.17420100f, 0.11323443f, 0.04802186f, -0.14970866f, 0.20552611f, -0.19347276f, 0.01076571f, 
    -0.04096298f, -0.03227419f, 0.11410303f, -0.17985165f, -0.38345325f, 0.01339388f, -0.29906055f, -0.10300410f, 
    -0.21947946f, -0.00955282f, 0.03083920f, -0.11047807f, 0.11009255f, 0.02141185f, -0.08409365f, 0.03497297f, 
    -0.15828185f, -0.09349842f, -0.02321360f, -0.08791269f, 0.15256839f, -0.02411133f, -0.03120214f, 0.10709403f, 
    0.15909179f, -0.24976738f, 0.11849501f, -0.27311510f, 0.32644030f, 0.19102916f, -0.00120425f, 0.16468902f, 
    0.20901762f, -0.05165904f, -0.18991247f, -0.07138686f, 0.05546437f, -0.06144497f, 0.12353360f, -0.10890528f, 
    -0.56977457f, 0.44233117f, -0.03671829f, 0.34374422f, 0.12096959f, 0.12946914f, -0.16880041f, 0.15244561f, 
    -0.07528240f, 0.06153015f, -0.00117709f, 0.02086201f, -0.26003772f, 0.16461295f, 0.18072729f, -0.33531630f, 
    0.07491496f, 0.00782016f, -0.10831884f, -0.06326999f, 0.09363198f, 0.11423656f, 0.01450992f, 0.02635495f, 
    0.05274874f, 0.11234072f, 0.22614031f, -0.00100859f, 0.04325413f, 0.23335859f, -0.00336871f, -0.10801710f, 
    -0.14978859f, -0.25093585f, 0.03990540f, -0.04210431f, -0.23355491f, 0.02057941f, 0.02770574f, -0.12286030f, 
    -0.05288927f, -0.08947872f, -0.03053053f, 0.01536344f, 0.00032725f, 0.01809105f, -0.19336283f, -0.01699622f, 
    -0.31751215f, -0.06430682f, 0.19171606f, 0.03855347f, 0.02908872f, 0.04418555f, -0.05933629f, 0.22619708f, 
    -0.00438336f, -0.03517159f, -0.22255181f, -0.04365095f, 0.55958712f, -0.08853038f, -0.12659031f, -0.06783575f, 
    -0.07802261f, -0.01541687f, -0.08792245f, 0.05970054f, 0.00065319f, -0.12867761f, 0.16052228f, 0.04770410f, 
    0.07759899f, -0.03935465f, -0.05339815f, -0.17786828f, -0.01407090f, 0.00914233f, -0.06241211f, -0.16616286f, 
    -0.10770628f, 0.01804718f, 0.08547886f, 0.05360382f, -0.05682078f, 0.14849742f, -0.06085824f, 0.03538467f, 
    0.07242348f, -0.02705025f, -0.04722409f, -0.00809107f, -0.02955679f, 0.04470809f, 0.00644682f, 0.13287854f, 
    -0.04537983f, 0.13924120f, 0.43060386f, -0.06980536f, 0.12595615f, 0.16103886f, 0.15974437f, -0.21445180f, 
    -0.04656012f, -0.00820540f, 0.13306141f, 0.15635826f, -0.13094078f, 0.10434642f, -0.01914215f, -0.03981340f, 
    -0.11624652f, -0.02986611f, 0.01216165f, 0.09205651f, -0.09823330f, -0.14507265f, -0.04027117f, -0.21256804f, 
    -0.47576028f, 0.04177921f, -0.09289350f, -0.00507764f, 0.22201742f, -0.07811107f, -0.06341958f, -0.21069071f, 
    -0.08841988f, -0.01964404f, -0.02097923f, -0.06462539f, 0.07975522f, 0.18506500f, 0.13064682f, -0.23112264f, 
    0.01573427f, 0.03748874f, 0.08051138f, -0.14286521f, 0.08510264f, -0.01471581f, -0.07962719f, -0.00697581f, 
    -0.01346526f, 0.22399470f, -0.17736070f, 0.33381510f, 0.01228513f, 0.03401325f, 0.00902060f, -0.01538358f, 
    -0.01059384f, -0.01295301f, -0.08608025f, 0.12137272f, -0.48952070f, 0.62329495f, -0.07595144f, 0.09107926f, 
    0.07690250f, 0.09232126f, 0.04637421f, 0.00791315f, 0.08311314f, 0.09669743f, 0.16007456f, 0.07235824f, 
    -0.03621059f, -0.11926594f, 0.24888477f, -0.09216889f, -0.21221541f, 0.09339146f, 0.04129496f, 0.32898223f, 
    0.02463617f, 0.11854903f, -0.13425501f, 0.04088524f, 0.54477543f, 0.23030861f, -0.12441222f, -0.08092668f, 
    0.14864139f, -0.00390844f, -0.14783159f, -0.03139830f, 0.02775383f, 0.10743035f, 0.08251546f, 0.17388900f, 
    0.19100426f, -0.25765720f, -0.00508099f, 0.08477066f, -0.06392112f, 0.00328105f, -0.03273461f, 0.02229296f, 
    0.02591010f, -0.12900473f, 0.01666876f, 0.02456219f, -0.07604329f, -0.80696279f, -0.17911962f, -0.15063697f, 
    -0.00830539f, 0.01212403f, -0.04328787f, 0.06322278f, -0.08338308f, -0.04950362f, 0.31576803f, -0.02079316f, 
    -0.01914845f, -0.50094700f, -0.20662342f, 0.17969938f, -0.11510255f, 0.05929876f, -0.00421851f, -0.00120234f, 
    -0.08992513f, 0.10272030f, 0.00425916f, -0.19699785f, -0.07182541f, -0.12833251f, 0.19785845f, 0.03973583f, 
    -0.04404526f, 0.20050842f, -0.00593801f, -0.00824076f, -0.11004911f, -0.11708941f, -0.07430084f, -0.00235681f, 
    -0.37445661f, 0.37798133f, -0.22558999f, -0.53819609f, 0.21775354f, -0.00371136f, -0.17368895f, 0.10135127f, 
    -0.09751984f, -0.05025697f, -0.10339534f, -0.19963732f, 0.00722837f, 0.15839797f, -0.09473766f, 0.00226462f, 
    0.09937868f, -0.02822988f, -0.19140233f, 0.06435493f, -0.06505009f, -0.16739948f, -0.00729291f, 0.06524599f, 
    -0.01932698f, 0.25857079f, -0.17231804f, -0.66918564f, -0.06505588f, 0.07307576f, 0.07702785f, 0.08163811f, 
    -0.10490067f, -0.07380100f, -0.05622861f, 0.01181894f, 0.27687874f, -0.10733837f, 0.25203300f, 0.16839093f, 
    0.19142109f, 0.01586349f, -0.08700544f, -0.01900641f, 0.02844322f, 0.00645279f, -0.02434432f, -0.02865368f, 
    -0.29548204f, -0.30319947f, 0.07854366f, 0.01450761f, 0.13871586f, -0.01221613f, -0.11574761f, 0.00719785f, 
    0.05082763f, 0.03019423f, -0.03379846f, -0.06229330f, -0.37502286f, -0.44482586f, -0.00540310f, -0.20712626f, 
    0.16229254f, -0.18651755f, 0.02314770f, -0.04748704f, 0.08749448f, 0.06681027f, 0.06778820f, 0.15443404f, 
    0.00861030f, 0.58936834f, 0.05287612f, -0.43185952f, -0.07736225f, -0.18987393f, 0.09256526f, -0.02448734f, 
    -0.03589264f, 0.07688624f, -0.09915857f, -0.26077384f, 0.06094912f, -0.00960237f, -0.20210259f, -0.29193240f, 
    -0.07077040f, 0.23010111f, 0.03585257f, 0.01146135f, -0.05482668f, -0.10740673f, -0.05451752f, 0.04996416f, 
    0.16645439f, -0.46072644f, 0.08584908f, 0.11412474f, -0.07694370f, 0.00637884f, 0.02457727f, 0.34873873f, 
    -0.22640854f, 0.11591624f, 0.00080481f, 0.04997723f, -0.27262884f, 0.14126703f, -0.13268669f, -0.10159019f, 
    -0.03483713f, 0.10166549f, 0.01550426f, 0.04871939f, 0.10207709f, 0.03025880f, 0.13060205f, -0.13622509f, 
    -0.16489373f, -0.13445243f, 0.01562009f, -0.03322712f, 0.08042150f, 0.10157556f, -0.00824490f, -0.04715082f, 
    0.04028590f, 0.00996900f, 0.06207220f, 0.18278132f, 0.02245419f, 0.21211711f, -0.35646987f, -0.44038987f, 
    0.14051081f, 0.02009846f, -0.09913576f, 0.18676415f, 0.03628486f, -0.00011149f, -0.13534354f, -0.02419472f, 
    0.08697602f, -0.01069589f, -0.07996991f, 0.06394462f, -0.29648057f, -0.02567518f, 0.11670956f, 0.11385769f, 
    0.17216644f, -0.22431663f, 0.01964025f, -0.08056614f, -0.46572411f, -0.55413377f, -0.21799137f, 0.00289739f, 
    -0.03223374f, 0.20106554f, 0.02590383f, -0.11121771f, 0.13111974f, -0.12023045f, -0.12173270f, -0.03789484f, 
    -0.39561495f, -0.25595722f, -0.09112605f, 0.08771869f, 0.09138752f, 0.13114145f, 0.13116780f, 0.15148443f, 
    0.15116189f, 0.15101390f, -0.00717517f, 0.13390344f, 0.08098795f, 0.04766797f, 0.12067798f, 0.00122632f, 
    -0.01863801f, 0.11323289f, 0.04761685f, 0.15349211f, 0.05664948f, 0.29628769f, 0.11816005f, 0.11023536f, 
    0.18507181f, -0.26700103f, -0.09986247f, -0.20173259f, 0.04075641f, -0.00688089f, 0.16389284f, -0.17572880f, 
    -0.00408543f, 0.19490947f, 0.12330395f, 0.14251688f, 0.11594501f, -0.01931817f, 0.13741420f, -0.25506049f, 
    0.06714210f, -0.04958275f, -0.05793060f, -0.01501577f, 0.07121173f, -0.01736244f, -0.03983823f, -0.01509808f, 
    0.01782774f, 0.23164563f, -0.04949635f, 0.14780287f, 0.09795697f, -0.05393640f, -0.04687189f, -0.06100756f, 
    0.06120123f, -0.10868542f, -0.19358814f, -0.23516452f, 0.23919873f, -0.05946496f, -0.04349337f, -0.00257121f, 
    -0.01463112f, -0.22567441f, -0.13887922f, 0.18727137f, -0.08066081f, -0.06315837f, -0.08199937f, -0.06496175f, 
    -0.30676529f, -0.41488436f, -0.04413200f, 0.14486730f, 0.07074282f, -0.00418818f, 0.13186879f, 0.23289564f, 
    0.08398777f, 0.14572255f, 0.08252200f, -0.02208410f, -0.55667537f, -0.18595402f, -0.16539250f, 0.02147968f, 
    0.08995946f, -0.06258140f, -0.11013702f, -0.04654395f, 0.09772794f, 0.08980837f, 0.14301194f, -0.07043981f, 
    -0.82406288f, -0.39493695f, -0.34183678f, -0.29609582f, 0.05604999f, 0.01423717f, -0.22880700f, -0.02464028f, 
    -0.08630306f, -0.04925936f, 0.01270160f, -0.01474428f, -0.80701268f, -0.29019552f, -0.05252805f, 0.17443481f, 
    0.27913150f, -0.06945969f, 0.07710834f, -0.05799842f, -0.00178515f, -0.04857032f, 0.02358021f, 0.27012214f, 
    0.43794224f, -0.05258805f, -0.02516265f, 0.22877508f, -0.08957435f, -0.22612263f, 0.01618149f, 0.09907512f, 
    -0.00379038f, -0.12445485f, -0.03618901f, 0.02317413f, -0.26030806f, -0.43870506f, 0.05185051f, 0.14587753f, 
    0.08630414f, -0.08774882f, 0.10855492f, 0.03620404f, 0.01503766f, -0.01165350f, -0.12652890f, 0.05815779f, 
    -0.17687908f, 0.11695021f, 0.01182324f, 0.09712728f, -0.06289783f, -0.07803116f, -0.10947551f, -0.26509982f, 
    -0.09392409f, -0.23213440f, -0.00019678f, -0.06573726f, -0.11639908f, -0.04144589f, -0.13447703f, -0.05282428f, 
    0.01680832f, 0.09921201f, -0.05139501f, -0.04642041f, 0.06612174f, -0.08660948f, -0.01934793f, 0.05384888f, 
    -0.00315456f, 0.11534999f, -0.05991081f, -0.06742895f, 0.05293544f, -0.16354236f, -0.01515244f, 0.02849628f, 
    0.13478388f, -0.16417286f, 0.13826258f, 0.09291822f, -0.17901282f, 0.13228358f, -0.21137066f, -0.12318330f, 
    0.03373403f, 0.09303650f, -0.11916538f, -0.08848368f, 0.13843036f, 0.04002645f, -0.30620971f, 0.02799093f, 
    0.08831661f, -0.09080990f, 0.04583109f, -0.18970740f, -0.10555658f, 0.05894658f, -0.14142139f, 0.02944956f, 
    0.00687371f, 0.01518041f, -0.04903699f, -0.03314328f, -0.17438518f, 0.04780034f, 0.17134356f, 0.00538650f, 
    0.11391973f, 0.07605029f, 0.04119629f, -0.04463961f, 0.01996510f, 0.08267736f, 0.06504101f, 0.10829538f, 
    -0.60788423f, -0.28272259f, -0.29197827f, -0.36908248f, 0.05720096f, -0.04695599f, -0.02883765f, 0.02043012f, 
    0.09583975f, 0.05756411f, 0.10065065f, 0.10383625f, 0.09881201f, 0.22043934f, -0.08216716f, 0.01510028f, 
    0.07857213f, 0.15035826f, 0.13001639f, -0.10454102f, 0.03936939f, 0.14609821f, 0.03546739f, -0.05389775f, 
    -0.08005381f, 0.12272447f, 0.13900481f, 0.07794185f, 0.15786573f, -0.09229754f, -0.05663970f, -0.10467885f, 
    0.00294147f, 0.11632071f, 0.00431747f, 0.07503548f, -0.82337141f, -0.30687314f, 0.26581892f, 0.22758609f, 
    0.18493940f, 0.09503643f, -0.11035126f, -0.03433870f, 0.03383949f, -0.02211628f, -0.09582341f, 0.16171506f, 
    0.32418740f, 0.12853436f, -0.09608781f, -0.04638768f, -0.34979814f, -0.15534534f, 0.02629175f, 0.01070249f, 
    0.11963843f, -0.03785178f, -0.14655012f, -0.10541696f, 0.14713879f, 0.17047040f, -0.14317706f, 0.10381673f, 
    -0.08378229f, -0.05986495f, 0.02156075f, -0.01403265f, 0.15976061f, 0.16528171f, 0.00968644f, -0.10522636f, 
    0.11028798f, -0.03542846f, -0.17437653f, -0.25138411f, 0.21377596f, 0.00655847f, -0.04799062f, 0.15898027f, 
    0.09103355f, 0.11711437f, 0.07167321f, 0.09668065f, -0.06148523f, 0.07431126f, 0.00883731f, -0.08279752f, 
    0.00534225f, 0.13009310f, 0.07403205f, 0.13949071f, 0.16421773f, 0.17333233f, 0.20097345f, 0.09301733f, 
    0.13914362f, 0.10975157f, 0.09897823f, -0.10157079f, -0.16419545f, 0.09679103f, -0.11916268f, -0.09209569f, 
    -0.05998053f, -0.08639827f, 0.09021374f, -0.15385810f, 0.48048773f, 0.12817374f, -0.10354571f, 0.00882599f, 
    -0.04661344f, -0.06777769f, 0.10551105f, 0.04613591f, -0.00734187f, -0.04786495f, 0.05643789f, 0.04794842f, 
    0.13228159f, 0.35835576f, 0.06145188f, -0.00859910f, 0.03670736f, 0.02014751f, 0.02455891f, -0.03235437f, 
    0.04313245f, -0.14801383f, 0.22053456f, -0.29943913f, -0.59554332f, -0.11977053f, -0.18352784f, -0.44879976f, 
    0.19822997f, 0.06210994f, -0.06372241f, -0.01837499f, -0.02966265f, -0.08352187f, -0.00910239f, -0.04676493f, 
    0.06194918f, -0.29777983f, -0.32416973f, 0.09789173f, 0.02871380f, -0.03411943f, 0.15814397f, -0.11814286f, 
    -0.07680902f, 0.17413071f, 0.10449794f, -0.01512002f, 0.02455399f, 0.17649232f, -0.20100242f, -0.15947808f, 
    0.11025143f, -0.01563683f, -0.07731415f, -0.02079017f, 0.05131492f, 0.13090505f, 0.17557724f, -0.01821364f, 
    0.46694273f, 0.12007952f, -0.08652393f, 0.11945606f, -0.10100579f, 0.03698352f, 0.06090343f, 0.06571069f, 
    -0.04799479f, -0.02914851f, -0.01417118f, -0.05041648f, -0.11429650f, 0.35267022f, -0.08446091f, 0.09602093f, 
    0.20382124f, -0.01584843f, -0.02225934f, -0.11536685f, -0.02292178f, -0.05852163f, -0.16382973f, -0.05590361f, 
    0.02968382f, 0.03668611f, -0.17847908f, 0.03314148f, 0.14996494f, 0.03758058f, -0.06290916f, 0.08091325f, 
    0.01589361f, 0.00005501f, -0.15902278f, -0.00296463f, -0.52970654f, 0.28651458f, -0.03255527f, -0.10185352f, 
    0.00620409f, 0.00985620f, -0.03502092f, 0.08610073f, -0.01706846f, -0.15217839f, 0.13786082f, -0.02491332f, 
    0.30140701f, -0.19784515f, -0.03542140f, 0.02815410f, -0.27814209f, -0.02989648f, -0.08662260f, -0.11581904f, 
    0.26275507f, 0.07904479f, 0.05840528f, 0.06533792f, 0.06422285f, -0.22510442f, 0.13393919f, -0.21741393f, 
    0.06448283f, -0.03170776f, 0.21489991f, -0.05282607f, -0.07785790f, -0.05417110f, -0.06908944f, 0.04268917f, 
    0.22446844f, -0.32116565f, -0.15008844f, -0.00293685f, 0.13746640f, -0.02236130f, -0.14443125f, 0.03730183f, 
    0.03076533f, -0.07157581f, -0.13108328f, -0.00163581f, -0.07762014f, -0.23902604f, -0.08139110f, 0.19044214f, 
    -0.08816270f, -0.10878617f, 0.01042948f, -0.01830868f, -0.09406841f, -0.21183772f, -0.08176828f, 0.04260674f, 
    -0.48202896f, 0.02767554f, -0.25400379f, -0.28928483f, 0.05916261f, -0.00419085f, 0.01147243f, 0.05760520f, 
    -0.01708135f, -0.01642966f, -0.17377120f, 0.01852869f, 0.43891603f, -0.03912871f, 0.05180242f, -0.39040056f, 
    0.07111889f, 0.04970676f, -0.12452853f, 0.10006046f, -0.00698144f, 0.03013001f, -0.04906143f, 0.10022313f, 
    0.05223324f, -0.02841637f, 0.09870492f, 0.00132665f, -0.02159738f, -0.04108443f, 0.03170802f, -0.01517980f, 
    -0.04508247f, 0.05468458f, 0.06204554f, 0.05551019f, -0.06787601f, 0.08232601f, -0.12128673f, 0.06503694f, 
    0.14086263f, -0.06106138f, 0.00529997f, 0.07908902f, 0.10241272f, 0.13216670f, 0.10736439f, 0.08747143f, 
    0.13521248f, -0.24075732f, -0.08113945f, -0.09163260f, -0.21240224f, 0.00596836f, -0.04366436f, -0.09269167f, 
    0.05333579f, 0.06387063f, -0.13911183f, -0.02204416f, -0.58194906f, -0.30839792f, -0.02067358f, -0.19810840f, 
    0.09774155f, -0.03170719f, 0.05676151f, 0.09848683f, -0.07945973f, 0.02204419f, -0.06259207f, -0.10961995f, 
    -0.38847262f, 0.22162539f, 0.01065820f, -0.16269283f, -0.12501927f, 0.00573119f, -0.03847474f, 0.14932279f, 
    -0.03246773f, -0.04836471f, -0.04638948f, 0.12328397f, -0.34454003f, -0.06584127f, 0.07299937f, 0.32701316f, 
    0.01238777f, -0.01753455f, -0.04393651f, 0.07127673f, 0.00240082f, -0.04979889f, 0.12444724f, 0.05090962f, 
    -0.24911159f, 0.25318795f, 0.07798452f, -0.04182082f, -0.07095194f, -0.05990027f, -0.05134347f, -0.26752970f, 
    -0.05179338f, 0.06993010f, 0.04265747f, -0.15231116f, 0.07660617f, 0.28270507f, -0.20332029f, 0.03003147f, 
    0.03376583f, 0.01094009f, -0.14638399f, -0.22205749f, 0.00256563f, 0.11461935f, -0.00726533f, 0.02657312f, 
    0.40725321f, -0.39309892f, -0.04540981f, -0.07866368f, 0.01991589f, -0.12668705f, -0.03713373f, -0.14316407f, 
    -0.04526208f, 0.12266360f, -0.00419791f, -0.12199619f, -0.01288804f, -0.04412461f, -0.09825079f, 0.15777123f, 
    -0.19815117f, 0.04745473f, -0.10681137f, 0.05102545f, -0.02585078f, -0.06180669f, 0.08957450f, -0.18226683f, 
    0.49777964f, -0.22631516f, -0.28664422f, -0.01783684f, 0.15648821f, -0.13339877f, 0.11111346f, 0.04503134f, 
    0.02027893f, 0.10205580f, 0.07703404f, 0.16094916f, 0.58934098f, 0.22431198f, 0.08905686f, 0.10673989f, 
    0.01095697f, -0.01271444f, 0.03304170f, 0.02586419f, 0.04626402f, 0.03627000f, -0.00994534f, 0.11672066f, 
    -0.30354157f, -0.23590660f, -0.05701720f, 0.08474908f, 0.03103018f, 0.13022417f, -0.02834480f, 0.02607903f, 
    -0.12435165f, -0.05143837f, 0.10196122f, -0.08387354f, 0.35608938f, -0.14196998f, 0.01742956f, -0.05911929f, 
    -0.17106266f, -0.10832706f, 0.01343635f, 0.08486909f, -0.09960197f, -0.11111338f, -0.09122424f, -0.07461975f, 
    0.31237900f, -0.05390573f, -0.11171361f, 0.53389800f, 0.09667932f, 0.08954902f, -0.03868898f, 0.02969725f, 
    0.10796267f, -0.00652695f, 0.01604903f, -0.11158035f, -0.06902395f, 0.03772804f, -0.26503524f, -0.09130307f, 
    0.06715420f, -0.05579026f, 0.08684347f, 0.02315538f, -0.09530731f, -0.11684871f, -0.08472709f, 0.09068953f, 
    -0.24310720f, 0.26201805f, -0.12845069f, 0.05785197f, -0.14987108f, -0.07036668f, 0.07871912f, -0.19940852f, 
    0.09812082f, -0.01845121f, 0.00959399f, -0.18020894f, 0.00787792f, 0.05259975f, -0.19557275f, 0.13617672f, 
    0.06656352f, -0.04426229f, 0.08351272f, 0.19474044f, -0.10988855f, -0.03463255f, 0.01742906f, -0.03440871f, 
    0.07062669f, -0.03096991f, -0.01022408f, 0.08721836f, -0.08567653f, 0.21770933f, 0.12985790f, -0.16303726f, 
    0.16909848f, 0.09056029f, -0.09416741f, -0.03305494f, 0.00891551f, -0.58001631f, -0.16545352f, 0.01156288f, 
    -0.00050935f, -0.00946249f, 0.04629567f, -0.08456860f, -0.11392020f, 0.23258056f, 0.05063198f, 0.01842664f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12438130f, 0.09813757f, -0.04703437f, -0.00020357f, 0.03757765f, -0.02273121f, -0.04742977f, -0.04437675f, 
    -0.04797709f, 0.03875094f, 0.09704196f, 0.02776339f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
