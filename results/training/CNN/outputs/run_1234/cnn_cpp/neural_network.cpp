#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85781229f, -0.82703072f, -0.12914327f, 0.43008226f, -0.12947236f, -0.20495673f, 0.05262559f, -0.11193331f, 
    -0.42067748f, 0.46067646f, 0.50838810f, 0.16655405f, -0.03712384f, 0.17651524f, 0.29364824f, -0.01317301f, 
    0.19990778f, -0.26608613f, -0.09670326f, -0.01761318f, 0.40021911f, 0.51066589f, -0.80154181f, -0.68080050f, 
    -0.23826078f, -0.13882768f, -0.30426279f, 0.25384077f, -0.16454180f, -0.47504371f, -0.62177777f, -0.48022965f, 
    -0.60803366f, -0.33142394f, -0.15742405f, -0.06264932f, -0.06299245f, -0.28882721f, 0.51584214f, -0.48355350f, 
    0.02421432f, -0.43620282f, -0.19684187f, 0.62166542f, -0.23241781f, 0.43578538f, 0.69181728f, 0.29198694f, 
    -0.74806392f, -0.42852369f, -0.18469232f, -0.04227225f, 0.53636521f, -0.14946502f, -0.77698034f, 0.22736439f, 
    0.28269148f, -0.41527137f, -0.40211791f, 0.86827135f, 0.22606446f, -0.31674725f, -0.26070565f, -0.29001263f, 
    -0.19257046f, 0.21001686f, -0.24012770f, -0.60774243f, -0.37314847f, 0.31807655f, 0.56894487f, 0.44960099f, 
    -0.35420382f, -0.33466542f, 0.55303389f, -0.45260933f, 0.37896502f, 0.47513261f, -0.30709723f, 0.04039091f, 
    0.23419689f, 0.29013011f, 0.38913614f, 0.23828490f, 0.10544462f, 0.37673256f, -0.34001136f, 0.48270795f, 
    -0.44164145f, -0.14783625f, 0.34782124f, -0.41022497f, 0.65031940f, -0.29214984f, -0.21064314f, 0.07691024f, 
    -0.44939721f, 0.25694680f, 0.25455213f, -0.53035885f, -0.37432989f, -0.05155584f, 0.21396273f, 0.20756291f, 
    -0.56314164f, 0.24460472f, -0.26476219f, 0.51653808f, 0.48997685f, 0.14549248f, -0.47523066f, 0.17959099f, 
    -0.52669531f, 0.14294207f, -0.43000996f, -0.31958491f, -0.20955633f, 0.33396238f, -0.42242995f, -0.27182293f, 
    0.29726356f, 0.45665723f, -0.37143773f, 0.53436130f, -0.18316294f, -0.08847483f, 0.66764766f, 0.42786095f, 
    0.07311064f, 0.02389480f, 0.24368447f, -0.60586494f, -0.19488341f, 0.14977744f, 0.21421988f, -0.76536351f, 
    0.42649356f, -0.26140833f, -0.01625366f, 0.98147881f, -0.50610381f, -0.11155887f, 0.22493982f, 0.04685127f, 
    -0.63175410f, -0.44366172f, -0.37879992f, 0.49556303f, 0.07264721f, -0.12149482f, -0.18710485f, -0.36107126f, 
    -0.34680435f, -0.29832539f, 0.48498949f, 0.05465450f, 0.17576101f, 0.30068320f, -0.73569864f, -0.00756175f, 
    0.04166607f, 0.21751371f, -0.17956716f, 0.61829597f, 0.50200522f, -0.30979255f, -0.22661437f, 0.39177060f, 
    -0.13886005f, -0.36971268f, -0.26214221f, 0.10507229f, 0.33735609f, -0.21581091f, 0.04053696f, 0.45328751f, 
    -0.32815781f, -0.08347858f, -0.32344010f, 0.24447271f, -0.50313497f, -0.50876552f, -0.03942444f, 0.02504784f, 
    -0.09590685f, -0.47387961f, -0.12219315f, -0.31654367f, 0.02734432f, 0.12315692f, -0.23557201f, 0.12773252f, 
    -0.13550004f, 0.30397621f, 0.44120196f, 0.16415234f, 0.11798903f, 0.58876199f, -0.08826806f, 0.82400930f, 
    -0.25144923f, -0.04268282f, 0.15109026f, -0.02870491f, -0.17543238f, -0.46620432f, 0.67629582f, 0.67811459f, 
    -0.31943998f, -0.59273380f, 0.45265061f, 0.54119557f, 0.67659366f, -0.33968177f, -0.12940897f, 0.08005486f, 
    -0.64452505f, 0.76117730f, -0.38448259f, 0.28519055f, -0.60428309f, 0.76049054f, -0.19718583f, -0.16652955f, 
    -0.10646337f, -0.06255165f, -0.39968553f, -0.67171621f, 0.44661868f, 0.37198141f, 0.37627870f, 0.23003720f, 
    0.21135728f, 0.04891171f, -0.41093996f, -0.35592335f, -0.41969848f, -0.39573285f, -0.15387082f, -0.10327826f, 
    0.51273692f, -0.23316425f, 0.21272996f, -0.89987367f, 0.66666204f, 0.12910874f, -0.12527002f, -0.20622039f, 
    -0.06584185f, -0.25691679f, 0.56138611f, -0.39745826f, 0.44293648f, -0.02931188f, 0.53167629f, -0.14567487f, 
    -0.17066713f, 0.43001008f, 0.56809396f, -0.05346360f, -0.26716298f, -0.59820265f, -0.59928721f, -0.01752714f, 
    0.34552509f, 0.57206911f, 0.41115206f, -0.20686020f, -0.37007400f, -0.30772695f, -0.48091203f, -0.46162611f, 
    0.26757395f, 0.60137230f, 0.08889233f, -0.60694546f, -0.10594938f, -0.15744972f, -0.34611276f, -0.31480587f, 
    -0.37660572f, -0.57719886f, 0.94693130f, -0.20322742f, 0.19209057f, 0.05746802f, 0.04984207f, 0.05734718f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04876230f, 0.05585439f, 0.00249843f, -0.07043326f, 0.41103131f, -0.15164182f, -0.10782769f, -0.13862854f, 
    0.27904490f, 0.09490356f, 0.00494859f, 0.23147538f, 0.09038198f, 0.27837160f, 0.47042120f, -0.14829609f, 
    0.17475839f, 0.07047760f, 0.03713866f, 0.24992837f, -0.44498482f, 0.05968162f, -0.40889356f, 0.08824306f, 
    -0.03819058f, 0.26405296f, -0.02619677f, -0.11487304f, 0.04840922f, -0.33431482f, 0.44754338f, 0.00733053f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13984989f, -0.06481973f, 0.10429038f, 0.11368211f, -0.03823357f, 0.18003361f, -0.05050519f, 0.00479575f, 
    0.04692723f, 0.18332916f, -0.06201326f, 0.19928427f, 0.08961084f, 0.06979555f, -0.01608430f, 0.09496359f, 
    0.02981794f, -0.04191693f, 0.15696286f, -0.20192069f, 0.01820306f, -0.15011449f, -0.08123671f, -0.04885869f, 
    -0.09885004f, 0.00898643f, 0.11319747f, -0.08151826f, 0.05424152f, -0.04220112f, -0.01655788f, -0.28563064f, 
    0.04764262f, -0.11146488f, 0.01636618f, 0.09304290f, -0.09783446f, -0.00160917f, -0.10706594f, -0.15158746f, 
    0.02136337f, 0.00600955f, -0.01000885f, -0.01824261f, 0.06465595f, 0.25921202f, 0.13741073f, 0.16487832f, 
    -0.11779708f, -0.08592760f, -0.10509387f, -0.07383466f, -0.12037872f, -0.02732618f, -0.03908573f, -0.11428915f, 
    0.30287471f, 0.15190133f, 0.11984082f, -0.06785329f, -0.07800760f, -0.09930779f, -0.03378580f, -0.10196082f, 
    -0.04542338f, -0.10542888f, -0.00603923f, 0.11721141f, -0.09491862f, -0.13210478f, -0.21321148f, -0.27305505f, 
    0.09110276f, 0.12251549f, 0.14100574f, 0.06754051f, 0.06232124f, -0.09070361f, -0.10825317f, -0.05537099f, 
    -0.05849351f, 0.26705354f, 0.01419530f, 0.08794433f, 0.04709736f, -0.06051877f, 0.03556538f, -0.05025001f, 
    0.06553666f, 0.09139633f, 0.06195221f, 0.15344551f, -0.02404146f, -0.08067192f, 0.07470773f, -0.07720473f, 
    -0.02141915f, -0.05359101f, -0.19607905f, 0.05876214f, 0.00986828f, 0.03256105f, 0.06082045f, -0.03491410f, 
    -0.05842872f, -0.01489092f, 0.01372146f, -0.13206956f, 0.14498317f, -0.04967275f, 0.05620702f, 0.15501681f, 
    0.03095319f, 0.02011645f, 0.03403477f, -0.07314057f, 0.06450658f, 0.23967308f, -0.02296536f, -0.13673462f, 
    -0.03360111f, -0.02502536f, 0.17271578f, -0.05065447f, -0.01909088f, -0.06816227f, 0.31927925f, 0.05179941f, 
    0.05879414f, -0.02059417f, -0.00504616f, -0.01367179f, -0.01479105f, 0.01008711f, -0.13520084f, -0.01218459f, 
    -0.27701053f, 0.08525272f, 0.10625575f, -0.16568013f, -0.08752452f, 0.09178241f, 0.08901132f, -0.14820556f, 
    -0.04180267f, 0.19223715f, 0.03669839f, 0.01153033f, 0.04684922f, 0.02879211f, 0.03812814f, 0.00224632f, 
    0.23653190f, 0.25615489f, -0.02997999f, 0.04396425f, 0.07276731f, -0.03703473f, -0.19244537f, -0.00105957f, 
    0.17162314f, -0.16436623f, 0.19189279f, -0.02581523f, 0.33042270f, 0.03736811f, -0.12736027f, -0.08308516f, 
    0.10637230f, -0.02721513f, 0.01428980f, 0.28841397f, -0.07005373f, 0.06502810f, 0.08754399f, 0.02864952f, 
    0.11952987f, 0.01713214f, 0.19897088f, -0.12034277f, -0.21459167f, -0.03205280f, 0.10760377f, 0.11608878f, 
    -0.04418567f, 0.12519787f, -0.08113226f, -0.05228629f, 0.10255168f, 0.03173793f, -0.04529418f, 0.05497659f, 
    0.05121251f, 0.01756183f, -0.02035077f, -0.08308816f, -0.07015982f, -0.22286087f, 0.30838636f, -0.10006898f, 
    0.13147400f, 0.09914055f, -0.20098421f, -0.04330732f, 0.06925942f, -0.11600257f, -0.17810130f, -0.01288166f, 
    -0.11537902f, 0.03477083f, -0.04703245f, 0.04627197f, -0.01503113f, 0.05563353f, -0.03450913f, -0.01401638f, 
    -0.05046363f, -0.11809050f, 0.05602191f, 0.22086799f, -0.09737739f, 0.07542858f, 0.04985953f, 0.06927029f, 
    0.05250926f, 0.05377736f, 0.01915158f, -0.09484991f, -0.00340887f, -0.12209495f, -0.01693064f, -0.03237374f, 
    0.00196540f, -0.06958079f, -0.19417715f, -0.00097818f, -0.03711974f, 0.24698122f, -0.21557780f, -0.08035060f, 
    0.04322283f, -0.00540168f, -0.03590013f, -0.41209930f, -0.04231984f, -0.21966775f, 0.00892753f, 0.06667578f, 
    -0.22448952f, -0.00315453f, 0.21657579f, -0.00007992f, 0.10071681f, 0.02525445f, 0.21771976f, 0.07368257f, 
    0.01733853f, -0.02530318f, 0.01277580f, -0.08958180f, -0.14681274f, -0.08426012f, 0.19816157f, 0.02299402f, 
    0.18343382f, 0.25584406f, -0.02141264f, -0.03724503f, -0.09224860f, 0.10313712f, -0.03299560f, 0.00628084f, 
    -0.13380685f, 0.01338306f, -0.07525429f, 0.14375430f, 0.04089627f, 0.06145075f, 0.16634874f, -0.09136604f, 
    0.15019186f, 0.02913393f, 0.04295440f, -0.10096054f, -0.02745798f, -0.12774779f, -0.14318997f, 0.08300602f, 
    0.16927947f, -0.08123530f, -0.13063499f, 0.04487757f, 0.12221330f, 0.09259501f, -0.10816090f, -0.13568419f, 
    -0.08061492f, 0.05380899f, 0.10791981f, 0.17327634f, -0.00166701f, -0.04629702f, -0.03998418f, 0.06615012f, 
    -0.05307909f, 0.00861904f, -0.14362752f, 0.11758796f, 0.05063377f, 0.02486296f, 0.00618991f, 0.03612037f, 
    0.00779596f, 0.00979620f, 0.04169935f, -0.03930723f, 0.20870028f, 0.16953215f, -0.02080727f, 0.07123996f, 
    -0.03876098f, -0.01892031f, 0.05385401f, -0.10928629f, -0.07731310f, 0.19347937f, 0.28104773f, 0.02343998f, 
    0.11338977f, -0.01781463f, 0.04631760f, 0.02818979f, -0.01450443f, 0.03970291f, -0.00129766f, 0.13795270f, 
    0.05939402f, 0.10534695f, -0.01647642f, 0.22247812f, 0.01781755f, 0.10670100f, -0.23683445f, 0.18408571f, 
    0.15213393f, 0.00426788f, -0.24884613f, -0.13516787f, -0.01852831f, -0.00838560f, 0.10756612f, 0.00711963f, 
    0.21621214f, 0.11962396f, 0.13345855f, 0.10932707f, 0.15861462f, 0.10823166f, 0.03183319f, 0.07276205f, 
    -0.08804137f, -0.04414737f, 0.13119420f, -0.07942151f, -0.04832382f, -0.17447835f, 0.02494416f, -0.05128679f, 
    -0.14036584f, 0.05052610f, 0.10755416f, 0.07006533f, 0.01451576f, -0.01730355f, -0.07903589f, -0.08868660f, 
    -0.15622036f, -0.09856330f, 0.00710444f, 0.01851964f, 0.19102983f, 0.01609927f, 0.18382196f, -0.07961821f, 
    0.06603803f, 0.14322656f, -0.00245300f, 0.15799007f, 0.04316710f, -0.05934630f, -0.02608836f, 0.01207029f, 
    0.10847912f, 0.12174957f, 0.09692777f, -0.06696117f, 0.06669956f, -0.11922308f, -0.13431042f, 0.02442572f, 
    0.08802199f, 0.09232694f, -0.08095684f, -0.18675533f, -0.17751461f, 0.11052208f, 0.01152998f, -0.01003353f, 
    -0.20558195f, -0.01601882f, -0.09090054f, -0.00712154f, 0.01152125f, 0.09580173f, 0.09223766f, 0.03716193f, 
    -0.06703278f, 0.03258123f, -0.08650276f, 0.02553923f, 0.12123418f, 0.00243518f, 0.10130591f, 0.21491893f, 
    0.15354888f, -0.01052278f, -0.23872735f, -0.11393695f, -0.07382696f, 0.05981265f, -0.07459614f, 0.04492211f, 
    -0.10559105f, -0.13357998f, -0.19034702f, -0.00097504f, 0.00566171f, -0.00147728f, -0.09319830f, -0.24138252f, 
    -0.02258986f, 0.24343646f, 0.15225846f, 0.01459448f, 0.09181483f, -0.09490140f, 0.04358440f, 0.01653362f, 
    0.03434945f, 0.11351168f, 0.07810582f, 0.06360344f, 0.17574182f, 0.10102216f, 0.06723316f, -0.02836949f, 
    0.13383777f, 0.03852358f, -0.02962371f, 0.11477793f, 0.27756983f, 0.03193157f, -0.01896623f, 0.09158815f, 
    0.05333612f, -0.16757338f, -0.08960467f, -0.10661686f, 0.09170626f, 0.08293930f, 0.00801277f, -0.08701157f, 
    0.01635607f, 0.12052802f, 0.00675585f, 0.01603727f, 0.00027748f, 0.06588107f, 0.00622393f, 0.13174956f, 
    -0.15813272f, -0.25291610f, -0.24905521f, -0.02612430f, 0.06866489f, 0.02455079f, 0.06653092f, 0.16829434f, 
    -0.10128178f, -0.21737312f, 0.06444789f, -0.06986660f, -0.20458046f, -0.02906438f, -0.02938944f, 0.16102979f, 
    0.12430632f, 0.06577861f, -0.24745433f, -0.03299943f, -0.18441954f, -0.00515715f, -0.12764823f, -0.16356798f, 
    -0.07839844f, 0.10830487f, 0.05150010f, 0.25242832f, 0.16118343f, -0.00869170f, -0.19230181f, -0.01875037f, 
    -0.03329214f, 0.07867163f, -0.07551438f, -0.12381761f, -0.14088258f, -0.12031189f, -0.23085736f, 0.06843042f, 
    -0.06892554f, -0.01809230f, -0.15729341f, -0.15009151f, -0.11256193f, 0.03583292f, 0.03293287f, 0.13485745f, 
    -0.11101121f, -0.02519779f, -0.11529012f, 0.04426401f, 0.00375365f, 0.31134084f, -0.00356334f, 0.19028838f, 
    0.05775419f, -0.01648258f, -0.01504771f, -0.00049072f, 0.04195420f, 0.11015069f, 0.11260930f, 0.07929361f, 
    0.01945009f, -0.10014657f, -0.09244218f, -0.03270897f, 0.05745915f, -0.12786366f, 0.02193409f, 0.07272919f, 
    -0.11370138f, -0.10244932f, -0.09375484f, -0.04867785f, -0.12081661f, -0.11244987f, -0.18788716f, 0.03354418f, 
    -0.24398804f, 0.02804862f, 0.07382230f, 0.12423741f, -0.13309433f, -0.10944306f, -0.08329177f, 0.06258020f, 
    -0.22326064f, -0.30877382f, -0.11822742f, 0.00023925f, -0.09849179f, 0.03917393f, -0.04323564f, 0.02186260f, 
    -0.03952864f, -0.06189512f, 0.02481513f, -0.02995649f, -0.03946031f, -0.01616408f, -0.03364461f, -0.01966133f, 
    -0.04502828f, -0.05474164f, -0.01971531f, 0.03935898f, -0.05903430f, 0.00372737f, 0.01270336f, -0.06686962f, 
    0.02550867f, -0.06309512f, -0.01827927f, -0.01647682f, 0.01159674f, -0.00809721f, 0.02336529f, -0.03748583f, 
    0.00201622f, 0.00650188f, -0.00824659f, 0.04424470f, -0.02600923f, -0.02526825f, -0.02578965f, -0.06599603f, 
    -0.01586136f, 0.03519582f, -0.04283940f, -0.04744057f, 0.02432305f, -0.04682949f, 0.00631532f, 0.04636401f, 
    -0.01870127f, 0.01122555f, -0.06353710f, 0.02123086f, -0.01662542f, 0.03488179f, -0.03459709f, -0.05591398f, 
    -0.04622190f, -0.00992011f, -0.03379520f, -0.00803683f, 0.02099511f, -0.03512303f, 0.04295555f, 0.04283753f, 
    -0.04389110f, -0.00880383f, -0.02541155f, -0.03923682f, -0.02126478f, -0.06611862f, -0.01492203f, 0.00856770f, 
    -0.06349878f, 0.01581581f, 0.02941959f, -0.02351829f, -0.01830371f, 0.00271732f, -0.05431951f, -0.01006629f, 
    -0.02813138f, -0.05331776f, 0.02673523f, -0.02368878f, 0.01452390f, 0.04379807f, 0.03622306f, -0.01206363f, 
    -0.00016017f, 0.01292368f, -0.00331048f, -0.02399065f, 0.00367126f, -0.00706116f, -0.01669267f, -0.01483295f, 
    -0.05360603f, -0.00691374f, 0.05296564f, -0.04372698f, -0.00206938f, -0.05606825f, -0.03931734f, 0.04935692f, 
    0.00762790f, 0.01321322f, 0.00147070f, 0.03067177f, -0.06493268f, 0.03107407f, 0.02725911f, 0.00278693f, 
    0.02825572f, -0.03287593f, 0.02595909f, -0.04829415f, 0.02605690f, -0.00328195f, 0.04281459f, 0.03674673f, 
    0.02267572f, 0.00763214f, 0.01436214f, 0.02583363f, 0.01403664f, 0.01132954f, -0.00350825f, 0.01532109f, 
    -0.06337943f, -0.03792408f, 0.04041733f, -0.00187742f, -0.03887336f, 0.01789165f, 0.02890325f, 0.03623345f, 
    0.05141098f, -0.02302362f, -0.00825640f, -0.05580075f, -0.05461329f, 0.00399853f, 0.02892466f, -0.06927574f, 
    -0.04593509f, -0.05677252f, -0.05742462f, -0.01027923f, -0.04048630f, -0.03108527f, 0.00443274f, 0.00912597f, 
    -0.02420618f, 0.04126363f, 0.00412624f, 0.04685008f, -0.02866590f, -0.05826681f, -0.04045059f, 0.04474503f, 
    -0.04992167f, -0.02191118f, 0.00163461f, -0.00326676f, -0.02756253f, 0.00159868f, -0.06964271f, 0.00544776f, 
    0.02045055f, -0.04102853f, 0.04235588f, -0.05390197f, -0.01113423f, 0.04184245f, -0.01302288f, 0.04612556f, 
    0.04408274f, 0.00151757f, 0.00925658f, -0.03022506f, 0.01519293f, -0.07081529f, 0.01622903f, -0.03351146f, 
    -0.00746595f, -0.06357233f, -0.01004823f, 0.04569191f, -0.06244883f, 0.01546923f, 0.03302998f, -0.02754740f, 
    -0.01202357f, -0.04450979f, -0.03478755f, -0.00986997f, 0.04638406f, -0.02376355f, -0.05024142f, -0.04804095f, 
    -0.04649967f, 0.01087161f, -0.05871683f, -0.01102684f, -0.03861079f, -0.05449283f, 0.01987372f, -0.01567033f, 
    -0.04236193f, 0.04276815f, -0.05237593f, 0.02605258f, -0.04042828f, 0.04166695f, -0.00260879f, -0.05326344f, 
    -0.00826225f, -0.04237821f, -0.03127455f, 0.02168125f, -0.00764446f, -0.04302568f, 0.02118308f, -0.02474627f, 
    -0.06372871f, -0.05254876f, 0.04479339f, 0.01287312f, -0.01977085f, -0.05069534f, -0.03344539f, -0.04203545f, 
    -0.01223694f, -0.03484300f, -0.03877923f, -0.00889032f, -0.03209767f, 0.02026575f, -0.06376094f, 0.02912378f, 
    0.03761375f, -0.05621202f, 0.02909362f, 0.02706541f, -0.02755369f, 0.01490179f, 0.03861222f, -0.06814270f, 
    -0.04230046f, -0.05732178f, -0.00740366f, 0.03497658f, 0.00388487f, 0.02796276f, 0.03130027f, -0.00838489f, 
    -0.05335109f, 0.00086378f, -0.01342442f, 0.03778927f, 0.03618608f, -0.00801318f, 0.05023772f, -0.05990433f, 
    -0.02909780f, -0.03306760f, 0.02109621f, -0.01596838f, 0.02872754f, -0.01738816f, -0.03458564f, -0.02602946f, 
    -0.01888898f, 0.04454814f, -0.01202160f, -0.06054580f, 0.01352164f, -0.05626159f, -0.05658772f, 0.00242383f, 
    0.03869182f, 0.04324188f, -0.05004288f, -0.02027500f, -0.03243929f, -0.05867492f, 0.02873589f, -0.04375796f, 
    -0.05136562f, -0.02794217f, 0.04134081f, 0.03068353f, 0.01689597f, 0.00773282f, 0.04408891f, -0.01395101f, 
    0.09466542f, -0.06165076f, -0.02278111f, 0.24436940f, -0.01817839f, 0.10145369f, 0.03083682f, -0.12890640f, 
    0.07504936f, 0.06347855f, -0.02503815f, 0.19780155f, -0.10230622f, -0.20143119f, 0.01795646f, -0.04950279f, 
    0.03056548f, 0.04041709f, -0.23459728f, 0.02336014f, 0.17499045f, 0.16632704f, 0.04026290f, -0.19930451f, 
    0.02220443f, -0.01699065f, -0.00047127f, -0.36404163f, -0.25824222f, -0.19201188f, -0.07248981f, 0.02837677f, 
    -0.02944730f, 0.06328312f, -0.11247714f, -0.10793058f, -0.16680878f, -0.20426658f, 0.15788589f, 0.08106336f, 
    0.10357945f, -0.04193911f, 0.03279852f, -0.09806567f, -0.00376492f, -0.00054093f, -0.00193902f, 0.17729244f, 
    0.02051454f, -0.01120611f, -0.02876048f, 0.04671726f, -0.06616846f, 0.06608643f, -0.04430722f, 0.57953501f, 
    0.06737357f, -0.05626470f, -0.33483711f, -0.02246621f, -0.14895889f, 0.00411803f, -0.00999942f, -0.46735916f, 
    -0.10893193f, 0.10070758f, 0.07606792f, 0.03037762f, -0.25256148f, 0.07873989f, -0.02721492f, -0.06520833f, 
    0.10149122f, 0.02226726f, -0.09395269f, 0.06727742f, 0.11227846f, -0.13572246f, 0.09406112f, 0.01657788f, 
    0.18741347f, 0.12281547f, 0.08398657f, 0.14503129f, 0.06935684f, -0.12034041f, -0.13307565f, -0.01859883f, 
    0.09348707f, 0.11358485f, 0.00220471f, -0.06546706f, -0.08651346f, -0.09913331f, 0.15903607f, 0.08619094f, 
    0.12692258f, -0.07391717f, 0.03582853f, -0.04064260f, 0.17895503f, 0.39830419f, -0.05965370f, -0.04311803f, 
    -0.14550672f, -0.06765359f, 0.06636988f, 0.10908616f, 0.02607842f, -0.00354736f, 0.22994322f, 0.03026331f, 
    -0.06454435f, -0.12576173f, 0.11810167f, -0.13777812f, 0.04976019f, -0.03327429f, -0.01739628f, 0.14296667f, 
    0.04911647f, 0.07199072f, 0.08743251f, -0.01335279f, 0.01545972f, 0.09005151f, 0.09756801f, 0.13514373f, 
    -0.06033531f, -0.08249263f, -0.01326033f, -0.03809755f, 0.12242736f, 0.07474345f, 0.04321963f, 0.12670283f, 
    -0.30694696f, 0.28855985f, -0.04517773f, -0.19583423f, 0.06883933f, -0.12504005f, -0.18134013f, 0.02770963f, 
    -0.09956075f, 0.09179615f, 0.01568094f, 0.01215475f, -0.03108931f, -0.00230972f, -0.00992260f, 0.04341947f, 
    0.08219049f, 0.10399867f, 0.05181092f, -0.05117646f, 0.15248546f, -0.03780903f, -0.00122410f, 0.22548109f, 
    0.05753577f, 0.10411425f, -0.13152313f, 0.16007335f, -0.01841716f, 0.00639012f, -0.09167250f, -0.00859401f, 
    0.09722891f, 0.10276394f, -0.00796299f, 0.15769219f, 0.06487685f, 0.03957677f, -0.07396781f, -0.00827082f, 
    0.02098008f, 0.16552605f, 0.07040181f, 0.05860311f, -0.20109849f, -0.09949040f, 0.15831046f, -0.09658562f, 
    -0.14832465f, -0.07070615f, -0.03424841f, 0.00136605f, -0.08598629f, 0.05451046f, -0.00348493f, -0.01497804f, 
    -0.09597765f, 0.05433910f, 0.10695233f, -0.01524433f, 0.11158306f, 0.07146763f, 0.02287373f, 0.37036476f, 
    -0.29571959f, -0.15594770f, 0.00419217f, 0.09994667f, 0.08991291f, -0.07655201f, -0.00037910f, 0.03798681f, 
    -0.22262351f, -0.21224208f, -0.01463527f, -0.09051161f, -0.13854502f, -0.01199559f, -0.13953574f, 0.01855283f, 
    -0.15984155f, 0.20327032f, -0.32793540f, -0.15073645f, -0.18909921f, 0.24666421f, -0.03622527f, -0.06732393f, 
    -0.00070517f, -0.15224275f, -0.07829491f, -0.07144370f, -0.09987079f, 0.11175808f, 0.04145176f, -0.05699646f, 
    -0.06477790f, 0.07114909f, -0.35193181f, 0.18491304f, 0.17876738f, -0.14192142f, 0.02346491f, -0.00787917f, 
    0.05209632f, 0.02230875f, -0.13439284f, -0.25040749f, -0.13050815f, 0.22064045f, -0.05790730f, -0.02564802f, 
    0.05294436f, 0.08510278f, 0.00409892f, 0.19087029f, 0.13703835f, 0.12927042f, 0.17798397f, -0.00536010f, 
    -0.13402480f, -0.04689108f, -0.03582003f, 0.12578292f, -0.03000809f, -0.34659228f, -0.12729475f, -0.28934950f, 
    0.09182216f, -0.04048686f, -0.38886189f, -0.06930441f, -0.06929393f, 0.24728538f, 0.01008316f, 0.06780227f, 
    0.27343470f, 0.12855710f, 0.07714549f, -0.10717367f, 0.00018424f, 0.09108201f, 0.10239767f, -0.35508657f, 
    -0.16536480f, -0.03578236f, -0.12557752f, -0.05451874f, -0.09528638f, -0.10306690f, -0.11897725f, -0.04626101f, 
    -0.10248409f, 0.15201113f, 0.06459633f, 0.01604137f, 0.00783616f, 0.20735593f, -0.13539000f, 0.17122275f, 
    0.15538533f, -0.12150730f, 0.05353295f, -0.09213995f, -0.11190680f, -0.03072579f, 0.02555082f, 0.02363392f, 
    -0.00539079f, 0.01178359f, 0.24455394f, 0.23599246f, 0.24888711f, 0.07473881f, -0.00129162f, 0.11949861f, 
    -0.10009280f, 0.09125482f, 0.00928494f, 0.04824670f, 0.09866405f, 0.20169289f, 0.02320229f, 0.06634203f, 
    -0.07694931f, -0.13569371f, -0.01152747f, 0.13464747f, 0.08220255f, 0.17701745f, 0.00502746f, 0.09238981f, 
    0.00856819f, 0.10353588f, -0.09869212f, 0.00061437f, 0.02908047f, -0.01593168f, 0.22630882f, 0.15539137f, 
    -0.13965616f, 0.01208064f, 0.13694365f, -0.01507744f, -0.06420899f, -0.01285884f, 0.36010605f, 0.07977693f, 
    -0.04261992f, -0.03764888f, 0.15739965f, 0.11214290f, 0.04351553f, -0.07899656f, -0.07273319f, -0.03654636f, 
    -0.00696185f, -0.09268409f, 0.23403640f, -0.02996296f, -0.13709249f, -0.09295817f, -0.05277683f, -0.32404134f, 
    -0.00629827f, -0.01439237f, -0.14093599f, 0.07159155f, 0.11909778f, 0.08645353f, -0.06218779f, -0.17644393f, 
    -0.11496738f, 0.00932071f, 0.07920159f, 0.00217372f, 0.00078818f, -0.00320650f, 0.11132920f, 0.02677808f, 
    0.09521541f, -0.02274665f, 0.08939952f, 0.04262438f, 0.06371738f, -0.04251492f, 0.11183520f, -0.09125914f, 
    -0.03185200f, -0.05838474f, -0.16207294f, -0.05022534f, -0.07858997f, -0.16175756f, 0.06524007f, -0.04513135f, 
    -0.03349368f, 0.07003263f, 0.04593509f, -0.07479161f, 0.01833774f, -0.12683645f, 0.04784126f, -0.05649525f, 
    0.08784562f, 0.08702575f, 0.06604233f, 0.07760735f, 0.15978272f, -0.00896948f, -0.04966098f, -0.05369557f, 
    -0.00460685f, -0.02443639f, 0.04451738f, -0.03770944f, -0.03422103f, 0.13542153f, 0.01709593f, 0.12416274f, 
    0.03084696f, -0.02817152f, -0.05343542f, -0.03552389f, 0.03129692f, -0.01193448f, -0.01645419f, 0.10162704f, 
    -0.15091826f, -0.01606761f, 0.18639877f, 0.11707744f, 0.08261611f, -0.07485754f, -0.16879755f, 0.13525487f, 
    -0.13573447f, 0.03162622f, -0.06567165f, -0.02760901f, 0.11714681f, 0.01393284f, 0.02221968f, 0.11923177f, 
    0.26592037f, 0.04950693f, -0.01594345f, -0.04690561f, 0.03639170f, -0.08891914f, 0.13500446f, 0.08182138f, 
    -0.08086243f, 0.04045132f, 0.10839812f, 0.15267754f, 0.01995667f, -0.04337797f, 0.08864856f, 0.11408698f, 
    -0.00045926f, -0.01466584f, -0.05447746f, -0.05089629f, -0.02011572f, 0.08762805f, 0.06873561f, 0.05691567f, 
    0.03076596f, 0.04585395f, -0.07255167f, 0.06851491f, -0.01571327f, 0.14456844f, -0.06381452f, 0.11102016f, 
    -0.03284988f, -0.01988707f, -0.05479325f, 0.06962535f, 0.02631869f, -0.08451713f, -0.13889138f, 0.00899244f, 
    0.08636520f, 0.11222954f, 0.01375844f, -0.12415788f, -0.22079481f, -0.16480690f, -0.06704690f, -0.09076043f, 
    0.11014824f, 0.13165659f, 0.12158711f, -0.08933098f, 0.11261561f, 0.06189329f, 0.05521632f, -0.23100987f, 
    -0.23895107f, -0.01478858f, 0.12179989f, 0.15931727f, 0.03010830f, -0.04050170f, -0.02466034f, -0.01458275f, 
    0.08356159f, -0.19397941f, -0.13063855f, 0.07108659f, 0.17377812f, -0.01965109f, 0.08859653f, 0.03563461f, 
    0.01250272f, -0.15602536f, -0.17974305f, 0.04789346f, 0.08481893f, 0.01724535f, 0.14295684f, -0.04436361f, 
    -0.17457268f, 0.03512328f, 0.09948064f, 0.05198506f, 0.01741394f, 0.15354672f, 0.17519142f, -0.04169804f, 
    -0.01741369f, 0.06492323f, -0.05753522f, 0.28303128f, 0.13489428f, -0.07790051f, 0.24280921f, -0.05838747f, 
    -0.09655358f, -0.02661300f, -0.08796508f, 0.03931800f, -0.05457783f, 0.12158194f, -0.06913411f, -0.04367299f, 
    -0.01737273f, -0.04191044f, -0.03964921f, 0.11558778f, -0.17545676f, -0.02486195f, 0.04376147f, -0.15848771f, 
    0.06026026f, 0.08009447f, 0.14443740f, -0.10657734f, 0.06968563f, 0.12946007f, -0.01899602f, 0.17914917f, 
    -0.04819655f, -0.04729598f, 0.07198716f, 0.00683402f, 0.00697807f, 0.11992028f, 0.13559948f, -0.16236085f, 
    -0.17246635f, 0.04152517f, 0.11188800f, 0.12771800f, 0.05478412f, -0.05121815f, 0.13645343f, 0.17015395f, 
    0.12438427f, -0.27648842f, -0.10773499f, -0.08253165f, -0.10068918f, 0.06416100f, 0.06191472f, 0.03113766f, 
    0.03179548f, -0.41759345f, -0.11146164f, -0.03857435f, -0.02076340f, -0.12941127f, 0.06206000f, 0.08083805f, 
    0.04777877f, -0.11393860f, -0.18224870f, -0.16689317f, 0.07979795f, 0.02278735f, -0.03171926f, 0.00854893f, 
    0.07558037f, 0.04398888f, 0.01844573f, 0.00754182f, -0.00544059f, 0.12764035f, -0.03465403f, -0.01130849f, 
    -0.13749374f, 0.05219194f, 0.06646947f, 0.02668122f, 0.12480166f, 0.22946322f, 0.21561401f, -0.11178909f, 
    0.11417396f, -0.01682464f, 0.00912608f, 0.12869824f, -0.04230920f, -0.19936648f, 0.11687725f, 0.22825658f, 
    0.03675501f, 0.00523741f, -0.04497012f, -0.01179353f, 0.05822007f, 0.03524526f, -0.39850315f, 0.24674110f, 
    -0.22318056f, -0.04538896f, -0.12832412f, -0.12774624f, 0.01776629f, 0.01917663f, 0.17458349f, 0.18149094f, 
    0.08950108f, 0.20360838f, -0.00561874f, 0.10199426f, 0.10882173f, -0.06147795f, -0.07286020f, 0.12901470f, 
    -0.17646614f, 0.18164052f, -0.28378719f, -0.04132787f, -0.06145173f, -0.08668776f, -0.00107121f, -0.02657001f, 
    0.01126670f, -0.28748697f, -0.03621398f, 0.25634056f, -0.18344319f, -0.04463409f, 0.08760875f, -0.02109873f, 
    -0.08179766f, 0.03218212f, -0.15601604f, -0.12286314f, -0.31984946f, -0.11916648f, 0.08346193f, 0.10647480f, 
    0.09344016f, 0.05677677f, 0.00599552f, 0.12976529f, -0.00239991f, 0.18942669f, -0.02703119f, 0.08147061f, 
    -0.04009572f, 0.03736543f, 0.12832835f, 0.12960660f, -0.04100230f, -0.19853401f, -0.11151575f, 0.05167805f, 
    0.03528509f, 0.02333254f, -0.03208813f, 0.16845147f, 0.07567326f, -0.03554307f, -0.09082237f, 0.23347755f, 
    -0.11170378f, -0.11226495f, 0.02882472f, -0.04725693f, 0.14454612f, -0.00944231f, -0.26178560f, -0.05672078f, 
    -0.22143398f, 0.00867607f, -0.05255919f, 0.17048900f, -0.04146976f, 0.10024857f, -0.01545042f, -0.33860201f, 
    0.08092281f, 0.11104552f, 0.02883443f, -0.00940256f, -0.19865800f, -0.07515344f, 0.04518233f, -0.13975745f, 
    0.02747336f, -0.05032776f, 0.18862447f, -0.04779538f, 0.04467104f, -0.08713262f, 0.07395183f, -0.10260382f, 
    0.06272172f, 0.07898282f, 0.02554657f, -0.14976132f, 0.04893101f, -0.05593444f, -0.02106666f, -0.04040691f, 
    0.01854826f, 0.10602082f, -0.32645652f, -0.38597736f, -0.07829890f, -0.02404198f, -0.06510838f, -0.02501542f, 
    0.08078288f, -0.03629385f, 0.17838433f, -0.00927410f, 0.10376208f, 0.11950267f, 0.03418025f, -0.00998857f, 
    0.04382366f, 0.05668087f, -0.07628142f, 0.02545658f, -0.10161228f, 0.17100900f, 0.11980700f, -0.06935912f, 
    -0.02608478f, -0.17590810f, 0.01869288f, -0.05386100f, -0.06113088f, -0.24285509f, 0.00424094f, 0.01174161f, 
    0.01226680f, -0.03923500f, -0.10255238f, 0.00466682f, -0.02885230f, -0.05090840f, -0.02780391f, -0.17444272f, 
    -0.06199722f, -0.00617102f, -0.00758603f, -0.15665352f, 0.03061806f, -0.13096040f, -0.00681585f, 0.08325326f, 
    -0.05331560f, 0.12493663f, -0.01656622f, -0.06613047f, -0.10307213f, 0.01302719f, -0.06036378f, 0.19863452f, 
    -0.36379018f, 0.04282694f, 0.06703421f, 0.07163956f, 0.13173062f, 0.10831657f, 0.12799263f, -0.03181116f, 
    -0.09439523f, -0.07903029f, -0.01180472f, 0.26503870f, -0.01206102f, -0.13285561f, -0.10252672f, 0.04700933f, 
    0.03936176f, 0.08522655f, -0.05340990f, -0.06378393f, 0.37868714f, -0.06900167f, -0.09416340f, 0.11334151f, 
    0.07305705f, 0.10134766f, 0.14313655f, 0.11297426f, -0.02472719f, 0.07262553f, 0.09480737f, 0.05504055f, 
    0.08633471f, -0.16841817f, -0.10032605f, 0.00646236f, -0.19870022f, -0.09637734f, -0.10546137f, -0.06257971f, 
    0.00611874f, 0.06763208f, 0.12355061f, -0.04661356f, -0.08816547f, -0.21938390f, 0.23212938f, 0.16332904f, 
    -0.00443201f, -0.06574441f, -0.20554538f, 0.06133761f, -0.04373138f, -0.06671686f, 0.01585689f, 0.00800759f, 
    0.17432091f, -0.01259691f, 0.00472235f, -0.18526348f, 0.08031527f, 0.02176208f, 0.08611988f, 0.08937039f, 
    -0.15018415f, 0.47624004f, -0.09282860f, -0.08975451f, -0.04916983f, 0.00710004f, -0.02452805f, 0.11145471f, 
    0.25426891f, 0.01726034f, -0.16367288f, 0.09549490f, 0.04001694f, -0.01464195f, 0.10101254f, -0.18449104f, 
    -0.08430447f, 0.04851705f, -0.18895887f, -0.02054101f, -0.05517187f, -0.05280393f, 0.08448829f, -0.08691990f, 
    0.09492833f, -0.00503229f, -0.02748375f, -0.07065385f, -0.28679046f, -0.01581453f, -0.10801521f, -0.01829480f, 
    0.02485889f, -0.01456899f, 0.02122731f, 0.11877906f, 0.21187867f, 0.08906661f, 0.01620982f, -0.01482099f, 
    -0.00782138f, -0.00487993f, -0.10406563f, -0.00106765f, 0.01946000f, 0.07960069f, 0.20675084f, -0.09938172f, 
    0.12863043f, 0.06957924f, 0.01473144f, 0.00975980f, 0.09468866f, -0.02154238f, -0.14956585f, 0.02145495f, 
    -0.12648995f, -0.02269467f, -0.03721922f, -0.09828085f, 0.02943675f, 0.15350309f, -0.54585147f, -0.04031786f, 
    0.33759388f, 0.12911537f, -0.17272954f, 0.03333546f, 0.07616588f, 0.00170925f, 0.12639332f, 0.19649623f, 
    0.38747200f, 0.30474484f, -0.04397934f, -0.01644018f, 0.00415260f, 0.02857984f, 0.08102567f, 0.19428037f, 
    -0.29649594f, -0.25711182f, 0.09316449f, 0.12289947f, 0.06226174f, 0.13891870f, 0.02222793f, 0.07292193f, 
    0.02053368f, -0.05269774f, -0.04326959f, 0.16613300f, 0.03625754f, -0.20388451f, -0.04671700f, -0.09447553f, 
    -0.03254532f, -0.06651095f, 0.06439342f, -0.08120213f, 0.23590468f, -0.11182445f, 0.18116762f, 0.01344822f, 
    0.00432385f, -0.03726139f, 0.05703120f, 0.18860033f, 0.13609615f, 0.04046957f, 0.01925520f, -0.05374766f, 
    0.05667134f, -0.02129817f, 0.00770597f, 0.02256527f, 0.11666654f, 0.31269833f, 0.11980551f, -0.02603100f, 
    -0.04397924f, -0.04760905f, 0.07099370f, -0.06832644f, -0.02513752f, -0.05724619f, -0.09110956f, -0.00869834f, 
    0.06855328f, -0.10811356f, -0.19569270f, -0.01574219f, 0.07007848f, 0.02768007f, -0.12641262f, -0.14031525f, 
    -0.14694445f, -0.00304637f, 0.02876294f, 0.08412287f, -0.03926165f, -0.00248503f, 0.02046674f, -0.43664047f, 
    0.05958826f, 0.21934961f, -0.11067279f, -0.09288823f, 0.13412416f, -0.07636339f, 0.12984416f, -0.10619307f, 
    0.01463341f, -0.04877082f, -0.04230825f, 0.08824927f, 0.07291576f, -0.04253826f, -0.01598324f, -0.05329704f, 
    -0.12221798f, -0.22378027f, 0.10521833f, -0.14187978f, -0.11570050f, -0.02009839f, 0.21380669f, -0.00049160f, 
    0.05878172f, 0.01811078f, -0.00227320f, 0.07358012f, 0.03041114f, 0.12010834f, -0.15393770f, -0.05514317f, 
    0.10311788f, -0.04167158f, -0.01015281f, -0.08146989f, 0.12901396f, -0.10728635f, -0.15863077f, -0.14865188f, 
    0.00409434f, 0.04938484f, 0.07363552f, -0.09210297f, 0.34883508f, -0.01506812f, 0.06831045f, 0.03522458f, 
    0.08227852f, -0.00531664f, -0.03384613f, -0.05491677f, 0.01179868f, -0.12387016f, 0.00854643f, 0.02964832f, 
    -0.03750415f, -0.12557775f, 0.08745628f, 0.03396850f, -0.04566631f, 0.02849847f, 0.08500239f, 0.28508347f, 
    -0.27312416f, -0.11223599f, 0.11989038f, 0.21426886f, -0.00131868f, -0.00752756f, 0.05137858f, -0.00345959f, 
    -0.31758970f, -0.24279347f, 0.04703882f, -0.11368941f, -0.01638134f, 0.13336805f, 0.06332158f, -0.03943221f, 
    -0.34228396f, 0.40766394f, 0.08867998f, -0.00821140f, -0.15054105f, 0.13097115f, 0.10858160f, 0.04822946f, 
    -0.06156374f, -0.15367658f, -0.37095845f, -0.25686839f, -0.00104405f, 0.01222761f, -0.03455182f, -0.05708928f, 
    -0.00347914f, 0.01483015f, 0.10816274f, 0.14413919f, 0.05300124f, -0.07930861f, -0.02294569f, 0.01544954f, 
    0.01816581f, 0.04812114f, 0.00986464f, -0.18729584f, 0.12989838f, 0.23489444f, -0.06273586f, 0.02658913f, 
    0.18330438f, -0.04540105f, 0.11737641f, 0.05110410f, -0.04639868f, -0.14879401f, -0.01238243f, -0.07998622f, 
    -0.00420925f, 0.11009661f, -0.21370745f, -0.06478720f, 0.01157538f, 0.09001891f, -0.24511500f, -0.17615093f, 
    0.03344918f, 0.06483872f, -0.05250771f, 0.10181235f, 0.09011577f, 0.11681959f, 0.07790383f, -0.00338610f, 
    -0.05943593f, 0.14211658f, 0.02471457f, -0.06143370f, -0.03435688f, 0.00506189f, -0.09721722f, -0.01670804f, 
    -0.07832155f, -0.10651252f, 0.03398598f, 0.10667437f, -0.10418646f, -0.17023884f, -0.03591157f, 0.02527945f, 
    -0.00629365f, -0.04579502f, 0.08277203f, -0.04938214f, 0.06583067f, 0.14887178f, -0.09847539f, -0.15306745f, 
    -0.20800570f, -0.39849710f, -0.17611779f, -0.11875406f, -0.06963017f, -0.05045969f, 0.05680764f, -0.04533180f, 
    0.07546607f, -0.12454651f, -0.15355091f, -0.07436728f, 0.23461597f, -0.13116701f, 0.08372710f, -0.00627583f, 
    -0.06509276f, -0.00095696f, -0.20311996f, -0.05468486f, -0.16387224f, 0.01957202f, 0.01493751f, 0.07910924f, 
    0.12636410f, 0.04298562f, 0.02009108f, -0.01239055f, 0.00423678f, 0.12110134f, 0.14929940f, -0.03116168f, 
    0.22672743f, 0.08004083f, 0.03796120f, 0.08948474f, 0.02693424f, -0.28609473f, 0.11540096f, 0.14201987f, 
    -0.02607078f, 0.12745039f, 0.00111035f, -0.02823448f, 0.09997633f, 0.00364513f, 0.03660574f, 0.33301258f, 
    0.09196575f, 0.03405976f, -0.07426812f, 0.17728996f, -0.03488252f, -0.04707698f, -0.02360103f, 0.10213143f, 
    0.23596887f, -0.02042215f, -0.05922747f, 0.07305698f, -0.15694949f, 0.15370712f, 0.05094650f, 0.02708560f, 
    -0.01096152f, 0.12132235f, 0.08985272f, 0.12146129f, -0.03677476f, -0.06672550f, 0.04184406f, 0.06417307f, 
    -0.03497309f, -0.35921943f, 0.01711506f, 0.01521999f, 0.01719697f, -0.05732551f, 0.00599005f, -0.02962267f, 
    0.00601269f, -0.08776348f, -0.29090926f, 0.05211736f, 0.26194972f, -0.00917870f, 0.17378956f, -0.02539429f, 
    0.06256834f, 0.05926012f, 0.01203074f, 0.10918158f, 0.14399599f, -0.17314447f, 0.05340726f, -0.00778190f, 
    -0.01501964f, 0.04141883f, 0.08573977f, 0.08451840f, -0.03254573f, -0.09258492f, 0.00967568f, 0.10336458f, 
    -0.00149735f, 0.04563731f, -0.06502281f, -0.16717318f, -0.21305972f, -0.01114867f, 0.14147094f, 0.09316169f, 
    -0.00807407f, -0.03236827f, -0.02771876f, -0.16477580f, 0.11122292f, 0.10944816f, -0.45454821f, 0.02183371f, 
    0.00957970f, 0.00963463f, -0.04195657f, 0.06239318f, -0.06200533f, 0.01784395f, -0.00962277f, -0.08413094f, 
    0.35392743f, -0.03927618f, 0.30077001f, 0.07583617f, -0.05666046f, 0.00973592f, -0.01024846f, 0.06724791f, 
    0.14861767f, -0.02595152f, -0.13958946f, -0.02033782f, -0.04919430f, 0.03955813f, -0.03497269f, -0.07771716f, 
    0.08595292f, -0.23546270f, 0.25418359f, -0.03932923f, 0.02869169f, 0.06462517f, -0.01825694f, 0.06739990f, 
    0.09891911f, 0.01554086f, -0.36527768f, -0.04446549f, -0.02811135f, 0.06866540f, 0.06728782f, -0.02131606f, 
    -0.07211034f, -0.17732888f, -0.21144250f, -0.12665842f, 0.15871310f, -0.01847632f, -0.01702332f, 0.09010344f, 
    -0.08529716f, -0.05699336f, -0.11076672f, 0.03972548f, -0.16586231f, -0.08381789f, -0.28755832f, 0.03665219f, 
    -0.00564190f, 0.02885056f, 0.06726031f, 0.17571573f, 0.05406881f, -0.17679262f, 0.04173318f, -0.00330490f, 
    0.00394297f, -0.04068257f, -0.05864723f, -0.02892332f, 0.07047488f, 0.07796557f, -0.20037405f, 0.06956901f, 
    0.31090117f, 0.11263075f, 0.19560467f, -0.10732357f, -0.10301895f, 0.00096029f, 0.14087659f, -0.05307142f, 
    -0.07481925f, -0.02658485f, 0.16560142f, 0.10821474f, -0.07259845f, -0.15148941f, -0.00165716f, 0.02964922f, 
    0.21557213f, 0.26400414f, 0.07864106f, 0.21694809f, 0.09113817f, -0.03293350f, -0.03713034f, 0.10104677f, 
    0.07720343f, -0.01484296f, -0.19603209f, -0.06786709f, -0.05097698f, 0.06752900f, 0.01112608f, 0.01894818f, 
    0.02232083f, -0.00501357f, -0.22377646f, -0.17785108f, 0.08910128f, -0.23491211f, 0.06085716f, 0.06322484f, 
    -0.02824558f, 0.04311607f, 0.07652442f, 0.03018054f, 0.45557889f, -0.15368845f, 0.15363359f, 0.17570877f, 
    0.13049923f, -0.06137356f, 0.03489659f, -0.14987150f, -0.20817561f, -0.08689800f, 0.06871479f, -0.15895447f, 
    0.05890036f, 0.03021583f, -0.06190924f, 0.17109862f, -0.06707730f, 0.19776542f, 0.04039110f, -0.04498258f, 
    0.08474980f, -0.07855073f, -0.01815532f, -0.04674127f, -0.04728320f, -0.02360756f, 0.16850340f, 0.17180613f, 
    0.08377546f, 0.03936438f, 0.05208634f, 0.03403797f, -0.02501477f, -0.05911331f, 0.04873776f, 0.06141005f, 
    0.01386411f, -0.02893715f, -0.02077088f, 0.04746678f, -0.10462444f, -0.03184251f, -0.04346653f, 0.03799828f, 
    0.26434520f, -0.01080461f, 0.03458543f, -0.09444918f, -0.12429205f, -0.20695892f, 0.17424840f, 0.07170893f, 
    -0.03372127f, -0.27729955f, -0.17694616f, -0.06882548f, -0.18686068f, -0.10626589f, 0.04784872f, -0.04363697f, 
    -0.02550412f, 0.04865475f, -0.01148585f, 0.27754799f, -0.04078435f, 0.01063318f, -0.08050678f, -0.00175884f, 
    0.01469349f, 0.11582177f, 0.12418547f, 0.06067985f, -0.10374489f, -0.17906316f, -0.09374133f, -0.02233660f, 
    -0.24211836f, -0.04489130f, 0.00939616f, -0.09012743f, 0.23720996f, -0.07705116f, -0.19157562f, 0.00199700f, 
    -0.11873195f, -0.03228813f, 0.02769378f, -0.12646206f, 0.26730311f, -0.41049832f, -0.23130310f, 0.05312311f, 
    -0.28611740f, -0.18626833f, -0.18396477f, -0.09579837f, -0.01334292f, 0.22567546f, 0.25177169f, -0.02933827f, 
    -0.23344386f, 0.10256948f, 0.01965147f, -0.10152606f, 0.12672603f, -0.14054255f, -0.14673027f, 0.05657901f, 
    -0.11121153f, 0.02750260f, -0.14666215f, 0.00241311f, -0.01445307f, 0.04448409f, -0.07497980f, 0.14791794f, 
    0.08594029f, 0.02893615f, -0.02131465f, 0.05189741f, 0.04500384f, -0.04924791f, 0.03368232f, 0.13114747f, 
    -0.01256848f, -0.17884623f, -0.23198371f, -0.02401289f, -0.08506617f, -0.11016385f, -0.05650028f, 0.04210468f, 
    0.06913664f, 0.21666281f, -0.13943411f, -0.15249693f, -0.12056198f, -0.02912522f, -0.05485432f, -0.02719758f, 
    0.02433404f, 0.12142418f, 0.18305306f, 0.07339878f, 0.12855844f, 0.06126757f, 0.04411608f, 0.06356563f, 
    0.00954954f, 0.01717726f, 0.07612108f, 0.11578991f, 0.04371246f, -0.02387891f, -0.00059171f, 0.07299636f, 
    -0.01105333f, -0.16055274f, -0.11423115f, 0.01490958f, -0.07577348f, 0.02551823f, -0.10311916f, -0.01067485f, 
    -0.04470549f, 0.07024829f, -0.04050605f, 0.13850197f, 0.04887906f, 0.09119987f, -0.30889049f, -0.17249283f, 
    0.01080166f, -0.08688176f, -0.03702319f, 0.07923187f, 0.09183740f, 0.07573194f, 0.12419384f, 0.26810575f, 
    -0.46531358f, -0.17679989f, 0.05713806f, 0.10751208f, -0.12693277f, 0.02795172f, -0.23690689f, 0.19086826f, 
    0.18460211f, 0.25343671f, 0.10337990f, 0.11652974f, 0.18808946f, 0.12442832f, 0.04098797f, 0.01114152f, 
    -0.20441301f, -0.10489471f, 0.02788485f, -0.03327682f, -0.11330388f, -0.15589580f, 0.08901355f, 0.08373675f, 
    0.09508450f, 0.17001538f, -0.20960900f, -0.17427471f, 0.07559689f, -0.09475295f, -0.05898003f, 0.04207571f, 
    -0.08523780f, -0.13873103f, 0.01205538f, -0.06897752f, -0.21342026f, -0.06025099f, 0.02817907f, 0.10281261f, 
    -0.01385603f, 0.20078391f, -0.04565763f, -0.06954111f, 0.16019201f, 0.20665129f, -0.09447040f, -0.01426520f, 
    -0.01998113f, -0.03810081f, 0.03416857f, -0.16316834f, -0.34196693f, -0.08670030f, -0.03900252f, -0.06741923f, 
    0.06724580f, 0.06801277f, -0.03217162f, 0.09471926f, 0.06026158f, 0.11940407f, -0.07273785f, -0.22049387f, 
    -0.06360061f, -0.12720887f, -0.01230738f, -0.14612056f, 0.22008914f, 0.07563318f, -0.10075208f, 0.23132342f, 
    -0.09953826f, 0.21837880f, 0.10419375f, 0.05078154f, 0.09648581f, -0.07293776f, -0.18549013f, -0.04065912f, 
    0.00013369f, -0.08808573f, -0.08490390f, 0.05935593f, -0.03100573f, -0.03959016f, -0.10850137f, 0.02493643f, 
    -0.16236681f, -0.05703543f, 0.06879147f, 0.22726199f, 0.07071383f, 0.11328192f, 0.15006581f, 0.01548922f, 
    0.06862648f, 0.08867715f, 0.15568681f, -0.04882716f, -0.18191603f, 0.12792890f, 0.11487969f, 0.00107286f, 
    0.11628912f, 0.06754748f, -0.15129983f, 0.30622494f, 0.08433121f, -0.13962533f, -0.11197771f, -0.18400671f, 
    0.14696875f, -0.05425768f, -0.21156646f, 0.07472225f, -0.19783127f, -0.11301502f, -0.00411434f, 0.03597629f, 
    -0.02492715f, 0.07851432f, 0.15099262f, 0.05626641f, 0.23050955f, -0.00130702f, 0.27547112f, 0.13750410f, 
    0.00603383f, 0.06727355f, -0.10850317f, -0.01802518f, -0.15249804f, -0.19625360f, 0.27530697f, 0.35247925f, 
    0.08800013f, 0.02622764f, 0.08699002f, 0.05830124f, 0.12088240f, 0.08336017f, -0.03830615f, 0.17923750f, 
    0.03872550f, 0.26301306f, 0.11389469f, 0.06760261f, -0.00320427f, 0.06988666f, 0.08307429f, 0.07290648f, 
    0.09846964f, -0.05601365f, 0.01749791f, 0.03471535f, 0.04579905f, 0.14151102f, -0.03603029f, -0.09078667f, 
    0.06076762f, 0.03249349f, -0.04120545f, 0.25898036f, -0.13143103f, -0.13271414f, -0.12452697f, -0.00284643f, 
    0.04587109f, -0.05977364f, -0.29935938f, 0.02439668f, 0.24299598f, -0.19986632f, 0.13070478f, -0.17194867f, 
    0.14174102f, 0.03293696f, 0.14969106f, -0.12080304f, -0.15842448f, -0.08886997f, -0.07906951f, -0.18610357f, 
    -0.04006234f, 0.12645756f, 0.10701963f, -0.03381964f, -0.00749193f, -0.11997350f, 0.25448936f, 0.08151073f, 
    0.26916841f, 0.04158000f, 0.11313459f, 0.03079337f, 0.27950248f, -0.01922241f, -0.00857071f, 0.29070383f, 
    -0.15722308f, -0.16097948f, -0.21629971f, 0.10287247f, 0.18873543f, 0.04276362f, -0.24637735f, 0.34314218f, 
    0.21534377f, 0.09390984f, -0.02669198f, -0.07724524f, -0.29487973f, 0.02815902f, 0.26987785f, -0.18850067f, 
    -0.19065863f, -0.12527689f, -0.07920470f, 0.03874995f, -0.22714940f, 0.17445405f, -0.05629711f, -0.01521344f, 
    0.00500644f, 0.03149945f, -0.06755146f, 0.20527743f, 0.07934105f, -0.03611537f, 0.08176714f, -0.02862900f, 
    0.05485554f, 0.00922998f, 0.12595670f, 0.12075989f, -0.02240651f, -0.10805573f, -0.10436162f, -0.05668959f, 
    0.11717241f, 0.01676709f, 0.04405933f, -0.03487292f, 0.12731308f, -0.06706256f, -0.00552007f, 0.16054200f, 
    0.07195333f, -0.00770421f, -0.10301291f, -0.05552130f, 0.03027693f, 0.34642380f, 0.08748764f, -0.06078217f, 
    -0.16154186f, 0.07348862f, 0.02013589f, 0.11173707f, 0.08801750f, 0.06391635f, 0.13137414f, 0.01153403f, 
    0.03478928f, -0.06379752f, -0.02563105f, -0.19511390f, 0.03309381f, 0.04093173f, -0.06102048f, 0.10703851f, 
    -0.00180000f, -0.02483384f, 0.03234822f, 0.05139450f, 0.15939541f, 0.06746956f, -0.02304363f, 0.14084047f, 
    -0.05279549f, -0.00650788f, 0.04599498f, -0.05884308f, 0.09972713f, 0.10567418f, -0.09597280f, -0.36131555f, 
    -0.01440770f, 0.32307202f, -0.04774661f, -0.04242248f, -0.03718920f, 0.00677702f, -0.13489746f, -0.06278569f, 
    -0.12397884f, -0.03529292f, -0.07540889f, -0.08151294f, 0.04072198f, -0.04690770f, -0.05954948f, 0.10181655f, 
    0.09642613f, -0.16877609f, 0.07697108f, 0.04164563f, 0.08758429f, -0.05823690f, -0.12758592f, 0.20348100f, 
    0.03093141f, 0.05059526f, -0.24341419f, 0.02608142f, 0.17169800f, 0.00027617f, -0.01047464f, -0.07995792f, 
    -0.01303773f, -0.00155379f, -0.02611417f, 0.06565473f, 0.17274037f, 0.01315739f, -0.03663056f, -0.02100639f, 
    0.10783344f, 0.07634827f, 0.07275675f, -0.04826930f, -0.19549009f, -0.22460556f, -0.08659917f, -0.12982793f, 
    -0.19432476f, -0.10220338f, 0.04235258f, 0.02730543f, 0.07823667f, -0.06532321f, -0.00128567f, -0.11162060f, 
    -0.01013225f, 0.06996320f, -0.02150897f, 0.10180106f, 0.15631993f, -0.00207092f, -0.13590527f, 0.35096306f, 
    -0.02489560f, -0.05186143f, -0.05527110f, 0.34501433f, -0.19405158f, -0.00035790f, -0.21231332f, -0.15139832f, 
    -0.18084258f, -0.23583081f, -0.15211909f, -0.03911537f, 0.01906904f, -0.01348914f, 0.04213238f, 0.10351311f, 
    -0.21729052f, 0.32984152f, -0.09121041f, 0.11253831f, -0.10650444f, 0.08963318f, -0.02284092f, 0.01864450f, 
    0.01847676f, -0.20567755f, -0.15766934f, -0.09863643f, 0.01281834f, -0.00014304f, 0.05820615f, -0.00294546f, 
    0.11592345f, 0.03864431f, -0.05357616f, -0.05623640f, 0.02916799f, -0.07007179f, -0.03324245f, 0.01085812f, 
    -0.02102112f, 0.04287373f, 0.14509073f, -0.35633633f, 0.02247641f, 0.10779648f, -0.12821285f, 0.15854210f, 
    -0.08974712f, 0.12364350f, 0.04505254f, 0.18511799f, -0.07180558f, 0.04563328f, 0.15091994f, -0.11225887f, 
    -0.03922146f, -0.07550652f, -0.09003219f, 0.04448049f, -0.05031386f, -0.11129391f, -0.20579371f, -0.20587225f, 
    -0.15104780f, 0.03510366f, -0.07253144f, -0.11990335f, -0.05991403f, 0.08711077f, -0.01853787f, 0.12444503f, 
    0.21049049f, -0.03069734f, 0.06004304f, -0.03739549f, 0.00249004f, 0.05311765f, 0.15001473f, -0.30434051f, 
    -0.12263117f, 0.01241686f, -0.03148431f, -0.09641319f, -0.05686050f, -0.04639252f, 0.04486489f, -0.02496915f, 
    -0.09508213f, 0.17094281f, 0.10889813f, 0.06023425f, 0.07954913f, 0.04255407f, -0.07823596f, -0.09910522f, 
    0.26442927f, 0.03152923f, -0.16602625f, -0.33659315f, 0.06603497f, -0.05547083f, -0.00126112f, -0.05207889f, 
    -0.05127086f, 0.05394957f, 0.06018332f, 0.14621782f, 0.23810746f, -0.09843509f, -0.06601661f, -0.07105795f, 
    -0.04351624f, -0.00400325f, 0.02739900f, 0.06331366f, 0.10098501f, 0.31463352f, 0.04649608f, 0.03862995f, 
    0.07334502f, 0.01346344f, -0.06574155f, -0.00373885f, -0.07314674f, -0.05068153f, 0.28356281f, 0.00827796f, 
    0.00891310f, 0.07573640f, 0.01071616f, 0.04573017f, 0.05980527f, -0.13629434f, 0.06154596f, -0.09535769f, 
    0.04674328f, -0.02330774f, -0.17896557f, 0.00096943f, -0.00016803f, -0.02871967f, 0.04830012f, -0.24517037f, 
    -0.40573850f, 0.15747640f, -0.05510908f, 0.05056122f, 0.04173260f, 0.12110668f, -0.04697787f, 0.12253197f, 
    0.17916094f, 0.21933840f, 0.11975066f, -0.12215647f, -0.03323244f, 0.04751177f, -0.15336445f, -0.34013793f, 
    0.00829601f, -0.01158748f, -0.21097630f, 0.06783839f, -0.02147516f, 0.07979273f, -0.06466443f, 0.00368724f, 
    -0.17373443f, 0.13081932f, -0.21355538f, -0.19468322f, 0.13479523f, -0.08431978f, 0.10746786f, 0.01053113f, 
    0.06275839f, 0.12362067f, -0.20577024f, -0.25614572f, -0.19378424f, 0.05758652f, 0.10242779f, -0.01025929f, 
    -0.01224083f, 0.05332204f, -0.11910117f, 0.22744361f, -0.07256274f, 0.16399737f, -0.01245919f, -0.08353936f, 
    -0.15308672f, -0.03138900f, -0.10581341f, -0.21054865f, -0.14648055f, 0.15480824f, -0.03761851f, 0.03485742f, 
    0.00111149f, 0.04528293f, 0.04366155f, 0.03594108f, 0.14030682f, 0.00905800f, 0.12323666f, -0.09702460f, 
    -0.10644879f, 0.02327920f, -0.00492550f, 0.02006750f, 0.02593945f, 0.02801550f, -0.01020977f, -0.10833856f, 
    -0.14061649f, 0.05775009f, 0.06638221f, -0.10731205f, -0.05440236f, -0.01168687f, -0.04602144f, 0.18579811f, 
    -0.25968990f, 0.13214642f, -0.15105247f, -0.06342074f, 0.05173117f, -0.30572081f, -0.03742427f, 0.14011261f, 
    0.18619253f, 0.00398795f, 0.09353606f, 0.03307138f, 0.01424274f, -0.00235846f, -0.11378942f, -0.00698684f, 
    0.15327083f, 0.11874840f, -0.12616166f, -0.18891361f, -0.05674792f, -0.05023166f, 0.01446821f, 0.03109950f, 
    -0.12599565f, -0.04886408f, 0.07841050f, -0.01284351f, -0.23534253f, 0.11233459f, -0.05270921f, 0.10279154f, 
    -0.01995884f, 0.07536522f, 0.08149334f, 0.01001415f, -0.18821654f, -0.25863612f, 0.11429930f, -0.07569310f, 
    -0.10758299f, -0.01020193f, -0.00862395f, 0.04197163f, 0.19506243f, -0.03834631f, 0.10056929f, 0.05118911f, 
    -0.03187115f, -0.12018546f, -0.03369991f, -0.06080450f, 0.10732400f, 0.01028187f, -0.13659017f, -0.24794067f, 
    0.05265383f, 0.11639638f, 0.07789968f, -0.00974364f, -0.11157203f, -0.11101183f, 0.11192602f, -0.12472958f, 
    -0.48896495f, 0.11269379f, -0.11847951f, 0.03985358f, -0.05378566f, 0.06799758f, -0.14546426f, 0.02228381f, 
    0.14621998f, -0.62472105f, -0.07118540f, 0.01523650f, 0.14934884f, -0.09518959f, 0.03924619f, 0.03750090f, 
    0.26030883f, 0.02080949f, -0.38480219f, 0.05840341f, 0.01284727f, 0.12683578f, 0.11397339f, -0.01997994f, 
    0.12092225f, 0.06660943f, 0.07721530f, 0.17446288f, -0.04426726f, -0.01156240f, -0.03132273f, 0.01878002f, 
    -0.05372450f, 0.00941037f, 0.09072310f, 0.07404164f, 0.15952848f, 0.11935647f, 0.02634978f, -0.02643825f, 
    0.08490865f, 0.07652698f, -0.03935429f, 0.02987074f, -0.04197595f, -0.04678127f, -0.19932881f, -0.15666620f, 
    0.04077520f, 0.07565691f, -0.01324146f, 0.16791253f, -0.03000046f, -0.23352170f, -0.31213057f, 0.12019307f, 
    -0.09919850f, -0.07440155f, 0.04701998f, -0.01491940f, 0.07280967f, 0.17330883f, -0.08127774f, -0.09042655f, 
    0.02784769f, -0.04669535f, 0.00968035f, -0.12208039f, 0.13366176f, 0.19406317f, 0.06952247f, -0.04304473f, 
    0.05429750f, -0.06006810f, -0.01025786f, -0.08439778f, -0.02040084f, -0.08433180f, 0.08905553f, 0.14963007f, 
    0.10040843f, 0.26195246f, 0.04342025f, 0.00512844f, -0.05476265f, -0.06291017f, -0.01770459f, -0.00671624f, 
    0.02589210f, -0.00633608f, -0.05764799f, 0.02271129f, 0.02240521f, -0.04062617f, 0.03981848f, -0.04316308f, 
    -0.03268558f, -0.02746085f, -0.01681609f, -0.04306966f, -0.00861825f, 0.03969036f, -0.01945055f, -0.05026419f, 
    0.01255039f, -0.02939362f, -0.04914058f, 0.02506649f, -0.03157163f, -0.06281161f, -0.00155728f, 0.02310407f, 
    0.03147260f, 0.03974170f, 0.02318609f, -0.01804955f, 0.04336770f, -0.05199815f, -0.02310130f, -0.06772657f, 
    0.04469837f, -0.01466465f, 0.00900292f, -0.06747527f, -0.01263480f, 0.03496452f, -0.04400235f, -0.04044681f, 
    0.03396998f, -0.05109030f, -0.00398277f, -0.02800991f, -0.06288726f, -0.03398930f, 0.01759869f, -0.04982034f, 
    -0.01949424f, -0.05249877f, 0.01501148f, 0.00003298f, 0.04482138f, -0.00246741f, 0.02792118f, 0.00003224f, 
    -0.05077684f, 0.01323320f, 0.02720688f, -0.00469661f, -0.05440773f, -0.01765460f, 0.00892203f, -0.00332206f, 
    0.03652062f, -0.01831574f, 0.02026405f, 0.05099045f, 0.05136004f, -0.00903302f, 0.05044869f, 0.04869386f, 
    -0.01380803f, -0.00356756f, -0.01653286f, -0.06305432f, 0.04696914f, -0.03272280f, 0.04630673f, 0.01340567f, 
    -0.01164489f, -0.06198202f, 0.02090970f, 0.04066286f, 0.02575102f, -0.02067208f, 0.03697351f, 0.02010251f, 
    0.02322996f, -0.01701543f, -0.03005752f, -0.03812333f, 0.02256408f, 0.00267711f, 0.04631534f, -0.06063157f, 
    0.00478007f, -0.02005591f, -0.02277129f, 0.00838799f, -0.05360668f, -0.05037046f, -0.05599755f, 0.00350325f, 
    0.03147267f, 0.01780510f, -0.03549031f, 0.04529097f, 0.03269651f, 0.01516900f, 0.02490948f, -0.01275809f, 
    -0.03220295f, -0.01951670f, -0.01314336f, 0.01192534f, -0.01390594f, -0.00781733f, -0.03736912f, -0.03210524f, 
    -0.05923746f, 0.04100110f, -0.05223145f, -0.06440996f, 0.00039316f, 0.01306756f, -0.00262241f, -0.04627903f, 
    -0.06273217f, 0.01631898f, -0.00473648f, 0.03361768f, 0.03762070f, -0.03746386f, -0.05094352f, -0.04421560f, 
    -0.05191381f, -0.03993482f, 0.04488810f, -0.00737130f, -0.00593055f, -0.02614330f, -0.02775054f, 0.04561681f, 
    -0.01868146f, -0.00505480f, -0.02163032f, 0.01984008f, -0.03041629f, 0.00378321f, 0.00410142f, -0.03067822f, 
    -0.04514709f, 0.03646318f, -0.03997548f, -0.02972184f, 0.04577650f, -0.01700444f, -0.05413651f, -0.00221543f, 
    0.04048467f, -0.05936527f, 0.03741254f, 0.03044294f, 0.03358844f, -0.04773863f, -0.05323569f, 0.01121447f, 
    -0.03644726f, -0.01413805f, 0.04035402f, -0.02496939f, -0.02808616f, -0.04311491f, 0.00702133f, -0.04889914f, 
    -0.01850262f, -0.03353392f, -0.00907405f, -0.05934042f, -0.05388722f, -0.04491675f, -0.04242920f, 0.00170251f, 
    0.02066018f, -0.05941170f, 0.03506413f, -0.00790225f, -0.01046911f, 0.03593763f, 0.04821900f, 0.00567192f, 
    0.02019815f, -0.01848913f, -0.06061730f, 0.05022987f, -0.05189954f, -0.01549894f, 0.04184191f, -0.00788600f, 
    -0.04170969f, 0.03245984f, -0.02321676f, 0.02805012f, 0.00597204f, -0.00529695f, -0.04868812f, -0.01177988f, 
    0.00769153f, -0.03028180f, 0.02174676f, 0.00141988f, -0.05155204f, -0.00243956f, 0.02766539f, -0.05225381f, 
    0.01061101f, -0.03231839f, -0.05071327f, 0.04195614f, 0.02511494f, 0.03112737f, 0.03385509f, 0.02162398f, 
    0.03872171f, -0.01078552f, 0.01672041f, -0.02861186f, -0.01784401f, -0.02363525f, -0.00583522f, -0.04397110f, 
    -0.00612787f, -0.00742742f, 0.02115250f, 0.03476837f, -0.03597162f, 0.02540108f, -0.01458065f, 0.00714250f, 
    -0.00714033f, -0.02782913f, 0.02092970f, -0.02797168f, 0.01558175f, -0.05155564f, -0.05134418f, 0.01506792f, 
    0.04722751f, 0.01079622f, -0.03757281f, -0.03738799f, 0.03343273f, -0.00121664f, 0.02331279f, -0.02031541f, 
    0.03375667f, 0.00671252f, 0.04921114f, -0.05162901f, -0.02829214f, 0.04646219f, -0.04604549f, -0.01770155f, 
    -0.05423105f, 0.04877741f, -0.04948528f, 0.05339731f, -0.03996750f, -0.05727832f, 0.01452596f, -0.04882379f, 
    -0.05245508f, 0.00399733f, 0.04248486f, -0.04970312f, 0.04991225f, -0.06430826f, 0.02924370f, 0.01436078f, 
    -0.02559334f, -0.02146677f, 0.03917364f, -0.01960440f, 0.00056476f, -0.02169030f, -0.05375555f, -0.05851299f, 
    0.09938498f, -0.26330510f, 0.17338370f, 0.04804315f, -0.05026370f, 0.13643643f, 0.00250979f, 0.00347978f, 
    0.05920701f, 0.04631185f, 0.02622644f, 0.15128039f, 0.09445597f, -0.04892911f, 0.03437377f, 0.06223667f, 
    -0.01327309f, 0.03714023f, 0.08242927f, -0.02841231f, 0.11897421f, 0.03882946f, 0.08665580f, -0.01575423f, 
    0.03887281f, -0.08911671f, -0.04256646f, 0.05366168f, -0.04397404f, -0.05326838f, -0.00974889f, 0.05353533f, 
    0.01845976f, -0.03265810f, -0.07383027f, 0.03410767f, -0.23335660f, -0.11297545f, 0.02614480f, -0.06021084f, 
    -0.00136270f, 0.02205948f, -0.04873230f, -0.17407094f, -0.11447013f, -0.07026484f, 0.07002720f, 0.26630858f, 
    -0.09760790f, -0.09726577f, -0.00402466f, 0.05984921f, 0.08406413f, -0.00790455f, -0.45022070f, 0.37662944f, 
    0.38248414f, -0.00216476f, 0.03705152f, -0.01486496f, -0.02069196f, -0.06069881f, -0.01959913f, -0.14182164f, 
    -0.06931042f, 0.05084829f, 0.13341641f, 0.21018934f, 0.04658539f, -0.07334679f, -0.08915496f, -0.06069491f, 
    -0.06108787f, 0.20525384f, 0.04880439f, 0.04989285f, -0.06956193f, 0.15153302f, -0.05527918f, 0.01452237f, 
    -0.03315721f, 0.09436265f, 0.13300826f, 0.02871041f, -0.01420038f, -0.01574607f, 0.05462549f, 0.10315278f, 
    0.09681982f, 0.08043914f, 0.13677804f, 0.10791557f, 0.28516024f, -0.03353279f, 0.07123946f, -0.04486891f, 
    0.00067263f, 0.04907012f, -0.08911913f, 0.00120108f, -0.12541352f, -0.01854744f, -0.06188368f, 0.18881504f, 
    -0.13923793f, -0.14591476f, 0.02563183f, -0.12482511f, -0.01541002f, -0.10875601f, 0.09964176f, -0.00731236f, 
    0.08177117f, 0.04336679f, 0.06556021f, 0.01331966f, 0.05492358f, 0.11799303f, -0.12434912f, 0.11630693f, 
    -0.10848802f, 0.07414998f, 0.11964446f, 0.03487482f, -0.19773263f, -0.02948700f, 0.08391858f, 0.18592326f, 
    0.09538718f, 0.05543885f, -0.02803061f, -0.07677039f, -0.02352176f, 0.16009694f, 0.03126230f, 0.08670587f, 
    0.03234031f, -0.02457037f, -0.07875911f, -0.04709000f, -0.12730421f, 0.01356333f, -0.06255066f, -0.08247855f, 
    -0.16362610f, -0.09138344f, -0.04045815f, -0.00731364f, 0.01100434f, -0.00179202f, 0.11712137f, 0.03633121f, 
    0.05935143f, 0.27951252f, 0.33871558f, -0.05106827f, -0.05504277f, 0.05886402f, -0.02926212f, -0.03014461f, 
    0.13210349f, -0.07762956f, -0.06024400f, 0.19633573f, 0.07721291f, 0.00648243f, 0.03949771f, 0.01995633f, 
    -0.00775467f, 0.00009985f, 0.03458709f, 0.17873481f, 0.25656289f, 0.14130655f, 0.00018717f, -0.00753277f, 
    0.14429106f, -0.05012188f, 0.03242071f, -0.07120328f, 0.12069713f, 0.16090930f, 0.28386199f, -0.04674245f, 
    0.13043045f, -0.01074708f, -0.08534179f, 0.04266344f, 0.01494185f, 0.11038779f, 0.11475911f, 0.06412842f, 
    -0.00237431f, 0.03465214f, 0.07860170f, -0.19130883f, 0.02273611f, -0.14311936f, 0.14475104f, 0.35459942f, 
    -0.05640786f, -0.05013603f, -0.06877083f, -0.10762085f, -0.17792656f, 0.09224779f, -0.03363026f, 0.11284426f, 
    -0.14312373f, -0.03758653f, -0.10727219f, -0.17043380f, -0.02087294f, -0.08760095f, 0.06449451f, -0.10514098f, 
    -0.27207208f, 0.25024104f, -0.16436879f, 0.09636587f, -0.00096208f, 0.12593110f, 0.03611662f, -0.01645665f, 
    -0.07471170f, 0.06191145f, -0.12407388f, -0.04675670f, -0.11981791f, -0.05134232f, 0.04701975f, -0.03746606f, 
    0.04342835f, -0.02021454f, -0.02112853f, -0.05670726f, -0.02585940f, 0.00552261f, 0.08505540f, -0.07497200f, 
    -0.04152661f, 0.02499407f, -0.11479168f, -0.32280841f, -0.05139060f, -0.02157610f, 0.09399959f, 0.03789962f, 
    0.13892448f, 0.10948401f, 0.01080767f, -0.14894493f, 0.13154107f, 0.17130747f, 0.10938326f, 0.06736520f, 
    -0.05652999f, -0.04382956f, 0.06033356f, -0.06627084f, -0.02915163f, -0.32900783f, 0.00180452f, -0.03274409f, 
    -0.22726408f, -0.06678467f, -0.00632005f, 0.10983822f, 0.04134736f, 0.14934580f, -0.25122029f, -0.18532592f, 
    0.01353504f, -0.02557925f, -0.01176190f, 0.07643931f, 0.04242951f, 0.08593171f, 0.05964835f, -0.11983231f, 
    -0.27435490f, -0.06606323f, -0.10219792f, -0.08090705f, -0.01055472f, 0.08109894f, 0.00656243f, -0.02926506f, 
    0.33081183f, -0.12701809f, -0.02868127f, 0.05716940f, -0.01427930f, 0.03325867f, 0.12754114f, 0.08338629f, 
    -0.09057176f, -0.07901872f, -0.21047725f, -0.25237471f, 0.09380459f, 0.02380822f, 0.04331988f, 0.02647355f, 
    -0.00269035f, -0.00607453f, -0.02917315f, 0.03032901f, -0.35584173f, 0.01017933f, -0.00620461f, -0.16309549f, 
    0.05351893f, 0.08365674f, 0.11573055f, 0.06721807f, 0.10586311f, 0.02233618f, -0.10091806f, 0.00722416f, 
    -0.02196257f, 0.00394230f, -0.01391923f, 0.16464344f, 0.11343078f, 0.07906300f, -0.03926673f, -0.08013371f, 
    -0.06338508f, -0.03349961f, 0.11507832f, -0.04144229f, 0.01675493f, -0.20278503f, -0.47799814f, -0.32371527f, 
    -0.23342212f, 0.01064398f, -0.32603997f, -0.00191024f, 0.04500175f, 0.11763910f, -0.75662851f, -0.25887263f, 
    0.34984478f, -0.05462172f, 0.03175480f, -0.05105028f, 0.05343192f, 0.13987236f, -0.05865433f, 0.17486189f, 
    0.32743686f, 0.21265833f, -0.01555164f, -0.06683053f, -0.04712935f, 0.11927051f, 0.08032805f, 0.19498733f, 
    -0.07223836f, -0.15884210f, -0.06311443f, -0.04441928f, -0.02194655f, 0.08793109f, 0.03676870f, 0.11395488f, 
    0.05050165f, -0.25677502f, -0.17075016f, 0.09998652f, -0.14364479f, 0.03014933f, -0.22456329f, 0.01369333f, 
    -0.04834380f, 0.05090161f, 0.27312449f, 0.14987375f, -0.09189159f, -0.19217183f, 0.21338391f, 0.01344292f, 
    0.19747072f, -0.09720905f, 0.08050806f, 0.17892821f, 0.11971601f, 0.21265881f, 0.03807571f, -0.10587782f, 
    0.05201093f, -0.04880075f, 0.02458765f, 0.08333001f, 0.11360785f, 0.20855017f, 0.16672254f, -0.19865012f, 
    0.09025060f, 0.02930878f, 0.05273847f, -0.11511339f, -0.02742118f, -0.02461965f, 0.01113992f, -0.31991097f, 
    -0.03689978f, -0.08498849f, -0.07357094f, 0.03033823f, 0.09775796f, 0.07923658f, -0.06041763f, -0.35181123f, 
    -0.24955857f, -0.03058455f, -0.19036220f, -0.14293784f, -0.03550847f, 0.03674649f, -0.00942100f, -0.63326746f, 
    -0.26282755f, -0.13875531f, -0.02620784f, 0.05076560f, 0.14900233f, -0.04174380f, -0.02325137f, 0.06502169f, 
    0.26703525f, 0.11639903f, 0.15576716f, 0.00528627f, -0.02451220f, 0.11190799f, 0.02062928f, -0.01836265f, 
    -0.03432252f, -0.25341168f, -0.12009280f, 0.07986384f, 0.07795072f, -0.05430954f, 0.01620530f, -0.04064181f, 
    0.07991741f, -0.08395808f, -0.51370502f, -0.27797881f, 0.03915302f, 0.05851257f, -0.11403856f, -0.03748737f, 
    0.03024971f, -0.11981378f, -0.12136167f, -0.11746510f, -0.15861186f, -0.00159342f, -0.13284750f, -0.05491825f, 
    -0.10646303f, 0.00779165f, -0.08639211f, 0.08698142f, 0.38431245f, 0.05290448f, 0.08882425f, 0.07355145f, 
    -0.01322702f, 0.18653631f, 0.10111956f, -0.08435156f, 0.05729406f, -0.03648071f, -0.13639569f, -0.26356077f, 
    -0.06126293f, 0.09643920f, 0.09933998f, 0.08019715f, -0.01275470f, 0.10254271f, -0.18282101f, -0.21533573f, 
    -0.16050163f, 0.10942625f, -0.18784900f, -0.02338076f, 0.24169567f, -0.01668150f, 0.08300877f, 0.83987534f, 
    -0.17374824f, -0.35580373f, -0.06764060f, 0.06022966f, -0.16521098f, 0.03408359f, -0.05656078f, -0.01959661f, 
    -0.80402118f, 0.20913991f, 0.14380322f, -0.12784211f, -0.05172141f, 0.03437882f, 0.00559387f, 0.00789740f, 
    -0.13790751f, 0.07791888f, -0.33333915f, -0.68951225f, 0.03517720f, 0.02864039f, -0.02122755f, 0.03591784f, 
    0.00065953f, -0.01713033f, 0.09589992f, 0.17439811f, 0.02851230f, -0.09009045f, 0.03255869f, 0.13415325f, 
    -0.08233859f, 0.10131848f, -0.02555835f, -0.26732272f, -0.07917083f, -0.04893405f, 0.00540313f, 0.05435923f, 
    -0.00383958f, -0.06741248f, 0.19383343f, -0.03154103f, -0.28171721f, -0.14073882f, 0.15354882f, -0.17558578f, 
    0.31402642f, -0.05298077f, 0.02460027f, -0.04387538f, 0.05264421f, 0.33769369f, -0.09559802f, 0.02549572f, 
    0.05034292f, -0.02492560f, 0.02330652f, 0.17455989f, 0.08038180f, 0.07721993f, 0.25152555f, 0.05634302f, 
    -0.01183824f, -0.02541926f, 0.02202445f, 0.05922020f, 0.03285920f, -0.02463864f, 0.01471978f, 0.06327637f, 
    -0.06149335f, -0.21709265f, -0.09248574f, -0.00826367f, 0.07111206f, -0.10480368f, 0.05607430f, 0.02827864f, 
    0.25147432f, -0.08390574f, -0.09146978f, 0.08321883f, 0.06218585f, 0.07082356f, -0.01160426f, 0.00892463f, 
    -0.06418312f, -0.17538534f, -0.05334207f, -0.02421231f, -0.04174776f, -0.13598157f, -0.00937073f, -0.04198152f, 
    -0.03701911f, 0.00315356f, -0.03924773f, -0.02327675f, -0.11114266f, 0.02450660f, -0.00435521f, 0.05332452f, 
    0.13651246f, -0.03154291f, -0.01438460f, 0.05402189f, 0.21432559f, -0.09397623f, 0.07940486f, 0.08968150f, 
    -0.02694704f, 0.09993631f, -0.01908030f, -0.15693215f, 0.12399088f, 0.07579371f, 0.15428665f, 0.08225610f, 
    -0.06371020f, 0.05776577f, 0.00274557f, 0.07723023f, -0.00488476f, -0.24081615f, -0.35962865f, -0.15499212f, 
    0.07926698f, -0.01203674f, -0.07768475f, -0.29870856f, -0.06704665f, 0.15838622f, -0.42155570f, 0.05488176f, 
    0.05428672f, 0.04886985f, -0.00767945f, -0.06138689f, 0.14496650f, -0.06276056f, 0.12622678f, -0.10708293f, 
    -0.01978595f, 0.26748043f, 0.06779630f, 0.13149574f, -0.04361628f, 0.13620096f, 0.04383197f, -0.07115793f, 
    -0.08344227f, 0.06369329f, 0.17305766f, 0.17976090f, 0.07268302f, -0.06480709f, -0.07623934f, 0.02462373f, 
    -0.12392301f, -0.07432628f, 0.04836731f, -0.06038143f, 0.00011609f, -0.14340234f, -0.13681012f, 0.04457516f, 
    -0.24315098f, 0.05090617f, 0.22894302f, -0.18867755f, -0.04610869f, -0.01894801f, -0.07569100f, 0.04736622f, 
    -0.02560664f, 0.05689313f, -0.14223787f, 0.16729183f, 0.08913053f, 0.20634609f, 0.10444336f, 0.00951222f, 
    -0.00519436f, 0.08986840f, 0.07171012f, 0.06521226f, 0.06507192f, 0.07047401f, 0.05724085f, 0.16754435f, 
    0.08899616f, -0.05088060f, -0.10423112f, 0.11644734f, -0.08297893f, 0.13374491f, 0.02198287f, 0.00509492f, 
    -0.06631687f, -0.06342477f, 0.08756258f, 0.00691568f, -0.05416597f, 0.07287247f, -0.07175685f, -0.20054179f, 
    -0.19105843f, 0.00062932f, -0.06821750f, 0.03302514f, 0.09145459f, 0.06096721f, 0.08166707f, -0.03095976f, 
    0.02548812f, 0.08288441f, 0.07121842f, 0.03756287f, -0.11898904f, 0.00731391f, -0.16848437f, 0.19118419f, 
    -0.17287041f, 0.07612374f, 0.15020061f, 0.05339661f, 0.06241384f, -0.01017011f, 0.02993136f, -0.08213052f, 
    0.09359441f, -0.07456611f, -0.14279236f, -0.10777231f, 0.08771113f, -0.00070000f, -0.11614763f, 0.13684210f, 
    0.08759899f, 0.09112959f, -0.13798618f, -0.08316172f, 0.01419526f, 0.02701680f, -0.05003918f, 0.00651666f, 
    0.01164123f, -0.07708841f, -0.02728517f, 0.07643850f, 0.02529317f, -0.03996600f, 0.05423696f, 0.08931345f, 
    -0.12802209f, 0.00541996f, -0.09399647f, -0.04757185f, -0.19399963f, -0.03310071f, -0.08661851f, -0.11868937f, 
    -0.03336117f, 0.04561834f, 0.05620788f, 0.03571397f, -0.19702679f, -0.15363130f, -0.11177087f, -0.06942186f, 
    -0.17683111f, -0.04911884f, -0.21486892f, 0.01175688f, 0.06993187f, -0.05936110f, 0.01399980f, -0.14076276f, 
    -0.22314282f, 0.06003237f, 0.07865892f, -0.00994089f, -0.02478583f, -0.24553201f, -0.25747848f, 0.10733612f, 
    0.02214626f, 0.00633255f, 0.08625322f, 0.08006478f, -0.04438769f, -0.00885227f, -0.12745588f, 0.02481485f, 
    -0.18731743f, 0.17597948f, -0.11631364f, 0.09969243f, -0.03604507f, -0.04110429f, -0.35205802f, 0.15471044f, 
    -0.21688132f, 0.13459161f, 0.07339072f, 0.05491981f, -0.15847239f, -0.05583973f, 0.03903958f, 0.10211825f, 
    -0.03486548f, 0.07408851f, 0.07371426f, 0.07266142f, -0.03914977f, -0.14060433f, 0.03116822f, 0.08294991f, 
    0.09088758f, 0.13576041f, -0.08743093f, 0.04686002f, -0.12698470f, 0.35706586f, 0.13453192f, 0.00023253f, 
    -0.03053110f, -0.23433140f, -0.00901176f, 0.01698680f, -0.22109048f, -0.25277928f, -0.06803841f, -0.12041705f, 
    0.09891714f, 0.02878310f, -0.07509512f, 0.04001821f, 0.12182398f, -0.45441291f, -0.00656792f, 0.24404079f, 
    0.10470381f, -0.13114566f, -0.09992457f, 0.00504252f, -0.23619388f, 0.01433407f, 0.01021315f, 0.07007955f, 
    0.10941818f, -0.03595040f, 0.04855794f, 0.05937353f, 0.06745750f, -0.10872550f, 0.04938573f, 0.17182222f, 
    0.11137621f, 0.11652986f, -0.10156942f, 0.12374020f, -0.06044503f, -0.03682544f, -0.01991468f, 0.03272691f, 
    0.46740678f, -0.24112168f, -0.25668973f, 0.05650591f, -0.01920542f, 0.03809387f, -0.06150373f, -0.01473549f, 
    0.03730293f, -0.00253692f, -0.01139049f, 0.02622037f, -0.10019244f, -0.09698557f, 0.08365893f, 0.07829314f, 
    0.05812949f, 0.05170347f, -0.11496805f, -0.45910478f, -0.26732200f, -0.02187746f, 0.08881967f, -0.02581822f, 
    0.12507409f, 0.10506095f, -0.09178309f, -0.15937784f, 0.07359570f, -0.27457160f, 0.02093451f, -0.09502713f, 
    -0.06246325f, -0.01954903f, 0.07748923f, 0.13128719f, 0.06942950f, 0.08280230f, -0.00987373f, 0.00689046f, 
    0.13581043f, 0.16890916f, 0.09230869f, 0.05374711f, 0.10064893f, -0.01937918f, -0.29071146f, -0.50855029f, 
    -0.15502799f, 0.01163042f, -0.00903959f, -0.00646747f, -0.03755293f, -0.08600674f, -0.55590016f, -0.23544435f, 
    -0.05794005f, -0.06675383f, -0.15447181f, -0.20206867f, 0.08235449f, 0.08978356f, 0.02457536f, -0.16178958f, 
    -0.19423468f, -0.25574473f, -0.13732855f, -0.08752193f, -0.00382945f, -0.12027864f, -0.12103460f, -0.02425365f, 
    -0.22764778f, 0.11500492f, 0.06583005f, 0.11459860f, 0.08168890f, 0.04555555f, 0.01976257f, 0.08548480f, 
    0.12148644f, 0.06326848f, -0.16624659f, 0.17813616f, -0.03469115f, 0.01201268f, -0.02753729f, -0.02520104f, 
    -0.03106366f, 0.02984976f, 0.08589569f, -0.16404752f, -0.39776683f, 0.01452986f, 0.02088097f, 0.20888695f, 
    -0.00350090f, -0.11598200f, 0.13327496f, -0.10338512f, -0.14358936f, 0.12247223f, -0.03398117f, 0.04152332f, 
    0.01117841f, 0.08599337f, 0.06841120f, 0.04928489f, 0.19802329f, -0.25090152f, -0.18705069f, 0.05475226f, 
    -0.07967504f, 0.01167683f, 0.05395659f, 0.02240477f, 0.02706909f, 0.34630093f, -0.12993811f, 0.14331514f, 
    -0.00722812f, 0.08710055f, 0.22431163f, 0.10279992f, 0.05000595f, 0.02868751f, 0.08694077f, -0.22045061f, 
    0.01480582f, 0.09228085f, 0.03445267f, 0.16290613f, 0.03161982f, 0.06280305f, 0.06853117f, -0.52349466f, 
    -0.37034023f, 0.05249397f, -0.14355704f, 0.07661034f, -0.17564538f, 0.19083358f, -0.17163078f, 0.03028810f, 
    0.08776911f, 0.13093843f, 0.13810955f, 0.02929428f, -0.05914819f, -0.01571168f, -0.03525803f, 0.01722595f, 
    0.11341225f, -0.13762735f, -0.34246674f, 0.11994611f, 0.04574453f, 0.14809380f, 0.06083509f, 0.16423890f, 
    0.10711630f, 0.15683533f, -0.40603748f, -0.24965408f, -0.15664080f, -0.14188930f, -0.13417950f, -0.02610548f, 
    -0.03126791f, 0.02473820f, -0.02968551f, 0.03863327f, -0.12798966f, 0.41097799f, 0.09428966f, 0.13735715f, 
    0.18911895f, 0.15610662f, -0.00725924f, 0.18442625f, -0.07142041f, 0.00121143f, 0.06939830f, -0.18435086f, 
    -0.07669029f, 0.01206682f, -0.03104953f, 0.04542244f, -0.00949126f, -0.09228417f, -0.02238195f, 0.11583528f, 
    0.07469817f, -0.03044217f, -0.07233573f, -0.06113062f, 0.04763752f, 0.08531192f, -0.38084832f, -0.46186695f, 
    0.07941829f, -0.09908091f, -0.15420982f, -0.09395371f, -0.11036234f, -0.23922238f, -0.14492457f, 0.39303958f, 
    -0.01157632f, 0.13595682f, -0.11353146f, -0.10930144f, -0.18850510f, 0.11810426f, 0.06974972f, 0.03688590f, 
    -0.53609049f, -0.11004338f, 0.02346754f, -0.05078997f, 0.09055585f, 0.07648467f, 0.24954002f, 0.01227182f, 
    -0.14418641f, 0.27162230f, -0.02664353f, 0.14649852f, -0.07394944f, -0.03063217f, -0.11078122f, 0.05972829f, 
    0.06321806f, 0.04478042f, -0.25561464f, -0.09442130f, 0.31422329f, 0.04667432f, -0.10328764f, 0.06602486f, 
    -0.09547269f, -0.02903100f, -0.01050084f, -0.71427453f, -0.31504226f, -0.33469579f, -0.01101213f, 0.04739878f, 
    -0.19853432f, 0.11669358f, 0.05500444f, -0.01853922f, 0.01087019f, -0.07993846f, -0.06466864f, -0.17356697f, 
    0.11729001f, 0.10075779f, -0.10478045f, 0.16125658f, -0.00239010f, -0.13621961f, -0.10417880f, 0.04167416f, 
    -0.01605984f, -0.14889947f, -0.31178325f, -0.04293359f, -0.08714504f, 0.10655388f, -0.03568709f, 0.03933349f, 
    0.02211628f, 0.00282082f, 0.08477707f, 0.13146877f, 0.11698394f, 0.12722124f, 0.11838288f, 0.16256425f, 
    -0.06990156f, -0.02260274f, -0.14779271f, 0.00751758f, -0.06387713f, 0.00473734f, 0.07196216f, 0.10054450f, 
    -0.01305931f, 0.15020198f, 0.18227230f, 0.02394671f, -0.12042128f, 0.10483358f, 0.06127954f, -0.06491809f, 
    0.21829709f, -0.03114955f, 0.09846954f, -0.18906519f, 0.02477475f, 0.05229549f, 0.05484692f, 0.10501345f, 
    -0.05558334f, -0.04934573f, 0.24389309f, 0.06127005f, 0.12030787f, 0.04929177f, -0.00960070f, 0.05062277f, 
    -0.02030008f, -0.08081645f, -0.03205593f, -0.18459237f, 0.08550038f, 0.16297157f, 0.14079845f, 0.03330421f, 
    0.01919490f, 0.03145139f, 0.03615024f, -0.10324486f, -0.06011739f, 0.00931959f, -0.00155247f, 0.04092909f, 
    -0.01803273f, 0.12878916f, 0.00985647f, -0.10891901f, -0.00689375f, -0.08056393f, 0.30751586f, -0.40544015f, 
    0.01010029f, -0.07599849f, -0.02758951f, 0.05390454f, -0.12944417f, -0.13506848f, -0.15220344f, -0.11461704f, 
    -0.05628037f, -0.18144745f, 0.07346421f, 0.08471438f, 0.12409354f, 0.04445444f, 0.02359160f, 0.01167136f, 
    0.06987093f, 0.04926058f, 0.16487581f, -0.04565224f, -0.13237533f, -0.22267696f, -0.31728446f, -0.22656138f, 
    -0.07470200f, -0.03075946f, 0.04078337f, 0.00400419f, -0.00921375f, -0.02678101f, -0.07353739f, 0.01406750f, 
    0.02846950f, 0.13870126f, -0.00482712f, -0.05130305f, 0.04865858f, 0.02210772f, 0.00809318f, 0.00799035f, 
    0.00167580f, 0.01301899f, -0.17954011f, 0.08897558f, -0.23439696f, -0.03031992f, 0.16985315f, 0.03829018f, 
    0.03300437f, 0.00830335f, -0.15440692f, 0.17284733f, -0.07692225f, 0.02133687f, -0.08778679f, -0.01289684f, 
    0.06057483f, 0.12138563f, -0.13618465f, -0.15486450f, -0.06079393f, 0.08933669f, 0.18394814f, 0.18890874f, 
    -0.04711775f, 0.01201520f, 0.04741486f, 0.14466974f, 0.07919787f, 0.03806640f, -0.20835012f, 0.08191843f, 
    -0.03655283f, -0.00435173f, 0.09219604f, -0.02915700f, 0.02056166f, -0.01527143f, 0.01719573f, 0.13270052f, 
    -0.11907684f, 0.02550321f, -0.06667587f, -0.01396051f, -0.07349300f, -0.10870123f, -0.13224526f, 0.10591088f, 
    -0.37777475f, 0.00183916f, -0.05982353f, 0.09450921f, 0.04644270f, 0.01603289f, 0.03513570f, -0.04129223f, 
    0.17368871f, -0.09317823f, 0.18105930f, 0.00696754f, 0.05710559f, 0.02164791f, 0.09543417f, 0.08132350f, 
    0.08110798f, 0.13884635f, 0.03153263f, -0.25099978f, -0.01540110f, 0.01332869f, -0.01293056f, -0.15696543f, 
    -0.18486597f, -0.08822425f, 0.08380771f, 0.22385177f, -0.27308637f, -0.06096454f, 0.07452931f, 0.01292179f, 
    0.02872332f, 0.11844314f, 0.03129436f, -0.07825352f, 0.11357645f, -0.03747907f, 0.20684338f, -0.02379235f, 
    -0.04988115f, -0.05970030f, 0.07684091f, -0.07467506f, 0.14734145f, 0.09723936f, 0.10898326f, -0.10638598f, 
    0.13777083f, 0.12973534f, 0.06973162f, -0.09773758f, -0.03027515f, -0.10008901f, -0.11045718f, 0.00368886f, 
    0.01538907f, 0.07022213f, -0.03781720f, -0.16997156f, -0.09463615f, -0.23689927f, -0.27237156f, -0.00360262f, 
    -0.24138404f, 0.02009355f, -0.13510226f, 0.04337050f, -0.00246271f, -0.08600376f, -0.01973205f, -0.19551036f, 
    -0.00399709f, -0.06067055f, 0.10039288f, 0.05472539f, 0.01810740f, -0.09474173f, 0.06627815f, -0.12787654f, 
    -0.04606319f, 0.17734987f, -0.22938287f, -0.22605795f, 0.00686974f, 0.15912467f, 0.21747495f, 0.09815323f, 
    0.01631396f, 0.01845675f, -0.09854817f, 0.12402841f, -0.01128947f, 0.04572239f, -0.01261666f, -0.10896816f, 
    -0.19422939f, -0.16049872f, 0.02907973f, -0.07947500f, 0.09703863f, 0.10399572f, 0.00937832f, -0.02496957f, 
    0.11575583f, -0.12880516f, -0.15152901f, -0.22027826f, 0.00637445f, 0.00647939f, -0.13997677f, -0.01395329f, 
    -0.10544214f, 0.11545915f, 0.04823665f, 0.20922732f, 0.04141457f, 0.00404323f, -0.18203634f, 0.04378726f, 
    0.07717026f, 0.01642100f, 0.12024616f, -0.05496071f, 0.03023754f, 0.21627092f, -0.00231620f, 0.08438860f, 
    -0.04798837f, 0.11748242f, -0.14438130f, 0.08372790f, -0.04994506f, 0.00027510f, 0.12014317f, -0.13817397f, 
    0.12614568f, -0.10381366f, 0.07752560f, 0.04166767f, 0.07526189f, 0.00634425f, 0.08024705f, 0.24111867f, 
    0.00753408f, 0.21639214f, 0.05537705f, 0.00054249f, 0.01937801f, 0.11972785f, 0.02736504f, -0.06485536f, 
    0.02321427f, -0.30422118f, -0.03745453f, -0.08866865f, -0.19242570f, 0.20127617f, 0.07212862f, -0.03336025f, 
    -0.00589020f, -0.32239431f, -0.04680854f, -0.16357793f, -0.10784718f, -0.15269454f, -0.04918573f, 0.12106144f, 
    0.11729546f, -0.09499472f, -0.14763382f, -0.01067578f, 0.18084581f, 0.01148432f, -0.08115448f, -0.14815480f, 
    -0.02696230f, -0.10050291f, -0.14256036f, 0.04886553f, 0.11085527f, 0.31480893f, 0.13230349f, -0.00426732f, 
    0.04269339f, 0.05651391f, 0.03098901f, 0.00458341f, 0.06964035f, 0.21241346f, 0.33119392f, -0.13740763f, 
    0.03154607f, -0.05632335f, -0.00187191f, 0.24326880f, 0.01538752f, -0.08366036f, 0.11589070f, 0.30580795f, 
    -0.06556765f, -0.03778388f, -0.24126066f, 0.03187184f, 0.08261980f, -0.02133785f, -0.20665714f, 0.20135614f, 
    -0.16561863f, -0.02063365f, -0.19228862f, -0.10924310f, -0.04101186f, 0.01370474f, 0.22617391f, 0.09898496f, 
    0.04460174f, 0.03564956f, 0.13403301f, -0.14330414f, -0.13041696f, 0.28440952f, -0.03756266f, 0.07664680f, 
    -0.25547868f, 0.14759929f, -0.25029546f, -0.06352887f, 0.07506470f, -0.01461123f, 0.02127653f, -0.12633626f, 
    0.01329071f, -0.29054067f, 0.09774102f, 0.00071100f, -0.00936265f, -0.18118143f, -0.09362520f, 0.12590413f, 
    -0.02319271f, 0.10358565f, -0.31069073f, -0.10953227f, 0.03299641f, -0.15494934f, 0.00000210f, 0.12469050f, 
    -0.00636536f, 0.03052260f, -0.03358015f, 0.17536646f, 0.07876597f, 0.19190618f, -0.00354112f, -0.11155117f, 
    -0.11903891f, 0.06454947f, -0.00568540f, -0.01154281f, -0.05805799f, -0.14914566f, 0.07462655f, -0.06213793f, 
    -0.08244974f, -0.20018551f, 0.07917873f, -0.03519593f, 0.03202170f, -0.13019483f, -0.01050977f, 0.24175853f, 
    -0.01816202f, -0.08820742f, -0.06323596f, 0.01842632f, 0.11845607f, 0.01864807f, -0.23306595f, 0.02643078f, 
    -0.18869451f, 0.00245284f, -0.09891115f, 0.01302561f, -0.00171530f, 0.02035164f, 0.02341996f, -0.36036029f, 
    0.28173751f, 0.05329580f, -0.06482027f, 0.00107810f, -0.14163806f, 0.07172441f, -0.20201246f, -0.03948754f, 
    -0.15460977f, -0.16998258f, 0.04532425f, -0.12045085f, 0.03206258f, 0.00159724f, -0.02312283f, 0.06282926f, 
    -0.03227089f, -0.11541358f, -0.00376542f, -0.29564664f, 0.12133443f, 0.02999522f, -0.19079457f, 0.00568300f, 
    0.01891851f, -0.00983909f, -0.00985091f, -0.26904526f, -0.06039068f, 0.00328931f, -0.09662583f, -0.06960529f, 
    0.01679988f, -0.04161448f, 0.02943037f, -0.08513369f, 0.06040146f, -0.02609148f, 0.09240492f, 0.02196358f, 
    -0.15092354f, 0.04149954f, 0.02811119f, 0.05721826f, -0.19626015f, 0.07102592f, 0.06090439f, 0.09248256f, 
    -0.02824300f, 0.05400054f, 0.00813902f, 0.11334254f, -0.08567491f, -0.24954408f, 0.01984627f, -0.02589012f, 
    0.00285283f, 0.02515310f, -0.05970445f, -0.00329321f, 0.08255845f, 0.00023639f, -0.28088710f, -0.14366142f, 
    -0.02544573f, 0.06847676f, 0.04331667f, -0.14945653f, -0.01409057f, 0.11081545f, -0.07572315f, -0.18166289f, 
    -0.13537051f, -0.35075310f, 0.07014348f, -0.00716169f, -0.05263713f, -0.05649977f, -0.01324261f, 0.09416223f, 
    -0.35030144f, 0.06637123f, 0.08097928f, -0.06940860f, 0.00032032f, 0.10725434f, -0.00118030f, -0.02726107f, 
    0.00959482f, -0.05762463f, 0.06545552f, 0.04096037f, 0.00371016f, -0.04268930f, 0.00006924f, 0.02085503f, 
    0.06960351f, 0.03879543f, 0.01263392f, 0.01259365f, 0.26208293f, -0.08457620f, -0.12784934f, 0.05497587f, 
    0.08033197f, -0.00828220f, -0.00044242f, 0.05895318f, 0.12652868f, 0.14719655f, -0.06900904f, -0.02543214f, 
    -0.06201056f, -0.08700796f, 0.05207645f, -0.10454363f, -0.24270631f, -0.02922529f, -0.21376787f, -0.10837736f, 
    -0.03630859f, -0.04687687f, 0.06855590f, 0.14890365f, -0.03989693f, -0.36891496f, 0.00664662f, -0.16503377f, 
    0.03044266f, -0.08575948f, -0.06559757f, 0.04444868f, 0.03884974f, -0.03608437f, -0.09839541f, -0.08244851f, 
    0.20751834f, -0.02640920f, 0.04615074f, -0.13283841f, -0.05618982f, 0.02816756f, -0.00691427f, -0.07176601f, 
    -0.02038023f, 0.39268929f, -0.10018052f, -0.08887833f, -0.05104667f, 0.01941854f, -0.00642663f, -0.03574036f, 
    -0.35717228f, 0.16834573f, 0.16549090f, 0.01649764f, 0.01805463f, 0.10004804f, 0.00638117f, 0.25933754f, 
    0.16397631f, 0.11249562f, 0.00558276f, -0.11446121f, -0.09189964f, 0.06745392f, -0.02246673f, 0.05322063f, 
    -0.04049442f, -0.07530825f, 0.14121902f, 0.13411878f, 0.14613776f, -0.03214423f, -0.05013133f, -0.05323700f, 
    0.09711326f, 0.18499464f, -0.09349141f, -0.18612844f, -0.14077787f, 0.06993141f, -0.03770913f, -0.04011801f, 
    -0.09978414f, -0.00697942f, 0.08467758f, 0.02062703f, -0.10885101f, 0.01050995f, -0.11413608f, -0.01450059f, 
    0.09223597f, 0.00167702f, -0.02438721f, 0.05012282f, 0.00417141f, 0.11679959f, -0.14820276f, -0.13535880f, 
    -0.12516542f, -0.08602307f, 0.08145931f, -0.05009319f, 0.02773986f, -0.00135544f, 0.22011922f, 0.15681662f, 
    0.20367426f, -0.18564902f, 0.17649320f, 0.12511714f, 0.08435986f, 0.04208842f, -0.02564117f, -0.21755891f, 
    -0.12190877f, -0.16508681f, 0.00870663f, -0.13808493f, -0.32625064f, -0.27091184f, -0.16576034f, -0.20226672f, 
    -0.00166088f, 0.03521556f, -0.08070122f, -0.06014082f, 0.13230741f, 0.11493677f, 0.07817728f, -0.10851520f, 
    -0.03218905f, 0.04061700f, -0.00536242f, -0.07111426f, -0.03566512f, 0.15085927f, -0.01543005f, -0.02310432f, 
    0.12722489f, -0.10654119f, 0.03384298f, 0.05567737f, 0.01009950f, -0.15662616f, -0.01679138f, 0.03345867f, 
    0.05808213f, -0.14976446f, 0.05054897f, -0.11371037f, -0.02861458f, 0.03938008f, -0.01647715f, -0.26128250f, 
    -0.02648899f, 0.03549770f, 0.04163498f, 0.03084125f, -0.19562611f, -0.12238522f, 0.28915447f, -0.07794168f, 
    -0.10716694f, 0.02884628f, 0.09652602f, 0.11489144f, 0.11135626f, 0.05383233f, 0.07158911f, 0.00655253f, 
    0.02670483f, 0.05796952f, 0.10956968f, 0.05935190f, -0.03939909f, -0.01682697f, 0.08263890f, 0.04467066f, 
    0.04247027f, -0.00262730f, -0.03373869f, -0.00640600f, 0.03503772f, 0.00854460f, -0.13394940f, -0.05943014f, 
    -0.11143998f, 0.01518958f, 0.03146590f, 0.10123339f, 0.07313227f, -0.26797536f, -0.09279109f, 0.12215198f, 
    -0.08217634f, -0.20934707f, 0.16051172f, -0.12686534f, -0.02111948f, 0.05902590f, -0.02543958f, 0.09678204f, 
    0.22763889f, 0.03103101f, -0.19449957f, -0.04778344f, 0.06272355f, -0.02369522f, 0.10647333f, 0.06601525f, 
    0.07086287f, -0.07967810f, 0.23737513f, 0.04182757f, -0.26980886f, -0.10703273f, -0.02316305f, -0.00665203f, 
    0.09246444f, -0.10674778f, -0.04485138f, -0.02732808f, 0.04767039f, 0.12126110f, 0.01947230f, 0.12264882f, 
    -0.01416518f, 0.07716337f, 0.11624315f, -0.06041269f, -0.13735849f, -0.17043014f, -0.13913488f, -0.02346224f, 
    0.07798861f, -0.22569537f, -0.07699186f, 0.02492158f, 0.03764482f, 0.02045261f, -0.00354858f, -0.00654010f, 
    -0.04390045f, 0.05923427f, -0.07202417f, 0.09981155f, -0.36299860f, -0.02422929f, -0.10215977f, -0.03274655f, 
    0.07375025f, 0.12232490f, 0.15169926f, -0.07443736f, 0.12040275f, -0.01426948f, -0.19371092f, -0.10670154f, 
    0.10202421f, 0.11327643f, 0.05226545f, 0.03841376f, 0.06388810f, -0.10342535f, -0.02593939f, -0.08957864f, 
    -0.00261959f, -0.07489783f, 0.14519683f, -0.09010659f, -0.12071225f, -0.06474745f, 0.13660058f, 0.28203517f, 
    0.11256201f, -0.02230330f, 0.19080956f, 0.17744002f, 0.07740735f, -0.04803477f, 0.09318192f, -0.00671618f, 
    -0.15604328f, -0.12452907f, -0.02602123f, 0.05457278f, -0.06688322f, 0.03157998f, 0.08748274f, -0.12768339f, 
    0.01112546f, -0.09569307f, -0.10211263f, -0.10859597f, -0.26261199f, -0.02961366f, -0.08166781f, 0.01329432f, 
    -0.24069843f, 0.13867179f, -0.18095781f, 0.04273607f, 0.17253949f, -0.02276926f, -0.06973463f, -0.04398953f, 
    0.10763433f, -0.12212137f, 0.01330438f, -0.06220806f, -0.12201267f, 0.04684870f, 0.02394534f, 0.05128954f, 
    -0.18752213f, 0.07694138f, 0.08985960f, -0.01534284f, 0.08601478f, 0.18072125f, -0.02883975f, -0.01362877f, 
    -0.12500924f, -0.17663832f, 0.07697622f, 0.00943269f, 0.05907430f, 0.13785224f, 0.16083203f, -0.06671253f, 
    0.08091049f, 0.39224362f, 0.00966369f, -0.09016725f, 0.12905408f, -0.00300601f, 0.17757866f, 0.12690398f, 
    0.24286884f, -0.02129112f, -0.26953313f, 0.08009280f, 0.06047000f, 0.09096871f, 0.02615595f, -0.06987129f, 
    0.06803104f, 0.10480547f, 0.27881831f, 0.11130614f, -0.05603560f, -0.06887078f, -0.19900918f, 0.02272710f, 
    0.00014205f, 0.06054068f, -0.25969833f, 0.04608377f, -0.03126587f, -0.06837991f, -0.06949080f, 0.02632770f, 
    0.12805897f, -0.00152194f, 0.18394652f, -0.12938279f, -0.33712074f, -0.30345678f, -0.04096307f, 0.04830028f, 
    -0.07937653f, 0.13127331f, 0.07282915f, 0.18522996f, 0.33429560f, 0.11334166f, 0.13001111f, 0.14375794f, 
    0.13132769f, 0.12333664f, 0.06895772f, -0.00589571f, 0.05021336f, 0.29746515f, 0.15148491f, 0.11125132f, 
    -0.09058014f, -0.12083436f, -0.19178380f, -0.07813867f, -0.06842351f, 0.06055854f, -0.13526006f, -0.35823804f, 
    -0.18800750f, -0.07600013f, -0.18852790f, 0.04356576f, 0.09450354f, -0.16212612f, 0.07817569f, -0.22080141f, 
    -0.31709230f, -0.20707980f, -0.07771808f, -0.12534203f, 0.03836913f, -0.13260028f, 0.14671759f, 0.03364101f, 
    0.08568385f, -0.11694613f, -0.07325534f, 0.02347726f, 0.10283651f, 0.13470259f, 0.11490738f, 0.01689524f, 
    0.10607449f, 0.12907146f, 0.04510796f, 0.03802149f, -0.11823662f, -0.02599369f, -0.14434871f, -0.03386673f, 
    0.07426551f, 0.07214149f, 0.40196258f, -0.03740161f, -0.10423366f, 0.10854883f, 0.01593849f, 0.01756473f, 
    0.05870513f, 0.09390692f, -0.05672956f, 0.01632849f, -0.13761781f, -0.10072213f, 0.04971461f, 0.07164335f, 
    0.11955107f, 0.21195896f, -0.02368999f, -0.05635303f, 0.04674970f, 0.01311159f, 0.07689498f, -0.02950214f, 
    -0.07878210f, 0.00816131f, 0.07547420f, 0.03974191f, 0.09565196f, -0.20116876f, 0.05090386f, 0.01345909f, 
    0.05810561f, 0.25659108f, -0.00671276f, 0.15632999f, 0.17441252f, 0.10427387f, 0.18662417f, 0.14420027f, 
    0.12241499f, 0.06763549f, -0.02141653f, -0.03640067f, 0.13323815f, 0.09493218f, 0.00758245f, -0.49707723f, 
    -0.35588232f, -0.39145416f, -0.24062409f, 0.06980889f, 0.01282169f, 0.07431031f, -0.16290361f, -0.19568925f, 
    0.15868348f, -0.15077217f, -0.36724070f, -0.12922300f, 0.12198518f, 0.16076566f, 0.11727589f, -0.00938522f, 
    0.02686495f, -0.01511143f, -0.04109561f, -0.04307809f, -0.03697465f, -0.09615476f, 0.01064269f, 0.12794268f, 
    0.04072631f, 0.08576275f, 0.21763334f, 0.02601602f, 0.26362464f, -0.05320540f, -0.20399624f, -0.04126950f, 
    -0.03471579f, -0.05070255f, 0.07532322f, -0.12304323f, 0.05666594f, 0.11221296f, 0.04116904f, -0.02588479f, 
    0.00901832f, 0.01559464f, 0.06305001f, 0.01537977f, -0.21598805f, -0.23933114f, -0.13125443f, -0.27382055f, 
    -0.16550031f, 0.00326828f, 0.15700972f, 0.01638920f, 0.03575353f, -0.10325369f, 0.04445451f, -0.00832182f, 
    -0.07238639f, 0.01469751f, -0.04031829f, 0.25066426f, 0.10719572f, -0.03077110f, -0.18410236f, -0.13052452f, 
    -0.04479162f, -0.09640195f, 0.09772627f, 0.00111795f, -0.04917199f, -0.06889582f, -0.25140810f, -0.16430250f, 
    0.05688429f, -0.00822242f, -0.03461684f, -0.01915779f, -0.11461419f, -0.01696393f, -0.05031149f, -0.03862187f, 
    -0.39254582f, -0.13759443f, -0.03793987f, 0.03020059f, -0.13860889f, 0.00255774f, 0.00233778f, 0.05844010f, 
    -0.15909626f, -0.30261874f, -0.15414506f, -0.19797763f, -0.00529066f, 0.09754509f, 0.04967998f, 0.07716788f, 
    0.04180936f, 0.10484687f, 0.02570051f, -0.22970609f, -0.36834988f, -0.10759709f, 0.05682714f, -0.00804275f, 
    0.00992930f, -0.02259047f, 0.01186059f, -0.26646847f, -0.04727418f, -0.51626182f, -0.07938353f, -0.06518723f, 
    -0.12688965f, 0.09252755f, -0.10782737f, 0.02952286f, 0.17488892f, 0.15350233f, 0.05926610f, -0.11678356f, 
    -0.09595495f, -0.10343114f, -0.04555331f, 0.04557111f, 0.07960477f, -0.04420169f, -0.49224749f, -0.65607297f, 
    -0.22954701f, -0.04233780f, -0.06184737f, -0.10939693f, -0.25260741f, -0.14261825f, 0.11113744f, 0.09641450f, 
    -0.09262810f, -0.00815387f, 0.11216802f, 0.20450898f, 0.16047128f, 0.00049015f, 0.17808613f, -0.48698938f, 
    -0.58750027f, -0.51033437f, -0.10487603f, 0.06967463f, 0.06994258f, -0.08181680f, -0.16269791f, -0.00451463f, 
    -0.01881435f, 0.04659987f, -0.04437355f, -0.05017143f, -0.01885846f, -0.06311353f, 0.00483761f, 0.03862117f, 
    -0.00002633f, 0.03025961f, -0.02467538f, 0.05870425f, 0.02597281f, -0.04983686f, -0.03123317f, -0.00152358f, 
    -0.04203979f, -0.00435662f, -0.02340612f, -0.02410861f, -0.06259421f, -0.04235063f, 0.02591566f, -0.03864373f, 
    -0.00501504f, -0.03916025f, 0.03248475f, 0.04144856f, 0.00519753f, -0.05520320f, 0.04505951f, -0.00100421f, 
    -0.05640636f, -0.02345508f, 0.01200648f, -0.05930770f, 0.00940011f, 0.02694210f, 0.02154259f, 0.00919542f, 
    0.01504591f, -0.00898711f, -0.02957812f, -0.05426591f, -0.00333676f, 0.00203913f, 0.05146243f, 0.04948118f, 
    0.05629425f, -0.01594292f, -0.03918364f, -0.03239910f, -0.04873778f, -0.02025047f, -0.00395641f, -0.01473901f, 
    0.03575679f, 0.03741058f, 0.03839759f, -0.04760907f, -0.00431342f, -0.00815497f, 0.00069150f, -0.03151323f, 
    -0.01401174f, -0.05913207f, -0.02117088f, -0.01225925f, -0.06441586f, -0.04316408f, 0.00873647f, -0.00624077f, 
    -0.01712519f, 0.01918088f, 0.04629879f, 0.00308025f, -0.03871728f, -0.05507483f, -0.02755982f, 0.03293640f, 
    0.02214633f, 0.01365664f, -0.03089972f, -0.04564066f, -0.06170842f, -0.04037505f, 0.03864789f, -0.01551705f, 
    -0.04884461f, -0.04197437f, -0.00466981f, -0.03144188f, -0.02315304f, -0.02219165f, 0.01211074f, -0.03829554f, 
    -0.04107871f, 0.02268887f, 0.02418191f, -0.01149916f, 0.01334794f, -0.00923144f, -0.00244589f, -0.03063405f, 
    0.04241305f, -0.05839816f, 0.05027077f, 0.03567805f, -0.05718146f, -0.03796406f, 0.05039285f, -0.04387365f, 
    0.01433000f, 0.03521944f, 0.02425267f, -0.06108297f, 0.00258166f, -0.02902055f, -0.00333983f, -0.02810369f, 
    -0.04849606f, 0.00647764f, 0.03380934f, -0.00121032f, -0.01261946f, -0.02169581f, 0.00541428f, 0.03376995f, 
    -0.04604443f, -0.02102859f, -0.01046153f, 0.02078833f, 0.03772787f, -0.03113876f, -0.04769745f, 0.03257290f, 
    0.03100926f, 0.03572505f, 0.02787264f, 0.04336196f, 0.05087419f, -0.05244960f, 0.00470704f, 0.04085043f, 
    -0.04284929f, 0.01781594f, -0.06073267f, -0.00071342f, 0.02632477f, -0.03843698f, 0.00465109f, -0.03691167f, 
    -0.01992284f, 0.05466422f, 0.05946532f, 0.02548684f, -0.00694902f, -0.00041102f, -0.02796174f, -0.00910064f, 
    -0.02019678f, -0.05116374f, -0.03935778f, 0.02873407f, 0.04136769f, -0.03167521f, -0.00021764f, 0.01092588f, 
    0.01765496f, -0.00387784f, 0.04522641f, -0.04810308f, -0.02088469f, -0.03338828f, -0.04816873f, 0.00842702f, 
    0.01017971f, 0.01725939f, -0.00799549f, -0.02331841f, -0.01505288f, 0.00227311f, -0.03813567f, -0.02793824f, 
    -0.01456400f, 0.05259937f, -0.03670374f, 0.03108722f, 0.00351065f, -0.04103507f, -0.04374524f, -0.06270460f, 
    0.02314493f, 0.04928166f, -0.01840588f, -0.05085854f, 0.03940719f, -0.03480206f, 0.00455967f, -0.00044720f, 
    0.03439147f, 0.00486648f, -0.05007146f, 0.06266131f, 0.01102619f, -0.01362096f, 0.02302898f, -0.01185024f, 
    -0.04945632f, 0.00924772f, 0.02212751f, 0.00194126f, 0.03236972f, 0.00236124f, 0.02960813f, 0.03455459f, 
    0.04182364f, -0.06586201f, -0.03820215f, -0.00045227f, -0.00045143f, -0.04874811f, -0.05910349f, 0.00920829f, 
    -0.01480823f, 0.01875478f, 0.00030757f, 0.02120890f, -0.06440993f, -0.01333863f, -0.02394968f, 0.02699280f, 
    -0.05543870f, -0.02179706f, -0.05907962f, 0.03477486f, 0.01382573f, 0.04321597f, 0.04918026f, 0.04140802f, 
    -0.04335467f, -0.02136399f, -0.02780810f, 0.02840114f, 0.00308837f, -0.00961504f, 0.03199045f, 0.02848395f, 
    0.02633542f, -0.03477903f, 0.03115524f, -0.02083434f, -0.05036967f, 0.04895958f, 0.04892487f, 0.00108081f, 
    -0.03438093f, 0.01969612f, -0.01728111f, 0.00900204f, 0.04509367f, -0.02488008f, 0.01299904f, -0.05418053f, 
    0.02554900f, -0.01759793f, -0.04836592f, 0.01366654f, 0.04781518f, -0.06649844f, 0.03837194f, -0.04122287f, 
    -0.02055718f, -0.05399624f, 0.01417122f, -0.03933988f, 0.00308837f, -0.04978628f, 0.02936085f, -0.00857200f, 
    -0.02193478f, 0.02823179f, 0.03048209f, 0.03711423f, -0.05709358f, 0.04276403f, -0.02647653f, -0.04623077f, 
    -0.05084473f, -0.06262954f, -0.01133271f, 0.00810206f, -0.02143102f, 0.02172535f, -0.04834503f, 0.00420954f, 
    0.00266631f, 0.05617142f, -0.01397992f, -0.03860400f, 0.01640457f, 0.00808535f, -0.03654344f, -0.02692723f, 
    -0.05967831f, -0.01249461f, -0.02133234f, 0.00888156f, -0.05635902f, -0.00788241f, -0.02572711f, 0.02965233f, 
    0.00886964f, 0.00974762f, -0.03046819f, 0.01236571f, -0.00920922f, 0.02237379f, -0.06164943f, 0.05134938f, 
    0.04843379f, -0.04899813f, 0.00407710f, 0.05223359f, -0.00076807f, 0.00218392f, -0.01817425f, 0.04856819f, 
    -0.05456570f, -0.04583237f, -0.00423979f, 0.00746557f, -0.01025353f, -0.03729789f, 0.03693685f, -0.00293556f, 
    0.01038527f, -0.04524817f, -0.02659626f, -0.00753418f, -0.03260905f, 0.01094490f, 0.01729403f, 0.02237465f, 
    0.03565015f, 0.03232164f, -0.01499171f, 0.02679902f, -0.05661884f, 0.01023578f, -0.05522997f, -0.01845688f, 
    -0.03319523f, -0.00508264f, 0.02139009f, 0.00152170f, -0.05606123f, 0.00904070f, -0.04377933f, -0.04989480f, 
    -0.01559556f, -0.01380850f, 0.03166321f, -0.00758752f, -0.02063367f, -0.04864765f, -0.03314671f, 0.05151946f, 
    0.05424725f, -0.02792841f, 0.00056763f, -0.05754526f, -0.01935525f, -0.00898499f, -0.00887040f, -0.02717695f, 
    -0.05431796f, -0.01629221f, -0.05341080f, 0.00444199f, -0.04183022f, -0.00385800f, 0.04199172f, 0.05068562f, 
    -0.02756136f, -0.01474689f, 0.03001943f, 0.01218363f, -0.01993442f, -0.04126401f, 0.04310239f, -0.05156516f, 
    -0.05900379f, 0.02053429f, -0.04243018f, 0.01895838f, 0.04054670f, -0.06782247f, 0.04568127f, 0.00605711f, 
    -0.05815508f, -0.06259193f, 0.04234095f, 0.04808284f, 0.01424495f, 0.01659998f, -0.03331595f, -0.03607095f, 
    -0.02499497f, 0.04865070f, 0.02082008f, 0.02492415f, -0.02972059f, -0.04701704f, 0.04765548f, -0.03136829f, 
    -0.03187299f, 0.01790308f, -0.03440464f, -0.06077150f, -0.04001791f, -0.04040659f, 0.04732558f, 0.04374293f, 
    -0.04173466f, -0.02024305f, -0.01411589f, -0.05621308f, -0.02939047f, -0.05601244f, 0.03314210f, 0.02092548f, 
    -0.04225609f, 0.04415281f, -0.00998179f, -0.03236534f, 0.02064686f, -0.02431366f, -0.01716082f, 0.00310501f, 
    0.03889867f, -0.04512636f, 0.04904832f, 0.05048366f, -0.03793506f, 0.02069657f, -0.02513211f, -0.05493174f, 
    -0.04126755f, 0.01725547f, 0.03130155f, 0.01906445f, -0.01262290f, -0.01281943f, -0.00247603f, -0.01816084f, 
    -0.00240944f, 0.03546657f, -0.03980053f, 0.04084361f, -0.02172468f, -0.01786377f, -0.03782433f, 0.03650545f, 
    -0.01541199f, -0.06502944f, -0.03431346f, 0.04526797f, 0.01011038f, -0.04110780f, 0.05094966f, -0.00223248f, 
    -0.05094520f, -0.05683239f, 0.03387276f, 0.03660843f, 0.02027996f, -0.04007066f, 0.00852881f, 0.02450188f, 
    -0.00349935f, -0.03526195f, 0.02876464f, -0.04041487f, -0.02448242f, 0.00255623f, -0.05221412f, -0.03920208f, 
    0.00962284f, -0.00372199f, -0.06205674f, 0.04087209f, -0.02701085f, -0.02647051f, -0.01589201f, 0.04677882f, 
    -0.03721552f, -0.01776579f, -0.05365364f, -0.02002485f, -0.02665288f, -0.00404231f, -0.05598576f, -0.03049370f, 
    -0.00076258f, -0.05499270f, 0.04805665f, -0.00099046f, -0.02036274f, -0.05374854f, 0.05099990f, 0.03946558f, 
    0.00551218f, 0.02512373f, -0.04113509f, 0.02755573f, 0.04194861f, -0.03772247f, -0.03927825f, 0.02820170f, 
    -0.01185460f, 0.00795268f, 0.03754869f, -0.05133496f, -0.02328271f, -0.05155890f, -0.06629454f, 0.00574162f, 
    -0.04248438f, -0.00023122f, 0.02933739f, -0.04662462f, -0.03657885f, 0.01018305f, -0.00800597f, 0.00220893f, 
    -0.06247777f, -0.00695836f, -0.04087946f, 0.03448420f, -0.00688285f, 0.00119538f, 0.04759512f, -0.00799805f, 
    -0.00503798f, -0.02981634f, -0.00557149f, 0.02142902f, -0.00460507f, -0.00138703f, -0.02547701f, 0.03707651f, 
    0.03117408f, 0.03804439f, 0.04864833f, -0.05595311f, -0.02403517f, -0.01002104f, -0.01403872f, -0.04717334f, 
    -0.01414050f, -0.04941667f, -0.04935144f, 0.03611239f, 0.04288945f, -0.05692345f, 0.03496764f, -0.01023407f, 
    -0.03245561f, 0.04887881f, 0.01219429f, -0.00628051f, 0.02626887f, -0.02080506f, 0.04945322f, -0.04297803f, 
    -0.20652762f, 0.06619182f, -0.05199564f, -0.11119990f, 0.12201831f, 0.05413364f, -0.06552297f, 0.13657357f, 
    -0.03552740f, -0.00487501f, 0.20276710f, 0.10292365f, -0.00920566f, -0.04451555f, 0.01551965f, 0.08906908f, 
    -0.00484187f, -0.05789960f, 0.02444517f, 0.32533175f, 0.00661406f, 0.00874525f, -0.16753151f, -0.04273563f, 
    0.06598056f, 0.06259339f, -0.16571550f, -0.06189992f, -0.05775774f, 0.17674883f, 0.09479064f, 0.11051764f, 
    0.11082893f, -0.07559817f, -0.02919487f, 0.00033834f, -0.05266736f, -0.01934180f, -0.02264885f, 0.05208331f, 
    -0.01132921f, -0.03566271f, -0.07833292f, 0.09847048f, 0.04225903f, 0.07452334f, 0.17165290f, 0.17658649f, 
    -0.03001874f, 0.01588250f, -0.21447448f, -0.02852253f, 0.05643924f, -0.10739771f, 0.19882669f, 0.25778195f, 
    -0.07317046f, -0.04136431f, 0.39392954f, -0.00338401f, -0.05705593f, -0.12430656f, -0.08852033f, -0.13732211f, 
    -0.14172889f, 0.02490187f, 0.06239383f, -0.05835969f, -0.08997457f, 0.11078665f, 0.04780142f, 0.09506838f, 
    0.25083488f, -0.20624079f, -0.09321368f, 0.02120812f, 0.07092275f, 0.04086446f, 0.05295981f, -0.10417734f, 
    -0.06488875f, -0.07003681f, 0.19497091f, 0.11089179f, -0.02322869f, -0.02564087f, -0.01199505f, -0.00587850f, 
    -0.04659843f, 0.09930187f, 0.28830957f, 0.01993154f, 0.08006932f, -0.06173236f, -0.15404968f, -0.19555470f, 
    -0.01974971f, -0.05879554f, -0.16081230f, -0.10007403f, 0.04750639f, -0.27585253f, 0.10439713f, -0.08210175f, 
    -0.05279769f, 0.09100267f, -0.01821809f, -0.00581185f, -0.00924566f, 0.02180980f, 0.21005407f, -0.05264233f, 
    0.04013557f, -0.06424214f, 0.07697966f, 0.12800932f, -0.00749842f, -0.11980625f, 0.24180548f, -0.21467383f, 
    0.08824981f, 0.11715069f, 0.03162501f, -0.00471216f, 0.03113779f, -0.03278506f, 0.13716498f, 0.22023435f, 
    0.15584770f, 0.05579406f, -0.12796323f, -0.07383371f, -0.03789460f, -0.03862545f, -0.04224507f, -0.03333993f, 
    0.07931886f, -0.42847928f, -0.05054488f, 0.14116430f, -0.00580983f, -0.03246607f, 0.10032309f, 0.00758813f, 
    -0.07106990f, -0.08209264f, -0.29632694f, 0.11156435f, -0.04476631f, 0.03689944f, 0.00822801f, 0.09266458f, 
    0.03673476f, -0.03427490f, 0.14647903f, -0.10586662f, -0.04055357f, 0.00207436f, -0.01157526f, -0.01831800f, 
    0.03371212f, -0.12911649f, 0.14407128f, 0.27465495f, 0.19302407f, -0.08877491f, -0.03549021f, -0.05549369f, 
    -0.01879401f, 0.07662380f, 0.05496741f, -0.04686984f, 0.02016207f, 0.03975230f, 0.09416275f, 0.00499944f, 
    -0.05581925f, -0.03617956f, 0.12238956f, 0.08670881f, 0.29336506f, 0.22128475f, -0.28037438f, 0.20033064f, 
    0.02225535f, 0.10778350f, -0.05580558f, -0.02997281f, -0.01035264f, 0.11174763f, -0.16352606f, -0.16134416f, 
    0.14563923f, -0.00091035f, 0.02209124f, -0.05223186f, -0.23058088f, -0.03699091f, 0.16637065f, -0.22267331f, 
    -0.04302041f, 0.12538461f, -0.05994570f, 0.06302726f, -0.03023901f, 0.07329375f, 0.18800664f, -0.19472651f, 
    -0.20487937f, 0.04004179f, 0.08160511f, 0.08624917f, 0.07481031f, 0.04587834f, 0.01014442f, -0.10931931f, 
    0.13210775f, 0.12791964f, -0.08702536f, -0.05616999f, 0.14828849f, 0.01823701f, 0.15501727f, -0.05536458f, 
    0.06796318f, 0.05051609f, -0.11538095f, -0.31161159f, -0.03011842f, 0.06489085f, 0.09195314f, 0.03779892f, 
    -0.01278566f, -0.02140489f, 0.20802945f, -0.15627618f, -0.05085976f, 0.12643161f, -0.13859755f, -0.04123449f, 
    0.02435622f, 0.04734015f, 0.11307586f, 0.05672481f, -0.04727094f, 0.00842517f, 0.03162387f, 0.02740704f, 
    0.01560637f, -0.02312130f, 0.06950320f, 0.05544719f, -0.00962930f, 0.20280547f, -0.07777107f, 0.01819795f, 
    -0.03068999f, -0.03909887f, 0.09712262f, -0.07806869f, -0.03521007f, 0.24515688f, -0.17001754f, -0.27027678f, 
    0.10860839f, -0.00351290f, 0.30653352f, 0.05144393f, 0.00498291f, -0.05528013f, -0.23328841f, 0.06002144f, 
    -0.31552711f, 0.06376117f, 0.00957612f, 0.07632436f, -0.02889538f, 0.00965091f, -0.01101715f, -0.07325866f, 
    -0.07724686f, -0.55251598f, 0.11676870f, 0.00703550f, 0.24983749f, 0.08498710f, 0.06043539f, -0.00238672f, 
    0.02057961f, -0.05674648f, 0.04062209f, 0.13224266f, -0.01776429f, 0.02713737f, 0.05612668f, -0.00391903f, 
    0.06143621f, -0.19285907f, -0.27418968f, -0.06562127f, 0.06544887f, -0.02756516f, 0.05701624f, 0.04295721f, 
    -0.05486810f, -0.05840139f, -0.00946716f, -0.10190625f, -0.12975362f, -0.00445158f, -0.05379041f, 0.00177264f, 
    0.00955686f, -0.14714912f, -0.04660909f, 0.11468820f, 0.29016063f, 0.21454704f, 0.02640765f, 0.11853687f, 
    0.07049219f, -0.07052037f, -0.12698965f, 0.00874084f, 0.09973901f, 0.11621994f, 0.25115988f, -0.00279409f, 
    0.09392473f, 0.06723192f, 0.03197290f, 0.14114307f, -0.01755909f, -0.24637476f, -0.46292642f, -0.02857228f, 
    0.11504315f, 0.09732857f, -0.02228140f, -0.07170679f, 0.07273091f, 0.02739513f, -0.22266592f, -0.05327841f, 
    -0.00258610f, -0.03707195f, -0.11395699f, -0.12079641f, 0.13519031f, 0.08548873f, 0.14570320f, 0.17172009f, 
    0.20784363f, 0.23622857f, 0.08666665f, -0.04428887f, -0.11010129f, 0.17039226f, 0.02240556f, -0.00618922f, 
    -0.15138547f, 0.00531499f, -0.06288197f, 0.01740611f, 0.03212044f, 0.07037441f, -0.05239917f, 0.10382436f, 
    -0.00700782f, -0.22205389f, -0.20744529f, 0.09481283f, 0.00082057f, -0.11698077f, -0.09248396f, 0.07168838f, 
    0.04845071f, -0.01437926f, -0.08696654f, -0.08272850f, -0.07457509f, 0.00006089f, 0.00674096f, -0.08643905f, 
    -0.06220651f, 0.16256990f, -0.03881291f, 0.37679100f, 0.04845874f, 0.19320132f, -0.07575431f, 0.09231235f, 
    -0.09102356f, -0.01252970f, 0.07734062f, 0.03649619f, -0.04471332f, 0.12371548f, 0.03449812f, 0.03201895f, 
    -0.00335272f, 0.01927093f, 0.01175952f, 0.04524250f, -0.01385281f, 0.04505435f, -0.10634414f, 0.07685889f, 
    -0.10923267f, -0.00273546f, -0.11348990f, -0.04327172f, 0.15498802f, 0.10639624f, -0.25504917f, -0.43224323f, 
    -0.23128808f, 0.10293034f, -0.01419333f, -0.07790475f, -0.03352691f, 0.07332728f, 0.03258377f, -0.11911885f, 
    -0.28666559f, 0.33006531f, -0.17506777f, -0.14675002f, -0.02815107f, 0.09182748f, 0.12133527f, 0.08509886f, 
    0.11565795f, 0.13838416f, 0.16903026f, -0.04560520f, 0.03437683f, -0.01665376f, 0.11592218f, -0.08420384f, 
    -0.01299366f, 0.00218748f, -0.23090510f, 0.03838824f, -0.03108964f, 0.04534945f, -0.03771964f, 0.02614381f, 
    0.10101940f, -0.01168670f, -0.17122255f, -0.26314142f, -0.23896861f, -0.03533673f, -0.07777718f, 0.01683501f, 
    0.04979242f, -0.11731685f, 0.11010985f, -0.01636086f, -0.15286562f, 0.00026845f, -0.04736125f, -0.01182917f, 
    -0.10033189f, -0.01233315f, -0.09098940f, 0.09397016f, 0.23417574f, 0.13346417f, 0.18791282f, 0.07697301f, 
    0.05218910f, -0.00552005f, 0.00763271f, -0.00653127f, -0.00761770f, -0.00765552f, -0.09713468f, -0.10375836f, 
    -0.10591908f, -0.02057024f, -0.11826750f, 0.08319540f, -0.05289716f, -0.08298275f, 0.16814759f, -0.31239408f, 
    0.15612029f, 0.12762505f, -0.07968839f, -0.17976187f, -0.00366361f, -0.22927256f, 0.04002347f, 0.09446645f, 
    0.08493880f, -0.09728297f, -0.09201038f, -0.12136601f, 0.05528816f, -0.05828740f, -0.21571328f, 0.04065108f, 
    -0.09264717f, -0.01104433f, -0.00312306f, -0.09139989f, -0.18125336f, 0.03374764f, 0.02782017f, 0.07536466f, 
    0.12327630f, 0.02115136f, -0.14069802f, 0.10101357f, -0.02758761f, -0.00878220f, 0.04007971f, -0.00673571f, 
    -0.10626252f, 0.05448472f, 0.21964759f, 0.08021980f, 0.21470609f, -0.06321374f, 0.10906398f, 0.00021347f, 
    -0.00208878f, 0.14599985f, -0.03649706f, 0.15028879f, -0.08429383f, 0.29164740f, -0.07600216f, 0.15827933f, 
    0.06380834f, -0.00423130f, -0.05471497f, -0.20035952f, -0.19296272f, -0.00793446f, -0.04837570f, -0.08027105f, 
    0.01685153f, -0.00435174f, 0.17464654f, 0.03724724f, -0.09559198f, -0.13268961f, -0.07416725f, 0.10894448f, 
    -0.21913971f, -0.02258374f, 0.04443613f, 0.13678652f, -0.04417008f, -0.00144421f, 0.15472370f, 0.00497845f, 
    0.07551703f, -0.03673571f, 0.02328804f, -0.00796915f, 0.06486734f, 0.04127954f, -0.05113443f, 0.23858277f, 
    -0.01822240f, 0.30941045f, -0.03163598f, 0.00114754f, 0.01046189f, -0.06319827f, -0.05921122f, -0.04157431f, 
    -0.01539099f, 0.08826954f, -0.12277368f, -0.16411693f, 0.02470030f, 0.10287126f, 0.11192435f, -0.21227129f, 
    0.04611918f, -0.23920622f, -0.25599816f, 0.03016628f, 0.10220551f, 0.05737232f, -0.03614140f, 0.15927714f, 
    -0.00847875f, 0.13725370f, -0.20314786f, -0.05800714f, 0.07056613f, -0.08198128f, -0.01012447f, 0.03153324f, 
    0.08851683f, -0.00435459f, 0.09396981f, 0.12792741f, 0.04975703f, 0.05495967f, 0.02803585f, 0.10068151f, 
    -0.01634182f, -0.04754172f, -0.01460704f, -0.06831764f, 0.16846173f, 0.10099927f, 0.13958673f, -0.02088841f, 
    0.09820804f, 0.12141905f, -0.08709024f, 0.00039017f, 0.07373189f, 0.18032585f, -0.17203592f, -0.22546135f, 
    0.08167902f, -0.06477975f, -0.02892841f, -0.08879600f, 0.04909985f, 0.07541145f, -0.42687529f, -0.01249286f, 
    0.35783193f, 0.16865651f, 0.01850384f, -0.22236526f, 0.10296992f, 0.02761447f, 0.12870230f, 0.31808943f, 
    0.22675095f, 0.25918102f, -0.13255608f, -0.05005779f, -0.01214898f, 0.01699245f, -0.00704831f, 0.00428240f, 
    0.10200541f, -0.27441591f, 0.13396442f, 0.04566238f, 0.05154710f, -0.11866985f, -0.00301610f, 0.07127941f, 
    0.00488369f, -0.22603180f, -0.10791015f, -0.13680761f, 0.14736600f, 0.11143240f, 0.10702799f, 0.21530424f, 
    -0.05528781f, 0.05617733f, -0.05260351f, -0.23895642f, -0.49696124f, 0.13908903f, 0.11020409f, -0.08158943f, 
    -0.02082317f, -0.01407594f, 0.10451671f, 0.07834958f, -0.00167817f, 0.05788954f, 0.19424278f, -0.10843252f, 
    -0.02792571f, 0.12333553f, -0.04821804f, 0.00618302f, 0.04962003f, -0.10032389f, -0.10711228f, -0.02151851f, 
    0.10543413f, 0.10577205f, 0.05133655f, 0.01594996f, -0.03569833f, -0.19800414f, -0.12344300f, -0.14744227f, 
    0.02977506f, 0.04408265f, 0.13068822f, 0.13393439f, -0.01361997f, 0.21038631f, 0.00950994f, -0.16643639f, 
    -0.33730927f, 0.12334286f, 0.11595099f, 0.07863022f, 0.06016495f, 0.03108348f, 0.02864588f, -0.59714955f, 
    -0.10854588f, -0.07776250f, -0.14681014f, -0.32146862f, 0.09192484f, -0.04576759f, -0.07552621f, 0.08473523f, 
    0.09876769f, 0.06560612f, 0.04597558f, -0.07712052f, -0.02530659f, 0.09341485f, 0.18172303f, -0.05399410f, 
    0.03101676f, -0.08796484f, 0.01043359f, -0.30724630f, 0.02644083f, -0.01944532f, -0.06687339f, 0.06407652f, 
    0.07241745f, 0.11168642f, -0.30149642f, -0.39626181f, -0.01141272f, 0.16002244f, -0.07273071f, -0.07195731f, 
    -0.16301914f, -0.04485625f, 0.05715501f, 0.01047684f, 0.13146096f, -0.16213709f, 0.01621745f, 0.02636946f, 
    0.03754480f, 0.00790841f, 0.03871550f, -0.01581275f, 0.00881811f, -0.12477644f, -0.04545222f, 0.07631306f, 
    -0.08723653f, -0.05590515f, 0.02083356f, -0.05371491f, 0.02922211f, -0.13421778f, -0.22138754f, 0.04350060f, 
    0.03799234f, 0.02452388f, -0.17731176f, 0.17440787f, 0.11254726f, -0.00452807f, 0.18232967f, -0.30839747f, 
    -0.49644855f, 0.10867233f, -0.01853059f, 0.07996840f, 0.19086616f, -0.16474147f, -0.16331477f, 0.08030591f, 
    0.02028013f, -0.19377704f, -0.29049048f, 0.07501423f, 0.00852106f, 0.10903081f, 0.06004439f, 0.11155229f, 
    0.02953725f, -0.10195396f, -0.17949142f, -0.01339716f, 0.18613866f, -0.16440170f, 0.02213442f, -0.09321369f, 
    -0.05449714f, -0.07872906f, -0.12371854f, -0.06661462f, -0.00440816f, -0.02379603f, 0.03066532f, 0.06393016f, 
    0.03123675f, 0.15197574f, -0.09021577f, 0.15291990f, 0.14646259f, 0.05527672f, -0.15481274f, -0.03034353f, 
    -0.07737211f, -0.05249018f, -0.13229755f, -0.28891784f, -0.17408675f, -0.14774677f, -0.08722925f, -0.24655958f, 
    -0.09722060f, -0.00010372f, -0.02223129f, 0.03802326f, -0.11249070f, -0.33536947f, 0.02991070f, 0.15019545f, 
    0.12233248f, -0.22353934f, 0.03044282f, 0.10552771f, 0.09266586f, 0.14695041f, 0.03954372f, 0.22296172f, 
    -0.04929394f, -0.11106623f, -0.00846174f, 0.00924316f, -0.12948197f, -0.06207746f, -0.11725657f, -0.00715047f, 
    0.09131904f, 0.05063073f, -0.05433621f, 0.04049413f, 0.12695661f, -0.10142402f, -0.05612930f, -0.00225223f, 
    -0.01056269f, -0.22120948f, -0.13950372f, 0.08832856f, 0.11903105f, 0.03000804f, -0.06177396f, 0.02887891f, 
    0.04403114f, -0.01099410f, 0.04277305f, 0.05238522f, 0.03794009f, -0.00230707f, 0.04752783f, -0.00048606f, 
    -0.04197471f, -0.02078220f, 0.03106597f, -0.02867797f, -0.01774060f, -0.04854576f, 0.02313893f, -0.00378212f, 
    0.05367570f, 0.03858642f, -0.05167356f, -0.02251022f, -0.02338756f, -0.00586919f, -0.03617315f, 0.00388353f, 
    0.05817703f, 0.01915759f, 0.01910330f, -0.00493667f, 0.04035531f, 0.02200294f, -0.01573957f, -0.00940667f, 
    -0.05104673f, -0.04402736f, 0.00208274f, 0.04060469f, -0.01788021f, 0.06230867f, 0.00233774f, 0.04987473f, 
    0.00614811f, -0.04978814f, -0.03389229f, -0.01856683f, 0.05558422f, 0.02579840f, 0.05576109f, 0.04773797f, 
    0.02660393f, -0.00824986f, -0.05588442f, -0.03251600f, 0.00814564f, 0.03161725f, 0.01123986f, -0.02679827f, 
    0.00452711f, 0.01443561f, 0.04271394f, 0.04924520f, -0.00182685f, -0.03086738f, 0.00148934f, 0.03096621f, 
    -0.05471734f, 0.01087235f, 0.02767467f, -0.05796334f, 0.00932914f, 0.01692546f, -0.00714465f, -0.05597797f, 
    0.03728466f, 0.02216689f, -0.05798971f, 0.02483059f, 0.01709186f, -0.04573099f, -0.04175719f, -0.04475674f, 
    -0.03457803f, -0.01770931f, -0.03655222f, 0.03841333f, 0.01121290f, -0.03620205f, -0.01908559f, -0.05520300f, 
    -0.05367943f, -0.00220005f, -0.05346786f, 0.03740958f, 0.04591833f, -0.04498002f, -0.05515298f, -0.06515574f, 
    -0.02499200f, 0.02895183f, -0.05971583f, -0.03595365f, 0.05239026f, -0.01480467f, 0.03409998f, 0.00290314f, 
    -0.03724007f, 0.00952769f, -0.01744293f, 0.05742975f, 0.00212642f, 0.02985246f, 0.04996882f, 0.02633040f, 
    -0.06190616f, 0.03809316f, -0.03965519f, -0.01708579f, -0.02292391f, 0.02316440f, -0.05536487f, 0.00420326f, 
    -0.02775808f, -0.01464395f, 0.03542925f, 0.04981149f, -0.01603191f, 0.02710825f, -0.01264617f, -0.04119550f, 
    -0.06043742f, 0.00167076f, -0.02316230f, 0.00780789f, -0.02239852f, -0.04191501f, 0.02874038f, 0.01864606f, 
    -0.00566833f, 0.02295749f, -0.03744505f, -0.03023406f, 0.01936349f, -0.00606536f, -0.02820447f, -0.02926609f, 
    0.01362200f, 0.02956398f, -0.04024344f, -0.00670722f, -0.04044850f, -0.01275503f, -0.05570562f, 0.02990926f, 
    0.00007328f, 0.05519642f, -0.03497440f, 0.03422427f, 0.05034760f, -0.04959543f, 0.04333902f, 0.01005273f, 
    -0.06268109f, 0.02240426f, 0.01586452f, -0.00777358f, -0.04570294f, -0.01917042f, 0.01675208f, -0.00198808f, 
    -0.01210650f, 0.00151995f, 0.00388460f, -0.01810324f, 0.00084320f, -0.05862833f, 0.01426826f, 0.01713779f, 
    -0.00014564f, -0.01059629f, 0.03734770f, 0.03559949f, 0.00732942f, 0.02061430f, -0.01660341f, -0.00406331f, 
    -0.01329712f, 0.02953938f, 0.04509916f, -0.03251537f, -0.00304130f, -0.03884737f, 0.03922254f, 0.05005049f, 
    0.05264197f, -0.04821537f, -0.05970280f, -0.04712700f, 0.04053482f, 0.02433460f, 0.04383073f, -0.03937227f, 
    -0.05906007f, -0.01742000f, -0.04130090f, 0.01160560f, 0.00195470f, -0.02237387f, 0.04584634f, 0.04833758f, 
    -0.01211587f, -0.00988644f, 0.05141347f, -0.01963109f, 0.01992352f, -0.03072010f, 0.04349465f, 0.00263916f, 
    -0.01590666f, 0.01676851f, -0.05496968f, 0.02414728f, -0.05187974f, -0.01982778f, 0.05352756f, -0.03033624f, 
    0.00346812f, 0.02733179f, 0.03451417f, -0.04679032f, 0.02141311f, -0.01917285f, -0.01785620f, -0.04363783f, 
    0.02764852f, -0.04481919f, -0.00381251f, -0.03994393f, -0.01035062f, 0.03683987f, 0.04763630f, -0.05003896f, 
    -0.04901327f, -0.03203488f, 0.05399295f, -0.05072535f, 0.02181311f, -0.05407619f, -0.06251183f, -0.03573121f, 
    0.00281573f, -0.01780481f, -0.02794599f, -0.05089479f, 0.02191379f, 0.02318009f, -0.05920411f, 0.02190095f, 
    -0.04375197f, -0.02046443f, 0.00811569f, -0.05162047f, -0.05912619f, 0.03359592f, -0.02433212f, -0.00551971f, 
    -0.03278026f, -0.02618433f, 0.05173582f, -0.02931075f, 0.01828131f, 0.02065080f, -0.04625361f, -0.04384870f, 
    -0.05344153f, -0.04425058f, -0.05383480f, 0.01758230f, 0.01516570f, -0.04549384f, -0.03150564f, -0.03577072f, 
    0.02104995f, 0.03911444f, 0.00850623f, 0.02039202f, 0.00842497f, 0.01048109f, -0.01783927f, -0.02502427f, 
    0.08341028f, 0.04197535f, -0.02820471f, 0.09548664f, 0.04633557f, 0.07577065f, -0.30998561f, -0.13637240f, 
    -0.15728655f, 0.03920618f, -0.03202436f, -0.10228729f, -0.01380584f, -0.02435726f, -0.11549717f, 0.02212017f, 
    -0.02594276f, -0.12858370f, 0.04129715f, -0.09998108f, -0.02353854f, 0.15427716f, 0.04337465f, 0.18874465f, 
    -0.03777523f, -0.13012698f, -0.17329217f, -0.08750281f, -0.01761460f, -0.25569436f, 0.11658923f, 0.16168778f, 
    0.06714056f, 0.04535393f, 0.14635578f, -0.01291313f, 0.17028078f, -0.03393795f, 0.01230130f, 0.09288665f, 
    0.06944937f, -0.03604714f, 0.11811982f, 0.08935559f, 0.02089006f, 0.10641131f, -0.03052282f, 0.03270514f, 
    -0.04495177f, 0.14664321f, 0.00386215f, -0.00974116f, 0.07423186f, -0.01164311f, 0.10004628f, 0.04587423f, 
    0.01931071f, 0.16867261f, -0.04265925f, 0.26298776f, -0.14397702f, -0.00178650f, -0.05239138f, -0.15429598f, 
    -0.05560477f, -0.09670128f, -0.09018111f, -0.08885508f, -0.11960521f, 0.19758165f, 0.23713790f, 0.24833652f, 
    0.07857981f, -0.01281388f, 0.08199031f, 0.13744135f, 0.08644545f, 0.09383982f, -0.05231766f, -0.00471017f, 
    0.13390467f, 0.03961504f, -0.02629424f, -0.03089332f, -0.01807060f, 0.00567511f, 0.02353844f, -0.01259533f, 
    -0.08188517f, -0.24981220f, 0.13270013f, 0.05161031f, 0.09334024f, 0.05131287f, 0.11042047f, 0.01825825f, 
    -0.06744784f, 0.15565638f, 0.09690449f, 0.04500028f, 0.10406880f, 0.05939310f, -0.02150217f, 0.07505413f, 
    -0.12684964f, 0.14247991f, -0.00094245f, 0.07874820f, 0.07834607f, 0.05130123f, -0.02647047f, -0.11631860f, 
    0.05845623f, 0.01889642f, -0.25035012f, -0.17185742f, -0.22597799f, 0.08276888f, 0.12291259f, -0.03099946f, 
    -0.00332478f, 0.16723725f, 0.04835157f, -0.11347380f, 0.07272916f, 0.01269370f, 0.01303138f, -0.09225888f, 
    0.01909562f, -0.00025124f, 0.02854834f, -0.01913905f, 0.13226105f, -0.02137227f, 0.12426314f, 0.09467757f, 
    0.26420274f, 0.50452089f, 0.30361637f, 0.14495626f, -0.05210207f, 0.06249352f, 0.08585589f, 0.12419689f, 
    -0.24273813f, -0.03730585f, 0.05509754f, 0.01023021f, -0.01160984f, -0.07789231f, -0.21812870f, -0.17835826f, 
    -0.08692157f, -0.06923807f, -0.16302450f, 0.11134428f, 0.21873710f, -0.00128937f, -0.02616372f, 0.14796533f, 
    0.20517389f, 0.07590307f, 0.07141069f, -0.17577791f, -0.08976462f, -0.04387451f, -0.15122233f, 0.08903029f, 
    -0.25468397f, -0.23772019f, -0.30884171f, 0.09158022f, -0.01579985f, 0.07976446f, -0.06333616f, 0.03115511f, 
    0.03608812f, -0.02910835f, -0.12284398f, 0.11124983f, -0.12429992f, -0.17164633f, -0.09523295f, 0.00489655f, 
    -0.08597066f, 0.07560288f, 0.08133080f, 0.01705073f, 0.02839809f, -0.00978381f, -0.00731549f, 0.02212279f, 
    0.18174671f, 0.12757865f, 0.04596966f, -0.03877386f, -0.02760327f, 0.09731677f, 0.13285974f, 0.12452494f, 
    0.14181277f, -0.04454368f, 0.08915640f, 0.03638552f, 0.18763173f, -0.08689311f, 0.05625498f, -0.08111392f, 
    0.04260607f, -0.11299366f, 0.12856463f, 0.27689442f, 0.16554001f, -0.03125317f, -0.10448448f, -0.00018058f, 
    -0.01738328f, 0.08078939f, -0.00488928f, 0.02542903f, 0.10799650f, 0.13849232f, -0.03533372f, 0.13900100f, 
    -0.25374773f, 0.06393084f, 0.15823282f, -0.05239914f, 0.16627081f, 0.17412248f, 0.03620438f, -0.02251279f, 
    -0.12129403f, 0.01098846f, -0.10087606f, 0.01895807f, -0.09982889f, -0.07416203f, -0.18237157f, -0.01307473f, 
    -0.00791945f, 0.17073600f, -0.01251045f, 0.21750019f, 0.00059849f, 0.25143167f, 0.13854477f, 0.08416177f, 
    0.09475867f, -0.05517744f, 0.02238774f, -0.29003951f, -0.02100310f, 0.00926340f, 0.02050508f, 0.00157285f, 
    0.00242756f, -0.00454617f, -0.08527333f, 0.07572880f, -0.05825159f, -0.30095702f, -0.26264590f, 0.01042291f, 
    0.20384941f, 0.08362873f, -0.04743033f, -0.15778628f, -0.14542168f, -0.21078305f, 0.03742018f, -0.00150513f, 
    0.09622119f, 0.11009057f, -0.01110318f, 0.02335995f, -0.18562859f, -0.14702640f, -0.12358056f, -0.02557054f, 
    0.33982450f, 0.02637625f, -0.02886311f, 0.08432501f, -0.18074250f, -0.06505048f, -0.01744425f, -0.07007432f, 
    0.19210908f, 0.30103028f, -0.11996877f, -0.00189049f, -0.01460495f, -0.05954408f, 0.24594598f, 0.05327641f, 
    0.15640815f, -0.04785686f, 0.01689181f, -0.03557679f, -0.15872683f, -0.06498142f, -0.25315562f, -0.04193199f, 
    0.00137808f, 0.04925185f, -0.23665930f, -0.23392023f, -0.10027007f, 0.13539283f, 0.03563958f, -0.08269995f, 
    0.22300231f, 0.09910409f, 0.06629584f, -0.29883373f, -0.18222642f, -0.26002085f, 0.06072038f, 0.00238565f, 
    -0.15625167f, 0.13761468f, 0.09668167f, -0.15076092f, 0.17937520f, 0.02839636f, -0.10379252f, -0.00676406f, 
    0.04607565f, 0.06574566f, 0.05612032f, 0.09161498f, 0.19744782f, -0.30922860f, -0.60214287f, -0.15909073f, 
    -0.19350055f, -0.08597609f, -0.18736070f, -0.10213342f, -0.01759338f, 0.00025557f, -0.19984947f, -0.17684518f, 
    -0.33890739f, -0.07251884f, 0.05366058f, -0.13768771f, -0.03414066f, 0.01232049f, -0.05577084f, -0.24968199f, 
    -0.48130950f, -0.22733887f, -0.10971089f, 0.05534510f, -0.17753854f, -0.13012806f, 0.12013153f, 0.00333314f, 
    0.19039574f, 0.08619457f, -0.10394495f, -0.04381322f, 0.20266132f, -0.05031797f, 0.14924599f, 0.11702734f, 
    0.13865374f, -0.09608380f, -0.01947062f, 0.03159158f, -0.12126976f, -0.20372200f, -0.00900533f, 0.07127052f, 
    0.02480060f, 0.01915561f, 0.22208798f, -0.10969942f, -0.43567371f, -0.19330956f, -0.08857978f, 0.05308530f, 
    -0.02037695f, 0.04100079f, 0.03948576f, -0.12444689f, -0.02615425f, 0.30786499f, 0.00805191f, 0.08959141f, 
    0.09611838f, 0.02602704f, 0.13646643f, 0.23344573f, 0.16726959f, 0.11680739f, 0.10561121f, 0.10218471f, 
    0.06727719f, -0.07001014f, 0.22984923f, -0.00837319f, -0.08827338f, 0.13766819f, 0.07420457f, 0.16684286f, 
    -0.09172687f, 0.07372493f, -0.00176741f, 0.08887820f, 0.23391224f, 0.15046783f, -0.10272282f, -0.03515344f, 
    0.12189508f, -0.02459552f, -0.04371427f, -0.03058830f, 0.04667640f, 0.14463583f, 0.09873372f, -0.22052899f, 
    -0.04954037f, -0.24015373f, -0.11159565f, 0.09610895f, -0.00110150f, 0.06015854f, 0.04464711f, 0.06755596f, 
    -0.13102876f, 0.20711596f, 0.25692669f, -0.05813577f, -0.10034449f, 0.07390583f, 0.14490457f, -0.01868655f, 
    0.00636679f, -0.10576440f, -0.03271708f, 0.02790823f, 0.00047243f, -0.02480711f, -0.21514669f, 0.14154914f, 
    0.19175150f, 0.18651113f, -0.08805662f, -0.19508791f, -0.09128522f, -0.03558988f, 0.01301655f, -0.08774385f, 
    0.03106872f, -0.07969293f, 0.03799425f, 0.03590153f, 0.10486979f, 0.05459489f, -0.12637430f, 0.13608766f, 
    0.14722529f, 0.12076740f, 0.04158546f, 0.05867397f, -0.24267113f, -0.19735572f, 0.05160758f, -0.17137446f, 
    -0.16476734f, -0.14217250f, -0.01117867f, 0.00997763f, -0.21999466f, -0.04943238f, 0.04416362f, -0.09435787f, 
    -0.19665413f, -0.08467128f, -0.16595727f, 0.08763664f, 0.08246772f, 0.15835468f, -0.18778476f, -0.22291745f, 
    -0.27716482f, -0.20428725f, 0.00572343f, -0.25435868f, 0.02354968f, -0.16751738f, 0.04491294f, 0.25380138f, 
    -0.08250374f, 0.10358439f, -0.19187690f, 0.10469579f, -0.17220950f, -0.02337053f, -0.06838550f, 0.03885407f, 
    -0.03774384f, -0.00391048f, -0.20448235f, -0.03914814f, 0.11366257f, -0.18297054f, 0.01683075f, -0.09865101f, 
    -0.01060416f, 0.01228556f, 0.14272152f, 0.16069256f, -0.08746783f, 0.12262432f, 0.07066313f, 0.07358501f, 
    0.10530408f, 0.06667852f, -0.22467932f, 0.01042512f, -0.03073906f, -0.11104842f, -0.01346263f, -0.00141338f, 
    -0.00639686f, -0.00918350f, -0.01859965f, -0.01856108f, -0.17210719f, -0.10540478f, 0.14323057f, -0.16897251f, 
    -0.06768140f, 0.19587278f, -0.00270712f, 0.13598785f, -0.01723075f, -0.02454498f, 0.01654080f, -0.19143620f, 
    -0.12103350f, -0.05106212f, -0.00403944f, -0.01970299f, 0.12883288f, -0.27326116f, -0.07865093f, 0.29698291f, 
    -0.32372749f, -0.10776809f, -0.17312825f, -0.01479977f, -0.03264171f, -0.12316473f, 0.01377607f, 0.24579978f, 
    0.17344624f, 0.14197123f, 0.00726572f, 0.05019337f, 0.19684173f, 0.07207301f, 0.02024722f, -0.23183715f, 
    0.22158699f, 0.13362569f, 0.01397384f, 0.02324453f, 0.01728599f, 0.07326870f, 0.05381964f, -0.03020648f, 
    -0.06284346f, 0.00440987f, 0.00725012f, -0.08247058f, -0.07187190f, 0.02490732f, -0.00151392f, -0.02008196f, 
    0.03665309f, 0.00652028f, -0.07845821f, 0.01619649f, 0.00359937f, -0.05719232f, -0.06599189f, -0.00597786f, 
    0.02149787f, 0.04309752f, 0.00050213f, -0.03674715f, 0.00058159f, -0.02098415f, -0.04060974f, -0.06133053f, 
    0.00992887f, -0.02777551f, -0.04948314f, 0.05373077f, -0.01528106f, 0.04301416f, 0.03239173f, -0.00254620f, 
    -0.04969488f, -0.06424633f, -0.03711453f, -0.06547149f, 0.01153399f, -0.01229189f, -0.05612684f, 0.04709486f, 
    -0.01211135f, 0.03934093f, 0.00821625f, -0.00293143f, -0.02340736f, 0.01597562f, -0.04073747f, -0.01291270f, 
    -0.05378184f, -0.04059013f, 0.00141418f, 0.01318493f, 0.03332081f, 0.00228998f, 0.01402419f, -0.00651800f, 
    -0.00674590f, -0.07400170f, 0.05026737f, -0.03559470f, -0.00179768f, -0.02458696f, -0.04655410f, 0.03479129f, 
    0.02032110f, 0.01205639f, 0.04596347f, -0.02169650f, -0.02634732f, -0.03742582f, 0.00298829f, -0.02815560f, 
    -0.00238175f, -0.04208780f, -0.05605980f, -0.01992826f, -0.04777465f, -0.05223057f, -0.02804859f, 0.03339531f, 
    0.05491403f, 0.01060083f, 0.03844175f, 0.01821101f, -0.03956602f, -0.08159996f, -0.07316294f, -0.03114413f, 
    0.00274399f, -0.05360657f, 0.00270678f, -0.01641808f, -0.04524304f, 0.05053306f, -0.03369705f, -0.05505198f, 
    0.01056859f, -0.01146515f, -0.04082315f, 0.01245534f, 0.01246917f, 0.00187687f, -0.02815087f, 0.04590303f, 
    -0.05387356f, 0.04266170f, 0.03322269f, 0.01593043f, -0.05252258f, 0.01069965f, -0.04640098f, -0.00505784f, 
    -0.02316048f, 0.00574472f, -0.05903498f, 0.07171418f, -0.00997174f, 0.03252133f, -0.06807513f, -0.02360225f, 
    -0.05701393f, -0.00722093f, -0.03343310f, -0.06952015f, -0.05040823f, 0.00696309f, -0.03937647f, 0.00631347f, 
    0.03320622f, -0.00136233f, 0.02183921f, -0.05208739f, 0.03978482f, -0.02218818f, -0.00320532f, -0.03122011f, 
    -0.00578611f, 0.01615703f, 0.02911900f, 0.01297182f, 0.03303400f, 0.02244871f, -0.01896430f, 0.00092785f, 
    -0.04912540f, -0.04477508f, 0.05936297f, -0.03787397f, -0.05851654f, -0.06844708f, -0.01460100f, -0.01852553f, 
    -0.05181297f, 0.01732710f, 0.00702824f, -0.06539788f, -0.01096556f, -0.01999229f, 0.00490254f, -0.00871369f, 
    0.03139450f, 0.05403199f, -0.05371350f, -0.00946658f, 0.02647124f, -0.04971011f, 0.01784409f, 0.01064168f, 
    0.04716379f, -0.03766479f, 0.05632273f, -0.03187992f, -0.06337750f, -0.04726570f, 0.03460379f, 0.00400936f, 
    0.04396918f, -0.00086632f, 0.02664953f, -0.03526773f, 0.06223327f, 0.01284036f, 0.02701185f, -0.02708592f, 
    -0.02619566f, 0.00455885f, 0.03513621f, -0.02894376f, -0.00519445f, -0.05339670f, -0.05933110f, -0.00940782f, 
    0.05421665f, -0.03138531f, -0.00373086f, 0.03947242f, -0.02352518f, -0.04178993f, 0.00646550f, -0.02522428f, 
    -0.00219613f, -0.03601478f, 0.01487509f, -0.06628875f, -0.00456894f, -0.01025296f, -0.02523291f, -0.04108742f, 
    -0.01369273f, -0.04475546f, 0.00716227f, -0.04547716f, 0.03223284f, -0.01817700f, 0.03736730f, 0.03011638f, 
    -0.02311362f, -0.00728673f, -0.01757463f, -0.03853021f, 0.03090361f, -0.06715123f, 0.02434440f, -0.03745763f, 
    -0.02034626f, 0.03987243f, 0.02881647f, -0.04920817f, 0.01777169f, -0.03091571f, -0.03551649f, 0.02544183f, 
    0.00382831f, 0.01045593f, -0.02792906f, 0.04480612f, 0.04115853f, 0.01345594f, 0.02396504f, -0.00324004f, 
    -0.04203614f, -0.08146412f, 0.01509842f, 0.03089613f, 0.02233516f, -0.02664517f, -0.02503731f, 0.03692203f, 
    -0.04243428f, -0.02896559f, -0.05380061f, -0.05148098f, -0.02942407f, -0.01479032f, -0.07553331f, -0.02543389f, 
    -0.06479190f, -0.03967274f, -0.03616431f, 0.05377391f, -0.03702999f, 0.03054210f, 0.03171967f, 0.04168937f, 
    0.02300183f, -0.04389589f, 0.01773696f, 0.04541420f, 0.06285316f, 0.05335242f, -0.05914557f, -0.05648333f, 
    0.05950377f, -0.00233763f, -0.03112929f, -0.04603286f, -0.00052208f, 0.01559743f, 0.02187599f, 0.03006325f, 
    -0.03510392f, -0.02459043f, -0.04758429f, -0.07922129f, -0.04356129f, -0.03894124f, -0.01771471f, -0.01023407f, 
    0.03767426f, -0.04122377f, 0.00571212f, 0.02996980f, 0.01951444f, 0.04510841f, -0.03699824f, 0.01456602f, 
    -0.02510852f, -0.00390887f, -0.03355641f, 0.00061105f, -0.00283302f, -0.04587964f, 0.03757465f, 0.02706833f, 
    0.00259043f, -0.06085644f, 0.04482887f, 0.02117626f, -0.02909022f, 0.01939997f, -0.00387249f, 0.00596843f, 
    0.00616250f, -0.04819338f, -0.05852538f, 0.04420804f, -0.05991355f, 0.01638427f, -0.03892577f, 0.03484730f, 
    -0.00174494f, -0.04567508f, -0.03657380f, 0.04479310f, -0.01955728f, -0.01496744f, -0.03491028f, 0.05154741f, 
    0.04503229f, 0.01927892f, -0.05298206f, -0.05342258f, 0.04660044f, 0.04280536f, -0.00402290f, 0.01422644f, 
    0.04743288f, 0.02612807f, 0.02955376f, -0.04742683f, -0.02958743f, -0.05579617f, 0.02632844f, 0.03420668f, 
    -0.00327284f, -0.05659853f, -0.00885725f, -0.04055753f, 0.04703823f, -0.00076076f, -0.04513378f, 0.01024842f, 
    0.00615860f, -0.05244556f, 0.03565537f, -0.00441602f, -0.06210215f, -0.02684173f, 0.02647658f, 0.00110038f, 
    0.05337663f, -0.03457905f, -0.05046875f, 0.00605967f, -0.06273466f, -0.01701050f, 0.03303500f, -0.04189343f, 
    0.02963827f, -0.05606855f, 0.03511485f, -0.04825323f, 0.04663964f, 0.03574344f, 0.04184665f, -0.01560906f, 
    0.05015511f, -0.02024886f, -0.06179218f, -0.05197246f, 0.02566174f, -0.00258290f, 0.02160676f, -0.02985385f, 
    0.03622192f, -0.05016353f, -0.04601143f, -0.02470265f, -0.00469350f, -0.01173090f, -0.05196433f, -0.05569344f, 
    -0.02931444f, -0.02322881f, 0.03797892f, -0.04004482f, -0.05073455f, 0.00559551f, -0.05206838f, 0.02636105f, 
    -0.00132034f, 0.01664548f, 0.03176633f, 0.00940291f, 0.00003551f, -0.00450090f, -0.00354102f, 0.00243220f, 
    -0.03969716f, 0.02590249f, 0.04218492f, 0.03388437f, -0.03877538f, -0.04522929f, 0.01089135f, -0.03913367f, 
    -0.00223465f, -0.01447235f, -0.05572295f, -0.02825425f, -0.03061110f, -0.02413751f, -0.03049891f, -0.00415507f, 
    -0.01184980f, -0.04351269f, 0.00526266f, 0.03660001f, -0.04152356f, 0.02058907f, -0.05652753f, -0.00398597f, 
    -0.00640903f, -0.03094698f, 0.04725890f, 0.01960663f, 0.01787284f, -0.03700041f, 0.04261564f, 0.03071344f, 
    0.01647979f, 0.00592980f, -0.04556865f, -0.05914148f, 0.02598879f, -0.02841821f, -0.05729861f, 0.05157130f, 
    0.04863939f, 0.00735891f, 0.00888315f, 0.05433947f, 0.00659532f, 0.02294362f, -0.05998769f, -0.02318673f, 
    -0.00939485f, 0.04838061f, 0.04940861f, -0.00290649f, 0.03467301f, -0.01395440f, 0.04181417f, 0.03467123f, 
    0.00543050f, 0.02438992f, -0.06499790f, 0.02963633f, 0.00210732f, -0.04555867f, 0.02850887f, -0.02766141f, 
    -0.02801887f, -0.02008423f, 0.00736742f, -0.05561072f, -0.00592417f, -0.01068144f, 0.03871594f, 0.00365452f, 
    0.02137618f, 0.03941002f, -0.04967348f, -0.03709567f, 0.05132075f, 0.04368669f, -0.04708902f, 0.02440289f, 
    -0.06038702f, -0.05417489f, -0.03998669f, -0.01419966f, 0.02905908f, 0.04037568f, -0.04386396f, -0.01905823f, 
    -0.06286646f, 0.01285272f, -0.03266557f, 0.04328654f, -0.06416958f, -0.02597535f, -0.01368436f, 0.02362114f, 
    -0.04773360f, 0.05849275f, -0.05042472f, -0.01430650f, -0.00859108f, -0.02943154f, 0.04564601f, -0.00457663f, 
    -0.01635700f, -0.05965681f, 0.03701172f, 0.02400145f, -0.04793531f, -0.03510672f, -0.02006606f, -0.06540655f, 
    0.00040152f, -0.02050258f, -0.03075444f, -0.01939518f, -0.05166868f, -0.03737776f, -0.00497473f, -0.03934377f, 
    0.01720727f, -0.06169873f, -0.05217137f, 0.01354294f, -0.01561533f, 0.05691519f, 0.02619536f, 0.03147248f, 
    -0.06249235f, -0.05746087f, 0.01265790f, 0.01346593f, -0.01942064f, 0.01891184f, 0.02673872f, -0.00548768f, 
    0.01802606f, -0.05846737f, 0.00484844f, -0.01109962f, 0.01511620f, -0.00062147f, 0.00461059f, -0.01861710f, 
    0.02030027f, -0.01274684f, 0.04991769f, 0.02720788f, -0.03275602f, 0.00050822f, 0.02450611f, 0.02170280f, 
    -0.01869951f, 0.01978575f, -0.05747531f, 0.05174278f, 0.04636567f, -0.02313947f, -0.04146265f, -0.01551371f, 
    -0.01428144f, -0.03791466f, 0.04658393f, -0.01233052f, -0.01560417f, -0.05516667f, 0.03251788f, 0.02909269f, 
    0.09759685f, 0.30093917f, 0.09909811f, 0.01428468f, 0.14027660f, -0.13089828f, 0.19188596f, -0.06841738f, 
    0.05053803f, -0.10994232f, -0.26367193f, -0.01617509f, 0.09576251f, -0.04458256f, -0.28452647f, 0.00501227f, 
    0.08611916f, 0.05942577f, -0.05079288f, -0.04914032f, 0.26818651f, -0.04729326f, 0.14533439f, 0.02422355f, 
    0.01354349f, 0.19684823f, -0.02505670f, 0.05590799f, 0.01563669f, 0.28610146f, 0.08701087f, -0.01835392f, 
    -0.03983166f, 0.12672655f, 0.02920489f, 0.04057498f, 0.06288826f, -0.04104621f, 0.24361394f, -0.07493854f, 
    0.06859442f, 0.09113813f, -0.12432349f, -0.10748899f, 0.24433559f, -0.04085847f, -0.20711273f, -0.37103131f, 
    0.01177388f, -0.29236037f, 0.12809971f, -0.14994247f, -0.04078294f, 0.00950446f, -0.02490252f, 0.20722845f, 
    -0.16327611f, -0.02602518f, -0.13012762f, -0.10902234f, 0.15010467f, 0.02945721f, 0.01595443f, 0.17657256f, 
    -0.26905683f, 0.10719953f, -0.09302126f, -0.02707356f, -0.02086880f, 0.02933537f, -0.15918884f, -0.15928596f, 
    0.26379719f, -0.32874617f, -0.21896496f, 0.20730034f, 0.03931828f, 0.01707040f, 0.07004296f, 0.06365518f, 
    -0.18120499f, 0.03618386f, 0.01115052f, 0.02832754f, 0.25086936f, -0.05802924f, -0.01972680f, 0.11033530f, 
    -0.07472309f, 0.05778685f, 0.04299273f, -0.41087383f, -0.32485321f, 0.04364800f, -0.10308625f, -0.01022827f, 
    0.05197652f, 0.05511373f, 0.09431968f, -0.06118372f, -0.10436904f, 0.21678875f, 0.01360636f, 0.06864538f, 
    0.00173839f, 0.10680389f, -0.05086591f, -0.04646074f, 0.32117608f, 0.09805301f, 0.02513427f, 0.18889742f, 
    0.01408240f, -0.03983855f, 0.00892609f, 0.07389615f, -0.04460522f, -0.04695753f, -0.08157527f, -0.04638615f, 
    0.05808214f, 0.00289875f, 0.11040898f, 0.08339594f, 0.08061034f, -0.00256810f, 0.04148639f, -0.06813577f, 
    -0.18204153f, 0.10445810f, -0.01845704f, 0.02609913f, 0.02794327f, -0.03433412f, 0.09518642f, -0.29698455f, 
    0.46725526f, -0.15787336f, -0.14350717f, -0.11245454f, -0.02194868f, 0.05908252f, 0.01704965f, -0.01830395f, 
    -0.29124123f, 0.17713343f, -0.09196746f, -0.03203684f, -0.00422610f, -0.03994178f, 0.00203939f, 0.05970985f, 
    0.04226039f, -0.32121715f, -0.25285074f, 0.01256875f, 0.05830876f, 0.00502125f, 0.09507914f, 0.04223973f, 
    0.06647237f, 0.13256337f, -0.18012172f, -0.07922780f, 0.07907216f, 0.00573195f, -0.16876608f, -0.27373639f, 
    -0.13524275f, 0.08571238f, -0.18516065f, 0.25658467f, 0.07311753f, -0.05504344f, 0.01117230f, -0.04045291f, 
    0.07667687f, 0.09625435f, 0.06830109f, -0.09877893f, -0.36075276f, -0.00399898f, 0.13159931f, -0.10036728f, 
    -0.10308840f, -0.08130535f, -0.02773495f, 0.10043705f, 0.04937765f, -0.20203373f, -0.33195093f, -0.00537328f, 
    -0.14607905f, -0.05650287f, -0.18257931f, -0.02637507f, 0.20502777f, -0.05067135f, 0.10155387f, 0.03901324f, 
    -0.31176636f, -0.13334490f, 0.16672973f, -0.00588413f, -0.11043943f, 0.11979883f, -0.06174930f, -0.25601146f, 
    -0.38260600f, -0.23900051f, 0.03975841f, -0.06638406f, -0.24633311f, 0.04140739f, 0.22282685f, -0.06197200f, 
    0.22485104f, 0.35034251f, -0.27752161f, -0.04173387f, 0.13935265f, -0.12070350f, 0.05880107f, 0.11138517f, 
    -0.10264786f, -0.19825588f, -0.08560637f, 0.11739112f, 0.10211823f, 0.03503860f, -0.09433104f, 0.10956530f, 
    0.05411886f, 0.17828047f, -0.00718480f, -0.07883789f, 0.17943984f, 0.05789286f, 0.00695491f, 0.06565592f, 
    0.06798957f, -0.10846094f, -0.14169700f, -0.16254759f, 0.08578726f, 0.42489144f, -0.02459506f, 0.00059925f, 
    -0.21538156f, -0.14047401f, -0.12448333f, 0.08059984f, 0.03343877f, -0.24979714f, -0.36368319f, 0.13399340f, 
    -0.23880823f, -0.15603425f, 0.01864112f, 0.07387979f, 0.04252017f, -0.36160368f, 0.09561228f, -0.38799566f, 
    -0.06063896f, 0.03569970f, -0.13162942f, 0.00102646f, -0.05590575f, -0.19796056f, -0.21776372f, 0.12482616f, 
    0.14627555f, 0.08246248f, 0.07848753f, 0.04811492f, 0.02201410f, 0.05926630f, -0.08472861f, -0.35008675f, 
    0.13591202f, -0.14929460f, 0.08704592f, -0.01798992f, -0.07527076f, -0.00460396f, -0.06958392f, -0.02515469f, 
    -0.15329793f, -0.39019755f, -0.09173609f, 0.01677803f, 0.10632284f, 0.29150149f, 0.01720407f, 0.04794447f, 
    -0.02318218f, -0.12076110f, 0.10340231f, -0.01478404f, -0.04139414f, -0.13169362f, -0.04999045f, 0.00425674f, 
    -0.02215093f, 0.03031822f, -0.10437800f, -0.21325301f, 0.32148352f, -0.17511611f, 0.02395613f, -0.17010967f, 
    0.02039110f, 0.11037750f, -0.04662773f, -0.09495620f, 0.00508994f, -0.15580674f, -0.08039691f, -0.04512000f, 
    0.05214681f, -0.05773190f, 0.10148545f, 0.13645890f, -0.18105049f, -0.21559732f, 0.00731164f, 0.12759587f, 
    0.00541545f, 0.10733208f, 0.14454152f, 0.01370331f, 0.10120821f, -0.63538235f, -0.05381154f, -0.07861350f, 
    0.03296131f, -0.03696338f, 0.00795571f, -0.08245006f, 0.07890088f, 0.11081419f, 0.23046011f, 0.06521645f, 
    0.31514698f, -0.13356449f, -0.04038100f, -0.18284766f, 0.02705669f, 0.21643472f, -0.02609217f, 0.09204689f, 
    -0.07586195f, 0.13286501f, -0.07146792f, -0.01915828f, -0.06330419f, 0.00509866f, -0.09615294f, 0.04779189f, 
    0.09232384f, 0.19568358f, -0.25339133f, -0.10688029f, 0.07882062f, -0.10166968f, 0.07785953f, 0.03920199f, 
    -0.07601995f, -0.04734467f, -0.01944863f, 0.05162922f, -0.12066671f, 0.05015131f, -0.15429161f, 0.01139884f, 
    0.03167395f, 0.13532631f, -0.05331272f, -0.09884034f, 0.03695530f, 0.15125960f, -0.12523890f, 0.00255709f, 
    0.15708132f, 0.06324069f, 0.04119485f, 0.37772697f, -0.17839564f, -0.25045404f, 0.02073438f, -0.02336920f, 
    0.01164721f, 0.05223128f, -0.02982075f, 0.01373155f, -0.25474438f, -0.00573444f, 0.04571814f, -0.03229360f, 
    -0.07298245f, 0.05558688f, 0.07473738f, -0.01788574f, 0.09446248f, -0.02259647f, -0.04411631f, 0.05397220f, 
    -0.07554132f, -0.02783501f, 0.07508388f, 0.13572477f, 0.05756879f, 0.09224769f, -0.25808758f, 0.04959720f, 
    0.17295061f, -0.00775524f, -0.10093235f, -0.04135873f, 0.07533745f, 0.08380318f, 0.08575181f, 0.29697144f, 
    0.12080767f, -0.15142421f, -0.28704888f, -0.02471398f, -0.13427487f, 0.07011052f, 0.01881073f, 0.09517876f, 
    0.34404594f, -0.13044125f, -0.38762522f, -0.05541462f, -0.07887258f, -0.05076821f, -0.00344393f, 0.04694179f, 
    0.00690593f, 0.07374438f, 0.01469075f, 0.15550044f, -0.16232504f, 0.17751586f, 0.01260880f, 0.00368081f, 
    0.02168681f, -0.02381078f, -0.13058355f, 0.06423934f, 0.16797267f, -0.02011815f, 0.05803295f, -0.04781333f, 
    -0.10388245f, 0.14698108f, -0.03123118f, -0.19248003f, -0.15162717f, 0.21502005f, 0.07775464f, -0.10819084f, 
    -0.06837031f, -0.06048808f, 0.09214031f, 0.04373957f, 0.41659430f, 0.18706286f, -0.13078780f, -0.11513564f, 
    -0.12970735f, -0.18264364f, -0.04660439f, -0.04764906f, 0.03725899f, -0.01136148f, 0.05385249f, -0.13122013f, 
    -0.07189080f, -0.13730054f, -0.13867158f, 0.09240211f, -0.01731101f, 0.00233303f, -0.18409866f, 0.02934294f, 
    -0.18160044f, -0.21100952f, -0.16381507f, 0.05121258f, -0.09438400f, 0.05144181f, -0.09759830f, -0.15358260f, 
    -0.01205130f, -0.08696096f, -0.07786565f, -0.15230703f, -0.00458760f, 0.02502267f, -0.00269055f, 0.06414575f, 
    0.25795957f, -0.06998371f, 0.08831023f, -0.01143129f, 0.00750807f, 0.05823344f, 0.04939104f, -0.06449523f, 
    0.18120234f, 0.11985306f, -0.13115124f, -0.18958715f, -0.02407275f, -0.07566975f, 0.11207881f, 0.10099036f, 
    0.04303963f, 0.01220012f, 0.37675962f, 0.05791910f, -0.23811316f, -0.04046847f, -0.06258284f, -0.00243654f, 
    -0.16690017f, 0.07112698f, -0.04879178f, 0.43156677f, -0.09217493f, -0.08255152f, 0.01673194f, 0.10961911f, 
    -0.11117954f, 0.12648666f, 0.14586426f, 0.01821958f, 0.06650142f, 0.02378238f, -0.00517995f, -0.04003526f, 
    -0.00714684f, 0.00191394f, -0.14300498f, -0.01574160f, -0.13400154f, 0.59079432f, 0.12753394f, -0.25503364f, 
    -0.16984871f, -0.08078043f, -0.13496646f, -0.04484283f, -0.04226822f, 0.06508106f, 0.16253670f, -0.27774912f, 
    -0.01753649f, 0.05106140f, 0.04363740f, -0.07347105f, -0.01585066f, 0.02787562f, -0.00136162f, 0.29892853f, 
    -0.46066856f, -0.52490401f, 0.00247945f, 0.04367359f, 0.11888790f, 0.01587815f, 0.04086434f, 0.00989503f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12656860f, 0.01136466f, -0.02994794f, 0.13534981f, -0.00991590f, 0.07404650f, -0.05397892f, 0.03204906f, 
    0.07917219f, 0.14133404f, 0.04236738f, 0.04448255f, 0.06741892f, 0.02040053f, 0.10182253f, 0.39630207f, 
    0.06087866f, 0.04413660f, -0.02561525f, 0.25330445f, 0.04437542f, -0.00460316f, -0.03323524f, 0.01281054f, 
    0.11661652f, -0.05061538f, 0.03031759f, 0.28380227f, -0.01610251f, 0.04633906f, 0.08249059f, 0.08748089f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05095209f, 0.05189126f, -0.12363830f, 0.13892664f, -0.01294716f, 0.14329045f, 0.08929235f, 0.27859217f, 
    -0.10644773f, 0.34476018f, -0.07266755f, -0.09649294f, -0.18215284f, -0.14705828f, 0.13790822f, 0.08139870f, 
    -0.17357041f, 0.31069222f, -0.35760933f, -0.19086692f, -0.05549024f, 0.05967209f, -0.22629492f, -0.06670216f, 
    0.24334715f, 0.08361664f, 0.06319264f, 0.30555421f, 0.12735261f, 0.00099447f, 0.42860189f, -0.27695429f, 
    0.10859422f, -0.39487919f, 0.14018735f, 0.09911215f, 0.15053716f, 0.12338478f, 0.05456722f, -0.05571150f, 
    -0.28456631f, -0.04052932f, 0.46205693f, 0.17020057f, -0.08857848f, -0.07144899f, 0.11937653f, -0.72143388f, 
    0.05983014f, 0.19008824f, -0.05653263f, 0.03562593f, 0.16613038f, 0.04158713f, 0.50188488f, 0.38798988f, 
    0.02685945f, 0.13680375f, -0.48402631f, -0.25097999f, 0.01755288f, -0.00243477f, 0.23837212f, 0.51783168f, 
    0.21306558f, 0.08831672f, 0.15134804f, -0.09317753f, 0.22096959f, -0.41935974f, -0.16438526f, 0.16171044f, 
    0.09096105f, -0.17141110f, 0.01279769f, -0.12954712f, -0.05134017f, -0.24437836f, -0.09486472f, -0.08626579f, 
    0.13617478f, -0.19152527f, -0.13522358f, 0.21461441f, 0.02386620f, 0.00110058f, -0.06287150f, -0.42639402f, 
    -0.03680757f, 0.12911600f, -0.10684263f, -0.21205683f, 0.04672069f, -0.11851384f, -0.48634711f, 0.36167687f, 
    0.14079243f, 0.03668946f, -0.10814463f, 0.14844584f, -0.07499745f, -0.16927619f, 0.04367127f, 0.15720206f, 
    -0.09183217f, 0.01458083f, -0.12996219f, 0.02489137f, -0.10207161f, 0.43430337f, 0.32864866f, -0.11570179f, 
    -0.09646221f, 0.12078925f, -0.13399458f, 0.53623599f, 0.10488280f, -0.15441237f, 0.05036023f, 0.02365707f, 
    -0.03868520f, 0.04846790f, 0.24174148f, -0.03215587f, 0.06562141f, 0.11652756f, 0.05628695f, -0.04096503f, 
    0.12201804f, -0.40248415f, 0.12384571f, -0.04093844f, 0.08183182f, -0.13525705f, -0.22742486f, 0.22448915f, 
    -0.10227230f, 0.31088212f, 0.19145113f, -0.04812701f, -0.06221043f, -0.06797962f, -0.16481471f, 0.07707254f, 
    0.16548859f, -0.21280937f, -0.00716450f, -0.16838670f, -0.08987077f, 0.11600778f, 0.10951586f, -0.20758609f, 
    0.09321108f, -0.12196733f, -0.09340296f, 0.20842806f, -0.08981858f, -0.08927877f, 0.49018651f, 0.00963748f, 
    0.17830659f, -0.26491562f, 0.00011449f, 0.32667136f, -0.03287872f, 0.18959814f, 0.00041391f, -0.29581141f, 
    0.11361640f, 0.11872809f, 0.06638694f, -0.06316214f, 0.03936830f, -0.30545112f, 0.11177094f, -0.15675583f, 
    0.09419373f, -0.03521241f, 0.33553919f, -0.18932848f, 0.16265059f, 0.01207605f, -0.06694138f, 0.10200898f, 
    -0.13636267f, -0.13783003f, -0.39190996f, 0.27303287f, -0.13749887f, -0.05269460f, 0.13165498f, 0.06659167f, 
    -0.38535479f, -0.18082926f, 0.09292225f, 0.15097451f, 0.02412068f, 0.13751146f, -0.01064102f, 0.30109045f, 
    0.04293656f, 0.06634979f, -0.05871680f, -0.00319728f, -0.41295055f, -0.49352154f, 0.10598172f, -0.25740656f, 
    0.03176179f, 0.07583012f, 0.11375303f, 0.21628119f, 0.10287721f, 0.07013592f, 0.06291613f, 0.10681852f, 
    -0.04487276f, -0.16343011f, 0.12454657f, 0.19857036f, 0.06945654f, 0.16708763f, 0.28664201f, 0.25858188f, 
    0.08431208f, 0.02953002f, -0.17352282f, 0.11341909f, -0.18722793f, 0.49336982f, -0.09816285f, -0.03811393f, 
    -0.10587817f, -0.06465732f, 0.06045229f, 0.05855653f, 0.20667465f, -0.02934190f, -0.08003514f, 0.21981496f, 
    -0.09651144f, 0.42726752f, -0.16627467f, 0.14213844f, 0.02461355f, 0.15757978f, 0.23990303f, 0.27607527f, 
    -0.05893115f, 0.12718590f, -0.23979759f, -0.06348793f, -0.02115912f, -0.06823801f, -0.20376433f, -0.24895035f, 
    -0.25968352f, -0.10091542f, 0.16128917f, -0.25289449f, -0.00378332f, 0.13002911f, -0.09139271f, 0.14885169f, 
    0.23289213f, 0.04549377f, -0.08794574f, 0.07199977f, -0.14471984f, 0.14300370f, -0.11922110f, 0.41949403f, 
    0.15337993f, 0.02642985f, -0.00096089f, 0.24289168f, -0.12170819f, 0.10783317f, 0.28087631f, -0.18879078f, 
    -0.09874538f, 0.03535364f, 0.12175222f, -0.09612572f, -0.16962059f, 0.17190628f, -0.16436087f, 0.28968683f, 
    0.07494899f, -0.00746211f, -0.05408075f, -0.01084403f, 0.20154038f, -0.06459485f, 0.13209625f, 0.12699609f, 
    0.29231089f, -0.04377193f, -0.27545023f, 0.00007068f, -0.10943944f, 0.18699108f, -0.23958801f, -0.05332265f, 
    0.00042956f, -0.13636397f, -0.14385654f, -0.35906067f, -0.17176311f, 0.07650985f, -0.45775107f, -0.10057611f, 
    -0.26432252f, -0.14982477f, 0.08679713f, 0.33686194f, 0.01456181f, 0.11761008f, -0.03574862f, -0.08258115f, 
    0.08076690f, -0.02828018f, -0.03305939f, -0.30278739f, 0.14919488f, -0.04476167f, -0.08729739f, -0.08664208f, 
    -0.06088150f, -0.16178849f, 0.32233474f, 0.07667855f, -0.03357249f, -0.22318751f, -0.10487576f, 0.22155358f, 
    0.27672079f, 0.04923703f, 0.08583060f, -0.25794849f, 0.00039238f, 0.08338260f, 0.25487387f, 0.17082775f, 
    0.13608761f, -0.05070638f, -0.10761718f, -0.07684682f, 0.07635439f, 0.15919231f, 0.03597257f, 0.03545123f, 
    0.26811719f, -0.00502485f, 0.12222329f, -0.09692339f, -0.11787303f, -0.13431211f, 0.09205379f, 0.15199147f, 
    -0.24585514f, 0.18253033f, -0.02959458f, 0.07829705f, -0.05989255f, -0.33645356f, 0.22278468f, -0.01083128f, 
    0.10635135f, -0.10593396f, -0.11545771f, 0.63033247f, 0.10308610f, -0.17713635f, 0.26461244f, -0.08587158f, 
    0.28867528f, -0.12926391f, -0.09440967f, 0.05230966f, 0.12235817f, 0.04083933f, -0.09123814f, 0.02170325f, 
    -0.18788025f, 0.03342319f, 0.14607021f, -0.13985156f, -0.18943882f, 0.07543142f, 0.08251163f, 0.43825898f, 
    -0.05499368f, -0.00433843f, -0.02382367f, -0.04625320f, -0.23439597f, -0.35442612f, 0.23379004f, 0.10855282f, 
    0.01078466f, 0.05128717f, 0.09142049f, -0.02878515f, -0.10386700f, 0.06217103f, 0.07474180f, -0.05005297f, 
    -0.23316669f, 0.04964203f, 0.13920102f, 0.18824013f, -0.06923494f, -0.15117708f, -0.32418066f, 0.25646880f, 
    -0.04434757f, -0.07287832f, -0.18315390f, 0.08560067f, -0.11464620f, 0.07929257f, -0.24312688f, -0.10290768f, 
    -0.01895537f, -0.02620619f, 0.12915844f, -0.03200265f, -0.17086948f, -0.00126763f, -0.01137942f, 0.15245053f, 
    -0.00056977f, -0.23758510f, 0.07307070f, -0.20266028f, -0.16776589f, 0.15810506f, -0.01001418f, 0.13570629f, 
    -0.02929667f, -0.11827487f, 0.02660952f, 0.12798297f, 0.10247993f, 0.09939245f, 0.03179232f, 0.14244686f, 
    -0.28969565f, -0.00591367f, 0.15290162f, -0.10508306f, -0.33892745f, 0.12623180f, 0.07964125f, 0.04577051f, 
    0.18879616f, -0.25317591f, -0.06208077f, -0.06387711f, -0.26012549f, 0.62079901f, 0.10287447f, 0.28963915f, 
    -0.10598969f, -0.17398846f, -0.01478355f, 0.17645729f, 0.10039958f, 0.02243820f, -0.52232271f, 0.10829026f, 
    0.19067401f, 0.13937759f, 0.22738484f, 0.10175333f, -0.18328403f, -0.08997801f, 0.12807383f, -0.27613273f, 
    -0.04016284f, -0.21801952f, 0.05283728f, 0.12287010f, 0.10010124f, 0.19323954f, -0.39751253f, 0.10325928f, 
    0.07239628f, 0.16490804f, 0.08087194f, 0.13259062f, -0.16572604f, -0.45074141f, -0.38413033f, 0.03681341f, 
    0.16298923f, 0.08735206f, 0.26537901f, -0.22591810f, -0.16449602f, -0.08285457f, 0.13032864f, -0.08958171f, 
    -0.23254101f, -0.00738522f, -0.29797876f, 0.06493443f, -0.05084066f, 0.17037924f, 0.02050089f, 0.18109691f, 
    -0.11196085f, 0.08660998f, -0.08100671f, 0.32066244f, -0.28138769f, -0.22131634f, -0.04681608f, 0.04932792f, 
    0.22058831f, 0.20234899f, 0.26684216f, -0.13373233f, -0.00904062f, 0.15137166f, -0.50247246f, -0.00582834f, 
    -0.08416249f, 0.23152013f, 0.03925979f, 0.04779769f, -0.13903703f, 0.08956841f, 0.05850084f, -0.26080590f, 
    0.30947366f, 0.01500263f, -0.14639391f, -0.06555860f, 0.12658086f, -0.08804420f, -0.22977144f, -0.11240441f, 
    -0.36723572f, 0.14560458f, -0.14581621f, -0.20125565f, -0.09979103f, -0.07384424f, 0.25247955f, 0.25692797f, 
    0.24726689f, 0.12159471f, -0.17886201f, -0.14854330f, -0.24814790f, 0.18775553f, 0.23976986f, 0.20707469f, 
    -0.04077394f, 0.08186841f, -0.16887675f, -0.20635359f, 0.05512065f, 0.05164173f, -0.01569930f, 0.04842661f, 
    -0.07048312f, 0.11380281f, 0.15993921f, 0.15029775f, -0.06123668f, -0.03098234f, 0.31275702f, -0.08731236f, 
    -0.11021048f, -0.25597870f, -0.12240095f, 0.25110531f, 0.02099959f, -0.07063884f, -0.10121600f, 0.32710966f, 
    0.29740086f, 0.21124811f, -0.10279395f, 0.01857422f, -0.23944134f, -0.24082156f, -0.17936145f, 0.01706658f, 
    -0.27030689f, 0.11276703f, 0.23923096f, 0.14713763f, 0.10723079f, 0.00666700f, -0.02089136f, -0.03916649f, 
    -0.17981070f, 0.13110319f, 0.03865790f, 0.37427971f, -0.09248169f, -0.13060229f, 0.16340023f, -0.26224178f, 
    -0.29264379f, -0.34430081f, 0.07344255f, -0.16674411f, 0.17505534f, 0.17232138f, -0.15593384f, 0.04863310f, 
    -0.06282914f, 0.15847763f, 0.18369116f, 0.05542323f, -0.31296551f, -0.38713744f, 0.03072984f, 0.23111911f, 
    0.15800102f, 0.03584195f, 0.11704900f, -0.30118871f, 0.02066487f, 0.00032832f, 0.00180545f, -0.20708716f, 
    0.28028312f, -0.12403337f, -0.00817731f, 0.40481225f, 0.04204300f, 0.01715720f, 0.45452660f, -0.06857480f, 
    0.02547392f, -0.15198368f, 0.07443047f, -0.13355310f, -0.06155818f, -0.08930526f, -0.09144753f, -0.05988129f, 
    -0.10978025f, -0.14167796f, 0.08665065f, -0.17470364f, -0.16536695f, 0.03539512f, 0.02659838f, 0.01581327f, 
    0.08965861f, -0.08457991f, 0.06493188f, -0.14872354f, 0.07738581f, 0.05278518f, -0.09747728f, -0.04914412f, 
    0.08549539f, 0.04805329f, -0.11892662f, -0.12779468f, 0.02126901f, 0.02520548f, 0.00688576f, -0.15820850f, 
    0.04720227f, -0.25938857f, -0.08582026f, -0.18551451f, -0.09042709f, 0.16762772f, 0.11923056f, -0.05663350f, 
    -0.02463759f, -0.16155495f, 0.08979286f, -0.09998962f, -0.05024789f, -0.16846742f, -0.14598601f, -0.16451839f, 
    -0.03980764f, -0.15200734f, 0.01488205f, 0.12380058f, 0.03958948f, -0.10777017f, -0.01230286f, -0.11818989f, 
    0.00537287f, -0.00390565f, 0.06886490f, -0.01713206f, -0.10949896f, 0.18142518f, -0.04756818f, 0.10619187f, 
    0.00453991f, -0.17620629f, -0.18156566f, -0.11567435f, 0.04357334f, 0.38997516f, -0.15988660f, 0.01110449f, 
    0.08436594f, -0.11280023f, 0.12802894f, 0.16848969f, 0.22080652f, -0.20230936f, -0.09145809f, 0.25336555f, 
    0.01938057f, 0.12739198f, 0.05662320f, 0.05038109f, 0.11678966f, -0.06477747f, -0.01079585f, -0.15269981f, 
    0.34286380f, -0.17053127f, -0.07937699f, -0.22201450f, -0.11204349f, -0.15329447f, -0.06945997f, -0.05989848f, 
    -0.07309455f, 0.00869640f, 0.07194134f, 0.00388715f, -0.20031983f, -0.17785250f, 0.11171836f, -0.01254396f, 
    -0.02177007f, 0.05302396f, 0.01680068f, -0.02397684f, -0.14908665f, 0.13505360f, 0.05433606f, 0.10164644f, 
    -0.14250837f, 0.03104218f, 0.08231738f, 0.09523903f, -0.13764656f, 0.11750197f, 0.12920211f, -0.18512920f, 
    -0.12525186f, -0.14002730f, -0.15878674f, -0.01527693f, -0.07365372f, 0.05794257f, -0.15268460f, -0.04290240f, 
    0.20676872f, -0.15538754f, 0.08503827f, 0.02857076f, 0.21924615f, -0.12353812f, -0.00060034f, 0.04595433f, 
    -0.16745463f, 0.01874514f, 0.37454358f, -0.07059784f, 0.07760739f, -0.02611714f, -0.15418722f, 0.01482022f, 
    0.21387464f, 0.00361959f, 0.21879429f, 0.04018735f, 0.17209724f, -0.12920412f, 0.13590582f, 0.05541749f, 
    0.36748606f, -0.01757920f, -0.22009742f, -0.24998184f, 0.01166370f, -0.15062931f, 0.40917453f, -0.11908429f, 
    -0.18766169f, 0.02504003f, -0.02845614f, -0.31117398f, 0.15627006f, -0.08211716f, 0.00924193f, 0.18575719f, 
    0.09570017f, -0.14187045f, 0.41974065f, 0.05531191f, -0.25612283f, 0.31806585f, 0.00835731f, -0.16666010f, 
    0.06355297f, -0.09207052f, -0.04862188f, 0.48072910f, 0.06885672f, -0.07118070f, 0.03555427f, 0.17341527f, 
    0.32986286f, -0.16131644f, 0.14702329f, -0.19623029f, -0.10296831f, -0.12734915f, 0.32364941f, 0.35820851f, 
    -0.32410353f, -0.18315977f, 0.09509771f, -0.15970601f, -0.21117237f, -0.08998013f, -0.07842949f, 0.28441378f, 
    0.40862811f, -0.10074662f, 0.17931381f, 0.02516446f, -0.35988432f, 0.12149033f, 0.18678863f, 0.02463259f, 
    0.02564314f, -0.32472429f, 0.01952557f, 0.43153423f, -0.09845053f, -0.01186015f, -0.06335458f, 0.09631108f, 
    0.28033853f, 0.09350921f, 0.20922320f, 0.25117260f, -0.17566665f, 0.03054828f, 0.08152445f, 0.24624144f, 
    -0.37758574f, 0.09229066f, -0.09721370f, -0.23202074f, -0.02395883f, -0.11763090f, 0.00921633f, 0.25601140f, 
    0.13142933f, 0.05012321f, 0.04915113f, -0.11508109f, -0.09457701f, -0.06654275f, 0.02455531f, -0.11568224f, 
    -0.18191366f, -0.11881758f, -0.23754013f, 0.27224007f, 0.03651336f, 0.16884698f, 0.06774569f, -0.22183612f, 
    0.02595274f, -0.10770102f, 0.10328992f, 0.24617085f, -0.07763714f, 0.17790893f, 0.20031236f, 0.33835569f, 
    0.16840167f, 0.00277080f, 0.13366984f, 0.02654088f, -0.00931072f, 0.08709030f, 0.06546171f, -0.27240020f, 
    0.21931981f, -0.21052919f, 0.00559685f, -0.11701764f, 0.10737879f, 0.20926394f, 0.17447542f, -0.10091189f, 
    0.20359153f, -0.27313438f, 0.08901539f, -0.29107121f, -0.03827347f, -0.05932661f, -0.28982526f, -0.04298495f, 
    0.20244595f, -0.09511586f, -0.03988388f, 0.22030249f, -0.17748676f, 0.05803181f, -0.26138553f, -0.03376833f, 
    -0.03064837f, -0.01508308f, 0.03975479f, -0.28128052f, 0.07881714f, 0.05382798f, 0.11429184f, -0.05995642f, 
    -0.03080512f, 0.17420174f, 0.00015934f, -0.15794994f, -0.30052748f, -0.06037602f, 0.18501991f, 0.12605369f, 
    -0.01568103f, -0.19713180f, 0.23728123f, 0.22048041f, -0.11502899f, -0.16416143f, -0.01493723f, -0.20756795f, 
    -0.07746744f, -0.12578556f, 0.13271751f, 0.40530464f, 0.14977300f, 0.04599336f, 0.25003818f, -0.21480469f, 
    0.08436871f, -0.19598931f, -0.03458393f, -0.22988948f, 0.19238810f, 0.00625483f, 0.21151119f, -0.08208514f, 
    0.10781893f, -0.08779805f, 0.04224353f, 0.03457733f, -0.18786111f, -0.15428622f, 0.29160845f, -0.15522335f, 
    -0.06324844f, 0.08529223f, 0.15075669f, 0.18253590f, 0.03418943f, -0.14161219f, -0.25364459f, 0.17123443f, 
    0.08241387f, 0.04799705f, -0.01744252f, 0.34992480f, 0.03359987f, -0.02757133f, 0.29588357f, -0.31041798f, 
    -0.04636905f, 0.12611005f, -0.07625759f, 0.00007897f, -0.23008420f, -0.06114234f, 0.29391897f, 0.12240776f, 
    -0.13962069f, 0.18771484f, 0.32518551f, -0.16378196f, -0.10599649f, 0.06732954f, -0.00769769f, -0.03635158f, 
    -0.15528539f, 0.08138058f, -0.18494135f, 0.50631171f, -0.12432047f, -0.14654933f, 0.27312461f, 0.35675973f, 
    0.27366018f, -0.17510526f, -0.12875772f, -0.23521625f, 0.09433858f, 0.06659489f, 0.25688344f, 0.41744399f, 
    -0.35047382f, 0.17483352f, -0.09326188f, -0.01534079f, -0.16109537f, 0.30370188f, 0.08561454f, 0.26854619f, 
    0.07849326f, 0.19314884f, -0.17599471f, 0.07650454f, -0.29842192f, -0.27751592f, 0.19743797f, 0.21468647f, 
    -0.11012927f, 0.10481672f, -0.32344943f, 0.04450106f, -0.11481142f, 0.01106832f, -0.11042841f, -0.02678953f, 
    0.16406594f, -0.12084040f, -0.00862953f, 0.28328693f, 0.06773184f, 0.14300354f, 0.57439852f, -0.04138507f, 
    -0.11576496f, 0.13839808f, -0.08834504f, 0.10723276f, -0.08588447f, -0.02694973f, -0.13163847f, 0.09724891f, 
    -0.01546045f, -0.02567390f, -0.18173511f, -0.15972976f, -0.15395549f, 0.08385690f, 0.05612332f, -0.10969258f, 
    -0.13091649f, -0.01713069f, 0.00310769f, -0.20741631f, 0.07141254f, -0.16579150f, -0.05983814f, -0.09063166f, 
    0.02895110f, 0.00734225f, -0.17787053f, -0.17803632f, 0.09339729f, 0.07208666f, -0.14671427f, -0.00336466f, 
    -0.11962935f, 0.16056560f, -0.06193212f, 0.09327494f, -0.12252539f, -0.00909868f, -0.05245986f, 0.05065377f, 
    0.30205727f, 0.08410209f, -0.02981593f, 0.10619996f, -0.27141687f, 0.07093460f, 0.34144393f, 0.08256629f, 
    -0.12951423f, -0.20312881f, -0.36889264f, 0.19140580f, -0.07605802f, 0.17743206f, 0.06957159f, -0.01167954f, 
    0.31308082f, -0.07381854f, -0.01968799f, 0.29818714f, 0.21119289f, -0.04044411f, 0.53741491f, -0.09445464f, 
    -0.03482552f, 0.16714941f, -0.15755084f, 0.16996819f, -0.02496527f, 0.00487290f, 0.04374110f, -0.09169310f, 
    -0.01448233f, -0.25796741f, 0.22228345f, 0.13155398f, -0.01800175f, -0.31146118f, -0.18671282f, -0.05819182f, 
    -0.18693469f, 0.07634792f, -0.22452050f, 0.04155388f, -0.00957785f, -0.01902372f, 0.11974219f, 0.09543666f, 
    -0.54503012f, 0.14196114f, -0.20499837f, 0.07238983f, -0.06791013f, -0.12332143f, 0.31384331f, 0.43215531f, 
    0.04756732f, 0.12636124f, 0.04302632f, 0.08069564f, -0.12788527f, -0.10309435f, -0.04204070f, -0.13568501f, 
    -0.08608729f, -0.19610508f, -0.07814848f, -0.08490533f, -0.15007101f, -0.12750725f, -0.14524913f, 0.09996900f, 
    -0.07726398f, 0.00624106f, -0.04827500f, -0.12657364f, -0.13579296f, -0.01565239f, 0.03642558f, -0.11476861f, 
    0.03115648f, 0.04554038f, -0.14915060f, 0.11188847f, 0.17593902f, -0.07090400f, -0.15833494f, -0.11924116f, 
    0.26428527f, -0.11374269f, -0.04846264f, -0.14035565f, -0.10880687f, -0.19329132f, 0.34681669f, -0.15881072f, 
    -0.06881984f, 0.15906057f, -0.20490293f, 0.16839892f, -0.13682230f, 0.54319572f, 0.02838799f, 0.12268018f, 
    0.01123320f, -0.34152588f, -0.00702251f, 0.07647335f, 0.09397043f, -0.12624581f, -0.08823626f, -0.12422077f, 
    0.24621274f, 0.13864626f, 0.14795423f, 0.16940628f, -0.09617040f, 0.11245196f, 0.14284372f, -0.29744899f, 
    0.00588921f, -0.05008730f, 0.03231066f, -0.51471788f, 0.08607202f, 0.20498498f, 0.17212866f, 0.21802491f, 
    0.24518137f, -0.22510777f, -0.02712858f, -0.08708721f, -0.15070745f, 0.63742083f, 0.02448758f, -0.14713572f, 
    -0.00565512f, 0.04925166f, -0.11572351f, -0.11811354f, -0.07691996f, -0.16227940f, -0.07714224f, 0.38230762f, 
    0.24650984f, -0.14225313f, 0.17230193f, -0.30792928f, -0.13902976f, -0.16379739f, -0.13314609f, 0.15696257f, 
    0.07516703f, -0.39806473f, 0.09791790f, -0.15287641f, 0.20551774f, 0.31772494f, 0.11383108f, 0.06621885f, 
    -0.00818809f, 0.00637034f, 0.23064767f, 0.02300549f, 0.17551146f, -0.13819931f, -0.31858203f, -0.11309525f, 
    0.31025290f, 0.04851754f, 0.14793424f, -0.45250195f, 0.11294703f, 0.10022059f, 0.33606863f, 0.17628126f, 
    -0.01964278f, 0.08390234f, -0.45160571f, -0.23717679f, -0.00515138f, -0.04254351f, -0.15989107f, 0.35170332f, 
    -0.13322291f, 0.01366958f, -0.15313368f, -0.06080656f, -0.01576220f, 0.47517055f, 0.30122897f, 0.08001450f, 
    0.20795079f, 0.24688433f, 0.05805009f, 0.11794949f, -0.10172063f, 0.22173075f, 0.27424559f, 0.16069862f, 
    0.08018134f, 0.22617015f, 0.03582195f, -0.57976151f, 0.05973842f, -0.01175198f, -0.39031997f, 0.21598104f, 
    0.18750274f, 0.09420017f, -0.02527632f, 0.03348746f, 0.08079863f, -0.14316900f, 0.43389064f, -0.19807987f, 
    -0.08138640f, 0.00269013f, 0.12672757f, -0.06796940f, 0.00793179f, 0.02839205f, -0.14725652f, -0.02231189f, 
    -0.10612939f, 0.14513935f, 0.06177985f, -0.10429027f, -0.19842237f, 0.14352636f, 0.05724205f, 0.08378799f, 
    -0.10991837f, 0.06072313f, -0.16872473f, 0.08462326f, -0.07265429f, 0.07058784f, 0.00829548f, -0.08352818f, 
    0.10986190f, 0.01687463f, -0.14574620f, 0.10958336f, -0.13026512f, 0.11943087f, -0.05903789f, -0.06723541f, 
    0.21355942f, -0.19023085f, 0.07695883f, 0.33641657f, 0.15138029f, -0.07168228f, 0.09744434f, 0.04775139f, 
    -0.04964979f, 0.27674392f, -0.13273603f, -0.00272157f, 0.17182633f, -0.20757076f, -0.35807496f, 0.10013009f, 
    -0.29479086f, 0.19184470f, 0.28283215f, 0.26889840f, -0.07727875f, -0.03549999f, -0.18958931f, -0.51210189f, 
    -0.44852522f, -0.04046983f, -0.22984827f, 0.01955772f, 0.13541241f, -0.04882348f, 0.17531395f, -0.21938820f, 
    0.18064000f, -0.42884111f, 0.00802714f, -0.24674693f, -0.03389858f, 0.11046316f, -0.04950679f, -0.01137695f, 
    0.13087748f, -0.06339180f, 0.21443897f, 0.02259855f, -0.17304689f, 0.07879227f, 0.47547397f, 0.12639552f, 
    0.14414729f, -0.09634864f, 0.10595228f, -0.27875954f, 0.03379741f, -0.05344876f, 0.09101328f, 0.43243644f, 
    0.43040174f, -0.16049461f, -0.22428198f, 0.01356785f, -0.06554122f, 0.03679312f, 0.18916342f, -0.05591341f, 
    -0.30863461f, -0.22911587f, 0.12006418f, -0.07651548f, 0.16354251f, 0.07949584f, -0.33712289f, -0.04923565f, 
    0.11116618f, -0.24138127f, 0.11957179f, 0.11353225f, -0.00032752f, -0.46319482f, -0.02069469f, -0.04800191f, 
    0.16635373f, 0.09306628f, 0.15313770f, 0.13850649f, 0.16692860f, 0.10204815f, 0.13081649f, 0.14073297f, 
    0.06184770f, 0.12482110f, 0.21490252f, -0.04951020f, 0.11525977f, 0.08241961f, -0.21670024f, 0.44400665f, 
    -0.13337544f, -0.02083365f, 0.06664684f, -0.16011287f, -0.31726873f, 0.01052745f, 0.22858605f, 0.18389457f, 
    -0.19580457f, 0.18617231f, -0.13992259f, 0.08250410f, 0.07601009f, 0.18203650f, 0.03267953f, 0.45842788f, 
    0.03383756f, 0.13828444f, -0.28077623f, 0.02519994f, -0.01478028f, 0.13951513f, 0.14874896f, 0.16596198f, 
    -0.00919613f, 0.06426138f, 0.15961489f, 0.03162277f, 0.21824895f, 0.08573941f, 0.07793915f, 0.14900936f, 
    0.05698707f, -0.12795760f, 0.02555195f, -0.05479122f, 0.05582259f, 0.34502140f, -0.27475852f, 0.17935456f, 
    0.01044074f, 0.29452974f, 0.03791570f, -0.02284778f, 0.06504729f, -0.48032847f, 0.16404533f, -0.00517190f, 
    0.21658295f, 0.37117270f, 0.02482930f, -0.18682906f, 0.06688010f, 0.05244662f, 0.07693281f, 0.00173713f, 
    0.15827179f, 0.09482316f, 0.05551761f, -0.08676574f, 0.22251625f, 0.01733287f, 0.28537750f, -0.20038421f, 
    -0.23669128f, 0.09275130f, -0.16718592f, -0.13607086f, 0.07412907f, -0.20004466f, 0.21201684f, -0.17607075f, 
    0.20583418f, 0.00845755f, -0.18417655f, -0.05430617f, -0.21597849f, 0.27904004f, 0.20322008f, 0.19843125f, 
    -0.13774368f, -0.17008638f, 0.18030724f, 0.05130323f, -0.02219883f, 0.04244209f, -0.16375200f, -0.18767029f, 
    -0.20373520f, -0.08835968f, 0.16675784f, 0.41057739f, -0.06842994f, -0.12509099f, 0.03792182f, -0.05808917f, 
    -0.15545414f, -0.02706991f, -0.00310020f, -0.04154951f, 0.15077494f, -0.25627810f, -0.18080369f, -0.27640852f, 
    0.09725478f, -0.26072901f, -0.01626694f, 0.02227347f, 0.10116094f, 0.02844804f, 0.09793556f, 0.17131948f, 
    -0.11450050f, -0.36171493f, 0.08857863f, 0.08858425f, 0.08448309f, 0.10625897f, 0.07902006f, -0.00956433f, 
    0.06570330f, -0.07165706f, 0.17342699f, 0.33090952f, 0.06958196f, -0.09220698f, -0.04687927f, 0.07708941f, 
    -0.08699945f, -0.19010437f, -0.06079048f, 0.07430249f, 0.25228149f, -0.01258045f, 0.17590220f, -0.15120907f, 
    0.10135271f, -0.19970383f, 0.44952840f, -0.17283948f, -0.24587248f, -0.11820278f, 0.13843927f, -0.48394263f, 
    0.13915066f, -0.01538561f, 0.10084251f, -0.05856982f, 0.10694414f, 0.01319020f, 0.08415592f, 0.19279662f, 
    -0.06254596f, 0.03963355f, -0.30833560f, -0.01494393f, -0.08022064f, 0.16446160f, 0.18162298f, 0.30552423f, 
    -0.00922191f, -0.31408060f, 0.10406640f, 0.14175771f, 0.20686133f, 0.27202469f, -0.29357532f, 0.09721398f, 
    -0.03543915f, 0.21582180f, -0.20162852f, 0.06523114f, -0.23550776f, 0.03609131f, -0.36494020f, 0.17287691f, 
    -0.03370322f, -0.00202685f, 0.22957186f, 0.04038111f, 0.12909311f, -0.08316615f, -0.16160129f, -0.11076193f, 
    -0.46098945f, 0.02506086f, -0.11113186f, 0.41008925f, 0.15383239f, 0.05601943f, -0.06388554f, -0.10645481f, 
    0.06228469f, 0.04762661f, -0.08655043f, 0.07984845f, -0.15690228f, 0.24340343f, 0.24311450f, -0.15573202f, 
    0.11292396f, 0.01402772f, 0.19538961f, -0.14616780f, 0.12589030f, 0.06216278f, 0.25102523f, -0.14034775f, 
    -0.12650488f, 0.22198147f, -0.25489408f, 0.24364568f, -0.14436831f, -0.05370474f, -0.22658671f, 0.17902184f, 
    -0.08491924f, -0.11211201f, 0.04397994f, -0.00138692f, 0.06358191f, -0.02126699f, 0.25518271f, -0.13428597f, 
    -0.42261973f, 0.02058046f, -0.07478417f, -0.07833178f, -0.18043183f, 0.06733812f, 0.38991085f, 0.42327443f, 
    0.13273963f, 0.07943168f, -0.16124268f, -0.03435573f, -0.20120893f, 0.55366617f, 0.09119783f, 0.03905740f, 
    -0.13000771f, 0.10595050f, -0.31695837f, 0.37472773f, 0.04794270f, -0.02218723f, 0.01860829f, 0.15671559f, 
    0.03554732f, 0.13295914f, 0.13495682f, 0.05944949f, -0.05178466f, 0.15749346f, 0.09303355f, 0.48855993f, 
    -0.06504504f, 0.07350238f, -0.13459851f, 0.04821697f, -0.08839455f, -0.10270222f, 0.11137893f, -0.13213091f, 
    -0.17127937f, -0.11040691f, -0.04629270f, -0.00856329f, -0.08561046f, -0.06836931f, 0.11387602f, 0.12416762f, 
    -0.24076170f, -0.10028271f, 0.02630336f, -0.16617565f, 0.08677663f, 0.01696961f, -0.17810878f, -0.11008746f, 
    -0.00830666f, -0.04998578f, -0.17403018f, 0.10523333f, 0.09539147f, -0.05901058f, -0.15528718f, -0.10858356f, 
    0.25390518f, -0.01370877f, -0.05167177f, 0.08265892f, 0.18388873f, -0.01743235f, 0.15958917f, -0.11788704f, 
    0.09976162f, 0.03645587f, 0.48042884f, 0.11694624f, 0.01538481f, 0.06616320f, -0.19768231f, -0.11491203f, 
    0.24293405f, 0.29670224f, 0.13829733f, -0.21325164f, 0.06163900f, -0.00201362f, 0.22812258f, 0.04252905f, 
    0.26421580f, -0.05415956f, -0.25065279f, -0.35613009f, -0.02639826f, -0.06856230f, 0.25370395f, 0.04922904f, 
    0.17475829f, 0.09671664f, -0.07675695f, -0.42570022f, -0.14174254f, 0.35144839f, 0.04318909f, -0.17510848f, 
    0.08243526f, -0.07785941f, -0.02318223f, -0.08153498f, 0.02953258f, 0.37943608f, 0.23258577f, 0.23171690f, 
    0.28083915f, -0.17897853f, -0.09071764f, -0.05281423f, -0.00989436f, -0.02070200f, 0.11292598f, 0.35264257f, 
    0.24887632f, -0.12500933f, -0.08488598f, 0.20167693f, -0.00060236f, -0.13632712f, 0.19209890f, -0.23190711f, 
    0.00326697f, 0.11022595f, 0.08445624f, -0.00538261f, -0.24772051f, 0.20106788f, 0.29262966f, 0.15696572f, 
    -0.13335596f, -0.14472896f, 0.00971508f, 0.02404152f, 0.03375512f, 0.61594826f, 0.29068163f, 0.18833989f, 
    0.00038911f, -0.01614887f, -0.28359330f, 0.23915088f, -0.05751733f, 0.08766910f, 0.25625673f, -0.00896039f, 
    0.42393839f, -0.09140632f, 0.11738186f, -0.02709139f, 0.17180012f, -0.06158767f, 0.22372550f, 0.13451727f, 
    0.10585433f, -0.17772429f, 0.05526419f, -0.09077539f, 0.04219146f, 0.41149977f, 0.00225573f, -0.13695168f, 
    0.30042669f, -0.13401903f, 0.12606311f, 0.03252714f, -0.25245520f, -0.13709626f, 0.37891039f, -0.09535244f, 
    -0.03744175f, 0.10439508f, 0.07364906f, 0.19109285f, -0.10471613f, -0.10500065f, -0.26194745f, 0.40511683f, 
    0.25473377f, 0.12673895f, -0.01038120f, 0.10458027f, -0.10785576f, 0.09463809f, 0.02547939f, -0.14959463f, 
    -0.03921192f, -0.10232154f, 0.03396191f, -0.00372937f, -0.00347275f, -0.11333869f, 0.07665286f, -0.01776114f, 
    -0.03704792f, -0.08129277f, -0.11576847f, -0.02011568f, 0.23089740f, -0.06538290f, -0.20013374f, 0.11924875f, 
    -0.20267394f, -0.03386091f, -0.20704646f, 0.25999427f, 0.17385428f, -0.12609738f, 0.00708042f, -0.11666308f, 
    -0.11582531f, 0.01870163f, -0.15212582f, 0.03198262f, 0.17644943f, 0.12445060f, 0.02766479f, -0.11287612f, 
    0.07985594f, 0.14455786f, -0.05451231f, 0.10782026f, -0.08069588f, -0.02183972f, 0.21004565f, 0.25265077f, 
    -0.28177986f, 0.51844180f, 0.07716931f, 0.13186511f, 0.03756236f, -0.05372786f, -0.01294505f, 0.18769474f, 
    -0.11292397f, 0.09451506f, 0.18437096f, -0.22121227f, -0.08859280f, -0.05832947f, -0.05947303f, 0.21750988f, 
    0.20702349f, 0.10234755f, -0.02253664f, -0.06755229f, -0.03761187f, 0.08239368f, 0.16506968f, -0.47264174f, 
    -0.17687356f, 0.03683165f, 0.11391899f, -0.33927211f, 0.03943496f, 0.21181451f, -0.05556007f, 0.10299908f, 
    0.11444426f, -0.31705824f, 0.11154359f, -0.01056014f, 0.10624833f, 0.11852997f, 0.05542425f, -0.06037088f, 
    0.10787559f, 0.12227098f, -0.06303959f, -0.06835137f, -0.08225359f, -0.06269379f, 0.35768899f, 0.02462131f, 
    0.02258609f, -0.11614275f, -0.14433224f, -0.19705783f, 0.09933913f, -0.06281590f, -0.05787473f, 0.36435726f, 
    0.01152792f, 0.08175214f, 0.09658308f, 0.37438947f, -0.06452357f, 0.09356132f, 0.15961474f, 0.35478863f, 
    0.18933563f, 0.25479966f, 0.21668303f, 0.09432285f, -0.05172379f, -0.48973820f, -0.06887324f, -0.36352235f, 
    -0.17008351f, 0.32770112f, -0.05816291f, 0.16252604f, 0.11297917f, 0.16088177f, -0.17507623f, 0.37401721f, 
    -0.39600518f, -0.17670116f, 0.10885623f, -0.18920812f, -0.08492797f, 0.10538921f, 0.11689560f, 0.01840770f, 
    0.14172632f, 0.03348662f, 0.15305112f, 0.10154826f, -0.11375988f, -0.11378876f, 0.34234458f, 0.18379457f, 
    -0.08523729f, 0.27483845f, 0.09035634f, 0.11441971f, -0.06580891f, 0.33366874f, -0.06879242f, -0.22664420f, 
    -0.18298073f, 0.19028533f, -0.14745060f, 0.15371385f, -0.04347609f, -0.13453083f, 0.03461121f, -0.03536563f, 
    -0.08349770f, -0.08464298f, 0.19026940f, -0.01569962f, -0.05370999f, -0.15797812f, 0.21427707f, -0.05285250f, 
    0.21298398f, -0.24349518f, 0.08195570f, 0.34088525f, 0.09367924f, -0.31536624f, 0.15981647f, 0.13508585f, 
    -0.11884677f, 0.32092085f, 0.21544875f, 0.11689410f, 0.10019784f, -0.03013345f, -0.43462864f, 0.00977795f, 
    0.04788226f, -0.06072637f, -0.10410605f, 0.48763055f, 0.17859329f, -0.13011858f, 0.10814133f, -0.18250243f, 
    0.17675048f, -0.12297365f, -0.17563806f, -0.24249586f, 0.12864304f, -0.04581779f, -0.02492719f, 0.00622145f, 
    0.11969519f, -0.24017668f, -0.04318491f, 0.02420310f, 0.13307784f, 0.01638766f, -0.01848520f, 0.15931749f, 
    -0.24055409f, 0.42196414f, -0.03991779f, 0.15472619f, -0.07210751f, -0.14484130f, -0.05118169f, -0.20405540f, 
    -0.21802832f, 0.36456126f, 0.23041236f, -0.04291982f, 0.15694998f, 0.07957374f, -0.18872878f, 0.09575845f, 
    0.07114965f, 0.14198506f, 0.14185567f, -0.01167728f, 0.07126021f, 0.02142647f, -0.05843533f, -0.16353700f, 
    0.11296249f, -0.02346453f, 0.08544527f, -0.09710811f, 0.03570845f, 0.21577440f, -0.03878220f, 0.12932672f, 
    0.00506858f, 0.26506940f, 0.02968727f, -0.02130998f, -0.16170807f, -0.43144771f, -0.14789490f, -0.10446278f, 
    -0.13427833f, 0.02539262f, 0.21476142f, -0.11011821f, -0.09001278f, 0.06632301f, -0.03208691f, -0.02506071f, 
    0.00650768f, 0.03413433f, 0.01261885f, 0.21945517f, 0.09218703f, -0.01297795f, 0.31482634f, -0.07401545f, 
    -0.02737295f, -0.28490224f, -0.05909276f, 0.19789855f, 0.14062540f, -0.11902419f, -0.25292206f, 0.16852026f, 
    0.05154434f, 0.15019739f, 0.09454584f, 0.11661069f, -0.17911722f, -0.35231715f, -0.02747869f, -0.05728376f, 
    -0.12472014f, -0.05152012f, 0.16188155f, -0.18460874f, 0.05092206f, -0.01134008f, 0.31096253f, -0.15971786f, 
    -0.22307934f, -0.16816902f, 0.09310126f, 0.33075738f, 0.08552977f, -0.16195494f, -0.01152590f, 0.32499060f, 
    -0.19985579f, 0.14916269f, 0.10222794f, -0.20128407f, 0.13714975f, -0.14409323f, 0.05047876f, -0.09462380f, 
    0.26699266f, -0.40116003f, 0.23490013f, 0.10590763f, -0.16878653f, -0.04920500f, -0.35711986f, -0.44527289f, 
    -0.09143742f, -0.01026033f, -0.04396036f, 0.05534230f, 0.05421547f, 0.15797929f, 0.00102430f, 0.05558975f, 
    0.10948323f, 0.08902775f, 0.00088259f, -0.40021712f, -0.09627687f, 0.01644832f, 0.02307807f, 0.18073171f, 
    -0.16070613f, -0.03033993f, 0.13044761f, 0.08892840f, 0.18017595f, -0.31366637f, 0.21975321f, -0.02748827f, 
    -0.27280405f, 0.26411894f, 0.04688067f, -0.14701709f, -0.11636724f, 0.02915841f, -0.09880875f, 0.18705891f, 
    0.13801222f, 0.00883749f, 0.13508050f, -0.37085536f, -0.03417662f, -0.12483882f, 0.23368707f, -0.04507867f, 
    0.27878353f, -0.01186921f, -0.09133659f, 0.09298076f, -0.09517568f, -0.16496499f, 0.23211245f, 0.26579130f, 
    0.11262234f, -0.14496563f, -0.00956712f, 0.40180033f, -0.12895794f, 0.16089116f, 0.12087946f, 0.18301770f, 
    0.28188959f, -0.06822453f, 0.02975454f, 0.05371315f, 0.15010208f, 0.06147225f, -0.04186545f, -0.09769226f, 
    -0.26771569f, -0.00231643f, 0.00525351f, 0.36829948f, -0.05079439f, -0.05418304f, -0.22426295f, -0.00689707f, 
    -0.39986986f, -0.15620162f, 0.12195234f, 0.25206906f, -0.08138070f, 0.10636522f, -0.08230063f, 0.23761004f, 
    0.09623265f, 0.04672113f, 0.07670265f, 0.20525342f, -0.06571705f, 0.17400005f, -0.09913003f, -0.09587984f, 
    0.15879446f, 0.18621054f, -0.07836222f, -0.15767272f, -0.01313404f, -0.03450209f, -0.00924578f, -0.12785113f, 
    -0.17068096f, 0.14354254f, -0.19071974f, 0.28405872f, -0.02833728f, -0.02917400f, -0.39051664f, 0.25058371f, 
    -0.24126261f, 0.14026964f, 0.10901833f, 0.17748097f, 0.08795517f, 0.03780526f, -0.05194369f, -0.33244479f, 
    -0.19038199f, 0.08362302f, 0.01500976f, 0.10017096f, 0.05124627f, 0.15958962f, 0.16252653f, 0.07360455f, 
    -0.16421714f, -0.09265881f, -0.06417308f, 0.02064877f, -0.03967018f, -0.13854839f, -0.01196924f, -0.22386880f, 
    -0.05914753f, -0.06323275f, -0.15297514f, 0.01442497f, -0.04560293f, -0.04732682f, 0.15721251f, -0.10894988f, 
    -0.18954089f, -0.08727942f, -0.10663204f, -0.07744087f, -0.06866592f, 0.14052603f, -0.22448745f, -0.12373907f, 
    -0.08629812f, -0.01975452f, -0.08567232f, -0.13644822f, -0.13973102f, -0.16141891f, 0.00555858f, -0.00873205f, 
    0.04785985f, -0.11765887f, -0.11996201f, 0.05997195f, -0.04387682f, 0.03914373f, -0.10427893f, 0.02391902f, 
    -0.21054958f, -0.15824926f, -0.00375930f, -0.04679685f, -0.04708564f, -0.02141450f, -0.16708769f, 0.02538013f, 
    0.05588120f, -0.17315461f, -0.07416133f, -0.03453014f, 0.05175979f, -0.08635031f, 0.07313027f, -0.07089312f, 
    -0.06174495f, -0.05029501f, 0.15867312f, -0.09637611f, 0.22012571f, 0.02960541f, -0.04320918f, -0.03302396f, 
    0.20612624f, 0.19110560f, 0.31542307f, 0.15217252f, -0.06313569f, -0.36830494f, -0.21268380f, -0.49173367f, 
    0.03350051f, 0.24415086f, 0.04271267f, -0.06579309f, -0.16666833f, 0.10328951f, 0.02528141f, 0.06600785f, 
    -0.18986841f, -0.02234857f, 0.10037436f, 0.01470754f, -0.03001781f, -0.11642196f, -0.15978195f, 0.36349180f, 
    -0.15392810f, -0.15537620f, 0.05386109f, 0.03775280f, -0.00897326f, 0.35376972f, -0.16199574f, -0.16879383f, 
    0.03619852f, 0.07569359f, -0.09682770f, 0.13901556f, -0.06070073f, -0.01226242f, 0.06291964f, 0.28627062f, 
    -0.09735256f, 0.18889247f, 0.20330536f, 0.30852592f, -0.02789620f, -0.15937333f, -0.03985430f, 0.06282814f, 
    -0.27749249f, -0.02708295f, 0.24025951f, 0.34597194f, 0.13982446f, -0.13218643f, -0.44451335f, 0.03233464f, 
    -0.06314308f, -0.16598731f, 0.05160249f, -0.13349490f, -0.07014091f, -0.03267504f, -0.02972237f, -0.01376378f, 
    0.01505799f, 0.09599357f, -0.05693972f, -0.10345960f, -0.20559207f, 0.01823041f, -0.13909671f, -0.02180734f, 
    0.14700666f, -0.18574528f, -0.06916949f, -0.11518785f, -0.14947383f, -0.11016202f, -0.04887791f, -0.13714112f, 
    -0.14595804f, -0.10289645f, -0.19523600f, 0.09791847f, -0.02320896f, -0.11335605f, -0.01002638f, -0.17858376f, 
    -0.05083955f, 0.17524008f, -0.01437996f, 0.14442161f, -0.23269804f, -0.15609762f, 0.24066754f, 0.02499108f, 
    0.19801018f, 0.17291752f, -0.13348503f, 0.15187697f, 0.16317254f, 0.40449733f, -0.04128462f, -0.29786938f, 
    -0.08022602f, 0.16089150f, 0.00468728f, 0.17896810f, -0.00738587f, -0.18160850f, 0.20309958f, 0.24915382f, 
    -0.16617851f, 0.13950756f, 0.17183153f, 0.02943049f, 0.00504155f, 0.11630144f, -0.18464060f, 0.30414554f, 
    -0.27063626f, 0.08173378f, 0.00227717f, -0.07808099f, -0.15247054f, -0.00034791f, 0.11517137f, 0.21615973f, 
    0.22772311f, 0.24709332f, -0.11756953f, 0.16295187f, 0.06448305f, -0.16208096f, 0.00164977f, 0.11908823f, 
    -0.07100205f, 0.13316125f, -0.26084977f, 0.04193881f, -0.15254220f, 0.10819770f, -0.47891745f, -0.03483650f, 
    -0.28001490f, -0.09677982f, -0.01677879f, 0.47274628f, -0.04225519f, -0.16157179f, 0.29316053f, -0.00261114f, 
    0.29442436f, -0.07388084f, 0.13565843f, 0.28784034f, -0.17169948f, 0.02859800f, 0.31859338f, 0.07216828f, 
    -0.10623384f, 0.29516116f, -0.17103061f, -0.09773389f, -0.03240886f, -0.00235578f, 0.25956056f, 0.10335571f, 
    0.00664767f, -0.01726140f, -0.19263625f, -0.10438982f, -0.09161672f, 0.07797942f, -0.35680777f, -0.01541582f, 
    0.02807334f, 0.08117142f, 0.23405167f, 0.28695169f, 0.16782460f, -0.13657729f, 0.01727083f, -0.26936138f, 
    -0.19657350f, -0.02955799f, -0.01404219f, 0.07434512f, -0.14248697f, -0.04344662f, -0.05340676f, -0.05236961f, 
    -0.18639408f, -0.15797450f, -0.07512227f, 0.13388228f, -0.02778446f, -0.07317789f, 0.06920989f, -0.05673926f, 
    -0.03333070f, -0.11654187f, 0.09161659f, -0.09795396f, 0.04779750f, -0.03585904f, 0.01888844f, -0.01753631f, 
    -0.16815230f, -0.17522477f, 0.00175787f, -0.12597328f, -0.14704333f, -0.05737080f, 0.06538869f, 0.00952702f, 
    -0.07602816f, -0.02527318f, -0.10344383f, -0.21971582f, 0.03989724f, 0.05926810f, 0.15979725f, -0.04600981f, 
    -0.20938379f, 0.18104932f, 0.17794988f, 0.10514931f, 0.11263989f, -0.12740639f, -0.06812871f, 0.29385626f, 
    -0.01603311f, 0.18324356f, -0.14426793f, 0.02917531f, 0.16318990f, 0.07414421f, -0.05729506f, -0.17931959f, 
    -0.03920971f, 0.14976197f, -0.24414866f, -0.00934070f, 0.07284366f, 0.13035816f, 0.19730155f, 0.10668472f, 
    -0.04349243f, -0.18547069f, -0.13732305f, 0.02155791f, -0.12714130f, 0.35803688f, -0.12349245f, -0.12612966f, 
    0.21165940f, -0.20841925f, -0.27150458f, -0.02795510f, 0.14657506f, 0.29585874f, 0.07493579f, 0.46836784f, 
    0.05873541f, -0.13612033f, 0.10891706f, 0.23038682f, -0.04044356f, 0.10282554f, 0.07688622f, -0.07337460f, 
    0.05811176f, 0.10566382f, 0.08820354f, -0.12838469f, -0.00069973f, -0.09453505f, -0.61157054f, 0.28174216f, 
    -0.15493973f, 0.23242803f, 0.08604405f, -0.09379325f, 0.00454671f, -0.29373085f, 0.33868399f, -0.09496259f, 
    -0.12085156f, -0.18074253f, -0.11986622f, -0.16120410f, 0.13810113f, 0.43962628f, 0.16987689f, 0.17091341f, 
    -0.15005417f, -0.26662850f, 0.09134707f, 0.12296448f, -0.08058597f, -0.12351622f, 0.32576987f, -0.17895834f, 
    0.01523535f, 0.04810435f, -0.05675012f, 0.30152729f, 0.00631280f, 0.08741899f, 0.04354137f, 0.34173813f, 
    0.02109025f, -0.26134381f, -0.07323784f, -0.05928244f, 0.22165239f, -0.18479949f, -0.47658199f, -0.21313347f, 
    0.07686162f, 0.03656119f, -0.35065091f, -0.08974214f, 0.13250659f, 0.00785747f, -0.20028988f, 0.22894761f, 
    0.15035956f, -0.17570281f, 0.21769464f, 0.10992093f, 0.02465797f, -0.12600936f, 0.00636774f, 0.01358678f, 
    0.00618306f, 0.10084457f, 0.08364106f, 0.33347598f, 0.02954626f, 0.06878652f, -0.33754715f, -0.16317484f, 
    0.31324059f, -0.25543135f, -0.08955312f, 0.16169760f, 0.02404010f, 0.15952012f, -0.11161982f, 0.22909784f, 
    -0.19147000f, 0.37884945f, 0.19534907f, 0.04944531f, 0.03656134f, -0.27297649f, -0.01218936f, -0.19099480f, 
    0.08279120f, 0.43127096f, -0.16039954f, -0.17326912f, 0.09468699f, -0.16610938f, -0.29844624f, 0.12382387f, 
    0.07961604f, 0.13997717f, -0.04416734f, 0.15532959f, 0.16832557f, 0.07539017f, 0.25390208f, -0.32144970f, 
    -0.09342913f, -0.20368543f, -0.09845009f, -0.04155478f, 0.00110149f, -0.11156606f, 0.12041086f, -0.12209549f, 
    -0.21566948f, 0.06301180f, 0.05037507f, -0.16725951f, -0.02651572f, -0.01432646f, -0.04713708f, -0.04285408f, 
    0.02653234f, 0.12722462f, 0.02216540f, -0.16234690f, 0.08316437f, 0.11050019f, -0.19153076f, -0.17433739f, 
    0.03030876f, -0.12323274f, 0.12859064f, -0.17495990f, -0.03070990f, 0.06229479f, 0.12137338f, 0.01547494f, 
    0.03625442f, -0.01938984f, -0.04993398f, 0.14648011f, 0.15015532f, -0.00147221f, 0.05121625f, -0.09254368f, 
    0.04434542f, -0.06074691f, 0.00126112f, 0.09066008f, 0.11893425f, 0.03380296f, -0.19897722f, 0.07812991f, 
    0.19361092f, -0.19335932f, 0.25445148f, -0.34646407f, 0.03570446f, 0.17601886f, -0.04641508f, -0.26013845f, 
    -0.13688549f, 0.13598682f, -0.28910455f, 0.26435086f, 0.03459781f, -0.14200126f, 0.16139895f, 0.10190044f, 
    0.21374562f, -0.02226028f, 0.17414567f, -0.26815522f, 0.05214005f, 0.05088163f, 0.15871124f, -0.14569038f, 
    -0.19212770f, -0.04424358f, 0.28460813f, 0.07171360f, 0.12623662f, 0.05646946f, 0.12389515f, 0.31972516f, 
    0.07360403f, -0.04321576f, -0.26446417f, -0.00482325f, -0.01672873f, -0.10894294f, 0.05312036f, 0.09661273f, 
    0.51760334f, -0.06441779f, -0.17845403f, 0.10367040f, -0.12754463f, 0.03879156f, 0.52796596f, -0.38383466f, 
    0.09613343f, -0.30960891f, 0.13714269f, 0.24450946f, 0.13577870f, 0.43739277f, -0.35554028f, -0.12518536f, 
    0.21538207f, 0.08488965f, 0.15512131f, 0.00102597f, -0.09633176f, -0.34661824f, -0.04772327f, 0.00758581f, 
    0.18394895f, 0.30079782f, 0.45641685f, -0.11547042f, 0.15307245f, 0.09617605f, 0.14241691f, -0.09999725f, 
    -0.07759339f, 0.05049137f, -0.17364000f, 0.31158513f, 0.10818221f, -0.01342699f, -0.24969856f, -0.05965447f, 
    0.09896591f, 0.22323890f, -0.13978428f, -0.04786773f, -0.12942323f, 0.05050346f, 0.20707722f, -0.18539584f, 
    0.18325265f, 0.10405165f, -0.16165538f, -0.07627779f, -0.00417862f, -0.48604146f, -0.20648561f, 0.24022610f, 
    -0.11933255f, 0.16098768f, -0.23192878f, 0.12560980f, 0.14465740f, 0.11283188f, 0.15697394f, -0.08891013f, 
    -0.49853104f, -0.17561959f, -0.43209007f, 0.10878747f, -0.08349041f, -0.11549106f, 0.49809614f, 0.32231978f, 
    -0.21239606f, 0.06224399f, 0.06241756f, -0.20788798f, -0.13639757f, -0.18730144f, -0.00257202f, 0.10387895f, 
    -0.07023738f, -0.01881255f, 0.08214467f, 0.15813923f, -0.21026286f, 0.01788490f, -0.05056505f, 0.09518293f, 
    0.02439749f, -0.18028265f, -0.13192277f, 0.04673751f, -0.01323270f, 0.15263920f, 0.11837955f, 0.03711891f, 
    -0.01402834f, -0.02861461f, -0.15718597f, 0.03714076f, 0.08428641f, -0.10220461f, -0.09370134f, -0.12812048f, 
    -0.20805690f, -0.06335633f, -0.05002113f, 0.07989082f, -0.18886298f, -0.03362333f, 0.15571465f, 0.00131995f, 
    -0.14362293f, -0.22486953f, -0.05742859f, -0.12001613f, 0.11501868f, 0.09021930f, -0.16266085f, -0.00494568f, 
    -0.05214011f, -0.07306319f, -0.12839308f, 0.04726920f, 0.00516965f, 0.01855293f, -0.09196734f, 0.06236585f, 
    -0.10383683f, -0.15645656f, -0.18461460f, 0.02266526f, 0.04621872f, -0.05184646f, 0.06837115f, 0.03869441f, 
    0.03194113f, 0.12917462f, -0.04993452f, -0.05037393f, -0.10312699f, -0.08238731f, 0.38360536f, 0.19807817f, 
    -0.06039667f, -0.02248435f, -0.12567513f, 0.12200686f, 0.00750247f, 0.35518393f, 0.04058630f, -0.18173756f, 
    0.01848422f, 0.11402173f, -0.17275241f, 0.00399149f, 0.10330179f, 0.04375821f, 0.11820209f, -0.03103112f, 
    -0.09654750f, 0.13658351f, 0.11958046f, 0.00650974f, 0.13190389f, -0.03201300f, 0.06456260f, 0.36644405f, 
    0.08463874f, 0.18022752f, -0.17607082f, -0.20435777f, -0.03128499f, 0.15583229f, 0.01619244f, -0.04753198f, 
    -0.12433711f, -0.31588602f, -0.12151418f, -0.01233880f, 0.18085107f, -0.14588740f, 0.25910652f, 0.38404968f, 
    0.23855989f, 0.23884280f, -0.11068162f, -0.27685449f, -0.10009590f, -0.13627771f, 0.30947378f, 0.15891112f, 
    0.08180448f, 0.13823585f, -0.30408254f, 0.19806696f, -0.12569430f, -0.14117771f, 0.21984169f, 0.17150621f, 
    0.11170000f, -0.11588816f, 0.06159024f, 0.07143415f, 0.10709435f, 0.06969877f, -0.07564642f, -0.36524019f, 
    0.07959782f, -0.10175297f, -0.24870396f, 0.17549160f, -0.08607253f, 0.31480744f, 0.01141853f, 0.48966861f, 
    0.20189694f, -0.18060492f, 0.08585551f, 0.10721217f, -0.01289827f, 0.09357169f, 0.03243410f, 0.02749838f, 
    0.23531137f, 0.12134568f, 0.10751958f, 0.06476788f, -0.15331607f, 0.08308604f, -0.35705951f, -0.26465729f, 
    0.11689302f, 0.18918277f, 0.18181336f, -0.01744837f, -0.01945599f, 0.06006846f, 0.39944702f, 0.15068573f, 
    0.16472417f, -0.14582989f, 0.24182077f, 0.06152043f, 0.04819905f, 0.19111502f, 0.08641338f, -0.08731741f, 
    0.01717729f, 0.11949091f, -0.12102511f, -0.22027287f, 0.05091633f, -0.00851184f, -0.15869744f, 0.35542753f, 
    0.17539749f, -0.01305344f, -0.15944967f, -0.23766287f, -0.20583770f, -0.16687913f, 0.07196152f, 0.16075303f, 
    0.10845155f, -0.10026685f, -0.02372049f, 0.06961652f, -0.11114448f, 0.04014922f, -0.10252501f, 0.00291225f, 
    0.05235668f, 0.06948407f, -0.22363548f, -0.08842062f, 0.14996746f, 0.16716745f, -0.19882815f, 0.21213357f, 
    0.06038305f, -0.32309699f, 0.10242467f, 0.16189095f, -0.06850579f, -0.10625228f, 0.13967182f, -0.06045748f, 
    -0.14194909f, 0.16006656f, 0.13313776f, 0.31213498f, 0.02153935f, 0.01680020f, 0.09550508f, -0.12578304f, 
    -0.03706393f, 0.01876704f, 0.12468702f, 0.08900133f, -0.15474394f, 0.27411473f, 0.06766411f, 0.40324214f, 
    -0.06699209f, 0.16395764f, 0.30570516f, 0.06552576f, -0.08461962f, 0.09906538f, -0.21583019f, -0.03231073f, 
    0.02563015f, 0.40484428f, -0.14071587f, 0.43179381f, 0.12874465f, -0.02738904f, 0.36689425f, 0.33832541f, 
    0.09351041f, 0.00113180f, -0.01699592f, -0.35006261f, 0.00168843f, -0.13832639f, -0.06522643f, 0.55947405f, 
    -0.17516567f, -0.03253208f, 0.10873933f, 0.06593657f, 0.17024577f, 0.00566424f, 0.07773059f, 0.38775066f, 
    -0.07911105f, 0.17424376f, -0.00384664f, -0.08362385f, -0.25548714f, -0.17878021f, -0.21048053f, -0.44393927f, 
    -0.15241900f, 0.04289701f, -0.05486792f, -0.05370291f, -0.11523250f, 0.06494072f, 0.39011905f, -0.15944378f, 
    -0.18244611f, 0.05070794f, 0.05703836f, 0.04589554f, 0.11134999f, 0.07286251f, 0.25173226f, 0.46996945f, 
    0.16313811f, 0.03920608f, -0.10828151f, -0.35558033f, 0.14375542f, 0.06329790f, -0.08501316f, 0.05995810f, 
    -0.35302565f, -0.09402855f, -0.05425524f, 0.15249622f, -0.12136039f, 0.08514784f, -0.03039753f, 0.49522707f, 
    -0.07197598f, -0.22626980f, 0.00015100f, -0.03292548f, 0.02523070f, -0.09535301f, 0.21043769f, -0.27327806f, 
    -0.02630680f, -0.00338172f, 0.07653993f, 0.11795487f, -0.02064584f, 0.03889189f, 0.10676637f, 0.01275857f, 
    -0.11628748f, -0.09463314f, 0.05084985f, -0.12027578f, 0.08082824f, -0.18445215f, -0.00425519f, 0.01648293f, 
    -0.04271455f, -0.13209258f, -0.07126157f, 0.02986597f, -0.08428097f, -0.19565752f, -0.14223628f, -0.12232895f, 
    -0.12654413f, -0.06591021f, 0.11865467f, -0.02695786f, -0.09428802f, 0.08254570f, -0.08834942f, 0.02367361f, 
    -0.02429911f, -0.11771798f, -0.15220922f, 0.07176742f, -0.11427388f, -0.15924111f, 0.15017398f, -0.09080464f, 
    -0.05521989f, -0.07378348f, 0.03437322f, 0.07747096f, 0.05734802f, 0.32227486f, -0.08842888f, 0.14573772f, 
    0.06838044f, -0.16860905f, -0.28434128f, 0.09835368f, 0.07324652f, 0.04453286f, 0.21731466f, -0.15569958f, 
    -0.16416489f, 0.16629417f, -0.05665234f, 0.16785635f, -0.02738846f, 0.08621354f, 0.06498867f, 0.29337475f, 
    -0.31801099f, 0.09348217f, 0.07062986f, 0.01467117f, -0.16638936f, -0.14974435f, -0.37754622f, 0.37743315f, 
    -0.01083165f, -0.12962630f, -0.08522318f, 0.33964849f, 0.08170867f, -0.54542392f, 0.16688822f, -0.16233046f, 
    -0.16552149f, 0.08314215f, -0.07001492f, 0.08156352f, 0.04149464f, -0.04544526f, -0.42640874f, 0.23811723f, 
    -0.12874620f, 0.01413497f, 0.12892096f, 0.15895821f, 0.07824506f, -0.03271132f, 0.21209079f, -0.66812760f, 
    -0.32131258f, -0.06930202f, -0.24698354f, -0.02734911f, 0.15026855f, 0.12389445f, 0.03510814f, 0.00127053f, 
    -0.03750125f, 0.21024357f, -0.08600176f, -0.45531791f, -0.14151762f, -0.00006233f, 0.08208746f, 0.11630981f, 
    0.31917715f, -0.03111999f, -0.25185069f, -0.06409035f, -0.19069549f, 0.47910783f, -0.00492858f, 0.33941430f, 
    -0.00170804f, -0.01019198f, -0.04592101f, -0.37174711f, -0.14739500f, 0.08742980f, -0.17939247f, 0.23571080f, 
    -0.10305755f, 0.04883913f, -0.06049547f, -0.11536786f, 0.04473851f, -0.03775811f, -0.44939619f, 0.12345517f, 
    -0.11141802f, -0.36685932f, 0.10850744f, 0.16587086f, 0.12454182f, -0.66208482f, 0.00572985f, -0.20034823f, 
    0.00473063f, 0.15477122f, -0.31974182f, -0.03164297f, -0.01641558f, 0.09413130f, -0.50681400f, 0.06806761f, 
    -0.14952581f, -0.11298004f, 0.27313295f, -0.03534897f, 0.14309426f, 0.11267991f, 0.00696529f, -0.44034120f, 
    -0.50638866f, -0.10316954f, 0.14207576f, 0.10351877f, 0.09270292f, 0.14118172f, -0.36072657f, 0.07773654f, 
    0.25113091f, 0.04282064f, 0.15177058f, 0.11073148f, -0.10699283f, -0.23318325f, 0.15087283f, 0.19795981f, 
    -0.06861870f, 0.22732525f, 0.23925155f, -0.02004597f, 0.16905585f, 0.00602244f, -0.02216479f, 0.02128394f, 
    0.02720475f, -0.04807273f, -0.01644161f, 0.36392581f, -0.17291059f, 0.06050783f, 0.06290497f, -0.23555376f, 
    0.31169632f, -0.01411094f, -0.18443096f, -0.12981838f, -0.12151904f, -0.02729240f, -0.05616144f, -0.38767233f, 
    -0.23848513f, 0.26032662f, -0.14167506f, 0.09602427f, -0.04954308f, -0.36274052f, 0.14319195f, -0.01377775f, 
    -0.08408482f, -0.09704342f, -0.01501480f, 0.04277572f, 0.13507882f, 0.13361479f, 0.38886493f, -0.14132145f, 
    -0.07218045f, -0.15759300f, 0.01151018f, 0.13732502f, 0.05965098f, -0.06829348f, 0.02175852f, 0.24710777f, 
    -0.04358334f, -0.14755514f, 0.30231625f, 0.30384740f, -0.07837219f, -0.16948242f, 0.04298698f, 0.13085297f, 
    0.11710034f, -0.09897361f, 0.00475811f, 0.36608702f, 0.16111195f, -0.12519059f, -0.03854726f, -0.15289035f, 
    0.23597270f, 0.14834847f, 0.10603435f, -0.12584400f, 0.00736797f, -0.09499025f, -0.02816199f, 0.07788223f, 
    -0.09648012f, -0.30672544f, 0.12401588f, -0.21224169f, 0.08929107f, -0.03208189f, -0.41403267f, -0.21944486f, 
    0.12547077f, -0.05161884f, 0.05018711f, 0.25947317f, -0.10711160f, 0.14011878f, 0.19038199f, -0.49435541f, 
    0.28572235f, 0.16119029f, 0.10573342f, -0.08509998f, -0.04621077f, 0.07666243f, 0.10469869f, -0.22239229f, 
    -0.23654459f, 0.13792796f, 0.16597109f, -0.12359511f, 0.13873164f, 0.10796131f, -0.09848437f, -0.12517487f, 
    -0.16471817f, 0.11330193f, -0.05045417f, 0.08195306f, -0.10721595f, 0.07302823f, 0.15240899f, 0.16550638f, 
    0.07567137f, 0.12383112f, -0.05601168f, -0.11761223f, -0.07985888f, 0.15961082f, 0.23158084f, -0.07367969f, 
    0.08938701f, 0.01495736f, -0.04040833f, -0.21544850f, -0.15572971f, 0.23090923f, -0.05804049f, 0.00601949f, 
    -0.08385479f, -0.10221179f, 0.14739855f, -0.13154738f, 0.19309568f, 0.30767134f, -0.17200056f, 0.43337038f, 
    0.07105610f, 0.23199774f, -0.17434482f, 0.02033977f, 0.11145601f, 0.13808183f, 0.05461715f, -0.08011534f, 
    -0.03878963f, 0.06699823f, -0.19269782f, 0.24737947f, 0.07761081f, 0.16853686f, -0.07868223f, -0.24058874f, 
    -0.00359626f, -0.28829429f, -0.10736278f, -0.00440761f, 0.22129562f, -0.12594499f, -0.29674822f, -0.00656571f, 
    0.05707348f, 0.15495504f, 0.28027773f, 0.03918495f, -0.17956746f, -0.38743955f, -0.07702886f, -0.11539172f, 
    0.00358969f, 0.05783684f, 0.05023192f, -0.28315040f, -0.11485003f, 0.07291969f, 0.33181360f, -0.08218522f, 
    0.10575864f, -0.03366466f, -0.22130761f, 0.20346901f, 0.13910042f, -0.12350574f, 0.16108286f, 0.27648535f, 
    0.16426145f, -0.07892670f, 0.11223591f, 0.03562304f, -0.07122599f, 0.14077303f, -0.01743714f, -0.12479061f, 
    -0.21352319f, 0.11628614f, -0.24284767f, -0.13511236f, 0.08689797f, 0.19170998f, 0.06813535f, 0.56496841f, 
    -0.09905946f, 0.08512542f, 0.14330000f, 0.07763154f, 0.04888193f, -0.04538419f, -0.24433620f, 0.16381201f, 
    -0.09646571f, -0.18046504f, 0.00033573f, 0.32662275f, -0.09307024f, 0.17471454f, -0.08510973f, -0.48867598f, 
    -0.01228504f, -0.03647497f, 0.10667685f, 0.07998674f, 0.09678816f, 0.23095360f, -0.07666371f, -0.21421444f, 
    0.24432111f, -0.27609512f, 0.31842169f, 0.01577341f, 0.12048784f, 0.17060246f, -0.22128153f, -0.18358250f, 
    0.23374587f, -0.07544997f, 0.06491302f, -0.31550413f, 0.10024013f, -0.14494145f, 0.21063775f, 0.26368570f, 
    0.05312758f, 0.09382188f, -0.26454580f, -0.07542384f, 0.03455254f, -0.13548324f, -0.11801489f, 0.41408271f, 
    -0.01631166f, -0.35289448f, 0.07262502f, 0.47218102f, 0.16426508f, -0.19936582f, -0.02605385f, -0.12835880f, 
    0.28276131f, -0.05580085f, 0.37954426f, -0.10521828f, -0.17474826f, 0.07243832f, -0.17283115f, -0.51234156f, 
    -0.02540397f, 0.06900351f, 0.20637499f, 0.11927389f, 0.14368804f, -0.14383128f, 0.23955736f, 0.03496637f, 
    -0.23424572f, -0.11637543f, -0.17739198f, -0.13832888f, 0.10956646f, 0.12144699f, -0.02845206f, 0.64220977f, 
    0.03058191f, -0.15464789f, -0.11542347f, -0.36186740f, -0.06909285f, -0.02962426f, 0.16922908f, 0.16772509f, 
    -0.08954539f, -0.10021186f, -0.06886588f, -0.14211072f, -0.10703602f, 0.32606694f, 0.21724787f, 0.18478028f, 
    0.00606692f, 0.06537793f, -0.19092685f, 0.21656899f, 0.01561418f, -0.15142520f, 0.02179966f, 0.30465472f, 
    0.33403021f, 0.07261216f, 0.16207418f, -0.25525275f, -0.09008022f, -0.07597513f, 0.01204508f, 0.02912382f, 
    -0.02465574f, -0.08466982f, -0.11597637f, -0.17510882f, -0.15357663f, -0.23778740f, 0.14845638f, 0.10066209f, 
    -0.03696835f, 0.09467125f, -0.07013961f, 0.08352321f, -0.14658821f, 0.38383391f, -0.11769765f, 0.45018345f, 
    0.02818242f, -0.29218405f, 0.06101706f, -0.14084546f, 0.05926981f, 0.17300621f, 0.13226643f, -0.11750715f, 
    0.28998271f, -0.05789910f, -0.05895339f, 0.06071692f, -0.08503637f, 0.16789079f, -0.00984773f, 0.04605194f, 
    0.27737361f, -0.16311371f, 0.06714178f, 0.46196440f, -0.06759640f, 0.13708125f, 0.07580090f, 0.19894145f, 
    -0.05893936f, 0.01570175f, -0.06983475f, 0.14213316f, 0.06820019f, 0.23809671f, 0.09155848f, -0.23295900f, 
    -0.16318400f, 0.36678344f, 0.23211606f, 0.28511754f, 0.11933959f, -0.04015963f, -0.19537783f, 0.24151531f, 
    -0.36467537f, -0.11323857f, 0.10958392f, 0.11368466f, 0.09454452f, -0.04992668f, -0.26181179f, 0.17149013f, 
    0.07288782f, -0.20597339f, -0.11421480f, -0.11380430f, 0.03281127f, 0.21000366f, -0.21691640f, 0.14728372f, 
    0.01446460f, 0.18867292f, 0.07184026f, -0.18519135f, -0.01942848f, -0.18341349f, -0.06474005f, 0.18038444f, 
    0.19774322f, 0.29842335f, 0.16329196f, -0.11038277f, 0.13210292f, 0.12040838f, 0.00448356f, 0.13008469f, 
    -0.22617650f, 0.03115636f, -0.08536846f, -0.17501697f, 0.09632945f, 0.03464566f, 0.05722574f, -0.32398072f, 
    0.17917995f, -0.05938113f, 0.04662276f, 0.18221688f, -0.07010815f, -0.13665420f, 0.08550841f, 0.04620827f, 
    -0.18432897f, -0.02684825f, 0.20814966f, -0.06723783f, -0.08976897f, -0.16185473f, -0.23882115f, 0.40778780f, 
    0.20558296f, -0.38631147f, 0.00120208f, -0.08409383f, 0.09559978f, -0.08855595f, 0.42924255f, -0.38064444f, 
    -0.32219103f, 0.10192727f, -0.14462538f, 0.00859191f, 0.04121498f, -0.05213285f, -0.18603899f, 0.06173055f, 
    -0.18224253f, -0.09584824f, -0.07120048f, 0.11719503f, 0.12536199f, -0.42861590f, 0.08750010f, -0.08752525f, 
    0.04822863f, -0.01099809f, 0.22562693f, -0.17498650f, -0.13906290f, 0.21188876f, 0.15303461f, -0.20907764f, 
    0.08481871f, -0.23345038f, 0.13278127f, 0.33945739f, -0.09166086f, -0.03691998f, -0.00671627f, -0.08360548f, 
    0.29621390f, -0.16843650f, -0.07827018f, -0.13656017f, 0.01687082f, -0.00892370f, 0.33418387f, 0.16077992f, 
    -0.26034817f, -0.09302722f, -0.14928420f, 0.17074850f, 0.10290150f, -0.00306495f, -0.00815117f, 0.16787539f, 
    0.33283398f, -0.08680240f, -0.07479256f, -0.02318181f, -0.24033213f, 0.27222520f, -0.25420773f, 0.18400867f, 
    -0.08676105f, -0.12313677f, 0.16943608f, 0.32411769f, 0.03704926f, 0.17244121f, 0.09737612f, -0.16436045f, 
    -0.30985555f, -0.03924612f, -0.06901815f, 0.13597971f, 0.00947703f, 0.06201782f, -0.22412361f, 0.34796044f, 
    -0.07474374f, -0.12803723f, -0.16902517f, -0.16234098f, 0.08657053f, -0.17754912f, -0.02429783f, 0.02386399f, 
    0.09717737f, 0.13980821f, 0.03506255f, -0.12590547f, -0.25145069f, -0.06595428f, 0.04757556f, 0.13889496f, 
    0.19973487f, -0.22958332f, 0.06834684f, -0.26858416f, 0.15132375f, 0.07915732f, 0.07193580f, -0.24136658f, 
    -0.09915759f, -0.08157028f, 0.02230043f, 0.04720909f, 0.13432877f, 0.06387722f, 0.27295941f, -0.10440831f, 
    -0.07240316f, -0.14138937f, -0.16056116f, -0.27777559f, 0.15809266f, 0.18331477f, 0.06297649f, 0.24045737f, 
    0.13984147f, -0.06453549f, 0.32419467f, 0.02376252f, 0.00076962f, -0.42523402f, -0.07972586f, 0.10249929f, 
    0.24300461f, 0.39160764f, -0.07314035f, -0.41579863f, 0.10600353f, 0.13599643f, 0.35605779f, -0.05686841f, 
    0.18794698f, -0.13858396f, -0.33318090f, -0.25356126f, -0.09563266f, -0.06704962f, 0.22508787f, -0.01824833f, 
    -0.07329669f, -0.35713294f, -0.07868426f, -0.00341241f, 0.24976520f, -0.25698426f, -0.09282634f, 0.06079005f, 
    0.21305221f, -0.00907963f, -0.02497325f, 0.08299832f, -0.41182259f, -0.28256726f, 0.04271195f, 0.19575381f, 
    -0.08830489f, -0.17307886f, 0.13194728f, 0.16873823f, -0.02384087f, 0.02750924f, 0.03872747f, -0.10148883f, 
    -0.07392836f, -0.06971984f, 0.13567492f, 0.44588861f, 0.06819820f, 0.15159586f, 0.42238903f, -0.28893518f, 
    -0.24654004f, 0.14079937f, -0.15969916f, 0.04739018f, -0.12770741f, 0.09145210f, -0.13674094f, -0.05451598f, 
    0.07305498f, -0.29600298f, -0.12954998f, 0.11503546f, 0.10788579f, 0.03906411f, -0.00228686f, 0.01264249f, 
    0.14089160f, 0.00942722f, 0.00864528f, 0.00655692f, 0.03712194f, -0.02239341f, -0.03973565f, -0.19654147f, 
    0.02413576f, -0.05891681f, 0.01465143f, -0.17534517f, -0.18448116f, 0.12883176f, -0.18807347f, -0.27207834f, 
    0.19249509f, -0.12734649f, 0.16930653f, 0.34863430f, -0.10440386f, 0.01860784f, 0.04983427f, 0.43008596f, 
    0.04330557f, 0.46557191f, -0.12392158f, -0.04938619f, 0.05152044f, -0.18821909f, -0.11884809f, -0.20804727f, 
    -0.33251983f, 0.29023996f, -0.22591771f, 0.01884935f, 0.14226481f, -0.07922886f, -0.13017461f, 0.05018410f, 
    0.19646907f, 0.04405933f, 0.13477311f, 0.11360104f, -0.12793171f, -0.04930732f, 0.20324689f, -0.12654001f, 
    0.05472872f, 0.01395463f, 0.05831199f, -0.12297612f, -0.12338351f, 0.48256123f, -0.06853773f, -0.04003374f, 
    -0.11471109f, -0.14483862f, 0.11502151f, -0.02401135f, 0.06554566f, 0.21200624f, 0.18144977f, 0.30938092f, 
    0.03040611f, 0.33246148f, 0.07859635f, -0.48521003f, -0.04814138f, -0.13947505f, -0.15446272f, 0.28379020f, 
    -0.13074327f, -0.03605183f, -0.00929542f, 0.20450939f, -0.16140541f, 0.00781671f, -0.34776419f, -0.33275354f, 
    0.22818951f, -0.30829623f, 0.14784819f, 0.22065811f, 0.16991696f, -0.17957908f, -0.28043187f, -0.34529710f, 
    0.19731507f, 0.14745843f, 0.03047550f, -0.14111304f, 0.30220449f, -0.22769102f, -0.54652894f, 0.22914661f, 
    -0.12238089f, 0.10142713f, 0.30426407f, 0.37115335f, 0.00667580f, 0.03714427f, 0.08647481f, -0.14394096f, 
    0.08923528f, -0.01202627f, -0.24004251f, 0.13477156f, 0.15525527f, 0.03543340f, -0.22794354f, 0.26170957f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02131315f, -0.06058621f, -0.14233819f, -0.03366258f, 0.00188592f, 0.21788403f, 0.18031830f, -0.20909764f, 
    0.07966887f, 0.20142308f, 0.12793536f, 0.17181370f, 0.14436609f, -0.06196767f, 0.15466836f, -0.06569538f, 
    -0.21080898f, 0.20282729f, 0.08147314f, 0.25931573f, 0.16496421f, -0.04325450f, 0.01892091f, -0.11795467f, 
    0.01667914f, -0.11620820f, 0.09672416f, -0.03734302f, 0.03219624f, 0.03396260f, 0.21557605f, -0.16419576f, 
    0.28909159f, 0.11783557f, 0.01988015f, -0.02954092f, 0.08696805f, 0.21698149f, 0.00488930f, 0.16948859f, 
    0.11784559f, -0.07974317f, 0.14062586f, -0.02599795f, -0.09328767f, 0.20313661f, 0.34349903f, -0.00248064f, 
    0.17000428f, -0.21225549f, 0.31256199f, -0.02716071f, -0.12018333f, -0.12400542f, -0.21645726f, -0.05127290f, 
    -0.03300169f, 0.25898346f, -0.12060683f, -0.06358838f, -0.16866961f, -0.24421836f, 0.07437965f, -0.13630921f, 
    0.05344157f, -0.00875333f, 0.25294402f, -0.11346494f, 0.13686311f, 0.27440587f, 0.05167196f, -0.11333617f, 
    -0.02035452f, -0.18907274f, -0.05985241f, -0.03583093f, -0.18050724f, 0.32662147f, -0.04384831f, -0.12987170f, 
    -0.09519028f, 0.15075889f, -0.08928711f, 0.27208161f, 0.06659444f, -0.14476626f, 0.13861713f, 0.11228187f, 
    0.22425793f, 0.17591453f, -0.06139927f, 0.02487999f, 0.01785338f, 0.03275471f, -0.02773413f, -0.04331991f, 
    0.08233310f, -0.12088168f, 0.05815221f, 0.01002801f, -0.18279888f, 0.04979617f, 0.12575030f, 0.04942584f, 
    -0.20302702f, 0.20188999f, -0.00828641f, 0.15370835f, 0.03593336f, 0.18292880f, 0.27107829f, 0.20052432f, 
    -0.12672508f, 0.01843778f, 0.04160923f, 0.08123841f, 0.14739656f, -0.13174595f, 0.10677475f, -0.17543033f, 
    -0.07169481f, 0.13076478f, 0.03326812f, 0.26393172f, 0.12530015f, -0.00185775f, 0.03096610f, -0.00778285f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.41416976f, 0.18411180f, -0.00237536f, 0.06267592f, -0.19298530f, -0.15981336f, -0.30879450f, -0.18365198f, 
    -0.00093120f, 0.11415788f, 0.00856416f, -0.59159428f, -0.20319918f, -0.06117238f, -0.00841771f, -0.10814467f, 
    0.04617223f, 0.06214977f, -0.54429752f, -0.65025622f, -0.04732728f, -0.02574446f, -0.24156177f, 0.01101694f, 
    -0.04831228f, 0.12814167f, 0.00355074f, -0.09175546f, 0.11951919f, -0.28403944f, -0.02694943f, 0.06067172f, 
    -0.26628783f, 0.02516193f, -0.07171506f, -0.35214582f, 0.04618881f, 0.13280317f, 0.22279994f, 0.14255567f, 
    0.01136866f, -0.14557408f, -0.09346885f, 0.13597663f, -0.10005973f, -0.04250329f, -0.55677158f, 0.05918482f, 
    -0.03397491f, 0.10872874f, -0.28071031f, 0.00002426f, 0.12188659f, -0.07015266f, 0.02601497f, 0.11999163f, 
    0.11404924f, 0.01898396f, -0.02179938f, -0.08655338f, 0.09249324f, -0.09320375f, 0.05246849f, 0.00584420f, 
    -0.17919816f, -0.38796493f, -0.16566558f, 0.17235124f, 0.08712928f, -0.09622806f, -0.06786640f, -0.06159639f, 
    0.03624157f, -0.00912011f, -0.11042524f, -0.06908912f, 0.16611953f, -0.32982013f, -0.07955265f, 0.01467815f, 
    -0.12164207f, 0.11164432f, 0.08882702f, 0.08119056f, -0.27077633f, -0.04056288f, -0.07364201f, 0.00026524f, 
    -0.40446264f, -0.18575625f, -0.06312902f, 0.02648885f, 0.11939355f, 0.00216711f, 0.12047144f, 0.11908230f, 
    -0.14533804f, 0.11713272f, -0.14927213f, -0.15808153f, 0.06191948f, 0.04796454f, -0.11149066f, 0.41980088f, 
    0.03724419f, -0.36327276f, 0.10675970f, -0.24104808f, 0.04924263f, -0.51680887f, -0.33929351f, -0.15625916f, 
    0.12520181f, 0.18411677f, 0.14478026f, 0.10418472f, 0.11533137f, -0.03113578f, -0.34341002f, 0.05345855f, 
    -0.00908191f, -0.13969895f, -0.09408987f, -0.51924789f, 0.11422921f, -0.24491188f, 0.01659812f, 0.05608552f, 
    -0.02015702f, -0.83617699f, -0.14200567f, 0.08473693f, -0.11955042f, -0.14803335f, -0.35021725f, 0.07238611f, 
    0.05086666f, 0.20493996f, -0.17861843f, 0.11964724f, -0.24618679f, -0.02129100f, 0.45184255f, -0.25291365f, 
    -0.00307457f, 0.07275805f, -0.08966143f, -0.26528212f, -0.01361145f, 0.03533038f, -0.09139813f, -0.05194441f, 
    -0.13041832f, -0.00493430f, 0.17325197f, 0.03173350f, 0.13803542f, 0.07325374f, 0.01870673f, 0.01960887f, 
    0.02035116f, 0.01300624f, 0.19830427f, 0.13587397f, -0.01886594f, 0.25066254f, 0.18459736f, -0.40441296f, 
    0.04265473f, -0.10532961f, 0.34237951f, -0.09574399f, -0.21060386f, 0.00152906f, -0.31233272f, 0.17346564f, 
    0.02274830f, -0.20942019f, -0.05922130f, 0.12289152f, 0.14868292f, 0.01155892f, -0.13385591f, 0.16449049f, 
    0.16704331f, 0.03585214f, 0.13756256f, -0.09081445f, -0.08166203f, -0.16702496f, 0.08197080f, 0.18120028f, 
    -0.24138050f, -0.09898073f, -0.39062312f, -0.01815656f, -0.33469528f, 0.27213886f, 0.08470221f, 0.04531484f, 
    0.00111922f, -0.23012754f, 0.00033361f, 0.05387721f, 0.05553443f, 0.11720040f, 0.12055279f, 0.00412933f, 
    0.07750053f, 0.06084441f, 0.08426618f, -0.09549634f, -0.23787545f, -0.05703739f, 0.03326863f, 0.05828016f, 
    -0.22632641f, 0.56452906f, 0.01107247f, -0.00274853f, 0.05096605f, 0.00383337f, 0.10123751f, -0.00970029f, 
    0.07439747f, -0.12915166f, -0.36876896f, -0.05162352f, -0.04046803f, -0.00949858f, 0.11578078f, 0.37585148f, 
    -0.19021955f, 0.10923178f, 0.00323030f, 0.04999907f, 0.07628018f, 0.21116169f, -0.48339647f, 0.09729297f, 
    -0.04630343f, -0.40832072f, 0.05750884f, 0.10236887f, 0.06481792f, -0.11548538f, 0.03609891f, 0.01367814f, 
    0.19453089f, 0.00214754f, -0.36059788f, -0.05625292f, -0.03826657f, -0.13261047f, 0.21216288f, 0.12408266f, 
    0.07511299f, -0.22007874f, 0.15259390f, -0.13040103f, 0.11715555f, 0.37015393f, 0.18192650f, -0.43667030f, 
    -0.22358918f, 0.23084237f, 0.05323988f, -0.27841780f, -0.06519880f, 0.30321461f, -0.45388028f, 0.12597661f, 
    0.00659534f, 0.01602123f, 0.04186741f, 0.24340223f, -0.05322100f, -0.04017024f, -0.12685372f, 0.04823810f, 
    -0.12184013f, -0.39632425f, 0.07722284f, 0.02228528f, 0.20609707f, 0.13499607f, 0.12090990f, -0.63063604f, 
    0.03944718f, 0.05354448f, 0.17367226f, 0.04258351f, -0.10346869f, -0.00879366f, -0.71366942f, -0.10657280f, 
    0.00192472f, -0.00919412f, -0.22162586f, 0.12968586f, 0.00011610f, -0.08788925f, 0.08700257f, 0.03432440f, 
    0.12224010f, 0.10793136f, 0.13405755f, 0.05536014f, -0.59224021f, -0.12277827f, -0.11621069f, 0.06204974f, 
    -0.25561950f, 0.24237138f, -0.02439721f, -0.09680614f, -0.06533606f, -0.06571204f, -0.23073350f, -0.55335969f, 
    -0.08508629f, 0.03679030f, 0.03442862f, 0.08029307f, -0.01531768f, 0.10082320f, 0.12840968f, -0.15854385f, 
    -0.02271378f, 0.06678150f, 0.10811906f, 0.05231169f, -0.03878753f, 0.38281626f, 0.16753297f, -0.06025164f, 
    -0.24982372f, -0.10376157f, -0.10002729f, 0.14623019f, 0.12927973f, -0.07688876f, 0.09427685f, 0.03794996f, 
    0.12081827f, -0.06128339f, -0.02618951f, -0.01649770f, -0.06301976f, 0.11633525f, 0.02280088f, -0.25557521f, 
    0.05284543f, -0.82104832f, -0.11746307f, -0.12237947f, -0.02944908f, -0.06309772f, -0.36769050f, -0.54455215f, 
    -0.41523814f, -0.01308402f, 0.15761442f, 0.26400745f, -0.07017420f, -0.25782180f, 0.20396911f, 0.04360548f, 
    0.04751957f, -0.00752589f, -0.29753780f, -0.12362944f, -0.18035555f, -0.00899494f, -0.37044466f, -0.06651799f, 
    -0.00819197f, 0.08254988f, -0.09896072f, 0.17967148f, 0.09874767f, -0.13337865f, -0.00845934f, -0.00398419f, 
    -0.22537766f, 0.19484365f, -0.48833272f, -0.29018763f, 0.09282108f, 0.14905940f, 0.20928939f, -0.24517822f, 
    0.11223606f, 0.02965106f, 0.15401979f, -0.09870411f, -0.20798352f, -0.03406359f, -0.23253429f, 0.33322951f, 
    -0.08227982f, -0.02360543f, -0.03625001f, 0.05946039f, -0.00887413f, 0.02486720f, 0.02292477f, -0.07681308f, 
    0.14981741f, 0.16311826f, 0.10864399f, 0.13820274f, -0.05356335f, -0.06159106f, 0.05709185f, -0.06556245f, 
    -0.06541173f, 0.01626062f, 0.06879657f, 0.09570964f, -0.01720017f, -0.40724391f, 0.09615478f, 0.18929766f, 
    -0.01119975f, -0.05016501f, -0.15027821f, 0.03515035f, 0.29709467f, -0.46246445f, 0.12272830f, 0.00953306f, 
    -0.03351337f, 0.22493124f, -0.04799923f, -0.10513636f, 0.00964652f, 0.02729843f, 0.13233215f, -0.09167648f, 
    -0.10747559f, 0.02522574f, -0.02506476f, -0.32086056f, 0.13717149f, 0.05327766f, -0.16381940f, -0.35775971f, 
    -0.11001027f, -0.02095894f, 0.17029093f, 0.51446521f, -0.00361904f, -0.02460451f, -0.21658403f, 0.02183206f, 
    -0.01019239f, 0.27186728f, -0.27517134f, -0.02169793f, -0.10559054f, -0.09442227f, -0.50213695f, -0.07061419f, 
    -0.15248927f, -0.19802527f, -0.21251221f, -0.23004459f, -0.02403465f, -0.07093959f, 0.10159284f, -0.04590744f, 
    0.09688353f, -0.13463038f, -0.04696130f, 0.06727601f, -0.01711293f, -0.01389325f, -0.42108476f, 0.02382574f, 
    -0.12769362f, 0.10030451f, 0.28475368f, -0.33235896f, -0.06964583f, -0.04570236f, -0.45329306f, -0.25032032f, 
    -0.11904633f, -0.54957116f, -0.28014135f, -0.09443311f, -0.19750348f, -0.40531683f, 0.22830839f, -0.54738861f, 
    0.17123467f, 0.30698550f, -0.10398532f, -0.22720921f, -0.22740154f, 0.12345321f, -0.66349727f, 0.11817623f, 
    0.09980191f, 0.14277302f, 0.31086272f, 0.03493709f, -0.05785207f, -0.22278479f, -0.16576815f, -0.48198062f, 
    0.09174404f, 0.20216063f, 0.06033690f, 0.03256175f, -0.13448589f, 0.16840459f, -0.07810486f, 0.30099663f, 
    -0.28243050f, -0.17783140f, 0.13831416f, -0.69090194f, -0.11252224f, -0.07602578f, -0.12770231f, -0.20939739f, 
    0.11453620f, -0.05981440f, -0.33254492f, -0.10784904f, -0.05063609f, -0.04685153f, 0.02404832f, -0.00852551f, 
    0.13122754f, -0.03617096f, -0.14662868f, -0.26127404f, 0.00371145f, -0.08859166f, 0.11414804f, 0.08826329f, 
    -0.07018849f, 0.07657611f, -0.00567085f, 0.01385736f, -0.02298265f, -0.15911955f, 0.12259562f, 0.05451028f, 
    0.08506498f, -0.00733276f, -0.41076070f, 0.12585562f, 0.04361649f, -0.07253343f, 0.15512004f, -0.13737454f, 
    -0.07942849f, 0.07767044f, -0.23661992f, 0.14244951f, -0.08981708f, -0.08659265f, 0.14102250f, 0.14875443f, 
    0.03643750f, 0.12731411f, -0.20644650f, 0.16751492f, 0.01180121f, 0.09236097f, 0.00278794f, -0.18315242f, 
    0.10803729f, 0.01547570f, -0.44035083f, -0.09989068f, -0.05364186f, -0.20419472f, 0.05945980f, -0.06032679f, 
    0.06392271f, 0.07071698f, -0.01385849f, -0.00795349f, -0.02726925f, -0.19379514f, 0.08805180f, -0.00423244f, 
    -0.17214642f, -0.01910224f, -0.20544134f, -0.15518142f, 0.31509185f, -0.07913271f, -0.09315649f, 0.13314870f, 
    -0.01857142f, -0.37445036f, -0.01847521f, -0.04485353f, -0.00153913f, 0.14249989f, 0.03620694f, 0.06388832f, 
    -0.16520822f, 0.09156811f, -0.16887553f, -0.10656536f, -0.04037265f, 0.03271427f, 0.07780232f, -0.43103418f, 
    0.01517502f, 0.09487514f, -0.06805618f, -0.19236967f, 0.18891858f, -0.06065536f, -0.17308655f, -0.00382354f, 
    0.07621533f, -0.17336075f, 0.10732626f, -0.33005261f, 0.11212632f, 0.12621000f, 0.00523674f, -0.06820750f, 
    -0.53926778f, -0.12932761f, 0.15533850f, -0.27195004f, -0.14001514f, -0.08603042f, 0.22728540f, -0.27984717f, 
    0.30027914f, -0.09666131f, 0.07119942f, 0.10739852f, 0.21114480f, -0.24739097f, 0.18044013f, -0.39154121f, 
    -0.16903959f, -0.08607033f, -0.00518902f, 0.25730079f, -0.21935135f, -0.02497275f, 0.08163851f, -0.34205052f, 
    -0.14232096f, 0.08644240f, -0.00324955f, 0.13493496f, 0.02390678f, -0.03882044f, -0.24726102f, -0.00122472f, 
    0.07314788f, 0.08972966f, 0.11603605f, 0.14529757f, -0.19735061f, 0.09724052f, 0.02696667f, 0.21870087f, 
    0.16240174f, 0.00319549f, 0.23044224f, -0.33435819f, -0.00440370f, 0.21075778f, -0.08065935f, -0.26591873f, 
    0.05457848f, 0.08399680f, -0.44291079f, 0.00551158f, -0.17786650f, 0.05226246f, -0.00040837f, 0.04382411f, 
    -0.07405257f, -0.07596274f, -0.20829880f, -0.00431775f, 0.06670810f, -0.04302696f, -0.00046322f, 0.05506427f, 
    0.15403092f, -0.03590174f, -0.12508380f, 0.22329322f, -0.09732646f, -0.05346378f, 0.21814859f, 0.07057495f, 
    0.06394865f, 0.02595073f, -0.05438024f, -0.08803441f, 0.23744854f, -0.21344860f, -0.09990387f, -0.09832047f, 
    -0.06265726f, -0.10821570f, -0.29464799f, -0.07423435f, -0.00903164f, 0.14752232f, 0.13730444f, 0.02751350f, 
    -0.17933889f, -0.45778105f, 0.05696262f, -0.14474121f, 0.13442625f, -0.00096057f, -0.09829386f, 0.17259677f, 
    -0.38868985f, -0.58289468f, 0.06123114f, -0.03520313f, 0.07350589f, -0.04566626f, -0.21522009f, 0.00190014f, 
    -0.02330295f, 0.04760403f, 0.21141537f, 0.10548383f, 0.05607666f, -0.26670152f, -0.07860608f, -0.38703904f, 
    -0.12737614f, 0.16581222f, 0.09653547f, -0.09097352f, 0.09698901f, -0.43643326f, -0.01050343f, -0.10832841f, 
    -0.24737620f, -0.38860577f, 0.13560827f, 0.10612042f, -0.24591893f, -0.04394397f, 0.02725427f, 0.14872281f, 
    -0.30557144f, 0.11835865f, -0.05369342f, 0.05232266f, -0.02385858f, 0.20820008f, -0.28875715f, -0.45381936f, 
    -0.20549661f, -0.26354739f, -0.11135774f, -0.05449296f, 0.18129268f, 0.14124444f, -0.28098395f, -0.48408574f, 
    0.07203374f, 0.17803812f, 0.05242451f, -0.07798941f, 0.09511781f, 0.05078158f, -0.45577705f, 0.10205276f, 
    -0.29265055f, -0.34915534f, 0.13578960f, 0.30995011f, -0.07890138f, 0.06002887f, -0.09134260f, 0.00108561f, 
    0.05342406f, -0.72227269f, -0.65706617f, -0.04327342f, 0.01587705f, 0.26730362f, 0.02932626f, -0.63829827f, 
    -0.58056957f, 0.01822931f, -0.51517230f, -0.39188972f, -0.00010759f, 0.20398453f, -0.50191146f, -0.05848823f, 
    -0.83663446f, -0.06902880f, 0.19770941f, -0.59812206f, 0.10555918f, -0.09964719f, -0.15803353f, 0.23081760f, 
    0.19149105f, -0.06910754f, 0.24819623f, -0.38264668f, -0.72465730f, -0.08584981f, -0.10123838f, -0.64351416f, 
    -0.33540767f, -0.58484519f, 0.02997045f, 0.07366797f, -0.27071363f, -0.42719248f, -0.14150612f, -0.06820396f, 
    0.16202956f, 0.04113379f, 0.14409010f, -0.08409964f, 0.19658734f, -0.28336331f, -0.12305865f, 0.06037160f, 
    -0.04160362f, 0.02144548f, 0.13328663f, 0.02210022f, -0.09214750f, -0.47503531f, 0.12390250f, 0.06448789f, 
    -0.05392837f, 0.03013775f, 0.14351644f, 0.27222919f, -0.20648384f, -0.02502316f, 0.20107059f, -0.07410712f, 
    0.14629272f, -0.18126354f, -0.09083273f, -0.00981381f, -0.18376380f, -0.12514642f, 0.18404260f, -0.39300886f, 
    0.13422076f, -0.63884270f, 0.03896295f, 0.13730435f, -0.02673622f, -0.22717766f, 0.16931821f, -0.28707093f, 
    0.46412328f, -0.24805169f, -0.01370254f, 0.18255220f, -0.09526844f, -0.07048848f, 0.07046234f, 0.18347377f, 
    -0.11744595f, -0.01376839f, -0.45114890f, 0.20341703f, -0.13293052f, 0.04297769f, 0.17631270f, 0.03879720f, 
    0.10211914f, 0.20731771f, -0.27245858f, 0.30253318f, -0.16897848f, -0.57500827f, -0.13038163f, 0.10139789f, 
    -0.06520939f, 0.49903917f, 0.09461623f, 0.03603149f, -0.00792355f, 0.19368109f, 0.11040598f, -0.00443028f, 
    -0.04826537f, -0.12510820f, -0.08432519f, -0.08652857f, 0.02405314f, 0.04332578f, -0.05061157f, 0.10352388f, 
    -0.00653137f, -0.35291666f, -0.20625490f, -0.52028751f, -0.03175759f, -0.00296241f, -0.35956699f, -0.04187809f, 
    -0.05492474f, -0.18003529f, -0.29563653f, 0.11848085f, 0.02547171f, -0.26491815f, -0.67402464f, 0.30758789f, 
    -0.35465044f, -0.09755176f, -0.36087540f, 0.25711256f, -0.02053340f, -0.38461623f, -0.50752872f, 0.17634676f, 
    -0.48507732f, -0.16147672f, -0.32219481f, -0.62517703f, 0.01628584f, 0.06166991f, -0.40258518f, -0.44561440f, 
    -0.00889420f, 0.09036493f, -0.12650806f, 0.01073753f, 0.10068222f, 0.01620907f, 0.08085715f, -0.22502810f, 
    0.06390417f, -0.49566841f, -0.21785031f, -0.03246077f, 0.11618193f, 0.03859899f, 0.07890901f, 0.00240694f, 
    -0.33776477f, -0.02635663f, 0.06262171f, 0.04738055f, 0.03537503f, 0.08628795f, -0.14798631f, 0.14758450f, 
    0.03437358f, 0.07026852f, -0.08574075f, -0.04712347f, 0.21804042f, -0.27355540f, -0.22264571f, 0.04633904f, 
    -0.06369600f, 0.00159579f, 0.19404733f, -0.17125084f, -0.30088800f, 0.04034444f, 0.05783371f, -0.11963909f, 
    -0.04606383f, 0.31686676f, 0.02156050f, -0.07860780f, 0.20522858f, 0.11530068f, -0.16666132f, -0.11809234f, 
    0.07287166f, 0.37615380f, 0.29557127f, -0.07930697f, -0.03991812f, 0.10517910f, -0.02113186f, -0.25854936f, 
    -0.15000328f, -0.17199299f, 0.09991843f, -0.65745026f, 0.05829743f, 0.00561238f, 0.16386612f, -0.19450609f, 
    0.21091314f, 0.52262855f, -0.40278688f, -0.00849874f, 0.01556393f, -0.22215651f, 0.12672524f, -0.03540926f, 
    0.20134152f, -0.25831750f, -0.16369697f, -0.38169631f, 0.02251716f, -0.35797188f, -0.33350602f, 0.00913667f, 
    -0.21543576f, 0.04864941f, 0.04152374f, 0.20775545f, -0.23496538f, -0.27803248f, 0.41040003f, 0.00279863f, 
    0.18938988f, -0.42044738f, -0.22969215f, 0.23008221f, 0.19200066f, 0.02151628f, -0.47282085f, -0.11035281f, 
    -0.15130790f, 0.02409442f, 0.06287394f, -0.04071256f, 0.05716503f, 0.02454515f, -0.04998882f, -0.02658245f, 
    -0.35193488f, 0.14660637f, 0.29981247f, 0.16816509f, -0.16385774f, 0.13887401f, -0.00277721f, 0.15617572f, 
    -0.02982185f, -0.06373368f, 0.02629297f, -0.30527773f, 0.03655202f, -0.17436400f, -0.30763683f, -0.63414615f, 
    -0.37614784f, -0.04565866f, -0.22076622f, -0.29108506f, 0.37212136f, 0.04970207f, -0.09007236f, 0.07353277f, 
    0.10190838f, -0.08478644f, -0.08503184f, -0.03893482f, 0.15390837f, -0.09996560f, -0.52099961f, -0.16565442f, 
    0.05710387f, 0.10730998f, 0.05563154f, -0.56407648f, 0.01215327f, -0.00091062f, -0.04763961f, -0.03016380f, 
    -0.00594276f, -0.01186888f, 0.07234301f, -0.34581515f, -0.30503908f, 0.24459998f, 0.05478052f, -0.21122897f, 
    0.00926759f, 0.08598080f, 0.28511009f, 0.05617749f, 0.15711573f, -0.15324000f, -0.08261541f, 0.00436783f, 
    -0.27923691f, 0.19580390f, -0.03857928f, 0.13483290f, -0.47895572f, 0.01248810f, -0.37011907f, -0.43914115f, 
    0.01869025f, -0.50204366f, -0.08158650f, 0.04801691f, -0.00050784f, -0.23562397f, 0.06532616f, -0.42634818f, 
    0.05261698f, 0.30040595f, 0.06713676f, 0.03525503f, 0.06727380f, 0.29051438f, -0.20318618f, -0.16808632f, 
    0.22172360f, -0.22355966f, 0.18598010f, -0.40037796f, -0.20054734f, -0.55860835f, -0.13985391f, -0.04075257f, 
    -0.32561496f, 0.12571862f, 0.23838313f, -0.19662383f, 0.21586597f, -0.08999619f, -0.09093127f, -0.07357674f, 
    0.09240649f, -0.12779467f, -0.37517557f, 0.07384040f, -0.06609032f, -0.09304267f, -0.09925769f, -0.00426953f, 
    -0.07431895f, -0.34338331f, -0.03244750f, -0.26957354f, 0.13880806f, -0.08807009f, -0.22052900f, 0.26451546f, 
    0.22765718f, -0.52989203f, 0.34144616f, 0.05571400f, -0.08761221f, -0.11893603f, -0.13586538f, 0.17584598f, 
    0.12666044f, -0.11997619f, -0.24155514f, 0.14094001f, 0.03256502f, 0.07670591f, 0.41139477f, -0.01087542f, 
    0.13083671f, -0.13594101f, -0.00121904f, -0.11661413f, -0.02656273f, 0.01865046f, -0.16279465f, -0.13119632f, 
    -0.02842328f, 0.06675807f, 0.02339005f, -0.04615702f, -0.10065429f, -0.01842488f, -0.30076912f, 0.23184685f, 
    -0.02861386f, -0.13781640f, -0.25803053f, 0.18515702f, 0.09388722f, 0.15757471f, 0.21153714f, -0.26809159f, 
    0.00397156f, -0.16571718f, 0.04305007f, -0.28558931f, -0.27944362f, -0.08787643f, 0.09125675f, 0.22374502f, 
    0.12648998f, -0.06048290f, -0.04373516f, 0.06284083f, 0.15855269f, -0.85596877f, -0.55841005f, -0.03062046f, 
    -0.15123193f, 0.01722889f, -0.02064646f, -0.07030505f, 0.08957074f, -0.58150774f, -0.39143547f, -0.07324761f, 
    -0.06618498f, -0.22273681f, -0.02004874f, -0.09129268f, -0.39753631f, -0.34273231f, -0.21368913f, 0.06343263f, 
    0.20451936f, 0.21748617f, -0.07264733f, 0.15164691f, -0.14426385f, 0.00819944f, 0.07620551f, 0.26055437f, 
    0.11622417f, 0.11804987f, -0.03333429f, -0.03923397f, -0.28802603f, 0.28786322f, 0.19914256f, -0.56147015f, 
    0.08927716f, 0.03508905f, -0.17956911f, 0.20048796f, 0.02982269f, -0.19020006f, -0.07414724f, -0.11272336f, 
    -0.37146404f, 0.02423895f, -0.44497526f, -0.17656176f, -0.13047811f, 0.33788475f, 0.13344994f, 0.05860695f, 
    0.14997634f, -0.37611884f, 0.18830796f, 0.25877538f, -0.66192496f, 0.13279219f, 0.15254916f, -0.08273539f, 
    -0.09792209f, 0.12888971f, 0.30197215f, -0.04831492f, -0.01836757f, -0.26521143f, 0.19841112f, 0.08424690f, 
    0.28218284f, -0.45129010f, -0.50196803f, -0.08822779f, -0.18180619f, -0.27702743f, 0.10051525f, 0.21876201f, 
    0.12807125f, 0.26092008f, -0.33174831f, -0.42681667f, 0.22989579f, 0.02315769f, -0.26220787f, 0.09248673f, 
    -0.31088957f, 0.23872480f, 0.03786642f, -0.06565630f, -0.02308076f, 0.07554626f, -0.00584445f, 0.05634427f, 
    -0.53054053f, -0.46019381f, -0.15195934f, 0.04725234f, -0.48045519f, -0.01386752f, -0.09887786f, -0.23143175f, 
    0.18452887f, 0.07918799f, -0.10288423f, -0.29883701f, -0.05357477f, -0.30611846f, -0.11197830f, -0.04225236f, 
    0.16646965f, -0.11425838f, -0.14123178f, -0.45134816f, -0.05725814f, 0.22283174f, 0.16483270f, 0.03082365f, 
    -0.31621403f, -0.34151453f, 0.14678058f, -0.02133979f, 0.07171360f, -0.03679109f, -0.24164858f, -0.24167961f, 
    -0.03041724f, -0.08722542f, -0.09820548f, 0.28764585f, -0.03651484f, 0.18716088f, 0.20345221f, -0.39635649f, 
    0.21260205f, 0.07184370f, 0.01515764f, -0.28021455f, 0.02410121f, 0.13472757f, 0.10226943f, 0.24033861f, 
    -0.04174696f, -0.00199446f, 0.14448743f, -0.03545512f, 0.08537861f, 0.38083228f, 0.24359855f, 0.02598951f, 
    0.08600070f, -0.12535797f, -0.26014268f, -0.22528136f, 0.20574853f, -0.03152480f, -0.13444753f, -0.32516363f, 
    -0.04361226f, -0.14714277f, -0.09130144f, 0.04049364f, 0.14884618f, 0.04471873f, -0.34543699f, -0.04366598f, 
    -0.06511644f, 0.14066628f, 0.16619700f, 0.09880488f, -0.03152493f, 0.13222869f, -0.53165919f, 0.38450459f, 
    -0.21682797f, -0.66078776f, -0.09288640f, -0.15723693f, -0.30182445f, 0.01097808f, -0.14196007f, 0.07492793f, 
    -0.30534834f, -0.52722895f, -0.01348007f, -0.07576463f, 0.19449419f, 0.14781450f, -0.01770185f, -0.62449968f, 
    0.05023847f, -0.02376173f, 0.11587455f, -0.09311589f, -0.03862425f, 0.25085932f, 0.19163941f, -0.45381781f, 
    -0.02379456f, -0.11116970f, -0.19182591f, 0.01530017f, 0.15350066f, 0.14713629f, 0.07642574f, 0.01595921f, 
    -0.03199447f, -0.13349865f, -0.32029775f, -0.00021246f, -0.07445244f, 0.02774208f, -0.11893569f, 0.20024942f, 
    0.21841437f, -0.48238409f, 0.19447593f, -0.12038256f, 0.04953028f, 0.06737094f, 0.09665290f, 0.02750932f, 
    0.06462345f, -0.03160162f, -0.03766123f, -0.15631144f, -0.09138706f, -0.03549344f, -0.07650719f, -0.09878943f, 
    -0.40756211f, 0.00930768f, -0.25602844f, -0.18013234f, 0.02744788f, 0.00502083f, -0.24453244f, -0.06836371f, 
    -0.19572040f, -0.06144773f, 0.32716373f, -0.09951621f, -0.09980053f, -0.19428867f, 0.09862662f, -0.31731799f, 
    -0.13471694f, -0.09098758f, 0.24223042f, -0.05498062f, -0.52653825f, 0.05346899f, 0.07348595f, -0.49335140f, 
    -0.32642409f, 0.13989693f, -0.02171808f, 0.14501487f, -0.35090527f, 0.17580411f, 0.08841197f, 0.25909114f, 
    0.29712987f, 0.07874157f, 0.10973708f, -0.17992464f, -0.21117721f, 0.21389444f, 0.20212600f, -0.05823766f, 
    -0.04720416f, 0.09566487f, 0.07651716f, 0.00234166f, 0.06401791f, -0.29928416f, 0.07745385f, -0.04490467f, 
    -0.21330267f, -0.07792079f, -0.42354879f, 0.12652250f, 0.34198394f, -0.08135309f, -0.03077538f, -0.22691448f, 
    0.20289819f, -0.27317098f, 0.05040570f, 0.05200114f, -0.23660667f, -0.61223280f, -0.08756283f, -0.15370612f, 
    0.10133327f, 0.09714632f, 0.01643633f, -0.43042186f, 0.01481867f, -0.01684663f, 0.02055695f, -0.38523957f, 
    0.24007417f, 0.12954436f, -0.34885412f, 0.18553436f, -0.07045980f, -0.28572237f, 0.00688477f, 0.02668409f, 
    -0.07075107f, 0.21454448f, -0.15347865f, -0.09450979f, 0.34943026f, 0.08777136f, -0.03931626f, 0.04222464f, 
    0.02380441f, 0.00552271f, -0.33444151f, 0.02661485f, -0.13376407f, 0.30014262f, -0.67365652f, 0.26409477f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12768754f, 0.03045865f, 0.04213021f, -0.00093207f, -0.16184792f, -0.00961911f, -0.05551936f, -0.18276262f, 
    0.08471898f, 0.03482315f, 0.02165365f, -0.06928515f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
