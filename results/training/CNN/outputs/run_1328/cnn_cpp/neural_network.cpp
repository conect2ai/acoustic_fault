#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78659219f, 0.65392989f, 0.20797759f, 0.10635410f, 0.09934323f, -0.18861955f, -0.27018437f, -0.24073827f, 
    0.28649822f, -0.00848347f, -0.05795402f, 0.20040874f, 0.12672861f, -0.27063850f, -0.45340586f, -0.00573163f, 
    -0.16434848f, 0.05824009f, 0.20163931f, 0.05762260f, -0.19986376f, 0.16499086f, 0.08684799f, -0.17106681f, 
    0.07695387f, -0.25702685f, -1.00950539f, -0.07808007f, 0.61860442f, 0.16569588f, 0.37231383f, 0.48243967f, 
    -0.41547093f, -0.39369789f, -0.07219067f, -0.36268020f, -0.04218317f, -0.30811909f, -0.16535716f, -0.00812191f, 
    -0.14935870f, 0.00685544f, 0.13882701f, 0.13786127f, 0.12155375f, 0.10885622f, -0.27405369f, -0.33627495f, 
    -0.27626517f, -0.35010666f, -0.60346395f, 0.07226686f, -0.12071547f, 0.03640066f, 0.18799645f, 0.24984416f, 
    0.25509608f, 0.08957027f, 0.73998022f, -0.28189379f, -0.39677101f, -0.21088727f, -0.08142364f, 0.04383839f, 
    -0.13737553f, 0.19686072f, -0.37405011f, 0.03931955f, -0.04107452f, 0.08615100f, 0.03823547f, 0.28066963f, 
    -0.08090088f, 0.00141115f, 0.02585301f, 0.51244462f, -0.23666219f, -0.06761433f, 0.18038189f, 0.32860783f, 
    0.07940695f, -0.09479065f, 0.11134325f, 0.21062768f, 0.33680922f, -0.22142582f, 0.02456051f, 0.30554849f, 
    0.16646752f, -0.22720170f, -0.41270101f, 0.04799311f, -0.37797093f, 0.14322756f, 0.11700472f, 0.12718752f, 
    -0.07792799f, 0.09637809f, 0.25970039f, 0.18314064f, -0.32554850f, 0.23222688f, 0.34121338f, 0.25658062f, 
    -0.71710020f, -0.28000700f, -0.24373142f, 0.57222074f, 0.34982669f, -0.25012112f, 0.10754051f, 0.07051551f, 
    0.23540093f, 0.09242912f, -0.13565847f, -0.09975034f, -0.20455958f, 0.34052634f, -0.15413000f, -0.11193019f, 
    -0.14186379f, -0.18450603f, -0.04159002f, 0.22753914f, 0.24675626f, 0.11980119f, 0.40808523f, -0.04465095f, 
    -0.02317714f, 0.14611974f, 0.29256681f, -0.52021998f, -0.31295347f, -0.00308091f, -0.40693077f, 0.21223883f, 
    -0.27785817f, -0.10811413f, 0.12953120f, 0.28022459f, 0.15155378f, -0.03852542f, 0.40716389f, -0.19673178f, 
    -0.03292026f, -0.12689136f, 0.21336739f, 0.08589233f, 0.16985254f, 0.33303645f, 0.30991092f, -0.62000299f, 
    -0.64015907f, -0.74876428f, -0.57573533f, 0.58413947f, 0.04195714f, 0.36332628f, 0.25326765f, -0.13086300f, 
    0.29611248f, 0.16702262f, 0.16754888f, -0.10737087f, -0.03007581f, -0.01899315f, 0.15449218f, -0.15755364f, 
    -0.06822286f, -0.18181235f, -0.15086417f, -0.26807681f, -0.13532177f, 0.14070930f, -0.31097838f, 0.48696819f, 
    0.13373926f, 0.12350275f, -0.56822020f, -0.81348175f, 0.42823508f, -0.11819221f, -0.06953562f, 0.24134809f, 
    0.15317349f, 0.22916944f, -0.22159195f, -0.23101223f, 0.51084042f, -0.35120168f, -0.13633807f, -0.00295285f, 
    -0.15421502f, 0.00300804f, 0.20846784f, 0.16722648f, -0.01195844f, -0.03441876f, -0.07879026f, 0.15466578f, 
    -0.60420841f, -0.29901868f, 0.57682717f, -0.32026690f, -0.05661201f, -0.43650502f, -0.63337427f, -0.36010513f, 
    0.29619002f, 0.09393733f, 0.18999907f, -0.50844246f, -0.39426094f, -0.34653872f, 0.35853612f, -0.15220435f, 
    0.13186774f, -0.02759566f, -0.14646566f, -0.43951210f, 0.04183853f, 0.02861082f, -0.16254930f, -0.01472212f, 
    0.12924960f, 0.09644655f, 0.28215837f, 0.35833779f, 0.11257375f, 0.31911927f, -0.32562587f, -0.11867898f, 
    0.26291808f, 0.27247512f, 0.04367280f, -0.24107876f, 0.15249538f, -0.25556773f, 0.19750386f, -0.04987029f, 
    0.11746139f, 0.05024948f, -0.07302234f, 0.04284047f, 0.16315988f, -0.09236511f, -0.25399959f, -0.30938026f, 
    -0.34793866f, -0.34531736f, -0.74221998f, -0.67766428f, 0.04091417f, 0.57064337f, -0.04336270f, -0.38750067f, 
    -0.96874988f, -0.35208559f, 0.17694606f, 0.09068488f, 0.17933463f, 0.40476030f, 0.08681309f, 0.49394974f, 
    -0.17503181f, -0.03863198f, 0.17764443f, 0.12885827f, -0.01897826f, 0.22337875f, 0.03613654f, 0.17434371f, 
    0.08794699f, -0.09660127f, 0.12933099f, -0.09115895f, -0.49564335f, 0.29168960f, 0.11599768f, 0.58472794f, 
    -0.40927872f, 0.14993377f, -0.19221447f, -0.22540310f, 0.01103206f, -0.27213272f, -0.15790300f, -0.06776880f, 
    -0.08449253f, -0.12025712f, 0.13977341f, -0.16638532f, -0.15270987f, 0.36887181f, 0.15204607f, -0.27431872f, 
    -0.18331748f, -0.01253912f, 0.23638448f, 0.29911780f, -0.44887137f, 0.04004503f, 0.36416146f, -0.20690183f, 
    -0.43944481f, 0.25850224f, 0.07424867f, -0.28304940f, 0.44309691f, -0.29994965f, 0.23865907f, -0.37690824f, 
    0.42889419f, -0.31930706f, 0.09035189f, 0.04339626f, -0.11524627f, -0.08805538f, -0.33215714f, 0.21108092f, 
    -0.01785370f, -0.02839850f, 0.32575741f, -0.01770654f, -0.07448836f, -0.38886255f, -0.38413897f, -0.39875600f, 
    -0.53049654f, -0.35880500f, 0.45366618f, 0.00403564f, -0.24734800f, -0.05499237f, -0.26554799f, 0.09262308f, 
    -0.26080370f, 0.13002035f, 0.21301886f, 0.34357411f, -0.04175590f, 0.02768768f, -0.01665663f, -0.13199820f, 
    -0.25211915f, -0.18018943f, -0.17850937f, -0.14685063f, 0.00234312f, 0.34931692f, 0.43916970f, -0.07157330f, 
    -0.70190603f, -0.54637492f, -0.01337572f, -0.15344854f, -0.09372479f, 0.11433662f, 0.07587913f, -0.24203996f, 
    0.08199226f, 0.09250409f, 0.43508792f, -0.16496235f, -0.31001127f, -0.02850861f, -0.13931684f, -0.13379645f, 
    -0.10924706f, -0.17662740f, 0.25528711f, 0.09398469f, 0.02717246f, 0.10505302f, 0.34082407f, -0.65715098f, 
    -0.61585522f, -0.05709953f, 0.18003055f, 0.53671241f, 0.27162910f, 0.65125871f, -0.03649964f, 0.15876839f, 
    0.56182998f, 0.14399098f, 0.21666449f, 0.09304880f, 0.19459571f, -0.32030803f, -0.01273369f, -0.09830042f, 
    -0.05425843f, -0.14949124f, 0.00441275f, -0.00366178f, 0.05348615f, -0.00331684f, -0.09145909f, 0.04281994f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24637812f, 0.05433238f, -0.10302838f, 0.17980157f, 0.07163988f, 0.11238811f, -0.11446913f, 0.25051185f, 
    0.07572030f, -0.09529074f, -0.05292629f, -0.00329611f, 0.31305483f, -0.15310314f, 0.20754492f, 0.07289643f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01684864f, 0.34960726f, 0.18330303f, 0.03199773f, 0.12885934f, -0.03656977f, -0.22871576f, 0.04311167f, 
    -0.06384683f, 0.12946689f, -0.04784336f, 0.00140349f, 0.09754273f, 0.25118545f, -0.02156044f, -0.11744843f, 
    -0.05325290f, 0.05464025f, 0.09439407f, 0.13352607f, -0.03956088f, -0.26824355f, 0.16811401f, -0.10153364f, 
    -0.08931641f, -0.25130856f, -0.19529974f, -0.00804938f, -0.09351414f, -0.14049169f, 0.02962231f, 0.05701844f, 
    -0.09244639f, 0.05969551f, 0.01529662f, 0.00551448f, 0.02042465f, 0.03038639f, 0.07031271f, -0.05343514f, 
    -0.12974766f, -0.21077260f, -0.02893746f, -0.24648376f, 0.07386970f, 0.14806868f, 0.03739475f, 0.16952850f, 
    0.03921824f, 0.08359585f, -0.09583645f, 0.08482242f, 0.02805867f, -0.08396179f, -0.07250451f, -0.13616958f, 
    0.07260521f, 0.01279530f, -0.01857720f, 0.16906548f, -0.05677849f, 0.04794314f, 0.19614172f, -0.16849050f, 
    0.03547347f, 0.04591927f, -0.00638707f, 0.01410547f, -0.04873905f, 0.01005540f, 0.00639471f, 0.24051954f, 
    0.03318093f, -0.28786311f, -0.15494460f, -0.25253037f, 0.09499233f, 0.02090205f, 0.17410216f, -0.04219509f, 
    0.11119346f, -0.01403915f, 0.05452742f, -0.12062615f, 0.14603919f, -0.26217368f, 0.27348423f, -0.14332779f, 
    -0.02661199f, 0.08122936f, 0.22313111f, 0.07794678f, 0.06816346f, 0.04701560f, 0.12976907f, 0.08801416f, 
    0.17756827f, -0.02804411f, 0.17860486f, -0.00027045f, -0.00423361f, 0.06247503f, -0.02634192f, 0.26050302f, 
    -0.05917713f, -0.04937094f, -0.13347208f, 0.02907415f, -0.01759279f, 0.11902604f, 0.09438433f, -0.04838844f, 
    0.04310086f, 0.04570270f, -0.02132826f, -0.09041038f, -0.23792338f, -0.03696401f, -0.16636041f, -0.12547490f, 
    0.20152578f, -0.15519722f, -0.03325982f, 0.10117111f, 0.13211308f, -0.01193782f, -0.03697302f, 0.11097943f, 
    -0.14950863f, -0.02612117f, -0.02087931f, 0.08933438f, 0.28766912f, 0.05108785f, 0.06290779f, 0.03360269f, 
    0.15347263f, 0.09480315f, 0.05200963f, 0.02790911f, 0.07756254f, -0.01381433f, -0.12687612f, 0.11103652f, 
    0.10396936f, 0.03525443f, -0.03619476f, -0.04156870f, 0.03241630f, 0.19113398f, 0.10282944f, 0.21882297f, 
    -0.08758237f, 0.21825896f, 0.02605314f, -0.05419859f, -0.04337147f, -0.03802742f, -0.01194750f, -0.11091856f, 
    0.20899941f, 0.03075678f, 0.14274733f, -0.09456597f, 0.01131916f, -0.02498915f, -0.02642054f, -0.07898629f, 
    -0.02515226f, -0.04053791f, -0.01687073f, 0.02514179f, 0.05296118f, 0.00403144f, 0.20573203f, 0.04251495f, 
    0.03064423f, 0.15323350f, -0.01871036f, 0.08904684f, -0.13107386f, -0.10430682f, -0.31467941f, -0.04239915f, 
    -0.22651936f, 0.07432724f, -0.12402335f, -0.16162127f, 0.04150549f, 0.07191139f, 0.05382113f, 0.03725123f, 
    0.10912862f, -0.19666488f, -0.20715457f, 0.06431604f, 0.11446536f, 0.17987147f, 0.15275070f, 0.02975766f, 
    0.03125572f, -0.02338626f, -0.04325354f, -0.11322404f, -0.07433997f, -0.16737822f, 0.08125163f, 0.12329925f, 
    0.02542266f, 0.12644216f, -0.12171689f, 0.14023377f, -0.00675039f, 0.08751018f, 0.07303876f, 0.16015474f, 
    0.05027479f, -0.01545457f, 0.02730517f, 0.23945606f, 0.22099242f, 0.11576472f, -0.02937625f, 0.07163511f, 
    -0.04516807f, -0.16214679f, -0.01463891f, 0.09319001f, 0.13402547f, -0.11502222f, 0.04839831f, 0.07666563f, 
    0.13839680f, 0.06105404f, 0.02136308f, -0.05506057f, 0.01568770f, -0.16365351f, -0.12755619f, -0.14739741f, 
    -0.04678057f, 0.16332345f, 0.05851433f, 0.14048539f, 0.10396753f, -0.11541101f, 0.05922405f, 0.13882531f, 
    -0.03451053f, 0.12531132f, 0.04103223f, -0.03995249f, 0.24237373f, -0.01070174f, -0.05156031f, 0.01813788f, 
    0.01847900f, 0.05375781f, 0.12963128f, 0.07986894f, 0.02922910f, -0.00505158f, -0.10414076f, -0.13095807f, 
    0.00652172f, 0.03851832f, 0.51533675f, 0.08790158f, 0.03929316f, -0.15973803f, -0.17042582f, -0.04794258f, 
    -0.10191140f, 0.10078650f, 0.14046687f, 0.20793672f, -0.25057006f, 0.04699869f, -0.06035890f, -0.08520711f, 
    -0.18896425f, -0.19824085f, 0.21313791f, 0.11284249f, 0.08960182f, 0.18658184f, 0.07236172f, 0.08956575f, 
    0.14957264f, 0.09249374f, -0.02205310f, -0.04613620f, -0.03062599f, -0.09345730f, 0.06391145f, -0.09349617f, 
    -0.08300087f, -0.05359668f, -0.05905997f, 0.14244732f, 0.04258429f, -0.05605222f, -0.20841311f, -0.04009375f, 
    0.12206101f, 0.17657062f, 0.07170086f, -0.05524460f, 0.13554093f, 0.17396468f, 0.02969478f, 0.28244504f, 
    0.27199531f, -0.00379308f, 0.09594602f, -0.04434308f, 0.01004053f, -0.15078536f, 0.06516614f, 0.04267172f, 
    0.01136924f, 0.06851971f, -0.04454093f, 0.04627230f, -0.22610961f, -0.18807982f, -0.06188037f, -0.07562787f, 
    0.12046627f, 0.19011401f, 0.02229705f, 0.17570788f, -0.11676168f, 0.07162105f, -0.05804296f, -0.02774545f, 
    0.06141137f, 0.06725286f, -0.02319246f, -0.07635680f, -0.00404476f, 0.00411313f, 0.00790705f, -0.04219186f, 
    0.09158626f, -0.11149085f, -0.07132346f, -0.09517373f, 0.08175997f, 0.01167770f, -0.12651475f, -0.10973389f, 
    -0.18596616f, -0.27325073f, -0.05763303f, 0.13687366f, -0.10597786f, 0.01827803f, 0.01995871f, 0.00743574f, 
    -0.00840281f, 0.08242942f, 0.28160954f, -0.25107387f, 0.09295344f, -0.21152706f, -0.05460112f, 0.08191057f, 
    -0.06440211f, -0.08986071f, 0.05990441f, -0.11713307f, 0.07855548f, 0.13251185f, 0.01585945f, 0.23618387f, 
    0.08491822f, 0.09254239f, -0.06155800f, -0.15328003f, -0.03947945f, 0.03624397f, -0.07322563f, -0.07984761f, 
    0.24623562f, 0.10200494f, 0.00143613f, 0.27954730f, -0.00287397f, -0.06544220f, 0.03365240f, -0.02695007f, 
    0.03982145f, 0.06093859f, 0.04925681f, 0.03085652f, -0.57217771f, -0.18624908f, -0.01712582f, -0.01244172f, 
    -0.16308430f, -0.18875974f, 0.13851470f, 0.00663624f, -0.07507566f, 0.03969890f, -0.06556138f, 0.17336351f, 
    0.13384150f, 0.22164398f, 0.37097606f, 0.04961576f, 0.12683204f, 0.08357432f, 0.09665229f, 0.07500988f, 
    -0.10862207f, 0.21953553f, 0.12149970f, -0.03576740f, 0.16201365f, 0.18017468f, 0.17879917f, 0.25108930f, 
    -0.01412046f, 0.03612512f, -0.13446793f, -0.04778372f, 0.04780223f, -0.11586698f, -0.05735967f, 0.01941857f, 
    -0.26242477f, -0.10303701f, 0.26452112f, 0.07456373f, -0.05280733f, -0.02529566f, -0.05772514f, 0.00561700f, 
    0.03940912f, -0.00525959f, 0.02283332f, -0.23877004f, 0.26616791f, -0.03358864f, -0.00879305f, 0.07736813f, 
    0.03837464f, 0.18922283f, -0.00455504f, -0.09021957f, -0.06612677f, -0.01415947f, -0.00264978f, 0.00716660f, 
    -0.16631292f, -0.34529427f, -0.23221146f, -0.16217382f, 0.07183125f, 0.24254152f, 0.07562289f, 0.11660005f, 
    0.34630108f, -0.06751104f, 0.03885666f, -0.20174800f, 0.32430911f, -0.20005451f, -0.29132631f, -0.08908278f, 
    0.02659678f, 0.12436984f, 0.03438088f, -0.14391568f, -0.01730306f, 0.16008638f, 0.02570837f, -0.03163813f, 
    -0.68150657f, -0.51758385f, 0.31094071f, 0.05935352f, -0.16103561f, -0.00565848f, -0.03429879f, 0.10610747f, 
    -0.09528156f, 0.00047438f, 0.02044564f, -0.13537247f, -0.02646863f, 0.05096042f, 0.09823991f, 0.18644719f, 
    0.09149101f, -0.05248616f, -0.03420014f, 0.18490854f, 0.20653874f, 0.13602687f, 0.15256613f, 0.03970532f, 
    -0.34437558f, 0.03575870f, 0.25103024f, -0.19962332f, 0.04928181f, 0.24534133f, 0.13515054f, 0.01494101f, 
    0.07896566f, -0.07470213f, -0.13581622f, -0.06163898f, -0.42658490f, -0.11836649f, 0.26251316f, 0.38279405f, 
    0.03253206f, -0.11523411f, -0.02514140f, -0.24860542f, 0.03953291f, -0.01194090f, -0.04427507f, 0.13722077f, 
    -0.17095794f, -0.11402293f, -0.13838539f, -0.30499589f, 0.18938597f, 0.10133029f, 0.12578350f, -0.04734770f, 
    0.05903259f, 0.15697560f, -0.02735394f, -0.07467879f, 0.01300821f, 0.08898320f, -0.12481294f, -0.15402824f, 
    0.10030191f, 0.24224193f, 0.11766273f, -0.00904000f, -0.12798518f, -0.06781434f, -0.10682733f, -0.02029379f, 
    0.02405150f, 0.21987072f, -0.11240666f, 0.06086590f, -0.00760510f, 0.22301430f, 0.00605968f, -0.22287889f, 
    0.03499667f, -0.01549313f, 0.07242015f, 0.01675952f, 0.23478065f, -0.11622970f, 0.04741098f, -0.07289803f, 
    0.00766036f, 0.07054731f, 0.02617696f, 0.07468759f, -0.05589609f, 0.10471682f, -0.07934996f, 0.04597720f, 
    -0.06773540f, -0.08397334f, 0.21390931f, 0.01092753f, -0.08864518f, -0.06747198f, 0.05558109f, 0.05835113f, 
    0.13332927f, -0.06640258f, 0.12887236f, -0.00769723f, 0.20081860f, 0.04501479f, 0.06718735f, -0.16891922f, 
    0.05317715f, -0.06561591f, -0.04187438f, 0.01963767f, -0.01871677f, 0.14226547f, -0.03824076f, -0.13134956f, 
    -0.00219312f, -0.02663566f, -0.34906659f, 0.10069260f, -0.06666563f, -0.04161757f, 0.05305648f, 0.02016361f, 
    0.10919730f, 0.12490230f, -0.02416583f, -0.10408484f, -0.14213660f, 0.00979242f, 0.13194229f, 0.11541422f, 
    -0.05541790f, -0.12995477f, 0.03811706f, -0.12987404f, 0.01523357f, 0.01540830f, -0.06661111f, 0.04618128f, 
    0.16039698f, 0.29154307f, -0.24537800f, 0.21458478f, -0.06187543f, -0.04444905f, -0.08527292f, -0.08482193f, 
    -0.10020428f, -0.07686909f, 0.00674380f, -0.14825062f, -0.37138310f, -0.11258643f, 0.06042343f, -0.19344147f, 
    -0.04633542f, -0.00320157f, 0.04640115f, 0.09063815f, 0.04033456f, -0.05496677f, 0.17487922f, -0.02037313f, 
    -0.03146938f, 0.22568603f, 0.00611506f, -0.06338902f, -0.08769134f, -0.07458515f, 0.06134745f, -0.08421456f, 
    0.18715219f, -0.12530023f, 0.08466136f, 0.13794370f, 0.06380212f, 0.46618116f, -0.17119102f, 0.15833654f, 
    0.08409766f, 0.02288279f, -0.13273449f, 0.17447780f, 0.16728818f, 0.20942947f, 0.02406302f, 0.21402790f, 
    0.02742955f, -0.17346126f, 0.10449343f, 0.08531883f, 0.07365134f, 0.33739465f, -0.05330989f, 0.06464288f, 
    -0.03563187f, -0.03713763f, 0.01553790f, 0.03963171f, -0.19099513f, -0.11234517f, 0.03011115f, 0.07920263f, 
    -0.03089461f, -0.17372513f, 0.04773119f, 0.07320232f, 0.01372287f, 0.00258349f, 0.00089788f, 0.03240123f, 
    0.00947274f, -0.47769925f, -0.02258616f, 0.08161119f, 0.00536862f, 0.03784533f, -0.11250757f, -0.10080171f, 
    0.11161097f, -0.01817446f, 0.07177858f, 0.04855339f, 0.00998805f, 0.00549051f, -0.10522412f, 0.14782286f, 
    -0.01268765f, 0.06624874f, -0.04712923f, 0.21215700f, -0.19880003f, -0.04571563f, 0.05125506f, 0.03836059f, 
    0.13388367f, 0.21173185f, -0.19861375f, 0.15061322f, 0.08498402f, -0.06204413f, -0.01983332f, -0.03354809f, 
    0.21464413f, 0.16809553f, 0.08527470f, 0.06516369f, -0.19533546f, -0.08694867f, -0.01227840f, -0.12166265f, 
    0.00571630f, 0.02754078f, -0.00690257f, -0.11613493f, -0.07977113f, -0.03670946f, -0.22592404f, -0.00915808f, 
    -0.02980329f, 0.00904456f, -0.28548813f, -0.05154388f, 0.22794281f, 0.23845406f, 0.08694787f, -0.15436694f, 
    0.07001597f, 0.08396530f, -0.04062596f, 0.07402699f, 0.24657251f, -0.27186000f, 0.27767596f, -0.15503666f, 
    -0.04187846f, -0.16795166f, -0.29099256f, 0.20156439f, 0.09464353f, -0.07231271f, 0.09326217f, -0.07383197f, 
    0.19738452f, 0.02732541f, -0.13905556f, 0.11490878f, -0.00003222f, -0.05121398f, 0.11456724f, 0.08090534f, 
    -0.14783324f, 0.07780438f, -0.09371815f, -0.04949857f, 0.21224086f, -0.05452214f, 0.06459775f, -0.16399653f, 
    -0.02305810f, -0.06639376f, -0.02204681f, 0.09969201f, 0.05551369f, 0.05196357f, -0.02054569f, -0.05914933f, 
    -0.41375786f, 0.02038958f, 0.03881702f, -0.03656307f, -0.10388462f, -0.11728153f, 0.08930863f, -0.19116645f, 
    0.11674619f, -0.03916704f, 0.05738356f, 0.08014676f, 0.06934898f, -0.00787323f, 0.01403339f, 0.21265250f, 
    -0.09468022f, 0.04690326f, 0.00181311f, 0.00603248f, 0.08368035f, 0.01726659f, 0.04436190f, 0.05018567f, 
    -0.18682058f, -0.20416121f, 0.17233647f, 0.13780981f, 0.06571290f, 0.10634615f, 0.07414649f, -0.08272106f, 
    0.13175762f, -0.23424733f, 0.01945681f, 0.10120317f, 0.04479514f, 0.02216306f, -0.19013457f, 0.09826711f, 
    0.07532953f, 0.16165629f, 0.05719841f, -0.05290446f, 0.10886455f, 0.00849647f, 0.07194534f, 0.13504782f, 
    0.15978514f, -0.15760615f, -0.14302543f, -0.27410957f, -0.00424294f, 0.02349224f, -0.05553143f, 0.06342621f, 
    -0.01809700f, -0.10625842f, 0.09776829f, -0.13621585f, 0.23251253f, -0.24552582f, -0.01036403f, -0.21694252f, 
    0.04460661f, 0.08952121f, 0.28793964f, 0.01249485f, 0.02414988f, -0.06913323f, 0.07504757f, -0.04857299f, 
    -0.10071696f, 0.26608643f, 0.10530076f, -0.13070329f, 0.06324805f, 0.06424297f, 0.06347486f, 0.14245588f, 
    0.15007682f, -0.01609732f, 0.16973405f, 0.02028039f, -0.03660452f, -0.16498668f, -0.07236531f, -0.05082882f, 
    0.09515901f, 0.01036636f, -0.16440989f, 0.11789214f, -0.27422681f, -0.14336310f, -0.05152868f, -0.16421297f, 
    0.03209360f, 0.19254875f, 0.25241414f, 0.02489707f, 0.04886120f, 0.06247582f, 0.14721388f, -0.15764114f, 
    -0.05153608f, -0.10376646f, 0.05112719f, -0.05726755f, 0.46735004f, -0.00255203f, 0.21629903f, -0.12370243f, 
    0.18331248f, 0.10004847f, 0.00729518f, -0.13211377f, 0.11221998f, 0.14840366f, -0.13080578f, 0.01167178f, 
    -0.24282591f, 0.06202627f, 0.07608133f, 0.00398825f, 0.06290922f, 0.05060831f, 0.15543792f, 0.10880461f, 
    0.02603425f, -0.01362182f, 0.14760938f, 0.18256421f, 0.07424821f, 0.14857486f, 0.13938595f, -0.26276556f, 
    0.04877575f, 0.09530875f, 0.05428034f, -0.07783313f, 0.06617670f, -0.11624228f, 0.03059157f, -0.03693826f, 
    0.10048316f, -0.13917890f, -0.01519265f, -0.32671347f, 0.07281317f, -0.01136424f, -0.02224277f, 0.05961786f, 
    0.11484364f, -0.07786205f, -0.10456493f, 0.06913379f, -0.25215301f, -0.31132495f, -0.05599888f, 0.35061476f, 
    -0.07395732f, -0.03334749f, -0.07993299f, -0.08271101f, 0.10080420f, 0.08989323f, 0.22895356f, 0.05011386f, 
    0.01622885f, 0.06225196f, -0.04522032f, 0.29991022f, 0.05711300f, 0.11866518f, 0.04005292f, 0.09750867f, 
    -0.02444102f, -0.08092964f, -0.02293368f, 0.01158738f, -0.02572675f, 0.24790491f, 0.15603693f, 0.06161747f, 
    0.05402847f, -0.10819775f, 0.01566148f, 0.00313600f, -0.12345488f, 0.11566320f, -0.16580865f, -0.22228886f, 
    0.17959090f, -0.24537894f, -0.12956060f, -0.18615349f, -0.06725086f, 0.07574145f, -0.00698214f, -0.17395027f, 
    0.15452746f, 0.08342182f, -0.03243273f, 0.04959033f, -0.14347351f, -0.01239492f, 0.17952728f, 0.00617203f, 
    -0.12863038f, -0.12524369f, -0.13106102f, 0.04385388f, 0.09867595f, 0.06362291f, 0.16121362f, 0.10929970f, 
    0.55345303f, -0.02658720f, -0.08679573f, 0.35734499f, 0.03073173f, 0.11671442f, -0.22165020f, 0.01483555f, 
    -0.08455859f, -0.19109309f, 0.00851160f, -0.07046907f, -0.02049363f, -0.05768894f, -0.06699171f, 0.02026673f, 
    -0.03744972f, 0.27130011f, 0.02933826f, 0.05223012f, 0.18994151f, 0.04377818f, 0.10745096f, 0.12698512f, 
    -0.19548444f, 0.21715523f, -0.17109711f, -0.19823518f, -0.02286152f, -0.09825891f, -0.17646523f, 0.08450800f, 
    0.02113398f, -0.16410789f, 0.11176329f, -0.18378930f, 0.09769744f, 0.11950157f, 0.05132577f, 0.37416977f, 
    -0.03139321f, 0.12168801f, 0.06680170f, -0.08735281f, 0.10969714f, 0.09287127f, -0.04371500f, 0.13961032f, 
    0.00239886f, -0.16189404f, 0.20018314f, 0.25344563f, -0.03069245f, -0.04570082f, 0.28695002f, 0.00942865f, 
    0.01255274f, 0.04027426f, 0.06033031f, 0.00488412f, -0.17456269f, -0.25724286f, -0.07826722f, -0.12803441f, 
    -0.07270838f, 0.03092732f, 0.04926752f, 0.03480284f, -0.17566241f, -0.09743267f, -0.07427979f, -0.35749152f, 
    0.28910688f, -0.11282408f, 0.23359933f, 0.19186039f, 0.05297869f, 0.10943755f, -0.01583553f, -0.11047804f, 
    -0.00536745f, -0.04362851f, 0.02392181f, -0.20217966f, 0.18693936f, 0.00001834f, 0.33002931f, 0.20490526f, 
    0.23100650f, 0.10273255f, 0.02099289f, -0.07030428f, 0.14196286f, 0.01762232f, -0.21215466f, 0.21795045f, 
    -0.01543494f, 0.05669192f, 0.15287951f, 0.34090787f, 0.09072097f, -0.12282832f, 0.06466789f, -0.12464726f, 
    0.17271829f, 0.02188827f, 0.12558198f, 0.08982414f, -0.13158965f, 0.19005902f, 0.02006884f, 0.06514852f, 
    0.09483305f, -0.00899336f, -0.05360480f, 0.08310890f, -0.17994304f, -0.11792159f, -0.16817322f, 0.06615129f, 
    -0.01245782f, -0.14441447f, 0.13285145f, -0.06187000f, 0.06966583f, 0.13688189f, -0.06327277f, -0.05953163f, 
    0.11773317f, -0.03885170f, -0.01636819f, 0.08358912f, -0.41650987f, -0.22669993f, 0.17643395f, 0.08800916f, 
    -0.03787909f, -0.03100244f, -0.05331996f, -0.00455451f, 0.14660825f, 0.08541395f, 0.28063974f, 0.03357031f, 
    -0.07575430f, 0.14359535f, 0.24483329f, -0.05648625f, -0.06906378f, 0.00057727f, -0.08250871f, 0.01354096f, 
    -0.03293085f, 0.06117294f, -0.01742077f, 0.08928295f, -0.12373027f, 0.06665161f, -0.04411009f, 0.11247911f, 
    0.04797188f, 0.11895736f, 0.03062942f, 0.01663404f, -0.01813200f, 0.07400694f, 0.00916088f, -0.07762861f, 
    -0.07136846f, -0.04352238f, -0.04987675f, -0.14155813f, -0.13059089f, -0.08319610f, 0.15433814f, -0.17037454f, 
    0.12924308f, 0.10300765f, 0.03140916f, -0.01536446f, -0.07539459f, 0.13240074f, -0.07153463f, -0.04105738f, 
    -0.22316748f, -0.18815976f, -0.05489924f, -0.05282925f, 0.03693665f, 0.14935963f, 0.08550111f, 0.02398292f, 
    0.27821359f, 0.00948984f, -0.02141932f, -0.12159398f, 0.01897084f, 0.03986656f, 0.01631423f, -0.08533273f, 
    0.07642968f, 0.03648052f, 0.14210795f, 0.22238879f, -0.18547219f, -0.11249734f, 0.13269250f, -0.07606599f, 
    0.00291984f, -0.03372519f, -0.03616296f, -0.13691469f, -0.00648606f, -0.01292140f, -0.04302153f, 0.18328939f, 
    -0.09548812f, 0.28757566f, -0.25432441f, 0.00057668f, -0.00478822f, -0.01016751f, 0.05591237f, 0.06109874f, 
    -0.01696166f, -0.00854328f, 0.03276908f, -0.07486752f, 0.22153820f, 0.08750398f, 0.44275126f, 0.25131628f, 
    0.21461482f, -0.04299155f, 0.10167553f, 0.01692861f, 0.08366454f, 0.10082973f, 0.13964859f, 0.11074039f, 
    -0.10270265f, -0.16346048f, -0.18558563f, -0.04260692f, -0.00263999f, -0.00757334f, 0.14800875f, 0.07141463f, 
    0.10326759f, -0.03843780f, -0.01259517f, 0.02530835f, -0.02788123f, 0.04524327f, 0.07389648f, -0.16097252f, 
    -0.04974960f, 0.01504705f, -0.12339373f, -0.03112294f, -0.13046263f, 0.02734214f, -0.07193870f, -0.17974618f, 
    -0.14593081f, -0.01252932f, -0.29094374f, 0.21234627f, 0.16651739f, 0.03457683f, -0.07049199f, 0.02770555f, 
    -0.16266160f, -0.08457214f, -0.01811982f, -0.02254534f, 0.14649686f, 0.06488292f, -0.06219341f, 0.25251165f, 
    -0.00443667f, 0.02323676f, 0.12412781f, -0.07780938f, 0.22502685f, -0.08980519f, 0.12586527f, 0.14473774f, 
    0.10614810f, 0.03960816f, 0.25930309f, 0.20137630f, 0.01394496f, 0.00477035f, 0.15269175f, -0.03684888f, 
    0.01867545f, 0.09551078f, 0.19161320f, 0.13331982f, -0.27024376f, -0.04368455f, 0.07925937f, -0.00062039f, 
    0.11331502f, -0.19440949f, -0.02206611f, 0.02352085f, 0.04379574f, 0.10186219f, 0.11468262f, -0.02596085f, 
    0.01744349f, -0.12314267f, -0.01449800f, 0.20464507f, -0.01942243f, 0.07766215f, 0.02682707f, 0.07069643f, 
    0.04368136f, 0.03054144f, 0.06768216f, 0.11997622f, -0.36328548f, 0.04978064f, -0.15350808f, -0.22714365f, 
    -0.04293960f, -0.08420721f, 0.02794526f, -0.03409100f, 0.00591754f, -0.10922194f, -0.02862540f, 0.00642050f, 
    -0.70917988f, -0.52005798f, -0.33724779f, -0.70463878f, 0.13031213f, -0.14219408f, -0.13573961f, -0.09312594f, 
    -0.21728304f, 0.08183652f, -0.03878879f, -0.14412017f, 0.22688048f, 0.09469896f, 0.15734269f, 0.04703993f, 
    0.04716004f, -0.02766793f, 0.12297647f, -0.05921467f, 0.13662562f, -0.08576661f, 0.14736930f, 0.21295035f, 
    0.07478625f, 0.28241599f, -0.08363279f, -0.16652840f, -0.11378260f, 0.10206995f, -0.01359546f, 0.15210885f, 
    -0.03422547f, -0.09341168f, 0.08577120f, -0.01841616f, -0.32276067f, -0.44667140f, -0.64264846f, -0.33204389f, 
    0.11644039f, 0.10605133f, 0.06780706f, 0.00869461f, -0.06269382f, -0.11834136f, -0.01571844f, 0.01155598f, 
    -0.38530517f, -0.18673602f, 0.24667145f, -0.30309761f, 0.02151502f, 0.14057396f, 0.03178794f, 0.09772094f, 
    0.08986772f, 0.11891993f, 0.05607829f, 0.12006829f, 0.09861974f, 0.08695569f, -0.04244619f, -0.11790109f, 
    0.14297342f, -0.06644188f, 0.05459752f, 0.06455903f, -0.01907966f, 0.03721615f, -0.04814171f, -0.04716129f, 
    0.26266187f, -0.08855424f, -0.06760475f, 0.22733757f, 0.19757774f, 0.10040475f, 0.10562123f, 0.16367398f, 
    -0.01672305f, 0.09320910f, -0.00648933f, 0.24953519f, 0.08850166f, -0.32505631f, 0.17203166f, -0.06576587f, 
    -0.00643529f, 0.02062924f, 0.04441394f, 0.02839739f, 0.00878505f, -0.19846414f, -0.08664177f, 0.01404267f, 
    0.11596201f, 0.27955863f, 0.23641877f, -0.12724549f, -0.02184307f, 0.05901562f, -0.14963794f, 0.12364099f, 
    -0.04428472f, -0.07185146f, 0.08808962f, 0.11985517f, -0.06972215f, 0.02293563f, -0.10732162f, -0.10645791f, 
    0.00516718f, -0.05302746f, -0.16187516f, -0.03778490f, -0.04178070f, -0.04323706f, 0.06790079f, 0.17811580f, 
    0.04272844f, 0.51673144f, 0.14748834f, -0.06330757f, -0.01019769f, -0.02254117f, 0.10129357f, 0.08274258f, 
    -0.03683256f, 0.05074683f, -0.10215545f, 0.06449262f, 0.13685393f, 0.07362504f, -0.06506220f, -0.19532588f, 
    0.05430993f, -0.09438692f, 0.04643218f, 0.03668964f, -0.09197939f, -0.08534425f, 0.01530203f, -0.08884654f, 
    0.06338961f, 0.08236496f, 0.15193062f, -0.23725884f, -0.01452359f, 0.11542851f, -0.07811312f, 0.17924550f, 
    -0.13194892f, -0.04312992f, 0.02683339f, 0.04848970f, 0.26522639f, 0.21316731f, 0.17016481f, 0.12809071f, 
    0.08010279f, 0.07156000f, 0.05931365f, -0.04241659f, 0.03436707f, 0.01388122f, 0.21831763f, -0.00703464f, 
    0.24368575f, 0.15624367f, 0.13082632f, 0.15436769f, -0.05094315f, -0.08723827f, 0.06943132f, 0.02267101f, 
    -0.11317537f, 0.05712974f, 0.00614273f, 0.05487530f, 0.13284321f, 0.24176890f, -0.31516868f, -0.33585006f, 
    0.06418896f, 0.02921997f, 0.24326923f, -0.10099492f, -0.04736152f, 0.13012947f, -0.07797714f, -0.03141797f, 
    -0.03588022f, -0.01482300f, -0.02538755f, 0.03398775f, -0.05672759f, -0.03728160f, 0.00592882f, 0.01092170f, 
    -0.03089348f, 0.01718211f, 0.00931438f, -0.04027706f, 0.04627913f, 0.03162204f, -0.06499823f, -0.04755620f, 
    -0.00509910f, -0.02603978f, 0.03643583f, 0.05279354f, -0.06185011f, -0.02145001f, -0.04006801f, -0.03024524f, 
    -0.01959865f, 0.03447714f, -0.06994245f, -0.04275850f, 0.03505571f, 0.05250793f, -0.07151007f, -0.01325799f, 
    -0.03207012f, 0.05858491f, -0.06951083f, 0.02361569f, -0.04509440f, -0.00465926f, 0.01838402f, 0.01304028f, 
    -0.03884060f, 0.02461254f, 0.04172445f, -0.07040443f, 0.04575129f, -0.04699771f, -0.07526778f, -0.04949827f, 
    -0.02192354f, -0.05993501f, -0.03484013f, 0.02285475f, -0.07266819f, 0.00105327f, 0.05871473f, -0.01615898f, 
    -0.01411634f, -0.04950160f, -0.07694633f, 0.06462222f, -0.05358898f, 0.03532325f, -0.04394988f, 0.02665801f, 
    -0.04096297f, -0.02225412f, -0.06887008f, 0.04628519f, 0.05761795f, -0.05137487f, 0.06026471f, -0.01615295f, 
    0.01842077f, 0.01615864f, -0.05018464f, 0.02741858f, -0.07447376f, -0.04260851f, 0.00136689f, 0.02028685f, 
    0.00419805f, -0.07148400f, 0.03511669f, 0.05434326f, 0.03069765f, 0.00808648f, -0.02792925f, -0.03505450f, 
    -0.02559115f, -0.04980185f, 0.06519470f, 0.01884679f, -0.04472528f, 0.04582028f, 0.00967523f, 0.00804321f, 
    0.05988671f, 0.00336806f, 0.04368267f, -0.07269830f, 0.00030570f, 0.02491195f, -0.07461114f, -0.04923852f, 
    0.05322015f, 0.03181634f, 0.05769640f, -0.01676195f, 0.01811502f, -0.05864203f, 0.03960039f, 0.02287438f, 
    -0.04134323f, -0.06113834f, -0.06296567f, -0.01398590f, 0.03802412f, -0.03662255f, 0.00412120f, -0.06445719f, 
    -0.00546033f, -0.05923235f, -0.01518738f, -0.02626156f, 0.03893097f, -0.03233175f, 0.01803871f, -0.01428209f, 
    0.00748249f, -0.02245640f, -0.00384582f, 0.01935997f, 0.00465378f, -0.01166494f, -0.07585545f, -0.02969720f, 
    -0.00467675f, 0.03178488f, -0.01829086f, 0.05779419f, -0.03024767f, -0.03555767f, 0.02134050f, -0.00329913f, 
    0.05517287f, 0.05693660f, 0.05539753f, -0.04663990f, 0.01543919f, 0.03418975f, -0.00635071f, -0.00166571f, 
    -0.07212947f, -0.05455504f, 0.06215336f, -0.00927590f, 0.00746824f, -0.06249185f, -0.06869435f, 0.04069538f, 
    0.05668601f, -0.03078780f, -0.02227126f, -0.02584686f, -0.02960493f, -0.04662330f, 0.06147725f, -0.07052629f, 
    -0.07797422f, 0.00185187f, 0.05970237f, -0.06623170f, 0.06515406f, -0.00574419f, -0.02125422f, -0.04822236f, 
    -0.00063643f, 0.01236538f, -0.05508218f, -0.05964449f, -0.03044932f, 0.05161768f, -0.05449187f, -0.06903616f, 
    -0.02867211f, 0.05754915f, 0.01941913f, 0.02209055f, -0.04951986f, -0.05997993f, -0.04287484f, 0.03386313f, 
    -0.03441694f, -0.05381846f, -0.01330707f, 0.02329360f, -0.02906055f, 0.00534736f, -0.03017233f, 0.02402136f, 
    0.00941353f, -0.05088632f, 0.06153252f, -0.00311380f, 0.01209764f, 0.01332782f, -0.04118499f, -0.01876885f, 
    -0.07628626f, 0.03422595f, -0.00475637f, -0.05012412f, 0.04509223f, -0.02523607f, 0.03635276f, -0.02868382f, 
    -0.00317850f, -0.03047927f, 0.04603979f, 0.01344959f, 0.02230543f, -0.02311145f, 0.04044521f, -0.07889562f, 
    0.02181885f, 0.02413256f, 0.00737381f, -0.00670643f, 0.05810229f, -0.00204113f, -0.05342622f, 0.02856623f, 
    0.03721549f, -0.01967633f, -0.03474875f, -0.03718679f, -0.06440527f, -0.02337526f, -0.00867763f, -0.04743723f, 
    -0.07006045f, -0.02902022f, -0.00003489f, 0.04190868f, -0.02604546f, 0.04652448f, 0.05366876f, -0.02138582f, 
    -0.02925321f, 0.01441940f, 0.02449075f, -0.02644962f, -0.06950828f, -0.03371639f, -0.03020263f, 0.01938052f, 
    0.02831668f, -0.02979013f, -0.02238269f, -0.05199357f, 0.04787856f, 0.00976339f, -0.01552425f, -0.00640742f, 
    -0.01173736f, -0.03093356f, 0.00772563f, -0.01946674f, -0.03228130f, 0.00652417f, 0.00567342f, 0.06783537f, 
    -0.04288975f, 0.06188928f, -0.05566102f, 0.00045561f, -0.01374716f, -0.02111766f, -0.02419451f, -0.05263564f, 
    0.05738639f, -0.07196143f, 0.03333910f, -0.00420905f, -0.01759145f, 0.04289081f, 0.05058125f, 0.05500340f, 
    -0.00478633f, -0.03307971f, -0.06729541f, -0.03272795f, 0.04681814f, -0.00491174f, 0.01716768f, -0.03550240f, 
    0.05349195f, 0.00980116f, -0.03270368f, -0.03549170f, -0.04256873f, 0.05988840f, 0.06122398f, -0.03320835f, 
    0.06535745f, 0.01393692f, -0.02909571f, 0.04437860f, -0.03934192f, -0.06725249f, -0.01032728f, 0.04454124f, 
    -0.02506641f, -0.02037353f, 0.06568605f, -0.00608353f, 0.02755165f, -0.01860941f, -0.04557133f, -0.02944412f, 
    0.04283880f, 0.03898255f, -0.00325259f, -0.04495499f, 0.02252019f, -0.01303520f, -0.01829934f, 0.00239763f, 
    -0.05958418f, -0.05211376f, -0.01607997f, -0.02025180f, -0.05720907f, 0.01219184f, -0.07185381f, -0.01090528f, 
    -0.04103934f, -0.00652004f, 0.04867652f, 0.05639005f, -0.07660116f, 0.06388313f, 0.05681390f, -0.01350661f, 
    -0.04900185f, 0.02476304f, 0.05764444f, -0.00197776f, 0.05233145f, 0.05785807f, -0.04874607f, -0.02972004f, 
    0.03023414f, -0.00992193f, -0.01851187f, -0.06466318f, -0.05032923f, -0.00364949f, -0.06216875f, -0.05302542f, 
    0.04231839f, -0.05868976f, 0.02085982f, -0.00860269f, -0.07188547f, -0.06667945f, 0.04313204f, -0.08124906f, 
    -0.03065983f, -0.01395364f, -0.07148612f, -0.04417306f, -0.05724314f, -0.04403668f, 0.00241723f, -0.04887635f, 
    -0.01247311f, -0.01852139f, 0.05105172f, -0.02032487f, 0.00538135f, 0.00887662f, 0.03774682f, 0.03405322f, 
    -0.01273990f, -0.01576865f, -0.01258208f, 0.00521467f, -0.03753836f, -0.05349075f, -0.05787445f, 0.03476212f, 
    -0.07416058f, 0.01833368f, -0.06534053f, -0.05822111f, -0.02595988f, -0.02107463f, -0.07768090f, -0.02030304f, 
    -0.07139321f, 0.03614779f, 0.06059267f, 0.05771051f, 0.00617668f, 0.04242592f, -0.00824387f, 0.01426624f, 
    0.00347093f, 0.00334881f, 0.05144095f, -0.06770761f, -0.02905658f, -0.04662814f, -0.07984462f, 0.04185621f, 
    0.02882479f, 0.04872147f, -0.06067871f, 0.05567997f, -0.06394486f, -0.06844360f, 0.00713761f, 0.04955293f, 
    -0.03779769f, 0.02781059f, -0.04872892f, -0.06882994f, 0.04122352f, 0.06604318f, -0.05325775f, -0.07424144f, 
    0.00374347f, 0.02351675f, -0.07368533f, 0.03378889f, 0.05207439f, -0.06736662f, -0.07368061f, 0.03570009f, 
    0.00476854f, 0.02717771f, 0.00109918f, 0.04158803f, 0.05062865f, -0.01634603f, -0.05719134f, -0.07654592f, 
    -0.02924759f, -0.04618322f, -0.01868434f, -0.06896403f, -0.06187756f, -0.03535023f, -0.05584023f, -0.02837946f, 
    -0.00719236f, -0.02470539f, -0.01210740f, 0.00742689f, 0.02466122f, 0.04566498f, -0.05715956f, -0.03106348f, 
    0.04427808f, -0.06638174f, -0.02910101f, 0.03185600f, 0.00864759f, -0.05333317f, -0.06310347f, 0.01161672f, 
    -0.05556576f, -0.01345280f, -0.05813744f, -0.07617715f, 0.03349799f, 0.02106917f, 0.01621196f, 0.05754252f, 
    -0.05814708f, -0.06204688f, -0.00130397f, 0.06781463f, -0.05218811f, -0.00401218f, 0.02136704f, -0.05991904f, 
    0.04069989f, -0.04490131f, -0.07340351f, -0.02853782f, -0.00488884f, 0.03613843f, -0.00246888f, -0.02004378f, 
    0.02346350f, 0.01610380f, 0.03796398f, 0.06257883f, 0.02911636f, 0.02654185f, 0.05243379f, 0.03540391f, 
    -0.02248826f, 0.02539125f, -0.05543566f, -0.01327173f, 0.00583879f, 0.01035504f, 0.00631846f, -0.03245046f, 
    0.00587688f, -0.00417258f, 0.03575053f, 0.00345822f, -0.05949716f, 0.03727383f, -0.04190417f, 0.06135246f, 
    -0.08243594f, -0.04619412f, 0.02348225f, 0.02664008f, -0.06593037f, -0.02544009f, -0.00103867f, -0.00552882f, 
    0.01751607f, 0.03362642f, 0.05306429f, 0.01493242f, -0.01856138f, 0.01674463f, -0.02010526f, 0.02555007f, 
    0.03174985f, 0.04258654f, -0.04946017f, 0.04830782f, 0.00221840f, -0.01968100f, 0.04502521f, -0.01334998f, 
    -0.03633352f, 0.00682097f, -0.01241945f, 0.03722474f, -0.02525572f, -0.07996349f, 0.00776337f, 0.04788600f, 
    -0.05536262f, 0.00206642f, -0.02534600f, -0.05261252f, -0.02798151f, -0.08281573f, 0.05611007f, 0.04867916f, 
    -0.05458955f, 0.07144108f, 0.03925564f, -0.06565163f, -0.02182208f, -0.05885083f, -0.03505797f, -0.06913558f, 
    -0.05258128f, 0.06623150f, 0.04884099f, 0.01178394f, -0.04878022f, 0.01181425f, -0.07694999f, 0.00765027f, 
    -0.22949825f, 0.25512385f, 0.15811229f, -0.09445807f, -0.03425161f, -0.06805723f, -0.08889979f, -0.04843834f, 
    -0.04185342f, 0.15965658f, -0.05408302f, 0.14017695f, 0.02130607f, 0.16284834f, -0.18998896f, -0.03024156f, 
    0.07563239f, 0.10738866f, 0.05719185f, -0.09883976f, -0.00093460f, -0.01757158f, 0.18008868f, -0.07053434f, 
    0.17850029f, -0.09582762f, -0.13270125f, -0.13687551f, -0.02917409f, 0.03241307f, -0.04756944f, 0.01682725f, 
    -0.03045359f, 0.09317245f, 0.14775148f, -0.01786739f, 0.00994214f, 0.06017860f, 0.06735538f, -0.22606075f, 
    -0.04263914f, -0.17849077f, 0.04543015f, -0.14921536f, -0.02573619f, 0.06626039f, 0.04654054f, 0.09370346f, 
    0.17254122f, 0.07791500f, -0.00998092f, -0.03436206f, 0.07176062f, -0.06179264f, -0.02894770f, -0.02477736f, 
    0.07002411f, 0.07631406f, -0.01939988f, 0.16661255f, -0.04295309f, 0.03990205f, 0.17261094f, -0.14583826f, 
    -0.09651437f, -0.11413199f, -0.01600019f, -0.08165831f, 0.00193900f, -0.05969848f, -0.01843389f, 0.04321929f, 
    -0.17143922f, -0.17751729f, -0.20510358f, -0.05063379f, -0.00504387f, 0.08430684f, 0.13482511f, 0.03423313f, 
    0.09733372f, 0.06385206f, -0.03859307f, 0.08178578f, -0.01267129f, -0.25644138f, 0.15869065f, 0.08261847f, 
    0.04429006f, 0.05463460f, 0.07821482f, 0.01131731f, -0.05064197f, 0.02338977f, 0.06743149f, 0.03546769f, 
    0.10858173f, -0.12628703f, 0.03546602f, 0.05620635f, 0.11100427f, -0.02672942f, -0.04264523f, 0.07155526f, 
    0.07746794f, 0.11720679f, -0.07730953f, 0.04840477f, -0.02890955f, 0.07194361f, 0.07894754f, -0.03122300f, 
    -0.02596050f, -0.03002035f, 0.14582025f, -0.13923490f, -0.08588098f, 0.11161479f, 0.08883249f, -0.13843054f, 
    0.19900560f, -0.03984472f, -0.12960194f, 0.02215980f, 0.12012921f, -0.00898666f, -0.05724838f, 0.22979151f, 
    -0.09777772f, -0.06057741f, -0.09398133f, 0.00466258f, 0.17625697f, 0.13244528f, -0.12016603f, 0.06144986f, 
    0.10560442f, 0.07372626f, 0.09273184f, -0.02472973f, 0.16236596f, 0.00076580f, 0.06835607f, 0.10605217f, 
    0.04487113f, -0.05303571f, -0.01593510f, -0.01714239f, -0.02826035f, 0.10217427f, 0.01133097f, 0.06390855f, 
    0.05388368f, 0.19700937f, 0.01737002f, -0.04217550f, -0.18807918f, -0.12764503f, -0.24382199f, -0.03504504f, 
    0.10679015f, -0.05620492f, 0.03673033f, 0.01738327f, 0.04556701f, -0.01164619f, 0.02744702f, 0.01688191f, 
    -0.11381584f, -0.17957307f, -0.14377896f, 0.14401327f, 0.09984599f, 0.01618738f, 0.10537627f, 0.04257859f, 
    -0.06192846f, 0.05013865f, 0.14267285f, 0.15676416f, -0.03259225f, 0.15245099f, -0.18299942f, -0.26230672f, 
    -0.11820798f, 0.00683685f, -0.05528750f, -0.08894107f, -0.00347948f, -0.07562178f, -0.13381225f, -0.04608458f, 
    -0.42774236f, -0.46632960f, -0.29054162f, -0.18789557f, 0.04013810f, 0.02881529f, -0.07542278f, -0.02942398f, 
    0.04699605f, -0.03487153f, 0.03608055f, -0.06596645f, 0.01438265f, 0.03994109f, 0.17841902f, 0.02830282f, 
    -0.17082529f, -0.06203448f, 0.02235092f, 0.04269645f, -0.02427197f, -0.03440293f, 0.05054585f, 0.17890322f, 
    0.16025184f, 0.14412615f, 0.05651458f, 0.03797475f, 0.20960231f, 0.04917916f, 0.02334260f, 0.24900106f, 
    -0.08518936f, 0.00513734f, 0.01727276f, -0.14696206f, -0.10649121f, -0.29493269f, -0.13070500f, -0.02823320f, 
    0.22487193f, 0.02214350f, 0.00297108f, 0.00422503f, -0.07559705f, -0.08552919f, -0.09836355f, -0.02510250f, 
    -0.17381632f, -0.22398606f, -0.03638912f, -0.11976019f, 0.05293508f, -0.12471583f, -0.08700813f, 0.00082581f, 
    -0.03390560f, 0.03853444f, 0.01650581f, -0.14225231f, 0.13210143f, 0.03935209f, -0.00798302f, 0.04782534f, 
    0.02562505f, 0.04811941f, 0.00470249f, 0.22105837f, 0.09490744f, -0.01790865f, -0.04416145f, -0.14597166f, 
    0.13619876f, -0.05856325f, 0.17247896f, 0.29799542f, 0.24195352f, 0.03233419f, -0.00738998f, -0.07603005f, 
    -0.10245779f, 0.15580277f, -0.10048396f, 0.33351621f, -0.20289198f, 0.08108575f, -0.03829738f, 0.18547100f, 
    -0.05866249f, 0.07255795f, -0.09007346f, -0.04051221f, -0.01648204f, -0.08567961f, -0.11161806f, 0.10311700f, 
    0.10974891f, 0.06371892f, 0.11069708f, 0.07346165f, -0.09870031f, 0.02064984f, -0.14228804f, -0.04351387f, 
    -0.13155591f, -0.05386049f, -0.07925394f, 0.06782854f, -0.15251251f, -0.20850739f, -0.12641992f, -0.00878282f, 
    0.08102742f, 0.05232376f, 0.01127471f, -0.03494427f, 0.12113070f, 0.00531414f, 0.08280656f, 0.31863940f, 
    0.38780126f, 0.31196657f, 0.27988178f, 0.02844264f, 0.01296758f, 0.11980105f, 0.11993214f, 0.02824594f, 
    0.24615039f, -0.00488204f, 0.00620040f, -0.09099434f, -0.11498656f, 0.00139442f, 0.17551580f, 0.06307342f, 
    0.01494667f, -0.07808555f, 0.01035725f, 0.15874420f, -0.15826799f, -0.12456857f, -0.03881189f, -0.12424512f, 
    0.19994260f, -0.01001916f, 0.05791054f, -0.23558359f, -0.02281594f, -0.01408981f, -0.06104764f, 0.00700854f, 
    -0.02379458f, -0.01696116f, -0.18376245f, -0.05311901f, 0.38629186f, 0.08182981f, 0.11926584f, 0.17448153f, 
    0.07032661f, 0.19519106f, 0.04592689f, 0.01578559f, -0.18252155f, 0.07550025f, 0.00512976f, 0.01029279f, 
    0.10916336f, 0.35482550f, 0.04328229f, 0.12578294f, 0.08085281f, -0.04491255f, 0.05610871f, -0.01769305f, 
    -0.08041248f, -0.17237282f, 0.03488708f, -0.03585882f, 0.05532185f, -0.01548417f, 0.00298960f, 0.04878855f, 
    0.20658384f, 0.07401016f, 0.08148080f, 0.10327531f, -0.01434673f, 0.07767978f, 0.03505623f, 0.00891658f, 
    -0.04816529f, 0.19011925f, 0.25302991f, -0.31177738f, -0.08589929f, 0.00261262f, -0.05943560f, 0.04573036f, 
    -0.00526632f, 0.10821485f, 0.14094816f, 0.07723861f, -0.02972200f, -0.20694697f, 0.01638534f, 0.11117952f, 
    -0.04683778f, 0.13637243f, -0.14482045f, -0.06611195f, 0.07913696f, -0.09591798f, -0.02936037f, 0.05231731f, 
    -0.29768777f, 0.39673230f, 0.08970395f, 0.01626320f, -0.15341963f, -0.11939741f, 0.00975702f, 0.02650327f, 
    -0.02453159f, 0.00964322f, 0.03963653f, -0.09907531f, 0.04779431f, 0.14751874f, -0.12519838f, -0.00759469f, 
    0.08318327f, 0.05668768f, 0.13066857f, 0.04876530f, 0.01224855f, 0.03855660f, 0.12350075f, 0.04152855f, 
    -0.16131383f, 0.18999323f, -0.01038183f, -0.25569555f, -0.04040859f, 0.05210264f, 0.07192890f, -0.10124470f, 
    0.12054721f, 0.16812713f, 0.06546566f, 0.21829925f, -0.16461740f, 0.03216890f, 0.06994572f, -0.07858209f, 
    0.10717127f, -0.21338667f, 0.06990366f, 0.03452670f, -0.09975442f, -0.00293455f, -0.00461478f, 0.06932045f, 
    0.04185666f, 0.20095825f, 0.02155557f, 0.17650253f, -0.11139336f, -0.07551333f, 0.02823780f, -0.04793154f, 
    -0.00880894f, 0.03513635f, -0.22667626f, 0.13970958f, 0.15794340f, 0.32929730f, 0.29179579f, 0.01978455f, 
    0.14964594f, 0.03563225f, 0.04831478f, 0.08974247f, 0.02974439f, 0.08819287f, 0.09512183f, -0.08030163f, 
    -0.18546745f, -0.11047403f, -0.26824090f, -0.10847253f, 0.07379238f, 0.07766604f, -0.14531422f, -0.00153466f, 
    -0.05843287f, -0.01820604f, -0.13532563f, 0.08115409f, -0.10683198f, 0.12025180f, 0.01712226f, -0.02452446f, 
    -0.04026386f, -0.10951031f, -0.02444577f, -0.14384650f, 0.26352468f, 0.09620617f, -0.00417744f, 0.18823856f, 
    -0.50584608f, 0.31202906f, -0.41370285f, 0.22368343f, -0.07364788f, -0.07962231f, -0.11813507f, 0.20476978f, 
    -0.29520831f, -0.11160500f, -0.06240983f, 0.04275972f, -0.18579209f, 0.02640866f, -0.31762636f, 0.07149601f, 
    -0.37783203f, -0.04018319f, 0.11947226f, 0.04086069f, -0.00005852f, -0.13638525f, 0.14079639f, -0.29613352f, 
    0.12995714f, 0.16494325f, 0.20159495f, 0.11376276f, 0.06374627f, 0.08286509f, 0.07787295f, 0.26382288f, 
    -0.12836875f, 0.13967817f, -0.03581396f, 0.13524307f, -0.13245015f, -0.10493066f, 0.20062976f, 0.23342076f, 
    0.04136094f, -0.05241964f, 0.09944434f, 0.04914830f, 0.15422659f, 0.14392610f, 0.03080557f, -0.29361719f, 
    0.04429131f, 0.07225930f, -0.00953281f, 0.31784996f, -0.07307359f, 0.08064247f, 0.17895178f, 0.06361095f, 
    -0.20225932f, 0.02007177f, 0.01788708f, -0.08732272f, 0.16104341f, 0.21470892f, 0.06176092f, -0.14103253f, 
    0.04695818f, 0.15380920f, 0.04757933f, 0.01223171f, -0.15658662f, -0.02568583f, -0.05817299f, 0.07548764f, 
    -0.00854300f, -0.01795175f, -0.26115400f, 0.03892133f, 0.05984525f, 0.12593420f, 0.21812354f, -0.05273439f, 
    0.13200615f, 0.01910564f, 0.08081231f, 0.07250912f, -0.16884258f, -0.23954521f, 0.14806400f, 0.05337560f, 
    -0.01096313f, 0.04214470f, -0.12771574f, 0.07845132f, 0.04578431f, 0.03984069f, 0.07990504f, -0.04818464f, 
    0.06793223f, 0.32637462f, 0.04592681f, -0.03813316f, 0.04825065f, 0.05714446f, -0.03451021f, 0.01064171f, 
    0.06072806f, 0.11428079f, 0.22273383f, 0.22852476f, 0.02507620f, 0.07300290f, 0.09138720f, -0.02256424f, 
    0.08242468f, -0.05428633f, -0.02954782f, -0.09651118f, 0.01641280f, 0.13709055f, 0.17733091f, 0.29203936f, 
    0.15904923f, 0.27354869f, -0.19992635f, 0.19975308f, -0.02929453f, -0.09864870f, -0.06241740f, 0.01398387f, 
    0.10606474f, -0.00187441f, -0.05096626f, 0.04295587f, -0.16267242f, -0.09211010f, -0.09489574f, 0.02285023f, 
    0.09830495f, 0.05994645f, 0.14251138f, 0.12115920f, 0.14481622f, -0.13692671f, -0.10269477f, -0.01609058f, 
    -0.24695386f, 0.43919486f, 0.12694484f, 0.02499690f, -0.00105890f, 0.06280182f, -0.08591259f, 0.22271954f, 
    0.03417913f, 0.03675452f, 0.14338008f, -0.04847816f, 0.16168258f, 0.45945567f, 0.00823853f, 0.10070426f, 
    0.12329124f, 0.06614064f, 0.15250792f, -0.04722447f, 0.12138151f, 0.11310770f, 0.18870677f, 0.00423386f, 
    -0.04606858f, -0.19312777f, -0.29134145f, 0.22707111f, -0.02697355f, 0.08749553f, 0.16621761f, -0.08010471f, 
    0.00643896f, 0.03267813f, 0.04996859f, 0.09614320f, -0.14958557f, -0.06896349f, -0.30438745f, -0.08684956f, 
    -0.02791100f, -0.04225900f, 0.07374571f, -0.08242355f, 0.27260214f, 0.13337159f, 0.05714711f, -0.00847140f, 
    -0.23422030f, -0.09827427f, -0.17288867f, 0.29475892f, -0.00654871f, -0.11123068f, 0.00946854f, -0.01197259f, 
    -0.09516706f, -0.12419911f, -0.20622724f, -0.11458628f, -0.18050376f, -0.13621761f, -0.02376881f, 0.13526976f, 
    0.17280339f, -0.00452948f, -0.02649777f, 0.30403876f, -0.08269794f, -0.17481910f, -0.02995508f, 0.00269648f, 
    0.10691594f, 0.26282537f, 0.08179991f, 0.30888724f, -0.03614227f, 0.09910465f, -0.05237687f, -0.00449662f, 
    0.11222781f, -0.07790008f, 0.10623492f, 0.08039666f, -0.25430369f, -0.13409412f, 0.02388966f, -0.04643799f, 
    -0.03133413f, -0.08079568f, 0.06982005f, 0.14389995f, -0.01014230f, -0.12395570f, -0.06391653f, 0.07303568f, 
    -0.12331799f, 0.17545909f, 0.09839339f, 0.06066894f, 0.01052688f, -0.03890981f, 0.10101049f, -0.04496571f, 
    -0.10599588f, 0.07706013f, -0.03039748f, -0.03386459f, 0.08328203f, -0.07023409f, 0.26067513f, -0.25514302f, 
    -0.01022182f, -0.00554747f, -0.17508820f, 0.18121472f, 0.04086354f, 0.00705555f, 0.10618359f, 0.02109588f, 
    0.25656581f, 0.05259129f, 0.17469746f, 0.07715381f, -0.06890886f, 0.11578728f, -0.03225712f, -0.06339632f, 
    -0.12451104f, 0.03070507f, -0.02122411f, 0.02457635f, -0.13083445f, -0.04743760f, -0.16607931f, 0.26576531f, 
    0.10612538f, 0.24005046f, 0.11838121f, 0.01334555f, -0.00748957f, 0.02344191f, 0.22664841f, 0.09006739f, 
    -0.25744569f, -0.14473943f, -0.05427545f, 0.05014910f, -0.07771776f, -0.10358615f, -0.00964494f, -0.04147978f, 
    0.07656313f, 0.07716709f, 0.09617315f, 0.01096112f, -0.00884767f, 0.13845748f, -0.04599557f, 0.10978898f, 
    0.00915214f, -0.00594212f, -0.00098747f, 0.06003038f, -0.03661495f, 0.02523980f, -0.09947336f, -0.03794447f, 
    0.00527505f, 0.21025418f, -0.06174059f, -0.11503721f, -0.01394191f, -0.07032505f, 0.13421834f, 0.01409895f, 
    0.02411234f, 0.27369574f, 0.04214785f, 0.10334773f, -0.07322308f, -0.16702467f, 0.05737323f, -0.14939408f, 
    0.01002113f, -0.15532762f, -0.05335633f, 0.03752384f, -0.01472598f, 0.01940826f, -0.03214335f, -0.00214411f, 
    -0.16716225f, 0.39158499f, 0.18381757f, -0.04968899f, -0.13718550f, -0.07195497f, 0.09092011f, 0.02441246f, 
    0.00571315f, 0.04904995f, -0.05839599f, 0.16852459f, 0.15697642f, 0.34976068f, 0.37575513f, 0.15730512f, 
    0.24971305f, -0.09677449f, 0.08292115f, 0.07836502f, 0.05623705f, -0.01852881f, 0.17920893f, 0.06161805f, 
    -0.01131666f, -0.08439665f, -0.28490564f, -0.08074137f, 0.03477370f, -0.05671152f, 0.03625674f, 0.00231263f, 
    0.02283187f, 0.01206706f, 0.11554348f, -0.07655670f, 0.11597223f, 0.01819922f, -0.11072278f, -0.08671941f, 
    -0.01006317f, -0.00657231f, 0.03379186f, 0.01220543f, -0.07109766f, 0.11308292f, 0.00731008f, -0.05407471f, 
    -0.21650605f, -0.37882912f, -0.34928969f, 0.04206562f, 0.07995204f, -0.15265167f, -0.06502898f, 0.05290701f, 
    -0.05362429f, 0.04228307f, -0.02177284f, 0.01132297f, -0.07166450f, 0.08819734f, -0.17187195f, 0.18560518f, 
    -0.12994042f, 0.03691067f, 0.06135565f, 0.12124555f, 0.03449551f, 0.02827967f, 0.09662951f, -0.07072121f, 
    -0.04060130f, 0.02460088f, -0.00195101f, 0.25589204f, 0.09125591f, 0.06206152f, 0.00122230f, 0.01362903f, 
    0.14988339f, 0.08049969f, 0.12948158f, 0.07354453f, -0.14990447f, -0.11944328f, 0.03173624f, 0.11714401f, 
    0.17172055f, -0.14546098f, 0.09691997f, -0.01312248f, -0.02566119f, 0.10403708f, -0.00027496f, 0.11491376f, 
    -0.03220992f, 0.08001496f, -0.08447242f, 0.03825585f, 0.09246012f, 0.00540399f, -0.04824848f, 0.07379033f, 
    0.02304088f, 0.14389314f, -0.00518703f, -0.04304677f, -0.10679585f, -0.09200393f, 0.06941252f, 0.00248871f, 
    -0.08590041f, -0.06206699f, -0.00180433f, -0.05136057f, -0.07540181f, -0.04458987f, -0.07354192f, 0.08277041f, 
    -0.27987516f, -0.06186609f, 0.20793928f, 0.20909695f, -0.00662811f, 0.05146771f, -0.05052369f, 0.07539856f, 
    0.09446933f, -0.02446909f, -0.02775409f, 0.00234001f, 0.08355503f, 0.20526509f, -0.03528674f, -0.05855453f, 
    -0.03661668f, -0.10966023f, 0.06638247f, -0.12410107f, 0.02841757f, 0.09088401f, 0.01931739f, -0.02274838f, 
    0.14435144f, -0.18315333f, -0.27189526f, 0.03246045f, 0.10372885f, -0.08985952f, 0.06594196f, 0.06793220f, 
    0.03036110f, 0.10934287f, 0.05366134f, -0.06446134f, -0.04919960f, 0.01356262f, 0.08974482f, 0.03021431f, 
    0.00118780f, -0.20957339f, -0.03403709f, -0.03438212f, 0.00619521f, 0.02015986f, 0.03107347f, -0.02595213f, 
    0.30705985f, 0.23592755f, -0.22601153f, 0.19806169f, 0.00221591f, -0.10167667f, 0.03793192f, -0.06126131f, 
    -0.09519216f, 0.02737230f, 0.08200008f, -0.14943337f, -0.32958794f, -0.16735902f, 0.16045371f, -0.21338649f, 
    0.09332704f, -0.02069394f, -0.04960096f, 0.06002267f, 0.07273190f, -0.18188305f, 0.08574183f, 0.02306528f, 
    -0.10620262f, 0.29974309f, 0.08955935f, 0.08707421f, -0.02378952f, 0.08767689f, 0.09456827f, -0.05730861f, 
    0.08245555f, -0.00345334f, -0.04687614f, 0.11354789f, -0.10013883f, 0.27129352f, 0.15503229f, 0.18247701f, 
    0.23780701f, 0.08591406f, -0.10904645f, 0.07057383f, 0.07111764f, 0.10946726f, -0.00972905f, 0.07388510f, 
    0.20828687f, -0.19429603f, 0.05911155f, -0.01937582f, 0.12040064f, 0.08035271f, -0.09422090f, -0.04915154f, 
    0.00311209f, 0.03957789f, -0.01903562f, -0.04645287f, -0.31200171f, -0.07194304f, -0.18346106f, -0.06847263f, 
    -0.05743384f, -0.00499227f, 0.06381237f, -0.00567385f, 0.09539056f, 0.07445925f, 0.21477500f, 0.04315082f, 
    0.24287158f, -0.41385791f, -0.06873014f, 0.09303620f, 0.00696333f, -0.00822075f, 0.00321859f, -0.08447935f, 
    0.13200925f, -0.19452022f, -0.05607600f, -0.08183473f, 0.08293378f, 0.16798532f, 0.07552826f, 0.22464535f, 
    -0.01598371f, -0.07179853f, -0.08270208f, 0.09985808f, 0.03742133f, -0.13664868f, -0.02783636f, 0.02881208f, 
    0.10616080f, 0.01918978f, -0.20025063f, 0.20233409f, -0.00151911f, -0.08032106f, 0.03037433f, -0.00898845f, 
    0.25554347f, 0.12678422f, 0.06572319f, -0.02935058f, -0.11230970f, -0.13943303f, 0.02430572f, 0.02470664f, 
    0.02648399f, 0.07785100f, 0.09531873f, 0.03802149f, -0.03084733f, -0.01488972f, -0.15868305f, 0.13997167f, 
    -0.04957631f, 0.06751333f, -0.16470712f, 0.10293821f, 0.15682311f, 0.13298759f, 0.00397384f, -0.04576761f, 
    0.06694547f, 0.01222717f, -0.10323676f, -0.05763989f, 0.04602464f, -0.05455668f, 0.16001061f, -0.13705952f, 
    -0.08624779f, -0.01449000f, -0.07703287f, 0.22464882f, 0.12912655f, -0.01933449f, 0.07505582f, -0.00714614f, 
    -0.05023527f, -0.01936289f, -0.07170982f, 0.05468679f, 0.03055673f, 0.04074206f, 0.01753570f, -0.03226650f, 
    -0.07481795f, 0.06189358f, 0.01576403f, -0.04861634f, 0.04545658f, 0.04220257f, 0.04432911f, 0.03639061f, 
    0.04125689f, -0.06309161f, -0.07114583f, -0.07242319f, 0.02109601f, -0.04420855f, -0.03972314f, -0.06789026f, 
    0.02102250f, -0.00734324f, -0.05636537f, -0.03911280f, -0.00850600f, -0.00987975f, -0.02563130f, -0.04036025f, 
    0.00159751f, 0.05469093f, 0.00879919f, -0.00911733f, -0.06493165f, -0.05170102f, -0.03901964f, 0.05417005f, 
    -0.01689682f, -0.00434676f, -0.03037265f, -0.00533086f, -0.02967355f, 0.06390271f, -0.06576879f, 0.02817169f, 
    -0.02642977f, 0.01006194f, -0.07358328f, -0.01200788f, -0.04071843f, 0.05125379f, 0.01686594f, -0.02146405f, 
    -0.01558046f, -0.05701056f, 0.02154719f, 0.02405098f, -0.05535831f, -0.06831597f, 0.05620112f, 0.00353015f, 
    0.03951174f, 0.05953258f, -0.05914204f, -0.05223867f, 0.06108256f, -0.08107854f, -0.01280134f, -0.00753675f, 
    0.05369695f, 0.03654703f, 0.04364630f, -0.03289606f, 0.03136228f, -0.07345326f, -0.03283355f, 0.02484913f, 
    0.03718734f, 0.04400939f, 0.00399976f, -0.06700687f, 0.06003755f, -0.02364153f, -0.02255039f, -0.01096878f, 
    0.04435474f, -0.04931353f, -0.02479198f, -0.07231860f, 0.05909324f, -0.06431653f, 0.04843613f, -0.04707355f, 
    -0.05039150f, -0.04218368f, 0.05013586f, -0.05080186f, 0.04723488f, 0.01897786f, -0.05493698f, 0.04645986f, 
    -0.04097582f, 0.02349950f, -0.01450434f, -0.06404047f, 0.05485180f, -0.03731585f, -0.07524110f, 0.04290190f, 
    0.00056367f, 0.04910440f, 0.02004488f, 0.00785044f, -0.05067354f, -0.04653289f, 0.04481049f, -0.01683271f, 
    0.01504300f, 0.01106070f, 0.04071979f, -0.07064164f, 0.00684088f, -0.01288471f, 0.06704351f, -0.04316603f, 
    -0.05028830f, -0.02703021f, -0.04642639f, 0.00730763f, -0.03007147f, 0.05849556f, -0.04100235f, 0.05892565f, 
    -0.01312129f, -0.00971399f, 0.02065866f, -0.00519943f, -0.06081010f, -0.06180272f, 0.01395497f, -0.00387107f, 
    -0.00222319f, 0.03899648f, 0.04954365f, -0.01248088f, -0.07328641f, -0.02415005f, -0.02637195f, 0.06155880f, 
    -0.03472354f, 0.02849066f, -0.02275664f, -0.04781168f, 0.00038051f, -0.04696466f, -0.01568781f, -0.01244176f, 
    -0.04139807f, 0.00228251f, -0.07189729f, -0.05350349f, 0.00452651f, -0.04768021f, -0.07991112f, 0.01249360f, 
    0.00308903f, -0.06038681f, -0.05668782f, -0.03543162f, -0.01237472f, 0.05443037f, -0.05449085f, 0.04297595f, 
    -0.01858876f, -0.00860942f, -0.05099971f, -0.02999919f, 0.02838913f, -0.06182260f, -0.06989493f, 0.04433893f, 
    -0.00791988f, -0.00653533f, 0.03545032f, 0.04516397f, -0.05193461f, 0.01522252f, 0.04648266f, -0.06546255f, 
    -0.48280892f, -0.19505942f, 0.06960528f, -0.24698184f, -0.01478069f, -0.11121781f, -0.27056360f, 0.11198552f, 
    0.13159916f, -0.07134520f, 0.07477673f, -0.02499237f, 0.10580326f, 0.18938862f, 0.11232229f, 0.06302707f, 
    0.17220791f, -0.02521681f, 0.05083775f, 0.08510609f, 0.08434762f, -0.00019269f, -0.14936711f, -0.05811044f, 
    0.15357172f, -0.04164033f, -0.26355216f, -0.05243541f, -0.07494867f, -0.03201813f, -0.01438050f, 0.01010151f, 
    0.15403946f, 0.06663628f, 0.06402963f, -0.12382183f, -0.16987646f, -0.22664629f, -0.25038162f, -0.18876512f, 
    -0.06176307f, -0.01940580f, 0.00166604f, 0.07158102f, 0.06646046f, -0.08282650f, -0.01239190f, -0.18066177f, 
    -0.04077173f, 0.01393537f, -0.35908961f, -0.18384004f, -0.04020620f, 0.13059486f, -0.13969527f, -0.06373275f, 
    -0.00419923f, 0.01055402f, -0.02379668f, -0.00649066f, -0.22486630f, -0.20881417f, 0.02566726f, -0.16774650f, 
    0.00732340f, -0.02212520f, 0.07667746f, 0.09145575f, 0.00733427f, 0.05863987f, 0.16061525f, 0.13255091f, 
    0.06755134f, 0.11210997f, 0.12231245f, 0.34974846f, -0.02792329f, 0.00191069f, 0.05744458f, -0.03653473f, 
    -0.11226425f, 0.14191008f, -0.10521220f, 0.21724489f, -0.13374554f, 0.21051316f, 0.10356661f, 0.09230036f, 
    -0.10341072f, -0.03615477f, -0.04079989f, 0.10830882f, 0.06424996f, 0.00698555f, 0.00406076f, 0.16116935f, 
    0.05253700f, -0.14677210f, 0.12446804f, 0.06167873f, 0.08949319f, 0.17692272f, -0.09280717f, 0.06667549f, 
    0.03202807f, -0.02240822f, -0.04453446f, 0.02210508f, -0.25869465f, -0.21285549f, -0.13508187f, -0.10225394f, 
    -0.00739486f, 0.00646293f, -0.17123316f, -0.02565942f, 0.05495131f, -0.09953979f, -0.03897069f, 0.14437768f, 
    0.02581083f, 0.15111749f, -0.04513216f, 0.06188549f, 0.00689641f, 0.15616632f, -0.08118974f, 0.19481251f, 
    0.11709595f, -0.01986824f, 0.09074463f, 0.06627399f, -0.29708478f, -0.08268561f, -0.10237326f, -0.02207985f, 
    -0.05272147f, -0.00971796f, 0.08782689f, 0.05189531f, 0.03831803f, 0.05750272f, 0.06753343f, -0.01138855f, 
    0.34499869f, 0.16046578f, 0.14738169f, -0.06147349f, 0.02797497f, 0.09937080f, 0.03336037f, 0.03346292f, 
    0.00539555f, 0.11604867f, -0.07934234f, 0.09913085f, 0.39527306f, 0.13690683f, 0.15334837f, 0.35094458f, 
    0.11089539f, 0.10484002f, -0.00326404f, 0.11343617f, -0.01315992f, 0.13225903f, -0.03648450f, 0.03150802f, 
    0.23322353f, 0.19067881f, 0.04518791f, 0.33097434f, -0.15341060f, 0.15380044f, 0.04313095f, 0.04116548f, 
    -0.00355614f, -0.04564193f, -0.09953634f, -0.03834884f, -0.15966222f, -0.17267510f, -0.10808839f, -0.20512515f, 
    0.06928933f, -0.24720404f, 0.07860649f, 0.04198245f, 0.00484885f, 0.07051588f, 0.08009851f, 0.12183212f, 
    0.27611223f, -0.02527548f, 0.15605450f, 0.16674078f, 0.02543135f, 0.20384462f, 0.10045461f, 0.07516780f, 
    -0.10968783f, 0.03642930f, -0.06305581f, 0.00331319f, -0.11114633f, -0.17982952f, -0.20631836f, 0.26538518f, 
    0.06748889f, 0.16945402f, 0.19104056f, -0.08252088f, -0.03702191f, 0.12840542f, 0.14566912f, 0.14269768f, 
    -0.10272528f, -0.09426209f, 0.13073653f, -0.04836756f, 0.06743803f, -0.04550724f, -0.12608391f, 0.01387935f, 
    0.22584824f, -0.10636318f, 0.01573193f, 0.10367188f, 0.13100356f, -0.00297612f, 0.08075695f, 0.14469460f, 
    0.02019256f, -0.01383678f, 0.01077302f, 0.13213974f, -0.03554903f, -0.03050775f, -0.09715443f, -0.11537171f, 
    -0.01616203f, 0.12777711f, 0.00718526f, -0.00076338f, -0.00325160f, -0.04771341f, 0.09328615f, 0.11899583f, 
    0.06927745f, 0.22477156f, -0.07235403f, 0.08620165f, 0.09809026f, -0.11446297f, 0.12206697f, -0.03628730f, 
    0.11089082f, -0.00630547f, 0.02993709f, 0.06806434f, 0.03180633f, -0.05972032f, 0.01392664f, -0.05223103f, 
    -0.14355826f, 0.29126543f, 0.16455528f, -0.20615104f, -0.13131836f, 0.01482735f, -0.04065737f, -0.08408664f, 
    0.02917869f, 0.10098794f, 0.16976614f, 0.14326896f, 0.20048995f, 0.10385405f, 0.17937842f, 0.08142000f, 
    0.28431460f, -0.04922379f, 0.15510389f, 0.03908210f, 0.17706852f, -0.12160094f, 0.15561211f, 0.05054422f, 
    -0.06553102f, -0.05466286f, -0.35594207f, -0.23088819f, -0.01965984f, -0.23554265f, 0.11025507f, -0.14714256f, 
    0.00029163f, -0.12185607f, 0.17208739f, 0.07294721f, 0.10180451f, 0.06028740f, -0.17669322f, -0.06800059f, 
    -0.03441388f, 0.03976380f, 0.11995409f, 0.07563922f, -0.05450623f, 0.02645043f, 0.02590903f, -0.00091328f, 
    -0.31364918f, -0.42478260f, -0.06918041f, -0.03902926f, 0.01948561f, -0.20036472f, -0.09205849f, -0.23445722f, 
    0.01018089f, -0.02572901f, -0.05869320f, 0.00313272f, 0.00985407f, -0.04756853f, -0.12859350f, 0.04849835f, 
    0.05647830f, -0.06399275f, -0.15785457f, 0.23963432f, -0.03141593f, -0.04879054f, 0.01726755f, -0.02827013f, 
    -0.40961885f, -0.18710364f, 0.01843162f, 0.09802701f, 0.05309910f, 0.02380844f, -0.01038521f, -0.19927885f, 
    0.12922530f, 0.02962622f, 0.03148435f, 0.18160354f, -0.20664676f, -0.05734909f, 0.03651796f, -0.20979849f, 
    -0.16932470f, -0.35672858f, -0.03449307f, -0.15040781f, -0.04648548f, -0.01432427f, 0.00814409f, 0.05414083f, 
    -0.07968453f, 0.12007848f, 0.03322686f, -0.42713708f, -0.01320691f, -0.17025916f, -0.23989877f, 0.01933434f, 
    0.06598435f, 0.12541182f, -0.12700672f, -0.12633276f, -0.18042001f, -0.04247387f, 0.03582311f, 0.12096366f, 
    0.14773549f, -0.06707730f, 0.09000447f, 0.07616767f, 0.17739989f, 0.12430262f, -0.06780475f, 0.03564215f, 
    0.17899910f, -0.05056826f, 0.09993535f, 0.16677272f, 0.02803058f, 0.05755096f, 0.03353463f, 0.01321365f, 
    0.00889737f, -0.02980522f, -0.03140743f, -0.09723501f, 0.18753049f, 0.29821447f, 0.04668217f, -0.04152539f, 
    0.10295944f, -0.10384065f, -0.04529558f, -0.01196281f, 0.06834389f, -0.05836134f, -0.02680522f, -0.12777589f, 
    -0.37024701f, -0.14225493f, 0.00546774f, 0.10905749f, 0.01264252f, -0.07001196f, 0.03344837f, -0.14464967f, 
    0.12303141f, 0.03684448f, 0.01526432f, -0.09224355f, 0.05313128f, 0.05846433f, 0.05905703f, 0.23038833f, 
    -0.17644951f, 0.05130378f, -0.02796361f, -0.07681164f, 0.14120911f, 0.00955356f, 0.08870210f, 0.01357468f, 
    -0.03798293f, -0.16519657f, -0.00530020f, -0.03025661f, 0.18848927f, 0.01948122f, -0.05103907f, -0.10574473f, 
    0.12247317f, -0.12512553f, -0.00785810f, 0.14173530f, 0.04770469f, -0.09667514f, -0.15360121f, -0.15657946f, 
    0.19884910f, 0.17365590f, 0.11725712f, -0.06592479f, 0.14742224f, 0.05167008f, 0.10866457f, 0.23088631f, 
    0.24425007f, -0.01647908f, -0.20582798f, -0.34833235f, -0.03430314f, 0.04473640f, -0.04828459f, -0.08586317f, 
    -0.16103029f, -0.05335025f, 0.02633093f, -0.04488022f, 0.35477218f, -0.15467842f, 0.01356924f, -0.15861897f, 
    0.11178383f, -0.05904777f, 0.32325390f, 0.06617106f, 0.06677429f, 0.07662679f, 0.14444512f, 0.10636237f, 
    0.02318087f, 0.15295529f, 0.18817939f, -0.37228927f, 0.01155076f, -0.02496731f, -0.06618235f, 0.20354284f, 
    0.07717944f, -0.10696607f, 0.05362951f, 0.00954160f, -0.11886790f, -0.05353499f, 0.00242060f, -0.08175084f, 
    0.00777269f, -0.06054138f, -0.14987411f, 0.08918480f, -0.29116914f, -0.01500439f, -0.07204106f, -0.24845766f, 
    0.02004215f, 0.02882944f, -0.07057738f, 0.04783565f, 0.18785927f, -0.10863802f, -0.02182768f, -0.09643213f, 
    -0.10524979f, -0.19315739f, 0.00968877f, -0.06960770f, 0.30379012f, 0.03319263f, 0.06237701f, -0.03286108f, 
    0.00657406f, 0.04635021f, 0.04000865f, -0.17118658f, 0.24884464f, 0.11123671f, -0.09902510f, 0.02087562f, 
    -0.06294783f, 0.02974108f, -0.05920719f, -0.04419822f, 0.14723654f, -0.05806956f, 0.13404277f, 0.16962738f, 
    -0.05939040f, 0.01720183f, 0.10939965f, 0.09152817f, 0.14743496f, 0.12822041f, 0.06988476f, -0.13919209f, 
    0.15569103f, 0.11233611f, -0.05055574f, -0.11976679f, -0.00910592f, -0.09794648f, 0.07671192f, -0.03669370f, 
    0.15365560f, 0.01354446f, 0.01389408f, -0.15663074f, 0.08711608f, 0.10889317f, 0.05431958f, 0.06633185f, 
    0.05063641f, 0.05640689f, -0.03036923f, 0.11117377f, -0.26848343f, -0.29311401f, -0.04468345f, 0.30728391f, 
    -0.02535149f, -0.06119075f, -0.12144229f, -0.08882641f, 0.01108592f, 0.07012053f, 0.14082181f, 0.15980487f, 
    -0.06122683f, -0.06055339f, 0.02082441f, 0.03044420f, -0.00848204f, -0.03145575f, 0.06254575f, -0.06462355f, 
    0.02897987f, -0.02789305f, -0.00967308f, -0.03039793f, 0.01476926f, 0.04860163f, -0.08265982f, -0.04754674f, 
    -0.00441100f, 0.05519621f, 0.00634017f, -0.08074557f, -0.07900307f, -0.06824069f, 0.05921191f, -0.03257043f, 
    -0.04967413f, -0.04320050f, 0.03034220f, -0.03755810f, -0.01876251f, -0.01752510f, -0.03832813f, -0.03925700f, 
    -0.01339989f, 0.03022574f, 0.01399246f, 0.02066342f, -0.00705532f, -0.07812733f, -0.02839141f, 0.03011375f, 
    0.02310134f, 0.02931190f, -0.00131200f, -0.01826945f, 0.02040661f, 0.01768403f, 0.01451458f, -0.02941220f, 
    0.03589572f, -0.00340967f, -0.02093947f, 0.01530663f, -0.04133149f, 0.03982496f, -0.07506803f, -0.03367143f, 
    -0.07731644f, -0.00266954f, 0.01714184f, -0.02192407f, 0.00247308f, 0.03143942f, -0.04193611f, 0.03618711f, 
    0.03551022f, 0.01858503f, -0.06708790f, -0.01533871f, -0.00761634f, 0.03448170f, 0.01148306f, 0.04976087f, 
    0.04372023f, 0.00571071f, -0.07007369f, 0.01003234f, -0.04859226f, -0.08110438f, 0.03383022f, 0.03673777f, 
    0.02770411f, 0.04299790f, -0.07704653f, 0.04041463f, -0.06157562f, 0.04223055f, -0.05291846f, -0.08684102f, 
    0.02415705f, -0.05670136f, -0.01693998f, 0.04492595f, -0.00904740f, -0.01556493f, 0.01564968f, -0.07207233f, 
    -0.01321927f, -0.03332634f, 0.00196387f, 0.07048712f, -0.01672425f, -0.00427059f, -0.06989662f, -0.05233465f, 
    0.03300247f, 0.01934806f, 0.01496643f, 0.02797962f, -0.00694913f, 0.03123474f, -0.06628020f, 0.04582051f, 
    -0.00337788f, -0.05949049f, -0.04196078f, -0.03669637f, -0.01753028f, 0.00999037f, 0.05103860f, -0.03430367f, 
    -0.07614370f, -0.05131825f, 0.04999416f, 0.00931733f, 0.05217082f, 0.01289023f, 0.04173680f, -0.00745359f, 
    0.00975966f, -0.04160083f, 0.02701115f, -0.03165960f, -0.00805357f, -0.05639767f, -0.06121350f, -0.02224523f, 
    -0.04288674f, -0.08520012f, -0.04838331f, 0.05253608f, -0.07303794f, 0.02346183f, 0.02203717f, 0.02733514f, 
    -0.00754084f, -0.05951200f, -0.06724758f, -0.02073434f, 0.04692366f, -0.00805980f, 0.00206576f, -0.08438095f, 
    -0.09329506f, -0.09126066f, -0.06824232f, -0.07030360f, 0.00798037f, -0.06850387f, -0.05552752f, -0.00585587f, 
    0.04929420f, -0.06659299f, 0.00250703f, -0.06647878f, 0.00155339f, 0.05122902f, -0.05853019f, 0.03719908f, 
    -0.00147601f, 0.04620079f, -0.04866397f, -0.07608420f, -0.03912780f, 0.04191569f, 0.03540973f, 0.03899042f, 
    -0.03198730f, -0.03260883f, -0.05502155f, -0.08951541f, -0.07312908f, 0.03278697f, -0.07764427f, -0.03872985f, 
    0.04476712f, -0.04322513f, -0.02878366f, 0.03703680f, -0.07371508f, 0.00870328f, -0.03449966f, -0.02135123f, 
    -0.15170144f, -0.20595330f, 0.15217510f, -0.10265206f, -0.05785439f, -0.03878349f, -0.11132538f, -0.13149077f, 
    0.09536784f, -0.17779885f, 0.12089898f, 0.06789857f, -0.20008337f, -0.02127384f, 0.13072391f, 0.15216988f, 
    0.04563837f, 0.12482324f, 0.01778894f, -0.01130986f, 0.17676513f, 0.13520813f, -0.00401907f, 0.12535642f, 
    0.25652865f, 0.13176689f, -0.06486241f, 0.01211224f, 0.06570949f, -0.07145225f, -0.15900399f, -0.00969999f, 
    0.05700232f, 0.01157513f, -0.02277049f, -0.09057083f, -0.12627925f, -0.14445783f, -0.17317557f, -0.07767716f, 
    0.09830005f, -0.12743087f, -0.13850924f, 0.05159008f, -0.18870515f, -0.14117001f, -0.09850091f, -0.13386559f, 
    -0.01417991f, 0.24852781f, -0.24239531f, -0.01909134f, -0.12656237f, 0.00112286f, -0.02183522f, -0.09510184f, 
    -0.12100152f, 0.06391561f, 0.09025667f, -0.03040609f, -0.15900983f, -0.25777382f, 0.08643938f, -0.02807423f, 
    0.05517688f, -0.13136524f, 0.00959760f, 0.11421913f, -0.12091670f, -0.11212603f, -0.10424914f, -0.42606303f, 
    -0.04988196f, 0.20381939f, 0.29310289f, 0.31269163f, -0.00331637f, -0.00514695f, 0.03106076f, 0.06219466f, 
    0.03673894f, 0.01896344f, -0.02375216f, 0.24599373f, -0.08021152f, 0.37727880f, 0.02223086f, 0.16782969f, 
    0.07405981f, -0.01835369f, -0.20378666f, 0.04607831f, -0.01777199f, 0.10040467f, 0.00825909f, 0.02171744f, 
    -0.06104367f, -0.13851352f, 0.01596911f, 0.40496331f, 0.04061785f, -0.00211878f, 0.09668618f, -0.08090778f, 
    0.03356765f, 0.20772919f, 0.02926685f, 0.08331472f, -0.19284180f, -0.10380832f, -0.15397853f, -0.03485613f, 
    0.01545113f, 0.05316510f, -0.02368567f, -0.27507693f, 0.32870921f, 0.10707042f, 0.03697844f, 0.26938966f, 
    -0.01034771f, -0.12554100f, -0.04442649f, 0.10365058f, -0.02697271f, 0.09241385f, -0.02216618f, 0.09790386f, 
    0.09971976f, 0.07266729f, -0.01620236f, -0.07440078f, -0.42984119f, 0.00805216f, -0.04141084f, 0.07441823f, 
    -0.06222490f, 0.02876087f, -0.04767022f, -0.08515523f, -0.11474890f, 0.03960826f, 0.04527177f, -0.11751045f, 
    0.24037060f, 0.20858715f, 0.06604154f, 0.17962392f, -0.01727927f, -0.03903566f, -0.03158602f, -0.06638929f, 
    0.08965598f, -0.05819049f, 0.02303747f, 0.04757571f, 0.09230565f, -0.03652609f, 0.10268562f, 0.30388060f, 
    0.02617391f, 0.03460802f, 0.06590418f, 0.26039088f, 0.06273651f, 0.13808937f, -0.11039980f, 0.09681303f, 
    -0.03251833f, 0.07206453f, 0.07683934f, 0.20862614f, -0.03342535f, 0.06756993f, 0.04981743f, 0.07192535f, 
    -0.14356670f, -0.13214213f, 0.03586359f, -0.17689626f, 0.22682191f, 0.17440657f, 0.32140845f, -0.24888065f, 
    -0.02652258f, -0.12548839f, -0.09251819f, 0.06501297f, 0.06750742f, 0.06033995f, -0.00856765f, -0.03686859f, 
    -0.00414329f, -0.05304866f, -0.04014276f, 0.03252380f, 0.00714333f, -0.07939471f, 0.03619812f, -0.02566169f, 
    0.05777898f, -0.01380492f, 0.01355569f, -0.06245676f, -0.04873886f, -0.02132614f, 0.01893864f, 0.02856638f, 
    0.04725832f, -0.02164255f, -0.02236895f, -0.01669933f, 0.06113237f, -0.06721030f, 0.04966095f, 0.04448244f, 
    0.01428421f, -0.04655521f, -0.04303119f, -0.00480911f, 0.03541784f, -0.02891290f, -0.03267343f, 0.03430516f, 
    0.00043546f, -0.04260453f, -0.02118284f, 0.04325156f, 0.02973201f, -0.03002964f, -0.06600441f, -0.04742226f, 
    -0.03221488f, -0.00653836f, -0.04648244f, 0.04416171f, -0.02536774f, -0.02412161f, -0.00117018f, -0.05148612f, 
    0.05567418f, 0.03569726f, -0.06702270f, -0.00224176f, -0.07488216f, -0.02558029f, 0.02297062f, -0.04573526f, 
    -0.06443851f, 0.00211305f, -0.05985991f, 0.01053390f, 0.04470336f, 0.01928704f, -0.00842202f, -0.01839566f, 
    -0.08127863f, -0.06719068f, 0.03112214f, 0.04008800f, 0.05333357f, 0.02987001f, 0.00553949f, -0.00127370f, 
    -0.05242233f, -0.00287379f, 0.01524232f, -0.05401980f, 0.00727796f, 0.00513478f, -0.07740313f, -0.03499932f, 
    0.05186264f, 0.02105660f, -0.07224170f, -0.07576995f, -0.05317324f, -0.06491873f, 0.04545762f, -0.05062730f, 
    -0.07552505f, 0.01982404f, -0.07864944f, -0.06093199f, 0.00806593f, 0.02336107f, -0.04320538f, -0.03383438f, 
    -0.05996051f, -0.04684554f, -0.01249464f, -0.05365673f, 0.06095094f, 0.05506482f, 0.01773668f, 0.03401311f, 
    -0.03017236f, -0.05831857f, -0.01258319f, 0.01587794f, -0.04439793f, 0.01272131f, -0.05219856f, -0.01868472f, 
    -0.04419235f, 0.06544336f, -0.07592434f, -0.02939912f, -0.03567419f, 0.04530831f, 0.06820101f, -0.02221517f, 
    0.04507338f, -0.03438136f, 0.00679747f, -0.03171415f, -0.01467020f, 0.03641306f, -0.04704382f, -0.04824417f, 
    -0.05131695f, 0.02706721f, 0.02128856f, -0.05023047f, 0.04896536f, -0.05002403f, -0.07631972f, -0.03758316f, 
    0.04618937f, 0.02900689f, -0.05495453f, -0.02839287f, 0.01001498f, 0.05538506f, -0.06909172f, 0.05329131f, 
    0.02261243f, -0.01566929f, -0.06437227f, 0.05839988f, 0.03361375f, 0.04038987f, -0.02207619f, -0.03829684f, 
    -0.07536209f, -0.03899680f, 0.00118002f, -0.04647865f, -0.03944733f, -0.04846749f, -0.03445006f, -0.00512030f, 
    -0.06085569f, 0.04109002f, 0.04800499f, 0.03024499f, -0.04356859f, 0.02476941f, -0.02136932f, -0.03342790f, 
    0.03600371f, 0.03225428f, -0.03002080f, -0.03100894f, -0.00384735f, 0.05703495f, 0.02576272f, 0.05687267f, 
    -0.01054851f, -0.06410527f, 0.00803570f, 0.02106057f, 0.02913498f, 0.00226976f, -0.06949650f, -0.03553487f, 
    0.06105102f, 0.02879456f, -0.02006723f, 0.00889380f, -0.04265019f, 0.03195909f, -0.06711595f, 0.05874302f, 
    -0.15249464f, -0.06858061f, -0.13019802f, -0.11288566f, -0.05848085f, 0.02244505f, -0.03035116f, -0.07126737f, 
    -0.07304973f, 0.03456712f, -0.11742896f, 0.08001085f, 0.18434368f, -0.08436986f, -0.01072155f, -0.12753142f, 
    0.05113026f, -0.03583864f, 0.03121168f, -0.10508667f, 0.10985506f, -0.10872441f, -0.11909411f, -0.04060923f, 
    -0.21012104f, 0.05375945f, -0.11050586f, 0.06998023f, -0.09475035f, -0.21104692f, -0.00374711f, -0.16547340f, 
    0.13271965f, 0.03634664f, 0.00847255f, 0.13973382f, -0.13922393f, -0.10098093f, 0.02814399f, 0.09790318f, 
    -0.21822010f, -0.06753793f, 0.01181070f, -0.01514496f, 0.04414543f, 0.20389794f, 0.11480434f, 0.13245660f, 
    0.02627628f, 0.09554750f, -0.09415832f, 0.11958798f, 0.00917133f, 0.05928556f, 0.01016670f, 0.01066916f, 
    0.12393037f, -0.13163336f, -0.05109726f, 0.19171564f, -0.11949433f, -0.00662290f, 0.00209302f, -0.12198984f, 
    0.15622461f, -0.01010862f, 0.01909381f, 0.01385052f, 0.07768846f, 0.05023481f, -0.00403793f, 0.19666609f, 
    0.18906502f, 0.17221442f, -0.11220013f, -0.33451289f, 0.06864359f, 0.16608514f, 0.03009571f, 0.00613327f, 
    0.03030344f, -0.10150681f, 0.16461819f, -0.15167741f, 0.04696226f, -0.05567851f, 0.08288258f, -0.02782539f, 
    0.08749146f, 0.00397457f, 0.14417063f, 0.16119970f, -0.03721418f, -0.11025935f, 0.22599356f, -0.09809089f, 
    -0.01511768f, -0.01277695f, 0.00506731f, -0.15954407f, 0.12231413f, -0.18558906f, -0.04949561f, 0.32264146f, 
    0.09807134f, 0.00455185f, 0.19598931f, -0.12438244f, -0.13591082f, -0.00058882f, -0.00330951f, -0.06182108f, 
    0.07470155f, -0.05433784f, -0.02711841f, 0.12887016f, -0.13191251f, -0.11811426f, -0.13612784f, -0.33078972f, 
    -0.02669706f, -0.20146108f, -0.15917437f, 0.05152399f, 0.04597982f, -0.18654355f, 0.09262384f, 0.10261644f, 
    -0.10494154f, -0.07355644f, 0.07875534f, 0.09603034f, 0.44000638f, -0.05026265f, 0.08787549f, -0.02150917f, 
    -0.09767740f, -0.01638892f, 0.01364298f, -0.00558280f, 0.24268678f, 0.11196360f, 0.11655667f, 0.06981636f, 
    -0.12173792f, 0.09431048f, -0.06919190f, 0.09140375f, 0.04628266f, 0.13653177f, 0.09254933f, 0.14501894f, 
    0.01971493f, -0.02444597f, 0.14501780f, 0.11666661f, -0.11305749f, -0.07717407f, 0.05902093f, -0.25926834f, 
    -0.04845934f, 0.02342045f, 0.14713365f, -0.14515771f, 0.08925539f, -0.13744166f, 0.10378560f, 0.11244948f, 
    -0.00766454f, -0.09275866f, -0.06941529f, -0.08838792f, 0.14496784f, 0.01945334f, 0.06019638f, -0.05906679f, 
    0.10559698f, 0.11482027f, 0.03673276f, 0.15001383f, -0.18182260f, -0.24877785f, 0.07359318f, 0.10915839f, 
    -0.05910781f, -0.07899806f, -0.04483467f, -0.10553156f, 0.17144857f, 0.03044198f, 0.06401440f, 0.03679083f, 
    0.14341639f, 0.03501821f, -0.00618351f, 0.00910823f, 0.07290549f, -0.10039067f, 0.12965532f, -0.11418217f, 
    0.13833383f, 0.11887329f, 0.05792839f, -0.03961688f, -0.17371896f, -0.41349688f, 0.18660532f, 0.03960539f, 
    0.08676098f, 0.18237750f, 0.03399428f, 0.13025579f, 0.04741719f, 0.08258120f, 0.11415270f, 0.05109656f, 
    0.09186961f, -0.10152412f, -0.11136560f, 0.04659744f, 0.09313886f, -0.04180859f, -0.00359897f, 0.14529602f, 
    0.07948146f, -0.00477113f, 0.06854121f, 0.19522026f, 0.11921971f, -0.08853517f, -0.04472682f, -0.07096076f, 
    0.12583193f, -0.03343472f, 0.06537437f, -0.05880701f, 0.11001560f, -0.01802139f, -0.13760918f, -0.15107934f, 
    -0.02679888f, 0.42262581f, -0.21498941f, -0.03686000f, -0.09026589f, 0.01768520f, 0.07905471f, 0.06263059f, 
    0.01786529f, 0.11506802f, 0.05876570f, 0.09073921f, -0.02086142f, 0.09378605f, -0.01226209f, -0.09048088f, 
    -0.02415167f, -0.09384197f, 0.17526476f, 0.28115344f, 0.11621121f, -0.08199023f, 0.00657809f, -0.10569134f, 
    -0.09313384f, 0.08058821f, 0.46466884f, -0.00898471f, -0.17729495f, -0.13569075f, -0.08622871f, 0.04349094f, 
    0.03850740f, -0.03665904f, -0.01165109f, 0.23536892f, 0.02168158f, 0.24560291f, 0.15986502f, -0.16275157f, 
    0.04539930f, 0.00173559f, 0.23247302f, 0.11339936f, 0.05440559f, 0.07790691f, 0.15442571f, 0.10336681f, 
    -0.07608260f, -0.10079646f, -0.07015713f, 0.47381946f, -0.05781963f, 0.13776837f, 0.02230912f, -0.02289467f, 
    -0.10328355f, 0.05462411f, -0.00066653f, -0.00758603f, 0.18113275f, 0.13905834f, -0.09981928f, -0.02521352f, 
    -0.03274418f, -0.01688606f, -0.01582739f, -0.05652686f, 0.13188799f, 0.07814503f, 0.07358816f, 0.11547013f, 
    -0.11232141f, -0.28618836f, -0.01749937f, 0.10195331f, -0.09736305f, -0.06579851f, -0.04915164f, 0.01248989f, 
    0.02173195f, 0.03422144f, -0.01567041f, 0.11545192f, -0.39143333f, -0.27776310f, -0.10210310f, 0.01251073f, 
    -0.00359489f, -0.00024924f, -0.01002907f, 0.22128928f, -0.20780869f, 0.03673532f, 0.00612119f, -0.06802757f, 
    -0.04034329f, 0.23317273f, -0.04919137f, 0.13479742f, 0.02951142f, 0.07425863f, -0.00471258f, 0.11714555f, 
    0.16410562f, -0.12276179f, 0.05872840f, 0.05852819f, -0.07124203f, -0.17513518f, 0.06447610f, -0.02226287f, 
    -0.14420451f, -0.15400802f, 0.06999326f, 0.13318343f, -0.05468765f, 0.12447499f, 0.07299431f, 0.02270025f, 
    -0.06627255f, 0.10173715f, 0.18698671f, -0.07241094f, 0.00654293f, -0.12623602f, 0.07937875f, 0.10215505f, 
    -0.03595672f, 0.00322079f, 0.00761053f, 0.03864483f, 0.35481876f, 0.06016345f, 0.12656997f, -0.08222324f, 
    0.04949620f, -0.03051340f, -0.08468745f, -0.02941672f, 0.11133283f, 0.01958016f, -0.14295748f, -0.09302799f, 
    -0.06456084f, -0.03086568f, -0.00338117f, 0.01175493f, -0.05455269f, -0.06416889f, -0.00556754f, -0.00243447f, 
    0.05949301f, -0.04895575f, -0.00673790f, -0.00776478f, -0.03060898f, -0.06155337f, 0.03766122f, -0.03694617f, 
    -0.05030981f, -0.06070153f, 0.02594911f, 0.06371840f, -0.01384535f, -0.00937449f, 0.06431393f, 0.01331648f, 
    0.04234217f, -0.04913917f, 0.05601845f, -0.03338430f, -0.03234407f, 0.01753793f, 0.04436500f, 0.05192244f, 
    0.01855871f, 0.05464942f, -0.01330103f, -0.05617443f, -0.06259570f, 0.03728868f, 0.04477016f, 0.03111467f, 
    -0.02512898f, 0.00833079f, -0.05138815f, -0.03336372f, -0.05728991f, -0.03767986f, -0.02333733f, 0.01444410f, 
    -0.01594519f, -0.01002281f, -0.02565136f, -0.06640042f, -0.07672905f, -0.02705785f, 0.00705883f, -0.01641809f, 
    -0.07193828f, -0.00281065f, -0.03358625f, -0.04694631f, -0.06579442f, -0.04129409f, -0.00350272f, -0.02942015f, 
    0.01946208f, -0.02067836f, 0.04397011f, -0.02870505f, 0.02484206f, -0.03555511f, -0.02525051f, 0.02927036f, 
    -0.00196587f, -0.00988447f, 0.03954092f, 0.02750052f, 0.04097788f, 0.00058856f, -0.05953822f, -0.04118286f, 
    -0.03708870f, 0.00111638f, 0.03683862f, 0.01270954f, 0.03809342f, -0.06546737f, 0.01748155f, -0.01133313f, 
    0.01149057f, 0.05187151f, -0.05613174f, -0.01520188f, -0.01677209f, 0.01276876f, 0.01501911f, -0.07442965f, 
    -0.01742799f, -0.02472485f, 0.04961199f, -0.06782991f, -0.06641245f, -0.04957319f, -0.07412641f, 0.06011165f, 
    -0.00512321f, -0.01598462f, -0.03280015f, 0.00311723f, -0.04728262f, -0.05988375f, -0.04258012f, 0.00951052f, 
    0.01783174f, -0.07050783f, -0.06794704f, 0.00482752f, 0.01686165f, 0.00300653f, 0.03734529f, -0.01865894f, 
    0.03725585f, 0.00464105f, 0.04192338f, -0.06725352f, -0.05474333f, 0.03659312f, 0.02827480f, 0.00629258f, 
    0.00768203f, -0.04125902f, -0.04312503f, -0.00939714f, 0.04649488f, -0.02907180f, 0.04052950f, -0.00078438f, 
    -0.07167459f, 0.04389009f, -0.00015552f, 0.03181615f, 0.01554133f, -0.00449951f, 0.01800459f, -0.02812899f, 
    -0.07127263f, -0.04655170f, 0.03657416f, -0.07046492f, 0.03039028f, -0.03213308f, 0.05875150f, 0.04397599f, 
    0.02554635f, -0.04435475f, -0.05023910f, 0.04319635f, -0.00466057f, -0.07025334f, 0.00028374f, -0.04239095f, 
    -0.05888550f, -0.05911445f, 0.05336291f, -0.03768229f, 0.00011580f, 0.01410255f, -0.02468713f, 0.01441746f, 
    -0.03112797f, -0.04843792f, -0.01577664f, 0.02795321f, -0.00717895f, 0.01008765f, -0.05012842f, -0.05823622f, 
    -0.00911103f, 0.06273874f, 0.05372716f, -0.07581873f, 0.00660707f, 0.02554020f, 0.04526704f, 0.02412569f, 
    0.02376106f, 0.02139353f, -0.01605827f, 0.00633068f, 0.02290547f, 0.02538358f, 0.05547690f, -0.02056357f, 
    0.05600657f, 0.03186947f, -0.03244480f, -0.06525092f, -0.03136135f, -0.06915669f, -0.04825955f, 0.00146535f, 
    0.01643730f, -0.04471382f, 0.06244464f, -0.03528073f, -0.01728823f, -0.00561645f, -0.00577813f, 0.03178146f, 
    -0.00054246f, -0.03228648f, -0.02204918f, -0.04656539f, 0.04713729f, -0.04963573f, 0.04820954f, -0.06191764f, 
    -0.01108066f, -0.04592816f, 0.05692498f, 0.00208074f, -0.03623958f, -0.06027884f, -0.06387526f, 0.00626856f, 
    0.05451349f, 0.04166662f, 0.04547929f, -0.01661530f, 0.03131283f, 0.00336400f, 0.05238585f, -0.06835078f, 
    -0.04334848f, -0.01219224f, -0.04311369f, -0.03284863f, -0.06061089f, -0.02600180f, -0.00306432f, 0.02318484f, 
    0.04993897f, 0.03746914f, 0.06414897f, -0.00059291f, -0.03805420f, 0.03830812f, -0.03266450f, 0.00261169f, 
    -0.02782736f, 0.00351162f, -0.04946837f, 0.06460254f, -0.06680300f, 0.02250489f, -0.06976207f, 0.05502044f, 
    -0.03058780f, -0.06017018f, 0.01940333f, -0.06214644f, -0.05898326f, 0.01337881f, 0.06149361f, -0.04612250f, 
    0.05961696f, 0.00822478f, -0.04783519f, -0.01430265f, -0.05965464f, 0.02037540f, 0.00904870f, -0.06285044f, 
    -0.06421195f, 0.05141745f, 0.01797182f, 0.00887112f, 0.01729404f, 0.04487725f, -0.06172492f, -0.03584605f, 
    0.03622618f, -0.02581560f, -0.02759721f, 0.04293731f, 0.02991525f, -0.04233725f, -0.01318701f, 0.01481372f, 
    -0.06245897f, -0.04514460f, 0.02227757f, -0.03161103f, 0.03478825f, -0.03145582f, 0.01663661f, -0.07186832f, 
    0.00898819f, 0.03719121f, -0.01611233f, 0.05074222f, -0.00642921f, 0.05819992f, 0.01484763f, -0.00122051f, 
    0.03347531f, -0.03460335f, 0.02573743f, 0.01962878f, -0.04515047f, -0.07035606f, 0.07010679f, -0.05098478f, 
    -0.00806964f, 0.05790169f, -0.05831605f, -0.06894676f, -0.04123201f, -0.04104451f, 0.01888276f, 0.04357251f, 
    -0.05667492f, 0.05639515f, -0.05916100f, 0.06112218f, -0.04402265f, 0.04686432f, -0.00024535f, 0.00672835f, 
    -0.04161609f, 0.02960972f, 0.05319453f, -0.05328211f, -0.07900842f, 0.01415284f, -0.05297751f, -0.05976882f, 
    -0.00829466f, -0.06207001f, -0.04171637f, -0.04296132f, -0.02709291f, -0.01211783f, 0.00617632f, -0.01577421f, 
    -0.00513372f, 0.05992410f, -0.04439470f, 0.00560041f, 0.01014341f, -0.06356794f, -0.04687333f, -0.02213262f, 
    -0.02155778f, 0.03915908f, 0.01565863f, -0.04709432f, 0.01409646f, 0.02467213f, 0.00109066f, -0.03921619f, 
    0.05805829f, -0.04231245f, -0.05538124f, -0.07734875f, 0.08089528f, -0.03047093f, -0.05673869f, 0.04370193f, 
    -0.01224738f, -0.05937053f, -0.03194307f, 0.06246188f, 0.03974732f, -0.00752141f, -0.05449226f, -0.00322390f, 
    -0.00326434f, 0.03247319f, -0.07297079f, 0.00773212f, -0.04303886f, -0.05472323f, -0.03057581f, -0.06415034f, 
    -0.30991003f, 0.29174522f, 0.12880436f, -0.10154641f, -0.01970797f, -0.13977796f, -0.15167391f, 0.05490605f, 
    -0.04818517f, 0.08621605f, 0.03909125f, 0.08151875f, 0.11511534f, 0.31321275f, -0.22954476f, 0.08348867f, 
    0.04954679f, 0.09740511f, 0.00306623f, -0.07970397f, -0.02813471f, -0.20922135f, 0.04580356f, -0.02587298f, 
    0.43476737f, 0.02551188f, -0.09609037f, -0.10882032f, -0.05265538f, 0.10297552f, 0.00754520f, -0.00715322f, 
    -0.08483982f, 0.04482507f, 0.18074170f, 0.03676515f, 0.03643647f, 0.12187283f, 0.15661682f, -0.23913869f, 
    0.05571204f, 0.01893259f, 0.17477217f, -0.06562907f, 0.11385573f, 0.04139514f, 0.14432138f, 0.12189551f, 
    0.23770860f, 0.00381000f, 0.16374409f, -0.14542599f, 0.10207982f, -0.08050584f, 0.06693702f, -0.11044179f, 
    0.17429347f, 0.19389193f, 0.09832886f, 0.02698188f, -0.13637288f, 0.03365399f, 0.13560908f, -0.12787370f, 
    -0.06140266f, -0.14319929f, -0.03296178f, 0.03178692f, -0.00471683f, 0.13805315f, 0.08127193f, 0.17549038f, 
    -0.11097122f, -0.41527233f, -0.20089634f, 0.16057426f, 0.02261524f, 0.02695154f, 0.08892764f, 0.02930827f, 
    0.04590872f, -0.04663413f, -0.10491011f, 0.03515065f, -0.23874691f, -0.25791535f, 0.16501907f, 0.14841171f, 
    0.04316678f, 0.07412979f, 0.12390237f, 0.03822168f, -0.02650208f, 0.16621049f, 0.05211560f, -0.04514022f, 
    0.24612461f, 0.00215464f, 0.02920289f, -0.14062890f, 0.15304925f, 0.06890938f, -0.09814899f, 0.13358623f, 
    -0.03379509f, -0.01072666f, -0.14577349f, 0.04482364f, -0.02355160f, 0.24493383f, 0.05379828f, -0.08774938f, 
    -0.05671317f, 0.06064525f, 0.08087599f, -0.08704358f, 0.09262152f, 0.13844033f, 0.06655727f, 0.08512965f, 
    0.22860396f, 0.25270525f, -0.16077580f, -0.08498305f, 0.14850076f, -0.09304109f, -0.07548901f, 0.17796475f, 
    -0.22495320f, -0.03216505f, 0.02188380f, 0.01081440f, 0.21974725f, 0.29408696f, -0.17716192f, -0.06742875f, 
    -0.07157390f, 0.06547029f, 0.12706965f, -0.07027651f, 0.03717694f, -0.09187826f, 0.03318411f, -0.01598193f, 
    0.15922089f, -0.12693131f, -0.08166425f, -0.13556644f, -0.05377277f, 0.07759658f, 0.00962585f, 0.25379401f, 
    -0.05575692f, 0.24386908f, -0.01569038f, -0.12448868f, 0.02308027f, -0.09472376f, -0.20144087f, -0.03528225f, 
    0.07424038f, 0.06339698f, 0.13940534f, 0.09989347f, -0.09902390f, -0.08525586f, -0.06870720f, -0.12085483f, 
    -0.10209021f, -0.20541160f, -0.14141022f, 0.32144600f, 0.09773831f, -0.02221973f, 0.22574568f, 0.02098222f, 
    -0.11404470f, 0.09893081f, 0.07615246f, 0.10598466f, 0.20243926f, 0.44396526f, -0.16776457f, -0.21436447f, 
    -0.07698449f, 0.05910965f, 0.04085547f, -0.13771510f, 0.00287906f, 0.05114567f, 0.02960348f, 0.02129878f, 
    -0.18604971f, 0.21235938f, 0.20091571f, 0.07430229f, 0.05420447f, -0.03998399f, -0.02450860f, -0.02802889f, 
    -0.05346452f, -0.01614719f, -0.07210890f, 0.09235357f, 0.14130108f, 0.35269681f, -0.22004369f, 0.09958114f, 
    0.09340442f, 0.13615336f, 0.12584892f, -0.18254124f, -0.04967681f, -0.08067274f, 0.04815232f, -0.07348692f, 
    0.33394375f, 0.12904246f, 0.07226139f, -0.14506347f, -0.06113808f, -0.00595641f, 0.02694611f, -0.01946468f, 
    -0.05677567f, 0.04221549f, 0.17224191f, 0.06874031f, -0.04436889f, 0.16754128f, 0.05968355f, -0.03644392f, 
    0.02316516f, -0.12200657f, 0.12380116f, -0.16311277f, -0.03881049f, 0.09949490f, 0.18462011f, 0.16005695f, 
    0.27794224f, -0.04089161f, 0.08783986f, -0.02766737f, -0.06490999f, -0.09115747f, -0.03504098f, -0.01174226f, 
    0.21822102f, 0.04382172f, 0.05940986f, 0.04506119f, -0.22641240f, -0.01029795f, 0.15201148f, -0.04645288f, 
    -0.05609215f, 0.01337106f, -0.01307092f, -0.03795714f, 0.08100254f, 0.00583923f, 0.12154522f, 0.06838942f, 
    -0.11020253f, -0.11482815f, -0.23345119f, 0.03181438f, 0.09160565f, 0.14825206f, 0.11439166f, 0.10895678f, 
    0.12172015f, -0.01830387f, -0.03152000f, -0.01977730f, -0.05670460f, -0.22498760f, 0.13593256f, 0.25907531f, 
    0.11107246f, 0.09333901f, 0.11435282f, -0.06075885f, 0.03197429f, 0.07702640f, -0.03690303f, -0.10407121f, 
    0.29136679f, 0.00019886f, 0.03332824f, -0.29194903f, 0.05327883f, -0.00412356f, 0.09712860f, 0.07578874f, 
    0.12852035f, -0.07325609f, 0.04870167f, 0.04728023f, 0.05072192f, 0.22030178f, 0.01874904f, -0.15723149f, 
    -0.14131786f, -0.01444771f, -0.02738237f, -0.02620527f, -0.06630474f, 0.13155758f, -0.06051247f, -0.18049638f, 
    0.11989971f, 0.11165403f, -0.26988947f, -0.11355717f, 0.09985927f, -0.06255200f, 0.01611339f, 0.03505481f, 
    -0.14185691f, 0.00970016f, -0.02428540f, -0.01046182f, 0.25386414f, 0.17643577f, -0.26311004f, 0.05403934f, 
    0.08833864f, 0.09989956f, 0.00407319f, -0.10667749f, 0.02380655f, -0.11196629f, 0.04889902f, 0.08211374f, 
    0.12766297f, -0.09483358f, 0.03310635f, 0.10718595f, -0.00129764f, 0.00983643f, 0.04553029f, 0.19081765f, 
    -0.05246702f, 0.20895214f, -0.01449904f, -0.01130950f, -0.06146774f, -0.09828959f, -0.20917743f, -0.10024315f, 
    0.08267378f, 0.03638329f, 0.08771804f, -0.14908482f, -0.01802754f, -0.10737539f, 0.00773671f, -0.00733431f, 
    -0.09542965f, -0.08152128f, -0.24729155f, 0.23845772f, 0.10460980f, -0.09152889f, 0.10462324f, 0.01858450f, 
    -0.01606222f, 0.04903359f, 0.04492503f, 0.07639029f, -0.00800048f, 0.25044149f, 0.04042801f, -0.24634796f, 
    -0.00977231f, 0.02133491f, -0.01375493f, 0.05775186f, -0.00106734f, 0.06899612f, -0.00686746f, 0.08129412f, 
    -0.06158685f, 0.11233490f, -0.04957668f, -0.03147203f, 0.03788413f, -0.05496233f, -0.04208988f, -0.08814709f, 
    0.05993856f, 0.09744972f, -0.05665452f, 0.00469441f, 0.38369519f, -0.08645464f, 0.00892572f, -0.10243630f, 
    -0.08701399f, -0.11778235f, 0.05265119f, 0.03699109f, 0.00098465f, -0.14170624f, 0.10334902f, 0.01151054f, 
    -0.02186308f, 0.00428045f, 0.10795359f, 0.22750036f, -0.05762594f, -0.12165669f, 0.03541696f, 0.04734935f, 
    -0.10020629f, 0.07945989f, 0.06871511f, -0.05775130f, 0.16989236f, -0.01024450f, 0.12932694f, 0.11417086f, 
    0.04445048f, 0.12028067f, 0.01889147f, -0.03953071f, 0.16180550f, 0.00126337f, 0.08646166f, 0.10481210f, 
    -0.14114928f, -0.06886925f, 0.03103146f, -0.16303228f, 0.09992734f, 0.03900712f, 0.01955375f, -0.04188361f, 
    0.10365634f, -0.06655726f, 0.02743173f, 0.10064582f, 0.00051271f, 0.18854916f, -0.02173712f, -0.04120766f, 
    0.02904807f, -0.06744010f, 0.04824575f, 0.07506710f, 0.00343391f, 0.05518259f, -0.04072937f, 0.06519222f, 
    0.28913414f, -0.45273998f, -0.06072069f, -0.15943447f, 0.08096478f, 0.04221693f, -0.01438896f, 0.08513803f, 
    0.05663117f, -0.05393283f, 0.09970839f, 0.03680199f, -0.10405023f, -0.29130635f, -0.09611436f, -0.27469841f, 
    -0.07512419f, 0.04489141f, 0.16009185f, 0.20418252f, -0.15142941f, -0.10689206f, 0.07466829f, -0.10008380f, 
    0.06639932f, 0.23378856f, 0.11741143f, -0.12058583f, 0.14894815f, 0.07993567f, -0.22406329f, 0.21174550f, 
    -0.00388485f, -0.01937948f, 0.02822021f, -0.01836369f, 0.10394553f, 0.15600832f, 0.08688775f, -0.04999587f, 
    0.12382916f, 0.01519287f, -0.04597513f, -0.04254628f, -0.19954325f, 0.09164237f, 0.04802471f, 0.10810632f, 
    0.27374822f, 0.08558832f, 0.01546852f, -0.14364088f, -0.02755389f, -0.04182674f, 0.10565504f, 0.06326397f, 
    -0.01963978f, -0.06550874f, -0.01202116f, -0.04903136f, 0.38579297f, -0.04655584f, -0.02638584f, -0.19826351f, 
    0.05197286f, -0.10728926f, -0.06610844f, -0.08456898f, 0.06254087f, -0.08559768f, -0.04502345f, -0.09966943f, 
    -0.15212901f, 0.02970668f, -0.19841550f, -0.24489386f, -0.02550451f, 0.02811099f, 0.17278823f, 0.20516196f, 
    -0.11189047f, -0.02206542f, 0.00308456f, -0.01078351f, 0.21318632f, -0.06738765f, 0.02595756f, -0.12339579f, 
    -0.03718074f, 0.18483333f, 0.18701491f, 0.01912690f, 0.11374968f, -0.15470311f, -0.02034021f, -0.15958905f, 
    0.07055964f, -0.08857892f, -0.10670684f, 0.02484036f, 0.06536162f, -0.02668278f, 0.20260787f, -0.00505841f, 
    -0.07610454f, 0.04639253f, 0.01683390f, 0.09735318f, 0.39640474f, 0.09305111f, -0.04750848f, -0.01756458f, 
    -0.14839868f, 0.05691023f, -0.11836857f, -0.10991736f, 0.06524434f, 0.01406042f, 0.07079902f, -0.05093751f, 
    0.20798256f, 0.01136846f, 0.23250221f, -0.08901403f, -0.03435963f, 0.07069164f, -0.10305914f, -0.05023165f, 
    -0.08877935f, 0.05122261f, 0.03872805f, -0.06944506f, -0.17147434f, -0.08653532f, -0.11495674f, 0.09681184f, 
    -0.01256904f, 0.03591435f, -0.02776738f, 0.05971757f, 0.14177212f, 0.00979101f, 0.05902502f, 0.11804818f, 
    -0.44414973f, -0.09068760f, 0.12252088f, 0.29550546f, 0.02053424f, -0.05874577f, -0.13353030f, -0.03417851f, 
    -0.01212496f, -0.06571930f, -0.02316963f, -0.13254592f, 0.19195150f, 0.13515505f, -0.17750452f, 0.17989399f, 
    0.12336153f, 0.15228733f, 0.10155953f, 0.15016831f, -0.01285838f, -0.07131608f, -0.02619058f, -0.03063327f, 
    -0.30832991f, -0.11477794f, -0.01748494f, -0.38289025f, 0.13031490f, -0.01309817f, 0.17344336f, 0.02349243f, 
    0.12097222f, 0.12947048f, 0.17505117f, 0.13812447f, 0.10503744f, 0.09610303f, 0.04838501f, 0.14262724f, 
    0.08498967f, -0.08402181f, -0.05153223f, 0.05220583f, -0.16567513f, 0.06102485f, 0.00806580f, -0.06731603f, 
    0.18837170f, -0.03607803f, 0.35818753f, 0.11630907f, -0.17619753f, -0.03613790f, 0.04967638f, -0.11553599f, 
    -0.14768595f, 0.01411253f, -0.10225194f, 0.03859348f, 0.04086513f, 0.15033147f, 0.29918602f, -0.13715304f, 
    0.18291396f, -0.06285947f, 0.04352083f, 0.22393288f, -0.06011904f, -0.08763622f, -0.01940643f, 0.08586421f, 
    -0.15863110f, 0.18724807f, -0.16879633f, -0.08423586f, 0.04865336f, -0.21276270f, -0.08369906f, -0.09798747f, 
    -0.08904442f, -0.06760231f, 0.03125458f, -0.00654406f, -0.00754962f, 0.01950131f, 0.01783426f, 0.03017105f, 
    -0.03187517f, 0.01270935f, -0.09834360f, -0.01104470f, 0.10470296f, 0.00255585f, -0.03597967f, 0.30583972f, 
    -0.34554109f, 0.21626371f, -0.18744399f, 0.28497714f, 0.01575890f, -0.08126224f, -0.09898683f, 0.11549540f, 
    -0.02642374f, -0.11862301f, -0.05926288f, -0.04052258f, -0.14703046f, -0.02462626f, -0.08137134f, -0.04718386f, 
    -0.20020710f, -0.03034911f, 0.06497271f, -0.22776757f, -0.00714922f, 0.00759353f, 0.15126340f, -0.17039634f, 
    0.01162228f, -0.10120831f, 0.14483565f, -0.18863833f, -0.02519584f, -0.12616803f, 0.19280665f, 0.08652340f, 
    -0.11021683f, -0.03039241f, -0.09790910f, -0.04676057f, 0.20564713f, -0.01578618f, 0.24172579f, 0.32636818f, 
    0.00683046f, 0.02014990f, 0.05536934f, -0.04530529f, 0.12448601f, 0.24271299f, 0.05632205f, -0.18672091f, 
    0.00800485f, 0.05198336f, 0.11864703f, 0.03156279f, -0.08485059f, 0.02733193f, 0.12840554f, 0.21099856f, 
    -0.10885523f, 0.00059248f, 0.10233241f, -0.13367367f, -0.05481783f, 0.13074344f, -0.30271092f, 0.24273285f, 
    0.00770075f, -0.00586531f, 0.12339073f, -0.02165867f, -0.08664671f, 0.13045593f, -0.15521327f, -0.03318058f, 
    0.11082234f, 0.27746707f, 0.31592089f, 0.11269476f, -0.09890961f, -0.03895643f, -0.17532559f, 0.02685718f, 
    0.04511560f, 0.07747968f, -0.07508928f, 0.00942446f, -0.09746336f, 0.25589663f, -0.21139696f, 0.11076438f, 
    -0.00262370f, -0.02516933f, 0.07734007f, -0.01338730f, -0.07739153f, -0.06219047f, -0.01587696f, -0.01199412f, 
    0.39470080f, -0.15166306f, 0.02624949f, -0.07828862f, 0.09938820f, 0.10732697f, 0.08016539f, -0.07283369f, 
    -0.16993621f, -0.05182879f, 0.00132637f, 0.02653039f, 0.15513115f, 0.08069046f, 0.08546908f, -0.12151076f, 
    -0.09574860f, 0.01359796f, -0.02373328f, -0.03176568f, 0.01951050f, -0.00346479f, 0.03512882f, -0.03561841f, 
    0.29712024f, -0.10327639f, 0.00004884f, -0.01639217f, 0.02807013f, 0.03714491f, -0.10466519f, 0.04560805f, 
    0.04874803f, 0.07148231f, -0.00802454f, -0.01607151f, -0.00683928f, 0.02354762f, 0.05497431f, -0.10670349f, 
    -0.05965337f, 0.06098542f, -0.05372877f, -0.10040394f, -0.04867091f, 0.02649695f, 0.11135423f, -0.09542316f, 
    -0.39627430f, -0.35893774f, -0.40732726f, 0.00318134f, -0.02183323f, -0.00254996f, 0.12724069f, 0.10433909f, 
    0.05943443f, -0.03970545f, 0.00761550f, 0.05369490f, -0.23795559f, -0.43049374f, 0.07757258f, 0.22329795f, 
    -0.10689387f, 0.18252806f, 0.07191829f, -0.08724309f, -0.06519808f, 0.10457308f, -0.08906326f, 0.15662511f, 
    0.19425559f, -0.04100927f, 0.24035102f, 0.08792601f, -0.03151127f, -0.01716937f, 0.11923940f, 0.11435115f, 
    -0.00380535f, -0.03083140f, -0.09996366f, 0.10118269f, 0.13190208f, 0.09953586f, 0.19046873f, -0.06845357f, 
    -0.10024203f, -0.09614485f, 0.00699985f, 0.00496172f, -0.06415171f, 0.07684882f, 0.01427110f, -0.06546072f, 
    0.20422974f, -0.04941729f, -0.04751250f, -0.19576669f, 0.14752461f, 0.11808769f, -0.03406630f, 0.03963416f, 
    -0.08459545f, 0.10502157f, 0.01082206f, 0.02986217f, 0.06879040f, 0.26184580f, -0.00965448f, 0.06558239f, 
    0.02929221f, 0.02241726f, 0.04991317f, -0.28113237f, 0.00526796f, -0.06031340f, -0.16398819f, 0.05518581f, 
    0.07256448f, -0.30580601f, 0.12720796f, -0.02238409f, 0.03015924f, 0.01226960f, 0.09496793f, 0.03131390f, 
    0.05568846f, 0.16211577f, 0.13271803f, -0.02600872f, -0.12965196f, -0.12795058f, -0.20755367f, 0.16006990f, 
    0.17088981f, 0.05129863f, -0.01163124f, -0.01034347f, -0.01053562f, 0.00053987f, -0.04177228f, 0.04590241f, 
    -0.13517299f, -0.27611572f, -0.05928627f, 0.26507416f, -0.01497020f, 0.08645742f, -0.01073727f, 0.13306502f, 
    0.03814857f, 0.01585441f, 0.09358764f, 0.11411206f, 0.04133962f, 0.25592455f, -0.15507603f, -0.21074784f, 
    -0.06243721f, 0.02560292f, 0.04067058f, -0.00884873f, 0.08746355f, -0.00547310f, 0.02250100f, 0.03349670f, 
    0.24213506f, 0.16225378f, 0.07749336f, 0.18912199f, 0.10068325f, 0.06825912f, -0.09122918f, -0.11071175f, 
    0.08830716f, -0.03600239f, 0.03859043f, -0.09272727f, -0.14731364f, 0.04901453f, 0.07490423f, 0.11719114f, 
    0.00800349f, 0.04629280f, 0.17262001f, 0.17596485f, 0.14984192f, 0.04652480f, 0.09013664f, 0.17187651f, 
    0.08526000f, -0.31543979f, 0.07162731f, 0.12338295f, 0.15954408f, 0.20000075f, -0.35215312f, -0.11963139f, 
    -0.08762385f, -0.10701395f, -0.02924024f, 0.07105789f, 0.07466207f, -0.11638166f, 0.09987172f, -0.28707927f, 
    0.16444936f, -0.07657358f, -0.15125607f, -0.15877157f, -0.11603860f, -0.06916840f, -0.17869966f, -0.25477365f, 
    0.05826072f, -0.02854609f, -0.15997110f, 0.18503816f, 0.04099226f, 0.04136233f, -0.12646237f, 0.10610242f, 
    -0.00764549f, 0.05675265f, 0.07022753f, -0.05055785f, 0.31602418f, 0.09832449f, -0.09429459f, 0.17240500f, 
    -0.06560543f, -0.02056035f, -0.11788401f, -0.00144428f, -0.12624070f, -0.03380613f, -0.05088807f, -0.51475215f, 
    -0.24070951f, -0.32945466f, 0.32844990f, -0.00411447f, -0.02305957f, 0.02774416f, -0.02385826f, 0.06309561f, 
    -0.00733991f, 0.11992988f, 0.04695662f, 0.09209087f, -0.17733286f, -0.09786008f, 0.18792965f, -0.09233230f, 
    -0.19233456f, 0.10602568f, 0.04969990f, -0.12122640f, 0.03184712f, -0.02074029f, -0.08947446f, -0.03155336f, 
    0.25100291f, 0.13996647f, 0.26742467f, 0.40197322f, -0.03181706f, -0.01667180f, 0.10559595f, -0.00897682f, 
    -0.07558990f, 0.15694335f, -0.04037075f, 0.08564395f, 0.03359056f, -0.17277800f, -0.11493634f, 0.09476715f, 
    0.13789798f, 0.24841806f, 0.11229301f, -0.15944916f, 0.14052953f, 0.16735867f, 0.21747637f, 0.18061058f, 
    0.44789824f, -0.08288276f, 0.35379276f, -0.06095858f, 0.20591573f, 0.06195069f, 0.13485618f, 0.07896170f, 
    -0.05749291f, 0.02633826f, 0.00145849f, -0.07224777f, -0.05167839f, -0.10531981f, 0.26471737f, -0.09264351f, 
    0.20194320f, -0.08892896f, -0.19304119f, -0.01805061f, 0.09469085f, 0.18636081f, -0.17103980f, -0.17249890f, 
    0.02597582f, -0.11330569f, 0.12489939f, -0.15165113f, 0.02222392f, 0.04366566f, 0.09606311f, -0.02639467f, 
    0.14219229f, -0.05984409f, -0.14438263f, -0.13045119f, 0.10498190f, 0.03542177f, -0.08192517f, 0.08865169f, 
    -0.03822376f, 0.02929511f, -0.10548134f, 0.22887294f, 0.11417840f, 0.02283365f, -0.12365911f, 0.10921345f, 
    0.03641023f, 0.05302907f, 0.35660404f, -0.00208068f, 0.10999779f, -0.03867715f, -0.00601029f, 0.04511739f, 
    -0.05692653f, -0.05114531f, -0.01692579f, -0.27256483f, -0.16417766f, 0.23245724f, -0.31927127f, 0.22155665f, 
    0.07431765f, 0.16032602f, -0.18255349f, -0.38127166f, 0.03205906f, -0.04757147f, 0.01882680f, -0.23584481f, 
    0.04812833f, -0.04763057f, 0.32171226f, 0.30063218f, -0.16493623f, 0.04344514f, -0.12119784f, 0.09888421f, 
    0.11996287f, -0.20775598f, -0.03226043f, -0.07948608f, -0.24219106f, 0.28310496f, -0.08232908f, 0.15501258f, 
    0.14515677f, 0.05169950f, 0.13127936f, 0.06170285f, -0.11177918f, 0.09906069f, 0.04067474f, 0.01532256f, 
    0.18726546f, -0.60316515f, -0.25364801f, 0.07378045f, 0.35542828f, 0.14803931f, -0.06944178f, 0.06202121f, 
    -0.13907394f, -0.02026791f, 0.00034134f, -0.03033911f, -0.04748860f, -0.14807020f, 0.05503821f, -0.17104086f, 
    0.06000589f, -0.12188788f, 0.06303285f, -0.08953866f, 0.01687795f, -0.09715953f, -0.11469734f, -0.15324631f, 
    0.20012593f, 0.00224525f, -0.16302049f, 0.07144490f, 0.07947857f, -0.15689129f, -0.09130420f, -0.11070953f, 
    -0.13417529f, 0.16052328f, 0.02903212f, -0.10196839f, 0.05723291f, -0.14101249f, 0.17095201f, -0.01375339f, 
    0.01696609f, 0.01590872f, -0.11927890f, 0.09450831f, 0.09784255f, 0.06619281f, 0.00069677f, -0.26512447f, 
    -0.20540553f, -0.01335015f, 0.18609978f, 0.24916671f, 0.10663458f, 0.10061447f, 0.12437802f, -0.22451028f, 
    -0.01611824f, -0.04291886f, 0.03508157f, 0.17904148f, -0.36913222f, 0.11194915f, 0.27737606f, 0.26599869f, 
    0.09648830f, 0.08754626f, -0.06602381f, -0.13934053f, -0.02237338f, 0.12306137f, 0.05709995f, 0.04654169f, 
    0.16257621f, -0.19486746f, 0.02196467f, 0.10496426f, -0.07945958f, -0.21387915f, -0.00044310f, -0.03145062f, 
    -0.08807394f, 0.10295516f, -0.07282204f, -0.00550793f, -0.05175439f, -0.16326590f, -0.03933762f, 0.00018999f, 
    -0.10795651f, -0.00466572f, -0.07948394f, -0.04293003f, 0.17559618f, 0.11123150f, 0.11132077f, 0.11792400f, 
    0.27657157f, -0.27084446f, -0.02632702f, 0.05161188f, 0.04753584f, 0.03705021f, -0.08936043f, -0.01008699f, 
    0.07048979f, 0.02067612f, 0.11121473f, 0.05015492f, -0.03452270f, 0.19960104f, 0.06133779f, 0.11618414f, 
    -0.05683847f, 0.02034195f, 0.06378948f, -0.06894665f, 0.15813398f, -0.10212927f, 0.01237470f, -0.14408544f, 
    0.06483022f, -0.18092301f, -0.14705089f, -0.04819816f, 0.03364626f, -0.04504005f, -0.00368724f, -0.11917923f, 
    0.13652515f, 0.23047951f, -0.09683909f, -0.04713294f, -0.06332748f, -0.02439387f, -0.04988649f, 0.17129330f, 
    0.12515673f, 0.13536382f, 0.06701124f, 0.09435799f, -0.01897479f, -0.09535261f, -0.14767826f, -0.03712613f, 
    0.05947747f, 0.04300416f, 0.09202287f, 0.14168635f, 0.06835803f, 0.18039785f, -0.04994849f, 0.02086149f, 
    0.05304130f, 0.00131136f, 0.06733951f, -0.06148368f, -0.43175039f, -0.03279194f, -0.12651934f, 0.01573310f, 
    0.02062479f, 0.02683498f, -0.05766834f, 0.02006310f, 0.02964327f, -0.12199272f, 0.00170301f, 0.12560412f, 
    0.22463588f, 0.03834476f, 0.32750273f, 0.03619450f, -0.02408999f, 0.05218017f, -0.18140784f, -0.01696895f, 
    -0.03229282f, 0.02855352f, -0.03939699f, -0.04050712f, -0.17985293f, 0.07193561f, 0.05402086f, 0.22731557f, 
    0.01666523f, 0.01127135f, 0.01287252f, 0.09360888f, 0.03140801f, 0.09299575f, -0.08321093f, 0.07515855f, 
    -0.09554859f, -0.24985138f, -0.06033165f, -0.10823854f, 0.08878785f, -0.15094447f, 0.01390296f, -0.02788076f, 
    0.11376551f, 0.01344088f, -0.11312896f, 0.06444471f, -0.08686657f, -0.07814930f, -0.17603306f, -0.09335038f, 
    -0.11587410f, 0.08205154f, -0.05214364f, 0.13369969f, -0.09345233f, -0.04794087f, 0.04420305f, -0.08921944f, 
    0.31330657f, 0.07401210f, -0.18890409f, 0.01418518f, 0.09931355f, -0.01855819f, 0.04402517f, -0.11773753f, 
    -0.12176311f, 0.08299430f, 0.19694477f, 0.08279826f, 0.05985820f, 0.03393400f, 0.25838956f, -0.08431620f, 
    0.13548948f, 0.00949770f, -0.04263864f, 0.18821299f, 0.03132180f, -0.15763637f, -0.02985832f, -0.18198967f, 
    -0.14274341f, 0.43660125f, 0.16101563f, 0.16090919f, -0.14940171f, -0.04865593f, 0.17159484f, -0.04808865f, 
    -0.09310404f, 0.03466054f, 0.01027394f, 0.02508146f, -0.09398576f, 0.28063148f, 0.62009758f, 0.34226683f, 
    0.28183636f, -0.01778260f, 0.02263569f, 0.04153338f, -0.02211094f, 0.00964870f, 0.06612138f, 0.16753207f, 
    -0.16190816f, -0.19333133f, -0.09730040f, 0.35540560f, -0.07076597f, -0.18460001f, 0.09822311f, -0.22505517f, 
    -0.02966443f, 0.01605277f, -0.01685362f, 0.08153738f, 0.00096629f, -0.26131865f, -0.08094677f, -0.25220415f, 
    -0.06828285f, -0.01230749f, -0.02493248f, -0.06577723f, 0.05217476f, 0.11863335f, 0.08664174f, -0.07229621f, 
    0.18492842f, -0.35776117f, 0.05458859f, 0.45756653f, -0.03643975f, 0.03562625f, -0.07359904f, 0.00044221f, 
    0.01732863f, 0.06021156f, 0.08713740f, -0.08528455f, 0.05980475f, 0.10673397f, 0.27293244f, 0.32855806f, 
    -0.11441305f, -0.00880197f, -0.00797406f, 0.09693238f, 0.09588809f, -0.02210766f, 0.00148663f, -0.13337420f, 
    -0.00682644f, -0.09380796f, 0.39271241f, 0.32200989f, 0.19616707f, -0.06220721f, 0.17746706f, -0.07413757f, 
    0.10752842f, 0.07035107f, 0.11354920f, 0.10824480f, -0.13752127f, -0.05219238f, 0.26381904f, 0.22054273f, 
    0.13533896f, -0.11119664f, -0.00322523f, 0.09546564f, -0.03764463f, 0.03023564f, -0.14754763f, 0.02386455f, 
    0.07176860f, 0.04414920f, 0.26723561f, 0.02777738f, -0.02336297f, 0.08691221f, -0.04045580f, 0.22287667f, 
    -0.02647091f, 0.01651477f, 0.01047281f, -0.16441119f, -0.42582262f, -0.00850116f, -0.18065785f, 0.03871096f, 
    -0.05368889f, -0.04322415f, 0.03676664f, 0.14413761f, 0.09590687f, -0.04897976f, -0.04407648f, -0.06377896f, 
    0.26346678f, 0.22170779f, 0.11746829f, 0.08291519f, -0.16879578f, -0.08395252f, -0.19508223f, -0.06758931f, 
    -0.07011075f, 0.04605283f, -0.07062011f, -0.02613882f, -0.18442796f, 0.10922900f, -0.04554801f, 0.08804546f, 
    0.08913673f, 0.03476262f, -0.06811693f, 0.11299674f, -0.00676287f, -0.09364226f, -0.07028234f, -0.05695361f, 
    -0.07184460f, 0.02963003f, 0.21258582f, -0.12602603f, -0.11072963f, -0.01612098f, -0.06902932f, -0.16581850f, 
    0.00864328f, -0.08616377f, 0.03461918f, 0.02827683f, 0.03568515f, 0.19936858f, -0.08597960f, 0.05129313f, 
    -0.19115613f, 0.09076814f, -0.08768538f, 0.01966690f, 0.06330816f, 0.15656033f, 0.13687682f, -0.01571601f, 
    -0.12191668f, -0.25990841f, 0.10812559f, -0.28606814f, 0.11971557f, 0.00098368f, -0.07280785f, -0.11904677f, 
    0.09666202f, 0.05876526f, 0.11057148f, 0.07482614f, 0.23581053f, 0.12230464f, -0.16336419f, 0.02840549f, 
    0.08228350f, 0.13391197f, 0.14950325f, -0.04929247f, 0.03298053f, 0.21747810f, 0.00007025f, -0.00477163f, 
    0.10509469f, -0.12781422f, -0.31832856f, 0.07081831f, -0.00458941f, -0.08546674f, -0.04238403f, 0.04886405f, 
    -0.10156565f, -0.04763394f, -0.09201532f, -0.14360732f, 0.07909621f, -0.13806805f, 0.20063940f, 0.05196379f, 
    0.14748126f, -0.03730962f, 0.14413247f, 0.00913829f, 0.08363614f, 0.03736025f, -0.03918520f, 0.01741739f, 
    -0.10216092f, 0.03290370f, -0.26741129f, -0.11143205f, -0.03681022f, -0.13375841f, 0.10941149f, 0.04848367f, 
    0.03139996f, -0.02732102f, -0.01725534f, 0.13070463f, 0.04612666f, 0.04708935f, 0.22369047f, -0.00695826f, 
    -0.00283974f, -0.00940074f, -0.20071350f, -0.13846065f, -0.11156362f, -0.04396563f, -0.15990177f, -0.06185572f, 
    -0.51037163f, 0.43762213f, -0.23677909f, 0.14387514f, 0.19141164f, 0.05917737f, -0.08932819f, 0.19375870f, 
    -0.09647374f, 0.13772973f, -0.12484608f, 0.04588977f, -0.14097641f, 0.05282826f, 0.09704224f, 0.01072672f, 
    -0.16681187f, 0.13536650f, 0.22816680f, -0.17249101f, 0.12803882f, -0.06731724f, 0.05556291f, -0.01650971f, 
    -0.03993568f, -0.07749165f, 0.18552850f, 0.01651196f, 0.01430020f, 0.02735250f, 0.09465556f, 0.12656862f, 
    -0.16957049f, 0.11851574f, 0.13075621f, 0.03667118f, 0.05112191f, 0.18157078f, 0.08734761f, 0.27721813f, 
    0.19077080f, -0.04708647f, -0.03339615f, 0.01500861f, 0.13960999f, 0.04948308f, 0.21255013f, 0.01507068f, 
    0.13282388f, -0.19421978f, 0.11636344f, 0.17227127f, -0.18736453f, 0.12498248f, 0.02440902f, 0.19781792f, 
    0.06638937f, 0.01573138f, 0.03501568f, 0.04978316f, -0.10903121f, 0.05802559f, -0.23717131f, -0.05313620f, 
    -0.04466324f, -0.09026416f, 0.01827391f, -0.20199405f, -0.08195207f, -0.00155700f, -0.07144447f, 0.23460789f, 
    -0.07096265f, 0.05073378f, 0.02356833f, 0.02834726f, -0.07629363f, -0.05390977f, 0.02375607f, -0.01590267f, 
    -0.01670217f, 0.02538277f, 0.00830349f, -0.03833283f, 0.02960877f, 0.01059245f, 0.02419334f, -0.07917100f, 
    -0.04815558f, -0.06231810f, 0.00433330f, 0.02990076f, -0.03574507f, -0.03813906f, 0.05361234f, 0.05737983f, 
    0.01765754f, 0.07228118f, 0.05178244f, 0.02397154f, 0.05882316f, 0.02960782f, 0.02415641f, -0.07845452f, 
    0.03280178f, -0.03885647f, -0.03454638f, -0.01652026f, 0.04231190f, -0.02770984f, -0.07664818f, -0.05700133f, 
    -0.04012265f, -0.06167610f, -0.06061995f, -0.08102843f, -0.05595107f, -0.05472692f, 0.01242664f, 0.01120712f, 
    -0.03770062f, 0.05200244f, -0.01654611f, -0.00135215f, -0.01830140f, -0.03291189f, 0.03751774f, -0.00920667f, 
    -0.07078935f, -0.07880625f, 0.06845858f, -0.01597861f, -0.07830483f, -0.02875873f, -0.03960533f, 0.00460642f, 
    -0.02040511f, 0.02878886f, 0.02984653f, 0.01343879f, 0.02257113f, 0.06135183f, 0.02523654f, -0.08242606f, 
    0.00117259f, -0.06205466f, 0.00624116f, 0.04411074f, 0.00531961f, 0.00392279f, 0.03092418f, -0.01710741f, 
    -0.06501503f, 0.06628577f, 0.05424087f, -0.04629565f, 0.03540285f, -0.00267412f, -0.04417166f, -0.01909673f, 
    0.03234631f, -0.06875730f, -0.04248227f, 0.03644315f, 0.01127297f, 0.01779102f, 0.03835970f, -0.03455408f, 
    -0.04939090f, -0.01590339f, -0.06399877f, -0.02980275f, -0.00955432f, 0.02601676f, -0.05612389f, 0.03646122f, 
    0.00319762f, 0.06142839f, 0.00458700f, -0.03746727f, -0.05959132f, 0.00643457f, 0.03472502f, -0.03364776f, 
    -0.07196736f, -0.07536995f, 0.01052162f, -0.02888225f, -0.01339744f, -0.02029470f, 0.03450015f, -0.00771581f, 
    -0.02218717f, -0.06685214f, -0.00006086f, 0.02484503f, -0.05293642f, -0.05274429f, 0.04565338f, 0.03990056f, 
    0.03155139f, 0.00499701f, -0.04552942f, -0.02345174f, 0.04752904f, -0.00694291f, -0.06795673f, -0.07454184f, 
    0.04140770f, -0.06646653f, -0.00306199f, -0.02784384f, -0.03484837f, -0.00516653f, -0.02493294f, 0.02055952f, 
    -0.02976523f, 0.03734876f, -0.07556090f, -0.04273564f, -0.07721677f, -0.01485361f, 0.05478460f, -0.00665428f, 
    -0.05973052f, -0.06708371f, -0.05137998f, -0.00477860f, 0.02310228f, 0.03832335f, 0.02560285f, 0.03157856f, 
    0.00203241f, -0.00240738f, -0.03880869f, -0.04598871f, -0.06437716f, -0.00401923f, 0.05586565f, -0.05116292f, 
    -0.07482362f, -0.03585588f, -0.05992360f, 0.04348610f, 0.05677414f, -0.03908711f, 0.02036920f, 0.02707504f, 
    -0.03680731f, 0.06338667f, -0.01351986f, -0.04743835f, -0.00507882f, -0.07049739f, -0.02175477f, 0.06479824f, 
    0.05042559f, 0.03207727f, -0.00324654f, 0.02194536f, -0.04569183f, -0.01023436f, 0.02238080f, -0.03309823f, 
    -0.21046361f, -0.00518840f, -0.06578170f, 0.07084306f, 0.23277487f, 0.05969247f, -0.01752562f, 0.00839710f, 
    0.12053389f, -0.18657671f, -0.00074438f, -0.00133519f, 0.05987956f, 0.05040349f, 0.12315302f, -0.14327340f, 
    0.12006293f, 0.05173390f, -0.00155602f, 0.11051004f, 0.10972143f, 0.23999406f, 0.08931421f, 0.11532497f, 
    0.14341730f, 0.17070401f, 0.00207822f, 0.21379389f, -0.06835785f, -0.06823567f, -0.23590940f, 0.07724620f, 
    -0.06694331f, -0.01187083f, -0.04130405f, -0.01374876f, -0.07456181f, -0.18742041f, 0.08724437f, -0.05071754f, 
    0.09630731f, -0.15288548f, -0.13640086f, -0.22508921f, -0.03143440f, -0.29512078f, -0.14739986f, -0.08312125f, 
    0.07813748f, 0.29848713f, -0.14054827f, 0.21257983f, -0.18372802f, -0.14555101f, -0.00573605f, -0.03908429f, 
    0.05405849f, 0.11212680f, 0.11621194f, -0.09676097f, -0.18712331f, -0.23706317f, -0.19274384f, -0.01231300f, 
    -0.02618693f, 0.05546174f, 0.10556661f, 0.00704843f, -0.13949531f, -0.17576949f, -0.05585523f, -0.29733345f, 
    0.12691499f, -0.04070799f, 0.37645331f, 0.05443236f, -0.02355896f, -0.09784973f, -0.09548538f, -0.04745836f, 
    0.12764862f, 0.02393782f, 0.10776829f, 0.24882033f, -0.17826283f, 0.17563365f, -0.18420352f, -0.20197418f, 
    -0.25012517f, 0.06869608f, -0.01678699f, -0.06698587f, 0.04015604f, 0.11373509f, -0.04784418f, 0.09285110f, 
    0.07980760f, 0.04566985f, 0.18526225f, 0.23085152f, 0.19580428f, 0.24892116f, 0.05251522f, 0.03881711f, 
    0.03453263f, 0.12971185f, -0.05346208f, 0.05453429f, -0.25438744f, -0.12483864f, -0.13989094f, 0.14251138f, 
    0.18203999f, 0.06648223f, 0.22084095f, -0.20876655f, 0.21692635f, 0.03194178f, 0.04143985f, 0.19859521f, 
    0.23070130f, -0.16975701f, 0.14859371f, -0.18682699f, 0.02989616f, 0.08564848f, 0.19404802f, 0.11826641f, 
    0.01984634f, -0.02967498f, -0.06348300f, -0.05784735f, -0.42320317f, -0.05218848f, 0.05966225f, -0.10102423f, 
    0.24945706f, 0.01441240f, -0.10981702f, 0.25923732f, -0.23855911f, 0.04333053f, -0.07365312f, -0.12405445f, 
    0.24298908f, 0.11120854f, -0.11612614f, 0.03400619f, -0.00392081f, 0.21659794f, -0.03836596f, 0.04470941f, 
    0.19856638f, -0.05062455f, -0.10582376f, -0.06634718f, 0.14277178f, -0.06346720f, -0.06746575f, -0.15860724f, 
    -0.13664204f, 0.14732002f, 0.08850738f, 0.19418795f, 0.10099233f, 0.08735908f, -0.09945578f, 0.08815306f, 
    0.04350479f, 0.21414810f, 0.04284439f, -0.07932613f, 0.13022961f, -0.01671905f, 0.10673083f, -0.06906195f, 
    -0.20548667f, -0.00970905f, -0.09504925f, -0.11761595f, 0.33432445f, 0.07756459f, 0.31112757f, 0.12848753f, 
    -0.15965247f, -0.00555662f, -0.41782337f, -0.10524280f, 0.16460936f, 0.02454893f, 0.08984209f, 0.00047285f, 
    -0.07538525f, 0.05379637f, 0.11782398f, 0.06626695f, -0.18442138f, -0.09112670f, -0.13142341f, 0.00118017f, 
    0.08950633f, 0.01581016f, 0.00179090f, -0.05449688f, 0.02285464f, 0.31805480f, 0.14420433f, -0.00697261f, 
    0.12754558f, -0.06280533f, -0.00152455f, -0.00141613f, 0.00450155f, 0.06685566f, -0.11483535f, -0.17276090f, 
    -0.07476312f, -0.07570314f, -0.18197060f, 0.05193179f, -0.03197575f, -0.01865959f, -0.00992912f, -0.05435311f, 
    -0.07794393f, 0.15749358f, -0.14090762f, -0.21676059f, 0.00942307f, 0.15529406f, 0.14150858f, 0.21448798f, 
    -0.12171799f, -0.08428556f, -0.00343147f, -0.15520714f, 0.07296083f, 0.09075833f, 0.07468427f, 0.00445958f, 
    -0.13167962f, -0.14795752f, -0.12269409f, -0.09165952f, -0.01607907f, 0.01917435f, -0.20022447f, -0.20767918f, 
    0.01323524f, -0.15909147f, 0.04419309f, -0.06324492f, -0.05531501f, -0.12248269f, -0.05173738f, -0.04570024f, 
    0.04223230f, 0.20174718f, 0.19216138f, -0.02449922f, 0.08788353f, 0.17075126f, 0.18257189f, 0.22921589f, 
    0.14008887f, -0.02747241f, -0.18663229f, 0.01000471f, -0.01309578f, -0.09996803f, -0.07762133f, -0.07484143f, 
    -0.10728884f, -0.12007670f, -0.04710474f, -0.00786906f, 0.10535536f, 0.10773173f, -0.01935576f, -0.00884053f, 
    -0.00946094f, 0.05115103f, 0.20258081f, 0.06308683f, 0.18029228f, 0.12789245f, 0.02235628f, 0.03426097f, 
    0.00411591f, -0.06770892f, 0.24551344f, -0.13412805f, 0.07915270f, -0.00802017f, -0.06402744f, 0.10286784f, 
    -0.07038137f, -0.01425655f, -0.02912635f, -0.00538845f, -0.11754944f, -0.02426175f, 0.10676788f, 0.02252178f, 
    -0.04496294f, -0.05211763f, -0.27361473f, -0.03160661f, -0.14631602f, -0.13961852f, -0.09893563f, -0.08785228f, 
    -0.12279385f, 0.26920065f, -0.13577546f, 0.13230853f, 0.19696504f, 0.18434587f, 0.00713871f, 0.17564768f, 
    0.11363123f, 0.08806228f, 0.03254502f, -0.08378841f, -0.00847887f, 0.15436910f, 0.17821832f, 0.12628995f, 
    -0.00884533f, 0.12685880f, 0.08413125f, -0.20927814f, 0.07703622f, -0.02444924f, 0.01957427f, -0.01347590f, 
    0.17869091f, 0.02542215f, 0.01279987f, 0.04159597f, 0.06949276f, -0.01787448f, 0.15245633f, 0.23022161f, 
    -0.10234544f, 0.08636034f, 0.07497267f, 0.09763847f, 0.11661427f, 0.16007741f, 0.16060482f, 0.21315366f, 
    0.16444644f, 0.19092044f, 0.05820398f, 0.10368164f, 0.00254246f, -0.06880724f, -0.07304910f, -0.10370313f, 
    0.29562032f, 0.06965495f, 0.12563661f, 0.26604044f, -0.01082041f, 0.33982781f, 0.11502328f, 0.02416114f, 
    0.07323811f, -0.00978006f, 0.10521233f, 0.01741294f, -0.24241196f, -0.10414262f, -0.03466232f, -0.01049262f, 
    0.08943488f, -0.04682643f, -0.19087403f, -0.20297426f, -0.03824970f, -0.03547068f, 0.04405936f, 0.16735643f, 
    0.14366738f, 0.20247805f, 0.20760722f, 0.26271453f, -0.05344182f, 0.12455566f, -0.11737163f, 0.20042075f, 
    0.06051305f, -0.04380577f, -0.02352681f, -0.07733647f, -0.09942799f, 0.32750365f, 0.04018517f, 0.00350288f, 
    0.14233682f, 0.03104338f, 0.13273856f, 0.04963040f, 0.02106658f, 0.19587454f, 0.10506113f, 0.04757322f, 
    0.17378001f, -0.34788421f, -0.19105065f, 0.01195757f, 0.14263521f, 0.06381473f, 0.08292468f, -0.14143100f, 
    0.04910398f, 0.03204327f, 0.01786986f, -0.01363185f, -0.00290201f, 0.04297185f, 0.15282020f, -0.20515670f, 
    -0.13671471f, -0.05839041f, 0.00213795f, -0.10032161f, -0.18405859f, -0.16643900f, -0.02917583f, -0.08680380f, 
    0.37065724f, 0.08497946f, 0.09295383f, 0.29464865f, -0.01716518f, -0.03037596f, 0.00139635f, 0.02471753f, 
    0.03997348f, -0.03686219f, 0.02230558f, -0.08560782f, 0.00103456f, -0.02295689f, 0.12047818f, 0.00756064f, 
    -0.29584116f, 0.23081793f, -0.06489185f, 0.01516230f, -0.08323616f, -0.19517228f, 0.13846649f, -0.10147752f, 
    -0.19991514f, -0.06146109f, -0.12596504f, -0.07918907f, -0.07165992f, -0.08947643f, 0.06914642f, -0.10621376f, 
    0.12069584f, 0.11113712f, 0.12084164f, 0.12659435f, 0.02508390f, -0.06618696f, 0.23180184f, 0.18991581f, 
    -0.15003788f, 0.22553234f, 0.11096124f, -0.05032947f, 0.11936873f, 0.17130636f, 0.09366491f, 0.14623280f, 
    0.13866751f, -0.00357166f, 0.13633844f, 0.06810191f, 0.04420298f, 0.08037055f, 0.06708649f, -0.00210624f, 
    0.06208368f, -0.01341208f, -0.11700618f, -0.04186792f, 0.03207071f, -0.15379733f, 0.08512645f, 0.02119112f, 
    -0.13980404f, 0.07813910f, 0.02250237f, -0.12534527f, -0.01289624f, 0.07459261f, 0.10459930f, -0.07609054f, 
    0.16663636f, -0.23701525f, 0.09755822f, -0.04814317f, 0.19465309f, 0.20973366f, -0.10693578f, 0.02239057f, 
    0.04003250f, -0.00782262f, 0.04675444f, -0.12065683f, 0.10447138f, 0.17594641f, 0.06668535f, 0.16359980f, 
    0.16212445f, 0.10280287f, 0.03808295f, 0.07520736f, 0.05818150f, 0.18041207f, -0.00408856f, -0.00076178f, 
    0.15719737f, -0.12725419f, 0.23458827f, 0.04108515f, -0.02055981f, 0.05934631f, -0.03530432f, -0.11223568f, 
    0.23228963f, 0.20632251f, 0.08547664f, 0.04212454f, -0.14645533f, -0.00564147f, -0.08593627f, -0.10024934f, 
    0.05459148f, 0.00142830f, -0.03189836f, -0.02156106f, -0.02239567f, 0.03728098f, -0.15017882f, 0.05936840f, 
    -0.11213297f, 0.02802056f, -0.04734131f, -0.06579446f, 0.08710857f, 0.01961934f, 0.04590083f, 0.01560829f, 
    -0.03021226f, -0.02541151f, -0.00906523f, -0.15204521f, -0.38342598f, 0.18322186f, -0.06732985f, -0.02633346f, 
    0.01637821f, -0.07571055f, -0.09451015f, 0.06222674f, 0.10342079f, -0.09665417f, 0.05468677f, 0.03167612f, 
    0.27097273f, 0.09535720f, 0.23154311f, 0.16872112f, -0.12417101f, 0.09513589f, 0.04420307f, -0.04397989f, 
    -0.00125821f, 0.04579432f, 0.01006073f, 0.02142552f, -0.36331546f, 0.05336075f, -0.04336919f, 0.22092846f, 
    0.06541529f, 0.01702933f, 0.20512225f, 0.03608476f, -0.09958054f, 0.23378490f, 0.08403931f, 0.01172702f, 
    0.07430247f, -0.24903949f, -0.03626249f, -0.10149083f, 0.14770181f, 0.10034492f, -0.01756173f, -0.15180196f, 
    0.00768880f, 0.00864923f, 0.07897788f, 0.09916842f, 0.01758167f, 0.02642739f, -0.15214986f, -0.12861367f, 
    -0.04661355f, 0.02707651f, -0.03390617f, 0.01828980f, -0.10247929f, 0.01294807f, -0.00895629f, -0.04087484f, 
    0.12268345f, 0.07828074f, -0.01722118f, 0.20146893f, 0.05677800f, 0.01293469f, 0.00494599f, -0.02782914f, 
    -0.12431756f, 0.04558060f, -0.04483923f, -0.11804968f, 0.05639008f, 0.01207979f, 0.25152752f, 0.04365759f, 
    -0.08260315f, 0.17897685f, -0.07731991f, 0.03664163f, 0.01538570f, -0.16892803f, -0.00269081f, -0.15543602f, 
    -0.25494903f, 0.25840944f, -0.10138512f, 0.02983713f, -0.11146584f, 0.02090081f, 0.20109540f, 0.06468127f, 
    0.05517254f, 0.05673198f, -0.05672295f, -0.02627390f, 0.20496020f, 0.09891953f, 0.32799536f, 0.31949085f, 
    0.22367263f, 0.07406167f, -0.00424667f, -0.04811708f, 0.09819596f, 0.07873170f, 0.07950840f, 0.10556667f, 
    -0.08059730f, -0.18747029f, 0.09210168f, 0.47313669f, -0.13920341f, 0.02113852f, 0.10528778f, -0.11524029f, 
    0.04333820f, 0.08723071f, 0.01021645f, -0.02329310f, 0.10212205f, -0.10960027f, 0.01753437f, -0.03674637f, 
    -0.05731464f, -0.00176609f, 0.01672266f, 0.06561005f, 0.12509792f, 0.14169340f, 0.12720847f, -0.10879193f, 
    -0.04101803f, -0.29742768f, 0.25451401f, 0.25922474f, 0.11451901f, 0.15879571f, -0.08522269f, -0.15769194f, 
    -0.05007668f, 0.07373840f, -0.01961312f, -0.13615865f, -0.16791184f, 0.17634970f, 0.16340145f, 0.33634987f, 
    -0.04015397f, 0.05726192f, 0.05351537f, 0.06474535f, -0.04982780f, 0.06900927f, -0.09785686f, 0.10982359f, 
    -0.15507713f, -0.06491502f, 0.21907839f, 0.22394045f, 0.09811653f, 0.05807785f, 0.02927772f, -0.22851671f, 
    0.21604463f, 0.09690507f, 0.03190717f, 0.03380129f, -0.30481100f, 0.00082004f, 0.04740178f, 0.05949293f, 
    0.16291308f, -0.07849144f, -0.12109521f, 0.05518680f, 0.03336128f, -0.01444083f, -0.11110017f, 0.17226937f, 
    -0.10034073f, -0.07138634f, 0.13623278f, 0.07131462f, -0.05306394f, 0.08839487f, -0.08199837f, 0.05344217f, 
    0.11853813f, -0.03752071f, -0.13717268f, -0.21823399f, -0.19276407f, 0.05290889f, -0.11605232f, -0.22511607f, 
    0.02611688f, -0.02242051f, 0.14208034f, 0.08998401f, 0.19273432f, 0.01919888f, 0.04324390f, 0.08153234f, 
    0.02208379f, -0.01478983f, -0.01269588f, -0.05163817f, -0.00844973f, -0.03933416f, 0.00926178f, -0.02851500f, 
    0.03106507f, -0.04142903f, -0.03349940f, 0.05333198f, -0.00078283f, 0.02309330f, -0.06302072f, -0.08244196f, 
    -0.03752704f, 0.01259363f, 0.04321579f, 0.04257122f, -0.03836047f, -0.03679105f, -0.07002974f, 0.03076163f, 
    -0.02870735f, -0.01680821f, -0.03220890f, -0.08095889f, -0.01623969f, -0.08256087f, 0.03282581f, -0.02977855f, 
    -0.07010306f, 0.00682718f, 0.00638022f, -0.00637415f, 0.00083922f, 0.05901945f, 0.05978199f, 0.04105905f, 
    0.04977635f, -0.01587233f, 0.00203752f, -0.04221430f, -0.02023133f, 0.01984265f, 0.02951301f, 0.04697711f, 
    -0.07018518f, 0.04587533f, -0.07373217f, 0.04545474f, -0.03540369f, -0.01005866f, 0.04653724f, -0.04624360f, 
    0.01949884f, -0.00003881f, -0.04812312f, 0.01420651f, -0.05765032f, 0.03948215f, -0.00554996f, -0.02965802f, 
    0.01733665f, 0.02468700f, -0.03816271f, 0.02280405f, 0.00003243f, 0.01521658f, -0.07462749f, -0.02738598f, 
    0.02843172f, 0.05595746f, 0.01691901f, 0.02957628f, 0.04601122f, 0.03929464f, -0.02472238f, -0.03178070f, 
    -0.00273200f, -0.02857881f, 0.01205767f, -0.03405043f, 0.03872090f, 0.02011903f, 0.01315662f, -0.08438002f, 
    -0.04586833f, 0.04388855f, 0.04325444f, -0.02647608f, 0.03908909f, -0.02314675f, -0.07180867f, -0.08825415f, 
    0.03404489f, -0.04419700f, -0.05052241f, -0.08501970f, 0.05161143f, -0.01848989f, -0.02891123f, -0.02957001f, 
    -0.06341147f, -0.05421268f, -0.06209696f, 0.01061388f, 0.05640481f, 0.02485812f, 0.01437662f, -0.05740838f, 
    0.02172959f, -0.05278683f, 0.04623251f, -0.06740104f, -0.00679466f, 0.05381151f, -0.01671645f, -0.08171135f, 
    0.00955025f, -0.07203744f, 0.03436839f, 0.00669236f, 0.00938449f, 0.05681630f, 0.06931270f, -0.00621978f, 
    -0.02771657f, -0.04639740f, -0.06403127f, -0.01212065f, 0.04892216f, 0.02403550f, 0.03671327f, 0.05533224f, 
    0.02497190f, -0.01213069f, -0.04423973f, -0.04195695f, 0.00770102f, 0.04802491f, -0.06872226f, 0.03243838f, 
    -0.01797505f, -0.05096356f, 0.03342448f, 0.02150473f, -0.02932698f, 0.01281368f, 0.03605776f, 0.01427511f, 
    -0.03509960f, 0.03140252f, 0.04518674f, 0.00049085f, 0.05561429f, -0.07187023f, -0.07668354f, -0.04276116f, 
    0.04172361f, 0.05875272f, 0.01931137f, 0.04326570f, -0.00296709f, -0.05759522f, 0.05054501f, -0.04719160f, 
    -0.01258303f, 0.02580051f, 0.01552017f, -0.06423893f, 0.02253150f, -0.07736276f, -0.07387940f, -0.01423308f, 
    0.03767369f, -0.08002620f, -0.05266665f, 0.02222260f, -0.07314718f, 0.01829849f, 0.05066333f, -0.08137999f, 
    -0.00635485f, -0.01514843f, -0.00370691f, -0.05615124f, 0.00599645f, -0.04260554f, -0.04274716f, -0.06303958f, 
    0.20273696f, -0.02585866f, -0.27153704f, 0.07524218f, -0.04988014f, -0.08198728f, 0.12050465f, -0.02813272f, 
    0.09989691f, 0.03103136f, 0.02221149f, 0.00790270f, 0.08467877f, -0.24646111f, 0.31854585f, -0.23457974f, 
    -0.06559397f, -0.04565828f, -0.14068156f, 0.09063005f, 0.09566770f, -0.09473348f, -0.06289502f, -0.09571032f, 
    -0.46956566f, 0.10460679f, 0.02582553f, 0.02327247f, -0.15191123f, -0.04299501f, 0.03361541f, -0.03745269f, 
    0.11349630f, 0.13183199f, -0.03937637f, 0.03884663f, -0.02425923f, -0.01841984f, -0.00554166f, 0.11769101f, 
    -0.05100750f, -0.00886106f, -0.06577034f, -0.07448585f, 0.00518798f, 0.05650906f, 0.07577837f, 0.11878689f, 
    -0.31902853f, -0.03444723f, 0.05838111f, 0.11385368f, -0.04781862f, 0.10685392f, 0.03658871f, -0.04914438f, 
    0.02701977f, -0.17742841f, -0.15266250f, 0.08973843f, -0.02338268f, -0.02204445f, -0.13576218f, -0.06230905f, 
    -0.05246812f, 0.15389231f, 0.15950330f, -0.05314714f, 0.02224088f, 0.03063931f, 0.00792063f, 0.14494719f, 
    0.18122193f, -0.03921452f, -0.06790358f, -0.32263517f, -0.03437072f, 0.06397969f, -0.12705819f, -0.05212067f, 
    0.04227417f, -0.13065909f, 0.12409475f, -0.30490109f, 0.24006836f, 0.14912553f, -0.33937147f, -0.39141709f, 
    -0.11668930f, 0.01975099f, -0.01197655f, 0.05276165f, 0.05061683f, -0.01202315f, 0.15107810f, -0.00102170f, 
    -0.23717995f, 0.20642087f, 0.13996033f, 0.21023929f, -0.04583842f, 0.19556771f, -0.04685541f, 0.25903201f, 
    -0.00194703f, -0.02965956f, 0.05302118f, 0.00944693f, -0.07019448f, 0.07244646f, 0.16765697f, 0.15694165f, 
    0.12989505f, -0.08224692f, -0.12062597f, -0.01948152f, -0.10330637f, -0.08857744f, -0.09425911f, -0.12261891f, 
    -0.16547720f, 0.17055799f, 0.22532602f, 0.13339618f, -0.02335271f, 0.05249549f, 0.20324120f, 0.01793433f, 
    -0.00833243f, -0.02734284f, -0.02508638f, 0.08984029f, 0.02134306f, -0.19266683f, 0.22546361f, -0.17102395f, 
    0.12287235f, 0.01241955f, 0.13324194f, 0.00753798f, -0.03827038f, 0.13225324f, -0.04713247f, 0.06893342f, 
    -0.25525320f, 0.29433000f, -0.09371839f, 0.05094467f, 0.00528655f, 0.10531814f, 0.01050009f, 0.06430127f, 
    -0.04880245f, -0.05133031f, 0.08951564f, 0.06607245f, 0.08241823f, 0.20533131f, 0.17671643f, -0.04316069f, 
    -0.06473473f, 0.19156067f, 0.04505703f, 0.00166917f, 0.15689555f, -0.05177610f, 0.04693933f, -0.02782211f, 
    0.05573443f, 0.08365338f, 0.11311524f, -0.08626063f, 0.04611714f, 0.14613152f, 0.07212617f, -0.06143909f, 
    0.18907548f, -0.00372971f, 0.02101754f, 0.06712453f, 0.08610784f, -0.36512908f, 0.14790806f, 0.12487144f, 
    -0.05942737f, -0.07844029f, -0.13520175f, -0.13962056f, -0.06206292f, -0.07067375f, 0.03388702f, 0.05832903f, 
    -0.07071318f, 0.02667963f, -0.06674968f, 0.03419228f, -0.07787178f, 0.02866516f, -0.04571696f, -0.06433725f, 
    0.04375685f, -0.02328404f, 0.00198322f, -0.05362396f, -0.03523178f, -0.02031102f, -0.05293950f, 0.05839850f, 
    0.02153498f, -0.03675212f, -0.06359304f, -0.02420295f, -0.00965335f, -0.01629359f, -0.00985303f, -0.03869734f, 
    0.01558475f, -0.05667037f, 0.03317659f, -0.06859649f, -0.05761139f, -0.00044069f, -0.00776831f, 0.02282633f, 
    0.03929330f, -0.01883787f, 0.02528661f, 0.04295471f, -0.01706894f, 0.04566767f, -0.00307099f, -0.07231239f, 
    0.02568546f, -0.03921626f, 0.00926204f, 0.02114928f, -0.04830453f, 0.02656498f, -0.07455295f, 0.00374836f, 
    0.03736268f, -0.07498067f, 0.02123865f, 0.05097222f, -0.02764669f, -0.04346325f, -0.00625957f, -0.05739939f, 
    -0.06041985f, -0.04513275f, -0.04328325f, -0.07218152f, -0.07554740f, -0.07071412f, 0.02092484f, -0.04466578f, 
    -0.06134481f, -0.06445836f, -0.04662545f, -0.02606412f, 0.00067872f, -0.01615389f, -0.05038177f, 0.02756258f, 
    0.03801999f, 0.01559086f, 0.03089734f, -0.02653293f, -0.07163975f, -0.07067352f, -0.01684728f, -0.05207136f, 
    -0.00977188f, -0.04584949f, -0.05963797f, -0.05061885f, -0.01862977f, -0.02993303f, 0.01831826f, 0.00533851f, 
    0.03697243f, -0.02329956f, -0.04323416f, -0.04700286f, 0.05169988f, -0.03843654f, 0.03163139f, -0.03313386f, 
    -0.02976091f, -0.07771641f, -0.02619167f, 0.02573969f, 0.01358796f, -0.06013062f, -0.01766308f, 0.02362043f, 
    -0.02227721f, -0.02713945f, 0.03669073f, -0.03286763f, 0.01138122f, -0.05796690f, -0.06333467f, -0.02858062f, 
    -0.03981390f, -0.06104295f, -0.00186496f, -0.02145011f, -0.06098807f, 0.00186898f, 0.03445507f, 0.06037840f, 
    0.03644475f, -0.05664486f, -0.03609726f, -0.06287076f, -0.02672345f, 0.02495894f, -0.01148758f, -0.01627368f, 
    -0.07537439f, 0.01347770f, 0.05449915f, -0.04750938f, 0.04671440f, -0.01883324f, 0.02246420f, -0.03466203f, 
    0.06601207f, -0.06263880f, -0.04209597f, -0.04712373f, 0.03758249f, -0.04034840f, -0.03580885f, -0.03869540f, 
    -0.06650247f, -0.00751045f, 0.06344979f, 0.04950984f, 0.06121977f, -0.07051142f, 0.06089734f, -0.04554484f, 
    -0.00969613f, 0.00687763f, -0.01896849f, 0.03890243f, 0.03415010f, 0.02213887f, -0.01318933f, -0.07136164f, 
    -0.01569233f, 0.01450935f, -0.01632660f, -0.02239439f, -0.03398500f, 0.00739898f, 0.01419227f, 0.04289702f, 
    0.05933021f, 0.05015584f, -0.04965145f, 0.06057473f, 0.00144827f, -0.07732440f, 0.03500055f, 0.03640555f, 
    0.02120108f, -0.03463887f, -0.03557150f, 0.00287209f, 0.00724975f, -0.07568677f, -0.01336504f, -0.01031652f, 
    -0.03625580f, -0.01029530f, 0.01933926f, 0.06346805f, 0.01411053f, 0.06500265f, -0.01337019f, -0.02399108f, 
    -0.04015604f, -0.02203861f, -0.01649800f, 0.04775058f, -0.02300249f, -0.07098529f, -0.01444281f, 0.02978195f, 
    -0.00132693f, 0.00854590f, 0.03808166f, -0.02513497f, -0.07382542f, -0.01181359f, 0.00228483f, 0.06549181f, 
    -0.03683180f, 0.05313420f, -0.05971269f, 0.03521002f, 0.04871549f, 0.05120915f, -0.03926085f, -0.05696797f, 
    -0.06656947f, 0.07074063f, -0.00578175f, -0.07350069f, -0.03624633f, 0.04242070f, -0.05641469f, -0.02651403f, 
    0.03320097f, -0.02508566f, 0.01366317f, -0.00626256f, -0.00819762f, 0.05229527f, 0.02228528f, 0.00891901f, 
    -0.04085473f, -0.05376456f, 0.01063848f, 0.00542617f, -0.04261098f, -0.00162191f, 0.07032958f, 0.04056033f, 
    -0.05853291f, -0.03442702f, 0.04085397f, 0.01777452f, 0.04500617f, -0.04253306f, 0.04108290f, -0.07283856f, 
    -0.05045344f, -0.04297179f, -0.01607149f, -0.06669968f, 0.06354647f, 0.06333278f, -0.02729930f, 0.04340210f, 
    -0.05074073f, 0.00974088f, -0.03544903f, -0.04890852f, 0.06247817f, -0.06995161f, -0.05755485f, 0.05226250f, 
    0.01793174f, 0.06408357f, 0.05715822f, 0.02493342f, -0.04319189f, -0.07141337f, -0.06309506f, -0.02938388f, 
    -0.04729164f, -0.04616172f, -0.01334364f, 0.04639071f, 0.05694023f, -0.00679232f, 0.04877427f, -0.05855983f, 
    -0.04856963f, -0.05870472f, -0.06634210f, 0.03133423f, 0.00303469f, 0.04603422f, -0.06964983f, -0.06457090f, 
    -0.04579035f, -0.03059849f, -0.02410326f, 0.03595550f, -0.03392813f, 0.04009847f, -0.03249042f, 0.05525158f, 
    0.04114447f, -0.04108233f, 0.00723041f, -0.04595058f, -0.05591111f, -0.05591102f, -0.03454357f, -0.06614787f, 
    -0.03606613f, -0.03529844f, -0.01691256f, -0.03805032f, -0.03274743f, -0.00541763f, 0.03822376f, -0.03058324f, 
    0.04820228f, -0.04916927f, -0.02925486f, -0.04195487f, 0.04054150f, 0.06514040f, -0.02205719f, -0.03819172f, 
    -0.05753421f, -0.07552747f, 0.05304512f, -0.03239269f, -0.00786661f, -0.01772233f, 0.02585500f, 0.03830682f, 
    -0.06879363f, -0.06852404f, -0.04218080f, -0.06633983f, 0.04463984f, -0.01615451f, -0.06840301f, -0.06260058f, 
    -0.06036793f, 0.01399111f, -0.05421130f, -0.05117342f, 0.01488682f, 0.06553005f, -0.05969587f, -0.05544841f, 
    0.01886347f, -0.06828067f, 0.04913124f, -0.03724667f, 0.03133996f, -0.06866499f, -0.00587143f, 0.05886362f, 
    -0.04696030f, -0.02009772f, 0.06062841f, 0.06203268f, -0.01318750f, 0.04574232f, -0.01270482f, 0.03109560f, 
    -0.02161507f, 0.00553846f, -0.03793932f, -0.02588464f, -0.00780563f, 0.04128274f, 0.03022788f, -0.07768994f, 
    -0.03105086f, -0.01819756f, 0.05199011f, 0.04910995f, 0.01272430f, 0.05940905f, -0.06980117f, -0.05075912f, 
    0.03764779f, 0.06986048f, -0.05737665f, 0.00415795f, 0.05559220f, -0.00340959f, 0.00059308f, -0.01430564f, 
    0.16160722f, 0.16069844f, 0.21721174f, 0.06647212f, -0.08702351f, -0.05255254f, -0.03966402f, 0.07963508f, 
    0.11458217f, 0.07497695f, 0.01912668f, 0.04491635f, 0.07891225f, 0.10739317f, 0.07363352f, -0.20465447f, 
    0.14940575f, -0.03464609f, -0.01018146f, 0.01700209f, -0.11443151f, -0.06387479f, -0.08927586f, -0.21981622f, 
    -0.29415089f, -0.04702588f, -0.11802380f, 0.10202679f, -0.09422234f, -0.07002235f, 0.02413883f, -0.14746507f, 
    0.06718881f, 0.11968695f, -0.09042875f, -0.19559152f, 0.00527790f, 0.19550578f, 0.07241792f, 0.17090373f, 
    -0.16961433f, 0.02962408f, -0.00746031f, -0.02425417f, 0.10674962f, 0.07083622f, 0.05297484f, 0.00191026f, 
    -0.22641288f, -0.09980018f, -0.00824760f, 0.03773777f, 0.01488968f, 0.02238286f, 0.09811407f, -0.04758905f, 
    0.06842471f, -0.19952741f, -0.01463953f, -0.10092849f, -0.01080180f, 0.06349631f, 0.03013826f, -0.07398858f, 
    -0.00717920f, 0.16543458f, 0.08909155f, -0.11825237f, -0.06785600f, 0.14654697f, 0.17908488f, 0.07539494f, 
    -0.02006435f, -0.20466596f, -0.45999083f, -0.30214339f, 0.04269837f, 0.09628993f, 0.11052120f, 0.04723338f, 
    0.11627035f, -0.12774014f, 0.00405736f, -0.29704267f, 0.25226155f, 0.13880371f, -0.09668645f, -0.11020496f, 
    0.16569282f, 0.07733062f, 0.07281138f, 0.16092841f, 0.13592677f, 0.03776093f, 0.06430838f, 0.06369861f, 
    -0.17619158f, -0.01524670f, 0.16278857f, 0.09477361f, 0.00814130f, 0.11874503f, -0.12092824f, 0.28426045f, 
    0.15482002f, 0.06787530f, -0.09700099f, 0.01311930f, -0.13835974f, -0.07784814f, 0.20538835f, 0.01582151f, 
    -0.07744839f, -0.03401461f, -0.00540796f, 0.11392041f, -0.10138074f, -0.24049465f, -0.14254940f, -0.22246724f, 
    -0.24295147f, -0.05927269f, 0.03023090f, 0.08678745f, 0.06114850f, 0.21430300f, 0.05039642f, 0.06981403f, 
    -0.03701916f, -0.04516341f, -0.00765795f, -0.01071072f, 0.07859447f, 0.03986351f, 0.00533808f, 0.03252741f, 
    -0.08407535f, 0.04295134f, 0.14976314f, -0.15621237f, 0.19945244f, 0.06290162f, -0.04159356f, 0.06774789f, 
    -0.06086621f, 0.08802467f, -0.08664863f, 0.00747043f, 0.06760635f, -0.03801942f, 0.12922423f, 0.21704789f, 
    0.08003262f, 0.03633860f, 0.08985145f, 0.07039107f, -0.08951774f, 0.08226733f, 0.13192931f, -0.08699460f, 
    0.14979906f, 0.13220669f, 0.03312849f, -0.14030218f, 0.00771208f, -0.08897300f, -0.04842130f, -0.03752642f, 
    0.04620550f, -0.16668716f, -0.15007536f, 0.03727970f, 0.10026456f, 0.34658891f, 0.08143028f, -0.04200174f, 
    0.11086363f, -0.03245342f, -0.03865242f, 0.14839616f, -0.03691952f, -0.24248560f, 0.02011212f, 0.08522996f, 
    -0.09695186f, -0.10126484f, 0.01461122f, -0.04584265f, 0.00642862f, -0.04064261f, -0.03360965f, 0.13129330f, 
    -0.00140729f, 0.05188125f, -0.04255338f, -0.04107048f, -0.06361021f, -0.02059473f, 0.05448643f, -0.02540856f, 
    0.04696655f, 0.05388176f, -0.04424171f, -0.03379136f, -0.03140207f, 0.05406882f, 0.02362644f, -0.05293024f, 
    -0.01338082f, 0.00245477f, 0.06137355f, 0.00389957f, 0.00135864f, -0.00422867f, -0.07718197f, 0.05632266f, 
    0.01702905f, 0.05498671f, -0.06033427f, -0.06958043f, -0.03128765f, 0.01891684f, -0.01935332f, -0.05385608f, 
    -0.05673428f, -0.08011267f, -0.04748030f, -0.02907390f, 0.05854432f, -0.00696503f, -0.05794002f, -0.04814581f, 
    -0.06905826f, 0.02634056f, -0.04187006f, 0.00457577f, -0.00858173f, -0.05650183f, -0.04248878f, 0.06377716f, 
    -0.04538608f, 0.02884011f, 0.01580754f, 0.06792623f, -0.05979617f, -0.04868773f, 0.00435917f, -0.01254577f, 
    -0.05564451f, -0.03953314f, 0.05359563f, -0.03820958f, -0.02161552f, -0.01659154f, -0.01426781f, 0.06122944f, 
    -0.01183425f, 0.03381571f, -0.01257782f, 0.05639257f, 0.03768624f, -0.04235128f, 0.03816995f, -0.04576974f, 
    0.03856678f, 0.01819379f, -0.05393663f, -0.01423406f, -0.06815136f, 0.04926465f, -0.01217033f, -0.07847964f, 
    -0.00468250f, -0.02897279f, -0.02720454f, -0.05648933f, -0.06843887f, -0.05554249f, -0.00807241f, -0.05231661f, 
    0.00933554f, 0.04478507f, -0.01304091f, -0.07882130f, -0.02061492f, -0.06984258f, -0.08077892f, 0.02415377f, 
    -0.00520850f, 0.02307689f, -0.03067788f, -0.00320547f, 0.02941169f, 0.00863004f, -0.06552272f, -0.00735150f, 
    0.05268047f, -0.01964281f, -0.05194166f, 0.03983250f, -0.02374042f, -0.00052578f, 0.05346291f, 0.00756814f, 
    0.04003763f, 0.00716126f, -0.03274405f, 0.03838962f, -0.07458481f, 0.03357773f, 0.03316481f, 0.02247369f, 
    -0.06462622f, 0.03258796f, -0.02851158f, -0.04658650f, -0.07195001f, 0.05417751f, -0.06285252f, -0.02851507f, 
    0.01667164f, -0.01907669f, 0.05542444f, -0.03610805f, -0.04745025f, -0.01788619f, -0.00585380f, -0.06503765f, 
    -0.03778905f, -0.03934170f, 0.03244299f, 0.02064111f, -0.07408589f, -0.06148276f, -0.03538088f, -0.03496910f, 
    0.01395968f, -0.02932715f, -0.05294728f, 0.02541404f, 0.02237349f, -0.03884808f, 0.00881044f, 0.05041233f, 
    -0.02255136f, 0.02693394f, 0.03037734f, -0.06333277f, -0.08155363f, -0.03454123f, -0.07313015f, 0.00580429f, 
    0.01088621f, -0.01996803f, 0.00723622f, -0.04021176f, 0.05528332f, 0.04305753f, 0.00594505f, 0.00598053f, 
    0.00394146f, 0.05534161f, -0.04460918f, -0.07265089f, -0.00775277f, -0.00467815f, -0.00816870f, 0.01660631f, 
    0.01550679f, -0.00296760f, 0.02730318f, 0.00860721f, -0.07432611f, 0.04350638f, 0.06495636f, -0.03623921f, 
    -0.05486540f, 0.03332995f, -0.04688261f, 0.00478986f, -0.06608330f, -0.05680529f, -0.08078958f, 0.02872271f, 
    -0.05724200f, -0.06026444f, 0.05965958f, 0.03432173f, 0.04885671f, 0.02581553f, 0.03502861f, 0.01797080f, 
    0.05758307f, -0.02183300f, -0.05052253f, -0.04278102f, -0.05473482f, 0.06030694f, -0.07124256f, 0.04243220f, 
    -0.03671945f, 0.00793280f, -0.00945630f, -0.04318907f, -0.03342124f, 0.03300007f, -0.04123272f, 0.05524225f, 
    -0.05385851f, -0.07462144f, 0.03400965f, 0.01574865f, 0.05125058f, -0.06746328f, -0.03618922f, -0.00887874f, 
    -0.05183442f, -0.06871956f, 0.00386130f, 0.00928075f, -0.06717300f, -0.00767345f, 0.03966662f, -0.06776718f, 
    0.03415697f, -0.05618737f, 0.01544174f, 0.01978189f, 0.04614307f, -0.01348025f, 0.03523931f, -0.04851355f, 
    -0.01969425f, -0.01810982f, 0.05696336f, -0.02308574f, -0.06214647f, -0.06789114f, -0.03974387f, -0.06662761f, 
    -0.02990517f, 0.01212572f, -0.05971599f, 0.04642364f, -0.06009749f, -0.02918880f, -0.05796931f, 0.01762293f, 
    0.01069411f, 0.06017872f, -0.00554815f, -0.04132828f, -0.02918464f, 0.02325686f, -0.04196874f, -0.07019807f, 
    0.04532374f, -0.05593676f, -0.05237338f, -0.00165588f, 0.00206630f, -0.00456269f, 0.04097215f, 0.04278009f, 
    -0.05789885f, -0.07567546f, 0.05015409f, 0.01805122f, 0.01471083f, 0.04328328f, -0.06172809f, 0.00651860f, 
    0.07119658f, 0.04033801f, -0.05855153f, -0.04365621f, -0.06369099f, 0.00827537f, -0.04737065f, -0.01663433f, 
    0.02668924f, -0.03352457f, -0.08053703f, -0.05897966f, -0.03835710f, -0.04044923f, -0.01802515f, 0.02403957f, 
    -0.03623390f, 0.01147429f, -0.06368107f, -0.02391343f, -0.03592484f, -0.06978083f, 0.03853501f, 0.05222661f, 
    0.00966018f, 0.01477421f, -0.05118971f, -0.04152675f, -0.06998090f, -0.07427323f, 0.02333169f, -0.07252144f, 
    0.02416558f, -0.04094441f, 0.03103838f, 0.04507411f, -0.05860589f, -0.03131159f, -0.00753134f, -0.00950903f, 
    -0.04494004f, 0.02732503f, -0.03521842f, -0.02905297f, 0.03909111f, 0.00381760f, -0.01722108f, -0.03278916f, 
    -0.04619657f, -0.05865891f, -0.01260499f, 0.04154561f, 0.00580369f, 0.00187994f, 0.05864812f, 0.07094634f, 
    0.02405467f, -0.04479020f, -0.02607396f, -0.04144857f, 0.02441546f, 0.04928392f, -0.05874770f, 0.00555173f, 
    -0.03234521f, 0.02975021f, -0.01413680f, -0.04724744f, -0.03903341f, -0.06351548f, -0.06282217f, -0.07248466f, 
    -0.05339095f, -0.00448329f, -0.07914790f, -0.01671506f, 0.05661020f, -0.07562522f, -0.04192931f, 0.00210284f, 
    -0.05737305f, -0.01320599f, -0.06111274f, -0.06826257f, -0.05701648f, 0.01052148f, 0.04838402f, -0.00471679f, 
    0.02081540f, -0.00564374f, 0.01063777f, -0.05382298f, 0.04816930f, -0.07296403f, -0.04575670f, -0.03825562f, 
    0.01330932f, 0.04485674f, -0.00696382f, 0.03944092f, -0.05300498f, -0.04043236f, 0.04375013f, -0.00975220f, 
    0.00640116f, 0.09857207f, -0.13955399f, -0.10838537f, 0.05979086f, -0.11436126f, 0.10648038f, -0.05997493f, 
    0.12938683f, 0.05313304f, 0.06020228f, -0.07857510f, 0.25211370f, -0.24163277f, 0.30602643f, -0.27491572f, 
    0.13123833f, 0.05037486f, -0.13318279f, 0.11241531f, 0.04768633f, -0.00602607f, -0.11769194f, -0.09428098f, 
    -0.08426392f, 0.25537369f, -0.07319298f, 0.01181457f, -0.20029524f, -0.09067503f, -0.05059735f, -0.09529328f, 
    0.01522883f, 0.19010840f, -0.02583035f, 0.03569894f, -0.00673582f, 0.03954501f, -0.06159052f, -0.00269198f, 
    -0.03841956f, 0.03887307f, -0.18210177f, -0.13795376f, 0.12177197f, 0.12542756f, -0.01102151f, 0.07644609f, 
    -0.25234979f, 0.15228371f, -0.07695793f, 0.09778309f, -0.12008570f, 0.15891224f, -0.04725640f, -0.06983431f, 
    0.03735593f, -0.15811385f, -0.06538486f, 0.08156896f, -0.16306275f, 0.14394869f, -0.18108879f, -0.04474643f, 
    0.06580301f, -0.03091206f, 0.34858453f, 0.04276031f, 0.00140273f, 0.12840477f, -0.13931975f, 0.09410600f, 
    0.24241342f, -0.23699848f, -0.10595652f, -0.19157873f, 0.05065389f, -0.12528530f, -0.19792479f, 0.17198741f, 
    0.07010460f, -0.08427812f, 0.03524446f, -0.16360351f, 0.22378950f, 0.20900483f, -0.31139860f, -0.24501562f, 
    -0.12426659f, 0.05203829f, 0.02333567f, 0.14067452f, 0.02301927f, 0.06184824f, 0.02458166f, -0.07989782f, 
    -0.28251353f, 0.11168244f, 0.10740418f, 0.24341057f, 0.03914576f, 0.21418819f, -0.11371453f, 0.15020370f, 
    0.00046089f, 0.09952068f, 0.03198713f, 0.03990224f, -0.01969248f, -0.00439923f, 0.07339490f, 0.11456580f, 
    0.11421305f, -0.17176971f, -0.07280770f, -0.10084791f, 0.04386232f, -0.16822994f, -0.11014609f, -0.04403258f, 
    -0.15531352f, 0.23325634f, 0.14740781f, 0.09005638f, 0.03384741f, 0.10448917f, 0.16356221f, 0.10345203f, 
    0.00293635f, 0.06662136f, -0.06523824f, 0.01652302f, -0.15395856f, -0.23190418f, 0.16125391f, -0.13967794f, 
    0.12282335f, 0.10901616f, 0.09664995f, 0.13047130f, -0.10707106f, 0.12973145f, 0.02361133f, -0.02074832f, 
    -0.00585147f, 0.40179047f, 0.03498730f, 0.04212224f, -0.05980662f, 0.10295323f, 0.05810713f, 0.25536558f, 
    -0.06213987f, -0.09373418f, 0.08708572f, 0.13889298f, 0.14509186f, 0.11331774f, 0.12580240f, -0.01912271f, 
    -0.07828388f, 0.04162201f, 0.08052500f, 0.10074481f, 0.12035298f, -0.01197541f, 0.06568643f, -0.06958465f, 
    0.05294268f, 0.03804203f, 0.05349708f, -0.02515811f, 0.04648827f, 0.13745144f, 0.19709809f, 0.01980247f, 
    0.11011281f, -0.10829691f, -0.06420704f, 0.22773173f, 0.45568743f, -0.08812874f, 0.14168052f, 0.05674685f, 
    -0.09490453f, -0.00812844f, -0.28317887f, -0.21203589f, 0.06737088f, 0.07561613f, 0.14265653f, -0.05023824f, 
    0.16557398f, -0.30792049f, -0.36525202f, -0.05838944f, 0.04491734f, 0.07655101f, 0.07283513f, -0.07271223f, 
    -0.03670791f, 0.07157378f, 0.00387386f, -0.06252880f, -0.06573288f, -0.32920283f, 0.23226430f, 0.04055288f, 
    0.11484024f, 0.08302689f, -0.03132011f, -0.00371493f, 0.24018644f, 0.06124838f, 0.02946346f, 0.03937245f, 
    -0.20765655f, 0.29198474f, 0.20313329f, 0.00114452f, -0.01500629f, -0.12586211f, -0.05327519f, -0.04496713f, 
    0.17755221f, -0.03403675f, 0.06423061f, 0.15390830f, -0.07156373f, -0.02888224f, -0.07943568f, 0.26753390f, 
    0.03823027f, 0.09645717f, -0.04584425f, 0.02881414f, -0.01683025f, 0.00800554f, -0.03781055f, 0.00141008f, 
    -0.10262612f, 0.03963367f, -0.02224650f, -0.08704866f, -0.07993501f, -0.00263830f, 0.02129769f, -0.04786847f, 
    0.15170322f, -0.07530720f, 0.02295809f, 0.08445068f, -0.05500398f, -0.22363880f, -0.26874748f, -0.05076101f, 
    0.19038492f, 0.12314421f, 0.10473933f, 0.08767369f, 0.06840467f, 0.05727838f, -0.09118280f, -0.06534967f, 
    0.14375120f, 0.44852018f, 0.28863424f, -0.01680020f, -0.09639176f, -0.05606654f, -0.25463194f, 0.10093663f, 
    -0.05305571f, 0.03078484f, 0.05558406f, 0.03254441f, 0.27093956f, 0.44022569f, -0.08170893f, 0.04032271f, 
    0.02711534f, -0.09809659f, 0.08494953f, 0.02041115f, 0.08724029f, 0.03872132f, 0.08306772f, -0.08953118f, 
    -0.19484819f, 0.07724054f, -0.29709429f, -0.09813644f, -0.02487445f, 0.05482583f, 0.05269938f, 0.01675951f, 
    -0.03765776f, 0.09139382f, 0.06457037f, 0.08262120f, -0.11104290f, -0.02375622f, -0.26287687f, -0.03488450f, 
    0.01547445f, 0.00250667f, 0.02317567f, 0.03447806f, 0.08542171f, -0.05655590f, -0.03490868f, 0.07041855f, 
    -0.43922573f, 0.04408300f, -0.01850235f, 0.13003501f, -0.08036520f, -0.01542177f, 0.05904618f, -0.10371624f, 
    0.01341109f, 0.06079073f, -0.00416827f, 0.03340652f, -0.32478407f, -0.22120433f, -0.09937995f, 0.06733556f, 
    0.02607283f, 0.04225361f, 0.16251415f, 0.11309336f, -0.03243445f, 0.02646235f, 0.06331887f, -0.09465837f, 
    -0.01934730f, 0.21314405f, 0.07271519f, 0.24405253f, 0.05628720f, 0.13758428f, -0.07036107f, 0.04163785f, 
    -0.00074589f, -0.19518501f, 0.09083618f, 0.17460784f, -0.03530823f, 0.12769867f, 0.10602910f, -0.11518040f, 
    -0.05024729f, -0.12990884f, 0.00326167f, 0.09329332f, 0.01588329f, 0.11865389f, 0.14376867f, 0.05875387f, 
    0.16755645f, 0.27706686f, 0.13686660f, -0.04527840f, -0.08258846f, -0.06451467f, -0.06049870f, 0.02731109f, 
    -0.04881933f, -0.10883348f, -0.03646900f, -0.07384601f, 0.03098726f, -0.24748221f, 0.34052444f, 0.14369862f, 
    0.03252866f, -0.12714645f, -0.05632367f, -0.02976662f, 0.01674743f, -0.05003575f, 0.02153512f, -0.01575743f, 
    0.18638192f, -0.15781593f, -0.49967355f, 0.22577098f, -0.08095653f, -0.02536657f, 0.14962605f, 0.00284145f, 
    -0.02150476f, -0.02299820f, -0.00415947f, -0.02574792f, 0.08697750f, 0.00378022f, 0.11577482f, 0.06700946f, 
    0.01823580f, 0.09885472f, 0.04448434f, 0.11604203f, -0.04608629f, 0.13842732f, -0.03529194f, 0.01710350f, 
    0.11648406f, 0.22656631f, 0.39193720f, -0.30754009f, -0.12080309f, 0.06964269f, -0.04867097f, -0.23703243f, 
    0.06504131f, 0.00960158f, -0.12195449f, 0.18139064f, -0.13548616f, 0.01024110f, -0.04002384f, -0.08083186f, 
    -0.15152232f, 0.00631587f, -0.21870595f, 0.09236500f, 0.04039263f, -0.08162383f, -0.00422702f, 0.08092238f, 
    0.06248523f, -0.11332998f, 0.15240557f, 0.31829622f, -0.06764250f, 0.11253539f, -0.03636914f, 0.21870641f, 
    0.07322812f, -0.21818127f, -0.12322313f, 0.02553841f, 0.02547574f, 0.08269312f, -0.40009016f, 0.30173641f, 
    -0.14282222f, 0.08651181f, 0.08440678f, -0.08149105f, 0.03470920f, -0.08934573f, -0.07525408f, 0.02071848f, 
    -0.10648053f, -0.06839277f, -0.14441131f, -0.06019463f, 0.04374145f, -0.06038646f, -0.21862295f, 0.28099924f, 
    0.06943834f, -0.09931592f, 0.01654815f, -0.10537528f, 0.24519801f, 0.11783779f, -0.34598544f, 0.08914337f, 
    -0.20194554f, -0.03461709f, 0.05587073f, -0.08794973f, -0.04722147f, -0.03853814f, -0.11034133f, -0.11096018f, 
    -0.12170321f, 0.13005666f, 0.01047237f, 0.10719892f, 0.02436991f, 0.11924417f, 0.29324439f, 0.01397626f, 
    0.09325570f, 0.14324164f, 0.04293943f, 0.15509076f, 0.02483638f, -0.14381620f, -0.03033347f, -0.02266682f, 
    -0.11570986f, -0.12061296f, 0.00484699f, -0.08144426f, -0.01522847f, -0.11572573f, -0.00262235f, -0.09188884f, 
    -0.05292611f, 0.29115552f, 0.38894400f, -0.08339416f, -0.00634906f, 0.17618632f, 0.02033818f, -0.12579340f, 
    -0.05988606f, 0.05319892f, -0.02446532f, -0.00566572f, -0.01190273f, -0.17262040f, 0.19722243f, 0.04651502f, 
    0.14461312f, 0.04793304f, 0.09519855f, 0.14946134f, -0.06300426f, 0.10133017f, -0.08066484f, 0.16412733f, 
    0.00453052f, 0.17227420f, 0.23928721f, 0.21980803f, 0.01475215f, 0.05464582f, -0.05385684f, -0.04500834f, 
    0.13696605f, -0.06487826f, 0.02706171f, 0.01494236f, 0.02595822f, 0.25610918f, -0.03163126f, -0.12078173f, 
    -0.10302217f, -0.13171893f, 0.03001832f, 0.15585133f, -0.11981781f, -0.02678305f, 0.02983125f, 0.20008105f, 
    0.03695504f, -0.07163156f, 0.05298313f, -0.00496325f, 0.00110310f, -0.01652036f, -0.14824417f, 0.12645909f, 
    0.04234583f, -0.06962521f, -0.06131841f, 0.05457952f, -0.18568322f, -0.10203867f, 0.41701713f, -0.18955071f, 
    -0.01379481f, -0.19313256f, -0.13751374f, -0.10492172f, 0.10315611f, -0.00084826f, 0.16026238f, 0.03213751f, 
    -0.04743502f, -0.06844212f, 0.01294500f, 0.04583919f, 0.03567097f, -0.07231843f, -0.06533855f, -0.00297769f, 
    -0.05557918f, 0.01124759f, 0.01868805f, 0.05030281f, 0.00961151f, -0.02426532f, 0.02574745f, -0.00145119f, 
    -0.01082458f, 0.01775595f, 0.01014276f, -0.06398682f, 0.06348721f, -0.02105216f, -0.04319898f, -0.02523663f, 
    0.02085631f, 0.05824426f, 0.02618005f, -0.00683063f, -0.06310325f, -0.06132471f, 0.00893749f, -0.02214693f, 
    -0.00571359f, -0.02476369f, -0.05581902f, 0.05159647f, 0.02591107f, -0.00772102f, -0.04971159f, -0.01000723f, 
    0.04384338f, -0.05323112f, 0.05706171f, -0.06853691f, -0.06955858f, -0.06150306f, -0.04683269f, 0.05793898f, 
    0.00005799f, 0.00486088f, -0.05598953f, 0.03967469f, -0.01221442f, -0.04016323f, -0.06520785f, -0.04873666f, 
    -0.02565861f, -0.05496687f, 0.07232599f, -0.07496753f, 0.04638021f, -0.00095814f, -0.01894099f, 0.01505779f, 
    0.04294388f, 0.03924660f, -0.03863487f, 0.00320387f, -0.01090735f, 0.03236360f, -0.00919974f, -0.03180544f, 
    -0.07327650f, -0.01003449f, -0.06640406f, -0.05445511f, -0.05450371f, 0.03750131f, -0.05515726f, 0.00066022f, 
    -0.03870626f, 0.02444679f, -0.01972013f, -0.02963266f, -0.01134177f, -0.03721542f, 0.00192466f, 0.04729981f, 
    -0.02578112f, -0.02241687f, -0.07541382f, -0.02315933f, 0.02382368f, -0.07254115f, -0.01706716f, 0.02061455f, 
    -0.07120638f, -0.03488245f, -0.02742484f, -0.03091311f, 0.00126775f, -0.05835970f, -0.05494113f, 0.00549191f, 
    0.00492614f, -0.05663653f, -0.01945611f, 0.03326385f, -0.06766098f, -0.04171338f, -0.02325943f, -0.05638695f, 
    -0.02404644f, 0.03597198f, -0.00273160f, -0.01088942f, 0.03938535f, -0.02017006f, -0.02175076f, 0.06297708f, 
    0.03628952f, 0.04164810f, -0.07928564f, -0.06212210f, -0.05090421f, -0.03046981f, -0.06392825f, 0.00103675f, 
    0.01056888f, -0.03689895f, 0.07256758f, -0.05049971f, -0.04251127f, -0.06187783f, -0.02528267f, 0.00774777f, 
    -0.03525072f, -0.01471603f, 0.05717263f, -0.00985203f, -0.05606057f, 0.04153050f, -0.00944644f, 0.02898888f, 
    -0.04259576f, 0.01788587f, -0.05992697f, -0.05115482f, 0.01121519f, -0.02051309f, 0.00544042f, -0.00913204f, 
    0.00422378f, -0.01515473f, 0.01828215f, 0.00194229f, 0.03304129f, -0.06161505f, -0.01136403f, -0.03662286f, 
    0.03130735f, 0.00898279f, 0.01191125f, -0.00325830f, -0.06871689f, 0.00361018f, 0.00982483f, -0.03523956f, 
    -0.01276444f, 0.05420886f, 0.03560772f, -0.04255673f, -0.07087515f, -0.05797766f, 0.00399788f, 0.05345919f, 
    0.05792283f, 0.06288861f, -0.03899647f, -0.07885297f, 0.05461431f, -0.00656372f, -0.01787852f, -0.05744031f, 
    -0.07693596f, -0.05063595f, 0.06622164f, -0.04183665f, 0.00338399f, -0.02388297f, 0.02724697f, 0.04665728f, 
    0.49539739f, 0.18066284f, 0.00254217f, 0.10549211f, -0.02921409f, 0.05435529f, 0.02511549f, 0.01310236f, 
    0.05857158f, -0.04592215f, 0.06554618f, -0.09903950f, -0.09207471f, -0.45773795f, 0.01415237f, 0.11442827f, 
    -0.04692917f, 0.25255644f, -0.04130631f, 0.22423382f, 0.22367412f, 0.01290415f, 0.16605449f, 0.23486415f, 
    -0.44714355f, 0.16953924f, 0.26028728f, 0.23150432f, -0.00842760f, -0.07229728f, -0.07590140f, 0.04312185f, 
    0.03925729f, 0.03594615f, 0.08484749f, 0.02910523f, 0.24850762f, 0.16719697f, -0.07790092f, 0.08172029f, 
    0.07391850f, 0.13116357f, 0.00016859f, 0.04351383f, -0.08186182f, -0.06560146f, -0.06442373f, -0.17804855f, 
    -0.39552149f, 0.01146538f, 0.16297108f, -0.26570365f, -0.02735870f, -0.04275082f, 0.20693986f, -0.05960385f, 
    0.10815649f, 0.08753625f, 0.08440149f, 0.13426852f, 0.13923465f, 0.02950614f, -0.13294108f, -0.00845799f, 
    0.08393685f, -0.11528208f, -0.01400237f, -0.06017306f, -0.16878866f, 0.09130038f, -0.11214205f, -0.24889457f, 
    -0.05457747f, -0.09640943f, 0.45232973f, -0.08861984f, -0.12888256f, -0.09551859f, -0.04793287f, 0.06798533f, 
    -0.04755885f, 0.11565292f, 0.05006941f, 0.11062012f, -0.00869897f, 0.17625660f, -0.01033845f, -0.30527493f, 
    0.03249801f, -0.00431380f, 0.13730533f, 0.06440461f, 0.10721528f, 0.01839223f, 0.05868814f, 0.08094763f, 
    -0.15702178f, 0.07611012f, -0.24548639f, 0.15932417f, 0.06173314f, 0.08899601f, -0.03658170f, 0.12634301f, 
    -0.00667581f, 0.03192316f, 0.14389533f, -0.08972317f, -0.08711827f, -0.02048450f, -0.01621229f, 0.22002800f, 
    0.00433199f, -0.00224742f, 0.06897182f, 0.05961773f, 0.38383132f, 0.01038042f, 0.15961468f, 0.27979213f, 
    -0.34214669f, 0.24400689f, -0.04150375f, 0.01066451f, 0.02458156f, -0.11667619f, -0.03872615f, -0.01849170f, 
    -0.18602408f, -0.16301386f, -0.06234182f, -0.10871179f, -0.30641681f, -0.09539682f, -0.03906327f, -0.09181041f, 
    -0.01584720f, -0.00187038f, -0.10963568f, 0.12812594f, -0.15374893f, -0.10380749f, 0.08676314f, -0.21831995f, 
    -0.16554503f, 0.16607301f, -0.02764404f, -0.02363480f, 0.01217277f, 0.06700651f, 0.13167228f, 0.06695516f, 
    -0.00078287f, -0.09896053f, -0.08698741f, 0.09835795f, -0.02751052f, -0.10260623f, 0.19411711f, -0.01224792f, 
    -0.06469893f, -0.07925718f, 0.16113766f, 0.12261773f, 0.09849712f, 0.13837491f, -0.02862033f, -0.10962748f, 
    -0.12724023f, 0.01586475f, 0.18123682f, -0.15626429f, -0.00934771f, -0.00038142f, 0.14306527f, 0.13312632f, 
    -0.02273223f, 0.03596391f, -0.09876728f, -0.04013028f, 0.24031432f, 0.09121820f, -0.00730353f, 0.11162042f, 
    0.07529360f, 0.06209727f, 0.00022589f, -0.07277180f, -0.09301653f, 0.02818960f, -0.02876758f, -0.01616303f, 
    -0.29310107f, -0.28058901f, -0.17068624f, -0.09993007f, -0.05795499f, -0.02340998f, -0.15497132f, 0.03945787f, 
    0.06919232f, -0.00957591f, 0.06421776f, 0.06777950f, -0.08918959f, 0.30084661f, 0.26606125f, -0.02670679f, 
    -0.00985915f, -0.11083467f, -0.02997046f, -0.02957926f, 0.10630501f, 0.00976688f, -0.14747010f, -0.01544379f, 
    -0.09441653f, 0.13689382f, 0.01611672f, -0.17303045f, 0.03181830f, -0.02382260f, 0.06690530f, 0.00562982f, 
    -0.09332671f, 0.07754227f, 0.00843567f, -0.16890928f, -0.27121043f, -0.11216445f, -0.00866365f, 0.11312559f, 
    -0.10926962f, -0.01894429f, -0.10778597f, 0.03602979f, 0.03514926f, 0.02280954f, 0.04160446f, 0.11464025f, 
    -0.10879455f, -0.15011270f, -0.17451270f, -0.01505246f, 0.01066480f, -0.06416290f, -0.20789438f, -0.09901181f, 
    -0.04408647f, -0.14798217f, -0.01201220f, -0.05517381f, -0.15039431f, -0.11220732f, -0.11687763f, 0.04326164f, 
    -0.05702909f, 0.19306506f, -0.03051334f, -0.28109089f, 0.13526575f, 0.08446916f, 0.06277834f, 0.17976288f, 
    0.24153949f, 0.26722920f, -0.09767199f, 0.18123521f, 0.18076444f, 0.18257812f, 0.06470746f, -0.12774980f, 
    -0.02771283f, 0.06305654f, 0.07968362f, -0.00320789f, 0.06064777f, 0.17739858f, -0.07647707f, 0.00266673f, 
    0.08754302f, 0.07452805f, -0.08174905f, -0.04795657f, 0.02458036f, -0.01515747f, 0.03646603f, -0.05135858f, 
    0.01780139f, -0.22337528f, 0.02450253f, -0.20144249f, -0.09708359f, -0.04490926f, 0.01050396f, 0.15330762f, 
    0.01552211f, 0.04118964f, 0.05840188f, 0.00923697f, -0.13161670f, -0.03480595f, -0.04642449f, -0.00724215f, 
    0.01691275f, 0.01824032f, -0.08744600f, 0.07476374f, -0.02917392f, -0.01703622f, -0.08847608f, -0.15234365f, 
    -0.18795815f, 0.31760004f, -0.25572315f, 0.09954334f, 0.06088558f, 0.11023725f, 0.14876007f, 0.17085230f, 
    0.08521430f, 0.06036160f, 0.01908525f, 0.12551218f, -0.11893424f, 0.14847839f, 0.13076925f, 0.16688122f, 
    0.03135736f, -0.06967714f, -0.01791788f, 0.01107146f, 0.12693997f, 0.00282212f, 0.02248836f, 0.05511862f, 
    0.41710788f, 0.15394062f, 0.06166496f, 0.01067989f, 0.04130698f, 0.01609188f, 0.07443365f, 0.11806987f, 
    -0.09339565f, 0.14877905f, 0.07567600f, 0.14815401f, 0.12093269f, 0.09980668f, 0.09936706f, 0.35637325f, 
    0.24103411f, 0.33606783f, 0.00786499f, 0.10059375f, 0.14114489f, -0.05052156f, 0.11556033f, 0.10887181f, 
    0.24467798f, 0.14061151f, 0.11190723f, 0.23917453f, -0.07746769f, 0.34344870f, 0.19828761f, 0.04162127f, 
    0.06495506f, 0.01168829f, 0.18506888f, 0.09988593f, -0.19887273f, -0.26052561f, 0.00950707f, 0.02546536f, 
    0.03028443f, -0.02039228f, -0.04580377f, 0.04556617f, -0.12805726f, -0.03382263f, 0.12183149f, 0.08843495f, 
    -0.48524830f, -0.14565697f, 0.20456575f, -0.08837990f, -0.04541680f, -0.05840859f, -0.30353281f, 0.06834296f, 
    -0.13342313f, -0.18514997f, -0.05076833f, 0.00850613f, 0.17010006f, 0.25355044f, -0.05033477f, 0.02528127f, 
    0.12023021f, -0.05511584f, 0.17621431f, 0.04809052f, 0.07618539f, 0.13152201f, 0.06523268f, 0.19184704f, 
    0.10701834f, -0.26214138f, -0.26054651f, 0.17004532f, 0.03041453f, 0.03326992f, 0.08865819f, 0.23178971f, 
    0.01575665f, -0.03047357f, 0.00346087f, -0.19140036f, -0.23636122f, -0.23621307f, -0.15731362f, -0.15287806f, 
    0.11725648f, -0.03999762f, 0.14175804f, -0.07173900f, -0.03120332f, -0.19105229f, 0.00059381f, -0.13182364f, 
    0.00588405f, -0.12204231f, -0.14206640f, -0.17831877f, 0.00598905f, -0.04440494f, -0.01121365f, -0.17489396f, 
    0.03639589f, 0.21730360f, 0.16269197f, 0.07324511f, -0.13962024f, -0.23074117f, 0.18521544f, -0.30650306f, 
    0.06809614f, 0.00216651f, -0.05716830f, 0.13734283f, -0.09192837f, -0.12212415f, -0.00864351f, -0.11575142f, 
    0.29777920f, 0.08254130f, 0.03518166f, 0.27522117f, 0.14198634f, 0.08465108f, 0.25247014f, -0.16351621f, 
    -0.01221118f, 0.19588171f, -0.02905329f, 0.37416807f, -0.07340206f, -0.04361480f, 0.22830996f, -0.10282100f, 
    0.03934957f, 0.04522978f, 0.04315412f, 0.07945261f, -0.06698862f, -0.01787948f, -0.01607578f, 0.03770955f, 
    0.25038192f, 0.15778211f, 0.21461114f, -0.26965046f, 0.07467479f, 0.16663280f, -0.10447420f, 0.06948596f, 
    -0.03692379f, 0.02510642f, -0.02353320f, -0.01527958f, -0.16579555f, -0.12716988f, -0.11802262f, -0.12489578f, 
    0.05807942f, 0.01296551f, -0.12647155f, 0.01296245f, 0.02960836f, 0.04320448f, -0.03815443f, 0.34318465f, 
    0.15526928f, -0.01438847f, 0.02011784f, -0.11590095f, -0.00143760f, -0.04343269f, 0.05300520f, 0.06282340f, 
    0.16794917f, -0.11998795f, 0.02653221f, 0.09166941f, 0.07223330f, 0.29122889f, -0.12321611f, -0.00790930f, 
    -0.10424621f, 0.04959883f, 0.11554866f, -0.02757424f, -0.15176323f, -0.15765259f, 0.12434201f, -0.23200907f, 
    0.29348543f, -0.00274774f, -0.12339849f, -0.23044878f, 0.11215658f, 0.14152315f, 0.01581672f, 0.08949832f, 
    -0.13924016f, 0.19784351f, 0.01780132f, 0.02745059f, 0.22545467f, -0.03441874f, 0.03109291f, 0.04590929f, 
    0.04522231f, 0.24882925f, 0.11917181f, -0.09360153f, -0.00218230f, 0.06962551f, 0.01833936f, -0.09431363f, 
    0.17767301f, 0.19869030f, -0.07795238f, 0.11294539f, 0.00411955f, 0.08938659f, 0.10019412f, 0.01198750f, 
    -0.25387281f, 0.07735287f, -0.04264741f, -0.09849786f, 0.03431936f, -0.09398255f, -0.17500365f, -0.03311871f, 
    0.08918162f, -0.15219052f, 0.12045877f, 0.07519989f, -0.00599464f, 0.03114286f, -0.00708230f, -0.02493146f, 
    -0.22565877f, -0.07129799f, 0.00978576f, 0.01709116f, 0.14279464f, 0.03446031f, -0.01232827f, 0.00602904f, 
    0.03271266f, 0.06496060f, -0.03301122f, 0.04992426f, 0.20844963f, 0.00109220f, 0.11660766f, -0.12457746f, 
    0.02071843f, -0.23404001f, -0.03954209f, 0.11275008f, -0.14624341f, -0.02138435f, -0.07350884f, -0.15267630f, 
    0.09365161f, -0.18783620f, -0.18377477f, 0.05419845f, 0.09890978f, 0.04646770f, -0.04563629f, -0.05012102f, 
    -0.02241045f, 0.05314995f, -0.11276786f, 0.17069069f, -0.12449517f, -0.15769251f, 0.07748022f, -0.04436225f, 
    -0.02319345f, -0.02412705f, 0.03838365f, -0.13980757f, 0.14321230f, 0.03742157f, 0.05370613f, 0.07841049f, 
    0.27617556f, 0.21817808f, -0.35920081f, 0.35572466f, 0.11141364f, 0.00307311f, -0.13482992f, 0.11131290f, 
    -0.09231748f, -0.25009495f, -0.06408427f, 0.06196969f, 0.00631685f, -0.00085836f, -0.05009903f, -0.06307526f, 
    -0.03325492f, -0.01126206f, 0.07733708f, 0.10416169f, 0.19931471f, -0.05372975f, -0.04031745f, 0.13508882f, 
    -0.11934942f, -0.03707507f, -0.07256175f, -0.11753318f, 0.03239195f, 0.08830716f, 0.06791922f, -0.02485843f, 
    0.02506943f, -0.21790107f, 0.14520301f, -0.20991527f, -0.38136581f, -0.06310349f, 0.04368211f, -0.03133013f, 
    -0.08838025f, 0.08874767f, 0.17299587f, 0.04010246f, -0.04674324f, 0.03699099f, 0.03102425f, 0.11441781f, 
    0.20171404f, -0.10839395f, 0.21365401f, 0.26586053f, -0.07390846f, -0.13838334f, 0.15123580f, 0.11606751f, 
    0.11945342f, -0.03427052f, 0.14739560f, 0.21849765f, -0.08091873f, 0.03782212f, -0.15004280f, -0.06763308f, 
    0.02045229f, 0.00557634f, 0.04447476f, -0.09950978f, -0.13739625f, 0.10152649f, 0.00859448f, -0.13328499f, 
    0.61503536f, -0.31008008f, -0.04851953f, 0.11659454f, -0.04885070f, -0.02249937f, 0.06859601f, 0.00878004f, 
    0.11624317f, 0.06518595f, 0.11363792f, 0.11449764f, 0.43691528f, -0.02574250f, 0.14100532f, -0.10620108f, 
    0.11017237f, -0.01455194f, -0.14029399f, 0.10364248f, 0.08792383f, 0.02455714f, -0.07105574f, 0.07392371f, 
    -0.02204502f, 0.03397577f, -0.08911855f, 0.08811951f, 0.00432904f, 0.08476425f, 0.08805776f, -0.01001138f, 
    0.15255339f, 0.07771223f, 0.14884469f, -0.03818060f, -0.14416847f, -0.11330342f, -0.12241616f, -0.28172040f, 
    -0.04805326f, 0.05798504f, 0.09372453f, -0.01657655f, -0.03445381f, -0.12114190f, -0.02132467f, 0.03735088f, 
    -0.05772509f, -0.06681792f, 0.05242359f, -0.10676278f, 0.02358668f, -0.08646857f, -0.05813577f, -0.05898686f, 
    0.06621588f, -0.00983680f, 0.05211892f, 0.16202739f, -0.08272958f, -0.08615264f, -0.01311781f, 0.01671208f, 
    -0.05506121f, -0.05153192f, -0.04987300f, -0.05800952f, 0.09217386f, 0.00098574f, 0.17588669f, 0.00137984f, 
    0.00343278f, 0.15362585f, 0.05551676f, -0.01015039f, -0.10396886f, -0.14353251f, -0.23939440f, -0.02110005f, 
    -0.05406165f, -0.00356178f, 0.02263073f, -0.04101404f, -0.24364534f, 0.31476679f, -0.21453443f, 0.18294978f, 
    0.14217672f, 0.16681342f, 0.02677264f, 0.03181688f, -0.09181760f, 0.12317681f, 0.06374943f, 0.07995605f, 
    0.31504014f, 0.18681303f, 0.13705520f, 0.03447983f, 0.11963001f, 0.19939543f, -0.01949962f, 0.03620905f, 
    -0.09107635f, -0.06316759f, 0.02145816f, -0.03921225f, 0.11321843f, 0.05207291f, 0.03051883f, -0.06764320f, 
    0.03846539f, -0.05665623f, 0.01313872f, 0.02377031f, -0.04785846f, -0.06182919f, -0.09330267f, -0.05657889f, 
    0.09558805f, -0.10670952f, 0.18635654f, -0.09517005f, -0.05925747f, -0.09787267f, 0.05701296f, -0.00852541f, 
    0.05687959f, 0.12895414f, 0.05755784f, 0.05618174f, 0.14970154f, -0.10874075f, 0.00327498f, 0.08977785f, 
    -0.21689172f, 0.00602081f, -0.11549041f, -0.10529061f, 0.01912594f, 0.02133207f, 0.06074663f, -0.12409421f, 
    -0.14365281f, -0.08512034f, -0.03884469f, 0.30160812f, 0.03609760f, -0.04146843f, 0.00288485f, 0.04834780f, 
    -0.11936712f, 0.05027763f, -0.12544753f, 0.15792671f, 0.02603547f, -0.17356561f, 0.04508693f, 0.22977559f, 
    -0.03277870f, -0.07809394f, 0.19758908f, 0.00314732f, 0.12229446f, 0.17380396f, -0.13960738f, 0.02298571f, 
    0.15273459f, -0.02798103f, 0.02402087f, -0.19001713f, -0.03043473f, -0.05113184f, 0.10264460f, -0.06045641f, 
    -0.04489171f, 0.02412195f, -0.11506969f, 0.05931725f, 0.13805349f, 0.11217158f, 0.08844472f, 0.06445285f, 
    -0.23982720f, -0.00157010f, -0.03163129f, -0.12047653f, 0.14530775f, 0.09468166f, -0.03428099f, -0.04590164f, 
    -0.30456474f, 0.34766138f, -0.13402325f, -0.21107350f, 0.11062719f, 0.06393729f, -0.10731439f, 0.03828980f, 
    -0.05337919f, 0.15326746f, -0.07653619f, -0.08061694f, -0.44037867f, 0.15643066f, -0.21040459f, 0.14321986f, 
    -0.03065246f, 0.15169650f, 0.09682411f, -0.01760010f, -0.01098250f, -0.04131359f, 0.01419980f, -0.01228880f, 
    0.28785720f, -0.05875953f, 0.26006272f, -0.08885308f, 0.01756598f, -0.02428603f, -0.07889552f, 0.11356743f, 
    0.00403744f, 0.18067607f, -0.03004695f, 0.00793309f, 0.01925385f, 0.02923560f, -0.13755150f, 0.25868493f, 
    0.09793421f, -0.03811495f, 0.02389476f, 0.05132453f, -0.09133975f, 0.01165884f, 0.05197990f, -0.12552269f, 
    0.02930701f, 0.11514664f, -0.04944726f, 0.27591270f, -0.04028433f, -0.06390903f, 0.09405736f, 0.10757615f, 
    0.04241095f, 0.00051313f, 0.03499274f, -0.00318775f, 0.00263925f, 0.27231011f, -0.02701176f, -0.28694606f, 
    0.10870260f, -0.03536718f, -0.00028679f, -0.01893553f, -0.19167463f, 0.02396690f, -0.19448455f, 0.10705487f, 
    0.02140357f, 0.05731829f, -0.06067650f, -0.04582308f, -0.05217705f, -0.03909516f, -0.00779494f, -0.02972628f, 
    0.03076578f, -0.00072833f, 0.02945126f, -0.03832822f, 0.01143389f, -0.05111844f, 0.03235852f, -0.07093687f, 
    -0.02316309f, 0.04238052f, -0.04067786f, 0.06719261f, -0.00625323f, -0.04703809f, -0.04572110f, 0.00714161f, 
    -0.03135867f, 0.00662313f, 0.06632765f, -0.06259897f, 0.05018871f, -0.00033933f, 0.01312457f, -0.02875262f, 
    -0.06818371f, 0.01315940f, 0.03388383f, -0.00749692f, -0.01163381f, -0.01788902f, -0.05724147f, -0.01834500f, 
    0.02865925f, 0.02018670f, -0.04381935f, -0.01897668f, -0.02853289f, 0.05587431f, -0.06972326f, -0.02701289f, 
    -0.01714882f, 0.07034788f, 0.02781702f, -0.02194448f, -0.01098232f, 0.05796168f, 0.03279012f, -0.05441321f, 
    0.06418099f, 0.00808577f, 0.01401634f, -0.07672105f, 0.03937554f, 0.04375286f, -0.06245361f, -0.05590450f, 
    -0.06775517f, -0.01518913f, 0.01351334f, -0.04762636f, 0.02609255f, 0.04031663f, -0.04937172f, -0.01871111f, 
    0.03700616f, 0.00726470f, -0.03254402f, 0.05074086f, -0.07073209f, -0.02720248f, -0.00401314f, 0.05903335f, 
    -0.00259537f, -0.06015755f, 0.04387657f, -0.01934267f, -0.05542512f, -0.02587060f, -0.04193214f, -0.00999293f, 
    -0.03797691f, -0.03986987f, -0.07226718f, 0.05527734f, -0.00894352f, 0.03348441f, -0.02602285f, -0.04638823f, 
    0.05985662f, -0.05551508f, 0.03793817f, -0.01459092f, -0.03969060f, 0.03374544f, -0.07479404f, -0.02927743f, 
    0.05358707f, -0.07491384f, -0.04615563f, 0.02573886f, -0.02188669f, -0.00197388f, 0.05583005f, -0.03597100f, 
    -0.04738502f, 0.00008206f, -0.07166959f, 0.04117526f, -0.00137527f, 0.04812648f, 0.02859013f, -0.04388598f, 
    -0.02684496f, 0.05183298f, -0.03148400f, 0.04735826f, -0.03008247f, 0.01084519f, -0.01155632f, -0.00314459f, 
    0.05398540f, 0.00298652f, -0.06947256f, 0.06181598f, 0.04124751f, 0.03743068f, -0.06465999f, 0.04091432f, 
    -0.07014877f, -0.02345009f, 0.01677349f, 0.02900987f, -0.02325349f, 0.02411689f, 0.01698867f, 0.01267640f, 
    0.00506579f, -0.03171895f, -0.04861032f, -0.01928405f, -0.03112277f, -0.05491793f, -0.02798168f, -0.00542079f, 
    -0.03986587f, -0.03195085f, -0.05622850f, -0.04896918f, 0.05039884f, -0.07036681f, 0.04103594f, -0.01332328f, 
    0.01494792f, -0.05705580f, -0.04059982f, 0.01289131f, -0.01722945f, 0.00258111f, 0.04404353f, -0.00918764f, 
    -0.03912469f, 0.00112047f, -0.01466440f, -0.07525665f, 0.03530878f, 0.04068378f, 0.05874730f, 0.03897788f, 
    -0.03670050f, 0.06184800f, 0.00391397f, 0.06176477f, 0.00061790f, -0.05289993f, 0.03391645f, 0.05640044f, 
    -0.02603994f, 0.00111511f, -0.02042661f, 0.00630402f, -0.03405143f, 0.05345505f, -0.00371687f, 0.00180633f, 
    0.20587325f, 0.15182546f, 0.20613405f, 0.10081462f, 0.03516418f, 0.06551133f, -0.07610280f, -0.08644750f, 
    -0.00776373f, 0.07802252f, -0.06368940f, 0.05715596f, -0.13565814f, 0.08079942f, -0.05849732f, 0.10843726f, 
    0.07398177f, -0.07894231f, 0.19484507f, -0.03997501f, -0.12244929f, 0.03701257f, 0.09309401f, -0.08737495f, 
    0.08681227f, -0.18720666f, -0.05798271f, -0.23990001f, -0.07043552f, -0.00671298f, 0.04813370f, -0.15501706f, 
    0.02467967f, -0.03515638f, -0.04571659f, 0.07387915f, -0.05967424f, 0.05025799f, 0.00078896f, -0.05615345f, 
    -0.02043410f, -0.14068736f, 0.00782985f, -0.00594783f, -0.07676431f, 0.02163702f, 0.00259191f, 0.15481058f, 
    0.21412617f, 0.13739686f, 0.05094521f, 0.19054604f, 0.03724092f, 0.01336163f, -0.02565156f, 0.07352187f, 
    0.07287468f, -0.00575243f, -0.07472264f, -0.00007519f, -0.08247974f, -0.04645310f, 0.13279724f, -0.06413713f, 
    -0.08655230f, 0.07045365f, 0.03834480f, 0.05034414f, 0.08846442f, -0.12719852f, 0.08221813f, 0.04137605f, 
    -0.14308007f, 0.12222298f, -0.34257290f, -0.09051749f, -0.04867051f, 0.00323626f, 0.05608502f, 0.11796951f, 
    0.10658123f, -0.03590440f, 0.08387006f, -0.08515528f, 0.17880686f, -0.12624821f, 0.30347458f, 0.23247086f, 
    0.19494101f, 0.13739745f, 0.05220465f, -0.06874416f, 0.01314103f, 0.02394719f, 0.08924324f, 0.01321814f, 
    -0.01270355f, -0.18909961f, 0.09983024f, 0.20865890f, 0.00811106f, -0.04697277f, 0.13920258f, 0.00419550f, 
    0.14404409f, -0.02754375f, 0.01544493f, 0.04143460f, 0.21833476f, 0.02616325f, -0.05411030f, -0.01121877f, 
    -0.01359835f, 0.03441769f, -0.03569572f, -0.07366809f, -0.05566693f, 0.00027323f, 0.01416974f, -0.21558887f, 
    0.10628398f, -0.43185356f, 0.03502454f, 0.11543070f, 0.04142154f, 0.12170314f, -0.10252932f, -0.05514393f, 
    0.03092420f, 0.01762137f, -0.00866792f, -0.09548344f, 0.25968510f, 0.06418942f, 0.09752884f, 0.21432260f, 
    0.02639408f, -0.00445945f, -0.02898126f, -0.07200561f, 0.10359276f, 0.03552381f, -0.02925852f, 0.13829593f, 
    -0.09039120f, -0.13899776f, 0.20950298f, 0.27029267f, 0.06914964f, -0.00884103f, 0.03659321f, -0.01973903f, 
    0.02001976f, 0.01512926f, 0.08769196f, 0.10247010f, -0.25246108f, 0.00100535f, -0.02410687f, 0.02534536f, 
    0.07391743f, -0.03499272f, -0.07659359f, -0.02217109f, -0.04322494f, 0.01735097f, 0.03810922f, 0.12748949f, 
    -0.14969781f, -0.18838747f, -0.01607618f, 0.01160107f, -0.01900459f, 0.01640145f, 0.00395629f, -0.05746789f, 
    0.05791347f, 0.03692098f, -0.03058844f, 0.04117272f, -0.15043160f, -0.00717490f, 0.01411595f, -0.21017221f, 
    -0.03034778f, -0.09792149f, -0.01277926f, 0.12128659f, 0.13175258f, -0.03780409f, 0.10144615f, -0.04234976f, 
    0.12542686f, -0.08241712f, 0.01775279f, 0.05847975f, -0.04449318f, 0.13616312f, 0.03182775f, 0.02538190f, 
    -0.02011913f, -0.09315045f, 0.06370039f, 0.00329452f, -0.06189022f, -0.03544848f, -0.04831991f, 0.31100926f, 
    0.07088833f, 0.13487214f, 0.05907032f, -0.06851057f, 0.13257831f, 0.04743410f, -0.04723385f, 0.22004056f, 
    -0.04221629f, 0.08858035f, 0.37245253f, -0.00992241f, -0.04525075f, -0.01478540f, -0.06517760f, -0.06746013f, 
    -0.01809142f, -0.17918925f, -0.03524201f, -0.07309999f, 0.02224234f, 0.13413745f, -0.10183253f, 0.08442218f, 
    -0.04377032f, 0.09320327f, -0.05538622f, 0.19265002f, -0.17339234f, -0.10535612f, 0.06417814f, -0.14308879f, 
    -0.06563545f, -0.14210588f, 0.09286379f, -0.31927118f, 0.10890055f, 0.03165323f, -0.04579931f, 0.13235590f, 
    0.05415482f, 0.16078354f, 0.12688921f, 0.02664568f, 0.13931111f, -0.08129776f, -0.02600109f, 0.06545945f, 
    0.20122139f, -0.02993480f, -0.02732996f, 0.07484295f, -0.07221372f, 0.05049226f, -0.12608008f, -0.20754081f, 
    0.04383059f, 0.23804072f, 0.07794377f, 0.24880539f, 0.07054045f, -0.04903325f, 0.06562608f, 0.14885134f, 
    -0.11659253f, 0.18601929f, -0.17358047f, 0.04367452f, 0.19616114f, 0.25243855f, 0.17623818f, 0.30673680f, 
    0.12919666f, -0.18954319f, -0.06896894f, 0.00167417f, -0.08331522f, -0.21964346f, -0.08633797f, 0.09613207f, 
    -0.07412619f, 0.11969497f, -0.26922399f, -0.19655111f, 0.03328141f, -0.12409300f, 0.14169617f, -0.27727398f, 
    -0.17351478f, -0.06477992f, 0.10397110f, 0.03994427f, 0.15377055f, 0.00189667f, 0.02938367f, 0.00111068f, 
    -0.01925043f, -0.02851035f, -0.05657146f, 0.12299503f, 0.01296230f, -0.04930274f, -0.03418605f, 0.14288598f, 
    -0.22808641f, 0.24697524f, -0.02846304f, 0.06730580f, -0.05161304f, 0.04156480f, -0.00811446f, -0.01536529f, 
    -0.01081607f, 0.10313775f, -0.11702683f, -0.08164605f, -0.17544083f, -0.02826440f, 0.16255100f, 0.12363683f, 
    -0.22731122f, 0.06331202f, 0.01251034f, -0.04005370f, -0.04027213f, 0.02352192f, -0.02957908f, -0.02651186f, 
    0.06603824f, 0.04239409f, 0.27263045f, 0.08422980f, 0.16129808f, 0.00587893f, 0.17144363f, -0.12094719f, 
    -0.03392772f, -0.00893978f, -0.05695606f, 0.07415762f, 0.19542716f, 0.11072747f, 0.24311996f, 0.26676980f, 
    0.02882162f, 0.02639583f, 0.02382950f, 0.01157759f, 0.05653886f, 0.16617134f, 0.14267899f, -0.03356736f, 
    0.16747415f, 0.06406289f, 0.07582340f, 0.10351923f, -0.13530384f, 0.13110587f, -0.13558269f, 0.19853768f, 
    0.03717451f, -0.14956628f, -0.02781268f, -0.17842728f, -0.10249704f, 0.08291696f, 0.01323405f, 0.20418569f, 
    0.02499793f, -0.09915719f, 0.20553146f, -0.05742575f, -0.05522535f, 0.09638667f, -0.02917993f, 0.09731892f, 
    -0.02332455f, -0.07700046f, -0.13077754f, -0.14755829f, 0.01161312f, -0.08095931f, -0.03886719f, 0.01524384f, 
    -0.07244705f, -0.00296249f, 0.07937481f, 0.07452292f, 0.12984648f, -0.14508629f, -0.05378880f, 0.04014278f, 
    -0.13342583f, 0.06106060f, -0.09498675f, -0.04999251f, 0.20945814f, -0.05043431f, -0.06567413f, 0.03603070f, 
    -0.31670579f, 0.28335473f, 0.32600665f, 0.03490510f, -0.11618480f, 0.00879877f, -0.02092418f, 0.05093058f, 
    -0.04087766f, -0.12740387f, 0.02582406f, 0.01989757f, -0.04734406f, 0.10677522f, -0.15388955f, 0.08361506f, 
    0.09344336f, 0.12188105f, 0.04335152f, 0.09704364f, -0.03350489f, -0.00827202f, 0.12305325f, 0.10163517f, 
    -0.44707918f, -0.24840239f, 0.41234660f, -0.34732103f, -0.01564247f, 0.09350470f, 0.11852073f, -0.05328647f, 
    0.25087896f, 0.10706129f, 0.04289111f, 0.10261234f, 0.04580783f, 0.08726788f, -0.08632907f, 0.05564461f, 
    0.17050318f, -0.15014784f, 0.01734563f, -0.04937970f, -0.02416837f, 0.18556519f, -0.00137415f, 0.08563363f, 
    0.16693814f, -0.10281897f, -0.00464311f, 0.05860235f, 0.05509486f, -0.06376198f, -0.10280847f, -0.03887043f, 
    -0.07955299f, 0.04036649f, -0.13687775f, 0.02977731f, 0.18467826f, -0.05068859f, -0.12630136f, -0.04038023f, 
    0.10117160f, -0.14955457f, -0.00726909f, 0.11468527f, -0.09178527f, -0.12049577f, 0.03236960f, -0.13677645f, 
    -0.10817452f, 0.26602510f, -0.09303303f, -0.34076655f, 0.05451858f, 0.02361080f, -0.04907158f, -0.01510623f, 
    0.00671741f, -0.11094514f, -0.01718482f, -0.20715857f, -0.13914697f, 0.01834246f, 0.17536330f, -0.01892978f, 
    0.05402868f, 0.01450741f, -0.10846976f, 0.00243417f, 0.09653521f, -0.19554672f, -0.01145234f, 0.03037287f, 
    -0.29564333f, 0.52650952f, -0.03450721f, 0.03523149f, -0.07828537f, -0.08681831f, 0.04513484f, 0.10627317f, 
    -0.07043149f, -0.08518248f, -0.09094175f, -0.03241497f, 0.08621067f, -0.04301461f, -0.10747958f, -0.07691797f, 
    -0.16055119f, -0.00151531f, 0.17980230f, -0.17619909f, -0.01289335f, -0.04955659f, 0.10420050f, -0.02617919f, 
    0.02107158f, 0.13980733f, 0.11683018f, -0.08344974f, 0.00346762f, -0.01569674f, -0.01231347f, 0.18061097f, 
    -0.12836851f, 0.03138720f, -0.16513917f, 0.03885381f, 0.18509784f, 0.09934609f, 0.06918872f, 0.10383267f, 
    0.03719619f, 0.06646477f, 0.03849787f, 0.02279404f, 0.09575561f, 0.11976431f, 0.17569654f, -0.15186152f, 
    0.01695208f, -0.01013918f, 0.05647226f, 0.07839701f, -0.06269750f, -0.00390213f, 0.05328054f, 0.06745247f, 
    -0.13775221f, -0.04744657f, 0.08296496f, 0.02979917f, 0.00780933f, 0.16617906f, 0.03942383f, 0.19695562f, 
    -0.10272680f, 0.13177043f, 0.12424868f, -0.08997377f, -0.13780569f, 0.03676760f, -0.06477590f, 0.01281647f, 
    -0.04387601f, -0.02591452f, 0.04480786f, -0.23916048f, -0.05066047f, -0.12291548f, -0.07407859f, 0.02612446f, 
    0.05425826f, 0.09403024f, 0.17005372f, -0.00591285f, 0.28376853f, -0.00411470f, 0.29864043f, -0.08547428f, 
    0.01296818f, -0.18462144f, -0.03788794f, 0.16402693f, -0.12257335f, -0.08947153f, -0.11761407f, -0.11683393f, 
    -0.35689017f, -0.10481305f, -0.17221390f, -0.07084771f, -0.14917879f, -0.15775199f, 0.03293294f, -0.10399257f, 
    0.17535564f, 0.22424784f, -0.14467847f, -0.05915798f, -0.14072600f, -0.06881996f, -0.19111772f, 0.07104845f, 
    -0.22853290f, 0.04496293f, -0.13777934f, 0.06404355f, 0.17314257f, 0.08919796f, 0.16417465f, 0.03388425f, 
    -0.26981851f, -0.14843236f, -0.15028808f, -0.23655975f, -0.04209638f, 0.26779690f, -0.04449809f, -0.00737063f, 
    0.07095721f, -0.15025525f, -0.05650231f, 0.10099118f, 0.05142132f, 0.13049069f, -0.10277052f, -0.03969302f, 
    0.05235130f, 0.14143325f, 0.28555977f, -0.02366874f, 0.00573899f, 0.19553737f, 0.14994116f, 0.31175125f, 
    0.28763020f, 0.05079595f, -0.23478325f, -0.18377657f, -0.06026049f, -0.07607652f, -0.02043482f, -0.05057912f, 
    -0.08094890f, 0.04044729f, 0.06137151f, -0.14890996f, 0.18802834f, -0.00263083f, 0.11787196f, -0.22190550f, 
    -0.04335885f, 0.02100117f, 0.14001308f, 0.15197790f, 0.05388602f, 0.03057205f, 0.00818484f, 0.04822173f, 
    -0.17366670f, 0.15915111f, 0.24482198f, 0.04502394f, 0.03659716f, 0.07101858f, -0.01544578f, 0.10877337f, 
    0.00637636f, -0.07690266f, 0.03281267f, 0.01497571f, -0.08618792f, -0.00734035f, 0.17821486f, -0.07738174f, 
    0.06124082f, -0.16780834f, -0.18831898f, 0.00820194f, -0.14446215f, -0.23341066f, -0.21829407f, -0.06464951f, 
    -0.02213864f, 0.14242764f, 0.08216882f, 0.07595459f, 0.02992364f, 0.12053023f, -0.01741920f, 0.10663707f, 
    -0.18043521f, -0.15625003f, 0.02626623f, 0.09468397f, 0.31637251f, -0.07936766f, 0.10943247f, 0.05587100f, 
    -0.01335720f, 0.01632873f, 0.05204860f, 0.03560606f, -0.07363614f, 0.13668334f, -0.11239584f, 0.01229279f, 
    0.03606953f, 0.24019584f, 0.13102770f, -0.01627941f, 0.08406214f, -0.01149142f, 0.16441491f, 0.17767888f, 
    -0.08170333f, 0.08290646f, 0.05643222f, 0.18102857f, 0.13268362f, 0.13284799f, 0.29162642f, 0.06267460f, 
    -0.02747636f, 0.01355375f, 0.09163939f, -0.05648523f, -0.07850170f, -0.08077464f, 0.00842140f, -0.01610481f, 
    0.13076101f, 0.00496050f, 0.07920393f, 0.07961962f, -0.03714072f, 0.10371194f, 0.02026110f, 0.20997731f, 
    0.05832396f, -0.03878109f, 0.05541897f, 0.09268487f, -0.19677153f, -0.35905918f, -0.23370135f, 0.01635622f, 
    -0.07803095f, -0.17958355f, -0.07345288f, -0.00650261f, 0.03316438f, 0.00610299f, 0.13257356f, 0.00652404f, 
    -0.07342014f, -0.35122856f, -0.17620537f, 0.09241512f, 0.16483179f, 0.01145413f, -0.13123961f, -0.00501135f, 
    -0.00793230f, -0.07762028f, -0.04199346f, -0.04344197f, 0.01957414f, 0.16874279f, 0.03256306f, 0.03919255f, 
    0.12176132f, 0.12478516f, 0.14330079f, 0.12782219f, -0.01228865f, -0.01207035f, 0.09597677f, 0.06294960f, 
    -0.09411040f, -0.26955920f, -0.15268578f, 0.12337889f, 0.09489362f, 0.23484930f, -0.09379137f, 0.05463221f, 
    0.03344151f, -0.08457662f, 0.09017868f, 0.16280885f, -0.13576029f, -0.38914648f, 0.07709777f, -0.14019503f, 
    0.26899928f, -0.03271285f, 0.00773575f, -0.20824607f, 0.10338011f, -0.08765976f, -0.08978284f, -0.08870312f, 
    -0.36070547f, -0.15403840f, -0.09242078f, 0.16692738f, -0.05954932f, -0.11169482f, -0.07109670f, 0.00484485f, 
    -0.00180536f, 0.13180633f, -0.07226643f, 0.07137397f, 0.40350041f, -0.08364160f, -0.15877107f, -0.02252559f, 
    0.05259632f, 0.08150110f, -0.14301330f, -0.01383336f, 0.06041884f, -0.09377558f, -0.03248190f, -0.44051209f, 
    -0.00255325f, -0.44396472f, 0.22011702f, -0.03802096f, 0.23285782f, 0.18436326f, 0.02683850f, 0.03553297f, 
    -0.10300677f, 0.13003211f, 0.09424928f, 0.23944238f, -0.20684257f, -0.31957898f, -0.09325138f, -0.34649459f, 
    -0.19974916f, 0.14303520f, 0.12741567f, -0.15579009f, 0.21049111f, 0.05307866f, 0.02163376f, 0.05770776f, 
    0.23437668f, 0.26603445f, 0.40439293f, 0.11729996f, -0.11062968f, -0.01122160f, -0.09256358f, 0.01598177f, 
    0.06311567f, 0.02837330f, 0.09138549f, 0.09403621f, -0.12058210f, -0.24099714f, -0.16049458f, 0.10579035f, 
    0.03651518f, 0.09360689f, 0.09315066f, 0.07919545f, 0.21947488f, 0.06548642f, 0.12871790f, 0.18775383f, 
    0.28776580f, -0.03522639f, 0.36031657f, -0.20885034f, 0.08219881f, 0.04581014f, 0.16950482f, -0.00755642f, 
    0.10622584f, -0.01534129f, -0.07390048f, -0.04568425f, -0.03607622f, -0.00189018f, 0.13647096f, -0.20040594f, 
    0.23906165f, -0.05674162f, -0.08773046f, 0.06133550f, 0.07931489f, 0.09363971f, -0.03802862f, 0.00135945f, 
    -0.01344422f, -0.01599884f, -0.12528881f, -0.24970925f, -0.08714093f, 0.07498571f, 0.00604066f, 0.01437982f, 
    0.12823312f, -0.06249205f, -0.15985024f, 0.05525693f, 0.26262689f, 0.01079052f, -0.14046994f, -0.09333568f, 
    0.03953831f, 0.07027468f, -0.04741596f, 0.12306013f, 0.01220021f, 0.00764069f, 0.01339243f, 0.09290855f, 
    0.15986618f, 0.18315221f, 0.18204436f, -0.01637124f, 0.14495093f, -0.18082902f, 0.08523864f, 0.04457761f, 
    -0.04572491f, 0.04403738f, -0.02865136f, -0.06935277f, -0.11983962f, -0.08388796f, -0.25390667f, 0.23175961f, 
    0.13688277f, 0.05483325f, -0.09381388f, -0.17766324f, 0.00623381f, 0.07261869f, 0.03641769f, 0.07925748f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15598965f, 0.04877730f, -0.04589932f, 0.17738298f, 0.11566668f, 0.07345640f, 0.20355728f, -0.12813985f, 
    -0.07047231f, -0.06360386f, -0.03179377f, -0.03288309f, -0.09841345f, 0.24244900f, 0.18984543f, 0.18603829f, 
    0.05549421f, 0.03155672f, 0.08012263f, 0.03541721f, 0.17201778f, 0.04565988f, -0.01794208f, -0.05963572f, 
    0.16428860f, 0.02845584f, 0.02737767f, -0.07038414f, 0.04614863f, -0.04300682f, 0.00731558f, 0.08672160f, 
    -0.14910907f, 0.02227951f, -0.01569781f, 0.06817783f, 0.10054815f, 0.04025646f, -0.06302221f, 0.15160532f, 
    0.07001578f, 0.09489006f, -0.02230820f, 0.14897476f, 0.06123355f, -0.02563567f, 0.18698320f, -0.01765879f, 
    -0.01205738f, 0.16805288f, 0.23333742f, 0.05314002f, 0.03853069f, 0.22907548f, 0.08236082f, 0.03978140f, 
    0.05209870f, -0.05688804f, -0.02640348f, 0.07455769f, 0.03315800f, -0.02256376f, 0.16906798f, -0.12843338f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04913371f, 0.09919760f, -0.15611354f, -0.18640304f, 0.19544244f, -0.03198987f, -0.00143528f, 0.20912512f, 
    0.00171858f, 0.02675834f, -0.12669751f, -0.05570047f, 0.12545377f, 0.02980753f, -0.02019682f, -0.09077158f, 
    -0.20867208f, 0.09275047f, 0.16547088f, -0.13694733f, 0.03104698f, -0.01255164f, 0.05851157f, -0.08320364f, 
    0.09106126f, 0.09547780f, -0.01424323f, -0.11643538f, -0.11685079f, -0.25798246f, 0.04781552f, -0.05000433f, 
    -0.35156551f, 0.03840809f, 0.00078051f, 0.18160054f, 0.03042401f, -0.11270788f, 0.09505995f, -0.00346702f, 
    -0.13118593f, -0.20990087f, 0.05264968f, 0.00332319f, 0.12389849f, -0.00753069f, -0.11185868f, 0.01658350f, 
    0.00098312f, 0.14807245f, 0.20194136f, 0.07718097f, 0.01955977f, 0.23581451f, 0.06224580f, -0.07498668f, 
    0.12076404f, -0.15608048f, 0.08819773f, -0.22898816f, 0.02998480f, 0.09176426f, 0.25381750f, 0.28632575f, 
    0.01756361f, 0.22686340f, 0.02665190f, 0.14498994f, 0.19157787f, -0.05397223f, 0.23187819f, -0.65753675f, 
    0.00506118f, 0.02602550f, -0.10708949f, -0.02681691f, -0.03852579f, -0.04869876f, -0.02678064f, 0.24626021f, 
    0.01618007f, 0.00678538f, -0.12820560f, 0.22033860f, 0.15943731f, -0.11998216f, -0.03993073f, 0.10747273f, 
    -0.01695400f, 0.14365759f, 0.02822521f, 0.08297544f, -0.19333340f, -0.09804286f, -0.24678573f, 0.22549741f, 
    -0.04310593f, 0.10911203f, -0.17957354f, 0.20989457f, -0.05602010f, -0.02589014f, -0.09620963f, -0.05364073f, 
    0.20046692f, 0.33034453f, 0.01594596f, -0.26820534f, 0.11952390f, 0.09171362f, -0.07450452f, 0.07591869f, 
    -0.05011046f, -0.10617026f, 0.22687383f, -0.05087675f, 0.03432975f, 0.34432676f, -0.25772905f, 0.00239148f, 
    -0.30386943f, 0.16505753f, -0.03680583f, 0.21892285f, 0.10896033f, -0.17907566f, -0.23448205f, -0.25649646f, 
    0.03116631f, -0.06778114f, 0.09262185f, 0.11271995f, -0.23693457f, -0.09095059f, -0.09792853f, 0.07647538f, 
    -0.00355964f, -0.04151553f, -0.08530706f, 0.07093556f, 0.28546599f, 0.00704425f, -0.00153752f, -0.20476539f, 
    0.21736559f, -0.11385931f, 0.08942426f, -0.27522987f, -0.25841609f, -0.04137582f, 0.36991730f, -0.08852846f, 
    -0.58962262f, 0.12097207f, 0.01622062f, 0.12313095f, 0.18871443f, -0.03131327f, -0.23627222f, -0.27092776f, 
    0.27640063f, 0.56138092f, 0.25704399f, 0.13754468f, -0.03964964f, -0.10994121f, 0.46016192f, 0.08111966f, 
    0.20299271f, 0.22805808f, -0.03623913f, -0.31975096f, 0.03881855f, -0.08201940f, -0.20043287f, -0.09868290f, 
    0.00216092f, -0.07818656f, -0.15417294f, 0.11876646f, 0.03883019f, 0.06769388f, -0.17398305f, 0.23791835f, 
    -0.05194689f, 0.11722624f, 0.02902597f, 0.14655177f, 0.00431909f, -0.29264319f, -0.12897137f, 0.27370292f, 
    -0.17680332f, 0.20648520f, 0.12792113f, -0.15817310f, -0.09230792f, 0.21987054f, -0.16115405f, 0.00622493f, 
    -0.03657559f, -0.06183251f, -0.06617071f, 0.06434943f, 0.15621923f, -0.19615664f, 0.22389369f, 0.06804002f, 
    0.16706163f, -0.02562420f, 0.03057663f, -0.05382472f, -0.10961834f, -0.10455323f, 0.13225095f, 0.02448785f, 
    -0.23662461f, -0.02033090f, 0.11018972f, -0.03291367f, 0.06747915f, 0.16163570f, -0.27795884f, -0.37877274f, 
    0.04549271f, 0.22135465f, 0.39518392f, 0.13406000f, -0.13493636f, 0.05107816f, 0.14968331f, 0.04205556f, 
    0.22392061f, 0.29898772f, -0.02124864f, -0.19911152f, -0.05195930f, -0.06298062f, -0.07288728f, -0.05119530f, 
    0.07030240f, -0.13758793f, -0.01688630f, 0.28000191f, -0.05422889f, -0.10600102f, 0.12506735f, -0.14851947f, 
    -0.02500155f, 0.16440846f, 0.04094863f, 0.06396976f, -0.06135388f, -0.30998111f, -0.22886595f, 0.23259349f, 
    0.28524542f, 0.08443146f, -0.31265631f, 0.03255400f, 0.13635570f, -0.01149376f, -0.09634229f, 0.14001791f, 
    0.12488524f, -0.11886691f, -0.10043597f, 0.03626197f, 0.08887126f, -0.12578964f, -0.09633441f, 0.03850025f, 
    0.21267368f, -0.02402515f, 0.14556497f, -0.14936046f, 0.30906293f, 0.08935591f, -0.05371187f, -0.04459014f, 
    -0.09350234f, -0.01790555f, -0.03914868f, -0.06331322f, -0.06735288f, -0.12454019f, 0.26216435f, 0.09018657f, 
    -0.12810528f, 0.08302613f, 0.13877952f, -0.00653535f, -0.16377652f, 0.09409751f, 0.23492154f, 0.23347268f, 
    0.17994203f, -0.09948858f, -0.09470259f, 0.07997102f, -0.09219468f, -0.04654872f, 0.23563078f, -0.00616318f, 
    -0.08393802f, 0.16168699f, 0.09197238f, -0.16057901f, 0.12549934f, -0.06546623f, 0.11935759f, 0.43698752f, 
    -0.21856186f, -0.18053612f, 0.09618843f, -0.10382877f, -0.10997133f, -0.21499549f, 0.30778003f, 0.27851889f, 
    -0.15258715f, 0.18764026f, 0.11313846f, 0.08187106f, -0.13591012f, 0.19986187f, -0.14677647f, -0.17923512f, 
    -0.10024230f, 0.02964180f, 0.03872384f, -0.02946824f, 0.05099092f, -0.17926027f, 0.12648271f, 0.17273615f, 
    0.06856811f, 0.05571894f, -0.08197167f, 0.16909242f, -0.04133209f, 0.00600652f, 0.21840993f, -0.00163714f, 
    -0.02324790f, 0.19328359f, 0.09325628f, 0.09371923f, -0.05768340f, 0.13255647f, -0.00406279f, -0.11505873f, 
    0.03205225f, 0.43431309f, 0.26071930f, 0.31839055f, -0.10709766f, 0.10117073f, 0.21868850f, -0.00432583f, 
    0.01954159f, 0.10005690f, -0.01389484f, -0.07717893f, -0.02917308f, 0.08206648f, 0.02467529f, 0.04662123f, 
    0.10933812f, -0.07459375f, 0.08606806f, 0.08584808f, -0.07772346f, -0.21147430f, -0.05724375f, -0.12602431f, 
    0.12239080f, 0.16167583f, 0.08194059f, 0.14942233f, 0.13786195f, -0.14523478f, -0.26754221f, 0.16353726f, 
    -0.00196337f, 0.13072386f, -0.04973153f, -0.16119711f, -0.00221117f, 0.07189889f, 0.11746795f, 0.14541307f, 
    0.10645068f, 0.05953493f, -0.09185130f, 0.04480330f, 0.15406185f, 0.17261355f, -0.05066869f, -0.02150851f, 
    -0.12516800f, -0.11018845f, 0.23125221f, -0.05910015f, 0.09163022f, -0.10420126f, 0.06519918f, 0.04058011f, 
    -0.19740327f, -0.18246733f, -0.10283622f, 0.08127000f, 0.20510279f, 0.11461844f, -0.12924254f, 0.37552077f, 
    0.15182053f, 0.06657787f, 0.12359153f, 0.21920024f, 0.22412156f, 0.03488484f, -0.16621828f, 0.15584634f, 
    0.13592549f, -0.04968074f, -0.08101254f, -0.36956161f, 0.07104295f, -0.06897077f, -0.09643998f, 0.06855708f, 
    -0.11849647f, -0.12645049f, -0.07404768f, -0.18843362f, 0.11262850f, 0.18426704f, 0.04179175f, 0.17108186f, 
    -0.30351233f, 0.32493627f, 0.04366773f, 0.00252137f, 0.20099798f, 0.13611501f, -0.07668671f, -0.12935586f, 
    -0.28065470f, 0.16076276f, -0.06124105f, 0.14699343f, 0.00795747f, -0.11342431f, -0.19327277f, 0.22301064f, 
    -0.06202336f, 0.09661406f, -0.03673007f, -0.06481962f, 0.06644373f, -0.06509204f, 0.21176760f, 0.14664111f, 
    0.20737235f, 0.09067556f, -0.10613711f, 0.08416769f, -0.03329759f, 0.04246546f, 0.22993961f, 0.09028909f, 
    -0.19662085f, 0.11747444f, -0.11609578f, 0.04934352f, -0.21041794f, -0.12284178f, -0.12643020f, -0.21020173f, 
    -0.31792551f, 0.24081168f, 0.01468474f, -0.01301124f, -0.23263372f, 0.10353716f, 0.16522336f, -0.05537954f, 
    0.02160249f, 0.09474087f, 0.06843638f, -0.15726042f, 0.02815542f, 0.10084186f, -0.35651875f, -0.10590439f, 
    -0.05395588f, 0.09934715f, 0.29594722f, 0.14472325f, 0.07916471f, 0.11815621f, 0.02394340f, 0.14579169f, 
    -0.40328014f, 0.06974389f, 0.03600827f, 0.02899026f, 0.18880007f, -0.18570147f, -0.17586231f, 0.26549464f, 
    -0.11389565f, -0.28274524f, 0.06392889f, -0.01273841f, 0.19710664f, 0.19341089f, 0.18628167f, -0.00038473f, 
    -0.08783792f, 0.00185162f, -0.01892475f, -0.03386381f, 0.09059762f, 0.03377615f, 0.11139637f, -0.21055229f, 
    -0.03220666f, 0.08479841f, -0.04920303f, -0.15408599f, 0.00415962f, -0.05015176f, 0.03488249f, -0.05580126f, 
    -0.15558961f, 0.03398527f, 0.11369867f, -0.11009671f, -0.17538856f, -0.04070027f, -0.15714607f, -0.43709230f, 
    -0.06841169f, -0.12941989f, -0.31672925f, 0.06034647f, 0.01939681f, -0.08490577f, -0.01847524f, 0.09182721f, 
    0.17608026f, 0.21946910f, -0.06158216f, 0.17264682f, -0.06470472f, 0.04874421f, 0.15517472f, 0.00662803f, 
    0.05024282f, 0.18561736f, 0.11783525f, 0.52202737f, 0.12059030f, -0.06121207f, 0.00960911f, -0.24495114f, 
    -0.13274276f, 0.06201372f, -0.02905895f, 0.02473899f, -0.08487196f, -0.09833154f, 0.16721371f, -0.23589909f, 
    -0.00583759f, 0.13083759f, 0.05477455f, -0.09053725f, -0.19732355f, 0.20626825f, -0.30388272f, 0.23665269f, 
    0.07211851f, -0.01105552f, -0.05316325f, 0.05584237f, 0.34770533f, -0.20118381f, 0.03433841f, -0.24572428f, 
    -0.15515590f, 0.03467863f, 0.19905691f, -0.25066644f, -0.11233911f, -0.11004495f, 0.08474954f, -0.08134816f, 
    -0.28464884f, -0.06244316f, 0.02040309f, 0.00075797f, 0.24093977f, 0.12774856f, -0.09238598f, -0.34283507f, 
    0.28356144f, 0.43387115f, 0.22446717f, -0.14794925f, 0.10261758f, 0.09462868f, 0.25986388f, 0.12221295f, 
    0.21032520f, 0.06890605f, -0.05612345f, -0.14501801f, 0.05052091f, -0.06040111f, -0.20398921f, 0.05052201f, 
    0.01233617f, 0.18072367f, 0.01281438f, 0.40363705f, -0.03603956f, -0.06703708f, 0.19660832f, 0.09790527f, 
    0.03763537f, 0.31148273f, -0.06524063f, -0.19010779f, 0.09739108f, 0.02022488f, -0.18058886f, 0.42091197f, 
    0.24274889f, 0.07193040f, 0.04027258f, -0.12285884f, 0.34437007f, -0.03543821f, -0.09277054f, 0.25531724f, 
    -0.10516723f, 0.05435682f, 0.04145268f, 0.02294459f, 0.06079411f, 0.05903435f, 0.13088180f, -0.04447028f, 
    -0.26222613f, -0.08765388f, -0.12784487f, -0.12582888f, 0.26310930f, -0.06060990f, -0.27690554f, -0.08542910f, 
    0.08011056f, 0.09387231f, -0.10546024f, -0.00015215f, -0.17857301f, -0.11606369f, 0.06071676f, 0.15436617f, 
    -0.22396778f, 0.04447442f, -0.25455904f, -0.14540479f, 0.21533032f, -0.09363165f, -0.11721271f, 0.00325921f, 
    0.08882762f, -0.02744098f, -0.04936160f, 0.18122023f, 0.11977281f, 0.01514487f, 0.11006946f, -0.10890482f, 
    0.04195654f, 0.19117853f, 0.01250945f, 0.22883600f, -0.03315904f, 0.27122498f, -0.02465849f, 0.06008192f, 
    -0.14455423f, 0.01222125f, -0.04165997f, -0.03815770f, 0.00569497f, -0.01991970f, 0.25529692f, 0.19567627f, 
    -0.25450674f, 0.09650669f, -0.21922295f, 0.13224354f, -0.30619124f, 0.05980518f, 0.07662046f, -0.30936581f, 
    -0.11672807f, -0.07134207f, -0.05920237f, 0.06218661f, 0.09277730f, 0.25065055f, 0.33473915f, 0.09233588f, 
    0.12332991f, 0.08613648f, -0.10812677f, 0.14815351f, -0.23036021f, -0.01824927f, 0.33611363f, 0.02472978f, 
    -0.22398263f, 0.22308959f, 0.09261103f, -0.02743939f, -0.22767928f, -0.22317596f, -0.38142118f, 0.15578476f, 
    -0.24229519f, 0.22299199f, 0.21708632f, 0.35167649f, -0.33034265f, -0.04077932f, 0.19774917f, -0.01676700f, 
    0.17332114f, 0.31564364f, 0.07105044f, -0.17112055f, 0.04167148f, 0.11297212f, -0.15320720f, 0.11787148f, 
    -0.05987820f, 0.09604742f, 0.26885411f, 0.05453128f, -0.03959637f, 0.09119720f, -0.07760216f, 0.00586189f, 
    0.10022078f, -0.12663218f, 0.01992036f, 0.03280416f, 0.16671403f, -0.26704043f, -0.29800701f, -0.03559922f, 
    0.15555407f, 0.08668797f, -0.45920378f, 0.24100383f, -0.21233892f, -0.14200401f, -0.03258705f, -0.11660347f, 
    -0.06241249f, 0.08406381f, 0.08326948f, 0.15125807f, -0.17467836f, 0.26539111f, 0.23360805f, 0.14148253f, 
    0.24990551f, -0.11725412f, -0.08092160f, -0.07739091f, -0.07593883f, -0.06422102f, 0.11983871f, 0.12272936f, 
    -0.02533714f, 0.30106688f, -0.05731298f, -0.04778572f, 0.28850228f, -0.01970148f, -0.01927878f, -0.15767185f, 
    -0.10896616f, 0.13873769f, -0.00638367f, -0.02125927f, -0.44390389f, 0.11608355f, 0.34888625f, -0.11578952f, 
    0.10094607f, 0.04265262f, 0.09047586f, -0.06290591f, 0.09598343f, -0.00000245f, -0.07026228f, -0.00251554f, 
    -0.07566677f, 0.04351304f, -0.01345663f, -0.33334464f, 0.08863322f, 0.08116297f, 0.01731373f, 0.07006786f, 
    0.22317545f, 0.02791128f, 0.02510163f, 0.00919282f, -0.26076099f, -0.18539652f, -0.06800578f, -0.00443343f, 
    -0.07380824f, 0.06022130f, -0.07433672f, -0.03854757f, 0.05186335f, -0.03070910f, 0.07173276f, -0.02486260f, 
    0.12072986f, -0.10715463f, 0.04645217f, -0.14729756f, 0.08327116f, 0.24319719f, 0.14524122f, 0.15842761f, 
    -0.10965050f, 0.08633810f, 0.00421389f, 0.15186074f, 0.00685205f, 0.02032386f, 0.16998729f, 0.06853302f, 
    0.06937145f, 0.13653164f, -0.09997112f, 0.03826164f, -0.27284145f, -0.20294158f, 0.01139167f, 0.05097134f, 
    -0.32989943f, -0.09963270f, -0.25677654f, 0.17243403f, 0.06311180f, 0.07513084f, -0.09840883f, 0.11113522f, 
    -0.00561357f, 0.01285813f, -0.10681313f, 0.09117547f, 0.09681052f, 0.06348276f, 0.00976265f, 0.00207413f, 
    -0.10071083f, 0.12588334f, 0.22649077f, 0.05637171f, 0.01249868f, 0.40138471f, -0.06144635f, -0.16592214f, 
    -0.06234482f, 0.00483439f, 0.11154831f, -0.10144953f, 0.20894398f, 0.17880464f, 0.01017600f, -0.01958200f, 
    -0.21108168f, 0.14388818f, -0.03085761f, -0.11279852f, 0.34668538f, 0.31824705f, 0.22151694f, -0.23802835f, 
    -0.01979953f, -0.01155378f, -0.09043778f, -0.02035192f, -0.21602841f, 0.00791359f, 0.18581598f, 0.16479170f, 
    -0.01656076f, -0.09942974f, -0.07237569f, 0.22239330f, 0.22371550f, 0.06166021f, -0.15805691f, -0.03215314f, 
    0.12367435f, -0.12225728f, 0.05391568f, 0.12251683f, -0.11862027f, 0.06601582f, -0.14199786f, 0.06084554f, 
    -0.11752235f, -0.20433377f, -0.17978026f, 0.11723584f, 0.09124947f, -0.03283463f, -0.26548526f, 0.08662380f, 
    0.27278006f, 0.10694107f, -0.04827135f, 0.09435004f, -0.04048388f, 0.01542979f, -0.06783694f, 0.13483107f, 
    -0.09438644f, -0.03487691f, 0.09503033f, 0.24943009f, 0.11108043f, 0.06307176f, 0.16464163f, -0.24528575f, 
    0.04064472f, -0.01284614f, 0.08011068f, 0.01449805f, 0.25211582f, 0.20496255f, 0.02407426f, -0.33325231f, 
    0.36055827f, 0.20815963f, -0.25639665f, -0.20366278f, 0.19347414f, -0.00555857f, 0.12771328f, 0.16479035f, 
    0.11160624f, 0.02531969f, 0.10255460f, 0.07033222f, -0.14744115f, 0.10022994f, 0.22965282f, 0.08686747f, 
    -0.13801503f, -0.09504063f, -0.21722411f, -0.04818356f, 0.11779414f, -0.07151376f, -0.24301526f, -0.07533412f, 
    0.16629077f, 0.12285975f, 0.04125218f, -0.03177015f, 0.32804775f, 0.13002132f, 0.20602874f, 0.06841420f, 
    -0.09629536f, 0.17143248f, -0.12447187f, 0.01164745f, 0.16503268f, 0.09940155f, -0.14077005f, 0.08773798f, 
    -0.07849563f, -0.15545361f, 0.06216038f, -0.04141663f, 0.02330132f, 0.08187888f, -0.05885070f, -0.08382966f, 
    -0.03452060f, 0.25505883f, 0.10926387f, -0.09390265f, -0.03884746f, 0.18806274f, -0.12484224f, -0.12839176f, 
    0.12338274f, -0.15000771f, -0.10868511f, 0.00358513f, -0.13067788f, 0.01666428f, 0.10797310f, 0.02468912f, 
    -0.12593116f, -0.14940408f, -0.13364370f, 0.11647572f, 0.31552261f, 0.21693133f, 0.15748458f, -0.08959987f, 
    -0.08376868f, 0.01167479f, -0.04658720f, -0.12525485f, -0.14605673f, -0.01959347f, -0.01505266f, 0.26098517f, 
    -0.00904311f, 0.08906173f, -0.02289356f, 0.17956470f, 0.25100699f, 0.05279038f, -0.03781341f, 0.01926249f, 
    -0.01570598f, -0.04180714f, 0.07373518f, -0.05072547f, -0.40546545f, -0.22480778f, -0.27729258f, -0.12942512f, 
    -0.24540044f, 0.02526725f, -0.12028876f, 0.32450643f, 0.19236974f, -0.03640652f, -0.30891648f, 0.11986853f, 
    0.16480242f, 0.29480946f, 0.02072005f, 0.13954486f, -0.09340119f, 0.06732658f, 0.20927458f, 0.00534321f, 
    0.06905978f, -0.02686495f, 0.11069231f, 0.19784352f, -0.05951592f, -0.05954894f, -0.06257641f, -0.14802714f, 
    -0.16094312f, -0.08837952f, 0.01728638f, 0.27745110f, 0.07718366f, -0.09914506f, 0.23193160f, -0.14555416f, 
    0.20954201f, -0.27590427f, -0.00538556f, 0.06398164f, 0.05753390f, 0.30215502f, 0.21373004f, -0.34163210f, 
    0.05057214f, -0.09035126f, 0.01907540f, 0.23603003f, -0.15954612f, -0.11418918f, 0.13224384f, 0.09001312f, 
    0.11204983f, -0.01540853f, 0.03528870f, 0.03424588f, 0.01069775f, 0.09683368f, -0.07840282f, -0.02328589f, 
    0.17200264f, -0.17590371f, 0.07524890f, -0.00964312f, 0.05699322f, 0.03364614f, -0.03541092f, -0.13518070f, 
    0.23548038f, -0.10273591f, 0.24496125f, 0.33489549f, 0.23354271f, -0.04149812f, -0.26744613f, 0.17242886f, 
    0.20139086f, 0.31934986f, -0.12187637f, -0.15000184f, -0.04362519f, -0.01270426f, 0.15776502f, 0.01185700f, 
    0.06157252f, 0.06170195f, 0.03341796f, -0.02633691f, 0.05150947f, -0.22036207f, 0.15480791f, -0.14978258f, 
    0.08729015f, -0.18806753f, 0.10982002f, 0.29652944f, 0.13338223f, -0.14568727f, 0.20590714f, -0.28406969f, 
    -0.20613232f, 0.05502592f, -0.07341532f, -0.07162046f, -0.08770479f, -0.00878778f, -0.00207736f, 0.25393367f, 
    -0.10933766f, -0.09581234f, -0.11040966f, -0.05943905f, 0.03931261f, 0.37331325f, 0.29957217f, 0.19042459f, 
    0.04345966f, 0.07023729f, 0.06344512f, 0.00339218f, 0.09349757f, 0.08701909f, 0.30171016f, -0.01427278f, 
    -0.06613707f, 0.14546449f, -0.05577228f, 0.01266081f, -0.12415206f, 0.08472258f, -0.16363159f, 0.23455323f, 
    -0.03138371f, -0.27934757f, 0.05915543f, 0.02000151f, 0.31769216f, -0.00815640f, -0.08505046f, 0.09610645f, 
    -0.21033053f, -0.01311467f, 0.01939431f, -0.11434016f, 0.07652830f, 0.07621999f, -0.04613068f, 0.08941395f, 
    0.01382591f, -0.03868701f, 0.21019359f, -0.04234034f, 0.06430248f, 0.37296236f, 0.13466910f, -0.02481248f, 
    -0.31754118f, 0.08024648f, 0.10266350f, -0.12862854f, 0.33806831f, 0.21145613f, -0.07691967f, -0.20548698f, 
    -0.03546317f, -0.11061548f, 0.06983137f, 0.17383704f, -0.12254253f, -0.17431417f, -0.13941167f, 0.25025067f, 
    0.11848116f, -0.07025246f, -0.01056154f, -0.02892207f, 0.18348296f, 0.24678038f, 0.02644101f, -0.05986026f, 
    -0.03426592f, 0.00531061f, 0.14526781f, -0.05455297f, -0.09089521f, 0.11183192f, 0.18018155f, -0.10067093f, 
    0.23621409f, 0.07241930f, 0.02803266f, 0.07864043f, -0.01607166f, 0.08359572f, 0.02747852f, -0.02862364f, 
    -0.15827496f, -0.25461054f, -0.18281102f, -0.10291031f, -0.04488032f, -0.12312797f, 0.29043558f, 0.16049536f, 
    0.04604260f, -0.14622083f, 0.00547888f, 0.28502080f, 0.02505757f, -0.03529595f, 0.20044741f, 0.08043407f, 
    0.04879599f, 0.31943351f, 0.24157253f, 0.07720540f, 0.09809256f, 0.33541700f, 0.18424976f, 0.28403410f, 
    -0.01808100f, 0.05789213f, 0.04356572f, -0.05541007f, 0.16753532f, 0.14247116f, 0.22095792f, -0.05140631f, 
    0.21025242f, -0.09357388f, -0.03364707f, 0.08642835f, -0.03593206f, 0.31088117f, 0.24245402f, -0.23798415f, 
    -0.03891082f, -0.03936192f, -0.02603346f, 0.20791297f, -0.14945109f, -0.00234884f, 0.04052264f, 0.26397216f, 
    0.12347571f, 0.06414283f, -0.05750914f, 0.22326769f, 0.08079228f, 0.08085544f, 0.06726510f, 0.01414693f, 
    0.15243277f, 0.19971532f, -0.09755744f, 0.05498455f, -0.11296291f, 0.05568637f, 0.06836215f, -0.07701128f, 
    0.22388053f, 0.09128468f, 0.21189958f, 0.31719258f, -0.07824088f, 0.12486925f, -0.26843765f, -0.00446141f, 
    0.24044251f, 0.35600019f, 0.01803675f, 0.01405688f, -0.11641899f, 0.07364479f, 0.14426851f, -0.11382174f, 
    0.10975451f, 0.08521114f, 0.05748796f, -0.23255444f, 0.01097370f, 0.04405895f, -0.08074953f, 0.00056454f, 
    0.03037396f, 0.00462929f, -0.12346641f, 0.27077478f, 0.00916677f, -0.23605287f, 0.07935733f, -0.08450846f, 
    0.06271832f, -0.10137907f, 0.20231451f, 0.23022702f, 0.03392717f, 0.00090301f, 0.07109939f, -0.22077228f, 
    0.10877217f, -0.05685174f, 0.02161271f, 0.11396956f, -0.23416649f, -0.04662472f, 0.25851169f, 0.14537196f, 
    0.38983685f, 0.05942500f, -0.44575998f, 0.05601354f, 0.02204104f, 0.05577484f, 0.16630648f, -0.10947667f, 
    0.11812183f, 0.27158660f, -0.01173134f, -0.00101217f, 0.20374143f, 0.23620389f, 0.17595720f, -0.09862113f, 
    0.14860371f, -0.28576455f, -0.10303164f, -0.14155485f, -0.19693393f, -0.01904491f, -0.06009748f, -0.17894043f, 
    -0.12485490f, 0.02028824f, -0.04349137f, -0.06095049f, -0.01330954f, -0.03638179f, 0.14284442f, -0.02715134f, 
    0.04890084f, 0.17899896f, -0.00694567f, 0.06032051f, 0.10556801f, -0.08183397f, -0.21317631f, -0.25248596f, 
    -0.08680311f, -0.20152457f, -0.10950383f, 0.06196615f, -0.08829930f, -0.04808373f, -0.27965736f, -0.31164697f, 
    0.02059139f, -0.19007684f, -0.01730071f, 0.06591177f, -0.07625593f, 0.22389735f, 0.28273600f, -0.03115668f, 
    -0.11002768f, -0.00967136f, 0.00690242f, 0.15270375f, -0.14268871f, -0.07546772f, 0.23351410f, -0.11570831f, 
    -0.05704484f, 0.06929806f, 0.08781458f, -0.16865550f, 0.04394070f, 0.12134211f, -0.04896585f, 0.08315772f, 
    -0.05535942f, 0.11906135f, 0.03232239f, 0.00649622f, 0.18051231f, 0.15792434f, -0.11337336f, -0.64370012f, 
    0.15136956f, -0.05932995f, 0.02395377f, -0.14919624f, -0.00730422f, 0.02759119f, 0.07391378f, 0.05395247f, 
    -0.03086812f, 0.10604388f, 0.00510861f, 0.02657120f, -0.05411436f, 0.04953246f, -0.01909168f, 0.01640375f, 
    0.11818773f, 0.16302887f, 0.02200302f, 0.48540065f, 0.04134445f, -0.27780315f, 0.12248506f, -0.33738253f, 
    -0.04405303f, 0.07398955f, -0.04551118f, 0.16437069f, -0.02308333f, -0.24696259f, 0.00462806f, -0.23097491f, 
    0.05995575f, -0.14009678f, 0.08564782f, -0.17209180f, -0.16382584f, -0.13401154f, -0.16926867f, 0.02564575f, 
    0.01023649f, -0.01914959f, -0.08664471f, -0.11329860f, -0.04651349f, 0.06114371f, -0.00260842f, -0.10412931f, 
    -0.03688009f, 0.09412046f, -0.11169392f, -0.12627065f, -0.04806450f, -0.08076984f, -0.04995203f, 0.00980277f, 
    -0.04723362f, 0.01159517f, 0.00112835f, 0.10484882f, -0.01455325f, 0.06994005f, -0.21549073f, -0.10488635f, 
    0.07077536f, -0.02096774f, -0.08912908f, 0.09106543f, -0.11163003f, -0.03683463f, -0.09680860f, -0.01913406f, 
    0.06264811f, 0.07124556f, 0.04812492f, 0.02977064f, -0.02864602f, -0.01025304f, -0.19722439f, -0.08064659f, 
    0.05970524f, -0.13283814f, -0.03652483f, -0.10062784f, 0.11724709f, 0.07002293f, -0.09534439f, -0.10981479f, 
    -0.03398246f, -0.17372486f, 0.00322461f, -0.02597080f, 0.07536671f, 0.00351542f, -0.02675942f, -0.05639575f, 
    -0.15836585f, 0.08167055f, -0.09371945f, 0.02283659f, 0.17929699f, -0.09240451f, -0.16170777f, 0.05297922f, 
    0.08618432f, 0.11341222f, 0.01813354f, -0.12315811f, 0.15664257f, -0.11750235f, -0.26987857f, -0.25223768f, 
    0.08315122f, -0.06909266f, -0.03338270f, -0.14908035f, 0.02596530f, -0.10160443f, 0.07060665f, -0.00893106f, 
    -0.13367572f, -0.13836473f, -0.08627386f, -0.01187482f, -0.00467390f, 0.02643059f, 0.10627732f, -0.08055504f, 
    0.12705781f, 0.15045503f, -0.00885442f, -0.05392199f, -0.16280004f, 0.01076071f, 0.18682724f, 0.04475912f, 
    0.04926612f, 0.01541428f, -0.11158684f, -0.05692371f, -0.04964465f, 0.09302704f, -0.16859449f, -0.10208602f, 
    -0.00111088f, 0.00124180f, 0.02296906f, 0.19660598f, -0.08945726f, 0.09629095f, 0.00426211f, 0.12768392f, 
    -0.10540974f, -0.07027178f, 0.11562912f, -0.17617789f, 0.10728993f, 0.09149662f, 0.01483890f, 0.06573296f, 
    -0.31505156f, 0.23861323f, -0.02199380f, 0.19590335f, 0.28735352f, 0.13952942f, -0.10299316f, -0.13782656f, 
    0.06342535f, 0.06483848f, 0.11115897f, -0.26368383f, 0.19117951f, -0.11962560f, 0.14817038f, 0.06632344f, 
    0.26696351f, -0.00347589f, 0.17863053f, -0.04213228f, 0.09569391f, -0.09051500f, 0.07805382f, 0.02685854f, 
    -0.00555661f, -0.06396502f, 0.11570254f, 0.02402594f, -0.28278360f, -0.17386755f, 0.01839435f, -0.13980857f, 
    -0.25905153f, -0.07554615f, 0.07590245f, -0.00379738f, -0.21696889f, 0.05779048f, 0.27766863f, 0.01719586f, 
    -0.08002359f, -0.13001235f, 0.02317018f, 0.07502440f, -0.10947220f, 0.10063382f, 0.09851680f, 0.09535656f, 
    0.11316239f, 0.18706831f, 0.29556420f, 0.15306289f, 0.09961319f, 0.03919446f, -0.04796346f, 0.02832691f, 
    -0.06454292f, -0.22281589f, 0.01793967f, -0.02483334f, 0.10909862f, -0.11636433f, 0.02899629f, 0.11298939f, 
    -0.07472369f, -0.36658174f, -0.00402912f, -0.01914709f, -0.19789977f, -0.12279459f, 0.32465318f, 0.05690390f, 
    -0.02418737f, 0.06491226f, -0.09012634f, 0.04183798f, 0.06355241f, 0.35241911f, 0.16457215f, 0.21284370f, 
    0.00166158f, -0.06923765f, 0.15139075f, -0.14071111f, -0.05093942f, -0.06672639f, 0.05958680f, 0.08635602f, 
    -0.14241472f, -0.02994595f, -0.01328558f, -0.04491990f, 0.21862844f, 0.17573075f, -0.23556206f, 0.19470873f, 
    -0.00693040f, -0.34038779f, 0.03000802f, 0.13529028f, 0.17892307f, -0.06388795f, -0.15321708f, 0.17919199f, 
    0.02836954f, 0.19434974f, -0.04853879f, -0.03537293f, -0.02138803f, -0.03351247f, 0.14860605f, -0.06668028f, 
    0.07448650f, 0.02905694f, 0.14744860f, -0.03174182f, 0.01044940f, -0.06438980f, 0.14561196f, -0.03654982f, 
    -0.41824833f, 0.32568699f, 0.07830346f, 0.13022751f, 0.03434037f, -0.00481239f, -0.00376196f, -0.36817890f, 
    -0.12123795f, -0.19763669f, -0.05217802f, 0.19859606f, 0.15496476f, 0.21152553f, 0.14449163f, -0.36280015f, 
    0.07672980f, -0.02071051f, 0.07615289f, -0.04987136f, -0.05732545f, -0.03056021f, 0.11672497f, 0.17024426f, 
    0.33578372f, 0.06173897f, 0.05749230f, 0.11912528f, 0.18524410f, 0.05554659f, 0.09587172f, 0.09384102f, 
    0.27207553f, 0.13709463f, -0.05193295f, -0.06689405f, -0.12132911f, 0.03218929f, 0.00268834f, -0.18025075f, 
    -0.12256154f, -0.05491909f, 0.34681559f, 0.23035792f, -0.28157347f, 0.02779505f, -0.10852446f, 0.14163682f, 
    0.12629846f, 0.17845260f, 0.08578636f, 0.10192540f, -0.01194403f, 0.02801724f, 0.09851215f, -0.11368065f, 
    -0.04893085f, -0.15970133f, 0.11638412f, -0.22901256f, -0.01564133f, -0.12543295f, 0.09971619f, 0.07701384f, 
    0.20130962f, -0.21807455f, -0.04484593f, 0.13976514f, 0.01873097f, -0.17331280f, -0.00951756f, -0.24175574f, 
    0.01126945f, -0.13436165f, 0.09851547f, 0.08040777f, -0.10235018f, -0.07319497f, 0.06893951f, 0.34594536f, 
    -0.07966875f, 0.04752572f, -0.03478850f, -0.00570922f, 0.04255790f, 0.25793391f, -0.01231927f, -0.00347462f, 
    0.03906600f, 0.01637771f, 0.17755617f, -0.18210880f, 0.17598060f, 0.01808261f, 0.10519826f, 0.09687607f, 
    0.08193190f, -0.27118418f, 0.06439614f, -0.08992019f, 0.23432435f, 0.10637851f, -0.06585255f, 0.03503896f, 
    -0.08862348f, -0.35600647f, -0.07041836f, -0.18198034f, 0.17117144f, 0.03657836f, 0.01091710f, 0.26736182f, 
    -0.05742590f, -0.07912243f, 0.07810618f, -0.11347178f, -0.03864537f, -0.03797470f, 0.11242066f, -0.01117726f, 
    -0.13034968f, 0.15262340f, 0.14601728f, -0.05207089f, 0.01535966f, 0.01778687f, 0.33104914f, 0.22923557f, 
    -0.07881478f, 0.20476413f, -0.05022055f, -0.11450497f, 0.19144097f, 0.26981053f, 0.16982220f, -0.14962079f, 
    -0.24931717f, 0.10683154f, 0.06144872f, -0.12734288f, 0.07534650f, 0.00952367f, 0.04224907f, -0.00027495f, 
    -0.09825813f, 0.08284172f, -0.03331003f, -0.16896832f, 0.03137990f, 0.00744688f, 0.23854527f, 0.16338962f, 
    -0.15422554f, 0.11757191f, 0.10804922f, 0.11041202f, 0.22172631f, 0.08238014f, 0.14577326f, -0.12401085f, 
    0.03313529f, -0.01672386f, -0.00397983f, -0.10133812f, -0.18383875f, -0.07450353f, -0.11747240f, -0.10125434f, 
    0.02878244f, 0.17378497f, 0.09832602f, -0.08177421f, 0.19037853f, -0.07567871f, 0.04972129f, 0.18165898f, 
    -0.03827833f, 0.04571100f, 0.01326161f, 0.18526989f, -0.00262990f, -0.10242429f, -0.06551304f, 0.03369714f, 
    0.01076223f, 0.02434145f, 0.33811602f, 0.46120635f, 0.00580156f, 0.20022644f, 0.13254759f, -0.29022345f, 
    -0.18406880f, 0.16151662f, -0.08746631f, -0.10588167f, -0.03381234f, -0.05260834f, -0.12910859f, 0.31536037f, 
    0.48453277f, -0.26429155f, -0.10938991f, -0.08906042f, -0.02846348f, 0.18371964f, 0.28247541f, 0.20334417f, 
    0.06657189f, 0.11474526f, -0.10564025f, 0.40261272f, 0.01014308f, -0.06688103f, -0.20292050f, -0.00341074f, 
    -0.12913500f, -0.05828656f, 0.05883612f, -0.21200788f, 0.02569476f, 0.09783300f, -0.04052030f, -0.01338953f, 
    0.07352583f, -0.08235352f, 0.03424191f, -0.02578165f, 0.41903287f, 0.29316771f, 0.08726265f, -0.29039642f, 
    0.41588429f, 0.04898747f, -0.11290102f, -0.14942940f, 0.29207906f, -0.06366317f, -0.14119591f, 0.10036358f, 
    0.22597487f, 0.18621437f, -0.00330966f, -0.10969772f, 0.04621146f, 0.12267582f, 0.09721114f, 0.00878125f, 
    0.06562036f, 0.14127597f, 0.00946893f, 0.02031016f, 0.06676474f, -0.16802761f, -0.02199281f, -0.02538060f, 
    -0.00757322f, 0.34702170f, 0.08099853f, 0.26761696f, -0.00307926f, -0.18454668f, 0.16624442f, 0.02845295f, 
    -0.07100637f, -0.12528566f, -0.14121267f, 0.01021144f, -0.09570537f, -0.01307519f, -0.13053367f, 0.04202366f, 
    -0.08738218f, 0.04327022f, 0.00532995f, -0.13608924f, -0.05779133f, -0.11415883f, 0.08742957f, -0.15403099f, 
    -0.03283460f, -0.02689517f, -0.05104110f, -0.02519920f, 0.08901415f, 0.09140818f, -0.15135179f, -0.07380448f, 
    -0.02884111f, 0.01848978f, 0.01248690f, -0.01904921f, -0.01885138f, -0.08347304f, -0.07941675f, 0.06343757f, 
    0.03663472f, -0.07737613f, -0.08661211f, -0.15311351f, 0.04618571f, 0.04653816f, 0.01554212f, -0.11962850f, 
    0.02679054f, 0.04513089f, -0.09481099f, -0.15014130f, 0.08802944f, -0.05401133f, -0.00421568f, -0.12188332f, 
    0.00214745f, -0.07199152f, -0.03791767f, -0.00414143f, 0.07487746f, -0.00414527f, -0.03657454f, 0.02160939f, 
    0.07627157f, -0.06086570f, -0.08198217f, 0.03334379f, 0.06448345f, -0.16621508f, -0.07988193f, 0.06351774f, 
    0.18229491f, 0.11836665f, -0.16709317f, 0.13791777f, 0.09342887f, 0.19652951f, -0.15634024f, 0.01281700f, 
    0.03320000f, 0.00474891f, -0.09305189f, -0.24720240f, 0.27000630f, 0.06126122f, -0.07786478f, -0.09275609f, 
    0.01679718f, 0.08226264f, 0.27739760f, -0.06604028f, 0.09477908f, 0.03273262f, 0.16669536f, -0.02670943f, 
    -0.13113359f, -0.01517103f, 0.07437557f, -0.05582340f, -0.29786190f, -0.24728480f, -0.02441690f, 0.19468391f, 
    -0.32299876f, 0.27286017f, 0.29403335f, 0.25990885f, 0.06554764f, 0.10836093f, -0.01046318f, 0.20794228f, 
    0.00990126f, 0.00387991f, 0.12754110f, -0.05430675f, -0.00973060f, -0.07566302f, -0.06756880f, 0.04632879f, 
    0.09611183f, 0.08605584f, -0.06438459f, -0.37721014f, 0.11235427f, -0.00251622f, 0.21248543f, 0.01869245f, 
    0.10952728f, -0.25125259f, -0.10422756f, -0.23146477f, 0.00310379f, -0.09010638f, 0.28958589f, 0.21131691f, 
    0.18920487f, 0.10161252f, 0.09042633f, 0.07228667f, 0.19281660f, 0.25144446f, 0.02017587f, 0.10397996f, 
    -0.01799471f, -0.10441450f, -0.01425747f, 0.07279316f, 0.03172917f, -0.22902721f, 0.01463363f, -0.15345642f, 
    0.01071255f, -0.10226307f, -0.00671467f, -0.06424367f, 0.20579021f, -0.09893720f, -0.09460084f, -0.07844586f, 
    0.02395021f, -0.26702669f, 0.10657694f, 0.09681240f, 0.08909536f, 0.06028479f, -0.24407536f, -0.36848620f, 
    0.22444390f, 0.05299416f, 0.23777138f, -0.07848244f, 0.01279454f, 0.05132537f, 0.07487657f, 0.13481385f, 
    0.17614040f, -0.06864852f, 0.10079790f, -0.20573223f, 0.06420039f, -0.05234135f, 0.04987403f, -0.05493699f, 
    0.10996051f, -0.11031280f, -0.03175228f, 0.23728828f, -0.03381668f, -0.26319191f, 0.00292194f, 0.02103981f, 
    0.02537425f, 0.25258666f, 0.10946055f, 0.13542777f, 0.01616528f, -0.24040744f, -0.01350102f, 0.16138250f, 
    0.08764344f, -0.10736934f, -0.37423614f, 0.14962274f, -0.01675709f, 0.13110612f, 0.30275202f, -0.30812311f, 
    0.06745776f, -0.08988918f, -0.05521338f, 0.02608554f, -0.14961788f, 0.32005763f, -0.04987896f, 0.02747407f, 
    0.05223489f, 0.04474851f, 0.08473813f, -0.06810475f, -0.06521317f, 0.05507574f, 0.14285932f, -0.04017154f, 
    -0.03265309f, 0.06313940f, 0.01218131f, 0.08419114f, 0.20021217f, 0.17845684f, 0.01369578f, 0.17684554f, 
    0.12143998f, -0.05467109f, -0.13049953f, 0.21087106f, 0.05094418f, -0.06073957f, -0.07060984f, -0.09615166f, 
    -0.04714318f, -0.09644353f, 0.10293303f, -0.23894922f, -0.01645721f, 0.07908763f, 0.01849213f, -0.02433099f, 
    0.04362302f, 0.07561668f, 0.09703218f, 0.02154763f, 0.06454205f, -0.08442778f, -0.07777283f, -0.04844802f, 
    -0.06944364f, 0.08842727f, 0.07809781f, -0.02283577f, 0.15961321f, 0.12745309f, 0.10167196f, -0.60155994f, 
    0.02829774f, 0.16619924f, -0.34628102f, 0.03768929f, 0.05541839f, -0.27546388f, 0.04141279f, 0.06287795f, 
    0.05001574f, 0.09398615f, -0.10321124f, 0.06960474f, 0.10623062f, 0.27228096f, -0.03979607f, 0.14600810f, 
    0.10923519f, -0.00951993f, 0.08324287f, 0.18707147f, 0.06419408f, 0.05229937f, -0.10406761f, 0.01740754f, 
    -0.04793060f, -0.12787075f, 0.09572557f, -0.07199531f, 0.41240191f, 0.29071188f, 0.21267878f, 0.20965666f, 
    -0.10536797f, -0.03952861f, -0.11688723f, -0.02469185f, -0.16685747f, -0.00025356f, 0.16172373f, 0.10196803f, 
    0.14375503f, -0.08319908f, -0.01256799f, -0.30036667f, -0.07650729f, -0.11448064f, -0.16064914f, 0.08381184f, 
    -0.04245728f, -0.02782280f, 0.09018781f, -0.17218244f, 0.12312920f, 0.33251134f, 0.00764534f, 0.27849045f, 
    -0.09220984f, 0.11495242f, -0.07663787f, -0.10939798f, 0.10811464f, 0.28195873f, -0.00319788f, 0.00595414f, 
    -0.03789146f, 0.07110588f, -0.06165390f, 0.01216880f, -0.31869850f, -0.06837954f, -0.12181304f, 0.06593412f, 
    -0.06417491f, 0.00680326f, 0.04642562f, -0.03161473f, 0.22279447f, 0.02012748f, 0.23416546f, -0.10860138f, 
    0.08105899f, 0.11907205f, 0.03543251f, -0.06520661f, -0.16717152f, 0.08834229f, -0.07258196f, -0.04168705f, 
    0.10358306f, 0.10673710f, -0.08535244f, 0.11943384f, -0.09719571f, 0.01473722f, 0.02253205f, -0.14902347f, 
    0.01624870f, -0.30428988f, 0.14813936f, -0.01204300f, -0.14962231f, -0.11030051f, -0.18830261f, -0.17397010f, 
    -0.32630906f, 0.11687562f, 0.03614465f, -0.01540126f, -0.06700256f, -0.03263961f, -0.22495688f, -0.11676136f, 
    0.00091340f, -0.05845145f, 0.06224347f, 0.16848841f, 0.05055271f, 0.02887725f, 0.06679390f, -0.06406336f, 
    -0.04405079f, -0.18253170f, 0.01762103f, -0.15251479f, 0.06670982f, -0.15230867f, -0.06227516f, -0.00725617f, 
    0.00571547f, 0.05012842f, -0.06602338f, -0.09942219f, -0.14650561f, -0.03457084f, 0.04725222f, 0.03037894f, 
    0.10495880f, 0.03957675f, 0.11156084f, -0.07935172f, 0.01987101f, -0.05916306f, -0.02158236f, -0.13773513f, 
    0.09546788f, -0.12470554f, -0.08738067f, 0.01935446f, -0.12523298f, 0.08820754f, -0.13881637f, 0.00323086f, 
    0.03146891f, -0.10532352f, 0.12215853f, -0.07651475f, -0.00946996f, 0.09829773f, 0.03838180f, -0.12960389f, 
    0.04828123f, -0.14450072f, -0.00867060f, -0.06894702f, 0.01096717f, -0.06758981f, 0.04310025f, -0.03880507f, 
    -0.13238518f, -0.04486068f, 0.04798691f, -0.12358493f, -0.03667434f, -0.07895844f, -0.05414193f, 0.04534733f, 
    -0.06639196f, -0.06485691f, -0.15272535f, -0.10894486f, 0.04886517f, 0.01720578f, 0.03920021f, 0.08085291f, 
    -0.12208110f, 0.06069024f, -0.10050325f, -0.09672900f, -0.14871493f, -0.09224114f, 0.07073730f, 0.10190998f, 
    0.20987707f, -0.05472062f, -0.41298637f, 0.25079703f, 0.00233998f, 0.15123978f, 0.16202115f, -0.33350259f, 
    -0.09245589f, 0.10704903f, 0.03422513f, 0.20376499f, -0.24575686f, 0.08967781f, 0.25744501f, 0.05876587f, 
    -0.01045100f, -0.09977183f, 0.06776083f, -0.12376546f, 0.04436356f, -0.02918772f, 0.08623762f, 0.08137999f, 
    0.21681547f, 0.02848290f, -0.07993156f, 0.02775219f, 0.06627189f, 0.11465982f, -0.22392398f, -0.44358164f, 
    0.02032372f, -0.21272770f, -0.10415804f, 0.09512559f, 0.06082946f, 0.06942958f, 0.14203431f, 0.10985661f, 
    0.13039136f, -0.00686504f, 0.10705449f, 0.14934231f, 0.03666751f, 0.05287311f, 0.15976013f, 0.02848998f, 
    -0.09779228f, 0.06176444f, -0.00863245f, 0.18416095f, -0.02218857f, -0.07802930f, 0.14915651f, -0.21541575f, 
    0.37479672f, -0.08981789f, -0.00890431f, -0.02666432f, -0.21089907f, -0.18755978f, 0.10624471f, -0.10126331f, 
    -0.03662860f, 0.27778307f, -0.18534419f, 0.13550025f, 0.22248256f, 0.05425427f, 0.15367153f, -0.27983624f, 
    -0.09873085f, 0.09436779f, -0.02255293f, -0.22437914f, -0.18015561f, -0.02267366f, 0.35562345f, 0.06491200f, 
    0.18928462f, -0.09853999f, -0.13052106f, 0.13571168f, 0.11059611f, -0.02205024f, -0.09670695f, 0.01439647f, 
    0.23038809f, 0.26583454f, 0.08491658f, -0.02340254f, -0.25638133f, -0.07816049f, -0.03455697f, -0.07652634f, 
    -0.43146139f, -0.01962893f, -0.32435244f, -0.06161984f, -0.38612819f, 0.10806499f, 0.24502814f, -0.07777522f, 
    -0.06258515f, 0.00782058f, -0.10297722f, 0.17162007f, -0.09532459f, 0.04494973f, 0.00949087f, -0.05874468f, 
    0.09760187f, 0.10693967f, 0.30862999f, 0.07676064f, -0.07113829f, 0.23037803f, 0.17900655f, -0.03604353f, 
    0.15782435f, -0.09671338f, -0.10160296f, -0.03515282f, -0.05912653f, 0.07512196f, -0.07821958f, 0.06053289f, 
    0.12643233f, 0.10485013f, 0.17152026f, 0.15054885f, 0.08855430f, -0.27241164f, 0.02860260f, -0.04033034f, 
    0.02300700f, -0.04255667f, 0.04596385f, 0.03650673f, -0.38707995f, 0.01440236f, 0.06464326f, 0.13156794f, 
    -0.11675534f, 0.09673344f, -0.63362509f, 0.19210529f, 0.03902704f, 0.05515731f, -0.07006866f, -0.00355608f, 
    0.09372484f, 0.10601246f, -0.08897193f, 0.13379443f, 0.04396189f, 0.17286071f, -0.08349010f, -0.14722815f, 
    0.09562410f, -0.12741105f, -0.52431303f, -0.37307674f, 0.01959368f, -0.00327891f, 0.27534524f, -0.03471065f, 
    0.14568776f, 0.19589496f, -0.05762161f, 0.01632951f, 0.05839241f, -0.07329945f, 0.21115983f, 0.12205182f, 
    0.07482548f, 0.11021704f, 0.15853685f, 0.18723884f, 0.07901365f, 0.49507180f, -0.17770040f, -0.58794242f, 
    -0.20169328f, 0.20723757f, 0.11192078f, 0.01537003f, -0.05328727f, -0.02950640f, -0.43028679f, 0.21545628f, 
    0.02146710f, 0.03226481f, -0.31276840f, 0.05457827f, -0.26973680f, -0.02516430f, 0.27714670f, -0.02021513f, 
    0.00433065f, 0.03499783f, 0.01526118f, 0.00528600f, -0.07376680f, 0.21862786f, -0.03222612f, 0.28728211f, 
    -0.01714884f, -0.04139663f, 0.13546638f, 0.17482708f, -0.03771799f, 0.02447769f, 0.27701515f, -0.07780670f, 
    -0.30132240f, 0.19145270f, 0.10070910f, 0.06142829f, 0.08835138f, -0.07340048f, -0.41080496f, 0.34587705f, 
    0.08795968f, 0.13779289f, 0.17902648f, 0.31369534f, 0.23612662f, -0.05756136f, 0.09692926f, -0.08145218f, 
    0.22154868f, 0.27733469f, -0.10457513f, -0.48383555f, 0.05251088f, -0.02196835f, -0.02863441f, -0.01515345f, 
    0.10489613f, -0.24983226f, -0.08443375f, -0.20971495f, 0.11802450f, 0.01653252f, -0.07174790f, 0.06158122f, 
    -0.26785082f, 0.24589837f, 0.02196143f, 0.14745125f, 0.19965470f, -0.15840738f, -0.22810020f, -0.02903365f, 
    -0.10886778f, 0.05751226f, -0.13009505f, 0.23958795f, 0.05335011f, 0.13173680f, 0.04429472f, -0.22981904f, 
    -0.11326601f, 0.00276884f, 0.06912596f, -0.24182108f, 0.01178825f, -0.01022563f, 0.03360058f, -0.20955728f, 
    0.13988265f, -0.02608481f, 0.25850704f, -0.29134610f, 0.08496002f, -0.02947824f, 0.20528439f, 0.09878787f, 
    0.04305829f, -0.15136926f, 0.07565168f, 0.00390105f, -0.29014486f, -0.19652124f, -0.13884255f, -0.08976506f, 
    -0.08717386f, 0.03531677f, 0.13854714f, 0.07778796f, -0.00623585f, 0.11698662f, 0.11223478f, 0.19257472f, 
    -0.00595629f, 0.08849574f, -0.10275537f, 0.26431292f, 0.08049446f, -0.07780568f, 0.16555181f, -0.08303355f, 
    0.09687100f, 0.26314718f, 0.07759740f, 0.07990839f, -0.08324683f, -0.03915972f, 0.03729078f, -0.08248027f, 
    0.15788130f, -0.18852317f, -0.02053883f, -0.13407734f, 0.03589845f, -0.04381996f, 0.23413613f, -0.08883559f, 
    0.10945144f, 0.15489350f, 0.13069108f, -0.26636651f, 0.08709092f, -0.21095221f, -0.15403056f, -0.20559761f, 
    0.06657296f, -0.09376102f, -0.09710570f, -0.06975086f, -0.12361021f, -0.00100364f, -0.03075250f, -0.09490522f, 
    -0.12288222f, 0.06874532f, -0.10764986f, 0.14990011f, -0.04170329f, 0.10952612f, -0.54510319f, -0.02471414f, 
    -0.22348626f, -0.00207522f, 0.00576474f, -0.03806674f, 0.09974569f, 0.04332199f, 0.08248854f, 0.03330931f, 
    -0.08713077f, -0.12975705f, -0.07528944f, -0.22146539f, -0.03361622f, -0.12131712f, -0.22490080f, -0.16956870f, 
    -0.07065396f, 0.05751433f, 0.03090106f, -0.04556584f, -0.10724722f, -0.06193370f, 0.15911265f, -0.03301732f, 
    0.08003449f, -0.02286254f, -0.01143786f, -0.03398976f, 0.00123051f, 0.14763910f, -0.16751915f, 0.04914697f, 
    -0.14997610f, -0.17010628f, 0.02942890f, -0.11403087f, 0.06160165f, 0.13373335f, -0.12317114f, -0.17522806f, 
    -0.09718552f, -0.04553896f, 0.02169997f, 0.00137603f, 0.02006768f, -0.03791989f, 0.05824196f, -0.11937765f, 
    -0.04969676f, 0.05826022f, -0.10642923f, -0.11108772f, 0.00420917f, -0.09247068f, -0.10266998f, -0.03012285f, 
    -0.07781101f, 0.12364639f, 0.02238942f, 0.03170270f, 0.06743203f, -0.01976815f, -0.05425818f, -0.01456620f, 
    0.01137089f, -0.14543417f, 0.11225276f, -0.01460089f, 0.02492515f, -0.07724576f, -0.03932017f, 0.04152999f, 
    -0.09377047f, 0.00358153f, -0.00817630f, -0.00277744f, -0.00228907f, -0.03854899f, -0.01558250f, -0.08954804f, 
    -0.12733047f, 0.08927265f, -0.09289464f, -0.10845894f, 0.02111730f, -0.01872025f, -0.00535665f, 0.03555080f, 
    -0.03744385f, -0.02878163f, 0.04014415f, 0.00630552f, 0.05439524f, 0.02308428f, 0.00053669f, -0.02728190f, 
    -0.03788936f, -0.14086588f, 0.08655511f, -0.07038517f, -0.02519410f, -0.10920959f, -0.06771854f, -0.00912355f, 
    -0.11413302f, 0.20517090f, -0.11699995f, 0.05185485f, -0.00284304f, 0.00994642f, -0.14487067f, 0.01879174f, 
    0.09593201f, 0.10915539f, 0.00020265f, 0.06440669f, -0.06887148f, 0.07130934f, 0.27195999f, 0.01870282f, 
    -0.06843542f, 0.05295277f, -0.15979519f, -0.07965343f, -0.20753510f, 0.03109753f, 0.14496161f, 0.10193423f, 
    -0.03940491f, 0.28897148f, -0.09309860f, -0.09708920f, -0.11157741f, -0.30851328f, -0.19206035f, 0.04503554f, 
    -0.32593209f, 0.17330176f, -0.20933279f, -0.08355287f, -0.45562628f, 0.07972971f, 0.31418034f, 0.01613656f, 
    0.07492444f, 0.05199074f, -0.01084105f, 0.26205224f, -0.00711417f, 0.02272692f, -0.14451198f, -0.03474897f, 
    -0.04635635f, 0.29399887f, 0.18689403f, 0.13186133f, -0.06257115f, 0.18318129f, -0.01087230f, -0.09032407f, 
    -0.01582327f, -0.25864905f, 0.00199494f, 0.01171341f, -0.15555063f, -0.18134855f, -0.07218684f, 0.30700082f, 
    0.16094229f, 0.01452289f, 0.17859299f, 0.17020459f, -0.00295142f, 0.02889467f, -0.25118595f, -0.03629155f, 
    -0.00589793f, 0.06376226f, 0.13192616f, 0.01753872f, 0.26383403f, -0.10569770f, -0.05774109f, -0.10106973f, 
    0.25833863f, 0.05674554f, 0.29429394f, -0.12362458f, 0.18850498f, 0.05436107f, 0.16938354f, -0.11391070f, 
    -0.13159959f, 0.03199302f, 0.10324564f, -0.09504276f, 0.02039514f, -0.10147290f, 0.10462426f, -0.07190147f, 
    0.19277929f, 0.38898426f, 0.35205340f, -0.01298783f, -0.21503621f, -0.07363322f, 0.39875972f, 0.07430985f, 
    0.15851696f, 0.01853511f, 0.00386073f, -0.08117334f, -0.09539096f, 0.05057010f, 0.12644167f, 0.05899371f, 
    -0.04059041f, 0.00695001f, -0.06609192f, -0.23876363f, -0.05171593f, -0.05372407f, 0.02994661f, 0.43451762f, 
    0.18454666f, 0.06878144f, 0.01625788f, -0.21600647f, 0.01216260f, -0.23587146f, 0.15755071f, 0.50868112f, 
    -0.20671526f, 0.22498721f, -0.08390795f, 0.00829369f, -0.16886012f, 0.01188605f, 0.00429538f, 0.02427654f, 
    0.01451559f, -0.11775123f, -0.01500539f, -0.08317492f, 0.22554134f, 0.18535908f, 0.08402347f, -0.03268558f, 
    0.02661753f, 0.11135026f, 0.07185980f, -0.09414575f, -0.02114275f, 0.08163599f, 0.10724837f, 0.11113157f, 
    -0.11851314f, 0.08080161f, -0.10138462f, -0.05875184f, -0.01520446f, -0.13039778f, -0.12351088f, 0.26520613f, 
    -0.11130955f, 0.22545987f, 0.20131715f, -0.04881348f, 0.36769521f, -0.10908009f, 0.25497180f, 0.08171853f, 
    -0.07169092f, -0.03725759f, -0.07290164f, -0.08897261f, 0.00468864f, 0.03509071f, -0.00381586f, 0.10519944f, 
    -0.06501275f, 0.11041319f, 0.06971111f, -0.00775361f, -0.09451880f, 0.18994322f, 0.05244870f, 0.07941442f, 
    -0.11394808f, 0.29045540f, -0.03761894f, -0.18703772f, 0.18077798f, 0.05086185f, 0.05107634f, -0.00885729f, 
    0.16051987f, -0.15407874f, 0.18877465f, 0.02517210f, 0.36460561f, 0.25895947f, -0.03774039f, 0.25363481f, 
    -0.01885433f, -0.08412094f, 0.08110685f, -0.07563628f, 0.20471105f, -0.36554125f, -0.29594946f, -0.05205810f, 
    -0.05537577f, -0.07799151f, 0.01834020f, 0.13660170f, 0.20580967f, 0.02071157f, -0.30138084f, -0.11216539f, 
    0.03250530f, -0.24867867f, -0.06477830f, 0.02436941f, -0.06897324f, -0.09304205f, -0.01691234f, 0.09334321f, 
    0.10992835f, 0.14340346f, 0.14671706f, 0.14925624f, 0.21577069f, -0.08617537f, -0.18052280f, 0.19325945f, 
    0.21069409f, 0.25175104f, -0.05267157f, 0.13375904f, -0.05726496f, -0.09782220f, 0.20257033f, 0.11702312f, 
    0.08942035f, -0.01802109f, -0.17357251f, 0.06330674f, 0.07509983f, 0.06300414f, 0.11041979f, 0.10113733f, 
    0.12989108f, -0.12539689f, -0.01882310f, 0.19329466f, 0.02012837f, -0.04990823f, 0.25801525f, 0.12865660f, 
    0.16674910f, 0.05117955f, -0.01521394f, -0.06741290f, 0.18443328f, 0.00167100f, 0.01816394f, -0.26524138f, 
    -0.06382848f, 0.05510352f, 0.10407096f, 0.25160322f, -0.17308794f, -0.00756675f, -0.00417602f, 0.14105026f, 
    -0.18713005f, -0.05867884f, -0.51924229f, -0.07109524f, -0.11670332f, 0.10683088f, -0.31376994f, -0.06535437f, 
    0.00066826f, 0.09979875f, 0.00606813f, 0.05750200f, 0.39867064f, 0.08056313f, 0.11553485f, 0.03680423f, 
    0.24191296f, 0.37647098f, 0.00901921f, -0.01760992f, 0.07287303f, 0.11233630f, -0.10468726f, -0.16569951f, 
    0.16426483f, 0.23944120f, 0.07640951f, -0.17087339f, 0.02775152f, 0.00474414f, 0.03358041f, -0.02268263f, 
    0.02395344f, 0.02600205f, -0.28785333f, -0.19089638f, 0.01410283f, 0.17155887f, -0.32133886f, -0.24301763f, 
    0.08970792f, 0.04484797f, 0.06162613f, 0.04317326f, -0.11182552f, -0.02684585f, 0.03777225f, 0.09037916f, 
    0.21213345f, -0.13625377f, 0.14717424f, 0.19206250f, 0.13983445f, -0.12794279f, -0.18231995f, -0.31410372f, 
    0.01100607f, 0.11849967f, -0.04975683f, 0.14772880f, -0.32222414f, -0.11576477f, -0.09273751f, 0.12881412f, 
    -0.26700348f, -0.10526648f, -0.39881158f, -0.01920893f, -0.06299458f, -0.05772703f, -0.18211487f, -0.10559089f, 
    0.08471211f, -0.05968849f, 0.07960270f, 0.04785762f, 0.25061959f, 0.11522812f, 0.05899615f, 0.01672003f, 
    0.05308965f, -0.03580012f, -0.03688909f, -0.60180962f, 0.25596279f, -0.09260806f, 0.14330679f, 0.01353408f, 
    0.13774408f, 0.05548242f, 0.00884908f, 0.09268139f, -0.02907635f, 0.12292209f, 0.35520259f, -0.05747146f, 
    0.03309497f, 0.29693326f, -0.00346928f, -0.06287800f, -0.00263416f, 0.33436161f, -0.14045045f, -0.31864637f, 
    -0.19899008f, 0.07418728f, -0.05589952f, -0.02027420f, -0.17015214f, -0.03831773f, -0.19025555f, 0.12928060f, 
    0.27985021f, -0.11953107f, 0.05252660f, 0.05455027f, 0.32760575f, 0.16161712f, -0.11353362f, 0.17051937f, 
    -0.09274166f, 0.11279812f, 0.09365527f, 0.14373104f, -0.02966928f, -0.07169301f, 0.01673683f, -0.14763954f, 
    -0.10643245f, 0.11849666f, 0.04035917f, -0.07554764f, 0.22182584f, -0.10665017f, -0.11762397f, 0.03739163f, 
    0.10935826f, -0.17161271f, 0.08869981f, 0.04395835f, 0.05742886f, 0.13712534f, 0.21682930f, -0.24466936f, 
    -0.06022861f, 0.03030143f, -0.30401561f, -0.17389999f, -0.05956952f, 0.06088528f, 0.13914543f, 0.06821986f, 
    0.11663314f, -0.13262828f, 0.08608732f, 0.18049280f, 0.06562568f, -0.09316431f, 0.05322490f, 0.06747011f, 
    0.10718733f, 0.28335121f, -0.08108416f, 0.21208163f, -0.03961313f, 0.00710021f, -0.02843247f, -0.01938203f, 
    0.17148799f, -0.15045185f, 0.12808427f, 0.05057667f, -0.03936166f, 0.09675111f, 0.11062232f, 0.17586413f, 
    0.23934570f, -0.25238845f, -0.47457510f, 0.35765007f, -0.18417899f, 0.21479827f, 0.22101802f, -0.18079638f, 
    -0.03498294f, 0.04207455f, 0.04485324f, 0.07288230f, -0.05025405f, 0.17619559f, 0.15213226f, 0.06939997f, 
    0.28476307f, 0.08558667f, 0.03676519f, -0.14425686f, 0.03055748f, 0.09826572f, 0.07512397f, -0.11079522f, 
    0.25637051f, -0.16091011f, 0.06486566f, 0.05744299f, 0.28733176f, 0.21415736f, -0.13115892f, -0.26423332f, 
    -0.07918572f, -0.31854582f, 0.20250492f, 0.03703257f, 0.09542507f, 0.08542720f, 0.09340371f, 0.22095084f, 
    0.07484858f, -0.12077010f, -0.02552047f, -0.14735852f, 0.09642640f, 0.07386795f, 0.28950772f, -0.08547017f, 
    -0.00743167f, 0.11607951f, -0.04653377f, -0.20121025f, 0.08605104f, -0.25196472f, 0.15599649f, 0.13271739f, 
    0.09915517f, 0.12905613f, -0.07365402f, 0.02591579f, -0.09606670f, -0.19277860f, 0.04289218f, -0.07810166f, 
    -0.10600690f, 0.06302428f, 0.01844282f, -0.05192100f, -0.05555963f, 0.00243668f, 0.20442376f, 0.11277670f, 
    -0.09526324f, -0.00067471f, 0.10472377f, -0.11839420f, 0.04280360f, 0.13282575f, 0.14063475f, 0.07342006f, 
    -0.08328033f, 0.10742495f, -0.02591097f, -0.01312328f, -0.11838070f, -0.04055015f, 0.09882443f, 0.00435951f, 
    -0.13152575f, 0.30204472f, -0.08201399f, 0.09077568f, -0.30225042f, -0.26752692f, -0.16341762f, 0.14334419f, 
    0.02499902f, 0.10279804f, -0.02574108f, 0.29800758f, 0.37834838f, -0.05809616f, -0.20382237f, -0.02161532f, 
    -0.10323653f, 0.18481024f, 0.00019146f, 0.11424718f, -0.05102462f, -0.04817823f, 0.08603670f, 0.05539385f, 
    -0.06384337f, 0.17614068f, 0.11504628f, 0.24839431f, -0.05238300f, 0.34452966f, -0.02088284f, -0.24824622f, 
    -0.09620114f, -0.01200359f, 0.11621498f, 0.15297191f, 0.16783914f, -0.05263590f, 0.22767588f, -0.11918726f, 
    0.27704462f, -0.17784686f, -0.07682713f, -0.31735590f, 0.02982824f, -0.09937621f, 0.24487153f, 0.18916114f, 
    0.11308415f, -0.06387438f, -0.08372978f, 0.21691211f, 0.00330246f, 0.12948316f, 0.08116033f, 0.02486323f, 
    -0.00772583f, 0.04332155f, -0.06681181f, 0.06280541f, 0.19514014f, 0.05732022f, -0.16497126f, 0.09611885f, 
    0.09208295f, -0.25883764f, 0.08714215f, -0.06471917f, 0.21326758f, 0.08674017f, 0.03588970f, 0.19413856f, 
    0.08816301f, 0.02271815f, 0.16440569f, 0.07871748f, 0.36913177f, -0.00186769f, -0.38605386f, 0.18664813f, 
    -0.02254190f, 0.15824284f, -0.04210887f, -0.14977844f, 0.08996467f, 0.01758008f, 0.00669715f, 0.08914324f, 
    0.07694951f, -0.18841848f, 0.02978303f, -0.29628870f, -0.00702639f, -0.02094475f, 0.06923886f, 0.10926192f, 
    -0.06183970f, 0.01646789f, 0.03896597f, -0.03530736f, 0.15652429f, 0.16988318f, -0.02691838f, 0.09933601f, 
    0.01472302f, 0.00478439f, -0.14090931f, -0.13884139f, -0.01272785f, -0.08552945f, -0.01047455f, -0.04967976f, 
    -0.10995964f, -0.11078305f, 0.03092877f, -0.12981156f, -0.06347437f, -0.07160726f, -0.12722567f, -0.13645536f, 
    -0.00735853f, -0.00992552f, -0.02674772f, -0.09614138f, -0.14879130f, -0.00806410f, 0.06657577f, 0.07753817f, 
    -0.00416800f, -0.11276479f, 0.06244540f, -0.07677847f, -0.13930848f, -0.09860636f, -0.10647319f, 0.09043440f, 
    0.05498624f, -0.12179653f, -0.14150035f, -0.06513753f, 0.03763800f, -0.05983062f, 0.03797606f, 0.00495421f, 
    0.06953979f, 0.03162459f, 0.05155730f, -0.04364110f, 0.10319597f, -0.06501120f, -0.13644183f, -0.02572965f, 
    -0.07302578f, -0.12737660f, 0.01672513f, 0.02061866f, -0.05578105f, -0.09402376f, 0.06443959f, 0.05419654f, 
    -0.10810138f, -0.07431901f, 0.00306009f, -0.04987965f, -0.05939823f, -0.09529548f, -0.10168139f, 0.07447536f, 
    0.14552523f, -0.22121085f, 0.08785328f, -0.13601691f, -0.13978964f, -0.03624479f, -0.00548416f, 0.18116945f, 
    -0.12469929f, 0.07238042f, 0.07567546f, 0.14277913f, -0.21644996f, 0.16851616f, 0.16023536f, -0.09047578f, 
    0.11446109f, -0.05212623f, -0.15824452f, -0.05790430f, 0.01780502f, -0.04694076f, -0.01893912f, -0.08363988f, 
    -0.18966469f, 0.06495959f, -0.03142853f, -0.07446557f, 0.33397856f, 0.17353815f, 0.10016344f, -0.11249744f, 
    0.28761974f, 0.03371354f, 0.03602321f, 0.19741802f, 0.10767249f, -0.09606156f, -0.10235132f, 0.00919754f, 
    -0.11487994f, 0.21174763f, 0.06095825f, -0.15803987f, 0.01527458f, 0.01146061f, 0.14090045f, 0.06764478f, 
    0.07919214f, 0.12414844f, -0.13875453f, -0.03405647f, 0.01655368f, -0.09734032f, -0.09385940f, -0.24493735f, 
    0.03282510f, 0.02718307f, -0.07491336f, 0.17858939f, -0.03494316f, -0.03729174f, 0.06999944f, -0.02878693f, 
    0.05664143f, -0.21788788f, 0.12678140f, 0.11840300f, 0.08635342f, 0.05445677f, 0.05425359f, 0.07292980f, 
    -0.08494381f, -0.05022395f, 0.09940717f, -0.06146055f, 0.09609756f, 0.14508617f, 0.22402214f, 0.17403847f, 
    0.01603191f, 0.06615224f, 0.13625544f, 0.11368161f, 0.19232866f, -0.04639262f, 0.19463024f, -0.07689878f, 
    0.11239121f, 0.07177716f, -0.10375309f, -0.11363751f, -0.25708064f, -0.11094774f, 0.05858777f, 0.01859942f, 
    -0.14461075f, -0.29920095f, -0.04229020f, -0.02567818f, 0.02181715f, 0.04504536f, -0.16523327f, 0.06320891f, 
    -0.22585656f, 0.06811576f, -0.09267822f, 0.21394601f, 0.01064754f, 0.04167738f, 0.11514569f, -0.00463644f, 
    0.02948310f, 0.21471050f, 0.05692341f, 0.14802389f, -0.08337729f, 0.03836367f, 0.18365812f, -0.18756473f, 
    -0.06860119f, -0.26352176f, 0.06462323f, 0.12701865f, 0.14277737f, 0.09760797f, 0.23828520f, -0.26799005f, 
    0.16541995f, 0.33872533f, 0.01719842f, -0.06015974f, 0.08024263f, -0.02637096f, -0.11162038f, 0.08360882f, 
    0.07442085f, 0.05359061f, -0.09961046f, -0.05142830f, 0.21200174f, -0.16330893f, -0.12853657f, 0.16876088f, 
    -0.05958645f, -0.06147532f, -0.00770984f, 0.17561251f, 0.20706378f, 0.09565356f, 0.04149474f, 0.04640890f, 
    0.13399859f, 0.18543397f, 0.09376504f, 0.09857287f, -0.04725006f, -0.16634884f, 0.05140435f, 0.20240407f, 
    -0.11764318f, 0.48358583f, 0.26333112f, 0.09988368f, -0.22727875f, 0.11202000f, 0.25412256f, 0.01152690f, 
    0.06349038f, 0.10152999f, 0.05891189f, 0.23462786f, 0.07712711f, -0.03059606f, 0.17034444f, -0.13023011f, 
    0.04311376f, -0.09614499f, -0.00872072f, -0.28983366f, 0.01334057f, 0.10719881f, -0.08109949f, 0.16825193f, 
    0.15422343f, -0.13175687f, -0.04204974f, 0.03635055f, 0.00979378f, -0.11137985f, -0.09036244f, 0.53888690f, 
    -0.26883706f, 0.26463848f, 0.15884578f, 0.20381624f, 0.15532915f, 0.07041407f, -0.37102613f, 0.34098348f, 
    -0.09616897f, 0.03140897f, -0.08243677f, -0.07146487f, 0.22783127f, -0.21954437f, -0.44708407f, -0.25490558f, 
    -0.02664802f, 0.06058973f, 0.07705768f, 0.13939381f, -0.13116951f, -0.10331762f, 0.19859543f, -0.10377295f, 
    -0.11246037f, -0.03934330f, -0.12120995f, 0.07301675f, 0.29942107f, 0.19644813f, 0.21226676f, 0.09724271f, 
    0.22655950f, 0.18422315f, -0.07121097f, -0.29119134f, -0.20823731f, 0.11258586f, 0.17623009f, 0.01265168f, 
    -0.02153077f, -0.13118233f, -0.08750121f, 0.07833117f, 0.01947781f, 0.08670658f, 0.02304298f, -0.00018090f, 
    -0.09308611f, 0.09224869f, -0.15834270f, 0.38971964f, 0.04094633f, -0.41807044f, -0.05526158f, 0.17639145f, 
    0.06587528f, 0.27705041f, 0.10714315f, -0.10637022f, 0.13906589f, 0.10292520f, 0.03352297f, 0.05704887f, 
    0.06589159f, -0.07399689f, 0.18610950f, -0.13542566f, 0.28142050f, 0.08229628f, -0.12055250f, 0.25724912f, 
    -0.03331862f, 0.08513451f, 0.08834101f, -0.21986794f, 0.08118925f, 0.09227391f, -0.02525950f, -0.18468820f, 
    -0.26186967f, 0.01522410f, -0.05967863f, -0.19282509f, 0.11695786f, -0.05998233f, -0.06312560f, 0.03931588f, 
    -0.14349785f, -0.02775861f, -0.00228707f, -0.05879318f, -0.18201347f, -0.21490560f, -0.03451818f, -0.01799393f, 
    0.10099506f, 0.18236499f, -0.25241637f, 0.07458194f, 0.22182915f, 0.03162374f, 0.06536550f, 0.15517369f, 
    0.07950253f, 0.10935391f, -0.09081350f, 0.33509511f, -0.00437776f, 0.02994584f, 0.21946523f, -0.09737270f, 
    0.01220804f, 0.34117663f, 0.14057499f, 0.40909171f, -0.00687133f, 0.11113416f, 0.00125681f, -0.03795589f, 
    -0.03364571f, -0.10556675f, -0.01435176f, 0.05415315f, 0.13788617f, 0.01802381f, 0.32843906f, 0.01298065f, 
    0.00433125f, 0.00113324f, 0.09230593f, 0.18475755f, -0.30052277f, -0.28817371f, -0.06798340f, 0.07158023f, 
    -0.02091277f, -0.09092586f, -0.11375099f, -0.04053099f, 0.16940007f, 0.32335559f, -0.01696309f, 0.09861164f, 
    0.05284023f, -0.00462031f, 0.21755880f, -0.13436161f, -0.11838605f, -0.11896188f, 0.30961135f, 0.01207526f, 
    -0.11624908f, 0.06071389f, -0.04866147f, -0.00763447f, 0.28779647f, -0.06957552f, 0.07128949f, 0.16455448f, 
    0.12476523f, -0.04365395f, 0.17351380f, -0.06424883f, 0.06619856f, -0.10889254f, 0.36618114f, 0.04406084f, 
    -0.11795520f, -0.11536869f, 0.09373216f, 0.10857952f, 0.05755816f, -0.00815520f, 0.15756504f, -0.12399857f, 
    0.10607135f, 0.09040715f, -0.06661437f, -0.25837624f, -0.09380399f, 0.13209385f, 0.15513057f, 0.31118345f, 
    -0.12699331f, 0.14905584f, 0.01675448f, -0.08964303f, -0.04285903f, 0.09914433f, -0.06304247f, -0.11547097f, 
    0.38382435f, 0.30958256f, -0.25159213f, 0.02281190f, 0.05654209f, -0.16402568f, 0.24579914f, 0.08777607f, 
    -0.07683191f, -0.11564923f, -0.00131822f, 0.22436494f, -0.09924689f, 0.32573393f, 0.18544553f, 0.16395259f, 
    -0.04127667f, -0.02694698f, -0.12160189f, 0.03637005f, 0.06910819f, 0.04406573f, -0.15490951f, 0.03935975f, 
    0.05993892f, 0.03768747f, 0.05414521f, 0.01303611f, 0.26308286f, 0.07679474f, 0.02414950f, 0.24657801f, 
    0.05028320f, 0.02379097f, 0.08958305f, 0.17394657f, -0.09276532f, 0.09203023f, -0.09365153f, 0.06765673f, 
    0.10367198f, 0.19107130f, 0.06618346f, 0.03917341f, -0.02208522f, 0.05167078f, -0.16168781f, -0.11706655f, 
    -0.02793296f, -0.05197686f, -0.06946624f, -0.44501716f, -0.07297283f, 0.30754754f, -0.12393922f, 0.01796552f, 
    0.06117622f, 0.02613176f, 0.00707613f, 0.01233021f, -0.06062737f, -0.05305429f, -0.03087747f, 0.07341392f, 
    0.09035160f, -0.15916333f, -0.01040624f, -0.07985894f, -0.05284608f, -0.06001640f, 0.03591916f, -0.02322468f, 
    -0.08300141f, -0.01566142f, -0.04356802f, 0.02669123f, -0.10209560f, -0.08568484f, 0.05846782f, -0.08514257f, 
    0.02461751f, 0.09273437f, -0.07176182f, 0.07991797f, 0.02496290f, 0.04933108f, 0.00092558f, -0.07109353f, 
    -0.12375431f, 0.08944144f, 0.08821584f, -0.09971001f, -0.09985137f, 0.07124811f, 0.04695735f, -0.13391383f, 
    -0.02979797f, 0.03372593f, 0.00981277f, 0.03003333f, 0.07209467f, -0.05607905f, -0.03748635f, -0.01569496f, 
    -0.04746612f, -0.08955906f, -0.04291585f, -0.02550796f, 0.00373926f, 0.10258152f, -0.05044928f, 0.11288118f, 
    0.07135986f, 0.00638371f, 0.03654359f, 0.05190747f, 0.01059897f, -0.10716519f, 0.03750588f, -0.11231966f, 
    -0.15432878f, 0.04601056f, 0.08742914f, -0.12668926f, -0.09773434f, -0.04837823f, 0.04376034f, 0.05943814f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05641153f, 0.07016280f, -0.14680116f, -0.01268754f, 0.13806576f, 0.05878192f, 0.05951218f, -0.15601254f, 
    0.02900994f, -0.03203852f, -0.01655501f, 0.17513157f, 0.13127533f, 0.09096155f, 0.18769562f, 0.05830329f, 
    0.23372865f, 0.23926012f, 0.28145474f, 0.02858218f, 0.03405825f, 0.00236450f, -0.09502854f, -0.04133790f, 
    -0.09596647f, 0.20206536f, 0.08298429f, 0.07526183f, 0.15834419f, 0.13859089f, -0.02271470f, -0.09552587f, 
    0.12012644f, 0.08229277f, -0.03863344f, -0.05493218f, -0.06514540f, -0.14328879f, 0.17891431f, 0.16290107f, 
    0.26530722f, 0.10453264f, 0.16230085f, 0.07682227f, -0.14088522f, -0.02211577f, 0.03541417f, -0.01726654f, 
    -0.05627123f, -0.05204944f, 0.08647468f, 0.12545992f, 0.06947087f, 0.08579373f, 0.16417772f, -0.00075940f, 
    0.06238485f, 0.11688063f, 0.12842801f, -0.26945108f, 0.04652908f, 0.00404162f, 0.13492121f, -0.10075426f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03482334f, -0.05585925f, 0.15415129f, 0.02245094f, 0.21435937f, -0.16506059f, 0.03041457f, 0.10962699f, 
    -0.07412904f, 0.19319877f, 0.11746821f, -0.59984756f, -0.07542263f, -0.25088120f, 0.00356921f, -0.23758815f, 
    -0.32988769f, -0.49772307f, -0.10341888f, 0.20443384f, -0.41027555f, -0.16433083f, -0.14585656f, -0.03721093f, 
    0.17791657f, 0.11089367f, -0.40466976f, -0.43841735f, 0.13781478f, -0.04049339f, 0.11397211f, -0.12727007f, 
    -0.05959118f, 0.21485452f, 0.00102398f, 0.25715232f, -0.16078410f, -0.04440128f, -0.51087183f, -0.10278279f, 
    -0.48770010f, -0.53562182f, -0.06220902f, -0.18563733f, -0.10597160f, -0.21653891f, 0.20981878f, -0.00905576f, 
    0.09039847f, -0.19328608f, -0.01941613f, 0.20454521f, -0.12006353f, -0.47691551f, -0.10509992f, 0.08963200f, 
    -0.19539726f, -0.12506515f, -0.01742872f, 0.13681005f, 0.14142850f, 0.11450004f, -0.33849674f, -0.14101653f, 
    0.23848055f, 0.04914834f, -0.51108521f, -0.66472977f, 0.24026966f, -0.38415021f, 0.01736678f, -0.56589496f, 
    -0.06435822f, -0.23730583f, 0.23284282f, -0.50333571f, -0.31782156f, 0.02533502f, -0.08273923f, -0.00378133f, 
    0.08060816f, -0.04963319f, 0.25087711f, 0.19566143f, -0.00053197f, 0.03813820f, -0.20408969f, -0.05039435f, 
    -0.40946308f, -0.03995459f, 0.23676366f, -0.08885838f, 0.19792986f, -0.01508736f, 0.12508267f, 0.04548163f, 
    0.21436214f, -0.22637755f, -0.16476957f, 0.00730100f, -0.02812023f, -0.08717514f, -0.16701616f, -0.11931491f, 
    0.30375227f, -0.30937898f, -0.01975669f, -0.02331214f, 0.05423401f, -0.28071260f, -0.05241147f, 0.02497997f, 
    0.11136755f, 0.08991013f, 0.27042976f, 0.01576808f, 0.06762373f, 0.16457610f, 0.14225811f, 0.04708409f, 
    0.03844231f, 0.21753830f, -0.04781739f, -0.23914230f, 0.15681918f, 0.12321499f, 0.05741376f, 0.00313498f, 
    -0.29588372f, 0.07543119f, 0.08985405f, -0.16974561f, 0.07145476f, -0.05015169f, 0.05183217f, -0.14553480f, 
    -0.16889158f, -0.41416648f, -0.23688382f, 0.20487595f, 0.21715730f, -0.00601933f, 0.06037486f, -0.21166843f, 
    0.04184691f, 0.07692739f, 0.12958330f, 0.12052496f, -0.01934213f, -0.30325478f, -0.29690140f, 0.04710556f, 
    -0.28381550f, 0.12251913f, 0.18290444f, 0.27656284f, 0.05664714f, -0.11770602f, -0.44309795f, -0.08005974f, 
    0.04432358f, -0.43407649f, 0.26935863f, 0.31495300f, -0.20058537f, -0.01733411f, 0.25209647f, 0.04178134f, 
    -0.52663326f, 0.22762275f, 0.24300075f, 0.24443281f, 0.01146100f, -0.05656633f, 0.06558163f, 0.11593583f, 
    -0.19177973f, -0.20428826f, -0.16892761f, -0.16638976f, 0.43855211f, -0.10194556f, -0.21048127f, 0.00472525f, 
    -0.44663751f, 0.02681422f, 0.00426103f, 0.14068128f, -0.27580264f, 0.24292682f, -0.04081999f, 0.06061461f, 
    -0.23771232f, -0.36409295f, 0.21575235f, 0.25019628f, 0.06658879f, 0.16340974f, 0.21752867f, -0.02981192f, 
    -0.32354578f, 0.19218631f, -0.40709803f, -0.02750550f, 0.01683710f, -0.41878128f, -0.53392804f, -0.25983208f, 
    -0.37355071f, -0.08735233f, 0.09167084f, -0.03116538f, -0.01249708f, -0.31398937f, 0.11396191f, -0.07403149f, 
    -0.15877078f, -0.10683812f, 0.25988534f, -0.06985923f, 0.13496517f, 0.03399414f, 0.17759958f, 0.03708204f, 
    -0.02884493f, 0.14100383f, -0.19125517f, 0.02402583f, 0.03831017f, 0.07742789f, 0.00542065f, -0.54006732f, 
    -0.31549403f, 0.28378162f, -0.10649120f, -0.60745686f, -0.10962124f, -0.31782237f, 0.17611736f, 0.12543853f, 
    -0.08051428f, -0.10166260f, -0.25439668f, -0.28717589f, 0.25268358f, -0.26325113f, 0.07635675f, -0.02886443f, 
    0.09662031f, -0.28217381f, -0.01124307f, -0.06997314f, -0.20703113f, 0.21683420f, -0.01162084f, -0.04754872f, 
    0.10752626f, -0.55545038f, 0.16822182f, 0.17156097f, -0.08535450f, 0.17008443f, -0.04809696f, 0.12936470f, 
    -0.11491432f, 0.07406770f, -0.17738587f, 0.15070726f, -0.38936242f, -0.09398006f, -0.29457438f, -0.28670618f, 
    -0.10037410f, -0.10468589f, 0.14610492f, 0.08945624f, 0.02958970f, 0.19918089f, -0.20162132f, -0.12907529f, 
    0.00772012f, 0.17793667f, -0.14925086f, -0.08138884f, -0.04259484f, 0.08987797f, -0.25511533f, -0.03245712f, 
    0.19722813f, -0.12269714f, -0.08332513f, -0.19370440f, 0.22096835f, -0.05051957f, -0.44423255f, -0.31546894f, 
    -0.08789317f, 0.02174908f, 0.13543347f, 0.09427784f, -0.08313200f, 0.04715850f, 0.05883331f, 0.19145288f, 
    0.08309949f, 0.09188295f, 0.17201155f, -0.13344003f, -0.35755050f, 0.22059612f, -0.17880790f, 0.03643628f, 
    0.19369058f, 0.15250888f, 0.06774266f, -0.04810167f, 0.17199507f, 0.11342788f, -0.22621320f, -0.01470845f, 
    -0.04681512f, -0.25927606f, -0.06218810f, 0.14492582f, 0.15033160f, 0.06270106f, -0.26483852f, -0.10321440f, 
    0.20887940f, -0.02921867f, 0.06217339f, -0.21711652f, -0.22411852f, -0.18721063f, -0.00139522f, -0.15230335f, 
    0.20739974f, 0.17871144f, -0.25858501f, -0.01742300f, 0.15055946f, -0.04003039f, 0.28777534f, 0.06107865f, 
    -0.14644009f, 0.15404388f, -0.20355904f, 0.11195560f, -0.05339129f, 0.02705855f, 0.13742439f, 0.07034623f, 
    0.13328119f, 0.21119161f, -0.21937288f, -0.53267264f, -0.16429321f, -0.02900228f, 0.11206765f, -0.01221515f, 
    -0.03992436f, -0.47113624f, 0.20142874f, -0.14272025f, -0.01847393f, 0.00892118f, 0.13866121f, -0.13554126f, 
    0.20185882f, -0.04512101f, -0.02191306f, 0.09555239f, 0.17044373f, -0.03244384f, -0.13109152f, -0.05033916f, 
    -0.09070887f, 0.11130889f, 0.01604593f, -0.06693085f, 0.16048917f, -0.17096198f, -0.16548768f, 0.01644578f, 
    -0.60537004f, 0.20412016f, -0.14056896f, 0.18837820f, -0.88805503f, 0.19458680f, -0.24556056f, 0.27008933f, 
    0.15196984f, -0.64161432f, -0.14267418f, 0.21512237f, 0.01370791f, 0.04344691f, 0.23984542f, -0.19216155f, 
    0.28336778f, -0.10092774f, 0.24961090f, -0.06432686f, 0.11056269f, 0.18439770f, 0.07475945f, -0.11860726f, 
    -0.33610988f, 0.11091802f, 0.25867620f, 0.24004219f, -0.16305347f, 0.06959492f, -0.40784252f, 0.10542385f, 
    -0.73925048f, -0.31353796f, -0.00481294f, -0.01153662f, -0.09511998f, -0.14378247f, -0.03178702f, 0.25285149f, 
    0.15922689f, 0.06180482f, -0.41240191f, -0.12179660f, -0.00151500f, 0.00937421f, -0.62296903f, -0.17030950f, 
    -0.32132500f, -0.37634444f, -0.29398477f, -0.18425553f, -0.01424859f, 0.05268264f, -0.30095968f, 0.07587112f, 
    -0.10614988f, 0.23821555f, -0.05759121f, -0.06190462f, -0.26571855f, -0.23736478f, -0.05214511f, 0.10401278f, 
    -0.33718386f, -0.04701705f, 0.41499308f, 0.01198738f, -0.19996399f, 0.02049774f, -0.53497642f, -0.01297891f, 
    0.31432733f, -0.04440818f, -0.02575726f, 0.21272668f, 0.37465984f, -0.06913184f, -0.59046048f, 0.08503031f, 
    -0.07009789f, -0.18689683f, -0.43445754f, -0.08185127f, 0.07631246f, 0.12288708f, 0.16240759f, -0.01177128f, 
    0.00051424f, -0.31359187f, -0.04010680f, -0.19708751f, -0.31882825f, -0.38798067f, 0.24627876f, 0.02561583f, 
    -0.50770432f, -0.45309055f, 0.06990034f, -0.17247528f, -0.09656581f, -0.11773589f, 0.11220409f, -0.03091673f, 
    0.12051927f, -0.06271780f, -0.13542771f, -0.04580273f, -0.16477314f, 0.41853386f, 0.06639707f, -0.24256776f, 
    -0.29287687f, 0.28605759f, 0.04076045f, 0.00382018f, -0.11862520f, 0.08977250f, -0.22540051f, 0.03810732f, 
    0.24236664f, -0.16106166f, 0.00753664f, 0.09851422f, 0.10767066f, 0.16162741f, 0.12426085f, -0.02222751f, 
    -0.20168567f, -0.08545929f, -0.38518426f, -0.20210356f, -0.13590868f, -0.19712165f, -0.02471742f, -0.26162446f, 
    -0.22851165f, -0.39855444f, -0.19205958f, -0.38331395f, 0.15001021f, -0.20422639f, 0.14985175f, 0.27230939f, 
    -0.13373806f, 0.26088893f, -0.11630622f, -0.19263479f, 0.13288648f, 0.15978432f, 0.17179571f, -0.11888752f, 
    -0.04291188f, -0.32895613f, 0.01292336f, 0.22571450f, 0.07418078f, -0.53966987f, 0.12802461f, 0.00257350f, 
    -0.30792138f, 0.09444135f, 0.24086717f, 0.28277972f, -0.17542236f, -0.11893629f, 0.27133852f, -0.00000629f, 
    -0.32986626f, -0.19559959f, -0.48059040f, 0.04462220f, -0.06710533f, -0.24063492f, -0.18675023f, -0.45969102f, 
    -0.02663068f, 0.20373709f, -0.16271694f, 0.10419478f, 0.36994869f, -0.45946023f, 0.14323822f, -0.15954995f, 
    0.20977166f, 0.07139400f, -0.17306338f, -0.17532581f, -0.44367564f, -0.26141050f, 0.16409862f, 0.02766548f, 
    0.24387115f, -0.05567713f, -0.07899136f, 0.06154633f, -0.07294446f, 0.14712843f, -0.31841296f, 0.12128073f, 
    -0.43093354f, -0.06423628f, 0.29020998f, 0.13452552f, 0.20147498f, 0.02723135f, -0.04056555f, 0.28269508f, 
    -0.11870798f, -0.58376384f, 0.04936930f, 0.07100447f, -0.12658489f, -0.12741308f, -0.32117888f, -0.14095229f, 
    -0.34558812f, 0.14542785f, -0.46717459f, -0.09152819f, -0.21980067f, 0.27764681f, -0.48704839f, -0.00305509f, 
    0.02254138f, -0.15521912f, -0.30323267f, 0.15841763f, -0.05047845f, -0.03333963f, 0.05089651f, 0.28197181f, 
    0.08516257f, -0.16538711f, -0.11303609f, -0.58572012f, -0.01363275f, 0.37071303f, 0.04759955f, 0.17568451f, 
    -0.33987817f, -0.06110010f, -0.09665179f, -0.03843849f, -0.39868826f, 0.04496995f, -0.22304194f, -0.08861350f, 
    -0.30401734f, -0.14071852f, 0.21411034f, -0.58423299f, -0.05312757f, -0.01817976f, 0.15168743f, 0.05795937f, 
    -0.00214768f, -0.04126194f, -0.33725619f, -0.04268657f, -0.35860944f, -0.22899473f, 0.21507668f, -0.26058149f, 
    0.40777484f, 0.11998415f, 0.10916346f, -0.07644811f, -0.25153747f, 0.03203505f, 0.29726070f, 0.01077805f, 
    0.10842973f, 0.04278114f, 0.27756029f, 0.06653001f, -0.17831281f, -0.35388607f, 0.45869261f, -0.04100747f, 
    0.00975831f, -0.12995593f, 0.45580456f, -0.35628021f, 0.21970651f, 0.18540071f, 0.19858976f, 0.07091846f, 
    -0.18315017f, 0.09586318f, 0.28388900f, -0.03883285f, -0.29528174f, 0.10662856f, 0.09815080f, -0.15239292f, 
    -0.40164331f, 0.05586186f, 0.04292497f, -0.38911018f, -0.05655148f, -0.35770479f, -0.55297595f, 0.17759721f, 
    -0.15919551f, -0.49477738f, -0.55368435f, -0.01450868f, 0.02438242f, 0.36471844f, -0.03817274f, 0.08019334f, 
    -0.00439071f, 0.10417172f, -0.88841248f, -0.04695627f, 0.26029161f, -0.08311463f, -0.25285578f, 0.05577300f, 
    -0.14686218f, 0.33574936f, 0.06963179f, 0.02479848f, 0.00456205f, 0.15583777f, 0.35145187f, -0.12556753f, 
    -0.36724171f, -0.09093849f, 0.12225515f, -0.03374978f, -0.26743481f, -0.06711558f, 0.20615271f, -0.01543749f, 
    0.24684685f, 0.12557298f, -0.12322233f, -0.64456820f, 0.14997497f, -0.18701640f, -0.44021654f, -0.14846683f, 
    0.05903124f, -0.25117913f, -0.08759278f, -0.02279705f, -0.35360003f, -0.10258786f, 0.06165019f, -0.10899820f, 
    0.12974693f, -0.01191696f, 0.08553948f, 0.06478779f, -0.25312039f, 0.00468879f, -0.21811761f, -0.16318429f, 
    -0.11211236f, 0.38110405f, -0.48290884f, -0.23271866f, 0.02292291f, -0.38012412f, -0.11631990f, -0.06360937f, 
    0.21233207f, 0.23678720f, -0.24340142f, -0.27269825f, -0.37205976f, 0.11023831f, 0.24077696f, 0.09835090f, 
    -0.02032606f, -0.32816362f, 0.17295535f, -0.24765366f, 0.02616297f, -0.42659426f, 0.18644215f, 0.04347048f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09644233f, 0.15411690f, 0.11924489f, -0.10132313f, -0.04221350f, 0.00764173f, -0.02735207f, -0.10286973f, 
    0.09870195f, -0.00106550f, -0.08685470f, 0.04321508f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
