#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28869823f, -0.70922816f, 0.02230670f, -0.04425407f, -0.89700621f, -0.91970640f, -0.66996115f, -0.88074249f, 
    -0.61440063f, -0.90447569f, 0.56960922f, 0.33399373f, 0.57480651f, 0.39979696f, 0.27875414f, -0.32064158f, 
    -0.23930053f, -0.25244737f, -0.21961387f, -0.36337385f, -0.15410811f, -0.27737156f, -0.00405793f, 0.10972952f, 
    -0.14386190f, 0.48136908f, -0.43712279f, -0.38306215f, -0.06267846f, 0.55864358f, -0.61003566f, -0.22667253f, 
    0.46399909f, 0.49525237f, -0.07849321f, -0.05916458f, 0.10124225f, 0.17142534f, -0.21999170f, -0.25871560f, 
    0.07796200f, -0.02432759f, 0.06966697f, -0.09286479f, -0.25160304f, -0.12657593f, -0.09543504f, -0.22946811f, 
    0.38197801f, 0.05463231f, 0.06406806f, -0.20124441f, 0.21795413f, 0.71176189f, 0.06938230f, -0.22496314f, 
    0.44561532f, -0.34018531f, -0.67214555f, -0.22394970f, 0.09660093f, 0.36673763f, -0.02222681f, -0.13859907f, 
    -0.09891751f, -0.45890665f, 0.11210333f, -0.02004553f, 0.22585016f, 0.30308944f, 0.27171585f, -0.08310770f, 
    0.13258851f, 0.22305097f, -0.30601740f, -1.22267890f, -0.02358186f, 0.49870566f, 0.71235079f, -0.12643099f, 
    -0.49515635f, -0.70591229f, 0.22789276f, 0.48713729f, 0.09843619f, -0.47499934f, -0.03477190f, -0.10045467f, 
    0.31320274f, -0.18562685f, 0.12991910f, 0.19553314f, 0.16759406f, -0.26372093f, 0.38304818f, 0.16755730f, 
    -0.20940700f, -0.20247287f, 0.18288718f, -0.10838848f, 0.41517127f, -0.77866215f, -1.00011230f, -0.83024222f, 
    -0.81399000f, -0.10781786f, -0.04585319f, 0.42470479f, 0.21713957f, 0.35065791f, 0.08218228f, -0.03690456f, 
    0.31799170f, -0.20050576f, -0.14749132f, -0.04322744f, 0.11099882f, 0.09055971f, 0.02526185f, -0.05209906f, 
    -0.19570458f, -0.36962965f, -0.19698465f, -0.31731731f, -0.23793989f, -0.37432110f, -0.18565857f, 0.15522796f, 
    0.42486650f, 0.54428524f, 0.11684521f, 0.18607478f, -0.23727189f, 0.10801156f, 0.27401024f, -0.26099482f, 
    0.70200932f, -0.13938852f, -0.18030681f, -0.17847285f, -0.19495536f, -0.07364438f, -0.22803973f, -0.32663393f, 
    0.06621794f, 0.04181250f, 0.54054207f, 0.10784160f, -0.26353297f, 0.13693553f, 0.37297425f, 1.00726390f, 
    0.50957268f, -0.20749332f, -0.79111886f, -0.49734405f, -0.19695701f, 0.36924922f, 0.10572441f, -0.05879912f, 
    -0.44671595f, -0.09092996f, 0.21074538f, -0.00742942f, -0.31087697f, 0.26164395f, 0.32982656f, 0.00601294f, 
    -0.26721007f, 0.17418322f, -0.10795400f, 0.14024371f, -0.36045042f, 0.10328926f, -0.26643473f, 0.40886253f, 
    -0.25495842f, 0.16173017f, -0.04914542f, 0.36468151f, 0.42169181f, 0.09144415f, 0.16658589f, -0.12221484f, 
    0.52657700f, 0.28829199f, 0.38069448f, -0.29919782f, -0.28882262f, 0.08129507f, -0.06925502f, 0.06106409f, 
    -0.06201920f, -0.05713262f, -0.24607189f, 0.11292311f, -0.26737827f, 0.04258003f, -0.03278805f, 0.01755211f, 
    -0.16112207f, 0.08616251f, 0.15365955f, -0.02475782f, -0.45513010f, -0.50127172f, -0.06085178f, 0.53123683f, 
    0.13387989f, -0.16123137f, -0.49905741f, -0.54765248f, 0.07886326f, 0.47160849f, 0.18134619f, 0.15502889f, 
    0.11674043f, 0.19300351f, 0.24966379f, -0.20364468f, -0.35440308f, -0.13511224f, -0.29239413f, -0.42610833f, 
    -0.44865510f, 0.21682411f, -0.15085617f, 0.36949986f, 0.50511706f, 0.29413372f, -0.10136436f, 0.00519682f, 
    -0.10120315f, 0.13071778f, -0.42368555f, -0.01372682f, 0.02981962f, 0.26671052f, 0.13957366f, 0.23201711f, 
    0.15698819f, -0.19675775f, -0.11609355f, -0.04109402f, 0.13056490f, -0.08454958f, -0.01013313f, 0.00312029f, 
    0.30362698f, -0.01603253f, -1.41618776f, -1.24510968f, -0.19766167f, 0.49127495f, 0.51642418f, 0.73077911f, 
    0.87216443f, -0.44037411f, -0.15394697f, 0.58938080f, 0.12380902f, -0.02788017f, 0.03588272f, -0.11638780f, 
    -0.51636326f, 0.02931017f, 0.17867948f, 0.14650896f, 0.10995173f, 0.26028451f, -0.11018990f, -0.23456167f, 
    -0.16108020f, 0.00854766f, -0.15997535f, -0.94893956f, -0.35040095f, 0.32389510f, 0.74333364f, 0.48848361f, 
    -0.43532804f, -0.77119488f, -0.18421502f, 0.10355845f, 0.44796640f, 0.37600982f, -0.39520633f, 0.33490628f, 
    0.01359372f, 0.41703182f, -0.40324488f, -0.12315358f, 0.11040317f, -0.23957160f, 0.25424245f, 0.00574859f, 
    0.11729001f, 0.26363879f, -0.06823029f, 0.03469091f, -1.04872859f, 0.05346221f, 0.48970631f, 0.55487937f, 
    0.20684104f, 0.26502696f, -0.52123398f, -0.00935633f, 0.39466056f, 0.18660350f, 0.03706144f, -0.40653586f, 
    -0.45031765f, 0.77746201f, -0.04395061f, -0.03974533f, -0.07237191f, -0.30419642f, -0.05503314f, -0.16743310f, 
    -0.02049781f, 0.15583315f, 0.35246876f, 0.09360611f, -0.16654888f, 0.88802856f, 0.28300092f, -0.84500015f, 
    -0.93603879f, -0.26284868f, 0.05918369f, 0.28353932f, 0.37623373f, 0.40905824f, 0.02726030f, 0.47715658f, 
    -0.21494602f, 0.01589891f, -0.22959314f, 0.16299236f, -0.09321852f, -0.17726383f, -0.23797815f, 0.09989076f, 
    0.00194520f, -0.28568053f, -0.10221884f, 0.25881952f, 0.14275536f, 0.25733700f, 0.89261585f, -0.04319914f, 
    -0.15391135f, -0.17044997f, -1.14387548f, 0.19176733f, -0.30083424f, -0.21726578f, 0.05013357f, 0.47331208f, 
    -0.33376661f, 0.37754264f, -0.64330417f, -0.25958380f, 0.35358959f, -0.02669038f, -0.21484315f, -0.41214013f, 
    -0.29841438f, -0.25633559f, -0.27666509f, -0.58274227f, -0.06675782f, -0.26459309f, -0.34295297f, 0.29958770f, 
    0.08056504f, -0.33718660f, -0.68010163f, -0.90619457f, -0.08545376f, -0.02883381f, -0.36739218f, -0.02858992f, 
    0.32147598f, -0.11568568f, 0.29633075f, -0.03978720f, 0.17416872f, 0.29115930f, -0.04719402f, 0.51660824f, 
    0.33216509f, -0.00577453f, -0.24404240f, -0.13938199f, 0.09692772f, 0.03752211f, -0.20743598f, 0.08965290f, 
    -0.11949620f, 0.48983189f, 0.63516146f, -0.00473965f, 0.35417673f, -0.97505379f, -0.85439503f, -0.37296134f, 
    0.17496777f, 0.25146365f, -0.32808653f, -0.41593596f, -0.50577891f, -0.22532547f, 0.74809498f, 0.10667925f, 
    0.12036470f, -0.14999628f, 0.04272810f, 0.07618953f, -0.17243157f, -0.11325925f, -0.35524482f, -0.05448012f, 
    -0.03262306f, -0.93306690f, 1.02414608f, 0.55773550f, -1.25179410f, 0.05372643f, -0.41601905f, 0.24052872f, 
    -0.03049236f, 0.08320622f, 0.05669885f, 0.42245597f, 0.08895566f, -0.22633603f, -0.40091166f, -0.08259298f, 
    -0.03031485f, 0.05511908f, -0.24359062f, -0.08316629f, -0.10170373f, 0.17039424f, -0.25030434f, -0.46731895f, 
    -0.39905462f, -0.77770501f, -0.69520903f, -0.60943180f, 0.42472500f, -0.72329950f, -0.41064271f, -0.64881468f, 
    -0.83660215f, -0.82538354f, -0.52165759f, -0.14808558f, 0.07463449f, -0.39853159f, -0.35364076f, 0.32400492f, 
    -0.02144605f, 0.26561007f, 0.21042766f, -0.01293417f, 0.06916692f, -0.02489348f, 0.31874257f, 0.30679634f, 
    0.23633604f, 0.04608176f, 0.03461156f, -0.07761391f, -0.51904112f, -0.27686200f, -0.28919262f, 0.63163459f, 
    0.11748128f, 0.66397125f, 0.66824836f, 0.02049132f, -0.15187113f, -0.19991004f, -0.21206734f, 0.15286765f, 
    -0.29040441f, -0.02982139f, -0.11250947f, 0.08252081f, 0.26558280f, -0.04681190f, 0.13172808f, 0.04120049f, 
    -0.16874021f, -0.43920615f, 0.30882150f, -0.08198891f, -1.03060055f, -0.98495001f, -0.27857083f, 0.19209957f, 
    0.28953579f, 0.24869432f, 0.11501773f, 0.06162983f, -0.16511309f, -0.62184250f, -0.13362047f, 0.49323544f, 
    0.25986600f, 0.52786678f, -0.43055961f, -0.00747638f, -0.31494099f, -0.42314574f, -0.22670574f, -0.05513898f, 
    0.17238632f, 0.18859394f, 0.04634364f, -0.12325822f, 0.19627616f, 0.29857093f, -0.54919028f, -0.12111659f, 
    0.30978671f, 0.09457980f, 0.43190321f, 0.24103101f, -0.53221703f, -0.73591179f, -0.37024912f, -0.36981165f, 
    -0.22178723f, 0.12425443f, 0.04777372f, 0.57703346f, -0.18920779f, -0.38669154f, 0.19802257f, 0.44115773f, 
    0.24611950f, -0.19165698f, -0.03016549f, 0.27563471f, -0.02214240f, -0.27137294f, 0.39600375f, -0.32223281f, 
    -0.30970454f, -0.15149312f, -0.29802540f, 0.56976759f, -0.48867735f, -0.13780123f, 0.20580341f, 0.52197367f, 
    0.15139900f, 0.03989882f, -0.22623692f, -0.10773697f, 0.03926751f, -0.57169986f, 0.13984966f, 0.39478129f, 
    -0.31622288f, 0.01457111f, -0.21040769f, 0.33702132f, 0.33313051f, 0.53815818f, 0.18547051f, -0.59853739f, 
    -0.28487793f, -0.58101237f, -0.93278480f, -0.08729564f, 0.20052494f, -0.25999448f, -0.54854339f, -0.59104681f, 
    -0.30566567f, -0.37710014f, -0.35613278f, -0.14283872f, -0.10626291f, -0.18720432f, -0.05194149f, -0.30711514f, 
    -0.13184148f, -0.36053130f, -0.43402961f, -0.20378917f, -0.00765482f, 0.04584496f, -0.48743746f, -0.18048249f, 
    0.99588364f, 0.50900167f, -0.19023681f, 0.39113751f, 0.11106439f, -0.20871750f, -0.46095842f, -0.40210801f, 
    -0.60019135f, -0.78649777f, 0.15033190f, 0.38178009f, -0.09859548f, 0.00664566f, 0.09002449f, 0.00648469f, 
    0.20359398f, 0.35481867f, -0.27728134f, -0.01033129f, -0.11602053f, -0.15190583f, 0.07275344f, 0.41323423f, 
    0.06655337f, -1.03697133f, -0.80660379f, -0.09401920f, -0.59551740f, -0.62036669f, 0.00352903f, -0.30359063f, 
    0.10259574f, 0.28760129f, 0.41676289f, -0.12272663f, 0.26029176f, -0.15150060f, 0.21667254f, -0.42743191f, 
    0.02031288f, -0.38350126f, -0.27347377f, 0.36849618f, 0.11069793f, -0.18539223f, -0.06799552f, 0.12123999f, 
    -0.43857178f, -0.30059811f, -0.16668841f, -0.92590195f, -0.14620319f, 0.92354596f, 0.41729587f, 0.52035499f, 
    -1.08593166f, -0.79094052f, 0.69107711f, -0.62345749f, -0.14338385f, -0.03407731f, -0.35516170f, 0.64544636f, 
    -0.27823642f, 0.18284206f, 0.15887561f, -0.20718776f, -0.13040851f, 0.01636995f, 0.15305185f, 0.12429272f, 
    -0.30883336f, -0.49176860f, 0.10866467f, 0.76895291f, 0.21658134f, -0.46762288f, 0.21632107f, 0.06496488f, 
    0.18052034f, 0.08003714f, -0.11899843f, -0.38758510f, 0.38613734f, -0.17834698f, -0.27155802f, -0.08655312f, 
    0.09121869f, -0.01326676f, -0.06776315f, -0.22707148f, -0.10917439f, 0.10020519f, -0.07804608f, 0.24734499f, 
    -0.11722570f, -0.22308508f, 0.08016153f, 0.00180370f, -0.90820050f, -0.43807259f, -1.05638003f, -0.94527954f, 
    -0.61796767f, 0.48344031f, -0.00353286f, 0.04780509f, 0.00077827f, 0.15252508f, -0.01698876f, 0.25591877f, 
    -0.59767503f, -0.52618098f, -0.05658161f, -0.41898167f, -0.49874637f, -0.18382145f, -0.22185580f, -0.20260701f, 
    0.15033688f, -0.04543628f, 0.12541494f, 0.37254453f, 0.40734497f, 0.53473622f, 0.51287133f, -0.36889085f, 
    0.08341490f, -0.35241026f, -0.05181714f, 0.12853558f, -0.14242157f, 0.12559918f, 0.25875080f, 0.30040604f, 
    -0.34304714f, 0.02275888f, -0.34426653f, -0.30419952f, -0.12872402f, 0.25089958f, 0.24181600f, -0.23517117f, 
    -0.41544452f, -0.62693375f, -0.44422558f, -0.59700423f, -0.40868598f, -0.73321414f, 0.68536043f, 0.17739677f, 
    0.41553077f, 0.32034796f, 0.35221723f, 0.39776319f, 0.47396976f, 0.24054763f, -0.13757654f, -0.23194744f, 
    -0.13012719f, 0.06088465f, -0.03992614f, 0.14320052f, -0.11118627f, -0.19989911f, -0.05136278f, 0.05599955f, 
    -0.10334267f, 0.04385863f, 0.14587329f, 0.19910608f, 0.01614096f, -0.23085676f, -0.09157206f, 0.92169982f, 
    -0.37339279f, -0.57970172f, -0.03767055f, -0.49228951f, -0.53869325f, -0.90168893f, -0.73997360f, -0.75282604f, 
    -0.95268887f, -0.56149292f, 0.17616628f, 0.23619378f, -0.47198918f, -0.27902055f, -0.39232892f, -0.29191348f, 
    -0.10241255f, 0.05960370f, -0.32559264f, 0.11072525f, 0.10627370f, -0.04952137f, -0.28150472f, -0.06266446f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04560276f, 0.55200458f, 0.23317511f, 0.30930266f, -0.03546684f, 0.62315971f, 0.40444338f, -0.04420217f, 
    -0.12744263f, 0.10387252f, 0.23948438f, 0.30719805f, 0.35411984f, 0.43506742f, 0.03631626f, 0.32889903f, 
    0.30454469f, -0.01067023f, -0.08250259f, 0.34799027f, 0.38276312f, 0.40551889f, 0.22864565f, -0.12634443f, 
    0.19160971f, 0.36872324f, 0.36880681f, 0.60855043f, -0.07973907f, -0.07392921f, -0.20450945f, -0.02896977f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37737301f, 0.23055130f, -0.09333055f, -0.34140569f, 0.06066453f, -0.13666548f, -0.05191521f, 0.12032277f, 
    -0.04078513f, 0.02677100f, -0.00778409f, 0.03532266f, -0.42937389f, -0.02336410f, -0.35426173f, -0.39056215f, 
    -0.15056868f, 0.04961264f, -0.02074801f, -0.00343107f, -0.24803974f, -0.18458226f, -0.07106807f, -0.11903965f, 
    -0.10178673f, -0.06324338f, 0.13130297f, -0.06172489f, -0.47139889f, -0.24678379f, -0.13340347f, -0.16316284f, 
    0.00053307f, 0.04273520f, 0.01482789f, 0.03937783f, 0.14240342f, 0.12615885f, 0.31039387f, -0.41782558f, 
    -0.03000470f, 0.03316547f, -0.12719034f, 0.15797187f, 0.01059372f, -0.07676282f, -0.10911831f, -0.08386651f, 
    0.28357014f, 0.11821217f, -0.08412368f, -0.00496468f, 0.23643243f, 0.17188483f, -0.10084082f, 0.05343784f, 
    -0.09234485f, 0.06583239f, 0.02058147f, 0.15076061f, -0.67656094f, -0.06888198f, 0.11024457f, -0.18271497f, 
    0.06604834f, -0.01294108f, 0.09403880f, 0.04454261f, -0.08024580f, 0.04920374f, 0.07280950f, -0.19240233f, 
    -0.90603864f, -0.56572187f, 0.19429719f, 0.09295568f, -0.03690133f, -0.00615393f, -0.11627785f, 0.02299592f, 
    0.01059937f, -0.09290347f, -0.06658377f, 0.00954654f, -0.07494725f, 0.03684238f, -0.09943563f, 0.03926027f, 
    0.05817071f, 0.06847542f, -0.01557122f, 0.00520661f, -0.15564291f, -0.16074802f, -0.13351545f, -0.11427110f, 
    -0.00325019f, -0.07082403f, 0.30621976f, 0.08592827f, -0.04385633f, 0.12494852f, 0.01453268f, 0.05889115f, 
    0.18716432f, 0.08458079f, 0.10020653f, 0.23526056f, -0.01946434f, -0.00241282f, 0.07940838f, 0.02148003f, 
    -0.05189932f, -0.00373424f, -0.02034933f, 0.03364137f, -0.06027495f, 0.03276343f, -0.00841880f, -0.02240398f, 
    0.80435449f, 0.19358675f, -0.10485621f, -0.06965582f, 0.09149406f, 0.07751127f, 0.18085124f, -0.05361966f, 
    0.05015457f, 0.13220245f, 0.03358367f, 0.00975382f, -0.29135409f, 0.24009337f, 0.47992522f, -0.51878083f, 
    -0.31033072f, 0.07105748f, -0.02718428f, -0.04599648f, -0.02983139f, -0.00568447f, -0.07561923f, -0.15720403f, 
    -0.14048876f, -0.43746203f, 0.27362746f, -0.41284075f, 0.01961405f, -0.07568007f, 0.04637503f, 0.08202445f, 
    0.00505949f, -0.05830947f, -0.23636299f, -0.11567296f, -0.28747392f, -0.45558372f, -0.40719223f, 0.07093659f, 
    0.08223181f, -0.11007706f, -0.06097780f, -0.14484559f, -0.12281819f, -0.31815290f, -0.44575825f, -0.34140006f, 
    -0.10138729f, 0.02358208f, 0.08858524f, -0.14014690f, 0.00388265f, -0.05198340f, -0.17253242f, -0.14263499f, 
    -0.17142004f, 0.04841753f, 0.11603793f, 0.07857461f, 0.27784571f, 0.02208294f, 0.04973345f, -0.00791974f, 
    0.02215053f, 0.04989787f, -0.12378132f, -0.14212219f, -0.00397421f, -0.01828229f, 0.10346613f, 0.07590512f, 
    -0.19584118f, 0.39146978f, 0.25112689f, -0.36512724f, -0.16977367f, -0.03732390f, -0.14585117f, -0.12966692f, 
    0.03201645f, -0.07690376f, -0.00814922f, -0.02096091f, -0.26469210f, -0.00372817f, 0.01505671f, 0.10030473f, 
    -0.05862272f, 0.04939838f, -0.14694893f, -0.01392264f, 0.01317753f, 0.09305660f, 0.10765231f, 0.03149600f, 
    0.36191323f, 0.24427152f, -0.02651912f, -0.45105627f, 0.13902129f, 0.13811582f, -0.08119646f, -0.03255359f, 
    0.02939313f, -0.02439019f, 0.03937960f, 0.03136975f, -0.01401666f, -0.44501761f, -0.11338534f, 0.04666563f, 
    -0.01940678f, 0.01974184f, 0.08412954f, 0.01698486f, 0.01461445f, 0.10370254f, 0.06648105f, 0.01339801f, 
    0.37733871f, 0.29839256f, -0.10192858f, -0.29624861f, -0.02171355f, 0.02439162f, 0.16521317f, -0.16285512f, 
    -0.11810736f, -0.21417020f, -0.05198442f, -0.29656595f, 0.30453134f, 0.01487219f, -0.06641092f, -0.03264137f, 
    -0.04505906f, -0.04333321f, 0.22078449f, -0.01724147f, -0.06843073f, 0.00240314f, 0.01949640f, 0.07237466f, 
    0.05828723f, -0.02670889f, -0.06541923f, 0.01556272f, -0.29824018f, 0.00921294f, -0.13289574f, -0.05324288f, 
    -0.09149092f, -0.09851070f, -0.19609986f, -0.09942050f, 0.27566350f, 0.29838794f, -0.13171478f, -0.03290188f, 
    0.13070874f, 0.25232595f, -0.00373102f, -0.10853909f, -0.20019260f, -0.29526833f, -0.11641502f, -0.07526691f, 
    0.18209456f, -0.16255732f, -0.26364887f, -0.09319898f, -0.12935622f, -0.07702155f, -0.28120625f, 0.05644430f, 
    -0.00846884f, 0.12720218f, -0.04685027f, -0.05914441f, 0.37981656f, 0.19661543f, 0.05443755f, -0.21838005f, 
    -0.00366911f, 0.05924341f, 0.09756356f, -0.06976511f, -0.01015348f, 0.06247429f, -0.05792009f, -0.00586716f, 
    0.23858684f, 0.03046531f, -0.10071807f, -0.43610182f, -0.24055950f, -0.15777649f, -0.03602395f, 0.19014424f, 
    0.02986548f, -0.08728668f, -0.09651721f, -0.15981267f, -0.64958501f, -0.09034928f, -0.60418636f, -0.11869396f, 
    0.00937194f, 0.03213447f, 0.00103987f, -0.00848618f, -0.06370062f, 0.00885325f, 0.02628485f, -0.01428341f, 
    0.31301746f, 0.06287263f, -0.06765912f, -0.09975380f, 0.20783538f, 0.21895494f, 0.00759314f, -0.15971076f, 
    -0.06181724f, -0.03055010f, -0.05709706f, -0.00106884f, -0.22561839f, -0.11839905f, -0.07680885f, 0.11848355f, 
    0.05824460f, 0.04628673f, -0.02048414f, 0.03859250f, -0.06552615f, 0.15455836f, 0.16359189f, 0.26138300f, 
    -0.05271513f, -0.16971596f, -0.09740165f, 0.09334201f, 0.04415454f, 0.04129535f, 0.07486036f, -0.00925730f, 
    -0.06802622f, 0.07982074f, 0.04385792f, 0.06423792f, 0.28633118f, 0.16387476f, -0.20183894f, -0.11005993f, 
    0.18903899f, 0.00051320f, -0.00731085f, -0.05336280f, -0.04065230f, 0.01511552f, -0.06410877f, -0.05639159f, 
    -0.23759173f, -0.05949583f, 0.15343051f, -0.30652848f, -0.08426564f, 0.09213792f, 0.00737820f, 0.13506946f, 
    -0.02842613f, -0.13937967f, 0.08790101f, 0.08760839f, 0.05068143f, 0.44000223f, 0.23491961f, 0.14342853f, 
    0.07537204f, 0.01169286f, 0.04908819f, -0.06459635f, 0.11699783f, 0.25076571f, -0.00943862f, 0.26508257f, 
    0.05359674f, 0.08370263f, -0.07774799f, -0.11086996f, 0.06296865f, -0.06006188f, -0.03471902f, -0.11085080f, 
    -0.10065681f, -0.10410030f, 0.01388988f, 0.07135878f, -1.03566623f, 0.10247088f, 0.05886132f, -0.26594234f, 
    -0.03352372f, -0.01859536f, -0.05066309f, -0.07073060f, 0.05020374f, -0.06468619f, -0.01232991f, 0.02644067f, 
    0.19906738f, 0.03247850f, 0.01543215f, 0.02877368f, -0.14072290f, 0.16321130f, -0.14123911f, -0.38202044f, 
    0.28882259f, -0.06325124f, 0.09062923f, -0.03004836f, 0.08649959f, 0.13613401f, 0.03210765f, 0.21300802f, 
    -0.03058104f, 0.02026302f, -0.06354371f, 0.10137706f, -0.04791063f, 0.04212380f, -0.23868245f, 0.11490529f, 
    0.17045367f, -0.06205277f, 0.29441148f, -0.16175714f, -0.01294660f, -0.13342197f, -0.05822705f, -0.02446251f, 
    0.06105258f, 0.01583016f, -0.10672998f, -0.01262957f, 0.23614807f, 0.10168826f, 0.13456009f, 0.10654525f, 
    -0.09381519f, 0.02735796f, -0.04121526f, -0.04945659f, 0.09003516f, 0.06703903f, 0.01039081f, 0.15211122f, 
    -0.16342409f, -0.10668794f, 0.01385573f, -0.06997303f, 0.10155479f, 0.12283419f, -0.01492247f, -0.20031479f, 
    -0.08713948f, 0.00960885f, -0.09194749f, -0.02983296f, 0.15204212f, 0.01010347f, -0.01927501f, 0.00728395f, 
    -0.14203137f, -0.01131518f, -0.00524415f, -0.12484312f, -0.07038278f, 0.03637544f, -0.01058330f, 0.01583637f, 
    0.68204451f, -0.09039263f, -0.20966461f, -0.05471634f, -0.02851390f, 0.01541638f, 0.11848065f, 0.01613011f, 
    0.09715290f, -0.26082641f, -0.15827329f, -0.05026316f, -0.57030046f, 0.18623874f, -0.25500244f, 0.05792786f, 
    -0.03197388f, -0.12346783f, 0.04219266f, 0.09139798f, -0.06477449f, 0.02300773f, 0.00491876f, -0.01791129f, 
    -0.20561083f, -0.10692532f, -0.09588748f, 0.18741469f, -0.00808334f, -0.04142140f, 0.07040730f, 0.12157869f, 
    0.00540048f, -0.05244139f, 0.17915860f, -0.01617713f, 0.25695872f, -0.07655878f, 0.08181502f, -0.08224814f, 
    -0.06213761f, 0.04378547f, 0.09952908f, 0.00852134f, 0.19126339f, 0.16686140f, 0.04460220f, 0.07154367f, 
    0.35538244f, 0.07977979f, -0.09075060f, -0.66118634f, 0.01204601f, 0.01382029f, 0.06422874f, -0.02251509f, 
    -0.07544814f, -0.08770601f, -0.26811245f, -0.66506642f, -0.00947607f, -0.12367193f, 0.10219512f, -0.17788449f, 
    0.07261448f, -0.00316745f, -0.12217035f, -0.19470313f, 0.06529268f, 0.01405534f, -0.05278211f, 0.03272822f, 
    0.07567395f, 0.00789662f, -0.18897299f, -0.27903166f, 0.12015325f, -0.04453653f, -0.12085725f, 0.06186570f, 
    -0.01498846f, 0.01846491f, -0.02249321f, -0.03480908f, 0.02904476f, -0.45446965f, 0.18394522f, -0.14837658f, 
    0.12916261f, -0.02191178f, -0.24979965f, 0.18854560f, -0.27633822f, -0.15039194f, -0.18805635f, -0.11158329f, 
    0.13978986f, 0.21353450f, 0.22378337f, 0.16860679f, -0.04644017f, -0.15746251f, -0.19983250f, 0.21440849f, 
    -0.06827104f, -0.03799661f, 0.06975576f, -0.03505150f, 0.08778252f, -0.18649051f, 0.22514871f, 0.07921767f, 
    -0.05040821f, -0.05589359f, -0.00719834f, -0.01406995f, 0.26163790f, -0.00326437f, -0.10767884f, -0.18356302f, 
    -0.62280649f, -0.42810467f, 0.15860330f, 0.01839169f, -0.06943041f, 0.07676253f, 0.43729252f, 0.01289842f, 
    0.00339011f, 0.00045362f, 0.14279957f, 0.10600786f, 0.09765041f, -0.01998250f, 0.07379181f, -0.00251516f, 
    -0.20355427f, 0.12820444f, -0.14935008f, 0.13042356f, 0.17120205f, 0.00429932f, 0.22532809f, -0.00737297f, 
    0.14713085f, 0.17126393f, -0.01040070f, -0.14152318f, 0.16496760f, -0.02892791f, -0.01006083f, 0.12903169f, 
    -0.18207850f, 0.12104540f, 0.03668460f, -0.18961267f, 0.08522603f, 0.19677620f, 0.16451286f, 0.42733127f, 
    0.16332823f, 0.02673011f, -0.09084614f, 0.23183525f, -0.00877922f, 0.04507393f, 0.06973870f, -0.05054941f, 
    0.13852084f, 0.11029281f, -0.23445378f, -0.01420407f, -0.03432544f, -0.19155347f, -0.03663551f, -0.07508609f, 
    -0.11849169f, 0.05895974f, -0.11367466f, 0.04882593f, -0.27469078f, 0.18811652f, -0.37859744f, -0.01177013f, 
    -0.11227330f, 0.26695761f, -0.07700386f, -0.14946541f, -0.05452004f, -0.03220348f, 0.03891656f, -0.30104667f, 
    -0.38142380f, 0.08060945f, -0.61200041f, -0.27037376f, 0.37327197f, -0.26968047f, 0.07506087f, 0.19949161f, 
    0.08992417f, -0.17276114f, 0.16457337f, -0.08155721f, 0.47025272f, 0.34737110f, 0.06915634f, 0.35157216f, 
    -0.00822887f, -0.06346750f, -0.02959166f, 0.02942455f, -0.01713957f, -0.05469856f, 0.17594177f, -0.01512655f, 
    0.24187851f, 0.28665218f, 0.11467608f, -0.24598913f, 0.10629158f, 0.22077602f, 0.10987622f, 0.29191464f, 
    -0.03925959f, 0.01523181f, -0.16711962f, -0.04115899f, -0.01331130f, -0.04250041f, 0.05259680f, -0.07899002f, 
    -0.02169919f, -0.02392880f, -0.09313507f, 0.02277624f, -0.21275990f, -0.62724507f, -0.29912868f, -0.01495916f, 
    0.32209602f, 0.11156522f, 0.17980506f, 0.26702559f, -0.11455171f, -0.04687626f, -0.06074395f, -0.02765759f, 
    -0.04452676f, -0.01649101f, 0.00691049f, 0.02915151f, 0.28752103f, 0.02817416f, -0.42086205f, -0.04663118f, 
    -0.22680284f, -0.07302071f, -0.30811936f, -0.16584778f, -0.05315978f, -0.05201754f, 0.01627213f, 0.10638193f, 
    -0.38742104f, -0.64990479f, -0.12264546f, -0.34631288f, 0.01862822f, -0.09511815f, -0.07193429f, -0.38822755f, 
    -0.10061274f, 0.05326432f, 0.00599604f, -0.02304984f, 0.17893912f, 0.15418360f, -0.08740393f, 0.34785926f, 
    -0.09997483f, -0.02156111f, 0.11640326f, -0.01269834f, 0.03872982f, -0.01453605f, 0.07636727f, -0.02978328f, 
    -0.02224077f, 0.11017946f, -0.19519715f, -0.12618279f, 0.17200364f, -0.26166168f, 0.04669608f, 0.25166044f, 
    -0.06407710f, 0.00505574f, 0.04181216f, -0.02982260f, 0.16043796f, 0.15114799f, -0.52784580f, 0.23587225f, 
    -0.00630851f, 0.00740948f, -0.10106204f, 0.01569316f, 0.02067091f, 0.10246478f, -0.01988974f, 0.03639726f, 
    -0.08361489f, 0.56846565f, 0.15491410f, 0.35999003f, -0.15931801f, 0.11838047f, 0.12792504f, -0.30135092f, 
    -0.06078629f, 0.01404324f, 0.06626732f, -0.01105365f, 0.07746548f, -0.07395260f, -0.36072263f, -0.14011875f, 
    0.10819482f, 0.07459701f, 0.03391771f, 0.06075444f, 0.01353636f, -0.02122935f, -0.07019578f, 0.03884137f, 
    -0.33760989f, -0.01293027f, 0.07746257f, -0.17834540f, -0.01047782f, 0.00942360f, -0.10834289f, 0.22624309f, 
    -0.04528523f, -0.06032090f, -0.01938756f, 0.06610115f, -0.12782174f, -0.24645884f, -0.02410540f, 0.00097777f, 
    -0.01829833f, -0.01097083f, 0.00321444f, 0.08413007f, 0.09013783f, -0.14076397f, -0.15598808f, 0.03107516f, 
    -0.00035371f, -0.01830287f, -0.10186575f, 0.01585388f, -0.01366653f, 0.00631651f, -0.07701869f, -0.15083751f, 
    -0.04763035f, -0.01489265f, 0.09596010f, -0.25645256f, -0.18847585f, 0.16920446f, -0.09483819f, 0.08852614f, 
    -0.19151686f, -0.09384664f, 0.04921563f, 0.11817388f, -0.08567543f, 0.12421422f, -0.01723760f, -0.03824271f, 
    -0.03109225f, -0.22469832f, 0.21587250f, 0.18693152f, 0.02447269f, -0.00761529f, 0.00279885f, 0.13904348f, 
    0.09428435f, 0.01764292f, 0.11357636f, -0.10942852f, -0.19036010f, 0.33162940f, -0.41340548f, 0.10935535f, 
    0.20423114f, 0.01937525f, -0.03543746f, 0.06242469f, -0.03193326f, 0.04386829f, -0.00718535f, -0.05486962f, 
    -0.14894877f, -0.01691662f, -0.39658967f, 0.07451276f, 0.07007826f, 0.01553539f, 0.07461293f, 0.03224728f, 
    -0.03834622f, -0.13467899f, 0.15779112f, 0.01975438f, -0.28599855f, 0.43234569f, 0.33667549f, -0.05554004f, 
    0.00319975f, -0.01365916f, 0.07054440f, -0.14679542f, -0.20608394f, -0.07335204f, -0.19207680f, -0.03155012f, 
    -0.22113809f, 0.43064818f, 0.14210226f, 0.00447747f, -0.07455986f, 0.02224356f, -0.01657270f, -0.14190209f, 
    -0.01635739f, 0.23215631f, -0.15526086f, 0.31689194f, 0.01836034f, 0.12733123f, 0.04295506f, 0.09629579f, 
    0.03967935f, 0.26784819f, -0.00330951f, -0.23123512f, 0.09526982f, 0.04070828f, 0.03093832f, 0.07368510f, 
    -0.29964241f, -0.29001310f, 0.11632750f, 0.05845812f, 0.00997623f, 0.09697124f, -0.06468902f, -0.02853240f, 
    0.00313750f, 0.01983695f, -0.10159241f, 0.03773437f, 0.22910117f, 0.05371324f, -0.00450574f, 0.02278329f, 
    0.05463769f, -0.05857049f, -0.09408945f, -0.20060654f, 0.04841382f, 0.13133506f, -0.03622965f, 0.36624032f, 
    -0.34704340f, -0.83795476f, -0.36395314f, -0.24440162f, -0.07542849f, 0.03469959f, -0.21757753f, 0.13162190f, 
    -0.02099144f, -0.00432699f, -0.01763345f, 0.06070174f, 0.06649940f, -0.07426850f, 0.09112633f, 0.08429518f, 
    0.06986713f, -0.09615540f, 0.14741187f, 0.17315635f, 0.04754491f, 0.12273968f, 0.12489811f, -0.19296102f, 
    0.42904836f, -0.07001285f, -0.00436983f, 0.19604330f, 0.05723728f, -0.11176651f, 0.08892052f, 0.11621339f, 
    0.01384210f, -0.04932413f, -0.06978183f, -0.16826090f, -0.10351440f, 0.14699364f, 0.11352699f, -0.05128448f, 
    0.09649761f, -0.04264780f, 0.04563501f, 0.02023188f, 0.11049612f, 0.07221052f, 0.03392921f, -0.12432923f, 
    -0.17592770f, 0.13670187f, -0.03489465f, -0.05020201f, 0.13011515f, 0.06206962f, -0.04346653f, -0.00763648f, 
    -0.05030896f, -0.08790658f, 0.01267569f, 0.07182321f, -0.42501488f, -0.16099732f, 0.24686117f, 0.08325750f, 
    -0.01778516f, -0.11081408f, -0.01047303f, 0.10631038f, -0.00313848f, -0.01706275f, 0.01937321f, -0.25252205f, 
    -0.53411710f, -0.04964304f, 0.04791938f, -0.08291633f, -0.34339878f, -0.39046085f, -0.22104050f, -0.22763388f, 
    0.01202390f, -0.03441080f, 0.00891877f, 0.02500254f, 0.35352349f, 0.55608428f, 0.10962406f, 0.55301505f, 
    -0.10633335f, -0.09488161f, 0.05870086f, 0.16916160f, -0.03594463f, -0.11359801f, 0.04979094f, -0.03558289f, 
    -0.43762454f, 0.41956300f, -0.27305102f, -0.09519252f, -0.04575088f, -0.23488989f, -0.02072173f, 0.19120696f, 
    -0.05274059f, 0.06256282f, -0.03022081f, 0.06560536f, -0.20507848f, -0.01378638f, 0.11911072f, 0.04066467f, 
    0.02359866f, 0.04804824f, 0.04734934f, 0.08265014f, 0.01869220f, -0.01250725f, 0.04191943f, -0.05773984f, 
    -0.31800520f, 0.52095735f, 0.54691970f, 0.37519246f, 0.03411008f, 0.12539950f, -0.05849841f, -0.03677599f, 
    -0.13811399f, -0.08656764f, -0.19389509f, 0.00539570f, -0.03435656f, 0.02163454f, -0.00665257f, -0.09669006f, 
    0.05024799f, -0.06826536f, -0.08701558f, -0.06383597f, 0.25747940f, 0.14606263f, 0.23239490f, 0.17130223f, 
    -0.12350652f, -0.08433916f, -0.46585000f, -0.18026230f, 0.01231287f, -0.03508663f, 0.03342252f, 0.03416395f, 
    0.00851739f, -0.04573140f, 0.03096553f, -0.00402845f, -1.15997517f, -0.19767064f, -0.00160776f, -0.48784319f, 
    -0.05561613f, 0.14637709f, -0.06415293f, -0.11065202f, 0.02820793f, -0.04595172f, 0.05829858f, -0.04622309f, 
    -0.00941481f, -0.17752774f, -0.08499913f, 0.32173589f, 0.15642937f, 0.03126252f, 0.15672632f, 0.25827777f, 
    -0.04839098f, 0.09507455f, -0.04185978f, -0.20341538f, -0.18846408f, -0.03987788f, -0.07753541f, -0.09532626f, 
    -0.09834807f, -0.30080435f, 0.09636020f, -0.17645733f, -0.22250287f, 0.08010917f, -0.29262176f, -0.14579564f, 
    -0.25174570f, 0.42241350f, -0.44562691f, 0.48691103f, -0.01417917f, -0.29549617f, -0.05045735f, -0.19161573f, 
    0.02719916f, -0.15829504f, -0.04497544f, 0.23898774f, 0.29448640f, 0.43717963f, 0.03376559f, -0.45478484f, 
    -0.08007612f, -0.21306667f, 0.03582800f, -0.16320528f, -0.16866304f, 0.15558122f, -0.20192800f, 0.10324714f, 
    -0.15459839f, -0.03996771f, -0.02044726f, 0.20614699f, 0.03378939f, 0.09569670f, 0.06931101f, -0.08176699f, 
    -0.07589430f, 0.02276676f, -0.07708908f, 0.15952291f, 0.16286612f, 0.07683952f, -0.14621301f, -0.49344552f, 
    -0.05659039f, -0.06899484f, -0.05586590f, 0.22189404f, -0.14554583f, 0.07617221f, -0.06869463f, -0.04055235f, 
    0.06929415f, -0.03101039f, 0.45662174f, -0.23731743f, -0.38542742f, -0.12481875f, 0.01742102f, 0.06616108f, 
    -0.00627117f, 0.12804981f, 0.17267779f, 0.06582310f, -0.11425381f, -0.37110257f, -0.67809057f, -0.29854083f, 
    0.02217805f, -0.01547632f, 0.31432158f, -0.37739813f, -0.06649014f, 0.31122971f, -0.02356471f, 0.23568358f, 
    0.48002815f, -0.00435711f, 0.13259651f, -0.02443518f, -0.17449239f, -0.01608511f, 0.00410918f, 0.13084842f, 
    -0.04731753f, 0.13917097f, 0.16405515f, -0.01072939f, -0.12758370f, -0.32098663f, -0.19961281f, 0.09878613f, 
    -0.06002218f, -0.54632056f, -0.08168073f, 0.07188130f, -0.07010809f, -0.07013445f, -0.05699367f, -0.04187124f, 
    -0.67340308f, 0.60851502f, -0.21204104f, -0.36674106f, 0.33250478f, 0.21974562f, 0.17464367f, -0.10157376f, 
    -0.29285803f, 0.07037297f, -0.18494895f, -0.10258812f, 0.41585696f, 0.12722361f, -0.16477443f, -0.58988690f, 
    0.18824199f, 0.03456291f, 0.02492070f, -0.06774338f, 0.21751508f, -0.10875019f, -0.01591569f, -0.17236750f, 
    0.24034123f, 0.68448079f, 0.00920896f, -0.64113384f, -0.28038058f, 0.20052357f, -0.03420461f, -0.06072102f, 
    -0.05992342f, -0.34076560f, 0.11710443f, -0.08875777f, -0.08834385f, 0.26070783f, -0.25386640f, 0.37111899f, 
    0.10261295f, -0.10791638f, -0.11488054f, -0.13515471f, -0.11885397f, 0.15686302f, 0.05951525f, 0.04060921f, 
    -0.46538568f, -0.10615277f, 0.05006470f, 0.12957489f, -0.13228329f, 0.12573510f, 0.01789396f, -0.05552863f, 
    0.11988407f, -0.01282051f, 0.01432972f, -0.00142485f, 0.01615542f, -0.20174327f, -0.10651835f, 0.33965865f, 
    -0.18222512f, -0.13692941f, -0.06046198f, -0.11895674f, -0.05061689f, -0.06064383f, -0.13228080f, 0.06980518f, 
    0.19148161f, -0.38183922f, 0.05204053f, -0.08296014f, -0.18273513f, -0.00719667f, 0.10425754f, 0.09378433f, 
    0.03400115f, 0.02449014f, 0.01066983f, 0.02697115f, 0.60270321f, -0.09426507f, 0.14830112f, -0.06920432f, 
    0.03449768f, -0.21364671f, -0.09118837f, -0.03747211f, -0.06598168f, 0.10206272f, -0.15027423f, 0.18312922f, 
    0.03728303f, -0.10896568f, 0.04362215f, 0.10864991f, -0.09279147f, 0.16447462f, -0.17074896f, -0.09291624f, 
    0.12506121f, 0.10912842f, -0.08625837f, -0.06938943f, 0.42793280f, 1.27207625f, -0.12228850f, -0.27661252f, 
    0.19821651f, 0.03104614f, 0.07262256f, -0.04201344f, -0.17443874f, -0.17479922f, -0.10237363f, -0.06501517f, 
    -0.17156488f, 0.06268377f, -0.25040296f, -0.07266042f, 0.01682118f, 0.05904224f, -0.07053875f, 0.05664392f, 
    -0.19698326f, -0.02886084f, -0.06171585f, -0.03900540f, -0.50771278f, 0.07707272f, -0.08264217f, 0.37435681f, 
    0.08690776f, -0.01265642f, -0.06848186f, -0.09161235f, -0.00750898f, -0.12932596f, -0.01957417f, -0.04362530f, 
    -0.15509082f, -0.12346739f, 0.33989498f, -0.03494420f, 0.09300802f, -0.21216474f, 0.09717366f, -0.17091535f, 
    -0.13170162f, 0.22710221f, -0.08198393f, 0.02850887f, 0.10084884f, -0.27036980f, -0.14643072f, 0.22939931f, 
    -0.02977808f, -0.10422527f, -0.13709737f, -0.10138606f, 0.00620467f, 0.09066705f, 0.01469644f, 0.03189905f, 
    -0.17312458f, -0.31501782f, 0.53433388f, 0.53618217f, -0.00384292f, -0.12679777f, 0.03938983f, 0.11361795f, 
    -0.01192172f, 0.11811253f, -0.14918295f, -0.02244347f, 0.13783525f, -0.13369541f, -0.00131516f, 0.08456998f, 
    0.01734559f, -0.02189317f, -0.03389925f, -0.12132634f, -0.04723651f, -0.06050999f, 0.01749937f, 0.10193945f, 
    -0.03273982f, 0.14290912f, -0.19062680f, 0.08603037f, -0.30379942f, -0.05548989f, -0.04543240f, 0.04509284f, 
    -0.18481061f, 0.04234093f, -0.02463976f, 0.13829547f, -0.30237287f, 0.03018708f, -0.43634817f, 0.18092649f, 
    0.02362368f, -0.07302949f, -0.09001674f, -0.05835929f, -0.06086256f, -0.14665417f, 0.06466321f, -0.01000346f, 
    0.15257415f, -0.11324121f, -0.03721584f, 0.34498933f, 0.16016133f, -0.08889119f, 0.06919672f, -0.11473634f, 
    -0.04593834f, 0.03463709f, 0.09630525f, 0.15074492f, -0.28199333f, -0.02421837f, 0.01761066f, -0.01941238f, 
    -0.19100051f, 0.01761055f, -0.08669743f, 0.11998444f, 0.09597787f, 0.21197571f, -0.00234465f, -0.04369687f, 
    -0.11988530f, -0.36326307f, -0.05220506f, 0.04764458f, 0.09230147f, 0.16560069f, 0.11597110f, 0.08644664f, 
    -0.05824261f, 0.03768254f, 0.17877732f, -0.02948070f, -0.12854710f, -0.06179404f, 0.11435649f, 0.30543554f, 
    0.10377758f, 0.14286733f, 0.13499956f, 0.17942789f, -0.05556272f, -0.01713536f, -0.06561708f, -0.08763804f, 
    0.21621023f, 0.40646937f, 0.33060569f, 0.25429124f, -0.15007101f, 0.06051311f, 0.00581857f, 0.14433685f, 
    0.13114706f, 0.18726431f, 0.03920279f, 0.01714381f, -0.24772412f, -0.23256233f, -0.06892745f, -0.30506328f, 
    -0.14050509f, 0.08168302f, -0.26061326f, 0.07510280f, -0.14692619f, -0.21016556f, -0.03353034f, -0.35712674f, 
    -0.01057203f, -0.04680429f, 0.20660499f, 0.16505837f, -0.01362371f, -0.02088108f, -0.03431755f, -0.10048213f, 
    -0.07058491f, 0.00460265f, -0.06825098f, 0.00373244f, -0.15385127f, -0.61831987f, 0.04821499f, 0.12475869f, 
    -0.36047688f, 0.01747543f, 0.04523252f, -0.04463924f, 0.04032209f, -0.04190150f, 0.03660709f, -0.00914270f, 
    -0.09163858f, 0.02718080f, 0.19045240f, 0.07150918f, 0.00599848f, -0.06987990f, 0.01733052f, -0.06059228f, 
    0.02764641f, -0.08392275f, 0.03976104f, 0.13925487f, 0.18396616f, 0.00702296f, 0.03709884f, 0.07961140f, 
    0.04773140f, 0.04306364f, 0.11483749f, -0.08894273f, -0.11114904f, -0.16219380f, -0.04995821f, 0.08854604f, 
    0.24893388f, -0.06561590f, -0.36624330f, 0.05549413f, 0.11769697f, 0.07717563f, -0.11233554f, -0.03921074f, 
    0.13346000f, -0.01545074f, -0.08260300f, -0.17004764f, -0.02580274f, -0.08339013f, -0.10636542f, -0.04345689f, 
    0.11370885f, 0.02624716f, 0.05065538f, 0.10944537f, -0.01913076f, -0.12273965f, -0.19311176f, -0.00428249f, 
    -0.08576505f, 0.08271495f, -0.14258395f, 0.01038272f, -0.02554029f, 0.04823400f, 0.00210503f, -0.05649634f, 
    -0.19557582f, -0.08405703f, -0.10553173f, 0.43399331f, 0.04944991f, -0.08489245f, 0.08056426f, 0.11356027f, 
    0.18776034f, 0.14112455f, -0.09102335f, 0.09976525f, -0.04283204f, -0.00587755f, -0.06090714f, 0.01350302f, 
    -0.05804749f, -0.32689008f, 0.14652404f, 0.20345646f, -0.36346787f, -0.08885931f, -0.08453273f, -0.13326626f, 
    -0.16030245f, 0.14983514f, -0.00335196f, 0.12845112f, -0.42089164f, 0.04131772f, -0.00203296f, 0.15284634f, 
    0.11770767f, -0.15644588f, -0.12492136f, -0.07004280f, -0.10495157f, -0.10194489f, -0.10331941f, 0.12017635f, 
    0.04509250f, -0.46746230f, -0.21177810f, 0.11985484f, -0.05494113f, -0.00217950f, 0.06913182f, -0.06433483f, 
    0.09221227f, -0.10251684f, -0.26388976f, -0.02671250f, -0.31647208f, -0.22279416f, 0.00436636f, -0.10328847f, 
    -0.05530762f, 0.05810612f, -0.12834331f, 0.13139638f, -0.32552293f, -0.27302042f, 0.04847677f, -0.08234873f, 
    0.09712158f, 0.07701811f, -0.34427717f, 0.11327685f, -0.03085962f, -0.04365392f, -0.08491061f, 0.00583826f, 
    0.01158537f, 0.07008854f, -0.08616684f, 0.20744310f, -0.07917482f, 0.08615943f, -0.00109857f, 0.16385110f, 
    -0.04611785f, -0.11074319f, -0.06114949f, -0.10314044f, -0.03895646f, 0.04503553f, 0.06681446f, -0.05469180f, 
    0.02410595f, 0.31379578f, -0.25060785f, 0.17240834f, -0.18415570f, -0.09553535f, -0.10734911f, -0.17360140f, 
    0.00121378f, -0.02928003f, 0.02663118f, 0.03776813f, 0.20455506f, 0.01721237f, -0.39618492f, 0.14176258f, 
    0.06190372f, -0.03060097f, 0.08203123f, -0.24811849f, 0.26931110f, -0.17988203f, 0.29542303f, 0.25863138f, 
    -0.02889041f, 0.16879112f, -0.00006576f, 0.18411934f, -0.19034398f, -0.01757438f, 0.11368298f, -0.22385441f, 
    0.02014996f, -0.03678558f, 0.05798883f, 0.05294853f, -0.24280669f, -0.24480718f, 0.02421483f, -0.04909832f, 
    0.01290159f, 0.06397979f, -0.10830548f, 0.11930994f, -0.01820477f, 0.07926293f, -0.15079764f, -0.05790857f, 
    0.41104978f, -0.21067354f, 0.17952938f, 0.11949255f, -0.17831755f, -0.09745222f, -0.29851234f, -0.22090106f, 
    -0.01277848f, -0.03548149f, 0.01695626f, -0.07646850f, 0.02495836f, -0.07742951f, 0.10514076f, 0.07092257f, 
    -0.14937764f, 0.03436411f, 0.08002595f, 0.09715882f, -0.08351588f, -0.00060857f, -0.08868438f, -0.00264927f, 
    0.09255028f, 0.05939686f, -0.08045039f, 0.05034162f, -0.02517959f, -0.00393578f, 0.04409285f, 0.04599701f, 
    0.00446296f, -0.26213300f, -0.26964667f, -0.05918631f, -0.10125804f, -0.03557367f, 0.13561149f, -0.03256976f, 
    -0.11011111f, -0.09281700f, -0.10931876f, -0.04348943f, 0.11674929f, -0.06242265f, 0.14156318f, 0.15166071f, 
    0.07373329f, 0.34966898f, 0.14451806f, 0.13057235f, 0.06005013f, 0.11356891f, 0.24626493f, 0.11803018f, 
    0.04110787f, -0.03282689f, -0.02064911f, -0.09004934f, -0.11616196f, 0.09438384f, 0.19350573f, 0.10827058f, 
    -0.10784516f, -0.23164590f, -0.01151335f, -0.05036398f, -0.00712433f, -0.00880932f, 0.01399725f, 0.06000665f, 
    0.33787638f, -0.31450209f, 0.47065902f, -0.23039806f, -0.09561945f, 0.02723196f, -0.51914698f, -0.11094422f, 
    -0.09124939f, 0.00459194f, -0.18035546f, 0.09022624f, -0.52627599f, -0.36147898f, -0.23334260f, -0.26343802f, 
    -0.00403276f, 0.01372869f, 0.04529384f, 0.08523984f, 0.02907060f, 0.09206243f, -0.04704954f, 0.06101457f, 
    0.01795990f, 0.12156690f, 0.11496323f, 0.23774512f, -0.14590906f, -0.23193295f, -0.07077646f, -0.22941656f, 
    -0.08289075f, -0.02647458f, -0.04212192f, -0.02479017f, 0.27896106f, -0.13170521f, -0.12474559f, 0.02648780f, 
    -0.00502725f, -0.03266871f, 0.05555812f, -0.07373909f, 0.28755775f, 0.04064307f, 0.14874600f, 0.33334807f, 
    -0.02208739f, 0.07665884f, 0.02725796f, 0.05952105f, 0.12071292f, 0.11038636f, 0.06437182f, 0.07298765f, 
    0.12030409f, 0.07691187f, 0.04057549f, 0.05298556f, 0.10307728f, 0.10535596f, 0.30723077f, -0.08256056f, 
    0.10701846f, -0.05653859f, 0.24342144f, -0.04189086f, -0.00615434f, -0.07642481f, -0.05508902f, -0.13857467f, 
    0.12648337f, 0.19869545f, 0.02881192f, -0.05648696f, 0.18293050f, 0.13217340f, -0.15746784f, -0.30108243f, 
    0.02506849f, -0.03018733f, -0.04177281f, -0.06286292f, 0.21950163f, -0.59527314f, 0.17260653f, 0.07705409f, 
    0.05930733f, 0.12061215f, -0.03248553f, -0.08017915f, 0.09813478f, -0.17239152f, 0.09357944f, 0.19133519f, 
    0.17612709f, -0.30989474f, -0.11973224f, -0.09958682f, 0.11220279f, 0.16834746f, -0.01524110f, 0.32062796f, 
    0.16628991f, 0.11018664f, 0.00490142f, -0.08764537f, 0.23202312f, -0.31508738f, 0.25575384f, 0.31311238f, 
    0.18195449f, 0.01053385f, -0.04273725f, 0.00872342f, -0.00838787f, -0.07474069f, 0.00023826f, -0.15128221f, 
    0.11472141f, -0.24313541f, -0.18849310f, -0.27532348f, 0.05382262f, -0.08258340f, -0.20287994f, 0.24823689f, 
    -0.24826324f, -0.28249466f, -0.06959912f, -0.13685995f, -0.09910376f, -0.27845082f, 0.23102050f, 0.08775350f, 
    -0.05742360f, -0.14780800f, 0.07046423f, -0.06160412f, 0.14803623f, -0.11874664f, 0.34656820f, -0.03902732f, 
    0.10886119f, -0.03144437f, -0.43678775f, 0.47581396f, 0.12170735f, 0.13393824f, 0.09585913f, 0.00575775f, 
    0.02542105f, -0.17768903f, 0.05679952f, -0.00428351f, -0.02245465f, 0.01605371f, -0.04482082f, 0.05123062f, 
    0.12290045f, -0.08891247f, -0.02339343f, 0.09117109f, 0.15326293f, -0.27144477f, 0.21334605f, -0.03276666f, 
    0.05187526f, -0.06857291f, -0.10692459f, -0.03289716f, -0.15092257f, -0.18591823f, -0.24384719f, -0.04684428f, 
    0.04293612f, -0.24674770f, -0.14902999f, -0.58111739f, -0.15670040f, -0.16274516f, -0.04158495f, 0.04816568f, 
    0.00952844f, -0.07503442f, 0.04946177f, -0.08691844f, -0.06068584f, -0.00023422f, 0.00625438f, 0.11538023f, 
    -0.62208575f, -0.19731975f, 0.10834040f, -0.32714581f, -0.04244769f, -0.01490625f, -0.01976127f, 0.16653055f, 
    0.00377279f, -0.09779833f, -0.00296824f, 0.08374872f, 0.38453060f, -0.42287326f, 0.55903733f, 0.22528638f, 
    -0.19651251f, -0.03372733f, 0.04190921f, 0.10152742f, 0.14699945f, 0.01134188f, -0.12400839f, 0.06368777f, 
    -0.31056297f, -0.42085174f, 0.43212995f, 0.04141467f, -0.03584598f, 0.05911105f, -0.12385846f, -0.01542241f, 
    0.08597681f, 0.21259890f, -0.12561338f, -0.03619903f, 0.06131171f, -0.10349830f, -0.36151546f, -0.32562125f, 
    -0.00017601f, 0.02094363f, -0.11214016f, -0.03748609f, 0.35931036f, 0.02222070f, -0.21012826f, 0.05161995f, 
    0.16894741f, -0.34916228f, -0.10486721f, 0.19401775f, 0.00369926f, 0.05443690f, 0.00020490f, 0.10589578f, 
    0.11977525f, -0.08873016f, -0.08297341f, -0.24707870f, 0.02210726f, 0.00369682f, -0.20427956f, -0.19456686f, 
    0.13761440f, 0.01997557f, 0.00367981f, 0.33702376f, -0.04919350f, -0.10308424f, 0.24076831f, 0.02362825f, 
    -0.37887722f, -0.08884175f, 0.41787401f, 0.27395356f, 0.13839468f, -0.06897844f, -0.10221691f, 0.18742929f, 
    0.02226812f, 0.05792300f, 0.02412312f, 0.05953631f, -0.64108008f, 0.42497131f, -0.04114954f, 0.02566942f, 
    -0.07932703f, 0.09810226f, -0.06630541f, 0.03930817f, 0.07397765f, -0.14554040f, -0.35755393f, -0.33763528f, 
    0.05340654f, 0.01486433f, 0.26258945f, 0.02728566f, 0.27595472f, 0.08243635f, 0.25880280f, 0.15148091f, 
    -0.02824278f, 0.08494350f, -0.01012107f, 0.06791979f, 0.04033303f, -0.05352242f, -0.35568953f, -0.11998401f, 
    -0.17727308f, -0.01593346f, -0.10164312f, 0.06159899f, -0.26383048f, -0.27655309f, 0.04442577f, 0.10815446f, 
    0.12668963f, 0.19925418f, -0.02369937f, -0.06136393f, 0.16537587f, 0.06620087f, -0.11476066f, -0.11602702f, 
    0.25952178f, 0.14217541f, -0.00012115f, 0.04181168f, 0.03635849f, 0.11147045f, -0.27018204f, -0.15913869f, 
    0.13656567f, -0.11286356f, -0.08831923f, -0.10594361f, -0.01241517f, 0.12237482f, -0.16513968f, -0.06879538f, 
    -0.08636043f, -0.28873459f, -0.03348260f, -0.09700654f, -0.11361950f, 0.39407614f, -0.14298095f, -0.10707719f, 
    0.41249827f, -0.13975939f, 0.19400066f, 0.01791915f, -0.04180012f, 0.31604335f, 0.08306590f, -0.28860578f, 
    -0.05766805f, -0.06512757f, 0.17412794f, 0.05616910f, -0.01125679f, 0.01623108f, -0.03188754f, -0.01160156f, 
    0.12704718f, -0.06268360f, -0.29252532f, -0.33789587f, 0.27181596f, 0.24523476f, 0.04960176f, -0.04501958f, 
    0.07873386f, -0.10702217f, 0.13269728f, -0.02055043f, -0.12153313f, -0.33886969f, 0.10781302f, -0.07743432f, 
    -0.01153229f, -0.00821633f, -0.01177563f, 0.08901249f, 0.04891283f, 0.02654561f, 0.03814803f, -0.02591447f, 
    0.15020359f, -0.06395864f, 0.28828689f, 0.11952531f, -0.22566164f, 0.25082725f, 0.13762780f, -0.15702583f, 
    0.08872519f, 0.00922301f, 0.00269703f, -0.03601963f, 0.15257490f, 0.02206948f, 0.02894062f, -0.24817879f, 
    0.00386490f, 0.00215277f, -0.03121381f, 0.05094023f, 0.03306896f, 0.02616999f, -0.16945578f, 0.05199668f, 
    -0.38893834f, -0.09363877f, -0.22144377f, -0.17774244f, -0.08585108f, 0.14623861f, 0.05315376f, -0.20184399f, 
    0.20547566f, 0.02661583f, 0.11666805f, -0.01840798f, 0.29392996f, -0.07031676f, -0.19923273f, 0.00821644f, 
    0.03371020f, 0.04790861f, 0.15947713f, 0.09767693f, -0.32398954f, -0.49770820f, -0.26695988f, -0.44535789f, 
    -0.15962832f, -0.23159038f, -0.16503461f, 0.05094004f, -0.00313088f, -0.02572686f, 0.02346000f, -0.08973923f, 
    0.01422723f, 0.00520056f, -0.04543963f, -0.12746529f, 0.26036027f, 0.15127279f, 0.25043625f, 0.02124934f, 
    0.10286107f, -0.00928603f, -0.09657631f, 0.04113914f, 0.00211715f, 0.02101513f, -0.03282016f, 0.03792592f, 
    -0.71746653f, -0.71882892f, -0.17506818f, -0.56823868f, -0.18066390f, -0.26287636f, -0.33360380f, -0.34091869f, 
    -0.10493159f, -0.15436091f, -0.02333509f, 0.04636004f, -0.01160443f, 0.15242869f, -0.25779480f, -0.14865451f, 
    0.01290401f, -0.17175481f, -0.06015942f, 0.18592450f, -0.14849854f, 0.19861169f, -0.00010949f, -0.11734308f, 
    -0.19355048f, -0.21228220f, -0.04540185f, 0.12964322f, 0.13588546f, 0.27265736f, 0.19199166f, -0.31167752f, 
    0.04317243f, -0.01353381f, -0.03299879f, 0.07257947f, -0.15890916f, -0.19679362f, -0.36885169f, 0.23053068f, 
    -0.15984102f, 0.15929423f, 0.27455321f, 0.03044948f, 0.01073353f, 0.03118195f, 0.08746266f, 0.06646237f, 
    -0.18679482f, 0.32563096f, -0.13618629f, 0.13928179f, -0.16296583f, 0.11802402f, 0.07682566f, 0.13030790f, 
    0.04218394f, 0.16618443f, -0.05667027f, 0.01605590f, -0.00660727f, -0.12476655f, -0.23384829f, 0.11010000f, 
    -0.02295687f, -0.03299892f, -0.09851641f, 0.02310348f, -0.00453129f, -0.01465949f, 0.13025305f, -0.16927336f, 
    0.35696837f, -0.04649166f, -0.18861881f, -0.31492788f, -0.14294337f, 0.06933454f, 0.19000392f, -0.01141828f, 
    -0.09945060f, 0.04770213f, 0.00448961f, 0.07335752f, 0.01170439f, 0.07520077f, -0.03359399f, -0.09677194f, 
    0.06894296f, 0.03101425f, 0.02781830f, 0.09810729f, -0.17269909f, -0.06373035f, 0.00662111f, -0.07221656f, 
    0.02086400f, 0.01041435f, -0.15631187f, -0.10402127f, -0.09879881f, 0.02774043f, 0.19126922f, -0.16185732f, 
    0.02128793f, -0.01951660f, 0.00413844f, 0.28185797f, -0.24334557f, -0.11501979f, -0.01715209f, 0.13161914f, 
    0.08696358f, 0.15423024f, 0.05653265f, 0.00271994f, -0.06149725f, -0.19783585f, -0.10517822f, -0.03063866f, 
    -0.29458544f, 0.02443169f, 0.45127416f, 0.10060809f, -0.01931486f, -0.09290591f, 0.05477697f, -0.06936537f, 
    -0.08774003f, 0.10236329f, 0.08366067f, -0.04627310f, -0.35881642f, -0.63227963f, -0.03858804f, 0.43861511f, 
    -0.04826657f, 0.17754796f, -0.00588381f, 0.08738689f, -0.01985569f, -0.09608843f, 0.06756503f, 0.08455415f, 
    -0.01237214f, 0.09204422f, -0.11937325f, -0.16963284f, -0.05336553f, 0.08554534f, -0.16271299f, 0.07911219f, 
    -0.00125370f, 0.03664786f, 0.17441851f, -0.07566343f, 0.41971779f, 0.39797392f, -0.07203105f, 0.55400848f, 
    -0.05326892f, -0.04595166f, 0.00572666f, 0.23574667f, 0.02860583f, 0.05722263f, 0.23443834f, -0.35882521f, 
    0.55744296f, 0.08580518f, -0.38137832f, 0.27064118f, -0.05772392f, -0.01590449f, -0.01747074f, 0.01459558f, 
    0.22261742f, 0.05380871f, 0.25745475f, 0.16124433f, 0.44511667f, 0.17640696f, -0.28806910f, -0.12331920f, 
    0.03547248f, 0.29791608f, 0.21828280f, -0.06059021f, 0.06351084f, -0.04479344f, -0.06599819f, -0.05380138f, 
    -0.09311347f, -0.43824840f, -0.77763057f, 0.18265605f, -0.14922585f, 0.13424577f, 0.33185795f, 0.18553989f, 
    -0.05478055f, -0.07180598f, 0.14618400f, 0.04864329f, 0.22372642f, -0.27273378f, -0.03493470f, -0.07181063f, 
    -0.00237357f, 0.08562447f, 0.03021442f, -0.03084373f, 0.06477612f, 0.34333587f, 0.22465056f, -0.16428731f, 
    -1.03199029f, -0.71339184f, -0.86297286f, -0.24505976f, -0.05738085f, -0.22929516f, -0.12995587f, -0.48711544f, 
    -0.01052630f, -0.03866336f, -0.03233148f, -0.06025717f, -0.13112134f, 0.13208880f, 0.10147349f, 0.02251713f, 
    0.09628315f, -0.04832691f, 0.06805583f, 0.07660907f, -0.01213236f, 0.15098065f, 0.05606421f, 0.16015996f, 
    -0.77260929f, 0.00789285f, 0.63513970f, -0.02591721f, -0.10803173f, -0.12021891f, -0.20677690f, -0.30657133f, 
    -0.22964022f, 0.18122563f, -0.03279589f, 0.10893085f, -0.45967597f, -0.62706155f, -0.02442157f, 0.73503023f, 
    0.16840836f, 0.06448256f, 0.09500140f, -0.14803633f, -0.01731727f, -0.08080070f, 0.02930870f, 0.16532132f, 
    -0.00895189f, 0.03500618f, 0.07254230f, 0.21853723f, -0.09579307f, -0.22197863f, 0.05109696f, 0.24270712f, 
    0.03129739f, -0.03453224f, 0.00453298f, -0.19315919f, -0.79347575f, -0.94443566f, -0.53029591f, -0.21022905f, 
    -0.08565307f, 0.00276783f, -0.02528941f, -0.25808677f, -0.06729809f, -0.02318945f, -0.01104805f, 0.13470455f, 
    -0.00803086f, -0.38910308f, -0.05781389f, -0.13147230f, 0.04231396f, 0.24750233f, 0.19229686f, -0.54319942f, 
    0.05931268f, -0.08421510f, -0.08159653f, 0.03307225f, -0.26977894f, -0.19436219f, 0.43943095f, 0.34924820f, 
    -0.12358978f, 0.21377006f, -0.00546259f, -0.11235350f, -0.01271091f, 0.17689714f, 0.01189239f, 0.15954158f, 
    -0.04934027f, -0.13029477f, -0.30087563f, 0.31431013f, 0.25489771f, 0.29366764f, -0.12450635f, -0.29703057f, 
    0.11344273f, -0.00836567f, 0.15826012f, 0.08626895f, -0.00301762f, -0.09098195f, 0.07694481f, -0.06807031f, 
    0.02524734f, 0.02225388f, 0.05185120f, -0.00436202f, -0.00584581f, 0.05479263f, -0.06553658f, 0.10166349f, 
    -0.81331784f, -0.54309976f, 0.14436319f, 0.37427497f, -0.17348991f, -0.42720279f, -0.07733017f, -0.12872316f, 
    -0.04796817f, -0.02135507f, 0.06588588f, -0.03346354f, 0.04163361f, 0.02073009f, 0.06210010f, -0.06181853f, 
    -0.02201907f, -0.01366281f, 0.08143088f, 0.12921545f, 0.11854966f, 0.47912696f, 0.13688077f, 0.05497581f, 
    -0.23085694f, -0.10589287f, -0.12474574f, -0.05703301f, 0.08290157f, 0.08794424f, -0.06241326f, -0.15498713f, 
    -0.09243133f, -0.17431948f, -0.16368064f, -0.03076328f, -0.37564909f, -1.11643720f, -0.59495682f, -0.28423068f, 
    -0.01268046f, 0.02412959f, 0.04026311f, -0.49172202f, -0.01286901f, 0.07585955f, -0.03330812f, 0.13025387f, 
    -0.74282169f, -0.54445755f, -0.08563380f, 0.71999657f, 0.21934976f, -0.05094482f, 0.07808837f, 0.21486880f, 
    0.08537242f, -0.03731325f, 0.05658700f, -0.02619238f, -0.11912622f, -0.29946509f, -0.24825074f, -0.18087406f, 
    -0.01580806f, 0.01788614f, 0.05355701f, -0.19319531f, 0.00006582f, -0.01461862f, -0.12508537f, -0.22753513f, 
    -0.06678440f, 0.02572838f, 0.01786576f, -0.06159718f, -0.14612772f, -0.15814725f, 0.14723825f, 0.04501694f, 
    -0.00538148f, 0.09083102f, 0.05795002f, -0.03878642f, 0.53561085f, 0.01584337f, -0.06842482f, 0.12733145f, 
    -0.07604085f, 0.02370865f, -0.19094068f, 0.05507496f, -0.09890687f, 0.06675499f, -0.00427345f, 0.10399743f, 
    -0.88368428f, -0.67318481f, -0.15630901f, -0.11484433f, -0.16930778f, -0.20225589f, 0.22065395f, -0.01677205f, 
    -0.00154023f, 0.12075142f, 0.03134285f, -0.01259219f, 0.18869635f, -0.00592114f, 0.04049065f, -0.23233317f, 
    0.01348165f, -0.05849944f, 0.05679690f, 0.04728128f, 0.06930775f, 0.03120227f, -0.09377341f, -0.23588742f, 
    -0.03065324f, 0.26674190f, -0.15430820f, 0.21304804f, -0.00289475f, 0.13909519f, -0.00706757f, -0.11740733f, 
    0.02320860f, 0.02247363f, 0.09161118f, 0.04608913f, 0.02730510f, 0.07046354f, 0.24862689f, -0.10399675f, 
    -0.00371782f, -0.00986786f, 0.00862976f, -0.01367138f, 0.00673921f, -0.22271864f, -0.18364930f, -0.54721522f, 
    0.03340119f, 0.08681592f, -0.05617389f, 0.25187892f, 0.05003753f, 0.05399673f, 0.31462014f, -0.18998218f, 
    -0.06503015f, -0.09639023f, -0.14805505f, 0.09700593f, 0.06647073f, 0.07460649f, -0.00629703f, -0.14755163f, 
    0.00910755f, -0.02736967f, 0.06388405f, -0.02271988f, -0.02048109f, 0.08987619f, -0.01654299f, -0.06745984f, 
    0.61260176f, 0.10752172f, 0.01263468f, -0.43227676f, 0.04468531f, 0.01665511f, -0.19771445f, 0.05691876f, 
    0.10634402f, 0.09102846f, 0.02466119f, -0.14798266f, 0.37982309f, -0.46883363f, 0.02305084f, -0.01057147f, 
    0.12748277f, 0.06642238f, 0.01207358f, -0.08585712f, 0.10618772f, 0.14842314f, 0.05119002f, -0.19307446f, 
    0.40362215f, -0.01454919f, 0.03604813f, -0.32276505f, -0.09697486f, 0.00589008f, -0.03517314f, -0.01057353f, 
    0.02991343f, 0.12487846f, -0.11545216f, -0.10053866f, -0.24659468f, -0.08828197f, -0.15297796f, -0.05021708f, 
    -0.00242789f, -0.09173664f, 0.17056957f, -0.08015502f, -0.16861469f, -0.02024551f, -0.07428196f, -0.09503356f, 
    0.23456818f, -0.35472491f, 0.55938971f, 0.05588681f, -0.03558870f, 0.00161476f, -0.11919061f, 0.00079377f, 
    0.10617395f, -0.01278733f, 0.13469370f, 0.09916231f, -0.26142460f, -0.01261818f, 0.08366456f, -0.15886520f, 
    -0.27319407f, 0.10322322f, 0.08238392f, -0.12832995f, 0.02346382f, 0.11519389f, 0.10019229f, -0.05022655f, 
    -0.20222901f, 0.05241355f, -0.10278521f, -0.12036279f, -0.07745086f, 0.04451055f, -0.10328095f, -0.19653274f, 
    -0.05321295f, 0.03761166f, -0.00646184f, 0.01545385f, -0.10110193f, -0.10347620f, -0.12009633f, 0.22364314f, 
    -0.07113921f, -0.06261496f, 0.05714808f, -0.03341927f, 0.05969945f, -0.02880078f, 0.05596527f, 0.06529726f, 
    -0.49589327f, -0.55557394f, -0.49944341f, 0.50574207f, 0.02888144f, 0.17916128f, -0.04164843f, -0.00988932f, 
    0.04489736f, 0.00953632f, -0.07036553f, -0.09031925f, -0.02938519f, 0.12275407f, -0.13424718f, -0.01233875f, 
    0.00114518f, -0.01480764f, -0.00486411f, -0.14381728f, -0.06231065f, -0.05138201f, 0.01468356f, -0.15368751f, 
    0.57688159f, 0.20002003f, 0.06963237f, -0.39422771f, 0.17668988f, 0.01726715f, -0.02020611f, 0.33675823f, 
    0.02393713f, 0.06863581f, 0.03005680f, -0.00178976f, -0.20702246f, 0.01813029f, 0.28043315f, -0.73524618f, 
    -0.16445333f, -0.09011912f, -0.07384649f, 0.10526009f, -0.15467951f, -0.08534887f, -0.00313651f, -0.06477375f, 
    0.05989661f, -0.16943941f, 0.23019105f, -0.10980125f, -0.34090501f, 0.13387431f, 0.10017326f, 0.01319899f, 
    -0.03291068f, -0.02553114f, 0.03946360f, -0.14533181f, -0.38682294f, 0.10512174f, 0.43114731f, -0.09567400f, 
    -0.10349540f, -0.05196118f, 0.09819154f, -0.00454825f, -0.02333686f, -0.16913578f, -0.04841005f, -0.22496782f, 
    -0.25563809f, 0.14667737f, 0.12038976f, -0.16236673f, -0.19957073f, -0.13788331f, -0.28509584f, 0.19172232f, 
    0.04245938f, -0.06501602f, 0.08228719f, 0.00930859f, 0.30341142f, -0.84300143f, -0.24070083f, -0.46030658f, 
    0.11985868f, 0.08772340f, -0.15723340f, 0.21849532f, 0.11509708f, -0.02006976f, -0.08632331f, 0.08794668f, 
    -0.20365700f, -0.69703484f, 0.59391499f, -0.52317059f, -0.27555683f, 0.07133497f, -0.04583148f, 0.01088777f, 
    -0.24750948f, 0.07121002f, -0.03300934f, 0.09285669f, -0.01648728f, -0.05484042f, 0.08322779f, -0.15843078f, 
    0.05485191f, 0.01266386f, -0.01085140f, -0.11210601f, 0.00502097f, 0.02209758f, 0.05928642f, -0.04980168f, 
    -0.15243477f, -0.64960492f, -0.74321789f, -0.54695261f, -0.13695382f, -0.07778370f, -0.03861531f, 0.10397916f, 
    0.01701852f, 0.00777048f, -0.00777770f, 0.08490574f, 0.04275940f, 0.16004501f, 0.24814066f, -0.04630039f, 
    0.01404474f, -0.03135884f, -0.02419352f, 0.01003307f, 0.00119067f, 0.03610141f, 0.09719199f, 0.10346832f, 
    0.09025135f, 0.09781851f, 0.03538316f, -0.05063383f, -0.03280398f, -0.00029969f, 0.02941755f, -0.05203191f, 
    0.11426704f, 0.02973264f, 0.07621882f, -0.01198361f, -0.80782109f, 0.13557124f, 0.55669063f, 0.27165583f, 
    -0.03457337f, -0.22248745f, 0.13810405f, 0.13669297f, 0.02671743f, -0.08524689f, -0.08653440f, -0.21301620f, 
    0.08113944f, -0.39730501f, -0.42237815f, -0.32892743f, 0.01029312f, 0.18256453f, 0.11104725f, -0.01959506f, 
    0.11399162f, -0.02358496f, -0.05982573f, -0.01953148f, 0.41042501f, -0.08082828f, -0.12545779f, -0.14341111f, 
    0.01800508f, -0.15303555f, 0.06100545f, -0.11657025f, 0.36010820f, 0.02715975f, 0.12312765f, 0.30324927f, 
    0.10031734f, 0.14879172f, 0.05295910f, -0.05999602f, -0.11253229f, 0.00380889f, 0.09643051f, 0.06678241f, 
    -0.03224999f, 0.07116438f, 0.02111544f, 0.06182128f, 0.50808233f, 0.26865321f, -0.22985253f, -0.17847443f, 
    0.24261279f, 0.04876271f, 0.03350762f, 0.00484538f, 0.08517183f, -0.13755678f, 0.13293506f, 0.02473696f, 
    -0.13861619f, -0.56753927f, -0.28831843f, 0.02842068f, 0.19030960f, 0.19576930f, 0.17722374f, 0.11128113f, 
    -0.05486623f, -0.30044079f, -0.19379899f, -0.16981632f, 0.09178627f, 0.09098174f, -0.03932168f, -0.06043478f, 
    -0.12273721f, -0.05416047f, -0.03115759f, -0.07492001f, -0.03678040f, 0.12816869f, 0.03544588f, 0.27789071f, 
    -0.55086803f, 0.06870118f, 0.05448684f, 0.17895056f, -0.03170716f, -0.01242297f, -0.19982207f, 0.05648970f, 
    -0.20678352f, -0.14024150f, -0.02660961f, -0.18108220f, -0.09438822f, -0.12897524f, -0.12086189f, -0.19524285f, 
    -0.08118372f, 0.00465113f, -0.05875822f, -0.03178673f, -0.06332231f, -0.01867589f, 0.01765187f, -0.02544178f, 
    -0.10050884f, -0.11309128f, -0.01977695f, 0.01599364f, 0.19438595f, 0.20966676f, 0.15884577f, 0.22355205f, 
    -0.01280250f, -0.14845616f, 0.07114886f, -0.62924320f, 0.13018943f, 0.05177693f, 0.07498339f, -0.03926538f, 
    -0.03679526f, 0.03112189f, -0.01397892f, -0.02035043f, 0.21945430f, 0.02943759f, 0.01546576f, 0.06610835f, 
    -0.10809973f, -0.13501631f, -0.47656095f, -0.18790165f, -0.13602445f, -0.09830945f, 0.02977431f, 0.03115338f, 
    0.07755195f, -0.11429858f, 0.20350493f, -0.05483422f, 0.50652438f, 0.14584909f, -0.17304543f, -0.34160444f, 
    0.11913985f, -0.06097549f, -0.12467910f, -0.23259839f, 0.09478360f, 0.03547198f, 0.11457136f, 0.13582826f, 
    0.32987595f, 0.06576324f, -0.18258086f, -0.51717836f, 0.14366975f, -0.06991217f, -0.03672602f, -0.02615351f, 
    0.02546905f, 0.13020541f, 0.18717733f, 0.26680392f, -0.39467695f, -0.10402755f, 0.10208809f, -0.08224111f, 
    -0.00981963f, 0.12619124f, 0.10162058f, 0.03253414f, -0.02963707f, 0.03058777f, 0.07593738f, 0.18380617f, 
    -0.62488580f, -0.11575983f, 0.17970406f, 0.24793284f, 0.09029840f, 0.01839627f, 0.02305626f, 0.01978896f, 
    -0.08161633f, -0.06883257f, -0.09965580f, -0.33629674f, -0.45505467f, -0.41764888f, -0.02012127f, 0.18796887f, 
    0.12212463f, 0.12749299f, 0.12299327f, 0.03225959f, -0.12759389f, -0.13217455f, -0.12408108f, 0.03609681f, 
    0.20804898f, 0.07420085f, 0.36292371f, -0.00837560f, 0.29913831f, -0.04831100f, -0.09003095f, -0.09433459f, 
    -0.03978274f, -0.17186324f, 0.04713200f, -0.04584607f, -0.02097790f, 0.11327857f, 0.07724539f, 0.01251590f, 
    0.09597451f, 0.07637109f, -0.03221903f, 0.03563155f, -0.30148274f, -0.04594024f, -0.13541722f, -0.45771945f, 
    -0.10738306f, -0.52093315f, -0.10936358f, -0.10387061f, -0.00316886f, -0.04353173f, 0.13956159f, 0.07881703f, 
    -0.07720773f, 0.04517265f, -0.02747310f, 0.02140409f, 0.07692873f, -0.14838043f, -0.01132720f, -0.11065268f, 
    -0.10820048f, -0.08795095f, -0.02206059f, -0.05036100f, 0.21936265f, 0.02746522f, 0.01557017f, 0.05818193f, 
    0.05399125f, -0.73658216f, -1.00010955f, -0.24485223f, -0.18954732f, 0.04934328f, 0.16038157f, 0.03983764f, 
    0.04088814f, -0.02590946f, 0.06742762f, 0.18424150f, 0.15487120f, -0.08689624f, 0.03039695f, -0.03335041f, 
    0.06063238f, 0.10392178f, 0.00063353f, 0.04072402f, 0.05384445f, -0.04761490f, -0.05725059f, 0.09282070f, 
    -0.22838067f, -0.08586633f, -0.07325396f, 0.09215292f, 0.19559219f, -0.00450825f, 0.11646410f, 0.03597979f, 
    0.11680984f, 0.13785090f, 0.13479123f, 0.35394645f, 0.21960983f, -0.35338336f, -0.21780357f, -0.46154433f, 
    0.02132534f, -0.09677771f, -0.08995935f, -0.06055365f, 0.00637252f, 0.02757220f, -0.08635820f, 0.00764829f, 
    -0.46133724f, 0.11521799f, 0.13436013f, 0.14874859f, -0.16690421f, -0.17324328f, -0.03645123f, 0.04383121f, 
    0.21005633f, 0.03362565f, 0.05175271f, 0.03073308f, -0.02418377f, -0.33467859f, -0.19758214f, 0.17870528f, 
    0.21049958f, 0.14823955f, 0.16978666f, 0.26350704f, -0.08127312f, -0.00602302f, -0.12065358f, -0.23034164f, 
    0.72791994f, -0.00500465f, 0.21340124f, -0.19524516f, 0.09698890f, 0.01643765f, 0.28062516f, -0.22563565f, 
    0.10982990f, 0.01366252f, 0.00495085f, -0.01095889f, -0.40037864f, -0.17995115f, 0.25893831f, -0.03177985f, 
    -0.06909724f, -0.10769965f, -0.00297854f, -0.13301131f, -0.08416401f, 0.01274505f, 0.05637444f, 0.08079650f, 
    -0.39122167f, -0.70838660f, -0.60188425f, 0.29674643f, 0.13129003f, 0.24631225f, 0.29108301f, 0.16206414f, 
    0.09309644f, -0.03583553f, 0.20856468f, 0.09876655f, -0.38594609f, -0.09170295f, -0.16635111f, -0.00421942f, 
    -0.02399001f, -0.12007293f, -0.03260475f, -0.08749762f, -0.27286297f, -0.08039812f, -0.36907023f, -0.73432845f, 
    -0.31113890f, 0.03363027f, 0.04292438f, -0.05949468f, -0.14132336f, -0.00176208f, -0.02372467f, -0.02110799f, 
    -0.16384172f, -0.05824003f, 0.01628460f, 0.05684498f, -0.07797527f, -0.35241011f, -0.44155544f, -0.11906729f, 
    -0.09548464f, 0.08001688f, -0.26667494f, -0.31884602f, 0.03188122f, 0.05327499f, 0.09571332f, 0.05006549f, 
    0.18651128f, 0.32715040f, -0.07419352f, -0.09809077f, -0.23839338f, -0.06813267f, 0.14005996f, 0.24350576f, 
    -0.08190697f, 0.02609875f, 0.01777828f, -0.02637314f, -0.11177286f, -0.10069483f, 0.47358692f, 0.21018170f, 
    0.26108652f, -0.32228360f, 0.00315283f, -0.16534980f, -0.05540270f, -0.07783267f, 0.00325738f, -0.29523534f, 
    0.14091000f, -0.77106911f, 0.05538612f, -0.19141574f, 0.12591015f, 0.24541071f, -0.21729863f, 0.01974345f, 
    0.09166365f, -0.07272030f, -0.13576283f, -0.13934752f, -0.46562281f, 0.22196792f, -0.33633900f, 0.13149972f, 
    -0.02748864f, -0.21738982f, 0.01876195f, -0.07875624f, 0.10265964f, 0.08671179f, 0.01519986f, 0.04456939f, 
    0.17217739f, 0.33562493f, 0.66253173f, -0.41755006f, -0.00505560f, -0.31229779f, -0.07432228f, -0.22297551f, 
    -0.05635037f, 0.05382066f, 0.08312114f, 0.07246471f, -0.21153110f, -0.23987304f, 0.14906339f, 0.10355464f, 
    0.13775453f, 0.17210434f, 0.00978660f, -0.05359082f, 0.02903030f, 0.06173484f, -0.06870724f, -0.13862169f, 
    -0.50091392f, 0.55165356f, -0.75686538f, -0.00602223f, 0.14129749f, -0.13864627f, 0.08295079f, -0.12611012f, 
    0.08973911f, -0.01883144f, -0.01625316f, 0.10362120f, 0.08688566f, -0.27617106f, 0.16545434f, 0.10539136f, 
    -0.01841768f, 0.08549536f, -0.06792882f, -0.09328136f, 0.24686609f, 0.25645077f, 0.22388837f, -0.18965931f, 
    -0.10405513f, 0.17358688f, -0.34091935f, 0.10315011f, 0.19488125f, -0.22331472f, 0.08772441f, 0.24525739f, 
    0.12159096f, 0.17482248f, 0.08838600f, 0.34371090f, 0.15934685f, -0.21002901f, 0.09844559f, -0.00979948f, 
    0.35583511f, 0.17864344f, 0.05320742f, 0.00438912f, 0.06891111f, -0.10680111f, -0.01125470f, -0.15193990f, 
    -0.07884039f, -0.11339208f, 0.35823905f, 0.50084621f, 0.00362366f, 0.01064112f, -0.38077173f, -0.20300210f, 
    0.24956179f, 0.07244899f, 0.05793120f, 0.13018879f, 0.17127673f, -0.60426944f, 0.08438203f, 0.05455451f, 
    0.03982628f, 0.00675068f, -0.02511693f, -0.10628407f, -0.02929391f, -0.04274338f, -0.09836233f, -0.08017317f, 
    -0.15124430f, -0.21496283f, -0.24730518f, 0.43361866f, -0.08466543f, 0.20225635f, -0.02726527f, -0.16650125f, 
    -0.15538205f, -0.29966229f, 0.10268123f, -0.10988514f, 0.15582430f, 0.11171132f, 0.52414852f, -0.67862540f, 
    0.12352966f, -0.29820850f, 0.06895955f, -0.11517248f, -0.10610059f, 0.07935917f, 0.09609184f, -0.16592993f, 
    0.10352042f, -0.19173226f, 0.10147315f, -0.58820540f, 0.00111767f, -0.00079235f, 0.09563191f, 0.08372653f, 
    -0.08176949f, 0.01437477f, 0.34762597f, 0.08267837f, -0.01772408f, 0.36071390f, 0.34202665f, -0.27736360f, 
    -0.12351273f, -0.20711924f, 0.01160583f, 0.17209424f, 0.00695256f, 0.04791411f, -0.08105892f, 0.06614273f, 
    -0.07010073f, -0.36786410f, -0.64696956f, -0.02851810f, 0.12566689f, 0.06316271f, 0.05859082f, 0.00431195f, 
    -0.00863017f, -0.02201224f, -0.00621780f, 0.01242217f, -0.57572740f, 0.19062497f, 0.01908083f, -0.05023086f, 
    -0.10898985f, 0.06034850f, -0.05451474f, -0.14633849f, 0.05789118f, 0.02213906f, 0.11309216f, 0.03330276f, 
    -0.12541614f, 0.05078786f, -0.53723747f, 0.08992568f, -0.25853854f, 0.11921547f, -0.02718711f, 0.10340434f, 
    0.02877961f, 0.03367758f, 0.07189470f, -0.06437283f, 0.03264546f, -0.00947477f, 0.19275095f, 0.22967623f, 
    0.08631694f, -0.11947019f, 0.07067503f, -0.20749757f, 0.12174978f, 0.00582710f, -0.00658423f, 0.19344284f, 
    -0.55410028f, 0.11289970f, -0.23651780f, 0.19707274f, -0.02090620f, -0.11453187f, -0.37271869f, 0.11926695f, 
    -0.02933874f, -0.25804958f, -0.11364976f, -0.03089306f, 0.33662966f, -0.33729279f, 0.16534473f, -0.62258971f, 
    -0.06047355f, 0.09096976f, -0.26158369f, 0.00815872f, -0.01238196f, -0.12493781f, -0.03126710f, 0.09888455f, 
    0.28765696f, -0.17131700f, 0.30951989f, -0.42014521f, 0.12577908f, -0.14479674f, 0.11403213f, -0.05049000f, 
    -0.05835686f, -0.05975182f, -0.04194997f, 0.16161518f, -0.17265449f, 0.10333084f, 0.16933616f, -0.25417244f, 
    -0.05966681f, 0.22432432f, 0.10063232f, 0.03826758f, 0.17894343f, 0.17890590f, -0.00093549f, 0.03736218f, 
    0.26704448f, -0.36299089f, -0.22625504f, -0.04469748f, 0.18747203f, 0.15627298f, -0.06718672f, 0.28012398f, 
    -0.09018586f, -0.18694711f, -0.18440111f, -0.22182751f, -0.56566316f, 0.02648402f, 0.15681538f, -0.23937878f, 
    -0.03049427f, -0.13537000f, -0.13847136f, -0.20185009f, 0.10772730f, -0.03951730f, 0.06606010f, 0.09551527f, 
    -0.29302293f, -0.73656529f, -0.63506895f, 0.11559795f, 0.01544751f, -0.09482084f, 0.14084215f, 0.09944101f, 
    -0.04956398f, 0.12337495f, -0.28443772f, -0.10633884f, 0.09219220f, -0.45685011f, 0.08402865f, -0.23914236f, 
    0.09062107f, 0.08523493f, 0.05383370f, 0.06375000f, -0.08992094f, -0.10057835f, -0.03545919f, -0.11642357f, 
    0.23830892f, -0.17982300f, 0.27148408f, -0.67150068f, 0.02511233f, -0.31379685f, -0.13690546f, 0.03848470f, 
    -0.08089384f, 0.01270840f, -0.01424514f, -0.01102557f, 0.14380985f, 0.04340265f, 0.05233494f, 0.10477113f, 
    -0.03783243f, 0.02726201f, 0.10496156f, -0.06853068f, 0.20131716f, 0.15335643f, 0.14747338f, 0.18883443f, 
    -0.07228745f, -0.25567630f, 0.19101419f, -0.21620908f, 0.16789329f, 0.17011033f, 0.06363840f, 0.16709612f, 
    0.16705997f, 0.00835451f, -0.00153184f, -0.01537393f, 0.07719425f, 0.20473011f, -0.09834374f, -0.40660310f, 
    -0.07474159f, -0.12303879f, 0.15219900f, 0.30437604f, 0.09258974f, 0.11435615f, 0.04815497f, -0.01388933f, 
    -0.45246592f, -0.10928641f, 0.14108574f, 0.17337348f, -0.09132767f, 0.09359480f, -0.08607115f, -0.05365975f, 
    0.02891814f, 0.28170717f, -0.03209480f, -0.04868866f, -0.54949868f, 0.40099356f, -0.25173205f, -0.12979041f, 
    -0.09883188f, 0.26200634f, -0.15782306f, 0.30335861f, 0.05189054f, -0.20438690f, 0.14878814f, 0.14678031f, 
    -0.50817412f, -0.37246251f, 0.30995828f, 0.16358270f, -0.09476083f, 0.12018817f, -0.19088498f, 0.16220856f, 
    -0.07137989f, 0.00272160f, 0.06319082f, 0.00215418f, -0.14103372f, 0.15312931f, -0.04784966f, 0.00462112f, 
    -0.11825491f, 0.33424863f, -0.20945008f, 0.18378738f, -0.10349656f, 0.04661519f, -0.00403743f, -0.16538458f, 
    -0.24842812f, -0.11619770f, -0.12848049f, 0.22315900f, 0.06381451f, -0.36491051f, -0.08053582f, 0.19604141f, 
    0.11467142f, -0.12228060f, -0.21679522f, -0.45368171f, -0.22936568f, 0.17551449f, 0.18938416f, 0.37852973f, 
    -0.18460543f, -0.12281682f, 0.10851647f, -0.06667699f, 0.05047491f, 0.01908023f, 0.23991278f, 0.39931899f, 
    0.26062483f, -0.30000442f, -0.07892951f, -0.08017667f, -0.35541239f, 0.21607570f, 0.08929510f, -0.06367363f, 
    -0.12678975f, 0.06868228f, -0.21258113f, -0.02889797f, -0.46724549f, 0.15362406f, -0.03452008f, -0.10790465f, 
    0.00209883f, -0.07603699f, 0.06036831f, 0.06036235f, -0.27477372f, -0.05540435f, -0.18980224f, -0.10754822f, 
    -0.02590998f, -0.05878540f, 0.06402499f, -0.35886446f, -0.15072253f, -0.05780175f, -0.17119123f, 0.03604817f, 
    -0.14976807f, -0.00901070f, -0.27702749f, -0.22688271f, -0.36069334f, 0.02954057f, -0.10871993f, -0.44645187f, 
    0.03274566f, 0.06363564f, -0.06840030f, 0.03241498f, 0.15544665f, 0.12338798f, 0.09153252f, -0.06300432f, 
    -0.66028357f, 0.15715474f, -0.12651688f, -0.15216933f, 0.33827385f, -0.05544128f, -0.18861386f, -0.21747705f, 
    -0.22747749f, 0.02224793f, -0.18255523f, -0.14238825f, -0.61485112f, -0.17306700f, 0.19683371f, 0.01640762f, 
    -0.14941865f, 0.11055859f, 0.11738237f, -0.00098100f, 0.05732866f, 0.10803843f, 0.09226096f, 0.29326090f, 
    0.00875175f, 0.84186071f, -0.04155006f, -0.14744446f, -0.15837541f, 0.02568596f, 0.19574726f, 0.14538473f, 
    0.01873711f, 0.27260840f, -0.36459172f, 0.17597850f, 0.15826465f, 0.09367795f, -0.05246899f, 0.52062404f, 
    -0.30439028f, -0.00596801f, 0.13569728f, 0.02393113f, 0.08233825f, 0.09189449f, 0.04957367f, 0.27338716f, 
    -0.32224113f, 0.22634289f, 0.01544987f, 0.05953741f, 0.12218957f, 0.08353594f, -0.01369056f, 0.00754866f, 
    -0.25093773f, -0.27446422f, -0.34581998f, -0.32379863f, -0.36047924f, -0.14065497f, 0.08018374f, 0.28005391f, 
    0.02851362f, -0.15582921f, 0.14571886f, 0.09361430f, -0.10622861f, -0.09391449f, 0.05033420f, -0.00712076f, 
    -0.15771554f, -0.01928037f, -0.17733236f, -0.15723452f, -0.06466636f, -0.06342934f, 0.20512614f, -0.19762531f, 
    0.05595188f, 0.12250745f, -0.05633293f, -0.19167525f, 0.49954104f, -0.22985202f, 0.20437549f, 0.11153850f, 
    -0.02307201f, -0.09190248f, 0.11860032f, 0.11269646f, -0.22587122f, 0.00878072f, -0.35530522f, -0.20326117f, 
    -0.19722849f, 0.02906133f, -0.31304294f, 0.08457870f, 0.01762041f, -0.20935205f, 0.29785082f, 0.15577558f, 
    -0.04414587f, 0.04941604f, -0.01354620f, 0.25836545f, -0.26293969f, -0.05389262f, 0.11891331f, -0.09305255f, 
    -0.09040782f, 0.26475492f, -0.16592434f, -0.10526755f, -0.05324953f, 0.02097856f, -0.03174546f, 0.18462564f, 
    -0.04241434f, 0.66431612f, 0.12382192f, 0.29233825f, -0.03672663f, 0.07605668f, 0.02876370f, 0.13983417f, 
    0.03463541f, 0.05435273f, -0.00964364f, 0.14727451f, -0.35524878f, 0.40497440f, 0.02291842f, 0.20674653f, 
    -0.00581277f, -0.01803588f, -0.26380625f, -0.10938698f, 0.18681030f, 0.00458714f, 0.02988482f, -0.05319403f, 
    0.05788975f, 0.27574334f, -0.31448099f, 0.27718782f, 0.02315726f, -0.07229472f, 0.11110760f, -0.06960235f, 
    -0.14026992f, 0.21878165f, 0.14356300f, 0.25184262f, 0.13622989f, -0.33478719f, -0.40775487f, 0.14218916f, 
    0.07184183f, -0.01215922f, 0.03232134f, -0.05489643f, 0.11994373f, 0.04532216f, -0.11737040f, -0.02920646f, 
    -0.07499091f, -0.25527960f, 0.20993954f, -0.08168782f, 0.01911278f, 0.14524566f, 0.03458778f, 0.07847688f, 
    -0.07864521f, 0.16073649f, 0.14205620f, -0.08184843f, 0.10242449f, 0.28139016f, 0.18672597f, -0.29435977f, 
    0.12873597f, -0.22822191f, 0.07562032f, 0.14127910f, -0.16368653f, 0.03293130f, -0.23740765f, -0.21716446f, 
    -0.51009214f, 0.64366943f, -0.69917262f, 0.33869475f, -0.14197040f, 0.15078939f, 0.00827520f, -0.24748835f, 
    -0.16035275f, -0.01792273f, -0.21124940f, -0.22799890f, -0.09494350f, 0.38466090f, -0.18304293f, 0.17845941f, 
    -0.12368589f, 0.03233857f, 0.13474794f, -0.06562066f, 0.13725807f, 0.07971966f, -0.03072144f, 0.04585447f, 
    0.02185145f, -0.23933879f, 0.05162922f, 0.06096063f, -0.31128740f, -0.08976930f, -0.00687614f, 0.21821307f, 
    0.05373624f, -0.03337984f, 0.09962352f, -0.07102025f, -0.21125065f, 0.30574185f, -0.21913019f, 0.07073972f, 
    0.08734164f, 0.00822644f, -0.04402652f, -0.01075083f, -0.25789586f, -0.29779932f, -0.38244352f, -0.40792376f, 
    -0.32760251f, -0.32905814f, -0.36316893f, -0.39959130f, -0.34939128f, -0.36620024f, -0.01556281f, 0.11671373f, 
    -0.03924193f, 0.05361213f, 0.02600226f, 0.05064098f, -0.47800708f, -0.26985529f, -0.14594376f, 0.23232529f, 
    0.12491543f, 0.05471889f, -0.05928628f, 0.14718063f, 0.09416141f, 0.09310156f, -0.05928474f, -0.05972579f, 
    -0.49211329f, -0.44782516f, -0.23298375f, 0.12646064f, -0.09167054f, -0.28372177f, -0.03941760f, -0.36262453f, 
    -0.03593309f, -0.06390400f, -0.04759747f, 0.09398187f, 0.15528908f, -0.08704974f, 0.01761385f, 0.20329241f, 
    -0.04800221f, 0.14955106f, -0.17381626f, 0.30139157f, -0.22148697f, 0.16394465f, -0.09581355f, -0.09534093f, 
    0.09288791f, 0.47290736f, -0.24000508f, -0.02830678f, -0.16512252f, -0.05741182f, 0.11488602f, -0.01849510f, 
    -0.02731870f, -0.10544825f, -0.05635048f, 0.05628021f, 0.14656733f, -0.60686290f, 0.20464891f, 0.04082166f, 
    0.23943974f, -0.14212248f, 0.25072753f, 0.06550965f, 0.06741655f, 0.08143220f, 0.29704082f, 0.20408073f, 
    0.00487593f, 0.01328033f, -0.04840143f, -0.43192831f, -0.12663585f, -0.03361013f, 0.11879897f, 0.14359152f, 
    -0.03182968f, 0.16795111f, 0.02961143f, -0.08104845f, -0.13582605f, 0.23105162f, -0.31492686f, -0.04570574f, 
    0.00303031f, 0.09378305f, -0.06950478f, -0.04050831f, -0.09871437f, -0.07859286f, -0.04926302f, -0.20835534f, 
    0.42513287f, -0.34055832f, 0.51805347f, -0.22303769f, -0.05378734f, -0.01192623f, -0.00136121f, 0.00697559f, 
    -0.17945363f, 0.11826762f, 0.19765624f, -0.04697200f, -0.25580904f, 0.23181930f, -0.35045907f, 0.07520670f, 
    -0.15964615f, 0.05136417f, -0.01618838f, 0.01010016f, -0.11215141f, 0.20548585f, 0.06816643f, 0.08495752f, 
    0.44985077f, 0.00927958f, 0.18602520f, -0.15341495f, 0.12158466f, 0.08745198f, 0.08891502f, 0.42192701f, 
    0.13296568f, 0.18148105f, 0.10511547f, -0.01434414f, 0.40237603f, 0.23023686f, 0.01086421f, -0.24695651f, 
    0.06409077f, -0.07932279f, -0.00954085f, 0.05015730f, -0.08334610f, -0.07132721f, -0.06166990f, 0.13009420f, 
    -0.87960583f, 0.17988020f, -0.76780474f, 0.33821461f, 0.12280382f, 0.03689457f, 0.08025627f, -0.08546475f, 
    -0.12447596f, 0.10882906f, 0.20497759f, -0.00293786f, 0.00605248f, 0.40578991f, -0.44648471f, 0.06262669f, 
    -0.12339208f, -0.01800789f, -0.01922885f, -0.03742505f, -0.02109164f, -0.17396869f, 0.03345285f, -0.17928652f, 
    -0.30665189f, -0.32589155f, 0.09606134f, 0.43249783f, 0.27142140f, -0.19962908f, -0.05215731f, -0.04996935f, 
    -0.00649071f, 0.01112595f, -0.00310260f, 0.05949158f, -0.09934381f, -0.33620051f, 0.25238195f, -0.04773130f, 
    -0.01702736f, 0.14607105f, -0.10478719f, 0.19636755f, -0.39248368f, -0.05103784f, 0.09421043f, -0.02099563f, 
    -0.33958155f, 0.05481601f, -0.17177051f, 0.15198956f, 0.03115064f, -0.01757144f, 0.11098461f, -0.00721851f, 
    -0.01749086f, 0.06826220f, -0.03516213f, 0.29378426f, 0.08375002f, -0.05038278f, 0.03439190f, 0.14503832f, 
    -0.04027266f, 0.07106868f, -0.09872738f, 0.06569634f, 0.00651239f, -0.14241324f, -0.20519221f, -0.04698993f, 
    0.89439583f, 0.25129998f, 0.12934363f, -0.06634996f, 0.00395869f, -0.03092551f, 0.15666531f, 0.05275132f, 
    -0.07813293f, 0.05997182f, -0.07121262f, -0.02052815f, 0.02417733f, 0.00804365f, 0.10084622f, -0.15500994f, 
    -0.06749026f, 0.01455758f, 0.14092922f, 0.08036691f, -0.09716506f, 0.13932703f, 0.10690111f, -0.10606770f, 
    0.15508012f, -0.14100637f, 0.16458343f, -0.32537633f, -0.05130474f, -0.31242710f, 0.10640017f, -0.55426133f, 
    0.02020567f, -0.04072780f, -0.14835770f, -0.14578924f, -0.23776509f, 0.05760920f, -0.12571026f, -0.15400673f, 
    0.07901756f, 0.11599502f, 0.11372045f, 0.04004056f, -0.15515831f, 0.15479510f, 0.08683481f, 0.06220050f, 
    -0.66930187f, -0.60108924f, -0.04949865f, 0.18501496f, 0.06388146f, -0.10816476f, -0.11634102f, 0.03149068f, 
    0.11336287f, -0.18177864f, -0.05838719f, -0.12891164f, -0.16891283f, 0.37283677f, -0.16995464f, 0.00919245f, 
    -0.06351102f, 0.03453257f, 0.03480495f, -0.10027016f, -0.00120982f, 0.03152522f, -0.06134096f, -0.03469553f, 
    -0.29797748f, 0.10312780f, -0.13431002f, 0.27476898f, 0.01352232f, -0.03130005f, 0.11270249f, -0.03586329f, 
    -0.27915782f, 0.00151510f, -0.26380160f, -0.21921162f, -0.23807162f, -0.15625606f, 0.07361142f, 0.13426109f, 
    -0.24522848f, -0.07339101f, -0.11570195f, -0.27552047f, 0.02824652f, 0.09062088f, 0.03161323f, 0.00307294f, 
    0.54940289f, 0.25371468f, 0.18923992f, 0.07399466f, -0.01053015f, 0.11516266f, -0.00469894f, 0.11366095f, 
    -0.10575806f, 0.04114510f, -0.06815215f, -0.00880866f, 0.43619436f, -0.16715239f, -0.00630840f, -0.52715176f, 
    0.03747360f, -0.18617697f, -0.04354165f, -0.04289951f, 0.10031783f, 0.13228911f, 0.04343990f, 0.09359627f, 
    -0.11248875f, -0.41022795f, 0.44571567f, 0.58162236f, 0.22637014f, -0.14954521f, 0.02471034f, -0.07133494f, 
    0.11289874f, -0.03111558f, 0.18153238f, 0.11715514f, 0.17663485f, 0.09595370f, 0.00828277f, 0.06360162f, 
    -0.07214653f, 0.03703790f, 0.11174262f, 0.11970188f, -0.10428074f, -0.04074446f, 0.04596969f, -0.05674639f, 
    -0.11383164f, 0.09336117f, -0.21583469f, -0.37257442f, 0.14298689f, -0.25331220f, -0.08947524f, 0.06578966f, 
    -0.17199720f, 0.01686128f, 0.02277348f, -0.15053800f, -0.13260642f, -0.00345101f, -0.00793865f, -0.05772267f, 
    -0.05194588f, 0.02705647f, 0.05938089f, -0.03329740f, -0.00366482f, 0.08723512f, 0.21016207f, -0.00246357f, 
    0.15790595f, 0.28089949f, -0.02288485f, -0.21244949f, -0.04101557f, 0.12217300f, -0.00971631f, 0.10959819f, 
    -0.14489341f, -0.03287274f, 0.07971200f, -0.14911468f, -0.05402964f, -0.30679432f, 0.12211475f, 0.33026826f, 
    -0.36458468f, -0.27464134f, -0.00570425f, 0.05442550f, 0.01048662f, 0.12760080f, -0.06295916f, -0.02285385f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20073941f, 0.15908189f, 0.14680564f, -0.10603572f, -0.13249949f, 0.03917753f, 0.00547678f, -0.18452907f, 
    0.06782237f, 0.03065383f, 0.05413103f, -0.03623404f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
