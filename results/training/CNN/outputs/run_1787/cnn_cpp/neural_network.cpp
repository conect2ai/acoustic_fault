#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.55103683f, -0.06081973f, -0.50225401f, 0.48603091f, 0.06342828f, -0.04395879f, 0.11648700f, 0.44045374f, 
    0.85244250f, 0.84978026f, 0.33312541f, -0.07766463f, -0.30775693f, -0.45237109f, -0.02776748f, 0.00025594f, 
    -0.01154516f, -0.18388706f, -0.17148383f, 0.19509690f, -0.09942146f, 0.04835474f, 0.28805983f, -0.24149077f, 
    0.12145612f, -0.10851097f, -0.70182031f, -0.01113543f, 1.14772010f, -0.22576822f, -0.46195808f, -0.37286311f, 
    -0.22966085f, 0.17838317f, -0.35404673f, -0.11844355f, 0.16300221f, 0.08669867f, 0.39935535f, 0.01585540f, 
    0.00208900f, -0.22949661f, -0.23250066f, 0.28005496f, 0.29495576f, -0.11726854f, -0.43660495f, -0.29536730f, 
    -0.32164493f, -0.49858579f, 0.68202740f, 0.18320400f, -0.23764449f, -0.12821177f, 0.22044958f, 0.13399951f, 
    0.09227221f, 0.19426185f, 0.02216521f, -0.24390474f, -0.19788656f, -0.11242563f, -0.17440933f, -0.08864050f, 
    -0.13544250f, 0.05760283f, -0.23781428f, -0.15144499f, -0.17507216f, -0.15706994f, -0.48205161f, -0.15225707f, 
    -0.51831424f, -0.53997415f, -0.62328845f, -0.93770766f, -0.28200138f, 0.05004213f, -0.05793614f, 0.14887314f, 
    -0.22648843f, -0.57060581f, 0.01215339f, -0.03565878f, 0.20667289f, -0.01055837f, 0.02647921f, -0.08740883f, 
    0.21872361f, 0.12125698f, -0.04614041f, -0.05221349f, -0.03349509f, -0.17956589f, -0.09487141f, 0.06050355f, 
    0.60268289f, 0.39396667f, 0.07115813f, 0.08593261f, 0.96002126f, 0.56021011f, -0.94225949f, -0.77897698f, 
    -0.77513182f, -0.28085607f, 0.00763581f, 0.21611685f, 0.39626354f, 0.20451154f, -0.26641017f, 0.31434047f, 
    0.34779847f, -0.15495822f, -0.20548140f, 0.14461842f, -0.33471501f, -0.10048360f, -0.04412234f, 0.11963586f, 
    -0.06792911f, -0.22207503f, 0.02751978f, 0.34898511f, 0.33115050f, -0.89014661f, -0.40681219f, 0.10930805f, 
    -0.29065785f, 0.09287838f, -0.48585886f, -0.89081138f, -0.68787003f, -0.61619753f, -0.37669241f, 0.36201677f, 
    -0.23493406f, -0.40713966f, -0.49124667f, -0.61136341f, -0.35487366f, -0.45628294f, -0.40374616f, -0.29094884f, 
    -0.52494246f, 0.20941262f, -0.11138923f, 0.07559556f, -0.24111924f, -0.26799387f, -0.08440345f, -0.56519347f, 
    0.35437453f, -0.04685112f, 0.44861364f, -0.22329459f, 0.18454328f, 0.24601656f, 0.22327986f, -0.31230724f, 
    -0.21785377f, -0.22196800f, -0.06923743f, 0.01721268f, 0.25024506f, -0.21854694f, -0.06558987f, -0.14178176f, 
    0.18028907f, -0.11537757f, -0.01322994f, -0.49079657f, -0.46918872f, 0.33542550f, 0.42511553f, 0.68771946f, 
    0.25326112f, 0.44517663f, 0.34408295f, -0.02423142f, -0.23327397f, -0.47505665f, -0.35555926f, 0.07022288f, 
    -0.10729641f, -0.06462923f, 0.02487555f, 0.16921997f, -0.07560293f, -0.11810560f, -0.27242520f, -0.22567204f, 
    0.10518008f, 0.21251409f, 0.06663296f, -0.06227242f, -0.04259003f, -0.13078129f, -0.09974765f, -0.06220759f, 
    -0.64289176f, -0.28154355f, -0.34177694f, -0.56150723f, -0.48550889f, -0.53186107f, -0.64761484f, 0.64766848f, 
    -0.39403921f, -0.56367892f, 0.07265879f, -0.21678421f, 0.23966497f, 0.02536651f, 0.10918064f, 0.15865901f, 
    0.20682554f, 0.13387795f, 0.02612154f, 0.47616413f, 0.02822911f, 0.15934549f, 0.12994070f, -0.31108510f, 
    -0.28436208f, -0.69060737f, -0.58171141f, -0.16561259f, 0.26161063f, 0.80344838f, -0.52441669f, -0.28243774f, 
    0.49880189f, -0.13008763f, 0.50227576f, 0.23559539f, -0.02801247f, 0.05330658f, -0.00245409f, -0.20214078f, 
    0.23510537f, 0.05749007f, -0.24748519f, -0.02389699f, -0.05541515f, -0.02222922f, -0.15572280f, 0.03937943f, 
    0.09875324f, -0.37670064f, 1.63276935f, -0.96531582f, -0.81638283f, -0.30052578f, -0.40583891f, 0.73421729f, 
    0.38471085f, 0.25697610f, 0.26990360f, -0.11765588f, -0.28735864f, 0.11553028f, -0.06466062f, -0.14315166f, 
    0.09332230f, -0.17098679f, -0.01831108f, -0.01243191f, -0.07054421f, 0.08280285f, 0.21328104f, -0.09405899f, 
    -0.13937715f, 0.04478122f, 0.12065481f, 0.23472279f, -0.88669580f, -1.43126512f, 0.41148260f, 0.73708594f, 
    0.48085773f, 0.58315372f, 0.70544231f, -0.69970536f, -0.02811676f, -0.38091505f, 0.02155091f, -0.00099486f, 
    -0.50577742f, -0.20939650f, 0.23022492f, 0.03200701f, 0.16667636f, 0.04778754f, 0.12514378f, 0.19297720f, 
    -0.16841623f, -0.20216775f, -0.30511272f, -0.06961470f, 0.29384124f, 0.48038241f, -0.35812214f, -0.49542764f, 
    0.02821746f, -0.02207919f, -0.38263381f, 0.34994140f, 0.19699667f, -0.15672483f, 0.10770717f, -0.34132737f, 
    0.20174931f, -0.24947529f, -0.21282081f, 0.07771673f, 0.25863618f, 0.13047753f, 0.02785727f, -0.11255542f, 
    -0.26863223f, 0.27338785f, -0.39224768f, 0.32500815f, 0.10739605f, -0.13916621f, -0.20718579f, -0.30156672f, 
    0.32510921f, 0.13300619f, 0.61490768f, 0.45140910f, -0.43168142f, -0.54095042f, 0.54836535f, 0.17863199f, 
    -0.13458948f, -0.46738380f, -0.13326848f, 0.36229116f, -0.12562548f, -0.15844616f, -0.02493868f, 0.16589920f, 
    -0.22764367f, 0.06890315f, -0.32869866f, -0.09286159f, -0.09477634f, -0.32060215f, -0.64344817f, -0.13116188f, 
    0.17153619f, -0.05383084f, 0.15453368f, -0.01731509f, 0.49262470f, -0.01744409f, -0.27363271f, 0.03528576f, 
    0.05895764f, -0.32874307f, -0.05639716f, 0.02486685f, 0.06579301f, -0.40390608f, -0.35685489f, 0.06282612f, 
    0.36222154f, -0.02541434f, 0.01535381f, 0.05397572f, 0.29914242f, 0.03305315f, 0.29040149f, 0.62029219f, 
    -0.10735168f, -0.29677585f, -0.32399020f, -0.00270782f, 0.16462776f, 0.13442819f, 0.16615683f, 0.10651374f, 
    0.13322678f, -0.23551463f, 0.65164167f, -0.18423121f, -0.29124427f, 0.17638394f, -0.10166014f, -0.21576165f, 
    0.25698143f, -0.13602501f, -0.09546833f, 0.21503608f, 0.23438169f, -0.16232270f, -0.11853390f, 0.05492558f, 
    -0.42246395f, -1.03595638f, -0.42642522f, -0.41249076f, 0.35801581f, 0.64904398f, -0.13073286f, 0.44499764f, 
    -0.24630423f, -0.09485665f, 0.23418981f, 0.43816525f, 0.03885837f, 0.45452043f, -0.35754463f, 0.26389092f, 
    -0.15418498f, -0.20150006f, 0.09982986f, -0.50726002f, -0.38917619f, 0.17447038f, 0.32107109f, -0.08456673f, 
    -0.09308678f, 0.20251547f, 0.07022697f, 0.22256403f, 0.24682882f, 0.32579061f, -0.01205185f, -0.03085697f, 
    -0.09273300f, -0.22713883f, -0.14383447f, 0.18408814f, 0.11409876f, 0.12853065f, -0.01164855f, 0.11886264f, 
    -0.07373756f, 0.12841356f, 0.00387618f, 0.06036193f, 0.09783868f, 0.00830409f, -0.02747425f, 0.02023830f, 
    0.07603899f, 0.06078578f, 0.04123183f, 0.46850505f, 0.05556722f, 0.64621246f, -0.41669837f, -1.38517737f, 
    -0.27669457f, 0.32224831f, 0.34164888f, 0.13327080f, 0.06310212f, -0.27619073f, -0.34620038f, 0.29927659f, 
    0.24724776f, 0.15201542f, -0.08663918f, 0.01566144f, -0.10650761f, -0.76325530f, -0.11657842f, 0.06120596f, 
    -0.13365498f, 0.08647945f, -0.21469411f, -0.77066469f, -0.81630725f, -0.31033373f, -0.41796878f, -0.37988904f, 
    0.24157940f, -0.01553800f, 0.08666309f, 0.28321975f, 0.62446600f, -0.22438902f, -0.32050142f, -0.13617091f, 
    -0.14343567f, 0.18050662f, -0.02693407f, -0.05185531f, -0.11559982f, -0.08510226f, 0.17694567f, -0.48415971f, 
    -0.50881726f, -0.18884242f, -0.33111963f, -0.38550779f, -0.75540817f, -0.68197894f, 0.76068473f, 1.09376109f, 
    -0.10343222f, 1.02147532f, -0.31636357f, -0.73841166f, -0.81552660f, -0.01176156f, -0.17550853f, -0.19797941f, 
    -0.36222309f, -0.11531451f, -0.00939715f, -0.28864715f, -0.28497544f, 0.25969809f, 0.15444931f, 0.11163383f, 
    -0.14144640f, 0.24178673f, -0.13012841f, 0.02952833f, -0.12565818f, 0.37441513f, -0.74612617f, -1.12006128f, 
    -0.95650953f, -0.77246404f, 0.44067150f, 0.24998267f, 0.29496124f, -0.00079044f, -0.14808059f, -0.14907691f, 
    -0.56745154f, -0.38125324f, -0.20408595f, 0.17533992f, -0.21821730f, -0.36785144f, -0.08473169f, 0.19207533f, 
    -0.34040943f, 0.00734429f, -0.15115348f, 0.21775511f, 0.13320300f, 0.21213245f, 0.16561173f, 0.44675890f, 
    -0.40892556f, -0.85456061f, -1.03245342f, 0.40432230f, -0.24741958f, -0.14555606f, 0.09592245f, -0.23501295f, 
    0.52767754f, -0.11736298f, 0.41401204f, 0.37514997f, 0.16531825f, -0.15313481f, 0.05572643f, 0.28759894f, 
    -0.27362484f, 0.03674933f, 0.17414536f, 0.43775213f, -0.09937391f, -0.38616702f, 0.06694596f, -1.41398335f, 
    0.47556472f, -0.12529993f, -1.04335582f, -0.50735766f, 0.65553439f, 0.44161570f, 0.26807338f, -0.31843469f, 
    -0.37295651f, -0.09973366f, -0.00094348f, 0.06349121f, -0.37464163f, -0.03527779f, -0.33697069f, -0.37236506f, 
    -0.36954182f, 0.00965095f, -0.10620728f, -0.08754947f, 0.17641097f, -0.24646497f, -0.26850429f, -0.75336814f, 
    -1.04229259f, -0.42177314f, -0.98512268f, -0.89265430f, -0.91674447f, 0.54541224f, 0.15186308f, 0.26058257f, 
    0.55460101f, 0.53359276f, 0.13116938f, 0.50158572f, -0.42070469f, -0.05994976f, -0.38804618f, -0.53718698f, 
    -0.26474345f, 0.21757881f, -0.13411164f, -0.30124956f, 0.03275765f, 0.02067123f, 0.02278469f, 0.17729282f, 
    0.19398236f, -0.21147990f, -0.31727305f, -0.33139482f, -0.60292870f, -0.79542422f, 0.44026843f, -0.29497439f, 
    -0.03521817f, 0.35440782f, 0.59063846f, 0.14168464f, 0.10689753f, 0.31120330f, 0.20043737f, 0.25425655f, 
    -0.13739046f, -0.09550907f, -0.25954160f, -0.08307846f, 0.26125973f, -0.09494990f, 0.10357432f, -0.03625308f, 
    -0.02157168f, -0.33593175f, 0.57886463f, 0.60912287f, 0.53328526f, 0.05297244f, 0.08006945f, 0.19925463f, 
    0.20349526f, 0.22799501f, 0.14437787f, -0.15953118f, -0.11494016f, -0.14777347f, -0.06564947f, 0.21418157f, 
    -0.15382116f, 0.13643640f, -0.08052493f, -0.18940903f, -0.01578799f, 0.11628236f, -0.23454550f, 0.14708580f, 
    0.11374683f, -0.09718134f, -0.11778341f, -0.00615578f, -0.55507547f, 0.16962171f, 0.05441372f, -0.40249461f, 
    -0.85150558f, -0.69007808f, -0.78218347f, -0.63014305f, -0.99890876f, 0.86475819f, 0.24191958f, -0.02452733f, 
    0.26114640f, 0.36028564f, -0.17265521f, 0.02454640f, -0.25651270f, -0.20553452f, -0.58839524f, -0.16239946f, 
    0.11431006f, 0.13908492f, 0.04999892f, -0.07476662f, -0.62706870f, -0.52877283f, -0.64260435f, -0.60229480f, 
    -0.11518516f, -0.01830177f, -0.84300876f, -0.75763196f, -0.80476880f, -0.50060147f, -0.24393418f, 0.13996045f, 
    -0.00541835f, -0.00559127f, -0.37218824f, -0.12346882f, -0.37262279f, -0.34239942f, 0.36096036f, -0.01919145f, 
    -0.16738959f, 0.08834551f, -0.31289351f, 0.14619967f, 0.24751359f, -0.92920560f, -0.40165293f, 0.03211983f, 
    0.33733821f, 0.48866662f, -0.73250681f, 0.37991792f, 0.51184034f, 0.35093248f, -0.38812554f, -0.16321957f, 
    0.14253007f, 0.15108502f, 0.27324113f, -0.03313878f, -0.37451905f, -0.04393499f, 0.04114862f, -0.29348457f, 
    -0.25552493f, 0.15044908f, 0.14899121f, 0.34633222f, -0.23993935f, 0.30041772f, -0.44703215f, 0.62908727f, 
    -0.21026613f, -0.40190288f, 0.71756208f, -0.15525626f, -0.25624910f, 0.38333020f, -0.10638387f, -0.30945301f, 
    0.24782348f, -0.17004660f, 0.04594386f, -0.35757622f, 0.55137634f, 0.37332430f, -0.30673167f, -0.33641922f, 
    -0.07220605f, -0.19187723f, -0.06431133f, 0.20206982f, 0.30923209f, 0.05311698f, 0.12054458f, 0.47236088f, 
    -0.91975474f, -0.50705898f, 0.12592107f, 0.01092025f, -0.75711840f, -0.79577994f, -0.35506606f, 0.01904897f, 
    -0.66126394f, 0.11169981f, -0.22119169f, 0.53629768f, -0.00920238f, 0.42413750f, 0.13257571f, 0.12571871f, 
    -0.22417650f, -0.17230988f, -0.12537403f, -0.34075779f, 0.12758809f, 0.19547041f, -0.23922452f, 0.34717742f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25232023f, -0.12456854f, -0.00106538f, 0.01309509f, 0.49883634f, 0.06101329f, 0.49925342f, 0.20057593f, 
    -0.04134977f, 0.10728960f, 0.42672724f, -0.05734987f, 0.30928135f, 0.39091554f, 0.10036931f, 0.54291874f, 
    0.15233330f, -0.00511070f, 0.27511427f, 0.18697016f, 0.24759857f, -0.15049507f, 0.41813326f, 0.01611741f, 
    -0.00087730f, -0.14047296f, -0.16367482f, 0.10532535f, -0.53561413f, 0.48620138f, 0.14982186f, 0.08109730f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01680031f, 0.14234519f, 0.18916421f, -0.08229673f, 0.02026558f, 0.06470729f, 0.05143642f, 0.06421764f, 
    0.03716685f, 0.02446272f, 0.02776703f, -0.21241172f, 0.24076101f, 0.08202909f, 0.23029128f, -0.18470035f, 
    -0.12270209f, -0.15056698f, -0.07209747f, -0.09197945f, 0.21933290f, -0.05299455f, -0.07736521f, 0.01657014f, 
    -0.50093275f, -0.55050218f, -0.35024431f, 0.09503771f, 0.02092068f, 0.01521958f, 0.02034986f, 0.04088137f, 
    0.02114269f, 0.03904274f, -0.00572899f, 0.09996867f, 0.10422540f, 0.28073218f, 0.19180681f, -0.08667225f, 
    -0.05842815f, 0.00567141f, -0.09148172f, -0.31047043f, 0.01772057f, -0.08040984f, -0.05276523f, 0.00829313f, 
    -0.34145710f, -0.35847136f, -0.24265204f, 0.05118155f, 0.04664076f, -0.05172092f, -0.10271826f, -0.28932813f, 
    -0.16379425f, -0.45693341f, 0.13737966f, 0.02887084f, 0.36724469f, 0.29673940f, -0.02850603f, -0.13423003f, 
    0.01270378f, 0.22967939f, -0.03973541f, 0.08455794f, -0.09065983f, -0.21489784f, -0.25812399f, -0.07210632f, 
    -0.31984785f, -0.32230642f, -0.05073002f, -0.11288475f, -0.03334365f, -0.01429651f, 0.06317249f, -0.03850330f, 
    -0.07564700f, -0.05519541f, 0.16671358f, -0.10502458f, -0.38267913f, -0.08304227f, -0.12446492f, -0.11856142f, 
    0.07116770f, -0.00915375f, 0.00048933f, 0.07692098f, -0.05632105f, 0.01945892f, 0.01209541f, 0.02076888f, 
    0.49121764f, 0.19437253f, 0.13570628f, -0.27353439f, 0.09863890f, 0.17995831f, 0.04026851f, 0.17309849f, 
    0.00171360f, 0.03713290f, 0.09460320f, 0.09837363f, 0.18764032f, 0.21668148f, 0.04633607f, -0.08242477f, 
    0.01895270f, -0.00072116f, 0.01623794f, 0.04060261f, -0.22345757f, -0.11117604f, 0.01782395f, 0.13770124f, 
    -0.06329612f, -0.32158101f, -0.72199309f, 0.10784774f, 0.09706727f, -0.04049279f, -0.06602222f, -0.01521366f, 
    -0.04406798f, -0.12198183f, -0.33199206f, -0.22627325f, 0.53417528f, -0.17921747f, -0.71425265f, 0.14269640f, 
    0.04632178f, 0.06163198f, 0.17895821f, -0.09173376f, 0.03769686f, 0.10598142f, -0.05902882f, 0.18587364f, 
    -0.18210033f, -0.12629998f, -0.25981882f, -0.00311799f, -0.15379693f, 0.09271996f, -0.07339737f, -0.03483871f, 
    0.12560862f, -0.15143029f, -0.09111024f, 0.00983248f, -0.18948638f, 0.16488373f, -0.18394707f, 0.11401019f, 
    -0.09116238f, -0.03172491f, 0.03184887f, -0.04223534f, -0.11049879f, -0.07174343f, 0.14249000f, 0.10212326f, 
    0.02017962f, 0.04294506f, 0.15572183f, -0.00955625f, -0.23924722f, -0.10146773f, 0.03966742f, 0.06735002f, 
    -0.07505403f, -0.06638305f, -0.03554569f, -0.07030581f, -0.29336029f, -0.25507265f, -0.26922598f, 0.03077767f, 
    -0.05897838f, -0.07198817f, -0.07478419f, -0.08125087f, -0.34545118f, -0.23705029f, -0.38331404f, -0.38151431f, 
    0.42925721f, 0.02606455f, -0.36860138f, 0.00220561f, 0.01257416f, 0.12026260f, 0.12270560f, -0.23569898f, 
    -0.14195882f, -0.16514623f, -0.09823718f, 0.03528086f, 0.07030126f, 0.01287484f, 0.07622734f, 0.05833341f, 
    -0.10700184f, -0.01375573f, 0.02310902f, 0.00981478f, -0.12678765f, 0.07397098f, 0.06042396f, 0.00911665f, 
    -0.72333682f, -0.18308146f, 0.60755575f, -0.18884118f, 0.00270652f, 0.06894085f, -0.06710319f, 0.00444273f, 
    0.03394519f, -0.04267252f, -0.28009817f, -0.04232344f, 0.16473819f, 0.15128852f, -0.01567835f, -0.07614335f, 
    0.05323768f, 0.15398303f, 0.08067620f, -0.10305620f, 0.04864933f, 0.02469115f, 0.08362412f, 0.01599252f, 
    0.76560146f, 0.20263685f, -0.47464275f, -0.72083133f, -0.13701765f, -0.21519658f, 0.00681579f, -0.05942551f, 
    -0.08639645f, -0.05499861f, 0.00880842f, 0.00029917f, 0.28155398f, -0.01739955f, -0.27213904f, -0.01072180f, 
    0.21542515f, 0.06269168f, -0.16040929f, -0.01773552f, -0.11198913f, -0.10492092f, -0.05354627f, 0.12121227f, 
    0.27404514f, -0.18324329f, -0.20632210f, -0.10792737f, -0.05538419f, 0.07556684f, -0.22926855f, -0.14017810f, 
    -0.11989638f, -0.09772886f, 0.03515553f, 0.03210570f, 0.07854866f, 0.22090082f, -0.13431272f, -0.15639828f, 
    0.02907366f, 0.12190924f, -0.20129672f, 0.01634149f, -0.11987345f, 0.03682690f, 0.00413606f, 0.19156297f, 
    0.21622001f, -0.03188483f, 0.02094351f, -0.09130411f, 0.18653381f, 0.20649266f, -0.09897599f, -0.02590131f, 
    -0.07668503f, -0.00100282f, -0.07806578f, 0.07800107f, 0.23770162f, 0.00597478f, 0.04303564f, 0.00803868f, 
    0.07409487f, 0.05743312f, 0.01926309f, -0.00279447f, 0.13260272f, 0.04705979f, 0.02005172f, 0.08169428f, 
    -0.12557282f, -0.15555719f, 0.00845429f, 0.04797956f, 0.01508231f, 0.02504538f, 0.08215688f, 0.01348362f, 
    0.04815891f, 0.05150109f, 0.05720614f, 0.05333055f, 0.35564312f, 0.16744547f, -0.22961757f, -0.39226645f, 
    -0.01873848f, 0.02110906f, -0.08329038f, 0.01468692f, 0.03101110f, 0.04979600f, -0.01415493f, -0.02701693f, 
    0.49094245f, 0.33560526f, -0.18932298f, -0.11928829f, 0.18784051f, 0.23437950f, 0.11918224f, 0.16304030f, 
    -0.03830909f, -0.11358705f, 0.02643738f, -0.00634304f, -0.32873386f, 0.06761879f, 0.12188920f, -0.18754987f, 
    -0.02028855f, -0.00097853f, 0.05530164f, -0.03134839f, -0.15560617f, -0.37345785f, -0.20011970f, -0.19353586f, 
    -0.09882752f, 0.20763367f, -0.01078248f, 0.02023559f, 0.06188782f, 0.08918966f, -0.02188417f, -0.11359298f, 
    -0.03184306f, -0.11608362f, -0.20257173f, -0.14925295f, 0.43605846f, 0.14983439f, -0.01178491f, -0.37506738f, 
    -0.07978596f, -0.05291921f, 0.08764812f, 0.03975341f, -0.08590362f, 0.03404098f, 0.02031759f, 0.00673711f, 
    -0.28821853f, 0.28510737f, -0.08937308f, 0.08358227f, -0.01148940f, 0.01754262f, -0.17014082f, -0.08878969f, 
    -0.04961848f, 0.00012630f, -0.22501981f, 0.42305788f, -0.23905580f, 0.04573396f, -0.09097207f, -0.14850159f, 
    0.08378275f, -0.08649568f, 0.13703476f, -0.02023262f, -0.28960851f, -0.15887758f, 0.36036295f, -0.21410300f, 
    0.20395294f, 0.09124974f, 0.11506591f, 0.07666322f, -0.05791489f, 0.00736856f, -0.08405618f, 0.06628672f, 
    -0.31047153f, 0.06168025f, -0.12134449f, -0.00597732f, -0.12257048f, 0.04360389f, 0.05128442f, 0.07551163f, 
    0.05560530f, 0.03019766f, 0.03188045f, 0.07236663f, -0.20340259f, -0.01703685f, 0.02208331f, -0.02106837f, 
    0.32055894f, -0.13668774f, 0.15499194f, -0.23773369f, 0.03976735f, 0.12833205f, 0.11342260f, -0.04729510f, 
    0.08797235f, 0.13034850f, -0.17097531f, 0.07730029f, -0.07744540f, -0.18638530f, -0.11782505f, -0.04050276f, 
    0.16023424f, -0.06090238f, -0.08537764f, 0.19793284f, 0.04129012f, 0.06943356f, -0.09331777f, -0.07176377f, 
    -0.18854640f, 0.20566897f, 0.15082642f, 0.19107017f, -0.01170634f, 0.06996099f, 0.09650338f, -0.16097581f, 
    0.27112642f, -0.02492975f, -0.03328380f, -0.13093434f, 0.02807461f, 0.14229120f, 0.08039893f, -0.10075948f, 
    -0.03534082f, -0.10921793f, -0.15518670f, -0.08386031f, 0.01204197f, 0.06265017f, 0.04575820f, 0.02503960f, 
    -0.14149134f, 0.33904701f, 0.20556287f, -0.04614972f, -0.05971267f, 0.03585821f, -0.11378859f, -0.32728401f, 
    -0.16921955f, -0.02184957f, 0.00152082f, 0.00396780f, -0.17186461f, -0.03457461f, -0.05593025f, 0.08204062f, 
    -0.12541051f, 0.04789040f, 0.07805562f, 0.09083851f, -0.08261768f, -0.11211871f, -0.06082157f, 0.11810143f, 
    1.23370397f, 0.10723248f, -0.40798509f, 0.10823567f, 0.03699987f, -0.02669240f, 0.02126671f, -0.12581494f, 
    0.06542341f, 0.11130808f, 0.07984173f, -0.01391172f, 0.52643216f, -0.51845568f, -0.19835243f, 0.12200850f, 
    -0.12106510f, -0.09095357f, 0.02012949f, -0.05701409f, 0.26817188f, -0.41566920f, -0.14020541f, 0.08490895f, 
    -0.02362955f, 0.07776550f, 0.24462758f, -0.08359511f, 0.04424635f, -0.05505358f, -0.01568624f, -0.12795608f, 
    -0.23063141f, 0.03984001f, 0.01066891f, 0.06929442f, 0.16662125f, 0.06610395f, -0.06871476f, 0.14439054f, 
    0.01468569f, 0.01107804f, -0.09867489f, -0.05698599f, -0.01690731f, -0.19385639f, 0.06213019f, -0.03252307f, 
    -0.05699840f, -0.06298243f, 0.10505233f, -0.00089427f, 0.18785313f, 0.11067931f, 0.13011838f, -0.09497354f, 
    -0.04413372f, 0.04811162f, 0.07463607f, -0.00974608f, 0.34223267f, 0.04360251f, 0.06254652f, -0.01434662f, 
    -0.05824448f, 0.04720296f, 0.03902325f, 0.06449258f, -0.00696934f, 0.24038094f, -0.31759456f, -0.07265978f, 
    -0.12326960f, -0.37095326f, -0.52121818f, 0.06697163f, -0.08252005f, 0.06154553f, 0.12394358f, 0.13344295f, 
    -0.04761741f, 0.25145766f, -0.06668737f, 0.09423635f, 0.08295294f, 0.01075561f, 0.07080328f, 0.02996949f, 
    -0.07773920f, -0.03480048f, -0.02072308f, -0.04104753f, 0.04753523f, -0.03024826f, -0.03510065f, 0.03745006f, 
    -0.37135458f, 0.26733074f, 0.24379130f, -0.22946522f, -0.01460441f, -0.00860546f, 0.02456155f, 0.03214122f, 
    0.07111202f, 0.05199751f, 0.05614006f, -0.07740540f, 0.10818491f, 0.30175290f, -0.10380436f, 0.01937247f, 
    -0.01411975f, 0.02114167f, -0.05282213f, -0.30551332f, -0.06175858f, 0.01117568f, 0.00507188f, -0.65386462f, 
    0.01916541f, -0.23863418f, -0.30098504f, 0.01848407f, -0.20257105f, -0.10501487f, -0.02118964f, 0.12966277f, 
    0.06438541f, 0.02713913f, 0.14193860f, -0.03582677f, 0.34122884f, 0.26361576f, 0.34532771f, -0.17967197f, 
    -0.07051419f, 0.04162384f, 0.22278093f, 0.01594142f, 0.02218709f, -0.06701051f, -0.10213639f, -0.19955711f, 
    -0.12268092f, -0.34762082f, -0.02054948f, -0.23430561f, 0.14155704f, 0.12418182f, -0.02569979f, -0.08745447f, 
    -0.31296614f, -0.01130146f, 0.13473369f, -0.02651057f, 0.03168827f, -0.20200557f, 0.10007905f, -0.04111758f, 
    0.04433807f, 0.09200674f, -0.08809260f, -0.04206448f, -0.25506559f, -0.15125951f, -0.20963979f, 0.11494933f, 
    0.09580261f, 0.06628216f, -0.34650484f, -0.50759196f, -0.06901261f, 0.08031079f, 0.05332106f, 0.10643834f, 
    0.06570844f, 0.05094751f, -0.11160909f, -0.17138727f, -0.13342369f, -0.05053210f, -0.10398804f, -0.07198279f, 
    0.00541508f, 0.04946312f, -0.07399341f, -0.02313803f, 0.04260705f, -0.08466382f, 0.05736949f, -0.15879755f, 
    0.24837406f, 0.23401426f, 0.18694367f, 0.19491817f, -0.10209741f, -0.10580462f, 0.01480443f, 0.02727218f, 
    -0.05678743f, 0.06728084f, 0.06766625f, 0.03469656f, -0.37991482f, -0.07877809f, -0.05312700f, -0.25636396f, 
    -0.30596235f, 0.03082906f, 0.02716244f, 0.29744476f, -0.11282054f, 0.00137335f, 0.04607108f, 0.12831394f, 
    0.26672602f, 0.19509327f, 0.25480300f, 0.64284831f, -0.26131412f, 0.10652879f, -0.13730304f, -0.30707088f, 
    -0.01528815f, 0.02113146f, -0.05607037f, 0.10301562f, -0.39741623f, -0.20747752f, 0.20018131f, -0.00541437f, 
    -0.13394745f, 0.08983489f, 0.06483431f, 0.01706487f, 0.16064906f, 0.07738649f, 0.13638985f, 0.02309511f, 
    0.07998537f, -0.22794276f, 0.02828473f, 0.14405824f, -0.11988604f, 0.13428110f, -0.09097209f, 0.01913987f, 
    -0.11969555f, 0.15185988f, -0.01179004f, 0.02451564f, -0.24804461f, 0.14945786f, -0.08294313f, -0.06989438f, 
    -0.01613446f, 0.03451152f, 0.04319736f, -0.36910966f, 0.01322191f, -0.06023327f, 0.07428336f, -0.03408617f, 
    -0.12179799f, -0.02201244f, 0.01191733f, 0.12365764f, 0.00668415f, 0.10904180f, 0.06002732f, 0.04196888f, 
    0.08796682f, 0.06695469f, -0.23789541f, 0.17428790f, -0.07081760f, 0.04507877f, -0.12487789f, 0.22432224f, 
    -0.02475887f, -0.13211256f, -0.16560648f, -0.07070652f, 0.06600105f, 0.02546572f, 0.05306496f, -0.37057170f, 
    -0.04356840f, -0.07335942f, -0.07426474f, -0.01522071f, -0.03629427f, 0.00117438f, -0.00077516f, -0.03192798f, 
    -0.12325881f, 0.07117363f, 0.13833027f, 0.19813576f, 0.02094605f, -0.06375569f, -0.08938970f, 0.18066071f, 
    -0.09722588f, -0.06840245f, -0.11829463f, 0.01465067f, 0.03083641f, -0.06026492f, -0.04522081f, -0.00506645f, 
    -0.17124036f, 0.42683968f, -0.04546350f, 0.14434049f, -0.08983064f, -0.05066310f, -0.05583911f, -0.00678910f, 
    -0.09772427f, 0.03922409f, -0.19348550f, 0.03153891f, -0.05170016f, 0.12599406f, -0.08502671f, -0.26029465f, 
    0.12139872f, -0.02920831f, -0.13291629f, -0.12871149f, 0.00465092f, 0.01535343f, 0.06006010f, 0.03135525f, 
    0.11398577f, -0.07815611f, -0.26997262f, 0.16916136f, -0.04995878f, -0.03499876f, 0.01984076f, 0.10736747f, 
    -0.15413141f, -0.05838702f, -0.11897406f, -0.14011374f, -0.65911901f, 0.20638712f, 0.17211641f, -0.30173439f, 
    -0.08095611f, 0.00411966f, 0.03194252f, -0.02877070f, 0.05013831f, -0.05752512f, 0.06663343f, -0.08823732f, 
    -0.26495507f, -0.12284246f, -0.21995647f, -0.00267792f, -0.00681121f, -0.11476368f, 0.29538760f, -0.31012842f, 
    0.04625477f, 0.05078935f, 0.05896696f, -0.04326783f, 0.11971025f, -0.08135738f, -0.14253005f, 0.16311249f, 
    0.04748938f, -0.03536154f, 0.04491129f, 0.03161356f, -0.04554430f, -0.04902185f, 0.09188087f, 0.16576792f, 
    -0.49349013f, 0.57187104f, 0.47191080f, 0.02204577f, -0.12005572f, 0.05052333f, -0.04238587f, -0.10385097f, 
    0.06294144f, 0.13724716f, -0.14853466f, -0.05384604f, -0.03968585f, -0.41965565f, 0.47127408f, 0.09684090f, 
    0.12899922f, -0.02226761f, 0.04229661f, 0.07030404f, 0.20741087f, 0.11483149f, -0.02576254f, -0.03263297f, 
    -0.08866633f, 0.07491022f, 0.13924290f, -0.10566153f, 0.12086491f, -0.06369460f, 0.06761596f, 0.12675314f, 
    -0.07248577f, 0.04956616f, 0.03016014f, -0.01142632f, 0.14902882f, -0.16830656f, 0.17132911f, -0.10405573f, 
    0.00897603f, -0.01125454f, 0.00843413f, 0.05164800f, 0.10792758f, 0.21570696f, 0.02496806f, 0.10069772f, 
    0.00918621f, 0.05355006f, -0.02588954f, 0.05761027f, 0.14167732f, 0.16766506f, -0.08303381f, 0.09826775f, 
    -0.09116554f, -0.01707680f, 0.05221520f, -0.20416835f, -0.01646589f, 0.07831605f, 0.09841709f, -0.01836103f, 
    0.01078560f, 0.11791505f, -0.06115910f, 0.08256358f, 0.05006337f, 0.09695027f, -0.09939307f, 0.18370211f, 
    0.03605784f, -0.28653619f, 0.18527412f, 0.11571191f, 0.02696705f, -0.04718924f, 0.08142470f, 0.04951577f, 
    0.07903720f, -0.30009097f, 0.07011683f, 0.02294978f, -0.13972427f, -0.03935950f, -0.02290033f, -0.01689462f, 
    -0.08658025f, -0.10851489f, -0.03772133f, 0.06885712f, -0.05444022f, -0.02136935f, 0.00144465f, -0.05082361f, 
    -0.77692193f, -0.57141972f, -0.12979127f, 0.21122600f, 0.04230556f, 0.06581641f, -0.06035278f, -0.10423551f, 
    0.05996722f, -0.00029845f, -0.10383940f, 0.14357802f, 0.04134443f, 0.03375588f, 0.23118815f, 0.27354807f, 
    -0.05191996f, -0.01660020f, 0.06000561f, -0.00204955f, -0.11709909f, 0.05243773f, -0.01449068f, -0.00120743f, 
    0.05468947f, 0.77968711f, -0.22124101f, -0.11850614f, 0.12136102f, -0.03706601f, -0.23733898f, 0.10677553f, 
    -0.03913539f, 0.06321216f, -0.02070548f, -0.12909992f, -0.56467807f, 0.47763738f, 0.71885484f, 0.14981829f, 
    -0.29561865f, 0.02736263f, 0.01194649f, -0.33591118f, -0.07144334f, 0.03117332f, -0.07276375f, -0.16015157f, 
    -0.07368116f, 0.13535835f, -0.00703987f, 0.15032630f, 0.02979592f, -0.07682041f, -0.16231111f, -0.07570404f, 
    0.20231950f, 0.02501640f, 0.04527980f, 0.02712241f, 0.32589298f, 0.43626788f, 0.19178326f, 0.35762385f, 
    -0.04784275f, -0.17295478f, 0.19765984f, 0.09073526f, -0.06615992f, -0.12110800f, 0.02479775f, 0.05069050f, 
    0.13585122f, 0.83564657f, 0.38841602f, 0.24057429f, -0.07633427f, -0.04838560f, 0.14175658f, -0.11519352f, 
    0.00943862f, -0.01444386f, -0.26844835f, 0.03978961f, 0.05162949f, 0.25271815f, 0.05411430f, 0.19123320f, 
    -0.01581333f, -0.06602275f, 0.10806727f, -0.21354756f, -0.09082941f, 0.06762112f, -0.00840232f, 0.06888747f, 
    -0.13969994f, -0.20821977f, -0.20070444f, -0.14747962f, -0.00176737f, -0.04763176f, 0.05214555f, 0.09688172f, 
    -0.09679519f, -0.08551691f, -0.04116061f, 0.06799722f, -1.02923810f, -0.41694835f, -0.23353685f, -0.23551054f, 
    -0.04868880f, -0.06539285f, -0.06429683f, -0.21533605f, 0.00176952f, -0.02533215f, -0.06010012f, 0.05248927f, 
    -1.00591421f, -0.66008466f, -0.19651139f, -0.34066010f, 0.01862011f, -0.09398723f, 0.23190702f, 0.15675227f, 
    -0.03918576f, -0.01594123f, -0.02602011f, -0.09106658f, -0.00682502f, -0.14532968f, -0.50692427f, 0.10239052f, 
    0.00832006f, 0.10369334f, 0.10356517f, 0.05712142f, -0.32192081f, 0.06262858f, 0.01737119f, 0.05752543f, 
    0.05916715f, -0.26310810f, -0.17643344f, 0.13581531f, -0.02194126f, -0.09077194f, 0.15203527f, -0.28347719f, 
    0.02313122f, 0.05331186f, -0.18335187f, 0.11114569f, -0.80434662f, -0.21217303f, -0.50054282f, -0.05964776f, 
    -0.30371851f, -0.04968154f, 0.21449833f, -0.42303523f, 0.03857756f, 0.06029809f, -0.03206231f, -0.06712218f, 
    0.67700976f, -0.06594156f, -0.01122706f, -0.54526627f, 0.46211076f, 0.07359896f, 0.19433290f, -0.10995553f, 
    -0.32134646f, 0.10155340f, -0.12879385f, -0.05824089f, -0.15015358f, 0.14423776f, -0.39028510f, 0.31064597f, 
    0.11635124f, -0.25164956f, 0.06502098f, 0.00343244f, 0.03803112f, -0.13703744f, 0.09351663f, 0.18135367f, 
    0.02390569f, 0.14645077f, 0.25302911f, 0.11714549f, -0.08778607f, -0.05760467f, -0.12711591f, 0.21722743f, 
    -0.01477498f, 0.12496766f, -0.00764615f, 0.05312090f, 0.32473919f, -0.04690334f, -0.02632503f, 0.03029876f, 
    0.07532658f, 0.02940593f, -0.10740609f, 0.09295727f, 0.20362915f, -0.00979701f, -0.10599007f, -0.04054572f, 
    -0.29790026f, 0.11205254f, -0.11022477f, 0.53163701f, -0.14692482f, -0.00905669f, -0.15300477f, -0.08906250f, 
    -0.05634195f, 0.16636652f, 0.31070140f, -0.00863884f, 0.01511203f, -0.07293525f, -0.01528771f, 0.10186554f, 
    -0.02041787f, -0.00127976f, 0.00651124f, -0.02801499f, -0.12280022f, 0.01935562f, -0.10214834f, 0.05824837f, 
    -0.60377872f, 0.57194060f, -0.48053187f, -0.56477934f, -0.01268164f, -0.23279418f, -0.02214571f, 0.08196225f, 
    -0.20038910f, -0.16817960f, -0.33271226f, -0.05243134f, -0.66759413f, -0.12419811f, 0.33126777f, 0.02960212f, 
    -0.25854087f, -0.05551288f, -0.12588026f, -0.25665030f, 0.11636663f, 0.02912896f, -0.04161132f, 0.10649540f, 
    0.23101939f, -0.20660637f, -0.13752815f, 0.09681149f, 0.13085471f, -0.07584037f, -0.01413493f, -0.02185325f, 
    0.06067043f, -0.09726690f, -0.03471623f, -0.00802095f, 0.07505502f, 0.11654688f, -0.34384823f, -0.78618300f, 
    -0.03887011f, -0.02583266f, 0.02536975f, -0.19468756f, -0.21527700f, -0.01389415f, -0.14248195f, -0.02657737f, 
    -0.94749898f, 0.57762533f, 0.13047148f, 0.28070295f, 0.11154030f, -0.00265678f, 0.19962029f, -0.23964965f, 
    -0.11503520f, -0.12872759f, 0.01913282f, -0.00015463f, 0.45915687f, 1.07884324f, -0.50503325f, 0.07865939f, 
    0.34238511f, -0.05093150f, 0.09733250f, -0.07624964f, -0.09996197f, 0.00925516f, -0.05071304f, -0.03579710f, 
    -0.01374181f, -0.11159798f, 0.01867363f, 0.23784721f, -0.23433626f, -0.12261365f, -0.07420275f, -0.12270026f, 
    -0.09762682f, -0.00894755f, -0.00282297f, -0.23268357f, -0.17639960f, 0.05560268f, -0.52713305f, -0.17249407f, 
    0.23778297f, 0.11584373f, 0.21693648f, -0.42104974f, -0.15095043f, -0.09488665f, -0.00184579f, -0.06341317f, 
    0.08284083f, 0.19702892f, -0.11341467f, -0.08375887f, 0.03856828f, 0.30525926f, -0.11001144f, -0.13931055f, 
    0.00688108f, -0.08771437f, 0.35183391f, -0.12015709f, -0.31648853f, 0.03792851f, -0.27015388f, 0.29686460f, 
    0.02920061f, -0.11456487f, -0.27786896f, -0.11597059f, -0.04859024f, -0.14566883f, 0.16677845f, -0.08569305f, 
    -0.38315222f, -0.06592067f, -0.34690264f, -0.12710966f, 0.11245105f, 0.13873702f, -0.13979799f, 0.16608645f, 
    0.02768855f, -0.01946205f, -0.07423035f, -0.00031191f, -0.37135568f, -0.28530848f, -0.04313619f, -0.32833990f, 
    -0.32593161f, -0.22899550f, -0.07164614f, -0.23659188f, 0.17865509f, -0.06725867f, -0.14184611f, 0.15595743f, 
    0.34717304f, 0.01695949f, 0.08572806f, -0.46738690f, -0.12480933f, -0.18575086f, -0.02249762f, -0.01723632f, 
    -0.17054026f, 0.00217173f, 0.09473206f, -0.07128557f, -0.02715888f, -0.19145116f, 0.01687338f, 0.00217656f, 
    0.18836513f, -0.01251425f, 0.15853438f, -0.12962818f, -0.09796263f, 0.11034855f, -0.03654206f, 0.14549693f, 
    -0.85227174f, 0.78968441f, 0.26940528f, 0.35315338f, -0.00604093f, -0.07338054f, -0.03798397f, 0.04986383f, 
    -0.30113053f, -0.15875416f, 0.02007893f, 0.13260798f, -0.26295638f, 0.01958952f, 0.01343370f, 0.32318622f, 
    0.02908695f, -0.07658479f, 0.05790335f, -0.06118583f, 0.01959175f, -0.04979328f, 0.23419341f, 0.01821994f, 
    -0.17634706f, -0.25510934f, 0.12568915f, 0.46265182f, 0.05109126f, 0.07228550f, -0.22462629f, 0.13429563f, 
    -0.07846235f, 0.14158283f, -0.18438776f, -0.05999023f, 0.41735074f, -0.16031753f, 0.09898947f, 0.40310499f, 
    0.07198809f, -0.06743073f, 0.06324660f, 0.02487229f, -0.10043523f, -0.06510953f, 0.16881110f, 0.05693961f, 
    0.25796157f, -0.13336857f, -0.00108815f, 0.23440357f, 0.17739508f, -0.01932694f, 0.02525547f, -0.01315538f, 
    -0.08136369f, 0.06858978f, 0.03515803f, -0.02000247f, -0.03573810f, -0.33814660f, 0.23357926f, 0.26452169f, 
    0.12207823f, 0.10467385f, 0.05192423f, 0.12513441f, -0.15287302f, -0.10844181f, -0.25985476f, 0.15316069f, 
    -0.59600019f, -0.31555799f, -0.22845572f, -0.19522041f, -0.22384524f, -0.01896427f, -0.08138504f, 0.31549880f, 
    -0.01751879f, -0.09827392f, 0.32320085f, -0.10808945f, -0.00537615f, -0.25453690f, -0.03118653f, 0.29281762f, 
    0.02093236f, 0.10645952f, -0.03607245f, 0.22659275f, -0.02527454f, -0.03351356f, 0.13853961f, -0.01799233f, 
    -0.14770195f, -0.15243423f, -0.12348493f, 0.21549936f, 0.14944701f, -0.03942823f, 0.08458387f, 0.05477374f, 
    0.03462230f, -0.10509733f, 0.00147244f, -0.07345633f, 0.28706065f, 0.23200762f, -0.19819611f, -0.71378785f, 
    0.17418936f, -0.01357610f, 0.04975719f, 0.07916347f, -0.14308989f, 0.08415139f, -0.12661941f, 0.00565508f, 
    0.35355082f, -0.31989595f, -0.08293138f, -0.19920449f, 0.13593772f, -0.01357825f, -0.00353039f, 0.02556717f, 
    0.00570136f, 0.00391460f, 0.18366228f, -0.19558963f, -0.07300326f, -0.22261710f, -0.28832436f, 0.27917099f, 
    0.09032463f, -0.01657884f, -0.06037877f, 0.10827640f, -0.05852282f, 0.14553055f, 0.00393053f, -0.38760459f, 
    0.22772917f, -0.12422527f, -0.32690832f, 0.01377047f, -0.12111352f, -0.11553250f, 0.12789999f, 0.10484686f, 
    0.13902088f, 0.01210245f, 0.01319908f, -0.10975020f, 0.05659635f, -0.05259340f, 0.25450948f, 0.09601364f, 
    -0.06270492f, 0.17426002f, -0.07974080f, -0.03299433f, 0.11903577f, 0.30434611f, -0.15779962f, 0.42316008f, 
    -0.04194048f, -0.00420773f, 0.03635459f, -0.14281635f, 0.02145930f, -0.04157811f, -0.00972794f, -0.05844481f, 
    0.24683353f, 0.03203645f, 0.10851534f, 0.54360056f, -0.06960017f, -0.05079123f, -0.01290657f, -0.02464280f, 
    -0.17140141f, 0.02972773f, 0.09991243f, -0.08002713f, 0.21949050f, -0.05542713f, 0.03885337f, 0.02622119f, 
    -0.52416152f, -0.18126974f, -0.19164380f, -0.24210599f, 0.03302123f, -0.31577033f, -0.30532208f, 0.12553720f, 
    -0.06630460f, -0.21416569f, 0.09521239f, -0.22911836f, -0.05589812f, 0.11010615f, 0.11499634f, 0.17359032f, 
    0.15905540f, 0.01160861f, 0.02001022f, -0.22382481f, -0.03994017f, -0.04005679f, 0.08620039f, 0.15231909f, 
    -0.37208602f, -0.42001021f, -0.09409261f, -0.13604249f, 0.01000453f, -0.01905409f, -0.03605588f, 0.04173979f, 
    -0.30609885f, 0.06783642f, -0.19502124f, -0.33745691f, 0.32452446f, -0.11899053f, 0.06670708f, 0.31724572f, 
    -0.00305391f, 0.02164794f, 0.15642449f, -0.03349318f, 0.02851468f, 0.06065569f, 0.03388400f, 0.03108808f, 
    -0.11625239f, 0.13057467f, 0.25133997f, 0.18418398f, -0.19864358f, -0.14665322f, -0.18558492f, -0.01183073f, 
    0.08538004f, 0.01663592f, 0.03891756f, 0.03305247f, -0.10878732f, 0.02216910f, -0.01238798f, -0.09237782f, 
    -0.15758215f, -0.03796672f, 0.02833034f, -0.04425909f, 0.00332100f, 0.22932412f, 0.10612600f, 0.10580653f, 
    -0.00606833f, -0.22834951f, 0.25663343f, -0.25145310f, -0.05577732f, 0.03284379f, -0.11767487f, 0.07804408f, 
    -0.01439541f, -0.20538594f, -0.23598343f, 0.32323834f, -0.63513327f, -0.54789221f, 0.27244094f, -0.27334070f, 
    -0.16814350f, 0.27003250f, -0.27465698f, -0.35461920f, 0.03188643f, 0.04074288f, 0.13108739f, -0.12279450f, 
    0.00328953f, -0.20585488f, -0.13848412f, -0.12981294f, 0.10238515f, -0.00924506f, -0.05016112f, 0.01785239f, 
    0.16595589f, 0.03801691f, -0.10162373f, -0.23173398f, 0.11250117f, -0.04208354f, -0.18664137f, 0.03933539f, 
    0.01527291f, -0.15714955f, -0.06173002f, 0.01441639f, -0.11775908f, -0.00628990f, -0.08060377f, 0.15585630f, 
    0.07156923f, 0.09220947f, -0.02847594f, 0.08775818f, 0.00591983f, -0.25901631f, -0.11810488f, -0.08501048f, 
    -0.05739908f, -0.15090939f, -0.13709378f, -0.09815980f, 0.04480093f, -0.03832860f, 0.02061085f, -0.24571708f, 
    -0.00009682f, 0.06945119f, 0.07171335f, 0.02246367f, -0.10442037f, -0.00572424f, -0.19947156f, -0.06048044f, 
    0.35585308f, -0.09949508f, 0.31103373f, 0.17253286f, -0.06041517f, -0.07323969f, -0.08034203f, -0.14172311f, 
    0.12002292f, -0.16412219f, 0.04744881f, -0.03002249f, 0.08092072f, 0.03197240f, 0.08289560f, 0.11468518f, 
    0.20314217f, 0.09266038f, 0.02495378f, 0.05853557f, -0.00797680f, 0.01690526f, 0.00415746f, -0.02044526f, 
    -0.47521949f, -0.14005508f, -0.39097252f, 0.30538586f, -0.10558677f, -0.12096047f, -0.06077541f, -0.08019082f, 
    0.02897928f, 0.01478979f, -0.07502417f, 0.02607975f, -0.27789995f, 0.03154530f, -0.09067751f, 0.06579407f, 
    -0.12983643f, -0.06522226f, 0.02115041f, 0.05969866f, -0.01444556f, -0.07430484f, -0.01587068f, 0.21540806f, 
    0.23657365f, -0.60054445f, 0.20312575f, -0.01614708f, 0.04534130f, 0.08614579f, 0.21609220f, -0.22513399f, 
    -0.12581027f, -0.10671967f, -0.09139912f, 0.10467438f, -0.24854884f, -0.03844161f, -0.01585094f, 0.12572311f, 
    -0.06249430f, 0.04397666f, -0.16168578f, -0.18862619f, -0.07498035f, 0.03590254f, 0.00574565f, -0.00647612f, 
    0.01996521f, 0.11814243f, 0.24422938f, -0.09338583f, -0.02114401f, -0.04394152f, -0.24950810f, -0.19988579f, 
    0.25322181f, 0.05246685f, 0.03183697f, -0.02412362f, -0.04117644f, -0.18962853f, 0.06024631f, -0.02117315f, 
    -0.03858983f, -0.22175469f, -0.06973220f, -0.15939553f, 0.12819198f, 0.06579767f, -0.04376341f, 0.10816134f, 
    0.19615711f, 0.25959879f, 0.11766586f, 0.27075854f, -0.10285311f, -0.11433318f, 0.02266595f, -0.03327372f, 
    -0.01986773f, -0.25475407f, -0.13231835f, -0.02517059f, -0.05413688f, 0.15535587f, 0.04088198f, 0.08518766f, 
    -0.03947951f, -0.04527920f, 0.05152217f, 0.10930730f, 0.24224269f, -0.16493137f, -0.11932159f, 0.14547320f, 
    0.02323883f, -0.03667524f, -0.03479990f, -0.05305627f, 0.13600500f, 0.09433528f, 0.09620166f, -0.01591497f, 
    0.15483139f, 0.01019223f, 0.00467043f, 0.05997867f, 0.27446097f, 0.38345113f, 0.35224116f, 0.19512558f, 
    0.02539325f, -0.01835999f, 0.15796171f, 0.07762877f, 0.09914324f, -0.04385458f, -0.03875220f, -0.06021767f, 
    -0.02173368f, 0.08349367f, 0.15712093f, 0.02135745f, -0.08774363f, 0.02960988f, 0.04117338f, 0.15900722f, 
    0.03539075f, 0.08909054f, -0.00908360f, -0.04702639f, 0.12300033f, -0.59069449f, 0.14327312f, -0.00128857f, 
    -0.01131064f, 0.00864923f, -0.08973406f, -0.02076493f, -0.13640913f, -0.29248807f, -0.24299254f, -0.18869124f, 
    0.11578221f, -0.20026234f, -0.00910668f, 0.17572510f, -0.06384038f, 0.00754743f, -0.24887139f, 0.07063442f, 
    0.09542472f, -0.23864523f, -0.19210848f, -0.05067725f, 0.32208759f, 0.21159500f, 0.42265314f, 0.07673818f, 
    -0.16357301f, -0.00462762f, 0.08692803f, 0.20532855f, 0.01564653f, -0.10080267f, 0.01385345f, 0.03566844f, 
    -0.70034260f, -0.24228086f, -0.04743427f, 0.11163347f, -0.10061072f, -0.18126383f, 0.06396729f, 0.08206031f, 
    0.04209386f, -0.16132157f, 0.04390138f, -0.03356383f, 0.12322267f, -0.13769209f, 0.06359375f, 0.00708616f, 
    -0.06397067f, -0.02569906f, -0.01258268f, -0.01455319f, -0.22820953f, -0.01936982f, -0.17480767f, -0.26894450f, 
    0.06579556f, -0.20326094f, -0.33767438f, 0.02953831f, 0.02105276f, 0.01977167f, 0.09505334f, 0.00779200f, 
    -0.16418810f, -0.33475500f, -0.34441450f, -0.85238570f, -0.09648159f, -0.13575540f, 0.13376664f, -0.03661392f, 
    0.05825448f, -0.04045039f, 0.25691980f, 0.02753844f, 0.18931489f, 0.06492867f, -0.00535464f, 0.03383718f, 
    0.38038921f, 0.05150686f, -0.08505049f, -0.03010923f, 0.06971196f, 0.16359413f, -0.11989712f, -0.11041680f, 
    0.24304889f, -0.12017558f, -0.24071549f, 0.17723879f, 0.10943572f, 0.31823564f, 0.34176627f, -0.08775163f, 
    -0.23939583f, -0.08430138f, 0.11225919f, 0.14531901f, 0.12679355f, -0.02187676f, -0.04509941f, -0.00970094f, 
    0.37409917f, -0.37235054f, 0.12510839f, 0.09314310f, 0.02155313f, -0.01495863f, -0.09372638f, 0.07181153f, 
    -0.10209846f, 0.04126326f, -0.01911909f, 0.31292671f, 0.00702865f, -0.29666817f, -0.23627618f, 0.23789562f, 
    0.15610832f, 0.07553936f, -0.06471135f, 0.06448416f, -0.04148917f, -0.09171893f, -0.04842611f, -0.01520096f, 
    -0.03426375f, 0.01551046f, -0.15847534f, 0.17173195f, 0.18070357f, 0.13078037f, 0.15299390f, 0.19197588f, 
    0.05050635f, 0.02356549f, 0.06466448f, 0.02878786f, -0.04126927f, -0.11973131f, 0.20010386f, 0.01691684f, 
    0.12256748f, -0.19215560f, -0.05565163f, 0.09628126f, 0.05568792f, -0.11804081f, 0.00471452f, -0.09356359f, 
    -0.30008879f, -0.38519147f, 0.11682062f, -0.39413613f, -0.01880750f, 0.03592021f, -0.11861593f, 0.11980274f, 
    0.21673873f, 0.06938848f, 0.13170946f, -0.22990140f, -0.38731360f, 0.34545293f, 0.03375753f, -0.24883547f, 
    -0.14710322f, -0.26853570f, -0.04038695f, 0.13103570f, -0.41017076f, -0.04828866f, -0.00197068f, 0.06958512f, 
    0.17134851f, 0.06862711f, -0.35022831f, 0.13435616f, 0.08509595f, 0.17351002f, -0.16995272f, 0.04937302f, 
    0.11398993f, -0.15665860f, 0.10983818f, 0.26820260f, -0.28659585f, 0.05233436f, 0.14684959f, -0.18709826f, 
    0.05068026f, 0.07427473f, 0.03408941f, 0.17451508f, 0.08509341f, 0.05290651f, -0.30214125f, -0.32356760f, 
    -0.06241859f, -0.05059265f, 0.00363277f, 0.11931875f, -0.06619328f, -0.05636950f, 0.05711582f, -0.01237900f, 
    0.13206361f, 0.15377443f, -0.19617371f, -0.01749593f, -0.10498417f, -0.08022521f, -0.15849468f, -0.01143873f, 
    0.00211427f, -0.02174683f, 0.00241621f, 0.03447555f, 0.22544231f, -0.09543332f, 0.39718130f, 0.12011103f, 
    -0.10020943f, 0.19541094f, 0.21491365f, -0.44345188f, 0.05187267f, -0.03589174f, 0.06315462f, -0.09295537f, 
    0.20054558f, -0.12701625f, -0.01064999f, -0.10494164f, -0.11872917f, -0.13561055f, -0.07793156f, -0.00652313f, 
    0.20633914f, 0.08317345f, -0.06106585f, -0.02288453f, -0.02004558f, 0.03128047f, -0.00099149f, 0.02908043f, 
    0.34393713f, -0.38109925f, 0.05259664f, 0.28983986f, 0.17677224f, 0.11363160f, -0.04368448f, 0.08510292f, 
    -0.03708945f, 0.12728322f, 0.07602467f, 0.03041890f, -0.20109245f, -0.26805174f, -0.05918496f, -0.16956697f, 
    -0.01109453f, 0.01322856f, -0.05069571f, 0.15173915f, 0.10222036f, -0.16929644f, -0.16823447f, 0.03436438f, 
    0.13015071f, -0.15101387f, 0.13828419f, -0.17616835f, 0.00832358f, -0.03450659f, 0.10972364f, 0.03089704f, 
    0.08094084f, 0.02921592f, -0.16186832f, -0.06797383f, 0.19219825f, -0.03355540f, -0.25952330f, -0.37726682f, 
    0.16629925f, -0.09795687f, -0.16097662f, 0.08286555f, 0.11101225f, 0.07098704f, -0.04591150f, 0.10315642f, 
    0.13330306f, 0.22820124f, -0.33588380f, -0.13046199f, -0.00282151f, 0.00473360f, 0.17078900f, 0.17446683f, 
    0.12084815f, -0.08608198f, 0.01380541f, -0.00065552f, -0.51366329f, 0.49987933f, -0.23319595f, -0.25035888f, 
    0.00204171f, 0.17986760f, -0.03873600f, -0.02687624f, 0.27365625f, -0.01470632f, 0.10389821f, -0.36897263f, 
    -0.62878698f, -0.33809966f, -0.17158276f, -0.28846449f, -0.07266250f, -0.04242095f, -0.12415190f, -0.10372604f, 
    0.19025317f, -0.05356154f, 0.21890980f, 0.04220439f, -0.13803327f, -0.23179860f, -0.08332881f, -0.15745962f, 
    -0.01249509f, -0.07121448f, 0.02241226f, 0.18881205f, -0.03234263f, 0.26284942f, 0.06131843f, -0.10479959f, 
    -0.08181637f, -0.18982916f, -0.07967367f, 0.21847761f, 0.05971041f, 0.06117721f, -0.00874376f, -0.09935274f, 
    0.03341436f, -0.05414341f, -0.14546320f, 0.02843646f, 0.22741847f, 0.21447368f, 0.14925431f, 0.00477748f, 
    0.10106776f, 0.03872823f, -0.05572462f, -0.25583607f, 0.00295133f, -0.01027136f, -0.03074855f, -0.08570840f, 
    -0.05424693f, 0.20943271f, 0.16058142f, -0.32577765f, 0.21121863f, 0.13933080f, -0.00577181f, -0.21739446f, 
    0.05779805f, 0.06430261f, 0.03973034f, 0.14251556f, 0.20508496f, -0.09058199f, 0.26724923f, 0.37561762f, 
    -0.09501968f, -0.19319715f, 0.08108283f, -0.02861249f, 0.02024415f, 0.04144468f, -0.00074021f, 0.04444107f, 
    -0.51615435f, 0.47789097f, 0.11434576f, -0.27172595f, -0.10565495f, -0.04350197f, 0.18828569f, -0.08110853f, 
    0.10539028f, -0.01164061f, 0.04344886f, 0.09078737f, 0.06761736f, 0.05014671f, 0.14414778f, -0.01112318f, 
    0.13357703f, 0.16172256f, 0.00711595f, -0.01427259f, 0.01875398f, -0.08597081f, 0.00860395f, 0.06449727f, 
    -0.08692295f, -0.03819264f, 0.17486285f, 0.37224090f, -0.13585189f, -0.04691246f, -0.08447856f, 0.11102672f, 
    -0.03193744f, 0.07908685f, 0.21622957f, 0.01374486f, -0.18021478f, 0.10821608f, -0.14159685f, 0.07689164f, 
    -0.11595620f, 0.14825960f, 0.09621226f, -0.13350756f, 0.31466502f, -0.09873384f, 0.04612193f, 0.17638838f, 
    -0.01145352f, 0.14033355f, 0.08653587f, -0.09914069f, 0.06827862f, -0.02360286f, 0.09625138f, 0.00824969f, 
    -0.00058028f, 0.24576266f, 0.16903943f, 0.03838006f, -0.11630569f, -0.12701206f, -0.13730472f, 0.06417505f, 
    -0.12193517f, -0.35583669f, -0.23596416f, -0.07020441f, -0.03297970f, -0.07512514f, -0.00152216f, -0.06255759f, 
    0.68341035f, 0.16745986f, -0.69217747f, 0.18567017f, -0.00472017f, -0.23421800f, 0.10156295f, 0.28175917f, 
    -0.05134007f, 0.07455181f, -0.06248067f, -0.08271374f, -0.54431212f, -0.85410804f, -0.35967654f, -0.23257576f, 
    -0.04060492f, 0.09028973f, 0.00369542f, -0.22560745f, -0.04527020f, 0.05512570f, 0.10898404f, -0.03161559f, 
    -0.04011675f, 0.09413984f, 0.05491694f, 0.01272714f, -0.02153777f, -0.05165933f, 0.05705515f, 0.09758822f, 
    -0.09786173f, -0.06956665f, 0.18706091f, 0.31482995f, 0.01246079f, -0.16571470f, -0.26794344f, -0.05941568f, 
    0.07202745f, 0.11074260f, 0.18516256f, 0.03217900f, -0.02885921f, -0.05331489f, -0.11335663f, 0.10380659f, 
    -0.80264467f, -0.71207881f, -0.98296314f, -0.36435336f, -0.09913904f, -0.01308564f, 0.17979299f, -0.35138097f, 
    0.13533309f, -0.02739418f, -0.03891281f, 0.04316516f, 0.07427969f, 0.21566652f, 0.04229814f, -0.05739591f, 
    -0.01545463f, -0.00422509f, 0.01641776f, 0.12500235f, 0.21397054f, 0.09615152f, 0.06119067f, -0.21445927f, 
    -0.04691268f, 0.47116300f, -0.21612522f, 0.16049501f, 0.02426758f, -0.00935543f, 0.12458957f, 0.02330660f, 
    0.18701728f, -0.06172923f, 0.26061934f, 0.13652079f, -0.21616146f, 0.28355935f, 0.27311945f, 0.02162225f, 
    0.00325074f, -0.06334379f, 0.09183171f, 0.02235787f, 0.06846447f, 0.26664755f, 0.08968124f, 0.01646949f, 
    0.09207445f, 0.01341754f, -0.14136522f, -0.14745162f, -0.04341412f, 0.05718502f, 0.08462906f, -0.00176211f, 
    0.14103073f, 0.10429841f, -0.07526278f, -0.01308351f, 0.04702424f, -0.00863573f, 0.07411070f, 0.11088467f, 
    0.13410012f, 0.10494614f, 0.13479425f, 0.00602860f, 0.04747058f, 0.03831590f, 0.30618364f, 0.04972197f, 
    -0.18195620f, -0.09456288f, -0.04606297f, 0.00913275f, -0.31029534f, -0.39991218f, 0.01733480f, 0.09309514f, 
    -0.10104132f, -0.10899460f, 0.07087538f, 0.05294459f, 0.09217260f, 0.12310445f, -0.20671645f, 0.03670891f, 
    0.14291994f, -0.09430007f, 0.07821441f, -0.00404981f, -0.03096464f, -0.09097022f, 0.03548546f, 0.05698637f, 
    -0.43592235f, 0.48386183f, 0.64778101f, -0.45417938f, -0.05010720f, -0.03091431f, -0.17756630f, 0.13772036f, 
    -0.15711625f, 0.26244330f, 0.13652582f, 0.04083278f, -0.01626535f, -0.16253908f, -0.08434757f, 0.11609429f, 
    0.04044341f, 0.02132591f, 0.00074091f, -0.03153002f, -0.04010402f, -0.08491420f, -0.10717941f, -0.02021342f, 
    0.45626843f, -0.05322387f, -0.86967939f, -0.44899786f, -0.18949066f, 0.06058301f, 0.18390989f, 0.12386112f, 
    -0.03733859f, 0.10583774f, 0.07719456f, -0.23182172f, -0.27950251f, 0.23876996f, 0.12538856f, 0.15408146f, 
    -0.16269097f, 0.07875224f, -0.00199867f, 0.15667312f, 0.02491672f, -0.06851733f, 0.09129843f, 0.06809948f, 
    -0.57720989f, -0.64007628f, -0.17263453f, 0.66904944f, 0.23177004f, 0.26864401f, -0.07004347f, -0.18008931f, 
    0.08913305f, 0.00582989f, 0.11010177f, 0.13725057f, -0.80648100f, -0.21875691f, -0.13475363f, 0.29509714f, 
    -0.05171682f, -0.08511979f, -0.01893408f, 0.06891125f, -0.02580498f, 0.00030244f, 0.18048640f, -0.09970934f, 
    0.42947787f, 0.32100970f, 0.24939658f, -0.18534952f, -0.01264924f, -0.14973557f, -0.03551988f, 0.08823302f, 
    0.18634620f, -0.01266525f, 0.01783153f, 0.05972180f, -0.51701039f, -0.23827510f, 0.47659755f, -0.43299404f, 
    -0.06795945f, 0.00946097f, 0.11389359f, -0.30902860f, 0.11234806f, 0.12990639f, -0.05806786f, 0.14596932f, 
    -0.90350318f, 0.16609514f, 0.51604187f, 0.71105349f, -0.02424694f, -0.06295279f, -0.07293373f, 0.00197562f, 
    -0.06980830f, 0.24138564f, -0.16686523f, -0.00566661f, 0.14440173f, 0.25461790f, 0.05820628f, 0.07262862f, 
    -0.01941144f, -0.05283771f, -0.24900375f, 0.08706194f, -0.09313335f, -0.24146548f, 0.15934049f, 0.16332054f, 
    -0.07338138f, -0.06775767f, 0.02634109f, -0.17117435f, 0.01950712f, 0.14608689f, -0.07033687f, -0.04845548f, 
    -0.09392486f, -0.13615361f, -0.10722426f, -0.05548559f, -0.64207721f, -0.76668131f, -0.30492061f, -0.43962014f, 
    -0.14434066f, 0.01534585f, -0.25954863f, -0.52737951f, 0.07088599f, -0.10843667f, 0.00781207f, 0.00932737f, 
    -0.66627306f, -0.75903356f, -0.64727402f, 0.11161659f, -0.16391677f, -0.23598832f, -0.14203119f, -0.52949184f, 
    -0.01705558f, -0.00447307f, -0.08976323f, -0.01520418f, -0.37935707f, 0.23720534f, 0.32783970f, -0.40155587f, 
    -0.10845901f, -0.00258259f, -0.11368182f, 0.05620781f, -0.00660774f, 0.08348852f, 0.10072624f, 0.20712987f, 
    -0.03355373f, -0.00697747f, 0.02260751f, 0.00000639f, 0.02799886f, -0.22908847f, 0.23306890f, 0.23126207f, 
    -0.08344478f, -0.13661128f, 0.20256767f, -0.26454762f, -0.90905875f, -0.23714095f, -0.79586822f, -0.17036791f, 
    -0.21192159f, -0.09841029f, -0.18214597f, -0.14742926f, 0.03822651f, -0.09971651f, -0.01026924f, 0.00765822f, 
    0.66407889f, -0.21678135f, 0.01640673f, -0.36854959f, 0.05786171f, -0.00633307f, -0.04479628f, -0.03690372f, 
    -0.12236787f, -0.06402631f, -0.02274322f, -0.27862957f, 0.18932861f, -0.16093037f, 0.04311712f, -0.05483853f, 
    0.08607757f, 0.06768686f, -0.04248904f, 0.03038347f, -0.04495477f, 0.13543314f, -0.20580135f, 0.24730034f, 
    -0.00139477f, -0.04053783f, -0.11235821f, 0.00906007f, -0.02069533f, -0.07565092f, -0.04922762f, -0.01056094f, 
    0.21783307f, 0.01427859f, 0.13867000f, 0.06301470f, 0.25074455f, -0.05113919f, 0.00554659f, 0.07232428f, 
    -0.18330675f, -0.30986527f, -0.33744156f, -0.11733404f, 0.03091858f, 0.08332814f, 0.08097262f, -0.01926217f, 
    -0.70280975f, -0.13811183f, -0.31033620f, 0.31440052f, -0.16056375f, -0.02613117f, 0.11983655f, -0.11006921f, 
    -0.04417759f, 0.09309991f, 0.06269779f, -0.00168874f, -0.40946388f, -0.26880047f, 0.27803499f, 0.55659610f, 
    -0.06318647f, 0.09423533f, -0.12373874f, 0.07809366f, -0.06577495f, -0.19850753f, -0.18969253f, 0.02569899f, 
    0.11211223f, -0.05192197f, -0.20400655f, -0.02909241f, 0.04994274f, 0.03830446f, -0.01965424f, -0.12509918f, 
    -0.15105772f, 0.12861626f, -0.28603426f, -0.10241534f, 0.09494217f, 0.04969072f, -0.06796296f, -0.23126261f, 
    -0.02555317f, -0.07172914f, -0.09584593f, 0.00803370f, 0.14484999f, 0.06907099f, 0.03975227f, -0.01756002f, 
    -0.54288667f, -0.20276153f, -0.55650866f, 0.24188444f, 0.43301764f, 0.03164676f, -0.02147410f, 0.06193607f, 
    0.06384792f, -0.00687022f, -0.04564277f, -0.01976889f, 0.34584394f, 0.00779863f, -0.18391947f, -0.08394679f, 
    0.03323580f, -0.00341899f, 0.04235512f, -0.08316321f, -0.00948446f, 0.01573463f, -0.24175151f, -0.23852278f, 
    -0.20672701f, -0.17255840f, 0.13995847f, 0.04283376f, -0.00911226f, 0.02628432f, 0.23510502f, -0.07710898f, 
    -0.32028696f, -0.05966261f, -0.05405417f, 0.06058647f, -0.13699268f, -0.02200138f, 0.09275796f, 0.21363236f, 
    0.14358665f, -0.23936260f, 0.20950340f, 0.11065055f, -0.06645895f, 0.02050557f, 0.06118136f, -0.21810035f, 
    -0.16222867f, 0.04034789f, -0.01224128f, 0.01324354f, -0.01285018f, -0.00836522f, 0.06528509f, -0.17848442f, 
    0.01094724f, -0.03673501f, 0.05517900f, -0.04348245f, 0.14333799f, -0.14041151f, 0.11301433f, -0.07293806f, 
    0.04664655f, -0.06108861f, -0.08194199f, -0.00572732f, -0.12349778f, -0.06014679f, -0.06860925f, -0.11870451f, 
    0.10307681f, 0.09107025f, -0.01010787f, -0.10544962f, -0.47426632f, -0.12135033f, 0.03333985f, 0.12120711f, 
    -0.06647964f, 0.00811197f, 0.04288374f, -0.05003013f, -0.07831416f, -0.09944052f, 0.12017002f, -0.12578002f, 
    0.00955364f, -0.04755137f, -0.00723995f, -0.05592266f, -0.11289258f, -0.26322287f, 0.06127418f, -0.14852326f, 
    0.16473760f, 0.00970621f, -0.16382377f, -0.24585898f, 0.01226605f, 0.07747372f, -0.01896176f, 0.02962864f, 
    0.12514597f, 0.09543828f, 0.12601176f, 0.01720016f, -0.01373208f, 0.00879885f, 0.05897736f, -0.11606307f, 
    0.00770974f, 0.03514165f, 0.01269537f, -0.05402396f, -0.02610266f, -0.00631030f, -0.00639871f, -0.01054781f, 
    -0.09926806f, -0.12939198f, 0.23953061f, 0.05153599f, -0.03276119f, 0.03801154f, -0.14789018f, -0.15572622f, 
    0.02423869f, -0.10403301f, -0.10695691f, -0.00997156f, 0.56869930f, -0.87896895f, -0.18216294f, -0.35313797f, 
    -0.01510945f, -0.18674833f, -0.20518951f, 0.10224360f, 0.18594243f, -0.06264253f, -0.03496513f, 0.08917050f, 
    0.34931633f, -0.39460328f, 0.11666019f, -0.49834862f, 0.11602383f, 0.03956956f, -0.17325427f, 0.06009421f, 
    0.02382939f, 0.05290501f, 0.04356083f, 0.07281867f, -0.73268956f, -0.17797272f, -0.67136896f, -0.38564533f, 
    0.07142258f, -0.06058038f, 0.27255410f, 0.04825959f, 0.04890626f, 0.00156641f, 0.05540727f, 0.09508613f, 
    -0.39873987f, -0.03442845f, -0.25319433f, -0.11691264f, -0.02166254f, 0.04472413f, 0.17061058f, -0.08309506f, 
    0.08763423f, 0.05907198f, 0.05557316f, 0.03206174f, -0.01220967f, -0.20439844f, -0.65430260f, -0.28802040f, 
    -0.00885883f, -0.11964784f, -0.01244975f, 0.21263731f, 0.15971905f, -0.10394696f, 0.08052914f, -0.03566648f, 
    0.50531322f, -1.01946533f, -0.74703115f, -0.61326146f, 0.00570579f, -0.18915604f, -0.03082823f, 0.01129046f, 
    0.15845212f, 0.10121465f, 0.13303497f, 0.01010489f, 0.07864521f, -0.10053553f, -0.04081211f, -0.11095846f, 
    0.01167538f, 0.05479577f, -0.02863219f, 0.04344241f, -0.00335233f, -0.03016224f, 0.07964613f, 0.09975866f, 
    -0.00967218f, 0.03097954f, -0.01408916f, -0.02663784f, 0.09873189f, 0.05260161f, -0.01417716f, -0.10460866f, 
    0.08341192f, 0.03889925f, 0.00189084f, -0.01750621f, -0.68979400f, -0.34993029f, -0.14363357f, 0.83072370f, 
    0.10190228f, 0.10415004f, 0.13019983f, 0.06296112f, 0.07576646f, -0.04334286f, 0.00721344f, 0.05701857f, 
    -0.54394317f, -0.68846929f, 0.14991388f, -0.01845103f, -0.08545470f, -0.04467844f, 0.02460049f, 0.22275585f, 
    -0.02117222f, -0.01152669f, -0.07345307f, 0.01826903f, 0.38884076f, 0.37181461f, -0.41744831f, -0.03987846f, 
    0.11639319f, 0.05156723f, 0.00393072f, -0.09976941f, -0.16212867f, 0.04376841f, 0.14826207f, -0.11520585f, 
    0.04861590f, 0.31329384f, -0.16325049f, 0.26682046f, 0.15628101f, -0.36314666f, 0.07309113f, -0.11673468f, 
    -0.00129807f, -0.00718773f, -0.09161057f, -0.03253144f, -0.89961350f, -0.73948729f, 0.12789284f, 0.33346632f, 
    -0.11455671f, -0.02827517f, 0.28239965f, 0.12725702f, -0.01653823f, 0.04814709f, 0.00582787f, -0.00443450f, 
    0.12824416f, -0.05888458f, -0.36902004f, -0.47309685f, 0.05445453f, -0.06089510f, 0.06307153f, 0.01232960f, 
    0.27136216f, 0.14075735f, 0.13062617f, 0.00522580f, 0.28911772f, -0.04060775f, -0.04477510f, 0.04077794f, 
    0.10186926f, 0.15199114f, 0.09250792f, -0.10971091f, -0.08404825f, -0.27169707f, 0.00103501f, -0.58932823f, 
    -0.48573032f, -0.11577629f, 0.05792067f, -0.09315500f, -0.05961480f, -0.00750286f, -0.08045752f, -0.11233314f, 
    -0.15187417f, -0.16594665f, -0.36482322f, -0.74658436f, 0.10335319f, -0.23554297f, -0.18687266f, -0.14538053f, 
    0.27700451f, 0.00730930f, -0.07626914f, -0.05680846f, -0.06900974f, 0.04644232f, 0.10578183f, 0.17286921f, 
    -0.78339279f, -0.07168709f, 0.09851206f, 0.23404668f, 0.04919173f, 0.06738134f, 0.10616188f, 0.04846028f, 
    -0.11294891f, -0.07551356f, 0.24164599f, 0.14988790f, 0.37962452f, -0.40020701f, -0.64397943f, -0.54923958f, 
    -0.14202504f, -0.27827257f, 0.12290875f, -0.15325047f, 0.00207632f, 0.14419493f, 0.03138348f, 0.02667790f, 
    0.44619772f, 0.03271887f, 0.04445001f, -0.12132310f, 0.01629968f, -0.10300278f, -0.04581260f, 0.05795497f, 
    0.28451696f, -0.14036091f, 0.40793443f, -0.15466201f, 0.03367359f, 0.01786752f, 0.12139659f, 0.07390276f, 
    -0.01800957f, -0.09806187f, -0.01022247f, -0.11987065f, -0.21217535f, -0.04476541f, -0.19329394f, -0.04980170f, 
    0.02197287f, -0.43892387f, -0.46589184f, 0.10728174f, -0.01860881f, -0.07146906f, 0.12946256f, 0.30378875f, 
    -0.15360719f, -0.11453812f, -0.04073406f, -0.07231388f, 0.19690478f, -0.07330833f, -0.42286584f, -0.19696325f, 
    -0.07996638f, -0.08334458f, 0.08136769f, -0.16961372f, 0.24300072f, -0.05291969f, 0.12799485f, -0.15877627f, 
    -0.44326133f, -0.31428435f, 0.20497474f, 0.19375591f, -0.00316710f, 0.14903043f, 0.11116402f, -0.17740281f, 
    0.11358243f, 0.20007512f, 0.11766787f, 0.23184419f, 0.21528240f, -0.31603795f, -0.39031821f, 0.00164112f, 
    -0.27410141f, 0.09671079f, 0.00404597f, -0.23730859f, 0.03545345f, -0.04061959f, -0.00765508f, -0.11325523f, 
    -0.38502342f, 0.07375343f, 0.02178679f, 0.10944595f, 0.05300582f, -0.06589721f, 0.02468403f, 0.00594554f, 
    0.11037005f, -0.06589065f, -0.01752128f, 0.01558916f, 0.05409127f, -0.15331459f, 0.03075994f, -0.18101950f, 
    -0.08275870f, -0.07450083f, -0.04656889f, -0.05723126f, -0.11618308f, -0.08794055f, -0.14896508f, -0.16470633f, 
    0.04816214f, -0.00491867f, -0.15077116f, -0.05032111f, -0.12052798f, -0.01468411f, -0.04557773f, 0.08490094f, 
    0.14864516f, 0.10856374f, 0.23254628f, 0.23079796f, -0.41858062f, -0.04480184f, 0.18088886f, 0.01936885f, 
    -0.04521212f, 0.09874503f, 0.10864082f, 0.05580504f, 0.08570039f, 0.10460384f, 0.08449560f, 0.22991282f, 
    -0.10969063f, -0.49196181f, -0.65305203f, -0.02712066f, -0.01199177f, 0.06486312f, 0.01620638f, 0.11057568f, 
    -0.06887449f, 0.04151298f, -0.21294363f, -0.06928194f, -0.02629146f, 0.00883753f, -0.01091311f, -0.02530961f, 
    -0.10771507f, -0.06858658f, -0.00644877f, -0.04020251f, 0.03334584f, 0.01477259f, 0.07213575f, 0.01689437f, 
    0.40534106f, 0.57013571f, 0.10833535f, -0.26366735f, 0.14769624f, 0.04209964f, 0.04233446f, 0.09765045f, 
    0.04071981f, -0.04293842f, 0.18133083f, -0.04252462f, 0.10411028f, -0.16169578f, -0.13781583f, 0.14542639f, 
    0.14246979f, 0.10700038f, 0.17040600f, 0.10085499f, -0.11176048f, -0.11453801f, -0.05672013f, -0.38266331f, 
    0.42010364f, 0.49640837f, 0.30806294f, -0.05603032f, 0.02062041f, -0.01153991f, -0.06723404f, 0.01427499f, 
    -0.08850963f, 0.07349516f, 0.00819844f, 0.18533041f, -0.25541431f, -0.81140149f, -0.14528388f, 0.35500005f, 
    -0.11226179f, 0.34076944f, 0.15731770f, 0.00728791f, 0.06283474f, -0.04730313f, 0.15503833f, 0.15640672f, 
    -0.29403871f, -0.38304386f, 0.11962119f, 0.23991621f, 0.10161519f, 0.15615837f, -0.01123131f, 0.22041298f, 
    -0.30699357f, 0.03870486f, -0.15575439f, -0.07866874f, 0.18742248f, 0.01257123f, -0.27256134f, 0.07769454f, 
    0.00719054f, 0.13963917f, 0.06684434f, 0.19931293f, -0.33078992f, 0.06275994f, -0.18929775f, -0.47158265f, 
    -0.69692385f, -0.65011495f, -0.50168222f, 0.48988113f, 0.11000733f, 0.14978449f, 0.23258561f, 0.11459927f, 
    0.12508531f, 0.06067069f, 0.08858456f, 0.13184759f, -0.23987079f, -0.24610679f, -0.23993142f, -0.13306041f, 
    0.03526388f, 0.09336460f, 0.08852518f, 0.10431968f, -0.02511205f, -0.07959919f, -0.04743776f, -0.05779902f, 
    -0.40750441f, 0.09837923f, 0.11996904f, -0.09689332f, -0.03111679f, -0.02177508f, -0.14474235f, -0.02450043f, 
    -0.08476520f, -0.14040866f, -0.03199108f, 0.02543102f, 0.17364518f, -0.41942671f, -0.26999745f, -0.20979272f, 
    0.02861182f, 0.04292748f, -0.07078650f, 0.15764293f, 0.02679723f, 0.06799394f, 0.00751132f, 0.07025123f, 
    -0.15335219f, -0.57381707f, -0.69797677f, -0.12451493f, -0.25462645f, -0.28353775f, -0.05839019f, -0.23973870f, 
    0.00764355f, -0.04154327f, 0.08053215f, 0.01708861f, 0.18018197f, -0.05100581f, -0.53746700f, -0.46883428f, 
    0.03522651f, 0.09927015f, -0.00874788f, 0.10276625f, 0.19273783f, 0.11117952f, 0.09603961f, 0.24257833f, 
    0.05079566f, -0.19741894f, -0.34891883f, -0.32728046f, 0.15887871f, -0.09474379f, -0.00985624f, -0.08658013f, 
    0.08128480f, 0.18238302f, 0.22998181f, 0.20916136f, 0.36816895f, -0.77360642f, -0.21283229f, 0.10660020f, 
    0.10576963f, -0.06641844f, -0.09275489f, -0.01251225f, 0.07394145f, 0.04207212f, 0.00370734f, 0.08078816f, 
    -0.07542003f, 0.40699691f, 0.50315231f, 0.36210471f, 0.02687636f, -0.07165357f, -0.18365239f, -0.21333952f, 
    0.02811211f, -0.01250802f, 0.06322113f, -0.22337124f, 0.17935342f, 0.03146628f, 0.01938265f, -0.13550252f, 
    -0.13795950f, -0.11633579f, -0.03618532f, 0.15716191f, 0.16431287f, 0.19447051f, -0.00840679f, 0.13467045f, 
    0.05298879f, -0.02671566f, 0.13753480f, 0.05227815f, 0.12569056f, 0.05476816f, 0.17037144f, 0.01536808f, 
    0.10964920f, 0.05493133f, 0.29183903f, 0.30117169f, -0.03208872f, 0.02296019f, -0.07306030f, -0.05994016f, 
    -0.02663701f, 0.01105827f, -0.04655050f, 0.07553439f, 0.04890007f, -0.09716401f, -0.01887232f, 0.02181014f, 
    -0.28118241f, 0.43837970f, 0.79729414f, -0.74336147f, 0.21770345f, -0.50038493f, 0.17577314f, -0.22674136f, 
    -0.21345489f, 0.16217566f, 0.14390630f, 0.07419011f, -0.25722530f, -0.12921458f, -0.03764352f, 0.10684998f, 
    -0.13773628f, 0.03814600f, 0.08485065f, 0.03130190f, 0.09011402f, 0.19477257f, 0.10251655f, -0.09571216f, 
    0.07827780f, 0.03651286f, 0.14622764f, 0.25714809f, 0.11499108f, 0.01065146f, -0.04176208f, 0.01397871f, 
    -0.21928070f, 0.07938123f, 0.06846136f, -0.07176872f, 0.20756873f, -0.33129475f, -0.30830368f, -0.01572012f, 
    0.13386969f, 0.27067479f, 0.24870610f, 0.06284429f, -0.03140352f, -0.00303586f, 0.00230498f, -0.08344977f, 
    -0.50343716f, -0.00222536f, -0.17993444f, -0.00517854f, -0.17924459f, -0.20807737f, -0.08568770f, 0.16670048f, 
    0.06101405f, -0.02937484f, 0.05339978f, 0.03300731f, -0.13696609f, -0.06169771f, 0.30486169f, 0.55754054f, 
    0.09695770f, -0.01648113f, -0.17923169f, -0.27604085f, 0.07294782f, 0.07082835f, -0.02728651f, -0.17896810f, 
    0.16031474f, -0.38585883f, 0.43536028f, -0.57169437f, 0.07263146f, -0.31581166f, -0.06605066f, -0.13806926f, 
    -0.26786056f, 0.00091494f, -0.07143182f, 0.00615073f, -0.28799021f, -0.30436453f, 0.17344041f, -0.00041989f, 
    0.20516698f, -0.01935681f, -0.28390777f, 0.31962448f, 0.01429921f, 0.15285219f, 0.03455868f, 0.05174788f, 
    -0.07839207f, -0.03207128f, -0.25894049f, -0.11642098f, 0.14790732f, -0.17271404f, 0.18127982f, -0.18631738f, 
    -0.14301856f, 0.06483120f, -0.10750082f, -0.24643038f, 0.20965061f, -0.36032233f, 0.17789167f, 0.09437304f, 
    -0.18968670f, 0.07926593f, -0.27577943f, -0.05048751f, -0.10332958f, 0.10123085f, 0.15918994f, 0.06476974f, 
    -0.03266748f, -0.20414095f, 0.10411868f, 0.03437054f, 0.23112762f, 0.27696183f, -0.18565492f, 0.06146768f, 
    -0.08604956f, -0.15700388f, 0.02634598f, -0.05140814f, 0.18267697f, 0.04922831f, 0.27426997f, -0.36285222f, 
    0.02486543f, -0.04690775f, -0.09037790f, -0.17148286f, 0.16086937f, 0.10788397f, -0.21883926f, -0.08029225f, 
    0.14766134f, 0.20010641f, 0.03444844f, 0.32145283f, -0.03227946f, -0.21122144f, -0.35436720f, -0.07748996f, 
    -0.01829315f, -0.00354849f, -0.07683747f, -0.00710260f, 0.10808460f, -0.25459114f, 0.00026621f, -0.16723479f, 
    0.19199219f, 0.18111494f, 0.14568989f, 0.02972329f, 0.06882735f, -0.03665981f, -0.02059798f, -0.02497976f, 
    -0.25983518f, 0.06960005f, -0.87107962f, 0.17706180f, 0.08184718f, -0.01731387f, 0.04849292f, -0.10601703f, 
    0.10073578f, -0.19064872f, -0.04826503f, -0.08570996f, 0.07618751f, -0.02020655f, 0.26712653f, 0.14580825f, 
    -0.09201007f, -0.07140778f, -0.21946473f, -0.17932172f, 0.01776297f, -0.02578428f, 0.20460039f, 0.20872824f, 
    -0.11111100f, -1.17459297f, 0.35309964f, -0.44818297f, -0.11832315f, 0.24183543f, -0.32909068f, 0.18634890f, 
    -0.02954931f, -0.05398348f, 0.03214726f, 0.00173542f, 0.28340033f, -0.52063847f, 0.06780732f, -0.51000881f, 
    -0.07447789f, -0.31143090f, -0.03427086f, 0.13961092f, -0.14017047f, -0.00049675f, 0.04059191f, -0.00859751f, 
    -0.01206525f, 0.49413422f, -0.02665960f, -0.49941018f, -0.12044043f, -0.25507867f, 0.14076626f, -0.12161061f, 
    0.07907184f, 0.04364660f, 0.03312936f, -0.03777567f, -0.46465275f, 0.09149995f, -0.12160952f, -0.29629672f, 
    -0.03512892f, 0.05772177f, -0.10006806f, -0.01792562f, 0.00064200f, -0.03687198f, 0.07737086f, 0.23364958f, 
    0.41043863f, -0.08519510f, 0.26389569f, -0.38349625f, 0.05278063f, -0.21056019f, -0.15842184f, -0.13898331f, 
    -0.00688011f, 0.04560092f, -0.02615033f, 0.04611044f, 0.22186224f, 0.29509860f, 0.17217371f, -0.41963625f, 
    -0.13370055f, -0.08532321f, -0.14505769f, -0.36691466f, 0.06308685f, -0.00636570f, 0.04610723f, 0.08879615f, 
    -0.21442044f, -0.04632084f, -0.23149198f, -0.02141993f, 0.18549812f, 0.09877410f, 0.22056022f, 0.14511116f, 
    0.15786584f, 0.08850904f, 0.02444167f, 0.03139520f, 0.29151380f, -0.02454967f, -0.12600552f, -0.25015613f, 
    0.06910712f, -0.10581938f, 0.07589852f, 0.14914113f, -0.02759807f, 0.06993140f, -0.03104852f, -0.07545760f, 
    -0.66950768f, -0.10810107f, 0.27979094f, -0.38263100f, -0.28363565f, -0.20469183f, 0.05324058f, 0.38730949f, 
    0.06345027f, 0.10386726f, 0.09926467f, -0.03231393f, -0.21366912f, 0.25782114f, 0.15223883f, 0.71666503f, 
    0.30426192f, -0.27615786f, -0.31775892f, -0.07737000f, 0.08104521f, -0.22906564f, 0.03754395f, -0.02726663f, 
    -0.54911751f, -0.07585385f, 0.16233060f, -0.07587232f, 0.17160994f, -0.17271285f, -0.05886774f, -0.29294619f, 
    0.00096976f, -0.23544896f, -0.03852938f, -0.13439538f, 0.03783678f, -0.22892779f, -0.02815834f, -0.15053344f, 
    0.17675334f, -0.22218516f, 0.01582625f, 0.16530061f, -0.12957035f, -0.00230879f, 0.01453661f, -0.02500704f, 
    -0.06106944f, 0.06561573f, 0.09606922f, -0.24704580f, -0.13319933f, 0.09451173f, -0.03292608f, 0.11253481f, 
    -0.03205941f, 0.01156734f, 0.03107166f, -0.23303413f, -0.35489234f, 0.44906959f, -0.31348741f, -0.42690790f, 
    0.01344388f, 0.41613990f, -0.38867277f, 0.03355838f, -0.03056580f, -0.09173109f, -0.46067810f, -0.40918157f, 
    -0.00255123f, 0.21200053f, 0.09892655f, -0.22428320f, -0.11489379f, -0.00895036f, -0.07535269f, 0.00195433f, 
    -0.06697805f, -0.21001524f, -0.35337088f, -0.47293943f, -0.25723130f, 0.21167679f, -0.07691299f, 0.00993762f, 
    -0.08062993f, 0.12085616f, 0.04608259f, 0.02514836f, -0.14780761f, 0.18888511f, 0.12138468f, 0.23556551f, 
    0.01081563f, -0.05035296f, 0.22530898f, -0.12961477f, -0.10397667f, 0.06952317f, 0.00700403f, 0.07607477f, 
    0.02912664f, -0.04507880f, 0.12537721f, -0.20856498f, -0.17102827f, -0.39360189f, -0.43230698f, -0.03199009f, 
    -0.01629795f, -0.01362516f, -0.02560306f, -0.08926041f, 0.06630914f, 0.16534238f, -0.01508860f, -0.04491226f, 
    -0.24397591f, 0.35992134f, 0.18115853f, -0.05469538f, 0.02993589f, 0.01891610f, -0.08309919f, 0.12067527f, 
    0.40735111f, -0.08594936f, 0.42350170f, -0.07202680f, -0.48592091f, -0.01652540f, -0.13552284f, 0.07665187f, 
    -0.19533476f, -0.28341264f, -0.20449553f, 0.06781551f, 0.03463997f, 0.10275542f, -0.03201764f, -0.14956634f, 
    -0.12515286f, -0.74998075f, 0.32497567f, 0.02749520f, -0.09315301f, 0.07757066f, -0.08392856f, 0.29009682f, 
    -0.30057758f, 0.09412363f, -0.04495356f, 0.04217236f, -0.71045864f, -0.00105504f, 0.43818745f, -0.31203932f, 
    -0.11423927f, 0.21882422f, -0.23959978f, 0.12447125f, -0.05581156f, -0.23785241f, -0.20896980f, -0.11134580f, 
    -0.35210797f, 0.48597291f, -0.23465566f, 0.21378964f, 0.06359281f, -0.09506039f, -0.13999519f, 0.38909411f, 
    -0.09603903f, 0.06799508f, 0.08576834f, -0.08055292f, -0.33063015f, 0.02376066f, 0.23856388f, -0.14646660f, 
    0.05910886f, 0.14734371f, -0.41547784f, 0.02383053f, -0.19590798f, -0.30168134f, 0.01198178f, -0.10741473f, 
    0.22308689f, -0.04017523f, -0.18298814f, 0.35550004f, -0.12026184f, -0.00158532f, 0.14053792f, -0.12803514f, 
    0.08510535f, 0.05175427f, -0.00161002f, 0.00114361f, -0.04915183f, 0.47786590f, 0.28782097f, 0.07351939f, 
    -0.01070909f, 0.30447462f, -0.18395427f, 0.01206947f, -0.03440077f, 0.06901664f, -0.21442862f, -0.18334602f, 
    0.07811835f, -0.05572722f, 0.28555229f, 0.10051226f, -0.03848878f, -0.03111101f, 0.05222816f, 0.03717189f, 
    0.13728730f, 0.23382038f, -0.13221383f, 0.35270834f, -0.20475174f, 0.31270525f, 0.14860581f, 0.26713845f, 
    -0.14799632f, 0.00707568f, 0.33448491f, -0.01201116f, -0.06426044f, -0.12907425f, 0.23510543f, 0.17876123f, 
    0.16347516f, 0.57792354f, 0.11547443f, 0.33566174f, 0.06312177f, -0.14155038f, 0.01281389f, -0.06371030f, 
    -0.04404802f, 0.26051793f, 0.03551235f, 0.01334104f, -0.23910126f, -0.42990816f, -0.22679497f, -0.22353061f, 
    -0.23261669f, 0.05214116f, -0.13665490f, -0.15690742f, -0.05283081f, 0.10415523f, 0.19333118f, -0.22055939f, 
    -0.24162276f, -0.10783553f, -0.03876935f, -0.19462605f, -0.09195407f, 0.05444751f, 0.29667485f, -0.03810166f, 
    -0.29479319f, -0.20267197f, -0.25670069f, 0.02204141f, -0.35758674f, 0.21828103f, -0.09715766f, -0.18068650f, 
    0.03928289f, -0.08824710f, -0.02875733f, 0.09434717f, -0.08276405f, 0.14450040f, -0.02728337f, -0.52284038f, 
    -0.14230864f, -0.32956809f, -0.39759389f, 0.40433922f, 0.02070352f, 0.16652152f, -0.19042327f, -0.17409939f, 
    0.01611267f, -0.03005894f, -0.16670208f, 0.02376909f, 0.06792571f, 0.04875576f, -0.15890200f, 0.34614986f, 
    -0.12607481f, 0.00681799f, -0.08270412f, 0.12275964f, 0.28016204f, 0.19445767f, -0.07043761f, 0.03399711f, 
    0.35109410f, -0.16430649f, -0.02338299f, 0.38605341f, -0.06902624f, -0.14891979f, 0.16349234f, -0.10259450f, 
    -0.06552731f, -0.00239282f, -0.00401070f, -0.00088530f, 0.82198042f, -0.73137629f, 0.13088760f, 0.12042768f, 
    0.05963576f, 0.10858055f, -0.04796904f, 0.07422698f, -0.31507355f, -0.13320683f, -0.65063089f, -0.55908668f, 
    0.23903757f, -0.01489313f, 0.07932010f, -0.10951451f, -0.11158706f, -0.01263537f, 0.03933227f, 0.00947670f, 
    0.05985569f, -0.04457958f, 0.07482490f, -0.27432269f, -0.38034105f, 0.16199775f, -0.16348392f, 0.20021170f, 
    0.10319567f, -0.18921855f, 0.10124861f, -0.06499691f, -0.08040387f, 0.22775085f, -0.05282238f, -0.29052413f, 
    -0.02606415f, -0.34444195f, -0.42984569f, -0.68554699f, -0.40671712f, -0.29945779f, -0.03398848f, -0.16357686f, 
    -0.06711978f, 0.19484736f, -0.14530997f, -0.05140456f, -0.33025768f, -0.07594018f, -0.16572970f, 0.20356776f, 
    0.10848151f, -0.11070874f, 0.11082557f, -0.00503110f, 0.05686035f, 0.15223178f, 0.05848115f, -0.10355395f, 
    -0.13652225f, -0.44979355f, -0.21300070f, -0.01882789f, -0.14540118f, -0.12149207f, -0.12559187f, 0.03821461f, 
    0.07633040f, 0.15733221f, 0.10309318f, 0.01797233f, 0.02868460f, 0.41500604f, 0.20802762f, -0.10870740f, 
    -0.31968674f, -0.03081445f, -0.09199812f, 0.21944535f, 0.18103750f, -0.08996969f, 0.18669364f, 0.02380126f, 
    0.26322371f, -0.03295470f, 0.23239212f, 0.46386987f, -0.17576483f, 0.18522191f, 0.32387403f, 0.12997693f, 
    0.11425907f, 0.09370655f, 0.15451193f, 0.20493516f, -0.61871845f, 0.31236023f, -0.00241567f, 0.38725919f, 
    0.14269285f, 0.00650655f, -0.31529522f, 0.32816243f, -0.09810681f, 0.00856917f, -0.02985666f, 0.11656401f, 
    -0.54350555f, -0.23540446f, -0.20633918f, -0.07791545f, 0.24973269f, -0.07547168f, 0.00523828f, -0.05829829f, 
    -0.10524807f, -0.10748699f, 0.17078285f, -0.13417481f, 0.21007001f, -0.25945580f, 0.13032386f, 0.09536149f, 
    0.11969460f, -0.38209841f, 0.06860846f, 0.38997835f, 0.13059764f, 0.15407126f, 0.06641941f, 0.30308053f, 
    0.19679222f, -0.01334325f, 0.04706269f, -0.07056142f, 0.00755190f, 0.15886773f, -0.15569702f, 0.03684544f, 
    0.22757232f, 0.10814966f, 0.16773194f, 0.20165190f, -0.10353970f, 0.13761994f, 0.09762481f, -0.10466856f, 
    0.04278785f, 0.17437546f, 0.04799949f, 0.04728016f, -0.10214362f, -0.14991575f, -0.25480297f, -0.43588048f, 
    0.21369922f, -0.49517536f, 0.46758580f, 0.08812137f, 0.07282662f, 0.19203457f, -0.03320266f, 0.32941657f, 
    -0.12344773f, 0.21897963f, 0.03263538f, -0.05270339f, -0.49539265f, -0.58362502f, 0.05917614f, 0.14374502f, 
    -0.12856412f, -0.06398649f, -0.05222948f, -0.26130521f, 0.06027586f, 0.11803971f, 0.05949181f, 0.03689036f, 
    0.05405195f, -0.22225788f, 0.02404953f, -0.13370284f, 0.07829086f, -0.02074094f, 0.12339903f, -0.09584793f, 
    0.03203563f, 0.01999017f, -0.06767438f, 0.16271348f, 0.67362446f, 0.39044273f, 0.40942273f, 0.12240752f, 
    -0.16293737f, -0.07077692f, -0.02435461f, 0.07918237f, 0.00036980f, 0.04903124f, -0.02958840f, 0.03978742f, 
    0.19676204f, 0.04660872f, 0.66674709f, -0.46847865f, -0.12808205f, -0.04289294f, -0.11214092f, -0.11204241f, 
    0.07311528f, 0.03993615f, -0.13672541f, -0.16256385f, -0.28747085f, -0.06057518f, 0.07358555f, -0.13309687f, 
    0.10383129f, 0.39531836f, -0.00788666f, 0.04142701f, 0.17147808f, 0.17688711f, 0.19185492f, 0.15093793f, 
    -0.62330914f, -0.32987523f, -0.11328921f, 0.29291174f, 0.10181909f, 0.21561687f, -0.01822332f, 0.37346622f, 
    -0.23653767f, -0.09522285f, -0.04761566f, -0.02840464f, -0.79157603f, 0.33563012f, -0.02322845f, 0.38765225f, 
    0.01607262f, 0.27390629f, 0.24303392f, 0.19259664f, -0.09175368f, 0.15372708f, 0.07713959f, 0.08915666f, 
    0.29614246f, -0.07497389f, 0.47021931f, -0.09977355f, -0.16396880f, 0.01449811f, -0.22802511f, 0.39327177f, 
    -0.08771116f, 0.09027436f, -0.02526595f, -0.21308964f, -0.49990851f, 0.42908219f, -0.55107605f, 0.22892304f, 
    0.01064392f, -0.16963920f, 0.26422757f, -0.09042840f, 0.23769136f, -0.00843066f, 0.12958857f, 0.37148339f, 
    -0.24892445f, 0.14025073f, -0.27874956f, 0.13721406f, 0.21055897f, -0.06850563f, -0.01565327f, -0.04526536f, 
    -0.04662117f, -0.13436289f, -0.12207831f, -0.24667200f, -0.05806921f, -0.02612692f, -0.14887266f, 0.44887644f, 
    -0.07722606f, 0.18595228f, -0.08184259f, 0.13620147f, -0.06197415f, -0.02235408f, 0.12955336f, -0.11482218f, 
    -0.47004282f, -0.32466277f, 0.16830121f, 0.22574653f, 0.00395014f, -0.12004466f, -0.07426081f, 0.06210382f, 
    -0.16436766f, -0.12523843f, -0.01451809f, -0.07514088f, 0.30388245f, 0.34339070f, -0.00964486f, -0.19610877f, 
    -0.08122707f, 0.06156318f, -0.06957728f, 0.00285035f, 0.00280267f, -0.06814177f, -0.09169170f, 0.00958513f, 
    0.69081813f, 0.18638504f, 0.02975134f, 0.32618955f, 0.06677659f, -0.15189673f, -0.00798811f, -0.01137716f, 
    -0.17969681f, 0.03850592f, 0.12490723f, 0.03683457f, 0.14259171f, 0.05842718f, -0.08293956f, -0.30330756f, 
    -0.04178993f, -0.17766716f, 0.11355840f, -0.01753049f, -0.03536262f, -0.01548772f, 0.13548197f, 0.20742542f, 
    -0.92606229f, 0.32629400f, -0.37516066f, 0.15603630f, 0.14440414f, -0.06621766f, 0.26962599f, -0.23846407f, 
    0.04878190f, -0.00637296f, 0.03526300f, -0.02905433f, -0.04902926f, -0.07144801f, 0.17388573f, -0.53638572f, 
    -0.12864718f, -0.00882609f, -0.04584109f, 0.00082864f, -0.11409940f, 0.05635213f, 0.07035899f, -0.03674071f, 
    -0.17691544f, -0.18153022f, 0.55592400f, 0.25407630f, -0.12777647f, 0.12877266f, 0.02157618f, -0.02982786f, 
    -0.01855566f, 0.07708019f, -0.24154423f, -0.02270412f, -0.24041849f, -0.10268515f, -0.03644266f, -0.21884596f, 
    -0.02966348f, -0.09015204f, 0.02949228f, -0.08839501f, 0.14195785f, 0.06929243f, 0.10991207f, -0.00434097f, 
    -0.22957642f, 0.09614528f, -0.31073126f, -0.66112864f, 0.03966748f, -0.23110218f, -0.06968333f, 0.11544959f, 
    -0.25102949f, 0.02228035f, 0.07895915f, -0.05229487f, 0.07129315f, -0.08299623f, 0.18541455f, 0.10375480f, 
    0.04248340f, -0.16700377f, 0.11469771f, -0.17950954f, 0.18625835f, -0.07027350f, -0.33560497f, -0.15577661f, 
    0.36628321f, -0.13847427f, 0.03760890f, -0.23567905f, -0.09141120f, -0.06972986f, -0.09488712f, 0.03796458f, 
    -0.00216153f, 0.00774469f, 0.07340526f, -0.03278741f, -0.24725907f, -0.03928901f, -0.11498520f, 0.21619122f, 
    -0.22786774f, -0.04868273f, 0.01748779f, -0.27886799f, -0.02989988f, -0.01158831f, 0.05134515f, 0.04790670f, 
    -0.12363159f, -0.56372017f, -0.25241187f, -0.15812527f, 0.07210129f, -0.34670460f, -0.05300126f, 0.10361739f, 
    0.07516524f, 0.05659638f, -0.09825045f, -0.06240965f, -0.13879573f, -0.43002900f, -0.19361083f, -0.10228372f, 
    0.13628307f, 0.17129122f, -0.05504304f, 0.08213481f, -0.06008570f, 0.12184449f, 0.08389333f, -0.12624992f, 
    0.30430233f, 0.02446062f, 0.35908726f, -0.52188945f, -0.15433866f, 0.22507228f, -0.55214977f, 0.36640021f, 
    -0.01465550f, -0.14860058f, 0.04266350f, 0.00531977f, -0.26519078f, -0.34560069f, 0.30052850f, -0.04708466f, 
    -0.15757418f, -0.29932234f, -0.10987156f, 0.03438674f, 0.04782295f, -0.10507233f, 0.01011545f, -0.02880416f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18105836f, 0.08759926f, 0.08584766f, -0.11171940f, -0.05350146f, 0.08104238f, 0.04800264f, -0.12671138f, 
    0.10051765f, -0.01576375f, 0.02210523f, 0.04748740f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
