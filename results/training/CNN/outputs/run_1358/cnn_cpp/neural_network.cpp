#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72147965f, -0.73773444f, -0.00094575f, 0.80008399f, 0.08505041f, -0.10561366f, -0.60770077f, -0.54820365f, 
    -0.22487898f, -0.29903233f, -0.16205969f, -0.04758915f, -0.33183575f, 0.08612124f, -0.45920110f, -0.04971173f, 
    -0.07680716f, -0.04134474f, -0.24698575f, -0.19942373f, -0.03033834f, -0.01691861f, -0.10921889f, -0.08848973f, 
    0.18572143f, -0.48796752f, -0.13543490f, -0.59639049f, -0.56212759f, -0.44895697f, 0.45282203f, 0.44183868f, 
    -0.16299540f, -0.16544703f, 0.28452063f, -0.07850771f, 0.38690278f, -0.09550673f, -0.15360805f, -0.08364850f, 
    -0.18019259f, 0.24444228f, -0.14600043f, 0.02116214f, -0.06522621f, -0.11904905f, 0.09380499f, 0.01818613f, 
    -0.37641245f, -0.52759397f, -0.03910130f, -0.30118847f, 0.09044253f, 0.01736975f, -0.03298635f, 0.40341628f, 
    0.17897457f, -0.12885271f, -0.21464553f, 0.22718863f, 0.07190400f, -0.01815769f, -0.08485602f, -0.17208374f, 
    0.13927794f, -0.31002724f, 0.09550866f, -0.09083469f, 0.15774758f, -0.00944302f, 0.27659586f, 0.11629876f, 
    0.15769078f, 0.30489311f, 0.12196501f, 0.47946915f, 0.66166836f, 0.28991371f, -0.33789918f, -0.74296820f, 
    0.69897252f, -0.28698871f, -0.11130706f, -0.28406301f, -0.20494355f, -0.02042403f, -0.31252366f, 0.03869249f, 
    -0.00403426f, 0.17353064f, 0.37613875f, 0.04243229f, 0.24649692f, -0.05822903f, -0.44242325f, -0.28880435f, 
    0.30248562f, -0.38671112f, -0.13103543f, 0.14917605f, 0.65412802f, 0.52653044f, 0.06614458f, -0.77087057f, 
    -0.80348408f, 0.15946107f, 0.26088586f, 0.19660045f, -0.25277063f, 0.06298044f, 0.13565645f, -0.47274938f, 
    0.39277059f, -0.14535888f, 0.01244418f, 0.21930310f, -0.06466781f, -0.23953784f, -0.15033549f, 0.16108489f, 
    -0.21466371f, -0.00412055f, 0.27689248f, 0.17809868f, 0.03873865f, 0.68777019f, -1.06900060f, -0.38612488f, 
    0.72987670f, 0.29976967f, -0.05113060f, 0.73551792f, -0.67472672f, -0.54289031f, -0.06485478f, 0.02894581f, 
    -0.01790649f, 0.00805644f, -0.31809658f, 0.36671397f, -0.17159636f, 0.02319549f, 0.08963884f, 0.04420383f, 
    -0.09652485f, -0.05858139f, -0.30336866f, -0.02421739f, 0.14944056f, -0.04310131f, -0.64425814f, 0.80321449f, 
    0.86106092f, -0.60148394f, -0.15115274f, -0.20342787f, -0.35625625f, 0.03784660f, 0.30249247f, 0.09294945f, 
    -0.15377232f, -0.33863372f, -0.27491096f, -0.08591114f, -0.29667389f, 0.14781921f, 0.06622487f, 0.09032875f, 
    0.29440200f, -0.15427966f, -0.00554195f, 0.00482730f, -0.27908364f, -0.30071679f, -0.37307498f, 0.18819527f, 
    0.72702730f, 0.00488375f, -0.18296377f, -0.22204512f, 0.18131086f, -0.52848417f, -0.31588155f, 0.17056969f, 
    -0.27421278f, -0.12593983f, -0.20232421f, -0.13897094f, -0.14229746f, -0.30825222f, 0.02416293f, -0.02239598f, 
    0.10495713f, 0.28969169f, -0.19575316f, -0.12772408f, -0.27523953f, 0.07986139f, 0.36595756f, 0.14119422f, 
    -0.17301449f, -0.29317680f, -0.26144651f, -0.10826258f, -0.31640983f, -0.42095572f, -0.44160536f, -0.23307590f, 
    -0.14055519f, -0.43302101f, 0.20692275f, 0.14309794f, -0.03306730f, -0.15255803f, 0.06684720f, -0.15618099f, 
    0.18107352f, 0.09694660f, -0.03013818f, -0.13620692f, -0.03809777f, -0.04206364f, -0.02290617f, 0.28321478f, 
    0.05696578f, 0.88735747f, -0.69085658f, -0.83615339f, -0.48951691f, -0.44583929f, 0.84281135f, 0.55340058f, 
    0.30624953f, -0.14903113f, 0.45303178f, -0.14733377f, 0.35222131f, -0.28229243f, -0.15146823f, -0.02820875f, 
    -0.23252261f, -0.04250407f, 0.14396404f, -0.01767226f, 0.13464232f, -0.02997611f, -0.14924452f, -0.10464486f, 
    0.10381415f, 0.12523001f, -0.26227221f, -0.47477487f, -0.57964808f, -0.09819515f, 0.29661301f, -0.06543281f, 
    0.41473815f, 0.50027192f, 0.17486228f, 0.07259905f, 0.02189187f, 0.15580489f, -0.12769975f, 0.15512812f, 
    0.15208854f, 0.05646598f, -0.15652807f, -0.28818426f, -0.20316337f, -0.04100907f, 0.24532114f, -0.09650978f, 
    -0.18292417f, 0.10696270f, 0.39139009f, 0.69728565f, -0.02016591f, 0.13041835f, 0.33400247f, -0.31687236f, 
    0.05196871f, 0.28529567f, 0.20656437f, -0.57168299f, -0.33939356f, -0.33737105f, 0.36856014f, -0.31107149f, 
    -0.35365015f, 0.04222252f, 0.12147199f, 0.09975562f, 0.20996794f, 0.19284716f, 0.08210452f, 0.17627279f, 
    -0.31904194f, -0.49185106f, -0.09781471f, -0.10754829f, -0.55618006f, 0.22108610f, 0.22923231f, -0.02114636f, 
    0.31881398f, -0.28692761f, -0.09477189f, -0.27278510f, -0.07577045f, 0.62036961f, -0.24084449f, 0.46685565f, 
    -0.32737541f, -0.37553707f, 0.19117686f, 0.27472427f, -0.09775978f, 0.14097886f, 0.18077740f, -0.20680870f, 
    -0.13820781f, -0.36223552f, 0.35382971f, 0.00123227f, 0.01497851f, 0.21740219f, 0.25569111f, 0.20449957f, 
    0.18599470f, 0.20399608f, 0.10523892f, 0.32368430f, 0.23846701f, 0.23225683f, 0.03259594f, -0.19473799f, 
    -0.16529791f, 0.29642209f, 0.21047184f, -0.24777497f, -0.07115056f, 0.10000537f, 0.06524850f, -0.07878032f, 
    -0.05455997f, 0.08961555f, -0.13506724f, -0.10055576f, -0.01016442f, 0.08018103f, -0.03544025f, 0.17297223f, 
    0.22461542f, 0.28239450f, 0.27556452f, -0.17977412f, 0.04829571f, 0.01039371f, 0.32947960f, 0.06430195f, 
    0.15220106f, -0.09866690f, -0.01088966f, -0.13361792f, -0.10032078f, -0.16477932f, -0.14704554f, 0.10529257f, 
    -0.01523023f, 0.11728530f, -0.24579613f, -0.10692052f, -0.35249195f, -0.05761532f, -0.41491863f, -0.78507346f, 
    -0.45829871f, -0.25052017f, 0.21608175f, 0.62423110f, 0.60247213f, 0.51105535f, -0.06679428f, -0.19391789f, 
    -0.38205075f, -0.04868976f, -0.43269742f, 0.49037576f, -0.24823250f, -0.04701633f, 0.02846155f, 0.08350677f, 
    0.31965318f, -0.29387426f, -0.33116132f, 0.07350519f, 0.01136231f, -0.21163677f, 0.21846482f, 0.25383472f, 
    -0.19211987f, 0.22531405f, -0.09006669f, -0.30378851f, 0.22165670f, 0.36309236f, -0.00375902f, 0.02522943f, 
    0.07737889f, -0.09383290f, 0.14838207f, 0.54364622f, 0.12206329f, -0.41186741f, -0.19547211f, -0.47948003f, 
    0.33635667f, -0.35776588f, 0.13093252f, 0.18545263f, 0.00537690f, 0.40637118f, -0.08417149f, 0.02970159f, 
    -0.25964513f, 0.19433178f, 0.16337089f, -0.29112884f, -0.58669752f, -0.18344082f, 0.05325009f, -0.25035182f, 
    0.11965489f, -0.57952636f, -0.43783319f, 0.27799526f, 0.29533282f, 0.41937181f, 0.37369400f, 0.01405703f, 
    0.03842575f, -0.38459507f, -0.13043763f, 0.13959366f, -0.31720543f, 0.21558715f, -0.27275053f, 0.17537513f, 
    0.25307941f, 0.17203699f, -0.03972246f, -0.20372590f, 0.16332319f, 0.30815843f, -0.01424255f, 0.13727979f, 
    0.22490256f, 0.03777547f, 0.25362986f, 0.17524551f, 0.18167500f, 0.13371177f, -0.04794819f, 0.11874563f, 
    -0.11728943f, 0.12920420f, -0.16897182f, 0.19764335f, 0.03559598f, -0.22786418f, 0.21264830f, -0.12030783f, 
    -0.07947553f, -0.05453797f, 0.29466674f, -0.63708961f, -0.31410837f, -0.68982595f, -0.91016167f, -0.62519139f, 
    0.32714570f, 0.25958246f, 0.27106243f, 0.11260081f, -0.06325997f, -0.08679159f, -0.35306713f, -0.34531888f, 
    -0.39227954f, -0.21081772f, -0.27793014f, -0.15029155f, -0.07742790f, 0.22980885f, -0.31684977f, -0.07380792f, 
    0.14901081f, -0.00699873f, -0.01217952f, -0.12812251f, 0.68140930f, -0.82224768f, -0.44493645f, -0.52563024f, 
    -0.01707465f, 0.00012077f, 0.05822581f, 0.35784945f, 0.06858049f, 0.01981507f, -0.23717083f, -0.16782296f, 
    0.05068785f, -0.21340968f, 0.44585240f, -0.07833277f, -0.31512469f, 0.19425616f, -0.20435460f, -0.33179519f, 
    0.25824341f, -0.28547630f, 0.09042228f, 0.04977478f, 0.00082594f, -0.13155071f, 0.25439480f, 0.32124639f, 
    0.40360519f, 0.19946453f, -0.31744266f, -0.23125088f, -0.14290930f, 0.05288955f, -0.19894204f, 0.00052491f, 
    -0.43694577f, -0.17002532f, 0.32130718f, 0.27294403f, -0.06068318f, 0.18569611f, -0.07046904f, -0.07479032f, 
    0.06742185f, 0.02129866f, 0.04001673f, -0.24593687f, 0.16056788f, -0.32137483f, -0.15120029f, -0.77653617f, 
    -0.74412411f, -0.38465306f, 0.32067731f, -0.23325607f, -0.35518390f, -0.23467937f, 0.11355751f, -0.16279612f, 
    0.58481598f, 0.37704623f, 0.32089272f, 0.26029423f, -0.11498479f, 0.09849736f, -0.17699347f, 0.14613265f, 
    -0.28953090f, -0.16765000f, -0.44549495f, 0.23655728f, -0.13419677f, 0.10691969f, -0.18408655f, 0.30690667f, 
    0.22830443f, 0.39720342f, -0.27977061f, 0.23716024f, -0.63192755f, -0.39162752f, -0.11793768f, 0.35823157f, 
    0.34731859f, 0.20226035f, -0.11459372f, 0.01757958f, -0.10575478f, 0.11378470f, 0.22863477f, -0.12276141f, 
    0.02537042f, -0.09492430f, -0.14366756f, -0.05713557f, 0.35421753f, -0.21550111f, 0.00611745f, -0.08152350f, 
    -0.37295786f, -0.34019351f, -0.24515428f, -0.12396199f, -0.21196468f, -0.33338502f, -0.31603336f, -0.62458235f, 
    -0.47983238f, -0.31715101f, -0.04168849f, -0.22989704f, -0.08001652f, -0.26364866f, -0.27660149f, -0.15752687f, 
    -0.08935910f, -0.42180857f, 0.05086676f, 0.07164662f, 0.05813399f, -0.22437711f, -0.26601812f, -0.24941440f, 
    -0.07067461f, -0.28254768f, -0.48731884f, -0.23201501f, -0.35588232f, -0.77281833f, -0.21498391f, -0.08953727f, 
    0.54356885f, 0.41229880f, 0.26801774f, -0.09408796f, 0.13495827f, 0.46842471f, -0.38929525f, -0.09393118f, 
    0.08225200f, -0.20417285f, 0.18082447f, 0.17506374f, 0.15640196f, -0.19247000f, -0.05436607f, -0.43032992f, 
    -0.34006265f, 0.40010804f, 0.03189909f, -0.18274751f, 0.37784719f, -0.36917287f, -0.14870243f, 0.17286104f, 
    -0.10565989f, -0.34473681f, -0.29657015f, -0.28765249f, 0.14202927f, 0.00675511f, -0.14781532f, 0.14692663f, 
    -0.12572071f, 0.13781044f, -0.16827376f, -0.18578361f, -0.03894639f, -0.33527899f, -0.10562311f, 0.31734464f, 
    0.35132191f, 0.40152878f, 0.32752565f, -0.93323982f, -0.42126942f, 0.10022617f, -0.47674078f, -0.53267634f, 
    0.57555890f, 0.42450780f, 0.13383350f, -0.09105366f, 0.48982012f, 0.18032838f, 0.23748571f, 0.12256479f, 
    0.15391198f, 0.04548712f, -0.15886414f, 0.07032866f, -0.08860682f, -0.17219932f, -0.12233327f, 0.06470824f, 
    0.07970216f, -0.03251771f, -0.01838307f, 0.00482955f, 0.57365608f, 0.14665088f, -0.05799922f, 0.11582298f, 
    -0.04024686f, 0.12133138f, 0.46840420f, 0.02060040f, 0.29449826f, -0.15683869f, -0.32769027f, 0.45069212f, 
    0.15896554f, -0.09052631f, -0.31317002f, 0.06036890f, -0.11942793f, 0.13859819f, -0.18912955f, -0.19058435f, 
    -0.02033982f, 0.00746332f, 0.30660090f, 0.04323811f, -0.02114326f, -0.99666196f, -0.63951749f, 0.46555766f, 
    0.51722240f, 0.20751038f, 0.78599328f, -0.35543382f, -0.15158017f, -0.21705987f, 0.10951874f, -0.37814513f, 
    -0.16553989f, -0.20324726f, 0.57514280f, -0.43188646f, -0.30520052f, -0.32343671f, -0.27027822f, 0.41147214f, 
    0.25624737f, -0.03588243f, -0.19432011f, -0.11803593f, 0.15123448f, 0.01642074f, 0.33207211f, -0.19546907f, 
    0.06008763f, 0.53235948f, 0.29145697f, -0.26349524f, -0.17717220f, -0.08446407f, -0.23728281f, -0.06685878f, 
    -0.06668867f, -0.04715074f, 0.22091861f, 0.16499658f, -0.07168420f, -0.19615792f, 0.03943810f, 0.00770423f, 
    -0.00779080f, 0.08796874f, -0.15765783f, 0.09891840f, 0.16155657f, 0.32571301f, -0.17174371f, 0.11226544f, 
    -0.61580652f, 0.19868685f, -0.13125445f, 0.39868534f, -0.14833756f, -0.31795552f, -0.17833924f, 0.34344897f, 
    0.14066871f, 0.06140122f, 0.19455367f, -0.37429526f, -0.25859955f, 0.54220062f, -0.08069567f, -0.23231982f, 
    0.02483706f, 0.15981601f, -0.03483321f, -0.16845332f, -0.04323939f, 0.13783713f, -0.07329793f, 0.37809327f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22517543f, -0.04640519f, -0.16842173f, 0.15395057f, 0.19415191f, 0.22257249f, 0.02473810f, 0.01934147f, 
    -0.00412824f, 0.03062260f, 0.10503709f, -0.05072116f, 0.02480097f, -0.27907971f, -0.01355268f, 0.20299995f, 
    -0.08997603f, -0.00822731f, -0.05530991f, -0.08569790f, 0.11155836f, 0.20637555f, -0.02852156f, 0.05679365f, 
    -0.25541359f, 0.16633217f, 0.01204261f, 0.07518078f, 0.11223150f, 0.13193381f, 0.08226217f, 0.27204171f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02801836f, 0.02986076f, -0.01370534f, 0.02314393f, 0.01221180f, -0.00228803f, 0.01311064f, 0.02124767f, 
    0.01599435f, -0.00597038f, -0.00226932f, 0.02705700f, 0.01174317f, 0.02227695f, -0.00561441f, -0.04291256f, 
    0.01835186f, -0.03203669f, -0.01766509f, 0.00002529f, 0.01301330f, 0.03207218f, 0.00186111f, 0.01569422f, 
    -0.02081632f, -0.05846990f, -0.01777396f, -0.01013252f, 0.03730576f, -0.02406237f, 0.01998512f, 0.04012882f, 
    -0.04613998f, -0.02638194f, 0.01971321f, -0.04991069f, 0.00878751f, 0.00256311f, 0.03081543f, 0.00213441f, 
    -0.00499314f, 0.00588328f, -0.01187640f, 0.03033719f, 0.00469277f, 0.04034591f, -0.03412649f, -0.00616287f, 
    -0.03219079f, -0.01114876f, 0.01453674f, 0.01479109f, -0.05046301f, -0.03173301f, -0.01182475f, -0.01956342f, 
    -0.03255624f, 0.02495876f, -0.01412624f, 0.04138963f, -0.01597714f, 0.01963965f, 0.00911702f, -0.03154168f, 
    0.03701602f, 0.01586057f, -0.04788831f, -0.01413835f, 0.01060211f, 0.03154438f, -0.01871134f, -0.04073652f, 
    0.00083425f, -0.01318163f, 0.00149275f, -0.01256099f, -0.02900485f, -0.02536066f, -0.04049991f, 0.04047262f, 
    0.00581400f, 0.01010952f, -0.00124151f, -0.02431637f, 0.03206397f, 0.03580110f, -0.03504401f, -0.02026462f, 
    0.00651428f, 0.02942558f, -0.02904979f, 0.04501990f, -0.04860995f, 0.04186299f, 0.01592630f, 0.01971967f, 
    -0.03928296f, 0.01311680f, -0.01996134f, -0.04132454f, -0.03094450f, -0.01382349f, -0.03158491f, -0.01073011f, 
    -0.03300531f, -0.03737473f, -0.00876146f, 0.01899513f, 0.01202690f, -0.04345967f, 0.01723562f, 0.00045464f, 
    -0.01880983f, -0.03646870f, 0.03426060f, 0.03458456f, 0.01178490f, -0.00633874f, 0.01348292f, 0.03169953f, 
    0.00993568f, 0.02151702f, -0.03706739f, -0.04243780f, 0.03873482f, 0.01117160f, -0.02381371f, 0.00236269f, 
    -0.03345868f, 0.03100915f, -0.03839783f, 0.00078375f, -0.00341689f, -0.01483651f, 0.01104347f, -0.03293369f, 
    -0.00073958f, 0.01171081f, 0.04219231f, 0.01707235f, 0.02610829f, 0.03547040f, 0.02675930f, 0.00000386f, 
    -0.03275368f, -0.03917286f, -0.02630305f, 0.00867245f, -0.01403534f, -0.05501320f, -0.02216268f, 0.00752187f, 
    -0.04281726f, -0.00624025f, -0.05261979f, 0.00353446f, 0.02170728f, 0.03338362f, -0.02877129f, -0.01835896f, 
    -0.02398726f, -0.04297463f, -0.06243379f, 0.02994274f, -0.02220192f, 0.01557909f, -0.04664429f, -0.05156521f, 
    -0.03465704f, -0.01385362f, -0.05144364f, 0.03562906f, -0.04804112f, 0.02530407f, 0.02635429f, 0.01713580f, 
    -0.02185614f, 0.02933227f, -0.03841387f, 0.01394631f, 0.01824142f, 0.02078258f, -0.01854701f, -0.01223905f, 
    -0.02409284f, 0.01528929f, 0.02760860f, -0.05447615f, -0.05388089f, 0.01991734f, -0.00385675f, -0.01363930f, 
    -0.02189218f, -0.00298593f, -0.01415372f, -0.04886033f, 0.03004099f, 0.03393080f, -0.03448684f, -0.00828310f, 
    -0.04455958f, -0.03542222f, -0.00302293f, -0.04064140f, 0.00954137f, 0.00331546f, -0.05992465f, 0.03152076f, 
    -0.05197815f, -0.02903993f, -0.03194518f, -0.01281847f, 0.00032945f, -0.04961786f, -0.03673263f, -0.01878728f, 
    0.02908733f, 0.00945618f, 0.03823528f, -0.03581973f, -0.01570386f, -0.01907644f, -0.00112186f, -0.04803803f, 
    -0.04584375f, -0.02512883f, 0.02547222f, 0.02536114f, 0.01160145f, 0.01593430f, 0.06010015f, 0.05628229f, 
    -0.02114946f, -0.02208777f, 0.03061312f, 0.00441764f, -0.04969776f, 0.02462436f, -0.04072039f, 0.01442402f, 
    0.01486477f, -0.01301783f, 0.03724500f, 0.02247800f, 0.04220235f, 0.03134166f, 0.04337863f, 0.04698975f, 
    0.00027407f, -0.01756391f, -0.02441219f, 0.01384368f, 0.01529577f, -0.00162652f, 0.01769645f, 0.02061480f, 
    0.02222005f, -0.03734252f, -0.03583925f, 0.01666034f, 0.04401489f, -0.03355163f, -0.04475314f, -0.05589103f, 
    0.00066212f, -0.02946424f, -0.00887483f, -0.01986952f, -0.00555068f, 0.04521377f, -0.00664738f, 0.00829117f, 
    0.03302291f, 0.00190928f, 0.01595932f, -0.04088909f, 0.02608899f, 0.00285474f, -0.01020556f, -0.04155447f, 
    0.02833129f, -0.05912872f, -0.04924108f, -0.01636402f, 0.02006831f, 0.03764398f, -0.00737529f, -0.00386720f, 
    -0.02756163f, 0.02924327f, -0.02653855f, -0.00820450f, -0.04619731f, -0.04358163f, 0.02889617f, -0.00116719f, 
    0.01321306f, 0.01481677f, 0.02566727f, -0.04083987f, 0.02031034f, -0.04265014f, -0.04180593f, 0.04780640f, 
    -0.03585872f, -0.02465820f, 0.02493541f, -0.04782622f, 0.03224334f, 0.01588646f, 0.00854179f, 0.00643853f, 
    -0.03331223f, -0.02752162f, 0.00377353f, 0.01793944f, -0.03017299f, 0.00852858f, -0.02625895f, 0.03159314f, 
    -0.00949043f, -0.01512631f, -0.04905938f, -0.00040337f, -0.02025208f, -0.00216742f, 0.00291831f, -0.04031613f, 
    -0.05131743f, -0.00951619f, 0.03346976f, -0.05599269f, -0.00504353f, 0.05371335f, -0.02173192f, 0.01105531f, 
    0.02945510f, -0.03630898f, -0.05528372f, 0.01887522f, -0.00449386f, 0.02051209f, 0.03253816f, -0.01474889f, 
    0.03795162f, 0.02079844f, 0.02163714f, -0.03053340f, -0.03911106f, -0.01591235f, -0.01868660f, 0.05097235f, 
    -0.00633948f, 0.01463558f, -0.00410364f, -0.02204425f, -0.01876850f, 0.01315012f, -0.04774213f, -0.02830702f, 
    -0.05801033f, -0.04040501f, 0.02241017f, -0.03569077f, 0.02461069f, 0.02929351f, 0.02299755f, -0.02604287f, 
    -0.03775343f, 0.02371406f, -0.02267263f, -0.02366620f, -0.06333166f, -0.05701452f, -0.01887126f, 0.03582529f, 
    -0.03319784f, -0.01538984f, -0.02284813f, 0.00887033f, -0.01792957f, 0.02915448f, -0.01845216f, -0.02007070f, 
    0.11022077f, -0.18860449f, 0.48989326f, 0.04792651f, -0.00664850f, 0.12054181f, -0.09935725f, -0.00954590f, 
    -0.00470817f, -0.10684403f, 0.04984146f, -0.05211945f, -0.14913410f, 0.08722351f, -0.13590845f, -0.14541577f, 
    -0.07833029f, -0.03415399f, 0.11909097f, 0.12691541f, 0.08308806f, -0.05761879f, 0.22019812f, -0.05112410f, 
    0.08425301f, -0.00924612f, 0.04681342f, -0.03572110f, -0.05560523f, 0.22396350f, 0.03420812f, 0.02539880f, 
    0.10628369f, -0.04454970f, -0.11292359f, -0.10397943f, 0.04617229f, 0.34111103f, -0.02335546f, 0.12449206f, 
    -0.12599742f, 0.01616407f, 0.26340413f, -0.04458012f, 0.00627749f, -0.15048862f, 0.10128426f, 0.20615947f, 
    -0.07167193f, 0.08650642f, -0.07155833f, 0.10366122f, 0.00144758f, 0.25461614f, -0.09662890f, -0.00285276f, 
    0.08001097f, -0.10176946f, 0.03091327f, 0.18447173f, -0.05867847f, -0.11393253f, 0.13491371f, -0.20917612f, 
    0.18819088f, 0.00919107f, -0.01072335f, 0.15736857f, -0.06272423f, 0.07355946f, 0.02427304f, 0.06844019f, 
    -0.16190842f, 0.14007498f, -0.12385426f, 0.14657326f, 0.02579490f, -0.04130748f, 0.07347254f, 0.03814685f, 
    0.02199751f, 0.17865968f, 0.04840650f, 0.02802639f, 0.42886251f, 0.05924407f, -0.10359164f, 0.08264446f, 
    0.14850119f, 0.03995548f, 0.00406102f, 0.06108179f, -0.00554661f, 0.08633813f, -0.00737954f, -0.06536062f, 
    0.17463079f, 0.14625123f, 0.16233054f, 0.07211691f, 0.06317035f, 0.00510922f, 0.03542838f, -0.04926731f, 
    0.09747577f, -0.03774209f, 0.05258146f, -0.03088637f, -0.51303101f, -0.04452891f, -0.20538439f, 0.01296499f, 
    -0.04294246f, -0.05019026f, -0.01851285f, 0.02990544f, -0.04262639f, -0.08809359f, -0.00671366f, -0.00380792f, 
    0.15243608f, 0.03332457f, -0.23186968f, -0.06078256f, 0.08026285f, 0.01922657f, -0.08985531f, -0.01429866f, 
    -0.10943052f, 0.07047514f, -0.01145040f, 0.11743406f, 0.04473330f, 0.13364442f, 0.02370354f, 0.10757154f, 
    0.07465888f, 0.09718879f, -0.06068436f, 0.03692535f, -0.25715888f, 0.21167853f, 0.11479479f, 0.06091693f, 
    0.00464590f, -0.05192646f, -0.03941588f, -0.02686938f, 0.01781620f, -0.07499289f, 0.01178181f, 0.16178103f, 
    -0.06049619f, -0.16349183f, -0.06487668f, 0.06985366f, 0.09208933f, 0.00735704f, -0.03367365f, -0.03002300f, 
    0.07874276f, 0.03892690f, -0.06751537f, 0.00496114f, 0.02072325f, -0.04263197f, -0.06341172f, -0.06162250f, 
    0.13155451f, 0.05659336f, 0.03672535f, 0.01116723f, 0.01336358f, -0.01829902f, -0.03783749f, -0.04484318f, 
    -0.08646709f, 0.01963825f, 0.16985592f, -0.07378724f, 0.46232694f, 0.09036771f, -0.07205320f, -0.17151429f, 
    -0.01101085f, 0.06456026f, -0.16252437f, -0.06405778f, -0.14913692f, 0.01290186f, 0.10874293f, -0.08492032f, 
    0.10256798f, 0.10147699f, 0.07402472f, -0.07466358f, -0.01732412f, 0.09507194f, 0.04261123f, -0.00282546f, 
    -0.01431323f, 0.00191383f, 0.00851617f, -0.16113207f, 0.16935764f, 0.28117016f, -0.00809053f, -0.06955270f, 
    0.07611117f, -0.04329513f, -0.05856840f, 0.11843187f, 0.08154472f, 0.06836225f, -0.01796465f, -0.00084927f, 
    0.09064930f, 0.06386848f, 0.01249408f, -0.02390666f, 0.01129632f, 0.01643965f, 0.03059802f, -0.07016473f, 
    -0.15729016f, -0.16481073f, -0.19435509f, -0.02155571f, -0.17440979f, -0.16814241f, -0.18913086f, -0.16753808f, 
    0.04380062f, 0.01206949f, -0.03991809f, -0.09782033f, -0.01058951f, -0.00279659f, 0.07803967f, 0.03733288f, 
    0.07335351f, -0.15124685f, -0.24635218f, -0.12437729f, -0.02795535f, -0.21936347f, 0.11146374f, -0.03215256f, 
    -0.01789035f, 0.01296726f, 0.06349100f, 0.09820260f, 0.09366897f, -0.13557534f, 0.18014961f, 0.09082966f, 
    -0.02645002f, -0.00226957f, -0.06099159f, 0.03662200f, 0.06383923f, -0.00485740f, 0.00101894f, -0.00325649f, 
    0.20014949f, -0.04668633f, 0.27689514f, 0.07323126f, 0.12902412f, -0.01464912f, -0.05178255f, 0.00765545f, 
    -0.00265037f, -0.00127336f, 0.13687907f, -0.08833981f, 0.09792485f, -0.03000711f, 0.03044637f, -0.03566238f, 
    0.01293005f, -0.04196416f, 0.04888268f, -0.06117220f, 0.05761724f, 0.05099273f, -0.01211650f, -0.07097660f, 
    0.04808768f, 0.11139224f, 0.25597680f, 0.01683347f, -0.02570065f, -0.06808443f, -0.18320473f, 0.04100766f, 
    0.00616147f, -0.03145739f, 0.07151091f, 0.13025793f, 0.05273882f, -0.09281159f, -0.06934265f, -0.04672048f, 
    -0.00493961f, -0.07495426f, 0.10009024f, 0.17349198f, -0.02350653f, -0.06153961f, 0.14241835f, 0.03047888f, 
    -0.10687090f, 0.23996937f, 0.02392846f, -0.05744025f, 0.00494384f, 0.15937629f, 0.10865611f, -0.15792815f, 
    -0.05927430f, 0.00205628f, -0.04964655f, -0.06498218f, -0.08692788f, 0.13861674f, -0.21081983f, -0.14444354f, 
    -0.01723830f, -0.04819926f, 0.00840191f, 0.05613906f, 0.22605108f, -0.06177330f, 0.15486473f, 0.07139138f, 
    0.06108987f, 0.13625155f, 0.05062573f, 0.03465641f, 0.11227740f, -0.03972998f, -0.04841146f, 0.01775891f, 
    0.03883753f, -0.05762612f, 0.03095722f, -0.13383219f, 0.12681720f, -0.30486581f, 0.25309557f, 0.03979955f, 
    -0.03742709f, -0.02393666f, -0.02674714f, -0.00645189f, 0.00113113f, 0.03949520f, -0.45934445f, 0.14229627f, 
    0.10803735f, -0.02598580f, 0.00844105f, 0.02569342f, -0.08112123f, 0.09963942f, 0.01226801f, 0.02631673f, 
    0.04759424f, -0.01357954f, -0.05778472f, -0.06518529f, 0.19191574f, -0.21858469f, 0.06999505f, -0.06080896f, 
    0.02825910f, -0.04351321f, -0.04167259f, -0.07813506f, -0.11426737f, -0.05885224f, -0.14591500f, -0.08341087f, 
    0.01735958f, -0.00443486f, -0.04185597f, -0.04854476f, -0.03639929f, 0.02297114f, -0.02739219f, -0.03190766f, 
    -0.05159210f, -0.03210534f, 0.02327461f, -0.04285271f, -0.00631617f, -0.02238607f, 0.00862105f, -0.04211551f, 
    -0.02423572f, 0.01152488f, -0.02395218f, -0.03530287f, 0.03240324f, -0.01590059f, -0.03091735f, -0.01193326f, 
    0.03765945f, 0.01487632f, -0.04127385f, 0.04515301f, -0.00287801f, -0.00176069f, -0.04397306f, -0.04159028f, 
    0.02503712f, -0.01179711f, -0.00553271f, -0.02788623f, -0.04095099f, 0.02705493f, 0.01784387f, 0.01415854f, 
    0.03495788f, 0.01300673f, 0.03339987f, 0.00751653f, 0.00879192f, -0.00209508f, 0.00493579f, -0.05367166f, 
    0.04131201f, -0.02833709f, -0.02486279f, 0.03264019f, -0.02100399f, -0.04174707f, 0.02748830f, 0.01440542f, 
    -0.02990782f, 0.00821001f, -0.03215338f, -0.00856041f, 0.02428952f, 0.02543193f, -0.00489307f, 0.01231061f, 
    0.00658356f, -0.01705728f, 0.01705713f, 0.00963594f, 0.01447638f, 0.00310790f, -0.05611445f, 0.03215041f, 
    0.01816067f, 0.00348844f, -0.03779070f, -0.05585090f, -0.02343497f, 0.02554951f, 0.03811625f, 0.00639022f, 
    -0.02960883f, 0.01196259f, -0.01789546f, -0.05174839f, 0.00335070f, -0.00299762f, -0.03033003f, -0.04047943f, 
    0.02422281f, -0.02610952f, -0.02478584f, -0.04329921f, -0.03326784f, 0.03144519f, -0.03037751f, -0.03669818f, 
    -0.01677623f, -0.01535216f, 0.02015413f, -0.04590077f, 0.01852367f, 0.04384756f, -0.02205333f, -0.01660782f, 
    -0.04836068f, -0.04479166f, 0.03109755f, -0.04624925f, -0.03135156f, 0.00422775f, 0.00196100f, -0.04214440f, 
    -0.03803536f, -0.02522839f, 0.01707635f, -0.03627641f, -0.03601354f, 0.01925858f, 0.00277474f, -0.03161044f, 
    -0.04183694f, 0.00627360f, -0.03258501f, -0.02648613f, -0.01964087f, -0.00409267f, 0.01892543f, -0.01061603f, 
    -0.01165440f, -0.01048853f, -0.02877114f, 0.01453291f, -0.05489961f, -0.03302570f, -0.00611102f, 0.02089586f, 
    -0.00060204f, -0.01933912f, -0.05392163f, 0.03833470f, 0.00086745f, 0.02567317f, -0.02526742f, 0.00369375f, 
    0.01356299f, -0.00200686f, -0.02108904f, 0.02124724f, -0.01985947f, 0.02967626f, 0.02085630f, 0.01720955f, 
    -0.04698292f, -0.02730317f, -0.01172986f, 0.02626971f, 0.00066950f, -0.03239531f, 0.00249504f, -0.03510666f, 
    -0.04528845f, -0.03367181f, -0.02220030f, -0.02565222f, 0.02790437f, 0.00004842f, -0.01601947f, 0.00342197f, 
    0.03973799f, -0.05214739f, -0.04562608f, -0.04214355f, 0.03738379f, 0.03431637f, -0.00869990f, -0.01918694f, 
    -0.01951307f, 0.01875952f, 0.00277583f, 0.01387796f, -0.00241979f, -0.00051805f, 0.03632398f, -0.01589610f, 
    -0.04146581f, 0.03597512f, 0.04085789f, 0.00577644f, -0.03072221f, 0.00145644f, -0.00588920f, 0.03602456f, 
    0.01503595f, -0.03194423f, -0.04930318f, -0.03170351f, -0.00326713f, -0.03423455f, -0.01361795f, -0.03359219f, 
    -0.02125886f, -0.01806983f, 0.02987966f, -0.03065914f, -0.02359493f, 0.01028000f, 0.01503450f, 0.00625191f, 
    -0.00486987f, -0.03236770f, -0.03869782f, -0.02497110f, -0.03735342f, -0.02171264f, -0.03031892f, 0.04417406f, 
    0.01118369f, -0.01003346f, -0.03738774f, -0.01442892f, 0.00474743f, -0.02328029f, -0.00260757f, 0.04509190f, 
    -0.02995410f, -0.04883867f, -0.04433596f, -0.02617520f, -0.00628452f, -0.02697558f, 0.02767400f, -0.05376585f, 
    0.03845197f, -0.05014376f, -0.01259329f, 0.04146543f, -0.04206328f, -0.02582456f, -0.03187817f, -0.03285041f, 
    0.01788987f, 0.02961563f, -0.02712605f, -0.04145014f, 0.02508350f, 0.02418991f, 0.00368031f, -0.02629097f, 
    -0.01328321f, 0.02741092f, 0.00153900f, 0.03806239f, -0.03487757f, -0.03920907f, 0.00737381f, -0.01725454f, 
    0.04421614f, -0.02365841f, 0.01216378f, -0.00482465f, -0.00102372f, 0.02026035f, -0.04411940f, -0.02314414f, 
    -0.03690841f, 0.00127706f, -0.02176606f, -0.00557720f, 0.02093974f, -0.01189347f, -0.03088122f, -0.03630909f, 
    -0.02861077f, -0.05748685f, -0.02933360f, 0.04280239f, 0.04056915f, -0.03115672f, 0.04325741f, -0.03183825f, 
    0.02133788f, -0.00176204f, -0.01460807f, 0.03595681f, 0.01852639f, -0.03865055f, -0.02943297f, -0.02862460f, 
    -0.05192996f, 0.00399961f, 0.02280768f, -0.00449545f, -0.00843656f, -0.01547581f, -0.02336408f, -0.00004522f, 
    0.00943197f, -0.02920543f, -0.02970755f, 0.01031798f, -0.03543324f, 0.04372664f, 0.01246206f, -0.02028709f, 
    0.00003730f, 0.02691303f, -0.03088124f, -0.03465002f, 0.02344202f, 0.01102626f, 0.04085137f, -0.02330140f, 
    -0.04248255f, 0.01399846f, -0.01068649f, 0.02168060f, -0.00792371f, -0.01308430f, -0.02697554f, 0.03878681f, 
    0.03653330f, -0.02965802f, -0.01405446f, -0.03231549f, -0.05471646f, 0.03929834f, 0.02131959f, -0.00929188f, 
    -0.03729394f, -0.04788216f, -0.00216934f, 0.03027291f, 0.03184597f, 0.01480153f, 0.00834646f, -0.05728124f, 
    0.00432893f, 0.02502584f, -0.05502658f, 0.01726167f, 0.00583320f, 0.00912278f, -0.01691969f, -0.02778294f, 
    -0.01845131f, 0.02850845f, -0.00430275f, -0.03915629f, -0.04190645f, -0.03552604f, -0.03614787f, 0.01089456f, 
    -0.00556744f, -0.03801410f, -0.02600575f, 0.01377381f, -0.02758238f, 0.01879559f, -0.02528507f, 0.00322606f, 
    -0.00336289f, -0.04606320f, -0.03406814f, -0.01187404f, -0.02112186f, 0.00434050f, 0.04161940f, -0.01143692f, 
    -0.03044185f, -0.04324481f, -0.04381955f, 0.04639820f, 0.04177590f, 0.02519573f, -0.04548357f, 0.03837796f, 
    -0.05612531f, -0.03652473f, 0.03181810f, -0.04645218f, -0.00130791f, -0.02082999f, 0.00509041f, 0.03836821f, 
    -0.07144833f, -0.04072555f, 0.15467849f, 0.07229844f, 0.06415809f, -0.02852349f, 0.02531765f, 0.06592462f, 
    0.14609540f, 0.09630837f, 0.05854156f, 0.05786499f, -0.21072644f, 0.10931179f, -0.00866520f, -0.26448029f, 
    -0.07206613f, 0.13049582f, -0.03549710f, 0.12475846f, 0.11635664f, 0.00654117f, 0.12727310f, -0.04493957f, 
    -0.08498484f, -0.17872079f, -0.03495647f, -0.08136719f, 0.02529813f, 0.19924851f, -0.03008146f, -0.01117715f, 
    0.13607870f, -0.00575402f, 0.09485216f, 0.11242847f, -0.05586994f, 0.01777545f, 0.00337413f, -0.23426478f, 
    -0.00358753f, 0.01450111f, 0.02653041f, 0.20996922f, 0.13449110f, -0.06320712f, -0.08614761f, 0.03296737f, 
    0.06977011f, 0.16761407f, -0.10052745f, -0.26589188f, -0.01283821f, 0.02846983f, -0.03266660f, 0.04922611f, 
    0.26868159f, 0.04698277f, 0.10025164f, 0.01686320f, 0.08078098f, -0.42964333f, 0.06905392f, -0.25424153f, 
    0.14155701f, 0.17866744f, 0.12991336f, 0.03919817f, 0.10059198f, -0.01836645f, 0.02531829f, -0.00564667f, 
    -0.52212977f, 0.11111092f, 0.04496743f, 0.04060451f, 0.07175174f, 0.05887957f, -0.01676106f, 0.23018473f, 
    0.04409300f, 0.01939322f, -0.11235148f, -0.00226091f, -0.01984307f, 0.12104888f, 0.04483949f, -0.09513351f, 
    0.08634943f, -0.03382459f, -0.02891915f, -0.04244269f, 0.03560903f, 0.00011871f, 0.05930148f, 0.08691557f, 
    -0.02583225f, -0.06628782f, -0.04614912f, 0.03311250f, 0.18010154f, 0.04509499f, 0.11850060f, 0.06853744f, 
    0.01965775f, 0.00476012f, 0.04119977f, -0.01349858f, 0.16333114f, -0.37049687f, 0.33928835f, -0.28307807f, 
    -0.02863894f, 0.01574804f, -0.03166029f, -0.04876250f, 0.07687241f, 0.12882610f, 0.17450526f, 0.16766943f, 
    0.01124705f, -0.00116530f, 0.00350899f, 0.10551345f, 0.06887657f, -0.14774956f, -0.11865702f, -0.10227556f, 
    0.14077570f, 0.20212428f, 0.18614832f, 0.17875350f, -0.15604250f, -0.07948807f, -0.10669135f, -0.06649135f, 
    0.02732912f, -0.06200007f, 0.11735398f, 0.07271761f, -0.12325823f, 0.09089686f, 0.02379274f, 0.08704524f, 
    0.12314215f, -0.08481856f, 0.02553616f, -0.18414272f, 0.05617859f, 0.05930419f, -0.17286201f, 0.19046934f, 
    0.13142075f, 0.01277612f, 0.13827945f, -0.02671300f, -0.05534611f, 0.02935697f, 0.00238474f, 0.05860492f, 
    -0.03248028f, -0.13539699f, -0.06564863f, -0.12335191f, -0.07018457f, -0.03590551f, -0.00787502f, 0.11612998f, 
    0.07852825f, -0.02342271f, 0.04770413f, 0.03601963f, -0.03827659f, 0.02343835f, -0.07954552f, -0.01943801f, 
    -0.05965086f, -0.08765134f, -0.09217352f, -0.19451955f, -0.03030715f, 0.24465865f, 0.03594443f, 0.15576288f, 
    -0.08879761f, -0.01777858f, -0.01477211f, 0.15644966f, 0.21149422f, 0.05642807f, -0.06772682f, 0.23719579f, 
    -0.13418821f, 0.01397140f, 0.22075668f, -0.11216231f, 0.03256937f, -0.01769029f, -0.13962996f, -0.08770315f, 
    0.24456733f, 0.12447724f, 0.16213797f, 0.31602675f, -0.26976505f, 0.14408544f, 0.02153901f, -0.23752747f, 
    0.12692942f, 0.06458489f, 0.04339949f, 0.03403779f, 0.02386324f, -0.00839154f, -0.00066830f, -0.00816869f, 
    0.00167742f, -0.02975967f, 0.02479345f, 0.03514836f, -0.01703573f, -0.05932418f, -0.04978617f, -0.12371579f, 
    0.19671214f, 0.14701305f, 0.20451921f, 0.19022727f, -0.07847486f, 0.00452944f, -0.06681117f, -0.15322423f, 
    0.05285221f, -0.02720320f, 0.20413193f, 0.08865535f, -0.04456839f, -0.00538922f, 0.06314597f, -0.00217511f, 
    0.30068687f, -0.21834867f, 0.26094615f, -0.11626885f, 0.14571820f, -0.09460151f, 0.02137769f, 0.10473529f, 
    0.07860730f, 0.14859617f, 0.03678630f, -0.00932653f, 0.03881964f, -0.23639125f, 0.08963183f, 0.06065125f, 
    0.07833984f, 0.06872211f, 0.09110044f, 0.01865372f, -0.07710998f, -0.01846865f, -0.01675211f, -0.08231168f, 
    -0.15395901f, -0.22697170f, 0.13016506f, -0.19495103f, -0.11188145f, -0.05265340f, 0.03423112f, 0.07133994f, 
    -0.01973073f, -0.16164550f, -0.07338119f, -0.06670989f, 0.10908929f, 0.05210793f, -0.23473540f, 0.06352441f, 
    0.10692516f, -0.01943831f, -0.06427377f, -0.04917375f, 0.00223492f, 0.02362643f, -0.13703193f, -0.03727366f, 
    -0.11419246f, 0.07755866f, 0.07110783f, 0.03120138f, -0.09341756f, -0.11855755f, -0.01785131f, -0.02231256f, 
    0.02485185f, -0.00043125f, -0.01576439f, -0.01999817f, -0.07285020f, -0.18761818f, -0.11804946f, -0.04664541f, 
    0.17001882f, -0.03312383f, 0.09517542f, 0.12811273f, -0.06574534f, -0.02101132f, -0.01964477f, 0.15622491f, 
    -0.15564647f, -0.05109344f, 0.04472451f, -0.26723698f, -0.07885367f, 0.03505512f, -0.03361512f, 0.09546649f, 
    0.12415977f, 0.04670314f, -0.01373250f, -0.02994184f, -0.43781978f, 0.03994272f, -0.16318785f, -0.06951419f, 
    -0.03108375f, 0.01842071f, -0.16437034f, -0.02659802f, 0.24955326f, 0.11127930f, 0.06272119f, 0.04328349f, 
    -0.07871769f, 0.02685948f, 0.13680525f, 0.18445897f, -0.03833814f, -0.04870259f, -0.11071701f, -0.17421173f, 
    0.07356642f, 0.07573871f, -0.01808276f, 0.12121712f, -0.02015184f, -0.15085363f, 0.04395327f, 0.00899729f, 
    0.13145179f, 0.07168861f, -0.09702673f, 0.10780123f, 0.13594016f, 0.04297406f, 0.03980548f, 0.05798911f, 
    0.09452223f, -0.18721768f, -0.10979871f, -0.08031230f, 0.27563787f, 0.02131534f, 0.08097924f, -0.01826447f, 
    0.04793277f, -0.08326631f, -0.09132324f, -0.00711917f, 0.27201805f, -0.34742454f, 0.18808398f, -0.03263760f, 
    0.16633447f, 0.00744734f, 0.06961374f, 0.16038920f, 0.14357951f, 0.02248011f, 0.04437413f, 0.18475631f, 
    -0.03602190f, 0.05026750f, 0.02747092f, -0.04709759f, 0.04167974f, -0.04611599f, 0.01473679f, -0.00612746f, 
    0.04126412f, 0.01532893f, -0.04140437f, 0.00260661f, 0.00893411f, -0.00924333f, -0.03005020f, -0.01190411f, 
    -0.04679772f, 0.01983529f, -0.04204151f, -0.01536131f, -0.03871073f, -0.05082778f, -0.01293297f, 0.01420898f, 
    -0.04410500f, -0.01387420f, -0.02770819f, 0.01794075f, -0.05096955f, -0.00279084f, -0.03173904f, -0.02538049f, 
    -0.03748712f, -0.02292788f, 0.00632571f, -0.02017025f, 0.03004830f, 0.04354191f, -0.00590604f, -0.00198746f, 
    -0.04338698f, -0.00017563f, 0.00867841f, 0.03432347f, -0.04231248f, -0.04526838f, -0.02171724f, 0.02064403f, 
    0.04308068f, -0.01122101f, -0.02365551f, 0.03723361f, -0.04609208f, 0.01591747f, 0.01034082f, 0.01561892f, 
    -0.03713227f, 0.04234855f, -0.00228992f, 0.01313188f, -0.04783446f, 0.03720136f, 0.04144192f, 0.00814130f, 
    0.02411570f, -0.01297286f, 0.00739440f, -0.05360600f, 0.04630171f, 0.02948179f, 0.02714977f, -0.02703738f, 
    0.02579350f, -0.03657173f, 0.02788610f, 0.02448327f, -0.03435278f, 0.01616341f, 0.02065916f, 0.00669798f, 
    -0.03035904f, -0.02087002f, 0.02170542f, 0.01620684f, -0.00192936f, 0.00706319f, -0.03258029f, -0.03760525f, 
    0.03487995f, -0.02337626f, 0.04049344f, -0.02999112f, -0.01405156f, 0.00527344f, -0.01080522f, -0.01929776f, 
    0.00970273f, -0.04517927f, -0.02930121f, -0.02888855f, -0.03287731f, 0.00753552f, -0.04381109f, 0.01271610f, 
    -0.04794316f, -0.00191663f, -0.01325659f, -0.04324246f, 0.03027464f, -0.03130447f, -0.01319236f, 0.02422554f, 
    -0.01579943f, -0.02455792f, -0.01600291f, 0.02193063f, 0.01123933f, 0.02605901f, -0.00009160f, -0.03059076f, 
    0.03521952f, -0.03126222f, 0.00342625f, 0.04724757f, -0.02958857f, 0.03093560f, 0.04858307f, 0.00659394f, 
    0.04770676f, 0.03225459f, 0.04240193f, -0.03706167f, -0.03672286f, 0.03900848f, -0.05383885f, 0.00170989f, 
    0.00545768f, -0.01646318f, -0.04793147f, -0.00120529f, 0.00412735f, 0.03600143f, -0.03559861f, 0.01160382f, 
    0.01010334f, -0.02371150f, -0.00929716f, -0.00463864f, -0.00060838f, 0.01312946f, 0.01687078f, -0.02228572f, 
    0.02965399f, 0.01108061f, -0.04058850f, -0.03142449f, 0.00710740f, -0.05166051f, -0.04116314f, -0.00735034f, 
    -0.00941380f, -0.00653958f, -0.03752137f, 0.00971984f, -0.05125758f, 0.01996414f, -0.00996324f, -0.03330719f, 
    -0.03637392f, 0.00812466f, -0.01898788f, -0.02519599f, 0.02827664f, -0.01799634f, -0.05311883f, 0.02546243f, 
    0.01055414f, 0.00661105f, -0.02840410f, -0.00227170f, -0.03147440f, 0.00102527f, -0.01750909f, -0.00222062f, 
    0.01681092f, 0.02833781f, 0.01197748f, -0.05442559f, -0.05068049f, 0.04677878f, 0.00674260f, -0.03504891f, 
    0.02098721f, 0.04533229f, 0.01117076f, -0.00049123f, -0.02849918f, 0.03911467f, -0.00532206f, -0.04793601f, 
    -0.02566556f, -0.03489131f, 0.01267048f, 0.01093681f, -0.01734681f, -0.03493784f, -0.02631746f, -0.02967368f, 
    -0.02487636f, -0.04559323f, 0.01499643f, -0.02729876f, -0.04808825f, -0.03978575f, 0.01282874f, -0.05244179f, 
    -0.05463987f, -0.02424323f, 0.03429786f, -0.03530568f, -0.04615282f, -0.00535044f, -0.04139243f, -0.04506066f, 
    -0.00549670f, 0.02261718f, 0.03756971f, 0.02019473f, -0.00328376f, -0.03652618f, 0.01050376f, -0.02702003f, 
    -0.03762785f, 0.00802196f, 0.04291020f, -0.01216310f, 0.00474277f, -0.04718899f, -0.04449613f, -0.00297449f, 
    0.03080885f, -0.00950215f, 0.01688398f, 0.04647087f, -0.00749721f, 0.03316741f, 0.01168620f, 0.01863108f, 
    -0.03404586f, 0.04536340f, 0.00547249f, 0.03656216f, 0.04220893f, -0.02060710f, -0.00045798f, -0.05339511f, 
    0.04529468f, 0.02788950f, -0.02043113f, -0.00166363f, 0.02943101f, -0.03330662f, 0.00366954f, 0.00867266f, 
    -0.02212971f, 0.02243361f, 0.01377918f, -0.02571003f, 0.01031046f, -0.03331117f, -0.04927796f, -0.02516266f, 
    0.01880017f, -0.03962942f, 0.03928868f, 0.00972863f, -0.00586042f, -0.05605762f, -0.04483937f, 0.00123167f, 
    -0.01905857f, 0.04150231f, 0.04016036f, 0.04135705f, 0.02551254f, -0.01725389f, 0.03498162f, 0.03812400f, 
    0.00573651f, 0.00468958f, -0.03829335f, 0.02455642f, -0.04090351f, -0.01882249f, 0.03091939f, 0.03897873f, 
    0.00825423f, 0.01918078f, 0.04218546f, 0.00174072f, 0.01310484f, -0.00821778f, -0.00859476f, -0.01104639f, 
    -0.02824473f, 0.01675053f, -0.04470051f, 0.01430416f, -0.03701758f, 0.03965475f, 0.02768168f, 0.01592961f, 
    -0.02485586f, 0.00199790f, -0.05078871f, -0.05160728f, 0.02257182f, -0.02019208f, -0.01022701f, 0.02976782f, 
    -0.02861779f, -0.01138852f, -0.05216115f, 0.02821260f, -0.02444677f, -0.03758954f, 0.02577163f, 0.04772137f, 
    0.01957587f, -0.04351857f, -0.01327217f, -0.05193961f, -0.00624221f, 0.03787471f, -0.01714136f, 0.01726961f, 
    -0.04647622f, 0.03078182f, 0.02262303f, 0.01103735f, 0.02341492f, -0.02485232f, -0.02641441f, 0.00303546f, 
    0.04440149f, -0.02547986f, 0.00743153f, -0.01951694f, 0.02458198f, 0.02326198f, -0.01606024f, 0.03961640f, 
    0.01024492f, -0.01013506f, -0.00312509f, -0.00592691f, 0.02795632f, 0.03977174f, -0.00282849f, -0.02324577f, 
    -0.05211082f, 0.00766397f, 0.02481839f, 0.01170401f, -0.02550294f, 0.02589238f, -0.05206342f, -0.05614559f, 
    0.01663077f, -0.01681988f, -0.05473398f, -0.02352912f, -0.04494121f, -0.04847644f, -0.02597527f, -0.00969647f, 
    -0.01070796f, -0.03014384f, 0.00590741f, -0.04729446f, -0.01605473f, -0.00007455f, -0.00074405f, 0.02401695f, 
    -0.01429581f, -0.03830275f, -0.04872368f, 0.02394477f, -0.04909876f, -0.04367748f, 0.02116245f, 0.04378741f, 
    -0.03480502f, -0.05087965f, 0.03727030f, -0.02933219f, -0.00890464f, -0.04535452f, 0.01963041f, 0.00544963f, 
    0.03529117f, -0.04096381f, 0.00797484f, 0.02603999f, -0.03670785f, 0.04992076f, 0.01665094f, -0.04085028f, 
    0.02012086f, 0.00396368f, -0.02330460f, -0.03907816f, 0.03030897f, 0.01083721f, -0.00531049f, -0.04832783f, 
    -0.04298820f, 0.04326203f, 0.00496329f, 0.03270340f, 0.02269218f, -0.03148173f, -0.03929163f, -0.03559293f, 
    0.02806753f, 0.02939320f, -0.02201215f, -0.00090645f, -0.00188383f, 0.02095551f, 0.03670621f, 0.01408375f, 
    0.04146297f, 0.00648213f, 0.02155048f, 0.03173150f, 0.00458872f, -0.00543085f, -0.03955954f, 0.04505160f, 
    -0.01222123f, 0.02945473f, -0.03015247f, -0.05380517f, -0.05448215f, 0.03652086f, -0.00876414f, -0.04873347f, 
    -0.01767206f, 0.00057527f, 0.01737178f, 0.01812405f, -0.04915445f, 0.03023271f, 0.00120696f, 0.02722018f, 
    0.03797809f, 0.04212811f, -0.02109709f, -0.02051367f, 0.04494813f, -0.04399718f, -0.04159837f, 0.01138788f, 
    -0.05075139f, -0.02390403f, 0.04550825f, -0.02684887f, -0.03357862f, -0.02241154f, 0.02855296f, -0.04731572f, 
    0.00385978f, 0.02026673f, 0.02696115f, -0.02779307f, 0.04638077f, 0.04829183f, -0.05009025f, -0.00308279f, 
    0.03009713f, 0.00089958f, -0.04148850f, -0.03194608f, 0.03602678f, 0.02549628f, 0.02248180f, -0.01794137f, 
    -0.03945543f, 0.03702097f, 0.01411999f, 0.00909820f, -0.01309627f, -0.03432008f, -0.04267237f, 0.01583121f, 
    -0.01706667f, 0.01435602f, -0.01201121f, -0.04146070f, 0.02715657f, -0.03566948f, -0.01886941f, 0.00895571f, 
    0.02709227f, 0.03257424f, 0.01204943f, -0.04509133f, -0.02902968f, -0.02225741f, 0.02879003f, 0.02775062f, 
    -0.05119026f, -0.03006979f, -0.00527557f, -0.02330793f, -0.03400765f, 0.00615656f, -0.03131664f, 0.02408808f, 
    0.01807836f, 0.04490485f, -0.05222576f, -0.00547862f, 0.01471468f, 0.02500883f, 0.03455077f, -0.01478217f, 
    -0.00907278f, 0.03608858f, 0.04048146f, -0.05245056f, 0.02315926f, -0.01315089f, 0.03536094f, 0.02455321f, 
    0.03313387f, 0.03146674f, -0.03471839f, 0.03000993f, 0.03894712f, -0.05646406f, -0.00148400f, -0.04011703f, 
    -0.05448547f, -0.04190249f, 0.01954525f, 0.03185072f, 0.00466468f, 0.03261091f, -0.00767602f, -0.03661890f, 
    0.00024715f, 0.03257224f, 0.02795545f, -0.02596110f, 0.00712956f, 0.01613463f, -0.04912176f, -0.04266238f, 
    0.03850883f, -0.00011821f, -0.00624600f, -0.01722713f, -0.04303002f, -0.01485659f, 0.01971673f, -0.00060013f, 
    -0.03201189f, -0.03504442f, 0.03958917f, -0.01379948f, -0.05012568f, -0.03009932f, 0.01555483f, 0.01065843f, 
    -0.03178883f, -0.00117328f, -0.03091864f, -0.04236400f, -0.00316616f, -0.03461777f, -0.02015727f, 0.00377270f, 
    0.01418652f, -0.02433753f, -0.05318985f, 0.02998737f, -0.05230309f, -0.01475618f, -0.05275488f, 0.01205283f, 
    0.00072808f, -0.00178256f, -0.01730378f, 0.03120507f, -0.01458398f, -0.02870624f, -0.02185792f, 0.01111256f, 
    0.02309022f, 0.03880864f, 0.04017977f, -0.02828292f, -0.04567588f, -0.03019034f, 0.02008783f, -0.05501936f, 
    -0.04556876f, 0.00817386f, -0.05461444f, 0.00078884f, -0.04422003f, -0.04094552f, -0.04268947f, -0.04856262f, 
    0.00574200f, -0.04955019f, -0.01243331f, 0.00592668f, -0.03323682f, 0.02874803f, 0.03177593f, -0.04207230f, 
    0.03210366f, -0.03136271f, -0.05054217f, -0.05511216f, 0.01286995f, -0.05413169f, 0.00149660f, -0.02764810f, 
    -0.05462273f, -0.03633010f, -0.00901008f, 0.02496123f, 0.00567777f, -0.01564384f, 0.02858154f, -0.03187329f, 
    -0.03948409f, 0.00609307f, -0.02479040f, 0.03647540f, 0.01888153f, -0.00266115f, -0.04925479f, 0.04277982f, 
    -0.03206503f, 0.03168140f, -0.00822654f, 0.04277411f, -0.00424913f, -0.02117905f, 0.01629969f, -0.02374625f, 
    -0.03990602f, -0.02155100f, -0.02529309f, 0.00121628f, -0.01108166f, -0.00518364f, -0.02943189f, -0.00285908f, 
    -0.01704380f, 0.01236521f, 0.01182870f, -0.03026166f, -0.05284122f, -0.05065276f, -0.05086804f, 0.00293771f, 
    0.01717336f, 0.00544361f, -0.03467548f, 0.01137769f, 0.01695698f, -0.03599240f, -0.01153983f, -0.00821197f, 
    -0.01942568f, -0.04506552f, -0.00823297f, -0.00392474f, -0.01207098f, 0.00677025f, 0.01148624f, -0.02676263f, 
    -0.02732489f, -0.04905299f, -0.00697046f, 0.03572374f, -0.03576761f, -0.01499572f, -0.01491095f, -0.00799664f, 
    0.01912167f, 0.00146985f, -0.01938208f, -0.03090823f, 0.02574722f, 0.02712931f, 0.04831009f, -0.04005467f, 
    -0.02502739f, -0.05111282f, 0.00355809f, 0.00142671f, -0.04416827f, -0.02162356f, 0.01446305f, -0.03097666f, 
    -0.01591614f, 0.01890562f, -0.04620301f, -0.00347903f, 0.03871444f, -0.03315063f, -0.02919047f, 0.00974150f, 
    -0.05279912f, -0.04817310f, 0.02905876f, -0.02424772f, 0.01779674f, 0.03609279f, 0.02743291f, 0.04230432f, 
    -0.05061235f, 0.01867011f, -0.01793705f, 0.02201725f, 0.04078100f, -0.01941273f, 0.01923012f, -0.00513473f, 
    -0.03181856f, 0.01537259f, -0.01185515f, -0.03934149f, 0.01940179f, 0.02404068f, -0.01044251f, -0.04009973f, 
    -0.03452537f, -0.00425116f, 0.00795452f, 0.01839351f, 0.00658678f, -0.02021172f, -0.01072300f, 0.04411368f, 
    -0.00609405f, 0.02804337f, -0.02896823f, -0.05259913f, 0.03688095f, -0.00064544f, -0.01800335f, -0.04249362f, 
    -0.01673781f, -0.03401238f, 0.01652064f, 0.02580228f, -0.03353355f, -0.01443085f, -0.03695181f, -0.01570102f, 
    0.31318635f, 0.23425634f, 0.02556701f, -0.24370253f, 0.06599434f, -0.08188467f, 0.03565839f, 0.00865981f, 
    0.16354494f, 0.08097012f, 0.03995742f, 0.04326823f, -0.08393216f, 0.08883534f, -0.41265732f, -0.00476584f, 
    0.05932256f, 0.32314914f, 0.05697095f, 0.02249526f, -0.11259199f, 0.03233099f, -0.02805552f, 0.02808599f, 
    -0.02748589f, -0.02132323f, -0.04584374f, 0.10540622f, -0.12055466f, -0.03684705f, -0.01472866f, -0.08024210f, 
    0.03152917f, 0.08778923f, 0.10967595f, 0.05138741f, -0.17294994f, -0.22915064f, -0.07028709f, -0.02624212f, 
    0.09512942f, 0.02915814f, -0.19392508f, 0.08845333f, 0.01521741f, -0.01498520f, 0.24790978f, -0.11742736f, 
    -0.06174602f, -0.18797523f, 0.08360808f, 0.05890004f, 0.04682726f, 0.04580927f, -0.09553693f, -0.02726647f, 
    -0.00862943f, 0.02397382f, 0.00691685f, 0.00646830f, 0.03218101f, 0.24584451f, -0.33021069f, 0.26689669f, 
    -0.10186539f, 0.00134434f, 0.12048059f, -0.03245001f, 0.03031619f, 0.03108085f, 0.07414607f, -0.01266800f, 
    -0.28416604f, -0.12498255f, 0.27871975f, -0.05723782f, 0.07881868f, -0.04703722f, -0.10627861f, 0.33364913f, 
    0.02595737f, -0.01913434f, -0.02641135f, -0.08558913f, 0.19549529f, 0.21490383f, -0.05536791f, 0.20284288f, 
    -0.05302622f, -0.11086549f, -0.15484416f, 0.02046834f, -0.02924000f, -0.02819155f, 0.04446695f, 0.07231968f, 
    0.32663497f, 0.07708073f, 0.00873620f, -0.06963055f, 0.09129297f, 0.09407157f, -0.02105120f, -0.04487377f, 
    0.04487010f, 0.00781851f, 0.07256668f, 0.03684073f, 0.15323317f, -0.31946158f, -0.70844054f, -0.04272994f, 
    -0.04571195f, 0.09874478f, -0.03869155f, -0.03011218f, 0.00774920f, 0.01048657f, 0.13323525f, 0.03528449f, 
    -0.31743339f, -0.04285451f, -0.14010283f, 0.08165113f, 0.11044179f, 0.03687500f, 0.05540259f, -0.00440313f, 
    0.06051277f, -0.03451373f, 0.14419505f, -0.01246944f, -0.06598399f, -0.08410647f, 0.01360958f, 0.04112049f, 
    -0.03215138f, 0.00127085f, -0.15409708f, 0.09334998f, -0.06020955f, 0.15058036f, -0.01130647f, -0.05223662f, 
    -0.07264365f, 0.26289281f, -0.03491949f, 0.10503034f, -0.05067679f, -0.00614503f, -0.04310912f, 0.24480066f, 
    0.18995973f, 0.04197001f, 0.07381396f, 0.08428904f, -0.09502298f, -0.18411350f, 0.06063082f, -0.01596531f, 
    -0.06384755f, 0.04105829f, -0.00001343f, 0.04439958f, 0.01888378f, 0.09098247f, 0.10335032f, 0.12735392f, 
    -0.09852105f, -0.18245323f, -0.05931696f, 0.01454050f, 0.02455592f, 0.02560625f, 0.01073548f, 0.00671490f, 
    -0.18426628f, -0.05563927f, 0.03764263f, 0.03138499f, -0.06368160f, 0.36797193f, -0.07742289f, 0.02998655f, 
    -0.17981616f, -0.06596386f, -0.08127823f, 0.00570195f, 0.05907735f, -0.06492420f, -0.03954403f, 0.17179461f, 
    -0.08741022f, -0.09513123f, -0.20122680f, -0.03197049f, -0.07826991f, 0.13807464f, -0.07118466f, 0.03074978f, 
    0.11514983f, 0.17936935f, 0.16480307f, 0.03150455f, 0.20584409f, 0.00582245f, 0.15614623f, -0.02730334f, 
    0.07411177f, 0.08436799f, -0.01022311f, 0.08445688f, -0.03048394f, 0.02127621f, 0.00956844f, -0.06071904f, 
    -0.08095298f, -0.04782855f, -0.00050046f, -0.00741257f, -0.06171913f, -0.03712461f, 0.08911635f, 0.05243338f, 
    0.11216799f, 0.11068432f, 0.08858230f, 0.14127040f, 0.32804224f, 0.00548778f, -0.21770546f, -0.04338186f, 
    0.06723674f, 0.06878690f, 0.07886446f, -0.06419166f, -0.04935277f, -0.03403093f, 0.06631541f, 0.06205494f, 
    -0.00041860f, -0.27174720f, -0.07051480f, -0.13736069f, 0.16782202f, 0.02750746f, -0.12326955f, 0.07349382f, 
    0.05340610f, -0.13161398f, -0.10036437f, -0.00412540f, -0.06435090f, -0.03046750f, 0.29976013f, 0.04789351f, 
    -0.00837546f, -0.03291184f, -0.05924260f, 0.02280144f, 0.03192640f, 0.01125716f, 0.00250455f, 0.07940529f, 
    0.28108937f, 0.08255753f, -0.11090066f, -0.27319941f, 0.11669730f, 0.22927055f, 0.21255597f, -0.12988582f, 
    0.09724393f, -0.07595464f, -0.03373928f, -0.09162331f, 0.00401004f, 0.09241724f, 0.02164342f, -0.03843019f, 
    -0.02749086f, -0.06580745f, -0.07211089f, 0.02955697f, -0.03773383f, 0.05665100f, 0.08996920f, 0.06392545f, 
    0.28576353f, 0.21232119f, 0.08267790f, -0.05627191f, -0.09929180f, -0.05211489f, 0.07489658f, -0.08134121f, 
    0.05740004f, 0.06058534f, 0.05356729f, -0.02924355f, 0.42149290f, -0.18578169f, 0.01930020f, -0.01914658f, 
    0.26074842f, 0.07200859f, -0.02983113f, 0.12878290f, -0.11380982f, -0.13562852f, -0.09327551f, 0.00561724f, 
    0.13540153f, 0.16930671f, 0.06053521f, 0.12437709f, 0.08022387f, 0.10052371f, -0.00659800f, -0.13497461f, 
    0.05578052f, -0.02691039f, 0.05753283f, 0.03128693f, -0.56494707f, -0.21258932f, -0.39584798f, -0.07053389f, 
    0.06350984f, 0.09521887f, 0.11842617f, 0.13165618f, 0.08579641f, -0.01560600f, -0.30423123f, -0.19245927f, 
    0.02949000f, -0.05984633f, -0.07788435f, 0.04585100f, -0.09183443f, 0.00182611f, -0.07898469f, 0.00350292f, 
    0.01178627f, 0.07239705f, 0.10894168f, 0.21817051f, 0.02633376f, 0.01506414f, -0.01866888f, -0.12651381f, 
    0.07634419f, -0.02554006f, 0.04005748f, -0.07472347f, 0.12471389f, -0.03244525f, -0.00545271f, 0.02180489f, 
    0.09751566f, 0.11786246f, 0.04520444f, -0.04238284f, -0.13147362f, -0.06233269f, -0.08189963f, -0.02161588f, 
    0.06287676f, 0.01722666f, -0.02896351f, 0.03415238f, 0.06335872f, 0.25120163f, 0.06678697f, -0.03662730f, 
    -0.18594612f, 0.07119579f, 0.09851664f, 0.04017276f, 0.00023238f, -0.10726037f, 0.02609588f, 0.14562379f, 
    0.09502937f, -0.01776830f, -0.20137691f, -0.01118269f, -0.01101422f, -0.10713669f, -0.05225043f, -0.05759798f, 
    -0.13240762f, -0.01171769f, -0.02190533f, -0.10614765f, 0.11620724f, -0.13034670f, -0.08109801f, 0.19951589f, 
    0.07745868f, 0.23445038f, 0.20343500f, 0.03445679f, 0.00507564f, 0.03641759f, -0.01602848f, 0.21699964f, 
    -0.16871853f, -0.16114612f, 0.03166736f, -0.03914945f, 0.08725965f, 0.05352248f, -0.05397283f, -0.07657697f, 
    -0.20551227f, -0.03398858f, 0.08045849f, 0.01685587f, -0.11580979f, -0.07879908f, 0.33255491f, -0.11568075f, 
    -0.22578029f, -0.00027401f, 0.02000892f, 0.08987048f, 0.13601267f, 0.05123245f, 0.29032388f, 0.02906039f, 
    0.09154279f, 0.16392416f, -0.08052938f, 0.34622803f, -0.00132208f, -0.00616262f, -0.05258390f, 0.03637616f, 
    0.02200032f, 0.02797969f, 0.00460730f, 0.07453421f, -0.21390793f, 0.06189971f, -0.12428020f, 0.29627424f, 
    0.10153374f, -0.10618536f, 0.13710582f, -0.14255363f, 0.11411799f, 0.02073850f, -0.03307795f, -0.03358095f, 
    0.11116008f, 0.12158123f, 0.16338836f, -0.02472558f, -0.21768177f, 0.33513746f, -0.03497536f, 0.19366691f, 
    0.15793252f, 0.13586192f, 0.14652400f, 0.13551150f, -0.17755583f, -0.01991536f, 0.11965587f, -0.10914488f, 
    -0.12847783f, -0.06710733f, -0.15044492f, 0.03632761f, 0.05664131f, -0.20191543f, 0.08216727f, -0.00719643f, 
    0.07394234f, -0.17310585f, -0.19179204f, -0.13697851f, 0.08215124f, 0.02451567f, -0.06495203f, -0.01394355f, 
    -0.01483727f, -0.04717085f, -0.10582196f, -0.09142064f, -0.33274060f, -0.09059596f, -0.04983470f, 0.34822950f, 
    0.04156066f, 0.03807462f, 0.24255159f, 0.07394935f, 0.06037692f, 0.02144906f, 0.09543744f, 0.15766579f, 
    -0.01489229f, 0.33148238f, -0.11897559f, -0.10907473f, 0.13669288f, -0.10947958f, 0.13635361f, 0.04003542f, 
    -0.05243098f, 0.06626309f, 0.07232179f, 0.01623224f, -0.21636970f, -0.06853657f, 0.20449138f, 0.10265125f, 
    -0.07851730f, 0.00212011f, 0.14545651f, -0.13979447f, 0.05541877f, 0.08499847f, -0.02241513f, -0.09739802f, 
    0.40590534f, -0.01320462f, 0.04940541f, -0.11104483f, 0.06605523f, -0.03800510f, 0.12866789f, 0.23052713f, 
    0.06018972f, 0.04944215f, 0.01444461f, 0.05695799f, -0.06676091f, 0.09419081f, -0.04094690f, -0.19217205f, 
    0.06709582f, -0.07597743f, 0.11217703f, 0.05237334f, -0.13288710f, -0.00674636f, -0.00135258f, 0.13595307f, 
    0.02171560f, -0.02862533f, -0.08581579f, -0.24081537f, -0.09469175f, -0.08266805f, 0.04848276f, 0.08752718f, 
    0.12915359f, 0.20793934f, 0.03129244f, 0.08893761f, 0.17408918f, 0.38325298f, 0.00877675f, -0.34806338f, 
    0.01504216f, -0.05111598f, -0.13430075f, 0.00897406f, -0.07576048f, 0.10665002f, -0.06014013f, 0.17538913f, 
    0.07635417f, 0.10162948f, -0.03749549f, -0.12183446f, 0.04355058f, 0.00880224f, 0.00413183f, -0.14724509f, 
    -0.01747255f, 0.12418120f, 0.11827142f, -0.06616561f, -0.12316544f, 0.13856421f, -0.14041874f, 0.18815072f, 
    0.11654863f, -0.14290290f, 0.07088000f, -0.07426559f, 0.02112199f, -0.02215738f, -0.05160509f, -0.21181005f, 
    -0.03376669f, 0.05220545f, -0.09404828f, -0.15607201f, -0.02109323f, -0.08517195f, 0.08208832f, 0.00527500f, 
    -0.08532128f, -0.02957400f, -0.10779018f, -0.10317852f, 0.07772486f, -0.22123870f, -0.14553922f, -0.00252910f, 
    0.12729913f, 0.06299847f, -0.00864555f, -0.00970901f, 0.01131052f, -0.02969715f, 0.08636806f, 0.07823091f, 
    0.06274024f, 0.16728292f, -0.33833170f, 0.12473971f, 0.13499020f, -0.07897995f, 0.07279037f, -0.03326466f, 
    0.10164320f, 0.06720775f, 0.11068229f, 0.09697668f, -0.13710411f, -0.04405553f, 0.15836611f, 0.03323352f, 
    -0.00905214f, 0.08205885f, 0.10214244f, -0.04799821f, -0.01627431f, -0.08787509f, 0.05576582f, 0.18456900f, 
    -0.00688237f, 0.12875238f, -0.25963181f, -0.17596124f, -0.00396210f, 0.05135985f, -0.01634575f, -0.01337991f, 
    0.00627186f, 0.17370377f, -0.13685000f, -0.16379578f, 0.02599307f, -0.23029560f, -0.19997366f, -0.19072828f, 
    -0.12313324f, 0.00487996f, -0.01370706f, -0.06797453f, -0.00286416f, 0.00797690f, -0.08382982f, -0.16770586f, 
    0.09193682f, -0.05343608f, -0.14754763f, -0.02574321f, 0.02742085f, 0.09334484f, 0.13305825f, -0.00516239f, 
    -0.07892552f, -0.07462549f, 0.01777365f, -0.09238626f, 0.14448430f, 0.12239730f, -0.08212370f, 0.13731290f, 
    0.23498714f, 0.00168109f, 0.33272588f, 0.07818528f, -0.04337903f, 0.01154622f, -0.04698699f, 0.07229803f, 
    -0.08588316f, -0.02366862f, -0.03511852f, -0.02961636f, -0.03052473f, -0.07759693f, -0.12171863f, -0.02465151f, 
    -0.09097869f, -0.01906977f, -0.08198660f, -0.00565627f, -0.02174387f, -0.05529258f, 0.24797998f, 0.03288452f, 
    0.07276143f, 0.03939387f, -0.00719440f, 0.14406501f, 0.05278989f, 0.12630145f, -0.04059489f, 0.02418316f, 
    -0.21669315f, 0.09629460f, 0.09633052f, -0.03765784f, 0.14160748f, -0.11208670f, -0.10277400f, 0.02880044f, 
    -0.11900568f, 0.09914406f, -0.05591964f, 0.10321751f, 0.29059920f, 0.33802146f, -0.05571500f, -0.37120882f, 
    0.04883444f, -0.03980745f, -0.06095943f, 0.10807472f, -0.09123249f, 0.06671529f, 0.19745575f, 0.08555058f, 
    -0.16383718f, -0.24395424f, -0.04789674f, -0.02035061f, 0.14920084f, -0.03484239f, 0.08249151f, -0.02942858f, 
    -0.07622669f, -0.17724185f, -0.14938170f, 0.01214856f, 0.18163359f, -0.12123727f, 0.01201086f, -0.12642430f, 
    0.06282716f, -0.06158710f, 0.17610511f, -0.11157937f, 0.09450611f, -0.03050743f, 0.14703692f, -0.06428409f, 
    -0.02238190f, -0.00856787f, 0.00807517f, -0.00984128f, 0.00176150f, -0.04788517f, -0.05747642f, 0.03921422f, 
    -0.04800405f, -0.00071678f, -0.01181584f, 0.03016621f, 0.03888997f, 0.01508976f, -0.03803436f, -0.03380712f, 
    -0.02982796f, 0.02172768f, -0.04824682f, 0.01013998f, 0.02885611f, -0.00522847f, 0.02367229f, -0.02369013f, 
    -0.01466662f, 0.02237895f, 0.03142472f, -0.00169369f, 0.02317187f, 0.02857445f, -0.01150798f, -0.04575760f, 
    -0.00136230f, -0.02750280f, 0.00924994f, 0.02928161f, -0.04215827f, 0.03156255f, -0.00925909f, 0.00421424f, 
    0.03284104f, -0.04836765f, -0.02828463f, 0.01831739f, 0.03575383f, 0.03556056f, -0.03479452f, -0.02871892f, 
    -0.04943870f, -0.01866980f, 0.01497398f, -0.01088839f, -0.03268433f, -0.02845051f, -0.02629658f, 0.03264005f, 
    0.01010559f, -0.00913549f, 0.01714240f, 0.04176173f, -0.03438656f, 0.01201609f, 0.01707518f, -0.04614442f, 
    -0.01341603f, -0.05380645f, -0.04463430f, -0.00650440f, -0.01605691f, 0.02866868f, -0.06062542f, 0.02741323f, 
    0.00126505f, -0.00238798f, 0.03389836f, 0.00405633f, -0.06031101f, 0.01632379f, 0.02546486f, 0.02631527f, 
    -0.01366692f, -0.03718343f, -0.01979606f, -0.00744857f, -0.04127668f, -0.03871040f, -0.00660395f, 0.02943943f, 
    -0.02075520f, -0.02083651f, -0.02193153f, 0.01356459f, 0.00896349f, -0.03154039f, 0.00130212f, -0.00859538f, 
    -0.00363003f, 0.01190170f, -0.02911589f, 0.00037773f, -0.02207227f, -0.02413890f, 0.02750054f, -0.01464812f, 
    0.00158046f, -0.02726042f, -0.02841023f, -0.01852179f, -0.01391236f, -0.00112085f, 0.03990715f, 0.02463029f, 
    -0.00247896f, 0.00589852f, -0.03041633f, -0.01397521f, -0.01269370f, -0.00713441f, -0.05647771f, 0.00197842f, 
    0.03567591f, 0.00892770f, -0.00307670f, 0.00059479f, 0.00686023f, 0.02786444f, 0.01837589f, -0.02349514f, 
    0.01159269f, 0.02211680f, 0.00670967f, 0.04334522f, 0.00374556f, -0.03033499f, -0.02117880f, 0.02586291f, 
    -0.06090563f, -0.05820811f, -0.05327765f, 0.02374921f, 0.04082701f, -0.00082894f, -0.01115275f, -0.04593015f, 
    0.03998092f, 0.04332496f, -0.03865184f, -0.02444423f, -0.02437090f, 0.03202192f, 0.02474155f, -0.01841840f, 
    -0.02894550f, -0.05733644f, -0.03080957f, 0.03670353f, 0.03819254f, 0.01430920f, 0.04223111f, -0.01416063f, 
    -0.00921775f, 0.04314729f, -0.01516978f, 0.03905929f, -0.05413916f, -0.04318880f, -0.05304469f, -0.02076554f, 
    -0.00574432f, 0.02921888f, 0.03380385f, 0.04095049f, -0.01524631f, 0.01082397f, -0.01225737f, -0.02884500f, 
    0.01575440f, 0.04018838f, 0.00411071f, 0.01798481f, 0.01523023f, 0.01051633f, 0.00198113f, 0.03214550f, 
    0.03050288f, -0.03450651f, -0.00860378f, -0.04402540f, -0.04372092f, -0.03360939f, -0.03997776f, -0.03149703f, 
    0.02030711f, -0.00962435f, -0.02944941f, -0.04039884f, 0.03570331f, -0.03477028f, -0.02900216f, 0.00796149f, 
    0.01951781f, -0.05374914f, 0.03475715f, -0.05281132f, -0.05109169f, 0.00551082f, 0.02136986f, -0.02533343f, 
    -0.01317644f, -0.01339228f, 0.02251699f, 0.02891083f, -0.01248778f, -0.03256418f, -0.00003478f, -0.03568237f, 
    -0.01705400f, -0.05699854f, -0.00394728f, -0.04098988f, -0.03794935f, -0.00181936f, -0.01085484f, -0.02968050f, 
    -0.02760869f, 0.02755604f, 0.01722906f, 0.02291954f, -0.04508803f, 0.03313415f, 0.04370360f, -0.04682039f, 
    -0.01649958f, -0.03834192f, -0.00525197f, -0.03262884f, -0.02806798f, -0.00593835f, 0.03758023f, 0.01598973f, 
    0.00190997f, 0.02135214f, -0.03711423f, -0.01571138f, 0.02963830f, 0.03046659f, 0.03603578f, -0.02429750f, 
    -0.05023316f, 0.01088570f, 0.00894757f, -0.02960919f, 0.00220874f, -0.01827838f, -0.05125327f, -0.05067749f, 
    -0.01013028f, -0.00193459f, -0.04763941f, -0.04175785f, -0.02340480f, -0.03431207f, -0.05113828f, -0.05255849f, 
    -0.01256882f, 0.00079209f, 0.02397028f, -0.05803766f, 0.00433168f, 0.02513664f, 0.00696478f, -0.03811653f, 
    -0.04865749f, -0.03561633f, 0.01877648f, -0.01668448f, 0.04452316f, -0.02454406f, 0.00186845f, -0.03233626f, 
    -0.03590867f, -0.04245117f, 0.00063256f, -0.05002300f, 0.02299611f, -0.02366317f, 0.02926441f, 0.02307204f, 
    -0.04694983f, 0.02124759f, -0.04293234f, 0.04436439f, 0.03479855f, 0.00192960f, -0.03741549f, -0.05171579f, 
    0.03820530f, -0.01298004f, 0.01536548f, -0.04481490f, 0.01450244f, 0.00727865f, 0.03004623f, -0.02713867f, 
    0.01460274f, 0.01149465f, -0.00101552f, -0.04002724f, -0.00129777f, 0.00266025f, 0.01228497f, 0.00106577f, 
    -0.00203961f, 0.02153602f, 0.00526646f, -0.00919997f, -0.01989218f, -0.04958744f, -0.00532045f, -0.01565329f, 
    0.00419616f, 0.03816887f, 0.03466246f, -0.02003194f, -0.02053218f, 0.04036351f, 0.02038392f, 0.03401207f, 
    0.01737677f, -0.02862741f, 0.03929032f, -0.04662013f, -0.05551866f, 0.02156695f, 0.03149560f, 0.03214138f, 
    -0.01112781f, -0.03762143f, -0.05313199f, 0.00839482f, -0.00956180f, -0.05069452f, -0.01128596f, -0.05427500f, 
    -0.04302756f, -0.01904555f, -0.00028687f, 0.04180689f, 0.03453603f, -0.02715206f, -0.02507964f, -0.02345894f, 
    -0.00869676f, -0.03307782f, -0.00706652f, -0.04784993f, -0.02168832f, -0.02960184f, 0.00219491f, -0.04091418f, 
    -0.04080274f, 0.00666420f, -0.00719191f, -0.01755285f, 0.01666374f, -0.00122050f, -0.04723217f, -0.03578683f, 
    -0.00676009f, -0.02943021f, 0.02575251f, 0.00618645f, 0.00048490f, -0.05804868f, -0.05754987f, 0.01597177f, 
    -0.04680569f, 0.02476226f, 0.01447769f, -0.00313333f, -0.03449058f, -0.00294143f, -0.05539711f, -0.01873183f, 
    -0.02893544f, -0.04320409f, 0.00428350f, 0.03884900f, 0.00823960f, 0.00092690f, -0.03930926f, -0.05400427f, 
    -0.05615315f, 0.02533529f, -0.05239853f, -0.00001260f, -0.05112116f, 0.00839996f, -0.01463942f, -0.05168964f, 
    0.00202435f, 0.00164747f, -0.01996919f, -0.02893331f, 0.00829526f, 0.04258798f, 0.01315152f, -0.01831177f, 
    -0.02226159f, 0.04442070f, -0.05347637f, 0.01670479f, -0.00511462f, -0.05077293f, -0.02266533f, 0.03934154f, 
    -0.02214338f, 0.00789318f, 0.00540206f, -0.01609195f, 0.01658823f, -0.00613572f, 0.04413985f, -0.04643954f, 
    0.01002436f, -0.02958314f, -0.00082504f, -0.04377522f, -0.04869439f, -0.01429599f, 0.01127113f, -0.02011940f, 
    -0.02837439f, 0.01105724f, -0.03010130f, 0.02221400f, 0.03386591f, -0.02206021f, 0.00955825f, 0.01749097f, 
    0.02484194f, -0.02695481f, 0.02058113f, -0.00321436f, -0.04078866f, -0.04996293f, -0.01819747f, -0.04609700f, 
    0.02316274f, 0.04190776f, 0.00049877f, 0.04201669f, -0.05481159f, 0.04351893f, 0.00416473f, -0.02017480f, 
    -0.03023199f, 0.02331933f, -0.01605025f, 0.02241166f, -0.05105112f, -0.05452174f, -0.02497580f, -0.02202655f, 
    -0.00463705f, 0.01152847f, -0.03157918f, 0.00277997f, 0.00167243f, -0.00867106f, -0.00591493f, 0.03527653f, 
    0.03162287f, -0.02996830f, -0.05248576f, -0.03162966f, -0.05584416f, -0.03736738f, 0.03573681f, -0.02519317f, 
    -0.02324087f, 0.00653561f, 0.00094244f, -0.00079997f, 0.01705002f, -0.02997117f, 0.04147402f, -0.02699280f, 
    0.03516543f, -0.02784580f, -0.03865585f, 0.02962146f, 0.02187107f, 0.03863528f, -0.00858987f, 0.03858834f, 
    -0.02968496f, 0.02605296f, -0.02901635f, -0.05273833f, -0.02592183f, 0.02590621f, 0.00750074f, -0.05643392f, 
    -0.04735360f, -0.03856741f, -0.05010508f, 0.01205873f, 0.04392528f, -0.02468458f, 0.02497900f, 0.01332516f, 
    0.01526490f, 0.03514355f, -0.04124681f, -0.05254794f, -0.02026830f, -0.04008507f, 0.01060606f, -0.01190355f, 
    0.00323321f, -0.01537284f, -0.02241758f, 0.03281431f, -0.05598602f, 0.01142440f, -0.03759658f, -0.01661297f, 
    0.02214034f, 0.04917564f, -0.04466531f, 0.03494775f, 0.00006265f, -0.01888539f, -0.04612557f, 0.00775216f, 
    -0.01695786f, -0.04977568f, -0.00753330f, 0.04327790f, -0.01738167f, -0.01435836f, -0.00149207f, 0.00078791f, 
    0.00314458f, 0.01909244f, -0.04012681f, -0.02370958f, -0.03591350f, -0.00698374f, -0.00341827f, -0.02177712f, 
    0.03449911f, -0.05080799f, -0.04310788f, -0.04470618f, -0.05633697f, 0.03608790f, 0.03012189f, -0.01234627f, 
    -0.00760047f, 0.02210996f, -0.02905073f, -0.04632314f, -0.03547974f, -0.03935553f, -0.01661256f, -0.03045357f, 
    0.04169149f, -0.04955246f, -0.01411348f, -0.05532636f, -0.00443094f, 0.04016756f, -0.05691076f, -0.03191856f, 
    -0.01963089f, 0.02165150f, 0.01264515f, -0.03911730f, -0.04777852f, -0.00614756f, -0.00468664f, -0.04362128f, 
    -0.02907764f, 0.00466301f, 0.00588877f, 0.04117388f, -0.01513740f, 0.01586330f, -0.01865015f, 0.03709078f, 
    -0.03866570f, -0.04189086f, -0.03767771f, -0.04245163f, 0.01709883f, -0.05392063f, 0.02925263f, 0.02953441f, 
    0.01945731f, -0.04482520f, -0.02146704f, -0.02302944f, -0.02511471f, -0.03237380f, -0.03368055f, 0.03466044f, 
    -0.04484826f, -0.01314398f, -0.02086351f, -0.01963734f, 0.01500650f, -0.00986216f, -0.02782394f, -0.05517798f, 
    -0.01992723f, -0.00010120f, 0.01805488f, 0.00613616f, 0.03010869f, 0.00570086f, 0.03905058f, 0.02607523f, 
    -0.00268832f, -0.01381693f, -0.00383201f, 0.01522860f, 0.00122207f, 0.00183902f, 0.03560069f, -0.00980782f, 
    0.03165974f, 0.01471635f, -0.03629124f, 0.03821554f, -0.04080728f, -0.02002964f, -0.00689028f, 0.02260378f, 
    -0.03599609f, 0.04293794f, -0.01063763f, -0.04943053f, -0.02018339f, 0.02235607f, 0.00133545f, 0.01267390f, 
    -0.01549303f, 0.00892854f, -0.02365803f, 0.00796617f, 0.02272437f, 0.02779582f, -0.03675205f, 0.04166128f, 
    -0.02978277f, 0.02456028f, -0.01117020f, 0.03654701f, 0.01600941f, 0.01996461f, -0.04457722f, 0.01799080f, 
    0.04379717f, 0.03741476f, 0.03223125f, 0.00726882f, -0.00752306f, -0.02279573f, 0.00322639f, 0.03878438f, 
    -0.03218367f, -0.03064123f, -0.00883691f, -0.03407102f, 0.01562339f, 0.04065262f, 0.03755051f, -0.00890007f, 
    0.03990273f, 0.04646120f, 0.00522712f, 0.03237618f, 0.03263552f, -0.00781149f, -0.04765844f, -0.03092121f, 
    -0.01577682f, 0.03220947f, 0.03222737f, 0.04017816f, 0.02039957f, 0.03349418f, -0.00381119f, 0.01094313f, 
    -0.00454591f, 0.03959011f, 0.02251660f, -0.05095042f, -0.04672456f, 0.01037529f, -0.00829629f, 0.02304254f, 
    0.04556825f, -0.02299488f, -0.05164962f, -0.05130409f, -0.05406808f, 0.02254433f, 0.02378961f, -0.04735072f, 
    -0.00969623f, -0.05188738f, -0.01550230f, 0.02100896f, 0.01661066f, -0.01347106f, -0.01834305f, 0.00116155f, 
    0.03749985f, -0.00929652f, 0.00107065f, -0.05553212f, 0.03024498f, 0.03987716f, -0.02406441f, -0.02814742f, 
    0.02709018f, 0.03334923f, -0.02321464f, 0.02867141f, -0.03835141f, -0.05063589f, -0.03713266f, -0.01201277f, 
    0.03966333f, -0.04247141f, 0.01582963f, -0.01447673f, -0.00006428f, -0.02216980f, -0.00366365f, -0.05337465f, 
    0.00538773f, -0.04159402f, -0.01261376f, -0.04090581f, 0.03254039f, -0.02108115f, 0.01443855f, 0.00634097f, 
    0.04432113f, -0.00470132f, 0.03044612f, 0.01880180f, 0.01556687f, -0.01974962f, 0.00724393f, -0.04972998f, 
    0.00269820f, -0.02653536f, -0.04130477f, 0.01672451f, 0.00856343f, -0.05270202f, -0.05562077f, -0.04132487f, 
    0.24421258f, 0.12671776f, 0.26698783f, 0.09888598f, 0.05686548f, 0.06237293f, 0.00928791f, 0.04256302f, 
    0.00477327f, -0.05494380f, 0.03559856f, -0.04774586f, -0.18723041f, 0.03359602f, -0.24051267f, 0.11172017f, 
    0.16696180f, 0.07667430f, -0.02360231f, -0.00736477f, 0.11139599f, 0.05422410f, 0.12954125f, 0.09707975f, 
    -0.17648801f, 0.02611160f, -0.09601340f, -0.02251906f, 0.17179258f, 0.11358230f, 0.03961625f, -0.24469088f, 
    -0.09567075f, -0.10922731f, -0.17403695f, -0.15011656f, -0.31013212f, 0.14388034f, 0.25715145f, -0.01598216f, 
    -0.26296225f, 0.07258009f, 0.09373375f, 0.12072179f, -0.03864113f, 0.12587674f, 0.27332643f, -0.02815147f, 
    -0.29288846f, -0.00497266f, -0.12011593f, -0.06291264f, 0.08685018f, 0.03584567f, -0.00570206f, -0.07939259f, 
    0.05578202f, -0.01376990f, 0.01356532f, -0.00333446f, -0.03129853f, 0.14438006f, -0.38957369f, 0.11573516f, 
    0.12684798f, -0.07989293f, 0.18731226f, 0.02817648f, 0.06883818f, 0.01520859f, -0.25842932f, -0.13352521f, 
    0.19093984f, 0.03357004f, 0.15197846f, -0.02917687f, -0.07692309f, 0.05830875f, 0.24224512f, -0.00954102f, 
    0.11956015f, 0.06745879f, 0.10576302f, 0.18107814f, 0.38675734f, -0.06480538f, 0.11881165f, 0.43248609f, 
    -0.16455476f, 0.09238521f, -0.10732936f, 0.18085191f, -0.06329082f, 0.03252890f, -0.07050283f, -0.07866412f, 
    0.34152278f, 0.06593674f, 0.11965822f, 0.17671123f, 0.09244656f, -0.01118911f, 0.09026189f, 0.15713254f, 
    -0.01620997f, 0.07084557f, 0.00412497f, 0.00588381f, -0.64972430f, -0.10521329f, -0.25768209f, 0.01616566f, 
    0.07516754f, 0.02710252f, 0.03040168f, -0.03409578f, -0.02390232f, -0.01367005f, 0.04965348f, 0.22452927f, 
    -0.08638159f, -0.05669820f, -0.28998864f, 0.06485289f, 0.15365253f, -0.06077135f, -0.09613520f, -0.15771769f, 
    -0.08298460f, -0.06227721f, 0.00572776f, 0.01948179f, -0.32839301f, 0.13896050f, -0.09979475f, 0.16660497f, 
    -0.01364676f, -0.02539664f, 0.30437371f, 0.21358040f, 0.11457522f, 0.19396536f, 0.00675866f, -0.10298236f, 
    -0.03983462f, 0.17603543f, -0.48032731f, 0.06113620f, 0.06999835f, -0.07016561f, -0.10997637f, -0.02192723f, 
    -0.03505329f, 0.17862989f, -0.09791359f, 0.10505271f, 0.01525552f, -0.28030297f, -0.11467661f, 0.03325925f, 
    0.15254293f, 0.00307334f, -0.00896271f, -0.00272467f, -0.00308640f, 0.11866183f, 0.00322676f, 0.01960671f, 
    -0.09126707f, -0.29616252f, -0.02967212f, 0.00459159f, -0.03851864f, 0.08641627f, 0.00770884f, -0.03717587f, 
    0.14391746f, 0.23295808f, 0.06847899f, 0.21135901f, -0.15905444f, 0.46046758f, -0.18042134f, -0.17069830f, 
    0.03237757f, 0.00423060f, -0.17063001f, -0.17740981f, -0.22469470f, 0.03649762f, -0.14271937f, -0.03985173f, 
    -0.19656755f, -0.03112204f, -0.07106959f, -0.23045085f, -0.16801812f, 0.20086837f, -0.12299306f, 0.00822227f, 
    0.32838222f, 0.14233615f, 0.03934991f, -0.00492772f, -0.00728459f, 0.20859621f, 0.02012402f, 0.21324436f, 
    0.12082233f, 0.00505585f, 0.02170538f, 0.10332091f, 0.00113056f, -0.10605728f, -0.10550887f, -0.27064258f, 
    -0.17870775f, -0.08659164f, -0.01833091f, 0.02651905f, 0.14636065f, -0.15970562f, 0.04962490f, -0.12099855f, 
    -0.02407980f, 0.00650999f, -0.08672972f, 0.02515156f, 0.16522267f, -0.15197119f, -0.05406286f, 0.12199626f, 
    0.15516636f, 0.04632561f, 0.03753039f, 0.03263386f, 0.04732921f, 0.06381259f, 0.17390597f, 0.15398705f, 
    -0.17795199f, -0.19259824f, -0.11877597f, 0.01447009f, 0.18773550f, -0.06272082f, -0.04634593f, -0.09609546f, 
    0.02894639f, 0.02280675f, 0.09916425f, 0.10064878f, 0.37085125f, -0.03582702f, 0.36190858f, 0.23658314f, 
    0.00385975f, 0.01579094f, -0.03320774f, 0.06305906f, -0.03761217f, -0.02017681f, 0.03511262f, -0.00770008f, 
    0.13585229f, -0.15277389f, 0.17560387f, 0.09894291f, 0.26630729f, 0.09505323f, -0.00892003f, -0.16520311f, 
    0.09000588f, 0.15292017f, -0.02348979f, -0.11914261f, 0.10866104f, 0.06922591f, 0.02034814f, -0.04991619f, 
    -0.06967568f, 0.08656964f, -0.02537177f, -0.06090807f, -0.03465269f, -0.04734236f, -0.01640030f, -0.16666004f, 
    0.09479967f, 0.01507577f, 0.15844126f, 0.12108655f, 0.03240839f, 0.09796387f, 0.08950815f, 0.19766828f, 
    0.07524968f, -0.00816692f, 0.03221163f, 0.04129363f, 0.21003361f, -0.24839243f, -0.04134886f, -0.05162517f, 
    0.27076927f, -0.01888435f, -0.09987774f, 0.19485737f, -0.09456745f, 0.01664548f, 0.04098807f, 0.03444459f, 
    -0.03036682f, 0.15986019f, 0.05123598f, 0.17794627f, 0.13367777f, 0.03998472f, 0.03650922f, -0.13012807f, 
    -0.01815441f, -0.15737092f, -0.25789803f, -0.28845394f, -0.37705737f, 0.13906062f, -0.15109158f, 0.12882015f, 
    0.00079969f, -0.04429642f, -0.07632758f, -0.19224003f, 0.10018393f, 0.08156717f, -0.12104842f, 0.06250017f, 
    -0.04698100f, -0.00526672f, -0.20398225f, 0.18010992f, 0.08860999f, 0.04842323f, -0.16779643f, -0.03203967f, 
    -0.00840631f, -0.01616479f, 0.07662151f, -0.00565829f, -0.29083186f, 0.02913793f, 0.10736946f, -0.00247986f, 
    0.20701990f, 0.07063159f, 0.05827487f, 0.00619879f, -0.05530119f, -0.08668364f, -0.06219738f, 0.21651952f, 
    0.27538732f, -0.07442468f, 0.15847638f, -0.02786283f, 0.03633341f, -0.10673700f, -0.06837286f, 0.16569576f, 
    -0.08476046f, -0.05701641f, -0.15366203f, -0.20668434f, 0.10580854f, -0.15692373f, 0.04193671f, -0.14126232f, 
    0.06870978f, -0.14646618f, 0.01589173f, -0.15363461f, 0.16940807f, -0.15247080f, -0.08731459f, -0.06021944f, 
    0.03601241f, -0.04794737f, -0.00813450f, -0.02697740f, 0.02540923f, -0.01409896f, 0.03268433f, -0.00241726f, 
    0.03625181f, 0.00490535f, -0.03903913f, -0.03323151f, -0.02110738f, 0.01203411f, -0.04680174f, -0.02929859f, 
    -0.00092584f, -0.02063382f, -0.03081493f, 0.00102906f, 0.01444572f, -0.00549393f, -0.02091937f, -0.04245644f, 
    -0.02986457f, -0.02225321f, 0.03007724f, 0.02406195f, -0.00323699f, -0.01997802f, 0.03221963f, -0.05290276f, 
    0.00940898f, 0.02418595f, 0.04292805f, 0.00325939f, 0.03596476f, -0.03689267f, 0.02989074f, -0.04597282f, 
    0.03419163f, 0.01289636f, 0.00288747f, 0.01676778f, -0.01037396f, -0.04448625f, -0.05159866f, 0.02229651f, 
    -0.04178264f, -0.00608091f, -0.03447689f, -0.05179562f, -0.03099840f, -0.05547117f, -0.02819022f, -0.01977107f, 
    0.02904716f, -0.02404557f, -0.02798945f, 0.00350963f, -0.03620744f, -0.04324130f, 0.03877877f, 0.00763580f, 
    -0.04637286f, -0.00079891f, -0.01111174f, 0.03621163f, -0.02783245f, -0.00689398f, -0.01703321f, 0.02324789f, 
    0.01563173f, -0.04934116f, -0.04620835f, -0.00989032f, 0.00904912f, -0.04907365f, -0.01733272f, -0.03759298f, 
    0.01334826f, 0.02251797f, 0.01651067f, -0.02264877f, 0.01474584f, -0.03294864f, 0.02680581f, 0.02691819f, 
    0.04287494f, -0.00737844f, -0.01539428f, 0.01080996f, -0.02604005f, -0.01690473f, -0.03509417f, -0.01815630f, 
    -0.02951540f, 0.00299278f, -0.03576363f, -0.00034046f, -0.04117636f, -0.05456227f, -0.03639492f, -0.02014771f, 
    -0.01109169f, -0.00716506f, 0.00059964f, -0.03238074f, 0.03653887f, -0.01139799f, -0.02246106f, 0.01647522f, 
    0.01793354f, -0.02867751f, 0.02130002f, -0.02660595f, -0.01973336f, -0.00468423f, 0.00060416f, 0.02671831f, 
    -0.00326199f, -0.01342201f, 0.04427312f, 0.02272144f, 0.01079357f, 0.03793132f, -0.05521316f, -0.01737801f, 
    -0.00654931f, 0.01127182f, -0.02704621f, 0.02442105f, -0.00069943f, 0.03735544f, 0.04487627f, -0.00721560f, 
    -0.05505673f, -0.01023034f, 0.02809629f, 0.00611782f, -0.03812171f, -0.00444609f, 0.03480776f, 0.03917087f, 
    0.03909200f, -0.02575419f, -0.03062096f, -0.00095086f, -0.05006187f, -0.03883984f, -0.04110736f, -0.02191394f, 
    0.00868748f, 0.00479291f, 0.04384001f, 0.03356057f, -0.02067998f, -0.02946918f, 0.02263333f, -0.01488876f, 
    -0.03040936f, 0.00594993f, -0.01598644f, -0.03392531f, 0.03991212f, -0.00364762f, -0.02757152f, 0.03060932f, 
    -0.01251331f, 0.01318455f, 0.02905593f, 0.01304447f, 0.00938480f, 0.02006859f, 0.01258155f, -0.04590248f, 
    -0.02131896f, 0.01567823f, -0.04905584f, -0.04320737f, -0.01544677f, -0.01753182f, 0.02209903f, -0.03846704f, 
    -0.00348217f, 0.02685707f, -0.04994533f, 0.03488836f, 0.03979893f, -0.04604766f, -0.04592898f, -0.00692248f, 
    0.01756601f, -0.05092185f, 0.01409073f, -0.05148598f, 0.02099303f, 0.01876517f, -0.02017455f, -0.01910315f, 
    -0.04528490f, -0.03798546f, -0.02697411f, 0.01937085f, 0.00538897f, -0.05302405f, -0.02521565f, 0.03228723f, 
    0.02338140f, -0.03318942f, -0.05325520f, 0.00052781f, -0.00576868f, 0.00336127f, -0.02113760f, -0.04332865f, 
    0.00160674f, 0.02452406f, 0.04250916f, -0.02407529f, 0.04483277f, 0.01806330f, 0.02198644f, 0.00157187f, 
    -0.04540764f, -0.04306970f, -0.03510271f, -0.05129520f, -0.02483816f, -0.01206719f, 0.01109458f, -0.01653271f, 
    0.04207235f, -0.02290932f, -0.02762762f, 0.01586922f, -0.02492823f, 0.03450339f, -0.04465167f, 0.03886041f, 
    -0.01697004f, 0.03797162f, 0.03393799f, -0.04898969f, -0.04863572f, 0.02050410f, -0.01500029f, -0.01584821f, 
    0.03249537f, 0.04429700f, -0.03635072f, 0.00143468f, 0.03621989f, -0.05167585f, -0.01457499f, -0.01490325f, 
    -0.01742955f, -0.02780403f, 0.02495129f, -0.02224393f, -0.04642805f, 0.03436727f, 0.01344133f, -0.05253069f, 
    -0.03428461f, -0.02328717f, 0.03199655f, -0.03135791f, -0.05425754f, 0.03336670f, 0.02555865f, -0.00531159f, 
    -0.03128236f, -0.04728659f, -0.00290793f, -0.00357185f, -0.01177199f, -0.04863730f, 0.04127382f, -0.04559415f, 
    -0.05456125f, 0.00772248f, -0.05580267f, 0.00364651f, 0.02104075f, -0.05041568f, 0.03398250f, 0.00963394f, 
    0.01723612f, -0.04663693f, 0.02989152f, 0.04478079f, -0.01847534f, 0.02823690f, -0.04455534f, -0.01200821f, 
    0.02134660f, -0.00567573f, -0.03353826f, -0.05059818f, -0.02978653f, -0.05148299f, -0.02898950f, -0.03510784f, 
    -0.05488607f, -0.04758013f, 0.00138138f, -0.02607464f, 0.03515971f, 0.02458857f, -0.03012929f, -0.01466480f, 
    -0.04766566f, 0.02069788f, 0.03417895f, -0.04367304f, -0.02482506f, -0.02163608f, -0.01851948f, -0.02622919f, 
    0.00502442f, 0.01920241f, -0.03774724f, -0.02972193f, 0.03462019f, 0.02714549f, -0.03889255f, 0.00228176f, 
    0.00841003f, -0.05061533f, -0.05541144f, -0.03517689f, 0.03704847f, 0.04398025f, 0.00490118f, 0.01852400f, 
    -0.05469946f, -0.02748171f, -0.02151216f, 0.03201342f, -0.03645282f, -0.05033446f, -0.03957432f, -0.00893213f, 
    0.03352603f, 0.00445083f, 0.02724340f, -0.02851034f, -0.00434292f, -0.03712262f, -0.04714305f, -0.05321246f, 
    0.03927634f, -0.02296771f, -0.03796919f, -0.01054168f, 0.00245346f, -0.02792854f, -0.04444592f, 0.04094225f, 
    -0.02933152f, -0.01096852f, -0.00691483f, -0.01334477f, 0.00400647f, 0.01086557f, 0.04011368f, 0.02779043f, 
    -0.01443808f, 0.00969881f, -0.01451123f, -0.05355566f, -0.01867745f, 0.00809043f, -0.01297836f, 0.00033982f, 
    -0.01119058f, -0.04154125f, -0.00675988f, 0.00379315f, 0.02697575f, 0.03900102f, 0.01824013f, -0.04879137f, 
    -0.28001454f, -0.04140095f, -0.16550675f, 0.18303268f, -0.02112642f, 0.07766250f, 0.04030886f, -0.02632096f, 
    -0.02229430f, 0.01287666f, 0.07912118f, 0.11375404f, -0.10462171f, 0.10476982f, 0.39598891f, -0.02390913f, 
    -0.00375830f, -0.07358158f, 0.09031998f, 0.20669208f, 0.10029566f, 0.09011609f, 0.13254990f, 0.14016598f, 
    -0.00080058f, -0.05055365f, 0.00038772f, -0.03617381f, 0.05984062f, 0.02792639f, -0.09095789f, -0.07119878f, 
    -0.09375822f, -0.04570769f, -0.04888225f, -0.08281197f, -0.05332841f, -0.05939199f, 0.11600318f, -0.03652318f, 
    -0.04717063f, 0.00824276f, 0.09647456f, 0.07257743f, 0.10815454f, 0.03510805f, 0.07445740f, -0.09854891f, 
    -0.04488304f, 0.05942127f, -0.13475925f, -0.18759540f, 0.02217583f, -0.03716786f, 0.02102102f, -0.01205034f, 
    0.09761427f, 0.17671444f, 0.03923472f, 0.05997249f, -0.17122066f, -0.09564142f, 0.07687219f, 0.15431157f, 
    0.14724153f, 0.13298862f, -0.15031080f, 0.21118402f, -0.05498123f, -0.05253301f, -0.03482833f, -0.02508910f, 
    0.28762600f, -0.08359803f, -0.30582082f, 0.25705224f, 0.02717261f, 0.02719205f, 0.14957510f, -0.18416128f, 
    -0.00346784f, 0.08108282f, 0.00931107f, 0.05579074f, -0.01304326f, -0.39852384f, 0.13035092f, 0.21477401f, 
    -0.04534673f, -0.02011255f, 0.03447523f, -0.00726082f, -0.04671272f, 0.01905864f, -0.03848866f, -0.00322243f, 
    -0.27684414f, -0.15102950f, -0.03223664f, 0.06745460f, -0.07206861f, -0.07306362f, 0.13978781f, 0.08800384f, 
    -0.02228543f, -0.01004625f, 0.06199313f, -0.03149193f, -0.52279413f, 0.38980025f, 0.65195954f, -0.03641307f, 
    -0.06922691f, -0.07899201f, -0.05269037f, -0.02314053f, -0.08963655f, 0.01830074f, 0.05042450f, 0.18227395f, 
    0.08490342f, 0.05676029f, 0.29832178f, 0.07173033f, 0.01647745f, -0.05273177f, -0.11451221f, 0.14096905f, 
    0.00475133f, -0.04352938f, 0.01066265f, -0.00265533f, -0.16628100f, -0.08137402f, 0.00171453f, -0.11910360f, 
    0.11521360f, 0.08569470f, 0.00147767f, 0.07049488f, 0.04545701f, 0.01800050f, -0.12604006f, 0.00195442f, 
    -0.00405466f, -0.18970482f, -0.19250239f, 0.03928979f, 0.01818098f, 0.04531758f, -0.02692443f, 0.01848696f, 
    0.00961087f, -0.05912067f, 0.12492614f, -0.04397573f, -0.22277632f, -0.14914936f, -0.14458169f, -0.04485292f, 
    -0.00495388f, -0.03394061f, -0.03357898f, -0.01424069f, 0.02524583f, 0.09308509f, -0.15277494f, -0.07788789f, 
    -0.12760432f, -0.09519210f, -0.16427951f, 0.03713947f, -0.04777128f, 0.05580854f, 0.02532792f, 0.06119088f, 
    0.31840241f, 0.17394163f, -0.08805181f, 0.20176196f, -0.19067873f, 0.10954530f, 0.02409498f, 0.21792018f, 
    0.19781867f, 0.10807871f, -0.12297045f, -0.00195761f, -0.13215220f, 0.04776811f, 0.08245116f, 0.00469192f, 
    -0.02832183f, -0.05064519f, 0.04443777f, -0.12749766f, 0.04902183f, -0.05201973f, 0.00923886f, -0.03792514f, 
    0.29093650f, 0.08649769f, -0.01992339f, 0.10756838f, -0.09114865f, 0.11374938f, 0.12207638f, -0.14182159f, 
    -0.02154318f, -0.06214877f, -0.10335094f, -0.06163150f, -0.03885949f, -0.03492709f, -0.04955425f, -0.08146524f, 
    -0.13679506f, -0.09090899f, -0.06265121f, -0.03717334f, 0.05855574f, 0.04323495f, -0.09710599f, -0.02026486f, 
    0.05114531f, 0.04841164f, 0.06583256f, -0.05358862f, -0.30682385f, -0.08941260f, 0.16730680f, 0.20325899f, 
    -0.13845384f, -0.05104306f, 0.01138565f, 0.05433519f, 0.01714853f, -0.00679115f, 0.09103688f, -0.05157861f, 
    -0.08474495f, 0.04043069f, 0.27383921f, 0.08449068f, -0.06807631f, -0.08058388f, 0.13133538f, 0.14035232f, 
    -0.06129234f, 0.14516000f, 0.08629128f, 0.28029820f, 0.21689643f, -0.04542270f, -0.10197089f, 0.45340475f, 
    -0.01347596f, 0.08654825f, 0.09940299f, 0.03298774f, -0.04454430f, -0.00164338f, -0.01626911f, 0.09326801f, 
    -0.21050628f, -0.08166719f, 0.33666277f, 0.12364883f, 0.14530243f, -0.17445333f, -0.09160665f, 0.12954544f, 
    -0.01285341f, -0.07413782f, 0.01227381f, -0.06389694f, -0.11497635f, -0.02155138f, -0.27453697f, 0.05926908f, 
    -0.11036402f, 0.05542690f, 0.11626615f, -0.01435420f, 0.06434057f, -0.00522299f, -0.07410316f, 0.02219557f, 
    -0.35730311f, -0.29714936f, -0.09434211f, -0.03527962f, -0.05751779f, 0.03856033f, 0.08424202f, 0.07587548f, 
    0.02567011f, 0.08171367f, 0.01962594f, 0.07085647f, 0.01170888f, 0.21238068f, 0.07247601f, 0.09593209f, 
    -0.01254320f, -0.07913075f, 0.05526973f, 0.27528098f, -0.07771043f, 0.06033592f, 0.08828662f, 0.01418939f, 
    0.00449874f, -0.11452214f, -0.11105035f, -0.11724590f, 0.03336129f, -0.10881380f, 0.00827625f, 0.04643039f, 
    0.06191387f, -0.01912554f, 0.01355975f, -0.00682566f, 0.06995350f, 0.32995418f, 0.34300840f, 0.18322937f, 
    -0.02748753f, -0.06912862f, 0.03106404f, -0.10564639f, 0.03530587f, 0.10790332f, 0.06677383f, 0.13686924f, 
    -0.25640169f, -0.13105074f, -0.05120095f, -0.11230180f, -0.02616652f, -0.04695365f, -0.01037329f, -0.04429509f, 
    0.08866200f, -0.03444206f, 0.03274476f, -0.02074668f, -0.38525456f, 0.08766325f, 0.08563627f, 0.37217292f, 
    0.01284347f, 0.05102412f, -0.09430631f, 0.04438834f, -0.06388088f, 0.05885751f, 0.12866507f, 0.11163682f, 
    0.00745846f, -0.17113186f, -0.02486117f, 0.07206100f, 0.12571661f, 0.09388784f, 0.02956054f, 0.09370055f, 
    0.01800260f, -0.03279946f, -0.05299239f, -0.08254637f, -0.02734081f, -0.08406974f, -0.04587602f, 0.04180348f, 
    0.02922786f, -0.01881137f, 0.14090826f, 0.10470410f, -0.07229345f, -0.08551855f, -0.01748092f, 0.03870692f, 
    -0.12779383f, 0.04958667f, 0.11845130f, 0.14898919f, 0.05021570f, 0.07321645f, -0.00087364f, -0.08594297f, 
    0.00820432f, 0.05219063f, 0.10553133f, 0.08598071f, -0.21324891f, 0.02185652f, 0.04800181f, 0.08180340f, 
    0.11057925f, -0.02590229f, 0.23790859f, 0.00752419f, -0.17340799f, 0.06274183f, -0.08353671f, -0.01668702f, 
    0.01147236f, 0.04569454f, 0.02555646f, 0.08378880f, 0.07945623f, -0.11392393f, -0.11599801f, -0.08230909f, 
    0.01824399f, 0.06283426f, -0.00154148f, -0.05307715f, 0.20610613f, 0.04837392f, -0.06238507f, -0.20652011f, 
    0.19922517f, 0.03936499f, -0.00746659f, -0.07307705f, 0.13072106f, 0.00989263f, -0.08503138f, -0.13947476f, 
    0.34505859f, -0.13215560f, 0.11083515f, 0.17274699f, 0.11221494f, -0.07333913f, 0.00055360f, -0.01109086f, 
    0.18963186f, 0.02998178f, -0.21026719f, -0.05591031f, -0.08002594f, 0.33475545f, 0.03108297f, 0.15394856f, 
    0.11591866f, 0.01856085f, 0.04584518f, 0.04121995f, -0.01183300f, 0.03767488f, -0.00160377f, -0.09422725f, 
    0.16325074f, -0.28850880f, 0.06264596f, -0.07120089f, -0.03590359f, -0.05867092f, -0.05022471f, 0.03570855f, 
    -0.14765491f, 0.01662496f, 0.13044864f, -0.14037532f, 0.15856332f, 0.20594506f, 0.16803624f, -0.21208678f, 
    0.13073146f, -0.06548556f, -0.06537027f, 0.08049534f, 0.08088517f, -0.01123901f, 0.07266097f, 0.02829817f, 
    -0.12181011f, 0.07662617f, 0.13640839f, 0.28436112f, -0.00423303f, 0.19181553f, 0.06327013f, -0.20528510f, 
    -0.02418132f, -0.00664894f, 0.06946566f, 0.08020195f, -0.00031719f, 0.27456903f, -0.14174891f, -0.00187731f, 
    -0.03815816f, 0.01735008f, 0.00066007f, -0.00546614f, 0.16140378f, 0.02338627f, -0.00710778f, -0.03369878f, 
    -0.08577855f, -0.12173827f, 0.02602214f, -0.17242482f, -0.07088774f, 0.04552305f, 0.03344209f, 0.05672396f, 
    0.22270775f, 0.00601629f, 0.03205935f, -0.06536438f, 0.15259415f, 0.00418237f, -0.05066745f, -0.05520193f, 
    -0.00597533f, -0.04594577f, -0.05043034f, -0.08679464f, 0.12678827f, -0.01409364f, 0.03011212f, -0.06811257f, 
    -0.04675939f, -0.01486674f, 0.05468048f, 0.16598822f, 0.02760950f, -0.00443792f, -0.03791058f, 0.01488847f, 
    -0.13589172f, -0.04052116f, 0.10032492f, -0.06165447f, 0.06183366f, 0.11424871f, 0.11751181f, 0.04716139f, 
    -0.09447170f, 0.02225481f, -0.06736544f, 0.01264042f, -0.00181203f, -0.03810231f, 0.03489584f, 0.05048569f, 
    0.01050925f, 0.08381560f, 0.04916047f, 0.05298950f, 0.01702496f, -0.01784589f, 0.01460625f, 0.02646668f, 
    -0.10249081f, -0.14308423f, -0.03279316f, 0.10988802f, -0.26657337f, -0.08335250f, 0.28495488f, -0.09235270f, 
    -0.20728317f, -0.19680086f, 0.04099946f, 0.10392737f, -0.01635707f, 0.07401814f, 0.14055765f, 0.08971541f, 
    0.08548043f, -0.03825740f, -0.07711571f, -0.00930273f, 0.00506614f, -0.09130994f, -0.03352457f, -0.07194955f, 
    0.20348459f, -0.04328127f, -0.07315693f, 0.17929851f, -0.03936726f, -0.21282254f, -0.08338655f, 0.01538701f, 
    -0.09263094f, 0.08669724f, -0.01008584f, 0.01901419f, -0.02672953f, 0.01541960f, 0.00857638f, -0.02800394f, 
    -0.01109283f, 0.03136790f, 0.07205164f, 0.05806447f, -0.00127400f, -0.07015674f, 0.03582424f, 0.05263129f, 
    0.05405067f, 0.08344276f, 0.14461310f, -0.00623529f, -0.26375321f, 0.14091846f, 0.10436148f, 0.20208301f, 
    -0.03173318f, -0.07326996f, -0.07553577f, -0.10844021f, -0.04725608f, 0.08260123f, -0.07210245f, -0.08253814f, 
    0.03129964f, 0.33120832f, 0.06709097f, -0.04188818f, -0.03137550f, 0.11989439f, 0.05094559f, 0.28473496f, 
    0.20335366f, -0.02406395f, -0.16674230f, -0.03895516f, -0.06326023f, 0.02359811f, 0.08166204f, 0.20209616f, 
    0.01675035f, 0.07638016f, -0.07392531f, -0.13772760f, -0.07310092f, -0.04430690f, 0.00605495f, -0.00600518f, 
    -0.22808632f, 0.10517817f, -0.03191457f, 0.26431173f, -0.13887340f, 0.14942411f, 0.06213034f, -0.07250842f, 
    0.11155593f, 0.20530212f, 0.00819617f, -0.00784129f, 0.02228078f, -0.03668596f, 0.14898741f, 0.10593321f, 
    -0.06745384f, 0.00558768f, 0.05024359f, 0.03832595f, -0.01638656f, 0.02988533f, 0.08315515f, -0.02927056f, 
    -0.18571472f, -0.07342531f, 0.14920878f, 0.21216899f, 0.05570029f, 0.05456969f, -0.12052041f, -0.21614805f, 
    0.00680002f, 0.08762971f, 0.16533460f, 0.10830752f, -0.20584796f, -0.04095507f, -0.12244777f, 0.05471557f, 
    -0.13139935f, 0.18736923f, 0.03708883f, 0.00811951f, -0.04523892f, -0.02146477f, -0.22381637f, 0.01085424f, 
    0.07207937f, -0.05242282f, 0.06792656f, -0.00927168f, 0.04108564f, -0.03975017f, 0.06402632f, 0.00693254f, 
    -0.04788322f, -0.00102773f, 0.09358021f, 0.07034633f, -0.12295865f, -0.17002940f, -0.04056218f, -0.15273191f, 
    0.00697279f, 0.03015423f, 0.08805488f, 0.01085960f, -0.04747129f, 0.09018809f, -0.11237036f, -0.17626911f, 
    0.16061388f, 0.12044371f, 0.07820749f, 0.09521745f, -0.07656960f, -0.01802644f, -0.05744262f, 0.04391067f, 
    0.01274030f, 0.02101872f, 0.07244170f, 0.12983605f, -0.06642126f, -0.01979974f, 0.13492586f, 0.08297566f, 
    -0.08708828f, -0.12767863f, -0.00827432f, 0.04597343f, 0.07111422f, 0.04683991f, -0.01844725f, -0.04090541f, 
    -0.07172482f, 0.04017498f, -0.02443160f, 0.13229650f, -0.05892184f, -0.03511956f, -0.06289586f, -0.02881413f, 
    -0.09334844f, -0.02495416f, 0.03480930f, 0.06784627f, -0.16376115f, 0.10147966f, -0.05134892f, 0.15218377f, 
    -0.20684198f, 0.07869539f, 0.03115594f, 0.01508637f, 0.02600059f, -0.08490959f, -0.08068798f, 0.15247504f, 
    0.11480813f, 0.22209339f, -0.08521147f, 0.00066483f, 0.08428939f, -0.13965484f, -0.00012942f, 0.11544150f, 
    0.01415418f, 0.04255117f, 0.10722841f, 0.05217928f, 0.04552799f, -0.05542268f, -0.15515922f, 0.01038236f, 
    0.04916502f, 0.17265119f, -0.03664837f, 0.11499132f, -0.15119030f, 0.05108716f, -0.15614392f, -0.19604309f, 
    -0.12058371f, -0.12383793f, -0.08720155f, -0.07070038f, -0.02886879f, -0.02209821f, -0.09514024f, -0.07784960f, 
    -0.02956311f, 0.11610822f, 0.17603289f, 0.14245032f, -0.59324521f, -0.15672882f, 0.32998812f, 0.29842260f, 
    -0.17419136f, 0.14168988f, -0.00199625f, 0.04484580f, -0.00625268f, -0.01540683f, 0.04884538f, -0.00725773f, 
    -0.33163846f, 0.00402398f, 0.16620110f, 0.24315530f, -0.11415832f, 0.02012404f, 0.08029014f, 0.07950803f, 
    0.13880296f, 0.03953064f, 0.06052697f, 0.17836955f, -0.00268905f, 0.16798761f, -0.11051985f, 0.16327113f, 
    -0.02660283f, 0.04448555f, 0.16382934f, -0.07840034f, 0.04737296f, 0.08544127f, 0.17440747f, 0.02868145f, 
    -0.03572528f, 0.16028310f, 0.37906587f, 0.06249765f, -0.00710061f, 0.07152212f, -0.06763639f, 0.31091905f, 
    0.05412280f, 0.02838094f, -0.16332878f, -0.06484493f, -0.09404355f, 0.16632621f, 0.08552628f, 0.04847731f, 
    -0.14019270f, -0.05371377f, -0.05848445f, -0.06401165f, 0.06392048f, -0.08684029f, 0.01104002f, 0.05170858f, 
    0.10548721f, -0.02188382f, -0.18980123f, -0.04086163f, 0.13016544f, 0.01401997f, -0.03715509f, 0.04830099f, 
    -0.05957546f, -0.02908899f, 0.02439608f, 0.05111308f, 0.23653457f, -0.33533081f, -0.04904169f, 0.16835333f, 
    0.03615604f, 0.05620508f, 0.06515747f, -0.10658510f, 0.10201006f, 0.10283177f, 0.02226110f, 0.04406246f, 
    -0.17213106f, 0.02213102f, -0.19607905f, -0.11066874f, 0.05101046f, -0.02910039f, 0.05851910f, -0.09068681f, 
    -0.00638117f, 0.06316135f, 0.20090249f, 0.16840422f, -0.21255070f, -0.10031910f, 0.08693993f, 0.10338239f, 
    -0.18963400f, 0.03407541f, -0.04627991f, 0.03620997f, -0.07013053f, -0.00166936f, 0.06880546f, -0.08886083f, 
    0.28501427f, 0.26741153f, 0.20072663f, -0.28447735f, -0.05332534f, 0.02105147f, 0.04219018f, -0.04909890f, 
    0.02902468f, -0.05193480f, 0.00405847f, 0.06162469f, -0.14787461f, -0.02522876f, 0.08454910f, -0.11116007f, 
    -0.11409931f, -0.11318822f, -0.13007937f, -0.17621790f, -0.01722635f, -0.10282184f, -0.00155715f, 0.07901895f, 
    0.01158585f, -0.01228995f, 0.12488540f, -0.16460134f, -0.05189924f, -0.00422528f, -0.03642754f, -0.09880178f, 
    -0.18049552f, -0.11904401f, -0.14620264f, -0.32232606f, 0.13068071f, 0.42677784f, -0.13733751f, -0.07667027f, 
    -0.04647859f, 0.11379873f, 0.10713321f, 0.02793589f, 0.07728745f, -0.01048833f, 0.00142578f, 0.32894278f, 
    -0.12291308f, 0.00037123f, 0.16447937f, -0.01024797f, -0.13163206f, -0.03894201f, -0.11015657f, -0.01736510f, 
    -0.03265621f, 0.19528486f, 0.15651011f, 0.02455353f, -0.15159358f, -0.11551328f, 0.07248627f, 0.17405827f, 
    -0.01258121f, 0.03552229f, 0.08974177f, 0.07335357f, 0.01220638f, 0.07336387f, 0.11547984f, 0.07724777f, 
    -0.12881562f, -0.06273925f, -0.12534778f, -0.13000950f, -0.14475711f, -0.07908960f, -0.11779859f, -0.12354209f, 
    0.03565885f, 0.00563260f, 0.14733709f, 0.15229084f, 0.32359418f, -0.12147233f, -0.16286649f, 0.01411134f, 
    0.11485925f, 0.10694603f, 0.09721664f, 0.16823307f, -0.06191902f, -0.05422371f, 0.07245044f, 0.04501344f, 
    0.00959116f, -0.06351800f, -0.06500042f, 0.08090509f, 0.23104052f, 0.07785229f, 0.02799235f, 0.08766766f, 
    0.10095876f, 0.11872078f, -0.00629840f, -0.06604309f, 0.08256331f, 0.04321488f, 0.22346950f, -0.20853366f, 
    -0.00709828f, 0.02272475f, 0.02601048f, -0.05457524f, 0.00223784f, -0.06588864f, -0.03331723f, 0.02280697f, 
    0.00245921f, -0.09549002f, -0.31184614f, -0.12567791f, 0.03642470f, 0.07840350f, 0.08048401f, 0.05037194f, 
    -0.17570907f, -0.09136243f, -0.18773921f, 0.04170314f, 0.00903838f, 0.17921326f, -0.02223435f, -0.21508005f, 
    0.11041787f, -0.16830622f, -0.00362186f, -0.08030232f, -0.20238186f, -0.04614221f, -0.02728651f, 0.00133481f, 
    0.18137711f, 0.01271992f, -0.10318918f, -0.06436985f, 0.04719301f, -0.05120151f, 0.07897642f, -0.05550934f, 
    -0.02947216f, -0.00752937f, 0.00613249f, -0.04670609f, 0.17042889f, -0.31232938f, -0.05916526f, -0.00622521f, 
    0.26424086f, 0.07811287f, 0.05466531f, 0.14249618f, -0.06634717f, -0.08466998f, -0.00922908f, 0.01056349f, 
    -0.06401005f, -0.14312923f, 0.00738769f, 0.08467822f, -0.11499918f, 0.00102172f, -0.04837764f, 0.16191502f, 
    0.12176239f, 0.23288994f, 0.07787484f, 0.14733122f, -0.18617041f, -0.39910746f, -0.21244572f, -0.10706037f, 
    0.02276768f, 0.12334519f, 0.00617222f, 0.09713469f, 0.00718917f, 0.09677424f, -0.02411814f, -0.05350496f, 
    -0.16595802f, 0.13436916f, 0.09600453f, 0.10506845f, -0.11796331f, -0.06359585f, -0.09368481f, -0.05963982f, 
    -0.02528919f, -0.00129277f, -0.09434054f, 0.17442660f, 0.20973401f, 0.32227734f, -0.12248389f, -0.24939676f, 
    0.09845728f, -0.05364057f, 0.00015494f, 0.08982278f, 0.11448244f, -0.05427404f, 0.11787660f, -0.15024340f, 
    0.02936959f, 0.07200564f, -0.14343973f, -0.14768630f, 0.12683810f, -0.03904831f, 0.03094949f, -0.06653071f, 
    0.08983810f, 0.06883439f, 0.05249206f, 0.02936485f, 0.29988399f, 0.02766668f, 0.06577620f, -0.22261287f, 
    0.02117349f, 0.00194610f, 0.00371631f, 0.04867657f, 0.19523436f, 0.14494480f, 0.13247903f, 0.14240044f, 
    -0.16202790f, -0.04291712f, 0.27211645f, 0.16708253f, -0.00082183f, 0.11754008f, -0.00277420f, -0.07045904f, 
    0.06311499f, 0.02681014f, 0.05731247f, 0.05207482f, -0.38408867f, 0.12062051f, -0.01412785f, -0.30162898f, 
    -0.00527278f, -0.01353392f, 0.13176879f, 0.15191753f, 0.03380195f, 0.05318283f, 0.08348201f, -0.15556979f, 
    -0.03070727f, -0.12128496f, 0.00534152f, -0.06788596f, -0.12571396f, 0.04885005f, -0.02871977f, -0.02694950f, 
    0.05856080f, 0.08309538f, 0.02585422f, -0.05898896f, 0.23250017f, 0.26932830f, -0.17346242f, 0.12672584f, 
    -0.02117287f, -0.01221925f, 0.15847202f, 0.03464641f, 0.23220406f, -0.17177579f, -0.06040684f, 0.10701487f, 
    0.08072073f, 0.13594420f, -0.11517659f, 0.21425337f, 0.07723166f, 0.20567104f, -0.07618909f, 0.03751211f, 
    0.21400660f, -0.04610804f, -0.02903601f, 0.10474678f, -0.19848393f, -0.06535938f, 0.30818069f, -0.06728764f, 
    0.18893810f, 0.21298978f, 0.14327438f, 0.13774350f, 0.10518097f, 0.10271493f, 0.01923180f, 0.01417211f, 
    -0.12176491f, 0.03693524f, 0.01100738f, 0.14528733f, 0.08422466f, 0.04288967f, -0.01488948f, 0.12679103f, 
    -0.08778425f, 0.17629805f, -0.09259512f, -0.01557587f, 0.32928076f, 0.05481058f, -0.02541774f, -0.03440023f, 
    0.13482170f, 0.02539951f, -0.07827489f, 0.04639556f, 0.04677242f, 0.08478458f, 0.01691688f, 0.03601183f, 
    -0.21112704f, -0.09541818f, 0.01498261f, 0.13750064f, 0.06946184f, 0.07589281f, 0.09475743f, -0.11991366f, 
    0.05924971f, -0.01358962f, -0.00460519f, 0.01441564f, -0.55819499f, 0.04346330f, 0.04219389f, -0.02524942f, 
    -0.07973871f, -0.00042826f, -0.05727221f, -0.00065227f, 0.05508452f, 0.09857405f, 0.02104508f, 0.05296179f, 
    -0.09522220f, -0.11544665f, -0.00655503f, -0.19820130f, -0.05940895f, -0.09542775f, -0.11152802f, -0.01891140f, 
    0.13696198f, 0.11124282f, 0.20397474f, 0.12555002f, -0.09269430f, -0.03006674f, -0.09921530f, -0.01099468f, 
    0.05361485f, 0.06214774f, -0.06781602f, -0.01514809f, -0.22549137f, 0.16112614f, 0.09164842f, -0.03023040f, 
    -0.03079224f, 0.01080390f, 0.06061132f, -0.03807336f, 0.09249696f, -0.04141402f, -0.04064913f, 0.20963778f, 
    0.02145979f, -0.10149232f, 0.25224173f, 0.06100395f, 0.01127215f, 0.01845614f, 0.02418665f, -0.06023721f, 
    -0.08245359f, -0.05137216f, -0.08361531f, -0.03937130f, -0.06928036f, -0.09221117f, -0.12975682f, 0.01187273f, 
    0.11559144f, 0.12014513f, -0.04826332f, 0.00979304f, 0.00700575f, -0.00404249f, -0.07090604f, -0.06324631f, 
    0.00731440f, 0.00532371f, -0.01067922f, -0.09025021f, 0.05541838f, 0.09232780f, 0.22354430f, 0.01890926f, 
    -0.21667980f, -0.04062876f, -0.01143720f, 0.10634504f, 0.03630844f, 0.02912925f, 0.11868606f, 0.29100332f, 
    0.07930731f, 0.03976447f, 0.18610445f, -0.14598922f, -0.11637064f, 0.02659894f, -0.10109533f, -0.03041879f, 
    0.19564314f, 0.00539564f, 0.33286253f, 0.12537156f, -0.18609756f, 0.05468223f, 0.01832704f, -0.12863380f, 
    0.01674147f, 0.08395028f, -0.13395086f, 0.06534670f, -0.00803269f, -0.01349937f, -0.00034627f, -0.01180110f, 
    0.00203314f, 0.04265478f, -0.00287200f, -0.06749123f, 0.01980188f, -0.07955369f, -0.04403729f, -0.05954681f, 
    0.09622039f, 0.01178749f, 0.13203590f, 0.13115971f, -0.32465866f, -0.12294623f, -0.19921578f, -0.07871571f, 
    -0.02003969f, -0.00737920f, 0.13726951f, -0.01364273f, -0.01192464f, 0.04007319f, 0.07745170f, -0.13172171f, 
    -0.01799293f, 0.02870201f, 0.03868909f, -0.07819849f, 0.02852095f, -0.14873962f, 0.07951910f, 0.33844554f, 
    0.17000768f, 0.09484240f, -0.03999052f, 0.08385850f, 0.07486106f, -0.26070955f, 0.16268882f, 0.16563313f, 
    0.12856326f, 0.10720368f, 0.05697603f, -0.12942854f, -0.06724636f, 0.03537205f, -0.02339056f, 0.04495208f, 
    -0.21201317f, -0.05811599f, 0.09327319f, -0.10627260f, -0.07061367f, 0.06398017f, -0.02040875f, -0.05315182f, 
    0.09242404f, -0.05264407f, 0.04935334f, -0.11689635f, 0.08643178f, -0.07418363f, -0.15016553f, 0.04757242f, 
    0.01945127f, -0.05865701f, 0.12662850f, -0.04112186f, -0.04341492f, 0.03233803f, -0.00091229f, -0.00163017f, 
    -0.12217432f, -0.06820652f, 0.18707353f, 0.07674243f, -0.10536926f, -0.03787309f, -0.06406888f, -0.05730959f, 
    0.07458600f, 0.03603882f, 0.02029279f, 0.00208477f, -0.09290021f, -0.20086578f, -0.05319604f, 0.04443473f, 
    0.09662440f, 0.03611899f, 0.00907797f, 0.28168064f, -0.02669591f, 0.02529395f, -0.09065656f, 0.14300148f, 
    -0.10515019f, 0.03934810f, 0.05567620f, -0.20976812f, -0.08133893f, -0.00568961f, 0.09534049f, -0.04267949f, 
    0.10267996f, 0.07876460f, -0.03363219f, 0.07447827f, -0.33492255f, -0.04398565f, -0.06868831f, -0.20772579f, 
    0.04337979f, -0.07800646f, -0.04095724f, 0.03343898f, 0.16598174f, 0.16617066f, 0.01032407f, -0.05566042f, 
    0.04908594f, 0.12660074f, 0.11664314f, 0.06119883f, -0.04667589f, -0.06373458f, -0.08911644f, -0.12401811f, 
    0.03290039f, -0.06468976f, 0.00430271f, 0.07868058f, -0.07315572f, 0.05629513f, 0.24617368f, 0.18334670f, 
    0.06737611f, -0.03667396f, -0.07080928f, 0.15308489f, 0.13230106f, 0.11532964f, -0.16733770f, 0.07782384f, 
    -0.07627792f, -0.18213269f, -0.05155496f, 0.02171354f, -0.05928409f, 0.14289784f, 0.09214977f, 0.08207131f, 
    0.01091400f, 0.01835499f, -0.00521788f, 0.00492350f, 0.18509562f, -0.19733660f, 0.13826109f, 0.18211843f, 
    0.01485030f, -0.03130334f, 0.18487515f, 0.15464333f, 0.12623236f, -0.04685046f, 0.04172694f, 0.13485651f, 
    0.01363091f, 0.02581592f, -0.00429171f, -0.01387348f, 0.00864308f, -0.02184072f, -0.02251765f, -0.04561030f, 
    -0.04559845f, 0.04291250f, 0.01789551f, 0.03777239f, -0.03951683f, -0.01529878f, -0.00813109f, 0.04040906f, 
    -0.01239008f, -0.03156773f, -0.05049972f, 0.02396315f, -0.02933285f, -0.00462864f, -0.01002358f, -0.05513123f, 
    0.01204094f, 0.01221924f, 0.01688642f, -0.04467544f, -0.02150973f, -0.02566134f, -0.01303894f, -0.02587537f, 
    -0.02478514f, -0.01432627f, -0.01341158f, 0.01738371f, -0.00988905f, -0.04116239f, 0.01825944f, 0.00348594f, 
    -0.04943102f, 0.03066775f, 0.00125772f, 0.02998568f, -0.05526381f, -0.04727462f, -0.02756419f, -0.05271153f, 
    0.00597525f, 0.03047465f, 0.02184362f, -0.03226522f, -0.05549857f, 0.01928047f, 0.02245336f, -0.04023418f, 
    -0.00332280f, -0.05658374f, -0.01088983f, 0.03535733f, -0.00117697f, -0.03176287f, -0.04007330f, -0.01982141f, 
    0.02174706f, -0.04421561f, 0.02774669f, -0.04150924f, 0.02487557f, 0.03180837f, -0.02473094f, 0.03969094f, 
    -0.00754754f, 0.02814573f, -0.01893006f, -0.01901568f, -0.04790205f, -0.00471755f, 0.01505653f, -0.04112407f, 
    0.03799594f, 0.03809378f, -0.00022613f, 0.01774221f, -0.00722498f, -0.02339155f, 0.03801640f, -0.01467177f, 
    -0.03458275f, 0.00498150f, -0.03814562f, -0.04737606f, -0.00284731f, -0.04775798f, -0.03649274f, 0.00396527f, 
    0.02999902f, -0.01421637f, -0.00627594f, 0.03870848f, -0.03916756f, -0.02703506f, -0.01224074f, 0.04254343f, 
    0.02349396f, 0.02782725f, -0.05183974f, 0.01718695f, -0.02209513f, 0.02435739f, 0.04450081f, 0.02407574f, 
    0.03923391f, -0.02220591f, -0.04522078f, -0.04317155f, 0.04237078f, 0.02350315f, 0.02336013f, 0.01035411f, 
    0.02711679f, 0.02591266f, 0.02116418f, -0.04076990f, -0.00126458f, -0.05146051f, 0.03276831f, -0.01815853f, 
    -0.03538573f, 0.00298949f, -0.05188689f, 0.03046190f, 0.02507117f, -0.04264431f, -0.05053472f, -0.00999432f, 
    -0.03777642f, -0.03719168f, -0.05305015f, -0.03014100f, -0.02812557f, -0.01332501f, -0.00091065f, 0.03657313f, 
    -0.00458335f, -0.04554481f, -0.00386449f, 0.02913756f, -0.02357024f, 0.02929394f, -0.03389388f, 0.01918809f, 
    -0.02265536f, 0.01299049f, 0.03996300f, -0.01276844f, -0.02999209f, -0.00300825f, 0.02133025f, -0.00186829f, 
    0.04402602f, -0.04629184f, -0.05151518f, 0.02373496f, 0.02542385f, -0.00171849f, 0.02264190f, -0.03763289f, 
    0.00672371f, 0.02284809f, -0.00145963f, -0.04384506f, -0.05767174f, -0.02338381f, 0.04392797f, -0.04989749f, 
    -0.04233763f, 0.01790978f, 0.01511158f, 0.00451912f, 0.01152965f, 0.01068010f, -0.01831373f, 0.00856750f, 
    0.01110001f, 0.00771996f, -0.05226660f, 0.00130934f, -0.03156912f, -0.00400220f, -0.04771673f, 0.02591568f, 
    -0.03314531f, 0.02524056f, -0.03938749f, 0.00917460f, -0.00578856f, -0.05013336f, -0.00752891f, -0.05149797f, 
    0.04124564f, -0.00819318f, 0.04185671f, -0.04042159f, 0.00516674f, -0.06005579f, -0.01691684f, -0.04846860f, 
    -0.00449581f, -0.05398293f, -0.04244307f, -0.00673026f, 0.03138890f, -0.01030873f, -0.05834208f, 0.01128596f, 
    0.01749737f, 0.00474826f, 0.03840546f, 0.03068603f, 0.02337682f, -0.00635959f, -0.03785372f, -0.00315990f, 
    0.00561368f, 0.02111741f, -0.01162215f, 0.02764701f, 0.01788416f, 0.03055738f, -0.04626346f, -0.04403337f, 
    0.00467038f, -0.00181800f, 0.02968375f, -0.02592770f, -0.00000713f, -0.02424100f, 0.00916695f, 0.00169413f, 
    0.01993871f, 0.03348810f, 0.03333673f, -0.02393689f, 0.01824592f, 0.03832075f, 0.01257916f, -0.04920118f, 
    0.03967332f, -0.03417942f, -0.04505920f, 0.00562000f, 0.02695130f, 0.02287201f, -0.03790815f, -0.03235241f, 
    0.02781818f, 0.00498141f, -0.02308936f, 0.03650586f, 0.04230288f, 0.01649043f, -0.03156471f, 0.01378505f, 
    0.00728991f, -0.01424265f, -0.05051356f, -0.02471573f, 0.01744222f, 0.00444537f, -0.02748646f, -0.04309879f, 
    0.03058048f, -0.04741938f, -0.02363879f, 0.03326283f, -0.03656805f, 0.00159371f, 0.01591338f, -0.00517005f, 
    0.04331237f, -0.03966146f, 0.01654916f, -0.01864080f, 0.00369030f, -0.01961704f, 0.02926187f, -0.04274432f, 
    -0.04012953f, -0.05942476f, -0.04408634f, 0.01652544f, -0.02416175f, 0.01747384f, -0.04510657f, 0.00464261f, 
    0.04455897f, -0.03038355f, 0.03307618f, 0.01634230f, -0.02160903f, 0.01824983f, 0.02885575f, -0.02523542f, 
    -0.01721986f, 0.00241956f, -0.00145757f, -0.05697646f, 0.00694866f, 0.03223111f, 0.00511546f, 0.04794943f, 
    -0.01062116f, -0.03960537f, -0.01276889f, -0.02875259f, -0.03708294f, 0.00184903f, 0.00849402f, -0.01238575f, 
    -0.00117843f, -0.03897506f, -0.02365040f, 0.02527904f, 0.00621024f, 0.02010149f, -0.03781981f, 0.03486137f, 
    0.01909729f, -0.00614866f, 0.02300892f, 0.02874188f, -0.03338385f, -0.04915707f, 0.02517891f, 0.00070129f, 
    -0.02363637f, -0.02933815f, 0.00643066f, -0.00502369f, -0.02433908f, -0.02208219f, -0.03013643f, -0.02924827f, 
    0.00038060f, -0.02268464f, 0.01455945f, -0.05303603f, -0.00965631f, -0.03374347f, 0.00684292f, 0.03806665f, 
    -0.04845542f, -0.01600674f, -0.02409976f, 0.00064635f, -0.00694333f, -0.04866845f, -0.02394915f, -0.02469220f, 
    -0.01478828f, -0.02198570f, -0.05371795f, 0.02688188f, -0.00167621f, -0.03275610f, 0.04083274f, 0.02997228f, 
    0.02272581f, -0.01274447f, -0.02809227f, -0.02009923f, 0.02775931f, 0.00077365f, -0.05659078f, 0.01932022f, 
    -0.03835872f, 0.02577475f, -0.02004205f, -0.02139386f, -0.00374758f, -0.02279353f, -0.01558129f, 0.02800924f, 
    0.01637008f, 0.02435392f, -0.04071462f, -0.00343604f, -0.05950139f, -0.04857865f, 0.00114228f, -0.04194698f, 
    -0.06626512f, -0.00719773f, -0.04797202f, -0.00595888f, -0.00421191f, -0.04283826f, -0.06114597f, 0.00393303f, 
    -0.00779448f, -0.00779917f, -0.00730687f, -0.04288324f, 0.00116240f, 0.00690483f, -0.00734814f, -0.04050774f, 
    -0.06564112f, 0.00856057f, -0.03227665f, 0.03056612f, -0.02264838f, 0.02429309f, 0.00894876f, -0.02199834f, 
    -0.02986930f, -0.06156206f, -0.03290046f, -0.06844997f, -0.02596192f, -0.07444143f, -0.06059190f, -0.04556426f, 
    0.01248822f, -0.00324527f, -0.00867898f, -0.00587393f, -0.03397272f, -0.06337461f, -0.01907538f, -0.00132623f, 
    -0.01885641f, 0.01092500f, -0.06080740f, -0.03226366f, -0.05124309f, -0.00241792f, -0.01187163f, -0.03917472f, 
    0.02188511f, -0.06024870f, -0.01610585f, -0.02908204f, 0.00759477f, -0.04439685f, -0.00335598f, -0.01001784f, 
    -0.02104313f, -0.00675872f, 0.00739806f, -0.03878617f, -0.00306046f, -0.02124479f, -0.01800437f, -0.02892789f, 
    -0.05643651f, -0.00317820f, 0.02398729f, -0.05087697f, 0.01085767f, -0.01580404f, -0.07540920f, 0.00490723f, 
    0.00038718f, 0.00858386f, -0.00500108f, -0.03998177f, 0.00876823f, -0.06740963f, -0.06745218f, 0.00433487f, 
    -0.05189332f, -0.05183519f, -0.04323959f, -0.02236967f, 0.00311244f, 0.02446208f, -0.02585866f, -0.07408655f, 
    -0.06719549f, -0.03871019f, -0.06893315f, -0.00131261f, -0.05609357f, -0.01803785f, -0.00602320f, 0.03085233f, 
    0.01103593f, -0.06838777f, -0.08891975f, -0.01617263f, -0.03023326f, -0.04310625f, -0.01791146f, -0.03322471f, 
    0.00479329f, -0.03202448f, -0.07040124f, 0.00782710f, -0.02522483f, -0.05408323f, -0.02020426f, 0.02419408f, 
    -0.06211705f, -0.05938700f, -0.06836629f, -0.01712218f, 0.00171346f, -0.01534148f, -0.01594182f, -0.05671393f, 
    -0.01359224f, -0.03588207f, -0.02413204f, 0.03220208f, -0.02057910f, -0.00609848f, -0.05851006f, -0.06691680f, 
    -0.04102392f, 0.00463209f, 0.00710268f, 0.00346962f, -0.05350003f, -0.07195456f, 0.03640732f, -0.03391941f, 
    -0.05494348f, -0.08381857f, -0.01891883f, -0.05380733f, -0.00735616f, -0.06586888f, -0.05196334f, 0.02119666f, 
    -0.01480879f, -0.06297404f, -0.05643502f, -0.04482284f, -0.04369139f, -0.04924818f, 0.03987604f, -0.04294184f, 
    0.00448865f, -0.04340533f, 0.00883315f, -0.01109860f, -0.01415409f, -0.05833340f, 0.00535822f, 0.00289650f, 
    -0.00722538f, -0.00085861f, 0.02074612f, -0.00831646f, -0.03722978f, 0.00493057f, 0.00920903f, -0.03397016f, 
    0.02196015f, -0.04856142f, -0.07223611f, -0.04117102f, -0.04021693f, -0.03960170f, -0.03381312f, -0.00023595f, 
    0.01195907f, -0.02405739f, -0.01278882f, -0.03646537f, -0.04024445f, -0.02674253f, -0.07078099f, 0.01401969f, 
    -0.05631211f, -0.06594453f, -0.03793284f, -0.05545656f, -0.02483900f, 0.01763761f, -0.05247122f, 0.01521695f, 
    0.03466652f, -0.01620464f, -0.01610222f, 0.01857044f, -0.03942490f, -0.06652221f, 0.01400906f, -0.04153046f, 
    0.02174356f, 0.02901112f, -0.08137401f, 0.02142948f, -0.07823960f, -0.06612982f, -0.07515921f, -0.04519169f, 
    -0.01730575f, -0.02572597f, 0.02454602f, 0.02651320f, -0.02368587f, 0.00344638f, 0.00987602f, 0.03136817f, 
    0.02754785f, 0.00321392f, 0.01419810f, -0.02561574f, -0.00686147f, -0.07415840f, 0.02041997f, -0.01112697f, 
    -0.05872984f, -0.03299840f, 0.01301382f, -0.07373411f, 0.00594289f, -0.03059230f, -0.08071081f, 0.01085349f, 
    -0.00828466f, -0.04155502f, -0.06886487f, -0.06812253f, -0.01038100f, 0.01336234f, -0.04582117f, 0.01751462f, 
    -0.05218013f, -0.05935291f, -0.05736013f, 0.02208886f, -0.01883021f, -0.04497552f, -0.04487681f, 0.01903028f, 
    -0.05751063f, 0.02174684f, -0.05138523f, -0.04077305f, -0.05707318f, 0.01550961f, 0.00263263f, -0.02815252f, 
    -0.09538861f, -0.01084329f, -0.07135336f, -0.06281450f, -0.02057281f, -0.06656940f, -0.00934313f, 0.01575683f, 
    -0.00072061f, 0.03083615f, -0.07420485f, -0.04764134f, 0.02531655f, -0.04448208f, 0.00356290f, 0.01483121f, 
    -0.07747011f, 0.01255758f, -0.01572258f, -0.07211751f, -0.07690448f, -0.00069716f, 0.00490519f, -0.04369519f, 
    -0.00203611f, 0.01291640f, -0.06409962f, 0.02159476f, -0.08005413f, -0.00241149f, -0.02472253f, -0.02951020f, 
    -0.05190499f, 0.00374366f, -0.04134646f, -0.04136661f, -0.04004138f, -0.02452205f, 0.00374504f, -0.05735910f, 
    0.00653468f, -0.04759419f, -0.00001347f, -0.04434209f, -0.02009550f, -0.02551117f, -0.01093737f, 0.01063287f, 
    0.01518787f, -0.00525954f, -0.04836110f, -0.00779471f, -0.02655953f, -0.04765358f, -0.07278979f, -0.03945377f, 
    -0.07826833f, 0.01096552f, -0.03866259f, -0.02168283f, 0.01387259f, 0.01325352f, -0.03710347f, -0.00505246f, 
    -0.01235215f, -0.03961188f, -0.03687573f, -0.04636477f, 0.03909246f, 0.01931511f, -0.04607297f, -0.00418228f, 
    0.00371047f, -0.00983208f, 0.01385905f, -0.00290093f, -0.06845440f, -0.00169046f, -0.06035944f, -0.02633610f, 
    -0.01854029f, -0.00417229f, -0.00638805f, -0.02518606f, -0.02028576f, 0.03083923f, -0.04966949f, -0.06309427f, 
    0.00184619f, -0.05264572f, -0.07246406f, -0.02282827f, 0.01422477f, -0.05213070f, -0.05428147f, 0.01432029f, 
    -0.02643104f, -0.06787974f, 0.03208485f, -0.05184682f, 0.02460623f, -0.01586791f, -0.04634210f, -0.03145112f, 
    -0.05838234f, -0.01285091f, -0.02330578f, -0.00204218f, -0.06573291f, -0.06796622f, 0.01619679f, -0.04974506f, 
    0.01904548f, -0.07598258f, -0.00356639f, -0.04379757f, 0.01603051f, -0.04966155f, 0.00077710f, -0.00772285f, 
    -0.03640409f, 0.02176383f, 0.03634216f, 0.04060648f, 0.02231344f, -0.05132742f, -0.01150087f, -0.02818289f, 
    0.01571941f, 0.03454991f, -0.03103275f, 0.02846801f, -0.03292603f, 0.00505076f, 0.00075862f, -0.04870231f, 
    -0.02514216f, 0.01552659f, 0.03445780f, -0.00081199f, 0.00822021f, -0.03394142f, 0.03201737f, 0.03806502f, 
    -0.01834035f, -0.03404813f, -0.03136618f, -0.00107915f, -0.03712540f, -0.02343861f, 0.00612243f, 0.04107080f, 
    -0.02268472f, -0.00400718f, -0.04744983f, -0.02012909f, 0.01506325f, -0.05322561f, -0.02667089f, -0.03779432f, 
    0.00989193f, -0.01831953f, 0.01209952f, -0.01357230f, -0.02532798f, 0.00918648f, -0.02603609f, -0.03294913f, 
    -0.02002200f, -0.03128631f, 0.04719637f, -0.03065830f, -0.04364517f, -0.04203547f, 0.01259559f, -0.05050125f, 
    -0.05336537f, -0.02993691f, -0.04935171f, -0.03411238f, 0.01161388f, 0.02260945f, -0.04917160f, -0.04400890f, 
    -0.03541957f, 0.04025800f, 0.00466579f, 0.01696839f, -0.04479702f, -0.01468210f, -0.03861638f, -0.05421953f, 
    0.02324355f, -0.05337670f, -0.04726053f, 0.00536598f, 0.01247008f, -0.01225215f, 0.00051883f, 0.01789647f, 
    -0.03565235f, -0.03061912f, -0.01153983f, 0.00947640f, -0.02041872f, 0.01816870f, 0.00346617f, 0.03790646f, 
    -0.03797728f, -0.01936709f, 0.02019446f, -0.02875409f, -0.05237295f, -0.04661850f, -0.04405618f, -0.02399235f, 
    -0.00049461f, 0.03784117f, 0.01792039f, 0.02499199f, 0.00067622f, -0.00705954f, 0.00242291f, 0.02708627f, 
    -0.04805331f, -0.02118570f, 0.00411074f, 0.00968397f, 0.03184267f, -0.05560780f, 0.03296550f, 0.00343693f, 
    -0.03694415f, -0.01672367f, 0.00743860f, 0.00027274f, -0.02154732f, -0.01271576f, -0.01356984f, 0.02278672f, 
    -0.03576907f, -0.00847952f, -0.01604258f, -0.05042517f, -0.04836396f, 0.03513260f, 0.00855106f, -0.05104846f, 
    -0.03125570f, -0.00551902f, -0.04885680f, -0.00649779f, 0.02706835f, 0.00580958f, -0.02091628f, -0.02145547f, 
    -0.04926562f, -0.03890284f, -0.05260296f, 0.02921460f, -0.00856153f, 0.01564942f, 0.00722970f, -0.01777720f, 
    0.00423990f, -0.01378042f, -0.01259215f, -0.02936625f, -0.03308891f, -0.04301523f, -0.02872736f, -0.03753533f, 
    -0.02899159f, 0.01093456f, 0.03209045f, 0.02978326f, -0.00814349f, -0.05017573f, 0.04435999f, 0.02909451f, 
    0.03287561f, -0.02397585f, 0.05009022f, -0.03763575f, -0.00045587f, -0.03056356f, -0.04035237f, 0.03839907f, 
    0.03666263f, -0.05245285f, 0.02342936f, -0.02682258f, 0.01988862f, -0.02127091f, -0.04437237f, -0.03433536f, 
    -0.00856687f, -0.00538733f, -0.03063785f, -0.04482256f, -0.03282303f, -0.00597482f, 0.00364491f, 0.03817152f, 
    0.00006046f, 0.03480000f, -0.02591136f, -0.03569571f, 0.01836157f, 0.00941252f, 0.03456314f, 0.03134344f, 
    -0.02157320f, -0.05520716f, -0.00780823f, -0.04755190f, 0.00180256f, -0.04410864f, -0.05916179f, -0.05083925f, 
    -0.04686230f, -0.01353104f, -0.01376690f, -0.01161184f, -0.03404413f, -0.04913981f, -0.02417967f, -0.02695792f, 
    0.02985556f, 0.02370600f, -0.05060415f, 0.01285841f, -0.02512192f, -0.05696938f, 0.01014931f, -0.02870131f, 
    0.03256826f, 0.01090445f, -0.01604159f, -0.01550072f, -0.01205466f, -0.03554869f, -0.02592932f, 0.00299431f, 
    0.00601137f, 0.03545159f, -0.01229414f, -0.03963754f, -0.03449216f, 0.00456383f, -0.05902918f, 0.00839227f, 
    -0.04064461f, 0.00305145f, -0.05568457f, -0.04539168f, 0.03615559f, -0.01281388f, -0.05360049f, 0.01904705f, 
    -0.05562985f, 0.02739264f, -0.00401039f, -0.00907849f, 0.03356911f, -0.01733697f, -0.00094482f, -0.00948549f, 
    0.01536348f, -0.00355075f, 0.03865355f, -0.01096263f, 0.00326726f, 0.04020935f, -0.04813688f, -0.01774861f, 
    0.02432929f, -0.03188530f, -0.00652557f, 0.02866456f, -0.00563132f, 0.02932019f, -0.02700716f, -0.03361712f, 
    -0.04023634f, -0.03534225f, 0.00244490f, -0.01624088f, -0.02560048f, -0.00421089f, -0.00762544f, -0.03910076f, 
    -0.05863370f, -0.00420439f, -0.04106623f, -0.03352337f, 0.02699697f, -0.03946762f, -0.00323061f, -0.05614219f, 
    -0.01229515f, 0.03843209f, 0.03589506f, -0.05195658f, -0.02176155f, -0.03735650f, -0.00889596f, -0.05744943f, 
    0.02284346f, 0.04022329f, 0.00196869f, -0.01889942f, -0.01577889f, -0.03635831f, 0.02782601f, -0.04837767f, 
    -0.00222031f, -0.03180807f, -0.00886136f, -0.02253576f, 0.01967514f, -0.00793763f, 0.02490533f, 0.01884307f, 
    0.01894000f, 0.01477750f, -0.00414360f, -0.04006680f, -0.05458299f, -0.03647001f, -0.05092617f, -0.02287541f, 
    0.03174961f, -0.03162647f, -0.03505335f, -0.05634830f, -0.03746824f, -0.01020053f, -0.01915626f, 0.03883963f, 
    -0.02288118f, -0.05188421f, -0.01905808f, -0.05871208f, 0.03191275f, 0.00966332f, -0.00722537f, -0.00507170f, 
    -0.01026422f, 0.00542808f, -0.01673131f, 0.00553121f, 0.01626791f, 0.00273852f, 0.03380224f, -0.00576860f, 
    -0.03468569f, -0.03146642f, -0.04339945f, -0.04002656f, -0.03415486f, 0.01564803f, 0.01045629f, -0.03995326f, 
    -0.00111212f, -0.04460576f, 0.02908179f, -0.05193995f, -0.02187685f, 0.01231895f, -0.05817340f, -0.01639535f, 
    0.02439672f, 0.01549960f, 0.02886465f, -0.02709904f, -0.03126448f, -0.04713533f, -0.00735166f, -0.04215483f, 
    -0.02890007f, 0.02135042f, 0.01287761f, 0.04429581f, 0.03364059f, -0.01634690f, -0.05992946f, 0.00377766f, 
    -0.00129599f, -0.01100618f, 0.02595689f, -0.02993806f, -0.05789101f, -0.05686408f, 0.04159612f, -0.02739919f, 
    -0.02249195f, -0.02979889f, 0.04846105f, 0.02399181f, -0.03189998f, -0.05853932f, -0.02911612f, -0.03717494f, 
    -0.00320978f, 0.06020588f, 0.01792875f, 0.01908566f, 0.07249720f, 0.03005255f, 0.10806603f, 0.20269635f, 
    0.01669404f, -0.05779134f, 0.04326716f, -0.08199487f, 0.05136466f, 0.02574520f, -0.10752046f, -0.19859116f, 
    0.03365738f, 0.00759395f, -0.14218299f, 0.03247050f, 0.23554353f, -0.05885641f, 0.07714421f, 0.12850498f, 
    -0.03501168f, -0.03649442f, 0.00991160f, -0.04139924f, 0.06571640f, 0.01164862f, 0.04006702f, -0.05411887f, 
    0.05001190f, -0.00571595f, -0.03666654f, -0.02838168f, -0.08863853f, -0.08110362f, -0.00201606f, -0.19496620f, 
    -0.07351638f, 0.13242410f, 0.05329277f, 0.13182679f, 0.05710297f, 0.05302094f, 0.00453469f, 0.07325986f, 
    0.11857796f, 0.05496718f, -0.16068396f, -0.25866240f, -0.01281082f, -0.08759619f, 0.01307415f, -0.02314591f, 
    0.18747260f, 0.11140691f, 0.08216169f, -0.05164627f, 0.19909565f, -0.14682393f, -0.14064588f, -0.28123760f, 
    -0.04057085f, -0.13922696f, 0.11763176f, -0.04564478f, 0.13009739f, -0.00959888f, 0.04112524f, -0.10140938f, 
    -0.27550527f, 0.07204743f, 0.16266632f, -0.02439149f, -0.11723316f, -0.06542106f, -0.04988770f, -0.04834341f, 
    0.06853815f, -0.04970540f, -0.01762589f, -0.03758759f, -0.08891197f, -0.01530496f, -0.07617510f, 0.11779474f, 
    -0.05458574f, -0.03998223f, -0.00872646f, -0.00884037f, -0.02924591f, -0.07560735f, 0.03640180f, 0.00395273f, 
    0.17294398f, 0.08248850f, 0.10103313f, 0.00500751f, 0.12460955f, 0.02306885f, 0.04474018f, 0.16423328f, 
    -0.06205496f, -0.06042582f, -0.01649621f, 0.01634546f, 0.71915376f, -0.26972976f, 0.00370918f, -0.40734702f, 
    0.03092019f, -0.07258969f, 0.00702134f, -0.09677573f, 0.10186639f, -0.03743228f, 0.01534036f, 0.05807248f, 
    0.12523629f, 0.24502462f, 0.04040351f, 0.29316109f, 0.11209086f, -0.11776894f, -0.08100038f, -0.08599197f, 
    -0.14445812f, 0.05535931f, -0.00359763f, 0.01720216f, 0.05150097f, -0.07846185f, -0.02344368f, 0.01238478f, 
    -0.07935926f, -0.11932401f, 0.12697423f, 0.09992152f, 0.12577118f, 0.12649031f, 0.05988523f, 0.01093797f, 
    -0.18279833f, 0.07271576f, -0.00554322f, -0.03476370f, -0.10865955f, 0.09513614f, -0.09960442f, -0.05061449f, 
    0.12853129f, 0.00970910f, 0.04973929f, 0.08631585f, 0.01367802f, -0.01645223f, 0.04758259f, 0.19401416f, 
    0.00238658f, 0.00115697f, 0.07085606f, -0.02050407f, -0.04148261f, 0.00370967f, 0.09209374f, -0.01312118f, 
    -0.06682707f, -0.14050309f, 0.05994881f, 0.15723489f, -0.05950779f, 0.09130313f, -0.02434823f, -0.02282766f, 
    0.02926912f, 0.01916356f, 0.11966752f, 0.06299303f, -0.07087018f, 0.21340917f, -0.09556825f, 0.01711201f, 
    0.08199550f, 0.04825686f, 0.06772505f, -0.00967295f, 0.05851068f, -0.08746407f, -0.06196993f, 0.08004653f, 
    -0.08064577f, -0.03398157f, 0.04867636f, 0.09729817f, 0.09226276f, -0.03250489f, -0.16434245f, 0.04028468f, 
    0.11704580f, 0.00313894f, -0.05192992f, 0.15266456f, 0.04518730f, 0.10745867f, -0.12040175f, -0.10074183f, 
    0.13254230f, 0.13853006f, 0.19004869f, 0.07311532f, 0.03173873f, 0.01961193f, -0.02137611f, -0.04706315f, 
    0.09056191f, -0.02796770f, 0.04402050f, 0.09438213f, -0.00099873f, -0.04172888f, -0.08160599f, -0.02742832f, 
    -0.01638260f, 0.08762451f, 0.05314233f, 0.04427978f, 0.35342181f, 0.20870507f, 0.07233688f, -0.04328998f, 
    0.00577865f, 0.03322781f, 0.08069005f, -0.03118070f, -0.06812900f, -0.11724482f, -0.02225699f, 0.04795172f, 
    0.21368857f, -0.17344388f, 0.16708207f, -0.05285356f, 0.06053102f, -0.05330712f, 0.06252983f, -0.24723075f, 
    0.04311088f, 0.07765733f, -0.01538290f, -0.07304559f, -0.08230784f, -0.16409577f, -0.00499237f, 0.11917894f, 
    -0.01798450f, -0.06246773f, 0.06050301f, 0.03563327f, -0.04195102f, -0.03325379f, 0.01649448f, -0.01048324f, 
    0.03724109f, -0.07450749f, 0.05866326f, -0.19434777f, 0.06548481f, -0.02690348f, 0.10014885f, 0.03613092f, 
    0.12264004f, -0.04529416f, 0.01494831f, 0.07083780f, -0.14799526f, -0.01937240f, -0.05423296f, 0.14004612f, 
    0.02777862f, 0.02810206f, -0.14678593f, 0.03445755f, 0.03744454f, -0.10311086f, -0.10004104f, 0.00728220f, 
    0.08688445f, 0.17832281f, 0.13966320f, 0.07744684f, 0.01148430f, -0.02029132f, 0.10078479f, 0.12043347f, 
    0.03110554f, 0.01883110f, -0.04937087f, -0.07114877f, 0.05589642f, -0.03128001f, -0.06350108f, -0.14695707f, 
    0.01314621f, -0.03764739f, -0.09851091f, -0.15969326f, -0.00140061f, 0.04500890f, 0.07582504f, 0.09214065f, 
    -0.05401430f, -0.00547119f, 0.11221924f, 0.02698342f, -0.01860028f, 0.12095828f, -0.04601269f, -0.00778872f, 
    -0.00414002f, -0.12541468f, -0.05208270f, -0.03316645f, 0.01193460f, 0.02060013f, -0.25829425f, -0.04313117f, 
    -0.10106501f, 0.00382021f, -0.15604819f, 0.01504826f, 0.02076987f, 0.00503943f, 0.01948355f, -0.01730232f, 
    0.05909844f, -0.12187508f, -0.03610273f, 0.15130025f, 0.01418830f, -0.03292834f, 0.02773092f, -0.01098079f, 
    -0.03461916f, 0.00779340f, -0.06179605f, 0.06930416f, -0.27671012f, 0.08089791f, 0.00202941f, -0.11686359f, 
    -0.00055268f, 0.06892150f, -0.06111120f, 0.02987250f, -0.01561629f, -0.02912104f, 0.13315059f, -0.04097604f, 
    0.05809212f, -0.17172125f, -0.02993198f, 0.04831334f, 0.12684445f, -0.11138878f, 0.01655825f, -0.08274909f, 
    -0.02079552f, -0.06124273f, -0.07908303f, -0.00896765f, -0.10150121f, -0.01691887f, 0.15171297f, -0.11892337f, 
    0.04419180f, 0.13041615f, -0.11339445f, -0.08902295f, 0.06281675f, -0.02770409f, -0.05100508f, 0.05237519f, 
    -0.11647459f, 0.00468664f, 0.29257324f, 0.22253768f, -0.08701000f, 0.19656625f, 0.04567940f, -0.00774264f, 
    0.11364835f, 0.00475345f, 0.01028711f, 0.00737096f, 0.04281326f, 0.13040082f, 0.25344372f, -0.05018277f, 
    0.08839653f, -0.11157525f, -0.03394566f, 0.14511792f, 0.00532241f, -0.14593484f, 0.04582496f, -0.14473452f, 
    0.12535866f, 0.00706136f, -0.04167839f, -0.05339837f, 0.09765574f, 0.07261951f, 0.00631357f, -0.07509265f, 
    0.17707150f, 0.08868593f, 0.04023864f, 0.00578078f, 0.26807842f, 0.17744124f, -0.42856246f, 0.15140474f, 
    0.05879781f, -0.08028991f, 0.02778171f, -0.07159279f, -0.01871136f, -0.16542679f, -0.20795123f, -0.05008429f, 
    -0.01777408f, -0.18048574f, -0.32771870f, -0.15287195f, 0.00723669f, -0.00968868f, -0.12016281f, -0.07431380f, 
    0.01220200f, -0.00412888f, -0.00485584f, -0.06019280f, 0.15776975f, -0.03869520f, 0.28452420f, -0.24995214f, 
    -0.01048878f, 0.10060637f, -0.14065500f, 0.12869975f, -0.07428965f, -0.06608552f, 0.00724572f, 0.05292654f, 
    0.05342323f, -0.07687876f, -0.15558057f, 0.07776462f, 0.07884126f, -0.20996515f, 0.03186507f, -0.20685539f, 
    0.06124771f, -0.01033188f, -0.06998950f, -0.03682891f, 0.19786862f, -0.02980195f, -0.14834347f, 0.32844073f, 
    0.12688461f, -0.01764897f, -0.00116199f, 0.00358254f, -0.04220304f, 0.12847883f, 0.00045757f, -0.09984245f, 
    -0.06695908f, 0.15875477f, 0.26174790f, 0.23601723f, -0.08171135f, -0.01596900f, 0.09223591f, 0.09534553f, 
    0.02282991f, 0.03806852f, -0.02963418f, -0.01310990f, 0.27014941f, 0.03414353f, 0.09773491f, -0.16246569f, 
    -0.06488391f, 0.06150969f, -0.07740902f, 0.12170768f, -0.08345835f, -0.10843797f, 0.07522748f, -0.06243405f, 
    0.09658799f, -0.10875965f, 0.01875371f, 0.12198455f, -0.02917492f, 0.04680802f, -0.02562289f, 0.03798612f, 
    0.04817457f, -0.00385883f, 0.06416397f, 0.08181889f, 0.02952466f, -0.09507485f, -0.18989733f, -0.08515868f, 
    0.05242489f, 0.00741910f, -0.05287263f, 0.11306529f, -0.06989109f, 0.09270394f, 0.01048827f, 0.01204666f, 
    -0.47487542f, -0.13014524f, -0.02194817f, 0.15590881f, 0.10305740f, -0.04828275f, -0.10553299f, 0.05100811f, 
    -0.02258963f, -0.00516540f, 0.21844670f, 0.09973065f, -0.20514156f, -0.27857336f, -0.25639600f, -0.08468419f, 
    0.03355134f, -0.03115671f, -0.08398878f, -0.04021093f, 0.07423467f, -0.04977252f, -0.00924780f, -0.01237322f, 
    -0.24329446f, -0.16211538f, -0.14180914f, -0.08690339f, -0.01725942f, -0.00148412f, -0.01886941f, -0.03831635f, 
    0.01833309f, -0.15907261f, -0.02650609f, 0.13463372f, 0.08820195f, 0.00581911f, 0.26438719f, 0.16870114f, 
    0.07063625f, 0.13561431f, 0.10833089f, 0.11757424f, 0.07769263f, -0.04670685f, -0.04911839f, 0.08921119f, 
    0.03882757f, -0.13800387f, -0.15693796f, -0.07010724f, 0.00776252f, 0.03749417f, -0.02587423f, 0.04173322f, 
    0.06092161f, -0.12005500f, -0.11085042f, 0.07185134f, 0.23863409f, 0.21814542f, 0.31286785f, 0.04222596f, 
    -0.01885882f, 0.18449047f, 0.04711113f, 0.13403955f, 0.03508548f, 0.06299476f, 0.03368928f, 0.01335671f, 
    -0.12269016f, -0.21866056f, -0.15039025f, -0.11573626f, 0.06076375f, -0.03990732f, -0.04585150f, -0.05597990f, 
    0.07638818f, 0.06204392f, 0.11475911f, 0.04622428f, -0.14418063f, 0.04096201f, 0.08347790f, 0.04307742f, 
    -0.05650448f, -0.03958886f, 0.09444218f, -0.00937715f, 0.07049046f, 0.06386869f, 0.02230041f, -0.12675799f, 
    0.09533476f, -0.01818711f, 0.13804236f, -0.02344901f, -0.04406034f, -0.00416882f, 0.02154231f, 0.19220959f, 
    0.05824904f, -0.11625503f, 0.07704289f, 0.04828872f, -0.08867720f, -0.26695421f, -0.20385720f, 0.21081215f, 
    -0.05413765f, 0.03391337f, 0.04607030f, -0.01300958f, -0.01192395f, 0.02162177f, -0.03061529f, -0.09001393f, 
    0.06539226f, 0.05030567f, 0.36674845f, 0.26767200f, 0.06773098f, 0.02731537f, 0.14116305f, 0.10149172f, 
    0.18176793f, -0.09206153f, 0.02814927f, 0.01009780f, -0.38714507f, -0.21425675f, -0.21191315f, -0.07921910f, 
    -0.15043585f, 0.01544829f, 0.05978331f, -0.05958148f, 0.13658358f, 0.03897805f, -0.03011876f, 0.14475878f, 
    -0.09079426f, 0.06476516f, 0.25050262f, 0.13592245f, 0.00824730f, -0.05231225f, -0.08966777f, 0.13975680f, 
    0.12158749f, 0.14514348f, 0.07495035f, 0.04381974f, -0.03253117f, 0.07738373f, 0.14944007f, 0.06669320f, 
    -0.03611068f, 0.04045257f, -0.08711964f, 0.08385275f, 0.00652701f, -0.06905834f, -0.00657547f, 0.00902425f, 
    0.16101159f, 0.30559099f, 0.25114429f, 0.22575396f, -0.01006065f, 0.15114745f, 0.18176700f, 0.07714429f, 
    0.07428537f, 0.01268663f, -0.02095599f, 0.00452902f, 0.07898253f, 0.27413967f, 0.03117210f, 0.01656126f, 
    0.01365967f, -0.06616757f, -0.05140520f, -0.08452079f, -0.02376710f, -0.01635063f, 0.10316211f, -0.03840192f, 
    -0.07638501f, -0.51078451f, -0.31540143f, -0.09494436f, -0.06569304f, -0.04201287f, -0.06159503f, -0.08129574f, 
    0.05373812f, -0.12875922f, 0.05156122f, 0.01619297f, -0.42517266f, -0.06820408f, 0.17438324f, 0.18218991f, 
    0.00942708f, 0.11507317f, 0.03805326f, -0.10434819f, -0.04063041f, 0.06208859f, -0.06523017f, -0.00706748f, 
    -0.04938334f, -0.22107251f, -0.10920756f, -0.02847023f, -0.03428118f, 0.15273708f, -0.02265777f, 0.05208810f, 
    0.06114992f, -0.04893926f, 0.03240127f, 0.01035437f, -0.31736660f, -0.03020576f, 0.08415315f, 0.03254258f, 
    0.01425616f, 0.06698584f, 0.05320293f, 0.10916793f, -0.05526223f, 0.02215174f, -0.06577340f, 0.01767546f, 
    -0.03004029f, 0.00444828f, 0.02123988f, 0.01521352f, 0.04212348f, 0.03817242f, 0.03838643f, -0.04528334f, 
    0.03009132f, -0.01847449f, 0.03954183f, -0.04947255f, 0.00747211f, 0.03102329f, -0.00474766f, 0.00121098f, 
    -0.02184681f, 0.01861670f, -0.02950528f, -0.00859944f, -0.05055587f, 0.01118551f, -0.03520408f, -0.01369768f, 
    0.04428039f, 0.01409808f, -0.00197872f, -0.03889131f, -0.00776803f, -0.04767314f, -0.04031576f, -0.02721829f, 
    -0.00651896f, -0.05333258f, 0.04518620f, 0.01902599f, -0.05091130f, -0.02301291f, 0.00278403f, -0.02870181f, 
    -0.01945638f, 0.00719857f, -0.04001790f, -0.01749255f, 0.04045810f, -0.00433140f, 0.00107981f, 0.00363234f, 
    -0.04343572f, -0.04298948f, -0.04960661f, -0.05305147f, -0.02656390f, 0.02891371f, 0.02394423f, -0.04916551f, 
    0.01301234f, 0.00690242f, 0.00538052f, -0.00559675f, -0.02874830f, -0.00245438f, -0.01238225f, 0.00822371f, 
    0.03175346f, 0.03475144f, 0.04913643f, -0.03130062f, 0.02364127f, 0.00493977f, 0.01120229f, -0.05141200f, 
    -0.05683482f, -0.04004620f, 0.02341164f, -0.03146357f, 0.03996665f, -0.04962366f, 0.03157113f, -0.05543215f, 
    -0.04423068f, -0.02029437f, 0.03080574f, -0.05230490f, -0.03029613f, 0.02841284f, -0.01422516f, -0.02566561f, 
    0.02935685f, -0.02115438f, -0.02669675f, 0.01777613f, -0.00616472f, -0.00376254f, -0.00479283f, 0.02005181f, 
    0.02748127f, 0.01985270f, 0.00059187f, 0.03421636f, -0.04750030f, -0.03818446f, -0.01424224f, -0.04467570f, 
    -0.03896319f, 0.03455399f, 0.01502784f, -0.01121000f, 0.00301648f, -0.05145043f, -0.04819309f, -0.03209024f, 
    -0.01288683f, 0.02852628f, -0.03573136f, 0.01053555f, 0.02798700f, -0.05392683f, 0.01852567f, 0.00730175f, 
    0.01073047f, -0.00490858f, -0.01892572f, -0.03337903f, 0.03962304f, 0.03184476f, 0.00513570f, 0.04072252f, 
    -0.03856063f, 0.01763832f, -0.03217738f, -0.02581481f, 0.01473278f, -0.00595781f, -0.05169706f, -0.03173548f, 
    -0.01514099f, -0.01987053f, 0.02745696f, 0.01040051f, -0.01661276f, -0.05150992f, -0.04565088f, 0.01826176f, 
    0.03067462f, 0.02848816f, -0.00509708f, -0.00234254f, 0.03820442f, 0.02106309f, 0.03344427f, 0.01582928f, 
    0.02276403f, 0.00922032f, -0.03387218f, -0.03725439f, -0.03412867f, 0.04424475f, 0.00949688f, -0.05002761f, 
    0.04583868f, -0.02582162f, -0.02147019f, -0.02113613f, 0.03279265f, 0.01264576f, 0.03614076f, -0.00258098f, 
    0.02086320f, -0.01552064f, -0.01070202f, 0.00440357f, 0.01556554f, 0.03755665f, -0.03334101f, -0.03558667f, 
    0.02881107f, -0.05274181f, -0.02044055f, -0.02621859f, -0.04037611f, -0.01065275f, -0.01961315f, -0.02283827f, 
    -0.03248326f, -0.02351786f, 0.02446886f, 0.01898554f, 0.04053612f, 0.04410259f, -0.05314967f, -0.05534217f, 
    -0.00067208f, 0.00840180f, -0.02508634f, 0.02867249f, 0.03330322f, -0.00492250f, -0.00738032f, -0.02043075f, 
    -0.05676665f, -0.03535788f, -0.02883299f, -0.01172525f, -0.01865279f, -0.03107045f, -0.04882351f, 0.00616054f, 
    -0.03105057f, 0.00578433f, 0.01515619f, -0.04866780f, -0.02074897f, 0.04523525f, -0.02068480f, -0.00852903f, 
    -0.03984826f, 0.02043280f, 0.03638655f, -0.00429342f, 0.02559970f, 0.02403346f, 0.03926719f, -0.04715669f, 
    0.00912498f, -0.02691045f, 0.03494410f, 0.00546479f, 0.00582545f, -0.02141345f, -0.01359295f, 0.04295668f, 
    -0.01696119f, -0.00079807f, 0.02343766f, -0.00659008f, 0.03988284f, -0.03531671f, 0.00269195f, -0.05911266f, 
    0.03222519f, 0.02863895f, -0.00821500f, -0.03699058f, 0.03840199f, -0.00159534f, 0.02729605f, -0.05128703f, 
    -0.03289564f, 0.00077135f, -0.03182957f, 0.03396614f, 0.03784402f, -0.02034315f, -0.00240091f, 0.04318899f, 
    -0.02855745f, 0.00692434f, 0.00565916f, -0.03471563f, 0.00637960f, -0.04213696f, 0.00007568f, -0.03242230f, 
    0.02476308f, 0.01261070f, -0.04001324f, -0.02748208f, 0.02479513f, 0.00801759f, 0.01779935f, 0.00809189f, 
    -0.01574312f, 0.00439268f, 0.03054079f, -0.01064819f, 0.04027195f, -0.04255198f, 0.01599549f, 0.03402775f, 
    -0.02493815f, -0.01802865f, 0.02933729f, 0.02891078f, -0.03496906f, 0.02802298f, -0.04281950f, 0.03358956f, 
    0.00492273f, -0.03511426f, 0.01905775f, -0.05113988f, -0.04620713f, -0.04159790f, 0.02100934f, 0.02432724f, 
    0.00609099f, -0.03120434f, 0.03350658f, -0.00560692f, -0.00324207f, -0.04995904f, 0.01050935f, -0.02672750f, 
    -0.01425889f, 0.01388714f, -0.02179761f, -0.00448682f, -0.00320170f, -0.02643566f, 0.03827012f, 0.01883049f, 
    -0.02547296f, -0.04504241f, 0.04338747f, 0.03137794f, 0.00070477f, 0.02496074f, -0.04790842f, -0.03558891f, 
    -0.02240654f, 0.00827755f, -0.00428542f, 0.01246884f, 0.00962040f, 0.03539914f, -0.02948532f, 0.01019213f, 
    -0.02901378f, 0.03945420f, -0.02982389f, 0.02361758f, 0.04004291f, 0.02291872f, -0.04323601f, 0.01146609f, 
    -0.01537975f, -0.02586154f, -0.04532389f, 0.00108886f, 0.02087255f, 0.00185146f, -0.00917636f, 0.00753070f, 
    -0.05155098f, 0.00594890f, 0.02788250f, -0.04398384f, 0.05057767f, -0.03177314f, -0.05399321f, -0.00228396f, 
    0.02116317f, -0.02254613f, 0.03200042f, 0.02721575f, 0.04902168f, -0.01471649f, -0.05488188f, 0.03665033f, 
    -0.01311014f, 0.03881441f, -0.00808672f, 0.00125947f, 0.00999088f, 0.01393467f, -0.05103811f, 0.02984407f, 
    0.04302531f, -0.04879647f, -0.01648200f, -0.04189080f, 0.01068459f, -0.03973804f, -0.02036736f, -0.04148777f, 
    0.03768468f, -0.01828331f, 0.03542917f, -0.03999512f, 0.02287982f, -0.03031976f, 0.00492464f, -0.03755208f, 
    -0.09645941f, -0.13769947f, -0.03958669f, -0.00308347f, -0.04836672f, -0.12373566f, 0.07096000f, 0.10702979f, 
    0.05663626f, 0.00508239f, -0.01729516f, 0.00574445f, 0.25311470f, 0.14051023f, 0.09955872f, 0.10626658f, 
    -0.10270245f, -0.11017840f, -0.21759404f, 0.07864079f, 0.16805126f, -0.04815154f, -0.03921717f, -0.00346038f, 
    0.07334183f, 0.04379452f, -0.01903325f, -0.01344972f, 0.06948630f, -0.02851751f, 0.07373165f, 0.07849962f, 
    -0.11418123f, -0.07033828f, -0.09192128f, -0.03516497f, 0.15337197f, -0.00138317f, -0.16238078f, 0.06266298f, 
    0.11524186f, -0.14348000f, -0.02521525f, -0.03316684f, -0.19526400f, 0.29836267f, -0.14827953f, 0.04332470f, 
    -0.05708400f, -0.06379274f, 0.26544681f, -0.33276272f, -0.11864038f, -0.19120213f, 0.13855176f, 0.05714206f, 
    -0.30496776f, 0.17422113f, 0.10217830f, -0.19588630f, 0.25171611f, -0.11563855f, 0.00867934f, -0.08074959f, 
    -0.16949265f, -0.02887635f, -0.12202659f, 0.09353706f, -0.08586885f, -0.00959121f, 0.05345405f, 0.00859685f, 
    -0.10035482f, -0.07891529f, -0.13116577f, -0.10267373f, 0.06625550f, -0.11275715f, 0.07521295f, -0.26270106f, 
    0.10849407f, -0.06852449f, 0.09377601f, 0.12375044f, 0.01101789f, -0.10256830f, -0.00357043f, 0.09903669f, 
    -0.13731089f, 0.02814145f, 0.11298771f, -0.10056011f, -0.00753406f, -0.06324901f, 0.09294838f, -0.11012772f, 
    0.01129439f, 0.11057878f, 0.07981382f, -0.03554999f, -0.18997127f, -0.18171464f, -0.02694778f, 0.12133604f, 
    -0.00749452f, 0.02193897f, -0.10135939f, -0.03293324f, 0.69349664f, 0.11395286f, 0.10580015f, -0.00143609f, 
    -0.06228215f, -0.02248677f, -0.03137965f, 0.09046785f, -0.10844625f, 0.04084994f, -0.02420789f, -0.06174265f, 
    0.13839093f, -0.02644376f, 0.04306747f, 0.05073964f, -0.12611738f, 0.04621703f, 0.09763700f, 0.07163998f, 
    -0.05959130f, -0.04489913f, -0.07287711f, -0.15641797f, 0.13024408f, 0.06829200f, -0.00132186f, -0.13728644f, 
    -0.05205898f, -0.02392898f, 0.05919030f, 0.05670251f, 0.24017446f, -0.04884319f, -0.02187675f, 0.07550816f, 
    -0.09874950f, -0.06814457f, 0.03950636f, 0.14315018f, -0.12612131f, 0.16203825f, 0.10988845f, -0.25630087f, 
    0.11634514f, 0.22173667f, -0.00811303f, -0.06557410f, 0.02516221f, -0.03681313f, 0.02722419f, 0.04234054f, 
    -0.00909829f, -0.00616771f, -0.00025512f, 0.04280458f, 0.07318983f, 0.10820255f, 0.09372093f, -0.07011861f, 
    0.05301874f, 0.06405060f, 0.04974794f, -0.03423803f, -0.01482694f, 0.02544448f, 0.01294926f, 0.00481988f, 
    0.18410839f, 0.15889579f, 0.18649302f, 0.16536170f, 0.10228322f, -0.43705535f, 0.17788357f, 0.42233106f, 
    0.13460436f, 0.22905786f, 0.14263844f, 0.03432121f, 0.17983471f, -0.06256204f, 0.03918733f, -0.31469479f, 
    -0.08584268f, 0.07331677f, -0.09918778f, 0.12129520f, 0.08211243f, -0.05777085f, 0.03035236f, 0.03542143f, 
    -0.23003419f, -0.01144981f, -0.21103097f, -0.08934393f, 0.18926920f, -0.08699308f, 0.14256546f, 0.06261072f, 
    -0.04960911f, 0.04604973f, 0.12907992f, 0.07693656f, -0.09521736f, 0.04728147f, -0.03593777f, 0.07204950f, 
    -0.05415989f, 0.04681630f, 0.00225567f, -0.02120513f, -0.00163155f, 0.04803048f, 0.01076382f, 0.03815013f, 
    0.10711063f, 0.06265062f, -0.06452107f, -0.15655592f, 0.02724932f, 0.11738273f, 0.21934634f, -0.11268240f, 
    -0.03906232f, -0.01103496f, -0.06860965f, 0.05210551f, -0.01357418f, 0.03412801f, -0.13425264f, 0.05512571f, 
    -0.01456956f, 0.01122027f, 0.11610349f, 0.05558133f, -0.13606280f, 0.07924873f, -0.01504253f, -0.11907320f, 
    -0.23758392f, -0.09667809f, 0.03799270f, -0.04416593f, 0.07242378f, 0.37208346f, -0.36795664f, -0.28775406f, 
    -0.07140019f, -0.11108349f, 0.02330899f, 0.04990419f, 0.05233333f, 0.06338135f, -0.05621246f, -0.06084001f, 
    0.08461089f, 0.03434748f, 0.07433426f, 0.26040423f, -0.00425038f, 0.03774952f, 0.02180271f, 0.07930360f, 
    0.15240352f, 0.18885674f, 0.12974411f, 0.03984787f, 0.04049680f, 0.14359930f, 0.08363353f, -0.04201768f, 
    -0.00124981f, 0.12204935f, -0.06333510f, 0.06213506f, 0.12037789f, -0.01918336f, -0.01040700f, 0.01395267f, 
    -0.00707563f, -0.00098717f, -0.05241564f, -0.03846983f, -0.11583167f, -0.09165288f, -0.04297508f, 0.09404615f, 
    0.04553182f, 0.05613276f, -0.03858837f, 0.02003825f, -0.05000053f, 0.20266385f, 0.23537831f, -0.21375810f, 
    -0.15978386f, -0.00111717f, -0.04272510f, -0.17715375f, 0.14043565f, 0.02797689f, 0.14195184f, -0.18911988f, 
    0.06739304f, 0.08329057f, 0.09742247f, 0.27979451f, 0.02166972f, 0.11589056f, 0.11029878f, 0.04577596f, 
    -0.09218530f, -0.16553704f, -0.01193274f, -0.07180505f, 0.42653024f, 0.21863490f, -0.06693280f, 0.11410744f, 
    -0.03893227f, 0.04531537f, 0.05575069f, -0.03796529f, -0.09390113f, -0.08243622f, 0.00762765f, 0.08861909f, 
    0.10659031f, -0.09221213f, -0.06980621f, -0.12012843f, -0.01743780f, -0.01919297f, 0.05709503f, 0.04289125f, 
    -0.06502714f, -0.02323714f, -0.00862684f, -0.06413317f, 0.22576763f, -0.37410617f, -0.11682137f, 0.29467881f, 
    0.05592874f, 0.08039356f, 0.17414710f, -0.23037356f, 0.07190318f, 0.15609957f, 0.29322231f, 0.11682808f, 
    0.10078079f, 0.13517658f, -0.00958784f, -0.19298641f, 0.01928284f, -0.05548532f, 0.05419170f, -0.01364793f, 
    -0.10047665f, -0.01694468f, 0.04983516f, 0.01981565f, -0.07393035f, 0.19401933f, -0.05113486f, 0.10227559f, 
    0.16758320f, 0.23295243f, -0.05633978f, -0.14848651f, -0.07296276f, 0.15940964f, 0.04752014f, -0.18022446f, 
    -0.06650906f, -0.11537280f, -0.22903268f, -0.15162869f, 0.13311134f, 0.10719562f, 0.11050195f, 0.06301071f, 
    -0.09806213f, -0.07643315f, -0.05570013f, -0.04491523f, 0.00333021f, -0.04273034f, 0.10370708f, 0.02461438f, 
    0.00670277f, -0.02713921f, -0.04831597f, -0.13036965f, 0.01246656f, 0.02271562f, 0.04981171f, 0.18925369f, 
    -0.02546722f, -0.04540948f, 0.00765088f, 0.02742042f, -0.09309299f, -0.06938346f, 0.00885338f, 0.04777461f, 
    -0.06676526f, -0.07897287f, 0.04832538f, -0.01541044f, 0.35230944f, -0.26801065f, -0.22227569f, -0.41020590f, 
    0.02302307f, 0.05164725f, 0.03072765f, 0.05934517f, 0.12734155f, 0.18670680f, 0.12904650f, -0.03459973f, 
    0.44612375f, 0.00932131f, -0.07011209f, -0.07950886f, 0.07750893f, -0.18336336f, 0.08513016f, 0.10166567f, 
    0.24264768f, 0.19421266f, -0.08298255f, -0.10083550f, 0.02224069f, -0.19977333f, 0.03165086f, 0.04644414f, 
    0.17210482f, -0.08744007f, 0.01662815f, -0.08444230f, 0.10630657f, -0.02111710f, -0.09556086f, -0.05189255f, 
    -0.27943248f, 0.07130625f, -0.15584156f, -0.11031228f, -0.08342854f, 0.17632410f, -0.02481279f, -0.08599397f, 
    -0.03120762f, -0.15113479f, -0.03563857f, 0.01075952f, -0.13732645f, -0.09224357f, -0.01928701f, -0.38241401f, 
    -0.09796392f, 0.08366215f, 0.06314612f, -0.01765416f, -0.07180367f, 0.01052339f, 0.02756343f, 0.04621426f, 
    -0.14460149f, -0.01168580f, -0.08161607f, -0.27738342f, 0.02186644f, 0.11545424f, -0.03071376f, -0.15795523f, 
    -0.09715329f, -0.00697608f, -0.03225692f, -0.00648104f, 0.29630464f, 0.07083210f, 0.20577531f, 0.05426823f, 
    0.03868785f, -0.00788526f, -0.11515779f, -0.08140778f, 0.29865614f, 0.11363594f, 0.13571469f, 0.07790606f, 
    -0.16807604f, 0.19166242f, 0.16396682f, 0.09636914f, 0.03014026f, -0.04053683f, 0.03730622f, -0.07100200f, 
    -0.07960508f, 0.11499707f, -0.02836288f, -0.07562480f, 0.07988107f, -0.09192181f, -0.07594419f, -0.17461021f, 
    0.07546573f, -0.06447484f, 0.18974589f, -0.08984245f, 0.22536519f, -0.10412631f, 0.01806657f, 0.00334568f, 
    0.00264795f, -0.13192612f, 0.07041530f, -0.01937460f, 0.00423212f, 0.11255456f, -0.00351755f, 0.02173029f, 
    0.10289055f, 0.05006786f, -0.06255754f, -0.06386898f, 0.00136778f, 0.04916524f, 0.07505795f, 0.11130914f, 
    -0.01885778f, 0.01925144f, 0.06818539f, 0.04530223f, -0.06758234f, -0.05216670f, -0.05902187f, -0.04614741f, 
    -0.14715782f, -0.01659446f, 0.02800348f, 0.15210500f, 0.02604512f, 0.03750999f, 0.00858523f, 0.05477492f, 
    0.18383950f, 0.13635278f, 0.03652884f, 0.28670642f, -0.42633998f, -0.31686583f, 0.29363221f, -0.03971374f, 
    0.06453402f, -0.06624141f, 0.06788336f, 0.04479020f, 0.06767251f, 0.04374992f, 0.05070319f, 0.11018230f, 
    -0.08902984f, -0.03793913f, 0.00535046f, 0.08919580f, 0.14580430f, -0.04159732f, 0.00638321f, -0.00076055f, 
    0.05871845f, -0.16290990f, 0.02465347f, 0.04073828f, 0.05901160f, -0.06484974f, -0.16442892f, -0.06654891f, 
    0.09875741f, -0.00590299f, 0.04125658f, -0.28069839f, 0.05193841f, -0.09380030f, -0.04803487f, 0.01507041f, 
    0.04798630f, -0.07771607f, 0.08298835f, 0.12879448f, 0.02316979f, 0.00803854f, 0.07589181f, 0.01417846f, 
    -0.10512122f, -0.08131674f, -0.11440827f, -0.01405143f, -0.16592382f, 0.33414567f, 0.28536463f, -0.05203215f, 
    -0.03587732f, 0.00862760f, 0.01981886f, -0.01584549f, -0.04868418f, -0.07494838f, -0.01226046f, -0.00609090f, 
    0.45311931f, 0.36283064f, 0.16125579f, 0.01546709f, -0.04154663f, 0.07086816f, 0.05474372f, -0.12911819f, 
    0.05364060f, 0.08737963f, 0.03556871f, -0.04082739f, -0.24522780f, 0.04156059f, -0.06764700f, 0.12075526f, 
    0.04437190f, 0.01958623f, 0.09850475f, 0.03266161f, -0.08718890f, -0.00722636f, -0.01102626f, 0.09617291f, 
    -0.10359018f, 0.22690117f, 0.04043533f, -0.24006830f, -0.17368186f, -0.08446851f, -0.09168068f, -0.02832436f, 
    -0.11266367f, 0.02986912f, -0.02396767f, -0.01208198f, 0.02847883f, -0.08479240f, -0.02376719f, 0.11008123f, 
    0.02229959f, 0.04996065f, -0.02858393f, 0.10237894f, 0.03752201f, -0.01962376f, -0.04501949f, -0.01411128f, 
    -0.05589249f, 0.08234590f, -0.14530954f, -0.18507424f, 0.12624349f, 0.10303360f, 0.04000392f, 0.10760941f, 
    -0.12033354f, -0.06217618f, -0.11305285f, -0.11349530f, -0.14735864f, 0.35993016f, 0.10132443f, 0.09251935f, 
    -0.05585711f, 0.04534414f, 0.15330732f, -0.08257734f, -0.04079703f, 0.19315816f, -0.01540816f, 0.14194214f, 
    -0.03769973f, -0.34927157f, -0.10253989f, -0.20046973f, 0.12749507f, -0.02871121f, 0.04258716f, 0.00468138f, 
    -0.00035770f, 0.02610526f, -0.07534906f, -0.02310902f, 0.10806540f, 0.10584255f, 0.40437272f, 0.08180996f, 
    -0.02303871f, -0.02924583f, -0.04692393f, 0.00385086f, 0.02418836f, 0.16722539f, 0.08037014f, 0.19404049f, 
    0.06237205f, -0.05286942f, -0.02255257f, -0.00682396f, 0.03404570f, 0.03937479f, 0.04390968f, -0.00210655f, 
    0.03147903f, 0.01068729f, -0.04734578f, -0.04412077f, 0.20079759f, -0.05388106f, 0.04448221f, 0.00203522f, 
    -0.19747514f, 0.02444191f, 0.00529125f, 0.04806047f, -0.03859445f, 0.07805338f, 0.13796908f, 0.07110114f, 
    -0.08432078f, -0.10653140f, 0.06282288f, 0.10636295f, 0.08349848f, 0.04108524f, 0.11005742f, 0.06992427f, 
    -0.12190364f, -0.03311784f, -0.01897293f, -0.02736630f, -0.04997953f, 0.01311570f, 0.02900985f, 0.14292632f, 
    -0.05176660f, -0.00273263f, 0.06336892f, 0.01686813f, 0.04708852f, 0.02010087f, 0.04416006f, 0.04259299f, 
    0.27085787f, 0.11086973f, -0.15169518f, -0.34175822f, 0.05726706f, 0.01193803f, 0.14461070f, 0.08522519f, 
    0.04414879f, 0.03763160f, -0.05087994f, 0.07375041f, 0.08055139f, -0.20378779f, -0.02177915f, 0.25676888f, 
    0.11766414f, 0.12751043f, 0.01405419f, 0.00667384f, -0.22853491f, 0.05463760f, -0.07083838f, -0.00182942f, 
    0.04315624f, -0.05278682f, 0.01524439f, 0.00528903f, -0.09751155f, -0.06059705f, 0.01510152f, -0.03664303f, 
    -0.04617488f, 0.00296611f, 0.04437255f, 0.03107344f, -0.40483752f, -0.24598897f, -0.13302591f, 0.15544209f, 
    0.19717830f, -0.06813210f, -0.10317045f, -0.10068288f, -0.19840060f, 0.05373654f, -0.01941007f, -0.00635140f, 
    -0.15190597f, -0.22278604f, 0.15333235f, 0.18559958f, -0.01069915f, -0.07291890f, -0.08455152f, -0.16374347f, 
    -0.17578422f, -0.03510759f, 0.00742807f, 0.07905234f, 0.22690064f, 0.08143668f, -0.00369031f, 0.08091061f, 
    0.00030978f, 0.10187386f, -0.07883797f, -0.08252234f, 0.05892045f, 0.04612898f, 0.03217441f, 0.10592768f, 
    -0.02153101f, 0.09267522f, 0.18854257f, -0.01833436f, 0.01188076f, -0.01211381f, -0.06817905f, 0.21027857f, 
    -0.05036199f, -0.01495133f, 0.00306376f, -0.00850311f, -0.26062676f, 0.39964250f, 0.05181085f, -0.24296744f, 
    0.06290804f, -0.05890228f, -0.00823261f, -0.04882390f, 0.03629308f, -0.06043422f, 0.01829765f, 0.05157841f, 
    0.10347633f, 0.16104315f, -0.06576512f, -0.10807537f, 0.11718485f, 0.11723083f, -0.03101766f, -0.07003722f, 
    0.00797558f, -0.02961145f, 0.00289870f, 0.11175521f, 0.39213347f, -0.08034535f, -0.06690929f, 0.28422001f, 
    0.05730990f, 0.07272454f, 0.00758632f, -0.13652985f, 0.24298140f, 0.16673997f, 0.07820154f, -0.10301030f, 
    -0.09277121f, 0.02705562f, 0.01820482f, -0.05889486f, -0.11051583f, 0.12114880f, 0.08083998f, 0.00244613f, 
    0.09503394f, 0.05549992f, 0.08527492f, 0.07348371f, -0.13834825f, -0.14243789f, -0.00925800f, -0.09829663f, 
    -0.10802078f, 0.02500912f, -0.12406304f, -0.04347594f, 0.08160101f, -0.06587544f, 0.06832581f, -0.10880791f, 
    0.03478874f, 0.12563196f, 0.11671264f, -0.14708260f, -0.02743073f, -0.08235714f, -0.00795422f, 0.09153999f, 
    -0.07315357f, -0.02989908f, 0.02722119f, -0.03947376f, -0.10680018f, -0.04704585f, 0.01110749f, -0.08288285f, 
    -0.07778497f, 0.01134804f, -0.10341746f, -0.10023960f, 0.05259342f, 0.03231198f, 0.09454968f, 0.06807981f, 
    -0.08105145f, 0.04790096f, -0.02931375f, -0.07965850f, -0.01947617f, -0.13796811f, -0.08246392f, -0.07919896f, 
    -0.17830876f, -0.13494898f, 0.14351204f, -0.00508149f, 0.21849503f, -0.10398072f, 0.05366493f, -0.18920179f, 
    -0.00880014f, -0.00847442f, 0.20515142f, -0.00246174f, 0.07568412f, -0.08666784f, -0.05515942f, 0.10792170f, 
    -0.05827293f, -0.10868981f, -0.25508684f, 0.12174107f, 0.00257515f, -0.12513565f, -0.03202458f, -0.00307996f, 
    -0.23273352f, 0.08773888f, -0.03061837f, -0.05833942f, 0.26219898f, -0.20525517f, -0.03826777f, 0.23538706f, 
    -0.00207471f, 0.12972246f, 0.13182411f, 0.09905335f, 0.05345700f, 0.04475068f, 0.08353292f, 0.06087887f, 
    -0.01118216f, -0.05386546f, -0.03734965f, -0.09254732f, -0.09468404f, 0.01128968f, -0.05672967f, 0.00585525f, 
    -0.00116565f, 0.05533570f, 0.04309732f, 0.06573875f, 0.10896463f, 0.14695960f, -0.02234362f, 0.10997108f, 
    0.12469611f, 0.15921704f, -0.05745404f, 0.09876235f, -0.05929757f, -0.01946075f, -0.10322808f, 0.23705447f, 
    0.03606763f, 0.18207276f, 0.02480987f, 0.23212354f, 0.09363154f, 0.22605231f, -0.03418283f, 0.08940898f, 
    0.15035452f, -0.00962839f, 0.00641339f, 0.11108451f, -0.29330891f, 0.20528734f, 0.01710705f, -0.23505178f, 
    -0.05751990f, -0.14251029f, -0.06580666f, -0.05834831f, -0.06937285f, 0.00423696f, 0.01779508f, -0.07494395f, 
    0.28826919f, 0.24763034f, -0.34026277f, -0.03813364f, -0.01250823f, 0.22395292f, 0.22380008f, 0.08842550f, 
    0.05914023f, 0.09724372f, 0.01336313f, 0.07534633f, -0.23547602f, 0.01484557f, 0.15066165f, -0.19006237f, 
    0.08603432f, -0.06943362f, -0.15689743f, -0.04132100f, 0.00451226f, 0.05244364f, 0.08010173f, 0.10476370f, 
    0.26333785f, 0.11559746f, -0.09556717f, -0.12862875f, 0.13723914f, 0.08301051f, 0.04317079f, -0.01441759f, 
    0.02032732f, -0.01117927f, 0.03943462f, 0.11038438f, -0.01956244f, 0.02539382f, -0.01216964f, 0.11259702f, 
    0.13491273f, 0.22404322f, 0.12795515f, -0.15052894f, 0.03115131f, -0.02541290f, 0.00476169f, -0.00961011f, 
    0.10371097f, 0.01907485f, 0.11822245f, 0.27362886f, 0.14135067f, 0.14207236f, -0.08103077f, 0.10763301f, 
    -0.06527958f, 0.04219169f, 0.11355454f, 0.07226335f, 0.13873936f, -0.23421831f, 0.09268618f, 0.01055716f, 
    0.02642345f, 0.08297342f, 0.05647154f, 0.08583742f, -0.09204058f, 0.00693331f, 0.12596917f, 0.06408835f, 
    -0.10430335f, 0.03202223f, 0.02417737f, -0.21837960f, -0.05912703f, 0.02013115f, -0.03364079f, -0.02369465f, 
    -0.00096947f, 0.02447259f, -0.02607680f, 0.15440261f, 0.40558726f, 0.17907555f, -0.13333966f, -0.21224587f, 
    -0.09405240f, -0.13010800f, -0.00766975f, -0.03967979f, 0.07816920f, -0.04925406f, -0.05627870f, -0.07453127f, 
    -0.30925688f, 0.05152152f, -0.04099797f, -0.05096888f, 0.05223202f, -0.08153106f, -0.14691932f, -0.14492629f, 
    -0.05713346f, 0.06900340f, 0.03915543f, 0.11150403f, -0.04351091f, 0.23186345f, -0.15220036f, -0.08256121f, 
    -0.07251459f, 0.15857342f, -0.13105766f, 0.07303929f, 0.03978533f, 0.00743901f, -0.01960617f, 0.10028112f, 
    -0.18073082f, -0.42201900f, -0.20685107f, -0.09708452f, 0.14900416f, -0.03198602f, -0.15638758f, -0.14662695f, 
    0.04323413f, 0.11632172f, 0.07177578f, -0.04854518f, -0.11254219f, 0.08583090f, -0.05464990f, -0.03602615f, 
    -0.07469258f, 0.08757805f, -0.00318655f, 0.00804530f, 0.12669700f, 0.03558172f, 0.06554402f, 0.10337658f, 
    -0.07506827f, -0.08474940f, -0.04590924f, -0.01378831f, 0.12219225f, 0.00096171f, -0.00946244f, -0.10102589f, 
    -0.13920754f, -0.15710755f, -0.06937362f, 0.00687169f, 0.41385525f, 0.18300411f, 0.16559421f, 0.13121565f, 
    -0.06377806f, 0.06305664f, 0.23422132f, 0.08150689f, 0.10073216f, 0.15020251f, 0.08500201f, 0.03038162f, 
    0.27848902f, 0.19199365f, 0.13128158f, -0.09046107f, -0.03449728f, -0.06959075f, 0.13785714f, 0.17657582f, 
    0.09741644f, 0.06171326f, 0.00436240f, 0.00128549f, -0.01035714f, -0.20707613f, -0.17108016f, -0.11893208f, 
    -0.01754263f, 0.17035586f, 0.07694117f, 0.22425331f, -0.00175874f, 0.06895692f, -0.03411816f, 0.09219871f, 
    -0.03889935f, -0.06688727f, -0.01080240f, 0.03085403f, -0.04442729f, 0.16632116f, 0.28318366f, 0.01139153f, 
    0.10629003f, 0.08837741f, 0.26016471f, 0.17940441f, 0.16571841f, -0.00713951f, -0.10434621f, 0.23080334f, 
    -0.08381732f, 0.03194818f, 0.03300776f, -0.07408319f, -0.06416869f, 0.01240570f, -0.09877525f, 0.04550897f, 
    -0.04676569f, -0.19360380f, -0.12804057f, -0.13080825f, 0.00518824f, -0.22086072f, -0.12568785f, 0.10235598f, 
    -0.08883543f, -0.06255005f, -0.02286077f, -0.05594328f, 0.33947301f, -0.18957295f, -0.10019171f, 0.01712339f, 
    0.01815608f, 0.01997960f, 0.02414386f, 0.06744274f, -0.05139005f, 0.12257633f, 0.06424268f, 0.08231023f, 
    -0.01785954f, 0.20821089f, 0.05659028f, 0.09607582f, -0.06715015f, -0.07983065f, -0.09182879f, -0.04798293f, 
    -0.14631440f, 0.05693967f, 0.12875949f, -0.03198388f, 0.04631631f, 0.05923730f, 0.03414634f, 0.07882129f, 
    -0.10918112f, -0.00495078f, 0.42123997f, 0.08267604f, 0.15723103f, 0.05216142f, -0.09646084f, 0.05368425f, 
    -0.08268593f, 0.04697933f, -0.04388743f, 0.03480373f, -0.10361391f, 0.03679699f, 0.02078477f, -0.01874400f, 
    0.09346896f, 0.12546468f, 0.05042180f, -0.01943389f, 0.08255670f, 0.14601073f, 0.15780327f, 0.00504559f, 
    -0.00943997f, -0.07668690f, 0.05720659f, 0.01260264f, -0.02140063f, 0.01598115f, -0.07857268f, 0.00800881f, 
    0.11347114f, 0.07437637f, 0.07381249f, -0.04825579f, 0.01740470f, 0.04438848f, -0.01179405f, -0.06783810f, 
    0.14479849f, 0.09754141f, 0.12773256f, 0.12593813f, -0.07282709f, -0.06028381f, 0.08248123f, 0.19637468f, 
    0.02069090f, 0.07005236f, -0.03555959f, -0.07824251f, -0.00565665f, 0.06176570f, -0.03097056f, -0.10630035f, 
    -0.11380001f, 0.13241374f, 0.15774044f, 0.04802657f, 0.00981157f, 0.07038812f, -0.00801782f, -0.11984377f, 
    0.08209557f, 0.02416477f, -0.00252957f, 0.07013347f, -0.12825005f, 0.04403193f, 0.01084956f, -0.18822850f, 
    -0.05760593f, -0.02519294f, 0.10739709f, 0.16854109f, 0.07381047f, -0.09658863f, -0.10281733f, -0.01502645f, 
    0.08947299f, 0.11960456f, 0.07653374f, 0.02440964f, 0.04095911f, -0.03654442f, 0.04605155f, -0.06667975f, 
    -0.01720580f, 0.08794178f, -0.04711576f, -0.09000060f, 0.09850220f, -0.43223578f, -0.24307039f, -0.16071461f, 
    0.06318846f, -0.16091719f, 0.13336265f, 0.16056778f, -0.05354024f, 0.09498080f, 0.03814058f, 0.13683377f, 
    0.14779237f, -0.22599955f, -0.06638889f, -0.06792541f, 0.01780982f, -0.03387222f, 0.03601716f, 0.12822929f, 
    0.01030677f, 0.09203299f, 0.06535554f, 0.00852990f, 0.30890670f, 0.17080887f, 0.02096536f, 0.04939372f, 
    -0.03795061f, 0.03314236f, 0.07891281f, -0.04147364f, -0.04699014f, 0.00823919f, 0.12219689f, -0.01171198f, 
    -0.17970374f, -0.08283374f, 0.16642621f, -0.15159178f, -0.06973127f, -0.05596446f, -0.07609784f, 0.02503852f, 
    -0.00877822f, 0.20976038f, -0.08182675f, -0.07016809f, 0.33303696f, 0.22581472f, -0.16708881f, -0.04227005f, 
    0.11340716f, 0.10165980f, 0.02197388f, -0.03314057f, -0.03003116f, -0.06804583f, 0.03286970f, -0.14579783f, 
    0.05231697f, -0.12110955f, -0.14991833f, -0.00302191f, 0.01579660f, -0.10403902f, 0.14703774f, -0.01673672f, 
    0.01767019f, 0.07543072f, 0.01320905f, 0.08054604f, -0.09543340f, -0.06246854f, 0.03107681f, -0.27972522f, 
    -0.04666556f, -0.34322482f, 0.26045004f, 0.00164983f, -0.03025059f, 0.02535616f, -0.09157655f, -0.15578882f, 
    -0.11738432f, -0.18281461f, -0.05526555f, 0.03837011f, 0.01642323f, -0.12662557f, -0.03068720f, -0.05490864f, 
    -0.08524831f, -0.00742363f, -0.13662675f, -0.17672659f, -0.24212064f, 0.12018921f, -0.12687525f, -0.16135406f, 
    -0.10859930f, -0.10029752f, -0.04940972f, -0.12885001f, 0.05656523f, 0.01064123f, -0.07000582f, -0.10951819f, 
    0.17393202f, 0.13926962f, 0.21110724f, 0.13415074f, 0.01084750f, 0.00660835f, 0.02672156f, -0.02695101f, 
    -0.07363563f, 0.08285002f, -0.09070246f, -0.06826312f, -0.01787815f, -0.27151850f, -0.08580869f, -0.05321008f, 
    0.03911014f, 0.09589752f, 0.10485423f, 0.02240680f, 0.02303043f, 0.09175680f, 0.09578933f, 0.25416514f, 
    0.24840663f, 0.01658594f, 0.00879748f, -0.03218720f, 0.19523764f, 0.02320746f, -0.03534773f, 0.02373890f, 
    -0.07530958f, -0.09201618f, -0.06881952f, -0.04853472f, 0.04696695f, -0.01422922f, 0.05982566f, 0.03272298f, 
    0.11555360f, -0.00868336f, 0.02492293f, 0.07375199f, -0.02230453f, 0.03598659f, 0.08412690f, 0.06463291f, 
    -0.14505909f, -0.07495101f, 0.33284751f, 0.19669120f, 0.04097482f, 0.05077254f, -0.05746231f, 0.04078090f, 
    0.12366033f, 0.03533610f, -0.04252300f, 0.03765322f, -0.19352163f, 0.12344243f, 0.11126190f, -0.10316264f, 
    -0.05045068f, -0.18231094f, 0.07610807f, 0.18884836f, 0.25768641f, 0.01405700f, 0.18090077f, 0.07696347f, 
    -0.01754384f, -0.08564826f, -0.05911945f, -0.06599322f, 0.00858876f, 0.23184705f, 0.00977388f, -0.05617489f, 
    -0.00951787f, 0.04240241f, -0.00461018f, -0.07657281f, -0.23295638f, 0.25743100f, 0.08718108f, -0.32757220f, 
    0.02572666f, -0.03625049f, -0.07070342f, 0.27568096f, 0.04006948f, 0.02856032f, 0.09657859f, 0.03430763f, 
    -0.22260672f, 0.27233669f, -0.14599457f, -0.24062920f, -0.00584860f, 0.17477457f, -0.08563606f, -0.09347263f, 
    0.19563088f, 0.09300863f, 0.07702124f, 0.05694530f, -0.02240181f, -0.17946298f, 0.03978978f, -0.16577010f, 
    0.09024436f, 0.06012474f, 0.05834994f, 0.15027185f, -0.08144727f, 0.03535460f, -0.12111446f, -0.04985081f, 
    -0.02929783f, -0.08676944f, 0.00106502f, 0.03504396f, 0.13652913f, -0.15285613f, 0.12076510f, -0.06727910f, 
    -0.06068518f, 0.06719623f, 0.05036737f, -0.02387387f, 0.30766514f, 0.00491939f, 0.37515396f, 0.01003532f, 
    0.19645679f, -0.05466436f, -0.04971718f, 0.12023919f, -0.06770663f, 0.05595158f, 0.07214464f, -0.08118518f, 
    -0.16435030f, 0.03564592f, 0.13736571f, 0.22063167f, -0.00904976f, 0.05171508f, 0.13015541f, -0.01549061f, 
    0.05333488f, -0.01121024f, -0.02338501f, -0.03965594f, -0.49422714f, -0.00919579f, 0.39942998f, -0.34662080f, 
    -0.08293986f, -0.06734725f, -0.12049260f, 0.07453594f, -0.09340888f, 0.00405494f, -0.00040402f, 0.09128514f, 
    0.14918932f, -0.17793214f, -0.01530777f, 0.03479318f, -0.00767792f, -0.05033224f, -0.07731253f, 0.09305987f, 
    0.07947795f, 0.19245669f, -0.03929774f, 0.18802236f, -0.09946571f, 0.03286238f, -0.18030109f, -0.03469950f, 
    0.04238845f, -0.01853261f, 0.09320774f, 0.20731983f, -0.02929981f, 0.18354601f, -0.03919929f, 0.14695169f, 
    0.05046837f, -0.18898539f, -0.11108464f, 0.04062833f, 0.19239025f, 0.05129632f, -0.17901209f, 0.11619427f, 
    0.08952799f, 0.09103203f, 0.11278792f, 0.07888001f, -0.04203154f, -0.12737796f, -0.07671809f, -0.02958538f, 
    0.01866370f, -0.03494451f, -0.05583118f, -0.05651659f, 0.02639934f, -0.02269982f, -0.06460429f, 0.01925863f, 
    0.05421253f, -0.16660345f, -0.20444408f, 0.03001209f, 0.06648494f, 0.05601447f, 0.06434523f, -0.01404137f, 
    0.09187743f, 0.10789851f, -0.04426449f, 0.15100701f, -0.06145709f, 0.11657603f, 0.09755547f, 0.02980836f, 
    0.01757359f, 0.10097297f, -0.13211897f, 0.04915421f, 0.05211531f, 0.09446079f, 0.04420534f, -0.10665002f, 
    0.17594931f, -0.13253202f, -0.03639158f, -0.17453198f, -0.07128773f, 0.05787880f, -0.06177426f, 0.04488656f, 
    0.32463405f, -0.01914652f, 0.09323701f, 0.26703209f, -0.23574133f, 0.08702195f, 0.13653331f, -0.11114354f, 
    0.07940112f, 0.07128730f, 0.00130849f, 0.11032410f, -0.11869657f, -0.16878699f, 0.02270689f, -0.07256787f, 
    -0.12217075f, -0.08287270f, -0.00380264f, 0.00952324f, 0.09252802f, -0.07694134f, -0.05048942f, 0.04149352f, 
    0.07037850f, 0.02774942f, 0.08071721f, 0.08921742f, -0.22720946f, 0.14478584f, 0.07307985f, 0.09152161f, 
    -0.10084802f, -0.13613762f, 0.12840661f, -0.02369702f, -0.04529341f, -0.09264378f, 0.07242916f, -0.03567770f, 
    -0.02854466f, -0.19339284f, 0.29190651f, -0.11378843f, -0.00079695f, -0.06133511f, 0.07796036f, 0.05854299f, 
    0.00144565f, 0.09050968f, 0.08129164f, 0.12419663f, 0.27119294f, -0.03787366f, 0.03305101f, 0.27908251f, 
    0.07508809f, -0.02914424f, 0.07867712f, 0.03427716f, -0.02302175f, 0.06597520f, 0.01163705f, -0.00475139f, 
    -0.05050983f, -0.29459992f, 0.35429320f, 0.10669873f, -0.01183193f, -0.19698572f, -0.00850056f, 0.02577540f, 
    0.08933304f, -0.17824996f, 0.09134637f, -0.08843266f, -0.17085825f, -0.13750972f, -0.01887953f, 0.18839002f, 
    0.03396763f, 0.02076357f, -0.01128627f, 0.03112415f, 0.09557159f, 0.07359474f, -0.04518824f, 0.00417756f, 
    -0.25431502f, -0.01655991f, 0.18818265f, 0.13683550f, -0.11283573f, -0.01876310f, -0.02555837f, 0.08527911f, 
    0.10644922f, 0.00239624f, -0.09782632f, 0.07369886f, 0.05555587f, 0.03642279f, -0.23650640f, 0.07725102f, 
    -0.02573477f, 0.08928336f, 0.01621835f, 0.17403224f, -0.10949717f, 0.01878398f, 0.08558412f, 0.11323114f, 
    -0.12261840f, 0.20248210f, 0.17751369f, -0.09124693f, 0.06444609f, 0.01058327f, -0.05434009f, -0.09053305f, 
    0.08841031f, -0.11290874f, -0.01088294f, -0.02728307f, -0.02285310f, 0.26861790f, -0.02804777f, 0.12863055f, 
    0.02324273f, -0.04175833f, -0.03817246f, 0.07250338f, 0.25228375f, 0.01676639f, -0.00139635f, 0.02187134f, 
    0.06304762f, -0.07063881f, -0.03337159f, 0.05497086f, -0.06104592f, -0.03224247f, -0.07648620f, -0.00798574f, 
    0.07226594f, -0.01031540f, 0.06021045f, -0.08739492f, -0.19455844f, -0.12583961f, 0.08995858f, 0.07079988f, 
    0.13698161f, 0.06268660f, -0.05386601f, 0.03232626f, -0.01830310f, 0.07604975f, 0.08512595f, 0.04711287f, 
    0.18643798f, -0.05209731f, -0.04533946f, 0.04453921f, -0.02621506f, -0.00453863f, 0.11642767f, 0.04556730f, 
    -0.01171050f, -0.05955516f, -0.01782991f, -0.06918422f, 0.22219555f, -0.25644937f, 0.06880648f, 0.20791803f, 
    0.03072358f, 0.19935788f, -0.01154173f, 0.06681076f, 0.04972638f, -0.00417045f, -0.07890584f, 0.01838112f, 
    0.30257118f, 0.05618748f, 0.02858420f, -0.09692787f, 0.06705848f, -0.07604844f, 0.17465395f, 0.05554479f, 
    0.03222660f, -0.09727933f, -0.07914289f, -0.04085457f, 0.32068813f, 0.11993799f, 0.03001181f, 0.13187800f, 
    0.03577465f, 0.05041464f, -0.03239620f, 0.03337178f, 0.01642925f, 0.00212487f, 0.03748189f, 0.01547580f, 
    -0.07482921f, 0.07151925f, 0.01623160f, -0.05942422f, -0.02787952f, -0.07563077f, 0.03065174f, -0.04730128f, 
    -0.04760279f, -0.05559794f, -0.04898814f, 0.04883808f, -0.00658473f, -0.25808603f, -0.38868564f, 0.38839650f, 
    0.06147979f, -0.06014319f, 0.00055446f, -0.12329058f, -0.24790570f, 0.07480910f, -0.13927671f, 0.08450398f, 
    -0.06584454f, -0.51907426f, 0.26406401f, 0.09068636f, -0.02844834f, -0.04473112f, -0.00905791f, 0.00123659f, 
    -0.24653281f, -0.09129554f, -0.13027817f, 0.00658309f, 0.09988020f, 0.05692494f, 0.09692208f, -0.03250054f, 
    -0.03162709f, -0.10680109f, -0.01701121f, 0.02069860f, -0.00611141f, -0.08491839f, 0.15394494f, 0.06277255f, 
    -0.13922152f, 0.09183862f, -0.09254039f, 0.05728365f, -0.01338689f, 0.04602499f, -0.04453990f, 0.05723330f, 
    0.09469239f, -0.03975463f, 0.03184569f, 0.02794680f, -0.25560552f, 0.05686584f, -0.25150549f, -0.01116262f, 
    -0.02314337f, 0.03059853f, 0.03318460f, -0.08973469f, -0.01648653f, -0.00026919f, -0.06952460f, 0.01866679f, 
    0.32568997f, 0.25820059f, 0.08246084f, -0.00858487f, 0.01838174f, 0.04498895f, -0.09858758f, 0.01639134f, 
    0.01471990f, 0.01381788f, 0.02857958f, 0.03257639f, 0.56070691f, 0.14558595f, -0.24518333f, 0.19351639f, 
    0.01534507f, 0.10668725f, 0.03456714f, 0.10207196f, 0.08884213f, 0.04239713f, -0.02437958f, -0.07766283f, 
    0.07029992f, 0.14164975f, -0.00190340f, 0.03284015f, -0.04858124f, 0.03952678f, 0.02676564f, -0.07740312f, 
    0.08722324f, 0.03178751f, -0.00670332f, -0.10723288f, 0.10042692f, -0.08218021f, 0.08595701f, -0.14627297f, 
    -0.06388115f, -0.01218736f, -0.15573280f, -0.10893252f, -0.10150994f, -0.15328318f, 0.01974523f, -0.05926412f, 
    -0.32868558f, 0.03370932f, 0.00262997f, 0.02100341f, 0.03701625f, 0.02581631f, -0.00285603f, -0.13473751f, 
    0.05024242f, 0.00894778f, -0.04266553f, -0.30550382f, -0.13670422f, -0.18596902f, -0.16117406f, -0.10216621f, 
    -0.05209441f, 0.07560986f, -0.05875116f, -0.00087334f, 0.00604076f, -0.04861846f, 0.05537673f, -0.02176312f, 
    -0.13409168f, 0.05344275f, -0.03427872f, -0.11129177f, -0.05352427f, -0.05863379f, -0.00478445f, -0.11308093f, 
    -0.12815046f, -0.00546016f, 0.07605143f, 0.05491434f, 0.18639597f, -0.36870992f, 0.11931772f, 0.17242961f, 
    0.02026062f, -0.03052129f, 0.11229985f, 0.02360584f, 0.13792449f, -0.04921067f, 0.04243655f, -0.07318544f, 
    -0.20070904f, 0.01573707f, -0.09399863f, 0.06654771f, -0.02944064f, -0.11050564f, 0.07937739f, 0.03858247f, 
    -0.27994421f, -0.08653597f, -0.11834400f, -0.24483500f, 0.45418760f, 0.03880808f, 0.04602161f, 0.16205394f, 
    -0.03599024f, 0.07516357f, 0.05456946f, 0.13419390f, 0.00100717f, 0.10940133f, -0.03242385f, 0.05412468f, 
    -0.15460886f, -0.03943301f, -0.08575628f, -0.07861208f, -0.11432604f, 0.04097284f, 0.02986149f, -0.02140362f, 
    0.00451892f, 0.09764528f, -0.09831033f, -0.08327916f, 0.25548765f, 0.16681434f, 0.05990472f, -0.00436516f, 
    0.08550589f, 0.18525235f, -0.12433815f, -0.01128036f, -0.04501224f, -0.02267132f, -0.13165571f, 0.10682955f, 
    0.09291321f, 0.19957227f, 0.03164534f, 0.10655253f, -0.03672409f, 0.12935174f, -0.11038585f, -0.02664994f, 
    0.05073201f, -0.08183141f, 0.01506821f, 0.08134370f, -0.32323086f, 0.07126226f, -0.29157290f, -0.52757841f, 
    -0.00759314f, 0.02170066f, -0.02490910f, -0.02553851f, 0.04261021f, 0.00312683f, -0.12507991f, -0.05665654f, 
    0.31675521f, 0.26073501f, -0.02536495f, 0.08015608f, -0.05078892f, 0.13645753f, 0.12875095f, -0.02258262f, 
    -0.04179403f, 0.17666395f, 0.03649306f, 0.06307064f, -0.22760373f, -0.16211246f, 0.12816826f, -0.17659226f, 
    -0.00289642f, 0.02401709f, -0.08973732f, -0.02414972f, -0.02267391f, -0.11308873f, 0.10693774f, -0.02036435f, 
    0.30427474f, 0.23377156f, 0.04697447f, 0.03994799f, 0.05954688f, -0.04072399f, 0.02589224f, 0.04032245f, 
    -0.06932433f, -0.00064056f, 0.04987288f, -0.02064951f, 0.05180288f, 0.16218413f, 0.17289838f, -0.19058231f, 
    -0.08636758f, 0.07948164f, 0.12131085f, -0.12721418f, 0.11301222f, 0.03638439f, -0.11226341f, -0.09820732f, 
    0.15672767f, 0.02311900f, 0.09092440f, 0.19427299f, 0.11857274f, 0.15269600f, 0.07758075f, 0.08085848f, 
    -0.17806524f, -0.08464459f, 0.06427241f, 0.09891340f, 0.25914159f, 0.03775374f, -0.05768035f, -0.10601933f, 
    -0.02655567f, 0.01226457f, 0.03912945f, -0.07097883f, -0.00439928f, 0.00113791f, 0.03916409f, 0.00144173f, 
    -0.32280657f, -0.45120144f, -0.46545255f, -0.43941218f, -0.06437796f, 0.02971913f, 0.03504432f, 0.03741985f, 
    -0.11132950f, -0.07627258f, -0.02180751f, -0.06742811f, 0.35765156f, -0.16456896f, -0.02257626f, 0.21663034f, 
    -0.11552141f, -0.03352374f, 0.12220890f, -0.09313780f, 0.09618750f, 0.00835720f, -0.10357065f, 0.08764692f, 
    -0.16749020f, 0.24545844f, -0.01109927f, -0.25354773f, -0.05001106f, 0.11038826f, -0.08233277f, -0.05603314f, 
    -0.07914149f, 0.00292577f, 0.07736975f, -0.00053788f, -0.12483109f, 0.27360159f, -0.12238802f, -0.07848129f, 
    0.08207215f, -0.03068247f, -0.04338212f, -0.11274538f, -0.11817664f, -0.00242105f, 0.02214073f, -0.22549416f, 
    0.01676639f, -0.10200766f, 0.07495998f, -0.02967831f, 0.04469587f, -0.06430979f, 0.01477100f, -0.02037899f, 
    -0.00534882f, 0.05563873f, -0.01510744f, 0.14123899f, 0.00594176f, 0.17927422f, 0.06206860f, 0.24416894f, 
    -0.12677832f, -0.10452997f, 0.07990027f, 0.06914139f, 0.02658824f, 0.12815537f, 0.04231355f, 0.02306587f, 
    -0.10467032f, 0.04158454f, -0.06934847f, -0.00113190f, 0.14755888f, 0.12057237f, -0.01277681f, -0.04178628f, 
    -0.09008973f, -0.03857730f, 0.03718689f, -0.06247482f, -0.11779057f, 0.05135666f, 0.27180597f, -0.28755027f, 
    0.26857695f, -0.10298178f, -0.30786788f, 0.14364126f, 0.01041667f, 0.28448907f, 0.02864532f, -0.18192956f, 
    -0.05067850f, -0.07140423f, 0.23062113f, -0.10195652f, 0.03999939f, 0.01737215f, -0.08059154f, 0.05683364f, 
    0.07503620f, 0.11804821f, 0.03072897f, 0.05517048f, 0.14039338f, 0.14778793f, -0.12084694f, 0.27889475f, 
    0.00333828f, 0.00605603f, 0.11497447f, 0.07486154f, -0.12862012f, -0.01255104f, -0.05204018f, -0.03417748f, 
    0.32707784f, -0.14287178f, 0.22063360f, -0.12325010f, 0.01494240f, -0.27141836f, 0.04248264f, 0.13495013f, 
    -0.07098181f, -0.08289016f, 0.01352029f, 0.01690412f, 0.11830083f, -0.05619999f, 0.47037154f, -0.05626422f, 
    -0.00525632f, -0.08777613f, -0.09615962f, -0.01658939f, -0.00059924f, -0.13323295f, 0.05235545f, -0.13020779f, 
    -0.17953315f, 0.08154249f, 0.15040800f, 0.09858625f, -0.09310245f, 0.01636060f, -0.07968740f, -0.11860780f, 
    -0.05431215f, -0.15036863f, -0.09707124f, -0.09368686f, -0.21814960f, 0.17376369f, -0.00327499f, 0.05835521f, 
    -0.12229460f, 0.03111933f, -0.03033515f, 0.02415969f, -0.06290083f, 0.03354748f, 0.05594315f, -0.03019636f, 
    -0.19530123f, -0.35939625f, 0.08266967f, 0.05436453f, -0.15574700f, 0.10076399f, 0.13415423f, 0.16738826f, 
    0.15143530f, 0.01420678f, -0.00877460f, 0.11878875f, 0.03295170f, 0.01647340f, -0.09061874f, -0.01250809f, 
    -0.01759501f, 0.03327831f, 0.05980708f, 0.17370816f, 0.12277311f, -0.05304415f, -0.04098287f, -0.08817853f, 
    0.13256972f, 0.01846334f, -0.12283394f, 0.15731889f, 0.08238126f, 0.00583556f, 0.08395147f, -0.07169924f, 
    0.04206840f, 0.17852837f, 0.07823217f, 0.00181367f, 0.00146642f, -0.05428933f, 0.04325701f, 0.03954791f, 
    0.01045428f, 0.02407156f, -0.04352859f, 0.15499598f, 0.02614358f, -0.02045434f, 0.04054451f, 0.03574974f, 
    0.01796797f, -0.03627387f, -0.11031306f, -0.04558720f, -0.03550775f, -0.02045188f, -0.05267278f, -0.01300984f, 
    -0.04203565f, 0.07778861f, -0.08294887f, 0.09095143f, -0.20771445f, -0.11867684f, 0.01519190f, 0.06325030f, 
    0.09525879f, 0.01706888f, 0.04858825f, 0.05870818f, 0.17960803f, 0.10492911f, 0.02134095f, -0.08991182f, 
    0.10039528f, -0.06218413f, -0.07118160f, 0.09151812f, -0.04445939f, -0.02903305f, -0.02150767f, 0.14267130f, 
    0.04848502f, 0.07171928f, -0.06290767f, 0.26416886f, -0.14951944f, -0.27745947f, 0.06195747f, -0.07953380f, 
    -0.10936908f, 0.03024615f, -0.05665404f, -0.00010821f, -0.09470861f, -0.13444656f, -0.07031207f, -0.04637408f, 
    -0.04829255f, -0.01216394f, -0.04046166f, 0.09030254f, 0.01010854f, 0.08069272f, 0.11890555f, 0.12496699f, 
    0.03641151f, 0.07664857f, 0.15809782f, 0.11812001f, -0.19302741f, 0.31472039f, 0.27614716f, 0.18900280f, 
    0.00350218f, -0.03958273f, 0.07806610f, -0.05526733f, -0.07865290f, -0.14131984f, -0.03250971f, -0.10010199f, 
    -0.08843074f, -0.05742300f, 0.25897452f, -0.01879904f, -0.12841566f, 0.15443079f, -0.04326000f, 0.01180777f, 
    -0.06267014f, -0.19595225f, -0.05457477f, -0.07988887f, 0.16125020f, 0.40220338f, 0.16159312f, 0.08283323f, 
    0.01048227f, -0.08526160f, -0.05288785f, 0.07576318f, -0.02611271f, 0.01793434f, -0.02519054f, -0.03312082f, 
    0.01486838f, -0.21868198f, -0.02304627f, 0.08666598f, -0.13703188f, -0.21351852f, -0.16445491f, -0.01747146f, 
    0.06253365f, 0.03905455f, 0.06403662f, -0.08940367f, 0.13469675f, 0.08762679f, 0.26872194f, 0.05977298f, 
    0.00024083f, -0.00299584f, 0.03580486f, 0.09239417f, 0.00762189f, 0.04268775f, 0.00582133f, 0.06239608f, 
    -0.19291660f, -0.10197127f, 0.02595108f, -0.01938117f, -0.09721120f, 0.01177582f, 0.05875371f, -0.09457422f, 
    -0.09908469f, -0.06218802f, 0.02435541f, -0.01204872f, 0.06463289f, 0.11426134f, -0.08607655f, 0.08987156f, 
    -0.12303267f, 0.14516005f, 0.12972334f, 0.04693457f, -0.09423674f, -0.04553463f, -0.11576130f, -0.19663234f, 
    -0.04790245f, -0.06368542f, -0.05641721f, 0.01586478f, 0.18228333f, 0.01767022f, -0.16335715f, -0.10541590f, 
    -0.08125848f, -0.10250090f, 0.01872143f, -0.03340918f, -0.23756416f, 0.01813300f, 0.04990563f, 0.17363390f, 
    0.01906689f, -0.00029304f, 0.13668096f, -0.04058461f, 0.15105578f, -0.07036424f, -0.07630812f, 0.07588616f, 
    0.13196026f, 0.00930504f, -0.01885754f, 0.11943102f, -0.06937817f, 0.04615225f, -0.04247149f, -0.00191429f, 
    -0.08638805f, 0.05572785f, 0.01520139f, -0.01842461f, 0.03252103f, -0.41774371f, -0.05823356f, 0.13990660f, 
    0.12653039f, -0.03714424f, 0.15009618f, -0.01715450f, 0.06263314f, -0.10907297f, 0.23110470f, 0.20416248f, 
    0.16005327f, 0.27385798f, 0.09810756f, 0.03721701f, -0.09138054f, -0.03425061f, 0.04615654f, -0.01945124f, 
    0.04840554f, 0.01256447f, 0.04074484f, 0.01357351f, 0.07306797f, 0.13562059f, -0.07529967f, 0.21621488f, 
    0.11894086f, 0.18685681f, -0.05329877f, -0.05708726f, -0.00107930f, 0.02642870f, 0.02998360f, 0.15169571f, 
    0.01850507f, -0.32173350f, 0.14843185f, 0.03202222f, -0.02996463f, -0.04476056f, -0.02950767f, -0.17429072f, 
    0.02766812f, 0.05630299f, 0.06901977f, 0.10351107f, -0.12378498f, 0.15130302f, 0.25181651f, -0.07950547f, 
    -0.19877486f, 0.06089651f, 0.07461713f, 0.02599058f, 0.13951960f, -0.03306158f, 0.14151821f, 0.05888775f, 
    -0.03413992f, -0.12074716f, -0.04424112f, -0.05766193f, 0.14917664f, 0.11143801f, 0.04015522f, 0.13324092f, 
    0.06739452f, -0.07667655f, -0.04142015f, 0.03604734f, 0.12793966f, 0.38801774f, 0.12467680f, -0.10811347f, 
    0.15434022f, -0.11414428f, 0.08225517f, 0.09515819f, 0.06275348f, 0.13197513f, 0.03736990f, 0.00675387f, 
    -0.04199916f, 0.13915995f, 0.02824689f, -0.05571343f, 0.08524934f, 0.17018785f, 0.09488963f, 0.18661238f, 
    0.11122066f, -0.13188417f, 0.07566506f, 0.11290441f, 0.06032215f, -0.45672143f, 0.05115673f, -0.14370552f, 
    0.12981062f, 0.14535487f, 0.28234059f, 0.02935500f, 0.02919951f, -0.01229949f, 0.01127440f, 0.12150314f, 
    -0.07314467f, 0.07422198f, -0.15873167f, 0.07045106f, 0.12272035f, 0.00010977f, 0.10859808f, 0.01148743f, 
    0.10699794f, 0.03934344f, 0.24461007f, 0.18968968f, 0.02066843f, 0.01335404f, 0.12813269f, -0.00921259f, 
    0.10558627f, 0.07920276f, 0.10857110f, 0.11601520f, 0.04539556f, -0.04262558f, -0.01840640f, -0.00576435f, 
    -0.17332081f, -0.07095496f, 0.07355429f, 0.06181965f, -0.04078737f, -0.05246294f, 0.00249312f, -0.10634002f, 
    0.03718349f, 0.03844382f, -0.02334526f, -0.03426473f, -0.26080811f, -0.09504092f, 0.26836786f, -0.05873131f, 
    -0.10222568f, -0.05296441f, 0.03200638f, 0.10955938f, -0.08477908f, -0.12168930f, 0.16362494f, 0.15372775f, 
    0.13931596f, -0.10802668f, 0.05639835f, -0.09148328f, -0.03298985f, -0.05114478f, 0.01813429f, -0.04481055f, 
    0.11728029f, 0.11937231f, 0.10003331f, 0.10952344f, 0.09855887f, 0.05929450f, -0.03235162f, 0.03833975f, 
    0.06208752f, 0.06802357f, 0.13009839f, -0.09282425f, -0.00376761f, -0.10627152f, 0.02963504f, 0.16597347f, 
    0.15845816f, -0.29803431f, -0.16360317f, 0.04701984f, 0.12043191f, 0.08319045f, -0.04017362f, 0.09052869f, 
    0.10963754f, 0.04369112f, -0.12073725f, -0.06149077f, 0.02195481f, 0.15686332f, 0.04327114f, -0.04312902f, 
    0.02150750f, -0.01168810f, -0.01876917f, -0.09799049f, -0.02379944f, -0.12407959f, -0.18908474f, -0.03902460f, 
    0.18085504f, 0.05139340f, -0.00558246f, 0.02319909f, 0.03256685f, -0.04122860f, 0.03083170f, -0.06922054f, 
    0.08093305f, 0.10113763f, 0.02033207f, 0.01883005f, 0.07448050f, -0.15421873f, 0.01424528f, 0.17872910f, 
    0.02604216f, -0.02046970f, 0.00615618f, 0.07653001f, 0.01885371f, 0.24778686f, -0.03534975f, -0.11385559f, 
    0.07174490f, 0.05102885f, 0.23813689f, -0.08211736f, 0.04717194f, 0.05327448f, -0.01395549f, -0.05040381f, 
    0.12146249f, 0.10746777f, -0.01770444f, 0.14403549f, -0.15275019f, 0.08423191f, -0.02670860f, -0.21890916f, 
    0.04042701f, -0.07625157f, -0.06225532f, -0.01442268f, -0.01629852f, -0.01262419f, 0.05770449f, 0.08498455f, 
    -0.00485357f, 0.07186643f, -0.06826689f, -0.05510482f, 0.00751752f, -0.01993875f, -0.00157678f, -0.04788891f, 
    0.12770425f, 0.15596412f, 0.03469502f, 0.11093505f, -0.26823992f, 0.03420745f, 0.03150248f, -0.08193707f, 
    0.02598102f, -0.05795000f, -0.02452815f, -0.10951590f, -0.01755074f, 0.02623739f, 0.04908406f, -0.04492867f, 
    0.09420130f, -0.18118075f, 0.12197234f, 0.00520510f, -0.09971002f, 0.00961095f, 0.10962103f, 0.17292467f, 
    0.01790723f, 0.14536935f, 0.04496776f, 0.07238676f, 0.23010796f, 0.13295697f, -0.02153925f, 0.04910706f, 
    0.10703040f, 0.00298341f, -0.05412746f, 0.02326745f, -0.00939664f, 0.01130359f, 0.07860327f, -0.07428779f, 
    -0.14414607f, -0.21393031f, 0.28910321f, 0.01348218f, -0.12454019f, -0.28347602f, -0.21042758f, 0.07962863f, 
    0.02832075f, -0.00871678f, 0.07053937f, -0.00363474f, 0.33292812f, -0.01149578f, -0.08578277f, -0.02443952f, 
    0.00699644f, -0.02998935f, 0.02496028f, -0.02965808f, 0.06378243f, 0.05506238f, -0.03601297f, -0.07473823f, 
    -0.14786035f, 0.00752184f, 0.13025007f, 0.01928864f, -0.09277587f, -0.07704250f, -0.01435932f, -0.14896958f, 
    0.06046370f, 0.06017325f, 0.05206192f, 0.04182643f, -0.12991440f, 0.14954692f, -0.11902171f, -0.02333089f, 
    -0.16933735f, -0.11472505f, 0.32262263f, 0.24122465f, 0.02220692f, 0.04944361f, -0.11266144f, 0.06315336f, 
    -0.23869793f, -0.08785190f, -0.10513218f, -0.14788251f, 0.06539260f, -0.04853879f, 0.16443534f, 0.28649333f, 
    0.07607117f, 0.05158498f, 0.03424052f, -0.10881248f, -0.20677310f, 0.14044622f, 0.12076907f, 0.03598032f, 
    -0.11001708f, -0.04496867f, -0.04632064f, -0.05956671f, 0.24382859f, 0.05005900f, 0.24168658f, 0.20044920f, 
    -0.00158591f, 0.07598844f, 0.13048549f, 0.02237910f, 0.03318999f, -0.06554152f, -0.03280211f, -0.01780231f, 
    0.08786715f, 0.03396537f, -0.14926563f, -0.14445163f, 0.16056526f, -0.52008700f, 0.09696271f, 0.04250498f, 
    0.14137432f, 0.06584533f, 0.02862383f, 0.12970340f, 0.07023343f, 0.11083656f, 0.09287082f, 0.34165648f, 
    0.15426189f, 0.05047371f, 0.02333384f, -0.00987777f, 0.10822050f, 0.02918707f, 0.01851957f, -0.01069577f, 
    0.04838275f, 0.00052730f, -0.01489333f, -0.01660201f, 0.34842712f, -0.30641398f, 0.01550063f, 0.11152750f, 
    0.32134351f, -0.11681870f, -0.05864431f, 0.19373523f, 0.01205016f, 0.02073082f, -0.04810217f, 0.09539847f, 
    0.18992236f, 0.02602328f, 0.39569995f, -0.07961495f, 0.02341094f, 0.10229948f, 0.01530772f, 0.05520379f, 
    -0.05168213f, -0.13427852f, -0.02679409f, -0.11885631f, -0.03316081f, 0.00142606f, -0.35032409f, -0.13101311f, 
    0.02586775f, 0.00495974f, 0.06732833f, 0.08288530f, 0.10538574f, -0.01877144f, 0.22683835f, -0.07393854f, 
    0.07389012f, 0.09257127f, 0.06222506f, 0.04831683f, -0.08806764f, 0.19070214f, -0.02340424f, -0.00305403f, 
    0.10865257f, -0.02047393f, -0.10579141f, -0.12383150f, 0.01552807f, 0.33615664f, -0.07748411f, 0.12294687f, 
    -0.11443248f, 0.08514816f, 0.18552427f, -0.09546223f, -0.00312998f, -0.26596594f, 0.06864734f, 0.24230626f, 
    -0.17570280f, 0.05217504f, -0.11339922f, -0.00671430f, 0.01815285f, 0.27984282f, -0.08779405f, -0.10781819f, 
    0.00490301f, -0.10252830f, 0.00736114f, 0.16108099f, -0.03253293f, 0.01293243f, 0.02413612f, -0.14219627f, 
    0.01559314f, -0.13709721f, -0.07105713f, 0.15713936f, -0.13746651f, 0.07065570f, 0.00478614f, -0.08342747f, 
    -0.14829786f, 0.17274059f, -0.07735418f, 0.11709408f, 0.00902548f, -0.02024469f, 0.11312938f, 0.12275743f, 
    -0.04527053f, 0.13325031f, 0.02379586f, 0.05321819f, 0.45788702f, 0.03726331f, -0.13824993f, 0.31642053f, 
    0.08498552f, -0.03938673f, -0.00413889f, -0.01772537f, -0.03118518f, 0.07353757f, -0.02811966f, -0.03535604f, 
    0.36869124f, 0.14946066f, 0.14921995f, 0.06752255f, 0.07450351f, -0.01849610f, 0.03669195f, 0.10600946f, 
    0.06118011f, 0.05668057f, 0.05663111f, -0.07136521f, -0.33558604f, -0.10523486f, -0.33414125f, -0.02453778f, 
    0.02927973f, 0.01478401f, 0.02587006f, 0.02409415f, -0.10003170f, -0.14194627f, -0.09580123f, -0.00290111f, 
    0.15712357f, 0.16450305f, -0.19978435f, 0.06836916f, 0.11800840f, -0.00341987f, -0.02021196f, 0.03252613f, 
    -0.12230041f, -0.01037867f, -0.04927789f, 0.14389549f, 0.04694998f, 0.09944811f, 0.05383855f, 0.15764616f, 
    0.04703369f, 0.01057936f, -0.10798459f, 0.13473259f, -0.20833857f, 0.26949725f, 0.08532479f, -0.04347360f, 
    -0.04806130f, 0.10341303f, -0.08101001f, -0.01618863f, -0.00132784f, -0.16170201f, 0.00366460f, 0.11157644f, 
    -0.00655480f, -0.16799967f, -0.11374293f, 0.16502044f, 0.15211931f, 0.00736509f, -0.00129980f, 0.02477426f, 
    0.12526736f, 0.07913533f, -0.02955840f, 0.02941251f, 0.08964810f, 0.02925891f, -0.00249148f, -0.03911458f, 
    0.07167485f, -0.00792570f, 0.07059011f, -0.03878377f, -0.01696774f, 0.02152933f, 0.00246680f, 0.00469778f, 
    0.01383502f, -0.00318724f, 0.16465938f, -0.04551098f, 0.44120082f, 0.16508339f, -0.15597245f, -0.09983791f, 
    0.09717756f, 0.12442651f, -0.14756168f, -0.07582129f, -0.08090468f, -0.15118374f, 0.09449941f, -0.00105005f, 
    0.03639956f, 0.12426867f, -0.00660556f, -0.11497503f, -0.06526837f, 0.16884682f, 0.01795753f, 0.01417037f, 
    0.07308986f, -0.01720642f, -0.00701896f, -0.14018643f, 0.24528770f, 0.32087138f, 0.05379156f, -0.04599401f, 
    0.15907238f, 0.06784988f, -0.08031313f, 0.15957177f, 0.06804370f, 0.03193520f, 0.02017757f, -0.01272244f, 
    0.04041789f, 0.05735982f, 0.07615674f, -0.00198793f, 0.06212068f, -0.00447902f, 0.03991165f, -0.03185115f, 
    -0.09526854f, -0.16136532f, -0.15405269f, -0.03476373f, 0.05133972f, -0.06662251f, -0.20824845f, -0.24494973f, 
    -0.02969906f, -0.02040220f, -0.07050357f, -0.01319855f, 0.00151021f, 0.00422273f, 0.00483389f, 0.11196041f, 
    -0.04343349f, -0.26190859f, -0.23373616f, -0.15434666f, -0.00571452f, -0.19746575f, 0.04512610f, -0.12951228f, 
    -0.02352766f, -0.07547848f, -0.02962979f, 0.10013817f, -0.00800347f, -0.19867916f, 0.18309677f, 0.08845180f, 
    -0.10888232f, 0.01259382f, -0.10884847f, 0.04039469f, 0.07257861f, 0.04543200f, 0.04631301f, -0.03841235f, 
    0.27273357f, -0.04558328f, 0.24618728f, 0.07193046f, 0.21617226f, 0.11511073f, 0.10399827f, -0.01907774f, 
    0.05808397f, 0.02371017f, 0.03120267f, -0.02576708f, -0.06419940f, 0.02418215f, 0.03209159f, -0.00233740f, 
    0.01655394f, 0.02459280f, 0.09527403f, -0.10815633f, 0.11168371f, -0.02319623f, 0.03561448f, 0.01685984f, 
    0.16273198f, 0.14639331f, 0.24090046f, 0.07175346f, 0.04221864f, -0.10984302f, -0.09978639f, 0.19196516f, 
    -0.04516104f, -0.07322594f, 0.04712183f, 0.08925713f, 0.17201844f, -0.22844012f, 0.03727759f, -0.08116870f, 
    0.05857354f, -0.05273695f, -0.04740656f, 0.04882195f, -0.03447342f, -0.02408995f, 0.15350862f, 0.02031880f, 
    0.06664088f, 0.34671345f, 0.10491217f, 0.01562804f, -0.04587254f, 0.19937310f, -0.07106743f, -0.22977377f, 
    -0.00170026f, -0.02182832f, -0.02205080f, 0.01232100f, 0.02874425f, 0.08791466f, -0.20264901f, -0.07115920f, 
    0.06615833f, -0.02080103f, 0.02572121f, 0.05283381f, 0.15481769f, 0.00147416f, 0.01058124f, -0.07093332f, 
    0.08928084f, 0.03538681f, -0.03165537f, 0.13733776f, 0.04447389f, 0.00547950f, 0.02966974f, 0.02249026f, 
    0.09700505f, -0.00210713f, 0.09032233f, -0.12371876f, -0.02036662f, 0.01190140f, 0.19884485f, 0.07574110f, 
    -0.02942951f, -0.03080805f, -0.03652939f, -0.01014157f, -0.03482041f, -0.01748409f, -0.38470256f, 0.09580765f, 
    0.10413361f, -0.00364344f, 0.07928230f, -0.03770478f, -0.11384404f, 0.04080652f, 0.01353222f, -0.03428080f, 
    0.03544879f, -0.02274501f, -0.00378853f, -0.02410221f, -0.00349690f, -0.07237168f, 0.08538380f, -0.16609201f, 
    -0.09864185f, -0.05870034f, -0.08512321f, -0.14507350f, -0.12966606f, -0.07153917f, -0.11901244f, -0.03285774f, 
    -0.08490564f, 0.09429985f, 0.03236554f, 0.04528650f, 0.09863196f, -0.00611161f, 0.06134044f, -0.00766918f, 
    0.14314675f, 0.08564410f, 0.08275938f, 0.04649018f, -0.16220447f, 0.20753716f, -0.13819668f, -0.13848132f, 
    -0.01955341f, 0.07617802f, -0.01532208f, 0.10746349f, -0.01179481f, 0.07759276f, 0.00528204f, -0.11479506f, 
    -0.11880489f, -0.14106323f, -0.13123487f, -0.03401008f, -0.05921263f, -0.04042620f, 0.00803224f, -0.01883481f, 
    0.04658759f, 0.03151463f, -0.00969251f, 0.01795355f, 0.37388062f, -0.08132130f, -0.03796204f, 0.00070300f, 
    0.05993278f, 0.22840731f, 0.08211005f, 0.09504173f, 0.17243764f, -0.17473623f, 0.00791540f, -0.00586019f, 
    0.45723507f, -0.02757606f, 0.08905850f, 0.02516435f, -0.02242700f, -0.00486295f, 0.05581918f, 0.05701219f, 
    0.18262412f, -0.04031515f, -0.08349521f, 0.05366495f, -0.19440809f, 0.14972360f, -0.18100624f, 0.15326160f, 
    0.03815733f, 0.11583615f, 0.30561534f, 0.10906582f, 0.13408963f, 0.02765776f, 0.07127137f, 0.05471732f, 
    -0.27608752f, 0.09447061f, 0.27427575f, -0.08322698f, 0.04744666f, 0.10433394f, -0.03942238f, 0.33179867f, 
    -0.04446975f, -0.02760977f, -0.23135467f, -0.17558500f, 0.22597997f, 0.20076534f, -0.13045938f, -0.23007958f, 
    0.09192162f, 0.01025702f, -0.08541236f, -0.01659367f, 0.03937785f, 0.01784713f, -0.06502642f, 0.12206879f, 
    0.02255498f, 0.06257188f, 0.02125662f, 0.05947624f, 0.05787752f, 0.19218346f, -0.04074261f, -0.16025929f, 
    -0.01305362f, 0.00951574f, -0.02342239f, -0.01763302f, 0.22000250f, -0.11168402f, -0.36993825f, -0.05389206f, 
    -0.06685275f, 0.03340177f, -0.09315654f, -0.00044343f, 0.08965731f, 0.05030922f, 0.06492746f, 0.03245195f, 
    -0.39151859f, -0.12716934f, -0.02219125f, -0.03117035f, -0.06117120f, -0.07075922f, -0.05219834f, -0.03709728f, 
    0.12114553f, 0.16647236f, 0.19560236f, 0.19642830f, 0.12973766f, -0.10184631f, -0.08679845f, 0.00143339f, 
    -0.04869645f, -0.03614425f, -0.00044436f, -0.05308981f, -0.12901728f, -0.01332857f, 0.03920726f, -0.07056129f, 
    -0.05083874f, 0.13984391f, 0.09035304f, -0.03195489f, -0.06579936f, -0.04107767f, -0.06633939f, 0.17957829f, 
    0.04187323f, -0.01158715f, 0.04841251f, 0.08528800f, 0.10052162f, 0.05597759f, 0.10508143f, -0.04583541f, 
    -0.10884567f, -0.04136417f, -0.16113670f, -0.16664924f, -0.13821723f, -0.14022113f, -0.14346744f, -0.12231708f, 
    0.10571957f, 0.18125008f, 0.07453591f, 0.07832459f, 0.03055073f, -0.03801506f, -0.06038122f, -0.06297095f, 
    -0.21345407f, -0.19046615f, -0.13118322f, -0.21091641f, -0.20635660f, 0.10514838f, 0.22449920f, 0.08594894f, 
    -0.05204044f, -0.09368677f, 0.17048624f, 0.13824637f, 0.30092996f, 0.01208262f, 0.07128894f, 0.30237764f, 
    -0.06063313f, 0.00119214f, 0.00324754f, 0.01588264f, -0.00967815f, -0.00340750f, -0.14408354f, -0.10585116f, 
    0.03634977f, 0.01183509f, 0.24438110f, 0.23495479f, -0.14026088f, -0.07488936f, -0.04944237f, -0.20689705f, 
    0.04491579f, 0.17945197f, 0.09878596f, -0.01425173f, -0.06958715f, 0.00164224f, -0.01351747f, 0.05335656f, 
    -0.00220300f, -0.03054990f, -0.01671436f, -0.02415790f, -0.12813410f, -0.11687543f, -0.11219186f, -0.11871707f, 
    0.02005362f, 0.07344418f, 0.10530744f, 0.13023490f, 0.03171517f, 0.11959793f, -0.04277775f, -0.11349321f, 
    0.11245531f, 0.05838725f, 0.14300723f, 0.01573268f, -0.00401513f, -0.02986885f, 0.05468133f, -0.05355094f, 
    0.14319605f, 0.18304291f, 0.08032109f, -0.15090950f, 0.06475609f, -0.02261963f, -0.03849129f, 0.17031018f, 
    0.16987289f, 0.06241804f, -0.02898059f, -0.13636096f, -0.03695998f, -0.26597959f, 0.14454268f, -0.05939458f, 
    0.10982917f, 0.01265342f, -0.08109010f, -0.04254329f, -0.10267793f, 0.00856612f, -0.01505581f, -0.04025516f, 
    -0.24011652f, 0.07217988f, -0.10573310f, -0.14371876f, -0.13042237f, 0.15172634f, 0.07105961f, 0.07035396f, 
    0.08432613f, 0.09334214f, -0.13454019f, 0.02970616f, 0.17112483f, 0.10637274f, -0.06512056f, -0.09203115f, 
    -0.05441304f, -0.12984744f, -0.14880174f, 0.07168532f, -0.10144281f, 0.01990992f, -0.04067506f, -0.13784818f, 
    0.08169297f, 0.12218886f, 0.13715820f, 0.03384537f, -0.05085292f, -0.06742066f, -0.04500169f, -0.24399000f, 
    0.03875178f, 0.00625171f, 0.00863384f, 0.00263965f, -0.00091851f, -0.17221160f, -0.01579979f, -0.05035748f, 
    0.13827191f, 0.03377623f, -0.02529408f, 0.00415609f, 0.11434985f, 0.02747032f, 0.00057680f, 0.04052646f, 
    -0.03292820f, -0.08991715f, 0.06976853f, -0.16227645f, -0.09266690f, -0.01027670f, 0.13190767f, 0.00692017f, 
    0.03215996f, 0.12870519f, -0.04231733f, 0.12596257f, -0.50643516f, -0.23856057f, -0.24515823f, -0.35489786f, 
    -0.07051601f, 0.01404869f, -0.05327016f, -0.01457480f, 0.07542688f, 0.11270511f, 0.12008327f, -0.06142445f, 
    0.26236856f, 0.10376446f, 0.16211975f, 0.10962015f, -0.05913101f, -0.02967027f, -0.06220219f, -0.10709745f, 
    -0.11703633f, -0.00257781f, -0.01696103f, -0.03000720f, -0.03326274f, 0.05409048f, 0.11025633f, 0.15480457f, 
    0.12960781f, -0.08155450f, -0.05013459f, -0.02459394f, 0.19971138f, -0.03895101f, 0.04289586f, -0.01835806f, 
    -0.06434578f, -0.00518070f, -0.12721120f, -0.07239094f, -0.08075972f, 0.00719622f, -0.01682402f, -0.11448415f, 
    0.04761021f, 0.02626061f, -0.05311759f, -0.01576114f, -0.01063755f, 0.02607672f, -0.00204654f, 0.16678858f, 
    0.03639069f, 0.13132261f, 0.06448893f, 0.07073075f, 0.18230054f, 0.05853479f, 0.06605851f, 0.07605520f, 
    0.01305301f, -0.01646457f, 0.02156650f, 0.03699147f, 0.06158743f, -0.05143325f, 0.14733447f, 0.14713567f, 
    0.04342497f, -0.05763483f, -0.06472728f, -0.01627238f, 0.30328643f, 0.08848052f, 0.27116278f, 0.16536893f, 
    -0.02207759f, -0.00223605f, 0.00208808f, 0.14177431f, 0.07863079f, -0.05943568f, -0.01122640f, 0.31279701f, 
    -0.07008250f, 0.04477165f, -0.02104698f, -0.14823969f, 0.07603572f, 0.02540829f, 0.03197338f, -0.03659770f, 
    -0.04977221f, -0.16928144f, -0.16638848f, -0.16778126f, -0.05720024f, -0.08268172f, 0.02229381f, -0.23798449f, 
    0.08163988f, -0.06115173f, -0.21568196f, 0.16772568f, -0.04267095f, 0.19626489f, -0.03279946f, 0.06328601f, 
    -0.10879494f, -0.12694770f, -0.13168585f, -0.52249229f, -0.05321253f, -0.07704408f, -0.06914441f, -0.07199553f, 
    -0.12129643f, 0.13393736f, 0.09952376f, -0.04820345f, 0.24605960f, -0.07728849f, -0.11697313f, -0.01022375f, 
    -0.15484731f, -0.08305699f, -0.07088658f, -0.06033911f, -0.11580205f, -0.16721365f, -0.06905147f, -0.10154699f, 
    0.16496821f, -0.15612540f, -0.01901870f, 0.05917686f, 0.05468524f, -0.05262469f, 0.01285307f, -0.02802216f, 
    0.16503461f, 0.02570289f, 0.20464027f, 0.15377693f, -0.14414333f, -0.08599269f, 0.16817045f, 0.19668625f, 
    -0.01616364f, -0.00313572f, 0.05033110f, -0.01546012f, -0.13320749f, -0.02602925f, 0.11618119f, -0.06605744f, 
    -0.03421439f, 0.17396098f, 0.18429880f, 0.07263874f, -0.10008860f, 0.00374320f, 0.14409697f, 0.09030883f, 
    0.01950979f, 0.02448255f, -0.03740369f, -0.02800017f, 0.49773917f, 0.17810275f, 0.15254945f, -0.35469463f, 
    0.01338006f, -0.03170383f, -0.06419059f, -0.11573807f, 0.00273332f, -0.15141341f, 0.05035178f, -0.00299662f, 
    0.19690001f, 0.14703935f, 0.15128574f, 0.23749584f, 0.02864240f, 0.04873212f, 0.01023901f, -0.00854621f, 
    -0.08406441f, -0.07827313f, -0.11825457f, -0.03805502f, 0.05461597f, -0.08288237f, -0.11489841f, -0.18465409f, 
    0.01145170f, -0.08616465f, 0.01546533f, 0.08447979f, 0.22182557f, -0.01294964f, 0.00147593f, 0.12982067f, 
    -0.16828677f, -0.19840918f, -0.14534841f, 0.03733861f, 0.04582940f, 0.07128555f, -0.16274980f, -0.34153226f, 
    0.10444713f, 0.05124800f, -0.10927340f, -0.16253188f, -0.15938672f, -0.29623219f, -0.27772155f, -0.06433816f, 
    0.01385963f, 0.06856430f, 0.07515985f, 0.00719186f, 0.07421482f, 0.00505114f, 0.16679446f, -0.09698300f, 
    -0.16656424f, -0.19517012f, -0.11964948f, -0.01208864f, -0.03691635f, 0.05089682f, 0.02357730f, -0.06693439f, 
    0.22433162f, 0.17232913f, 0.10048109f, 0.16317962f, -0.04876991f, 0.06559678f, -0.12669712f, 0.25410980f, 
    0.33435130f, 0.14197686f, 0.14013658f, -0.01716178f, -0.00680094f, 0.04269379f, 0.00877667f, -0.13668899f, 
    -0.04465744f, -0.21506000f, -0.22993809f, 0.15872884f, 0.13449669f, -0.02445922f, 0.02340762f, 0.13603330f, 
    -0.06825463f, 0.04250732f, -0.31140205f, 0.03287088f, 0.14661072f, 0.03846847f, 0.05823277f, -0.02111768f, 
    0.02677519f, 0.05602732f, 0.08306389f, 0.07234254f, -0.05923073f, -0.07116093f, 0.00436967f, -0.05826905f, 
    -0.18916415f, -0.19219616f, -0.12713510f, 0.02267972f, 0.01354821f, 0.00904607f, -0.04155286f, -0.01900713f, 
    -0.01294767f, 0.04728385f, 0.01457998f, -0.12141774f, 0.27348664f, 0.35767668f, 0.37432915f, 0.25322843f, 
    0.09458546f, 0.04005229f, -0.08367943f, 0.09029880f, 0.00300416f, -0.01271095f, 0.04794553f, 0.10210527f, 
    0.21433648f, 0.08040154f, 0.38748419f, 0.18786427f, -0.04646336f, 0.10723706f, 0.00690123f, -0.21289374f, 
    -0.11039083f, 0.00443881f, 0.07958307f, 0.14473258f, 0.08210389f, 0.10176755f, -0.27223849f, 0.06795194f, 
    -0.03037584f, -0.14480375f, 0.00703093f, -0.00438620f, 0.03433857f, 0.00591383f, 0.01123750f, 0.00124260f, 
    0.17313091f, 0.01381840f, 0.23447593f, 0.26421264f, 0.03758914f, -0.03560977f, 0.02714100f, 0.08805725f, 
    0.06737452f, 0.04551092f, 0.13132969f, 0.05854023f, -0.15675236f, -0.19410951f, 0.21701021f, 0.14316267f, 
    -0.03466605f, 0.10707496f, -0.21592669f, -0.06768817f, 0.04765033f, -0.04259604f, -0.01272228f, 0.03737310f, 
    -0.02433106f, 0.02971550f, 0.07567014f, 0.00392879f, 0.02046605f, 0.03865067f, 0.07346939f, 0.18439879f, 
    0.07277018f, 0.04493336f, 0.00233386f, 0.08266000f, 0.15670581f, 0.37048540f, 0.00143955f, 0.00892195f, 
    -0.03974538f, 0.05986096f, 0.02917254f, -0.06633565f, 0.02277012f, 0.12684888f, 0.05067076f, -0.01250655f, 
    0.11416069f, 0.04030742f, 0.03655146f, 0.19004953f, 0.13087502f, 0.10557530f, 0.04587537f, 0.16193222f, 
    -0.15298302f, -0.13145903f, -0.04413291f, -0.17879614f, 0.31437343f, 0.21207513f, 0.12576620f, 0.26231954f, 
    -0.00087070f, 0.03184618f, 0.00602496f, -0.13025300f, 0.00340719f, -0.11404824f, 0.10932738f, 0.08183956f, 
    -0.06994459f, -0.28217241f, -0.21647142f, -0.12867817f, -0.03570253f, 0.02128507f, 0.02582111f, -0.03462575f, 
    -0.03499736f, -0.02566722f, -0.07503220f, -0.12139308f, -0.13249564f, -0.08506981f, 0.04676797f, 0.10853867f, 
    0.08502266f, 0.12138440f, 0.10940477f, 0.02712939f, -0.02391926f, -0.03945385f, 0.19318356f, 0.09668325f, 
    0.04380956f, 0.06983302f, -0.07175578f, -0.07293100f, 0.03858358f, -0.06857585f, 0.04508558f, -0.05662456f, 
    -0.06238935f, -0.13657036f, -0.05889805f, -0.11894815f, -0.25109968f, 0.05115404f, -0.11242409f, -0.15191413f, 
    0.06539730f, 0.06648966f, -0.19648422f, -0.08163717f, -0.13018064f, 0.05924332f, -0.17573267f, -0.13191277f, 
    -0.08650383f, 0.09829246f, -0.10271671f, 0.12345687f, -0.09290715f, 0.01174599f, -0.05675836f, -0.19994238f, 
    0.02666411f, 0.10646231f, 0.06377549f, 0.07643867f, -0.22866824f, 0.13817957f, -0.04701070f, 0.25258258f, 
    -0.00598007f, 0.03385176f, 0.13974567f, -0.02563083f, -0.06649620f, 0.17338897f, -0.03146825f, -0.05899103f, 
    -0.16207631f, 0.05783741f, -0.17494610f, 0.05008311f, 0.17012303f, 0.05064665f, -0.03680073f, -0.15000045f, 
    -0.12815261f, -0.01501130f, -0.00994188f, 0.02998721f, 0.08529896f, -0.06917681f, 0.17054912f, 0.22302340f, 
    -0.00040167f, -0.05764848f, 0.00916385f, -0.02319334f, 0.01711545f, 0.03142070f, 0.08638842f, -0.10100799f, 
    0.16510411f, -0.11286784f, 0.13332120f, 0.41010743f, -0.03141141f, 0.05369035f, -0.09266648f, 0.03592147f, 
    -0.09203069f, -0.08203694f, -0.03976247f, 0.13133177f, -0.37443200f, 0.61085796f, -0.27588248f, 0.51851487f, 
    0.08246495f, 0.20104627f, 0.15430339f, 0.16854274f, 0.08721689f, -0.03431299f, -0.00698726f, 0.03327755f, 
    0.47012475f, -0.30014676f, 0.16644421f, -0.01844184f, 0.05220818f, -0.03332253f, 0.15248506f, 0.17641488f, 
    -0.02162639f, 0.13661820f, 0.03628737f, -0.03203654f, 0.22956948f, -0.22515085f, 0.09490941f, 0.03424100f, 
    0.02581257f, 0.05378712f, -0.05926306f, 0.03801088f, 0.02660365f, -0.02526954f, -0.05298501f, 0.03813505f, 
    -0.00292025f, -0.11497623f, -0.11885588f, 0.13720618f, -0.08994158f, 0.08725235f, -0.04627622f, -0.21194752f, 
    -0.00824030f, -0.03982317f, 0.00273708f, -0.00016063f, -0.49629930f, 0.25589335f, -0.35558707f, 0.27624127f, 
    -0.06423125f, 0.03040656f, 0.01831469f, 0.06354290f, 0.02953447f, -0.06668144f, 0.09103588f, 0.17731696f, 
    -0.14866060f, -0.09858464f, -0.01071822f, -0.11625597f, -0.07329136f, 0.04962011f, -0.00043823f, 0.18346079f, 
    0.19338365f, -0.01860749f, 0.14831984f, 0.10790123f, -0.02392427f, -0.04664455f, -0.05323694f, 0.13547666f, 
    -0.04275919f, 0.00225272f, -0.09537060f, 0.07614190f, -0.04575378f, 0.06484306f, -0.07804577f, -0.06371954f, 
    0.06705802f, 0.24691641f, -0.25387678f, 0.10646795f, 0.05986685f, 0.03069816f, 0.15259279f, 0.07983320f, 
    -0.04530251f, -0.00667048f, -0.03938719f, 0.06277654f, -0.06407660f, -0.09010028f, 0.03356422f, -0.18285058f, 
    -0.10050478f, -0.01909846f, -0.04691300f, 0.01620421f, -0.08492485f, 0.02543992f, -0.07749519f, -0.05705207f, 
    0.01381675f, 0.05822345f, -0.09626521f, -0.04176060f, -0.08815458f, -0.09414140f, -0.08580387f, -0.03210207f, 
    -0.01470944f, 0.03375036f, -0.07585990f, -0.07408703f, -0.23322076f, 0.28474927f, 0.03056548f, 0.02276602f, 
    -0.01713782f, -0.07431860f, 0.02921734f, -0.03166532f, -0.13289014f, -0.00106904f, 0.04759530f, 0.10106327f, 
    0.01552949f, -0.00069957f, 0.07019831f, -0.08257232f, -0.20300916f, -0.01608737f, 0.02142592f, -0.12588340f, 
    0.10889686f, 0.14812875f, 0.21592830f, 0.07612702f, -0.03957397f, -0.15767087f, 0.16964927f, 0.06689944f, 
    -0.03506850f, 0.08834305f, -0.07170156f, 0.09908045f, -0.09943305f, -0.11447041f, -0.00760719f, -0.01104420f, 
    -0.07559573f, -0.00235625f, -0.08847737f, -0.00416009f, 0.03904250f, -0.03217169f, 0.06074232f, 0.00618122f, 
    0.16285805f, 0.07470154f, 0.07115473f, 0.15873773f, -0.12689552f, -0.38141170f, -0.06849860f, 0.14710507f, 
    -0.00954972f, 0.00495793f, -0.10370869f, -0.12503694f, 0.02241906f, 0.03387232f, 0.13578568f, 0.03994955f, 
    -0.18561329f, 0.24799237f, -0.15142919f, 0.08544785f, -0.01059553f, 0.08915067f, -0.04494865f, 0.32364058f, 
    0.09711792f, 0.02925529f, 0.05268568f, 0.04726077f, 0.13651495f, 0.09722812f, 0.18168762f, 0.09390659f, 
    0.11602760f, 0.07588308f, 0.04681451f, -0.04343556f, -0.07179777f, 0.01687524f, 0.05704888f, 0.01762177f, 
    -0.20897126f, -0.05204886f, -0.13952860f, 0.14590150f, 0.02658733f, 0.03759556f, 0.04141697f, -0.00959158f, 
    0.05460649f, 0.09925083f, -0.10083147f, -0.03730255f, 0.15530889f, 0.11961027f, -0.08289444f, -0.13281660f, 
    -0.03221804f, -0.00517616f, 0.18647744f, 0.04805388f, -0.14843915f, 0.05456756f, 0.09321097f, -0.15538450f, 
    -0.10130595f, -0.20264253f, -0.12897302f, 0.07727583f, -0.10033083f, 0.00653415f, -0.02255940f, -0.23354419f, 
    0.03308692f, 0.10097837f, -0.00441190f, 0.06070319f, 0.14623542f, -0.13302301f, 0.04581254f, 0.08302327f, 
    0.16927646f, 0.02773295f, 0.05605248f, 0.17158814f, -0.02224448f, -0.01570217f, -0.04099446f, -0.13220695f, 
    -0.06155032f, -0.04197450f, -0.06427766f, 0.00501049f, 0.01616650f, -0.07999009f, 0.11775193f, 0.01731210f, 
    -0.03261396f, 0.05192120f, -0.06218803f, 0.03189522f, -0.37557060f, -0.03794855f, 0.02045732f, 0.01084773f, 
    0.03760760f, -0.07790782f, 0.08913269f, -0.02987824f, -0.04494987f, 0.03925971f, 0.06739274f, -0.09145860f, 
    -0.00474442f, 0.06795672f, 0.13073133f, 0.07144240f, -0.12458788f, 0.04094228f, -0.12096210f, -0.00276838f, 
    -0.05074000f, 0.01441101f, -0.01435118f, 0.05250208f, -0.23623793f, 0.16211085f, 0.03526161f, 0.10978825f, 
    0.11922347f, 0.02379975f, -0.00112380f, 0.00860335f, 0.03142410f, -0.06474214f, -0.00241401f, 0.05524054f, 
    -0.03890199f, 0.11807487f, -0.01910355f, 0.05289929f, -0.09978992f, 0.11460184f, -0.00513146f, 0.10359455f, 
    0.05657942f, -0.03290281f, 0.01296583f, 0.04505720f, 0.08327074f, 0.20421590f, -0.15979254f, 0.19042660f, 
    0.08635087f, 0.05214752f, 0.15285923f, 0.09840300f, 0.04606452f, -0.03841353f, 0.06708185f, 0.03576228f, 
    0.01406125f, 0.03637791f, -0.03485945f, 0.02696946f, 0.02708385f, 0.03310866f, -0.03289785f, -0.03727359f, 
    -0.04366080f, 0.01581503f, 0.04385266f, -0.02017922f, -0.03324480f, 0.00795717f, -0.03635071f, -0.03875632f, 
    -0.03577749f, -0.02797251f, -0.04847568f, 0.04173778f, 0.03431961f, -0.03037428f, -0.03331900f, -0.04468513f, 
    -0.02070815f, -0.00127334f, 0.01542403f, -0.00206816f, 0.00655857f, -0.04820891f, -0.02067514f, 0.00359722f, 
    0.03256164f, -0.03017831f, -0.05130558f, 0.01819339f, -0.00917180f, 0.02006579f, -0.06056345f, -0.03705228f, 
    0.02376819f, 0.02588717f, -0.03917661f, -0.03241837f, -0.05543690f, -0.05709761f, 0.00702462f, -0.01684664f, 
    0.00558102f, -0.05660394f, -0.02379314f, 0.02943719f, -0.05702825f, 0.03787359f, 0.02374030f, -0.04537055f, 
    -0.00263637f, 0.02643665f, -0.05980583f, 0.01369522f, -0.00491388f, -0.03674171f, 0.00452605f, 0.03094841f, 
    0.03854917f, -0.05394689f, 0.02704099f, -0.03597108f, 0.02929548f, -0.00723935f, -0.00350307f, 0.02424553f, 
    -0.05583875f, 0.00085177f, -0.01990779f, -0.02325945f, -0.03665209f, -0.03853950f, -0.01021372f, 0.01513574f, 
    0.01278652f, -0.01439083f, 0.02730527f, -0.01701552f, -0.05670986f, -0.05475508f, 0.02011975f, 0.00632599f, 
    -0.04348404f, 0.01567801f, 0.01543179f, 0.02736565f, -0.03562888f, -0.05590703f, 0.04470593f, -0.05141610f, 
    -0.05293359f, 0.01767897f, 0.04103634f, -0.01035379f, -0.02929054f, -0.02383908f, -0.04524352f, -0.05149337f, 
    -0.03200448f, -0.02526113f, -0.05389945f, -0.00067798f, -0.05607901f, -0.04074941f, -0.05320926f, 0.00779030f, 
    -0.05152314f, -0.03561343f, -0.02430540f, 0.02394869f, -0.01784509f, -0.04327079f, -0.03181411f, 0.04039739f, 
    0.01020551f, 0.01108315f, -0.03719187f, -0.05679060f, -0.05572928f, -0.03583210f, -0.02010235f, -0.01630608f, 
    -0.05127472f, -0.01823288f, 0.03965792f, -0.01684196f, -0.01528742f, -0.00323232f, -0.01961398f, 0.02844766f, 
    0.03258250f, 0.01360607f, -0.02167141f, -0.01907604f, -0.03090798f, 0.00783329f, 0.01332313f, -0.00838013f, 
    -0.05184991f, 0.02048647f, -0.02548267f, -0.03709630f, 0.00907545f, 0.03190222f, -0.00875809f, -0.01937880f, 
    -0.02055643f, 0.02299700f, 0.03043733f, -0.01933557f, 0.00664598f, 0.02271532f, 0.02531816f, -0.04287390f, 
    -0.01778270f, 0.03100024f, -0.05394796f, -0.01000620f, 0.03296940f, -0.03215490f, 0.03310288f, 0.00686054f, 
    -0.03762724f, 0.02624921f, -0.00318175f, -0.04019343f, -0.03057034f, -0.00138349f, 0.00986926f, 0.01478874f, 
    -0.05044068f, -0.00145413f, -0.00854973f, -0.03538385f, 0.00597643f, 0.00777139f, -0.00284706f, 0.01483741f, 
    -0.02198801f, -0.02699075f, -0.01100730f, -0.05018329f, -0.01757226f, 0.03440411f, -0.01329235f, 0.01106817f, 
    -0.05297422f, -0.05984655f, -0.04722589f, 0.01248604f, -0.01020664f, 0.03920004f, 0.01300723f, 0.02382033f, 
    -0.04248304f, -0.05587303f, 0.01571880f, -0.04557477f, -0.00766848f, 0.01269584f, 0.01304277f, -0.02050743f, 
    0.03270038f, 0.03380986f, 0.02258277f, -0.02496761f, -0.01390254f, -0.00127750f, 0.00659240f, 0.02590199f, 
    0.01941716f, -0.01253556f, -0.00367986f, -0.01435788f, 0.01327522f, 0.00472758f, -0.00049533f, 0.02110609f, 
    -0.04080389f, 0.03760406f, 0.03658530f, -0.02364938f, -0.00585930f, 0.03551546f, -0.03828905f, -0.04491494f, 
    -0.05780795f, 0.03109234f, -0.01036671f, -0.04353265f, 0.04283071f, -0.03344239f, 0.02442734f, 0.03087344f, 
    -0.05409836f, 0.00647832f, -0.04976016f, -0.05927550f, -0.01736556f, -0.02594958f, -0.01200472f, 0.02451614f, 
    0.02764670f, -0.04807545f, 0.01469258f, -0.03226752f, 0.03435471f, -0.02427319f, 0.00886361f, -0.03937244f, 
    -0.05103842f, -0.04303698f, -0.05483340f, 0.03814625f, -0.05837071f, -0.02072686f, -0.01830089f, -0.00940945f, 
    -0.05595940f, -0.00648586f, 0.03930603f, -0.00491830f, 0.03120819f, -0.04227261f, -0.04303844f, 0.02468912f, 
    0.02377841f, 0.03756619f, 0.03235736f, -0.03900381f, -0.02591955f, 0.02014445f, -0.02535903f, -0.04265643f, 
    -0.04748480f, -0.00716977f, 0.02360031f, 0.03218086f, 0.01684124f, -0.00332409f, 0.03124234f, 0.00114330f, 
    -0.04184350f, -0.01737019f, 0.00911990f, 0.00463220f, -0.00196151f, 0.01889452f, 0.02750990f, -0.01911315f, 
    -0.05528324f, 0.00292812f, 0.03318998f, 0.02237953f, 0.02280321f, 0.03785703f, 0.00619300f, 0.02666486f, 
    -0.05804481f, 0.01094255f, -0.05236148f, 0.02516788f, -0.00743590f, -0.04777686f, -0.00141565f, -0.04766480f, 
    0.01002236f, -0.05677160f, 0.03750289f, -0.03896994f, -0.05712352f, -0.05203787f, 0.04253392f, -0.02254735f, 
    -0.02172671f, -0.02340269f, -0.02185592f, -0.03439989f, -0.04212996f, -0.03335833f, -0.04256172f, 0.04051841f, 
    -0.04250436f, 0.02985032f, -0.02930581f, -0.05793989f, 0.01007830f, -0.00730483f, -0.04049388f, -0.04059375f, 
    -0.02110187f, -0.00730268f, -0.01406270f, -0.05667019f, -0.04993826f, -0.05066620f, -0.00452160f, -0.04463773f, 
    0.02146181f, -0.01866080f, -0.03438327f, 0.03728706f, -0.05268094f, 0.01577077f, -0.04967235f, -0.03205166f, 
    -0.03018375f, 0.01853131f, 0.02090653f, -0.01725005f, -0.01977778f, -0.03183151f, -0.00253703f, -0.03701929f, 
    0.00480784f, -0.05645148f, 0.02169054f, -0.01743901f, -0.03335649f, -0.05064105f, 0.03918565f, 0.03455638f, 
    -0.03703360f, 0.01002099f, -0.05523285f, -0.02896473f, 0.02927613f, 0.03450712f, -0.03075427f, -0.03462462f, 
    -0.00110861f, 0.02707773f, -0.04616433f, -0.02895913f, 0.03631967f, -0.00156471f, -0.01314649f, -0.05586911f, 
    -0.18322019f, 0.05178240f, 0.08060782f, 0.23647077f, 0.01389510f, 0.22248559f, 0.08237098f, -0.01892147f, 
    -0.03698416f, -0.01978898f, -0.05083627f, -0.01021084f, -0.07424974f, -0.22102472f, 0.14070025f, -0.14758545f, 
    0.02023317f, -0.00726820f, -0.09009688f, -0.01274339f, -0.02551510f, -0.13632685f, -0.01827804f, 0.09961122f, 
    0.06619103f, -0.03567829f, 0.01691300f, 0.04354152f, -0.00408878f, -0.01708549f, -0.00889650f, -0.02212214f, 
    0.02541639f, -0.00383811f, 0.02179782f, -0.03727066f, 0.42936909f, 0.14663766f, -0.20882364f, 0.17603736f, 
    0.04539379f, 0.10859262f, 0.12074106f, -0.05505709f, 0.09384596f, -0.08595490f, -0.01521112f, 0.07500315f, 
    0.34977311f, 0.05024848f, -0.15040359f, 0.13880497f, 0.01872153f, -0.02373865f, -0.00981943f, -0.09192677f, 
    0.11046872f, 0.01442955f, -0.01579747f, -0.06182623f, 0.03498099f, 0.05053319f, 0.10505220f, -0.16094494f, 
    0.20782138f, 0.02480559f, -0.06558128f, -0.05763335f, -0.01079396f, -0.03717073f, -0.02474271f, -0.00040730f, 
    0.14478841f, -0.00662849f, -0.13595986f, 0.12007274f, -0.08982800f, -0.02196008f, -0.13492236f, -0.16973279f, 
    0.05002098f, 0.00490034f, 0.00972117f, -0.08531851f, 0.12813370f, 0.09132716f, -0.21977492f, 0.11164605f, 
    -0.02036905f, -0.00368038f, -0.00065071f, -0.09479740f, -0.00151800f, 0.00547546f, -0.09995817f, 0.08116473f, 
    -0.03714332f, 0.05493945f, 0.19988839f, 0.25674421f, 0.02099585f, 0.06327751f, 0.15374024f, 0.09017813f, 
    -0.07445900f, 0.00174577f, -0.01629553f, 0.01197229f, 0.55578983f, -0.02783236f, -0.07230191f, -0.12421183f, 
    -0.01302436f, -0.06449983f, -0.00064683f, 0.06048942f, 0.18654001f, -0.02729622f, -0.00021238f, 0.04077520f, 
    0.16329867f, 0.26348501f, 0.01166674f, 0.05919375f, 0.02182548f, -0.14942905f, -0.07709686f, -0.02166282f, 
    -0.04165495f, 0.00950397f, 0.02394529f, 0.01474773f, 0.16003625f, -0.08907176f, 0.06214079f, 0.10828535f, 
    0.03574804f, -0.07657129f, -0.01305179f, -0.06610461f, 0.01681771f, 0.03080432f, 0.08879524f, -0.01160056f, 
    -0.16725571f, 0.00784019f, 0.04409918f, 0.01988073f, -0.01779357f, -0.05648189f, -0.08315101f, 0.04609725f, 
    0.07299002f, -0.06067182f, -0.04508255f, 0.06454211f, 0.05273559f, 0.07509474f, 0.07292715f, 0.11481114f, 
    0.01087219f, 0.02612443f, 0.02067251f, -0.11842436f, 0.10637834f, 0.04290147f, 0.01751612f, 0.01346695f, 
    -0.02639562f, 0.02788769f, 0.02328660f, -0.00243218f, -0.02710469f, -0.02117213f, -0.00771417f, -0.04721926f, 
    0.08106044f, -0.00404234f, 0.17068388f, 0.16386548f, -0.04960483f, -0.05459243f, 0.19220950f, 0.04116377f, 
    0.12303086f, 0.07559108f, 0.11520778f, -0.05130944f, 0.04753398f, -0.03056062f, 0.05075580f, 0.18083662f, 
    0.00971035f, -0.00535535f, 0.06014941f, 0.01322322f, 0.11563215f, -0.01366143f, -0.11516815f, -0.12554838f, 
    0.04717084f, -0.02167118f, -0.04046280f, 0.08360769f, 0.23202056f, 0.25776255f, 0.04730829f, 0.04154734f, 
    0.15648462f, 0.11600229f, 0.17854576f, 0.07379492f, 0.09709217f, 0.00359672f, 0.06258613f, 0.01730355f, 
    0.06514683f, -0.01987963f, 0.08891931f, 0.02682052f, 0.03199628f, -0.03810207f, -0.09649639f, -0.06808630f, 
    0.02367741f, 0.01900688f, -0.00430491f, 0.04511233f, 0.04410218f, -0.17639950f, -0.02267114f, 0.07761671f, 
    0.00603198f, 0.01380987f, -0.00712225f, -0.00444735f, -0.01580628f, -0.01420069f, -0.11073865f, 0.02216020f, 
    0.29607648f, 0.29967424f, -0.16787112f, -0.03736241f, -0.02496946f, -0.12698084f, 0.03037441f, 0.15034285f, 
    0.12588303f, 0.07766931f, -0.03920863f, 0.08825054f, -0.16665494f, -0.30884293f, -0.11178398f, 0.14031114f, 
    -0.01893757f, 0.05135268f, -0.10679663f, 0.00869808f, -0.06930149f, -0.02428117f, -0.04837248f, 0.02045216f, 
    -0.16659166f, 0.12219177f, 0.04591558f, 0.12552901f, 0.12996911f, 0.10438149f, 0.09944107f, 0.11151230f, 
    0.15825400f, -0.02274961f, 0.00377510f, -0.00564372f, -0.18396822f, -0.03855690f, -0.12910832f, 0.03443924f, 
    -0.04669927f, -0.08812018f, 0.00512413f, -0.05691264f, 0.11840313f, 0.01822869f, -0.02846725f, -0.02596519f, 
    -0.05253409f, 0.09615380f, 0.16427964f, 0.33153418f, 0.14725007f, 0.09434905f, -0.09284455f, 0.03305801f, 
    -0.05923570f, 0.01919952f, 0.00061517f, 0.05681181f, -0.25682431f, -0.14320318f, 0.04538574f, -0.05873926f, 
    -0.16639666f, -0.06115335f, -0.12895617f, 0.06280628f, 0.03617369f, -0.08606867f, -0.14281030f, 0.03532656f, 
    0.09743199f, 0.15644987f, 0.12287653f, 0.15223752f, -0.00093734f, 0.02070825f, 0.16868627f, -0.00236607f, 
    0.05482602f, -0.03645666f, 0.03320967f, -0.03174486f, 0.23555483f, 0.08277386f, 0.03959192f, -0.15831009f, 
    0.00272933f, -0.13641566f, -0.10356203f, -0.05699553f, -0.10712319f, 0.15143345f, 0.15894659f, 0.00176050f, 
    0.08861564f, 0.06072385f, 0.04065465f, 0.05604751f, 0.02504486f, -0.06704812f, 0.00420551f, -0.06464969f, 
    0.05554215f, 0.02727923f, -0.01908115f, 0.09656091f, -0.34478262f, 0.23950358f, 0.21922278f, -0.00028698f, 
    -0.17112921f, 0.00913623f, -0.18433827f, -0.09726579f, -0.00346874f, 0.00302937f, -0.15610634f, -0.01728315f, 
    -0.07813529f, -0.10373122f, -0.00488273f, 0.01783877f, 0.06371239f, 0.03363292f, -0.04971291f, -0.05541497f, 
    -0.07445617f, -0.06489720f, -0.05678917f, 0.01634448f, -0.19451506f, -0.08680839f, 0.03131535f, -0.07491414f, 
    -0.07413503f, 0.04050393f, 0.05905590f, 0.12414821f, -0.06703071f, -0.04457407f, -0.10709064f, 0.05034521f, 
    -0.15481167f, -0.20831561f, -0.17223574f, 0.00505529f, 0.01629732f, -0.06304565f, -0.08246317f, -0.14567477f, 
    0.01008140f, 0.03604156f, 0.02394583f, 0.04753203f, -0.09719741f, 0.02192632f, 0.07335024f, 0.20786522f, 
    -0.06339311f, 0.12706570f, 0.16051942f, 0.01555728f, -0.07555297f, 0.08260417f, 0.00691227f, 0.03366695f, 
    -0.07409450f, -0.07177109f, -0.06195565f, -0.00153663f, 0.03294296f, -0.06383828f, -0.03456810f, 0.02569089f, 
    -0.09187661f, -0.16883785f, -0.15828237f, -0.08832723f, 0.42205179f, -0.03102975f, 0.19707124f, -0.33869728f, 
    0.18355982f, -0.00532694f, -0.09518242f, 0.02956974f, 0.18863197f, 0.13749437f, 0.15847526f, -0.03602642f, 
    0.38933817f, 0.10513921f, 0.16181603f, 0.11945464f, -0.03996974f, 0.04794198f, -0.00901638f, 0.13802831f, 
    0.06160577f, -0.04858339f, 0.02238444f, -0.00310801f, -0.07237325f, -0.01794102f, 0.01987223f, 0.31907505f, 
    0.03005509f, 0.09698239f, 0.11023908f, -0.02952402f, -0.01293207f, 0.05327475f, 0.07332099f, 0.02552644f, 
    0.02526114f, -0.06680950f, 0.06329508f, -0.08733829f, -0.07583944f, 0.13112387f, 0.00146051f, 0.07296307f, 
    0.04350148f, 0.08494429f, 0.01344798f, 0.04867251f, 0.00052494f, -0.01450578f, 0.34183314f, -0.38656142f, 
    0.01148626f, -0.14586566f, -0.10169017f, -0.05018007f, 0.02228347f, -0.06909937f, 0.04265209f, -0.06219318f, 
    -0.31649625f, -0.13962157f, -0.24752404f, -0.15222113f, -0.04652882f, 0.01801906f, -0.03006490f, -0.20471068f, 
    -0.02876357f, -0.10772975f, -0.02291442f, -0.10568635f, -0.18360262f, 0.13144310f, -0.00917256f, 0.16950864f, 
    -0.10418139f, 0.00959517f, 0.02649779f, 0.09658775f, 0.02421733f, 0.01051719f, 0.07015064f, 0.00214259f, 
    -0.10522006f, 0.00660111f, 0.12433977f, -0.13221100f, -0.19936068f, -0.07775116f, 0.06673045f, 0.04253710f, 
    0.05721857f, 0.10772742f, -0.06104584f, 0.02411017f, 0.12038352f, -0.04834989f, -0.07772172f, -0.01123976f, 
    0.08774707f, 0.00092744f, 0.05964540f, -0.27294436f, 0.13033395f, 0.04298078f, 0.02479103f, 0.07113466f, 
    0.29830912f, -0.17808892f, 0.11794049f, 0.16156080f, 0.05077047f, -0.06698709f, 0.08005850f, 0.22042048f, 
    0.01252896f, 0.05593271f, 0.05253521f, -0.05006051f, 0.02140496f, 0.11144421f, 0.00747172f, -0.06220661f, 
    -0.08470228f, -0.06273803f, -0.05799716f, -0.04573070f, 0.04171679f, 0.09791584f, 0.04726589f, 0.05706460f, 
    0.11364186f, 0.12664390f, -0.09882806f, -0.02138565f, -0.00771716f, -0.15090959f, -0.00974912f, -0.04793486f, 
    0.17900874f, 0.11416433f, 0.08587002f, 0.12488647f, 0.09737476f, -0.11678328f, 0.28071931f, -0.01564513f, 
    0.04642123f, -0.12441162f, 0.02469320f, 0.10098898f, 0.08818515f, 0.17707901f, -0.01147470f, 0.00856865f, 
    0.09856884f, 0.10016682f, -0.03668278f, 0.02175191f, 0.12901084f, -0.01397842f, 0.06437153f, -0.12204655f, 
    -0.02766296f, -0.05312340f, -0.01569122f, 0.06115098f, -0.12002074f, -0.13586660f, -0.15413092f, -0.22051926f, 
    0.04986477f, -0.07128511f, 0.03283664f, -0.17970710f, -0.07101975f, -0.11164351f, -0.16159849f, -0.07067166f, 
    -0.00680331f, 0.06422751f, -0.00501521f, -0.08128717f, -0.00808001f, 0.01151218f, -0.02157746f, -0.04004095f, 
    -0.00060373f, -0.03555397f, -0.10207602f, 0.02128955f, -0.51743197f, 0.13863809f, 0.23994298f, 0.12105259f, 
    -0.00027940f, -0.11137861f, -0.00667734f, 0.00186762f, -0.09601461f, -0.14648938f, -0.08028844f, -0.04145319f, 
    0.11901415f, 0.28656015f, -0.00426199f, 0.01157905f, -0.13342707f, 0.08807351f, 0.05772384f, 0.01935522f, 
    0.00417829f, 0.07174422f, 0.01580070f, 0.00334140f, -0.08626512f, 0.23029046f, 0.14565483f, 0.13110121f, 
    -0.05253308f, -0.10259921f, 0.01208430f, -0.02723281f, 0.03086545f, 0.02331938f, 0.10938971f, -0.03291961f, 
    -0.31932825f, 0.05116111f, -0.18935145f, -0.17083231f, -0.15849350f, -0.02749209f, 0.03586933f, 0.12657151f, 
    0.06589424f, 0.07619049f, -0.07490953f, -0.15295058f, 0.26181021f, -0.12947610f, 0.03275727f, 0.00710764f, 
    -0.11862987f, 0.00470840f, -0.05215408f, 0.02419813f, 0.05010057f, 0.02206608f, -0.05659151f, -0.03820241f, 
    -0.23832394f, -0.13536878f, -0.22660923f, -0.11959437f, -0.05709592f, 0.06951787f, 0.02855901f, -0.15375383f, 
    -0.01266940f, -0.07278544f, 0.02829862f, -0.06540525f, -0.13637993f, 0.33667704f, -0.08880925f, 0.22880982f, 
    0.04190195f, 0.04143127f, 0.36269990f, 0.05748109f, -0.06192028f, -0.06310169f, -0.02470622f, -0.00844996f, 
    -0.00538973f, -0.13356623f, -0.00850896f, -0.06586802f, -0.05730814f, -0.11895253f, -0.07001203f, -0.07322560f, 
    -0.09905005f, -0.12419950f, -0.02715779f, -0.09205640f, 0.09703560f, -0.00315292f, 0.30171037f, 0.04386174f, 
    -0.04543790f, -0.04245978f, 0.07956776f, 0.00817694f, 0.01122188f, -0.05547873f, -0.01299321f, 0.12904499f, 
    0.09216667f, 0.13189131f, 0.09116868f, -0.05384117f, -0.06319186f, -0.05180043f, -0.02282031f, -0.05904362f, 
    -0.02753127f, 0.11739422f, -0.05763341f, 0.01476207f, 0.39230713f, -0.13630754f, 0.02597277f, -0.03075246f, 
    -0.04870282f, 0.02776390f, 0.05635279f, 0.13781035f, 0.03413759f, 0.11414734f, 0.20554894f, 0.11908952f, 
    -0.09283064f, 0.12427817f, 0.01411165f, 0.09989835f, -0.00797366f, -0.05707931f, 0.01555035f, -0.10003971f, 
    -0.08104087f, -0.15331732f, -0.05847114f, 0.06295051f, 0.17320028f, -0.01380819f, -0.09075147f, 0.28677246f, 
    -0.09009919f, 0.08456329f, 0.06507830f, 0.17705931f, -0.07465747f, 0.01468653f, 0.06979971f, -0.05862693f, 
    0.02234546f, 0.03687703f, 0.02641970f, -0.01954801f, 0.00191564f, -0.02835143f, -0.04420699f, -0.04973150f, 
    -0.02513252f, 0.01711862f, 0.01752678f, -0.01059382f, -0.05117495f, 0.02213010f, -0.01438849f, 0.02906807f, 
    0.01617396f, 0.00742947f, -0.00022490f, -0.02319476f, 0.03027847f, -0.00094121f, 0.01101069f, -0.01623348f, 
    0.01461583f, -0.03456070f, 0.04091474f, 0.04224067f, -0.02294709f, 0.01166557f, -0.01999436f, -0.04963181f, 
    0.03616785f, -0.05555588f, 0.03304246f, 0.04288338f, 0.01219705f, 0.02450081f, 0.01358900f, -0.03695487f, 
    0.03791847f, -0.01200405f, -0.01481979f, -0.03409260f, -0.02063826f, 0.00585685f, 0.00262356f, 0.04403818f, 
    -0.03569516f, -0.03187032f, 0.00013177f, -0.04651837f, 0.03931401f, 0.04458662f, 0.03523985f, -0.04186774f, 
    -0.01802379f, 0.02382218f, -0.04531654f, 0.04658427f, -0.04481320f, 0.03445707f, -0.04479726f, 0.01559178f, 
    0.01661541f, -0.03129156f, 0.00476852f, -0.02188203f, 0.01635531f, -0.04230848f, -0.04512915f, 0.01836774f, 
    0.00580574f, -0.05775482f, -0.03463125f, 0.04509027f, 0.00314438f, -0.02984573f, -0.01850351f, -0.05027460f, 
    0.04084214f, -0.02534663f, -0.01766623f, 0.01575953f, -0.00009149f, -0.00259674f, 0.02778209f, -0.02992487f, 
    -0.05679934f, 0.03010774f, 0.02250282f, -0.05159041f, 0.00033720f, 0.03910974f, 0.01891202f, -0.04001436f, 
    0.02358437f, -0.00712777f, 0.02536024f, 0.01251789f, -0.00857942f, -0.01407323f, -0.03668109f, -0.03416771f, 
    -0.03132318f, 0.03503896f, 0.02356841f, -0.02710045f, -0.03650186f, 0.04124127f, -0.04531212f, 0.03317118f, 
    -0.04935757f, 0.02699379f, -0.04628631f, 0.02282223f, 0.04023576f, -0.03586079f, 0.02742190f, 0.00008142f, 
    0.02195449f, -0.01041848f, -0.00928677f, -0.02099198f, -0.01828580f, -0.01533241f, 0.01930922f, -0.02272826f, 
    -0.02779514f, -0.01997933f, -0.00847906f, -0.04373100f, -0.03152652f, -0.04842738f, 0.03783644f, -0.02732420f, 
    0.00956264f, 0.02678912f, -0.00291237f, -0.00730623f, -0.03981944f, -0.03354847f, -0.03424569f, 0.01355836f, 
    -0.02316705f, -0.02517022f, 0.02804207f, 0.01758942f, -0.05486329f, -0.04328150f, -0.03204893f, -0.03715398f, 
    0.00925229f, -0.01597206f, 0.01682804f, -0.02090227f, 0.00715395f, -0.03947699f, -0.01741569f, -0.02059465f, 
    0.01963156f, 0.03569325f, 0.00774431f, 0.02579864f, -0.02333370f, 0.00536859f, -0.04149371f, -0.05326823f, 
    -0.03094951f, 0.04004820f, 0.01745966f, 0.03481937f, 0.02655256f, 0.02309109f, -0.02442028f, -0.04289481f, 
    -0.02291708f, -0.04815727f, 0.03243974f, 0.03004033f, 0.00206943f, -0.02034152f, 0.02466725f, 0.04155713f, 
    0.03568529f, -0.00136622f, 0.00464708f, 0.02820191f, -0.05511056f, 0.03325693f, 0.03858677f, 0.03961035f, 
    -0.04351663f, 0.01391255f, -0.00033475f, 0.03915352f, -0.02030019f, 0.03797187f, -0.03717588f, 0.01395893f, 
    -0.03675792f, 0.03117965f, 0.01099634f, 0.03870765f, 0.01061058f, -0.01798951f, 0.00264369f, -0.02366682f, 
    0.02974487f, -0.01967939f, 0.03687864f, -0.03676447f, 0.02346302f, 0.02555031f, 0.00326358f, 0.00834254f, 
    -0.05371713f, -0.02271974f, -0.03843154f, 0.02864096f, -0.03835018f, -0.00646942f, 0.01753076f, -0.00645573f, 
    0.03898909f, 0.04296479f, -0.01325835f, 0.00366081f, -0.04125508f, -0.02630783f, 0.03714793f, -0.03086153f, 
    0.01302452f, 0.03701236f, -0.00959962f, 0.04216329f, 0.01631384f, -0.02236642f, -0.02208291f, -0.05196965f, 
    0.00308889f, -0.02079238f, 0.04365980f, 0.04170819f, 0.01085358f, -0.02114158f, -0.03570902f, 0.03105128f, 
    -0.05150839f, 0.02463791f, 0.00280799f, -0.02698868f, 0.02597662f, 0.03938906f, 0.00186624f, -0.00737419f, 
    -0.02890899f, 0.01458795f, -0.00863057f, 0.03839993f, -0.03960954f, 0.00754703f, -0.02182323f, 0.00074072f, 
    -0.03074837f, -0.03827029f, 0.02775286f, 0.04211969f, -0.00936125f, 0.01339222f, -0.05105292f, -0.01151640f, 
    0.03639085f, -0.00018158f, -0.01026998f, 0.00483950f, 0.03547555f, 0.02118132f, 0.00686193f, -0.04316321f, 
    0.02972568f, 0.00067180f, 0.02404715f, 0.01891638f, 0.02334825f, -0.03128618f, -0.01512122f, -0.04670456f, 
    -0.03145259f, 0.01540221f, 0.01464766f, -0.00649551f, 0.01209694f, 0.01270360f, 0.03452781f, -0.00789971f, 
    -0.02766917f, 0.02653008f, -0.03462099f, 0.02065567f, 0.01126203f, -0.02516425f, -0.03082787f, 0.01650033f, 
    0.01688060f, -0.04392575f, -0.00111683f, -0.00754750f, -0.01408742f, -0.02689308f, -0.01105377f, 0.01654411f, 
    -0.00668221f, 0.02357967f, -0.05080281f, 0.01559781f, -0.04066115f, 0.04981195f, 0.02403838f, -0.02992664f, 
    -0.00537165f, 0.01480632f, -0.05581779f, -0.04602335f, -0.01684328f, -0.04173882f, -0.02838022f, 0.00734629f, 
    0.01818630f, 0.03715733f, -0.04743300f, 0.00085053f, -0.00165300f, -0.00248271f, 0.00344476f, 0.03021987f, 
    -0.02790066f, 0.04443882f, 0.00910184f, -0.04548627f, -0.00106078f, -0.01624632f, -0.04080083f, 0.01251610f, 
    -0.01309316f, 0.01695481f, 0.02256175f, -0.03419863f, 0.01859469f, -0.00309105f, 0.04690270f, 0.00685510f, 
    0.03918629f, -0.03467323f, 0.03885208f, -0.04017255f, 0.03749618f, -0.00926419f, -0.03415315f, -0.03975623f, 
    0.02228604f, -0.04262866f, -0.02840824f, -0.03098788f, 0.03160883f, 0.04601317f, 0.04390941f, -0.03832287f, 
    -0.02884009f, -0.02431848f, -0.05063675f, 0.03120708f, -0.00884973f, 0.02077237f, 0.00146154f, -0.00535632f, 
    -0.00795309f, -0.04090306f, 0.01558227f, -0.02917138f, -0.03480233f, 0.00560455f, 0.00787388f, -0.00986953f, 
    -0.32048652f, 0.02547280f, -0.18267538f, 0.24849415f, -0.00076407f, -0.11551032f, 0.05858590f, 0.04013232f, 
    -0.05174357f, -0.01431904f, -0.01105880f, -0.03171697f, 0.03977595f, 0.10280232f, 0.07683870f, 0.02381887f, 
    -0.06933696f, 0.00797684f, -0.06916974f, 0.01557937f, 0.04327930f, 0.11933984f, -0.02277423f, 0.04651951f, 
    -0.19277196f, 0.00272438f, -0.09465758f, -0.10434377f, 0.13925208f, 0.03053019f, -0.06673493f, -0.13585725f, 
    -0.03363925f, -0.01636010f, 0.00491179f, 0.02798602f, 0.11846071f, -0.24937183f, 0.39977497f, 0.11073238f, 
    -0.20444128f, -0.00256057f, 0.05156457f, -0.03121145f, 0.17922072f, -0.03628064f, -0.01219345f, -0.03200029f, 
    0.33315220f, -0.00813555f, 0.23560521f, -0.07786678f, -0.14012153f, -0.12730552f, 0.07162817f, -0.03789397f, 
    0.06228663f, 0.07463587f, 0.07528558f, 0.08205753f, -0.34512666f, 0.39419267f, -0.23752426f, 0.32854918f, 
    -0.09489071f, 0.02900869f, -0.06421892f, 0.04661977f, 0.09470528f, -0.05488802f, 0.01421941f, -0.07725231f, 
    0.28008917f, -0.21825640f, 0.13054223f, -0.14562975f, -0.05354479f, -0.02288725f, 0.03254845f, -0.05153196f, 
    -0.02370927f, 0.12594551f, -0.00661318f, 0.03579390f, 0.13632569f, -0.26739091f, 0.01393204f, 0.07839871f, 
    -0.22529520f, -0.02876298f, -0.10100581f, -0.20926557f, 0.01064047f, 0.02272624f, -0.12653878f, 0.06330127f, 
    -0.13933718f, -0.09281290f, -0.01786586f, 0.04421184f, -0.03473006f, -0.07959458f, 0.03805265f, 0.13848153f, 
    -0.03933462f, -0.04669286f, -0.04787509f, -0.03681340f, 0.34891772f, 0.13859449f, -0.04236183f, -0.03110071f, 
    0.07394601f, 0.08542086f, -0.00594755f, -0.07784013f, 0.04088613f, 0.02329781f, 0.10366158f, 0.12549967f, 
    -0.01253389f, 0.17476158f, 0.17960760f, 0.20619324f, 0.16454796f, -0.04993184f, -0.05809722f, 0.06265042f, 
    -0.07721367f, 0.02241520f, 0.09440941f, 0.06532527f, 0.19589151f, -0.02346417f, -0.02998760f, -0.06510906f, 
    -0.12857923f, -0.16862464f, 0.04876713f, 0.02087231f, -0.01369847f, -0.02518685f, 0.05231450f, -0.00209092f, 
    -0.07789149f, 0.10345335f, -0.05985561f, -0.06541338f, -0.05096524f, -0.02259895f, -0.09545676f, -0.16717172f, 
    0.11524843f, 0.04969280f, -0.06353585f, 0.07836901f, 0.05808627f, -0.06628864f, -0.00432345f, -0.06966890f, 
    -0.03143517f, 0.00917744f, 0.03905300f, -0.00250440f, 0.04163539f, 0.15590881f, 0.00173557f, -0.10564266f, 
    -0.06363184f, 0.07323240f, -0.03214534f, -0.04925780f, -0.06266305f, -0.01287992f, -0.11442856f, 0.01169922f, 
    0.19709884f, 0.11641770f, -0.03193257f, -0.13802989f, -0.38107502f, 0.24843800f, 0.00720770f, 0.30230212f, 
    0.21465749f, 0.07484014f, 0.15809721f, -0.01913938f, -0.00466400f, -0.02546373f, 0.13013716f, -0.02531630f, 
    -0.15862492f, -0.13663957f, 0.07388462f, -0.04216254f, 0.00617890f, 0.08203099f, 0.00995429f, -0.11944630f, 
    0.05577101f, 0.14862809f, -0.02918614f, 0.09037874f, -0.13958655f, -0.06919881f, 0.17271088f, -0.07876046f, 
    0.08048448f, 0.12923932f, 0.17764306f, 0.06238478f, 0.02008518f, -0.07015400f, 0.05351672f, -0.06291468f, 
    -0.10404225f, -0.02977657f, 0.02035540f, 0.05941784f, 0.00598682f, -0.01727500f, -0.02410628f, -0.09869754f, 
    0.06640073f, 0.15557289f, 0.14620034f, -0.01744107f, 0.19191551f, 0.00729351f, 0.13309416f, 0.07355468f, 
    -0.00344801f, -0.09337263f, 0.09480467f, 0.07675302f, 0.08199722f, 0.09843757f, 0.08421598f, -0.00175179f, 
    0.06062878f, 0.22936323f, 0.20020001f, 0.06750778f, 0.01751013f, -0.03834977f, -0.07004835f, 0.05845993f, 
    -0.06742008f, 0.05111605f, 0.09555279f, -0.06694589f, 0.09082341f, -0.07262057f, -0.17472939f, 0.09651882f, 
    -0.12677963f, -0.02240011f, -0.04448403f, 0.00538822f, 0.03567367f, 0.05963613f, 0.05815813f, -0.05010756f, 
    -0.44646132f, -0.08791136f, -0.05699438f, 0.04460202f, 0.11569994f, -0.02282652f, 0.13166489f, 0.19347125f, 
    0.04242972f, 0.13958101f, -0.14551434f, -0.01053533f, 0.21516994f, 0.12107829f, -0.17728738f, -0.09542175f, 
    -0.08769131f, -0.09849007f, 0.03668876f, 0.01458383f, -0.05349099f, 0.01131782f, 0.04481116f, -0.10272884f, 
    -0.09429080f, -0.12827939f, -0.06630063f, 0.09540427f, -0.08822147f, -0.05644314f, 0.07339573f, -0.05154372f, 
    -0.01856923f, -0.01617636f, 0.01735738f, 0.06703554f, -0.04219121f, 0.06141719f, 0.10149164f, -0.03720865f, 
    -0.01066555f, -0.08177214f, -0.12776439f, -0.01247910f, 0.02933606f, 0.06949788f, 0.06877600f, -0.12249994f, 
    -0.00584059f, -0.07416281f, 0.04376067f, -0.03580508f, -0.11111790f, -0.06961010f, 0.02926349f, 0.00137071f, 
    0.02529847f, 0.05733545f, 0.02953451f, 0.06551872f, -0.01538211f, 0.15990667f, 0.02646611f, 0.03627504f, 
    0.07909261f, -0.06620096f, -0.03217392f, -0.11710766f, -0.14137678f, 0.07178321f, 0.03658399f, 0.00360159f, 
    0.09864245f, -0.01756119f, 0.08281590f, 0.04938104f, -0.10428924f, 0.01293539f, -0.04102104f, 0.00914678f, 
    -0.21543361f, 0.14247982f, 0.00760506f, 0.04643606f, -0.50957006f, 0.30658191f, -0.08060717f, 0.22902265f, 
    0.03367559f, 0.07725614f, -0.06949321f, -0.05720020f, 0.05862389f, -0.15388751f, 0.10773721f, 0.01269738f, 
    0.14465448f, -0.06433655f, -0.21913975f, -0.02151598f, -0.09801778f, -0.04673764f, -0.00701347f, 0.01579821f, 
    0.03419515f, 0.01318150f, 0.01436916f, -0.03007180f, -0.29445481f, 0.08927121f, -0.16260317f, 0.08576141f, 
    0.07666192f, 0.12631305f, 0.04564467f, 0.04700302f, 0.06340304f, 0.12865080f, 0.03040730f, 0.06127418f, 
    -0.21617500f, 0.18536513f, 0.04795132f, 0.17503184f, 0.14927460f, 0.00600633f, -0.04155752f, 0.21342154f, 
    0.06243259f, -0.02157289f, 0.03167730f, -0.01760568f, 0.05275056f, 0.05281369f, -0.13188748f, -0.09038725f, 
    -0.05198604f, -0.24702023f, -0.06369369f, 0.10039958f, -0.02119775f, 0.03473261f, -0.03249241f, -0.22932537f, 
    -0.14438350f, -0.02943112f, -0.16729219f, -0.09261960f, -0.03763946f, 0.01817606f, 0.10068104f, -0.02235523f, 
    0.14134830f, 0.18505503f, 0.09676801f, -0.04298979f, -0.10827156f, 0.02205794f, 0.26539877f, 0.06113147f, 
    -0.13894165f, 0.13046275f, 0.04568506f, -0.01836440f, 0.03981991f, -0.05357016f, -0.06287400f, 0.15406930f, 
    -0.08605561f, 0.01395720f, 0.26763225f, 0.12240261f, -0.13706028f, 0.09177022f, 0.02160695f, 0.01506334f, 
    0.21323757f, 0.10715275f, -0.08010544f, 0.20213808f, -0.31918669f, 0.59787381f, 0.17197691f, 0.16494016f, 
    -0.03964652f, 0.09291194f, 0.19051501f, 0.23471880f, -0.11101544f, 0.19788830f, 0.23225267f, -0.17486578f, 
    0.18593258f, 0.05401753f, 0.32255611f, -0.10004980f, -0.02045813f, -0.09951598f, 0.01309627f, 0.17413408f, 
    -0.21498546f, 0.03964069f, -0.19255862f, -0.12242721f, 0.34651995f, 0.10271198f, 0.22907132f, -0.07724515f, 
    -0.02534670f, -0.01005164f, -0.10473439f, 0.05862267f, -0.01644598f, 0.04995172f, 0.04627859f, -0.01659411f, 
    -0.05142859f, 0.02140082f, 0.00253811f, 0.07423931f, -0.06151460f, 0.02087642f, -0.05030628f, 0.05497368f, 
    -0.05933220f, -0.00394869f, -0.04811954f, -0.02465610f, -0.22428931f, 0.29631108f, -0.04208501f, -0.05191953f, 
    -0.06537969f, -0.09583784f, -0.10391462f, -0.12203509f, -0.06306354f, 0.14039865f, -0.12220195f, -0.04671180f, 
    -0.11628745f, -0.17626327f, -0.07743809f, -0.11804448f, -0.06558567f, 0.04386352f, -0.00981328f, -0.04902798f, 
    0.02364673f, 0.12485889f, 0.00604701f, 0.22522359f, -0.01561226f, 0.05809237f, -0.13338462f, -0.07024041f, 
    -0.02024938f, -0.08086498f, -0.20112649f, 0.21238862f, -0.13396083f, 0.09131054f, 0.04350973f, -0.06215521f, 
    0.01255254f, 0.25040585f, 0.31579718f, -0.07608353f, 0.08183000f, 0.08906687f, -0.14017743f, -0.07103950f, 
    -0.09637141f, 0.03768269f, 0.07448634f, 0.13760005f, 0.09122534f, -0.01269690f, -0.03612940f, -0.13902149f, 
    -0.16748215f, -0.09221317f, -0.13823403f, -0.04171958f, -0.02148384f, 0.03291354f, 0.05882427f, -0.10059311f, 
    0.12189315f, 0.09415621f, -0.05569184f, -0.14106850f, -0.13775185f, -0.06320973f, -0.12787831f, -0.14057933f, 
    0.04606040f, -0.12196472f, -0.16030239f, -0.19237122f, 0.04279606f, 0.22664569f, 0.05555880f, -0.03139983f, 
    0.14159071f, 0.13399281f, 0.05232606f, 0.29027173f, 0.12125783f, -0.11339254f, 0.32954353f, 0.00169067f, 
    0.13436289f, 0.04220540f, -0.02235929f, -0.01106950f, -0.10156771f, 0.00830464f, 0.05622062f, 0.15422581f, 
    0.08076395f, -0.07802378f, 0.20135176f, 0.07964925f, -0.26499772f, -0.26740435f, 0.03628455f, -0.05977534f, 
    0.00444280f, 0.22033826f, -0.00305513f, 0.17028332f, -0.04746079f, 0.01825718f, -0.02470591f, 0.09330726f, 
    -0.10963465f, -0.01271571f, -0.05636588f, -0.07181850f, -0.08029586f, -0.07151201f, -0.06293127f, -0.08557366f, 
    0.03666106f, 0.00479963f, 0.21632218f, 0.09753381f, 0.08827503f, 0.18819183f, 0.05712447f, 0.04357491f, 
    -0.05249315f, -0.06830531f, 0.07187625f, 0.09296948f, 0.02650905f, 0.00601287f, 0.01237126f, -0.10162538f, 
    -0.11357020f, 0.06578106f, 0.08894308f, 0.01424935f, 0.01189881f, -0.11819069f, 0.01677273f, -0.00752159f, 
    -0.04467377f, 0.01944002f, -0.03078092f, -0.06960911f, 0.12916467f, 0.17002782f, 0.09499325f, -0.14113630f, 
    -0.13326487f, -0.06031944f, -0.07199144f, -0.01330321f, 0.00850070f, 0.08924753f, -0.08004165f, -0.10572278f, 
    -0.29727131f, -0.22522213f, -0.31154120f, 0.07094875f, 0.01248657f, 0.12050106f, 0.17400853f, 0.03522623f, 
    -0.04652712f, -0.04575239f, 0.07288871f, 0.01524915f, -0.01403100f, 0.08790716f, 0.26272619f, -0.04539597f, 
    -0.12185501f, -0.09381425f, -0.08822136f, 0.08499403f, -0.14213283f, -0.02430132f, -0.04433304f, -0.00484267f, 
    -0.03891086f, -0.10127748f, -0.02078496f, 0.03383059f, -0.05715571f, -0.05853181f, -0.03618355f, -0.00717573f, 
    -0.06398480f, -0.02352933f, -0.15602836f, -0.09120423f, 0.14010672f, -0.17465490f, -0.03439988f, -0.08581726f, 
    -0.02694724f, 0.08999977f, -0.24496584f, -0.05466772f, 0.10230620f, -0.02638112f, 0.08379167f, 0.00927412f, 
    -0.01990629f, 0.13330658f, 0.09471783f, -0.01641566f, -0.19861458f, 0.10454185f, 0.16130352f, 0.11516017f, 
    0.05833193f, 0.04635043f, 0.04697403f, 0.22746620f, 0.13939297f, -0.22292869f, -0.30921465f, -0.09828282f, 
    -0.01693267f, -0.11683496f, -0.11130793f, 0.09295613f, 0.05609398f, -0.04332640f, -0.00726130f, 0.02040094f, 
    0.33055261f, 0.12153739f, 0.11724866f, 0.19655710f, -0.23892479f, -0.08010940f, -0.04726254f, 0.05440930f, 
    0.00352539f, 0.01425954f, 0.14058128f, -0.00264906f, -0.10873438f, 0.47735187f, -0.04236041f, 0.13434602f, 
    0.21994808f, -0.07308224f, 0.01316215f, 0.11152766f, -0.04150557f, -0.00941577f, 0.00761390f, -0.15596423f, 
    -0.01992217f, 0.30068824f, -0.12920855f, -0.17718427f, -0.22421733f, -0.02942368f, 0.07851330f, 0.07371660f, 
    -0.00093125f, 0.08964930f, 0.15559848f, -0.02122950f, -0.03294039f, 0.18306836f, -0.05857496f, 0.28796491f, 
    -0.03273320f, 0.27131182f, 0.09460894f, -0.10902538f, 0.10815811f, 0.33019355f, 0.05869291f, -0.04391893f, 
    0.01437883f, 0.02470972f, -0.02915096f, 0.03546019f, 0.01894927f, 0.03828424f, -0.01888635f, -0.02365730f, 
    0.03183948f, 0.00406354f, -0.00853949f, -0.06031844f, -0.00272633f, -0.00814492f, 0.03070306f, -0.02480355f, 
    -0.03596519f, 0.02894440f, 0.00121452f, -0.01726538f, -0.05534329f, 0.04585405f, 0.02445049f, 0.02297674f, 
    -0.02668840f, -0.01995211f, -0.03443452f, -0.00431315f, 0.04507599f, 0.01437521f, -0.00579684f, 0.02732863f, 
    -0.02640864f, -0.04148383f, 0.00161779f, 0.03194421f, 0.04939042f, -0.02429824f, 0.03290291f, 0.00274536f, 
    0.03555567f, -0.03384274f, -0.02215184f, 0.03924144f, -0.03369781f, -0.02625693f, 0.01458199f, -0.00075757f, 
    -0.04284482f, 0.03539745f, -0.00111254f, 0.00735751f, -0.01357989f, -0.03836879f, 0.04078010f, -0.01687221f, 
    0.04187966f, 0.00243835f, 0.02948801f, -0.00367829f, 0.04299397f, -0.01158337f, -0.00208887f, -0.04955723f, 
    0.00534032f, 0.00852792f, -0.03698441f, -0.04207838f, 0.02701189f, -0.03335985f, -0.04526420f, -0.00284158f, 
    -0.03991957f, -0.00593097f, -0.02778559f, -0.04042565f, -0.03019685f, 0.00588199f, 0.04275510f, 0.04161818f, 
    -0.00082271f, -0.02793788f, -0.03325073f, -0.04007983f, -0.00554790f, -0.00344243f, -0.00331171f, 0.03976692f, 
    0.03021540f, -0.01560424f, 0.04004349f, -0.02894772f, -0.02106817f, 0.04350473f, -0.01198371f, -0.00663126f, 
    -0.05143658f, -0.00210556f, -0.04491752f, -0.03542686f, 0.05072606f, 0.00616926f, -0.01709896f, -0.01769918f, 
    -0.03666497f, -0.03504109f, 0.00337046f, -0.00193217f, -0.01351754f, 0.01296717f, 0.02351227f, -0.02690157f, 
    0.04261817f, -0.03006008f, -0.04225369f, 0.00864292f, -0.00892339f, 0.00292139f, -0.05604877f, -0.03242146f, 
    -0.03314617f, -0.00289302f, -0.03712709f, 0.00705249f, 0.00073658f, 0.01850617f, 0.03764181f, -0.02850838f, 
    0.03050115f, 0.03909659f, 0.04572983f, 0.00889220f, 0.03822137f, 0.01983969f, -0.01454556f, -0.03867813f, 
    0.00720175f, -0.01943310f, 0.00830156f, 0.03470176f, -0.03022002f, 0.03490888f, 0.01949915f, -0.01754283f, 
    -0.02223301f, -0.03560399f, -0.03435897f, -0.05325493f, 0.01976304f, -0.00853190f, 0.02310301f, 0.04318108f, 
    0.02978197f, 0.01357575f, 0.02193801f, -0.00104616f, -0.02552053f, 0.04140731f, 0.01482559f, -0.01425619f, 
    -0.03093519f, -0.03238519f, 0.01259823f, -0.05400423f, 0.01291963f, -0.04842915f, 0.01852022f, -0.00085302f, 
    0.04365180f, -0.01628678f, -0.02771171f, -0.04012135f, 0.00152079f, -0.02818239f, -0.04950010f, -0.03466087f, 
    0.04518859f, -0.02522952f, -0.02470214f, -0.01337340f, 0.04114084f, -0.02401379f, -0.03596163f, 0.01007054f, 
    0.03380648f, -0.04916037f, 0.03692906f, -0.00784588f, -0.03364219f, -0.03669087f, -0.02971872f, -0.01935785f, 
    -0.02869368f, 0.00479740f, 0.02767107f, 0.00008104f, -0.03223099f, -0.00884294f, 0.04798661f, 0.03760880f, 
    -0.01367442f, -0.01001469f, 0.03417043f, -0.03062146f, -0.04825061f, 0.01696116f, -0.01042718f, -0.03159197f, 
    -0.04216455f, 0.01250209f, 0.00548358f, 0.00901638f, -0.03771505f, -0.04315829f, 0.00675999f, -0.04167245f, 
    0.01034593f, 0.02926220f, -0.00417923f, 0.02297568f, 0.03925363f, 0.00958083f, 0.00577039f, 0.00042494f, 
    -0.02639743f, 0.01197465f, 0.03097471f, 0.00347248f, -0.01828775f, 0.03161335f, 0.00660053f, 0.03101113f, 
    -0.03365931f, 0.01915197f, -0.02029805f, -0.01968899f, -0.04621792f, -0.05678743f, -0.05044924f, -0.01770568f, 
    0.02345075f, -0.03775287f, 0.03941637f, 0.00053089f, -0.03761267f, 0.02613112f, -0.03500791f, -0.01289595f, 
    -0.02126017f, -0.00057507f, -0.00069348f, 0.04710660f, -0.03176627f, -0.00958818f, 0.01785563f, 0.02318121f, 
    0.04142191f, -0.03667209f, -0.03387929f, -0.03995248f, -0.03856383f, -0.03732458f, -0.02310485f, -0.03209241f, 
    -0.01263068f, -0.01855547f, 0.01928992f, -0.00833109f, -0.02464966f, -0.02823563f, -0.02497532f, 0.01203024f, 
    -0.01102324f, -0.00210934f, 0.01468042f, 0.02186530f, -0.02781583f, 0.01497362f, 0.02353835f, -0.04515574f, 
    -0.03221821f, 0.01595342f, -0.02026407f, -0.03615637f, 0.00750449f, -0.01021168f, -0.05350264f, 0.04709594f, 
    -0.00769393f, 0.01332589f, -0.00920570f, -0.00670416f, -0.02863361f, -0.04879995f, 0.04051225f, -0.02177111f, 
    0.04343840f, -0.04237698f, 0.04718040f, -0.02426434f, 0.05182583f, -0.02256699f, -0.04393448f, 0.01500039f, 
    -0.03018687f, -0.03319877f, -0.01435494f, -0.03145414f, 0.01518070f, -0.05011719f, 0.00561888f, 0.01958444f, 
    -0.03864551f, -0.04224874f, 0.00029389f, -0.00218487f, 0.03416409f, -0.02268014f, -0.03389356f, -0.01983307f, 
    0.02582101f, 0.02253897f, 0.00831168f, 0.01304111f, 0.02937758f, 0.03883046f, -0.01546209f, -0.00556486f, 
    -0.03550525f, 0.04023233f, -0.00669527f, 0.03073435f, 0.00204576f, -0.03501619f, 0.01009826f, -0.04221446f, 
    -0.03662266f, 0.01801164f, 0.03271713f, -0.01390528f, -0.05175888f, -0.03622611f, 0.03012412f, 0.02327544f, 
    -0.04456599f, 0.02549218f, 0.02233709f, 0.03411280f, -0.04566194f, -0.03929249f, 0.03744357f, -0.04811826f, 
    0.01925603f, 0.03161853f, -0.01150617f, -0.02620111f, -0.00141934f, -0.03105616f, 0.03952595f, -0.02187145f, 
    -0.05085573f, -0.03411850f, -0.03985254f, -0.04760648f, 0.00821563f, 0.01344038f, -0.01575864f, -0.01186950f, 
    0.01493499f, -0.02369748f, -0.01530401f, -0.05199160f, 0.03242018f, -0.04038213f, 0.02347751f, 0.03601048f, 
    0.02493435f, 0.00175600f, 0.03864458f, 0.03991086f, -0.03893177f, 0.00528751f, -0.00858379f, -0.01792400f, 
    0.18803167f, 0.15247220f, 0.16420045f, -0.18114832f, -0.00132260f, -0.01254710f, 0.01378423f, 0.18307264f, 
    -0.03599482f, -0.02156526f, -0.03159703f, 0.01920707f, -0.03047419f, -0.23830102f, -0.00679028f, 0.01744158f, 
    0.11912161f, 0.12001315f, 0.11573560f, 0.12129660f, -0.07458042f, -0.08180661f, -0.12096118f, -0.04291974f, 
    0.04834267f, -0.08466218f, 0.09091131f, -0.04568772f, -0.13613795f, 0.01094021f, -0.06009745f, 0.01084188f, 
    0.10442062f, 0.13161878f, 0.14719285f, -0.01700497f, -0.29863754f, 0.01391500f, -0.00926840f, 0.11126211f, 
    0.07344678f, 0.01122130f, -0.11318054f, 0.22070569f, -0.00294412f, 0.05750921f, -0.20155498f, 0.00373516f, 
    -0.28714848f, 0.23728862f, -0.24588571f, 0.15628810f, 0.02436068f, -0.00098210f, -0.02223427f, -0.08609879f, 
    0.08348083f, -0.00645020f, -0.00512880f, -0.06146472f, 0.30738813f, -0.27904966f, 0.35298255f, -0.22047132f, 
    0.01206402f, -0.00469347f, -0.05465277f, -0.11833903f, 0.22616191f, 0.06004119f, -0.04766000f, -0.00955209f, 
    -0.24960268f, 0.34048244f, 0.08380820f, 0.14569587f, -0.03281908f, 0.10904850f, -0.19810717f, 0.19844227f, 
    -0.09720394f, 0.01791103f, -0.10320520f, -0.12234449f, -0.20359823f, 0.34495983f, 0.12258768f, -0.19065057f, 
    0.03741384f, -0.03151979f, -0.02885937f, -0.01592503f, 0.03505579f, -0.00854119f, 0.06458979f, -0.04985261f, 
    -0.15944342f, 0.00933449f, -0.16645773f, -0.08678385f, 0.18021753f, 0.08906835f, -0.03933012f, 0.04463243f, 
    -0.01233926f, -0.06175796f, -0.02946041f, 0.03355233f, 0.07307947f, -0.08910070f, 0.40987065f, -0.06982831f, 
    -0.03779761f, 0.12273497f, 0.15582922f, -0.11739378f, 0.23612225f, 0.22681643f, 0.01023632f, -0.20446150f, 
    0.23578377f, -0.01340095f, -0.09080072f, -0.02753389f, 0.00768330f, 0.08001247f, 0.10650464f, -0.02362370f, 
    -0.00269819f, 0.15506051f, -0.04331810f, 0.04879977f, -0.17734078f, -0.00722894f, -0.01108252f, -0.08936785f, 
    -0.02844050f, -0.05345099f, -0.09586880f, -0.09649427f, 0.07123352f, -0.00919160f, 0.02412342f, -0.02518087f, 
    0.20742300f, -0.03940313f, 0.23326257f, -0.13447662f, 0.12175684f, -0.06042419f, -0.05666271f, 0.01214258f, 
    -0.00840172f, -0.01653158f, 0.25329608f, 0.00985746f, -0.12269337f, 0.11056468f, -0.09691621f, 0.09811398f, 
    -0.09150733f, 0.00672498f, -0.04285285f, -0.09029238f, 0.00771839f, -0.06074419f, 0.12535775f, 0.13497598f, 
    -0.00858317f, -0.01035898f, -0.03049104f, -0.00527605f, 0.04701911f, -0.03227446f, 0.02835911f, -0.03850049f, 
    -0.07226633f, -0.07415978f, -0.00696575f, -0.10087873f, 0.41482055f, 0.03145124f, -0.12398116f, -0.21866710f, 
    -0.01084883f, -0.00086147f, 0.03469636f, 0.02309590f, 0.19649109f, 0.02773170f, -0.07309256f, 0.25529674f, 
    0.05492255f, 0.03814429f, -0.09982417f, 0.12156979f, 0.07874600f, -0.16502340f, -0.01040429f, 0.02916586f, 
    -0.03994324f, -0.07277926f, 0.09017985f, 0.06605285f, -0.27482605f, -0.08627270f, -0.14903937f, 0.26872328f, 
    0.05330649f, -0.02295626f, -0.00298127f, -0.11173790f, 0.05633806f, 0.09890378f, -0.00054724f, -0.02255840f, 
    0.09292469f, -0.01304151f, -0.07277030f, -0.11462374f, -0.03792403f, 0.01862099f, -0.03832809f, 0.04800799f, 
    -0.03009401f, -0.02607262f, 0.03610674f, 0.12454740f, -0.10735299f, 0.31793055f, -0.05316989f, 0.03776132f, 
    0.04154250f, -0.00685272f, 0.09900687f, 0.15982637f, -0.07503378f, -0.10396283f, -0.07341062f, 0.01932222f, 
    0.19088994f, -0.05606447f, 0.08041274f, 0.09735758f, 0.19748861f, 0.15261245f, 0.07285766f, -0.09346796f, 
    0.14080812f, 0.08157218f, -0.06382335f, -0.07432965f, 0.09622846f, -0.02383444f, 0.00922585f, -0.00479453f, 
    0.00459482f, -0.11125774f, 0.13523903f, 0.02089392f, -0.00840911f, -0.00353495f, -0.02650140f, 0.02407449f, 
    0.33139214f, 0.04797126f, -0.08167200f, -0.02459487f, -0.05137902f, 0.11594735f, 0.17240995f, 0.10681512f, 
    -0.15437326f, -0.20858733f, -0.08989837f, 0.07289489f, -0.26018426f, -0.11165880f, 0.09212293f, 0.08256263f, 
    0.12473742f, -0.01985336f, -0.16326424f, -0.03303224f, 0.01225024f, 0.03626416f, 0.05805006f, 0.14818424f, 
    0.06225929f, 0.12874323f, 0.02847742f, -0.16971999f, 0.07927723f, 0.03705644f, 0.03746587f, 0.11244071f, 
    -0.00916953f, -0.12001429f, -0.02051210f, 0.04964803f, 0.03557543f, -0.06219220f, -0.28176466f, 0.26854536f, 
    0.09528429f, 0.29148588f, 0.02376284f, -0.01618066f, -0.08329922f, -0.05184595f, -0.04619715f, 0.04010862f, 
    0.04447385f, 0.04848477f, 0.13229778f, 0.02426179f, -0.08141951f, -0.04839296f, -0.27870360f, 0.04086909f, 
    0.02356947f, 0.04991541f, 0.13186564f, 0.11436491f, 0.35175720f, -0.24852695f, 0.00736623f, -0.00898634f, 
    0.05238683f, 0.11738504f, -0.03007109f, 0.02844025f, 0.04876426f, 0.07683680f, 0.08020221f, 0.04461162f, 
    -0.21694025f, 0.02619067f, -0.02981861f, -0.00501148f, -0.06820886f, -0.00688275f, 0.00614035f, -0.08583556f, 
    0.15999435f, -0.08967695f, 0.08672648f, 0.19828159f, 0.42089427f, 0.28763139f, -0.01752948f, -0.36900347f, 
    0.02029481f, -0.10547359f, -0.09167358f, 0.11789544f, 0.02847810f, 0.02082003f, 0.01923057f, -0.17078499f, 
    -0.24356548f, -0.12188654f, 0.00326630f, 0.00514816f, 0.13502508f, -0.16123442f, 0.03595064f, -0.14277050f, 
    0.05665526f, 0.07587220f, 0.04387005f, 0.08720995f, 0.29080781f, -0.26517442f, 0.03446425f, -0.19154094f, 
    -0.01072707f, 0.00853874f, 0.02094098f, 0.03165330f, 0.19400562f, 0.15623103f, 0.02444666f, 0.16057615f, 
    0.25251094f, 0.24270716f, 0.02683294f, -0.17650501f, -0.02390127f, 0.13790402f, 0.06572041f, -0.05618928f, 
    -0.00737070f, 0.00247183f, 0.06472823f, 0.00538675f, 0.07586472f, 0.03457512f, -0.15235987f, -0.06877687f, 
    0.16282645f, 0.03349917f, 0.03325007f, 0.08595891f, -0.23992552f, 0.00055610f, -0.05036050f, -0.20428553f, 
    -0.11858707f, -0.03709766f, -0.08385216f, -0.02058316f, -0.13336173f, -0.14378548f, -0.01440332f, -0.04802503f, 
    -0.00510758f, 0.05421071f, -0.05056369f, 0.01106482f, 0.12278344f, -0.17645067f, -0.48682481f, 0.30677366f, 
    0.09593092f, 0.04584140f, 0.16084754f, -0.03245395f, -0.02083956f, 0.00523883f, -0.04119674f, 0.03398035f, 
    0.23110302f, -0.29786989f, 0.00170871f, 0.18275093f, 0.07284649f, -0.01409865f, -0.01138836f, 0.00683145f, 
    0.01322680f, 0.03488671f, -0.11640451f, 0.11455889f, 0.17786394f, 0.09753732f, 0.14505509f, -0.08725613f, 
    0.12310208f, 0.09576984f, -0.00269027f, 0.11287823f, 0.01851186f, -0.03249153f, 0.14924625f, 0.04423971f, 
    -0.37792754f, 0.14073156f, 0.00149737f, -0.04169663f, -0.02747657f, -0.07579368f, -0.04226503f, 0.18423702f, 
    0.01206606f, 0.02705556f, -0.24634056f, -0.17436878f, -0.03152881f, 0.25055075f, -0.31957760f, 0.01282610f, 
    0.01081490f, -0.09772166f, -0.04648620f, -0.04080264f, -0.05056842f, -0.07624304f, -0.07105935f, 0.06403749f, 
    0.25608516f, 0.19058430f, 0.05319474f, -0.03815432f, 0.16039516f, 0.16116737f, -0.08462642f, -0.12211537f, 
    -0.06863046f, -0.00025551f, 0.05422671f, -0.02957600f, 0.30169573f, 0.05356161f, -0.28531048f, 0.11139024f, 
    -0.02274315f, 0.00973194f, -0.03899131f, 0.01118773f, 0.18862118f, 0.12841529f, -0.02185707f, -0.15621050f, 
    -0.20858066f, -0.05546851f, 0.03759851f, -0.02803014f, -0.07304811f, 0.05429197f, -0.01252251f, -0.06749131f, 
    0.17678195f, 0.04884225f, 0.17410833f, 0.01286658f, -0.03831789f, -0.19680007f, -0.05455216f, -0.12562892f, 
    -0.10563304f, -0.02176440f, -0.15520683f, 0.01268228f, -0.05803753f, -0.02980256f, 0.09290983f, -0.17339262f, 
    -0.19332239f, 0.19249734f, 0.17585449f, -0.02589330f, -0.07844740f, 0.03978049f, 0.08944454f, 0.18523030f, 
    -0.01116269f, -0.10992089f, 0.15727408f, -0.03290759f, -0.06620319f, -0.05476590f, -0.00379452f, -0.04605288f, 
    -0.09553982f, -0.03155609f, -0.06246193f, -0.12205840f, -0.05407308f, -0.04178844f, 0.01576334f, 0.02962101f, 
    -0.13108274f, -0.05529330f, 0.00223712f, 0.00823515f, -0.01526136f, -0.12022073f, -0.04418848f, -0.07979298f, 
    -0.25563258f, -0.21086429f, -0.02102974f, -0.09231532f, 0.15662029f, -0.07228701f, 0.19026023f, 0.11108365f, 
    -0.15016969f, -0.00638477f, 0.10109336f, 0.09957120f, 0.12540179f, -0.10006930f, 0.03391389f, 0.27703884f, 
    -0.06299385f, 0.03131335f, 0.08244177f, 0.14135954f, -0.06377872f, -0.01371483f, -0.01774504f, -0.00119767f, 
    -0.08785762f, -0.01973269f, 0.29039961f, 0.02757051f, 0.30800301f, -0.00363849f, -0.05438398f, -0.00031492f, 
    0.02432899f, 0.00414540f, -0.04468115f, 0.05699428f, -0.01220112f, 0.11827121f, -0.05995763f, 0.04818306f, 
    -0.04173045f, -0.07609052f, 0.00003930f, 0.01133218f, -0.17345588f, -0.00744414f, -0.03729526f, 0.00365526f, 
    0.12290831f, 0.04492745f, 0.10476195f, 0.18902902f, 0.15331264f, 0.06313135f, -0.07845111f, -0.13608727f, 
    0.06071294f, 0.12625372f, -0.03122501f, -0.01475667f, -0.13919210f, -0.14737608f, -0.15377642f, -0.06146783f, 
    0.08979219f, 0.13629368f, -0.09137578f, -0.00852079f, 0.10577893f, 0.11667439f, -0.13798958f, 0.15755828f, 
    0.14110433f, -0.06800497f, -0.07883825f, 0.00035083f, -0.19634867f, -0.07349478f, 0.14454302f, -0.09222012f, 
    0.06287494f, 0.07198930f, 0.00238511f, -0.01062946f, -0.05091032f, -0.01194293f, -0.06429200f, 0.01700826f, 
    0.27212277f, 0.29201424f, -0.17910470f, -0.04695532f, -0.12330436f, 0.14576100f, -0.01705235f, -0.14600933f, 
    -0.07307530f, -0.07005045f, -0.07898492f, -0.00401784f, -0.10352030f, 0.14980844f, -0.02428998f, 0.03003252f, 
    0.03468732f, 0.01906732f, -0.01969820f, 0.02415743f, -0.06986387f, -0.09557591f, 0.02463378f, 0.08075704f, 
    0.33370656f, 0.23351134f, 0.01265338f, -0.11322060f, 0.07413603f, 0.03188099f, -0.07611753f, -0.19360471f, 
    -0.02925279f, -0.03385582f, 0.01294084f, -0.11085785f, -0.00539872f, -0.13856477f, 0.17742640f, -0.01076076f, 
    0.07996773f, 0.27978474f, 0.12483320f, 0.05742472f, 0.00684921f, -0.14659217f, 0.00827031f, 0.01917540f, 
    0.12530966f, -0.07780138f, -0.05599940f, -0.01649262f, 0.06793208f, 0.07707444f, 0.15206940f, 0.05646880f, 
    -0.08581758f, 0.10720455f, -0.05166395f, 0.07690728f, -0.08109777f, -0.20938309f, -0.17041023f, -0.14739811f, 
    -0.03843449f, 0.04060198f, 0.01992881f, 0.06106721f, -0.01159707f, -0.00081239f, 0.01726992f, 0.00711290f, 
    -0.01630373f, 0.08361235f, 0.03530480f, 0.05346701f, -0.10165103f, -0.08475720f, -0.01429614f, 0.00505736f, 
    -0.01792612f, -0.07195279f, 0.03908702f, 0.15376659f, 0.42761663f, 0.07169929f, 0.01616875f, 0.11243501f, 
    -0.01166692f, -0.06560913f, 0.07949217f, -0.01111993f, 0.29310641f, -0.02068565f, -0.09145421f, -0.21449462f, 
    -0.12347005f, -0.00011560f, 0.02952950f, -0.06706940f, 0.07985120f, 0.14099357f, 0.01006043f, 0.07062390f, 
    -0.05793622f, -0.02728354f, 0.00718169f, 0.03089899f, 0.02956964f, 0.27770308f, 0.05942255f, -0.01540727f, 
    -0.02152823f, 0.03641919f, 0.12969992f, 0.12257604f, 0.15624809f, 0.02723206f, 0.15320161f, 0.05045332f, 
    -0.05464156f, 0.03501040f, -0.02818987f, 0.14114417f, 0.00213597f, -0.00560576f, -0.07273623f, -0.04322157f, 
    -0.14719181f, 0.06665800f, -0.06748505f, 0.01870925f, 0.07698788f, -0.14767313f, 0.08250993f, 0.33029720f, 
    0.02343432f, -0.09695587f, 0.14314558f, 0.01505793f, -0.00648943f, 0.08793557f, 0.01822323f, 0.25091359f, 
    0.05967895f, 0.10957270f, -0.08866447f, -0.11225767f, 0.13731004f, 0.04246237f, 0.03593375f, -0.18011928f, 
    -0.33321398f, -0.04158110f, 0.02186593f, -0.09889414f, -0.13584761f, 0.15967411f, 0.46467447f, 0.13980749f, 
    0.01881094f, -0.01480776f, -0.07194754f, -0.02631776f, -0.01035859f, 0.06863233f, 0.18768501f, -0.11682937f, 
    -0.19943763f, 0.30527946f, -0.06791599f, 0.43241313f, 0.04420817f, 0.21836616f, -0.22537506f, -0.05556671f, 
    -0.08802499f, -0.01337511f, 0.08094274f, -0.02308860f, -0.32767999f, 0.45721209f, 0.08816240f, 0.43224835f, 
    0.15170117f, -0.00436748f, 0.09275202f, -0.03368580f, -0.06435315f, 0.00670809f, -0.20451103f, -0.01270880f, 
    0.69276178f, -0.12849972f, 0.15481330f, 0.02767762f, -0.06245020f, 0.10209301f, 0.10498097f, -0.07222621f, 
    0.13254064f, 0.16600087f, 0.14859720f, 0.16980112f, 0.06633317f, -0.00962717f, 0.32073870f, 0.01995212f, 
    0.02291878f, -0.05641561f, -0.14799355f, 0.15409970f, -0.11733507f, -0.01575210f, 0.02568791f, -0.30992472f, 
    -0.13055083f, -0.15320143f, -0.15191108f, 0.01080449f, -0.05409259f, -0.08139596f, 0.06506413f, 0.03692663f, 
    0.01084787f, -0.05610232f, -0.14685304f, -0.05892415f, -0.61404729f, 0.34560558f, 0.13355865f, 0.27136028f, 
    -0.05696455f, -0.04773369f, 0.05959107f, 0.01895272f, -0.07573393f, 0.02325984f, -0.00407240f, 0.09230351f, 
    0.20440181f, 0.17365842f, -0.21643744f, -0.15416811f, -0.09965824f, -0.08363152f, 0.17444396f, 0.10602622f, 
    0.05084760f, 0.00509299f, -0.13952675f, -0.12242704f, -0.16008557f, 0.24971056f, 0.11576538f, 0.27705848f, 
    0.12908885f, 0.03260773f, 0.07440887f, 0.02803526f, 0.15444659f, 0.18127607f, -0.11937744f, -0.20227107f, 
    0.38750356f, -0.01839159f, 0.00312124f, 0.14188698f, 0.08806324f, -0.19644651f, 0.24117093f, -0.06928509f, 
    -0.02947793f, 0.08711732f, -0.13827115f, 0.06151648f, -0.02002488f, 0.04754828f, -0.18452297f, -0.20123686f, 
    0.01952686f, -0.06385838f, 0.01988226f, 0.14163543f, 0.06779414f, 0.14510562f, 0.09684158f, -0.08442904f, 
    0.08662879f, 0.00628462f, -0.20487587f, -0.28330541f, -0.20877407f, -0.07891479f, -0.00328329f, -0.04414334f, 
    0.39306042f, 0.30768460f, 0.05745905f, 0.27490363f, 0.23703854f, 0.15529443f, -0.03453616f, -0.30289260f, 
    0.21479024f, -0.00349374f, -0.03310651f, -0.02646906f, -0.16795717f, 0.24566250f, -0.01687533f, -0.09010805f, 
    0.29744303f, 0.12881391f, -0.16494350f, -0.32515806f, -0.06013667f, -0.01712321f, 0.17345615f, -0.06009043f, 
    0.03837824f, -0.05677183f, -0.09512176f, -0.07684627f, -0.13810636f, 0.05325748f, -0.02752751f, 0.42879269f, 
    0.05220329f, -0.12639131f, 0.00779476f, -0.08000424f, -0.06773272f, -0.10201680f, 0.06819511f, -0.30906832f, 
    -0.06963046f, 0.00986761f, -0.14205268f, -0.38322034f, 0.08838675f, -0.03449331f, 0.08385774f, 0.10192675f, 
    -0.09870970f, -0.12640581f, -0.11556355f, -0.17196231f, -0.15199427f, -0.16131566f, 0.09627537f, 0.30260301f, 
    -0.02118578f, -0.04809598f, -0.01077776f, 0.13941282f, 0.03770536f, 0.01671323f, 0.07724736f, 0.05200147f, 
    -0.25247517f, 0.24805944f, -0.30688384f, 0.25423467f, 0.06160474f, -0.02840302f, 0.11920501f, 0.06472259f, 
    -0.01028064f, 0.09096088f, 0.10924730f, 0.14008375f, 0.12144741f, 0.26808941f, 0.17794350f, 0.10836776f, 
    -0.08183882f, -0.05324168f, -0.08858406f, 0.13992989f, 0.00268888f, -0.04950199f, -0.03012649f, -0.00836627f, 
    -0.05120887f, -0.00560607f, -0.15217136f, 0.17325994f, 0.01070729f, -0.02959054f, -0.02895353f, -0.02027312f, 
    0.15366957f, 0.13437985f, 0.08985811f, -0.17584531f, -0.06087333f, -0.35539934f, 0.20933908f, -0.03405562f, 
    -0.14388894f, -0.00017307f, 0.03199396f, -0.06984235f, -0.03536232f, 0.06692239f, -0.01465573f, -0.04789544f, 
    -0.14039457f, -0.25910440f, -0.06034116f, 0.10154942f, 0.03895298f, 0.05367902f, 0.03250054f, 0.07003933f, 
    0.04940167f, -0.04052705f, -0.02978543f, -0.02466158f, 0.11605334f, 0.04560557f, -0.08800828f, 0.19420448f, 
    0.02718529f, 0.02656939f, 0.09723302f, 0.20423189f, 0.05170998f, 0.00472422f, 0.06416824f, -0.07058920f, 
    -0.07253365f, 0.08817203f, -0.07515156f, 0.24977344f, 0.09875254f, -0.00785785f, 0.02480851f, -0.06719494f, 
    -0.19003768f, -0.25701624f, -0.02325992f, -0.02970538f, 0.47190511f, 0.12019163f, 0.37482482f, 0.24138923f, 
    0.04441525f, -0.10198268f, 0.05413001f, -0.00982315f, 0.06913859f, 0.07836434f, -0.07457493f, 0.08321521f, 
    -0.01011738f, 0.10075503f, -0.02449500f, -0.20959330f, -0.06822596f, -0.08011293f, -0.08915021f, 0.05094677f, 
    -0.10724095f, -0.05167573f, 0.12466306f, -0.04150533f, 0.08541390f, 0.39443743f, 0.07180379f, -0.23365985f, 
    0.01205716f, 0.05528547f, -0.03818149f, 0.08070971f, -0.25164258f, 0.15662979f, 0.08466961f, 0.16235439f, 
    -0.18079284f, 0.06411555f, 0.05587412f, 0.08608668f, -0.14259420f, -0.04453490f, -0.04827482f, 0.01412747f, 
    -0.16849110f, -0.24724121f, -0.09159461f, -0.03993466f, -0.00207347f, -0.13265328f, -0.21815959f, -0.06326798f, 
    -0.03262172f, 0.09173328f, 0.09270222f, -0.14814124f, 0.00183569f, -0.04141065f, -0.06896487f, -0.15574096f, 
    0.02841646f, -0.02479048f, -0.01571703f, 0.03607974f, -0.03610298f, 0.01913689f, -0.00051950f, 0.01881474f, 
    0.00507298f, -0.00131959f, -0.01127292f, 0.01493224f, 0.01906580f, 0.03888924f, 0.02266031f, -0.05393214f, 
    0.02897479f, 0.01678592f, -0.04476739f, -0.04851262f, 0.02431710f, 0.03959966f, -0.03367374f, 0.03468605f, 
    -0.01694126f, 0.01265009f, 0.00398708f, -0.02044198f, 0.01761214f, 0.03325222f, 0.02665559f, 0.03042096f, 
    0.02222625f, -0.03563841f, 0.04215265f, 0.03636363f, 0.01705765f, 0.00388628f, -0.01738193f, -0.01362820f, 
    0.01818441f, -0.02827008f, -0.01777133f, -0.02012446f, -0.03861352f, -0.05694507f, -0.05125954f, -0.00236883f, 
    -0.03961702f, 0.01034232f, -0.04321887f, -0.04465486f, 0.03036015f, 0.00183535f, -0.02259851f, -0.05113496f, 
    0.01195689f, -0.05117920f, 0.00721807f, -0.00215157f, -0.00581390f, 0.01226074f, 0.02355935f, -0.02685885f, 
    0.04815329f, -0.03246894f, -0.04540510f, -0.00084789f, -0.04211687f, -0.00305101f, 0.04235559f, 0.00527534f, 
    -0.02479495f, 0.04043860f, -0.03084066f, 0.03779868f, -0.05274875f, -0.02481705f, 0.02787804f, -0.03897481f, 
    -0.03053559f, 0.02161681f, -0.01521080f, -0.05981667f, -0.05465252f, -0.01134580f, -0.02661198f, -0.04121920f, 
    0.03722608f, -0.00410600f, 0.00254947f, -0.03999263f, 0.04424398f, 0.01751832f, -0.04845411f, 0.01752003f, 
    -0.00196424f, 0.00853234f, -0.00417978f, -0.02050955f, -0.03126721f, 0.04129145f, -0.03597131f, 0.02584140f, 
    -0.04784317f, 0.00386083f, 0.03604786f, 0.01482138f, -0.05046368f, 0.03495962f, -0.00876919f, -0.04983278f, 
    0.04548489f, 0.01995146f, 0.01718936f, -0.05372594f, 0.00510912f, -0.03249537f, -0.00315819f, -0.02032313f, 
    -0.01374874f, -0.00778733f, -0.05334311f, 0.02877041f, 0.00093275f, 0.01650452f, 0.00117321f, -0.04972442f, 
    -0.02917488f, -0.03731945f, 0.00411781f, 0.00567626f, -0.00129204f, 0.00073233f, -0.03713613f, 0.02809869f, 
    0.03610523f, -0.05380184f, -0.01497392f, 0.03578879f, 0.01976501f, -0.05315560f, -0.00341249f, 0.00944064f, 
    0.00067115f, -0.04300247f, -0.02619961f, -0.01877486f, -0.04859409f, -0.02249219f, 0.01474654f, 0.02470661f, 
    -0.00874160f, -0.00020614f, 0.02615924f, 0.01664198f, 0.02290690f, 0.00890351f, -0.05110144f, -0.00089870f, 
    -0.04036011f, 0.01212430f, 0.01257263f, -0.05592629f, 0.03943468f, -0.03936852f, 0.01820938f, -0.00950074f, 
    -0.04581655f, 0.00059720f, -0.01131650f, 0.00445079f, -0.04179182f, 0.03903420f, -0.04147524f, -0.04812453f, 
    -0.02905071f, -0.02580091f, 0.04069150f, 0.03766380f, -0.02834058f, -0.01615298f, -0.00616518f, 0.03506363f, 
    0.00906702f, 0.02012822f, 0.03650337f, 0.01451774f, -0.02758544f, 0.03721625f, -0.04207240f, -0.03992682f, 
    -0.03648800f, -0.00735335f, -0.04614887f, 0.04078441f, -0.02085083f, -0.01481548f, -0.00682764f, -0.01027001f, 
    -0.04625231f, 0.00089909f, -0.03083465f, -0.00818379f, 0.03928564f, 0.00136615f, -0.04934828f, -0.02327612f, 
    -0.01287123f, -0.02738271f, -0.01485063f, -0.04469316f, -0.01130351f, -0.01542383f, -0.02917792f, 0.00624915f, 
    0.00314259f, -0.01725260f, -0.01552040f, -0.02661080f, 0.02094223f, 0.03203202f, 0.02826044f, 0.01916901f, 
    -0.00277601f, 0.02069403f, -0.00400990f, 0.00538096f, 0.00960563f, 0.04531492f, -0.04462711f, 0.02031928f, 
    -0.02497374f, 0.00864416f, -0.03647183f, -0.04208376f, -0.01890023f, -0.02912942f, 0.02276815f, -0.01299138f, 
    0.03504447f, -0.03758517f, -0.02649201f, -0.00607085f, 0.03248356f, 0.03298011f, -0.00724673f, -0.05123669f, 
    0.00697375f, -0.01800162f, -0.00699243f, -0.03571986f, -0.01063131f, 0.00120595f, 0.02813920f, 0.00589967f, 
    0.02423240f, -0.05153941f, -0.05143136f, 0.03776605f, -0.05110848f, -0.01940702f, 0.01257274f, -0.03163233f, 
    0.00185401f, -0.03159005f, 0.02870865f, -0.02318440f, 0.05560378f, -0.03104412f, -0.01520375f, -0.00799230f, 
    -0.03284584f, 0.00195803f, 0.02640657f, -0.00196460f, 0.02294931f, -0.01122945f, 0.01498093f, -0.04270044f, 
    -0.01447988f, 0.03067294f, -0.00686672f, 0.00641488f, -0.00956348f, -0.03501075f, 0.03872071f, -0.04292388f, 
    -0.01352118f, -0.03321670f, 0.00229044f, -0.02193227f, 0.01241403f, 0.03719524f, -0.00349770f, 0.03202679f, 
    -0.02968268f, -0.05474887f, -0.00159000f, -0.06066572f, 0.04095447f, -0.03707624f, -0.02167625f, 0.04308871f, 
    -0.04698327f, -0.00928995f, 0.04408554f, 0.03419430f, -0.02872698f, -0.04868430f, 0.01637478f, -0.04215723f, 
    0.00669790f, -0.02022575f, 0.04250985f, -0.05346091f, -0.03993366f, -0.03866034f, -0.01680743f, 0.04565134f, 
    0.03804379f, -0.02872775f, -0.01045574f, -0.03150308f, -0.03218025f, -0.04429713f, 0.00324652f, -0.02907764f, 
    -0.04625429f, -0.05756088f, -0.01708022f, -0.05613831f, 0.00562624f, 0.00287266f, -0.02050072f, 0.04915706f, 
    -0.04641894f, 0.01080774f, -0.01804951f, -0.06432447f, 0.01702718f, 0.01289889f, -0.04411707f, 0.02226193f, 
    0.00596835f, -0.02743481f, -0.04386513f, -0.00074156f, 0.02044117f, 0.00648612f, 0.03613069f, -0.00520016f, 
    0.04247268f, -0.02182358f, 0.03046037f, -0.04249241f, -0.01867354f, -0.01349179f, -0.02883083f, -0.03381543f, 
    -0.00407820f, -0.05159884f, -0.01578594f, -0.02813102f, -0.03737927f, -0.00899616f, -0.01463781f, 0.00514855f, 
    0.04281456f, 0.01882943f, 0.02456523f, 0.01712148f, 0.02298077f, 0.02361478f, 0.00792283f, -0.01983161f, 
    -0.05257664f, 0.03973474f, -0.01770647f, -0.02587142f, -0.00583795f, 0.00095357f, -0.01533927f, -0.03352397f, 
    0.01647284f, -0.15385672f, -0.00254086f, -0.05402094f, 0.04501940f, 0.02260559f, -0.02290762f, -0.05714244f, 
    -0.00635745f, 0.02944177f, 0.00276958f, 0.01899694f, -0.07139377f, 0.01812855f, -0.11143821f, -0.00975498f, 
    -0.05216793f, -0.09953562f, -0.06811239f, -0.04327581f, 0.16744179f, 0.00142763f, 0.11531924f, 0.10003830f, 
    0.00902859f, -0.00659729f, 0.00569708f, 0.00793829f, 0.02846378f, -0.07544022f, -0.09901540f, -0.07560793f, 
    -0.06112753f, -0.12805860f, -0.14650655f, -0.07817993f, 0.42215759f, 0.19386335f, 0.09923482f, 0.19250815f, 
    0.13388008f, -0.04405156f, 0.22823022f, -0.03854683f, -0.06076045f, 0.15450943f, 0.09039571f, 0.03786814f, 
    0.14913386f, 0.08274510f, 0.18854083f, -0.18193388f, -0.06797398f, -0.07148855f, 0.05669905f, 0.15502691f, 
    0.08876607f, 0.06981839f, -0.02513790f, 0.03449905f, 0.08061367f, -0.00618004f, -0.23958294f, -0.06486584f, 
    0.07048783f, 0.05416154f, 0.10067221f, 0.27875978f, -0.04617996f, 0.03747953f, -0.06915492f, 0.09233292f, 
    0.01462688f, -0.13437565f, 0.08436551f, 0.00013935f, -0.03888410f, -0.02843683f, 0.25513592f, -0.10453037f, 
    0.07558563f, 0.07161164f, 0.14537115f, 0.20753542f, 0.44549429f, 0.05769902f, 0.07224947f, 0.31637600f, 
    -0.00646922f, -0.09299120f, 0.01886301f, -0.04504658f, -0.05163430f, -0.01773863f, -0.14939201f, -0.06855869f, 
    0.21488351f, 0.14520313f, 0.15965618f, -0.00777320f, -0.03720203f, -0.03304619f, -0.08394869f, 0.02638034f, 
    -0.12531470f, -0.00478248f, -0.07687248f, -0.11663651f, 0.29846421f, -0.04250291f, -0.33383569f, -0.06794331f, 
    -0.01713298f, -0.12642181f, -0.08296630f, 0.03243463f, -0.04182757f, 0.07641070f, -0.05309881f, 0.10906160f, 
    -0.01440498f, -0.01235871f, 0.02692297f, 0.17112073f, -0.04856020f, -0.07376415f, -0.02563509f, -0.04044013f, 
    -0.03812896f, -0.01013604f, -0.06718164f, 0.03158657f, 0.17342943f, 0.03430292f, 0.05586794f, 0.06867455f, 
    0.00510988f, -0.03132290f, 0.25365493f, 0.10555374f, 0.28351483f, -0.05481419f, -0.10886721f, 0.03750292f, 
    -0.09395725f, 0.06003763f, -0.08263882f, 0.16967016f, -0.15001665f, -0.01798356f, -0.03958638f, -0.18640453f, 
    0.01852251f, 0.14679895f, -0.06367219f, -0.14664973f, 0.22720806f, 0.12920395f, 0.10483065f, 0.11436503f, 
    0.01810805f, 0.00544688f, 0.02229786f, 0.02669203f, 0.00980435f, 0.02397893f, -0.02774256f, -0.14309281f, 
    0.03942863f, 0.03684375f, 0.07277427f, 0.04919434f, -0.03693244f, 0.00407773f, -0.05426676f, -0.01496120f, 
    0.05485234f, 0.02083150f, 0.04230062f, 0.20704846f, -0.29086870f, -0.30121741f, -0.02303130f, 0.29608935f, 
    0.24634135f, 0.09967902f, 0.00005740f, -0.04629584f, 0.02262973f, -0.05204656f, -0.03889621f, -0.12463082f, 
    0.01796275f, 0.13021606f, 0.04221747f, 0.11809929f, -0.03765433f, 0.11026490f, -0.00429583f, -0.07276721f, 
    -0.06467081f, -0.03205663f, -0.16967411f, -0.00039531f, 0.11218835f, -0.11061499f, -0.02541541f, -0.15342662f, 
    0.07991997f, -0.03108499f, 0.01474589f, 0.17996904f, -0.07406352f, -0.14809901f, -0.21194956f, -0.06449644f, 
    0.04572020f, 0.04537768f, 0.01787380f, 0.06980722f, 0.00885778f, 0.00605456f, -0.00849914f, -0.09628793f, 
    0.02963262f, 0.02031699f, -0.01922453f, -0.07364789f, -0.02276623f, -0.18238381f, -0.12787928f, -0.15413098f, 
    0.01865730f, -0.02000400f, 0.07340237f, 0.08471578f, -0.09858087f, 0.01772512f, -0.01917800f, 0.13569334f, 
    -0.12494440f, -0.30093798f, -0.04537937f, -0.17042731f, -0.07921772f, -0.02672556f, 0.00554114f, 0.07529846f, 
    -0.05488107f, -0.02678441f, -0.05158184f, 0.01227783f, 0.33076435f, 0.32829985f, 0.10915125f, 0.11559594f, 
    -0.01537166f, 0.09008439f, -0.07343728f, 0.01371569f, -0.04683907f, 0.03881295f, 0.03474567f, -0.08885679f, 
    -0.10804471f, -0.15421064f, 0.32369581f, 0.07888680f, 0.26186404f, 0.07388126f, 0.01909925f, 0.09426696f, 
    0.05226500f, 0.17078926f, -0.05143054f, -0.01119779f, 0.27897283f, 0.25193626f, 0.06870933f, 0.09562287f, 
    -0.00038396f, 0.07989982f, -0.09987233f, 0.01981739f, -0.07416895f, -0.09070152f, -0.01433573f, -0.12486806f, 
    0.13163064f, 0.05165420f, 0.09332389f, 0.05833987f, 0.03141601f, -0.03494581f, 0.10354655f, -0.02272121f, 
    -0.03224789f, 0.07969210f, 0.02700891f, 0.09948984f, -0.32249036f, -0.06213466f, 0.04777192f, -0.32236269f, 
    -0.11508728f, -0.16866519f, 0.08531587f, -0.06221538f, 0.00933819f, 0.04362205f, 0.06376768f, -0.05466166f, 
    -0.01052672f, -0.01608021f, -0.00240730f, 0.05638422f, 0.01385769f, 0.04367919f, 0.02903605f, -0.12557596f, 
    -0.08972869f, -0.08760735f, -0.12657620f, -0.05453614f, -0.18263458f, 0.13320281f, -0.35792401f, -0.10317530f, 
    -0.10677201f, -0.15688679f, 0.02966499f, -0.11047703f, -0.07749681f, -0.11505834f, -0.08295714f, -0.09461296f, 
    0.31516096f, 0.19298653f, 0.20230940f, 0.17148797f, 0.01503746f, -0.05988848f, 0.04135929f, 0.06019448f, 
    0.00343666f, 0.05241989f, -0.04489018f, -0.12075943f, -0.18706584f, -0.34118095f, -0.03093837f, 0.17063431f, 
    -0.03934969f, 0.12268540f, 0.21669433f, 0.00295890f, 0.03106663f, 0.07321236f, 0.08873535f, 0.19759890f, 
    0.22253640f, 0.19172674f, 0.17035870f, 0.05743499f, -0.03746846f, 0.01179811f, -0.04560060f, 0.09046510f, 
    -0.09689033f, -0.10894009f, -0.07832821f, -0.10567620f, -0.05695556f, 0.17894721f, -0.01298695f, 0.10886809f, 
    -0.03370837f, 0.13256839f, -0.02409958f, 0.02696154f, -0.04629631f, -0.06370300f, -0.04717660f, -0.03219236f, 
    0.09080222f, 0.03768013f, 0.19713636f, 0.13341747f, 0.09144220f, 0.13329296f, 0.08008256f, 0.11046188f, 
    0.05605734f, 0.11880965f, -0.03657724f, 0.02441092f, -0.05127014f, -0.05864765f, 0.10779527f, -0.10131866f, 
    -0.11164597f, -0.14879414f, -0.22751808f, 0.04123478f, -0.12155181f, 0.03710427f, -0.13484180f, -0.18715546f, 
    0.09089987f, 0.00955238f, -0.01212594f, 0.01032732f, -0.06653187f, -0.02398119f, 0.01101040f, 0.04705158f, 
    -0.00256063f, 0.12372047f, 0.06968202f, 0.08729668f, 0.00230967f, 0.11361162f, -0.09256878f, 0.44198510f, 
    0.20072424f, -0.12437765f, 0.03780689f, 0.04502308f, -0.11727612f, 0.11583458f, -0.26834291f, -0.07635643f, 
    -0.17412098f, -0.03406885f, 0.16550791f, 0.03397198f, -0.03790214f, 0.06277788f, -0.03484003f, 0.10587512f, 
    0.00147728f, 0.07563564f, 0.01723542f, -0.02624064f, 0.36061767f, -0.16605626f, 0.41937247f, -0.24625415f, 
    -0.00045373f, 0.18192537f, 0.03884254f, 0.19224195f, -0.15295227f, -0.09319188f, 0.09074824f, 0.01917567f, 
    -0.22004926f, 0.06623404f, -0.11997069f, 0.14428589f, 0.06416535f, -0.07014916f, -0.07791907f, -0.00127929f, 
    -0.04413072f, -0.15186408f, -0.15629271f, -0.08202907f, 0.11382042f, 0.28627276f, 0.14041279f, 0.04727016f, 
    0.03552421f, -0.13839577f, 0.03194698f, -0.02548797f, -0.02833801f, -0.03802090f, -0.05755443f, 0.01001340f, 
    -0.08577567f, 0.14091112f, 0.15703839f, 0.16473190f, 0.05686696f, -0.03849827f, 0.01584451f, 0.03931393f, 
    -0.12223636f, -0.06494370f, 0.00879499f, 0.04511350f, 0.50844508f, -0.05595069f, 0.21259910f, -0.22988610f, 
    -0.12089051f, -0.12101781f, -0.02079492f, -0.02374653f, 0.03171310f, 0.14551587f, -0.01594662f, -0.11228066f, 
    0.08089145f, -0.30066824f, 0.03878818f, -0.08343596f, -0.22507912f, 0.08555766f, 0.02670480f, -0.11342862f, 
    0.28320858f, 0.10974241f, 0.15244940f, 0.04489965f, 0.11264414f, 0.06253958f, 0.03550815f, -0.10853504f, 
    -0.06748334f, 0.00365263f, -0.12228651f, 0.08602145f, -0.02977307f, -0.23605402f, -0.09361301f, -0.07288400f, 
    -0.00473864f, -0.04041800f, 0.25213805f, 0.01762169f, 0.09403727f, 0.04367887f, 0.02861001f, -0.13396089f, 
    -0.06660932f, -0.01717868f, 0.18195160f, -0.18578121f, 0.02282966f, 0.13963456f, 0.08312775f, 0.04850264f, 
    -0.12792403f, -0.03663641f, -0.15513730f, -0.12931734f, 0.17823352f, -0.03000480f, 0.03811486f, 0.06765252f, 
    0.14095969f, 0.15743023f, 0.07905651f, -0.08281399f, 0.01956174f, -0.02646771f, -0.10543887f, -0.20331147f, 
    -0.04170650f, -0.22294666f, -0.12821938f, -0.14072986f, 0.23173118f, -0.37357473f, 0.16612071f, 0.31471699f, 
    -0.07828642f, 0.08638047f, 0.21458274f, 0.11179926f, 0.34405869f, -0.01363701f, -0.01841836f, 0.03001193f, 
    0.04105501f, 0.10485200f, 0.02881342f, 0.05740121f, 0.03059366f, -0.11162326f, 0.13512206f, 0.10670231f, 
    -0.12142137f, 0.10823748f, -0.04342676f, 0.02279134f, -0.03029794f, -0.09295187f, 0.16224873f, 0.04581688f, 
    -0.09684411f, 0.04681239f, -0.01435243f, 0.13839605f, -0.05387119f, -0.00759155f, -0.09466258f, 0.04828141f, 
    0.07702485f, 0.06975649f, -0.06688578f, -0.08567504f, -0.11354185f, 0.10370735f, -0.10003102f, -0.01677153f, 
    0.26331297f, 0.08959519f, 0.19568187f, 0.08694922f, -0.06613574f, 0.10286173f, 0.09296002f, -0.04552676f, 
    -0.01154363f, 0.01921436f, 0.04628873f, 0.04794303f, -0.00749237f, -0.03868599f, -0.21817303f, -0.08401202f, 
    0.09419662f, -0.09868938f, 0.17779399f, 0.04146948f, -0.13571543f, 0.11309788f, -0.09454786f, 0.04883066f, 
    0.11136401f, -0.08822764f, -0.05584538f, 0.00929779f, 0.10887336f, 0.29677516f, -0.08273540f, -0.12720342f, 
    -0.13411613f, -0.08278917f, 0.02742010f, -0.09419835f, -0.03907449f, -0.08172975f, -0.10396903f, -0.16630952f, 
    -0.00191719f, -0.13243060f, -0.00861237f, 0.16227716f, -0.01094501f, -0.04877226f, 0.06468230f, 0.04268251f, 
    -0.00177938f, -0.13879173f, -0.00068585f, -0.01960288f, -0.03855702f, 0.08923646f, 0.09013215f, 0.03744899f, 
    0.09757093f, -0.06802133f, 0.02465904f, -0.07869308f, -0.03770715f, -0.03122633f, 0.07257377f, 0.10555312f, 
    0.08032499f, 0.08379985f, 0.04072885f, 0.08241546f, 0.00280074f, 0.06976682f, -0.03280571f, 0.01828848f, 
    0.07343224f, 0.02980890f, -0.00022459f, -0.06730408f, -0.16224182f, -0.18195879f, 0.01733281f, -0.13110988f, 
    -0.16867781f, 0.17054339f, 0.02372531f, 0.03786691f, 0.09092714f, -0.05520910f, -0.05531365f, -0.13225488f, 
    0.08339410f, -0.06075838f, 0.08263465f, 0.15584099f, -0.03404187f, -0.00768637f, -0.03324512f, 0.13768288f, 
    -0.05356150f, 0.07948167f, 0.14869678f, 0.05849987f, 0.16190857f, -0.13849625f, -0.22624592f, -0.07280684f, 
    -0.12601326f, -0.00321020f, 0.01751078f, 0.02059207f, 0.00694644f, 0.00467153f, 0.08226108f, 0.03236639f, 
    0.13265117f, 0.15712900f, 0.07249703f, 0.02035969f, -0.20081650f, -0.11131190f, -0.01954859f, -0.08635048f, 
    0.07877732f, -0.04304943f, -0.02731799f, 0.11764940f, 0.35123500f, -0.07378115f, 0.05480396f, 0.19441549f, 
    -0.08445753f, -0.00198629f, -0.00450375f, -0.04692660f, 0.23432247f, 0.06835492f, -0.00442373f, -0.08219497f, 
    0.04817473f, 0.20103610f, -0.02677127f, -0.09524736f, 0.07842404f, 0.08914838f, -0.12950641f, -0.02628610f, 
    -0.05995569f, 0.10543722f, 0.05625391f, 0.01861327f, 0.13510178f, 0.12572938f, 0.08444651f, -0.04161794f, 
    0.11984253f, 0.07501919f, -0.06316998f, 0.02275497f, -0.00031414f, 0.21211164f, 0.05820759f, 0.03820808f, 
    -0.00078068f, 0.00460548f, -0.04646463f, 0.01772839f, -0.02677927f, 0.01317378f, -0.02449846f, -0.04582901f, 
    0.04608700f, -0.02164847f, 0.01451253f, -0.03262177f, -0.03485106f, 0.00582515f, -0.01916672f, -0.01466478f, 
    0.01417420f, -0.04882848f, -0.05449232f, 0.01530442f, -0.02740824f, 0.04120768f, 0.02431897f, -0.02265940f, 
    0.01280648f, -0.04558815f, -0.03394298f, 0.03523834f, 0.03049014f, 0.00024168f, -0.00626293f, -0.03322100f, 
    0.01029555f, -0.05589009f, -0.00338466f, -0.03277755f, 0.01768038f, -0.03335945f, -0.02460157f, 0.04727777f, 
    -0.04117949f, -0.04678367f, 0.01497285f, 0.04437257f, -0.00650181f, -0.05594694f, 0.04311822f, -0.01893922f, 
    0.03026938f, -0.00158356f, -0.05045908f, -0.03491387f, 0.02397582f, 0.00084215f, -0.04759533f, -0.02159820f, 
    -0.03622901f, 0.00846594f, -0.03305988f, -0.03401543f, -0.04466600f, -0.03095302f, -0.03476796f, -0.02965134f, 
    -0.04309078f, -0.00043361f, -0.04971315f, 0.01152837f, 0.01937732f, -0.03751158f, -0.05229260f, -0.04118044f, 
    0.01308875f, -0.04027067f, 0.04228735f, 0.01681576f, -0.01488352f, -0.03737962f, -0.04290978f, -0.04145158f, 
    -0.05349315f, -0.03525406f, -0.03093670f, -0.00290840f, -0.02179358f, -0.04542537f, -0.03700682f, 0.00523120f, 
    0.04145020f, 0.04391739f, 0.04197356f, 0.00931177f, -0.00722508f, -0.04796623f, -0.01489027f, 0.01430697f, 
    0.01685460f, -0.04538822f, -0.01427824f, -0.01193133f, 0.00407229f, -0.04026471f, 0.01334715f, -0.04085340f, 
    -0.03325337f, -0.03283990f, 0.01657356f, 0.02735844f, 0.00059015f, -0.05121179f, -0.01615551f, 0.02775677f, 
    -0.03636750f, 0.01950115f, 0.02516865f, 0.03805080f, 0.03992229f, -0.03233384f, 0.02992711f, -0.04036546f, 
    0.03950923f, -0.05055381f, 0.03222709f, -0.04292689f, -0.03613911f, -0.04596761f, 0.00710286f, -0.02428096f, 
    0.04274791f, -0.02049797f, -0.00395242f, -0.00637505f, 0.01665286f, 0.01359948f, 0.00961612f, -0.02084167f, 
    0.01721176f, 0.01641705f, -0.00108291f, -0.01317787f, 0.00836674f, -0.00768815f, -0.00097252f, -0.04389261f, 
    -0.01826787f, -0.05500073f, 0.01303748f, -0.04296996f, -0.00468755f, 0.03432404f, -0.01253064f, 0.02825842f, 
    -0.04530045f, 0.02750045f, 0.02351012f, 0.03291509f, 0.01721157f, -0.02435397f, -0.05231543f, -0.02514381f, 
    -0.01668972f, 0.03471960f, 0.02838212f, 0.02577642f, 0.01287669f, -0.02076072f, -0.05469181f, 0.03566968f, 
    -0.05503777f, -0.02902640f, -0.03571241f, 0.01861931f, -0.02117677f, -0.05544766f, 0.02644610f, -0.04082675f, 
    0.01807124f, -0.01443761f, -0.04298209f, 0.01781729f, -0.03847587f, -0.02313736f, 0.00778141f, -0.01131997f, 
    -0.01330253f, -0.01436111f, -0.00232725f, -0.01697830f, -0.00058158f, -0.03823528f, 0.03062388f, -0.01089244f, 
    -0.01433767f, 0.01086969f, -0.01690221f, 0.00062235f, 0.00686852f, -0.01636198f, 0.03060587f, -0.01155544f, 
    0.04515803f, 0.01702339f, 0.01873201f, -0.04174605f, -0.02675691f, 0.02481600f, 0.00248855f, -0.02496135f, 
    0.00163756f, -0.02441501f, -0.01796171f, -0.01649403f, 0.03465581f, 0.00931068f, -0.01318047f, 0.02288080f, 
    0.00688681f, 0.02001766f, 0.03915419f, -0.01970574f, -0.01945685f, 0.01967032f, -0.03809808f, 0.00054974f, 
    -0.04119005f, -0.05575006f, 0.00370981f, -0.01939250f, -0.04623724f, 0.02709574f, 0.03220932f, -0.01279506f, 
    0.04247358f, 0.00422692f, -0.00479042f, -0.04973181f, 0.00398454f, -0.03397027f, -0.03783777f, 0.03097122f, 
    -0.03756287f, -0.03936221f, -0.05613031f, -0.01265176f, -0.03068697f, -0.00473246f, 0.01191077f, -0.03220095f, 
    -0.00979913f, 0.00581854f, -0.05428926f, 0.03637061f, 0.00850446f, 0.02239578f, -0.01585328f, 0.03649450f, 
    -0.00602273f, -0.04744007f, -0.02072461f, 0.02681742f, -0.01742546f, 0.01434802f, -0.05363972f, 0.02449397f, 
    0.03041615f, 0.03755825f, -0.04350007f, -0.01699624f, -0.01812024f, 0.00007045f, -0.01806754f, 0.02208876f, 
    -0.03675588f, -0.03451820f, -0.00061010f, 0.02724766f, -0.02619430f, 0.03175702f, 0.00495213f, -0.01375452f, 
    -0.05058426f, -0.00685346f, -0.01881461f, 0.02234243f, 0.03850174f, 0.00250682f, -0.00480797f, -0.00347637f, 
    0.04421578f, 0.01327171f, -0.02846586f, -0.00444421f, -0.00978382f, -0.02935680f, 0.04330820f, -0.03917192f, 
    0.04441484f, -0.03062996f, -0.04836127f, -0.04457170f, -0.04648131f, 0.01070890f, 0.03200733f, -0.01122964f, 
    -0.04719673f, -0.04932220f, -0.05509996f, 0.03297769f, 0.03183109f, 0.01628419f, -0.04415101f, 0.01285036f, 
    -0.00272009f, 0.03402715f, -0.01977121f, -0.03310271f, 0.00586839f, 0.00746255f, -0.00333386f, -0.01131905f, 
    0.02260237f, 0.04730508f, -0.02041328f, 0.04331338f, -0.01099566f, 0.04021097f, 0.02986926f, 0.01878125f, 
    -0.04844379f, -0.03208169f, 0.01876283f, 0.02174977f, -0.00212101f, -0.03280955f, -0.01100072f, 0.00833455f, 
    0.00114657f, -0.03137081f, 0.01905590f, -0.03042996f, -0.03831195f, -0.04376985f, -0.05061473f, -0.00276490f, 
    0.04308864f, 0.02748936f, -0.03707544f, 0.02575486f, 0.02151601f, 0.03557188f, -0.04688082f, 0.02200290f, 
    0.04300670f, 0.00349278f, -0.04218091f, 0.00569094f, -0.01575335f, -0.00546077f, -0.00693607f, 0.01599146f, 
    -0.00484991f, -0.02618383f, -0.00940499f, -0.00517066f, -0.03971636f, 0.04560746f, -0.02525619f, 0.00966059f, 
    0.03947247f, -0.04351883f, 0.02984482f, -0.04040583f, -0.04549989f, 0.01284713f, 0.01516940f, 0.04008828f, 
    -0.01470780f, -0.01781300f, 0.01047937f, -0.00436685f, -0.04901177f, -0.02907516f, 0.01086407f, 0.02848887f, 
    0.00094353f, 0.04702213f, -0.03730787f, 0.00868740f, 0.01697662f, 0.01547773f, -0.04554935f, -0.02074644f, 
    0.02690711f, 0.02123968f, 0.01917779f, 0.01064924f, 0.04025627f, -0.02195944f, -0.01071576f, -0.04228757f, 
    0.03639210f, 0.02281149f, -0.05074278f, 0.00021967f, -0.03477647f, -0.04331984f, -0.01399172f, -0.02812604f, 
    0.00290339f, 0.03164563f, -0.00538262f, -0.05510259f, -0.04983037f, -0.05668042f, -0.05415278f, 0.02950712f, 
    0.01232188f, -0.01430839f, 0.02128583f, -0.01245595f, 0.02308293f, -0.03862778f, -0.00543469f, -0.02864039f, 
    -0.03812999f, -0.05526016f, 0.01612301f, -0.03525238f, -0.02055962f, -0.01628598f, -0.05185832f, -0.02719441f, 
    -0.03174456f, -0.00462020f, 0.00598202f, 0.00623414f, -0.04482077f, -0.03599096f, 0.03933656f, 0.03579102f, 
    0.02323420f, -0.01427769f, -0.00940560f, 0.04072877f, -0.05245023f, 0.03350012f, -0.04437322f, 0.01454688f, 
    -0.03497417f, 0.02891419f, -0.02050942f, -0.04306803f, -0.00543387f, -0.00257337f, 0.02212785f, 0.02553266f, 
    -0.02145856f, 0.02130979f, -0.00157416f, 0.02457136f, -0.00641260f, 0.00244408f, 0.02941122f, 0.03414613f, 
    -0.03690540f, 0.00753294f, -0.03940899f, -0.01371939f, -0.01107012f, 0.04582770f, 0.01328183f, -0.03306174f, 
    0.01240138f, -0.03354089f, -0.05413651f, 0.03826192f, 0.02020988f, 0.02498111f, -0.03730305f, -0.05787907f, 
    0.02180207f, -0.03517264f, -0.01049934f, 0.03412139f, -0.04608042f, -0.01809737f, -0.04546809f, -0.03653744f, 
    -0.05168663f, 0.04145399f, 0.03202905f, -0.03377374f, 0.01213589f, -0.04761333f, -0.05801672f, 0.00810620f, 
    -0.00340967f, 0.03707092f, 0.02607877f, -0.01806687f, -0.03271181f, 0.02234919f, -0.05835508f, 0.04490317f, 
    0.02123518f, -0.00018328f, -0.02811120f, -0.05038430f, -0.05718323f, 0.02062502f, 0.01365219f, 0.03945359f, 
    0.03720549f, 0.02715177f, -0.05542773f, -0.02555914f, 0.02848807f, -0.00445573f, -0.02887067f, 0.00376351f, 
    -0.03570918f, -0.01303393f, -0.01555461f, -0.00794177f, 0.01404700f, 0.00454576f, 0.03455456f, 0.02587912f, 
    0.00163842f, -0.03710573f, 0.01562788f, 0.00647568f, -0.01905052f, -0.02755463f, 0.01943515f, 0.03327392f, 
    0.04167371f, -0.00823682f, 0.01968218f, -0.01138305f, -0.02647080f, -0.05293681f, 0.02907806f, -0.05641798f, 
    -0.03394060f, -0.03824509f, -0.00071293f, -0.01902642f, -0.04561925f, -0.01992263f, 0.00336025f, -0.05302917f, 
    -0.01449219f, -0.04232617f, -0.04274780f, -0.01080202f, -0.03202408f, -0.04722052f, -0.01724425f, -0.01354790f, 
    0.00822570f, 0.01235512f, -0.01267418f, 0.03774801f, -0.05525104f, -0.04217518f, 0.02353707f, 0.01640873f, 
    0.02232478f, 0.01164214f, 0.01219584f, 0.04343639f, -0.04842084f, -0.02193134f, -0.02028771f, 0.02361708f, 
    -0.04103131f, 0.02955206f, -0.05433834f, -0.04569384f, 0.03048766f, -0.04486679f, -0.05601010f, 0.01154706f, 
    0.02833137f, 0.03973055f, -0.05710766f, 0.02902424f, -0.03675346f, -0.03894038f, 0.01513253f, -0.02913582f, 
    0.02457910f, -0.02425331f, 0.00373257f, -0.06093347f, -0.01850463f, -0.04105112f, 0.03036450f, -0.01723191f, 
    0.02146943f, -0.00051358f, 0.02114660f, -0.02021231f, -0.00431125f, -0.05541555f, -0.00300810f, -0.00976558f, 
    0.03435785f, 0.04140417f, -0.02499354f, 0.01667748f, 0.02022218f, 0.01324544f, -0.02960472f, -0.00281610f, 
    -0.04740831f, -0.00080452f, -0.05351748f, -0.01524110f, -0.02624704f, -0.02319510f, -0.03978758f, -0.00285918f, 
    -0.01560622f, -0.02640823f, -0.02127049f, 0.00290596f, -0.05111167f, 0.04437930f, 0.04266011f, -0.00531889f, 
    0.01654361f, 0.02597718f, 0.00861787f, -0.01140133f, 0.00512533f, -0.04541504f, -0.01948613f, -0.04949560f, 
    0.04032866f, -0.03595857f, -0.02829426f, -0.05412398f, 0.01478345f, -0.04374609f, 0.03918939f, -0.03019653f, 
    -0.05596941f, -0.05166508f, 0.02785727f, -0.05739237f, -0.00617093f, -0.03724251f, -0.01423645f, 0.00288605f, 
    0.03567505f, 0.01928403f, -0.05396426f, -0.02304524f, 0.01472542f, -0.01250324f, 0.02611608f, -0.01917433f, 
    -0.03250425f, 0.00222654f, -0.01954909f, -0.02447105f, 0.02280374f, -0.03486074f, 0.01495403f, -0.01077974f, 
    -0.04260853f, 0.01518738f, -0.04716595f, -0.05049868f, 0.01465869f, 0.00208772f, -0.02190791f, 0.02258025f, 
    0.00202281f, -0.00127322f, -0.01690359f, -0.05587355f, -0.01005832f, -0.04836778f, 0.01364633f, 0.03736551f, 
    -0.00348712f, 0.00508127f, -0.01824059f, -0.05069431f, -0.01100401f, -0.03387797f, -0.02356252f, -0.03713578f, 
    0.03814317f, -0.01341757f, -0.00217924f, -0.00227606f, -0.04749055f, -0.05769802f, -0.02173430f, -0.01785975f, 
    0.01618749f, -0.05626890f, -0.04520105f, -0.02940669f, 0.00811684f, -0.03096813f, -0.03026208f, 0.00126230f, 
    0.03942943f, 0.02451884f, -0.03948901f, 0.04125899f, 0.01657816f, -0.03568555f, -0.02647341f, 0.03769586f, 
    -0.02784462f, 0.00671819f, -0.02685597f, -0.00949079f, 0.00667720f, 0.02053911f, -0.01655588f, -0.01569561f, 
    -0.04914961f, 0.00239999f, 0.03184388f, 0.02607062f, -0.00896952f, -0.01652444f, -0.03896958f, -0.05150301f, 
    0.02507235f, -0.02855251f, -0.03263867f, 0.04221172f, -0.04430675f, 0.01760408f, 0.03814800f, 0.02356619f, 
    -0.01291791f, -0.01344905f, -0.03564225f, 0.02565908f, -0.04419154f, 0.02633835f, 0.04018044f, 0.01115851f, 
    0.04246872f, -0.01905413f, 0.02915240f, -0.00453354f, 0.01593106f, 0.02608485f, -0.02795609f, -0.05543808f, 
    0.00026000f, -0.05004289f, -0.01513998f, 0.01144917f, -0.02933764f, -0.03858861f, -0.03829363f, 0.03593246f, 
    -0.03121943f, 0.22724532f, -0.27187237f, -0.01409691f, 0.05416079f, -0.13485830f, 0.00585192f, 0.13488859f, 
    0.03037975f, 0.06301116f, 0.05416301f, 0.02870681f, 0.12929001f, 0.02384600f, -0.10625518f, 0.24297112f, 
    -0.04678355f, 0.08435316f, 0.02918540f, 0.01490055f, -0.11217641f, 0.09699806f, -0.13263285f, -0.04695535f, 
    -0.31278649f, -0.09905661f, -0.15361865f, -0.12469731f, -0.02990698f, 0.00317233f, -0.02310609f, -0.07991695f, 
    -0.14205405f, 0.03310828f, 0.12963146f, 0.09435157f, -0.52121127f, -0.35074675f, 0.51659185f, 0.08099109f, 
    0.05372288f, 0.11467290f, -0.23619318f, 0.02275266f, 0.05530795f, 0.14899962f, 0.10899036f, -0.06105080f, 
    -0.23837632f, -0.11379515f, 0.32318705f, 0.05592385f, -0.13030359f, 0.00962125f, -0.02310915f, -0.05081601f, 
    0.16480285f, 0.18386661f, -0.02801274f, 0.10159791f, -0.08684397f, 0.42516172f, -0.30843130f, 0.56961614f, 
    -0.06763577f, 0.10343920f, 0.19196530f, 0.01318799f, 0.05741524f, 0.06294128f, 0.21303989f, -0.00928245f, 
    0.18206757f, -0.02166012f, 0.42623270f, -0.14884304f, 0.05212649f, -0.09540719f, -0.04440995f, 0.22129431f, 
    -0.11150220f, 0.00226726f, -0.13360327f, -0.11979043f, -0.16676100f, -0.06416792f, 0.34355032f, -0.07383403f, 
    -0.05425495f, -0.09405707f, -0.08765174f, -0.03203228f, 0.07397630f, -0.09856091f, 0.04412272f, -0.03960984f, 
    -0.04899023f, 0.00114074f, -0.14998148f, -0.12706399f, 0.04979947f, -0.06449331f, -0.07633481f, -0.01008986f, 
    -0.04680746f, -0.06956612f, -0.05394804f, -0.03364925f, 0.19985825f, 0.28019339f, 0.01447166f, 0.17374757f, 
    -0.04170404f, 0.06818193f, 0.07498191f, -0.07159825f, -0.00719800f, 0.10844420f, 0.05005393f, 0.09011964f, 
    -0.24779375f, -0.02412638f, 0.08576965f, -0.08342906f, -0.00004309f, 0.08003057f, 0.12591240f, 0.01053221f, 
    0.03443910f, 0.04360674f, 0.05271984f, 0.25347012f, -0.18148458f, -0.06117994f, 0.06236356f, -0.00977898f, 
    -0.21124773f, -0.01978513f, -0.08127511f, 0.05120042f, 0.07266866f, -0.07190340f, 0.04541748f, -0.12398378f, 
    0.31180376f, 0.26989421f, 0.15260245f, -0.13497353f, -0.02898420f, 0.02492886f, -0.00200672f, -0.06290619f, 
    0.00892639f, 0.12947701f, -0.04054021f, 0.07442287f, -0.12190474f, -0.05704387f, 0.00251609f, -0.14643194f, 
    -0.15240209f, -0.12202041f, -0.12970886f, -0.06273952f, -0.03745445f, 0.00980966f, 0.13682276f, -0.11941446f, 
    0.00152480f, 0.09596397f, 0.02850434f, -0.03008487f, -0.08157001f, -0.17937441f, -0.17986175f, -0.15147981f, 
    -0.01488658f, 0.02033214f, -0.09156150f, -0.21828465f, -0.09782257f, 0.37109190f, -0.22046331f, 0.04179462f, 
    0.11815440f, 0.05967415f, 0.13918132f, 0.12451878f, 0.04992989f, 0.04616050f, 0.17135648f, 0.07968378f, 
    0.00067667f, -0.14397390f, -0.13090657f, 0.21357042f, -0.17111325f, -0.02242402f, 0.05440607f, 0.02318045f, 
    -0.07168544f, 0.16367616f, 0.06825545f, 0.14051232f, -0.26392147f, -0.34465849f, 0.00115688f, -0.02688480f, 
    -0.01891937f, 0.07315255f, 0.08864019f, 0.04946848f, 0.03952614f, 0.00198436f, 0.11434025f, 0.04491873f, 
    -0.19480133f, -0.04164200f, -0.11666305f, -0.06679426f, -0.17052323f, -0.13560461f, -0.11542071f, -0.08263297f, 
    0.01612189f, 0.02509774f, 0.20107979f, 0.04175876f, 0.30830485f, 0.15520142f, 0.10667175f, 0.19666326f, 
    0.05211986f, 0.09668415f, 0.07963177f, 0.11791419f, -0.06494607f, 0.01844341f, 0.08335562f, 0.00326547f, 
    -0.05005018f, 0.10628564f, 0.21591368f, 0.17511739f, 0.04060786f, 0.18332066f, -0.03864551f, -0.06680374f, 
    -0.00105618f, 0.04378548f, 0.06353960f, -0.13543615f, 0.12849629f, 0.30714336f, 0.22527905f, -0.09806403f, 
    0.00343309f, -0.17746532f, 0.02740703f, 0.10869417f, -0.03604008f, -0.00670047f, -0.04180403f, -0.04581209f, 
    -0.19834937f, -0.06860094f, -0.42803475f, -0.11571719f, 0.02785263f, 0.02253762f, 0.11163896f, 0.12286191f, 
    -0.12982585f, 0.02404874f, -0.04879173f, 0.07640696f, 0.08397296f, 0.32460478f, 0.22171125f, -0.15933706f, 
    -0.02605634f, -0.13461350f, -0.19480485f, 0.05898585f, -0.25259417f, -0.01241482f, -0.02730335f, 0.03660269f, 
    -0.03621327f, -0.12973417f, -0.24829377f, -0.06326997f, -0.01078575f, -0.04185917f, 0.12629658f, -0.12052985f, 
    -0.09307715f, -0.06148099f, -0.01379334f, -0.12511221f, 0.27134433f, 0.02989441f, -0.13313885f, 0.09384895f, 
    0.15502641f, 0.13744538f, -0.07549592f, -0.01278692f, 0.02461449f, -0.02299261f, 0.09035682f, -0.06022452f, 
    -0.05504988f, -0.19499002f, -0.07145713f, 0.00487241f, -0.04685851f, 0.02046241f, -0.05254683f, 0.14770319f, 
    -0.01667238f, 0.17289166f, 0.16686192f, 0.10641330f, -0.06858877f, -0.25381336f, -0.08204694f, 0.12524875f, 
    0.02942318f, 0.06504849f, -0.00654471f, 0.09463025f, -0.14321803f, 0.03317962f, 0.06684238f, 0.01994197f, 
    -0.00576348f, 0.07250281f, 0.12150341f, 0.10397536f, -0.23849478f, -0.01976352f, -0.15176381f, -0.01159943f, 
    -0.13058770f, 0.07715108f, 0.01862254f, 0.10655417f, 0.08074238f, 0.31159613f, -0.20869385f, 0.03050712f, 
    0.19707666f, -0.08993229f, 0.03417319f, 0.03303319f, 0.02842454f, -0.29050940f, 0.23933704f, -0.20195034f, 
    0.08660002f, 0.35865182f, -0.08240374f, 0.05028167f, -0.09296107f, -0.14178291f, -0.02354063f, -0.02754239f, 
    0.01781798f, 0.04807669f, 0.11417960f, 0.02887248f, 0.05162052f, 0.31131184f, -0.19693434f, 0.08280683f, 
    0.08242556f, 0.13517082f, -0.01887098f, 0.13250078f, 0.15021497f, 0.21595187f, 0.09607531f, 0.09729552f, 
    -0.27329305f, -0.11126641f, -0.08972884f, 0.23812716f, -0.04089764f, 0.07963791f, 0.01318709f, -0.07704875f, 
    -0.00430569f, 0.07602745f, 0.01815957f, 0.05760258f, -0.10365157f, 0.12102918f, 0.24940215f, 0.01893270f, 
    -0.01963381f, -0.20283610f, 0.12715182f, 0.10772474f, 0.17103688f, 0.07547104f, 0.09021100f, 0.13622706f, 
    -0.05273135f, -0.00692495f, -0.07137582f, 0.04472395f, 0.08974019f, -0.02944048f, 0.01674329f, -0.08619180f, 
    -0.14514862f, -0.11564686f, -0.07509731f, -0.11634730f, 0.31668025f, 0.01113771f, 0.22407943f, 0.01487635f, 
    0.07019088f, -0.02570301f, 0.04322980f, 0.04767770f, -0.02348511f, 0.03821738f, 0.09199841f, 0.00539646f, 
    0.19367620f, 0.05883433f, 0.03482535f, -0.16399865f, 0.00147917f, 0.01212201f, 0.06823811f, 0.00847153f, 
    0.03515720f, 0.02974856f, 0.00617645f, 0.05431932f, -0.27671313f, 0.22893712f, -0.03123905f, 0.27135465f, 
    0.05937545f, 0.05141012f, -0.17006476f, 0.19839230f, -0.04985503f, -0.02235708f, -0.09741481f, -0.09781494f, 
    0.46236604f, -0.18092294f, -0.17388104f, 0.01071011f, 0.08160947f, -0.05489805f, 0.11656469f, -0.18815951f, 
    0.04458570f, 0.16304642f, 0.16447192f, 0.09377690f, 0.18343395f, -0.35780200f, 0.14004645f, 0.10647254f, 
    -0.04272446f, -0.00655770f, 0.04499773f, -0.02367474f, -0.07491628f, 0.04342979f, 0.03145069f, -0.05780780f, 
    -0.33440405f, -0.12231752f, 0.01653999f, 0.09048540f, -0.12034655f, -0.10831640f, 0.03615885f, 0.00049200f, 
    0.05317260f, 0.01211665f, -0.00089517f, -0.00949121f, -0.36619222f, 0.61880845f, 0.30852196f, -0.02798723f, 
    -0.01135877f, -0.06418327f, -0.10767802f, 0.05680901f, -0.14213283f, -0.03360904f, -0.02174999f, 0.06729055f, 
    0.02560236f, 0.00176451f, 0.33389932f, 0.12886694f, -0.07451569f, -0.00944837f, -0.07215839f, 0.15263613f, 
    0.00098862f, -0.02128571f, -0.01626023f, -0.02671444f, 0.01391888f, -0.01067131f, -0.10328371f, -0.06532232f, 
    0.06001091f, 0.08666987f, 0.12943611f, 0.09151519f, 0.06705292f, 0.05343664f, -0.08551707f, 0.05050818f, 
    -0.14096481f, -0.10470048f, -0.27244985f, 0.17239864f, 0.14202599f, 0.04146948f, -0.02262349f, -0.09757225f, 
    0.00164142f, 0.03992213f, 0.04816163f, 0.01982482f, 0.03105074f, -0.14092666f, -0.11310238f, -0.09315953f, 
    0.05272265f, 0.02354769f, -0.02093389f, 0.07509860f, 0.08011481f, 0.01670830f, -0.06458863f, -0.07238702f, 
    -0.09973432f, 0.02811563f, -0.11558221f, 0.06711615f, 0.00837316f, 0.07897484f, 0.01836209f, 0.01131576f, 
    0.21417886f, 0.21520448f, -0.03690470f, 0.13910036f, -0.28627712f, -0.04785692f, 0.15725513f, 0.26260591f, 
    0.24601911f, 0.04632036f, -0.05279722f, 0.00366188f, -0.08066226f, 0.07010756f, 0.17016762f, -0.08987568f, 
    0.02942246f, -0.08976942f, -0.02445005f, -0.02416785f, -0.00231026f, 0.04195321f, 0.07227682f, -0.09240972f, 
    0.13503861f, -0.02819132f, -0.01512766f, 0.09742293f, -0.08121174f, -0.06909396f, 0.19904977f, -0.05907614f, 
    -0.07317651f, -0.04287465f, -0.07505299f, -0.06727968f, -0.06479364f, -0.10679310f, -0.04681008f, -0.06554073f, 
    -0.05613636f, -0.01311362f, 0.05327465f, 0.05582252f, 0.09445694f, -0.00490558f, -0.02236505f, 0.07236122f, 
    0.02162505f, 0.01701757f, -0.03408711f, -0.04172229f, -0.21638435f, 0.01638713f, 0.27372813f, 0.13276577f, 
    -0.09934163f, -0.09817377f, -0.06459866f, 0.01452201f, 0.03804231f, 0.05752261f, 0.10182393f, -0.05726721f, 
    -0.12118954f, 0.27555040f, 0.18125100f, 0.03225853f, -0.14882483f, 0.01595689f, 0.08548504f, 0.17271264f, 
    -0.08436158f, 0.12725864f, 0.10983939f, 0.15873446f, 0.28030181f, 0.13942048f, -0.14469482f, 0.32134759f, 
    0.09779846f, 0.09503465f, 0.07590096f, 0.02316992f, 0.02436499f, 0.01502292f, 0.02599245f, 0.06541834f, 
    -0.29090002f, -0.06875712f, 0.18595915f, 0.23176302f, 0.09422619f, -0.16622542f, -0.01893596f, 0.06603064f, 
    0.08581361f, 0.08167857f, 0.10507064f, -0.04039747f, 0.01142552f, 0.02715660f, -0.09441596f, 0.07870525f, 
    -0.05331172f, 0.05502060f, 0.08465111f, 0.05325362f, -0.00756976f, 0.02937174f, 0.06216752f, -0.05003894f, 
    -0.31493494f, -0.26385739f, 0.00324631f, 0.11065606f, -0.02555015f, 0.06083628f, -0.02196511f, -0.01543707f, 
    0.02279068f, 0.10213775f, 0.08860333f, 0.07314216f, -0.02474056f, 0.26511282f, 0.12031448f, 0.10004720f, 
    -0.06479264f, 0.03338099f, -0.09505454f, 0.06018225f, 0.04085475f, 0.11044038f, 0.08814678f, -0.02608157f, 
    -0.02734330f, 0.01023730f, -0.07558381f, -0.08111016f, 0.06739762f, -0.03418267f, 0.08107039f, -0.03423537f, 
    -0.01095150f, -0.05738714f, -0.07353742f, -0.09321172f, 0.13320927f, 0.41428268f, 0.33422658f, 0.21183158f, 
    -0.05167459f, -0.12866454f, 0.02828498f, -0.09132942f, -0.07221097f, 0.01701417f, 0.09461039f, 0.04650116f, 
    0.02909641f, -0.09825143f, 0.00350673f, -0.03781657f, 0.00300381f, -0.01517866f, 0.02948710f, 0.05408020f, 
    -0.06584385f, 0.01160777f, 0.05648730f, -0.09930321f, -0.47504088f, 0.04821315f, 0.10303280f, 0.51020688f, 
    0.11339103f, 0.08763468f, 0.02586410f, -0.09578954f, 0.02664271f, -0.00122427f, 0.12184555f, 0.18365818f, 
    0.07421152f, -0.01425880f, -0.03886452f, 0.05171059f, -0.07090428f, 0.13793547f, 0.04959431f, 0.14077538f, 
    -0.02907482f, -0.02433238f, -0.05825403f, -0.06737132f, -0.28965223f, -0.00115786f, -0.10680249f, 0.23421849f, 
    0.02531490f, 0.07725128f, 0.09598912f, 0.03789001f, -0.05516692f, -0.01990880f, -0.07917039f, 0.01992341f, 
    -0.19253813f, -0.06984985f, -0.28896794f, 0.23051992f, -0.10961881f, -0.11227082f, -0.04638803f, -0.05475275f, 
    -0.03442807f, 0.01408294f, 0.07716898f, 0.04693577f, 0.17400333f, -0.03193575f, 0.03073224f, 0.15363783f, 
    -0.07898697f, 0.08172137f, -0.03052233f, -0.08302429f, -0.00524577f, 0.18611966f, 0.03112397f, 0.06474068f, 
    -0.12664706f, 0.07627265f, 0.00469804f, -0.03810574f, 0.23533475f, 0.02478172f, -0.01714387f, -0.08276860f, 
    -0.25063837f, -0.11650549f, -0.06162935f, 0.08654667f, 0.22077440f, -0.10032908f, 0.40231806f, 0.30764663f, 
    -0.12046918f, -0.04963180f, 0.12301571f, -0.17024882f, -0.02428812f, 0.11749013f, 0.05593848f, -0.00660663f, 
    0.26476958f, -0.00372578f, 0.33599931f, 0.09957398f, -0.05146209f, -0.10474962f, 0.06224009f, 0.10739326f, 
    -0.17907658f, 0.09585800f, 0.01852206f, 0.00345611f, -0.19816387f, 0.34096459f, -0.19723913f, 0.45630726f, 
    -0.10540827f, 0.07838950f, 0.01942688f, 0.16543886f, -0.03065596f, -0.04703403f, 0.01979938f, 0.13788114f, 
    0.45913330f, -0.13085762f, -0.04548268f, -0.09173755f, -0.06979552f, 0.10679682f, 0.19197458f, -0.04651704f, 
    0.09826666f, 0.12158914f, 0.18642388f, 0.18413335f, 0.00721426f, -0.29163668f, -0.03847612f, 0.18733640f, 
    -0.21462190f, -0.09509406f, -0.10563307f, -0.18416272f, -0.04935645f, 0.02172069f, -0.08219182f, -0.05340345f, 
    0.00920579f, -0.08760440f, -0.09047336f, -0.08525224f, -0.07743644f, -0.16621760f, -0.00025296f, 0.11824129f, 
    -0.01375852f, -0.02500160f, -0.09623282f, -0.09779964f, 0.36475322f, 0.12313025f, -0.11643927f, 0.26468208f, 
    0.04580061f, 0.00011777f, 0.10440485f, 0.02366532f, -0.04842807f, 0.05077281f, 0.17009173f, 0.21253768f, 
    0.00763704f, 0.31197789f, 0.14539257f, 0.13926893f, 0.07901403f, -0.08888055f, -0.03779857f, 0.06064165f, 
    0.00629208f, -0.06751193f, 0.09981564f, -0.02252733f, 0.20410565f, 0.03135137f, 0.15007341f, 0.02399939f, 
    -0.14154671f, -0.09512080f, 0.19848712f, 0.07562288f, 0.07548980f, -0.04879267f, -0.09817557f, 0.04633780f, 
    0.09330822f, 0.09760473f, -0.18816535f, 0.02998352f, -0.08748360f, 0.06601492f, 0.09999429f, -0.18877578f, 
    0.11631556f, 0.00580364f, -0.03008153f, -0.10279097f, 0.01030179f, -0.04665143f, 0.04415439f, -0.17559779f, 
    0.08220959f, 0.04277017f, 0.01399419f, 0.07328806f, 0.06532680f, 0.15668182f, 0.03548170f, -0.03763550f, 
    0.03309053f, 0.02645923f, 0.03379500f, -0.12266727f, -0.16065171f, -0.04091483f, 0.03702122f, -0.00041224f, 
    0.17747851f, 0.20732285f, 0.08330846f, 0.00506321f, -0.19997993f, 0.04044255f, -0.03139527f, 0.22864908f, 
    0.23352972f, 0.00499480f, 0.09307852f, 0.01048562f, -0.07131752f, 0.03694682f, 0.04015036f, -0.00403470f, 
    -0.07434605f, 0.09372080f, 0.04075386f, -0.00104669f, 0.01024681f, 0.10123516f, 0.16128457f, -0.11704070f, 
    -0.09175345f, 0.12547025f, -0.14021826f, -0.02824659f, 0.11665551f, -0.05989722f, 0.10099640f, 0.05034449f, 
    0.01553167f, 0.04031441f, 0.11575700f, 0.13189392f, -0.02682400f, 0.00068361f, -0.11459708f, -0.01232285f, 
    -0.06534410f, 0.01366626f, -0.06548803f, 0.02861940f, -0.01943081f, -0.01656404f, 0.04498447f, -0.03003138f, 
    0.13291650f, 0.13575236f, 0.04650147f, -0.03749554f, 0.24160220f, -0.21873279f, 0.01779991f, 0.02009968f, 
    0.06931498f, 0.04566937f, -0.04519192f, -0.00711624f, -0.01191497f, 0.06697030f, 0.06529947f, 0.08826099f, 
    -0.09012070f, 0.27751186f, -0.09080578f, 0.12011688f, -0.01764054f, 0.01734367f, -0.00542363f, 0.07485634f, 
    -0.03982517f, 0.07391956f, 0.09361594f, 0.04914779f, 0.14047363f, 0.24810131f, -0.10474773f, -0.08985698f, 
    -0.12558326f, 0.05227841f, 0.04814227f, -0.03880835f, 0.06036474f, -0.00591636f, 0.03031022f, 0.01795827f, 
    -0.40075612f, -0.07103476f, -0.11691502f, 0.08850358f, 0.16581117f, -0.01859470f, 0.09932814f, 0.11876875f, 
    -0.00297855f, 0.29562500f, -0.08527822f, -0.12200852f, 0.42388803f, 0.16384672f, -0.12601475f, -0.20288391f, 
    -0.09487364f, 0.07602378f, 0.11853243f, 0.04355292f, -0.04355213f, -0.02676503f, 0.10183337f, -0.17308368f, 
    0.04809918f, -0.18682790f, -0.21240208f, 0.09657805f, 0.00876701f, 0.06567941f, 0.11185108f, -0.06351009f, 
    -0.10233568f, 0.01401955f, 0.07723741f, 0.07854438f, -0.05171333f, 0.10539680f, 0.13302882f, -0.27018651f, 
    -0.08162037f, -0.15750757f, 0.12498379f, -0.08128422f, 0.03771313f, 0.03717847f, -0.08004284f, -0.15955029f, 
    0.06949269f, -0.08701208f, 0.04216061f, 0.14510772f, 0.04788155f, -0.12623844f, -0.04349838f, 0.02518173f, 
    -0.12650810f, 0.02858301f, -0.00251512f, -0.06197735f, 0.01598454f, 0.06202899f, 0.03340536f, -0.10422918f, 
    -0.04744295f, -0.03193181f, 0.06021157f, -0.10463259f, -0.10513192f, 0.02474624f, 0.00691221f, -0.07323451f, 
    0.07373652f, 0.07054403f, 0.18316974f, -0.12535362f, -0.01035026f, -0.04560527f, 0.03613704f, 0.07165109f, 
    -0.12996729f, 0.17157631f, -0.03468778f, -0.04366951f, -0.18004575f, 0.03133800f, -0.09792998f, 0.08375437f, 
    -0.07569940f, 0.02356046f, 0.13261272f, -0.03128310f, 0.05859016f, 0.00270365f, 0.15675037f, 0.22433650f, 
    0.21588887f, 0.13202496f, -0.09284180f, 0.03415408f, 0.02900323f, 0.03373488f, -0.10610580f, 0.13085748f, 
    -0.01944018f, 0.02069157f, 0.00080152f, 0.02188090f, -0.10620935f, 0.15826309f, -0.09264430f, 0.05347809f, 
    0.10594928f, 0.00681526f, 0.08640381f, 0.07287441f, -0.05502095f, -0.01135239f, 0.11680301f, -0.09529223f, 
    0.27386555f, 0.11295003f, 0.24845889f, -0.09151271f, 0.02821221f, 0.14716434f, -0.03401427f, 0.09988457f, 
    -0.05494350f, 0.01255227f, -0.05248131f, -0.05415405f, -0.04633904f, 0.01672745f, 0.03828650f, -0.01883393f, 
    0.06153021f, -0.00907097f, 0.05873374f, 0.07088326f, 0.09001289f, 0.10785276f, 0.09830658f, 0.19374397f, 
    0.08282897f, -0.10750184f, 0.17037104f, 0.05255581f, 0.08300626f, 0.13083003f, -0.12861583f, -0.19159357f, 
    -0.07127316f, -0.05619401f, -0.32291305f, -0.22488786f, -0.43836498f, 0.34625813f, -0.13786300f, 0.05363134f, 
    -0.19727486f, 0.01930325f, 0.06496831f, 0.22019337f, -0.06500804f, 0.01710298f, 0.12107373f, -0.02341207f, 
    -0.44487089f, 0.12333991f, -0.46637267f, -0.12747493f, 0.18232405f, 0.20373538f, 0.03510157f, -0.04356344f, 
    -0.01841329f, -0.02032262f, 0.11524338f, -0.02282658f, 0.26064324f, -0.30468893f, 0.06228977f, -0.52621120f, 
    0.16850302f, 0.02692726f, 0.04655829f, -0.07386442f, -0.12555553f, -0.07117467f, -0.27356917f, -0.01279812f, 
    0.00913957f, 0.21140602f, -0.25489023f, 0.28913558f, -0.13594127f, -0.03785416f, 0.15407588f, -0.14315864f, 
    0.18630016f, -0.01532785f, 0.15970311f, 0.06930371f, -0.01275428f, 0.05086030f, -0.15074737f, 0.40915784f, 
    -0.04622573f, 0.10070293f, 0.03766586f, 0.13691530f, -0.12800650f, -0.04441815f, -0.03731647f, -0.22288975f, 
    0.20386285f, 0.00595820f, 0.07275397f, -0.05950987f, 0.21255134f, -0.01481899f, 0.09546612f, 0.21057318f, 
    0.03945041f, 0.07128709f, 0.13336474f, 0.04691328f, -0.35710922f, -0.06094334f, 0.38209110f, 0.04246354f, 
    -0.01527093f, -0.10436781f, -0.12016705f, -0.06484047f, -0.05071369f, 0.09904431f, -0.03763204f, 0.02423425f, 
    0.07461909f, 0.04029486f, 0.10265484f, 0.16351712f, 0.04125286f, -0.04940134f, -0.25785476f, -0.11396400f, 
    0.02946582f, -0.07018070f, -0.09566358f, -0.13204250f, -0.65385169f, 0.03853992f, -0.03180308f, 0.00468647f, 
    0.03359936f, 0.05485607f, 0.16241890f, 0.31148833f, 0.04454185f, 0.21679246f, -0.16295825f, 0.01883006f, 
    -0.04887795f, 0.09554131f, -0.24194065f, -0.05197198f, -0.18459210f, -0.03452820f, 0.11088227f, -0.11556139f, 
    0.02907095f, -0.15832701f, 0.13823165f, -0.04178832f, -0.26570994f, -0.13416605f, -0.14513412f, 0.24290811f, 
    0.22156233f, -0.07999586f, 0.05570762f, 0.05453200f, 0.05490424f, 0.09640157f, -0.04148137f, 0.06418535f, 
    -0.16815500f, -0.40730545f, -0.08405651f, 0.13069610f, 0.05685450f, 0.12665284f, 0.04371270f, -0.01318224f, 
    0.19852701f, 0.05769343f, 0.09640430f, 0.23743898f, 0.15376632f, 0.30322546f, -0.14155768f, -0.01387237f, 
    -0.04383773f, 0.17804810f, -0.12724692f, -0.02191490f, -0.14428096f, -0.03295740f, -0.13089769f, 0.00606041f, 
    -0.10993509f, 0.11107641f, 0.02452292f, -0.14174409f, -0.11798735f, -0.02412758f, -0.11455755f, 0.00262711f, 
    0.23416367f, 0.00416643f, 0.15462719f, 0.06935923f, 0.11860608f, 0.29884580f, -0.16867976f, 0.11459265f, 
    0.09752504f, -0.10008371f, -0.05688943f, 0.01242071f, -0.04128360f, -0.13459009f, -0.07747281f, -0.19814529f, 
    0.07692485f, -0.16430290f, 0.05038769f, 0.05383151f, 0.11158498f, -0.00931758f, -0.03050159f, 0.04931087f, 
    -0.01180031f, -0.02599127f, -0.00636503f, 0.02764311f, 0.09930396f, -0.11779075f, -0.10205611f, 0.00257093f, 
    -0.03453592f, 0.08639368f, 0.07227936f, 0.16083841f, 0.07790444f, -0.01197628f, 0.06613286f, 0.04074850f, 
    -0.08025374f, -0.26563492f, 0.03088265f, 0.07152183f, 0.18667211f, -0.20228870f, 0.08447577f, 0.01063397f, 
    0.09168348f, 0.10776470f, 0.07678363f, 0.18990104f, 0.18402651f, -0.06817476f, 0.28288445f, 0.28595245f, 
    0.09434918f, 0.10617735f, 0.04164143f, 0.09486379f, -0.10060699f, -0.17684415f, -0.12568821f, 0.13625711f, 
    0.52482283f, 0.01620545f, 0.36768046f, 0.04668081f, 0.23559554f, -0.04237648f, -0.11819325f, -0.10184076f, 
    0.11385976f, -0.05760631f, -0.04328037f, -0.05964427f, -0.27216023f, 0.07179690f, -0.26494992f, 0.22095150f, 
    0.18950385f, 0.18107817f, 0.03196985f, -0.30045149f, 0.04861497f, -0.08688059f, -0.03817611f, -0.00997177f, 
    0.18047525f, 0.10226420f, 0.10964511f, -0.04365152f, 0.15008062f, 0.07007384f, 0.05701322f, 0.27666473f, 
    0.14062363f, 0.04671873f, 0.06264479f, 0.05993972f, 0.11281689f, -0.07929959f, 0.07286974f, 0.03740696f, 
    0.22297384f, -0.07644337f, -0.10127853f, 0.14942868f, -0.01888674f, 0.03625261f, 0.06249101f, 0.00641627f, 
    0.04109642f, 0.02416787f, -0.11114342f, -0.00809778f, 0.14576416f, 0.13189760f, -0.00333416f, 0.03665863f, 
    -0.01058123f, -0.11013469f, -0.13779294f, -0.16599406f, -0.12263827f, 0.27626407f, 0.06060041f, 0.23898718f, 
    -0.09911305f, -0.08268588f, -0.05842404f, -0.08528064f, 0.14104088f, 0.02342697f, -0.00786636f, 0.14621778f, 
    -0.21456236f, -0.08064266f, -0.16016679f, 0.25268513f, 0.34901020f, -0.06507701f, -0.25229171f, -0.11898690f, 
    0.16315827f, -0.18456747f, 0.01575434f, -0.00328463f, -0.08571889f, -0.01450418f, 0.25541434f, -0.05017529f, 
    -0.01598116f, -0.05372386f, -0.02693945f, 0.04670312f, 0.03422788f, 0.03742414f, 0.05307706f, 0.01415684f, 
    0.23709241f, -0.45396659f, 0.14867263f, 0.13559560f, 0.36984676f, 0.05912060f, -0.07882025f, 0.09551551f, 
    -0.01235074f, -0.14095145f, -0.19867192f, -0.28654528f, 0.13608159f, -0.22387525f, 0.33558935f, -0.36724338f, 
    0.04633120f, -0.20834200f, 0.13695133f, -0.17003658f, 0.01847865f, -0.13732211f, -0.07857589f, 0.02313577f, 
    0.23418994f, 0.13912097f, 0.17489725f, -0.15349190f, 0.06043262f, 0.24896306f, 0.06794057f, 0.00322579f, 
    0.04278531f, -0.12011451f, 0.03354506f, 0.01363927f, -0.03547872f, 0.16627394f, -0.00796797f, -0.14685470f, 
    0.05512801f, -0.12300869f, 0.11479512f, 0.17404552f, -0.06663866f, -0.03351255f, 0.10570389f, -0.13272989f, 
    -0.04319678f, -0.06868225f, -0.00522814f, 0.09717535f, -0.16347368f, -0.04789277f, -0.03108345f, -0.03487042f, 
    0.09121746f, 0.14095487f, 0.00817567f, -0.02492048f, -0.00521920f, 0.01610603f, -0.68979388f, 0.17059708f, 
    -0.03284947f, 0.05175092f, 0.17145029f, 0.13009049f, -0.04511965f, -0.15769833f, 0.08857945f, 0.06691652f, 
    0.00411889f, -0.25710616f, -0.23054692f, 0.04053997f, 0.14352183f, 0.06138069f, -0.02780782f, 0.00151386f, 
    0.11633457f, 0.02465636f, -0.06674624f, 0.17360733f, 0.16793272f, -0.07751814f, 0.17489944f, -0.27015379f, 
    0.25440824f, 0.16703849f, -0.04036425f, 0.21273027f, -0.00270028f, 0.04494142f, -0.03393605f, 0.00421465f, 
    -0.25753284f, 0.17238897f, -0.20376237f, 0.22642256f, -0.04739433f, -0.11931544f, 0.03131150f, 0.07954675f, 
    -0.01584336f, -0.02422431f, -0.19120240f, -0.13935532f, 0.18807879f, 0.08155278f, -0.33393091f, 0.16434136f, 
    0.04830022f, -0.00685096f, -0.07607682f, 0.11608603f, 0.01620490f, -0.01418417f, -0.00372499f, -0.01132106f, 
    0.19436193f, 0.07780955f, 0.06700915f, -0.07444937f, 0.12295198f, 0.12798770f, 0.05557919f, -0.07510581f, 
    -0.02507998f, 0.03552606f, 0.08825894f, -0.01932707f, -0.33704606f, 0.06713028f, -0.06459785f, -0.04900488f, 
    -0.11174652f, 0.00003441f, -0.18874253f, 0.03319198f, 0.07473612f, 0.09871670f, -0.12180579f, -0.02766857f, 
    -0.08576977f, -0.14382820f, 0.03477665f, -0.00850593f, 0.00266593f, 0.00706482f, -0.15101403f, -0.02370323f, 
    0.13702233f, 0.07321791f, -0.03002449f, 0.04012050f, -0.33769727f, -0.19141753f, -0.09143005f, 0.00889081f, 
    0.12297826f, 0.10985104f, -0.09343425f, 0.18878394f, -0.00664353f, 0.14034669f, 0.05628959f, -0.09930676f, 
    -0.27294901f, 0.09302735f, 0.04869305f, 0.06086717f, 0.04509816f, -0.02563047f, 0.05052489f, 0.22613777f, 
    -0.05408327f, -0.07357094f, 0.21284159f, 0.07549934f, -0.15874135f, -0.09170821f, -0.01168520f, 0.04916439f, 
    -0.07474522f, -0.01765212f, -0.00422704f, 0.05422627f, 0.04036972f, -0.00456120f, -0.02158036f, 0.07508952f, 
    -0.23262633f, -0.21489404f, -0.17571808f, 0.08454837f, 0.00265950f, 0.01619524f, 0.05454342f, 0.02502064f, 
    -0.10223572f, -0.20638064f, -0.00517797f, 0.12273621f, 0.16498911f, 0.05325164f, 0.11171959f, 0.01237031f, 
    -0.15928920f, 0.10105518f, -0.16053988f, -0.03978643f, -0.04183239f, -0.12401737f, 0.01532125f, 0.17767671f, 
    -0.07569756f, 0.00765980f, 0.12527092f, -0.05064813f, -0.05170051f, 0.02561656f, -0.04542858f, 0.05330365f, 
    0.15653054f, -0.12008458f, 0.31019524f, 0.11696722f, 0.25935161f, 0.15868603f, -0.00315104f, -0.05855606f, 
    0.03190507f, 0.04674080f, -0.14521670f, 0.01672907f, -0.03660205f, -0.00344926f, -0.12891871f, -0.05596238f, 
    -0.05929359f, -0.08921592f, -0.00328303f, 0.07067701f, -0.02037946f, -0.01836803f, -0.00819710f, 0.04664878f, 
    0.04720757f, -0.07341831f, 0.07032933f, 0.16172040f, -0.12256007f, -0.00847882f, -0.15707804f, -0.09581500f, 
    0.02386549f, 0.07018057f, 0.01758928f, 0.01524542f, -0.04630259f, -0.10353640f, 0.00148444f, -0.12178129f, 
    0.02731803f, -0.08099481f, 0.00360977f, -0.13597056f, 0.07317644f, -0.06258886f, -0.06578079f, 0.24687570f, 
    0.07604824f, -0.10179444f, -0.03486283f, 0.15890811f, -0.04345435f, -0.31546301f, 0.17812273f, 0.14871331f, 
    0.12311712f, 0.13381396f, 0.07936687f, -0.01259651f, -0.05922884f, -0.03183698f, -0.16013159f, -0.02962510f, 
    0.38823140f, 0.24614245f, 0.26044080f, -0.04981559f, 0.05995221f, 0.05842374f, -0.12623079f, -0.12729590f, 
    -0.13470861f, -0.20191807f, -0.02332193f, -0.05346671f, -0.28712770f, 0.08910257f, -0.19920799f, 0.17199518f, 
    -0.04002929f, 0.13737886f, 0.16743287f, -0.05987402f, -0.07143405f, -0.03537815f, -0.00161030f, 0.08967395f, 
    0.15936923f, 0.17991720f, 0.09393344f, -0.10108061f, 0.07513423f, -0.00529064f, -0.14273876f, 0.10455273f, 
    0.05564689f, -0.03898947f, -0.05311607f, -0.04475461f, 0.15651001f, -0.09694853f, 0.08589440f, 0.04738977f, 
    0.19294803f, 0.05863519f, 0.02312547f, 0.28926402f, -0.06124396f, 0.01548192f, 0.01811865f, 0.05929452f, 
    0.15229659f, 0.10680149f, -0.11405934f, -0.11958806f, 0.07204642f, 0.10164957f, 0.16023856f, -0.07778365f, 
    0.10899679f, 0.03698704f, -0.02256368f, 0.06075409f, -0.12322173f, 0.04178375f, -0.00764215f, -0.05249347f, 
    -0.10332619f, -0.07876331f, -0.01688516f, 0.09390607f, 0.17041118f, -0.00160859f, -0.00993340f, -0.04160450f, 
    -0.17595457f, -0.03823167f, -0.06418570f, 0.18956283f, -0.00534029f, -0.05476891f, -0.05562933f, -0.03133079f, 
    0.16313010f, -0.17650370f, 0.09766658f, 0.06094398f, 0.23368201f, -0.00196973f, 0.21004052f, 0.21965210f, 
    -0.00149302f, -0.04299371f, -0.00075395f, -0.04666241f, 0.04807357f, 0.07655817f, -0.23026943f, -0.04476130f, 
    -0.08366830f, -0.18172021f, 0.09218809f, -0.05811191f, 0.20431814f, 0.17323223f, 0.06782987f, 0.19797547f, 
    0.05369539f, 0.00053289f, -0.03461681f, -0.01153635f, -0.00037215f, 0.10463998f, 0.09925554f, 0.01926316f, 
    0.02346556f, -0.08532549f, 0.16676033f, 0.12017381f, 0.12382498f, -0.09427676f, 0.01791219f, 0.04015116f, 
    -0.04637523f, -0.09621458f, -0.15065236f, -0.05734405f, -0.05009062f, 0.16469927f, 0.14519887f, -0.00420714f, 
    -0.07567380f, 0.01208431f, 0.04531254f, 0.14154178f, -0.07435692f, -0.04013728f, 0.47902650f, -0.08290880f, 
    -0.01066951f, -0.04689744f, -0.02866915f, 0.08797587f, 0.00408864f, 0.03053819f, -0.01556146f, 0.14627352f, 
    -0.00511561f, -0.12848693f, -0.04805374f, -0.02159979f, 0.02969348f, -0.09717229f, -0.07584170f, 0.03634759f, 
    0.00604883f, -0.05595418f, 0.01253471f, 0.06732152f, 0.26843679f, -0.11379767f, -0.33139744f, -0.10198206f, 
    0.19255529f, -0.00377647f, 0.11955639f, 0.04804667f, 0.13572997f, 0.06441968f, -0.00898083f, 0.02824165f, 
    0.39154530f, -0.01883259f, -0.09443992f, -0.12889299f, 0.19769625f, -0.11537753f, -0.02300775f, 0.07232950f, 
    0.11635789f, 0.12510283f, -0.08820739f, 0.08349206f, 0.18775611f, -0.35374659f, 0.28309146f, -0.14133391f, 
    0.23188181f, 0.26244730f, -0.12969309f, 0.00467235f, 0.05518128f, -0.10203999f, 0.00533254f, 0.06005562f, 
    -0.23803909f, 0.04548903f, -0.32158220f, 0.14700799f, 0.03351790f, 0.05140639f, -0.01254727f, -0.04840896f, 
    -0.01127600f, 0.05818610f, 0.00797060f, 0.03561434f, -0.17549486f, -0.01871815f, -0.20785856f, -0.11266666f, 
    0.08456141f, 0.03865680f, 0.13739939f, -0.06361976f, 0.00323847f, -0.01728860f, -0.06611971f, 0.05369874f, 
    -0.25462151f, -0.00737213f, -0.04170793f, -0.10627268f, 0.14352913f, 0.07486428f, 0.09965118f, -0.10940618f, 
    -0.08802138f, 0.03602626f, 0.04286407f, 0.07289414f, 0.15319276f, 0.11526525f, 0.58813953f, 0.00200827f, 
    -0.13319668f, -0.13749719f, -0.19315864f, 0.01305263f, 0.19098611f, 0.12244219f, 0.04189104f, -0.02901749f, 
    0.04759916f, 0.07834625f, 0.42725635f, -0.00714366f, -0.08907723f, -0.07241447f, -0.13348337f, 0.01929849f, 
    0.16579413f, 0.02293140f, 0.05906675f, -0.10302336f, -0.06367262f, -0.28425869f, -0.10020122f, -0.25639626f, 
    0.12511450f, 0.07642427f, -0.05840599f, -0.09647734f, 0.09159284f, -0.23626117f, 0.07653335f, 0.04850886f, 
    -0.07057347f, -0.29397050f, -0.06350280f, -0.06791545f, -0.05302363f, 0.09439669f, -0.00731939f, 0.07745682f, 
    0.07056091f, -0.05014422f, 0.12640171f, -0.10196436f, -0.12786394f, -0.01367093f, -0.06482720f, 0.02788776f, 
    -0.06815653f, -0.09380517f, -0.04412480f, -0.11950739f, 0.10972915f, -0.01877735f, -0.20615278f, 0.05081100f, 
    -0.10222984f, 0.04223105f, -0.07965929f, 0.13726585f, -0.01628967f, -0.02805071f, -0.03910610f, 0.00323737f, 
    0.10810600f, -0.02087510f, -0.00050329f, 0.07680209f, -0.08778368f, -0.29342425f, 0.32815170f, 0.30032650f, 
    -0.04228932f, -0.02165607f, 0.06466500f, -0.01716033f, 0.09043276f, 0.05963355f, 0.08280621f, 0.12987617f, 
    -0.05227841f, -0.14590059f, 0.10376319f, 0.07028635f, 0.10146927f, -0.12002003f, 0.01335275f, -0.09142991f, 
    0.17996645f, -0.00318122f, 0.01872568f, 0.14475341f, 0.08451667f, -0.02822039f, -0.24189946f, -0.31286705f, 
    0.06403103f, 0.00762911f, 0.10310486f, -0.02421867f, 0.07406402f, 0.04953329f, 0.02230135f, 0.02923704f, 
    0.04757918f, -0.10945886f, -0.02597892f, -0.02002768f, -0.01957212f, -0.00527422f, -0.06384183f, -0.01641074f, 
    0.12084305f, 0.01508947f, 0.04672591f, -0.04549443f, -0.38342878f, 0.05963963f, 0.19159922f, 0.03218231f, 
    0.01293887f, 0.00730466f, 0.04033186f, 0.07924982f, 0.01260250f, -0.02808138f, -0.02720959f, -0.10387159f, 
    0.34076178f, 0.36076578f, 0.33048862f, 0.05670517f, -0.07188378f, 0.02908340f, 0.01820202f, 0.22916391f, 
    0.19645420f, 0.03815776f, -0.05407020f, 0.18969949f, -0.20481038f, -0.07936849f, -0.22134148f, 0.19727498f, 
    0.06117290f, 0.05879705f, 0.13746464f, -0.06601014f, -0.03348610f, -0.06382827f, 0.00338465f, 0.03223486f, 
    -0.09629066f, 0.31989726f, 0.21912329f, -0.15655819f, -0.16599274f, -0.11338285f, -0.09213274f, 0.09988719f, 
    -0.07653835f, -0.12045584f, -0.04572213f, 0.11700708f, -0.09863738f, -0.11035528f, -0.28355825f, 0.04862368f, 
    -0.01251559f, -0.02041565f, 0.07302219f, -0.04912018f, 0.05264797f, 0.02978938f, -0.07808144f, -0.06052976f, 
    -0.13375123f, -0.02735966f, -0.16297360f, -0.14663710f, 0.06332503f, 0.11095950f, -0.05819905f, 0.07877729f, 
    -0.04600411f, 0.02054794f, -0.01722598f, 0.04128512f, -0.26455179f, 0.33312979f, 0.06390383f, 0.10320409f, 
    -0.17732061f, -0.01694887f, 0.10661611f, 0.09453955f, 0.06571610f, 0.02601463f, 0.01729894f, 0.14247702f, 
    0.08636650f, -0.33237380f, -0.24477863f, -0.25254408f, 0.23197263f, 0.03966168f, 0.18984087f, 0.15732540f, 
    0.12243216f, 0.01184031f, 0.03348504f, 0.02388300f, 0.25001583f, 0.21518639f, 0.49049577f, 0.00411158f, 
    -0.10330442f, -0.07895797f, -0.05438892f, -0.11066770f, 0.00130040f, 0.15891606f, 0.14149149f, 0.13396235f, 
    -0.19688949f, -0.10791186f, 0.04145093f, -0.03618117f, -0.01121191f, -0.04036311f, 0.01005975f, -0.11978821f, 
    0.08329191f, -0.02718050f, -0.00403763f, -0.00654062f, 0.14315255f, -0.03524724f, 0.15038534f, 0.32482892f, 
    -0.22188783f, 0.09554995f, -0.10813432f, 0.03620626f, 0.15827504f, 0.04429763f, 0.04030377f, 0.05969316f, 
    -0.23079710f, -0.32284269f, -0.10277054f, 0.12880774f, 0.23150530f, 0.11843756f, -0.02689069f, 0.01718474f, 
    -0.02358354f, -0.02434899f, -0.04030181f, -0.02439974f, -0.09353478f, -0.04669241f, -0.00284215f, 0.02302026f, 
    -0.00939830f, -0.06992513f, 0.07559403f, 0.21811251f, 0.00660457f, -0.04666295f, 0.00852804f, 0.19728646f, 
    -0.38322669f, -0.17320956f, 0.12343644f, -0.32299444f, 0.14070550f, 0.18913750f, -0.07059684f, 0.07252568f, 
    -0.04646013f, 0.06318773f, -0.07424914f, -0.10686567f, -0.13403556f, -0.51641828f, -0.07571780f, -0.34944129f, 
    -0.07466167f, -0.10524871f, -0.16148816f, 0.07036520f, -0.05631196f, 0.01368060f, 0.01614627f, -0.01661491f, 
    0.03548550f, 0.02457807f, 0.07229540f, 0.04446376f, -0.09779648f, -0.07212248f, -0.09062953f, -0.00872198f, 
    -0.00850995f, 0.03312993f, 0.05551440f, -0.04667120f, 0.03505603f, 0.25284833f, 0.00492165f, 0.25707671f, 
    0.00088535f, 0.01280642f, 0.24157208f, -0.00586651f, -0.00829152f, 0.29190958f, -0.03170358f, 0.05280399f, 
    0.03585326f, 0.26105067f, -0.03139101f, 0.06657712f, -0.09774498f, -0.07373182f, 0.14076045f, 0.12214505f, 
    0.06635922f, 0.22934055f, 0.09919848f, -0.16846542f, 0.36777556f, -0.20067096f, 0.12965538f, -0.43527657f, 
    -0.01038677f, 0.10432694f, 0.09411807f, 0.12548630f, -0.06693134f, 0.14448220f, -0.06422637f, 0.05676470f, 
    -0.01605371f, 0.15443315f, 0.14985564f, 0.12986109f, -0.09626554f, 0.04842133f, 0.00480056f, -0.00297507f, 
    0.03340721f, -0.05745012f, 0.04892517f, 0.06071791f, 0.41936576f, 0.40773764f, 0.12874623f, 0.21746394f, 
    -0.15265642f, -0.08077995f, 0.03384396f, -0.05348009f, -0.05449039f, -0.01360148f, 0.06684134f, -0.04112710f, 
    -0.48648658f, -0.40444955f, -0.52844024f, -0.02841302f, 0.08070038f, -0.14333268f, -0.08035865f, 0.28607157f, 
    -0.10281967f, -0.03708360f, 0.00391087f, 0.01339978f, 0.44500059f, -0.15179841f, 0.02006387f, -0.17334819f, 
    -0.13112526f, -0.16824551f, 0.04881581f, 0.01356353f, 0.08264393f, 0.28627893f, 0.01484231f, -0.12248647f, 
    0.26448429f, -0.05876404f, -0.08358581f, -0.07804048f, -0.09327703f, -0.03516667f, 0.00600009f, -0.13393714f, 
    0.01227598f, 0.03546106f, -0.11286532f, -0.02707338f, 0.07201202f, 0.12736002f, 0.03608315f, 0.03328645f, 
    -0.06667586f, -0.06306743f, 0.07177293f, -0.00309945f, 0.30705833f, 0.10865673f, -0.06629072f, 0.03414670f, 
    0.07820995f, 0.10268307f, 0.18067716f, 0.04509512f, -0.14599659f, 0.05565117f, 0.01610052f, -0.10092314f, 
    0.00675283f, -0.03360350f, 0.14960438f, 0.10690176f, 0.17551631f, 0.17347744f, 0.06075038f, 0.15053035f, 
    -0.04337854f, 0.01561638f, 0.03812660f, -0.02814754f, 0.16969578f, 0.01942047f, 0.05741599f, 0.05931017f, 
    0.05451390f, 0.09730621f, 0.07609551f, 0.04219563f, 0.03167908f, 0.06989098f, 0.03096798f, -0.00142698f, 
    0.23054396f, 0.02524417f, 0.08230390f, 0.37012023f, 0.35719523f, -0.29113719f, 0.05677240f, 0.15059167f, 
    0.12501086f, 0.20885526f, 0.05981563f, -0.04195596f, 0.01496042f, -0.05828419f, 0.01288958f, -0.04687610f, 
    0.08201940f, 0.14415208f, 0.01004379f, 0.01659302f, 0.06480543f, -0.03980486f, -0.00045030f, -0.06315054f, 
    0.10936528f, 0.22324479f, 0.00086491f, 0.09416753f, -0.38593680f, -0.42554313f, -0.31002140f, -0.03902332f, 
    0.03760187f, 0.07926178f, 0.11434716f, 0.14560035f, 0.00022092f, -0.00055324f, -0.00455427f, 0.03245285f, 
    0.13507219f, 0.11972978f, 0.05219770f, 0.04066118f, -0.07181917f, 0.04860837f, -0.08982489f, -0.07286657f, 
    0.05977318f, -0.11016256f, -0.07793031f, -0.06447522f, -0.29244485f, -0.73557907f, -0.45487729f, -0.31632799f, 
    -0.06250225f, -0.12934782f, 0.16781217f, 0.21386975f, -0.04723535f, -0.00804872f, -0.14451599f, -0.01157750f, 
    0.03154729f, -0.48463067f, -0.20235211f, -0.21539687f, -0.03700378f, -0.01708541f, -0.08317252f, -0.00091685f, 
    0.04318787f, 0.04582637f, -0.04653389f, -0.12311932f, 0.30907217f, 0.35580206f, 0.22566125f, 0.12799470f, 
    -0.18748489f, -0.10807603f, -0.00595724f, 0.08370554f, -0.05489991f, -0.05021958f, 0.07580533f, -0.02865134f, 
    -0.36044711f, -0.68039358f, -0.15858856f, 0.06854199f, 0.30846757f, 0.31819442f, 0.19811231f, 0.04295604f, 
    0.05242186f, -0.06215594f, -0.01220552f, 0.06149121f, 0.03747487f, 0.12629715f, 0.09690363f, 0.13244015f, 
    0.01404302f, -0.01779922f, -0.09974281f, 0.06441700f, -0.00023126f, -0.03800802f, 0.00159008f, 0.03332893f, 
    -0.20482714f, -0.31820548f, -0.12224680f, -0.01343900f, 0.19466454f, 0.12287512f, 0.10678443f, 0.15829875f, 
    -0.08329350f, -0.01510913f, -0.08240572f, -0.00234967f, -0.57419056f, -0.46250892f, -0.12106016f, -0.23727867f, 
    -0.21850960f, -0.07057406f, -0.03834898f, -0.01960157f, -0.04692141f, -0.17262100f, -0.07006238f, -0.15161379f, 
    0.13469131f, 0.04898453f, 0.09031442f, 0.16541636f, -0.01255990f, 0.01844874f, 0.15361522f, 0.09337940f, 
    -0.07621600f, -0.00993191f, 0.02984854f, 0.04828052f, 0.15537898f, -0.25638044f, -0.42328414f, -0.18306808f, 
    -0.02923251f, -0.03407824f, -0.07479668f, 0.04687998f, -0.06895857f, 0.04770401f, 0.04095670f, -0.13815679f, 
    0.24267849f, 0.27079427f, 0.20135958f, 0.16186634f, 0.00870476f, -0.04546842f, 0.00307887f, -0.06255662f, 
    0.10971946f, 0.01409418f, 0.03413766f, 0.13847774f, 0.20985700f, 0.15112168f, -0.03735130f, -0.23332649f, 
    -0.09119618f, 0.02318025f, 0.00991032f, 0.06853310f, -0.06060836f, 0.17748630f, 0.20391932f, -0.03226976f, 
    0.08324212f, 0.07136176f, 0.11103237f, 0.07144743f, 0.04971374f, -0.17655906f, -0.08919087f, -0.01078360f, 
    -0.04814085f, -0.01426688f, -0.00684258f, 0.02376299f, 0.00601955f, 0.04945865f, 0.16039523f, -0.06843808f, 
    0.00529105f, 0.03477292f, -0.00148069f, 0.01949239f, -0.01253692f, 0.11813115f, 0.03742620f, 0.02578515f, 
    -0.17712072f, 0.08268860f, -0.14205472f, 0.22615501f, -0.08722325f, -0.01197689f, -0.05783645f, -0.04014332f, 
    -0.17391688f, 0.00960512f, 0.02791028f, 0.05194771f, 0.08365917f, -0.21269974f, 0.27621916f, 0.20370363f, 
    0.03785763f, -0.05499318f, 0.07701568f, 0.09395882f, -0.15582164f, 0.05276108f, -0.11094360f, -0.01354723f, 
    0.00673561f, 0.06504574f, 0.06852666f, -0.05529696f, 0.21944578f, 0.08151665f, -0.01599109f, -0.02805205f, 
    -0.11557490f, 0.11046362f, 0.15027040f, 0.05447581f, -0.30866608f, 0.03045825f, 0.60513055f, 0.44893259f, 
    -0.06661616f, -0.04727885f, 0.01210150f, -0.17942196f, 0.03191449f, 0.14446513f, -0.15344600f, -0.09386428f, 
    -0.28986612f, 0.10146681f, 0.05341047f, 0.42427322f, -0.06833260f, 0.09306768f, 0.02566009f, 0.00989761f, 
    -0.10457325f, -0.01196640f, 0.10914896f, 0.02159886f, -0.17823154f, 0.41603464f, 0.13351800f, 0.38077259f, 
    -0.14795981f, -0.02893092f, -0.14451027f, -0.09725846f, -0.01571638f, 0.05400677f, -0.02219176f, -0.00904632f, 
    0.59574282f, -0.13636920f, 0.10129418f, 0.10671782f, -0.09330995f, -0.02156571f, -0.00928526f, -0.04248010f, 
    0.04842570f, 0.12684330f, 0.07818853f, -0.01840229f, -0.21234784f, -0.14266059f, 0.27118909f, 0.01939285f, 
    -0.16616306f, -0.03956835f, -0.03933170f, -0.06714787f, 0.10290574f, -0.03397705f, 0.00713113f, -0.08486272f, 
    -0.17945640f, -0.11029191f, -0.01706727f, 0.17752066f, -0.07615914f, -0.05323322f, -0.04533563f, 0.12923007f, 
    -0.05280792f, -0.06938774f, -0.09166441f, 0.05403463f, -0.03171289f, 0.22258638f, 0.37497184f, 0.22179216f, 
    0.01267396f, 0.05747942f, 0.10370807f, -0.00472167f, -0.00183443f, -0.07154716f, 0.05205226f, -0.00503935f, 
    0.36324388f, 0.11410100f, 0.01752915f, -0.23595452f, -0.12320634f, 0.02230766f, 0.06667885f, 0.07362175f, 
    -0.02331439f, 0.00970958f, 0.06287737f, 0.08072177f, -0.00596843f, 0.09274438f, 0.24778537f, 0.14102390f, 
    -0.12534003f, 0.01232743f, -0.13360330f, -0.07387354f, 0.04929436f, -0.02848166f, -0.01444372f, -0.02551008f, 
    0.27494183f, -0.07921077f, 0.03852347f, -0.16743341f, 0.03442902f, -0.10203732f, 0.10556962f, -0.26223350f, 
    -0.05694865f, 0.04341891f, -0.00537608f, 0.01992504f, -0.02771740f, 0.07472069f, -0.10968284f, -0.20883174f, 
    -0.02301360f, -0.00958916f, -0.04599589f, -0.09163354f, 0.15750559f, 0.02270967f, 0.07882442f, -0.00912811f, 
    0.03077908f, 0.12656924f, -0.08828580f, -0.27436665f, -0.09436776f, -0.06122052f, -0.07227826f, -0.13037053f, 
    0.08149222f, 0.15740007f, -0.06568529f, -0.16781367f, 0.12746924f, 0.10242465f, -0.06859152f, -0.11142120f, 
    0.28645495f, 0.10491487f, 0.07644223f, 0.00963713f, -0.10712041f, 0.04121139f, 0.05741911f, -0.02758287f, 
    0.16677068f, 0.01058879f, -0.01176799f, 0.00827844f, 0.01455467f, -0.17134047f, 0.08182199f, -0.05586525f, 
    -0.10406788f, 0.16322252f, -0.15404327f, 0.01492784f, -0.09980576f, -0.11408828f, 0.09230863f, 0.32008028f, 
    -0.01144354f, 0.06415983f, 0.07462914f, 0.15717922f, 0.06975880f, -0.00223819f, 0.15033996f, -0.01338724f, 
    -0.03665885f, 0.03859482f, -0.07698395f, -0.17181316f, 0.01012661f, 0.00407771f, -0.08377753f, 0.01088893f, 
    0.10310465f, 0.11019111f, 0.17661761f, -0.00877844f, 0.07373337f, -0.11564773f, 0.13027367f, 0.32591292f, 
    0.04808169f, -0.02486264f, -0.01719656f, 0.13374002f, -0.05844415f, 0.03014506f, 0.05241522f, 0.14512545f, 
    -0.17802659f, 0.30059716f, -0.11872281f, 0.18813801f, -0.01488938f, 0.07297117f, 0.04332961f, 0.16645052f, 
    0.05163033f, 0.05561861f, 0.09123527f, 0.02906198f, 0.07360387f, 0.16340661f, -0.11926227f, -0.05062522f, 
    -0.17625992f, -0.14666909f, 0.02945759f, 0.01590057f, 0.04499099f, -0.01908568f, -0.00599407f, -0.05518971f, 
    -0.21104468f, -0.11232015f, -0.26177588f, 0.28716788f, 0.08501620f, 0.00444205f, 0.14285551f, 0.16474488f, 
    0.03032183f, 0.02987488f, 0.04897754f, 0.03802761f, -0.05452355f, -0.08076482f, -0.01799715f, -0.27009219f, 
    -0.08244175f, -0.09140199f, 0.01222493f, -0.10732431f, -0.04499582f, 0.04727205f, 0.10485072f, 0.06874773f, 
    -0.15890807f, -0.26743051f, -0.13026977f, 0.21342066f, 0.00450368f, 0.07612348f, 0.06053655f, -0.04426829f, 
    -0.06488618f, 0.00356768f, 0.04934233f, 0.04296947f, -0.05092618f, -0.10413582f, -0.04053226f, 0.11370605f, 
    -0.04067486f, 0.04441544f, -0.04837801f, 0.04981725f, -0.01781809f, -0.14217353f, -0.05374477f, -0.16763401f, 
    0.01099486f, -0.02585123f, 0.01449274f, 0.25699505f, -0.04503550f, -0.14235677f, -0.01285425f, 0.12584801f, 
    0.01494782f, 0.06581155f, 0.18833289f, 0.09321978f, 0.61374104f, -0.09594475f, 0.19474140f, 0.00015609f, 
    0.10231747f, -0.02716584f, 0.07124146f, -0.05139874f, -0.14450467f, 0.04708134f, 0.07330918f, 0.05437830f, 
    -0.21573001f, 0.15239558f, 0.21307573f, -0.15257461f, -0.03461656f, -0.03592657f, 0.03210095f, -0.04190138f, 
    -0.00540915f, 0.09299693f, 0.04069136f, 0.10460530f, -0.15835826f, 0.36468181f, -0.07077532f, -0.18218142f, 
    -0.05505178f, 0.05679642f, -0.06606230f, -0.07059905f, -0.10467601f, -0.06502169f, 0.05360531f, -0.11020052f, 
    -0.14953054f, 0.07938572f, -0.13150778f, 0.04007805f, 0.00571695f, -0.04970431f, -0.12286830f, -0.09410736f, 
    0.05461077f, 0.07356587f, -0.00344825f, -0.02681675f, -0.02921903f, -0.02087061f, -0.23748840f, -0.10776431f, 
    0.00179437f, -0.00419413f, 0.01455185f, 0.05132180f, -0.06484191f, 0.11710258f, -0.05369855f, -0.07053571f, 
    -0.02533687f, 0.01869257f, 0.02333245f, -0.01164530f, -0.05077894f, 0.02670753f, 0.01402966f, -0.02562093f, 
    0.03494798f, -0.04070082f, -0.03356081f, -0.01459843f, -0.03315420f, -0.02500956f, -0.01399438f, -0.04178512f, 
    -0.01645904f, -0.05283363f, 0.02578164f, 0.02144529f, -0.02565799f, 0.03780329f, 0.04570013f, -0.04175983f, 
    -0.04513422f, -0.00281236f, -0.04693249f, 0.01110413f, 0.00604432f, -0.04862757f, 0.01614084f, 0.02464088f, 
    0.02976170f, -0.04755292f, 0.03442752f, 0.03833129f, -0.02578156f, -0.00225599f, 0.04631830f, -0.02696721f, 
    0.00686528f, -0.02101593f, 0.02004302f, 0.00497477f, 0.03756893f, 0.02955907f, -0.00073028f, -0.02664369f, 
    0.03965393f, 0.02730608f, 0.02399057f, 0.03294110f, -0.01685327f, -0.01150250f, 0.03315832f, 0.03062491f, 
    0.01273156f, -0.01087081f, 0.04245635f, 0.02846541f, 0.01490142f, -0.02056892f, 0.02249517f, -0.03127895f, 
    -0.04818460f, -0.04267177f, 0.01050086f, 0.02986312f, 0.03260408f, -0.04885630f, 0.01279769f, -0.02408901f, 
    -0.03598646f, 0.01218408f, 0.01484842f, 0.04348731f, -0.04859485f, 0.04910981f, -0.05733030f, 0.04079904f, 
    0.01638070f, -0.00699116f, -0.05795107f, -0.04298912f, -0.02289149f, 0.03871495f, 0.00664124f, 0.00174231f, 
    0.01152787f, -0.03740254f, -0.04625336f, -0.00518734f, -0.05004001f, -0.00671309f, -0.02117598f, -0.00847506f, 
    -0.04984919f, -0.02994508f, -0.00758712f, -0.05066819f, -0.00475531f, 0.03688005f, 0.00105975f, 0.03415019f, 
    0.04452262f, -0.04917931f, -0.05218535f, 0.01663221f, 0.01925469f, -0.02211834f, 0.00620557f, -0.04402810f, 
    0.03527474f, -0.04203837f, -0.03318180f, -0.03937339f, -0.01672359f, -0.04353257f, 0.04179670f, 0.00609655f, 
    0.03917122f, -0.05595919f, -0.04950863f, 0.00197426f, -0.01378773f, -0.05402958f, -0.02084457f, 0.02995472f, 
    0.02420346f, 0.02794728f, -0.01591267f, -0.01999764f, -0.03929709f, -0.03380663f, 0.03494549f, -0.02677489f, 
    0.01893916f, 0.03153268f, -0.04141647f, 0.03995230f, 0.02838654f, -0.04849766f, -0.02626242f, -0.06055894f, 
    0.03045425f, -0.01827814f, -0.05700469f, -0.03043241f, -0.05416296f, -0.02748030f, -0.02874288f, -0.05153642f, 
    0.03583235f, -0.05334745f, 0.01810048f, -0.04425972f, -0.03832344f, -0.00226216f, 0.00862214f, 0.00133340f, 
    -0.02998974f, -0.01030839f, 0.01416638f, 0.03753306f, 0.00993638f, 0.02381775f, 0.00474401f, -0.03815223f, 
    -0.00092115f, 0.03119171f, 0.01519772f, 0.05395444f, -0.04408051f, -0.03222723f, -0.01060135f, 0.01603818f, 
    0.00830690f, 0.01921813f, -0.05291186f, 0.04140177f, -0.04424558f, -0.03569169f, -0.00398298f, -0.05349028f, 
    0.00515190f, 0.00022139f, 0.02725590f, 0.00331124f, -0.05492827f, -0.04864975f, -0.01721404f, -0.02531927f, 
    0.03874250f, 0.03490071f, 0.00810490f, 0.01493839f, 0.01857876f, -0.02963228f, 0.02606115f, 0.03900630f, 
    -0.00688843f, -0.02946866f, -0.01632666f, 0.03477328f, 0.01922582f, -0.05257573f, -0.00003001f, 0.00247137f, 
    0.02005151f, -0.03003220f, -0.03335997f, -0.03156281f, -0.02088272f, -0.05782844f, -0.05046659f, 0.02700157f, 
    -0.03646469f, -0.02115858f, -0.03316856f, -0.03088286f, -0.03899859f, 0.02505068f, 0.00975916f, -0.05735222f, 
    0.00276793f, 0.01535712f, -0.03803725f, 0.00187722f, 0.01547784f, 0.00332691f, -0.00314410f, -0.00653288f, 
    -0.03798659f, 0.01628235f, -0.02910028f, -0.03269259f, -0.00745522f, 0.01838420f, 0.00449162f, 0.02812690f, 
    0.04544152f, 0.02863467f, 0.02322198f, -0.03648749f, -0.05295769f, -0.01278031f, 0.01660635f, 0.03237452f, 
    -0.02112246f, -0.00601842f, -0.03690880f, -0.02060251f, 0.04228982f, -0.03518319f, 0.01873844f, 0.01937946f, 
    0.00746703f, 0.01952832f, 0.00799550f, -0.02946584f, 0.02629142f, 0.02915279f, -0.01230197f, -0.04581536f, 
    0.02931009f, -0.05104423f, -0.02727086f, 0.03012924f, -0.00456543f, 0.01288886f, -0.05090318f, -0.03692975f, 
    0.04721791f, -0.01360744f, 0.03317972f, 0.00897405f, 0.02528599f, -0.00300584f, 0.02200502f, -0.00005693f, 
    -0.05306146f, -0.01797042f, 0.00762102f, -0.05463794f, 0.02240204f, -0.04036568f, -0.01832247f, 0.00245702f, 
    0.02543067f, -0.01650617f, 0.03507608f, -0.04425268f, 0.03618831f, 0.03153495f, 0.00037320f, -0.00084435f, 
    -0.02396910f, 0.00598486f, -0.01780810f, -0.03691471f, -0.01588866f, -0.02239346f, 0.00099899f, 0.03491085f, 
    -0.03771875f, -0.00844940f, -0.04398455f, -0.00240399f, -0.04852903f, -0.02908437f, 0.01237864f, 0.04816859f, 
    -0.00821885f, -0.04984355f, 0.04102767f, 0.02908543f, 0.01285675f, 0.02889436f, -0.04961815f, -0.04191711f, 
    -0.04639532f, -0.00960362f, 0.04807667f, -0.04987463f, -0.02486242f, 0.00180334f, 0.02907456f, -0.02375771f, 
    0.00788913f, -0.04107095f, 0.04382839f, -0.01907246f, -0.05555040f, 0.04459941f, 0.04671311f, 0.04058097f, 
    0.00491073f, -0.02758231f, 0.04606314f, 0.02475470f, 0.02495395f, -0.04130647f, -0.03203410f, -0.04613669f, 
    0.01016726f, -0.03917857f, 0.03927581f, 0.00338080f, -0.02076557f, -0.02863647f, -0.00753700f, 0.00751780f, 
    0.04328281f, -0.04555757f, -0.01540334f, -0.03660958f, 0.00734150f, -0.03683335f, -0.00838032f, -0.01136412f, 
    0.03299403f, -0.00122897f, 0.00143402f, -0.00646251f, 0.01773025f, -0.04509579f, 0.02877448f, 0.03528226f, 
    -0.05794177f, 0.03428822f, 0.03840672f, -0.00465277f, 0.03878333f, -0.02286605f, -0.04555582f, 0.01635606f, 
    -0.04539607f, -0.00822545f, -0.01474338f, 0.01433875f, 0.00933295f, -0.03964138f, -0.04203079f, -0.01486942f, 
    -0.02872610f, -0.01703222f, 0.02683386f, -0.04638070f, -0.02113293f, 0.03254199f, -0.00827341f, -0.04849438f, 
    0.00944304f, -0.01219457f, 0.03875619f, -0.04110105f, 0.02103327f, 0.00073783f, 0.04195609f, 0.00686554f, 
    -0.02566297f, -0.02357520f, -0.05167459f, 0.01466715f, -0.01129926f, -0.03999750f, -0.03590625f, 0.04355320f, 
    -0.04298812f, 0.02558964f, -0.00841778f, 0.03895304f, 0.01893399f, 0.03975964f, -0.04280167f, -0.02731164f, 
    -0.03676451f, -0.02035056f, 0.02929877f, -0.00570146f, -0.01159628f, 0.03464796f, -0.01674546f, 0.03021636f, 
    -0.01359044f, -0.04015926f, -0.04927590f, -0.02264664f, -0.02451617f, -0.03564768f, 0.01816519f, -0.02643947f, 
    0.03832743f, 0.02889432f, 0.01661216f, -0.03109668f, 0.02436978f, 0.03635835f, 0.03374043f, -0.02455338f, 
    -0.03020339f, -0.03326684f, -0.00767744f, 0.03858694f, -0.01711491f, -0.00798447f, 0.02262252f, 0.01981668f, 
    0.03008308f, 0.02976250f, -0.03010304f, -0.01260166f, 0.03490667f, 0.04196538f, -0.03105318f, -0.00759177f, 
    0.03129373f, 0.00493760f, -0.05052173f, -0.00442168f, -0.02251536f, 0.03284797f, -0.00537800f, 0.01848477f, 
    0.02760080f, -0.05466529f, -0.05394475f, -0.01824458f, -0.00712263f, 0.00420367f, 0.03833169f, 0.03289264f, 
    -0.04457838f, -0.02795403f, -0.02879222f, -0.03498129f, -0.03715938f, -0.01980316f, -0.02479979f, 0.02330443f, 
    -0.04384860f, -0.04702693f, -0.04511938f, -0.03664914f, 0.04674082f, 0.03630377f, -0.05107040f, 0.02295403f, 
    -0.01068566f, 0.03831771f, 0.00364919f, -0.01870540f, 0.04133340f, -0.02899755f, -0.04744625f, -0.02216027f, 
    0.00459526f, 0.02149886f, -0.05283727f, -0.02495565f, -0.04843858f, -0.05319959f, -0.02785380f, -0.05100698f, 
    0.04424711f, -0.03768195f, 0.00026465f, -0.05242457f, 0.00642779f, -0.03720982f, -0.01286669f, 0.02617288f, 
    0.04496289f, -0.01391526f, -0.03036362f, -0.02542097f, -0.00247568f, 0.02137085f, 0.03025869f, -0.00896369f, 
    0.03990461f, 0.02415395f, 0.02782349f, 0.01892312f, -0.01401613f, 0.03534056f, -0.04259589f, -0.03754439f, 
    0.00177170f, 0.01804014f, -0.04190845f, -0.04941608f, -0.01324106f, -0.03547618f, -0.03027508f, 0.04840436f, 
    -0.00620631f, 0.02057252f, -0.00398980f, 0.03233522f, -0.04598019f, -0.05540426f, -0.04514462f, -0.02214153f, 
    0.04231252f, 0.02891698f, 0.03525488f, -0.01246212f, 0.02409969f, -0.00346885f, -0.02916805f, -0.00563845f, 
    0.00771320f, 0.02433235f, 0.04397071f, -0.01997366f, 0.00209131f, -0.00326666f, -0.05228778f, 0.03638660f, 
    0.01116469f, -0.03783421f, -0.03124887f, 0.00893839f, -0.00093412f, -0.02752914f, -0.03778269f, -0.00944168f, 
    -0.04559789f, 0.01376520f, -0.03645731f, 0.00711172f, -0.01056538f, 0.01393768f, 0.01266813f, -0.04854549f, 
    0.00723902f, -0.04586964f, -0.01599058f, -0.04827779f, -0.02134257f, -0.03922358f, -0.00940189f, -0.02550550f, 
    0.01867091f, 0.02957131f, 0.02341082f, 0.02209105f, -0.02801630f, 0.04181781f, -0.04027330f, -0.01411907f, 
    0.04491888f, 0.03076823f, 0.01594747f, 0.02157980f, -0.02986408f, 0.03623907f, 0.03427863f, 0.02622461f, 
    -0.01217614f, -0.05393081f, -0.01464399f, 0.00090648f, -0.02237066f, 0.04154202f, 0.03599863f, -0.01548859f, 
    0.04148384f, -0.00847696f, 0.03121997f, 0.01545779f, -0.03675343f, -0.03981488f, 0.00476967f, -0.01505627f, 
    -0.04829997f, -0.04191013f, -0.01831614f, -0.03999687f, -0.03529993f, 0.03643789f, 0.02710599f, -0.03446909f, 
    -0.03785043f, -0.01940162f, 0.02897685f, 0.02464525f, -0.03848062f, 0.01083907f, -0.01420951f, -0.03036886f, 
    -0.03285967f, 0.03667935f, -0.03372775f, 0.00714986f, -0.04236552f, -0.04026352f, 0.01719393f, -0.01041488f, 
    0.03166427f, 0.02530961f, 0.03901035f, -0.03273652f, 0.00633667f, -0.04001546f, -0.01744406f, -0.05596522f, 
    0.04274827f, 0.02939344f, -0.02326802f, -0.00376701f, -0.01938129f, -0.02355222f, -0.00066417f, 0.04116912f, 
    -0.00407470f, -0.03861761f, -0.01150921f, 0.02186846f, -0.03748309f, 0.00086560f, 0.02135489f, 0.01743471f, 
    -0.03503114f, -0.04183003f, 0.03022957f, 0.01164498f, -0.00747802f, 0.02775509f, 0.02947806f, -0.02252021f, 
    -0.02554678f, -0.02877236f, 0.01405694f, 0.03678611f, -0.03015440f, 0.00340213f, -0.04165425f, -0.03107247f, 
    -0.00427567f, 0.01031877f, 0.04344045f, 0.00497455f, 0.04301086f, -0.04183495f, -0.00449955f, 0.00870256f, 
    0.01020596f, -0.01899454f, -0.05453600f, -0.00865466f, -0.02554642f, -0.03069274f, -0.04163952f, -0.03909738f, 
    -0.00478318f, -0.03049513f, -0.03564209f, -0.03164759f, -0.04621513f, 0.00287714f, -0.00864351f, -0.01755790f, 
    -0.01942490f, -0.00200131f, -0.01077478f, 0.01179305f, -0.04096137f, 0.00055632f, 0.04043117f, 0.00416733f, 
    0.03511328f, -0.01310587f, -0.00713867f, -0.01967876f, -0.00924616f, -0.03087286f, 0.01960406f, 0.00401034f, 
    -0.03591204f, -0.05211533f, -0.00437424f, 0.00882939f, 0.02717265f, -0.01852878f, -0.04631294f, -0.00627978f, 
    0.00752867f, -0.03523456f, 0.03966725f, -0.03470319f, -0.05086505f, 0.02498809f, 0.00977371f, -0.02683365f, 
    -0.00274636f, 0.03831025f, -0.04689936f, -0.03388771f, -0.04839954f, 0.03497261f, -0.03449678f, -0.04704892f, 
    -0.00454097f, 0.01060274f, 0.02425434f, 0.01422776f, -0.04981657f, 0.02583477f, -0.00318906f, -0.02131108f, 
    0.00959677f, -0.05729770f, 0.04201104f, -0.01763904f, -0.03718695f, 0.00002051f, -0.03669809f, 0.03218065f, 
    -0.00329039f, 0.00616493f, 0.03986821f, -0.03035760f, -0.00862489f, -0.03859816f, 0.02064990f, 0.01196160f, 
    0.01397694f, 0.22581343f, -0.02719475f, 0.04890164f, 0.15907751f, 0.03373600f, 0.19811058f, 0.21778256f, 
    0.03323999f, -0.12044846f, -0.04790093f, -0.05933738f, 0.33897910f, 0.03992512f, -0.03618946f, 0.16997087f, 
    0.06566215f, -0.01900919f, -0.05036316f, -0.04449186f, 0.03262766f, -0.07438292f, -0.00264432f, 0.09133606f, 
    -0.05606986f, -0.03031727f, -0.11691500f, -0.14111933f, 0.08777275f, -0.03171622f, 0.00874323f, 0.02608939f, 
    -0.06247096f, -0.05484336f, -0.04623193f, -0.12081491f, 0.16038138f, -0.12688629f, 0.11879355f, -0.00763573f, 
    0.02626321f, 0.12713690f, -0.16957606f, -0.06074038f, -0.00603667f, 0.10679632f, 0.07228698f, 0.03521250f, 
    0.17296688f, -0.15135753f, 0.06476141f, -0.01472313f, -0.16003582f, -0.16902129f, 0.04240057f, -0.10753041f, 
    0.08265743f, 0.08569546f, 0.00784741f, -0.12139856f, 0.03348975f, 0.40316918f, -0.05932553f, 0.14845710f, 
    -0.04272355f, -0.15915294f, -0.00601625f, -0.05261422f, 0.05345056f, 0.02632093f, 0.10950981f, -0.11322169f, 
    0.16553317f, 0.01460336f, 0.39870515f, -0.15955648f, -0.05424778f, 0.04767224f, -0.09096598f, 0.03113397f, 
    0.05719245f, -0.06585810f, -0.02295369f, -0.05125105f, -0.07356076f, 0.15665153f, 0.12373155f, -0.17908964f, 
    -0.06974956f, -0.00238362f, -0.00580566f, -0.10002023f, -0.00042081f, -0.03354097f, 0.02940483f, -0.06807962f, 
    0.14276670f, 0.22827502f, 0.08519652f, 0.13033472f, -0.02687808f, 0.13923319f, -0.02639033f, 0.02904747f, 
    -0.05591705f, 0.02942722f, -0.10358655f, 0.00529732f, 0.70941341f, 0.36294255f, -0.31693938f, -0.18574572f, 
    -0.07150931f, -0.13007393f, 0.00295043f, -0.13304292f, 0.16288431f, 0.04309582f, -0.05019214f, -0.10074763f, 
    0.11514873f, 0.01419591f, -0.10569630f, 0.09752299f, 0.02574922f, 0.02198431f, 0.07619641f, -0.07450204f, 
    -0.02213717f, 0.01647174f, -0.08442193f, 0.09958988f, 0.23692727f, 0.00995538f, 0.02814838f, -0.06711495f, 
    -0.17720281f, -0.07953443f, -0.03461948f, -0.02846119f, 0.17302573f, 0.04294695f, 0.10027094f, -0.10081385f, 
    -0.11094712f, 0.01562575f, 0.16856167f, -0.05687555f, 0.10811833f, 0.01234537f, -0.07682239f, -0.16246060f, 
    0.08913881f, 0.03026629f, -0.15146770f, 0.02416375f, 0.18495388f, 0.01973169f, 0.02739416f, 0.04578303f, 
    -0.07002346f, -0.00495519f, -0.05151725f, -0.11280725f, -0.01669412f, 0.03598125f, 0.13498881f, -0.07027476f, 
    -0.02476302f, 0.11781964f, 0.12362387f, -0.04185702f, -0.06737686f, -0.08624058f, -0.05189678f, -0.04532110f, 
    0.00959037f, -0.02759911f, 0.01934453f, -0.01389932f, -0.13204636f, 0.00356604f, -0.06793126f, -0.11330906f, 
    0.27470729f, 0.03374809f, 0.23204999f, 0.10165773f, 0.12093516f, -0.09188721f, 0.09984754f, 0.01827667f, 
    0.03292641f, -0.10529672f, -0.22485763f, 0.18111874f, 0.16464370f, -0.11042447f, -0.07142927f, 0.04786239f, 
    -0.08157039f, -0.01205241f, -0.15773298f, 0.03494386f, 0.09106551f, -0.03899748f, 0.04051311f, 0.12339206f, 
    0.00260255f, 0.03082730f, 0.09317023f, 0.01676888f, -0.01193631f, 0.00347340f, 0.06095585f, 0.02923166f, 
    0.00546721f, 0.00820385f, -0.03782682f, -0.03547506f, -0.06888030f, 0.03058897f, -0.07053114f, -0.03635405f, 
    0.00162103f, 0.05175816f, 0.06445571f, 0.01480284f, 0.31374004f, 0.37085781f, 0.26538420f, 0.14884447f, 
    0.03895964f, 0.08797762f, -0.07494121f, -0.02337372f, -0.02660464f, 0.03331326f, -0.11837961f, 0.04063388f, 
    0.22075462f, 0.28209782f, 0.01477146f, 0.09964675f, 0.00106753f, 0.17417797f, -0.02753770f, -0.27867451f, 
    0.01339753f, 0.01986632f, 0.03601365f, -0.17670660f, -0.03720982f, 0.15337884f, -0.01512770f, -0.13274969f, 
    -0.12019025f, -0.05656654f, -0.07339408f, 0.03674987f, -0.00612631f, -0.03058078f, -0.07315651f, -0.07722932f, 
    -0.02608307f, 0.21330439f, -0.19441336f, 0.18850215f, 0.10763510f, 0.13541627f, 0.11228090f, 0.06079072f, 
    0.08584031f, 0.14272438f, 0.12099578f, 0.19213925f, -0.07919658f, -0.11724802f, 0.27930126f, -0.06465276f, 
    -0.16260560f, -0.13648346f, -0.29041189f, 0.08074069f, -0.00910525f, -0.05948389f, 0.01934412f, 0.04901594f, 
    0.20255317f, 0.15966086f, 0.04972868f, 0.07132196f, 0.19078763f, 0.09005214f, 0.08421165f, 0.11137147f, 
    -0.08356644f, -0.01149510f, -0.06518488f, -0.04009083f, 0.03625386f, 0.11011057f, -0.02054089f, -0.03274928f, 
    -0.01446169f, 0.13180572f, -0.08758115f, -0.33142436f, 0.19741240f, 0.08675784f, 0.10565240f, -0.00345511f, 
    0.00998791f, 0.00004060f, 0.07385949f, 0.16923663f, -0.06375645f, 0.09252910f, 0.06712682f, 0.10220436f, 
    -0.20214559f, -0.06651912f, -0.00116778f, 0.00063158f, 0.40052265f, -0.21247378f, -0.01545813f, -0.04391304f, 
    -0.00554605f, 0.01285083f, -0.09485967f, -0.01044471f, -0.09383825f, -0.09638654f, 0.04900828f, -0.00963866f, 
    0.26098686f, -0.02090168f, -0.02937641f, -0.03994421f, -0.13275525f, -0.02296915f, -0.00226048f, -0.03088846f, 
    -0.10627460f, -0.03656882f, -0.00522327f, -0.04032997f, 0.00379678f, 0.31742829f, -0.12606396f, -0.08823731f, 
    0.08102841f, 0.03819430f, 0.02466362f, -0.00420678f, 0.01480865f, -0.06876876f, 0.05740072f, -0.20193689f, 
    -0.15117751f, 0.26368773f, -0.05517663f, -0.04848225f, -0.11213179f, -0.08264364f, -0.00545908f, -0.02887408f, 
    -0.10638602f, 0.03151819f, -0.02486954f, -0.05608456f, -0.24548158f, 0.16062264f, -0.20118923f, -0.06212604f, 
    -0.05536359f, 0.24430183f, -0.14832392f, -0.05209214f, 0.05318900f, 0.19787435f, -0.11511815f, -0.02293902f, 
    0.31122369f, 0.07567278f, 0.49201584f, -0.11261286f, 0.02534432f, 0.14038970f, 0.14238550f, 0.09639428f, 
    0.05896407f, -0.04849092f, -0.08037799f, -0.02874466f, 0.16302961f, 0.22624668f, 0.00760144f, -0.04381955f, 
    0.06330830f, -0.07367787f, 0.03559090f, 0.10511971f, 0.06220134f, -0.07982217f, 0.22034726f, 0.03409294f, 
    0.02904812f, -0.11565229f, -0.06687848f, -0.07872175f, 0.17438099f, 0.20607114f, 0.08982358f, -0.01908323f, 
    0.19101259f, 0.10395974f, -0.07498109f, 0.09471259f, 0.02802943f, 0.10386182f, -0.50586432f, -0.20791876f, 
    -0.02933641f, 0.01088855f, -0.00236606f, 0.15569624f, 0.00989588f, -0.12068404f, 0.02767460f, 0.02709940f, 
    0.03675666f, -0.23661807f, -0.47204208f, -0.34127969f, 0.11334819f, -0.03390749f, -0.06397385f, 0.01697793f, 
    0.18546042f, 0.07204629f, 0.09486500f, -0.05321813f, 0.48831129f, -0.28363407f, 0.01376182f, -0.34228981f, 
    0.05947692f, -0.05282169f, 0.09609257f, 0.08662364f, 0.03203336f, 0.02094287f, 0.00335072f, 0.05794393f, 
    -0.44292367f, 0.28588045f, 0.11282335f, 0.08678754f, -0.04026696f, -0.10995761f, -0.05772764f, 0.07390426f, 
    0.06459958f, -0.18438765f, 0.02681631f, -0.11526944f, 0.02362480f, 0.11280823f, -0.26084775f, 0.05480178f, 
    0.03820878f, -0.05827212f, -0.11042499f, 0.11807582f, -0.01253634f, -0.02171166f, 0.00891873f, -0.02187295f, 
    0.36429861f, 0.34022734f, 0.32142136f, 0.11476137f, 0.07877003f, 0.15414017f, 0.07035348f, 0.08779784f, 
    0.03100091f, -0.00362403f, 0.05956729f, -0.01728510f, 0.40610558f, -0.18626679f, -0.25080496f, -0.25409615f, 
    0.06024892f, 0.07330280f, 0.09120221f, 0.05792794f, 0.14675555f, -0.00214103f, 0.14775501f, 0.07143376f, 
    0.05869347f, -0.08669478f, -0.13814086f, 0.28354165f, 0.05368182f, 0.03588815f, -0.02703100f, -0.04032982f, 
    0.13724089f, 0.06273717f, 0.13364208f, 0.05759440f, -0.10083415f, -0.11071774f, -0.19066559f, 0.00243782f, 
    0.04022336f, -0.06790426f, 0.05169979f, 0.01403048f, 0.02736061f, 0.15721866f, 0.04919000f, -0.00024271f, 
    -0.47003525f, -0.06889743f, -0.10947665f, 0.06208617f, 0.17746814f, 0.03076594f, -0.12531891f, 0.15206423f, 
    -0.00034281f, 0.06774212f, 0.08618589f, -0.04827634f, -0.26995227f, -0.37598297f, -0.30195761f, -0.06526837f, 
    0.05015333f, 0.01259176f, 0.02012776f, 0.00524366f, 0.06624033f, -0.09125537f, 0.04970135f, 0.08145749f, 
    -0.31127304f, -0.36032790f, -0.06614774f, -0.05805492f, 0.05053207f, 0.04634296f, -0.03690505f, 0.00215954f, 
    -0.13354091f, -0.19892927f, 0.01451113f, 0.04366964f, 0.05330472f, 0.18207996f, 0.09391168f, 0.09384538f, 
    -0.03410017f, 0.00910938f, 0.00852394f, 0.08355681f, 0.09843599f, 0.03235104f, -0.07862009f, -0.00468023f, 
    -0.19407564f, -0.20801741f, -0.19352354f, 0.01023997f, 0.07020745f, 0.14579149f, -0.13300708f, 0.15323584f, 
    0.05463776f, 0.00543220f, 0.02560192f, 0.09052578f, 0.43823090f, 0.33754385f, 0.09863620f, -0.03546277f, 
    0.13007386f, 0.06820356f, 0.06805871f, 0.20908143f, 0.00135681f, 0.09032512f, -0.09514671f, 0.00978477f, 
    -0.17289452f, -0.29685113f, -0.13896090f, -0.06705555f, 0.07443141f, 0.06782950f, 0.08110106f, 0.05463890f, 
    0.03166744f, 0.12497837f, 0.11834159f, 0.15765701f, 0.27521092f, 0.38645956f, -0.00805757f, -0.10215773f, 
    0.01660451f, 0.05106498f, 0.16216500f, 0.04896483f, -0.03587398f, -0.03734855f, -0.04824508f, -0.03751626f, 
    0.21283776f, -0.20516999f, 0.21952951f, -0.06829311f, 0.01221479f, -0.05720808f, -0.02691826f, 0.07544258f, 
    0.13805331f, -0.10572376f, 0.05919292f, 0.01737674f, -0.11548430f, -0.24940076f, -0.11110821f, 0.00783221f, 
    0.02026635f, 0.00416888f, -0.09113019f, 0.01090998f, -0.00150205f, -0.01543475f, -0.07755607f, 0.01123948f, 
    0.54160208f, 0.21287502f, 0.44428831f, -0.02690106f, 0.04471396f, 0.17084296f, -0.04230728f, 0.04150116f, 
    -0.06339505f, 0.00739254f, -0.03472637f, -0.03399726f, -0.35959253f, -0.16179171f, -0.02778003f, 0.02544603f, 
    -0.06900749f, 0.01267808f, -0.09567816f, 0.04241061f, 0.14784358f, -0.03582268f, 0.02506157f, 0.13011123f, 
    0.31332996f, 0.33181173f, 0.41219950f, 0.03634903f, 0.12675372f, 0.07586708f, -0.05241386f, 0.16114554f, 
    0.06469224f, -0.06958107f, 0.03180834f, 0.10938577f, 0.24287735f, 0.15009229f, 0.07118363f, -0.03612857f, 
    -0.04590669f, 0.13635063f, 0.03254584f, 0.05658160f, -0.08091026f, 0.02386506f, -0.04724704f, 0.07718286f, 
    0.17185305f, 0.25794542f, 0.21579534f, -0.01602686f, 0.04173296f, 0.08136862f, 0.13450246f, 0.02694752f, 
    -0.02231112f, 0.01919654f, -0.02847338f, -0.05663608f, -0.15341534f, -0.00768193f, -0.20288499f, -0.03584004f, 
    -0.04205565f, 0.01913187f, -0.00143777f, 0.01989987f, 0.15680763f, 0.00502627f, 0.18731557f, 0.03253562f, 
    -0.08871167f, -0.53303319f, -0.41051179f, -0.01419643f, 0.04659038f, -0.04155295f, -0.02837776f, -0.05617164f, 
    0.07772726f, -0.08874209f, -0.03449992f, -0.11698226f, -0.09112397f, -0.28223920f, 0.14704435f, 0.08574372f, 
    0.04466343f, 0.03367418f, 0.04843916f, -0.06698120f, 0.13223022f, 0.07479281f, -0.09883291f, 0.02350597f, 
    0.00913511f, -0.16202195f, -0.01727526f, -0.14705515f, 0.08222933f, 0.10374276f, 0.01268832f, -0.02811389f, 
    0.03344835f, 0.07200631f, 0.01987865f, -0.05536309f, 0.00751168f, -0.15413930f, 0.10435563f, -0.12570266f, 
    0.10032945f, 0.01126735f, -0.21057405f, 0.06324276f, 0.07342994f, -0.03612141f, -0.15088618f, 0.11345643f, 
    0.01000929f, -0.04911754f, 0.02026599f, -0.01359930f, -0.00470959f, 0.00095341f, 0.01437165f, -0.01352046f, 
    -0.02683922f, -0.04008326f, -0.02963113f, 0.02043497f, 0.00636035f, 0.03636227f, 0.02498992f, 0.02115711f, 
    0.02145099f, 0.03922946f, 0.03548862f, 0.03740364f, -0.02806791f, -0.02509573f, -0.04871658f, -0.03965323f, 
    -0.02251786f, -0.00218861f, -0.02207524f, 0.03480680f, 0.01675325f, -0.01698434f, -0.01134809f, -0.00657591f, 
    -0.02223954f, 0.02139861f, 0.03605080f, 0.02413839f, -0.00181031f, 0.03344900f, -0.00619714f, 0.03443218f, 
    0.02838488f, -0.01905929f, 0.03219580f, 0.02659300f, 0.01176856f, 0.03878974f, 0.00295141f, -0.01663165f, 
    0.03716682f, 0.02296441f, 0.01943125f, -0.04851294f, 0.02213483f, -0.05873517f, 0.01899479f, 0.01855882f, 
    -0.02789562f, -0.04905511f, 0.02044034f, 0.01704909f, -0.05202478f, -0.04650703f, -0.04776873f, 0.02014973f, 
    -0.04908916f, -0.03697256f, -0.04884989f, 0.03026294f, -0.05740325f, -0.05157335f, -0.03932499f, 0.03151072f, 
    -0.04556375f, 0.02903432f, -0.02027620f, 0.02568143f, 0.00190096f, 0.02223015f, 0.02632709f, 0.01630031f, 
    -0.05331021f, -0.02234341f, 0.01013499f, -0.02143781f, -0.03322383f, 0.03231059f, -0.01083834f, 0.01376023f, 
    -0.01533011f, -0.05961955f, -0.02835533f, 0.02780673f, 0.01120554f, -0.04393851f, -0.04291914f, 0.03931205f, 
    -0.02985650f, 0.04940706f, 0.02326328f, -0.04461715f, -0.02351479f, 0.02108703f, -0.02235611f, -0.03504757f, 
    0.01065685f, 0.03310315f, -0.02863863f, -0.00350946f, -0.04320005f, 0.00729075f, -0.00546345f, -0.04902364f, 
    -0.03572511f, 0.01310864f, 0.00652445f, -0.00783541f, -0.03042199f, -0.05395211f, -0.02212290f, -0.05619439f, 
    -0.00841760f, 0.02092872f, 0.00086990f, 0.00069434f, -0.03245602f, -0.05092645f, 0.00694155f, -0.05764419f, 
    0.00545916f, -0.04890943f, -0.06031353f, 0.02565595f, -0.04979789f, 0.02768117f, -0.03893243f, -0.02765633f, 
    0.03008127f, 0.02177946f, -0.01989337f, -0.03447658f, 0.02904342f, -0.03418107f, 0.01282797f, -0.02484531f, 
    0.01208591f, -0.00005655f, -0.01743315f, 0.03443474f, -0.01337570f, 0.01677376f, -0.03353599f, -0.01881830f, 
    -0.05764753f, 0.00081787f, 0.01672378f, 0.01858960f, -0.02892253f, -0.00304866f, -0.05003928f, 0.00222847f, 
    0.00192179f, 0.03383370f, -0.00361582f, -0.03486504f, 0.01016931f, 0.01883109f, 0.00884673f, -0.05654270f, 
    0.00562505f, 0.04070335f, 0.01098206f, -0.02401967f, -0.02481072f, -0.03048087f, 0.02193947f, 0.02900000f, 
    -0.05482074f, -0.05600625f, -0.00542211f, 0.00964728f, -0.02992931f, 0.03013684f, -0.03698229f, 0.00409715f, 
    -0.02040071f, -0.03433335f, 0.03991490f, 0.02015583f, 0.03628495f, 0.02847484f, -0.03863037f, -0.01781386f, 
    0.03232353f, 0.02417181f, 0.01874643f, -0.01283025f, -0.02471241f, -0.00688886f, 0.02845697f, 0.02517487f, 
    0.02536194f, -0.01841739f, -0.02971797f, 0.00837243f, -0.00128174f, -0.05560980f, 0.00831609f, 0.00377680f, 
    0.03745030f, 0.02934621f, 0.01642780f, -0.02133342f, 0.00112718f, 0.00896900f, 0.01530735f, -0.03567196f, 
    -0.05020370f, 0.02672836f, -0.00936993f, -0.02469160f, 0.01034218f, -0.01388431f, -0.05287676f, -0.00551608f, 
    -0.04924677f, 0.02898098f, -0.01336823f, 0.01473362f, 0.00335318f, 0.02755724f, 0.00963540f, -0.04077715f, 
    0.01249157f, 0.02577775f, -0.00871418f, -0.01442256f, -0.03264096f, -0.03062021f, -0.04754546f, 0.04145492f, 
    0.02415863f, 0.04383283f, 0.02447767f, 0.01051162f, 0.04248255f, 0.01813903f, -0.04074846f, -0.05982586f, 
    0.03321553f, -0.00341374f, -0.04028928f, 0.01004125f, -0.05409471f, -0.03594973f, -0.05027758f, -0.04397739f, 
    0.01688012f, -0.03007672f, -0.02075822f, 0.00723280f, -0.05098634f, -0.03266661f, -0.05907240f, 0.02560001f, 
    -0.02491600f, 0.03648809f, 0.00122926f, 0.00552077f, 0.03706916f, -0.04883117f, -0.02075072f, -0.04691718f, 
    -0.04949414f, 0.02468196f, 0.00943452f, 0.03099808f, -0.01579962f, -0.02792437f, 0.03140216f, 0.00113610f, 
    0.03403222f, 0.02256664f, -0.03628674f, -0.00280267f, 0.03922082f, -0.04423579f, 0.05050216f, -0.04502235f, 
    -0.04095212f, 0.02303289f, -0.00284022f, 0.03302118f, -0.05179310f, -0.00969839f, -0.04451464f, -0.03632517f, 
    0.04001801f, 0.01602175f, 0.01506109f, -0.02953210f, -0.03978620f, -0.01740994f, -0.02375459f, 0.03771355f, 
    -0.01995919f, 0.02425508f, -0.02513701f, 0.03863839f, 0.02159127f, 0.00508649f, -0.00174947f, 0.02868949f, 
    0.00337371f, 0.03590458f, 0.00297327f, 0.03325602f, 0.00346147f, -0.00121056f, -0.03937516f, 0.02075179f, 
    0.02503277f, 0.01137222f, 0.03811652f, -0.01269321f, 0.04219360f, 0.03887648f, -0.00160127f, 0.03282708f, 
    -0.02212586f, 0.03107895f, 0.00204670f, 0.00033013f, -0.03457745f, -0.01578439f, -0.05094956f, 0.02688055f, 
    0.04931636f, -0.00800513f, -0.00425944f, -0.02138792f, -0.03199133f, -0.01347155f, 0.00358758f, -0.05437283f, 
    0.03225404f, 0.01513505f, 0.01384646f, 0.03371971f, 0.01489858f, -0.00412658f, -0.03202425f, 0.02496932f, 
    0.00749348f, -0.00555368f, 0.03043404f, 0.02710342f, -0.05055076f, -0.02614666f, 0.03379544f, -0.05829328f, 
    -0.04146367f, -0.04613940f, 0.02184400f, -0.00490274f, -0.04555222f, 0.01704001f, 0.03932153f, 0.00952502f, 
    -0.04827997f, -0.05080087f, -0.02944922f, -0.01656952f, -0.01554849f, -0.04006971f, 0.00404802f, 0.03100959f, 
    -0.02172568f, -0.00384948f, -0.00799352f, -0.03124345f, -0.02284984f, 0.01139805f, 0.03888555f, -0.00778978f, 
    -0.05788013f, -0.03647023f, -0.02638692f, -0.02414389f, 0.01154523f, -0.00846667f, 0.04581816f, 0.01846685f, 
    0.01685706f, -0.00510756f, -0.01704964f, -0.04929502f, 0.03411080f, 0.02981537f, -0.03661860f, 0.00310035f, 
    -0.04971972f, 0.05405986f, -0.06247011f, 0.04818017f, 0.01416670f, -0.00171096f, -0.03930809f, 0.02029151f, 
    0.01162199f, 0.01239265f, -0.01543964f, -0.06155302f, -0.01843852f, 0.02070548f, -0.03898839f, 0.00465337f, 
    -0.00685690f, -0.04703024f, -0.04803849f, -0.00574630f, -0.02597106f, -0.05264116f, 0.01012179f, -0.05269627f, 
    0.02138109f, -0.05046861f, -0.04662972f, 0.02331569f, -0.01775054f, -0.02053876f, -0.01257264f, -0.04966823f, 
    0.04352772f, -0.05397828f, 0.01855541f, -0.02287412f, 0.01253037f, -0.07034475f, 0.00405396f, -0.02089357f, 
    -0.00985842f, -0.03698105f, -0.06556412f, -0.03643547f, -0.04724859f, -0.04306129f, -0.04047204f, 0.03665541f, 
    0.02594916f, -0.03599451f, 0.04044401f, 0.04696357f, 0.00208162f, -0.05072143f, -0.02405776f, -0.02731005f, 
    -0.04431782f, -0.02392713f, -0.04770118f, -0.01235278f, 0.03620188f, -0.02958934f, 0.03223303f, 0.04845577f, 
    0.00863228f, -0.04498375f, -0.01179407f, 0.02012604f, 0.04548246f, -0.02857544f, 0.00858407f, -0.06207157f, 
    0.04111591f, 0.04527782f, 0.02744692f, 0.04577550f, -0.03454284f, 0.03994929f, -0.02921146f, -0.03960482f, 
    0.00802489f, -0.04260690f, 0.01174534f, -0.02576720f, -0.02143852f, -0.04694259f, -0.02083609f, -0.05189810f, 
    0.01853583f, 0.00931987f, -0.04027965f, -0.05473644f, -0.06861257f, -0.05556317f, -0.01945973f, -0.01166132f, 
    0.04371655f, 0.02588385f, -0.05366896f, -0.03490714f, 0.00969477f, -0.02340754f, 0.01359471f, -0.01413035f, 
    -0.00149554f, 0.01077961f, -0.00580461f, -0.05311329f, -0.00099607f, -0.03850185f, -0.02589344f, -0.00784491f, 
    -0.03834907f, 0.03196438f, -0.01407570f, -0.00982008f, -0.03013318f, 0.03463153f, -0.04670852f, -0.03957335f, 
    0.01898763f, 0.00973067f, 0.01133518f, -0.02498066f, -0.03607289f, -0.01777540f, -0.01727584f, -0.02519551f, 
    0.01196071f, -0.03547109f, -0.05124903f, 0.01061910f, 0.04582398f, 0.00355945f, 0.03914279f, 0.00238521f, 
    0.02628639f, -0.01913669f, -0.00760165f, 0.02455270f, -0.00328183f, -0.04179575f, 0.02045532f, 0.01568677f, 
    0.02335253f, -0.01838513f, 0.00238798f, -0.01236349f, 0.03439225f, -0.02908003f, 0.02750399f, 0.03277078f, 
    0.03211290f, 0.03876743f, -0.02700962f, -0.00748574f, -0.02266142f, 0.02158015f, -0.00478444f, 0.01224716f, 
    -0.03996900f, -0.03857595f, -0.06128732f, -0.04230272f, 0.02036856f, 0.01660150f, 0.00598113f, -0.00514902f, 
    -0.01199029f, 0.01791709f, -0.03041870f, -0.01922428f, -0.00396067f, 0.04447607f, 0.02579668f, 0.03256164f, 
    0.00407652f, 0.02049609f, 0.00659385f, -0.04766461f, 0.03121842f, -0.04114092f, 0.02060962f, 0.00599296f, 
    -0.00712843f, -0.00916576f, 0.03351396f, -0.02207470f, -0.01208923f, -0.02478795f, -0.04360479f, -0.00347748f, 
    0.00852263f, -0.02366200f, -0.01987585f, -0.05781102f, 0.01082586f, 0.01623497f, 0.02004136f, 0.03318524f, 
    -0.03253256f, -0.04037693f, -0.05357244f, -0.01602814f, -0.01098583f, -0.01296092f, -0.03963243f, -0.00493486f, 
    0.02026235f, -0.00307761f, -0.02433485f, 0.01257585f, -0.03849793f, 0.03295416f, 0.06620771f, 0.01715479f, 
    -0.00763056f, -0.05825226f, 0.00990916f, -0.03427798f, -0.01325772f, 0.00480433f, 0.04917518f, 0.02702087f, 
    -0.00074783f, -0.00395822f, -0.00819081f, 0.01721410f, 0.01798564f, -0.02148780f, -0.04654466f, -0.04192515f, 
    -0.00291270f, 0.00627426f, -0.04060731f, -0.05308026f, -0.02045339f, -0.00806928f, -0.03616806f, 0.02485666f, 
    -0.01101445f, -0.00266418f, 0.00427241f, 0.04047921f, 0.03800025f, -0.05592433f, 0.04394370f, 0.04258998f, 
    -0.01973712f, 0.00213202f, 0.01999942f, 0.00930321f, -0.02446063f, 0.01301103f, -0.00075079f, 0.04190889f, 
    0.02310331f, -0.04633854f, 0.00155912f, -0.00857396f, -0.00491075f, 0.01285665f, 0.02828991f, 0.01432274f, 
    -0.02849450f, -0.05226269f, -0.02017423f, -0.00644807f, 0.02670259f, 0.02979651f, 0.01696906f, -0.06449419f, 
    0.01543934f, 0.01306277f, -0.03214726f, -0.02828914f, 0.00876766f, 0.05280137f, 0.00239494f, -0.00296772f, 
    -0.01709199f, -0.03661815f, 0.02353724f, 0.02730511f, -0.00535513f, 0.05734022f, -0.01565470f, 0.02155502f, 
    -0.02994589f, -0.00614401f, -0.04018657f, -0.03118722f, 0.02026944f, 0.02982913f, -0.03168296f, 0.03847937f, 
    0.00466675f, 0.01996198f, -0.01605613f, -0.02033234f, 0.02708403f, 0.00825809f, 0.02542443f, -0.03236835f, 
    -0.02324289f, 0.03875811f, -0.01873827f, -0.06384860f, 0.03753308f, 0.02741493f, -0.04299819f, 0.00166129f, 
    0.02888921f, 0.01057168f, -0.01819808f, -0.01041370f, 0.01301638f, 0.03755545f, -0.05087763f, -0.03134241f, 
    -0.03831910f, -0.01842568f, 0.02047329f, -0.05290393f, -0.03439132f, 0.01022870f, -0.01966506f, 0.04481716f, 
    -0.00459398f, 0.02953554f, -0.05290383f, -0.07249033f, -0.04492662f, 0.04351969f, 0.04579272f, -0.03653651f, 
    -0.01078818f, -0.03860154f, -0.02530929f, -0.01575022f, -0.00455226f, -0.05291797f, 0.03378455f, -0.03805148f, 
    -0.05471930f, -0.00047656f, 0.03083229f, -0.04281551f, 0.02540440f, -0.06073587f, -0.03819368f, 0.00621065f, 
    -0.06042969f, -0.03255255f, 0.00459006f, -0.05188439f, 0.00314662f, 0.03311344f, 0.02024918f, -0.04103997f, 
    -0.03292049f, -0.05020577f, -0.02702054f, -0.01009981f, 0.00893051f, 0.00688635f, 0.00301109f, -0.01150762f, 
    0.12502877f, -0.01980022f, 0.15681976f, 0.01190780f, 0.02869575f, 0.10129761f, -0.04555586f, 0.12291043f, 
    -0.16488695f, 0.05122709f, -0.08087418f, -0.05734415f, 0.19768879f, -0.25796360f, 0.03303581f, 0.13091999f, 
    0.00328206f, -0.13980742f, 0.03129443f, -0.03437566f, 0.20733880f, 0.03919508f, 0.12122656f, 0.25461292f, 
    0.22008641f, -0.18102753f, 0.06307796f, -0.33919758f, -0.00481811f, 0.01360073f, -0.08238762f, -0.11887158f, 
    -0.18750653f, -0.29413101f, -0.19737089f, -0.47790068f, -0.11232539f, 0.36692423f, 0.19900881f, 0.05522489f, 
    -0.13699318f, -0.05417550f, -0.02425427f, 0.21922372f, -0.12117679f, 0.00609187f, 0.04490934f, 0.06712744f, 
    -0.39545757f, 0.32511503f, -0.17885838f, -0.05080169f, 0.07221556f, 0.11665224f, 0.05981933f, 0.09271590f, 
    -0.19350374f, -0.03841960f, 0.00440293f, -0.01576823f, 0.28982300f, -0.22724193f, 0.22195311f, -0.44773167f, 
    0.04571105f, 0.01272448f, 0.03591607f, -0.02913212f, -0.20847054f, -0.00729129f, -0.11890829f, -0.10871571f, 
    0.14917135f, 0.17222482f, 0.07448903f, 0.18822023f, 0.02701604f, 0.13616256f, 0.23578900f, -0.09270890f, 
    0.24630402f, 0.06662535f, 0.22365028f, 0.26918849f, -0.02105260f, 0.18057171f, 0.10576718f, 0.13106407f, 
    0.05969557f, 0.00690287f, 0.11225139f, 0.24537626f, -0.25384161f, -0.12119175f, -0.01115399f, -0.38141569f, 
    0.06146774f, -0.00715963f, 0.04025252f, 0.04727391f, -0.01460660f, -0.18500270f, 0.05632627f, 0.24905995f, 
    -0.02127358f, 0.02938335f, -0.02182430f, -0.01616780f, -0.06712592f, -0.21011144f, 0.32202330f, -0.06800515f, 
    -0.21696417f, -0.30287731f, 0.02720767f, -0.21686514f, 0.07533801f, -0.02256904f, 0.00641260f, 0.03601031f, 
    0.22170451f, 0.21776600f, -0.14769182f, -0.00559044f, -0.07640893f, -0.23281831f, 0.07745318f, -0.24630041f, 
    0.01076949f, 0.05588673f, -0.11038345f, -0.12482517f, -0.09312747f, 0.22325380f, 0.21517825f, 0.00204752f, 
    0.16358916f, -0.00254286f, 0.27195624f, 0.20374469f, 0.00245144f, 0.08883458f, -0.11913969f, -0.01383509f, 
    0.15028936f, -0.09970821f, 0.16307323f, -0.08143503f, 0.02731819f, -0.00576260f, -0.06371325f, -0.34740326f, 
    0.15879084f, 0.00816076f, -0.02932513f, -0.07646219f, -0.00550650f, 0.05733693f, -0.11115104f, 0.10626419f, 
    -0.00642239f, -0.07029935f, 0.10606716f, -0.03621403f, -0.11090815f, -0.00684155f, 0.10612684f, 0.01741693f, 
    0.12912691f, -0.06023603f, 0.10870975f, 0.03444833f, -0.17289981f, 0.13982150f, 0.19549619f, -0.05112201f, 
    0.25011042f, 0.23741986f, 0.19440749f, 0.32211146f, 0.22960851f, 0.05412157f, -0.05799185f, -0.09405694f, 
    0.14786685f, 0.06402931f, -0.01487204f, 0.07401461f, -0.01627843f, 0.06261495f, 0.04140906f, -0.25019896f, 
    0.21450230f, 0.08527450f, -0.10169063f, -0.12086871f, 0.08798978f, -0.08947147f, 0.02577455f, 0.07412618f, 
    0.07547160f, -0.09644174f, -0.18042527f, -0.22565535f, -0.05773991f, 0.28074285f, -0.12656951f, 0.29598463f, 
    0.09145062f, -0.10489459f, 0.07066134f, 0.03780760f, -0.06242533f, -0.03219675f, -0.02492720f, -0.29490387f, 
    0.07260151f, 0.05352648f, -0.04256765f, -0.30150127f, -0.11030469f, -0.00321645f, -0.05511698f, -0.02140420f, 
    -0.06558181f, -0.09928294f, -0.15898924f, -0.16689952f, 0.02826357f, -0.07449039f, 0.02241658f, 0.14930090f, 
    -0.00750712f, 0.00662995f, 0.05160407f, 0.06446615f, 0.14215992f, 0.09623478f, 0.07773507f, 0.15830499f, 
    -0.12162124f, -0.06614133f, -0.20139334f, 0.16850123f, 0.02071830f, -0.04834588f, 0.23657458f, -0.20517336f, 
    -0.01834421f, 0.16225113f, 0.04982239f, 0.17720795f, 0.15943377f, 0.12217674f, 0.10786335f, 0.09095862f, 
    -0.11449787f, -0.04652808f, 0.03394581f, 0.02996720f, -0.08025886f, -0.06480662f, -0.09434549f, 0.02543188f, 
    0.33793366f, -0.04315257f, 0.17387265f, 0.18865258f, 0.05982378f, -0.07494419f, -0.06530511f, -0.03944317f, 
    0.15870361f, 0.07511348f, 0.16300377f, -0.02455038f, -0.20714520f, -0.24539386f, 0.18006532f, 0.13317338f, 
    -0.06452644f, -0.03275215f, -0.19018538f, -0.28735548f, 0.10105165f, -0.17818579f, -0.01399904f, -0.02828080f, 
    0.03051068f, 0.01674606f, 0.03624102f, 0.10188351f, 0.08782198f, 0.05110059f, 0.03644729f, 0.35440958f, 
    0.10959325f, 0.04621714f, 0.07014338f, 0.07603151f, -0.03455234f, -0.00576751f, -0.04857676f, -0.13692087f, 
    -0.10397097f, -0.02681390f, -0.03356719f, -0.09578626f, 0.10972212f, 0.21086338f, 0.05906548f, 0.08942041f, 
    -0.18259707f, 0.12236031f, -0.02859990f, 0.26931038f, 0.01242440f, 0.11903024f, -0.11441150f, 0.08760691f, 
    -0.31525806f, -0.29605010f, -0.09269739f, -0.35151574f, 0.54294598f, 0.12862590f, 0.06003403f, 0.16456984f, 
    -0.16662069f, -0.03496325f, -0.11084875f, -0.09430616f, 0.25127003f, 0.03223055f, -0.13046359f, 0.14013642f, 
    0.00230433f, 0.02270457f, -0.08361018f, 0.00310961f, 0.10557987f, -0.20072939f, -0.05798769f, -0.05321096f, 
    -0.05591168f, -0.19981059f, -0.04983472f, -0.18220511f, 0.20035835f, 0.21219945f, 0.15192097f, -0.27617472f, 
    -0.10062984f, 0.06058645f, -0.10707957f, 0.23324566f, -0.06531614f, 0.23761591f, 0.09709000f, 0.15857039f, 
    -0.01721614f, -0.05838149f, 0.06194114f, -0.06896334f, -0.00423171f, -0.02643125f, 0.00036899f, -0.14052613f, 
    -0.31678796f, -0.15654179f, -0.24925260f, -0.37670809f, 0.09910249f, -0.34900010f, 0.02105498f, -0.26487306f, 
    -0.02442572f, -0.09969435f, -0.13778685f, -0.40858716f, -0.02495940f, -0.04475113f, -0.16478844f, -0.21413329f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03932756f, -0.08326794f, 0.03487495f, 0.18654357f, -0.00946489f, 0.00351962f, 0.05994488f, -0.06192637f, 
    -0.01932609f, -0.00661878f, -0.02588688f, 0.04415579f, 0.17941870f, 0.14931726f, 0.04312225f, 0.13081543f, 
    -0.04376958f, -0.05578380f, 0.02451027f, -0.00654701f, 0.10981660f, -0.03606013f, -0.00702165f, 0.08010010f, 
    -0.02232594f, 0.11734198f, 0.09748307f, -0.15204322f, 0.15175100f, 0.18318354f, -0.13728157f, 0.16732292f, 
    0.03034425f, 0.04403921f, -0.03560487f, 0.04644903f, 0.16282910f, 0.01135213f, 0.04165397f, 0.06023173f, 
    0.03129281f, 0.09322805f, 0.08022981f, -0.08197117f, 0.01266720f, 0.08932237f, 0.13779676f, 0.03685831f, 
    -0.03279087f, 0.12940367f, 0.08131987f, 0.00361477f, 0.03723265f, 0.00736759f, 0.13227169f, 0.09805025f, 
    -0.05575579f, 0.01645781f, -0.04190984f, -0.01529311f, 0.07526159f, 0.00244670f, -0.01113211f, -0.06609522f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04935567f, 0.00877976f, -0.06011984f, -0.30857247f, 0.06557476f, -0.09549148f, 0.16556258f, 0.19230491f, 
    -0.13040411f, 0.10864072f, 0.11053658f, -0.06765127f, -0.34950614f, -0.13043681f, 0.05936356f, -0.36663046f, 
    -0.10164329f, -0.04934230f, 0.09543556f, 0.06471926f, -0.12078248f, 0.00127075f, 0.01680906f, 0.13914409f, 
    0.21285963f, 0.00865411f, -0.59455568f, 0.36076233f, -0.21750388f, -0.30491510f, 0.13852166f, -0.10898118f, 
    0.01828804f, -0.23618013f, -0.10507344f, -0.01567690f, 0.15842155f, -0.01889913f, -0.39857662f, -0.26836979f, 
    0.07149366f, 0.15825725f, 0.30600736f, -0.13148554f, -0.04297086f, -0.13568808f, -0.15887311f, 0.01929885f, 
    -0.09196322f, -0.07050269f, -0.37303761f, -0.09564088f, 0.16270249f, 0.23505370f, -0.12070435f, -0.42770195f, 
    -0.26412824f, -0.10460905f, -0.07520606f, 0.13733663f, 0.11004595f, 0.09344676f, -0.05053384f, 0.13719243f, 
    0.07473820f, -0.17576540f, 0.07567943f, 0.00679334f, -0.09007744f, -0.05717635f, 0.04578798f, -0.45252031f, 
    0.06671909f, -0.10656998f, -0.43450475f, 0.09891564f, -0.29405159f, 0.10871838f, -0.01170421f, -0.09885351f, 
    -0.01901062f, -0.00817100f, 0.04209665f, 0.12310732f, 0.04872014f, -0.01599403f, 0.20612919f, 0.05443817f, 
    0.16033193f, 0.18584384f, -0.21119782f, 0.36363018f, -0.00091348f, -0.06196035f, -0.12613659f, 0.18412381f, 
    0.14810780f, -0.09398103f, -0.04267443f, 0.11013731f, 0.02058138f, -0.11626632f, 0.13058226f, 0.06733888f, 
    -0.00486475f, 0.04070727f, 0.10238063f, -0.56870288f, 0.01548041f, 0.33957827f, 0.18808168f, 0.03197958f, 
    -0.06624366f, 0.07416070f, -0.13442035f, 0.06150230f, -0.89185631f, -0.28064832f, -0.03569959f, 0.24208196f, 
    -0.05302262f, 0.04635302f, -0.01842484f, 0.34361702f, 0.05751132f, -0.03367286f, 0.05816379f, -0.35641336f, 
    0.05777956f, -0.17762698f, -0.05193479f, -0.03870375f, 0.04422991f, 0.00301175f, -0.20208211f, -0.11754591f, 
    0.03593035f, 0.11770876f, -0.39719659f, -0.13008541f, 0.16504855f, 0.11474780f, -0.31636027f, -0.08244245f, 
    -0.13002495f, -0.06374306f, 0.10140923f, -0.06090519f, -0.03312743f, 0.01006775f, 0.10745894f, 0.16716917f, 
    0.02054474f, -0.29945931f, 0.24062377f, -0.51446909f, 0.26204386f, -0.03942524f, -0.19572559f, -0.16636512f, 
    0.29578075f, -0.25980958f, -0.00113639f, -0.15540358f, 0.33277234f, -0.09401415f, -0.03970062f, 0.17303161f, 
    -0.06329718f, 0.15423319f, -0.28064072f, 0.33112246f, 0.03881027f, -0.32342449f, 0.00111189f, -0.03561058f, 
    0.06677091f, 0.28345752f, 0.25291061f, -0.28897685f, -0.29372695f, -0.17884450f, 0.11773000f, -0.29632342f, 
    0.04392595f, 0.12163033f, -0.02421772f, 0.17564884f, -0.35476130f, -0.02978956f, 0.02547354f, 0.10656661f, 
    -0.01178602f, -0.21394134f, 0.04275090f, -0.20679782f, -0.01502311f, -0.00553224f, 0.05058606f, 0.25085920f, 
    -0.00644100f, 0.11498490f, 0.27495888f, -0.06639623f, 0.01007664f, -0.00947422f, 0.16919905f, -0.26310745f, 
    -0.11372737f, 0.09439889f, -0.09630457f, 0.10208536f, -0.04983036f, -0.08182891f, -0.34048143f, -0.17564169f, 
    0.03203345f, -0.06647412f, -0.15095694f, -0.13566643f, -0.13403809f, -0.32336700f, 0.02711221f, -0.19234546f, 
    0.07906991f, 0.15736644f, 0.01011946f, 0.09744828f, -0.51088482f, -0.00987880f, 0.17615370f, -0.02047363f, 
    -0.13152368f, 0.00135993f, -0.24110551f, 0.33554691f, 0.01481042f, -0.39447680f, -0.39366454f, -0.04157360f, 
    0.06375463f, 0.22521257f, 0.02088984f, 0.17793579f, 0.02500744f, -0.23806295f, -0.35639572f, -0.20735697f, 
    0.53535968f, 0.06513560f, 0.04899090f, 0.16533211f, -0.13367085f, -0.11712498f, -0.00270112f, 0.15084799f, 
    0.08602918f, 0.14109695f, 0.00791994f, -0.21006647f, -0.04010072f, 0.00982962f, -0.08198749f, -0.24816021f, 
    -0.05665351f, 0.05530083f, 0.16364428f, -0.05414003f, 0.13126484f, 0.10814375f, -0.51681125f, -0.11691180f, 
    0.05378600f, -0.10770699f, -0.01827098f, -0.04426178f, 0.28066376f, -0.06937408f, 0.03100544f, -0.07563656f, 
    0.00108718f, -0.45026895f, 0.02709459f, 0.08142216f, 0.03477972f, -0.04534972f, 0.19462910f, -0.32459065f, 
    0.14354344f, -0.00174512f, -0.00516541f, 0.12245353f, -0.23143247f, 0.09833462f, -0.21533121f, -0.33495361f, 
    -0.07460312f, -0.11101119f, -0.13908896f, 0.17592759f, 0.02574658f, 0.07255707f, 0.02802118f, -0.00461836f, 
    -0.10720824f, -0.50413191f, 0.10138905f, -0.14170684f, 0.17725632f, 0.10705917f, -0.00282441f, 0.11779688f, 
    -0.01067858f, -0.10831444f, -0.13344741f, -0.08592658f, 0.08140428f, 0.03005137f, 0.00851716f, 0.20794378f, 
    -0.01808181f, 0.07498605f, -0.00936245f, 0.22644562f, -0.04174441f, -0.11390610f, 0.14925966f, -0.23868471f, 
    0.09445600f, 0.03875906f, 0.08104455f, 0.06839642f, -0.06610674f, 0.17430863f, -0.00684866f, 0.26944810f, 
    0.11598858f, 0.09107246f, 0.06434459f, 0.13794577f, 0.15508533f, 0.08966481f, -0.38314325f, -0.00353628f, 
    -0.02286025f, -0.11409710f, 0.16745652f, -0.17132731f, -0.12423199f, -0.02307058f, 0.13244921f, 0.23387741f, 
    -0.14502336f, 0.02128764f, -0.07903094f, 0.11019672f, -0.21590233f, 0.07731818f, -0.07302550f, 0.05128472f, 
    0.01437402f, 0.08683261f, 0.16275336f, -0.49553183f, 0.02902795f, -0.25789276f, 0.01317812f, -0.03646990f, 
    0.08665049f, -0.20711933f, -0.09086467f, -0.51855302f, 0.03052805f, 0.30241284f, -0.01815606f, -0.19627997f, 
    -0.46623030f, 0.03507691f, 0.01036515f, -0.04510257f, 0.15995826f, -0.09964225f, -0.03769369f, -0.27373749f, 
    0.10336456f, -0.07712881f, -0.07982662f, 0.11421334f, -0.03610114f, -0.09029150f, -0.32193893f, 0.41098827f, 
    0.08234498f, 0.02425552f, -0.32567114f, -0.03573944f, 0.15635949f, 0.04519566f, -0.29427478f, 0.13171621f, 
    0.11465601f, 0.11047650f, 0.07100798f, -0.18076411f, -0.36633366f, -0.02809748f, -0.10324427f, 0.24605253f, 
    -0.15256961f, 0.22325742f, -0.15171038f, -0.19441260f, -0.06366543f, 0.18927324f, -0.24788235f, 0.15528031f, 
    -0.17637205f, 0.16688657f, -0.07111254f, 0.06138539f, 0.36665484f, -0.06562516f, 0.17009686f, -0.58943367f, 
    0.00110767f, -0.15581666f, 0.02840771f, 0.09833127f, -0.07598933f, -0.10706332f, -0.35838848f, -0.09369318f, 
    0.08328795f, -0.28747094f, 0.20865221f, 0.28121731f, -0.32751390f, -0.13818759f, 0.25027251f, -0.46581018f, 
    -0.10175159f, 0.02212428f, 0.07924341f, -0.46032357f, -0.86883730f, -0.09115156f, 0.11190915f, -0.37950692f, 
    -0.04411289f, 0.17697018f, -0.13060990f, 0.08979090f, 0.01207344f, -0.02829899f, -0.43655455f, 0.20300683f, 
    -0.03717694f, 0.03089275f, -0.06665152f, -0.05023243f, -0.20928335f, -0.15097727f, 0.03032641f, 0.11304589f, 
    0.02640986f, -0.08573040f, 0.06271055f, -0.03634272f, -0.12895794f, 0.08485788f, 0.12093060f, -0.14207000f, 
    -0.08010028f, 0.02080157f, 0.02382217f, -0.01850405f, -0.19511141f, 0.08032458f, 0.15433028f, -0.05854311f, 
    -0.45096266f, -0.26977307f, -0.06427605f, 0.04768742f, 0.01501196f, 0.11339089f, -0.24660698f, 0.14081870f, 
    0.07659952f, 0.22966318f, -0.13074739f, 0.35348231f, -0.03645689f, -0.13769089f, 0.13977760f, 0.04474516f, 
    0.05054139f, -0.39408076f, -0.33124870f, -0.13890573f, -0.10131621f, -0.26968437f, -0.30575675f, 0.15494397f, 
    0.20514524f, 0.05675076f, 0.05383843f, -0.09546368f, -0.47690341f, 0.05740501f, -0.07652256f, 0.51497263f, 
    -0.06857907f, -0.17400564f, -0.03607389f, 0.14274503f, 0.05324121f, 0.05364928f, 0.12901719f, 0.03696098f, 
    0.06449832f, -0.01089584f, -0.15511438f, -0.06812149f, -0.09526029f, 0.01613214f, 0.39229256f, 0.08054020f, 
    0.01794747f, -0.08311483f, 0.06227254f, -0.28697887f, -0.54698414f, 0.00915786f, -0.16906360f, -0.34738657f, 
    0.22996484f, 0.06064104f, -0.09421638f, -0.18222721f, 0.21803670f, 0.08333850f, -0.29425862f, 0.00943089f, 
    -0.61567587f, 0.16390286f, 0.04546724f, -0.38501978f, 0.07805895f, 0.02141448f, -0.22221251f, -0.03340171f, 
    -0.01393191f, 0.23397271f, 0.14119951f, -0.06954037f, 0.01140203f, -0.26530463f, 0.24983042f, 0.04349286f, 
    0.02841109f, 0.33269072f, -0.40238664f, -0.02567008f, 0.06409999f, -0.05804233f, -0.09475794f, 0.00116319f, 
    0.21441995f, -0.00131430f, -0.09330735f, -0.41992012f, -0.37126344f, -0.02267494f, -0.08763289f, -0.33004400f, 
    -0.08504192f, -0.12449079f, -0.08343532f, 0.26432678f, 0.02078363f, 0.09925119f, -0.11605933f, -0.15376990f, 
    0.11363586f, -0.00023447f, 0.05214531f, 0.01545537f, 0.25465602f, -0.44202214f, -0.21716715f, -0.08079936f, 
    0.08402811f, -0.01351729f, -0.01738935f, 0.32545456f, 0.17136946f, -0.01638557f, 0.23407649f, 0.01845245f, 
    -0.36704221f, 0.23132215f, 0.07845585f, -0.40200222f, -0.25000346f, 0.14199127f, -0.08799978f, -0.20049688f, 
    0.24706976f, -0.52415478f, -0.10182456f, 0.06250430f, -0.16613559f, 0.09481468f, 0.14516671f, -0.52801079f, 
    -0.09312814f, -0.13113645f, -0.37393156f, -0.37482157f, 0.07938067f, 0.11966158f, -0.05830802f, 0.03582260f, 
    -0.06173575f, -0.36120257f, 0.12100406f, 0.12873812f, 0.35139367f, -0.13104402f, 0.18118131f, -0.11660592f, 
    -0.34824413f, -0.08789473f, 0.08658174f, -0.42735663f, 0.04350566f, -0.10961142f, -0.01824844f, 0.18601859f, 
    -0.01904041f, -0.28903341f, 0.10627631f, -0.23103741f, 0.01145232f, 0.05040831f, -0.17293331f, -0.34978744f, 
    -0.03305232f, -0.02215563f, -0.56415451f, 0.03620411f, 0.17587197f, 0.12869968f, 0.03998376f, 0.15465462f, 
    -0.08944222f, 0.02098032f, 0.10682075f, -0.36315638f, 0.17748165f, -0.08620793f, 0.03903315f, -0.37193954f, 
    0.10246411f, -0.40872574f, -0.39996928f, 0.17565578f, -0.33833161f, -0.44069809f, -0.10660043f, 0.03533514f, 
    -0.28638011f, 0.29755765f, -0.00235799f, 0.21036431f, -0.20591842f, 0.09698937f, 0.25748822f, 0.35920185f, 
    0.00316218f, -0.13112658f, 0.30269751f, 0.08320870f, 0.09387504f, -0.33570239f, 0.28847903f, 0.06411865f, 
    -0.01348633f, 0.09039740f, 0.20330767f, 0.33082157f, -0.35839549f, 0.21423548f, 0.10059227f, -0.25481686f, 
    0.43431574f, -0.10373735f, -0.10016978f, -0.04788124f, -0.38718668f, 0.00309495f, -0.01367410f, -0.37484398f, 
    -0.10138676f, 0.04310777f, -0.00935970f, -0.06844687f, -0.02405761f, -0.03596533f, 0.07586033f, -0.17921236f, 
    -0.01579846f, 0.11521833f, 0.39054796f, -0.03154466f, 0.00540454f, -0.11796805f, -0.07207112f, -0.01154348f, 
    -0.02446612f, -0.09871759f, -0.09006558f, -0.15062003f, -0.22478494f, 0.04541708f, 0.20822167f, -0.23075478f, 
    -0.57625455f, 0.26074576f, 0.02994226f, -0.09162562f, 0.35854596f, 0.04803428f, 0.06961552f, 0.08036178f, 
    -0.07458880f, 0.33043185f, -0.11540710f, -0.46271566f, 0.01320871f, 0.01897038f, 0.18888547f, 0.26467335f, 
    0.09368847f, -0.58899784f, -0.11794789f, 0.02602770f, -0.11188475f, 0.33351550f, -0.16470963f, 0.10474445f, 
    0.01407795f, 0.27174157f, 0.18143480f, 0.31268001f, -0.22206812f, -0.18474513f, -0.65182525f, -0.29634458f, 
    -0.28130564f, -0.09565801f, 0.06773268f, -0.08521529f, -0.07713159f, 0.06839772f, 0.02611722f, -0.29704693f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09499941f, 0.00163671f, 0.17469196f, 0.02403487f, -0.12338716f, 0.10194351f, 0.13981053f, -0.07562204f, 
    -0.08044538f, 0.15396409f, -0.02715304f, 0.02104045f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
