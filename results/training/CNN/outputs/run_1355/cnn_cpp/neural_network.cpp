#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37497249f, 0.37780753f, 0.57036066f, 0.21864471f, 0.21638460f, -0.58652395f, -0.28655517f, 0.21811134f, 
    -0.03439408f, -0.42267510f, -0.55265355f, -0.42779332f, -0.36326930f, 0.12869322f, 0.52573782f, 0.19172086f, 
    -0.10131141f, 0.22535428f, 0.17832966f, 0.06729534f, -0.21191832f, 0.19376943f, 0.05192663f, -0.20620167f, 
    -0.31969655f, -0.96701044f, -1.08891749f, 0.07242111f, 0.48727459f, 0.08094721f, 0.76036870f, 0.67737806f, 
    -0.03510568f, -0.33741638f, -0.00283948f, -0.10398496f, -0.34566069f, -0.04281034f, 0.34164384f, -0.11435396f, 
    -0.03435538f, -0.14082350f, -0.31962612f, 0.23641418f, 0.33814815f, -0.19839998f, 0.11039534f, 0.24779689f, 
    0.21849030f, -0.23703519f, -1.14417386f, -0.24826263f, -0.49077007f, -1.09148431f, -0.09363607f, 0.18444435f, 
    -0.56308901f, -0.64521837f, -0.50115424f, -0.15449989f, -0.40556911f, 0.30162594f, 0.19213898f, -0.09763914f, 
    -0.16697763f, -0.33152470f, -0.90618128f, -0.11051202f, -0.56827599f, -0.25562584f, 0.26052600f, 0.11315264f, 
    -0.31850675f, 0.27408075f, 0.07908499f, 0.70055455f, 1.19278383f, 0.19249901f, 0.13771063f, -0.69395781f, 
    -0.51113820f, -0.10174103f, -0.39998177f, -0.36627972f, -0.26227409f, 0.23272763f, -0.29813489f, 0.23240297f, 
    -0.03724498f, -0.13620783f, 0.08066955f, 0.12035810f, 0.30648750f, 0.04997136f, -0.28758976f, -0.18449135f, 
    0.28490198f, -0.36181584f, -0.05736367f, 0.21579170f, 0.32892430f, -0.23728342f, 0.30449805f, 0.34150881f, 
    0.37335351f, -0.82462054f, -1.07145441f, -0.44089538f, 0.68025458f, 0.98727220f, -0.10776494f, -0.05988657f, 
    0.05338490f, 0.07959723f, 0.02367901f, -0.08780295f, -0.02239495f, 0.40362465f, 0.04025324f, -0.33369213f, 
    -0.14010061f, 0.04213552f, -0.36328158f, 0.11813491f, 0.13377312f, -0.43684921f, -0.34347621f, -0.50309342f, 
    -0.15828525f, -0.35510078f, 0.14955305f, -0.59926528f, -0.52765900f, -0.32378942f, 0.12258718f, -0.62982583f, 
    -0.30427021f, -0.24912284f, -0.64530361f, 0.20496055f, 0.13559876f, 0.31232455f, -0.11305172f, 0.28538933f, 
    0.30837211f, -0.12129270f, 0.38389671f, -0.24201657f, -0.30890957f, -0.42556491f, -0.04609886f, -0.35937440f, 
    -0.80956304f, -0.51158255f, 0.31967795f, -0.98467422f, -0.93595976f, -0.72630578f, -0.86759067f, -0.90320742f, 
    0.41585159f, 0.09177226f, 0.40091789f, 0.32814273f, 0.00244985f, 0.22609505f, -0.31747401f, -0.11986206f, 
    0.11481676f, -0.07934886f, 0.02300422f, 0.37821177f, -0.10611984f, -0.04512381f, 0.47097993f, 0.04517046f, 
    -1.17414749f, 0.27377495f, 0.93820912f, -0.16067941f, -0.23304643f, 0.18016219f, -0.37802264f, -0.07433514f, 
    -0.50783271f, -0.33430198f, 0.27136916f, -0.06537796f, 0.16542089f, 0.09532712f, -0.33319265f, -0.00016519f, 
    0.07713062f, 0.16766597f, -0.09522615f, 0.00429983f, -0.35309443f, -0.38433439f, -0.29543504f, -0.40211824f, 
    0.98915672f, -0.39682746f, -0.51492691f, -0.03249557f, -0.01246938f, 0.46897745f, 0.71430719f, 0.34014228f, 
    -0.69060278f, 0.03945261f, -0.18128519f, 0.14456765f, -0.22455730f, -0.50204682f, -0.30183735f, 0.14330158f, 
    0.07016718f, 0.29884964f, -0.27839521f, 0.03334747f, 0.03204478f, -0.12281401f, -0.20507838f, 0.12410188f, 
    0.03666269f, 0.46917722f, 0.43338943f, 0.62774277f, -0.07900247f, 0.04516184f, -0.66467464f, 0.18298051f, 
    -0.02377998f, -0.19758847f, -0.21899213f, -0.05096954f, 0.35331014f, 0.01226285f, -0.05184317f, -0.26388952f, 
    0.02898943f, -0.46769252f, -0.04509567f, 0.14946716f, 0.21970253f, -0.09033098f, 0.25163716f, 0.12081431f, 
    -0.06436002f, -0.03454098f, -0.04947636f, 1.00638723f, 0.20680371f, -0.24475795f, -0.50786245f, -0.54638046f, 
    -0.34565791f, 0.04587875f, 0.37901545f, 0.26815420f, -0.39853838f, -0.28788567f, 0.07309784f, 0.47043109f, 
    -0.38300642f, 0.19595455f, -0.12550943f, -0.19424081f, 0.39229238f, 0.43423983f, -0.00031396f, 0.15437487f, 
    -0.05762740f, -0.10426971f, -0.22041300f, -1.04220855f, -1.30314791f, -0.58134121f, 0.55156142f, 0.60976607f, 
    0.89360273f, 0.40942958f, 0.15210046f, 0.22678220f, -0.05279509f, 0.29610652f, -0.26770085f, -0.22712348f, 
    0.21215566f, -0.07758630f, -0.11107003f, 0.23038158f, 0.05615052f, -0.30602854f, -0.43553653f, -0.14227273f, 
    -0.17015082f, 0.01734370f, -0.04678840f, -0.05460765f, 0.53865445f, 0.56654882f, -0.19954039f, -0.58342201f, 
    0.09568627f, -0.01689632f, 0.22986181f, 0.29238760f, 0.14886524f, -0.30558553f, -0.04314387f, -0.07863285f, 
    0.03994168f, -0.28725836f, -0.21296360f, 0.05980288f, -0.09855658f, 0.23729166f, -0.21333988f, 0.00794888f, 
    0.08340698f, -0.13972636f, -0.40504101f, -0.15634745f, -0.40970668f, -0.08790912f, -0.32336539f, 0.31180522f, 
    -0.04466012f, 0.04383368f, 0.38523212f, 0.46123642f, -0.30935830f, -0.11323150f, 0.27519134f, 0.11650737f, 
    0.02781745f, 0.03626427f, -0.08197333f, 0.34459534f, -0.21547382f, 0.26477477f, 0.07737014f, -0.34575915f, 
    -0.11843593f, 0.01862478f, 0.08812021f, -0.19503252f, 0.13041760f, 0.18192582f, -0.25768372f, 0.05396155f, 
    0.04676425f, -0.19659448f, 0.08218061f, 0.38643479f, 0.36859316f, -0.34887165f, 0.07973447f, -0.01355461f, 
    0.18037629f, 0.40635437f, -0.24752782f, -0.03713224f, -0.22320369f, -0.13346323f, -0.21777961f, -0.12973638f, 
    0.07575256f, -0.25455469f, 0.24077271f, 0.18129988f, -0.20601118f, 0.00451304f, 0.32185113f, 0.98250401f, 
    0.70555222f, -0.08372588f, -0.95517641f, -1.51796758f, -0.01822724f, 0.34939641f, 0.26029664f, 0.18929715f, 
    -0.06376889f, 0.02686287f, 0.24222662f, -0.06639124f, 0.16949870f, -0.15606575f, -0.17833942f, 0.02953012f, 
    -0.33536747f, -0.07708643f, 0.18130305f, 0.21459892f, -0.09922735f, 0.04502648f, -0.12201242f, 0.30639201f, 
    -1.53503895f, -0.15917908f, -0.90234876f, -0.77270555f, -0.96604317f, 0.94378495f, 0.75150102f, -0.03436451f, 
    -0.12571557f, 0.81767732f, 0.31613293f, 0.15511534f, -0.03835915f, -0.20064133f, 0.25381103f, -0.09391585f, 
    0.07948345f, -0.10098625f, -0.09337184f, 0.00844937f, -0.11276675f, -0.20991510f, -0.00674354f, 0.07165945f, 
    -0.24618345f, 0.41187587f, -0.25932503f, 0.29481444f, 0.46924841f, 0.17766105f, 0.52995086f, -0.19593409f, 
    0.14750129f, 0.15160528f, 0.03349726f, -0.15167487f, 0.45627052f, -0.05637792f, -0.58028418f, -0.26756817f, 
    -0.19145359f, 0.41017678f, -0.35178831f, -0.21536832f, -0.51727307f, 0.09133098f, 0.10736191f, -0.16355678f, 
    -0.24904269f, 0.08694782f, -0.81089127f, -0.00706381f, 0.42210928f, 0.21349196f, 0.33924323f, 0.05572174f, 
    0.17924446f, -0.35814878f, -0.11036965f, -0.38560432f, -0.05747147f, -0.17761911f, -0.19246528f, 0.30224431f, 
    0.02520993f, 0.18209161f, -0.39180592f, -0.05264050f, 0.11461437f, -0.08518861f, 0.05467594f, 0.16695188f, 
    0.12370361f, 0.09882280f, -0.07814080f, -1.12920499f, -0.65952879f, -0.43052968f, -0.40539503f, -0.14050731f, 
    -0.20680143f, -0.64085191f, -0.35336986f, -0.47030163f, 0.37531844f, -0.44259360f, -0.45090917f, 0.27116990f, 
    -0.00386901f, -0.45389894f, 0.04783858f, -0.22751381f, -0.42142004f, 0.08011597f, -0.06692082f, -0.05047039f, 
    -0.10208592f, -0.33154491f, -0.27498820f, -0.20232521f, -1.19642270f, -0.26931569f, -0.27383554f, 0.87544918f, 
    0.67621094f, -0.35750982f, -0.49230790f, -0.17575558f, 0.66771567f, 0.63489276f, 0.17277989f, 0.07617030f, 
    -0.06696342f, 0.11199498f, 0.15742990f, -0.15928765f, -0.30436853f, 0.11184011f, -0.28743711f, 0.19898924f, 
    -0.23897234f, -0.24519330f, 0.18096292f, 0.27157602f, 0.05357459f, 1.09697247f, -0.58873558f, -0.85850412f, 
    -0.33044016f, 0.58344144f, 0.60221797f, 0.25197837f, -0.21290272f, -0.47026089f, -0.29217601f, -0.30933750f, 
    0.13576955f, -0.24564065f, -0.11853486f, 0.21167465f, 0.07237734f, -0.07992503f, -0.12756683f, 0.00849791f, 
    -0.43022609f, 0.30816448f, 0.00722630f, 0.21857269f, 0.09241141f, 0.30935168f, 0.47024307f, -0.37779173f, 
    0.11164427f, 0.04994466f, -0.38373542f, 0.81779069f, -0.60934538f, 0.14523269f, 0.27001402f, 0.37885413f, 
    -0.09456863f, 0.11727306f, -0.36765811f, 0.15351108f, -0.24469309f, -0.04301427f, -0.16519578f, -0.13673985f, 
    -0.06707356f, 0.31382319f, -0.08460919f, -0.07090660f, -0.05950493f, 0.39788023f, -0.18516554f, 0.41230214f, 
    -0.09275210f, -0.06116521f, 0.06177680f, 0.37174374f, -0.24523303f, 0.30955729f, 0.24545059f, 0.08845332f, 
    -0.25241759f, 0.35953298f, 0.06830680f, 0.00184357f, -0.74591398f, 0.23849948f, -0.25919655f, -0.13895629f, 
    -0.19236755f, -0.21703924f, 0.15662959f, 0.13075125f, -0.07004963f, -0.14845777f, 0.00288418f, 0.24873087f, 
    0.13201104f, 0.58971101f, -0.08069755f, -0.52311063f, -0.28855065f, -0.07534941f, -0.12829775f, 0.10960456f, 
    0.13387467f, 0.11241208f, 0.14982338f, -0.02238042f, -0.22760664f, -0.20433584f, -0.40543506f, -0.14277270f, 
    0.00066935f, 0.02397849f, -0.05888278f, -0.39237535f, -0.48410431f, -0.39671484f, -0.64083940f, -0.63081187f, 
    -0.76871192f, -0.05965262f, 0.32358307f, -0.07245220f, 0.28736421f, -0.35282680f, -0.24420582f, 0.02697886f, 
    -0.04624661f, 0.47529855f, -0.31130105f, -0.42701715f, -0.13047807f, 0.14637479f, 0.09143106f, 0.05630321f, 
    -0.09673689f, 0.20125933f, -0.04997044f, -0.75695825f, 0.28967512f, 0.03037300f, 0.00152560f, -0.00092702f, 
    -0.02923420f, -0.03650487f, 0.68861037f, 0.72105545f, 0.48319843f, 0.36341825f, -0.09317166f, -0.13031316f, 
    0.24956088f, 0.25794518f, 0.06782504f, 0.05648675f, 0.22015318f, 0.01921315f, -0.08695636f, -0.02564380f, 
    -0.16936111f, 0.14775620f, 0.14919566f, 0.07319986f, 0.02051166f, -0.20936479f, -0.08773480f, 0.18024433f, 
    0.04596519f, -0.14731538f, 0.09074441f, -0.74480313f, -0.15222153f, -0.08098466f, 0.45464611f, -0.03193799f, 
    0.15724154f, 0.21040002f, 0.01007002f, -0.06286466f, -0.17100945f, -0.08958432f, -0.12434328f, 0.21191840f, 
    0.41426441f, -0.69309437f, 0.05133671f, -0.08538587f, -0.07017932f, -0.36418304f, -0.26927656f, 0.47844383f, 
    -0.08018203f, 0.10771815f, 0.36436352f, 0.47386920f, 0.24026887f, 0.34242359f, 0.44504172f, 0.32313022f, 
    0.16992150f, 0.19344255f, -0.04374141f, -0.25648946f, 0.04268290f, 0.05905397f, 0.00986636f, -0.11923890f, 
    -0.09693643f, -0.01289348f, 0.11324726f, -0.04796058f, 0.06254350f, 0.06724921f, -0.11099573f, -0.20564835f, 
    -0.28461891f, -0.10039985f, -0.33927736f, -0.27992716f, -0.49666476f, 0.15906432f, -0.28191859f, -0.48770967f, 
    0.08309039f, -1.04111707f, -0.61843002f, -0.27812576f, -0.72299010f, -0.93471992f, -0.74047911f, 0.42847383f, 
    0.53905046f, 0.24173284f, -0.39472711f, -0.35471335f, -0.02703597f, 0.22455534f, 0.25421345f, 0.25843209f, 
    -0.19494663f, -0.32370445f, -0.26412779f, -0.05871737f, -0.05202187f, -0.40606305f, -0.36217490f, -0.38726881f, 
    -0.56841677f, -0.47018790f, -0.12673290f, -0.27794859f, -0.42090449f, 0.27490890f, 0.43019074f, 0.14774540f, 
    -0.45805451f, -0.26208693f, 0.20797557f, -0.30512288f, -0.27881220f, -0.26270217f, -0.17626549f, -0.20816924f, 
    -0.51143909f, -0.35632926f, -0.57636541f, -0.10846563f, 0.10407703f, -0.36218065f, -0.47547773f, -0.17782772f, 
    0.19917762f, 0.38503000f, -0.15357535f, -0.02032086f, 0.42559308f, 0.24741451f, -0.17247508f, 0.08372649f, 
    0.26505134f, 0.41769564f, -0.11920700f, 0.20468071f, -0.28309485f, 0.06394831f, 0.29855937f, -0.26308477f, 
    0.07408167f, 0.23733188f, -0.39070916f, -0.04477277f, -0.12773700f, 0.16826029f, 0.27871895f, 0.33251736f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06451523f, 0.24825582f, 0.09093076f, 0.35348091f, 0.39581132f, 0.06432189f, -0.03176621f, 0.08360130f, 
    0.36503565f, 0.34066704f, 0.41560176f, 0.05485029f, 0.30217898f, 0.14440835f, 0.36862293f, 0.54580295f, 
    0.21863709f, 0.30536187f, 0.12278958f, 0.09650116f, 0.31078634f, 0.13597310f, 0.50637335f, 0.46598384f, 
    -0.15208818f, 0.37930346f, -0.14316851f, 0.14534485f, 0.02472889f, -0.09042040f, 0.02705908f, 0.02390525f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21429951f, 0.07410612f, 0.27662471f, -0.00918283f, 0.02834325f, -0.17340425f, -0.01975717f, -0.08600056f, 
    0.03545172f, -0.05322092f, -0.05343460f, 0.06664186f, 0.68035990f, -0.23103100f, -0.30412564f, -0.23894045f, 
    0.20087753f, 0.02511231f, 0.05294928f, -0.03591850f, -0.02501590f, -0.06673366f, -0.11083701f, 0.04629938f, 
    0.31801093f, 0.26773968f, -0.16850041f, -0.19095024f, -0.00786680f, 0.18051778f, -0.00394292f, -0.13869071f, 
    -0.03369419f, -0.24475914f, -0.01189557f, -0.07993979f, -0.13915856f, -0.36457998f, -0.21523494f, -0.05941727f, 
    0.05824256f, -0.05918581f, -0.08373652f, -0.22858216f, -0.00504932f, -0.01069968f, 0.06421465f, 0.05244163f, 
    -0.64824337f, 0.33969325f, 0.27202615f, -0.39630923f, -0.04365516f, 0.00238080f, -0.03384665f, 0.01073730f, 
    -0.04695679f, -0.22001839f, -0.04738639f, 0.04153593f, 0.31123516f, 0.36947238f, 0.04667519f, -0.09302028f, 
    0.09117748f, 0.37544769f, 0.16079047f, -0.04279928f, 0.03157133f, 0.09057880f, -0.01453884f, 0.02325479f, 
    0.37378901f, 0.42302904f, -0.35504788f, -0.21276602f, -0.00324171f, -0.08313045f, 0.10729951f, -0.08748427f, 
    0.00331605f, -0.00415814f, 0.01664056f, -0.06728379f, 0.23938547f, -0.06168792f, 0.12921663f, -0.46203980f, 
    -0.03299838f, -0.24713705f, -0.13258843f, -0.19314717f, 0.09921674f, -0.17411411f, -0.14884613f, 0.06312466f, 
    0.03787728f, -0.22649708f, -0.93659401f, -0.13170040f, -0.04049171f, -0.01764956f, 0.08455233f, -0.01931290f, 
    -0.06570058f, -0.03915135f, 0.01777149f, -0.10225528f, -0.44334882f, -0.28554899f, 0.08946925f, -0.04397911f, 
    0.03223374f, 0.02589735f, -0.03300780f, 0.03061375f, -0.04803465f, 0.04203153f, 0.00366225f, 0.04040341f, 
    -0.48427323f, -0.03859519f, 0.13065420f, 0.05219517f, -0.07636115f, -0.01210587f, -0.09949355f, -0.28584525f, 
    0.15752472f, -0.12368986f, 0.05518201f, -0.02141632f, 0.57366437f, -0.02000290f, -0.01491845f, -0.14057234f, 
    0.09136932f, 0.15395474f, 0.14444712f, 0.03606313f, 0.02813273f, 0.07931671f, -0.12973148f, 0.06012585f, 
    -0.46330288f, -0.42660812f, -0.44016558f, 0.16958991f, 0.06893229f, 0.03851049f, -0.01699937f, -0.01976549f, 
    -0.02915386f, -0.13054100f, -0.08657665f, -0.04911026f, -0.00921306f, -0.02821400f, -0.08813703f, 0.00819404f, 
    -0.05625977f, 0.04972303f, 0.06096596f, -0.02342897f, -0.03639833f, -0.11322232f, -0.02558361f, -0.16995075f, 
    -0.30422232f, -0.11964885f, -0.36910260f, -0.08438975f, 0.00064401f, 0.07190400f, 0.01436963f, -0.01979206f, 
    -0.11624613f, -0.00824611f, -0.08216431f, -0.26517168f, -0.00468947f, -1.08949780f, -0.42811984f, 0.09513739f, 
    -0.09068680f, -0.03540428f, -0.39620292f, -0.14441681f, -0.13109636f, -0.07573196f, -0.00430153f, -0.22624634f, 
    0.15171425f, 0.12343559f, -0.19106579f, -0.02982373f, 0.16760378f, 0.14405900f, 0.04358643f, 0.00605766f, 
    0.02038609f, -0.05903443f, 0.09974217f, 0.08471522f, -0.37944198f, -0.33249208f, 0.21749263f, 0.35053170f, 
    0.02168153f, 0.03660251f, 0.10564315f, 0.07079295f, -0.05180749f, 0.09984063f, 0.07656426f, -0.08406135f, 
    0.10294097f, -0.04607216f, -0.08791556f, -0.20798598f, 0.18169659f, -0.00771646f, 0.11354948f, -0.01490328f, 
    -0.02466455f, -0.00995541f, -0.06837339f, -0.06179333f, 0.44589856f, 0.29550418f, 0.10265408f, -0.11775719f, 
    0.18983121f, 0.26252121f, 0.05610047f, 0.03788692f, -0.10203880f, -0.13189299f, -0.07363639f, -0.07441734f, 
    0.25333390f, 0.20410089f, 0.32738334f, -0.20135202f, -0.06419002f, 0.13273749f, -0.02326222f, 0.05530611f, 
    0.03487159f, -0.06249296f, 0.00955875f, -0.06225828f, 0.06195283f, 0.13262185f, -0.67237532f, 0.26565975f, 
    -0.04635010f, -0.21409798f, 0.05559366f, -0.10364868f, -0.07703254f, -0.10702322f, -0.04951395f, -0.15607010f, 
    -0.15722284f, -0.64047831f, -0.02788763f, -0.09846391f, -0.04937221f, -0.00249589f, -0.01296277f, 0.00415729f, 
    0.00247584f, -0.07365101f, -0.27371809f, -0.12229168f, -0.46377397f, -0.78079754f, -0.24585412f, 0.05035222f, 
    -0.08346540f, 0.02236735f, 0.01813237f, -0.03897160f, -0.02542347f, -0.08874814f, 0.02291238f, -0.06100373f, 
    -0.42475110f, -0.13866653f, -0.13310023f, 0.13118272f, 0.03130079f, -0.00547165f, -0.09793105f, -0.02471481f, 
    -0.10665122f, 0.01977185f, 0.15156430f, 0.15603969f, -0.51049703f, -0.38516057f, 0.22747946f, -0.12054855f, 
    -0.04701419f, 0.03442228f, -0.06357664f, 0.05579731f, -0.02287465f, -0.03814460f, -0.03105414f, -0.23057996f, 
    -0.08230401f, -0.11877155f, -0.08357956f, 0.07492995f, 0.10170432f, 0.04682517f, 0.00862750f, 0.03306311f, 
    -0.03691458f, 0.06354145f, 0.00040695f, 0.05291345f, 0.08164650f, 0.06377346f, -0.05069057f, -0.05571260f, 
    0.03786632f, -0.10463605f, 0.15763433f, 0.06954890f, -0.07872695f, -0.02011336f, -0.14320686f, -0.17890288f, 
    -0.36239278f, -0.12148273f, 0.05936384f, 0.08557836f, 0.04890173f, 0.03231841f, -0.01233080f, 0.05763810f, 
    -0.09596825f, 0.05078093f, 0.02238631f, 0.18434583f, 0.41746718f, 0.20108777f, -0.28679714f, -0.15245035f, 
    0.29530933f, -0.01695126f, 0.07674423f, 0.18020311f, 0.08713442f, 0.08258176f, -0.05574161f, 0.12687702f, 
    0.16473576f, 0.17794636f, 0.13859078f, 0.09270209f, -0.07171687f, -0.01524011f, -0.12728426f, -0.16936657f, 
    -0.15804283f, -0.14112441f, -0.03072339f, 0.22054729f, -0.01731247f, -0.02913428f, 0.02961476f, 0.05584647f, 
    -0.07438038f, -0.03600267f, -0.02359327f, -0.00652749f, -0.22232759f, -0.34021294f, -0.34024790f, 0.02161093f, 
    -0.15848304f, -0.04220447f, -0.12701516f, -0.23723423f, 0.12430892f, -0.42073527f, -0.16219141f, 0.11299589f, 
    -0.09148749f, 0.15668510f, -0.00038175f, -0.17438853f, 0.13788189f, -0.30073041f, 0.22263493f, 0.04976771f, 
    -0.00522390f, 0.04333130f, 0.14163680f, 0.09131018f, 0.09461807f, -0.13546838f, 0.17937087f, -0.10812742f, 
    -0.05201221f, -0.00324529f, 0.15814817f, 0.48210859f, 0.12077582f, 0.29750338f, 0.03069436f, 0.32399547f, 
    0.00777930f, -0.01532233f, 0.02294862f, 0.00598718f, 0.07096430f, -0.11415739f, 0.05856351f, -0.49053004f, 
    -0.31535360f, -0.16329737f, -0.28831920f, -0.22766933f, -0.07314814f, -0.02437542f, -0.02105732f, 0.06485202f, 
    -0.61471385f, 0.23988959f, 0.24359213f, -0.05890624f, 0.01347613f, 0.01446796f, -0.08672750f, 0.11601098f, 
    0.00352768f, 0.00268598f, 0.09719152f, 0.03927623f, 0.07899491f, 0.17195919f, -0.09059703f, -0.09759863f, 
    0.14545943f, -0.02118229f, -0.43344522f, -0.21681769f, -0.08940665f, -0.01953910f, -0.10471496f, -0.05311310f, 
    -0.04581350f, 0.00636728f, 0.04160303f, 0.08881849f, -0.16395263f, 0.03989915f, 0.09789532f, -0.26812211f, 
    -0.09981875f, 0.01327500f, -0.01377445f, 0.10294566f, -0.05852000f, -0.08548621f, -0.10882670f, -0.46067241f, 
    0.02653675f, 0.03738479f, 0.09225139f, -0.04456145f, 0.04925061f, -0.56895292f, 0.27675861f, -0.11250243f, 
    0.97142065f, -0.08552756f, 0.24224368f, -0.05479402f, -0.12735066f, -0.08647929f, -0.01058181f, -0.07054713f, 
    0.17234510f, -0.06114839f, -0.09785664f, 0.19645716f, 0.33970279f, -0.00873557f, 0.09074379f, -0.14025417f, 
    -0.06683180f, -0.08568703f, -0.08400685f, 0.00018352f, -0.06681567f, 0.01466045f, 0.05672596f, -0.00566794f, 
    -0.06931595f, -0.02244339f, 0.06283376f, -0.11811155f, -0.08453631f, -0.02461226f, -0.09266186f, -0.00710277f, 
    -0.01983328f, -0.05898808f, 0.02742858f, -0.04570065f, 0.06023626f, -0.44294345f, -0.14562166f, -0.07937825f, 
    -0.11002782f, -0.09429702f, 0.09871713f, 0.02700076f, 0.10778792f, -0.03879978f, -0.09759858f, -0.08865424f, 
    0.21557045f, -0.10629170f, 0.18527295f, 0.05796174f, -0.01230633f, -0.07210493f, -0.07290439f, 0.01652401f, 
    -0.10880817f, 0.07040709f, -0.08441660f, 0.06640057f, 0.11497970f, 0.03051304f, -0.01366916f, 0.05100707f, 
    -0.04876020f, -0.05651208f, -0.00435627f, -0.04298189f, -0.00854110f, 0.03742634f, 0.14540170f, -0.13216896f, 
    0.07586476f, 0.03925416f, 0.02649205f, -0.01441960f, -0.06354954f, -0.10516018f, 0.00070160f, 0.13526893f, 
    0.07532573f, -0.08742566f, -0.04390232f, 0.12923647f, 0.54143989f, -0.49507880f, -0.13417840f, -0.58705986f, 
    -0.00411155f, 0.08545138f, 0.10484075f, -0.03696964f, 0.18985438f, 0.21867292f, -0.10210564f, 0.05599993f, 
    0.34371203f, 0.00865160f, -0.24908142f, -0.23852378f, 0.01159439f, 0.02328035f, -0.02518371f, -0.17937425f, 
    -0.02045070f, -0.03538499f, 0.02401517f, -0.11424445f, 0.50505370f, 0.32363835f, 0.12297778f, 0.21491015f, 
    -0.02016800f, -0.02586173f, -0.02909923f, 0.08172561f, 0.06258521f, 0.12413101f, -0.26629269f, 0.10979275f, 
    -0.18588182f, -0.43634915f, -0.03689496f, 0.01345078f, -0.09584748f, -0.13738275f, 0.06774834f, 0.04406499f, 
    -0.07332207f, 0.06913590f, 0.18091533f, -0.11147049f, 0.13660800f, 0.09533743f, -0.17338343f, 0.41673419f, 
    -0.02385682f, 0.12648746f, 0.01807050f, -0.30095017f, 0.03370735f, 0.02951619f, -0.03878083f, -0.05858250f, 
    -0.39306253f, 0.19053487f, -0.03967638f, -0.02833913f, -0.02677625f, -0.04633996f, -0.00159553f, 0.01835079f, 
    0.04364703f, 0.15713321f, -0.18826559f, 0.08581965f, 0.85139698f, -0.06507378f, -0.32806575f, 0.04823183f, 
    -0.26975337f, 0.04568034f, 0.09610587f, -0.07726913f, -0.10468315f, 0.00475362f, -0.04904998f, 0.01023892f, 
    0.41408333f, 0.36967942f, -0.10779209f, -0.24683094f, -0.04318708f, -0.10214808f, -0.06283385f, -0.00828569f, 
    0.03909451f, 0.08387569f, 0.03291591f, -0.16259342f, 0.28231683f, -0.00243035f, 0.17979161f, 0.19973162f, 
    0.01009662f, -0.00313369f, 0.07638331f, -0.10916717f, 0.05369836f, 0.12597124f, -0.13544253f, 0.02652653f, 
    -0.05595597f, 0.09122108f, 0.23533753f, -0.06324543f, -0.02490437f, -0.01661958f, -0.17402260f, 0.07243510f, 
    -0.37417313f, -0.47077250f, -0.38964465f, -0.07133754f, 0.04328624f, 0.22372045f, 0.12618968f, -0.17379402f, 
    -0.00631124f, 0.00733102f, -0.00435316f, -0.00418895f, -0.00505524f, -0.01662282f, -0.06717371f, -0.04504311f, 
    0.30789152f, 0.17189221f, 0.17648268f, 0.09334091f, -0.11059600f, -0.02582701f, -0.10434640f, -0.07657498f, 
    -0.07048120f, 0.05887147f, -0.00241945f, 0.04282454f, -0.40969548f, -0.00402571f, 0.19849096f, 0.09477319f, 
    0.01661216f, 0.03984913f, 0.09115818f, -0.01677430f, 0.00818928f, -0.17321619f, 0.06516362f, 0.16953693f, 
    0.13124683f, 0.14519885f, 0.15392405f, 0.10621027f, 0.02561421f, 0.02980255f, 0.01064085f, 0.04246944f, 
    0.08840755f, 0.14778756f, 0.06210065f, -0.12630002f, 0.04088596f, 0.11051731f, -0.22234249f, -0.28360766f, 
    -0.28093258f, -0.08151612f, -0.30539456f, 0.05674328f, -0.04311266f, -0.04387089f, -0.04361132f, 0.17229253f, 
    -0.24396825f, 0.27067864f, -0.13046825f, -0.05985731f, 0.10873730f, 0.12496891f, 0.02554945f, 0.02385598f, 
    -0.02228163f, -0.05689765f, -0.13149889f, -0.44986761f, -0.05207289f, 0.08571863f, 0.05550319f, 0.07119200f, 
    -0.04755031f, 0.04995846f, 0.04778603f, 0.02677498f, -0.12949611f, 0.02755952f, 0.09428094f, -0.05845594f, 
    -0.02714260f, 0.21181321f, -0.21328965f, 0.14697006f, -0.08157235f, 0.10550202f, 0.09358337f, -0.29770324f, 
    -0.00697082f, 0.03445812f, -0.03531267f, -0.02915713f, -0.01350982f, -0.06585170f, 0.55033612f, 0.11393750f, 
    0.08904813f, -0.09147963f, 0.17255647f, 0.11813937f, 0.02792069f, -0.06894454f, 0.13237745f, -0.09938011f, 
    0.08991500f, -0.13835095f, 0.00752730f, 0.50488561f, -0.00157779f, -0.07241918f, -0.01697722f, 0.10573258f, 
    0.01752787f, 0.01766523f, -0.03340323f, -0.06435601f, -0.36126012f, -0.19176544f, 0.68659848f, -0.36559013f, 
    0.25957206f, 0.21672040f, -0.46842083f, 0.03829851f, 0.06039047f, -0.19765130f, 0.14883156f, 0.01418357f, 
    -0.63479543f, -0.02213673f, 0.11976553f, 0.28679222f, -0.09841717f, 0.17424606f, -0.00478289f, -0.05224389f, 
    0.08924861f, -0.02661610f, 0.11905867f, -0.09139334f, -0.75924867f, -0.52976334f, 0.18125869f, 0.28826937f, 
    -0.23988296f, -0.08671303f, -0.06332624f, 0.01567478f, -0.03581769f, 0.02706048f, -0.09159210f, -0.01361973f, 
    -0.99318016f, -0.77691573f, -0.37336904f, -0.21300459f, -0.01972559f, -0.02414420f, -0.11893082f, 0.00365214f, 
    0.03980712f, -0.04932970f, -0.03363680f, -0.07236872f, 0.01755526f, 0.13351531f, -0.16695647f, 0.01210139f, 
    0.01787730f, -0.08692316f, -0.08186597f, 0.08608989f, 0.03692123f, 0.08071093f, 0.12476546f, -0.14011991f, 
    -0.22277230f, 0.02389231f, 0.19868578f, -0.14408930f, 0.02118626f, -0.09199295f, 0.07733115f, 0.03739986f, 
    0.09142009f, 0.03147209f, -0.06591959f, 0.02440176f, -0.04686376f, -0.07310455f, 0.19168811f, -0.41348830f, 
    0.03200226f, 0.10356079f, 0.05951596f, 0.08264316f, 0.03065861f, -0.05883126f, 0.01330866f, 0.05959325f, 
    0.12513974f, -0.06760665f, 0.07705237f, 0.11392393f, 0.03995867f, 0.17856574f, -0.27809456f, 0.18871935f, 
    -0.04701569f, 0.08838797f, 0.00409265f, 0.04732031f, -0.09850895f, -0.22944985f, 0.72038412f, 0.12177453f, 
    -0.01616345f, -0.00762032f, 0.10567231f, 0.16499351f, 0.07921835f, -0.03042484f, -0.10544444f, -0.02142642f, 
    0.03734142f, 0.00502995f, 0.01893689f, -0.07781851f, 0.03130516f, -0.07705782f, -0.01342498f, 0.00539626f, 
    0.09787168f, 0.17147171f, 0.19324417f, 0.10685319f, 0.11695483f, -0.18567061f, 0.09906404f, -0.01013622f, 
    0.05309461f, 0.04548977f, -0.03889588f, 0.04984559f, -0.15766101f, -0.14711288f, 0.04478891f, 0.09071843f, 
    0.13504741f, -0.31034553f, -0.21450908f, -0.26065919f, 0.16155389f, 0.01872951f, 0.06140001f, 0.24233902f, 
    -0.02941434f, -0.25132424f, 0.04438239f, -0.04506674f, -0.26773992f, 0.69568372f, -0.05798119f, -0.27341402f, 
    -0.01104947f, 0.01849449f, -0.39635375f, 0.14172235f, 0.08094796f, -0.03600862f, -0.32285500f, -0.00715557f, 
    0.36237958f, -0.00146610f, 0.67474097f, 0.36199990f, -0.09866055f, -0.11853494f, 0.07126044f, 0.04236238f, 
    -0.05281239f, 0.11286504f, 0.04091905f, 0.16597857f, -0.20912923f, 0.05943124f, -0.49825585f, -0.19730204f, 
    -0.04729285f, -0.00618831f, 0.02096026f, 0.01098604f, -0.00412374f, -0.06391500f, -0.04550547f, 0.00691612f, 
    0.07990088f, 0.12568477f, -0.18855202f, 0.14537968f, 0.03531516f, -0.26158732f, -0.02913305f, -0.00324912f, 
    -0.09094623f, -0.02076664f, 0.01651493f, -0.06669381f, -0.08588519f, -0.02756525f, 0.11485089f, 0.50728399f, 
    -0.11076842f, -0.00127955f, -0.20630233f, 0.01315271f, 0.01179690f, 0.00914840f, 0.00969477f, -0.05107404f, 
    0.02212814f, -0.00036208f, -0.21017534f, 0.21180674f, 0.03577777f, 0.02578168f, -0.01719359f, 0.07215529f, 
    -0.07949142f, 0.04887662f, -0.25396279f, -0.03724945f, -0.37895864f, -0.03536697f, 0.10115993f, -0.04924644f, 
    -0.11476386f, -0.06706023f, 0.03562982f, -0.12465201f, 0.01481652f, 0.04136645f, -0.07371959f, -0.10525285f, 
    -0.40477717f, 0.47379228f, -0.20773965f, 0.09163401f, 0.01115300f, -0.05612272f, 0.02843142f, 0.06476285f, 
    -0.07116704f, 0.23707817f, 0.11400017f, 0.04257800f, 0.22139382f, 0.08036374f, -0.27154046f, 0.10153745f, 
    0.08585226f, 0.07460846f, 0.02031878f, 0.05722658f, 0.06468911f, 0.10136805f, -0.19821583f, 0.04038682f, 
    -0.03235307f, -0.02381020f, -0.01562512f, -0.02037626f, -0.01535484f, -0.09119488f, -0.00807777f, -0.11432633f, 
    0.18601771f, 0.12320597f, 0.12520386f, 0.25630540f, -0.11154749f, -0.23109157f, -0.27891529f, 0.16506499f, 
    0.05941229f, -0.00561539f, -0.02052924f, 0.03392051f, 0.05449418f, -0.03413639f, -0.09797488f, 0.07863304f, 
    -0.38171327f, -0.34929889f, -0.03833165f, -0.13886768f, 0.02541692f, -0.06276199f, -0.04647392f, 0.00929609f, 
    -0.01196575f, -0.10944567f, 0.01012333f, 0.02894090f, 0.03157359f, -0.16051783f, -0.23347580f, -0.03629135f, 
    0.08603816f, -0.02169333f, 0.04351556f, 0.05551181f, -0.01591020f, -0.09016149f, 0.06055312f, -0.17729498f, 
    -0.18887785f, -0.04678259f, -0.04020863f, -0.15735945f, 0.05877569f, -0.04895634f, 0.01141594f, 0.06118472f, 
    -0.10438238f, -0.05408475f, -0.00930635f, 0.12878788f, -0.56497204f, -0.36250541f, -0.07853370f, -0.53255868f, 
    -0.17608969f, 0.11400682f, -0.08375581f, -0.52730596f, 0.03704025f, -0.04725509f, 0.07868075f, -0.04874799f, 
    -0.24421330f, 0.34827560f, 0.13708884f, 0.50864089f, -0.09316101f, -0.02814152f, 0.19417894f, -0.04625979f, 
    -0.03916365f, -0.01248342f, 0.05146222f, 0.03656202f, -0.01229069f, -0.11256590f, 0.05192529f, -0.09075465f, 
    0.12853301f, -0.00717145f, -0.05780198f, 0.05287436f, -0.13535060f, -0.10859638f, 0.24056511f, 0.07786668f, 
    0.62734842f, 0.20772760f, 0.24393903f, -0.03000516f, -0.14219855f, 0.14089625f, -0.04342390f, 0.15278605f, 
    0.18025225f, -0.00846889f, 0.28320280f, 0.21705651f, -1.00976717f, 0.89883506f, -0.28187570f, -0.43928924f, 
    0.15730646f, 0.33037972f, -0.03109342f, 0.09836695f, -0.15558246f, -0.19262403f, 0.06540424f, -0.08620783f, 
    0.07686376f, -0.12742031f, -0.09018008f, 0.11290154f, 0.06406549f, -0.05801834f, 0.02376242f, 0.05009404f, 
    -0.06860460f, 0.16277532f, -0.09036861f, 0.03586747f, -0.51190913f, -0.33979863f, 0.45172432f, 0.19471481f, 
    -0.17819588f, 0.28479379f, 0.03105911f, 0.02087933f, 0.01999008f, 0.05079488f, -0.04317321f, -0.05052922f, 
    0.11075524f, -0.17884821f, 0.00454390f, -0.16539596f, -0.27721938f, -0.31871486f, -0.23011377f, -0.41111052f, 
    -0.07882775f, -0.00186667f, -0.00787678f, -0.12648152f, 0.05377662f, -0.09836649f, -0.07617956f, 0.16024815f, 
    -0.03076528f, -0.07554021f, -0.09302802f, 0.06750878f, 0.03578039f, 0.15256590f, -0.08693272f, 0.16788310f, 
    0.01657744f, -0.16042913f, -0.05175996f, 0.31285733f, 0.16035028f, 0.09774229f, 0.09042101f, 0.17318462f, 
    0.08611445f, -0.12570736f, 0.10587924f, -0.33328393f, -0.33566564f, 0.37480882f, -0.25417212f, 0.60734010f, 
    -0.06803519f, -0.09877710f, 0.06986709f, -0.06653032f, -0.21116234f, 0.01667688f, -0.02293111f, 0.14654139f, 
    -0.09656669f, 0.62978536f, -0.06929306f, 0.00251048f, 0.08084667f, -0.04991706f, 0.15153609f, -0.02088293f, 
    -0.03758878f, 0.09064806f, 0.03497226f, -0.04312979f, -0.45992795f, -0.05810307f, 0.39393702f, -0.07063480f, 
    -0.16424993f, -0.05785206f, -0.16783056f, -0.06994239f, -0.09956852f, -0.23438281f, 0.13908291f, 0.09842567f, 
    0.21712373f, 0.03295472f, 0.06757458f, -0.25260767f, -0.34145069f, -0.03204723f, 0.10826901f, 0.03472333f, 
    -0.01314463f, -0.15081128f, 0.07466343f, -0.07496307f, 0.01104848f, 0.51865220f, -0.29058138f, -0.42851323f, 
    0.32939130f, 0.16834611f, -0.02718797f, -0.10288104f, -0.46803042f, -0.00760278f, -0.08468899f, 0.09974001f, 
    0.22411120f, -0.01890673f, 0.46019512f, -0.00308030f, -0.01308944f, 0.09286072f, -0.18105195f, 0.07826878f, 
    0.07852264f, 0.18933198f, 0.11884794f, -0.16717331f, -0.13713801f, 0.15156722f, -0.36221361f, -0.28449526f, 
    0.23379472f, -0.08819811f, -0.01201929f, 0.09011579f, -0.12474424f, 0.11112150f, -0.16503282f, 0.11751132f, 
    0.12672845f, 0.08144294f, -0.36321723f, -0.07756611f, 0.22576590f, -0.18246028f, -0.10516474f, -0.10083926f, 
    -0.04076623f, -0.04510809f, 0.00439483f, -0.00649863f, -0.43736202f, 0.06832507f, 0.16085811f, 0.74568248f, 
    -0.06772281f, -0.10507271f, -0.22460341f, -0.06710401f, -0.06897094f, 0.06309064f, -0.02514342f, 0.08055919f, 
    0.40396610f, -0.38662329f, 0.11279124f, 0.31427643f, 0.30528247f, 0.06532872f, 0.18523751f, -0.22856049f, 
    -0.03549717f, 0.14537945f, -0.00650312f, -0.01443838f, -0.37902510f, 0.14216807f, 0.05493727f, -0.29560441f, 
    0.09975173f, 0.05208343f, -0.04683200f, 0.00490873f, -0.23838130f, 0.12714316f, -0.10244881f, -0.03078847f, 
    0.19823818f, 0.51227897f, -0.21827210f, -0.11507792f, -0.20607759f, 0.04825303f, -0.13446482f, -0.05498870f, 
    -0.09262613f, -0.14563918f, 0.18554144f, -0.03155789f, -0.02534408f, -0.17309983f, -0.14000903f, 0.05293267f, 
    0.04924475f, -0.03202841f, -0.00983350f, -0.06224556f, -0.12362222f, 0.01461573f, 0.14026755f, 0.09545409f, 
    0.32323560f, 0.22482164f, -0.14442109f, -0.86296302f, 0.22416006f, 0.17649581f, -0.09550297f, -0.06219520f, 
    -0.08688866f, 0.08464413f, -0.08160440f, -0.06710909f, -0.11857125f, 0.62271005f, -0.01210350f, 0.56719059f, 
    0.27511486f, -0.20121744f, 0.16316877f, -0.45010093f, -0.07597330f, -0.22835086f, 0.14603435f, 0.07318123f, 
    -1.06182241f, -0.17911609f, 0.19616723f, -0.49734107f, -0.06106362f, 0.04923317f, -0.07151134f, -0.08338766f, 
    -0.17370343f, 0.00971059f, 0.02890448f, 0.08701122f, -0.33089578f, 0.47428387f, -0.19348539f, -0.00545555f, 
    -0.15390502f, -0.15101558f, 0.03655773f, 0.06216799f, -0.03077060f, 0.19340426f, -0.13678169f, -0.13524863f, 
    0.17122255f, -0.20702387f, 0.05131505f, 0.00629868f, -0.22959261f, 0.07925503f, -0.04406315f, -0.01188183f, 
    0.04507298f, 0.06216799f, -0.10881933f, -0.05555139f, 0.13572729f, -0.05172546f, -0.08787467f, -0.34445480f, 
    0.08642985f, -0.09208100f, -0.06596535f, 0.10704374f, -0.17628536f, 0.11910541f, -0.17816734f, -0.08271769f, 
    -0.61617190f, -0.26344258f, -0.16589880f, -0.15116148f, -0.15748759f, 0.03643936f, -0.30728468f, 0.20904030f, 
    -0.10300183f, 0.12030617f, 0.01293168f, -0.09577791f, 0.08679892f, -0.04562913f, -0.09574351f, -0.31330454f, 
    -0.04993102f, 0.10699099f, -0.18608589f, -0.02171818f, -0.18337062f, 0.34732765f, -0.12689915f, 0.21057034f, 
    -0.34423473f, 0.13532622f, 0.11442708f, -0.05698073f, -0.13608269f, 0.17421308f, -0.02037095f, 0.00716780f, 
    0.09969626f, 0.19298314f, 0.01689296f, 0.18555927f, -0.25130737f, -0.27459952f, -0.00543958f, 0.40184790f, 
    -0.04429519f, 0.06643017f, 0.17073673f, -0.03977224f, -0.00797301f, 0.00537536f, -0.01101431f, 0.07100959f, 
    0.13258098f, -0.08124924f, -0.12371352f, 0.15033360f, -0.01266574f, -0.07949701f, -0.03140726f, -0.09575176f, 
    -0.00690573f, 0.13489558f, -0.03455037f, 0.19484602f, -0.14406723f, 0.00503173f, -0.12189921f, 0.18522575f, 
    -0.09699792f, -0.01378546f, -0.28026825f, -0.18739165f, 0.03033968f, 0.01286563f, -0.00142993f, -0.39678332f, 
    0.18402080f, 0.08567023f, -0.23311368f, 0.44833457f, 0.01099621f, 0.26636946f, 0.01231206f, -0.28152385f, 
    0.14387463f, -0.17221250f, -0.07785650f, 0.05054313f, 0.24478582f, -0.47141722f, 0.12111322f, 0.05653265f, 
    -0.43101001f, -0.18057549f, 0.01020581f, -0.13797036f, -0.13745981f, 0.10503085f, -0.15652353f, 0.08624293f, 
    0.06736089f, 0.19598623f, 0.11971283f, 0.14946909f, -0.11999193f, -0.18600656f, -0.14638844f, -0.07407071f, 
    0.10027843f, -0.05106473f, 0.01914840f, 0.02525598f, 0.18406966f, 0.35611823f, -0.09032425f, 0.35537165f, 
    0.13883764f, -0.12927087f, 0.04904492f, 0.21111572f, 0.12765391f, -0.02789287f, -0.16134238f, -0.05939654f, 
    -0.06878279f, -0.24094914f, -0.23215683f, 0.00727462f, -0.28346586f, 0.03659981f, 0.03530939f, -0.08550604f, 
    -0.12277786f, 0.03937976f, -0.07998906f, 0.08015095f, -0.17951037f, -0.09605715f, 0.13077687f, -0.04581011f, 
    -0.09546682f, 0.02897469f, -0.09031904f, -0.13718878f, -0.01149204f, -0.07373681f, 0.03230439f, -0.05668964f, 
    0.22696806f, 0.19559874f, 0.50038868f, 0.23062682f, 0.00415221f, -0.07821252f, 0.01655541f, 0.38580626f, 
    0.12374346f, -0.01865764f, -0.00521358f, -0.00625887f, -0.02821159f, -0.28829625f, 0.31415758f, 0.00111838f, 
    0.01211669f, 0.00382041f, -0.09146996f, -0.05550106f, 0.24085470f, 0.18964729f, -0.11887731f, 0.19247881f, 
    -0.44526905f, -0.13419341f, -0.39313570f, -0.19460778f, 0.09834531f, 0.07706975f, -0.04887861f, 0.05002464f, 
    -0.14532563f, -0.02710953f, 0.08739325f, -0.04983784f, -0.06223494f, 0.00614525f, -0.07395601f, 0.24589275f, 
    0.03338164f, 0.06527849f, 0.16262662f, -0.07447429f, 0.13745193f, 0.01767923f, -0.01894967f, -0.03037819f, 
    0.04327524f, -0.01596902f, -0.19354695f, -0.00022786f, 0.17794152f, 0.08358143f, -0.19566745f, -0.04259331f, 
    0.13701290f, -0.00115271f, -0.04347380f, -0.01196708f, 0.03150278f, -0.45536962f, 0.26299679f, 0.00495147f, 
    -0.20661113f, 0.00138604f, -0.03873981f, -0.00726447f, 0.20106320f, 0.11911448f, -0.00104197f, -0.10684763f, 
    0.01836825f, -0.01677136f, -0.29770872f, -0.15887152f, 0.07721804f, -0.02822344f, 0.02029229f, -0.05546704f, 
    0.08903962f, -0.18434866f, 0.02357007f, 0.09506591f, 0.04821453f, 0.01345651f, -0.04099935f, 0.07110971f, 
    0.03568143f, 0.00587037f, 0.00586424f, -0.06763337f, -0.27315873f, -0.00498813f, -0.09036881f, -0.21542454f, 
    0.18882424f, 0.10804601f, -0.11567467f, 0.25617638f, -0.05425620f, -0.04227059f, -0.00284921f, -0.03506918f, 
    -0.19319640f, -0.14584133f, -0.06428637f, -0.24348529f, -0.35716295f, -0.07096840f, -0.06446720f, -0.06387430f, 
    0.20600013f, -0.08069745f, -0.51687640f, -0.18903819f, -0.16635512f, -0.13533978f, -0.00796993f, -0.26763725f, 
    0.22229046f, 0.14323182f, 0.06844348f, 0.17891556f, -0.01341732f, -0.21935090f, -0.00068117f, 0.06239585f, 
    0.04532215f, -0.16462880f, -0.05174857f, 0.13352183f, 0.57551301f, -0.79180264f, 0.18747438f, -0.36695895f, 
    0.07237557f, 0.05432015f, 0.00248443f, 0.04249074f, 0.04039712f, -0.03729375f, 0.04088112f, -0.05569752f, 
    0.05987577f, -0.20009246f, 0.11367295f, 0.12715307f, 0.16302690f, 0.11879974f, -0.17926407f, -0.07648867f, 
    0.04131772f, -0.06182741f, -0.14080034f, 0.10241464f, -0.21375099f, 0.03641745f, 0.07414503f, -0.03583026f, 
    -0.17160130f, -0.01834571f, -0.04704771f, 0.03510813f, -0.02131178f, 0.01079862f, 0.00951010f, 0.16400102f, 
    -0.18008329f, 0.10176728f, -0.09456626f, -0.04522638f, -0.01913973f, -0.02627389f, -0.01694146f, 0.00497922f, 
    -0.37383890f, -0.05305649f, -0.19035767f, 0.17415719f, 0.18460748f, -0.36607987f, 0.00323258f, -0.09183741f, 
    -0.02652945f, 0.23135185f, -0.33543658f, 0.11924934f, 0.05220052f, -0.04417423f, -0.00432363f, -0.17355044f, 
    -0.01729483f, 0.00090076f, -0.16641107f, 0.03669103f, 0.01348145f, -0.02778660f, 0.08723349f, 0.10605580f, 
    -0.26456645f, -0.02534772f, -0.46739131f, 0.00199397f, -0.19932899f, -0.07032473f, 0.12516129f, -0.56546050f, 
    0.01445659f, 0.00937651f, -0.01462302f, 0.05158754f, -0.07807522f, -0.05322471f, -0.07926089f, -0.07018670f, 
    0.16614382f, -0.03671424f, -0.12861060f, 0.02057191f, 0.02887080f, -0.06218986f, 0.07710638f, -0.04925659f, 
    0.37777513f, 0.03826022f, 0.27969226f, 0.39955878f, -0.21862774f, -0.35208443f, 0.08382833f, -0.28518915f, 
    -0.03537053f, -0.07398004f, -0.03361528f, 0.04303818f, 0.08476925f, -0.06652044f, -0.03937878f, -0.09511700f, 
    0.07195104f, 0.08259792f, -0.09735647f, -0.04675855f, 0.14660454f, 0.03062215f, 0.11072150f, 0.05525428f, 
    0.14522074f, 0.07860076f, 0.03493377f, 0.01567174f, 0.34201393f, -0.17701183f, -0.09210169f, 0.05604807f, 
    -0.03153332f, 0.16968113f, -0.05549083f, -0.05824186f, -0.04473922f, -0.21912482f, -0.13967308f, -0.26454467f, 
    0.04216382f, -0.09903797f, -0.21014100f, 0.17198119f, 0.05028409f, -0.05121397f, 0.03015502f, -0.06644556f, 
    0.11078357f, 0.03475745f, -0.03057933f, 0.27047563f, 0.21856037f, 0.19505830f, 0.43783644f, 0.14872430f, 
    -0.05114440f, -0.07564609f, -0.01280257f, 0.09428456f, 0.03812750f, 0.00222879f, 0.13992244f, -0.13418505f, 
    -0.13628596f, 0.06863777f, 0.14941834f, 0.07024689f, -0.01387995f, -0.07205819f, -0.09796573f, 0.00051576f, 
    -0.14307611f, -0.13151062f, 0.08158360f, 0.16240817f, 0.06982093f, 0.16207793f, 0.05901010f, 0.08928145f, 
    0.09465530f, 0.15110201f, 0.15185128f, -0.00590990f, -0.01412266f, -0.35677972f, -0.04193568f, -0.14057896f, 
    -0.48290706f, -0.24365549f, 0.17595473f, 0.09253885f, -0.08107822f, -0.11036491f, -0.03029992f, 0.18228236f, 
    0.03377129f, 0.02302909f, 0.01975471f, -0.07470442f, -0.37932122f, -0.13952574f, -0.40211919f, 0.02327447f, 
    0.09683666f, -0.10548484f, 0.01519623f, -0.10549560f, 0.13426006f, 0.34866682f, -0.19542807f, -0.03948871f, 
    0.04599086f, 0.15916011f, 0.10462585f, -0.38727787f, 0.20124859f, 0.09135269f, 0.07787693f, -0.18371688f, 
    0.08610301f, -0.02556682f, 0.02007459f, -0.03766115f, 0.18236142f, 0.14837746f, -0.78174859f, 0.35233858f, 
    0.32068926f, 0.08555543f, 0.01012776f, 0.09955899f, -0.04627708f, -0.08792262f, 0.13021360f, 0.00462697f, 
    0.03039464f, -0.27767146f, 0.12191758f, 0.28532457f, 0.09588624f, -0.20116270f, -0.09142728f, 0.11891259f, 
    0.02273486f, 0.07715426f, -0.04100169f, 0.05757606f, 0.06940551f, 0.13144615f, 0.27661476f, 0.02436376f, 
    0.10188007f, -0.18931915f, 0.27956864f, 0.30765313f, -0.00144843f, 0.05885779f, 0.10045248f, 0.07367088f, 
    0.06641268f, 0.15686004f, 0.04616281f, -0.14433682f, 0.23703986f, 0.20120312f, 0.00559880f, -0.10293462f, 
    0.01629700f, 0.01661826f, -0.03356994f, 0.12056155f, 0.29680052f, 0.00587692f, 0.09727614f, 0.16847591f, 
    -0.01281731f, -0.04155944f, -0.08113462f, -0.13332057f, -0.26329160f, 0.02734974f, -0.09128688f, -0.23913392f, 
    -0.24697758f, 0.03371540f, -0.39848393f, -0.01800320f, 0.01550123f, 0.00301182f, -0.14716026f, -0.00766248f, 
    -0.01348726f, -0.13313542f, -0.02349667f, -0.16050695f, -0.45556986f, -0.12463650f, -0.30678102f, 0.38284841f, 
    0.14025241f, -0.10727520f, -0.04321055f, 0.02636757f, 0.06395192f, -0.00290883f, -0.11826077f, 0.02729794f, 
    -0.11326809f, -0.01099212f, -0.08290334f, 0.24361041f, 0.14051516f, -0.11361092f, 0.20539442f, 0.06221032f, 
    0.01054639f, 0.19570605f, -0.11536106f, -0.10043983f, -0.21924073f, 0.05293511f, -0.15764530f, -0.11563075f, 
    -0.06593665f, 0.02241518f, 0.00347715f, -0.07333604f, -0.11494381f, -0.24430737f, -0.09406630f, 0.09604780f, 
    0.04008907f, 0.12157564f, -0.35600567f, 0.00290222f, -0.00238010f, 0.07526574f, 0.03468943f, -0.04103614f, 
    -0.06862958f, -0.33853257f, 0.04535858f, -0.12179591f, -0.02307780f, -0.15907523f, 0.05455608f, 0.05387354f, 
    -0.09450800f, -0.07199143f, -0.03938753f, 0.01786039f, 0.34960127f, -0.04013844f, 0.05176835f, 0.12452149f, 
    -0.22961187f, -0.00574305f, 0.05713722f, -0.06255449f, -0.01275169f, 0.11589115f, -0.01082446f, -0.19669287f, 
    0.24518435f, 0.13441154f, 0.18365200f, 0.25085619f, 0.12457751f, 0.04772510f, -0.52068067f, -0.00308325f, 
    -0.01924444f, 0.01311864f, 0.00827261f, 0.02663328f, 0.23349346f, -0.05034406f, 0.02224547f, 0.11050570f, 
    -1.11922657f, 0.05218808f, -0.46960381f, -0.43008718f, -0.07681336f, 0.02292802f, -0.03895732f, 0.20428760f, 
    0.15775527f, -0.11495277f, -0.13490897f, -0.20910253f, -0.21785106f, -0.35120335f, -0.01697202f, 0.33598685f, 
    0.07528902f, 0.06453361f, 0.08077451f, -0.02351297f, 0.10135671f, -0.12777416f, 0.46594703f, 0.18611111f, 
    -0.10076359f, 0.16131550f, 0.15009835f, -0.18440329f, 0.03954503f, 0.00013198f, 0.29733893f, 0.03836576f, 
    0.08290188f, -0.07399464f, -0.08838536f, 0.07084651f, -0.06132424f, 0.00578929f, 0.35658142f, -0.16096202f, 
    0.11488351f, -0.13879798f, -0.09361719f, 0.15227647f, 0.08853944f, -0.05939039f, -0.11504100f, -0.03059626f, 
    -0.02583002f, -0.38485911f, 0.30752197f, 0.27654773f, -0.22232582f, -0.17367512f, 0.07822729f, 0.02795859f, 
    0.14074048f, -0.16653086f, 0.14284836f, -0.15214662f, -0.29975241f, 0.08064457f, 0.19475667f, -0.51638871f, 
    -0.10743809f, 0.06574761f, -0.01157656f, 0.14326851f, 0.13477661f, 0.02453648f, 0.03912258f, 0.04195679f, 
    0.03438654f, -0.38740179f, -0.16258766f, 0.19493178f, -0.02627349f, -0.01935621f, -0.08268290f, -0.04929595f, 
    0.28965932f, -0.23674807f, 0.27049759f, 0.16024898f, 0.11067302f, -0.05991702f, -0.32216406f, 0.10702641f, 
    0.12453103f, -0.05840743f, -0.08080811f, -0.02370172f, -0.02297954f, -0.09697796f, 0.09530406f, 0.30425552f, 
    -0.05361815f, -0.03069424f, -0.19493966f, -0.03003597f, -0.00900337f, 0.06309495f, 0.16734114f, 0.02236049f, 
    -0.24283902f, -0.34150141f, -0.25557876f, -0.66355145f, 0.21699412f, -0.12235784f, -0.23585789f, 0.54456675f, 
    0.10187691f, 0.05963319f, -0.08064085f, -0.04458452f, -0.03331165f, 0.00604845f, 0.19794968f, 0.12414689f, 
    -0.04964032f, -0.12703738f, -0.11737910f, 0.10210478f, 0.09735909f, -0.07205204f, -0.03366391f, -0.11547984f, 
    -0.00955697f, -0.09383769f, -0.08875450f, -0.06380068f, 0.01541869f, 0.14238727f, 0.00121342f, 0.04761173f, 
    -0.04518718f, -0.20383237f, -0.12948082f, 0.00600310f, 0.13691573f, -0.00328477f, -0.08958324f, 0.07176130f, 
    -0.06048721f, -0.15964326f, 0.04500594f, 0.06094717f, 0.08937747f, 0.05208573f, 0.04935817f, 0.00109950f, 
    0.14737946f, -0.22739190f, -0.12869509f, -0.39046818f, 0.15503524f, 0.30899739f, 0.02527407f, -0.12277212f, 
    0.22979380f, 0.07386491f, -0.06762154f, 0.02912019f, -0.07663307f, -0.02166114f, 0.03907606f, -0.01049043f, 
    0.22683735f, -0.17803350f, 0.17250016f, -0.06329770f, -0.01932582f, -0.07978395f, 0.06494812f, -0.00897691f, 
    0.20310232f, -0.06745177f, 0.00290326f, -0.15328507f, -0.05579882f, -0.02892577f, -0.05991969f, -0.06582899f, 
    0.04660312f, -0.09051721f, -0.15897700f, 0.02747939f, 0.28408182f, 0.21740584f, -0.11874928f, 0.19161841f, 
    -0.47716239f, -0.31826475f, 0.00214626f, 0.11684266f, -0.02251465f, 0.31858650f, 0.03329804f, -0.27143961f, 
    -0.13078457f, -0.00743898f, 0.08274694f, 0.09045501f, -0.12146361f, 0.03519319f, 0.18446355f, -0.08865879f, 
    -0.14414959f, -0.08496818f, -0.13506408f, -0.06586971f, -0.06907696f, 0.01402623f, 0.00120016f, 0.17235152f, 
    -0.88683587f, -0.27643871f, 0.21661165f, -0.31933343f, -0.09813966f, -0.28573447f, -0.11889725f, -0.47109589f, 
    -0.04454878f, 0.05356198f, -0.03929859f, 0.02931470f, 0.30758074f, -0.61395282f, -0.50919580f, -0.54772747f, 
    -0.04511396f, 0.04088427f, 0.56031638f, 0.12331986f, 0.03972180f, 0.19004466f, -0.08909852f, -0.01473530f, 
    0.26149133f, -0.43640444f, -0.61903459f, 0.04658386f, -0.16702601f, 0.02547797f, 0.19556662f, 0.33034086f, 
    -0.12914760f, 0.12612909f, -0.16992052f, 0.02731368f, -0.52234519f, -0.71871626f, -0.38617042f, 0.24616843f, 
    0.04420113f, 0.15412003f, -0.02377021f, -0.08374625f, 0.00568281f, -0.03617011f, 0.09046252f, -0.05385780f, 
    -0.90255702f, -0.88030279f, -0.52616793f, -0.16514210f, -0.04467921f, -0.43441755f, -0.35601133f, -0.20322660f, 
    -0.01370232f, -0.06400405f, -0.03000306f, -0.00131947f, -0.29820088f, -0.08132344f, -0.03314747f, 0.18212964f, 
    0.00339929f, 0.17135498f, 0.13826118f, -0.12305063f, 0.22523288f, 0.05624235f, -0.03259124f, -0.00582702f, 
    -0.16860403f, -0.04980887f, 0.10713576f, 0.10101108f, 0.06702664f, 0.08696818f, 0.01986512f, -0.03260453f, 
    0.01652180f, 0.14621486f, 0.05092508f, 0.07813663f, -0.05711642f, -0.13235110f, -0.14768483f, -0.11360116f, 
    0.08677100f, 0.11114121f, 0.11093313f, -0.09299950f, -0.06137709f, -0.01504640f, 0.00852758f, -0.01413633f, 
    0.24450983f, 0.05725602f, -0.33221614f, 0.00045889f, -0.08247755f, 0.26638079f, 0.17840745f, 0.11776046f, 
    0.02857059f, -0.15647243f, 0.02940298f, -0.06170478f, -0.49901506f, 0.23730752f, 0.18805519f, -0.16659403f, 
    0.02284315f, -0.01894706f, -0.06059318f, -0.02467887f, 0.08770780f, 0.19643071f, 0.04604332f, 0.05210269f, 
    0.13938336f, 0.12408192f, 0.02293367f, -0.11894061f, 0.10608730f, 0.02799203f, 0.08045676f, 0.00763172f, 
    -0.02679970f, 0.11309874f, 0.06819859f, 0.08751018f, 0.07013231f, 0.06952372f, 0.17415436f, -0.01049874f, 
    -0.00359888f, 0.03218984f, -0.01268672f, 0.12249647f, -0.09290627f, 0.11880761f, 0.00093940f, 0.14480637f, 
    -0.12715533f, -0.02138095f, 0.21877527f, 0.23093142f, 0.12775262f, -0.06496587f, 0.08504004f, -0.08062954f, 
    0.09647541f, 0.04694842f, 0.16046089f, -0.03173701f, 0.94081622f, 0.39286852f, 0.19989677f, 0.30208418f, 
    -0.00611472f, -0.15035057f, 0.21976961f, -0.05729244f, 0.09163714f, -0.13074866f, -0.04981595f, -0.17552043f, 
    -0.55889773f, 0.34433979f, 0.60947901f, 0.25521356f, -0.10872084f, 0.02716449f, -0.07031793f, 0.02424338f, 
    -0.17102106f, 0.06484647f, 0.12463447f, 0.12341192f, -0.17689548f, -0.05604693f, -0.06719107f, -0.28106976f, 
    0.01248059f, 0.08154023f, -0.04983241f, -0.03718507f, -0.03727627f, 0.03008086f, 0.05166356f, 0.00832848f, 
    -0.23116887f, -0.19653790f, -0.15477762f, 0.22230852f, 0.17853150f, 0.06478035f, -0.10270825f, -0.16121203f, 
    -0.04514734f, -0.03927530f, 0.03961296f, -0.00732497f, -0.55288744f, -1.03302658f, -0.02085346f, -0.30457360f, 
    -0.17637233f, -0.07062935f, 0.09179951f, -0.26120526f, 0.03236593f, 0.04865681f, -0.10534878f, 0.15010193f, 
    -0.07904504f, -0.06051162f, -0.12758633f, 0.32081464f, -0.08519506f, -0.04510486f, -0.00480798f, 0.20760378f, 
    0.01073920f, -0.00903154f, 0.11394880f, -0.04758297f, -0.62706959f, -0.29990670f, 0.21734591f, 0.08704036f, 
    0.21523492f, -0.00423578f, -0.02105735f, 0.07136304f, 0.00686611f, 0.11921543f, 0.03956747f, 0.04286350f, 
    0.11477076f, 0.14634804f, 0.06895538f, 0.24944766f, 0.06817315f, 0.11516722f, -0.03040633f, -0.02832375f, 
    0.11849421f, -0.11238465f, 0.07662135f, -0.01071740f, -0.12052925f, 0.01436907f, 0.05945534f, -0.04190428f, 
    0.17698713f, -0.02506011f, -0.05322682f, -0.00358166f, -0.05317000f, -0.03979028f, 0.03843391f, -0.11741365f, 
    0.07354408f, 0.06325959f, -0.01908655f, -0.01843498f, 0.03147475f, 0.00792421f, 0.04919271f, 0.13695283f, 
    0.18170479f, 0.31006703f, 0.24749637f, 0.04825629f, -0.08863552f, 0.26356047f, 0.14594546f, -0.16693611f, 
    -0.05677763f, 0.13732801f, 0.10192741f, 0.06992149f, -0.07084165f, -0.05752183f, 0.04774764f, 0.13135678f, 
    0.02935069f, -0.03728380f, -0.18323125f, -0.20528109f, 0.00843619f, 0.03852054f, 0.11143900f, -0.03987010f, 
    -0.09223825f, -0.08242990f, -0.11711324f, -0.08470636f, 0.04066100f, -0.06821299f, 0.18507606f, -0.25035957f, 
    -0.32077777f, -0.30216247f, 0.14420402f, -0.03622353f, -0.08306581f, 0.21356969f, -0.03850067f, 0.03238741f, 
    0.07979803f, -0.07802558f, -0.10951100f, -0.02773432f, 0.02735579f, 0.06969134f, 0.05528908f, 0.01337107f, 
    -0.03397986f, -0.05178069f, 0.04920059f, 0.00350874f, -0.61361325f, -0.70866793f, -0.12871474f, -0.05750703f, 
    -0.30912837f, 0.06688388f, 0.02819102f, -0.36650562f, 0.06054458f, 0.04329979f, -0.13548855f, -0.00881164f, 
    -0.01642963f, 0.05862736f, -0.13776554f, -0.29551950f, -0.21053320f, -0.02827020f, -0.08749310f, 0.22291553f, 
    -0.11628891f, 0.11480016f, 0.06609673f, 0.23075286f, 0.07540565f, -0.03236415f, 0.16690755f, 0.02922315f, 
    0.01354705f, -0.18256541f, -0.03392838f, 0.07778754f, -0.19974503f, -0.11169167f, -0.32076216f, -0.33417338f, 
    0.04378304f, 0.07413716f, -0.27593639f, 0.09494094f, -0.17659727f, 0.00059369f, -0.09921428f, -0.22967543f, 
    -0.02937726f, 0.05566153f, 0.01297106f, 0.08478368f, 0.25231379f, 0.17573771f, -0.26976341f, -0.21385215f, 
    0.01452235f, 0.07940247f, -0.04239081f, 0.13422722f, -0.08786100f, 0.21526659f, 0.12222922f, -0.00434910f, 
    -0.22232717f, -0.69218457f, 0.18397464f, -0.18104799f, 0.03062083f, 0.00455169f, -0.13208918f, 0.10165099f, 
    -0.06384881f, 0.02313696f, -0.00007436f, 0.03419881f, -0.17034557f, 0.09336796f, -0.00902637f, -0.07970404f, 
    -0.10363854f, -0.07104615f, -0.12095245f, 0.21468246f, 0.05093750f, -0.09609634f, 0.01650226f, 0.03292258f, 
    0.11309642f, -0.53011590f, 0.14484245f, -0.19065671f, 0.08811080f, 0.08691517f, -0.12896851f, -0.23778476f, 
    0.02369024f, -0.00073709f, -0.02968951f, 0.03298651f, -0.48232663f, -0.46126339f, 0.35439694f, -0.47329929f, 
    0.10106315f, 0.05495321f, 0.07995529f, 0.18897623f, 0.03600878f, -0.07180537f, 0.02057946f, -0.08561958f, 
    -0.99584353f, -0.48227480f, 0.19747314f, 0.49236318f, 0.09662963f, -0.04932414f, 0.13208061f, -0.05318209f, 
    0.07250634f, 0.05430768f, -0.04303849f, 0.05410636f, -0.20714508f, -0.39462823f, 0.01655418f, -0.31513828f, 
    -0.04204363f, -0.06992973f, -0.02214639f, -0.01606788f, -0.08640048f, 0.12979908f, 0.05444636f, 0.01964678f, 
    -0.14320016f, 0.15378869f, 0.20783593f, 0.20317614f, 0.08831354f, 0.00122316f, 0.13939531f, -0.06997661f, 
    -0.22751676f, 0.02595332f, 0.14148678f, 0.02482911f, -0.16074395f, 0.02480891f, -0.10654791f, -0.05158167f, 
    -0.08169167f, -0.06315027f, 0.00238580f, -0.04610549f, 0.04503351f, 0.04922802f, 0.01206568f, -0.04417030f, 
    -0.09869038f, -0.01288398f, -0.11183723f, 0.06776816f, -0.13954471f, 0.16342889f, -0.12304948f, -0.33327016f, 
    -0.00599223f, 0.06065740f, -0.00533910f, 0.08670083f, 0.44074365f, -0.19410180f, -0.34529930f, -0.80090237f, 
    -0.00742656f, -0.05939436f, -0.02699891f, 0.02525553f, 0.16365345f, 0.12906580f, 0.03700466f, -0.14435938f, 
    -0.04964701f, 0.17180628f, -0.04538061f, 0.09407875f, 0.03563671f, -0.04307957f, 0.07863022f, -0.04806101f, 
    0.08041599f, -0.00203488f, 0.07988331f, -0.17850362f, 0.04089436f, 0.00157630f, 0.02019646f, -0.13052198f, 
    0.04403833f, 0.01605139f, -0.06585637f, -0.04329442f, -0.11789335f, -0.12764387f, -0.25043729f, -0.20925358f, 
    0.06161730f, 0.00414254f, 0.06141981f, -0.11446732f, -0.00764508f, 0.02704186f, -0.00512766f, -0.00542987f, 
    -0.02038284f, -0.04929813f, -0.08502349f, -0.01699708f, -0.58321875f, 0.14905593f, -0.59848332f, 0.42491111f, 
    -0.13810918f, 0.07771087f, 0.25683287f, -0.02238971f, -0.17462663f, -0.02116052f, 0.06722498f, 0.00183197f, 
    0.89240336f, -1.26676989f, -0.80993557f, -0.25990361f, -0.19085655f, -0.10048834f, -0.13276798f, 0.09904274f, 
    0.15281291f, 0.03389239f, 0.13336812f, 0.06374606f, 0.06356069f, 0.02854593f, -0.01063362f, -0.35902235f, 
    0.09030224f, -0.00367789f, 0.03006255f, 0.00069373f, 0.01831725f, -0.03455611f, -0.03313208f, -0.13066217f, 
    0.10998131f, 0.08128450f, -0.00112079f, 0.02632053f, -0.21746244f, -0.10314745f, -0.10526142f, 0.16032836f, 
    -0.04799473f, 0.09270451f, -0.03896665f, 0.01334059f, 0.31315422f, -0.65471739f, -0.10801806f, -0.04022124f, 
    0.20743808f, 0.09369855f, 0.08576523f, 0.31044695f, -0.01681313f, -0.12755363f, -0.07963038f, 0.07536217f, 
    0.48157331f, -0.35977095f, -0.05343376f, -0.23154879f, 0.13445449f, 0.11016601f, -0.04882108f, -0.07013489f, 
    -0.17048962f, -0.05941078f, -0.11106501f, -0.27168745f, -0.13970751f, 0.24263988f, 0.79870600f, -0.32592714f, 
    0.10038295f, -0.36322680f, 0.29867294f, 0.00169182f, 0.08774388f, 0.02402747f, -0.03714628f, -0.12948279f, 
    -0.01380310f, -0.22707480f, 0.17729697f, -0.18060301f, 0.03866835f, 0.15317464f, -0.04517037f, -0.10340989f, 
    -0.14197002f, -0.05029592f, -0.04291356f, -0.13051128f, -0.00577894f, -0.06692942f, -0.05701995f, -0.14849275f, 
    -0.03361515f, 0.01802625f, -0.02873255f, -0.10250666f, -0.04164768f, 0.01036380f, -0.06974123f, -0.21042287f, 
    0.00215189f, -0.07629252f, 0.10407617f, 0.09485949f, -0.00424314f, -0.01808058f, -0.02395792f, -0.06930158f, 
    0.21848027f, 0.18668786f, 0.00505183f, 0.04226448f, 0.01159825f, 0.03283182f, -0.06788978f, 0.06282988f, 
    -0.10961819f, 0.07764991f, 0.00237834f, -0.14103761f, -0.04334892f, 0.06482883f, -0.02462871f, -0.11896553f, 
    -0.01059221f, 0.07354138f, 0.09165769f, -0.01750661f, 0.05304884f, 0.01590871f, -0.03110096f, -0.03763095f, 
    0.07641519f, -0.04190575f, 0.00318522f, 0.01073236f, 0.28598794f, 0.14715309f, -0.05281778f, -0.07488720f, 
    0.02390007f, 0.04483824f, 0.03628724f, 0.16331303f, -0.08580522f, 0.05612393f, 0.02596643f, 0.01276497f, 
    0.11291138f, 0.02460126f, 0.05367112f, -0.06338392f, 0.00338433f, -0.08383152f, 0.04288727f, 0.02700248f, 
    -0.00270589f, -0.20301802f, 0.06042479f, -0.03974873f, -0.72990865f, -0.02959274f, 0.13686080f, 0.17433190f, 
    0.18682723f, 0.01678358f, 0.15759692f, 0.16356669f, 0.04862659f, -0.09787782f, -0.03251835f, -0.04780174f, 
    0.01346974f, -0.87406129f, -0.53542489f, -0.13314979f, -0.10097270f, -0.14290361f, 0.03524360f, 0.03500823f, 
    0.17571184f, -0.05597495f, 0.03684124f, 0.00192161f, 0.08003475f, 0.04464139f, 0.03606910f, -0.13787878f, 
    -0.01532573f, 0.08108635f, 0.00857374f, 0.02358185f, -0.01446621f, -0.08000877f, -0.07286438f, 0.04950486f, 
    0.05301514f, -0.08048239f, 0.33094746f, -0.15804464f, 0.02244943f, 0.02228591f, 0.00845132f, 0.08807495f, 
    -0.06740120f, -0.06300828f, -0.00561124f, -0.03280256f, 0.09870249f, -0.11218218f, -0.13295187f, -0.38699165f, 
    -0.26629052f, -0.06073726f, 0.01410673f, 0.09886774f, 0.13536097f, -0.08742347f, 0.09488176f, 0.03393112f, 
    -0.11787748f, -0.84675586f, -0.77254492f, -0.32443243f, 0.02100575f, 0.20651874f, 0.13659249f, 0.02652388f, 
    0.07498179f, 0.15301995f, 0.07747015f, 0.03737826f, -0.61690128f, 0.15966776f, 0.09722280f, 0.33354390f, 
    0.16373834f, -0.16844155f, -0.23713510f, -0.15036243f, -0.07375747f, 0.05069194f, 0.04578283f, 0.02333149f, 
    0.64754796f, 0.05498110f, 0.05004302f, -0.12268642f, 0.35242993f, -0.13272806f, -0.02256903f, -0.07175210f, 
    -0.05846056f, 0.02622488f, 0.18763781f, 0.05971005f, 0.22440033f, 0.08602770f, -0.04997426f, -0.02312842f, 
    -0.08108965f, 0.14821386f, 0.16529596f, -0.18315271f, -0.02521042f, -0.01393687f, -0.12035106f, -0.14505863f, 
    -0.13932005f, -0.63375044f, -0.27230012f, 0.04184532f, -0.12822747f, -0.05417452f, 0.06335413f, 0.05916465f, 
    -0.07712694f, 0.24970886f, 0.07624067f, 0.11475738f, 0.40145642f, 0.30526623f, -0.10535790f, 0.12121402f, 
    0.11586042f, 0.27606151f, 0.11793089f, 0.00114211f, -0.03773186f, -0.20674397f, -0.14041354f, -0.10897876f, 
    -0.07584828f, -0.23697269f, 0.26407605f, 0.10884840f, -0.16282424f, 0.04492366f, -0.06505989f, -0.02359766f, 
    0.19130373f, 0.01872151f, -0.01317822f, 0.08330503f, -0.04467725f, 0.23203680f, 0.06530671f, -0.01288181f, 
    -0.06881201f, -0.01266880f, -0.13159341f, -0.04024352f, -0.05841913f, -0.03657002f, 0.07054643f, 0.02217247f, 
    -0.10329308f, 0.03079588f, 0.12741324f, 0.08339618f, 0.05209970f, 0.05197231f, -0.06660657f, 0.24571964f, 
    -0.15682833f, -0.23815380f, 0.17990609f, -0.02463293f, -0.13717949f, -0.25021982f, -0.37940839f, -0.48862389f, 
    -0.12459339f, -0.04358255f, 0.04184741f, 0.11512093f, -0.09288556f, -0.03360877f, -0.08594986f, -0.05516495f, 
    -0.47470579f, -0.03542424f, 0.15244266f, 0.04459869f, -0.06680153f, -0.13524494f, -0.05905810f, -0.02992755f, 
    -0.15141554f, -0.02503889f, -0.32125255f, -0.12528309f, -0.11385827f, -0.14241162f, -0.04120446f, -0.07269941f, 
    -0.02361163f, 0.03835606f, 0.06068743f, 0.03771803f, 0.12210823f, 0.05974003f, 0.13503505f, 0.10801210f, 
    -0.05598698f, 0.03371224f, -0.15793446f, -0.06682059f, -0.09839098f, -0.07853456f, 0.07341187f, 0.01949306f, 
    0.05694759f, 0.20658028f, 0.04138087f, -0.06529291f, -0.88785261f, 0.29087538f, 0.21567670f, 0.36918670f, 
    0.04616784f, 0.14664309f, -0.10372373f, 0.09949329f, -0.26852030f, 0.08793941f, 0.10649847f, 0.20835187f, 
    -0.34316254f, -0.44245937f, -0.26188442f, 0.16492586f, 0.05167276f, 0.18470895f, 0.19146879f, 0.13575377f, 
    -0.06973895f, -0.13204519f, -0.05997356f, -0.15498199f, 0.07867027f, 0.23582447f, 0.01468114f, -0.36572203f, 
    -0.12693074f, -0.09811518f, 0.00130818f, -0.12616909f, -0.05296046f, 0.09069660f, -0.21901394f, 0.17338914f, 
    0.34950855f, -0.02797012f, -0.05609331f, -0.16144469f, -0.13646716f, -0.01910396f, -0.04703899f, 0.06387398f, 
    0.06302241f, 0.25601828f, 0.04089016f, 0.28620583f, 0.20838723f, -0.25440204f, -0.65678287f, -0.34924436f, 
    0.14820322f, -0.13052876f, 0.10116647f, 0.00907609f, -0.10722226f, -0.11332699f, -0.10781387f, -0.15507270f, 
    0.53404826f, -0.06322375f, -0.31034899f, -0.32875949f, 0.12026866f, -0.13187212f, 0.06397330f, -0.15313965f, 
    0.18640539f, 0.05775031f, 0.18337449f, 0.15391022f, -0.09780564f, -0.55210364f, -0.05936728f, -0.18854672f, 
    0.11507761f, 0.15738361f, -0.02177740f, 0.00330506f, 0.08383561f, 0.14938116f, 0.12041009f, 0.27533141f, 
    -0.05269097f, 0.07961532f, -0.03716019f, -0.01301530f, 0.01125055f, -0.07398921f, -0.08759680f, -0.02176842f, 
    0.06434527f, 0.15144430f, 0.11635920f, -0.04609467f, 0.09635095f, 0.01973539f, 0.15946065f, -0.17189869f, 
    -0.22238195f, -0.03037349f, -0.00530515f, -0.09083624f, 0.05757417f, 0.05103628f, 0.16916254f, 0.12579806f, 
    -0.20299262f, -0.00788018f, -0.00107303f, 0.06805336f, 0.02362890f, 0.06595697f, -0.03699268f, 0.01878401f, 
    -0.48791084f, 0.13611047f, -0.23795786f, -0.41758594f, -0.14621246f, 0.29491654f, 0.10008149f, 0.12478603f, 
    0.02708651f, -0.00236365f, -0.11855795f, 0.04207619f, 0.12748559f, -0.01220227f, 0.09011418f, 0.19941506f, 
    -0.43173480f, 0.24528463f, 0.07756841f, 0.06446024f, -0.04742168f, -0.10025284f, -0.11126811f, -0.04765771f, 
    -0.09386235f, -0.02875895f, -0.02795782f, 0.02737200f, 0.08398296f, -0.16447841f, 0.02816326f, -0.02682970f, 
    -0.02999564f, -0.03111328f, -0.07756069f, -0.17342521f, 0.14894959f, 0.21668084f, 0.18044613f, 0.12311973f, 
    -0.27597082f, -0.13831761f, -0.03079495f, -0.17134409f, -0.05750553f, -0.12794702f, -0.05813389f, -0.07470553f, 
    -0.29790261f, -0.12841824f, -0.11209689f, -0.35586286f, -0.12225511f, 0.15177497f, -0.25394741f, 0.30059755f, 
    -0.01508662f, 0.08439863f, 0.01268652f, -0.03474172f, -0.05009018f, -0.00652356f, -0.08780447f, -0.01228151f, 
    -0.00422245f, -0.35062927f, -0.26043025f, -0.13424845f, 0.23991893f, 0.18901792f, 0.09120332f, 0.19824730f, 
    0.07695729f, -0.05508445f, -0.25177819f, -0.47211739f, 0.04341438f, -0.01473098f, -0.04763825f, -0.00643119f, 
    -0.04244941f, -0.09667747f, -0.09796437f, 0.09269936f, 0.20567323f, 0.11918590f, 0.13711342f, 0.07919057f, 
    -0.11637246f, -0.18799652f, -0.80274189f, -0.06230214f, 0.23400262f, -0.01851150f, 0.09168100f, 0.29470250f, 
    -0.02003491f, -0.17579149f, 0.06649895f, 0.04930535f, -0.34059471f, -0.02549393f, 0.04050850f, 0.55263287f, 
    0.00592850f, 0.14122112f, -0.41436961f, 0.04159519f, 0.06675786f, -0.47681826f, 0.16465476f, 0.10983560f, 
    -0.30257806f, 0.13272956f, 0.25455159f, -0.43087327f, -0.31132725f, -0.19400899f, 0.10047792f, 0.14022946f, 
    0.07963183f, 0.02956433f, 0.06351541f, 0.00019187f, -0.24561578f, 0.53168327f, -0.70887560f, 0.01088163f, 
    0.02452896f, 0.06302922f, 0.09353998f, 0.08806923f, 0.04780718f, -0.06882600f, -0.16052215f, -0.03496472f, 
    0.15342014f, -0.08077870f, -0.27924541f, 0.07956947f, 0.09319674f, 0.07550281f, 0.21428326f, -0.35994661f, 
    0.08808231f, -0.11194885f, -0.15726273f, 0.01682930f, -0.09909108f, -0.31247431f, -0.07865795f, -0.37693229f, 
    -0.10088070f, 0.06411257f, -0.19070286f, 0.08275550f, 0.14234275f, 0.00421411f, 0.11850190f, 0.03728315f, 
    -0.19333537f, 0.35628754f, -0.02445452f, -0.55433637f, -0.07500265f, -0.33989969f, 0.36271188f, 0.06660320f, 
    -0.09192110f, -0.00724795f, -0.14710394f, 0.00952067f, -0.09102625f, -0.34719342f, -0.02237355f, 0.02288912f, 
    -0.00905013f, -0.06321242f, -0.02287492f, 0.06785637f, -0.03286530f, 0.19499689f, 0.03581506f, 0.23771726f, 
    -0.02671906f, -0.50990361f, 0.09257387f, -0.46122611f, 0.07387485f, 0.01024428f, -0.01329997f, 0.13349389f, 
    0.01353239f, 0.01514800f, 0.01517135f, -0.00837176f, 0.06921186f, -0.19211762f, -0.47195944f, 0.07417982f, 
    0.18107763f, 0.24199712f, 0.17940016f, 0.12623838f, 0.13601489f, -0.01672603f, -0.04705860f, -0.11698504f, 
    -0.47734466f, 0.54719037f, -0.80026239f, -0.21858726f, 0.13509685f, -0.18726249f, 0.10725965f, -0.24113990f, 
    0.09238029f, -0.01931940f, -0.02065903f, 0.18177690f, 0.29236436f, 0.24155061f, 0.34082922f, 1.00838017f, 
    0.09235003f, -0.06262890f, -0.23523214f, -0.01251932f, -0.11706850f, 0.01282169f, 0.10049795f, -0.14496498f, 
    -0.09864808f, 0.05806950f, 0.01871007f, 0.04286579f, 0.00571494f, -0.05016910f, 0.17268090f, 0.01277585f, 
    0.06161108f, 0.07689656f, 0.02813298f, 0.18359222f, 0.21794240f, 0.00147059f, 0.16347887f, 0.21958022f, 
    -0.05945297f, 0.03555311f, -0.24516843f, -0.19606036f, -0.04969313f, 0.03163508f, 0.02183315f, 0.05014773f, 
    0.03328490f, -0.03339935f, 0.22760111f, 0.09256506f, -0.01742950f, 0.05995280f, -0.29415843f, -0.19990496f, 
    -0.17253734f, 0.30382878f, -0.32552519f, -0.07590052f, -0.47314805f, 0.57973301f, -0.00909277f, -1.39797759f, 
    0.02547930f, -0.04592331f, 0.29764497f, 0.08485064f, 0.08037057f, 0.04354604f, 0.10502411f, 0.03631856f, 
    -0.00182189f, -0.03283146f, 0.09811958f, -0.19296017f, -0.10878177f, -0.08699391f, -0.30072245f, -0.25091007f, 
    0.12466820f, -0.01168545f, 0.13406113f, 0.10405444f, -0.03763601f, -0.35684979f, 0.13743936f, 0.22631049f, 
    0.08305928f, 0.12876685f, -0.02158664f, 0.07181643f, 0.01199272f, 0.08493384f, -0.09039659f, -0.06538329f, 
    -0.36661530f, -0.15876977f, 0.10027712f, -0.13591780f, -0.04027276f, 0.19902614f, -0.10325181f, 0.24285960f, 
    -0.03392180f, -0.23336640f, -0.13448843f, -0.24395157f, -0.54182154f, -0.01309207f, -0.03141886f, -0.10524692f, 
    -0.15751536f, -0.07785077f, 0.05686229f, 0.07369332f, 0.08827905f, 0.08610442f, 0.14874659f, 0.01958665f, 
    -0.18952116f, -0.00223363f, 0.63004196f, 0.31532320f, 0.14401208f, -0.12171504f, -0.14373651f, -0.22306602f, 
    0.03766130f, 0.02635499f, 0.10781362f, 0.03622446f, 0.27817205f, -0.61622810f, 0.07940894f, -0.55538946f, 
    -0.04351420f, -0.30779967f, -0.00549739f, 0.02287615f, -0.09921359f, -0.05018281f, -0.16207410f, 0.03398799f, 
    0.05776411f, -0.20943107f, -0.01226368f, -0.31721562f, -0.05533168f, -0.06193367f, 0.03266753f, -0.13674258f, 
    -0.09505206f, 0.04767928f, 0.11456070f, 0.03699746f, -0.18001266f, -0.19768547f, 0.02212442f, -0.13268647f, 
    -0.00728473f, 0.09107776f, 0.05768237f, 0.00470535f, -0.06559689f, -0.05180628f, 0.06739365f, -0.23717700f, 
    0.07644743f, -0.01118296f, 0.16669464f, 0.03689484f, 0.00645759f, 0.03925278f, 0.02995614f, -0.03908331f, 
    0.04503531f, 0.18089610f, 0.15407079f, 0.19249094f, -0.11234286f, 0.12174041f, -0.72272676f, 0.10309912f, 
    0.02474278f, -0.23825920f, -0.15191646f, -0.14629474f, 0.11527732f, -0.12872237f, -0.11070286f, -0.11972861f, 
    -0.22466134f, -0.26922283f, -0.28965682f, 0.03491731f, 0.09141819f, 0.25374722f, 0.20141777f, 0.18861334f, 
    0.09081615f, 0.04547026f, 0.08501999f, 0.06551386f, -0.25973800f, -0.04822799f, -0.02531571f, 0.31423813f, 
    0.09666976f, 0.35129902f, -0.15011247f, 0.06624777f, -0.11572450f, -0.28422791f, -0.21252826f, -0.21162476f, 
    0.13337016f, -0.19530137f, 0.04459663f, 0.10732888f, 0.04873323f, 0.20896836f, 0.14576632f, 0.02350639f, 
    -0.08636735f, 0.14976740f, 0.16057800f, 0.09737413f, 0.14471878f, 0.20351270f, 0.14602438f, -0.24922742f, 
    0.00261916f, -0.18380053f, 0.07249187f, 0.33931765f, 0.08283149f, 0.03309665f, -0.00645362f, -0.04650317f, 
    -0.22564039f, 0.02026752f, 0.06748725f, 0.06543010f, 0.04495506f, -0.07214971f, -0.01080797f, -0.03902559f, 
    0.04014331f, 0.04865344f, 0.05828521f, -0.01190615f, -0.09772223f, -0.04854850f, -0.11108851f, 0.00044223f, 
    -0.11233199f, 0.08590441f, 0.10976332f, -0.04916583f, 0.16836147f, 0.11158340f, -0.22313225f, -0.08768654f, 
    -0.10003519f, -0.35583794f, -0.11307618f, -0.23744059f, -0.37275308f, -0.05137947f, -0.07114861f, 0.14670868f, 
    -0.21774563f, -0.03668105f, -0.19074889f, 0.04644927f, -0.06301302f, 0.42040190f, 0.12159517f, -0.04826311f, 
    -0.00600880f, -0.11295325f, -0.12087569f, 0.03732614f, -0.13308632f, 0.19999011f, -0.22846437f, -0.01801907f, 
    -0.02499927f, -0.23435469f, 0.10855143f, -0.05336447f, -0.14228782f, 0.03451445f, 0.09281227f, 0.04011338f, 
    0.05701917f, 0.12315362f, 0.17174861f, -0.02118655f, 0.04065066f, -0.37270126f, 0.16666456f, 0.29374477f, 
    -0.19776669f, 0.03987964f, 0.45610479f, -0.28604355f, -0.12882014f, 0.07815377f, 0.03430538f, 0.00941207f, 
    -1.00361717f, 0.40593937f, -0.65318835f, -0.08867507f, -0.17203896f, 0.05649301f, 0.20728643f, -0.10151705f, 
    -0.04515172f, 0.02294874f, -0.08078945f, 0.05407041f, -0.13630748f, -0.08717138f, -0.33927935f, 0.02863282f, 
    0.01993713f, -0.06632522f, -0.08684901f, -0.23386130f, -0.09072079f, 0.12881251f, 0.01096059f, -0.12423063f, 
    -0.33614087f, -0.35746160f, -0.16169493f, 0.24671341f, -0.05492382f, 0.15877150f, 0.00064207f, -0.10570651f, 
    0.02579601f, 0.11996443f, 0.12090563f, 0.13741197f, -0.47054726f, 0.39133412f, -0.04137451f, 0.08251622f, 
    -0.02804760f, 0.34581113f, -0.16325468f, 0.25920627f, -0.08426838f, -0.10803903f, 0.00148105f, -0.42439908f, 
    -0.19311981f, 0.12566802f, 0.26467124f, 0.14006257f, 0.05676250f, 0.03286703f, -0.22674923f, -0.02289787f, 
    -0.02727180f, -0.13051918f, -0.12536205f, 0.05135978f, -0.19764748f, -0.39212549f, 0.29016423f, -0.19435473f, 
    -0.13152093f, -0.07577723f, 0.06248701f, 0.14086497f, 0.03537647f, 0.24072754f, 0.08637216f, 0.02911609f, 
    0.19627656f, 0.27295151f, -0.06839434f, -0.05709851f, -0.19443929f, -0.07337779f, 0.22656973f, 0.08296400f, 
    0.12217347f, 0.24099526f, -0.24568792f, 0.04351737f, -0.35862416f, 0.39135748f, -0.91765440f, 0.15506059f, 
    0.09518096f, -0.02609163f, -0.12644215f, -0.03552835f, -0.03826551f, -0.12505932f, 0.02342783f, 0.03647502f, 
    0.01741669f, 0.19191232f, -0.17660008f, 0.10849163f, -0.03654966f, -0.10684706f, 0.00815409f, -0.04419023f, 
    -0.16774361f, -0.27154028f, -0.13177241f, 0.04338382f, -0.13532375f, 0.42045489f, 0.17830868f, -0.12678327f, 
    -0.00521823f, -0.19309703f, 0.09992268f, 0.08538999f, -0.24851684f, 0.19129799f, 0.16811559f, 0.07480073f, 
    0.30972970f, 0.08549217f, 0.38982093f, -0.01053778f, -0.20347095f, -0.07448085f, 0.25493875f, 0.06786424f, 
    0.04587912f, -0.06851634f, 0.06370399f, 0.01499258f, 0.13499530f, -0.37652153f, 0.33666816f, 0.03595824f, 
    -0.34997910f, -0.02070506f, 0.13498357f, 0.06506193f, -0.09178020f, -0.13947181f, 0.09685970f, -0.07199764f, 
    0.20299384f, 0.01139418f, 0.27679446f, 0.00001711f, 0.04800769f, -0.09189280f, -0.13360746f, 0.17442852f, 
    -0.26227838f, 0.22219540f, -0.10509595f, -0.26468414f, -0.44288257f, -0.07159070f, -0.28215066f, 0.28498614f, 
    -0.13175437f, -0.03972912f, -0.12675367f, -0.07530408f, -0.09003384f, -0.18311580f, 0.01071148f, -0.04663177f, 
    0.01986259f, 0.31611621f, 0.11222216f, -0.02122658f, -0.20125343f, 0.02215401f, -0.03763252f, 0.12573317f, 
    0.09307437f, 0.14718512f, -0.06185850f, 0.29916734f, -0.15262234f, 0.04899208f, -0.11470516f, -0.17725074f, 
    -0.08355965f, -0.04707020f, -0.04160450f, 0.14038131f, 0.02660712f, 0.12814516f, -0.06994380f, -0.16837475f, 
    -0.86208940f, 0.23001486f, -0.21468255f, -0.60271329f, -0.04486433f, 0.23881234f, 0.03214237f, 0.07363068f, 
    -0.13371469f, -0.05988244f, 0.03344854f, 0.02254283f, -0.33085296f, 0.56378239f, -0.03681251f, 0.24657330f, 
    0.02897584f, -0.01450733f, 0.08039353f, 0.16744290f, 0.02052370f, 0.19853114f, 0.11152382f, 0.34425271f, 
    -0.02893741f, 0.15945064f, 0.23245116f, 0.61472666f, 0.14169852f, 0.19233370f, -0.04001155f, 0.05718715f, 
    0.06943392f, 0.16063347f, 0.13356943f, -0.17051783f, -0.23631215f, 0.14923282f, 0.39339873f, 0.32108590f, 
    -0.20258227f, 0.10764124f, 0.08880959f, 0.08858911f, 0.16183344f, -0.22357941f, 0.11825693f, 0.09507833f, 
    0.06682498f, 0.22680718f, -0.03596099f, -0.02704384f, 0.08432927f, -0.06351987f, -0.04209904f, -0.07160431f, 
    0.02999764f, -0.16234863f, -0.53044730f, -0.36750776f, -0.00148277f, 0.28716215f, 0.20852743f, -0.02856189f, 
    -0.12565792f, 0.20664580f, 0.31361020f, -0.01618797f, -0.01022630f, -0.07023050f, 0.07161107f, 0.01470831f, 
    0.04216148f, -0.50450140f, -0.42678705f, -0.66843528f, -0.29888216f, -0.34181285f, -0.06975389f, -0.16179189f, 
    -0.09166979f, 0.09884184f, -0.11419263f, -0.03615152f, -0.01399528f, 0.59402502f, 0.13617997f, -0.03222583f, 
    -0.19299586f, 0.12926722f, -0.07180931f, 0.10700256f, 0.21567068f, 0.20902623f, 0.32227466f, 0.24633652f, 
    -0.17818466f, 0.07998944f, -0.30628809f, -0.07237455f, -0.18504854f, -0.03517622f, 0.00489286f, 0.00797005f, 
    -0.13845278f, -0.13673271f, -0.32473317f, -0.22110067f, -0.16390575f, -0.60423481f, -0.03196039f, 0.14175081f, 
    -0.02179413f, 0.18752891f, -0.08294861f, -0.09251146f, -0.06392955f, -0.02497525f, -0.07536078f, -0.07733209f, 
    -0.22450086f, 0.02267736f, 0.05604113f, -0.10473280f, 0.06290858f, -0.05274384f, 0.05295977f, 0.11583389f, 
    0.04082526f, -0.02793374f, -0.62929523f, -0.34656280f, 0.10441387f, -0.13811918f, 0.04095348f, 0.08075326f, 
    -0.10903893f, -0.09091441f, 0.05151319f, -0.29904011f, -0.05487724f, 0.22865503f, 0.11208225f, 0.30884326f, 
    0.63159025f, 0.26511273f, 0.10620540f, -0.44038436f, -0.04457205f, 0.08602811f, 0.14469928f, -0.10264027f, 
    -0.05311427f, 0.14259574f, -0.02050333f, 0.02448126f, -0.57657909f, 0.05980723f, -0.51037657f, 0.47594637f, 
    0.27886000f, 0.04260121f, 0.07654162f, -0.05898621f, -0.00414678f, -0.22985989f, -0.06040169f, 0.13198981f, 
    -0.61761254f, -0.46704549f, -0.11381882f, 0.11718210f, -0.07874827f, -0.33856219f, 0.07565161f, -0.10905839f, 
    -0.06730398f, 0.08076473f, 0.01986475f, -0.17697588f, 0.42122728f, 0.13977458f, 0.60244173f, 0.17726238f, 
    -0.08516270f, -0.18507020f, -0.13479678f, 0.01402063f, -0.06492806f, 0.01460986f, 0.06004692f, -0.17315005f, 
    0.63448066f, 0.02022169f, -0.05912748f, 0.16187741f, 0.20979531f, 0.01967544f, 0.13567801f, 0.16093607f, 
    -0.08813484f, 0.03150213f, 0.01736727f, -0.18123236f, 0.27414027f, 0.01735844f, -0.20079148f, 0.14840409f, 
    -0.21772213f, -0.04014997f, 0.20436825f, -0.06301636f, 0.00214774f, 0.05626806f, 0.02714651f, 0.04510371f, 
    0.11883602f, -0.07462040f, 0.15785739f, -0.28989753f, -0.18336673f, -0.01804538f, -0.56327051f, -0.03662682f, 
    -0.01167635f, -0.11588647f, 0.01384592f, -0.10159235f, -0.23512803f, 0.05660062f, -0.04625895f, 0.14623517f, 
    0.05456566f, 0.01725390f, 0.12513302f, 0.43632030f, 0.00390033f, 0.25907025f, 0.06342620f, 0.18228129f, 
    -0.52529615f, 0.40526497f, -0.39850521f, 0.29831415f, -0.14234246f, -0.07049003f, -0.03272956f, 0.20567022f, 
    -0.29270831f, 0.20601200f, 0.08999638f, -0.02342340f, 0.44873801f, 0.32376868f, 0.35108113f, 0.03452240f, 
    -0.13151269f, 0.05200281f, -0.01493341f, -0.03111212f, -0.23863010f, 0.07304374f, -0.06099861f, 0.05409940f, 
    0.53190291f, -0.54369569f, 0.54921341f, -0.24308868f, 0.15653691f, -0.00374773f, -0.04187242f, -0.01194569f, 
    -0.08389924f, 0.11346742f, -0.10973097f, -0.00893580f, -0.90143114f, -0.18786752f, -0.15649837f, 0.59653002f, 
    0.12888239f, 0.02598350f, -0.03825827f, 0.01098393f, -0.02218224f, 0.08988708f, 0.28809208f, 0.05996741f, 
    0.10326703f, -0.17773777f, 0.05790375f, -0.13658309f, -0.13617571f, 0.20729558f, -0.03329951f, 0.10161287f, 
    -0.08987895f, 0.32611451f, 0.15066078f, 0.02689068f, -0.51225591f, 0.18748008f, -0.42123884f, 0.03191347f, 
    0.15397680f, -0.06657247f, 0.19279581f, 0.04881151f, 0.04313532f, -0.04564788f, -0.02629834f, 0.11639029f, 
    -0.21406969f, 0.00723316f, -0.25891969f, 0.01044501f, -0.05143776f, 0.06286500f, 0.04303835f, 0.09160994f, 
    0.00312786f, -0.05499102f, 0.07363862f, -0.14083567f, 0.06376161f, -0.69538176f, 0.59998059f, -0.13108519f, 
    0.08037211f, 0.10791615f, 0.24751264f, -0.10335103f, -0.21691452f, -0.02989059f, 0.08475653f, 0.09629406f, 
    -0.60660768f, 0.52636528f, -0.68332380f, -0.16152321f, -0.05124197f, -0.11393973f, 0.12509997f, -0.02257160f, 
    -0.08157458f, 0.03447014f, -0.13306187f, -0.03924187f, -0.19921465f, 0.26178646f, -0.18289787f, 0.15705776f, 
    -0.07606563f, -0.04191874f, 0.00020505f, -0.01821787f, -0.03987372f, 0.21116439f, 0.00686685f, -0.11170851f, 
    -0.21142724f, 0.10562731f, 0.03865688f, 0.00327137f, 0.05257867f, -0.15392876f, 0.11877435f, -0.33937508f, 
    -0.09911183f, -0.07837128f, 0.08696929f, -0.11057533f, 0.09146595f, -0.27118063f, 0.05350816f, -0.27445272f, 
    -0.10124929f, -0.02453597f, 0.21283115f, 0.06236756f, -0.01299202f, 0.09253518f, 0.12501498f, 0.02300565f, 
    -0.27116650f, -0.24913150f, -0.23015040f, 0.13240014f, 0.11932680f, 0.09359275f, 0.03722373f, 0.01245702f, 
    0.03992233f, 0.06962971f, 0.09976352f, -0.07179026f, -0.61901522f, 0.08318596f, -0.62961340f, 0.37330499f, 
    -0.14394583f, 0.18127473f, -0.24627256f, 0.04185146f, -0.29220456f, -0.16235188f, -0.06472453f, -0.14496681f, 
    -0.07166397f, -0.33765766f, 0.08095333f, 0.33408332f, 0.14657311f, -0.12848954f, 0.10094222f, 0.03511405f, 
    -0.04227263f, 0.12385607f, -0.09696662f, 0.05763064f, 0.11001585f, 0.19037928f, -0.07904310f, -0.02425053f, 
    -0.11587608f, 0.09917112f, -0.05077090f, 0.21239676f, 0.10182704f, -0.06473300f, 0.05919507f, -0.10377156f, 
    0.04740794f, -0.03450919f, -0.04638892f, -0.18381859f, 0.05037130f, 0.02518366f, -0.13802820f, 0.03193586f, 
    -0.08362368f, 0.10409615f, 0.21737818f, 0.03501026f, 0.31432146f, -0.40761405f, 0.22010778f, -0.22558080f, 
    0.03590224f, -0.14664122f, 0.01773208f, -0.03759595f, 0.09049868f, 0.20163040f, 0.13402548f, -0.02012994f, 
    0.28908092f, 0.02545409f, 0.03997492f, -0.09440906f, -0.08224902f, -0.01355527f, -0.03893899f, 0.09254634f, 
    -0.14854383f, -0.02976849f, 0.04378064f, -0.17999955f, -0.18080091f, -0.14332817f, -0.11837846f, 0.11679278f, 
    0.36798292f, -0.31166270f, 0.08337442f, 0.13138528f, -0.02630990f, 0.01744790f, -0.16949537f, -0.34091547f, 
    0.13532016f, 0.19585928f, -0.15223710f, -0.17888193f, -0.08876158f, -0.03674033f, -0.01788587f, 0.02235316f, 
    0.14032346f, 0.11477754f, 0.03301832f, -0.04899324f, -0.17960353f, -0.28238875f, -0.01888811f, 0.27466172f, 
    -0.27968490f, -0.04080339f, 0.12255028f, -0.15772796f, 0.04518895f, 0.15550599f, -0.05180452f, -0.05844652f, 
    -0.23573215f, -0.28918764f, 0.07563279f, -0.53536874f, 0.06045774f, 0.00146755f, -0.14693448f, 0.04791714f, 
    -0.11227687f, 0.10767899f, 0.24270840f, -0.05363824f, -0.15899602f, 0.01966194f, -0.07454968f, -0.09150709f, 
    -0.00236826f, 0.03137533f, 0.09659273f, -0.01560916f, -0.10797750f, 0.18001854f, 0.00813837f, 0.00052206f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15102907f, 0.04920181f, 0.13441920f, -0.13390377f, -0.13986811f, 0.10556205f, -0.00779376f, -0.13118514f, 
    0.07007983f, 0.03961108f, 0.06167860f, -0.02797712f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
