#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38679779f, -1.31142545f, -0.05917004f, 0.87753922f, 0.27934381f, -0.00588782f, 0.51322812f, 0.39940274f, 
    0.22164311f, 0.18882935f, -0.10261565f, 0.28074357f, -0.37305453f, 0.19253650f, -0.08290245f, -0.11023453f, 
    -0.03582143f, -0.32223228f, -0.05221815f, -0.16254044f, 0.00787378f, 0.02788332f, 0.00075113f, -0.03783372f, 
    -0.16322538f, -0.90365881f, 0.28360257f, -0.45203769f, -0.79393268f, -0.61949110f, 0.31803918f, -0.13855988f, 
    0.10313568f, 0.53273392f, 0.37251011f, 0.25040230f, 0.06661486f, 0.04332205f, -0.03478570f, -0.28978240f, 
    0.06147008f, 0.34442437f, 0.25220525f, 0.27642697f, -0.25761488f, -0.33392546f, 0.08432613f, -0.26785091f, 
    -0.18667355f, -0.18220443f, 0.39476904f, 0.69183820f, 0.56779301f, 0.59500873f, -0.71108627f, -0.11387037f, 
    0.02912007f, -0.73237050f, -0.75473046f, 0.50021094f, 0.50317180f, 0.26228654f, -0.23144968f, -0.07819009f, 
    -0.15179808f, 0.22147591f, -0.04654970f, 0.20350121f, -0.17690152f, -0.02927429f, 0.27310458f, 0.23074749f, 
    0.14834908f, 0.05307411f, -0.06537599f, 0.41624755f, -0.10699566f, 0.61020929f, 1.04129720f, 0.00454653f, 
    0.05009111f, 0.31300828f, -0.11308825f, 0.33986512f, 0.07658680f, -0.18250579f, 0.04662091f, -0.05692864f, 
    0.09301233f, -0.34283963f, -0.24831320f, -0.13221185f, 0.36110908f, 0.12345411f, -0.33513036f, 0.04568562f, 
    0.34696758f, 0.03657991f, 0.30292350f, -0.13707483f, 0.61600447f, 0.22609782f, 0.69381857f, 0.37088940f, 
    0.75082660f, -0.68626195f, -0.52251279f, -0.05715118f, 0.06277341f, -0.57335001f, 0.25700894f, -0.02223343f, 
    0.07068430f, -0.27480492f, 0.07426891f, -0.10884156f, 0.00432008f, 0.01197760f, -0.05931607f, 0.17255655f, 
    -0.22554523f, -0.25786313f, -0.14646743f, -0.15145899f, 0.05755684f, -0.02338983f, -0.46229732f, -0.47074971f, 
    -0.40458664f, -0.27531701f, -0.06657588f, 0.75351739f, -0.03697271f, -0.19460846f, 0.31008437f, -0.21326549f, 
    -0.20821036f, -0.35916734f, -0.14295985f, -0.11290897f, -0.04629060f, 0.31253836f, 0.22731906f, 0.09170942f, 
    -0.06770349f, 0.06001437f, 0.15613092f, -0.12137307f, -0.21536854f, 0.03343466f, -0.61295390f, -0.66046977f, 
    -0.41693756f, -0.30763781f, -0.19620806f, -0.56041777f, 0.50529104f, 0.36552545f, -0.42353761f, 0.47610128f, 
    -0.10670504f, 0.14577098f, 0.22896993f, 0.05641114f, -0.09130399f, -0.07356225f, -0.07246298f, 0.11771733f, 
    -0.06432231f, 0.14950995f, 0.47739390f, 0.25665632f, -0.20398566f, 0.42910612f, 0.11846608f, 0.81992817f, 
    -0.19088681f, -0.86292529f, -0.55355752f, -0.13739724f, 0.52917671f, -0.04055431f, -0.06968274f, -0.20479421f, 
    0.05253005f, -0.46365082f, 0.07017516f, 0.27890640f, -0.00724445f, -0.00117677f, -0.34686092f, -0.15725213f, 
    -0.21784814f, 0.26681378f, -0.22116052f, -0.07337832f, -0.04082293f, 0.07416218f, 0.08937459f, 0.35339203f, 
    -0.78829110f, -0.23584247f, 0.47495514f, -0.27257684f, 0.39862004f, 0.75235331f, -0.14983144f, -0.16780889f, 
    0.15923643f, -0.50918198f, -0.01381916f, 0.35643807f, 0.33629093f, -0.08393378f, -0.35606349f, -0.25849366f, 
    -0.04228576f, -0.09938302f, -0.23620661f, 0.10075372f, 0.23955500f, -0.10987290f, 0.00080161f, 0.08737993f, 
    0.02632805f, 0.67957044f, 0.48848268f, 0.39325452f, 0.89432138f, 0.47849193f, -0.41869718f, 0.34943569f, 
    0.34838843f, -0.03237480f, 0.12762557f, -0.43448859f, -0.15877002f, 0.16787040f, 0.14565256f, -0.00112279f, 
    -0.24114564f, 0.07560359f, -0.13767508f, 0.00785895f, -0.01567976f, 0.24575558f, -0.09411968f, -0.14477479f, 
    0.23573858f, -0.11300604f, 1.02267528f, 0.09594328f, 0.11586407f, 0.82035750f, 0.57773650f, 0.47027126f, 
    0.21315743f, -0.12508665f, -0.21951555f, -0.50215173f, 0.09967159f, 0.07500096f, -0.18148749f, 0.08723075f, 
    0.17903151f, 0.29768395f, -0.27304551f, 0.00770815f, 0.29155633f, -0.22216938f, -0.05625458f, -0.26801547f, 
    0.23809905f, 0.25661293f, 0.13826536f, 0.00485533f, -0.21642871f, -0.44793686f, -0.28152341f, -0.10665287f, 
    -0.46094272f, 0.49448460f, 0.26384479f, -0.40933496f, -0.34893900f, -0.13487434f, -0.14990191f, -0.51437294f, 
    -0.54811192f, -0.44264746f, 0.32519653f, 0.01205348f, -0.39783031f, -0.27172896f, -0.33447403f, -0.17267510f, 
    -0.31577271f, -0.16011429f, -0.22008684f, -0.18389142f, 0.60064155f, 0.21881220f, 0.38803199f, 0.78065974f, 
    0.92351180f, 0.05207427f, -0.52941185f, -0.27110791f, -0.38399366f, 0.17830360f, 0.28143483f, 0.06549756f, 
    0.08635865f, 0.16783553f, 0.09981088f, 0.28878662f, -0.06415734f, 0.22939940f, 0.37283167f, 0.41853839f, 
    0.19171378f, -0.06959391f, -0.01251071f, -0.09077894f, 0.06090591f, 0.03114406f, -0.13480513f, -0.26038942f, 
    -0.30662206f, -0.13293497f, -0.16354111f, 0.38048029f, 0.22423993f, -0.47173366f, -0.41772822f, -0.25342804f, 
    0.26585859f, -0.13669622f, -0.15690514f, -0.50696218f, -0.41345134f, -0.17869179f, -0.37954178f, 0.07725067f, 
    -0.08364683f, -0.32518083f, 0.11430724f, 0.39739031f, -0.06704341f, 0.66181952f, -0.51160771f, -0.23107608f, 
    -0.29813474f, -0.48129976f, -0.10104842f, -0.19028138f, -0.60485214f, 0.10413086f, -0.10123026f, -0.50493020f, 
    -0.00073332f, -0.10835589f, -0.17154659f, -0.18892802f, 0.07827240f, 0.24810354f, 0.30705479f, -0.47292316f, 
    0.01241630f, -0.04494959f, -0.20759264f, 0.44649050f, 0.34922376f, 0.17166428f, -0.04987063f, -0.62855363f, 
    0.07987831f, 0.60419989f, -0.07964180f, 0.32936335f, -0.22847483f, -0.02233615f, -0.18518807f, -0.06547716f, 
    0.20247701f, -0.62210435f, -0.24826555f, 0.04136651f, 0.12030804f, -0.23514065f, 0.13193941f, 0.17281424f, 
    0.07255752f, -0.35012689f, 0.34397507f, -0.22269863f, 0.11790586f, -0.46670020f, -0.21439344f, 0.05551472f, 
    -0.54072195f, -0.28323814f, -0.39420217f, -0.32656080f, -0.47560170f, -0.26334959f, -0.03684318f, -0.38242853f, 
    -0.34795004f, 0.18912426f, -0.22066765f, 0.17481415f, -0.27301762f, 0.38516024f, 0.21566813f, 0.13366577f, 
    -0.20286022f, 0.09794604f, 0.18501136f, -0.09510990f, -0.10830922f, 0.11126921f, -0.06130026f, -0.29099739f, 
    -0.18114598f, 0.47691885f, -0.14664398f, -0.23151420f, -0.13894773f, -0.26059920f, -0.47641763f, -0.58320546f, 
    -0.08536127f, -0.20609951f, -0.56329256f, -0.53352731f, 0.12918636f, 0.29459262f, -0.40207902f, -0.50664252f, 
    0.10094631f, -0.49103656f, 0.25043207f, 0.14486246f, -0.42819861f, 0.18002963f, -0.12304058f, 0.04863228f, 
    -0.03945392f, 0.23209253f, 0.65314049f, 0.37511542f, -0.46839622f, 0.25412109f, -0.97588176f, 0.34450626f, 
    -0.46280083f, 0.32739171f, -0.12265878f, 0.31594485f, 0.17324241f, -0.31579828f, 0.09445098f, 0.32603085f, 
    -0.17155652f, -0.09810215f, -0.11059904f, -0.16444984f, -0.52184409f, 0.13099541f, 0.09144472f, -0.14585818f, 
    0.32151827f, 0.12096925f, -0.27790299f, -0.22370367f, -0.42434439f, -0.27246901f, 0.10211864f, 0.02843823f, 
    0.12123873f, -0.86541688f, -0.53151977f, -0.56316096f, -0.79240626f, -0.25709602f, 0.00670332f, 0.34574190f, 
    0.19552286f, 0.28752252f, 0.04940423f, 0.04326514f, -0.34478384f, 0.08628621f, 0.09186267f, -0.06321513f, 
    0.03885244f, 0.31959179f, -0.20210563f, 0.03695708f, 0.81141955f, 0.66616529f, 0.65895671f, -0.11817364f, 
    -0.36994073f, -0.20403895f, -0.43905306f, 0.06869576f, 0.11516034f, 0.48605901f, 0.46584401f, -0.07468519f, 
    0.09685588f, -0.09612295f, -0.34276620f, -0.28167060f, -0.37590703f, 0.07521091f, 0.07997262f, -0.21024396f, 
    0.10990036f, 0.39240250f, -0.10695972f, -0.04796422f, 0.07972291f, -0.62360239f, -0.20126382f, 0.19103906f, 
    0.39880592f, 0.31598502f, -0.58731323f, 0.40506032f, 0.46897221f, -0.50988990f, 0.10340085f, 0.06630146f, 
    0.04968088f, 0.45584714f, 0.14390235f, 0.32434916f, -0.01138662f, -0.04752937f, 0.19490217f, 0.14485271f, 
    0.12317995f, 0.22980732f, 0.06898897f, -0.48166403f, 0.01997911f, -0.18829638f, 0.36619255f, 0.90341067f, 
    0.60259557f, -0.23432881f, 0.15011182f, -0.37473151f, 0.34826502f, -0.33624303f, -0.33586136f, 0.46004510f, 
    0.28423449f, -0.25624263f, -0.19475240f, 0.12845410f, 0.06453848f, -0.02540541f, -0.19628426f, -0.17221217f, 
    0.13971587f, 0.14913785f, -0.37715623f, 0.16466315f, -0.05159641f, -0.37472534f, 0.14451151f, -0.22054835f, 
    -0.04886136f, 0.65404725f, 0.01102216f, -0.25586745f, -0.75955153f, 0.39005929f, -0.31721434f, -0.32101282f, 
    -0.27028617f, -0.04812192f, 0.29001567f, -0.31644920f, -0.37152413f, -0.47618893f, 0.13550498f, -0.33484963f, 
    -0.12439910f, -0.15788031f, 0.45523846f, -0.16329923f, -0.12560557f, -0.13609049f, -0.25846180f, -0.20486645f, 
    -0.18102244f, -0.46338052f, -0.36757949f, 0.57001966f, -0.28497660f, -0.53163302f, -0.66643369f, -0.21077093f, 
    0.20029636f, 0.14756270f, -0.04076307f, 0.39317375f, -0.10764511f, 0.29249579f, -0.59464717f, -0.05348732f, 
    -0.09457432f, -0.04741058f, 0.19171213f, -0.06824037f, 0.34715962f, -0.13185976f, 0.10494590f, -0.09494603f, 
    -0.01700498f, -0.34175572f, -0.56812859f, -0.75492126f, -0.47587630f, -0.22298577f, 0.20639752f, -0.09003890f, 
    0.16627827f, 0.53664964f, 0.39750153f, -0.36477154f, -0.12895097f, -0.12523170f, -0.09989870f, -0.30080020f, 
    0.06312136f, 0.17230305f, 0.04242058f, -0.01197281f, 0.00078840f, -0.02764559f, -0.13442402f, -0.22844020f, 
    0.19227433f, 0.15121895f, -0.34855387f, 0.04102278f, -0.21148710f, -0.15031061f, -0.33620259f, 0.21934883f, 
    -0.72203881f, 0.29181743f, 0.54912031f, -0.56098455f, -0.60516053f, -0.03452836f, 0.02007115f, 0.10018229f, 
    -0.07460093f, -0.36433494f, 0.09793235f, 0.06318730f, 0.01105832f, -0.14607625f, 0.05533805f, 0.11993349f, 
    -0.08669750f, 0.25554737f, 0.05008953f, -0.41758391f, -1.04646850f, -0.67615694f, -0.06740833f, 0.30939102f, 
    -0.61815834f, 0.48833108f, 0.45896134f, -0.24044372f, 0.31323385f, 0.21544065f, 0.24333960f, 0.24613006f, 
    0.07699859f, -0.00892655f, -0.41919768f, -0.00250337f, 0.06244041f, -0.04022752f, -0.14577003f, -0.05469834f, 
    -0.10042732f, 0.27531996f, -0.12387280f, 0.03164026f, 0.22499932f, 0.59548676f, 0.79001939f, 0.45948920f, 
    0.20686474f, -0.20592542f, 0.29656738f, -0.72927958f, -0.79189551f, -0.38146165f, 0.40920052f, 0.10255151f, 
    -0.19766061f, -0.03234475f, -0.17508070f, -0.16594300f, 0.06173759f, -0.25992453f, -0.01689293f, 0.34838244f, 
    0.26237497f, 0.29775390f, 0.15269454f, 0.10790017f, 0.44036859f, 0.85040283f, 0.39321488f, 0.72789776f, 
    0.01718116f, 0.05942515f, 0.45404592f, 0.02599842f, 0.01034034f, -0.50883985f, -0.19985379f, -0.00754314f, 
    0.03594283f, -0.32593176f, 0.22484685f, -0.04275338f, -0.00314685f, 0.14086993f, 0.03803328f, -0.01592689f, 
    -0.20074300f, -0.12417427f, 0.49573767f, 0.20753069f, -0.11869008f, -0.13486716f, 0.30266181f, -0.28047711f, 
    0.90209311f, 0.65621674f, -0.94444269f, -0.03808479f, -0.85103691f, 0.34661263f, -0.00934274f, 0.27117297f, 
    0.10585812f, -0.03487414f, -0.30449730f, 0.01886823f, 0.08028376f, 0.03787394f, 0.16832140f, 0.01814457f, 
    -0.00289735f, -0.11955100f, -0.01837921f, -0.00556867f, -0.11386156f, -0.05933232f, -0.46899948f, 0.62273121f, 
    0.07763146f, 0.14354470f, 0.58689803f, 0.47431123f, 0.51425743f, -0.49564767f, 0.13312116f, 0.61650902f, 
    -0.30675349f, -0.40288523f, -0.19962819f, -0.25013942f, -0.47999361f, -0.02865609f, 0.06934028f, 0.11277221f, 
    -0.03824557f, -0.14213525f, -0.14307763f, -0.10326999f, -0.17077348f, 0.15684271f, -0.24905218f, -0.15877745f, 
    -0.47075593f, -0.44917369f, -0.35264900f, 0.07888658f, 0.08511558f, 0.45988768f, 0.83494699f, 0.20729597f, 
    -0.35103318f, 0.25472808f, -0.32088178f, -0.28793976f, -0.09171779f, -0.42659122f, 0.13328545f, -0.41070315f, 
    0.26071450f, 0.21896236f, 0.04084028f, -0.44843793f, -0.08591354f, -0.36034235f, -0.14032564f, -0.19977853f, 
    -0.08479457f, -0.78424621f, -0.67396581f, 0.37331495f, 0.03842659f, -0.71021330f, 0.43955481f, 0.69756001f, 
    0.12110126f, -0.19249648f, 0.17588881f, 0.00851357f, -0.11550014f, -0.18028353f, 0.20600420f, -0.01916677f, 
    0.11122821f, 0.05566275f, -0.18959311f, -0.10921786f, -0.23836154f, -0.04746382f, 0.06235942f, 0.07351098f, 
    -0.08314183f, -0.02347115f, 0.61506456f, -1.10452712f, -0.37435564f, -0.14449717f, 0.41210434f, 0.33150959f, 
    0.59109229f, -0.01058698f, 0.21714084f, 0.44922754f, -0.18574421f, -0.03493136f, -0.29708686f, 0.36031741f, 
    -0.12578903f, 0.04826320f, -0.06732948f, 0.01392366f, -0.01426148f, -0.17378063f, -0.03484181f, -0.10818610f, 
    0.04654716f, 0.04943013f, 0.18618301f, 0.23033148f, 0.63687372f, -0.35441470f, -0.14850897f, 0.35244599f, 
    -0.45730039f, 0.25349289f, 0.48809692f, 0.12466415f, 0.41010717f, -0.37347871f, 0.04416974f, -0.38349935f, 
    -0.37280610f, -0.63621885f, -0.03969268f, -0.26210994f, 0.22409385f, -0.22278300f, 0.24422213f, 0.31926599f, 
    0.37950796f, 0.15763876f, 0.15203160f, -0.05247825f, 0.29643184f, 0.30571833f, 0.52194387f, 0.45259178f, 
    0.53086621f, -0.22050717f, -0.06613705f, 0.12762004f, -0.00515398f, 0.31528753f, -0.21078588f, -0.43303138f, 
    -0.49068493f, -0.21748573f, 0.09485967f, -0.38339388f, -0.26295310f, -0.06226738f, -0.21423540f, -0.01468866f, 
    0.38713589f, -0.21847139f, -0.34377095f, -0.03244963f, 0.07743745f, 0.86083472f, -0.04469403f, -0.11907577f, 
    0.54429621f, 0.84651583f, 0.43840399f, 0.17002942f, -0.05362640f, 0.14009267f, 0.27656421f, -0.17656571f, 
    0.28149351f, -0.13814713f, 0.15474758f, 0.05122695f, -0.15180358f, -0.00069466f, 0.23897372f, 0.12338371f, 
    -0.14118408f, -0.14236838f, 0.07385327f, -0.12572111f, 0.19397253f, -0.05002500f, 0.76712888f, 0.06483322f, 
    0.12223203f, -0.76023018f, -0.71636301f, 0.23426665f, -0.39845842f, -0.18705557f, -0.41988474f, -0.60519087f, 
    0.47716552f, 0.18561912f, 0.13359061f, -0.18703209f, -0.01195054f, 0.09444157f, 0.06665302f, -0.13376343f, 
    0.11493097f, -0.18576166f, 0.26282573f, -0.01183078f, 0.23225850f, 0.03376792f, 0.14382367f, 0.11627772f, 
    -0.31764674f, -0.57075614f, -0.64174676f, -0.38079894f, 0.15868075f, 0.47087941f, 0.50824821f, 0.44700968f, 
    -0.30897829f, -0.07445564f, -0.23906913f, -0.01986409f, 0.00417565f, 0.17841148f, 0.23175111f, -0.26465148f, 
    -0.18613648f, -0.02027292f, 0.03980679f, 0.25467396f, 0.35920489f, -0.12261882f, 0.07358297f, -0.11819907f, 
    -0.52594209f, -0.64283627f, -0.11909641f, 0.48176157f, 0.03577770f, 0.25161073f, 0.47275180f, 0.17285998f, 
    0.42761722f, 0.49089471f, -0.17793426f, -0.33153537f, 0.01261236f, 0.14926642f, -0.38355598f, -0.30675772f, 
    -0.31508073f, 0.07082027f, 0.10778778f, -0.05527433f, -0.36009955f, -0.01477005f, -0.33632669f, -0.20044111f, 
    -0.15928544f, -0.56271094f, -0.81159359f, -0.10128862f, 0.09498615f, 0.67642415f, -0.42117828f, 0.38614589f, 
    0.12286852f, -0.47513282f, 0.15322149f, 0.33713982f, -0.08149219f, 0.23198912f, -0.29362863f, 0.04914717f, 
    -0.00291579f, 0.26191512f, -0.21070710f, 0.07048307f, -0.22958510f, -0.11078829f, -0.34183726f, 0.07342543f, 
    -0.01062506f, -0.00260946f, 0.98744118f, 0.41947854f, 0.56652963f, -0.44435820f, -0.45425704f, -0.39785492f, 
    0.12114903f, 0.22916849f, 0.37424874f, 0.40504238f, -0.07510503f, 0.08145756f, -0.11410537f, -0.08418368f, 
    -0.32899094f, 0.21846062f, 0.09659244f, 0.18818866f, 0.12957573f, -0.07038690f, 0.10699474f, -0.24937777f, 
    -0.01483356f, 0.16467924f, 0.31486183f, -0.26834074f, 0.54243565f, -0.15073618f, -0.59590513f, -0.25767085f, 
    0.29543588f, -0.26579729f, -0.54982859f, -0.00170504f, -0.62650263f, -0.35161036f, -0.01721181f, 0.14476155f, 
    0.17427990f, -0.08614884f, 0.34359798f, 0.10136918f, 0.28828925f, 0.23861879f, 0.20190552f, 0.33351719f, 
    0.24999602f, -0.43833697f, -0.08285549f, 0.05796971f, -1.19086492f, 0.02293701f, 0.05658573f, -0.23326486f, 
    -0.64496022f, 0.23659569f, -0.09745634f, -0.09587725f, 0.31419250f, 0.49838915f, 0.19582306f, -0.43112665f, 
    0.36708936f, 0.24560726f, 0.32655317f, -0.32781163f, -0.45247257f, -0.17093015f, -0.41362134f, 0.17057405f, 
    0.07556053f, -0.28848919f, -0.01727043f, -0.07939088f, -0.06194723f, -0.27785516f, -0.51996803f, -0.31931791f, 
    -0.17945957f, -0.02141057f, -0.33645570f, 0.03169028f, -0.36764321f, -0.07610683f, 0.62031901f, -0.11464833f, 
    0.25529853f, 0.00568234f, -0.30205414f, 0.12716132f, 0.05683405f, -0.26366529f, 0.30071217f, 0.36994594f, 
    -0.03440478f, 0.23509650f, 0.12512283f, -0.17114429f, 0.11410308f, 0.02944668f, -0.58839023f, 0.33758634f, 
    -0.06648351f, -0.31419453f, 0.03803059f, 0.30788749f, 0.93534023f, 0.37810278f, 0.15214382f, 0.58735651f, 
    -0.19552751f, -0.00798102f, -0.11789336f, -0.26059476f, -0.00900154f, 0.11588996f, -0.01903739f, -0.16996571f, 
    0.03134080f, -0.10683006f, -0.16565566f, -0.06158120f, -0.08406328f, -0.21666096f, 0.15580633f, 0.14530516f, 
    0.54180199f, -0.22955008f, 0.40922341f, 0.03237761f, 0.04794556f, 0.27213782f, 0.53674769f, 0.29161686f, 
    0.52267516f, 0.18300523f, -0.24445730f, 0.45178163f, -0.52436447f, 0.18083929f, -0.09349503f, -0.29355797f, 
    -0.37656778f, -0.14214946f, -0.25655180f, -0.28454065f, -0.15765774f, -0.27434278f, -0.17595051f, 0.00163938f, 
    0.72078460f, 0.48504120f, -0.07166652f, 0.59708166f, -0.32338068f, -0.10067875f, 0.22009076f, 0.46509331f, 
    0.28372604f, 0.45884979f, -0.15929665f, -0.23797768f, 0.26405123f, 0.10242432f, 0.11200601f, 0.48238018f, 
    -0.25374317f, -0.13385664f, -0.37107888f, 0.24845175f, 0.07210623f, -0.12720054f, 0.03127929f, 0.06447943f, 
    0.01560453f, 0.53841907f, 0.29520679f, -0.53744012f, -0.61811018f, -0.66812092f, 0.28615561f, 0.56916982f, 
    0.06333333f, 0.03828383f, 0.25022438f, 0.32678819f, 0.12711316f, 0.11861274f, 0.03693353f, -0.11779201f, 
    0.14483443f, 0.03916587f, 0.16034336f, -0.08644804f, -0.06015790f, 0.09104154f, -0.29286835f, 0.43152016f, 
    -0.25261495f, 0.04420272f, 0.52922159f, 0.61309052f, 0.36857110f, -0.94351774f, 0.10859880f, 0.04624487f, 
    0.38541821f, 0.04754547f, -0.47798601f, -0.46237150f, 0.13399744f, -0.14976424f, 0.25231037f, 0.18942352f, 
    0.19311143f, 0.16030003f, 0.41453925f, 0.23221631f, 0.10043132f, -0.24860987f, 0.16160767f, 0.10467578f, 
    -0.09492541f, 0.03470923f, 0.25991270f, -0.43992069f, -0.17373422f, 0.20881979f, 0.20137121f, -0.17906184f, 
    -0.45836452f, 0.04456569f, -0.06251285f, -0.65260869f, 0.40216389f, 0.48611769f, 0.05784836f, -0.55795741f, 
    0.06870329f, -0.13396488f, -0.06807524f, -0.19199802f, 0.46039295f, -0.15077184f, -0.25181195f, -0.22278804f, 
    0.00460682f, -0.13247284f, 0.12558214f, -0.24396938f, 0.44877955f, 0.65946275f, 0.47564095f, 0.54661995f, 
    0.44078338f, -0.34074906f, 0.34737563f, -0.12663178f, -0.68998706f, -0.30671012f, -0.32555509f, 0.26883048f, 
    0.37599498f, 0.13257286f, 0.34403634f, -0.05667518f, 0.10951229f, 0.50473171f, -0.11941707f, -0.16634443f, 
    -0.11668601f, -0.15268141f, -0.16591233f, 0.02478307f, 0.06949653f, -0.24929379f, -0.54370481f, -0.48602307f, 
    0.19207899f, 0.06374440f, 0.31002739f, 0.37820080f, -0.74545115f, 0.16421959f, -0.19916157f, -0.00864710f, 
    0.35894775f, -0.27037245f, 0.39554840f, -0.10455417f, 0.02399404f, -0.05045597f, -0.43131599f, -0.23959816f, 
    0.34182370f, 0.28986526f, -0.02559573f, 0.26280999f, 0.23441085f, -0.20310453f, -0.56843209f, 0.19153400f, 
    -0.27587536f, -0.59201097f, -0.06873977f, 0.52013367f, 0.40907168f, 0.30801475f, 0.45196101f, 0.45327696f, 
    0.38040489f, 0.25406352f, 0.22792757f, -0.37662986f, 0.18461771f, 0.28608125f, -0.20037171f, -0.03340583f, 
    -0.29053071f, -0.07092918f, -0.11107167f, -0.15806670f, -0.15563200f, -0.08314026f, -0.33633268f, -1.50503719f, 
    1.09539640f, -0.06705384f, -0.48775128f, -0.13056459f, -0.29114303f, 0.51858419f, 0.17697906f, 0.20572332f, 
    -0.13177344f, -0.47084513f, 0.06604497f, 0.05079912f, -0.18416134f, 0.20935848f, 0.20191213f, 0.08124494f, 
    -0.17247981f, 0.08362363f, 0.03195709f, 0.31604651f, 0.22599745f, 0.02235337f, 0.28198579f, 0.28404525f, 
    -0.47638777f, 0.96742904f, -0.19647060f, -0.75839901f, -0.54761904f, 0.85868949f, -0.40675312f, -0.27485746f, 
    -0.42449042f, -0.25505522f, 0.08002915f, -0.10912581f, 0.15483025f, 0.41013989f, 0.07129679f, 0.01546637f, 
    0.11754151f, 0.10359704f, -0.12446506f, 0.27561370f, -0.07932817f, -0.00551729f, -0.07903904f, -0.07821878f, 
    0.04382581f, 0.73490602f, 0.29700196f, 0.00786423f, 0.23105505f, 0.91756731f, 0.68815351f, 0.38272521f, 
    -0.29831064f, 0.42746669f, 0.16920279f, -0.25321913f, 0.19657552f, 0.00998858f, 0.03818568f, -0.11415896f, 
    -0.11744409f, -0.01970816f, 0.11141595f, -0.05917680f, 0.03356905f, 0.20593274f, -0.06373043f, 0.28394508f, 
    -0.11738226f, 0.00636000f, -0.46423352f, -0.79647636f, 0.55459768f, 0.36042991f, -0.67951542f, -0.22126696f, 
    0.05542288f, 0.58264339f, -0.15859443f, -0.42981994f, -0.07582764f, 0.08144000f, -0.25386059f, -0.04083259f, 
    0.31625220f, 0.21724123f, -0.03429479f, -0.33161953f, -0.38172078f, -0.19048338f, 0.23222570f, 0.09135377f, 
    0.13879654f, 0.32008108f, 0.03221974f, 0.99351370f, 0.12990759f, -0.67103648f, 0.15605153f, -0.54299009f, 
    -0.53745872f, -0.45940980f, -0.09982079f, 0.15168518f, 0.17001329f, -0.12080299f, 0.31115335f, 0.15291686f, 
    0.03157864f, 0.01411890f, 0.16342352f, -0.00418127f, -0.17619963f, 0.23145200f, 0.56895578f, -0.11384302f, 
    0.10489003f, 0.14537925f, -0.40376750f, -0.11699432f, -0.20816511f, -0.33557513f, 0.27844664f, 0.63288206f, 
    -0.16087440f, -0.42355582f, -0.42847767f, 0.63629317f, 0.32885683f, -0.40386066f, -0.01888643f, -0.35576582f, 
    -0.30324763f, -0.35730085f, -0.00018676f, 0.00453326f, 0.37245679f, -0.06122535f, 0.13968331f, -0.40791199f, 
    -0.17121625f, -0.10475697f, -0.11387520f, -0.15968908f, -0.00975197f, 0.33041799f, -0.57795238f, -0.32996351f, 
    -0.48289785f, -0.19287018f, 0.22574465f, -0.59617054f, 0.31637296f, 0.67982662f, -0.32049805f, -0.26649141f, 
    -0.04997888f, -0.22300974f, -0.17298019f, -0.17080632f, 0.09651060f, -0.08177924f, -0.03124474f, -0.13073310f, 
    0.12098846f, 0.05840299f, 0.22379731f, -0.00384038f, 0.21811825f, -0.48240232f, -0.49024910f, -0.71839416f, 
    0.42395616f, 0.45222867f, 0.33464181f, 0.46765020f, 0.38874760f, 0.03798196f, 0.13883638f, -0.61858988f, 
    0.27305633f, 0.08474991f, 0.01632400f, 0.49337184f, 0.33338875f, 0.53132457f, 0.30482003f, 0.42162764f, 
    -0.09094176f, 0.18153423f, -0.09340250f, -0.10446623f, -0.43825245f, 0.06921448f, 0.32210037f, -0.03535004f, 
    -0.10823982f, -0.59904832f, -0.63437539f, -0.21325620f, 0.36829287f, -0.29200664f, 0.16234006f, 0.46998495f, 
    -0.09918092f, -0.53725111f, -0.18448779f, 0.05506162f, -0.09108087f, -0.59609771f, -0.03229040f, 0.04275870f, 
    0.30181897f, -0.03010211f, 0.48180375f, -0.11556841f, -0.32769352f, -0.03215504f, 0.06135731f, 0.32693440f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07702192f, 0.24967743f, 0.08070490f, 0.34350464f, -0.04360992f, 0.02225512f, 0.11999065f, 0.12180088f, 
    0.24917673f, 0.03386164f, 0.26652953f, -0.02944757f, 0.02679395f, 0.19329844f, 0.01257792f, 0.24762110f, 
    0.21820799f, 0.26958925f, -0.00722011f, 0.04120155f, 0.07154619f, 0.22679605f, 0.18093826f, 0.13088524f, 
    0.20167175f, -0.12554707f, 0.14855050f, 0.16643155f, 0.25293717f, 0.02106410f, 0.21503673f, 0.09092753f, 
    -0.05992287f, 0.08250809f, 0.14465243f, 0.07315527f, 0.13180496f, 0.06772129f, 0.27712262f, 0.16221705f, 
    0.21625850f, 0.13373910f, 0.05944004f, 0.16002074f, -0.03458405f, 0.25137007f, -0.09656281f, 0.24322613f, 
    0.31824052f, -0.04891821f, 0.03455218f, 0.04858177f, 0.19598638f, 0.25340247f, -0.22253925f, 0.26394290f, 
    0.22523527f, -0.01398304f, 0.18706714f, 0.06937229f, 0.10470375f, 0.00727055f, 0.13320750f, -0.10160657f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24885127f, -0.39474273f, 0.04114092f, 0.00431029f, 0.06448681f, -0.10427530f, 0.01793840f, 0.03300130f, 
    0.04645228f, -0.06776306f, 0.00896648f, 0.09164534f, -0.10713152f, -0.07867146f, 0.04228344f, -0.05395469f, 
    0.01232077f, 0.00314711f, 0.04794357f, 0.04106632f, -0.11275678f, -0.02757921f, 0.08498770f, -0.06910080f, 
    0.11813718f, 0.29645377f, 0.02063720f, -0.03537212f, 0.11950848f, 0.06597405f, 0.17623776f, -0.02168316f, 
    -0.02161462f, 0.03725122f, 0.08649796f, 0.00667442f, 0.01145771f, -0.12256534f, 0.10138702f, -0.02931318f, 
    0.13190979f, 0.03894120f, 0.03038110f, -0.01883959f, 0.03522592f, 0.12376019f, 0.13757372f, -0.00350192f, 
    -0.08644305f, 0.19642076f, -0.10899105f, -0.25133255f, 0.05716159f, -0.02489550f, -0.12530176f, 0.04621999f, 
    -0.01357499f, 0.06197492f, 0.04628645f, 0.12066013f, 0.38907573f, -0.09608577f, -0.28969198f, -0.14733568f, 
    0.06316225f, -0.01050631f, -0.06404786f, -0.09753517f, 0.08424418f, 0.01491652f, -0.02392195f, -0.12731677f, 
    0.19526522f, -0.12436620f, -0.13196321f, -0.09450985f, -0.00565553f, 0.10832497f, 0.00866167f, -0.02541143f, 
    0.03728090f, 0.15109369f, 0.11417419f, 0.13021426f, -0.19904570f, 0.16508271f, 0.11691245f, -0.09126315f, 
    0.04921748f, 0.04284674f, 0.05825232f, 0.01742607f, 0.16025004f, -0.05655732f, 0.10494997f, -0.03177759f, 
    0.05868991f, -0.00775585f, 0.03158287f, 0.21495876f, -0.02920544f, 0.03085943f, -0.01662571f, 0.09021280f, 
    0.10380765f, -0.01638282f, 0.17843509f, 0.08065785f, -0.25837627f, -0.08547360f, -0.17732045f, -0.12760726f, 
    0.22209413f, 0.07270263f, -0.05048404f, 0.02980821f, 0.01454907f, 0.05539438f, 0.04453726f, 0.08686179f, 
    -0.24022678f, -0.08685645f, -0.22811025f, -0.01495648f, 0.10597330f, 0.04355342f, 0.05832428f, 0.08932497f, 
    0.01636661f, 0.11258551f, 0.01513360f, 0.13127761f, 0.05581231f, -0.03290925f, -0.35579988f, -0.05419441f, 
    -0.00017302f, 0.10777592f, -0.08893677f, -0.04790111f, 0.07761613f, -0.16441001f, -0.10207151f, -0.06347453f, 
    0.04324820f, 0.18459055f, -0.06243172f, -0.36269942f, 0.02528886f, -0.16233909f, -0.00089440f, 0.06263744f, 
    -0.03165649f, 0.13602749f, 0.02706526f, 0.16377106f, 0.07017954f, 0.10015073f, -0.10379008f, 0.13633640f, 
    0.00774596f, 0.07608854f, -0.04987305f, -0.07492569f, 0.12010901f, 0.03129186f, 0.03884104f, 0.04066755f, 
    0.00441470f, -0.04555623f, 0.07018920f, -0.12830360f, -0.02527394f, 0.04284810f, 0.08957421f, -0.02253621f, 
    0.01336612f, 0.02089752f, -0.00419254f, 0.11212400f, 0.03746779f, 0.03812200f, 0.02995121f, -0.11353158f, 
    0.05268478f, -0.01475713f, 0.00249501f, 0.02383090f, 0.05150108f, 0.11562999f, 0.02552744f, -0.00395364f, 
    0.01509060f, -0.14802070f, -0.17802148f, -0.08857203f, -0.05600584f, 0.01754893f, 0.09425428f, 0.00340228f, 
    -0.08473096f, -0.00925584f, -0.00442853f, -0.01706908f, -0.23221920f, -0.00559231f, 0.05474886f, -0.11900818f, 
    0.11993795f, 0.03633825f, 0.10749622f, 0.05517503f, -0.00884173f, -0.03115857f, 0.13448909f, 0.03251638f, 
    -0.18793456f, 0.23885533f, 0.28829107f, 0.03628033f, 0.08680474f, 0.08982077f, 0.20225498f, -0.03908038f, 
    0.15851220f, -0.02440841f, 0.07246398f, 0.07492837f, 0.17301694f, 0.00569335f, -0.15112822f, -0.11685665f, 
    0.10263193f, 0.01652828f, 0.17623049f, 0.00597737f, -0.05823820f, 0.14682040f, -0.10269663f, -0.01714109f, 
    0.17355840f, 0.28120708f, 0.18530868f, 0.09560692f, 0.17026605f, 0.00221750f, 0.01081051f, -0.04491760f, 
    -0.03049647f, 0.07505976f, -0.05266931f, 0.07163946f, 0.38811025f, 0.01840430f, -0.15613154f, -0.00905304f, 
    0.08561014f, 0.08299833f, -0.11347433f, 0.10898235f, 0.02589849f, 0.10577694f, 0.11728862f, 0.07801060f, 
    0.10142882f, 0.07973015f, 0.00608973f, -0.02060862f, 0.15847956f, 0.01493524f, -0.04412071f, -0.06578102f, 
    0.14709850f, 0.07288507f, -0.02591700f, 0.12781975f, 0.03370995f, 0.05467298f, -0.01545100f, -0.06557584f, 
    0.00666736f, -0.01397571f, -0.10053685f, -0.03150178f, 0.13196267f, -0.06560434f, -0.08456288f, 0.14862530f, 
    -0.06673566f, -0.07776999f, 0.10373220f, -0.16496091f, 0.06468806f, -0.05451228f, 0.11113813f, 0.08621757f, 
    0.05317144f, -0.03823029f, 0.09941744f, 0.10262164f, 0.00399762f, -0.07588819f, -0.05855000f, -0.26300797f, 
    -0.06013276f, -0.00161342f, -0.04111457f, -0.08290403f, 0.01583136f, -0.03113370f, -0.04522622f, 0.05730684f, 
    -0.16373470f, -0.03177031f, 0.11797225f, -0.08302041f, -0.07269687f, -0.04489857f, 0.01683163f, 0.07428058f, 
    0.06685649f, 0.17059937f, 0.00149043f, -0.01128582f, 0.29938531f, -0.15459037f, -0.03204196f, 0.01529811f, 
    -0.06684585f, -0.03260574f, 0.02354625f, 0.06249337f, 0.05055140f, -0.09172092f, 0.05734122f, -0.07465208f, 
    0.20566154f, 0.18710355f, -0.10954175f, -0.20576976f, 0.06222487f, 0.16983303f, 0.00180962f, 0.04914792f, 
    0.06721240f, 0.06266295f, 0.05644572f, 0.15035564f, -0.03391381f, 0.04344600f, -0.20000027f, -0.12020998f, 
    0.04206683f, -0.02103886f, 0.15680447f, -0.09462737f, -0.09041722f, 0.06444862f, -0.06121927f, -0.03362187f, 
    -0.14385311f, 0.24198800f, 0.14713076f, 0.23101625f, 0.11177526f, -0.05678419f, 0.00547632f, -0.03485352f, 
    -0.00010933f, -0.05455132f, 0.09462151f, 0.03025790f, -0.37961650f, -0.02582658f, 0.05682904f, -0.15026139f, 
    0.08543991f, 0.02554981f, -0.05489830f, -0.03005058f, -0.04153572f, 0.03647985f, 0.04571386f, -0.08820421f, 
    0.42767358f, 0.08550800f, -0.15372270f, 0.04832506f, 0.00932006f, 0.13698523f, -0.14327547f, -0.01663118f, 
    0.08123882f, -0.14005126f, -0.02677882f, -0.14436534f, 0.22379516f, -0.01773769f, -0.11442291f, 0.12572475f, 
    -0.16939186f, -0.03149627f, 0.08551386f, -0.14013377f, 0.05902884f, 0.12448999f, 0.14104998f, 0.02251752f, 
    0.36502028f, -0.05342819f, 0.05017445f, -0.00031471f, 0.06251778f, 0.04257371f, 0.11124285f, 0.14177327f, 
    0.00345145f, 0.07167520f, 0.12309364f, 0.02466979f, -0.04278151f, 0.07899620f, -0.05595625f, 0.02170250f, 
    0.08456897f, -0.05931468f, 0.06904037f, 0.03048037f, 0.11473147f, -0.00127405f, 0.10127149f, 0.14331083f, 
    -0.20699257f, 0.06155717f, -0.00616524f, -0.19565426f, 0.22445121f, 0.04872780f, -0.03858080f, 0.07925870f, 
    0.04568646f, 0.00313726f, -0.05565832f, -0.02355136f, -0.24505392f, 0.17550924f, -0.01895162f, -0.06743617f, 
    0.09107696f, -0.02419423f, -0.00631915f, 0.00751536f, 0.03888215f, 0.13319089f, 0.13270049f, 0.06902651f, 
    0.10055641f, 0.02724059f, 0.06124328f, -0.01492320f, 0.15449420f, 0.00049581f, 0.09836085f, 0.08862179f, 
    0.09316123f, 0.10426834f, 0.05307222f, 0.17149833f, 0.13911222f, 0.00503958f, 0.08609293f, -0.00055476f, 
    -0.01217290f, -0.08109739f, -0.01596101f, 0.09880274f, 0.04458405f, 0.11251552f, 0.00253086f, 0.00659919f, 
    0.34046900f, -0.07673409f, 0.10183311f, -0.02537892f, 0.07109457f, -0.03918207f, -0.11176720f, 0.10768594f, 
    -0.02296358f, 0.06662587f, -0.15392654f, 0.05726315f, 0.47193810f, 0.07472335f, -0.06446472f, 0.08661690f, 
    -0.03929775f, 0.12758511f, 0.03980857f, -0.02528702f, 0.03290742f, -0.07556106f, 0.04552591f, 0.01968089f, 
    0.12006094f, 0.10393312f, 0.15963301f, 0.37647167f, 0.08069783f, 0.07226427f, -0.07474107f, -0.10709012f, 
    0.00687364f, -0.06370576f, -0.07140043f, 0.13422620f, -0.18049425f, -0.12171704f, 0.02342481f, -0.08599644f, 
    -0.01881016f, 0.11926324f, -0.06585960f, -0.02509614f, 0.01091584f, 0.00373385f, -0.00467479f, -0.07562300f, 
    0.00646425f, -0.01287462f, 0.03603555f, 0.04950624f, -0.08470749f, 0.00771157f, 0.07581809f, -0.04754675f, 
    -0.06606624f, 0.07605221f, -0.00758840f, -0.06899057f, 0.19591790f, -0.07267222f, -0.00222669f, -0.04149963f, 
    0.08803105f, 0.12199420f, 0.18454072f, -0.02601686f, 0.02506341f, 0.17500792f, 0.09047606f, 0.03337471f, 
    0.36939672f, -0.16344976f, -0.08914325f, -0.04810127f, -0.06787688f, 0.02711374f, -0.01478406f, -0.00474129f, 
    0.02627639f, 0.05547022f, 0.07151810f, 0.04515994f, 0.12930886f, 0.02081053f, -0.00863570f, 0.14569794f, 
    0.03105973f, 0.04876570f, -0.05003792f, -0.06916481f, 0.16543707f, -0.04018549f, -0.03827862f, 0.08246849f, 
    -0.21332832f, 0.05756190f, 0.11129420f, 0.08468288f, 0.14936809f, 0.15885137f, 0.11181892f, -0.01029652f, 
    0.04696775f, -0.04310745f, -0.00494636f, 0.21263477f, 0.11427746f, 0.15786281f, 0.07656683f, -0.00905547f, 
    0.06203631f, -0.06283912f, 0.04430919f, 0.07879227f, 0.06790458f, -0.07689053f, 0.19976893f, -0.01813206f, 
    0.07923136f, 0.01272836f, -0.18763940f, 0.21642613f, 0.04226554f, 0.05055215f, -0.05467552f, 0.00155655f, 
    -0.06328677f, 0.06024462f, 0.10267673f, 0.08077653f, 0.20826828f, 0.07088877f, -0.09366093f, 0.01793119f, 
    0.03296655f, 0.05477983f, 0.07556185f, 0.03690217f, -0.07022192f, -0.05047130f, 0.09601437f, 0.05703266f, 
    0.09285370f, 0.04982238f, -0.31828892f, -0.10078663f, 0.07240184f, 0.05402368f, -0.01352063f, 0.01465100f, 
    0.04768129f, 0.08264102f, 0.14300215f, 0.01662255f, 0.18043385f, -0.11418624f, -0.01485399f, 0.15629832f, 
    -0.01516692f, 0.12157436f, -0.02463325f, 0.06127236f, 0.19376428f, -0.04463080f, 0.05794255f, 0.07961074f, 
    0.15054645f, -0.21851677f, -0.05715683f, -0.07980378f, -0.09349145f, 0.01135733f, 0.05043146f, 0.13226430f, 
    -0.03247385f, -0.07347816f, -0.05804904f, -0.08609062f, -0.03582381f, -0.24036701f, -0.00662335f, 0.16946140f, 
    -0.05292942f, 0.03597866f, -0.07068726f, 0.04559651f, 0.09209778f, 0.07027909f, 0.18020865f, 0.08033630f, 
    -0.31740254f, -0.17222586f, -0.08086731f, -0.05792341f, -0.02333273f, 0.11398199f, -0.01244751f, -0.05292085f, 
    0.11624141f, 0.07735463f, -0.00381683f, 0.09678233f, -0.32454252f, 0.21440075f, 0.02065883f, -0.05895711f, 
    0.12601966f, 0.02379186f, 0.01385088f, 0.04562781f, 0.09762520f, 0.02084734f, 0.16831052f, 0.06620536f, 
    0.03944153f, 0.08291435f, -0.05455108f, 0.19341448f, 0.05316813f, 0.11919373f, 0.08406522f, -0.03508009f, 
    0.11282479f, 0.08472618f, 0.00041071f, 0.06095318f, -0.30038682f, -0.03746282f, 0.23056614f, -0.06909254f, 
    0.21761912f, -0.10984375f, 0.01156057f, -0.07218159f, -0.06372418f, 0.06850027f, 0.02573799f, 0.20733562f, 
    -0.12927099f, 0.14508615f, -0.00086524f, 0.09107481f, -0.00942977f, -0.02027829f, -0.10978509f, 0.02994698f, 
    0.05845834f, -0.00412817f, -0.01020679f, 0.04041856f, -0.00289231f, 0.02565058f, 0.09302296f, -0.04419795f, 
    0.02179613f, -0.10635978f, 0.04948955f, 0.11894728f, 0.09875676f, 0.07770405f, 0.04090571f, 0.08519041f, 
    0.38448483f, 0.05516034f, -0.22013465f, 0.16770357f, -0.03021432f, 0.10985931f, -0.05986387f, 0.05991322f, 
    0.00574802f, 0.03267320f, 0.08958219f, 0.20560740f, -0.17800695f, -0.08085530f, 0.11975222f, -0.17258009f, 
    -0.05896975f, 0.10134029f, 0.01254723f, 0.09456959f, 0.16673350f, -0.01127682f, -0.05984589f, -0.00680795f, 
    -0.02245790f, -0.00568038f, 0.01587960f, -0.02157436f, 0.02863468f, -0.03851889f, 0.00079210f, 0.00007304f, 
    -0.01500504f, 0.00945901f, -0.04099258f, -0.02762937f, -0.03525484f, -0.00586465f, 0.00539395f, 0.01418990f, 
    0.00269894f, -0.03199830f, -0.02732744f, -0.03035734f, 0.00285600f, -0.04041814f, -0.00566202f, -0.00135281f, 
    0.01455664f, -0.01734373f, -0.00370697f, 0.02921298f, 0.03048441f, 0.01258110f, -0.01884536f, -0.04072693f, 
    -0.00650681f, -0.00572909f, -0.03304676f, 0.00519533f, 0.02619146f, 0.01696391f, 0.01585750f, 0.01252515f, 
    -0.02324046f, -0.02195627f, 0.01570519f, -0.02491433f, -0.02760266f, 0.02506795f, -0.02858503f, -0.00711876f, 
    0.00434557f, 0.02260133f, 0.01841729f, 0.02764718f, -0.03962830f, 0.00860723f, 0.00121098f, -0.02234114f, 
    0.01561797f, 0.03167430f, 0.01247453f, -0.00065938f, 0.02118296f, -0.03810436f, 0.01416208f, 0.01092660f, 
    0.01777278f, 0.00702692f, -0.02639670f, 0.00679856f, -0.00946029f, 0.02218425f, 0.02737322f, -0.01512570f, 
    -0.02393143f, 0.00707655f, -0.01684758f, 0.00374756f, -0.01751242f, -0.01010386f, 0.01011168f, -0.01963491f, 
    -0.01846298f, -0.03883665f, -0.00533174f, -0.03207930f, -0.00087276f, -0.00577284f, -0.04041049f, 0.01926584f, 
    0.02859418f, 0.02801731f, 0.00544099f, 0.02236463f, 0.01676630f, 0.00532216f, 0.01642079f, 0.01676442f, 
    0.02170450f, -0.02401116f, -0.00369889f, -0.01827576f, -0.00462299f, -0.01156653f, 0.01540288f, -0.02581629f, 
    -0.03331428f, -0.02998042f, 0.00680419f, 0.00018753f, 0.00282995f, -0.02063297f, -0.01510458f, 0.02627949f, 
    -0.00739470f, -0.02467893f, -0.02696833f, -0.01202809f, -0.00082041f, 0.01057531f, 0.02566237f, -0.02009685f, 
    -0.01934314f, -0.01991581f, 0.01613282f, -0.02751732f, -0.01047687f, -0.02478511f, -0.00465990f, -0.00707765f, 
    0.02305272f, 0.02887953f, 0.01673182f, 0.00721043f, 0.00757398f, -0.00668810f, -0.00084153f, -0.00147976f, 
    0.02665931f, 0.02853346f, -0.01950068f, 0.01701148f, -0.02275856f, -0.00717244f, 0.02332970f, 0.00177265f, 
    -0.03910591f, -0.02012803f, 0.00902672f, 0.02848921f, -0.03346675f, 0.02867322f, -0.01248965f, -0.00135330f, 
    0.00996152f, 0.01748350f, -0.03930328f, -0.02747210f, 0.01837463f, -0.02145009f, -0.02749885f, -0.01568948f, 
    0.01970366f, 0.02366200f, 0.03058473f, 0.01780956f, 0.01959687f, 0.00653199f, 0.02107467f, -0.00966481f, 
    0.01729261f, -0.01472293f, 0.00573853f, -0.02125256f, 0.03011883f, 0.01931137f, -0.02031277f, 0.01177258f, 
    0.01425601f, -0.02622042f, -0.02662080f, 0.00260761f, 0.02400140f, -0.00509444f, 0.00351520f, -0.01299735f, 
    -0.01029411f, -0.02425749f, 0.02850619f, 0.00195235f, 0.00007570f, -0.00971707f, 0.00535688f, 0.02108234f, 
    -0.00294733f, -0.00516179f, 0.01990637f, 0.03125522f, 0.00797843f, -0.03613555f, -0.02485519f, 0.02580895f, 
    0.01152566f, 0.03105807f, -0.01317545f, -0.00040570f, 0.00547558f, -0.00939399f, 0.02072257f, -0.03798987f, 
    -0.00747777f, 0.01796428f, -0.01974245f, 0.00085017f, -0.01113524f, 0.01619797f, -0.00348283f, -0.00364331f, 
    0.01025871f, -0.03711959f, 0.00500790f, -0.00394175f, -0.03923492f, 0.03287563f, 0.01045207f, -0.01795191f, 
    -0.02501166f, -0.02101571f, -0.00698516f, -0.01193615f, -0.00319676f, -0.03318876f, -0.00815279f, 0.00955112f, 
    -0.01139179f, 0.03000043f, -0.02720970f, 0.02295464f, -0.00042872f, 0.01601833f, -0.00035662f, 0.01210374f, 
    -0.03626377f, -0.00391900f, -0.02533084f, -0.01964125f, 0.02480734f, -0.01651042f, -0.01312781f, 0.00430418f, 
    0.00997987f, 0.00762166f, -0.02371795f, -0.00285368f, -0.02397227f, 0.00486910f, -0.01782088f, 0.00717196f, 
    -0.00295178f, -0.01232400f, 0.03141068f, -0.01857771f, 0.00265677f, 0.02399765f, -0.03269212f, -0.03852426f, 
    -0.03895723f, -0.02035253f, -0.03407981f, 0.00201984f, -0.00294529f, -0.00041451f, 0.01841271f, -0.01720873f, 
    -0.02237640f, -0.03624654f, -0.02736732f, -0.01556294f, -0.03647550f, -0.01266076f, -0.00366891f, 0.00053212f, 
    -0.02806592f, -0.03938780f, -0.03934960f, -0.03027790f, -0.02895499f, 0.02044986f, 0.00094563f, -0.01103015f, 
    0.02762823f, 0.02425073f, -0.02095480f, -0.01812736f, -0.00612897f, 0.01042315f, -0.00377969f, -0.04130323f, 
    -0.02600621f, 0.02375908f, 0.01266532f, -0.03520365f, -0.00054611f, -0.01263127f, -0.00154038f, 0.02760771f, 
    0.00703235f, -0.01490261f, -0.02531277f, 0.01600908f, -0.03976838f, -0.01852741f, -0.01132071f, 0.02285348f, 
    -0.03559463f, -0.01726597f, -0.00714767f, -0.01443668f, 0.02501011f, 0.03002706f, 0.00043117f, -0.03731069f, 
    -0.01204285f, 0.01573454f, -0.00968238f, -0.03266351f, -0.02451526f, -0.02129137f, 0.01091289f, 0.01075175f, 
    0.01250859f, 0.01899572f, 0.00617856f, -0.02094947f, 0.00575320f, -0.03877189f, -0.01103006f, -0.00852645f, 
    -0.03072638f, -0.00692267f, -0.03383394f, 0.02465366f, -0.00108050f, -0.00463266f, -0.02157539f, -0.02926361f, 
    0.00271440f, -0.00715727f, 0.00977990f, -0.03263837f, -0.01299300f, 0.02272396f, -0.02155465f, 0.01493072f, 
    -0.04090501f, -0.02993410f, -0.01507560f, 0.00608859f, 0.01946936f, -0.03480246f, 0.00991133f, -0.01850353f, 
    0.00598007f, -0.03574951f, -0.01039294f, 0.02573048f, 0.03077114f, 0.01129019f, 0.00960460f, -0.03716158f, 
    -0.01209522f, -0.00130854f, 0.00624983f, 0.01815572f, 0.03072665f, 0.01827738f, 0.01687046f, 0.03035192f, 
    -0.03253231f, -0.01548017f, 0.01433653f, -0.03611174f, -0.03541779f, -0.03871727f, -0.03861198f, 0.00873812f, 
    -0.03355021f, -0.00506105f, -0.03392110f, -0.02220987f, 0.00277654f, -0.03459855f, -0.02663708f, -0.00491600f, 
    -0.03554869f, -0.02645531f, 0.03237228f, 0.02382088f, -0.02625797f, -0.03805234f, 0.02540368f, 0.00606035f, 
    -0.01722549f, 0.00686126f, -0.03596715f, 0.02605019f, -0.01239841f, -0.01375114f, -0.03165980f, -0.02432870f, 
    0.03043672f, 0.00460767f, 0.01647026f, -0.00606364f, -0.00783904f, -0.00166598f, -0.03868582f, 0.03039316f, 
    -0.03594328f, -0.03748715f, -0.01697362f, -0.01858341f, 0.00459199f, -0.00493987f, -0.00603643f, 0.01861899f, 
    -0.01185656f, -0.01168007f, -0.03944734f, 0.03056175f, 0.01506284f, -0.02899492f, 0.00162442f, 0.02636847f, 
    -0.01518313f, -0.02242156f, -0.02069890f, -0.03070420f, 0.01159548f, -0.01343829f, 0.02927167f, -0.02515136f, 
    -0.00386559f, 0.01085156f, -0.00974628f, -0.03328528f, -0.00798790f, -0.01254558f, -0.03901570f, 0.02366350f, 
    -0.01343651f, -0.01127266f, 0.01970041f, 0.00355172f, -0.04008605f, -0.01880435f, 0.00179376f, 0.01961886f, 
    0.00076206f, -0.00712573f, 0.02614843f, 0.00316163f, -0.03363930f, 0.00496416f, 0.02262037f, -0.01384994f, 
    0.01291356f, -0.02783062f, -0.01609069f, -0.03721600f, 0.02673329f, 0.00829678f, -0.01096214f, -0.01571229f, 
    -0.02444824f, 0.01962484f, 0.02023012f, -0.02948638f, -0.03188771f, 0.01405387f, -0.02816774f, -0.01496418f, 
    0.01048040f, 0.01537021f, 0.01989193f, -0.01568782f, -0.01960667f, -0.01339230f, 0.01375098f, 0.00579471f, 
    0.00690023f, -0.00245512f, 0.00389296f, -0.03586696f, 0.02485846f, -0.01628332f, -0.00861497f, -0.01063971f, 
    0.01726831f, -0.01575008f, 0.01301215f, -0.00912197f, 0.00974832f, -0.01433253f, 0.02964372f, -0.01671970f, 
    -0.00763158f, 0.01369543f, -0.03444793f, -0.00175669f, -0.00766209f, -0.00597544f, 0.00283081f, 0.02150516f, 
    -0.02761436f, -0.01433183f, -0.01951093f, 0.02214154f, -0.02030362f, -0.00507381f, -0.02148133f, -0.00285514f, 
    0.01190947f, -0.02430528f, 0.00551819f, 0.00949651f, 0.03027827f, 0.02074160f, -0.00950531f, 0.02734439f, 
    0.00434191f, 0.00741350f, -0.01186344f, 0.01209837f, 0.03083126f, -0.01836416f, 0.01545218f, -0.01538851f, 
    -0.01460795f, -0.02050382f, -0.03549549f, 0.00998810f, 0.01923389f, -0.01581717f, -0.00905232f, 0.00328390f, 
    0.01215733f, -0.03716812f, 0.00649546f, -0.03231983f, 0.01972560f, -0.03179244f, 0.01994642f, 0.00981747f, 
    0.02564941f, 0.01188034f, -0.00002899f, -0.02900411f, -0.02547444f, -0.02471900f, 0.01819099f, -0.02562251f, 
    0.02869542f, -0.01126475f, 0.01297613f, -0.00458241f, -0.02531815f, -0.01690607f, -0.02329324f, 0.02311004f, 
    0.02650711f, -0.03440472f, -0.00925093f, 0.00268549f, 0.02785865f, 0.01804335f, -0.03371295f, -0.01589624f, 
    0.00926269f, -0.03087258f, 0.01006859f, 0.02173905f, -0.02189499f, 0.02096532f, -0.01777706f, -0.03696996f, 
    0.02344951f, -0.01781069f, 0.02039973f, -0.02599082f, -0.02142642f, -0.00948509f, -0.03921384f, 0.00385055f, 
    -0.00912422f, 0.01250325f, -0.02751089f, -0.00371506f, -0.00854078f, -0.03089232f, 0.02148058f, -0.00464142f, 
    0.02895362f, 0.02127734f, 0.00762946f, -0.00973583f, 0.00845297f, -0.01243637f, 0.02146768f, -0.01488083f, 
    -0.03861747f, -0.02987154f, 0.01484315f, -0.01119357f, -0.01530336f, -0.00915119f, 0.02480717f, -0.03740983f, 
    -0.02458868f, -0.03009871f, 0.02886113f, 0.01429713f, -0.01196948f, -0.01194032f, -0.03181600f, 0.01751337f, 
    -0.02147865f, -0.02140353f, 0.01331049f, -0.01855476f, 0.00538434f, -0.01685131f, -0.00602582f, -0.00718161f, 
    0.02103445f, -0.03064041f, -0.01860061f, -0.04086324f, -0.00263414f, -0.01262303f, -0.01964756f, -0.01290404f, 
    0.02980766f, 0.01728694f, -0.00758977f, -0.03496432f, -0.02507083f, -0.01118123f, 0.01947726f, -0.01889340f, 
    0.00776206f, -0.01609769f, -0.01215374f, -0.03923415f, 0.00534227f, -0.00705207f, -0.00431996f, -0.03112777f, 
    0.01733834f, -0.01633746f, 0.01264295f, 0.01190614f, 0.00741276f, -0.02660913f, 0.01846123f, 0.01070890f, 
    0.00306176f, -0.00143566f, -0.04022463f, -0.00961249f, -0.00747344f, -0.01915300f, 0.00879656f, -0.03008101f, 
    -0.02564987f, 0.02261347f, 0.01411914f, 0.02663102f, 0.00039575f, -0.03645209f, 0.01736484f, 0.02285415f, 
    0.02956487f, -0.01195854f, 0.01636305f, -0.00563371f, 0.02756806f, 0.01574937f, 0.01122583f, -0.02313394f, 
    0.00554648f, -0.01082123f, -0.01085690f, 0.00807475f, -0.04111229f, -0.01699378f, -0.00753156f, -0.03224847f, 
    0.02819554f, -0.03579892f, -0.01952093f, 0.00572570f, -0.01242247f, -0.00768745f, 0.02789923f, -0.00314809f, 
    -0.03528128f, 0.01551774f, -0.03173507f, 0.01399149f, -0.02395406f, -0.02583730f, 0.02721733f, -0.03767965f, 
    0.02656480f, -0.03843602f, -0.01683060f, -0.00264177f, -0.02661764f, -0.03640739f, 0.01215204f, 0.01928189f, 
    0.03182964f, 0.01321772f, -0.01052710f, -0.02149093f, -0.00645187f, 0.01277037f, 0.00913240f, 0.00421508f, 
    -0.02858113f, 0.03438720f, -0.02049879f, -0.03506516f, -0.01209009f, -0.03159796f, 0.02798466f, 0.01855270f, 
    -0.03563339f, 0.00495032f, 0.02049471f, 0.00921992f, -0.01906244f, -0.01949338f, -0.00676428f, -0.01624706f, 
    0.00700308f, 0.01514089f, 0.02007391f, -0.03623638f, 0.02184078f, 0.00967762f, -0.03649718f, -0.01189909f, 
    0.00751818f, -0.00147564f, -0.03359617f, -0.00204958f, -0.02930431f, -0.01878315f, 0.00383378f, 0.02733084f, 
    0.02353097f, -0.02620100f, -0.03229824f, 0.02012423f, -0.02308903f, -0.02898629f, 0.02823888f, -0.02544930f, 
    -0.03036212f, -0.01056784f, 0.02881164f, -0.02101316f, 0.02330445f, -0.00545538f, 0.02257468f, 0.03303416f, 
    -0.01538987f, -0.03404216f, 0.00077211f, -0.01855557f, -0.01803284f, -0.00449357f, 0.00407681f, -0.02434109f, 
    -0.01201804f, 0.00132778f, -0.02340372f, -0.02981604f, -0.02172757f, 0.00055169f, -0.03821239f, 0.01830285f, 
    0.02344274f, -0.02739956f, -0.03910855f, 0.01242443f, -0.01341652f, -0.01915879f, -0.03505877f, -0.02308620f, 
    -0.04253843f, -0.01854704f, 0.00099211f, 0.02096160f, 0.02699273f, 0.01496965f, -0.03005174f, -0.02220743f, 
    -0.03187473f, -0.02196313f, 0.02652265f, -0.01924029f, 0.03120484f, 0.01021368f, -0.01015088f, -0.00722431f, 
    0.02651493f, 0.03106885f, 0.01415741f, -0.00893094f, -0.01841821f, -0.00178055f, -0.02071275f, -0.00963871f, 
    0.02062711f, -0.03819738f, 0.02007798f, -0.03314964f, 0.03667645f, -0.01343452f, -0.00342763f, 0.03295286f, 
    0.03612133f, -0.00169382f, -0.01774817f, -0.01966822f, 0.02721532f, 0.00801237f, -0.00987585f, -0.01831474f, 
    -0.00047900f, -0.01384767f, 0.00084359f, 0.01773007f, 0.00921345f, -0.01713338f, 0.01868680f, 0.02238902f, 
    0.01813448f, -0.01983120f, -0.03541862f, 0.01444578f, -0.00866299f, 0.02901640f, 0.03230697f, 0.01412698f, 
    -0.02460263f, 0.00251787f, -0.02599118f, -0.00586928f, 0.00148863f, 0.02066175f, 0.01220644f, 0.01535840f, 
    0.02890766f, -0.03072691f, 0.01196215f, -0.03226744f, 0.00243173f, -0.01497741f, 0.00676002f, -0.01006959f, 
    0.02206531f, 0.00356223f, 0.02858683f, -0.01805905f, -0.01298516f, 0.01049437f, 0.01680337f, 0.00401718f, 
    0.02424162f, 0.00982860f, 0.01870880f, -0.00704827f, -0.00320103f, -0.02521392f, 0.02443997f, -0.02239718f, 
    -0.03705590f, -0.00905664f, -0.00579075f, 0.00948728f, -0.01107493f, -0.01333799f, -0.01988998f, -0.00667264f, 
    -0.01643998f, 0.00007866f, 0.02455750f, 0.02359619f, 0.04213868f, -0.01844964f, 0.00285048f, 0.01657977f, 
    -0.02916129f, -0.02833812f, -0.02020285f, 0.00152463f, 0.02259419f, 0.02532286f, -0.03687091f, -0.02297726f, 
    -0.01688726f, 0.00717881f, -0.04072585f, -0.02273221f, -0.01948813f, 0.01273914f, -0.03842692f, -0.00069686f, 
    -0.01488966f, 0.02677521f, -0.04007765f, -0.01430264f, -0.02497772f, 0.01460640f, 0.01526464f, 0.00206670f, 
    -0.01686796f, -0.00545049f, -0.03096009f, -0.02503664f, -0.00925547f, -0.01743668f, 0.02776705f, -0.02757948f, 
    0.01183852f, -0.03002449f, 0.01791686f, -0.02389116f, -0.01719483f, 0.03578522f, 0.03835868f, -0.00817367f, 
    0.01482377f, 0.02347791f, -0.03037373f, -0.00752660f, 0.01571639f, -0.01574838f, -0.01335817f, -0.00272321f, 
    0.01245503f, 0.03108945f, 0.01689275f, 0.02046999f, 0.02034793f, 0.00188876f, -0.03528820f, -0.03300130f, 
    -0.03270115f, 0.03789729f, -0.02716924f, -0.01797450f, -0.01082764f, -0.01439473f, 0.02746057f, 0.01864002f, 
    0.00971851f, 0.02254087f, 0.01404200f, -0.01041008f, 0.04151572f, -0.00920788f, 0.01830483f, 0.02282285f, 
    -0.03385164f, -0.03462513f, 0.01824372f, 0.00261901f, -0.01109548f, -0.01092157f, -0.00227182f, -0.00353006f, 
    0.03002802f, -0.02141799f, -0.02371548f, 0.01542057f, -0.00643171f, 0.02855048f, 0.01807954f, -0.01555543f, 
    -0.00740841f, 0.00310575f, -0.03000053f, 0.01894506f, -0.01260518f, -0.01653146f, -0.02917166f, 0.00005563f, 
    -0.01938142f, -0.00088286f, 0.01692991f, -0.01082928f, -0.04206961f, 0.00593503f, -0.03918058f, -0.00022283f, 
    -0.02231129f, 0.02048445f, -0.02382611f, 0.01097191f, 0.01162217f, 0.01893853f, -0.01296509f, -0.03437678f, 
    0.01868926f, 0.00083053f, -0.03570694f, 0.00267900f, -0.02674816f, 0.01667392f, -0.01301538f, -0.03553004f, 
    0.00325619f, 0.02554089f, 0.02149383f, -0.00312252f, 0.00773521f, -0.03393632f, -0.00108932f, -0.01828088f, 
    0.03066526f, -0.03674919f, 0.01415193f, 0.00497276f, 0.02600847f, -0.00549380f, -0.02069728f, -0.04209089f, 
    -0.02731313f, -0.02144511f, 0.01587044f, 0.02584482f, -0.01265486f, -0.01835929f, -0.01326696f, 0.03233826f, 
    0.01752225f, -0.02725789f, -0.02069710f, -0.02026348f, -0.03654042f, -0.00658235f, -0.00287454f, -0.02133235f, 
    0.00754721f, 0.02138691f, 0.02035414f, 0.02754844f, 0.01964809f, 0.02457264f, 0.02946260f, 0.02420814f, 
    -0.01331946f, -0.00039065f, -0.03787933f, 0.00450881f, 0.02107378f, 0.01623343f, -0.02325369f, -0.02672907f, 
    0.03973002f, 0.03572966f, 0.01273497f, -0.00853165f, -0.02435481f, -0.01249049f, -0.01723858f, 0.02145398f, 
    -0.00615011f, 0.00966554f, 0.00027938f, 0.03587718f, 0.02680499f, 0.01088453f, -0.01298556f, -0.01518056f, 
    0.00468665f, 0.01278027f, -0.02239708f, -0.01564273f, -0.01887981f, 0.00569986f, 0.01529042f, 0.02728685f, 
    -0.02660484f, -0.00708183f, -0.00109488f, 0.00506421f, -0.00152973f, -0.03528182f, -0.03678609f, 0.02525632f, 
    0.02078097f, -0.02969411f, -0.01257548f, -0.03063986f, 0.01432829f, -0.02945759f, 0.01625715f, 0.00898926f, 
    -0.01179967f, 0.02862718f, -0.02798237f, 0.02296433f, 0.00357638f, 0.02020130f, -0.02898481f, -0.02202622f, 
    0.00997585f, -0.04561688f, 0.02185832f, -0.02120386f, 0.00007614f, -0.00015401f, 0.01647499f, 0.02037159f, 
    -0.01617072f, -0.01796280f, -0.00093285f, 0.01535630f, 0.01682478f, -0.00449152f, 0.02354955f, -0.02702111f, 
    -0.01061204f, -0.00489329f, 0.00155382f, 0.01852424f, 0.00377382f, 0.00643456f, 0.00428245f, 0.00046847f, 
    0.00782485f, -0.01906624f, -0.01165421f, -0.02139201f, -0.03677369f, -0.00938972f, 0.02459089f, -0.02263556f, 
    -0.01734021f, 0.00344263f, -0.02764851f, 0.01128253f, -0.01956345f, -0.01356509f, 0.00538859f, 0.03092591f, 
    -0.03280480f, 0.02693873f, 0.01062613f, 0.03102591f, -0.03562947f, -0.02451818f, 0.00308916f, 0.01122693f, 
    0.02697272f, 0.02844970f, -0.02692290f, -0.02990934f, -0.02748850f, -0.00819926f, -0.01997368f, 0.01798589f, 
    0.00336120f, -0.02751074f, -0.01637359f, 0.00053917f, -0.04215162f, 0.00061067f, -0.01464789f, 0.00025884f, 
    -0.03845416f, -0.02343878f, -0.02910934f, -0.01394147f, 0.02231344f, -0.01896213f, 0.00071469f, -0.02198348f, 
    -0.03419285f, 0.00660136f, 0.01522602f, 0.01155599f, -0.01684810f, 0.01219817f, 0.01429726f, -0.03883128f, 
    -0.00793086f, -0.00015057f, -0.01216751f, 0.01460404f, -0.00521996f, -0.01528550f, 0.00974850f, -0.04309317f, 
    -0.01283101f, 0.02218476f, -0.01987251f, 0.00942267f, 0.02049886f, 0.01199805f, -0.03292602f, -0.01315704f, 
    0.02416322f, -0.01699455f, 0.01568871f, 0.02858001f, -0.02980644f, -0.00325016f, -0.00275123f, -0.02705994f, 
    -0.01968544f, -0.01625567f, -0.01172474f, 0.00795947f, -0.01208271f, -0.02414232f, -0.00054512f, 0.00182467f, 
    -0.02728929f, -0.02700206f, 0.01233952f, -0.00755684f, 0.00204811f, -0.03484635f, 0.03260634f, -0.00819622f, 
    -0.01955758f, -0.01158634f, 0.00255842f, 0.00992647f, -0.03475874f, 0.00722272f, -0.01034883f, -0.01704209f, 
    0.02930946f, 0.02984910f, 0.00370402f, -0.00873838f, -0.01212659f, -0.03687309f, -0.02668180f, -0.01469065f, 
    0.01794622f, -0.02448707f, -0.02141961f, -0.00307621f, -0.00312616f, -0.01885369f, -0.02396157f, -0.00498172f, 
    0.00987603f, -0.03570601f, 0.02478052f, -0.03974091f, -0.00767493f, -0.02873584f, 0.01781755f, 0.01722659f, 
    0.00653365f, 0.02427556f, 0.00506315f, 0.01261779f, -0.04256966f, 0.00627005f, -0.04237865f, 0.00068832f, 
    0.00905869f, 0.02100284f, -0.00502202f, 0.02593913f, -0.01479058f, 0.02506761f, -0.00329953f, 0.00028589f, 
    -0.00630493f, 0.02487240f, -0.00153866f, -0.04219022f, -0.00603114f, 0.00481798f, -0.02371805f, -0.03788337f, 
    0.02321609f, 0.00389600f, -0.02965562f, -0.01865002f, 0.00174135f, 0.00131000f, -0.01280893f, 0.03176942f, 
    -0.00306468f, 0.00435987f, 0.02708139f, -0.03867135f, -0.01650938f, -0.03607807f, -0.00887734f, -0.00057242f, 
    -0.01764408f, 0.01330512f, 0.01305590f, 0.01274782f, -0.01978899f, -0.01273904f, 0.00789853f, -0.02974261f, 
    -0.01356539f, -0.01831000f, -0.01062565f, 0.01849094f, 0.00712576f, 0.00268874f, 0.01288933f, -0.03792473f, 
    -0.00959916f, -0.03862999f, 0.02798340f, 0.03219226f, 0.00455059f, -0.00564080f, -0.03734431f, -0.03739911f, 
    0.01733734f, -0.02323687f, -0.02490099f, -0.04018106f, 0.02974141f, -0.02819668f, -0.02412306f, -0.00827331f, 
    -0.01848751f, 0.02085117f, 0.02166414f, -0.01972129f, -0.03795199f, -0.03967209f, 0.01849969f, 0.00528822f, 
    0.01833873f, 0.03514795f, -0.02209641f, -0.03236908f, 0.01654137f, 0.01359605f, -0.01893017f, 0.02508092f, 
    0.02565233f, 0.03453581f, -0.02418969f, -0.04405235f, -0.00857476f, 0.03603030f, -0.01166853f, -0.01811166f, 
    0.00336063f, 0.01127020f, 0.03025573f, -0.01189506f, -0.03110556f, -0.01546012f, -0.03396168f, -0.03453439f, 
    -0.01870261f, -0.02938189f, -0.01627724f, -0.03583436f, 0.03071991f, -0.03082106f, -0.01789616f, -0.02971901f, 
    0.00460795f, -0.00801054f, -0.02697277f, 0.01978590f, 0.01820175f, 0.03068967f, -0.01007826f, 0.03315144f, 
    0.00465031f, 0.00987571f, -0.02501146f, -0.04344061f, 0.02337864f, -0.02127577f, -0.02875113f, -0.02020369f, 
    -0.00613287f, 0.00000478f, 0.00467969f, 0.01960729f, 0.00737291f, 0.01512146f, 0.00982654f, -0.00399131f, 
    0.03260928f, -0.00143575f, -0.00596290f, -0.02836492f, 0.00477229f, 0.00937644f, 0.01677573f, 0.03118517f, 
    -0.02837113f, 0.00765803f, 0.00978102f, 0.01969280f, 0.01915708f, -0.01770466f, 0.01627587f, -0.03941642f, 
    0.02687852f, 0.01389392f, 0.03285203f, 0.02201311f, 0.01015946f, 0.02181639f, 0.01516287f, 0.00137633f, 
    -0.01273163f, -0.03027183f, -0.02817193f, -0.02835908f, -0.00187590f, -0.03766815f, 0.02152520f, 0.01298771f, 
    0.02198419f, -0.03430347f, 0.02778008f, 0.02061537f, 0.02738953f, 0.00806057f, 0.03568779f, 0.02373730f, 
    -0.02337730f, 0.02508517f, 0.01831437f, -0.04326039f, 0.00568812f, 0.01086890f, -0.01754917f, -0.03437903f, 
    0.00057585f, -0.03327391f, 0.01361691f, -0.02680023f, 0.03224468f, -0.01378961f, -0.02672391f, -0.02790728f, 
    -0.02233443f, -0.02101986f, 0.02181621f, -0.00775574f, -0.00996006f, 0.01408556f, -0.00306831f, -0.01823777f, 
    -0.00012402f, -0.01405061f, -0.03293653f, -0.00662800f, -0.02330649f, -0.01873050f, -0.03223544f, 0.02556679f, 
    -0.01981966f, 0.02612444f, 0.00945878f, -0.03522443f, 0.00952161f, -0.01554328f, 0.01072213f, -0.03556620f, 
    -0.01452723f, 0.00046638f, 0.01551835f, 0.01158178f, 0.03253594f, -0.00349078f, -0.01700561f, 0.02049837f, 
    -0.02117485f, -0.01085754f, 0.00972233f, 0.02467256f, 0.00256149f, 0.01213874f, 0.00028559f, -0.00892267f, 
    -0.00116309f, -0.00281310f, -0.02723130f, -0.00558610f, 0.00179285f, -0.01010030f, 0.00798251f, 0.02382804f, 
    -0.01658119f, 0.00822403f, -0.04387910f, -0.01137955f, -0.00102806f, 0.02646929f, 0.00397694f, -0.00361596f, 
    0.00150335f, -0.01377300f, -0.00052586f, 0.02034022f, -0.01759866f, -0.00607015f, 0.03809608f, 0.01304659f, 
    0.04042926f, 0.01428443f, 0.02688423f, -0.00540793f, 0.00904920f, -0.02865094f, 0.02954361f, 0.03182054f, 
    0.25329295f, -0.11909828f, 0.01671887f, 0.00762171f, -0.07964050f, 0.04134440f, 0.09426143f, -0.02462212f, 
    0.14038405f, 0.01265944f, 0.01255516f, -0.00891927f, -0.27905753f, 0.06841160f, -0.01880524f, -0.11745042f, 
    -0.05772857f, 0.08439824f, -0.06171962f, 0.01594281f, 0.11656242f, 0.08280984f, 0.00073674f, 0.09783644f, 
    0.02292191f, -0.09604047f, -0.03799418f, 0.21321678f, -0.06332936f, 0.13441034f, 0.00786235f, 0.02567836f, 
    -0.03299983f, -0.06045321f, 0.02712764f, -0.04434326f, -0.00852773f, -0.13022383f, 0.06694704f, 0.03922758f, 
    -0.09945246f, 0.04341797f, 0.01128819f, 0.04881815f, 0.09704654f, -0.00996841f, 0.04077175f, -0.07001192f, 
    0.10451293f, 0.12360185f, 0.09165792f, 0.27448636f, 0.12503517f, 0.16473489f, 0.05340784f, 0.02654835f, 
    -0.06368320f, 0.03134288f, -0.04975410f, 0.01102970f, 0.08458705f, -0.01089624f, -0.21398166f, 0.04805131f, 
    0.01761828f, -0.02243966f, 0.04931688f, 0.08463217f, 0.08977440f, 0.04741723f, -0.09582985f, -0.05824094f, 
    0.18868408f, 0.00287185f, -0.07735496f, 0.04714004f, 0.08774393f, -0.10970934f, -0.06240113f, -0.07640215f, 
    -0.00435938f, -0.03653797f, 0.02800283f, 0.10535885f, 0.30992007f, -0.23602669f, 0.01255278f, -0.07292873f, 
    0.04273421f, -0.01142169f, 0.03978759f, 0.01715531f, -0.02593188f, -0.07359768f, 0.03376434f, -0.06567357f, 
    0.22160910f, -0.21426511f, -0.09511160f, 0.13828593f, -0.00404286f, 0.06979692f, 0.06390356f, 0.00488852f, 
    0.01982202f, 0.02158413f, -0.11388341f, 0.04744893f, -0.09025043f, 0.09815781f, 0.07459483f, -0.05647555f, 
    -0.07250580f, -0.05237056f, 0.03066270f, 0.04695672f, 0.00739329f, 0.08140429f, -0.00557460f, 0.13372324f, 
    0.00085254f, -0.22671874f, 0.27703083f, 0.04489443f, 0.12091289f, 0.06445844f, 0.02885787f, 0.02797494f, 
    0.04528109f, 0.03898727f, -0.13414685f, 0.07593687f, 0.08554778f, 0.00136179f, 0.08077261f, 0.02789027f, 
    0.07730784f, -0.06975482f, -0.00028383f, 0.02588916f, -0.02849535f, -0.00431941f, -0.07699622f, 0.05507018f, 
    0.05875216f, -0.16454040f, 0.17133734f, 0.17298895f, 0.00046581f, 0.05311956f, 0.02569114f, -0.02886456f, 
    -0.03734836f, -0.01236656f, -0.04350346f, 0.10846871f, 0.09951883f, -0.01160140f, -0.06080748f, 0.03433583f, 
    -0.07862932f, -0.14037384f, -0.03829412f, 0.12369792f, -0.01757138f, 0.00325097f, 0.06150644f, 0.03777305f, 
    0.03877198f, 0.11547391f, 0.14689116f, -0.12159939f, -0.04458522f, -0.09565298f, -0.06170600f, 0.05040672f, 
    0.21391883f, 0.09896059f, 0.00949095f, 0.05499239f, 0.01448200f, 0.01721123f, 0.01874079f, 0.05182306f, 
    0.03515922f, 0.03883407f, 0.07380483f, -0.04728281f, -0.02650770f, 0.18208541f, 0.06813415f, -0.16665584f, 
    0.09727529f, 0.18292718f, -0.07122145f, 0.00342402f, -0.14033805f, -0.02277765f, 0.02543729f, 0.04669736f, 
    -0.05730537f, 0.13879073f, 0.11914011f, 0.12169203f, 0.19415122f, -0.06554545f, 0.00101275f, -0.06696458f, 
    0.09470763f, 0.03845980f, 0.08635347f, 0.04420649f, 0.06361727f, -0.08748863f, -0.06284209f, 0.01106137f, 
    0.38388792f, -0.02575471f, -0.15732422f, 0.06565686f, 0.11304499f, -0.03715900f, -0.01303918f, 0.11115111f, 
    0.11118676f, 0.01777960f, -0.01161043f, 0.03193906f, 0.13610464f, 0.13073598f, 0.12699677f, 0.03704066f, 
    0.04844921f, 0.03064780f, -0.00666382f, -0.05024744f, 0.01674696f, 0.07967920f, 0.10617054f, 0.04019595f, 
    -0.01016819f, -0.04423821f, -0.05545357f, 0.21876021f, -0.06979414f, 0.04869724f, 0.09362101f, 0.08986670f, 
    0.15317561f, -0.03340663f, -0.02216830f, 0.04507079f, -0.15522076f, 0.05847022f, 0.09188553f, -0.00279931f, 
    0.07842607f, -0.01328850f, -0.02196138f, 0.01375082f, -0.02818536f, 0.03331840f, -0.02483194f, 0.07883288f, 
    0.00109233f, 0.03462589f, -0.02036951f, 0.02251948f, -0.02749034f, 0.03397166f, 0.07965431f, 0.02111583f, 
    0.01821573f, -0.03431704f, 0.05941498f, -0.01699723f, -0.24796632f, 0.27889112f, -0.23377803f, -0.00718040f, 
    0.10444347f, 0.13950761f, 0.01427412f, 0.05885452f, -0.05852560f, -0.17629451f, 0.09495075f, 0.01111558f, 
    -0.01178028f, 0.18966639f, -0.11607660f, 0.05682189f, 0.02824971f, 0.01859806f, -0.07144003f, 0.04263426f, 
    0.00635360f, 0.03411370f, 0.00239594f, 0.07612833f, 0.03980653f, -0.09087349f, -0.12226087f, -0.16517864f, 
    -0.10285097f, -0.06182454f, -0.02100076f, -0.00254175f, 0.06124575f, 0.00610721f, -0.07268213f, -0.01581284f, 
    -0.22487438f, -0.03608299f, -0.03718117f, 0.01238624f, -0.13382320f, -0.08273888f, -0.03408290f, 0.08450867f, 
    0.00925850f, 0.00780780f, -0.03949939f, 0.00810179f, 0.41201726f, -0.13672064f, -0.03882788f, -0.00407565f, 
    -0.05776819f, 0.01604669f, 0.05066277f, 0.05670540f, -0.01040945f, -0.13742769f, 0.05527959f, -0.01377128f, 
    0.07289267f, -0.17367288f, 0.11247908f, 0.10606006f, 0.00444543f, -0.01439283f, 0.06182200f, 0.02367022f, 
    -0.04817711f, 0.05051054f, 0.22333013f, -0.14133202f, -0.02716484f, -0.11391141f, 0.02312031f, 0.20251678f, 
    -0.02090777f, -0.07031626f, -0.01462885f, 0.01085784f, -0.04103104f, -0.03784899f, 0.05047606f, -0.04574288f, 
    -0.15908191f, 0.00109302f, 0.00861090f, -0.03023789f, -0.03297799f, 0.15880886f, 0.00194572f, 0.07744114f, 
    0.05496161f, 0.00012972f, 0.10292705f, -0.01218190f, -0.17560861f, -0.08587095f, -0.13617173f, 0.11670382f, 
    -0.07666670f, 0.05645157f, 0.06133601f, 0.01832194f, 0.11925842f, 0.00844721f, -0.02232743f, 0.06311209f, 
    -0.04268081f, -0.10109767f, -0.10295632f, 0.04215779f, 0.01110723f, 0.05655374f, -0.08408216f, 0.07114597f, 
    -0.00389028f, 0.00805351f, 0.08591300f, -0.08080003f, -0.10473248f, -0.00214847f, -0.21642950f, -0.00313668f, 
    -0.07279172f, -0.04498119f, 0.05001404f, -0.02300992f, -0.10981533f, -0.03672484f, 0.07478952f, -0.00471409f, 
    0.34866324f, -0.25884488f, -0.06461906f, -0.12481765f, 0.08326813f, 0.05978438f, 0.01031853f, -0.08167316f, 
    0.02147466f, -0.00891230f, -0.00313630f, 0.12454563f, -0.08899170f, 0.10729651f, -0.05277656f, -0.03250202f, 
    0.02204617f, 0.13711138f, -0.01449954f, 0.09620088f, 0.16523990f, -0.20367780f, -0.09978783f, 0.07464436f, 
    -0.01616426f, -0.01649724f, -0.03761508f, 0.06419452f, 0.04317973f, 0.08368894f, 0.05818561f, 0.03687056f, 
    0.08026664f, 0.03120975f, -0.01987438f, 0.08659725f, 0.07650425f, -0.22715540f, 0.03752880f, -0.07115903f, 
    -0.03217276f, 0.01835064f, -0.07064614f, -0.01619264f, 0.11545983f, -0.06192745f, -0.06807243f, 0.13769902f, 
    0.18731639f, -0.29355788f, -0.06955137f, 0.05806193f, 0.04658184f, 0.13474844f, 0.04148659f, 0.11393988f, 
    0.04479891f, 0.07251380f, 0.02419609f, -0.11358283f, 0.08648700f, -0.32134709f, -0.09848166f, 0.09149469f, 
    -0.00282561f, -0.06944902f, 0.00466894f, -0.05080526f, -0.03275386f, -0.03898948f, -0.04014802f, -0.01102583f, 
    -0.00201086f, 0.02952135f, -0.16506428f, -0.07133290f, 0.03997400f, -0.05423039f, -0.02415407f, -0.01455304f, 
    -0.02670361f, -0.01132890f, 0.06485498f, 0.00438883f, 0.27680263f, 0.05836162f, 0.01868349f, 0.06452385f, 
    -0.02532291f, 0.06373665f, 0.04733774f, 0.18914871f, -0.02307686f, 0.04205734f, -0.05680230f, 0.04245852f, 
    0.06558388f, 0.07060833f, -0.08336696f, 0.01471094f, -0.02088997f, -0.04133139f, 0.09207324f, -0.00498676f, 
    -0.02241073f, -0.09154452f, -0.04688016f, -0.06558083f, 0.20646827f, -0.16752391f, 0.00902598f, 0.15861721f, 
    0.00384003f, 0.24124938f, 0.04387528f, 0.07000630f, -0.01537671f, 0.08799881f, 0.04411244f, -0.05181260f, 
    -0.36684659f, 0.22100091f, 0.10790403f, -0.12849033f, 0.02291819f, 0.05309940f, 0.06391472f, -0.01162631f, 
    -0.02319464f, -0.10837918f, -0.02893301f, 0.06112627f, 0.03760890f, 0.12231709f, -0.02468898f, 0.04212273f, 
    0.06874985f, -0.00520519f, -0.03879431f, 0.10624976f, -0.02425725f, -0.01725527f, -0.04303101f, 0.09507585f, 
    -0.41615006f, -0.02765034f, -0.08089555f, -0.08306687f, -0.00322204f, -0.05692034f, 0.03156359f, 0.02598888f, 
    0.03943323f, 0.02621344f, 0.05656854f, -0.13432293f, -0.00935926f, 0.12689547f, -0.00310297f, -0.00197867f, 
    0.05236606f, 0.06649936f, 0.00084040f, 0.04337357f, 0.02358575f, -0.00926696f, -0.14266016f, 0.04752855f, 
    0.07914511f, 0.06243914f, 0.12650636f, 0.05721842f, -0.13479021f, -0.12035054f, -0.00029884f, 0.11892671f, 
    0.02629853f, 0.03887137f, -0.10568997f, 0.01251517f, 0.14327015f, -0.29936472f, 0.00095750f, -0.01371054f, 
    0.06332451f, -0.06848410f, 0.01408360f, 0.06590810f, -0.01273771f, -0.01493828f, 0.00757795f, 0.00468130f, 
    0.10110478f, -0.06572965f, 0.03955786f, 0.11177938f, 0.01671194f, 0.00934440f, 0.08048893f, 0.05731589f, 
    0.03619923f, 0.09274289f, -0.06210341f, 0.04776498f, 0.02915457f, 0.18809122f, 0.19340971f, 0.14391927f, 
    -0.01581202f, 0.03108790f, 0.00880192f, 0.10143686f, -0.07355693f, -0.04187613f, -0.20600955f, -0.02277912f, 
    -0.03139131f, 0.06739218f, 0.16194595f, 0.07258120f, 0.03331038f, 0.15962957f, 0.00483862f, 0.01123760f, 
    0.07840750f, -0.06877091f, -0.04256020f, 0.07462752f, 0.34495780f, -0.12743321f, -0.10932107f, 0.03752111f, 
    0.04612075f, 0.01985373f, 0.06005448f, -0.01877399f, -0.03317299f, -0.05351724f, 0.05397255f, 0.01864133f, 
    -0.32420108f, -0.03494786f, 0.04678207f, -0.12944779f, -0.01557155f, 0.03451684f, -0.12023816f, -0.00863434f, 
    0.05325780f, 0.02320525f, -0.02134093f, 0.15973808f, -0.57106405f, 0.21120301f, -0.07208147f, -0.23350891f, 
    0.02221490f, 0.05147048f, -0.04412438f, 0.06029871f, -0.06262606f, 0.06061472f, 0.04469563f, 0.02956651f, 
    0.14342211f, -0.05267459f, 0.09403555f, 0.13736238f, 0.00518536f, 0.08778390f, 0.12536536f, 0.07701278f, 
    -0.02014815f, 0.01874887f, 0.01197087f, -0.03771642f, 0.10778889f, -0.18767263f, 0.04476889f, -0.00920140f, 
    -0.07044455f, -0.06625520f, -0.03184469f, -0.05604877f, 0.03948196f, -0.12611347f, 0.08557325f, 0.10330130f, 
    -0.15519288f, 0.02290984f, -0.03850178f, -0.07159199f, -0.04270978f, -0.09309263f, 0.01146003f, -0.08595327f, 
    -0.04374997f, -0.13142188f, 0.01533519f, 0.05447790f, 0.39638186f, -0.09307158f, -0.00431647f, 0.00335775f, 
    0.04882662f, 0.04125677f, 0.05693892f, 0.01906955f, -0.07212853f, 0.07178890f, -0.01243987f, -0.01435857f, 
    -0.09249216f, -0.00083791f, 0.09583385f, -0.14088668f, 0.08641063f, 0.08065212f, -0.07203861f, 0.04406388f, 
    0.00609895f, -0.04819244f, -0.08513845f, -0.09133713f, -0.13280351f, -0.24332288f, 0.02693203f, -0.03873520f, 
    0.04816718f, 0.02039961f, 0.11162373f, -0.12108479f, 0.10954323f, 0.11160404f, -0.09470251f, -0.00187039f, 
    -0.13722177f, 0.07873222f, 0.05891510f, -0.06262390f, -0.04901348f, 0.06652422f, -0.08101997f, -0.04777377f, 
    -0.06932367f, 0.02957033f, 0.01151774f, -0.00381204f, -0.02823475f, -0.25502655f, 0.06074072f, 0.00888565f, 
    -0.06836819f, -0.10304490f, 0.05019460f, 0.01678885f, 0.02280820f, -0.05742079f, 0.09077109f, 0.06603165f, 
    0.02061155f, 0.02980419f, 0.01573431f, -0.00475970f, 0.00522462f, -0.03748588f, 0.00737922f, 0.01458185f, 
    -0.01683647f, 0.00593284f, 0.02836441f, -0.02706013f, 0.01152581f, -0.03370947f, -0.00925865f, -0.04170201f, 
    -0.02937663f, -0.02672834f, -0.03530649f, 0.01736468f, -0.00966802f, -0.00395420f, 0.00402932f, 0.01297631f, 
    -0.01370397f, -0.03633660f, -0.00526385f, -0.00557989f, 0.01518102f, -0.00721322f, -0.02279949f, -0.03853469f, 
    0.01160667f, -0.03062176f, -0.02072796f, 0.00058724f, 0.01144685f, -0.04151361f, 0.00206835f, -0.01070775f, 
    -0.02970348f, -0.00205789f, -0.00367628f, -0.04087435f, 0.02940532f, -0.03978665f, 0.00877050f, 0.01880697f, 
    0.00128435f, 0.02175070f, -0.02649332f, -0.03642312f, 0.01926859f, -0.01739999f, 0.02251237f, 0.00432601f, 
    -0.01203812f, -0.02361253f, 0.02952121f, 0.00337346f, -0.03312058f, 0.01607593f, 0.00075601f, 0.02381989f, 
    -0.04124244f, 0.02939431f, -0.02645366f, -0.03724780f, -0.00430655f, 0.01178571f, -0.03058069f, -0.01498512f, 
    0.00097638f, -0.04001440f, -0.03304195f, -0.01343380f, -0.02951762f, -0.00456769f, 0.00805846f, -0.03602108f, 
    0.02661276f, -0.02079344f, -0.03910334f, 0.01732697f, -0.00010486f, -0.01742416f, -0.03768892f, -0.03997277f, 
    0.02476646f, 0.01801825f, -0.04184325f, -0.02664684f, 0.02920041f, -0.03720687f, -0.02321964f, 0.00613450f, 
    0.01035216f, 0.01144117f, -0.02859951f, -0.02787612f, -0.01443508f, 0.02225050f, 0.00518753f, 0.01414149f, 
    -0.02247806f, -0.04187471f, -0.03278796f, 0.00029338f, 0.00191237f, -0.00983210f, 0.01521990f, -0.01280473f, 
    -0.03533325f, -0.00408921f, 0.01566142f, 0.01050407f, -0.00633516f, 0.00483444f, -0.00332889f, -0.04164390f, 
    0.01062950f, -0.01280577f, -0.01339844f, 0.01246381f, 0.01336905f, -0.00405082f, -0.00297176f, -0.01527056f, 
    -0.00269009f, -0.03550572f, -0.02858711f, -0.00082509f, -0.03652012f, 0.01937567f, -0.04113636f, 0.00713405f, 
    0.00390085f, -0.01395758f, 0.01918856f, -0.04033384f, 0.02000346f, -0.03299091f, -0.02623773f, 0.02651671f, 
    0.01372844f, 0.02286410f, -0.01562384f, -0.00406148f, -0.01447412f, -0.03476163f, 0.01179502f, -0.00686398f, 
    0.00961700f, 0.00147388f, 0.00458593f, 0.01543677f, -0.03674709f, 0.00254246f, 0.01191041f, 0.00544555f, 
    0.02695794f, -0.03816906f, 0.00872525f, 0.00818843f, -0.01912835f, 0.02168456f, -0.02813823f, 0.01087717f, 
    -0.00931547f, 0.02699273f, -0.03358789f, -0.01992345f, 0.00203366f, -0.00869294f, 0.02767084f, 0.02466066f, 
    -0.02381725f, -0.01271187f, -0.00736090f, -0.04133205f, -0.02718589f, -0.02350587f, 0.01561341f, -0.01367008f, 
    -0.00602542f, 0.02210956f, -0.00982836f, 0.01573557f, -0.02635658f, 0.01483265f, -0.02743662f, -0.02733907f, 
    0.02271223f, -0.02678760f, 0.01639026f, -0.00082475f, -0.02852502f, -0.00071014f, -0.03364022f, -0.03621896f, 
    -0.04022565f, 0.01822133f, 0.02575379f, -0.01636908f, 0.01427854f, -0.01118729f, -0.03099442f, 0.00042259f, 
    -0.01349142f, 0.01852299f, 0.01501148f, -0.03175038f, -0.02873076f, -0.03326290f, 0.00080571f, -0.00775188f, 
    0.00405221f, 0.01801208f, -0.00798345f, 0.01726125f, 0.01384285f, 0.02804761f, -0.03885133f, -0.01882087f, 
    -0.01887425f, -0.00836624f, 0.02294938f, 0.00535442f, -0.00772817f, -0.00073735f, 0.01944478f, -0.04172692f, 
    -0.00251602f, -0.02308496f, -0.03459213f, 0.02009675f, -0.00507875f, 0.02898691f, -0.01834195f, -0.02776830f, 
    0.00051069f, -0.00420799f, -0.02547650f, -0.01304761f, 0.01367198f, -0.01601911f, -0.02351329f, -0.03256004f, 
    -0.03037930f, 0.00707183f, -0.02942002f, -0.00973262f, 0.02486604f, -0.03724646f, -0.01060168f, -0.02009949f, 
    -0.01158663f, -0.04061149f, 0.00417067f, 0.02654069f, -0.03857009f, 0.01856005f, 0.00243297f, -0.03413359f, 
    -0.02213036f, -0.02533313f, -0.02610373f, -0.00358663f, -0.01972850f, 0.01490897f, 0.00297226f, 0.00090108f, 
    -0.01633828f, -0.02500086f, 0.00714575f, 0.01571365f, 0.01655231f, 0.00253191f, 0.02651510f, 0.00669934f, 
    -0.01282788f, -0.02248538f, -0.04047569f, -0.01315425f, 0.01908647f, 0.02857559f, -0.02239035f, -0.03207447f, 
    -0.00729983f, -0.02389275f, -0.02798168f, -0.01310004f, -0.00060908f, 0.02656128f, -0.01178048f, -0.04031886f, 
    -0.02973736f, -0.01734644f, -0.03340422f, 0.01312789f, -0.04155191f, -0.03679157f, -0.02102917f, -0.03815476f, 
    0.02945388f, -0.03324040f, -0.03226396f, -0.01304260f, 0.02349726f, -0.01089898f, 0.02821892f, 0.00171642f, 
    0.00450920f, -0.04076643f, 0.00301380f, 0.02471999f, -0.00525341f, 0.00432471f, -0.03266742f, 0.00287975f, 
    -0.00815538f, -0.01248148f, -0.02822156f, 0.02435688f, 0.01224424f, -0.03280017f, 0.00551515f, -0.01360643f, 
    -0.03277903f, -0.00106176f, 0.00816511f, -0.02311893f, -0.02608855f, -0.03164283f, -0.01414424f, 0.01222923f, 
    -0.01344559f, 0.02771514f, 0.01521360f, 0.00135420f, 0.01902076f, -0.03722056f, 0.02048256f, -0.04182089f, 
    -0.00103769f, -0.00453038f, 0.01144463f, -0.01527668f, -0.02147286f, 0.00743166f, -0.02676331f, -0.01828758f, 
    0.01883091f, -0.02319360f, 0.00837277f, -0.01174995f, -0.02166173f, -0.03984891f, 0.00452001f, -0.02094737f, 
    -0.02370692f, 0.02771492f, -0.01264816f, -0.03552883f, 0.02316192f, 0.02250075f, 0.00585582f, 0.01820403f, 
    0.00652091f, 0.01194338f, 0.00399240f, 0.02408265f, -0.03909699f, 0.01759140f, -0.02847197f, -0.02135949f, 
    -0.03377835f, 0.00466219f, -0.03737845f, 0.01102879f, 0.00778395f, -0.00710837f, 0.00021005f, -0.02338056f, 
    -0.01025933f, 0.02546153f, -0.03826007f, 0.02851869f, -0.00243879f, -0.02192434f, 0.00185326f, -0.01069443f, 
    -0.02748983f, 0.01685439f, 0.02978524f, -0.03647080f, -0.04095469f, -0.00139004f, -0.03254846f, -0.02171180f, 
    0.02120933f, -0.02044352f, -0.03286650f, -0.00804630f, 0.01483940f, 0.01088117f, 0.00874347f, -0.00632337f, 
    0.00599192f, 0.00230643f, -0.00562402f, 0.00685666f, -0.00810836f, -0.03873066f, 0.02877769f, -0.00692917f, 
    0.02715734f, 0.02418630f, 0.00956790f, -0.02520228f, 0.00055981f, -0.03158023f, 0.00872949f, 0.01832179f, 
    0.01109949f, -0.03663423f, -0.00795857f, 0.01726417f, -0.04187416f, 0.00998394f, -0.00236125f, 0.00465516f, 
    -0.00339545f, -0.02007681f, -0.01030642f, 0.01716990f, 0.02875688f, -0.00990710f, 0.02835856f, 0.00457613f, 
    -0.02840540f, -0.03850031f, 0.01297265f, 0.01880527f, 0.01208069f, 0.02551264f, -0.00711092f, -0.02155022f, 
    -0.01213370f, -0.00080340f, -0.00549903f, -0.01665176f, -0.02320852f, 0.01421554f, -0.02516325f, -0.01454556f, 
    -0.00317830f, -0.00429953f, 0.01569584f, -0.01405589f, -0.00280959f, -0.03938380f, -0.03247591f, 0.00389101f, 
    -0.01050171f, 0.00887362f, 0.00906357f, 0.00318807f, -0.02403730f, -0.04129922f, 0.01641727f, -0.00257309f, 
    -0.00433370f, 0.00286746f, -0.01394132f, -0.02605210f, -0.00989154f, 0.00000303f, -0.00956202f, -0.02558524f, 
    0.02475088f, -0.01474119f, 0.02513557f, -0.03087323f, 0.01646052f, 0.00813053f, -0.03543236f, -0.03551951f, 
    0.02229907f, 0.01463126f, -0.02955166f, -0.02913780f, -0.02134120f, 0.01123062f, 0.00497395f, -0.02931983f, 
    0.02680182f, -0.02293160f, -0.01724881f, -0.02003383f, -0.00523887f, 0.02383772f, -0.00309811f, 0.01854106f, 
    0.02619483f, 0.02003789f, -0.03232054f, -0.04055257f, -0.03287792f, -0.02577721f, -0.00863754f, -0.01617980f, 
    0.02592083f, 0.01672373f, -0.03674660f, 0.00835734f, -0.03508684f, -0.00780171f, 0.02057794f, -0.02733602f, 
    -0.00106430f, 0.00704498f, -0.04055692f, -0.02037088f, 0.01050872f, 0.02320393f, -0.02738064f, -0.02016972f, 
    -0.02155121f, -0.03081021f, -0.03760323f, -0.03155003f, -0.03221982f, -0.03518315f, 0.00725253f, 0.01644024f, 
    0.00779726f, -0.02273102f, 0.02485316f, 0.00777528f, 0.00252246f, 0.00410173f, -0.02623565f, -0.00612332f, 
    -0.03512000f, 0.01314918f, -0.03434433f, 0.01695379f, -0.04033469f, -0.02355467f, 0.01452116f, 0.02246838f, 
    -0.02553233f, -0.02081974f, -0.02209060f, 0.02959226f, -0.02198005f, -0.00524579f, -0.03397071f, -0.02403743f, 
    0.01934135f, 0.02724538f, 0.00498165f, -0.01717870f, 0.00452763f, -0.01567253f, 0.00695225f, 0.02363336f, 
    -0.04038670f, 0.00689572f, -0.02290264f, 0.00683340f, -0.01805528f, -0.04107331f, 0.00096338f, 0.00876041f, 
    -0.01668522f, -0.00251966f, 0.02494955f, -0.04020542f, 0.00236352f, -0.02945063f, -0.01091781f, -0.00136880f, 
    0.01584490f, 0.01039872f, -0.02513037f, 0.02162854f, 0.01246310f, -0.01016244f, -0.03049391f, 0.02193922f, 
    0.01093868f, -0.02403845f, -0.00425613f, -0.01852399f, -0.02903016f, -0.00896103f, -0.02039977f, 0.01119542f, 
    0.02165713f, -0.02597014f, -0.00694934f, -0.02575435f, -0.01970562f, -0.01321566f, -0.03955938f, -0.00496397f, 
    -0.00348205f, -0.03593775f, -0.01369226f, 0.00123546f, -0.03874306f, 0.01726556f, -0.02977045f, 0.00019991f, 
    0.02860021f, 0.01692608f, 0.02207991f, -0.02634242f, 0.02568141f, 0.02800595f, 0.01688086f, 0.00269748f, 
    -0.02309867f, 0.00407134f, -0.01174910f, -0.04153961f, 0.01707950f, -0.03655688f, -0.03276370f, -0.04078375f, 
    0.01452797f, 0.02593862f, 0.02378913f, -0.03793117f, -0.03531675f, -0.02256615f, -0.01012558f, 0.01809088f, 
    -0.02590436f, 0.01827797f, -0.02999448f, 0.02502499f, -0.00663855f, -0.04088599f, -0.02475221f, -0.00867907f, 
    -0.00961566f, 0.00898274f, -0.02359480f, 0.00333798f, 0.00581427f, -0.01201426f, 0.01075751f, -0.02461017f, 
    0.02507797f, 0.01905031f, -0.04128662f, -0.02033475f, 0.02925784f, -0.03541297f, -0.01107938f, -0.00324732f, 
    -0.02916811f, 0.02492938f, -0.03827006f, -0.02391315f, -0.02658586f, -0.01926437f, 0.02722745f, 0.00803910f, 
    -0.00725757f, -0.00575784f, 0.01837604f, 0.00502838f, -0.03656948f, -0.01041026f, -0.02584435f, 0.00809462f, 
    0.00050025f, 0.01553664f, -0.03199567f, 0.02646174f, -0.02543173f, 0.02084325f, -0.00512115f, -0.01903618f, 
    -0.01190162f, -0.02914432f, -0.01060297f, -0.04167308f, -0.00788659f, -0.04043612f, -0.00947359f, -0.01321326f, 
    -0.03955783f, -0.01530868f, 0.02445162f, -0.00028019f, 0.00912151f, -0.03066785f, 0.01074860f, 0.02149370f, 
    -0.01716574f, 0.00206993f, -0.01450386f, -0.02605004f, -0.00669521f, -0.01009833f, 0.01836210f, 0.02408216f, 
    0.01657355f, -0.03669781f, -0.03746063f, -0.04098219f, -0.01091932f, -0.01572475f, 0.01988827f, -0.01243096f, 
    -0.01628009f, -0.02688251f, -0.00521235f, -0.03638439f, -0.03037334f, 0.00450955f, 0.01019306f, 0.00692734f, 
    0.01396578f, 0.02641073f, 0.01786284f, 0.02640964f, -0.02254928f, -0.02228230f, 0.02561507f, 0.02825898f, 
    -0.02279095f, 0.02840887f, -0.02303948f, 0.00665856f, -0.01807531f, -0.02597407f, -0.03711478f, 0.01245512f, 
    0.01332903f, -0.02117056f, -0.03342393f, 0.00537233f, 0.01765213f, -0.01187964f, -0.01840875f, -0.02206459f, 
    -0.02483596f, 0.00188938f, 0.02344563f, -0.04115184f, 0.02100414f, -0.03629997f, 0.00143714f, -0.00311170f, 
    -0.01718712f, -0.01289430f, -0.02994204f, 0.01988689f, 0.00894432f, -0.01800084f, 0.02766152f, 0.00128915f, 
    -0.00004629f, 0.02743115f, -0.03885781f, 0.01004809f, -0.02293912f, 0.00476106f, 0.00021433f, 0.01250108f, 
    0.00576493f, -0.03122095f, 0.01375098f, 0.03233396f, 0.02976822f, 0.02499483f, -0.01153020f, -0.03139764f, 
    0.00580023f, -0.03310688f, -0.01195172f, 0.01218598f, 0.00208403f, -0.00948970f, -0.00753886f, 0.01778583f, 
    -0.03853804f, -0.04399104f, 0.02920184f, 0.01645194f, -0.02843985f, -0.01200795f, 0.02834442f, 0.00792871f, 
    0.02298858f, -0.00871012f, 0.01317611f, -0.01975585f, -0.02504940f, -0.02427493f, -0.00860616f, 0.03099816f, 
    0.00388188f, 0.02628775f, 0.00708812f, -0.02158424f, -0.01604125f, -0.01061640f, -0.02072337f, -0.00146431f, 
    0.02573716f, 0.01044533f, 0.00245151f, 0.01179774f, -0.01572761f, -0.00122365f, -0.02401799f, 0.03540099f, 
    -0.00361244f, -0.00246208f, 0.03663106f, 0.01536825f, 0.02390346f, 0.00007923f, -0.01042913f, 0.01075807f, 
    -0.01223934f, 0.00675460f, -0.01882446f, 0.00640894f, -0.00125908f, -0.00190380f, 0.01532905f, 0.01914787f, 
    0.01847024f, 0.01322264f, -0.02143096f, -0.03734119f, -0.00424922f, 0.01650496f, 0.01490456f, 0.02504957f, 
    0.01053460f, 0.02498883f, 0.02376300f, 0.02950368f, -0.00971888f, -0.03973616f, -0.01849753f, 0.00681666f, 
    -0.01508718f, 0.02318391f, 0.02775523f, -0.01526934f, 0.02484205f, 0.01009773f, -0.00368019f, 0.00300589f, 
    -0.02213530f, 0.01549898f, -0.00077220f, -0.02398395f, -0.00509588f, -0.00002112f, 0.01556887f, -0.02377825f, 
    -0.00163927f, 0.02464511f, -0.02190149f, 0.02195283f, -0.02832049f, -0.01349635f, 0.02373208f, 0.02685887f, 
    0.03170573f, 0.02069877f, -0.00989670f, 0.00004050f, -0.01785122f, -0.03113288f, 0.00357146f, -0.00689201f, 
    0.02797860f, -0.00941807f, -0.01093421f, -0.02791020f, 0.02002146f, 0.01718432f, 0.02651583f, -0.02731097f, 
    0.03567054f, 0.02731592f, -0.02970449f, 0.01142122f, 0.02617765f, -0.03131883f, -0.03840983f, -0.02351736f, 
    0.03691833f, 0.03821203f, 0.01469143f, -0.01626001f, -0.01835786f, -0.02473579f, 0.03051436f, 0.01207866f, 
    -0.01642376f, -0.00987116f, -0.02670208f, -0.00165921f, 0.02421607f, -0.02269586f, -0.03278299f, 0.02501860f, 
    -0.04036424f, 0.02991790f, -0.00559920f, 0.01009831f, 0.00256525f, 0.01382688f, -0.02674350f, -0.01921110f, 
    -0.01399640f, -0.03705787f, -0.01944729f, -0.03831701f, 0.02157860f, -0.02797452f, -0.00427684f, -0.02065545f, 
    -0.03217709f, -0.01367707f, -0.04487666f, -0.03255442f, 0.02649027f, -0.02772897f, -0.01929635f, 0.02795709f, 
    0.00682472f, -0.01227011f, 0.02208321f, 0.01046711f, 0.02446050f, 0.00045637f, -0.02976642f, 0.02107126f, 
    0.00702196f, -0.00124977f, -0.01511960f, 0.00243822f, -0.01874727f, 0.03088233f, -0.00636558f, -0.03655418f, 
    0.01319979f, -0.02392901f, 0.01259844f, 0.02241301f, 0.00383164f, -0.02591427f, -0.01150383f, 0.02568027f, 
    0.01830640f, -0.02173641f, 0.01821243f, -0.02442928f, 0.01170563f, -0.03231177f, 0.01173014f, -0.00704826f, 
    0.02622959f, 0.00591207f, 0.00469249f, -0.00073142f, -0.00872316f, 0.01069569f, 0.01671342f, -0.03081609f, 
    0.00187253f, -0.02459299f, -0.02546324f, 0.01248290f, 0.01852273f, 0.00096952f, -0.00194693f, -0.02467196f, 
    -0.02387196f, -0.00738761f, -0.00131336f, -0.02145062f, -0.00360116f, -0.02340343f, -0.00209812f, -0.01857818f, 
    -0.00811710f, -0.01467835f, -0.01256303f, -0.00833307f, 0.00692798f, 0.01622593f, -0.03318709f, 0.00470288f, 
    0.00597684f, 0.01308379f, -0.01804423f, -0.02041434f, -0.02427209f, -0.02595017f, -0.01872111f, -0.00418574f, 
    0.00628601f, -0.00812822f, -0.03548662f, 0.04152612f, -0.00795611f, -0.00161815f, -0.00403260f, 0.01195993f, 
    0.02215202f, 0.00734235f, -0.02932621f, 0.00459686f, 0.01466348f, -0.00220128f, -0.02659562f, 0.02532322f, 
    -0.01295556f, -0.01876521f, 0.01074262f, -0.02540582f, -0.00605560f, 0.03012789f, -0.02237977f, 0.02229411f, 
    -0.00646796f, -0.01240749f, -0.01498701f, 0.04489931f, -0.00405818f, 0.01049299f, -0.01841234f, -0.03488930f, 
    -0.02867194f, 0.01454747f, -0.03218970f, 0.03091211f, 0.00740200f, 0.00221312f, 0.03798687f, 0.02668077f, 
    0.00439729f, 0.00973000f, -0.02727923f, 0.03143227f, 0.01657465f, 0.01457434f, -0.02659784f, 0.01000398f, 
    -0.03327140f, -0.02252659f, -0.00677094f, 0.02296298f, 0.01914130f, -0.03466051f, -0.01827135f, -0.02750693f, 
    -0.03810602f, 0.03382131f, -0.04579300f, -0.02356611f, -0.01917622f, -0.01172795f, 0.03888764f, -0.00106938f, 
    -0.03527280f, -0.02671187f, 0.00919505f, 0.02608298f, -0.01421313f, -0.02244554f, -0.00995180f, 0.00794356f, 
    -0.02204622f, 0.00748249f, -0.01761005f, 0.03110927f, -0.00569651f, -0.02133334f, 0.02500965f, 0.02395140f, 
    0.00110898f, -0.00910415f, -0.01074898f, -0.01409621f, -0.01886333f, 0.01144761f, 0.00731403f, 0.00541280f, 
    -0.01752246f, -0.04255046f, -0.03140797f, 0.03198247f, -0.01955654f, 0.02449851f, -0.02947200f, -0.02712992f, 
    -0.00044748f, 0.00984937f, 0.01218346f, -0.02653862f, 0.02898603f, -0.03795139f, 0.03381127f, -0.00450597f, 
    0.00202256f, 0.01383556f, -0.01540272f, -0.02213166f, -0.02743869f, 0.01175470f, -0.03817252f, -0.03935772f, 
    -0.02819084f, 0.00893782f, -0.03461726f, -0.02140113f, 0.01190809f, -0.00624809f, -0.00152393f, 0.01918772f, 
    -0.03041381f, 0.01421466f, -0.02346474f, -0.02766445f, -0.02196674f, 0.01684054f, -0.02548091f, -0.03175024f, 
    -0.00703335f, 0.01694887f, 0.02907800f, 0.01835775f, -0.03898977f, 0.01931947f, -0.02439944f, -0.01126245f, 
    0.02096827f, -0.02938254f, -0.01315078f, 0.01094650f, 0.01750104f, -0.00901446f, 0.03437128f, -0.00009928f, 
    -0.02237873f, -0.03327611f, -0.03466602f, 0.00363530f, -0.01659484f, 0.01689772f, 0.02922487f, 0.01950395f, 
    0.02237092f, -0.00133292f, 0.00227503f, -0.03557833f, 0.01163214f, -0.01442266f, 0.02214611f, -0.03722761f, 
    0.02670080f, 0.02617269f, 0.02386910f, 0.02494662f, -0.00159320f, -0.03058844f, 0.01051172f, -0.01046829f, 
    0.00592072f, -0.03129108f, -0.00793277f, 0.02802093f, 0.02742995f, -0.04206844f, -0.00306096f, -0.00411418f, 
    -0.04032829f, -0.03820786f, -0.02648463f, -0.00701108f, -0.01452590f, 0.01543453f, 0.00532056f, -0.02476403f, 
    -0.00509348f, 0.02654033f, -0.01138669f, -0.03664173f, 0.02469768f, -0.01269230f, -0.00624053f, -0.01554315f, 
    0.00987831f, -0.01236609f, 0.00584990f, -0.00942276f, 0.02382806f, 0.01950201f, 0.02160045f, -0.01172419f, 
    -0.02257292f, -0.00752102f, -0.03570288f, 0.02620835f, 0.02298646f, -0.01330752f, -0.01185883f, -0.00608072f, 
    0.02023890f, 0.00646325f, -0.01246370f, 0.01394355f, -0.02306433f, -0.03923503f, 0.01850769f, 0.02053786f, 
    0.01237158f, -0.03060149f, -0.02615845f, -0.03226150f, -0.01995268f, -0.02068649f, 0.01595768f, 0.00276903f, 
    -0.04231991f, 0.02143730f, 0.01887824f, 0.03031091f, 0.02364518f, -0.03919862f, 0.03029259f, -0.03614412f, 
    0.02107885f, 0.00770594f, -0.02362121f, -0.01157439f, -0.02713706f, -0.01332365f, -0.01935564f, -0.00378984f, 
    -0.04268918f, -0.03815099f, 0.01025337f, -0.01359318f, -0.02270175f, -0.01934528f, -0.03653836f, 0.03101590f, 
    -0.00796679f, -0.01320369f, -0.00921666f, -0.00960187f, -0.01819158f, 0.01285655f, 0.01639321f, -0.02624713f, 
    0.00686029f, -0.02896350f, 0.02299405f, -0.00190615f, -0.03631274f, -0.00503832f, 0.00302662f, -0.01510839f, 
    0.00105775f, -0.02797780f, -0.01834703f, -0.02518588f, -0.03134333f, -0.02207446f, -0.00993611f, -0.01203591f, 
    -0.01517979f, -0.01576596f, 0.02781825f, 0.03067143f, -0.01872645f, -0.00298279f, 0.00142443f, 0.00852698f, 
    -0.02985318f, 0.00234815f, -0.01298807f, 0.01036242f, -0.03102756f, 0.03947163f, -0.01142855f, 0.02201828f, 
    -0.00504808f, 0.00008570f, -0.02460407f, 0.02799977f, -0.01750211f, 0.01053224f, 0.02182056f, 0.02508173f, 
    0.02319336f, 0.01376099f, 0.02531279f, -0.00171186f, 0.00696366f, -0.00233783f, -0.00469771f, -0.03209489f, 
    -0.03014144f, -0.00785196f, 0.02961731f, 0.00598510f, -0.02536430f, -0.01898247f, -0.01075395f, -0.02110839f, 
    -0.02235659f, -0.02024925f, -0.02095949f, -0.03068129f, -0.01464846f, -0.02739506f, -0.00480450f, -0.02218978f, 
    -0.03369227f, -0.01629212f, -0.00834283f, 0.00035231f, 0.00586338f, -0.04374827f, -0.01261046f, -0.03424392f, 
    -0.02691994f, -0.02159591f, -0.01563901f, -0.01193795f, -0.01354020f, 0.00612627f, -0.01612646f, 0.00757025f, 
    -0.01800874f, 0.01433657f, 0.01478376f, 0.02076615f, 0.02591424f, -0.03818702f, 0.02925339f, 0.00868969f, 
    0.03031056f, -0.02075555f, 0.01894060f, -0.02148385f, -0.02477759f, -0.02496579f, -0.01736301f, -0.01105308f, 
    0.00614297f, -0.00343785f, -0.01750044f, 0.03221854f, 0.03523541f, -0.00513301f, -0.00771452f, 0.02136119f, 
    0.02832005f, 0.00512023f, 0.00359403f, 0.02235379f, 0.03415708f, -0.00983290f, -0.00418642f, -0.00174724f, 
    -0.03951855f, -0.00952722f, 0.02331792f, -0.01295251f, -0.02891227f, -0.01628930f, 0.02022912f, -0.01815581f, 
    -0.02711187f, -0.00281251f, 0.03446417f, 0.02531078f, -0.01736525f, -0.01923220f, -0.00239723f, 0.03487640f, 
    -0.00558002f, -0.01941770f, -0.01183182f, -0.02545257f, -0.00255545f, -0.01771499f, 0.01047689f, 0.00434944f, 
    0.01762916f, 0.02700416f, -0.00514127f, 0.00659098f, -0.01789854f, 0.00774535f, -0.02343941f, -0.02706618f, 
    0.01231407f, -0.01254010f, -0.03987574f, -0.00274976f, -0.01292851f, 0.02153174f, -0.03214514f, 0.00445510f, 
    0.00839125f, 0.03218260f, -0.01844186f, -0.01714909f, -0.01397276f, 0.00263516f, -0.01784308f, 0.01890138f, 
    -0.00448008f, -0.01100952f, -0.01004896f, 0.00484322f, -0.00419705f, 0.00924910f, -0.02466898f, -0.01158355f, 
    0.01368481f, 0.02350101f, -0.01551554f, 0.02889674f, -0.04218248f, -0.03053143f, 0.01487998f, 0.01832095f, 
    -0.02207079f, -0.00286944f, -0.01639734f, -0.03128360f, -0.00557429f, 0.01188762f, 0.01481479f, -0.03136425f, 
    0.02246881f, -0.00940377f, -0.01562307f, 0.02061082f, 0.00695049f, -0.01801750f, 0.01120994f, -0.01672948f, 
    0.01584084f, 0.01315229f, 0.03058401f, -0.02886491f, 0.00205443f, -0.01539984f, -0.03015594f, 0.02883270f, 
    0.03252130f, 0.01512348f, -0.00897253f, -0.00602367f, 0.02645806f, -0.01487605f, -0.01275938f, -0.00703414f, 
    0.01410844f, -0.02015849f, -0.01606698f, 0.02965135f, 0.01515404f, 0.00479823f, 0.02779155f, 0.02227103f, 
    0.01230695f, -0.01916616f, 0.00767105f, -0.00695387f, 0.02975645f, -0.02789473f, 0.00949060f, -0.00258714f, 
    -0.00278901f, 0.02341217f, 0.03157855f, 0.01127715f, -0.02956212f, -0.02588622f, 0.01446748f, 0.00125727f, 
    0.03325019f, -0.00956780f, 0.02872957f, 0.00242333f, -0.00060223f, 0.02314056f, 0.03445228f, -0.01710899f, 
    -0.00939390f, 0.04401768f, 0.02966740f, -0.03443426f, 0.00784100f, -0.00180060f, -0.02729462f, 0.02657338f, 
    -0.03854496f, -0.01562698f, -0.03541659f, 0.01058555f, -0.04074650f, -0.00596848f, 0.00577322f, -0.01404426f, 
    0.00077406f, -0.04247140f, -0.01316212f, 0.02825423f, 0.00259305f, 0.00224915f, -0.01823751f, 0.00563273f, 
    -0.38705313f, 0.26495463f, -0.05135315f, 0.00227247f, 0.10346672f, 0.01920940f, -0.06272770f, 0.08331412f, 
    0.02112641f, 0.16243635f, -0.00884960f, -0.03842886f, 0.19203235f, 0.24676174f, 0.06244026f, 0.14044584f, 
    -0.03283457f, 0.02655424f, 0.10561983f, 0.02350068f, -0.01671576f, -0.07362062f, 0.00032571f, -0.03792672f, 
    0.11287276f, -0.25900519f, -0.00957943f, 0.08446571f, -0.01097439f, -0.02777145f, -0.06111025f, 0.03883477f, 
    0.06008703f, -0.08856762f, 0.02154403f, 0.05264019f, -0.13268225f, 0.02766176f, -0.05311736f, -0.05117828f, 
    -0.01072739f, 0.03261656f, -0.05636080f, -0.01437865f, 0.07592539f, 0.00596964f, -0.05607605f, 0.06667336f, 
    -0.07649775f, -0.18483454f, -0.04408347f, 0.23090385f, 0.09651173f, 0.00862177f, 0.05937704f, -0.01429737f, 
    -0.01648494f, -0.02926787f, 0.01424966f, -0.16910771f, -0.04726969f, 0.15058796f, 0.35217229f, 0.18618084f, 
    -0.08001714f, -0.03075884f, 0.07798214f, 0.02401986f, -0.03219965f, -0.05370993f, 0.04643429f, 0.08131365f, 
    0.18010551f, 0.21805747f, 0.27183816f, 0.16525480f, -0.03786996f, -0.02758425f, -0.05739815f, 0.04959401f, 
    0.02498218f, -0.08809204f, -0.01166604f, 0.00031365f, -0.12393209f, 0.06379507f, -0.08030742f, 0.22461917f, 
    0.05193254f, -0.00722887f, -0.01305960f, 0.05803347f, -0.07023125f, 0.16026661f, 0.05792477f, 0.10119027f, 
    0.01365649f, 0.28426516f, 0.21854091f, -0.06110732f, 0.04949087f, -0.07689702f, -0.00317600f, 0.02078381f, 
    -0.08903752f, 0.02409384f, -0.04092994f, -0.02386155f, 0.00826988f, -0.13596852f, -0.08607578f, -0.06164699f, 
    0.05723006f, 0.02564460f, 0.02636918f, -0.03853955f, 0.03924847f, -0.07117216f, 0.05254544f, -0.03484487f, 
    0.02430151f, -0.00237252f, 0.10864428f, 0.09534024f, 0.04189895f, -0.03793363f, 0.00783131f, -0.07542445f, 
    -0.06660751f, -0.07244375f, 0.10277101f, -0.07642067f, 0.00953488f, 0.05604317f, 0.27683493f, -0.00028929f, 
    -0.02306272f, -0.06158897f, 0.11879832f, 0.01255215f, -0.00105665f, 0.19365554f, 0.08390165f, 0.01989241f, 
    -0.21338563f, -0.14825507f, -0.10123980f, 0.37927607f, 0.15628730f, 0.07217728f, -0.00103456f, -0.06785385f, 
    0.02280715f, -0.01597778f, 0.07610490f, -0.06266168f, -0.03680849f, 0.09173839f, 0.19787899f, 0.00804367f, 
    0.13792220f, 0.04092157f, -0.03101998f, -0.01350672f, 0.02262913f, 0.08811942f, -0.08735801f, 0.00147721f, 
    0.07038892f, 0.05549620f, -0.05503081f, 0.08178880f, 0.08502872f, 0.09069172f, -0.07353735f, -0.09606551f, 
    -0.09416728f, -0.08541422f, -0.01056810f, -0.02304712f, 0.07568711f, 0.06446707f, 0.09367561f, 0.20836110f, 
    -0.04742451f, 0.02522576f, 0.01398294f, -0.00663173f, 0.05988913f, -0.13543002f, -0.13456962f, 0.14004932f, 
    0.19065033f, 0.06438541f, 0.12520292f, 0.01584051f, 0.02903378f, 0.01450008f, -0.14598772f, 0.08400270f, 
    0.07786582f, -0.13241595f, 0.04568019f, 0.02925459f, 0.05574215f, 0.21429527f, -0.03162868f, 0.16605790f, 
    -0.01011584f, 0.01365152f, -0.08898094f, -0.07362328f, 0.08129482f, 0.12741831f, -0.01797704f, -0.04045917f, 
    -0.06522822f, -0.10810206f, -0.11355748f, -0.17578016f, -0.06738422f, -0.07055563f, -0.05774184f, 0.03644232f, 
    -0.10092383f, 0.03427282f, 0.01083889f, 0.01461919f, 0.06469858f, 0.00984713f, 0.00091681f, -0.00347981f, 
    -0.00899361f, 0.02107782f, -0.09699567f, 0.07605336f, 0.12086660f, -0.03709079f, -0.03013426f, -0.06653800f, 
    0.01030365f, -0.08644089f, -0.14701855f, -0.18053137f, 0.03656160f, 0.09979708f, 0.02855478f, -0.03663146f, 
    0.06286629f, 0.13389808f, 0.09027916f, 0.00311556f, 0.06868505f, 0.14382321f, 0.07085796f, 0.07807831f, 
    -0.00149460f, 0.04738024f, 0.06885203f, -0.03466432f, 0.02298605f, 0.02332607f, -0.03714908f, -0.00582154f, 
    0.08154152f, -0.12642643f, -0.12145896f, 0.15813734f, 0.02755249f, 0.02973001f, -0.04701712f, -0.03400623f, 
    -0.04812590f, 0.01701356f, 0.09912606f, -0.01866196f, 0.05442648f, 0.18064509f, 0.11739337f, 0.14902839f, 
    0.03188017f, -0.01963762f, 0.06415582f, 0.06126531f, 0.01353210f, 0.18180585f, -0.01627891f, -0.04609938f, 
    0.18812402f, -0.07865986f, 0.08705114f, -0.03040673f, -0.02889988f, 0.12518984f, -0.06656520f, -0.02841710f, 
    0.07018916f, 0.04967339f, 0.00139701f, -0.00731936f, 0.07246276f, 0.18881717f, 0.10505033f, 0.44893348f, 
    -0.04913593f, 0.05643772f, 0.06001475f, 0.05751129f, 0.03181874f, -0.01441605f, -0.01223196f, -0.06663386f, 
    0.17425668f, 0.15786877f, -0.02536296f, 0.05282932f, 0.08304639f, 0.13575375f, 0.02126689f, -0.00981721f, 
    -0.18673716f, -0.01302951f, 0.06498470f, 0.00803641f, 0.01636774f, 0.24975656f, 0.14941715f, 0.11457995f, 
    -0.09562258f, -0.03588431f, 0.01247640f, -0.06501164f, 0.00330522f, 0.13811618f, -0.07831693f, 0.05536146f, 
    -0.04890618f, 0.00790579f, -0.02227004f, 0.27405930f, -0.01227072f, -0.03110053f, -0.01613604f, -0.02287337f, 
    0.02281090f, -0.00555408f, -0.09981118f, 0.02809447f, -0.12773317f, -0.12124894f, 0.06185984f, -0.03686603f, 
    0.07011133f, 0.09915591f, -0.02969525f, -0.00891223f, 0.17173113f, -0.01156680f, 0.02989922f, 0.03362827f, 
    0.01098727f, -0.10194586f, -0.02878752f, -0.11017664f, 0.00773603f, 0.12012835f, -0.01161538f, 0.06884283f, 
    0.04334943f, 0.12658136f, -0.07348976f, -0.00759607f, 0.28608182f, -0.02471920f, 0.03487319f, -0.00166331f, 
    0.14957145f, 0.03838325f, 0.04201110f, -0.03915271f, 0.08963088f, 0.04257796f, -0.00381520f, 0.10163178f, 
    -0.05726475f, -0.02617856f, 0.20205148f, 0.02768112f, -0.03798466f, -0.14349914f, 0.16766757f, -0.03379529f, 
    -0.03866932f, 0.05949843f, -0.05309227f, -0.05833839f, 0.18587118f, 0.01039665f, 0.27199668f, -0.05341792f, 
    0.12140955f, 0.00315078f, -0.09867669f, 0.21949890f, 0.08285978f, -0.02215368f, -0.07876261f, -0.06744802f, 
    -0.36055478f, 0.21205011f, 0.03652724f, 0.11839807f, -0.09067854f, -0.02999631f, 0.06690147f, 0.05738254f, 
    -0.03958330f, 0.00318915f, -0.01623505f, -0.09994291f, 0.13813187f, -0.04441645f, -0.14695285f, 0.04345892f, 
    -0.03447449f, 0.01547332f, 0.04391775f, -0.01909255f, -0.08717655f, 0.16370866f, 0.04476598f, -0.02070609f, 
    -0.04642024f, -0.15777901f, -0.12769105f, 0.04772235f, 0.00959425f, -0.01679405f, 0.00689980f, -0.09561421f, 
    0.07938216f, 0.04447987f, 0.12422670f, 0.02165728f, -0.14668410f, -0.02790543f, 0.03638842f, 0.07426088f, 
    0.17296740f, 0.02662691f, 0.05683547f, 0.02488501f, -0.03729746f, -0.09586893f, 0.05885770f, -0.01960255f, 
    -0.15891603f, 0.08136568f, 0.07284465f, -0.07976297f, -0.04329094f, -0.05743641f, -0.09689461f, -0.03867351f, 
    0.08211292f, -0.02693226f, -0.07082883f, 0.01371661f, -0.01549232f, 0.21678473f, 0.14514615f, 0.08849986f, 
    -0.11566284f, 0.18317565f, 0.10009374f, 0.10643980f, -0.10767111f, -0.02010627f, -0.01573922f, 0.00222674f, 
    0.01952986f, 0.10120448f, 0.06467157f, 0.05139010f, -0.07505717f, 0.03467043f, 0.07985515f, 0.11482313f, 
    0.11061977f, 0.02810811f, 0.03295750f, -0.07049243f, -0.10645597f, 0.02463012f, 0.20369372f, 0.02976748f, 
    -0.03066945f, -0.05099881f, -0.05519742f, -0.08339275f, 0.01304849f, 0.07657934f, -0.02385603f, -0.01341666f, 
    -0.15744132f, 0.00838279f, -0.07808450f, -0.26139551f, -0.03727487f, 0.09343835f, 0.18500444f, 0.06801255f, 
    0.02092892f, 0.06919929f, 0.06104191f, 0.14852229f, 0.10247299f, 0.16971682f, -0.14233288f, -0.06313650f, 
    0.06381231f, -0.12138870f, 0.01489642f, 0.01116944f, 0.05572699f, -0.08783286f, 0.01067114f, 0.03837486f, 
    0.23927490f, 0.09118881f, -0.06472192f, -0.04915077f, 0.05162627f, 0.02540929f, -0.00215828f, 0.05969893f, 
    0.12972626f, 0.09315896f, -0.01041814f, 0.01112805f, 0.09347372f, 0.11074118f, 0.19102037f, 0.10347884f, 
    -0.06706090f, -0.03516786f, -0.05689740f, 0.06450792f, 0.08964100f, -0.06932832f, 0.04211153f, -0.02163054f, 
    0.21860389f, 0.28752637f, 0.06017374f, 0.05583308f, -0.04388417f, 0.02650152f, -0.01805076f, 0.17119513f, 
    -0.07941381f, 0.02753707f, 0.00741573f, -0.07491276f, -0.00952324f, -0.03020853f, -0.05927437f, -0.10083350f, 
    0.02996766f, -0.06913746f, 0.03962430f, 0.05843195f, -0.14338431f, 0.06084812f, 0.14834860f, -0.04826505f, 
    0.07228758f, -0.16166258f, -0.16371033f, -0.17442656f, 0.10491494f, 0.01807188f, 0.02174668f, 0.02869434f, 
    -0.11034041f, 0.04941731f, -0.02517930f, -0.03074780f, -0.05788999f, 0.25288045f, 0.06887357f, -0.05134790f, 
    -0.04293635f, -0.02431153f, -0.04761894f, 0.01007165f, -0.03566323f, -0.00788156f, -0.05979721f, -0.02596393f, 
    -0.17462310f, -0.11317548f, 0.09788492f, -0.02605638f, 0.04948656f, -0.06438572f, 0.01232158f, -0.03394529f, 
    -0.01713765f, -0.00829606f, 0.03487199f, -0.05508423f, 0.09122369f, 0.08770060f, 0.22389972f, 0.02662441f, 
    0.06282365f, 0.05322655f, 0.00137596f, -0.03674602f, 0.11677700f, 0.07968263f, 0.10219482f, -0.00383632f, 
    -0.07716690f, -0.14903162f, 0.13739929f, 0.19156449f, 0.10721821f, 0.00304503f, -0.00427407f, -0.07694212f, 
    -0.00622280f, 0.06946456f, -0.02949267f, 0.02603317f, 0.07426411f, 0.15005174f, 0.22726533f, -0.08720705f, 
    0.00696800f, -0.07253607f, 0.01373325f, 0.08546498f, -0.02156045f, 0.09016698f, -0.01086396f, -0.04224221f, 
    0.20856366f, 0.32355449f, 0.08741433f, 0.11089036f, -0.01919935f, -0.01065285f, 0.01853506f, 0.05284682f, 
    0.00312428f, 0.02882230f, -0.03366690f, -0.04261468f, 0.18034875f, 0.30144966f, -0.01081694f, 0.05231750f, 
    0.00466854f, 0.03676265f, -0.02198965f, -0.02159816f, 0.03439548f, 0.01339218f, 0.00655675f, 0.05378584f, 
    0.10658175f, 0.27616137f, -0.15189664f, -0.10271599f, 0.04391757f, -0.05484695f, -0.08354467f, 0.06711179f, 
    0.00002612f, -0.00910811f, -0.01144856f, 0.01864881f, 0.31028286f, -0.10916675f, -0.02922687f, 0.00396567f, 
    0.16262108f, 0.11823088f, 0.01306632f, -0.03813443f, -0.01888856f, 0.03378036f, -0.06075984f, -0.01722605f, 
    0.16945070f, 0.06620903f, 0.17712003f, -0.15017976f, -0.00892484f, 0.07797105f, -0.11060409f, 0.13296004f, 
    0.05208378f, 0.11697943f, -0.01750588f, -0.04384956f, -0.08733197f, 0.11312966f, -0.15706185f, -0.01292505f, 
    -0.02918907f, 0.14252089f, 0.02246998f, -0.00508645f, 0.16326562f, 0.06247931f, -0.00556944f, -0.09278964f, 
    0.18721390f, 0.00588595f, 0.03846014f, 0.07774324f, -0.07821470f, 0.00075873f, 0.14422642f, 0.10585202f, 
    -0.01657587f, 0.03884045f, 0.07684562f, 0.05168363f, -0.00925836f, 0.20683028f, 0.03548560f, 0.23492625f, 
    -0.11409333f, 0.16070370f, -0.05987236f, 0.13495286f, -0.03495683f, -0.03159374f, 0.02332988f, -0.02114807f, 
    -0.06716000f, -0.17048423f, 0.31722814f, 0.01952755f, 0.01911062f, -0.08554899f, 0.08269002f, -0.02959844f, 
    -0.02303055f, -0.01201856f, -0.03178402f, 0.00647139f, 0.00213980f, 0.26951337f, -0.06596345f, 0.26257101f, 
    0.08105446f, 0.04098557f, -0.05940900f, 0.02102930f, -0.13561982f, 0.11971103f, -0.02523819f, -0.05041121f, 
    -0.28138202f, 0.14057398f, -0.18147565f, -0.00846586f, 0.11407045f, 0.08221840f, -0.01295957f, 0.02517766f, 
    0.07652432f, 0.04259558f, 0.02583161f, 0.01287765f, -0.02748428f, -0.29255137f, 0.06557627f, -0.04206529f, 
    0.14299579f, 0.00912670f, 0.06503345f, 0.07179896f, -0.03403765f, 0.00522993f, -0.03849321f, -0.01779673f, 
    -0.15694609f, 0.11945202f, 0.17573671f, -0.15195401f, 0.00720178f, -0.03245923f, 0.07549272f, 0.03907841f, 
    0.06183466f, -0.00304084f, 0.03366149f, -0.01961385f, -0.13224472f, 0.10555670f, -0.00754354f, 0.19389620f, 
    0.01348482f, 0.04246653f, -0.04740958f, -0.00603776f, 0.04855828f, 0.06418945f, -0.07492273f, 0.01875168f, 
    -0.00451923f, -0.09628990f, -0.14729941f, 0.30942476f, -0.03475055f, -0.06661099f, -0.00905884f, 0.00441227f, 
    -0.01374297f, -0.05973618f, 0.01282426f, 0.05690635f, -0.09410520f, -0.11206921f, -0.05998204f, 0.00944468f, 
    0.10095356f, -0.00577503f, 0.01373900f, 0.10474787f, 0.03913541f, -0.00782866f, -0.01076670f, -0.03264134f, 
    -0.02300115f, -0.17648070f, -0.17612028f, 0.02250696f, 0.07237279f, -0.03402386f, 0.03203626f, 0.20080835f, 
    -0.03778734f, 0.03968190f, -0.06806768f, 0.01327403f, -0.20926161f, 0.04628815f, 0.22158124f, -0.00235609f, 
    0.06488421f, -0.16204302f, -0.00547096f, 0.12648161f, -0.05048445f, -0.02743283f, 0.09390907f, 0.03508008f, 
    -0.23967588f, -0.01387669f, -0.03789622f, -0.00144222f, 0.00648286f, -0.07180931f, 0.01856261f, 0.00426265f, 
    -0.02668785f, 0.00921060f, 0.10849895f, -0.03980393f, 0.10186401f, 0.05223419f, -0.01754047f, 0.19957541f, 
    0.11385302f, 0.07908411f, 0.09133096f, -0.00597930f, -0.00138720f, 0.00285753f, -0.06292991f, -0.00682645f, 
    0.07748064f, 0.16243392f, 0.04265636f, 0.11563108f, 0.09716078f, -0.06362686f, -0.00052687f, -0.04001586f, 
    0.00104058f, 0.10313190f, -0.06229864f, 0.07184013f, -0.02270209f, -0.02001782f, -0.25557697f, -0.00866454f, 
    -0.01478479f, 0.06627558f, 0.04646584f, 0.07468635f, 0.08819520f, 0.04569148f, -0.08166034f, -0.07007709f, 
    0.02548239f, 0.03849846f, 0.00738370f, 0.12070881f, 0.10460147f, -0.02619952f, -0.01719500f, 0.01053633f, 
    -0.02384963f, 0.12105674f, -0.00597725f, 0.06820108f, -0.25111836f, 0.10195563f, -0.05667657f, 0.01549838f, 
    0.02288281f, -0.07662091f, -0.13378242f, 0.05345745f, -0.16698518f, 0.08732688f, 0.05199526f, 0.05304750f, 
    0.01244104f, -0.11009975f, -0.07831986f, 0.10862289f, 0.05162402f, 0.11957010f, 0.00812464f, 0.13996552f, 
    -0.00821103f, -0.02647044f, -0.02752790f, -0.01757001f, 0.13680296f, -0.01844218f, -0.01337583f, -0.03014725f, 
    0.00797087f, -0.01599319f, -0.02581172f, -0.07720354f, -0.02914545f, 0.06863228f, 0.00274752f, 0.05850200f, 
    -0.19731298f, -0.22321884f, -0.03635687f, 0.03711311f, 0.03705608f, 0.11641602f, 0.02294172f, 0.07648430f, 
    -0.00369993f, -0.08048657f, -0.07990781f, -0.02924671f, -0.15712677f, 0.01045505f, 0.01256441f, 0.02651714f, 
    0.02256890f, -0.06450228f, -0.01205680f, -0.05490469f, 0.00586767f, 0.05371162f, 0.01440963f, -0.03954971f, 
    0.07115442f, 0.00174265f, 0.15221596f, -0.20395160f, 0.05969243f, -0.18224059f, 0.10232887f, -0.06610166f, 
    0.05249059f, -0.12331697f, 0.09523644f, -0.10486847f, -0.25093248f, 0.00919287f, -0.02111440f, -0.04716907f, 
    -0.04804369f, 0.05959438f, 0.04045862f, 0.09362759f, -0.04829204f, 0.12727724f, 0.09454665f, 0.05106262f, 
    0.20947762f, 0.06998141f, 0.26387739f, -0.12347031f, -0.14220053f, -0.01597874f, 0.19150358f, 0.08659732f, 
    -0.00019461f, -0.17212617f, 0.07097249f, 0.02225314f, 0.17953289f, 0.08861195f, -0.13026175f, -0.03064573f, 
    0.02878695f, 0.00193003f, -0.01157511f, -0.08823595f, -0.01499612f, 0.07076831f, 0.06835985f, -0.09150027f, 
    0.14327931f, -0.13696456f, 0.18025218f, -0.07943416f, -0.02473264f, -0.06085825f, 0.05193369f, -0.00579127f, 
    -0.08160017f, 0.03076233f, 0.03438281f, -0.00000818f, -0.00955967f, -0.01573516f, -0.07363605f, 0.07224619f, 
    -0.15427954f, -0.05685542f, 0.05325364f, 0.04707256f, 0.04620127f, 0.05694605f, -0.02190263f, 0.00165739f, 
    -0.34535387f, -0.31874999f, -0.08750286f, 0.14493370f, -0.05051991f, 0.07064530f, 0.02328826f, -0.01758541f, 
    0.10359512f, 0.00365574f, -0.05610450f, 0.07828856f, -0.03730043f, -0.13434248f, 0.04754160f, 0.22014280f, 
    0.22253884f, 0.07294950f, 0.06276009f, 0.05973881f, 0.08958590f, -0.03557453f, 0.02427353f, 0.02897440f, 
    -0.28989366f, -0.09169349f, -0.03989039f, 0.01380343f, 0.01140012f, -0.01037637f, -0.08370221f, 0.03623762f, 
    -0.06564857f, -0.05527775f, -0.00699776f, 0.08984347f, -0.02480112f, -0.20343469f, -0.11793958f, 0.11200266f, 
    0.01606980f, 0.03067034f, -0.05474498f, 0.04664943f, -0.01856142f, -0.03905113f, 0.00739913f, -0.00561807f, 
    0.01240550f, 0.11649578f, 0.06328965f, 0.07611656f, -0.07202045f, -0.01635179f, 0.03071448f, -0.02078856f, 
    -0.01303885f, 0.12847193f, 0.05331457f, -0.02072360f, 0.14751309f, 0.19107161f, 0.17993012f, -0.06558827f, 
    -0.03951971f, 0.07507064f, 0.07160027f, -0.04333605f, 0.04833131f, 0.01861276f, -0.02450738f, 0.00432977f, 
    -0.01061034f, 0.10009857f, 0.00810719f, -0.07472843f, -0.14509235f, 0.02674223f, -0.04652738f, 0.03162691f, 
    0.06327519f, -0.06092642f, 0.15454769f, -0.06730048f, 0.17970966f, 0.10884056f, 0.02285222f, 0.18028520f, 
    0.15106747f, -0.07569519f, 0.01581535f, -0.03490952f, 0.07227407f, -0.03006412f, 0.10572195f, -0.06383116f, 
    0.00874286f, 0.22367957f, 0.03173356f, 0.04871252f, 0.10351784f, 0.05858164f, -0.04208796f, -0.00489386f, 
    0.09204771f, -0.08246493f, 0.04405287f, -0.09812465f, -0.20540683f, 0.01868700f, -0.10945664f, -0.14796352f, 
    -0.02140396f, -0.01607792f, 0.00684124f, 0.02564618f, 0.10628825f, 0.07072870f, -0.01576938f, -0.06017176f, 
    0.03513411f, 0.05718519f, -0.19478023f, -0.01831574f, 0.05979139f, 0.01446224f, 0.00314906f, 0.05775946f, 
    0.02316542f, -0.00161054f, -0.03754194f, 0.00661348f, 0.33687904f, -0.04621392f, 0.02512934f, -0.11535722f, 
    0.00516758f, 0.03517257f, 0.06863778f, 0.01083693f, 0.03206702f, -0.04730745f, 0.06397497f, 0.00774994f, 
    0.07009023f, -0.03488591f, -0.04000091f, 0.16438663f, -0.00402919f, 0.07731585f, 0.09309156f, -0.01322454f, 
    0.03998559f, 0.13105392f, -0.00222852f, -0.01639824f, 0.05462200f, 0.23426221f, 0.00683469f, 0.01704737f, 
    0.30051109f, -0.05873618f, 0.05646686f, 0.00611101f, -0.03866472f, 0.04451818f, 0.05983147f, 0.05956153f, 
    0.01924047f, 0.10478175f, 0.27658692f, -0.07752797f, 0.00110829f, -0.08711751f, -0.07088269f, -0.03389714f, 
    0.09511177f, -0.03818912f, 0.03640984f, -0.01116481f, -0.11879707f, 0.04131322f, -0.01394787f, 0.13301034f, 
    0.05278096f, -0.01682290f, 0.00707100f, 0.11265240f, 0.06484961f, 0.10339312f, -0.11932240f, -0.02743212f, 
    0.01011198f, 0.08890723f, -0.03731219f, 0.12998787f, 0.04397831f, 0.04603118f, -0.00270174f, 0.02952487f, 
    0.00504164f, 0.05816196f, -0.01279148f, -0.04572519f, 0.06747310f, -0.15688127f, -0.13507643f, -0.07815723f, 
    0.01750857f, 0.11117238f, 0.03962265f, -0.02882878f, -0.00621285f, 0.08102216f, 0.10418551f, -0.09941392f, 
    0.34998208f, 0.05582980f, 0.16238861f, -0.07052936f, -0.07398088f, 0.08262993f, 0.06342738f, 0.01747303f, 
    -0.05278581f, -0.05635143f, 0.04321670f, 0.13386896f, -0.31720519f, 0.01178707f, 0.08600451f, -0.10456623f, 
    0.04945761f, -0.00942376f, 0.06917516f, -0.01945058f, 0.07656907f, -0.07512190f, 0.01278744f, 0.06822119f, 
    -0.22141276f, -0.01439605f, -0.04149493f, -0.08591741f, 0.03800455f, -0.06405659f, 0.10738742f, 0.03344220f, 
    0.03477374f, 0.03414974f, -0.07097914f, -0.09910832f, -0.02552798f, -0.21902561f, 0.12158001f, 0.04384150f, 
    -0.03373523f, 0.03047939f, 0.17035605f, 0.15036449f, -0.03683643f, 0.08429090f, -0.02680152f, -0.00223350f, 
    0.19143726f, 0.01307825f, 0.16376327f, -0.06523289f, 0.07909178f, 0.05658451f, 0.02350116f, 0.10064140f, 
    -0.03231598f, 0.16125943f, 0.13204587f, 0.00701053f, 0.31712469f, -0.00432131f, -0.02993239f, 0.04360307f, 
    -0.00422437f, 0.02231216f, 0.06685649f, -0.05128467f, 0.02296340f, 0.03329524f, -0.03228356f, -0.01227914f, 
    0.25612631f, 0.10383416f, -0.01977740f, 0.02867980f, 0.00242306f, 0.00979745f, 0.10869090f, -0.05233448f, 
    0.05133023f, 0.02151739f, -0.00412356f, 0.05443868f, 0.10733293f, -0.00994089f, 0.21872570f, -0.19204307f, 
    -0.03552147f, -0.07682951f, 0.03933251f, 0.05775606f, 0.00940916f, 0.02926913f, -0.02278705f, -0.06992275f, 
    0.07277372f, 0.08442281f, 0.14508140f, -0.09957959f, 0.01455563f, 0.04915839f, -0.01447603f, -0.05030841f, 
    -0.00666328f, 0.04852870f, 0.08296736f, 0.08277793f, 0.08084918f, -0.22651228f, -0.06502050f, -0.00143489f, 
    0.01662563f, 0.12651961f, -0.06919281f, 0.03071404f, -0.00041656f, -0.08546376f, 0.10224706f, -0.06499847f, 
    0.20648581f, 0.15576977f, -0.02311999f, 0.12229905f, 0.00514532f, 0.13511269f, -0.03448128f, 0.07806201f, 
    -0.12345617f, 0.01576283f, 0.01637160f, 0.04314915f, -0.30037016f, -0.21128131f, -0.01928136f, -0.04175160f, 
    0.00364120f, 0.03276690f, -0.06757414f, 0.02962974f, 0.00669052f, 0.08905648f, -0.03048448f, -0.07761751f, 
    0.13794805f, -0.01528355f, 0.04779153f, -0.16262788f, 0.04105049f, -0.01420227f, 0.04630852f, 0.05423825f, 
    0.01406866f, 0.04978012f, -0.04700566f, -0.14404930f, -0.05715125f, -0.26975894f, -0.16447811f, -0.01182762f, 
    -0.07204204f, 0.03713502f, -0.00278377f, 0.01104311f, 0.06286141f, -0.09964195f, 0.15257566f, 0.04682271f, 
    -0.45121062f, -0.04174115f, 0.19652317f, -0.36651081f, 0.01187886f, 0.08433665f, 0.01048685f, -0.11053536f, 
    0.02222491f, -0.01232951f, 0.07348970f, -0.07696369f, 0.17538777f, 0.19276844f, 0.05537667f, -0.06373527f, 
    0.12238501f, 0.01568993f, -0.00276696f, 0.04205566f, 0.12420410f, 0.02762525f, -0.13089673f, 0.01506153f, 
    -0.09924435f, 0.10886226f, -0.24810496f, -0.03088629f, -0.07474135f, 0.05476316f, -0.01373266f, 0.15489811f, 
    -0.00122802f, 0.05643006f, -0.06841875f, -0.01027903f, -0.15314163f, 0.04859589f, 0.14484254f, -0.03011265f, 
    -0.10006130f, -0.05960519f, 0.10992592f, -0.11624192f, -0.08831195f, -0.04558535f, -0.01217954f, 0.03539601f, 
    -0.03439978f, 0.07267983f, -0.26247615f, 0.19303678f, -0.08242962f, 0.08167153f, -0.06400350f, 0.05731793f, 
    0.08827119f, 0.05106203f, 0.06623653f, -0.00580487f, 0.04243072f, 0.02029046f, -0.12135785f, 0.13285889f, 
    0.02302642f, -0.02164934f, 0.01414962f, 0.00661082f, 0.16723849f, -0.05199016f, -0.02092561f, 0.03110833f, 
    0.21906367f, 0.15971977f, -0.15420566f, 0.06462807f, 0.02174915f, 0.01611516f, -0.05017072f, -0.03214789f, 
    -0.01419577f, -0.04716053f, -0.03958400f, 0.17155224f, -0.19093809f, -0.16226777f, 0.17181312f, 0.08748538f, 
    0.11236876f, 0.01144469f, -0.09400466f, 0.04331458f, -0.06680053f, -0.09316096f, 0.04346103f, 0.02785062f, 
    -0.00867238f, -0.01244885f, 0.01806059f, 0.04692691f, -0.03145001f, 0.02856621f, -0.02230330f, -0.03258988f, 
    -0.01674538f, 0.00384612f, 0.00201623f, 0.02643718f, -0.00449357f, 0.01012776f, -0.00083648f, -0.02805583f, 
    0.02146857f, -0.02264672f, 0.00492004f, -0.00610347f, 0.01186117f, -0.00007676f, 0.03051428f, -0.02289938f, 
    -0.01957027f, -0.01057701f, -0.00510154f, -0.05000614f, -0.03356292f, -0.01751140f, -0.00382704f, -0.01163991f, 
    0.00343155f, -0.02095716f, 0.03996246f, -0.04615594f, -0.02272661f, -0.00687934f, -0.03568492f, 0.03179702f, 
    -0.04068999f, -0.03377144f, -0.01347078f, -0.00599052f, -0.01505752f, -0.02841756f, 0.01610240f, -0.01176190f, 
    -0.01529305f, 0.03593117f, 0.01523223f, 0.00026981f, -0.01637874f, -0.05896030f, -0.04557404f, -0.01886656f, 
    -0.00357840f, -0.02388969f, 0.02394104f, -0.01382252f, -0.02958287f, 0.00817932f, -0.02193820f, -0.02897887f, 
    0.03315553f, 0.01916132f, -0.00077757f, -0.01033283f, -0.01061048f, -0.03379283f, 0.02859803f, -0.01993159f, 
    -0.02031805f, -0.03089545f, -0.04053852f, -0.03074033f, 0.02464131f, -0.02062693f, 0.02601390f, -0.00717489f, 
    0.01014722f, -0.00232321f, 0.03099062f, 0.03471762f, 0.02857457f, -0.01228257f, -0.00249702f, -0.00738555f, 
    0.03704889f, 0.01235367f, -0.00683410f, -0.03499320f, -0.02740162f, -0.02466133f, 0.01948586f, -0.00826984f, 
    -0.01016597f, -0.01579334f, 0.00198370f, -0.02838431f, 0.00657000f, -0.02409369f, -0.02635318f, 0.02506204f, 
    0.00100398f, -0.02140292f, -0.03585910f, -0.02485472f, 0.01078733f, 0.01610588f, 0.02224610f, 0.03904436f, 
    -0.06110378f, -0.05029141f, -0.03178874f, -0.04250797f, -0.02271694f, -0.02004982f, -0.00859675f, -0.01069590f, 
    0.02181712f, -0.00495818f, 0.01443086f, 0.00256194f, -0.03751545f, 0.01068609f, -0.04459359f, 0.00825747f, 
    0.03009766f, 0.02487472f, -0.02245426f, 0.02495319f, -0.03041421f, -0.04069794f, 0.00199953f, 0.01258550f, 
    -0.03623393f, 0.02394868f, -0.03761980f, -0.03422004f, -0.03155470f, -0.00083179f, -0.00029951f, 0.00350956f, 
    -0.02428542f, -0.04771944f, -0.01385550f, -0.02222129f, 0.00659087f, -0.01253803f, 0.01487850f, 0.01874159f, 
    -0.01319917f, -0.02109539f, -0.02152526f, 0.02243702f, -0.02912023f, 0.02044383f, -0.01035403f, -0.03734932f, 
    0.00440246f, -0.01930361f, 0.00422273f, 0.04309341f, -0.02604347f, 0.03071975f, -0.00148615f, 0.02553682f, 
    0.00757128f, -0.01543956f, 0.01468856f, 0.00979450f, 0.04642916f, 0.00785648f, 0.03409432f, -0.01067801f, 
    0.02247640f, -0.02591193f, 0.00630354f, 0.03669840f, -0.03512346f, -0.01357087f, 0.01434196f, -0.02366153f, 
    -0.03611988f, -0.03036802f, -0.02282578f, 0.00271829f, 0.00348204f, 0.01068266f, -0.00623642f, 0.01883612f, 
    -0.01751256f, -0.05488273f, -0.03624450f, -0.02222553f, 0.01028202f, -0.02460217f, -0.00024212f, -0.02041570f, 
    -0.00731261f, -0.04650331f, 0.02269644f, -0.02255788f, -0.00219888f, 0.00904254f, 0.01445498f, -0.03231353f, 
    0.00347233f, 0.02479267f, -0.00907678f, 0.02213597f, -0.03659743f, -0.04026438f, -0.00431337f, 0.02646341f, 
    0.02411037f, -0.03031589f, 0.02430543f, -0.00993583f, -0.00221655f, -0.01592901f, -0.01450451f, 0.00062547f, 
    0.01010138f, 0.02972053f, -0.02790195f, 0.01502424f, -0.06946521f, 0.00338715f, -0.01704247f, -0.04934633f, 
    -0.00698354f, 0.01819476f, 0.01140073f, -0.01491436f, -0.01613973f, 0.01850589f, 0.02073582f, -0.00839064f, 
    -0.01446488f, -0.02245840f, 0.00680152f, -0.00574909f, -0.03154512f, -0.04895828f, -0.04330635f, 0.01859161f, 
    -0.00847015f, -0.03647496f, -0.01314104f, -0.03832611f, -0.05030899f, 0.03312787f, -0.03447551f, -0.01292245f, 
    -0.00586538f, -0.00107360f, -0.01960168f, 0.02363921f, -0.00099106f, 0.01373532f, -0.00512207f, 0.01552355f, 
    0.01007751f, -0.02279452f, 0.00524702f, -0.01020667f, -0.03217024f, 0.01134687f, -0.01332781f, -0.01506796f, 
    -0.04330887f, -0.03713320f, 0.01197312f, -0.02896302f, -0.00101490f, -0.02647758f, -0.02544007f, 0.00400437f, 
    0.02679581f, -0.02651064f, 0.01756857f, 0.03480468f, -0.05253127f, -0.01194885f, 0.02460058f, -0.00563930f, 
    -0.00113095f, -0.01148690f, -0.05511213f, -0.00441042f, 0.02241762f, -0.01507611f, -0.01601865f, 0.03637590f, 
    -0.04857970f, 0.01477495f, 0.00649801f, -0.01217302f, 0.00266482f, -0.01373358f, 0.00005676f, -0.01652328f, 
    0.02143772f, 0.01792328f, -0.03360165f, 0.00213979f, -0.00494977f, -0.04966195f, -0.02204164f, 0.01907767f, 
    -0.02756573f, -0.00414264f, -0.00874595f, 0.01324355f, -0.02221852f, 0.01932387f, -0.04530682f, -0.00710987f, 
    -0.00550123f, 0.00161345f, 0.00231383f, 0.02633443f, 0.00714941f, -0.02375996f, -0.03170726f, 0.03289536f, 
    0.01785954f, 0.01313938f, 0.02995889f, 0.02743586f, -0.01527549f, 0.02531191f, -0.02114915f, -0.01668854f, 
    -0.00847872f, -0.03128817f, -0.01162897f, -0.01880779f, -0.02045886f, -0.01577865f, 0.02993139f, -0.02490174f, 
    -0.00494980f, 0.04383143f, 0.02126848f, -0.03907850f, -0.00290137f, 0.03381038f, 0.03114933f, -0.01711618f, 
    0.01068425f, 0.00359691f, -0.01100168f, -0.02804434f, -0.03111164f, 0.03924815f, -0.00292110f, 0.02744310f, 
    0.02214500f, 0.01407163f, 0.00890930f, -0.01151631f, -0.01595481f, -0.00884246f, 0.02366850f, -0.01729248f, 
    -0.03153110f, -0.00150129f, -0.01526286f, 0.03778785f, 0.01535837f, 0.03470916f, 0.02915254f, -0.01073427f, 
    -0.01905541f, -0.04227857f, -0.04562267f, -0.00553492f, 0.01445615f, -0.04360099f, 0.02855811f, -0.00095522f, 
    0.00865983f, 0.00795745f, 0.01328820f, 0.03876211f, -0.02418633f, -0.02774712f, -0.01638708f, -0.01004610f, 
    -0.01220772f, -0.03261949f, -0.02331462f, 0.02942835f, -0.06364865f, -0.01636175f, -0.00368621f, 0.01876745f, 
    -0.00356020f, 0.04004343f, -0.02921165f, -0.02014383f, 0.01664112f, 0.00979877f, -0.00861188f, 0.01307454f, 
    0.04347678f, 0.02174089f, 0.02224769f, -0.02837168f, -0.03159154f, -0.02951689f, -0.02250482f, 0.00869278f, 
    -0.03506066f, -0.02005125f, -0.02434257f, -0.02581524f, 0.02075183f, -0.00483369f, 0.01770612f, 0.03506857f, 
    0.03311452f, -0.01008262f, -0.04685268f, -0.02662605f, -0.01667882f, -0.03424885f, -0.02747700f, 0.00135848f, 
    0.04715436f, -0.01269023f, 0.02403769f, -0.01867618f, -0.01392591f, -0.04440320f, -0.02385490f, -0.03452291f, 
    0.02512307f, 0.00950660f, -0.02555211f, 0.00084819f, 0.02205995f, -0.01906525f, 0.04845721f, -0.01438803f, 
    0.00577195f, 0.02163589f, 0.01213334f, -0.00755033f, -0.01752120f, 0.00361919f, -0.01790843f, 0.02714072f, 
    -0.04172632f, -0.01002088f, 0.02960458f, -0.05439716f, -0.02336839f, 0.01894914f, -0.03295579f, 0.02518771f, 
    -0.02410334f, -0.00331043f, -0.03315887f, 0.00407147f, -0.02768827f, -0.01371143f, -0.02934746f, 0.01007268f, 
    0.00145399f, 0.03036128f, 0.03144449f, 0.01235957f, -0.00165377f, -0.01614867f, -0.03990126f, 0.01767232f, 
    -0.01543555f, -0.00224718f, -0.01334368f, -0.00817858f, -0.03660148f, 0.01770937f, 0.00412871f, -0.02269871f, 
    0.02167122f, 0.00441228f, -0.01217250f, -0.00583180f, -0.04914320f, 0.01503277f, -0.02949384f, 0.01533580f, 
    0.01908281f, 0.03329711f, -0.01055713f, -0.00718250f, -0.00314959f, -0.03050347f, -0.01592485f, 0.04525866f, 
    0.03440820f, -0.01153800f, 0.00983929f, 0.03581093f, -0.04407090f, 0.01274322f, -0.02935346f, -0.01989124f, 
    -0.00175911f, -0.03373984f, -0.01013682f, -0.01268503f, -0.02503264f, -0.00419119f, 0.02688405f, -0.03400964f, 
    0.01907552f, -0.00724921f, 0.01678974f, -0.02945920f, 0.01390107f, -0.01156853f, 0.01756006f, -0.02355010f, 
    -0.03519879f, 0.01330009f, -0.04515005f, 0.01537047f, -0.01013842f, 0.00685009f, -0.02529669f, 0.03182822f, 
    -0.02331001f, -0.03926639f, 0.03196660f, 0.00857233f, -0.01274445f, -0.00997730f, -0.01062838f, -0.03590532f, 
    0.00116595f, -0.00582876f, -0.01057489f, 0.00468125f, 0.00403840f, -0.00461621f, 0.02743149f, 0.02871038f, 
    0.03480237f, 0.05163486f, -0.02283400f, -0.01086086f, 0.00755085f, -0.02989150f, -0.01397335f, -0.04295503f, 
    0.02999638f, -0.04285493f, -0.00071151f, 0.00209143f, 0.02782740f, 0.02385058f, -0.00269544f, 0.04982356f, 
    -0.02328313f, -0.04507169f, -0.03444300f, 0.01411930f, 0.03789706f, -0.01769067f, 0.02496004f, 0.02850202f, 
    0.03335723f, -0.02329090f, -0.02135058f, -0.01895538f, -0.00344673f, -0.01877561f, -0.00237292f, -0.04442545f, 
    0.03599888f, -0.00872580f, -0.00239390f, 0.04124795f, 0.02576157f, -0.03562053f, -0.00763310f, -0.00535338f, 
    0.01667952f, -0.02289846f, 0.00660238f, -0.01767183f, -0.01446179f, -0.02363366f, 0.00597045f, 0.01034793f, 
    -0.02986754f, -0.00014896f, 0.01751772f, -0.02862401f, -0.02506549f, 0.03572262f, 0.01276599f, 0.00622223f, 
    -0.00613679f, 0.00476823f, 0.03333204f, 0.00766672f, -0.03148115f, 0.01174881f, 0.00164589f, 0.00471914f, 
    -0.02557248f, 0.01946129f, -0.00736516f, 0.00859827f, -0.00863112f, -0.03937711f, 0.00333237f, -0.01949335f, 
    -0.02177734f, 0.00247210f, -0.00052624f, 0.02398642f, 0.00049089f, -0.04234328f, -0.02273673f, -0.00454529f, 
    -0.00215182f, -0.03636970f, 0.02750535f, -0.00661279f, 0.00285777f, 0.00385113f, 0.01012916f, -0.02476468f, 
    -0.02671039f, -0.02220527f, 0.03261087f, 0.01756628f, 0.01880424f, 0.01313189f, -0.03209620f, 0.02088565f, 
    0.03930347f, -0.01403333f, -0.00656144f, -0.03064012f, -0.02774995f, 0.02266712f, -0.00894934f, -0.00713930f, 
    -0.01017473f, -0.04943759f, 0.01765914f, 0.02240615f, -0.03798971f, 0.01383226f, -0.01203614f, 0.00351347f, 
    0.01250121f, 0.02871422f, -0.00759040f, -0.00843850f, 0.01705338f, -0.03890052f, -0.03549455f, -0.00093125f, 
    -0.04297327f, 0.02298242f, 0.01778369f, -0.04269481f, 0.02146759f, 0.03415398f, -0.01939651f, 0.02927779f, 
    0.00088249f, 0.03255822f, -0.00498859f, -0.04006959f, -0.02355850f, -0.02491350f, 0.02732772f, 0.00264451f, 
    0.02232702f, -0.01030754f, 0.00467376f, 0.00983456f, 0.03013036f, 0.00451789f, -0.02894984f, -0.02047593f, 
    -0.06712908f, -0.02013477f, -0.06043460f, -0.01708407f, 0.00920674f, 0.03059721f, 0.00294491f, -0.00294286f, 
    -0.01298708f, 0.00124296f, -0.01110550f, 0.01645890f, -0.04100460f, -0.04777220f, -0.02882775f, -0.00899452f, 
    0.02911739f, 0.01587331f, 0.02862452f, -0.02227961f, -0.02753923f, 0.01646550f, -0.01771859f, -0.05395634f, 
    0.01385958f, -0.01985782f, -0.00637668f, 0.01073405f, -0.00144107f, -0.01640842f, -0.00994189f, 0.04115808f, 
    -0.01497503f, -0.00384402f, -0.04575339f, -0.00924359f, 0.02852173f, 0.00444911f, 0.01528221f, 0.00318250f, 
    -0.00185256f, -0.02888069f, -0.01359218f, -0.02824669f, -0.00087433f, -0.00171624f, -0.05081505f, 0.00937494f, 
    -0.03813012f, -0.00245943f, 0.02541756f, -0.02143068f, 0.02213477f, 0.00793124f, 0.00566446f, 0.02686074f, 
    -0.00826226f, 0.01263304f, -0.03136734f, 0.02185333f, -0.02679522f, -0.01215005f, -0.03887574f, 0.02108365f, 
    0.03944603f, 0.00486891f, -0.00099299f, 0.00519353f, 0.00958887f, -0.03009246f, -0.01784032f, -0.01287408f, 
    -0.02414284f, -0.01007350f, -0.01805853f, -0.02740697f, 0.01707705f, 0.01699872f, 0.01784763f, -0.01169730f, 
    -0.02133438f, -0.00114116f, -0.04069571f, -0.03393337f, 0.02126535f, 0.02142414f, 0.03402848f, 0.01494423f, 
    0.02467468f, -0.03487321f, -0.03490841f, -0.03834167f, -0.00802543f, -0.00120674f, -0.03808694f, 0.03334912f, 
    0.02376641f, -0.02254608f, -0.02331939f, -0.02621075f, -0.03152028f, 0.01272088f, 0.01443056f, 0.01973489f, 
    0.02858366f, 0.02705472f, 0.01935049f, -0.04022465f, -0.00845088f, 0.01888133f, 0.03075494f, 0.00131866f, 
    -0.01377506f, 0.00051072f, 0.00995070f, 0.00786803f, -0.03389324f, 0.02752764f, 0.01404905f, 0.00971106f, 
    0.00262595f, 0.02359874f, 0.00700229f, -0.00197804f, 0.01849661f, 0.01864049f, -0.03409983f, 0.02404184f, 
    -0.02097570f, -0.03081057f, 0.01711715f, 0.02129672f, 0.00945208f, -0.01615058f, -0.00101533f, -0.01073049f, 
    0.02763709f, 0.00150402f, -0.00230043f, -0.00731685f, -0.02851250f, 0.03024062f, 0.00675389f, -0.02899565f, 
    -0.02466604f, 0.02675367f, -0.00019597f, -0.01604265f, 0.02675753f, -0.02757904f, -0.01909189f, 0.01065638f, 
    -0.03910412f, -0.01765698f, -0.01174358f, 0.00383064f, -0.01423538f, -0.03290397f, -0.01988759f, 0.02758775f, 
    0.01409433f, -0.01772431f, 0.02283071f, -0.01272887f, -0.01882572f, 0.02663617f, 0.01745363f, -0.02213326f, 
    -0.03779174f, -0.03944970f, -0.00887314f, -0.02714268f, -0.03202516f, 0.01926031f, -0.01261770f, 0.01948433f, 
    -0.00303786f, -0.02632885f, 0.00775217f, -0.02358881f, 0.00352832f, -0.03996138f, -0.01966433f, -0.03787389f, 
    -0.03101795f, -0.02812616f, 0.01162290f, -0.02925249f, 0.01811114f, -0.01220957f, -0.01088039f, 0.00606755f, 
    0.01112204f, -0.03917384f, -0.00251901f, 0.00127306f, -0.02264549f, 0.00124307f, 0.02563920f, -0.02960306f, 
    -0.02349073f, -0.01016627f, -0.01072908f, 0.01957016f, -0.00067127f, 0.00564238f, -0.01098781f, 0.02768569f, 
    -0.03677016f, -0.00139436f, -0.00307655f, -0.01237370f, -0.01546803f, 0.02834172f, 0.00322277f, 0.03309674f, 
    0.02550888f, -0.01385312f, -0.02199343f, -0.02281888f, -0.02318375f, -0.02140645f, 0.02671861f, 0.01879814f, 
    -0.01653057f, 0.00063930f, -0.02211899f, 0.00377781f, 0.01102462f, -0.00705582f, 0.01019656f, 0.00567128f, 
    -0.02603768f, 0.02602367f, 0.03104311f, -0.02075668f, -0.00492942f, -0.00109404f, 0.01412122f, -0.03432029f, 
    0.01533077f, -0.02796979f, 0.02036499f, 0.00373030f, -0.00776645f, 0.01853773f, -0.00933697f, -0.01222947f, 
    0.00525717f, 0.01459637f, -0.00933289f, -0.02711217f, 0.02433736f, 0.02013765f, -0.01966478f, 0.02743328f, 
    0.02304394f, 0.01741270f, -0.02898400f, -0.00047099f, -0.00883481f, -0.03124453f, -0.02031803f, -0.00226063f, 
    0.02627958f, 0.03157375f, 0.00565520f, 0.01552752f, 0.00605389f, -0.00561928f, 0.01563803f, -0.00019158f, 
    0.02734938f, 0.02950309f, -0.00901094f, -0.03753665f, -0.02105984f, 0.02409440f, 0.00564911f, -0.02731700f, 
    -0.01701058f, -0.02797350f, 0.00779726f, -0.00589511f, 0.03144285f, 0.02169149f, -0.01728630f, 0.02228635f, 
    -0.00660933f, -0.01927495f, -0.03322237f, 0.00151066f, -0.03434327f, -0.01646570f, 0.01527517f, -0.00943726f, 
    -0.02829828f, 0.02284830f, -0.02063196f, 0.00024308f, -0.03495575f, 0.03167779f, 0.02329022f, -0.01854793f, 
    0.01152370f, -0.02528834f, -0.00159040f, 0.00762971f, 0.01662226f, 0.01346776f, 0.00162030f, 0.02237934f, 
    -0.04078745f, -0.03998079f, -0.01721453f, 0.02475852f, 0.00560627f, -0.02926585f, -0.01009155f, 0.02903717f, 
    0.01464968f, 0.00879895f, 0.01556680f, 0.01939869f, -0.00955238f, 0.02860944f, 0.02640396f, -0.03894361f, 
    0.03021210f, -0.00592652f, 0.02743168f, 0.03015717f, 0.01597907f, -0.01969639f, -0.02380028f, -0.00531813f, 
    0.02977669f, 0.00995009f, 0.02275061f, -0.02500166f, -0.01918969f, -0.02814429f, 0.01694039f, -0.01729588f, 
    -0.00065218f, -0.01116613f, -0.01728618f, 0.02359757f, 0.00926059f, 0.00221362f, 0.02150994f, -0.00995251f, 
    -0.02339740f, 0.01179044f, 0.02535085f, 0.02284019f, -0.00249431f, -0.02304928f, 0.02292668f, 0.00554159f, 
    0.01773314f, -0.01406793f, -0.01385074f, -0.03737688f, 0.02121689f, -0.03134862f, 0.00248045f, 0.00026212f, 
    -0.02061161f, -0.03444921f, 0.00931059f, 0.00126955f, -0.01228480f, -0.00961198f, 0.01175097f, -0.02763367f, 
    0.00155929f, 0.01940403f, -0.00992379f, 0.00183024f, -0.02153233f, 0.02764617f, 0.03255577f, -0.01984039f, 
    0.02380076f, -0.02325800f, -0.03396128f, -0.01802224f, -0.00737866f, -0.02640796f, -0.02937836f, -0.00571358f, 
    -0.02930107f, 0.00826969f, 0.03336333f, -0.02002227f, -0.03580905f, 0.01663660f, 0.00809704f, -0.00881370f, 
    -0.02821103f, -0.00893755f, 0.03020334f, 0.03049991f, -0.02882388f, 0.03507657f, 0.01795919f, 0.01626007f, 
    -0.03238912f, -0.03754139f, 0.00934335f, -0.03107535f, 0.02928111f, -0.00386430f, -0.00702251f, -0.00544329f, 
    0.01460648f, 0.01411012f, -0.03890012f, -0.01315858f, 0.02697498f, -0.00528066f, 0.02018351f, 0.01045760f, 
    0.01592220f, -0.03665599f, -0.00858294f, -0.00029010f, 0.02048879f, 0.02552581f, -0.00801620f, 0.02791655f, 
    -0.00456728f, 0.02416943f, -0.00798739f, 0.00108093f, -0.03661516f, -0.02928200f, 0.02094503f, 0.02038385f, 
    0.02330114f, -0.01462664f, -0.04190535f, 0.02737709f, -0.01177208f, -0.01460719f, -0.04039827f, -0.02704459f, 
    -0.00502888f, 0.02951574f, 0.02201007f, -0.01716957f, -0.03383976f, -0.02613227f, -0.01564314f, 0.01195897f, 
    0.01522845f, 0.03236293f, 0.01329737f, -0.02098511f, -0.00272434f, 0.02890351f, -0.03695833f, -0.03377902f, 
    0.00383514f, 0.00278949f, -0.02472256f, -0.02805521f, 0.00818831f, 0.00616363f, 0.00256642f, 0.02509204f, 
    -0.03384896f, -0.00457418f, 0.00400861f, -0.01771014f, 0.02405462f, -0.02737253f, -0.02308691f, 0.00049793f, 
    -0.02464618f, -0.02274054f, -0.02030953f, 0.01116472f, -0.03644946f, 0.01277217f, -0.02668673f, -0.01378988f, 
    -0.04101716f, 0.01315370f, -0.02764751f, -0.00589593f, -0.02317165f, 0.00895723f, 0.03106622f, -0.00301710f, 
    0.00823898f, -0.01815479f, -0.01832174f, -0.00873325f, -0.01831306f, -0.02213174f, -0.00578242f, -0.02724899f, 
    -0.01408483f, 0.00777557f, -0.02105917f, 0.01653821f, 0.00170264f, 0.02401578f, -0.01545410f, -0.03428243f, 
    -0.03525145f, 0.01878215f, 0.01882146f, 0.01217726f, 0.00197067f, -0.00492341f, 0.02881013f, 0.01920475f, 
    -0.03506090f, -0.00793026f, 0.03077173f, 0.00540436f, -0.03978939f, 0.01582367f, 0.01675065f, -0.01310217f, 
    -0.00312344f, -0.01800477f, 0.01690429f, -0.04091333f, -0.01651356f, -0.03333626f, 0.01163897f, 0.00414167f, 
    -0.00916324f, 0.00546314f, -0.02521413f, 0.00882638f, -0.00127554f, -0.03557682f, 0.02158213f, -0.00731315f, 
    -0.00110506f, 0.02032955f, -0.03477796f, 0.01114369f, -0.00234095f, -0.03571515f, -0.02224400f, 0.00717095f, 
    0.00184161f, -0.03030807f, 0.03053120f, 0.01138145f, -0.03429737f, -0.02936314f, 0.00302854f, -0.03951142f, 
    -0.01845979f, 0.00744040f, 0.00797621f, -0.00546789f, 0.02386107f, 0.01278167f, 0.00619011f, 0.01409256f, 
    -0.01446308f, -0.00317475f, -0.00759674f, 0.02136494f, -0.01656251f, -0.01037626f, -0.00813684f, 0.02341782f, 
    0.02488426f, 0.00105460f, 0.00593200f, 0.00146804f, -0.03504412f, 0.01044029f, -0.02262088f, -0.02026339f, 
    -0.02873932f, -0.02032490f, -0.01371636f, 0.02661642f, 0.00357860f, -0.03134200f, 0.00248544f, 0.00326199f, 
    -0.01962429f, 0.01596376f, -0.01405933f, -0.03454452f, 0.01386864f, 0.01065241f, 0.03300221f, -0.03134403f, 
    -0.02220282f, 0.01472293f, 0.01227738f, 0.03282065f, 0.00504017f, 0.01714532f, -0.03009639f, 0.01992528f, 
    -0.01378011f, -0.02749931f, -0.00824235f, 0.01022326f, -0.03109013f, 0.01045720f, 0.03198935f, -0.00772236f, 
    -0.00405224f, 0.01705470f, -0.03903174f, 0.00588273f, 0.02107832f, -0.02096166f, 0.00447360f, -0.00676180f, 
    -0.03540159f, -0.01439950f, 0.00546164f, -0.02819502f, -0.02783243f, 0.01959194f, 0.00856183f, -0.03190831f, 
    -0.00338653f, 0.00131126f, -0.00940276f, 0.01253820f, -0.02311553f, -0.01623256f, -0.00118109f, 0.01903126f, 
    0.02509214f, 0.00971278f, -0.03156433f, -0.00857510f, 0.02190353f, -0.02458942f, -0.02762430f, -0.03101781f, 
    -0.03427135f, 0.00017065f, 0.01364209f, -0.00608472f, 0.02706988f, -0.01993599f, -0.02302105f, 0.02391063f, 
    0.00461265f, 0.01210927f, -0.02025707f, -0.00397133f, 0.01463617f, 0.01782152f, 0.00085580f, 0.01803519f, 
    0.00075400f, 0.01847061f, 0.01062462f, -0.02643103f, 0.02865619f, 0.01381791f, -0.00464240f, 0.01665161f, 
    0.00527634f, 0.01899792f, 0.01222229f, -0.00257377f, 0.00436624f, 0.01514248f, -0.01767728f, 0.02888900f, 
    0.03156539f, -0.03719326f, 0.02918476f, 0.03344059f, -0.02512292f, -0.02434532f, -0.00467076f, 0.02650181f, 
    0.00743042f, -0.03840072f, -0.02382460f, -0.03946650f, -0.03115171f, 0.01458760f, 0.01896218f, 0.02349540f, 
    -0.02628274f, 0.02412821f, -0.00004279f, 0.00450928f, -0.03302865f, 0.03181832f, -0.01406569f, 0.02643358f, 
    -0.01197778f, 0.01396597f, -0.03792475f, -0.02268679f, 0.01537452f, -0.02481117f, -0.01884124f, 0.00007652f, 
    -0.00123801f, 0.01152542f, -0.02678545f, 0.00987740f, -0.02361999f, -0.02147347f, 0.02186781f, 0.01986095f, 
    0.02616563f, -0.00553881f, 0.00350518f, 0.00791531f, -0.01933191f, 0.00492777f, -0.01877685f, -0.02592449f, 
    0.01165896f, -0.00509793f, 0.01519703f, 0.00025611f, -0.00757499f, -0.01323004f, -0.00343361f, -0.02786326f, 
    0.00654056f, -0.01457423f, -0.02626231f, 0.02158103f, 0.01557362f, 0.00749006f, -0.01200241f, -0.03674354f, 
    0.00497066f, 0.02143331f, 0.00602821f, -0.00673958f, 0.02955123f, 0.02628237f, -0.01261333f, -0.00126153f, 
    -0.03424659f, -0.00277197f, -0.00998549f, -0.02151669f, -0.01274409f, -0.02958682f, -0.00128615f, -0.00282822f, 
    0.02606314f, 0.00435917f, 0.03353089f, -0.01903769f, -0.03380467f, 0.02005219f, 0.00198702f, -0.02332200f, 
    -0.00223631f, 0.00845980f, -0.02844946f, -0.03567255f, -0.02689142f, 0.02754848f, 0.00716229f, -0.03250153f, 
    -0.03057004f, 0.01413557f, -0.01935135f, -0.00582225f, -0.02188270f, -0.02015335f, -0.01320290f, -0.02158786f, 
    -0.03593535f, 0.01496208f, -0.01304690f, -0.01914380f, -0.03490669f, -0.00898868f, 0.01699213f, -0.02063040f, 
    0.01354160f, 0.00853181f, -0.00409253f, 0.02057412f, -0.02916306f, -0.01296829f, -0.01291633f, -0.00155872f, 
    -0.01514419f, 0.01147463f, -0.00393557f, -0.03487984f, -0.02281426f, -0.01072006f, -0.01808149f, -0.00836507f, 
    0.01264269f, 0.02017157f, -0.02639329f, -0.01539630f, 0.00665879f, -0.01730764f, -0.02014150f, -0.03985848f, 
    -0.01481642f, -0.00939998f, 0.00016285f, 0.02103311f, -0.02374624f, -0.03658194f, -0.01460115f, 0.00476149f, 
    -0.00547546f, -0.00935447f, -0.01634797f, -0.00445909f, 0.00097207f, -0.01188719f, 0.01987311f, -0.03532036f, 
    -0.03588003f, -0.00359647f, 0.03203355f, -0.00532932f, 0.01610396f, 0.02512175f, 0.02487039f, 0.02408803f, 
    0.01458083f, -0.02781901f, 0.02199896f, 0.02309851f, 0.00851626f, 0.02858701f, -0.00213563f, -0.03182887f, 
    -0.01688425f, 0.03286222f, 0.00531809f, 0.01526009f, -0.03222443f, -0.03193144f, 0.01887679f, 0.02512463f, 
    0.02323502f, -0.00503128f, -0.02522513f, -0.02235961f, -0.00135083f, 0.00916028f, 0.01275187f, -0.03432710f, 
    0.00411325f, -0.00358413f, -0.02203351f, 0.03579802f, -0.01356606f, -0.00565916f, -0.00604196f, 0.02064964f, 
    -0.02875075f, -0.01169334f, -0.03176163f, -0.00908853f, 0.02385724f, -0.01291714f, 0.00515673f, -0.03196347f, 
    -0.03168783f, 0.00542419f, -0.02628351f, -0.00662502f, 0.00719568f, 0.01958918f, -0.01242536f, 0.02299890f, 
    0.02658404f, -0.00051465f, 0.00783742f, -0.02140479f, -0.02590601f, -0.03431335f, 0.00933559f, -0.00347566f, 
    -0.01436708f, 0.02820931f, -0.00793780f, -0.00617602f, 0.02972475f, -0.03445086f, -0.01114626f, 0.00571403f, 
    -0.03803524f, -0.01062342f, -0.01963416f, 0.01008133f, 0.02321077f, 0.00158481f, 0.00018485f, -0.03464220f, 
    -0.03351513f, 0.00088383f, 0.02178387f, 0.01195751f, 0.02596221f, -0.03515528f, 0.03358626f, 0.00133787f, 
    -0.00934018f, -0.02543270f, 0.03367603f, 0.02033415f, -0.04033804f, -0.00809827f, -0.01991519f, -0.01994818f, 
    -0.02057242f, -0.01175583f, -0.02767907f, -0.02416075f, 0.02769292f, 0.01518254f, -0.00244314f, 0.00450251f, 
    -0.02087405f, -0.00210585f, 0.02098139f, -0.03337145f, 0.01615032f, -0.02354074f, -0.00019931f, -0.00291397f, 
    -0.02650101f, -0.03013933f, 0.01056376f, -0.00726014f, -0.02075282f, 0.02414869f, -0.02191049f, -0.02159784f, 
    0.01401655f, -0.03339192f, 0.02489747f, -0.03846334f, -0.01135871f, 0.01563673f, 0.01756295f, 0.03839535f, 
    -0.02064520f, 0.01525750f, -0.01277490f, -0.03892072f, 0.01947417f, 0.02350370f, 0.02364894f, -0.00808561f, 
    -0.03645058f, -0.02055794f, 0.00107553f, 0.00818036f, 0.03318099f, 0.01120508f, 0.01363604f, -0.02827300f, 
    -0.03266136f, -0.01237635f, -0.00260767f, -0.01888306f, -0.01569704f, -0.03045818f, -0.00080731f, 0.00207698f, 
    0.02936528f, 0.02611036f, -0.03483275f, -0.03558351f, -0.01198244f, -0.00556862f, 0.02446064f, 0.01381600f, 
    -0.01317850f, 0.00256095f, -0.01862029f, -0.02746396f, -0.00488938f, -0.02883190f, 0.01108522f, -0.01170254f, 
    -0.00117451f, -0.03512510f, 0.02273385f, -0.03076253f, 0.01799178f, -0.01455081f, -0.02214438f, 0.01795083f, 
    -0.03835494f, -0.02833129f, 0.02262747f, -0.00328545f, -0.01821491f, 0.01377387f, -0.03314937f, 0.00162302f, 
    -0.01140843f, -0.00829229f, -0.02491379f, 0.02795298f, -0.02374041f, 0.01018608f, -0.02739317f, -0.00007756f, 
    0.02934677f, 0.01983758f, -0.01533958f, -0.01076868f, 0.01149662f, -0.02558146f, 0.03005252f, 0.02253114f, 
    -0.01751714f, -0.00707917f, -0.02211920f, 0.02464671f, -0.03426642f, -0.02164166f, 0.02150782f, -0.01195422f, 
    0.02484414f, -0.02659359f, 0.02655436f, -0.04159356f, -0.02640606f, 0.00698815f, -0.00688359f, -0.00064036f, 
    0.02116761f, -0.00112381f, -0.01698568f, -0.02577995f, -0.02104711f, -0.01398923f, -0.02841934f, 0.01049133f, 
    -0.03565767f, -0.00822524f, 0.02198721f, -0.01926418f, 0.00659551f, 0.00560872f, -0.01577609f, 0.02796223f, 
    0.00651377f, -0.00170964f, 0.02669418f, -0.02808254f, -0.02541647f, 0.01611047f, -0.00291546f, -0.01064767f, 
    0.01509644f, 0.00356909f, -0.03996169f, -0.02085049f, 0.02358252f, -0.00625035f, 0.02617349f, -0.03555721f, 
    0.02627173f, -0.02493911f, 0.00978598f, -0.00978909f, 0.00254659f, -0.02348397f, 0.02910697f, -0.01044686f, 
    0.00167989f, 0.00832651f, -0.02213443f, -0.03092487f, -0.00949127f, -0.01092736f, 0.03193188f, -0.01524151f, 
    -0.01088117f, -0.03696637f, -0.01165794f, 0.03153896f, 0.00617444f, -0.03788539f, -0.03288461f, 0.00987458f, 
    0.00091665f, 0.01694078f, 0.02806555f, -0.02620156f, -0.00768639f, -0.02924472f, 0.00201675f, -0.03259317f, 
    0.01657324f, -0.01622868f, -0.02900619f, -0.02557950f, -0.02190212f, -0.00335137f, 0.00926066f, 0.00278912f, 
    0.01724272f, 0.00343252f, -0.00515608f, -0.00199172f, -0.01122210f, -0.00667399f, 0.02960014f, -0.02100047f, 
    -0.02236270f, 0.01210722f, -0.02118646f, 0.02629845f, 0.02778173f, -0.02906645f, 0.02551384f, -0.02120772f, 
    -0.02477794f, 0.01231125f, -0.02561380f, 0.00492661f, -0.00025362f, -0.03271693f, 0.02755274f, -0.00475809f, 
    0.03126901f, -0.00248659f, -0.01949903f, -0.03490376f, 0.02664335f, 0.02260830f, -0.00358865f, 0.01975676f, 
    -0.00525694f, -0.00283217f, 0.01816279f, 0.00866155f, -0.00887058f, 0.02502357f, -0.00645620f, -0.01988152f, 
    -0.03273568f, -0.03650482f, -0.00804685f, -0.01598103f, -0.02351650f, 0.02045684f, 0.02613463f, -0.02716263f, 
    0.03018388f, -0.00251097f, 0.00554088f, -0.00548520f, -0.03126222f, 0.00750248f, 0.02606060f, -0.02763904f, 
    0.02516413f, 0.03056756f, -0.02180741f, -0.00696353f, 0.00862292f, -0.02373124f, -0.01654277f, 0.02712563f, 
    -0.01447216f, 0.00878703f, -0.02288017f, -0.02899896f, 0.02484363f, -0.03241765f, -0.01608607f, 0.01272914f, 
    0.01938855f, 0.00636757f, 0.00022585f, -0.02913372f, 0.01908442f, 0.00150332f, -0.01978418f, 0.00951554f, 
    0.02046739f, 0.02387823f, 0.00621356f, 0.00834453f, -0.02647461f, 0.02880679f, -0.01119933f, -0.01565827f, 
    0.02333491f, 0.00110356f, -0.01123579f, -0.01867610f, 0.00645089f, 0.02604001f, -0.01157320f, -0.01718426f, 
    -0.01170521f, -0.03188338f, 0.02762034f, 0.02644327f, 0.00238846f, -0.02040480f, 0.00131691f, 0.00973082f, 
    -0.00765183f, 0.03237468f, -0.00738346f, 0.00134715f, 0.03283064f, -0.00601058f, 0.01696931f, -0.01342503f, 
    -0.03846136f, -0.00930307f, -0.03559241f, 0.03158244f, -0.02141236f, -0.03422804f, 0.02478500f, 0.02652062f, 
    0.00282001f, 0.02518727f, -0.03237090f, 0.02582379f, -0.00349031f, 0.02977997f, -0.02114927f, 0.01005118f, 
    -0.01104096f, 0.02551791f, 0.02818834f, -0.02281070f, 0.02046485f, -0.03757927f, 0.00153453f, -0.02342401f, 
    -0.02759653f, 0.02557850f, -0.03984556f, 0.00014726f, 0.01320567f, -0.02282485f, 0.02249680f, -0.03355853f, 
    0.01552571f, 0.03446639f, 0.02040888f, 0.01550516f, -0.02962076f, -0.03979560f, -0.02656949f, -0.02360604f, 
    -0.03117699f, -0.01170707f, -0.00430933f, -0.01365863f, 0.03170928f, 0.02616520f, -0.00108692f, -0.03734606f, 
    -0.02378508f, -0.00172028f, -0.03620566f, -0.02064269f, -0.04041305f, 0.01605352f, -0.00494913f, -0.03662665f, 
    -0.02528196f, 0.02183213f, -0.01821324f, 0.01176564f, -0.03466330f, 0.00713046f, -0.01131136f, -0.02750242f, 
    -0.03904059f, 0.00082349f, -0.02628120f, -0.03907257f, -0.00078499f, -0.01770992f, -0.00778157f, -0.00784463f, 
    0.00946695f, 0.00812504f, 0.01076996f, -0.03543588f, -0.03490156f, -0.02042738f, -0.03577832f, 0.01325117f, 
    0.02535274f, 0.03067699f, -0.04010003f, -0.01383322f, -0.01090913f, -0.02144242f, 0.01791935f, 0.02595133f, 
    0.01181857f, -0.00150805f, 0.02882131f, 0.02403526f, -0.00316886f, 0.01036859f, 0.02021262f, 0.02004259f, 
    0.00884180f, 0.01371465f, -0.03191617f, 0.02794560f, -0.00377071f, 0.01941756f, -0.02978978f, -0.02686357f, 
    -0.01544637f, 0.01751884f, 0.00150363f, 0.02329207f, 0.00231720f, -0.01618997f, -0.01456603f, -0.01784093f, 
    0.02482980f, 0.03071867f, 0.02493609f, -0.01415384f, -0.02193238f, -0.02661986f, 0.02338131f, 0.00348415f, 
    -0.02073646f, 0.02485860f, 0.02670549f, 0.00614640f, -0.00013017f, 0.01643268f, 0.02708695f, 0.01869117f, 
    -0.03898868f, 0.02673506f, -0.02369250f, 0.01553433f, 0.01612161f, 0.00151532f, -0.00051695f, 0.02597310f, 
    0.03038994f, 0.01647104f, -0.02947568f, -0.01817705f, 0.00875590f, 0.03258459f, -0.02783909f, -0.01702704f, 
    0.02410014f, -0.01686990f, 0.02428867f, -0.00536803f, 0.03007821f, -0.01243430f, 0.00027550f, 0.00161364f, 
    -0.00559780f, -0.03024196f, -0.00515117f, 0.02368612f, 0.00542673f, -0.01670778f, -0.00637707f, 0.02533830f, 
    0.00905675f, -0.03545487f, -0.01341683f, -0.02549222f, -0.03338675f, 0.00330677f, -0.00578956f, -0.01177049f, 
    0.02503952f, -0.01555086f, -0.00654599f, 0.01454234f, -0.02641556f, 0.00810667f, 0.02978233f, -0.00897286f, 
    0.01028628f, -0.00360080f, -0.01019178f, 0.00456321f, 0.00698819f, 0.00916030f, 0.02105115f, -0.03355022f, 
    -0.02433917f, -0.00628181f, -0.03768352f, 0.01379024f, -0.01943394f, 0.02517267f, -0.00993286f, -0.01227850f, 
    0.01476009f, 0.02208618f, -0.01537878f, -0.01676117f, 0.03116350f, 0.02039611f, 0.00707502f, 0.00545344f, 
    0.00142661f, -0.03227166f, 0.01617142f, -0.01585051f, -0.00434038f, 0.01806074f, -0.01983067f, -0.01025575f, 
    0.02168039f, 0.00563313f, -0.01907540f, -0.03123204f, 0.00214278f, -0.01622069f, 0.00135814f, 0.00229333f, 
    -0.00716248f, -0.00865346f, -0.00691747f, 0.01225984f, 0.02736564f, 0.02505401f, -0.03069289f, 0.02027835f, 
    0.01976223f, 0.00428724f, -0.03155349f, -0.00835392f, -0.03438096f, -0.02656613f, 0.00415818f, -0.00270323f, 
    -0.01452031f, 0.03032978f, -0.03821448f, 0.00593999f, -0.01186203f, 0.00321296f, -0.00552649f, -0.01963773f, 
    0.02044762f, 0.01026699f, 0.00291846f, 0.02614955f, -0.01449921f, -0.02779986f, -0.02382634f, 0.02736442f, 
    -0.03146730f, -0.03286833f, -0.00543790f, 0.00962638f, -0.01009941f, -0.01770146f, -0.00824963f, -0.00409851f, 
    -0.01811039f, -0.01392104f, -0.02736802f, -0.02405893f, -0.02052730f, -0.03913859f, -0.03729880f, -0.03630916f, 
    0.00083382f, 0.00131086f, -0.01035824f, 0.01146842f, 0.02101826f, 0.00528591f, 0.00543047f, 0.00057667f, 
    0.02768315f, -0.02376622f, -0.01254767f, -0.02542488f, -0.01959134f, -0.01305626f, 0.02110347f, -0.03676709f, 
    -0.00795874f, -0.02484478f, 0.02823006f, -0.03759301f, -0.02886251f, -0.01900456f, 0.01943829f, 0.00142513f, 
    0.01902234f, 0.02848766f, -0.01610762f, 0.02847569f, -0.00039317f, 0.02228791f, 0.02089874f, -0.02109556f, 
    -0.03900288f, -0.02193017f, -0.02368926f, 0.00930430f, -0.00046570f, 0.02934559f, -0.02813953f, 0.01176381f, 
    -0.00327704f, -0.01913558f, 0.02726543f, 0.03087817f, 0.00395907f, -0.02745422f, -0.01728060f, -0.01361138f, 
    0.00074872f, -0.03782769f, 0.01558701f, -0.03437014f, 0.01729376f, 0.01669142f, -0.00827428f, -0.02606611f, 
    -0.03389939f, 0.01775183f, -0.00949517f, -0.01804052f, 0.01285112f, 0.01641638f, 0.00541929f, -0.01196176f, 
    0.00875540f, -0.00942154f, -0.00685289f, 0.03084493f, -0.00247899f, -0.01608938f, 0.02717770f, -0.00419231f, 
    -0.02858452f, 0.02287557f, -0.02263387f, 0.02675232f, -0.01627940f, 0.00349395f, 0.02815479f, -0.01043714f, 
    0.01582655f, 0.01578145f, 0.01521496f, -0.02774292f, -0.03578983f, -0.01416666f, -0.00722304f, -0.03315359f, 
    0.01221691f, -0.03195746f, 0.00099215f, 0.01085386f, -0.02196513f, -0.02037671f, -0.01788777f, -0.01364335f, 
    0.00077657f, 0.03208149f, -0.00541591f, -0.01294181f, 0.00608800f, -0.02776026f, 0.02285769f, -0.01405801f, 
    0.00463654f, -0.00201805f, -0.03175764f, 0.02583655f, 0.00525712f, -0.01507537f, 0.01264432f, 0.03024548f, 
    0.02396461f, 0.02115010f, -0.00354523f, -0.00998505f, -0.00684704f, -0.02875128f, 0.02299265f, -0.03022872f, 
    0.02342927f, 0.02755468f, -0.01925006f, 0.01734425f, 0.00211589f, -0.00441151f, 0.02149562f, 0.02786063f, 
    0.02626553f, -0.01468567f, 0.01702082f, -0.00886574f, 0.01330573f, -0.02280529f, 0.00867057f, 0.02788853f, 
    -0.03052542f, 0.02888465f, 0.00264098f, -0.02629657f, 0.02946213f, 0.01952275f, 0.00460837f, 0.02934711f, 
    0.01179855f, -0.03621640f, -0.01330868f, 0.02705146f, -0.00461232f, -0.00046246f, -0.01135622f, 0.02142003f, 
    -0.01799710f, -0.03175746f, -0.03489374f, -0.03191883f, -0.00434993f, -0.02160603f, -0.00666457f, -0.03136708f, 
    0.01728811f, 0.01167659f, -0.00713672f, -0.01429692f, -0.01301130f, 0.01279465f, -0.02973503f, -0.01906133f, 
    0.00074004f, 0.01933669f, -0.01566221f, 0.01342795f, -0.01343348f, 0.00861133f, 0.02815724f, 0.00716809f, 
    -0.02194334f, 0.02469951f, -0.00861844f, -0.01040779f, 0.01939759f, -0.00357035f, -0.00086828f, 0.00278892f, 
    -0.01953163f, -0.01119617f, -0.02825077f, -0.00910874f, -0.03115765f, -0.02477370f, -0.03310136f, -0.00901223f, 
    -0.00361730f, 0.01720863f, -0.03957029f, -0.00508363f, -0.03291740f, -0.01390787f, -0.02965575f, 0.00624133f, 
    0.00901462f, 0.00255788f, 0.01909045f, -0.02035188f, 0.02457454f, -0.03435907f, -0.02709557f, 0.00242232f, 
    -0.02546682f, -0.00917550f, -0.03549711f, -0.02433220f, -0.03988642f, -0.03544419f, 0.02671399f, 0.02077927f, 
    -0.00981583f, -0.02734515f, -0.03622653f, 0.01511908f, -0.00575522f, -0.03124233f, -0.03754829f, -0.03054199f, 
    0.00291820f, 0.02841857f, 0.00383922f, -0.00412899f, -0.03428192f, -0.03828543f, 0.01240472f, -0.00930439f, 
    -0.03864152f, 0.02099044f, -0.02177218f, -0.02170073f, 0.00887802f, 0.00828753f, 0.02837212f, -0.03222702f, 
    0.02468689f, 0.02291360f, -0.01751746f, -0.02517567f, -0.03503367f, 0.00325758f, 0.00128948f, -0.00695018f, 
    -0.01761745f, -0.04051128f, -0.01856195f, -0.00780314f, 0.00927393f, -0.02385326f, 0.02444950f, 0.02111060f, 
    -0.00564218f, -0.00655298f, 0.02279335f, -0.01988020f, -0.03550518f, 0.00384957f, 0.00939381f, 0.01850644f, 
    0.01902951f, 0.00040074f, 0.00873076f, -0.00718061f, 0.01035002f, -0.01515718f, -0.01456436f, 0.01602017f, 
    0.01235191f, -0.01676736f, -0.03003643f, -0.00441297f, -0.00567457f, -0.02994752f, -0.02626845f, 0.01189153f, 
    -0.00363124f, -0.00873553f, -0.00761124f, -0.04197787f, -0.02171152f, 0.02980179f, -0.03312888f, -0.00025234f, 
    0.00775124f, 0.01348684f, -0.03677918f, -0.02313540f, 0.01028400f, -0.02080417f, 0.00886911f, -0.01706825f, 
    -0.03957169f, -0.03047826f, -0.02467436f, -0.04105987f, -0.01631347f, -0.03682710f, 0.00767353f, 0.00202472f, 
    0.00914841f, 0.02642543f, -0.00874669f, 0.01921368f, -0.03825305f, 0.00921728f, -0.03318877f, -0.02630236f, 
    -0.01243974f, -0.04012961f, -0.01034048f, -0.00085057f, -0.00920495f, -0.03483248f, -0.02732873f, 0.00424860f, 
    -0.01939591f, -0.01875639f, -0.01165694f, 0.02727819f, -0.03278932f, -0.00284987f, -0.00058851f, -0.01912905f, 
    -0.00173406f, 0.02848072f, -0.01646595f, 0.01795935f, -0.01681891f, 0.02337004f, -0.03082390f, 0.00909167f, 
    -0.00816395f, -0.03283992f, 0.00740340f, 0.01961176f, -0.00230507f, 0.00004342f, 0.02905039f, -0.01843917f, 
    -0.00550858f, -0.00348047f, 0.02321769f, 0.01497587f, 0.02914511f, -0.03775197f, 0.00344298f, -0.04022653f, 
    -0.03841683f, -0.02121257f, 0.00045054f, 0.02753346f, -0.00903464f, 0.00453206f, 0.00075115f, -0.00784123f, 
    -0.04002877f, -0.02059784f, 0.02511075f, -0.00997835f, -0.04115277f, 0.01795157f, -0.03021208f, -0.04167819f, 
    0.01635714f, 0.01515038f, -0.03716732f, -0.01813153f, -0.03461209f, -0.00018463f, 0.01087619f, -0.03519079f, 
    -0.02918949f, 0.01513716f, 0.00694357f, -0.00611397f, 0.02275174f, 0.02485303f, -0.00063023f, -0.02121106f, 
    -0.00870058f, -0.03271230f, -0.03660235f, 0.00479729f, -0.03785675f, 0.02880699f, 0.00073123f, -0.04188088f, 
    0.00398615f, -0.02906094f, 0.00235180f, -0.02743498f, 0.00126273f, -0.00680119f, -0.03423151f, 0.00903222f, 
    0.02858789f, 0.00127274f, 0.02582955f, -0.02081371f, 0.00854620f, -0.01125575f, 0.02947852f, 0.02871400f, 
    -0.01437664f, -0.03277874f, -0.02098621f, 0.00580046f, 0.01831229f, 0.01003690f, -0.02141517f, -0.01875692f, 
    0.02106026f, -0.01627070f, -0.00933690f, -0.03808911f, -0.02365852f, 0.01559833f, 0.02232016f, 0.00342520f, 
    0.02796845f, -0.03052328f, -0.03893666f, 0.00928618f, -0.01378963f, 0.00362800f, -0.00473126f, -0.01496269f, 
    -0.01877015f, -0.00595691f, -0.00863951f, -0.00168587f, 0.00752544f, 0.00586832f, -0.02328154f, -0.00883549f, 
    0.02391757f, 0.00007647f, 0.02188373f, -0.03386453f, -0.01673729f, 0.01776066f, -0.03655552f, -0.03536106f, 
    -0.01005804f, -0.03456734f, -0.03435012f, 0.01717662f, -0.00046846f, -0.01164581f, -0.02538664f, 0.02403065f, 
    -0.02633360f, 0.02785809f, -0.02189252f, 0.01819705f, -0.02331486f, -0.02726493f, 0.01833117f, 0.02001302f, 
    -0.02553455f, 0.01732899f, -0.01477599f, 0.02805925f, -0.03958264f, 0.00669360f, 0.01170839f, -0.00900040f, 
    -0.03002756f, -0.00583465f, -0.01375120f, -0.02149018f, 0.01700894f, -0.04058574f, 0.00659835f, -0.03152369f, 
    -0.01810695f, 0.00059466f, -0.00183719f, -0.02094068f, -0.02459312f, 0.00306970f, 0.02449472f, 0.02591206f, 
    -0.04167633f, -0.01776845f, -0.03306149f, -0.00898884f, -0.00589139f, 0.00859363f, 0.01401106f, -0.04191770f, 
    -0.00441675f, 0.02889949f, -0.02963339f, 0.00296511f, 0.01855715f, -0.03835799f, -0.01837057f, 0.02249661f, 
    -0.02840190f, -0.00062809f, -0.00716269f, 0.02388651f, 0.02583229f, -0.02634551f, -0.03078942f, 0.01306373f, 
    -0.01184742f, -0.00201637f, 0.01661786f, -0.00892381f, 0.01378226f, -0.00955458f, -0.01865805f, -0.01530777f, 
    0.01222007f, -0.01821293f, 0.01681810f, -0.02278101f, 0.00389337f, -0.02247943f, -0.03122527f, 0.02626270f, 
    -0.00451860f, -0.01778768f, -0.03211407f, 0.02847055f, -0.04031271f, 0.01700209f, 0.01262073f, -0.01033227f, 
    -0.04091401f, -0.02893087f, -0.03336643f, -0.01588805f, 0.02476811f, -0.01417524f, 0.00323877f, -0.01271745f, 
    -0.01022197f, 0.00736446f, -0.02728143f, 0.02751132f, 0.02958617f, 0.00345492f, -0.01177151f, 0.00716787f, 
    -0.00348192f, -0.02143876f, -0.02683370f, 0.01006019f, -0.03688559f, 0.00354014f, 0.00699655f, -0.02119672f, 
    0.02346971f, 0.01330342f, 0.00939061f, -0.02243400f, -0.02901429f, -0.02894661f, 0.00528160f, 0.03005215f, 
    -0.02578214f, -0.02873119f, 0.01693014f, 0.01009069f, -0.02494674f, -0.00014270f, -0.03290566f, -0.01326705f, 
    0.02698258f, 0.01012215f, 0.00321283f, -0.01115085f, -0.03002359f, -0.00438445f, -0.02040273f, 0.01682180f, 
    0.00865564f, -0.03956959f, -0.00493758f, 0.00565686f, -0.00612745f, 0.00538967f, -0.02518425f, 0.01330483f, 
    0.00451859f, -0.02699687f, 0.00657743f, 0.01569966f, -0.03221750f, 0.02733864f, 0.01484074f, 0.02284877f, 
    0.01227929f, -0.00202651f, -0.00368885f, -0.01884996f, -0.01313589f, 0.01263251f, -0.01104780f, -0.01400003f, 
    -0.02610940f, -0.00602252f, 0.00909749f, -0.00027706f, -0.00421623f, -0.01009428f, 0.00222220f, -0.02903107f, 
    0.00940790f, 0.00836635f, -0.00471670f, -0.01879912f, -0.03968349f, -0.03637077f, -0.02194296f, -0.02757538f, 
    0.02726884f, -0.02687383f, -0.01915497f, -0.02854990f, 0.01298609f, -0.01997274f, -0.00007325f, -0.01682931f, 
    -0.00599513f, 0.02163473f, -0.03093021f, -0.02842416f, -0.03457141f, -0.01951925f, -0.03624234f, -0.03834814f, 
    -0.00113975f, -0.03642177f, -0.02851132f, -0.00808271f, -0.00850959f, 0.01089484f, -0.00237413f, 0.01916578f, 
    0.01693340f, 0.00215393f, -0.01053684f, -0.00631340f, -0.01871426f, -0.02716495f, -0.01622196f, -0.00612308f, 
    -0.00550500f, 0.00521161f, -0.02823552f, -0.00084634f, -0.03470401f, -0.00750322f, 0.02946534f, -0.03311456f, 
    0.01563718f, 0.01134463f, 0.02322955f, 0.01786855f, -0.00503638f, -0.03627194f, -0.00254914f, -0.03478559f, 
    -0.01009560f, -0.02266199f, -0.03995400f, 0.02034303f, -0.00152282f, -0.00310280f, -0.00994458f, -0.01528226f, 
    0.02711775f, -0.03863243f, -0.02919298f, -0.00436855f, 0.00952044f, 0.01117919f, -0.04041114f, 0.02341530f, 
    -0.03851273f, -0.01769865f, -0.02803700f, 0.00533495f, 0.01324764f, 0.00916794f, 0.00263282f, 0.00199739f, 
    0.00007965f, 0.01906272f, -0.03786891f, -0.00372201f, -0.03824100f, -0.03629950f, -0.00523135f, -0.03569621f, 
    0.01735503f, 0.02105216f, 0.02863023f, 0.02558536f, 0.02919809f, -0.00117939f, 0.00479652f, 0.02599067f, 
    -0.04140259f, 0.00461050f, -0.00162294f, 0.00549777f, -0.00044838f, -0.04189220f, -0.02470126f, -0.00268208f, 
    0.00297091f, -0.03934322f, -0.01217263f, -0.00259734f, 0.01624363f, 0.02040609f, 0.01258434f, -0.01417678f, 
    0.01020578f, -0.00033582f, -0.03860812f, 0.01477186f, -0.02676508f, 0.01727841f, 0.02132436f, -0.01838372f, 
    -0.01705341f, -0.03715316f, 0.01865552f, -0.02160067f, -0.01304801f, -0.02488708f, -0.02000091f, -0.00781048f, 
    -0.02474323f, -0.03762137f, -0.02330553f, 0.01776796f, -0.01562319f, 0.00063483f, -0.04201197f, 0.01794230f, 
    -0.02969694f, -0.01308057f, 0.02168079f, -0.01271538f, -0.04072982f, -0.00329390f, -0.02770363f, 0.01015114f, 
    0.00025694f, -0.00490154f, -0.01111863f, -0.00746711f, 0.01993366f, -0.02542212f, -0.02135911f, -0.02635032f, 
    0.01909715f, -0.00597362f, 0.00295292f, 0.02418911f, -0.02026075f, -0.02958482f, 0.01366519f, 0.02141468f, 
    0.01401639f, -0.01405580f, -0.02677050f, 0.01430777f, -0.03806973f, 0.00608929f, -0.01713320f, -0.00722825f, 
    0.01847859f, 0.00373519f, -0.00424424f, -0.03034284f, -0.02854852f, 0.01549482f, 0.01379438f, 0.00445492f, 
    -0.02756161f, -0.03057913f, 0.01239369f, 0.00412100f, 0.02833566f, 0.02880277f, -0.02269677f, -0.03761900f, 
    -0.02812616f, -0.00089723f, 0.01396120f, -0.03437666f, 0.02816305f, 0.00356004f, 0.02784994f, -0.03108184f, 
    -0.00896754f, 0.00875315f, -0.03575764f, -0.03949874f, -0.02660897f, 0.02148854f, 0.01249107f, -0.00516901f, 
    -0.03006847f, -0.02459806f, 0.00747155f, -0.02635218f, -0.00518873f, -0.00605527f, 0.00847569f, -0.01067929f, 
    -0.02278703f, 0.01017280f, -0.02287242f, -0.03284047f, 0.00574057f, -0.02994379f, 0.01403530f, -0.02648346f, 
    0.00468186f, -0.01177020f, 0.02029427f, 0.00595604f, 0.01453171f, 0.02100171f, -0.00153090f, -0.00782248f, 
    0.02256835f, -0.01437180f, -0.02914874f, 0.00207677f, 0.02553764f, -0.02237762f, -0.03244262f, 0.02893799f, 
    0.00791636f, 0.00073106f, 0.02458836f, 0.02994831f, -0.03528936f, -0.00916540f, -0.00191983f, 0.02993564f, 
    -0.01475905f, 0.02627173f, -0.01318324f, 0.02894003f, -0.01632636f, 0.01941184f, 0.00943347f, 0.01634529f, 
    -0.00178049f, -0.04117380f, -0.03286863f, -0.02187661f, -0.01941078f, -0.01515321f, 0.02381794f, 0.01380602f, 
    0.01381155f, 0.00498603f, 0.00487364f, 0.02595742f, -0.02774164f, 0.02937010f, -0.01483245f, 0.01893652f, 
    0.47612754f, -0.20037954f, 0.21522574f, -0.11777052f, -0.07759957f, 0.09408508f, 0.09820273f, 0.06643066f, 
    0.15215349f, 0.01134353f, 0.03851049f, -0.00605307f, -0.15263936f, 0.07052824f, 0.07727669f, 0.20723480f, 
    0.11519641f, -0.04450497f, 0.13139449f, 0.14737438f, -0.02124001f, 0.07389443f, 0.10609065f, 0.00738585f, 
    -0.35889888f, -0.05328845f, 0.12118947f, -0.26059702f, -0.01006507f, 0.18585415f, 0.07074822f, -0.03123604f, 
    0.01089627f, -0.08056165f, -0.10172290f, -0.02559617f, 0.16927335f, 0.10098707f, 0.15023416f, -0.07030117f, 
    -0.05415990f, 0.10179579f, -0.01310688f, 0.00197699f, -0.04984456f, 0.06202957f, 0.11548188f, 0.02189005f, 
    -0.04684820f, 0.20273805f, 0.05884838f, 0.02259235f, 0.05541410f, 0.04566708f, 0.00219647f, -0.05707761f, 
    0.07221688f, 0.06741925f, -0.05805423f, -0.04834457f, -0.11646658f, 0.06980123f, 0.05897915f, 0.10383132f, 
    0.07804193f, -0.04032616f, -0.03687339f, -0.03611261f, 0.00671957f, 0.03500100f, 0.04388148f, 0.01498604f, 
    0.32094964f, -0.05125282f, 0.16727729f, 0.03529124f, 0.09035406f, 0.01897690f, -0.03979398f, -0.13267969f, 
    -0.04209969f, -0.02388518f, 0.03587995f, -0.04739051f, 0.01063468f, 0.08151668f, -0.03549104f, -0.12538697f, 
    -0.06741446f, 0.06308122f, 0.01900263f, -0.06808130f, -0.07215444f, -0.06996296f, -0.04305008f, -0.03101999f, 
    0.23644973f, 0.01019241f, -0.19271305f, -0.00845140f, -0.03646604f, 0.01033045f, -0.00183470f, -0.01674760f, 
    0.11901969f, 0.02479924f, -0.00098985f, 0.03857148f, 0.10567228f, 0.24919248f, 0.14036685f, 0.10267492f, 
    0.05396030f, 0.06090958f, 0.01475483f, 0.02531560f, -0.03023239f, 0.16121635f, -0.04440783f, 0.04007194f, 
    0.05175673f, 0.14651392f, -0.02490914f, -0.16232194f, 0.05867582f, -0.10391510f, -0.05822433f, 0.08391304f, 
    -0.01908610f, 0.11013976f, -0.01117596f, 0.05805894f, 0.24579999f, -0.06050717f, -0.12774040f, -0.09922008f, 
    0.02396926f, 0.01194146f, -0.12754759f, 0.06492113f, 0.00779951f, -0.04836168f, -0.00528107f, 0.05451607f, 
    -0.00566285f, 0.24524161f, 0.14352603f, -0.16254696f, 0.04342783f, 0.02173209f, -0.09247313f, -0.00944204f, 
    0.04400438f, -0.08775447f, -0.08875336f, -0.12755047f, 0.19104026f, -0.10700325f, -0.03796399f, -0.14713962f, 
    0.01755072f, -0.04310723f, -0.01226716f, -0.09624659f, -0.10923821f, 0.05213178f, 0.04667519f, 0.07256889f, 
    0.03620944f, -0.00001766f, 0.05457338f, -0.00508063f, -0.01378356f, -0.01349457f, -0.02816004f, 0.03524851f, 
    0.00762191f, 0.07863022f, 0.16433950f, 0.08802635f, 0.29974833f, -0.12246812f, -0.07253505f, -0.10742069f, 
    -0.07187489f, 0.01085030f, 0.10044274f, -0.01359391f, -0.03946571f, 0.17402981f, 0.11994851f, -0.14672482f, 
    0.03943843f, 0.14628801f, 0.03722074f, 0.05776451f, 0.03368108f, -0.04341749f, 0.10655657f, 0.00960039f, 
    -0.02409984f, 0.07975820f, -0.07269964f, -0.02669245f, -0.08257271f, -0.18231598f, -0.28547159f, -0.14083770f, 
    -0.03465771f, -0.00389375f, -0.02687998f, 0.06245892f, -0.03960433f, -0.04674406f, 0.01107263f, -0.00259654f, 
    -0.21017215f, 0.13899112f, 0.14066079f, 0.14433126f, -0.19775486f, 0.17770486f, 0.04166687f, -0.06531444f, 
    0.05508376f, -0.01274628f, -0.07473681f, 0.00496603f, -0.23955233f, 0.06235767f, -0.05122035f, -0.21809551f, 
    0.05191971f, -0.02581131f, 0.02769188f, -0.07502951f, -0.04137891f, -0.03619726f, 0.01473996f, 0.00093672f, 
    -0.28904283f, 0.11546558f, 0.22883937f, 0.20796920f, -0.07186082f, -0.01498235f, 0.16275661f, 0.03025698f, 
    -0.10008606f, 0.01470528f, 0.03746925f, -0.05026839f, 0.44072416f, -0.19077316f, 0.01660601f, 0.03434011f, 
    -0.08480599f, 0.00617815f, -0.02837447f, -0.01987361f, 0.04163473f, -0.00628763f, -0.09484783f, -0.03581569f, 
    -0.09208946f, 0.13394397f, 0.08646105f, 0.02427133f, -0.05925152f, 0.07244811f, 0.04444464f, -0.04067519f, 
    0.01865239f, -0.06203792f, -0.16144860f, -0.03877345f, 0.10180704f, -0.31115413f, -0.03599561f, -0.34396660f, 
    0.02386202f, 0.02182172f, 0.11265462f, -0.11879924f, -0.17856571f, -0.00405572f, -0.04234234f, 0.01080620f, 
    -0.22077474f, 0.01117823f, 0.02437105f, -0.02474677f, -0.01585730f, 0.06206088f, -0.12427475f, 0.04001673f, 
    -0.08719116f, 0.02100749f, -0.00593167f, -0.03767162f, -0.32715061f, -0.13314578f, 0.25218707f, 0.28623229f, 
    0.00531855f, -0.07458755f, -0.01983441f, 0.14357372f, -0.01384079f, 0.06171140f, -0.02643564f, 0.09666358f, 
    -0.27199748f, 0.14179598f, -0.08204060f, -0.13861036f, -0.06134279f, -0.18057996f, 0.07915448f, 0.07811099f, 
    0.05156054f, -0.03097686f, -0.09636232f, 0.05255350f, 0.42375487f, -0.14110690f, 0.22972342f, 0.08287051f, 
    -0.09615925f, 0.13624595f, -0.01069921f, -0.00981347f, 0.00029029f, -0.11488777f, -0.00274937f, 0.05906640f, 
    -0.15403202f, 0.05340171f, 0.06189296f, -0.18391211f, 0.00978941f, -0.00176891f, -0.00356827f, -0.02887904f, 
    0.06211976f, 0.01807943f, 0.08267561f, -0.07965446f, -0.20002843f, 0.24316761f, 0.10937948f, -0.03632761f, 
    0.19720483f, 0.03101786f, -0.15340565f, 0.05663602f, -0.08518572f, 0.09455272f, 0.03039372f, 0.07236306f, 
    -0.23466803f, 0.09350919f, 0.06084802f, -0.29555213f, -0.05337318f, 0.10192639f, 0.03018021f, -0.00256697f, 
    0.04641028f, -0.00481544f, -0.06851955f, 0.07624595f, -0.16956837f, 0.27483973f, -0.06738193f, -0.04809248f, 
    -0.02445947f, 0.03265364f, 0.06448761f, 0.00212414f, 0.08536629f, 0.07766210f, -0.05207084f, 0.08200981f, 
    0.00155026f, -0.12458192f, -0.06675069f, 0.06098782f, -0.02013247f, 0.03916200f, -0.00713646f, 0.13990447f, 
    -0.06695648f, 0.08215377f, 0.04533589f, 0.19616295f, 0.31488281f, -0.14889747f, -0.11871006f, -0.00265978f, 
    -0.06177530f, -0.06101980f, 0.11977287f, -0.02656287f, -0.05217079f, 0.03150651f, 0.00603552f, 0.02465388f, 
    0.16311599f, -0.10618806f, 0.13387316f, -0.12207284f, -0.00185011f, -0.01506841f, -0.00106099f, 0.01825630f, 
    0.06027788f, -0.04540814f, 0.04140179f, 0.04507343f, 0.09700576f, 0.04864137f, 0.14149743f, 0.18358120f, 
    -0.02617893f, -0.04024141f, 0.06515548f, -0.07093391f, -0.02382571f, -0.18781538f, -0.02270190f, 0.19987306f, 
    0.04792735f, 0.16606361f, 0.23226193f, 0.03939691f, 0.17330419f, -0.00913382f, 0.07387025f, 0.00706467f, 
    0.01069677f, -0.01065192f, 0.04427464f, 0.08763675f, 0.14336769f, 0.20773582f, -0.02726821f, -0.15760444f, 
    -0.00981375f, -0.02240374f, -0.12601763f, 0.10876779f, 0.11587386f, -0.04623825f, -0.10641973f, -0.02385271f, 
    -0.02930035f, -0.03968010f, -0.21162766f, -0.13549466f, 0.05807733f, 0.16666214f, 0.15154730f, -0.02307727f, 
    -0.03964493f, -0.00179817f, 0.08118216f, -0.00899465f, 0.02867241f, 0.07864780f, 0.07774249f, 0.21367867f, 
    -0.02277485f, -0.05941664f, -0.04434501f, 0.07595678f, -0.01844797f, -0.11007994f, -0.02354240f, -0.01219465f, 
    0.01002863f, -0.17498869f, 0.03569224f, 0.09494753f, -0.06504428f, 0.06760817f, -0.08285566f, 0.04962623f, 
    -0.02055275f, 0.07830863f, 0.03787603f, 0.09269398f, 0.46154338f, -0.20274483f, 0.02910838f, -0.01699879f, 
    -0.03751196f, -0.05260998f, 0.03875915f, 0.04474332f, 0.08296783f, -0.05535756f, 0.03414809f, -0.01757966f, 
    -0.03708244f, 0.03819332f, 0.15068598f, 0.15091364f, 0.05587407f, -0.10236931f, 0.03704787f, -0.00934612f, 
    0.01537257f, -0.06250586f, -0.01773572f, -0.15028054f, -0.13798796f, -0.05692354f, -0.07872245f, 0.07384774f, 
    0.06453505f, -0.05786136f, 0.03219535f, 0.05159933f, -0.01457604f, 0.01522927f, -0.06464551f, -0.08701634f, 
    -0.00979333f, 0.14336485f, 0.18255420f, -0.03707928f, 0.05624526f, 0.03024120f, 0.08448516f, 0.00836445f, 
    -0.14330263f, 0.06991352f, -0.03926434f, -0.06405314f, -0.00700919f, 0.01517612f, 0.12833273f, -0.03945780f, 
    -0.03407549f, 0.12312710f, -0.05700359f, -0.00617277f, -0.03653312f, -0.04200738f, 0.03312624f, 0.08022302f, 
    0.13967882f, -0.05235922f, -0.06064767f, 0.23375998f, 0.01677803f, -0.03242418f, 0.05938483f, 0.05010469f, 
    -0.02397356f, 0.01907488f, 0.08756395f, 0.08234747f, 0.17982133f, -0.01471235f, 0.08226345f, 0.16883425f, 
    0.06245710f, 0.02165478f, 0.02539048f, 0.04493568f, 0.05388455f, 0.01818251f, 0.06827391f, 0.09332176f, 
    0.08003449f, 0.11390845f, 0.18984877f, 0.10932565f, -0.08743927f, -0.02906542f, 0.00820165f, 0.08342883f, 
    -0.02349333f, 0.02478938f, 0.01401570f, -0.01307761f, 0.13421990f, 0.17759290f, 0.15146485f, 0.18832570f, 
    -0.02014690f, 0.03302882f, 0.13408209f, 0.12112806f, 0.04646581f, 0.05339293f, 0.02216656f, 0.00334527f, 
    0.01106491f, -0.04551097f, -0.17145097f, -0.03465083f, 0.15201603f, -0.04184635f, -0.07662156f, -0.04782274f, 
    0.00994336f, -0.13203056f, -0.09866064f, -0.02308289f, 0.15980172f, -0.21316348f, 0.06225297f, -0.12171115f, 
    -0.03148241f, 0.05150818f, 0.11365927f, 0.00291037f, -0.08971894f, 0.05489775f, -0.08641252f, 0.00566891f, 
    0.08138693f, 0.05567975f, 0.05775497f, -0.08220687f, 0.08454841f, 0.08101953f, -0.04259200f, -0.04545429f, 
    0.10274498f, 0.01354579f, -0.14937219f, -0.04706668f, 0.04943265f, -0.04777292f, -0.03014987f, -0.00697612f, 
    0.01215643f, 0.07974108f, -0.21146671f, 0.01281788f, 0.02079874f, -0.02923495f, -0.05767087f, 0.00491446f, 
    -0.01221563f, 0.08119214f, 0.01425897f, 0.16925880f, -0.02215317f, -0.00472744f, 0.05858878f, 0.22252031f, 
    0.00160199f, 0.11213855f, 0.09952178f, 0.09813726f, 0.26889515f, -0.22599013f, -0.18874724f, -0.02628571f, 
    0.00103316f, -0.06846064f, 0.12232954f, -0.09918614f, -0.02424620f, -0.02425512f, 0.01284953f, -0.07974466f, 
    0.02523740f, 0.17851324f, -0.00647668f, -0.02317536f, 0.05752462f, 0.01110066f, 0.09523419f, 0.02276035f, 
    -0.10158887f, -0.05769672f, -0.03673377f, -0.01328942f, 0.01378234f, 0.13258369f, 0.04690668f, 0.09276862f, 
    -0.06070339f, 0.01542135f, -0.02702494f, -0.02423941f, -0.13325761f, -0.08802067f, -0.04854815f, 0.10171969f, 
    0.11403037f, -0.18341795f, -0.07707763f, -0.18100734f, -0.05478776f, 0.00326907f, 0.02214781f, -0.14317618f, 
    -0.05851477f, -0.02461499f, -0.00832887f, 0.02579729f, -0.02565688f, 0.03988571f, -0.01231814f, 0.02681806f, 
    -0.01687155f, 0.08816479f, 0.21936198f, -0.01481829f, -0.11009336f, 0.00844737f, 0.05940101f, -0.04378940f, 
    0.03543927f, -0.12907209f, -0.01499309f, -0.15919356f, 0.02794878f, 0.03965097f, -0.14010254f, 0.00013794f, 
    0.07995240f, 0.02438884f, -0.05793707f, -0.08266304f, -0.25262994f, 0.07632042f, -0.09187930f, 0.13125971f, 
    0.06380606f, 0.01097463f, 0.10451403f, 0.01046793f, 0.12773451f, 0.06035119f, -0.01302399f, 0.12350264f, 
    0.33661461f, -0.06816617f, -0.20539187f, -0.11580890f, -0.05035387f, 0.09878990f, -0.08261274f, 0.02669580f, 
    -0.02099983f, -0.00552816f, -0.11475280f, -0.19013846f, -0.27578151f, 0.00282193f, 0.14072843f, 0.25404644f, 
    -0.03335316f, -0.07599372f, 0.07015905f, 0.11067376f, 0.11692681f, 0.07431948f, 0.13179228f, 0.06334414f, 
    -0.04034698f, -0.01584282f, -0.00268753f, 0.01549421f, -0.02955130f, 0.02586976f, -0.01539109f, -0.01787729f, 
    -0.00990556f, 0.01761462f, 0.00610419f, 0.02665356f, 0.01844367f, -0.01872377f, -0.03380493f, 0.00800489f, 
    -0.01627315f, -0.01099153f, 0.00708067f, -0.03294095f, -0.04243270f, 0.00965201f, 0.00047747f, 0.00962729f, 
    0.01889105f, -0.03710276f, 0.03388156f, -0.03622880f, 0.00441028f, 0.00877627f, -0.01700936f, 0.01865454f, 
    -0.01605340f, 0.01813087f, 0.02855155f, 0.00006179f, -0.03880201f, -0.02517881f, -0.03958347f, 0.02467135f, 
    -0.02846128f, -0.03830428f, 0.02058666f, 0.01318310f, -0.00585822f, -0.00785430f, 0.03510332f, -0.04070047f, 
    -0.00216425f, 0.00585882f, -0.03337337f, -0.03951214f, -0.02366250f, -0.01630520f, -0.00714922f, -0.00619401f, 
    0.00470594f, -0.00093885f, -0.01879090f, 0.02381009f, 0.00169625f, -0.02193912f, -0.01691307f, 0.01691916f, 
    -0.02710583f, 0.00872618f, 0.02702769f, 0.03298382f, 0.02014705f, -0.00179333f, -0.01505329f, -0.03035263f, 
    0.02770822f, -0.00285612f, -0.00314867f, -0.03030725f, -0.02851883f, -0.03699019f, -0.03314662f, -0.01666413f, 
    0.01140848f, -0.01501484f, 0.00525564f, -0.01629847f, 0.00025783f, 0.00871821f, -0.00902759f, -0.02664133f, 
    0.01870548f, 0.01709501f, 0.01689978f, -0.02758212f, 0.01359440f, -0.02528345f, -0.03523081f, 0.02803161f, 
    -0.04266499f, -0.02770190f, -0.01452104f, -0.00440422f, 0.02578240f, -0.03765339f, -0.00624844f, -0.04035262f, 
    0.02320128f, 0.02799664f, -0.01418947f, -0.01844217f, 0.01057092f, -0.00944954f, -0.03316316f, -0.01238743f, 
    -0.01559842f, 0.00207284f, 0.01250748f, 0.00173796f, -0.02714209f, 0.02161062f, 0.01924284f, 0.00826893f, 
    -0.03753305f, -0.04067774f, 0.01456700f, 0.02206666f, 0.00404170f, -0.03291837f, 0.02503425f, -0.01340097f, 
    0.00187383f, -0.04415916f, -0.00992694f, 0.02651625f, -0.00777792f, 0.01222219f, 0.02543558f, 0.00511725f, 
    -0.01311305f, -0.04248984f, -0.03136595f, 0.01610514f, -0.02393756f, -0.01938988f, -0.02289136f, -0.03487316f, 
    -0.04237766f, -0.00769379f, -0.04033018f, -0.00121656f, -0.03616533f, -0.01253504f, 0.02165353f, -0.02227841f, 
    -0.01525126f, 0.00801746f, 0.00779186f, -0.03886870f, -0.02658892f, 0.02111640f, -0.00168860f, 0.01375165f, 
    0.01098108f, -0.02511007f, 0.00994195f, -0.02883828f, -0.02046330f, -0.02731000f, 0.01819911f, 0.02116848f, 
    -0.00498057f, -0.01633339f, -0.02623552f, -0.03086668f, 0.01282971f, -0.02654964f, 0.00507373f, -0.00113350f, 
    -0.02955852f, 0.02435246f, -0.03151968f, -0.03214327f, -0.00712806f, 0.00192188f, -0.04299274f, -0.03551095f, 
    0.02455907f, -0.02258238f, 0.01416279f, -0.00217053f, -0.00176426f, -0.02713105f, 0.00371623f, 0.00819306f, 
    0.01354059f, -0.03831422f, 0.02648838f, 0.00901597f, -0.00000910f, -0.02097362f, -0.01488237f, -0.02977959f, 
    -0.02973944f, -0.01357224f, -0.01018298f, 0.02487921f, 0.00158307f, -0.01843585f, 0.02199245f, 0.01940318f, 
    -0.01119400f, -0.02777416f, -0.01773676f, 0.03801861f, -0.02164098f, -0.00608988f, 0.00228509f, -0.00352285f, 
    -0.01879151f, -0.02455951f, -0.03154944f, -0.03970592f, -0.00105464f, 0.03666914f, 0.00926969f, -0.02593711f, 
    0.00627817f, 0.01995848f, -0.04303637f, -0.03885874f, -0.02761711f, 0.00504205f, 0.01408604f, -0.01156662f, 
    -0.01051426f, 0.02255975f, -0.01472524f, -0.04392673f, 0.03221891f, 0.02491016f, -0.01389853f, -0.02602922f, 
    0.00832695f, -0.02241564f, -0.00552050f, 0.02027074f, 0.02045873f, -0.02816438f, 0.02297234f, -0.03941254f, 
    -0.02055852f, 0.00277079f, -0.00071069f, -0.00958502f, -0.00108564f, 0.02374320f, -0.03033697f, -0.01089551f, 
    0.02143239f, -0.03034170f, 0.03061593f, 0.00732575f, -0.01563591f, 0.02384859f, 0.02108404f, -0.02644549f, 
    -0.03889227f, -0.03098938f, -0.03153827f, -0.00065122f, -0.01693832f, 0.02937366f, -0.03291564f, 0.02755973f, 
    0.00624916f, -0.03822358f, 0.01422104f, 0.02418831f, -0.00529137f, 0.00590341f, 0.02579247f, 0.00813322f, 
    -0.02279320f, 0.01700781f, 0.00695300f, -0.01859498f, 0.01946348f, 0.00515673f, 0.02385906f, -0.03024700f, 
    0.02156755f, -0.02211192f, 0.01981822f, 0.01572856f, -0.00223852f, 0.01620115f, 0.00875330f, 0.02281536f, 
    0.00685174f, -0.00336839f, 0.02042707f, -0.02839089f, -0.00786583f, -0.02437648f, -0.00864739f, -0.03490639f, 
    0.00071221f, 0.01605469f, 0.00005416f, 0.00392289f, 0.03389330f, -0.01290863f, 0.00301822f, 0.01215033f, 
    -0.03936262f, 0.01409918f, 0.01429414f, 0.01632686f, -0.03579075f, -0.01754210f, -0.01044169f, 0.03158264f, 
    0.02336527f, 0.00482787f, -0.03055145f, -0.01122808f, -0.02063892f, -0.04016091f, -0.01161365f, -0.02306740f, 
    -0.00740584f, -0.00752733f, 0.00917137f, -0.02815287f, -0.04182500f, 0.01976269f, 0.02657370f, 0.01488077f, 
    0.01439315f, -0.03799525f, -0.02870052f, 0.01800396f, 0.01418942f, 0.01864842f, -0.02451389f, -0.00843345f, 
    -0.00000452f, 0.01304680f, -0.00494691f, -0.03961731f, 0.01120415f, -0.01358880f, -0.01157387f, 0.02249486f, 
    -0.04001321f, -0.01383876f, 0.00280929f, 0.00510614f, 0.00521357f, 0.01100204f, -0.04256447f, 0.01976211f, 
    -0.01394286f, 0.01231239f, -0.03353167f, 0.02899585f, 0.00058658f, -0.04049262f, 0.01719943f, 0.00167302f, 
    -0.00716802f, -0.01668265f, -0.03657014f, 0.02241015f, 0.02342185f, 0.02044588f, -0.01956230f, -0.03621158f, 
    -0.01389894f, -0.01384032f, -0.04412206f, -0.03692459f, 0.00813126f, 0.00711992f, -0.02233734f, -0.03782279f, 
    0.00816395f, -0.03235726f, -0.00625647f, 0.02753495f, -0.00305593f, 0.01023899f, -0.00625462f, 0.02339271f, 
    0.02236822f, 0.01454879f, -0.01485966f, 0.00618429f, 0.00003286f, 0.01656616f, 0.00612085f, -0.02362659f, 
    -0.00278060f, 0.02150806f, -0.01305327f, 0.00228110f, 0.00485344f, -0.01928223f, -0.01147198f, 0.01979728f, 
    -0.00012721f, -0.02284208f, 0.00428448f, -0.01786591f, -0.02617114f, -0.01477332f, 0.02322521f, 0.01823828f, 
    -0.04142297f, -0.00559786f, 0.03940168f, 0.00513781f, -0.00204004f, 0.02033555f, 0.01242566f, -0.02950127f, 
    0.00352245f, -0.00129695f, -0.02188870f, -0.02285287f, -0.02421430f, -0.01618659f, -0.01390657f, -0.00385113f, 
    0.01265933f, 0.01793498f, -0.03879761f, 0.01360758f, 0.02214601f, -0.01505826f, 0.00398355f, 0.02320895f, 
    0.00666582f, -0.04269143f, 0.01910899f, -0.03078455f, 0.01320449f, -0.03493065f, -0.00094120f, -0.04288229f, 
    0.01541567f, -0.04085409f, 0.01056801f, 0.02872659f, -0.01087703f, -0.00834066f, 0.01334324f, -0.02900642f, 
    -0.03375630f, 0.01440454f, -0.04311524f, -0.03246471f, -0.02718301f, -0.02944545f, -0.00267018f, 0.00730645f, 
    0.00205575f, -0.00881605f, -0.00318885f, 0.03582654f, -0.00056662f, 0.01408582f, -0.03405539f, -0.02209047f, 
    -0.02233012f, -0.01303482f, 0.00968606f, -0.00786287f, -0.00302986f, -0.04101598f, 0.02591344f, -0.01750601f, 
    -0.02360262f, 0.01175969f, -0.02602715f, 0.03562822f, 0.01276455f, -0.01492401f, -0.03387399f, 0.02308193f, 
    0.01639449f, -0.02405365f, 0.02271936f, -0.00644331f, -0.03754934f, -0.02808954f, 0.00986495f, 0.03106895f, 
    -0.03227782f, -0.00467279f, 0.00752959f, 0.03110182f, -0.01124700f, -0.02411984f, -0.03134656f, 0.01077086f, 
    0.01579016f, -0.00808215f, 0.00505331f, -0.01464751f, -0.03565183f, -0.01491401f, 0.02181966f, 0.03025899f, 
    -0.00881667f, 0.01677155f, 0.02235360f, -0.01445354f, -0.02690732f, 0.00506432f, 0.01529400f, 0.00439429f, 
    -0.01907634f, -0.02343446f, -0.02767782f, -0.03585195f, -0.03937633f, 0.01393103f, 0.00097970f, -0.00197719f, 
    0.00548162f, -0.00853331f, -0.02950984f, -0.02688890f, 0.01056067f, -0.02006099f, -0.03745516f, -0.02830270f, 
    -0.03876536f, 0.01574918f, -0.03539117f, -0.00673487f, 0.01012576f, -0.00582578f, 0.00085105f, -0.01159441f, 
    -0.04283532f, -0.01311914f, 0.02195736f, 0.02826439f, -0.03007504f, 0.01151965f, -0.03305734f, 0.02433233f, 
    0.00182084f, -0.01828119f, 0.02106443f, -0.02163788f, -0.03271155f, 0.02643821f, -0.00696612f, -0.00887758f, 
    -0.01262504f, 0.00890382f, 0.00048182f, 0.00271820f, -0.02269383f, -0.00493845f, -0.03765312f, -0.01501115f, 
    -0.00687961f, -0.01490621f, -0.01049846f, 0.00617876f, -0.03956413f, -0.03595005f, -0.00846738f, -0.02002080f, 
    -0.03718884f, 0.01974151f, -0.03837550f, -0.01713300f, 0.00382515f, 0.02475875f, -0.00473905f, 0.02018768f, 
    -0.03815854f, 0.02576467f, -0.01670823f, -0.01368698f, -0.00064847f, -0.03798348f, 0.00506274f, -0.03417877f, 
    0.03020739f, 0.02361400f, -0.01187818f, 0.00927340f, -0.00851502f, 0.00605682f, 0.03846768f, 0.01258950f, 
    -0.00129052f, 0.02364490f, -0.01778578f, -0.04179484f, 0.00536791f, 0.01613894f, 0.01900272f, 0.01779515f, 
    -0.03286305f, 0.00088051f, -0.01808048f, -0.03098151f, -0.00385174f, -0.00255387f, -0.01553608f, 0.01286930f, 
    0.00687889f, 0.00377298f, -0.01669976f, -0.00636276f, 0.02316879f, 0.01769218f, -0.02844111f, 0.01426894f, 
    -0.02123779f, 0.03502643f, -0.04365743f, -0.01599222f, 0.00000538f, -0.01249180f, -0.01393941f, -0.03258725f, 
    0.01252784f, 0.02553040f, 0.01056140f, -0.02655521f, 0.02548139f, -0.03477499f, 0.02799098f, -0.03215158f, 
    0.00077605f, -0.01969267f, -0.04111215f, 0.02834480f, 0.03286228f, -0.02700914f, 0.00586374f, -0.01425447f, 
    0.03042422f, -0.04001382f, 0.00453980f, -0.02097004f, 0.00268169f, 0.02227242f, -0.01838969f, -0.01337515f, 
    0.01997246f, -0.00316008f, -0.02770557f, -0.03093222f, -0.00171542f, 0.02419562f, -0.02630449f, -0.04305699f, 
    0.00504611f, -0.00583580f, -0.02204024f, 0.01653496f, 0.01747225f, 0.02897452f, -0.02576980f, -0.00204988f, 
    -0.02193738f, 0.03616167f, -0.03472644f, 0.02146064f, -0.03730797f, 0.01220814f, -0.01192238f, -0.04300409f, 
    -0.00908413f, -0.01204490f, -0.00993503f, -0.00847237f, -0.04375268f, -0.00889370f, 0.01186373f, -0.00945573f, 
    0.00051418f, -0.01574720f, 0.03569372f, -0.00206493f, -0.04309642f, 0.00257990f, 0.02398610f, -0.03575167f, 
    0.01510771f, -0.03367646f, 0.00806497f, -0.02551267f, -0.00598022f, -0.02821040f, -0.00399120f, 0.01614219f, 
    0.03167310f, 0.01550025f, -0.00225474f, 0.00035879f, -0.04192181f, -0.03257167f, 0.02178277f, 0.00601753f, 
    -0.04032842f, 0.02026641f, -0.03872191f, 0.02410255f, 0.02911130f, 0.03477276f, 0.00981562f, -0.00116622f, 
    0.00495025f, -0.02846039f, -0.01039895f, -0.03664163f, -0.03618894f, -0.01879521f, 0.02726100f, 0.00360502f, 
    -0.04355901f, -0.02136908f, 0.01814200f, -0.03781091f, -0.03124438f, 0.02289527f, -0.01930299f, -0.00834592f, 
    -0.04233331f, -0.02006355f, -0.01941928f, -0.02774375f, 0.02792701f, 0.01614434f, -0.01537727f, 0.01083402f, 
    -0.03154463f, -0.01119180f, 0.01919535f, -0.01723010f, 0.01150059f, -0.03972293f, -0.03599507f, -0.03168812f, 
    0.01522267f, 0.01091169f, 0.00301973f, -0.02666236f, -0.00572348f, -0.01568112f, 0.01032415f, -0.01202466f, 
    0.01162807f, 0.01895547f, 0.01674844f, -0.01401425f, 0.00518534f, 0.02055847f, 0.01711433f, -0.01107895f, 
    0.19421344f, -0.00858721f, -0.04757806f, 0.08136696f, 0.01659026f, 0.11834247f, 0.04514062f, -0.04863854f, 
    -0.01707462f, 0.14824909f, 0.15464267f, 0.12438694f, 0.17564175f, 0.04547860f, -0.02199443f, -0.00655696f, 
    -0.00561582f, 0.07663473f, 0.10881137f, 0.06383588f, 0.03168463f, 0.14458810f, 0.00435725f, -0.03036196f, 
    -0.04720843f, 0.06651431f, 0.03037162f, 0.14172527f, -0.04156970f, 0.03473147f, -0.02267545f, -0.04266462f, 
    -0.03135120f, 0.07335668f, -0.06206648f, -0.05113614f, 0.07662303f, 0.04960736f, -0.08443253f, -0.07344035f, 
    0.05081338f, 0.04938820f, 0.04604106f, -0.00431933f, -0.04614719f, 0.04773354f, -0.00940757f, 0.16957688f, 
    0.20266774f, 0.22704746f, 0.11821476f, -0.24584347f, -0.13603628f, -0.08101127f, 0.09975544f, 0.07513100f, 
    0.10731076f, 0.10652646f, 0.01120136f, -0.14247367f, -0.13693117f, -0.08669907f, 0.22927080f, 0.05369068f, 
    -0.07615767f, 0.03355310f, 0.03158903f, -0.04278439f, -0.18623191f, 0.04180866f, 0.08584613f, 0.14327876f, 
    -0.11737560f, 0.07504907f, 0.03711777f, -0.09160592f, -0.10552067f, -0.01779283f, -0.01223712f, -0.09412280f, 
    -0.06580144f, -0.03240812f, -0.01309667f, -0.02953788f, 0.01643855f, -0.12031719f, -0.07972094f, 0.16033694f, 
    0.05596414f, 0.00864572f, 0.01403116f, -0.03402103f, -0.05315528f, 0.16086520f, -0.07038738f, 0.13070685f, 
    0.18254957f, 0.13240203f, 0.00112124f, -0.09441603f, 0.06560287f, -0.02090796f, 0.00353124f, 0.01674597f, 
    0.05197539f, 0.05944728f, 0.03906342f, 0.06436083f, -0.06282929f, -0.01175439f, 0.00196845f, -0.08806185f, 
    -0.12965837f, -0.00616718f, -0.02051377f, -0.03873958f, 0.00724721f, 0.03605115f, 0.06104188f, 0.04946775f, 
    0.15755811f, 0.01201179f, -0.13461055f, -0.18529594f, -0.04721699f, -0.03128983f, 0.00415665f, 0.14898482f, 
    -0.01933922f, -0.00216215f, 0.10620320f, -0.13994917f, -0.09976203f, 0.08889248f, 0.23464927f, 0.10227527f, 
    -0.04548708f, -0.01245262f, 0.03999892f, 0.08418834f, -0.05438340f, 0.08532605f, 0.35368860f, 0.07033336f, 
    0.10923459f, 0.03534218f, 0.02786348f, -0.11324532f, -0.08726779f, 0.08526816f, 0.05992834f, 0.05753017f, 
    0.08272267f, -0.19909105f, 0.07821145f, -0.18820986f, 0.01492256f, -0.00324974f, 0.21147063f, 0.07908800f, 
    -0.02394816f, 0.01869567f, 0.17495850f, -0.00789636f, 0.05392987f, 0.01201511f, 0.08321806f, 0.01434137f, 
    0.01629826f, 0.03518127f, -0.14095452f, 0.15302637f, -0.06172668f, -0.04905252f, -0.08179601f, 0.01684905f, 
    -0.08961374f, -0.07700140f, 0.15603735f, -0.01584315f, -0.07665128f, -0.03294839f, -0.03696381f, 0.16124560f, 
    -0.00364363f, 0.02834297f, 0.16241959f, 0.04087910f, 0.09525531f, -0.07266115f, -0.00991246f, 0.11749090f, 
    0.03412569f, 0.05619237f, 0.07799780f, 0.00872300f, -0.00667568f, -0.02302699f, -0.06479053f, -0.01964146f, 
    0.01854627f, -0.04526147f, -0.03454905f, 0.01485059f, 0.09264848f, 0.07885907f, 0.05932890f, 0.12341823f, 
    -0.05496598f, 0.01426111f, -0.03387930f, 0.04128717f, -0.01756377f, 0.20240426f, -0.05674600f, 0.05817875f, 
    -0.11001012f, -0.03903347f, -0.09918237f, 0.19231585f, -0.06320792f, 0.27963763f, -0.17558742f, 0.01341500f, 
    -0.11270677f, 0.08114757f, -0.03726072f, 0.11239845f, 0.14160939f, -0.01344492f, 0.11599667f, 0.18540879f, 
    0.09669279f, -0.01844482f, -0.08114852f, 0.04374006f, -0.02855990f, -0.22747734f, -0.08492512f, 0.02227686f, 
    -0.20481877f, -0.03868134f, -0.08194739f, -0.01968248f, 0.04716377f, 0.05068213f, -0.08088154f, -0.05215558f, 
    -0.01056574f, 0.14342932f, -0.05496622f, 0.05903335f, -0.24313709f, -0.05830012f, 0.05842356f, 0.07545573f, 
    -0.11479070f, 0.05495464f, 0.18460713f, 0.04097290f, 0.02557834f, -0.07177044f, -0.04946559f, 0.10318161f, 
    -0.14898124f, 0.11570286f, 0.08495928f, -0.05126312f, -0.03815097f, 0.08744515f, 0.01785869f, 0.10680899f, 
    0.11598859f, -0.02982955f, 0.00003067f, -0.07592256f, 0.07495145f, 0.15003994f, 0.31479943f, 0.09004971f, 
    0.09773723f, 0.07495851f, 0.01922146f, 0.06279308f, 0.02919739f, 0.05655508f, 0.12147988f, 0.02549914f, 
    0.24366769f, 0.27428532f, 0.01877097f, 0.07562100f, 0.05621613f, 0.05458933f, 0.09283092f, -0.05411625f, 
    0.01720770f, 0.02179219f, -0.03303071f, -0.15417832f, -0.03345409f, 0.04701355f, -0.08628548f, -0.08657709f, 
    -0.03944899f, -0.08104903f, 0.06741571f, 0.07396357f, -0.06587904f, 0.14350052f, 0.08563846f, 0.04534285f, 
    0.33602598f, 0.12836660f, 0.03207491f, 0.03439992f, 0.05233383f, -0.00500276f, 0.10811964f, -0.07662082f, 
    0.11289965f, 0.09337439f, -0.00860708f, 0.11851257f, -0.19548081f, 0.21954671f, -0.06206604f, -0.00688143f, 
    0.10766710f, 0.02649553f, 0.05744803f, 0.04601245f, 0.01828681f, 0.22844523f, -0.04361264f, 0.02271141f, 
    -0.03100663f, 0.08429776f, 0.03957095f, -0.11505008f, 0.07048447f, -0.00995357f, -0.03491497f, 0.07326286f, 
    0.03402922f, -0.13524078f, 0.00977289f, -0.06933539f, -0.10358696f, -0.05325153f, -0.11842227f, -0.09140045f, 
    0.02201791f, -0.05956106f, -0.12486564f, 0.07724372f, -0.06473500f, 0.05232741f, 0.03043650f, 0.00407461f, 
    0.18673337f, -0.08809946f, 0.03255319f, 0.19456023f, 0.08142097f, 0.07731558f, 0.19092584f, 0.06186381f, 
    -0.10920819f, 0.04414655f, -0.05331933f, 0.08751622f, 0.01944751f, 0.06021972f, -0.09813119f, -0.01691632f, 
    -0.10609559f, 0.13170947f, 0.00687840f, 0.04783360f, -0.03566899f, 0.00877614f, -0.02896815f, 0.12140909f, 
    -0.12629931f, -0.25342420f, 0.10370875f, -0.05765076f, -0.02190433f, 0.08785532f, 0.12590884f, 0.28889835f, 
    0.04325647f, 0.20311074f, 0.00521083f, 0.38748032f, 0.28981546f, 0.03641385f, 0.16562417f, 0.01498313f, 
    0.08114707f, 0.08661032f, 0.01475465f, 0.14866093f, -0.00774242f, 0.04809969f, 0.05870912f, 0.02653088f, 
    -0.16845986f, 0.05274198f, 0.11796004f, 0.08454006f, 0.05740809f, -0.02189307f, 0.07335651f, -0.00594073f, 
    -0.09839077f, 0.14927696f, 0.09511250f, 0.01372527f, -0.26712409f, 0.02484063f, 0.12790959f, 0.00962445f, 
    -0.04254058f, 0.00271241f, 0.04009699f, -0.07007051f, -0.16759066f, 0.14231110f, 0.13759749f, 0.07200857f, 
    -0.01443224f, -0.00107864f, 0.09727044f, -0.08658638f, -0.05648024f, -0.05056197f, 0.00341412f, -0.08045021f, 
    -0.01846720f, -0.06375310f, 0.11083169f, 0.19107056f, -0.00116276f, -0.13374600f, -0.06975070f, 0.02025775f, 
    -0.19300021f, 0.10711932f, 0.01263663f, 0.11026817f, -0.02291084f, 0.03656572f, -0.02385175f, -0.06647842f, 
    -0.19673099f, -0.04465494f, -0.05837159f, 0.06805719f, -0.07433826f, 0.04454347f, 0.04459888f, -0.07601657f, 
    -0.14006089f, -0.04959414f, 0.00435171f, -0.02807779f, -0.03565078f, -0.00490790f, -0.00757884f, -0.06722926f, 
    -0.00964447f, 0.07881361f, 0.10198046f, -0.12710549f, -0.05134029f, -0.12480817f, 0.13490686f, 0.09820974f, 
    -0.12251029f, -0.07576156f, -0.05530561f, -0.07099690f, 0.00665397f, 0.13487934f, 0.14165619f, 0.06177405f, 
    0.03158497f, 0.05368131f, 0.03816554f, 0.15542720f, -0.17912750f, 0.09289573f, -0.01523673f, 0.15737505f, 
    0.12184027f, -0.05145920f, 0.03223541f, 0.11604293f, 0.04694970f, 0.15289506f, -0.03790351f, -0.01712890f, 
    -0.36008456f, -0.04533786f, -0.00257130f, -0.01460756f, 0.04095184f, -0.03296709f, 0.00022232f, 0.09169949f, 
    0.00478883f, 0.16767886f, 0.01010894f, -0.16169366f, 0.17460747f, 0.12254589f, 0.08327127f, 0.16906288f, 
    -0.02480784f, -0.01106009f, 0.12258183f, -0.03672723f, -0.03507545f, -0.04969930f, -0.07960398f, 0.05920924f, 
    0.39525852f, 0.06314573f, -0.13167553f, -0.00159904f, -0.05161802f, 0.10476320f, -0.11060036f, 0.10677394f, 
    0.07710002f, -0.04621160f, 0.06208650f, 0.20521326f, -0.03086368f, 0.05023614f, -0.03260542f, -0.04396658f, 
    0.04735165f, -0.02917933f, -0.04098598f, -0.10163690f, 0.01643320f, -0.02621066f, -0.04172333f, -0.00830921f, 
    -0.09625546f, -0.04029166f, 0.02723509f, -0.02231078f, 0.09001161f, -0.00642959f, 0.09236576f, 0.04294901f, 
    0.06740189f, -0.05141268f, -0.12847757f, 0.08951695f, -0.26606056f, -0.09898545f, -0.01467256f, -0.12921064f, 
    0.03783959f, -0.01365228f, 0.09591930f, 0.18046190f, 0.07683636f, 0.06299350f, 0.13834986f, 0.10206728f, 
    -0.26340887f, -0.02575452f, -0.03563482f, -0.07540987f, -0.05929769f, 0.04994597f, -0.08408500f, 0.01334155f, 
    0.02087658f, -0.04088236f, 0.15825728f, -0.09140627f, -0.31790921f, -0.17018226f, -0.03143554f, 0.05727923f, 
    0.03953369f, 0.12529810f, 0.04608082f, 0.04780134f, 0.03649025f, 0.12785496f, -0.06884383f, 0.07435229f, 
    -0.14126350f, -0.07163478f, 0.01546494f, -0.06710358f, -0.06762861f, -0.08629864f, 0.03791005f, 0.03569747f, 
    -0.04940983f, -0.09635401f, -0.09886196f, -0.08420759f, -0.20156479f, 0.00318359f, 0.04794429f, 0.00946717f, 
    -0.02652190f, -0.08065291f, -0.01942110f, 0.04534132f, 0.12113700f, 0.20586878f, 0.08387306f, 0.09817416f, 
    -0.11431605f, 0.00087253f, 0.07816716f, -0.15860811f, -0.06436229f, -0.20453109f, 0.01484830f, 0.05642741f, 
    0.03468045f, 0.10352725f, -0.15368086f, -0.01260018f, -0.00522276f, 0.29565760f, 0.03186829f, 0.09213092f, 
    0.09566829f, -0.01666711f, 0.00768566f, 0.05639947f, -0.02151594f, -0.01375054f, 0.07511122f, -0.08965256f, 
    0.06806792f, -0.10699265f, -0.01938944f, 0.03735266f, 0.00153016f, 0.09211948f, 0.16076754f, 0.02067155f, 
    0.05634569f, 0.08094199f, 0.13484031f, 0.04198536f, 0.45927039f, 0.20261952f, 0.08603711f, 0.08162966f, 
    0.02920818f, -0.03483260f, 0.14673014f, 0.03663037f, -0.12414506f, -0.05080234f, -0.06467738f, -0.01972694f, 
    0.46003887f, 0.05363089f, 0.07352227f, 0.19190365f, 0.01731627f, 0.07133371f, 0.02281011f, 0.17999452f, 
    -0.02986348f, -0.09198304f, -0.13893153f, 0.00896939f, -0.23161981f, -0.01468325f, -0.14922635f, -0.07950818f, 
    -0.08846497f, 0.08892868f, 0.04151964f, 0.08007748f, -0.09223981f, 0.03072751f, 0.00892064f, 0.04619510f, 
    0.25234053f, 0.01336584f, 0.10047697f, 0.01860422f, 0.07937429f, 0.00183031f, -0.03944634f, -0.13270470f, 
    -0.04563393f, 0.04189724f, 0.23216206f, -0.03863215f, -0.02468016f, 0.03584130f, 0.06081018f, 0.21680775f, 
    -0.04256028f, 0.19083141f, -0.04273396f, 0.13876407f, 0.09622201f, -0.12398736f, 0.06076302f, -0.10284170f, 
    0.20449752f, 0.00700744f, 0.10161524f, 0.15575659f, 0.04461901f, -0.02712095f, 0.18713880f, -0.01331748f, 
    -0.01545294f, 0.04979159f, 0.12740825f, 0.06532812f, 0.09151511f, 0.06611204f, 0.08896215f, 0.04015937f, 
    0.08935788f, 0.14395711f, 0.02567397f, -0.00635849f, -0.07733630f, 0.01657215f, 0.15852730f, 0.05283942f, 
    -0.00360742f, -0.04288778f, -0.03172098f, 0.00485688f, 0.14001751f, -0.08899575f, 0.17900230f, 0.04806351f, 
    0.18325168f, -0.02857515f, -0.11025085f, -0.28197619f, 0.14856088f, 0.16894396f, -0.09663177f, 0.01141619f, 
    0.04736275f, -0.08466285f, 0.09986894f, 0.05149118f, 0.06962866f, 0.12352031f, -0.06190243f, 0.13114218f, 
    0.19633134f, -0.20422274f, -0.01223785f, 0.11233838f, -0.05649480f, 0.16481158f, -0.00641102f, -0.02284448f, 
    -0.03131673f, 0.08369200f, 0.25193638f, 0.11435337f, 0.01573403f, -0.13097818f, 0.00507359f, -0.06846667f, 
    0.02727528f, 0.07345789f, -0.02273658f, 0.03823499f, 0.02398822f, 0.14433283f, -0.11265720f, -0.14374472f, 
    0.46202424f, 0.10474307f, -0.03837596f, 0.00789717f, -0.09860584f, 0.00325644f, 0.12724769f, -0.13820173f, 
    0.02965627f, 0.07036494f, -0.03125598f, -0.03703061f, 0.15094042f, 0.02152412f, -0.12550220f, 0.03632458f, 
    0.01860091f, 0.05517703f, 0.07193498f, -0.13861753f, -0.02356226f, 0.01435609f, -0.14563319f, 0.00941446f, 
    0.23701796f, 0.05687423f, -0.12386826f, -0.04733650f, -0.04799309f, -0.04072016f, -0.02313730f, 0.09307684f, 
    0.07408138f, -0.07554614f, -0.03311926f, -0.17454767f, 0.10029939f, 0.02071578f, 0.06782413f, -0.00165906f, 
    0.03434838f, -0.01628507f, 0.07383037f, -0.04484142f, -0.09543844f, 0.11012293f, 0.03593332f, 0.07891465f, 
    -0.03087514f, 0.06893843f, 0.02031305f, -0.01943737f, -0.06324171f, -0.05783614f, -0.06985699f, -0.04256068f, 
    0.05314797f, -0.08750654f, -0.07151029f, -0.04993141f, 0.21059422f, -0.04979193f, 0.02255945f, -0.07870886f, 
    0.05928794f, -0.16901216f, 0.02088845f, 0.00524581f, -0.13517644f, 0.03682638f, -0.10086892f, 0.09009919f, 
    -0.08820922f, -0.14132275f, 0.04201500f, 0.12051944f, 0.03583184f, 0.02674731f, 0.04091785f, -0.03347235f, 
    0.02352551f, 0.02095583f, -0.01983995f, -0.04486220f, 0.22938523f, 0.16057020f, -0.16920251f, 0.04037514f, 
    0.02965624f, 0.05447203f, -0.00734969f, -0.01462202f, 0.05004377f, -0.02359009f, 0.01276169f, 0.03578490f, 
    0.13902992f, -0.04868068f, -0.09943001f, -0.00766278f, 0.05094132f, -0.05179451f, 0.03155191f, 0.05799537f, 
    -0.10920097f, 0.03098119f, -0.04093171f, -0.07265349f, -0.01294665f, 0.16129464f, -0.01991463f, 0.15392630f, 
    -0.12680948f, -0.01153893f, 0.01076223f, 0.03447017f, -0.02139022f, 0.09535392f, 0.22916259f, -0.07305022f, 
    0.19351193f, 0.11203614f, -0.08611051f, 0.05143978f, -0.02921213f, 0.01216424f, 0.05301224f, -0.00567760f, 
    -0.09052498f, -0.10647434f, -0.06253997f, -0.18228872f, -0.19985771f, 0.03506734f, 0.01809834f, 0.09214817f, 
    -0.07712957f, -0.06142955f, 0.03335691f, -0.08473184f, -0.13425815f, 0.10432154f, 0.04710699f, 0.03324503f, 
    -0.17290603f, 0.04327317f, -0.07503718f, 0.06394422f, -0.07154139f, -0.12425294f, -0.06724815f, 0.10463373f, 
    0.01166588f, -0.11518377f, 0.09093329f, -0.09006316f, -0.19147508f, -0.20023715f, -0.07410997f, -0.02679644f, 
    -0.09677660f, 0.03787196f, 0.11353493f, -0.02819152f, -0.09183587f, -0.02401937f, 0.00702531f, -0.00910844f, 
    -0.03920192f, -0.04792868f, 0.01124034f, 0.04464241f, -0.02491677f, -0.00245370f, -0.01982345f, -0.08579621f, 
    0.05404260f, -0.03911469f, -0.21016206f, -0.03787455f, -0.06532115f, 0.09819347f, -0.19940563f, -0.01826003f, 
    -0.02653328f, -0.06560687f, -0.02064546f, -0.04132552f, 0.01305225f, 0.18086314f, -0.06871832f, -0.00867333f, 
    0.19645748f, 0.11884023f, 0.06518757f, -0.04296577f, -0.07545806f, 0.02467464f, -0.12031218f, 0.11782476f, 
    -0.05722850f, -0.00191113f, 0.15845688f, 0.01921988f, -0.39137697f, -0.07038541f, 0.00627398f, -0.01843695f, 
    -0.05871698f, -0.02736513f, -0.00555832f, 0.16343844f, -0.07440820f, -0.11219206f, -0.06531028f, 0.05211414f, 
    0.46328437f, 0.20652953f, 0.04646779f, -0.18785390f, -0.10284682f, -0.04760610f, -0.01937752f, -0.03738447f, 
    -0.03326375f, 0.07694685f, -0.09708219f, 0.08514345f, 0.05365386f, 0.05505388f, 0.00444755f, 0.04473798f, 
    -0.03011695f, 0.02442604f, 0.03617335f, -0.06286038f, -0.02460065f, -0.08461317f, -0.01288024f, 0.02700718f, 
    0.48615843f, -0.00751951f, 0.17847975f, 0.00018254f, -0.11165775f, 0.07195670f, 0.06517269f, 0.03904635f, 
    0.08104504f, -0.03654290f, 0.03555067f, -0.01128831f, 0.09513211f, -0.10131246f, -0.07387073f, 0.03638845f, 
    -0.07086366f, 0.12343870f, -0.04292578f, 0.03922911f, 0.00901474f, -0.02624687f, 0.07873330f, -0.13628453f, 
    -0.32877752f, 0.01194620f, -0.20561369f, 0.00088928f, -0.16903438f, 0.01826473f, 0.01456424f, -0.04509816f, 
    -0.01462470f, 0.01787179f, -0.04379495f, -0.13653484f, 0.13663548f, 0.11005849f, -0.06229296f, -0.10801312f, 
    0.04144458f, -0.05341954f, 0.02955416f, 0.08255674f, 0.03019462f, 0.12740587f, 0.08177287f, 0.06508317f, 
    0.04375719f, 0.17309801f, -0.03327351f, 0.12570809f, -0.02155811f, -0.06993236f, -0.02429517f, -0.08966481f, 
    0.07998046f, 0.00350648f, -0.01737423f, 0.04347789f, 0.03311240f, 0.10094405f, -0.06896284f, 0.04907221f, 
    0.00989168f, -0.12358028f, -0.06426694f, 0.00701518f, -0.02069832f, 0.09958760f, 0.08973339f, -0.02741723f, 
    0.39134380f, -0.09847718f, -0.09752977f, -0.01221245f, -0.06111427f, -0.02419855f, -0.04716898f, -0.05273892f, 
    -0.08595315f, -0.11324044f, -0.00800963f, -0.09281260f, 0.50819921f, 0.03181216f, -0.16243684f, -0.21187386f, 
    -0.04088372f, -0.01026593f, -0.00141693f, -0.03684453f, -0.10021611f, 0.09874348f, -0.10100220f, -0.09125516f, 
    0.28810558f, 0.11369072f, -0.01938201f, -0.13688937f, -0.14905117f, -0.06437017f, 0.13058205f, 0.04212539f, 
    -0.07791577f, -0.02363018f, 0.02320539f, 0.05649950f, 0.23859668f, 0.12076595f, -0.04850617f, 0.14124008f, 
    0.01805845f, 0.09671887f, -0.14403905f, 0.08310357f, -0.01367390f, 0.03643155f, 0.15825896f, -0.02351779f, 
    0.12524053f, -0.10211746f, 0.09052474f, -0.01133951f, 0.16083534f, 0.18182965f, 0.04483875f, 0.19176902f, 
    0.09032304f, 0.14511991f, 0.11814168f, 0.26556107f, 0.11323949f, 0.13238843f, 0.16380964f, 0.12152664f, 
    0.00151928f, 0.12114257f, -0.01832998f, 0.03003381f, 0.03072860f, 0.10653562f, 0.10809078f, 0.10076211f, 
    0.16902323f, -0.20268586f, 0.09477162f, -0.03576313f, 0.09501724f, -0.00928999f, 0.02478438f, -0.01569825f, 
    -0.08008035f, 0.21511479f, 0.05350126f, -0.10693032f, 0.01274313f, 0.14869609f, 0.09422839f, -0.14919156f, 
    0.08046588f, 0.07075106f, -0.02930260f, -0.03035579f, 0.00726535f, -0.07153348f, 0.13034558f, 0.05071359f, 
    0.15496476f, 0.02900573f, -0.00701149f, -0.07122416f, 0.01131808f, -0.02973545f, 0.06813965f, -0.07723995f, 
    0.09694117f, -0.12169463f, -0.03715232f, 0.09385984f, 0.21564408f, 0.17041473f, -0.06559031f, 0.18943927f, 
    0.04066448f, -0.01432242f, 0.00883083f, 0.12883310f, 0.00003637f, 0.02252531f, -0.13312700f, -0.10302299f, 
    0.06581835f, -0.17113324f, -0.13809343f, -0.01314906f, -0.08047377f, -0.06721289f, 0.07644819f, -0.13534003f, 
    -0.05960497f, 0.00942892f, 0.09816912f, -0.14286014f, -0.08238114f, 0.17154787f, -0.04959935f, 0.11414301f, 
    0.12060677f, -0.07039481f, -0.00310609f, -0.07135093f, 0.01532819f, -0.07281896f, 0.03808195f, 0.05801058f, 
    -0.03472335f, -0.03682612f, -0.05912976f, -0.03878314f, 0.13326837f, 0.08120924f, 0.12654264f, 0.03660185f, 
    -0.01126128f, 0.01645801f, -0.02093740f, 0.13598947f, 0.08263958f, -0.06253923f, -0.00224180f, 0.05962582f, 
    -0.02456570f, 0.00201144f, 0.07096103f, 0.02181989f, -0.07036172f, 0.20690174f, 0.05531948f, -0.09139886f, 
    0.37456408f, 0.31007358f, -0.01359504f, -0.08921030f, 0.03892019f, -0.17462228f, -0.04848572f, 0.07356467f, 
    -0.07663575f, 0.06599464f, -0.04992973f, -0.15974823f, -0.00944928f, 0.08215231f, -0.00337931f, 0.07951242f, 
    -0.15674333f, 0.14118476f, 0.12593736f, 0.01164678f, 0.03956191f, -0.07796936f, -0.19283673f, 0.00688138f, 
    0.11965895f, -0.00263789f, 0.09693567f, -0.02313037f, -0.00241360f, 0.11878563f, -0.03320398f, 0.06061435f, 
    0.12753206f, -0.08623473f, 0.02537264f, 0.17004475f, 0.05235496f, -0.07067741f, 0.04890033f, -0.14900522f, 
    -0.07248893f, -0.06904869f, 0.07819118f, 0.01113394f, -0.08811560f, -0.07317780f, -0.17239301f, 0.01673723f, 
    0.07148992f, -0.07698059f, 0.13874164f, -0.08352543f, 0.10208837f, 0.04742263f, 0.07711037f, -0.00779694f, 
    0.02579157f, 0.03820322f, 0.10631964f, -0.09435490f, -0.12833329f, 0.03745547f, 0.04911024f, -0.08283642f, 
    -0.02232518f, -0.01327700f, 0.06952558f, 0.11096907f, 0.18983904f, 0.12854864f, 0.11887419f, 0.02298319f, 
    -0.01197531f, 0.22496174f, 0.04334725f, 0.10937042f, -0.11967929f, 0.04722703f, -0.00701916f, 0.10131010f, 
    0.05397469f, -0.08318563f, 0.04694683f, -0.17810534f, 0.10360073f, -0.13071169f, 0.11706579f, -0.12147156f, 
    0.12789851f, 0.02228177f, 0.10588871f, 0.07171799f, -0.06834257f, 0.04688754f, -0.06826763f, -0.02184945f, 
    0.20765892f, 0.14169809f, -0.12364218f, -0.07584365f, -0.08145632f, 0.01383826f, 0.05022353f, -0.02871096f, 
    -0.02926536f, 0.00333585f, -0.07063662f, -0.07523955f, -0.00367722f, -0.06292655f, -0.07748459f, 0.04040047f, 
    -0.09520473f, -0.00382787f, -0.01687831f, -0.03790973f, 0.06395484f, 0.12920213f, 0.15605488f, -0.07289604f, 
    0.22562376f, 0.10766258f, -0.22512195f, 0.01734396f, -0.06444576f, -0.05855143f, 0.10149080f, -0.03351465f, 
    -0.00016349f, -0.02611671f, -0.13549672f, -0.01127227f, -0.11781428f, -0.09530302f, -0.04124876f, 0.01810263f, 
    -0.01184061f, 0.07237259f, -0.13083155f, -0.02324660f, -0.04342181f, 0.00334371f, -0.00733185f, -0.08955507f, 
    0.08217140f, -0.10887121f, 0.01548135f, -0.05188276f, 0.12006114f, 0.10102553f, 0.14509040f, 0.10022245f, 
    0.08559696f, 0.10908812f, 0.09687304f, -0.12258271f, 0.16829306f, 0.04151595f, -0.07560650f, -0.11013575f, 
    0.02550518f, -0.08436159f, 0.03541509f, 0.10005935f, -0.10529841f, -0.11941417f, 0.00926364f, -0.03120089f, 
    0.00818499f, -0.01478890f, 0.11643308f, -0.06194206f, -0.11593626f, 0.09188450f, -0.01190758f, 0.03957792f, 
    0.06883568f, -0.18723649f, -0.08189822f, 0.00842664f, 0.05761038f, 0.27202439f, -0.04619249f, 0.20925975f, 
    -0.08592591f, 0.06846102f, -0.04047143f, -0.00340211f, -0.03296567f, 0.08945352f, -0.02479404f, -0.05460034f, 
    0.01520601f, 0.04438881f, 0.13535278f, 0.07833099f, -0.05343694f, -0.04872869f, -0.13006707f, -0.02713350f, 
    0.05592607f, 0.05748844f, 0.12578368f, -0.03169816f, 0.14170907f, 0.21702021f, -0.04244895f, -0.03988909f, 
    -0.01093036f, -0.08194562f, -0.02824512f, 0.11809385f, -0.16146523f, -0.05869741f, 0.03244159f, -0.00521354f, 
    0.07987048f, 0.10410349f, -0.02040039f, 0.07053529f, -0.13244587f, -0.06292935f, 0.00966397f, -0.00311667f, 
    0.06660466f, 0.00957216f, 0.15225586f, -0.04112225f, 0.26192975f, 0.22144862f, 0.01712568f, 0.03913114f, 
    0.16069883f, 0.00932676f, 0.03017170f, 0.02863369f, -0.03618201f, 0.06602182f, 0.04838397f, 0.10643099f, 
    0.25260997f, -0.04136513f, 0.06512635f, -0.01461822f, 0.02002444f, -0.07197229f, 0.11690276f, -0.06195659f, 
    -0.00540934f, -0.08520617f, -0.08152384f, -0.10400625f, 0.25366196f, 0.15155338f, 0.03917160f, 0.00977445f, 
    0.07661779f, -0.03607354f, 0.08192740f, 0.08972797f, -0.00518917f, 0.04437351f, -0.06205549f, 0.09680817f, 
    -0.03941621f, 0.01839304f, -0.00039740f, 0.02212556f, -0.03504701f, 0.00465643f, 0.02816831f, -0.03460440f, 
    0.00510889f, -0.03963154f, 0.02009152f, -0.02857691f, -0.00448298f, 0.00155033f, -0.02981962f, 0.01979406f, 
    0.01794343f, -0.00985037f, -0.01719313f, -0.01353117f, 0.02454468f, -0.03053148f, -0.02971121f, -0.02111238f, 
    -0.02227948f, -0.04216745f, -0.03010399f, -0.02514966f, -0.03559869f, -0.00956165f, 0.01490256f, -0.03222053f, 
    -0.00577045f, -0.02509594f, -0.01782708f, -0.01819500f, -0.01257506f, 0.00732687f, -0.03052245f, -0.00221466f, 
    0.00208413f, 0.02687373f, 0.00214014f, 0.00915999f, -0.01844621f, 0.01175756f, -0.02784811f, -0.00466049f, 
    0.01878333f, 0.01440756f, 0.00388920f, -0.00432764f, 0.00914437f, 0.02992856f, -0.00902489f, 0.00390867f, 
    -0.01689052f, -0.01853321f, -0.03193842f, 0.00079939f, 0.00556133f, 0.02650978f, 0.01770734f, 0.00072931f, 
    -0.02280124f, -0.03094302f, -0.00765656f, 0.02064295f, 0.02936950f, -0.00937231f, -0.03852662f, 0.01154018f, 
    -0.01795765f, 0.02339237f, 0.02786630f, 0.02124200f, -0.01925892f, -0.00916213f, -0.04082538f, -0.03330826f, 
    0.02766361f, -0.02157722f, 0.00520854f, -0.01662278f, 0.00156867f, 0.01290475f, -0.01805123f, -0.03512934f, 
    -0.03546859f, -0.00913420f, 0.01885257f, -0.03580774f, 0.00040242f, 0.01379320f, 0.02355625f, 0.00942789f, 
    -0.02482651f, 0.01725139f, -0.03074027f, 0.02029837f, -0.02410299f, 0.01749383f, 0.00010465f, 0.00422040f, 
    0.02412296f, -0.04084827f, -0.01577165f, 0.01984886f, 0.01667787f, -0.00684522f, -0.01542986f, 0.00463785f, 
    -0.03910239f, -0.00019350f, 0.02158253f, -0.04181018f, 0.00499350f, -0.01515847f, 0.00064766f, -0.03908624f, 
    0.01732343f, -0.00836672f, -0.04192634f, -0.01010974f, -0.00252605f, -0.01046015f, -0.02206806f, 0.02160301f, 
    -0.02660842f, -0.04112302f, 0.00680794f, -0.02239132f, 0.00270560f, 0.01383068f, 0.01246539f, -0.00189749f, 
    -0.01281628f, -0.00069752f, 0.01811024f, -0.00715071f, 0.01898143f, 0.00464936f, -0.01767012f, -0.04037966f, 
    0.02610723f, -0.01231044f, 0.02076267f, 0.01683263f, -0.01537151f, -0.01483470f, -0.02711368f, -0.02354486f, 
    -0.03658866f, -0.03379123f, 0.01583475f, 0.00532744f, 0.00244621f, -0.00733672f, -0.00997725f, 0.01608258f, 
    0.02440780f, 0.02673737f, -0.00090694f, 0.00955328f, -0.01194157f, 0.00226461f, -0.01752677f, -0.01242922f, 
    0.00431648f, 0.01030167f, 0.00917989f, 0.01150641f, -0.03901704f, 0.00891639f, -0.00923511f, 0.02457431f, 
    0.00616341f, 0.02325200f, -0.01491338f, -0.02857436f, 0.00243887f, -0.01822453f, 0.00411044f, 0.02261579f, 
    -0.03939796f, 0.01151109f, -0.00417847f, 0.01946342f, 0.01077522f, -0.03966483f, -0.02245320f, 0.02143940f, 
    -0.00383297f, 0.01596898f, 0.00298143f, 0.00103964f, -0.01736673f, 0.01354928f, 0.02185746f, -0.03925033f, 
    0.02432261f, -0.00719249f, 0.01229902f, 0.01122260f, 0.01612518f, -0.02196403f, -0.02617033f, 0.02352713f, 
    0.01343332f, -0.00750711f, -0.02284374f, 0.00335053f, 0.00433868f, -0.01208607f, -0.00420017f, -0.02607452f, 
    0.00428229f, 0.01085853f, -0.00139545f, -0.02463474f, -0.02740737f, -0.03654830f, 0.01778101f, 0.01607898f, 
    0.00140759f, 0.01120525f, -0.01269604f, -0.04190065f, 0.02521834f, -0.04119474f, 0.01968229f, -0.03023955f, 
    -0.00981305f, -0.01199602f, -0.03190910f, -0.03754576f, -0.04185303f, -0.02666514f, -0.01406648f, -0.04110901f, 
    0.02621410f, -0.00883918f, -0.01657874f, 0.02820057f, -0.00086882f, 0.01522809f, -0.01060542f, -0.02927138f, 
    -0.01448438f, 0.02327276f, -0.01268559f, -0.02009744f, -0.01003156f, 0.00319656f, 0.02881378f, 0.00183248f, 
    -0.01362790f, -0.02532578f, -0.02353785f, 0.01273837f, 0.00168209f, -0.02552993f, 0.01600919f, -0.03319789f, 
    0.00987497f, 0.01250653f, -0.01573570f, -0.02689730f, 0.02433785f, 0.00316037f, -0.00266743f, 0.01336216f, 
    0.02405336f, 0.02816299f, -0.01099660f, -0.03112690f, -0.00108077f, 0.01031777f, -0.02566881f, -0.03208975f, 
    -0.03549808f, 0.00468718f, 0.01375435f, -0.03324616f, -0.01171016f, -0.02819448f, -0.01763745f, -0.01651642f, 
    -0.00308186f, 0.02558852f, -0.01208973f, -0.01927617f, 0.01131342f, -0.00065375f, 0.02733110f, -0.03324522f, 
    -0.00400802f, 0.00210327f, 0.02285128f, -0.03915635f, 0.01518785f, -0.03621471f, -0.01627215f, -0.00519354f, 
    0.03078514f, 0.00632961f, -0.01930957f, -0.00149254f, -0.00049297f, 0.00252765f, 0.01852337f, -0.03542461f, 
    -0.02043993f, 0.01392122f, 0.01822866f, -0.03178476f, -0.02090842f, -0.03565513f, -0.02012230f, 0.02822963f, 
    -0.03173662f, -0.01936825f, 0.02165554f, 0.02817468f, -0.03350956f, 0.00831651f, 0.01275035f, 0.03170084f, 
    -0.00597583f, -0.02875360f, -0.03228137f, -0.03250081f, -0.02105674f, -0.03010014f, 0.00173997f, -0.00748709f, 
    -0.01688485f, -0.02083147f, -0.02811828f, 0.01953043f, 0.00866359f, -0.01576832f, -0.02190146f, 0.01388280f, 
    0.02354841f, 0.01226198f, -0.00191946f, -0.03324231f, -0.03172759f, -0.02998697f, -0.00227626f, 0.00843344f, 
    0.01375259f, -0.02638089f, 0.00665284f, 0.02745428f, -0.03164568f, 0.01829659f, 0.02783626f, -0.01848061f, 
    -0.01637102f, 0.00292594f, -0.03430360f, 0.02403308f, 0.00828863f, -0.04229495f, -0.01488163f, 0.02342704f, 
    -0.01344686f, -0.03572841f, -0.01146106f, -0.01608455f, -0.04172586f, -0.02508054f, -0.04126035f, 0.01487625f, 
    -0.00644231f, 0.02642920f, -0.00884937f, 0.00809147f, -0.02445226f, 0.00913319f, -0.03485477f, 0.02110585f, 
    -0.03804469f, 0.00053525f, -0.03428179f, -0.03179724f, -0.02552780f, -0.00502272f, 0.01865857f, -0.01822724f, 
    0.01682376f, 0.01105148f, -0.03780709f, 0.01501422f, -0.01347671f, 0.02332084f, 0.01214651f, -0.02093503f, 
    -0.02063454f, 0.00335823f, -0.03277943f, 0.02074090f, -0.00598333f, -0.03035178f, -0.01283266f, -0.01492550f, 
    -0.03279009f, -0.03954198f, -0.00609433f, -0.03244521f, 0.02605032f, -0.02687097f, -0.01498174f, -0.02956161f, 
    -0.02047284f, -0.02539474f, 0.00301098f, 0.02027362f, 0.00070036f, 0.00060235f, 0.00621574f, -0.03334327f, 
    -0.01854951f, 0.00084557f, -0.03395629f, -0.02010874f, 0.00269798f, 0.01553094f, 0.02011941f, 0.01424318f, 
    0.01409153f, 0.00453074f, -0.04077703f, 0.02697630f, 0.00743348f, 0.01516999f, -0.03767592f, -0.01654331f, 
    -0.01988250f, -0.02824007f, -0.00632783f, -0.03909826f, -0.01492754f, -0.03567959f, 0.02290697f, -0.01127809f, 
    -0.02351512f, 0.00324402f, 0.00313886f, -0.02236763f, 0.01136713f, 0.01174729f, -0.03677909f, 0.01480292f, 
    -0.01720410f, 0.00899143f, 0.00510035f, 0.02925779f, -0.01957240f, -0.01242107f, 0.01492762f, 0.00675874f, 
    -0.03401447f, 0.01778604f, -0.03525981f, -0.01096886f, 0.01113053f, -0.03039333f, -0.00116127f, -0.02215210f, 
    -0.00587651f, 0.01334034f, -0.01787205f, 0.02709287f, 0.02446200f, -0.02508252f, -0.00581379f, -0.02496409f, 
    -0.00982288f, -0.03220820f, -0.00836070f, 0.01926627f, -0.01704914f, -0.00047643f, 0.02280674f, 0.02537257f, 
    0.02945800f, 0.02414928f, -0.00037497f, -0.03335551f, -0.02385852f, 0.01161507f, -0.01215611f, -0.03922024f, 
    -0.03907538f, 0.01609742f, 0.00017559f, -0.02099646f, -0.02263252f, -0.02618271f, -0.00493527f, -0.02724539f, 
    -0.02203809f, -0.03016555f, -0.00883580f, 0.00274758f, 0.00407778f, 0.01790162f, 0.00366155f, 0.00176648f, 
    -0.02842592f, 0.01080025f, -0.00074374f, -0.00345051f, -0.00268519f, 0.01326211f, 0.00807017f, 0.02223222f, 
    -0.02302746f, -0.00264199f, 0.02490919f, -0.02430791f, 0.00526212f, -0.01576242f, 0.01804915f, 0.02940593f, 
    -0.00093911f, -0.03892150f, -0.02828647f, -0.02614901f, -0.02003079f, -0.01423882f, -0.00104379f, -0.00789042f, 
    0.00166159f, -0.02911406f, -0.00012870f, -0.03417877f, -0.00118722f, 0.00940240f, 0.00630635f, -0.01554838f, 
    0.01381755f, 0.02290443f, 0.01603048f, -0.00433913f, -0.00297360f, 0.01137868f, -0.00433112f, -0.03459154f, 
    -0.04132298f, -0.00287440f, -0.03942603f, -0.02856890f, 0.00675332f, 0.01418806f, 0.00290950f, 0.01815549f, 
    0.01231061f, -0.03075662f, 0.01796008f, -0.02103430f, -0.00955291f, -0.03931699f, -0.03700716f, -0.02908796f, 
    -0.03982571f, -0.03986280f, -0.02491128f, -0.03734560f, -0.00478244f, -0.03483632f, -0.00112631f, 0.00320377f, 
    -0.02746133f, 0.01173415f, -0.03646487f, 0.02626102f, -0.04010510f, -0.02872015f, -0.01829994f, -0.03281582f, 
    0.00383144f, -0.02719760f, 0.02746892f, -0.00095786f, 0.01820579f, -0.03407366f, -0.01485281f, -0.01268922f, 
    -0.00129638f, 0.02317836f, 0.01775199f, -0.01188341f, 0.00511093f, -0.03939202f, -0.01329696f, -0.03792227f, 
    0.02358341f, -0.03907471f, -0.04265562f, 0.01135068f, 0.00610976f, -0.02367858f, -0.02204202f, 0.02662082f, 
    -0.02695555f, -0.00253312f, -0.03724274f, -0.01211660f, 0.01042697f, -0.02777298f, -0.02764064f, -0.00783556f, 
    0.00657376f, 0.01061269f, -0.01447457f, -0.01024980f, 0.02604382f, 0.00897190f, -0.03768936f, -0.01253905f, 
    0.02071632f, 0.02842096f, -0.01066578f, -0.01364931f, -0.02037100f, -0.01716114f, -0.01339921f, -0.02835797f, 
    0.00444459f, -0.00463263f, 0.01540693f, 0.01527038f, -0.02494118f, -0.04183445f, -0.01535440f, -0.00084202f, 
    -0.03423494f, -0.00514643f, -0.03030647f, 0.00316664f, 0.02377908f, 0.01919082f, -0.02802531f, 0.00440063f, 
    0.01100029f, -0.00945884f, 0.02222438f, -0.01360416f, -0.03814891f, -0.03971972f, -0.00435368f, -0.03342910f, 
    -0.01478775f, 0.01823826f, 0.01782033f, 0.02020801f, -0.03326863f, 0.01633289f, -0.03019615f, -0.02743078f, 
    -0.02012539f, -0.00426102f, -0.00353557f, -0.04066356f, -0.03535069f, -0.03955898f, 0.01952739f, -0.02233150f, 
    -0.01037471f, 0.02708014f, 0.00940286f, 0.02754770f, -0.00073728f, -0.02510180f, -0.00152346f, 0.00913148f, 
    -0.01672239f, 0.00194639f, -0.00553290f, 0.01282804f, -0.00026210f, -0.00240418f, -0.03455325f, -0.02445846f, 
    0.02002285f, -0.02760737f, 0.02430183f, -0.02222972f, -0.02536854f, -0.04017258f, -0.00399835f, 0.01212326f, 
    -0.03231562f, 0.01406778f, 0.02693624f, -0.00732255f, -0.03155340f, 0.01594680f, 0.00612402f, -0.00447902f, 
    0.01837051f, -0.03475208f, 0.01737835f, 0.02417048f, 0.00955570f, -0.01332846f, -0.03159187f, 0.02922674f, 
    -0.00273296f, -0.00200004f, -0.02803348f, -0.01439932f, -0.01309269f, 0.02703376f, -0.02097757f, -0.03032294f, 
    0.02475945f, 0.01088103f, -0.01796865f, 0.01917949f, -0.01510371f, -0.03090973f, 0.01810138f, -0.03264118f, 
    -0.03976976f, 0.02429186f, 0.01774588f, -0.00405948f, -0.01791216f, 0.00773064f, -0.02647752f, -0.04193768f, 
    -0.00936246f, 0.00216256f, -0.01503364f, 0.00988980f, 0.01186128f, 0.02136059f, -0.02432825f, 0.01413900f, 
    -0.02127459f, 0.00697824f, -0.00149607f, -0.02972288f, -0.03544534f, -0.01085411f, 0.00588285f, -0.04105220f, 
    0.02891457f, 0.00396278f, 0.02612689f, -0.03828710f, 0.02845873f, 0.02530699f, -0.00830764f, -0.03047906f, 
    0.02292827f, -0.01100249f, -0.00085983f, -0.02340452f, 0.01521461f, -0.03569669f, -0.03491591f, 0.00178192f, 
    0.00076861f, 0.02697338f, -0.03241269f, -0.03331449f, -0.02812115f, -0.00719791f, -0.03850720f, -0.02062846f, 
    -0.02735269f, -0.01356385f, -0.02258885f, 0.01929031f, 0.01216896f, -0.01580164f, 0.02917446f, -0.03374592f, 
    -0.01842862f, 0.01218691f, -0.03090063f, -0.03293556f, -0.03201270f, -0.00523434f, 0.01137345f, -0.02100776f, 
    0.00273001f, -0.00349594f, 0.00858580f, 0.01514778f, 0.01001481f, -0.02918182f, -0.03531003f, 0.02854929f, 
    -0.02005335f, 0.02827570f, 0.00016295f, -0.03386603f, -0.03072806f, 0.02722117f, -0.03237960f, 0.02273646f, 
    0.00734532f, -0.02936837f, 0.01424268f, -0.01994311f, -0.04059190f, 0.02033257f, 0.02686744f, 0.03026782f, 
    -0.02618293f, 0.00531141f, -0.03940726f, 0.01209201f, 0.00426129f, -0.02320769f, -0.02892883f, -0.01705762f, 
    0.00466584f, 0.00500342f, 0.03022861f, 0.01750327f, 0.00666601f, -0.00641522f, -0.03609853f, 0.02732813f, 
    0.02744838f, -0.01699847f, -0.03272374f, 0.00817440f, 0.01329719f, -0.01292951f, 0.02016464f, -0.01077405f, 
    -0.02555327f, -0.00691827f, -0.01837633f, -0.01500797f, 0.02922963f, -0.00266109f, -0.02036661f, -0.01898490f, 
    -0.00757485f, 0.02740912f, -0.01967519f, 0.01626940f, 0.01885651f, -0.00225738f, -0.02175888f, -0.01557328f, 
    -0.01530299f, 0.01420878f, 0.02159166f, -0.02142525f, 0.02367743f, 0.00038950f, -0.02671816f, 0.00428914f, 
    -0.00840729f, 0.02055252f, -0.02902942f, -0.00646486f, -0.03048374f, -0.00058436f, -0.01903918f, -0.02647458f, 
    -0.02286075f, -0.03584939f, 0.00109679f, -0.01934686f, 0.02801889f, 0.00294165f, -0.02054130f, -0.01989800f, 
    -0.01002883f, -0.01854325f, -0.03793956f, 0.00952520f, -0.02370294f, -0.02092944f, 0.00102708f, -0.00822488f, 
    0.02623494f, -0.02755245f, -0.01538536f, 0.02489590f, -0.00667512f, 0.02953291f, 0.01995330f, -0.02123301f, 
    -0.03236677f, -0.02098374f, -0.00978089f, -0.01581313f, -0.03492006f, -0.01982266f, -0.01592760f, 0.02490004f, 
    -0.04007617f, 0.01827451f, -0.01830514f, -0.02899761f, -0.03922391f, -0.01456634f, -0.00469399f, -0.03688979f, 
    -0.02696265f, 0.01590930f, -0.01963380f, 0.01121158f, -0.02699963f, 0.02140672f, -0.03651781f, 0.01687243f, 
    0.03025629f, -0.01032291f, 0.00284332f, -0.00948149f, 0.02475819f, -0.03894022f, -0.00598949f, -0.03167791f, 
    0.00259615f, -0.03774446f, -0.01836611f, 0.00399467f, -0.02984672f, -0.00807142f, -0.01244693f, 0.00845865f, 
    0.02419469f, 0.02954088f, -0.00940526f, -0.03800617f, -0.00371483f, -0.01137471f, 0.00310490f, -0.01345387f, 
    -0.00609535f, 0.01283763f, -0.03284625f, -0.03986530f, -0.00116235f, -0.01202733f, -0.03665772f, -0.03732121f, 
    -0.03935700f, 0.02525352f, -0.03902792f, -0.01348422f, -0.01600375f, -0.00977346f, -0.00709509f, -0.01539867f, 
    0.02132088f, -0.00829580f, -0.00564774f, 0.01875758f, -0.00219339f, -0.02109385f, -0.01771022f, 0.02069430f, 
    0.01331517f, -0.01488874f, -0.01570024f, -0.02650462f, -0.00101360f, -0.01975860f, -0.01409425f, 0.02392546f, 
    0.01646459f, 0.01848662f, 0.00273142f, -0.03479858f, -0.01528016f, -0.03038142f, 0.01674358f, 0.01011753f, 
    0.00800125f, -0.01495730f, 0.00555703f, -0.03994356f, -0.01425465f, 0.00168100f, -0.03979735f, -0.03174489f, 
    -0.03682773f, 0.01354020f, -0.01920419f, -0.03095229f, -0.04066171f, 0.00931907f, 0.02591573f, 0.01045397f, 
    -0.03761850f, -0.00963688f, -0.00577582f, 0.00142876f, 0.02662660f, -0.00530878f, 0.01084430f, 0.00560892f, 
    -0.02817484f, -0.01006784f, -0.03515461f, -0.04004655f, -0.02129873f, -0.03466330f, -0.01325424f, -0.04034859f, 
    -0.02918438f, -0.02959671f, -0.02551454f, 0.03024848f, -0.02752608f, 0.02360449f, -0.00094597f, -0.00095092f, 
    0.02388547f, -0.03397080f, 0.00431466f, -0.03619328f, -0.02834654f, -0.02433274f, 0.03166717f, -0.01015160f, 
    -0.03377778f, -0.01180884f, 0.03046790f, -0.03889002f, 0.00571204f, -0.01633977f, 0.02386895f, -0.00618534f, 
    -0.00261151f, 0.00584413f, 0.00430770f, 0.02687209f, -0.03552713f, 0.00194017f, -0.03865549f, -0.02732282f, 
    0.00228860f, -0.03694087f, -0.02498624f, 0.01133822f, -0.00657186f, 0.01538277f, 0.01327221f, 0.00690684f, 
    0.00900009f, 0.01094118f, -0.03745610f, -0.00705857f, 0.02796021f, 0.02011866f, -0.02692554f, 0.01087857f, 
    0.02201611f, -0.02117075f, 0.01041726f, -0.00821955f, -0.03109376f, -0.02578303f, 0.02274850f, 0.00605618f, 
    -0.01879137f, 0.01915325f, 0.00318239f, -0.01729715f, -0.01516753f, 0.01507406f, -0.01260246f, 0.01324874f, 
    -0.01172733f, -0.01231145f, 0.01906999f, 0.00467374f, -0.02637809f, -0.01229375f, -0.03804744f, -0.01113538f, 
    -0.02507405f, 0.00774816f, 0.00544874f, 0.00193568f, -0.02086085f, -0.01382470f, -0.02862194f, 0.00872682f, 
    -0.01255181f, -0.00739097f, 0.02918226f, -0.03678992f, -0.00299225f, 0.00202153f, 0.01790524f, -0.03617522f, 
    0.02262216f, 0.00207813f, 0.01403190f, -0.01112392f, -0.00144777f, -0.03619036f, 0.00757042f, -0.02217510f, 
    -0.03699131f, 0.02771826f, -0.00376355f, -0.01145022f, -0.01253164f, -0.00875219f, -0.00219290f, 0.00798533f, 
    0.02287676f, -0.02936523f, -0.02449257f, 0.02561469f, 0.00204636f, -0.03590982f, -0.00142370f, -0.01936332f, 
    0.02029991f, -0.00476031f, -0.00908924f, -0.01300958f, -0.00297403f, -0.00850280f, 0.03051790f, -0.02761645f, 
    -0.03578923f, 0.02881448f, -0.02522732f, -0.00969175f, -0.03334528f, -0.02369049f, -0.03383976f, -0.03619558f, 
    0.01780861f, 0.02235031f, -0.02413029f, -0.00070521f, -0.02453373f, -0.02789181f, 0.01350358f, -0.01598193f, 
    -0.00682610f, 0.01692571f, 0.02391301f, 0.01023401f, -0.01411326f, -0.02805296f, 0.00914689f, 0.00912078f, 
    -0.01881871f, 0.00753300f, -0.02202534f, 0.01469526f, -0.00686405f, -0.01688513f, 0.01926323f, 0.02672015f, 
    -0.02785940f, -0.03584052f, 0.00904346f, 0.00043108f, -0.01880028f, 0.00810299f, -0.03404433f, -0.00636112f, 
    -0.03294151f, -0.00537931f, -0.03206723f, 0.00651270f, 0.01042458f, 0.02245428f, -0.03211793f, 0.00318232f, 
    -0.03275215f, -0.02207457f, 0.01752570f, -0.01160797f, -0.00672744f, 0.00953553f, 0.02762695f, -0.04099727f, 
    0.02474445f, -0.01856892f, -0.01991523f, 0.01984621f, -0.03378101f, 0.00512103f, 0.00164561f, 0.02292943f, 
    0.02103489f, 0.01916783f, -0.02859444f, 0.02916841f, 0.02576258f, -0.00027013f, -0.00360106f, 0.00044526f, 
    -0.01346733f, -0.00671675f, -0.02509767f, -0.02213520f, 0.01268008f, -0.01244514f, -0.02157050f, -0.03245042f, 
    0.00041983f, 0.00700991f, 0.00645936f, -0.03463718f, 0.01629881f, 0.01154696f, -0.03892629f, 0.03334611f, 
    -0.03574817f, 0.01348715f, -0.01049112f, 0.01204624f, -0.03850780f, 0.02170152f, 0.02412480f, -0.02304859f, 
    0.01475522f, -0.01789358f, -0.02727452f, -0.01915382f, -0.03307123f, 0.00089093f, 0.02451129f, 0.01105271f, 
    0.02284183f, -0.02007706f, 0.00007210f, -0.03008787f, -0.03076672f, 0.02785426f, -0.03928933f, -0.01891799f, 
    -0.01349074f, 0.01332579f, 0.00776981f, -0.01107642f, 0.02996876f, 0.01169084f, -0.01502502f, 0.00716116f, 
    -0.00980937f, -0.01421869f, 0.00383236f, -0.03254538f, -0.03060202f, -0.00120699f, 0.01556407f, -0.00735407f, 
    -0.03932714f, -0.03662326f, -0.03410773f, -0.01517444f, 0.02092740f, 0.02083090f, -0.03176470f, -0.03657126f, 
    -0.02222163f, 0.00052149f, -0.03300924f, 0.01776043f, 0.00038265f, 0.00395410f, -0.03494373f, 0.03050356f, 
    -0.03703615f, 0.03114774f, -0.02456127f, 0.01748431f, -0.00941308f, 0.00655639f, 0.02959516f, 0.02435097f, 
    0.03003200f, -0.01866294f, 0.00061351f, -0.00874865f, -0.00544162f, -0.01169794f, 0.00635537f, -0.02385256f, 
    -0.00816069f, 0.00491844f, -0.02698284f, -0.02689464f, 0.01958326f, 0.00965320f, -0.01231697f, -0.00990953f, 
    0.01704651f, 0.01959615f, -0.01942408f, -0.00581095f, -0.02986302f, 0.02222001f, -0.03273399f, -0.01599063f, 
    0.03015969f, -0.00576532f, -0.00994481f, 0.01825302f, -0.02737253f, -0.00419951f, -0.00830212f, -0.00353299f, 
    0.02708358f, -0.02993342f, 0.01406624f, -0.03893967f, 0.01991834f, 0.01977503f, 0.02958408f, -0.00840301f, 
    0.00121670f, -0.00589244f, -0.03007993f, 0.00339423f, -0.01580073f, 0.01586467f, 0.02209952f, -0.01775976f, 
    -0.03217830f, 0.00995369f, -0.03819713f, 0.01361993f, 0.02629708f, -0.03672508f, -0.02038275f, 0.00490641f, 
    0.00395114f, -0.02476777f, -0.00088710f, -0.02315824f, 0.02296046f, -0.00740457f, -0.03871503f, 0.01534459f, 
    0.02195785f, 0.02279633f, 0.01544028f, 0.01580104f, -0.01445162f, 0.02929679f, -0.00956998f, 0.00354687f, 
    -0.01809137f, 0.02618271f, 0.02204874f, -0.02179459f, 0.00215151f, -0.02963292f, -0.00011089f, -0.01434099f, 
    -0.03996819f, 0.01288659f, -0.00675165f, 0.01163044f, -0.03657615f, -0.01400723f, -0.02487123f, 0.01408534f, 
    -0.02628167f, -0.02916823f, -0.00770718f, 0.03589596f, 0.01518822f, -0.01231769f, 0.02103183f, -0.03290379f, 
    0.02618789f, 0.03056613f, -0.01532950f, -0.03647572f, -0.02408027f, 0.02574383f, -0.00275556f, -0.03306827f, 
    -0.01887671f, -0.00454025f, -0.01835639f, -0.03644529f, 0.00159959f, -0.03740045f, -0.03006771f, -0.01482746f, 
    -0.03693108f, 0.02814186f, -0.01784827f, -0.00059717f, -0.00586555f, 0.01815251f, 0.00608139f, -0.01727317f, 
    -0.03927399f, 0.02401518f, -0.03612963f, 0.01141802f, -0.01225881f, -0.00950497f, 0.01742894f, 0.00005257f, 
    -0.02162691f, 0.02409467f, 0.03221136f, -0.01156534f, -0.01124017f, -0.01847146f, 0.01065040f, 0.02380721f, 
    -0.00676454f, 0.00257055f, -0.03577334f, -0.00332275f, -0.03400208f, 0.01545815f, 0.00854513f, -0.04001232f, 
    0.02213824f, -0.01168015f, 0.02515831f, -0.02244007f, 0.01784747f, -0.03625576f, 0.02963045f, 0.00745527f, 
    -0.01306447f, -0.01502885f, 0.03024753f, -0.01574770f, -0.02813625f, 0.02829536f, -0.02434233f, 0.01118555f, 
    -0.00443766f, -0.02075654f, -0.03033968f, 0.01054875f, 0.00908285f, -0.01754163f, -0.00119000f, 0.00483612f, 
    -0.02747599f, 0.01187907f, -0.01207287f, 0.02512239f, -0.02607721f, 0.02734377f, 0.02538400f, -0.00660854f, 
    -0.00423656f, 0.03014703f, -0.03502512f, -0.00887819f, 0.01904218f, 0.02610569f, -0.03129201f, 0.02948569f, 
    0.03034899f, 0.01392747f, -0.00449573f, -0.00925837f, 0.00090199f, -0.00340286f, -0.00766161f, -0.03603334f, 
    -0.03291890f, 0.01271696f, 0.00056161f, -0.01792029f, -0.00957094f, -0.04046062f, 0.00393450f, 0.01397444f, 
    -0.00371572f, 0.02009761f, 0.00927047f, -0.01476669f, 0.02076333f, 0.02942066f, -0.03585282f, -0.02456048f, 
    0.01048834f, -0.03101886f, -0.01241185f, -0.01235726f, -0.02626478f, 0.00905004f, -0.03723806f, 0.01718243f, 
    0.00867955f, -0.00507535f, -0.01160762f, 0.01202991f, 0.00011793f, -0.01632080f, 0.01059172f, -0.02081678f, 
    -0.01455870f, -0.02999281f, -0.03482692f, 0.00718490f, 0.02365268f, -0.01870954f, 0.02299207f, 0.01134488f, 
    0.01920452f, -0.00588970f, -0.00896893f, -0.03176975f, -0.03434391f, -0.03497276f, 0.01155074f, -0.02084383f, 
    0.02079097f, 0.00369938f, -0.01793702f, -0.02683279f, 0.00872705f, -0.00158686f, 0.00527927f, 0.02499875f, 
    -0.02620769f, 0.14345017f, 0.03857396f, 0.21173759f, -0.02880180f, 0.03289090f, 0.03172341f, 0.00789091f, 
    -0.04144156f, -0.03689731f, -0.09036518f, -0.06265231f, -0.02077488f, 0.00190141f, -0.10623305f, -0.07263881f, 
    0.15641332f, -0.06278313f, -0.12827669f, -0.01781535f, 0.16659869f, -0.08351545f, 0.00924076f, 0.00319418f, 
    -0.15310946f, 0.08705232f, -0.09994973f, -0.03943901f, -0.02429445f, -0.13385464f, 0.06648707f, 0.00320504f, 
    0.00701267f, 0.05036925f, 0.08031656f, 0.07451285f, 0.13222128f, 0.02917260f, 0.01388554f, 0.42867494f, 
    -0.04851675f, -0.11364771f, -0.01136745f, 0.00476064f, 0.04802897f, -0.06680588f, 0.02978962f, -0.09697577f, 
    -0.02088723f, -0.26220936f, -0.01581987f, 0.23541954f, 0.02014663f, 0.02509787f, -0.08599611f, -0.05343301f, 
    -0.10177154f, -0.07736406f, 0.02335071f, 0.16933049f, -0.02056297f, 0.21652499f, 0.01226875f, -0.18478605f, 
    0.15928775f, 0.00664507f, -0.00887043f, 0.07904246f, 0.20343770f, -0.01731536f, -0.02753671f, -0.04370100f, 
    -0.16958970f, -0.03704328f, 0.05106695f, 0.06129033f, 0.15079592f, 0.03657347f, 0.09595020f, 0.28167421f, 
    0.08942536f, 0.13406295f, -0.02248669f, -0.01747454f, 0.27665210f, -0.01750362f, 0.20067590f, -0.26205769f, 
    -0.07369066f, 0.06290765f, 0.05418464f, 0.05447106f, -0.05233127f, -0.13594314f, 0.04082023f, -0.06718703f, 
    -0.34092799f, -0.14857532f, 0.08010394f, -0.05976893f, -0.00550205f, -0.04013014f, 0.05997622f, -0.05760984f, 
    -0.02025064f, -0.02656153f, 0.00916749f, -0.08754916f, 0.30771416f, 0.01958598f, 0.12741219f, 0.39324617f, 
    -0.08206741f, -0.00065338f, 0.02040225f, 0.05542765f, 0.03260917f, -0.04862854f, 0.03187641f, -0.05543055f, 
    0.03056576f, 0.15739660f, 0.07588624f, 0.36578223f, -0.07258034f, 0.09703403f, 0.00592706f, -0.07098638f, 
    0.00939719f, -0.03786328f, -0.04387962f, 0.16480027f, 0.04726566f, 0.00444713f, 0.07619130f, -0.02074713f, 
    0.01379022f, 0.03395723f, 0.03921252f, -0.03116760f, 0.04174963f, 0.01773975f, -0.21745832f, -0.01928173f, 
    0.07765381f, -0.05564370f, 0.01964157f, 0.15399089f, -0.09871793f, 0.00970391f, -0.01679451f, 0.04564135f, 
    0.00539982f, 0.19205591f, 0.01295213f, 0.13235576f, 0.03733513f, -0.06453088f, -0.13961643f, -0.16194192f, 
    -0.03586078f, -0.03044580f, 0.02051566f, 0.10010532f, -0.10932977f, -0.08931883f, -0.03217995f, 0.03095624f, 
    -0.00761135f, -0.00914649f, 0.23791279f, 0.05720329f, 0.10055524f, 0.01989131f, 0.17678969f, 0.12904766f, 
    0.02893511f, 0.09827622f, -0.15546352f, 0.01682089f, -0.04212920f, -0.11105423f, 0.00943331f, -0.07793441f, 
    0.12185237f, -0.03563598f, -0.12397668f, -0.01316067f, -0.07003515f, 0.04346061f, 0.08120819f, -0.09467085f, 
    -0.18603048f, 0.02348729f, 0.06626964f, 0.06819865f, 0.14921275f, 0.01569247f, 0.07931846f, -0.05649693f, 
    -0.00727859f, 0.08315612f, -0.00654171f, 0.00908788f, 0.06432753f, -0.14954722f, -0.02803392f, -0.00174895f, 
    -0.02242964f, -0.03367553f, -0.02933831f, 0.04654006f, -0.03521271f, -0.18138777f, 0.07288431f, 0.00948965f, 
    0.08561071f, -0.08357804f, 0.00194533f, -0.16273201f, -0.02934065f, -0.19448197f, 0.09520543f, 0.05621828f, 
    0.01660812f, -0.04450044f, 0.03600217f, -0.10330115f, -0.27157670f, 0.09549125f, 0.04182314f, 0.12546067f, 
    -0.11276820f, -0.01037847f, 0.02013639f, -0.06395790f, 0.02292882f, 0.25091293f, 0.09967764f, 0.14718731f, 
    0.05239701f, -0.05351579f, 0.00708344f, 0.05933033f, 0.01916893f, -0.04802599f, 0.01549210f, 0.02979785f, 
    0.04130138f, -0.20027903f, 0.01576549f, -0.08367147f, -0.06148676f, -0.02447626f, 0.08233257f, 0.00291612f, 
    0.06400048f, -0.03993141f, -0.07769479f, -0.01820435f, -0.03352680f, 0.07569143f, 0.09695255f, -0.08254448f, 
    0.07007380f, -0.11463320f, 0.03546364f, -0.11785382f, 0.00457657f, -0.10667458f, 0.07426358f, 0.01662016f, 
    -0.12880613f, 0.07080222f, 0.00487252f, 0.04591009f, -0.11246853f, -0.33609664f, -0.07682579f, 0.10663208f, 
    -0.01324027f, -0.09320001f, -0.06889842f, -0.07189213f, 0.05086213f, -0.00309900f, -0.00551069f, 0.07296696f, 
    -0.13569818f, -0.08715297f, 0.04933752f, 0.23590991f, -0.12580971f, -0.10301689f, -0.04965501f, 0.06679172f, 
    -0.03013440f, -0.05500785f, -0.02254188f, 0.07598446f, 0.06043695f, -0.00502158f, 0.18297999f, -0.11402197f, 
    0.25001717f, 0.21481664f, 0.03901839f, 0.01047258f, 0.06562039f, -0.05661182f, -0.02741931f, -0.01834734f, 
    -0.08788329f, -0.09366064f, 0.13314313f, 0.12631683f, 0.08025136f, -0.04434072f, -0.00224403f, -0.03254221f, 
    0.04614936f, -0.09600582f, 0.04175570f, -0.05546078f, -0.17886481f, -0.09006805f, 0.10428459f, -0.11269483f, 
    0.02192411f, 0.00809302f, -0.00267691f, 0.03760932f, 0.01572021f, -0.04296732f, 0.05198468f, 0.04571384f, 
    -0.15327950f, -0.12077584f, 0.09141300f, 0.11279803f, -0.11945434f, 0.00976622f, 0.03870393f, 0.00085316f, 
    -0.05496501f, 0.09824904f, -0.04482485f, 0.09078041f, 0.25868711f, 0.21133530f, 0.16725884f, 0.16834086f, 
    -0.14106998f, 0.04818619f, 0.05988587f, -0.08294771f, -0.04625434f, -0.09454685f, -0.02272660f, 0.02911267f, 
    0.13133809f, 0.07018525f, -0.22390547f, 0.01365488f, -0.14093912f, -0.14119780f, -0.03956510f, -0.07633221f, 
    0.04346499f, -0.05363062f, 0.04353619f, -0.02674724f, 0.31077737f, -0.02090224f, 0.20514636f, 0.36397555f, 
    0.00234398f, -0.08188915f, -0.05770345f, -0.06692730f, -0.00399422f, 0.02235867f, 0.05138000f, -0.05284141f, 
    -0.00459670f, 0.43635467f, -0.04378301f, -0.01030521f, 0.01739705f, 0.05988548f, -0.02308566f, -0.11752525f, 
    0.07327153f, -0.12806726f, 0.06303693f, -0.17591123f, -0.33097097f, 0.16030829f, 0.02786099f, 0.02222645f, 
    0.05771279f, 0.03949497f, 0.07242415f, -0.09835698f, -0.05160815f, -0.02246983f, -0.11854522f, 0.06062234f, 
    0.22037531f, 0.05036477f, -0.05523777f, -0.05035076f, -0.04221249f, 0.10479271f, -0.12765232f, -0.10454638f, 
    0.05366082f, -0.01936783f, -0.04560666f, 0.02715325f, 0.27592593f, -0.06220192f, 0.04571610f, -0.06206160f, 
    -0.00603593f, -0.03873024f, -0.09540302f, 0.05111243f, 0.17730004f, -0.00383330f, -0.03093440f, -0.09814376f, 
    0.17295897f, 0.00998473f, 0.04771555f, 0.30005738f, -0.14182700f, -0.01134277f, 0.02203267f, 0.06970716f, 
    -0.10338609f, 0.04415077f, -0.04484103f, -0.22006436f, 0.35923102f, 0.12491634f, 0.03494430f, 0.25508437f, 
    -0.00411842f, -0.03568121f, -0.02400180f, -0.03695587f, -0.01715910f, 0.06366424f, -0.00155277f, 0.11530745f, 
    0.17511714f, 0.28557181f, 0.05003068f, -0.01622189f, -0.02573488f, 0.04028859f, -0.00299315f, 0.04682428f, 
    0.09392433f, 0.03960681f, 0.05620971f, 0.06224763f, 0.01861816f, -0.02977972f, -0.11061426f, -0.16971096f, 
    0.06022079f, 0.01700140f, 0.00343927f, 0.05481683f, 0.12631543f, 0.13276845f, -0.11114694f, -0.04850845f, 
    -0.09317930f, 0.18753725f, 0.05727842f, 0.13401994f, 0.10579798f, -0.05976063f, -0.06370312f, -0.11755320f, 
    -0.10323068f, -0.07620952f, 0.12061691f, -0.20321284f, -0.22335890f, -0.06715478f, -0.02573101f, -0.14436804f, 
    -0.03412987f, 0.07723359f, -0.05032737f, -0.08152590f, -0.04222601f, 0.00145815f, -0.04258204f, 0.03961618f, 
    0.42789215f, -0.04501466f, -0.17371234f, -0.03388913f, 0.08335975f, -0.11305305f, -0.13669202f, -0.07974474f, 
    -0.00581680f, -0.06245868f, 0.07179657f, 0.09726152f, -0.09506854f, 0.09857867f, 0.09319162f, -0.18126988f, 
    0.03285746f, -0.03652639f, 0.00389619f, 0.11697250f, 0.10369740f, 0.13134828f, 0.20636879f, 0.10800657f, 
    -0.18461685f, -0.18125415f, 0.08430742f, 0.05406984f, 0.17564446f, -0.08290777f, 0.09448563f, 0.00747418f, 
    -0.02318507f, -0.02117835f, 0.09775677f, -0.06168912f, -0.14340740f, -0.06501802f, -0.02752045f, 0.07121129f, 
    0.02022491f, -0.02238474f, 0.11664868f, 0.10947962f, -0.02346236f, 0.04360481f, 0.00960908f, 0.02235607f, 
    0.01244495f, 0.18083704f, 0.06776445f, -0.05617417f, 0.04658032f, 0.02851467f, -0.04489604f, -0.22813551f, 
    0.11216031f, 0.05353794f, 0.05006854f, 0.09338702f, 0.25391784f, 0.11672634f, 0.09803772f, 0.08027918f, 
    -0.05565271f, 0.04995992f, -0.03288580f, -0.12677011f, -0.06261962f, -0.03869695f, -0.11143772f, -0.06231764f, 
    0.31246489f, 0.00317101f, 0.01955990f, 0.10886902f, -0.01084496f, -0.06118402f, 0.03710325f, -0.03876946f, 
    0.03069298f, 0.02437104f, -0.02318516f, 0.08862179f, 0.23983788f, 0.12855090f, -0.07956111f, -0.14326815f, 
    -0.02758394f, 0.01618482f, 0.00595158f, -0.05289899f, -0.01027374f, 0.03533028f, 0.10393114f, 0.04199193f, 
    0.21668538f, 0.34482282f, 0.08529038f, -0.15768383f, 0.00159077f, 0.04032304f, 0.03838967f, 0.00655323f, 
    0.20769985f, 0.03393885f, 0.19693145f, 0.10139916f, -0.25234321f, -0.07854813f, -0.17816876f, 0.01572210f, 
    -0.01758365f, -0.05175265f, -0.06965992f, -0.01230361f, 0.00745568f, -0.16587749f, 0.00478793f, -0.00001991f, 
    0.16747949f, 0.13196795f, -0.01216180f, 0.21357946f, -0.13176394f, 0.02988813f, 0.06248655f, -0.03488335f, 
    -0.05789252f, -0.05902383f, 0.18596280f, -0.02353607f, -0.22610714f, -0.03267346f, 0.01649907f, -0.03847708f, 
    -0.05292803f, -0.04739652f, 0.17647104f, -0.04393196f, -0.02141737f, 0.07954223f, 0.03540461f, 0.06815067f, 
    0.03748257f, 0.10006332f, -0.01091852f, -0.03950582f, 0.10397581f, -0.03371596f, -0.06384058f, -0.10952944f, 
    0.05313262f, -0.07834537f, -0.06299972f, 0.02250964f, -0.14232214f, -0.06490374f, 0.11129703f, -0.14321296f, 
    0.08859316f, 0.05193076f, -0.02115308f, 0.00186782f, 0.16791072f, -0.01800089f, 0.03891328f, -0.01326642f, 
    -0.07508157f, 0.09453812f, 0.05079631f, -0.16902225f, 0.00434051f, -0.10602935f, 0.12851065f, -0.08373574f, 
    0.01365854f, 0.13349289f, 0.05883132f, 0.04909660f, 0.27512267f, 0.07150427f, 0.06453342f, 0.23807172f, 
    -0.09905884f, -0.07304279f, -0.06639566f, -0.04832589f, 0.09440301f, 0.12539537f, -0.02980695f, -0.09891188f, 
    -0.20361504f, -0.04911830f, -0.02693726f, 0.17828140f, 0.01109033f, -0.00461985f, 0.06119951f, 0.05726058f, 
    -0.03027274f, 0.00792475f, -0.21886714f, 0.04560078f, 0.26521003f, -0.15018824f, -0.12292350f, -0.07776427f, 
    -0.09608366f, -0.11729412f, -0.02276102f, -0.03037678f, -0.07008320f, 0.11311790f, -0.00790810f, 0.10568384f, 
    -0.16189988f, -0.03718629f, -0.09572806f, 0.05810811f, -0.00644199f, 0.01278675f, -0.02808243f, -0.09615866f, 
    -0.04856927f, -0.07957263f, -0.04863858f, -0.01260297f, 0.29144171f, -0.08840871f, 0.04269204f, -0.15404214f, 
    -0.02298391f, 0.06007430f, 0.03900532f, -0.04788597f, 0.08241142f, 0.00258304f, -0.04272516f, 0.03182081f, 
    -0.28835344f, 0.10954287f, 0.05271395f, 0.04546346f, -0.01962632f, 0.02920569f, -0.00446366f, -0.03076361f, 
    0.02325300f, 0.13179955f, 0.09636326f, 0.23450027f, 0.20408447f, 0.02439076f, 0.15122458f, -0.26369208f, 
    0.17576452f, 0.10471229f, -0.04820585f, 0.08083563f, -0.02394284f, -0.08387241f, 0.12399802f, 0.00267499f, 
    -0.16347612f, 0.04830434f, -0.05942176f, -0.07697625f, -0.02116750f, -0.03234138f, -0.04938900f, 0.04672723f, 
    -0.01859502f, -0.07435389f, -0.09897537f, -0.05147917f, 0.17868045f, 0.07813805f, -0.11300896f, 0.01386137f, 
    0.08722525f, -0.00774333f, -0.01604830f, -0.21653210f, 0.10886043f, 0.02213151f, -0.13925405f, -0.06691491f, 
    0.34251404f, 0.03508038f, 0.08235875f, 0.15013732f, -0.00203902f, -0.12097699f, -0.03891637f, 0.07414979f, 
    0.03367794f, 0.04326837f, 0.07814322f, 0.02128890f, 0.03368768f, 0.00754143f, -0.00374682f, -0.01328094f, 
    0.00546433f, -0.04889859f, -0.05852804f, 0.04872059f, 0.01880230f, 0.03724491f, 0.11278456f, -0.13575414f, 
    0.05844832f, 0.01369679f, -0.14648053f, 0.08521756f, 0.00430916f, 0.09892485f, 0.00674749f, 0.07091293f, 
    -0.05429283f, -0.08261869f, -0.04066736f, 0.29789609f, 0.37040022f, 0.09135724f, -0.07106663f, 0.02743533f, 
    0.05225774f, 0.01459376f, 0.10136470f, 0.10302569f, 0.13109013f, -0.08746084f, -0.06462895f, -0.10810647f, 
    -0.02146727f, 0.17023519f, -0.18477057f, 0.11204258f, -0.03455848f, 0.09456459f, 0.02734720f, 0.13708363f, 
    0.14080577f, 0.04025270f, 0.06514129f, 0.01770223f, 0.23834407f, -0.29775649f, -0.03346530f, -0.16429710f, 
    -0.08646525f, 0.01877059f, -0.00450821f, 0.03338081f, 0.06538714f, -0.11277193f, 0.09071134f, -0.07499011f, 
    -0.10799972f, -0.15264226f, 0.11567622f, 0.11768715f, -0.03812804f, 0.12477192f, 0.00604467f, -0.03140472f, 
    -0.03109479f, 0.08243432f, -0.06510537f, 0.10304080f, -0.04725537f, 0.09903367f, 0.03387899f, -0.21903218f, 
    -0.04174899f, 0.00491465f, -0.05826784f, 0.06017131f, 0.01755772f, -0.04611631f, 0.06921213f, 0.01218229f, 
    -0.03742064f, -0.12684996f, 0.23759970f, 0.11222233f, -0.08503126f, 0.11933379f, 0.01313943f, -0.03726761f, 
    0.09012024f, 0.00967812f, -0.08639202f, 0.00722453f, 0.16686228f, 0.04164642f, 0.13281600f, 0.00554529f, 
    0.00385667f, 0.09557176f, 0.06998312f, -0.02600484f, 0.11473022f, -0.06635431f, -0.24184878f, -0.05469377f, 
    0.19197969f, -0.17858529f, -0.02583857f, -0.01420410f, -0.03339668f, -0.03604319f, -0.04506249f, 0.04937370f, 
    -0.00455926f, 0.07060339f, 0.06354719f, 0.26860228f, 0.13440636f, -0.02969859f, 0.06955869f, 0.05499328f, 
    -0.13543740f, -0.05371030f, -0.07664376f, -0.01043194f, 0.11051273f, -0.02604245f, -0.03149313f, -0.17578131f, 
    0.00927175f, 0.09345448f, 0.23737417f, -0.00597016f, 0.06293765f, 0.05683656f, 0.08350765f, 0.00406178f, 
    0.00704661f, 0.07426719f, -0.15533254f, -0.06413332f, -0.06860957f, 0.11916146f, -0.02761769f, 0.17367302f, 
    0.05823945f, 0.00708046f, -0.09972840f, -0.07516037f, 0.02192866f, -0.00453745f, -0.02620364f, -0.11293183f, 
    0.08898892f, 0.09699677f, -0.08203770f, 0.17073524f, 0.00957889f, 0.10972900f, 0.08926641f, 0.09094682f, 
    -0.01476625f, 0.08815876f, 0.07851764f, -0.04519643f, 0.00253204f, 0.08580299f, 0.15695167f, 0.15120529f, 
    0.06545287f, -0.01628325f, 0.02180316f, -0.02355961f, -0.04956738f, -0.16618302f, 0.06836517f, -0.02287624f, 
    0.18678120f, -0.09089842f, -0.12040218f, -0.02597497f, 0.24841624f, -0.20273134f, -0.00888451f, 0.00889499f, 
    -0.01732453f, 0.01378883f, 0.02996850f, -0.03043436f, 0.00920631f, 0.00211228f, 0.12775217f, 0.08625360f, 
    -0.03905327f, 0.07486430f, 0.03645032f, -0.00295291f, -0.08925439f, 0.11899129f, 0.09875150f, 0.13088515f, 
    0.03061650f, 0.00470291f, -0.06549974f, -0.08383112f, 0.06632143f, 0.02092234f, 0.04898838f, 0.09666424f, 
    0.14737917f, -0.14086807f, 0.08101767f, 0.04907468f, -0.18756361f, 0.10058869f, -0.12878650f, -0.01210300f, 
    0.09521995f, 0.06310789f, -0.08161908f, 0.03713012f, 0.04551189f, 0.03601544f, 0.11800400f, -0.05378584f, 
    0.13604064f, 0.09416201f, 0.00733964f, 0.03769293f, 0.01603901f, -0.01353821f, 0.13366126f, 0.00358904f, 
    -0.02201211f, 0.01457960f, 0.04931455f, 0.06540575f, 0.09382495f, 0.02176783f, -0.10050265f, 0.26429471f, 
    -0.00986412f, 0.03472719f, -0.04877988f, -0.02589975f, 0.05045128f, -0.15002063f, 0.05919929f, -0.04740204f, 
    0.21143052f, 0.06769178f, -0.18589318f, -0.04066668f, 0.04891190f, -0.00132457f, -0.00996474f, 0.03257282f, 
    0.10980110f, 0.00386941f, 0.09689864f, 0.03681695f, 0.40412042f, 0.22497171f, -0.19014026f, -0.00627853f, 
    0.04521353f, 0.14833216f, 0.08019941f, -0.08925605f, 0.09542779f, 0.01991365f, -0.02716887f, -0.07763316f, 
    0.14561102f, 0.05166586f, -0.11891761f, 0.16240111f, 0.02783889f, 0.18012616f, -0.09785984f, -0.01377822f, 
    0.01517973f, 0.03316369f, -0.03443272f, -0.12175053f, 0.13914983f, -0.02797153f, -0.13706531f, -0.22705351f, 
    0.09270675f, -0.00973139f, 0.04594024f, 0.07986701f, 0.04440603f, 0.00846521f, 0.11739527f, -0.05901509f, 
    0.26682255f, -0.20911177f, 0.15322156f, 0.15572089f, -0.08843945f, 0.00596206f, 0.04991563f, -0.06761674f, 
    0.00373027f, 0.08217697f, 0.04174948f, 0.08635723f, -0.11730461f, -0.05870561f, 0.06481446f, 0.13642071f, 
    -0.12847413f, -0.07493116f, 0.16982931f, -0.09952124f, -0.01287215f, 0.07200050f, 0.06114971f, 0.00407316f, 
    -0.08966636f, 0.09951594f, -0.09932161f, 0.22684462f, 0.08415187f, -0.11473158f, -0.15373789f, -0.03019990f, 
    -0.01739382f, -0.03605513f, 0.13208893f, -0.00818632f, -0.00234283f, -0.07675016f, 0.04466348f, -0.08596223f, 
    -0.05935390f, 0.05297825f, 0.01494636f, 0.03085469f, -0.03868941f, -0.09552243f, 0.03690331f, 0.02900468f, 
    0.07250738f, 0.34837297f, 0.08029494f, -0.00375602f, 0.02346177f, 0.01261282f, -0.16199653f, -0.07071379f, 
    0.04906234f, -0.17169306f, 0.05474415f, -0.24550940f, -0.35721064f, 0.35527757f, -0.09072238f, 0.27338168f, 
    -0.02048655f, 0.10584663f, 0.03618545f, 0.00025984f, 0.01629604f, -0.01959619f, 0.03971072f, -0.03775239f, 
    -0.08968214f, -0.19149888f, 0.03756252f, -0.10924156f, -0.02983947f, 0.02682335f, 0.00043474f, 0.10210784f, 
    0.03121291f, 0.01330749f, -0.11322046f, 0.02816267f, -0.02619014f, 0.10178512f, -0.04458546f, -0.20521536f, 
    0.10341659f, -0.01738154f, -0.02541152f, 0.04368969f, 0.19128278f, -0.00361014f, 0.01006901f, -0.07812741f, 
    0.07745969f, 0.02176895f, -0.09263463f, -0.17186175f, -0.09510580f, 0.05442853f, -0.02735645f, 0.11226807f, 
    -0.00685998f, 0.03483444f, -0.14552054f, 0.07543925f, 0.02411352f, -0.28139877f, 0.25221035f, -0.02648172f, 
    -0.11958688f, 0.00777204f, -0.00899193f, -0.11055786f, 0.00847379f, 0.02732540f, -0.00793188f, -0.06050596f, 
    -0.21222721f, -0.10759682f, 0.06842871f, 0.17523810f, 0.01302091f, -0.04434675f, -0.07807115f, 0.10686912f, 
    0.05155569f, 0.05698346f, 0.00989338f, 0.02662572f, 0.16251741f, -0.03312238f, -0.09626184f, -0.09898324f, 
    0.03944592f, 0.00355615f, 0.10406100f, -0.09011493f, 0.07712991f, 0.07087339f, 0.00581231f, 0.08168103f, 
    0.03798725f, 0.21340360f, -0.15899324f, -0.02819029f, 0.06598201f, -0.06490273f, -0.12248028f, -0.02688408f, 
    -0.08391151f, -0.06183311f, -0.10212992f, -0.11369675f, -0.10186376f, 0.11523543f, -0.08142810f, -0.14113651f, 
    -0.05468292f, 0.09009217f, -0.00648722f, 0.09050214f, 0.02290256f, -0.06034363f, 0.01054231f, 0.07302749f, 
    -0.03731063f, 0.04547936f, 0.00398360f, -0.11554547f, -0.01888568f, 0.00469935f, 0.07461971f, 0.03110630f, 
    0.04784492f, -0.06756765f, -0.00338700f, 0.00089922f, 0.05418944f, 0.01808313f, -0.02553657f, 0.27440569f, 
    0.03105992f, 0.13854441f, 0.03420512f, -0.02837235f, 0.02664884f, 0.08906157f, 0.11919263f, 0.03109726f, 
    0.01566048f, -0.06311443f, -0.15733127f, 0.34630218f, -0.03678649f, 0.02873182f, 0.00678958f, -0.03531924f, 
    0.04415877f, -0.06987473f, -0.10201167f, -0.03640621f, 0.15555580f, -0.01359167f, -0.06947605f, 0.10691635f, 
    0.04799996f, -0.01511710f, 0.06975502f, 0.18169691f, 0.01094176f, 0.01335660f, -0.02208186f, 0.01167187f, 
    -0.09538698f, 0.11676893f, 0.00782766f, -0.16618982f, -0.07686856f, 0.00153636f, 0.02349316f, -0.05159208f, 
    0.06874148f, 0.05060848f, -0.02485101f, 0.00186924f, -0.05906641f, 0.11315430f, 0.07753295f, -0.06395019f, 
    -0.06022348f, 0.04214485f, 0.03347119f, -0.02841208f, -0.05223453f, -0.15731476f, -0.14369765f, -0.02660258f, 
    -0.01477985f, 0.03690487f, -0.04299363f, -0.07925458f, -0.02832937f, 0.06869049f, 0.07908744f, 0.03507888f, 
    -0.00152522f, 0.07537290f, -0.05406477f, 0.02965481f, 0.04551031f, -0.10429260f, -0.15864784f, -0.15940778f, 
    -0.01821552f, -0.05316428f, 0.02357642f, -0.09317191f, -0.02213206f, -0.02023883f, -0.00249806f, 0.00944711f, 
    -0.07828466f, 0.05574716f, 0.20783763f, 0.24185587f, -0.01178144f, -0.00129164f, 0.14459793f, 0.05343123f, 
    0.07477970f, 0.14095369f, 0.06429656f, 0.06264768f, 0.22266938f, 0.29830182f, -0.08729941f, 0.11301323f, 
    -0.05806289f, 0.02667306f, 0.02029915f, 0.03625216f, -0.05136228f, -0.16172297f, -0.11064753f, -0.01061409f, 
    0.03309673f, 0.10099892f, 0.05683619f, 0.05454271f, -0.03012729f, 0.05465585f, -0.00139891f, -0.00136376f, 
    -0.05714085f, -0.05883329f, 0.24429673f, 0.04235287f, 0.09988592f, -0.13471933f, 0.00583176f, -0.10917351f, 
    -0.07713082f, 0.00651022f, 0.15279427f, -0.04212400f, 0.05149432f, -0.01818782f, -0.02018342f, 0.06376290f, 
    -0.00197986f, -0.06052538f, 0.05372026f, -0.19096793f, 0.02115298f, -0.06294455f, -0.02686160f, -0.19285263f, 
    0.03876172f, -0.02190750f, -0.10690692f, 0.02914031f, -0.49474254f, 0.09637274f, -0.01225534f, 0.23895280f, 
    -0.04887428f, 0.14605130f, -0.14065899f, 0.00766701f, 0.09057225f, 0.13011950f, 0.03041763f, 0.00970636f, 
    -0.22834753f, -0.22442289f, -0.02096570f, 0.30513155f, 0.05614906f, 0.01564836f, 0.06798082f, -0.12849472f, 
    0.03876445f, 0.17718884f, 0.13199383f, -0.03752816f, 0.05005558f, -0.17708369f, 0.18945861f, 0.00309215f, 
    0.02300327f, -0.07670119f, 0.02326461f, -0.03796931f, 0.13908038f, 0.11971362f, 0.12294281f, 0.03609066f, 
    -0.28523964f, 0.06917193f, -0.01206320f, 0.15406993f, -0.09417222f, 0.07535169f, 0.11050358f, 0.07324714f, 
    0.14460364f, -0.00957032f, -0.01767009f, -0.04205010f, 0.13452858f, -0.03375325f, 0.02433835f, 0.02975146f, 
    0.06999497f, -0.14549787f, 0.00374822f, -0.02483688f, -0.01717329f, 0.05013319f, 0.00630912f, 0.01637175f, 
    -0.04962859f, 0.14575471f, -0.11678266f, -0.15155989f, 0.18234189f, 0.14579883f, -0.11846235f, -0.04214174f, 
    0.03395884f, 0.05862934f, -0.02613738f, -0.02709389f, 0.10034504f, -0.07198785f, -0.05161232f, -0.05031954f, 
    0.06253358f, 0.00156782f, 0.10246102f, -0.15511984f, 0.02161595f, 0.00496585f, -0.01745625f, -0.07755788f, 
    -0.33126211f, 0.00145134f, 0.27773422f, -0.05632523f, -0.04918857f, 0.14164995f, -0.05192599f, 0.09286571f, 
    0.05046724f, 0.05114774f, 0.19378676f, 0.17453596f, 0.39907688f, 0.11506104f, -0.08772679f, -0.00477892f, 
    0.08018555f, 0.08425672f, 0.04851906f, -0.05260234f, -0.07232288f, -0.06434116f, -0.05617834f, -0.10966112f, 
    -0.22552682f, 0.25292727f, -0.00975073f, -0.31852353f, 0.12768240f, -0.06554952f, -0.02358412f, -0.07787302f, 
    -0.04574359f, 0.00339705f, -0.01959182f, 0.01678392f, -0.22614218f, -0.09796631f, 0.07508277f, 0.04103234f, 
    0.10652361f, 0.03222242f, 0.01596333f, 0.12646213f, -0.01950896f, -0.04285624f, 0.04830792f, 0.16661705f, 
    -0.26338705f, -0.00755515f, 0.03567464f, 0.10394873f, 0.06398456f, -0.02780915f, -0.11579406f, 0.06421760f, 
    0.01125381f, 0.00412473f, -0.06179843f, 0.01882423f, -0.20021829f, 0.04308998f, -0.03154333f, -0.11638034f, 
    0.15282878f, 0.00738794f, -0.08963157f, 0.03519229f, 0.06927191f, 0.01474342f, -0.06494462f, 0.10465828f, 
    -0.12334919f, -0.26497412f, 0.10123504f, -0.01144926f, -0.03660810f, -0.01432126f, 0.08327032f, -0.04298018f, 
    -0.02573581f, -0.03287925f, 0.10167747f, 0.04978487f, -0.16072911f, 0.02776843f, 0.03351403f, 0.13961001f, 
    -0.05066375f, 0.10132691f, 0.04287978f, 0.11409671f, -0.08123067f, -0.00869429f, -0.04995706f, 0.05266452f, 
    -0.00878730f, -0.12427923f, 0.07299154f, 0.06741662f, 0.07190859f, 0.00442665f, 0.03460858f, -0.00685816f, 
    -0.13492231f, 0.09500459f, -0.11791646f, -0.04414010f, -0.09025235f, 0.28285846f, 0.09548644f, 0.32374185f, 
    -0.06078929f, 0.08933251f, 0.02638834f, 0.08766092f, 0.05250430f, 0.11712935f, 0.04630607f, -0.03919613f, 
    0.00452478f, 0.04556818f, -0.15643939f, 0.01588090f, 0.10490090f, -0.08657853f, 0.01287599f, 0.12544188f, 
    -0.02703338f, 0.02313065f, 0.11002658f, -0.00086173f, -0.15034740f, -0.14588828f, 0.11901508f, -0.17217930f, 
    -0.00186800f, 0.01001740f, 0.06797185f, -0.04464677f, -0.08290140f, -0.04933413f, -0.07223976f, 0.02925607f, 
    -0.20541193f, 0.31512672f, -0.10277304f, -0.09979095f, 0.05652317f, 0.01030850f, 0.08046148f, -0.10577443f, 
    -0.04744193f, -0.03434633f, 0.09818026f, 0.11594287f, 0.17378426f, -0.06338577f, 0.14952195f, 0.20796707f, 
    0.06316748f, 0.14413251f, 0.12630281f, 0.18036576f, 0.00004050f, 0.08485753f, 0.08846037f, 0.02698458f, 
    -0.32665524f, 0.12807091f, -0.14708814f, -0.18275703f, 0.10084800f, 0.01817176f, 0.05204014f, -0.04414217f, 
    -0.04443371f, 0.05646959f, 0.01296614f, -0.01927939f, 0.09205285f, -0.02096466f, 0.11050588f, 0.13998015f, 
    0.08780771f, 0.01748615f, 0.01304981f, 0.21191245f, 0.03234025f, -0.00196555f, 0.07216038f, 0.10260480f, 
    0.22751701f, -0.00425669f, -0.00533481f, 0.25247404f, 0.07712466f, 0.02082803f, 0.05199476f, 0.04072903f, 
    0.01477380f, -0.07719516f, -0.00062171f, 0.04900081f, 0.11954597f, -0.01562386f, 0.19564600f, 0.03777922f, 
    0.05725657f, -0.05300907f, -0.08359729f, 0.08456960f, 0.03685905f, 0.06583140f, 0.02076137f, 0.14436774f, 
    -0.04929018f, -0.00585568f, 0.08455668f, 0.07377338f, 0.09320872f, 0.14797415f, -0.00169738f, 0.04849928f, 
    0.02566002f, -0.00421597f, 0.06285892f, 0.13041280f, 0.24674244f, 0.06345744f, 0.07975152f, 0.29606137f, 
    0.01469123f, -0.02838446f, -0.01730434f, 0.02568531f, 0.06124012f, 0.03598755f, 0.00164449f, 0.00813657f, 
    0.01281325f, 0.14934744f, 0.02840045f, 0.04661494f, 0.10373914f, -0.03467505f, 0.05768194f, -0.10027346f, 
    0.13798690f, -0.02595161f, 0.12829298f, -0.01800980f, 0.25937322f, 0.08869766f, -0.01870611f, 0.29101217f, 
    -0.02680945f, 0.03455634f, 0.05426069f, 0.12354380f, 0.00152614f, -0.03498466f, 0.07054223f, 0.02346601f, 
    -0.02567728f, -0.21867043f, 0.01081513f, -0.09214596f, -0.00710105f, 0.03598398f, 0.04741788f, -0.05008283f, 
    -0.09166298f, -0.01293328f, 0.08254911f, -0.02101129f, 0.05022962f, -0.15349281f, 0.04796850f, -0.21628904f, 
    0.08762019f, -0.03276870f, 0.07298738f, -0.02301361f, 0.00405704f, 0.06956464f, -0.10802528f, 0.01183733f, 
    -0.07187615f, -0.35714284f, 0.13241576f, 0.09036437f, 0.05989483f, -0.03199753f, -0.10133306f, -0.02103354f, 
    -0.07310673f, -0.01621092f, 0.10775856f, -0.03655415f, 0.03265517f, 0.07759523f, 0.15701047f, 0.20053490f, 
    -0.11360686f, -0.00345287f, 0.05707580f, 0.14125629f, 0.07230307f, 0.06815334f, 0.01033348f, 0.10491674f, 
    0.17112537f, 0.06754158f, 0.06859465f, 0.18047892f, 0.01518745f, -0.01947683f, 0.08994645f, -0.14107060f, 
    0.08976006f, 0.07693800f, -0.00725776f, 0.03728017f, -0.01249645f, -0.02554837f, 0.08239059f, 0.12603845f, 
    0.09041718f, 0.08623710f, 0.08028071f, -0.00291316f, -0.10017862f, 0.07842699f, 0.06880851f, 0.00364133f, 
    0.27377424f, -0.02489679f, 0.18279298f, 0.21357003f, 0.05300450f, 0.00982962f, 0.00008071f, 0.08233307f, 
    -0.07294760f, 0.02437029f, 0.06487830f, 0.15705286f, -0.27927741f, -0.08167215f, 0.07003680f, -0.01305780f, 
    0.01870892f, 0.07084278f, -0.03626415f, -0.03448670f, -0.00332801f, 0.05632813f, -0.04537946f, -0.01228174f, 
    -0.28463027f, -0.12657745f, 0.00137939f, -0.01115984f, 0.04077879f, -0.05981424f, 0.02290670f, 0.04939346f, 
    -0.03706590f, 0.04711257f, -0.01667153f, -0.03358408f, 0.01688371f, -0.08374246f, 0.08583917f, 0.11258522f, 
    0.01473426f, 0.12855764f, 0.04711727f, 0.04923307f, 0.04661677f, -0.12014636f, 0.01954920f, 0.11655045f, 
    0.45808256f, 0.09773461f, 0.06202505f, -0.13045463f, 0.04718221f, 0.09790155f, 0.09938367f, 0.08547465f, 
    0.06844709f, 0.02188784f, 0.00700666f, -0.04567799f, 0.13852277f, 0.12727584f, -0.00851520f, -0.02758829f, 
    -0.00324207f, -0.05406691f, 0.04522697f, -0.09901637f, 0.02443931f, 0.06181447f, 0.05698209f, 0.05528004f, 
    -0.18972664f, 0.07354130f, -0.03421990f, -0.00316648f, -0.04310818f, 0.01998232f, 0.13715392f, -0.15001144f, 
    -0.02345095f, 0.03005474f, 0.03300618f, -0.03944153f, -0.07714353f, 0.11685151f, -0.00457521f, 0.05550235f, 
    0.18471897f, -0.02555127f, -0.06663287f, -0.02520162f, -0.02195437f, 0.01220501f, 0.00253734f, 0.02170298f, 
    -0.17182685f, 0.31749192f, -0.24155137f, 0.04813812f, -0.04177904f, 0.08680126f, -0.06330658f, -0.01159350f, 
    0.03760614f, -0.00173917f, -0.02924767f, -0.01344348f, 0.07584269f, -0.20763765f, 0.03215244f, -0.01373528f, 
    -0.05077296f, 0.06977095f, -0.13661884f, 0.03160136f, -0.18703982f, 0.10899219f, -0.04113526f, -0.12890604f, 
    -0.15114760f, -0.18188557f, -0.07198316f, 0.00140088f, -0.02196189f, 0.05845451f, 0.01172064f, -0.08055481f, 
    -0.01494352f, 0.03293596f, 0.05332040f, 0.00927928f, -0.32765919f, 0.32059747f, -0.12788977f, -0.12946144f, 
    0.11321000f, 0.01674153f, 0.03914228f, -0.13312170f, -0.06994023f, -0.01225155f, 0.03459230f, -0.02670488f, 
    0.11378803f, 0.08795087f, 0.07799684f, 0.25405872f, 0.01036748f, -0.10342857f, -0.08155038f, 0.00392172f, 
    0.00790768f, 0.01716539f, -0.08346388f, -0.03656744f, 0.07346887f, -0.00890664f, 0.08590908f, 0.12878518f, 
    0.10067582f, 0.11898762f, 0.00760607f, 0.06043934f, 0.02298531f, 0.05303307f, -0.08865125f, -0.07921475f, 
    -0.18986346f, 0.03023430f, 0.07118125f, -0.15813273f, 0.02745743f, 0.03973573f, 0.02668059f, -0.04037796f, 
    -0.01795727f, 0.02353015f, 0.16651253f, 0.04631954f, -0.21802726f, -0.04141580f, -0.06148406f, -0.10900142f, 
    0.16565394f, 0.07302381f, 0.06472667f, -0.00789014f, 0.01135620f, 0.05964825f, 0.19338979f, -0.14090098f, 
    0.04272719f, -0.28405303f, 0.04469341f, -0.00548773f, -0.01162851f, 0.17312351f, 0.07435031f, -0.01828399f, 
    0.01200035f, 0.08615137f, 0.06573648f, 0.15108989f, 0.16891186f, 0.17566670f, 0.11254762f, 0.05072574f, 
    0.09492196f, -0.09338655f, -0.02340339f, -0.01546000f, 0.01273387f, 0.01668294f, 0.02578113f, -0.00190716f, 
    -0.32994288f, -0.03699110f, -0.00838074f, 0.01632750f, 0.09534489f, -0.13261726f, 0.07099213f, -0.02341711f, 
    0.11626120f, 0.10345195f, -0.08012377f, -0.01787833f, -0.11730250f, -0.01628720f, -0.04117421f, 0.03179203f, 
    -0.02214239f, 0.06732480f, 0.03017250f, -0.14624493f, -0.01671599f, 0.01585577f, 0.02670613f, -0.07576603f, 
    -0.29949602f, -0.06913256f, 0.04008871f, -0.08967270f, 0.04922022f, 0.05596675f, -0.04800777f, -0.08085848f, 
    -0.03343613f, 0.11166184f, 0.01350696f, 0.05185441f, -0.01622987f, -0.06647312f, 0.00902296f, -0.20246387f, 
    0.01574034f, 0.00715365f, -0.00758289f, 0.00040155f, -0.07452060f, 0.04379532f, -0.00820929f, -0.00862863f, 
    0.00877937f, 0.06199903f, -0.00150132f, -0.27176586f, 0.10818202f, -0.00782466f, 0.04786399f, -0.17821239f, 
    0.10363147f, -0.02520548f, -0.01146822f, 0.07204118f, -0.27310231f, 0.09605587f, 0.10134885f, 0.15562661f, 
    -0.12557375f, 0.09493208f, -0.12233930f, 0.03445601f, 0.13864215f, 0.01930059f, -0.04200874f, -0.04942610f, 
    0.10389397f, -0.28790039f, 0.24682955f, 0.14290661f, 0.04242561f, 0.12887207f, -0.04547992f, 0.01943808f, 
    -0.01281940f, 0.00662914f, 0.05031206f, -0.06086980f, -0.07311396f, 0.07400910f, 0.23940822f, -0.00270022f, 
    0.04827588f, 0.01051484f, -0.03118818f, 0.06416348f, 0.06773362f, 0.02971739f, 0.11346988f, -0.03674611f, 
    -0.10115433f, -0.12829420f, 0.22821996f, -0.04214224f, 0.03172470f, -0.00523792f, 0.00970097f, 0.03007018f, 
    -0.08538387f, 0.06769862f, -0.01118382f, -0.02975991f, -0.28176749f, 0.18842615f, 0.05628869f, 0.16517338f, 
    0.05451518f, -0.00971417f, 0.05285797f, 0.00545656f, 0.03921201f, 0.16186798f, -0.04653313f, -0.01231443f, 
    -0.36832479f, -0.02058682f, 0.06895057f, -0.05183031f, 0.05197755f, 0.05207328f, -0.07057197f, -0.02581188f, 
    0.07375865f, 0.06231155f, 0.02989712f, -0.05925738f, 0.07774930f, -0.30264819f, 0.16159718f, 0.16765051f, 
    0.03738930f, -0.05928190f, 0.09346375f, -0.03309909f, 0.00447709f, -0.01432875f, 0.05448198f, 0.04280389f, 
    0.00193230f, 0.04497039f, 0.20438950f, 0.12869844f, 0.09555324f, -0.01054272f, -0.05569541f, 0.07217955f, 
    -0.01371794f, -0.01533908f, 0.01408402f, -0.01870280f, -0.25728542f, 0.33465078f, -0.11985128f, -0.22334720f, 
    0.09505964f, 0.05519135f, -0.04299362f, -0.04377658f, 0.10264309f, -0.02466893f, -0.03071114f, -0.02612757f, 
    0.43744743f, 0.00372983f, 0.05032340f, 0.00845315f, 0.06282034f, -0.08914007f, -0.02680623f, 0.10981514f, 
    -0.12791514f, 0.05201907f, -0.00231983f, 0.00681170f, 0.01558877f, 0.22258922f, -0.07851671f, 0.06632595f, 
    -0.12204532f, 0.12551874f, 0.03711912f, -0.13912703f, 0.01139657f, -0.06697155f, -0.04043247f, -0.02236982f, 
    0.35624063f, 0.01703600f, 0.10531967f, 0.15801674f, 0.02857990f, 0.04824112f, 0.09444066f, 0.08111243f, 
    -0.03377207f, 0.02991666f, 0.13243622f, -0.02891185f, 0.25976864f, 0.00237724f, 0.00292457f, 0.25005123f, 
    -0.08186682f, -0.06211929f, -0.06164240f, 0.16291381f, -0.01506189f, -0.01478871f, 0.01064721f, -0.06153379f, 
    0.04933373f, 0.23712075f, -0.03065060f, -0.11030679f, 0.12774457f, -0.08689011f, 0.00955786f, -0.01528449f, 
    0.03003681f, -0.02003552f, -0.03723865f, -0.04294476f, 0.16781946f, 0.05400120f, 0.15983345f, 0.13581739f, 
    -0.02303714f, 0.00240115f, -0.04884896f, 0.02090097f, 0.04252122f, -0.01645361f, 0.01184258f, -0.03946247f, 
    0.00182968f, -0.00227360f, 0.00387016f, -0.02548270f, -0.00221703f, -0.03162207f, -0.02266584f, 0.01059305f, 
    -0.00467273f, -0.02103598f, -0.02779721f, -0.03121022f, 0.00582018f, -0.02220265f, -0.00571442f, -0.02353008f, 
    -0.01222766f, -0.00933463f, 0.03321167f, 0.03170238f, 0.02683779f, 0.00631501f, 0.02376317f, 0.02825326f, 
    0.00180547f, 0.01394438f, -0.00625270f, 0.03685502f, -0.01808223f, 0.03488426f, -0.00351588f, -0.02978086f, 
    0.00205252f, 0.02467494f, 0.00853158f, 0.02663609f, 0.01704316f, 0.02391562f, -0.02047849f, -0.03794282f, 
    0.02566320f, 0.01683754f, 0.00216655f, -0.03592940f, 0.02703728f, 0.03205282f, -0.00245851f, 0.00758558f, 
    0.03081621f, -0.00333988f, -0.01322570f, 0.01687547f, -0.00197154f, 0.01444865f, 0.01531014f, -0.00979844f, 
    0.03236566f, -0.04403437f, -0.02908220f, 0.02312512f, -0.00882057f, -0.04322225f, -0.00003941f, 0.02392526f, 
    -0.00727350f, 0.02591879f, -0.01017471f, -0.03362643f, 0.00699672f, 0.02699785f, 0.00683337f, 0.02162417f, 
    -0.00798148f, -0.01710488f, 0.02121498f, -0.00050399f, 0.00112632f, 0.00438800f, -0.03066094f, -0.03250661f, 
    0.00970582f, 0.03026792f, -0.02921108f, 0.02688248f, -0.00009016f, -0.00409731f, 0.00364227f, -0.02527087f, 
    0.00920983f, 0.02033958f, 0.01268994f, -0.02760951f, 0.02442110f, -0.01627142f, -0.01746419f, -0.02796040f, 
    0.02745342f, 0.00444855f, -0.02464125f, -0.00940368f, -0.00850277f, -0.02715291f, -0.00736583f, -0.03213591f, 
    -0.01009323f, 0.03332289f, -0.02028265f, -0.00711288f, 0.02635584f, 0.01482457f, 0.01954708f, -0.00649596f, 
    -0.01400165f, 0.00358676f, 0.01832166f, -0.02290050f, 0.00012569f, -0.01936717f, -0.00375275f, -0.01039212f, 
    -0.03607529f, -0.01345816f, 0.01033629f, -0.00859842f, 0.02309997f, -0.00257563f, -0.01653608f, -0.01546323f, 
    -0.01829525f, 0.01802402f, 0.02586246f, -0.01170759f, -0.00712213f, -0.02258457f, 0.02495223f, -0.00631916f, 
    -0.01757634f, 0.00563744f, 0.02290701f, -0.00835695f, 0.00901152f, 0.00954957f, -0.03464794f, 0.01738410f, 
    -0.00218476f, 0.03130239f, -0.01956962f, 0.00511434f, -0.01094033f, -0.00255776f, -0.01007083f, -0.01615054f, 
    -0.00226245f, -0.03729523f, -0.03799750f, 0.01702056f, -0.03229994f, -0.02894619f, 0.03279437f, -0.02842649f, 
    -0.03416263f, -0.02195764f, -0.03487291f, -0.03218413f, 0.01019473f, 0.00184430f, -0.02117754f, -0.02749146f, 
    -0.01633114f, 0.01411785f, 0.01538926f, 0.01597458f, 0.02229868f, 0.01396373f, 0.01059382f, 0.03395079f, 
    0.02540795f, -0.01989390f, -0.00999869f, 0.02942411f, -0.02214153f, -0.00964797f, -0.04114743f, 0.01047750f, 
    -0.03234387f, 0.00160973f, 0.00931175f, 0.02334638f, 0.01921589f, -0.00444249f, 0.02368037f, 0.02561461f, 
    -0.00631617f, -0.00225843f, 0.00052701f, 0.02752978f, 0.02296532f, -0.02068492f, 0.01649653f, 0.00040427f, 
    -0.02951428f, -0.03239467f, -0.01656611f, 0.01102551f, 0.00771427f, -0.04329845f, -0.02014862f, -0.02921717f, 
    -0.02282867f, -0.00167428f, 0.01260578f, 0.02111710f, -0.00558383f, -0.03364637f, -0.01065356f, -0.01902760f, 
    -0.03002965f, -0.01609164f, -0.02380512f, -0.01746491f, -0.00246360f, -0.04249201f, -0.02534282f, 0.00800813f, 
    -0.01660520f, 0.00430005f, -0.00564353f, -0.01818991f, -0.02097224f, -0.01817275f, -0.04164109f, -0.03389245f, 
    0.01479456f, 0.01541521f, -0.00016449f, -0.00790223f, 0.02538031f, -0.03286750f, -0.04097366f, -0.00552981f, 
    -0.00142763f, 0.01020805f, -0.01780243f, -0.02506115f, -0.00374528f, -0.03767325f, 0.00894657f, -0.03857682f, 
    0.00573219f, 0.02964039f, -0.03220137f, -0.01827635f, -0.00938347f, 0.02770282f, -0.00334385f, -0.03453056f, 
    -0.00472903f, -0.03967685f, -0.01850695f, -0.01422611f, -0.03626008f, -0.01051036f, 0.01448682f, 0.02874623f, 
    -0.00584500f, 0.00538282f, -0.00549958f, -0.01608644f, 0.01046646f, -0.01932651f, -0.03287848f, 0.01757229f, 
    -0.03028592f, 0.02616232f, 0.00381880f, 0.00627996f, 0.00218409f, 0.01753090f, 0.01224186f, 0.02451438f, 
    0.00004651f, -0.03858299f, -0.00330922f, -0.00633257f, 0.00429654f, -0.03284461f, 0.00169222f, -0.01481706f, 
    -0.03444074f, -0.03047160f, 0.00425071f, -0.00567231f, 0.02271474f, -0.03744928f, -0.03912009f, -0.00295464f, 
    -0.01642942f, 0.00923958f, -0.03891200f, -0.02633941f, -0.02000929f, 0.02427250f, 0.01403750f, 0.01083233f, 
    -0.02988832f, 0.01037247f, 0.01791598f, -0.03843103f, 0.03049120f, 0.01227233f, 0.01315972f, -0.02023924f, 
    0.01574519f, 0.01735777f, 0.00243716f, 0.00692037f, -0.02996330f, -0.01319893f, 0.02545992f, -0.03242316f, 
    -0.00499913f, 0.00265143f, 0.01014510f, -0.03633619f, 0.00361336f, 0.02243795f, 0.02104565f, 0.03089254f, 
    0.03408376f, 0.01435919f, 0.02545830f, -0.00729722f, 0.02763292f, -0.03173243f, 0.01285555f, -0.01878701f, 
    -0.03492483f, 0.00993415f, 0.03425952f, 0.00102731f, -0.00154000f, 0.00752841f, -0.00925844f, -0.02588017f, 
    -0.00138774f, 0.01504104f, -0.00153843f, -0.00478258f, 0.00041784f, 0.02159034f, -0.00130192f, -0.00054800f, 
    -0.00676263f, -0.03676933f, 0.02786932f, -0.00947317f, 0.00081804f, -0.00127059f, -0.02774661f, -0.00422318f, 
    0.02771557f, -0.02407427f, -0.02781640f, 0.01811740f, 0.02232910f, 0.03116032f, -0.02844172f, -0.01821795f, 
    -0.01847810f, 0.00051447f, 0.03404681f, -0.03779530f, -0.00356720f, 0.02066060f, -0.02251396f, -0.01283182f, 
    -0.00613653f, -0.02586188f, 0.00486403f, 0.01292359f, -0.01979523f, -0.03248227f, -0.01573445f, -0.00348988f, 
    -0.00381159f, 0.02296495f, -0.03871371f, -0.04049354f, 0.02627768f, 0.01711456f, -0.03289564f, 0.01896029f, 
    -0.03496605f, -0.02307089f, -0.01521232f, -0.00067690f, -0.03524044f, -0.01568032f, -0.03398262f, 0.00365608f, 
    0.01586027f, -0.03757376f, 0.01791369f, 0.00156251f, -0.02002149f, 0.00184235f, 0.01980373f, -0.01780873f, 
    0.01500170f, 0.02156230f, 0.03098697f, 0.01461347f, 0.00986405f, -0.03428419f, -0.00530130f, -0.01649160f, 
    0.02287463f, -0.03687372f, 0.02343710f, -0.03555985f, 0.01587718f, -0.02207167f, 0.00246606f, 0.02841243f, 
    -0.02066762f, 0.03034992f, 0.00582182f, 0.00026358f, -0.02411490f, -0.02157533f, -0.03353577f, 0.01255094f, 
    0.00633780f, 0.01695736f, 0.02861275f, -0.01934016f, 0.02747609f, -0.02609277f, -0.01328612f, -0.00945638f, 
    -0.01508028f, 0.01300571f, 0.01045067f, -0.01914682f, 0.02523253f, -0.03052274f, 0.03280700f, -0.00644202f, 
    -0.00234078f, -0.00883466f, -0.01372846f, -0.01723473f, 0.00904899f, 0.01035743f, 0.00562535f, -0.00476216f, 
    -0.03706127f, 0.00233331f, 0.02975516f, 0.00097979f, -0.03472901f, -0.00694498f, 0.00613239f, 0.00438178f, 
    0.03074512f, -0.02570195f, 0.02996186f, 0.01537473f, -0.00859213f, 0.00808051f, -0.00150510f, 0.00693178f, 
    -0.01145168f, -0.00576250f, 0.01683148f, 0.00202544f, -0.00883153f, 0.02577817f, 0.02867999f, -0.03253811f, 
    -0.01874591f, 0.03420963f, 0.01731968f, -0.01615901f, 0.01998550f, 0.01332892f, -0.00252817f, -0.03370218f, 
    -0.02241347f, 0.01958842f, -0.01244226f, 0.01117808f, 0.01834355f, 0.00994279f, 0.00105875f, 0.02518264f, 
    -0.00136672f, -0.03428436f, -0.00138516f, 0.02280876f, 0.00216444f, 0.01838465f, 0.03580959f, 0.00931600f, 
    -0.03314492f, 0.00156912f, 0.03167341f, 0.01254364f, 0.00658824f, 0.02470347f, 0.00842630f, 0.02937149f, 
    0.00898048f, -0.03990722f, -0.00744155f, -0.02452266f, -0.04063259f, -0.02897081f, 0.01743308f, -0.02972773f, 
    -0.02429641f, 0.02689461f, -0.00648164f, -0.02626179f, 0.00848134f, -0.03068374f, -0.01520202f, 0.02546010f, 
    0.03529292f, -0.02794102f, 0.02590186f, -0.04221403f, -0.02576160f, -0.00240728f, 0.03858633f, -0.04085147f, 
    -0.02339885f, -0.02232977f, 0.00640812f, -0.01277086f, 0.02005617f, 0.02005565f, -0.00693476f, 0.02395749f, 
    0.01156569f, 0.00249851f, 0.03413339f, 0.03308057f, -0.01336694f, -0.01780107f, -0.02190511f, -0.00272790f, 
    0.02042403f, 0.01961592f, 0.02575758f, -0.03224577f, -0.04001244f, -0.01496398f, -0.03475301f, 0.02665891f, 
    -0.00213384f, -0.01025327f, -0.00997613f, 0.00902972f, 0.02532975f, 0.03869764f, 0.02077152f, -0.00056865f, 
    0.00845035f, -0.00334798f, 0.02462371f, -0.02111524f, -0.03801471f, -0.03546534f, -0.00223801f, -0.00357835f, 
    0.01748565f, -0.01704463f, -0.01302073f, -0.00171419f, -0.04079285f, -0.02582954f, -0.00946645f, -0.02699578f, 
    -0.01172076f, 0.01731821f, -0.03687997f, -0.02146820f, -0.02052141f, -0.01583661f, -0.03407782f, 0.01634129f, 
    -0.01011074f, -0.02020884f, 0.01309141f, -0.00758647f, 0.00149144f, 0.00082428f, -0.03265049f, 0.02677965f, 
    0.01394547f, -0.00291414f, 0.03760913f, 0.00679315f, -0.01097361f, -0.02350740f, 0.00983461f, 0.01359775f, 
    -0.03528295f, -0.01106851f, -0.03732321f, -0.02390842f, 0.03092631f, 0.01075589f, 0.00106236f, -0.02867892f, 
    0.00770218f, -0.00558235f, -0.00976695f, 0.02294273f, 0.01826434f, 0.00073913f, -0.02668905f, 0.01608868f, 
    0.02260900f, -0.02746370f, 0.00256462f, 0.01478199f, 0.00062631f, -0.00852750f, -0.02041670f, -0.02356896f, 
    0.01744105f, -0.01083162f, -0.03007539f, 0.03443825f, -0.00622389f, 0.02570223f, 0.02155527f, -0.00713250f, 
    -0.03158357f, -0.02301123f, 0.00121883f, -0.02208801f, 0.01523695f, 0.00121741f, -0.02231576f, 0.00005285f, 
    -0.01341689f, -0.00352434f, 0.02485406f, 0.02413365f, -0.00018442f, -0.03567856f, -0.00806440f, 0.01224854f, 
    0.01655207f, -0.01418391f, 0.02300109f, 0.00577996f, -0.03827656f, -0.02371835f, -0.02213687f, -0.02888518f, 
    0.01743416f, -0.02663032f, 0.02695758f, -0.03423706f, 0.02669161f, -0.02242058f, 0.01966466f, -0.02825944f, 
    -0.04055541f, -0.00371268f, 0.01093917f, -0.02818974f, -0.01580805f, 0.03548316f, -0.02164187f, 0.03000098f, 
    0.01517093f, 0.02184594f, -0.02703631f, -0.00773500f, 0.02370029f, 0.02816072f, 0.03773747f, -0.02707309f, 
    0.00316712f, 0.00151078f, 0.00253158f, 0.02697437f, -0.03443472f, -0.03133044f, -0.03526944f, -0.00036227f, 
    0.02225265f, 0.01927296f, -0.00290371f, -0.00626189f, 0.00138331f, 0.01834943f, -0.00654101f, -0.03095326f, 
    0.00944951f, -0.04236858f, 0.02351413f, -0.01881820f, 0.01972164f, -0.00304846f, -0.03691969f, -0.00003125f, 
    0.01478463f, 0.02293573f, -0.02236625f, -0.00103530f, -0.01356640f, -0.00137510f, 0.02317645f, -0.03471323f, 
    0.01302321f, -0.01519260f, -0.03234600f, -0.02255699f, 0.02393804f, -0.02473941f, -0.00626392f, -0.02722544f, 
    0.02957509f, -0.03173351f, 0.00761249f, 0.00608502f, 0.00993692f, -0.00272223f, 0.02593920f, 0.03019568f, 
    -0.03022751f, -0.01396062f, 0.00845938f, 0.02747823f, -0.01570598f, -0.00666695f, -0.01447995f, 0.02938952f, 
    0.00864113f, -0.01343863f, 0.01670572f, 0.00569789f, -0.00355899f, -0.03135303f, -0.00964561f, -0.01346379f, 
    -0.01288099f, -0.03527861f, 0.03735241f, 0.02336609f, -0.02069616f, -0.02858338f, -0.02877098f, -0.00975773f, 
    -0.01173400f, -0.00449831f, -0.02884538f, -0.02668355f, 0.02162162f, -0.00053562f, 0.00670094f, 0.02307240f, 
    -0.04095205f, 0.01609486f, -0.03666212f, -0.00030143f, 0.00874191f, 0.01373131f, -0.03400991f, 0.01084147f, 
    0.01334852f, 0.02530633f, -0.04006920f, 0.00262877f, 0.02198946f, -0.00158780f, -0.00533897f, -0.01524929f, 
    -0.03407126f, 0.00329959f, 0.02894233f, 0.02019524f, -0.00843264f, -0.02804032f, -0.01161908f, 0.02589926f, 
    0.00801431f, 0.02852710f, -0.01177739f, -0.01046742f, -0.01320876f, 0.02703730f, 0.01548083f, -0.02002639f, 
    -0.02645545f, -0.03757897f, -0.00639310f, -0.01994629f, 0.00581277f, 0.00782712f, 0.00013462f, 0.00600879f, 
    -0.02070866f, -0.02508839f, -0.00968035f, -0.02289855f, -0.04105328f, -0.03406543f, -0.03502322f, 0.00195743f, 
    -0.02565565f, 0.01001075f, 0.02761127f, -0.03335495f, 0.01644017f, 0.00148097f, -0.00590346f, 0.02602411f, 
    0.02041689f, 0.00424899f, 0.02974538f, 0.01906692f, -0.00693719f, -0.03019485f, -0.02041448f, -0.01439078f, 
    -0.00904519f, 0.02305262f, -0.00707264f, -0.04133908f, 0.00914183f, 0.01250685f, 0.00569799f, 0.02003803f, 
    -0.01971421f, -0.02856930f, -0.04071106f, -0.02262374f, -0.01442902f, 0.00406907f, -0.00004268f, -0.01773604f, 
    -0.01156330f, 0.02157079f, -0.02527174f, -0.01838506f, -0.00882070f, -0.00566581f, -0.01981638f, 0.02770232f, 
    0.01735996f, -0.01407354f, 0.00351633f, -0.00476102f, 0.02853148f, -0.02447756f, -0.00139970f, -0.00406867f, 
    -0.00244335f, 0.01532828f, 0.00294355f, 0.02701319f, 0.02871782f, -0.02719565f, 0.00678370f, -0.01127017f, 
    0.02943342f, -0.02315200f, 0.02657849f, 0.00408097f, 0.01296120f, -0.01403564f, -0.02693572f, 0.03077826f, 
    0.02164821f, 0.03131322f, 0.02018810f, -0.01263846f, -0.01037517f, 0.00733271f, -0.03522744f, 0.00139951f, 
    0.01607058f, -0.01595609f, -0.03451796f, 0.02061842f, -0.00435086f, -0.00608416f, 0.00748814f, -0.01327561f, 
    -0.00223492f, -0.02278443f, -0.02513833f, -0.03251718f, 0.02291309f, -0.03052348f, -0.03160075f, -0.03877147f, 
    -0.00508533f, 0.00515241f, 0.02238977f, 0.02847416f, -0.01903705f, 0.00909587f, 0.00915690f, -0.03777139f, 
    0.00392634f, -0.03095608f, -0.00160448f, 0.00997360f, 0.00181487f, 0.01927539f, 0.02400570f, -0.04090421f, 
    0.00526431f, -0.04056436f, 0.01867101f, 0.01140590f, 0.02850810f, -0.00593892f, 0.02783566f, 0.02809720f, 
    0.00575391f, 0.01832203f, -0.03026772f, 0.01273265f, 0.00573493f, 0.00059028f, 0.01370506f, -0.02107774f, 
    0.02252275f, -0.01275784f, -0.03950368f, -0.02861530f, 0.01952320f, 0.02769728f, -0.03559186f, 0.01919503f, 
    -0.00275701f, 0.02552782f, -0.00818551f, -0.00196674f, -0.00375309f, 0.01091658f, 0.01051496f, -0.01665180f, 
    -0.03077901f, 0.01651629f, -0.04105058f, -0.03455096f, -0.03316057f, -0.01779987f, -0.00751129f, -0.00897713f, 
    -0.04027538f, 0.02384818f, -0.03456994f, -0.00664695f, 0.02725223f, -0.03386520f, 0.00316606f, 0.01213601f, 
    -0.02709095f, -0.01308393f, 0.02883877f, -0.03398117f, -0.02213840f, -0.03069035f, -0.03869696f, 0.00291116f, 
    -0.00395924f, -0.01219538f, -0.01728829f, 0.01712219f, 0.00485369f, 0.01992401f, -0.02909294f, -0.00447176f, 
    -0.00840415f, -0.03992904f, 0.00549583f, -0.04095846f, 0.00018551f, -0.00172253f, -0.01337096f, -0.03374801f, 
    -0.00667158f, -0.02677151f, 0.01850207f, 0.01243013f, -0.01037566f, 0.00012085f, 0.02088846f, 0.00296954f, 
    -0.04195368f, -0.00205792f, 0.01111096f, -0.03741771f, -0.00828411f, 0.01635886f, -0.03541055f, 0.00807806f, 
    -0.00519195f, -0.01570106f, 0.00689372f, -0.02917580f, 0.01638871f, -0.01823977f, 0.02072542f, 0.02185713f, 
    0.00827109f, -0.01684516f, -0.03984887f, 0.02852329f, -0.02963540f, -0.04038389f, -0.03679053f, -0.01008721f, 
    -0.01110829f, -0.00056311f, 0.00700890f, -0.04200248f, -0.04086141f, -0.00660068f, 0.01759371f, -0.03827639f, 
    -0.01672210f, -0.02384012f, -0.03893368f, -0.00464807f, 0.01204108f, -0.03271997f, 0.00770065f, -0.03030416f, 
    0.00198527f, -0.01552138f, 0.02317509f, -0.02206271f, -0.02849091f, -0.00988557f, 0.00448078f, 0.00591200f, 
    0.02668685f, -0.03241372f, -0.04191175f, 0.01768033f, 0.01810138f, -0.03554208f, -0.02791431f, -0.00487953f, 
    0.00319141f, 0.01702338f, -0.00599182f, 0.02118443f, -0.03007848f, -0.03887462f, 0.02103672f, -0.01366747f, 
    -0.03827491f, -0.02855792f, -0.01611528f, -0.00185574f, -0.02046807f, -0.00907854f, -0.01462320f, -0.02994040f, 
    -0.00777506f, -0.00638639f, -0.03283672f, -0.02524192f, -0.02463024f, 0.00305186f, 0.00048662f, -0.00533279f, 
    -0.02262838f, -0.01234502f, 0.00060322f, -0.01605944f, -0.02633627f, -0.01715953f, 0.00480644f, -0.01391832f, 
    0.02924961f, -0.00594059f, -0.03312542f, -0.02930481f, -0.02930142f, -0.00314443f, -0.00669433f, 0.01867130f, 
    0.00338814f, 0.00594998f, -0.03872650f, -0.03195775f, -0.02799467f, 0.02128042f, -0.03374330f, -0.02249235f, 
    -0.02245473f, -0.01129933f, 0.02628936f, -0.00828160f, -0.02537677f, -0.02330075f, -0.02918455f, -0.01757687f, 
    -0.02326463f, 0.01393336f, 0.01870387f, 0.00161530f, -0.03269909f, -0.04057475f, 0.02448702f, 0.02706562f, 
    0.01092823f, 0.01036538f, 0.01139812f, 0.03037593f, -0.02702695f, -0.00208834f, -0.03888185f, 0.00970869f, 
    0.01642809f, -0.00618757f, -0.01487880f, 0.00171652f, 0.02303980f, 0.01430866f, -0.00744135f, -0.03333537f, 
    -0.03803432f, 0.00099657f, 0.01648949f, -0.02147524f, 0.01334595f, -0.01778482f, 0.00133777f, -0.03430535f, 
    0.02798750f, -0.02010121f, -0.03543816f, -0.01135489f, -0.02716784f, 0.02165589f, -0.02788777f, 0.00137840f, 
    -0.03060739f, 0.00453496f, 0.00758396f, 0.00463329f, 0.00922566f, 0.00977295f, 0.00422918f, 0.00382379f, 
    -0.01948770f, -0.04190817f, 0.02383269f, -0.02154848f, -0.01068906f, 0.02720249f, 0.02003965f, -0.00435068f, 
    0.00458245f, -0.02896327f, -0.03983824f, -0.03091514f, 0.00121421f, -0.03256552f, 0.01923872f, -0.00729175f, 
    -0.00002552f, -0.01236301f, -0.00252539f, 0.02881004f, 0.01369266f, -0.00749147f, 0.00240368f, 0.00263444f, 
    -0.03808120f, -0.03001371f, -0.01266943f, 0.01830859f, 0.00233045f, 0.00902884f, -0.00788496f, 0.02186802f, 
    -0.00531518f, -0.03134647f, -0.00541715f, 0.00281754f, -0.00917556f, 0.02282656f, 0.00646761f, -0.03971554f, 
    -0.03545701f, 0.00016763f, -0.00037128f, -0.00431659f, -0.01673404f, 0.01739919f, -0.02839956f, -0.00334743f, 
    0.00122260f, -0.03205369f, 0.00359752f, 0.00155568f, -0.01739453f, 0.00692900f, -0.03145130f, -0.00035297f, 
    -0.02050478f, 0.01569460f, 0.00724903f, -0.01289498f, -0.01141644f, -0.02398811f, 0.00254475f, -0.01954030f, 
    -0.01568040f, 0.01295524f, 0.02308057f, -0.02680978f, 0.00494909f, -0.03414584f, 0.01774083f, 0.02053794f, 
    -0.00825316f, -0.00968156f, 0.02354152f, 0.00793008f, -0.02832504f, 0.00116447f, 0.02789310f, -0.04107420f, 
    0.00262740f, 0.01577332f, 0.02589021f, -0.02101994f, 0.02992521f, 0.01165323f, 0.00815713f, 0.02858974f, 
    0.00267840f, -0.00786132f, 0.02336217f, -0.00947759f, 0.02410015f, -0.00470776f, 0.02809618f, -0.00864040f, 
    -0.02001620f, 0.01475205f, -0.00500833f, 0.02848216f, 0.02173237f, -0.00699939f, -0.01704168f, -0.01087072f, 
    -0.01379513f, -0.02191867f, -0.00136588f, -0.02605433f, -0.00034897f, -0.03982805f, -0.01594409f, 0.01749020f, 
    -0.03043525f, -0.02742817f, -0.00359126f, -0.03050994f, -0.03378089f, -0.04077743f, -0.01614756f, -0.01349415f, 
    -0.00383011f, -0.03894800f, -0.02776854f, -0.02248198f, -0.03528794f, 0.01200842f, -0.03544272f, 0.01843584f, 
    -0.01636606f, -0.00303095f, 0.00074239f, -0.00829511f, -0.00986088f, 0.02367624f, 0.01599133f, -0.01684555f, 
    0.02019995f, -0.02661804f, 0.02765801f, 0.01555166f, -0.01741532f, 0.00299191f, 0.01384129f, 0.02225933f, 
    -0.02858453f, 0.01083622f, 0.02939110f, -0.02956948f, -0.01084651f, -0.03923313f, 0.01141396f, -0.01614942f, 
    -0.01581348f, 0.02083069f, 0.02674928f, 0.02367750f, -0.03985956f, -0.01421610f, -0.03047770f, 0.00254470f, 
    0.01564942f, -0.03766444f, -0.03248882f, -0.00207766f, 0.01449153f, 0.02269597f, -0.02811672f, -0.01807173f, 
    -0.03041045f, -0.02222785f, -0.02024372f, -0.01275695f, 0.00984581f, -0.03075854f, -0.00925979f, -0.04195075f, 
    -0.03307161f, 0.02330125f, 0.01074866f, -0.03909573f, -0.03221426f, 0.00581380f, -0.00813858f, -0.01964863f, 
    -0.01783180f, -0.00096885f, 0.02380913f, 0.02899983f, -0.03391154f, -0.03940905f, 0.00419879f, -0.01981513f, 
    -0.03934000f, 0.02343547f, -0.00871396f, -0.01965491f, -0.01201745f, -0.00541743f, 0.01547116f, 0.00869391f, 
    0.02093482f, 0.02950519f, 0.02397819f, -0.03587472f, -0.02934373f, -0.01248559f, -0.02779096f, -0.02628275f, 
    -0.03716703f, 0.01313242f, 0.00912208f, -0.00398782f, -0.02605403f, 0.00756949f, -0.02247850f, -0.01396783f, 
    -0.03864110f, -0.01302923f, -0.03086533f, 0.00952227f, -0.03580639f, -0.02647359f, -0.00454921f, 0.00381207f, 
    0.00135308f, 0.00240329f, -0.03202057f, -0.00249232f, -0.02274678f, 0.01057950f, -0.03440214f, 0.00328105f, 
    0.01733373f, 0.00581348f, -0.02290252f, -0.03870839f, 0.00162993f, -0.02487540f, -0.03286052f, 0.02952568f, 
    -0.03997697f, -0.01939250f, 0.00910450f, 0.00507661f, -0.02252956f, -0.03381767f, -0.01613135f, 0.00110238f, 
    0.01919683f, 0.02208110f, -0.02209790f, -0.02403089f, 0.02393860f, 0.01666665f, -0.03572755f, 0.01421265f, 
    -0.00290758f, 0.02147426f, 0.02553836f, 0.01573676f, -0.02001887f, -0.00711297f, -0.01918887f, 0.02114629f, 
    0.00893650f, 0.00001005f, -0.03003320f, -0.02381694f, -0.02431070f, 0.01420336f, -0.01401834f, -0.00423450f, 
    0.00939337f, -0.03280466f, -0.03947733f, 0.02488864f, -0.03003689f, -0.04058826f, 0.01678118f, -0.03023951f, 
    -0.01803923f, -0.02522874f, 0.02076930f, -0.03081631f, -0.00976811f, -0.01867918f, -0.03914816f, -0.02458134f, 
    -0.02050848f, 0.00421646f, 0.02906469f, -0.01628205f, -0.01238450f, -0.00590668f, 0.00430465f, 0.00847111f, 
    -0.00461315f, 0.01536369f, -0.01905408f, 0.02840954f, -0.00976329f, 0.00967371f, 0.02251195f, -0.03734398f, 
    -0.03645508f, -0.04124343f, -0.03283233f, 0.02629502f, -0.03505470f, 0.00871361f, -0.01230593f, -0.00412472f, 
    0.00435217f, -0.03446634f, 0.02155889f, -0.00011374f, -0.00372212f, -0.02553448f, -0.03108552f, 0.02694015f, 
    -0.00067696f, -0.01832335f, -0.00328720f, -0.04181044f, 0.01238352f, 0.02701536f, 0.00130196f, 0.02546075f, 
    -0.03516388f, -0.02447357f, -0.02137683f, 0.00698066f, 0.03006217f, 0.00864267f, -0.03309394f, 0.02741778f, 
    -0.04101184f, -0.02915391f, -0.02231527f, -0.04186163f, -0.03078219f, 0.01564495f, 0.00947751f, -0.04182193f, 
    -0.04051460f, -0.00379125f, -0.03843431f, -0.03940735f, -0.02745199f, 0.00522069f, -0.01592944f, 0.01927873f, 
    -0.02853353f, -0.04109379f, -0.02262869f, 0.00032846f, -0.02569188f, 0.01222108f, 0.00262280f, 0.01881025f, 
    -0.01587076f, 0.00544453f, 0.02565012f, 0.02310873f, 0.01090840f, -0.04181261f, 0.00807310f, 0.03164850f, 
    -0.03041761f, 0.01234831f, -0.00200512f, -0.04013851f, -0.01500633f, -0.02865080f, -0.03167496f, 0.02837537f, 
    -0.53222364f, 0.31153956f, 0.02056730f, -0.24553896f, 0.14064421f, -0.12974951f, 0.01053640f, -0.00115425f, 
    -0.04378181f, -0.01029052f, -0.05191378f, 0.01593237f, 0.11543527f, -0.16312771f, 0.09406840f, 0.11655034f, 
    -0.05128363f, 0.08441225f, 0.02584761f, -0.03611020f, -0.04512047f, -0.00771494f, 0.04044067f, 0.10005774f, 
    0.28421408f, -0.05763109f, 0.13018377f, -0.09548042f, 0.05081052f, -0.04621927f, -0.09677691f, 0.05343321f, 
    0.07069550f, 0.03406798f, -0.05942106f, 0.02116220f, -0.02744185f, 0.09383682f, 0.13156345f, -0.24086784f, 
    0.20171395f, 0.00634592f, -0.00510333f, 0.02664499f, 0.03528536f, -0.02680675f, -0.06065614f, 0.00995953f, 
    -0.11558363f, -0.08749372f, 0.06326073f, -0.22134769f, -0.04291088f, -0.05188321f, 0.03265204f, 0.03098003f, 
    0.02054142f, -0.02013407f, 0.06686541f, 0.13023852f, -0.15255684f, -0.17475750f, -0.04590461f, 0.14659759f, 
    -0.03999643f, 0.06684510f, -0.00004784f, 0.01673440f, -0.00982883f, -0.05129855f, 0.03599624f, -0.01769565f, 
    -0.39839470f, -0.06800575f, -0.14680141f, -0.00565252f, 0.01934900f, 0.05569299f, 0.06835365f, -0.01790791f, 
    -0.13749659f, -0.01564014f, 0.03800427f, -0.04887024f, -0.19290669f, 0.23187096f, -0.11676032f, 0.20504491f, 
    0.03820430f, -0.04071056f, -0.06568794f, 0.03409662f, 0.20220914f, 0.05094900f, 0.01570368f, 0.02146822f, 
    0.00229576f, 0.12032429f, -0.04628125f, -0.02438250f, -0.01117806f, 0.08576202f, -0.00594673f, 0.11298998f, 
    -0.05388931f, 0.05168627f, 0.03188583f, 0.11112021f, -0.02235230f, 0.06355570f, 0.15411553f, -0.19588619f, 
    0.12235797f, -0.01423884f, -0.02117166f, 0.04064460f, 0.00374471f, -0.02605182f, -0.06114637f, -0.03826123f, 
    0.08219787f, 0.08685323f, -0.02297490f, -0.08626571f, 0.04075751f, 0.02247254f, 0.03782601f, -0.03329280f, 
    0.02073927f, -0.00446677f, 0.13048092f, 0.06357907f, -0.15075831f, -0.09406339f, -0.09085698f, 0.05089174f, 
    0.06966419f, 0.06305594f, 0.10846172f, 0.07127880f, 0.12389538f, 0.03889826f, 0.04814468f, 0.11248270f, 
    -0.02898513f, 0.06712018f, -0.11161604f, -0.14669530f, 0.06357880f, -0.04853531f, 0.06984389f, 0.09025091f, 
    0.04453639f, -0.02410537f, 0.04237138f, -0.03253431f, -0.17243600f, 0.01155270f, 0.01571844f, 0.08082067f, 
    0.15461470f, 0.02741558f, -0.06440970f, 0.05589896f, 0.12424564f, 0.00904929f, -0.00458368f, -0.03902563f, 
    0.09248904f, -0.03849560f, -0.08178501f, -0.01007948f, -0.00208793f, 0.08047583f, 0.02409852f, -0.00774080f, 
    -0.08916581f, -0.02378549f, 0.00038934f, 0.00482059f, -0.05090695f, 0.22146267f, 0.06231439f, -0.08180112f, 
    -0.04125431f, 0.04220501f, -0.12309547f, 0.06194432f, 0.12070035f, -0.03515872f, 0.03131315f, 0.13320994f, 
    0.02513609f, -0.10550725f, 0.01529203f, 0.03087268f, 0.05523151f, 0.03705943f, -0.00084870f, 0.09075250f, 
    0.10399044f, -0.01191135f, 0.13077311f, 0.05348839f, 0.03052887f, 0.09140397f, 0.11665037f, 0.06577490f, 
    -0.05236440f, -0.00348556f, 0.09199254f, -0.02876514f, -0.01746076f, -0.01302561f, 0.07065199f, -0.02486264f, 
    0.05378876f, 0.06290650f, 0.11635489f, -0.00301009f, 0.14639857f, -0.09575674f, 0.01043841f, -0.07359477f, 
    -0.00436950f, 0.02444805f, 0.09635240f, 0.00286845f, 0.10068365f, -0.04523647f, -0.03652015f, 0.05670879f, 
    0.03066985f, 0.01171841f, 0.10490768f, 0.11624212f, 0.01503266f, -0.07116214f, 0.10507214f, 0.07161348f, 
    0.27640304f, -0.04720811f, 0.10420989f, -0.11745314f, 0.05760383f, 0.00942000f, -0.05612443f, 0.04609984f, 
    0.04536586f, 0.01413624f, 0.07282632f, -0.04064635f, -0.06901181f, -0.04996403f, -0.07170695f, -0.08085553f, 
    0.01412134f, -0.04614504f, 0.00416212f, 0.04108954f, 0.01835607f, -0.01551423f, 0.02641244f, -0.01791597f, 
    0.04180818f, -0.05976632f, -0.04444391f, 0.17569679f, -0.01941704f, -0.01750021f, -0.05092607f, 0.02827845f, 
    0.01846196f, 0.05963465f, 0.10576242f, 0.03214869f, 0.16304986f, -0.02045898f, 0.02577890f, 0.04973787f, 
    -0.08313160f, -0.08098405f, 0.03244898f, 0.09860075f, 0.14993730f, 0.12291279f, 0.01697861f, 0.08867080f, 
    0.06530943f, -0.00301872f, 0.00982777f, -0.04657989f, 0.13001497f, 0.03552874f, 0.08515304f, -0.06362603f, 
    0.10435954f, 0.10191940f, 0.07173864f, 0.09705222f, -0.11248469f, -0.16267236f, -0.08131815f, 0.13372956f, 
    -0.03394865f, -0.00193330f, -0.07537936f, -0.09762955f, -0.00853440f, 0.04981340f, 0.04682777f, 0.04424586f, 
    0.19204283f, -0.19603620f, 0.06299513f, -0.09353415f, 0.04895230f, 0.13225433f, 0.04280116f, 0.07231341f, 
    -0.09062044f, 0.04211355f, 0.12570176f, 0.05002142f, -0.59817880f, 0.10317556f, -0.08003067f, -0.07933805f, 
    0.13599668f, 0.03503194f, 0.03556723f, 0.05705351f, 0.06107132f, 0.00966356f, 0.02600918f, -0.04618696f, 
    0.13322605f, 0.04443816f, -0.01674745f, -0.04262822f, 0.07860269f, -0.01828996f, 0.03032409f, 0.02024783f, 
    0.01341724f, -0.00024624f, -0.08380663f, 0.00064385f, 0.15829025f, 0.06613636f, 0.09004508f, 0.11891183f, 
    0.07451168f, 0.10119399f, 0.04846013f, 0.04723996f, 0.20523876f, -0.03940706f, 0.01582586f, 0.06274676f, 
    0.26121145f, -0.08329518f, 0.21978329f, -0.19583398f, 0.18145373f, 0.03133912f, -0.06446478f, 0.04265215f, 
    0.07273914f, 0.06950291f, 0.05215597f, 0.00409639f, -0.03987378f, 0.05309344f, 0.01112203f, -0.24635166f, 
    0.10829782f, -0.08610396f, 0.14399943f, -0.01330903f, -0.01079115f, -0.03418987f, 0.04313821f, 0.03773634f, 
    -0.24094008f, -0.01900519f, -0.03260084f, 0.00652413f, 0.00639566f, -0.09567717f, 0.11970647f, -0.16923930f, 
    -0.04979291f, -0.00471204f, -0.02827991f, -0.06412130f, -0.31794161f, -0.11416696f, -0.17044380f, -0.10219710f, 
    0.06847414f, 0.00981979f, -0.07823879f, 0.02946214f, 0.03805412f, 0.00636418f, 0.03063015f, -0.01091828f, 
    -0.29827291f, 0.28172484f, -0.09974352f, 0.09590173f, 0.04147787f, -0.11459180f, 0.05233268f, 0.12554324f, 
    0.11057342f, -0.06659933f, 0.00347414f, -0.00453874f, 0.07044950f, -0.00811244f, 0.02043330f, 0.13747185f, 
    -0.01674931f, 0.00756415f, 0.04191129f, 0.03101383f, -0.06499480f, 0.06249846f, -0.01177451f, -0.16720887f, 
    0.04481933f, 0.14423162f, 0.02893395f, 0.00824349f, -0.07017982f, 0.01344607f, 0.00445974f, 0.10143711f, 
    0.04952503f, 0.04474241f, 0.03441358f, 0.00563840f, -0.20087579f, 0.11211779f, -0.06937472f, -0.10973236f, 
    0.13996989f, -0.02519298f, 0.07446435f, -0.00703368f, -0.03213932f, 0.05571641f, 0.05187351f, -0.02110049f, 
    0.21429090f, 0.16898805f, 0.16416529f, 0.12580293f, 0.00778307f, -0.02572416f, -0.02069933f, -0.05588821f, 
    0.05261317f, -0.01083062f, -0.05861948f, 0.05631938f, -0.12514192f, 0.02857585f, 0.07197962f, -0.02477532f, 
    0.06571019f, 0.01848454f, -0.07025723f, 0.07615353f, 0.00891894f, 0.06998859f, 0.03996539f, -0.00893075f, 
    -0.07357898f, -0.04784689f, 0.04925213f, 0.02607737f, 0.01981917f, 0.01475760f, 0.07693405f, 0.07958034f, 
    0.10465495f, 0.05993833f, 0.02869577f, 0.05970823f, -0.31903440f, 0.10611359f, -0.11523210f, -0.11962287f, 
    0.07916854f, 0.04338789f, 0.07545044f, -0.00587473f, 0.05477831f, -0.10644013f, 0.17620665f, -0.01761581f, 
    0.06578654f, -0.14455998f, 0.12829134f, 0.03482774f, -0.04062901f, 0.15728909f, 0.07110639f, -0.02405459f, 
    0.09200684f, 0.01650894f, 0.03324591f, 0.14670901f, 0.04848486f, -0.08340078f, 0.09262219f, 0.11059900f, 
    0.04493980f, -0.07640937f, -0.02861883f, -0.01616510f, 0.03390711f, -0.04142212f, 0.01830044f, -0.05187529f, 
    -0.15319936f, -0.26225802f, -0.03305640f, 0.10478896f, -0.04302272f, -0.04405559f, -0.08920030f, -0.03339327f, 
    0.11349849f, 0.11835185f, -0.02580933f, -0.05961580f, -0.08331963f, 0.06439913f, -0.05742225f, 0.05561183f, 
    0.02948579f, -0.02771343f, -0.07216737f, 0.01328235f, 0.09777584f, 0.00046535f, 0.09425264f, -0.01002993f, 
    -0.20277999f, -0.15557693f, -0.01355413f, 0.10901277f, 0.02268791f, 0.04323903f, 0.02138367f, 0.03343581f, 
    -0.11491320f, -0.01431359f, 0.01442238f, 0.05555988f, -0.05467851f, -0.09732749f, 0.02414206f, 0.02653065f, 
    -0.00251648f, -0.01916288f, 0.05166712f, 0.03017244f, -0.04863339f, 0.12311866f, 0.02070414f, 0.03725447f, 
    -0.01774384f, 0.03590136f, 0.06969915f, -0.08940935f, 0.22711417f, 0.05308658f, 0.04118301f, -0.07860558f, 
    0.04731585f, 0.07264485f, -0.01670720f, -0.01483573f, -0.11618932f, 0.06485552f, 0.01720535f, 0.22987875f, 
    0.06218208f, 0.05899261f, -0.15137288f, -0.06814372f, 0.10542105f, -0.00662500f, -0.04752483f, -0.03254303f, 
    0.12629016f, -0.10383499f, 0.06530559f, 0.25498015f, -0.04897991f, 0.13193899f, -0.01915886f, -0.02679747f, 
    -0.02148190f, 0.01225901f, 0.01328640f, -0.02905954f, 0.08920670f, -0.00794449f, -0.01044328f, -0.17797211f, 
    0.00031344f, 0.06596132f, 0.01602530f, 0.10660133f, -0.02923045f, 0.08173930f, 0.00357799f, 0.02002217f, 
    0.03045247f, -0.01455874f, 0.09888870f, -0.11208431f, 0.04211834f, -0.02085780f, 0.02872440f, 0.06918553f, 
    -0.06023020f, 0.03082423f, 0.07590830f, 0.03982082f, -0.20077392f, 0.10954412f, -0.02161611f, 0.07744124f, 
    0.04421713f, -0.00878415f, 0.02993783f, 0.03444266f, 0.01845721f, 0.06351108f, -0.07089429f, 0.04569446f, 
    -0.20219840f, -0.11972817f, -0.04854653f, 0.10239756f, 0.04550882f, 0.07051918f, 0.01068296f, -0.09878777f, 
    -0.05241406f, 0.08231744f, 0.03826931f, -0.06258567f, 0.00717268f, -0.20050053f, 0.09784621f, 0.21749507f, 
    -0.12079097f, -0.01558541f, 0.00260236f, -0.02948834f, -0.02033940f, 0.00753146f, -0.02996662f, -0.01783993f, 
    -0.03415607f, -0.21791491f, 0.06004060f, 0.14004570f, 0.07124562f, -0.01516902f, -0.13498583f, -0.07808519f, 
    0.01866945f, -0.02116685f, 0.09067962f, 0.01943097f, -0.24550430f, -0.01259293f, -0.07776625f, -0.14298780f, 
    0.09104384f, 0.03789295f, 0.06287482f, 0.07399457f, 0.07798138f, -0.00063619f, 0.04401945f, -0.05186224f, 
    -0.11416602f, -0.02173203f, -0.01238327f, -0.10023618f, 0.07905568f, 0.02380225f, 0.01302801f, 0.13226134f, 
    -0.09858017f, 0.03238702f, 0.00778769f, 0.01928186f, -0.10022677f, 0.19417547f, 0.04209519f, 0.08764175f, 
    0.01458974f, -0.02436385f, 0.02504667f, -0.11099402f, 0.07116453f, -0.01757823f, 0.02505733f, -0.04938804f, 
    0.01344500f, -0.03716699f, 0.01594676f, -0.16256280f, 0.08364120f, 0.07550937f, 0.09179885f, 0.05902512f, 
    0.02170864f, 0.01154848f, 0.01773784f, 0.09354289f, -0.11130745f, -0.04538043f, -0.05862533f, 0.05100916f, 
    -0.00751757f, -0.11852386f, -0.11268970f, 0.10526710f, -0.12390301f, -0.03938286f, 0.05963834f, -0.03463058f, 
    0.01114898f, 0.08721970f, 0.02056023f, -0.08441599f, 0.06877563f, -0.03148534f, -0.08510710f, 0.05686608f, 
    -0.00277287f, 0.01241051f, 0.04619222f, 0.10967557f, -0.15148053f, -0.07631531f, -0.08336078f, 0.15854876f, 
    -0.09390309f, 0.00696169f, -0.05854400f, -0.11784477f, -0.00198822f, -0.03264749f, -0.06985551f, -0.07122678f, 
    0.01090753f, -0.02283394f, -0.01550391f, 0.03328275f, 0.00912441f, -0.03491348f, -0.01174758f, -0.03690667f, 
    0.00504715f, -0.02186225f, 0.03811225f, 0.02470799f, 0.03735386f, -0.01999127f, -0.02614376f, 0.00869934f, 
    -0.02292964f, -0.00667763f, -0.03654287f, 0.02216163f, 0.01337568f, 0.02203139f, 0.02582626f, -0.01153009f, 
    0.00449246f, -0.04320698f, -0.00924288f, -0.01821734f, 0.01596911f, -0.01465150f, -0.00157515f, 0.00272361f, 
    0.00182706f, -0.00710040f, -0.00709936f, -0.01295481f, -0.02270901f, 0.02400224f, 0.02909063f, -0.04081040f, 
    -0.02026341f, -0.00235561f, -0.00872723f, -0.00027719f, -0.03897998f, -0.01508966f, 0.00012162f, 0.02813732f, 
    -0.01108860f, -0.01294603f, 0.03048291f, -0.03407702f, -0.01562340f, -0.01349584f, 0.00998653f, -0.02326732f, 
    0.03074954f, 0.02782359f, 0.00019777f, -0.02022186f, 0.01164504f, 0.01315290f, -0.02506552f, -0.00244516f, 
    -0.00576418f, -0.01973915f, 0.02143994f, 0.03062430f, 0.02810492f, -0.03096550f, -0.01155445f, 0.02345371f, 
    -0.03961831f, -0.00085101f, 0.02382765f, 0.00523144f, 0.00853417f, 0.00199810f, 0.02557121f, -0.02955362f, 
    0.00274172f, -0.00516022f, -0.04085425f, 0.01335673f, -0.00254836f, -0.02837483f, -0.02276922f, 0.02722673f, 
    0.00432404f, -0.04497368f, -0.01717097f, -0.01691126f, -0.03198951f, 0.02119987f, -0.00996414f, 0.00129263f, 
    -0.03891214f, -0.00922980f, -0.01446945f, -0.00709571f, -0.00285931f, 0.00472326f, -0.02236632f, -0.00907816f, 
    -0.04160378f, 0.01254291f, -0.02258607f, -0.02774010f, 0.02118739f, -0.00452753f, -0.03345097f, -0.00382748f, 
    -0.02197924f, -0.02063263f, 0.01144861f, -0.01192093f, 0.02641373f, 0.02577677f, -0.02620094f, 0.01076239f, 
    0.00705033f, -0.03253673f, 0.03646212f, -0.01806454f, -0.03460737f, 0.01038601f, 0.01562497f, 0.00463731f, 
    0.00572352f, 0.01811099f, 0.00184147f, -0.02444635f, 0.00470329f, -0.02045347f, -0.01281739f, -0.02779353f, 
    -0.00988980f, 0.02580727f, 0.00350237f, 0.00653771f, -0.01097414f, -0.00964249f, 0.02564920f, -0.02382804f, 
    0.00132035f, -0.01059073f, -0.02114855f, 0.00168889f, 0.02900392f, -0.00741481f, -0.02104717f, -0.01610360f, 
    -0.03450675f, -0.03608111f, 0.02331568f, -0.02256991f, 0.02618650f, -0.00665312f, -0.00482000f, -0.03086091f, 
    -0.01804596f, -0.01978392f, 0.00627790f, -0.00423721f, -0.02645882f, 0.00129242f, 0.02723378f, -0.03833823f, 
    -0.02466769f, 0.01416728f, -0.01252475f, -0.03810900f, -0.02001899f, -0.01639869f, -0.03161055f, 0.02030720f, 
    -0.01958829f, -0.00144735f, -0.01417611f, -0.00581956f, 0.01856070f, 0.01476890f, -0.01836146f, 0.01396849f, 
    -0.02029856f, -0.00757483f, -0.00884997f, 0.00589143f, -0.03469243f, 0.01887454f, 0.00386425f, 0.00188542f, 
    0.00796095f, 0.02312720f, 0.02334484f, 0.02191739f, 0.02773489f, 0.02613820f, 0.02376340f, -0.00799295f, 
    -0.03124149f, 0.02204071f, -0.02789981f, 0.00816892f, -0.02091571f, -0.02673013f, -0.00295833f, -0.03155033f, 
    -0.01167683f, 0.01328153f, -0.01379631f, 0.02658133f, -0.00264374f, -0.02321326f, 0.00238135f, -0.01577191f, 
    0.02380389f, -0.02253232f, 0.02338145f, 0.00869494f, -0.03407566f, 0.01922297f, -0.01648544f, 0.02236212f, 
    -0.01505866f, 0.01154187f, 0.01932382f, 0.01130796f, -0.02953034f, 0.02304572f, -0.01025562f, -0.01034498f, 
    0.02768663f, 0.01678935f, 0.01958424f, 0.03552122f, 0.02829064f, 0.01487638f, 0.01206287f, 0.02614671f, 
    -0.00696807f, -0.02342009f, 0.01191563f, -0.03051745f, 0.01917488f, 0.01531773f, -0.04091960f, -0.02209589f, 
    0.00662651f, -0.00585857f, -0.00026551f, 0.03021320f, -0.01426159f, -0.03373653f, 0.03531817f, 0.02419810f, 
    -0.01352512f, 0.02426561f, -0.03476416f, -0.02510641f, 0.00202152f, -0.03436019f, 0.01521215f, 0.01639546f, 
    0.00406907f, -0.01105729f, -0.04042790f, -0.00602783f, 0.01636691f, 0.01906375f, 0.01505604f, -0.00385864f, 
    -0.02080087f, 0.01594196f, 0.01917482f, -0.03804703f, -0.00045916f, 0.00205887f, 0.00269471f, 0.02147173f, 
    0.02025786f, 0.03459572f, -0.02689897f, -0.02213610f, -0.01660866f, 0.02523168f, -0.01794790f, 0.00928634f, 
    -0.03805146f, 0.02756049f, -0.02985248f, 0.01157090f, 0.01414274f, 0.02579521f, 0.01494702f, -0.03175584f, 
    0.02450475f, -0.00402159f, 0.00683491f, -0.01128647f, -0.00805793f, -0.01323203f, -0.03319420f, -0.00494474f, 
    -0.03903621f, 0.01916262f, -0.02162158f, -0.02940332f, -0.00745729f, -0.00516406f, -0.00647524f, -0.01761803f, 
    0.02492252f, -0.00039065f, 0.02146591f, -0.03621767f, 0.00037199f, -0.03413393f, 0.01981392f, -0.02305467f, 
    0.02075650f, -0.03573366f, -0.00860633f, 0.02569071f, -0.02435309f, 0.01641891f, -0.03385366f, -0.04123428f, 
    0.00847673f, -0.02466878f, -0.00899401f, -0.02158821f, 0.02505151f, -0.02214241f, 0.01294394f, 0.00478986f, 
    0.00143808f, -0.02853856f, -0.00785840f, -0.02271965f, 0.00134729f, 0.01230432f, -0.01158756f, 0.00895406f, 
    0.01235503f, -0.00859218f, -0.02800389f, 0.01579440f, 0.04050320f, -0.03698194f, 0.00162848f, -0.00608157f, 
    0.00332649f, -0.00658942f, 0.00825391f, -0.04098934f, 0.03639817f, 0.00088088f, 0.01855167f, 0.00928899f, 
    0.02728163f, -0.03675676f, 0.00699721f, -0.02852816f, -0.03873368f, -0.03112309f, 0.01995921f, 0.03187178f, 
    0.02277411f, -0.02490381f, -0.01771438f, -0.00927363f, 0.03359491f, -0.03839507f, -0.00294806f, -0.03348147f, 
    -0.00387806f, 0.00226912f, -0.01263433f, 0.01886428f, 0.00149261f, 0.03304002f, -0.00976270f, -0.02371210f, 
    0.01396608f, -0.05174292f, 0.02205946f, -0.01658502f, 0.00440519f, 0.02356947f, 0.00904110f, -0.00537385f, 
    0.02665650f, 0.00768581f, 0.00769092f, 0.01708583f, 0.02171485f, -0.03118652f, 0.00331209f, -0.03709213f, 
    -0.02708917f, 0.00256286f, 0.03007441f, 0.01940543f, -0.03643769f, -0.03230529f, -0.03030598f, 0.02322018f, 
    -0.03320596f, 0.00246766f, -0.04133306f, 0.03124774f, -0.03436641f, 0.00123277f, -0.03179013f, -0.05141582f, 
    -0.03746621f, -0.03050111f, -0.00526650f, -0.02964862f, 0.01277306f, -0.00686168f, -0.03200607f, 0.01430547f, 
    -0.00127378f, -0.01475789f, 0.01037361f, 0.02717906f, -0.01139276f, -0.02440508f, 0.02279143f, 0.01288056f, 
    -0.01779037f, 0.01653599f, 0.03586760f, 0.03109356f, 0.01492026f, 0.00907151f, 0.02598851f, 0.02407963f, 
    -0.00584422f, 0.02196052f, 0.01529034f, -0.02026271f, 0.00912193f, 0.00481396f, 0.00088745f, -0.02996317f, 
    0.01638388f, -0.00135086f, -0.01936444f, 0.01396174f, 0.01396047f, 0.03526274f, -0.00925107f, -0.00813227f, 
    0.01729593f, 0.00268892f, -0.02951221f, 0.01977611f, -0.01389856f, 0.02900905f, -0.01297941f, -0.02156349f, 
    -0.01107099f, 0.01854492f, -0.01449756f, -0.04287805f, 0.02314452f, 0.00592994f, -0.03368852f, 0.00306250f, 
    -0.01687317f, -0.00934357f, 0.02422244f, 0.01187334f, -0.02504243f, 0.02249800f, -0.01632110f, 0.02251529f, 
    -0.02217776f, 0.00592546f, 0.00390896f, -0.01203962f, 0.03308317f, 0.01042201f, 0.01397269f, -0.00599019f, 
    -0.01198349f, -0.02838279f, 0.02176373f, -0.02501920f, 0.00170005f, -0.01941888f, 0.01709734f, -0.00182882f, 
    0.00674580f, 0.00379906f, -0.01220445f, 0.03121172f, 0.02000910f, -0.03280525f, 0.01007724f, -0.02890550f, 
    -0.00764591f, -0.03926829f, -0.01212546f, 0.00286680f, -0.01533505f, -0.02809829f, -0.01796737f, -0.01217087f, 
    0.00552270f, -0.02760407f, -0.01925826f, 0.00419236f, 0.01402778f, -0.00598042f, 0.00581503f, -0.01809511f, 
    -0.03221179f, -0.01225583f, 0.00899909f, 0.02841244f, -0.00091711f, 0.01302988f, 0.01789882f, -0.02656046f, 
    -0.01736021f, 0.01439523f, -0.00376279f, 0.00053881f, -0.02187942f, 0.00738780f, -0.01753045f, 0.02160669f, 
    0.00909045f, 0.02827171f, -0.03347669f, 0.02161297f, -0.00414045f, 0.03465034f, 0.00673557f, -0.00065273f, 
    0.00362179f, -0.01680121f, -0.02266454f, -0.03675001f, 0.00143010f, -0.00246433f, -0.03556384f, -0.01406139f, 
    0.02051855f, -0.01428214f, -0.03030613f, 0.01906228f, -0.02469221f, -0.03546434f, -0.02408682f, 0.03070650f, 
    0.02974287f, 0.00323808f, -0.01964801f, 0.00627013f, -0.03817660f, -0.01723099f, -0.02629667f, 0.01892449f, 
    -0.01499916f, 0.00083486f, 0.00021890f, 0.00338879f, 0.02393737f, -0.03149939f, 0.01531945f, -0.01973360f, 
    0.01988581f, -0.04601010f, 0.00550513f, 0.00511596f, -0.02049849f, -0.00867041f, -0.03358376f, 0.00770835f, 
    0.00805223f, -0.00195860f, 0.01653779f, 0.00386487f, 0.01116775f, -0.00475226f, 0.00501142f, -0.00710523f, 
    0.00632180f, -0.03089580f, -0.02654237f, -0.00235611f, 0.00332568f, 0.01896637f, -0.02288586f, -0.01254494f, 
    0.03656656f, 0.01622062f, 0.00980142f, 0.02784009f, 0.02292620f, -0.00705849f, 0.01474698f, -0.00497199f, 
    -0.03933997f, 0.01945859f, 0.01411660f, -0.03678194f, 0.02179746f, 0.02194380f, -0.02908801f, 0.01705153f, 
    -0.00641552f, -0.01199628f, 0.00829401f, 0.02392955f, -0.04106770f, -0.03112718f, -0.01989926f, 0.02384041f, 
    0.01781391f, -0.01611100f, 0.02837150f, -0.00053950f, 0.00537028f, -0.01832978f, -0.02480345f, -0.04244480f, 
    -0.00340924f, -0.03223720f, 0.00065489f, -0.03606223f, 0.03079278f, 0.01839328f, 0.01482273f, 0.02369475f, 
    0.02138351f, 0.01689124f, -0.01498876f, -0.03597727f, -0.03714271f, -0.01071917f, -0.03908147f, -0.01314269f, 
    -0.03150158f, -0.02412754f, -0.00772615f, 0.00875268f, 0.02316546f, 0.01534187f, -0.01367282f, 0.00757288f, 
    0.02850602f, -0.01935728f, 0.03344174f, -0.01571695f, -0.04183095f, -0.03904402f, -0.03536706f, -0.04153711f, 
    -0.00226851f, 0.02458991f, -0.01759848f, -0.03514943f, -0.01895263f, 0.01471634f, -0.01395511f, -0.01193218f, 
    -0.02370198f, -0.01363868f, 0.02188379f, -0.00261344f, 0.01892505f, -0.00879731f, 0.01095441f, -0.03249379f, 
    0.02577090f, -0.01567368f, -0.02447280f, -0.00354428f, 0.02077612f, -0.04050621f, -0.02232932f, -0.01485407f, 
    0.02841237f, 0.00801606f, -0.02576488f, -0.03906519f, 0.00798583f, -0.03950601f, -0.00645383f, -0.03796926f, 
    -0.03946248f, 0.01341203f, -0.00608745f, -0.02538606f, -0.01790795f, 0.01983741f, -0.00319481f, 0.02723279f, 
    0.02904082f, -0.03280289f, 0.03184644f, -0.02149067f, 0.01726610f, 0.03401545f, 0.00587625f, -0.02432941f, 
    0.00806832f, 0.00778940f, -0.03243844f, -0.00069197f, -0.01786521f, 0.00799554f, -0.03835773f, -0.03765306f, 
    0.01520031f, 0.02032800f, 0.00758110f, 0.01822143f, 0.02144198f, 0.02216246f, 0.02436337f, -0.00461527f, 
    0.01986866f, -0.00961902f, 0.03815177f, -0.01367069f, 0.03360795f, -0.00750410f, -0.02267677f, -0.04360427f, 
    -0.00578673f, -0.02894213f, -0.00610543f, 0.00574460f, 0.00176239f, 0.00712223f, -0.03899026f, 0.01447794f, 
    0.00228896f, 0.01939059f, -0.01388433f, 0.00016070f, -0.01108076f, 0.02818434f, 0.03106430f, -0.01654277f, 
    -0.04411738f, 0.01909835f, -0.03941135f, -0.03668803f, 0.00368748f, 0.00383245f, -0.01723876f, -0.00436200f, 
    -0.00991374f, -0.03111654f, -0.01413358f, 0.02936767f, -0.01970100f, -0.00275144f, -0.00371634f, 0.00950907f, 
    0.06132691f, -0.00055330f, 0.04259133f, -0.01958642f, 0.00849201f, -0.15233377f, 0.11760782f, 0.05923097f, 
    0.04160052f, -0.00693054f, -0.04941127f, 0.00137748f, -0.06678683f, 0.11178903f, 0.09607363f, 0.14739381f, 
    -0.09859664f, 0.04775909f, 0.00105220f, 0.03919907f, 0.02661656f, -0.02158304f, 0.01675156f, 0.04798903f, 
    0.45921066f, -0.25344130f, -0.07350630f, -0.03466834f, -0.04751595f, -0.01383136f, -0.04037262f, -0.02367659f, 
    -0.00794612f, -0.05289196f, -0.01625351f, 0.07514196f, 0.26666439f, -0.03899389f, 0.15630479f, -0.17302735f, 
    0.02898140f, -0.02491545f, -0.01659396f, -0.00000916f, 0.06789593f, -0.08299091f, 0.07589696f, -0.05777238f, 
    -0.01484086f, -0.12195228f, 0.17708136f, 0.02789109f, 0.22937399f, 0.08417263f, -0.07654159f, -0.05382340f, 
    0.06503332f, 0.10781634f, -0.01959142f, -0.03011553f, -0.09799040f, 0.09056532f, -0.07273486f, 0.06775858f, 
    0.03668460f, 0.02039247f, -0.01912744f, 0.05651105f, 0.04912668f, 0.00983703f, 0.02848917f, -0.04656420f, 
    -0.18117216f, 0.11226076f, 0.15733044f, 0.11497887f, 0.08033695f, 0.04109551f, 0.03801168f, -0.12725826f, 
    0.00695010f, -0.18721497f, 0.03603650f, -0.05109135f, 0.04418047f, 0.12441989f, -0.18587726f, -0.07205049f, 
    0.02365097f, 0.08506636f, 0.01285947f, -0.01634815f, 0.11380259f, -0.02668512f, -0.07871800f, -0.04037273f, 
    0.11649573f, -0.00208346f, 0.02460448f, -0.00834515f, -0.05227571f, 0.14081837f, 0.00203529f, 0.01380912f, 
    0.06101960f, -0.00644318f, -0.05468540f, 0.11089164f, 0.31141433f, 0.20788045f, 0.02288044f, -0.03785836f, 
    0.06690627f, -0.09560988f, -0.03506913f, 0.04652546f, 0.05904153f, 0.12504365f, 0.00988747f, 0.04429623f, 
    0.15779571f, -0.13163665f, 0.20602244f, 0.01757411f, 0.05103140f, 0.05422301f, 0.00856848f, -0.08949082f, 
    -0.04003776f, 0.04069263f, 0.03336303f, 0.11365026f, -0.15819401f, -0.02102286f, -0.00106889f, -0.11071949f, 
    0.12234049f, -0.09821097f, -0.05436103f, -0.03670500f, 0.00766204f, 0.03231692f, 0.00825780f, 0.16529562f, 
    0.11544631f, -0.07398354f, 0.05604939f, 0.13492280f, 0.05464954f, -0.01041267f, -0.02414338f, -0.00467877f, 
    0.02656569f, 0.00962458f, -0.01326404f, 0.03461064f, -0.04459035f, -0.04599966f, -0.07045956f, -0.04817768f, 
    0.07555245f, -0.03572497f, -0.07811527f, -0.03133187f, 0.02909559f, -0.11000033f, -0.02232228f, -0.04192879f, 
    -0.18750305f, 0.10790318f, 0.04338585f, -0.27817664f, -0.06709508f, -0.06389424f, 0.01485499f, -0.10702410f, 
    0.04846625f, 0.00388281f, -0.07856380f, 0.08033508f, -0.10472199f, 0.08930466f, -0.04199876f, -0.09555309f, 
    -0.07279046f, 0.07429401f, -0.07160304f, 0.03218961f, 0.00960500f, 0.09884871f, 0.08679118f, -0.02182774f, 
    0.07100466f, 0.12593496f, 0.03954751f, 0.02395089f, 0.07932606f, -0.03935534f, -0.04010323f, -0.05597439f, 
    0.14850076f, 0.09629519f, 0.04418221f, -0.04627926f, -0.00665997f, 0.04445386f, -0.10295806f, -0.15318535f, 
    -0.04136083f, -0.05006693f, 0.01214569f, 0.02214013f, 0.04836555f, -0.11674699f, 0.02068376f, -0.02056638f, 
    0.22103220f, 0.04860876f, -0.00680578f, 0.00898914f, -0.02328141f, -0.05478814f, -0.14074895f, 0.04372687f, 
    0.05070638f, 0.09259169f, 0.06527741f, 0.00625111f, -0.16008301f, -0.08653162f, 0.01411793f, -0.18170328f, 
    -0.04931235f, -0.03657493f, 0.03814648f, -0.05268763f, 0.16897947f, -0.04291154f, 0.01892564f, 0.01279549f, 
    0.30185044f, 0.05270042f, -0.12887552f, 0.04216906f, 0.08655100f, 0.06012490f, -0.03877231f, 0.10011216f, 
    0.11411030f, 0.12466329f, 0.09046166f, -0.01572655f, -0.03636250f, -0.06921332f, 0.05748421f, 0.06894576f, 
    -0.01434967f, -0.04467188f, 0.03743807f, 0.07810847f, 0.04745156f, 0.05224575f, 0.05715222f, 0.02340149f, 
    0.18872914f, 0.18526766f, -0.25013614f, 0.20103100f, 0.01349819f, 0.09327975f, -0.04264767f, -0.01297566f, 
    0.00578780f, 0.12070587f, 0.10002238f, -0.02160931f, 0.03990279f, -0.06608091f, -0.13771743f, -0.20806809f, 
    0.03258567f, 0.03548435f, -0.03544488f, -0.12854671f, -0.11045410f, 0.02112677f, 0.02516027f, 0.00886190f, 
    -0.03013750f, 0.05588488f, 0.09005293f, -0.19335562f, 0.03925645f, 0.00877755f, -0.11609317f, 0.10153297f, 
    -0.02892052f, 0.06521247f, 0.11834204f, 0.06501880f, -0.26449597f, -0.11578401f, 0.14495489f, 0.06044742f, 
    -0.13681015f, -0.05030197f, -0.06494176f, 0.02564853f, 0.08306684f, -0.02240254f, -0.04293603f, -0.04844706f, 
    -0.02572030f, -0.02017811f, 0.03211640f, -0.21371910f, -0.02081011f, 0.03700724f, 0.09000480f, 0.05782603f, 
    0.01127658f, 0.01241424f, 0.08452655f, -0.15320218f, -0.17945033f, 0.09817131f, 0.08460942f, -0.00603406f, 
    0.04518043f, 0.05362482f, 0.08733117f, 0.01179164f, 0.06918906f, -0.06144527f, 0.06561895f, -0.01458905f, 
    0.25928423f, -0.06817598f, -0.03091899f, 0.08463576f, 0.05671859f, -0.01296915f, 0.04575507f, -0.05122146f, 
    0.03451155f, -0.01023095f, 0.06789636f, -0.02587411f, 0.27787840f, 0.14179063f, 0.02865355f, 0.07722060f, 
    0.11321285f, 0.05325781f, -0.07263616f, -0.00202007f, 0.05164140f, 0.00927246f, 0.05264297f, 0.04274534f, 
    -0.00695100f, -0.08171888f, 0.13774975f, -0.33275124f, 0.12791798f, 0.05991094f, 0.01352980f, 0.01440397f, 
    0.13315070f, 0.06361146f, -0.01726600f, 0.08242955f, -0.02508625f, 0.03996335f, 0.03118309f, -0.07963070f, 
    -0.02151821f, -0.07424515f, 0.06286357f, 0.00060859f, 0.06561568f, -0.00802387f, 0.06740198f, 0.10801046f, 
    -0.15301238f, -0.24246730f, -0.12634467f, -0.00061546f, -0.04660006f, -0.11824294f, 0.08662811f, -0.03807419f, 
    -0.06478590f, 0.01879292f, 0.06206089f, 0.06987871f, -0.30252728f, -0.23707844f, -0.04591151f, -0.04757952f, 
    -0.00416372f, 0.09636001f, 0.05315025f, -0.02859154f, -0.08003318f, -0.05754195f, 0.02614868f, 0.03413724f, 
    0.03107090f, -0.04363467f, 0.03750154f, -0.10593619f, 0.03218904f, -0.07570054f, 0.07550632f, -0.00241683f, 
    0.13667345f, -0.05939221f, 0.04372127f, 0.08469061f, -0.04188131f, 0.16797964f, -0.04830139f, 0.16102350f, 
    0.10178021f, -0.00727690f, 0.02727128f, 0.06972294f, 0.11386356f, -0.16008767f, -0.13087529f, 0.02890840f, 
    0.21827985f, 0.18091311f, -0.04151924f, 0.05586811f, 0.07420239f, -0.03277848f, -0.02495633f, 0.07895160f, 
    0.08885182f, 0.03185734f, 0.00829553f, 0.04858851f, 0.15939540f, -0.10427615f, 0.03563038f, -0.01430864f, 
    0.01559357f, -0.03403818f, 0.03104467f, -0.03030970f, 0.12770317f, -0.08064108f, -0.08088064f, 0.04722971f, 
    0.29144895f, 0.07535278f, -0.16023648f, -0.08393024f, -0.00540308f, 0.12962775f, 0.01195407f, 0.00973770f, 
    0.05530354f, -0.01276949f, -0.01740989f, 0.07540008f, -0.10409661f, 0.03189545f, 0.01780654f, -0.04676425f, 
    0.09234632f, 0.04507582f, -0.09012369f, 0.07712166f, -0.08464015f, -0.08925181f, -0.02380906f, -0.01052196f, 
    -0.06307883f, -0.14925855f, 0.05582572f, -0.01142387f, -0.00587341f, 0.01902526f, 0.03812093f, 0.03153985f, 
    0.10861429f, 0.01899386f, 0.05861145f, -0.03824452f, -0.18924293f, 0.05227811f, 0.13924743f, -0.05103031f, 
    0.00041907f, -0.05152919f, 0.05928601f, 0.02476988f, 0.03631957f, -0.00649551f, 0.01692818f, 0.08236258f, 
    0.09405807f, 0.10278510f, -0.05556036f, -0.03129045f, 0.03860481f, -0.11578387f, 0.01984867f, 0.00333530f, 
    0.03529270f, -0.03245176f, -0.01961217f, -0.00704438f, 0.12853649f, -0.03479401f, -0.17615536f, 0.15215082f, 
    -0.04242066f, -0.01127746f, -0.06917565f, 0.09946366f, 0.09658462f, -0.07252870f, 0.01092247f, -0.12704057f, 
    -0.14641826f, -0.17089309f, 0.16874236f, -0.05262192f, 0.03236743f, 0.09807643f, 0.00935362f, 0.04445949f, 
    0.06155686f, 0.01200937f, 0.05567928f, -0.01843909f, 0.00239679f, 0.24740042f, -0.03300345f, 0.08394401f, 
    -0.00695508f, 0.01099432f, -0.10248989f, 0.08339813f, 0.03047422f, -0.10602671f, 0.06263887f, 0.04946533f, 
    -0.26442277f, 0.01521461f, -0.20518966f, 0.17711593f, -0.07409066f, -0.05113449f, -0.00046046f, 0.10934244f, 
    -0.11495163f, -0.03371256f, 0.00233304f, -0.01461545f, 0.01061842f, 0.01297062f, -0.02827229f, 0.05716960f, 
    0.13824826f, -0.01438656f, 0.00142229f, 0.14918648f, 0.00136393f, 0.07480465f, 0.00186326f, -0.04221764f, 
    0.20093063f, 0.01262381f, 0.08044372f, 0.02849378f, 0.10522150f, -0.06983770f, -0.02806858f, 0.05168876f, 
    -0.07249025f, 0.11752958f, -0.08289105f, -0.04562571f, 0.22701769f, 0.10745192f, -0.16388832f, 0.15254380f, 
    0.20091204f, 0.12369077f, 0.00693303f, 0.09167907f, -0.04300971f, 0.01820319f, 0.03494735f, 0.09883260f, 
    0.20787430f, 0.09889970f, -0.18942811f, 0.17908084f, 0.10060620f, 0.04390419f, 0.04444115f, -0.03286048f, 
    0.10417130f, -0.04519301f, -0.01140593f, 0.02694541f, 0.12101108f, -0.04534879f, 0.03979284f, -0.12554114f, 
    0.06085682f, -0.00192139f, 0.11470258f, 0.02691915f, 0.01317831f, 0.16904168f, -0.09376254f, 0.06406831f, 
    0.14896575f, 0.08965005f, 0.12965268f, 0.09113716f, 0.03615303f, -0.00910099f, -0.00212522f, -0.07229390f, 
    0.11557342f, -0.07825071f, 0.01125041f, 0.12694439f, 0.18732832f, 0.05958540f, -0.04414807f, -0.01110420f, 
    -0.00403064f, -0.01650738f, 0.04411251f, -0.05990527f, -0.06111169f, -0.05150126f, -0.03968419f, 0.17376907f, 
    -0.24896501f, 0.08357058f, -0.05471936f, 0.20442097f, 0.14291221f, 0.08370236f, -0.01237640f, 0.10942358f, 
    -0.05511687f, 0.15252115f, 0.03294872f, 0.09964375f, -0.29211310f, 0.14032227f, 0.02314673f, -0.03506679f, 
    -0.03161289f, 0.03935185f, 0.00487744f, -0.06406859f, -0.03191685f, 0.01547123f, -0.07344463f, -0.02283115f, 
    0.21494986f, -0.09127051f, -0.15260352f, 0.10782138f, 0.03269760f, -0.04674565f, -0.04849146f, -0.00270595f, 
    -0.02582791f, -0.02337938f, 0.03551053f, -0.00303679f, 0.21633880f, -0.21446030f, -0.03477654f, 0.09718007f, 
    -0.06185739f, -0.04817331f, -0.00783836f, -0.05923739f, -0.02600897f, -0.06201169f, 0.07875553f, -0.04229916f, 
    -0.27503982f, -0.07902409f, 0.18702234f, -0.21128406f, 0.00343802f, -0.05723238f, 0.02725987f, -0.02025459f, 
    -0.08523308f, -0.01794253f, 0.03929845f, 0.06283807f, 0.08133756f, 0.07107095f, -0.19647568f, 0.00538196f, 
    0.03198610f, 0.09094435f, -0.01935466f, -0.05190640f, 0.10868524f, 0.15903005f, -0.00377554f, 0.02705237f, 
    -0.12498332f, -0.19156739f, 0.08750948f, -0.42403147f, 0.08068986f, -0.01409439f, 0.02031003f, -0.04711977f, 
    0.01048993f, -0.03633334f, -0.06146708f, 0.05500821f, -0.25066012f, 0.02235609f, 0.03504327f, -0.17323984f, 
    -0.03411916f, -0.04929864f, 0.03940162f, 0.09815606f, -0.03112260f, 0.02774595f, 0.02801167f, 0.08922928f, 
    -0.17644720f, -0.16381331f, 0.17781490f, -0.16738150f, -0.12365509f, -0.01949948f, -0.12771010f, 0.08039024f, 
    -0.17008695f, 0.07622969f, 0.04588490f, 0.01281859f, -0.17969893f, -0.05378467f, -0.05437743f, 0.18483059f, 
    -0.13016888f, -0.07008100f, 0.05491891f, -0.09833994f, 0.06208327f, 0.00177162f, 0.02970542f, -0.04527142f, 
    -0.06315944f, 0.06978416f, -0.13507506f, 0.37982303f, 0.00310268f, 0.05705579f, 0.03339068f, 0.03889304f, 
    -0.01592716f, 0.00771300f, 0.04079283f, 0.06375071f, 0.20279150f, 0.24583042f, 0.09163616f, -0.11368768f, 
    -0.12241973f, 0.00544060f, 0.08219574f, 0.11421413f, 0.02344592f, -0.00596292f, 0.07855816f, 0.04751111f, 
    -0.40811166f, -0.14010341f, 0.01947713f, -0.12342419f, -0.08466113f, 0.05504098f, 0.08994059f, 0.01223345f, 
    0.08193559f, -0.01908734f, 0.03674282f, 0.08216131f, -0.08131542f, 0.09466178f, -0.12684508f, 0.23708208f, 
    -0.18012869f, 0.02238896f, -0.00190809f, 0.02392582f, 0.05462035f, 0.00323367f, -0.01123474f, 0.16003108f, 
    -0.07859844f, 0.00985168f, 0.01556745f, 0.18337636f, 0.04427050f, -0.07656121f, -0.02177866f, -0.03418186f, 
    0.10580279f, 0.07436603f, -0.00278706f, -0.10626059f, -0.09091379f, -0.03741508f, 0.18474270f, -0.07969884f, 
    -0.05460514f, -0.13559143f, 0.02468966f, -0.09336435f, 0.02914604f, 0.10624819f, 0.04304126f, 0.00519614f, 
    0.20339523f, 0.14429866f, 0.06340484f, 0.04926281f, -0.05001761f, 0.03135497f, -0.01789373f, 0.18062620f, 
    0.08362897f, -0.05820928f, 0.06173186f, 0.08993944f, -0.03543280f, -0.13395713f, 0.09627092f, -0.04710640f, 
    0.12536047f, -0.06277416f, 0.10015423f, -0.01950211f, -0.06581280f, -0.04189086f, 0.03572496f, 0.01546395f, 
    0.04603744f, 0.48390290f, 0.00915756f, -0.23509187f, 0.09639333f, -0.07601530f, -0.01124187f, 0.04926709f, 
    0.06192683f, -0.11732849f, 0.04224968f, -0.09382752f, 0.06155898f, -0.15679784f, -0.19374891f, 0.35014772f, 
    -0.05751593f, 0.00336388f, -0.05803562f, 0.05018778f, 0.06862181f, -0.01663042f, 0.04237325f, -0.02434306f, 
    0.18156962f, -0.13706319f, 0.03555863f, 0.08278432f, -0.06391232f, -0.06307016f, -0.04793855f, 0.05570970f, 
    0.04818374f, 0.06024060f, 0.09076786f, -0.03455367f, -0.18720926f, 0.04253735f, 0.12158230f, -0.17258304f, 
    -0.02240387f, -0.18453768f, -0.05080448f, -0.00024353f, -0.11394624f, -0.02687986f, 0.07338426f, 0.03475441f, 
    -0.03994610f, -0.25205842f, 0.04686468f, 0.34366798f, 0.01933327f, -0.03232083f, 0.02403529f, -0.00098785f, 
    0.15450013f, 0.01225831f, 0.06267988f, -0.06788951f, -0.03402783f, 0.16137333f, 0.07120644f, -0.20256728f, 
    0.09866124f, 0.04892302f, 0.05054471f, 0.02076998f, -0.05472747f, 0.03376144f, -0.07674745f, -0.03699398f, 
    -0.00135831f, -0.04578475f, -0.06047664f, -0.05156051f, 0.03401332f, 0.08380295f, -0.01135280f, 0.01074589f, 
    0.04127006f, 0.04061814f, 0.12857817f, 0.07116622f, -0.01260865f, 0.16485314f, -0.13367647f, 0.00032452f, 
    -0.01829705f, 0.05378914f, -0.00572011f, 0.10302509f, 0.01928860f, -0.00657485f, 0.01736408f, 0.07464373f, 
    0.15934734f, 0.02374275f, 0.05722345f, -0.03652225f, 0.03741338f, -0.00071771f, 0.04090409f, 0.07143059f, 
    0.04361736f, -0.00612879f, 0.01478141f, 0.04017151f, -0.04922675f, -0.06655290f, 0.12815052f, -0.07034872f, 
    0.03781977f, 0.10094516f, 0.01649807f, 0.04017724f, 0.04644475f, 0.10345034f, 0.01495729f, 0.03663735f, 
    -0.22503626f, -0.35045731f, 0.01186760f, -0.06118294f, -0.17365214f, 0.07422156f, 0.11911877f, -0.03377392f, 
    0.01150462f, -0.00589441f, -0.18280926f, 0.09681338f, 0.10689003f, 0.11093429f, 0.06757950f, -0.10334470f, 
    0.13559277f, 0.10943926f, 0.05675607f, -0.03693255f, 0.18984893f, -0.02023973f, -0.15655987f, -0.03126415f, 
    -0.12145043f, -0.03977832f, 0.03962315f, -0.03024155f, 0.04076278f, 0.01717456f, 0.01489953f, -0.07224949f, 
    0.07120479f, 0.12591964f, -0.13125519f, 0.04255787f, -0.19661787f, 0.19348538f, -0.01754263f, 0.23349743f, 
    -0.02520252f, -0.04093266f, 0.03579417f, 0.03872886f, 0.00152050f, 0.09388021f, -0.00346867f, 0.08299682f, 
    -0.30236554f, 0.09639041f, -0.15024957f, -0.12421686f, -0.03297616f, -0.04060533f, 0.04999485f, 0.02902585f, 
    0.08535372f, 0.04642100f, -0.13014153f, 0.01658316f, -0.25657678f, 0.16924380f, 0.21036866f, -0.13456857f, 
    0.17734240f, 0.01357376f, -0.02138987f, -0.01429148f, -0.05965481f, 0.05570079f, -0.01922102f, 0.02709473f, 
    0.13385113f, -0.01732089f, 0.10046288f, 0.06625029f, 0.05046884f, 0.11602242f, 0.04309620f, 0.24551627f, 
    -0.01268726f, -0.07501366f, -0.03937907f, 0.06772252f, 0.00722972f, -0.05651864f, 0.07086223f, 0.15124781f, 
    -0.09889749f, -0.11900134f, 0.03826225f, 0.17200789f, 0.01784378f, -0.02506884f, 0.00190182f, -0.04988109f, 
    -0.10957186f, 0.02364906f, -0.07542869f, -0.27862999f, 0.05568017f, 0.05440676f, 0.09919462f, -0.01631054f, 
    -0.01026708f, 0.02476254f, -0.03332908f, 0.01026046f, 0.15235044f, 0.20870884f, -0.03032165f, 0.24257249f, 
    -0.06657781f, 0.03572580f, 0.04561901f, 0.11402708f, -0.02504568f, 0.03952004f, -0.03388097f, 0.06187912f, 
    -0.31620610f, 0.33503765f, 0.12828034f, -0.02383213f, -0.00102323f, 0.02922301f, -0.02513338f, 0.02264490f, 
    0.12195070f, 0.04952418f, 0.00472266f, -0.03479036f, -0.16744004f, -0.00507202f, 0.05823174f, -0.22971953f, 
    0.02626437f, 0.04882477f, -0.19874032f, -0.00265928f, 0.11885929f, -0.01317006f, -0.00407670f, -0.02454613f, 
    -0.45407838f, -0.14138223f, 0.05309616f, 0.14035305f, -0.09348116f, 0.11059459f, -0.02222130f, -0.10897098f, 
    0.01699112f, 0.10579942f, -0.02133515f, 0.13682042f, 0.05634047f, -0.20718272f, -0.02528221f, 0.15585788f, 
    -0.00057354f, -0.00857802f, -0.00665515f, 0.07928585f, 0.07639928f, -0.02796471f, -0.10405108f, -0.00016617f, 
    -0.01429754f, 0.00196802f, 0.00473036f, 0.09896518f, 0.01644214f, -0.10106913f, 0.05150687f, 0.08268359f, 
    -0.03904852f, 0.04259998f, -0.00374682f, -0.01303134f, 0.15052322f, -0.11976816f, 0.09353074f, -0.16449702f, 
    -0.11247090f, -0.08051183f, 0.03307557f, 0.14311373f, 0.04065136f, 0.02239385f, -0.12085199f, 0.06772605f, 
    0.12098139f, -0.01991546f, 0.04743801f, 0.18368514f, 0.07443934f, -0.09854808f, 0.01992399f, 0.01787831f, 
    -0.02231443f, -0.00897793f, 0.11345886f, -0.04617485f, 0.05317363f, -0.02491638f, 0.04428353f, 0.21372275f, 
    -0.13717613f, 0.02706965f, 0.14181256f, -0.02969660f, 0.15768936f, 0.00422923f, 0.05940948f, 0.18415701f, 
    0.01710249f, 0.01062297f, 0.04840234f, 0.27891961f, 0.06270063f, -0.04733030f, 0.02946482f, 0.00922192f, 
    0.07385032f, 0.03874738f, 0.12636079f, 0.05442960f, 0.25422564f, -0.34046993f, -0.18669213f, 0.21115330f, 
    0.01162401f, -0.01652407f, -0.07319819f, 0.10174563f, 0.04488211f, -0.01227348f, 0.04936338f, 0.12500586f, 
    -0.04188517f, 0.13344990f, 0.26463896f, -0.37855017f, 0.05674827f, 0.12296808f, 0.07888986f, 0.01353001f, 
    0.04609846f, 0.02897650f, 0.09094614f, 0.02060264f, 0.07272130f, -0.00711957f, 0.09170209f, -0.10387189f, 
    -0.12740014f, 0.07723051f, 0.05752993f, 0.05848887f, -0.00964416f, 0.00352834f, 0.08211656f, 0.00475177f, 
    0.09169513f, 0.05567349f, -0.05083833f, 0.23034139f, -0.03903816f, 0.04602118f, 0.03026905f, 0.15465127f, 
    0.10270593f, 0.07636146f, -0.00250876f, 0.03177617f, 0.05881854f, 0.17655575f, 0.08702967f, 0.27170965f, 
    0.03966871f, -0.04948331f, -0.15318595f, 0.03793097f, -0.04732665f, 0.00963569f, -0.07834165f, 0.06375737f, 
    -0.16626637f, -0.06687517f, 0.00684984f, -0.12470511f, 0.02549451f, -0.08233503f, -0.03877412f, -0.00872540f, 
    0.02228921f, 0.06930446f, -0.00455341f, -0.01087431f, -0.06568733f, 0.04049853f, 0.08546083f, -0.29411229f, 
    0.03909501f, 0.01711826f, 0.06186440f, 0.07031033f, -0.04495261f, 0.02458372f, 0.00109592f, 0.13210832f, 
    0.18546580f, 0.15056150f, -0.00560768f, -0.16636899f, 0.03220814f, 0.08058988f, 0.07418007f, 0.18506974f, 
    -0.06515037f, -0.02370008f, 0.07977316f, 0.05805441f, 0.14898856f, 0.08039360f, 0.07687823f, 0.16727021f, 
    0.12637243f, 0.00841376f, 0.02282899f, 0.13679390f, 0.09995387f, 0.02477463f, 0.03169715f, 0.07690416f, 
    0.22578414f, 0.17435297f, 0.05263830f, -0.02525943f, 0.01706025f, -0.05500957f, -0.01599814f, 0.18303560f, 
    -0.03822732f, -0.01357237f, -0.03848146f, 0.04652986f, 0.19248518f, -0.11541439f, -0.16575789f, 0.14266515f, 
    0.06775533f, 0.10254192f, 0.03175253f, 0.07661153f, 0.04048597f, 0.08103396f, 0.08907493f, 0.02232447f, 
    0.03359461f, -0.32087466f, -0.16305800f, 0.16613837f, -0.05985630f, -0.05672590f, -0.07316642f, 0.07499356f, 
    -0.03260574f, 0.07591067f, 0.06061547f, 0.13076966f, 0.08130875f, -0.09027439f, 0.16305366f, -0.22962533f, 
    -0.04064338f, -0.05303416f, 0.12961818f, 0.02351696f, -0.09941057f, -0.00961613f, 0.03406102f, 0.07676277f, 
    -0.28935283f, 0.15393136f, -0.00487444f, -0.51047730f, -0.07541439f, -0.01909955f, -0.07295644f, -0.00371241f, 
    0.01249368f, -0.05634811f, -0.00660856f, 0.02859217f, -0.25132433f, -0.11072813f, -0.05282377f, 0.07757285f, 
    0.07833252f, -0.03223640f, -0.00878130f, 0.02179230f, -0.06360611f, -0.02970027f, 0.00132993f, 0.13117705f, 
    -0.17368904f, 0.05671569f, -0.06832589f, 0.08776165f, 0.01089009f, -0.01326204f, -0.04784768f, -0.01398621f, 
    0.08984062f, 0.02278426f, -0.03702293f, 0.01049853f, 0.26478478f, 0.11405257f, 0.03626313f, 0.03301637f, 
    0.07557747f, -0.05280852f, -0.02936975f, 0.12008087f, 0.00093506f, 0.00632959f, 0.05577366f, 0.00555038f, 
    0.37010321f, 0.20994706f, 0.04345893f, 0.09424242f, -0.06349023f, 0.00575723f, 0.03010405f, 0.09448572f, 
    -0.10178705f, -0.07730912f, 0.02530145f, 0.06531972f, 0.16191952f, 0.38087076f, -0.08563329f, -0.40295199f, 
    0.04342654f, 0.08619624f, 0.03321669f, 0.06603473f, 0.13105099f, -0.01235439f, -0.03719795f, 0.05506412f, 
    0.05186216f, 0.14685671f, -0.10947807f, -0.38169700f, 0.05455457f, 0.05049288f, 0.17641644f, 0.08919611f, 
    0.02890289f, 0.07329056f, -0.01128249f, 0.07444640f, 0.34460708f, -0.35136092f, -0.20866132f, 0.08924142f, 
    -0.07047322f, -0.00096155f, 0.01138417f, -0.00148270f, -0.14010809f, 0.02278362f, 0.00043419f, 0.06492262f, 
    -0.27764890f, 0.08428872f, -0.07467025f, -0.03212919f, 0.01047123f, 0.11730801f, -0.05168720f, -0.01748168f, 
    0.00014271f, -0.02580561f, 0.03743041f, 0.07410537f, -0.06694892f, -0.35952091f, 0.05811279f, 0.02635792f, 
    0.06207376f, 0.08389079f, 0.08274885f, 0.02073026f, 0.16453217f, 0.13194062f, 0.03714258f, 0.08949059f, 
    -0.23661198f, 0.05270965f, -0.10324026f, 0.24402905f, -0.09284735f, -0.02945618f, 0.08168557f, 0.03969070f, 
    -0.11029994f, 0.05835063f, -0.03016934f, 0.10371796f, -0.16685729f, -0.02145423f, 0.08923507f, -0.06298680f, 
    -0.04925017f, 0.12325896f, 0.08816726f, -0.07147863f, 0.04664699f, 0.06423049f, 0.06792706f, 0.06642548f, 
    -0.07770281f, 0.06626938f, -0.09914196f, 0.09233338f, -0.00315192f, -0.05180520f, 0.06458443f, 0.15237656f, 
    -0.02270244f, 0.00367589f, 0.09992074f, -0.02421549f, -0.31446224f, -0.14249831f, 0.02734755f, -0.07653686f, 
    0.03914320f, -0.06514531f, 0.02420150f, 0.14844522f, -0.04308079f, 0.11985395f, 0.13694637f, 0.11366496f, 
    -0.18427856f, 0.38672715f, -0.00954152f, -0.02303769f, -0.01520944f, 0.04475616f, -0.00357914f, 0.00448266f, 
    -0.00395467f, -0.04064988f, -0.03564173f, -0.06676140f, 0.40337646f, -0.09514782f, -0.06668168f, 0.11986954f, 
    0.10970920f, -0.03823942f, 0.03410084f, 0.00230795f, 0.13580157f, 0.11236433f, -0.06784479f, -0.03235391f, 
    -0.13386503f, 0.14343761f, 0.17915626f, -0.05884863f, -0.12268428f, -0.04252247f, -0.11913767f, 0.02898042f, 
    0.09265377f, 0.07950120f, -0.09347052f, -0.00564280f, 0.16589753f, 0.24395101f, 0.09174031f, 0.13264501f, 
    0.00604427f, 0.04949920f, 0.01660448f, 0.06719595f, -0.07841204f, -0.06357608f, 0.02668818f, 0.09750342f, 
    0.18695650f, 0.11876164f, 0.16844435f, 0.05003995f, -0.14565532f, -0.03686644f, 0.08939389f, -0.09554201f, 
    0.06829002f, -0.02727645f, -0.06140123f, 0.17395626f, -0.34796003f, -0.01676573f, 0.17676066f, 0.04299824f, 
    0.02266406f, 0.00592905f, 0.03939504f, 0.03993537f, 0.01962658f, -0.04804937f, 0.08245414f, 0.09018317f, 
    -0.48778570f, 0.02516157f, -0.18131386f, 0.02667738f, 0.07424453f, 0.08518440f, 0.08048373f, 0.11362205f, 
    -0.08857748f, -0.04845818f, 0.05590677f, -0.14492817f, 0.09149922f, -0.28538463f, -0.09570695f, -0.01099048f, 
    -0.02270139f, 0.02913390f, -0.02991997f, -0.04999116f, -0.01731264f, 0.01966557f, 0.00319363f, -0.05261671f, 
    -0.10141456f, -0.02404904f, -0.04464819f, -0.24655525f, -0.01726305f, 0.13359892f, 0.03902088f, -0.08882030f, 
    -0.07213993f, 0.11751044f, -0.06952291f, 0.15149908f, 0.25025514f, 0.26409569f, 0.21414199f, 0.10003848f, 
    -0.11559425f, 0.06111843f, 0.02832461f, 0.08057528f, 0.04508871f, -0.01238595f, 0.03274226f, -0.02465712f, 
    0.31630889f, 0.19092470f, 0.15697870f, -0.03962326f, -0.02621576f, 0.01553819f, -0.00413113f, 0.01698161f, 
    0.07448627f, -0.05564118f, 0.06380813f, -0.10809441f, -0.07759057f, 0.01748420f, 0.05893118f, 0.01544928f, 
    0.02415842f, 0.03521295f, -0.00499988f, 0.08490353f, 0.10470855f, 0.11192600f, 0.02982922f, 0.02882330f, 
    0.23779236f, 0.05534440f, 0.16287383f, -0.09796204f, -0.13341652f, 0.09158827f, -0.00468239f, 0.09807279f, 
    0.14642096f, -0.09737703f, 0.10423977f, 0.03088463f, -0.11023017f, -0.12518759f, 0.01628445f, -0.08757629f, 
    -0.01226654f, -0.00619147f, 0.02184564f, -0.01619241f, -0.07061660f, -0.03829806f, 0.01633913f, -0.15616883f, 
    0.00289597f, -0.12840858f, -0.06072275f, 0.10474162f, 0.02871797f, 0.10100947f, 0.03586852f, 0.01910310f, 
    -0.07173757f, 0.08516350f, -0.07009413f, -0.04731167f, -0.07924476f, 0.06741490f, -0.10610344f, 0.09532193f, 
    -0.01471809f, 0.07889775f, 0.02323132f, -0.02037464f, 0.08711787f, -0.02504611f, 0.04383745f, 0.01178097f, 
    -0.10517086f, 0.03613045f, 0.10032278f, 0.15852726f, 0.18526198f, 0.01481631f, 0.05225493f, 0.08074455f, 
    0.04248279f, 0.08236042f, 0.05056062f, -0.04681163f, 0.04329016f, -0.09221487f, 0.14037503f, 0.09619972f, 
    -0.10266352f, 0.05433585f, 0.02776979f, -0.03570244f, -0.08128040f, -0.04816359f, -0.01606371f, -0.01792663f, 
    0.02987604f, -0.18493718f, -0.10337644f, 0.09494030f, 0.02636656f, -0.10798975f, -0.08403493f, -0.04726525f, 
    -0.25965640f, 0.00667997f, -0.13118103f, -0.03919809f, -0.20436764f, -0.02434366f, 0.18753994f, 0.03299584f, 
    -0.02729910f, 0.03925712f, -0.01816612f, -0.02021510f, -0.02493016f, -0.11524791f, 0.10757458f, 0.11185815f, 
    -0.26532730f, -0.05064159f, 0.11207159f, 0.04468754f, -0.02451367f, -0.06607883f, -0.00771278f, 0.02981776f, 
    0.05892669f, -0.10133944f, 0.04138935f, -0.07494393f, -0.28765488f, 0.00727661f, -0.07554194f, 0.05345926f, 
    -0.08865850f, -0.04327094f, 0.06504576f, 0.04899525f, 0.03575285f, -0.06007625f, 0.00787382f, -0.03161587f, 
    -0.16878127f, 0.17185147f, 0.10331536f, -0.00762967f, -0.12480688f, 0.00858582f, 0.07833564f, 0.08369356f, 
    0.01878417f, -0.03018459f, -0.00049942f, 0.01116977f, 0.13441460f, -0.21648100f, 0.05830423f, 0.17272870f, 
    0.01498217f, -0.03886189f, 0.10170100f, -0.05708337f, -0.00042011f, 0.05026032f, 0.05902763f, 0.00465701f, 
    0.10695772f, 0.08560855f, -0.07288891f, 0.17562768f, 0.07265978f, -0.02829886f, 0.00283353f, -0.08608253f, 
    0.05785737f, 0.03450954f, 0.03709539f, -0.03906078f, -0.04453502f, -0.10475258f, -0.20027353f, 0.09157266f, 
    0.15757170f, 0.08464051f, 0.04367686f, 0.01776627f, 0.03244886f, 0.05425236f, 0.07647038f, -0.01157567f, 
    0.19584870f, -0.14986904f, -0.08426905f, -0.02021147f, 0.03592702f, 0.12858097f, 0.06268589f, -0.06382643f, 
    0.03801370f, -0.06883751f, -0.03038070f, 0.03029597f, -0.52229196f, 0.08737353f, -0.19123112f, -0.16541341f, 
    0.18892279f, 0.09844583f, 0.07871681f, 0.05205505f, 0.03594825f, 0.04997509f, -0.01017631f, 0.01459051f, 
    -0.03025297f, 0.08523642f, 0.25252098f, 0.01006766f, -0.00667741f, -0.03115795f, 0.03227374f, -0.00011276f, 
    -0.03350561f, -0.06031674f, -0.02897764f, -0.07079614f, -0.01292844f, 0.21697588f, 0.22561163f, 0.17992082f, 
    0.04202534f, 0.02583307f, -0.05707367f, 0.05694380f, 0.04027155f, 0.00909545f, 0.09787837f, 0.06838866f, 
    0.08011147f, -0.23299427f, -0.02425166f, 0.00306064f, 0.06700525f, 0.04883331f, 0.00796429f, 0.01613828f, 
    -0.06151175f, -0.05457901f, -0.05580717f, 0.06905784f, 0.13251474f, 0.10594047f, -0.00244926f, -0.02885251f, 
    -0.11862143f, 0.01392153f, 0.13272329f, 0.05521191f, 0.03635059f, -0.06632996f, -0.06027789f, 0.11277930f, 
    -0.37287253f, 0.14116728f, 0.00216275f, -0.05153469f, 0.03259036f, -0.04289632f, 0.03642486f, 0.01889680f, 
    0.06026798f, 0.02567970f, 0.04197346f, 0.10380203f, -0.38910192f, 0.02913168f, -0.14765269f, -0.04740750f, 
    0.08815750f, 0.05550285f, -0.01924581f, 0.15163575f, 0.01094991f, -0.00880235f, -0.15036014f, 0.00570170f, 
    -0.35238862f, 0.09424559f, 0.05586691f, -0.09168508f, 0.03576178f, -0.05560960f, -0.04565141f, 0.01647210f, 
    0.08562474f, -0.03388709f, -0.03105734f, -0.00001045f, 0.06555395f, -0.00552879f, 0.16612191f, 0.01006836f, 
    -0.07654272f, 0.05039860f, 0.04827113f, -0.01174916f, -0.09263942f, 0.02116975f, -0.00932204f, -0.11908095f, 
    0.21706133f, 0.14513911f, 0.17520539f, 0.14527357f, -0.19920425f, -0.01004097f, 0.01458495f, 0.01909456f, 
    -0.04555450f, 0.00421346f, -0.05524608f, 0.05085604f, 0.39812523f, -0.14834410f, 0.17787638f, -0.02659915f, 
    -0.12093183f, 0.04329383f, -0.02773087f, 0.07217511f, -0.01409697f, 0.07022820f, -0.04936717f, -0.04151941f, 
    -0.14870816f, 0.10535530f, 0.10910597f, 0.15047321f, -0.08222275f, 0.11175979f, 0.01945837f, 0.03772387f, 
    -0.00807051f, -0.12209228f, -0.01074619f, 0.03652733f, -0.12373745f, -0.02941353f, -0.09068231f, -0.16608572f, 
    0.04445859f, 0.01003285f, 0.08164155f, -0.04461301f, 0.09531531f, 0.04172097f, 0.08266650f, 0.07578489f, 
    -0.18275541f, 0.10745531f, -0.12023743f, 0.05098915f, -0.06385504f, 0.07286434f, 0.06384359f, -0.03206944f, 
    0.00013021f, 0.03823014f, 0.02099916f, -0.03447524f, -0.41512358f, 0.04129903f, -0.21127303f, -0.13912037f, 
    0.09680427f, -0.03998680f, -0.06074933f, 0.04987567f, 0.07695029f, 0.01858410f, -0.00637236f, 0.08152016f, 
    -0.11865148f, -0.10785913f, 0.14552771f, -0.00650316f, -0.06588587f, 0.03756665f, 0.04335367f, 0.00533691f, 
    0.08071798f, 0.08419615f, 0.08856095f, -0.07755599f, -0.01565880f, -0.08146573f, 0.13131407f, 0.05182390f, 
    0.04822140f, -0.09164047f, 0.17175600f, -0.02015421f, 0.07211860f, 0.05308564f, 0.04845006f, 0.12935925f, 
    0.14517911f, -0.22084181f, -0.17568961f, 0.20540281f, 0.04152505f, 0.00251085f, -0.10659515f, 0.05064844f, 
    -0.01107808f, 0.00380126f, -0.02802460f, 0.02420776f, -0.27740932f, -0.15704544f, -0.02866589f, 0.07198345f, 
    0.05885648f, -0.08188226f, -0.00874040f, 0.08740848f, 0.03102721f, 0.00249772f, 0.00022366f, -0.05074565f, 
    -0.10221534f, -0.00553173f, 0.02902835f, 0.06845611f, 0.05139196f, 0.02361788f, 0.09505332f, -0.09984220f, 
    0.04544213f, 0.02039515f, -0.06902551f, 0.14670159f, -0.08442935f, -0.01568225f, 0.12150413f, 0.06547107f, 
    -0.02915182f, 0.03971599f, 0.13068154f, 0.08577395f, -0.08331680f, -0.00739206f, 0.10132571f, 0.03314480f, 
    0.06640009f, 0.05317233f, 0.05718675f, 0.01248084f, -0.00297795f, -0.02662813f, 0.01879339f, 0.01479944f, 
    -0.03757475f, 0.10737725f, 0.07183763f, -0.07374351f, -0.13191359f, -0.17103830f, -0.13451345f, 0.03910962f, 
    0.02106363f, 0.11720283f, 0.02577488f, -0.06616180f, 0.00152323f, 0.12838632f, -0.08177922f, 0.03307451f, 
    -0.06483644f, 0.19789125f, 0.25873077f, -0.09254699f, -0.07975275f, -0.04365008f, 0.05826389f, -0.00475242f, 
    0.18992697f, -0.01851185f, -0.03097219f, -0.03797838f, -0.09877444f, -0.11523301f, -0.08486886f, -0.14829268f, 
    -0.09503903f, -0.03531572f, 0.03483546f, 0.03069890f, -0.01227571f, 0.04336836f, -0.12592123f, 0.08672462f, 
    0.03261809f, 0.20516565f, 0.28619659f, -0.04904181f, -0.07723751f, -0.07334267f, 0.06970770f, 0.07969831f, 
    -0.11201844f, -0.07901909f, 0.03623646f, 0.01774614f, -0.35509315f, 0.07546324f, 0.04465618f, -0.08953048f, 
    0.05799356f, -0.01293900f, 0.04123710f, -0.03727101f, -0.03656844f, 0.01317415f, 0.00921389f, 0.02163688f, 
    0.09833838f, -0.12979348f, -0.05620615f, 0.09532250f, 0.10456239f, -0.00334867f, 0.06799197f, -0.17725013f, 
    -0.01618814f, 0.01678465f, 0.05238892f, 0.07942109f, 0.19515440f, 0.01310162f, 0.04213957f, 0.16202329f, 
    0.01553629f, -0.03781904f, 0.04087088f, -0.05468706f, -0.02663472f, -0.00400882f, -0.16434522f, -0.10515873f, 
    0.14341584f, -0.09357656f, 0.08278409f, 0.25806537f, 0.09087199f, -0.05349591f, 0.13441309f, -0.01944875f, 
    -0.07226917f, 0.10324463f, 0.01064108f, -0.05630072f, -0.00585506f, -0.13877496f, 0.10700190f, -0.00184513f, 
    -0.07270084f, -0.02823110f, 0.01169037f, 0.14062668f, -0.01805083f, 0.07225432f, -0.00578618f, 0.03393808f, 
    -0.27995527f, -0.15118493f, -0.14970912f, -0.01551947f, -0.05789446f, -0.00098503f, 0.08960587f, 0.02082750f, 
    -0.13512410f, -0.06270774f, 0.02498643f, -0.04294856f, 0.10078088f, -0.07628978f, 0.10763253f, 0.19509262f, 
    -0.15333287f, -0.00066509f, 0.09147292f, 0.08690383f, 0.06276841f, -0.06082871f, 0.00113552f, -0.14738774f, 
    0.01418767f, -0.06861168f, -0.19590646f, -0.02704949f, 0.15625529f, 0.19065650f, 0.09960962f, -0.07884042f, 
    -0.01306389f, 0.01755184f, -0.01992324f, 0.11391696f, -0.10603805f, -0.19359256f, -0.20018394f, -0.02926154f, 
    0.04216222f, 0.03270863f, 0.04351564f, -0.17180315f, -0.02448495f, -0.09672200f, 0.05993231f, -0.02797391f, 
    -0.29873884f, 0.08653240f, -0.00215507f, -0.13167217f, 0.15262528f, 0.02434032f, 0.10189275f, 0.09583604f, 
    0.19938236f, 0.06055918f, 0.09890617f, 0.00103019f, 0.13050307f, -0.02274672f, -0.19515613f, 0.06264918f, 
    0.03271970f, -0.03033682f, 0.09581902f, -0.12536541f, -0.07708886f, 0.05335797f, 0.01402218f, -0.03351171f, 
    0.31708866f, -0.09500131f, 0.08691572f, 0.04126884f, -0.02412362f, 0.04371718f, 0.01124780f, -0.07768658f, 
    0.11541321f, 0.03072970f, 0.09040821f, -0.08431048f, -0.24285467f, -0.14097835f, -0.12426062f, -0.23826526f, 
    0.02127335f, 0.04958070f, -0.11542983f, 0.09158526f, 0.13008249f, 0.02699390f, -0.02883725f, 0.09858739f, 
    -0.12184566f, 0.33529267f, -0.07833242f, 0.19189005f, 0.01293825f, 0.07578609f, 0.03346680f, 0.01715556f, 
    -0.07994716f, 0.07944760f, 0.05525439f, -0.06195706f, 0.09388416f, -0.12411094f, 0.06645439f, 0.26741040f, 
    -0.02084570f, -0.02592230f, 0.04309961f, 0.03440946f, 0.03141203f, 0.05083729f, -0.00836801f, -0.00261360f, 
    0.33750832f, 0.26815996f, 0.23174399f, 0.11800510f, -0.06607001f, 0.10707550f, 0.11227152f, -0.06080752f, 
    -0.01742816f, 0.06103103f, 0.07619666f, 0.04358114f, -0.13787492f, -0.09075556f, -0.18112816f, -0.22337756f, 
    0.00126567f, -0.01540565f, 0.04740562f, 0.07649124f, -0.02358079f, -0.03780024f, -0.07799871f, 0.11760192f, 
    -0.21929871f, -0.21648183f, -0.13362573f, -0.20517321f, 0.12179400f, -0.06091861f, 0.07889874f, 0.02791106f, 
    -0.07233246f, -0.02100200f, -0.04957771f, 0.06301145f, 0.20232588f, 0.04494615f, 0.12925042f, -0.09854685f, 
    0.07581194f, 0.04331996f, 0.05154594f, 0.04149715f, 0.03068712f, 0.00861081f, 0.07983153f, 0.06285006f, 
    -0.00220968f, -0.46340343f, 0.08347443f, 0.24155922f, -0.03682674f, 0.06154849f, 0.05771906f, -0.06474462f, 
    0.10813600f, 0.15323283f, -0.07846045f, 0.00719773f, 0.00045087f, -0.00396421f, 0.18620582f, 0.18699908f, 
    -0.10289944f, 0.02328426f, -0.00494849f, -0.03434260f, -0.05334278f, 0.06045999f, 0.08126411f, 0.05563209f, 
    0.05343302f, -0.01055564f, 0.02905272f, 0.04851561f, 0.07029904f, 0.04281250f, -0.02538432f, 0.07991718f, 
    0.07163215f, -0.01366552f, 0.02173894f, 0.04614358f, -0.16615331f, 0.08408543f, -0.15578082f, 0.03101264f, 
    0.09349345f, 0.00307851f, 0.05356462f, -0.04996160f, 0.01457177f, 0.17733286f, 0.02298870f, 0.00268802f, 
    0.26365623f, 0.15723446f, 0.28928420f, 0.08283266f, -0.08855505f, 0.14189725f, 0.02428603f, -0.07349050f, 
    -0.06335601f, 0.00175155f, -0.04481681f, 0.11199847f, -0.02674298f, 0.05796397f, -0.07819331f, 0.03545492f, 
    -0.06507783f, -0.06226594f, 0.13856857f, 0.10657145f, -0.04053951f, -0.00202792f, 0.10565257f, 0.19941585f, 
    -0.14831786f, -0.09426868f, -0.01585751f, -0.02062888f, 0.00222444f, -0.04287882f, -0.01736699f, 0.04766265f, 
    0.13345680f, 0.03567785f, -0.00260255f, 0.06031906f, 0.12846769f, -0.19081920f, 0.10369464f, 0.11511860f, 
    0.17229885f, 0.01000272f, 0.14220217f, -0.05498818f, -0.00870315f, 0.06596075f, 0.06661078f, -0.04448924f, 
    -0.37385201f, -0.05628685f, -0.06284547f, -0.18814534f, -0.02301327f, -0.02271137f, -0.08003645f, -0.04903631f, 
    0.01106096f, 0.08937176f, 0.05252164f, -0.04703452f, 0.03574390f, -0.03988924f, -0.00531778f, -0.03003042f, 
    0.11848354f, 0.04756436f, -0.01056066f, 0.03525082f, 0.01448925f, -0.00010088f, -0.05602982f, 0.08489524f, 
    0.37225494f, 0.20416863f, -0.10008518f, 0.11188563f, 0.05218925f, 0.12221328f, -0.00636202f, 0.19677939f, 
    -0.03828143f, 0.07507742f, 0.00926632f, -0.00783940f, -0.04266384f, -0.01643405f, 0.03130289f, 0.02307631f, 
    0.03046953f, 0.01292283f, -0.17885552f, -0.01705556f, -0.02876541f, 0.00414338f, 0.13140529f, 0.01033166f, 
    -0.05578759f, 0.08589406f, -0.04856889f, 0.29522008f, -0.05622195f, -0.00443625f, -0.02674780f, 0.02076545f, 
    -0.05246250f, -0.00086499f, 0.06502701f, -0.03060520f, 0.00981578f, -0.05729812f, 0.14676899f, 0.01619196f, 
    0.04527036f, 0.03685456f, -0.00850698f, 0.04108310f, 0.05374359f, -0.03395716f, 0.00511521f, -0.02560315f, 
    0.02950382f, 0.06496954f, 0.21039362f, -0.06639395f, 0.00835704f, 0.07917558f, 0.00701398f, 0.04766186f, 
    -0.02286847f, -0.03376000f, 0.11540663f, 0.01068198f, -0.12686709f, 0.19268043f, -0.18910764f, 0.14212649f, 
    0.10021728f, 0.05573131f, 0.01931186f, 0.11894739f, 0.01139557f, 0.00018934f, 0.10131530f, 0.05911831f, 
    -0.25130334f, -0.06297419f, -0.00937371f, 0.07811049f, 0.00988460f, -0.09356353f, 0.03789887f, -0.00667896f, 
    0.02368564f, 0.03882249f, 0.02202896f, -0.03041704f, -0.14293000f, -0.09694796f, -0.11258633f, -0.42577538f, 
    0.02413380f, 0.01475877f, -0.00634149f, 0.01936838f, 0.02519305f, 0.03550648f, 0.01212044f, 0.11729424f, 
    -0.26127705f, -0.14912237f, 0.11286959f, 0.15893140f, -0.01003681f, -0.10366083f, -0.04248898f, 0.00827580f, 
    0.06475355f, -0.01241942f, -0.01536222f, 0.15638550f, -0.11318935f, -0.14814404f, -0.08111226f, -0.13280828f, 
    0.05479047f, -0.02179736f, -0.03321050f, -0.01511196f, -0.00510337f, -0.00312660f, 0.00305612f, 0.02671380f, 
    0.01835704f, -0.04847600f, 0.07568043f, 0.14015055f, 0.06871155f, -0.00105968f, 0.01585774f, 0.02202616f, 
    -0.08648890f, -0.05802429f, 0.12965313f, 0.00662641f, 0.09676936f, 0.16749953f, 0.01871113f, 0.23999694f, 
    -0.18320581f, -0.11635691f, -0.04260075f, 0.07807152f, -0.04852269f, -0.03934941f, 0.01952705f, -0.05175557f, 
    0.15574381f, -0.07023030f, -0.06979483f, 0.20721382f, -0.07786698f, 0.06769674f, 0.10058273f, 0.12141585f, 
    0.00257770f, 0.05909078f, -0.01655066f, 0.00093015f, -0.17736861f, 0.05766314f, 0.03196627f, 0.28883028f, 
    -0.05323212f, 0.03730381f, 0.01707954f, -0.02940491f, 0.05946876f, 0.08958799f, 0.00696747f, -0.02341003f, 
    -0.03045621f, -0.05429798f, 0.03673794f, -0.09764586f, 0.03839747f, 0.08972563f, -0.07817827f, 0.11297160f, 
    0.17878462f, 0.03947453f, -0.04256022f, 0.13521817f, -0.04245519f, -0.08236821f, -0.00995039f, -0.16505963f, 
    0.01747899f, -0.02341278f, 0.03824599f, -0.02615060f, -0.03807885f, -0.03798000f, 0.03786826f, -0.02759676f, 
    0.23430806f, 0.08567423f, 0.07118183f, -0.12428419f, 0.07338304f, 0.02485415f, -0.03419336f, -0.09890524f, 
    0.04497477f, 0.02967417f, 0.10442076f, 0.08908713f, -0.09547383f, 0.06285148f, 0.11437874f, -0.17553876f, 
    -0.03113406f, 0.02082792f, -0.07610258f, 0.01346746f, -0.06703514f, -0.06569110f, 0.02016934f, 0.07599694f, 
    -0.03657840f, -0.02132587f, 0.11688052f, 0.05752789f, -0.02984939f, 0.03767546f, -0.09399921f, -0.03309698f, 
    0.05111051f, 0.05706310f, 0.02939267f, -0.06291317f, 0.15475477f, 0.10689094f, 0.19847052f, -0.06551987f, 
    -0.09591230f, 0.08608254f, -0.04031299f, 0.00898017f, 0.08993630f, 0.03382093f, 0.06609240f, 0.13653198f, 
    0.06739073f, -0.04358732f, -0.16387551f, 0.08596944f, -0.03279787f, 0.06074402f, 0.06696057f, -0.01008240f, 
    -0.02505650f, -0.04148574f, -0.03656588f, -0.04498909f, -0.10294556f, -0.11656274f, -0.24250796f, -0.06228541f, 
    0.06558326f, -0.02715945f, -0.01244581f, -0.04713840f, 0.05811484f, -0.02689926f, -0.06329692f, 0.08781554f, 
    -0.01112024f, -0.06800278f, 0.04947679f, -0.01089450f, 0.00098670f, -0.03340400f, 0.03910114f, -0.09672458f, 
    -0.04820819f, -0.02901777f, 0.13230275f, -0.01009835f, 0.04366016f, -0.14803019f, 0.00346498f, 0.06876887f, 
    0.03789448f, 0.09317785f, 0.08935121f, 0.01989624f, 0.02286977f, 0.14795803f, -0.10782792f, 0.03706492f, 
    0.17563410f, 0.19753151f, -0.15448020f, 0.24636884f, -0.08786921f, 0.00665849f, -0.06099876f, -0.01620850f, 
    -0.08791004f, 0.02425928f, 0.10289517f, -0.05795499f, 0.05945884f, -0.09731150f, 0.07120413f, -0.05969856f, 
    0.01464029f, 0.11413892f, 0.01302893f, -0.03477613f, 0.00530201f, 0.00096357f, -0.03315851f, 0.07176627f, 
    -0.02210923f, 0.06927102f, -0.01030205f, -0.24225579f, 0.02550483f, 0.00205720f, -0.07058875f, -0.06221309f, 
    -0.01911083f, 0.02564358f, 0.12287972f, 0.00017556f, -0.30849940f, -0.13340467f, -0.00721174f, -0.21190047f, 
    -0.01406635f, 0.03823430f, 0.00233120f, -0.06001766f, -0.05173401f, -0.07219443f, -0.03032240f, -0.05074919f, 
    0.04160712f, -0.04557284f, -0.00933860f, -0.06875154f, -0.01039591f, -0.06832340f, 0.01251445f, -0.02550282f, 
    0.08704890f, 0.03803358f, 0.00526035f, -0.01360719f, 0.05490275f, 0.16857384f, 0.00445132f, -0.01677770f, 
    -0.06265303f, -0.03626289f, 0.02404327f, -0.07333296f, 0.08949541f, 0.01238307f, 0.07721671f, 0.02588738f, 
    0.13752042f, 0.14673445f, 0.04198471f, 0.19042152f, -0.10638881f, 0.00478218f, 0.10494843f, 0.04238160f, 
    0.01074950f, 0.03738628f, 0.04809916f, -0.07173584f, 0.06760070f, -0.12913786f, -0.12730716f, 0.00664548f, 
    -0.02970568f, -0.02716661f, 0.10808936f, 0.05267885f, 0.03251889f, 0.00914024f, 0.01765683f, 0.01747515f, 
    0.10643549f, 0.14778806f, 0.07385414f, 0.07752970f, -0.04160599f, -0.03485494f, 0.07414360f, 0.03835863f, 
    0.00344558f, 0.10405044f, 0.02397676f, 0.07301493f, -0.11678942f, -0.07962363f, 0.08082531f, 0.01342958f, 
    0.01491134f, -0.00840834f, -0.03873049f, 0.06106200f, 0.09636547f, 0.01250108f, 0.06491388f, 0.00848735f, 
    0.10646705f, 0.04536527f, 0.06186035f, 0.04536457f, 0.00675979f, 0.01173008f, 0.04396812f, 0.03183269f, 
    -0.01349206f, -0.08522670f, -0.00482295f, 0.05933119f, -0.12022859f, -0.12406836f, -0.01922820f, -0.09130976f, 
    0.03392075f, 0.03239510f, 0.10749788f, -0.01047613f, 0.00520326f, -0.05131265f, 0.11930697f, -0.04474783f, 
    -0.10856421f, -0.23360306f, -0.04970098f, -0.21526861f, 0.02299574f, -0.09390898f, -0.15747507f, -0.06487986f, 
    0.07630295f, -0.02198344f, 0.05287730f, 0.11232373f, -0.13452071f, 0.07793207f, 0.06425784f, -0.03182106f, 
    0.00817219f, 0.03307506f, 0.04783241f, 0.06981198f, 0.00600038f, -0.05158205f, -0.03784146f, -0.03504999f, 
    0.23030914f, 0.12276211f, 0.13017040f, -0.03518657f, -0.06051585f, 0.01607513f, 0.06299111f, 0.09093712f, 
    0.07687329f, -0.18084267f, -0.04484461f, 0.02951433f, -0.04395758f, 0.03704701f, 0.25905377f, -0.02743183f, 
    -0.06656059f, -0.03627592f, -0.08270852f, -0.00702755f, 0.15400770f, -0.00216370f, 0.04192316f, 0.02495754f, 
    0.10771525f, -0.01486045f, -0.04717700f, 0.06173335f, 0.06707042f, -0.09026481f, 0.06013620f, -0.06043178f, 
    0.06399355f, 0.01154928f, -0.01620277f, -0.06714478f, 0.21556230f, 0.03037576f, 0.16109742f, 0.02578171f, 
    0.01203784f, -0.00831128f, -0.03287724f, 0.14837739f, 0.01611835f, -0.04660514f, -0.03543882f, 0.03921197f, 
    -0.03250133f, -0.07652641f, 0.13018166f, 0.16812816f, 0.05694133f, 0.06555126f, 0.00011130f, 0.00342626f, 
    0.02245341f, -0.05425898f, -0.00475633f, 0.02556661f, -0.14447649f, -0.08303809f, -0.02881173f, -0.05747685f, 
    0.04492919f, 0.00900374f, 0.10174152f, -0.06785510f, 0.11416660f, 0.01299174f, -0.13934375f, -0.01781697f, 
    -0.08374176f, -0.10412583f, -0.03105395f, 0.13339470f, 0.04522897f, 0.02059620f, 0.06181167f, -0.18731838f, 
    0.16493160f, 0.04514458f, -0.03088585f, -0.00149676f, -0.02762531f, -0.03722424f, 0.05868336f, -0.25444311f, 
    0.01073996f, 0.02633552f, 0.07199586f, -0.09233260f, 0.12642224f, -0.05179157f, 0.06075733f, 0.11819145f, 
    -0.02870205f, 0.01065028f, -0.00270890f, -0.03592387f, 0.00094118f, -0.03023799f, -0.04033862f, -0.04216613f, 
    0.00507829f, 0.01088201f, 0.00799790f, -0.03738536f, 0.01798823f, 0.01698316f, -0.02545588f, 0.01813216f, 
    -0.01958997f, 0.00795178f, -0.02123364f, -0.03695438f, -0.02182476f, 0.01655963f, -0.01903460f, 0.00735574f, 
    0.01413582f, 0.00613978f, 0.00294505f, -0.03012288f, -0.02347131f, -0.01262985f, -0.02866336f, 0.02289515f, 
    0.00775671f, -0.02592446f, -0.03799328f, -0.01131330f, 0.01903333f, -0.02877139f, -0.03096658f, -0.01828162f, 
    -0.02220915f, -0.01265983f, 0.02669388f, -0.04008779f, 0.01266444f, -0.00572081f, -0.00658794f, 0.02740038f, 
    -0.01084054f, -0.00530473f, 0.02103882f, 0.02149805f, 0.01397086f, -0.00048631f, 0.01769046f, 0.01329396f, 
    0.02799954f, 0.01364184f, -0.02786148f, 0.01246814f, -0.01133218f, 0.01525057f, -0.01566928f, -0.00585885f, 
    -0.01287148f, -0.01156453f, -0.00811521f, -0.03675073f, 0.01446643f, 0.00856937f, 0.00788466f, -0.01629286f, 
    -0.03853263f, 0.00110274f, -0.02295679f, -0.00311893f, 0.02560356f, 0.02258644f, -0.00353075f, -0.02016713f, 
    0.00604521f, -0.00332922f, 0.01426049f, -0.02497969f, 0.01324418f, 0.02135473f, 0.02342246f, -0.00339595f, 
    0.01436918f, -0.01781132f, -0.01539233f, 0.02525398f, -0.03379728f, 0.02872124f, 0.00041541f, 0.01078496f, 
    0.02928511f, -0.02278926f, -0.04201363f, -0.01167000f, 0.02636565f, -0.03097580f, -0.02364219f, 0.02765519f, 
    0.00452357f, 0.02682536f, -0.00493751f, -0.02584361f, 0.02211798f, 0.01234296f, 0.00162952f, -0.03750110f, 
    0.01176735f, -0.03928054f, -0.03619726f, -0.03060856f, -0.03914681f, -0.02371229f, 0.02336052f, -0.02371657f, 
    0.01678788f, -0.01176922f, 0.02737513f, -0.01498828f, 0.01867058f, -0.00045208f, -0.00794310f, -0.03849906f, 
    -0.00431435f, -0.01716923f, 0.00620507f, -0.03498669f, -0.03033891f, 0.00826480f, -0.02107201f, 0.02782412f, 
    -0.03449468f, -0.04201430f, -0.00560364f, -0.02634935f, 0.02523402f, -0.03900876f, 0.01849994f, -0.03032087f, 
    -0.02194140f, -0.02732124f, 0.02134530f, -0.00538932f, -0.02408386f, -0.00582138f, 0.02176625f, -0.01846881f, 
    -0.02914270f, -0.03454588f, -0.00316124f, -0.00482159f, 0.02851320f, -0.01175294f, -0.01196369f, 0.01158347f, 
    -0.04162227f, -0.03506792f, 0.00132562f, 0.02471021f, 0.00276844f, -0.01251806f, -0.03111561f, 0.02836972f, 
    -0.02824023f, -0.02735684f, 0.02085898f, -0.03679383f, -0.01522357f, -0.00104768f, -0.00886689f, -0.01858026f, 
    0.01209418f, -0.01698515f, 0.01468753f, 0.01895097f, 0.02228533f, -0.02370384f, 0.01740635f, -0.03536614f, 
    -0.04035385f, 0.01979673f, -0.03852370f, 0.01775184f, 0.00975623f, 0.00138250f, -0.00660158f, -0.03440170f, 
    0.00160405f, -0.02575610f, -0.01776488f, -0.01754280f, 0.02253907f, -0.03932492f, -0.01474881f, -0.01927629f, 
    -0.01579508f, -0.03781356f, -0.03154206f, 0.02142126f, -0.00001996f, 0.00031780f, 0.00265027f, -0.03424773f, 
    -0.03952889f, -0.01335805f, 0.02064533f, 0.02653065f, 0.00187632f, 0.00622282f, 0.01489534f, 0.01207413f, 
    -0.03295705f, 0.02443185f, -0.00533862f, 0.01674713f, 0.00430326f, -0.01491997f, -0.00353911f, -0.03600548f, 
    0.01700383f, 0.00645369f, -0.02256636f, -0.00934621f, -0.00254825f, 0.01096582f, -0.03499429f, -0.03471128f, 
    -0.00419067f, 0.01098191f, -0.04146616f, -0.01849344f, 0.01277033f, -0.03630852f, -0.02596585f, 0.02589389f, 
    -0.03179587f, 0.00328707f, 0.00099350f, 0.01960994f, -0.04394249f, -0.01759065f, -0.03562693f, 0.02665786f, 
    0.01466976f, -0.02244565f, 0.00152755f, -0.03767166f, 0.02383351f, -0.03380061f, -0.04151937f, 0.00781312f, 
    -0.00310321f, -0.03837166f, -0.01844093f, -0.03329900f, -0.02086691f, -0.03143208f, -0.02809755f, 0.01110317f, 
    0.00397208f, 0.00316536f, 0.01803217f, -0.01110594f, 0.01808812f, -0.00066223f, 0.01749464f, 0.00884965f, 
    0.02568495f, 0.00068062f, -0.02492113f, -0.03776788f, 0.02752118f, -0.03247667f, -0.04204205f, 0.01142800f, 
    0.02219312f, -0.01400713f, -0.03488386f, 0.02673960f, -0.01387447f, -0.03120291f, 0.02337603f, 0.01289164f, 
    -0.01909116f, -0.00291301f, 0.00203683f, -0.00133902f, -0.02450754f, -0.03139789f, 0.01171727f, -0.00831067f, 
    -0.01098590f, 0.00262846f, 0.02537796f, 0.00741338f, 0.01631063f, -0.03762863f, -0.02382551f, -0.04178766f, 
    0.02717136f, -0.01877522f, -0.00928947f, 0.02244889f, 0.00519173f, 0.01422675f, -0.04188357f, 0.00787383f, 
    0.02428811f, -0.00061608f, 0.01778548f, 0.01965621f, -0.01806059f, -0.03531230f, 0.00733815f, 0.00033188f, 
    -0.02587494f, 0.01214736f, -0.00576931f, -0.00600092f, -0.01758819f, 0.01300588f, -0.01761215f, -0.01997295f, 
    0.02939260f, -0.03635915f, -0.04083394f, -0.03488368f, -0.04241675f, -0.02708261f, -0.02007364f, -0.00401722f, 
    0.01088721f, 0.01145043f, -0.03837874f, -0.01055481f, -0.03840410f, -0.04227273f, 0.00881088f, 0.01508191f, 
    -0.00388050f, 0.02516698f, -0.02076685f, 0.01065085f, -0.00392182f, -0.01249003f, 0.01292439f, -0.02241920f, 
    -0.03597470f, -0.02245437f, -0.00131446f, -0.03176941f, 0.01852612f, 0.00940055f, -0.02347695f, 0.00969901f, 
    0.00644431f, -0.03201031f, -0.02142913f, 0.00896919f, 0.01417259f, 0.00833711f, -0.01681640f, -0.00045402f, 
    -0.02839779f, 0.01094729f, 0.02027994f, -0.01175264f, -0.02411948f, 0.02776430f, 0.02207807f, 0.00095748f, 
    0.01552060f, -0.02932837f, -0.03076974f, 0.00428320f, 0.02880261f, -0.00918365f, 0.02163912f, -0.00586040f, 
    -0.01290496f, -0.02686495f, 0.00884389f, -0.01188927f, -0.03954224f, -0.01914811f, 0.00396353f, -0.02675736f, 
    -0.01814142f, 0.00563472f, 0.00824642f, -0.02640696f, 0.02270543f, -0.00157915f, -0.00580008f, 0.00214183f, 
    -0.03680910f, -0.02761273f, 0.02570264f, 0.01572040f, -0.00886934f, -0.01243197f, 0.01772169f, 0.02847121f, 
    -0.00707027f, 0.01670988f, -0.03046000f, -0.00360154f, 0.00979829f, 0.00021542f, 0.00000883f, -0.01471044f, 
    0.01504393f, 0.02344857f, -0.03951463f, -0.03619280f, 0.01632940f, -0.00026256f, -0.02266400f, -0.03837964f, 
    -0.04158960f, 0.01068865f, 0.01014235f, -0.03347112f, 0.01153168f, -0.00843296f, 0.00345397f, -0.01071402f, 
    -0.00759538f, 0.00892405f, 0.01703907f, 0.02805783f, -0.03927131f, 0.01696444f, -0.03018802f, -0.02632170f, 
    0.02910180f, 0.01679307f, 0.02090203f, -0.01700009f, 0.00437579f, -0.00006856f, 0.00038737f, 0.01707169f, 
    -0.02997652f, -0.01139942f, 0.01499415f, -0.01678951f, 0.01788030f, -0.03608713f, -0.01564534f, -0.03667405f, 
    0.02313837f, -0.02220151f, -0.03719526f, -0.04202029f, -0.00287664f, 0.02105988f, -0.00088459f, -0.00073549f, 
    0.00401930f, -0.03621153f, 0.02832636f, -0.00101432f, -0.00473149f, -0.03894208f, 0.01841571f, 0.01829778f, 
    -0.02985474f, -0.01438716f, 0.02886655f, 0.00245135f, 0.02960458f, -0.03254693f, 0.00771356f, -0.02301037f, 
    0.02659760f, 0.01242604f, -0.00941861f, -0.03715431f, 0.02475846f, 0.02688216f, 0.01583775f, 0.00157399f, 
    0.00603224f, 0.00387436f, -0.03443515f, -0.00240123f, -0.00689367f, 0.02274004f, -0.01643035f, 0.02317699f, 
    0.00189087f, 0.00826552f, 0.01418574f, -0.02687133f, -0.00608568f, 0.01396186f, -0.01903434f, 0.01206804f, 
    -0.01815888f, -0.01818384f, -0.02139921f, -0.00333241f, 0.02435453f, -0.04063580f, -0.02327418f, 0.01915032f, 
    -0.00288235f, -0.01725760f, 0.01182403f, -0.00104402f, -0.03939534f, -0.01528323f, 0.01725155f, -0.00671930f, 
    0.01853297f, 0.02530308f, -0.04207641f, 0.00369649f, -0.01440583f, 0.00894546f, 0.02943111f, -0.00450285f, 
    -0.03740770f, -0.04242276f, 0.02040164f, -0.01140830f, 0.02821452f, -0.03205139f, -0.04211584f, -0.03966204f, 
    0.01147967f, 0.02190718f, -0.02457193f, -0.00063255f, -0.02900663f, -0.00486245f, -0.01089849f, 0.01139522f, 
    0.00284705f, 0.01715378f, -0.03561976f, -0.03722881f, -0.04060656f, -0.00352502f, 0.00834974f, -0.02992310f, 
    -0.02198437f, -0.00911267f, -0.02777033f, -0.03788418f, -0.03611022f, 0.02584850f, 0.02081962f, -0.00127145f, 
    0.01150208f, -0.00557921f, -0.00349164f, -0.04008115f, -0.03996804f, -0.03324395f, 0.01227363f, -0.04095023f, 
    -0.02453935f, 0.01180311f, -0.03853021f, -0.02631572f, 0.02668623f, -0.03067694f, -0.01660925f, -0.02448555f, 
    -0.03051623f, -0.04178049f, 0.00225591f, -0.02647537f, -0.02218249f, -0.00151538f, -0.04121111f, -0.03620921f, 
    -0.00577760f, 0.01450318f, 0.01913217f, -0.01956516f, 0.02483295f, -0.02101935f, 0.00679629f, 0.02178565f, 
    -0.02419022f, -0.01360898f, 0.02034490f, 0.02879638f, 0.00245299f, -0.00758482f, -0.02204398f, -0.00431265f, 
    -0.01475695f, -0.02656285f, -0.01592728f, -0.02054979f, 0.01737237f, -0.00201278f, 0.02110922f, 0.02829794f, 
    0.02747474f, -0.00958688f, -0.03527034f, -0.03870182f, 0.01063181f, 0.00052950f, 0.00131412f, 0.01803618f, 
    -0.03087175f, -0.01472444f, -0.02734404f, 0.02256231f, -0.01211196f, 0.01578312f, 0.02117962f, -0.00928356f, 
    -0.00129286f, 0.02873686f, -0.02788761f, -0.00723689f, 0.01509792f, -0.03329580f, -0.00909266f, -0.02566346f, 
    0.00246957f, 0.00379083f, -0.01698248f, 0.00259622f, 0.02915869f, -0.02308792f, -0.01725124f, -0.01402086f, 
    -0.00067338f, -0.03277359f, -0.03270765f, 0.01306415f, 0.00411204f, 0.01205746f, -0.03210786f, -0.00601684f, 
    0.00043040f, -0.01379431f, -0.03261308f, -0.02557552f, 0.01924380f, 0.01123533f, 0.01043361f, -0.01909878f, 
    0.02802423f, -0.01330248f, -0.01450070f, -0.01645320f, -0.01142689f, -0.01917325f, -0.00061487f, -0.01126071f, 
    0.00568488f, -0.02693450f, -0.04133512f, 0.00471867f, 0.01039161f, -0.02285259f, 0.01428755f, -0.03220014f, 
    -0.02735743f, 0.00562825f, 0.02369824f, 0.01147431f, -0.00561930f, -0.03560485f, 0.02918983f, -0.04151389f, 
    0.00756826f, -0.02718436f, -0.01962175f, -0.02318822f, 0.02503766f, 0.00021195f, -0.02487478f, 0.00214488f, 
    0.00799809f, 0.00378730f, -0.01864299f, 0.02313020f, -0.00886301f, 0.00848165f, 0.02018008f, -0.00056185f, 
    -0.00345354f, -0.01333627f, -0.04039562f, -0.00896640f, 0.00656586f, 0.02840299f, -0.03453273f, -0.03132138f, 
    0.00986691f, -0.04139631f, -0.01576823f, -0.01825986f, -0.03364643f, -0.00343477f, -0.01812009f, -0.01028126f, 
    0.02012902f, 0.01202446f, 0.02873339f, -0.02381399f, -0.03472664f, -0.02340372f, 0.02875254f, 0.01126595f, 
    0.00192136f, -0.01489525f, -0.01742837f, -0.02113616f, -0.02463059f, 0.00930975f, -0.01757369f, -0.03471147f, 
    -0.02268070f, -0.00399385f, 0.01063721f, -0.01141599f, 0.01073052f, -0.03889020f, -0.01992625f, -0.03932676f, 
    -0.01449480f, -0.00087812f, -0.01397277f, 0.01476157f, -0.04197421f, -0.00085719f, -0.01696604f, 0.02306357f, 
    0.02558444f, -0.03162123f, 0.00261309f, 0.02600048f, 0.01363361f, -0.02202749f, -0.02061846f, -0.01840116f, 
    0.01238064f, 0.00120688f, -0.00036228f, 0.01571222f, -0.03176669f, 0.02206075f, 0.01431275f, 0.02395579f, 
    -0.01493667f, -0.00760267f, 0.00396154f, -0.02605771f, 0.02474538f, -0.02123662f, 0.02773784f, -0.03687388f, 
    -0.00957207f, -0.01340203f, -0.00868757f, -0.02968809f, -0.00620431f, -0.03545961f, -0.02899808f, 0.01499740f, 
    0.02871586f, 0.03269994f, -0.00820008f, 0.02854951f, 0.01969852f, 0.00916968f, -0.01931152f, 0.02413832f, 
    -0.03176759f, -0.03571578f, 0.00773309f, -0.03917227f, 0.01621963f, 0.02922365f, -0.01541786f, -0.02904042f, 
    0.01811698f, 0.02677313f, -0.02974823f, 0.02048802f, -0.02232429f, 0.02692464f, 0.02764167f, -0.02127725f, 
    0.02173635f, 0.01929987f, -0.00021064f, -0.00753102f, 0.02698401f, 0.00945072f, -0.03030073f, 0.01552568f, 
    0.01599929f, 0.00036465f, 0.01881568f, 0.01703635f, 0.02993081f, 0.02220285f, -0.01608863f, -0.03295410f, 
    0.03173329f, 0.00412087f, 0.00579787f, 0.00672720f, 0.01151007f, 0.02160187f, -0.01093553f, 0.00695936f, 
    -0.00181399f, 0.00303211f, 0.02598131f, 0.00705330f, -0.01335672f, 0.03387004f, 0.03121662f, -0.01005296f, 
    -0.02837427f, -0.02920488f, -0.01662918f, -0.02848508f, 0.02010318f, -0.00671641f, -0.02042619f, 0.02796601f, 
    -0.02596660f, -0.00464583f, 0.01443521f, 0.00174008f, -0.01362221f, -0.01749342f, -0.03172295f, -0.01023191f, 
    -0.02270624f, -0.03427880f, -0.02604109f, -0.02795759f, -0.03715966f, 0.00385418f, -0.00351866f, 0.02046487f, 
    -0.02364035f, -0.03254197f, -0.00073125f, 0.01638823f, 0.02067040f, -0.00496788f, -0.00215535f, -0.03757003f, 
    0.00663122f, 0.03155386f, -0.00556814f, 0.02580084f, 0.01583165f, -0.03575077f, -0.01154346f, 0.00040910f, 
    -0.02756933f, 0.01384477f, -0.02520818f, 0.02528580f, -0.00898983f, -0.02778308f, -0.01354811f, -0.02438495f, 
    -0.00380033f, -0.03498930f, -0.02719511f, -0.02066164f, -0.01329761f, 0.00979755f, -0.01656920f, -0.01619877f, 
    -0.01856317f, 0.03032761f, -0.03624721f, 0.01791242f, -0.01122436f, -0.00868830f, 0.01511039f, 0.02594719f, 
    0.01148728f, -0.00907154f, -0.00327830f, 0.02624386f, 0.00080183f, -0.01346498f, -0.00423158f, 0.00296354f, 
    -0.01580391f, -0.01311602f, -0.00687655f, -0.02112821f, -0.01732150f, -0.02126364f, 0.02778681f, 0.00248616f, 
    -0.03864166f, 0.00295044f, -0.03930834f, 0.02984780f, 0.00761470f, -0.02859190f, -0.03683656f, -0.02475680f, 
    0.02799607f, 0.00067094f, -0.00486824f, -0.01535736f, 0.00886407f, 0.02796792f, 0.00844426f, 0.02767414f, 
    0.00443194f, 0.01883270f, -0.02193267f, 0.00527294f, 0.01681813f, -0.00852332f, -0.02821144f, 0.01962168f, 
    0.03045465f, 0.00999408f, -0.00718785f, -0.01523454f, -0.00142183f, 0.00410864f, -0.03303060f, 0.00573474f, 
    -0.02288267f, -0.01846373f, 0.02327561f, -0.03321787f, -0.00124756f, 0.01370315f, 0.02861154f, -0.00481749f, 
    -0.01308897f, -0.00490188f, 0.02608206f, -0.04099238f, -0.03820141f, 0.03112997f, 0.00241055f, -0.01345260f, 
    -0.02908748f, -0.00988328f, 0.00580900f, 0.01320750f, -0.03398329f, -0.02352920f, 0.02814649f, -0.02320001f, 
    -0.00365350f, 0.00251094f, -0.02104540f, 0.00989330f, 0.02466598f, 0.02613783f, -0.03528882f, 0.00323744f, 
    0.02893770f, 0.02404752f, 0.00801711f, 0.01921824f, -0.00490298f, -0.03426022f, -0.02046922f, 0.01050991f, 
    -0.02347294f, -0.02213721f, 0.01658210f, -0.02466682f, -0.03286528f, -0.02859456f, 0.02528002f, -0.03294357f, 
    -0.02954317f, 0.01749939f, -0.02747330f, -0.01132394f, 0.01202378f, -0.00710136f, -0.03451623f, -0.01420285f, 
    0.02180629f, 0.02228640f, 0.00704291f, 0.02048724f, -0.03385505f, -0.03576073f, -0.02100042f, 0.03092729f, 
    -0.03541466f, -0.02463527f, -0.03631891f, 0.01776945f, -0.01714699f, -0.02185881f, 0.01903189f, -0.01850871f, 
    0.01973825f, 0.01106278f, -0.03161993f, 0.00884508f, 0.01291019f, 0.01028760f, -0.02362976f, 0.01376368f, 
    -0.02574459f, 0.01161154f, -0.00519710f, -0.03344827f, 0.00850693f, 0.03006971f, -0.00519296f, -0.01064548f, 
    0.01437886f, -0.01019904f, -0.03672444f, 0.02642624f, 0.01353596f, 0.00584441f, -0.03236393f, -0.01875761f, 
    -0.00008005f, 0.01458093f, 0.02494174f, -0.03141959f, -0.03592175f, 0.02638418f, -0.03555293f, -0.00523630f, 
    -0.02946609f, -0.03030926f, 0.02338436f, -0.01542936f, -0.01903107f, -0.02656899f, -0.03492689f, 0.00263652f, 
    -0.01265314f, -0.01350558f, 0.01908167f, 0.02637925f, 0.00224590f, 0.00305816f, 0.01273575f, -0.00049257f, 
    -0.00983247f, 0.00230907f, -0.01614253f, -0.01830786f, -0.02577271f, 0.00980601f, -0.02729544f, 0.00145587f, 
    -0.02559794f, -0.00541031f, -0.00495924f, 0.02447309f, -0.00304125f, -0.03499643f, 0.00111778f, -0.00657272f, 
    0.00348483f, -0.01605613f, -0.03644411f, -0.02720994f, -0.01781430f, -0.00058245f, 0.00571597f, -0.01567794f, 
    0.00194403f, -0.03298857f, -0.00432335f, -0.00926961f, -0.03573035f, 0.01571616f, 0.02559353f, -0.03304446f, 
    0.01282966f, -0.01853129f, -0.00568739f, 0.00166476f, 0.00323635f, 0.01320202f, -0.02182306f, -0.01443363f, 
    -0.03061598f, 0.00532996f, -0.00756835f, 0.02145835f, -0.02768230f, -0.03903360f, -0.00758505f, 0.01481175f, 
    -0.02622405f, -0.02279292f, -0.01804071f, 0.00286223f, 0.01473498f, -0.04072588f, 0.01574674f, -0.01764054f, 
    -0.03084137f, 0.02205379f, 0.00264347f, -0.01575530f, -0.02736479f, 0.02774189f, -0.03054996f, -0.04084636f, 
    0.00579179f, 0.01240423f, 0.00966882f, 0.00135314f, -0.02115843f, 0.02396370f, -0.01634842f, -0.03781666f, 
    -0.00539519f, -0.03302620f, -0.00057933f, 0.01363197f, -0.00232153f, 0.01946666f, -0.02387794f, 0.01555320f, 
    0.00271314f, -0.04120006f, -0.02435177f, 0.01098256f, -0.01716526f, -0.01645810f, 0.02860903f, 0.02107946f, 
    0.02052244f, -0.02692527f, 0.01264285f, 0.01983881f, 0.02946005f, -0.03669073f, -0.00140953f, 0.02218511f, 
    -0.03334432f, -0.04108607f, 0.02726317f, 0.00185302f, -0.04125241f, -0.02871801f, 0.00691205f, 0.00094199f, 
    -0.01152223f, -0.03424745f, 0.00205194f, 0.00617524f, -0.03614280f, 0.01631192f, 0.02122499f, -0.01812715f, 
    -0.02029727f, -0.02984229f, -0.03301308f, -0.03096299f, -0.00411869f, -0.00674486f, -0.02744614f, -0.00805433f, 
    0.00551493f, -0.03617063f, -0.02388747f, -0.01889507f, -0.01673116f, -0.03506309f, -0.02661557f, -0.00060310f, 
    0.01367475f, -0.02482681f, -0.01935203f, 0.00334289f, -0.01789000f, 0.01220826f, 0.00757164f, 0.02126961f, 
    -0.00503083f, -0.01723698f, -0.03109162f, 0.02310285f, -0.00175659f, -0.00366698f, -0.00418881f, -0.00810672f, 
    0.01497841f, -0.01479431f, -0.00154229f, 0.01055993f, 0.01795882f, -0.03301062f, 0.02627252f, 0.03076105f, 
    -0.01592996f, -0.00837703f, -0.00099923f, 0.01792248f, 0.00835319f, -0.02052766f, 0.01127432f, -0.02059644f, 
    -0.03647691f, -0.00483078f, -0.00460278f, -0.00477076f, -0.00713485f, 0.03409116f, -0.00947672f, -0.01105287f, 
    -0.03452298f, 0.00304102f, 0.00018359f, -0.02298483f, -0.03785755f, -0.01542393f, 0.03203721f, -0.01797458f, 
    -0.00957969f, 0.02018741f, 0.01899507f, -0.02976083f, 0.00055671f, -0.03782958f, 0.02268040f, 0.02719904f, 
    0.01215610f, 0.01114789f, 0.00716836f, 0.01115152f, 0.01561345f, 0.00106250f, 0.02969675f, -0.03102028f, 
    0.03025253f, 0.00459925f, 0.01815487f, -0.00549566f, -0.02418428f, -0.01591912f, -0.03863194f, 0.02361539f, 
    -0.01385331f, -0.02325225f, -0.03091605f, 0.00831007f, -0.02266888f, -0.02508137f, -0.02604635f, -0.03428464f, 
    0.03046569f, -0.02594758f, 0.00236414f, 0.02450162f, -0.03131516f, -0.01000287f, 0.02104229f, -0.01341431f, 
    -0.03414137f, -0.02250003f, -0.00750338f, -0.02908777f, -0.03721995f, 0.02034116f, -0.03017885f, 0.00035626f, 
    0.02782419f, 0.01944776f, 0.00117025f, -0.02909986f, 0.01662899f, -0.01102973f, 0.02276393f, 0.00575000f, 
    -0.02664659f, -0.00460322f, 0.01877298f, -0.02467691f, 0.01324219f, 0.00141329f, -0.03404718f, 0.01434273f, 
    -0.00562256f, -0.03576642f, -0.02703867f, 0.03228385f, -0.00699140f, 0.01268491f, -0.03724233f, 0.00699310f, 
    0.00410685f, -0.02756633f, 0.02677814f, -0.02577198f, -0.00623089f, 0.00611744f, 0.02813536f, 0.02700123f, 
    0.00658097f, 0.01021185f, -0.00220053f, -0.00847405f, 0.02957862f, 0.03283470f, -0.01306785f, -0.03053092f, 
    0.01980229f, -0.01281111f, 0.02026085f, -0.02545539f, -0.00316478f, 0.01272102f, 0.02856870f, -0.03246251f, 
    -0.00975493f, -0.02746156f, -0.01273573f, 0.02880464f, 0.02090409f, -0.01944245f, -0.03274437f, 0.00179102f, 
    0.00845948f, -0.00210333f, 0.01558520f, -0.00664716f, -0.00412234f, 0.00895368f, 0.00985233f, -0.01876349f, 
    0.03259001f, 0.02946389f, 0.02001001f, -0.02716553f, -0.03734685f, 0.02575878f, -0.00074482f, 0.01708878f, 
    0.02655322f, 0.03664218f, 0.02765919f, -0.00551831f, 0.00829173f, 0.02655730f, -0.00833321f, 0.00618190f, 
    0.02488899f, -0.02626286f, -0.02763300f, -0.02589945f, 0.00406336f, -0.01771197f, 0.00226795f, 0.02776877f, 
    -0.02224293f, -0.03933178f, 0.00484083f, -0.03264953f, -0.02793074f, -0.02161682f, 0.00849531f, -0.03485316f, 
    0.02517007f, 0.01990401f, 0.01763030f, -0.03046965f, 0.01326417f, -0.03473181f, -0.01739512f, -0.01478248f, 
    -0.00694890f, -0.01218232f, 0.03286310f, -0.02709997f, -0.02835670f, -0.01542303f, -0.00342147f, 0.02493554f, 
    -0.00915281f, 0.01224532f, -0.00374452f, 0.03013955f, -0.01336662f, -0.00354668f, -0.00904315f, -0.03151422f, 
    0.00621186f, -0.01527027f, -0.03597425f, 0.01177199f, -0.02494724f, 0.02841254f, -0.02244076f, 0.00861265f, 
    -0.04365324f, -0.00390449f, -0.03886166f, 0.02014890f, 0.00948597f, 0.03316390f, 0.03040815f, 0.01650866f, 
    -0.00216752f, -0.01760024f, -0.02074589f, -0.01069873f, -0.02799778f, 0.01000867f, -0.02524686f, -0.00514078f, 
    0.01352705f, -0.03965167f, 0.02305594f, -0.01515109f, -0.01774323f, 0.01072015f, 0.02369799f, -0.03563404f, 
    -0.03676646f, 0.01697549f, 0.01661606f, 0.02095287f, -0.01779883f, -0.00930659f, 0.00208630f, -0.01308837f, 
    0.03164566f, 0.01692761f, -0.01654492f, -0.01317147f, -0.01082600f, -0.00327980f, 0.02225780f, -0.03950892f, 
    0.03166485f, -0.04105535f, 0.01497184f, 0.00312699f, 0.02339499f, 0.01026364f, -0.01776600f, -0.01790946f, 
    0.03139675f, 0.00699266f, -0.03452774f, -0.02635212f, -0.00812180f, -0.00740941f, -0.00993067f, 0.01426359f, 
    0.00253605f, -0.02430313f, 0.02324310f, -0.02658219f, -0.01917272f, 0.01460226f, 0.00447363f, -0.03277842f, 
    -0.00559311f, -0.01022039f, -0.02705859f, 0.00281850f, -0.03176422f, -0.02212958f, 0.00917482f, 0.01418241f, 
    -0.01292956f, -0.03811564f, -0.01963378f, 0.02122231f, -0.03970703f, -0.01016780f, -0.00727500f, -0.03188004f, 
    0.03131159f, -0.00250963f, -0.03676542f, -0.02933702f, 0.00301955f, 0.01558995f, 0.02137041f, -0.02859118f, 
    0.01635282f, 0.02154896f, 0.01610238f, -0.03889945f, -0.02261848f, 0.01076343f, -0.00465631f, -0.03724349f, 
    0.01716440f, 0.02041735f, -0.02169312f, 0.02543950f, -0.00474975f, 0.02717727f, 0.00551055f, 0.02211052f, 
    0.02092804f, -0.00147328f, -0.03107468f, 0.01275153f, 0.01146870f, -0.03538705f, 0.00926012f, 0.02022008f, 
    0.02446489f, -0.02309924f, 0.00188055f, 0.01805854f, -0.01155905f, 0.02971549f, -0.02687301f, -0.02368167f, 
    0.03069136f, -0.03464986f, 0.00160967f, -0.01708859f, -0.01530929f, -0.02359223f, 0.00890068f, -0.02099071f, 
    0.02592836f, -0.02009892f, -0.02971863f, 0.00870097f, -0.01485112f, 0.01641250f, -0.01114641f, -0.02027341f, 
    0.03037692f, -0.03292453f, -0.01461921f, -0.03980753f, 0.01293488f, 0.01814142f, 0.02859163f, 0.02437672f, 
    0.03045382f, -0.02132683f, 0.01154057f, 0.03207728f, -0.02573997f, -0.03467625f, -0.02897476f, -0.01213510f, 
    0.00066704f, 0.00024534f, -0.00399416f, -0.02487474f, 0.01464196f, 0.00148033f, 0.02610893f, -0.02436184f, 
    -0.01633632f, 0.01489363f, -0.03369865f, 0.02822859f, 0.01664983f, -0.02060563f, -0.00834791f, 0.03024786f, 
    0.02805461f, -0.01221696f, 0.01812576f, -0.01372096f, -0.02632124f, -0.00142927f, -0.03849859f, -0.03591264f, 
    0.02337419f, -0.02595172f, 0.00670257f, 0.01551925f, 0.01488771f, 0.01838167f, -0.04115633f, 0.02480626f, 
    -0.02840867f, 0.02231906f, -0.02867312f, 0.02751603f, -0.03151242f, 0.01254492f, 0.01570734f, 0.01220651f, 
    -0.01679353f, -0.00031371f, 0.02738392f, -0.02841348f, -0.00234408f, 0.02499531f, -0.02794356f, -0.02565512f, 
    -0.02954991f, 0.02858367f, 0.01468241f, -0.03135724f, 0.01101979f, 0.02023672f, -0.02671564f, -0.03849905f, 
    0.00664202f, 0.02281628f, -0.02911335f, 0.02842033f, 0.02318250f, 0.00642611f, 0.02240409f, 0.01835059f, 
    0.01281977f, 0.02889598f, -0.03367070f, 0.03125824f, -0.01505919f, -0.01158670f, -0.02684189f, -0.03084495f, 
    -0.03180042f, 0.01671178f, 0.00634161f, -0.00950818f, -0.00711081f, 0.03088605f, 0.03112845f, -0.01435027f, 
    -0.01298342f, 0.00872048f, 0.00205829f, 0.02505852f, -0.03216909f, -0.02911142f, 0.02061706f, -0.00515245f, 
    0.00765304f, -0.00305813f, 0.02035994f, -0.00522782f, -0.03705091f, 0.00053440f, -0.03941167f, 0.00363068f, 
    0.00780013f, -0.03618034f, -0.02131062f, -0.03508812f, 0.02693897f, 0.02633138f, -0.00603818f, -0.00836632f, 
    -0.01206381f, -0.01641821f, -0.02197752f, 0.02357115f, 0.02379895f, 0.02763644f, -0.02598973f, 0.02232208f, 
    0.00006572f, 0.01460058f, -0.00414945f, -0.00323693f, 0.01219522f, -0.02082521f, 0.00253943f, -0.02935597f, 
    0.03213026f, 0.01902185f, -0.00943671f, -0.00348233f, 0.02630490f, -0.00954702f, 0.01567836f, -0.00586892f, 
    -0.02911728f, -0.04069654f, -0.00693765f, -0.03476376f, -0.02277780f, 0.02932844f, 0.00514559f, -0.02077304f, 
    0.00031939f, -0.04166599f, 0.02782467f, -0.03031067f, 0.02024615f, 0.00415838f, 0.01523886f, -0.03703146f, 
    0.00227199f, -0.00188377f, 0.01108440f, 0.00613950f, -0.02287505f, -0.03240139f, 0.01626319f, -0.02991067f, 
    0.02075834f, -0.00747625f, 0.00611560f, -0.00717419f, 0.02518333f, -0.04037297f, -0.01987454f, -0.01739075f, 
    -0.00213310f, -0.03311209f, 0.01998230f, -0.02318721f, -0.03928432f, -0.02228662f, -0.01481390f, 0.01446285f, 
    -0.00464253f, 0.01615964f, 0.02566774f, 0.03399399f, 0.01179434f, 0.00367747f, 0.00662328f, -0.03371524f, 
    -0.02882334f, -0.02310865f, -0.00862831f, 0.00041745f, -0.00863213f, 0.00604275f, -0.02507176f, 0.00907708f, 
    -0.00215085f, -0.04051271f, 0.01192707f, 0.00172712f, -0.03480824f, -0.00808538f, 0.01535351f, -0.02837161f, 
    -0.02739666f, 0.02276077f, 0.02411838f, 0.03094187f, 0.01395196f, -0.03043498f, 0.02413114f, 0.03008096f, 
    0.01430351f, -0.01080952f, -0.01737621f, -0.01693738f, -0.01110121f, -0.03541110f, -0.02954011f, 0.00573070f, 
    -0.02680383f, 0.01383249f, 0.02289712f, 0.02465842f, -0.01792192f, 0.01523498f, -0.02860642f, -0.01908506f, 
    -0.02795758f, 0.00539075f, -0.01009137f, 0.02709281f, -0.00153597f, -0.02374874f, 0.02660059f, -0.03886944f, 
    -0.01559198f, -0.02282213f, 0.02814965f, -0.02641815f, -0.01687351f, 0.00151159f, 0.01349580f, 0.00136054f, 
    0.01290425f, -0.00399775f, 0.01175934f, -0.01146760f, -0.02322883f, -0.00493015f, 0.02009618f, 0.00882689f, 
    0.02582018f, 0.00125072f, 0.02262370f, 0.00187005f, -0.03894065f, -0.02445057f, -0.02452575f, -0.00351183f, 
    -0.02794779f, -0.01193087f, 0.00963303f, -0.03399422f, -0.00122372f, -0.04075877f, -0.02072910f, 0.02073463f, 
    -0.00148954f, -0.01870361f, -0.03404376f, -0.01156124f, 0.01852031f, 0.03632513f, 0.01272306f, -0.00033088f, 
    -0.02902660f, -0.00060736f, 0.01317355f, 0.01186350f, 0.00189279f, 0.01890695f, 0.02108680f, -0.00023481f, 
    -0.01275952f, -0.01861759f, 0.00032033f, 0.00891657f, 0.00858239f, 0.02301899f, -0.02195954f, -0.01731773f, 
    0.00682093f, 0.02420285f, 0.02164088f, -0.03828567f, -0.00211304f, -0.02129003f, -0.03917155f, -0.00158739f, 
    -0.03209372f, -0.02209422f, -0.02864760f, -0.01095335f, -0.00265221f, 0.02567706f, -0.04183957f, -0.01306864f, 
    0.01956063f, 0.00840125f, -0.00492609f, -0.03387095f, -0.01320681f, 0.02130424f, -0.02274435f, 0.01489503f, 
    -0.03928087f, -0.02884601f, -0.01854482f, 0.00975485f, -0.00584894f, 0.01034872f, -0.00639569f, 0.02237014f, 
    -0.01427890f, 0.00480755f, -0.03061778f, 0.00156342f, -0.03803704f, -0.02348406f, -0.00053268f, -0.02003113f, 
    -0.04103981f, -0.01112447f, -0.02339569f, -0.03085959f, -0.01251492f, -0.00349965f, 0.00978583f, 0.01002864f, 
    -0.02005367f, -0.01072253f, 0.02318101f, -0.00543199f, -0.03979727f, 0.00972255f, 0.02062977f, 0.02146543f, 
    -0.03454607f, -0.00885438f, 0.01752347f, -0.02825009f, -0.02492214f, -0.01577543f, 0.03080800f, -0.00499506f, 
    -0.00354092f, -0.01771826f, 0.02114308f, -0.03585551f, -0.02782276f, -0.03987090f, -0.02640118f, -0.01169570f, 
    0.00825097f, 0.00200199f, -0.00995568f, 0.00695212f, -0.01283756f, -0.01030804f, -0.02045887f, 0.02872824f, 
    0.02877582f, 0.02024925f, -0.00289920f, -0.01743896f, -0.03203656f, 0.00370873f, 0.00654730f, -0.03498106f, 
    -0.01920476f, 0.00135730f, 0.01886569f, 0.01067737f, 0.00865081f, -0.00529989f, 0.00289908f, 0.01411983f, 
    0.01038363f, -0.03312099f, 0.01752378f, 0.02594404f, 0.02564931f, -0.03049487f, -0.00811499f, 0.01155669f, 
    -0.03917602f, 0.02789096f, -0.00038743f, -0.01231727f, -0.00078918f, 0.00472086f, 0.00457370f, 0.03053874f, 
    -0.00054039f, -0.03520085f, 0.00745562f, -0.03176230f, -0.03864865f, 0.02845282f, 0.01891246f, -0.01866283f, 
    0.00828159f, 0.02572162f, 0.00141871f, -0.03925262f, -0.03827570f, 0.00689633f, 0.00892226f, -0.00219546f, 
    0.01110606f, -0.01467056f, 0.01735481f, -0.02907865f, 0.01665333f, -0.02665520f, 0.01251000f, -0.03199634f, 
    0.01557929f, -0.01070708f, 0.02689985f, 0.02080842f, 0.03066804f, -0.03365466f, -0.03013694f, -0.04081582f, 
    -0.04009944f, -0.02176200f, 0.00825304f, -0.00084670f, 0.01189905f, 0.00410651f, 0.01535114f, -0.01870330f, 
    -0.02184268f, 0.00819627f, -0.01106018f, 0.03207145f, -0.03831911f, 0.01466070f, 0.02818868f, -0.01847653f, 
    0.00556806f, -0.02105685f, -0.03724822f, 0.00448448f, 0.03050226f, 0.01038572f, -0.03385340f, 0.02657811f, 
    -0.02748474f, -0.02217644f, -0.01903022f, -0.01199263f, 0.01498786f, -0.00952708f, -0.03356021f, 0.00209563f, 
    -0.00484483f, 0.00500078f, 0.00787361f, -0.02817569f, -0.03098056f, -0.00610929f, -0.01868163f, -0.01659816f, 
    0.03016207f, 0.00152377f, -0.01521512f, 0.01766921f, 0.02404705f, 0.01274204f, 0.01863782f, -0.02312632f, 
    -0.04079105f, -0.03119879f, -0.01586903f, -0.02723020f, -0.03301253f, -0.03726354f, 0.02288131f, 0.00558446f, 
    -0.02822722f, -0.01529090f, 0.01557093f, -0.02606706f, -0.00542669f, -0.03116539f, 0.02740516f, -0.00786506f, 
    -0.02428073f, -0.01685496f, 0.01416718f, 0.03059119f, -0.01064252f, -0.02826303f, 0.00766089f, 0.01037819f, 
    0.01728512f, 0.01654911f, -0.02347829f, -0.03412829f, 0.01336983f, 0.02201102f, -0.02377835f, 0.01798927f, 
    -0.00131840f, 0.00147906f, -0.01681885f, 0.02479967f, 0.01926883f, 0.01660061f, 0.02481066f, -0.01745531f, 
    -0.02547757f, -0.02997500f, 0.00590755f, -0.00768115f, 0.01765005f, 0.01252729f, -0.03931682f, 0.02510462f, 
    -0.01337525f, -0.00449472f, -0.01966277f, -0.01343314f, -0.01418357f, -0.03616981f, -0.00462306f, 0.03640201f, 
    0.02427019f, 0.01520011f, 0.00872357f, -0.03167162f, -0.00788755f, 0.02243541f, 0.00532699f, -0.01163879f, 
    0.00972906f, -0.01425076f, -0.03240779f, 0.02441487f, 0.00873369f, -0.01608993f, -0.00229625f, 0.00295166f, 
    0.00590085f, 0.00689224f, 0.00094263f, 0.00580253f, -0.01599899f, 0.01654849f, -0.01125911f, 0.00490892f, 
    0.02278951f, -0.02635414f, -0.02526499f, 0.00827449f, 0.02331610f, -0.01754823f, 0.01154053f, -0.00601263f, 
    -0.00382838f, 0.01141480f, -0.03058765f, -0.03255124f, -0.03099189f, -0.00771085f, -0.02604275f, -0.01171093f, 
    -0.02009933f, 0.03108131f, -0.02433741f, 0.00216115f, 0.02695751f, -0.00301872f, -0.00661017f, 0.01927426f, 
    -0.03988223f, 0.01485431f, 0.01274981f, 0.01339537f, 0.00908476f, -0.02679015f, -0.00331198f, -0.01437148f, 
    -0.02252024f, -0.01666234f, 0.02487108f, -0.03264541f, 0.00689479f, 0.02792089f, 0.00514200f, -0.01403802f, 
    0.00823350f, 0.01607136f, 0.02060811f, -0.02436575f, -0.00334453f, -0.01720078f, -0.03307127f, -0.00574619f, 
    -0.00080392f, -0.03720971f, 0.02787171f, 0.01847614f, -0.02709182f, 0.02245998f, 0.02171734f, -0.03503688f, 
    0.00685778f, -0.01542506f, 0.00211617f, 0.00592947f, 0.03045646f, -0.01789262f, 0.02740169f, 0.00855450f, 
    -0.04034305f, 0.02612773f, 0.00566780f, 0.02008265f, -0.03268348f, 0.00583676f, -0.00643092f, 0.00598874f, 
    -0.00473708f, 0.00278082f, 0.01610584f, 0.01344167f, -0.03877875f, 0.01449193f, 0.00149782f, -0.01712979f, 
    -0.00921600f, -0.00650003f, -0.02468244f, -0.01074546f, -0.00998568f, 0.01545316f, -0.01685098f, 0.02826456f, 
    0.02489705f, -0.00029535f, -0.01064938f, -0.00588825f, 0.02335735f, -0.00029034f, 0.00852598f, 0.02791403f, 
    -0.02960882f, 0.00718866f, -0.02804607f, -0.02409040f, -0.03452144f, 0.02263116f, -0.01140862f, 0.00857181f, 
    -0.01001970f, -0.00226481f, 0.02982690f, -0.01362190f, 0.00712631f, -0.00015537f, -0.01994155f, 0.00861493f, 
    0.01729954f, -0.03448353f, -0.04058366f, -0.02520819f, -0.00877077f, -0.00184671f, -0.03751160f, -0.01116777f, 
    0.01328566f, -0.03923965f, 0.02809736f, 0.01250952f, 0.02563315f, -0.03138090f, -0.01389059f, -0.03358987f, 
    -0.01293774f, -0.00284275f, 0.01963605f, -0.02082783f, -0.02719103f, 0.00933015f, -0.00044040f, -0.03453503f, 
    -0.01289074f, 0.00513561f, -0.01852494f, 0.01195813f, 0.03193179f, 0.01517666f, -0.01390452f, 0.00424856f, 
    0.01003956f, 0.00842900f, 0.01813168f, -0.02994402f, 0.02386949f, -0.02973429f, -0.01969645f, -0.01193795f, 
    -0.00535069f, 0.02476306f, -0.02179985f, -0.01979002f, 0.00912850f, 0.02364812f, -0.01948830f, 0.01453671f, 
    0.01464023f, 0.01938915f, -0.01191180f, -0.03667327f, -0.00868799f, -0.03334870f, 0.01613492f, -0.00448058f, 
    -0.01931589f, -0.01134269f, -0.03372471f, -0.02789544f, 0.02320230f, 0.03166631f, 0.02559485f, -0.00636990f, 
    -0.00946648f, -0.00505385f, -0.02906392f, 0.01368973f, 0.03038634f, -0.01959964f, 0.01916797f, -0.02863738f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11398688f, 0.01931650f, 0.00600302f, 0.01863366f, -0.01788622f, 0.00944893f, 0.00741853f, -0.02417588f, 
    0.00286781f, 0.01226008f, 0.00100940f, -0.02720138f, -0.04072494f, 0.02550600f, 0.02127359f, -0.07654568f, 
    -0.00603299f, -0.01079711f, -0.03439368f, 0.05630288f, -0.00537286f, -0.00336017f, 0.01279581f, 0.05678390f, 
    0.03020817f, 0.02248464f, 0.06845720f, -0.02670254f, -0.02069185f, 0.02736665f, -0.01080712f, -0.03872981f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13357362f, -0.05823085f, 0.13905382f, -0.44627282f, -0.00945071f, -0.06943025f, -0.05847416f, 0.01727964f, 
    0.10299219f, 0.14744174f, 0.03312822f, 0.04124743f, -0.40157208f, -0.02850319f, 0.19645469f, 0.36278352f, 
    0.02264353f, 0.07921908f, 0.27728701f, 0.03379786f, -0.48433954f, -0.04581428f, -0.08376853f, -0.31668171f, 
    0.12013714f, -0.40566960f, 0.14061829f, 0.28742427f, 0.14118353f, -0.10700345f, -0.10255668f, 0.05113658f, 
    0.01594465f, 0.01081449f, -0.02664454f, 0.44311002f, 0.06724745f, 0.12948598f, -0.36247852f, 0.19312073f, 
    0.10719004f, -0.11747475f, -0.00589766f, 0.06869113f, 0.14282510f, -0.07310790f, -0.37566540f, 0.13273214f, 
    0.02327024f, 0.05070149f, 0.36919475f, 0.12403695f, -0.38225627f, 0.07799967f, 0.06381246f, -0.45100081f, 
    -0.01850063f, 0.03788961f, 0.02836349f, -0.09067629f, 0.09661774f, -0.12999193f, 0.07615124f, -0.03809175f, 
    0.14980285f, 0.07564084f, -0.13907327f, -0.14889973f, -0.12268505f, 0.03800912f, 0.27607560f, 0.30182204f, 
    -0.13523398f, 0.16525432f, -0.01034808f, -0.09993286f, 0.42655671f, -0.08097597f, -0.24254747f, 0.15924403f, 
    0.12483797f, -0.05228873f, -0.48782951f, -0.21325395f, -0.52936190f, 0.10544662f, -0.05246146f, -0.38594285f, 
    0.00394737f, -0.30011547f, 0.08207633f, -0.39603397f, -0.04431124f, 0.05101145f, -0.10063287f, -0.06621931f, 
    -0.30771309f, -0.14104669f, 0.07994913f, 0.33939847f, 0.05464470f, 0.01239609f, 0.23533472f, -0.58367389f, 
    -0.14037907f, -0.13402696f, -0.03506766f, -0.08565492f, -0.49383327f, -0.07749483f, 0.14424673f, -0.17110273f, 
    0.01296892f, 0.07761756f, -0.21696638f, -0.14659460f, 0.18012139f, 0.01392919f, -0.08647707f, -0.20523396f, 
    0.14664914f, -0.09891786f, 0.10847464f, -0.48358747f, 0.20913921f, -0.02036155f, 0.04707395f, 0.05135111f, 
    -0.43661639f, -0.03282857f, -0.06899833f, -0.26775670f, 0.01153631f, 0.16791168f, 0.15393382f, 0.01155847f, 
    0.17227815f, -0.14915346f, 0.00878621f, 0.16533294f, 0.06326399f, 0.15304536f, 0.07983587f, -0.23372781f, 
    -0.06328860f, -0.03991851f, -0.06250425f, -0.19303167f, 0.06514569f, -0.15403163f, -0.01609730f, 0.29278794f, 
    0.13726087f, 0.11348835f, 0.19339298f, 0.47347590f, -0.29849759f, 0.07254193f, 0.11414240f, -0.16459827f, 
    -0.02796653f, 0.04169093f, 0.17281017f, -0.01723076f, -0.01602765f, -0.04494085f, -0.14667784f, 0.20244707f, 
    -0.06056135f, -0.13284136f, -0.01877680f, 0.08693901f, -0.31381476f, -0.06103333f, -0.34264228f, -0.22691403f, 
    0.00942622f, -0.05181013f, 0.27574554f, 0.36427972f, 0.16228187f, 0.10953937f, 0.12093537f, 0.23991179f, 
    0.00222026f, -0.13125141f, -0.43889508f, 0.24652156f, 0.14889702f, 0.07632408f, 0.02594147f, 0.00735594f, 
    0.08897298f, 0.08472798f, -0.07970567f, 0.10495488f, -0.13032360f, -0.02033683f, -0.44133618f, -0.38370457f, 
    -0.08575214f, 0.10058214f, 0.15857515f, -0.05863517f, 0.36203688f, -0.09464502f, 0.22882475f, 0.10158491f, 
    0.11213528f, -0.07200631f, -0.37184674f, -0.15344706f, -0.22492224f, 0.09826743f, -0.09803291f, -0.05131670f, 
    0.08224739f, 0.17876808f, -0.29747206f, 0.18372659f, 0.26129508f, 0.02324235f, -0.06452842f, 0.07044920f, 
    -0.31340900f, 0.06085406f, 0.16388874f, -0.32560322f, 0.15254685f, -0.06556532f, 0.31436348f, -0.29517075f, 
    -0.03652742f, 0.11298358f, 0.05508109f, 0.00878443f, -0.03669018f, -0.13313049f, 0.13531396f, 0.20269908f, 
    0.17826450f, 0.07338929f, 0.06787491f, 0.19810273f, 0.36034995f, -0.02901499f, -0.14704646f, -0.37021196f, 
    0.01943771f, -0.21468294f, -0.37809753f, -0.14063336f, -0.61420107f, 0.16252446f, 0.02310880f, -0.16476995f, 
    0.08037685f, -0.07718084f, -0.07457140f, -0.38450298f, -0.13489915f, -0.11673805f, 0.16460934f, -0.05874258f, 
    -0.00261757f, 0.03291140f, 0.08277641f, -0.05134621f, 0.07322542f, -0.06760442f, -0.50223839f, -0.23736419f, 
    0.00237533f, 0.06138258f, 0.40348291f, -0.38479155f, -0.26156527f, -0.14443862f, -0.04879058f, 0.06745308f, 
    0.10916208f, 0.49648169f, 0.11699198f, -0.42526460f, -0.01315886f, 0.11673301f, -0.14853834f, 0.00360751f, 
    0.24234708f, -0.02009000f, 0.17507115f, -0.44109386f, -0.15504353f, -0.08434066f, -0.19322631f, 0.29235598f, 
    -0.16680963f, 0.00247080f, -0.07644256f, -0.11529161f, 0.00885054f, -0.13403246f, -0.06985661f, 0.23207067f, 
    0.08420236f, 0.15032065f, -0.12567173f, -0.54485470f, 0.36645588f, -0.08548985f, -0.15653154f, 0.18195499f, 
    0.01934414f, -0.40516940f, -0.19976434f, -0.28351536f, -0.02184515f, 0.08535663f, -0.05498626f, -0.00147104f, 
    0.43599766f, 0.01159575f, -0.08415876f, -0.11725112f, -0.05092423f, 0.07446865f, 0.06541190f, -0.45236513f, 
    0.09287517f, 0.12441774f, 0.03527116f, 0.14792699f, -0.23982260f, -0.03967528f, 0.00587949f, -0.76113319f, 
    -0.13420619f, 0.11171018f, -0.44630665f, 0.21048228f, -0.13919178f, -0.07957283f, -0.13282736f, 0.04999280f, 
    -0.05190491f, -0.24854408f, 0.27978465f, -0.40675241f, -0.47204578f, 0.14099424f, -0.17308049f, 0.05725881f, 
    -0.02428186f, 0.07241882f, -0.06203656f, 0.03165958f, -0.02996987f, 0.16258730f, 0.11366734f, -0.16230205f, 
    0.00580010f, 0.04288650f, -0.13244063f, -0.11846437f, -0.56394643f, -0.09734827f, -0.03448526f, 0.47163156f, 
    -0.16792420f, -0.00666393f, -0.44947600f, 0.24049076f, -0.26708841f, -0.16263153f, -0.16353349f, 0.31571272f, 
    0.14451711f, 0.42158756f, -0.20761515f, -0.19738182f, -0.24925555f, 0.04683042f, -0.02308518f, -0.07169954f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16806039f, -0.01000460f, 0.01461732f, 0.06666751f, -0.13296515f, 0.10203744f, 0.06308725f, 0.03279281f, 
    -0.04740023f, 0.01854894f, 0.29021689f, -0.03717104f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
