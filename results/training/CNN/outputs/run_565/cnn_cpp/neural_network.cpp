#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04396841f, 0.79502654f, 0.79751891f, 0.14480719f, -0.27235034f, -0.84672278f, 0.31170371f, -0.44482279f, 
    -0.38521659f, 0.02699267f, 0.45484361f, 0.25473022f, -0.13305411f, 0.14108483f, 0.10779249f, 0.35759681f, 
    0.06359751f, -0.21862510f, 0.13081753f, 0.22774462f, 0.16067646f, 0.19907770f, 0.51164550f, -0.07453674f, 
    0.44594154f, -1.02647781f, -0.23478723f, -0.62441105f, -0.78943342f, -0.48589215f, -0.56459874f, -0.29342210f, 
    0.12816383f, 0.33070534f, -0.44350502f, 0.41013110f, 0.16738687f, -0.09554342f, 0.23855354f, 0.07044385f, 
    0.57279736f, -0.06033743f, 0.20237796f, 0.10977358f, -0.03587350f, 0.22043362f, 0.18809439f, 0.21405050f, 
    -0.18464413f, 0.07929607f, -0.30310419f, 0.16886616f, -0.67813659f, -0.61658764f, -0.21545780f, 0.09738541f, 
    -0.27822369f, 0.21637151f, 0.21019135f, -0.75064951f, -0.65854245f, 0.27983060f, -0.28037375f, -0.28617501f, 
    -0.62124872f, -0.04377910f, 0.42609507f, -0.41430920f, -0.42997757f, -0.48890629f, 0.36548290f, 0.37338927f, 
    0.02310953f, 0.36354604f, 0.22407849f, -0.39826840f, -0.61034924f, -1.22051251f, -1.01448822f, -0.09910399f, 
    0.48604548f, -0.50283515f, 0.58383077f, 0.49780762f, 0.24764752f, -0.54567260f, 0.00703248f, 0.29103318f, 
    0.09071840f, -0.71755648f, 0.04845669f, -0.01592533f, 0.30185792f, 0.08141284f, 0.20915940f, -0.18247277f, 
    -0.12461628f, -0.37846741f, 0.20117103f, -0.08238817f, -0.62680060f, 0.89118403f, 0.00786138f, -0.49079722f, 
    0.55814922f, -0.74811679f, 0.24536245f, -0.56146437f, -1.05320573f, -0.24256641f, -0.01652092f, 0.41829771f, 
    0.24216019f, 0.22423856f, 0.23843056f, 0.09050442f, -0.23221521f, 0.15478235f, -0.08441664f, -0.35916245f, 
    0.28252003f, 0.24078566f, 0.07122049f, 0.31120461f, 0.06648760f, 0.42237699f, 1.12828887f, -0.93373114f, 
    -0.37735829f, -0.79455477f, 1.01208246f, -0.22016643f, -0.17644854f, -0.52558529f, -0.17313913f, 0.58806926f, 
    0.04119727f, 0.26587749f, 0.13511972f, -0.13445739f, -0.08226608f, -0.05432646f, -0.15707865f, -0.00155393f, 
    -0.11734794f, 0.09942006f, 0.30902213f, 0.02897473f, -0.14392343f, 0.05750049f, 0.54804653f, 0.80390197f, 
    0.88588959f, 0.53318810f, 0.46788085f, 0.54081064f, 0.33215436f, -0.21461321f, 0.59774977f, -0.32964748f, 
    -0.15184148f, 0.14757313f, 0.11601000f, 0.18421224f, 0.11852349f, 0.25473487f, 0.11982870f, -0.12976398f, 
    0.14842582f, 0.64536059f, -0.35153550f, -0.06380074f, 0.10338507f, -0.22487600f, 0.10257258f, -0.92781943f, 
    -1.39267802f, -0.50660443f, 0.55144078f, 0.31232598f, 0.76827085f, 1.24063432f, 0.39462721f, 0.22215235f, 
    -0.06579511f, -0.21352215f, 0.06939879f, 0.20718804f, 0.35820451f, -0.09091253f, -0.23404445f, 0.01349015f, 
    -0.18527691f, -0.24193752f, -0.17643005f, -0.11101885f, -0.02105561f, 0.07973364f, -0.10303391f, -0.12856348f, 
    1.10591412f, 0.30441824f, 0.22982529f, 0.47711983f, 0.92925227f, 0.38303727f, -0.02849165f, -0.82144153f, 
    -0.34288272f, -0.26929337f, 0.35827753f, 0.20720260f, -0.52087700f, -0.06580851f, 0.07031412f, 0.20368178f, 
    -0.32929194f, 0.10282089f, 0.12680133f, -0.08772758f, -0.18187882f, 0.11889248f, 0.10979469f, 0.17299798f, 
    0.04838774f, -0.52096891f, 0.21920624f, 1.00791252f, 0.30062625f, 0.09132452f, 0.33960950f, 0.82155263f, 
    0.04335501f, -0.17574899f, -0.01572873f, -0.13113424f, 0.20132233f, 0.29344991f, -0.51671642f, -0.67790711f, 
    -0.21510199f, -0.19845776f, 0.11647427f, 0.17524594f, -0.53568023f, 0.10665569f, 0.30841446f, -0.08624104f, 
    0.41254219f, -0.32101259f, -0.57025301f, -1.23047900f, -0.20185979f, 0.25012955f, -0.00938972f, 0.13547438f, 
    -0.57962316f, -0.21084335f, -0.00848155f, -0.09988634f, -0.28973809f, -0.06220850f, 0.17136836f, 0.33890805f, 
    0.40260851f, 0.49923602f, 0.15964304f, 0.05059975f, -0.00809679f, -0.37163568f, 0.24670094f, -0.04197696f, 
    -0.03568913f, -0.03250165f, 0.15712485f, 0.92029744f, 0.80743325f, 0.65331447f, -0.05463032f, 0.00024746f, 
    -0.89675367f, -0.50295681f, -0.08536931f, -0.08921400f, -0.22390880f, -0.10508499f, -0.11434920f, -0.37018707f, 
    -0.33440313f, -0.14118144f, -0.31260362f, -0.33248752f, 0.37311301f, -0.43093812f, -0.26168525f, 0.39189851f, 
    0.28891417f, -0.20518553f, 0.03901510f, -0.03464321f, -0.22225267f, -0.86295408f, -0.03776878f, 1.11911762f, 
    0.67563087f, -1.08971453f, 0.21372180f, -0.35789993f, -0.72826374f, 0.26668176f, 0.46543482f, 0.26704454f, 
    0.25102583f, 0.13395314f, 0.17798822f, 0.09215901f, 0.42341638f, 0.23622826f, 0.32188293f, 0.08047830f, 
    0.01691217f, -0.19611800f, -0.28705886f, -0.13407077f, -0.01255920f, 1.19245112f, 0.84694397f, 0.46904585f, 
    -0.23423392f, 0.85703421f, 0.37122864f, -0.43099955f, -0.05566764f, -0.45017532f, 0.16037020f, -0.14085853f, 
    0.27502897f, 0.13137521f, 0.55329275f, -0.11215574f, -0.04873953f, 0.24834700f, 0.17645398f, 0.30157477f, 
    0.13483459f, 0.00670322f, 0.02999134f, -0.27190992f, -0.31457675f, 0.11437445f, 0.44925445f, -0.72315729f, 
    0.47186059f, 0.00896632f, 0.43267128f, -1.03651369f, -0.97941393f, -0.67696846f, -0.57656485f, -0.11107394f, 
    -0.14566620f, 0.16509110f, -0.19498126f, 0.07629101f, -0.00242376f, -0.32703248f, -0.43721485f, -0.38925627f, 
    -0.08998915f, 0.07876805f, -0.19887578f, 0.08840726f, -0.00069254f, -0.16763818f, 0.08288831f, 1.27070689f, 
    0.36350885f, -0.11316910f, 1.18036056f, 0.82551932f, 0.65564287f, 0.43750739f, -0.36099789f, 0.42032158f, 
    0.46544379f, -0.57042491f, -0.04881645f, -0.28752270f, 0.08377682f, -0.26819143f, -0.17793073f, 0.07304087f, 
    -0.19657274f, -0.29945683f, -0.21823379f, 0.26330197f, 0.14039300f, 0.05023199f, 0.14340359f, 0.19033660f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25111926f, 0.21207999f, 0.20444140f, 0.07872666f, 0.18972519f, 0.04558080f, 0.39385208f, 0.20410714f, 
    0.10500544f, -0.05195269f, 0.21913658f, 0.29566568f, 0.12000042f, -0.04135707f, 0.23302393f, 0.13654850f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21600580f, 0.05212295f, 0.06526712f, -0.07749739f, -0.16178922f, -0.04709931f, 0.07466982f, -0.08487523f, 
    0.12426493f, 0.18544446f, 0.01729559f, 0.11611145f, 0.31370384f, 0.11000969f, -0.02030477f, -0.20936809f, 
    0.32908738f, -0.00249532f, -0.04553650f, 0.07976311f, 0.15279227f, 0.12422194f, -0.09629245f, 0.13829570f, 
    -0.07943341f, -0.05042177f, -0.19919218f, -0.41004276f, 0.09810346f, 0.13510814f, 0.03518164f, 0.08530722f, 
    0.14756961f, -0.18982261f, 0.07327447f, 0.03117563f, -0.32903254f, -0.23843154f, 0.06322717f, 0.13833280f, 
    0.06550733f, 0.08445101f, -0.10578056f, 0.06563457f, 0.14740759f, -0.09891240f, 0.10865160f, -0.04454768f, 
    -0.39909530f, 0.23386264f, -0.10382026f, -0.08307321f, -0.13970082f, 0.08103592f, 0.18271792f, -0.10324775f, 
    -0.04089729f, -0.14632733f, 0.06881078f, 0.03515944f, 0.16146722f, 0.17947148f, -0.38539389f, -0.17865653f, 
    0.01708997f, 0.09397478f, -0.01553625f, -0.13495998f, -0.00946047f, -0.06553610f, 0.09586804f, -0.02385262f, 
    0.02181403f, 0.08831945f, 0.08929377f, 0.26099840f, 0.19536856f, 0.11542463f, -0.08002880f, -0.07413354f, 
    0.07370982f, 0.08644508f, 0.00924964f, -0.02058750f, -0.74291599f, 0.25634375f, -0.07474636f, -0.08216454f, 
    0.06012134f, 0.14608246f, 0.05856021f, 0.01559887f, 0.09056103f, 0.03893197f, -0.13958775f, -0.09073236f, 
    0.20709601f, -0.09365378f, 0.45315140f, 0.06969783f, 0.01507321f, -0.00846395f, -0.00580118f, 0.01087842f, 
    0.03874344f, -0.16100290f, 0.00871687f, 0.14660904f, -0.03801419f, 0.38111046f, 0.04223623f, 0.10051996f, 
    -0.15422884f, -0.14382398f, -0.15362372f, 0.27855328f, -0.02463049f, -0.00910528f, 0.06126222f, -0.12533103f, 
    -0.38541853f, 0.01153671f, 0.10675252f, 0.00786662f, 0.07816392f, -0.04480454f, -0.04006712f, 0.11359686f, 
    0.00948537f, 0.09542503f, 0.09400910f, 0.03560825f, -0.10784069f, 0.10091309f, 0.31006160f, 0.04983359f, 
    -0.01595729f, 0.08547337f, -0.12516719f, -0.00251261f, 0.34921601f, 0.04603883f, 0.00317873f, 0.04884691f, 
    -0.04434370f, -0.06289127f, -0.18271370f, 0.12184424f, -0.04406840f, -0.11841694f, -0.03012777f, -0.00175940f, 
    0.14643338f, -0.02094431f, 0.11341815f, 0.16726691f, -0.01105036f, -0.10693999f, 0.45226023f, 0.04186818f, 
    -0.03355308f, -0.00954900f, -0.21429500f, -0.05383252f, 0.21524955f, 0.04704850f, 0.15275390f, -0.00016304f, 
    -0.18755674f, -0.22755246f, 0.34536800f, -0.10037894f, 0.08374529f, -0.14181229f, -0.07618929f, -0.03128684f, 
    0.11526421f, -0.04468084f, 0.12607907f, 0.04402291f, 0.86022997f, -0.14105621f, 0.20958838f, 0.37952131f, 
    -0.16025005f, 0.01852535f, -0.05649520f, 0.08745370f, 0.07363549f, 0.07334756f, 0.01520429f, 0.05341049f, 
    0.02319371f, 0.00836037f, 0.02434373f, -0.02590182f, -0.03595113f, -0.07221972f, 0.02705574f, 0.00544047f, 
    0.05425080f, 0.03481667f, -0.07892604f, -0.04323224f, 0.04449621f, -0.06202397f, -0.01386358f, -0.06522644f, 
    0.00206084f, -0.02193957f, 0.01834250f, -0.00806058f, 0.00366973f, 0.06135210f, -0.03328281f, -0.03094484f, 
    -0.05185444f, -0.08371000f, 0.05014551f, -0.03291027f, -0.01081173f, 0.01892551f, -0.00420384f, -0.02910679f, 
    0.05363337f, -0.06654522f, -0.01751565f, -0.04877936f, 0.00530876f, -0.06329386f, -0.00809365f, 0.04436579f, 
    -0.00636423f, -0.05646106f, 0.02862235f, -0.07227948f, 0.00689269f, 0.04490104f, -0.04457189f, -0.03065062f, 
    0.03961989f, 0.01993465f, 0.00255034f, -0.00024377f, 0.03470707f, 0.05523685f, 0.00694714f, -0.04922021f, 
    -0.04926185f, 0.04411122f, -0.03933832f, -0.04029527f, 0.00486679f, 0.01031845f, -0.07769075f, 0.01085890f, 
    -0.01386141f, 0.00788655f, 0.04870114f, -0.07733849f, -0.01861834f, 0.01468974f, 0.01065835f, -0.02471707f, 
    0.05505757f, 0.05558770f, 0.04229309f, -0.02320327f, 0.00270726f, -0.06506173f, -0.06487153f, -0.04547380f, 
    0.04790928f, -0.04301286f, 0.05596701f, 0.06241604f, 0.06301567f, -0.03507487f, 0.01161852f, -0.03710734f, 
    0.04779736f, 0.01132953f, -0.04124841f, -0.04159849f, -0.02645828f, -0.02943195f, -0.00427172f, 0.04667333f, 
    -0.02752922f, -0.04113168f, -0.05484753f, -0.06405044f, 0.05246823f, -0.07369960f, 0.05210186f, 0.05254117f, 
    0.02350548f, -0.04518483f, -0.04084801f, 0.00950788f, -0.03537330f, -0.01184762f, -0.03751868f, 0.01422559f, 
    -0.04688837f, -0.01499610f, -0.00230626f, 0.01474151f, 0.05532295f, -0.01174074f, 0.05629942f, 0.05476928f, 
    -0.01277960f, -0.04791404f, 0.01764026f, -0.06127265f, 0.02294354f, -0.05071750f, 0.04704027f, -0.05346532f, 
    -0.06701533f, -0.00490041f, 0.02011957f, 0.00790380f, -0.04213005f, 0.03454279f, -0.03932387f, 0.03204948f, 
    -0.00103808f, -0.00646557f, -0.06205634f, -0.02895057f, 0.02726266f, -0.02524224f, -0.06916716f, 0.05704347f, 
    -0.06739774f, 0.04735603f, -0.03974317f, -0.06396917f, -0.05879532f, 0.01754441f, 0.05844958f, -0.00615623f, 
    -0.02343770f, 0.05641397f, -0.01808035f, -0.06854299f, 0.01208104f, -0.01250596f, -0.05125679f, -0.07286350f, 
    -0.02220400f, -0.06936667f, -0.03508008f, -0.03724306f, 0.02127167f, -0.08748961f, 0.02967108f, 0.03902365f, 
    -0.03334149f, -0.06762294f, -0.04956951f, -0.02962326f, -0.07892785f, -0.07892822f, 0.02689784f, 0.00065309f, 
    0.06093658f, -0.06044363f, 0.05244335f, -0.03775517f, -0.02992733f, 0.04606270f, 0.01290962f, 0.04191573f, 
    0.03612239f, -0.01026643f, -0.01550378f, 0.02035702f, 0.05535428f, -0.06058241f, 0.02308424f, 0.05618701f, 
    -0.25895995f, 0.11233161f, 0.08067732f, 0.05309902f, -0.03836719f, -0.10113816f, 0.01461420f, -0.06461959f, 
    -0.03359947f, 0.01162883f, -0.04513521f, -0.24564841f, -0.14397609f, 0.16155373f, -0.03873881f, 0.11518347f, 
    -0.07281061f, 0.05665137f, 0.05039738f, 0.04011872f, 0.12686516f, -0.12784410f, 0.01957392f, 0.01879729f, 
    0.24019799f, -0.12067774f, 0.07172687f, 0.04384384f, -0.02506350f, 0.07800347f, 0.14497752f, -0.00734761f, 
    -0.17945994f, 0.13840726f, -0.07918226f, -0.05652655f, 0.20003080f, -0.44776535f, -0.19895832f, -0.53567165f, 
    0.03119131f, 0.05855855f, 0.16276278f, 0.01864496f, 0.17742203f, 0.15929481f, 0.07002494f, 0.20078585f, 
    -0.34587863f, 0.20314604f, 0.50872087f, 0.01779117f, -0.09654482f, -0.04333565f, -0.10448620f, -0.04198123f, 
    0.07280391f, 0.06826910f, -0.11026378f, 0.14408132f, 0.28680050f, -0.03530881f, -0.05666196f, 0.21343763f, 
    -0.04599354f, 0.12081751f, -0.04761805f, 0.17182802f, -0.08493721f, 0.18637682f, -0.14469758f, 0.06763202f, 
    0.20233634f, 0.11175881f, 0.02073578f, 0.16870992f, -0.08833338f, -0.13850415f, -0.08372302f, 0.08743787f, 
    0.02006474f, 0.04645861f, 0.14915267f, -0.10642388f, -0.35212541f, -0.06151229f, -0.40773878f, -0.08883400f, 
    0.22589810f, 0.11979277f, 0.15119213f, -0.07348900f, -0.06840782f, 0.06683666f, 0.04314606f, 0.13509302f, 
    0.20656896f, -0.20562454f, 0.10659704f, 0.19564380f, -0.14051695f, 0.12692457f, -0.06696519f, 0.13031682f, 
    -0.02902443f, -0.07737996f, 0.01557173f, 0.00531401f, -0.45827907f, 0.13820891f, 0.19298750f, 0.40262461f, 
    0.14354096f, -0.05826018f, 0.11644202f, 0.15717739f, 0.14778297f, 0.09121370f, -0.02850442f, -0.00089422f, 
    -0.07223804f, 0.20543943f, 0.08035035f, 0.08373024f, -0.12250377f, 0.17405534f, 0.04634509f, -0.14009938f, 
    0.15027848f, 0.03717136f, -0.15908332f, -0.02508602f, 0.53879267f, 0.12667377f, -0.27587256f, 0.07643548f, 
    0.08998964f, 0.06234467f, 0.16064546f, 0.07567785f, -0.11850357f, 0.01632842f, 0.00581045f, -0.05077589f, 
    -0.58561456f, 0.08595558f, 0.13616277f, -0.11915048f, -0.05737987f, -0.11357237f, 0.17557453f, -0.07303696f, 
    0.13363267f, -0.01416228f, 0.05994021f, -0.15541355f, 0.58245397f, 0.23579003f, 0.15030614f, 0.17888705f, 
    -0.14621258f, 0.10309943f, -0.06533252f, -0.03053086f, 0.06749455f, -0.11535854f, -0.12859960f, -0.06720787f, 
    0.16411288f, -0.09422624f, 0.12324211f, 0.25017524f, -0.02519127f, 0.07949637f, 0.09786040f, 0.04693761f, 
    -0.20752300f, 0.02052367f, 0.12964867f, 0.06601474f, 0.10727861f, -0.03765316f, 0.08148792f, 0.26071230f, 
    -0.26455203f, 0.00752621f, 0.01555514f, -0.03879647f, -0.04291612f, -0.12933046f, 0.00547956f, 0.15164340f, 
    -0.34020102f, -0.04711353f, 0.13689423f, -0.06593335f, 0.09768970f, 0.12259971f, 0.07244252f, -0.08298730f, 
    -0.12732260f, -0.04675501f, -0.11607984f, -0.26936689f, 0.42938665f, 0.20782608f, 0.11568572f, -0.12252178f, 
    0.01316172f, -0.06889220f, 0.01586348f, -0.12578470f, 0.03051558f, -0.03926755f, 0.02548873f, -0.11717621f, 
    0.45734498f, 0.07212447f, 0.07774263f, 0.01401619f, -0.15210238f, -0.03502018f, 0.10309123f, 0.01949526f, 
    -0.14955758f, 0.19330122f, 0.14968438f, -0.11466876f, -0.17532003f, 0.34446883f, -0.05773038f, 0.48143238f, 
    -0.02332313f, -0.24335630f, 0.11881652f, 0.19886094f, -0.03020746f, 0.17039141f, -0.06750366f, 0.09168904f, 
    -0.17441951f, -0.04790302f, 0.06638290f, 0.02044097f, 0.07604010f, -0.01863359f, -0.07763459f, -0.06127019f, 
    0.10015024f, 0.06276904f, 0.00015603f, 0.05809865f, 0.03487224f, -0.05137270f, -0.31158370f, 0.42379084f, 
    -0.02599979f, -0.01602378f, 0.10241856f, 0.14243403f, -0.11164538f, 0.14541973f, 0.06926328f, 0.03494566f, 
    -0.41371047f, 0.13596387f, -0.16807169f, -0.25043449f, -0.08037705f, -0.21368043f, 0.10950851f, 0.15955684f, 
    0.00285159f, -0.11615149f, -0.01181500f, -0.03013078f, 0.18358482f, -0.28565463f, 0.13064019f, 0.04864298f, 
    -0.19738129f, -0.02678287f, 0.08623510f, -0.02654458f, 0.20193633f, -0.04106825f, -0.06302793f, 0.11442537f, 
    -0.23005912f, 0.01919148f, 0.29745197f, -0.11110684f, 0.00143297f, 0.03092844f, 0.02656919f, 0.01010970f, 
    0.09403358f, -0.16069663f, 0.03375785f, 0.04586491f, 0.38393092f, 0.00415838f, -0.01355138f, -0.34236592f, 
    0.17767692f, -0.12636797f, -0.04823327f, 0.12084635f, 0.12185312f, 0.10404738f, 0.10450106f, 0.01942275f, 
    0.05732683f, -0.02354701f, 0.03311656f, -0.17782992f, -0.01690994f, -0.09699376f, -0.18571149f, 0.01727551f, 
    -0.08251230f, -0.13985699f, 0.06152575f, -0.25107259f, -0.37051865f, -0.03443153f, 0.09701315f, 0.02317669f, 
    0.15338254f, -0.03197854f, 0.13157550f, -0.03776801f, 0.13195850f, 0.04505351f, -0.10356808f, 0.18181866f, 
    0.27368981f, 0.08923692f, 0.36549950f, 0.15004364f, -0.02435702f, 0.16247366f, 0.05509471f, 0.05346226f, 
    0.01907352f, 0.04436625f, -0.15482879f, 0.04648884f, -0.34589332f, -0.09515920f, -0.16346464f, 0.18973573f, 
    0.01178254f, -0.06998969f, 0.05091246f, -0.01779056f, -0.00183082f, -0.00371291f, 0.01324877f, -0.06326938f, 
    0.10470546f, 0.05292444f, 0.09839072f, 0.24037395f, 0.16591701f, 0.16544937f, -0.04319201f, -0.11045303f, 
    0.12360917f, 0.14529699f, 0.02369079f, 0.01754887f, 0.00997095f, 0.02391256f, 0.09487218f, -0.03858312f, 
    -0.08039089f, 0.14517593f, 0.07114243f, 0.03590343f, -0.08904044f, 0.07297458f, 0.10996532f, 0.14019892f, 
    -0.05065193f, -0.01259923f, 0.00393322f, 0.01738713f, -0.03217653f, -0.00808754f, 0.02053969f, -0.04988347f, 
    0.04672125f, 0.02058612f, 0.05406167f, 0.00658194f, -0.05527274f, -0.03288000f, -0.00690314f, 0.04057898f, 
    -0.04903804f, -0.11020929f, -0.00290457f, 0.03481143f, 0.03421026f, 0.02938312f, 0.00423242f, -0.07436205f, 
    -0.06456876f, -0.09473782f, -0.09379747f, -0.04984836f, -0.01964917f, 0.01635808f, 0.06465543f, 0.01368941f, 
    -0.08198516f, 0.00369801f, -0.02177831f, 0.04536362f, -0.03755934f, -0.09511682f, -0.01754311f, 0.00316917f, 
    -0.03133002f, -0.08915629f, 0.01445537f, -0.02440999f, -0.10427477f, 0.07117806f, -0.08372551f, -0.01291178f, 
    -0.03498181f, -0.04652860f, -0.07722974f, -0.06808235f, 0.00117705f, -0.00842561f, -0.01783918f, -0.08763585f, 
    -0.01368558f, -0.05628690f, -0.06153867f, 0.00706060f, -0.08636208f, 0.01651388f, -0.02637291f, 0.04213603f, 
    -0.06996851f, -0.01671423f, 0.03654572f, -0.03218315f, 0.06997017f, -0.01015122f, -0.10211768f, 0.06532040f, 
    -0.03684250f, 0.04476479f, 0.05959288f, -0.05951736f, 0.01407174f, -0.04704231f, -0.08355154f, 0.04587626f, 
    0.04006314f, -0.03365691f, -0.08428419f, -0.06241694f, -0.05931413f, 0.04436663f, -0.07889103f, 0.03513654f, 
    -0.04268530f, -0.03872324f, -0.02087683f, -0.00390975f, 0.00734757f, -0.05677359f, 0.02358308f, -0.07395326f, 
    -0.03749372f, -0.01662877f, -0.00181234f, -0.04941981f, 0.00425496f, -0.01938397f, 0.00635778f, -0.05419954f, 
    0.03340897f, 0.00990143f, -0.09863836f, -0.08534329f, 0.02938368f, -0.00754205f, -0.05020374f, 0.00227086f, 
    -0.03497750f, -0.09256790f, -0.07040776f, 0.02318374f, -0.07208554f, -0.06057386f, 0.00738979f, -0.05797617f, 
    0.02210324f, 0.00077105f, -0.06895158f, -0.04333765f, -0.00702280f, -0.04956093f, -0.07627098f, -0.07180356f, 
    -0.01221241f, 0.01608030f, 0.00259943f, 0.03916350f, -0.04575396f, -0.05791232f, -0.07907845f, -0.06853749f, 
    -0.07195135f, -0.05214264f, 0.00409650f, -0.04598813f, -0.06694944f, -0.11390199f, -0.00408588f, 0.05615769f, 
    -0.09151572f, 0.03503070f, -0.09239963f, 0.00715378f, 0.03625533f, 0.04039901f, -0.00651894f, -0.01412135f, 
    -0.06403685f, -0.06053285f, 0.01758623f, -0.07471446f, -0.08907634f, 0.03745453f, -0.08756462f, -0.01806229f, 
    0.00482345f, 0.03147104f, 0.00876554f, 0.00631411f, -0.04501123f, -0.08917520f, 0.02355237f, -0.01893532f, 
    -0.00220877f, 0.03252272f, -0.09733292f, 0.02240951f, 0.00119581f, 0.00523191f, -0.06814878f, -0.02070029f, 
    -0.01361981f, 0.07051644f, -0.02100253f, -0.09734041f, 0.00879887f, 0.04642182f, 0.00646351f, -0.02303335f, 
    -0.00296072f, -0.00101272f, -0.01707918f, 0.04420691f, -0.03818847f, -0.03050082f, -0.03191145f, -0.01677655f, 
    -0.06302895f, -0.03330646f, -0.03346094f, -0.07808702f, -0.07581906f, -0.02141208f, -0.03136932f, -0.03211831f, 
    -0.00450567f, -0.03841966f, -0.00648565f, -0.04117060f, -0.03588067f, -0.05102358f, 0.01003631f, -0.04681996f, 
    -0.04652723f, -0.03928510f, 0.04981683f, -0.01565178f, 0.00525723f, 0.06392194f, 0.03323311f, -0.00238215f, 
    0.05713429f, -0.06535736f, 0.04322620f, -0.07659438f, -0.00720808f, 0.01857763f, -0.04282139f, 0.05965028f, 
    0.05221551f, 0.06089874f, -0.04060500f, -0.05310630f, -0.06213483f, 0.04009642f, -0.07272505f, -0.02892724f, 
    0.03801575f, 0.04139961f, 0.01400973f, 0.03893582f, -0.04651905f, -0.04307999f, -0.05554361f, -0.02166038f, 
    0.00868554f, 0.02665451f, -0.01686714f, -0.01448714f, -0.00088566f, -0.03486628f, -0.03912505f, -0.06653628f, 
    -0.06580760f, -0.01537878f, 0.02525641f, 0.04151933f, 0.03013159f, -0.05966045f, 0.01285162f, 0.04310419f, 
    0.04261627f, -0.01078163f, -0.07577529f, -0.04545503f, -0.07437827f, -0.05830783f, -0.01767804f, -0.02819108f, 
    -0.06478022f, 0.00509445f, 0.02003915f, 0.01115318f, -0.03165147f, 0.02758027f, -0.07342974f, -0.07335742f, 
    0.02906010f, -0.00375750f, -0.04396600f, -0.06639577f, -0.03745225f, -0.00729726f, -0.01781942f, -0.04813413f, 
    0.00942452f, 0.02158491f, -0.03127753f, -0.07547005f, 0.01724562f, -0.01654473f, -0.02025004f, 0.01849991f, 
    -0.02680315f, -0.00696806f, 0.00970492f, -0.04809793f, 0.00665874f, -0.00747720f, 0.01321315f, -0.06066637f, 
    -0.03373138f, 0.03852599f, 0.02575718f, -0.06428683f, -0.06806271f, 0.01855398f, -0.01844820f, 0.01635631f, 
    0.05702830f, -0.00404547f, -0.02222598f, 0.05398628f, -0.07151996f, -0.02883330f, 0.05630890f, 0.05434008f, 
    0.00096107f, -0.02076656f, 0.04155012f, 0.05557197f, -0.01540018f, 0.06026947f, 0.02774757f, 0.01396161f, 
    -0.04083256f, -0.04364077f, -0.07209114f, -0.03243481f, -0.02780125f, -0.06429897f, 0.01502835f, -0.02431986f, 
    -0.03789335f, 0.00354962f, -0.02900581f, 0.04738253f, 0.00862854f, -0.01319069f, -0.00836636f, 0.00318511f, 
    -0.07647721f, 0.03184796f, -0.03275162f, -0.06949507f, -0.07579055f, -0.06138505f, 0.06162056f, -0.05820064f, 
    -0.04777316f, -0.01740714f, 0.01536902f, 0.02598007f, -0.01481144f, 0.05304446f, 0.03133069f, 0.01800827f, 
    -0.00860147f, -0.04142519f, 0.05341597f, -0.05511414f, -0.07051539f, -0.00232822f, 0.04865711f, -0.06687599f, 
    -0.07863103f, 0.03806749f, 0.00639189f, 0.00393988f, -0.03269016f, -0.03843123f, 0.06330051f, -0.04922503f, 
    -0.06628020f, 0.03243260f, 0.01312171f, -0.07396971f, 0.00662766f, -0.04468295f, 0.01466289f, -0.05424399f, 
    0.02621626f, -0.00286718f, 0.00976042f, 0.03813181f, -0.07891330f, 0.06248353f, -0.04570045f, -0.00085036f, 
    -0.01642330f, 0.11507654f, 0.24318475f, 0.14956522f, -0.05033467f, -0.04415354f, -0.08010653f, 0.04562281f, 
    -0.09453008f, -0.03173750f, -0.09797971f, -0.46969420f, 0.02584792f, 0.02234723f, -0.16127937f, 0.01013298f, 
    -0.05334367f, -0.16432074f, 0.01155107f, -0.26922172f, 0.00166483f, -0.05686722f, -0.08731838f, -0.24683794f, 
    0.23377526f, 0.14200786f, -0.09079343f, 0.15636635f, -0.10916336f, -0.16178899f, 0.12784290f, -0.05413502f, 
    -0.21964726f, 0.32581115f, 0.18123430f, 0.15522052f, -0.37088516f, -0.15563098f, -0.33287898f, 0.36248606f, 
    -0.19025651f, -0.19133833f, 0.10859573f, 0.22672302f, -0.07864494f, 0.01090483f, -0.08040107f, 0.14158081f, 
    -0.12246473f, 0.00927794f, 0.00023438f, 0.34606677f, -0.02047658f, -0.09873588f, 0.02357117f, 0.05661291f, 
    -0.06581525f, -0.05567580f, 0.03141973f, -0.04027547f, 0.22824533f, 0.04545788f, -0.16328207f, 0.53436315f, 
    0.09387077f, 0.11129513f, -0.08599318f, -0.02588039f, 0.03474587f, 0.17098396f, 0.10748410f, 0.05326378f, 
    0.17115347f, 0.20486972f, -0.08273059f, -0.16693848f, 0.08191870f, -0.08745993f, -0.02186418f, 0.11564887f, 
    0.06620536f, -0.15878014f, -0.06077884f, -0.16510502f, -0.24535389f, -0.52975577f, 0.03274313f, 0.09345967f, 
    0.01088927f, -0.16114064f, 0.08322618f, 0.06559142f, 0.12368584f, 0.15491331f, 0.15629709f, 0.35703510f, 
    0.06225742f, 0.26011777f, -0.03094738f, -0.09964768f, 0.29437298f, 0.14285737f, 0.06260089f, -0.10249531f, 
    -0.01696914f, -0.00675933f, 0.24311769f, 0.13741229f, 0.21037008f, -0.12492749f, -0.07517967f, -0.35180798f, 
    0.27251196f, 0.07752860f, 0.07744078f, 0.26810697f, 0.26784110f, 0.18499064f, -0.04690470f, 0.18391322f, 
    0.43574536f, -0.07242438f, -0.12437432f, -0.23835348f, 0.09043188f, -0.02803891f, -0.02817465f, -0.18907744f, 
    -0.00043108f, -0.09940451f, 0.01628828f, -0.33097327f, 0.06981347f, 0.12644918f, 0.25924957f, 0.02180400f, 
    0.04469852f, 0.03925887f, 0.04571007f, -0.02803150f, 0.02528668f, 0.12711811f, 0.04169138f, -0.02722123f, 
    -0.49351662f, 0.37470907f, 0.30384278f, 0.00395081f, 0.27524638f, 0.05128087f, 0.16025643f, 0.04702072f, 
    -0.02927468f, 0.01126418f, -0.12854372f, -0.15955073f, -0.07496203f, 0.12169841f, -0.38194358f, 0.53656757f, 
    0.06773009f, 0.14963187f, 0.05966715f, -0.10778269f, 0.13886382f, 0.02554644f, -0.04996973f, -0.17406069f, 
    -0.00284387f, 0.24869989f, -0.05843244f, 0.01107710f, 0.04777164f, -0.00441577f, 0.06341112f, -0.15149544f, 
    0.30137581f, 0.04953361f, 0.15151039f, 0.23342128f, -0.20216556f, 0.08397748f, -0.07610142f, -0.35348475f, 
    0.20020738f, 0.01250152f, 0.15841196f, -0.08609988f, 0.04775066f, 0.12180825f, 0.21323571f, 0.25337794f, 
    0.37628791f, -0.24874835f, -0.20939656f, 0.09204934f, -0.06596656f, -0.16915989f, -0.00162866f, 0.00508546f, 
    -0.11109618f, 0.04723097f, -0.00271949f, 0.05753503f, 0.01264967f, -0.10049075f, -0.09185338f, 0.19842079f, 
    -0.01712686f, -0.00651836f, 0.01188487f, -0.03138909f, 0.02328106f, 0.01032092f, -0.11741824f, -0.02330194f, 
    0.15573682f, -0.03085586f, -0.03081087f, 0.18668424f, 0.20068406f, 0.03522898f, 0.16479842f, 0.08803454f, 
    0.16056392f, -0.15728575f, -0.21734102f, 0.10331173f, -0.03159716f, 0.31333542f, 0.19078994f, 0.67732984f, 
    0.04019808f, -0.00854810f, -0.15732709f, -0.06504866f, -0.05252063f, -0.09398226f, -0.03908722f, -0.15571840f, 
    0.04581209f, -0.27499670f, 0.12224285f, 0.46209335f, 0.09124152f, -0.19284500f, -0.07335880f, 0.07577078f, 
    -0.04357601f, -0.04912709f, 0.08319430f, 0.08760276f, -0.18624756f, 0.48391089f, 0.21826370f, -0.16734572f, 
    0.02065230f, -0.05246266f, -0.01839256f, -0.18212044f, 0.10068535f, -0.18800232f, 0.31197232f, 0.09060912f, 
    0.34937224f, 0.16535547f, -0.15131187f, 0.08713954f, 0.29124388f, 0.28299567f, 0.00377065f, -0.01699116f, 
    -0.07345242f, -0.11278372f, -0.04660714f, 0.11717212f, -0.52411777f, 0.05288693f, 0.45663941f, 0.03010104f, 
    -0.04363104f, -0.06578662f, -0.08811290f, 0.04976016f, -0.03344883f, 0.16470364f, -0.03516129f, -0.07680569f, 
    -0.29428419f, 0.07977165f, -0.16889672f, 0.06405364f, 0.12868747f, 0.02418550f, 0.05196504f, -0.11853128f, 
    -0.11092977f, -0.10033656f, -0.02228536f, 0.18352631f, 0.10429198f, -0.10030115f, -0.00977744f, -0.04524978f, 
    0.08443546f, -0.02442065f, -0.04262502f, -0.01559548f, 0.00637417f, -0.04363563f, -0.24974158f, -0.06890859f, 
    -0.21153890f, -0.11907452f, 0.10722840f, -0.27616879f, 0.02296787f, 0.03233263f, -0.03152514f, 0.11481895f, 
    0.09140874f, 0.32148585f, 0.04498025f, 0.04843710f, -0.03825564f, -0.41791785f, -0.05124867f, -0.03183741f, 
    0.16081086f, 0.01316882f, 0.06504007f, 0.04989979f, 0.02218694f, -0.01465304f, 0.11487956f, -0.10807028f, 
    0.01704697f, -0.24102493f, 0.06661886f, -0.15572460f, 0.21725208f, -0.23395897f, 0.17646855f, 0.12988575f, 
    0.12832628f, 0.07422734f, 0.08439256f, 0.01120641f, -0.18622544f, 0.08352893f, -0.21381564f, 0.07836770f, 
    0.00448905f, 0.10219827f, 0.04277549f, -0.05794071f, -0.13772303f, 0.09699417f, 0.18005919f, 0.07253521f, 
    -0.50777626f, -0.28305310f, -0.50937080f, 0.04399513f, 0.01420309f, -0.11775108f, -0.03657581f, -0.24150178f, 
    0.22686864f, 0.01015068f, 0.14020282f, -0.01557557f, 0.06403375f, 0.25494230f, -0.10610867f, -0.03924218f, 
    0.21859561f, 0.08807697f, 0.04818088f, -0.02538863f, 0.12266960f, 0.07868196f, 0.00338385f, -0.03767505f, 
    -0.26276666f, 0.12176923f, -0.10399984f, -0.22482985f, 0.09912922f, 0.09874043f, 0.11002673f, -0.06459022f, 
    0.13981695f, 0.09994715f, -0.16056705f, -0.08193021f, 0.00340671f, 0.16545284f, 0.15404166f, -0.25300705f, 
    0.11793217f, 0.07237561f, -0.10940000f, 0.05886963f, 0.07622609f, 0.10587064f, 0.06677807f, 0.09535982f, 
    0.05522458f, -0.07943510f, -0.07454085f, -0.26644590f, -0.07509606f, -0.16237959f, 0.04509890f, -0.00128099f, 
    0.00608144f, 0.10922167f, -0.06682663f, -0.17487222f, -0.41067898f, -0.09139214f, 0.05028760f, -0.23785727f, 
    -0.09371374f, -0.10034690f, 0.16329421f, 0.12695244f, 0.04456313f, 0.05544711f, 0.12272761f, 0.00495498f, 
    -0.32648221f, 0.28160897f, -0.08921129f, -0.46310267f, 0.05461374f, 0.16016653f, -0.00580746f, -0.19048870f, 
    0.09698512f, 0.06865222f, -0.10861651f, -0.01025233f, 0.42893246f, 0.23334329f, -0.38938084f, 0.10976824f, 
    -0.06766500f, -0.12865838f, 0.00463625f, 0.16313529f, 0.00787882f, 0.03759173f, -0.02560499f, 0.05856459f, 
    0.16267060f, 0.01491297f, 0.15173440f, 0.29606906f, -0.10584822f, -0.13429429f, 0.02019056f, -0.04008194f, 
    0.04366750f, 0.06211322f, 0.00693866f, -0.06834963f, 0.53415775f, -0.14738832f, -0.00513003f, 0.03340845f, 
    -0.10200456f, 0.16419286f, 0.11999062f, -0.13320190f, 0.09221658f, -0.03452418f, -0.15800020f, 0.00910354f, 
    0.09724418f, -0.03891605f, 0.29323894f, -0.06638690f, 0.12200444f, -0.01482540f, 0.03272580f, 0.09004334f, 
    0.10158552f, -0.03318397f, 0.01195571f, 0.05859162f, 0.28040016f, -0.07622822f, 0.03713969f, 0.21312779f, 
    -0.06518570f, -0.07819638f, -0.04356509f, 0.09994612f, 0.01169584f, 0.03512670f, 0.17784880f, 0.02838575f, 
    -0.07905363f, 0.19069131f, 0.10401068f, -0.19409420f, -0.01781616f, 0.00676840f, -0.10929566f, -0.00313432f, 
    -0.02314998f, -0.07380984f, 0.01469793f, -0.09328410f, -0.43494651f, 0.03968940f, -0.07616439f, 0.05027089f, 
    0.20049518f, 0.13596240f, 0.20445864f, 0.12817878f, 0.02082074f, -0.10390153f, -0.08690725f, 0.23893218f, 
    0.41853055f, -0.03909406f, -0.10033754f, 0.06914714f, -0.08315969f, 0.13319734f, 0.07528135f, 0.03621310f, 
    0.01416322f, -0.05975238f, -0.04448950f, 0.11054726f, 0.08155375f, -0.09467784f, 0.26747915f, 0.12033139f, 
    -0.14546156f, -0.01580219f, -0.10776694f, 0.06965899f, 0.11516304f, -0.07500496f, 0.14205597f, -0.13712889f, 
    0.10400557f, 0.11883255f, 0.06676110f, -0.21505837f, 0.11652637f, 0.05252364f, -0.06295420f, 0.12640603f, 
    -0.00200328f, 0.14321150f, -0.00619485f, -0.00477591f, 0.37087166f, -0.10687088f, 0.33224070f, 0.34510159f, 
    -0.18501070f, -0.03977150f, -0.11000016f, 0.02341191f, 0.01644905f, -0.09837073f, 0.07123765f, 0.02775515f, 
    -0.03760924f, -0.03692152f, 0.01311143f, -0.03676665f, -0.04021445f, -0.04340418f, 0.02381720f, 0.06483487f, 
    0.03670908f, 0.06080761f, -0.02874265f, -0.02473629f, -0.03866066f, -0.07368481f, -0.05556292f, -0.07695318f, 
    0.00480840f, 0.05949333f, -0.03701523f, -0.00079825f, -0.07650752f, -0.07480700f, 0.06037936f, -0.07662270f, 
    0.06029947f, 0.04957897f, -0.01188630f, -0.03184410f, -0.05398893f, -0.00357259f, 0.01964749f, 0.00061876f, 
    -0.06231949f, 0.00910200f, 0.03904619f, 0.02313889f, 0.02454979f, 0.03872845f, -0.08086058f, 0.03703294f, 
    -0.00959277f, -0.02470082f, -0.00720555f, 0.01745210f, 0.00338624f, -0.06878536f, -0.07621377f, -0.07283100f, 
    0.03763128f, -0.07105117f, -0.07428005f, 0.03958274f, -0.04347674f, 0.00203046f, -0.02533515f, 0.01563442f, 
    -0.00527109f, -0.01516115f, 0.06123794f, 0.01818345f, -0.03734168f, -0.03509881f, 0.01510730f, 0.06409045f, 
    -0.07890153f, -0.02388017f, 0.02508605f, 0.01143897f, -0.00261842f, -0.03371423f, -0.00990473f, 0.01257057f, 
    -0.04986769f, -0.07432469f, -0.06654113f, 0.00011882f, 0.03472314f, 0.03200551f, 0.03174905f, 0.05734874f, 
    -0.05110140f, 0.05338405f, -0.06046687f, -0.03415443f, -0.02315666f, 0.05883600f, 0.02419434f, 0.06378087f, 
    0.01738127f, -0.05037629f, -0.01735292f, -0.01188652f, 0.02188777f, 0.04004542f, -0.05035633f, -0.00814273f, 
    0.00640978f, 0.05083619f, -0.05831194f, 0.03707480f, 0.04875704f, 0.05296459f, -0.02670438f, -0.03748973f, 
    -0.07723524f, -0.05517510f, 0.01549702f, 0.02310910f, 0.04108961f, -0.00177710f, -0.01825750f, -0.03414679f, 
    -0.06236374f, -0.06929559f, 0.03357010f, -0.05474652f, -0.00994744f, 0.04767595f, 0.05811976f, 0.04281687f, 
    -0.08330256f, -0.07200878f, -0.03025734f, -0.05237526f, -0.06666997f, 0.04948896f, 0.05106563f, 0.04787746f, 
    -0.02547253f, 0.03881401f, 0.04672314f, 0.01934192f, 0.04666841f, 0.01274256f, -0.06656218f, 0.02830704f, 
    -0.07119545f, 0.03658715f, -0.01233937f, 0.04125416f, -0.07162963f, -0.04410185f, -0.05317118f, 0.03577487f, 
    0.01634472f, -0.02885527f, -0.06418681f, 0.00137569f, -0.01690363f, 0.03514425f, -0.07269574f, 0.03143710f, 
    0.03068871f, -0.06044142f, -0.02147209f, 0.00817958f, -0.01791118f, -0.00091552f, 0.01314183f, -0.05265918f, 
    -0.03767553f, 0.03867451f, 0.02325747f, -0.06631035f, -0.02919267f, -0.00950279f, -0.04245357f, -0.05722806f, 
    0.05646382f, 0.01208028f, -0.02886627f, 0.00917144f, 0.01728267f, -0.05737476f, -0.07144112f, 0.03207323f, 
    0.02318661f, 0.04471229f, -0.07021133f, 0.02076720f, -0.06253748f, -0.01548280f, -0.00996114f, 0.04443178f, 
    -0.07198375f, 0.02433899f, -0.07376053f, -0.00925245f, -0.02237334f, 0.05429544f, -0.06921688f, 0.02228170f, 
    -0.50394410f, -0.22656457f, -0.00039040f, -0.18486956f, -0.16552718f, -0.02411640f, 0.07781432f, -0.15644181f, 
    -0.04940417f, -0.09367884f, -0.13977480f, -0.23121667f, 0.61672503f, 0.32464314f, 0.22156030f, 0.33701822f, 
    0.03818858f, -0.03285443f, 0.18608502f, 0.01410394f, 0.04544481f, 0.03284839f, -0.04128991f, -0.07982787f, 
    0.33910337f, -0.00362892f, 0.08442082f, 0.30752775f, 0.00355231f, -0.05624587f, -0.04486578f, 0.07688507f, 
    -0.11245570f, -0.03164461f, 0.00600453f, 0.09651262f, 0.28801888f, 0.20825295f, 0.02948251f, 0.32872796f, 
    0.00554159f, -0.01770571f, 0.19869111f, 0.18947549f, -0.13156849f, 0.17661940f, 0.20036121f, 0.01103934f, 
    -0.07355520f, -0.08699472f, 0.17430647f, -0.08704837f, -0.17831784f, -0.01789960f, -0.16903076f, -0.11368565f, 
    0.26342779f, 0.09918309f, -0.01730473f, -0.00287834f, 0.09546664f, 0.22385667f, 0.04768525f, 0.16992520f, 
    -0.16644856f, -0.06163039f, 0.10269807f, 0.12203299f, -0.11937191f, 0.10052526f, 0.00426775f, -0.09607796f, 
    0.05736960f, 0.20603520f, -0.19491519f, -0.07969932f, -0.01134753f, -0.10540925f, 0.06209526f, 0.10561791f, 
    -0.00936273f, 0.06444525f, -0.06792863f, 0.00464312f, -0.02574017f, 0.22295035f, -0.06308404f, 0.03049169f, 
    -0.00815033f, -0.02690610f, 0.01164284f, 0.21124257f, -0.07127708f, -0.00388947f, -0.17346132f, -0.16780873f, 
    -0.30276769f, -0.09817654f, -0.06906132f, 0.07985492f, -0.01853598f, -0.07111899f, -0.02663313f, 0.15004240f, 
    -0.11739998f, -0.10378385f, 0.15763554f, -0.17907506f, -0.14799151f, 0.16150455f, 0.25010520f, 0.04844495f, 
    0.12324066f, 0.13549538f, -0.00178034f, 0.28101930f, -0.01237119f, 0.01810945f, -0.10973945f, -0.00473186f, 
    0.14206798f, 0.27210408f, 0.15925521f, 0.28634477f, -0.14928575f, -0.09855395f, -0.10721663f, -0.14453124f, 
    -0.15919118f, -0.05798024f, -0.23147698f, 0.04190772f, 0.04035864f, -0.53868741f, -0.09357291f, 0.21095265f, 
    0.07053182f, -0.04837992f, 0.10965572f, -0.01540106f, -0.11599334f, 0.10086701f, -0.13449733f, -0.03551562f, 
    -0.18300618f, -0.27914062f, 0.22142357f, -0.25656161f, 0.10756471f, -0.02099811f, -0.11261541f, 0.01971351f, 
    -0.17872903f, 0.05782810f, -0.14728449f, -0.15023820f, 0.01202800f, -0.15097666f, -0.13220577f, 0.02815327f, 
    -0.02098193f, 0.10172693f, -0.01189622f, 0.05713119f, -0.11462700f, -0.22699228f, -0.13536218f, 0.01041864f, 
    0.12969053f, 0.01048689f, 0.11856338f, 0.19323769f, -0.16918811f, 0.11122781f, -0.04308433f, -0.08218023f, 
    -0.18944940f, 0.16075091f, 0.21429615f, 0.07214858f, 0.26318395f, 0.19308549f, -0.23369689f, 0.04925190f, 
    -0.02999418f, 0.00279585f, -0.07031128f, 0.02405376f, 0.00229041f, -0.13583873f, 0.01108530f, -0.06353625f, 
    0.29721394f, -0.27071750f, -0.14983410f, 0.05674573f, 0.29265761f, -0.08801158f, -0.01073277f, 0.07765793f, 
    -0.07072432f, 0.14280933f, 0.13252723f, 0.37563270f, 0.27421230f, 0.30292627f, 0.59164286f, 0.07513146f, 
    0.14318533f, 0.19092716f, 0.05532099f, -0.00446659f, -0.06264950f, -0.00088772f, -0.07282957f, -0.06929252f, 
    0.02580352f, 0.21911904f, 0.21358761f, 0.27465054f, -0.00446257f, 0.01973457f, 0.01129309f, 0.04927117f, 
    0.14632326f, -0.41444731f, -0.17637153f, 0.06171569f, 0.59393835f, 0.54778028f, 0.42764699f, 0.22186866f, 
    0.13245997f, 0.04638691f, 0.07932782f, -0.06746517f, 0.18523391f, -0.09345987f, -0.09878216f, 0.02981577f, 
    0.36634722f, -0.08624820f, -0.36144590f, 0.09071096f, -0.11167508f, -0.01391133f, -0.10603497f, 0.16347358f, 
    0.10816103f, -0.12961133f, 0.22356305f, 0.11810241f, 0.26524886f, 0.00368956f, -0.03808104f, -0.21138787f, 
    0.07991883f, -0.04546596f, -0.08195475f, -0.11671705f, 0.09465379f, 0.27614379f, 0.00691530f, -0.15564328f, 
    -0.06782984f, -0.26321468f, -0.08491075f, -0.07319493f, 0.16620319f, 0.09355048f, -0.11858609f, -0.10838401f, 
    -0.02326874f, 0.08415982f, 0.17412028f, 0.15466194f, 0.49202192f, 0.10535467f, 0.16893780f, 0.15847526f, 
    0.11052731f, -0.05474338f, 0.21014671f, 0.19476412f, -0.09697213f, 0.08130293f, -0.05923048f, -0.13850042f, 
    -0.37269825f, -0.02708107f, -0.32897657f, 0.16467175f, -0.07532016f, -0.23443985f, -0.11321083f, -0.25087413f, 
    -0.07788530f, 0.03370263f, -0.16826397f, -0.07018341f, -0.03857367f, -0.16466226f, -0.23439160f, -0.15565158f, 
    0.08345991f, 0.20052564f, -0.18487900f, 0.06631240f, -0.02524788f, 0.04305132f, 0.15449494f, -0.06068859f, 
    0.11862710f, 0.20793833f, 0.16051282f, 0.08280714f, -0.20388754f, 0.01401132f, 0.31883714f, -0.11421140f, 
    -0.15992291f, -0.03402170f, 0.13294071f, 0.03202264f, 0.13399324f, -0.05899352f, 0.17218861f, -0.00176702f, 
    0.05207579f, 0.01674307f, 0.07868038f, 0.00457969f, 0.07546881f, 0.11229471f, 0.02105579f, -0.03062634f, 
    -0.56610012f, 0.20176615f, -0.02569805f, -0.24446142f, -0.02013226f, -0.08090149f, -0.09496369f, 0.12441368f, 
    -0.29901394f, -0.13136724f, 0.09487250f, -0.01670313f, -0.03888052f, -0.01811991f, -0.59168822f, 0.25707883f, 
    0.14276543f, -0.03081501f, -0.19857031f, 0.03046251f, -0.07853375f, -0.12674001f, -0.09646684f, 0.03348419f, 
    -0.17427933f, -0.13608479f, -0.12468296f, -0.17823146f, 0.18940511f, -0.24938481f, 0.02124001f, -0.07133871f, 
    0.13285367f, 0.02873633f, -0.05936615f, -0.00195721f, -0.39121541f, 0.13371876f, -0.48449060f, -0.21582066f, 
    0.02775026f, -0.07384590f, -0.08928581f, -0.14875758f, 0.19422297f, 0.00659710f, 0.02715638f, -0.05830118f, 
    0.60723352f, -0.39603019f, 0.09551821f, 0.06625284f, -0.08436332f, -0.04682881f, -0.12287047f, -0.06473747f, 
    -0.06376041f, -0.06020200f, 0.08274660f, 0.04068459f, -0.10050168f, -0.24311540f, -0.16015461f, 0.31782487f, 
    0.07688364f, 0.13382171f, 0.02967240f, -0.03741845f, -0.09129041f, -0.06596686f, -0.08478153f, -0.01737361f, 
    -0.05752199f, 0.04201981f, 0.03806186f, 0.27239051f, 0.14028002f, 0.31637079f, 0.06707348f, -0.05819028f, 
    0.03394736f, -0.00816363f, 0.08277936f, 0.06298109f, 0.54960656f, -0.10631583f, -0.10488312f, -0.03822228f, 
    0.30272308f, 0.27132481f, -0.02525165f, -0.10637705f, 0.07729803f, -0.01585582f, -0.09153228f, -0.07779612f, 
    -0.09624831f, -0.33959681f, 0.05861429f, 0.57912731f, -0.03930699f, -0.09083807f, -0.02789641f, 0.07735935f, 
    -0.17893046f, -0.18957224f, -0.05258468f, -0.09648431f, -0.23339705f, -0.32750565f, 0.25664568f, 0.22904773f, 
    0.07445703f, 0.16401799f, -0.05065149f, -0.04465092f, 0.11272189f, -0.15083037f, 0.09617084f, -0.09400881f, 
    0.05189506f, 0.36377272f, 0.11602642f, -0.10646991f, 0.01555913f, 0.21128598f, 0.01872983f, -0.08728663f, 
    0.00735779f, -0.10197907f, -0.05943032f, -0.03287621f, -0.77639121f, -0.04265710f, -0.09377830f, -0.33534646f, 
    0.29404652f, 0.05418733f, 0.13590148f, 0.02619912f, 0.00895528f, 0.12816426f, 0.15370123f, 0.13282298f, 
    0.13915052f, 0.38787678f, -0.26532394f, -0.07508164f, -0.01190638f, -0.02243714f, 0.01566743f, 0.00374168f, 
    -0.07461099f, 0.07616381f, 0.03508208f, 0.02934510f, 0.01934368f, -0.07635243f, -0.02445963f, -0.03036847f, 
    0.19343279f, -0.05329545f, 0.05604123f, -0.15230641f, 0.10075447f, 0.08082018f, -0.04176056f, 0.07051805f, 
    -0.05322490f, 0.01984616f, 0.01802525f, 0.07570471f, 0.17881443f, 0.09189800f, 0.08717583f, 0.07669843f, 
    0.03809742f, -0.00673467f, 0.02015443f, 0.07887512f, 0.55597562f, 0.29275259f, 0.11159420f, 0.10154164f, 
    -0.02512161f, -0.04841892f, -0.04457770f, 0.05199329f, -0.02013207f, -0.04451670f, 0.09144882f, -0.05736147f, 
    -0.31398523f, 0.30294958f, -0.08156696f, -0.26041713f, 0.05243234f, -0.01878152f, -0.08414336f, 0.01498801f, 
    -0.06018725f, -0.03789434f, 0.02299862f, -0.06022360f, 0.37380239f, 0.49986634f, 0.13220935f, -0.12173537f, 
    0.02121689f, -0.02685221f, 0.08653005f, 0.00092437f, 0.02724031f, 0.13146359f, -0.03837122f, -0.02606821f, 
    0.13508369f, -0.17477901f, -0.04679814f, 0.09754991f, -0.15998182f, -0.14505200f, 0.13002877f, -0.04897483f, 
    -0.13044235f, -0.16701609f, 0.02057774f, 0.27216148f, -0.35156399f, 0.29371208f, 0.08129852f, -0.28770611f, 
    0.06394664f, -0.01370932f, 0.05446312f, -0.04303714f, 0.03110904f, 0.05835721f, -0.01612454f, -0.06208310f, 
    0.18316445f, -0.24994101f, -0.02528897f, 0.00450492f, -0.08012860f, -0.08388035f, 0.06976812f, -0.11506221f, 
    0.02747504f, 0.14474303f, -0.09127365f, 0.10529025f, 0.08374897f, -0.27711993f, -0.01434676f, 0.11944698f, 
    0.42938441f, 0.27841836f, -0.04669419f, 0.07630870f, 0.00826586f, -0.02335212f, -0.01116004f, 0.09843595f, 
    0.05104743f, -0.10217329f, -0.13343452f, -0.01121597f, 0.07598090f, 0.12816864f, 0.04538415f, 0.14325950f, 
    0.24146734f, -0.06070650f, -0.02568824f, 0.08688382f, -0.17105356f, -0.16379686f, 0.17629524f, 0.38223276f, 
    0.31851187f, 0.19885768f, -0.14424020f, 0.08352184f, 0.10314553f, -0.03613799f, 0.11791813f, -0.13308245f, 
    0.16200483f, -0.20867091f, -0.16458017f, 0.21854575f, -0.02730389f, 0.05722025f, 0.03070683f, -0.01583852f, 
    -0.01115168f, 0.02529735f, 0.12815455f, -0.00496238f, -0.22185782f, 0.29118311f, 0.18069923f, 0.06096875f, 
    0.09770116f, 0.01399328f, -0.03868004f, -0.30560216f, 0.04304190f, -0.11897638f, 0.10044125f, -0.18940601f, 
    0.02608738f, 0.36895061f, 0.14219716f, 0.06398220f, 0.28180900f, 0.23894717f, -0.05159875f, -0.08506121f, 
    -0.05096403f, 0.01277846f, -0.02303885f, 0.00362826f, -0.33323553f, -0.07239741f, 0.12478685f, 0.00590434f, 
    -0.03116526f, -0.03136636f, -0.13281564f, -0.04332954f, -0.00716150f, 0.07124139f, -0.07472808f, -0.13658956f, 
    -0.38996384f, 0.38831377f, 0.02291485f, -0.14347838f, 0.12283958f, -0.02081912f, 0.08792838f, -0.10511618f, 
    -0.08897720f, 0.02493804f, -0.03352266f, 0.09309944f, 0.29641643f, -0.15343206f, -0.04214002f, 0.00064653f, 
    0.23038004f, -0.03632470f, -0.05072853f, -0.07197058f, 0.08211955f, -0.21095076f, 0.08488819f, -0.12138792f, 
    -0.23554555f, -0.08183039f, 0.12308189f, -0.33214235f, 0.10264406f, -0.09583925f, 0.06363460f, -0.05868448f, 
    -0.08479995f, 0.05901131f, 0.14692259f, 0.06069787f, -0.14110115f, -0.37426120f, 0.30889809f, 0.18573654f, 
    0.04596988f, 0.07392315f, 0.07237361f, 0.06739650f, 0.16541630f, 0.10494030f, 0.02086439f, 0.00591929f, 
    0.05999611f, -0.13887703f, -0.05255901f, -0.27698675f, -0.04004426f, -0.17733239f, -0.05091593f, 0.05450822f, 
    0.18186086f, 0.06152438f, 0.12635946f, -0.03925134f, -0.31485718f, 0.14943023f, 0.06219282f, 0.20189722f, 
    0.06208107f, 0.06504499f, -0.06597468f, -0.01146530f, -0.02513119f, 0.03663906f, 0.10677987f, -0.07089061f, 
    -0.17490375f, -0.14475861f, 0.05847260f, -0.12199116f, -0.11084504f, 0.04707666f, 0.02421021f, -0.08240587f, 
    0.01159910f, -0.06242747f, 0.19640681f, 0.19275030f, -0.08292041f, 0.47857979f, 0.24084775f, 0.00041828f, 
    0.10469471f, 0.05193169f, -0.06984834f, 0.04611194f, -0.02166610f, -0.08992390f, -0.06912901f, -0.09281138f, 
    -0.30014178f, 0.50314927f, -0.10750049f, 0.03937349f, 0.07182853f, -0.01769438f, -0.00421692f, 0.11178482f, 
    0.17329910f, 0.04410483f, 0.15341738f, 0.09553374f, -0.23254696f, -0.13293809f, 0.04724073f, -0.22731577f, 
    0.05877123f, 0.10878731f, 0.14071745f, 0.09735526f, 0.05922558f, 0.10982809f, 0.11090894f, 0.12216631f, 
    -0.21959543f, -0.10395946f, 0.00894560f, 0.07752825f, -0.06353409f, -0.17506401f, -0.00802880f, 0.03070213f, 
    0.17462003f, -0.03522213f, -0.14478093f, 0.21159400f, -0.30846530f, -0.31523675f, 0.11808205f, -0.25589424f, 
    -0.26963899f, -0.05535740f, -0.03205012f, -0.05371556f, -0.06201028f, -0.10281351f, 0.17370932f, -0.08126244f, 
    0.37812316f, 0.23874244f, -0.15787379f, -0.27088329f, 0.03192798f, 0.17607918f, 0.05685918f, 0.03731033f, 
    0.16640906f, 0.10855883f, 0.11215796f, 0.14368446f, 0.04408263f, 0.11248489f, 0.13337067f, -0.19359145f, 
    0.16432804f, -0.06354658f, -0.00307570f, 0.12047323f, 0.19305174f, 0.06021256f, 0.10017449f, -0.06409877f, 
    0.29361111f, -0.22837196f, 0.19300325f, 0.10881764f, 0.19731024f, 0.16199051f, -0.06898887f, -0.04473137f, 
    -0.00263365f, 0.20014887f, 0.17130820f, 0.07879633f, 0.90244305f, 0.07494734f, -0.19532692f, 0.21900856f, 
    -0.09159077f, -0.09772294f, -0.07555182f, -0.02416506f, -0.08052245f, 0.02267745f, 0.00907224f, -0.05807218f, 
    -0.18882340f, -0.13678288f, -0.00685734f, 0.01175413f, 0.09998875f, 0.00907124f, -0.07866536f, -0.06466971f, 
    -0.03207321f, 0.13784869f, 0.03358667f, 0.05627361f, -0.19041052f, -0.15365462f, -0.01042627f, 0.12141558f, 
    0.03296300f, 0.30116430f, -0.04607698f, 0.01531588f, -0.08604216f, -0.16705924f, 0.21954289f, 0.02161871f, 
    0.33426380f, -0.00703885f, -0.10079381f, 0.09579079f, -0.08810848f, -0.07998568f, 0.09714004f, -0.02244235f, 
    0.02245445f, 0.23335344f, -0.01226027f, 0.11475801f, -0.11282273f, -0.15423584f, 0.10446096f, 0.26311949f, 
    0.18076782f, 0.13335992f, 0.05361986f, 0.13541599f, -0.10549921f, 0.04643674f, 0.16172688f, 0.07928446f, 
    -0.28681597f, -0.08914724f, -0.12927143f, -0.04382451f, 0.04927690f, 0.02869646f, -0.14453793f, 0.11358620f, 
    -0.04929650f, 0.10188230f, 0.15764631f, -0.02418827f, -0.17954677f, -0.28758839f, -0.10734866f, 0.23181887f, 
    0.06534328f, -0.00373678f, -0.14227019f, 0.01538906f, -0.06578229f, -0.23663329f, 0.07262707f, 0.12194830f, 
    0.02931226f, 0.46999872f, 0.11034213f, -0.18359281f, 0.17196897f, 0.11430179f, 0.03101979f, 0.08230351f, 
    0.09524865f, 0.10070214f, 0.00540010f, -0.09665418f, -0.20403095f, -0.16979812f, -0.14972000f, -0.17773758f, 
    0.12459256f, -0.01541093f, -0.02034770f, -0.09656408f, 0.24411325f, -0.12006716f, 0.01918158f, 0.04317851f, 
    -0.18951932f, 0.09130801f, 0.11032516f, 0.06759542f, -0.11658926f, 0.01933497f, -0.04323915f, 0.03250965f, 
    -0.02784656f, -0.03519535f, 0.18291916f, -0.06552166f, 0.33887902f, -0.05762361f, -0.27009273f, 0.04963461f, 
    0.01585559f, 0.03563358f, 0.10024017f, 0.40579566f, 0.18088789f, 0.14277244f, -0.04108593f, -0.21158314f, 
    -0.27959964f, -0.01520085f, -0.10963969f, -0.28570926f, 0.08446660f, -0.24220613f, -0.09100048f, 0.09477161f, 
    0.08204409f, -0.14045650f, 0.18132789f, 0.16035910f, 0.07189453f, -0.07187135f, -0.04255585f, 0.23587060f, 
    0.09834627f, -0.09957761f, -0.00263515f, 0.15325305f, 0.01273845f, 0.10635298f, 0.03570199f, 0.02860024f, 
    0.23288602f, -0.05917592f, -0.26223528f, -0.34989393f, 0.04653512f, 0.12740676f, 0.12756911f, 0.07857351f, 
    0.04407417f, 0.00137209f, 0.01224809f, -0.00407721f, -0.04735593f, -0.51796120f, 0.24793701f, -0.63198131f, 
    0.11064254f, -0.08444170f, 0.13733248f, -0.04797196f, -0.00701879f, 0.18863937f, 0.00256233f, -0.02437162f, 
    -0.02115709f, 0.04839218f, -0.11338079f, -0.12600242f, 0.11863640f, -0.01572712f, 0.10407660f, 0.13789172f, 
    0.05197189f, -0.01428705f, 0.08126514f, 0.07735904f, 0.30533713f, 0.47564226f, -0.43866989f, 0.35523659f, 
    0.00191469f, 0.04808201f, -0.20943350f, 0.09444620f, 0.14282441f, 0.06786370f, -0.01245985f, -0.00145390f, 
    0.31849051f, -0.13744530f, 0.31890234f, -0.07470641f, 0.04621119f, -0.13773267f, -0.03884304f, -0.11219160f, 
    -0.00339937f, 0.17459653f, 0.10648523f, -0.26434934f, -0.25158331f, 0.50991362f, -0.08342624f, -0.11438997f, 
    -0.23229904f, 0.23318169f, -0.05070891f, 0.04019899f, -0.33696142f, 0.15403496f, 0.09752401f, -0.08013819f, 
    0.40014139f, 0.09411558f, -0.12519145f, 0.39694124f, -0.09465470f, -0.05245541f, 0.05885433f, 0.04106031f, 
    0.06975134f, -0.24025345f, -0.12339411f, 0.18176761f, 0.16028947f, 0.12079207f, 0.05736965f, -0.08054671f, 
    -0.19661161f, 0.00848130f, 0.03583249f, -0.14178389f, 0.09319290f, 0.11500007f, -0.01873495f, -0.03108964f, 
    -0.08554470f, -0.03577802f, -0.23036703f, 0.51531041f, 0.11726566f, 0.07484208f, -0.13291250f, 0.03214242f, 
    0.04151589f, 0.04893513f, 0.02751034f, -0.07740334f, 0.07194506f, -0.27607623f, -0.08332428f, -0.11738824f, 
    0.15274221f, -0.14361551f, 0.07082994f, 0.01900678f, 0.12746532f, 0.05396191f, -0.23447788f, -0.00200150f, 
    -0.42328268f, -0.20112275f, 0.32001323f, -0.18913697f, 0.21015845f, 0.01847408f, -0.00858598f, 0.00811325f, 
    0.08838710f, 0.10090529f, 0.10305777f, 0.02435457f, 0.34627718f, 0.08945276f, -0.11828846f, 0.10796800f, 
    0.19702616f, 0.07540310f, 0.20976910f, 0.07399363f, 0.01052291f, 0.14801557f, 0.18795846f, 0.16596203f, 
    0.23310655f, -0.13081701f, -0.03385815f, -0.05154662f, 0.08061455f, 0.07198114f, -0.04330274f, -0.05178535f, 
    0.22178124f, 0.11388399f, 0.04729960f, 0.03492282f, -0.01508843f, 0.30598783f, 0.03326169f, 0.03937341f, 
    0.02777524f, -0.07519159f, -0.00289584f, 0.04405393f, -0.00396895f, -0.00112887f, -0.07700127f, 0.08380013f, 
    -0.13265690f, -0.01488193f, -0.17633192f, -0.27524614f, -0.07355689f, -0.15465368f, -0.00300378f, -0.19976149f, 
    0.09794327f, -0.12105057f, 0.01162429f, -0.17113559f, 0.18739018f, -0.21246655f, 0.05470601f, -0.41862401f, 
    0.04279228f, -0.03945864f, 0.21453156f, -0.00364390f, 0.24821937f, 0.09458601f, 0.07202435f, 0.13119984f, 
    -0.28414398f, 0.00896571f, -0.10418085f, -0.17443037f, -0.11247158f, 0.03649146f, 0.13199250f, 0.01012125f, 
    0.08638003f, 0.01722843f, -0.01148189f, 0.02101182f, 0.12920175f, -0.65529597f, -0.25053647f, 0.22307089f, 
    -0.13830082f, 0.07271568f, -0.03734264f, 0.06326111f, -0.03940572f, 0.00869633f, -0.06051121f, 0.00800202f, 
    -0.01315538f, 0.06257142f, 0.19658662f, 0.00248810f, -0.20666072f, 0.01934112f, -0.01504225f, 0.04793559f, 
    -0.00508895f, 0.08863263f, 0.02366317f, -0.01952156f, 0.30568445f, -0.23284969f, -0.31685016f, -0.18468478f, 
    0.09573021f, 0.12036473f, 0.01513509f, 0.00005632f, 0.04288875f, 0.04630970f, 0.12270334f, 0.04827709f, 
    0.32030937f, -0.23860535f, 0.08864094f, -0.08687073f, -0.12355726f, -0.01431960f, 0.06109027f, 0.17224059f, 
    0.11873323f, 0.01359277f, -0.11594550f, 0.07635060f, 0.11541725f, 0.07139666f, 0.02608986f, 0.15412886f, 
    0.00564071f, -0.07477077f, -0.05788423f, 0.06676665f, 0.05724921f, 0.02097279f, 0.29666138f, -0.02117465f, 
    -0.16708679f, 0.36752361f, 0.15879379f, -0.04814678f, -0.22941932f, 0.16223198f, 0.09173065f, 0.08105695f, 
    0.05816296f, -0.04310106f, 0.07143950f, -0.00858515f, 0.09031759f, 0.50696474f, -0.11939520f, -0.01373941f, 
    0.06092753f, 0.09065783f, 0.11985487f, 0.10282943f, 0.07361692f, -0.03388399f, -0.05744404f, 0.22176005f, 
    0.06300027f, 0.08960351f, -0.35807288f, 0.14480260f, -0.09925389f, 0.15260589f, -0.12765491f, 0.03974933f, 
    0.04798130f, -0.07776958f, 0.02686439f, 0.04788936f, 0.44632053f, 0.09127679f, 0.17688410f, -0.00453169f, 
    0.00762032f, -0.00821808f, -0.00921337f, 0.14576420f, 0.08559044f, -0.05124440f, 0.09035859f, -0.19339605f, 
    0.11846478f, -0.28937998f, -0.08290810f, -0.04570330f, 0.09849620f, -0.22274482f, 0.05696382f, 0.23277950f, 
    -0.09071459f, 0.16021198f, -0.00744004f, 0.16618323f, 0.15009968f, -0.01404069f, 0.25829300f, 0.07828657f, 
    -0.35223541f, 0.04301412f, 0.06377872f, 0.10349443f, -0.03344917f, -0.00787753f, 0.04031890f, 0.14947395f, 
    0.05548135f, -0.05973637f, -0.06971430f, -0.01867402f, -0.06209906f, -0.00976380f, -0.07025138f, 0.01538875f, 
    -0.07760905f, -0.07124399f, -0.02824017f, -0.04766233f, -0.07381786f, 0.05482080f, -0.08076522f, -0.05780831f, 
    0.04816435f, 0.06076967f, 0.02206177f, 0.03043850f, -0.01923750f, -0.07120644f, 0.03873667f, 0.03669771f, 
    0.04876883f, 0.03212329f, -0.08009526f, -0.02514450f, -0.06533385f, -0.01082346f, 0.06021160f, -0.05424976f, 
    0.05968507f, -0.01277631f, -0.04105197f, 0.02549572f, -0.06946694f, -0.00216621f, 0.00073597f, 0.01822919f, 
    -0.07720169f, -0.01404599f, -0.06244309f, -0.04503467f, -0.05252464f, 0.03985944f, 0.04954164f, 0.03755771f, 
    0.05036832f, 0.05479192f, -0.01626877f, -0.07093354f, -0.08005606f, -0.02771291f, -0.06087799f, -0.01526960f, 
    0.04757323f, -0.02405730f, -0.01551484f, -0.01177756f, 0.03347472f, 0.04055305f, -0.04251601f, 0.03456007f, 
    0.04762919f, 0.01845357f, -0.02746915f, -0.01870333f, 0.00395109f, -0.06097808f, 0.04350644f, -0.00684258f, 
    0.01499324f, -0.04677011f, -0.07701391f, -0.00950245f, 0.00392986f, -0.03273349f, -0.05737085f, 0.04052692f, 
    -0.07903820f, -0.03561827f, -0.05947875f, 0.04791748f, -0.03538504f, -0.05178314f, -0.01018895f, 0.04103284f, 
    -0.03056456f, 0.02984064f, 0.03742310f, -0.03583868f, 0.03903472f, -0.02182364f, -0.07505187f, -0.06877942f, 
    0.00219985f, 0.04854713f, 0.05802880f, -0.02197175f, -0.06933454f, -0.06632753f, -0.05540637f, 0.00128408f, 
    -0.03797040f, -0.01455092f, 0.05193432f, 0.00413449f, -0.05919053f, 0.04299460f, -0.04716159f, -0.05651100f, 
    -0.01229656f, 0.02056981f, -0.02543008f, -0.00475465f, -0.07324915f, -0.06522966f, -0.06974774f, 0.04402515f, 
    0.05812065f, 0.01403922f, -0.01742626f, -0.02841504f, 0.01172283f, 0.01932573f, -0.05515613f, 0.00113032f, 
    -0.07840866f, -0.00362855f, -0.05701837f, -0.00647637f, 0.03791888f, -0.06426039f, -0.02571489f, 0.00975360f, 
    0.01148844f, -0.06227776f, 0.01418998f, -0.07890225f, -0.00541937f, 0.00295595f, -0.03759071f, -0.06213866f, 
    -0.03734577f, -0.02312013f, -0.00840024f, -0.00795382f, -0.08173127f, 0.00072600f, -0.07598172f, -0.08091439f, 
    -0.03364608f, -0.04268307f, -0.04687976f, 0.04508533f, 0.01572675f, 0.01294539f, -0.07455087f, 0.02625534f, 
    -0.05813698f, -0.00310914f, -0.00177377f, 0.01696007f, -0.03093150f, 0.05488809f, 0.02081585f, -0.06519932f, 
    -0.06037175f, -0.03977178f, -0.02034556f, -0.00139128f, -0.02637769f, -0.03525896f, -0.06782239f, -0.07944425f, 
    -0.06841942f, 0.04541949f, 0.01540893f, -0.03335298f, 0.04545020f, 0.05440539f, 0.00073278f, 0.02259905f, 
    -0.01821122f, -0.00893289f, -0.08224266f, -0.02778998f, -0.03028496f, -0.05646475f, -0.06853908f, 0.03782322f, 
    -0.03153989f, 0.05101808f, 0.06861562f, -0.00609093f, -0.05440782f, -0.03491284f, -0.15218386f, 0.03028849f, 
    -0.21316883f, -0.16936563f, -0.03726095f, 0.12467443f, 0.19875896f, 0.00892777f, -0.05044409f, 0.16992602f, 
    0.03094832f, -0.17351098f, -0.17124306f, -0.16189666f, -0.06597607f, 0.01691353f, 0.00703672f, -0.13320285f, 
    0.23360223f, -0.06273717f, 0.09127143f, 0.29296464f, 0.07172511f, 0.33218336f, 0.07032567f, 0.05984980f, 
    -0.05986153f, 0.31961769f, 0.28189921f, 0.20886847f, 0.46516946f, 0.11502856f, -0.31129754f, -0.09269197f, 
    0.12769224f, 0.09595206f, 0.07859471f, -0.02049847f, -0.12008642f, 0.18830700f, -0.07128762f, 0.12270666f, 
    0.10161054f, -0.10387713f, 0.45103410f, 0.17441656f, 0.00668088f, -0.07976428f, -0.10036778f, -0.17494474f, 
    -0.08659443f, -0.21173844f, -0.02001400f, 0.05963767f, -0.18057461f, 0.44989163f, 0.16977914f, -0.18058860f, 
    0.02162303f, 0.15156421f, -0.04000333f, 0.05302813f, -0.02266674f, 0.14995703f, 0.05645530f, -0.00864761f, 
    -0.00527951f, -0.05936523f, -0.17525741f, 0.08182973f, -0.02310448f, -0.01878579f, -0.16005805f, -0.10920168f, 
    -0.04739999f, -0.24542432f, -0.21123244f, 0.05706957f, -0.42538476f, 0.46051118f, 0.16815148f, -0.17666481f, 
    0.04692103f, -0.01293700f, 0.09988693f, 0.20812581f, -0.00487939f, 0.04354754f, 0.16100159f, 0.01658630f, 
    0.16771127f, -0.01773850f, 0.04970103f, 0.33105883f, 0.20620021f, 0.18984781f, -0.06631555f, -0.18225151f, 
    0.00386796f, -0.06012397f, 0.12243599f, -0.04884629f, -0.22364347f, 0.07648902f, 0.07304770f, 0.08480737f, 
    -0.06685846f, -0.12909503f, -0.09115077f, 0.11505470f, 0.08414922f, 0.17262696f, -0.12124375f, -0.05423325f, 
    0.26007944f, -0.31968281f, -0.24395590f, 0.44707260f, 0.23872362f, -0.04994790f, -0.15023136f, -0.00104842f, 
    0.11575701f, 0.09695407f, -0.18746029f, -0.01308064f, 0.24209146f, 0.14302488f, -0.12852813f, -0.12938756f, 
    0.01734123f, -0.04585151f, -0.28615060f, -0.20250076f, 0.04197088f, 0.00511229f, 0.13972211f, -0.04178165f, 
    0.11397653f, -0.06042771f, 0.14709750f, 0.01154061f, 0.23747002f, -0.01862475f, 0.13598385f, -0.15074340f, 
    -0.08706902f, -0.11209531f, -0.10452779f, -0.23925537f, 0.09936330f, -0.02413702f, 0.19470644f, -0.30547315f, 
    0.06224391f, -0.01777441f, 0.16234507f, -0.43284786f, -0.09729514f, -0.13520241f, -0.21168694f, 0.09468184f, 
    0.29996035f, 0.06921507f, -0.05217883f, 0.33236852f, -0.01097491f, 0.12801266f, 0.02702157f, -0.02581754f, 
    -0.00596569f, -0.03772527f, -0.07111945f, 0.07617556f, 0.22396602f, -0.22981511f, -0.19786726f, 0.22799298f, 
    0.06709008f, -0.15217687f, 0.02005447f, -0.31270429f, 0.02668105f, 0.11937557f, -0.08212283f, -0.08032357f, 
    -0.02859364f, 0.05217527f, -0.06218359f, -0.05461312f, 0.01647481f, -0.06761716f, 0.02409222f, -0.05553242f, 
    -0.05639666f, -0.00847504f, 0.03219192f, 0.01116585f, -0.06730162f, -0.05544395f, 0.03669405f, -0.01389108f, 
    -0.03495120f, -0.05345491f, -0.05770033f, -0.04016472f, 0.02012164f, -0.03535748f, 0.01235943f, 0.01161143f, 
    -0.05805457f, 0.04153980f, -0.01711590f, -0.00191461f, 0.03077204f, 0.01157046f, 0.05986579f, -0.01224795f, 
    -0.02020266f, -0.06268024f, 0.01611185f, 0.04850639f, -0.00967653f, 0.03717417f, -0.07054684f, -0.02709092f, 
    -0.03982205f, -0.05029742f, 0.01826560f, 0.01292301f, 0.04280103f, -0.03342452f, -0.02436189f, -0.03097832f, 
    0.02269004f, 0.05270168f, 0.03693187f, -0.04320088f, 0.01216421f, -0.03740070f, -0.06366893f, 0.05708093f, 
    -0.00398858f, 0.06502676f, -0.00826864f, -0.05156817f, 0.02764816f, 0.05526017f, 0.05002500f, -0.02587946f, 
    -0.01160371f, 0.04118794f, -0.01223108f, -0.05959221f, -0.07018451f, -0.06447592f, -0.02408912f, -0.02104261f, 
    -0.05281554f, 0.01162106f, 0.03283207f, -0.05013274f, -0.00682334f, -0.02007763f, 0.00432824f, -0.01762997f, 
    -0.03843950f, -0.00594894f, -0.05392171f, -0.06446499f, 0.06310359f, 0.01721502f, 0.01419050f, -0.02212672f, 
    0.04507606f, -0.06457825f, -0.05956946f, -0.00999363f, 0.04383997f, 0.02141884f, -0.01456194f, -0.03744459f, 
    0.01368829f, -0.06570802f, -0.05157167f, 0.05575787f, -0.00483710f, -0.07547654f, 0.05490266f, -0.00451661f, 
    0.05670818f, -0.05922946f, -0.02643879f, -0.06341041f, 0.06143024f, 0.02120074f, -0.02350826f, 0.01039166f, 
    -0.00606460f, 0.05128664f, -0.00783773f, -0.03494687f, 0.02331916f, -0.00510613f, -0.05383437f, -0.07090008f, 
    0.04181621f, -0.00930027f, 0.02062445f, 0.03707974f, -0.05839176f, -0.00016074f, 0.04353917f, -0.00731681f, 
    -0.06452501f, 0.00758708f, -0.02002139f, 0.03342702f, 0.04679741f, 0.00620625f, 0.00950258f, -0.04873452f, 
    0.05672252f, 0.01059238f, -0.02078644f, -0.01133000f, -0.01314031f, -0.07103354f, 0.03839901f, 0.04708999f, 
    0.06003888f, 0.00239524f, -0.03577584f, 0.00502476f, -0.03055537f, 0.00321153f, -0.02616492f, -0.01830969f, 
    -0.03577518f, -0.06150290f, -0.04107981f, -0.03380686f, 0.05840341f, 0.03611442f, 0.03675974f, 0.05320825f, 
    -0.07833291f, -0.03102424f, 0.02620857f, 0.04137523f, -0.05805209f, -0.05078930f, 0.05852313f, 0.02859983f, 
    -0.06164479f, 0.06333350f, -0.07383233f, -0.06027819f, 0.02435257f, -0.05029749f, -0.04599045f, -0.01033878f, 
    -0.05702703f, -0.05920235f, 0.01357526f, -0.05286353f, -0.04876671f, 0.00443076f, -0.07558232f, 0.06141765f, 
    0.04692125f, -0.00416437f, -0.04080578f, 0.01340046f, -0.00251967f, 0.03925595f, -0.05199987f, -0.07493761f, 
    0.08054886f, 0.26883909f, -0.03782421f, -0.00096222f, 0.07018557f, -0.13438189f, 0.06891634f, 0.16085877f, 
    0.03407799f, 0.08648928f, 0.00004411f, 0.16217415f, -0.16335721f, -0.13580406f, 0.17322777f, -0.13853420f, 
    0.07480099f, 0.15822889f, -0.00273411f, -0.24069692f, -0.02826953f, -0.02233866f, 0.02299153f, 0.08578051f, 
    0.18233976f, 0.20419148f, 0.08840339f, 0.26416013f, -0.04380354f, 0.21619245f, -0.01358121f, -0.01362475f, 
    -0.00889982f, 0.04308163f, 0.07025278f, -0.03038348f, 0.21863498f, 0.08623904f, 0.04191613f, -0.30128309f, 
    -0.00336756f, 0.28511071f, -0.17244317f, -0.10056571f, -0.09499238f, -0.12709634f, 0.01516021f, -0.03739205f, 
    0.57226884f, 0.07479571f, 0.15846896f, 0.08142995f, 0.04577602f, 0.08026073f, -0.02793737f, 0.01632883f, 
    -0.10888094f, 0.23577076f, 0.14020260f, -0.08918960f, -0.06539465f, 0.09758520f, 0.03422541f, 0.24195354f, 
    -0.06058339f, -0.00058289f, -0.06101864f, 0.08481748f, 0.13029812f, 0.03500448f, 0.08055811f, -0.08066537f, 
    -0.42877331f, -0.19543470f, -0.06484201f, -0.05425619f, 0.11782006f, -0.00867690f, 0.03386413f, -0.09091283f, 
    0.11163720f, 0.10665797f, 0.01873758f, 0.09267669f, 0.39772800f, 0.14968738f, 0.17163090f, -0.06986660f, 
    -0.14014035f, -0.15623628f, 0.04871031f, 0.06242127f, -0.07246255f, -0.06009778f, 0.05041669f, -0.11620106f, 
    -0.29348469f, 0.07702336f, -0.28291300f, -0.10745832f, -0.07352799f, 0.02602939f, 0.04937196f, -0.02353668f, 
    0.04605236f, 0.11631378f, 0.00900327f, 0.11206233f, -0.21134558f, -0.45503336f, -0.00420481f, 0.03749707f, 
    0.04561280f, 0.06317211f, -0.06641982f, -0.21575071f, 0.13266723f, -0.04763202f, -0.06135358f, -0.08245709f, 
    0.12525727f, 0.04296356f, -0.08003819f, -0.03775137f, 0.19283217f, 0.00777919f, 0.20548558f, -0.10726867f, 
    0.07719592f, 0.28068128f, 0.15251540f, 0.08451344f, -0.18682085f, -0.06732081f, 0.17855591f, 0.15455002f, 
    0.18226796f, -0.06639717f, -0.15297878f, 0.10059477f, -0.17103931f, 0.05588806f, 0.15888774f, -0.00262362f, 
    0.14520006f, 0.11743772f, 0.28196511f, -0.08795166f, -0.02125547f, 0.11077956f, 0.01707973f, 0.09931236f, 
    -0.08022982f, 0.01321252f, 0.04258829f, 0.08282556f, -0.51204395f, -0.09322163f, 0.00102867f, 0.07060128f, 
    0.00002444f, -0.03729574f, -0.01541223f, -0.03040419f, -0.17081769f, 0.04236671f, 0.04647202f, 0.14260530f, 
    0.51560903f, 0.68663108f, 0.04815809f, 0.11038800f, -0.02035195f, 0.07215545f, -0.00014978f, 0.06525636f, 
    0.15384963f, -0.04772330f, 0.02495403f, -0.03756742f, -0.90459687f, -0.18747534f, -0.09777655f, -0.33253729f, 
    0.04106042f, -0.09285905f, -0.06145484f, -0.02823939f, 0.23572195f, -0.17117532f, -0.15886480f, -0.16519910f, 
    0.55982947f, -0.20461734f, 0.08538391f, 0.02366571f, 0.16321297f, 0.24009544f, -0.10723862f, 0.00532167f, 
    -0.11695016f, -0.01232740f, -0.00868451f, -0.06789232f, -0.13216333f, 0.07798885f, -0.07315528f, 0.20602323f, 
    -0.16562743f, -0.09643351f, 0.02196626f, -0.26327795f, -0.25039604f, -0.13102837f, 0.04309883f, -0.17741254f, 
    -0.11196993f, 0.38455167f, 0.08496547f, 0.21165460f, 0.01186652f, -0.15986700f, -0.06750965f, -0.01925561f, 
    -0.06130932f, 0.25663194f, 0.11936388f, -0.03814058f, 0.10439996f, 0.41775280f, 0.02805406f, 0.15540555f, 
    -0.14130554f, -0.05930490f, 0.18031268f, 0.11465905f, -0.00148302f, 0.15677467f, -0.12843074f, 0.11800449f, 
    0.02955673f, -0.26108840f, -0.30305165f, 0.05550836f, 0.19785310f, 0.06575064f, -0.08167718f, 0.09846982f, 
    -0.06190925f, -0.00356079f, -0.04799832f, -0.06976586f, 0.06540684f, -0.13405015f, 0.07080503f, 0.27666402f, 
    0.04658443f, -0.03270003f, -0.08964705f, -0.02152530f, 0.09177766f, -0.07254286f, 0.10334934f, 0.05570088f, 
    -0.11773945f, -0.08204044f, -0.08280596f, -0.20788048f, -0.16981015f, 0.08508930f, 0.00895091f, 0.04957469f, 
    0.01970981f, -0.11534612f, -0.15651134f, -0.11146340f, 0.56504428f, -0.52292407f, 0.36906648f, 0.00989213f, 
    -0.00315027f, 0.00658847f, 0.00301663f, 0.15371482f, 0.08658639f, -0.05295192f, 0.16815072f, 0.30919802f, 
    0.12844166f, 0.21484922f, -0.24345864f, -0.15183768f, 0.11813312f, -0.07382391f, 0.08581724f, 0.01642627f, 
    0.04875405f, -0.05352074f, 0.08117510f, -0.05996925f, 0.63705283f, -0.30682045f, -0.17140424f, -0.16928068f, 
    0.08810414f, 0.02554911f, 0.01782742f, -0.10836939f, -0.07899781f, 0.21007615f, 0.10880922f, 0.12384560f, 
    0.11604020f, -0.08237633f, -0.01573982f, -0.24971220f, -0.01315619f, 0.03558332f, -0.05803385f, -0.05283437f, 
    0.04532044f, -0.09508240f, 0.00687967f, -0.12123156f, -0.07832456f, 0.36633423f, 0.03198400f, -0.26990718f, 
    0.07578601f, -0.05388493f, 0.09143129f, -0.02547889f, -0.06538180f, 0.03325987f, 0.01574736f, 0.02177169f, 
    0.66461802f, 0.25123039f, 0.03971458f, 0.11016238f, -0.03372509f, 0.15461497f, 0.10358905f, 0.06617744f, 
    -0.18284802f, -0.12315548f, -0.22393945f, -0.09378621f, 0.07952784f, 0.26448843f, -0.32067642f, -0.05033503f, 
    0.02675367f, 0.00767858f, 0.19015920f, -0.08636398f, -0.02374371f, 0.12276775f, -0.08436412f, -0.12420201f, 
    0.06879175f, 0.08252810f, -0.39243275f, -0.12766096f, 0.16411811f, 0.00230389f, -0.06246750f, 0.05495375f, 
    0.09444496f, 0.05605750f, -0.02960426f, 0.13077718f, -0.40146622f, 0.08995124f, 0.03033577f, -0.22807308f, 
    0.17879991f, 0.00897592f, 0.07603902f, 0.04943958f, -0.09007206f, 0.14499880f, 0.20186922f, 0.10788727f, 
    0.22550870f, 0.15111762f, -0.23864490f, 0.24314830f, -0.05293640f, 0.08836895f, 0.00078438f, 0.06886309f, 
    -0.03866541f, 0.14462994f, 0.06085175f, 0.31460124f, -0.15023969f, 0.26387370f, 0.19435443f, -0.16720401f, 
    -0.01037254f, -0.14033507f, -0.07406491f, -0.11414225f, 0.03293264f, 0.09972706f, -0.07217395f, 0.17878409f, 
    -0.12079965f, -0.01842675f, 0.13523620f, -0.03456109f, 0.06935868f, 0.24058484f, 0.04246578f, -0.18218182f, 
    0.07943954f, -0.11919494f, -0.19261912f, -0.02632011f, 0.01432789f, 0.08998926f, -0.09308479f, -0.10415574f, 
    -0.14557390f, 0.01712254f, -0.04408720f, -0.32433215f, -0.05885155f, -0.13843150f, -0.00760504f, -0.13670205f, 
    0.01201996f, 0.31416979f, 0.25739262f, 0.20707905f, 0.00215081f, -0.05667042f, 0.00333399f, -0.02107495f, 
    0.03086678f, -0.00461897f, 0.15529685f, 0.08903211f, 0.04646625f, 0.11499686f, -0.18899024f, -0.09671023f, 
    0.06949797f, 0.03121445f, -0.13648117f, 0.07379384f, 0.15685409f, 0.05296260f, 0.02560906f, 0.00142506f, 
    0.20879927f, -0.29147187f, 0.02987124f, 0.35883695f, 0.07148281f, 0.04593025f, -0.12459597f, -0.13411786f, 
    -0.09419134f, 0.09684284f, 0.04154522f, 0.20202520f, -0.42577282f, 0.38291627f, 0.22558866f, -0.23727192f, 
    -0.02631352f, -0.00971833f, 0.14983280f, 0.04844347f, -0.07873840f, -0.07592901f, 0.03791324f, -0.04519060f, 
    0.35007581f, -0.44270116f, -0.01540309f, 0.48995274f, -0.07245279f, 0.13734077f, 0.12179271f, -0.05629174f, 
    0.15127161f, -0.02460557f, -0.00936383f, 0.06650040f, -0.43395320f, 0.11596341f, 0.10125769f, 0.21218731f, 
    -0.08976742f, -0.13654016f, -0.04363968f, 0.02285150f, 0.19855121f, 0.05724705f, -0.08866954f, -0.02189280f, 
    -0.20485361f, 0.02881236f, 0.02981104f, 0.26419461f, -0.06155850f, -0.01368973f, -0.07919542f, 0.24980356f, 
    0.20931821f, 0.19086692f, 0.10124251f, 0.19262682f, 0.14666648f, 0.18306619f, -0.15326084f, -0.05379885f, 
    0.02800388f, 0.13456844f, -0.15258722f, 0.15335324f, 0.10264795f, -0.02297596f, -0.02381709f, -0.05577175f, 
    0.00858297f, -0.02319104f, 0.05414223f, 0.07782894f, 0.09075268f, 0.02025396f, 0.06675582f, 0.04972853f, 
    -0.10139381f, -0.03697942f, 0.11444893f, 0.05427797f, 0.19598554f, -0.27200598f, 0.06067472f, 0.23755813f, 
    0.07966871f, 0.10297539f, 0.00044254f, -0.01202305f, 0.07342209f, 0.09024354f, 0.23558238f, 0.26096523f, 
    0.06020467f, 0.14619966f, -0.01212889f, 0.35856563f, 0.06263930f, -0.05070107f, 0.00724163f, -0.00737395f, 
    0.04291966f, -0.00445919f, -0.08687203f, -0.21592870f, 0.51307583f, -0.67334294f, -0.09018882f, 0.10050617f, 
    0.06260290f, -0.14471130f, -0.01146717f, -0.05045092f, 0.20008563f, 0.08785927f, -0.20958711f, -0.09139056f, 
    0.57027453f, 0.02292723f, -0.10932052f, -0.08260065f, -0.01503927f, 0.07983375f, 0.06863041f, -0.06229409f, 
    0.10838928f, 0.03549552f, 0.07044518f, 0.24728383f, -0.15629746f, -0.13021596f, -0.06729842f, -0.02094068f, 
    0.31047276f, 0.17362086f, -0.10238352f, 0.14480390f, 0.04113818f, 0.01606729f, 0.00314113f, 0.21056421f, 
    -0.52752519f, -0.06505529f, -0.20731099f, 0.03499823f, 0.03605144f, -0.12685134f, -0.09739592f, -0.05724478f, 
    0.23176351f, -0.26443091f, -0.18233185f, 0.09058540f, -0.11231224f, -0.18486170f, 0.19529429f, -0.07109714f, 
    0.01657179f, 0.10813139f, -0.16652131f, -0.09645090f, 0.11971422f, -0.15934789f, 0.05228071f, -0.11457002f, 
    0.34365931f, 0.01918009f, -0.33467561f, -0.22112510f, -0.10190297f, 0.16632059f, 0.05511634f, 0.11990111f, 
    0.06525382f, 0.08975067f, 0.00825442f, 0.01991870f, -0.24490765f, -0.38523686f, 0.15271236f, -0.22110085f, 
    0.07421482f, -0.23304227f, -0.04315953f, -0.05383107f, 0.13364315f, -0.15389390f, 0.05662313f, -0.15786971f, 
    0.32731128f, 0.06040180f, 0.29232752f, 0.11082482f, 0.08840241f, 0.24116886f, 0.09415890f, -0.07354661f, 
    0.01356830f, 0.14644323f, 0.10922441f, 0.12349501f, 0.60620570f, 0.06290726f, -0.04495588f, -0.14656968f, 
    -0.04312686f, 0.12998743f, -0.09895704f, 0.03435142f, 0.06373721f, -0.01067576f, -0.00306455f, -0.03140165f, 
    0.16460706f, -0.20753364f, -0.04983461f, -0.20989811f, 0.01481318f, -0.01415650f, -0.04680526f, 0.05615190f, 
    0.02696540f, 0.16510408f, 0.00559662f, -0.00396465f, 0.17572489f, -0.14217740f, 0.01151802f, 0.22682361f, 
    -0.16008610f, 0.13164070f, 0.00316249f, -0.04780040f, 0.06326530f, -0.01895496f, 0.22009104f, -0.02875291f, 
    0.10330340f, 0.18679306f, -0.11824003f, -0.02365578f, -0.06971534f, 0.10175253f, -0.04084741f, -0.03058920f, 
    -0.03599818f, 0.12442739f, 0.11747368f, 0.15946667f, -0.12664860f, 0.15418862f, -0.01301364f, 0.15734474f, 
    -0.03550033f, 0.06671754f, 0.07393362f, 0.10572879f, 0.02847992f, -0.08870982f, 0.07442977f, 0.22744678f, 
    0.56398505f, 0.05084595f, -0.37776482f, -0.01271783f, 0.07049205f, 0.14510459f, -0.24277800f, 0.08443589f, 
    0.00554781f, -0.08258180f, 0.08638121f, 0.09707396f, 0.10560668f, 0.01535444f, 0.41472590f, -0.04434671f, 
    0.10979097f, -0.15418072f, 0.06679482f, -0.02186228f, -0.00642931f, -0.07796405f, 0.01451451f, 0.12523405f, 
    -0.05504382f, 0.14198472f, -0.15850741f, -0.25237435f, 0.09211937f, -0.01894704f, 0.01796827f, 0.11049107f, 
    -0.08929619f, -0.02629540f, -0.01160746f, 0.04381007f, 0.07882029f, -0.04073409f, 0.18264757f, -0.32943547f, 
    0.08372129f, -0.00356757f, -0.00378150f, 0.13947535f, 0.19471627f, 0.01389215f, 0.00761356f, 0.00525385f, 
    0.13689783f, -0.02232938f, -0.01619919f, 0.13123101f, -0.05934362f, -0.04436745f, 0.05975278f, 0.08159694f, 
    0.01991676f, 0.10043099f, 0.04118910f, 0.09022044f, 0.11481638f, 0.53294611f, 0.09966438f, 0.05010085f, 
    -0.07565139f, -0.12760697f, -0.10109980f, -0.00420646f, 0.03576463f, 0.02786721f, -0.04460426f, 0.00045047f, 
    0.02126421f, 0.04636267f, 0.01589438f, -0.13475867f, 0.04981087f, 0.16522582f, 0.14321378f, -0.06236611f, 
    -0.21909782f, 0.05762448f, 0.08475058f, -0.17169136f, 0.30979902f, 0.29839432f, -0.00359692f, -0.00874045f, 
    -0.06028660f, 0.06445213f, 0.25852489f, -0.07769591f, 0.08706473f, -0.00908381f, -0.05175118f, -0.02664146f, 
    -0.25892538f, 0.27435854f, 0.15983945f, -0.00541440f, 0.07902978f, -0.08054598f, 0.02997700f, -0.09989808f, 
    0.06472529f, -0.08459343f, -0.03456831f, -0.01686529f, 0.28360051f, 0.05664457f, -0.28590888f, -0.34187087f, 
    -0.04808562f, 0.04955888f, -0.08159938f, 0.10716989f, 0.01081883f, 0.10450877f, -0.03027445f, 0.02825795f, 
    0.18903176f, -0.22265300f, -0.20711675f, 0.32382318f, -0.10602343f, -0.21281666f, -0.11963762f, 0.03729023f, 
    -0.07002342f, -0.05629858f, 0.00575150f, 0.01735631f, -0.34306252f, 0.23788719f, 0.20393142f, 0.05057066f, 
    -0.02606676f, 0.11209134f, 0.19665396f, 0.08820682f, 0.01178295f, -0.12014253f, 0.01309375f, 0.13247101f, 
    0.28444180f, -0.21250319f, 0.18354596f, 0.51031333f, -0.06057975f, 0.02641768f, 0.04788622f, 0.00706917f, 
    0.08906732f, -0.11681395f, -0.08656123f, -0.13363023f, -0.16084248f, 0.40335000f, 0.07488438f, 0.20546906f, 
    -0.17805658f, -0.08012642f, -0.00223634f, 0.13339448f, -0.00062395f, 0.20844558f, -0.14008108f, -0.17479526f, 
    -0.20371634f, 0.02212437f, 0.19304161f, 0.10705343f, -0.14861843f, -0.01355954f, -0.02250754f, 0.23189500f, 
    0.22963972f, -0.08744881f, -0.11343914f, 0.14539282f, 0.24329902f, 0.13920684f, -0.26679045f, -0.14029269f, 
    -0.11784390f, -0.05328572f, -0.06278946f, -0.08689031f, 0.05559351f, -0.06195787f, -0.05408337f, -0.01222988f, 
    0.09276794f, -0.19952928f, 0.11304991f, 0.24292658f, -0.02377796f, -0.07603241f, 0.22234382f, -0.12388227f, 
    0.02004639f, -0.10224522f, -0.04092427f, 0.00939609f, 0.43372995f, -0.11507487f, 0.06035001f, -0.09886632f, 
    0.02967507f, 0.01940980f, -0.03158674f, -0.03753690f, 0.04571047f, 0.13727391f, 0.03954984f, -0.02349178f, 
    0.01394071f, -0.22307301f, 0.04492466f, 0.20728886f, 0.00547679f, -0.07356934f, -0.04228595f, 0.02100914f, 
    -0.03763704f, 0.10280075f, 0.03032276f, -0.07343923f, 0.63674247f, -0.28936049f, 0.00252847f, 0.53685158f, 
    -0.14763245f, 0.00908751f, -0.00165802f, -0.00146833f, -0.05606263f, 0.08620616f, -0.17356023f, -0.02570268f, 
    -0.21814796f, -0.13127762f, 0.10086199f, -0.07318099f, -0.17928748f, -0.06330834f, 0.03997270f, -0.03464362f, 
    -0.04588807f, -0.20161125f, -0.13508825f, -0.32846066f, 0.08577441f, -0.09289356f, -0.26505744f, 0.43295574f, 
    0.14096187f, 0.11474045f, 0.08606818f, 0.26089457f, 0.25088811f, -0.00573313f, -0.11699481f, -0.13109307f, 
    0.22248265f, -0.03954867f, -0.10246968f, 0.17369352f, 0.09058537f, -0.05565188f, 0.01791230f, 0.15315230f, 
    -0.22508499f, 0.15483436f, -0.05366891f, 0.08734198f, 0.18269388f, -0.17575733f, 0.02048213f, 0.21363322f, 
    0.19628555f, 0.16063610f, -0.10200660f, 0.13122906f, -0.18515380f, 0.01849775f, 0.16529585f, 0.12757449f, 
    0.14751706f, -0.10482805f, 0.39857668f, -0.02306565f, -0.02191914f, -0.14796045f, -0.00220221f, 0.09285410f, 
    -0.07622457f, 0.08967668f, -0.07640633f, -0.02572753f, 0.08988777f, 0.06689237f, 0.33074364f, -0.02200333f, 
    0.03607406f, 0.00036986f, -0.08196878f, -0.10195743f, -0.15742902f, 0.09359834f, -0.03937541f, -0.03640321f, 
    0.36258706f, 0.41570002f, 0.06108159f, 0.03666979f, 0.06163906f, -0.03983323f, 0.17500743f, 0.09136595f, 
    -0.01819799f, -0.10752659f, 0.02165836f, -0.07022859f, -0.25952628f, -0.10283214f, -0.16772848f, 0.17166515f, 
    0.16940577f, 0.09958734f, -0.15529317f, 0.01125284f, -0.06709147f, 0.09497210f, 0.00734112f, 0.03229252f, 
    -0.01545196f, 0.21377207f, -0.03235611f, -0.07888446f, 0.06182488f, 0.11919703f, -0.00310520f, 0.10538229f, 
    -0.23981839f, -0.03261884f, 0.09189709f, -0.06913013f, -0.21322063f, 0.00963729f, 0.10260849f, 0.04913127f, 
    0.08248691f, 0.06701445f, 0.21669559f, 0.05661467f, 0.04103767f, 0.17628120f, -0.11544164f, 0.06426213f, 
    0.20244382f, 0.09399357f, -0.05091663f, -0.00346318f, 0.03719722f, -0.05907825f, -0.04623733f, -0.21368952f, 
    0.02528239f, -0.15769722f, -0.14495377f, 0.09033101f, 0.26705858f, -0.32592076f, -0.06707747f, 0.21419425f, 
    -0.04295123f, -0.08782267f, 0.17705888f, 0.08122858f, -0.12910768f, 0.01547029f, -0.04173700f, -0.08269217f, 
    -0.53393537f, -0.11645036f, 0.20180494f, -0.09781191f, 0.11259121f, -0.01459481f, 0.13289736f, -0.05561951f, 
    0.05485448f, 0.00991729f, -0.12450381f, -0.29342604f, 0.20161913f, 0.44585580f, 0.15375727f, 0.12140781f, 
    -0.09979666f, 0.00518965f, 0.20500207f, -0.05173119f, -0.06582695f, -0.01393384f, -0.33108255f, -0.05859604f, 
    -0.11187641f, 0.01074347f, 0.08988699f, 0.19214304f, -0.12728684f, 0.19608763f, 0.20861058f, -0.09752823f, 
    -0.06132634f, -0.13372670f, 0.23433499f, 0.11359212f, -0.11570755f, 0.48869053f, -0.02671858f, 0.02604480f, 
    0.01335081f, 0.09796458f, 0.16914319f, 0.00500165f, -0.01510089f, -0.05635959f, -0.00107608f, -0.00378136f, 
    -0.28679129f, 0.18422353f, 0.27419749f, 0.09970818f, 0.11586121f, 0.00736649f, -0.10467758f, 0.16513512f, 
    -0.10624551f, -0.15477581f, 0.14531760f, -0.15123057f, 0.09400722f, 0.05605162f, -0.11660789f, -0.02765208f, 
    -0.26055622f, -0.07928072f, 0.14416833f, 0.05203887f, -0.03869388f, -0.04049463f, 0.06213164f, -0.23613775f, 
    0.26942092f, 0.35931462f, 0.26031044f, 0.07072743f, -0.05313386f, -0.08113626f, 0.02711694f, 0.13720798f, 
    -0.03188575f, 0.25876290f, 0.29492456f, 0.15433952f, 0.07509580f, 0.12027424f, -0.11097613f, 0.23991403f, 
    -0.09054251f, -0.22734311f, 0.19618532f, 0.16782786f, -0.05652735f, 0.09946870f, 0.01309523f, 0.15548274f, 
    0.09266473f, -0.01115160f, -0.10131332f, -0.04666877f, 0.15684997f, -0.00563684f, 0.02714745f, 0.07677817f, 
    0.04244475f, -0.05868003f, 0.02414154f, -0.06473646f, -0.01640721f, -0.06647771f, 0.18082680f, -0.02011250f, 
    0.06489815f, 0.03041131f, 0.11538821f, 0.15116268f, -0.11771087f, 0.19107082f, -0.04686955f, 0.10252056f, 
    -0.28347534f, -0.17026791f, -0.29618329f, -0.43668994f, 0.01342481f, -0.17604122f, 0.01374289f, 0.26241565f, 
    0.09773985f, -0.10513784f, 0.02684817f, -0.04421572f, 0.30939895f, 0.00597400f, -0.06403271f, 0.43862894f, 
    -0.01431119f, -0.15936948f, -0.00914015f, 0.18775435f, 0.11509757f, 0.01996838f, 0.06468860f, 0.14272639f, 
    -0.00852712f, 0.30605724f, 0.01316156f, 0.01406073f, 0.03680612f, -0.09575637f, -0.02197382f, 0.00152835f, 
    -0.01203234f, -0.04793295f, 0.19965985f, -0.17282647f, 0.07472771f, 0.26280612f, -0.12563504f, -0.27912533f, 
    0.03491287f, 0.18703671f, 0.04003650f, 0.00777658f, -0.19598581f, 0.11512192f, -0.01027412f, 0.10779730f, 
    0.46158084f, -0.13793118f, -0.09500404f, 0.19847220f, -0.00067074f, -0.03813614f, 0.06458067f, -0.08773353f, 
    0.08608416f, -0.18099079f, -0.12935050f, -0.03127674f, 0.02366036f, 0.12695961f, 0.28539720f, -0.24103066f, 
    0.02857505f, -0.02251757f, -0.01146157f, -0.23718177f, -0.03968479f, 0.19433710f, 0.03306489f, -0.05325437f, 
    -0.30136985f, 0.09861839f, 0.15306580f, 0.26282045f, 0.10683915f, 0.00706421f, 0.06268246f, 0.01571097f, 
    -0.11224327f, 0.13320705f, -0.12157480f, -0.05608452f, -0.22900543f, -0.17500962f, -0.49994102f, -0.04729218f, 
    0.03744787f, -0.02908067f, -0.04270391f, -0.07967547f, 0.01081107f, 0.11699828f, -0.20488569f, -0.04207166f, 
    0.10104439f, 0.10925666f, 0.17633466f, -0.01912211f, 0.13531905f, 0.05847393f, 0.11183669f, -0.08162875f, 
    0.16337335f, 0.08580235f, 0.10326579f, 0.12819266f, -0.40139708f, 0.16346435f, -0.30681267f, -0.11835179f, 
    0.20512944f, 0.15037540f, 0.13628291f, -0.12130179f, -0.07681568f, 0.12745826f, 0.14128090f, 0.19664560f, 
    0.13180119f, 0.11470060f, -0.10570882f, 0.08426936f, -0.21550685f, 0.14469358f, -0.10637528f, 0.05186244f, 
    -0.09319604f, -0.18128994f, 0.12717719f, 0.13415357f, -0.41709125f, -0.45824301f, -0.45852011f, 0.15087450f, 
    0.14518100f, 0.01683888f, -0.27775028f, 0.12431222f, 0.09134320f, 0.19356801f, -0.01023105f, 0.17147650f, 
    -0.59931791f, -0.21906842f, 0.01470045f, 0.04784632f, 0.19559124f, -0.02965664f, 0.06081574f, -0.01516052f, 
    -0.05506075f, 0.05168802f, -0.06950099f, 0.06729604f, -0.17964849f, 0.11632356f, -0.05086092f, 0.15276840f, 
    0.05454174f, 0.30873179f, 0.00658787f, 0.07543060f, 0.06441355f, 0.08038783f, -0.04817064f, -0.03317190f, 
    0.28452086f, -0.14342667f, -0.01523486f, -0.33168426f, 0.10917385f, 0.01208187f, -0.18007378f, 0.02067911f, 
    0.04760941f, 0.02737728f, 0.14786270f, -0.08604921f, -0.29899657f, 0.01289791f, 0.25847331f, -0.47179890f, 
    0.06831498f, -0.20817031f, -0.10272135f, 0.20122579f, -0.03587364f, -0.13612829f, 0.00513760f, -0.07605949f, 
    0.27364385f, 0.03301996f, 0.20728554f, -0.03619635f, -0.00368066f, -0.05052247f, 0.24661423f, -0.27787784f, 
    0.04898036f, 0.13448197f, -0.08792771f, 0.00065249f, 0.19807355f, 0.22593220f, -0.18005286f, -0.23524947f, 
    0.02436259f, -0.03873334f, 0.04540332f, 0.11570870f, -0.06046651f, -0.07153763f, 0.01267865f, -0.01450445f, 
    0.15894455f, 0.05085898f, 0.27334228f, 0.04738997f, -0.00398519f, -0.09215638f, -0.01789709f, -0.13025668f, 
    0.00098005f, 0.19064289f, -0.06664762f, -0.00885423f, 0.18257138f, 0.10220926f, 0.00103596f, 0.07912890f, 
    -0.10411803f, -0.14173605f, -0.04389337f, 0.01972004f, -0.03274123f, 0.04338727f, -0.04016738f, 0.09902773f, 
    -0.25727430f, -0.16556506f, -0.19631393f, 0.16036700f, 0.03612681f, -0.03063355f, -0.22135171f, -0.06465935f, 
    0.03386160f, -0.00028243f, 0.15343307f, 0.24111430f, -0.24857110f, -0.02124118f, -0.19104262f, 0.12510216f, 
    -0.22952653f, -0.04460451f, 0.00638271f, -0.04589915f, 0.10814469f, 0.07671607f, -0.06271192f, 0.28391925f, 
    0.78018355f, -0.38272858f, -0.09554347f, 0.03424945f, -0.17246012f, 0.21775018f, 0.15833521f, -0.00259337f, 
    -0.09586481f, 0.02965060f, -0.00377425f, 0.06466999f, 0.10269602f, 0.26255822f, 0.68363786f, -0.20820594f, 
    -0.11519498f, -0.11128078f, 0.14615744f, -0.03761411f, -0.19750337f, 0.01532935f, -0.25540265f, 0.27455172f, 
    0.14496823f, 0.30686319f, 0.05530300f, 0.19029963f, 0.06466422f, 0.05136419f, -0.00977485f, 0.09237120f, 
    -0.10385182f, 0.15734233f, 0.12440819f, 0.06218526f, 0.38360569f, -0.23147927f, 0.03778243f, -0.13301037f, 
    -0.06964206f, -0.02234234f, -0.02562018f, -0.20355694f, 0.06669138f, 0.12755649f, -0.13558745f, 0.00760927f, 
    -0.32648784f, -0.14713335f, 0.23209155f, -0.07069664f, 0.00478046f, 0.07016588f, 0.14808771f, 0.10421763f, 
    0.12392862f, -0.00914777f, -0.05766714f, 0.01755704f, 0.23673812f, 0.03933151f, 0.06838865f, -0.01612636f, 
    0.00642425f, -0.08933815f, 0.12144782f, -0.22864623f, -0.16071552f, -0.02646589f, 0.04738574f, 0.03371978f, 
    0.30204174f, -0.02686593f, 0.27027020f, 0.17144288f, 0.04395256f, 0.20974490f, 0.08726811f, -0.08711579f, 
    -0.06341321f, -0.00305243f, 0.06792429f, -0.12977736f, 0.23083553f, -0.00677664f, -0.08040982f, -0.16105652f, 
    0.01972337f, 0.03291092f, 0.01544663f, -0.05870143f, 0.08073413f, 0.11857612f, -0.11808995f, 0.00066235f, 
    -0.16995308f, -0.08489288f, 0.25494599f, 0.29666749f, 0.00711415f, 0.02456962f, -0.00864204f, -0.13140869f, 
    0.01512924f, 0.20621355f, -0.14781342f, -0.01385521f, -0.18074878f, 0.04713386f, -0.07268432f, 0.52026224f, 
    -0.20338374f, 0.14521167f, 0.21021645f, 0.19471663f, -0.04429794f, -0.05802466f, -0.03042709f, -0.04730391f, 
    -0.43115506f, 0.25748414f, -0.00733416f, -0.07278534f, -0.08189064f, -0.05223284f, 0.00907437f, 0.04605296f, 
    0.17357621f, 0.17042698f, 0.03795175f, 0.05668231f, -0.33286321f, 0.02655666f, -0.21498342f, -0.25105509f, 
    -0.06141229f, 0.07325284f, 0.14418015f, -0.09390034f, 0.04288848f, 0.01932019f, 0.15902728f, -0.02082143f, 
    -0.16859399f, 0.03470567f, 0.00733818f, -0.24672684f, -0.11556506f, 0.12631591f, 0.03737663f, 0.11764018f, 
    0.11959941f, -0.11461066f, 0.06059838f, 0.12920360f, -0.20591369f, -0.11169899f, 0.02143094f, 0.06962489f, 
    0.03616470f, -0.25943401f, -0.00789652f, -0.08666246f, 0.16591218f, -0.10497412f, 0.00649996f, 0.17664669f, 
    -0.32206306f, 0.07944782f, 0.02676860f, 0.06563659f, 0.25727904f, -0.01733665f, 0.00644929f, 0.09527454f, 
    -0.09714661f, 0.18977772f, 0.08208421f, -0.08187860f, -0.21392718f, -0.00563878f, 0.04025216f, 0.17430884f, 
    0.11977988f, -0.01713136f, -0.10270094f, 0.11297468f, -0.02157817f, -0.03035141f, -0.04981488f, 0.06829081f, 
    0.12745298f, -0.04334255f, 0.19721609f, -0.17654462f, -0.11566634f, 0.14163962f, 0.07660783f, 0.07363207f, 
    -0.10755837f, 0.07143450f, -0.03121884f, 0.23058617f, -0.13705960f, 0.04475456f, 0.40017286f, -0.21531436f, 
    -0.09532628f, 0.07807266f, 0.15204524f, 0.05916743f, 0.02628488f, 0.06407049f, 0.05819961f, 0.24977066f, 
    0.58421707f, 0.14200585f, 0.20435013f, 0.36479098f, -0.06867047f, 0.03955742f, -0.11250128f, 0.04618769f, 
    -0.23582006f, -0.05068036f, -0.11281048f, 0.06149834f, -0.25231507f, -0.09059947f, 0.24774918f, -0.04193169f, 
    -0.17414740f, -0.08255924f, 0.00967633f, 0.04774467f, -0.02876928f, -0.00881012f, 0.01597187f, 0.00480809f, 
    0.38706040f, 0.03091735f, -0.00986024f, -0.11578304f, 0.28804606f, 0.19212605f, -0.13258122f, -0.02394871f, 
    0.15073252f, -0.15315123f, -0.02025306f, -0.05615274f, -0.55538791f, -0.06616373f, -0.02360530f, -0.03013958f, 
    -0.12055440f, 0.14943895f, -0.04196814f, -0.03720725f, -0.09294613f, -0.12083752f, -0.00760562f, 0.07892758f, 
    -0.18048251f, 0.13039343f, -0.02746935f, -0.01251771f, -0.11482237f, -0.05743444f, -0.11881432f, -0.11743805f, 
    0.00207824f, 0.13486205f, -0.01387900f, -0.06034962f, -0.11278425f, 0.02487120f, 0.17653005f, -0.53403819f, 
    0.01662041f, 0.06278344f, 0.19777073f, 0.19317460f, 0.02954478f, 0.04933225f, 0.02798680f, 0.20360503f, 
    -0.12407482f, 0.11410729f, -0.21684687f, -0.41976753f, 0.05945034f, 0.05811783f, -0.06880816f, -0.07464192f, 
    0.00035433f, 0.04152162f, -0.20363387f, -0.05130509f, 0.23196505f, 0.34104180f, 0.11783379f, -0.12901908f, 
    -0.10843319f, -0.07616942f, -0.07357598f, -0.00963279f, -0.00682300f, 0.01608251f, -0.04954520f, 0.11707796f, 
    0.37756741f, -0.06120350f, 0.21785128f, 0.21225181f, -0.09525855f, 0.09185657f, -0.00906370f, -0.09936763f, 
    0.12709150f, 0.12779722f, -0.06051153f, -0.03057980f, 0.59629709f, -0.34873050f, 0.19382337f, 0.04641015f, 
    0.15332071f, 0.07150066f, -0.08284507f, 0.00910583f, -0.03277254f, 0.02834530f, 0.07414699f, 0.12451562f, 
    0.14889669f, 0.23688631f, 0.00680128f, 0.02223705f, -0.13908006f, -0.13220023f, -0.13224418f, 0.10997511f, 
    0.03760800f, 0.09960229f, -0.02549942f, -0.09617857f, 0.48751900f, -0.21266048f, 0.08513697f, 0.16357867f, 
    -0.03265453f, -0.00758612f, 0.00684680f, -0.07417227f, 0.01689160f, 0.02403106f, 0.18436593f, 0.24426557f, 
    -0.08990670f, -0.03161816f, 0.17445502f, -0.09334092f, -0.04312000f, 0.03132501f, -0.03157078f, -0.06887336f, 
    0.02310800f, -0.07900689f, -0.04082002f, 0.00373864f, -0.00322769f, 0.11779699f, -0.07231023f, -0.10623207f, 
    0.03943844f, -0.00608646f, 0.04903038f, -0.09020464f, -0.12551230f, -0.06572985f, -0.06814084f, 0.09718337f, 
    0.47279698f, -0.08154944f, -0.00087747f, 0.05391371f, 0.01818290f, 0.00882496f, -0.01311287f, 0.09656174f, 
    0.12216946f, -0.12292632f, -0.08725174f, -0.03052156f, 0.41486385f, 0.40986270f, 0.13905838f, -0.15130590f, 
    -0.24231569f, 0.14919971f, 0.01532446f, -0.00277288f, -0.01151910f, -0.05606183f, -0.06070740f, -0.12327535f, 
    0.00881383f, -0.00202977f, -0.26082996f, -0.26313195f, -0.07859819f, 0.03440129f, -0.06554145f, 0.08900877f, 
    -0.16124117f, 0.06527458f, 0.02438493f, 0.07535291f, -0.06643038f, 0.25623772f, 0.22334781f, 0.23073536f, 
    -0.03358455f, -0.03426509f, -0.19278631f, -0.12302496f, -0.02057621f, 0.04877059f, 0.06720959f, 0.01363679f, 
    -0.38674694f, 0.05626290f, 0.14879185f, 0.12441070f, -0.09937658f, -0.06284524f, 0.16625534f, 0.02414053f, 
    -0.00040731f, 0.09034126f, 0.03447998f, 0.11855846f, 0.32561946f, -0.12053499f, 0.00073250f, -0.12271560f, 
    0.09320008f, 0.00224976f, 0.18230885f, 0.03493259f, 0.06632116f, 0.05470886f, 0.05943562f, 0.04380231f, 
    0.16112658f, -0.17507796f, 0.05155498f, -0.06901093f, 0.00031647f, 0.18555526f, 0.03501124f, 0.14678527f, 
    0.14555573f, -0.08194015f, 0.06567612f, 0.05521948f, -0.02698110f, -0.32384893f, -0.24117158f, 0.09356478f, 
    0.06041710f, -0.10699849f, -0.10541560f, -0.00099809f, 0.04469081f, -0.00899823f, 0.04054563f, -0.04068525f, 
    -0.12110506f, -0.00819891f, 0.25331113f, 0.24776244f, -0.11329438f, 0.01975155f, 0.12362137f, -0.02962906f, 
    -0.03515581f, 0.02072726f, 0.05289750f, 0.03363876f, -0.11019276f, -0.20412956f, 0.00323753f, 0.14031722f, 
    0.08299369f, 0.13325456f, 0.05766227f, 0.11074160f, 0.05048475f, 0.10881077f, -0.02820336f, -0.01328748f, 
    -0.39330623f, 0.30809554f, 0.01784855f, -0.26256099f, 0.06764684f, 0.01115708f, -0.05510205f, 0.05977192f, 
    0.10707323f, 0.05478031f, 0.01016985f, 0.19475888f, -0.70618647f, 0.31870872f, -0.39784837f, -0.12938812f, 
    0.07880541f, -0.00311229f, 0.02833766f, 0.01988928f, 0.04566969f, 0.11025436f, 0.07300826f, -0.05155244f, 
    -0.02725113f, 0.00843436f, 0.18397634f, -0.19636199f, -0.03686249f, 0.06264296f, 0.07847000f, -0.09692663f, 
    0.06765731f, 0.04592543f, 0.06462634f, 0.10813323f, -0.47041017f, 0.26426840f, 0.01849686f, -0.18920107f, 
    0.12758115f, -0.10374239f, -0.09267753f, 0.07671455f, -0.00386132f, -0.09590729f, -0.03446782f, -0.01100849f, 
    0.03539865f, -0.05496709f, -0.10685988f, 0.15295513f, 0.22001854f, -0.02148745f, 0.08063456f, 0.06040092f, 
    -0.07586221f, 0.13818897f, 0.00366771f, 0.05883497f, 0.11544240f, 0.03441041f, 0.32961604f, 0.28935310f, 
    -0.00328551f, 0.07842317f, -0.08912618f, -0.03471324f, 0.15665123f, 0.08617990f, 0.01390664f, 0.04066379f, 
    -0.50226313f, -0.00908585f, 0.10442779f, 0.00258090f, 0.06078167f, -0.08632354f, -0.07226470f, 0.11088177f, 
    0.02794158f, 0.04352545f, 0.17129919f, 0.18640225f, -0.19449513f, -0.17011881f, 0.15140152f, 0.04635578f, 
    0.01500258f, -0.00552240f, -0.10335691f, 0.08120300f, 0.17204934f, 0.01814375f, -0.00761417f, 0.14898905f, 
    0.02740899f, -0.01523910f, 0.50888282f, 0.23647575f, 0.00282388f, 0.04874745f, 0.03029444f, -0.10509742f, 
    0.00858710f, -0.02540318f, 0.05494666f, 0.15029857f, 0.02972904f, -0.03788647f, -0.05263058f, -0.06798334f, 
    -0.13521709f, 0.02989021f, 0.07124054f, 0.02792002f, 0.05787909f, -0.03188039f, 0.03911019f, 0.07172682f, 
    -0.34981769f, 0.11901956f, 0.31791610f, -0.06095250f, 0.04595604f, 0.08422727f, -0.01117173f, 0.07664753f, 
    0.15865001f, 0.00215607f, 0.09621749f, 0.09935030f, -0.03814959f, -0.27238813f, -0.01777112f, 0.03255293f, 
    -0.09167808f, 0.07455418f, 0.03778072f, 0.01365103f, -0.03519215f, -0.08568706f, 0.04054347f, -0.18044463f, 
    0.05829581f, 0.24001613f, 0.06885090f, -0.06430192f, 0.04785939f, 0.13240559f, -0.03059003f, 0.19226368f, 
    0.15126559f, 0.11158382f, 0.12727766f, 0.12968217f, 0.07151383f, 0.06779883f, 0.05460883f, -0.42235306f, 
    0.18742582f, 0.21667582f, 0.03265914f, 0.09770137f, 0.04591620f, 0.19171754f, -0.11950555f, 0.15827306f, 
    -0.10632998f, -0.13475457f, 0.01209418f, -0.18723817f, 0.04141275f, 0.02031890f, 0.09715089f, -0.07373597f, 
    0.04141789f, -0.00862227f, -0.17696467f, -0.18458214f, 0.00814322f, 0.49023944f, 0.32427627f, -0.19595063f, 
    -0.07913783f, 0.20093937f, 0.16544165f, -0.00711282f, 0.09802358f, -0.08845403f, 0.06537857f, 0.11604799f, 
    -0.41453767f, 0.01956094f, -0.10437921f, -0.19893955f, -0.07420932f, 0.16860014f, 0.05464317f, 0.15169275f, 
    0.24249251f, 0.01800437f, 0.00301353f, 0.02254611f, 0.00510992f, 0.13018508f, 0.01603573f, 0.43449464f, 
    0.01080806f, 0.01659996f, -0.11223877f, 0.17359968f, 0.02464336f, 0.06702547f, 0.01306017f, -0.12474801f, 
    -0.22151685f, 0.65596759f, 0.00104806f, -0.44079959f, 0.08413988f, -0.15135282f, 0.04181812f, 0.23967296f, 
    0.13016720f, -0.02807818f, 0.03434443f, -0.05589537f, 0.23023452f, -0.05753726f, -0.04984239f, 0.01907815f, 
    -0.00264473f, 0.16178332f, 0.04703562f, -0.00555515f, -0.17582999f, -0.10095043f, -0.08933963f, 0.19986482f, 
    -0.13861267f, -0.25247946f, 0.17748983f, 0.30008140f, 0.16204147f, -0.04372342f, 0.02710702f, -0.05659410f, 
    0.02530684f, 0.00493916f, -0.13117169f, 0.04987466f, -0.14027546f, -0.03545912f, 0.25134945f, -0.25384498f, 
    -0.05167444f, 0.03061774f, -0.07897466f, -0.11807951f, -0.05262008f, 0.02653526f, 0.05491228f, -0.05420084f, 
    0.22013627f, -0.01836406f, -0.01996523f, 0.18800300f, -0.12913717f, -0.17859714f, 0.06991119f, 0.10199584f, 
    0.04288496f, -0.03607998f, -0.06541898f, 0.06562832f, -0.09919289f, 0.39113173f, 0.21775025f, -0.66328913f, 
    -0.09186701f, 0.21150532f, 0.00181606f, 0.03877841f, 0.07021594f, 0.11093112f, -0.04677585f, -0.06110340f, 
    0.28199086f, -0.11973633f, 0.20488654f, -0.33716965f, -0.30469254f, -0.01480817f, -0.16446637f, -0.03841484f, 
    -0.07922997f, -0.08436258f, 0.01225595f, 0.02647264f, -0.35840702f, 0.37690493f, 0.01372498f, 0.32343447f, 
    0.01519702f, -0.01878402f, 0.00934473f, 0.04923506f, 0.00406029f, -0.01226724f, 0.17307842f, -0.01672899f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03726577f, 0.02516875f, 0.04290532f, 0.02754480f, -0.03846628f, 0.01296343f, 0.16332465f, -0.07786774f, 
    -0.06206230f, -0.06687689f, 0.01434975f, 0.13508643f, -0.02246751f, -0.06523412f, 0.25905722f, 0.14992942f, 
    0.01755243f, -0.02506043f, -0.05919946f, -0.02223847f, 0.09171016f, 0.04822009f, 0.03868936f, 0.07755017f, 
    -0.14679825f, -0.12246998f, 0.06929324f, -0.04187227f, -0.02157910f, -0.02215629f, 0.07598530f, 0.01571977f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10987375f, 0.04157225f, 0.28005108f, -0.35366386f, 0.04317085f, 0.03514114f, -0.60554588f, -0.46515289f, 
    0.03851728f, 0.03622462f, -0.07876527f, -0.95931655f, -0.03169176f, -0.48160037f, -0.41317573f, 0.13637303f, 
    0.15988286f, -0.01580838f, 0.56072241f, 0.05307328f, -0.73900765f, -0.19680457f, 0.22698297f, -0.23065855f, 
    0.58546329f, -0.08346350f, -0.01207463f, 0.15525723f, 0.22551414f, 0.20515592f, -0.12275751f, 0.57645762f, 
    0.14794077f, -0.00582666f, 0.24598812f, -0.26951981f, 0.03875305f, 0.11232772f, -0.47676063f, -0.42936498f, 
    0.27844501f, -0.11486880f, 0.46604580f, 0.45210010f, -0.32986236f, -0.06547038f, 0.29071122f, 0.34341517f, 
    0.36320654f, 0.14760795f, -0.74970627f, -0.15763478f, -0.62645036f, -0.46275803f, -0.01576979f, 0.25001982f, 
    0.13588670f, 0.07595992f, -0.20655690f, 0.20662384f, -0.17197499f, 0.19536206f, -0.13640551f, -0.19506736f, 
    -0.02793724f, 0.11354186f, -0.88865131f, 0.24296902f, 0.03992233f, 0.00830384f, -0.18646479f, 0.12853156f, 
    0.18915711f, 0.04202291f, -0.10519327f, -0.48538542f, -0.57805628f, -0.01372978f, -0.02880410f, 0.33421987f, 
    -0.23355794f, 0.13101561f, 0.09689032f, 0.05972598f, -0.01495262f, 0.50519776f, -0.02754751f, 0.36257079f, 
    0.04330523f, 0.01950628f, -0.04782961f, 0.68688142f, -0.29518551f, 0.19768547f, -0.78670257f, -0.11447274f, 
    -0.40201819f, -0.17534240f, 0.39282116f, 0.12767556f, 0.12587105f, -0.09905352f, 0.37152198f, -0.22455727f, 
    0.01897475f, 0.02245357f, 0.24869634f, -0.16636455f, -0.64692473f, -0.79372281f, 0.40408143f, -0.20428133f, 
    -0.43818435f, 0.00001484f, 0.32347929f, 0.11501769f, 0.29036841f, -0.25289384f, 0.29071718f, -0.47832420f, 
    0.06645963f, 0.18435207f, 0.30017480f, -0.64196992f, 0.12827091f, -0.38472623f, -0.02824028f, -0.36532301f, 
    0.34538311f, 0.05722398f, 0.10952214f, 0.22434746f, -0.12685607f, 0.00376013f, 0.27320570f, 0.09763087f, 
    -0.09327016f, -0.15039766f, 0.21716778f, -0.32750604f, 0.02127363f, 0.25028861f, -0.33911052f, 0.23174898f, 
    -0.14878505f, 0.01056293f, 0.12426537f, -0.03760487f, -0.39615330f, -0.48640022f, -0.14082384f, -0.34736869f, 
    0.05569121f, 0.27723065f, 0.09830676f, -0.26601955f, 0.13048747f, -0.71519703f, 0.37937459f, -0.00382820f, 
    0.09069395f, -0.00006367f, 0.12703486f, -0.47862041f, 0.06216645f, -0.09280096f, -0.18821785f, 0.38234740f, 
    -0.18655926f, 0.01459007f, -0.36718240f, -0.07616538f, 0.40544289f, 0.24520230f, 0.04003072f, -0.35911363f, 
    -0.04008900f, 0.05355152f, 0.13636565f, -0.07209636f, 0.37228307f, -0.45094916f, 0.30448812f, 0.21502638f, 
    -0.17679116f, 0.13132204f, -0.56896752f, 0.21706970f, 0.30935654f, -0.19258030f, 0.15551701f, -0.11550203f, 
    -0.08510088f, 0.11547747f, 0.15671375f, 0.32612711f, 0.10080482f, -0.17277482f, 0.33459964f, -0.51417267f, 
    0.39152932f, -0.06745081f, -0.36144865f, -0.49818534f, 0.11555325f, 0.05887220f, -0.13965371f, -0.59749460f, 
    0.35408604f, 0.00199563f, -0.63407266f, -0.10840234f, 0.05069525f, 0.51107442f, -0.49898186f, -0.01757525f, 
    -0.38126361f, -0.03909163f, -0.07946020f, -0.07166656f, 0.30162421f, 0.43212241f, -0.22422002f, 0.20590992f, 
    -0.64599037f, -0.00386329f, 0.01589664f, 0.21266401f, 0.02532612f, -0.07653628f, -0.31449008f, 0.41887721f, 
    -0.33107013f, -0.08059848f, 0.44557443f, 0.39907402f, 0.22670452f, 0.34372559f, -0.47310489f, -0.58988786f, 
    -0.26186696f, 0.15529300f, 0.21830699f, 0.04521957f, 0.25030938f, 0.14203028f, -0.23519731f, -0.34359980f, 
    0.05518606f, 0.24002670f, 0.00162519f, -0.14776573f, 0.30005866f, 0.18236449f, -0.25729957f, -0.10990804f, 
    0.42157060f, -0.08385349f, -0.23932260f, -0.24997097f, -0.13359073f, -0.07259367f, -0.19639678f, 0.49948123f, 
    0.34471160f, -0.11884987f, -0.21948346f, 0.29573622f, -0.67538053f, 0.44978097f, 0.29271752f, -0.40007070f, 
    -0.29629448f, -0.04153701f, -0.59224939f, -0.11954524f, -0.04810378f, -0.23913388f, 0.30304867f, -0.02068543f, 
    0.29761401f, -0.44858718f, -0.37335491f, -0.22840156f, -0.48427042f, 0.37523299f, -0.44096071f, 0.05969869f, 
    -0.34095186f, 0.10951273f, -0.05487516f, -0.44045606f, -0.20287043f, -0.09342245f, 0.13366918f, 0.08941054f, 
    -0.38275483f, -0.11296377f, -0.32181743f, 0.24173667f, 0.24668397f, 0.27278978f, 0.27881807f, 0.29659215f, 
    -0.34200725f, -0.12253450f, -0.19649829f, 0.08471322f, 0.28478441f, 0.13036627f, -0.81512421f, 0.03171067f, 
    -0.72220063f, 0.47668481f, 0.35295978f, -0.14414351f, -0.28599733f, 0.17463301f, -0.16493176f, 0.59686834f, 
    -0.02526588f, 0.07557675f, -0.59929663f, 0.17249991f, -0.09598012f, 0.13899714f, -0.24134958f, -0.62689489f, 
    -0.06633167f, -0.13892466f, -0.12541734f, 0.34766075f, -0.46565357f, -0.07654274f, 0.47952843f, 0.28741431f, 
    -0.09861187f, 0.01777760f, -0.36225510f, -0.12728262f, 0.52286547f, -0.01465493f, -0.00132659f, 0.12387142f, 
    -0.49081954f, -0.89756489f, 0.34555045f, -0.48664379f, 0.28937611f, -0.70894027f, 0.31503138f, 0.33003643f, 
    -0.15405995f, -0.04830439f, 0.04797680f, -0.15589279f, 0.06053027f, -0.15807547f, 0.35430494f, 0.06229993f, 
    -0.40611714f, -0.12057488f, -0.91161972f, 0.35075402f, 0.40806121f, -0.32543549f, -0.15491083f, 0.16429070f, 
    0.29441741f, -0.09315100f, 0.03641327f, 0.08140621f, -0.13539797f, 0.53765833f, 0.33757374f, 0.05507185f, 
    0.20753564f, -0.23172595f, 0.18867998f, -0.66581887f, -0.30029768f, -0.24462543f, -0.16895314f, -0.90555912f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01005892f, -0.07273221f, 0.02689031f, 0.14830764f, 0.15552406f, -0.10538276f, 0.05178451f, 0.01993592f, 
    0.01588636f, 0.07201085f, 0.01729070f, 0.20904291f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
