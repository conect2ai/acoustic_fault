#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.42353070f, 0.43457648f, -1.41200185f, 0.85314244f, -0.18879390f, 0.26926067f, 0.07136638f, 0.05736703f, 
    0.32709944f, 1.16451597f, 0.60284346f, 1.08926070f, 0.15945973f, -0.55049288f, 0.80017608f, -0.32528475f, 
    -0.10676980f, -0.05648562f, -0.63528460f, -0.99879408f, -0.14942123f, 0.84538800f, 1.31367052f, 0.79861730f, 
    0.29571933f, 0.43559086f, 0.39754823f, 0.54446810f, 0.28856692f, -0.23594646f, -1.24563313f, 0.56829578f, 
    0.85425425f, 0.19243784f, 0.38308921f, 0.79844832f, 0.20437799f, 0.88105595f, 0.37642810f, -1.23777974f, 
    -0.58449721f, -1.31274199f, 0.09070829f, 0.57287383f, 0.24097298f, -1.08758473f, -0.66848969f, -1.01182878f, 
    -0.62789881f, 0.19090083f, 0.76633447f, -0.02108365f, 0.20699131f, -0.24901570f, 0.43516630f, 1.29463005f, 
    -0.03567976f, -0.47327396f, -0.70874715f, -0.51050228f, -0.55539018f, -0.69586194f, -0.45737904f, 1.07250226f, 
    1.06681168f, 0.75666708f, 0.50676489f, 0.99740773f, -0.28878650f, 0.27473664f, 0.39632964f, 0.25271443f, 
    0.14104062f, -0.85879409f, -0.71060818f, -0.82564360f, 1.38089955f, -0.65642059f, -0.44940820f, 0.36081532f, 
    0.09713003f, -0.85960966f, 0.92249763f, -0.55764437f, -0.19980088f, 0.31069890f, -1.01069129f, 0.87403601f, 
    -0.54112172f, -0.96545517f, -1.46650374f, 1.02857113f, -0.18795064f, 0.20956695f, 0.39798853f, -0.56406105f, 
    -0.44444722f, 0.13686985f, 0.21068819f, -0.91403496f, -0.70984131f, 0.77026200f, 0.97635186f, -0.74472237f, 
    -0.33002815f, 0.70732743f, -0.05690822f, 0.52969205f, -0.07488604f, -0.53010321f, 0.99627191f, -1.20019031f, 
    0.38230854f, 0.09730481f, 0.31444201f, -0.07561500f, -0.13943198f, -0.97672617f, -0.68556398f, -0.67127824f, 
    0.63331574f, 1.07232475f, -0.27971354f, -0.03533603f, -0.41845354f, -0.90482044f, -1.20788848f, -1.13301730f, 
    -0.97605497f, -0.26911026f, -1.07725167f, -0.45209533f, -0.44734859f, -0.27531064f, 0.00270506f, -0.57263893f, 
    -1.54114962f, -0.68246919f, -1.06069303f, -0.34055349f, -0.09335373f, 0.35086051f, 0.42388007f, 0.51972467f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12200350f, 0.98305851f, 0.32640567f, 0.32007968f, 0.22109659f, 0.27082556f, 0.07623669f, 0.34255850f, 
    0.03951219f, 0.11750851f, 0.31246954f, 0.18204762f, 0.16667058f, 0.08401158f, -0.20411544f, 0.26759470f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.42555383f, -0.23286329f, 0.14771259f, -0.02674007f, -0.08686190f, 0.09026892f, -0.35961309f, -0.01958216f, 
    -0.13103360f, -0.55077773f, 0.15229972f, -0.35626882f, -0.05050716f, 0.23977752f, 0.31803453f, -0.19561510f, 
    -0.10684887f, 0.11807528f, 0.20395261f, -0.10433786f, 0.45622823f, -0.19406444f, -0.21208175f, -0.03911075f, 
    0.30733660f, -0.06432804f, -0.02846477f, 0.25268343f, 0.05011898f, -0.10638746f, -0.04285285f, -0.01420845f, 
    0.24224566f, 0.03185109f, 0.19221751f, 0.19289817f, 0.40482423f, 0.31053740f, -0.04171351f, -0.06808939f, 
    -0.05674161f, 0.08150733f, -0.06297975f, -0.08272742f, -0.28110608f, 0.07814610f, -0.12792893f, -0.05361483f, 
    -0.52599317f, 0.23025216f, -0.04487707f, -0.22199187f, 0.02449710f, 0.17814040f, 0.24614403f, -0.07061794f, 
    0.05481088f, -0.05491439f, 0.34007668f, 0.10678013f, 0.01465775f, 0.03272564f, 0.08261885f, 0.01742202f, 
    -0.01467612f, -0.16603848f, -0.00461874f, 0.13249689f, 0.23087640f, -0.04910310f, 0.09089516f, -0.05838655f, 
    0.10680133f, 0.11076697f, 0.09644575f, 0.10561278f, 0.09023441f, -0.09537473f, -0.25587568f, -0.19418098f, 
    0.04276342f, -0.01687997f, -0.15219516f, 0.22990580f, 0.01010188f, 0.15849160f, -0.13837612f, -0.05238199f, 
    0.08415201f, -0.05615009f, 0.24581502f, -0.37895319f, -0.46985775f, -0.18769565f, -0.05177183f, -0.00289477f, 
    -0.10998296f, 0.03428652f, -0.07955752f, 0.10749087f, 0.14818186f, -0.05242615f, 0.00680773f, -0.14701322f, 
    0.15226941f, -0.10315443f, 0.09962931f, -0.18697284f, 0.62089318f, 0.10129581f, -0.40203294f, 0.02093656f, 
    0.07659081f, 0.02857073f, -0.17503911f, 0.25341070f, -0.06763056f, -0.02510106f, 0.31172073f, 0.43655747f, 
    0.18980774f, -0.14084755f, -0.09465778f, -0.04647027f, 0.21202753f, 0.21681480f, -0.85060567f, -0.17703505f, 
    -0.12946586f, -0.26109847f, -0.01242697f, -0.38173801f, 0.16849136f, -0.01946016f, 0.21591920f, 1.01492238f, 
    -0.33853549f, -0.12888262f, -0.08842000f, 0.01088305f, -0.34295109f, -0.01388433f, -0.14099354f, 0.02739071f, 
    0.03245356f, -0.09691945f, -0.02324704f, -0.09641835f, -0.08054232f, 0.05258431f, 0.06677382f, 0.02093140f, 
    0.06393569f, 0.02934571f, 0.06178394f, 0.02910567f, -0.06100785f, -0.07556342f, 0.03939746f, -0.05427315f, 
    -0.01707064f, -0.04131000f, -0.03452833f, -0.01266900f, 0.03751461f, -0.02866098f, -0.09139206f, 0.03707602f, 
    -0.05776744f, -0.06696928f, 0.00783657f, -0.01396187f, -0.05327322f, -0.03573775f, -0.01425065f, -0.09430313f, 
    -0.00292357f, -0.09627840f, -0.07308763f, -0.03512806f, -0.09895346f, -0.06042727f, 0.03709284f, 0.03708205f, 
    -0.04437953f, 0.02482322f, -0.03298392f, -0.02524879f, -0.04848154f, -0.05464205f, -0.06232892f, 0.03763848f, 
    -0.00582680f, 0.01710153f, -0.02702874f, -0.04339407f, -0.04171701f, -0.02228729f, 0.03398618f, -0.01977546f, 
    0.03388320f, -0.01875507f, -0.06226194f, 0.03449756f, 0.00134169f, 0.04299151f, -0.07908896f, -0.06139819f, 
    -0.00018915f, -0.08951151f, 0.00793151f, -0.02817740f, 0.04180798f, -0.06831092f, 0.01701685f, -0.03004995f, 
    -0.07233640f, 0.05282311f, 0.03240851f, -0.00212636f, -0.02219009f, 0.02856285f, -0.04932998f, -0.02682963f, 
    0.06250761f, -0.00483097f, 0.04571456f, -0.04174253f, -0.08014253f, -0.03903489f, -0.01573809f, -0.07111853f, 
    0.06866892f, 0.06256476f, -0.05449054f, 0.05388711f, -0.05873516f, -0.03490010f, 0.03945301f, 0.01847164f, 
    -0.06396493f, -0.09490775f, 0.06792660f, 0.02575261f, -0.02819648f, -0.07968313f, -0.01388983f, 0.04776552f, 
    -0.04300763f, 0.01529536f, 0.01293392f, 0.02829541f, 0.00832119f, 0.01538006f, 0.00456468f, -0.06012137f, 
    0.04774111f, -0.05692859f, 0.01633570f, -0.07187137f, 0.05132480f, -0.08952413f, -0.01198341f, -0.06876047f, 
    -0.02363637f, -0.08588851f, -0.06440295f, -0.04327875f, -0.01892100f, 0.06304538f, -0.00078561f, -0.06542944f, 
    0.07864606f, -0.08137955f, 0.05917682f, -0.01208534f, -0.08583345f, -0.05120113f, 0.06353300f, -0.00892871f, 
    -0.08148935f, -0.04338278f, -0.10710267f, -0.01048755f, 0.03102226f, 0.06013646f, 0.06289825f, -0.03764482f, 
    -0.41724640f, -0.24468602f, 0.51680154f, -0.00111744f, 0.01334222f, -0.36320782f, 0.11968489f, -0.04201154f, 
    0.22836863f, 0.45221785f, 0.36770114f, 0.39231673f, 0.05485597f, 0.09014110f, 0.19754344f, 0.31508479f, 
    0.01708809f, 0.23463064f, -0.42461216f, -0.73729497f, 0.02087129f, -0.13916081f, -0.01309147f, 0.16300075f, 
    0.04252490f, -0.10847580f, -0.18712766f, -0.04839338f, 0.28627202f, 0.27909815f, -0.11168563f, 0.00547177f, 
    -0.01418220f, 0.34049270f, 0.05298305f, 0.22661759f, 0.43439957f, 0.23653480f, -0.09230061f, 0.12238400f, 
    0.00900696f, 0.19932322f, -0.01180509f, -0.04389206f, 0.04179935f, -0.44946212f, 0.00551192f, 0.04291254f, 
    0.06796258f, 0.21028332f, -0.05843642f, 0.00604805f, -0.00494062f, 0.02736100f, 0.33190244f, -0.21318053f, 
    -0.03047519f, 0.26670769f, 0.19253963f, 0.20327710f, -0.07316001f, -0.15720676f, 0.08920079f, 0.40326017f, 
    0.33220372f, 0.06794962f, 0.18358350f, 0.15609340f, -0.03899206f, -0.06775358f, 0.19686104f, 0.04213104f, 
    -0.23056965f, 0.05166219f, -0.40686280f, 0.20068429f, 0.26571119f, 0.22463158f, -0.35859132f, -0.39526090f, 
    -0.29502261f, 0.04668162f, -0.41892806f, 0.04870167f, -0.03134349f, 0.07298721f, -0.11127061f, 0.06851695f, 
    0.04809506f, 0.11601264f, -0.40065831f, -0.48902720f, 0.03363004f, -0.16519290f, 0.12725981f, 0.11795948f, 
    0.01417317f, 0.04815546f, 0.09524067f, -0.00137380f, -0.28545669f, -0.31861079f, -0.03451125f, -0.12420331f, 
    0.05265665f, 0.17992313f, -0.13856229f, 0.06043151f, 0.17308460f, 0.01789081f, 0.17543001f, 0.11463241f, 
    0.00739036f, 0.07387518f, 0.20989954f, -0.06784917f, 0.15436623f, -0.38817310f, -0.25521681f, -0.42297599f, 
    -0.00848494f, 0.00508128f, -0.14346358f, 0.03519394f, 0.01026135f, -0.17890674f, -0.03956516f, 0.34133720f, 
    0.00845814f, -0.11708277f, -0.03084436f, 0.05069014f, -0.20455410f, 0.10333639f, 0.14866661f, -0.06358542f, 
    0.17031102f, -0.31454512f, 0.01573290f, 0.14570622f, 0.10615359f, 0.04948784f, 0.03374946f, -0.16409700f, 
    -0.61837894f, 0.55158454f, -0.15632157f, -0.35897329f, -0.02220810f, -0.10980058f, -0.28640604f, -0.07982440f, 
    -0.02064112f, 0.00951400f, 0.23654446f, 0.35357445f, 0.02201605f, 0.15707481f, 0.00172453f, 0.10772993f, 
    0.02185942f, -0.17487206f, 0.29104924f, -0.10136553f, 0.36121535f, 0.01929384f, -0.01415646f, 0.22502261f, 
    -0.11037498f, 0.04628291f, 0.11368935f, 0.40544426f, -0.09958567f, 0.04894902f, -0.30715111f, -0.09720413f, 
    -0.08362293f, 0.17159933f, -0.01603153f, 0.05088799f, 0.12021788f, -0.04181711f, -0.60107005f, 0.10055180f, 
    0.22683033f, -0.26545492f, 0.09238530f, 0.19834243f, 0.00709191f, -0.26469764f, 0.03466348f, 0.26902261f, 
    -0.07017407f, 0.10147613f, 0.00286083f, -0.02550902f, 0.06641133f, -0.07753957f, -0.62191975f, -0.23609188f, 
    -0.31943721f, 0.15117356f, -0.23102899f, -0.12777795f, -0.12310519f, -0.01938728f, -0.13680209f, 0.40996733f, 
    0.17629781f, -0.04327408f, -0.08183121f, -0.25020939f, 0.02897206f, 0.06574555f, -0.04795982f, 0.18204308f, 
    -0.42858735f, 0.35632816f, -0.42790896f, -0.04530007f, 0.19722126f, 0.37224779f, -0.13455538f, -0.08762621f, 
    -0.05495540f, -0.24199700f, -0.36895892f, -0.84362900f, 0.14204733f, 0.22672695f, 0.09592027f, 0.03517338f, 
    0.00554582f, 0.17172407f, -0.62317502f, 0.03766353f, -0.58863020f, 0.51797247f, 0.08081199f, 0.02927759f, 
    0.11396582f, 0.08049031f, 0.11747424f, 0.68293577f, 0.07166529f, 0.07867358f, 0.01449222f, -0.03035495f, 
    -0.04817765f, -0.05035917f, -0.04064023f, 0.09248289f, -0.74735248f, -0.56658286f, -0.09791861f, 0.24224722f, 
    -0.05072313f, -0.24682698f, 0.17175472f, -0.26950532f, 0.28873977f, 0.05753366f, -0.49391359f, 0.22053875f, 
    -0.07019919f, -0.18489517f, -0.05766549f, 0.14738624f, -0.19982900f, -0.00023081f, 0.01194146f, -0.03928086f, 
    0.29355747f, 0.07414784f, -0.08067670f, 0.27411252f, 0.00362564f, 0.12811166f, 0.19970965f, -0.21696572f, 
    0.51468992f, 0.44091538f, 0.02178153f, 0.18250780f, 0.28702745f, -0.05509657f, -0.00953174f, 0.06924474f, 
    -0.12991582f, -0.96812010f, -0.35227758f, -0.39690670f, -0.01589854f, -0.01470693f, -0.20401539f, -0.00982011f, 
    0.15046392f, 0.38142627f, 0.33674937f, 0.06947137f, 0.14259033f, -0.10983167f, 0.01117665f, -0.08013739f, 
    0.13036658f, 0.06909158f, -0.29284027f, 0.75994903f, -0.22203039f, 0.07347261f, 0.07455198f, -0.03975034f, 
    0.05132364f, 0.10710657f, 0.15899372f, -0.15512523f, 0.16778959f, -0.45451248f, -0.16240735f, 0.05545346f, 
    -0.07229978f, 0.02979694f, 0.10927694f, 0.12424903f, -0.07447669f, -0.24964960f, 0.19936772f, -0.25072646f, 
    -0.39230472f, -0.02233916f, 0.02267484f, -0.06395739f, 0.07762837f, -0.33658084f, 0.50978833f, -0.35649574f, 
    0.30409208f, 0.29675701f, 0.09972957f, -0.15175134f, -0.13117816f, 0.10169119f, 0.03262328f, 0.15369739f, 
    0.37682980f, -0.17295790f, -0.17668951f, 0.04225483f, -0.06470521f, -0.07479861f, 0.10558228f, -0.09669442f, 
    0.28236726f, 0.20252857f, 0.07589622f, 0.05214990f, -0.06263170f, 0.14794709f, -0.01574593f, -0.08291259f, 
    -0.62736517f, 0.10848589f, -0.03231912f, 0.09993443f, -0.07145055f, 0.28159314f, 0.07899678f, -0.25124216f, 
    -0.29683983f, 0.11338066f, 0.14896794f, -0.00309559f, 0.23992182f, 0.29022029f, 0.10275150f, 0.13975035f, 
    0.12483487f, 0.02343680f, 0.31440023f, 0.00983154f, 0.32976872f, 0.33596990f, 0.01310768f, 0.06780156f, 
    -0.00160280f, 0.04768861f, -0.04908293f, -0.54231602f, -0.05529663f, -0.03107263f, 0.02068055f, 0.01166122f, 
    -0.25211570f, -0.18386565f, -0.01064449f, -0.02952860f, -0.20060918f, -0.19798186f, -0.37463608f, 0.03110892f, 
    -0.04554345f, -0.02937794f, 0.03355826f, 0.16763310f, 0.02080700f, 0.53516871f, 0.15317495f, 0.08381568f, 
    -0.18116285f, 0.13526775f, -0.03676478f, -0.02405904f, 0.12912129f, -0.14223459f, -0.55851841f, -0.15022717f, 
    0.08986567f, 0.11014796f, -0.06051179f, -0.13566230f, 0.21066298f, 0.02872096f, -0.16826490f, -0.07728440f, 
    -0.18961053f, 0.26057604f, 0.15415043f, 0.01316499f, 0.11018667f, 0.21577328f, 0.13853112f, 0.10482506f, 
    -0.07010888f, 0.00697315f, -0.02752368f, 0.06420692f, -0.05675296f, -0.07948617f, -0.02009752f, -0.01561855f, 
    0.00832886f, 0.05973577f, -0.07889831f, -0.06668544f, 0.01099306f, -0.02433047f, -0.01939251f, 0.05163309f, 
    -0.09695941f, 0.07046172f, -0.05874116f, -0.02930852f, 0.03161196f, 0.04344666f, -0.02573753f, 0.05583041f, 
    0.00330662f, 0.05516098f, 0.03355294f, -0.02551619f, -0.05679746f, -0.05716906f, 0.04239382f, -0.06121899f, 
    0.02841260f, -0.01131104f, -0.06052004f, -0.01834964f, -0.01011623f, 0.01633894f, -0.01644123f, -0.06265203f, 
    0.03106502f, -0.03591370f, 0.02964736f, -0.00140411f, -0.01961499f, -0.00930801f, -0.08819564f, -0.04554534f, 
    0.05089461f, -0.02529090f, -0.04250722f, -0.00312368f, 0.06223273f, -0.02126495f, -0.04500295f, -0.07509032f, 
    0.05376708f, 0.05904815f, 0.05569700f, 0.06466185f, -0.03994751f, 0.05488800f, -0.08496948f, 0.05516917f, 
    0.01884793f, -0.07916329f, -0.05495773f, -0.07442160f, -0.01715403f, -0.03176655f, 0.03739879f, -0.04512843f, 
    0.01060198f, 0.02250045f, 0.00659532f, 0.05672290f, 0.03036174f, -0.02111424f, -0.09148715f, -0.07624431f, 
    -0.00795705f, -0.01357866f, -0.03363634f, -0.03379466f, 0.03023732f, 0.06456978f, 0.05269732f, 0.02428246f, 
    -0.08941852f, 0.00000343f, 0.06663591f, -0.02488076f, -0.07013170f, -0.00602602f, 0.03220546f, 0.03320709f, 
    -0.03410644f, 0.06029240f, -0.04878997f, -0.08705603f, -0.05683890f, 0.01523888f, -0.06468612f, 0.02986443f, 
    -0.02836602f, -0.09917974f, -0.02197472f, 0.06331151f, -0.07872240f, -0.08394305f, -0.03881021f, -0.06691756f, 
    0.05709511f, 0.01600381f, 0.06877396f, -0.07131798f, 0.02661022f, 0.07301439f, -0.03272009f, 0.03575278f, 
    -0.06487847f, 0.03383737f, -0.05077015f, -0.01105486f, -0.03850094f, -0.05093510f, 0.05703801f, -0.02811174f, 
    -0.06910149f, 0.04845257f, -0.05969625f, -0.04151859f, 0.06061038f, -0.07622126f, -0.01976882f, -0.04511793f, 
    0.01542894f, 0.07159985f, 0.01190020f, 0.01715424f, 0.06036690f, -0.05522015f, -0.05222143f, -0.06572753f, 
    0.02592410f, 0.06135508f, 0.00512801f, 0.00388595f, -0.01744785f, 0.01275582f, -0.04814913f, -0.06389109f, 
    0.00023167f, -0.01243870f, -0.07421519f, 0.03718893f, -0.02236447f, 0.05687534f, -0.05173897f, 0.01259043f, 
    -0.07665618f, -0.08963320f, 0.03975835f, 0.03318476f, -0.07883772f, -0.09130748f, -0.08435911f, 0.03203250f, 
    0.03593274f, -0.07126490f, -0.08248030f, 0.03188318f, -0.03633263f, -0.07669371f, -0.01263382f, 0.04742526f, 
    0.05383498f, -0.07173971f, -0.04500737f, -0.03523919f, -0.04309555f, -0.02083630f, 0.04849833f, -0.06436537f, 
    0.05947184f, 0.00002710f, -0.02479170f, -0.06444031f, -0.03906668f, 0.00946507f, -0.00675405f, 0.01947422f, 
    0.05992113f, -0.04962744f, -0.01289174f, 0.02362585f, 0.03221167f, 0.06168871f, -0.08962269f, 0.01276678f, 
    0.03226653f, -0.09188151f, 0.01114000f, -0.00586078f, -0.04876392f, -0.07079912f, 0.05165153f, -0.06601578f, 
    0.01745630f, 0.02659185f, -0.11713235f, 0.03755061f, -0.06303162f, 0.05266737f, 0.03291043f, -0.10500256f, 
    -0.06026123f, 0.03161619f, 0.02905837f, -0.04989032f, -0.03089083f, -0.09155322f, -0.06592481f, -0.06323612f, 
    0.04892690f, -0.01301776f, 0.05798806f, -0.02627795f, -0.05801113f, -0.06374413f, 0.02170499f, -0.03642963f, 
    0.03908752f, -0.04239410f, 0.04529125f, -0.02784783f, 0.01767173f, -0.09193783f, -0.07205931f, 0.02949016f, 
    -0.01970850f, -0.04179019f, 0.02121746f, -0.08129144f, 0.03981083f, 0.05412690f, 0.01609845f, -0.06343876f, 
    -0.03561801f, 0.01982392f, -0.07752118f, 0.04884287f, -0.02259938f, -0.06823708f, 0.01938906f, 0.01139600f, 
    -0.07102346f, -0.04681285f, 0.05085240f, -0.10833272f, 0.01489932f, 0.06253176f, 0.00528431f, 0.04790887f, 
    0.04207600f, -0.01687656f, -0.08056494f, 0.04972947f, -0.06272943f, -0.07299828f, -0.07341302f, 0.02656624f, 
    -0.08658838f, -0.07472765f, -0.02938993f, -0.06473337f, -0.06035791f, 0.02725065f, 0.03024024f, 0.00942553f, 
    -0.03744885f, 0.03447903f, -0.05940734f, 0.06295905f, -0.04133032f, -0.08551560f, -0.07975860f, -0.02949566f, 
    0.09673133f, -0.03721860f, 0.27716950f, 0.12164668f, 0.10923867f, 0.02386234f, 0.13928390f, -0.09614696f, 
    -0.30382931f, 0.04861713f, -0.02206148f, -0.12213573f, -0.05361008f, 0.12539271f, 0.04435611f, 0.21521388f, 
    -0.07064614f, 0.08220158f, 0.02787054f, -0.07144550f, 0.10626556f, 0.06892036f, 0.09681729f, 0.29152966f, 
    0.02322463f, -0.16065510f, 0.07139896f, -0.12185646f, -0.07711580f, -0.04183936f, -0.07226230f, 0.18054274f, 
    0.05656352f, 0.15100074f, -0.10061387f, -0.54165745f, 0.08115859f, 0.03238080f, 0.22483106f, 0.22283298f, 
    0.05309459f, -0.42197794f, 0.15464517f, 0.05982807f, -0.17437081f, -0.04146202f, 0.21341798f, 0.02390071f, 
    -0.01907624f, -0.06968768f, -0.12896907f, -0.14025491f, -0.12503929f, 0.51890147f, 0.94347870f, 0.05767718f, 
    -0.32526532f, 0.37876317f, -0.04834762f, -0.21205556f, 0.24810706f, 0.03488098f, -0.09688112f, -0.01432376f, 
    -0.33901623f, 0.04825935f, 0.23458454f, -0.19054636f, 0.14739698f, -0.06254653f, 0.23570712f, 0.01748000f, 
    0.12235068f, 0.20707124f, 0.45229396f, -0.14894292f, -0.31199756f, -0.06263759f, 0.03066575f, 0.16608700f, 
    0.21914852f, 0.42076984f, -0.04509924f, -0.31004533f, -0.47420844f, 0.15452123f, -0.07090393f, -0.16106381f, 
    0.24931273f, -0.01497083f, 0.30699426f, 0.09646583f, -0.01345191f, 0.03938421f, -0.20620586f, 0.04514146f, 
    0.01541580f, -0.13168147f, 0.04956763f, -0.16002044f, 0.02290078f, -0.29776183f, 0.07540149f, 0.17496330f, 
    0.30935967f, 0.05912585f, -0.34338251f, -0.55553234f, -0.38195536f, 0.11529379f, -0.06826687f, 0.03235096f, 
    -0.04258363f, 0.06947529f, -0.01901022f, 0.07806779f, 0.03944563f, -0.34583434f, -0.28358409f, -0.05228433f, 
    -0.33700320f, -0.03590352f, 0.24385004f, -0.22315525f, 0.23830144f, 0.37602270f, 0.36411685f, -0.03852144f, 
    0.22570446f, -0.45842686f, -0.23303546f, 0.14218584f, 0.29114336f, -0.16686882f, 0.36234504f, -0.17615171f, 
    0.14512222f, -0.07679073f, 0.06034386f, 0.00638453f, 0.02044964f, 0.01302953f, 0.10182080f, -0.04735292f, 
    0.31902358f, 0.43718457f, 0.13189985f, -0.09955165f, -0.05723173f, -0.10841851f, -0.01227510f, -0.04830237f, 
    0.03802425f, -0.03794094f, 0.09038875f, -0.09359277f, 0.18086505f, 0.32905284f, -0.24886131f, -0.12783365f, 
    0.01723580f, -0.10732487f, -0.51913524f, -0.08492300f, 0.29332009f, 0.28590712f, -0.04839817f, 0.16227934f, 
    -0.04768414f, -0.05606619f, 0.14109436f, -0.19277743f, 0.33905870f, -0.30893201f, -0.18665399f, 0.01531716f, 
    -0.02477924f, 0.20632854f, -0.28796673f, -0.06885265f, 0.03360638f, 0.19052301f, -0.26530808f, 0.01461680f, 
    -0.04797458f, -0.54385847f, 0.04797622f, -0.15042800f, 0.15638977f, 0.11273464f, -0.40821105f, 0.36509037f, 
    0.26125512f, 0.13743073f, 0.05921422f, -0.10345961f, -0.17899959f, 0.12419012f, 0.01077336f, 0.04779797f, 
    0.07738147f, -0.02217761f, 0.18059547f, -0.08028445f, -0.19443291f, 0.14370309f, 0.06287646f, -0.09222937f, 
    -0.04250252f, -0.15490760f, 0.01033062f, -0.19583343f, 0.04268669f, -0.09149271f, -0.08234615f, -0.12043773f, 
    0.07009373f, 0.04515959f, 0.38511103f, -0.02281583f, 0.10327525f, 0.07792840f, -0.15427010f, 0.10739320f, 
    -0.03465645f, -0.48911417f, -0.03358314f, 0.05665465f, 0.17935039f, 0.12603831f, -0.07409212f, -0.06546709f, 
    -0.26519096f, 0.08425113f, -0.06785764f, -0.26632193f, 0.21161158f, 0.11297733f, 0.10925402f, 0.06951275f, 
    0.08808079f, -0.03611184f, 0.17177431f, -0.23605862f, -0.01413197f, -0.57460880f, -0.21115835f, 0.02112404f, 
    0.12665725f, 0.00807251f, 0.27457428f, -0.08581309f, -0.09941424f, -0.50586319f, -0.11461038f, -0.15451619f, 
    -0.07765683f, 0.01054958f, 0.46879765f, -0.00603369f, 0.14653519f, -0.38524693f, 0.14159624f, 0.22176212f, 
    0.25686252f, -0.00656583f, 0.26382524f, -0.29472673f, 0.13159712f, 0.18178192f, -0.10834252f, -0.03219900f, 
    0.37667549f, 0.69371045f, 0.24205430f, 0.11298457f, -0.00485334f, 0.01202350f, 0.20393918f, 0.30689067f, 
    0.12716728f, 0.21240787f, 0.29883012f, -0.00015213f, -0.14233392f, 0.02877471f, -0.15183134f, -0.18943156f, 
    -0.13290086f, -0.03825558f, 0.11554506f, 0.06098387f, -0.13924140f, -0.10316573f, -0.14547871f, 0.01527580f, 
    0.00647625f, -0.51755768f, -0.49615803f, -0.03600105f, -0.01624806f, -0.01032768f, -0.03240345f, 0.11978143f, 
    0.11061532f, 0.39545313f, 0.49394649f, 0.31456643f, -0.00180382f, 0.11490751f, 0.18468611f, -0.15251103f, 
    0.09996191f, 0.07648285f, 0.23499706f, -0.29611939f, -0.16260420f, 0.08398219f, -0.09336580f, -0.14389713f, 
    -0.07017449f, -0.00053637f, 0.08562655f, 0.13832130f, 0.08781764f, -0.25723788f, 0.02565288f, -0.13350569f, 
    -0.03513574f, 0.52603948f, -0.10547442f, -0.14214842f, -0.16352449f, -0.07407769f, 0.10804386f, -0.03255763f, 
    0.18304242f, -0.18344989f, -0.23572832f, 0.17919938f, 0.14066012f, 0.13574818f, 0.16295357f, -0.16319984f, 
    0.04537083f, -0.24798773f, 0.11111712f, 0.23104036f, -0.54168439f, -0.10754287f, -0.27172288f, -0.41337144f, 
    -0.20087875f, -0.25947881f, -0.06187379f, 0.14056078f, 0.01131200f, 0.21015722f, -0.11492851f, 0.38903069f, 
    -0.01643975f, 0.08291053f, 0.20563272f, 0.21592729f, -0.06714111f, 0.13052119f, -0.06494745f, 0.07661770f, 
    -0.40132418f, 0.26630771f, 0.10873219f, -0.23843578f, 0.11908284f, -0.07483279f, -0.04395816f, -0.11334991f, 
    0.41220137f, -0.48171973f, 0.18968768f, -0.15732023f, 0.00533635f, -0.03799547f, 0.00897130f, 0.01770942f, 
    -0.35896355f, 0.04565865f, -0.12788855f, -0.08323344f, 0.12611733f, 0.24099730f, 0.04334804f, -0.00378172f, 
    -0.00402414f, 0.07852112f, 0.09149684f, -0.11823319f, 0.06825246f, 0.22565733f, 0.02984356f, 0.26977468f, 
    -0.12988986f, 0.05264978f, -0.21839255f, -0.01955961f, 0.03898773f, 0.28125492f, 0.03670127f, 0.16508882f, 
    0.07166573f, -0.01086918f, 0.00922929f, 0.29707596f, 0.17820707f, -0.05020612f, 0.33460268f, 0.29774815f, 
    0.18743233f, -0.28721523f, 0.29319659f, 0.19163921f, -0.18947795f, 0.05221022f, -0.05720084f, 0.05925997f, 
    0.30507746f, -0.06182003f, 0.06073067f, -0.24075624f, 0.21329036f, 0.12092262f, 0.10832337f, -0.20968579f, 
    -0.08404606f, 0.05220916f, -0.08633178f, 0.04879844f, -0.02655582f, -0.03107644f, -0.00415596f, 0.01838318f, 
    -0.06599985f, -0.07265579f, 0.02624380f, -0.00395285f, -0.01350471f, -0.03775172f, -0.02689902f, -0.03016036f, 
    0.05770161f, -0.02093359f, 0.03761297f, 0.04977892f, 0.01477801f, -0.05461162f, 0.04784749f, -0.03346546f, 
    -0.06390246f, 0.07935345f, -0.00110284f, -0.07263467f, -0.04579978f, 0.07116361f, 0.01568346f, -0.01604518f, 
    -0.01374444f, 0.04368647f, -0.03924256f, 0.05799560f, -0.01373658f, -0.01251896f, 0.03391279f, 0.05991324f, 
    -0.03787361f, -0.07492542f, -0.01544647f, -0.01995891f, -0.09164848f, 0.00402180f, 0.02103429f, 0.05787298f, 
    -0.03121553f, 0.02424258f, -0.07507616f, -0.03690021f, 0.00255135f, -0.06985058f, 0.03731324f, 0.00853590f, 
    -0.03568110f, -0.00470779f, 0.02201870f, 0.01231970f, 0.01097622f, 0.06242808f, 0.00818092f, -0.03646032f, 
    0.03583337f, -0.00319753f, 0.05350561f, 0.04884599f, 0.01045670f, -0.07804078f, -0.04616085f, 0.01145228f, 
    0.03811246f, -0.00083594f, -0.03469319f, 0.06362224f, -0.07698542f, -0.05562762f, -0.08512493f, 0.07630350f, 
    -0.07141683f, 0.02241788f, -0.05131793f, 0.04414685f, 0.01638392f, -0.03658680f, 0.01203412f, -0.02957189f, 
    -0.08820063f, 0.06639336f, -0.02747552f, 0.01410812f, 0.04563072f, -0.06536474f, 0.00616930f, 0.01935259f, 
    0.00902916f, -0.06549485f, 0.06357466f, -0.04933861f, 0.05862249f, -0.02542361f, 0.05906270f, 0.04483008f, 
    -0.07747986f, -0.08176332f, -0.00158274f, -0.08751547f, -0.01801743f, -0.01598643f, -0.01465010f, -0.05699662f, 
    0.00409530f, -0.06223549f, -0.03248693f, -0.07444231f, -0.04153360f, 0.06531779f, 0.02712306f, 0.06586046f, 
    -0.09331674f, -0.02969783f, -0.04729112f, -0.05425838f, -0.05514374f, -0.04673379f, -0.00959672f, -0.03912389f, 
    0.00085144f, 0.05943454f, -0.00991955f, -0.04405468f, -0.07976583f, 0.07850800f, -0.04520415f, -0.08676482f, 
    -0.09591629f, -0.02678006f, -0.08958849f, 0.06673744f, 0.02982601f, -0.08031304f, -0.00057603f, -0.00193095f, 
    -0.41611144f, -0.27812380f, 0.48226184f, -0.11458278f, -0.07522118f, 0.17335019f, -0.19841024f, 0.20323962f, 
    -0.07816590f, 0.25091949f, 0.14428052f, 0.53362268f, 0.16984504f, 0.22934465f, -0.09436221f, 0.05643669f, 
    -0.05959947f, -0.28192189f, 0.21386524f, 0.13324270f, -0.43832099f, 0.30021921f, 0.05385672f, 0.17274673f, 
    0.13951203f, -0.01353859f, -0.10615575f, -0.37151396f, -0.20833829f, -0.14859283f, -0.21232980f, 0.14139268f, 
    0.09851628f, -0.13049103f, 0.05866323f, -0.12953925f, 0.20706171f, -0.00225404f, 0.06361232f, -0.39927292f, 
    0.09787989f, -0.08014853f, -0.38665640f, 0.13791618f, 0.33693719f, -0.20260857f, 0.01855285f, -0.58066332f, 
    -0.09320284f, 0.31090537f, -0.02487681f, 0.12808375f, -0.01930052f, 0.08137309f, 0.33376917f, 0.13644475f, 
    0.27723199f, -0.26664314f, -0.13657247f, -0.02722882f, 0.08655893f, 0.09865592f, 0.11611375f, -0.38199344f, 
    0.38132426f, 0.41732126f, 0.38599038f, 0.22874361f, 0.18345228f, -0.07825079f, 0.03064976f, 0.09732419f, 
    -0.44594878f, 0.01035033f, -0.08009689f, 0.01554210f, 0.24201509f, -0.10115370f, -0.47398064f, 0.01679674f, 
    0.04849911f, -0.05071367f, 0.24725026f, -0.08934348f, -0.11957619f, 0.12483067f, -0.02559381f, 0.17391393f, 
    0.05865568f, -0.02588101f, 0.99579602f, -0.29784638f, 0.07190985f, -0.03342420f, -0.11544765f, -0.11429191f, 
    0.27153429f, 0.00918502f, -0.04457974f, -0.15206355f, 0.02454827f, -0.27205276f, 0.30993927f, -0.10849975f, 
    -0.08669409f, 0.08720879f, 0.09909196f, -0.16199940f, -0.19595452f, -0.42260462f, -0.03731732f, 0.06646560f, 
    0.22858019f, 0.12790316f, -0.11536080f, 0.03681902f, 0.08387408f, 0.14425619f, 0.05439338f, -0.23877628f, 
    0.16495360f, 0.13215427f, 0.04794605f, 0.35133532f, -0.01674764f, -0.13158582f, -0.62786931f, -0.01156462f, 
    0.19289987f, -0.03903458f, -0.09446563f, -0.04311929f, 0.00310084f, 0.18075053f, 0.10891172f, -0.40819922f, 
    -0.11405338f, -0.19997980f, -0.08619447f, 0.21752533f, -0.19882964f, 0.11346894f, -0.08827624f, -0.12167107f, 
    -0.22587022f, -0.08568760f, -0.08519547f, -0.35292482f, 0.13030283f, -0.08989254f, -0.15430887f, -0.00592751f, 
    0.01173128f, -1.13245201f, -0.29863849f, 0.43183997f, 0.18834202f, 0.45430729f, 0.10865141f, 0.02547794f, 
    0.04154463f, -0.22243196f, 0.33085403f, 0.28220698f, -0.04873973f, -0.07187055f, -0.07124343f, 0.06739565f, 
    0.16253692f, 0.14202163f, 0.00718270f, -0.68169439f, 0.00740491f, -0.22830071f, 0.18875819f, -0.01370643f, 
    -0.01441623f, 0.27062950f, 0.10482372f, 0.14909646f, 0.34680447f, 0.14359161f, 0.03557182f, 0.35292822f, 
    0.02443855f, -0.09683345f, -0.34110427f, 0.04230521f, 0.04059288f, 0.06982076f, 0.14256939f, 0.07660357f, 
    -0.17418784f, 0.16939549f, -0.04014175f, -0.28028291f, 0.05745976f, 0.01501142f, -0.22411019f, 0.31158218f, 
    0.02296652f, 0.40256500f, 0.04898680f, -0.02608570f, 0.05970028f, 0.07539660f, -0.01314574f, -1.20264220f, 
    -0.11547405f, -0.08381406f, -0.23267771f, 0.07378364f, 0.05893096f, 0.19503185f, -0.02763403f, 0.14797285f, 
    -0.02959080f, -0.32801923f, 0.20987323f, -0.18929777f, -0.09536549f, 0.15324911f, 0.32438624f, 0.12390550f, 
    0.09669088f, 0.57873267f, 0.08193681f, -0.02797665f, 0.06610957f, 0.23233978f, 0.21263035f, 0.21175534f, 
    -0.02223841f, -0.05486948f, 0.18678690f, 0.02791816f, -0.35763627f, -0.00552627f, -0.18360864f, -0.20864263f, 
    0.29203027f, 0.10216954f, 0.04098405f, 0.06258722f, 0.15291347f, -0.27106088f, -0.23035738f, 0.09998480f, 
    -0.18355770f, -0.20998599f, -0.00771960f, 0.21300223f, 0.33538970f, 0.07919139f, 0.43404257f, -0.04626753f, 
    -0.09440167f, -0.19890437f, -0.06418174f, 0.17827676f, -0.22785912f, 0.21699925f, -0.32957456f, -0.25544918f, 
    -0.23409532f, 0.09188651f, 0.16600046f, -0.01539905f, 0.10754258f, -0.15580574f, -0.29566124f, 0.06008756f, 
    0.11455687f, -0.20004618f, 0.11112393f, 0.15595573f, -0.03910584f, -0.17340577f, 0.06736960f, 0.00722612f, 
    0.21105285f, 0.37724572f, -0.10900907f, -0.29483268f, 0.00573475f, -0.21714129f, 0.13389209f, 0.09880298f, 
    0.06691591f, 0.04643147f, 0.01431343f, -0.08292941f, 0.06759299f, -0.05589804f, 0.04705457f, 0.03968930f, 
    -0.04005063f, 0.01906610f, 0.01101411f, -0.02197630f, -0.08592737f, -0.00258237f, -0.07592241f, -0.04650192f, 
    0.00872081f, 0.04163246f, -0.00185700f, 0.02532321f, 0.02228669f, 0.03047617f, 0.02253003f, 0.05742532f, 
    -0.06634251f, 0.04493469f, -0.03723552f, 0.01700780f, -0.09734844f, -0.10042706f, -0.07937352f, -0.04216297f, 
    -0.09256881f, -0.08844993f, -0.02132656f, -0.06507909f, -0.04138528f, -0.05341489f, 0.00964906f, -0.01397488f, 
    -0.02684248f, 0.02277542f, 0.04588862f, 0.06447058f, -0.06860613f, -0.07212860f, 0.02606621f, 0.01384931f, 
    -0.04986288f, 0.06706731f, -0.07384085f, -0.04956349f, -0.04118914f, -0.02945084f, -0.04365867f, -0.02549481f, 
    -0.04038695f, -0.10085762f, -0.02647998f, 0.01320380f, 0.00844905f, 0.04221097f, -0.05428290f, -0.02985078f, 
    -0.03969860f, 0.05304663f, -0.03652001f, 0.03160365f, 0.02923510f, -0.07311907f, -0.00379844f, 0.05259823f, 
    0.01955856f, -0.04207280f, -0.04791932f, -0.00432714f, -0.07400788f, 0.06971166f, -0.01112452f, -0.00938027f, 
    0.01002380f, 0.05519498f, -0.00938594f, -0.05713341f, 0.06841607f, 0.01443680f, -0.07706269f, -0.09062947f, 
    0.06723527f, 0.05837735f, -0.08398402f, -0.07832774f, -0.00780599f, -0.00391650f, -0.01319853f, -0.07987061f, 
    0.00273238f, -0.09847426f, -0.07068646f, -0.01506617f, 0.00061787f, -0.02293373f, -0.03610335f, 0.03406777f, 
    -0.06585323f, 0.04233373f, 0.03132020f, -0.04683869f, -0.01879618f, 0.01131274f, -0.01904023f, 0.05888464f, 
    -0.04244074f, -0.05154986f, 0.04581405f, 0.04266269f, 0.02326294f, -0.07248863f, -0.09759563f, -0.02057780f, 
    0.01918261f, 0.06324187f, -0.01052526f, 0.03375864f, 0.00533792f, -0.05141929f, -0.01827924f, -0.07840378f, 
    0.02611985f, -0.07913175f, -0.05194722f, 0.06097053f, 0.01217139f, 0.05303866f, 0.02189334f, -0.08204269f, 
    0.06470086f, 0.02929147f, -0.07378349f, 0.04861126f, -0.06928117f, -0.06431167f, -0.07755142f, -0.00701772f, 
    0.00048612f, 0.07946059f, 0.42874202f, 0.11267018f, 0.01460088f, -0.03846678f, 0.22079752f, 0.22451711f, 
    0.05050051f, -0.31063738f, 0.13124140f, -0.27609578f, 0.20493962f, 0.11160001f, 0.22686183f, 0.14208624f, 
    0.03946547f, -0.22433749f, 0.33162853f, 0.14079496f, 0.24634658f, -0.07817529f, 0.03414572f, -0.01807753f, 
    -0.06103147f, -0.07309502f, 0.26069692f, -0.33198360f, 0.17369418f, -0.04221109f, -0.01173157f, -0.05822251f, 
    -0.06750512f, 0.11967977f, 0.14443758f, 0.29518190f, 0.13010463f, -0.04256454f, -0.05944028f, -0.10839631f, 
    -0.02215300f, -0.07449209f, -0.15378305f, -0.06678566f, 0.02723848f, -0.06076511f, -0.23587190f, 0.22589506f, 
    -0.13201138f, -0.00450002f, -0.26873702f, 0.05162152f, -0.02767382f, -0.11410377f, -0.56006336f, 0.08314345f, 
    0.07574441f, 0.32332125f, -0.03246623f, -0.22754462f, 0.11594385f, 0.22227962f, -0.06273664f, 0.44930324f, 
    -0.51440859f, -0.09738755f, 0.34241509f, 0.30276015f, -0.03152826f, 0.16595948f, -0.01821821f, 0.23348372f, 
    -0.02264704f, -0.05784862f, -0.00369912f, 0.12702385f, 0.03936819f, -0.03988818f, -0.07856324f, -0.02062747f, 
    -0.35003003f, -0.40650475f, 0.32368958f, -0.04740822f, 0.18095089f, 0.19809741f, 0.20513383f, 0.06361903f, 
    -0.10651548f, -0.11381926f, -0.52272272f, -0.22626390f, -0.14476578f, 0.00408310f, -0.39675757f, -0.17851245f, 
    -0.04399633f, 0.11269969f, 0.04339852f, -0.06687567f, -0.20945622f, -0.16620038f, -0.12406395f, -0.09345356f, 
    0.14233315f, 0.14386790f, -0.17556788f, 0.11993688f, -0.19822343f, -0.04832643f, -0.37076798f, 0.01415117f, 
    0.15218526f, -0.01291514f, -0.21253309f, 0.18110025f, -0.06972823f, -0.10218114f, 0.41260788f, 0.44364676f, 
    -0.01004836f, -0.09713499f, 0.06637646f, -0.00906213f, 0.08483820f, 0.03763830f, 0.39274883f, 0.32866582f, 
    0.08279763f, 0.29437536f, -0.26580024f, -0.09189294f, -0.02567241f, 0.00406788f, -0.10190959f, 0.22119948f, 
    0.04745458f, 0.01757285f, -0.01228865f, -0.26979282f, -0.09588053f, -0.04375938f, 0.14961207f, 0.06258453f, 
    -0.17477472f, -0.62390018f, -0.10402444f, 0.04059878f, -0.00045158f, -0.03697004f, 0.26466033f, -0.15542477f, 
    0.12918259f, -0.03976660f, 0.27518588f, 0.00568915f, 0.25433138f, -0.09201852f, 0.13280781f, 0.01067166f, 
    -0.01053071f, 0.09299166f, 0.21443725f, 0.21343043f, -0.03055087f, -0.36826605f, 0.08043099f, 0.02485518f, 
    -0.07757672f, -0.11646330f, -0.14714561f, 0.29420996f, 0.04966671f, -0.30650368f, 0.15436248f, 0.03101397f, 
    0.05652497f, -0.01312098f, 0.06503665f, 0.25058445f, 0.53692269f, -0.02343838f, -0.47379991f, 0.14762703f, 
    -0.00065360f, 0.23603341f, 0.09340061f, -0.10052904f, 0.01199815f, 0.26084876f, 0.24984346f, -0.08089038f, 
    -0.14557065f, 0.07240776f, 0.02955510f, -0.17762510f, -0.12840545f, 0.04412379f, 0.45901522f, 0.13459788f, 
    -0.26298490f, 0.05252896f, 0.19656752f, 0.14269297f, -0.07092171f, 0.13156109f, -0.26239112f, 0.47018191f, 
    0.16398963f, 0.21917836f, -0.11081664f, 0.07793909f, 0.06647039f, -0.00356976f, 0.14896978f, -0.09421267f, 
    0.02289411f, -0.45295280f, -0.50211072f, 0.09012710f, 0.16602382f, 0.22200443f, -0.04513638f, 0.00097708f, 
    -0.16406396f, -0.12781860f, -0.31095001f, -0.28833163f, -0.02959332f, 0.10574904f, 0.16227680f, -0.06933841f, 
    -0.00361035f, 0.10604311f, -0.49010229f, -0.20830426f, -0.20250005f, -0.13544339f, -0.16203015f, 0.12448510f, 
    0.13539015f, 0.01427612f, -0.04059211f, -0.44084093f, 0.32256889f, 0.46017691f, -0.35209525f, 0.28339940f, 
    -0.23179761f, 0.19595702f, 0.03067920f, 0.05747331f, 0.18996467f, 0.01116315f, -0.20885792f, -0.12158372f, 
    -0.18023051f, 0.05466554f, 0.16436149f, 0.09103957f, -0.08950028f, 0.31063652f, -0.04181739f, -0.18119007f, 
    -0.03529165f, -0.19693831f, 0.00126629f, 0.12490426f, 0.05934548f, -0.10177778f, -0.32885379f, -0.12648106f, 
    -0.05535254f, -0.00583735f, 0.19514737f, 0.32919556f, 0.12101565f, -0.03768546f, -0.01700125f, 0.49380863f, 
    0.00890581f, -0.11467262f, 0.05813079f, 0.07409613f, 0.08640830f, -0.13909318f, 0.12350101f, -0.44470066f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08043209f, 0.06185772f, 0.31365773f, 0.28878906f, 0.20435168f, 0.02678105f, -0.05465114f, 0.06095643f, 
    -0.20532790f, -0.00163797f, 0.01887256f, 0.28818566f, 0.22076777f, 0.04286112f, 0.00647272f, 0.02237329f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.36351463f, 0.12182187f, -0.72829515f, -0.10088350f, 0.88148445f, 0.11073792f, 0.14914194f, 0.14569142f, 
    -0.14334099f, -0.23401450f, -0.08207460f, 0.42895716f, -0.16419816f, 0.02103489f, -0.03596574f, -0.03509140f, 
    -0.41673225f, -0.07721852f, 0.11866818f, 0.52656943f, 0.14695601f, -0.17317455f, -0.10476471f, -0.33039987f, 
    -0.52967894f, 0.28496039f, -0.10583854f, 0.04713167f, -0.21174040f, 0.08271597f, -0.37497687f, 0.62347960f, 
    1.33645010f, -0.04032053f, -0.12345503f, 0.16709682f, -0.59140718f, 0.07967366f, 0.12007605f, -0.29707691f, 
    0.15865490f, -0.70313162f, -0.26048580f, -0.37241021f, -0.02552975f, 0.13775943f, -0.48159841f, 0.49625605f, 
    0.20268726f, 0.16024971f, -0.33241841f, -0.27582985f, -0.51969415f, 0.17070709f, 0.17037907f, 0.46826926f, 
    -0.27244544f, 0.34457907f, -0.10673520f, -0.22458409f, 0.68775725f, -0.06648836f, -0.28443030f, -0.30597895f, 
    -0.09105936f, 0.07512350f, -0.22037077f, -0.10046891f, 0.14719065f, -0.06525730f, -0.19293770f, 0.41629520f, 
    0.31976259f, -0.41337189f, -0.17199974f, 0.18486354f, -0.01973205f, 0.11318177f, 0.27457839f, -0.56002831f, 
    -0.61866635f, -0.07508595f, 0.42930430f, -0.43358290f, 0.32123730f, -0.10329304f, -0.13538431f, -0.46577287f, 
    -0.17787445f, 0.36169210f, 0.18532649f, 0.22137491f, -0.67246646f, -0.16173115f, -0.00709143f, 0.15163828f, 
    -0.35939571f, 0.16153316f, 0.64740628f, -0.59157503f, -0.22332412f, -0.03771872f, 0.01835679f, 0.05785832f, 
    -0.08988786f, -0.46951368f, 0.03020589f, 0.30573517f, 0.19060121f, 0.24620867f, -0.45301655f, 0.02915805f, 
    0.31500337f, -0.10434014f, -0.81331748f, -0.17153162f, -0.28950551f, -0.11623202f, -0.20532355f, -0.33617082f, 
    0.79105496f, 0.33863553f, -0.07952921f, -0.25532290f, -0.41948637f, -0.00099984f, 0.86651272f, -0.60738420f, 
    -0.27506223f, -0.01885655f, 0.25486186f, 1.19896650f, 0.14583461f, -0.00373860f, 0.15897752f, -0.50666291f, 
    -0.40245253f, 0.04890599f, 0.15102823f, -0.67715979f, -0.46287137f, -0.11884815f, 0.36702281f, 0.09023323f, 
    -0.29695791f, 0.11489907f, 0.01943434f, 0.10361029f, -0.51186216f, 0.01689020f, 0.20715672f, 0.20245834f, 
    0.48173714f, -0.48318470f, 0.16969001f, 0.70915604f, -0.25086141f, 0.00025579f, 0.14809467f, -0.56952238f, 
    0.17453133f, 0.15483546f, 0.13335055f, -0.11878770f, -0.26350027f, -0.14568412f, -0.01330787f, -0.45609811f, 
    -0.44056314f, 0.30073509f, -0.06012760f, -1.05168915f, 0.71658605f, 0.23261826f, 0.24432676f, 0.31022060f, 
    0.19823754f, -0.22728927f, 0.05450311f, -0.62447423f, -0.42491233f, -0.04359760f, -0.00297870f, 0.74771774f, 
    -0.17217797f, -0.04373379f, -0.05766476f, -0.51175141f, -0.19236422f, 0.14523330f, 0.13256693f, 0.38037163f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21228524f, -0.13768150f, -0.47178751f, 0.07358979f, 0.09128720f, 0.18960562f, 0.01360435f, -0.52837765f, 
    -0.61518884f, -0.08282822f, 0.47822943f, 0.03703052f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
