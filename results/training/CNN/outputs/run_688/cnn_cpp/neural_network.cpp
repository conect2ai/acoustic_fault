#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.04462302f, -1.34144306f, 0.91869026f, -1.18865812f, 0.47796538f, -0.16810499f, 0.36081758f, -0.12906191f, 
    0.16074979f, -0.65822029f, -0.89818096f, -0.34684399f, 0.55106872f, 0.90048540f, 0.69163382f, -0.43784162f, 
    0.82406342f, 0.02593272f, 0.61004341f, 1.14785123f, 0.20779045f, -0.70621520f, -0.75654507f, -0.72933060f, 
    0.52092510f, -0.06688101f, 0.03876296f, -0.95659560f, -0.95115685f, -0.74117392f, -0.86579120f, -0.37024683f, 
    0.00944705f, -0.39850786f, -0.35259488f, -0.36951128f, -0.46890080f, -0.86281037f, 0.53633982f, -0.22075620f, 
    0.20457886f, 1.18274200f, -0.32258239f, -0.27629021f, 0.13377447f, 1.16558480f, 0.70306402f, 0.17061730f, 
    -0.58352864f, 0.67084765f, -0.89907438f, -0.27632743f, 0.02745608f, -0.50251174f, -0.95530826f, -0.90332484f, 
    -0.37856710f, 0.43862870f, -0.72071505f, 0.04206918f, 0.23785093f, 0.37159514f, 0.60959244f, 0.83928311f, 
    0.70809382f, 0.72492856f, 0.42817929f, -0.56367183f, 0.52057540f, 0.42383957f, 0.65903997f, -0.09558370f, 
    -0.24356282f, -1.58901727f, 0.96409380f, 0.63650888f, 0.49694157f, 0.20072635f, -0.21968359f, -0.14531922f, 
    -0.10099659f, -1.02000666f, 0.93082041f, 0.47228006f, 1.03040373f, -0.34483984f, 0.30645138f, -0.39836830f, 
    -0.58279818f, 0.34735879f, -0.53061461f, 1.19188464f, 0.05770710f, 0.50604039f, 0.84273940f, 0.95925754f, 
    -0.16246630f, 0.10852748f, -0.52762926f, 0.62221593f, -0.52608466f, 0.47795656f, -0.53259689f, -1.05110431f, 
    -0.94602150f, 0.66764587f, 0.73387361f, 0.02266607f, -0.26004779f, -0.66010737f, -0.61635953f, 0.81311393f, 
    0.84578419f, -0.61369371f, -0.39576751f, -0.34126028f, -0.10273458f, 0.92031354f, 1.14524913f, -0.11018717f, 
    0.73103189f, -0.25765294f, -0.53812176f, 0.45010936f, 0.15544271f, -0.25552794f, 1.33631754f, 0.68590748f, 
    0.53322113f, -0.37780774f, 0.02434016f, 0.30421504f, -0.20662235f, -0.26766312f, 0.18671328f, 0.97715944f, 
    -0.08985361f, 0.80248636f, 0.77516186f, 0.11731876f, 0.47463140f, -0.60262179f, 0.02017002f, -0.66214865f, 
    0.29806480f, 0.95044917f, 0.24994896f, 0.40848395f, -0.31147081f, -0.79511911f, -0.65020007f, -0.33411211f, 
    -0.51193678f, -1.13859689f, -0.16782460f, -0.81924832f, 0.71340537f, 0.69678324f, -0.23868804f, -0.13227367f, 
    -0.36794880f, 0.25857881f, 0.77681667f, -0.05728086f, -1.12845480f, 0.30624977f, 0.21309520f, -0.33518186f, 
    0.12011842f, 0.55372524f, -0.47039142f, -0.76159114f, 1.20319378f, -0.97845000f, 0.42258143f, -0.58250600f, 
    -1.21732843f, 0.16045536f, 0.39706439f, -0.20386475f, -0.16277058f, 1.40141881f, 0.32872203f, 0.29949775f, 
    1.10731781f, -0.27971405f, -0.41979685f, 0.02283457f, 0.21682616f, 1.22619843f, 0.55946827f, -1.20649457f, 
    0.31887946f, 0.58984089f, -0.62572098f, 0.16189942f, -0.25982386f, 0.58252537f, -0.18871912f, -0.79431933f, 
    -0.89212430f, -1.05539286f, -0.62521046f, -0.33557099f, -0.06229923f, 0.32753736f, 0.62713444f, 0.94249594f, 
    -0.14062425f, 0.97354031f, 0.66175520f, -0.27409157f, 0.25459406f, 0.10388002f, -0.29214707f, 0.02602767f, 
    0.79993129f, -0.44240987f, -0.96215218f, -0.03670199f, -0.25140581f, -0.46406201f, -0.39641526f, -0.55292380f, 
    0.56272638f, 1.05865657f, -0.43907154f, -0.49176517f, 0.88936061f, 0.30462712f, -0.44630632f, -0.03507400f, 
    0.18517034f, -0.00416758f, -0.12498840f, -1.40846407f, -0.76714855f, -0.46228704f, 0.82583439f, 0.25216961f, 
    -0.06251181f, 0.37150675f, -0.44749710f, -1.64752829f, -0.14647810f, 0.80520684f, 0.87474632f, 0.17339544f, 
    0.49328166f, 0.09644637f, 0.03905616f, 0.02942138f, -0.63270855f, -0.86465758f, -0.53054994f, 0.27633423f, 
    1.03856671f, 0.65721905f, 0.04931365f, -0.37393278f, -0.22266647f, 0.68263668f, 0.97666866f, -0.25236505f, 
    -0.69669962f, 0.61412644f, 0.99281061f, -0.18100764f, -0.35020396f, 0.26113081f, 0.97828931f, 0.40698227f, 
    0.30826759f, -0.67987430f, -1.32772303f, 0.02068861f, 0.29224738f, 0.30930865f, -0.11345225f, -0.25725210f, 
    -1.16509032f, -0.58130777f, 0.89229780f, -0.59645569f, 0.25456184f, -0.26726803f, -0.10691262f, -0.32048890f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17778845f, -0.14679430f, 0.09679184f, 0.26666570f, 0.12566148f, -0.05583055f, 0.26316774f, 0.14940611f, 
    0.04220909f, -0.06853148f, 0.01064985f, 0.16833942f, 0.07799283f, -0.13562050f, 0.40605018f, 0.30826965f, 
    -0.09895279f, -0.19784887f, 0.37749791f, 0.15403491f, 0.08326411f, 0.29498684f, 0.31856716f, 0.26547277f, 
    0.13313448f, -0.00719862f, 0.27924150f, 0.09299366f, 0.00943591f, 0.25082478f, 0.22983862f, 0.09038451f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.48225370f, -0.22144157f, -0.03914085f, 0.16790141f, -0.57520080f, -0.14795417f, -0.16329315f, -0.00157643f, 
    0.05199618f, -0.03099312f, -0.05519827f, -0.02352200f, -0.07055227f, -0.07098745f, 0.04019069f, -0.08478018f, 
    -0.17740729f, 0.00146532f, 0.05285728f, 0.11012360f, -0.11353853f, 0.28839213f, -0.05731558f, -0.24762179f, 
    -0.32300192f, 0.10441574f, 0.03944055f, 0.02203553f, 0.05085503f, -0.05883215f, 0.07657265f, -0.03169804f, 
    0.06059381f, 0.03102151f, -0.00633018f, -0.05435187f, -0.05373728f, -0.04621190f, -0.04219385f, 0.03719603f, 
    -0.00651493f, 0.12450093f, 0.04482660f, -0.01967867f, 0.22439596f, -0.16643323f, -0.08202427f, -0.07344716f, 
    0.02899327f, -0.07967135f, 0.08164848f, -0.03676053f, 0.01911852f, -0.05899304f, -0.01594469f, 0.06359226f, 
    -0.02923025f, 0.12045318f, 0.03074714f, -0.07170212f, -0.33221811f, -0.00275952f, -0.35819638f, 0.12494248f, 
    -0.14890461f, 0.00991043f, -0.05988911f, -0.14157438f, 0.02494020f, -0.01824402f, 0.05264735f, -0.05328784f, 
    -0.11579433f, 0.01645007f, 0.01905343f, 0.04957383f, -0.02100248f, 0.00811306f, 0.03707788f, 0.04146885f, 
    -0.24484937f, 0.17440559f, -0.09258690f, 0.12119924f, -0.19720623f, 0.07238881f, 0.14903863f, -0.07443437f, 
    0.03757785f, -0.15502250f, 0.09101137f, -0.05196364f, -0.01976139f, 0.03462329f, 0.01357198f, 0.08845232f, 
    -0.02367919f, -0.01143581f, 0.08750714f, -0.02040010f, 0.02972692f, 0.16648592f, 0.03521482f, -0.04642094f, 
    0.20252475f, -0.00750079f, -0.12943728f, -0.06381229f, 0.05468642f, 0.12850712f, 0.00310375f, 0.07626785f, 
    0.03422052f, -0.14168409f, 0.07464838f, 0.03436250f, 0.09468055f, -0.04335835f, 0.08197351f, 0.00298189f, 
    -0.25243849f, -0.48175415f, -0.16453879f, -0.09298496f, -0.04272403f, -0.00612810f, -0.00215731f, -0.07455640f, 
    0.00842833f, 0.14077893f, -0.10290952f, 0.00644426f, -0.01049977f, -0.10473581f, 0.08082903f, 0.03935616f, 
    0.01381918f, 0.14934123f, -0.11025499f, -0.11203714f, 0.13886359f, -0.00139636f, -0.05630451f, -0.28173158f, 
    0.00017036f, -0.17443517f, -0.06659731f, -0.02784241f, -0.00669369f, 0.09909485f, -0.00923753f, -0.08076352f, 
    -0.02073602f, 0.03947987f, -0.10919835f, -0.06683715f, -0.03236347f, -0.15429670f, -0.06693184f, 0.07981195f, 
    -0.32056624f, 0.13728359f, 0.28273174f, 0.10333817f, -0.46986568f, 0.05613592f, 0.01524418f, 0.08087935f, 
    0.11820218f, -0.07299104f, -0.06455887f, 0.05740131f, -0.11976971f, -0.04726652f, 0.01485523f, -0.06237396f, 
    -0.00945889f, 0.00437800f, -0.02921418f, -0.00601598f, 0.13599300f, -0.11773082f, 0.10845872f, 0.14058167f, 
    0.02562447f, -0.14381553f, 0.00672450f, 0.06266141f, -0.17432447f, 0.13270217f, 0.04955943f, -0.01945043f, 
    -0.01131193f, 0.08681940f, 0.06083269f, -0.05917068f, -0.04759413f, 0.00003751f, -0.10878216f, -0.10162825f, 
    0.22733732f, 0.07201733f, 0.18292785f, -0.09520757f, 0.31087250f, 0.00267470f, -0.13554905f, 0.19168992f, 
    -0.17995213f, -0.00066035f, -0.02429026f, -0.10886367f, -0.15133083f, -0.10431866f, 0.05504281f, 0.09245662f, 
    0.01517709f, -0.17304260f, 0.08931947f, -0.02444039f, 0.01570342f, -0.34390804f, 0.13719040f, 0.15111384f, 
    -0.09920113f, -0.13878594f, 0.00211607f, 0.02620401f, -0.13347442f, 0.01207413f, -0.07900520f, 0.06751861f, 
    -0.02706311f, -0.00667026f, -0.08550345f, 0.04939020f, -0.04796994f, -0.01489102f, 0.09220164f, -0.01446323f, 
    0.16163430f, 0.14908820f, 0.14303800f, -0.01068306f, -0.18950631f, -0.02094106f, -0.01970077f, 0.02141372f, 
    -0.05430532f, -0.17068715f, 0.12351006f, 0.06299581f, -0.00392893f, 0.10866436f, 0.04410006f, 0.00508150f, 
    -0.00987817f, 0.04475304f, -0.09394821f, 0.00473537f, 0.12397547f, 0.02323068f, 0.08387259f, -0.12654063f, 
    0.25826442f, -0.21124282f, 0.07780687f, 0.05014896f, 0.06429145f, -0.07827757f, 0.09424337f, 0.09281105f, 
    -0.09371518f, 0.03493239f, -0.05639863f, 0.07625002f, 0.03544067f, 0.13191752f, -0.04621405f, -0.00956907f, 
    0.17074004f, 0.15083551f, -0.13351400f, -0.25450325f, 0.21691839f, -0.18115331f, -0.18758506f, -0.15146914f, 
    0.01744254f, -0.03406309f, -0.05818661f, -0.05358160f, 0.04198145f, -0.09768216f, 0.00162512f, 0.04045902f, 
    0.02942297f, -0.07886981f, 0.01185891f, 0.10391318f, 0.28908792f, -0.06396386f, -0.00661143f, 0.01926715f, 
    -0.03604580f, -0.03356611f, -0.15571764f, 0.07779220f, 0.02779050f, -0.10795292f, -0.10619655f, 0.03982818f, 
    -0.02308213f, 0.00771972f, -0.10689410f, 0.13423365f, -0.01162573f, -0.01763911f, 0.03717709f, 0.03979355f, 
    0.00121869f, 0.08283035f, 0.14088258f, -0.01864228f, 0.16526692f, 0.05319909f, -0.18537921f, 0.02497628f, 
    0.00637035f, 0.01364342f, 0.02926147f, 0.10357225f, -0.13879672f, 0.13503715f, -0.09801329f, 0.08749021f, 
    0.03360162f, 0.01852683f, -0.07221381f, -0.02338925f, 0.72041690f, 0.11561092f, 0.06457443f, -0.15799996f, 
    -0.34045434f, 0.02647440f, 0.03100004f, -0.10154355f, 0.02785166f, -0.15525860f, 0.04620497f, 0.00228452f, 
    -0.02885441f, 0.01934798f, 0.11260118f, 0.08006795f, 0.01916716f, 0.03925021f, 0.00696091f, -0.01343522f, 
    0.00127050f, -0.24906339f, 0.07353538f, -0.07071061f, 0.21282898f, -0.13972706f, -0.07389983f, 0.08589237f, 
    -0.00125609f, -0.08183587f, -0.05297614f, -0.00547176f, 0.11892003f, -0.09676755f, 0.08767065f, -0.09327376f, 
    0.01651638f, 0.07370339f, 0.08599641f, -0.03510608f, 0.11179370f, -0.11260699f, 0.17044134f, -0.01344337f, 
    0.04416911f, -0.02043663f, -0.07627040f, 0.06701323f, -0.14890179f, 0.12637539f, 0.04030800f, 0.05594448f, 
    -0.06934095f, -0.00012064f, 0.02440830f, -0.04141463f, 0.03384828f, 0.16382469f, -0.02534221f, -0.13036957f, 
    0.19904269f, 0.00844674f, 0.17971241f, -0.13619076f, 0.33572450f, -0.15740904f, 0.05808533f, 0.06030206f, 
    -0.06677931f, -0.05313761f, 0.06472253f, 0.00577769f, -0.05705354f, 0.04045164f, -0.00907707f, -0.08699566f, 
    -0.04945921f, 0.08860938f, -0.05036105f, 0.03614454f, -0.20373957f, -0.10137236f, 0.10251731f, -0.00992021f, 
    0.27005738f, -0.19632716f, 0.01993103f, -0.00943381f, 0.10340326f, -0.06229593f, -0.00496796f, 0.02669927f, 
    0.05424427f, 0.03270008f, -0.09456138f, 0.11070903f, -0.11151616f, 0.03357144f, -0.09918027f, -0.04543743f, 
    -0.29290760f, -0.48609823f, 0.00304032f, 0.09102032f, -0.15030359f, 0.01767942f, -0.13371855f, 0.15188929f, 
    0.07881284f, 0.01216978f, 0.06260798f, -0.04673265f, -0.04436607f, 0.00606283f, 0.03036688f, -0.14872247f, 
    -0.13185155f, -0.01203222f, 0.09189160f, -0.05646060f, 0.27490565f, -0.29022136f, 0.08773898f, -0.04498113f, 
    -0.11063516f, -0.11743947f, -0.09146512f, 0.05172389f, 0.00972895f, -0.04644983f, -0.12496744f, 0.01639815f, 
    -0.07322987f, -0.01549482f, 0.00264434f, -0.06521589f, -0.05232790f, 0.09661444f, -0.02177037f, 0.09689480f, 
    -0.11374918f, -0.41026822f, 0.32163876f, 0.22518530f, 0.02627024f, -0.04866930f, 0.10000592f, 0.04200951f, 
    0.00404270f, -0.06912809f, -0.16108733f, 0.07933931f, 0.06417280f, 0.05971701f, -0.01758561f, 0.09553040f, 
    -0.12950394f, -0.15924427f, -0.13610619f, -0.12644452f, 0.19209041f, -0.12668498f, 0.04381873f, 0.01243201f, 
    0.30808097f, -0.04219403f, -0.13850406f, -0.04524175f, 0.05512007f, -0.07672308f, -0.11784551f, 0.20881894f, 
    0.06734827f, -0.01723143f, 0.01737363f, -0.01369631f, 0.00754183f, 0.03194341f, -0.09010077f, 0.09973400f, 
    -0.25194699f, 0.04541565f, -0.17238767f, -0.07447778f, -0.36404556f, -0.00583455f, -0.03636823f, -0.04555299f, 
    0.01057909f, 0.05199517f, -0.03376176f, 0.03466934f, 0.09239036f, -0.06689454f, -0.02503491f, -0.08461216f, 
    -0.03871048f, 0.07033176f, -0.08679473f, 0.01949758f, -0.00559739f, 0.05093004f, 0.37586984f, 0.01953212f, 
    -0.09325517f, 0.04105049f, 0.04437084f, 0.03136492f, -0.04966588f, 0.00356625f, 0.01207318f, -0.08138163f, 
    0.00981414f, -0.17625818f, -0.02996574f, 0.06432902f, -0.04768075f, -0.03385302f, 0.10473143f, -0.04054592f, 
    -0.03991937f, 0.29273292f, 0.13394564f, -0.24124806f, -0.32098839f, 0.08951608f, 0.11249609f, -0.01496653f, 
    0.12304033f, -0.05892634f, 0.02048826f, -0.02657635f, 0.04788768f, 0.09010629f, -0.01430379f, 0.01644021f, 
    0.08478076f, -0.02552588f, 0.05041358f, -0.02785252f, -0.30575243f, 0.05705207f, -0.07118159f, -0.22785898f, 
    0.38847941f, -0.14229810f, -0.11001105f, -0.10108085f, 0.05497121f, -0.06264996f, 0.04540880f, -0.04033066f, 
    0.16735390f, 0.00883478f, -0.03762135f, 0.03544394f, 0.11988118f, -0.18927811f, -0.04793788f, -0.03672294f, 
    0.11906392f, -0.15267242f, 0.05321757f, -0.11824049f, 0.11893926f, -0.11195368f, -0.01734812f, -0.15287192f, 
    0.01347637f, 0.01939269f, -0.06680562f, -0.09246396f, 0.10188442f, -0.12577169f, 0.02780374f, -0.02348541f, 
    -0.00274031f, -0.07068483f, 0.09330504f, 0.03464666f, 0.28455818f, -0.24272013f, -0.07130052f, -0.03260148f, 
    -0.49323580f, 0.10527948f, -0.00417686f, 0.12549557f, 0.11130603f, -0.07340432f, 0.01205795f, -0.08774172f, 
    -0.02952352f, 0.05118543f, -0.02902712f, 0.14900997f, 0.02704880f, 0.01342973f, 0.01416676f, 0.06659868f, 
    -0.01354336f, -0.39068577f, -0.04538527f, 0.00697136f, -0.04606410f, 0.11149682f, -0.10756022f, -0.01964296f, 
    -0.01465185f, -0.04662848f, 0.08431473f, 0.05262511f, -0.00648232f, -0.04533572f, -0.14032774f, -0.01050029f, 
    -0.15609345f, 0.00452163f, -0.05035419f, -0.10112171f, 0.25478184f, 0.04098991f, -0.15052664f, 0.00287807f, 
    -0.14549506f, 0.05992341f, -0.00935760f, -0.02411489f, 0.00074763f, 0.12027872f, 0.04962665f, 0.04959706f, 
    -0.02422323f, 0.04020581f, -0.14328928f, 0.06571070f, 0.13637039f, 0.03427576f, -0.06063252f, 0.08359575f, 
    0.02607213f, -0.15933092f, -0.13927022f, -0.10214416f, 0.06594267f, 0.03041380f, -0.05783816f, 0.10716646f, 
    -0.00888426f, 0.01310574f, -0.12726745f, 0.02842084f, 0.09014102f, 0.09719390f, 0.09991752f, -0.04492288f, 
    -0.00941067f, -0.19353679f, -0.10381638f, -0.00341302f, 0.19391234f, -0.14850961f, 0.05571018f, -0.03557323f, 
    -0.20375267f, -0.09027430f, -0.12014557f, 0.02595234f, 0.03899812f, -0.02856437f, 0.03343033f, 0.01994910f, 
    0.04811082f, 0.08342630f, -0.00295171f, -0.11256127f, -0.00236054f, -0.12549888f, -0.15801248f, -0.16704333f, 
    -0.26385769f, 0.10214206f, -0.08013123f, -0.02286045f, -0.21024300f, -0.09346614f, -0.02208561f, -0.13144799f, 
    -0.09293681f, 0.05037256f, -0.01054425f, 0.06082453f, -0.14164427f, -0.06255308f, 0.02604041f, 0.04589204f, 
    0.00211316f, -0.00128524f, -0.00443266f, -0.00577023f, 0.39700121f, -0.00308899f, -0.02284407f, -0.04999308f, 
    0.22791047f, -0.09304754f, -0.13199265f, 0.10133308f, -0.01536589f, 0.01607497f, 0.01050245f, -0.07487969f, 
    -0.00673231f, 0.08347180f, -0.04204125f, -0.06693109f, 0.06168699f, 0.01732554f, -0.04729009f, 0.05388413f, 
    0.12375751f, 0.28905231f, -0.01499167f, 0.06351939f, -0.07683963f, 0.06437425f, -0.06503537f, 0.17049544f, 
    0.05070546f, -0.01465343f, 0.09558097f, -0.09912767f, 0.05203416f, 0.05673704f, -0.08253008f, 0.11615008f, 
    0.15304017f, -0.16331302f, 0.11743665f, -0.09418931f, 0.04360899f, 0.22280002f, 0.17686059f, 0.18771744f, 
    0.20740926f, -0.10541289f, -0.10162857f, 0.02834690f, -0.01790641f, 0.04291037f, -0.01231836f, -0.01621413f, 
    0.05360635f, 0.03969960f, -0.04231314f, 0.01892839f, 0.08896372f, -0.04535120f, -0.00531798f, 0.04695696f, 
    0.13701476f, 0.04874698f, -0.16539705f, 0.06729037f, -0.31337139f, -0.08655178f, 0.18167727f, 0.02216934f, 
    -0.05083878f, 0.18814690f, 0.07336891f, -0.03136309f, 0.01035296f, 0.00217990f, 0.06450909f, -0.03417884f, 
    0.11493573f, 0.06080440f, 0.02055738f, -0.00832302f, -0.06114884f, 0.10365602f, -0.05500858f, -0.04362725f, 
    0.11633925f, 0.01629458f, 0.01717517f, 0.02368064f, -0.24253406f, -0.11271518f, -0.03060893f, 0.07899588f, 
    0.07309896f, 0.01834206f, -0.02207930f, 0.10120117f, -0.08584405f, 0.04045084f, 0.13905808f, 0.08017277f, 
    -0.31945205f, 0.22161579f, 0.03668113f, -0.01464242f, 0.17363863f, -0.06430043f, 0.03349920f, -0.09641253f, 
    -0.11564707f, -0.00659131f, 0.16589604f, 0.12956904f, 0.09648228f, -0.01889119f, 0.07734548f, -0.01620676f, 
    0.00796749f, 0.15746953f, -0.08872669f, 0.02831697f, -0.04824498f, -0.09991014f, 0.12806064f, -0.04614332f, 
    -0.21296072f, 0.12508793f, 0.02652526f, -0.00047454f, 0.12205929f, -0.04842026f, 0.01239889f, 0.01619428f, 
    0.06241821f, 0.02360746f, 0.05647230f, 0.03977563f, 0.01959696f, -0.22983573f, -0.04906350f, 0.05520617f, 
    -0.02954568f, -0.19265938f, -0.23627897f, -0.03353295f, -0.24120684f, 0.02088096f, -0.02931879f, 0.01585711f, 
    0.08602328f, 0.06852784f, 0.00283823f, 0.06489443f, 0.00881689f, -0.09892648f, -0.01255344f, -0.01638612f, 
    0.00742232f, -0.09828033f, 0.04613167f, -0.05111589f, 0.03113488f, -0.15444541f, 0.13452142f, -0.03375419f, 
    0.16708772f, -0.00183054f, -0.09310165f, 0.03448385f, -0.04582233f, -0.00456543f, -0.11918249f, 0.01021174f, 
    -0.04137632f, 0.00412248f, -0.03272785f, -0.08228239f, -0.04344000f, -0.17099205f, 0.04306962f, -0.04089806f, 
    0.31073451f, -0.00724406f, 0.07820952f, 0.23841242f, 0.03981236f, -0.04084245f, -0.15619253f, 0.06448981f, 
    0.02848277f, 0.02820335f, -0.02036920f, 0.07807807f, -0.17046979f, 0.11567473f, -0.04977802f, 0.10633648f, 
    -0.01537011f, 0.05430149f, -0.08086937f, -0.09266183f, 0.35464516f, 0.02356567f, 0.05272026f, 0.00800104f, 
    0.09615565f, 0.01660151f, -0.01305354f, -0.00542762f, 0.03645950f, 0.14748862f, 0.06318743f, 0.02773385f, 
    0.01112903f, -0.11330183f, -0.08267538f, -0.02997844f, 0.03037383f, 0.05269257f, 0.10541037f, 0.13280281f, 
    0.07654208f, -0.12494792f, -0.00686071f, -0.02893940f, 0.22391513f, -0.09753946f, -0.03058593f, 0.01247853f, 
    0.05564645f, -0.00198159f, -0.07054783f, -0.17836581f, 0.06186530f, -0.20293163f, 0.08612850f, 0.00635577f, 
    -0.02495085f, -0.04769775f, 0.03214112f, 0.01435182f, -0.37243104f, 0.10903903f, -0.18974127f, 0.01536080f, 
    -0.18144964f, 0.04701615f, -0.05860653f, 0.06710191f, -0.00748029f, 0.01238171f, 0.03660000f, 0.14712408f, 
    -0.01388338f, -0.14267997f, -0.02573460f, 0.01975166f, -0.00834390f, 0.00482609f, 0.03103915f, -0.08563134f, 
    0.27023920f, -0.49094638f, 0.00840668f, -0.07229602f, -0.16154604f, 0.02810725f, 0.05302702f, -0.07114567f, 
    0.02491264f, 0.11291726f, -0.07375818f, -0.06445995f, -0.13272806f, 0.10416225f, -0.03649346f, 0.13085043f, 
    0.10548829f, -0.02222470f, -0.01550213f, 0.01825516f, -0.43779269f, -0.35226706f, -0.34439117f, -0.32575193f, 
    0.22501162f, 0.07499852f, -0.03770656f, -0.00452495f, -0.06194829f, 0.06945080f, 0.12508653f, 0.13664067f, 
    0.09812913f, -0.02734281f, 0.04801827f, -0.00440502f, -0.08210915f, -0.21977858f, -0.09350514f, 0.04220542f, 
    -0.06735644f, 0.43150851f, 0.03806265f, -0.04919903f, 0.35793522f, -0.11794142f, 0.13100995f, -0.04004712f, 
    -0.07491350f, 0.10722500f, 0.01603160f, -0.10111070f, 0.18300949f, -0.00105154f, 0.02970112f, -0.01838863f, 
    -0.02255792f, 0.03205560f, -0.01676773f, -0.07756051f, 0.32145324f, -0.36784604f, 0.01816208f, -0.18734215f, 
    -0.13643689f, 0.01108325f, -0.06526214f, -0.05713873f, -0.02693581f, -0.04057993f, -0.07660968f, 0.05456559f, 
    -0.09261452f, -0.12353253f, 0.14306131f, -0.10584641f, 0.01581646f, -0.14055480f, 0.10281207f, -0.07422552f, 
    -0.05996130f, -0.25601643f, 0.01158404f, -0.05732431f, -0.06076078f, -0.01838019f, -0.03740828f, -0.00957670f, 
    0.04709563f, 0.00176535f, -0.24709947f, -0.07182465f, 0.08645804f, 0.00101803f, 0.05268658f, 0.09936162f, 
    -0.06176665f, -0.04713623f, -0.05688003f, -0.11446120f, 0.04697601f, 0.11254115f, 0.06260751f, 0.00762789f, 
    0.06019424f, -0.04136312f, -0.12414869f, 0.04508191f, 0.03685888f, 0.15797774f, 0.16546860f, -0.00752730f, 
    0.06251904f, 0.02516984f, -0.00750273f, -0.00568035f, -0.01531427f, -0.02923458f, 0.06014644f, 0.09506276f, 
    0.05376847f, -0.41303775f, -0.04611300f, -0.44837537f, -0.01546010f, -0.03706655f, -0.11180878f, 0.02528253f, 
    0.09799127f, 0.05184539f, -0.10717145f, -0.04786277f, -0.08461457f, -0.06401291f, 0.04157269f, -0.22981010f, 
    -0.05975390f, -0.22592095f, 0.07521322f, -0.20104954f, 0.32869846f, -0.69372010f, 0.14556517f, -0.20803460f, 
    -0.21969862f, -0.00093213f, 0.00730773f, -0.14906819f, -0.02365219f, -0.19880928f, -0.04860981f, -0.12494881f, 
    -0.06385855f, 0.09851478f, -0.07108776f, 0.07199894f, 0.01432278f, -0.24009594f, 0.09601962f, -0.04376836f, 
    0.37814152f, -0.39905807f, -0.13606344f, 0.12309961f, 0.03084041f, -0.11915014f, 0.02898221f, 0.03172151f, 
    0.02751862f, 0.05470948f, 0.05060619f, -0.02917310f, 0.03890080f, 0.08600151f, -0.06849866f, 0.16334181f, 
    0.04284114f, 0.00088386f, -0.13562025f, 0.14475170f, -0.40163669f, 0.14155547f, -0.19725998f, 0.02007373f, 
    -0.19125226f, -0.05095637f, -0.01332365f, 0.00705167f, 0.01852735f, 0.02450998f, -0.05604707f, 0.18452755f, 
    -0.08034570f, -0.00413296f, -0.01270126f, 0.04331830f, -0.09234205f, 0.03449744f, 0.02012655f, 0.09614664f, 
    0.28542927f, 0.03045071f, -0.19570638f, 0.07006641f, -0.13464275f, -0.08858523f, 0.06117539f, -0.07061345f, 
    -0.06349972f, 0.02971240f, 0.00751607f, 0.07534425f, -0.12921210f, -0.05741398f, 0.08911481f, 0.09551622f, 
    -0.01665425f, -0.01808354f, -0.07935014f, 0.06379324f, 0.31012958f, 0.16015780f, 0.15883066f, -0.00218955f, 
    0.02012484f, -0.01804215f, -0.00314251f, -0.10982668f, 0.07104264f, -0.10229406f, -0.06360586f, -0.03165238f, 
    -0.19309254f, 0.11678129f, -0.02985986f, 0.00598567f, -0.04241796f, 0.14199975f, -0.03816556f, 0.04031613f, 
    -0.07169669f, 0.02193900f, 0.13052258f, 0.03693875f, -0.08780345f, 0.04947909f, -0.11647487f, 0.03367054f, 
    0.03467502f, -0.02035220f, 0.02474369f, 0.01857633f, -0.01018522f, 0.15512702f, -0.02234220f, -0.04304657f, 
    -0.10660009f, -0.10923438f, -0.05120598f, -0.13940617f, 0.07092153f, 0.04664628f, -0.08746555f, -0.02963265f, 
    -0.17273504f, -0.05090755f, 0.03096744f, -0.10834307f, -0.09469876f, 0.14654015f, 0.17354175f, -0.01837255f, 
    0.03691730f, 0.00264707f, -0.06284023f, -0.07700497f, 0.02313364f, -0.15376322f, -0.00184079f, -0.04300964f, 
    0.41356084f, 0.29806966f, -0.13590384f, -0.18098544f, -0.15130916f, -0.04303606f, 0.03536106f, 0.08996437f, 
    0.01210214f, 0.00700163f, -0.05859073f, -0.00980436f, -0.12646222f, -0.06982069f, -0.10311338f, 0.05077703f, 
    0.02941616f, -0.05107312f, 0.12567998f, 0.00206418f, 0.29718795f, 0.03450281f, 0.15812828f, 0.09507743f, 
    0.19834198f, -0.23319106f, -0.09695163f, -0.12804580f, 0.07953153f, -0.03267379f, 0.08333048f, -0.13295287f, 
    -0.05666817f, -0.01200296f, -0.04447613f, -0.04956633f, 0.00715335f, -0.06585209f, 0.01351088f, -0.01244448f, 
    -0.04821793f, 0.04981125f, -0.09640501f, -0.14048505f, -0.00505540f, 0.12647752f, 0.07033348f, 0.09651190f, 
    -0.22186707f, -0.15133017f, -0.08763831f, 0.08082019f, -0.06479508f, -0.03511514f, -0.04719926f, 0.05068459f, 
    0.02688848f, 0.13252056f, -0.06324097f, -0.03435332f, 0.25555602f, -0.38599771f, -0.26839629f, 0.02724355f, 
    -0.26135507f, -0.18319640f, 0.01957669f, -0.03000294f, -0.08971959f, -0.09141202f, -0.05477500f, 0.09451717f, 
    0.07587830f, 0.06212973f, -0.02592782f, -0.04290947f, -0.08910150f, 0.06085008f, 0.00891017f, -0.00300819f, 
    0.19547603f, 0.01203777f, -0.04211424f, 0.04193081f, -0.08244205f, -0.06493174f, -0.01526806f, 0.04199001f, 
    0.04298237f, 0.05521209f, 0.02042068f, -0.04026080f, -0.02028043f, -0.01328826f, -0.01016263f, -0.01517175f, 
    -0.04216882f, -0.05497524f, 0.03735936f, 0.01950409f, 0.10721447f, 0.14052203f, -0.08092040f, -0.30024996f, 
    0.12305348f, 0.09748657f, 0.01955447f, -0.00156905f, -0.00233269f, -0.02464650f, -0.12711334f, 0.03368089f, 
    -0.07928650f, -0.10603108f, 0.02292877f, 0.00486071f, 0.06302615f, 0.00817040f, -0.04385844f, -0.05404282f, 
    -0.01279282f, -0.02351117f, 0.09675906f, -0.09025006f, 0.03849720f, -0.09957433f, -0.10488189f, -0.26504937f, 
    0.00156000f, 0.09417522f, -0.08616675f, 0.03651147f, -0.00057382f, -0.08213910f, -0.03038003f, -0.01461003f, 
    0.02092341f, 0.12629810f, 0.08581548f, 0.02324711f, -0.12135731f, 0.14545333f, 0.13767655f, -0.08461860f, 
    0.05326213f, 0.02127333f, 0.06577145f, 0.14129619f, -0.05284610f, -0.10828213f, -0.02599782f, 0.03791873f, 
    0.01194596f, 0.04097653f, 0.08530749f, 0.03717921f, -0.06520485f, -0.13604517f, -0.00703118f, -0.02408889f, 
    0.10231600f, -0.16879031f, 0.01679395f, -0.09817193f, 0.07431865f, -0.09762634f, 0.02277872f, 0.06200818f, 
    -0.00878085f, -0.09832396f, 0.11840945f, -0.08892330f, 0.01766683f, -0.11261740f, 0.07429549f, 0.06902172f, 
    -0.03272068f, 0.01383123f, 0.04052674f, 0.01426316f, 0.22831456f, 0.28677160f, 0.04985316f, -0.00294789f, 
    0.03435665f, 0.04718975f, 0.06056421f, -0.01963267f, 0.04347236f, 0.04147135f, -0.08612296f, 0.07898984f, 
    0.12414666f, 0.14974971f, -0.01096912f, -0.09626337f, 0.08407837f, -0.01539859f, -0.03538723f, -0.01683060f, 
    0.36118445f, 0.11355253f, -0.13797058f, -0.18197455f, 0.02417258f, -0.01005107f, -0.12149341f, 0.10095196f, 
    0.03550394f, 0.06735478f, -0.05906282f, -0.04675307f, 0.13108630f, 0.12782784f, -0.11768674f, -0.04381991f, 
    -0.10631593f, -0.04170902f, -0.10024632f, -0.01172748f, -0.22175936f, -0.03403429f, 0.11154129f, -0.23393507f, 
    -0.16121881f, 0.07583313f, 0.14159286f, 0.01056231f, -0.09303050f, -0.02877206f, 0.08688562f, -0.00854998f, 
    0.10054568f, -0.08860777f, -0.01494921f, 0.03488542f, 0.03991129f, 0.02063880f, -0.01909933f, -0.08243009f, 
    0.27460515f, -0.25732544f, 0.19233371f, 0.00650315f, 0.20034447f, 0.04216153f, -0.07914381f, -0.09759168f, 
    -0.04041981f, 0.11818916f, 0.03189020f, -0.01419682f, -0.11048090f, 0.07821555f, 0.05098790f, 0.00199479f, 
    -0.07572158f, -0.04741117f, -0.04344628f, -0.00767254f, 0.24369425f, -0.21884884f, 0.06413880f, -0.08461388f, 
    0.06196294f, 0.12296680f, -0.03108609f, 0.18917754f, -0.09080075f, 0.00020809f, 0.02017291f, 0.06041714f, 
    0.07578344f, -0.09189988f, -0.13496841f, 0.08207992f, -0.01741483f, 0.05931765f, -0.09993764f, -0.01587792f, 
    -0.08507369f, 0.19734971f, -0.03855653f, -0.15879001f, 0.13612109f, 0.05040992f, -0.04121824f, 0.14561357f, 
    0.05492882f, -0.08154061f, -0.12717265f, 0.04541182f, 0.00635597f, -0.01472855f, -0.00784121f, -0.10078476f, 
    0.03974909f, 0.02898335f, -0.05348506f, -0.02042039f, -0.40258563f, 0.12801765f, 0.10965052f, -0.20693822f, 
    0.08034802f, 0.07879513f, 0.00670241f, -0.01477547f, 0.08217721f, 0.02205559f, -0.09411719f, -0.01902862f, 
    0.02094513f, -0.08553293f, 0.05289849f, -0.04935613f, -0.01473103f, -0.08605206f, -0.10494681f, -0.00279506f, 
    0.09589546f, -0.36306316f, -0.08367594f, -0.01777631f, -0.06076580f, 0.13529681f, 0.10888419f, 0.10796541f, 
    -0.07263726f, 0.04101796f, 0.01644954f, 0.07878023f, -0.06548013f, -0.05056630f, -0.12252285f, -0.03629538f, 
    -0.04642047f, -0.01080309f, -0.18681754f, -0.02564116f, 0.39071721f, -0.03121611f, 0.09549347f, 0.02684022f, 
    0.29066563f, -0.00569106f, -0.14779310f, -0.23667385f, 0.09061705f, 0.14841510f, 0.01619926f, -0.04256624f, 
    -0.02880850f, 0.04468727f, 0.08252968f, -0.01354075f, -0.09601072f, 0.01085317f, -0.00660070f, -0.02974692f, 
    -0.01997913f, -0.19799109f, 0.09867203f, -0.27426043f, -0.13083930f, -0.02992831f, -0.02060738f, 0.03718807f, 
    -0.01839608f, 0.02661965f, 0.00991623f, -0.00103588f, 0.02793122f, -0.09906587f, -0.04654576f, 0.04246186f, 
    -0.07616770f, -0.11974968f, -0.00834778f, -0.06229164f, -0.14862379f, -0.37633535f, -0.05350970f, -0.29452837f, 
    -0.28346059f, 0.12942563f, -0.09171238f, 0.10411194f, -0.03419080f, -0.04495948f, -0.12203727f, -0.03684133f, 
    0.04335639f, -0.05381194f, -0.17665735f, 0.03829641f, -0.05722461f, 0.11725585f, 0.08527631f, 0.01212885f, 
    0.23161379f, -0.10427965f, 0.01830485f, -0.22708853f, -0.09972893f, 0.07142951f, 0.01899387f, 0.06906530f, 
    -0.04490772f, 0.04352201f, -0.02346617f, 0.09073956f, 0.05845472f, 0.04012312f, 0.05236167f, -0.04192673f, 
    -0.08675625f, -0.04065907f, -0.19916779f, -0.03639150f, 0.10478284f, -0.03636391f, 0.06463579f, -0.27537361f, 
    -0.12409319f, 0.07518559f, -0.18046699f, 0.01859161f, 0.01280167f, -0.02224452f, -0.15615681f, -0.01924455f, 
    0.03692865f, 0.04068295f, -0.00772893f, -0.01337157f, -0.10834158f, 0.08287371f, -0.00197373f, -0.03854633f, 
    0.48549998f, -0.30153134f, -0.09070978f, -0.14017227f, -0.50075746f, 0.02475910f, 0.09905270f, -0.07942683f, 
    -0.13738750f, 0.09418344f, 0.09173726f, 0.09657045f, -0.10046283f, -0.14027394f, -0.02257852f, -0.14713654f, 
    0.06293346f, 0.13859570f, -0.06256167f, 0.00450612f, -0.41759998f, 0.14556523f, 0.01161325f, 0.01475657f, 
    0.05138506f, 0.08652611f, 0.03275381f, 0.02999987f, 0.05686172f, -0.06121900f, -0.06055180f, -0.01154908f, 
    -0.03570119f, -0.01060741f, 0.06795446f, -0.08427376f, -0.00328801f, -0.01785038f, -0.10311718f, 0.01827065f, 
    -0.35612950f, -0.55442268f, 0.02824769f, -0.16889644f, -0.49229434f, -0.04484519f, -0.13158713f, 0.02112678f, 
    -0.02455170f, 0.04877085f, -0.10746104f, 0.06199676f, -0.05969259f, 0.08538699f, -0.02413666f, -0.10497259f, 
    -0.07171980f, 0.11340135f, 0.00126830f, -0.02895958f, -0.15761985f, -0.18519823f, 0.11931724f, -0.23843776f, 
    -0.06165254f, 0.00426728f, -0.19618535f, 0.04505283f, 0.11157247f, 0.02508603f, -0.03570664f, 0.05213871f, 
    -0.00668247f, -0.03494861f, -0.00716375f, 0.07747710f, -0.12578321f, -0.01785299f, -0.07373422f, -0.04055705f, 
    0.32546842f, -0.04578708f, 0.01800010f, 0.01098879f, 0.02507000f, -0.18429095f, 0.05319478f, -0.03345273f, 
    -0.03934839f, -0.05211996f, 0.09157798f, -0.06916888f, 0.03697257f, 0.09428629f, -0.01483886f, 0.04726529f, 
    -0.03527856f, -0.03460646f, -0.11323023f, -0.04363954f, 0.41643229f, 0.08606793f, 0.00843668f, -0.01895553f, 
    0.18076666f, -0.15721703f, -0.03085751f, -0.03426223f, 0.02208264f, 0.01921268f, -0.05634744f, -0.00808562f, 
    -0.02218075f, -0.03846990f, 0.05060039f, 0.00663390f, 0.04381439f, -0.06633859f, 0.00817056f, -0.04337265f, 
    0.22759448f, -0.09513897f, 0.18981493f, 0.12405865f, 0.24936543f, -0.02219743f, -0.06767440f, -0.11383212f, 
    0.01432255f, 0.07498557f, 0.05953714f, 0.00219380f, 0.01274047f, 0.02777589f, 0.03640427f, 0.00124949f, 
    -0.02916606f, 0.00377808f, -0.06495187f, 0.00180423f, 0.00046676f, 0.02223484f, -0.11622918f, 0.04743508f, 
    -0.10693375f, 0.06639399f, 0.01584597f, 0.10591021f, 0.05109643f, -0.00342804f, -0.00971874f, 0.05974591f, 
    0.08637839f, 0.03367405f, -0.02951168f, -0.06455708f, -0.02710620f, -0.00012784f, -0.03085613f, -0.07798236f, 
    -0.33954942f, 0.15841947f, -0.01629885f, -0.19115174f, -0.00116177f, 0.01394933f, 0.09073157f, 0.05802694f, 
    -0.01572484f, -0.05893528f, -0.02908002f, 0.04381263f, 0.07955093f, -0.06023304f, 0.02287727f, -0.02558486f, 
    0.01733447f, 0.01553029f, 0.01548987f, -0.04679042f, -0.35250077f, -0.05121710f, 0.07042655f, 0.16325904f, 
    0.15687388f, -0.10162190f, -0.07829609f, -0.20169517f, 0.01824736f, -0.01216138f, -0.05467450f, -0.04397774f, 
    -0.09944258f, 0.10504552f, 0.08826339f, -0.02803786f, -0.02957413f, -0.14380914f, 0.03286485f, -0.00571198f, 
    -0.41594833f, 0.27311590f, -0.07760358f, 0.28333750f, 0.08326192f, -0.01126287f, 0.22403683f, 0.01153677f, 
    0.10204822f, -0.02672545f, -0.09133892f, 0.01473377f, 0.01769476f, -0.06728813f, 0.06250986f, 0.01114183f, 
    0.00838160f, 0.03594332f, 0.09747308f, -0.02647631f, -0.12178699f, -0.01266638f, -0.08791134f, -0.06712565f, 
    -0.21560748f, -0.02635460f, -0.09562852f, 0.02409136f, -0.09068643f, -0.03994669f, -0.16391516f, -0.06580818f, 
    0.05155540f, 0.00921955f, 0.08015688f, 0.06235092f, -0.09326958f, 0.00038052f, 0.07816572f, 0.04119463f, 
    0.02241545f, -0.05770614f, -0.13109247f, 0.13503103f, 0.28390896f, 0.03797233f, 0.22828078f, 0.00501616f, 
    0.02062922f, 0.06397685f, 0.02857163f, -0.00475551f, -0.05387700f, -0.16976826f, -0.13896586f, 0.02734560f, 
    0.03249881f, 0.01970647f, 0.07982406f, -0.08710244f, 0.05406428f, 0.08064163f, 0.14212598f, 0.11647794f, 
    -0.04436179f, -0.14189716f, -0.16166942f, 0.07566703f, -0.01443888f, -0.03287547f, -0.04992050f, -0.01191377f, 
    0.02351643f, -0.05561246f, 0.06635707f, 0.01765210f, 0.09357250f, 0.21542338f, 0.13143902f, 0.02451975f, 
    0.33698300f, -0.25524399f, 0.10237906f, -0.03264822f, -0.11121761f, 0.03765235f, -0.06203468f, 0.00107320f, 
    -0.07773886f, -0.02640685f, -0.15617912f, -0.00482943f, -0.00578392f, 0.03222558f, 0.13864177f, -0.02625467f, 
    0.07144363f, 0.08791651f, -0.03611427f, -0.02269536f, -0.20470308f, 0.05292059f, -0.12788981f, -0.12559341f, 
    0.25722557f, -0.06770974f, 0.12912855f, 0.02941697f, -0.05140083f, 0.10939453f, -0.07947781f, 0.00868476f, 
    0.13219345f, 0.07387319f, 0.02494762f, 0.04079581f, -0.00837705f, -0.03594553f, -0.00679088f, 0.19136372f, 
    0.08464824f, 0.15296383f, -0.12814857f, -0.05084840f, -0.03626319f, -0.12273873f, -0.02762931f, -0.08756822f, 
    0.08974476f, 0.06051199f, -0.08693213f, -0.01528890f, 0.04899644f, -0.08958732f, 0.02897774f, -0.02379172f, 
    -0.12538946f, -0.06984945f, -0.09004858f, 0.03898201f, -0.21019037f, -0.72047526f, -0.36758375f, 0.20516258f, 
    0.04335688f, -0.11170569f, -0.13247590f, -0.00195051f, 0.00448931f, -0.15013324f, -0.01168577f, 0.03606874f, 
    -0.13872539f, -0.12250271f, 0.09760588f, -0.04608690f, -0.12978588f, 0.04148404f, -0.09615478f, -0.13326879f, 
    0.29634684f, -0.19498546f, 0.05990319f, -0.17454405f, -0.14820449f, -0.03780681f, -0.08955713f, -0.09452334f, 
    -0.04037741f, -0.09753253f, 0.09644743f, -0.02692535f, 0.02783841f, -0.05640583f, -0.03309787f, -0.04833536f, 
    0.01103636f, -0.03911656f, 0.06713203f, 0.03406565f, 0.17005439f, 0.04056899f, -0.12905420f, 0.04013124f, 
    -0.02149668f, -0.00184956f, -0.04914111f, -0.05059486f, 0.14905854f, -0.12938480f, 0.06834086f, -0.01106281f, 
    -0.04197908f, 0.11452018f, -0.04473449f, -0.02133875f, 0.08009917f, -0.03853869f, 0.03740307f, 0.04682105f, 
    -0.86465740f, -0.06601691f, 0.05233029f, -0.25594455f, -0.31198582f, -0.16438718f, -0.10879961f, -0.06614824f, 
    0.14847296f, -0.07164913f, -0.07164665f, -0.05201322f, -0.02535082f, -0.02117474f, 0.02684341f, -0.03856546f, 
    0.08329947f, -0.16433045f, 0.09922359f, 0.10281787f, 0.02105558f, 0.05886035f, 0.03228154f, 0.23448803f, 
    0.10550991f, 0.00013108f, 0.17907605f, 0.03403268f, 0.03364550f, 0.09734724f, -0.04850429f, 0.04166596f, 
    -0.03620563f, -0.19002923f, -0.05156129f, 0.00235615f, -0.03043351f, 0.12745990f, 0.08608063f, -0.12856589f, 
    0.01201927f, 0.02708351f, -0.16101930f, 0.02953468f, 0.06148354f, -0.00645645f, -0.13000010f, 0.06397102f, 
    0.01164439f, -0.05683280f, -0.07249692f, 0.00082248f, 0.04214915f, -0.00492618f, -0.01365130f, 0.05785111f, 
    -0.00014195f, 0.08370351f, -0.00279818f, 0.07541092f, 0.20925395f, 0.03799252f, -0.40070298f, 0.14449973f, 
    0.13682730f, -0.11378787f, -0.04614861f, -0.02786852f, 0.08952327f, 0.03261805f, -0.03160655f, -0.05151844f, 
    -0.06550708f, -0.04966262f, 0.05048388f, -0.09854447f, 0.02401193f, 0.11947578f, -0.01751004f, -0.05320387f, 
    -0.05587174f, -0.69823033f, -0.39951223f, -0.10510791f, 0.11700641f, -0.09246527f, 0.05825087f, 0.00602732f, 
    -0.02171473f, -0.05468340f, 0.04462650f, 0.02141771f, -0.01322084f, 0.02433220f, 0.09139765f, -0.04964144f, 
    -0.02052434f, -0.00402055f, -0.04429544f, 0.01301186f, -0.33044234f, -0.35122585f, -0.34720799f, -0.07622391f, 
    -0.05845214f, -0.08784024f, 0.00049499f, -0.02425920f, -0.02452268f, -0.08085053f, -0.04889000f, -0.07374160f, 
    0.03185297f, -0.05633647f, -0.02848601f, 0.09709073f, -0.09218226f, 0.03048122f, -0.03628396f, 0.10439672f, 
    0.34010795f, -0.25596160f, -0.25487554f, 0.01950146f, 0.26594517f, 0.03005449f, -0.01248053f, -0.03726037f, 
    -0.05925661f, 0.03702409f, -0.04135128f, -0.02187719f, -0.02410666f, 0.13243796f, -0.01253141f, 0.05321144f, 
    0.11988694f, 0.04952599f, 0.09487688f, 0.03066589f, -0.10046396f, 0.11176854f, -0.20718881f, -0.07343361f, 
    -0.01763396f, -0.08590172f, -0.20133182f, 0.04429771f, 0.14212038f, -0.11714710f, -0.10060225f, -0.05582484f, 
    -0.11428807f, -0.05524859f, 0.04270962f, -0.25699952f, -0.11236200f, -0.01481191f, -0.05640530f, 0.05227344f, 
    0.17331910f, 0.01738694f, 0.02270208f, 0.13135517f, -0.01506914f, -0.09375550f, -0.03104076f, -0.02086461f, 
    0.06186580f, 0.01222244f, -0.01140043f, -0.01717143f, 0.07051396f, -0.02313991f, 0.04666196f, -0.07272994f, 
    0.06700362f, -0.00747251f, -0.05059910f, -0.02318336f, 0.66129601f, 0.39389855f, -0.06804001f, 0.18467024f, 
    0.08089433f, 0.08248138f, 0.12251153f, 0.08673819f, 0.10140394f, 0.06094023f, -0.05209898f, -0.09759677f, 
    -0.07716985f, -0.05882924f, 0.00252825f, -0.05512559f, 0.01702059f, 0.10026270f, -0.01352385f, 0.08548302f, 
    0.14777778f, -0.03963216f, -0.05049589f, 0.00126981f, -0.14371482f, -0.06193577f, -0.03106095f, -0.13887781f, 
    0.20318529f, -0.00686025f, -0.06481352f, -0.02157445f, -0.02569839f, 0.07360014f, -0.14442366f, 0.07390735f, 
    0.00281752f, -0.11686652f, 0.11146683f, 0.11077097f, 0.08851147f, -0.05199772f, 0.02247268f, 0.03550179f, 
    -0.07863189f, -0.01418929f, -0.00345277f, 0.04576802f, -0.02989173f, 0.07080561f, -0.05876438f, -0.06440187f, 
    -0.04558999f, 0.01077435f, -0.04649959f, -0.06264374f, -0.04265663f, 0.06571294f, -0.14641380f, 0.02905168f, 
    0.22435549f, 0.14305712f, 0.14740552f, 0.13812535f, -0.02269843f, -0.02392808f, -0.03453812f, -0.04757294f, 
    -0.11235497f, -0.01257224f, 0.01440208f, 0.02643397f, 0.03266819f, -0.08503684f, 0.06788731f, 0.05643892f, 
    0.00228706f, 0.11344516f, 0.00150029f, 0.15054519f, -0.27187076f, -0.45322451f, -0.36477038f, 0.02161966f, 
    0.01300904f, -0.02238279f, 0.03953478f, 0.00874818f, 0.06083592f, -0.11699398f, 0.04143536f, -0.04410817f, 
    -0.03876312f, 0.05253451f, -0.05788890f, -0.01369023f, 0.09370366f, 0.05190239f, -0.00519316f, 0.01179262f, 
    0.26168427f, 0.05177638f, 0.26252729f, -0.00341912f, -0.16454826f, 0.09617618f, 0.13862838f, -0.01198735f, 
    -0.00523283f, 0.02892620f, -0.00795876f, -0.00116646f, -0.05587558f, -0.05265381f, -0.05695950f, 0.03827723f, 
    0.00024664f, -0.00530191f, -0.03213986f, 0.10093722f, -0.09902502f, 0.16215235f, -0.02843801f, 0.19275944f, 
    -0.04877023f, -0.03843838f, 0.02015208f, 0.02597196f, 0.10714042f, -0.09244734f, -0.05005157f, -0.03259670f, 
    0.05667089f, 0.06651800f, -0.07625687f, -0.00049248f, -0.13799264f, 0.05826057f, -0.10360842f, -0.01472700f, 
    0.00608332f, 0.07059670f, 0.09000044f, 0.08007278f, -0.11222756f, -0.04408956f, -0.15139197f, 0.02311665f, 
    -0.01584390f, 0.00758778f, -0.04925580f, 0.08779328f, 0.01679081f, 0.02782306f, 0.01477982f, -0.02952427f, 
    0.07324158f, 0.01036394f, 0.04840309f, 0.00012702f, -0.17483450f, 0.05195150f, 0.07400486f, -0.11819503f, 
    -0.04785528f, -0.06268580f, -0.15616754f, -0.03350142f, 0.05902288f, -0.05430026f, 0.07009253f, -0.01234007f, 
    0.01608180f, -0.01551819f, -0.09475011f, -0.07263859f, 0.00126423f, -0.09564739f, -0.01663436f, -0.05417145f, 
    -0.01266074f, -0.15774724f, -0.05594768f, -0.05964931f, -0.15277070f, -0.04300778f, -0.19254005f, 0.15536341f, 
    -0.08891729f, -0.01336870f, -0.09086306f, 0.07461478f, -0.02170467f, -0.01496084f, 0.00433961f, 0.06674137f, 
    -0.03059373f, 0.03811001f, 0.10688996f, 0.04855895f, -0.13464105f, -0.59880728f, -0.19766003f, -0.11972402f, 
    -0.02037250f, -0.15484497f, 0.06222475f, -0.00317558f, 0.01280060f, -0.05081582f, -0.01428469f, 0.01431236f, 
    0.00224049f, 0.01979828f, 0.08774591f, -0.00789451f, 0.02851760f, -0.02261462f, -0.01104507f, 0.02891942f, 
    0.11704105f, -0.26486960f, -0.01616368f, 0.23445548f, 0.21281414f, 0.04099676f, 0.11448307f, 0.03149208f, 
    -0.05449867f, -0.02244332f, 0.08868898f, 0.03228037f, -0.04421515f, -0.10171402f, -0.07036150f, -0.04182122f, 
    -0.08587316f, -0.03061809f, 0.01835156f, -0.04023022f, 0.02661644f, 0.10379368f, -0.13974369f, -0.01005237f, 
    -0.01093800f, -0.04283704f, 0.00286796f, -0.00314922f, 0.06886461f, 0.02482379f, -0.06389628f, 0.00852748f, 
    0.03367722f, -0.00729227f, 0.00530816f, -0.04352926f, -0.00239249f, 0.05953486f, -0.06278726f, -0.00680406f, 
    -0.67443949f, -0.13462079f, -0.00894690f, -0.08721184f, -0.12556942f, -0.00564316f, 0.01600463f, 0.08013397f, 
    -0.08332507f, 0.03166387f, 0.02160901f, -0.03302925f, 0.07938687f, -0.11279066f, -0.02853209f, -0.06821337f, 
    0.03048574f, 0.03274171f, 0.07570221f, -0.02259320f, -0.71478134f, 0.17428195f, 0.10122164f, 0.04930259f, 
    0.16479520f, 0.04611695f, -0.06548093f, -0.05165006f, -0.02315561f, 0.07952202f, 0.02715355f, 0.09344935f, 
    -0.04385663f, 0.01314337f, 0.09774061f, 0.02242867f, 0.03136510f, 0.01744226f, 0.07439886f, -0.14794077f, 
    -0.32696417f, -0.37335685f, 0.22079091f, 0.24797118f, -0.04740928f, -0.16996433f, -0.00069396f, -0.01020001f, 
    -0.08767205f, -0.02855038f, 0.00206685f, 0.00605634f, -0.05616161f, -0.09684114f, 0.06205289f, -0.02084109f, 
    -0.01570282f, 0.04947692f, 0.12504037f, 0.06975033f, -0.05905570f, -0.01384456f, -0.03848404f, 0.05008429f, 
    0.16343492f, 0.08912300f, -0.03783728f, -0.00951299f, 0.13226925f, 0.04911731f, 0.04976072f, -0.01658475f, 
    0.02762356f, -0.02372309f, 0.05365113f, -0.00438607f, 0.11398128f, -0.00749513f, 0.16383401f, -0.01553239f, 
    -0.16463940f, -0.04949035f, 0.01219287f, -0.00886917f, 0.21841589f, -0.03133172f, 0.04183177f, -0.04350714f, 
    0.07722785f, 0.07273670f, -0.13690418f, -0.10746999f, 0.02866175f, 0.14001606f, -0.10805357f, -0.08058473f, 
    0.00467680f, -0.10880603f, -0.04520058f, -0.10704432f, 0.02754835f, 0.07792919f, 0.36203349f, 0.15767702f, 
    -0.10923224f, -0.05083285f, -0.07444403f, -0.02726730f, -0.00336657f, 0.01627313f, 0.10400346f, 0.03144627f, 
    -0.06365003f, -0.07339243f, 0.01861218f, 0.01764531f, 0.05402489f, -0.07724991f, -0.09600526f, 0.02002733f, 
    -0.01058540f, 0.08882729f, 0.08237489f, -0.07911367f, 0.10673662f, 0.11174272f, 0.05500276f, 0.03172298f, 
    0.04686271f, -0.01088980f, 0.11614594f, -0.05761946f, -0.11441002f, -0.05020995f, -0.00657814f, -0.00883701f, 
    -0.15773331f, -0.17021285f, -0.05932919f, 0.10812104f, -0.20328958f, -0.31751955f, -0.03930952f, -0.00511796f, 
    0.03638816f, -0.08485417f, -0.01589218f, -0.23883598f, -0.04216133f, 0.03022024f, 0.19371434f, -0.02403556f, 
    0.05957697f, -0.02312835f, -0.02395535f, 0.02473811f, -0.07336613f, -0.12452552f, -0.05950136f, -0.08538724f, 
    -0.41010439f, 0.17692518f, -0.18967576f, -0.24664822f, -0.01201637f, 0.05071124f, -0.03011852f, -0.05136740f, 
    0.03007297f, -0.22325805f, 0.04606830f, -0.04511293f, -0.05775234f, 0.12364011f, 0.00833617f, 0.10697190f, 
    0.02138710f, -0.05682127f, -0.03318216f, -0.05105912f, 0.31423381f, 0.22315282f, -0.26068923f, -0.08235767f, 
    0.13125235f, 0.08442893f, -0.11070164f, -0.00228858f, 0.10515146f, -0.00633097f, -0.10115436f, 0.04637003f, 
    -0.01707523f, -0.05999436f, -0.01814518f, -0.03399955f, -0.03575872f, -0.06077951f, 0.01874701f, 0.01606108f, 
    0.28241327f, -0.12440088f, -0.08930112f, 0.19883011f, 0.11317600f, 0.13601451f, 0.05722443f, 0.20181905f, 
    0.10850246f, 0.03559143f, -0.05699817f, -0.02344595f, 0.04526172f, 0.19292450f, -0.09573953f, 0.01991754f, 
    -0.00581215f, -0.03919838f, 0.04198208f, -0.02979227f, -0.10935726f, -0.29387581f, 0.16806495f, 0.20966969f, 
    -0.02473143f, -0.03657717f, -0.02121339f, -0.10673790f, -0.12975895f, -0.02895442f, 0.10725866f, -0.01728068f, 
    -0.06224795f, -0.07308220f, 0.11551143f, -0.13377228f, -0.12289116f, 0.06264510f, -0.05963467f, -0.01356590f, 
    -0.52329665f, 0.03888060f, 0.04968851f, -0.02472245f, 0.05546859f, -0.03285890f, 0.01949153f, -0.06679725f, 
    -0.01615957f, 0.04112975f, -0.03893489f, -0.02146323f, 0.06490105f, 0.14517102f, 0.06233507f, -0.07143398f, 
    0.06392679f, 0.18019943f, 0.06999620f, -0.00638078f, -0.28253976f, -0.00221873f, 0.10256527f, 0.01959605f, 
    -0.06132377f, -0.05628356f, -0.09758487f, -0.10615498f, 0.06771471f, 0.08918174f, -0.01224922f, -0.19233061f, 
    -0.04489110f, -0.02668310f, 0.05191699f, 0.07205193f, -0.01721186f, -0.04974872f, -0.07755741f, -0.05860349f, 
    0.15956374f, -0.16447943f, 0.28127834f, -0.03508865f, -0.24204670f, -0.11024228f, 0.05697178f, -0.03098683f, 
    0.07380254f, 0.06416436f, 0.08989568f, 0.07722396f, -0.01507251f, -0.16493002f, -0.01977433f, -0.09249167f, 
    0.10739061f, -0.04836318f, 0.07923789f, 0.05640874f, -0.12185378f, 0.06253712f, 0.00612583f, -0.06637552f, 
    -0.04129246f, 0.05106001f, -0.02655439f, -0.05954111f, 0.03178431f, 0.00142409f, 0.09258930f, 0.10362872f, 
    0.01749296f, 0.01016371f, -0.11744268f, 0.08674240f, 0.02879177f, -0.08191648f, -0.10754479f, -0.02976096f, 
    0.05614382f, 0.21211855f, 0.08020210f, 0.05069317f, 0.00272490f, -0.07265234f, 0.05783240f, 0.01160907f, 
    0.00025911f, 0.02606515f, -0.04305443f, 0.00363283f, 0.07973738f, 0.03273683f, -0.06206544f, -0.12188930f, 
    0.16260755f, 0.07911805f, 0.00329912f, 0.12779212f, -0.37175933f, -0.08326108f, -0.11092599f, 0.00488382f, 
    0.10002571f, 0.07226449f, 0.04875684f, 0.07474649f, -0.02060387f, 0.02599240f, 0.06887207f, -0.08932744f, 
    0.07325587f, -0.01584080f, -0.08978109f, -0.00548516f, 0.07980137f, 0.10342810f, 0.23282515f, 0.06091109f, 
    -0.01697077f, 0.17397822f, -0.14780653f, 0.02927558f, -0.09193378f, -0.05524041f, -0.02356311f, 0.01746120f, 
    -0.03505415f, -0.02570073f, -0.08569993f, 0.02471457f, -0.06928715f, 0.03341211f, -0.05959114f, -0.05223095f, 
    -0.04601679f, -0.04383666f, -0.14581673f, -0.06194448f, 0.15318900f, -0.00219679f, 0.13012649f, -0.16139303f, 
    -0.28483820f, -0.00978245f, 0.05982167f, -0.14333934f, 0.03073919f, -0.09254365f, -0.00350928f, -0.11242221f, 
    0.06849796f, -0.00606441f, 0.09821565f, -0.10556334f, 0.07850951f, 0.13643083f, -0.05047050f, 0.16046853f, 
    -0.42196605f, 0.18294898f, -0.03811571f, -0.02716653f, 0.00889904f, 0.05237601f, -0.17133711f, 0.15429151f, 
    0.06455543f, -0.03645418f, 0.01891806f, 0.12839343f, -0.17906077f, 0.00882174f, 0.09623647f, 0.02674768f, 
    0.19418269f, -0.08001922f, -0.02510710f, 0.06976009f, 0.27247375f, -0.05032491f, -0.24810965f, -0.03770056f, 
    -0.20726162f, -0.01352815f, 0.02638046f, -0.01312292f, -0.04543744f, -0.05435261f, -0.05531700f, -0.10546345f, 
    0.09602789f, 0.06547938f, -0.05396304f, -0.03971297f, 0.05953134f, 0.03034346f, -0.02289753f, -0.05617438f, 
    0.10711867f, 0.02785861f, -0.09877446f, 0.23199514f, -0.04469352f, 0.08894927f, -0.00208339f, -0.00807633f, 
    0.11327486f, -0.03034288f, 0.08045860f, 0.20626520f, -0.01892948f, -0.08456718f, 0.04393221f, -0.01970376f, 
    -0.11066840f, -0.02085240f, -0.00619570f, 0.00330937f, -0.09249640f, 0.20197813f, 0.11721379f, -0.15805586f, 
    -0.00642457f, 0.11958573f, -0.01979753f, -0.09574863f, 0.07735076f, 0.00435203f, -0.05074310f, -0.03615402f, 
    0.00927831f, -0.02312706f, -0.12865376f, -0.09811741f, 0.02777226f, -0.06048330f, -0.01343609f, -0.07861309f, 
    0.21827996f, 0.21808942f, -0.29795319f, 0.16208141f, -0.25103748f, -0.04898718f, -0.10924578f, 0.06311321f, 
    -0.04089808f, -0.22929153f, 0.04208487f, -0.02033697f, 0.03767452f, -0.01063591f, -0.02814727f, -0.04467522f, 
    -0.00212195f, 0.15608440f, 0.11663718f, 0.10311008f, -0.01143539f, 0.23979920f, -0.09756856f, 0.00045596f, 
    -0.28399047f, 0.01783750f, -0.01394985f, 0.00696581f, -0.06605055f, -0.14177190f, 0.01734250f, -0.09786457f, 
    0.06442336f, 0.07697289f, 0.03247326f, -0.04230548f, -0.09453856f, -0.03144036f, -0.21775228f, -0.02864994f, 
    -0.49147382f, 0.30720374f, 0.18339586f, 0.01489711f, 0.06578742f, 0.20071846f, -0.09518126f, 0.03257026f, 
    0.04349257f, 0.16993280f, -0.04289325f, 0.05981110f, -0.01929037f, 0.02932896f, 0.00807152f, -0.07802184f, 
    0.05038478f, 0.08293331f, 0.11119141f, -0.18842773f, 0.43445179f, 0.38427582f, -0.36237037f, -0.35319558f, 
    0.10464406f, 0.00357549f, 0.05602202f, 0.05622694f, 0.09084091f, -0.24505444f, -0.01759123f, -0.06995142f, 
    -0.03726015f, 0.08861758f, -0.09570094f, 0.02968175f, -0.01704997f, -0.22549205f, -0.02092205f, -0.04605786f, 
    -0.65502197f, -0.10854380f, -0.03052412f, 0.09313415f, 0.23159456f, 0.02119536f, 0.04602425f, 0.05404344f, 
    0.05314466f, 0.03193366f, 0.00451228f, -0.05378969f, 0.13336849f, 0.08659189f, 0.08544800f, -0.04427446f, 
    0.12362880f, 0.06002806f, 0.10002240f, -0.14106153f, 0.28210968f, -0.31047860f, 0.19164611f, -0.00575849f, 
    -0.05173560f, -0.03729149f, -0.06854171f, 0.10004164f, -0.02988498f, 0.12522373f, -0.05420125f, 0.02727016f, 
    -0.03732926f, -0.09430269f, 0.06974480f, 0.00239531f, -0.03099008f, -0.20073800f, 0.10821987f, -0.11219809f, 
    -0.15908058f, -0.45698789f, 0.06677047f, 0.23519692f, -0.02511780f, -0.23123182f, 0.07147810f, 0.00747801f, 
    -0.16972281f, 0.04317887f, 0.12730424f, 0.05960324f, -0.04653577f, -0.05294232f, 0.04167664f, -0.04084262f, 
    -0.02720047f, 0.11284351f, -0.04651665f, 0.01661767f, -0.46932864f, -0.17225780f, -0.13669550f, 0.19202572f, 
    0.07186753f, 0.04896549f, -0.01284129f, 0.03133067f, 0.04003538f, 0.11683530f, 0.07815801f, 0.00911270f, 
    -0.08657005f, 0.00261330f, 0.02650040f, 0.05636360f, -0.03410541f, 0.01282864f, 0.04077550f, 0.14386281f, 
    -0.24876222f, 0.08689000f, 0.22871739f, 0.01689597f, 0.03718055f, -0.21180309f, -0.02990906f, -0.05437804f, 
    0.11354014f, 0.16740435f, 0.00627135f, -0.16010086f, 0.00799770f, 0.03599597f, 0.08807850f, -0.02641331f, 
    -0.01688761f, -0.04404444f, -0.15090725f, -0.04352634f, -0.47234169f, -0.02358332f, -0.08465738f, -0.10121618f, 
    -0.07585775f, -0.03776269f, 0.09226178f, 0.15827745f, 0.00100449f, -0.20173319f, -0.04101424f, -0.05490331f, 
    0.09652312f, -0.06822752f, 0.00018510f, 0.08129719f, -0.01473121f, -0.04433588f, 0.11444250f, 0.00711841f, 
    0.14342751f, -0.01285780f, 0.05458654f, 0.18103506f, -0.03466929f, -0.09237370f, -0.02406325f, 0.04915475f, 
    0.06232380f, 0.11163709f, -0.11129735f, -0.12187403f, -0.04077287f, 0.19489042f, 0.16448104f, -0.03610278f, 
    0.08127797f, -0.16669223f, 0.03434218f, 0.04360732f, -0.17791398f, 0.10820393f, -0.23138168f, -0.03513754f, 
    0.08036878f, 0.20599939f, 0.17663398f, 0.13813472f, 0.00538382f, 0.12768322f, -0.01068875f, 0.05386205f, 
    -0.01337205f, -0.04168840f, 0.01305531f, -0.10788551f, 0.00733152f, 0.03051545f, -0.21192065f, -0.02799729f, 
    -0.02466888f, 0.05315739f, -0.12869300f, -0.05653512f, -0.08868597f, 0.04337641f, 0.01540407f, 0.15624988f, 
    0.03939622f, -0.04087741f, -0.09583920f, 0.04338058f, -0.04840397f, -0.03436708f, -0.10254774f, -0.04803985f, 
    -0.05253586f, 0.06540535f, 0.07808237f, 0.16876568f, -0.02818413f, -0.26359341f, -0.15722406f, 0.05184857f, 
    0.17145635f, 0.02016676f, 0.11335821f, 0.06411720f, -0.01901630f, -0.06578320f, -0.08845092f, 0.00568727f, 
    0.11346657f, 0.05656102f, 0.09578142f, -0.15284404f, -0.07370582f, 0.05682020f, -0.07018303f, -0.03856590f, 
    -0.47853762f, -0.56002617f, -0.16644874f, 0.00765954f, 0.01990902f, 0.03447383f, 0.17653099f, -0.05086637f, 
    -0.02006829f, 0.07152969f, -0.04614376f, 0.13664706f, 0.14239547f, 0.09951600f, 0.03300447f, 0.02703959f, 
    0.01751368f, 0.03331322f, -0.08442302f, 0.06910846f, 0.09561073f, 0.07514731f, 0.08756279f, 0.17100903f, 
    -0.12075852f, -0.05144402f, 0.04015621f, -0.01226175f, 0.02503854f, -0.02403268f, -0.05511465f, 0.01849136f, 
    -0.13222082f, 0.04843705f, 0.08880421f, 0.05157613f, 0.08186119f, 0.20669432f, -0.02660184f, -0.06772331f, 
    -0.57263231f, 0.31423458f, -0.12981728f, 0.13064115f, -0.23375483f, 0.12106617f, -0.13657707f, -0.01014155f, 
    -0.13893861f, -0.04378975f, -0.06679290f, 0.07812840f, 0.07884421f, -0.08427849f, -0.10116886f, 0.02634401f, 
    -0.06652845f, 0.00747088f, 0.08578182f, -0.06631505f, -0.32246321f, -0.16249503f, 0.32855594f, 0.06986430f, 
    -0.44696763f, 0.14626607f, 0.04272815f, -0.04284742f, 0.07583829f, -0.07415652f, -0.02271520f, 0.04292996f, 
    -0.09027542f, -0.35372940f, -0.08389188f, -0.06101827f, 0.05687438f, 0.04292405f, -0.00484341f, 0.08105651f, 
    0.09532202f, 0.16127193f, 0.14801271f, 0.05740734f, -0.26499823f, -0.00945462f, 0.09123596f, -0.06619973f, 
    0.02693730f, -0.02506953f, 0.17230444f, 0.01595936f, -0.13393345f, 0.00885737f, 0.02397051f, 0.04751570f, 
    0.01074209f, 0.09554587f, 0.02940209f, 0.03705248f, 0.05126423f, -0.03484451f, -0.08092266f, 0.13415849f, 
    0.33901373f, -0.18543598f, -0.21526688f, 0.10980467f, 0.13119905f, 0.12223492f, 0.08398002f, -0.06840485f, 
    0.07617503f, 0.16704330f, 0.13823900f, -0.02846173f, 0.16540775f, -0.15889060f, -0.12160443f, -0.10286167f, 
    -0.13085262f, 0.18524802f, -0.17765532f, -0.21520332f, 0.06110233f, -0.00825728f, 0.11089056f, -0.02328715f, 
    0.01840322f, -0.08733541f, 0.04578285f, -0.08015587f, 0.00311956f, -0.16121078f, 0.10584363f, 0.04815437f, 
    0.10546236f, -0.18342751f, -0.01637601f, 0.03976150f, -0.03859355f, 0.04608446f, -0.14750755f, 0.04375261f, 
    -0.04438968f, 0.14114280f, 0.03841595f, -0.08217809f, -0.07833066f, 0.01801956f, -0.10909133f, -0.06534281f, 
    -0.01152560f, -0.02027757f, 0.10357476f, 0.01671877f, -0.02948293f, -0.06031285f, 0.10714794f, 0.01226479f, 
    0.14122331f, 0.06249674f, 0.14908746f, -0.00607964f, 0.14021435f, 0.00347079f, -0.01539811f, -0.10389813f, 
    -0.05666199f, 0.10177222f, 0.00042444f, -0.07441682f, 0.06447109f, 0.07003783f, -0.01053271f, -0.00330218f, 
    -0.15640011f, 0.05646330f, 0.06068371f, -0.00273725f, -0.05981852f, 0.08146792f, 0.23258580f, 0.08756678f, 
    0.11347248f, -0.02558407f, -0.07417668f, 0.07671922f, -0.12006831f, -0.04475854f, 0.02685750f, -0.01294162f, 
    -0.01594036f, 0.06218305f, 0.14191701f, -0.05525604f, 0.00628890f, 0.04088104f, -0.08565820f, -0.09851050f, 
    0.00929780f, -0.04268742f, 0.02163431f, 0.05206046f, -0.22992194f, -0.10124770f, -0.06167749f, 0.01276468f, 
    -0.03967814f, -0.02027725f, -0.01931225f, 0.12117239f, -0.02744787f, -0.01138349f, 0.09177852f, -0.14349203f, 
    -0.21587427f, -0.01693546f, 0.02410582f, -0.09489080f, -0.49855104f, 0.02245480f, -0.06359206f, -0.26226860f, 
    -0.10405316f, 0.06004738f, 0.11107852f, 0.14143002f, -0.12394577f, -0.06206520f, 0.06080510f, -0.11710776f, 
    0.08850879f, -0.11640340f, 0.05178660f, 0.07076547f, 0.05205581f, -0.13455465f, -0.03185792f, 0.04410574f, 
    -0.22370680f, -0.08813868f, 0.11209971f, -0.04323325f, 0.09822726f, 0.00799260f, -0.14997002f, -0.02059500f, 
    -0.02300360f, -0.07370771f, 0.05529812f, 0.02742360f, -0.03595230f, -0.02581398f, 0.07712894f, -0.04785280f, 
    -0.04025998f, -0.04356711f, -0.01938197f, -0.06805354f, -0.19496375f, -0.00569179f, 0.15446506f, 0.14677371f, 
    -0.12335400f, -0.10667201f, 0.01719734f, 0.08774450f, 0.00815162f, 0.05590378f, -0.08683258f, 0.02018823f, 
    -0.05614489f, 0.08679926f, -0.13632451f, -0.02256150f, 0.01338386f, -0.23357886f, 0.02828190f, -0.05101178f, 
    -0.08599670f, -0.14475787f, 0.03954104f, 0.11052375f, -0.36072779f, 0.02012665f, -0.08464347f, -0.00742594f, 
    0.03569502f, 0.01135038f, 0.00569229f, 0.01559257f, 0.09947190f, -0.04679461f, -0.01958490f, 0.14154255f, 
    -0.05942503f, -0.02213134f, 0.19231647f, 0.03753167f, -0.02005801f, 0.18816452f, -0.00567209f, -0.01630672f, 
    0.22104838f, -0.04219761f, -0.13637748f, 0.08969478f, -0.06507634f, 0.10700773f, 0.06888042f, 0.01107102f, 
    0.00761890f, 0.00384648f, 0.02151123f, 0.01986375f, 0.13282168f, -0.10351791f, -0.00851037f, 0.09116815f, 
    -0.26615524f, -0.16031134f, -0.06027116f, -0.06022433f, 0.14382295f, 0.03188631f, 0.02333937f, -0.05320365f, 
    -0.13094610f, 0.10687350f, 0.05357473f, 0.03185678f, 0.11761144f, 0.18119398f, -0.06730831f, -0.01413771f, 
    0.13613261f, -0.13319726f, -0.11518133f, 0.08003756f, 0.17061971f, -0.00340641f, 0.06144571f, 0.25657314f, 
    0.05806464f, -0.04675507f, 0.15917873f, 0.01420618f, -0.05139330f, -0.05466127f, 0.01859767f, -0.04729609f, 
    -0.01313210f, -0.04529990f, 0.00394407f, 0.15411884f, -0.02952628f, 0.01813167f, -0.01211123f, -0.06289345f, 
    0.09859198f, -0.18558705f, -0.19900875f, 0.05532224f, 0.13581099f, -0.01957611f, -0.06619919f, -0.08405451f, 
    0.08916212f, 0.15111499f, 0.10993266f, 0.02913163f, 0.08428419f, 0.06461778f, -0.07423864f, -0.04415879f, 
    -0.01816182f, -0.11248953f, -0.13337135f, 0.00684498f, -0.14884374f, 0.05762543f, 0.06937271f, 0.01470545f, 
    0.26326603f, 0.01889617f, 0.04820034f, 0.05408035f, -0.02462114f, 0.09824958f, 0.12719184f, -0.02017949f, 
    0.02931556f, -0.03516489f, 0.02129887f, -0.04657923f, 0.16240287f, -0.05826094f, 0.13536024f, -0.12610048f, 
    -0.49124137f, 0.03873298f, -0.18980785f, -0.05976336f, 0.00296200f, 0.19145139f, 0.01108497f, 0.04576138f, 
    0.00822965f, -0.12951843f, 0.00493597f, -0.06556217f, -0.16634579f, -0.02182175f, 0.00823622f, -0.07203540f, 
    -0.09134764f, -0.07666881f, -0.01751643f, -0.02870797f, -0.51739496f, -0.42217100f, 0.15930189f, 0.07398780f, 
    -0.24262097f, 0.14883904f, -0.03842369f, 0.03925050f, -0.19594465f, 0.06361004f, 0.08528753f, -0.11955155f, 
    0.01337164f, -0.01285905f, -0.05890470f, -0.08602523f, 0.08119509f, 0.17263079f, -0.01480887f, -0.03593070f, 
    -0.21234900f, 0.08864378f, -0.26448613f, -0.21925768f, -0.14843792f, 0.10606446f, 0.05025330f, 0.12659921f, 
    -0.09686538f, -0.16843091f, 0.14767104f, 0.01663838f, -0.03786617f, -0.12684469f, -0.03888876f, 0.02809081f, 
    -0.09474066f, 0.00824549f, -0.01729728f, -0.01881740f, 0.14955778f, 0.15574472f, 0.05814886f, 0.09217323f, 
    -0.08560935f, -0.11448553f, -0.02127380f, -0.05663414f, -0.16597193f, 0.26113740f, 0.04412685f, -0.01355349f, 
    0.02681946f, 0.00898495f, -0.06713192f, -0.00900668f, -0.02877769f, 0.09168746f, 0.14301825f, -0.02113400f, 
    0.11727606f, 0.15027168f, -0.05140984f, 0.16751280f, 0.09027752f, -0.09735713f, -0.09628163f, -0.12560764f, 
    0.02177761f, -0.01020947f, -0.08404018f, -0.12326811f, 0.00049897f, 0.11272097f, 0.10975362f, 0.03648998f, 
    0.02789547f, 0.04051870f, -0.03749793f, -0.09894966f, -0.22813261f, -0.02089879f, -0.29928905f, -0.04142575f, 
    -0.01794185f, 0.13623111f, 0.06845141f, 0.04869044f, -0.07658976f, 0.01280071f, 0.04499100f, 0.22802535f, 
    0.10244594f, -0.23532484f, -0.00586457f, 0.05672928f, 0.02847391f, -0.03966277f, 0.00579932f, -0.10190688f, 
    0.51738650f, 0.18774962f, 0.21975914f, 0.14201598f, 0.21890372f, -0.10214260f, 0.05582283f, 0.02007237f, 
    -0.03425086f, -0.05526068f, 0.03227326f, -0.04093152f, 0.12522298f, 0.10216718f, 0.10068200f, 0.16915713f, 
    -0.03334426f, -0.02725252f, 0.07812601f, -0.07456174f, 0.10380130f, -0.45370787f, 0.01524313f, -0.03318517f, 
    -0.01916794f, 0.01296510f, -0.01118988f, -0.10174383f, 0.03473503f, -0.00746339f, -0.00989215f, 0.01919583f, 
    -0.13075173f, 0.14806217f, 0.02768509f, -0.07237021f, 0.01855549f, -0.00479445f, -0.13054052f, -0.08665591f, 
    -0.05292326f, 0.31443518f, 0.03699968f, -0.05970956f, -0.33772659f, 0.06468944f, 0.02580780f, -0.01677483f, 
    0.00121346f, 0.01684525f, 0.05901971f, 0.11116457f, -0.13818026f, -0.04290507f, -0.25437671f, 0.08058780f, 
    -0.05706774f, 0.10259938f, 0.03459113f, -0.02581026f, -0.23246844f, 0.08458372f, -0.06523032f, -0.54915518f, 
    0.09475289f, -0.01920962f, -0.04854798f, 0.01095559f, -0.06185893f, -0.00722115f, -0.01933523f, -0.07982817f, 
    0.00119582f, -0.04982243f, -0.03798074f, 0.08545053f, -0.04194089f, -0.07445855f, 0.09158433f, 0.14627886f, 
    -0.14621146f, -0.55656773f, 0.15007544f, 0.04619019f, -0.00095267f, 0.11282696f, -0.06547733f, 0.04745221f, 
    -0.04625309f, 0.09952622f, 0.01239009f, -0.00118295f, 0.05021152f, -0.00963143f, 0.19607756f, -0.00457020f, 
    0.04795365f, -0.02552133f, 0.07204593f, -0.12414587f, -0.28401127f, 0.21986015f, 0.08397252f, 0.01357847f, 
    -0.68028080f, 0.13616532f, 0.07626828f, 0.12352429f, 0.02924111f, -0.02278628f, -0.05294859f, -0.01336292f, 
    0.05667936f, 0.10374591f, 0.00027549f, 0.14688131f, -0.13270907f, -0.06604682f, 0.09860532f, 0.04820214f, 
    -0.02970226f, -0.04893706f, -0.14195231f, -0.22649617f, 0.02271567f, -0.01807660f, -0.07073159f, -0.07323370f, 
    -0.14912601f, -0.15432878f, -0.01977309f, -0.02639598f, -0.22908501f, 0.01179865f, -0.03320348f, -0.18733384f, 
    -0.02470743f, 0.07190149f, 0.03062681f, 0.03073705f, -0.23758940f, 0.31323954f, 0.00427930f, 0.23175862f, 
    -0.04241887f, -0.00979243f, -0.00591046f, -0.01098071f, 0.03546266f, 0.00303778f, -0.08820576f, 0.04556402f, 
    0.01607011f, -0.07643842f, -0.05012643f, -0.05993994f, -0.03657274f, -0.05488021f, -0.01807152f, -0.14255948f, 
    0.25456083f, -0.53283411f, -0.09964232f, 0.05425223f, 0.20581426f, 0.11299579f, 0.06117001f, 0.01103998f, 
    0.08118007f, 0.06076026f, -0.05851164f, -0.05209096f, 0.08515818f, 0.01342279f, 0.06305860f, -0.01755664f, 
    -0.06137765f, -0.02260136f, -0.08840074f, 0.07570965f, 0.21877503f, -0.13090664f, -0.12084841f, -0.01692357f, 
    -0.06920584f, -0.18200958f, 0.03057355f, 0.04518380f, 0.04352316f, 0.06299805f, -0.08097547f, -0.04431948f, 
    0.07261879f, 0.01945208f, 0.00580627f, 0.06451108f, 0.01851877f, -0.11360404f, 0.07514718f, -0.05196519f, 
    0.02786526f, -0.10480203f, -0.13159913f, 0.18725581f, -0.24731970f, -0.15820925f, -0.04824561f, 0.03337312f, 
    0.03971314f, 0.01696449f, -0.07237083f, -0.01444234f, 0.07491948f, -0.00774009f, -0.03870137f, -0.00357124f, 
    -0.15525797f, -0.06497376f, -0.09915201f, -0.16474932f, -0.04905362f, 0.14162715f, -0.06018831f, -0.05822431f, 
    -0.12377638f, 0.05212198f, 0.12232260f, -0.02085928f, -0.05536995f, 0.04642463f, -0.07955728f, 0.00342353f, 
    -0.15942313f, 0.01595711f, -0.19340970f, 0.01700791f, -0.04480403f, 0.29089224f, 0.03189144f, 0.10071129f, 
    0.27140659f, -0.30593970f, 0.01264073f, -0.11533609f, 0.14579917f, -0.03681265f, 0.09042654f, -0.14525069f, 
    -0.08250855f, -0.14444235f, 0.00944201f, 0.04068785f, 0.07448381f, 0.15229972f, 0.02763413f, 0.10604353f, 
    0.02188554f, 0.00223598f, -0.07142671f, 0.13348900f, -0.03711184f, 0.21546218f, -0.23662870f, 0.21201955f, 
    -0.40741768f, -0.13247173f, 0.00871288f, 0.03329742f, 0.11713681f, -0.02796111f, 0.14128894f, 0.14800827f, 
    0.01600933f, -0.04380726f, -0.02522671f, -0.20164837f, 0.01241987f, 0.09117553f, -0.14637642f, 0.03324421f, 
    -0.41173580f, 0.28518561f, 0.15092149f, 0.12259634f, -0.14624582f, 0.00654469f, 0.00561614f, -0.02757861f, 
    0.11206873f, 0.03297653f, -0.00663372f, 0.00484424f, 0.11253016f, -0.01955090f, 0.02050519f, 0.01362802f, 
    0.13158794f, -0.21750620f, -0.00850959f, -0.10820996f, -0.31425819f, 0.06273062f, 0.04208038f, 0.12902804f, 
    0.27335602f, -0.13412169f, -0.04985214f, -0.04423678f, 0.10422419f, 0.04027118f, -0.12285308f, -0.02411534f, 
    -0.04414639f, 0.11230528f, 0.13191238f, 0.01351884f, 0.01034298f, -0.09880274f, 0.00584813f, -0.05012670f, 
    -0.07062095f, 0.29562408f, -0.05977645f, 0.05477513f, -0.22643818f, 0.02706908f, 0.09431538f, 0.08297006f, 
    0.10726893f, 0.07273491f, 0.05236004f, 0.03108000f, -0.01084645f, -0.07033428f, -0.00939702f, -0.00069747f, 
    0.07644223f, 0.11393051f, 0.03527626f, 0.18784253f, 0.04865856f, -0.15755928f, 0.12216994f, -0.02790731f, 
    0.16613908f, -0.17680265f, 0.02441116f, -0.14428219f, 0.00768820f, -0.07138000f, -0.06954884f, 0.16028209f, 
    -0.17226858f, 0.12430394f, 0.05302754f, -0.05017621f, 0.05780694f, -0.03901706f, -0.16331482f, 0.01682599f, 
    -0.06584994f, -0.16168866f, -0.18913794f, 0.10723171f, 0.09826647f, 0.08592471f, 0.10417219f, -0.04511705f, 
    0.15982729f, 0.04135793f, 0.01579025f, -0.06364120f, -0.00852071f, -0.08847602f, 0.03490147f, -0.08542888f, 
    0.02736554f, 0.17282668f, 0.01895368f, 0.01352772f, 0.13156685f, -0.19232750f, 0.00247917f, 0.18654101f, 
    0.18191846f, 0.01216768f, 0.15581536f, -0.08366978f, 0.00490738f, -0.08132993f, 0.00780220f, -0.04374398f, 
    -0.08064467f, 0.01546327f, 0.05328916f, 0.02069808f, 0.01478667f, 0.15452838f, 0.06656545f, 0.02725657f, 
    0.03368734f, -0.05196118f, -0.02963141f, 0.11475928f, -0.30336827f, 0.01710500f, 0.02287563f, 0.13140731f, 
    0.05361367f, 0.01993689f, -0.08261950f, 0.02049891f, -0.18786313f, 0.01091156f, -0.11418447f, -0.05722164f, 
    -0.00619777f, 0.14611866f, -0.18958820f, -0.07044181f, -0.12670289f, -0.00490442f, -0.14466028f, 0.26291862f, 
    -0.06156638f, -0.00236648f, 0.16063865f, -0.14987378f, 0.04427603f, 0.00287383f, 0.03638237f, -0.01932962f, 
    0.07594007f, -0.05772138f, -0.16672447f, 0.16015892f, -0.04106810f, 0.08374617f, -0.06738868f, 0.01248279f, 
    -0.12210947f, 0.02397524f, -0.07812539f, -0.20326722f, 0.16861306f, -0.00173202f, 0.06869146f, 0.08591103f, 
    -0.09494752f, 0.04288317f, 0.05797759f, -0.11203153f, -0.03617655f, -0.03049358f, -0.06987002f, -0.09944968f, 
    0.04909233f, 0.01595019f, -0.00689201f, 0.01513071f, -0.26398841f, 0.10919797f, -0.01723718f, 0.14089085f, 
    0.18731570f, -0.09346517f, -0.02617033f, -0.02452393f, 0.02603938f, 0.05886117f, -0.09265178f, 0.07578114f, 
    0.00392464f, 0.08043298f, 0.11889396f, -0.05410047f, -0.01068712f, 0.04593011f, 0.10751712f, -0.07663728f, 
    -0.10158332f, -0.17197335f, -0.20100249f, -0.03866344f, 0.18127392f, -0.02044566f, 0.12996486f, -0.05996940f, 
    -0.16193546f, 0.04232664f, -0.02936615f, -0.01425274f, 0.03246614f, 0.01498723f, -0.10457820f, 0.13264179f, 
    0.09261626f, 0.15215531f, 0.15496217f, 0.00461726f, -0.05694802f, -0.36382258f, -0.13932452f, -0.11461045f, 
    0.29568809f, -0.14241007f, 0.05196130f, 0.02046128f, 0.00943783f, 0.14550723f, -0.06554224f, -0.02096018f, 
    0.02858217f, 0.00128337f, -0.00189292f, -0.04845370f, -0.05197923f, 0.10104261f, -0.11926817f, 0.10298068f, 
    0.31877455f, -0.02139517f, 0.04457758f, -0.32717556f, 0.23389979f, -0.03341069f, -0.00388571f, -0.06976841f, 
    -0.11220855f, -0.11589763f, -0.05736640f, -0.05113464f, 0.10949308f, -0.14537567f, 0.01615257f, 0.01965055f, 
    -0.02424141f, 0.07212208f, 0.00508000f, 0.12712972f, 0.24097180f, -0.50210035f, -0.21554363f, 0.11983532f, 
    -0.18527772f, 0.02471045f, 0.01134758f, -0.01048199f, 0.00408408f, 0.04122265f, 0.01631550f, 0.10617971f, 
    -0.13331097f, -0.00440467f, 0.01736687f, 0.03963710f, -0.00720659f, 0.00296001f, -0.09585132f, 0.03806440f, 
    -0.01834329f, -0.40348014f, -0.05569267f, -0.22683164f, 0.01197233f, 0.01663288f, -0.00043214f, 0.01264729f, 
    -0.01148912f, -0.01340688f, -0.05961438f, 0.03586641f, 0.10338408f, 0.12836362f, -0.02868229f, -0.03466862f, 
    -0.02123970f, -0.12109063f, -0.12561819f, 0.07822012f, -0.67961675f, 0.35926372f, -0.02654882f, 0.09583224f, 
    -0.05109696f, 0.11940618f, -0.18082115f, 0.05756119f, 0.09408645f, -0.15254074f, 0.06929958f, 0.05498558f, 
    -0.08367969f, 0.01981729f, -0.05003574f, 0.05368419f, 0.01334148f, -0.24225675f, -0.07387514f, -0.10163993f, 
    0.00703817f, 0.21326526f, -0.03096769f, -0.14037390f, -0.14813784f, 0.02900438f, 0.10728107f, 0.03370038f, 
    0.09142952f, 0.03191650f, -0.01996938f, 0.04677831f, -0.02278426f, -0.05560952f, -0.11800839f, 0.00845183f, 
    0.03133250f, 0.00289451f, 0.08453926f, 0.10264536f, -0.33700818f, -0.07920782f, -0.14744680f, -0.52922809f, 
    0.14177172f, -0.12508620f, -0.02477245f, -0.00715084f, 0.00309734f, -0.09436985f, -0.12684684f, -0.05653577f, 
    -0.05449589f, 0.02745077f, 0.07082991f, -0.10161474f, -0.02274001f, 0.09097780f, -0.01447461f, 0.04281107f, 
    0.23576763f, 0.15424311f, -0.22748125f, -0.02443710f, 0.25209531f, -0.31895596f, -0.00928998f, -0.07833984f, 
    0.01627729f, -0.02928253f, -0.10727452f, -0.02723438f, -0.09891862f, 0.12350182f, -0.05589946f, -0.01448182f, 
    0.01677483f, 0.01273940f, -0.08167579f, 0.10881994f, 0.15188788f, -0.20916639f, 0.21598861f, 0.08868924f, 
    0.08254243f, -0.02800250f, 0.11126602f, -0.03626255f, 0.02064403f, -0.08553203f, 0.01346388f, 0.04818457f, 
    -0.05872806f, 0.06678183f, -0.09384417f, -0.08983955f, -0.01690659f, 0.06351203f, -0.03344036f, -0.06313232f, 
    -0.47356257f, -0.06409704f, -0.18087980f, -0.00676443f, 0.08319949f, 0.01167151f, -0.16063854f, -0.16541459f, 
    0.00739097f, -0.05306493f, -0.04165616f, 0.02718387f, 0.04031739f, -0.01637437f, -0.02995807f, -0.10643787f, 
    0.02003970f, 0.04266378f, -0.02708457f, 0.04567962f, 0.09441601f, 0.10719229f, 0.23703583f, 0.01999566f, 
    0.20312448f, 0.16660281f, 0.15389059f, -0.08605745f, -0.01858403f, -0.00737242f, 0.00313490f, -0.00941449f, 
    -0.01652951f, -0.05749743f, -0.09821688f, -0.00625038f, -0.01833584f, -0.06204419f, 0.06857169f, 0.00367870f, 
    0.14509946f, -0.26803985f, -0.00405861f, 0.05408998f, 0.09704538f, 0.03539047f, -0.04912423f, -0.01597300f, 
    0.01703156f, -0.06294212f, -0.00289566f, 0.02999195f, 0.03963238f, 0.04649892f, -0.05405507f, -0.05375712f, 
    0.02332778f, 0.01012676f, 0.01852060f, -0.05843198f, -0.14787284f, -0.25625134f, -0.24720167f, 0.15231659f, 
    0.04607134f, -0.02167149f, -0.07757745f, -0.00545782f, 0.04454238f, -0.05192447f, -0.00552988f, -0.00877975f, 
    -0.07988660f, -0.01199080f, -0.02515447f, 0.04558847f, -0.06184988f, -0.01792761f, -0.01926931f, -0.05761206f, 
    -0.01629128f, 0.14304025f, 0.11817200f, 0.19486871f, 0.12581339f, 0.03558471f, 0.00645539f, 0.03418886f, 
    -0.01366593f, -0.05450077f, -0.11846430f, 0.05258659f, -0.07404832f, -0.04196298f, 0.00316449f, -0.02963213f, 
    -0.08347641f, 0.08163772f, 0.04462673f, -0.11619662f, -0.27076328f, -0.03933100f, -0.17437558f, -0.28283873f, 
    -0.17779365f, 0.11628417f, -0.07806285f, -0.01057095f, -0.00507039f, -0.09454001f, -0.13483042f, 0.01806356f, 
    -0.01521723f, -0.04609568f, -0.02603189f, -0.03901273f, -0.03495786f, -0.03630988f, -0.03565000f, 0.08880087f, 
    -0.11706604f, -0.05643275f, 0.02881289f, 0.00768715f, 0.26521391f, 0.06197812f, 0.10116158f, -0.00738483f, 
    0.04577287f, -0.06089083f, -0.00628682f, -0.00297610f, -0.09065365f, -0.00578521f, -0.03499200f, -0.07748076f, 
    -0.04504872f, -0.01241032f, -0.01163340f, 0.04010160f, 0.03594509f, 0.21957171f, -0.10801063f, 0.14669742f, 
    -0.18622947f, 0.07674083f, -0.03471107f, 0.01351332f, 0.04593201f, -0.05570524f, -0.01357055f, 0.00916363f, 
    0.04585412f, 0.01564296f, -0.05209860f, 0.02072314f, -0.07057346f, 0.00884586f, -0.06467623f, 0.04443567f, 
    0.00545981f, -0.14510235f, 0.04464110f, -0.08119845f, -0.20017599f, 0.09960604f, -0.18335371f, 0.00378863f, 
    -0.07313677f, -0.09936682f, 0.06594777f, -0.01482870f, -0.06608431f, 0.13519856f, -0.16124737f, 0.03789594f, 
    0.08348503f, -0.06704522f, -0.02110315f, -0.04185610f, 0.00070911f, 0.15597180f, -0.30943277f, 0.06196435f, 
    0.08525407f, -0.13994524f, -0.15958005f, -0.14203709f, -0.06847820f, -0.07251083f, -0.10599665f, 0.05250540f, 
    -0.00435582f, -0.02274337f, -0.02977660f, -0.06668936f, -0.10666053f, -0.02469152f, -0.04706424f, 0.07186483f, 
    -0.23818910f, 0.23341000f, 0.19186339f, -0.03706690f, 0.14062232f, 0.02388566f, 0.05916919f, 0.03186241f, 
    0.04728175f, 0.03532401f, -0.01617472f, -0.01503818f, -0.02084270f, 0.02600155f, -0.11138904f, 0.01058816f, 
    0.01917826f, 0.00266951f, -0.01798948f, 0.06170234f, -0.38551876f, 0.11020134f, 0.00537013f, -0.01247570f, 
    0.01701602f, 0.08650274f, -0.16273105f, 0.03602960f, -0.00257446f, -0.07363866f, -0.02282189f, 0.03107782f, 
    -0.03075237f, 0.07816473f, -0.05278931f, -0.05689649f, 0.00738835f, 0.01457626f, -0.02863744f, 0.04421464f, 
    -0.28829348f, -0.14485690f, -0.24305718f, -0.21748990f, -0.29946992f, -0.09126784f, -0.00760958f, 0.03581183f, 
    -0.03526699f, -0.02824817f, -0.11572453f, -0.10918911f, 0.01753560f, -0.03953016f, -0.02111005f, -0.08476388f, 
    0.03009594f, 0.02305140f, 0.00294584f, 0.04563326f, 0.07201312f, -0.12352019f, -0.23388860f, -0.18659483f, 
    -0.06921203f, -0.05510706f, 0.01110363f, 0.01811633f, -0.05415671f, -0.09100430f, -0.00159710f, -0.00110693f, 
    -0.07503989f, 0.02555609f, -0.04309133f, -0.03326385f, -0.08378845f, -0.04521998f, -0.01409340f, -0.00796842f, 
    0.00285814f, 0.09316137f, -0.03991404f, 0.14701894f, 0.08656067f, -0.04034009f, -0.05616536f, 0.02390618f, 
    -0.02516829f, -0.07209130f, -0.05388095f, -0.01295787f, -0.00772414f, 0.12832324f, -0.09153929f, 0.03219765f, 
    -0.03420938f, -0.05462697f, -0.01053634f, -0.13307804f, -0.20440884f, 0.15664324f, 0.19809380f, 0.10363392f, 
    0.11728058f, 0.16713107f, 0.06453742f, 0.14647247f, 0.10870805f, 0.16050646f, -0.09558613f, 0.05314578f, 
    0.06588923f, 0.07241370f, -0.06004315f, 0.05654623f, 0.08165359f, 0.03753945f, 0.01348485f, -0.03795121f, 
    -0.27231586f, 0.17810492f, -0.16930673f, 0.04513501f, 0.12096459f, -0.12158728f, -0.00562957f, -0.08440968f, 
    -0.05281591f, -0.05058248f, 0.09009141f, 0.11298696f, -0.06388289f, 0.00019793f, -0.01551889f, -0.00588121f, 
    -0.09139138f, -0.02472672f, -0.11029425f, -0.05286943f, -0.31990111f, 0.10240667f, 0.06842952f, 0.08512800f, 
    0.17962158f, -0.02397759f, -0.30028784f, -0.09382217f, 0.05412943f, 0.00456844f, 0.01367277f, 0.00100356f, 
    0.02894757f, -0.06671610f, -0.09402999f, -0.01105458f, -0.04117239f, 0.06606407f, 0.00489524f, 0.01044572f, 
    -0.05316272f, 0.01010843f, 0.11416452f, -0.00104197f, -0.19925758f, 0.04549464f, -0.13434352f, 0.04927217f, 
    -0.05359512f, -0.12293369f, -0.00670325f, 0.02612615f, -0.12074497f, 0.00881663f, -0.19177987f, -0.00540033f, 
    0.09566195f, 0.06533217f, -0.08333296f, -0.03941875f, -0.24611400f, 0.23055743f, 0.03901384f, -0.02375455f, 
    -0.06523769f, -0.02470530f, 0.08361153f, -0.01952290f, 0.01053913f, -0.04966077f, -0.06019462f, -0.04880384f, 
    -0.05387083f, -0.02440343f, -0.03934747f, -0.05734628f, 0.02488513f, 0.02615536f, -0.03217360f, -0.04373280f, 
    0.22959366f, 0.17125854f, 0.18788679f, -0.06060411f, 0.15539539f, 0.00312693f, 0.09169537f, -0.06992903f, 
    0.06071701f, -0.01248703f, -0.03538521f, -0.01331357f, -0.04503871f, -0.03806472f, -0.05905152f, -0.08597519f, 
    -0.05658906f, 0.08464265f, 0.06453259f, -0.07468255f, -0.08417457f, -0.04184980f, -0.19124432f, -0.16882840f, 
    0.02183750f, -0.07998958f, -0.00633269f, -0.01706263f, -0.05272628f, -0.07904784f, -0.11306800f, -0.01392726f, 
    -0.01398531f, -0.05633308f, -0.00138989f, -0.04776801f, -0.10184162f, -0.03995414f, -0.04293717f, 0.00031157f, 
    0.06175906f, 0.34407607f, 0.03408906f, 0.06244877f, 0.28138003f, -0.08267189f, 0.10681273f, -0.06573571f, 
    -0.01284229f, -0.03607628f, -0.12494053f, -0.03130120f, -0.05646789f, -0.12584694f, 0.01911819f, 0.01009205f, 
    0.02724822f, 0.18321767f, -0.02293901f, -0.05098589f, -0.20769668f, 0.15935634f, -0.18528967f, -0.05130298f, 
    -0.04701543f, -0.14507541f, 0.03083588f, -0.06858213f, -0.04320507f, 0.01188415f, -0.12488440f, 0.04042736f, 
    -0.16435112f, -0.01539783f, -0.03022870f, -0.02056900f, 0.01641813f, 0.07108249f, -0.09298119f, 0.01988177f, 
    0.25109431f, -0.01220450f, 0.31252223f, -0.03625184f, 0.14595616f, -0.04191924f, 0.13853984f, -0.06982003f, 
    0.05399346f, 0.03785139f, 0.00170659f, 0.01365417f, -0.12764311f, 0.02208660f, -0.07392189f, 0.00198789f, 
    -0.01854325f, -0.00052246f, -0.03502327f, -0.07425165f, 0.19392663f, 0.00668988f, 0.08540893f, 0.16905755f, 
    0.16578376f, 0.18864620f, -0.00811376f, -0.03473321f, 0.04207156f, 0.01708994f, -0.06694277f, -0.01453381f, 
    0.01801840f, -0.10788550f, -0.05442110f, 0.04209895f, 0.06182417f, -0.01938016f, -0.02342398f, 0.02407325f, 
    0.03353753f, 0.08004909f, 0.20822325f, 0.08529465f, 0.07195035f, 0.06385764f, 0.07554626f, 0.00537456f, 
    0.09087412f, 0.01279852f, -0.02267229f, 0.04454942f, 0.09630930f, 0.06140407f, -0.08972830f, -0.01246430f, 
    -0.00535625f, -0.02823120f, 0.06851451f, -0.07327026f, -0.03332020f, -0.13939850f, -0.02658209f, -0.17171703f, 
    -0.22606017f, -0.01017302f, -0.00779544f, 0.08559689f, -0.10690122f, 0.04130668f, -0.05176370f, 0.03607520f, 
    -0.04251275f, -0.10974779f, -0.09321719f, -0.02116128f, 0.12773196f, -0.03814134f, -0.05474892f, 0.08303231f, 
    -0.16984910f, 0.11466913f, -0.40424147f, -0.05371333f, 0.09438623f, -0.02053853f, -0.09854126f, -0.11297680f, 
    -0.01594734f, 0.01458855f, -0.14692806f, 0.05418871f, -0.02625586f, -0.08972988f, 0.02313952f, -0.08613925f, 
    0.01444122f, -0.01148894f, -0.00833203f, 0.10689066f, 0.16539305f, 0.15303484f, 0.19639853f, 0.20967990f, 
    0.21193442f, 0.03095717f, 0.11259254f, -0.02008355f, 0.03525226f, -0.09416291f, -0.10432526f, -0.00161758f, 
    -0.03886057f, -0.02892119f, -0.09774884f, 0.02535968f, 0.00479415f, 0.03598515f, -0.06305199f, -0.00259124f, 
    -0.05811208f, -0.09593365f, -0.15489455f, -0.25901470f, -0.11175112f, 0.18928155f, 0.02936983f, -0.08970978f, 
    -0.16283396f, -0.17457980f, 0.03991741f, 0.10377797f, 0.05351265f, -0.02927889f, -0.10115302f, 0.02512666f, 
    0.15465134f, 0.07397545f, -0.03083339f, -0.01545721f, -0.05644644f, -0.13658276f, 0.11563514f, 0.06896088f, 
    0.18691772f, -0.12002611f, -0.03463761f, 0.04019820f, 0.02668358f, 0.03820335f, 0.00307975f, -0.03507549f, 
    -0.08387905f, -0.05938196f, 0.03935222f, 0.10637291f, -0.00931208f, -0.04819157f, 0.04763871f, 0.08180405f, 
    0.03873504f, 0.05850976f, -0.28318724f, -0.08535716f, 0.01964723f, 0.20078804f, 0.04137938f, -0.02625435f, 
    0.04214416f, -0.10668731f, 0.04966724f, 0.02058978f, 0.13562578f, -0.02155424f, 0.04419964f, 0.06388564f, 
    0.01867158f, -0.00961568f, 0.08662893f, -0.08338559f, -0.20028709f, -0.06505359f, 0.21387987f, -0.34337205f, 
    -0.13061824f, 0.07332887f, 0.03519498f, -0.02751538f, -0.04588937f, -0.09869422f, 0.04095624f, 0.02154317f, 
    -0.13485631f, -0.00399502f, -0.07114487f, -0.18075079f, -0.02623871f, 0.08186048f, -0.25401694f, -0.13903588f, 
    0.00321156f, -0.00856606f, 0.19912183f, -0.08174374f, 0.21689595f, -0.00895795f, -0.04415573f, -0.01653904f, 
    -0.04286894f, -0.03563142f, -0.02428461f, -0.07492002f, 0.04615534f, -0.03487445f, 0.04701181f, 0.03067037f, 
    -0.02740979f, 0.15593308f, -0.11009706f, 0.00412531f, 0.05782096f, -0.08215047f, -0.30208281f, 0.07495803f, 
    0.09288045f, 0.04095422f, 0.08777973f, -0.05452599f, -0.09150734f, -0.06482708f, 0.00920624f, -0.02071361f, 
    0.11750627f, -0.00061875f, 0.08466743f, -0.05404677f, -0.15306255f, -0.04828759f, 0.09070549f, -0.17753375f, 
    -0.24793296f, -0.05174565f, 0.19601801f, -0.09437433f, -0.06263165f, -0.11660389f, -0.00815425f, -0.04928541f, 
    -0.05734244f, -0.12591314f, 0.07187622f, 0.03868253f, 0.16202578f, 0.05731484f, 0.03556880f, 0.00660222f, 
    -0.09180294f, -0.08038924f, -0.09131209f, 0.03701574f, 0.20153463f, 0.15359986f, -0.16270560f, 0.04046397f, 
    0.15528214f, 0.09233384f, 0.03990716f, -0.05314565f, 0.01062492f, 0.00498338f, 0.05605194f, 0.04464729f, 
    -0.06922465f, 0.08489066f, -0.10588995f, 0.00205419f, -0.00188304f, 0.07350894f, 0.05285441f, -0.03316455f, 
    -0.07121582f, -0.03022400f, 0.16496928f, -0.01425847f, 0.08468746f, -0.09971905f, -0.13213132f, -0.06874038f, 
    -0.07015451f, -0.03174246f, -0.00556457f, -0.02614634f, -0.01609768f, -0.08294766f, -0.00661833f, -0.01694691f, 
    -0.05218383f, -0.00041969f, 0.08994669f, 0.03669805f, 0.00825075f, 0.01184049f, 0.06680241f, -0.20515159f, 
    0.11258490f, 0.01324408f, -0.09577418f, -0.19058868f, 0.09811151f, 0.00256871f, 0.07174905f, 0.02116932f, 
    0.13537516f, -0.22919786f, 0.03567494f, -0.03161136f, 0.06771681f, -0.00845242f, 0.08420965f, 0.03627169f, 
    0.22190377f, 0.27177420f, -0.12779106f, 0.12865768f, 0.16566095f, -0.11555265f, -0.08933014f, -0.16825756f, 
    -0.09395925f, -0.01282065f, -0.14564441f, 0.01176995f, -0.06373888f, -0.04096204f, 0.04772848f, 0.12584384f, 
    0.02725391f, -0.00160244f, 0.09334081f, 0.01857969f, 0.05983961f, 0.08861468f, -0.11518870f, -0.23447928f, 
    -0.10864749f, -0.03503980f, 0.03015589f, -0.02994244f, -0.02848450f, -0.07058178f, 0.00291242f, 0.11140003f, 
    0.08040569f, 0.05034249f, -0.03710647f, 0.03226221f, 0.03671890f, -0.02168649f, -0.06200571f, 0.10977530f, 
    0.10555757f, -0.03349987f, 0.11777519f, -0.05017703f, -0.02594997f, -0.06897604f, -0.09881305f, -0.04699514f, 
    -0.02857704f, 0.04783492f, 0.03141673f, -0.04194890f, -0.03423807f, -0.07970338f, 0.07773435f, 0.06461833f, 
    -0.12445347f, -0.09499715f, 0.04959968f, -0.05148265f, 0.06353159f, 0.10489988f, -0.05329796f, 0.10307533f, 
    0.12708694f, 0.01546013f, 0.13179226f, -0.08243737f, -0.07592380f, -0.05813505f, -0.01238311f, -0.09318624f, 
    -0.03619237f, -0.01098963f, 0.10567304f, -0.00388862f, 0.03251661f, 0.00149746f, 0.13552906f, -0.12817955f, 
    0.01606197f, 0.02069264f, -0.07848299f, 0.08237325f, 0.17058979f, 0.12688100f, 0.04494720f, -0.09601641f, 
    -0.07224841f, -0.09757259f, 0.07596042f, -0.02236673f, -0.02767611f, -0.03375729f, 0.00649499f, -0.08515863f, 
    0.05379203f, 0.07959345f, 0.06737772f, -0.09016573f, 0.16456746f, 0.25981721f, 0.01219757f, 0.01951750f, 
    0.05027029f, -0.04188070f, 0.01693375f, -0.05464922f, -0.10367768f, -0.11038594f, -0.02293546f, 0.01137699f, 
    -0.03661557f, -0.05163068f, 0.00115529f, -0.14255099f, 0.00783718f, 0.05548417f, 0.00760549f, -0.12093882f, 
    -0.14802416f, -0.23582713f, -0.12937430f, 0.15238078f, 0.15265334f, 0.10435420f, 0.03141648f, -0.14052777f, 
    -0.02597708f, 0.00733087f, 0.11987896f, 0.00927965f, 0.11017596f, -0.01183452f, 0.13143669f, -0.05684232f, 
    0.06212229f, 0.02321059f, 0.09966589f, -0.14998037f, -0.12631699f, -0.28297791f, 0.19920634f, -0.05177711f, 
    0.04291556f, -0.12464351f, -0.16907036f, -0.11802277f, -0.09053940f, 0.15191326f, -0.00306408f, -0.06582236f, 
    -0.03104077f, -0.13004561f, 0.03110437f, -0.01875447f, 0.03465189f, -0.00300793f, 0.06534196f, 0.07241465f, 
    -0.01220520f, 0.24584761f, -0.13840392f, -0.05858405f, -0.08235992f, -0.07975107f, 0.02958951f, -0.08040417f, 
    -0.03090582f, 0.01370574f, 0.09642478f, -0.01640422f, 0.05713883f, 0.04131509f, 0.01796531f, -0.04428318f, 
    -0.01846351f, -0.05308037f, 0.00009852f, 0.11605965f, -0.18311442f, 0.06910240f, -0.26339883f, -0.12679286f, 
    -0.24974418f, 0.01927754f, -0.03627696f, -0.23474869f, 0.01554027f, -0.09288014f, 0.11523733f, -0.03562516f, 
    0.00175559f, 0.05198791f, 0.08331005f, -0.00354574f, -0.00708782f, -0.19263956f, 0.04334573f, 0.02244088f, 
    0.24766545f, 0.15521973f, -0.26526234f, 0.15676115f, 0.12790118f, 0.02324225f, 0.00037936f, -0.25934026f, 
    -0.02792730f, 0.04425673f, -0.02934702f, 0.01306718f, -0.01185691f, -0.15071043f, 0.04424758f, -0.02240077f, 
    0.02822952f, -0.04671321f, 0.17499921f, 0.02421351f, -0.05143126f, 0.07177401f, -0.10245553f, 0.09780873f, 
    -0.11953139f, -0.05041861f, 0.02631664f, -0.04602485f, -0.09885067f, 0.00346236f, 0.12066333f, 0.01262878f, 
    0.00732842f, -0.04732477f, -0.03154996f, -0.03101300f, -0.10765284f, -0.14279985f, 0.13984485f, -0.02600807f, 
    -0.26884305f, 0.19773935f, 0.04754286f, -0.21137272f, -0.27162540f, -0.12915362f, -0.01571606f, -0.07107115f, 
    0.01693831f, -0.15214254f, 0.04617628f, -0.06530127f, 0.09492874f, 0.11113781f, 0.04495892f, -0.00769575f, 
    -0.00989835f, -0.15792061f, -0.16246335f, 0.02904292f, 0.04975853f, 0.12740234f, -0.01041303f, 0.09245951f, 
    0.02738895f, 0.09041692f, 0.04967974f, -0.15862554f, -0.12587316f, -0.11678876f, 0.06534719f, -0.00602606f, 
    -0.04843768f, -0.01132395f, -0.15828668f, -0.08971781f, 0.07660262f, 0.10913225f, 0.04594760f, -0.13257934f, 
    -0.26653317f, 0.18398392f, -0.06173803f, -0.29253688f, -0.52075231f, -0.10715371f, -0.08237356f, -0.01563521f, 
    -0.04798083f, -0.07708868f, 0.11666294f, -0.04202818f, -0.04223593f, -0.03135853f, 0.04676407f, -0.06262752f, 
    -0.08865067f, -0.17792149f, 0.01186253f, -0.01344502f, 0.13629816f, 0.24581666f, 0.08414223f, 0.07366784f, 
    -0.07945253f, -0.16020148f, 0.08461975f, 0.07606973f, -0.11846147f, -0.00541402f, 0.07406560f, 0.03292216f, 
    0.00749510f, -0.03793519f, 0.02659239f, -0.09113406f, -0.02693980f, -0.09593814f, 0.16480221f, -0.06892668f, 
    -0.20228636f, 0.11917344f, 0.03455431f, -0.11709336f, 0.13499740f, 0.00087979f, -0.03883257f, -0.02830766f, 
    -0.04187842f, -0.05267402f, 0.08645870f, -0.02080591f, -0.07801064f, 0.01919421f, 0.03800049f, -0.03441978f, 
    0.04302375f, -0.10418896f, 0.04485417f, -0.00164612f, -0.02271263f, -0.15171829f, 0.17736833f, 0.07438788f, 
    0.06794441f, -0.13834374f, -0.09413365f, 0.04811944f, -0.04260732f, 0.04219682f, -0.01095589f, -0.02009792f, 
    0.02011493f, -0.01603880f, 0.00006254f, -0.02797426f, -0.08092821f, 0.09744689f, 0.08432951f, 0.08329678f, 
    0.01295728f, -0.08329322f, 0.15763913f, 0.05066364f, 0.20707715f, -0.19498433f, -0.06819722f, 0.05376878f, 
    -0.06697827f, 0.07422419f, -0.00377737f, -0.06191854f, -0.09111349f, -0.10608379f, 0.11184379f, 0.04923589f, 
    -0.03126081f, 0.01863260f, 0.08613528f, 0.07264952f, 0.16977657f, 0.04406484f, -0.19945435f, 0.10173831f, 
    0.05333027f, 0.05750762f, 0.07982247f, -0.13635676f, -0.00320946f, -0.02639856f, 0.01208463f, 0.07710609f, 
    -0.05602089f, -0.02651175f, 0.07120650f, -0.03943744f, -0.10221660f, 0.04343710f, 0.12307560f, -0.07366886f, 
    -0.09767137f, -0.00840165f, -0.24320059f, -0.22916089f, -0.01600320f, 0.09724423f, 0.05544126f, -0.06036438f, 
    -0.01093997f, -0.04748511f, 0.08917435f, -0.00660248f, -0.01185433f, 0.04299419f, -0.00738342f, -0.08168574f, 
    0.02502504f, 0.10108076f, 0.04320795f, 0.03253513f, -0.37924549f, -0.08970544f, 0.33511397f, -0.19679175f, 
    -0.00314368f, -0.10738340f, -0.06132330f, -0.00981323f, -0.03360568f, -0.14092629f, 0.03406754f, 0.07673809f, 
    -0.06948230f, -0.00435655f, 0.05255161f, -0.18393780f, 0.03651037f, -0.05830522f, -0.00889278f, -0.14780112f, 
    0.01989638f, -0.23646964f, -0.09455575f, -0.00996583f, -0.51909649f, 0.06188989f, 0.04356049f, -0.10568634f, 
    0.01252964f, -0.04565679f, -0.20636433f, -0.10289355f, -0.10394578f, 0.18062012f, -0.00231681f, -0.09147435f, 
    -0.04492206f, -0.01311185f, 0.04207120f, 0.04796809f, 0.02239781f, -0.23080821f, -0.14423349f, 0.08242229f, 
    -0.02415450f, 0.11899673f, -0.05544322f, -0.03924447f, -0.11658830f, 0.06063798f, 0.01160992f, 0.00264452f, 
    0.08629399f, 0.02164649f, 0.02882417f, -0.07992439f, -0.16381642f, -0.13382478f, -0.01960896f, 0.09220006f, 
    -0.14213830f, 0.05407813f, 0.23056386f, -0.30411166f, -0.25922596f, -0.14840670f, 0.09767342f, -0.06751420f, 
    -0.02409723f, 0.04958303f, 0.01877793f, -0.07274877f, -0.00797415f, -0.18325284f, -0.05216448f, -0.05705392f, 
    -0.01758285f, 0.12048259f, -0.05472140f, -0.02361468f, 0.04837682f, -0.08869743f, -0.06065147f, 0.13991137f, 
    -0.07076981f, -0.13988091f, 0.10813275f, -0.01357361f, -0.04708987f, 0.01035620f, -0.03999029f, 0.00038852f, 
    -0.00077817f, 0.07991156f, 0.10458561f, 0.11326212f, 0.05294082f, 0.07290316f, 0.00289028f, 0.05167305f, 
    0.45755056f, 0.09655901f, -0.17620951f, -0.04647170f, -0.00414067f, 0.10784943f, -0.02318756f, 0.10530739f, 
    -0.09821430f, -0.11719436f, 0.01627876f, 0.03690121f, 0.07395841f, 0.04397113f, -0.00037687f, 0.11020784f, 
    0.04740496f, -0.03357305f, 0.01390039f, 0.09613988f, -0.41646647f, -0.01742227f, 0.02323229f, -0.15434054f, 
    -0.13703224f, -0.10305877f, -0.03929165f, -0.19110744f, 0.11829349f, -0.03611792f, 0.04105001f, 0.10615588f, 
    -0.15226033f, 0.03993760f, -0.12662105f, -0.01319851f, 0.03983840f, 0.21299464f, 0.17361575f, -0.02079148f, 
    0.01396799f, -0.03445831f, -0.16884306f, 0.20878132f, 0.03302555f, -0.03728805f, 0.03956523f, -0.06087241f, 
    0.02954712f, 0.00494773f, -0.02425186f, -0.01106425f, -0.00618201f, -0.12377406f, -0.02678954f, -0.04476096f, 
    0.02730434f, 0.08014699f, 0.00487436f, -0.00732778f, 0.29195678f, -0.05930736f, 0.10264117f, -0.25036976f, 
    -0.39032996f, -0.00152709f, 0.02800777f, 0.14442654f, 0.01302325f, -0.04217953f, -0.15171155f, -0.03061245f, 
    0.11070725f, -0.21761756f, 0.05286898f, -0.07681388f, 0.06437664f, -0.19015950f, 0.09670013f, 0.00434018f, 
    0.65270871f, -0.12372701f, -0.02641867f, -0.29575866f, 0.20818605f, 0.06140774f, -0.05491527f, 0.13970348f, 
    -0.08715313f, 0.10215736f, -0.10318141f, 0.04574024f, 0.01525700f, 0.18613051f, -0.10839810f, -0.00716561f, 
    0.11842159f, -0.01852866f, -0.04417142f, -0.09989157f, -0.21025749f, -0.26437518f, -0.00410988f, -0.23710267f, 
    -0.08780826f, -0.06892751f, 0.05413666f, 0.04145778f, -0.04839030f, 0.08129449f, 0.12393896f, -0.14572416f, 
    -0.03935649f, 0.13433756f, 0.04565445f, 0.07470861f, 0.02630092f, 0.04828474f, -0.09448603f, -0.19104031f, 
    -0.00205076f, -0.52090508f, 0.08019043f, -0.03817006f, -0.06549147f, -0.00343623f, -0.02465229f, -0.06860109f, 
    0.06032892f, -0.14051454f, -0.06147695f, 0.10152677f, 0.00287139f, -0.05565212f, -0.00634020f, -0.00534507f, 
    0.02617943f, -0.24362977f, -0.02951332f, 0.13938241f, 0.12323496f, 0.21941362f, -0.17244953f, -0.40118226f, 
    -0.24308574f, -0.07188319f, 0.07799533f, 0.03573005f, -0.03173017f, 0.00409643f, -0.04277599f, -0.05591473f, 
    -0.08686543f, -0.13288935f, -0.03004479f, -0.04566899f, -0.02096039f, -0.00128087f, 0.16244526f, -0.01676559f, 
    -0.43425143f, -0.04149003f, -0.01000511f, 0.15737863f, 0.18668868f, 0.09408411f, -0.02807985f, -0.06522743f, 
    0.01385941f, 0.24216394f, -0.04653459f, -0.00614638f, -0.02732690f, 0.02561518f, -0.08203631f, 0.06142696f, 
    -0.06714895f, 0.01125720f, 0.05068192f, -0.02778111f, -0.17688163f, 0.16284227f, 0.33682045f, -0.27543503f, 
    -0.00200260f, -0.03366666f, 0.03273772f, -0.02083154f, -0.05563809f, 0.06839728f, -0.09845085f, 0.01826812f, 
    0.01314229f, -0.09909964f, 0.05368090f, 0.08272146f, -0.01097446f, 0.12591517f, -0.06346011f, 0.04205285f, 
    -0.21069893f, -0.12705907f, -0.02417580f, 0.18683341f, -0.26162964f, 0.07849137f, 0.11938698f, 0.08649619f, 
    -0.08214971f, -0.01740433f, -0.01892119f, -0.12001250f, -0.09919616f, -0.10208974f, 0.01556916f, -0.02637922f, 
    -0.10764235f, -0.09995995f, -0.11014870f, -0.05620987f, 0.23448001f, 0.03880483f, -0.09137800f, 0.10186991f, 
    -0.13840771f, 0.00531939f, 0.10116418f, 0.01347039f, 0.06306178f, -0.12313117f, -0.00359080f, 0.00484850f, 
    -0.02423030f, 0.05959810f, -0.04626257f, 0.05094497f, 0.06806388f, 0.03196862f, 0.02506382f, 0.00085288f, 
    -0.22647122f, -0.06792173f, 0.12347830f, -0.25766763f, -0.00895464f, -0.04466812f, 0.13272522f, -0.26726806f, 
    -0.02024653f, -0.01137514f, -0.08732291f, -0.01317050f, 0.02006923f, 0.03951350f, 0.03840808f, 0.12315135f, 
    -0.02789956f, -0.03925250f, -0.04636025f, -0.01605620f, -0.05057707f, -0.40931410f, -0.11942993f, 0.24338855f, 
    -0.02859612f, 0.03011900f, 0.00915247f, 0.01129306f, 0.01056985f, 0.12902695f, -0.07725199f, 0.07138713f, 
    -0.04228774f, 0.15641916f, -0.04102940f, -0.01043603f, -0.05598891f, 0.04499774f, -0.06084221f, 0.04557272f, 
    -0.27042469f, 0.32457268f, 0.19060725f, 0.11880986f, -0.01065158f, 0.11713934f, 0.04501023f, 0.00985884f, 
    0.00000444f, -0.07868917f, -0.00342425f, 0.06171692f, 0.09807267f, 0.03356593f, -0.03620875f, 0.08597801f, 
    -0.08694524f, 0.07296315f, 0.00446448f, -0.07751410f, -0.46060178f, -0.09460802f, 0.16635557f, -0.06046241f, 
    0.13797751f, -0.12360688f, 0.02321858f, 0.02903375f, 0.07712083f, -0.02416467f, -0.08186561f, -0.06115154f, 
    -0.05221235f, -0.03891516f, -0.07802373f, 0.15884848f, -0.02855468f, -0.01395699f, -0.00987226f, 0.06128397f, 
    0.35704881f, -0.39324176f, 0.21724522f, -0.17313752f, 0.14795262f, 0.13435094f, 0.01402293f, 0.04017629f, 
    0.06902450f, -0.17770582f, 0.07161383f, -0.01692398f, -0.04569725f, 0.08979607f, -0.03303478f, -0.05143263f, 
    -0.00603708f, -0.06617370f, -0.13832700f, 0.00450177f, -0.59286815f, 0.21157813f, 0.20778340f, -0.00287448f, 
    0.05418791f, 0.15493321f, 0.01774988f, 0.07183065f, 0.04055804f, -0.04586745f, 0.03545117f, 0.02961253f, 
    -0.03584311f, 0.01029550f, 0.08839088f, 0.08352134f, 0.09240765f, 0.10332873f, -0.10634586f, 0.02690953f, 
    -0.25401518f, -0.12053726f, -0.26094732f, 0.17269316f, 0.08578058f, -0.05046900f, 0.01648606f, -0.02828807f, 
    -0.02965688f, -0.02860927f, 0.01887860f, -0.03941504f, -0.18083006f, -0.05268843f, 0.00239707f, 0.02151168f, 
    -0.00729659f, 0.08154050f, 0.11097353f, 0.03527712f, 0.35415706f, -0.03838829f, -0.10357711f, -0.02147488f, 
    -0.17271900f, -0.05551999f, 0.08201598f, 0.02957253f, 0.01920436f, -0.10893200f, 0.01844524f, -0.05237455f, 
    -0.03411264f, -0.00536679f, -0.08596182f, 0.07776099f, -0.05538226f, -0.13422932f, -0.07988118f, 0.09234674f, 
    -0.59015954f, 0.16634579f, -0.01702354f, 0.03377371f, -0.00337659f, 0.17645350f, 0.07916514f, -0.04525999f, 
    -0.00241957f, 0.03649835f, -0.07627138f, -0.05084914f, -0.07003645f, 0.07746478f, 0.12696363f, 0.11336790f, 
    0.06510308f, 0.19381152f, -0.08403493f, 0.12357177f, -0.37463647f, 0.51328558f, -0.14705390f, 0.32209668f, 
    -0.16616793f, 0.17611164f, -0.00331818f, 0.02620312f, 0.18517007f, 0.01106226f, -0.05219542f, 0.03473628f, 
    0.04495800f, -0.07595652f, 0.12138837f, 0.13061023f, 0.02883187f, 0.13287966f, -0.18655993f, -0.06710348f, 
    -0.18279321f, -0.10282143f, -0.07717388f, 0.12850417f, -0.11904753f, -0.07598146f, 0.05941428f, -0.03549530f, 
    -0.00372928f, 0.05018951f, 0.06104573f, 0.01314538f, 0.04164809f, 0.03964334f, 0.12640494f, 0.05882959f, 
    -0.02394429f, -0.00238495f, 0.08628542f, -0.06267614f, -0.03985382f, -0.06190993f, -0.25927299f, 0.07328049f, 
    0.07102594f, 0.12704897f, -0.05732769f, -0.00726524f, -0.00763267f, 0.18382329f, 0.05570292f, -0.05133284f, 
    0.13897270f, 0.12532392f, 0.07282090f, 0.03441017f, -0.06638039f, -0.17393659f, -0.04957623f, -0.12708227f, 
    0.14492068f, -0.04494182f, -0.08123549f, 0.15655218f, 0.00028100f, 0.06163073f, 0.02220010f, -0.12605368f, 
    0.04561376f, 0.14066030f, 0.02948088f, 0.04265206f, -0.03604642f, 0.03841034f, -0.01060157f, -0.03844701f, 
    -0.07811339f, 0.00351429f, 0.02363188f, 0.01680470f, 0.22194223f, -0.25433359f, 0.03115080f, 0.11689779f, 
    -0.12874530f, 0.00054404f, 0.06133256f, 0.14751086f, 0.01264423f, -0.04620062f, -0.01264179f, -0.03372510f, 
    0.02477754f, -0.00630678f, 0.00857894f, 0.13688359f, 0.02329419f, 0.01205209f, -0.06808355f, -0.04211392f, 
    0.00886942f, -0.04407284f, 0.13608244f, -0.10535989f, -0.47870207f, 0.02110488f, -0.05356458f, 0.17261450f, 
    -0.00567598f, 0.04083237f, -0.04181348f, 0.02597131f, -0.01685817f, -0.10492827f, -0.00264601f, -0.14475934f, 
    0.03023811f, -0.05054974f, 0.01520170f, -0.02188453f, 0.39967844f, 0.01554951f, 0.02866337f, 0.05883635f, 
    0.09386886f, 0.03700225f, -0.01634717f, -0.04472306f, -0.08850125f, 0.04002538f, -0.09914956f, -0.10177518f, 
    0.09068252f, 0.08221189f, 0.13669272f, 0.10591938f, 0.03459413f, 0.08005446f, 0.00112572f, 0.02105828f, 
    -0.43930343f, -0.14143078f, 0.18429649f, -0.16058084f, -0.20643683f, 0.07432779f, 0.12590845f, -0.00629616f, 
    0.00592621f, 0.02005675f, 0.06298371f, 0.09538358f, -0.05348241f, -0.08166093f, 0.04905980f, 0.12693784f, 
    0.07795469f, 0.03183981f, -0.07766593f, 0.13569385f, 0.24496420f, 0.07972458f, -0.07605561f, -0.06331196f, 
    0.02486492f, -0.18532744f, -0.03784575f, 0.03245013f, 0.07513988f, 0.03027130f, -0.07795472f, 0.01605158f, 
    -0.00718582f, -0.06787080f, -0.05379087f, -0.09951806f, 0.02526279f, 0.08289957f, 0.03675423f, 0.04671652f, 
    -0.05845969f, 0.06921724f, 0.11002930f, -0.07015524f, -0.12182330f, 0.15804608f, -0.01657187f, 0.02357794f, 
    0.01365741f, 0.07232753f, 0.00082235f, 0.09370613f, 0.01771937f, 0.17268954f, -0.01632062f, 0.02754289f, 
    -0.03799688f, -0.06565283f, -0.14860961f, -0.04219704f, 0.15690951f, -0.10541897f, 0.05597469f, 0.08280068f, 
    -0.00488217f, 0.02281453f, 0.04366191f, 0.05713800f, 0.04004832f, 0.01113091f, 0.01353228f, 0.01736310f, 
    -0.07678976f, 0.02259417f, -0.11304852f, -0.03023027f, -0.11921237f, -0.23304124f, -0.19781777f, -0.08968082f, 
    0.03394529f, -0.01293867f, -0.01929840f, 0.00253927f, 0.05223614f, -0.10405909f, 0.03779125f, 0.03802336f, 
    0.06130233f, -0.04115487f, 0.06634197f, 0.04293710f, 0.06277402f, -0.02196113f, -0.02954360f, -0.01040186f, 
    0.09667122f, -0.00221501f, -0.06176293f, 0.11065113f, -0.53906029f, -0.30347940f, 0.21537633f, 0.06222896f, 
    -0.28236523f, -0.03403794f, 0.07321052f, 0.00728665f, -0.00873454f, 0.14619362f, 0.10824295f, -0.02658338f, 
    -0.06493653f, -0.10388158f, 0.02785781f, 0.01425907f, 0.03380918f, -0.03954291f, -0.08361375f, -0.08495370f, 
    0.21804848f, 0.12560689f, 0.01956384f, -0.04821092f, -0.06071776f, 0.01674172f, -0.09836552f, 0.19844446f, 
    -0.00294650f, 0.01948869f, -0.04966772f, -0.11751026f, 0.09554699f, -0.01801832f, -0.02557076f, 0.03650305f, 
    0.14080806f, 0.02826478f, 0.11118174f, 0.06255128f, -0.64906669f, -0.36123127f, -0.18748322f, -0.09878562f, 
    -0.05877000f, 0.13716875f, -0.01869806f, -0.06008336f, -0.04275527f, 0.01857373f, 0.00257857f, 0.04083532f, 
    0.04739650f, 0.16734174f, 0.04184480f, 0.10492339f, 0.13209827f, 0.10856570f, 0.10584251f, 0.10639125f, 
    0.08169021f, 0.12220876f, 0.02325944f, 0.23990695f, 0.01332017f, -0.04454741f, -0.04814798f, -0.04367941f, 
    0.09915643f, 0.02711911f, 0.06894846f, 0.02849908f, 0.06695705f, -0.08639950f, -0.01326928f, 0.01228953f, 
    -0.09168456f, 0.10992392f, -0.06089743f, 0.02758689f, -0.45782113f, -0.09098005f, -0.29651383f, -0.08510139f, 
    0.09332848f, 0.03733342f, 0.02631759f, -0.02458567f, -0.05016549f, 0.02435735f, 0.06912637f, -0.01610919f, 
    -0.01807318f, -0.17900908f, 0.13654642f, -0.01424526f, -0.04341864f, 0.14027496f, -0.07113663f, 0.07182887f, 
    -0.30406255f, -0.07052058f, -0.21447112f, -0.13360569f, -0.09252001f, 0.05715935f, 0.11313143f, -0.24382868f, 
    -0.08011033f, -0.00156658f, 0.00486822f, -0.02222465f, -0.08693693f, -0.09329235f, 0.11975003f, -0.06238368f, 
    0.05995766f, 0.20552060f, -0.01254279f, 0.06463289f, 0.12394395f, 0.12063190f, 0.09453961f, -0.15291432f, 
    -0.02185021f, 0.13449088f, 0.04665493f, -0.04289535f, 0.06977016f, 0.02261027f, -0.00801459f, -0.00641459f, 
    0.08002863f, 0.01133572f, -0.00506414f, 0.00555725f, 0.14575118f, -0.04430078f, 0.01343719f, 0.02486852f, 
    0.29985118f, 0.08872258f, -0.20417479f, 0.16419023f, -0.15104400f, -0.11674403f, -0.09442098f, 0.04185452f, 
    0.05083952f, -0.09594868f, 0.01807137f, -0.01625033f, 0.06341163f, -0.09877484f, -0.10787889f, -0.02942827f, 
    -0.07223661f, -0.06828906f, 0.00649984f, -0.10928789f, -0.64919543f, -0.46435374f, -0.16698617f, -0.21975614f, 
    -0.23275784f, 0.04098013f, 0.06429992f, -0.02484608f, -0.05329913f, 0.00087731f, 0.07170155f, 0.07275499f, 
    -0.00072150f, 0.06253298f, -0.05571756f, 0.05019635f, -0.05424028f, -0.03099514f, 0.06244145f, -0.01108023f, 
    -0.72187781f, -0.34075418f, 0.04666863f, -0.12144549f, -0.13704678f, 0.07636312f, 0.01697499f, 0.03636818f, 
    -0.10200275f, -0.00283391f, 0.07563420f, -0.00210324f, -0.05610690f, 0.17551225f, 0.05088234f, 0.10665883f, 
    -0.03862294f, 0.10488474f, -0.04601730f, 0.02920549f, -0.40343687f, -0.21288200f, -0.02806035f, -0.03655139f, 
    -0.15246867f, 0.06312738f, 0.08107774f, 0.00963745f, -0.00570782f, 0.05384421f, 0.03228096f, 0.01484612f, 
    0.06939067f, -0.00275592f, 0.05496239f, -0.07489223f, 0.04127465f, 0.13142158f, 0.14727961f, 0.09867471f, 
    -0.59706157f, -0.07798762f, 0.05236404f, -0.13552792f, -0.18291862f, 0.04126903f, -0.04148208f, -0.06682882f, 
    -0.02752667f, 0.05867928f, -0.05366559f, -0.05123746f, -0.04901956f, -0.05996309f, 0.01693875f, -0.01235930f, 
    -0.20398612f, -0.10695817f, -0.02492044f, -0.07228038f, 0.27469802f, 0.13590734f, -0.19513527f, 0.16468631f, 
    -0.16343397f, -0.24524905f, -0.11955065f, 0.07637869f, -0.09203390f, -0.12678052f, 0.01547988f, 0.00453603f, 
    -0.02756457f, -0.08513582f, -0.10160030f, -0.00094346f, -0.09962682f, 0.00005549f, -0.10285614f, -0.14967690f, 
    -0.02894916f, -0.10676809f, -0.09074464f, -0.00020945f, 0.06288952f, 0.09167714f, 0.01738792f, -0.07635454f, 
    0.07071505f, 0.06346241f, 0.07797252f, -0.01058967f, 0.02060294f, 0.05631816f, 0.04153557f, 0.05036012f, 
    0.11393084f, 0.01366667f, 0.21677934f, 0.03478936f, 0.09943128f, 0.03482788f, -0.10803275f, 0.07560946f, 
    0.07990368f, 0.10003892f, -0.02389985f, 0.10127496f, 0.05023390f, 0.06063965f, 0.00152602f, 0.08368539f, 
    0.04735847f, -0.02603918f, 0.03553642f, -0.00829852f, 0.06228405f, -0.21652156f, 0.06640451f, 0.08459290f, 
    -0.74141681f, -0.19411580f, -0.52101117f, -0.16110629f, -0.16441473f, -0.02284290f, 0.04295886f, -0.26001918f, 
    -0.03429268f, 0.04015413f, 0.00522467f, -0.06704112f, 0.03601166f, -0.15074752f, 0.06600130f, -0.06699567f, 
    -0.04799963f, 0.09813088f, 0.03054775f, 0.02387338f, -0.16143928f, -0.11280537f, -0.03929069f, -0.05765116f, 
    0.04529043f, 0.05647844f, 0.13906989f, 0.10788279f, 0.04296159f, -0.05072433f, 0.16793847f, 0.01294578f, 
    -0.01895943f, -0.05846429f, 0.08840831f, 0.03544750f, -0.01521536f, 0.02496957f, 0.16742250f, 0.02901952f, 
    0.20525946f, 0.05160331f, -0.00092547f, -0.00791173f, 0.07772144f, 0.11733104f, 0.12132335f, 0.07857338f, 
    0.09058018f, -0.08046842f, -0.05711874f, 0.03572029f, 0.03899787f, 0.02841766f, -0.03213225f, 0.11065638f, 
    0.08834261f, -0.20721896f, -0.05576554f, 0.05829018f, -0.47407106f, -0.31507948f, 0.05829187f, -0.05538833f, 
    -0.17207994f, 0.04683673f, -0.00840995f, 0.02144513f, -0.06247331f, 0.05094720f, -0.03959973f, 0.02769811f, 
    0.00784617f, 0.03039794f, 0.08625244f, -0.07137341f, -0.08024281f, 0.03646008f, -0.00708968f, 0.04054428f, 
    -0.10892715f, -0.17712393f, 0.04715363f, 0.01369586f, 0.08480695f, -0.00322461f, 0.18212298f, 0.07135388f, 
    0.04197287f, -0.02099540f, 0.08901010f, 0.01653527f, -0.03839333f, -0.06623124f, 0.09559625f, -0.03516858f, 
    0.00649727f, -0.24882889f, 0.05200900f, 0.01461698f, -0.40427801f, -0.17531213f, -0.16594186f, 0.00433474f, 
    -0.02413252f, 0.05124343f, 0.00674352f, 0.06713383f, -0.00419388f, 0.01552908f, 0.14481643f, -0.02124767f, 
    0.00172841f, -0.06018594f, 0.01154059f, -0.01402446f, -0.03261391f, 0.04176161f, 0.26180005f, 0.05609922f, 
    0.24421759f, -0.11011125f, -0.01886138f, 0.04597876f, 0.02330926f, -0.11330447f, 0.02566503f, -0.00791611f, 
    0.06187111f, -0.00443156f, -0.00545621f, -0.02483276f, -0.07984179f, 0.00670899f, -0.01161306f, -0.04619394f, 
    0.01151639f, -0.09529279f, -0.03118387f, -0.02599296f, -0.05573639f, 0.13939983f, -0.17931965f, 0.06705841f, 
    0.00563650f, -0.02051968f, 0.01108968f, -0.02380595f, -0.01692884f, 0.06135336f, -0.02661616f, 0.06942919f, 
    0.08268477f, -0.02237053f, 0.07938249f, -0.08931286f, -0.00451670f, 0.15906207f, -0.00109572f, 0.00277974f, 
    0.26918712f, 0.01614366f, -0.07297061f, 0.00295146f, -0.03603378f, -0.21751028f, -0.06870518f, -0.06657080f, 
    -0.00455918f, -0.11652240f, -0.01540845f, -0.02725542f, -0.08482324f, -0.08554278f, -0.07766685f, -0.08282691f, 
    0.01535282f, -0.02284141f, -0.15261617f, 0.00581654f, -0.34264061f, -0.15266941f, -0.11858275f, -0.01409106f, 
    0.16010492f, 0.01554075f, 0.05035540f, -0.03800082f, -0.10004752f, -0.05846426f, -0.02317356f, -0.06752539f, 
    -0.00778270f, 0.06633884f, 0.08651040f, -0.01814593f, 0.03528458f, 0.12658645f, -0.04709311f, 0.13136943f, 
    -0.17827910f, 0.00456365f, 0.12405103f, -0.01912070f, 0.05549457f, 0.10887029f, -0.03414642f, 0.01743147f, 
    -0.01599043f, -0.00943215f, 0.02240724f, 0.04171020f, 0.02649037f, 0.13313602f, 0.04078803f, 0.06024939f, 
    0.02924135f, 0.00428503f, -0.07278065f, 0.02422553f, 0.12449643f, 0.09077831f, 0.08744099f, -0.02681263f, 
    -0.08477434f, -0.04615009f, -0.16966155f, 0.08657662f, 0.04180654f, 0.10712329f, -0.00263140f, 0.05599479f, 
    -0.04759267f, -0.09373911f, -0.11138066f, -0.00740798f, -0.04765675f, -0.05185968f, -0.01946765f, -0.01509989f, 
    -0.23161313f, 0.44842979f, -0.02667823f, -0.15365565f, 0.64074576f, 0.30009469f, -0.20235726f, 0.01777271f, 
    0.05343982f, 0.15338635f, 0.02974975f, 0.07684264f, 0.09004131f, -0.01016936f, 0.00445681f, -0.07814183f, 
    0.18640783f, 0.01810099f, -0.13880648f, -0.05761148f, -0.24584635f, -0.00836637f, -0.12539820f, -0.03572247f, 
    0.05369300f, -0.06982528f, -0.03029714f, 0.01990183f, 0.00692629f, 0.03474617f, -0.09054159f, -0.02065420f, 
    0.01471247f, -0.15424047f, -0.02800457f, -0.02363360f, -0.03625397f, 0.01201228f, -0.13230051f, -0.08364946f, 
    0.46195421f, 0.12613465f, -0.31922162f, -0.01584141f, 0.16141592f, -0.08968758f, 0.10690559f, -0.09651869f, 
    0.05783176f, -0.07619153f, 0.16239731f, 0.07128761f, -0.02265821f, 0.08803961f, 0.01307862f, 0.04074896f, 
    -0.00433353f, 0.02430888f, -0.00005408f, 0.12049564f, 0.01666172f, 0.10697732f, -0.08743493f, -0.13239741f, 
    0.00179840f, -0.15748064f, -0.24765909f, -0.02711020f, -0.12805144f, -0.15264718f, 0.05534697f, -0.11353986f, 
    -0.01700321f, 0.05067852f, 0.06552136f, 0.11929834f, -0.01292547f, -0.04575078f, 0.14281338f, 0.12826498f, 
    -0.49136013f, 0.29399619f, 0.06960088f, -0.04039723f, 0.04131897f, -0.01681075f, -0.11901621f, -0.00350358f, 
    0.01841917f, 0.15979737f, 0.09060811f, -0.08057715f, 0.01305067f, -0.04794246f, -0.09368938f, -0.07126240f, 
    -0.05251047f, -0.04121046f, -0.12381436f, -0.02413940f, 0.44234350f, 0.14343244f, -0.25669137f, -0.08361652f, 
    -0.19268534f, -0.08723296f, -0.04739306f, 0.06826746f, -0.03590854f, -0.02277594f, 0.05875796f, 0.04935568f, 
    0.01367796f, -0.06145957f, -0.11657302f, -0.06382149f, 0.04467890f, 0.00839410f, -0.06030976f, 0.00084828f, 
    0.23285545f, 0.05230336f, -0.00855131f, -0.07484004f, -0.03014296f, -0.04441809f, 0.00689576f, 0.08503567f, 
    0.02831864f, -0.03129377f, 0.00617958f, -0.09745160f, -0.08264843f, 0.03776893f, -0.01708471f, -0.01229614f, 
    -0.07966700f, 0.06534918f, -0.07552887f, -0.12755664f, 0.50105673f, -0.18380845f, -0.08937586f, -0.20426227f, 
    -0.11353084f, 0.12042999f, 0.06156956f, -0.01426966f, 0.01390519f, 0.04750028f, 0.13237430f, -0.03052129f, 
    0.01936677f, -0.01611919f, 0.01891880f, 0.00844136f, -0.07328658f, -0.02650529f, 0.04725438f, 0.05093124f, 
    -0.52875102f, -0.01364173f, 0.03178766f, 0.01833898f, 0.17062519f, -0.07873624f, -0.02319143f, 0.05496619f, 
    0.00810058f, 0.07821871f, -0.03777757f, -0.00311783f, 0.06839790f, 0.10077256f, -0.05321816f, -0.03218929f, 
    -0.05792801f, -0.02137974f, -0.11558123f, -0.04777203f, -0.42059827f, -0.25767088f, 0.05474307f, 0.07288639f, 
    0.17545389f, -0.08772149f, 0.20265143f, 0.01277801f, 0.02751537f, -0.05655058f, 0.00522442f, -0.04757423f, 
    -0.04153809f, 0.10969596f, -0.05671913f, -0.10992170f, -0.07562990f, -0.03284688f, -0.14061876f, -0.03372236f, 
    -0.46407434f, -0.28901273f, -0.28157648f, -0.12181430f, -0.32768041f, 0.05221479f, 0.07442815f, -0.03175040f, 
    0.09221625f, 0.04693798f, -0.12806293f, 0.07490731f, 0.06476855f, -0.03474454f, -0.06591342f, -0.12659289f, 
    -0.00649281f, -0.10651948f, -0.21816717f, -0.02894432f, 0.06389461f, 0.02465709f, -0.11607718f, -0.09654981f, 
    0.23580591f, 0.13601375f, -0.11728991f, -0.01958981f, 0.09995686f, 0.01791487f, 0.00145787f, 0.01946077f, 
    0.01022361f, -0.00787078f, 0.06274928f, 0.07703342f, -0.07948519f, 0.04590009f, -0.04491825f, 0.13275659f, 
    0.19571519f, -0.22486877f, 0.12037824f, 0.07109308f, -0.03520803f, -0.08678099f, 0.03560304f, 0.12706704f, 
    -0.03442872f, 0.00064588f, -0.12900646f, -0.05427652f, -0.05414176f, -0.01765787f, -0.10222507f, -0.10138888f, 
    -0.10289037f, -0.00829763f, -0.13995564f, 0.00153262f, 0.38295630f, -0.09099755f, -0.09138072f, 0.09950674f, 
    -0.05022432f, 0.10199089f, -0.04427505f, -0.00324749f, -0.04073295f, -0.02480357f, 0.08785873f, 0.10568595f, 
    0.09791592f, 0.04454114f, -0.02632993f, -0.03008676f, -0.01503185f, -0.07092402f, -0.01113779f, 0.08343015f, 
    0.20012175f, 0.41048557f, -0.16940826f, -0.09886231f, -0.10316447f, 0.12976770f, -0.02657737f, -0.01521249f, 
    0.05979621f, 0.05234931f, 0.11403248f, 0.05868123f, -0.07626576f, 0.01117563f, 0.10753693f, -0.00762911f, 
    0.02649620f, 0.00695334f, -0.04340996f, 0.12488949f, -0.05561886f, -0.43371186f, -0.15440702f, -0.26853350f, 
    -0.15747948f, -0.02308800f, -0.02685596f, 0.04929652f, -0.02286075f, 0.11933701f, 0.00466267f, 0.00612514f, 
    -0.00050099f, 0.02300221f, -0.03766131f, -0.04289748f, 0.04692987f, 0.03935667f, 0.01240696f, -0.06730980f, 
    0.19039261f, 0.05652656f, -0.21197195f, -0.06876999f, -0.21770872f, -0.05615706f, 0.00524026f, 0.01403361f, 
    -0.01454374f, -0.08869353f, 0.12103654f, -0.01156256f, -0.02040010f, -0.00374463f, -0.00940746f, 0.04639741f, 
    0.03669271f, -0.03250243f, 0.02885918f, -0.00489247f, 0.21542053f, -0.26680321f, 0.10270362f, -0.10644804f, 
    0.00190869f, -0.01013756f, 0.12674190f, -0.01311355f, -0.06237064f, -0.12259881f, -0.10682601f, -0.11646309f, 
    0.07956473f, 0.11923876f, -0.07155760f, -0.03078675f, -0.06865136f, -0.05572838f, -0.26639473f, -0.02384744f, 
    0.07000988f, 0.08077817f, 0.02413268f, 0.01911352f, 0.04835584f, 0.05324312f, 0.03844321f, -0.00131029f, 
    -0.05805784f, 0.02046743f, 0.03134686f, 0.02134352f, 0.06252102f, 0.03868454f, -0.09313417f, -0.12262838f, 
    -0.04776706f, -0.08946785f, -0.02239239f, 0.03570587f, 0.08225268f, -0.03948282f, -0.00268195f, 0.22077353f, 
    -0.04684985f, -0.04051747f, -0.02236666f, 0.05411957f, -0.01007610f, -0.18098503f, 0.15986194f, -0.05249191f, 
    -0.00350492f, -0.00335921f, -0.05521702f, 0.09975178f, 0.06951089f, 0.04316549f, -0.01571508f, -0.12754934f, 
    -0.09338310f, -0.01709371f, -0.29082352f, 0.06122183f, -0.44269136f, -0.01466265f, 0.08206152f, 0.00393664f, 
    -0.05760537f, 0.04576595f, -0.07946141f, -0.09980270f, 0.08288436f, -0.05160600f, 0.10338802f, 0.02138723f, 
    0.05875580f, -0.08853720f, -0.06934193f, -0.08107620f, 0.11926206f, -0.04669447f, 0.00550439f, 0.13646150f, 
    -0.05137298f, 0.15987450f, 0.05068131f, -0.04610231f, 0.04481611f, 0.09694052f, -0.04669753f, 0.00793033f, 
    0.01538212f, 0.09333460f, 0.07571103f, -0.02943849f, 0.06911970f, 0.03014568f, -0.07082497f, -0.03075108f, 
    -0.21462069f, 0.25402695f, -0.21693096f, -0.19190346f, 0.05690830f, -0.06690728f, -0.16219825f, 0.07546523f, 
    -0.13679415f, 0.00780228f, 0.10275939f, 0.04977711f, 0.01156585f, 0.04392060f, 0.01099752f, 0.04805920f, 
    -0.01605392f, -0.00381103f, 0.08548320f, -0.02439083f, 0.14426783f, -0.16553651f, -0.08487283f, -0.14146295f, 
    -0.08264834f, 0.03569321f, -0.10678001f, 0.02077171f, -0.01547581f, 0.07312988f, 0.03068842f, 0.01144212f, 
    0.05100248f, -0.01492705f, -0.05251096f, 0.03639925f, 0.05298860f, -0.10853296f, 0.01665654f, -0.10627892f, 
    0.09220989f, 0.17539786f, -0.10247610f, 0.06120535f, 0.08059116f, 0.01286282f, -0.20232065f, 0.01908859f, 
    0.00026613f, 0.01387836f, 0.05587861f, 0.04793555f, -0.08272808f, 0.01493257f, 0.03915123f, -0.09299300f, 
    0.14695752f, 0.07138830f, -0.02692135f, 0.01668236f, -0.01578327f, -0.32888401f, -0.04365043f, 0.05615699f, 
    0.00932067f, 0.09331474f, 0.02643537f, 0.01245622f, -0.04178150f, 0.13241419f, -0.02267301f, 0.05156033f, 
    -0.19729160f, -0.01107702f, -0.01990649f, -0.09967741f, 0.11293761f, -0.01590779f, -0.10030925f, -0.02579382f, 
    -0.19007726f, 0.16241102f, -0.10565571f, 0.01283680f, -0.06850858f, -0.09052951f, -0.16293792f, 0.09994635f, 
    -0.04329532f, -0.05151752f, 0.06038794f, -0.05540527f, 0.06323802f, -0.06853259f, 0.02000131f, 0.11290316f, 
    0.03664182f, -0.02706448f, 0.08918343f, -0.06299511f, -0.34559721f, -0.09084212f, 0.22164062f, -0.05386410f, 
    0.18842301f, -0.11739600f, 0.19247088f, 0.01334503f, 0.07511923f, -0.11280669f, -0.08009386f, 0.04092477f, 
    0.05792744f, 0.04337432f, -0.00306665f, 0.06514835f, -0.02341073f, -0.02921213f, -0.12542483f, 0.01335478f, 
    -0.17381254f, -0.06713855f, 0.10217117f, 0.00015311f, -0.08529274f, -0.04202423f, 0.01841892f, 0.01048184f, 
    -0.04136020f, -0.02283351f, -0.04683039f, -0.03500820f, 0.00924350f, -0.01909423f, -0.10756787f, -0.11534942f, 
    -0.01531786f, -0.03214416f, -0.05433396f, -0.02468503f, -0.36588824f, 0.32915527f, -0.16765702f, 0.08662376f, 
    -0.40092629f, 0.09813412f, 0.13325165f, -0.01079777f, 0.06388963f, 0.11159504f, 0.00990705f, -0.02804833f, 
    -0.05058414f, -0.00998417f, 0.09215295f, -0.06427873f, 0.05318343f, -0.05496264f, -0.08743200f, 0.09769681f, 
    0.24112204f, 0.21944995f, -0.16929938f, -0.13591202f, 0.21788810f, 0.14699104f, 0.00140409f, 0.01246986f, 
    0.10631101f, -0.04942449f, 0.09218548f, 0.05701786f, -0.08331148f, -0.01250956f, 0.03913387f, 0.04923997f, 
    0.00168627f, 0.03047589f, -0.05038287f, 0.11350415f, 0.25413865f, -0.09166675f, 0.06000640f, -0.04854819f, 
    0.08583535f, -0.11554840f, -0.07509886f, -0.04208057f, -0.02005823f, -0.23674865f, -0.05576989f, -0.09549659f, 
    0.05631715f, 0.02002899f, -0.14575703f, -0.04041303f, -0.10377445f, 0.00282946f, 0.00520456f, -0.00802779f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09375649f, 0.00505419f, -0.00510318f, 0.03883352f, 0.02585633f, 0.00279858f, -0.02902613f, -0.09819321f, 
    -0.01833659f, -0.00039229f, 0.08522040f, -0.00185584f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
