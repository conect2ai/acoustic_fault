#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31888631f, 0.50955302f, -0.02634438f, -0.58867699f, -0.46072951f, -0.03447729f, -0.06775171f, 0.22499782f, 
    -0.22469725f, -0.09513808f, 0.17321044f, -0.00583728f, 0.16270614f, -0.30768847f, -0.14875719f, -0.08531113f, 
    -0.06298982f, -0.21074165f, -0.29009759f, -0.57252467f, -0.15814017f, -0.07238962f, -0.35918760f, -0.26365355f, 
    -0.43368971f, -0.67785990f, -0.46974361f, -0.42701477f, -0.20901281f, -0.10208019f, 0.12610601f, -0.30337843f, 
    0.30478269f, 0.31745982f, 0.45251465f, 0.25388539f, -0.23794274f, -0.10039728f, -0.34668753f, -0.07434513f, 
    0.20814562f, -0.12097353f, -0.16414188f, 0.11227077f, 0.07582869f, -0.05833987f, 0.15519145f, 0.20070830f, 
    -0.10602462f, 0.19091186f, -0.51781887f, -0.33051530f, 0.02748753f, -0.35432738f, -0.41149473f, 0.18507832f, 
    0.39622453f, 0.40873978f, -0.12816466f, -0.08862761f, 0.21600886f, -0.16975760f, -0.17087960f, -0.12271811f, 
    0.10744962f, 0.32511556f, 0.18490934f, -0.07008578f, -0.21430248f, -0.25073725f, 0.12583885f, -0.22183728f, 
    0.26690185f, -0.11765995f, -0.26106068f, -0.11708882f, -0.32495341f, -0.00357100f, 0.45288345f, 0.39806083f, 
    0.14018115f, 0.18781024f, -0.01854403f, 0.03281260f, 0.20575400f, 0.11895832f, 0.04236074f, -0.02303190f, 
    0.18091889f, 0.04371182f, 0.05208906f, -0.22410932f, -0.11598644f, -0.20059386f, -0.21637562f, -0.01047675f, 
    -0.13359521f, -0.15908697f, -0.08458931f, -0.03459404f, -0.15630765f, -0.17770602f, -0.40562430f, -0.55537957f, 
    -0.55215508f, -0.02689145f, 0.01290064f, 0.14194147f, 0.19463158f, 0.45625448f, 0.34742945f, 0.41378278f, 
    0.04380452f, 0.11508501f, 0.35050565f, -0.13201952f, 0.07059938f, 0.02098426f, 0.00975003f, -0.27777746f, 
    0.06602618f, -0.17110367f, -0.17568669f, -0.31724060f, 0.20143957f, -0.25436249f, -0.00765422f, 0.14227177f, 
    0.11811985f, 0.10387604f, -0.12073825f, -0.16673934f, 0.36870575f, 0.51683396f, 0.22892094f, -0.14493617f, 
    0.07154926f, 0.00812737f, 0.21303810f, -0.03522487f, -0.23298740f, 0.17003901f, -0.02101693f, -0.08237673f, 
    -0.23428680f, 0.37980786f, -0.48278755f, 0.07702642f, 0.15751928f, 0.01339648f, -0.32830164f, -0.09734911f, 
    -0.01975224f, 0.27685556f, -0.01786065f, 0.06130023f, -0.08512174f, 0.23603168f, 0.38663104f, 0.35261610f, 
    -0.29669043f, -0.28999937f, 0.20562619f, 0.27671939f, -0.07582809f, -0.23671225f, -0.07508120f, -0.17880104f, 
    -0.00220075f, 0.02147532f, 0.08078330f, -0.09474935f, -0.19292165f, 0.23383628f, 0.39033574f, 0.74503094f, 
    -0.23708726f, -0.40904671f, -0.04396181f, 0.57873183f, -0.10489950f, -0.03711312f, -0.18641093f, -0.51229650f, 
    -0.63272542f, -0.05517476f, 0.26681852f, 0.20261116f, 0.19368559f, -0.02537184f, -0.13080460f, -0.26477328f, 
    0.30310443f, 0.01320486f, 0.20529374f, -0.09737679f, 0.20678104f, -0.00958941f, -0.31226954f, -0.33681518f, 
    0.40778443f, 0.17486787f, 0.03316024f, 0.22747824f, 0.04737326f, -0.26651829f, 0.21670485f, 0.07324437f, 
    -0.09867354f, -0.14668880f, -0.02356398f, -0.21342872f, -0.14910761f, -0.26975867f, -0.16081193f, -0.00904351f, 
    0.32149026f, 0.19515890f, 0.28099900f, -0.21575022f, -0.08681337f, -0.18610597f, -0.17478867f, 0.01349659f, 
    0.02077292f, 0.38175657f, 0.11828917f, 0.26806954f, -0.09522864f, -0.07885585f, 0.35954049f, 0.25890768f, 
    -0.19203570f, -0.07287230f, 0.21866417f, -0.06181217f, 0.03244121f, 0.16630037f, -0.21083474f, 0.34462130f, 
    -0.09400865f, -0.25153589f, -0.17481826f, -0.01708607f, -0.05044387f, -0.10741267f, -0.10497294f, -0.21258268f, 
    -0.12357566f, 0.47237936f, -0.56429607f, 0.41508722f, 0.08012531f, -0.04031353f, 0.18611878f, 0.23690595f, 
    -0.12155699f, -0.08838391f, 0.09259991f, 0.23380794f, -0.04080391f, -0.00457149f, -0.03852592f, -0.26984772f, 
    -0.32014394f, 0.21177205f, 0.04299295f, -0.03506729f, 0.10100332f, 0.17750829f, -0.26607236f, 0.05685037f, 
    -0.33938783f, -0.26753092f, -0.53349596f, 0.28805828f, -0.28950265f, 0.24896722f, -0.41352743f, -0.72346240f, 
    0.24380754f, 0.04309902f, -0.08911815f, -0.04035939f, 0.13513748f, 0.15790819f, -0.38556412f, -0.20487867f, 
    -0.09619362f, 0.14538063f, -0.13435286f, 0.33869281f, 0.15599887f, -0.08056573f, 0.10600962f, -0.09027664f, 
    0.29402524f, -0.22309251f, -0.30848542f, -0.41843474f, 0.59189075f, 0.48664156f, 0.44982302f, 0.20684116f, 
    0.14152008f, -0.14083126f, -0.35844594f, -0.25280514f, 0.10497772f, -0.05334408f, 0.34869111f, -0.37278590f, 
    -0.24961622f, 0.20562723f, 0.06898742f, 0.00357959f, 0.10423516f, 0.14284286f, -0.11976811f, 0.16133361f, 
    0.06169814f, 0.10895926f, -0.13329709f, 0.08644272f, -0.09735574f, -0.09011508f, 0.15016557f, 0.07377086f, 
    0.19679621f, 0.30763954f, 0.21924730f, -0.01364097f, 0.13714810f, 0.05030222f, -0.05808292f, 0.06346573f, 
    0.17662522f, 0.04377173f, -0.01997161f, 0.19950442f, -0.09074666f, -0.09078819f, 0.01115713f, 0.05199915f, 
    0.13912827f, -0.04268393f, 0.09744767f, -0.00890793f, 0.08232138f, 0.10483149f, 0.34290409f, 0.20338584f, 
    0.04736161f, 0.08724821f, 0.19341145f, -0.24814555f, 0.12112439f, 0.19882075f, -0.24220586f, 0.43726912f, 
    -0.11666256f, 0.21611366f, -0.43717140f, -0.36728910f, 0.21016583f, 0.28242204f, 0.02643182f, 0.12363485f, 
    0.00802760f, -0.31675541f, -0.09386189f, -0.00620626f, -0.04453340f, -0.21860546f, -0.25879368f, 0.16883679f, 
    -0.57791889f, -0.48282862f, 0.11952415f, 0.74014246f, -0.10883179f, 0.34021971f, -0.03661991f, -0.25522092f, 
    -0.39956161f, -0.33570883f, -0.56912172f, 0.01900514f, -0.23988272f, 0.31434393f, -0.26389432f, -0.31077126f, 
    0.06449174f, 0.32442725f, -0.52943611f, 0.38356224f, -0.03069764f, 0.00611372f, -0.17386401f, -0.30191693f, 
    0.86343110f, -0.07968541f, -0.25208017f, -0.15039793f, -0.27109244f, -0.20171037f, 0.30155697f, 0.16521305f, 
    -0.10473389f, 0.29004791f, 0.06153262f, 0.03912632f, 0.27317724f, -0.57024586f, -0.24913895f, 0.06236626f, 
    -0.31647891f, 0.19761394f, -0.24583888f, -0.13421270f, 0.03753085f, -0.22189304f, 0.06507312f, 0.20686816f, 
    0.35335687f, -0.75212777f, -0.03978557f, 0.60558122f, 0.40029910f, 0.04989826f, 0.17482747f, 0.10831353f, 
    -0.34983590f, 0.12368321f, -0.36345857f, -0.40161216f, 0.23850667f, -0.30330455f, 0.32759261f, 0.22826935f, 
    -0.20924026f, 0.21057382f, -0.20947711f, -0.02704553f, 0.22109289f, 0.24573231f, 0.13118495f, 0.02119283f, 
    -0.08371931f, -0.24549548f, -0.18988030f, -0.30994686f, -0.25946242f, -0.09564608f, -0.01818692f, 0.32577994f, 
    -0.30542538f, -0.09616224f, 0.52145410f, -0.13214760f, 0.06978567f, 0.07334536f, 0.11358965f, 0.05943128f, 
    0.17450665f, -0.17591409f, 0.25293890f, 0.06425673f, -0.06703144f, 0.32839540f, -0.06319104f, -0.13216370f, 
    0.02696815f, -0.08865407f, 0.08492780f, 0.12937611f, -0.06935371f, -0.16951357f, 0.20132461f, 0.27246371f, 
    0.22157273f, 0.06650359f, 0.03095935f, 0.11457638f, 0.23321037f, 0.26305491f, -0.16011116f, -0.24771751f, 
    0.56188112f, -0.01086260f, -0.25970829f, 0.06655244f, 0.15793622f, 0.01489283f, -0.45243472f, 0.00373174f, 
    0.27893320f, -0.04652543f, 0.07553934f, -0.06197565f, 1.05430019f, 0.30222389f, -0.38113123f, -0.73747379f, 
    -0.92264938f, -0.17500150f, -0.25262409f, 0.10753183f, 0.27130133f, 0.17194471f, 0.23666048f, 0.32479948f, 
    0.18125486f, -0.34767514f, -0.09464081f, 0.30210146f, 0.15718502f, 0.28237885f, 0.16479954f, -0.16776454f, 
    0.38625598f, -0.26106095f, -0.30824715f, -0.05060465f, -0.20024741f, -0.60960108f, 0.60249561f, -0.47407287f, 
    -0.11172532f, 0.53172356f, 0.04402774f, 0.37168685f, 0.30769095f, -0.00487036f, -0.24127023f, -0.08933042f, 
    -0.26904872f, -0.37878633f, 0.07347731f, 0.00793771f, 0.30406716f, -0.03015272f, -0.12169568f, 0.26518717f, 
    -0.03386347f, -0.23575233f, -0.16261886f, -0.25631401f, -0.33262721f, -0.47719267f, -0.84643650f, -0.29071543f, 
    -0.32313210f, 0.45289341f, 0.20046255f, 0.25575697f, 0.33044645f, 0.15589893f, -0.05823635f, 0.27966568f, 
    0.49308971f, 0.02843843f, -0.09024138f, -0.06174993f, 0.18300363f, 0.00507452f, -0.10357332f, -0.20404321f, 
    0.02437815f, 0.12026687f, 0.17415844f, 0.06694367f, -0.13321203f, 0.10864547f, 0.10106836f, 0.11493766f, 
    -0.14738457f, 0.64546806f, 0.53529245f, -0.69019735f, -0.63083255f, -0.34754023f, 0.26495746f, 0.39677003f, 
    -0.21007591f, 0.22753218f, -0.26082820f, -0.17707701f, 0.20202506f, 0.02722202f, 0.12098329f, 0.03631085f, 
    0.37441847f, 0.19588833f, -0.16677196f, -0.06362549f, 0.22450827f, -0.47948125f, -0.39252779f, 0.14978090f, 
    -0.01088989f, -0.24838607f, -0.33957705f, -0.23527132f, -0.33265218f, -0.42069781f, -0.22875288f, 0.01214107f, 
    0.08320218f, -0.17418016f, -0.01199875f, -0.27731988f, -0.03723526f, 0.09012301f, 0.13342352f, 0.05145792f, 
    0.07820764f, -0.07055598f, 0.06869602f, -0.22127980f, 0.16959311f, -0.26411775f, -0.33920628f, -0.23090662f, 
    -0.07447329f, -0.71074623f, 0.72601968f, -0.30123973f, 0.04394225f, 0.07593814f, 0.00956632f, -0.22820316f, 
    0.16624537f, -0.02411262f, -0.28379586f, -0.09881116f, 0.50845307f, -0.23309340f, -0.18252566f, 0.32803783f, 
    -0.08973403f, -0.01866010f, 0.01834510f, 0.20708990f, -0.09424011f, -0.12204093f, 0.27817175f, 0.03196651f, 
    -0.13231231f, 0.21565536f, -0.50615025f, 0.26700738f, 0.22013544f, -0.54849482f, 0.19518501f, -0.09455562f, 
    -0.06304670f, -0.19729000f, -0.13775037f, -0.35585004f, 0.01183585f, -0.12328950f, -0.15384030f, -0.06569516f, 
    0.07574142f, 0.11605903f, -0.12495098f, -0.01291904f, 0.02134253f, -0.36042231f, 0.13385318f, 0.06332163f, 
    -0.01161602f, 0.20398568f, 0.45916441f, -0.04692172f, -0.02099346f, -0.21850973f, -0.53853375f, -0.03137601f, 
    -0.71440583f, -0.71327221f, -0.48169237f, -0.36333504f, -0.52874947f, 0.62383741f, 0.23327531f, 0.41478688f, 
    -0.08985974f, -0.00922209f, -0.23031585f, 0.04165798f, 0.07991192f, 0.01148870f, 0.06802906f, 0.13236099f, 
    0.10688911f, -0.04377186f, -0.35507724f, 0.24841717f, 0.49693441f, -0.30379277f, 0.00080746f, -0.22896385f, 
    -0.35539630f, 0.16213340f, -0.01745549f, -0.04727660f, 0.13177960f, 0.17947114f, -0.22209674f, 0.09991506f, 
    0.04489618f, -0.18540595f, 0.05628584f, -0.26358792f, 0.20725001f, -0.18003671f, 0.05942367f, -0.49912965f, 
    0.18544778f, 0.21500006f, 0.42963240f, 0.08167309f, 0.40359834f, -0.10655225f, -0.00893642f, 0.26174361f, 
    0.35451686f, -0.17748341f, 0.18649125f, -0.20619334f, -0.16505095f, -0.40479591f, 0.24411359f, -0.21528263f, 
    -0.06430233f, -0.03317828f, -0.06283093f, 0.34810868f, 0.09293458f, -0.24195087f, 0.06659140f, 0.32380441f, 
    -0.13461760f, -0.40954307f, 0.23441336f, 0.06572684f, 0.15415610f, -0.05743698f, 0.51035601f, -0.76651543f, 
    -0.21601182f, -0.02793386f, -0.26150143f, -0.30507198f, -0.33327064f, 0.03918978f, 0.17657250f, 0.11937591f, 
    -0.09807488f, -0.49242520f, -0.39671990f, 0.23985289f, 0.00071893f, -0.41401199f, -0.28120100f, 0.24271387f, 
    -0.23390484f, -0.39338559f, 0.06223539f, -0.33720705f, 0.14496335f, -0.30277309f, 0.04390217f, -0.64994973f, 
    -0.69413871f, -0.22936910f, 0.41073078f, 0.72442722f, 0.41564476f, 0.86193931f, 0.31600955f, -0.80134839f, 
    -0.29637939f, 0.17919268f, -0.36040345f, 0.02159212f, -0.40895057f, -0.20911966f, 0.04761129f, 0.27124536f, 
    0.09959262f, -0.20819375f, 0.22868244f, -0.02068647f, -0.21825220f, -0.08322149f, 0.21293867f, 0.27282470f, 
    -0.31870797f, 0.39837873f, 0.39761752f, -0.18291873f, 0.00561028f, -0.01932198f, 0.06602159f, 0.15585330f, 
    -0.15053928f, -0.21828777f, -0.13737087f, 0.31653097f, -0.14244081f, 0.03385600f, -0.00818023f, 0.17334108f, 
    -0.21677646f, -0.30523983f, -0.30342048f, 0.00631136f, 0.12487406f, 0.16075253f, 0.04899827f, 0.29049703f, 
    -0.05600009f, 0.03288177f, 0.38066256f, 0.09682786f, 0.04288606f, -0.28709817f, 0.04786367f, 0.11986375f, 
    0.06256776f, -0.05155677f, 0.27636516f, 0.00379512f, 0.04604430f, 0.01494808f, 0.27590084f, -0.40049121f, 
    -0.02840747f, -0.29551312f, 0.29541972f, -0.22523241f, 0.05608360f, 0.37979409f, 0.29054397f, -0.20611475f, 
    -0.28775135f, 0.12184381f, 0.46028128f, -0.04910830f, 0.37417108f, 0.08460063f, 0.05556612f, -0.38256967f, 
    0.02307079f, 0.50389808f, -0.20791368f, -0.25544524f, 0.16573653f, -0.13594747f, -0.24185313f, -0.15886833f, 
    0.15515639f, -0.16445769f, -0.17607877f, -0.19456156f, 0.27151090f, 0.23941828f, 0.11230037f, 0.24532194f, 
    -0.14714959f, -0.24000502f, -0.16590576f, -0.14054763f, -0.57416111f, 0.49360466f, 0.63908911f, -0.16424544f, 
    -0.24637486f, -0.74215877f, -0.34319192f, 0.00852770f, 0.40002614f, 0.16073567f, 0.01243322f, -0.04732826f, 
    0.08493430f, 0.20169736f, -0.41743106f, 0.11008664f, 0.25673270f, -0.19544435f, -0.09933388f, 0.23021203f, 
    -0.09525137f, -0.04982005f, 0.29087496f, 0.15130199f, 0.50808448f, 0.62273794f, 0.34272555f, 0.43870658f, 
    -0.70566428f, -0.19165778f, -0.33069625f, -0.17638883f, -0.21756862f, -0.19310702f, 0.14557602f, -0.10528760f, 
    0.10405716f, -0.08018157f, -0.25737295f, -0.04745042f, 0.02004070f, -0.07615744f, 0.13626759f, 0.06969702f, 
    0.00364243f, -0.01203663f, 0.09316152f, 0.10169392f, -0.08317649f, -0.69592494f, -0.32120100f, -0.56499618f, 
    0.26935783f, 0.39080730f, -0.09164783f, 0.24454698f, -0.14478873f, -0.25088602f, 0.40758029f, -0.17550053f, 
    -0.23458882f, -0.28792188f, -0.27121383f, 0.46066594f, 0.23047435f, -0.21914701f, 0.13559178f, -0.48966724f, 
    0.09954818f, -0.09856774f, 0.04215017f, -0.20421775f, -0.44709471f, -0.01625912f, -0.28035209f, -0.07328399f, 
    -0.45201120f, -0.56844527f, -0.06012436f, -0.17498444f, -0.25864333f, -0.31686482f, -0.29424399f, -0.24294375f, 
    0.22666316f, 0.40064210f, 0.14520913f, -0.30965349f, -0.21289818f, -0.39052922f, -0.35542181f, -0.20892644f, 
    -0.48040235f, -0.09475195f, 0.30066991f, -0.08221058f, 0.05462376f, -0.07576554f, 0.10252990f, 0.34913993f, 
    -0.09305836f, -0.06804082f, 0.24781542f, 0.15250167f, 0.15167648f, 0.11435152f, -0.16688320f, 0.24102362f, 
    -0.16917376f, 0.30227822f, -0.02561945f, -0.19130884f, 0.25987035f, -0.02197535f, 0.25213838f, -0.23814698f, 
    0.15568049f, -0.06024123f, 0.00770470f, 0.00957738f, 0.26841310f, -0.11313337f, -0.02727863f, 0.12851433f, 
    -0.03719795f, -0.30314600f, -0.29739669f, 0.02780202f, -0.02793174f, -0.36216754f, -0.16183667f, 0.01215034f, 
    -0.18373160f, 0.23468842f, 0.24466981f, 0.37194204f, 0.05277619f, 0.22437553f, -0.12432630f, 0.10928714f, 
    -0.27708593f, -0.27122134f, -0.04214740f, 0.00057629f, -0.10433293f, 0.19891459f, -0.07521980f, 0.33098313f, 
    0.03961309f, -0.54946560f, -0.55436087f, -0.59718740f, -0.30520096f, -0.97644174f, 0.91302407f, 0.57289940f, 
    -0.15040497f, 0.20011379f, 0.25413901f, -0.04891038f, -0.25016153f, -0.14705239f, -0.15703005f, -0.33374292f, 
    0.05222907f, -0.11935268f, -0.04190531f, 0.14207084f, -0.07992186f, -0.11039711f, -0.18710048f, -0.15077381f, 
    -0.00801698f, -0.04339036f, 0.03748575f, -0.46528479f, 0.24494706f, 0.31669745f, 0.33933657f, -0.04473053f, 
    -0.27634147f, -0.26256594f, 0.01764613f, 0.25006115f, -0.04187771f, -0.06082515f, 0.17646255f, 0.37407219f, 
    -0.26075345f, -0.19106345f, 0.05890840f, -0.02023973f, -0.16636138f, -0.20185779f, -0.36318746f, 0.32723260f, 
    0.25400546f, 0.30866984f, 0.18874656f, -0.57369047f, -0.24284655f, -0.01108208f, -0.07378339f, -0.12775616f, 
    -0.25406423f, 0.04588631f, 0.01640263f, -0.17171627f, -0.08026506f, -0.27032474f, -0.31248674f, 0.09555495f, 
    0.08104631f, 0.39949673f, 0.26133955f, -0.22636804f, -0.01262994f, -0.12203208f, 0.13554147f, 0.17648017f, 
    0.18459713f, 0.31096897f, -0.26775405f, 0.29154614f, -0.44714272f, 0.32659376f, -0.42829323f, -0.41507137f, 
    -0.58601815f, 0.14518148f, 0.16666105f, -0.29467157f, 0.09147969f, 0.37277132f, -0.05211497f, 0.43491018f, 
    0.04826589f, 0.34293497f, 0.04724490f, 0.03702351f, -0.02100825f, -0.22588649f, 0.12724225f, 0.04494626f, 
    0.10638179f, 0.19851573f, -0.13466182f, 0.12144377f, 0.11507214f, -0.59209764f, -0.10951527f, -0.45511118f, 
    0.43943828f, 0.57905030f, 0.01604220f, -0.22562243f, 0.22865225f, 0.43566719f, -0.09810984f, 0.04866264f, 
    -0.23676477f, -0.00663327f, 0.74502403f, -0.39533556f, -0.00827494f, 0.38076866f, -0.26544490f, 0.03594903f, 
    -0.18637799f, 0.10849314f, 0.21364582f, -0.03913553f, -0.11929545f, -0.17823036f, -0.16450801f, -0.02571317f, 
    0.27327880f, 0.26298541f, -0.38098097f, -0.13616630f, 0.28529075f, 0.42343330f, -0.50878960f, 0.04134724f, 
    -0.23290798f, -0.16285695f, -0.10237207f, 0.42048228f, -0.11640372f, 0.00484320f, 0.22330512f, -0.51841396f, 
    -0.06194783f, -0.07282956f, 0.23428689f, 0.07662886f, -0.04437841f, 0.21264386f, -0.03036085f, -0.29125649f, 
    0.67397261f, 0.26866210f, -0.17702429f, -0.46576110f, -0.47256255f, -0.23964074f, 0.07380261f, -0.15594177f, 
    0.64083427f, -0.29757360f, -0.22324109f, 0.35695404f, -0.43333378f, -0.23129825f, 0.30363896f, 0.12853613f, 
    0.06464218f, -0.17619918f, -0.36392969f, -0.13947101f, -0.20233810f, -0.12517606f, 0.27796206f, -0.15272707f, 
    0.12219349f, -0.32884970f, -0.52059370f, -0.50108677f, -0.10427190f, 0.29404980f, 0.43758675f, 0.25286102f, 
    0.14715411f, 0.03071655f, -0.00204200f, 0.37110618f, 0.19230534f, 0.02547533f, 0.10112851f, -0.08872049f, 
    -0.09713536f, -0.00735654f, -0.23629266f, -0.04405287f, 0.07853831f, -0.33991382f, 0.09561406f, 0.30029699f, 
    0.26582637f, 0.77974504f, 0.47102195f, 0.18406422f, -0.43047625f, -0.47315553f, -0.03585394f, 0.12760000f, 
    0.38470200f, -0.11282127f, -0.02582265f, -0.24715717f, 0.17653050f, -0.16748291f, 0.48902872f, -0.24204005f, 
    0.20307446f, 0.03903628f, -0.29743528f, -0.17317981f, -0.04612436f, -0.03706508f, 0.15062298f, -0.09494313f, 
    -0.30179650f, -0.06166757f, -0.24278395f, 0.28971153f, 0.41970164f, 0.41442493f, 0.04898471f, -0.31723994f, 
    -0.22542304f, 0.21822080f, 0.20366684f, 0.15810202f, -0.04570535f, -0.08654330f, 0.10724516f, 0.41757831f, 
    -0.31035367f, -0.18796578f, -0.17464076f, -0.04444602f, 0.05451460f, -0.16387293f, -0.08959116f, -0.07282422f, 
    0.33447820f, -0.08068363f, -0.14140737f, -0.77121800f, -0.59712511f, -0.21177776f, -0.41335779f, -0.18602754f, 
    0.59347969f, -0.06124693f, 0.13420624f, 0.34486941f, 0.44858190f, 0.18731183f, 0.00058508f, -0.02797509f, 
    0.41983724f, -0.11136784f, -0.21442597f, 0.00014740f, -0.24175602f, -0.03063136f, -0.14226340f, -0.16735080f, 
    -0.12020947f, 0.34256232f, 0.11773787f, -0.26078609f, 0.36558640f, 0.63913608f, 0.46042365f, -0.36391121f, 
    -0.43111944f, -0.04785162f, 0.18414642f, -0.17468809f, -0.08914436f, 0.37728325f, -0.04739896f, -0.16329850f, 
    0.47024333f, -0.36088023f, -0.11850593f, 0.28960007f, -0.37399420f, -0.07557465f, 0.23777036f, -0.20111127f, 
    0.03868897f, 0.23843428f, 0.01741779f, -0.26893640f, 0.23746637f, 0.24939291f, 0.64180946f, -0.24012224f, 
    -0.56777382f, 0.15467703f, 0.31606266f, -0.10812880f, 0.07114367f, -0.53700876f, -0.53351015f, -0.26178584f, 
    0.28252017f, 0.34789842f, 0.08527100f, -0.24423395f, -0.03432033f, 0.27730849f, 0.18039435f, 0.10755046f, 
    -0.30759606f, -0.21771976f, -0.12769896f, -0.46174315f, 0.23031566f, 0.31544742f, -0.46651638f, -0.39146644f, 
    -0.33018458f, 0.09183709f, -0.04055750f, -0.00748031f, -0.03533725f, -0.55868638f, -0.59905797f, -0.31879798f, 
    -0.23606271f, -0.21472542f, -0.10574321f, -0.46540564f, -0.29094112f, -0.01560510f, 0.20804366f, -0.18954869f, 
    0.03052299f, 0.18899114f, 0.09549706f, -0.05027476f, 0.02364029f, 0.02386885f, 0.00895820f, -0.46664467f, 
    -0.34807163f, -0.12657446f, -0.50536603f, -0.17071436f, 0.63036168f, -0.00267536f, -0.13219346f, 0.26940244f, 
    -0.33219376f, -0.34461468f, -0.22095601f, 0.00037839f, 0.44937503f, -0.21882543f, -0.19264352f, -0.20224084f, 
    -0.09950105f, -0.03774169f, 0.27142218f, 0.09112113f, 0.17258239f, -0.09501932f, 0.05499743f, 0.17034122f, 
    -0.96702594f, 0.26051667f, -0.17980930f, -0.70325994f, -0.69128001f, 0.12821099f, 0.35328674f, 0.15626217f, 
    0.38971809f, 0.29018107f, -0.13242395f, -0.34322181f, 0.05342513f, -0.23172571f, 0.08606909f, 0.17499286f, 
    -0.03002939f, -0.04431221f, 0.30998817f, 0.24590570f, -0.01546743f, 0.23585682f, 0.33178028f, -0.04847100f, 
    -0.07308293f, -0.87173694f, -0.68027645f, -0.49082360f, 0.35939246f, 0.86212927f, 0.43765587f, 0.11194944f, 
    -0.90563262f, -0.54926586f, -0.14560559f, 0.14806524f, 0.05836035f, -0.00669552f, -0.31975436f, -0.23744266f, 
    -0.00235943f, -0.05464776f, 0.07837728f, 0.58202237f, 0.19044095f, 0.06246959f, -0.28008747f, -0.09993780f, 
    0.10718682f, -0.38587958f, -0.03990365f, 0.73764801f, 0.13038604f, -0.00986411f, -0.38251576f, 0.16321039f, 
    -0.27802753f, 0.16249697f, 0.68717027f, -0.40440643f, -0.30946606f, -0.40696916f, -0.15975301f, 0.02442797f, 
    -0.31749207f, 0.26685104f, 0.13290429f, -0.13096917f, 0.21745116f, -0.07294756f, 0.12417002f, 0.08494610f, 
    -0.00714057f, -0.03042001f, -0.21507074f, 0.61498672f, 0.43905321f, 0.50040996f, -0.52564025f, -0.25711945f, 
    -0.13179576f, 0.12208555f, -0.33829191f, -0.08389557f, -0.04296070f, 0.31436405f, -0.27489617f, 0.19183484f, 
    -0.04768940f, -0.14716542f, 0.21333578f, 0.08611387f, 0.06304099f, -0.18448888f, 0.11915984f, 0.00453933f, 
    0.24461155f, 0.22273657f, -0.11759955f, 0.04833949f, -0.50640887f, -0.15759026f, -0.14677981f, -0.35860994f, 
    -0.09188274f, -0.37535930f, -0.02007171f, -0.00281877f, 0.25183055f, -0.47279721f, -0.12363540f, -0.36240557f, 
    0.15716784f, 0.12167168f, -0.12031124f, 0.19032218f, -0.18487824f, -0.01816319f, -0.13450447f, -0.21881647f, 
    -0.12626649f, -0.02313129f, -0.41467071f, 0.21543828f, 0.39603227f, 0.36611825f, 0.16325462f, -0.06221906f, 
    0.56165498f, -0.44797859f, 0.22677298f, -0.32010299f, -0.51397431f, 0.03372339f, 0.48196796f, 0.26590002f, 
    -0.20979440f, -0.17927615f, 0.08309440f, 0.29420504f, 0.22299246f, 0.07917510f, -0.26780236f, -0.10653032f, 
    -0.10583639f, 0.04513537f, 0.01343094f, 0.19805317f, 0.10795143f, -0.05038592f, -0.72427684f, -0.23706801f, 
    -0.34910795f, 0.49063674f, 0.55647552f, 0.09392226f, -0.24688058f, 0.14422950f, 0.46526879f, 0.30394608f, 
    0.32556435f, -0.09345340f, -0.01951766f, -0.14028186f, 0.00546008f, 0.06221236f, 0.08030318f, 0.28556758f, 
    -0.21885481f, -0.20523979f, -0.29345092f, -0.16644885f, 0.28922907f, 0.33676857f, -0.09143650f, -1.26879311f, 
    0.85993236f, 0.00672346f, -0.57896245f, 0.08726265f, -0.35028756f, 0.33041802f, 0.26775476f, 0.55975324f, 
    -0.14476785f, 0.01943915f, 0.29076830f, -0.25717884f, 0.11348789f, 0.07150663f, 0.06565800f, -0.34643206f, 
    -0.22440311f, -0.15351464f, -0.04760681f, -0.02773431f, 0.05582136f, 0.16534671f, -0.06586456f, -0.31655017f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09032559f, -0.21162337f, 0.08626100f, 0.10383619f, -0.01611401f, 0.13053204f, -0.07304808f, -0.10211315f, 
    -0.05580125f, 0.13283426f, 0.01070880f, -0.01429844f, -0.10199082f, -0.34165534f, -0.17781544f, 0.23354994f, 
    0.05314079f, 0.04288382f, -0.33677068f, 0.05736906f, 0.05373596f, -0.01608855f, 0.11862355f, 0.03385843f, 
    -0.20138527f, 0.00213740f, 0.06784608f, 0.06203999f, -0.11476348f, 0.07065769f, -0.09215918f, 0.12671071f, 
    -0.12577893f, -0.11706118f, -0.06948686f, 0.03812658f, 0.33743939f, -0.09137761f, -0.05841524f, -0.08131678f, 
    0.01340195f, -0.05561095f, -0.24543405f, -0.07218391f, 0.17097405f, 0.08477597f, -0.02203600f, 0.27749389f, 
    -0.18402421f, -0.03467389f, 0.02322775f, -0.04207829f, 0.27723473f, 0.28691906f, -0.18682168f, -0.12706721f, 
    0.04556253f, 0.06512535f, -0.08647593f, 0.08402656f, -0.21573608f, 0.02156270f, 0.40042549f, 0.09017274f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03683906f, 0.01520781f, -0.02114947f, -0.02602064f, 0.00924440f, 0.02041103f, -0.00258460f, -0.01001194f, 
    -0.00115612f, 0.02594867f, 0.02125495f, -0.01699045f, -0.03560118f, -0.01898683f, -0.01500297f, -0.03606268f, 
    -0.03791270f, -0.03294780f, -0.03436023f, -0.04007822f, 0.00868225f, 0.01320466f, -0.01987065f, -0.02562668f, 
    -0.01967098f, -0.00157096f, -0.03812998f, 0.00173775f, -0.03902391f, -0.01398617f, -0.03903357f, 0.01513303f, 
    -0.03262606f, -0.01288789f, -0.00559894f, -0.02024370f, -0.01853098f, 0.00670646f, 0.02883927f, -0.04075387f, 
    0.02771465f, 0.00712665f, 0.01506485f, 0.04004719f, -0.03668419f, 0.01509128f, 0.00926934f, 0.01428952f, 
    -0.03931424f, 0.00421558f, 0.00441938f, -0.00018749f, 0.02840343f, -0.02588064f, -0.03074506f, 0.01903518f, 
    -0.03341400f, 0.02087739f, -0.03687297f, -0.04397153f, 0.02666537f, 0.00326454f, 0.00643797f, -0.02847461f, 
    0.00916335f, 0.02860055f, 0.00280938f, 0.00057994f, 0.02241107f, -0.02508810f, -0.00703998f, 0.02103836f, 
    -0.02257390f, 0.03049831f, -0.00684597f, -0.00187910f, -0.02428933f, -0.00573983f, -0.01353250f, -0.02184184f, 
    -0.02944811f, -0.01287831f, -0.01353608f, 0.02632405f, 0.02219578f, -0.03903281f, 0.01360041f, -0.01954909f, 
    -0.01086848f, -0.02268099f, -0.00067945f, -0.00126141f, -0.03464028f, 0.00911783f, 0.02393009f, 0.01889662f, 
    -0.03156420f, -0.00230279f, 0.02710503f, -0.01366235f, 0.01420501f, 0.02767840f, -0.04220670f, 0.01159799f, 
    0.02203392f, -0.00377513f, -0.00039865f, -0.03183554f, -0.00872833f, 0.01588422f, 0.01218559f, 0.03042302f, 
    0.00959050f, -0.00296775f, 0.00309669f, -0.02756866f, -0.01475691f, -0.00521700f, -0.03115304f, -0.03067802f, 
    -0.00526159f, -0.02207643f, 0.02735469f, -0.02239436f, -0.00192834f, -0.03507982f, -0.03268847f, 0.00139234f, 
    -0.00895315f, -0.04144565f, -0.03673871f, -0.01555661f, -0.02621385f, -0.04080227f, -0.01411507f, 0.01173227f, 
    0.00480259f, 0.00636238f, -0.04358867f, -0.03375352f, -0.00298853f, -0.01394865f, -0.04054260f, 0.01061035f, 
    0.01564643f, -0.01163435f, 0.00804470f, 0.02111801f, -0.03293343f, -0.00646463f, 0.02662851f, -0.01268208f, 
    0.00354156f, -0.03977663f, 0.00923407f, 0.00830278f, 0.01452284f, -0.01536544f, -0.00832508f, 0.01572775f, 
    0.02258667f, 0.00328882f, -0.02329934f, -0.00475124f, 0.02511078f, -0.02440619f, 0.02477113f, 0.02499449f, 
    -0.03552895f, -0.01572373f, -0.00367149f, 0.01025181f, 0.01763432f, -0.00963415f, -0.01854870f, -0.03496802f, 
    0.01043408f, -0.02454801f, -0.00680362f, -0.02844136f, -0.01140512f, -0.03090997f, 0.00302326f, 0.01407073f, 
    -0.01638722f, 0.01296453f, -0.02825649f, -0.00679904f, -0.03749194f, -0.01432145f, -0.00548531f, 0.00615002f, 
    0.03013693f, -0.02785113f, -0.03632820f, -0.01430040f, 0.01054263f, -0.00770151f, -0.01865562f, 0.01545355f, 
    -0.01908466f, -0.02113118f, 0.01293220f, 0.02126842f, -0.01821409f, 0.00412411f, 0.00714757f, -0.03950916f, 
    -0.02492796f, -0.02435464f, -0.01234864f, -0.00957200f, -0.01383958f, 0.00215361f, 0.01409336f, -0.01363859f, 
    0.01025712f, -0.01728779f, -0.01466385f, 0.03093378f, 0.01265633f, -0.00647699f, -0.01697098f, -0.02417385f, 
    -0.03417218f, -0.02705655f, 0.02488204f, -0.03951988f, -0.03486024f, 0.02701070f, -0.00394670f, 0.01413737f, 
    -0.02798137f, 0.00505825f, 0.02017704f, -0.00678660f, -0.01943051f, 0.02518570f, -0.02240496f, 0.02683818f, 
    0.00815414f, -0.01855189f, -0.02223680f, -0.02588533f, 0.01098931f, -0.01823031f, -0.02061014f, -0.00234997f, 
    -0.00205540f, 0.02485435f, -0.00851363f, -0.02630833f, 0.00417136f, 0.02048397f, 0.00663678f, -0.03892217f, 
    0.00145018f, -0.00761122f, 0.02703999f, 0.02069486f, 0.00377405f, 0.00660232f, 0.02640343f, -0.00883781f, 
    -0.03399659f, 0.00400009f, -0.01075759f, -0.03999747f, -0.03204780f, 0.01032611f, -0.01528996f, 0.03395969f, 
    0.01709502f, 0.00439349f, -0.01756614f, 0.00195889f, -0.01158914f, 0.00764495f, 0.01854036f, -0.00679298f, 
    -0.00057806f, 0.02280645f, -0.02690164f, 0.01099954f, -0.01517526f, -0.00609609f, 0.00276849f, -0.02851206f, 
    -0.00114196f, -0.00789681f, -0.00036109f, 0.01748913f, 0.02799327f, 0.00746153f, -0.03484610f, -0.03215317f, 
    -0.04036378f, -0.00016087f, -0.01693694f, -0.03362316f, -0.02662274f, -0.01107133f, -0.00403894f, -0.02648344f, 
    -0.03035005f, 0.02287087f, -0.01454816f, -0.01002427f, 0.00580180f, 0.02845711f, -0.01725235f, -0.00741453f, 
    -0.00201817f, 0.02757533f, 0.00329222f, 0.00416822f, 0.02294623f, -0.02635421f, 0.00429102f, -0.03140276f, 
    -0.03158760f, 0.00643819f, 0.00715074f, -0.02987628f, -0.01320724f, -0.01580868f, -0.04266763f, 0.01582631f, 
    -0.03263129f, -0.00090638f, -0.04260316f, 0.02202889f, 0.00739187f, 0.02339578f, -0.01672415f, -0.01856094f, 
    -0.04048987f, -0.01581508f, -0.00605943f, 0.00609022f, 0.01068297f, 0.04093386f, 0.01043562f, -0.02388504f, 
    -0.00686137f, 0.02976304f, -0.00755832f, 0.03126945f, 0.02640310f, 0.00744487f, -0.02857459f, 0.00904559f, 
    -0.00239665f, -0.00901897f, 0.02606485f, 0.00970133f, 0.00842375f, 0.00089153f, -0.02917173f, 0.02213937f, 
    0.00295068f, 0.02211003f, -0.03944556f, -0.02356035f, 0.01913165f, 0.00733892f, -0.01358459f, 0.00650933f, 
    0.02505013f, -0.02185405f, -0.03033598f, -0.01316886f, -0.00831936f, -0.02199066f, 0.00114421f, -0.02578530f, 
    -0.02374269f, -0.00247632f, 0.02284139f, -0.02244249f, -0.01043680f, -0.02841760f, 0.00207836f, 0.00272666f, 
    -0.01476083f, -0.02910292f, 0.01835678f, 0.02782770f, -0.03774809f, 0.03991764f, 0.01517683f, 0.01453196f, 
    0.00497006f, -0.02697410f, 0.00672453f, 0.02811953f, -0.03852524f, 0.02926388f, -0.01639413f, -0.00743538f, 
    -0.03300451f, 0.00777948f, 0.01168102f, -0.00580933f, 0.00068382f, 0.00312790f, 0.02112417f, -0.02535409f, 
    -0.00955486f, -0.01358666f, -0.02621221f, -0.00206026f, -0.00748037f, -0.01251873f, -0.04095742f, -0.04098267f, 
    -0.00453048f, -0.01582294f, 0.00294022f, -0.02606133f, -0.00300418f, 0.00338994f, 0.00639626f, 0.00907678f, 
    -0.01439097f, -0.02258827f, -0.02002321f, 0.00750833f, -0.01193578f, -0.00586547f, -0.02088998f, 0.02871931f, 
    -0.00546108f, -0.01031663f, -0.03717683f, -0.01130746f, -0.03262838f, -0.02587875f, -0.03814638f, -0.00915737f, 
    -0.02556740f, -0.02459895f, 0.01596852f, -0.02130875f, 0.01649711f, 0.02969733f, 0.00287472f, -0.03573709f, 
    -0.00367698f, 0.01326178f, 0.02610764f, -0.02142193f, -0.00812818f, -0.03781944f, -0.01665772f, 0.02186274f, 
    0.02026528f, 0.02835084f, 0.02775115f, 0.00421263f, 0.00932212f, 0.00897433f, -0.01240124f, -0.00292868f, 
    -0.02115353f, 0.00032264f, 0.01874808f, 0.02608092f, 0.03145714f, 0.00372557f, -0.00671307f, -0.03109442f, 
    -0.01686928f, -0.02370573f, 0.00959675f, -0.01385700f, -0.01451893f, -0.01230450f, 0.00723265f, -0.00179258f, 
    0.01227833f, -0.00878779f, -0.00280133f, -0.01933986f, -0.02755612f, 0.01105228f, -0.01909160f, 0.01820025f, 
    -0.00896875f, -0.01800398f, 0.01328448f, 0.01267153f, 0.01359775f, -0.01703781f, 0.00041305f, -0.01691214f, 
    -0.01853762f, -0.02727334f, -0.01651412f, 0.01121817f, -0.02797320f, 0.01504759f, 0.01244476f, -0.01277462f, 
    0.02184706f, -0.03501227f, -0.02923609f, 0.01814647f, -0.02028722f, -0.00582975f, -0.03218953f, 0.03507626f, 
    0.03879173f, -0.02340273f, 0.00742323f, 0.00608784f, -0.02682755f, -0.03778704f, 0.03022431f, -0.00719376f, 
    -0.02539423f, -0.03708823f, -0.00634647f, -0.00372410f, 0.02615212f, 0.01827572f, 0.01088379f, -0.00430594f, 
    -0.01657134f, 0.00332805f, -0.02513935f, 0.02096189f, 0.02259631f, -0.01702123f, -0.02937895f, -0.00717972f, 
    -0.04030695f, 0.00882007f, -0.02987321f, -0.03653264f, 0.02146399f, -0.01223573f, 0.01712694f, -0.00934066f, 
    -0.01267053f, 0.02392563f, 0.02684361f, -0.01969947f, -0.03319988f, 0.02066804f, -0.02739991f, 0.00997433f, 
    0.02219522f, -0.02970400f, 0.04099092f, 0.02029926f, -0.02285586f, -0.00926794f, -0.03223638f, -0.01246405f, 
    -0.00842088f, -0.03953582f, -0.03317628f, -0.00593433f, 0.00209463f, -0.00717252f, -0.00282092f, -0.01683693f, 
    0.02740820f, -0.02253548f, 0.01640607f, 0.02361615f, -0.03808551f, -0.03256043f, -0.01042156f, 0.00338920f, 
    -0.01457494f, -0.03274333f, 0.00857628f, -0.02446762f, -0.03615988f, -0.00556512f, -0.01922107f, 0.03166197f, 
    0.02827307f, 0.01903308f, -0.02852396f, 0.00770608f, -0.01279415f, 0.01302493f, 0.01401581f, -0.02635324f, 
    -0.02793780f, -0.03254493f, -0.01012651f, -0.02742895f, 0.00777496f, 0.00003753f, -0.03678874f, -0.02780435f, 
    -0.01893980f, 0.02381711f, -0.03992216f, -0.01790163f, -0.00552002f, 0.00741585f, -0.03237214f, -0.02954282f, 
    0.00165454f, 0.02860505f, -0.03986445f, -0.02320767f, 0.02006997f, -0.03512498f, -0.02853366f, -0.02619039f, 
    0.00307051f, -0.02808974f, -0.02229160f, 0.01893018f, 0.01600513f, 0.01754793f, -0.04265410f, -0.02051216f, 
    -0.02932562f, 0.01490343f, 0.00900758f, -0.01627350f, 0.01648061f, -0.00317014f, -0.00856507f, 0.00669166f, 
    -0.01722226f, -0.02242482f, -0.02070911f, -0.03551495f, -0.03823517f, -0.02440508f, 0.01144679f, 0.02808382f, 
    0.01282550f, -0.01321051f, 0.00931542f, -0.00558929f, -0.01612483f, 0.01482141f, -0.03972546f, 0.00731302f, 
    -0.03274523f, -0.04046259f, 0.00593054f, -0.00310522f, -0.01154331f, 0.02033787f, 0.02291581f, -0.01387738f, 
    -0.00737103f, 0.01248246f, -0.03858082f, 0.01783694f, 0.02913074f, -0.02447286f, -0.00410384f, -0.00418873f, 
    -0.01415169f, 0.01773171f, -0.01547682f, 0.02793630f, -0.01228188f, 0.02632776f, -0.01990484f, -0.03585060f, 
    -0.03045172f, -0.00556446f, -0.02042364f, -0.02830437f, 0.02315589f, -0.02326942f, -0.02280061f, -0.04250481f, 
    -0.00546724f, -0.02945120f, -0.04322088f, 0.00225145f, -0.03825177f, 0.01401799f, -0.01262914f, 0.01217705f, 
    -0.04118950f, -0.01290928f, 0.00746901f, -0.02381231f, 0.00767959f, -0.03700124f, -0.02439582f, -0.03457482f, 
    -0.01604878f, 0.02887613f, -0.02132337f, -0.01370261f, -0.02166219f, -0.00425575f, -0.01769369f, -0.02754408f, 
    -0.03385485f, -0.02342495f, -0.00859171f, -0.03917743f, -0.01830602f, -0.00633891f, -0.02123748f, 0.01049175f, 
    -0.03676840f, -0.03255909f, -0.01178163f, -0.00612693f, -0.01025329f, 0.00778421f, -0.01917123f, -0.00426783f, 
    0.00108241f, 0.02018126f, -0.01936898f, -0.00649607f, 0.02056811f, -0.01529374f, -0.01951058f, -0.00115468f, 
    -0.03847992f, 0.00791549f, -0.02083106f, 0.02802719f, 0.01601747f, -0.02982178f, -0.03114882f, 0.03495571f, 
    0.02327945f, -0.03268354f, 0.00766132f, 0.02434685f, -0.03985173f, -0.03725145f, -0.02320868f, -0.01212119f, 
    0.02868661f, -0.03699826f, -0.03670498f, -0.00951373f, -0.02567764f, 0.04086215f, 0.00442584f, -0.00305085f, 
    0.01880107f, 0.01069528f, -0.02317504f, 0.00798442f, -0.03027119f, -0.01777742f, -0.00422935f, 0.02762718f, 
    0.01312289f, 0.00710022f, -0.00376592f, -0.03045779f, -0.03254498f, -0.00706989f, -0.03285686f, 0.02322914f, 
    -0.01755263f, -0.01914066f, 0.01388541f, 0.02298708f, -0.01060092f, 0.03006922f, -0.00722695f, 0.01280713f, 
    0.02583139f, -0.02021003f, 0.00972533f, 0.03319959f, 0.03507436f, -0.00607525f, 0.00264214f, -0.01353892f, 
    0.03416163f, 0.03395310f, -0.00982908f, -0.00820210f, -0.00723157f, 0.02100007f, -0.03254067f, -0.01508773f, 
    -0.00790375f, -0.03302745f, -0.00653635f, 0.03369977f, 0.00476396f, -0.01180839f, -0.00232093f, -0.00939574f, 
    0.01271180f, -0.01374644f, -0.01933042f, 0.02496207f, -0.03530258f, -0.01368839f, -0.05319431f, 0.01151034f, 
    -0.01622594f, -0.00514682f, 0.00132315f, -0.00768348f, 0.00725061f, -0.04487373f, -0.03640710f, -0.03138120f, 
    0.02291384f, 0.02740896f, -0.03279244f, 0.01906357f, -0.01583989f, 0.02247064f, -0.00881846f, -0.00986377f, 
    0.03305816f, -0.03451851f, -0.02964957f, 0.01811049f, 0.01139171f, -0.00438202f, -0.02930578f, -0.01038551f, 
    0.00681666f, 0.01091135f, -0.01832122f, 0.00335378f, 0.00502045f, -0.04347403f, -0.03829106f, 0.00612889f, 
    0.01521978f, -0.01553952f, -0.04129066f, 0.00924498f, -0.05015117f, -0.02909212f, -0.05044506f, 0.00352527f, 
    -0.03346964f, -0.04949149f, -0.01880084f, -0.00874001f, -0.02085507f, -0.00304282f, 0.00944943f, -0.02421801f, 
    -0.01807078f, -0.01032749f, -0.02230210f, -0.00842714f, 0.00798661f, -0.00102536f, -0.00132450f, -0.01480746f, 
    -0.02352516f, 0.01754201f, -0.00054332f, -0.00221696f, 0.00160041f, -0.02478969f, -0.04791531f, -0.02341017f, 
    -0.05171104f, -0.04757079f, 0.00773973f, -0.01174920f, 0.00932951f, -0.00595601f, -0.02063411f, -0.01923039f, 
    0.00656363f, -0.04147883f, -0.04533484f, -0.02042813f, -0.00356026f, 0.01235490f, -0.01525096f, -0.01571281f, 
    -0.02637515f, 0.01854194f, 0.02359284f, -0.00440560f, -0.02860575f, -0.00529062f, -0.02188459f, -0.03512898f, 
    0.00305870f, -0.01704799f, -0.03442014f, -0.01680339f, 0.02933479f, 0.02084464f, -0.02262024f, 0.02202719f, 
    -0.00460439f, -0.02172288f, 0.02407267f, 0.02324489f, -0.03167902f, 0.01138035f, -0.00098020f, 0.02101295f, 
    -0.01610796f, 0.01422245f, -0.03727795f, -0.02624983f, -0.00275490f, -0.03109803f, -0.05417603f, -0.01725973f, 
    -0.02784457f, -0.00816107f, -0.00219426f, -0.00833232f, -0.04384321f, 0.00792912f, -0.01594545f, 0.00467686f, 
    -0.02023085f, 0.01092362f, -0.01772235f, 0.00416098f, -0.01858248f, 0.00339528f, -0.02551508f, -0.03410657f, 
    -0.01271833f, -0.00494449f, -0.03143471f, -0.00827008f, -0.02892327f, -0.05028020f, -0.04740487f, -0.00885895f, 
    -0.01113968f, -0.04935921f, -0.01480709f, -0.01332475f, 0.00195553f, -0.02992089f, 0.00552645f, 0.00162231f, 
    -0.03417021f, -0.01089695f, -0.00476123f, 0.00557407f, -0.00426420f, -0.02934686f, 0.03270498f, -0.02548664f, 
    -0.03869454f, -0.04769266f, -0.04468898f, -0.03792950f, -0.01665618f, 0.01476902f, 0.01519367f, -0.04144015f, 
    -0.03032526f, -0.02305523f, -0.02718306f, -0.01604102f, -0.01681420f, -0.04429815f, -0.00089602f, -0.01949385f, 
    -0.00596044f, -0.01300829f, -0.01878348f, -0.05058384f, 0.00784214f, -0.00424236f, 0.01349500f, -0.02510852f, 
    -0.05082151f, -0.04348892f, 0.01681290f, -0.00557677f, 0.01327955f, -0.02063396f, -0.02172522f, 0.00485226f, 
    -0.01922710f, -0.01229891f, 0.00877014f, -0.03299986f, 0.01257615f, -0.04566252f, -0.03219969f, -0.01652739f, 
    0.01102275f, -0.03955345f, -0.00345093f, -0.00923737f, -0.05186053f, -0.02596246f, -0.01232268f, -0.01614220f, 
    0.00258186f, -0.03350015f, -0.00444424f, -0.04804974f, -0.04534636f, -0.02706986f, 0.01213452f, 0.00769380f, 
    -0.04910750f, -0.02997429f, 0.02001228f, -0.01867325f, 0.01664189f, 0.01382754f, -0.00900506f, -0.02175915f, 
    0.00993542f, -0.00027716f, 0.01849769f, -0.02535941f, -0.02036241f, -0.01683977f, 0.02679922f, 0.01854817f, 
    -0.03685873f, -0.03257111f, -0.05194343f, 0.00254498f, -0.04367303f, -0.01707497f, 0.00003852f, -0.03864103f, 
    -0.00741676f, -0.03971295f, -0.04756879f, -0.01345566f, 0.01339160f, -0.01835613f, 0.00986627f, -0.05336573f, 
    0.01370102f, 0.00100422f, -0.02583042f, -0.01033836f, -0.04213999f, -0.02649609f, -0.03578514f, -0.00343188f, 
    -0.02607144f, -0.03044298f, -0.00031555f, -0.01313924f, -0.00594221f, 0.00280594f, -0.01380184f, -0.00071251f, 
    -0.01229765f, -0.02176822f, -0.02632311f, -0.02749786f, -0.02931336f, -0.04210521f, -0.04366817f, -0.04976420f, 
    -0.01592193f, -0.02558111f, -0.02300699f, -0.01413386f, -0.00012988f, -0.05241771f, -0.04018006f, -0.04424009f, 
    0.02051582f, 0.00130075f, 0.00019115f, -0.00766080f, -0.01295282f, 0.00790776f, -0.01700187f, 0.02508530f, 
    0.00401912f, 0.00003488f, -0.02358589f, -0.02547104f, 0.00437207f, -0.03332420f, 0.00929884f, -0.00960741f, 
    -0.03579699f, -0.01101240f, -0.02347655f, -0.02867470f, 0.01170641f, 0.00905804f, 0.01205047f, -0.02387564f, 
    -0.05269677f, 0.01768203f, -0.04831208f, -0.02875433f, -0.05128276f, -0.00508981f, -0.00208523f, 0.00334953f, 
    -0.01717041f, 0.00687086f, -0.03236059f, -0.03898748f, -0.03203120f, -0.02204517f, 0.01365806f, -0.02815770f, 
    -0.04212591f, -0.04337542f, -0.03529728f, -0.00428706f, -0.01755164f, -0.00680273f, -0.00082400f, 0.00151634f, 
    -0.01739302f, 0.02284050f, -0.00934872f, -0.01527516f, -0.01493758f, -0.02124291f, 0.02708717f, 0.02247081f, 
    -0.00659878f, -0.01940189f, 0.00438061f, -0.02048837f, -0.00523373f, -0.04643959f, -0.01104703f, -0.01787333f, 
    -0.04075899f, -0.02640015f, -0.00559106f, 0.01493850f, 0.00234381f, 0.01917459f, 0.01825826f, -0.02521376f, 
    -0.02625267f, -0.04828295f, -0.04365166f, -0.00821223f, -0.02817471f, -0.01304092f, -0.02014653f, -0.03471537f, 
    0.01258342f, -0.01799379f, -0.03369063f, 0.01540917f, 0.01278973f, -0.04953855f, -0.02834549f, -0.02731293f, 
    -0.00942193f, -0.03125428f, -0.05048857f, -0.02806585f, -0.00052637f, -0.02075249f, 0.01391195f, 0.01134194f, 
    -0.01478659f, -0.01469301f, 0.00837802f, -0.04020227f, 0.00525983f, -0.04160429f, -0.00639779f, -0.00825100f, 
    -0.00418084f, -0.03591192f, -0.04026524f, 0.00638619f, -0.00698705f, -0.03222884f, 0.00811577f, -0.00256366f, 
    -0.03161847f, -0.03695374f, 0.01502155f, 0.00314323f, 0.00260583f, 0.01216710f, -0.02304123f, -0.03894428f, 
    -0.00788944f, 0.00799344f, 0.02331312f, -0.00804906f, -0.04774843f, -0.02424615f, -0.00922658f, -0.00647581f, 
    -0.01685329f, 0.01654475f, -0.05225185f, -0.04123156f, -0.03192209f, -0.03121883f, 0.02895692f, -0.01392337f, 
    0.00224076f, 0.01742587f, -0.03564592f, -0.02417627f, 0.03082927f, 0.00085046f, -0.00456271f, -0.00693292f, 
    -0.01989506f, -0.00256540f, 0.01320435f, 0.00912634f, -0.02747685f, -0.01144168f, -0.01467552f, 0.01470288f, 
    0.01716957f, -0.03392686f, -0.00417350f, -0.02587806f, 0.01218092f, -0.03701017f, -0.01526350f, 0.00789167f, 
    0.01175623f, 0.00514314f, -0.03354411f, -0.01977801f, -0.02897269f, -0.01677823f, -0.00180296f, -0.03063528f, 
    -0.00868075f, -0.00782805f, -0.02492934f, 0.01781152f, -0.01365823f, -0.04094805f, -0.03408445f, -0.00539973f, 
    -0.01000460f, 0.00059190f, -0.02903470f, -0.02839539f, 0.02569402f, -0.00437637f, -0.01841024f, 0.03504337f, 
    -0.02150053f, 0.02229636f, 0.03310484f, 0.03123923f, 0.02585145f, -0.00975217f, -0.02379440f, 0.03041544f, 
    -0.00713217f, -0.01213171f, -0.02228414f, -0.01430541f, -0.04068685f, -0.00284392f, -0.05021080f, -0.01973341f, 
    0.00229941f, -0.00668112f, -0.04758520f, -0.02397213f, -0.02662299f, -0.03209996f, -0.02237777f, -0.02702807f, 
    -0.03068171f, 0.02475952f, 0.01783917f, 0.00987498f, 0.01561596f, 0.00339811f, -0.04719418f, -0.03288462f, 
    -0.04869943f, -0.00970235f, -0.05233924f, -0.04653942f, -0.04862255f, -0.04632178f, -0.03366702f, -0.04889097f, 
    -0.05241434f, -0.01564663f, 0.01365953f, -0.01325622f, -0.02181586f, 0.00361899f, 0.00451073f, -0.02631587f, 
    -0.00456959f, -0.04915157f, -0.02028014f, -0.02128465f, -0.05056249f, -0.04203196f, -0.02351773f, -0.00115339f, 
    -0.05423310f, -0.04772250f, -0.02614545f, -0.05407414f, -0.05152264f, -0.05129875f, -0.04605152f, 0.01117183f, 
    -0.04753846f, -0.00877404f, -0.05156267f, 0.01770695f, -0.00646739f, -0.03345287f, -0.01361014f, -0.03381381f, 
    0.01253207f, -0.00870334f, -0.00442289f, -0.00513353f, 0.02700694f, 0.00531797f, -0.00538720f, 0.03349917f, 
    -0.01361848f, 0.01578201f, -0.05138294f, 0.00438335f, -0.03983670f, 0.00608460f, -0.01878413f, 0.01414612f, 
    -0.02747328f, -0.02356890f, -0.01513504f, -0.01400888f, -0.04069948f, 0.00742496f, 0.01625071f, 0.00061310f, 
    -0.03111736f, -0.04259571f, -0.01494713f, -0.04063737f, 0.01192550f, -0.04470037f, 0.01821654f, 0.02845724f, 
    -0.02790748f, -0.05022752f, -0.02736329f, 0.00362767f, 0.00807240f, -0.03536891f, -0.02955265f, -0.04201152f, 
    -0.03056060f, 0.01510176f, -0.00514710f, -0.00331341f, -0.02070810f, -0.02763054f, -0.00576304f, -0.03065582f, 
    -0.00874728f, -0.01855633f, -0.00379629f, 0.00861991f, -0.03168477f, 0.00074538f, -0.05201769f, -0.01593387f, 
    -0.05348852f, 0.00357804f, 0.01353176f, -0.01808235f, -0.02930201f, -0.03617313f, -0.04194806f, -0.02729098f, 
    -0.04629067f, -0.01833057f, -0.01806941f, -0.04179013f, 0.01968389f, 0.02224445f, -0.03017911f, 0.00365442f, 
    -0.01427950f, -0.02511349f, 0.03448129f, 0.01814282f, 0.00040551f, 0.03599507f, 0.03405526f, -0.00134692f, 
    -0.02365772f, -0.00432395f, 0.01401909f, 0.01171485f, 0.00134723f, -0.01092830f, 0.02831435f, -0.00920883f, 
    -0.01233159f, -0.02964087f, -0.01918112f, -0.00002202f, 0.02349928f, 0.00384758f, -0.01128183f, 0.00534404f, 
    -0.00334955f, -0.00007742f, 0.00427588f, 0.00193300f, -0.03331814f, -0.02648251f, 0.01660352f, 0.01901401f, 
    -0.01939428f, 0.00564801f, 0.01156450f, 0.03289364f, 0.01588252f, 0.01616162f, -0.02047123f, -0.03328300f, 
    -0.00248991f, -0.01201439f, -0.03903736f, 0.01755359f, -0.02133457f, -0.01324207f, 0.02014403f, -0.00593098f, 
    0.03580355f, 0.02023787f, -0.01258904f, 0.01047559f, -0.03297751f, -0.00994408f, 0.01719340f, 0.02848059f, 
    0.00402133f, -0.00774992f, -0.04439083f, 0.00540500f, -0.03585575f, -0.03300781f, -0.02705299f, 0.01557178f, 
    -0.05083592f, -0.01016558f, 0.02549208f, -0.02865379f, -0.00858395f, -0.05212126f, -0.03238379f, -0.01614942f, 
    -0.02177040f, 0.00707992f, -0.02418622f, -0.01230246f, -0.04033852f, 0.00877070f, -0.04193430f, 0.00961401f, 
    -0.00318347f, -0.03118965f, -0.01692203f, -0.01278939f, 0.01933992f, 0.01817329f, 0.03136611f, 0.02219805f, 
    -0.03138125f, -0.02324297f, 0.01087275f, -0.03135695f, -0.01467146f, -0.02878184f, -0.02521768f, 0.00536664f, 
    -0.00405513f, -0.00138600f, -0.03725611f, 0.01004499f, 0.00849743f, -0.00984360f, -0.02931020f, 0.00041062f, 
    0.00178879f, -0.03499712f, -0.00736958f, -0.04986768f, -0.04264955f, -0.03644653f, -0.03137744f, 0.01419911f, 
    -0.02153193f, -0.04385088f, -0.00689296f, -0.02651477f, -0.01997342f, -0.02378841f, 0.00514260f, -0.01509550f, 
    -0.02935448f, 0.02851448f, -0.01502495f, -0.02601759f, -0.03545237f, -0.01247944f, 0.01627851f, -0.02420330f, 
    -0.03756499f, 0.03366729f, 0.03788070f, 0.04793325f, 0.08896939f, 0.06960937f, -0.01063819f, -0.09118202f, 
    0.17869693f, -0.00408401f, -0.04443016f, -0.02478797f, -0.03333106f, -0.09808113f, -0.10056208f, 0.07353616f, 
    0.06881036f, 0.00695219f, -0.06084254f, -0.01526596f, -0.06021513f, 0.02436887f, -0.00807997f, 0.19286288f, 
    0.08189358f, 0.09502123f, 0.12424053f, 0.03243288f, 0.11418042f, 0.01134879f, 0.02454115f, -0.01434805f, 
    0.07886700f, 0.02642962f, -0.03470679f, 0.17257623f, 0.25710005f, 0.13097227f, 0.00377832f, -0.01733647f, 
    -0.13197459f, -0.13151959f, -0.02251493f, -0.07090212f, -0.01650493f, 0.14318989f, 0.11319590f, -0.00698459f, 
    -0.17350395f, -0.09271502f, -0.11016906f, 0.23195244f, -0.00684358f, 0.11422871f, -0.04689365f, -0.00139874f, 
    -0.01112112f, -0.05702478f, -0.00927875f, 0.16855974f, 0.03824929f, 0.10182273f, 0.02243027f, -0.00838195f, 
    -0.10243504f, -0.13965008f, 0.09757014f, -0.10562208f, 0.06132125f, -0.01007349f, 0.05398734f, 0.21246280f, 
    -0.01485275f, 0.21735515f, 0.12382832f, 0.01854857f, -0.06965019f, -0.00425958f, -0.10221664f, -0.04721802f, 
    -0.13892682f, 0.05170037f, 0.23109658f, 0.03228366f, -0.02953917f, 0.11387227f, 0.09489261f, 0.14069417f, 
    0.03114079f, -0.16019055f, -0.13163354f, 0.03238631f, 0.10357405f, 0.00379952f, 0.03526028f, 0.13749219f, 
    0.31209138f, 0.26608229f, 0.11591174f, 0.07036800f, -0.14465190f, -0.00108789f, -0.02739748f, -0.07953589f, 
    0.03189551f, -0.08961979f, -0.05949725f, -0.02382450f, 0.16808416f, 0.25982675f, 0.07339768f, 0.13347247f, 
    -0.03845463f, -0.07480137f, -0.15904132f, -0.08233614f, 0.17484245f, -0.00480609f, 0.11039075f, 0.04916919f, 
    0.09414450f, 0.10817804f, 0.11651842f, -0.05841700f, -0.04019634f, 0.01942316f, -0.11375016f, 0.00579549f, 
    -0.11048142f, -0.07325786f, -0.14455605f, -0.09626334f, -0.12304911f, -0.05920222f, 0.19622515f, 0.01790920f, 
    0.01310787f, -0.03504197f, -0.11998208f, -0.04874635f, -0.01963906f, 0.01679262f, -0.14789642f, 0.09751532f, 
    -0.15249474f, 0.10442618f, 0.15796214f, -0.18527490f, -0.18291318f, -0.16572398f, -0.21236782f, -0.13015175f, 
    0.01921824f, -0.07081261f, -0.00271769f, 0.07607913f, 0.05881800f, 0.00121410f, 0.01895542f, -0.00563762f, 
    -0.13607453f, -0.19014113f, -0.09683302f, -0.11885919f, 0.08536480f, 0.00207983f, 0.03617701f, 0.01598440f, 
    0.03794641f, -0.00254805f, 0.21409050f, 0.00227649f, 0.00533975f, -0.07545828f, -0.09613542f, -0.06835441f, 
    0.02113873f, 0.16504471f, -0.08047228f, 0.15284182f, 0.07566994f, 0.34102282f, -0.14340086f, 0.16423978f, 
    0.01449087f, -0.02929933f, 0.07991423f, -0.07905153f, -0.05306470f, 0.11466978f, 0.16898815f, -0.25384617f, 
    0.12493483f, 0.39892742f, 0.10672630f, 0.10737998f, 0.11532111f, -0.01546307f, -0.01257261f, -0.22257887f, 
    0.18780881f, 0.16308656f, 0.07537442f, -0.10144462f, 0.20407870f, 0.49185193f, -0.21197209f, -0.03800391f, 
    0.06951362f, -0.04384719f, 0.00469009f, 0.18538149f, -0.01669148f, 0.08939983f, 0.00694305f, 0.04164687f, 
    -0.13124560f, -0.23555210f, -0.16455369f, -0.03219521f, -0.09169605f, -0.01181785f, -0.02267913f, 0.05799861f, 
    0.01470713f, 0.10223666f, -0.15791725f, -0.04260004f, 0.05111077f, 0.10472783f, 0.18466377f, -0.13093430f, 
    -0.06599659f, -0.12466805f, -0.03512415f, -0.03202905f, -0.03243132f, 0.04356458f, 0.29715246f, 0.17314434f, 
    -0.13159870f, 0.02489901f, -0.15537748f, 0.01654508f, 0.04440173f, 0.12882110f, -0.09720977f, 0.00772282f, 
    0.00456719f, -0.07541463f, 0.01665957f, 0.08606352f, 0.27632746f, 0.07873579f, -0.11796820f, -0.05088164f, 
    -0.03447603f, -0.02006871f, -0.00008247f, -0.13770519f, -0.08940614f, -0.06502508f, -0.21441980f, -0.14855500f, 
    0.18737462f, -0.09195654f, -0.08830134f, -0.19858855f, 0.00044417f, -0.09382773f, -0.00924129f, 0.01509664f, 
    0.13093339f, 0.07949150f, -0.01189990f, 0.09066407f, -0.03868980f, -0.17529473f, 0.06141625f, 0.12541015f, 
    -0.11834382f, 0.11178242f, -0.12265679f, -0.02737234f, 0.10735482f, -0.00258242f, 0.09269980f, 0.00841964f, 
    -0.05113562f, -0.02951514f, 0.00852933f, 0.10886656f, 0.03686802f, 0.05126992f, 0.06169672f, 0.06762456f, 
    -0.03378695f, -0.02316443f, 0.10941583f, -0.05011654f, 0.09466846f, -0.10250979f, -0.26290584f, -0.18357253f, 
    0.09842459f, 0.13661784f, -0.13092639f, 0.05506373f, -0.04361503f, -0.15855800f, -0.08785128f, 0.14355575f, 
    -0.00647110f, -0.04892400f, 0.13978206f, 0.10692790f, 0.12483934f, 0.18175340f, 0.07171431f, 0.13352168f, 
    0.06398453f, -0.00897864f, -0.01010287f, 0.00238902f, -0.04712306f, -0.14273037f, -0.05767745f, 0.09485506f, 
    0.13722485f, 0.28853297f, -0.02137630f, 0.01601104f, -0.02191239f, -0.03479622f, -0.02840572f, 0.01425658f, 
    -0.06806623f, -0.00389534f, 0.07087167f, 0.05839364f, -0.09836455f, 0.06642255f, -0.10361708f, -0.10550460f, 
    0.16306327f, 0.04561526f, -0.12266021f, 0.09718948f, -0.11314012f, 0.19348332f, 0.04338085f, 0.15044346f, 
    -0.03555565f, -0.09051487f, -0.12350501f, 0.07498240f, -0.09988401f, -0.06335612f, 0.18455915f, 0.10336679f, 
    -0.17983727f, -0.02516604f, 0.03028397f, 0.09357288f, 0.05567916f, 0.11568347f, -0.10021789f, -0.02828762f, 
    -0.13416755f, 0.06080521f, 0.19788523f, -0.13275200f, -0.05059590f, 0.40403348f, -0.31262770f, -0.14679213f, 
    -0.06389096f, 0.03243294f, 0.14095762f, 0.04062452f, 0.13369934f, 0.03116543f, -0.04930367f, 0.17252506f, 
    0.20958301f, 0.07065734f, -0.11997121f, 0.11184245f, 0.06309897f, -0.20625567f, -0.10564829f, 0.04485867f, 
    -0.08188580f, -0.04202809f, -0.12633911f, 0.06982253f, 0.15240677f, 0.15657236f, -0.01403768f, 0.05053059f, 
    -0.03427780f, -0.09639697f, -0.32743680f, 0.02996388f, -0.06156618f, 0.08799084f, -0.01713864f, -0.00197657f, 
    0.20647912f, 0.31030115f, -0.01574248f, 0.26327422f, -0.00097115f, -0.14357355f, -0.22599381f, -0.06901731f, 
    -0.05869498f, 0.05936494f, -0.06091715f, -0.06778291f, 0.02112453f, -0.10419524f, -0.08479937f, 0.08960776f, 
    -0.05828153f, -0.09417526f, -0.05309285f, 0.15970603f, -0.02998835f, -0.01686434f, -0.01991187f, -0.07770137f, 
    -0.01537047f, 0.38122967f, 0.26423046f, 0.08467228f, 0.03786578f, -0.09734122f, -0.13550395f, -0.06478632f, 
    0.01834696f, -0.12598562f, -0.02644306f, 0.00788948f, -0.02344882f, -0.05048068f, -0.08992850f, 0.09811810f, 
    0.10352491f, -0.08083965f, -0.12518051f, 0.06483958f, -0.02947694f, 0.05719908f, -0.19246545f, 0.02181558f, 
    -0.11623718f, -0.08162992f, -0.09380599f, 0.08486643f, 0.05887817f, 0.04155247f, 0.11801749f, 0.13172078f, 
    0.08840860f, 0.08202442f, 0.06215232f, 0.00958167f, 0.06601162f, 0.04344335f, 0.05913019f, -0.01383280f, 
    -0.01171069f, -0.11060826f, -0.08218694f, -0.05800677f, -0.10859978f, 0.06350403f, 0.00404156f, 0.02698453f, 
    -0.14062315f, -0.28715795f, -0.31852478f, -0.05660013f, 0.13542353f, 0.05715657f, 0.22356850f, 0.06643066f, 
    0.15625378f, 0.10071295f, -0.03697567f, -0.08146898f, -0.12293842f, -0.11867004f, 0.18268184f, 0.14784290f, 
    0.00863180f, 0.04843840f, 0.03287802f, -0.00384559f, -0.06958552f, -0.04468431f, 0.08532479f, 0.03356596f, 
    0.10749709f, -0.06931003f, -0.02247859f, -0.05127463f, -0.12286320f, -0.24954902f, -0.09320342f, 0.00571534f, 
    -0.04806295f, -0.04820950f, 0.02572177f, 0.04695656f, -0.02851014f, -0.12431261f, -0.08539605f, 0.06635219f, 
    0.12677798f, 0.08362232f, -0.03292637f, 0.08966351f, 0.01650008f, 0.10861741f, -0.04996167f, 0.00271076f, 
    0.03808500f, -0.23799072f, -0.22622196f, 0.07147596f, 0.09890749f, 0.04690285f, -0.01025845f, 0.06901791f, 
    -0.06544390f, -0.05313029f, -0.00863908f, 0.01269670f, 0.05128967f, -0.15527171f, -0.05931858f, -0.16402513f, 
    -0.05557480f, -0.13175817f, 0.03652869f, -0.01254856f, -0.10438155f, -0.06566180f, 0.12135690f, 0.06263402f, 
    0.18920696f, 0.02140415f, -0.13924599f, 0.29250228f, -0.00777035f, -0.20192212f, -0.03831920f, -0.02770182f, 
    0.01013097f, -0.08302643f, 0.02357702f, 0.09148487f, 0.25143191f, 0.06189031f, 0.01991410f, 0.03476838f, 
    0.08657959f, -0.02407025f, -0.05405457f, 0.10158157f, 0.02280758f, 0.15167962f, 0.00293268f, -0.06417166f, 
    -0.14648457f, -0.12450482f, -0.00772833f, 0.01786509f, -0.05504256f, -0.00046679f, 0.06321654f, -0.05999175f, 
    0.05965166f, -0.01029013f, -0.03693134f, 0.07108508f, -0.01315761f, 0.08143507f, 0.04959887f, 0.21405584f, 
    -0.04176892f, -0.05087844f, -0.17259865f, -0.01732731f, 0.21432804f, 0.06205716f, 0.08172774f, 0.07934230f, 
    0.19201833f, 0.31388560f, 0.21802540f, 0.02845299f, -0.11931869f, -0.14324117f, -0.14919440f, -0.08293603f, 
    0.05615797f, -0.02408869f, 0.19916582f, 0.03697203f, 0.00059217f, -0.21289763f, 0.00347709f, -0.02688242f, 
    0.00926284f, 0.03508374f, 0.00427025f, -0.00308243f, 0.07622699f, 0.01800156f, 0.17377038f, 0.04500085f, 
    0.11773530f, 0.29761490f, 0.12270488f, 0.12308611f, -0.01456820f, -0.03202454f, -0.21686715f, 0.01930414f, 
    0.08851253f, -0.03663916f, 0.14582190f, -0.10506844f, -0.03413057f, 0.03960097f, 0.23417310f, 0.05946236f, 
    0.07814199f, 0.10128991f, 0.11345471f, -0.09816596f, 0.06451050f, 0.08758174f, 0.08979282f, 0.20270987f, 
    -0.17073788f, 0.06774852f, 0.07811628f, 0.09228545f, 0.02240698f, -0.00073667f, -0.01297639f, 0.12922265f, 
    0.03911241f, 0.02469162f, -0.03567912f, 0.08270706f, -0.11759651f, -0.13684797f, 0.04488856f, 0.10362108f, 
    0.01119837f, 0.10436118f, 0.04749962f, 0.02862500f, -0.06862645f, 0.05587075f, 0.09118247f, -0.08769227f, 
    0.20980358f, -0.11087674f, 0.00690176f, 0.23464970f, 0.03514273f, 0.00536809f, -0.03941172f, -0.06834654f, 
    -0.07563565f, 0.06795705f, 0.08841787f, 0.07367294f, -0.12813920f, 0.23640604f, -0.13320765f, -0.13875642f, 
    0.04662960f, 0.03068924f, 0.15387318f, 0.04769529f, 0.13800877f, 0.05988211f, -0.01262055f, 0.06798660f, 
    0.29736668f, 0.06436910f, 0.25559536f, -0.07193069f, -0.05832218f, -0.13459961f, 0.00872913f, 0.10674164f, 
    -0.04100566f, -0.00375452f, -0.00973647f, -0.06402844f, -0.07913788f, 0.11422379f, 0.10251131f, -0.18049707f, 
    0.07233311f, -0.03529864f, -0.20624501f, -0.04178009f, 0.04474686f, -0.03584544f, -0.03979730f, -0.05855727f, 
    0.08445644f, -0.16837202f, -0.09698471f, 0.11519942f, 0.10399042f, 0.08163679f, -0.00754727f, -0.06907400f, 
    0.09110099f, 0.02910022f, 0.08437910f, 0.03062018f, -0.14770162f, 0.02617832f, 0.11477733f, -0.15895477f, 
    -0.10492550f, 0.00071433f, -0.10710415f, -0.03583134f, 0.11965770f, -0.01465099f, -0.04618762f, 0.08677759f, 
    0.25068855f, -0.08215969f, -0.06527998f, -0.29643777f, -0.14341401f, -0.02389604f, 0.10682493f, 0.01783368f, 
    0.00028868f, -0.07774522f, 0.06669622f, 0.17623590f, 0.51889795f, 0.22061346f, -0.12239059f, 0.21844271f, 
    -0.02368415f, -0.06824175f, -0.14913282f, -0.12960641f, -0.05115920f, 0.07841375f, -0.05374278f, 0.00987385f, 
    0.01336362f, -0.00063329f, 0.04016297f, -0.00889293f, -0.00900109f, -0.02390124f, -0.02208889f, -0.04330317f, 
    -0.02052842f, 0.01973274f, 0.03232952f, 0.01357775f, 0.00446996f, -0.02942378f, -0.02101723f, -0.03111970f, 
    -0.03055408f, 0.00677615f, 0.03438959f, -0.02767977f, -0.00038844f, -0.02449636f, 0.01994797f, -0.01701315f, 
    -0.00002332f, 0.03325115f, 0.01637725f, 0.01456972f, 0.01064769f, 0.03706189f, -0.03251266f, -0.02550046f, 
    -0.03598370f, 0.01582876f, 0.01915256f, 0.02717359f, -0.01092130f, -0.00935922f, -0.00767605f, 0.02497987f, 
    0.01800290f, 0.00478424f, -0.02711509f, -0.04236078f, -0.01374268f, -0.04222569f, 0.02052065f, -0.04298142f, 
    -0.02073931f, -0.02245223f, -0.01295501f, -0.00647894f, 0.01290898f, -0.01090725f, -0.02136450f, -0.03024891f, 
    -0.01994660f, -0.00510142f, 0.01972625f, -0.03137211f, 0.00796822f, -0.01409809f, 0.02573743f, 0.02576165f, 
    -0.02348714f, -0.00514817f, 0.01080603f, 0.00614831f, -0.02881322f, 0.02502659f, -0.01321691f, 0.02622159f, 
    0.02490900f, -0.02722734f, 0.02824418f, 0.01166504f, 0.02448805f, 0.01083777f, -0.01907896f, -0.01958394f, 
    0.01107796f, -0.03030951f, 0.01994057f, 0.00988330f, -0.00226479f, -0.01889412f, -0.03876138f, -0.02125656f, 
    0.00890568f, 0.02428915f, -0.01022370f, -0.00830742f, -0.00455832f, 0.01762463f, -0.01522096f, 0.00934218f, 
    0.00537333f, 0.01579250f, 0.02481533f, 0.00487077f, -0.04175315f, -0.02351694f, 0.02887540f, -0.01511848f, 
    0.01891794f, -0.04196744f, -0.01949295f, 0.02024714f, -0.03725838f, 0.00176860f, -0.04031975f, 0.00697344f, 
    -0.02539641f, 0.00214515f, 0.02059829f, -0.04252825f, -0.04271138f, 0.00310961f, 0.01308723f, -0.04073329f, 
    -0.01276423f, 0.00730241f, 0.02968908f, 0.02144513f, -0.04210532f, -0.03869423f, 0.02648438f, -0.04299697f, 
    -0.02820899f, 0.00013405f, 0.00788075f, -0.02496758f, 0.02095567f, -0.01527207f, 0.00873661f, 0.01533717f, 
    -0.04096733f, 0.03549183f, -0.02327584f, -0.00192699f, -0.02771857f, 0.00801853f, -0.00086788f, -0.00410351f, 
    0.00695225f, -0.02737700f, -0.03282383f, 0.00929873f, -0.03520570f, -0.00429407f, -0.02944431f, -0.04079675f, 
    0.01278974f, 0.00827143f, 0.01864317f, -0.01455832f, -0.03418775f, 0.01480078f, 0.01586213f, 0.02191235f, 
    -0.00013696f, -0.00695920f, -0.03355439f, -0.00613073f, 0.00545184f, 0.01238897f, -0.00407125f, 0.02259528f, 
    -0.00918314f, -0.01573233f, 0.00646430f, 0.01309463f, -0.03515170f, 0.01186124f, -0.03574920f, 0.02841831f, 
    -0.00487104f, -0.03189901f, -0.01136811f, -0.02634290f, 0.00892211f, -0.01698938f, 0.01408254f, 0.00386290f, 
    0.02944852f, -0.01877367f, -0.01795371f, -0.00444578f, 0.00924480f, 0.00346846f, 0.00845665f, -0.00259938f, 
    -0.00080645f, 0.02106224f, -0.01892053f, 0.03155259f, 0.02538848f, 0.00707622f, 0.00674174f, -0.03454655f, 
    -0.03178133f, 0.00580210f, 0.02589874f, 0.03288490f, 0.02796330f, -0.03661977f, 0.02081602f, 0.00348922f, 
    -0.00291307f, -0.02215420f, 0.00974396f, 0.01526395f, 0.02576154f, 0.01171651f, 0.00092786f, -0.00789441f, 
    -0.01824509f, -0.01873096f, -0.01071407f, -0.02578404f, 0.01669845f, -0.03363677f, 0.01735706f, 0.02339364f, 
    -0.00575163f, -0.00241956f, 0.00583730f, 0.03139342f, -0.02703057f, -0.02909282f, -0.02954510f, -0.02404895f, 
    -0.03843486f, -0.01482521f, -0.00934999f, 0.01868341f, -0.00897623f, 0.01533723f, 0.01917991f, 0.02043794f, 
    0.01236680f, -0.00775623f, -0.03212335f, 0.00146635f, -0.03197121f, -0.03010176f, -0.01371029f, -0.02716898f, 
    -0.00691131f, -0.02350256f, 0.01322547f, 0.00879540f, -0.01175150f, 0.00860957f, 0.02669043f, -0.01302179f, 
    -0.02857197f, 0.00389343f, -0.03006860f, -0.01592407f, -0.02481744f, -0.02089899f, -0.01229157f, 0.03760299f, 
    -0.01395715f, 0.00213123f, 0.00844711f, 0.01124076f, -0.02389989f, 0.00081419f, -0.04249181f, 0.02120232f, 
    0.00262593f, 0.01905459f, 0.00948683f, -0.01094001f, 0.01542663f, -0.01869830f, -0.02111288f, 0.02583078f, 
    -0.01944810f, -0.03938824f, -0.02728247f, 0.00067750f, -0.00503998f, 0.00781421f, -0.02684921f, 0.02571900f, 
    -0.00582052f, -0.00617277f, -0.01221203f, -0.02541435f, 0.00484342f, -0.00079048f, -0.01799310f, -0.01321977f, 
    -0.00165892f, -0.01776089f, 0.03672829f, 0.01936141f, -0.00683770f, -0.01734352f, 0.02126290f, 0.02545656f, 
    -0.00119315f, -0.03418335f, -0.00652570f, -0.01682529f, 0.01616076f, 0.01324668f, -0.00184187f, 0.01024216f, 
    0.00298581f, 0.01244095f, -0.01939181f, 0.02794327f, -0.03068591f, 0.03443294f, 0.02074481f, -0.00116980f, 
    0.00216890f, 0.01299088f, -0.02646901f, -0.00527930f, 0.02549078f, -0.01672451f, -0.03287922f, 0.03404260f, 
    -0.02934278f, 0.01219603f, -0.03129998f, 0.02331142f, 0.02353734f, 0.03215573f, -0.02567860f, 0.01149737f, 
    -0.01334080f, -0.04273745f, 0.00242071f, 0.02373155f, -0.02515169f, 0.00705331f, -0.00018967f, -0.02456946f, 
    -0.03596506f, -0.04178967f, 0.01119297f, -0.03652461f, -0.03186956f, -0.01691099f, 0.02728379f, 0.02662852f, 
    0.00655621f, 0.01223226f, -0.02702278f, 0.02091455f, 0.01015656f, -0.00916603f, -0.01938923f, 0.02655323f, 
    0.00737627f, -0.01930507f, -0.03093024f, -0.00996153f, 0.03697337f, 0.01811078f, 0.03518348f, 0.02062783f, 
    -0.02496403f, -0.01586418f, 0.00964109f, 0.00280778f, -0.03350317f, -0.00362649f, -0.00203882f, -0.03933143f, 
    0.00691977f, 0.02314757f, -0.01690762f, -0.00195815f, -0.02588204f, -0.04207057f, 0.01230047f, 0.02509006f, 
    0.00712960f, -0.03794581f, 0.00879849f, -0.03487627f, -0.00031358f, -0.01342189f, 0.01291538f, 0.01766103f, 
    -0.01944179f, -0.01943900f, -0.01751519f, 0.01143509f, -0.02863686f, -0.04061377f, -0.01031062f, -0.02811732f, 
    -0.02859455f, -0.02559180f, -0.00563973f, -0.04296007f, -0.04246905f, 0.00853383f, -0.00679656f, 0.02000770f, 
    0.01832182f, -0.01511149f, 0.01772702f, 0.02831669f, 0.03076708f, 0.00617708f, 0.03062322f, -0.02136529f, 
    0.00960483f, -0.02705214f, -0.02957089f, 0.00912343f, 0.00601114f, -0.02832817f, 0.01601459f, -0.00639633f, 
    0.00591431f, -0.02228394f, 0.00180984f, -0.00911124f, 0.02838045f, 0.00942044f, -0.01042942f, 0.02613581f, 
    0.02814360f, -0.02765053f, 0.01764731f, 0.02378480f, -0.00706567f, -0.01848273f, -0.03300450f, -0.02980856f, 
    -0.01010452f, -0.04083325f, -0.03970034f, 0.00468043f, -0.00024324f, 0.00574803f, -0.00346618f, 0.01806024f, 
    0.02818765f, 0.02679669f, 0.01770643f, -0.02343560f, -0.00400769f, -0.00743733f, 0.02672946f, -0.01836233f, 
    0.03718808f, 0.03363012f, -0.03401903f, 0.01656685f, -0.00469452f, -0.00600548f, 0.02322585f, -0.02275860f, 
    -0.00460067f, -0.00369776f, -0.02340003f, -0.02526952f, -0.00754942f, -0.02484433f, 0.00461584f, 0.02664706f, 
    0.00625720f, 0.02211475f, -0.03360527f, 0.02732485f, 0.00149510f, 0.00705596f, -0.00949110f, 0.01527434f, 
    -0.02754629f, 0.00147173f, -0.02550142f, -0.00893143f, -0.03581991f, -0.01550479f, -0.01454054f, -0.03105657f, 
    0.01867934f, 0.01591047f, -0.02968152f, 0.01319266f, 0.00870035f, -0.03365865f, -0.02335843f, -0.03223580f, 
    0.01478568f, 0.01435678f, -0.00039717f, -0.02062406f, -0.00620278f, -0.03149254f, 0.02063164f, -0.00517987f, 
    -0.04081610f, -0.01644639f, 0.00560727f, 0.01588420f, -0.02360445f, -0.03471355f, 0.00420707f, -0.01072128f, 
    0.00042317f, -0.00612540f, 0.01689689f, -0.00386241f, -0.00925774f, 0.00771265f, -0.00047046f, 0.00247212f, 
    -0.03881639f, 0.02041632f, 0.02200808f, -0.03736410f, -0.02206451f, -0.01202664f, -0.00984058f, -0.01706194f, 
    0.01518026f, -0.01119852f, 0.01129235f, -0.00322678f, 0.01105422f, 0.00238170f, -0.01186695f, -0.03612441f, 
    -0.01428813f, 0.00201396f, 0.01274383f, 0.01088693f, -0.02416497f, -0.01170159f, -0.02628049f, 0.01392402f, 
    -0.01464990f, -0.01181110f, 0.01123128f, -0.03709722f, -0.00522362f, -0.02004790f, -0.02335032f, -0.01773529f, 
    0.02673957f, -0.00635651f, -0.02302363f, -0.01071403f, -0.03855984f, -0.00960738f, -0.03821354f, -0.03889109f, 
    -0.02453302f, -0.02459549f, -0.00236956f, -0.00212549f, 0.00066961f, -0.02814403f, 0.00403337f, 0.00516506f, 
    -0.03258581f, 0.01645310f, 0.02672337f, 0.00193929f, -0.00227693f, 0.00733207f, -0.01192787f, 0.00458999f, 
    -0.00817227f, -0.04068121f, -0.01718847f, 0.00453790f, -0.01580318f, 0.01209069f, -0.03151455f, -0.02783387f, 
    -0.04224410f, 0.02459656f, 0.01785514f, -0.03083405f, -0.03196390f, -0.03027434f, -0.02320172f, -0.00018925f, 
    -0.04292675f, 0.01318113f, 0.02523070f, -0.00387651f, -0.01403748f, 0.00359972f, -0.01723915f, 0.02643740f, 
    -0.02034519f, 0.01787691f, -0.01622161f, 0.01503602f, 0.00380244f, -0.03632286f, 0.02044686f, 0.02225510f, 
    0.01295342f, 0.01294986f, -0.04255503f, -0.02240904f, -0.00357919f, -0.00965830f, -0.00140640f, 0.01969244f, 
    -0.00644498f, -0.01390536f, 0.01703036f, -0.02040280f, 0.02300709f, 0.00745299f, 0.01723413f, -0.02546287f, 
    -0.02109447f, 0.02470068f, -0.03724433f, 0.02596769f, -0.02023968f, -0.01378314f, 0.00447782f, -0.03362272f, 
    0.01252117f, 0.02476390f, -0.03222688f, -0.00445151f, -0.02865548f, 0.00183348f, -0.02667093f, 0.02001874f, 
    0.01218254f, -0.02774182f, -0.01793222f, -0.00795348f, 0.00849586f, -0.00513226f, -0.00524497f, -0.01493732f, 
    -0.03050607f, 0.02803327f, 0.02564204f, -0.03366236f, 0.01677252f, -0.01510876f, -0.03772451f, -0.02761357f, 
    -0.03450426f, -0.02368178f, -0.01808330f, -0.00159173f, 0.01318169f, -0.01265211f, 0.01986869f, -0.01238760f, 
    0.00994353f, -0.02254224f, -0.02019149f, 0.03453485f, -0.00681768f, 0.01040913f, 0.02632429f, -0.00803519f, 
    0.02955387f, -0.00691492f, -0.01675746f, 0.02485990f, -0.00160244f, -0.01367140f, -0.03441814f, -0.01533458f, 
    -0.04016016f, -0.01336845f, 0.01207632f, -0.02397263f, -0.01696181f, -0.00116480f, 0.02103199f, 0.01432182f, 
    -0.03612490f, -0.01839516f, -0.01417230f, 0.01416283f, 0.03386116f, -0.01981137f, 0.00025759f, -0.00136401f, 
    0.01757111f, -0.02269233f, 0.00777248f, 0.01596891f, 0.02081245f, -0.02120031f, -0.03411301f, -0.00504815f, 
    0.00505911f, -0.03317007f, -0.03182914f, -0.01940916f, -0.03256924f, 0.00523063f, 0.02734250f, -0.03030066f, 
    -0.00358594f, 0.00433521f, -0.00262359f, 0.00211970f, -0.02017544f, 0.00771892f, -0.02144480f, -0.02157624f, 
    -0.01452233f, -0.02933070f, 0.01329447f, 0.00452025f, -0.01788336f, 0.00500455f, 0.00214365f, 0.00080782f, 
    -0.00777754f, 0.02008567f, -0.01648275f, 0.01287336f, 0.01582822f, -0.04023466f, -0.02627339f, -0.03044767f, 
    -0.04107774f, 0.01196361f, -0.02355638f, -0.01346285f, -0.02248113f, -0.03402120f, 0.00742235f, -0.04122727f, 
    0.01426048f, 0.01914956f, -0.03161307f, -0.03802912f, -0.00993832f, -0.03606048f, -0.00162034f, -0.04222757f, 
    -0.01061156f, -0.00670863f, -0.01246763f, -0.03506467f, 0.01825719f, -0.00095625f, -0.01448241f, 0.00017496f, 
    0.00198679f, 0.01548201f, -0.00242253f, -0.04368448f, -0.03850337f, -0.02298827f, -0.03642464f, 0.00908933f, 
    -0.13177985f, 0.26644066f, 0.23487438f, -0.14809746f, -0.00103514f, -0.04559369f, 0.07841304f, -0.05086463f, 
    0.06680534f, 0.13503060f, 0.19428645f, 0.22212663f, -0.01846845f, 0.01829632f, 0.28978363f, 0.02919467f, 
    0.06834636f, -0.18961465f, -0.05436395f, 0.01197027f, -0.01668265f, -0.00828643f, 0.20542973f, -0.01901381f, 
    -0.16217987f, 0.17440413f, 0.27252591f, 0.13724552f, -0.05231936f, 0.04757807f, 0.15427260f, -0.02449047f, 
    0.01491361f, 0.02917904f, 0.09998658f, 0.04380243f, -0.13170378f, -0.04412368f, -0.04383828f, 0.15348925f, 
    0.02682606f, -0.03123914f, -0.03450466f, -0.02652867f, 0.15881619f, 0.21129814f, 0.10180657f, 0.16165979f, 
    0.04431378f, 0.19688314f, 0.21140923f, -0.07965671f, -0.08060288f, -0.16851291f, -0.00383608f, -0.10829244f, 
    -0.01937928f, 0.10825943f, 0.02190491f, 0.12484030f, 0.11074256f, 0.05480683f, -0.15314338f, 0.07692839f, 
    0.06781165f, 0.02944719f, 0.02795556f, -0.04237071f, 0.02796652f, 0.07462151f, -0.03055312f, 0.07404948f, 
    0.14077388f, -0.07671133f, -0.14507787f, 0.07585014f, -0.00009696f, -0.06116757f, -0.00421413f, -0.01715166f, 
    0.03404159f, -0.04797158f, -0.12034284f, -0.02455522f, 0.02302316f, 0.01148772f, 0.35114250f, -0.12267321f, 
    -0.10852332f, 0.08908927f, -0.03858873f, 0.05954881f, 0.18744440f, -0.04593782f, 0.04398133f, 0.05737700f, 
    0.12952921f, -0.04175197f, 0.04330167f, 0.08230446f, -0.11179493f, -0.09287864f, 0.14101332f, 0.18990436f, 
    0.09929284f, 0.10364006f, 0.03310103f, -0.01921964f, 0.08505438f, -0.05082640f, 0.09334666f, -0.18020260f, 
    -0.02675334f, -0.01724371f, -0.07569420f, 0.01947896f, -0.10455397f, 0.16872101f, 0.06100754f, -0.12445740f, 
    0.06633009f, -0.19474630f, -0.10140857f, 0.11795273f, -0.01854080f, 0.08127742f, 0.00684289f, -0.07271994f, 
    0.25422922f, 0.18237914f, 0.21029195f, 0.31613487f, -0.14055774f, 0.12414605f, -0.09764048f, -0.05095196f, 
    -0.19240968f, -0.05590656f, 0.04339835f, 0.06593712f, 0.19358125f, 0.04966091f, 0.14265029f, 0.26363239f, 
    0.27501240f, 0.07506476f, 0.03544276f, 0.00970281f, -0.09494508f, 0.05786829f, -0.06693372f, -0.05800693f, 
    0.05036664f, -0.07873594f, -0.11624872f, -0.07599733f, 0.05138079f, 0.05067885f, -0.14513119f, -0.06155934f, 
    0.07705296f, 0.07717505f, -0.01079219f, 0.06232704f, 0.01304415f, 0.05349409f, -0.06295864f, -0.05432798f, 
    0.12606007f, -0.13148630f, -0.24310297f, -0.02764453f, -0.06022588f, 0.00215435f, 0.08470450f, 0.02141010f, 
    0.23185717f, 0.22484824f, 0.09437346f, 0.07982878f, -0.20877206f, -0.30036268f, 0.24333838f, 0.07857618f, 
    0.07646373f, 0.19178273f, -0.10044087f, 0.00067878f, 0.07878856f, -0.03475409f, 0.07690006f, 0.17289925f, 
    0.00603062f, 0.13559903f, 0.20195471f, -0.25951788f, 0.03325653f, -0.02195426f, 0.00505977f, 0.09780212f, 
    -0.26205605f, 0.20119296f, -0.01897770f, -0.27716351f, -0.14413504f, 0.16737208f, -0.08098939f, 0.04142443f, 
    0.10618444f, 0.11813363f, -0.02706012f, -0.04026747f, -0.10819016f, -0.16441645f, 0.01172919f, 0.31803888f, 
    -0.01487798f, -0.04486939f, 0.21608458f, 0.10121725f, 0.07728270f, -0.06108925f, 0.01876613f, -0.04849560f, 
    0.02407739f, -0.13426369f, -0.12690485f, -0.04254461f, 0.12632331f, -0.16731076f, 0.06260254f, 0.28571114f, 
    0.09610304f, 0.02683904f, -0.08373319f, -0.04793723f, 0.04717980f, -0.01069851f, 0.02524524f, -0.02340968f, 
    -0.27629200f, 0.36702046f, 0.48458073f, -0.06239359f, 0.09764834f, 0.13238902f, 0.18677087f, -0.11294320f, 
    -0.05081985f, 0.17146352f, -0.08461043f, -0.12494050f, 0.03576845f, 0.07418845f, -0.03052821f, 0.19694097f, 
    0.18714935f, 0.12628804f, -0.11204915f, 0.05766209f, 0.18376096f, 0.11340839f, 0.27451062f, 0.32999873f, 
    -0.17090784f, 0.05470100f, 0.13445365f, 0.25343880f, 0.04081507f, 0.03070472f, -0.04463373f, -0.05107104f, 
    -0.20148292f, -0.05330108f, 0.00020881f, -0.06100152f, 0.07703394f, 0.16935326f, -0.05889802f, 0.17016472f, 
    0.08704134f, -0.06653531f, 0.06493986f, 0.19093242f, 0.21178862f, 0.00462302f, 0.12111381f, 0.00684465f, 
    -0.15366879f, -0.01175534f, 0.03100105f, -0.11024313f, 0.00464381f, -0.15860829f, 0.08521243f, 0.02873949f, 
    0.06187404f, 0.12334565f, 0.06980536f, 0.09596504f, 0.08134808f, -0.01917480f, -0.13444412f, 0.07705668f, 
    0.24364354f, -0.07260582f, -0.19330470f, 0.06854644f, -0.02322542f, -0.16042493f, -0.16461691f, -0.21503866f, 
    -0.04901168f, -0.03878912f, -0.10215922f, 0.06908131f, 0.03947628f, -0.17781112f, -0.08094461f, -0.09419869f, 
    -0.06577528f, -0.05950291f, -0.10199634f, -0.17550603f, -0.12450935f, 0.00978773f, -0.05370117f, -0.03109413f, 
    -0.09718523f, -0.07901471f, -0.03899575f, -0.00032090f, 0.03565973f, -0.03074977f, -0.15526512f, -0.20072375f, 
    0.01948784f, 0.26180032f, 0.10806993f, 0.03646168f, 0.14512649f, -0.03549390f, -0.03686349f, 0.03870690f, 
    -0.18858576f, -0.14815056f, -0.20793279f, -0.21177307f, 0.24301714f, 0.06936961f, 0.01064622f, -0.01139153f, 
    0.06120934f, -0.03195937f, 0.04280449f, 0.04911330f, 0.09002955f, -0.16974196f, -0.10871850f, -0.18904555f, 
    -0.07588758f, -0.09098018f, 0.08617889f, 0.10661149f, 0.00843431f, -0.03087085f, 0.10326939f, -0.14643680f, 
    -0.11618252f, 0.16303872f, 0.13763852f, 0.33119226f, -0.50311941f, -0.02517720f, 0.10706594f, 0.18277471f, 
    0.18131198f, 0.27244538f, -0.05247466f, 0.05314818f, -0.11642437f, -0.05131261f, 0.11986043f, -0.16549337f, 
    0.07362463f, 0.17525688f, -0.01561424f, -0.11982862f, 0.00528611f, 0.05133227f, -0.00780268f, -0.06981425f, 
    -0.05792830f, -0.06134897f, -0.14928399f, -0.17696463f, -0.06056083f, 0.02740133f, 0.13041420f, -0.09679392f, 
    0.08979549f, 0.07408613f, -0.04368951f, -0.05092446f, 0.10941334f, -0.06577581f, -0.15499887f, -0.13841568f, 
    0.04867585f, 0.27105510f, -0.02394881f, -0.04326122f, -0.14418718f, 0.06789680f, -0.16661409f, 0.04783250f, 
    0.18044993f, -0.05909115f, 0.05197287f, 0.24815032f, 0.01478869f, 0.05736592f, -0.16807592f, 0.12234891f, 
    0.05969747f, -0.20479903f, 0.06003057f, -0.14270608f, -0.23893097f, -0.15541309f, -0.19144137f, -0.01710594f, 
    0.23250468f, 0.14767601f, 0.36945614f, 0.20170996f, 0.02264279f, 0.07094879f, 0.02708870f, -0.03560839f, 
    -0.08539524f, 0.00448096f, 0.07262559f, 0.04586790f, -0.18180031f, -0.25216529f, 0.01948260f, 0.17418878f, 
    0.14935672f, 0.16154687f, 0.04832223f, -0.02444734f, 0.12410383f, 0.09487833f, 0.19526522f, 0.14954181f, 
    -0.11482809f, 0.00184032f, 0.13313392f, -0.00418953f, -0.19727792f, -0.20531687f, -0.10913515f, 0.01156409f, 
    0.19717632f, 0.28476959f, 0.01196710f, -0.00752737f, 0.06760048f, -0.05504428f, -0.02595650f, 0.04750865f, 
    0.02639315f, 0.08228708f, -0.05826883f, 0.12706883f, 0.04313136f, -0.05093855f, -0.07292199f, -0.17808717f, 
    0.15801319f, 0.02779159f, 0.07338239f, 0.02499563f, -0.01163857f, -0.20345892f, -0.04072748f, 0.03620378f, 
    0.02405203f, -0.13934833f, -0.01867168f, -0.06093173f, -0.12118381f, -0.11069442f, 0.09414034f, 0.22338752f, 
    -0.03399535f, -0.08233954f, -0.03581810f, 0.10306929f, 0.02960412f, 0.08735368f, 0.08275072f, 0.08961802f, 
    -0.02120827f, -0.06481197f, -0.03276400f, 0.13224329f, 0.18310706f, -0.15127794f, -0.08011678f, 0.11737555f, 
    -0.16515474f, -0.17370580f, -0.11764349f, -0.17420921f, 0.00832615f, -0.03612657f, 0.03445783f, 0.07572839f, 
    -0.15377671f, 0.11488166f, 0.01517025f, -0.17168082f, 0.04776773f, -0.18930925f, -0.06203182f, -0.13863462f, 
    -0.04058782f, 0.32055590f, 0.10046989f, 0.00555432f, -0.01882374f, -0.12303207f, 0.00977468f, -0.02271497f, 
    0.04660226f, -0.02797031f, -0.10389788f, 0.01189411f, 0.11092588f, -0.06000521f, -0.12114722f, 0.52576298f, 
    0.09459940f, 0.01573664f, -0.22204192f, 0.17321013f, 0.14313558f, -0.03190305f, 0.15392451f, 0.20914826f, 
    -0.01989210f, 0.16425906f, -0.03850867f, -0.06574873f, 0.03215766f, 0.01063660f, -0.03933531f, -0.04874079f, 
    0.05541471f, -0.33874279f, -0.08415942f, -0.13930634f, -0.04878398f, 0.06709813f, 0.03074411f, -0.06438325f, 
    0.01504986f, -0.10032218f, -0.01325325f, -0.10041747f, 0.01928863f, 0.07934905f, 0.01413224f, -0.00276379f, 
    0.02084947f, 0.18201315f, 0.15660937f, -0.03945443f, -0.00159195f, -0.09812692f, -0.14269885f, -0.05889575f, 
    -0.14484546f, 0.04663502f, 0.02072809f, 0.00822224f, -0.15241927f, 0.16578785f, 0.04916746f, -0.25560489f, 
    -0.00493161f, -0.04895176f, 0.03009766f, -0.03553362f, 0.06434563f, 0.06514718f, 0.26102677f, 0.11645614f, 
    0.08609580f, -0.08474346f, -0.03115077f, 0.15165934f, 0.01823726f, 0.01456975f, 0.03674647f, -0.07262196f, 
    -0.01117339f, 0.02030124f, 0.15914604f, 0.16628921f, 0.14492236f, 0.13119105f, 0.11883349f, 0.34970719f, 
    -0.03640322f, -0.14099453f, -0.03043333f, -0.06135066f, -0.13942851f, -0.06238228f, 0.00854269f, 0.21566086f, 
    0.06394253f, 0.15241173f, 0.30279395f, -0.17753239f, -0.07154407f, 0.04458153f, -0.01551893f, -0.03685761f, 
    -0.03749486f, -0.01223629f, 0.03132189f, -0.06330044f, -0.10526873f, 0.10954963f, 0.38875723f, -0.08543316f, 
    -0.07699062f, -0.10307831f, 0.01350346f, 0.09725322f, -0.05074304f, 0.13686366f, -0.02756969f, -0.34178522f, 
    -0.22705609f, -0.36529452f, -0.14780572f, 0.04290132f, -0.19150347f, 0.04038385f, -0.00522074f, 0.04319547f, 
    -0.06745995f, 0.01698786f, -0.00409025f, 0.01242409f, -0.05333218f, -0.17011657f, 0.12231435f, 0.12473175f, 
    0.01560626f, -0.11126047f, -0.08516680f, 0.12506740f, 0.02802659f, -0.20796382f, -0.08903433f, -0.00030998f, 
    0.01744949f, 0.02903445f, 0.09318309f, -0.10753452f, 0.07825603f, 0.03165869f, 0.03553167f, 0.04900241f, 
    -0.02297691f, -0.07068454f, -0.03074745f, -0.00561620f, -0.22759447f, -0.40515503f, 0.09599830f, 0.30753103f, 
    -0.08629958f, 0.16343288f, -0.21727276f, 0.07822929f, -0.10199068f, -0.05694203f, 0.04627573f, -0.02167380f, 
    0.04223708f, -0.21681419f, -0.05308179f, 0.19958039f, 0.00132925f, -0.05363844f, 0.09537465f, 0.16296691f, 
    -0.06207398f, -0.01748469f, 0.02924193f, 0.08100382f, 0.08378556f, 0.18095000f, 0.20056698f, -0.08826634f, 
    0.07004321f, 0.12891193f, 0.04359114f, -0.08230232f, -0.04975474f, -0.03414900f, -0.12191902f, -0.08664366f, 
    -0.20550862f, 0.00568189f, -0.09148841f, 0.01142314f, 0.02864508f, -0.26586118f, -0.00664167f, 0.15973495f, 
    -0.04130678f, 0.18636687f, 0.05994330f, -0.10721600f, 0.22167538f, -0.02024262f, 0.03487660f, 0.13731821f, 
    0.04989731f, 0.03793017f, 0.18874913f, -0.07983389f, -0.04886064f, -0.11792077f, -0.16260204f, -0.06717148f, 
    -0.10142200f, 0.03076405f, 0.10097225f, 0.20382306f, 0.25042599f, -0.06403808f, -0.05924344f, -0.10795079f, 
    -0.05337198f, 0.12851644f, 0.05756418f, -0.02207692f, -0.14027345f, -0.06264749f, -0.22794873f, 0.02230012f, 
    0.09247269f, 0.02562367f, -0.10700259f, -0.01216607f, -0.11215775f, -0.12122370f, 0.15810998f, 0.18299018f, 
    0.00396910f, -0.04140673f, -0.03280511f, 0.03319510f, -0.02320902f, 0.02800932f, -0.02424386f, 0.02476935f, 
    -0.02658557f, -0.03733701f, -0.03349515f, 0.02962454f, -0.04066087f, 0.00054998f, 0.03088698f, -0.03372584f, 
    -0.02721077f, 0.03123591f, 0.01915630f, 0.00348824f, 0.00243592f, -0.02949782f, -0.01541052f, -0.01302233f, 
    0.01916077f, 0.00979294f, 0.00185857f, -0.03409192f, -0.00615258f, -0.01554874f, -0.02895022f, -0.03088726f, 
    -0.03373865f, 0.02084664f, 0.02633453f, -0.02806904f, 0.00807383f, 0.02435977f, 0.00882524f, 0.03639968f, 
    0.02570741f, -0.01283717f, 0.00635774f, -0.01053712f, 0.00710764f, 0.01018494f, -0.03258707f, 0.00056847f, 
    0.02931109f, 0.01352478f, -0.02050252f, 0.02850678f, -0.04515571f, 0.01176140f, -0.00857059f, -0.01273223f, 
    0.02772273f, 0.01520210f, -0.00623033f, 0.01230204f, -0.01742625f, 0.01332208f, 0.00346168f, 0.00877295f, 
    0.02751528f, 0.00855723f, 0.02009877f, -0.01299840f, 0.01863333f, 0.02442162f, 0.00507815f, 0.00543275f, 
    -0.02703295f, 0.00394338f, -0.02031423f, -0.01287296f, 0.00109018f, 0.02830651f, -0.00625011f, -0.03910668f, 
    0.00959009f, -0.00289261f, 0.00837040f, -0.04242668f, 0.02875417f, 0.03109148f, -0.00668815f, -0.01852716f, 
    0.01765694f, -0.01140709f, 0.00369383f, -0.00273767f, -0.02913876f, -0.00292318f, 0.02506889f, -0.01121732f, 
    0.02015769f, -0.03837578f, 0.02532395f, -0.01921073f, -0.02630827f, -0.00262824f, 0.01004754f, 0.00379135f, 
    0.01295663f, -0.01156362f, 0.03035505f, 0.02349333f, 0.00312672f, -0.03340651f, 0.00460766f, -0.02006449f, 
    0.01696727f, -0.03381352f, 0.00354187f, -0.02792005f, 0.00556772f, 0.00802379f, -0.03005984f, 0.02564551f, 
    -0.03071719f, 0.00742522f, -0.02620930f, -0.03254753f, 0.02722703f, 0.01627909f, -0.00694203f, -0.00015646f, 
    -0.03644168f, 0.01281299f, 0.01443635f, -0.03530776f, -0.01758359f, -0.03600449f, 0.00337056f, -0.01492299f, 
    -0.01812229f, -0.02900264f, -0.03112411f, -0.03361997f, -0.01896314f, 0.01601090f, 0.00114897f, 0.01969050f, 
    0.01176578f, -0.03052928f, -0.03562306f, -0.00093293f, -0.00760190f, 0.02294366f, -0.00544295f, 0.02454406f, 
    -0.03344309f, -0.03106182f, -0.02208034f, 0.01719406f, 0.01797604f, -0.03542585f, 0.01730462f, -0.02319480f, 
    0.02968611f, -0.02827014f, -0.03991682f, 0.02951321f, 0.00834550f, -0.00400331f, -0.02290188f, -0.00975445f, 
    -0.02643612f, -0.02690449f, -0.01373141f, 0.01787068f, 0.01009801f, -0.00288530f, 0.00271911f, 0.02269506f, 
    0.02282570f, -0.01778367f, -0.01509756f, 0.01069463f, 0.01687944f, 0.02472206f, 0.00203426f, -0.01439295f, 
    -0.03531094f, -0.01440080f, -0.02737215f, -0.01390292f, 0.02689210f, -0.03114101f, 0.02339367f, 0.00309874f, 
    -0.01630592f, 0.00870187f, 0.00653539f, -0.01557307f, -0.01678238f, 0.00248961f, -0.02390076f, -0.00806617f, 
    -0.02930454f, -0.02341376f, 0.01826572f, -0.01283290f, -0.01756340f, 0.01881200f, 0.00102055f, 0.00525082f, 
    -0.00297607f, 0.01755958f, -0.03519960f, -0.01124103f, 0.00796153f, -0.00884089f, 0.01285190f, -0.01545202f, 
    0.00933623f, 0.03368625f, -0.01777461f, 0.00990925f, 0.00300208f, 0.03195428f, -0.00304181f, 0.02193454f, 
    -0.01946986f, -0.03086058f, 0.00744681f, -0.02205796f, 0.00968782f, -0.01987754f, -0.02477441f, -0.02824086f, 
    -0.02727357f, 0.00729350f, -0.00872718f, -0.00946887f, -0.02048304f, -0.01730874f, -0.03079999f, -0.03111720f, 
    -0.01631417f, -0.00916902f, 0.01752822f, -0.02435468f, 0.01532199f, -0.03494300f, -0.02412632f, 0.02495065f, 
    -0.01999571f, -0.01025750f, -0.02217119f, -0.01646228f, -0.03288170f, 0.03017356f, 0.00738762f, -0.03210768f, 
    0.00504780f, 0.01752526f, -0.02309438f, -0.00896980f, 0.02458103f, -0.00343187f, -0.02669026f, -0.00436785f, 
    0.01537106f, -0.02388367f, 0.01679452f, 0.00657606f, 0.02270684f, -0.00042153f, -0.03206429f, 0.01232894f, 
    -0.03231400f, -0.02435925f, -0.00489265f, 0.02877504f, 0.00446293f, -0.02560385f, 0.02301401f, -0.00966579f, 
    0.02300939f, 0.02894961f, -0.03668566f, -0.01374284f, -0.02264689f, 0.00075104f, -0.01469042f, -0.01317681f, 
    0.03009336f, -0.03110119f, -0.00327506f, -0.00957135f, 0.00444058f, -0.02076153f, -0.01216444f, -0.02796220f, 
    0.00711303f, -0.01591918f, -0.00042835f, 0.01187074f, -0.00687500f, -0.03131130f, -0.03372464f, -0.02036252f, 
    0.02780124f, 0.00359932f, 0.00096824f, -0.00847335f, 0.01430602f, 0.02072485f, -0.01726296f, -0.01143168f, 
    -0.01019600f, -0.01664494f, -0.03243226f, -0.01369813f, -0.03381142f, 0.00934514f, 0.01964639f, -0.00299582f, 
    -0.03425684f, 0.00040079f, -0.03322887f, 0.02588894f, 0.01531841f, 0.02785657f, 0.01214036f, 0.01119359f, 
    -0.00980635f, -0.00359507f, 0.02823791f, 0.01680526f, 0.02629774f, 0.01999982f, -0.03667056f, 0.03414754f, 
    0.02699292f, 0.01593568f, -0.01825886f, -0.02130204f, -0.01082332f, -0.00608633f, 0.02546719f, 0.01314350f, 
    -0.03505759f, 0.01106941f, 0.01382859f, 0.02349581f, -0.03306709f, -0.02307977f, -0.00237717f, -0.03813271f, 
    -0.03488762f, -0.00931755f, 0.02732946f, -0.03320363f, -0.01084595f, -0.00126920f, -0.01088964f, 0.01715669f, 
    0.00135224f, 0.02909700f, -0.02770662f, -0.02232312f, -0.00437142f, 0.02514994f, -0.04058019f, 0.02679619f, 
    0.01824654f, 0.02313124f, 0.02759943f, 0.01630191f, 0.00905467f, 0.00170303f, 0.02252575f, 0.01024855f, 
    0.00043235f, 0.01102515f, -0.02574703f, -0.03509287f, -0.01230340f, 0.03201852f, -0.03589685f, 0.02791316f, 
    0.02835404f, -0.03014733f, 0.01579547f, 0.00049304f, 0.00107872f, -0.00111648f, -0.02154138f, -0.03173632f, 
    0.01382126f, -0.02643345f, -0.02681927f, 0.00327815f, 0.02495018f, -0.03917581f, 0.00282003f, -0.01892318f, 
    0.00079697f, -0.02642470f, -0.00958909f, -0.00082300f, 0.00120280f, -0.01965000f, 0.01537234f, -0.03598366f, 
    0.01438497f, 0.00979398f, -0.00326765f, 0.00443256f, -0.00359811f, 0.01696084f, 0.02458054f, 0.01559561f, 
    -0.00719427f, 0.01978130f, -0.00938749f, -0.00658595f, -0.04101293f, 0.03178143f, 0.01576487f, -0.02050889f, 
    0.01617091f, -0.03225532f, -0.01766647f, -0.03396847f, -0.03156199f, -0.02560335f, -0.02906212f, -0.04056995f, 
    -0.01194437f, -0.00556936f, -0.02206936f, -0.04084878f, -0.01265120f, -0.01462208f, -0.02226387f, -0.00844513f, 
    0.01807374f, 0.02847299f, 0.03393318f, -0.01941299f, -0.04063645f, -0.00031148f, -0.03794619f, -0.02460335f, 
    -0.03987290f, -0.01067666f, -0.01944702f, -0.02832022f, -0.03897958f, -0.00270491f, -0.01221692f, -0.03679390f, 
    -0.02144683f, -0.00556456f, 0.00245223f, -0.02899932f, -0.01153801f, -0.01282820f, -0.00143498f, 0.02116258f, 
    0.01697260f, 0.00018035f, 0.01233015f, -0.01617094f, -0.03565743f, -0.02803305f, -0.01687359f, -0.00549839f, 
    0.02395637f, -0.00116552f, -0.02937427f, 0.01101812f, -0.03594146f, -0.01451492f, -0.02927539f, 0.00042378f, 
    -0.03870936f, 0.01978740f, -0.01370970f, -0.01163447f, -0.00907846f, 0.02075266f, 0.01924106f, 0.00896478f, 
    0.01395450f, -0.02179988f, -0.03059040f, 0.00725141f, -0.03682731f, -0.01031973f, 0.00882949f, -0.00678983f, 
    0.01251742f, 0.02381373f, 0.00501848f, 0.02775965f, 0.00209925f, -0.02161817f, 0.01937080f, -0.02666852f, 
    0.00354811f, 0.02661237f, 0.00583075f, 0.03151977f, 0.01766389f, -0.02632713f, 0.00932841f, -0.01062176f, 
    0.02844725f, -0.01204111f, 0.00356583f, -0.02084609f, 0.01655414f, -0.02996794f, 0.02881802f, 0.01641275f, 
    -0.02272048f, 0.00471041f, -0.00977876f, -0.01781190f, -0.02736325f, 0.00764723f, 0.00245976f, -0.00085933f, 
    -0.00634973f, -0.00289177f, 0.00762863f, -0.03647393f, 0.03121543f, -0.02595880f, 0.02021246f, -0.04259731f, 
    0.02229983f, -0.01346497f, 0.02579772f, 0.01715248f, 0.02856682f, 0.00693989f, -0.03161594f, 0.00611790f, 
    0.01782929f, 0.03136392f, -0.02448443f, -0.00773777f, -0.00749056f, -0.00843690f, 0.02545245f, -0.03486520f, 
    0.01695874f, -0.00090773f, 0.01876854f, -0.03049948f, 0.02992089f, 0.01101355f, 0.01833344f, -0.03512758f, 
    0.00827923f, 0.02620628f, -0.00619224f, 0.02914350f, -0.03002837f, -0.01401552f, 0.02720574f, -0.00359103f, 
    -0.03080425f, 0.02001661f, -0.01840065f, 0.00475161f, -0.03157907f, 0.02075946f, -0.00574607f, -0.00600517f, 
    -0.02660138f, -0.00803985f, 0.00826512f, -0.03215161f, -0.00081944f, 0.00739974f, 0.01317935f, 0.00837907f, 
    0.00506862f, -0.02079062f, -0.01082083f, -0.01281506f, 0.02870753f, 0.02993460f, -0.01741809f, -0.00771370f, 
    -0.00389069f, -0.02845393f, 0.00507341f, -0.03458714f, 0.03356420f, -0.01998979f, 0.02479061f, -0.01345777f, 
    -0.01760136f, 0.00398283f, -0.04052619f, -0.01735426f, 0.00650058f, 0.01228555f, -0.00807753f, 0.00548923f, 
    0.02241565f, 0.02695554f, -0.01280712f, -0.03041470f, -0.01258272f, -0.02099186f, -0.00801082f, -0.01049739f, 
    -0.02364992f, -0.01205743f, -0.03790527f, -0.02268041f, -0.00014701f, 0.01266797f, -0.01399003f, 0.03025300f, 
    -0.01439687f, -0.01231681f, 0.02873627f, -0.01240959f, 0.01738558f, -0.02751917f, -0.02821615f, 0.02054527f, 
    -0.03035433f, 0.01114805f, 0.01027559f, -0.03942787f, 0.02627591f, 0.01961827f, -0.03758731f, 0.01172993f, 
    0.02524961f, 0.00087234f, 0.02278748f, -0.04255666f, -0.02936102f, 0.02659847f, 0.01650705f, -0.01611674f, 
    -0.03679489f, -0.01955834f, 0.00878273f, 0.01171521f, -0.00845995f, 0.02621977f, 0.00696539f, -0.00712861f, 
    0.01754353f, 0.01946145f, 0.01060089f, 0.02611032f, -0.00228840f, -0.02630125f, -0.02411374f, 0.00953489f, 
    0.01265101f, -0.01492217f, -0.03305004f, 0.01809118f, 0.00360413f, 0.02041458f, -0.01439448f, 0.01642693f, 
    -0.02335997f, 0.00234587f, -0.03850174f, -0.03144397f, 0.02173535f, -0.03084665f, -0.01877015f, 0.00078041f, 
    0.02585726f, -0.00361269f, -0.00822550f, 0.01352666f, -0.03047671f, -0.00203391f, -0.00161182f, -0.02438658f, 
    0.00483700f, -0.03596798f, -0.01566797f, -0.03466225f, 0.02540790f, -0.00836938f, -0.03041387f, -0.03762087f, 
    0.02480629f, -0.02540153f, 0.01753703f, 0.01967666f, -0.03148785f, -0.03601122f, 0.00179240f, 0.00383978f, 
    -0.02813275f, 0.01260331f, 0.01030439f, 0.01871663f, -0.00397127f, -0.02657058f, -0.01875581f, 0.02512571f, 
    0.03373018f, -0.03276461f, -0.01160724f, -0.00518891f, -0.00547182f, 0.01384912f, 0.00384043f, -0.03505530f, 
    0.00082548f, -0.01705395f, -0.01574468f, 0.00154584f, 0.01181323f, -0.00148270f, 0.00513943f, -0.00575361f, 
    0.00052844f, 0.01530826f, -0.01224130f, 0.01051510f, 0.01476711f, -0.03587606f, 0.01402847f, -0.00105877f, 
    0.00218169f, -0.02690998f, -0.04008762f, -0.00469824f, 0.00354913f, -0.00284409f, 0.01914247f, -0.02342670f, 
    0.00933951f, 0.00127142f, 0.00080667f, -0.00152164f, -0.02584971f, 0.01662450f, -0.03835095f, 0.01528337f, 
    0.02229424f, -0.01946082f, -0.00563113f, 0.02938082f, -0.00887643f, -0.01792719f, 0.01043622f, 0.01865869f, 
    -0.02126443f, -0.03702214f, -0.03390096f, -0.03152720f, -0.01657675f, -0.03293511f, -0.03880174f, 0.01305638f, 
    0.02677395f, -0.12077592f, 0.18164167f, 0.04337769f, 0.08116404f, -0.03168457f, 0.03533391f, 0.06956255f, 
    -0.20125301f, -0.17537618f, -0.26153228f, -0.13034271f, -0.05661979f, 0.07796521f, -0.08769912f, -0.03442315f, 
    0.14353338f, 0.13083597f, 0.07246828f, -0.07719988f, -0.16592047f, 0.00483229f, -0.08659267f, 0.04101023f, 
    0.30392003f, -0.11482050f, 0.06673934f, 0.18202914f, 0.11321647f, -0.12705618f, -0.12093012f, 0.10555403f, 
    0.05295618f, 0.02988410f, -0.10801892f, -0.04410363f, -0.07393675f, 0.10861950f, -0.07035421f, -0.08897444f, 
    -0.06308516f, -0.03446840f, -0.02953147f, -0.11846615f, -0.05688330f, -0.19349749f, -0.08786570f, 0.02591156f, 
    -0.20844281f, -0.15770757f, -0.18336529f, -0.15055470f, -0.01841165f, 0.03785527f, -0.03324744f, 0.14306356f, 
    0.12407746f, -0.09258697f, -0.08426777f, -0.13791122f, -0.16759571f, 0.03096045f, 0.18988508f, -0.12526770f, 
    -0.02353754f, 0.01619574f, -0.14792892f, -0.01009076f, 0.16765110f, -0.06847068f, 0.20455310f, -0.00582935f, 
    -0.24108578f, 0.03901899f, 0.10398753f, -0.01952448f, -0.09964189f, -0.08335441f, -0.08152834f, -0.24231181f, 
    0.16247229f, 0.01611828f, 0.02548208f, -0.02090132f, 0.13404106f, 0.03191610f, -0.26392034f, 0.01524713f, 
    0.04250067f, -0.00789976f, -0.07183672f, 0.19413348f, -0.15862522f, -0.04822347f, -0.07931378f, -0.02913119f, 
    0.09921537f, 0.05278688f, 0.15426837f, 0.01417515f, -0.05307617f, 0.02195316f, -0.07787421f, -0.20476253f, 
    -0.16378891f, -0.04688402f, 0.01418186f, -0.11004096f, 0.01558176f, 0.16654530f, -0.02365831f, 0.05387134f, 
    -0.07520842f, -0.00685061f, 0.02291062f, -0.10727049f, 0.17678140f, -0.06633461f, -0.02265327f, 0.01469261f, 
    -0.07977168f, 0.14662512f, -0.02005923f, -0.00970697f, -0.01733125f, -0.02371847f, -0.07615763f, -0.09449606f, 
    -0.24434870f, -0.05309406f, -0.08859938f, -0.23582517f, 0.08794671f, 0.07029605f, 0.05489441f, 0.15324843f, 
    -0.02342284f, -0.14188890f, 0.08427443f, 0.01912779f, -0.10168013f, -0.08615149f, -0.12604564f, -0.27024701f, 
    0.03424225f, 0.16704148f, -0.03912555f, 0.01061533f, -0.02502850f, -0.08690643f, -0.01053786f, -0.12357762f, 
    -0.13559674f, 0.08385676f, -0.02890595f, -0.01473087f, -0.05288685f, -0.05846133f, -0.01190915f, -0.14283793f, 
    -0.12678787f, -0.12423540f, -0.21259697f, -0.23660950f, 0.11054843f, 0.03659908f, 0.00250511f, -0.09716249f, 
    -0.10431852f, 0.29396832f, 0.22595051f, 0.06250059f, -0.08245224f, 0.01246364f, -0.03010510f, -0.14119424f, 
    -0.20490564f, -0.13099685f, -0.09423842f, 0.01687699f, 0.04450645f, 0.28821000f, -0.05917181f, 0.16053660f, 
    -0.09668106f, 0.14852956f, 0.07833034f, 0.07237138f, -0.00062959f, 0.02833259f, 0.04338717f, -0.01455803f, 
    0.21141796f, 0.20041485f, 0.33277538f, 0.12421557f, -0.07102746f, -0.00380694f, -0.11065364f, -0.00002789f, 
    0.13005927f, -0.16468695f, 0.11080910f, 0.21414892f, 0.04563768f, 0.26260903f, 0.09622063f, -0.25974384f, 
    -0.03186636f, -0.10768788f, 0.09307238f, 0.08730821f, 0.04160383f, 0.02944867f, 0.21263729f, 0.02697234f, 
    -0.18287475f, -0.02599023f, -0.24066605f, -0.17242454f, -0.01772038f, -0.01445978f, -0.02999343f, -0.22653636f, 
    -0.04851970f, 0.11423299f, 0.02752052f, -0.22057118f, -0.06310021f, 0.21352859f, -0.04258596f, 0.07557196f, 
    -0.16281642f, 0.01384579f, 0.00104856f, -0.02039299f, 0.01037331f, 0.02337116f, 0.12908745f, 0.09980584f, 
    -0.02253664f, -0.27518699f, 0.07199050f, 0.08556642f, -0.05231712f, 0.01806203f, 0.07217658f, 0.05835980f, 
    -0.06200011f, -0.16089220f, 0.00917622f, 0.03389465f, 0.02807969f, -0.06329509f, 0.11618908f, -0.09579329f, 
    -0.05996674f, 0.01708211f, -0.13854259f, -0.11363030f, -0.13495974f, -0.00662275f, -0.13713925f, -0.10393855f, 
    -0.13898705f, 0.06835844f, -0.22794379f, 0.00891836f, 0.01583233f, -0.05011178f, -0.10242336f, -0.11749877f, 
    0.03298208f, 0.09934221f, 0.14186347f, 0.09336880f, -0.11198845f, 0.08154111f, 0.10569606f, -0.01638485f, 
    0.01099473f, 0.10330972f, 0.08450413f, 0.02299487f, -0.10143905f, -0.04553193f, -0.03389999f, -0.11693762f, 
    0.13608178f, 0.06921957f, 0.07288671f, 0.08618986f, -0.07068885f, -0.05555167f, 0.06328084f, 0.09152114f, 
    0.00458809f, -0.03934399f, -0.12435482f, -0.16965893f, 0.17493562f, -0.22277083f, 0.16847996f, -0.08813719f, 
    0.07234363f, 0.24043591f, 0.09915611f, 0.38895801f, -0.17916813f, 0.18870030f, 0.05319770f, 0.09189484f, 
    0.23856829f, -0.04291064f, 0.25739250f, 0.12961379f, -0.06379187f, 0.05093127f, 0.17215928f, 0.16789946f, 
    0.04986876f, 0.08099625f, 0.17200719f, 0.14742485f, 0.04217829f, -0.05598841f, 0.15978217f, 0.23136221f, 
    -0.03588976f, 0.12215887f, 0.17139880f, 0.20991334f, -0.15380320f, 0.05647215f, 0.07799640f, 0.16702248f, 
    0.04497818f, 0.10500751f, 0.03458887f, 0.18575111f, -0.09892605f, 0.00830278f, -0.03524151f, -0.09856731f, 
    -0.04451005f, 0.27598849f, 0.13298145f, 0.07576922f, -0.07517035f, 0.02152571f, 0.15043755f, -0.09930097f, 
    -0.03227961f, 0.15856211f, 0.01530377f, 0.02056054f, 0.15824616f, 0.04553127f, 0.11234511f, -0.03472457f, 
    -0.06079336f, 0.12469013f, -0.13750212f, 0.13000160f, -0.02542860f, 0.02797188f, -0.05070296f, 0.25112551f, 
    -0.01235490f, -0.06088414f, 0.01159506f, -0.20725474f, -0.14584197f, 0.02001194f, 0.12687446f, 0.22604866f, 
    0.11150046f, 0.14872776f, -0.00665165f, -0.10184438f, 0.16977224f, 0.01584236f, 0.05146766f, 0.15812056f, 
    0.12533312f, -0.17598444f, 0.22755606f, -0.11895698f, 0.01842912f, -0.06698401f, 0.03666940f, -0.01820220f, 
    0.08011508f, 0.01628484f, 0.13253424f, 0.06187546f, 0.04174368f, 0.06039456f, 0.08771396f, 0.02127263f, 
    -0.26861334f, -0.07837390f, -0.05721288f, -0.10749184f, 0.09965588f, 0.07300875f, 0.13606417f, 0.12773593f, 
    0.10795221f, -0.13704039f, 0.27895316f, -0.02599682f, 0.01864804f, -0.20089215f, -0.03912218f, 0.00197860f, 
    -0.16580771f, -0.09514613f, -0.03419511f, -0.11928876f, -0.18606618f, 0.10655422f, -0.16436417f, -0.18351012f, 
    0.07221020f, -0.09856184f, -0.14398447f, -0.17313375f, -0.08703115f, 0.02418127f, 0.05515319f, 0.07668450f, 
    0.09580313f, -0.12280803f, 0.17213146f, 0.13327120f, 0.10657189f, 0.08087415f, -0.01259845f, -0.06117736f, 
    0.04020702f, 0.01946726f, 0.03349875f, 0.07936113f, -0.12459768f, 0.26453513f, -0.01851731f, 0.21786886f, 
    0.02185251f, 0.02005467f, -0.04904356f, 0.08245532f, -0.12084704f, -0.00002753f, -0.06158366f, -0.15631048f, 
    -0.01318246f, -0.18797591f, 0.07499638f, 0.15871096f, -0.04752349f, 0.12831900f, 0.12867588f, 0.34227446f, 
    -0.03975211f, -0.00534086f, 0.01807310f, -0.00170563f, -0.08436880f, 0.07819074f, -0.05116609f, -0.05215551f, 
    -0.03013768f, -0.06463385f, -0.16737850f, -0.15547000f, -0.05417836f, 0.14196725f, 0.16358219f, 0.05995456f, 
    -0.03858720f, 0.01834923f, -0.01750018f, -0.04852384f, 0.04209432f, 0.06538048f, -0.03467034f, 0.10397455f, 
    0.01644293f, 0.03161609f, 0.13573588f, 0.03800954f, 0.40432978f, 0.26065210f, 0.05368444f, 0.03938005f, 
    0.15812775f, 0.02519086f, -0.13442424f, 0.05400496f, 0.07748090f, -0.09695371f, -0.02269878f, -0.16484134f, 
    0.05611325f, 0.31703100f, -0.17007896f, -0.00448254f, 0.02886403f, -0.10936166f, -0.08068123f, -0.13163494f, 
    -0.09560218f, 0.20615253f, 0.02145276f, 0.22562754f, -0.09555898f, 0.03142035f, 0.16697428f, 0.13337417f, 
    -0.07119849f, 0.07618707f, 0.01905520f, 0.28287935f, 0.01830792f, 0.05975908f, 0.10596409f, -0.01872660f, 
    -0.25423661f, -0.11009365f, -0.05260100f, -0.20806891f, 0.03809145f, 0.00823152f, -0.05566712f, -0.05907140f, 
    0.01404528f, 0.08530246f, 0.06326427f, 0.01634989f, -0.37510067f, 0.24636917f, -0.11581881f, 0.11352570f, 
    -0.02803071f, -0.05819045f, 0.09218895f, -0.08300435f, -0.12342726f, -0.02620080f, 0.07839185f, 0.07013716f, 
    -0.03017466f, -0.07365587f, 0.28744403f, -0.05966186f, 0.06035957f, 0.00865878f, 0.01208978f, 0.04336615f, 
    0.09660812f, 0.03565775f, 0.22239006f, 0.14601345f, 0.08225621f, 0.14039561f, 0.43724817f, 0.10376067f, 
    0.15727781f, 0.04185928f, 0.05338936f, -0.11955515f, 0.07440247f, -0.08053483f, 0.08261474f, 0.08125152f, 
    0.08841629f, -0.09440677f, -0.10122406f, -0.10878330f, -0.04131744f, -0.04303826f, 0.01473142f, -0.03507005f, 
    0.19008830f, 0.07307852f, 0.04094672f, -0.10914549f, 0.07489060f, -0.17567232f, 0.33819094f, 0.06251664f, 
    -0.07452272f, -0.07232765f, -0.04061095f, 0.10305243f, -0.05397106f, -0.01382977f, -0.15319951f, 0.05291282f, 
    0.08661892f, 0.22518171f, 0.18886897f, -0.01388565f, -0.03382583f, -0.04456370f, -0.07755357f, -0.04667586f, 
    0.02042989f, 0.03538391f, 0.00665405f, 0.01670518f, -0.02828234f, 0.17919526f, -0.30923989f, -0.14179826f, 
    0.02996751f, -0.05892627f, 0.03729953f, -0.01602006f, -0.03751681f, 0.02116897f, 0.02184686f, -0.08518758f, 
    0.08119299f, 0.19811733f, 0.42591980f, 0.12846602f, -0.13559234f, 0.07083902f, 0.06219814f, -0.06408041f, 
    -0.01909170f, 0.10679692f, 0.04382156f, 0.10828114f, 0.22506079f, -0.04417534f, 0.20846939f, 0.31797633f, 
    0.11588614f, 0.05925780f, 0.25155437f, 0.13826342f, 0.15048099f, 0.09786049f, 0.15566821f, 0.28018492f, 
    -0.01927425f, -0.01083204f, 0.05316279f, 0.23382977f, -0.02659185f, 0.03065689f, 0.08092148f, 0.00670453f, 
    0.03816699f, -0.04212660f, -0.04730196f, 0.01689433f, 0.14628053f, 0.38338855f, 0.08334936f, 0.20715573f, 
    -0.01085817f, 0.00882236f, 0.16762057f, 0.12710884f, 0.04727700f, 0.06936388f, 0.10886294f, -0.06548642f, 
    0.21091317f, 0.01679689f, 0.19746637f, -0.05698312f, -0.02251020f, 0.06416001f, 0.04684772f, -0.00812149f, 
    -0.05058049f, 0.04955794f, -0.07260899f, 0.00347049f, -0.16204993f, 0.23156068f, -0.15296608f, 0.01335856f, 
    0.10675433f, 0.17259091f, 0.10023034f, -0.03275934f, 0.09840986f, 0.02488833f, 0.04369333f, -0.05367058f, 
    0.13544899f, -0.03087585f, 0.05516822f, 0.17137298f, -0.10516204f, -0.00359003f, 0.02870028f, -0.08888169f, 
    -0.04993902f, 0.05309765f, -0.12790352f, -0.07991181f, 0.12094102f, 0.05239650f, 0.13851364f, 0.14180547f, 
    0.00797793f, -0.07545602f, 0.07590108f, 0.03169729f, -0.08251488f, 0.11738969f, -0.01800935f, 0.07231674f, 
    0.12757312f, 0.20604181f, 0.26020694f, 0.06487380f, -0.00055312f, 0.12298835f, -0.00469583f, 0.02361369f, 
    0.08073100f, 0.01115130f, 0.01595483f, -0.01540651f, -0.14836323f, 0.32099807f, -0.11149709f, 0.00652917f, 
    0.13963801f, 0.03204104f, 0.08692615f, -0.14517322f, -0.03201834f, 0.08149469f, 0.11946321f, 0.12359072f, 
    -0.26567939f, 0.07478509f, -0.18747392f, 0.01289103f, -0.00955850f, 0.00782724f, 0.03166331f, -0.11396110f, 
    -0.04039903f, -0.02447214f, 0.06628732f, 0.24664962f, 0.34688449f, -0.10493333f, 0.22375245f, -0.25370100f, 
    -0.09929518f, 0.04338795f, -0.01198376f, 0.08729135f, -0.17651403f, -0.02627671f, -0.03769448f, -0.01590735f, 
    0.04103720f, 0.14532566f, 0.02192804f, 0.26456824f, 0.00115275f, -0.03368868f, 0.02928918f, -0.01564559f, 
    0.20879865f, 0.07879905f, 0.17440023f, 0.32017568f, 0.07019857f, 0.06991979f, 0.10666404f, 0.05912404f, 
    -0.05049076f, -0.08913319f, -0.08866627f, 0.09594055f, 0.12324622f, -0.02680103f, 0.01820289f, -0.04098954f, 
    -0.08830611f, 0.07798106f, 0.17807968f, 0.05397863f, -0.03627910f, -0.09794515f, 0.11167454f, 0.04492901f, 
    -0.06046074f, 0.06568182f, 0.07216121f, 0.22611900f, 0.11660888f, -0.09416582f, 0.06884626f, 0.06932251f, 
    -0.07930645f, -0.05701488f, -0.11717234f, -0.14308202f, 0.17452320f, 0.26438737f, 0.08090750f, 0.09265672f, 
    0.20040795f, 0.25782004f, 0.23374210f, 0.07742610f, -0.10453811f, -0.10018444f, 0.03094127f, -0.17993860f, 
    0.04384851f, 0.11300221f, 0.09870870f, 0.11641763f, 0.13473837f, 0.20309527f, -0.14612640f, 0.00098380f, 
    -0.13463390f, -0.00705075f, 0.01786814f, -0.20340468f, -0.03184837f, 0.05572171f, -0.12766302f, 0.06636838f, 
    0.25065377f, 0.19981420f, -0.10277345f, 0.02838647f, -0.26544577f, -0.02348967f, -0.13601200f, -0.11825369f, 
    -0.01400617f, 0.03633291f, -0.02101203f, -0.09217074f, 0.01765878f, -0.02040199f, 0.37107137f, 0.01386322f, 
    0.23419139f, -0.04892023f, 0.11655024f, 0.12657015f, 0.26506981f, -0.00141305f, 0.16508189f, 0.16745988f, 
    -0.07342683f, -0.12675531f, -0.07133207f, 0.03036200f, 0.02249571f, -0.04544445f, 0.05093440f, 0.18829358f, 
    0.18515433f, 0.14550783f, 0.09052387f, 0.10884535f, -0.02314701f, -0.15711264f, 0.03978424f, -0.14050709f, 
    -0.02975795f, -0.12254161f, -0.19078994f, -0.04848589f, -0.15056732f, 0.18290967f, 0.17867984f, -0.16870108f, 
    0.22734861f, -0.14702007f, -0.03100681f, 0.09393761f, -0.04948153f, 0.16323158f, 0.08903845f, 0.08624969f, 
    0.31867358f, 0.14843962f, 0.18356730f, 0.31618842f, -0.11073253f, -0.00709148f, 0.00766784f, -0.16820146f, 
    0.03854756f, 0.05997182f, 0.03823240f, 0.12075116f, 0.22042869f, 0.09695532f, 0.12959902f, 0.33691239f, 
    -0.20709993f, -0.18348315f, -0.16803446f, 0.04887153f, -0.00269182f, 0.12921908f, 0.01080367f, -0.06124684f, 
    0.03166336f, -0.10232347f, -0.07377108f, 0.01660958f, 0.00974579f, -0.13866489f, -0.06823461f, 0.05140443f, 
    0.19744410f, 0.14483188f, 0.10703702f, 0.08283465f, -0.09343504f, -0.00275553f, -0.00018467f, 0.01390996f, 
    0.06049581f, -0.34677896f, -0.06753704f, -0.17650153f, -0.02160167f, -0.03682766f, 0.04369244f, 0.05055189f, 
    0.25910527f, 0.22754642f, 0.21673103f, 0.19525437f, -0.07893752f, -0.10013274f, 0.15837863f, -0.14776814f, 
    0.17817706f, 0.06334507f, -0.09068926f, 0.08481846f, 0.12088303f, 0.02726157f, -0.01177596f, 0.15807918f, 
    -0.08771469f, 0.00312319f, -0.06147644f, -0.00901607f, -0.00656358f, -0.17446576f, 0.04993606f, -0.02727320f, 
    -0.08891992f, 0.18816303f, -0.02267510f, -0.14570114f, 0.10611045f, -0.04107971f, -0.06801137f, 0.15779893f, 
    -0.03259242f, 0.04168969f, -0.15168144f, -0.08170249f, 0.02363845f, -0.01112920f, -0.09813722f, 0.12243100f, 
    0.18118046f, 0.12814924f, 0.15946542f, -0.01196689f, -0.11216608f, 0.13341738f, 0.06535163f, 0.28620210f, 
    0.09761486f, -0.06187233f, -0.02550115f, -0.05824496f, 0.25739369f, -0.12560080f, 0.02536445f, 0.04836597f, 
    -0.13945101f, -0.05722759f, -0.18835910f, -0.26252675f, 0.02778029f, -0.08058973f, -0.05923490f, -0.11125349f, 
    -0.32565176f, 0.25447026f, 0.14775397f, -0.06311818f, 0.11193261f, 0.02772938f, 0.08866924f, 0.03439525f, 
    0.06195358f, 0.07860967f, 0.06721850f, 0.06239761f, 0.12654886f, 0.01483089f, 0.01563780f, 0.22222252f, 
    0.03150590f, 0.06640597f, 0.10223521f, 0.09883373f, 0.24252209f, 0.14441022f, 0.20128803f, 0.31682855f, 
    0.26358852f, 0.20965107f, 0.29757842f, 0.01196634f, -0.24470522f, -0.06699280f, -0.13637803f, -0.05144909f, 
    -0.01043907f, -0.00057222f, -0.17387891f, -0.17161494f, -0.11095206f, 0.09247053f, -0.14235677f, -0.20784327f, 
    0.04466055f, 0.12754704f, -0.03279908f, -0.06171318f, 0.19878125f, 0.18644463f, 0.09785583f, 0.09202679f, 
    -0.03232570f, -0.00793347f, 0.02841331f, 0.05405751f, 0.13805510f, 0.12314804f, -0.00240559f, 0.04984514f, 
    0.10859447f, 0.16011597f, 0.09967795f, 0.15791801f, -0.01981358f, -0.08291343f, -0.17194082f, 0.01700660f, 
    -0.04397213f, -0.09135576f, 0.23770897f, -0.19880787f, 0.10496173f, -0.20754972f, -0.10373449f, -0.22451971f, 
    0.01110536f, 0.14175573f, -0.06076715f, 0.23633738f, 0.08856894f, 0.05407345f, 0.01926123f, -0.09596884f, 
    -0.14632441f, -0.10283323f, -0.21610245f, -0.22191003f, 0.05310115f, 0.18906178f, 0.10236329f, 0.17375609f, 
    0.05559722f, -0.01074654f, 0.09264576f, 0.16291249f, 0.13279276f, -0.04252581f, 0.03292935f, -0.13463050f, 
    0.03402560f, 0.02382591f, 0.13522333f, 0.04866635f, 0.15685132f, 0.04463983f, -0.10148738f, -0.11341425f, 
    -0.18701032f, -0.28923273f, -0.11305375f, -0.12907772f, 0.08438161f, -0.04078254f, -0.14091352f, -0.03983621f, 
    0.07621474f, 0.03190418f, -0.03695688f, -0.12012491f, -0.20555787f, -0.17622286f, -0.14675991f, -0.19738141f, 
    -0.06095227f, 0.08683011f, 0.15094748f, 0.00866263f, 0.03709826f, 0.05850423f, 0.10164399f, -0.08540753f, 
    -0.00158905f, 0.10823447f, 0.02527952f, 0.28100654f, 0.14247730f, -0.15923558f, 0.12080617f, 0.02408491f, 
    -0.07112276f, -0.04323039f, -0.06154991f, 0.09578436f, -0.04927854f, 0.09126724f, 0.03660579f, -0.11475980f, 
    -0.06149942f, 0.23591802f, -0.04147672f, 0.18307705f, 0.03627290f, 0.09347621f, 0.02470321f, -0.02178938f, 
    -0.17476280f, -0.24078558f, -0.28166565f, -0.17404799f, 0.06490042f, -0.00018197f, -0.13355656f, -0.10401452f, 
    0.10968621f, 0.15915677f, -0.07292490f, -0.12717551f, 0.02767168f, -0.19645391f, -0.15400805f, -0.01631058f, 
    -0.18444729f, 0.09823050f, -0.13800482f, 0.02760668f, -0.07677563f, 0.09677099f, 0.14403886f, -0.01811037f, 
    0.31568342f, 0.09040000f, -0.03271581f, 0.21164985f, -0.15514022f, 0.05021091f, 0.21267501f, 0.00218417f, 
    -0.14047301f, 0.22394347f, 0.01652090f, -0.05953742f, -0.23710130f, -0.14776848f, -0.34950081f, -0.18489863f, 
    -0.04725908f, 0.13216650f, -0.01747183f, 0.25290391f, 0.00891262f, 0.04113040f, 0.00839413f, -0.00241324f, 
    -0.11876779f, -0.05948501f, -0.02465282f, -0.03115505f, 0.10916359f, -0.06403753f, 0.02542358f, -0.04568979f, 
    0.16253527f, 0.12970920f, 0.02414649f, -0.03975743f, 0.13278693f, 0.15562525f, 0.02016448f, 0.25571096f, 
    0.24925601f, 0.23932357f, 0.12471814f, 0.16723107f, 0.09613448f, -0.10704050f, -0.04742597f, 0.04300775f, 
    0.24864271f, 0.12163784f, 0.07084477f, 0.12150493f, 0.03949694f, -0.20468904f, -0.01817345f, -0.06349116f, 
    -0.05003716f, 0.02975853f, 0.12736292f, 0.02780133f, 0.01732512f, -0.13805024f, -0.15094832f, -0.16838548f, 
    0.08732218f, 0.22123674f, 0.14222179f, -0.00878910f, -0.06618588f, -0.05770401f, -0.06149678f, -0.12038039f, 
    -0.18301493f, -0.06194786f, -0.19377820f, -0.21300144f, -0.07669006f, -0.05589250f, 0.04306081f, 0.08199891f, 
    -0.04119515f, -0.07295579f, 0.07393686f, 0.09758084f, -0.00148776f, 0.07125559f, 0.04850104f, 0.13399243f, 
    -0.11710745f, 0.00177424f, 0.26413852f, 0.05265213f, 0.03588821f, 0.20592804f, -0.00069017f, -0.07833882f, 
    -0.13114862f, -0.34963715f, -0.10626493f, -0.43107939f, 0.08372533f, 0.06091475f, -0.19704802f, -0.13063729f, 
    0.06364433f, 0.03168838f, -0.00917330f, -0.02917317f, -0.05396290f, -0.18723434f, -0.18810250f, -0.01973716f, 
    0.33785561f, 0.21966626f, -0.02235892f, -0.04621004f, -0.22369035f, -0.09182473f, 0.04479497f, -0.04270618f, 
    0.02189002f, -0.09212280f, -0.07946167f, -0.11247478f, 0.17299217f, 0.08489026f, 0.05866291f, 0.02623384f, 
    -0.22086249f, 0.10062298f, -0.30616361f, -0.01143708f, 0.20155561f, 0.03434711f, 0.01408475f, 0.09967342f, 
    -0.04169082f, 0.01181965f, -0.10950050f, 0.01973148f, 0.03796317f, -0.00710539f, -0.16339086f, -0.12711371f, 
    -0.06915496f, -0.17952400f, -0.16387117f, -0.23476043f, -0.05506819f, 0.05137362f, -0.25928429f, 0.14194977f, 
    -0.09451960f, -0.09198146f, -0.04756251f, -0.05562825f, 0.05268705f, 0.06136528f, 0.04964394f, 0.14420538f, 
    0.39169508f, 0.23229596f, 0.12557659f, -0.07376330f, -0.18230206f, -0.20407015f, -0.13775434f, -0.24537954f, 
    -0.05514282f, 0.05315320f, -0.05720545f, -0.06114779f, -0.15711570f, 0.12289235f, -0.26169720f, 0.03729270f, 
    0.07971717f, -0.17297678f, 0.06819818f, -0.06934670f, 0.16573191f, 0.04319689f, 0.09417843f, 0.12344027f, 
    -0.14278913f, -0.01913309f, -0.15500881f, 0.14031431f, -0.14901274f, 0.05465750f, 0.08672074f, -0.23380575f, 
    0.00723778f, 0.03485714f, 0.09426645f, 0.21247512f, 0.37514672f, 0.25892019f, 0.21088733f, 0.24651274f, 
    -0.23036766f, -0.03954449f, -0.10777114f, -0.09010974f, 0.10459486f, 0.03261259f, 0.00257265f, 0.21198423f, 
    0.07218190f, -0.19025208f, -0.21840765f, 0.02147317f, -0.03213459f, -0.09037413f, -0.07220985f, -0.04096963f, 
    0.04578406f, -0.10867133f, 0.06637696f, 0.00084375f, 0.03286523f, 0.03559371f, 0.03702538f, -0.03472500f, 
    0.03691534f, -0.02961744f, 0.04452428f, 0.15220526f, -0.08529235f, 0.02014728f, -0.01654556f, -0.37012824f, 
    0.00073426f, -0.06329692f, 0.00750797f, -0.00903970f, 0.08060138f, 0.05343175f, -0.03329094f, 0.24862431f, 
    0.04590775f, 0.09770259f, 0.11294183f, 0.05241039f, -0.09800880f, -0.03253362f, -0.07324611f, -0.02266242f, 
    -0.06436741f, 0.07016184f, -0.23769514f, 0.02752228f, -0.01398270f, -0.13062786f, -0.09359819f, -0.10946740f, 
    -0.07952899f, -0.03232046f, -0.07823348f, -0.01756306f, -0.01269283f, -0.07626867f, 0.02405485f, 0.04553283f, 
    -0.05414436f, -0.13088794f, 0.01256711f, -0.03161104f, 0.05231412f, -0.19243674f, 0.14062725f, 0.06804760f, 
    0.01740387f, 0.11130577f, -0.24941097f, 0.12757359f, -0.00880751f, 0.11351382f, 0.00016769f, 0.00752439f, 
    -0.06292557f, 0.08276300f, -0.27025193f, 0.13693181f, -0.02432416f, -0.05587336f, 0.17401867f, 0.06868380f, 
    0.19250023f, 0.01637792f, 0.19977091f, 0.09013221f, -0.14713985f, -0.09144779f, -0.17575818f, 0.05450556f, 
    0.02711670f, 0.12702532f, 0.04375797f, 0.00662103f, -0.05202392f, -0.18022789f, -0.12755996f, -0.07551470f, 
    0.00588748f, 0.04752498f, -0.08967096f, 0.08769606f, 0.04895195f, 0.01527422f, 0.02013337f, 0.09244332f, 
    0.03006911f, 0.16118264f, 0.02947435f, -0.02928422f, 0.13910729f, -0.28530413f, -0.07458120f, 0.04109480f, 
    -0.11016823f, 0.11666306f, -0.09714437f, -0.08352048f, -0.19476323f, -0.20650111f, -0.18203782f, -0.05340724f, 
    0.11981276f, 0.07717727f, 0.25072396f, 0.04462776f, 0.03139780f, 0.07220029f, -0.03237271f, -0.07816059f, 
    -0.02931190f, 0.04867523f, 0.01484290f, -0.06544003f, 0.16810565f, 0.30364460f, -0.02599717f, 0.23504023f, 
    -0.01815410f, -0.16753548f, 0.08630496f, -0.18022823f, 0.09907317f, -0.13160767f, -0.04182952f, 0.19025636f, 
    -0.07278735f, -0.00643958f, 0.16531685f, -0.20264010f, 0.01073787f, 0.00169879f, 0.00851343f, 0.09070823f, 
    -0.07181777f, -0.05849503f, 0.03513408f, 0.13200392f, 0.01535047f, 0.32694718f, 0.09088425f, -0.05124473f, 
    0.03337297f, -0.02174894f, 0.07598101f, -0.05963554f, 0.00567250f, -0.02636212f, 0.02773356f, -0.02874289f, 
    -0.09319858f, 0.02644565f, -0.04452262f, -0.00621503f, -0.03552432f, -0.06185208f, -0.03188932f, -0.04814939f, 
    0.04785754f, -0.02978375f, 0.01823733f, -0.09939895f, -0.05101221f, -0.02560900f, -0.01283645f, 0.30919683f, 
    0.03340930f, -0.02317367f, 0.03745013f, 0.02927018f, 0.04036345f, 0.00884467f, 0.00417510f, 0.00165586f, 
    0.03076343f, -0.07176042f, 0.08467938f, -0.39250004f, -0.08683138f, -0.01701931f, -0.05395341f, 0.00271000f, 
    0.06405012f, 0.05141682f, 0.07787946f, -0.01415629f, -0.12419496f, -0.15507123f, 0.03855696f, 0.22780600f, 
    -0.11113603f, 0.00760082f, 0.02848795f, -0.06327856f, 0.12741688f, 0.04156883f, 0.04806245f, -0.03989286f, 
    -0.10094400f, -0.05339233f, -0.04716644f, 0.17282259f, -0.03372500f, 0.09581041f, 0.09856781f, 0.00724892f, 
    0.11674979f, -0.09785166f, -0.09823807f, 0.01338523f, 0.30887941f, 0.08516137f, -0.20576604f, -0.26081002f, 
    -0.12442631f, -0.09234516f, -0.02520928f, -0.02387367f, -0.09127127f, 0.05260237f, 0.01098279f, -0.00702212f, 
    0.19168399f, -0.12418279f, -0.08386908f, 0.02220171f, -0.00278231f, -0.09091847f, 0.08036568f, -0.00281418f, 
    0.05370576f, -0.03635835f, 0.06483071f, 0.06020435f, 0.13300933f, -0.02812381f, 0.00105066f, 0.12770890f, 
    -0.05318630f, 0.09750839f, 0.02228947f, -0.14377758f, 0.03266913f, 0.16333255f, -0.05604874f, 0.00981799f, 
    -0.15704508f, -0.05755210f, -0.02123326f, 0.16129658f, 0.02368127f, 0.07458240f, -0.06995995f, -0.03134450f, 
    -0.08748712f, -0.04671048f, 0.00386314f, 0.01619955f, 0.05024997f, 0.07827765f, -0.06198670f, -0.16991177f, 
    -0.04784396f, -0.04099194f, -0.08850689f, -0.01227790f, 0.13207908f, -0.05739042f, 0.12103618f, 0.06627657f, 
    0.33536363f, 0.14493126f, -0.03045812f, 0.18712437f, 0.04849729f, -0.08313746f, -0.02152811f, 0.03954605f, 
    -0.00230520f, 0.00631300f, -0.01446296f, 0.03313855f, 0.08132420f, 0.10467593f, -0.01426893f, 0.14409418f, 
    0.13645133f, -0.02105037f, -0.04243415f, 0.01757411f, 0.01944009f, 0.09617036f, 0.05466499f, -0.00868539f, 
    0.16870616f, -0.00027327f, -0.13509515f, 0.19646798f, -0.02526570f, 0.10896326f, 0.07420547f, -0.08469606f, 
    0.14178471f, -0.03977226f, -0.03177449f, -0.03984076f, 0.01852479f, -0.39698309f, 0.32394680f, -0.03496971f, 
    0.12111860f, 0.11468895f, -0.00882405f, 0.01108522f, 0.07997933f, -0.02726018f, 0.03268782f, -0.06181059f, 
    0.37921450f, -0.03135268f, 0.20714457f, -0.16268110f, -0.06202985f, 0.04149895f, 0.09605297f, -0.03545923f, 
    -0.09423923f, -0.00361332f, -0.16981536f, 0.15113142f, -0.16014476f, -0.35723069f, 0.11025785f, 0.06162738f, 
    0.06382174f, 0.01267699f, 0.03150136f, 0.12415871f, 0.03367461f, -0.16795488f, 0.11589240f, 0.03681060f, 
    -0.02127404f, -0.11200181f, 0.13041712f, -0.05698715f, 0.03552897f, -0.01460621f, 0.08526028f, -0.10046452f, 
    -0.07640342f, -0.09351277f, 0.14802590f, -0.07157677f, 0.11346890f, -0.15778759f, -0.06097731f, 0.25270423f, 
    -0.01270808f, 0.03306108f, -0.04359021f, 0.01846676f, 0.11495949f, 0.00928938f, -0.00315939f, -0.13754970f, 
    0.02406308f, -0.14818567f, 0.53578973f, -0.24593198f, 0.03846363f, 0.02749446f, 0.07369376f, -0.11998861f, 
    -0.03044454f, 0.02894850f, -0.02403973f, 0.03278101f, -0.32674414f, 0.02399204f, 0.07829747f, 0.22445524f, 
    0.10700972f, 0.04129104f, -0.20533217f, 0.10216106f, 0.00605555f, -0.07515524f, 0.10235284f, 0.18284445f, 
    -0.11433990f, 0.02863613f, 0.03812486f, 0.36685309f, 0.05511923f, -0.02498328f, -0.04373118f, -0.03337348f, 
    -0.20361285f, 0.02278076f, 0.02321040f, 0.06109449f, -0.12995321f, 0.05021291f, 0.15005501f, -0.04740581f, 
    0.00941358f, 0.04064874f, -0.00515326f, -0.02953233f, 0.12540632f, -0.03719220f, -0.06621563f, -0.12305794f, 
    0.04879533f, 0.10724655f, 0.13111848f, -0.08307560f, 0.05791755f, -0.05600699f, 0.00681056f, -0.10632241f, 
    0.05526462f, 0.08433688f, -0.05778223f, -0.05313975f, -0.27032202f, 0.02638800f, -0.09054245f, 0.24644575f, 
    0.08148443f, 0.05508565f, -0.08234596f, 0.00778211f, -0.23330818f, 0.16805510f, -0.10448311f, -0.00963439f, 
    -0.06432371f, 0.11768595f, 0.11529279f, 0.07180651f, 0.03669022f, -0.01590193f, 0.00769817f, 0.08201467f, 
    -0.01607177f, 0.02996633f, 0.05299427f, -0.11024386f, 0.08244798f, 0.29742733f, -0.02772163f, -0.06285065f, 
    -0.07991600f, -0.14022674f, 0.05319742f, 0.08374387f, -0.00868076f, -0.01026390f, -0.09856339f, 0.02626492f, 
    0.27942255f, 0.13370265f, -0.01715801f, -0.03353310f, 0.05195384f, -0.01994863f, 0.07638060f, 0.12123385f, 
    -0.15763758f, 0.03724987f, -0.07824372f, -0.18314271f, 0.15829152f, -0.07284373f, -0.00314506f, -0.17698558f, 
    -0.08962011f, 0.00158501f, 0.01635673f, -0.00265421f, 0.04423531f, 0.03756301f, -0.04034936f, -0.13499138f, 
    0.23426472f, -0.01483814f, 0.11872387f, 0.01540069f, 0.03492193f, -0.04513700f, 0.09100685f, -0.05222978f, 
    0.10490903f, 0.07682592f, -0.05444896f, 0.06442723f, -0.06574125f, -0.35515907f, 0.14217687f, 0.16861498f, 
    0.04670825f, 0.04658716f, 0.15557265f, -0.02111769f, 0.20445585f, -0.00024401f, -0.03888293f, -0.03212802f, 
    -0.12314517f, -0.02045618f, 0.02811326f, 0.00595387f, -0.04941366f, 0.01191177f, 0.00626459f, -0.00814785f, 
    0.04198026f, -0.06915588f, 0.03742078f, 0.03797781f, 0.04380674f, 0.02137224f, 0.09822071f, 0.02284609f, 
    -0.04963148f, 0.05221001f, -0.04862580f, 0.01494656f, 0.11403023f, -0.08392117f, -0.02696954f, -0.02155764f, 
    0.21177667f, 0.05063158f, -0.10762225f, -0.02982421f, 0.00195690f, -0.00487744f, -0.17306660f, 0.02191582f, 
    0.04753032f, -0.06589512f, 0.20952024f, 0.03586554f, -0.16091585f, 0.16035302f, -0.00309202f, -0.20314550f, 
    -0.04539785f, -0.09861339f, 0.03779838f, -0.02730595f, -0.05205845f, -0.16807652f, 0.04704086f, 0.07854141f, 
    0.27380902f, 0.04903564f, -0.04336121f, -0.10996632f, 0.03978932f, -0.14979522f, -0.07428836f, -0.02790149f, 
    -0.00689394f, 0.02723372f, 0.05532133f, 0.04238882f, 0.00400478f, 0.02855192f, 0.19098885f, 0.23797515f, 
    0.06912546f, 0.12221877f, -0.03008627f, -0.09479122f, 0.12952223f, 0.04391148f, 0.03830399f, -0.00124642f, 
    -0.01578033f, 0.19061801f, 0.09174228f, 0.01563572f, 0.02669233f, 0.05453059f, -0.02425014f, 0.09172695f, 
    0.12018006f, 0.09543263f, -0.10308198f, 0.11360441f, 0.14156741f, -0.07446751f, 0.02308562f, 0.17936707f, 
    0.03561819f, 0.10677392f, -0.05974156f, 0.05727980f, 0.05079287f, 0.04492382f, 0.01497239f, -0.08624820f, 
    0.06864616f, -0.04172518f, 0.04790846f, -0.00664633f, 0.03161570f, 0.00698526f, 0.00640394f, 0.09145809f, 
    0.13321790f, -0.07335699f, 0.01628385f, 0.18099117f, 0.35472155f, 0.31684074f, -0.19886631f, -0.20983730f, 
    -0.07141456f, -0.08930627f, -0.00284192f, 0.03338334f, 0.09720624f, -0.06876996f, 0.03470428f, -0.01160940f, 
    -0.16482583f, 0.09430837f, 0.00090425f, 0.11737286f, 0.09264249f, -0.02468961f, 0.07903449f, 0.08474322f, 
    0.00891784f, -0.07822540f, -0.08232638f, -0.05735919f, -0.07930961f, 0.15727019f, 0.18310985f, 0.11230672f, 
    -0.13506407f, 0.04721807f, 0.00820656f, -0.07910137f, 0.05182809f, -0.02136454f, 0.10708171f, -0.03957332f, 
    -0.38776886f, 0.09946224f, -0.10497323f, -0.24738358f, -0.01796637f, 0.02421874f, -0.06837902f, -0.01271731f, 
    0.03553664f, 0.03663964f, -0.02082233f, 0.10839732f, -0.23447829f, -0.26274639f, 0.05435935f, 0.52026427f, 
    0.07219706f, -0.11977000f, -0.00661979f, 0.07209344f, 0.07147950f, -0.14098385f, 0.02180601f, 0.00324304f, 
    -0.02366374f, -0.13374256f, 0.16984510f, -0.10133573f, 0.12491630f, 0.00395052f, 0.06096060f, 0.00689443f, 
    0.07380651f, -0.15725499f, 0.14214914f, -0.05849139f, -0.36304134f, 0.03704583f, 0.17738789f, -0.04886957f, 
    0.16894208f, -0.04318795f, 0.06740005f, -0.06784670f, 0.15053426f, 0.03299915f, 0.05026343f, -0.02247022f, 
    0.28123167f, -0.11598644f, -0.12791994f, -0.09599125f, 0.01866439f, -0.04797558f, 0.02449277f, -0.10793129f, 
    -0.02405332f, 0.01145465f, 0.03823576f, -0.05647308f, 0.13886382f, -0.09879863f, -0.01835458f, -0.08207855f, 
    0.05406675f, -0.00481314f, 0.02601368f, 0.09815720f, 0.02887777f, 0.01304180f, -0.10787880f, 0.12015663f, 
    -0.03662090f, -0.20827264f, 0.06633632f, 0.21151154f, 0.09179717f, 0.01180521f, -0.02282081f, -0.04678178f, 
    0.03251525f, -0.01901447f, 0.13446796f, 0.02742369f, 0.15383588f, 0.06944264f, -0.13143523f, 0.00267115f, 
    -0.05708846f, -0.15838233f, 0.03112676f, -0.06635743f, -0.15749139f, -0.10876449f, -0.01466263f, -0.07259089f, 
    0.12506066f, -0.04863925f, 0.17662825f, -0.13119647f, -0.11799960f, 0.09916793f, 0.03680854f, 0.00571171f, 
    -0.03689887f, 0.04687310f, 0.00213136f, 0.02081968f, 0.14825256f, -0.02807285f, -0.19188555f, -0.05346774f, 
    0.06154307f, -0.04938434f, -0.02022278f, 0.07509017f, 0.06007883f, 0.03695098f, -0.06173356f, 0.05309891f, 
    0.13750216f, 0.03729029f, 0.16989881f, -0.11139029f, -0.02786692f, -0.04711451f, 0.09366109f, -0.01216376f, 
    0.07620747f, -0.03853118f, -0.04218498f, 0.03319301f, 0.06986449f, 0.06313282f, 0.18461187f, -0.01024934f, 
    0.06741464f, 0.00395447f, 0.06971858f, 0.10667463f, 0.09375662f, -0.20416963f, 0.11634794f, -0.05255168f, 
    -0.32715932f, 0.32636333f, 0.03304137f, -0.37879956f, -0.02099042f, 0.04152012f, -0.04846013f, -0.01252416f, 
    0.02868303f, -0.03206481f, -0.07219379f, -0.04654870f, 0.14309266f, -0.18484099f, 0.13207397f, 0.04796448f, 
    -0.12012382f, -0.03516807f, 0.04948314f, 0.03692993f, 0.05137427f, -0.06209093f, -0.00425681f, 0.02677941f, 
    -0.18789931f, -0.13870223f, -0.17779602f, 0.16605581f, -0.04139301f, -0.07124535f, 0.08752413f, 0.03826030f, 
    0.12196670f, -0.15417199f, -0.07790495f, 0.09331756f, 0.41639894f, 0.04808236f, -0.06993878f, -0.05116900f, 
    -0.00935504f, -0.02973844f, 0.06625400f, -0.12046485f, -0.06858505f, -0.01147349f, -0.02050728f, -0.03161536f, 
    -0.08611540f, 0.22972427f, 0.15132329f, 0.04150996f, 0.08884538f, 0.03492925f, 0.07733154f, 0.05843014f, 
    0.00840472f, 0.01198012f, 0.04985017f, -0.14801532f, 0.11866232f, 0.11412528f, -0.05699173f, 0.05945054f, 
    0.11663395f, -0.08357979f, 0.05368722f, 0.02411623f, 0.01759784f, 0.07141041f, 0.13114806f, 0.01940845f, 
    -0.18624787f, 0.03612094f, 0.14510545f, 0.34359351f, 0.06289465f, -0.12388545f, -0.00220392f, -0.03237253f, 
    0.01589852f, 0.03996369f, -0.01332451f, 0.00370362f, -0.85426140f, -0.34814617f, -0.13441975f, -0.23192711f, 
    0.04082178f, 0.11049922f, -0.08392441f, 0.17447661f, -0.00181103f, 0.05183430f, 0.07927074f, 0.11179896f, 
    -0.00054676f, -0.03446218f, -0.02966784f, -0.00072218f, -0.02189271f, 0.01147526f, 0.00734687f, 0.02074944f, 
    -0.01868233f, -0.01992594f, 0.00709575f, -0.00484355f, 0.02144784f, -0.03114180f, -0.01391566f, 0.00695872f, 
    -0.02351880f, 0.00490565f, 0.01036802f, -0.02330432f, -0.03912271f, -0.01957815f, -0.01571249f, 0.00599542f, 
    -0.00937345f, 0.02945260f, -0.02702388f, -0.02680397f, -0.03742364f, -0.01887567f, -0.01712482f, -0.00907057f, 
    -0.01533924f, 0.02560070f, 0.02317956f, 0.02509123f, -0.01857425f, -0.02547685f, 0.02935927f, -0.00543891f, 
    0.01279105f, -0.03730739f, 0.02698127f, 0.00150444f, -0.00149327f, 0.02124441f, -0.03138732f, -0.01992015f, 
    0.00659310f, -0.01964728f, -0.00566779f, -0.01206381f, -0.04117515f, 0.00134989f, -0.00319581f, -0.01740282f, 
    0.00183358f, -0.02129920f, 0.02936130f, 0.03063053f, -0.02693886f, -0.00094391f, -0.03398186f, -0.03449776f, 
    0.01764371f, -0.00141746f, -0.02119028f, 0.03086105f, -0.02317667f, -0.01869126f, 0.01686748f, -0.02567563f, 
    0.01977982f, -0.02161722f, -0.03803230f, 0.00452221f, -0.01891710f, 0.00144711f, 0.02221831f, -0.03015166f, 
    -0.03152005f, -0.02585763f, 0.01705382f, -0.01927251f, -0.01369360f, 0.02251453f, -0.01580496f, 0.02611023f, 
    0.01661931f, 0.03180123f, 0.00115884f, 0.03076339f, -0.03291805f, 0.02872087f, 0.02216921f, -0.02167691f, 
    -0.02330616f, 0.00154740f, 0.02322539f, -0.00525049f, 0.01628664f, 0.01510745f, 0.01384316f, -0.01830680f, 
    0.01371527f, 0.00203147f, -0.02000964f, -0.02318128f, 0.03563502f, 0.02829921f, 0.00946462f, -0.00793259f, 
    -0.01185823f, 0.02558905f, 0.00922552f, -0.02772889f, 0.02488293f, -0.03383743f, 0.00439074f, 0.01599029f, 
    -0.01233182f, 0.02015898f, -0.01489350f, 0.01346173f, -0.00981824f, 0.00680956f, 0.02934773f, 0.01673173f, 
    -0.02778358f, -0.02505821f, -0.02680041f, -0.01869579f, -0.01748889f, 0.01032396f, 0.01287953f, -0.03762348f, 
    -0.01699664f, 0.03113450f, -0.02744092f, -0.02597983f, -0.03695438f, -0.03546144f, 0.01805332f, -0.00658696f, 
    0.01767247f, -0.01805431f, 0.00702109f, -0.02253374f, 0.02071554f, -0.00125811f, -0.00985538f, -0.00480571f, 
    -0.03858587f, -0.00695809f, -0.00399080f, 0.00939214f, -0.02457095f, -0.01558876f, -0.01105985f, -0.00902074f, 
    0.03636029f, 0.00783334f, -0.00440759f, -0.00019413f, 0.00077551f, 0.02645900f, 0.00728006f, -0.01043297f, 
    0.00464122f, -0.00663744f, -0.04068800f, 0.00790718f, 0.01994969f, -0.01358834f, -0.02075447f, 0.01804234f, 
    -0.04104685f, -0.00049663f, -0.02768048f, 0.01764315f, -0.00879862f, -0.00776560f, -0.01158001f, 0.02700828f, 
    0.02977101f, -0.02460928f, -0.00079776f, -0.00394002f, -0.04334456f, 0.02973846f, 0.01627364f, 0.03220958f, 
    -0.01442280f, -0.02708226f, 0.00960422f, 0.02426683f, 0.01423456f, -0.03121334f, -0.02225291f, -0.01643248f, 
    -0.00096840f, -0.02857736f, 0.02772395f, 0.02251887f, -0.02271223f, -0.02180212f, 0.00573782f, -0.00790311f, 
    -0.01704474f, -0.01382137f, -0.01568990f, 0.00163206f, -0.00162039f, 0.02738726f, -0.02291695f, 0.02549968f, 
    -0.00821084f, 0.02523169f, 0.00759020f, -0.00246042f, 0.01986750f, 0.01172783f, -0.00843827f, -0.01535672f, 
    -0.00181075f, -0.01662247f, -0.02126653f, 0.02537563f, 0.02235860f, 0.00623742f, 0.02606853f, -0.02251427f, 
    -0.03348067f, -0.00429151f, -0.02265684f, 0.01245213f, 0.03576757f, 0.02798117f, 0.01723286f, -0.00227670f, 
    -0.03262393f, 0.01290873f, 0.00652614f, -0.00586318f, -0.00339926f, -0.00919583f, 0.01276154f, -0.01429102f, 
    -0.03345821f, 0.02871943f, 0.01782985f, -0.04575133f, -0.01481305f, 0.01271804f, -0.02543611f, 0.01666251f, 
    -0.01617301f, -0.03045329f, -0.01453394f, -0.00566507f, -0.00909106f, -0.02065585f, -0.02618326f, 0.03795067f, 
    -0.01340177f, -0.02279735f, -0.02178717f, -0.01200646f, -0.02428858f, -0.03172303f, -0.03770006f, -0.00218378f, 
    0.00349761f, -0.02096354f, -0.02128747f, 0.00061594f, -0.01432780f, 0.02104235f, -0.03433936f, 0.00912243f, 
    -0.00092333f, -0.01089174f, 0.01811021f, -0.03727541f, 0.01030320f, 0.02073942f, 0.02261015f, 0.01074468f, 
    0.00619571f, -0.00681362f, -0.02553270f, 0.01565314f, 0.00798574f, 0.00788729f, -0.00279492f, -0.01087680f, 
    -0.02581711f, -0.02928354f, 0.03158884f, 0.02973179f, 0.00041111f, 0.01346098f, -0.00839542f, -0.02187383f, 
    -0.02274112f, 0.01870982f, -0.03968509f, 0.02610544f, 0.00682962f, -0.02101182f, 0.00907773f, -0.03717292f, 
    0.02225079f, -0.00756691f, -0.00302994f, -0.01625108f, -0.02423694f, -0.00972726f, 0.01584675f, -0.01364434f, 
    -0.02115622f, 0.00581835f, -0.02631553f, -0.02376530f, -0.03490429f, -0.01945743f, -0.02273369f, -0.01338119f, 
    0.01287045f, -0.01700757f, -0.00917462f, 0.01187819f, -0.02932690f, 0.01004948f, -0.02926059f, 0.01164862f, 
    -0.02398775f, 0.03390587f, -0.02429712f, 0.00442711f, -0.02757835f, 0.00566618f, -0.02785835f, 0.01771494f, 
    0.01997671f, -0.03802194f, -0.00022307f, -0.01345980f, 0.00163151f, 0.02682815f, 0.00795773f, -0.00851971f, 
    0.02341107f, 0.00350538f, 0.02469176f, 0.01089353f, 0.02743240f, 0.02165193f, -0.02529376f, 0.02645551f, 
    -0.03600218f, 0.02120500f, -0.01085681f, 0.03219550f, -0.00991691f, 0.01360342f, 0.00445671f, 0.00626976f, 
    -0.00490306f, 0.00720763f, 0.02014064f, -0.01827303f, 0.01548839f, -0.03081548f, 0.01254523f, 0.02711603f, 
    -0.00670488f, -0.02308003f, -0.02129954f, -0.01514472f, 0.03073130f, 0.02152771f, -0.03255332f, -0.02998534f, 
    0.03081388f, -0.02314088f, 0.00464868f, -0.01749907f, 0.00931880f, 0.00215267f, -0.01228446f, -0.00552743f, 
    -0.03135140f, 0.00976490f, 0.00557430f, 0.02290826f, -0.00625001f, -0.01560879f, -0.02795858f, -0.00020747f, 
    0.01033013f, 0.00684123f, 0.03523090f, -0.04107623f, 0.01101157f, -0.02404332f, -0.03786924f, -0.03446002f, 
    0.01061071f, 0.00891202f, -0.01997106f, 0.00982412f, -0.01200995f, -0.00584654f, 0.00785662f, 0.01486223f, 
    -0.02894641f, -0.00088904f, -0.00917857f, -0.01204639f, -0.03305170f, -0.00358022f, -0.01721855f, 0.01459222f, 
    0.00578778f, -0.00320330f, 0.00643422f, 0.01441703f, -0.03663998f, 0.02105500f, 0.01038524f, -0.02374705f, 
    0.00248547f, -0.01476251f, -0.02376562f, 0.00042287f, -0.01044777f, 0.02577642f, 0.02184763f, 0.01730909f, 
    0.02392223f, -0.03900346f, -0.03083558f, 0.01408560f, -0.01632823f, -0.03353324f, -0.03670083f, 0.02375210f, 
    0.00384358f, 0.01384100f, 0.03306799f, -0.02545827f, -0.03479663f, -0.04142488f, -0.01315119f, 0.00749772f, 
    -0.02166888f, 0.02024143f, -0.03088561f, -0.00622236f, 0.00091722f, 0.02337973f, 0.00516071f, 0.02507784f, 
    -0.02892299f, -0.00937971f, 0.00984740f, -0.01873874f, -0.01619623f, -0.01280652f, -0.01512423f, 0.01850764f, 
    -0.02277624f, 0.01874838f, 0.00621840f, 0.00767546f, -0.04176731f, -0.03386875f, -0.00350289f, 0.01051394f, 
    -0.02671543f, -0.00168443f, -0.03206709f, 0.03359987f, -0.01106797f, 0.02550397f, -0.03469732f, -0.00554478f, 
    0.00359643f, 0.02781460f, -0.00311651f, -0.00081722f, 0.00984075f, -0.02215389f, -0.01480656f, -0.02363108f, 
    -0.01785140f, -0.01062058f, 0.01100051f, 0.01314451f, -0.01621217f, -0.02711681f, -0.03352121f, -0.02476884f, 
    0.02009318f, 0.03230911f, 0.03010200f, 0.02568539f, -0.00910129f, -0.00235738f, -0.02433061f, -0.02317767f, 
    0.00211908f, 0.02337690f, 0.00380153f, -0.01656320f, -0.02763812f, -0.01040962f, -0.01539397f, -0.01472852f, 
    -0.01868271f, -0.00892677f, 0.00434342f, -0.01910313f, -0.00990651f, 0.00585445f, -0.01860767f, -0.01393867f, 
    -0.00893393f, -0.02811579f, -0.03036673f, 0.01693462f, -0.00570743f, -0.02326526f, -0.01296607f, 0.00639103f, 
    0.01508217f, -0.02460679f, -0.03868181f, 0.02877445f, 0.00523305f, -0.00212436f, -0.02054990f, -0.02268258f, 
    -0.00357295f, 0.01002315f, 0.01778459f, 0.00690191f, -0.01621898f, 0.01833257f, 0.00815236f, 0.00899291f, 
    -0.00283725f, 0.00317849f, 0.01159832f, -0.03329740f, -0.01104861f, -0.03109582f, 0.00073317f, -0.01574408f, 
    0.00052428f, 0.02215098f, -0.00563157f, 0.02524995f, 0.01904430f, 0.01845562f, -0.02776407f, 0.00540046f, 
    -0.00720325f, 0.02537551f, 0.01835164f, 0.00673078f, -0.00204851f, 0.01257286f, -0.03061360f, 0.00819807f, 
    0.00274507f, -0.00278169f, 0.01898793f, -0.01126912f, -0.00425142f, -0.03409708f, 0.00907591f, -0.03276490f, 
    0.00175169f, 0.00863398f, -0.03305312f, -0.00443941f, 0.01193755f, 0.02571155f, 0.02097931f, 0.02842442f, 
    -0.03942021f, -0.01751802f, 0.00635150f, 0.02621878f, 0.02071964f, -0.00629447f, 0.01119628f, -0.02899082f, 
    0.02441090f, -0.01316666f, 0.02311332f, -0.01185869f, -0.03945295f, 0.01635138f, 0.00296044f, -0.04458243f, 
    -0.02514074f, -0.00396680f, 0.02653704f, -0.02187259f, -0.00570746f, -0.02652154f, -0.04095138f, 0.01506027f, 
    0.01336970f, -0.00311491f, 0.01477462f, 0.02963225f, 0.00364960f, 0.00330203f, -0.01056886f, -0.01770974f, 
    0.01807996f, 0.00722131f, 0.01024943f, 0.03802812f, 0.02103749f, 0.00404961f, 0.03825969f, 0.00025203f, 
    -0.01715874f, 0.00088706f, -0.04227544f, -0.00945283f, 0.01089975f, -0.00461969f, -0.03560632f, -0.04013950f, 
    -0.00862995f, -0.02950884f, -0.00313856f, -0.00947489f, -0.01919013f, 0.00600293f, 0.00005211f, 0.02569276f, 
    0.02533134f, 0.01422932f, -0.00108821f, 0.00647919f, -0.01745185f, -0.01169056f, -0.01966678f, -0.01890036f, 
    -0.03608223f, -0.02694025f, -0.02195553f, -0.04343779f, 0.01207841f, 0.01595606f, -0.03033091f, 0.00920974f, 
    0.02956408f, -0.01278079f, 0.01442961f, -0.01581649f, -0.03698300f, -0.03662163f, -0.01362469f, -0.00636445f, 
    -0.01767485f, -0.01785815f, -0.03003507f, -0.01024505f, 0.01408942f, 0.02442298f, -0.02719415f, -0.00632468f, 
    -0.01543704f, -0.02316527f, 0.02773485f, -0.02939627f, 0.00396442f, -0.02107696f, 0.01025354f, 0.00643162f, 
    0.01895219f, -0.02341327f, -0.02185824f, -0.01943927f, 0.00479835f, 0.01572210f, 0.00488421f, -0.03054524f, 
    0.02654259f, -0.02640997f, -0.02603575f, 0.00427873f, 0.01885842f, -0.00678164f, -0.03982348f, 0.02210889f, 
    -0.04382905f, 0.00818695f, -0.02820201f, -0.01651270f, 0.01476097f, 0.03805568f, 0.01010790f, 0.00140466f, 
    0.01354566f, 0.04174538f, 0.01159611f, -0.03141327f, -0.03246648f, -0.02546732f, -0.02492526f, -0.01677531f, 
    0.01985361f, -0.02745381f, 0.01957369f, -0.00963132f, -0.02392509f, -0.01537701f, 0.02226832f, -0.03395998f, 
    -0.01013239f, 0.01802436f, -0.04292300f, 0.01413203f, 0.03145970f, 0.01277362f, 0.02668029f, -0.02753624f, 
    -0.03177712f, 0.00667891f, -0.02736109f, -0.03313032f, -0.02681950f, -0.01359665f, 0.02583697f, -0.00596272f, 
    0.00948511f, 0.03822892f, -0.00567256f, 0.02128504f, 0.02236121f, 0.00559498f, -0.02827667f, -0.00143243f, 
    0.02173457f, 0.01495134f, -0.02447018f, -0.03664454f, 0.00754615f, 0.02988122f, -0.01919134f, 0.01853094f, 
    0.01731139f, -0.01771341f, 0.02779061f, -0.03215268f, -0.03408863f, 0.02439978f, -0.02681579f, -0.02075561f, 
    -0.03333609f, -0.00851759f, -0.01060622f, -0.03836131f, -0.01416000f, 0.00682427f, -0.03253597f, 0.02987973f, 
    -0.00526247f, -0.03589106f, 0.02234622f, -0.04101810f, 0.02702261f, -0.00456068f, -0.01600498f, -0.03580028f, 
    -0.04301398f, 0.00096783f, 0.00835172f, -0.00987159f, -0.01729482f, -0.01649864f, 0.00115576f, -0.00614504f, 
    0.01947419f, 0.01869616f, -0.02614521f, 0.02368619f, 0.02596521f, 0.02544745f, 0.00033952f, -0.01762609f, 
    -0.00570617f, -0.02591616f, 0.01595628f, 0.00479961f, -0.00555747f, 0.01500528f, 0.01991016f, 0.00643844f, 
    -0.00296890f, -0.02733629f, 0.00128706f, -0.03895783f, -0.00508557f, 0.01596506f, -0.03660994f, -0.00699583f, 
    0.01540431f, 0.01101922f, -0.00562701f, -0.01103530f, -0.01251543f, -0.00950438f, -0.02725744f, -0.01657078f, 
    0.00742120f, 0.01599514f, -0.01686868f, -0.01141594f, -0.00705721f, -0.03697116f, -0.03962518f, -0.01613774f, 
    0.02391545f, 0.02101153f, -0.00906601f, -0.02283246f, 0.02927544f, 0.02785158f, 0.00662670f, -0.04292376f, 
    -0.01915529f, -0.02098610f, -0.01812628f, 0.00731831f, -0.02533183f, -0.03315431f, 0.01273456f, -0.00698102f, 
    -0.02416945f, -0.00280993f, -0.01973128f, -0.02612050f, 0.01638427f, -0.02798994f, 0.02692240f, 0.00832851f, 
    -0.03814650f, 0.02454504f, -0.03536905f, -0.00601320f, 0.02445728f, -0.03026750f, -0.04081068f, -0.03431987f, 
    -0.01987785f, 0.02833396f, -0.00025089f, -0.00290699f, -0.03510070f, -0.03480045f, 0.02390694f, -0.04156751f, 
    -0.03178501f, -0.03769733f, 0.02405626f, 0.02076720f, -0.03722713f, -0.01152641f, 0.02717370f, -0.04103308f, 
    -0.03460941f, -0.03962155f, -0.00989333f, 0.00371407f, -0.01392157f, 0.01335588f, 0.00933570f, -0.03914898f, 
    0.02180183f, -0.01672596f, -0.02365426f, 0.00523296f, 0.00721234f, -0.03409924f, -0.02457320f, 0.01128468f, 
    -0.03657838f, 0.00754930f, -0.01059799f, 0.00610102f, -0.03215188f, 0.02411813f, -0.02191325f, -0.02842060f, 
    0.00244982f, 0.00848039f, 0.00013328f, -0.01431471f, -0.01392306f, 0.00924457f, -0.02001084f, -0.03313499f, 
    -0.02941506f, -0.02819623f, 0.00416893f, -0.01709901f, -0.03324367f, -0.02176654f, 0.00245503f, -0.02164872f, 
    0.02366921f, -0.02362417f, 0.01924821f, -0.02201244f, 0.03639206f, -0.00790770f, 0.02411221f, 0.01092486f, 
    -0.02324632f, 0.00834880f, -0.00989553f, 0.02557236f, -0.01224781f, -0.00400552f, -0.00019101f, 0.00097835f, 
    0.02034467f, -0.01145228f, 0.00795563f, -0.02235745f, -0.02537881f, -0.01307951f, 0.00027661f, 0.00695588f, 
    -0.00551240f, -0.03197877f, 0.02863293f, 0.01908125f, 0.02810192f, 0.01582955f, -0.04287260f, 0.02181822f, 
    -0.01742511f, -0.02230516f, -0.02059988f, -0.01166066f, 0.02638661f, 0.00399245f, 0.01995328f, -0.04172125f, 
    0.00667093f, -0.03948327f, -0.01582695f, -0.00008856f, -0.03802821f, 0.00276722f, 0.01921612f, -0.00423212f, 
    0.00935901f, 0.00860100f, -0.04100978f, 0.02024354f, -0.01427623f, 0.01080853f, 0.01090723f, -0.03348230f, 
    -0.03834412f, -0.00677194f, 0.01707264f, 0.00091137f, -0.00152806f, -0.02736374f, -0.03913159f, -0.02089646f, 
    -0.02549283f, 0.00075341f, 0.00072606f, 0.02115694f, 0.01879548f, -0.04157082f, -0.02313966f, -0.03003317f, 
    -0.01389615f, 0.00724027f, -0.01015357f, -0.01545025f, -0.01364611f, -0.04158121f, 0.00852100f, -0.01363551f, 
    -0.02725282f, -0.02282856f, 0.02008241f, -0.03691642f, 0.02906002f, 0.01235727f, -0.01246805f, -0.00584347f, 
    -0.02302796f, 0.02376430f, -0.00562387f, -0.01261984f, -0.00025416f, -0.03508783f, 0.02411671f, -0.02152039f, 
    -0.01595792f, -0.00651731f, 0.02694363f, -0.04043635f, -0.02184211f, 0.00950618f, 0.00118431f, -0.01693187f, 
    -0.01077607f, 0.00901484f, -0.03584267f, -0.00227316f, 0.00912410f, -0.01777065f, -0.04074216f, 0.00598187f, 
    0.01924919f, -0.03506802f, -0.00893913f, -0.01284323f, 0.00763352f, -0.01286551f, -0.02258465f, -0.00692144f, 
    -0.00648913f, 0.00960500f, 0.02193492f, -0.00102199f, -0.01732685f, -0.01062853f, -0.03991250f, -0.00279963f, 
    -0.00996916f, 0.01247664f, -0.00960561f, -0.00041888f, -0.03917833f, -0.02141093f, -0.01347586f, -0.00829655f, 
    0.00970027f, -0.02811824f, -0.00204093f, -0.01175587f, -0.00438561f, -0.00694826f, 0.00203065f, 0.02073686f, 
    -0.02499137f, -0.01253443f, 0.00716506f, 0.02705608f, 0.00001018f, 0.02149300f, 0.02789152f, 0.01293903f, 
    -0.00128240f, -0.01876677f, 0.01916850f, -0.00576295f, -0.00308338f, -0.01641770f, -0.02995644f, -0.00041783f, 
    -0.01125259f, -0.03635783f, 0.02146832f, 0.00081824f, -0.02111657f, -0.03809494f, -0.04045329f, -0.00268264f, 
    0.02446236f, -0.02686932f, -0.04269390f, 0.00258835f, -0.00060722f, 0.00338115f, 0.00142793f, -0.03547270f, 
    -0.00826365f, -0.02199482f, -0.02804061f, 0.02085353f, 0.01917511f, 0.01460972f, -0.00348401f, -0.02335528f, 
    -0.02740895f, -0.01812689f, 0.00913169f, 0.02398266f, 0.01451176f, 0.00699817f, 0.00014684f, -0.02081902f, 
    0.01832003f, -0.00236792f, -0.02828511f, -0.01543913f, 0.02478710f, 0.01353320f, -0.02139202f, -0.00440613f, 
    -0.01581112f, -0.03113699f, -0.00312621f, 0.01136295f, -0.03801671f, -0.00603650f, 0.00798755f, -0.03663231f, 
    -0.00591101f, -0.02475334f, -0.02532411f, -0.01088973f, -0.04411091f, 0.02213151f, 0.02349596f, -0.03712318f, 
    -0.01045123f, 0.00794825f, 0.02251472f, -0.00904747f, 0.00419747f, -0.03323616f, 0.00425256f, 0.00975273f, 
    0.00187264f, 0.02153674f, -0.03135248f, 0.02422013f, -0.01413426f, -0.00627936f, -0.01592430f, 0.00146832f, 
    -0.02637809f, 0.02176772f, 0.02880272f, -0.03050231f, -0.02340705f, 0.02967568f, 0.00848990f, -0.01763333f, 
    -0.02174384f, 0.03004578f, -0.00991694f, -0.00407314f, -0.00430497f, 0.01517777f, 0.02547114f, 0.01136405f, 
    -0.00889170f, -0.02657497f, 0.02077187f, -0.02918654f, -0.03354444f, 0.01936652f, -0.03385969f, -0.02223980f, 
    0.02321992f, 0.01811021f, 0.02850294f, -0.02444746f, 0.00555507f, -0.02133157f, -0.03541229f, 0.00109935f, 
    -0.03373533f, -0.01600509f, 0.00238276f, 0.01975392f, 0.01614187f, -0.02256634f, -0.02413164f, -0.00750463f, 
    0.01472268f, 0.01211853f, 0.02792420f, 0.01208970f, -0.03146154f, 0.00962055f, -0.03104163f, 0.00440244f, 
    -0.01301137f, -0.00801562f, 0.01824732f, -0.01516698f, -0.02957173f, -0.02758513f, 0.01169117f, 0.01615021f, 
    0.01606830f, 0.01325741f, 0.01766424f, 0.02266790f, 0.00707377f, 0.02822342f, -0.00582602f, -0.03848607f, 
    -0.00814419f, 0.00250300f, -0.03421519f, -0.00011106f, 0.02729740f, -0.03935684f, -0.03909410f, -0.01812667f, 
    -0.02545666f, 0.01807541f, 0.00740276f, 0.00473889f, -0.00806633f, 0.01340454f, 0.01027742f, 0.00729129f, 
    -0.01857145f, -0.01804988f, -0.02317908f, -0.01062120f, 0.01739302f, 0.00237076f, 0.01818862f, -0.01923363f, 
    -0.02046075f, 0.02521455f, -0.00387972f, -0.01511924f, -0.00809885f, 0.00331720f, 0.00095127f, -0.02551364f, 
    -0.03716323f, -0.02007388f, 0.01302798f, 0.02820868f, 0.00998663f, -0.01987160f, -0.03446962f, -0.00409373f, 
    -0.02840682f, -0.01364268f, 0.00745481f, -0.02861714f, -0.01672192f, -0.01036651f, 0.00102297f, 0.01048775f, 
    -0.01128711f, 0.02724211f, -0.00962005f, 0.00082065f, -0.03353722f, -0.00435025f, -0.02498391f, -0.01343429f, 
    -0.03417465f, -0.02541642f, 0.01524524f, -0.02232258f, -0.01453508f, -0.04035667f, 0.02816005f, -0.01825580f, 
    -0.03215742f, -0.03170931f, -0.01227590f, -0.04041176f, -0.01119738f, -0.01970907f, 0.02260181f, 0.00350437f, 
    -0.03604794f, -0.02532760f, 0.02083679f, -0.02012190f, -0.01075370f, 0.00795854f, 0.02153548f, 0.01574219f, 
    0.00520041f, -0.02801421f, -0.01817037f, -0.00401381f, -0.03713078f, -0.03471965f, -0.01942649f, -0.01095126f, 
    0.01507529f, 0.02897082f, 0.00069214f, -0.00771801f, 0.00203282f, -0.01650325f, -0.03989311f, -0.03692331f, 
    0.02322216f, -0.02039327f, 0.00339463f, -0.03123225f, -0.02111867f, -0.01097474f, -0.01639184f, -0.01754511f, 
    0.00598923f, 0.01713608f, 0.01122014f, -0.02951681f, -0.00369614f, 0.00292434f, 0.00191430f, -0.03275044f, 
    0.01392100f, -0.02779161f, 0.00098658f, 0.02122050f, 0.00608709f, -0.03856084f, 0.02193786f, 0.00406654f, 
    0.00089483f, 0.01464863f, -0.03930396f, -0.01503158f, 0.02754980f, -0.00694125f, 0.01896525f, -0.03014927f, 
    0.02090809f, -0.01890806f, 0.01160120f, -0.00463799f, -0.02676235f, 0.00350617f, -0.02848529f, -0.00153146f, 
    -0.01868604f, -0.00642250f, 0.01525720f, 0.00150077f, 0.01491591f, -0.03892566f, 0.02409308f, 0.00952996f, 
    -0.03679788f, 0.03169743f, -0.01622888f, 0.01188276f, -0.02580864f, 0.00376040f, -0.03752933f, 0.01494514f, 
    0.01352276f, -0.03793086f, -0.03968894f, 0.02699529f, -0.00397653f, 0.01445770f, 0.01197033f, 0.02551199f, 
    0.01757590f, -0.00774420f, -0.03873821f, -0.04049675f, 0.00557575f, 0.01366961f, 0.01558213f, -0.02177034f, 
    -0.03384934f, -0.01117176f, -0.02199565f, 0.00367079f, -0.01464789f, -0.01311887f, -0.02993232f, -0.02164654f, 
    0.02308239f, -0.00534028f, -0.03250670f, -0.03422808f, -0.03969981f, -0.02562599f, 0.01210405f, -0.02711793f, 
    -0.04005795f, -0.02844260f, -0.03844764f, 0.01453348f, 0.01047863f, -0.03882425f, 0.01079510f, -0.02080285f, 
    -0.00527460f, -0.03064622f, -0.01558893f, 0.02440729f, -0.01099357f, -0.03789728f, -0.03353320f, -0.01890861f, 
    -0.02609408f, 0.02457990f, -0.03291992f, -0.01897098f, 0.02076364f, -0.02230917f, -0.02927445f, 0.01498817f, 
    0.02710411f, -0.02970476f, -0.04041405f, 0.01171249f, -0.01748965f, -0.00531983f, 0.01788113f, -0.03467076f, 
    -0.00608661f, -0.01965664f, 0.01269662f, -0.02874431f, -0.03513473f, -0.02386652f, -0.01359885f, -0.00467673f, 
    0.02468698f, -0.03068712f, 0.02568250f, 0.02274175f, -0.00923353f, -0.00722960f, -0.01417711f, -0.00899315f, 
    -0.01899709f, 0.01806052f, -0.00434635f, -0.03877781f, 0.01937593f, -0.02402950f, -0.01408128f, -0.02554327f, 
    -0.00461954f, -0.03423030f, -0.03572937f, 0.02645713f, -0.01331842f, 0.01684903f, -0.04121557f, -0.00920887f, 
    0.00054738f, 0.00684250f, 0.02323429f, -0.01243186f, -0.03422214f, 0.01417662f, -0.00475337f, -0.01876767f, 
    -0.00369494f, -0.00282664f, 0.01280878f, -0.03689872f, -0.01511826f, -0.02741664f, -0.03736210f, 0.02863016f, 
    0.01040125f, 0.01325542f, 0.01629996f, -0.03109463f, -0.03074393f, 0.01161848f, -0.01591978f, 0.02761145f, 
    0.01835842f, -0.00004684f, 0.01502887f, 0.00447816f, 0.01304816f, 0.02745538f, -0.01894695f, 0.00108003f, 
    -0.03917448f, -0.00573382f, 0.01653890f, -0.04065284f, -0.00255052f, 0.00750466f, -0.02203032f, -0.00564968f, 
    -0.02576208f, 0.01521545f, -0.00766524f, 0.00066840f, 0.00187129f, 0.00922202f, -0.01097007f, -0.03238069f, 
    -0.02088973f, -0.01052162f, -0.01978121f, 0.01565512f, 0.02849443f, 0.02161964f, 0.01824525f, 0.00798756f, 
    -0.02904368f, -0.00002052f, 0.00756229f, 0.02638960f, 0.00715636f, 0.02680700f, 0.00780963f, -0.01283745f, 
    0.02418632f, 0.00757631f, -0.02808168f, 0.01354202f, -0.00399517f, 0.02388672f, -0.03341066f, 0.02525992f, 
    -0.01446799f, -0.03640018f, -0.02353381f, 0.01164863f, -0.02203032f, -0.03020548f, -0.04319523f, -0.04466922f, 
    -0.02447209f, -0.02589239f, -0.01858190f, -0.00070804f, 0.01211521f, -0.00833802f, -0.01443797f, -0.02499427f, 
    0.01355352f, 0.01507610f, -0.00678372f, -0.00545888f, -0.00427604f, -0.00816032f, -0.02578463f, -0.02384780f, 
    -0.04536463f, 0.02275981f, 0.02086740f, 0.02107588f, 0.02252876f, -0.03362203f, -0.01025322f, 0.00221597f, 
    -0.01738533f, -0.02448862f, -0.01469471f, -0.00484665f, -0.01086600f, -0.02350060f, 0.02070278f, 0.03736437f, 
    -0.00455431f, -0.02754810f, 0.02385764f, -0.01800219f, -0.01973327f, -0.04029011f, -0.01746688f, 0.02008340f, 
    0.00629479f, -0.02415543f, -0.03802006f, 0.02409692f, -0.01688292f, 0.02293675f, 0.01607052f, -0.01628071f, 
    0.02591181f, 0.02018734f, -0.00383172f, -0.02975641f, -0.01706558f, -0.01922917f, -0.01814359f, -0.04348841f, 
    -0.02618591f, 0.00478263f, 0.02038188f, -0.00977538f, -0.00801051f, 0.00215409f, 0.00832612f, -0.03523439f, 
    -0.01138851f, 0.02704621f, -0.03458461f, 0.01535032f, -0.00277244f, -0.00849925f, 0.02575406f, 0.01113061f, 
    0.00531285f, -0.03636440f, -0.02018407f, -0.00546287f, -0.00177265f, 0.02670461f, 0.00470235f, -0.00929841f, 
    -0.02333517f, -0.00162066f, 0.00818758f, -0.00797437f, 0.00769410f, -0.00589715f, -0.02479151f, 0.02224407f, 
    -0.03199658f, -0.04053956f, -0.00766359f, -0.03200177f, 0.00231162f, 0.01595747f, 0.01419087f, 0.00008823f, 
    -0.03420428f, 0.01642887f, -0.01031904f, 0.00452808f, -0.01304387f, 0.00010416f, -0.01344384f, -0.01772740f, 
    0.00307957f, 0.01102387f, -0.00020066f, 0.02642958f, 0.01585296f, 0.02881432f, -0.02551533f, 0.00876179f, 
    -0.03311591f, 0.00710699f, 0.02106223f, 0.02198957f, -0.04023431f, -0.00436925f, -0.01234419f, 0.01993552f, 
    0.00237107f, -0.00083877f, 0.01489385f, -0.00045131f, -0.01629543f, 0.01420398f, -0.00866181f, 0.02627834f, 
    -0.03393716f, -0.02001957f, 0.00244769f, -0.04190138f, 0.00412562f, -0.01895122f, 0.01799338f, 0.00688722f, 
    -0.03018996f, 0.02985008f, 0.02341044f, -0.01240382f, 0.02689563f, -0.01828079f, -0.02009164f, 0.01269063f, 
    -0.03697715f, -0.04182886f, 0.02097026f, 0.00712686f, -0.01656505f, -0.00841857f, -0.01210521f, -0.01103564f, 
    -0.00186439f, 0.02047667f, -0.03228755f, 0.00954335f, 0.02445368f, 0.01502556f, -0.02561807f, 0.02558027f, 
    -0.03243254f, 0.02397205f, -0.01695450f, 0.00670191f, -0.01635772f, 0.02848349f, -0.03584350f, -0.01320005f, 
    0.01067221f, -0.02529940f, -0.01439460f, 0.01346015f, -0.04004158f, -0.03012402f, 0.02199597f, -0.02206967f, 
    -0.02536086f, -0.00892994f, 0.01800418f, -0.03710409f, -0.01951956f, -0.00750597f, 0.02216481f, -0.01902074f, 
    0.00544009f, 0.00865579f, -0.04312833f, -0.02363823f, -0.03021590f, -0.01927804f, 0.00688048f, 0.01624038f, 
    0.01794574f, 0.01148092f, -0.00329243f, 0.00863704f, 0.01524048f, -0.02419195f, -0.01122851f, 0.02376585f, 
    0.01288743f, -0.02348758f, -0.01520767f, -0.03552736f, -0.01313944f, -0.00343961f, 0.01706768f, -0.04048350f, 
    -0.00750592f, 0.00430238f, 0.01823540f, -0.00954635f, -0.03826082f, -0.01156286f, 0.02337228f, -0.02992802f, 
    -0.03835884f, -0.02918654f, -0.00095093f, -0.03536643f, -0.01511441f, 0.03320865f, -0.00503902f, -0.01622305f, 
    0.02629006f, -0.01120125f, -0.00315852f, 0.00227306f, 0.01489391f, 0.02505426f, -0.02069338f, -0.00667317f, 
    0.00842796f, -0.03800973f, -0.01755645f, -0.01920523f, -0.01577248f, -0.01593245f, -0.00981565f, -0.00256751f, 
    0.00135906f, -0.01058923f, -0.03803142f, -0.03529521f, 0.01873685f, 0.00283148f, 0.00923825f, -0.04252020f, 
    -0.01898871f, 0.00376823f, -0.01374526f, -0.00624309f, -0.00507172f, 0.02354756f, -0.01427666f, 0.02542576f, 
    -0.00059924f, 0.00613907f, 0.00727856f, -0.03838993f, -0.02365375f, -0.02792884f, -0.00716572f, 0.01929453f, 
    -0.01538304f, 0.00479919f, -0.02359414f, 0.00014642f, -0.03360889f, -0.00977930f, -0.01049692f, -0.03523239f, 
    -0.03817356f, -0.03555682f, -0.03340860f, -0.04182860f, 0.00344276f, -0.00768605f, -0.00209092f, 0.01974582f, 
    -0.04352321f, -0.00249289f, -0.01677561f, -0.00751949f, 0.02157791f, -0.03305068f, -0.02741975f, 0.01708676f, 
    0.00821711f, 0.00220510f, -0.00324709f, -0.03147392f, -0.01429538f, -0.03166571f, -0.00746618f, -0.03672511f, 
    -0.00670393f, 0.02922794f, -0.03201457f, 0.00166794f, -0.00365869f, 0.00578146f, -0.00483084f, 0.01845155f, 
    -0.03852353f, 0.02484698f, -0.03623298f, -0.00541522f, -0.00676693f, -0.04203882f, 0.01264735f, -0.01756343f, 
    0.00756295f, -0.00141129f, -0.01109153f, -0.02557517f, -0.03486066f, 0.01178590f, -0.02256902f, 0.02504347f, 
    -0.01130799f, 0.02232544f, 0.02478624f, 0.02343104f, 0.00306602f, -0.02360649f, -0.02131173f, 0.00857720f, 
    -0.02918853f, -0.01300472f, 0.02820841f, -0.02646750f, -0.00335569f, -0.02608456f, -0.02735399f, 0.00226988f, 
    -0.02739774f, -0.03938095f, 0.02236164f, -0.03307032f, -0.04133784f, -0.03946960f, -0.02639872f, 0.01292307f, 
    0.02603946f, 0.03137303f, -0.02737639f, 0.02617371f, -0.02618391f, 0.02709551f, 0.02349485f, 0.00005386f, 
    -0.04665698f, 0.02313140f, 0.01305287f, -0.03399195f, 0.01719716f, -0.01818625f, -0.01463088f, 0.00065745f, 
    0.01039365f, -0.00085085f, 0.02703016f, -0.00592989f, -0.01324301f, -0.01628143f, -0.02166369f, 0.00510771f, 
    -0.00154311f, -0.02828003f, 0.02116310f, -0.03742825f, 0.02517357f, 0.01585772f, -0.01325408f, 0.00221720f, 
    0.00696393f, -0.00189367f, 0.01548647f, -0.00040913f, -0.00097424f, -0.03900415f, 0.03049379f, -0.02133609f, 
    -0.01320223f, -0.01700063f, 0.02180900f, 0.03748358f, -0.01662332f, 0.00615901f, -0.02571115f, -0.02392990f, 
    -0.02425829f, -0.01687881f, -0.00357596f, 0.02012439f, 0.00868665f, 0.03087612f, 0.02895574f, 0.00988573f, 
    -0.00596147f, 0.01965864f, -0.00320218f, 0.00434765f, -0.01005406f, 0.02399425f, -0.03941013f, 0.01166185f, 
    -0.00730654f, 0.00662443f, -0.02012423f, -0.00080265f, -0.00999011f, -0.01474700f, -0.02904576f, -0.03320906f, 
    0.00669307f, 0.00183715f, -0.02798526f, 0.01379121f, -0.02128398f, 0.01452026f, 0.00373325f, 0.02070036f, 
    -0.01579406f, -0.02700136f, -0.04140320f, -0.03211877f, 0.01046342f, -0.00118298f, 0.01532385f, -0.03227304f, 
    -0.00042347f, -0.00623754f, 0.00774142f, 0.00794041f, -0.01133701f, -0.02388879f, 0.02771487f, -0.03828294f, 
    0.02022410f, -0.01157005f, -0.03910263f, 0.01824989f, 0.02674556f, -0.01921961f, -0.02981344f, 0.01668029f, 
    -0.01816102f, 0.00898743f, 0.00222411f, -0.00363718f, -0.04161906f, -0.03026000f, -0.02859113f, -0.02956412f, 
    -0.00414379f, -0.03587036f, -0.00795441f, -0.02389251f, -0.00716519f, 0.01242119f, 0.04029604f, -0.02400480f, 
    0.00845017f, 0.02826706f, 0.00904980f, -0.01753971f, 0.01777823f, 0.00464457f, -0.01160821f, -0.01439347f, 
    -0.03912058f, 0.01450506f, -0.00959728f, 0.02394716f, 0.01477581f, 0.02842133f, 0.00195670f, -0.01670926f, 
    -0.03685166f, -0.02806670f, -0.01530152f, 0.01807250f, -0.02299394f, 0.01469870f, 0.00364828f, -0.00072884f, 
    -0.04202896f, 0.00065144f, 0.00136775f, -0.03717444f, -0.02270007f, -0.02773109f, 0.01858053f, -0.04233629f, 
    0.00851671f, -0.01885340f, -0.00793973f, -0.00777820f, -0.00447387f, 0.01065225f, -0.00495502f, -0.01359244f, 
    0.00311093f, 0.01465198f, 0.03466371f, -0.00080809f, -0.00678484f, -0.02113635f, -0.00479725f, -0.03017684f, 
    0.00499095f, 0.02192614f, -0.02446162f, 0.02852039f, -0.00394614f, 0.02668285f, -0.01113755f, -0.00507070f, 
    -0.00375013f, -0.01939997f, 0.00124228f, 0.00651903f, -0.02046603f, -0.02761879f, 0.03035269f, 0.00638759f, 
    -0.03520297f, -0.01349515f, 0.00308454f, -0.01350505f, 0.02941609f, -0.01282092f, 0.02496622f, -0.00865212f, 
    -0.00894909f, -0.03969052f, 0.01580589f, 0.00160047f, -0.00409719f, 0.02646902f, 0.01110826f, -0.02722719f, 
    -0.01672785f, -0.00785123f, -0.02427186f, -0.00285122f, -0.03382682f, 0.01026691f, 0.01639775f, 0.01594209f, 
    0.00328625f, -0.02858615f, -0.01965974f, -0.03840962f, 0.00914587f, 0.02288790f, 0.00563658f, -0.04568091f, 
    -0.04164538f, 0.02486034f, -0.02281653f, 0.02006803f, 0.00985363f, 0.00227269f, 0.00858034f, -0.01945861f, 
    0.02961945f, -0.01961214f, 0.02968853f, 0.01977008f, 0.02377431f, 0.03740465f, 0.00901359f, 0.00695294f, 
    0.01847128f, -0.00446721f, 0.02445328f, -0.00869722f, 0.01443506f, -0.02219285f, -0.03282573f, -0.02119929f, 
    -0.04331949f, 0.01200016f, -0.02066206f, -0.03743792f, 0.00787042f, 0.02870726f, -0.00462325f, 0.02776958f, 
    -0.01024847f, -0.00767846f, -0.00042155f, -0.01556125f, 0.00933699f, -0.00554577f, -0.00380321f, -0.04012085f, 
    -0.01324212f, 0.02573803f, -0.03303247f, 0.00024419f, 0.02096713f, 0.01697285f, -0.03832035f, -0.03027535f, 
    0.00953980f, 0.02695407f, -0.00894381f, 0.02410882f, -0.03588232f, -0.03980333f, -0.01555660f, -0.00840928f, 
    0.03523581f, -0.03897681f, -0.02113209f, 0.00056143f, 0.01486112f, 0.00266245f, -0.03499781f, -0.01855945f, 
    -0.00235440f, -0.04186638f, 0.03032484f, -0.02190274f, 0.00147450f, 0.00064379f, -0.00562493f, -0.04282936f, 
    -0.00282974f, 0.01100919f, -0.04053224f, 0.00624740f, 0.01322954f, -0.01100178f, -0.01634076f, 0.02015901f, 
    -0.01103716f, 0.01597522f, 0.00911804f, 0.00679136f, -0.00826324f, -0.01301159f, 0.00689285f, -0.01327087f, 
    -0.04091348f, 0.01651400f, 0.02373911f, 0.01812624f, -0.00555380f, -0.01657831f, 0.02253993f, -0.02409642f, 
    0.01797477f, -0.03151558f, -0.03002246f, 0.01327121f, -0.02525073f, -0.00432741f, 0.00052211f, -0.01688655f, 
    0.00097720f, 0.02003348f, -0.01172910f, -0.00404164f, -0.00710910f, -0.03112332f, -0.02722231f, -0.01194116f, 
    0.00508069f, -0.03527807f, -0.00940915f, 0.01723918f, 0.00474158f, -0.01532184f, -0.03271120f, -0.00042469f, 
    0.02625663f, -0.02810111f, -0.04200387f, -0.03307444f, -0.04436620f, -0.00998981f, -0.01139983f, 0.01146826f, 
    0.01205071f, 0.00220434f, -0.02261302f, -0.01588488f, 0.01235023f, -0.01474943f, -0.01634329f, 0.00743174f, 
    0.00317680f, 0.02176896f, -0.00697286f, -0.01108536f, 0.01656437f, -0.01050711f, -0.02290441f, -0.03377613f, 
    -0.03333255f, -0.01596552f, -0.00698191f, 0.00348832f, 0.00968315f, -0.02307392f, 0.03106045f, 0.02074657f, 
    -0.02961687f, -0.00862040f, -0.00883915f, 0.01897470f, -0.00121648f, -0.00250132f, -0.00950877f, -0.00612206f, 
    -0.00577848f, -0.02765404f, -0.00502313f, 0.02245470f, -0.00879784f, 0.00369345f, 0.03460114f, 0.00870459f, 
    -0.01361141f, -0.02705162f, 0.01705083f, 0.01461391f, -0.00595690f, -0.03835899f, -0.02055406f, -0.02906909f, 
    -0.00316103f, -0.03033433f, -0.00067636f, -0.04273546f, 0.00184842f, -0.03571202f, 0.02472020f, 0.00079026f, 
    -0.03084417f, -0.02393623f, -0.00579186f, 0.01613655f, -0.03329954f, -0.01210134f, 0.00287817f, -0.00877352f, 
    -0.00991159f, -0.01844209f, -0.01444726f, -0.04371654f, -0.01967921f, -0.02439153f, -0.04084760f, 0.01700489f, 
    0.10269310f, 0.20354243f, -0.00004495f, 0.16322076f, 0.05548569f, 0.16351458f, 0.10422277f, -0.04936491f, 
    0.22734965f, 0.06292614f, 0.13316174f, -0.05953408f, -0.09735676f, -0.10289871f, 0.05691935f, 0.22550848f, 
    0.06184892f, 0.09517545f, 0.00608212f, 0.13767482f, 0.06572708f, -0.16042186f, -0.05061372f, -0.00695409f, 
    -0.17802285f, 0.28976107f, 0.02393755f, -0.05542052f, 0.09147715f, 0.04419091f, 0.18901943f, -0.07705909f, 
    -0.03454055f, -0.10781339f, 0.03016168f, 0.04285128f, -0.06003365f, -0.12686640f, 0.00181012f, -0.11370832f, 
    0.12646088f, -0.03075657f, -0.04494475f, 0.05187275f, 0.11194647f, 0.25797814f, 0.05832367f, 0.12688084f, 
    -0.03763886f, 0.05102620f, 0.13709606f, 0.33968717f, 0.19116890f, 0.07309289f, 0.12621957f, 0.21198048f, 
    -0.15561874f, 0.01306791f, 0.07797950f, -0.00002174f, 0.11524528f, -0.27980149f, -0.20393302f, 0.06821655f, 
    0.11605718f, -0.21175089f, -0.08911408f, -0.02545152f, 0.00218351f, 0.06477329f, -0.12739486f, 0.07195131f, 
    0.08610622f, -0.22565515f, -0.04410474f, 0.11082800f, 0.07490213f, -0.20948485f, -0.31581315f, 0.07886235f, 
    0.02436110f, 0.00529925f, 0.07118609f, 0.17912027f, 0.01265316f, 0.07662595f, 0.26850992f, 0.05925982f, 
    0.12968284f, -0.04462764f, 0.03814612f, -0.05554339f, 0.08725383f, -0.08656305f, 0.03270067f, 0.02019384f, 
    0.00224529f, -0.16263650f, -0.25601143f, -0.03129407f, -0.00100137f, -0.00580523f, -0.13777837f, 0.12522919f, 
    0.15818837f, -0.02677965f, -0.03374278f, 0.04227347f, -0.40702304f, -0.20064992f, -0.23203364f, -0.05945314f, 
    0.07162415f, -0.04294284f, -0.11920340f, 0.02484645f, 0.02391159f, 0.01540172f, 0.07477593f, 0.26474658f, 
    -0.17205992f, -0.26111627f, 0.03475668f, -0.19647060f, -0.10241553f, -0.00519444f, 0.09665246f, 0.18591246f, 
    0.15481213f, -0.02339527f, 0.00995796f, 0.06337717f, 0.02312768f, 0.09255702f, 0.01826545f, 0.02784020f, 
    0.12973246f, 0.12372847f, 0.12425707f, 0.14301984f, 0.05603328f, -0.04262498f, -0.04550802f, 0.07009917f, 
    -0.51677591f, -0.34987879f, -0.20768890f, 0.02702950f, 0.15286955f, 0.08641493f, -0.10845134f, -0.16350225f, 
    -0.02965008f, -0.10471684f, -0.04250205f, 0.00408618f, -0.20812936f, -0.22224270f, -0.19267966f, 0.05942144f, 
    0.01562633f, -0.12643597f, -0.07017212f, 0.00293492f, 0.07187320f, -0.02125656f, 0.09434345f, 0.19158973f, 
    -0.09190954f, -0.13906170f, -0.43087181f, -0.22258870f, 0.07004764f, -0.14359100f, -0.05268521f, 0.16689616f, 
    0.14272211f, 0.01552827f, 0.12210695f, 0.03939346f, 0.03642649f, 0.25698116f, 0.01244105f, -0.07897989f, 
    0.13318343f, -0.07235894f, 0.13110863f, 0.12942256f, -0.09904606f, -0.03842332f, -0.01211161f, 0.11477172f, 
    -0.06659175f, -0.15516280f, -0.13530959f, 0.21984228f, 0.02205951f, -0.11868063f, -0.09601011f, -0.05237455f, 
    0.16067301f, 0.02635036f, -0.01888356f, 0.13106114f, 0.06463245f, -0.20605437f, 0.21788959f, 0.41771197f, 
    -0.00114643f, -0.07065568f, -0.13205549f, 0.03710536f, -0.01479017f, 0.15560472f, -0.27801263f, 0.23307505f, 
    0.07713795f, -0.14267780f, -0.04570658f, -0.01711845f, 0.02627907f, 0.03887163f, -0.06664491f, 0.16763926f, 
    0.18724701f, 0.07497567f, -0.09945960f, 0.10269166f, -0.08508188f, -0.25241897f, -0.05506673f, -0.11767778f, 
    0.10485796f, -0.21316566f, -0.04628597f, 0.02619126f, -0.06898613f, 0.05802011f, 0.16031533f, -0.00415032f, 
    0.13917847f, 0.12957531f, -0.12837809f, -0.11028185f, -0.04643426f, 0.16549459f, -0.07491405f, 0.16944203f, 
    -0.04328790f, 0.18545718f, 0.02576636f, -0.16856153f, -0.03373759f, 0.18056072f, -0.18594760f, -0.25028926f, 
    0.00318341f, -0.06707648f, 0.16500221f, 0.11277191f, -0.13940178f, 0.03861064f, -0.12854239f, -0.04670298f, 
    -0.26345006f, 0.02073294f, -0.02524118f, -0.05693864f, 0.02336776f, -0.12904775f, -0.00628435f, 0.17326406f, 
    0.15540260f, -0.01360833f, -0.08014436f, -0.03062311f, 0.18715766f, -0.23835741f, -0.24655344f, 0.18008819f, 
    0.11425263f, -0.03153739f, -0.22642587f, 0.19719149f, -0.00637027f, 0.10221622f, 0.09101785f, 0.04973685f, 
    0.11119162f, 0.15801936f, 0.17173085f, 0.27844247f, 0.14164849f, 0.15776180f, 0.08669020f, 0.26864645f, 
    0.04315283f, -0.07388139f, 0.03665685f, 0.06028429f, -0.09096012f, 0.19137694f, -0.06423511f, 0.04335112f, 
    0.01691644f, 0.06819781f, 0.09482057f, 0.12968525f, 0.36648607f, -0.12365174f, -0.07388815f, 0.21032837f, 
    0.18923222f, 0.24184282f, 0.28277904f, 0.24125651f, 0.03797416f, 0.06076293f, 0.13869502f, -0.01622605f, 
    0.18101123f, 0.03532907f, -0.09130573f, 0.14600781f, 0.27976573f, 0.34904116f, 0.47509953f, 0.33778471f, 
    0.13009889f, 0.01881412f, -0.02311140f, 0.02297619f, 0.01883879f, -0.00413666f, 0.01472900f, -0.06772455f, 
    -0.08795649f, -0.32324710f, -0.14498195f, -0.07418355f, -0.07307470f, 0.05303811f, -0.08300861f, -0.01232616f, 
    0.20612906f, 0.00364537f, -0.05704701f, -0.01063608f, 0.01545033f, -0.03648810f, -0.08215764f, 0.25499561f, 
    0.20664798f, -0.02821435f, -0.10570940f, 0.06925560f, 0.02458601f, 0.05517153f, -0.07581319f, 0.15242834f, 
    0.15958752f, -0.11212678f, 0.17438924f, 0.15415600f, 0.15406060f, 0.09581439f, 0.06381834f, 0.13817723f, 
    0.09255756f, -0.08873931f, 0.20465736f, -0.11714455f, -0.08363630f, 0.57791579f, -0.11417961f, -0.08641823f, 
    0.01957754f, 0.09586072f, -0.02761317f, 0.03131130f, -0.12342989f, -0.14027832f, -0.08145945f, 0.12995134f, 
    -0.14559363f, 0.04938336f, -0.29389575f, 0.07952412f, 0.14972576f, 0.02346142f, -0.29232648f, 0.03093367f, 
    0.05852369f, 0.03515080f, -0.18350382f, -0.03682479f, -0.07808661f, -0.20320311f, -0.33896714f, -0.05698345f, 
    0.07606106f, 0.00991977f, -0.19285747f, -0.12355893f, -0.00517365f, -0.10281485f, -0.04321244f, 0.02695087f, 
    -0.22548175f, -0.10751443f, -0.10533829f, 0.20190918f, 0.08753757f, 0.03973290f, -0.01407447f, -0.18483715f, 
    0.09765504f, 0.03465625f, -0.18702848f, 0.03160961f, 0.36949113f, -0.26165029f, 0.19890679f, 0.30723649f, 
    0.03152093f, -0.05140803f, -0.01954383f, 0.23297697f, 0.08189534f, 0.11542166f, -0.16582817f, -0.00712753f, 
    0.02410678f, 0.19002248f, -0.04648449f, 0.46947455f, 0.09770085f, 0.10052712f, 0.03389746f, 0.01797146f, 
    0.07193583f, -0.00623437f, -0.02074346f, -0.13248231f, -0.09286535f, 0.22544171f, 0.19480748f, -0.07449957f, 
    0.06726310f, -0.04085718f, -0.02285005f, 0.23528536f, 0.01409746f, -0.08463763f, -0.04081572f, 0.17094670f, 
    0.11120498f, 0.15091406f, 0.17231551f, 0.14941573f, 0.08271517f, 0.09060812f, 0.05938040f, -0.07315370f, 
    0.01654451f, 0.01007223f, 0.14665179f, -0.02551744f, -0.19798030f, -0.38865921f, -0.16171619f, -0.16862532f, 
    0.12546033f, -0.16400248f, 0.06822868f, -0.05280523f, 0.05251313f, -0.10321821f, -0.07328780f, 0.12283113f, 
    0.10185709f, 0.03617421f, 0.22367470f, 0.11873507f, 0.08736774f, 0.02144242f, 0.10165641f, 0.03911402f, 
    -0.01449448f, 0.06419747f, -0.15019949f, -0.12740859f, -0.27165225f, -0.04466164f, 0.05760340f, 0.05543910f, 
    0.20571424f, 0.14983070f, 0.10461834f, -0.11226033f, -0.07945881f, -0.08806065f, -0.04744682f, 0.13067926f, 
    0.06070841f, -0.31069258f, 0.13573267f, 0.07237150f, -0.04993261f, -0.03049361f, -0.03844006f, 0.07566769f, 
    0.20893225f, -0.00632712f, -0.00732821f, -0.04944742f, 0.22516498f, 0.08442680f, 0.03497048f, 0.12708360f, 
    0.33774516f, 0.04758278f, 0.12961979f, 0.17178743f, 0.19413073f, -0.05057596f, -0.07376511f, 0.07062439f, 
    -0.02262506f, -0.08305723f, -0.08897677f, 0.10830100f, 0.04825651f, 0.10405149f, 0.08899041f, 0.24300258f, 
    -0.04132773f, 0.02469621f, -0.03311125f, -0.08511853f, 0.09915599f, -0.53869611f, 0.15523458f, -0.21011907f, 
    -0.01050090f, -0.11464465f, -0.07558922f, 0.00569180f, 0.13204820f, 0.16622126f, 0.11781619f, 0.01034392f, 
    0.10773247f, 0.01163652f, -0.30235428f, 0.06659741f, 0.02974951f, -0.24401617f, -0.18441400f, -0.02748698f, 
    -0.03299880f, 0.21721143f, -0.18990074f, -0.12195997f, 0.24976479f, 0.02167956f, -0.15112327f, 0.15710483f, 
    0.04528530f, -0.14443024f, -0.07109071f, -0.00088349f, 0.01479372f, 0.08979935f, 0.11577937f, -0.02272666f, 
    -0.08175164f, 0.01197498f, -0.07356942f, 0.14975984f, 0.00993150f, 0.00628731f, -0.00937223f, 0.05638658f, 
    -0.05561398f, -0.06589407f, -0.01178582f, 0.09552173f, -0.08756024f, 0.10402135f, -0.27428854f, -0.04937062f, 
    0.08292227f, 0.02755154f, -0.05859619f, -0.24002898f, 0.13254729f, 0.11659002f, 0.06011880f, -0.16348037f, 
    -0.19875261f, -0.03948063f, -0.05804779f, 0.04471675f, 0.17418627f, -0.05733707f, 0.00356012f, -0.02342213f, 
    0.08434059f, 0.04375786f, -0.04582419f, 0.09087594f, -0.40736389f, -0.22198109f, 0.18058228f, 0.26200461f, 
    0.19165102f, 0.07196145f, 0.13233547f, 0.04357388f, 0.16779533f, 0.02364706f, 0.03328824f, -0.01392577f, 
    -0.13999711f, -0.09732457f, -0.42721602f, 0.03478981f, 0.11378438f, -0.12829483f, -0.03698619f, -0.14642781f, 
    0.22483058f, 0.02672817f, 0.07314078f, 0.08772193f, 0.07357470f, 0.47652587f, 0.10834278f, 0.02322569f, 
    -0.03534950f, 0.23725535f, -0.17142077f, -0.01859786f, -0.07890442f, 0.01708210f, 0.09576107f, -0.08992366f, 
    0.03738110f, 0.32044366f, 0.36476952f, 0.28310916f, 0.07616463f, 0.06380475f, 0.15971427f, 0.10192230f, 
    0.05740730f, 0.04152061f, 0.10122807f, 0.12343803f, 0.11838647f, 0.04308130f, 0.07036186f, 0.07820132f, 
    0.22296284f, 0.12531441f, 0.02629438f, -0.22532703f, 0.01414664f, -0.05537691f, -0.09070930f, -0.07438345f, 
    0.08099744f, 0.03333939f, -0.05411681f, 0.20463227f, 0.09611452f, -0.03410171f, 0.11965804f, 0.09380154f, 
    0.08868783f, 0.03729182f, 0.00087240f, 0.04686209f, -0.17886001f, 0.22754112f, 0.29104191f, -0.04119547f, 
    0.15455735f, -0.00627896f, 0.19759817f, 0.07871620f, -0.01692516f, 0.05598101f, 0.01630533f, 0.17351171f, 
    0.63081706f, 0.10449149f, -0.11291514f, -0.20478447f, 0.03651971f, 0.07699851f, -0.06636517f, -0.13694386f, 
    0.10349013f, -0.02170183f, 0.15322201f, 0.01394276f, -0.37548736f, 0.02629351f, -0.33609039f, -0.01684684f, 
    0.07171028f, 0.22034712f, 0.07131545f, -0.12365236f, 0.16066234f, 0.03492059f, -0.06683604f, -0.15256409f, 
    0.10865071f, -0.01512743f, 0.01473993f, 0.27050716f, 0.21630204f, -0.00139323f, -0.13238388f, 0.02743408f, 
    0.02234696f, -0.10963611f, -0.03849309f, 0.16194808f, -0.15016204f, -0.27813166f, -0.20156664f, 0.09582517f, 
    -0.03805709f, -0.01711655f, -0.16673462f, 0.11167068f, -0.00841729f, 0.01499625f, -0.09684772f, 0.10130265f, 
    0.13076563f, -0.20755085f, 0.03085218f, 0.01111061f, 0.01970278f, 0.00989102f, 0.06378216f, 0.09151535f, 
    0.13207522f, 0.01558156f, 0.08536930f, 0.06339535f, -0.16605559f, 0.16280606f, -0.10982347f, 0.47782600f, 
    0.12602402f, -0.09475040f, 0.02512788f, 0.00586179f, -0.01984274f, 0.14917041f, -0.04871861f, -0.13851905f, 
    -0.02764237f, 0.01101108f, -0.02695557f, 0.00532729f, -0.01099735f, -0.00339771f, -0.02022834f, 0.01564368f, 
    -0.01570409f, -0.04200779f, -0.01746297f, 0.00393094f, 0.01304181f, -0.00993374f, -0.03985047f, 0.00595840f, 
    -0.02883344f, 0.01274305f, -0.01288498f, -0.03654068f, 0.00249861f, 0.00005700f, -0.04043970f, 0.02740689f, 
    0.01243979f, 0.02454475f, -0.04277376f, -0.00074709f, 0.02776843f, -0.01691145f, 0.01758280f, -0.03427237f, 
    -0.03500191f, -0.03083633f, 0.01241362f, -0.02661712f, 0.01008244f, -0.03112150f, -0.01418263f, -0.02669066f, 
    0.03064016f, 0.01732179f, 0.02271135f, -0.01938513f, 0.00327697f, -0.00328524f, -0.02679310f, 0.00901278f, 
    0.00474747f, 0.02501162f, -0.01687057f, -0.03027111f, -0.00858511f, -0.03874519f, -0.01783913f, -0.01520037f, 
    0.01723225f, -0.02720248f, -0.03999081f, 0.01864281f, -0.04184898f, -0.02454314f, 0.02497024f, 0.01665829f, 
    0.01027180f, 0.02427491f, 0.02747959f, -0.01018349f, 0.02575389f, 0.02115004f, -0.03865285f, 0.01864688f, 
    -0.01211230f, 0.01894245f, 0.01725006f, -0.01835833f, -0.00225269f, -0.02598659f, 0.01234869f, -0.01526304f, 
    -0.03666347f, -0.02268105f, 0.03639924f, -0.03298875f, -0.03880955f, -0.02327777f, -0.00236373f, -0.04108163f, 
    0.00820952f, -0.03630631f, -0.00230389f, 0.01611502f, -0.00760109f, -0.02011911f, 0.02600522f, 0.01932400f, 
    0.01835754f, -0.02186263f, 0.01918865f, 0.00822679f, -0.00893162f, -0.01999588f, 0.00486748f, 0.00458819f, 
    0.01677279f, -0.02024260f, -0.03940376f, -0.00213669f, -0.04179621f, 0.00374953f, 0.01438749f, -0.02119229f, 
    0.02443671f, 0.02107652f, -0.00747690f, -0.03830818f, 0.00774120f, -0.00528999f, -0.02714506f, -0.03088180f, 
    -0.03371444f, -0.02614917f, 0.01393932f, 0.02737723f, 0.01764297f, -0.03364608f, -0.02356404f, 0.01842525f, 
    0.01477975f, -0.02862207f, -0.01804387f, 0.00849365f, 0.00717161f, -0.02547220f, -0.02585911f, 0.02122146f, 
    0.01894772f, -0.00277370f, -0.03802467f, 0.00934591f, -0.03196074f, -0.01150097f, 0.02779920f, -0.01016404f, 
    -0.00051523f, -0.00833321f, -0.02092092f, -0.03706992f, 0.00687465f, 0.00689742f, -0.02770412f, 0.01445789f, 
    0.00779933f, 0.00405850f, 0.01272419f, 0.01628733f, 0.03580392f, -0.00456762f, -0.02295790f, -0.00849857f, 
    0.02424986f, -0.01409221f, 0.01879611f, 0.02623428f, -0.00861913f, 0.01932435f, -0.02553038f, -0.02746456f, 
    0.02394213f, -0.00449804f, -0.03797046f, 0.02399517f, -0.03906779f, 0.02020979f, -0.01590942f, -0.01437307f, 
    -0.04039871f, -0.01840349f, 0.02453857f, 0.00671557f, 0.01384733f, 0.01206017f, -0.02629948f, -0.01687221f, 
    0.01132498f, 0.01957007f, 0.00566051f, -0.02470036f, -0.01591190f, -0.03865138f, -0.04425538f, -0.01255031f, 
    0.01959411f, -0.01649148f, -0.03155713f, -0.02018760f, -0.02030627f, -0.03437325f, -0.02836364f, -0.02519816f, 
    -0.00534049f, -0.00936854f, 0.01572915f, -0.00763713f, 0.01422456f, -0.01440769f, 0.01309040f, 0.02012108f, 
    -0.02820015f, 0.02604111f, -0.00902095f, 0.00968797f, 0.01095769f, -0.00049364f, -0.03751592f, -0.01523105f, 
    0.02187925f, 0.02119741f, -0.02264611f, 0.00497446f, -0.02486018f, 0.00607888f, -0.00295395f, 0.01208105f, 
    -0.02540815f, 0.02167092f, -0.02428899f, -0.00811773f, -0.01385937f, -0.00923628f, -0.01505194f, 0.00558454f, 
    0.02838829f, -0.02145550f, -0.00446955f, -0.04113684f, 0.00956008f, -0.01876555f, 0.01565474f, -0.00487485f, 
    0.01841675f, -0.03126508f, 0.00887289f, -0.02801797f, -0.02697479f, -0.03719465f, -0.04169533f, -0.01787846f, 
    -0.00712095f, 0.02184608f, -0.00473980f, -0.03601993f, -0.01228491f, 0.00349601f, -0.03207511f, -0.01191159f, 
    -0.02324121f, -0.00483736f, 0.00955910f, -0.03126919f, 0.01809729f, 0.01297984f, -0.02301291f, -0.00599167f, 
    0.01760041f, 0.00073295f, -0.03534732f, -0.02654713f, 0.02445098f, -0.00310248f, 0.02245048f, 0.01162101f, 
    -0.03805624f, 0.01907191f, -0.02096680f, 0.00281744f, -0.02168184f, 0.02307808f, 0.00919841f, -0.01147114f, 
    -0.01182640f, 0.01131857f, -0.02823457f, -0.01551064f, -0.01291481f, 0.02069683f, -0.02979278f, 0.00709951f, 
    0.02754136f, -0.03626418f, 0.00935266f, 0.00147997f, -0.00771846f, -0.00521010f, 0.02662728f, -0.02753874f, 
    -0.03434103f, -0.00936406f, -0.01444994f, -0.00763034f, 0.00703477f, 0.01796146f, 0.02944656f, -0.03071137f, 
    -0.03484604f, -0.02118150f, 0.03878817f, -0.03588146f, 0.00508422f, -0.02583070f, -0.02198226f, 0.00072344f, 
    0.01358772f, -0.02584255f, -0.02393138f, -0.00237893f, 0.02449670f, 0.00578880f, -0.01276592f, 0.02898878f, 
    0.00348266f, -0.02101328f, 0.00286401f, -0.02822695f, -0.03451193f, -0.02730658f, 0.00596973f, 0.02329586f, 
    0.02456155f, -0.01450333f, 0.01777822f, 0.00248660f, -0.03635571f, -0.03165206f, -0.01782503f, -0.03005621f, 
    0.01501079f, 0.02692655f, -0.01374461f, 0.02172997f, -0.01344402f, 0.01779318f, 0.02645284f, 0.00431591f, 
    -0.00701055f, 0.02440006f, -0.03675254f, 0.02059191f, -0.00265052f, 0.02562063f, 0.00156114f, 0.02262217f, 
    -0.01912440f, 0.01472639f, -0.01242047f, 0.01266427f, -0.00783878f, 0.00065542f, -0.02551399f, 0.02147936f, 
    -0.01616801f, -0.01316842f, -0.00059367f, -0.03281688f, -0.04444792f, 0.02134413f, 0.02778919f, -0.00252092f, 
    -0.00356847f, 0.02232870f, -0.01419559f, -0.00192635f, 0.00637314f, 0.00785109f, 0.01205725f, 0.01674409f, 
    0.00846974f, -0.01146932f, 0.02384045f, -0.03630982f, -0.01113142f, -0.02908255f, 0.00555259f, -0.01846759f, 
    -0.00195442f, 0.03756944f, -0.00135257f, 0.00422224f, -0.02632388f, -0.01523906f, -0.00779649f, 0.03607313f, 
    0.01968117f, -0.00350882f, 0.00629289f, 0.01850754f, 0.00586899f, -0.01393538f, -0.02346704f, -0.01198587f, 
    0.00496849f, 0.03184310f, 0.01621351f, -0.01982565f, 0.00006371f, -0.01202788f, 0.02680959f, -0.00689845f, 
    -0.01646338f, -0.02918108f, 0.02402600f, -0.03633909f, -0.01211871f, -0.00655139f, 0.02071117f, 0.01408911f, 
    0.02418923f, -0.01916323f, 0.01289931f, 0.02293569f, 0.02973378f, 0.00900865f, 0.02635946f, -0.02758447f, 
    0.02612874f, 0.00377946f, 0.02178779f, -0.02837080f, 0.00719667f, -0.02705291f, -0.03447944f, 0.01333174f, 
    -0.03896137f, -0.03189571f, -0.01513316f, 0.01681500f, -0.00422641f, -0.01313392f, 0.02027526f, 0.01362947f, 
    -0.03021759f, -0.01528492f, 0.02541254f, 0.02093617f, 0.01695580f, 0.01697352f, 0.01741033f, 0.01294404f, 
    0.02012789f, -0.01843703f, 0.00577451f, -0.00699190f, -0.00535339f, -0.03687267f, 0.00226349f, 0.02754104f, 
    -0.02096397f, -0.00366321f, 0.01283153f, -0.03083515f, 0.00207672f, 0.02534669f, -0.01796621f, 0.02657594f, 
    -0.02501837f, -0.01059928f, -0.01464138f, -0.01588025f, 0.01247630f, 0.01445108f, 0.00906167f, -0.01600787f, 
    0.02544714f, 0.02236835f, 0.03685116f, 0.02625324f, 0.01855270f, 0.01818954f, 0.03531828f, 0.00024873f, 
    -0.00379534f, -0.02161236f, 0.01439708f, -0.02973886f, -0.00437738f, -0.04319507f, -0.02598276f, -0.00728911f, 
    -0.02016882f, 0.02664909f, -0.00493470f, 0.02331238f, -0.02737111f, -0.02393497f, 0.01604751f, 0.01591514f, 
    0.01520208f, 0.00021478f, -0.03721632f, -0.01290437f, -0.03610273f, -0.03751473f, 0.02694772f, -0.02821775f, 
    -0.02479772f, -0.02045860f, -0.02934160f, -0.02707468f, -0.02620275f, 0.00665381f, 0.01887756f, 0.02276754f, 
    0.00176367f, 0.01615918f, 0.00261340f, -0.02154223f, -0.01477755f, 0.01169060f, -0.00992910f, -0.00263601f, 
    0.01900209f, -0.04316235f, -0.00013521f, -0.03349760f, 0.01470301f, -0.02023580f, -0.01263816f, -0.02886061f, 
    0.01237542f, -0.00362045f, 0.02909036f, 0.01501733f, 0.02137273f, -0.01021018f, 0.01101422f, -0.00864634f, 
    0.00719697f, -0.03166945f, -0.00664881f, -0.02725859f, -0.00491228f, -0.03235432f, -0.01483351f, 0.00284446f, 
    -0.03207190f, -0.00201388f, -0.02998357f, -0.03013125f, -0.03591646f, -0.02566948f, 0.01096124f, -0.03425210f, 
    -0.04214063f, 0.01996501f, -0.01160136f, -0.00403701f, -0.01043238f, -0.02383733f, 0.00223278f, 0.01474745f, 
    0.02524163f, 0.01375335f, -0.03173361f, 0.00442002f, -0.00766297f, 0.00430295f, -0.00996679f, 0.02271852f, 
    -0.03284932f, -0.01511172f, -0.02181753f, -0.00182360f, -0.02072951f, 0.01526919f, -0.01502780f, -0.03079810f, 
    -0.02783213f, 0.03182752f, 0.01846038f, 0.00002268f, -0.03831398f, 0.00565810f, 0.02171643f, -0.02882888f, 
    0.02603226f, -0.01646981f, 0.03463564f, -0.02683389f, -0.01399466f, -0.00781228f, 0.02431460f, 0.03300124f, 
    0.00772908f, -0.04025926f, -0.04247476f, -0.03345678f, -0.02348862f, -0.03318076f, -0.01598542f, -0.02997134f, 
    -0.02131421f, -0.00245171f, -0.04351411f, -0.03778295f, 0.01159639f, -0.02043951f, -0.03169189f, -0.02371313f, 
    -0.01488362f, -0.01409541f, -0.03190108f, 0.01964975f, -0.01325243f, 0.02061366f, -0.00883493f, -0.03665620f, 
    0.02559712f, -0.04313317f, 0.02155725f, 0.00254684f, -0.01778755f, -0.03160502f, 0.01351108f, -0.00165013f, 
    -0.03942909f, -0.02179409f, 0.01083566f, -0.00678310f, -0.01078243f, 0.00737957f, -0.03731801f, 0.00403132f, 
    -0.01024808f, 0.02525379f, -0.02272839f, -0.00140882f, -0.04266353f, 0.00837737f, -0.03085206f, 0.01383409f, 
    -0.02023641f, 0.01383349f, 0.02797704f, -0.02820036f, -0.01635281f, -0.01511817f, -0.02578852f, 0.02606748f, 
    0.00096185f, 0.00946927f, 0.01865555f, 0.00380557f, 0.00911741f, -0.03720058f, -0.02974435f, 0.00784038f, 
    0.02315488f, 0.00431508f, -0.02626505f, -0.03641750f, -0.00019075f, -0.01871715f, 0.03060113f, -0.02090601f, 
    -0.00434139f, -0.01941713f, -0.01203489f, 0.01534903f, -0.02436672f, -0.00237448f, -0.00091125f, -0.00733176f, 
    -0.02756484f, -0.01933592f, 0.02814916f, -0.02297317f, 0.02551975f, -0.02080098f, -0.02307056f, -0.02475568f, 
    -0.02861892f, -0.02717848f, -0.02609340f, 0.01125312f, -0.01566747f, -0.01241175f, -0.04233449f, 0.00374683f, 
    0.01830247f, 0.00744234f, 0.00423306f, -0.02409567f, 0.01570217f, -0.02690675f, -0.01937797f, 0.00400784f, 
    -0.04010846f, 0.01789933f, 0.02982654f, -0.02107812f, 0.02492702f, -0.00066779f, -0.04287513f, 0.00172267f, 
    0.01076695f, -0.03998315f, -0.00145693f, 0.02193016f, -0.02348829f, -0.00090829f, -0.01244318f, -0.00718037f, 
    -0.02689284f, -0.01416249f, -0.01776323f, -0.01681650f, 0.02590846f, 0.02221464f, -0.02208999f, 0.03741871f, 
    0.01676040f, -0.02029969f, -0.03967959f, -0.00423729f, -0.02956209f, -0.00908213f, -0.03558531f, 0.00709424f, 
    -0.03255254f, 0.00070636f, 0.02066942f, -0.03320400f, 0.00615179f, 0.00348936f, 0.03183504f, 0.03883592f, 
    0.01997671f, 0.02089301f, -0.00119826f, -0.00384298f, -0.01523130f, 0.03794904f, -0.01844762f, -0.00052280f, 
    -0.00311059f, -0.00552915f, -0.00612111f, -0.01168093f, 0.00147774f, -0.00964581f, -0.03585325f, -0.03223530f, 
    -0.03883526f, 0.01821765f, 0.01088134f, -0.03453500f, -0.00436370f, -0.01157018f, -0.00509223f, -0.01134994f, 
    -0.01166747f, 0.00460085f, 0.01192932f, -0.04322960f, -0.02405845f, 0.02103365f, -0.01721147f, -0.01414716f, 
    0.04898698f, 0.05600828f, 0.08013189f, -0.08383347f, 0.07877681f, 0.07459673f, 0.12074789f, 0.17895931f, 
    0.01994571f, 0.00688290f, 0.01200790f, -0.28318098f, -0.31554884f, -0.22573704f, 0.08545919f, 0.07925214f, 
    -0.18566814f, 0.05402998f, -0.00730320f, -0.00630959f, -0.12444145f, -0.08057232f, 0.00392201f, -0.01364761f, 
    -0.15294339f, 0.03810614f, -0.16395135f, 0.04214318f, -0.07195311f, 0.00212627f, -0.05491995f, 0.08102827f, 
    0.18618919f, -0.02813115f, 0.05399228f, -0.03785580f, 0.01818973f, 0.10663262f, 0.11994791f, -0.08277505f, 
    -0.04294368f, -0.02746856f, -0.07668775f, 0.02089502f, 0.16985077f, 0.00320602f, 0.06341521f, 0.05528887f, 
    0.01030532f, 0.03201331f, 0.04006919f, -0.10433124f, -0.08286769f, -0.08761678f, 0.10593768f, 0.08207881f, 
    -0.09548139f, -0.14378521f, -0.03249587f, -0.09351988f, 0.09280949f, 0.06259051f, 0.11801176f, 0.13556033f, 
    0.02572466f, -0.09988029f, -0.03630277f, -0.03205129f, 0.28741556f, 0.04719292f, 0.31062794f, 0.12423734f, 
    -0.19931781f, 0.07500426f, 0.18308194f, 0.09830666f, 0.01072975f, -0.12880585f, -0.09940695f, -0.09100697f, 
    0.23629449f, 0.13788904f, 0.04832836f, 0.26759711f, -0.20588520f, -0.07659014f, -0.01874395f, -0.04842637f, 
    0.07548240f, 0.18121056f, -0.07870067f, -0.06638225f, -0.04989376f, -0.03555247f, -0.08106496f, 0.06173198f, 
    0.09397374f, -0.06995182f, 0.01933432f, -0.05220207f, 0.00162871f, 0.02642957f, 0.10503365f, -0.08919916f, 
    -0.03474868f, -0.08962730f, 0.00455905f, -0.07603506f, 0.11318098f, 0.10881340f, 0.01521814f, 0.07273945f, 
    -0.04076832f, -0.05084675f, 0.01418826f, 0.06187255f, 0.17312518f, 0.00497114f, 0.00992047f, 0.34461403f, 
    -0.34641629f, -0.18262704f, 0.06126329f, -0.04043205f, 0.02001977f, 0.06676555f, 0.03899354f, -0.06619932f, 
    0.07148359f, 0.00720423f, 0.00407102f, -0.12027514f, 0.12526883f, -0.00516891f, -0.06254326f, 0.03033684f, 
    0.14347847f, 0.06684595f, 0.29196426f, 0.17067622f, -0.13510945f, -0.02348392f, 0.14167508f, -0.21402857f, 
    0.10024435f, -0.03837996f, -0.02612139f, -0.09261617f, 0.19966458f, 0.02199514f, 0.04740341f, -0.05187024f, 
    -0.17204745f, -0.05989303f, 0.03166802f, -0.06399989f, -0.11884429f, -0.00719575f, -0.01153159f, -0.06786269f, 
    -0.12626182f, -0.09152492f, -0.05657379f, -0.02481680f, 0.09455980f, -0.04067004f, 0.02657116f, 0.03471948f, 
    -0.06602444f, 0.29109365f, -0.07865390f, -0.08741100f, -0.06547259f, -0.04208677f, -0.02735359f, 0.07822747f, 
    0.01936172f, -0.14763825f, 0.08550502f, -0.00569202f, -0.00315506f, 0.04612816f, 0.06370219f, 0.08575420f, 
    0.12843767f, 0.07046349f, 0.09760153f, 0.20631270f, -0.07595736f, 0.15614574f, 0.24617793f, 0.07201810f, 
    0.32328823f, 0.01693148f, 0.01351239f, 0.11557559f, -0.12821935f, -0.15276825f, -0.13899980f, -0.07189519f, 
    0.06083860f, -0.01013811f, -0.09433607f, 0.22513683f, -0.16684571f, -0.06191438f, 0.26767695f, 0.30321568f, 
    0.04584168f, 0.08319215f, 0.09118743f, -0.00937078f, 0.04620519f, 0.08061932f, 0.12762903f, 0.12005541f, 
    -0.13836670f, 0.01576885f, -0.01494584f, -0.04587076f, -0.04631401f, -0.07634602f, -0.05985789f, -0.08136142f, 
    0.01066843f, -0.12106036f, 0.04040116f, -0.00157159f, 0.00729650f, 0.11956068f, 0.12348025f, -0.07574575f, 
    0.00052936f, 0.00653275f, -0.05004421f, 0.05619232f, -0.03860240f, 0.27665678f, 0.24567093f, 0.16940513f, 
    0.27216470f, -0.16233844f, -0.24841385f, 0.02283164f, 0.10479472f, 0.16327879f, 0.07327630f, 0.25731888f, 
    -0.15266468f, -0.02144564f, -0.09431285f, -0.17965347f, -0.31955713f, 0.14852074f, 0.18669340f, -0.28241119f, 
    -0.09864248f, -0.01169742f, 0.10740820f, 0.00276240f, -0.06120706f, -0.05641397f, -0.07855714f, -0.32776043f, 
    -0.14766908f, -0.03065727f, 0.00651885f, 0.12673078f, -0.06824316f, -0.03767619f, 0.00302384f, 0.09261999f, 
    0.32724744f, 0.01445836f, 0.13112053f, 0.02658611f, 0.01625492f, -0.08555327f, -0.36158755f, 0.16602965f, 
    0.30881843f, 0.05816614f, 0.28499243f, 0.16659774f, -0.02431983f, 0.09856795f, -0.06214333f, -0.08527672f, 
    -0.03848624f, 0.07219073f, -0.07416312f, -0.07689133f, -0.01566119f, -0.10949962f, 0.07419381f, -0.05732598f, 
    0.04033422f, -0.03487366f, -0.00407728f, -0.00363312f, -0.36312154f, 0.22988500f, 0.11814906f, -0.02832543f, 
    0.01015480f, 0.07590085f, -0.10675011f, 0.41800308f, 0.16530363f, -0.05712224f, -0.14922446f, 0.07994956f, 
    -0.25683391f, -0.06727678f, -0.06148117f, -0.24767938f, -0.01185361f, -0.03893501f, 0.08286849f, 0.10872027f, 
    0.00103100f, -0.03161971f, -0.02792520f, 0.11436962f, -0.10732164f, -0.20272274f, 0.08857468f, -0.07996255f, 
    0.00664428f, -0.10380547f, -0.06862497f, -0.19772752f, -0.17242323f, -0.01294896f, -0.01204395f, 0.10160743f, 
    -0.11310195f, -0.10602063f, -0.03569788f, -0.07841723f, 0.01869703f, -0.18924461f, -0.24495426f, -0.12407101f, 
    0.17008972f, 0.08230443f, 0.03706519f, 0.11336253f, 0.21975133f, 0.02492787f, 0.00612131f, -0.08034216f, 
    0.08965708f, 0.11573631f, 0.12247512f, 0.05789508f, 0.14526920f, 0.07365888f, -0.05358131f, 0.09414414f, 
    0.17643538f, -0.16590983f, -0.11555019f, -0.01785581f, 0.10137610f, 0.07270624f, 0.11096229f, 0.21274178f, 
    0.33027661f, 0.10572742f, 0.10482563f, -0.14165220f, -0.15207183f, 0.08370721f, 0.17055655f, 0.09446456f, 
    -0.16326426f, 0.04683436f, -0.00421950f, 0.01731345f, 0.19093993f, 0.00592419f, 0.10732142f, 0.14982635f, 
    -0.15063104f, -0.10796126f, -0.16267173f, -0.03273607f, -0.06451714f, -0.08795592f, -0.07552715f, -0.15141895f, 
    0.05750355f, 0.12550025f, 0.08713765f, -0.05980262f, -0.04931358f, -0.05511747f, 0.07454309f, 0.00989724f, 
    -0.18078648f, -0.16535820f, 0.01173383f, 0.03857815f, -0.01270721f, 0.10763144f, 0.01019744f, 0.03161516f, 
    0.10781890f, 0.01838744f, 0.25669834f, -0.05883766f, 0.08204117f, -0.06231752f, -0.05212912f, 0.02853242f, 
    -0.09009259f, -0.06622839f, -0.01664782f, -0.21161099f, 0.39344299f, -0.18101524f, -0.24495836f, 0.16485722f, 
    0.12712918f, 0.05245946f, 0.14259811f, -0.01456819f, 0.15896477f, -0.00755915f, 0.09412441f, -0.00949771f, 
    0.46440187f, 0.11307316f, -0.21038112f, -0.07875267f, 0.12179919f, 0.10245745f, 0.22686505f, 0.02474322f, 
    0.03866597f, -0.03811667f, 0.01205730f, -0.01197844f, -0.13759245f, 0.05146709f, 0.17458177f, 0.05305256f, 
    -0.03984735f, 0.00398305f, 0.10487437f, 0.28528258f, 0.18070567f, -0.16566096f, 0.16472505f, 0.00943816f, 
    -0.20798469f, -0.16456130f, 0.12245239f, -0.20287427f, -0.18021189f, -0.01384262f, 0.04552038f, -0.08801880f, 
    0.12406034f, 0.12062317f, 0.07735170f, -0.02778041f, -0.05724239f, -0.01989669f, -0.02059264f, 0.03062215f, 
    0.06598294f, 0.02953540f, -0.09344275f, -0.06462202f, 0.09701759f, 0.04388701f, 0.00276677f, -0.03895376f, 
    0.02164562f, -0.04354491f, 0.15295294f, 0.00746488f, -0.09740910f, -0.03602671f, 0.00087558f, 0.05579179f, 
    0.04167381f, -0.09679119f, -0.11284318f, -0.07008258f, -0.22149740f, -0.19528064f, -0.03018788f, -0.17524467f, 
    -0.03112974f, -0.05920552f, -0.04257287f, -0.01440741f, 0.05901705f, -0.03696794f, -0.01476971f, 0.08435652f, 
    0.04849683f, -0.24286160f, -0.13572751f, -0.09623285f, 0.01175485f, 0.02907387f, -0.08497958f, -0.02048811f, 
    0.07360429f, 0.10696843f, -0.11777312f, 0.16337733f, -0.19850414f, -0.07997993f, -0.03447083f, 0.09197039f, 
    0.07725602f, 0.03252338f, 0.10662028f, 0.21817595f, -0.11696897f, -0.16502236f, -0.06275921f, 0.09995423f, 
    -0.25402316f, 0.12395009f, 0.12686449f, -0.09179978f, 0.07946108f, 0.06937526f, -0.01652805f, 0.10693108f, 
    0.02770592f, 0.01922881f, -0.06567684f, -0.15832317f, -0.09684059f, 0.12644355f, 0.09384071f, -0.08182546f, 
    0.21026403f, -0.12522973f, 0.14321317f, -0.08792728f, 0.04656041f, 0.09209717f, 0.22667649f, 0.17177510f, 
    -0.04933150f, -0.02851840f, -0.03788596f, 0.05677620f, 0.00931922f, -0.05843643f, -0.09327817f, -0.04681132f, 
    -0.07921123f, 0.17890386f, 0.01285415f, 0.09774387f, 0.09637816f, 0.00330892f, 0.05712820f, 0.10527328f, 
    0.16036345f, -0.01319596f, 0.24399641f, 0.24916694f, 0.07114978f, 0.18988821f, -0.02486061f, -0.06265692f, 
    -0.17098969f, -0.01043937f, 0.11391664f, -0.07003172f, -0.16386513f, -0.02687354f, -0.10828996f, 0.14660388f, 
    0.12507375f, 0.06452017f, -0.01351147f, 0.06537344f, 0.21880551f, 0.02071825f, 0.18928836f, -0.05547554f, 
    -0.07123005f, 0.02422369f, -0.02093220f, 0.08388527f, 0.03271974f, 0.03048952f, 0.16784503f, 0.07794212f, 
    0.15654860f, 0.17419423f, 0.04609520f, 0.03298529f, 0.00927219f, 0.02022436f, 0.14395420f, -0.01337431f, 
    -0.01113057f, -0.01687213f, -0.06902686f, 0.03032731f, -0.50251603f, -0.03785602f, -0.01893592f, -0.09487436f, 
    0.02346736f, -0.03968750f, -0.10124846f, 0.01697891f, 0.15529536f, 0.09668165f, 0.07180577f, 0.05862606f, 
    0.13102150f, 0.19165339f, -0.11136632f, 0.09454989f, -0.00348844f, -0.14552644f, 0.14505467f, 0.04359761f, 
    0.11020789f, 0.10143084f, -0.07172895f, 0.17983598f, -0.08865735f, 0.19861293f, 0.04265315f, -0.02933441f, 
    0.09516846f, 0.32763806f, 0.01401410f, 0.12342504f, 0.01383991f, -0.00785248f, 0.11165951f, 0.25366774f, 
    -0.21474443f, 0.02971343f, 0.00210110f, -0.06581195f, -0.07232839f, -0.02470455f, 0.05086700f, -0.09952064f, 
    0.01835908f, 0.04686086f, 0.04301978f, 0.06281758f, -0.15929371f, -0.03487415f, -0.09727401f, -0.09525491f, 
    0.18298949f, -0.07713203f, 0.10979383f, -0.17600319f, -0.00959294f, -0.06706162f, -0.04176022f, 0.06581470f, 
    -0.44933963f, -0.08561745f, -0.12951727f, -0.05860493f, 0.10956176f, 0.04126156f, 0.01861872f, 0.06467114f, 
    -0.09814743f, -0.01375872f, -0.03523285f, -0.07497127f, -0.13631563f, 0.02955730f, 0.13868539f, -0.08708673f, 
    -0.00698836f, 0.05373012f, 0.19591919f, 0.07743204f, 0.22185017f, 0.14812611f, 0.09437658f, 0.02320014f, 
    -0.01122841f, 0.20824452f, 0.10610764f, -0.27418253f, 0.00364722f, -0.13399106f, -0.03751029f, -0.04022566f, 
    -0.08089190f, -0.02712192f, -0.06493661f, -0.08178127f, 0.06301089f, -0.02191798f, -0.12878166f, 0.01077699f, 
    0.20615192f, -0.01098113f, 0.14685409f, 0.17150062f, -0.01099041f, -0.07103933f, 0.00203840f, 0.03303585f, 
    -0.16975103f, 0.00042106f, 0.06368126f, -0.06494249f, 0.03840358f, -0.04294959f, -0.05733226f, -0.05227191f, 
    0.05182771f, 0.00636399f, 0.02177886f, 0.20678467f, 0.19430345f, 0.11245327f, -0.19334510f, -0.01729998f, 
    0.09319068f, 0.03464216f, 0.15420797f, 0.06782489f, 0.08012225f, 0.17802685f, 0.02450917f, 0.04664459f, 
    0.11515121f, -0.03530163f, -0.01749778f, 0.26589453f, -0.10661184f, 0.09228823f, -0.02798581f, 0.12637213f, 
    0.30215088f, 0.09307491f, 0.13870512f, 0.28260115f, -0.62730598f, 0.09613232f, 0.23147097f, 0.08505199f, 
    -0.08259130f, -0.01841933f, -0.10358398f, 0.04231171f, 0.18952903f, 0.19171795f, 0.14918886f, -0.11802889f, 
    -0.03222696f, 0.01321073f, -0.03524286f, 0.00713663f, 0.02560456f, 0.01974930f, 0.02745276f, -0.01364568f, 
    0.02251774f, -0.00500220f, 0.01891232f, -0.01159409f, -0.02220369f, 0.02803237f, 0.00982793f, -0.00198288f, 
    -0.01567531f, 0.00426090f, -0.00448861f, -0.01563615f, 0.02376119f, -0.02002609f, -0.02995125f, 0.02166365f, 
    -0.02546799f, -0.01686136f, 0.01289087f, 0.00727560f, 0.00740284f, 0.02002601f, 0.00253538f, -0.00033577f, 
    0.00781740f, -0.02459826f, -0.01292452f, 0.00885130f, -0.00016353f, 0.02150908f, -0.01587828f, -0.00659493f, 
    0.01229448f, 0.03059202f, -0.01254789f, -0.04171466f, 0.01266175f, 0.00306856f, 0.01138675f, -0.01332939f, 
    -0.02760551f, 0.02713662f, 0.02045419f, -0.02311105f, 0.00567027f, -0.00130082f, 0.00968057f, 0.01603341f, 
    -0.03542954f, -0.02327960f, -0.02073752f, 0.02547671f, -0.03933933f, -0.03769939f, -0.02555799f, -0.01053432f, 
    0.02893905f, 0.01408467f, 0.02240809f, -0.00179365f, 0.01596413f, 0.00051687f, -0.02209309f, 0.02426875f, 
    -0.01512868f, -0.01298527f, 0.00598773f, -0.02470599f, -0.00795289f, -0.01911718f, -0.01004794f, -0.01980907f, 
    -0.02322788f, 0.02066080f, -0.02311569f, -0.01084133f, 0.01015993f, 0.00942896f, -0.02227290f, 0.00306660f, 
    -0.00032795f, 0.00390614f, -0.03351814f, 0.02550411f, -0.01219572f, -0.02019854f, -0.04178872f, -0.02749965f, 
    -0.02121314f, -0.01593697f, -0.02770409f, -0.00453402f, 0.01652279f, -0.03810479f, -0.03109678f, 0.01671018f, 
    -0.01293248f, -0.00515384f, -0.04444628f, -0.01525176f, -0.01501946f, 0.02804989f, -0.03295074f, 0.01772969f, 
    -0.00576802f, 0.02629771f, -0.00875181f, -0.01968110f, -0.01995541f, 0.02441880f, 0.01007587f, -0.01666159f, 
    -0.03070728f, -0.01005639f, 0.01084068f, 0.01872633f, -0.00921133f, 0.01229766f, 0.00085921f, 0.01488954f, 
    0.00671036f, -0.00187292f, -0.04211919f, -0.03896437f, -0.00296623f, -0.02446400f, -0.00783873f, -0.01359952f, 
    0.01636563f, -0.00660766f, -0.02512449f, -0.00355448f, -0.04342723f, -0.02357866f, 0.00436307f, -0.02690877f, 
    0.02457099f, -0.01275408f, -0.01212438f, -0.03420432f, -0.00390233f, -0.00073415f, 0.02926610f, 0.00164706f, 
    0.02491563f, -0.01525017f, -0.01539787f, -0.01408695f, 0.02035853f, -0.02816602f, -0.02240397f, 0.02035938f, 
    -0.00131931f, 0.02841116f, 0.00477783f, 0.02628911f, -0.01441803f, -0.03687268f, -0.00525148f, 0.04451011f, 
    0.00140362f, -0.02151505f, 0.03033480f, -0.00670744f, -0.03641135f, -0.04065550f, -0.04211234f, -0.01851402f, 
    -0.02120360f, 0.03285034f, -0.03638849f, -0.03309877f, -0.02479252f, 0.02845033f, 0.02335681f, 0.00406502f, 
    -0.04367114f, 0.02595193f, -0.01580180f, 0.00606274f, -0.02829629f, 0.02729589f, -0.03612811f, -0.03810150f, 
    -0.00449210f, -0.00953662f, 0.03412664f, -0.02542560f, -0.00994455f, -0.03859729f, 0.01774998f, 0.02165704f, 
    0.01020581f, -0.03285370f, 0.01201836f, -0.00709803f, 0.01622807f, 0.02257145f, 0.00567067f, -0.00197128f, 
    -0.03130740f, 0.00277309f, 0.01983172f, -0.03816888f, -0.03047486f, -0.03274118f, -0.03348662f, -0.02397880f, 
    -0.03933721f, 0.02047567f, 0.02655282f, 0.00917131f, -0.01436224f, -0.01683068f, -0.00025578f, -0.03298403f, 
    0.00795719f, 0.01387450f, 0.00442435f, 0.02318898f, -0.01650440f, -0.00201809f, 0.02883816f, 0.00137749f, 
    0.02214726f, -0.03701499f, 0.01661226f, 0.00252232f, -0.02446739f, 0.02785582f, 0.01614762f, -0.00863986f, 
    -0.02293754f, -0.03883715f, -0.00671779f, -0.00106869f, -0.01483314f, 0.00431158f, -0.02223020f, -0.00186274f, 
    -0.02813980f, 0.01355285f, -0.02186360f, -0.00612019f, -0.03705505f, -0.03194324f, 0.01425434f, -0.04194733f, 
    -0.02725914f, -0.00358821f, 0.00737045f, 0.02531721f, -0.02000169f, 0.02414802f, -0.02471785f, -0.01035129f, 
    -0.01806293f, -0.03542325f, -0.02153272f, 0.00151100f, 0.02975715f, -0.02975358f, -0.02632336f, -0.00366108f, 
    -0.00443615f, 0.01269502f, -0.02631621f, -0.03849579f, -0.02061176f, -0.04146793f, 0.00327547f, -0.02366684f, 
    0.02966694f, 0.00279287f, -0.02754061f, -0.00725180f, -0.01910358f, -0.03777404f, 0.00138186f, -0.02913637f, 
    0.02397476f, 0.01972517f, -0.02710894f, 0.01210005f, -0.00314719f, -0.03020096f, 0.02326516f, -0.01215385f, 
    -0.02560427f, 0.01316570f, 0.02728515f, -0.00325318f, -0.03722041f, -0.01871617f, 0.02439147f, -0.00433631f, 
    -0.04092830f, -0.03285576f, 0.02014897f, -0.01975646f, 0.02216256f, -0.02525078f, -0.01775865f, -0.02175855f, 
    -0.01957940f, -0.03823059f, 0.01957427f, 0.00463090f, -0.03807212f, -0.01216389f, -0.00466922f, -0.00274464f, 
    -0.02121472f, 0.02590710f, -0.04399606f, 0.02609922f, 0.00167957f, 0.02397602f, -0.02106000f, -0.01959188f, 
    -0.03809173f, 0.00452258f, -0.03566346f, -0.04037410f, 0.00424455f, 0.03027869f, 0.02818941f, -0.01883476f, 
    0.02544768f, -0.01846602f, 0.01183027f, 0.01883213f, -0.03334189f, -0.01404110f, 0.01865606f, 0.01473811f, 
    -0.01526120f, 0.02624467f, -0.00870720f, 0.02376592f, -0.00751079f, 0.00195970f, 0.00636501f, -0.01489525f, 
    -0.00449046f, -0.02971164f, -0.01947989f, -0.03016476f, -0.02267804f, -0.03768965f, 0.00616606f, -0.02097043f, 
    0.00435870f, -0.04352647f, 0.01825622f, 0.00476628f, 0.02172684f, -0.00737529f, 0.01210807f, -0.02480403f, 
    -0.03025187f, -0.03716172f, 0.00566694f, 0.00109965f, -0.00027065f, -0.00345500f, -0.01802643f, -0.00908550f, 
    -0.02088290f, 0.01252003f, -0.01221106f, -0.02569605f, 0.01491295f, 0.01583226f, 0.01543579f, -0.00378102f, 
    0.02371264f, -0.01971366f, -0.00093351f, 0.02730987f, -0.04364857f, -0.02743175f, 0.01625551f, 0.01028939f, 
    -0.02691926f, -0.01545952f, -0.01499644f, 0.02545600f, -0.00099509f, 0.02808160f, -0.00696032f, 0.03049431f, 
    -0.00515980f, 0.02010212f, -0.03057639f, 0.01180789f, -0.00829613f, -0.03719438f, -0.02089415f, 0.01017560f, 
    -0.02206982f, -0.01520810f, 0.01617790f, 0.01338645f, -0.03687520f, 0.00810654f, -0.01062268f, -0.00463595f, 
    0.00202472f, 0.01803535f, 0.01688392f, 0.02322772f, 0.03206503f, 0.02544121f, 0.01591265f, -0.02105342f, 
    -0.00161337f, -0.02100591f, 0.02154256f, -0.03319579f, -0.01377990f, -0.02218375f, 0.01491695f, -0.03114653f, 
    -0.00594443f, -0.04118625f, -0.02815017f, -0.01074951f, -0.03737845f, 0.02376584f, 0.01623337f, 0.02223581f, 
    -0.03608560f, 0.00719423f, -0.00220281f, 0.01895546f, -0.00933971f, 0.01739472f, 0.01869937f, 0.00970725f, 
    -0.00180101f, -0.00029920f, -0.04265403f, 0.02740368f, 0.03273197f, 0.01926495f, 0.00597829f, 0.01157079f, 
    -0.01568528f, 0.00395922f, -0.00103913f, -0.03642021f, -0.03816913f, -0.02788021f, -0.03644905f, 0.00938128f, 
    0.00400460f, -0.03352126f, -0.03838804f, 0.02029828f, -0.00679347f, 0.03135738f, 0.03206353f, -0.00744677f, 
    -0.03265424f, -0.03583262f, 0.00793663f, -0.03133487f, -0.01719813f, -0.01182380f, 0.02147960f, 0.03223049f, 
    -0.02361832f, 0.02590562f, -0.04246906f, 0.02381736f, 0.01836093f, -0.03006319f, -0.03871617f, -0.03228807f, 
    0.02513586f, -0.03641412f, -0.03738364f, -0.03952622f, -0.02387634f, 0.00057391f, -0.02038494f, -0.00737125f, 
    -0.01394997f, 0.00112838f, -0.00356820f, -0.01966003f, -0.03906897f, 0.01801037f, -0.00122174f, 0.00761612f, 
    0.02639418f, -0.02178394f, 0.04012716f, 0.01071486f, 0.02513001f, -0.00357550f, -0.02290957f, 0.00499889f, 
    -0.00842159f, 0.01500737f, 0.00222053f, 0.02865171f, 0.02600548f, -0.01576088f, 0.00285756f, 0.02649039f, 
    -0.01141917f, -0.02538664f, -0.03306631f, 0.00033705f, 0.01823116f, 0.01152641f, 0.01219721f, 0.00892619f, 
    0.00852575f, -0.01610980f, 0.02348613f, 0.01847133f, 0.03404821f, -0.02747525f, 0.00756528f, -0.00048925f, 
    -0.01536588f, 0.00514905f, -0.02005328f, 0.01724410f, 0.02706558f, -0.03526015f, -0.01315855f, 0.00267168f, 
    -0.03101162f, 0.01327648f, -0.00956950f, -0.03720776f, 0.00290254f, 0.02711187f, -0.01523015f, -0.02948981f, 
    0.01582726f, 0.01503297f, -0.02502918f, 0.02105497f, -0.00073732f, -0.02314403f, 0.02509755f, -0.02752144f, 
    0.02373446f, -0.01754984f, 0.00287883f, 0.03656046f, 0.02319900f, -0.00421445f, -0.02458142f, -0.02317247f, 
    0.00142562f, -0.00264012f, 0.02644524f, -0.03530436f, 0.01389700f, -0.00842725f, -0.00362876f, -0.01225790f, 
    -0.01637424f, -0.03973446f, 0.03351891f, -0.03913222f, 0.01681836f, 0.03164474f, 0.00092171f, 0.03801030f, 
    0.00484211f, 0.01848433f, -0.01416859f, 0.02858970f, -0.02569523f, 0.02795875f, -0.04055690f, 0.04424269f, 
    0.03210276f, 0.02606486f, 0.00087805f, 0.00596161f, -0.01000356f, 0.02639927f, -0.03353431f, 0.02624719f, 
    -0.00438550f, -0.01367685f, -0.00422833f, -0.02027886f, -0.02321750f, -0.00558508f, 0.00542697f, -0.00389935f, 
    0.02085670f, -0.02204644f, 0.01503953f, -0.01192410f, 0.01788636f, -0.03508270f, -0.02315656f, 0.00103036f, 
    0.02324619f, -0.02274808f, -0.01191095f, 0.02445072f, 0.02541336f, 0.02370491f, -0.00049037f, -0.03289433f, 
    -0.01358987f, -0.01074847f, -0.00917401f, 0.03556440f, -0.03394737f, 0.02206014f, -0.03270016f, -0.00206645f, 
    -0.04141801f, 0.01558681f, 0.01921315f, -0.01810663f, -0.00884304f, -0.02275723f, -0.03651295f, -0.00538167f, 
    -0.01930895f, 0.00958369f, 0.00682461f, 0.02785635f, 0.01778568f, -0.00548189f, -0.01018559f, 0.02372563f, 
    0.01744797f, 0.00530041f, -0.01758112f, -0.01292935f, 0.02548813f, 0.00031578f, 0.00132256f, -0.00559064f, 
    0.03150177f, -0.03042777f, -0.01987408f, -0.01164019f, 0.02634643f, -0.03785610f, 0.01590310f, -0.02587247f, 
    -0.00948642f, 0.02550990f, -0.00637617f, 0.01872041f, -0.00712311f, 0.00101470f, -0.02729162f, -0.03237458f, 
    -0.00342749f, -0.01629349f, -0.01456830f, -0.00388291f, 0.02538079f, -0.01022305f, -0.02020707f, -0.03285900f, 
    -0.01297521f, -0.04189088f, 0.00704040f, -0.01926428f, 0.02345133f, -0.03118860f, 0.02515838f, 0.00182800f, 
    -0.00599766f, -0.00480668f, -0.01200799f, -0.03399570f, -0.02215875f, -0.01412152f, -0.04349031f, -0.01140788f, 
    0.01315133f, -0.00249527f, -0.00800405f, -0.01629538f, 0.02664233f, -0.04067486f, -0.03629297f, -0.03135800f, 
    0.03313431f, -0.00089825f, -0.03948482f, -0.02333874f, -0.01860808f, -0.03236423f, 0.04108767f, 0.01629856f, 
    -0.02544718f, 0.02721822f, 0.01510188f, -0.02010385f, -0.01905837f, -0.01090411f, -0.02769795f, 0.01580074f, 
    0.00477613f, -0.02711468f, -0.02310390f, -0.03085368f, -0.00262727f, -0.02932985f, -0.02458971f, 0.01086765f, 
    0.00560593f, -0.02267854f, 0.02675990f, -0.00671017f, -0.03570896f, 0.01736115f, 0.02977308f, 0.01180035f, 
    -0.00826436f, -0.00190248f, -0.03456533f, -0.03316424f, -0.01241519f, 0.02277106f, 0.00151753f, 0.00283383f, 
    0.01939207f, -0.00863877f, -0.03984084f, -0.03197423f, 0.01713979f, -0.00212273f, 0.01543577f, -0.01637203f, 
    -0.00899124f, -0.02127268f, -0.02569318f, -0.01451295f, -0.03497019f, -0.01422838f, 0.03272088f, 0.02718762f, 
    -0.01586654f, -0.01447567f, -0.00949190f, -0.00549321f, -0.00448882f, 0.01972225f, -0.01611697f, 0.02254113f, 
    -0.03699220f, -0.03251974f, 0.02381200f, -0.00903815f, 0.01016878f, -0.02839041f, -0.03305585f, 0.03303660f, 
    0.01438066f, 0.01345405f, -0.01204967f, 0.02542830f, 0.01368825f, -0.00932682f, -0.02426639f, 0.01591802f, 
    0.01093829f, -0.03406221f, -0.01793720f, 0.02092039f, -0.01104346f, -0.03615886f, 0.02046479f, -0.00244825f, 
    -0.01634337f, -0.02246646f, 0.02775927f, -0.02436956f, 0.00376010f, 0.01581124f, 0.01092127f, -0.00762611f, 
    -0.01525067f, -0.01387213f, 0.00473517f, -0.00294439f, 0.00929367f, 0.02365379f, -0.00896531f, -0.00027154f, 
    -0.03683782f, -0.02915946f, -0.01818408f, 0.02607572f, -0.03379162f, -0.01430797f, 0.01326245f, -0.02025498f, 
    0.01148306f, 0.02162598f, -0.02652301f, 0.01351092f, -0.03850076f, 0.01393349f, 0.00649191f, -0.03486411f, 
    0.00077670f, 0.00102872f, -0.02325882f, -0.01082705f, 0.03229309f, 0.03418519f, -0.02193853f, -0.02149246f, 
    -0.02516480f, 0.02111325f, -0.04223331f, -0.03077698f, -0.00664296f, -0.02416113f, -0.00591822f, 0.01976290f, 
    -0.00385152f, -0.00164813f, 0.01925550f, -0.03135128f, -0.02069391f, -0.00045176f, -0.04567537f, -0.03725493f, 
    0.01191950f, -0.01870831f, 0.00808763f, -0.03041298f, 0.00771772f, 0.02559876f, -0.00681217f, -0.01524254f, 
    0.01125559f, 0.01791307f, -0.03548988f, 0.01194682f, 0.02837852f, 0.02802540f, 0.01277366f, -0.01251594f, 
    0.00306005f, 0.02498163f, -0.00700065f, 0.00352363f, -0.00550018f, -0.02718648f, 0.00420184f, 0.01830518f, 
    0.00698522f, -0.03392654f, 0.01892476f, 0.00083606f, -0.02247639f, 0.00854532f, -0.01742055f, -0.03200679f, 
    -0.01847173f, -0.01662367f, -0.01259103f, -0.03419579f, -0.02323682f, 0.00632138f, 0.00318024f, 0.00859082f, 
    -0.01436629f, -0.00149303f, -0.02098510f, -0.01969532f, 0.00882271f, -0.00799248f, 0.02871352f, 0.00857938f, 
    0.00052756f, -0.00111447f, 0.01048854f, -0.02159781f, -0.00237108f, 0.01691006f, -0.02016740f, -0.02797822f, 
    0.02516452f, 0.00597276f, 0.02006378f, -0.03195493f, -0.00760104f, -0.02067178f, 0.02692903f, -0.02830847f, 
    -0.01172424f, -0.01890555f, 0.01640193f, 0.02202598f, 0.03028829f, 0.01812990f, -0.00571305f, 0.00577423f, 
    0.01642499f, -0.01508647f, 0.00682394f, 0.01472415f, 0.02080347f, 0.03122047f, -0.02703900f, 0.02452290f, 
    0.00081106f, -0.02461743f, 0.00052725f, 0.01290707f, 0.00457650f, 0.01008474f, 0.02028379f, -0.02059489f, 
    -0.00013258f, -0.00032074f, 0.00479326f, -0.00339255f, -0.00128352f, 0.00642950f, -0.02981084f, -0.02558956f, 
    -0.01931861f, -0.03565600f, -0.00202988f, -0.03716604f, -0.00525592f, 0.02555524f, 0.00353713f, -0.01385553f, 
    0.02048201f, -0.00277816f, -0.01501644f, 0.01238644f, -0.00001637f, -0.01400876f, 0.00560006f, 0.00010081f, 
    -0.00094749f, -0.02986377f, -0.02559217f, -0.03432048f, -0.02771818f, -0.01604517f, 0.01328972f, -0.03647118f, 
    0.00365858f, -0.02212448f, 0.00400730f, -0.01348235f, -0.03198080f, 0.02376029f, -0.00307926f, 0.01782176f, 
    -0.03200135f, -0.02593321f, -0.01652517f, -0.00144968f, 0.00221397f, -0.04058108f, 0.01652155f, 0.02691202f, 
    0.02339577f, 0.01764520f, -0.01474735f, -0.00200144f, -0.03070668f, -0.00636419f, 0.02008146f, -0.02209451f, 
    0.02127527f, -0.00996802f, -0.03664797f, -0.00429609f, -0.01155495f, -0.02577790f, 0.02286644f, 0.01260399f, 
    -0.03257412f, -0.03524895f, -0.00532811f, 0.00870302f, -0.03150046f, -0.01582052f, -0.00224295f, 0.01892227f, 
    -0.00564274f, -0.03427731f, -0.02995802f, -0.03060732f, -0.01726249f, 0.01943567f, -0.02304308f, -0.03077647f, 
    0.00156036f, -0.03255672f, -0.03073649f, -0.01105590f, 0.02129397f, 0.02735990f, 0.00984314f, 0.01444730f, 
    -0.00278959f, 0.01952824f, -0.02050867f, -0.02514851f, -0.00872050f, -0.03699198f, -0.00869367f, 0.01646313f, 
    -0.00323851f, 0.00898720f, 0.02165041f, -0.01564726f, -0.02992094f, -0.03365648f, 0.00384801f, -0.01886938f, 
    -0.03847943f, -0.03747442f, -0.02197910f, 0.02033151f, 0.00708327f, -0.01849732f, -0.02551747f, 0.00705601f, 
    0.02334858f, 0.01215560f, -0.02492634f, -0.01669645f, 0.03751219f, 0.01067862f, -0.01089520f, -0.03464014f, 
    0.02864496f, 0.02857353f, 0.02084539f, 0.02103188f, -0.02139930f, -0.01541097f, 0.00533697f, -0.03010795f, 
    -0.02597406f, -0.01344708f, -0.01239741f, -0.02304233f, 0.01009245f, 0.00480520f, 0.03095051f, 0.01917993f, 
    -0.01029289f, 0.01156317f, 0.01697485f, -0.00184558f, 0.00295994f, -0.00086226f, 0.01262722f, -0.00438359f, 
    -0.03962652f, 0.01940112f, -0.00644545f, -0.04044373f, -0.00916037f, -0.02698975f, 0.01195424f, -0.00680069f, 
    0.02603397f, 0.02307673f, -0.01263947f, 0.02753364f, 0.00291658f, -0.03667202f, -0.00789079f, 0.01344247f, 
    0.01815158f, -0.01766952f, 0.00930815f, -0.01371351f, 0.02693016f, 0.01946892f, -0.00471807f, -0.02155351f, 
    -0.02763886f, 0.00331227f, -0.01337628f, 0.01910304f, -0.01018178f, 0.01791190f, 0.00051527f, -0.00310722f, 
    -0.00877603f, -0.03527356f, 0.01162982f, -0.00586035f, -0.01053090f, -0.01735885f, -0.03938603f, 0.03093344f, 
    0.00884767f, -0.02602916f, 0.00236191f, 0.00118755f, -0.02388698f, -0.02895236f, 0.00222086f, 0.01578782f, 
    -0.02820959f, 0.00181465f, 0.01656114f, 0.02800192f, -0.02376954f, -0.02036009f, 0.00398412f, -0.00085038f, 
    0.01261247f, 0.01935693f, -0.02720639f, -0.01989125f, -0.02440759f, -0.02341259f, 0.03475180f, -0.00961018f, 
    0.02584645f, 0.01918824f, 0.00188532f, -0.02539279f, 0.01038975f, -0.01893128f, 0.01141690f, -0.00501584f, 
    0.03460783f, -0.01565812f, 0.03015532f, -0.01613327f, 0.02855638f, -0.02393493f, -0.02482959f, -0.02946632f, 
    -0.02067156f, -0.02488242f, -0.03535310f, -0.00211680f, 0.00376400f, 0.01044425f, 0.01202811f, -0.03026172f, 
    0.00252887f, -0.01138001f, -0.01207787f, 0.01866427f, 0.02625242f, 0.01789287f, -0.03672696f, 0.02691096f, 
    -0.01385938f, -0.00691688f, 0.03084824f, 0.02300081f, 0.03074669f, -0.03186199f, -0.00039942f, 0.01311432f, 
    0.01288326f, -0.04681323f, 0.00410307f, -0.00772857f, 0.02508373f, -0.04150799f, -0.02536719f, 0.00656079f, 
    0.01043359f, 0.00624269f, 0.01729580f, -0.01305194f, 0.02097371f, 0.00528720f, -0.00024897f, 0.02400059f, 
    -0.03228977f, -0.00062726f, 0.03670839f, 0.04081094f, -0.01466229f, -0.00722360f, -0.00514192f, -0.02645700f, 
    -0.03009529f, -0.03851749f, -0.00745295f, -0.02884159f, -0.01893787f, -0.02345309f, 0.01954683f, 0.02549063f, 
    -0.02356726f, -0.00291958f, -0.00825064f, -0.00784219f, -0.01017798f, 0.01581898f, -0.02461012f, 0.03592472f, 
    0.00674010f, -0.01380801f, 0.00630614f, 0.00545253f, -0.02718162f, 0.01945804f, 0.02021621f, 0.00092697f, 
    0.00695972f, -0.00088950f, -0.03901525f, -0.02896502f, 0.03229899f, 0.02472708f, 0.01567408f, -0.03482866f, 
    0.03154728f, 0.03029490f, -0.02599382f, -0.02732342f, -0.04140170f, -0.00347071f, 0.02691246f, 0.00945004f, 
    0.02792698f, 0.02822529f, 0.00300770f, -0.02759346f, -0.03096415f, -0.03377376f, 0.01899422f, -0.03985573f, 
    -0.03673372f, -0.01904992f, -0.02814531f, -0.02598541f, 0.00534198f, 0.02052646f, 0.00710426f, -0.01187783f, 
    -0.01137055f, -0.04489723f, -0.00085306f, 0.00983248f, 0.01662474f, -0.03613169f, 0.01731460f, -0.03886914f, 
    0.03141193f, 0.02382303f, -0.01851651f, -0.02749023f, -0.02533423f, 0.02321086f, 0.03042145f, 0.02629827f, 
    0.01905714f, -0.01647951f, -0.02123479f, -0.02314823f, 0.01126966f, -0.03491814f, -0.03933619f, -0.01378848f, 
    -0.01190185f, -0.00138729f, 0.02090899f, -0.00537295f, -0.03483251f, -0.03891282f, -0.04311090f, -0.00443886f, 
    -0.00603871f, -0.02176814f, -0.03024642f, -0.00193719f, -0.01791948f, 0.00252980f, -0.04045795f, -0.02102561f, 
    -0.02501005f, -0.00512330f, -0.00905974f, 0.01898855f, 0.01857645f, 0.01471960f, -0.02798341f, -0.02731864f, 
    -0.01643131f, -0.01234868f, -0.04040403f, -0.02243420f, -0.01871412f, 0.02059406f, -0.02283208f, -0.00781808f, 
    -0.00585438f, -0.02448180f, -0.01053709f, 0.00832913f, 0.02992633f, -0.02561927f, 0.00834915f, -0.02098903f, 
    0.00651747f, -0.00426876f, -0.04160457f, 0.02199576f, 0.01068141f, -0.00434166f, -0.03733542f, 0.03240997f, 
    0.03020657f, -0.01729012f, 0.02110501f, 0.02164526f, 0.01982658f, 0.00100180f, 0.02045006f, -0.00760541f, 
    0.00010395f, 0.02899938f, 0.01871410f, -0.03542138f, -0.03728982f, -0.02061824f, -0.01225652f, -0.01422163f, 
    0.00704004f, -0.03864993f, -0.02443407f, -0.04375685f, -0.02368759f, -0.01409114f, 0.01594690f, -0.00246593f, 
    -0.01947219f, -0.01027257f, -0.01959845f, 0.01161785f, 0.01585373f, 0.01981370f, -0.01266470f, 0.01898465f, 
    0.01470028f, -0.01708348f, 0.00739740f, 0.02188809f, 0.02034766f, -0.00971955f, -0.00914040f, -0.00485588f, 
    -0.00612877f, -0.01748910f, 0.00306456f, -0.01941765f, 0.02997117f, -0.02958545f, 0.00540312f, -0.02350699f, 
    0.00333975f, -0.03207125f, 0.00148455f, 0.01625947f, -0.03283700f, 0.00053741f, -0.03104507f, 0.00877860f, 
    0.01946395f, 0.00993957f, -0.00874349f, -0.01686403f, -0.00337594f, -0.03416307f, -0.01867962f, 0.01038857f, 
    0.02235968f, 0.01094344f, 0.01112920f, -0.00157972f, 0.00734060f, -0.00824048f, -0.01846865f, 0.01673403f, 
    -0.03157796f, -0.04529633f, -0.02795718f, -0.00166283f, 0.00644171f, -0.02379824f, 0.02728044f, 0.00569611f, 
    -0.00357459f, -0.01740601f, 0.01428683f, -0.01081467f, -0.00044147f, -0.00806494f, 0.00418960f, 0.01123691f, 
    0.01906167f, -0.02197549f, -0.00765389f, -0.02529220f, 0.01754135f, -0.02101249f, -0.03365931f, 0.01078407f, 
    -0.00878286f, -0.00884163f, -0.00813532f, -0.00699465f, -0.00650089f, -0.00952027f, -0.03107995f, 0.01092984f, 
    -0.01989110f, -0.01900150f, -0.03576562f, -0.00312050f, -0.00603999f, -0.01554974f, -0.02914171f, 0.02719887f, 
    -0.01023903f, 0.00633335f, 0.01149409f, -0.04074915f, -0.03969198f, 0.00339152f, -0.01762702f, -0.02768466f, 
    0.01170958f, 0.02623076f, -0.03632678f, -0.00724867f, -0.01173327f, 0.00914673f, -0.02416488f, -0.03708547f, 
    0.02430039f, -0.00043068f, 0.02885206f, 0.01637631f, -0.02070722f, 0.01891452f, -0.00891326f, -0.00270022f, 
    -0.03387778f, -0.00596428f, 0.03087342f, 0.00490560f, -0.02963902f, -0.00411788f, 0.02590314f, -0.00310275f, 
    0.01459592f, -0.01422817f, -0.03116934f, -0.01321785f, 0.00117808f, 0.00699799f, -0.03304395f, -0.02610476f, 
    0.02674685f, 0.01236590f, -0.00530481f, 0.02117418f, -0.02335646f, -0.03421703f, 0.02848374f, 0.01324912f, 
    0.03580640f, 0.00678497f, -0.00670050f, -0.03572462f, 0.01433581f, 0.00536099f, -0.02288144f, 0.00229522f, 
    0.02256378f, -0.00660494f, -0.02994026f, 0.00243906f, -0.00528553f, -0.04127493f, -0.00633092f, -0.00525843f, 
    0.01686066f, -0.01140530f, 0.02006042f, -0.04001272f, -0.02295059f, -0.04801416f, -0.01140201f, 0.00734924f, 
    -0.04254465f, -0.02234836f, 0.01448778f, -0.02937796f, -0.01106219f, -0.02724088f, -0.01462737f, 0.01281097f, 
    -0.01206622f, 0.03380661f, -0.03210151f, 0.03353931f, 0.00809041f, 0.00881359f, -0.03111886f, -0.01160143f, 
    0.00077853f, -0.12665962f, 0.09830489f, -0.21100217f, 0.18859735f, 0.04040649f, 0.03261574f, 0.15101032f, 
    -0.09904947f, 0.02251562f, -0.04961720f, -0.10101258f, -0.01689632f, -0.02847457f, -0.00210084f, -0.05655855f, 
    0.06364029f, 0.05987195f, 0.08238192f, -0.11261342f, -0.16203436f, -0.01896984f, -0.00624497f, -0.12920292f, 
    0.02554999f, -0.12083406f, -0.11839775f, 0.08505980f, -0.00170346f, 0.08838191f, -0.06980205f, -0.01729220f, 
    0.06720913f, -0.02710609f, -0.02082004f, -0.15950643f, -0.10549311f, 0.01965204f, -0.10377107f, -0.07324645f, 
    -0.02504441f, 0.03735919f, 0.02500155f, 0.02232570f, 0.06086691f, -0.08214571f, 0.05671487f, 0.06298628f, 
    -0.10351018f, -0.08009505f, -0.12585700f, -0.22021973f, -0.02054391f, -0.01334664f, 0.00470340f, 0.07750621f, 
    0.02188736f, -0.10071662f, -0.09977026f, -0.11556552f, -0.03042160f, -0.02190166f, 0.23121682f, -0.04085653f, 
    -0.01618610f, 0.07321285f, 0.03661830f, 0.01406125f, 0.25536969f, -0.00222926f, 0.30818239f, 0.07746780f, 
    -0.11562850f, 0.09639286f, 0.11914569f, 0.04352961f, 0.03540326f, 0.02377798f, 0.09199391f, -0.04654103f, 
    0.25571552f, 0.09087183f, 0.07271439f, 0.15788177f, -0.03969819f, 0.05615548f, -0.18481651f, 0.00740222f, 
    -0.14713371f, 0.02744616f, -0.15928991f, -0.00468635f, -0.19662057f, -0.01004094f, -0.14617880f, 0.04145900f, 
    0.15011445f, 0.04683430f, 0.12666537f, 0.00676434f, -0.11845200f, -0.01909128f, 0.10236266f, -0.16055781f, 
    -0.01769022f, -0.02148661f, -0.05321954f, -0.07078016f, 0.22245416f, 0.16765191f, 0.02716782f, 0.08049498f, 
    -0.04567515f, 0.01141897f, 0.11803128f, -0.00441704f, 0.04098291f, 0.05248670f, 0.03866893f, 0.09854371f, 
    -0.16979538f, 0.02213112f, -0.11221194f, -0.10470772f, 0.08457457f, 0.06885877f, -0.00233754f, -0.01310898f, 
    -0.10922483f, -0.05451689f, -0.00520976f, -0.14140327f, 0.10141476f, 0.01571039f, -0.12485019f, 0.10975702f, 
    0.10448007f, -0.00187678f, 0.16378064f, 0.01954810f, -0.15149453f, 0.03578151f, 0.09137978f, -0.16177982f, 
    0.34064695f, 0.16343899f, 0.16916116f, 0.03958045f, 0.01007211f, -0.06228555f, -0.00532339f, 0.00749594f, 
    -0.11314781f, -0.02841018f, 0.01108483f, -0.05278352f, 0.01463548f, 0.10729685f, 0.00840099f, -0.02155666f, 
    -0.06361761f, -0.06285035f, -0.01447843f, -0.05751316f, 0.04445647f, 0.02491956f, 0.01867123f, -0.03252439f, 
    0.01545827f, 0.19513127f, -0.06119173f, 0.04953989f, -0.05137325f, 0.02445184f, -0.00691646f, -0.03111660f, 
    -0.05507499f, 0.00674749f, -0.04448569f, -0.00643411f, 0.10820505f, -0.12702167f, -0.00775071f, 0.25626135f, 
    0.08762281f, 0.17494945f, 0.03911545f, -0.01007357f, 0.12347340f, 0.14342238f, 0.16713800f, 0.08234910f, 
    0.25064793f, 0.06179257f, 0.17138360f, 0.01278502f, -0.05957979f, -0.07441629f, -0.03779284f, 0.07593703f, 
    -0.00447498f, 0.00706621f, -0.04872835f, 0.20515570f, -0.30770424f, 0.13946016f, 0.17086333f, -0.09263416f, 
    0.07756563f, 0.10875472f, 0.18264538f, -0.04178506f, 0.10133047f, -0.04878037f, 0.30298054f, 0.01922714f, 
    -0.12171673f, 0.05216876f, 0.04785527f, -0.07994263f, 0.00111854f, -0.03591443f, 0.09363724f, -0.09168711f, 
    -0.14118877f, -0.11473299f, -0.04474477f, -0.16226825f, -0.14544733f, 0.15692376f, 0.04320351f, 0.03265326f, 
    0.03304764f, 0.06756027f, -0.00382806f, 0.08270872f, 0.07713370f, 0.19363606f, 0.10969815f, 0.17318791f, 
    0.19563608f, -0.41375050f, -0.00170312f, 0.11630457f, 0.10779857f, 0.10547775f, 0.07733659f, 0.07637282f, 
    -0.04167700f, -0.00905950f, -0.19914837f, -0.12319467f, -0.13533017f, -0.00814984f, -0.01608793f, -0.11905563f, 
    -0.05347564f, 0.00095783f, -0.04866572f, 0.03303587f, -0.08213599f, -0.04209630f, 0.08483054f, -0.10735349f, 
    -0.18767446f, 0.00725040f, -0.13789493f, 0.11675725f, -0.04575977f, -0.01274805f, 0.14760065f, -0.00574559f, 
    0.05460377f, 0.02501170f, 0.14536276f, 0.02527990f, -0.02436761f, -0.04096536f, 0.11139279f, 0.02211771f, 
    0.10019249f, 0.05794367f, 0.24830319f, 0.04643863f, 0.11975890f, -0.14327908f, -0.13592540f, -0.11136224f, 
    0.09430265f, 0.07834690f, 0.03443162f, -0.09807836f, 0.04569323f, -0.16316208f, 0.10350332f, -0.05524669f, 
    0.00250736f, -0.00113984f, -0.02939490f, -0.07266370f, -0.07618131f, 0.10546579f, 0.13760576f, -0.04845649f, 
    0.05901296f, -0.00359028f, -0.19835006f, 0.30911779f, -0.15108672f, 0.05259902f, -0.04865818f, -0.07749632f, 
    -0.11345585f, -0.05334870f, -0.07882605f, -0.13625228f, -0.05048091f, -0.15730713f, -0.04516451f, 0.13910821f, 
    -0.04347215f, -0.02250875f, -0.03238820f, -0.01105861f, -0.02082888f, -0.19336849f, -0.06144975f, -0.22899112f, 
    -0.19191550f, -0.09188245f, -0.07981253f, -0.11488887f, -0.14589535f, -0.02125345f, -0.04128158f, 0.10265052f, 
    -0.04868772f, 0.08310824f, -0.02436486f, 0.04105436f, 0.06007900f, -0.10653117f, -0.01793932f, 0.07579518f, 
    -0.04334654f, 0.01799174f, -0.08763371f, -0.09630185f, 0.14768539f, 0.25070217f, 0.07081980f, -0.10367885f, 
    -0.04577342f, 0.04900338f, 0.18271293f, 0.03211462f, -0.01423102f, 0.10532033f, 0.07891724f, -0.11315500f, 
    0.12044566f, -0.03665404f, -0.13637282f, 0.03235792f, 0.17112139f, 0.04617685f, 0.08057582f, 0.12206776f, 
    0.21889280f, 0.15924552f, 0.16681950f, 0.02814182f, -0.04999812f, -0.10747828f, 0.08559254f, 0.02870341f, 
    0.02948080f, 0.08415395f, 0.11596272f, -0.09110679f, 0.15084998f, -0.00107387f, 0.06905481f, 0.09516061f, 
    0.04008909f, -0.16785643f, -0.02862573f, -0.10626771f, 0.01265364f, -0.09266518f, 0.01167250f, -0.08230737f, 
    -0.00731705f, 0.03889368f, 0.18589567f, -0.01445644f, -0.01497838f, 0.10211464f, 0.21798624f, 0.02149341f, 
    -0.15584210f, -0.10463651f, 0.04143850f, 0.10884454f, 0.00714252f, -0.05082436f, 0.07597234f, -0.05158856f, 
    0.40694109f, 0.28277421f, 0.21000977f, -0.11185589f, -0.10248473f, -0.04454677f, -0.06740916f, -0.03716226f, 
    -0.05930911f, -0.11206562f, 0.03563372f, -0.02915470f, 0.04702510f, 0.07327121f, -0.24455838f, -0.08955394f, 
    0.18411717f, -0.16228852f, 0.01726627f, -0.14792232f, 0.00172533f, -0.15405166f, 0.13167724f, -0.02563770f, 
    0.30622175f, 0.04403977f, 0.24898998f, -0.22224995f, -0.07376794f, -0.14599098f, 0.09467894f, -0.19463365f, 
    -0.08906180f, -0.00918612f, 0.01996123f, 0.05805133f, -0.00296102f, 0.02530528f, -0.01917950f, 0.18273328f, 
    0.10751133f, 0.19034153f, 0.11961962f, 0.02165676f, 0.04402146f, 0.00238474f, 0.29079819f, -0.11173225f, 
    -0.19538912f, -0.20683402f, -0.00314031f, -0.11693805f, -0.08308796f, 0.02834806f, 0.02750543f, 0.02178326f, 
    0.01595705f, 0.15227053f, -0.04966499f, 0.01858150f, -0.00200053f, 0.11742573f, 0.08396405f, 0.04452635f, 
    -0.01220387f, 0.10972411f, -0.07793325f, -0.03831454f, -0.00689306f, 0.07186489f, 0.02604885f, -0.05521376f, 
    0.05447505f, -0.11204954f, -0.07407072f, -0.08703382f, -0.07032824f, -0.00044140f, 0.08427444f, 0.03764026f, 
    0.14986566f, -0.08713593f, -0.03371542f, -0.03781755f, 0.18862975f, -0.00994763f, -0.11676189f, 0.03397039f, 
    0.06169413f, -0.04944840f, -0.00780893f, -0.05228919f, 0.08092605f, 0.02720272f, 0.03224480f, 0.04479919f, 
    -0.01646644f, 0.08625349f, -0.20608816f, -0.05621179f, 0.14726263f, -0.06977602f, -0.07531874f, 0.05649716f, 
    -0.19581330f, 0.07390474f, -0.06517890f, 0.11316570f, -0.13125011f, -0.06825333f, 0.14012381f, 0.20167421f, 
    -0.19162741f, -0.04267009f, -0.00502550f, -0.05484436f, -0.16536124f, -0.08114699f, -0.02186228f, -0.12131409f, 
    -0.29476985f, 0.03495451f, 0.06054091f, 0.07806040f, 0.02701342f, 0.03945916f, -0.02377632f, 0.05032938f, 
    -0.00136813f, 0.05037639f, -0.18758295f, -0.10433550f, -0.15490621f, 0.12128999f, 0.12659094f, -0.02931331f, 
    0.23513700f, 0.06975089f, 0.06383003f, 0.03085128f, -0.09455795f, 0.01396943f, 0.15841849f, 0.08499543f, 
    -0.07854205f, -0.06611703f, 0.16893873f, 0.02912910f, 0.04936029f, -0.03542505f, 0.13729756f, -0.11833008f, 
    -0.00994650f, -0.06856024f, 0.12701258f, 0.07060964f, 0.10165883f, -0.05265522f, 0.34433985f, -0.07161640f, 
    0.08986700f, 0.11253390f, 0.16367462f, 0.16635837f, 0.13174592f, 0.18718801f, 0.07575712f, 0.03896808f, 
    -0.10269995f, -0.14046687f, -0.08810741f, -0.03132803f, -0.05739772f, 0.11596100f, -0.02313343f, 0.11267928f, 
    0.13266049f, 0.03329267f, -0.18175051f, -0.06364179f, 0.17713575f, -0.07262931f, 0.22360577f, -0.11016975f, 
    -0.05754512f, 0.01207947f, 0.03674982f, 0.15082693f, -0.01321399f, -0.08562534f, 0.07520107f, 0.13720243f, 
    0.26222694f, 0.03509383f, 0.12017623f, -0.10499066f, -0.00569139f, 0.07695103f, 0.04046702f, 0.00501566f, 
    -0.02557358f, -0.02556029f, 0.09278444f, 0.06016681f, -0.29511404f, -0.03635069f, -0.18680289f, -0.22700214f, 
    -0.03374965f, 0.05389313f, -0.01536600f, 0.10720956f, -0.00406946f, 0.04283817f, -0.00154203f, -0.10267409f, 
    0.12718552f, 0.12223675f, 0.33972311f, 0.01930065f, -0.03449170f, 0.02150938f, 0.12726444f, 0.07014012f, 
    -0.13481832f, 0.07074881f, 0.06055832f, 0.02823559f, -0.02642719f, -0.15280429f, 0.17078915f, 0.11985096f, 
    0.03819415f, 0.06126188f, 0.05694091f, 0.06622334f, 0.15203954f, 0.11264913f, 0.02281712f, 0.27444762f, 
    0.13616011f, 0.08488980f, -0.10149510f, -0.09394345f, -0.13562547f, -0.06507778f, 0.00224247f, -0.23101456f, 
    -0.04985471f, -0.01470926f, -0.04354995f, -0.04249967f, -0.02766485f, -0.01096846f, 0.05205537f, 0.00577155f, 
    0.06341800f, -0.06437168f, 0.18234530f, -0.00689521f, -0.07159886f, -0.07824830f, 0.00646307f, 0.08409874f, 
    -0.22255445f, 0.07388835f, 0.08422200f, -0.09298037f, 0.04207157f, 0.10536452f, -0.09236863f, -0.12492881f, 
    -0.21598262f, -0.07631964f, -0.12428322f, -0.14873438f, 0.10461101f, 0.01169786f, -0.10747173f, 0.12282120f, 
    -0.10034721f, 0.01664961f, 0.18060905f, -0.08406512f, 0.06574967f, -0.09738813f, 0.09376596f, -0.09088809f, 
    -0.19296040f, -0.08112912f, 0.38413185f, 0.01855152f, -0.17477256f, -0.13754743f, -0.09633286f, -0.03347506f, 
    0.01517501f, 0.01904387f, -0.07696670f, -0.07683387f, 0.14977077f, -0.07009953f, 0.25703734f, 0.05679711f, 
    0.07392164f, -0.10850915f, 0.07988071f, 0.01467690f, -0.09657469f, -0.04760080f, 0.03364167f, -0.02241587f, 
    -0.03988335f, 0.08023937f, 0.22201377f, -0.12381653f, -0.04432384f, -0.03876685f, 0.06977301f, 0.01887712f, 
    0.07487457f, 0.05035859f, 0.00313576f, 0.07499520f, -0.00694250f, 0.17835112f, -0.01408945f, -0.00839799f, 
    0.14144614f, 0.01740119f, 0.19976372f, 0.04681175f, 0.02896356f, 0.07606901f, 0.08976373f, -0.07881273f, 
    -0.12839711f, 0.01938144f, -0.09604898f, 0.09467048f, 0.01666918f, 0.09074661f, -0.01386673f, 0.03795389f, 
    0.14781998f, 0.04834763f, 0.05516115f, 0.16379403f, -0.38308096f, -0.34829339f, 0.21905896f, -0.26705807f, 
    -0.19876356f, 0.08175502f, -0.09351673f, 0.15722352f, 0.01977362f, 0.12709367f, 0.20013209f, 0.00212269f, 
    0.01697388f, 0.02290166f, -0.02015914f, -0.03567654f, -0.02178141f, -0.01970662f, 0.00058550f, 0.00075572f, 
    0.01970113f, 0.01493471f, 0.01536664f, -0.02190894f, 0.02946194f, 0.01056804f, -0.00892561f, -0.00371865f, 
    0.02067250f, 0.01946770f, -0.01411147f, 0.00648016f, 0.02629777f, -0.00925806f, -0.03100325f, -0.03931219f, 
    -0.01974054f, 0.02441053f, 0.00433580f, -0.02582392f, -0.03673968f, -0.01523207f, -0.03584109f, 0.00815027f, 
    0.02688210f, 0.02021023f, 0.00484538f, -0.01638361f, 0.02426728f, -0.03858988f, -0.03597841f, -0.02076244f, 
    -0.00714329f, 0.00097112f, -0.02193271f, 0.00002026f, 0.00552266f, 0.01358910f, -0.02943785f, 0.00322459f, 
    -0.01410969f, -0.03977424f, 0.02044690f, 0.01315901f, -0.03862350f, 0.02494663f, -0.00044380f, -0.01500933f, 
    0.00049000f, -0.01325104f, -0.03682100f, -0.00047519f, 0.02613866f, -0.03846759f, 0.02365422f, -0.02936993f, 
    0.01397430f, -0.01428618f, -0.01760832f, -0.03728880f, -0.02501260f, -0.02584971f, 0.02336143f, -0.03972752f, 
    0.01958924f, -0.04105660f, 0.00749031f, -0.01502800f, 0.02234790f, -0.04180400f, -0.03547718f, -0.03171469f, 
    0.00789736f, -0.00284031f, 0.02884137f, 0.02532982f, -0.00263582f, 0.01272676f, 0.01263937f, -0.01881179f, 
    0.02865206f, -0.00914625f, -0.02798878f, -0.01665067f, -0.01694334f, -0.00178149f, -0.04152526f, 0.00666058f, 
    -0.03536381f, -0.03313466f, 0.01722151f, 0.02214995f, -0.00630378f, 0.02013649f, -0.01392035f, 0.02561135f, 
    0.01698574f, -0.00222408f, 0.02842668f, -0.00313116f, -0.00288861f, -0.01561163f, 0.02363066f, 0.01115298f, 
    0.00617609f, -0.03853638f, -0.02800768f, -0.00267978f, 0.00998300f, -0.00337883f, -0.03284780f, 0.00184491f, 
    -0.00087390f, -0.00519000f, -0.01999265f, 0.02142414f, -0.00550467f, 0.01785769f, -0.02545562f, -0.01128337f, 
    -0.02497562f, 0.00246674f, -0.01109420f, 0.02631996f, -0.01691357f, -0.02314819f, -0.03593009f, -0.02501436f, 
    -0.03773552f, 0.01815754f, -0.01314396f, 0.00127027f, -0.00503445f, 0.00346616f, 0.00902904f, 0.00390096f, 
    0.02577006f, -0.00443481f, -0.02802960f, 0.03031190f, -0.01041998f, -0.02187000f, -0.02622913f, -0.03734012f, 
    -0.03179203f, -0.03805588f, -0.02192723f, -0.02151223f, -0.03276318f, 0.02599611f, -0.01338743f, -0.04067313f, 
    -0.04186408f, -0.01915431f, 0.01542835f, 0.01536816f, 0.01452016f, 0.00754443f, -0.02330982f, -0.01504539f, 
    0.00403808f, 0.01234347f, 0.00170594f, -0.02785749f, -0.01416986f, 0.02364832f, -0.02114497f, -0.01035571f, 
    -0.02507558f, -0.03573251f, 0.02507446f, 0.00922573f, -0.02957400f, -0.02593261f, 0.01253073f, 0.01961834f, 
    0.00306309f, -0.03788326f, 0.01443186f, -0.00442935f, -0.01594025f, -0.03361132f, 0.02757659f, 0.00394432f, 
    -0.02093709f, -0.00023248f, -0.02878159f, -0.03143850f, -0.00706260f, -0.00208292f, -0.01721487f, -0.00423958f, 
    -0.01884420f, -0.02313715f, -0.03733723f, -0.00247905f, -0.02034602f, 0.02247238f, -0.04204743f, 0.02230736f, 
    -0.00893565f, -0.03281731f, -0.00788970f, -0.04000392f, -0.03750522f, -0.01197400f, -0.00574917f, -0.03420029f, 
    0.01490441f, -0.00432468f, 0.02799761f, -0.01457800f, 0.01227568f, -0.00137046f, -0.03268421f, -0.01041491f, 
    0.01255155f, -0.01902290f, 0.02817866f, -0.03168010f, 0.02745710f, -0.00761987f, 0.02752901f, -0.03347495f, 
    -0.01097307f, -0.02635761f, -0.03566663f, -0.03949469f, 0.02272223f, 0.00878948f, 0.01260447f, 0.02666869f, 
    -0.00555468f, 0.00538344f, -0.03111210f, -0.01878156f, -0.02699850f, 0.02432008f, -0.01220023f, 0.00375373f, 
    -0.02863226f, -0.00729993f, -0.01931979f, -0.03860642f, 0.00817746f, -0.00899587f, -0.03040063f, -0.02760193f, 
    0.00291694f, -0.00296709f, -0.00156008f, 0.02543797f, -0.03234506f, -0.02046253f, 0.02970470f, -0.01235864f, 
    -0.01511134f, -0.00760025f, -0.01005990f, -0.00798271f, 0.00478002f, -0.00612887f, 0.00458926f, 0.00929039f, 
    -0.01912664f, -0.02240853f, -0.04080916f, 0.00767529f, -0.02183159f, -0.02676949f, -0.03218781f, 0.01638672f, 
    0.01844033f, -0.00426514f, -0.02321496f, -0.03277032f, 0.01205523f, -0.03508035f, -0.03031681f, -0.01072937f, 
    -0.00994425f, 0.00804489f, -0.01081870f, 0.02581104f, -0.03868029f, -0.00557621f, -0.03248681f, -0.04088552f, 
    -0.02483107f, 0.00444758f, 0.01577893f, -0.03265894f, -0.00041413f, 0.00418072f, 0.01499387f, -0.01363418f, 
    0.01650396f, 0.00911757f, 0.02254369f, -0.01546018f, -0.01005787f, -0.00266205f, -0.00765177f, 0.01372187f, 
    0.00891631f, 0.00343557f, -0.01857633f, -0.00756445f, -0.00693443f, 0.02597715f, -0.01757370f, -0.04063519f, 
    -0.01220818f, 0.02301874f, -0.01789884f, -0.02292050f, -0.03270707f, 0.02421815f, 0.02359654f, -0.01815211f, 
    -0.03844598f, -0.01712358f, 0.02467184f, 0.01803488f, -0.02183028f, 0.02666849f, 0.01657427f, -0.01539685f, 
    0.01890463f, -0.00554365f, -0.02928721f, -0.03767733f, -0.01470963f, -0.02712104f, 0.01152543f, -0.02733822f, 
    -0.02995154f, -0.02556181f, -0.02804994f, 0.01236194f, 0.00172283f, -0.01007417f, 0.00785654f, -0.03554828f, 
    0.00166948f, 0.02587662f, 0.01693410f, 0.02364001f, 0.01103926f, 0.02051509f, 0.01003092f, -0.01074203f, 
    0.01790679f, 0.00570283f, -0.01365699f, 0.02492395f, 0.01464015f, 0.02822803f, -0.01392722f, -0.02969573f, 
    -0.02417911f, 0.02640492f, 0.01749546f, -0.03140242f, -0.00582936f, -0.01298227f, 0.01491020f, -0.03833792f, 
    -0.03045208f, 0.02766150f, -0.01544401f, 0.00662450f, -0.02449809f, -0.00723863f, -0.02419888f, -0.03860584f, 
    -0.03583579f, -0.00878047f, 0.01396115f, -0.02658715f, -0.02648270f, -0.03004216f, -0.03969497f, -0.01767135f, 
    -0.03791978f, -0.02432806f, 0.00863620f, -0.01212845f, -0.02204431f, 0.01472729f, -0.03703515f, 0.01094824f, 
    0.00256419f, -0.00263438f, 0.01170860f, -0.03233447f, -0.03870595f, 0.02203774f, 0.02521056f, -0.00481476f, 
    -0.03311433f, -0.03338777f, 0.02462540f, -0.01544635f, -0.04047408f, 0.02855013f, -0.03466295f, -0.03521824f, 
    -0.03568926f, -0.03529506f, -0.00539977f, 0.02590124f, -0.04196240f, 0.02544233f, -0.01325784f, -0.02748844f, 
    -0.01511514f, -0.03333255f, -0.03483039f, -0.03237947f, -0.02385246f, 0.01530666f, -0.00576863f, 0.00943169f, 
    0.01368011f, 0.00446789f, -0.02900532f, -0.02614852f, -0.01877525f, 0.02684294f, -0.00751193f, -0.01859566f, 
    -0.01545119f, 0.03007624f, 0.03006728f, 0.01327555f, -0.03424631f, 0.02892289f, -0.04036799f, -0.03545682f, 
    -0.04009905f, -0.00836851f, -0.02104709f, 0.02482077f, 0.01014136f, 0.00439174f, -0.03493609f, 0.01769876f, 
    0.01197381f, -0.01215239f, 0.00768899f, -0.00495634f, -0.00790637f, 0.02610568f, -0.03720044f, 0.00155771f, 
    -0.03780111f, -0.02535893f, 0.00931113f, -0.00167590f, 0.02831943f, -0.00119940f, 0.00963261f, -0.02961398f, 
    -0.01733503f, 0.02898505f, 0.01986423f, -0.00635632f, 0.00739944f, 0.02585988f, -0.01504685f, -0.01410202f, 
    0.01318109f, 0.01220241f, 0.00937269f, 0.01187834f, -0.02391850f, 0.01851030f, 0.02399398f, -0.01988665f, 
    0.01867342f, -0.00862266f, 0.00008023f, -0.04162619f, -0.01777277f, -0.00715160f, -0.00118319f, 0.02829135f, 
    0.01285090f, -0.00223877f, 0.02133434f, -0.02250116f, 0.02398281f, 0.02150407f, 0.02534235f, -0.00347468f, 
    -0.04137184f, -0.03156079f, -0.00735554f, 0.00714013f, -0.01423788f, -0.04203848f, -0.04061989f, 0.02045939f, 
    -0.02362415f, -0.01291779f, 0.02682604f, 0.02197557f, 0.00044481f, 0.00285911f, -0.00122521f, -0.01386280f, 
    0.00918284f, 0.02741193f, 0.00883309f, 0.00031390f, 0.02567563f, 0.02831164f, -0.04031731f, -0.01171472f, 
    0.00122381f, -0.02695308f, -0.01903975f, 0.02264206f, -0.03345511f, -0.03329491f, -0.00277520f, -0.03413728f, 
    -0.01307420f, -0.04176283f, 0.02181426f, -0.02154380f, 0.00873675f, -0.04054485f, 0.01963925f, -0.01439271f, 
    -0.00552042f, -0.03121660f, -0.01855662f, -0.00672098f, -0.00444278f, 0.00941507f, -0.02810276f, 0.02090615f, 
    -0.01643309f, 0.01151229f, 0.02967499f, 0.01247737f, 0.02596563f, -0.00649887f, -0.03221686f, 0.00246460f, 
    -0.00712787f, 0.02376356f, 0.02091472f, -0.03827004f, 0.00743834f, -0.01181978f, -0.02037975f, 0.02710321f, 
    0.02026418f, -0.01974580f, -0.03449995f, 0.01633458f, 0.00182907f, -0.01260365f, -0.03532712f, -0.03979572f, 
    -0.00465805f, -0.03206765f, -0.02607713f, -0.02757381f, -0.00666151f, 0.02179858f, -0.01319429f, -0.02147123f, 
    -0.00007477f, -0.03395287f, 0.00164218f, -0.01063669f, -0.03350770f, -0.03492220f, 0.01837741f, -0.01777190f, 
    0.00103843f, 0.00006762f, -0.01443974f, 0.01945989f, -0.02972977f, -0.01542396f, 0.02100508f, -0.01397229f, 
    -0.00902597f, -0.00702474f, -0.01631042f, -0.00164798f, -0.03806914f, 0.00230570f, 0.01532158f, -0.00779030f, 
    0.00363852f, 0.02004396f, -0.02516208f, -0.03927521f, -0.00388078f, -0.00838554f, -0.01148385f, -0.01819541f, 
    -0.02942704f, 0.00963984f, 0.02196192f, -0.00278395f, -0.00911457f, -0.02219064f, 0.00181959f, -0.00028481f, 
    0.01551010f, -0.04168591f, -0.01175440f, 0.00585988f, -0.01171614f, 0.00491425f, -0.00608874f, -0.03194595f, 
    0.01663206f, -0.03015435f, 0.02133565f, -0.02374637f, -0.01291274f, -0.02711276f, 0.02512792f, -0.00932351f, 
    0.01639891f, -0.00036028f, 0.01644778f, -0.03525079f, -0.01536479f, 0.01761670f, -0.01253363f, 0.02052460f, 
    0.02109094f, -0.01114699f, -0.00536263f, 0.00517381f, 0.00058065f, -0.00471716f, -0.03205933f, -0.01004405f, 
    -0.00936272f, -0.01600343f, -0.01249454f, 0.01800775f, -0.00295848f, -0.00854908f, 0.00525933f, -0.03747474f, 
    0.01418472f, -0.03517292f, 0.02665202f, -0.00131813f, -0.03976199f, 0.00816274f, -0.00279718f, 0.01012845f, 
    0.02780446f, -0.03801871f, 0.02516478f, 0.00787155f, 0.01677146f, -0.03538647f, -0.03110947f, 0.00397166f, 
    0.01915487f, -0.00907458f, -0.00021062f, -0.03210896f, -0.01336847f, 0.00854203f, 0.02590894f, 0.01501213f, 
    -0.00187947f, -0.01640940f, 0.00310497f, -0.00675922f, -0.03969543f, -0.01171747f, -0.00134112f, -0.02166252f, 
    0.02543522f, 0.01864061f, 0.02257948f, -0.02490515f, 0.02138199f, -0.03741937f, -0.00665869f, -0.02131685f, 
    -0.03841980f, 0.00049808f, -0.00930801f, -0.02279114f, 0.01229414f, -0.00410860f, -0.02344020f, 0.01268142f, 
    0.00116879f, 0.00603309f, 0.02781328f, -0.00419982f, 0.00572025f, 0.01350923f, -0.01153663f, -0.02782205f, 
    -0.01642282f, -0.03421250f, -0.02035048f, -0.00599596f, -0.01664842f, 0.00697555f, -0.02538795f, -0.03500325f, 
    0.00844363f, -0.00512767f, -0.03545385f, 0.00360307f, 0.01738742f, -0.00726312f, -0.02089372f, 0.02626929f, 
    -0.01297365f, -0.01291378f, 0.01316855f, 0.01930851f, -0.00007496f, -0.03022554f, -0.01327926f, -0.03221669f, 
    0.01080289f, -0.04010188f, -0.01307071f, 0.02516938f, -0.02018608f, 0.00843487f, -0.01534289f, -0.02556593f, 
    0.00398214f, 0.02948191f, -0.00447727f, -0.00855289f, 0.02137269f, -0.00905589f, 0.00546842f, 0.00405152f, 
    -0.03390446f, -0.02560596f, -0.03056923f, -0.03836674f, -0.00663042f, -0.01175975f, -0.01253850f, -0.03047096f, 
    -0.03591822f, -0.02966097f, -0.00896060f, 0.02372156f, 0.00338153f, -0.03179687f, 0.00647468f, -0.03462393f, 
    0.01026142f, -0.02773537f, -0.01490621f, -0.00173056f, 0.01611739f, -0.03198369f, -0.02237663f, 0.02479993f, 
    0.00370092f, -0.02854890f, 0.01265557f, 0.01507292f, -0.01142146f, -0.04192286f, 0.00269392f, -0.01026375f, 
    -0.03806962f, 0.00836229f, 0.01275508f, -0.02052374f, -0.01104100f, -0.03702782f, 0.01314888f, -0.02024489f, 
    -0.02483744f, -0.03243689f, 0.02548565f, -0.00519723f, 0.00595787f, 0.00893832f, -0.03187370f, -0.01364373f, 
    0.00396353f, 0.01359263f, 0.00633186f, 0.01874148f, -0.00238821f, 0.00714046f, 0.02025259f, 0.03341204f, 
    -0.00268903f, 0.01936823f, 0.00429715f, -0.02993545f, -0.03254592f, 0.02361369f, 0.02813884f, -0.04105036f, 
    -0.03524493f, -0.04180751f, -0.00521844f, -0.00950332f, -0.02825585f, -0.04057708f, 0.01136009f, -0.03657424f, 
    0.01430174f, 0.00360187f, -0.00610373f, 0.00080130f, -0.00851788f, -0.01870179f, 0.01988515f, 0.01996336f, 
    -0.02958960f, -0.03688783f, 0.01865412f, 0.02993482f, -0.01679274f, -0.02932505f, -0.02759617f, -0.04120445f, 
    0.01487735f, 0.00246169f, -0.02632823f, -0.02882797f, 0.01252766f, -0.03049935f, 0.00661399f, -0.02318536f, 
    -0.01653437f, -0.03755306f, 0.02621961f, 0.00785806f, 0.02005116f, -0.04097487f, 0.00299097f, 0.01206514f, 
    -0.00583215f, -0.00288141f, -0.01212703f, 0.01216108f, 0.01151428f, -0.01232333f, 0.01596716f, -0.00521419f, 
    -0.04383289f, -0.04091635f, -0.03190233f, 0.00142730f, 0.02394183f, 0.02031330f, 0.00071064f, 0.01059246f, 
    -0.04044199f, -0.01220266f, -0.03140176f, 0.00505804f, -0.00609313f, 0.01746058f, -0.01606651f, -0.00842604f, 
    0.00250178f, 0.00593035f, -0.01201540f, -0.00434859f, 0.00803574f, -0.01171250f, 0.02361311f, -0.02484778f, 
    0.00922983f, -0.01216970f, 0.02683644f, -0.02132149f, -0.00470995f, -0.02857660f, 0.00343691f, 0.01180425f, 
    0.00166555f, -0.00837158f, 0.01539048f, -0.01676051f, 0.00222239f, -0.01497104f, -0.03136575f, 0.02084198f, 
    -0.01711223f, -0.02810448f, 0.01593605f, 0.01268542f, -0.03308761f, -0.02292209f, -0.02421745f, -0.00269603f, 
    -0.03358627f, -0.03694918f, 0.00660458f, -0.04107431f, 0.02510221f, -0.02910318f, -0.01873434f, -0.03925599f, 
    -0.03580561f, -0.00587513f, -0.00417544f, -0.01811565f, 0.01117729f, -0.02238693f, 0.00684039f, 0.02209331f, 
    -0.00115919f, -0.02436142f, 0.01877024f, -0.02485673f, -0.00569789f, 0.01967154f, 0.01413269f, -0.00339640f, 
    -0.02561419f, -0.00129178f, 0.03658388f, -0.02623771f, -0.03192413f, -0.03382848f, -0.03960602f, 0.00287680f, 
    -0.02802529f, -0.01932478f, 0.02093034f, -0.01869337f, -0.00997420f, -0.02731599f, 0.00660001f, 0.00583978f, 
    -0.03453805f, 0.00775582f, 0.02140114f, -0.00168388f, -0.02308871f, 0.02235579f, -0.01719322f, 0.02691962f, 
    -0.04144084f, -0.04046031f, -0.03396108f, -0.01913797f, 0.00083632f, -0.00034278f, -0.02085754f, 0.01861180f, 
    0.00845923f, -0.03004438f, -0.04003207f, -0.00355920f, -0.02857400f, 0.01951664f, 0.01445212f, -0.01797767f, 
    -0.02176307f, -0.00472551f, -0.02064374f, 0.02022853f, 0.00641729f, -0.00064529f, 0.00892529f, -0.02346130f, 
    -0.01794432f, -0.01527946f, 0.02480451f, 0.00742334f, -0.01666473f, 0.01131709f, 0.01280741f, -0.04115790f, 
    -0.00397132f, -0.01408672f, 0.02736131f, 0.00091733f, 0.02591457f, 0.00521435f, -0.03349845f, -0.01855460f, 
    0.02501168f, -0.01867886f, -0.03069915f, -0.01034915f, 0.02515580f, 0.00429900f, 0.00606743f, -0.00798053f, 
    -0.03894247f, -0.02255493f, 0.02975119f, -0.02145932f, -0.03733271f, 0.00684059f, -0.00768619f, -0.03958303f, 
    0.01780996f, -0.02022778f, -0.03665855f, -0.01982574f, 0.01488432f, 0.01061248f, -0.02945011f, -0.03076844f, 
    -0.00172603f, -0.00158211f, 0.02121785f, 0.01227144f, 0.02353203f, 0.02329078f, 0.00485668f, 0.00107243f, 
    0.02494805f, 0.00326545f, 0.01678035f, -0.02576152f, 0.03001100f, -0.01828753f, 0.01063768f, 0.01917590f, 
    0.02712000f, 0.00399704f, -0.03157990f, -0.03436885f, -0.00786823f, 0.00806713f, 0.02294259f, -0.04211139f, 
    -0.02976071f, -0.03809590f, -0.03588628f, -0.01464747f, 0.02699543f, -0.04148629f, -0.03838862f, -0.03214496f, 
    0.00520152f, -0.04308103f, 0.00773393f, -0.01462089f, -0.01106390f, -0.02087933f, -0.03031932f, -0.00951524f, 
    -0.01141621f, -0.01340534f, 0.00063413f, 0.03126036f, -0.01151549f, -0.00993534f, -0.03870326f, 0.00017996f, 
    -0.04329859f, 0.00961360f, -0.02692596f, 0.02234449f, 0.00478086f, 0.02049786f, -0.02449476f, 0.02679673f, 
    -0.03967961f, -0.01621566f, -0.01878296f, 0.00941900f, -0.02069929f, -0.04194615f, -0.01951729f, 0.00537403f, 
    0.03011901f, -0.00634687f, -0.04216690f, -0.01714567f, 0.01758200f, 0.01015894f, -0.04180417f, -0.02786960f, 
    -0.02279564f, -0.03594761f, -0.02317312f, -0.01052220f, -0.00700423f, 0.01060414f, -0.01646362f, -0.01353839f, 
    -0.00574097f, -0.03001910f, -0.01708734f, -0.04013784f, 0.00235237f, 0.00128172f, -0.01810247f, 0.01118602f, 
    0.02860352f, 0.00956577f, 0.01819780f, 0.01549844f, 0.02091897f, 0.00357725f, 0.02024936f, 0.02023952f, 
    0.01656687f, 0.02685201f, -0.03691172f, -0.00204510f, -0.03248844f, -0.04190218f, -0.02514958f, -0.03649751f, 
    -0.03219300f, -0.03406308f, 0.02264267f, 0.00522486f, -0.00019707f, -0.02688965f, -0.01277802f, -0.03758278f, 
    -0.03386026f, -0.00923500f, 0.00926977f, 0.02846750f, 0.01989000f, 0.02679733f, -0.03141889f, -0.03863558f, 
    -0.03948732f, -0.03247033f, -0.02171473f, 0.01899478f, -0.02994797f, 0.02437917f, 0.01024558f, -0.03053275f, 
    0.01179241f, 0.00096941f, 0.00600447f, 0.01996970f, 0.00121475f, 0.02628416f, -0.00686138f, 0.02518123f, 
    0.02538365f, -0.00693368f, 0.02672875f, -0.02834651f, -0.00596946f, 0.02162186f, -0.01789469f, -0.00081572f, 
    -0.03017734f, -0.02164222f, -0.02534372f, 0.02797955f, 0.02356531f, -0.00288110f, 0.01597522f, -0.02782083f, 
    -0.01844532f, 0.00472485f, -0.00483438f, -0.01144290f, -0.01114951f, 0.01572671f, -0.00942404f, -0.01456392f, 
    -0.02181494f, -0.01582615f, 0.03480047f, -0.02534680f, 0.01124692f, -0.01896860f, 0.02414652f, -0.03373332f, 
    0.01648342f, 0.00668868f, 0.02740062f, -0.00806369f, -0.03621283f, 0.00190015f, -0.03368313f, 0.00411233f, 
    -0.01687091f, -0.03839277f, 0.02486704f, 0.01340766f, -0.02557359f, 0.00385712f, -0.01391285f, -0.02348524f, 
    -0.01603946f, 0.00892853f, -0.00395478f, -0.00720722f, -0.02643727f, 0.01742016f, -0.01108096f, -0.04125581f, 
    -0.03358829f, -0.00939351f, -0.03105793f, -0.01187688f, 0.01648171f, 0.01487727f, -0.03430468f, -0.00827298f, 
    -0.01108629f, 0.01649237f, -0.00597924f, 0.02171882f, 0.02460866f, -0.04040773f, -0.00141637f, -0.03655106f, 
    0.01104727f, -0.00692707f, -0.03875047f, -0.03026584f, -0.00582603f, -0.00129264f, -0.01835731f, -0.02502126f, 
    0.02020300f, -0.00781075f, -0.02387744f, -0.01620727f, -0.01682444f, -0.03166943f, -0.00617930f, 0.00067729f, 
    -0.01103385f, 0.02340784f, 0.00740834f, 0.02733846f, 0.00209849f, -0.01389762f, -0.01088445f, -0.03720694f, 
    -0.01286358f, 0.00239662f, -0.02164623f, -0.03961030f, -0.02824884f, 0.01042160f, -0.02779905f, -0.02334035f, 
    0.01494035f, 0.00645949f, -0.03338161f, 0.01193154f, -0.04138093f, -0.02513658f, 0.02740005f, -0.01663788f, 
    -0.03139524f, -0.03498903f, -0.02040126f, -0.02904555f, -0.03131463f, 0.00513331f, -0.01941749f, -0.01268432f, 
    -0.00525275f, -0.01449094f, 0.02972953f, -0.00504635f, 0.03138226f, -0.03477979f, 0.00405256f, -0.03833846f, 
    0.00227732f, -0.02157351f, -0.03976262f, 0.03255727f, -0.00749246f, 0.02401971f, -0.01658142f, -0.04006352f, 
    0.00580549f, -0.01299857f, 0.01073429f, 0.01017451f, -0.02931291f, 0.02362168f, 0.02956997f, -0.03871296f, 
    0.00728462f, -0.03526158f, 0.02647354f, -0.04048356f, 0.01964986f, 0.00581215f, 0.02219322f, 0.01312522f, 
    -0.01648120f, -0.01893238f, -0.02399819f, 0.02271931f, -0.00229446f, 0.03200506f, 0.00507865f, 0.01988097f, 
    -0.02708450f, -0.02201347f, -0.03188803f, -0.00307900f, 0.02536628f, -0.01490433f, -0.00087856f, 0.01296551f, 
    -0.04162853f, 0.02746941f, 0.00877028f, -0.00489516f, -0.03256782f, 0.01891116f, 0.02575713f, -0.02143337f, 
    0.00882892f, -0.02336345f, 0.00380574f, -0.01806348f, 0.00338050f, -0.01773332f, -0.00844964f, -0.01758372f, 
    -0.02253389f, 0.00795131f, -0.02869337f, 0.01446124f, -0.02423566f, -0.01566991f, 0.01158219f, 0.00865399f, 
    -0.02826943f, -0.01299536f, -0.01572794f, 0.02342794f, 0.02331712f, -0.01463758f, 0.03157101f, -0.03807871f, 
    -0.00834702f, -0.01159686f, -0.04313652f, -0.02598224f, -0.00105062f, 0.02224721f, 0.00443891f, -0.03539352f, 
    0.00670819f, 0.02863082f, 0.00519774f, -0.03694499f, -0.01345648f, 0.02381702f, -0.03711016f, -0.03636792f, 
    0.02492790f, -0.01991261f, -0.04336672f, -0.03146716f, 0.02213445f, -0.01077473f, 0.00971723f, -0.00885625f, 
    0.00499943f, 0.02667139f, -0.02284192f, 0.01993236f, -0.02809924f, 0.01194140f, 0.02512696f, 0.00299857f, 
    -0.01705391f, -0.03051443f, -0.02845269f, -0.02950754f, -0.00772858f, 0.00602806f, -0.03506494f, 0.01832060f, 
    0.00979497f, -0.01303479f, -0.01729069f, 0.02161518f, -0.04299127f, -0.03411594f, -0.01990195f, -0.03030789f, 
    0.02593256f, 0.01530778f, -0.03483083f, -0.01297171f, -0.00668887f, -0.01250910f, 0.01851545f, 0.01043583f, 
    0.01571696f, -0.00551339f, 0.00468591f, -0.00099091f, -0.03424603f, -0.02184722f, -0.01773420f, 0.01766787f, 
    -0.02756317f, 0.01197287f, 0.00971498f, -0.04417730f, -0.03113641f, 0.00555591f, 0.00638981f, 0.01171282f, 
    -0.01034711f, 0.02127727f, -0.01385334f, 0.01779430f, -0.02690549f, 0.03029613f, -0.00271736f, -0.03872146f, 
    -0.03731720f, -0.02215917f, -0.01455757f, 0.02837025f, -0.00119521f, 0.02816430f, 0.02357513f, 0.01076553f, 
    -0.00798850f, -0.03722643f, -0.01356326f, -0.02925603f, -0.03624360f, -0.02507510f, -0.02560120f, -0.03071226f, 
    0.00772509f, 0.01242229f, -0.00260414f, -0.04208603f, -0.02491263f, -0.03010397f, 0.02046731f, 0.00050773f, 
    -0.02577421f, -0.02987841f, -0.00473537f, 0.02473639f, -0.01454234f, 0.01648750f, -0.02666820f, -0.00436433f, 
    0.01999728f, 0.00403079f, 0.00608280f, 0.02545553f, -0.03246757f, 0.00350921f, -0.02057527f, 0.01893070f, 
    0.00430345f, -0.00832255f, -0.03343743f, 0.00383249f, -0.00904417f, -0.03323422f, -0.00112965f, -0.01435421f, 
    -0.01053676f, 0.01320028f, -0.03478593f, -0.02725621f, 0.02331468f, -0.00412469f, -0.02487323f, -0.02024117f, 
    0.00974100f, -0.00206554f, -0.00125417f, 0.02724766f, -0.00577254f, 0.01680353f, 0.01553305f, -0.02160631f, 
    -0.03028739f, -0.03341147f, -0.00748924f, 0.00181868f, -0.02811901f, -0.04133377f, -0.01658921f, 0.02851409f, 
    0.01587971f, 0.00775499f, -0.01173156f, -0.02802190f, -0.01452057f, -0.01662421f, -0.00700339f, -0.03504295f, 
    -0.00811002f, -0.03302486f, 0.00238311f, -0.00265511f, -0.00561039f, 0.02771590f, -0.02994383f, 0.02205767f, 
    0.01187682f, 0.07903463f, -0.08284649f, -0.06080009f, 0.01794312f, 0.08568651f, 0.10770918f, 0.04907431f, 
    0.13209389f, 0.13890940f, 0.12438270f, -0.03806960f, -0.24511270f, -0.28484169f, 0.03555335f, 0.20401035f, 
    -0.14328429f, -0.02595440f, -0.03864823f, 0.08093120f, 0.02537260f, 0.11606476f, 0.14140727f, -0.01973371f, 
    -0.15005262f, 0.08301482f, 0.02182521f, 0.04663691f, -0.04833376f, 0.11266215f, 0.08324596f, 0.01225550f, 
    0.06974714f, 0.09408846f, 0.11025228f, 0.04500241f, 0.23432122f, 0.11727123f, 0.11654719f, -0.15290329f, 
    0.02995205f, -0.03594991f, -0.01633777f, -0.00161596f, 0.08105695f, 0.12813850f, 0.12285674f, 0.04393057f, 
    0.00530634f, 0.04015343f, -0.05727000f, 0.18767628f, -0.01594581f, -0.07391281f, 0.05031382f, -0.13454261f, 
    -0.05364374f, -0.01114988f, 0.03180857f, 0.13177887f, 0.24982113f, 0.18162201f, -0.06234984f, -0.01996583f, 
    0.14103454f, -0.00956783f, 0.03123822f, -0.04084744f, -0.05783517f, 0.06179146f, 0.03084529f, 0.10800905f, 
    0.17906274f, 0.03701330f, -0.00364329f, -0.05422999f, 0.02964765f, -0.03863322f, -0.00212513f, -0.00514307f, 
    -0.18850343f, 0.11784924f, 0.04012900f, 0.17573607f, -0.36321190f, 0.00577433f, 0.28867009f, 0.23063605f, 
    0.09221352f, 0.23883571f, 0.10035039f, -0.05623616f, 0.14952698f, -0.05848061f, 0.02633152f, 0.14259365f, 
    0.06644634f, 0.22448055f, 0.17652728f, 0.06613969f, 0.04717987f, 0.02660106f, 0.01088085f, -0.00904847f, 
    -0.04263610f, 0.06405172f, 0.03973374f, 0.00239193f, 0.07586019f, 0.22438446f, 0.15711096f, -0.08073686f, 
    0.06207579f, -0.11560212f, -0.03669076f, 0.06524524f, 0.10324229f, -0.04700782f, 0.00892722f, 0.05301767f, 
    0.20699276f, -0.01475672f, 0.09604538f, -0.06208205f, 0.06816392f, -0.07311530f, -0.00551326f, 0.12870647f, 
    0.16267528f, 0.02177335f, 0.09294775f, 0.04552202f, 0.04921419f, -0.02392971f, 0.09106597f, 0.08880639f, 
    -0.01765890f, 0.13711484f, 0.20771149f, 0.12631848f, 0.01977550f, -0.06134766f, 0.00270532f, 0.00224390f, 
    0.01417214f, -0.11656038f, 0.17340194f, -0.21930222f, -0.03826320f, 0.02275664f, -0.04024528f, -0.12479384f, 
    0.03009700f, -0.03436520f, -0.03827816f, -0.03301054f, -0.02776792f, -0.00638931f, -0.00916619f, -0.05380317f, 
    -0.08868217f, -0.03415421f, 0.00296357f, 0.00338964f, -0.02015264f, -0.20327647f, -0.10362727f, -0.08571940f, 
    0.17470458f, 0.06617443f, 0.06025133f, 0.02731651f, 0.02541248f, -0.08539340f, -0.07415005f, 0.10368218f, 
    -0.09108762f, 0.06518757f, 0.12721698f, -0.01918529f, -0.11786079f, 0.23296089f, -0.10890956f, 0.10819799f, 
    0.05645918f, 0.01566423f, 0.04172520f, 0.01742895f, 0.00870259f, 0.08770408f, 0.08760796f, 0.06588361f, 
    -0.04725009f, 0.09586344f, -0.19903770f, 0.02388437f, 0.07869428f, -0.01967937f, 0.03652881f, -0.02099313f, 
    -0.08770359f, 0.24978831f, 0.04149428f, -0.13642605f, 0.07785631f, 0.19619365f, -0.04159194f, 0.14409567f, 
    0.05662381f, 0.17740519f, -0.01560701f, -0.04655994f, -0.04915266f, 0.11573226f, 0.00785871f, 0.11666781f, 
    -0.08576769f, 0.00275942f, -0.05368478f, 0.00417548f, -0.02522155f, -0.14604364f, -0.06247789f, -0.00622065f, 
    0.03129634f, -0.01896380f, -0.09610036f, 0.13987824f, 0.03090907f, 0.21915856f, 0.20696764f, -0.17672655f, 
    0.06637120f, -0.00993091f, -0.00463783f, -0.02766243f, -0.08589356f, 0.09817724f, 0.10985446f, 0.13558333f, 
    0.17948087f, 0.23639467f, -0.36069480f, 0.03752621f, 0.07030436f, 0.07027178f, 0.03875877f, 0.11448520f, 
    0.08868899f, -0.03234568f, -0.06163454f, -0.01771445f, 0.26449716f, 0.17768231f, 0.03251075f, -0.06890335f, 
    0.01267978f, -0.08052342f, 0.20265482f, -0.00084127f, 0.10272138f, 0.00616029f, -0.04899959f, -0.15689288f, 
    0.11161423f, -0.08256225f, 0.09792992f, -0.20386423f, 0.01629945f, -0.04076569f, 0.02763241f, 0.11526845f, 
    0.21556295f, -0.01467148f, -0.01517090f, -0.00379659f, 0.31949529f, -0.08234186f, -0.24490426f, 0.21178484f, 
    0.04600246f, -0.04644683f, 0.16254361f, 0.01991635f, -0.15093321f, 0.01366692f, 0.13785048f, 0.11595202f, 
    -0.13579991f, -0.08754067f, -0.13062537f, 0.01755487f, -0.03792680f, -0.08386195f, 0.07116954f, -0.03460295f, 
    0.12732875f, -0.05198129f, 0.03801838f, 0.07215872f, 0.08997466f, 0.07385661f, 0.01044870f, -0.08121502f, 
    0.08926211f, -0.04181828f, -0.07082976f, 0.11181933f, 0.19236082f, -0.16991058f, 0.05215886f, 0.07908369f, 
    -0.19866109f, -0.17972203f, -0.07712499f, -0.11052949f, 0.04558278f, -0.00798112f, -0.06554253f, -0.01484655f, 
    0.03781064f, 0.02060751f, -0.01211569f, 0.07631277f, -0.26904476f, -0.33114186f, 0.02541650f, 0.08317452f, 
    0.10821608f, 0.16792484f, -0.12209200f, -0.17412394f, 0.08863840f, 0.03096795f, 0.02814746f, -0.00536965f, 
    -0.19566870f, 0.05601117f, 0.02962493f, -0.09956235f, -0.06532300f, -0.05824684f, 0.02144898f, 0.01047829f, 
    0.27195415f, 0.01793685f, 0.04649199f, 0.07721228f, -0.07247379f, 0.04824088f, 0.08764625f, 0.22160490f, 
    0.13588393f, 0.01503375f, -0.04137950f, 0.15058142f, 0.11979403f, -0.01967787f, 0.03940109f, 0.08684693f, 
    -0.15703234f, -0.09480628f, -0.09936462f, 0.05326529f, 0.03876473f, 0.17286590f, 0.00346918f, -0.06667667f, 
    0.01638331f, -0.00123682f, 0.06869270f, -0.00033954f, -0.21839616f, 0.40081799f, -0.06311164f, -0.10558125f, 
    0.14447296f, -0.07329478f, -0.11754301f, 0.17427148f, -0.13918224f, 0.04920539f, -0.01329318f, 0.08590374f, 
    0.14610229f, 0.11309642f, -0.07302485f, -0.00143714f, -0.01441317f, 0.03110443f, 0.03858472f, -0.07856970f, 
    0.00518220f, -0.00692593f, -0.04770186f, -0.09394251f, 0.06452954f, 0.04960588f, 0.05168634f, -0.01401766f, 
    0.02288513f, -0.17570554f, -0.00605319f, 0.01842394f, -0.00450844f, 0.04512290f, -0.07330386f, 0.01658510f, 
    0.15475865f, 0.21012054f, 0.09743513f, 0.16351496f, 0.02447059f, -0.02981530f, 0.00199704f, -0.14425415f, 
    0.01684431f, 0.02540359f, 0.01599498f, 0.02121063f, 0.12890054f, -0.35243008f, -0.09042272f, 0.41823244f, 
    0.14834651f, 0.08889265f, 0.10748582f, -0.00428256f, 0.07697847f, 0.10929840f, -0.10861883f, -0.06806906f, 
    0.14752768f, 0.11067253f, 0.10949408f, -0.02615589f, 0.00217828f, 0.11843041f, 0.15544610f, -0.03313585f, 
    0.09286931f, -0.00979136f, 0.03691955f, 0.00892721f, -0.13789657f, -0.16195981f, -0.01122865f, -0.06605222f, 
    -0.01692898f, -0.16523030f, 0.03384269f, 0.18876107f, -0.02762494f, -0.04745790f, 0.11487525f, 0.10164519f, 
    -0.22720635f, -0.17968386f, 0.07385215f, -0.08118024f, -0.05482881f, -0.06319524f, -0.00971838f, -0.20236765f, 
    0.09227972f, 0.06391124f, 0.00676382f, -0.01007650f, 0.01664826f, 0.06114191f, 0.02707965f, -0.03230576f, 
    0.00761157f, -0.14195201f, 0.02220075f, 0.05099975f, 0.03350404f, -0.15970170f, -0.03931836f, -0.02393967f, 
    -0.07718906f, -0.14116968f, -0.07505567f, 0.13855971f, 0.00930728f, -0.08338777f, -0.05887263f, 0.00321286f, 
    0.01422040f, 0.11210409f, 0.06010737f, -0.04864741f, -0.40646678f, -0.40498215f, 0.25241962f, 0.18212634f, 
    -0.04780525f, 0.03058179f, 0.04024400f, 0.04650086f, -0.09613018f, 0.15869950f, -0.01826224f, 0.11865829f, 
    0.05280865f, -0.25162432f, -0.00697973f, -0.08815049f, -0.13038293f, -0.04670381f, -0.01689572f, 0.16060315f, 
    -0.00156372f, 0.02295760f, -0.07361955f, -0.02412279f, -0.15631220f, -0.36816755f, -0.20528798f, 0.12016827f, 
    0.13675652f, 0.01999467f, 0.04644127f, -0.05600276f, 0.10147114f, 0.05600832f, -0.02328365f, 0.12863864f, 
    0.18697079f, 0.04564122f, 0.08824685f, 0.18510863f, 0.07140062f, -0.07449564f, 0.01839651f, 0.07730486f, 
    0.07556704f, 0.02314624f, 0.07443690f, 0.00607991f, 0.28951454f, 0.07572659f, 0.01151384f, -0.31961700f, 
    0.03894709f, -0.03494532f, -0.03844095f, 0.01242971f, -0.00250597f, 0.07268780f, 0.13820063f, 0.13027166f, 
    0.22166687f, 0.27352613f, -0.16373870f, 0.14203416f, -0.16095972f, 0.07076205f, 0.00567074f, -0.06708840f, 
    -0.09581192f, 0.06581267f, -0.07830689f, -0.00710042f, 0.37136304f, -0.13058141f, -0.15750636f, -0.01251623f, 
    -0.04896776f, 0.14045489f, 0.05756406f, 0.13409308f, -0.12127601f, 0.12086500f, -0.02553192f, -0.08358693f, 
    -0.35916129f, 0.30851325f, 0.13780640f, -0.04319353f, -0.03229546f, -0.05490347f, 0.01125373f, 0.01709095f, 
    -0.09184615f, 0.02659423f, -0.03202290f, 0.14229079f, 0.25739053f, 0.30671868f, -0.08227232f, -0.07491655f, 
    -0.11497732f, 0.03754617f, 0.00983320f, -0.06595215f, -0.00995591f, -0.08211390f, 0.32341221f, -0.00293882f, 
    0.21388634f, 0.22503012f, -0.03763570f, -0.05365603f, -0.11326939f, 0.00197765f, -0.01805105f, 0.05934512f, 
    -0.04555803f, 0.00473257f, -0.00974292f, -0.02339426f, -0.22135499f, -0.17942549f, 0.19783647f, 0.00908244f, 
    0.04469267f, 0.01299370f, -0.12390248f, 0.02111333f, 0.07635267f, 0.05314009f, 0.07947137f, 0.12116998f, 
    0.18625338f, 0.19740964f, -0.12571235f, 0.04367641f, 0.07617705f, -0.05549744f, -0.05419822f, 0.06061291f, 
    0.14108118f, -0.00026935f, -0.00496511f, 0.02027645f, -0.24698709f, 0.19764645f, 0.27658036f, -0.17288211f, 
    -0.01935215f, 0.03045357f, -0.03638931f, -0.08365177f, -0.01548283f, 0.02796927f, -0.05411143f, -0.01001246f, 
    -0.29244480f, -0.09256068f, -0.06133265f, 0.11102176f, -0.03629520f, -0.00102226f, -0.07138494f, 0.00523852f, 
    -0.00966134f, 0.04331495f, 0.04141391f, 0.02444682f, -0.20350747f, -0.25431448f, -0.05946185f, -0.00508845f, 
    0.12040585f, -0.05783064f, -0.01899096f, -0.16027930f, 0.08268356f, 0.13556869f, -0.10178825f, 0.12573111f, 
    0.00702217f, -0.27229050f, -0.19094029f, 0.28479511f, 0.10766016f, 0.02325069f, 0.06700187f, 0.04114659f, 
    0.00516446f, 0.03395599f, 0.12073679f, 0.04163371f, -0.38475841f, -0.04859630f, 0.14490297f, 0.01206059f, 
    0.07957728f, 0.02334747f, 0.04767119f, 0.12991093f, -0.03150206f, 0.16671781f, 0.02280133f, 0.00329312f, 
    0.19811557f, 0.13215287f, 0.29319540f, -0.25753522f, 0.01370465f, 0.12324496f, -0.06104423f, -0.00708065f, 
    -0.13324477f, 0.00020394f, 0.17071936f, 0.02326892f, 0.00258531f, 0.04303442f, 0.19534180f, -0.03170496f, 
    -0.00933772f, 0.05028116f, -0.12085782f, 0.05140905f, 0.08198500f, -0.08816902f, 0.04310074f, 0.02534351f, 
    -0.12634701f, -0.24849233f, -0.16586633f, -0.00734497f, -0.02995875f, -0.09886505f, -0.05038504f, 0.00296015f, 
    0.06341368f, 0.13132131f, 0.00691489f, 0.23488031f, 0.24409480f, -0.13499525f, 0.17201458f, -0.03391100f, 
    -0.03794214f, 0.02300475f, -0.01027456f, 0.06512757f, 0.11084005f, -0.01943350f, -0.12084042f, -0.07455655f, 
    0.22093365f, -0.21625568f, 0.02248598f, -0.07349707f, -0.01815332f, 0.00158207f, -0.04511989f, 0.13944004f, 
    0.04007720f, 0.06711235f, 0.00795487f, -0.01674263f, 0.26952532f, 0.27061197f, -0.04407002f, 0.35152587f, 
    0.08660939f, -0.02422228f, -0.06586939f, -0.17458369f, 0.10082833f, 0.07575928f, 0.04676345f, -0.01805408f, 
    0.15069653f, -0.09224994f, -0.04819459f, -0.23903757f, -0.03869485f, -0.05733738f, -0.14226109f, -0.15021706f, 
    0.10299572f, 0.17196831f, 0.11722799f, 0.41012818f, 0.07602454f, 0.43804327f, -0.05141426f, 0.02469035f, 
    0.04077943f, 0.01862914f, 0.03644554f, -0.06440006f, 0.01046936f, 0.01306445f, 0.09659581f, -0.03485269f, 
    0.03979017f, 0.15139705f, 0.35367593f, -0.02776590f, 0.06166559f, 0.09214772f, 0.13882087f, -0.15336609f, 
    -0.00508255f, 0.04999599f, -0.02813822f, 0.05906196f, -0.07586996f, 0.09346713f, -0.13012514f, 0.11744963f, 
    0.05183789f, -0.03786210f, 0.06776322f, 0.05939141f, -0.09965603f, 0.07565215f, 0.01834322f, 0.13377507f, 
    0.14302628f, 0.06687996f, -0.03742617f, 0.02901971f, -0.04243376f, 0.07232180f, -0.05493307f, -0.07781937f, 
    0.18606380f, 0.13673484f, -0.03173397f, 0.14009212f, -0.05977216f, -0.14586356f, -0.04112391f, 0.03523752f, 
    0.03833699f, 0.09417450f, 0.12604070f, 0.09474082f, -0.07645635f, 0.03024455f, -0.06113870f, 0.01858107f, 
    -0.10164736f, -0.13363218f, -0.14949232f, -0.01110516f, 0.00062441f, 0.16295189f, 0.08379009f, 0.14659935f, 
    -0.18891956f, -0.01118776f, 0.01815526f, -0.04059899f, 0.03642114f, 0.09946685f, -0.03476557f, -0.04832291f, 
    -0.19191666f, 0.03625134f, -0.13397738f, -0.05424682f, -0.13014641f, 0.04018494f, 0.13456452f, 0.08617033f, 
    0.22479413f, 0.17535880f, -0.02808073f, -0.01296150f, -0.04018464f, -0.06436956f, 0.00791393f, -0.03783341f, 
    0.02751747f, -0.00952790f, -0.02139309f, -0.00111100f, 0.24888375f, 0.07409672f, 0.04679133f, -0.01494527f, 
    -0.01931592f, 0.08301606f, -0.01037371f, 0.03246244f, -0.21342559f, 0.07527864f, -0.01178176f, -0.21311955f, 
    0.20120421f, 0.11837561f, -0.09574246f, 0.02203729f, 0.01209622f, -0.03511002f, 0.01246117f, 0.04756371f, 
    0.07346850f, 0.08773369f, 0.18056795f, 0.12918918f, -0.10496691f, 0.08440592f, 0.07516764f, 0.02223880f, 
    -0.01570078f, 0.01894784f, -0.06908358f, -0.05243659f, 0.18007444f, 0.19771713f, 0.02589403f, 0.25350386f, 
    0.23260716f, 0.08696402f, 0.14514381f, 0.05381842f, -0.07801485f, -0.06296300f, -0.11004835f, 0.10232399f, 
    0.11527814f, -0.05927910f, -0.07448757f, 0.05256183f, 0.03743932f, 0.08757721f, -0.03995847f, 0.10746863f, 
    0.05126690f, 0.03576896f, -0.01065280f, 0.09636195f, -0.12163022f, 0.02588544f, -0.09686720f, -0.08379180f, 
    0.26576802f, -0.01741585f, -0.16383207f, 0.20803298f, 0.02244049f, -0.01868404f, 0.00755192f, 0.01526142f, 
    0.10571691f, 0.11806754f, -0.06397693f, 0.02135679f, -0.06375960f, -0.07269243f, 0.06943735f, 0.22911701f, 
    0.00840342f, 0.00744513f, -0.10395442f, -0.22208944f, 0.17615068f, -0.00180394f, 0.04971713f, -0.18344496f, 
    0.25611186f, 0.01725702f, 0.04250924f, -0.21907386f, 0.04504103f, 0.09939044f, 0.10318358f, 0.02117576f, 
    -0.10170241f, 0.17765169f, -0.12115002f, -0.06877716f, -0.33312142f, 0.10568067f, -0.12890442f, 0.04320331f, 
    0.19319661f, 0.04296183f, 0.12782240f, -0.13205037f, 0.06401788f, -0.01732910f, 0.07636515f, 0.08038926f, 
    -0.05820524f, -0.10932774f, 0.06143812f, 0.19545117f, 0.06661813f, -0.09565569f, -0.03507872f, -0.06273206f, 
    -0.06974213f, -0.00651339f, -0.01329288f, -0.00660747f, -0.13176116f, -0.02013926f, -0.04859705f, 0.22346921f, 
    0.04133127f, -0.00876890f, 0.10413072f, 0.13183299f, 0.09671025f, -0.07376783f, -0.00256340f, -0.03669122f, 
    0.30154887f, -0.07547650f, 0.04924410f, -0.05928787f, 0.05925883f, 0.06671734f, 0.00222401f, -0.05566126f, 
    0.12794042f, 0.13369119f, -0.02946441f, 0.08831370f, 0.10751054f, -0.11641844f, -0.10761154f, 0.06547820f, 
    0.11674228f, -0.02860789f, -0.09259061f, 0.04890852f, 0.13741119f, 0.15095390f, 0.16268444f, 0.17546542f, 
    -0.21370828f, 0.01907452f, -0.02232950f, 0.05943754f, 0.07662664f, -0.07744262f, 0.11353213f, 0.08225948f, 
    -0.19099870f, -0.00939139f, -0.11173917f, 0.16129820f, -0.01670986f, -0.10568026f, 0.28330725f, -0.09768976f, 
    0.01786455f, -0.00369627f, -0.04677902f, -0.12569892f, 0.15505412f, 0.07715501f, 0.07476174f, 0.08132445f, 
    -0.14768654f, -0.10010699f, 0.06736665f, -0.11681046f, -0.02067559f, 0.12053354f, 0.14939612f, -0.16522260f, 
    0.00303802f, 0.09336669f, 0.02610154f, -0.05001837f, 0.09984899f, -0.20272322f, -0.12481016f, 0.20891082f, 
    0.13764030f, 0.02429232f, -0.19896144f, -0.15386021f, -0.15305285f, 0.04753328f, -0.00760368f, -0.01081418f, 
    0.00794507f, -0.12701239f, 0.05703639f, 0.02455216f, 0.17567030f, -0.09001786f, -0.13167885f, 0.02072755f, 
    -0.12661533f, -0.06447463f, -0.09971248f, -0.23065893f, -0.27560386f, -0.09256269f, -0.20619388f, -0.19093321f, 
    -0.01456838f, 0.17877041f, -0.18997578f, -0.10484411f, 0.02250194f, -0.09411962f, -0.12149386f, -0.05516694f, 
    0.00308072f, 0.15096067f, -0.07472817f, -0.07030313f, -0.03830138f, 0.08784401f, 0.20080997f, 0.12381476f, 
    -0.16469742f, -0.08842091f, -0.07384019f, -0.24370763f, -0.16016012f, 0.29032686f, -0.11298779f, 0.09557120f, 
    0.05118729f, -0.09336727f, 0.19769099f, 0.01897760f, -0.04204036f, -0.02588372f, 0.16690414f, -0.14721221f, 
    -0.32906568f, 0.13858847f, 0.05811215f, -0.00488898f, -0.02864812f, -0.03019199f, 0.01871211f, -0.15665729f, 
    -0.02734799f, -0.08781718f, 0.15278199f, 0.33479303f, -0.11370622f, -0.13731445f, 0.07782553f, -0.01865877f, 
    0.17953746f, -0.01328896f, 0.24989884f, -0.05884806f, 0.04699568f, 0.10739730f, -0.09716891f, 0.00130014f, 
    0.28481215f, -0.03630001f, -0.02784518f, -0.15348080f, 0.14826995f, 0.02041438f, 0.00147557f, 0.12117288f, 
    -0.09417927f, -0.00963188f, -0.10218252f, 0.04386749f, 0.17146158f, -0.03006515f, 0.15612933f, -0.16311337f, 
    0.15456583f, 0.00767454f, -0.16284077f, 0.11111749f, 0.08011063f, -0.15455878f, 0.03319694f, -0.15862672f, 
    0.44277468f, 0.31457949f, -0.24052510f, 0.00532908f, 0.04808113f, -0.03314701f, -0.18378656f, -0.01494745f, 
    0.06206783f, -0.04162606f, 0.09744748f, 0.13144039f, -0.54146397f, 0.18974970f, -0.16909523f, 0.17201219f, 
    0.09929122f, -0.06739952f, 0.07820660f, 0.02341341f, -0.06534332f, -0.14851654f, -0.05378436f, -0.07783227f, 
    0.07250020f, 0.06267558f, 0.48891819f, -0.34902230f, 0.01369669f, -0.14812417f, -0.04158161f, -0.04540445f, 
    -0.08422939f, 0.01130635f, 0.04178853f, -0.00020774f, -0.09037597f, -0.37945244f, -0.01717361f, 0.07837915f, 
    0.02282973f, -0.01576792f, -0.04955009f, -0.06316321f, 0.01447560f, 0.06840046f, 0.12286666f, 0.12182505f, 
    -0.12293097f, -0.08928882f, -0.14250107f, 0.21200898f, 0.11454607f, 0.08086684f, -0.09401753f, -0.05882169f, 
    -0.08632447f, -0.00719163f, -0.16133833f, -0.06480462f, 0.03475656f, 0.11109725f, 0.00967464f, 0.16191317f, 
    0.00761292f, 0.03939198f, -0.06197242f, 0.12445872f, -0.06103840f, -0.03151151f, -0.05349228f, -0.11216451f, 
    -0.12197826f, -0.10711170f, -0.23577827f, 0.09959395f, 0.05381099f, 0.01953841f, 0.00004890f, 0.11826379f, 
    0.10003585f, -0.06880589f, -0.07533901f, 0.08453128f, 0.13360097f, 0.43402648f, 0.31304893f, 0.21038364f, 
    0.07319259f, -0.07562374f, 0.14790025f, 0.00739020f, -0.03171664f, 0.06903563f, 0.03369422f, 0.10713988f, 
    -0.09970661f, 0.12938984f, -0.24022682f, 0.15942991f, -0.04068969f, -0.02420761f, 0.14728633f, 0.12687673f, 
    -0.12286290f, -0.19362073f, 0.03681491f, -0.13440733f, -0.00040578f, -0.06058147f, 0.14351124f, 0.31117558f, 
    -0.12698169f, 0.02915978f, 0.00400789f, -0.29761803f, 0.04198432f, 0.01325204f, 0.01761563f, -0.07665755f, 
    0.12751912f, 0.01474050f, -0.03245492f, 0.33764595f, 0.06950924f, -0.13790488f, -0.00217808f, 0.07780982f, 
    0.09268788f, -0.00264636f, -0.03602623f, 0.08596640f, -0.17309588f, -0.30702937f, 0.08082748f, 0.16718534f, 
    -0.00956470f, 0.06592469f, -0.03935031f, 0.28079134f, 0.06479314f, -0.09384205f, 0.03067300f, 0.03226506f, 
    0.21279934f, 0.02435003f, -0.03067742f, -0.17615007f, 0.14307475f, -0.00780760f, 0.14424187f, 0.02566533f, 
    -0.03156228f, -0.15481956f, 0.19185238f, -0.00919541f, 0.28406936f, -0.18627834f, 0.26844567f, -0.28747168f, 
    -0.00155336f, 0.01740713f, -0.13073078f, -0.00775629f, 0.03138253f, 0.15483479f, -0.03358834f, -0.08363910f, 
    0.01598816f, 0.14416824f, -0.08798227f, 0.05285216f, 0.06622484f, 0.07134498f, 0.13226222f, 0.06467460f, 
    -0.16878442f, -0.02478942f, -0.02236768f, 0.01779709f, 0.55653882f, -0.15674326f, 0.02585891f, -0.16548023f, 
    0.01517361f, -0.00315363f, -0.12338214f, 0.01490641f, -0.08117000f, -0.07955057f, 0.10078011f, 0.19842651f, 
    0.10016770f, -0.06148043f, 0.10187658f, -0.10754843f, 0.01054864f, -0.03906603f, -0.13384998f, 0.06215975f, 
    -0.06391691f, -0.07857385f, 0.15210682f, -0.09713311f, -0.02310070f, 0.15659189f, 0.24476461f, 0.12869777f, 
    0.06060926f, -0.06114816f, 0.05920749f, 0.03553089f, -0.12621704f, -0.07365689f, 0.05056809f, 0.04501986f, 
    0.45266563f, -0.26135990f, 0.37130281f, -0.22856846f, 0.04737280f, 0.14815865f, -0.06772438f, 0.08935782f, 
    -0.17893833f, -0.08374732f, 0.14534922f, -0.11717001f, 0.22341949f, -0.25800240f, 0.04669048f, -0.14244084f, 
    0.00469872f, -0.12251985f, -0.15487716f, -0.21238685f, -0.00647713f, -0.06180884f, -0.02780771f, -0.07437253f, 
    -0.08595967f, -0.15486565f, -0.12035286f, 0.03615083f, -0.05553733f, -0.03047563f, 0.08564705f, -0.15595914f, 
    -0.08587333f, -0.05437431f, -0.18037139f, -0.05792896f, -0.22430819f, -0.11674681f, 0.40460980f, 0.22370562f, 
    0.11404085f, -0.04911976f, 0.09376999f, 0.07710730f, -0.02798275f, -0.05416911f, -0.06212774f, -0.07114134f, 
    0.16385931f, 0.25454989f, 0.31903505f, 0.21759671f, 0.14552864f, 0.04047979f, -0.10390112f, -0.09144827f, 
    -0.01589706f, -0.04381797f, 0.04469678f, -0.04462207f, -0.11996218f, -0.16124387f, -0.12718983f, 0.31356737f, 
    -0.02882120f, -0.07581257f, 0.20048499f, 0.02011589f, -0.00422079f, -0.03885226f, -0.07438239f, 0.03276780f, 
    0.09342726f, -0.33221680f, 0.45831087f, -0.14880429f, -0.04037865f, -0.06648397f, -0.15379278f, 0.16580050f, 
    0.09777077f, 0.01843380f, 0.00102850f, -0.03576258f, 0.45865110f, -0.14577548f, 0.28186557f, -0.23055518f, 
    -0.09148309f, -0.10049796f, -0.08637539f, -0.16894931f, -0.02793862f, -0.04960195f, 0.04885899f, -0.08238269f, 
    -0.02927056f, -0.05152750f, -0.08026106f, 0.00318137f, -0.03870934f, -0.05844515f, 0.09917393f, -0.09489866f, 
    -0.07534260f, 0.02214395f, -0.01271152f, -0.20606057f, -0.07218351f, -0.00522152f, 0.02447121f, 0.04170842f, 
    0.07547608f, -0.08562832f, 0.14704303f, 0.09494728f, 0.08222655f, -0.05374106f, -0.16409793f, 0.01380779f, 
    -0.36031058f, 0.00083305f, -0.09493463f, 0.04095552f, 0.01492746f, 0.00783825f, 0.07134740f, 0.07349778f, 
    -0.12584509f, 0.03914317f, -0.07743800f, -0.01710577f, 0.03068964f, -0.41485891f, -0.28120285f, -0.17413950f, 
    0.00730280f, 0.03818944f, -0.09171160f, 0.09729623f, -0.06433289f, 0.16072217f, 0.14013986f, 0.11929321f, 
    -0.01367661f, -0.04153464f, -0.02339509f, -0.00595626f, -0.00217267f, -0.02175819f, -0.00375203f, 0.01247708f, 
    0.01576446f, -0.04426319f, -0.03961320f, -0.02762753f, 0.02814114f, 0.00814559f, -0.02510369f, 0.01420397f, 
    -0.02368672f, 0.00277624f, 0.00919658f, 0.00255327f, -0.03863334f, 0.00985389f, 0.00901516f, -0.00143779f, 
    0.02619320f, -0.03205728f, 0.02370935f, 0.00533422f, 0.01404539f, -0.01598603f, -0.01617247f, -0.00617880f, 
    -0.03497664f, -0.03131980f, -0.03116238f, -0.01734040f, -0.00471789f, 0.01722152f, 0.00548381f, -0.02470863f, 
    -0.01851464f, 0.00246938f, 0.00284649f, -0.00151567f, 0.02411980f, -0.03228813f, 0.00467509f, 0.00077397f, 
    0.02079253f, 0.02225092f, -0.03026407f, -0.00622659f, -0.01582891f, -0.00162744f, 0.01827506f, -0.03571863f, 
    0.00844134f, 0.02388204f, 0.02331659f, 0.01585233f, 0.00895911f, -0.02810357f, 0.00338016f, 0.02054156f, 
    -0.01670926f, -0.03621096f, 0.02433953f, -0.01700676f, 0.01648995f, 0.01985272f, -0.00279205f, -0.04114975f, 
    0.00364115f, -0.03445854f, -0.01604465f, 0.01118651f, -0.01163563f, 0.02337915f, -0.03784565f, -0.01168119f, 
    0.01673510f, -0.02964492f, 0.00122122f, -0.00515275f, -0.00076006f, -0.03490934f, -0.02643900f, -0.04602361f, 
    -0.00704429f, -0.02167296f, 0.02878480f, -0.01227902f, 0.02253847f, 0.01466855f, -0.01702690f, -0.02063388f, 
    -0.00082264f, 0.00301139f, -0.00487454f, -0.01451635f, 0.00850075f, 0.02272061f, -0.01762597f, -0.00125036f, 
    0.02094634f, 0.00852902f, -0.00338232f, -0.01188149f, 0.00540094f, 0.00888261f, 0.00477294f, 0.00349140f, 
    -0.01102417f, -0.01824864f, 0.01096395f, 0.01608145f, -0.00104111f, -0.00711981f, 0.00961902f, 0.00111620f, 
    0.00398624f, -0.00824952f, 0.02136681f, 0.01548951f, 0.01309484f, -0.04251294f, 0.02025577f, -0.00741031f, 
    0.01810180f, 0.00110104f, 0.01678837f, 0.00588856f, 0.03114532f, -0.00408408f, 0.02841387f, -0.03020837f, 
    0.00149877f, 0.02614839f, -0.00080021f, -0.00780792f, -0.00478631f, -0.00915399f, 0.01533705f, -0.02104995f, 
    -0.02390500f, -0.02756104f, -0.01007196f, 0.02583960f, -0.04275041f, 0.01100610f, -0.01742144f, 0.01858865f, 
    0.02521398f, 0.01152445f, -0.03310903f, -0.01060050f, 0.00178569f, -0.03645819f, 0.00999526f, -0.01890194f, 
    0.02230006f, 0.01684263f, 0.02741066f, -0.02632325f, 0.02412164f, 0.03106049f, 0.03423038f, -0.01465369f, 
    -0.00878826f, -0.02379665f, -0.01049421f, -0.01886927f, -0.03415374f, 0.01860209f, 0.02790069f, 0.01313441f, 
    -0.01950451f, -0.03084343f, -0.01102121f, 0.00859710f, -0.02891158f, -0.00589142f, -0.01909493f, -0.02044297f, 
    0.00880934f, -0.02216030f, 0.01981883f, -0.00831210f, -0.02451755f, -0.01506338f, 0.00680580f, 0.01764613f, 
    0.03472643f, -0.03381707f, 0.01316775f, 0.02415192f, -0.04099404f, -0.00433696f, -0.00529204f, 0.03227083f, 
    0.00070623f, -0.02670345f, 0.00168763f, -0.03402635f, 0.02421046f, 0.01212102f, -0.00183639f, 0.00953049f, 
    -0.01087847f, -0.01198450f, 0.00495983f, -0.03234721f, -0.00568965f, 0.01193666f, -0.02109358f, -0.03976453f, 
    -0.02069392f, 0.01165434f, -0.03219225f, 0.00724401f, 0.02703425f, 0.00274042f, -0.02278305f, 0.02340328f, 
    0.01537818f, 0.03376033f, -0.00833493f, -0.01506826f, 0.01394469f, -0.03388947f, -0.03961830f, -0.00313787f, 
    0.00361644f, -0.02894754f, -0.00387349f, -0.03334080f, 0.00955445f, 0.01727376f, 0.00093340f, -0.02172444f, 
    0.01392126f, 0.01947462f, -0.02541762f, -0.03566872f, 0.03065971f, -0.02891937f, 0.03120666f, 0.00665093f, 
    0.01133422f, -0.00033437f, -0.00004999f, 0.02449616f, -0.04865425f, 0.01278837f, -0.03308518f, -0.00477829f, 
    -0.00992451f, 0.01049682f, -0.01123878f, 0.01984291f, 0.03177314f, -0.00833035f, 0.00149386f, 0.02106175f, 
    -0.00090659f, 0.00693933f, -0.01596782f, -0.03188409f, 0.02855209f, 0.00833205f, 0.01833173f, -0.02926525f, 
    -0.01744931f, 0.02676768f, 0.00035790f, -0.00831108f, -0.03516429f, 0.02961888f, -0.02056867f, -0.01812610f, 
    -0.01254555f, -0.01259415f, 0.03034322f, 0.02936749f, -0.00953605f, -0.01510048f, -0.01604831f, -0.00826712f, 
    0.01166496f, -0.03520988f, -0.00486534f, -0.00094559f, 0.00401613f, 0.02088760f, 0.00178555f, 0.01631215f, 
    0.01075253f, 0.02771598f, -0.03920605f, 0.02613387f, -0.01826383f, 0.01568801f, -0.02683358f, 0.02231488f, 
    -0.02733726f, -0.00663115f, 0.02401079f, -0.00002851f, -0.02269355f, -0.01249143f, -0.02352031f, -0.01168918f, 
    -0.00619449f, 0.00998206f, -0.02448403f, 0.01150544f, 0.00780372f, -0.00635292f, -0.02578502f, -0.02408381f, 
    -0.02656833f, -0.00716789f, -0.03802464f, 0.02149042f, -0.01592018f, -0.02514518f, -0.00074282f, 0.03475737f, 
    -0.02672527f, -0.00575074f, 0.03380442f, 0.02585851f, -0.01987143f, -0.03844197f, -0.03790148f, 0.03139640f, 
    -0.02872113f, 0.02242941f, 0.02824631f, -0.02897407f, -0.04073505f, -0.02527827f, 0.01909591f, -0.00839974f, 
    0.02139757f, -0.01451099f, 0.03646011f, -0.02396384f, 0.03170806f, -0.03327851f, 0.02119359f, -0.03395438f, 
    -0.01062544f, -0.00749045f, -0.00658390f, -0.01960688f, -0.01631800f, -0.01460550f, 0.02577882f, -0.02552088f, 
    -0.03678347f, 0.01826707f, -0.00078911f, -0.02921505f, 0.00025779f, 0.01763409f, 0.00029133f, 0.02930841f, 
    0.04153843f, -0.02021870f, -0.02975472f, -0.03522526f, 0.00427895f, -0.00537050f, -0.00265904f, 0.00215902f, 
    0.02562728f, -0.00200768f, 0.01737082f, -0.01039172f, 0.00922293f, -0.02796314f, 0.02377015f, -0.01088863f, 
    -0.00685846f, -0.02627933f, -0.03112813f, -0.02647029f, 0.02434110f, 0.02467540f, -0.00544505f, -0.00071440f, 
    0.01973243f, -0.03706200f, 0.03518099f, -0.02940380f, 0.00306302f, 0.00718489f, 0.00859015f, -0.03843344f, 
    -0.02556017f, -0.02429161f, -0.02691453f, 0.02905745f, -0.02443028f, 0.00869901f, -0.01272440f, -0.01344017f, 
    0.01806675f, -0.03866906f, -0.01987043f, -0.00449501f, 0.01941357f, 0.00318977f, 0.02981132f, 0.01862758f, 
    0.03301412f, 0.01722924f, 0.01193708f, -0.00664180f, 0.00488361f, -0.02844146f, -0.04633147f, 0.01957012f, 
    0.00182321f, 0.00168814f, -0.01855532f, 0.02458603f, -0.01773767f, 0.02496737f, 0.02355081f, -0.01277601f, 
    -0.03353676f, -0.03951960f, -0.00057600f, -0.00296266f, -0.02031709f, -0.01047619f, -0.02645423f, 0.00656080f, 
    -0.02366522f, -0.00200802f, 0.00218183f, -0.00643711f, 0.00176549f, -0.01460745f, 0.01321244f, -0.03785958f, 
    0.00723072f, -0.02393600f, -0.02238627f, -0.01952175f, -0.01599944f, -0.02837093f, 0.01844582f, -0.00018415f, 
    -0.02405903f, -0.00776770f, -0.02793961f, 0.03196531f, 0.01866736f, -0.02910871f, 0.00910039f, -0.00983209f, 
    -0.01528137f, -0.02696898f, 0.00016372f, 0.02680922f, -0.01000268f, 0.00899634f, -0.00240620f, -0.01788203f, 
    -0.02866755f, 0.00348891f, -0.02210133f, 0.01150381f, -0.00303371f, 0.01267525f, -0.02994687f, -0.01098957f, 
    -0.00813684f, -0.00681749f, -0.01837180f, 0.00871195f, -0.03515416f, 0.01717363f, -0.03800719f, 0.00515032f, 
    -0.01166236f, -0.03074832f, -0.00522824f, -0.03681885f, 0.03221305f, -0.02824273f, 0.00357707f, -0.01700597f, 
    0.01093437f, 0.01749419f, -0.02087653f, -0.04377317f, -0.01778604f, -0.00430513f, 0.00931009f, 0.03135652f, 
    -0.04612683f, 0.00805714f, 0.01252904f, -0.03853458f, 0.01940016f, 0.02786202f, -0.03916847f, -0.01709557f, 
    0.01439048f, 0.01270180f, 0.02588236f, 0.02588123f, -0.03929482f, 0.02675996f, 0.01019805f, 0.01217346f, 
    0.01306672f, -0.01404101f, 0.00935968f, -0.00259277f, 0.00465518f, 0.02052971f, 0.00672696f, -0.03499704f, 
    -0.04262168f, -0.02581430f, 0.01100656f, -0.02363178f, 0.00832722f, 0.01983654f, 0.03075749f, -0.02164307f, 
    0.01989757f, -0.01571162f, 0.00182898f, 0.02791553f, -0.01777280f, 0.03052620f, -0.04583976f, -0.01396795f, 
    -0.00114017f, -0.02944816f, -0.01674276f, -0.00132659f, -0.01128270f, 0.01110257f, -0.02459645f, -0.01632584f, 
    0.02424525f, 0.00735259f, -0.01907158f, -0.02423082f, -0.01621686f, 0.02081248f, -0.00982840f, 0.00443238f, 
    -0.02572607f, -0.00118343f, -0.03644289f, 0.01047847f, -0.02940288f, 0.00129681f, -0.02826105f, -0.02290162f, 
    -0.00555083f, -0.02555212f, 0.01989106f, -0.00275613f, -0.03654692f, -0.02923437f, -0.01778139f, -0.01717977f, 
    0.01726231f, -0.00331789f, -0.03003535f, -0.03896692f, 0.02682899f, -0.03209121f, 0.00894428f, 0.02477728f, 
    -0.02929364f, -0.02562583f, 0.00880114f, 0.01662776f, 0.01179819f, -0.02377724f, 0.04289623f, -0.01256940f, 
    0.02613089f, -0.00060392f, 0.00171131f, -0.01450715f, -0.02193750f, -0.02860251f, 0.02732601f, -0.02434619f, 
    0.00875667f, 0.01015413f, 0.03084704f, -0.02694298f, -0.04259303f, -0.03271448f, -0.02385552f, -0.04165289f, 
    -0.01360548f, 0.01875873f, -0.01596137f, -0.01627876f, -0.02140838f, 0.00936417f, 0.00804993f, 0.03243338f, 
    0.01361477f, -0.00980459f, 0.02881015f, 0.01714312f, -0.01105204f, 0.00127942f, -0.00579683f, -0.03074762f, 
    0.01599512f, 0.01993840f, 0.03260966f, 0.00183770f, -0.02175497f, 0.02481325f, -0.01681993f, -0.02777001f, 
    0.03095446f, -0.00930643f, 0.01205437f, 0.03374775f, -0.01263711f, 0.02321988f, 0.03543819f, 0.01644355f, 
    -0.01106498f, -0.00424593f, -0.03015034f, 0.01834325f, 0.00654978f, -0.01068000f, 0.01377620f, -0.03332368f, 
    -0.02863727f, -0.04431453f, 0.01477173f, -0.03490992f, -0.00158940f, -0.01312901f, -0.02544360f, 0.00556389f, 
    0.01210566f, -0.03593097f, 0.00730071f, 0.02666743f, 0.02485728f, -0.01246986f, 0.00027766f, -0.03642690f, 
    -0.02651828f, -0.00977585f, -0.00792670f, 0.01135355f, -0.01083915f, -0.03517667f, -0.03244111f, 0.00457004f, 
    -0.02612084f, 0.01718665f, 0.03512103f, -0.03519884f, 0.02741085f, -0.00719800f, -0.02149219f, 0.00667858f, 
    -0.02637250f, 0.00376854f, -0.02657213f, -0.01511693f, -0.01726197f, -0.01695726f, 0.00922804f, 0.03788190f, 
    -0.03403090f, -0.01033933f, 0.00512949f, -0.01202411f, -0.00033681f, 0.01945921f, -0.02713410f, 0.00915208f, 
    -0.04352243f, 0.03447528f, 0.00040451f, 0.04418661f, 0.00343177f, -0.02805811f, 0.00270448f, -0.03618572f, 
    0.01318843f, 0.02411446f, 0.02296491f, 0.00030381f, -0.00788907f, -0.02728805f, 0.00474423f, 0.00788477f, 
    0.01799760f, -0.00456592f, 0.03542751f, -0.00595490f, -0.00768259f, 0.01099964f, -0.01429304f, 0.00589603f, 
    0.01085481f, -0.02161485f, -0.02609622f, -0.03073267f, -0.00451112f, -0.00343292f, -0.03731064f, -0.02503036f, 
    -0.02743292f, 0.02188360f, 0.02332585f, -0.00937595f, -0.01263307f, -0.03019741f, 0.01410595f, -0.00433160f, 
    -0.03026836f, 0.00572619f, -0.03233368f, 0.00736696f, -0.03857379f, 0.02328320f, -0.00044180f, -0.00484729f, 
    0.02127790f, 0.00535999f, 0.01899595f, -0.01446872f, 0.00973375f, 0.02466763f, -0.02569549f, -0.03272165f, 
    -0.02019812f, -0.03617110f, 0.02729733f, -0.01614015f, 0.02405332f, -0.01457657f, -0.01015770f, -0.01825309f, 
    -0.03118073f, -0.02601810f, -0.00150497f, -0.01234479f, -0.03751590f, -0.02349526f, -0.02602114f, -0.03246074f, 
    0.02150863f, -0.02430681f, -0.01471026f, -0.03154277f, -0.00199996f, -0.00660085f, -0.01132119f, -0.03724558f, 
    -0.01397216f, -0.00186454f, -0.01832114f, -0.03787278f, -0.03680440f, -0.02269469f, 0.02958478f, -0.00147028f, 
    0.01318309f, -0.03975272f, -0.02343319f, 0.02991077f, -0.00681763f, -0.00557022f, -0.02181083f, -0.02897980f, 
    -0.03091600f, -0.02597137f, 0.02329344f, 0.01850890f, -0.01404959f, -0.03464399f, -0.03607491f, -0.01063003f, 
    -0.00114932f, -0.03094187f, -0.01470182f, 0.00848784f, 0.01026072f, -0.00351745f, -0.00768314f, 0.00938531f, 
    0.00301360f, 0.03028934f, -0.02461478f, -0.00358176f, 0.00393643f, -0.00959179f, 0.02195076f, 0.02417765f, 
    0.02043127f, -0.02567738f, -0.02670358f, 0.00876785f, -0.04005387f, -0.01678808f, 0.01855565f, -0.03857174f, 
    0.00665258f, -0.00436864f, -0.02305076f, 0.01382462f, -0.00940843f, -0.02246564f, 0.00565119f, -0.01690386f, 
    0.01688176f, 0.02855295f, -0.02864902f, 0.01398380f, -0.00702294f, -0.03839665f, 0.02104658f, 0.00577511f, 
    -0.00844450f, 0.01757275f, 0.00865256f, 0.02975601f, 0.00528636f, 0.00514881f, 0.01766478f, -0.01717120f, 
    -0.02556912f, 0.02936696f, -0.04133763f, 0.01734430f, -0.00820555f, 0.01853801f, 0.02177110f, 0.00501101f, 
    0.02014795f, -0.03720319f, 0.00206098f, -0.03231677f, -0.01101555f, 0.01744784f, -0.02190045f, 0.01769319f, 
    0.01014000f, -0.01564785f, -0.03909447f, -0.02051168f, -0.03815338f, 0.02210613f, -0.01738556f, 0.00953549f, 
    -0.01092744f, -0.02435256f, 0.00905356f, 0.00820836f, -0.00298355f, 0.00989452f, 0.01467876f, 0.00796731f, 
    -0.01403428f, -0.00154677f, -0.02405224f, -0.01905969f, -0.02621917f, -0.03959827f, 0.02749799f, 0.02280239f, 
    -0.01088211f, 0.02174746f, -0.02684026f, -0.01684594f, -0.04178863f, 0.01109858f, -0.00770443f, -0.03847359f, 
    -0.02551340f, -0.01953661f, -0.03872747f, -0.03717007f, -0.00870353f, 0.02745420f, 0.01894488f, -0.01136376f, 
    -0.00078382f, -0.02346544f, 0.01158462f, -0.00575165f, 0.01523795f, 0.00602703f, 0.00569741f, 0.00205596f, 
    0.01369944f, 0.00050439f, 0.01483238f, 0.01838130f, -0.01864341f, -0.01453627f, -0.03327538f, -0.01600643f, 
    0.02138856f, 0.01207716f, -0.01465174f, -0.00142743f, -0.01513142f, 0.03016112f, -0.00491611f, -0.01609561f, 
    -0.01392120f, -0.01897863f, 0.00500345f, 0.00131833f, -0.01054133f, 0.00514385f, -0.03223795f, 0.00202185f, 
    -0.01131347f, 0.01543448f, 0.01502825f, -0.03674364f, 0.03878121f, 0.01298222f, 0.01190794f, -0.01011427f, 
    0.00085480f, -0.02657631f, -0.02997815f, 0.01069214f, -0.03968352f, 0.00302523f, 0.01862965f, 0.02940946f, 
    0.00853360f, 0.01519852f, 0.00107005f, -0.00199496f, 0.01897931f, 0.01949880f, -0.02838849f, -0.03028862f, 
    0.02115075f, 0.00073061f, 0.00355102f, -0.04171888f, 0.02818038f, -0.01304994f, -0.02502641f, 0.01608123f, 
    0.02908403f, -0.04166641f, 0.00431791f, 0.04166959f, -0.01343579f, -0.00170944f, 0.00556706f, -0.02919148f, 
    -0.00232914f, -0.02056250f, 0.02601132f, -0.02966450f, -0.02832131f, -0.00567231f, 0.01803821f, -0.02531016f, 
    0.00171547f, 0.00171197f, -0.01602161f, -0.01658730f, -0.00992462f, 0.00218943f, 0.01306141f, -0.02757479f, 
    -0.01797342f, -0.03482703f, -0.02581785f, 0.01187783f, -0.02776966f, 0.00762136f, 0.01172786f, 0.00525512f, 
    -0.03597129f, 0.00537325f, 0.00686239f, 0.02322162f, -0.02256387f, -0.02523880f, -0.02180024f, 0.02889761f, 
    -0.04173662f, 0.02815967f, -0.03986847f, 0.01259962f, 0.00423131f, -0.01699480f, 0.01716338f, 0.02076843f, 
    -0.02671892f, 0.00523251f, 0.01326149f, 0.01606736f, 0.00682423f, -0.01180150f, -0.04104743f, -0.04096957f, 
    0.01934916f, -0.02859796f, -0.04031039f, 0.00444664f, -0.00010958f, 0.02450835f, 0.01058792f, -0.01186433f, 
    -0.02633073f, 0.00498652f, -0.01816718f, -0.03825763f, 0.02591022f, 0.00584490f, 0.01054925f, 0.01899263f, 
    0.00731981f, 0.01909524f, -0.03018179f, 0.02579464f, -0.03818764f, -0.02181259f, -0.00696450f, -0.00461229f, 
    -0.04166955f, -0.02621369f, 0.01139294f, -0.03536593f, -0.01228564f, 0.01950026f, -0.03464593f, 0.00331468f, 
    -0.02959908f, 0.00461529f, -0.00558933f, -0.03033422f, 0.02264642f, 0.04137892f, -0.00757201f, -0.00393201f, 
    -0.01957385f, 0.00310308f, -0.02039881f, -0.01821525f, 0.00182256f, -0.01557515f, -0.00677377f, 0.01188223f, 
    0.02403964f, 0.02887653f, 0.01561475f, -0.00129889f, -0.02885907f, -0.02748086f, -0.00221449f, 0.00524798f, 
    0.02192044f, 0.02761934f, 0.02029991f, -0.03113607f, -0.02474387f, 0.01158287f, 0.01105664f, -0.02406324f, 
    0.02136955f, -0.02376719f, -0.02283508f, -0.00317982f, -0.03146745f, -0.01020874f, -0.00063666f, -0.00849884f, 
    -0.03392902f, -0.04202274f, -0.01005190f, -0.01365814f, 0.03108248f, -0.01402794f, 0.00174134f, -0.03950113f, 
    0.00997829f, 0.00779643f, 0.02898661f, -0.03375979f, -0.00179693f, 0.02731579f, -0.03634210f, -0.03353973f, 
    -0.02622566f, 0.00129132f, -0.02247649f, 0.02116562f, -0.02921106f, -0.03217858f, -0.03409144f, -0.02276327f, 
    0.01296440f, -0.03060841f, 0.01217563f, 0.01727530f, 0.01167466f, 0.03982282f, 0.04047708f, -0.03302178f, 
    -0.04149193f, -0.04167754f, 0.02581066f, -0.03013204f, 0.01041884f, -0.01861588f, 0.00559274f, -0.00260997f, 
    0.02035122f, -0.03225490f, -0.00991991f, 0.02605495f, 0.00661619f, 0.02570589f, -0.02285687f, -0.03559066f, 
    -0.04079170f, 0.02090589f, 0.01905480f, -0.01743807f, -0.01637662f, 0.01815299f, 0.02117704f, -0.03269375f, 
    -0.00502236f, 0.00593575f, 0.02301666f, 0.02296980f, -0.00709736f, -0.00209481f, 0.00975767f, 0.00749167f, 
    -0.01116274f, -0.01452269f, 0.02730542f, 0.00731047f, 0.01117028f, 0.00442803f, 0.01240032f, -0.00146882f, 
    -0.03576205f, 0.01374704f, -0.03011709f, -0.01115173f, -0.02136363f, -0.03871673f, -0.03819245f, -0.04004860f, 
    0.02596478f, 0.01640942f, -0.03966558f, -0.00628150f, 0.01310839f, -0.01865279f, -0.03927164f, -0.01247665f, 
    -0.03780646f, -0.00287748f, -0.02244771f, -0.02865794f, -0.00924191f, -0.00956284f, -0.03051533f, 0.02657404f, 
    0.01148399f, 0.01519639f, 0.00682012f, -0.04172747f, -0.02462917f, -0.01175555f, -0.01577589f, -0.01350318f, 
    0.01630422f, -0.02331134f, -0.01735171f, 0.02099109f, -0.03377860f, -0.02636014f, -0.00887402f, 0.01106277f, 
    0.00161665f, -0.02292462f, -0.02992450f, 0.01616821f, 0.00169055f, 0.00232698f, 0.02353284f, 0.01268991f, 
    -0.02720719f, 0.03046095f, 0.01339938f, 0.00588350f, -0.02269419f, 0.01071633f, -0.02847297f, 0.01914138f, 
    -0.03415225f, 0.00623624f, 0.02906678f, 0.00158159f, -0.02886970f, -0.00811495f, -0.01029582f, -0.02547584f, 
    -0.01248524f, 0.02171318f, 0.00541687f, 0.01937570f, 0.01923586f, 0.01010450f, -0.03401059f, 0.02432076f, 
    -0.02736462f, -0.01438025f, -0.00413137f, -0.02100760f, -0.02015235f, -0.02112916f, 0.00862826f, -0.00112923f, 
    -0.00999910f, -0.01873173f, 0.00156776f, -0.00982651f, -0.00530552f, -0.04103702f, -0.02593634f, 0.01467639f, 
    -0.04146112f, 0.02168485f, -0.03331247f, -0.00944558f, -0.01228151f, -0.02347923f, -0.03012673f, -0.01352228f, 
    0.00683825f, 0.00246848f, -0.02945686f, -0.01449777f, 0.00180295f, -0.02737734f, -0.02096073f, 0.00993967f, 
    -0.01396524f, -0.02873550f, 0.00951492f, -0.03129660f, -0.02666251f, 0.01791424f, -0.00238217f, -0.02791075f, 
    -0.04005139f, -0.04147014f, 0.01702840f, 0.01848277f, -0.01598423f, 0.01278148f, 0.00169274f, -0.01251913f, 
    0.02201575f, -0.01772719f, -0.02060334f, -0.00339880f, 0.01276418f, -0.01890405f, 0.02503628f, 0.00501379f, 
    0.01362887f, -0.04033265f, -0.03426057f, 0.02130430f, 0.02876705f, -0.00822669f, -0.00542730f, 0.00196276f, 
    -0.04021506f, -0.01511172f, -0.00028916f, -0.01824685f, 0.00349402f, 0.02577038f, -0.01285218f, -0.03010968f, 
    -0.00402573f, 0.04139172f, 0.02387251f, -0.02770238f, 0.00725209f, -0.02370910f, -0.00353878f, 0.01248326f, 
    -0.01779572f, -0.03618411f, -0.00336953f, -0.02455799f, 0.02387730f, 0.00844796f, -0.00220186f, -0.00217282f, 
    -0.00793758f, -0.00604683f, -0.02351731f, 0.00952371f, 0.00308876f, 0.01992086f, 0.02957846f, 0.02542504f, 
    -0.03669011f, -0.01075400f, -0.04049837f, -0.01083052f, 0.02899396f, 0.02558896f, -0.02428077f, 0.02292002f, 
    0.02590992f, 0.00705627f, -0.04032298f, -0.01147701f, -0.00154522f, -0.00906452f, -0.01060712f, -0.03749986f, 
    -0.00000243f, -0.04152389f, -0.02032715f, -0.02497435f, -0.04138095f, 0.02756227f, 0.02733665f, -0.02254869f, 
    -0.03299753f, 0.00694210f, -0.01391512f, 0.01696660f, 0.03595324f, 0.01782952f, 0.00256202f, 0.01337873f, 
    0.01582567f, 0.01463064f, -0.02128915f, -0.00814965f, -0.03233431f, 0.00119097f, -0.00420550f, -0.01564140f, 
    0.00000376f, 0.01963175f, -0.01377372f, 0.02382361f, -0.02234066f, -0.03451840f, -0.03673390f, 0.02830460f, 
    -0.00538454f, 0.02108375f, -0.00982317f, 0.00467804f, 0.01615681f, -0.03126926f, -0.01184660f, -0.03279540f, 
    -0.01717311f, -0.03721728f, 0.00595742f, 0.00788694f, -0.00808305f, -0.02558046f, 0.01183617f, 0.00247836f, 
    -0.02482728f, -0.00999775f, 0.01488028f, 0.00639846f, -0.03361005f, 0.01710426f, -0.00081679f, 0.02247749f, 
    0.00356025f, -0.02174052f, 0.01296477f, 0.01764648f, -0.00025286f, 0.01705556f, 0.01004863f, 0.02599061f, 
    0.00253845f, -0.03609402f, -0.02764475f, 0.02575779f, -0.02326706f, -0.00820434f, -0.03181731f, 0.00152582f, 
    -0.00617335f, 0.01226411f, -0.01615464f, -0.01879731f, 0.01847296f, 0.00272820f, 0.01993564f, -0.00568608f, 
    -0.03896585f, -0.01873535f, 0.02987118f, 0.01091865f, 0.00679119f, 0.03679782f, -0.00606102f, -0.02685326f, 
    -0.02869955f, -0.02555888f, 0.02953269f, 0.02056658f, 0.02407228f, -0.03932589f, -0.02232893f, -0.01771643f, 
    0.02027699f, 0.02125888f, -0.04021625f, -0.02388359f, 0.02015929f, -0.00482529f, -0.00228889f, 0.01117922f, 
    0.00923872f, -0.02657299f, -0.03691685f, -0.00384328f, 0.02670815f, -0.01922957f, -0.02638015f, -0.02319262f, 
    -0.01430443f, -0.01344386f, 0.00636589f, 0.00818637f, 0.02561584f, -0.00145602f, 0.01642645f, -0.03192623f, 
    0.01101684f, -0.00424623f, -0.01611072f, -0.01027598f, -0.03763550f, 0.00667392f, -0.02709293f, 0.00384043f, 
    -0.03798763f, -0.00259457f, 0.00393326f, -0.02563378f, -0.00120402f, 0.00615774f, 0.02329196f, -0.01928310f, 
    -0.03335924f, -0.00824963f, 0.01522877f, -0.02293225f, 0.01631738f, -0.01269099f, -0.02893258f, -0.00624963f, 
    0.02840511f, 0.02614716f, 0.00052298f, 0.02048124f, -0.00786168f, 0.02783410f, -0.01416330f, -0.01596205f, 
    -0.01679628f, 0.01194572f, 0.00452673f, -0.01187523f, -0.03081095f, -0.00222428f, -0.03153072f, 0.02878607f, 
    -0.02781239f, 0.01038257f, 0.02126520f, -0.01746292f, -0.03663093f, 0.00909818f, -0.01571267f, 0.02436430f, 
    -0.02878041f, 0.01668334f, -0.01621367f, -0.02509119f, 0.00637918f, 0.01425825f, 0.01842028f, -0.01264291f, 
    0.00052956f, 0.03123473f, 0.00777191f, 0.02749025f, 0.01620304f, -0.02842502f, -0.00237584f, 0.02156953f, 
    -0.05731897f, -0.09590566f, 0.04679635f, 0.00182909f, -0.02945309f, 0.06413474f, 0.00960211f, 0.04010713f, 
    -0.09139990f, -0.18640517f, 0.01556005f, -0.14352883f, -0.13006601f, 0.04254208f, 0.01711908f, 0.02965614f, 
    0.07146735f, 0.10729922f, 0.04107153f, -0.08611406f, 0.01718239f, -0.13269742f, -0.06616605f, -0.03686433f, 
    -0.22230801f, -0.04109313f, -0.26300701f, -0.02056307f, 0.08094818f, -0.06432164f, -0.16670860f, -0.08519814f, 
    -0.03482001f, -0.00931956f, -0.01157795f, -0.08448263f, 0.20193930f, 0.03347639f, 0.20613466f, 0.19798064f, 
    0.00003647f, -0.00866282f, 0.00268176f, -0.05111223f, 0.02702017f, 0.05460099f, -0.04260102f, -0.05922923f, 
    -0.04176063f, -0.12515280f, 0.12124880f, -0.16161263f, 0.01147118f, 0.06458940f, 0.01456137f, -0.01076081f, 
    -0.05481259f, 0.05779275f, 0.13559566f, -0.15802582f, 0.06014163f, 0.04711571f, 0.07913475f, 0.20074326f, 
    -0.12478292f, -0.09093071f, -0.01767405f, -0.05969587f, 0.05064856f, -0.03126819f, -0.03141145f, -0.05176859f, 
    0.11552703f, 0.12475391f, 0.12161429f, 0.13537316f, -0.04469851f, -0.07370536f, -0.05247066f, 0.00680987f, 
    -0.07498056f, -0.16187511f, -0.03099598f, 0.00280072f, 0.28817564f, 0.07756811f, -0.18373489f, -0.08537077f, 
    0.03663399f, -0.02980698f, 0.11420193f, 0.00949981f, 0.09152775f, 0.00611118f, -0.01091627f, -0.06296770f, 
    0.22703375f, -0.06316531f, 0.01539330f, 0.11694688f, 0.12286743f, 0.01611841f, 0.00704902f, 0.05947618f, 
    0.14631930f, -0.01153088f, 0.01597143f, 0.06923559f, 0.11264262f, -0.02840797f, 0.05504145f, 0.25238949f, 
    0.01540510f, 0.02777040f, -0.04615343f, -0.05742056f, 0.18663870f, 0.06567176f, -0.09978721f, 0.17498586f, 
    -0.18204129f, -0.11471286f, 0.09755529f, 0.08286659f, -0.07738523f, -0.00653094f, -0.00659680f, 0.02605022f, 
    -0.08542676f, -0.03232661f, -0.07220463f, -0.00987168f, 0.01960080f, -0.10377747f, -0.05076612f, -0.20315577f, 
    0.05590328f, -0.05990825f, -0.16335899f, -0.00303431f, -0.03922456f, -0.08731280f, 0.08247621f, -0.11344944f, 
    0.11652517f, 0.04668587f, -0.04501364f, 0.25730842f, 0.20606452f, 0.07187831f, 0.07053913f, 0.01374952f, 
    -0.00258177f, -0.01008109f, 0.09988774f, 0.03312260f, 0.13038051f, 0.07825166f, 0.10880318f, 0.22502112f, 
    0.09330320f, -0.02673772f, 0.01766493f, 0.06677617f, 0.08166680f, -0.01624632f, 0.13582379f, 0.04440610f, 
    0.10489565f, 0.04838289f, 0.00388122f, 0.08441136f, 0.07586023f, 0.07569972f, 0.08267462f, 0.00434593f, 
    0.11299053f, -0.02386767f, 0.05114504f, 0.02041951f, 0.12440711f, -0.17528705f, 0.17082503f, -0.28748986f, 
    0.10478762f, -0.01235235f, 0.08166737f, 0.09162299f, -0.13500200f, -0.05250366f, -0.09686541f, -0.08118203f, 
    0.29728332f, 0.03054251f, -0.00765520f, 0.10081236f, 0.01304451f, -0.01770983f, 0.00178160f, -0.11394234f, 
    0.08290509f, -0.10383508f, -0.07602414f, 0.16453978f, 0.10507476f, -0.44255942f, 0.24898513f, 0.13839370f, 
    -0.07801304f, 0.00549879f, -0.15595065f, 0.18382990f, 0.05576465f, -0.05669448f, -0.05019360f, -0.08868124f, 
    0.10175013f, 0.04137386f, 0.00749508f, -0.09704890f, -0.07079531f, 0.03277342f, 0.08339088f, 0.02056430f, 
    0.01854093f, -0.04970713f, 0.08640964f, -0.08118814f, 0.30755997f, -0.03230657f, 0.10044838f, 0.05163365f, 
    0.03303724f, -0.02252262f, -0.01506003f, -0.00484120f, 0.04687641f, -0.04864488f, -0.06443528f, -0.11927976f, 
    0.12940599f, -0.11321755f, 0.19941385f, -0.13280816f, 0.09059216f, -0.11235388f, -0.06072485f, -0.07156707f, 
    -0.02700356f, -0.06019125f, 0.02441743f, -0.14027627f, -0.34562457f, 0.15488128f, 0.08779247f, 0.15704000f, 
    -0.11272504f, -0.01586870f, -0.03417477f, 0.01208932f, -0.12788031f, -0.15513214f, 0.00002251f, -0.07546952f, 
    0.29011872f, 0.04409050f, 0.06951041f, 0.19419275f, 0.04369138f, 0.04212908f, -0.03615423f, -0.04595007f, 
    0.04151192f, 0.02614811f, -0.01279927f, -0.06311719f, -0.04511653f, 0.04430234f, -0.08261548f, -0.02124236f, 
    0.05471747f, 0.00503796f, -0.05416920f, -0.07529905f, -0.07624562f, -0.03787218f, -0.10164855f, -0.07556038f, 
    0.13888194f, 0.13463242f, 0.07574517f, 0.01003295f, 0.14181687f, 0.20286469f, -0.11786906f, -0.06406751f, 
    -0.07433724f, -0.07075779f, -0.07481170f, -0.00449845f, -0.39633861f, 0.19207977f, -0.01539181f, 0.13479957f, 
    -0.15595274f, -0.00597257f, 0.13232028f, -0.06826117f, -0.04124080f, 0.07056088f, -0.01500650f, 0.00002911f, 
    -0.17027272f, 0.21388322f, 0.06962202f, 0.10985313f, 0.05661040f, 0.14510928f, 0.12808768f, 0.01711051f, 
    0.04113564f, 0.01231456f, 0.02966844f, 0.03799159f, 0.31553611f, 0.39505818f, 0.16348150f, 0.08460262f, 
    0.06321053f, -0.13429765f, 0.09587050f, 0.09236203f, -0.02632671f, -0.01804487f, 0.02161200f, 0.05221093f, 
    0.25189888f, -0.06380563f, 0.08943206f, -0.01722088f, 0.04850111f, 0.01949539f, -0.10017476f, 0.01957488f, 
    0.01914880f, 0.01772143f, -0.02994684f, -0.01577821f, 0.16967830f, -0.27848387f, 0.01378735f, -0.06482609f, 
    -0.08015588f, 0.04580473f, -0.08280224f, 0.02550065f, 0.03714413f, 0.02520704f, -0.08846436f, 0.08384970f, 
    0.41960630f, -0.06994290f, 0.20177086f, -0.00583859f, 0.00408219f, -0.01012663f, -0.01301942f, -0.01739175f, 
    0.08577817f, 0.01627357f, -0.18109028f, -0.19886002f, 0.33914956f, -0.12536906f, 0.00150990f, -0.00018734f, 
    -0.21895692f, 0.01214258f, 0.05552514f, -0.05121440f, 0.11217181f, 0.05236287f, -0.04197968f, -0.02653471f, 
    -0.18411584f, 0.03957406f, -0.00172742f, 0.24334015f, -0.09898765f, 0.10111391f, -0.00001719f, -0.06671435f, 
    0.06784931f, -0.04393922f, 0.00460122f, -0.01652815f, 0.18806137f, 0.10027580f, 0.01319977f, 0.14676732f, 
    -0.01732970f, 0.07737353f, 0.10483778f, -0.02765197f, 0.00485062f, 0.07085619f, -0.04870725f, 0.04693415f, 
    0.08581214f, -0.10382468f, 0.08576880f, 0.08664668f, 0.11293679f, 0.02448626f, 0.07886728f, 0.00788968f, 
    -0.03559222f, 0.05656023f, 0.11002268f, -0.03413733f, 0.18517138f, -0.05915745f, 0.18703794f, -0.21286361f, 
    -0.19887955f, 0.11150964f, -0.02535726f, 0.13847679f, -0.00192697f, -0.06898811f, 0.04207163f, 0.02480531f, 
    0.24451752f, 0.12846299f, -0.36739767f, 0.08290021f, 0.05390240f, -0.05237454f, -0.03732883f, 0.03727847f, 
    0.03470373f, -0.00615144f, 0.04125871f, -0.05587748f, -0.00022797f, 0.19828720f, 0.04748424f, -0.01321664f, 
    -0.02966325f, 0.06994837f, -0.08017517f, -0.20010714f, 0.04675264f, -0.05749923f, -0.15703370f, -0.02090120f, 
    0.07872473f, 0.24931009f, 0.16987595f, 0.00032237f, 0.01496788f, 0.16415033f, 0.06182550f, 0.04974703f, 
    0.02237262f, -0.12486648f, 0.07670686f, 0.13306244f, 0.19757308f, -0.10432743f, 0.11418647f, 0.10715894f, 
    0.19399044f, 0.07543166f, 0.00697560f, -0.06062150f, 0.09661924f, 0.03870912f, -0.01176317f, 0.04973160f, 
    -0.03845323f, -0.01073189f, 0.19777960f, -0.09404554f, 0.02437649f, 0.17308637f, 0.10793763f, 0.03698389f, 
    0.02104022f, 0.11074603f, 0.05885028f, 0.06016201f, 0.04322801f, 0.00660403f, -0.33919826f, -0.26247314f, 
    -0.07591248f, -0.03594238f, -0.01696740f, -0.02464472f, -0.00371599f, -0.06847616f, -0.03179900f, 0.02548083f, 
    0.00989503f, -0.02610720f, 0.12260170f, 0.05753722f, 0.06804182f, 0.05194641f, -0.01995688f, -0.10365622f, 
    0.19022229f, -0.04506561f, -0.06661190f, 0.09755871f, -0.06482500f, 0.09093019f, 0.04319692f, -0.08729594f, 
    0.08450319f, 0.09918235f, 0.03388044f, 0.14237411f, 0.02669209f, -0.00722887f, 0.01614250f, 0.06617778f, 
    -0.20224570f, 0.02991104f, -0.09329880f, -0.29379633f, -0.05789809f, 0.14622904f, 0.02996472f, -0.02227981f, 
    0.03557897f, 0.03988007f, -0.04595254f, -0.01390110f, 0.01664019f, -0.15725388f, 0.11687466f, 0.15312934f, 
    0.01254249f, -0.16390438f, 0.08254460f, -0.13890809f, 0.02054293f, -0.07043138f, 0.02341274f, -0.05296667f, 
    0.04394849f, -0.12466656f, 0.09183022f, 0.14320721f, 0.06136667f, 0.14698128f, -0.08215206f, -0.03454377f, 
    -0.03022099f, 0.02747258f, -0.07210980f, -0.06526492f, -0.32748884f, 0.02238441f, -0.16005602f, 0.03219295f, 
    0.10731092f, -0.06649482f, 0.03248243f, -0.04812516f, 0.01210891f, -0.03139278f, 0.05809204f, -0.00077035f, 
    0.28624156f, -0.18675558f, -0.08872058f, -0.01221551f, 0.05577581f, 0.01049814f, 0.03440976f, -0.18391307f, 
    0.14517544f, 0.04312762f, -0.08459593f, -0.06193295f, 0.13721940f, 0.03308693f, -0.17471178f, 0.18582673f, 
    0.08663582f, 0.03235179f, 0.03940575f, -0.02605559f, 0.12783633f, 0.05802545f, -0.16948767f, -0.05765007f, 
    -0.08278280f, -0.03543203f, 0.11345594f, 0.24659181f, 0.08046804f, 0.00306153f, 0.01099869f, 0.00634747f, 
    0.10989682f, 0.01616970f, 0.00644542f, 0.05734807f, 0.01888622f, -0.17000438f, -0.14994790f, -0.08852328f, 
    -0.02450093f, -0.03673721f, -0.00081128f, -0.07203563f, 0.09898295f, -0.05856369f, 0.05138155f, -0.17680602f, 
    0.14761834f, 0.06909796f, -0.34408474f, 0.12681653f, 0.00001007f, -0.00538549f, 0.12049329f, -0.00528758f, 
    0.11984690f, 0.06714457f, -0.04347510f, 0.12340772f, 0.06930970f, 0.18719879f, -0.52450740f, 0.01265534f, 
    0.09716722f, 0.03631580f, 0.00319356f, 0.08445097f, 0.06182696f, -0.00248270f, -0.08737244f, 0.08716165f, 
    0.18090902f, 0.27686381f, 0.31838971f, -0.06680769f, 0.16278826f, -0.00799375f, 0.08016276f, 0.07476128f, 
    -0.00869430f, -0.01522070f, 0.02733339f, 0.03765401f, 0.04791768f, 0.00783201f, -0.03543124f, -0.10155454f, 
    0.04720031f, 0.05858655f, -0.06154964f, -0.01681138f, 0.10116912f, -0.01226770f, 0.09107995f, 0.00681516f, 
    -0.54327905f, 0.08715682f, -0.20847352f, -0.23368095f, -0.02342076f, -0.06044831f, -0.02172365f, 0.03171879f, 
    0.05603328f, 0.02484242f, -0.01764011f, -0.02320386f, 0.27113584f, -0.03348387f, 0.16478747f, -0.28026572f, 
    0.01410573f, -0.02617705f, 0.04930320f, 0.01122270f, 0.03250025f, 0.03399033f, -0.02049255f, 0.01501104f, 
    0.13858971f, 0.26160771f, -0.34594607f, -0.03755067f, 0.05950065f, 0.00690442f, 0.13243805f, -0.03634939f, 
    0.04681290f, -0.12000913f, 0.02704549f, -0.03652829f, 0.19477974f, 0.08858909f, -0.35149431f, 0.07490700f, 
    0.08499189f, 0.11957633f, 0.05218632f, -0.00154748f, 0.01499317f, 0.05776966f, -0.04224070f, 0.00542962f, 
    -0.09715831f, 0.17829882f, 0.03152564f, 0.07531986f, 0.20345193f, 0.25206593f, 0.09206155f, -0.10654603f, 
    0.03721913f, -0.05410613f, -0.02715029f, -0.00578881f, 0.18044850f, -0.00464264f, -0.11680315f, 0.09501152f, 
    0.12788853f, -0.02735175f, -0.18848844f, 0.11435783f, 0.01707074f, 0.06616869f, 0.20142604f, -0.04595216f, 
    0.16696963f, -0.03067080f, 0.22891895f, 0.21489525f, -0.04152017f, -0.12507287f, -0.03400418f, -0.02098991f, 
    0.09639792f, -0.05683684f, 0.01563541f, 0.01062330f, -0.92476743f, -0.04157323f, -0.06151581f, 0.02255707f, 
    0.00475229f, 0.02636449f, 0.02151504f, -0.01973051f, 0.15275413f, 0.04832583f, 0.00292063f, -0.11804852f, 
    0.01190223f, -0.02426454f, -0.03670763f, -0.02736621f, 0.00982958f, 0.01971249f, -0.02114816f, -0.03788842f, 
    -0.00547417f, 0.02265150f, -0.01654169f, 0.02652229f, -0.00589872f, 0.02847349f, -0.03497689f, -0.02697103f, 
    0.00850353f, -0.00787972f, 0.00438118f, -0.02637578f, -0.03104264f, -0.00203755f, 0.00552501f, 0.02553153f, 
    -0.03066610f, 0.02247070f, 0.02789146f, 0.02363803f, -0.03651168f, -0.03331069f, -0.01815227f, -0.01975638f, 
    -0.01437132f, 0.02611120f, -0.01967888f, -0.03218053f, -0.03160901f, -0.02315434f, -0.00932997f, 0.02072949f, 
    0.01297944f, -0.00346476f, 0.00170663f, -0.01033626f, -0.03654564f, -0.02435861f, -0.01610313f, -0.02844235f, 
    0.00701985f, -0.02486962f, -0.00652403f, -0.00553630f, -0.00454727f, 0.01050729f, -0.03267389f, 0.00083629f, 
    -0.02071689f, -0.01630503f, -0.02510398f, -0.01470719f, -0.02817212f, -0.02072470f, -0.02555495f, 0.02825113f, 
    0.01270396f, -0.03796002f, 0.03067594f, -0.03377343f, -0.02508372f, -0.03922509f, 0.02251818f, -0.02218533f, 
    0.02742942f, -0.01917936f, -0.03441067f, -0.03456846f, -0.01055593f, 0.00862314f, -0.02128076f, 0.02214592f, 
    -0.00499608f, -0.00676914f, 0.00894177f, 0.02104473f, 0.02527522f, -0.00407404f, -0.03931903f, -0.01478187f, 
    0.00425094f, 0.02900860f, -0.00688856f, -0.02285912f, -0.00823795f, -0.01197363f, -0.01221602f, 0.00415019f, 
    -0.02905297f, -0.03560669f, -0.02041598f, -0.03957343f, 0.00343567f, -0.03230809f, -0.03350142f, 0.02253700f, 
    -0.01859172f, -0.02868638f, 0.02845776f, -0.03959958f, 0.00051027f, -0.02528773f, -0.03071065f, -0.00335847f, 
    0.02411818f, 0.01365028f, 0.01890487f, -0.04117796f, -0.00262873f, -0.00697326f, -0.01510594f, -0.00628460f, 
    -0.01555897f, 0.00673693f, -0.00464643f, -0.02237364f, -0.00191709f, -0.01196972f, -0.04040213f, -0.01212611f, 
    -0.02197636f, 0.02644948f, -0.01551632f, 0.01891235f, -0.02432108f, -0.02227255f, 0.01033911f, 0.02035259f, 
    -0.02312547f, 0.02766654f, -0.03106254f, -0.01623586f, 0.02329054f, -0.00497891f, 0.01952171f, 0.00747239f, 
    -0.01064144f, -0.00008059f, -0.03786202f, -0.01628668f, 0.01942828f, 0.01409441f, -0.00933295f, -0.01211252f, 
    -0.03457516f, -0.02796389f, -0.00709214f, -0.03578582f, -0.00951202f, -0.00252433f, -0.00887243f, -0.01460567f, 
    -0.01430592f, 0.02268828f, -0.01082025f, 0.03425095f, -0.01971104f, -0.02884055f, -0.00083547f, -0.02190561f, 
    0.02956068f, 0.02722635f, 0.02284667f, 0.02884570f, -0.03729915f, 0.02012168f, -0.00555676f, 0.02516319f, 
    -0.01972070f, -0.02051817f, -0.01986284f, -0.02991763f, 0.00926416f, 0.02387407f, -0.00894804f, 0.01351614f, 
    -0.00280355f, -0.02199875f, 0.02136665f, 0.02840357f, 0.02396917f, -0.02021746f, -0.00314118f, 0.00267720f, 
    -0.02918602f, 0.00910283f, -0.02374238f, -0.03304467f, 0.00661119f, 0.01428265f, -0.01803281f, -0.00216774f, 
    -0.03382972f, -0.03433065f, 0.00410078f, 0.01901631f, -0.01276649f, -0.00869540f, -0.00845068f, 0.01681263f, 
    -0.03405226f, -0.02909765f, 0.02131144f, 0.00685325f, -0.03226939f, -0.02495407f, 0.00778867f, 0.00103561f, 
    0.00097950f, 0.03093050f, -0.02065584f, 0.00204640f, 0.00682907f, 0.00323369f, 0.03337895f, 0.01260889f, 
    -0.03058449f, -0.02592815f, -0.02577727f, -0.00903193f, -0.01420841f, 0.02674041f, 0.02830143f, -0.02556084f, 
    0.00596911f, -0.01183819f, -0.00142627f, -0.02976117f, -0.03062147f, -0.01208612f, -0.04085428f, -0.00384914f, 
    -0.02040090f, -0.01268716f, -0.02364957f, -0.00478075f, 0.02158163f, 0.00647754f, -0.00271131f, -0.04142876f, 
    0.01703325f, -0.02900347f, 0.01334271f, -0.01292282f, 0.01247621f, 0.02643062f, 0.00957295f, -0.01073629f, 
    -0.02374870f, -0.01098651f, -0.01450396f, 0.00036596f, 0.01408533f, -0.03480639f, 0.01751815f, -0.00558101f, 
    -0.03623933f, 0.00259915f, 0.00536978f, -0.03093575f, -0.00838153f, -0.00465160f, -0.00421081f, 0.01835275f, 
    0.02365782f, -0.01522354f, -0.03760949f, -0.01669611f, 0.01297037f, 0.02981295f, -0.01493515f, -0.02696230f, 
    0.00744493f, -0.03007982f, 0.00543947f, 0.01749919f, 0.00955706f, -0.03316452f, 0.01822893f, -0.01079731f, 
    0.01355624f, 0.01526508f, -0.03660485f, 0.02944269f, -0.02607179f, -0.02384296f, -0.00091835f, -0.01019193f, 
    -0.00288229f, -0.02449912f, -0.00455230f, -0.03356602f, 0.00817095f, -0.03864046f, -0.01124696f, 0.00613162f, 
    -0.03078099f, -0.02244879f, 0.00783791f, 0.00330028f, -0.01198760f, -0.02349601f, -0.01631883f, 0.01358659f, 
    -0.03528193f, 0.00331302f, -0.02288735f, -0.02670585f, -0.03594601f, -0.00003690f, -0.00177041f, -0.02155316f, 
    -0.02700064f, -0.00466644f, 0.00643219f, 0.02492746f, 0.00593544f, 0.02229945f, -0.00392597f, -0.00771593f, 
    -0.02858408f, -0.04007512f, 0.00989244f, 0.02605601f, -0.02362307f, -0.03452791f, -0.01811056f, -0.01139331f, 
    0.02120438f, 0.00417298f, -0.02678879f, -0.00351177f, 0.02902374f, -0.00985611f, -0.01852176f, 0.01377991f, 
    0.01960081f, 0.02844282f, -0.03410548f, 0.02412128f, 0.02326348f, 0.02980687f, -0.00463074f, 0.00138095f, 
    -0.02969223f, -0.02499975f, 0.00643206f, -0.02768089f, -0.03490168f, -0.01043197f, 0.02740188f, -0.00474116f, 
    0.01708598f, -0.00466852f, -0.01563630f, -0.02579967f, 0.01121976f, -0.03040201f, -0.03855714f, -0.02996808f, 
    0.00330532f, 0.02395058f, -0.00411141f, -0.02745028f, -0.01030375f, 0.00932976f, 0.01958933f, -0.01272698f, 
    0.00431824f, -0.01766288f, -0.02664121f, -0.01812200f, 0.01792490f, -0.03208653f, -0.01955386f, -0.00539283f, 
    0.00837213f, 0.00953918f, -0.00527056f, -0.03058305f, -0.01971313f, 0.01937759f, -0.00970399f, -0.03507939f, 
    -0.00351384f, -0.02908289f, -0.03233723f, -0.00511968f, -0.02968437f, 0.02334566f, 0.00523241f, 0.00407947f, 
    -0.01891500f, -0.02032257f, -0.03875222f, -0.00260930f, 0.02566614f, 0.01866787f, 0.02167059f, 0.01173016f, 
    -0.03268021f, 0.02940127f, 0.01110586f, 0.01915709f, -0.03110095f, -0.01282908f, 0.02213420f, -0.01002103f, 
    -0.00666308f, -0.03699487f, -0.03611316f, -0.00116152f, 0.00828552f, 0.02253480f, 0.01252630f, -0.02308104f, 
    0.01359318f, 0.01110433f, 0.01475775f, -0.01300648f, -0.01906847f, -0.00029058f, -0.03231492f, -0.01743370f, 
    0.00918177f, -0.01606313f, -0.02350791f, -0.00155749f, -0.01015864f, -0.01055519f, -0.03338677f, -0.00243916f, 
    -0.00205644f, 0.00959182f, -0.03797610f, -0.01256000f, -0.02277115f, 0.03247814f, -0.01271275f, -0.02806143f, 
    -0.01913610f, 0.02208109f, -0.01839883f, -0.02765336f, 0.02110055f, 0.02124115f, 0.02470143f, -0.02356500f, 
    0.02330641f, -0.02290219f, 0.01087123f, 0.01133924f, -0.01955993f, 0.02479068f, -0.00469959f, 0.02086699f, 
    0.02324675f, 0.02025441f, 0.01557239f, -0.01506805f, -0.00118623f, 0.02150430f, -0.02044815f, -0.02752741f, 
    0.00863650f, -0.01140703f, -0.01168398f, 0.02667556f, 0.02812667f, -0.03145311f, 0.02825209f, 0.00139343f, 
    -0.01219277f, 0.02119418f, -0.01703125f, -0.02980399f, -0.01084481f, -0.01494387f, -0.02771376f, 0.02047784f, 
    -0.01086313f, 0.01672464f, 0.00888546f, -0.02369088f, 0.00830712f, -0.00673746f, -0.01265231f, 0.01830756f, 
    -0.02887595f, -0.01375114f, 0.01085753f, -0.01558179f, -0.03280011f, -0.00423311f, -0.01898254f, 0.00705898f, 
    0.00352857f, -0.02421589f, -0.01946738f, -0.02965709f, 0.00479349f, 0.00977530f, 0.00271299f, 0.00458078f, 
    -0.00511856f, -0.04067811f, -0.03538553f, -0.02238264f, -0.03884001f, 0.00623644f, -0.00660933f, 0.01102545f, 
    -0.02777912f, 0.00446437f, -0.01627656f, -0.01180084f, -0.01513346f, -0.02350676f, -0.00850283f, -0.00170686f, 
    -0.01572698f, -0.00783259f, 0.02123884f, -0.00054432f, -0.03734275f, 0.02036875f, -0.02695476f, -0.01584121f, 
    0.01215534f, 0.02137314f, -0.01247539f, 0.02637568f, -0.04135748f, 0.01823064f, -0.03528575f, 0.00107096f, 
    -0.02995009f, -0.02797634f, -0.03353147f, -0.03238247f, -0.03959164f, 0.02042534f, 0.01906181f, 0.01852161f, 
    0.01703014f, -0.00034396f, 0.01634575f, 0.00307482f, 0.00916574f, -0.03194757f, 0.01956755f, 0.02306898f, 
    0.02207928f, 0.02180389f, 0.00086202f, 0.01115968f, -0.03562547f, -0.03968457f, -0.00999773f, -0.02093070f, 
    0.03029468f, -0.02977948f, 0.00590714f, -0.02905497f, -0.01796869f, 0.02511597f, -0.00862348f, -0.00956174f, 
    0.00531878f, -0.01278616f, 0.02739304f, -0.01089768f, 0.01259484f, 0.00044572f, -0.03246637f, 0.00352097f, 
    0.03017348f, 0.01902112f, -0.01789276f, 0.01232485f, -0.00994557f, -0.02212307f, -0.00897256f, -0.00989110f, 
    0.01508143f, -0.02306822f, -0.01541221f, 0.02998305f, -0.00545031f, 0.01129318f, 0.02676478f, -0.00485418f, 
    0.02126024f, -0.03153314f, -0.03181656f, -0.01965937f, -0.02432397f, 0.01769413f, -0.02236032f, -0.02820016f, 
    0.02155300f, -0.01504346f, 0.01394530f, 0.01086709f, -0.00962439f, -0.01282361f, -0.03458914f, -0.00851367f, 
    0.02543572f, 0.00560182f, -0.04020761f, -0.03534572f, 0.00676467f, -0.03592966f, 0.00210848f, 0.02982234f, 
    -0.03234279f, -0.01626427f, -0.00828588f, 0.01660699f, -0.01130215f, 0.01151019f, 0.01759461f, -0.03406805f, 
    0.00316336f, 0.02612798f, -0.00665402f, 0.00969899f, 0.00251018f, -0.02132592f, 0.00442180f, 0.01632011f, 
    -0.02944490f, -0.04011848f, -0.02970241f, -0.01697167f, -0.02932031f, 0.00153034f, 0.02294875f, 0.00056404f, 
    0.01758610f, 0.01426211f, 0.02748964f, 0.00500960f, 0.02461433f, 0.02018426f, -0.00341380f, 0.01143078f, 
    -0.03978591f, -0.01842294f, 0.01664815f, 0.01766805f, 0.02536453f, -0.03319193f, 0.02534512f, 0.01075662f, 
    -0.00798052f, -0.02896653f, 0.01132743f, 0.00495525f, -0.00870713f, -0.00244402f, 0.00254459f, 0.00703340f, 
    -0.03612148f, 0.00150157f, -0.04072404f, -0.00988408f, -0.01764196f, -0.00243666f, -0.02694285f, -0.00751078f, 
    0.01494616f, -0.02147239f, -0.01319769f, -0.00173831f, -0.03384023f, -0.00114294f, -0.03616241f, 0.02198431f, 
    0.00999624f, -0.00067324f, -0.00402109f, -0.00999135f, 0.00788207f, -0.00786479f, -0.01760665f, 0.02056727f, 
    -0.01891273f, -0.02121534f, -0.00497123f, 0.01325368f, 0.00899447f, 0.02430597f, 0.01756120f, -0.02921160f, 
    -0.00287713f, 0.00647391f, -0.02199225f, -0.03443954f, -0.02610595f, 0.00453545f, -0.02067925f, 0.01677243f, 
    0.00204955f, -0.00536232f, -0.03252909f, 0.01285736f, 0.00593927f, 0.00346650f, -0.00595038f, -0.03130502f, 
    -0.00334631f, -0.00611605f, -0.01935626f, 0.01469246f, -0.00834021f, 0.02482631f, 0.02549759f, -0.02772274f, 
    0.01604975f, -0.00648764f, -0.02881301f, -0.01420115f, 0.02639019f, -0.02845693f, 0.00225316f, 0.01629904f, 
    0.02334991f, -0.00521294f, -0.03225032f, -0.01619797f, -0.00018424f, -0.03909953f, 0.01366251f, -0.01787926f, 
    -0.03003578f, -0.01709528f, -0.01039480f, -0.02683588f, 0.02656523f, 0.01478397f, 0.00238593f, -0.03236871f, 
    0.00626860f, -0.00598206f, 0.01719910f, 0.00435929f, 0.00569443f, -0.02753699f, -0.02308306f, 0.02400847f, 
    0.00890010f, -0.03250349f, 0.00678479f, 0.02256725f, -0.03295832f, -0.03613111f, -0.00471020f, -0.03054172f, 
    0.02284452f, 0.01926316f, -0.03182745f, -0.00896960f, -0.00271730f, 0.02206144f, 0.00429588f, -0.00134349f, 
    0.03047099f, -0.01271140f, 0.02005413f, 0.00053662f, -0.01092515f, 0.02124532f, -0.00831701f, 0.01494766f, 
    -0.00489224f, 0.00141604f, -0.00453250f, 0.01277490f, -0.00335113f, -0.02323545f, 0.00216857f, 0.01701303f, 
    -0.00089181f, -0.03743992f, 0.02678999f, -0.01325046f, 0.01072685f, -0.00103468f, 0.01361488f, -0.03727947f, 
    -0.02348672f, -0.01432241f, -0.00124239f, 0.00224833f, -0.03575776f, -0.03902385f, 0.00773646f, 0.00005984f, 
    -0.02459245f, 0.00399129f, 0.01435411f, -0.03181120f, -0.01011776f, 0.00866443f, -0.00275398f, -0.01311084f, 
    0.02860310f, -0.03021722f, -0.02851875f, -0.01387975f, 0.01606866f, -0.00020237f, -0.02086192f, -0.00380506f, 
    0.01545931f, 0.02863649f, -0.03218325f, -0.00129174f, 0.02030803f, 0.00721161f, -0.01040606f, -0.00648782f, 
    -0.03442730f, 0.02690749f, 0.01680134f, -0.00435791f, -0.03476701f, 0.03067155f, 0.02498167f, 0.01557225f, 
    -0.01638463f, -0.01654765f, -0.03648886f, 0.02141881f, -0.02801584f, -0.00391401f, 0.04023718f, 0.00835893f, 
    0.01288673f, -0.02535394f, -0.02784443f, 0.02898169f, 0.02829499f, -0.03852104f, 0.01949556f, -0.03680345f, 
    0.01457586f, -0.03405838f, -0.03515251f, -0.00616790f, -0.02441196f, -0.01328648f, -0.00966316f, 0.02265862f, 
    0.03852051f, 0.03098834f, 0.02731417f, -0.00725856f, -0.03557425f, 0.02323759f, -0.00933337f, 0.02398243f, 
    0.00715780f, 0.01465777f, 0.01850085f, -0.02164961f, 0.00520674f, -0.01840673f, 0.01647279f, 0.01801896f, 
    0.01815925f, 0.01422994f, -0.02476861f, -0.00225518f, -0.01543162f, -0.02803970f, 0.00945164f, -0.01899032f, 
    -0.01613591f, 0.01048924f, -0.03681157f, -0.00027504f, 0.02151239f, -0.00321558f, 0.00129802f, -0.00167515f, 
    0.02077070f, -0.00318296f, 0.01364330f, -0.01670121f, 0.01504017f, -0.02788868f, -0.03791384f, -0.03325153f, 
    -0.01643625f, -0.01417570f, -0.02386954f, 0.01332322f, 0.01465709f, -0.04146355f, -0.02897341f, 0.00503956f, 
    0.01483258f, -0.01509253f, -0.02534334f, -0.01097092f, 0.00011696f, 0.01065167f, -0.02615396f, -0.00327785f, 
    0.02103908f, -0.03354287f, -0.01704572f, 0.00122994f, -0.03481403f, -0.02458507f, -0.03001966f, -0.02642569f, 
    0.01883060f, 0.00014062f, -0.01872820f, -0.01196882f, 0.02266205f, 0.00958248f, 0.02589560f, 0.01997084f, 
    0.02105732f, -0.01518175f, -0.00385640f, 0.01974223f, -0.02079077f, -0.02569018f, 0.01799368f, 0.01849281f, 
    0.00048993f, 0.00127928f, 0.01223855f, -0.01075043f, -0.00310641f, -0.02791256f, 0.00409101f, 0.02240852f, 
    0.01802921f, 0.02265239f, 0.02870171f, 0.00669497f, 0.01671597f, -0.01516786f, 0.01026420f, -0.02413253f, 
    -0.03865097f, -0.00853045f, 0.00115399f, -0.02504012f, 0.03041404f, 0.02752384f, -0.03099160f, -0.03588570f, 
    -0.02681644f, -0.02675897f, 0.02309661f, -0.02454337f, 0.00202829f, -0.00281277f, 0.01262802f, -0.04132628f, 
    -0.02880153f, -0.03322493f, 0.03095519f, -0.01262992f, -0.02368066f, -0.01002088f, 0.00254597f, 0.01693243f, 
    -0.03593013f, -0.01704648f, 0.02361582f, 0.01042383f, 0.01150351f, -0.03634000f, 0.00003563f, -0.02558860f, 
    0.00251960f, -0.00855885f, 0.01548932f, 0.02154070f, 0.01644903f, 0.01648290f, 0.02082614f, 0.00120559f, 
    0.02978971f, 0.02723971f, 0.00036409f, 0.01069107f, 0.00869323f, 0.01959820f, 0.02558181f, -0.03981451f, 
    0.01360810f, -0.00434690f, 0.01879645f, 0.03006651f, 0.00212476f, -0.02011172f, -0.00118455f, -0.01965048f, 
    -0.03020113f, -0.03112284f, 0.01948543f, -0.01825496f, 0.02066437f, 0.03355687f, -0.03537651f, -0.02139067f, 
    0.01016887f, -0.01495703f, -0.03449516f, 0.00384252f, -0.01540649f, -0.04205082f, -0.03450397f, -0.03644396f, 
    0.00619276f, -0.01010768f, -0.01124769f, 0.02175272f, -0.01973257f, -0.03082499f, 0.02404518f, -0.02815173f, 
    -0.02006721f, -0.02616847f, 0.02578495f, -0.00675897f, 0.02681616f, 0.02258961f, -0.02814577f, -0.00447095f, 
    -0.01560286f, -0.01945432f, 0.01415427f, -0.00258652f, -0.02109372f, -0.00968189f, 0.01074270f, -0.02647015f, 
    0.00640508f, 0.02147482f, -0.02832539f, -0.01407008f, 0.02340046f, -0.01691653f, 0.00712772f, -0.01587395f, 
    0.03000097f, 0.00559515f, 0.01221637f, -0.03815590f, -0.02233916f, -0.03429812f, -0.01202659f, -0.00141697f, 
    0.01097057f, 0.00908955f, 0.00550125f, 0.02144111f, -0.00298073f, -0.00838513f, 0.02163187f, 0.00680668f, 
    0.00292084f, -0.02887312f, 0.00077523f, -0.01488861f, 0.00460529f, 0.00068286f, -0.01318061f, -0.01421508f, 
    -0.01914423f, -0.01309829f, -0.02890574f, 0.02205076f, -0.04154307f, -0.01144351f, -0.00760383f, -0.00903567f, 
    -0.02065986f, -0.03576268f, 0.00715209f, 0.00144540f, -0.00168723f, -0.00899787f, 0.00418025f, -0.01449777f, 
    0.02813136f, -0.00200892f, -0.00951484f, -0.03617943f, 0.02134209f, 0.00921622f, 0.00474096f, -0.00373630f, 
    0.02438690f, 0.02862868f, 0.03192990f, 0.02781078f, -0.03797207f, -0.01026040f, -0.02609599f, -0.00693137f, 
    -0.01132875f, -0.02702617f, -0.00263931f, 0.00394001f, -0.00442786f, 0.00734500f, -0.03271075f, 0.00236208f, 
    0.02739901f, 0.02127261f, 0.01848677f, 0.01211936f, -0.00178717f, -0.00426244f, 0.02013895f, -0.02447565f, 
    0.00943661f, 0.02628697f, 0.01012291f, -0.00327355f, -0.02024406f, -0.02690401f, -0.01303196f, -0.03954725f, 
    -0.01252450f, 0.01266360f, -0.01602419f, 0.00016396f, 0.02718625f, 0.02817204f, -0.02973196f, 0.01744585f, 
    0.01442061f, 0.01590229f, -0.02340407f, -0.01151589f, -0.03488646f, -0.04157303f, 0.00986984f, -0.02614054f, 
    -0.04297951f, 0.02326300f, -0.03456863f, -0.01539368f, 0.00840570f, 0.01280541f, -0.00113338f, -0.03625300f, 
    0.01275661f, -0.01043401f, 0.01721723f, -0.01850854f, -0.00756786f, -0.00881747f, 0.02107128f, -0.00951944f, 
    -0.01617688f, -0.00121643f, -0.03808745f, 0.02678940f, -0.03116747f, 0.01540919f, 0.00269841f, -0.00657045f, 
    0.03085866f, 0.01360992f, -0.01800022f, -0.01339176f, -0.01554969f, 0.00320759f, -0.02142819f, -0.02808948f, 
    0.01762701f, 0.02252508f, -0.00148090f, -0.00273216f, 0.01944290f, -0.02038809f, -0.04043422f, 0.01275290f, 
    0.01707514f, 0.01678392f, 0.02504933f, 0.00279958f, -0.03776369f, -0.02682465f, 0.00612371f, 0.01181874f, 
    -0.01868444f, -0.00271991f, -0.02899333f, 0.01211151f, -0.01913178f, -0.01090875f, -0.00503153f, -0.02500495f, 
    -0.01771590f, -0.01253156f, -0.03148216f, -0.02511094f, 0.01839857f, -0.03306881f, -0.02082556f, 0.00258090f, 
    -0.01250249f, -0.02079886f, -0.00534436f, 0.02555411f, -0.00366708f, 0.00963711f, 0.01266042f, -0.00958221f, 
    0.02321356f, -0.02596664f, -0.00100517f, -0.01231856f, -0.04014185f, -0.01119486f, -0.03687773f, -0.03382510f, 
    -0.04223647f, 0.00124744f, -0.00537077f, -0.03710318f, -0.00346824f, 0.01832091f, -0.02966082f, 0.00668583f, 
    0.01980839f, 0.02844084f, -0.02363809f, -0.01013057f, -0.02839404f, 0.01697383f, 0.02027603f, 0.00472673f, 
    -0.03225673f, -0.03125634f, -0.00132799f, 0.03230080f, -0.03089274f, -0.01243414f, -0.03158434f, 0.02882823f, 
    0.04056244f, 0.01455880f, 0.01483741f, 0.01573676f, -0.03431657f, 0.01814310f, 0.00558228f, -0.00003616f, 
    0.01454003f, 0.01153102f, 0.01744017f, 0.02094799f, -0.01801669f, -0.04223403f, -0.04122482f, -0.02543576f, 
    0.00017309f, -0.02101214f, -0.01345285f, -0.00459998f, -0.03688136f, 0.00866748f, -0.02676500f, -0.01936819f, 
    0.00042076f, 0.01078616f, -0.02913904f, 0.00572128f, 0.02243945f, -0.03354700f, 0.00453671f, -0.00547045f, 
    0.02520299f, 0.01443461f, -0.01118306f, 0.02292162f, -0.02056264f, 0.02356507f, 0.00083764f, -0.00540051f, 
    0.02849699f, 0.00447325f, 0.00516635f, 0.01215418f, -0.03396240f, 0.01111320f, 0.02539502f, -0.02531912f, 
    -0.02964911f, 0.00322851f, -0.03739801f, -0.01572613f, -0.00894385f, 0.01651944f, -0.00720336f, 0.02258773f, 
    0.01609696f, -0.02216275f, 0.00354402f, -0.00537565f, 0.00190602f, 0.02293611f, -0.00194567f, -0.04021338f, 
    -0.02366904f, 0.01192349f, -0.01088580f, 0.01684806f, -0.01158875f, -0.01157293f, 0.02760350f, 0.02558949f, 
    0.00581915f, -0.02473505f, -0.02432456f, -0.01810210f, 0.01323682f, 0.02178230f, -0.02820496f, 0.02145468f, 
    0.02803854f, -0.03495987f, -0.04010007f, 0.00321933f, -0.00324296f, 0.03025203f, -0.03506692f, 0.02323266f, 
    -0.03837004f, -0.01860784f, 0.00006990f, 0.02722686f, 0.00114230f, -0.02550611f, -0.01513243f, -0.04049215f, 
    0.00907804f, -0.02884812f, 0.00894024f, 0.00165838f, 0.00733410f, 0.01970433f, -0.01074812f, -0.01835714f, 
    -0.01540744f, -0.03204464f, -0.01015898f, -0.03054058f, 0.02045043f, 0.01546549f, -0.00456612f, -0.03573402f, 
    -0.01330410f, -0.03615103f, 0.02814812f, 0.00123432f, 0.00104955f, -0.00054146f, -0.02104768f, -0.02806805f, 
    0.02777525f, -0.01581483f, -0.01228046f, -0.02263564f, -0.02930553f, -0.02903402f, -0.01703698f, -0.01062819f, 
    -0.02031173f, -0.01875553f, 0.02280285f, 0.00055746f, -0.01668177f, -0.03977315f, 0.00031612f, 0.01249299f, 
    -0.02879861f, -0.00804100f, -0.03501363f, -0.02968361f, -0.03908375f, -0.02610554f, -0.02895963f, 0.01057960f, 
    -0.01474575f, 0.00706118f, 0.02433408f, -0.02321172f, -0.04000261f, -0.00556786f, 0.00751707f, -0.02630545f, 
    -0.03538999f, -0.02917572f, 0.00654741f, 0.01713542f, -0.01228227f, -0.01254369f, -0.00410123f, 0.00164750f, 
    -0.00848004f, -0.02024441f, 0.00027952f, -0.04171638f, -0.00576523f, -0.01576809f, 0.01357359f, -0.03465240f, 
    -0.02648465f, -0.02395458f, 0.01911261f, 0.01145764f, 0.02334760f, 0.01505142f, -0.00135368f, 0.00013957f, 
    -0.03014050f, -0.03642182f, -0.00329665f, -0.02780382f, 0.00852630f, -0.03048841f, -0.02966246f, 0.01494220f, 
    -0.02570198f, 0.02335574f, -0.00483343f, 0.01879599f, -0.04068384f, 0.02560202f, 0.01949534f, 0.02211298f, 
    -0.01745123f, -0.02541409f, 0.00726267f, -0.00889596f, 0.00202265f, -0.01014784f, 0.00031421f, 0.02583748f, 
    -0.03549314f, 0.02112029f, 0.00943523f, 0.00240603f, 0.03143937f, -0.03062401f, 0.01780150f, -0.00427371f, 
    -0.00636549f, 0.02484528f, 0.01952774f, 0.01610009f, -0.03764722f, 0.02838498f, 0.02715160f, 0.00556852f, 
    0.00865921f, -0.01678697f, -0.01929142f, 0.02325965f, 0.01841442f, -0.00966564f, -0.01665520f, 0.02174517f, 
    0.02641312f, 0.02765768f, 0.02036569f, -0.00312424f, 0.01993566f, 0.01315005f, 0.03090441f, -0.00464264f, 
    -0.02786813f, 0.03452362f, 0.00749222f, -0.02767122f, -0.01087039f, -0.02468859f, -0.00582108f, -0.00651458f, 
    -0.00392688f, 0.00384262f, 0.01484435f, -0.01855919f, 0.00163707f, -0.03003988f, 0.02701231f, -0.01026413f, 
    -0.00146271f, 0.01049314f, -0.00925210f, 0.02061350f, 0.00381316f, 0.00850473f, -0.00699149f, -0.04007200f, 
    0.01557837f, -0.03602784f, 0.01772470f, -0.01095109f, 0.02165733f, -0.03604791f, -0.02081437f, 0.00018965f, 
    -0.03584139f, 0.01239535f, -0.00802496f, 0.00918593f, -0.02804860f, -0.02130116f, 0.01937521f, -0.01556198f, 
    -0.14129736f, -0.04546625f, 0.06078962f, 0.08410097f, 0.02898776f, 0.05334803f, -0.06293542f, -0.06010895f, 
    -0.08941139f, 0.05560310f, -0.10453597f, -0.09067728f, 0.26630142f, 0.14453559f, -0.16971384f, -0.11940989f, 
    0.17724815f, -0.02752978f, 0.05806794f, -0.05106883f, -0.00276974f, 0.04298001f, -0.07530858f, 0.09792563f, 
    0.21610579f, -0.11066422f, 0.10452923f, 0.06995917f, 0.15472542f, 0.12728488f, 0.00769778f, -0.07727581f, 
    -0.06498226f, 0.02483473f, -0.10512147f, -0.01681579f, -0.14995769f, -0.06890302f, -0.21522658f, -0.18301825f, 
    -0.03643752f, 0.01609809f, 0.03464077f, 0.02761820f, -0.13540910f, -0.15787409f, 0.02670104f, -0.01030093f, 
    -0.20997345f, -0.08095913f, -0.25102156f, 0.12867741f, 0.14272039f, 0.20286809f, 0.05499218f, 0.12208761f, 
    -0.02289077f, -0.05386019f, -0.04986058f, 0.01510139f, 0.05029334f, -0.10928186f, 0.10132118f, -0.21503067f, 
    0.07580907f, 0.03721557f, 0.04064084f, 0.10023985f, -0.04590853f, -0.09726658f, 0.04079199f, -0.02571574f, 
    0.05408620f, -0.10093164f, 0.02381916f, -0.04226227f, 0.18504854f, 0.07531671f, 0.06377666f, 0.00230291f, 
    0.08911525f, 0.09663396f, 0.06363468f, -0.10096140f, 0.06672788f, -0.03334738f, -0.02607984f, 0.11494690f, 
    -0.20704976f, -0.09323008f, -0.16717939f, 0.12069269f, -0.12533598f, 0.06545597f, -0.00156162f, -0.00434324f, 
    -0.06028983f, 0.12098825f, 0.24348707f, 0.09257324f, -0.10148364f, 0.05906668f, -0.11434504f, 0.01884134f, 
    0.00730368f, 0.03157900f, -0.06074765f, 0.02104174f, -0.20492643f, 0.11427545f, -0.16809823f, -0.01943671f, 
    0.10347100f, 0.05508826f, 0.01341905f, 0.03584064f, -0.04074609f, -0.09882788f, 0.14801820f, -0.09109116f, 
    0.03033422f, 0.17826228f, -0.02451597f, -0.14596725f, 0.03472700f, -0.07553169f, -0.00310870f, -0.04228642f, 
    -0.14365494f, -0.02647131f, -0.11733954f, -0.04693535f, -0.19169413f, 0.16420650f, 0.06805821f, 0.25935224f, 
    0.00932694f, 0.10173916f, -0.11421176f, -0.15887095f, -0.00432018f, 0.12657033f, -0.16039078f, -0.03053004f, 
    -0.14341377f, 0.22817448f, 0.24935809f, -0.01876617f, -0.06965553f, -0.10895008f, -0.09456035f, 0.04549729f, 
    0.00526975f, 0.05517377f, 0.01519470f, 0.03360325f, 0.04053917f, 0.04427832f, -0.03577197f, -0.10659126f, 
    -0.07798541f, -0.00984653f, 0.01792171f, -0.03654237f, 0.06709636f, 0.08415423f, 0.03108534f, 0.05197110f, 
    -0.28953308f, 0.06312247f, 0.16380100f, 0.05727601f, -0.00297556f, 0.05046398f, -0.05420819f, -0.01550035f, 
    -0.09670132f, 0.10805115f, -0.11164848f, 0.08470131f, 0.14448759f, 0.22490920f, -0.27333081f, 0.08697270f, 
    -0.18787310f, 0.02136015f, 0.07485466f, -0.06899141f, 0.10249412f, 0.07750677f, -0.06717980f, 0.00624725f, 
    -0.45475969f, 0.11953517f, 0.27736726f, 0.14803298f, -0.03155580f, 0.14368932f, -0.05578198f, 0.08582264f, 
    0.03031133f, -0.19577023f, 0.26275209f, -0.01779856f, 0.15744977f, 0.48458436f, -0.17109381f, -0.34593883f, 
    -0.01415264f, -0.17306255f, 0.12693965f, -0.01155192f, -0.04105294f, 0.06535845f, -0.09633955f, -0.06063942f, 
    -0.02636027f, -0.03297061f, -0.05685246f, 0.04665068f, 0.06404531f, 0.12738824f, 0.12676711f, 0.02875886f, 
    0.10736386f, 0.17543858f, -0.08877151f, -0.02640373f, -0.23845573f, 0.11346606f, -0.03347605f, 0.05402140f, 
    -0.01317607f, 0.01145052f, 0.07491150f, 0.05680456f, 0.02506447f, -0.02842470f, 0.01562755f, 0.14932011f, 
    -0.33224207f, 0.05692340f, 0.12589149f, 0.25253019f, -0.17391545f, 0.10055710f, -0.12589371f, -0.06481839f, 
    -0.05333135f, -0.12288833f, 0.06725329f, 0.07979751f, 0.32568070f, -0.15920003f, -0.19546524f, -0.10805219f, 
    0.02894887f, 0.08032583f, -0.09260675f, -0.00045089f, -0.10503154f, 0.14453314f, -0.17507173f, 0.05877040f, 
    -0.07738614f, 0.01159454f, -0.29360485f, -0.11796604f, 0.06564457f, -0.01282649f, 0.12582186f, 0.07015356f, 
    -0.00067997f, -0.03196231f, 0.15965150f, 0.10736109f, -0.00272552f, -0.00003894f, 0.32055944f, 0.06908907f, 
    0.00289595f, -0.10362396f, -0.18258773f, 0.09211218f, -0.00619858f, -0.16790067f, 0.03380242f, -0.01458661f, 
    0.18253238f, -0.13614747f, 0.10616683f, 0.08485466f, -0.04907529f, -0.00091394f, -0.02143415f, 0.12802331f, 
    0.01564257f, -0.02615356f, 0.05875892f, -0.05325985f, 0.40659145f, -0.19708125f, 0.02040802f, -0.19207557f, 
    0.15556663f, 0.12405304f, 0.02579067f, 0.00550002f, -0.15353149f, 0.16915505f, 0.14991817f, 0.03828518f, 
    0.38461602f, 0.04997001f, 0.09673824f, 0.05039345f, -0.07498420f, 0.12255915f, -0.00793646f, -0.02857642f, 
    0.04492501f, 0.09994006f, 0.07677157f, 0.04891557f, 0.13616748f, -0.01928506f, -0.16897516f, -0.12661579f, 
    -0.04926375f, 0.13974221f, 0.08320854f, 0.15883064f, 0.00980942f, 0.18769604f, 0.06407684f, 0.05893606f, 
    -0.14115697f, 0.03581954f, 0.04792752f, 0.23821874f, -0.02764412f, 0.26256439f, 0.05397916f, 0.02324588f, 
    -0.04837118f, 0.10472111f, 0.02058168f, 0.11039400f, -0.20731464f, 0.21159787f, 0.14338179f, -0.09438217f, 
    0.03596995f, -0.17231795f, 0.02454378f, 0.00955534f, 0.01484213f, 0.09267137f, 0.17090477f, -0.05951769f, 
    -0.22780062f, 0.09185062f, 0.00979658f, 0.00908115f, 0.09058754f, 0.08283442f, -0.15865073f, 0.10148869f, 
    -0.03806283f, 0.00261729f, 0.18507016f, -0.03367784f, 0.08894066f, 0.35413572f, -0.27395865f, -0.08383720f, 
    0.00143286f, 0.01972845f, 0.05993760f, 0.00812189f, -0.05803230f, -0.06830659f, 0.06471509f, 0.07739943f, 
    0.09454930f, -0.02886724f, 0.09875178f, -0.12094833f, 0.18647118f, -0.11851589f, 0.05484483f, 0.09409191f, 
    -0.02030240f, 0.05428490f, 0.10847358f, 0.07097333f, -0.19333003f, 0.01933066f, 0.16530181f, 0.00092005f, 
    0.03701150f, 0.15115105f, 0.00829778f, 0.07471303f, -0.14132804f, 0.10778486f, 0.23829933f, 0.08284635f, 
    -0.11284641f, -0.05703989f, 0.20789838f, 0.04932664f, -0.08428574f, 0.00171635f, -0.11460099f, 0.08467161f, 
    -0.01722737f, 0.00086952f, -0.03960880f, 0.02820837f, 0.07073731f, 0.23819952f, -0.03908483f, -0.26547506f, 
    0.26365390f, -0.24649119f, 0.00550177f, -0.09064558f, 0.05811937f, 0.01123618f, 0.05744758f, -0.04224664f, 
    -0.56823826f, -0.13116316f, 0.42560685f, 0.09376159f, 0.03929070f, -0.09329575f, -0.11036376f, -0.08902265f, 
    -0.03266335f, 0.02670395f, 0.05899558f, 0.01078949f, 0.03218592f, 0.11695924f, -0.22106703f, 0.04347486f, 
    0.10096238f, 0.06917072f, 0.09206410f, -0.05583869f, -0.05657459f, 0.20862707f, -0.03984337f, -0.18327865f, 
    0.15315256f, -0.16222580f, -0.26866752f, 0.08217284f, 0.04144194f, -0.02186255f, 0.04410290f, 0.04379830f, 
    -0.18756740f, 0.00269566f, 0.00341344f, -0.04890542f, -0.09542303f, 0.14600731f, 0.07096380f, -0.07115354f, 
    -0.08754379f, 0.02111993f, -0.02518697f, 0.05646123f, -0.03285985f, 0.11617954f, 0.12910846f, 0.12778816f, 
    0.12708785f, 0.00640678f, -0.31312609f, -0.02657643f, 0.03154510f, -0.02170736f, 0.22114223f, -0.01326113f, 
    0.03893535f, 0.08959362f, 0.11366966f, 0.09661742f, 0.20352012f, 0.16116172f, 0.14048804f, 0.24669304f, 
    0.21949613f, 0.24289367f, -0.01997640f, -0.12545514f, -0.01761243f, -0.09125905f, 0.10968297f, -0.08229227f, 
    0.07562068f, 0.25655958f, -0.09515491f, -0.09610181f, 0.19687936f, -0.11751933f, 0.00888246f, -0.02939490f, 
    0.05263718f, 0.20267095f, 0.04787248f, 0.12669282f, 0.27964893f, 0.05681257f, 0.10324665f, 0.01745486f, 
    -0.04640545f, 0.06478406f, -0.01947903f, 0.01505846f, 0.04850601f, 0.11042244f, 0.03081922f, -0.07453744f, 
    0.18318054f, -0.22841555f, -0.12758361f, 0.19716147f, 0.01762858f, 0.10313074f, 0.11265488f, 0.07984377f, 
    0.01273907f, -0.06229320f, 0.01619997f, 0.04595253f, 0.08538020f, -0.06141002f, -0.14378840f, -0.13131452f, 
    0.13625661f, 0.00996244f, 0.10376919f, 0.04211525f, -0.14958523f, 0.06505795f, -0.05706062f, 0.03532981f, 
    -0.14974687f, 0.08796505f, 0.16907676f, -0.01674632f, -0.00099757f, -0.13499680f, 0.16430442f, 0.07280082f, 
    0.10089170f, -0.03460481f, 0.05368748f, 0.04807906f, 0.14901119f, 0.17010199f, 0.31271261f, -0.15020418f, 
    0.09305633f, -0.03016105f, -0.13201572f, -0.02954358f, -0.13507435f, -0.02544724f, 0.08264198f, 0.06483696f, 
    -0.07396552f, -0.08639958f, -0.05324358f, 0.17250045f, 0.03813423f, 0.19541608f, 0.11346848f, 0.13037738f, 
    0.03482226f, -0.00371378f, -0.03942030f, -0.05205059f, -0.31102341f, -0.13134392f, 0.26403558f, 0.07857872f, 
    -0.02073639f, 0.12498386f, -0.13186260f, 0.06304901f, -0.19995913f, -0.04341803f, -0.13343932f, -0.08123557f, 
    0.31600803f, 0.03609398f, 0.15061153f, -0.22413780f, 0.13690263f, -0.02742230f, -0.06205376f, -0.05358386f, 
    -0.02544339f, 0.05742359f, 0.05729847f, -0.00773362f, -0.10929542f, -0.05251766f, -0.06801409f, 0.08197188f, 
    0.00151510f, 0.14268555f, 0.18278922f, 0.07948814f, -0.06952388f, -0.02093460f, -0.01971620f, -0.03871462f, 
    -0.41635153f, 0.14635094f, 0.39037091f, 0.06956723f, 0.06449667f, 0.17597839f, -0.11063459f, -0.06988645f, 
    -0.14956455f, 0.08603729f, 0.11892172f, -0.08093082f, -0.03383652f, -0.18925871f, 0.18717450f, 0.22272117f, 
    -0.00780926f, -0.02937897f, 0.04628218f, 0.01455959f, 0.09077892f, 0.03368793f, 0.13427818f, 0.13150454f, 
    0.16923268f, 0.09062301f, -0.23162512f, 0.12772493f, -0.00359715f, 0.03249682f, 0.03646024f, -0.09559588f, 
    0.00998228f, 0.00692233f, -0.03336360f, -0.08925301f, 0.14585233f, 0.03548036f, 0.02955163f, 0.19969155f, 
    -0.08382484f, 0.07892627f, 0.08375707f, 0.16075560f, -0.02206011f, 0.05161254f, 0.00253789f, 0.01460095f, 
    0.63441414f, -0.01964173f, 0.27148119f, 0.23913836f, -0.00999245f, 0.05411291f, 0.04482102f, -0.01616270f, 
    -0.00495980f, 0.05244428f, -0.06127747f, 0.00775849f, 0.20786151f, 0.46885577f, -0.44797650f, 0.03307846f, 
    0.08595444f, -0.00483450f, 0.07953203f, -0.24989781f, 0.03052270f, -0.14461453f, 0.03347755f, 0.04964226f, 
    -0.10635734f, -0.25958186f, 0.22327025f, 0.33496490f, 0.04651306f, 0.08287871f, -0.14725342f, -0.06063663f, 
    -0.08418066f, 0.15066433f, -0.02345331f, 0.00206602f, -0.41471916f, 0.11904214f, 0.27376691f, 0.03813277f, 
    0.03397039f, -0.01638851f, -0.02575428f, -0.05548517f, -0.09437662f, 0.11615434f, 0.10225724f, 0.00383677f, 
    0.32231471f, 0.00030162f, 0.17333977f, -0.00441554f, -0.03030399f, 0.02794473f, -0.06628700f, 0.03934525f, 
    0.02329497f, -0.00168726f, 0.11986502f, -0.03371562f, -0.47378579f, 0.27317941f, 0.22010703f, -0.09297977f, 
    0.11786827f, -0.05841938f, 0.07004338f, -0.04384469f, -0.00857860f, -0.01145044f, 0.10561449f, 0.14683913f, 
    0.00247725f, 0.11898815f, -0.17181249f, -0.30917254f, 0.09770592f, 0.03472764f, 0.18622047f, -0.10981581f, 
    -0.04676881f, -0.08047502f, 0.04790118f, -0.06902898f, 0.74122798f, -0.19480816f, 0.02955734f, -0.13946295f, 
    0.01558386f, -0.00098301f, 0.01047536f, 0.03983568f, -0.21664876f, 0.01690741f, -0.06715050f, 0.07549310f, 
    0.33296266f, 0.20503376f, -0.04224560f, -0.03052321f, 0.11486524f, -0.05431078f, 0.06095097f, -0.03390857f, 
    0.08021636f, -0.06240844f, -0.11019480f, 0.08723318f, -0.27539757f, 0.25165126f, 0.13185948f, 0.22883636f, 
    -0.09176887f, 0.07870075f, 0.11452223f, -0.00329242f, 0.00463747f, 0.03984861f, 0.00616073f, 0.14715004f, 
    0.12658207f, 0.25130519f, 0.37453189f, 0.09205030f, -0.00693932f, -0.14577560f, 0.07317235f, 0.11460907f, 
    0.08165658f, 0.05446286f, 0.07281115f, 0.03116947f, -0.09216179f, -0.05251345f, 0.07716531f, 0.10333968f, 
    -0.00310836f, 0.02402487f, -0.04388259f, 0.05238844f, -0.04038996f, -0.10506427f, -0.11517965f, -0.03325192f, 
    0.29665479f, 0.25039116f, 0.30567539f, 0.03681611f, -0.07059748f, -0.02740224f, 0.00796479f, -0.02820738f, 
    0.02257830f, 0.02459594f, -0.11449388f, -0.00647316f, -0.18504517f, 0.10332588f, -0.13814932f, 0.18553747f, 
    0.01969490f, 0.01893293f, -0.08986503f, 0.16936766f, 0.16703394f, 0.10288204f, 0.18493678f, 0.05864839f, 
    -0.36271799f, -0.09852538f, -0.06805027f, 0.08501766f, -0.18641964f, -0.11611658f, -0.02135627f, 0.01046447f, 
    0.02786849f, -0.09000625f, -0.05711087f, 0.02392988f, 0.04156320f, -0.15150455f, -0.11661681f, -0.19793865f, 
    0.04797459f, -0.09862164f, 0.08720203f, -0.14366323f, -0.05016856f, -0.03955802f, 0.08232778f, 0.00678770f, 
    -0.25090614f, -0.13992742f, -0.14278875f, -0.03910893f, 0.16564307f, 0.06983748f, 0.06798510f, 0.09448622f, 
    -0.04729228f, -0.14923155f, -0.07745725f, -0.15340300f, -0.11963976f, -0.31428915f, 0.09325086f, -0.11947382f, 
    -0.05565677f, 0.00735024f, 0.01574891f, 0.07845496f, -0.05395722f, 0.02769825f, 0.06942419f, 0.02826875f, 
    0.00543547f, -0.11607614f, -0.09791770f, 0.14826320f, -0.00463413f, 0.03511172f, 0.00566297f, -0.09935341f, 
    0.13042188f, 0.15473938f, 0.07328429f, 0.06290323f, 0.13232836f, 0.15158561f, 0.06801146f, -0.09334084f, 
    0.00030440f, -0.09814767f, -0.08699226f, 0.09705898f, 0.06406634f, 0.05610480f, 0.05896408f, 0.06811576f, 
    -0.24759743f, -0.16761646f, -0.32962286f, 0.01453691f, 0.15788791f, 0.14124890f, 0.16517544f, 0.03408764f, 
    -0.00810893f, 0.04444334f, -0.09482883f, -0.03242816f, -0.16234592f, -0.14240372f, -0.08798744f, 0.08962439f, 
    0.01000177f, 0.02456422f, -0.01553125f, 0.00448451f, 0.03782748f, 0.05165351f, 0.02744389f, 0.05051396f, 
    -0.00813488f, -0.04195525f, -0.11375786f, -0.09660300f, 0.00013066f, 0.00550120f, 0.06179300f, -0.00549543f, 
    0.01445188f, -0.19675155f, -0.06800686f, -0.12707843f, -0.00387458f, -0.10723586f, 0.18077727f, -0.04756014f, 
    0.03435322f, 0.04977039f, 0.02376148f, 0.16672015f, 0.04775902f, -0.06233684f, -0.01271242f, 0.05337735f, 
    0.15066032f, -0.16381149f, -0.10888044f, -0.27336559f, -0.09035517f, -0.05297548f, -0.08257125f, 0.00533407f, 
    0.03871177f, -0.02979123f, 0.04150072f, 0.15759242f, 0.00006042f, -0.44949639f, 0.06137136f, 0.38570368f, 
    0.01542162f, -0.16063559f, -0.00697357f, -0.02598069f, 0.07597561f, -0.02998580f, 0.00977299f, 0.30462024f, 
    -0.09122840f, 0.22166897f, -0.02489037f, 0.10107777f, 0.03698720f, -0.03686823f, -0.06802060f, 0.03980871f, 
    0.14347020f, 0.12014683f, 0.09079378f, 0.09032532f, -0.08030339f, -0.02682863f, -0.16906098f, 0.10265224f, 
    -0.04161786f, 0.01262028f, 0.05095332f, -0.02260447f, 0.00595478f, -0.07723637f, 0.13287246f, -0.01306785f, 
    0.31552571f, 0.11158909f, -0.07832659f, -0.16189367f, 0.11998661f, -0.06033997f, -0.03388379f, 0.07661170f, 
    0.03405983f, 0.17743403f, 0.14755026f, 0.08042881f, -0.14902903f, -0.01619351f, 0.17761265f, -0.09563226f, 
    0.06107716f, -0.04342383f, -0.01242270f, 0.08198512f, 0.15571217f, 0.05898672f, -0.09325740f, 0.07018134f, 
    -0.29517236f, -0.03202755f, 0.35440579f, 0.13104884f, -0.02960557f, 0.07541166f, -0.05761830f, 0.07834925f, 
    0.19402763f, 0.14581406f, -0.05996329f, 0.11206228f, -0.14374596f, 0.25494009f, -0.31602460f, -0.16039167f, 
    0.06336249f, 0.01373616f, -0.04026477f, -0.02011404f, 0.03217511f, 0.18581979f, -0.09655531f, -0.03793374f, 
    -0.08220278f, 0.12575991f, 0.10363850f, 0.11198583f, 0.04670557f, 0.04793366f, -0.05394188f, -0.18673819f, 
    0.07309772f, 0.11918738f, -0.00711239f, -0.03388900f, -0.16997634f, -0.27511528f, -0.02355975f, 0.28312501f, 
    -0.04948935f, 0.05758896f, 0.11992381f, 0.31385830f, 0.17454253f, 0.09424707f, 0.02710669f, 0.14567491f, 
    0.05371357f, -0.01529141f, 0.04466077f, 0.02497976f, 0.07865772f, -0.00392902f, 0.17695424f, 0.08687433f, 
    -0.03484483f, 0.04280782f, 0.07164178f, 0.08582201f, -0.15438688f, -0.05330610f, 0.11224211f, 0.03162580f, 
    -0.02216030f, 0.04698625f, 0.11616035f, -0.03159658f, 0.02389247f, 0.02339195f, 0.01238854f, 0.07167900f, 
    0.00926215f, 0.04326406f, -0.04620279f, -0.05004593f, 0.01216730f, -0.01955056f, -0.09445699f, -0.00000559f, 
    -0.05090508f, 0.04698249f, 0.07331238f, 0.08156123f, -0.00134573f, -0.15635042f, -0.15047233f, 0.27589798f, 
    0.08974191f, 0.18863693f, 0.03338063f, -0.01704906f, 0.14962387f, -0.01588318f, -0.08217213f, 0.04864952f, 
    0.11133831f, 0.23887350f, 0.05319352f, -0.08949433f, -0.14714810f, -0.00503720f, 0.18033311f, 0.06089800f, 
    0.20004861f, -0.09422718f, -0.11143120f, 0.03292497f, 0.03635794f, -0.55036885f, 0.48622033f, 0.25284663f, 
    0.03040548f, 0.03579173f, -0.16648982f, 0.06791858f, 0.16553062f, 0.02092925f, 0.11807913f, -0.08426070f, 
    -0.03841694f, -0.26719549f, -0.05091095f, -0.10261595f, -0.02415308f, 0.06708204f, -0.03786806f, 0.01914110f, 
    0.08242704f, 0.01826441f, 0.12913430f, 0.17282531f, 0.03200270f, -0.01886844f, -0.13472249f, -0.10531120f, 
    0.03603170f, -0.05791125f, 0.07231261f, -0.06646566f, 0.09899875f, -0.12190030f, 0.09493361f, 0.11419572f, 
    -0.24763486f, -0.30799487f, -0.13442859f, -0.14753677f, 0.08746957f, -0.00225322f, 0.08456457f, -0.01943620f, 
    -0.07477047f, -0.08778809f, -0.06594504f, 0.00771173f, -0.29707700f, 0.07052075f, -0.36098298f, 0.13110277f, 
    -0.00626290f, 0.13039267f, -0.15140238f, 0.00104410f, 0.00062461f, 0.08624925f, 0.12898794f, 0.05767927f, 
    -0.03904624f, -0.08557904f, -0.25156295f, -0.12737040f, 0.11031941f, 0.22919101f, 0.06657381f, 0.16881166f, 
    0.09282714f, 0.02014921f, -0.02935372f, -0.02004295f, -0.11311042f, 0.06945769f, 0.42463973f, 0.21531141f, 
    -0.17942221f, 0.00437620f, -0.13921976f, 0.11704376f, -0.06465122f, -0.12298447f, -0.07716002f, 0.12009149f, 
    0.19237645f, 0.10855254f, 0.15765600f, 0.03531244f, 0.00850306f, 0.13430627f, -0.05463274f, 0.03247881f, 
    0.04132313f, -0.02636941f, -0.06065227f, -0.00976341f, -0.12049046f, -0.08437027f, -0.12450083f, 0.04800332f, 
    0.09840264f, -0.02888067f, 0.07774235f, 0.01990355f, 0.07856113f, 0.04956839f, 0.06288899f, 0.10832371f, 
    -0.01413339f, 0.24104847f, 0.11556559f, 0.03858826f, -0.02003051f, 0.13623209f, -0.21797398f, 0.08113801f, 
    -0.11313939f, -0.23526326f, 0.00403121f, -0.06940155f, 0.18837500f, 0.36957443f, 0.46098861f, 0.12341075f, 
    -0.03103718f, -0.11882456f, 0.08096143f, -0.12567498f, 0.10196153f, 0.02277440f, -0.12572597f, -0.07765066f, 
    -0.00558627f, -0.06996596f, -0.26508403f, 0.14454706f, -0.13278647f, 0.01572994f, 0.06025661f, 0.06740242f, 
    0.02057188f, -0.00659718f, 0.12391111f, 0.11984325f, -0.12058682f, 0.04544431f, 0.15684116f, 0.16275427f, 
    -0.05323722f, -0.00557105f, 0.14533493f, 0.28016168f, -0.02134943f, -0.02681477f, 0.00574803f, 0.14833730f, 
    -0.06315065f, 0.20435667f, 0.17040659f, 0.03832376f, 0.01145671f, 0.04581300f, 0.01230413f, 0.00120121f, 
    0.15238851f, 0.00632036f, 0.06839862f, 0.03430675f, -0.52107733f, 0.18310376f, -0.02866501f, 0.28940374f, 
    -0.20273431f, -0.07494746f, 0.03876259f, 0.12009338f, 0.26595461f, -0.12193204f, 0.01212464f, 0.13965638f, 
    -0.03450983f, -0.23495910f, 0.00413990f, -0.23332897f, 0.10201000f, 0.03550244f, -0.16110475f, 0.02317831f, 
    0.01304124f, 0.06267040f, 0.21350327f, 0.08885147f, 0.09562914f, 0.00741949f, 0.16315673f, 0.11274755f, 
    0.04882399f, 0.02525817f, 0.09415501f, -0.06586366f, 0.15755054f, -0.06085564f, 0.01599033f, -0.03189259f, 
    0.05489551f, 0.17498897f, 0.26094532f, -0.05879015f, -0.04317592f, -0.04332538f, -0.06143275f, 0.10731966f, 
    0.06386515f, -0.01857599f, 0.16789554f, -0.03475736f, 0.08051272f, 0.00683956f, -0.01904860f, -0.17389336f, 
    0.01841148f, -0.16995651f, -0.09909885f, -0.09930198f, -0.12829092f, 0.10260628f, -0.00442861f, 0.13982092f, 
    -0.39452520f, 0.03396437f, -0.19150187f, 0.13888432f, -0.00979196f, -0.03937191f, 0.10422754f, 0.09598517f, 
    -0.03087153f, 0.04808596f, -0.14382233f, 0.02167159f, 0.00775514f, 0.65930784f, 0.22978936f, 0.33304608f, 
    0.04528396f, -0.06029216f, 0.16120529f, -0.02990870f, -0.04187158f, -0.04647212f, -0.00533743f, 0.04845598f, 
    0.25052795f, -0.19140242f, 0.05530707f, -0.16478096f, -0.05039159f, -0.14707634f, 0.07119930f, 0.10352246f, 
    0.09730343f, -0.06837514f, 0.00492213f, 0.08744216f, 0.25501847f, -0.09833601f, -0.18112095f, -0.09206622f, 
    0.06267604f, 0.02598904f, 0.03371824f, -0.01772817f, -0.07059307f, -0.12963311f, 0.15277095f, -0.19304277f, 
    -0.19379379f, -0.18220337f, 0.06704510f, 0.02369224f, -0.00449747f, 0.09560262f, 0.06216553f, -0.05664457f, 
    0.07836411f, 0.04933327f, 0.07940180f, 0.06120738f, -0.01061303f, 0.39937201f, 0.13942674f, 0.26141253f, 
    0.00832767f, -0.04381952f, 0.11047941f, -0.09178422f, 0.05006174f, 0.09808228f, 0.04705373f, -0.10901926f, 
    -0.16214460f, 0.26675341f, 0.13132602f, 0.02895561f, 0.03820703f, -0.01347425f, 0.03144459f, 0.13712569f, 
    0.07240847f, 0.03376730f, 0.03050865f, 0.07959142f, -0.21897803f, -0.34587529f, 0.30675715f, 0.10968988f, 
    0.08026580f, 0.01511858f, 0.01219365f, 0.12417725f, 0.06674742f, 0.16798274f, 0.05354794f, 0.01247018f, 
    0.08733471f, 0.13853657f, -0.25251549f, -0.37642443f, 0.04072363f, -0.03317663f, 0.03266967f, 0.01190519f, 
    -0.03601097f, -0.11190619f, -0.12478785f, -0.00379560f, 0.19814251f, -0.14939773f, -0.16392505f, -0.07034463f, 
    -0.01436581f, -0.10150400f, 0.09325735f, 0.19015516f, 0.07563942f, 0.01628531f, 0.02126469f, 0.05336082f, 
    -0.06559426f, 0.25680384f, 0.09868784f, 0.11984897f, -0.10038888f, 0.07434984f, 0.05743970f, -0.23419026f, 
    0.02338660f, 0.02800244f, 0.06973480f, -0.01990276f, -0.02063094f, -0.12602668f, -0.24339138f, 0.17295846f, 
    0.01546229f, -0.01522767f, 0.06004067f, 0.03850034f, -0.09742199f, 0.19065209f, -0.01408716f, 0.13653739f, 
    -0.26652557f, 0.06555913f, -0.18775596f, 0.39603692f, -0.01707878f, 0.01535774f, 0.03454730f, 0.13807267f, 
    0.10248707f, 0.14559023f, 0.11433519f, 0.27298591f, -0.20446467f, 0.14197029f, 0.21598582f, -0.00837158f, 
    0.07307149f, -0.01939792f, 0.10235897f, 0.09522895f, 0.04438648f, 0.03086065f, -0.07431308f, 0.00185904f, 
    0.02546273f, 0.02983930f, -0.01885736f, -0.01638089f, -0.03597496f, 0.00527167f, 0.02754808f, 0.02185685f, 
    -0.01421774f, -0.02364880f, 0.01395297f, 0.01608463f, -0.02787182f, -0.00043519f, -0.03765236f, 0.00405694f, 
    -0.00082282f, 0.02586544f, 0.01994438f, -0.01152619f, 0.00072618f, -0.01766508f, 0.01696537f, 0.01425415f, 
    0.02808448f, -0.03121987f, 0.02188824f, -0.03109231f, -0.01421811f, 0.00888534f, -0.00583802f, -0.00694764f, 
    -0.02190998f, -0.03798390f, -0.01524265f, -0.02414995f, -0.00317563f, 0.02821182f, 0.02628061f, 0.02543061f, 
    -0.00942149f, -0.00937156f, 0.01398138f, -0.03156180f, -0.01559072f, 0.02743524f, -0.03416495f, -0.01224423f, 
    -0.01342613f, -0.02526676f, -0.02477806f, 0.02907203f, 0.00304608f, -0.02016678f, 0.02686314f, -0.01657767f, 
    -0.02124606f, -0.02254249f, 0.02740777f, 0.01189178f, -0.01879927f, 0.02811621f, 0.00301207f, 0.04267735f, 
    0.02716149f, 0.01799494f, 0.01013379f, -0.03957289f, 0.01666098f, -0.02135033f, -0.01774917f, -0.04305281f, 
    0.01522269f, 0.00530486f, 0.00760368f, 0.00318683f, -0.01703814f, -0.04087924f, -0.00353669f, 0.01908978f, 
    -0.03821141f, 0.00279110f, -0.02153514f, -0.03226297f, -0.00641017f, -0.03010487f, -0.00331925f, -0.02086953f, 
    -0.02210802f, -0.00197148f, 0.00451722f, -0.00150184f, -0.00244971f, 0.01111930f, 0.03071691f, -0.02191822f, 
    -0.03535691f, 0.00459739f, 0.01344415f, -0.01640414f, -0.02692567f, -0.03362484f, 0.02235540f, 0.00974051f, 
    -0.03985001f, -0.02809097f, -0.03626221f, 0.02330179f, 0.01436954f, -0.01310651f, 0.00875011f, -0.01629833f, 
    0.00168830f, 0.01012779f, 0.02042429f, -0.01778449f, -0.01062449f, -0.00629568f, 0.02730682f, -0.01699900f, 
    0.00837522f, 0.01739335f, 0.03211148f, -0.00008674f, 0.01811182f, -0.02901161f, 0.02601635f, -0.00158440f, 
    -0.03258287f, 0.02210720f, 0.00828399f, -0.01085022f, 0.02010633f, -0.00108923f, -0.03518791f, 0.00738689f, 
    0.00121779f, 0.01048202f, -0.01926143f, -0.01790232f, -0.02431460f, -0.03587876f, 0.01327491f, 0.00135097f, 
    0.00115370f, 0.01717444f, 0.00971044f, -0.03562688f, 0.03140783f, -0.02011529f, -0.01782501f, 0.01441897f, 
    -0.03267245f, 0.00510049f, -0.00202857f, -0.01243134f, -0.01301658f, -0.01158372f, 0.03098029f, -0.03525303f, 
    -0.01319018f, -0.02437880f, 0.02247600f, -0.00400831f, -0.00728418f, -0.02046742f, -0.00710064f, -0.03096654f, 
    0.03412556f, -0.00631557f, -0.02292245f, 0.02562357f, -0.01742149f, -0.03926181f, 0.00256529f, -0.00974092f, 
    0.00293508f, -0.00600710f, -0.04270553f, -0.00599974f, -0.01081281f, -0.00007370f, -0.01460485f, 0.01011922f, 
    0.02521715f, 0.02471511f, -0.03430028f, -0.03317750f, -0.02134297f, -0.00084076f, 0.00451768f, -0.03140265f, 
    -0.01202998f, -0.02201872f, -0.01130354f, 0.02507007f, -0.01334536f, 0.01842807f, -0.00192479f, -0.03829535f, 
    0.01023858f, 0.01012697f, 0.03246456f, -0.03085919f, 0.00609112f, -0.00128520f, -0.01933550f, -0.00429544f, 
    -0.01582106f, -0.03111022f, -0.03932586f, 0.02997888f, -0.02585858f, -0.03834460f, -0.01178348f, 0.00553737f, 
    -0.02295453f, -0.01773870f, -0.01636066f, 0.02602696f, 0.01464719f, 0.03032220f, -0.03113759f, -0.03934618f, 
    -0.02893379f, 0.03034190f, 0.01887791f, -0.01717988f, -0.03344104f, -0.02622365f, -0.00458143f, 0.02533860f, 
    0.00506631f, 0.00434548f, -0.00319747f, -0.00562570f, -0.01302762f, 0.01641666f, -0.03610551f, -0.03747044f, 
    0.04088372f, -0.02724358f, -0.01971178f, -0.00366949f, 0.02907042f, -0.01307306f, -0.00397555f, 0.00787256f, 
    -0.00085921f, 0.01926627f, -0.01284988f, -0.00080008f, 0.01408891f, 0.00276242f, -0.01019197f, 0.02556931f, 
    0.02721182f, -0.02956004f, -0.02967698f, -0.03410358f, -0.00750199f, -0.02138320f, -0.02985966f, -0.01666168f, 
    -0.00041633f, -0.03243967f, -0.02879288f, -0.00237160f, 0.02504180f, -0.03985944f, -0.01543482f, 0.01514461f, 
    -0.02390810f, 0.01322769f, -0.02792227f, 0.00443284f, 0.02593086f, -0.00948073f, -0.00436246f, 0.02517396f, 
    -0.03379919f, -0.01632307f, 0.01648433f, -0.02300981f, -0.03786473f, -0.00248631f, -0.03986562f, 0.02078920f, 
    -0.00991385f, -0.04329969f, 0.01398441f, 0.02434909f, 0.02769921f, -0.03711295f, 0.00786909f, 0.02989227f, 
    -0.01201523f, 0.00542872f, -0.02331310f, 0.00770442f, -0.02646216f, -0.01588389f, -0.02096412f, 0.03278266f, 
    -0.03809908f, -0.02247500f, 0.01484269f, -0.00074119f, 0.00482991f, 0.00767674f, -0.03280059f, 0.02210147f, 
    -0.02971966f, -0.00836014f, -0.02423619f, 0.01177009f, -0.00802378f, -0.00569215f, -0.01193582f, -0.02984030f, 
    -0.02887121f, -0.01755586f, 0.01710026f, -0.00808977f, -0.03481853f, -0.02591565f, -0.00276035f, -0.03847822f, 
    0.01242924f, -0.00109317f, 0.01867274f, 0.02064036f, -0.03042922f, 0.00740425f, 0.01262540f, 0.03014577f, 
    -0.02717480f, -0.00392319f, 0.02790625f, -0.02424474f, 0.02045469f, 0.00349452f, 0.02908472f, 0.02405727f, 
    0.02051919f, -0.03112067f, 0.02588814f, -0.03700358f, -0.02085102f, 0.00877507f, 0.01376811f, -0.02788245f, 
    -0.01391849f, 0.02375738f, -0.02629429f, -0.02153409f, -0.02011269f, -0.01988090f, 0.02497383f, 0.00162561f, 
    -0.03283790f, -0.04071574f, 0.00684033f, 0.01333474f, -0.01422650f, 0.01001699f, -0.00757086f, -0.01633567f, 
    0.00438315f, -0.00839911f, -0.00640001f, 0.00355759f, -0.01266872f, -0.00581824f, 0.02017966f, 0.00989113f, 
    0.01422982f, -0.02612097f, -0.00609405f, -0.02942203f, 0.02255034f, 0.03065223f, -0.04199028f, 0.03177177f, 
    0.01957697f, 0.02372024f, -0.02227650f, -0.01258764f, -0.02684464f, -0.01590513f, 0.00371600f, -0.02082139f, 
    -0.02957385f, 0.00196246f, 0.01010188f, -0.01567438f, -0.03356010f, 0.00168324f, -0.02691061f, 0.01503435f, 
    0.00589179f, -0.01238075f, 0.01999223f, -0.04258043f, -0.01147251f, -0.02169188f, 0.01240356f, 0.00132797f, 
    -0.00259208f, -0.02179589f, -0.02659355f, 0.01011075f, -0.02365109f, -0.00074510f, -0.04260239f, -0.02891458f, 
    0.00227990f, -0.02959730f, 0.01003881f, -0.03749453f, -0.03997505f, -0.01932528f, 0.02683797f, -0.00412450f, 
    -0.01343028f, -0.01714449f, -0.00118077f, 0.00499724f, -0.01001138f, -0.00182616f, -0.03332802f, -0.01209930f, 
    0.01172529f, -0.02811810f, -0.01147027f, -0.01076373f, -0.01120095f, 0.00581691f, -0.00004869f, -0.02605543f, 
    -0.00708091f, -0.01308507f, -0.02183905f, 0.01842381f, 0.01708100f, 0.02270414f, 0.01649925f, -0.01287398f, 
    -0.01841923f, 0.01453365f, 0.00277729f, -0.00566692f, 0.01514535f, 0.02732761f, -0.04048694f, 0.00811866f, 
    -0.03029049f, 0.00759650f, -0.00608845f, -0.03907765f, 0.00369426f, 0.02673333f, -0.00243731f, 0.00065778f, 
    0.02491767f, 0.01738652f, -0.00805674f, -0.02871775f, 0.01115410f, 0.02457375f, -0.00773358f, -0.02691895f, 
    -0.01577001f, 0.02238142f, -0.02054462f, -0.01949153f, 0.00775217f, -0.02602069f, -0.02780459f, -0.00966372f, 
    -0.00612203f, 0.01750424f, 0.02359040f, 0.01110977f, -0.01918931f, 0.01670158f, 0.01445735f, -0.01156563f, 
    -0.03834153f, 0.02309301f, 0.01541746f, -0.03933367f, -0.01410847f, 0.01168137f, 0.03497554f, -0.02429063f, 
    -0.00648568f, -0.02680599f, -0.03868792f, 0.01398512f, 0.03045362f, 0.00289151f, -0.00686505f, 0.00286339f, 
    -0.00667480f, 0.03057206f, 0.00735689f, -0.04094965f, -0.03663226f, -0.03336957f, -0.02804210f, 0.02725198f, 
    0.02393016f, -0.02809185f, -0.02541947f, -0.00523354f, -0.00580805f, -0.00298877f, -0.01847845f, -0.00099288f, 
    0.02070957f, 0.01658085f, 0.00921398f, 0.01476483f, -0.00253313f, -0.02573868f, -0.01030185f, 0.00394328f, 
    0.00202450f, -0.02221752f, 0.00280427f, -0.00530668f, -0.01341014f, -0.03267813f, 0.02014315f, -0.04251633f, 
    0.00158105f, -0.01924204f, -0.02821094f, -0.03426676f, 0.00646984f, 0.02732750f, 0.01550851f, 0.02354251f, 
    0.00413225f, 0.03160192f, -0.03011476f, 0.03863854f, 0.01597555f, 0.01735168f, -0.00302785f, -0.00770857f, 
    0.00078461f, -0.03839651f, 0.00500285f, 0.01550635f, -0.02557228f, 0.01456709f, -0.02052447f, -0.00988817f, 
    -0.02224262f, -0.02284870f, 0.02124691f, 0.01210104f, 0.01465703f, 0.03427757f, -0.00744953f, 0.00725079f, 
    -0.01242045f, 0.01747275f, -0.03302921f, -0.02953810f, 0.00565340f, 0.01502058f, -0.02936356f, -0.03950115f, 
    0.01714921f, -0.03040330f, -0.04003106f, 0.00398027f, 0.01056230f, -0.00738525f, 0.00488466f, -0.03047463f, 
    0.02218488f, -0.00663244f, -0.02864636f, -0.02963269f, -0.00185043f, 0.02545234f, 0.00124757f, -0.01425558f, 
    -0.04143340f, 0.02441389f, 0.01424910f, 0.00380196f, -0.00740269f, 0.02975833f, -0.00488665f, -0.04190413f, 
    -0.00911230f, -0.01750128f, 0.02505508f, -0.02023196f, 0.02871473f, -0.03747472f, -0.00971697f, 0.01428297f, 
    -0.00371619f, -0.04170191f, -0.00350125f, 0.02335473f, -0.00258668f, -0.00759471f, 0.00270179f, 0.01050861f, 
    0.00674235f, -0.03708788f, -0.02909802f, 0.00409333f, 0.01821932f, -0.01202539f, -0.00020104f, 0.00134781f, 
    -0.03702270f, 0.00293867f, -0.01764322f, 0.02323643f, -0.00788473f, 0.01488326f, -0.00653348f, 0.01292914f, 
    -0.00568603f, 0.02689969f, 0.01136607f, 0.01902237f, 0.01170593f, -0.03171284f, -0.01630084f, 0.01836457f, 
    0.02121172f, -0.01336170f, 0.00361010f, 0.01930687f, -0.00276679f, -0.00903336f, -0.03876550f, -0.04412552f, 
    -0.03102895f, -0.02099896f, -0.02070159f, -0.02626498f, -0.02481037f, 0.02742851f, 0.02511263f, 0.01090927f, 
    0.01120572f, -0.02536784f, 0.02180525f, -0.02596846f, -0.04242187f, -0.03953172f, 0.02816863f, 0.00316781f, 
    0.00942592f, -0.00780224f, 0.01869278f, 0.02578910f, -0.01617894f, 0.01868732f, -0.00013138f, -0.04090387f, 
    0.01100469f, -0.01631611f, 0.03056068f, -0.03423003f, -0.01030431f, -0.00630184f, -0.02280570f, -0.03852381f, 
    0.02178512f, 0.01449257f, 0.00769690f, 0.01648372f, -0.02886182f, -0.02319708f, 0.00810074f, -0.02710965f, 
    0.01380477f, 0.00160656f, -0.01328710f, 0.00651642f, -0.00474705f, 0.01749456f, -0.02378363f, 0.01276177f, 
    -0.02101619f, 0.02388964f, -0.02607614f, -0.00250185f, 0.01504431f, 0.00294984f, 0.02104864f, 0.01547877f, 
    0.02009261f, -0.01687009f, -0.03372068f, -0.00181797f, -0.03290380f, -0.01107379f, 0.00095204f, 0.00654017f, 
    0.02399876f, 0.02717776f, -0.02037379f, -0.01476508f, -0.00426317f, -0.01646772f, -0.03284044f, 0.01412702f, 
    0.03116479f, 0.01905470f, -0.00084762f, -0.01583675f, 0.03450016f, -0.00778434f, -0.01929009f, -0.01015076f, 
    0.02360330f, -0.01044131f, 0.01671571f, 0.02541040f, -0.03704796f, 0.01232765f, -0.00526178f, -0.03567806f, 
    0.01769651f, -0.01666657f, -0.03685681f, -0.03354271f, 0.02730927f, -0.02965025f, -0.01703645f, -0.03163620f, 
    0.02317169f, 0.01388469f, -0.00618986f, -0.01574443f, -0.02466717f, 0.00590902f, 0.02440821f, -0.02510907f, 
    -0.03803162f, 0.00312248f, 0.00811245f, 0.01741116f, -0.03666113f, -0.01699852f, 0.00757422f, -0.03540038f, 
    -0.01210513f, 0.03011853f, -0.02631938f, 0.02063096f, 0.01918964f, 0.01505622f, 0.03534922f, -0.00057856f, 
    -0.02069085f, 0.01404647f, -0.02882799f, -0.02668844f, -0.00029758f, 0.01776457f, 0.02101305f, -0.00388789f, 
    0.02395052f, 0.00839727f, 0.02094613f, -0.03396075f, -0.02071951f, 0.00934729f, 0.01768396f, -0.02694822f, 
    0.01776953f, 0.01947251f, -0.02920562f, -0.01198336f, -0.00467865f, -0.01538589f, 0.02318726f, -0.03557531f, 
    -0.02737078f, -0.01091977f, 0.02935005f, -0.01581069f, 0.01813054f, -0.00956743f, -0.03465259f, 0.01093767f, 
    -0.03134082f, -0.01063656f, 0.01454027f, -0.01242291f, -0.02982170f, -0.00006513f, -0.01279905f, -0.02372949f, 
    0.00903434f, 0.00899623f, 0.00846848f, 0.02174366f, -0.00125355f, -0.00852826f, -0.03439634f, 0.03417328f, 
    0.00577047f, 0.00912674f, -0.03289248f, 0.00116603f, -0.03560161f, 0.00516871f, 0.01775319f, 0.00050049f, 
    0.02482125f, 0.00752716f, 0.01582400f, -0.03537230f, -0.02945418f, -0.02265616f, 0.01332619f, -0.03596340f, 
    0.00574270f, -0.00499879f, -0.04397089f, -0.01386320f, 0.02520353f, 0.02717254f, -0.03490495f, -0.00163464f, 
    -0.02593728f, -0.03519804f, -0.02894055f, -0.00399790f, -0.02427051f, 0.02046901f, 0.00003836f, -0.00666899f, 
    -0.01063703f, 0.00805791f, -0.00201394f, -0.01749831f, 0.00176359f, -0.03866754f, 0.01142937f, 0.01885507f, 
    -0.03790119f, -0.02757815f, -0.02233171f, 0.00444684f, -0.02486747f, -0.03526359f, 0.01468699f, 0.00904442f, 
    -0.03297649f, 0.02774842f, -0.00477019f, -0.02160547f, -0.01013006f, -0.03112530f, 0.02015837f, -0.00909698f, 
    0.01376857f, -0.02833060f, 0.00178495f, -0.00829499f, -0.01255522f, 0.00531107f, 0.00117778f, 0.00261786f, 
    -0.04092856f, -0.01427946f, -0.02549285f, -0.01967988f, -0.01832189f, -0.01152302f, -0.00800819f, 0.01003024f, 
    0.00191129f, -0.04168075f, -0.00573652f, -0.03448057f, 0.02819373f, 0.02744384f, -0.03118633f, -0.02727310f, 
    -0.02982630f, -0.03820208f, -0.02581778f, 0.02071465f, -0.03714635f, -0.03031692f, -0.02235921f, -0.00848279f, 
    0.02166038f, 0.02763715f, -0.04175680f, -0.00112503f, 0.01141914f, 0.02306029f, 0.00982735f, -0.03965847f, 
    0.02931108f, -0.02481014f, -0.02470105f, 0.00393176f, -0.01631698f, 0.01215861f, -0.00197366f, -0.01646063f, 
    -0.00612647f, -0.00912314f, -0.00324678f, -0.03422664f, 0.01058875f, 0.01089376f, -0.01355781f, -0.02035065f, 
    -0.01071640f, -0.01193385f, -0.01558589f, -0.00472494f, -0.00379929f, -0.01028734f, 0.03417691f, -0.03374375f, 
    0.01243409f, -0.03706322f, -0.00412727f, -0.01550736f, -0.02844541f, 0.01588716f, -0.02353746f, -0.03462107f, 
    0.00027907f, -0.00432164f, 0.01887457f, -0.00848559f, -0.03505730f, -0.03717633f, -0.00159363f, -0.03627555f, 
    0.00413282f, -0.04401448f, 0.01110121f, -0.00590241f, -0.02327494f, -0.00655097f, -0.02975167f, -0.01075090f, 
    -0.03020665f, -0.02105794f, -0.03079430f, -0.01853318f, -0.01232319f, 0.00452884f, 0.03301770f, -0.01878627f, 
    0.00801287f, 0.03136690f, 0.01825527f, -0.01359346f, -0.03699097f, 0.00493611f, -0.02701943f, -0.00650205f, 
    -0.01004724f, -0.01538945f, 0.02611325f, -0.02562227f, -0.03406782f, 0.00466978f, -0.00263452f, -0.03295692f, 
    -0.02423946f, -0.03386820f, 0.00801038f, -0.01504509f, -0.01643947f, -0.01914701f, -0.02864224f, -0.01174215f, 
    0.00117300f, -0.00519290f, -0.03425023f, 0.01412997f, 0.01090769f, -0.02623452f, 0.03929279f, -0.03791638f, 
    -0.03307535f, 0.02546040f, -0.03647891f, 0.01416103f, 0.01927251f, 0.01330833f, 0.00859913f, -0.01143823f, 
    -0.00315575f, -0.03248401f, 0.02207825f, 0.00457204f, -0.03651093f, 0.01648710f, -0.00068355f, -0.01870355f, 
    -0.03347104f, -0.00191827f, -0.01407667f, -0.00440433f, 0.00249139f, -0.02074822f, -0.02133880f, -0.00073302f, 
    -0.01994221f, -0.01573097f, 0.00249427f, -0.02753262f, 0.02273322f, 0.00165546f, -0.01223542f, 0.01141250f, 
    0.02502519f, -0.03456515f, 0.02679148f, -0.04317509f, -0.02622151f, -0.03145969f, 0.01776338f, 0.00754966f, 
    0.01416720f, -0.03431370f, 0.02149956f, 0.01960673f, -0.02485173f, -0.01431897f, 0.00235339f, 0.02384945f, 
    0.00648349f, -0.00072527f, 0.02302930f, 0.00006748f, -0.00061137f, 0.02469208f, 0.02144645f, 0.02141942f, 
    0.02683831f, -0.01513119f, 0.00680393f, 0.01131319f, -0.00290460f, -0.03284729f, -0.03141419f, -0.00586720f, 
    0.00193119f, -0.03091477f, -0.04081377f, -0.01076035f, 0.02566536f, 0.01543128f, -0.02621098f, -0.02878443f, 
    -0.02068654f, 0.03328417f, 0.02932526f, 0.03736693f, -0.00381827f, 0.02841873f, 0.00154304f, -0.02132703f, 
    -0.03391761f, 0.02031571f, -0.02384533f, -0.01474998f, 0.03238161f, -0.03686517f, -0.00620765f, 0.02065867f, 
    -0.03384939f, -0.02151624f, 0.01536645f, -0.04327497f, 0.02051000f, -0.02195815f, 0.02193892f, 0.01865131f, 
    0.00150968f, 0.02139246f, -0.03141529f, 0.01306808f, 0.00821826f, 0.02397889f, -0.00559327f, -0.03363959f, 
    0.01479127f, 0.00480506f, -0.02778247f, 0.01547504f, -0.03385380f, -0.00914281f, 0.02209425f, 0.00431763f, 
    -0.03759259f, -0.02290927f, -0.00277754f, -0.03383407f, -0.03208031f, 0.02326312f, -0.01412119f, 0.02522005f, 
    -0.00517687f, 0.01706515f, -0.00554516f, -0.03065384f, 0.01040936f, -0.01671676f, 0.00193615f, 0.01901579f, 
    0.02307614f, 0.00175422f, -0.00567425f, -0.03492805f, 0.02064681f, -0.02244943f, -0.04191207f, -0.02077829f, 
    -0.00153438f, 0.02708080f, -0.01001932f, -0.02888911f, 0.01998238f, -0.01076616f, -0.04085168f, -0.01816178f, 
    -0.03806660f, -0.01883195f, 0.02432293f, 0.01953783f, -0.01456679f, -0.00063411f, -0.02811792f, 0.01349211f, 
    0.00595147f, 0.02374976f, -0.00069763f, -0.01721895f, 0.02010437f, -0.01825701f, 0.03063516f, 0.02273957f, 
    -0.01965661f, -0.01134035f, 0.00053760f, 0.02821085f, 0.02447462f, 0.01633060f, 0.03422505f, -0.04114094f, 
    0.02504651f, 0.03092813f, 0.03213263f, -0.02859025f, -0.02699441f, -0.00513003f, -0.01687943f, -0.02157496f, 
    0.01692943f, -0.02121560f, -0.00387897f, -0.01088060f, 0.00745932f, 0.01043833f, -0.03515111f, 0.03111880f, 
    -0.03155565f, 0.02537634f, -0.03125203f, 0.02501550f, 0.02682109f, -0.01416028f, -0.01504245f, 0.00461868f, 
    -0.00519034f, -0.01936634f, 0.02544289f, -0.00283656f, -0.03660313f, 0.01995132f, -0.00886460f, -0.00203802f, 
    0.02509855f, 0.01379725f, -0.01636304f, -0.02019140f, 0.02638932f, -0.04370146f, 0.00172588f, -0.03925156f, 
    -0.04203206f, -0.00155502f, 0.00299276f, -0.01754340f, 0.00795040f, -0.03266881f, 0.02625531f, -0.02794932f, 
    -0.00074827f, 0.02551051f, 0.02715105f, -0.01291074f, -0.03428305f, 0.00912801f, -0.03392129f, -0.01083288f, 
    0.02852499f, -0.02934399f, 0.00069249f, 0.02667378f, -0.02903464f, -0.01134748f, 0.02613059f, -0.03259749f, 
    -0.00709666f, -0.00816181f, 0.02238121f, -0.02629837f, -0.03187453f, -0.02290503f, -0.03843918f, -0.01818547f, 
    -0.03217001f, -0.02405088f, 0.00365765f, -0.04002601f, -0.00586421f, -0.00850620f, 0.04019362f, -0.00321800f, 
    -0.03796192f, 0.01443968f, 0.00795506f, -0.00343199f, 0.00088447f, -0.03121162f, -0.03586568f, 0.02041573f, 
    -0.01285858f, -0.01574401f, -0.03477624f, 0.02167051f, -0.01523556f, -0.02403725f, -0.01299750f, 0.00447364f, 
    0.00832039f, -0.01470379f, -0.01535554f, 0.01749312f, 0.00366313f, 0.01610358f, 0.01861426f, -0.04135980f, 
    0.03281457f, 0.00547353f, -0.00120464f, 0.00649734f, -0.01683011f, -0.02907864f, 0.00663887f, -0.01593424f, 
    0.02368389f, -0.01713496f, -0.03511731f, 0.02134642f, 0.02667633f, 0.02256106f, -0.00117676f, -0.04287506f, 
    0.02539412f, -0.00694903f, 0.04113717f, 0.01353759f, 0.01432677f, 0.00743001f, 0.00450651f, 0.01616255f, 
    -0.00768922f, -0.01269079f, -0.02969016f, -0.00743136f, -0.01618178f, -0.01838720f, 0.00284558f, -0.03093391f, 
    -0.01207911f, -0.01531900f, 0.01061139f, -0.01683526f, 0.01949483f, 0.02301201f, -0.02889718f, 0.01768357f, 
    -0.00757166f, 0.02929350f, 0.01906127f, 0.01684001f, -0.01966262f, 0.00055558f, -0.00926811f, 0.01712576f, 
    0.04252623f, -0.01729740f, -0.03746683f, -0.03084091f, 0.00133574f, 0.00099661f, 0.03731244f, -0.00249744f, 
    0.02795232f, -0.02673507f, 0.00073032f, 0.00970284f, 0.02820463f, -0.02742415f, 0.01232865f, -0.01409370f, 
    -0.01196666f, 0.03138974f, -0.01495450f, -0.01000559f, -0.02369898f, -0.01143374f, -0.00701655f, -0.01255959f, 
    0.00034426f, -0.01337466f, -0.02705954f, 0.02643723f, 0.02050336f, -0.00236325f, 0.00078985f, -0.03494741f, 
    -0.02613014f, -0.03109239f, 0.01115225f, -0.00234601f, 0.02242452f, -0.00105751f, -0.03058087f, -0.01453709f, 
    -0.00926028f, 0.00823179f, 0.00690979f, 0.01330305f, 0.01885797f, 0.00211078f, -0.03156775f, -0.01401327f, 
    -0.00494809f, -0.03263453f, 0.02576937f, -0.03747886f, -0.03691170f, 0.00867367f, -0.00562008f, 0.02164874f, 
    -0.03444231f, 0.02445434f, -0.00950397f, 0.00926187f, -0.03499940f, -0.00413285f, 0.00400604f, 0.02254837f, 
    -0.03478398f, 0.02475094f, -0.01098857f, -0.01594272f, -0.03485615f, 0.01683887f, 0.00403018f, 0.01647407f, 
    -0.00302636f, -0.01939650f, -0.03361659f, -0.02265346f, -0.03775563f, -0.02574180f, -0.03596354f, -0.00556097f, 
    -0.01172431f, -0.01615279f, -0.00960455f, -0.03321951f, -0.02296610f, -0.01343105f, 0.01892910f, 0.02813301f, 
    -0.00019525f, -0.00446820f, -0.02814562f, 0.00901058f, -0.04320547f, -0.01222390f, 0.01917258f, 0.02356513f, 
    -0.03248062f, 0.02167048f, 0.01265418f, -0.03974326f, 0.03227649f, -0.02953803f, -0.03969581f, 0.01787638f, 
    0.01515913f, -0.00809948f, -0.03543460f, -0.04248005f, 0.02180295f, -0.00169539f, -0.03548188f, -0.03080715f, 
    0.02490512f, -0.03489090f, -0.00700319f, 0.03189346f, 0.00450279f, 0.01568127f, 0.02191157f, -0.03296313f, 
    0.00424493f, 0.02748719f, -0.00501755f, 0.01288093f, -0.00447847f, 0.02461598f, -0.02315163f, -0.03322767f, 
    0.00752974f, -0.01592986f, -0.01025272f, -0.01526461f, -0.03671673f, 0.01548337f, -0.00870629f, 0.02380015f, 
    -0.01952333f, -0.00844036f, -0.00094953f, 0.03410151f, -0.02082408f, 0.02296734f, -0.02868071f, -0.02926305f, 
    -0.00455571f, 0.01151236f, 0.00887837f, -0.02959274f, -0.01234575f, -0.00643750f, 0.00258564f, 0.02588159f, 
    -0.03584840f, -0.00555839f, 0.01340843f, -0.02939292f, -0.03363347f, -0.00728979f, -0.01010567f, -0.02826401f, 
    0.00656045f, -0.01405611f, -0.02205718f, 0.02289063f, -0.00891192f, -0.02166033f, 0.01783661f, -0.04339961f, 
    -0.00393542f, -0.00889131f, -0.00558753f, -0.01850677f, 0.01639330f, -0.03741760f, 0.02001642f, -0.02213439f, 
    -0.02153759f, 0.03411289f, 0.01512603f, -0.03542058f, 0.02094501f, -0.02514611f, -0.03293099f, -0.03142422f, 
    -0.00348818f, -0.01880158f, -0.02624259f, -0.02539315f, 0.01092134f, 0.01656598f, -0.00908028f, -0.01196399f, 
    -0.02179251f, -0.03982332f, 0.01806366f, -0.00863103f, -0.02244222f, -0.01047511f, 0.01889349f, -0.02068067f, 
    -0.02963152f, 0.00666751f, -0.00764888f, 0.01067979f, -0.00841534f, -0.03665365f, 0.00432243f, 0.03233612f, 
    0.00451514f, -0.03510276f, 0.00478702f, -0.00380279f, -0.02582497f, 0.02355772f, -0.01752810f, -0.04158645f, 
    -0.16659158f, -0.03646237f, -0.01074677f, 0.02885251f, -0.06664512f, 0.08179642f, -0.03287487f, -0.06661425f, 
    0.00613131f, 0.09797800f, 0.05414306f, 0.05687580f, 0.39374697f, 0.24262924f, 0.06682345f, -0.22416309f, 
    0.25827464f, 0.08948653f, 0.01286316f, 0.05425225f, 0.10111561f, -0.04867401f, 0.00280284f, 0.12049013f, 
    0.16370939f, 0.08884874f, -0.14100109f, -0.17857637f, 0.07556909f, 0.17413998f, 0.04743715f, -0.03034754f, 
    -0.05570154f, 0.03648812f, 0.06204739f, 0.13822933f, 0.05350569f, 0.06843028f, -0.05856274f, 0.05207471f, 
    -0.07793955f, -0.06314864f, 0.07541519f, -0.08234634f, 0.00835794f, 0.05796727f, 0.06079219f, 0.13656425f, 
    -0.00266330f, -0.20435883f, -0.09439117f, -0.12501018f, 0.04217836f, 0.12749590f, -0.08450241f, -0.00610131f, 
    0.07846858f, 0.08511025f, 0.10958346f, 0.12387274f, 0.02496371f, -0.29172197f, 0.07579528f, 0.01314494f, 
    -0.10010494f, -0.01089138f, 0.09666104f, -0.07733839f, 0.03451125f, -0.00329452f, -0.05519468f, 0.03927674f, 
    0.08355931f, -0.19589013f, 0.07840444f, 0.03659681f, 0.13175233f, 0.06324989f, -0.06084338f, -0.01477687f, 
    0.22630088f, 0.01502358f, 0.02475071f, 0.02014205f, 0.28462589f, 0.29643354f, -0.07314327f, -0.06801986f, 
    -0.06024625f, -0.14366563f, 0.00121770f, 0.10465989f, -0.08639384f, 0.13495907f, 0.01813556f, -0.15050404f, 
    0.07504491f, -0.18051997f, 0.00015247f, 0.16049874f, 0.00067105f, -0.06341588f, -0.05145198f, 0.06450956f, 
    0.00489873f, -0.00433935f, -0.00257099f, 0.13021408f, 0.13086000f, 0.10874944f, -0.13596687f, 0.08084938f, 
    -0.01410889f, -0.00568909f, -0.05031052f, -0.11606300f, -0.04329314f, -0.12267536f, -0.09935415f, 0.00242828f, 
    -0.19196269f, 0.27778143f, 0.09415989f, -0.01070964f, 0.02138563f, 0.06250198f, 0.06914978f, 0.06678457f, 
    -0.03051381f, -0.06023581f, 0.01255251f, 0.11456083f, 0.06730200f, 0.01112353f, -0.05293612f, -0.05236608f, 
    -0.00045591f, 0.12537426f, 0.06532706f, -0.08369187f, 0.12239870f, 0.10243984f, 0.00417635f, 0.08980900f, 
    0.08174369f, 0.15257396f, 0.35886127f, 0.00660539f, -0.23745553f, -0.08079793f, -0.13043897f, 0.08060241f, 
    -0.05676084f, -0.13435714f, 0.02874108f, 0.04788763f, 0.16346063f, 0.11432314f, -0.06354915f, -0.22625175f, 
    -0.06228510f, -0.01124152f, -0.04685914f, -0.05655154f, -0.05857024f, -0.03728278f, -0.05412127f, -0.06299660f, 
    -0.09744338f, -0.22548950f, 0.07265245f, 0.27515990f, 0.04059505f, -0.01286269f, 0.03981853f, -0.06004996f, 
    0.05121909f, 0.06539582f, 0.03539724f, 0.04229748f, 0.19765063f, 0.13277772f, 0.03868598f, 0.01736880f, 
    0.03744908f, -0.11637681f, 0.20483905f, 0.04070054f, -0.00102571f, 0.10444367f, 0.05483763f, 0.02896046f, 
    -0.12672457f, 0.04325978f, 0.02256252f, 0.29988825f, 0.11723172f, -0.03746039f, 0.04097889f, -0.02136472f, 
    0.00494096f, 0.06329343f, 0.08766007f, 0.01281725f, -0.01908413f, 0.24577583f, -0.00635619f, -0.26892450f, 
    0.12305604f, -0.01993352f, 0.08951499f, 0.26118052f, 0.04425438f, -0.00142484f, -0.05875975f, -0.10897448f, 
    0.16414680f, -0.32080820f, 0.02811963f, -0.12929048f, -0.11387188f, 0.04611565f, -0.01835416f, -0.04030264f, 
    0.09825058f, 0.03251794f, 0.03278982f, -0.10628068f, 0.01664430f, -0.27745521f, 0.08623686f, 0.07907797f, 
    0.00266136f, -0.02993978f, -0.13388196f, -0.10680528f, 0.02049991f, 0.12566467f, 0.02111638f, 0.01348942f, 
    -0.39199311f, -0.20639689f, 0.27556047f, 0.09817219f, -0.06397627f, 0.15109843f, 0.02673957f, -0.03636601f, 
    -0.00054996f, 0.11880475f, 0.22894505f, 0.02577354f, 0.06865937f, 0.06415719f, -0.24914463f, 0.22798607f, 
    0.01949740f, 0.02570723f, 0.07337725f, -0.00142974f, -0.08612526f, 0.10607201f, 0.08799972f, 0.18349172f, 
    -0.00166229f, -0.01926962f, -0.37021872f, -0.12507777f, 0.07947464f, -0.03219438f, 0.10372547f, -0.10511454f, 
    -0.00309204f, 0.01350597f, 0.06973187f, -0.02936123f, -0.03679324f, -0.26124483f, 0.51879311f, 0.13915367f, 
    -0.05665113f, 0.06823997f, 0.05657179f, 0.16356108f, 0.19863978f, -0.12129463f, 0.00330790f, 0.05524936f, 
    0.17041229f, 0.08844576f, 0.09509100f, -0.09992579f, 0.09237999f, 0.10625989f, 0.02845541f, 0.26097700f, 
    -0.03016286f, 0.04097922f, 0.09192409f, 0.05843619f, -0.00783722f, 0.26762259f, -0.10817552f, -0.21986295f, 
    0.16258071f, 0.17505704f, -0.07757197f, -0.33044314f, -0.04387641f, 0.05416529f, -0.01121093f, 0.08748408f, 
    0.10276750f, 0.22712983f, 0.09141956f, 0.01940612f, 0.00798694f, 0.22203630f, -0.02074049f, 0.08043157f, 
    -0.03254234f, -0.07455082f, -0.09806100f, -0.11735225f, 0.31182832f, 0.32228276f, -0.07070256f, -0.10674354f, 
    0.04878507f, -0.02151787f, 0.03545913f, 0.09587697f, -0.03438501f, -0.01060817f, -0.02594426f, -0.11767729f, 
    -0.03733570f, -0.28742793f, -0.19301918f, 0.00443249f, -0.03473610f, 0.14155945f, 0.01690304f, -0.14530186f, 
    0.00712610f, -0.13552080f, -0.07041016f, -0.05572271f, 0.10505345f, 0.13754112f, 0.02081545f, -0.25982875f, 
    -0.00382234f, -0.00651175f, -0.02052160f, -0.01590739f, -0.16579445f, -0.00833868f, 0.07827982f, -0.07074941f, 
    0.13106766f, 0.04063619f, 0.25576365f, 0.04489094f, 0.17619066f, 0.02498493f, -0.03967551f, -0.05553256f, 
    -0.14336331f, 0.14932194f, 0.13827461f, -0.01676049f, 0.21138369f, 0.30945370f, -0.33546853f, -0.12576526f, 
    0.04821529f, -0.02648345f, 0.25032777f, 0.12215246f, 0.10372856f, 0.09053642f, 0.13693243f, 0.04220574f, 
    -0.11422454f, 0.09411839f, -0.09721251f, -0.01359829f, -0.00989294f, -0.03025840f, 0.02264368f, 0.11392456f, 
    -0.14152561f, -0.01254898f, -0.15418079f, -0.01684229f, -0.00338810f, -0.01217057f, 0.02035658f, -0.00213812f, 
    0.00143992f, 0.15483524f, -0.08333532f, -0.01049990f, -0.03211262f, 0.03752319f, 0.01189562f, -0.12347386f, 
    0.00652193f, 0.06904421f, 0.01884791f, 0.08735781f, -0.07125553f, 0.00316666f, -0.00772557f, 0.09806748f, 
    0.02378078f, 0.11041430f, -0.05201874f, 0.06742018f, 0.17220250f, 0.13183261f, 0.59475958f, -0.17373571f, 
    0.05154138f, 0.01578647f, 0.07166677f, 0.19844849f, 0.16695829f, -0.15581411f, -0.03817971f, -0.05458314f, 
    -0.13340887f, 0.10909383f, 0.13983849f, 0.12113681f, -0.00764683f, -0.08098027f, -0.18273672f, -0.00526398f, 
    -0.16650808f, -0.09526655f, -0.02938924f, 0.05887282f, 0.29735094f, 0.17406310f, -0.02475017f, -0.02518316f, 
    0.27803764f, -0.02676679f, 0.09744213f, -0.12466691f, 0.11848741f, 0.15671287f, 0.01378225f, -0.03744799f, 
    0.12024428f, 0.23317955f, -0.22125882f, -0.02442026f, 0.12583962f, -0.00668553f, 0.05673629f, 0.11359811f, 
    -0.05541381f, -0.00343558f, 0.04300663f, -0.01212167f, 0.00250829f, -0.03593361f, 0.05123556f, -0.12592839f, 
    -0.26169211f, 0.00651215f, 0.00242243f, -0.04979338f, -0.20672078f, 0.02799308f, -0.00688079f, -0.09586839f, 
    0.05951630f, 0.00341729f, -0.02958153f, -0.07101674f, 0.09220850f, -0.02680171f, 0.21268190f, -0.01624709f, 
    0.02875209f, 0.08616904f, -0.10159616f, -0.03236322f, 0.26644215f, 0.25293311f, -0.31985679f, -0.20957866f, 
    0.05814688f, 0.07779831f, 0.09807795f, 0.07381152f, 0.05384942f, -0.01072644f, 0.23972306f, 0.17816195f, 
    -0.10594454f, -0.04113777f, 0.29075032f, -0.08958478f, 0.14750254f, 0.08260160f, -0.05283223f, -0.19892332f, 
    0.11078895f, -0.17214577f, -0.00917604f, -0.16290358f, 0.21485484f, 0.14122082f, -0.00155806f, -0.26000035f, 
    0.16538502f, 0.02720907f, -0.03821446f, -0.11062928f, 0.08699653f, -0.02159318f, -0.11105467f, -0.09092140f, 
    -0.01789938f, -0.38759616f, -0.27779067f, -0.21496785f, -0.04371288f, 0.00094546f, -0.07057287f, -0.17034851f, 
    -0.00384189f, 0.04329561f, -0.10742401f, 0.01628692f, 0.20368634f, -0.17307958f, 0.06483708f, 0.24424790f, 
    0.13026950f, 0.00521958f, 0.05819887f, 0.00619883f, 0.10875808f, 0.09473118f, 0.07422400f, -0.08073986f, 
    -0.06763079f, -0.07320078f, -0.19126676f, 0.10831639f, 0.07385881f, -0.07443617f, 0.12436742f, 0.02449081f, 
    0.06798631f, -0.07972816f, -0.16854148f, 0.12728451f, -0.22427480f, 0.19040154f, 0.15917259f, 0.00442154f, 
    0.03025573f, 0.01911941f, -0.03180747f, 0.15940623f, 0.02824604f, -0.00529109f, 0.09604450f, 0.08351584f, 
    -0.09171102f, -0.45326078f, -0.38722005f, 0.00813073f, 0.01270997f, -0.01683829f, 0.04714988f, -0.08559186f, 
    0.05056959f, 0.03778968f, -0.08248060f, 0.03781847f, -0.21067958f, -0.11498672f, -0.06985772f, 0.32549930f, 
    -0.05628143f, 0.07371381f, 0.00592447f, -0.01490126f, 0.17475887f, 0.07873403f, -0.12856215f, -0.01196109f, 
    0.09973418f, -0.09605855f, 0.35420668f, 0.13155925f, 0.11445609f, -0.03970139f, -0.14556140f, -0.07041472f, 
    0.06356760f, -0.10175867f, 0.09200396f, -0.00738255f, 0.22214016f, -0.31199497f, -0.08321033f, -0.19945313f, 
    -0.05606424f, 0.13358031f, -0.06783260f, -0.04663190f, 0.09399208f, 0.07917918f, 0.01677320f, 0.00929244f, 
    -0.30064234f, -0.01704515f, 0.01665615f, 0.12120292f, 0.06174021f, 0.17063764f, -0.08979130f, -0.07066316f, 
    -0.06582907f, 0.05820700f, 0.06234138f, -0.03435234f, 0.05835197f, 0.12777908f, 0.02527128f, 0.10618141f, 
    0.07742114f, 0.03814941f, 0.03452972f, 0.12620430f, 0.04102975f, 0.05786489f, -0.02449834f, 0.14139658f, 
    0.44946852f, 0.41522226f, 0.11979344f, -0.06840181f, 0.13947645f, -0.06164622f, 0.04882897f, 0.12134714f, 
    -0.05140540f, -0.05999675f, 0.00408369f, -0.00539090f, 0.26223922f, -0.06450229f, -0.00217237f, -0.17872913f, 
    -0.02025658f, 0.20558137f, -0.00401706f, 0.19577530f, -0.05760425f, -0.14187334f, 0.01662118f, 0.04917971f, 
    0.07182646f, 0.06404043f, 0.01922112f, -0.18918979f, 0.03556657f, 0.15790632f, 0.05842020f, 0.01393144f, 
    -0.02059398f, 0.03896413f, -0.05737593f, 0.08212604f, 0.43464458f, 0.49398699f, -0.04741991f, -0.11843454f, 
    -0.00968917f, -0.00439723f, 0.23307145f, 0.03479107f, 0.08491108f, -0.02888094f, 0.12455610f, 0.05880522f, 
    -0.27017283f, -0.24003173f, -0.10106914f, 0.49409422f, 0.02119013f, -0.00077944f, -0.00423762f, 0.04389082f, 
    0.01929779f, 0.04195145f, 0.03666865f, 0.01769940f, -0.32491505f, 0.09243883f, 0.07397915f, -0.09846650f, 
    0.00741510f, 0.22475183f, 0.12000977f, -0.20175011f, -0.07381948f, 0.06241075f, 0.02681042f, -0.08495510f, 
    0.27450082f, 0.16797864f, 0.04512692f, -0.03883818f, 0.17482993f, 0.10265216f, 0.03420752f, 0.25142342f, 
    0.05104468f, -0.09245176f, 0.06721840f, 0.08465973f, -0.18580335f, -0.02784919f, 0.34371325f, -0.09469752f, 
    -0.13113821f, 0.02701731f, -0.03270007f, -0.06581572f, 0.01759869f, -0.12704462f, 0.16794343f, 0.06332514f, 
    0.01492100f, -0.04485369f, 0.27842137f, -0.24043874f, 0.05572334f, 0.08427304f, 0.07876552f, -0.18097793f, 
    0.17550771f, -0.04565592f, 0.12700580f, 0.03610809f, 0.05984564f, -0.17625421f, -0.11422028f, 0.07997950f, 
    -0.00936602f, -0.04663925f, -0.03661805f, -0.03556802f, 0.00271966f, 0.19549400f, 0.02927433f, 0.06310721f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00832917f, -0.03964543f, 0.07508458f, -0.01066770f, 0.08777258f, -0.01290351f, 0.09865022f, -0.05873556f, 
    0.05980876f, 0.02126385f, 0.01085088f, 0.00277530f, 0.07793616f, 0.00518532f, 0.22995268f, -0.03457122f, 
    0.01448914f, 0.14193588f, -0.03768304f, -0.02179088f, 0.10252767f, -0.00184374f, 0.01412531f, -0.02763372f, 
    -0.00624224f, 0.00410390f, -0.02388699f, -0.07017293f, 0.15804553f, -0.03673073f, 0.01692827f, -0.06575727f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09638409f, 0.16778462f, -0.17834553f, -0.11768997f, -0.00193680f, 0.07212216f, 0.30680227f, 0.08152216f, 
    0.26518837f, 0.08648476f, 0.15801731f, -0.12663101f, 0.14002806f, -0.17236170f, 0.15717696f, 0.12675464f, 
    -0.01479736f, -0.09952017f, -0.14968073f, -0.00617038f, -0.43161595f, -0.38778010f, -0.11166847f, -0.02447312f, 
    0.17472959f, -0.11160860f, 0.15456505f, -0.31027144f, 0.25516015f, 0.00508643f, -0.12055811f, 0.25862288f, 
    0.09484305f, 0.17665580f, 0.08823635f, 0.14222610f, 0.00115738f, -0.02472737f, 0.14374812f, 0.09463137f, 
    0.02657474f, 0.02905342f, -0.07903932f, 0.14849903f, -0.14069377f, 0.15114664f, -0.07439080f, 0.07408168f, 
    -0.05858635f, -0.12355355f, 0.06878916f, -0.09241733f, -0.10830480f, 0.04102021f, 0.13480538f, 0.06104274f, 
    0.04138022f, -0.13984405f, 0.15387681f, -0.18069850f, -0.18882069f, -0.13373497f, 0.09804995f, -0.14710686f, 
    0.09558327f, -0.11623030f, 0.15181150f, 0.10794902f, -0.09030443f, 0.10547233f, -0.19924927f, 0.26451266f, 
    -0.44541615f, -0.01250088f, -0.05949013f, -0.08568265f, 0.32415256f, -0.03644558f, 0.01201665f, -0.09916917f, 
    0.00501714f, -0.22981705f, -0.16794610f, 0.09589630f, 0.30366519f, 0.13455112f, -0.08916970f, 0.12416342f, 
    -0.05475816f, -0.10979069f, 0.04470165f, -0.22788548f, 0.01143761f, -0.08373369f, 0.18308477f, 0.13438740f, 
    0.06161736f, 0.07019752f, 0.05683750f, -0.06604137f, -0.05877201f, -0.05549743f, 0.33509085f, -0.34715313f, 
    -0.24259421f, -0.16763952f, 0.07519438f, -0.17180277f, 0.06034749f, 0.08017329f, 0.32255882f, 0.11156365f, 
    0.01039142f, 0.35260156f, 0.07391508f, 0.12189969f, 0.01570409f, -0.18614559f, -0.04363271f, -0.13388366f, 
    0.00952231f, -0.01300677f, -0.15280533f, -0.08774720f, 0.05953281f, -0.14572845f, -0.01015379f, -0.14463983f, 
    -0.12678513f, -0.05410574f, 0.18775241f, -0.01488353f, 0.17805898f, -0.01671641f, -0.19377539f, 0.45968607f, 
    -0.25241196f, -0.04689289f, 0.09924326f, 0.03318468f, 0.26761103f, 0.07464694f, -0.03048089f, -0.12510146f, 
    0.05291715f, -0.12397681f, 0.10859576f, -0.13699818f, -0.08004759f, -0.68724638f, 0.07791024f, -0.13923484f, 
    0.10250934f, -0.03260654f, 0.04023106f, -0.04021784f, -0.07976631f, -0.10425503f, -0.14560415f, 0.28186676f, 
    0.02197463f, 0.14729536f, -0.15191200f, -0.08673296f, 0.39916694f, -0.01814330f, 0.10226068f, -0.09517061f, 
    0.10075181f, -0.02745784f, 0.03544692f, 0.01235751f, -0.15564525f, -0.03010235f, 0.45435095f, 0.16066588f, 
    -0.00054192f, 0.32297626f, 0.06853425f, -0.17109072f, -0.00439624f, -0.31670249f, 0.08231810f, 0.10230704f, 
    -0.18219307f, -0.07742039f, -0.06487791f, 0.05781681f, 0.34247413f, -0.08548424f, -0.13663186f, 0.08615237f, 
    -0.08901469f, -0.12477145f, -0.08138960f, -0.02248716f, -0.31271431f, -0.07900091f, 0.40586644f, -0.09691089f, 
    -0.16025515f, -0.07115899f, 0.13812487f, 0.04772992f, 0.31143868f, 0.11723395f, -0.16689266f, -0.16990316f, 
    -0.09235384f, 0.12757795f, -0.09593948f, -0.08293135f, -0.34372142f, -0.17509806f, -0.01076361f, 0.09308571f, 
    -0.05330804f, -0.00557373f, 0.15303822f, 0.11971345f, 0.10092787f, 0.09456398f, -0.17166969f, 0.16970211f, 
    0.12276983f, 0.15547904f, -0.02438399f, -0.03764072f, -0.09116496f, 0.03910429f, -0.07145950f, -0.10043107f, 
    -0.02414265f, -0.06364291f, 0.06717248f, 0.14574474f, 0.04904770f, -0.17875896f, 0.03829793f, 0.06329926f, 
    -0.08515587f, -0.16903250f, 0.05386940f, 0.05474715f, -0.05956669f, 0.00411304f, -0.17681158f, 0.04639450f, 
    -0.12913971f, 0.11840816f, 0.14683695f, -0.07052016f, 0.00458004f, -0.03232052f, -0.05317308f, -0.18507256f, 
    -0.13505134f, -0.18065159f, 0.30908695f, 0.00061278f, 0.18518318f, -0.08963164f, 0.01409253f, -0.21455283f, 
    0.06688429f, -0.14455828f, 0.11142148f, -0.05774654f, -0.11014435f, 0.13208716f, 0.11399712f, 0.11548534f, 
    0.04203857f, 0.19840682f, 0.11787780f, 0.14028847f, -0.06172999f, 0.26995149f, -0.11488856f, 0.14882387f, 
    -0.29682729f, -0.16545200f, 0.04953786f, 0.16006315f, -0.11103189f, -0.08051199f, 0.15281011f, 0.29799104f, 
    -0.04214777f, 0.17001496f, 0.26313579f, 0.08227671f, 0.18964486f, -0.10811390f, 0.30418861f, -0.04407848f, 
    -0.26421043f, 0.03524709f, 0.11237410f, 0.04300253f, -0.05876692f, -0.07931370f, -0.15789719f, -0.09453307f, 
    0.11684787f, 0.04503781f, 0.09297353f, -0.03560561f, 0.16397256f, 0.02763004f, 0.07731350f, 0.03782982f, 
    -0.40327752f, -0.09065515f, -0.15301569f, 0.30801868f, -0.23309666f, 0.00881872f, 0.15070911f, 0.26146904f, 
    -0.03964537f, 0.02182090f, 0.19664386f, 0.11300259f, -0.14851893f, -0.17038469f, -0.16245198f, 0.22543328f, 
    -0.25162658f, -0.16025010f, 0.12995784f, 0.05924545f, -0.15191841f, -0.04799731f, 0.11475242f, 0.03743877f, 
    -0.15635230f, 0.10852335f, -0.05664947f, -0.18451226f, 0.33891711f, -0.26586822f, -0.14960206f, 0.10944084f, 
    -0.08907799f, -0.04182936f, 0.06481319f, -0.58246422f, 0.14889570f, 0.06257384f, -0.11228342f, 0.03063475f, 
    -0.07164920f, 0.01555109f, 0.24398819f, -0.11405826f, 0.18329223f, 0.11345106f, 0.32177329f, -0.03160181f, 
    0.14820774f, -0.05093976f, -0.08122420f, 0.16605447f, -0.34489289f, -0.03217796f, 0.19093229f, 0.05181507f, 
    -0.15696007f, 0.02420780f, 0.02033819f, -0.05367066f, 0.15510683f, -0.17002501f, -0.12978141f, -0.02520466f, 
    0.14734331f, -0.17347170f, -0.11217728f, -0.14780098f, -0.40067598f, -0.04654722f, 0.10990983f, -0.00148962f, 
    -0.00514058f, 0.17304720f, 0.08625582f, 0.16730396f, 0.31937858f, -0.15929650f, -0.08325297f, 0.34910491f, 
    0.13738631f, -0.17514695f, 0.06495982f, -0.03040806f, 0.29744259f, 0.06292552f, -0.35588670f, 0.12745687f, 
    -0.03592421f, -0.28978887f, 0.02063967f, 0.10357831f, -0.22109912f, 0.01059316f, -0.15895514f, -0.05512831f, 
    -0.24384277f, 0.06683207f, -0.13698588f, 0.05455011f, 0.09871063f, -0.13122988f, -0.02473982f, 0.13236849f, 
    0.00621132f, -0.13807939f, 0.25614941f, -0.03300794f, 0.34270793f, 0.00161251f, 0.07400248f, 0.31924507f, 
    0.32732320f, 0.05608624f, -0.16269498f, 0.15778476f, 0.04081294f, 0.08402403f, -0.03180094f, -0.10230855f, 
    -0.00584658f, 0.03816708f, 0.16488370f, 0.02803050f, -0.10303365f, 0.26845723f, -0.13164501f, 0.13844195f, 
    0.10712223f, -0.11016729f, 0.14007647f, -0.31465167f, 0.22174586f, 0.10342667f, 0.05993158f, -0.06050266f, 
    0.06208441f, -0.00579282f, 0.19482763f, 0.09901854f, 0.12963615f, -0.05291049f, -0.04033100f, -0.19981745f, 
    0.00370577f, -0.05533613f, -0.00717932f, 0.03878916f, 0.23002914f, -0.05574197f, 0.33024985f, -0.12958913f, 
    -0.03938968f, 0.13159829f, 0.12047904f, 0.11651922f, 0.42065507f, -0.07371442f, 0.00905784f, -0.04960667f, 
    0.02587052f, -0.04682182f, -0.02071281f, -0.19659193f, 0.11363785f, 0.07532311f, -0.01071429f, -0.17272995f, 
    0.03103086f, 0.13272937f, -0.09111321f, 0.16167152f, 0.27908415f, 0.02489112f, -0.24920300f, 0.18121941f, 
    -0.00224712f, 0.08934002f, 0.04680732f, -0.03792606f, 0.32886803f, 0.03324558f, 0.20353369f, 0.02692115f, 
    0.02849038f, -0.24735077f, 0.07257038f, -0.04913171f, 0.23045489f, -0.06289942f, -0.06312259f, 0.03113636f, 
    0.10028570f, -0.02024709f, -0.11743940f, -0.34843951f, 0.12558751f, 0.13576597f, -0.12395859f, -0.14467569f, 
    0.12565200f, 0.10045315f, 0.25302312f, 0.02065448f, -0.29114941f, 0.03691429f, 0.30238298f, -0.33416450f, 
    0.20890367f, 0.04004197f, 0.13631608f, -0.06002311f, 0.09832957f, 0.16436383f, 0.19733767f, 0.13946278f, 
    0.16250117f, 0.27644667f, -0.11164492f, -0.10913026f, -0.20526966f, 0.06665055f, 0.11406811f, -0.10492326f, 
    -0.12942594f, -0.11862233f, -0.15354455f, -0.05415339f, -0.09583718f, 0.01683784f, -0.15482613f, 0.27055079f, 
    0.09058974f, -0.19320582f, 0.01122414f, -0.08101888f, 0.09081033f, -0.10620438f, 0.26269299f, 0.20572656f, 
    -0.40270880f, 0.05442563f, 0.06280321f, 0.02992842f, 0.00085471f, -0.02732032f, -0.00088574f, 0.08260003f, 
    -0.07355282f, 0.10008243f, -0.03958960f, 0.05562726f, 0.00537246f, 0.17109577f, 0.03608994f, -0.01431204f, 
    -0.40381116f, 0.13348646f, 0.09271222f, -0.02052570f, 0.16917719f, -0.02036931f, -0.13154168f, -0.19230722f, 
    -0.07319473f, -0.09179699f, 0.14212753f, 0.15712328f, 0.03238516f, 0.01863186f, -0.05528642f, -0.17576061f, 
    0.07168265f, -0.08751407f, 0.08689166f, -0.12510717f, -0.07534207f, -0.17737150f, 0.02122555f, -0.04288153f, 
    -0.13530946f, 0.26041204f, -0.15439747f, 0.01852223f, -0.03669445f, 0.03479527f, -0.08756246f, -0.10121999f, 
    -0.00964422f, -0.08895455f, -0.03206217f, 0.26438314f, -0.20782343f, -0.04413159f, -0.03312590f, 0.33589032f, 
    0.12166037f, 0.02211068f, 0.46408564f, -0.00150923f, -0.27297512f, -0.01532856f, 0.20994815f, -0.08480582f, 
    -0.17325604f, -0.07234536f, -0.01752717f, -0.06683110f, 0.20995975f, 0.16998231f, 0.01913643f, -0.01710489f, 
    -0.05241003f, -0.04481807f, -0.06608391f, -0.12954079f, -0.12736985f, -0.13859722f, -0.07604292f, 0.14272782f, 
    0.04498519f, -0.16629364f, -0.05249185f, 0.14483184f, 0.09586918f, 0.12009618f, -0.00899102f, 0.10766221f, 
    0.04196994f, -0.00878924f, 0.03733313f, 0.15928492f, -0.00973382f, -0.09950139f, 0.09312262f, 0.34191370f, 
    -0.00742343f, -0.01227015f, -0.16725791f, -0.15095045f, -0.02498443f, -0.15900660f, -0.11918425f, 0.00574269f, 
    -0.05358105f, -0.07720429f, -0.02991210f, 0.02825003f, -0.34031504f, 0.18981168f, -0.08386356f, -0.16160609f, 
    -0.13448738f, 0.06975383f, 0.10533504f, 0.08643454f, 0.27564561f, 0.06072764f, 0.11298987f, 0.14548957f, 
    0.01131738f, 0.04206908f, 0.19089632f, 0.08764108f, 0.14261279f, 0.09884144f, 0.07163774f, 0.22138391f, 
    -0.05855934f, -0.08937332f, -0.10223304f, 0.05531822f, -0.20400603f, 0.06646711f, 0.18341398f, 0.08281247f, 
    0.01372047f, 0.23099768f, 0.03937580f, 0.01594335f, 0.08375016f, -0.23047259f, -0.05346505f, 0.15918449f, 
    0.24923371f, -0.03779685f, 0.16116887f, -0.38860878f, -0.17772067f, -0.15382968f, -0.16855437f, -0.04763637f, 
    0.11115132f, -0.13954435f, -0.09795370f, 0.04215321f, -0.10939208f, -0.02684994f, -0.14715058f, -0.03319525f, 
    -0.15135615f, 0.11295685f, -0.02227069f, -0.06447638f, 0.03669863f, -0.03247068f, 0.04792637f, 0.11793888f, 
    -0.16202465f, -0.17381747f, -0.07049030f, -0.02403833f, 0.05691398f, 0.09697913f, 0.01097855f, 0.07721846f, 
    -0.01879928f, -0.09947976f, -0.16459875f, -0.11614753f, -0.12814479f, -0.07378204f, 0.07688367f, -0.03538923f, 
    0.02457983f, -0.14905521f, 0.05609602f, -0.10346141f, 0.07243785f, 0.05282484f, -0.03472677f, 0.10083816f, 
    -0.21889952f, 0.16159841f, -0.11487698f, -0.09498615f, 0.05792340f, 0.15106592f, 0.11914755f, -0.12524642f, 
    0.05081720f, 0.25201043f, -0.13731061f, 0.08905216f, 0.19439685f, 0.48145670f, -0.03935051f, 0.12590557f, 
    -0.52745593f, 0.13780969f, -0.15873018f, -0.15915985f, -0.06253186f, 0.02689373f, -0.02474153f, 0.04428327f, 
    -0.00930632f, 0.12486385f, 0.12208425f, 0.15956345f, -0.06283800f, -0.06224561f, -0.02959730f, 0.11101113f, 
    0.02208748f, -0.17362413f, -0.03950972f, -0.12463503f, -0.08275466f, 0.15232605f, -0.20586005f, -0.12663600f, 
    -0.15493761f, -0.08480840f, -0.05061876f, -0.13075003f, 0.01266917f, 0.09519536f, 0.03975121f, -0.01812083f, 
    -0.02727076f, -0.08863725f, 0.14852987f, 0.22645161f, -0.06858996f, -0.02837848f, 0.03099844f, 0.05264013f, 
    0.01611346f, -0.16134851f, 0.02789323f, 0.12257230f, 0.13856381f, -0.17607220f, 0.02218553f, 0.04750314f, 
    -0.54188162f, 0.09556670f, -0.06335223f, 0.13330200f, 0.14517154f, 0.00260098f, 0.02175151f, -0.10510208f, 
    0.07871579f, -0.00175471f, -0.00715336f, 0.13305040f, 0.04126684f, -0.28331262f, 0.14640622f, -0.00709816f, 
    -0.22382995f, 0.13884267f, -0.05606980f, 0.34058717f, -0.32025787f, -0.12273893f, 0.08125699f, 0.33771098f, 
    0.13377637f, -0.08539495f, 0.19980218f, 0.12439060f, -0.18248637f, -0.05946218f, 0.08398597f, -0.08554132f, 
    -0.58779258f, -0.09492873f, 0.02283790f, 0.11893278f, 0.14737374f, 0.01735997f, 0.31397074f, -0.02882479f, 
    -0.11125185f, 0.01432584f, 0.12461423f, 0.15864103f, 0.28576624f, -0.30215040f, 0.00681769f, -0.03158737f, 
    -0.37259316f, -0.04745794f, -0.01251380f, -0.04186574f, 0.04639288f, 0.12214199f, 0.12267689f, -0.01222977f, 
    -0.14111006f, -0.09746676f, 0.01841301f, -0.15226504f, -0.41850218f, -0.13858750f, 0.09782026f, 0.10015734f, 
    -0.18605450f, 0.13209455f, -0.05292565f, -0.14049640f, 0.33500436f, 0.11253908f, 0.12189128f, 0.01911383f, 
    -0.04367443f, -0.11495859f, 0.04111855f, -0.12912671f, -0.22971773f, -0.26740587f, -0.17281580f, -0.03329662f, 
    0.36969227f, 0.16152921f, -0.09968375f, -0.08865853f, -0.17338820f, 0.07935370f, 0.09450643f, 0.39856142f, 
    0.04795814f, -0.09113433f, 0.02366999f, 0.09532114f, 0.01261699f, 0.09559170f, 0.42600375f, -0.07214828f, 
    0.20806552f, 0.00390769f, -0.14104265f, 0.15871906f, -0.00254673f, 0.10778480f, 0.25011432f, 0.16125995f, 
    -0.04928095f, 0.28756765f, -0.12739231f, -0.17153162f, -0.15709202f, -0.18970989f, -0.00875793f, 0.12276179f, 
    0.04922436f, 0.12890206f, 0.05081884f, -0.06976078f, -0.01648059f, -0.02955378f, 0.04460227f, -0.17696612f, 
    0.06933871f, -0.17523256f, 0.21304423f, 0.09180958f, 0.04937334f, 0.05736885f, 0.32971013f, 0.00446501f, 
    -0.46584255f, 0.12611701f, -0.13076094f, 0.09129597f, -0.01340197f, 0.12855719f, -0.05492988f, 0.08986910f, 
    0.07477149f, -0.21778740f, 0.16847648f, -0.16146778f, 0.16983578f, -0.20484453f, 0.13425457f, 0.07344356f, 
    -0.36075759f, -0.02037073f, 0.05527856f, 0.25107110f, 0.17237981f, 0.05361212f, 0.15904149f, -0.18430966f, 
    -0.11643282f, -0.15912363f, -0.10486267f, -0.05644664f, 0.43535402f, -0.09485839f, -0.07337759f, 0.06620228f, 
    0.20811921f, 0.12357190f, 0.05800520f, -0.13561840f, -0.09908445f, 0.14720005f, 0.14616591f, -0.04534252f, 
    0.09019791f, 0.28223625f, 0.16658919f, -0.02530873f, 0.17677495f, 0.15092845f, 0.02308420f, -0.18042058f, 
    -0.19996244f, -0.08426894f, -0.09466180f, -0.25221196f, -0.15405215f, 0.09814549f, 0.15279764f, 0.03890423f, 
    -0.09910193f, -0.15239801f, 0.20381936f, 0.15461493f, -0.08628294f, 0.05129004f, 0.00173235f, 0.13885948f, 
    0.03493024f, 0.01176807f, 0.06460355f, -0.13674884f, -0.31349507f, -0.04911406f, 0.17201476f, -0.12933064f, 
    -0.07140498f, 0.14436568f, 0.10395630f, -0.12151762f, -0.01854696f, -0.14809184f, -0.05600772f, 0.00896116f, 
    0.34927806f, -0.13264228f, -0.00950030f, 0.08081445f, -0.29970479f, -0.02604873f, 0.16587947f, -0.01322629f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03203751f, -0.12541698f, 0.12289570f, -0.00798577f, 0.06176806f, 0.16612104f, -0.10035001f, 0.06494550f, 
    0.14998430f, -0.01902306f, -0.01275457f, 0.16244209f, -0.03487061f, 0.31643188f, 0.06135661f, 0.09001350f, 
    0.01306467f, -0.03670908f, 0.12903656f, 0.33112061f, 0.12304302f, -0.09107747f, 0.09571898f, 0.00994610f, 
    -0.27713600f, -0.22097591f, 0.09716506f, -0.07506172f, 0.07917928f, -0.03144196f, 0.21091114f, 0.11038780f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.23780973f, 0.07950199f, -0.03539699f, -0.25664115f, 0.26894981f, -0.07395387f, 0.09395874f, -0.02536304f, 
    -0.10107940f, -0.19344425f, -0.11227737f, -0.57673585f, 0.09477162f, 0.01485676f, -0.58627301f, -0.35305816f, 
    0.03515420f, -0.17738229f, 0.13874629f, -0.00589993f, 0.34177047f, -0.21770702f, -0.10646974f, -0.66006994f, 
    0.13635944f, 0.16355839f, -0.63014543f, 0.26556629f, -0.26157126f, -0.55087912f, 0.17212088f, -0.24305205f, 
    0.35417253f, -0.07390215f, -0.35220996f, 0.07250786f, -0.76073360f, -0.07069524f, 0.20518671f, 0.10764001f, 
    0.06669058f, -0.28720078f, 0.19890527f, 0.09368557f, -0.00354650f, 0.14861940f, -0.00176529f, -0.34979811f, 
    0.30022550f, -0.13114263f, 0.15209697f, 0.17429295f, 0.02595858f, 0.33791453f, 0.07307900f, -0.06268276f, 
    0.02757024f, -0.74194974f, -0.37999335f, -0.00967662f, 0.19118068f, -0.19318028f, 0.15008159f, -0.08777802f, 
    -0.44320801f, 0.06908055f, 0.29495761f, -0.16020921f, -0.11781418f, 0.11996613f, -0.66939890f, 0.09228822f, 
    0.05143684f, 0.17873779f, -0.07534805f, -0.68796533f, -0.00036067f, 0.28828532f, -0.02364699f, 0.03421348f, 
    0.05756307f, 0.21497719f, -0.22945265f, 0.03928454f, 0.26988086f, -0.41311812f, -0.10626462f, 0.18135589f, 
    -0.16683759f, -0.24742925f, 0.12279982f, -0.69118994f, -0.32691428f, -0.01530089f, -0.05937643f, -0.21772088f, 
    -0.33876622f, -0.14378951f, 0.19776781f, -0.21314000f, 0.11894981f, -0.37929469f, 0.02123289f, 0.04381986f, 
    -0.04817585f, 0.33921120f, -0.32470974f, -0.31220812f, 0.13834518f, 0.02497301f, -0.21223681f, -0.02340584f, 
    -0.15855876f, 0.19314297f, -0.11936645f, 0.18845260f, -0.15728951f, -0.30605763f, -0.12393299f, -0.04162782f, 
    -0.02108726f, 0.43659818f, 0.02565007f, -0.00470938f, -0.25808701f, 0.28782058f, -0.32883897f, -0.67893577f, 
    0.05780338f, 0.14667141f, 0.21313855f, -0.47820273f, 0.13415518f, -0.11334245f, -0.01840915f, -0.11891084f, 
    -0.37988698f, -0.36479276f, -0.67658067f, 0.00788652f, 0.28060946f, 0.14017786f, 0.01283259f, 0.27895936f, 
    -0.40415221f, 0.31860834f, 0.07075763f, 0.09112904f, 0.08224032f, -0.22248591f, 0.07340943f, -0.07699968f, 
    -0.06179059f, -0.17897047f, -0.37201342f, -0.03620311f, 0.01563163f, -0.09781879f, -0.28171095f, 0.11658378f, 
    0.23970053f, -0.16597793f, 0.14659753f, 0.13761142f, 0.09200272f, -0.06709465f, 0.11522104f, 0.07887407f, 
    -0.21328339f, -0.34872752f, -0.05231073f, -0.04184948f, -0.35498732f, -0.05341985f, 0.19477725f, 0.29090148f, 
    0.14456241f, -0.36204964f, 0.02858658f, 0.18214893f, -0.27233973f, -0.18997306f, -0.00578540f, -0.42632574f, 
    0.24431242f, -0.30256674f, 0.27507240f, 0.22191525f, 0.04998606f, -0.22253531f, -0.28826421f, -0.16261739f, 
    -0.59444857f, 0.08097083f, 0.15121362f, -0.00880598f, -0.27834508f, 0.02049360f, -0.15799449f, -0.17890869f, 
    -0.19243652f, -0.50574630f, 0.29629967f, -0.43841997f, -0.59978777f, 0.16075394f, 0.21896361f, 0.26089287f, 
    -0.18008903f, 0.23542543f, -0.27958259f, -0.67477036f, -0.55568343f, 0.12249807f, -0.13489725f, 0.42538360f, 
    0.10282549f, -0.37573233f, 0.26101729f, -0.39468330f, -0.17659748f, -0.34435153f, 0.22671530f, -0.23632360f, 
    -0.25887841f, -0.10659584f, 0.21113439f, -0.24721710f, 0.29025209f, -0.43426535f, -0.40630478f, -0.10304472f, 
    -0.04815266f, 0.24067788f, 0.37268803f, 0.10550478f, -0.25161347f, -0.23716685f, -0.06994979f, -0.04559642f, 
    -0.13574429f, -0.23198754f, 0.16559517f, -0.25618929f, -0.58051234f, 0.14938910f, 0.00018421f, 0.08665227f, 
    0.04893069f, 0.29585543f, 0.11531435f, 0.11773881f, -0.15940280f, -0.09293328f, -0.00292979f, 0.09227754f, 
    -0.72908711f, -0.06341792f, -0.36598194f, 0.22820249f, 0.06104273f, 0.24467215f, -0.05901683f, -0.05090836f, 
    0.01538190f, 0.12289121f, -0.01480461f, -0.27429086f, -0.61675477f, -0.57450861f, 0.07166038f, -0.37500271f, 
    0.01518138f, -0.39142695f, 0.08512242f, 0.18542010f, -0.81729573f, -0.02157450f, 0.12253803f, -0.21807060f, 
    -0.31326297f, 0.31880686f, 0.23135269f, 0.00593715f, 0.13461202f, 0.06777235f, -0.13417521f, -0.00254971f, 
    0.31642875f, -0.02975070f, -0.10460417f, -0.33392730f, 0.33034876f, 0.26791602f, -0.60756290f, -0.08245011f, 
    -0.25593683f, -0.33672950f, 0.09375876f, -0.11815455f, 0.18947318f, 0.28786352f, -0.02602739f, 0.32459062f, 
    -0.23055890f, -0.44891292f, -0.44035929f, -0.59686065f, -0.07604115f, 0.26386422f, 0.09655214f, -0.27535638f, 
    -0.24172579f, -0.23503371f, -0.34744969f, -0.44979385f, 0.06594274f, -0.35592356f, 0.12560888f, -0.22043091f, 
    0.02423875f, 0.11661940f, -0.33888808f, 0.27448124f, -0.30855548f, 0.23527187f, 0.14224519f, -0.03088695f, 
    -0.32752249f, 0.17740983f, -0.01355517f, -0.30596903f, -0.39261046f, -0.14164795f, -0.14233376f, -0.36732638f, 
    0.01483490f, 0.44732568f, -0.43221089f, 0.00982534f, 0.04866466f, -0.22016217f, 0.03613725f, -0.18767571f, 
    -0.27413031f, -0.18195975f, 0.23446290f, -0.42851213f, 0.23838390f, 0.51658481f, -0.28731310f, -0.87470204f, 
    -0.12289597f, -0.00835279f, -0.22919121f, 0.09543546f, -0.41363397f, 0.18450019f, -0.11618221f, 0.00008872f, 
    0.27497658f, 0.30833110f, -0.46229121f, -0.18412539f, -0.23896974f, 0.04107642f, 0.04147804f, -0.11902592f, 
    0.22186199f, -0.20231707f, 0.09439590f, -0.41156879f, -0.08525705f, -0.09513160f, 0.13882534f, 0.32321495f, 
    -0.53613311f, 0.13566418f, -0.22475927f, -0.50120026f, 0.07965749f, -0.63684738f, 0.38254368f, -0.49650574f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.26655513f, -0.03911692f, 0.05477830f, -0.28524107f, 0.07565895f, -0.10726256f, -0.00515666f, 0.12189725f, 
    -0.14039238f, 0.08613225f, 0.13973081f, 0.07600319f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
