#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82129484f, 0.93575794f, 0.98619950f, 0.08259906f, 1.12319911f, 0.89811432f, -0.87909591f, 0.14613813f, 
    -0.50733209f, -0.01986346f, 0.76176089f, 0.19814970f, -1.02484512f, 0.76932222f, -0.84015870f, 0.21822198f, 
    -0.23732778f, 0.89087492f, 1.41160464f, -1.31048119f, -0.17460315f, -0.55227882f, -1.11396527f, -0.49709061f, 
    -0.45370319f, -0.59152150f, 0.42549792f, 0.70183694f, -1.01768196f, 0.25562122f, -0.25383580f, 0.16096006f, 
    1.03330207f, 0.70108503f, 0.22855818f, 0.16757248f, 1.14151478f, 0.39711699f, 0.45662931f, -0.87513602f, 
    0.58506274f, 0.05160277f, 0.54158741f, -0.09621225f, 0.13981590f, 1.44301760f, -0.72889793f, -1.26799583f, 
    -0.01948010f, 0.43208593f, -0.46087572f, 0.27506286f, -0.08763818f, -0.41071725f, -1.06315112f, -0.39800254f, 
    -0.54982555f, -0.21949099f, 0.48226503f, -0.74443769f, 0.75545061f, -0.70929551f, 0.50412065f, 1.24932551f, 
    0.74224263f, 0.78538495f, -0.52698773f, 0.14437488f, -1.10500228f, 0.08828887f, 0.36303172f, 0.14911000f, 
    0.22996271f, -0.46471494f, 0.09837470f, -1.35478294f, -1.32398450f, -0.06622543f, 0.66383219f, 0.63807893f, 
    -0.35107636f, -0.89942282f, -0.63772446f, 0.74272346f, 0.47680527f, -0.15649101f, -1.04066813f, 0.70240301f, 
    0.56525367f, -0.45866472f, 0.64697230f, -0.68312454f, -0.46321252f, 1.41917419f, 0.85543442f, -0.01737658f, 
    0.51509416f, 0.64326650f, 0.12619533f, 0.32438624f, 0.50548738f, 1.06861174f, -0.51349694f, -0.34956917f, 
    0.74309254f, -0.77003127f, 0.21249092f, 0.80267978f, -1.10174668f, 1.01782382f, 0.35850444f, 0.25248817f, 
    -0.41463357f, -0.89113480f, -0.07644370f, -0.61874658f, -0.98688847f, 0.95405883f, 1.37369144f, -1.34100378f, 
    0.93600762f, 0.07364027f, -0.49490914f, 0.18776865f, -0.03872971f, 0.16003023f, -1.20777524f, -0.44760799f, 
    -0.12842607f, 0.34789020f, 1.25053596f, 0.52603841f, -0.08786642f, -0.47904426f, -0.38043582f, -0.65499145f, 
    -0.66255134f, -1.10356510f, -0.26728937f, 1.10995555f, 1.27965653f, 0.01177216f, -0.38872138f, -0.05207197f, 
    -0.30479690f, -0.28925657f, -0.06975367f, -1.13922405f, 1.35813665f, -1.07644510f, 0.29869780f, 0.44032371f, 
    -0.57168436f, -1.18025255f, -0.79790229f, -0.94053996f, 0.28662983f, 0.19028670f, 0.27814469f, -0.21653187f, 
    0.31081060f, 0.38926080f, -0.80537957f, -0.14175679f, 1.00866187f, 0.53730476f, -0.82803351f, 0.34325022f, 
    0.44295341f, -0.44275016f, 0.78762400f, -0.35846326f, -0.73547459f, -0.88360631f, 0.13217929f, -0.91670859f, 
    0.72229671f, -0.90622938f, -0.45302996f, -0.36377439f, -1.08839607f, -0.81707937f, 0.49072191f, 0.59486037f, 
    0.56004524f, -0.46150333f, -0.56926572f, 0.02156603f, -0.69684321f, 0.17706966f, 0.92606038f, 0.13916820f, 
    0.97161001f, -0.22205977f, -0.96431184f, -0.74937212f, -0.19875516f, -0.07364062f, 1.17381895f, 0.98067713f, 
    0.94216835f, 1.02716899f, 0.42719153f, 0.46306062f, 0.58375472f, 0.83848816f, -0.11386006f, -0.55199832f, 
    -0.90307635f, -0.59825432f, -1.09675205f, -0.02002538f, -0.24463330f, 0.83781338f, 0.16770814f, 0.81019497f, 
    -0.39892885f, -1.00331128f, -1.23542118f, -0.29815811f, -0.54437524f, -0.80974817f, -0.34300801f, 0.25507423f, 
    -0.19487728f, 1.09146655f, -0.77759904f, 1.00503576f, 1.19908583f, 0.40659782f, 0.30452219f, -0.83595186f, 
    -0.42921892f, 0.27281076f, -0.87600821f, -0.42522138f, 0.02686884f, 1.46218300f, 1.07303655f, 0.54893744f, 
    0.07171614f, -0.30355090f, 0.28478068f, -1.14104033f, -1.29531431f, -0.85897154f, -0.47639889f, 0.04239823f, 
    0.81771404f, 0.03926854f, 0.20666450f, 0.24010216f, 1.16027451f, 1.71191359f, 0.60841966f, -0.59406066f, 
    -0.97267169f, -0.34644946f, 0.08874647f, 0.08578356f, 0.08781989f, 0.24359348f, 0.77809006f, 1.01119614f, 
    -1.02460742f, -0.26378852f, -1.09018803f, -0.29410076f, 0.37032202f, 0.05209478f, 1.07412159f, 0.70755327f, 
    -0.39213285f, -0.86679041f, 0.45158136f, 0.96327430f, -0.48209119f, 0.39775628f, 0.72141957f, 1.25729895f, 
    0.92715651f, 0.91982067f, 0.66186404f, 0.11603840f, -0.08767736f, -0.27084696f, -0.54957819f, 0.41130486f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08448743f, -0.18160596f, 0.03810876f, 0.34396794f, 0.24009463f, 0.19100773f, -0.11227936f, -0.28306696f, 
    0.13934533f, -0.08811881f, 0.04127103f, 0.23422249f, 0.27435756f, -0.28331858f, 0.08879726f, -0.09731547f, 
    -0.09282585f, -0.01339923f, -0.07926102f, -0.14429523f, -0.21793628f, 0.11850321f, 0.27323145f, 0.14671044f, 
    0.37395868f, -0.02367556f, 0.25421643f, 0.01590158f, -0.33103359f, 0.33374500f, 0.39566198f, 0.22915815f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05049197f, -0.03890315f, 0.01424243f, -0.00372067f, 0.05293596f, -0.05499341f, 0.02841986f, 0.03242998f, 
    -0.05960076f, -0.01160196f, 0.00261204f, -0.04906435f, 0.01303363f, -0.04305390f, -0.00487945f, 0.03319253f, 
    -0.00640463f, 0.03497699f, 0.04077077f, -0.02215608f, -0.05389421f, 0.02413330f, 0.02259639f, 0.02602668f, 
    -0.02962518f, 0.03127885f, -0.04393568f, 0.04597091f, -0.05098077f, -0.02800908f, -0.04862661f, -0.06293514f, 
    -0.04787075f, -0.04855396f, 0.02682895f, -0.04093757f, -0.01850477f, -0.03736885f, 0.03676572f, -0.03679758f, 
    0.00483944f, -0.01762838f, -0.03864704f, 0.04536776f, -0.05708516f, 0.04397299f, 0.02974146f, 0.03821358f, 
    -0.02699789f, 0.03331870f, 0.01343015f, 0.05401360f, -0.03449533f, 0.02616853f, -0.00709033f, 0.04553872f, 
    0.01543364f, 0.00946212f, -0.05767722f, -0.05880734f, -0.01229748f, -0.00958853f, -0.04352762f, -0.04036367f, 
    -0.06659421f, -0.01887662f, 0.02097375f, 0.04986517f, 0.04287348f, -0.05265049f, 0.05046801f, -0.04374743f, 
    0.01660901f, -0.06319346f, 0.01247646f, 0.02673722f, -0.05429014f, -0.05435039f, -0.05212769f, 0.03289642f, 
    -0.06533121f, 0.00650144f, 0.00337732f, -0.02476848f, -0.00537220f, 0.03417715f, -0.00881501f, -0.00712231f, 
    0.03824049f, 0.05206221f, -0.02411087f, -0.04382372f, -0.04599803f, -0.04533562f, -0.01552069f, -0.00044561f, 
    -0.02978335f, 0.00325718f, -0.02163753f, -0.04720506f, -0.05776852f, 0.00285744f, -0.05783435f, 0.05853414f, 
    -0.04250210f, -0.01279350f, -0.02829757f, 0.00367986f, -0.00812966f, -0.06352651f, 0.00322225f, 0.04824940f, 
    0.04520369f, -0.05392144f, 0.01596050f, -0.00453909f, 0.02913952f, -0.01814152f, 0.01813665f, 0.02559548f, 
    0.00738487f, -0.06140759f, -0.05818820f, -0.01115120f, 0.03068685f, -0.05003946f, -0.05614016f, 0.00304806f, 
    -0.02515262f, -0.02331107f, 0.00363260f, 0.04401892f, -0.04139094f, -0.01477396f, 0.04060980f, 0.02224031f, 
    0.03174065f, -0.05759252f, 0.01006103f, 0.03062891f, -0.00068095f, -0.03050378f, 0.04906623f, 0.03612777f, 
    0.04158942f, 0.04686536f, 0.04359484f, -0.00997651f, -0.00997081f, 0.00394274f, 0.00861474f, -0.01460329f, 
    0.04131296f, 0.01043891f, 0.01470287f, -0.03159307f, 0.01796836f, 0.01110688f, 0.01444001f, 0.01255345f, 
    -0.06665485f, -0.02783045f, 0.02534417f, -0.04423203f, -0.05764930f, -0.02948804f, -0.05305418f, -0.02581926f, 
    -0.01330819f, -0.05443596f, 0.02122660f, -0.05295768f, -0.06417462f, -0.03080656f, -0.05945640f, -0.04561428f, 
    -0.02002280f, -0.04482374f, -0.03729988f, 0.03096536f, -0.02992141f, 0.02549396f, 0.02689802f, 0.03538169f, 
    0.01233393f, -0.04367125f, 0.04849013f, 0.02535946f, -0.04291795f, -0.01967415f, 0.01108930f, -0.02588364f, 
    -0.03444888f, 0.03896395f, -0.05641599f, -0.03058314f, 0.01230500f, 0.03622765f, 0.02769331f, 0.05066459f, 
    -0.04224733f, -0.02643388f, -0.01228200f, -0.03653516f, -0.03627307f, -0.06198881f, 0.04749877f, -0.06209742f, 
    -0.05542382f, 0.01331628f, 0.05080178f, -0.02114492f, 0.01464560f, -0.05619168f, -0.06189822f, 0.00459975f, 
    -0.03171840f, 0.03566188f, -0.00881054f, 0.04946681f, -0.01351845f, -0.04811924f, 0.03575685f, -0.02980338f, 
    0.01734911f, -0.04851919f, -0.00444542f, -0.05750954f, -0.06908108f, -0.00552468f, 0.03100715f, -0.03849396f, 
    -0.04448941f, -0.01621055f, -0.00617765f, 0.03405554f, 0.01983295f, -0.06443205f, -0.04676588f, -0.02108070f, 
    -0.04178387f, 0.02196367f, -0.05639662f, 0.03743426f, 0.01869525f, -0.00673258f, 0.04384233f, -0.00545950f, 
    -0.00831772f, -0.05615184f, 0.00087978f, 0.04647117f, 0.00565727f, 0.02956479f, 0.03497321f, -0.05945912f, 
    -0.04119099f, -0.04018028f, 0.02368595f, -0.01007715f, 0.00972357f, -0.02617182f, -0.00521647f, -0.03474174f, 
    -0.00072765f, 0.02580166f, 0.03018249f, -0.00826262f, -0.01060888f, 0.01372770f, -0.03833618f, -0.01359148f, 
    -0.01986074f, -0.03521721f, -0.01533398f, -0.06401832f, -0.03887088f, -0.01584252f, -0.00874216f, -0.00915952f, 
    -0.00322289f, -0.03172359f, 0.02026866f, 0.00572759f, -0.02507052f, 0.03774228f, 0.01767606f, 0.05269876f, 
    -0.04007431f, 0.10171689f, -0.23411292f, 0.03229095f, -0.21918230f, -0.35442773f, 0.12452657f, 0.16674392f, 
    0.00670327f, 0.23829648f, -0.08259794f, -0.19449717f, -0.09558369f, -0.03670673f, 0.03579327f, -0.01263899f, 
    -0.07393599f, 0.12172492f, -0.70205265f, 0.12205137f, -0.11176309f, 0.01743590f, 0.09399641f, 0.25216156f, 
    -0.13392767f, 0.06692208f, -0.06252323f, -0.31431347f, 0.15299094f, 0.16250221f, -0.02397934f, -0.30264622f, 
    0.35857722f, 0.36320326f, -0.18497314f, 0.04697022f, 0.32935920f, 0.02318331f, 0.07597663f, 0.16069613f, 
    0.14453492f, 0.17857298f, 0.06659257f, 0.03697671f, 0.18513250f, -0.54526609f, -0.77948791f, -0.13733310f, 
    0.02938088f, -0.10054250f, 0.01549433f, 0.18284240f, 0.19290636f, 0.01741650f, 0.05412818f, -0.09873803f, 
    0.04677282f, 0.00575112f, -0.05019257f, 0.17547533f, 0.13476090f, 0.13713115f, -0.08810148f, 0.08939115f, 
    0.35847163f, -0.00573377f, 0.12804759f, -0.25955918f, 0.14093700f, -0.09068143f, -0.00479596f, -0.07897110f, 
    0.12690736f, -0.01366593f, 0.10572447f, 0.15848061f, 0.08514719f, 0.12009586f, -0.00614967f, -0.08746605f, 
    0.12661001f, 0.16721720f, -0.14687100f, 0.04909253f, 0.01396656f, 0.11560300f, 0.01865476f, 0.10473511f, 
    -0.01186383f, -0.01169790f, -0.01182661f, -0.43907461f, 0.15260069f, -0.14196771f, -0.11590335f, -0.00849456f, 
    0.16111794f, -0.05760951f, 0.05012290f, 0.08295156f, 0.21657999f, -0.28266081f, 0.09731829f, -0.07859279f, 
    0.21824354f, -0.05518459f, -0.04896970f, 0.34224352f, 0.26173416f, -0.49040702f, -0.15384281f, -0.01716099f, 
    -0.00008283f, 0.25227386f, -0.05183043f, -0.23939691f, -0.22696437f, -0.07089585f, -0.54448003f, -0.11457178f, 
    -0.14242201f, 0.08804100f, -0.23213796f, -0.06439123f, 0.00771816f, 0.16305588f, -0.10717524f, 0.09659316f, 
    -0.35657847f, 0.01846627f, -0.00039553f, -0.02785271f, -0.00625551f, -0.23444088f, -0.22414148f, 0.29163373f, 
    0.17214465f, -0.17905602f, 0.08297221f, -0.09021734f, -0.06457604f, 0.02512256f, 0.06496429f, 0.02854663f, 
    0.14335102f, -0.20363596f, -0.46773994f, -0.04398807f, 0.10366843f, 0.17127299f, 0.02141427f, 0.00931543f, 
    -0.21253216f, 0.02207640f, 0.37466058f, -0.12500606f, -0.21545257f, 0.00778790f, -0.03210078f, -0.13136977f, 
    0.13613552f, -0.12090831f, -0.00724039f, 0.17812677f, 0.29849982f, 0.05890463f, 0.21917094f, 0.11328428f, 
    0.05604351f, 0.11542065f, -0.05836283f, -0.19356677f, -0.19018063f, -0.25116721f, -0.07330590f, 0.21458659f, 
    -0.18216562f, -0.29258829f, -0.14088629f, -0.07710240f, 0.35462752f, -0.36007413f, -0.14278860f, -0.02289085f, 
    -0.05904392f, 0.00649312f, -0.18823965f, 0.12618600f, -0.16012000f, -0.04446921f, -0.22035794f, 0.05175077f, 
    -0.01823929f, 0.15474340f, -0.09233186f, -0.25846282f, 0.02311631f, 0.08092532f, 0.12998688f, 0.09943369f, 
    0.32535282f, 0.05337387f, 0.14420918f, -0.07102825f, -0.04483194f, 0.03760900f, 0.21832426f, 0.40646118f, 
    0.06943953f, 0.06103230f, -0.21173054f, 0.07844661f, 0.12468116f, 0.07346708f, 0.04354649f, -0.20382248f, 
    0.06916814f, 0.02308486f, -0.48474962f, 0.17168735f, 0.17615418f, 0.06434647f, -0.13742559f, -0.02552603f, 
    -0.05935479f, -0.55025434f, 0.05441280f, 0.11425973f, -0.00620548f, -0.15142672f, -0.14570110f, 0.05630193f, 
    -0.12912127f, 0.06639296f, -0.13907780f, 0.19809325f, -0.14718214f, -0.18163030f, -0.06255500f, -0.12510982f, 
    -0.03645459f, -0.12655012f, 0.06976014f, 0.33527070f, 0.13427241f, 0.02715125f, 0.28561255f, 0.08964205f, 
    0.16420436f, -0.06603709f, 0.02328355f, 0.02059323f, 0.33282131f, 0.12692638f, -0.17090458f, 0.08498332f, 
    0.05057938f, 0.10683770f, -0.11628033f, -0.13163438f, -0.01505893f, 0.19905634f, 0.12721895f, -0.34484801f, 
    0.16556279f, 0.01339316f, 0.03372058f, 0.01594567f, -0.08559830f, 0.01368453f, 0.08516603f, 0.21881926f, 
    0.12705174f, 0.14741188f, -0.03752268f, -0.09554970f, -0.08043516f, 0.12378278f, 0.38102093f, 0.04365880f, 
    0.07429022f, 0.16898206f, 0.06699452f, -0.10457488f, -0.03595879f, -0.03939230f, 0.00722989f, 0.02241686f, 
    -0.66578221f, 0.01815540f, -0.23725292f, 0.15804674f, 0.01362735f, -0.18303768f, 0.12908964f, -0.07126729f, 
    -0.29248103f, -0.26208943f, 0.03561368f, 0.14011993f, 0.11581719f, 0.06081407f, -0.13350330f, -0.24594672f, 
    -0.02766226f, 0.18334122f, 0.03475351f, 0.03139067f, 0.42595905f, 0.11095172f, -0.03387461f, -0.01602859f, 
    0.00623733f, 0.21721789f, -0.08964601f, 0.13380840f, -0.06255031f, 0.10071836f, 0.13479592f, -0.00323739f, 
    -0.07249653f, 0.07577044f, 0.21399227f, 0.03451241f, -0.95592624f, -0.23202649f, 0.02474860f, 0.06720635f, 
    0.14186783f, -0.21336311f, 0.06355102f, -0.01721133f, -0.07953888f, 0.01011901f, -0.21179636f, 0.01700533f, 
    -0.05801471f, -0.24208719f, 0.12185407f, -0.12719810f, 0.09839931f, -0.09698781f, -0.17708865f, 0.04182626f, 
    -0.06723665f, 0.06092091f, 0.19857606f, 0.07011841f, 0.14847402f, -0.05194274f, 0.16274919f, -0.99973100f, 
    -0.17307223f, 0.24593005f, 0.03000825f, 0.15047757f, 0.08125704f, 0.04644395f, -0.07268590f, 0.23114410f, 
    0.45823818f, 0.26735359f, -0.12353971f, -0.21482432f, 0.03646968f, -0.06840651f, 0.01029076f, 0.33531758f, 
    0.19864142f, 0.09443582f, 0.10654926f, -0.11329141f, 0.02867029f, -0.52067733f, 0.07428414f, -0.12190813f, 
    0.11313150f, 0.11450008f, -0.02137970f, 0.24342091f, -0.21682772f, -0.15943882f, 0.17045721f, 0.23573983f, 
    0.07311860f, 0.13784124f, 0.04152165f, -0.35355872f, -0.08962723f, 0.08362605f, 0.22335234f, 0.16385713f, 
    0.10320972f, 0.03971854f, 0.11805066f, -0.03757313f, 0.32440251f, 0.21890201f, -0.07726733f, 0.17185985f, 
    0.14526373f, -0.07819334f, 0.04603747f, 0.08946191f, -0.26115489f, -0.38787672f, 0.04020587f, -0.15498240f, 
    0.10406689f, 0.01728469f, 0.08874554f, 0.15126139f, 0.02973366f, -0.08532128f, 0.24323033f, 0.16757497f, 
    -0.08661322f, -0.01602720f, -0.17472491f, -0.00846461f, 0.06210081f, 0.09628213f, -0.02861638f, 0.32027081f, 
    -0.10604388f, 0.08587284f, -0.04134213f, -0.06274904f, 0.01546056f, -0.01309064f, 0.28110340f, -0.10601511f, 
    -0.06851695f, 0.05293416f, -0.10284474f, 0.02050101f, 0.05418241f, 0.22947374f, 0.08819763f, 0.04212075f, 
    -0.21124566f, 0.05447160f, 0.12043579f, 0.08137602f, -0.14874519f, -0.12500398f, 0.13229269f, 0.00886008f, 
    -0.03150862f, 0.15076658f, -0.28670543f, 0.06403919f, -0.14779778f, 0.09518120f, -0.07830296f, 0.03856606f, 
    -0.11392216f, -0.04218677f, 0.18636993f, -0.13487899f, -0.15611480f, 0.36457834f, 0.19592054f, 0.06732870f, 
    0.00820722f, -0.12652110f, -0.07021609f, -0.10635396f, 0.01076469f, 0.08050548f, -0.21270360f, 0.02739917f, 
    -0.11209229f, 0.01439283f, 0.12530167f, 0.01625440f, -0.21056524f, 0.10629496f, 0.18742968f, -0.25406283f, 
    0.12164619f, 0.16447222f, 0.06851822f, 0.14901634f, 0.08405204f, 0.06305283f, -0.91921926f, -0.40247020f, 
    -0.33670840f, 0.05489998f, -0.11706903f, -0.13735135f, 0.23742881f, 0.13948616f, 0.13302796f, -0.08546750f, 
    0.12536222f, 0.00955670f, 0.01806864f, 0.20687269f, 0.00996561f, -0.12010073f, -0.00601661f, 0.09248540f, 
    0.05048895f, -0.15017432f, -0.00554174f, 0.20549567f, -0.06788008f, 0.15282859f, -0.20942000f, 0.06244259f, 
    0.23925430f, -0.44804356f, -0.09271795f, -0.28472641f, 0.05228165f, 0.22757654f, 0.02143961f, 0.19396649f, 
    -0.00845732f, -0.01826414f, 0.31250271f, 0.27998829f, -0.21258722f, -0.03913771f, 0.05319727f, 0.28091758f, 
    0.13560610f, 0.15606640f, -0.10194727f, -0.09065761f, 0.07157713f, -0.01906595f, 0.05519477f, 0.03826138f, 
    -0.16220006f, 0.04616691f, 0.07921098f, 0.16333471f, -0.69561207f, 0.19624883f, -0.13357265f, 0.25166014f, 
    0.06147622f, -0.07866070f, -0.16365933f, -0.08938143f, 0.10855380f, 0.29493868f, 0.21621603f, 0.24370687f, 
    0.14190502f, 0.07212952f, 0.13988276f, -0.25937492f, -0.10607665f, 0.09569335f, -0.36500582f, -0.33087638f, 
    -0.32387277f, -0.07248881f, 0.12770610f, -0.12206086f, 0.31013656f, 0.17732073f, 0.03200715f, -0.90260595f, 
    -0.48720172f, -0.39108652f, 0.03919590f, 0.16382445f, 0.09085832f, 0.02918886f, -0.08033130f, -0.11659129f, 
    -0.29180527f, 0.17189825f, 0.11875688f, 0.18564755f, -0.12041713f, 0.30527961f, -0.06902537f, -0.15602165f, 
    -0.37901658f, -0.11863366f, 0.22324747f, 0.14404419f, -0.08757761f, -0.24715103f, 0.03862378f, -0.24173927f, 
    0.07883692f, -0.25459823f, 0.53088140f, 0.13966428f, -0.01755394f, -0.13399428f, -0.09186060f, -0.39264640f, 
    0.05101131f, 0.14787129f, 0.25852993f, 0.13212995f, -0.16974069f, -0.13967872f, -0.16193497f, 0.24514037f, 
    0.02107690f, -0.13347423f, -0.14120971f, -0.39198428f, -0.00793976f, 0.21432202f, 0.11468241f, -0.10669346f, 
    -0.08925162f, -0.02314164f, -0.10118481f, -0.12257959f, 0.04281340f, 0.23691513f, 0.29649073f, 0.27608496f, 
    -0.08671622f, -0.06891075f, -0.03529251f, -0.08900451f, 0.22641332f, 0.15055436f, -0.07509375f, -0.01894102f, 
    0.06284227f, -0.29461265f, 0.02448664f, 0.01283801f, 0.06703064f, -0.19445434f, 0.13935915f, 0.03070376f, 
    0.01608112f, 0.03148666f, -0.15188509f, -0.02121410f, -0.14314760f, 0.03940377f, -0.14894229f, 0.22303247f, 
    -0.08396081f, -0.04956634f, 0.06293932f, 0.25685769f, 0.20843579f, -0.39228103f, 0.05891353f, -0.07913591f, 
    -0.10999265f, 0.27307618f, -0.18610500f, 0.20567830f, 0.17849898f, 0.13304088f, -0.05239069f, 0.01386585f, 
    -0.23393369f, -0.11800712f, -0.30706233f, 0.19822681f, -0.06603442f, 0.32335833f, 0.14595768f, -0.05212279f, 
    -0.28163877f, -0.10855740f, -0.08564000f, -0.20036805f, -0.01519108f, -0.03784393f, 0.07404087f, 0.28776923f, 
    -0.01053989f, -0.00353033f, -0.22249287f, 0.11440545f, 0.44667074f, 0.19381861f, 0.10063757f, -0.00284769f, 
    -0.09951822f, 0.22657977f, 0.16122808f, 0.09702640f, -0.03221451f, 0.37138599f, -0.35923979f, 0.03028287f, 
    -0.07245628f, -0.08410489f, 0.06463851f, -0.07660151f, 0.13392626f, -0.21228856f, 0.04335922f, -0.04180923f, 
    0.04753479f, -0.20380320f, 0.03610089f, 0.16253679f, 0.04370128f, 0.10743497f, 0.25434643f, -0.36460131f, 
    0.11812842f, 0.21105784f, 0.07218761f, 0.15198834f, 0.42667323f, 0.04356545f, -0.21594091f, -0.00910137f, 
    -0.01279459f, 0.27276850f, 0.09407423f, -0.39597347f, -0.03719699f, -0.23411360f, -0.00503496f, 0.34047151f, 
    0.12511785f, 0.06335038f, -0.19551618f, 0.13169199f, 0.05873698f, 0.07743815f, -0.01226959f, -0.01612859f, 
    -0.16970105f, 0.22849704f, -0.05529066f, -0.05774744f, -0.12563454f, -0.10989104f, 0.14102380f, 0.11636914f, 
    0.11345553f, 0.04996233f, -0.16776963f, -0.04853354f, 0.01981504f, 0.05194805f, -0.52797526f, 0.03673214f, 
    -0.18942536f, -0.33168343f, 0.33984464f, 0.24654415f, -0.15126930f, -0.14612308f, 0.09964253f, 0.00604445f, 
    -0.20129463f, 0.10522524f, 0.17397605f, -0.12577474f, 0.13386536f, 0.43827090f, -0.10511895f, -0.17257179f, 
    0.10013261f, -0.12492857f, 0.10399348f, 0.05909757f, 0.26491275f, -0.14359947f, -0.42148846f, -0.16217469f, 
    0.10902181f, 0.11955065f, 0.31554973f, 0.16445717f, -0.06050296f, -0.20737414f, -0.15846224f, -0.02750165f, 
    0.03692579f, -0.13442431f, -0.05035041f, 0.11369286f, -0.24456611f, 0.13358463f, -0.25450325f, -0.07137325f, 
    -0.05324699f, -0.11316917f, -0.06124584f, -0.03285499f, -0.00745900f, -0.13301119f, 0.00662969f, 0.00536334f, 
    0.24188346f, -0.40112111f, 0.09964230f, -0.11228339f, 0.06647898f, -0.08511580f, 0.20604388f, -0.23221365f, 
    0.19732472f, -0.32174110f, -0.23191197f, -0.17519388f, 0.07603016f, 0.22454382f, -0.02908257f, 0.17014870f, 
    -0.26953590f, 0.05453790f, 0.02450510f, 0.17287076f, -0.13722882f, -0.15296970f, -0.02877596f, 0.00080070f, 
    -0.17297786f, 0.12451313f, -0.14556257f, -0.11988994f, -0.11829490f, 0.03221961f, 0.13206211f, 0.05867711f, 
    0.24396627f, -0.07480502f, 0.16651249f, 0.01800782f, 0.21093032f, 0.08003184f, -0.03921486f, 0.07354297f, 
    0.05288003f, 0.04987291f, -0.19785191f, -0.07800336f, -0.07752003f, -0.10555045f, -0.13201326f, 0.21570657f, 
    -0.15640473f, -0.24944879f, 0.10230506f, 0.25709701f, 0.10002407f, 0.16397502f, -0.44355077f, 0.05259628f, 
    0.19984503f, -0.11203007f, 0.26227948f, 0.04314141f, 0.16199325f, 0.07109673f, 0.02888347f, 0.19983672f, 
    0.03258539f, -0.04962870f, 0.03597979f, -0.00668961f, -0.04124280f, 0.02874985f, -0.02239809f, -0.05539173f, 
    0.00107701f, -0.01791218f, -0.00876131f, -0.02861995f, 0.01345354f, 0.00951728f, -0.02017805f, 0.01715892f, 
    -0.05147454f, -0.02111956f, -0.06141067f, 0.00308925f, -0.05532427f, -0.05600173f, 0.00100547f, 0.04571288f, 
    -0.05039354f, -0.01894666f, -0.06521235f, -0.01520543f, 0.03256905f, 0.01465687f, 0.05098167f, -0.00066430f, 
    0.03234671f, -0.02959046f, 0.04840872f, -0.05950249f, -0.00655581f, 0.03700957f, -0.00166502f, 0.03408472f, 
    -0.05006853f, 0.01390243f, 0.05045241f, -0.02364600f, 0.04748525f, -0.04041984f, -0.01736081f, -0.00051703f, 
    0.03953689f, -0.04211226f, 0.00042947f, -0.06065436f, 0.03059996f, -0.02985774f, -0.02026177f, 0.05238308f, 
    -0.00397995f, -0.00809576f, -0.01645242f, 0.01168437f, 0.01050977f, 0.04584654f, -0.06473101f, 0.00057992f, 
    -0.01961548f, 0.03856698f, 0.03981128f, -0.03509136f, -0.04571079f, -0.01393117f, 0.04246632f, -0.02066294f, 
    0.03761449f, -0.01567045f, 0.04012755f, -0.05980765f, -0.01781793f, 0.03028740f, -0.02910092f, 0.01036434f, 
    0.03825722f, 0.02135467f, -0.03230973f, 0.00869537f, -0.03790796f, -0.01018790f, -0.04706963f, -0.03375742f, 
    0.04961408f, 0.03160942f, 0.01859528f, -0.03076550f, 0.04297978f, 0.02256431f, -0.03801120f, 0.00624599f, 
    0.00335021f, -0.00292746f, -0.03766573f, 0.05111769f, -0.01096252f, -0.05219638f, -0.00008490f, -0.05859605f, 
    -0.04667327f, -0.02904008f, -0.01392722f, 0.01240621f, 0.02212384f, -0.00710574f, -0.00271150f, -0.03904215f, 
    -0.02128513f, -0.06329715f, 0.02275978f, -0.03522400f, 0.03921489f, -0.05535798f, -0.04982360f, 0.04391292f, 
    -0.01780056f, 0.04746100f, 0.02448613f, -0.03617958f, 0.00582562f, 0.04087926f, 0.04257829f, 0.01280243f, 
    0.01389130f, -0.01519512f, 0.03105619f, -0.01424358f, 0.00953906f, -0.06483888f, -0.00695779f, 0.02389503f, 
    0.04127796f, -0.03316603f, -0.00183355f, 0.04169665f, -0.02388845f, -0.01251842f, -0.02400135f, 0.00959457f, 
    -0.03834704f, -0.00043282f, 0.03504249f, -0.05653962f, 0.02109162f, -0.00965222f, 0.03951777f, 0.00898016f, 
    0.00799575f, -0.03816857f, 0.03517977f, -0.00301389f, -0.01438656f, -0.06299304f, 0.00699041f, -0.00558791f, 
    -0.00535503f, -0.06527515f, -0.04615086f, -0.03136258f, 0.03949345f, -0.02843801f, 0.02086959f, 0.00939970f, 
    -0.05481026f, -0.05358111f, 0.03592618f, -0.01793769f, -0.01071020f, -0.00380989f, 0.04430951f, 0.02425147f, 
    0.04256295f, -0.01045812f, 0.01168901f, 0.01610607f, -0.01394053f, -0.02458626f, -0.05383481f, -0.00455009f, 
    0.01315787f, 0.00345014f, -0.01648272f, -0.04347815f, 0.02390941f, 0.02116750f, 0.02611975f, 0.03343517f, 
    0.00237538f, -0.00605310f, 0.04876011f, 0.01964647f, -0.05612213f, -0.06184242f, -0.04836730f, 0.01229494f, 
    -0.00404814f, 0.05112490f, -0.05719440f, -0.04726826f, -0.05605563f, -0.01426484f, -0.01437039f, 0.03587357f, 
    0.03565114f, -0.05496234f, 0.03885456f, -0.05516526f, -0.01822676f, 0.00143150f, 0.04871392f, 0.03077329f, 
    0.01376573f, -0.03955608f, 0.00223291f, 0.00129701f, -0.03768286f, -0.00094310f, -0.06210081f, -0.03976744f, 
    0.04600512f, -0.01790762f, -0.04134274f, 0.03163238f, -0.06021214f, -0.03165632f, -0.02091105f, 0.03816042f, 
    -0.05004279f, 0.01071606f, 0.00644626f, -0.05082295f, 0.01190308f, 0.02777171f, -0.00550934f, 0.01492381f, 
    0.02730076f, -0.04861997f, -0.06348995f, 0.04733526f, -0.04546812f, -0.05866677f, 0.00212472f, 0.00222068f, 
    -0.02467838f, -0.06361827f, -0.03381899f, -0.05891274f, -0.05590660f, 0.02904024f, -0.06209256f, -0.05161854f, 
    -0.03641737f, -0.02188879f, 0.01701767f, -0.04548156f, -0.05077809f, 0.00081028f, -0.04383842f, 0.05114768f, 
    -0.02112363f, -0.03136984f, 0.03389670f, 0.02130768f, -0.06439020f, -0.02354086f, -0.05318695f, -0.01951976f, 
    -0.05561402f, 0.00820960f, -0.04564191f, -0.01936468f, -0.02501817f, -0.03060005f, -0.00818464f, -0.01557102f, 
    0.03482512f, -0.00282433f, -0.05423146f, -0.02131709f, 0.02634920f, -0.05468806f, -0.05871116f, -0.03002419f, 
    -0.02276926f, -0.07644337f, -0.00944677f, -0.06351877f, -0.01283216f, -0.06462299f, -0.02113221f, -0.06406482f, 
    0.01334072f, 0.01400155f, -0.00127870f, -0.03691709f, 0.00747173f, -0.01321014f, 0.04755316f, -0.05490502f, 
    -0.00340140f, 0.00378989f, -0.03556196f, -0.00407830f, 0.05660984f, 0.02051011f, 0.03541422f, -0.04385695f, 
    -0.03301410f, -0.05946936f, -0.01435090f, -0.00776801f, 0.02120490f, 0.00868193f, -0.04431229f, -0.03486818f, 
    -0.03912155f, -0.00409168f, 0.00517695f, 0.02583234f, -0.01262808f, -0.03763818f, -0.07352139f, -0.02098563f, 
    -0.02715168f, -0.05875343f, -0.05589066f, 0.03442205f, -0.00073224f, -0.01627306f, -0.03090676f, 0.03400947f, 
    -0.06592103f, -0.01702808f, 0.01846155f, 0.01250901f, -0.06475106f, -0.05414062f, -0.02004920f, 0.00878373f, 
    -0.04578761f, 0.04179645f, -0.01399988f, 0.00044286f, -0.03112832f, 0.00037818f, 0.02666125f, 0.05299715f, 
    -0.01341659f, -0.05128571f, -0.01687402f, 0.01154215f, -0.03230211f, 0.04277790f, -0.08841156f, -0.04703702f, 
    0.03796927f, -0.05096497f, 0.02113333f, -0.01621574f, -0.04703969f, -0.01979725f, -0.04890953f, 0.05279078f, 
    -0.01832313f, -0.00359206f, -0.03124359f, -0.00431481f, -0.04034417f, -0.05591216f, -0.03591718f, -0.03380926f, 
    0.00700432f, 0.01617881f, -0.02471749f, 0.04476847f, -0.02554988f, 0.03065321f, 0.01630457f, -0.06693330f, 
    0.01700424f, -0.04741694f, -0.06646276f, -0.02521244f, -0.01222855f, 0.01573510f, -0.04633828f, -0.03643879f, 
    -0.02648801f, 0.01260332f, -0.03133047f, -0.06090892f, -0.02601508f, 0.00785262f, 0.01233575f, 0.04855912f, 
    -0.04237470f, -0.00047068f, -0.03309502f, -0.01924435f, 0.01333730f, 0.02765949f, 0.02407205f, -0.06379645f, 
    -0.06318793f, -0.05043636f, -0.07202996f, 0.01395688f, 0.01341936f, 0.01949664f, -0.03300892f, -0.04443244f, 
    0.01679333f, 0.04138883f, -0.04271699f, -0.06062761f, 0.03653104f, 0.03392221f, 0.02256477f, 0.00805738f, 
    -0.05644093f, -0.07196471f, 0.04061554f, 0.04066619f, 0.01868141f, 0.00383135f, -0.05674755f, 0.01424489f, 
    -0.02209963f, -0.02884491f, -0.01736582f, -0.04749857f, -0.03049881f, 0.01369702f, -0.05366180f, 0.04310127f, 
    -0.03366787f, 0.02974354f, 0.03138391f, -0.01336032f, 0.04757172f, 0.03962357f, 0.01677792f, -0.03914126f, 
    0.05467795f, 0.03987374f, -0.03083915f, 0.01504926f, -0.05048222f, -0.00078819f, -0.00018147f, 0.01766226f, 
    0.02640149f, -0.04393106f, -0.03437696f, 0.04881937f, 0.04294840f, -0.01508434f, -0.06346731f, 0.05001987f, 
    -0.03424869f, -0.04475050f, 0.03521641f, 0.03460854f, -0.01383032f, -0.01599736f, -0.04453260f, -0.02663423f, 
    -0.02766240f, 0.00296043f, 0.00867151f, -0.03122886f, -0.01851108f, -0.03583085f, -0.03656220f, 0.04182637f, 
    0.03508697f, 0.02991262f, -0.07599458f, -0.03427126f, 0.00819498f, 0.01784173f, -0.02767342f, 0.00333270f, 
    -0.02095136f, -0.07190645f, -0.06283806f, 0.00897348f, 0.01772098f, 0.02292424f, -0.03669407f, 0.03603797f, 
    -0.06412035f, 0.04857373f, -0.05681000f, -0.04073723f, 0.01363245f, -0.05551981f, -0.04106797f, 0.02618055f, 
    -0.06399691f, 0.04181453f, -0.02980930f, -0.00147460f, 0.00877975f, -0.06952883f, 0.01296108f, -0.00429258f, 
    -0.01196995f, -0.03189847f, -0.01756641f, -0.02900396f, 0.01769143f, -0.04578685f, -0.04264909f, -0.02444510f, 
    0.01733346f, 0.04698985f, -0.05892142f, 0.02945417f, -0.00511854f, -0.03249448f, -0.00638137f, -0.03596348f, 
    -0.01646961f, 0.00941565f, -0.04681757f, -0.03273855f, -0.03531979f, -0.01755205f, 0.07554325f, -0.00267454f, 
    -0.05870510f, 0.02413323f, -0.03086094f, -0.06148521f, -0.01151070f, -0.00482740f, -0.03580210f, -0.02727865f, 
    -0.04676452f, 0.02974624f, 0.01800540f, -0.06213025f, -0.03946760f, 0.03252560f, -0.03970389f, -0.04613486f, 
    0.00538789f, -0.04654475f, 0.01587863f, -0.02330971f, -0.05444065f, 0.00359642f, 0.04501667f, 0.01724086f, 
    -0.07906260f, -0.02678971f, -0.02690820f, -0.03878674f, -0.00958916f, -0.05147104f, 0.02453172f, -0.02494581f, 
    0.00772966f, -0.06454573f, -0.04371567f, 0.00200647f, -0.04765144f, -0.03696440f, -0.05245554f, -0.06086128f, 
    0.02343629f, 0.02324037f, -0.03828894f, -0.00893159f, -0.02997239f, 0.05260075f, -0.03544146f, -0.05073901f, 
    0.02091039f, 0.01209305f, 0.02206798f, -0.04170807f, -0.02488637f, 0.01250702f, 0.00844427f, 0.02785235f, 
    -0.03366411f, -0.01086458f, 0.03364145f, 0.01611678f, -0.02682801f, -0.04588995f, -0.00889374f, -0.03765721f, 
    0.00547520f, -0.04299475f, 0.03308712f, -0.00820490f, -0.00243147f, 0.00321238f, -0.03551478f, -0.02691371f, 
    -0.00641279f, -0.03454197f, -0.05573286f, -0.03899109f, -0.02350160f, 0.03834669f, 0.04039874f, -0.02665542f, 
    0.00351699f, -0.05739629f, -0.01300855f, -0.02459542f, -0.00345817f, -0.02100347f, 0.05102870f, -0.00761328f, 
    -0.03954838f, -0.00404557f, -0.02993668f, 0.01951375f, -0.01019434f, -0.00987607f, 0.03284899f, -0.00907043f, 
    -0.04590223f, -0.05977281f, 0.04386957f, 0.05431915f, 0.00401944f, -0.01732497f, -0.05762076f, -0.00561710f, 
    -0.06009507f, -0.00863043f, 0.02729055f, 0.03565352f, -0.05661591f, -0.06708841f, -0.04353791f, 0.04420112f, 
    0.05301121f, 0.02931385f, -0.03348197f, 0.01265899f, -0.05114865f, -0.01538575f, -0.03498245f, -0.06408296f, 
    -0.03207463f, 0.00721837f, -0.02806664f, 0.02443781f, -0.01393928f, -0.04599041f, -0.00934610f, 0.00944429f, 
    -0.01257458f, -0.03490566f, -0.04996714f, -0.05714625f, 0.00755519f, 0.04171460f, -0.00330795f, -0.05424885f, 
    0.00815661f, -0.00448754f, 0.01364154f, 0.03229675f, 0.02915903f, 0.02493905f, -0.03272530f, 0.00173197f, 
    -0.05186903f, -0.02005941f, -0.01870788f, -0.05887733f, -0.02633040f, 0.04593172f, -0.02592432f, 0.02206171f, 
    0.01476680f, -0.01734917f, -0.01854186f, 0.04434870f, 0.02860433f, 0.03624926f, 0.01438333f, 0.00268503f, 
    0.00784366f, -0.00471502f, 0.01791296f, -0.00735355f, 0.02937354f, 0.00852148f, -0.01125363f, -0.03476569f, 
    -0.00350551f, 0.04434796f, 0.03651047f, 0.04100978f, -0.02469910f, -0.03874663f, 0.00513463f, 0.02595071f, 
    -0.04564051f, 0.00412354f, 0.02381551f, -0.05933945f, -0.01484105f, 0.01761890f, -0.00448931f, 0.00909502f, 
    -0.03288217f, -0.03377250f, -0.05443105f, -0.03863105f, -0.01371307f, -0.01417851f, -0.00527400f, 0.01526325f, 
    0.05839396f, -0.03417363f, -0.02011162f, -0.01461972f, 0.05443896f, -0.05140453f, -0.01797092f, -0.03338169f, 
    0.05162640f, -0.00707282f, -0.03723801f, 0.03477462f, -0.00246651f, -0.02645447f, 0.05065341f, -0.05576209f, 
    0.01898720f, 0.00910647f, -0.04567394f, -0.05283383f, 0.05802384f, 0.01130046f, 0.02187047f, -0.03939781f, 
    -0.05608954f, -0.02211727f, 0.03359018f, -0.05714955f, -0.03303891f, -0.05089115f, -0.01675942f, -0.04742322f, 
    -0.04794184f, 0.02693316f, 0.00425105f, 0.04370781f, 0.00639479f, -0.03570723f, -0.00258917f, -0.04500105f, 
    -0.05914247f, -0.03125943f, -0.02298944f, -0.05718385f, -0.04521108f, 0.01158976f, -0.05256176f, 0.00847291f, 
    0.02823074f, 0.00435505f, -0.04875849f, 0.05362812f, 0.04950050f, -0.00476252f, 0.00579154f, -0.06063699f, 
    -0.00452592f, -0.03546155f, -0.02890465f, 0.01742592f, -0.05402784f, -0.02715580f, -0.00427268f, 0.03809753f, 
    0.02331743f, 0.01294374f, 0.02090619f, -0.03349931f, 0.01248037f, 0.00839890f, 0.02515640f, -0.04205077f, 
    -0.02433705f, 0.05221275f, 0.03080374f, 0.03311262f, 0.01786309f, -0.06080877f, -0.05666811f, 0.05108065f, 
    -0.04947481f, 0.00499565f, 0.02250283f, -0.04532445f, -0.05708020f, 0.01807542f, 0.02426550f, 0.02385498f, 
    0.02658194f, -0.03148962f, -0.05725521f, -0.00747647f, -0.00765375f, -0.05170608f, 0.04446238f, 0.06137820f, 
    0.00582546f, -0.04138788f, -0.00652483f, -0.05208577f, 0.00633511f, -0.04060512f, -0.04539476f, 0.01945808f, 
    0.03057170f, -0.02854893f, -0.04728049f, 0.02198744f, -0.02814828f, 0.00713194f, -0.03340695f, 0.00236981f, 
    -0.04615870f, 0.03837454f, -0.01975957f, 0.02821395f, -0.03435309f, 0.01797652f, -0.06749645f, 0.02341660f, 
    0.03201959f, -0.03325520f, 0.00882159f, 0.03486031f, -0.02472293f, -0.01046255f, -0.01141159f, -0.02523637f, 
    -0.00759180f, 0.04299949f, 0.01824605f, 0.04593104f, 0.02865277f, 0.03993699f, -0.05694754f, -0.02364165f, 
    -0.31931454f, -0.08351568f, -0.26675093f, 0.05131263f, -0.01085060f, 0.06258275f, -0.22646259f, 0.06954346f, 
    0.09218913f, 0.00509547f, 0.17491764f, -0.09504167f, -0.06528059f, 0.26232669f, 0.17313083f, 0.19720082f, 
    -0.18920693f, -0.23119183f, 0.15998463f, -0.04836280f, -0.33446816f, 0.06836443f, -0.37358755f, 0.22459021f, 
    -0.05817121f, 0.14451858f, -0.00919683f, -0.38985154f, -0.29070368f, -0.20093441f, 0.22271109f, 0.04606849f, 
    0.15569903f, 0.09103363f, 0.05659160f, -0.22829890f, -0.01633400f, 0.45211628f, -0.02805159f, 0.11774489f, 
    0.14184736f, -0.06544888f, -0.00982456f, 0.21439943f, -0.13575567f, -0.03194447f, 0.17457648f, 0.09171569f, 
    -0.03295053f, -0.09214018f, -0.18148392f, 0.00500652f, 0.22687900f, 0.05903653f, 0.12762970f, 0.12012929f, 
    0.28878289f, -0.11901779f, 0.02213253f, 0.09977014f, 0.15726672f, 0.17549641f, -0.15582696f, 0.15072845f, 
    0.01857173f, -0.17421921f, -0.13825010f, 0.00876715f, 0.02304722f, 0.00387499f, -0.11989639f, 0.10140830f, 
    -0.03000271f, 0.04481924f, -0.36988932f, -0.22364452f, -0.04828386f, 0.11904575f, 0.21049254f, 0.25289327f, 
    -0.26272440f, 0.19905362f, -0.06308789f, -0.25080127f, -0.17196110f, 0.00426462f, 0.11929220f, -0.08129243f, 
    0.21446428f, -0.21424064f, -0.21233122f, -0.09794200f, 0.01897914f, 0.28561011f, 0.15365073f, 0.07093839f, 
    0.03435550f, 0.02782663f, -0.17586152f, -0.08350039f, 0.04597953f, -0.13609998f, -0.00786634f, -0.25760746f, 
    -0.02391001f, -0.18480419f, 0.07257121f, 0.03170400f, -0.11203386f, -0.21074729f, -0.02738121f, 0.03914335f, 
    -0.00440496f, 0.19969675f, -0.16074955f, 0.11437351f, -0.04310675f, 0.40843761f, 0.26978531f, -0.07391972f, 
    0.20185584f, -0.03331687f, -0.31225461f, -0.06495735f, -0.08194918f, -0.10018090f, -0.02109587f, 0.10287216f, 
    -0.00689421f, 0.08304395f, -0.04441343f, 0.22564371f, -0.18056300f, 0.28623125f, 0.29921141f, -0.41356400f, 
    -0.09994253f, -0.04239046f, 0.18230110f, -0.05176480f, -0.28845659f, -0.07000661f, 0.06661791f, -0.06960849f, 
    0.16216943f, 0.43329543f, 0.01571844f, 0.24339363f, -0.21483301f, 0.01150293f, -0.04602733f, -0.09820043f, 
    0.00222528f, 0.04755681f, 0.15339901f, 0.22945748f, 0.14664412f, 0.19058049f, 0.00749208f, 0.07742766f, 
    -0.11994047f, 0.16994378f, 0.10112201f, -0.26068568f, -0.17452486f, 0.03530599f, -0.30172685f, 0.18917173f, 
    0.10251565f, 0.03639789f, -0.34502888f, 0.50914150f, 0.10771371f, 0.18538508f, 0.09394362f, -0.12086315f, 
    0.14536136f, -0.10667867f, 0.17729479f, -0.09588618f, 0.14888221f, 0.17085110f, -0.11604799f, -0.11831119f, 
    0.06143590f, 0.17053580f, -0.26220065f, -0.00728019f, 0.07898424f, 0.15937358f, -0.19350186f, 0.22732188f, 
    -0.03640860f, 0.23241517f, 0.13179153f, -0.01128988f, -0.15609595f, 0.11899223f, 0.39086577f, -0.23911220f, 
    -0.05607369f, 0.23265585f, 0.15404139f, -0.12801999f, 0.12475254f, 0.04847712f, 0.12109195f, -0.05992471f, 
    0.27118921f, 0.07486042f, -0.14084087f, 0.01089267f, 0.16462639f, 0.13000418f, 0.02262800f, -0.03727962f, 
    0.28025419f, 0.13220270f, 0.34260282f, 0.01524815f, -0.07679534f, -0.20221283f, 0.01152627f, 0.15867738f, 
    0.19387023f, -0.30359468f, -0.40043408f, -0.24672407f, 0.13392311f, 0.18100461f, 0.26221567f, 0.25798541f, 
    -0.15227798f, 0.06708514f, 0.02146997f, -0.26514775f, 0.03339801f, 0.00140503f, 0.07327849f, 0.04118135f, 
    -0.14677033f, 0.03650076f, 0.20511988f, -0.36946014f, 0.17724964f, 0.14396410f, 0.26214704f, -0.06692020f, 
    -0.12463593f, 0.10205393f, 0.12617390f, -0.10820455f, 0.78205234f, 0.32835004f, -0.00553979f, -0.09652717f, 
    0.02132015f, -0.13203642f, 0.05466793f, 0.11383673f, 0.07612769f, 0.09329478f, -0.22929333f, -0.27949858f, 
    0.11643602f, -0.04906207f, 0.02119002f, 0.11491719f, -0.18354775f, 0.19452216f, -0.64478862f, 0.26764467f, 
    -0.02401763f, -0.06553911f, 0.20714428f, -0.00769394f, 0.09797146f, -0.21598928f, -0.17029656f, 0.43113515f, 
    0.18222226f, -0.05202200f, 0.15912241f, -0.01720600f, 0.13066930f, -0.03281983f, -0.02286479f, 0.04687270f, 
    0.02507707f, 0.00329453f, -0.01907368f, -0.01690119f, -0.03266801f, -0.00612314f, 0.00328488f, -0.03666975f, 
    -0.02530189f, -0.00112940f, 0.02810075f, -0.00571693f, 0.01277127f, -0.04335913f, 0.03426786f, 0.01493713f, 
    -0.02161894f, 0.01880149f, -0.05019150f, -0.04729136f, -0.03920587f, -0.05388045f, -0.00731463f, -0.03181434f, 
    -0.02152388f, 0.02101964f, 0.02084395f, -0.03517878f, -0.00634934f, 0.03794801f, -0.04846486f, -0.03247051f, 
    0.03438021f, -0.01219883f, -0.00782100f, -0.03446552f, 0.04680315f, 0.00814843f, -0.00724470f, 0.03351347f, 
    -0.06076327f, -0.04906930f, -0.00454635f, -0.01437072f, -0.05247596f, -0.01921755f, -0.03039760f, -0.01591586f, 
    0.02956291f, 0.03401570f, 0.04456815f, -0.03420842f, -0.03165749f, 0.05418029f, 0.02445599f, 0.02297538f, 
    -0.03723284f, -0.02120483f, -0.01747729f, -0.03561469f, 0.05223476f, 0.00085788f, -0.00912033f, 0.01853365f, 
    0.01355052f, -0.00522276f, -0.04449656f, 0.01242134f, 0.00918256f, 0.01817549f, -0.05042613f, 0.03046666f, 
    -0.03706381f, -0.02668617f, 0.03408437f, 0.05683568f, -0.06096258f, 0.03164010f, 0.01049763f, 0.04569345f, 
    0.02298244f, 0.02972626f, 0.05173417f, 0.03534522f, -0.05038113f, 0.05263849f, 0.00140818f, -0.00163049f, 
    -0.04825878f, -0.02337555f, -0.04163135f, 0.03398072f, 0.01109205f, -0.05469703f, -0.03245391f, -0.04522197f, 
    0.05190479f, 0.03446757f, -0.04870870f, -0.06821842f, 0.03680981f, -0.00953408f, 0.04634793f, 0.02242708f, 
    -0.00366596f, -0.06675781f, 0.00297235f, 0.01861477f, 0.02737674f, 0.03681837f, -0.02220370f, -0.04325892f, 
    -0.00879933f, -0.03145777f, 0.02956330f, -0.02157153f, -0.02016367f, 0.03943603f, 0.00266884f, -0.03412339f, 
    -0.03778985f, 0.01839801f, 0.03760700f, -0.03633602f, 0.02575972f, -0.05625188f, -0.01166047f, -0.06128318f, 
    -0.03200409f, -0.03380722f, 0.02272262f, -0.05858052f, -0.06520684f, -0.01793367f, -0.05933840f, -0.04200858f, 
    -0.01897198f, 0.05122621f, 0.03531176f, -0.05405118f, -0.04975181f, -0.02124260f, -0.02507935f, -0.05716550f, 
    -0.05377417f, -0.02503656f, -0.03701894f, -0.03305036f, -0.04768807f, -0.06376917f, -0.05569784f, -0.04014798f, 
    0.03277633f, 0.03169048f, -0.03667404f, 0.02948100f, -0.00311747f, -0.01365829f, 0.03705992f, 0.03888316f, 
    0.00807939f, 0.00293635f, -0.00293204f, 0.01386925f, -0.05270551f, -0.05589769f, 0.03678960f, 0.05725383f, 
    0.00674926f, -0.02386752f, -0.05623533f, -0.03835622f, 0.00768851f, 0.00831501f, 0.04350242f, -0.03943945f, 
    0.00428040f, -0.02639900f, 0.04073023f, -0.06533049f, -0.04340387f, -0.01633115f, -0.04819579f, -0.06722994f, 
    0.04494434f, 0.03094441f, -0.05802103f, -0.01064354f, -0.03649873f, 0.02089366f, 0.03918032f, 0.01895083f, 
    0.05039643f, -0.00063728f, -0.05088487f, -0.01435864f, -0.04780040f, -0.00412524f, -0.00793795f, -0.02255013f, 
    -0.02362259f, -0.02250836f, -0.02983582f, 0.03940522f, -0.00303345f, 0.00490550f, 0.05695081f, -0.06432732f, 
    0.00078974f, -0.03603079f, -0.00199386f, -0.03458811f, 0.03153977f, -0.03818982f, -0.05869712f, 0.03661151f, 
    0.04926614f, -0.00225303f, 0.04720984f, 0.00064074f, -0.04078162f, 0.02486164f, 0.00851100f, -0.02970178f, 
    -0.06132486f, 0.00883712f, -0.00556426f, 0.02870432f, -0.02344519f, 0.01337930f, -0.02057592f, 0.01793368f, 
    0.01883845f, -0.03663100f, 0.02721224f, 0.03126341f, -0.03232108f, 0.00709870f, -0.00496465f, -0.03226021f, 
    -0.03533299f, -0.02799070f, 0.00097063f, -0.06223129f, 0.05013795f, 0.04194645f, 0.02392155f, -0.02535291f, 
    0.04936800f, -0.03247775f, -0.03874147f, -0.03707907f, -0.05968245f, -0.03264565f, -0.00897674f, -0.04709348f, 
    -0.06278490f, 0.00535042f, 0.00595897f, 0.03252878f, 0.03726914f, 0.03136364f, 0.03355579f, -0.05224454f, 
    0.06072504f, 0.00043201f, -0.05529128f, 0.01166956f, 0.00773332f, 0.03374430f, 0.01168665f, -0.02634286f, 
    0.02448530f, 0.00157787f, -0.03541229f, 0.02558019f, -0.00489848f, -0.00270681f, -0.02351104f, -0.05988234f, 
    -0.04132631f, 0.05082436f, -0.04026991f, 0.02266276f, 0.04695194f, 0.00137375f, -0.06357933f, 0.03912744f, 
    -0.06005532f, -0.04142210f, -0.05763531f, -0.00707943f, -0.06410211f, -0.04528935f, 0.03368957f, 0.03700630f, 
    0.00172086f, 0.01484636f, -0.02203390f, -0.01300630f, 0.03460852f, 0.03390229f, 0.01923009f, 0.02761499f, 
    0.02364860f, -0.05632553f, -0.04669807f, -0.01001974f, 0.00438669f, -0.01416405f, 0.04228961f, -0.06107272f, 
    -0.06978178f, 0.04370165f, 0.00481803f, 0.00645495f, -0.03113483f, -0.01556572f, -0.04088812f, 0.01631185f, 
    0.00689726f, -0.03708179f, -0.01844117f, -0.03616527f, 0.03459815f, 0.04238169f, -0.02189079f, 0.00541066f, 
    0.00788430f, -0.00155485f, -0.00668964f, 0.02742352f, -0.01561583f, -0.04907056f, -0.01679831f, -0.01372471f, 
    -0.00459533f, -0.00889818f, -0.04724800f, -0.04803622f, 0.01641311f, -0.04917929f, 0.03037245f, -0.04137042f, 
    -0.05104322f, -0.05260563f, -0.03055334f, -0.03869196f, -0.03058197f, 0.01984612f, 0.02663194f, -0.01150510f, 
    -0.02225052f, 0.04049394f, -0.03016168f, -0.03821225f, 0.04133638f, 0.05449395f, -0.01307207f, -0.01380757f, 
    -0.04719032f, -0.01158059f, 0.02984114f, 0.01752783f, 0.02477959f, -0.00199918f, 0.01774010f, -0.00179115f, 
    0.02949620f, 0.03748951f, 0.05299634f, -0.02208964f, -0.01305548f, 0.00161426f, -0.02430283f, -0.03434406f, 
    -0.05410935f, 0.03158611f, 0.03990708f, 0.03374973f, -0.03987271f, 0.03712162f, 0.02980148f, 0.04020080f, 
    0.01904075f, 0.03930279f, -0.02603220f, 0.00628796f, -0.07008990f, 0.04745707f, -0.02963801f, -0.03327982f, 
    0.00920016f, 0.00766148f, -0.03585420f, 0.01500725f, 0.02844998f, 0.03074578f, 0.04597035f, -0.02802081f, 
    -0.01551079f, 0.01530522f, -0.04757942f, -0.05422053f, -0.02246829f, 0.03004171f, -0.01475761f, 0.00303911f, 
    -0.06382871f, -0.02921028f, -0.03074799f, -0.04933851f, 0.00130468f, 0.02194465f, -0.04771508f, -0.05110113f, 
    -0.06619032f, 0.03142444f, -0.01353657f, -0.02867299f, 0.00644586f, 0.04066667f, -0.03895165f, -0.06492682f, 
    0.02352997f, -0.02644697f, -0.01942443f, -0.03682096f, -0.02812240f, 0.04505533f, -0.02630216f, 0.04859179f, 
    -0.05092649f, 0.04421704f, -0.06329476f, -0.03448656f, -0.00738420f, 0.03431216f, 0.01190164f, 0.00760858f, 
    -0.03664374f, 0.00264741f, -0.05137015f, -0.05710511f, 0.02243828f, -0.03213428f, 0.02735827f, -0.02702338f, 
    0.02570104f, -0.03003179f, 0.03507365f, -0.05904949f, -0.07115147f, -0.05545808f, 0.04535779f, -0.01574405f, 
    -0.01780918f, 0.04550334f, 0.04139438f, 0.03744009f, -0.03822790f, -0.02624666f, -0.00489164f, -0.02052530f, 
    0.00431161f, -0.01004818f, 0.01791655f, 0.01533829f, -0.06085330f, -0.01271264f, 0.03220826f, 0.03523807f, 
    -0.05217591f, 0.03072283f, -0.06381104f, -0.00418878f, 0.01706198f, -0.04882487f, 0.00844293f, 0.02924969f, 
    0.03206759f, 0.01505886f, -0.01915466f, 0.00806483f, 0.03556262f, -0.02574281f, 0.05099658f, -0.02630831f, 
    0.00975528f, -0.00557444f, -0.05344452f, 0.02938678f, -0.05084528f, -0.01599529f, -0.05004903f, -0.03984553f, 
    0.04920759f, -0.04616458f, -0.04568093f, -0.02343494f, 0.02049488f, -0.05470691f, -0.00598504f, -0.01836720f, 
    -0.02009136f, -0.04107785f, 0.03083752f, 0.03111904f, 0.01147107f, -0.04813157f, -0.04446984f, 0.04181298f, 
    -0.03879909f, -0.01891590f, 0.00194401f, 0.04561765f, -0.02481441f, -0.00249435f, -0.05825169f, -0.02842157f, 
    0.01784329f, 0.03344422f, -0.00284220f, 0.03486660f, -0.04508235f, 0.02613191f, 0.00608555f, 0.03170342f, 
    0.01752652f, 0.00229181f, 0.04237083f, 0.03469362f, 0.03921143f, -0.05887287f, 0.01646216f, -0.00927208f, 
    0.05408387f, -0.00520743f, -0.01190686f, 0.00608795f, 0.01613180f, -0.00078083f, -0.02368682f, -0.05306916f, 
    -0.05094121f, -0.04179497f, 0.04832879f, 0.04263892f, 0.03732035f, 0.02584409f, -0.05489442f, -0.03118003f, 
    -0.04009296f, 0.00474723f, 0.00572176f, -0.04752800f, -0.01947876f, 0.00483825f, -0.06339044f, -0.03172714f, 
    0.00669758f, 0.04298554f, 0.02954941f, 0.02981235f, -0.04547179f, -0.04829163f, -0.01454388f, -0.01521712f, 
    0.04652291f, -0.02379141f, -0.01671880f, -0.04673570f, -0.03460832f, -0.00333433f, 0.04874643f, 0.04063842f, 
    0.02408467f, -0.01836476f, -0.06377083f, 0.00108013f, -0.05776784f, -0.07017741f, -0.06794829f, -0.05987371f, 
    0.02111046f, -0.05134041f, 0.04949706f, -0.02357524f, 0.02140464f, -0.02622442f, -0.03218587f, 0.02571000f, 
    -0.05775592f, -0.06382032f, -0.00016630f, -0.00355735f, -0.03421743f, 0.01517967f, -0.00099633f, -0.02960030f, 
    0.02190248f, 0.04360075f, -0.01754571f, 0.00574399f, -0.05356495f, -0.06447594f, -0.02380300f, -0.02279312f, 
    -0.02182628f, 0.03741475f, -0.03227921f, 0.04746805f, 0.00463249f, -0.06246763f, 0.01213967f, -0.02265880f, 
    0.04166191f, -0.06969105f, -0.06452114f, -0.01755521f, 0.04033189f, 0.02941310f, -0.03640613f, 0.04330955f, 
    -0.04364375f, 0.01012147f, 0.03767507f, 0.03380547f, 0.00212191f, -0.01062427f, -0.01406109f, 0.02541406f, 
    -0.06110726f, 0.02636676f, 0.02092000f, -0.03290683f, 0.02935085f, -0.06615096f, 0.05292496f, -0.06166909f, 
    0.05067758f, -0.01460893f, 0.04418235f, -0.04398277f, 0.01846097f, 0.02391906f, 0.03337421f, -0.04414835f, 
    -0.03721825f, -0.03584578f, 0.03896540f, -0.02497976f, -0.00740452f, -0.00128503f, 0.00317584f, -0.03585596f, 
    -0.02735400f, 0.03712311f, -0.03097871f, 0.04382632f, -0.05824127f, -0.04002941f, 0.04855158f, -0.05881736f, 
    -0.00636382f, -0.01974459f, -0.02934894f, 0.00589523f, -0.00793835f, 0.02513726f, 0.01721783f, 0.01438842f, 
    0.01611690f, 0.02447467f, 0.03574320f, 0.00904812f, 0.04069228f, 0.01501950f, -0.04992681f, -0.02392386f, 
    -0.00820789f, -0.03359222f, 0.02180609f, 0.04786939f, -0.00092437f, -0.04474760f, 0.00523082f, 0.03738616f, 
    -0.02457177f, 0.01598216f, 0.05110612f, -0.04271825f, -0.04396927f, -0.07001010f, -0.00747301f, -0.02046485f, 
    -0.05823968f, 0.02348318f, 0.01314672f, -0.04824688f, 0.04990435f, -0.01906432f, -0.00281206f, -0.04114068f, 
    -0.00807216f, 0.00541147f, 0.00314732f, -0.00538673f, -0.01204117f, 0.01535786f, -0.00819561f, 0.02127009f, 
    0.02384804f, 0.01635283f, -0.05177380f, -0.01027010f, -0.06101648f, 0.01400389f, -0.05458041f, -0.04083734f, 
    -0.01161374f, -0.04618997f, -0.00939940f, -0.02583353f, -0.01505742f, -0.01703666f, 0.01043272f, -0.00102017f, 
    -0.06527459f, -0.04821663f, 0.02593808f, -0.01514016f, -0.00402152f, 0.02055035f, 0.02485556f, -0.05943108f, 
    -0.00949755f, -0.05871988f, 0.02913224f, 0.03178245f, 0.02507997f, 0.04094155f, -0.06471429f, -0.06611645f, 
    0.00797361f, -0.04908698f, -0.06603225f, -0.04596192f, 0.03254412f, 0.05091379f, -0.01242242f, 0.01233453f, 
    0.02952309f, 0.05233004f, -0.04303345f, 0.00029288f, -0.05819198f, -0.01451618f, 0.02595459f, -0.03434148f, 
    0.03058445f, 0.01687407f, 0.02902405f, 0.00157283f, 0.04891235f, 0.04566616f, -0.03562266f, 0.02554323f, 
    -0.01969299f, 0.04794202f, -0.04025837f, -0.03242017f, -0.02632897f, -0.06527870f, -0.00844838f, 0.03413820f, 
    -0.03739263f, -0.05906151f, -0.05105692f, 0.02184819f, -0.03499475f, 0.00592673f, 0.03497789f, -0.03372639f, 
    -0.00604114f, -0.00212912f, -0.02001460f, 0.02742027f, -0.00216113f, -0.00428644f, -0.05553065f, -0.00611597f, 
    -0.00957275f, 0.02311273f, 0.01203000f, -0.00838195f, 0.00596098f, -0.00017880f, -0.06404594f, -0.01843290f, 
    0.04677247f, 0.04503275f, -0.00307654f, 0.01966172f, -0.00957634f, -0.01544882f, -0.03392155f, -0.03514344f, 
    0.02842499f, 0.03025761f, 0.02804107f, 0.01899086f, 0.03331720f, 0.04122672f, 0.02373993f, -0.04993466f, 
    -0.01531453f, -0.04064298f, -0.04952034f, -0.00829452f, -0.01471086f, 0.03985693f, 0.03097216f, 0.02146231f, 
    0.02754599f, 0.00766046f, -0.01941258f, -0.04546937f, 0.06261186f, -0.02522761f, -0.00117573f, -0.04985490f, 
    -0.05833538f, -0.04028703f, 0.04334680f, 0.05052597f, -0.03726359f, -0.00887705f, -0.01696100f, -0.06065483f, 
    -0.00290944f, 0.00636254f, -0.01330837f, 0.01794278f, -0.05450773f, -0.06161918f, -0.01350494f, 0.03640084f, 
    -0.05722532f, -0.04184861f, 0.01349795f, 0.02597968f, -0.01110567f, -0.02905889f, 0.04144109f, -0.00336577f, 
    0.03705989f, -0.02465314f, -0.06181394f, -0.06504083f, -0.06676683f, -0.04847443f, -0.02818642f, -0.04268166f, 
    -0.01235026f, -0.05266654f, -0.00420050f, 0.02531197f, -0.05495452f, -0.03599716f, 0.00293685f, -0.06324733f, 
    -0.01970245f, -0.05784196f, -0.00294051f, 0.01511910f, 0.00215110f, -0.04088876f, 0.04335014f, -0.04856434f, 
    0.00511468f, 0.00398092f, 0.03272784f, 0.00040894f, -0.05045950f, 0.01314364f, -0.00895612f, -0.04649400f, 
    0.03919566f, -0.00306207f, 0.02161698f, -0.00281698f, -0.02508238f, 0.02414672f, -0.01234863f, 0.02707632f, 
    0.01111114f, -0.04858049f, 0.03020018f, 0.03465635f, -0.05990202f, -0.03949709f, -0.04654090f, 0.02692579f, 
    -0.01319357f, 0.00733829f, 0.01897424f, -0.03663089f, -0.06967127f, -0.03180636f, -0.02441313f, 0.02752507f, 
    -0.00735341f, 0.01490081f, -0.01206343f, -0.05225854f, 0.03182791f, -0.00196556f, 0.00249703f, 0.01436042f, 
    -0.02453259f, -0.01118529f, -0.00463391f, -0.02568066f, 0.04061094f, -0.05000458f, -0.04092348f, -0.05284039f, 
    -0.05377384f, 0.01673785f, -0.04854740f, 0.05045091f, 0.05060877f, -0.06310239f, 0.04084914f, -0.05699459f, 
    -0.01627947f, -0.00030647f, -0.00902163f, -0.03796626f, -0.03961201f, 0.00736005f, -0.03165839f, 0.00456366f, 
    -0.03318772f, -0.01169888f, -0.06879745f, -0.03525638f, 0.01005571f, 0.00144759f, -0.05606869f, 0.00336989f, 
    0.02100351f, -0.03296955f, 0.03394586f, -0.04157908f, -0.06159604f, -0.00408166f, -0.06089777f, -0.00541461f, 
    0.03065895f, -0.05294304f, 0.02508209f, 0.01261600f, 0.00054576f, 0.01312507f, -0.03005571f, 0.01258601f, 
    0.04373154f, -0.02307077f, 0.01929793f, -0.03439089f, 0.02078817f, -0.06038280f, -0.06103003f, -0.02801572f, 
    0.02260863f, 0.01654244f, -0.06376766f, -0.03401657f, 0.03862677f, 0.00388152f, 0.02153483f, 0.04429253f, 
    0.01315513f, -0.03106120f, 0.01049963f, -0.06053826f, -0.03380856f, -0.02641917f, 0.04286233f, -0.03486441f, 
    0.03192171f, -0.05151013f, -0.02776985f, 0.02873756f, -0.05873967f, 0.00405738f, 0.01726942f, -0.04362705f, 
    -0.01929806f, -0.00680845f, -0.03022316f, -0.00587160f, 0.03690426f, -0.05396067f, 0.02958761f, 0.00953368f, 
    -0.03127073f, 0.03906025f, 0.02486978f, 0.04778726f, 0.02899393f, 0.00876774f, -0.03771890f, 0.02135562f, 
    -0.03441149f, -0.05579963f, 0.02193545f, -0.05647707f, -0.00548040f, -0.05498778f, -0.05517019f, -0.01687697f, 
    0.01669082f, 0.04246491f, -0.04847895f, 0.00233645f, 0.02249410f, -0.03732892f, -0.02175676f, 0.00189255f, 
    -0.02252150f, -0.05784147f, -0.06353261f, -0.05427561f, 0.00434104f, -0.07043942f, -0.05565911f, -0.04653858f, 
    -0.01394259f, -0.05612806f, 0.02555381f, -0.00592214f, -0.03055084f, 0.02448905f, -0.01708252f, -0.03466912f, 
    -0.01022067f, 0.01664475f, 0.02202578f, 0.04114759f, 0.02430889f, 0.03967259f, 0.01735340f, 0.01380346f, 
    -0.05122636f, 0.04002961f, -0.00718782f, -0.06198769f, -0.02340676f, 0.03907912f, -0.02740911f, -0.01621888f, 
    -0.05655929f, -0.03260875f, -0.03584856f, 0.02209244f, -0.06607731f, -0.05590859f, -0.04197793f, 0.02169426f, 
    -0.03599299f, 0.01054781f, -0.01769960f, -0.01376352f, -0.02288360f, -0.01809261f, 0.04191887f, 0.03800309f, 
    0.03564894f, -0.04466606f, 0.03839182f, -0.01362420f, 0.00160990f, -0.06119446f, -0.02996534f, -0.05204012f, 
    -0.07152747f, -0.02747513f, -0.00585140f, -0.00662014f, 0.02040664f, 0.05116916f, 0.00654017f, -0.06730153f, 
    -0.02038616f, -0.02764512f, 0.03253082f, 0.02360356f, 0.04717667f, -0.04590657f, 0.03841833f, -0.01824397f, 
    0.00576784f, 0.00847308f, -0.06757793f, 0.02167074f, -0.05006905f, -0.00003974f, 0.00509312f, 0.03301642f, 
    -0.01985900f, 0.02928931f, -0.05106363f, -0.04187662f, 0.03602589f, 0.00817152f, -0.02046950f, -0.02796323f, 
    0.01253021f, 0.00288729f, -0.02904073f, 0.03731462f, 0.02072369f, -0.02673585f, 0.02567378f, 0.03295778f, 
    -0.02569219f, -0.04965702f, 0.04394362f, -0.03912143f, -0.05461306f, -0.00827568f, 0.02385909f, -0.00619116f, 
    -0.03448886f, -0.01486294f, 0.00305733f, 0.01279792f, 0.02778387f, -0.02782073f, -0.05062363f, -0.05786081f, 
    -0.06098852f, 0.04081953f, -0.05970198f, 0.04755646f, 0.03055412f, 0.03984425f, 0.01092669f, -0.06597316f, 
    -0.01350351f, 0.02907852f, 0.02495145f, -0.04167515f, -0.05222351f, 0.04719220f, -0.02690331f, -0.03496204f, 
    0.02885939f, 0.05098303f, 0.05033695f, -0.02942029f, -0.01476756f, 0.01612790f, -0.01342538f, 0.04923061f, 
    0.02914979f, -0.02719153f, -0.02903473f, -0.04960736f, -0.04008303f, -0.04379786f, 0.03494604f, -0.06481641f, 
    0.03663791f, -0.04526107f, -0.02078616f, 0.00747214f, 0.00718953f, 0.01585939f, 0.03678963f, 0.04310880f, 
    -0.04439293f, -0.03630437f, -0.04446688f, -0.02213513f, -0.04577323f, 0.03585189f, -0.01237919f, -0.02525458f, 
    0.03689487f, -0.00900749f, -0.05417829f, -0.04817213f, 0.00450637f, 0.04754725f, 0.01166520f, 0.01239477f, 
    -0.05261419f, 0.00890504f, 0.01272894f, 0.03886484f, -0.06218409f, -0.00377469f, -0.04870946f, -0.04755453f, 
    -0.04426811f, -0.03436056f, -0.03499389f, 0.02170005f, 0.02129811f, -0.02915043f, 0.02175887f, -0.05915820f, 
    0.03820890f, 0.04057609f, -0.06008738f, -0.03062752f, 0.04886143f, -0.06721970f, 0.02605669f, 0.02900798f, 
    -0.00776949f, -0.05543897f, 0.02959800f, 0.02838493f, -0.00231732f, 0.03155738f, -0.04476978f, -0.05086262f, 
    0.02678764f, 0.04557844f, -0.00944888f, 0.02006195f, -0.01111237f, 0.01822495f, 0.01363026f, -0.03553097f, 
    0.02605696f, -0.02442067f, -0.00845947f, -0.03778700f, 0.04547981f, -0.04397710f, -0.05745629f, 0.00468925f, 
    -0.03285517f, -0.05811473f, -0.02076348f, -0.00629687f, -0.01727979f, -0.00712258f, 0.01878851f, -0.01195052f, 
    -0.04581186f, 0.04365967f, -0.04405932f, 0.04335731f, -0.00013761f, -0.03468062f, 0.02316700f, 0.03799840f, 
    -0.05663989f, -0.05514185f, 0.03814620f, 0.04689652f, 0.04268245f, 0.04616831f, -0.02857945f, -0.02352134f, 
    -0.04146785f, 0.03666575f, 0.02085265f, -0.01807394f, 0.02990652f, -0.02543665f, 0.00866676f, 0.00638726f, 
    -0.03806084f, -0.02353770f, 0.01989777f, 0.04590650f, -0.01366999f, 0.03961433f, 0.03274943f, -0.00980505f, 
    0.01378357f, -0.02423018f, -0.03159288f, -0.02308846f, -0.03152103f, -0.01817044f, 0.02193741f, -0.03187976f, 
    -0.00198923f, 0.05250654f, -0.02122594f, 0.00518176f, -0.04579423f, 0.00862169f, 0.03968786f, -0.06054597f, 
    0.02284463f, -0.04865878f, -0.00847851f, 0.03508712f, -0.01788820f, -0.00412450f, -0.02453653f, 0.02250546f, 
    0.03305145f, -0.05140250f, -0.03452131f, 0.00152912f, -0.02731978f, -0.05032064f, -0.00390822f, -0.06599390f, 
    -0.06433070f, 0.00360711f, -0.02549565f, -0.05178447f, 0.04996730f, 0.00037207f, 0.02631253f, 0.04270895f, 
    0.00096313f, 0.04180379f, -0.02734606f, -0.01654216f, -0.03427574f, 0.03265637f, -0.03160141f, -0.06809753f, 
    -0.01891042f, -0.05796228f, 0.00765954f, -0.03840321f, 0.04373357f, 0.04608823f, -0.02861709f, 0.04041401f, 
    -0.00669617f, 0.03566064f, -0.03125098f, -0.05316749f, 0.02394450f, 0.02826227f, -0.04185095f, 0.00674264f, 
    0.00129695f, 0.03237640f, 0.03462023f, -0.04149084f, -0.03022292f, -0.06484959f, -0.01850879f, -0.00035509f, 
    -0.03309194f, -0.05446474f, -0.03902546f, -0.00633228f, -0.00493722f, -0.05784404f, 0.00546591f, -0.04475975f, 
    -0.03805526f, -0.03383913f, -0.00730295f, -0.00145766f, -0.01499251f, 0.00528987f, 0.00637168f, -0.05883146f, 
    0.00189731f, 0.00200041f, 0.01438393f, -0.01016934f, 0.02776462f, 0.01908303f, 0.01436619f, 0.00338685f, 
    -0.04920949f, 0.00925480f, 0.00234614f, -0.05851321f, 0.04955670f, -0.03636440f, -0.03360126f, -0.03866911f, 
    0.04641486f, -0.06598722f, 0.01436763f, 0.01398003f, 0.04991748f, 0.00239963f, 0.04426236f, 0.02333997f, 
    0.04792082f, 0.01581983f, -0.02311134f, 0.01978183f, 0.03144157f, -0.02807942f, -0.02619909f, -0.01634016f, 
    0.05453959f, -0.02695142f, -0.02104991f, -0.04604699f, 0.02868349f, 0.00887694f, -0.04000994f, 0.02050066f, 
    -0.06288603f, 0.02071921f, 0.01811956f, -0.01418637f, -0.03762460f, -0.02458528f, -0.01259378f, -0.03431503f, 
    -0.01820778f, 0.01201447f, -0.04039156f, 0.04230545f, -0.03712337f, -0.00014087f, -0.05188189f, 0.04652777f, 
    0.00138395f, -0.06103082f, -0.05406894f, -0.05848164f, 0.04735339f, -0.04297540f, -0.00713302f, 0.04040927f, 
    0.00357803f, 0.03585723f, -0.02526505f, -0.02959307f, 0.00620400f, -0.01182494f, 0.03284946f, 0.01698624f, 
    0.02185448f, -0.04906990f, -0.05625755f, 0.00942799f, 0.02648147f, -0.01288194f, 0.03160155f, -0.00972975f, 
    -0.05183377f, -0.00376348f, -0.01975904f, -0.03219314f, 0.00797083f, -0.02396701f, 0.04581535f, -0.02109672f, 
    -0.06637992f, -0.04288820f, -0.06520112f, 0.02592914f, -0.06371019f, 0.00020054f, 0.03293029f, -0.02192284f, 
    0.04626389f, -0.05657114f, 0.01596918f, -0.01744560f, -0.06194848f, 0.04688714f, -0.03162459f, -0.06104266f, 
    -0.02150049f, -0.04892121f, -0.00518398f, -0.00804830f, -0.03531252f, -0.00675476f, -0.02068674f, 0.01305148f, 
    0.01500553f, 0.03027037f, 0.02021386f, 0.03523128f, -0.06027102f, -0.05475131f, -0.04530722f, -0.00171365f, 
    0.02121947f, -0.05693259f, -0.01349501f, 0.04124674f, 0.01085098f, 0.03240138f, -0.04338886f, 0.02389053f, 
    0.02405818f, -0.01795263f, -0.00091923f, 0.03839007f, -0.00507554f, 0.01058488f, 0.03726805f, -0.05480004f, 
    -0.04207478f, 0.00495817f, 0.01510827f, -0.01716969f, 0.02909640f, 0.03924638f, 0.01414418f, -0.04479640f, 
    -0.05658739f, -0.04110424f, -0.05003204f, 0.02402434f, -0.04976191f, -0.02075867f, -0.04958028f, -0.03276720f, 
    0.00433501f, 0.04093682f, 0.04671827f, 0.04152620f, -0.00636440f, 0.04721683f, 0.03775517f, 0.04359853f, 
    0.01743043f, -0.01788639f, -0.00064999f, -0.02734565f, 0.03623004f, 0.01905292f, -0.02821346f, -0.00687222f, 
    -0.01013188f, -0.02469329f, 0.01561125f, -0.03808814f, 0.04722692f, 0.00740934f, 0.01158400f, -0.05625835f, 
    -0.06802886f, 0.01469610f, 0.00311528f, 0.00575077f, -0.03923168f, -0.00406832f, -0.05050968f, 0.04296071f, 
    -0.02923477f, 0.03483247f, 0.04527334f, 0.01007012f, -0.02894206f, -0.02372762f, -0.04410044f, 0.01213706f, 
    -0.03833676f, -0.00661404f, -0.01713008f, 0.03565125f, 0.05084115f, -0.03965130f, -0.00531788f, -0.00628262f, 
    -0.06012840f, 0.02571742f, 0.05100390f, -0.00094285f, -0.05331779f, -0.06887598f, -0.01712562f, -0.01250191f, 
    -0.06306297f, -0.04121673f, 0.01433106f, 0.03898711f, -0.05490604f, -0.03737483f, 0.00239327f, 0.04728051f, 
    0.00706013f, 0.04916560f, -0.01329002f, -0.02118659f, 0.03355749f, -0.00731276f, 0.02799546f, 0.00867465f, 
    0.00622953f, 0.00379911f, 0.04674232f, 0.04204577f, -0.02167664f, -0.04446503f, -0.03737551f, -0.06666443f, 
    -0.05057024f, -0.04857663f, 0.04389356f, 0.02166613f, 0.01924576f, 0.00528896f, 0.02687742f, 0.02999736f, 
    0.00268300f, -0.05085361f, 0.02103912f, -0.01123538f, -0.02942134f, -0.06198006f, -0.02333652f, -0.03200321f, 
    -0.03667682f, 0.00801803f, -0.03501278f, 0.02170918f, -0.06220042f, 0.03739249f, -0.03599422f, 0.04435224f, 
    -0.00441983f, -0.03317706f, -0.04866453f, 0.01474474f, 0.03716253f, 0.04825843f, 0.02604160f, 0.02455731f, 
    0.01717744f, 0.02859390f, 0.03035730f, -0.04695967f, 0.03577695f, 0.04563124f, 0.01532793f, 0.05152266f, 
    -0.04332924f, -0.01956512f, -0.04287559f, -0.06359678f, -0.01781083f, -0.03789019f, -0.04004900f, -0.03771926f, 
    0.01440197f, 0.00317391f, -0.01420936f, 0.03249778f, 0.04353534f, -0.01158889f, 0.01600786f, -0.01331844f, 
    -0.06265706f, -0.06765175f, 0.04142642f, -0.01007675f, -0.01581982f, -0.01429768f, -0.02639600f, -0.01284931f, 
    -0.03282094f, -0.00822235f, -0.02249309f, -0.06176233f, 0.00910545f, -0.01754524f, 0.04028026f, 0.04128762f, 
    -0.06992321f, -0.00482461f, -0.06540406f, -0.02680438f, 0.03482322f, 0.01894541f, -0.05384883f, -0.06487185f, 
    -0.00514120f, 0.03997750f, 0.01075872f, -0.04149774f, -0.05865983f, 0.04089649f, -0.04810138f, -0.05887485f, 
    -0.01449414f, 0.03115213f, 0.02694448f, 0.05023678f, -0.00594048f, -0.04768915f, -0.03722500f, -0.00656662f, 
    0.04446527f, -0.03184777f, 0.04338496f, -0.02678448f, 0.03007079f, 0.00574142f, 0.03907496f, 0.04246321f, 
    0.00001136f, -0.05692373f, 0.01377714f, -0.03820818f, -0.02255490f, 0.02048289f, -0.06162236f, -0.03294326f, 
    0.00453997f, 0.01205848f, -0.04382148f, -0.00921488f, -0.00330316f, 0.02940921f, -0.06069506f, -0.05494966f, 
    -0.04161529f, -0.04911725f, 0.01469788f, 0.02143181f, 0.02578625f, -0.03967386f, 0.02641453f, 0.03312791f, 
    0.01334524f, -0.05371963f, 0.00750519f, -0.06319296f, 0.00916954f, -0.03771329f, 0.04920116f, -0.01026170f, 
    0.04361430f, -0.04350624f, -0.01334374f, -0.01242985f, -0.05011166f, -0.04349372f, 0.02352319f, 0.00074246f, 
    0.04406998f, 0.00719504f, -0.06171202f, -0.04317034f, -0.05744867f, 0.04625557f, -0.05885480f, 0.03572756f, 
    -0.04376188f, -0.00919008f, -0.04792774f, 0.02400569f, 0.03925446f, 0.03639489f, -0.02565121f, 0.01507117f, 
    0.02327425f, -0.02566548f, -0.03344152f, 0.01627367f, -0.02722521f, 0.04892407f, -0.06164948f, -0.02178946f, 
    0.00469595f, -0.05284050f, 0.03582220f, -0.04351822f, -0.06363312f, 0.00921171f, -0.05060616f, 0.03829445f, 
    -0.04944559f, -0.04354286f, 0.04691814f, 0.01163169f, 0.00860866f, -0.01545725f, -0.04945172f, -0.04797983f, 
    0.03461492f, -0.00065582f, 0.03060753f, 0.00274218f, -0.02936803f, -0.02037570f, 0.03415142f, 0.03631227f, 
    0.05028488f, -0.02472486f, 0.01218657f, 0.01262501f, 0.02964776f, 0.00187888f, -0.02362770f, 0.01065704f, 
    -0.00067676f, -0.05392306f, -0.05120723f, -0.06403688f, -0.03686720f, -0.02746665f, -0.03292142f, -0.03434156f, 
    -0.02549788f, -0.03397886f, 0.03459702f, -0.01180885f, 0.02656998f, 0.01983829f, 0.01388120f, -0.02069695f, 
    0.02839583f, -0.00375577f, -0.00827138f, -0.01244763f, 0.00749724f, -0.01852216f, 0.00689320f, -0.04664915f, 
    -0.00481600f, 0.04416773f, 0.01931743f, -0.03305927f, -0.04477587f, -0.04340603f, -0.02262571f, -0.05269279f, 
    -0.06228100f, -0.06107146f, 0.00447540f, -0.05499569f, 0.02307055f, 0.02930820f, -0.03507105f, 0.02218209f, 
    0.02793534f, -0.06178145f, -0.03378072f, -0.05069698f, -0.01978190f, 0.02172040f, 0.03461356f, 0.02295012f, 
    -0.02008539f, -0.02152392f, 0.00635499f, 0.02413980f, 0.00301248f, 0.00523032f, -0.00258243f, 0.02408794f, 
    0.01709887f, 0.01003649f, -0.02692372f, -0.04984664f, -0.02903554f, 0.01680103f, -0.03268107f, -0.04233171f, 
    -0.03641290f, -0.05701068f, -0.04759108f, 0.03533446f, -0.03496401f, -0.01127873f, 0.02477032f, 0.05722158f, 
    -0.01284863f, -0.00964503f, 0.02417606f, 0.05026425f, -0.01124504f, 0.04168114f, -0.05610965f, 0.04966969f, 
    -0.00858103f, 0.01505051f, 0.01512480f, -0.02879631f, -0.02786993f, 0.00328787f, 0.00700005f, 0.01950802f, 
    0.03752293f, 0.02998107f, -0.04947555f, -0.01356384f, -0.03675531f, -0.03179554f, 0.01716282f, -0.05135811f, 
    -0.06305392f, -0.00204478f, -0.01209398f, 0.02827528f, -0.04838877f, -0.05286846f, 0.00690281f, -0.00943912f, 
    -0.03352658f, -0.03718016f, -0.05679143f, -0.05942605f, 0.01804137f, -0.01877281f, -0.00330447f, 0.04887862f, 
    0.01407922f, 0.04704400f, -0.00831398f, -0.02183670f, -0.03645472f, -0.03472842f, 0.02360454f, -0.04163368f, 
    -0.05565404f, -0.00475479f, -0.01837972f, -0.01376582f, 0.03275070f, -0.00219746f, -0.00508878f, -0.06044446f, 
    0.03711150f, -0.05113422f, -0.03851720f, -0.03215930f, -0.05072797f, -0.05230204f, 0.04230388f, -0.01109898f, 
    0.03850995f, -0.01728419f, -0.04602489f, -0.03186825f, 0.04174531f, 0.03930150f, -0.04143855f, -0.02633084f, 
    -0.03512290f, 0.00111321f, -0.04552313f, -0.03117125f, -0.03425596f, 0.01599257f, 0.02981103f, 0.04643445f, 
    0.05012473f, -0.00423201f, 0.02694338f, 0.04745129f, -0.03860518f, -0.03612959f, 0.04336741f, 0.01188582f, 
    0.01652136f, 0.04114101f, -0.00318255f, -0.00560499f, 0.01123319f, -0.02862786f, 0.02393351f, 0.02199028f, 
    0.04700656f, 0.02395761f, 0.00740484f, -0.02752443f, 0.05033465f, -0.01411177f, -0.05671148f, -0.01629846f, 
    0.01779353f, 0.04110016f, -0.03872218f, -0.06218929f, 0.04733438f, -0.05023227f, 0.01252595f, 0.04743543f, 
    0.00220761f, -0.00827932f, -0.03585254f, -0.06057486f, 0.03881957f, -0.03761742f, -0.01190836f, -0.06350069f, 
    -0.01782721f, 0.03243934f, -0.02264506f, 0.02046500f, -0.02643602f, 0.04652287f, -0.04905161f, 0.03937915f, 
    -0.03015268f, -0.02310419f, 0.03967625f, 0.01024988f, -0.00971188f, 0.01695737f, -0.02031243f, -0.04828695f, 
    -0.02910757f, 0.04192390f, 0.03541086f, 0.04935954f, -0.01217516f, -0.05708833f, -0.00610579f, 0.01580524f, 
    -0.06224082f, 0.03408987f, -0.02082817f, -0.01301591f, 0.00090687f, 0.04028089f, 0.04694987f, -0.05478937f, 
    -0.05540220f, 0.01822250f, 0.04508711f, 0.04005848f, -0.06594311f, 0.00405228f, -0.06655257f, 0.02379161f, 
    -0.01333765f, 0.00161240f, -0.04943096f, -0.00245798f, -0.04654591f, -0.02194690f, 0.03572228f, 0.00238739f, 
    -0.04893664f, 0.03954941f, -0.06060899f, -0.06184023f, -0.04782052f, 0.00043092f, 0.02852529f, 0.00303724f, 
    -0.01771130f, 0.01280816f, 0.04216122f, -0.00669367f, 0.01361722f, 0.01539937f, -0.00266845f, 0.03431101f, 
    -0.04535553f, -0.05543311f, -0.05986563f, 0.00862975f, -0.02199886f, 0.02421303f, 0.00137274f, -0.03302218f, 
    -0.04649999f, 0.00597353f, -0.06688907f, -0.02454874f, -0.03860258f, -0.04532122f, 0.05024324f, -0.00282290f, 
    -0.04685718f, 0.04893591f, -0.05004579f, 0.00133125f, -0.01974805f, 0.04870446f, -0.06389585f, -0.04422527f, 
    -0.05770630f, 0.01458762f, -0.04063041f, -0.06736025f, 0.03434791f, -0.03940781f, 0.02517431f, -0.03554968f, 
    -0.00556398f, -0.02572122f, -0.06517651f, -0.00282445f, -0.03295522f, 0.03791773f, 0.01784252f, -0.05298144f, 
    0.05544498f, 0.01149844f, -0.01234002f, 0.01873588f, -0.01300975f, 0.01155273f, 0.04507321f, -0.01336624f, 
    0.00728758f, 0.02780025f, -0.04476321f, 0.00873033f, -0.00033568f, 0.02711469f, 0.02650937f, -0.02110180f, 
    -0.03251367f, -0.01882159f, 0.04528321f, -0.01499098f, -0.05620890f, -0.01163703f, -0.04591071f, -0.05268202f, 
    -0.00432346f, 0.02798082f, -0.00226525f, 0.03724623f, 0.01252730f, -0.06396294f, -0.02507972f, 0.01623761f, 
    -0.04003788f, 0.01701304f, 0.03580906f, -0.01095284f, 0.02201653f, -0.04817966f, -0.01546995f, 0.01890058f, 
    0.03510936f, -0.00651873f, -0.04574164f, -0.05326105f, -0.02202068f, -0.01455702f, 0.00931102f, 0.03140611f, 
    -0.02738789f, 0.04304259f, 0.03922393f, -0.04843421f, -0.04044579f, 0.03049246f, -0.01556239f, 0.01767834f, 
    -0.02630795f, -0.04331606f, -0.02104161f, 0.00551959f, -0.05141965f, 0.00092234f, 0.00715486f, -0.01045123f, 
    0.05675776f, -0.02015874f, -0.01624783f, -0.06747559f, -0.06567220f, 0.00982079f, 0.00251201f, -0.01823791f, 
    0.04856771f, 0.00847661f, 0.00472858f, -0.02689109f, 0.04657875f, -0.05037323f, 0.02846878f, -0.05122830f, 
    0.04920023f, 0.01166214f, 0.02111784f, 0.01798209f, -0.04855355f, 0.03388290f, 0.00385171f, -0.04192976f, 
    -0.01816329f, 0.04042090f, 0.04558970f, 0.01443600f, 0.00744551f, 0.00355738f, 0.00184536f, -0.06668574f, 
    0.05052280f, 0.01030445f, 0.00416524f, 0.05089855f, -0.04021905f, 0.03460789f, 0.03876717f, -0.02064480f, 
    -0.06080077f, 0.00835349f, -0.04782439f, -0.00151442f, 0.00618299f, 0.01167925f, -0.03718932f, -0.03575290f, 
    -0.01938085f, -0.03846805f, 0.02356377f, -0.06183206f, 0.00448017f, -0.00668531f, 0.02898110f, -0.02576863f, 
    0.02466146f, -0.05581875f, 0.00093037f, -0.02613220f, -0.02893692f, -0.00460309f, -0.04653513f, -0.03577305f, 
    -0.06107876f, -0.05392884f, -0.04032205f, -0.02565218f, -0.01109432f, -0.01024049f, 0.00436143f, -0.02590560f, 
    0.04783363f, 0.01420147f, -0.00671414f, -0.04324806f, 0.01391590f, -0.00130629f, -0.04311131f, -0.03078519f, 
    -0.00946528f, 0.03486331f, -0.03063671f, -0.02520862f, -0.04672011f, 0.03814641f, 0.03433073f, -0.02957744f, 
    0.02236986f, 0.01174015f, -0.03024164f, 0.01795110f, -0.06521492f, -0.04743044f, -0.02026831f, 0.02995634f, 
    0.02179920f, 0.00063489f, -0.03522744f, -0.03279502f, 0.01151310f, -0.01749127f, -0.03276562f, 0.04453921f, 
    -0.06417242f, 0.01908849f, 0.00543642f, 0.02768512f, -0.02587322f, -0.06429571f, -0.06219843f, -0.03254350f, 
    -0.05599063f, -0.05987137f, -0.05663507f, -0.01438383f, -0.04721962f, -0.00106530f, 0.02804406f, 0.00336293f, 
    -0.01883626f, -0.01123635f, 0.04170172f, -0.04975012f, -0.03998914f, -0.06056121f, 0.04747713f, -0.00490418f, 
    0.02980212f, 0.02095487f, -0.03633727f, 0.01630856f, 0.00247847f, -0.05912682f, -0.00340871f, 0.02738189f, 
    0.01648104f, -0.03997171f, -0.01052243f, 0.01776496f, -0.02013434f, 0.03118002f, -0.06387593f, 0.01429762f, 
    -0.02729041f, -0.00916477f, -0.01331080f, 0.03179811f, -0.05295969f, 0.02540416f, -0.00702320f, -0.02953596f, 
    -0.04427402f, 0.03561392f, -0.03281700f, 0.04577063f, -0.04730212f, -0.01179208f, 0.04629923f, -0.01534016f, 
    0.05023395f, -0.04330890f, 0.02526195f, -0.00732819f, -0.04357379f, 0.03871656f, -0.05080591f, 0.03356191f, 
    -0.00511343f, 0.05063144f, -0.00074502f, -0.04439062f, -0.00857241f, -0.05940688f, -0.03882108f, 0.00134418f, 
    -0.03396400f, -0.00034009f, 0.04072516f, -0.03400847f, 0.02798180f, -0.03623866f, -0.03720994f, 0.00700073f, 
    -0.01220162f, -0.03278302f, -0.00689478f, 0.03676277f, 0.03872792f, -0.02179192f, -0.01297078f, -0.02408184f, 
    -0.04879839f, -0.05515296f, -0.00417760f, -0.03777877f, -0.03096204f, -0.00189826f, 0.01314344f, -0.04590204f, 
    -0.02245583f, 0.04490693f, -0.00999452f, -0.05783636f, -0.03880069f, 0.01626294f, 0.00683906f, -0.05388107f, 
    -0.03746587f, 0.03850456f, 0.00825553f, 0.04195832f, -0.01095371f, -0.03986090f, -0.00772535f, -0.01990377f, 
    0.02576528f, 0.03143007f, -0.03825785f, -0.03485568f, 0.01943508f, 0.00926258f, -0.03447308f, -0.02407104f, 
    0.04025869f, 0.02307372f, -0.03459560f, -0.05411579f, 0.02113220f, 0.05118434f, 0.00684336f, 0.03265871f, 
    -0.03838914f, -0.02106955f, -0.05589376f, 0.01666271f, -0.05241866f, -0.05163068f, -0.03285232f, -0.03449928f, 
    0.04407307f, -0.03512424f, -0.02610636f, -0.04865866f, -0.05673620f, -0.03256574f, -0.03819577f, -0.04489250f, 
    0.03844145f, -0.05711852f, -0.05736230f, 0.01487092f, 0.00370290f, -0.03306428f, -0.00474373f, -0.05358448f, 
    0.04114185f, 0.04136851f, -0.01341086f, 0.01996529f, -0.05139270f, 0.04342775f, -0.05804447f, -0.02590951f, 
    0.04142436f, -0.01387926f, 0.00367729f, -0.06180199f, -0.02931005f, -0.01332293f, 0.00598348f, -0.01041500f, 
    0.04279258f, -0.04555865f, 0.00592203f, 0.04058522f, -0.03700775f, -0.03360334f, -0.01224194f, 0.04315643f, 
    -0.03274187f, -0.04426366f, 0.02705980f, 0.04645222f, -0.03395410f, 0.04593917f, -0.04021180f, -0.04486829f, 
    -0.01336951f, -0.01879382f, -0.04852261f, -0.01376071f, -0.04164667f, 0.04640994f, 0.01518334f, -0.06308303f, 
    0.01965818f, -0.00891343f, 0.01325865f, -0.02412269f, 0.03205920f, 0.02863833f, -0.05129720f, 0.01029674f, 
    -0.02217643f, -0.05149446f, 0.04940244f, -0.01782534f, -0.04220502f, 0.02235283f, 0.01878898f, 0.01236830f, 
    0.04151119f, -0.04961368f, -0.00282870f, 0.01444164f, -0.03951615f, 0.02529198f, 0.02791223f, -0.01710281f, 
    0.00521228f, 0.01565991f, 0.00579427f, 0.00000186f, -0.06057282f, -0.00184861f, -0.02318207f, -0.03227444f, 
    -0.00230829f, -0.01725140f, 0.02985576f, -0.00537979f, -0.03833687f, -0.00730947f, -0.00440662f, -0.03614370f, 
    0.03872704f, -0.06173103f, 0.02629076f, 0.03878210f, -0.00466581f, 0.05477085f, 0.02147710f, 0.04810547f, 
    -0.03334012f, -0.00025240f, 0.01021225f, 0.00409585f, -0.02998460f, 0.00452225f, -0.02973447f, -0.01643188f, 
    -0.03472434f, 0.05301303f, -0.01458866f, 0.00322240f, 0.03775550f, -0.04206739f, -0.01226497f, 0.04494603f, 
    -0.00412598f, 0.04793221f, 0.03882230f, -0.00547561f, -0.06106726f, -0.00154125f, -0.04078714f, 0.03313841f, 
    -0.03873972f, -0.03464762f, -0.03296312f, -0.01680112f, 0.02660109f, -0.02306413f, -0.02513105f, 0.02918913f, 
    0.01152170f, 0.02017559f, -0.00313918f, 0.03747077f, -0.05698263f, 0.01642667f, 0.03583140f, -0.02138630f, 
    -0.06367171f, -0.01020586f, -0.03534799f, 0.02084425f, 0.05054695f, -0.06457316f, -0.05512989f, 0.01722179f, 
    0.02603140f, -0.02420327f, -0.03166020f, -0.02731025f, 0.04550182f, 0.03737886f, 0.00247876f, -0.02976895f, 
    0.00547139f, -0.01866667f, -0.06223240f, -0.00673419f, 0.00245492f, 0.00591992f, 0.03023086f, 0.01290155f, 
    -0.02752199f, 0.00160925f, 0.00407839f, 0.03007600f, -0.06403393f, 0.01282489f, -0.02685407f, -0.00646695f, 
    -0.00307926f, -0.01095677f, -0.02936082f, 0.01314416f, -0.04022988f, -0.01522188f, -0.01535730f, -0.04228931f, 
    0.20824724f, 0.14317279f, 0.30889523f, -0.12512554f, -0.05389577f, -0.16818315f, 0.15526532f, -0.13766687f, 
    0.21716672f, -0.25105989f, 0.06946864f, 0.31080103f, -0.01210797f, 0.15604569f, 0.22248650f, -0.08362239f, 
    0.08549486f, -0.17955679f, -0.21251881f, -0.30037907f, -0.43401346f, 0.20812006f, -0.20180467f, 0.35679790f, 
    0.07318728f, -0.01808115f, -0.16696328f, -0.10271315f, -0.06280205f, 0.11406248f, -0.03057414f, 0.05576174f, 
    -0.18283394f, 0.10696483f, 0.19214472f, 0.23251946f, -0.39923328f, -0.21329160f, 0.32274285f, 0.12068742f, 
    0.08996037f, -0.12524593f, 0.04619735f, -0.00200317f, 0.03797965f, 0.66172945f, 0.10325625f, 0.04504507f, 
    0.08613610f, -0.20276669f, 0.20416752f, 0.02147396f, -0.19054118f, -0.04079136f, -0.02557095f, 0.08320063f, 
    -0.30337086f, 0.25533897f, -0.01310317f, -0.16301291f, -0.00273695f, 0.18269956f, -0.03427831f, -0.07230031f, 
    -0.20078380f, 0.34381872f, 0.13528970f, 0.05437082f, -0.14993842f, -0.06467120f, -0.07379115f, 0.22987156f, 
    0.14458099f, -0.06702142f, -0.23384653f, -0.02089669f, -0.18437909f, -0.09424986f, 0.02909060f, -0.04857097f, 
    0.07432057f, -0.28664583f, 0.18171774f, -0.45415395f, -0.26922837f, -0.23193190f, -0.00534837f, 0.10860817f, 
    -0.19133215f, 0.44404548f, 0.19722581f, -0.00745324f, 0.45189914f, 0.02308581f, 0.09410826f, 0.16132988f, 
    0.19405392f, 0.19749890f, -0.13570337f, -0.26862273f, -0.21622576f, -0.18752013f, 0.05310969f, 0.01314014f, 
    -0.12328704f, 0.01278041f, -0.01609212f, 0.21954113f, 0.11754385f, 0.00491356f, 0.01499180f, 0.21629132f, 
    0.11530007f, 0.03754525f, 0.11297521f, -0.03809097f, 0.15350343f, -0.20959614f, -0.19353390f, -0.19589256f, 
    -0.13283786f, -0.10211901f, -0.08202425f, -0.13964424f, 0.17528765f, -0.07543823f, -0.31217784f, 0.18968770f, 
    -0.03556496f, 0.12345589f, -0.05471114f, 0.10313089f, -0.20955177f, -0.06970096f, -0.11676359f, -0.11878478f, 
    0.11272028f, 0.33605987f, -0.10429130f, -0.11836375f, -0.31894225f, -0.10562071f, -0.21633020f, -0.10115571f, 
    -0.10386649f, 0.17829897f, 0.03583280f, 0.05677437f, 0.15059200f, -0.21084493f, 0.00995482f, -0.23639956f, 
    -0.16027068f, -0.18571910f, 0.20163205f, 0.19948737f, -0.01949606f, 0.01953389f, 0.00101129f, -0.01815948f, 
    0.08061261f, -0.07152887f, 0.11380707f, 0.24176948f, -0.08841442f, -0.28744307f, -0.07533964f, -0.37535048f, 
    -0.25768375f, -0.12828760f, -0.11690096f, -0.17528623f, -0.03450869f, -0.15646017f, 0.07177047f, 0.11557934f, 
    0.04645430f, -0.20622581f, 0.11260327f, -0.15379804f, -0.02084594f, -0.17790765f, -0.45206735f, -0.26404795f, 
    -0.06109855f, -0.06688089f, 0.03846683f, -0.06186274f, -0.01709440f, -0.31559718f, -0.06169285f, 0.20007749f, 
    0.11094943f, -0.05073675f, -0.02639826f, -0.05426561f, 0.18182631f, -0.01299911f, -0.00695891f, 0.18884715f, 
    0.09059815f, 0.09029425f, -0.10167684f, -0.23706037f, -0.00390199f, 0.02246054f, 0.24811156f, 0.13619940f, 
    0.18041782f, -0.32231042f, -0.27876145f, -0.26416966f, 0.12847455f, 0.03915847f, 0.24604830f, 0.07304940f, 
    0.40807793f, 0.38248110f, 0.15803219f, 0.03496295f, -0.00123305f, -0.05396287f, 0.16968964f, -0.02818309f, 
    -0.05305992f, 0.33489931f, 0.22562686f, -0.05067659f, -0.13754392f, 0.25162575f, -0.20942169f, 0.14385808f, 
    0.12920365f, -0.18593237f, -0.17348891f, 0.00248675f, -0.02102644f, -0.01514088f, 0.14730428f, 0.19175154f, 
    -0.04522750f, 0.04078086f, -0.32607216f, 0.03573767f, 0.42944697f, 0.28066266f, 0.12797131f, -0.22849029f, 
    0.11680175f, -0.00108562f, 0.04653193f, 0.21076658f, -0.85852730f, -0.23596130f, 0.27204046f, -0.04443048f, 
    -0.25120965f, -0.08366005f, -0.08516680f, 0.05236210f, 0.12868986f, -0.22761343f, -0.13076147f, 0.18851987f, 
    0.23227771f, 0.02509092f, 0.28283679f, -0.02567974f, -0.09609541f, 0.31516179f, 0.10663892f, -0.20146860f, 
    0.09339017f, 0.06987381f, 0.00997414f, -0.11357470f, -0.10633617f, 0.05307086f, 0.24998209f, 0.01026706f, 
    0.42409685f, 0.24569021f, 0.10455146f, -0.21839777f, -0.06469987f, -0.01856015f, 0.14195696f, 0.08400259f, 
    0.01044249f, 0.02402861f, 0.00994648f, -0.00951566f, 0.03149578f, 0.01856306f, -0.04687120f, -0.03687473f, 
    -0.00572767f, 0.04946331f, 0.00247458f, -0.03131142f, 0.03406315f, -0.01159855f, -0.04558517f, 0.03524698f, 
    0.03956456f, 0.02362626f, 0.04578035f, 0.04052084f, 0.00433875f, 0.00039959f, 0.01793544f, 0.03074235f, 
    -0.04802435f, 0.01245056f, 0.00340587f, -0.03642290f, 0.02554547f, 0.00993006f, -0.03808268f, -0.03852647f, 
    -0.00762481f, -0.00719051f, -0.05648989f, -0.01842063f, -0.04429896f, -0.03280096f, -0.03825311f, 0.00287667f, 
    -0.04716916f, -0.00964585f, -0.03541454f, -0.05998186f, -0.02567956f, 0.00632066f, 0.02185705f, -0.03471899f, 
    0.01977014f, 0.01282711f, -0.00633513f, 0.04056527f, -0.03795596f, 0.04018564f, -0.04094430f, -0.00127526f, 
    -0.03384302f, 0.02161791f, 0.00943237f, -0.04740392f, 0.02745984f, -0.01153574f, 0.00707313f, -0.06502201f, 
    -0.07022197f, -0.03505154f, 0.02351936f, -0.03475768f, -0.03556274f, 0.03215378f, 0.05052383f, -0.03605691f, 
    -0.01073840f, -0.00828723f, -0.06899806f, -0.03981026f, 0.03980849f, 0.00364991f, -0.03390275f, -0.01279565f, 
    -0.06257989f, -0.00452562f, 0.02842587f, -0.04593485f, 0.05448868f, -0.00885328f, 0.00693546f, -0.06214577f, 
    0.00843715f, -0.03699763f, 0.04310327f, -0.02417106f, 0.00382692f, -0.04981977f, 0.01772924f, 0.01580916f, 
    -0.01902040f, 0.04582072f, 0.00403249f, -0.04422445f, 0.02587182f, 0.04435440f, 0.02629128f, 0.00086000f, 
    -0.02582076f, -0.00863648f, -0.04764307f, -0.01659632f, -0.06940672f, 0.02152298f, -0.02454883f, -0.03371411f, 
    0.04375664f, -0.00148134f, 0.04562952f, -0.03752273f, -0.00248584f, 0.01605954f, -0.05770084f, -0.04177685f, 
    -0.04860982f, -0.00814056f, -0.01773073f, 0.02360271f, 0.03892843f, 0.02761821f, -0.02017978f, 0.04932361f, 
    -0.06718597f, 0.03268809f, 0.02573167f, -0.03085870f, 0.02544351f, 0.01656377f, -0.01289859f, 0.00784734f, 
    0.03844573f, 0.03104657f, -0.03480148f, -0.03281217f, 0.03061187f, 0.01357147f, 0.01333699f, 0.03773643f, 
    0.03540280f, -0.03952205f, -0.00833160f, 0.01127473f, 0.03245213f, 0.04344604f, 0.00008769f, -0.00597908f, 
    -0.06832337f, 0.02254613f, 0.02672358f, -0.05647559f, -0.00598237f, -0.02729436f, -0.06384162f, -0.01305264f, 
    0.01466024f, -0.00202015f, -0.03957185f, -0.02840980f, -0.06842317f, -0.06904099f, -0.00240338f, -0.05299997f, 
    -0.01125071f, -0.02126603f, -0.00747478f, -0.01749053f, -0.05472152f, -0.04392153f, 0.02076954f, -0.06948394f, 
    0.01513795f, -0.06465263f, 0.03375900f, 0.02522841f, 0.01856521f, -0.02728539f, -0.05132687f, -0.00421894f, 
    0.04421401f, -0.06371689f, -0.02769065f, -0.01569759f, -0.06960173f, -0.00233613f, -0.02841651f, -0.03128481f, 
    0.00244326f, -0.07173610f, -0.03943120f, -0.03825399f, -0.00305951f, -0.04644874f, -0.03335289f, -0.02842935f, 
    -0.05215658f, 0.01116151f, -0.03814009f, -0.04949666f, 0.02147945f, -0.04376134f, 0.00450601f, 0.03731276f, 
    -0.01298493f, 0.03235897f, -0.03140130f, 0.02729647f, -0.03103152f, -0.05388014f, -0.03244281f, -0.00733974f, 
    0.03273579f, -0.00278742f, -0.00104831f, -0.05481206f, -0.02065115f, 0.01045815f, -0.06004023f, 0.02570365f, 
    -0.01921507f, 0.00739723f, -0.01876138f, 0.03781143f, -0.02217931f, 0.01065490f, -0.05907282f, -0.06465549f, 
    -0.04331073f, -0.03250753f, 0.02070604f, -0.01064625f, 0.02784133f, 0.02389293f, 0.04480108f, 0.02613801f, 
    -0.03591210f, 0.01184654f, 0.01220474f, 0.00276572f, 0.00666496f, 0.01533816f, 0.03474854f, -0.02877687f, 
    -0.05397719f, -0.00425901f, 0.03291667f, 0.02928260f, 0.00654490f, 0.00454543f, 0.01099828f, 0.00725419f, 
    -0.04326078f, 0.01164126f, -0.02177397f, -0.00925270f, 0.01347107f, 0.02381833f, 0.00112021f, 0.02656537f, 
    0.04009813f, 0.03435192f, 0.01307144f, 0.04676004f, 0.00098108f, 0.03218072f, -0.04267164f, -0.03151320f, 
    -0.03062518f, 0.00928232f, -0.01109132f, -0.00706570f, -0.00332815f, -0.04872063f, -0.00303603f, 0.03830510f, 
    0.02527468f, 0.03970009f, 0.04489153f, -0.03696951f, -0.03424361f, 0.02778397f, -0.00165662f, -0.05835211f, 
    0.27126178f, 0.01027232f, 0.29016656f, 0.30641803f, -0.02938514f, -0.11642971f, 0.10610295f, 0.06121526f, 
    0.08869956f, 0.26079902f, 0.21290585f, -0.13902839f, 0.01236835f, -0.27995452f, -0.05596683f, 0.11008453f, 
    0.00751901f, 0.00034311f, -0.33800614f, -0.17196539f, -0.38300884f, -0.22410029f, -0.21773712f, -0.03471238f, 
    0.22602767f, -0.24824350f, 0.46569765f, -0.16768983f, -0.16948242f, -0.28228423f, 0.05374170f, -0.06528265f, 
    0.00239298f, 0.12589031f, -0.09035529f, 0.28746793f, -0.24262890f, 0.18367292f, 0.45678759f, -0.03885596f, 
    0.17467146f, 0.20032316f, -0.05114715f, 0.05021960f, 0.01983495f, -0.38881859f, -0.55643499f, -0.03822202f, 
    -0.18536982f, 0.10981753f, -0.04155797f, 0.11155801f, 0.29532501f, 0.13923702f, -0.37994140f, 0.07905389f, 
    -0.22695656f, 0.00240937f, -0.20763783f, 0.20210947f, 0.17806895f, -0.08751460f, -0.35330606f, -0.01527293f, 
    0.19164379f, 0.47113714f, -0.16295406f, 0.21680877f, 0.00143610f, -0.49183100f, -0.23440821f, 0.06601612f, 
    0.28339216f, 0.01721136f, -0.02399511f, 0.00214322f, 0.33765170f, 0.00358925f, 0.06386293f, 0.32248798f, 
    0.11208444f, 0.05896322f, -0.48497429f, -0.02431819f, 0.13871692f, 0.19397834f, -0.14848465f, 0.18686672f, 
    -0.00430165f, 0.29179516f, -0.11909864f, -0.33667082f, 0.10141861f, 0.05154134f, 0.27200633f, -0.19838227f, 
    0.02549098f, 0.05416838f, -0.45648628f, -0.01490832f, 0.24397397f, 0.31581846f, 0.03905502f, -0.02785121f, 
    0.25395554f, 0.13942344f, 0.13037930f, 0.31251577f, -0.00746155f, 0.08316848f, 0.25677109f, 0.17891520f, 
    0.34457806f, -0.18294688f, 0.16792333f, 0.07576661f, 0.32573739f, -0.48044229f, -0.28706822f, 0.29128245f, 
    -0.18957306f, 0.04035419f, -0.15054119f, -0.00323596f, -0.10657606f, -0.05511802f, 0.01520532f, -0.33197430f, 
    -0.60611802f, -0.00439104f, -0.02415781f, 0.20028470f, 0.19785999f, -0.17705613f, 0.00293945f, -0.44635746f, 
    -0.36634049f, -0.64599431f, 0.21886989f, 0.11207966f, 0.26659092f, -0.01994503f, -0.03907060f, -0.20416558f, 
    -0.17320862f, -0.26517361f, -0.11117087f, 0.16943043f, 0.71326458f, 0.03359409f, -0.03345174f, -0.36694384f, 
    -0.15353493f, -0.70034623f, -0.36728248f, -0.44918418f, 0.19877978f, 0.12421496f, 0.06035630f, 0.15548699f, 
    0.26713356f, -0.08311436f, -0.13072528f, -0.57771236f, -0.28750834f, -0.14821181f, -0.15825006f, 0.16247208f, 
    -0.07210295f, -0.02295772f, 0.04367066f, -0.13658692f, 0.03648322f, 0.04036512f, 0.17536999f, 0.24978849f, 
    -0.02878914f, 0.00364827f, -0.00842919f, 0.35067558f, -0.01743983f, -0.35874704f, -0.37034449f, 0.00187273f, 
    -0.17181906f, 0.09835869f, 0.25523379f, -0.05523800f, -0.13990878f, -0.31244528f, 0.27326208f, 0.12991238f, 
    0.06844243f, 0.29644486f, -0.06256683f, 0.41209310f, 0.16698597f, 0.08823767f, -0.06277154f, 0.18635312f, 
    0.44692361f, 0.28729770f, 0.09378941f, 0.11044578f, 0.12047584f, 0.15852912f, -0.12348160f, -0.14354897f, 
    -0.05424916f, -0.17544161f, 0.44337374f, 0.16591311f, 0.16708416f, -0.09154007f, -0.03048169f, 0.14371233f, 
    -0.18986171f, 0.46144086f, -0.00097482f, 0.20439535f, 0.22733396f, 0.06804147f, 0.21442580f, 0.11252485f, 
    0.11000036f, 0.20863512f, -0.07984944f, 0.00849685f, 0.03966172f, -0.02464135f, -0.13664250f, 0.14452396f, 
    -0.11770635f, 0.04888153f, 0.03864352f, -0.31169891f, -0.00410889f, 0.13982931f, 0.19059736f, 0.30765709f, 
    0.17598656f, -0.14316718f, -0.16411728f, -0.63872564f, -0.25289774f, -0.56073844f, 0.39078695f, 0.21417275f, 
    -0.02272857f, -0.04902927f, -0.03138376f, 0.10438685f, 0.05021983f, 0.44097608f, 0.28482285f, -0.05780431f, 
    -0.06329964f, -0.05895030f, -0.31457543f, 0.07728159f, -0.00549752f, 0.46190867f, 0.17984930f, 0.16446534f, 
    -0.05916985f, 0.09352927f, -0.01722276f, -0.19520368f, 0.15802035f, 0.39269039f, -0.19766086f, 0.02938757f, 
    0.06819912f, -0.00917667f, 0.07023170f, 0.10802742f, -0.24637224f, -0.14547527f, -0.07031942f, 0.15733168f, 
    0.45960978f, 0.42907622f, 0.22131988f, 0.35817730f, 0.00381420f, 0.24707957f, 0.02634426f, 0.05030743f, 
    -0.05723055f, 0.21588400f, -0.04978433f, 0.05341429f, 0.25598854f, 0.01119019f, 0.09628696f, -0.00806968f, 
    -0.07646561f, 0.08768421f, -0.08123101f, 0.05865537f, 0.18234316f, 0.11886417f, 0.03644839f, 0.04433606f, 
    -0.17105326f, 0.11298877f, -0.23270904f, 0.11112218f, 0.32735950f, 0.19912043f, 0.18196188f, -0.04275502f, 
    -0.07058206f, -0.00875225f, 0.15427206f, 0.02926718f, -0.02133383f, 0.06133999f, 0.07920757f, 0.01070460f, 
    -0.04286610f, -0.15976235f, -0.08777203f, 0.17785738f, -0.01443700f, 0.31712407f, 0.03837504f, 0.13104659f, 
    0.20249324f, -0.01114010f, 0.06804684f, -0.03222747f, 0.01101240f, -0.13351676f, -0.12543689f, 0.24407201f, 
    -0.15878016f, -0.02031942f, 0.08649935f, -0.16984846f, 0.08684245f, -0.00700589f, 0.00270628f, 0.37821215f, 
    -0.04131765f, 0.06522074f, -0.07077727f, -0.10367866f, -0.02000853f, -0.06661712f, 0.04923144f, -0.00096259f, 
    0.09578355f, 0.28906807f, 0.09259029f, -0.11459162f, 0.07481280f, 0.16747496f, 0.08881542f, -0.17508228f, 
    -0.01702858f, 0.05645283f, 0.06123609f, -0.17937030f, -0.11849666f, -0.14355247f, -0.15223080f, 0.18553336f, 
    -0.00679707f, -0.26876384f, -0.07448606f, 0.13200726f, 0.15926787f, -0.11883240f, -0.10891247f, -0.13255094f, 
    -0.02009701f, -0.08909271f, 0.40844479f, -0.30188453f, -0.24624625f, -0.22489607f, 0.07855921f, -0.16647723f, 
    0.05137483f, -0.15698335f, 0.06227234f, 0.04325484f, 0.18881911f, 0.51630527f, 0.11293342f, -0.01122482f, 
    -0.17929000f, 0.30292356f, 0.03964312f, -0.06660987f, 0.55401593f, 0.15693271f, 0.00257872f, 0.28248200f, 
    0.02811922f, -0.29049519f, 0.23903516f, -0.03426301f, 0.17097624f, -0.17666051f, -0.17221938f, -0.52272105f, 
    -0.35440689f, -0.03313219f, 0.14318277f, -0.13081546f, -0.11909985f, -0.02187339f, 0.13466407f, -0.11725857f, 
    -0.14563063f, -0.08705564f, 0.04021945f, -0.05896515f, -0.36280197f, 0.11587926f, 0.09183247f, 0.23341925f, 
    -0.34017086f, -0.30677566f, -0.18378483f, 0.21691106f, 0.12168977f, -0.13797750f, 0.08783568f, 0.07611979f, 
    0.08920337f, 0.11290350f, -0.34398529f, 0.16473617f, 0.20472337f, 0.15217303f, -0.20352179f, -0.14304997f, 
    0.04970429f, 0.04878861f, -0.09928588f, -0.13865526f, -0.20330335f, -0.05226106f, 0.08238317f, 0.07903229f, 
    -0.07050820f, -0.10206617f, 0.38441774f, -0.02150388f, -0.02382545f, 0.07750452f, 0.04242915f, 0.03728839f, 
    -0.00943130f, -0.17333859f, -0.10621284f, -0.63937175f, -0.60219747f, -0.01434462f, -0.11559609f, 0.12838294f, 
    0.06785093f, -0.08708736f, -0.00790788f, -0.07145613f, 0.12554358f, -0.31012005f, -0.02947798f, -0.07751419f, 
    0.14845660f, -0.08002029f, -0.06392572f, -0.11961383f, -0.04555050f, 0.23877273f, 0.16260882f, -0.09328052f, 
    -0.05328614f, -0.05450703f, 0.11319474f, 0.07010046f, 0.01815957f, 0.15413693f, -0.50333005f, -0.26248753f, 
    0.08792079f, -0.05486821f, -0.30649641f, -0.16669720f, 0.07857300f, -0.02797785f, 0.03228178f, -0.21009837f, 
    -0.19685133f, 0.09749459f, 0.04000197f, -0.03564961f, 0.22210138f, 0.10317031f, 0.12676799f, -0.11299431f, 
    0.10568371f, -0.01552595f, 0.14555153f, -0.28413117f, -0.16927665f, 0.07791399f, 0.09452561f, -0.10979237f, 
    0.04512189f, -0.44673598f, -0.28181511f, 0.01459702f, 0.25000012f, -0.03992851f, -0.02287903f, 0.00399551f, 
    -0.04561846f, -0.06876778f, 0.41567081f, -0.04917390f, -0.06580940f, 0.03526858f, 0.07647526f, 0.02954198f, 
    -0.03986745f, 0.07777246f, 0.00123618f, 0.20594865f, -0.24074541f, 0.27936208f, -0.00165139f, -0.11038765f, 
    0.09593191f, 0.16672795f, -0.14724192f, 0.11283172f, -0.41549838f, -0.05762831f, 0.46639490f, 0.03097531f, 
    -0.16842413f, -0.33611795f, 0.03974728f, -0.03419884f, -0.08364990f, 0.50896162f, 0.23760982f, 0.30387855f, 
    0.14929302f, 0.08469740f, -0.17399977f, 0.09244844f, 0.03834229f, -0.02240603f, -0.29662737f, 0.05848311f, 
    -0.11620684f, -0.04604441f, 0.17293142f, 0.01341658f, 0.19520336f, -0.07511447f, 0.01320521f, 0.00734024f, 
    -0.19857456f, 0.33608875f, -0.12109715f, -0.18989629f, 0.27469155f, 0.09476381f, -0.25454265f, 0.09647065f, 
    -0.09451839f, 0.01222108f, 0.06047590f, -0.00644327f, 0.03783274f, 0.27148628f, 0.12825248f, 0.20647864f, 
    0.12520377f, -0.13388771f, 0.01356732f, -0.25271422f, 0.11734918f, 0.15708315f, 0.20524031f, -0.13832985f, 
    -0.11018175f, -0.27151331f, 0.41574213f, 0.05157510f, -0.12527846f, -0.09816649f, -0.18713340f, -0.17982456f, 
    -0.20921412f, -0.27823573f, 0.08852150f, -0.02438415f, -0.35146281f, -0.29717490f, -0.26576519f, -0.14124975f, 
    -0.12832797f, -0.02526612f, 0.28910086f, 0.17495370f, -0.12647827f, 0.10575448f, -0.03772355f, -0.09067971f, 
    -0.23867589f, -0.19259214f, -0.02391901f, -0.15214771f, 0.14934401f, 0.18197185f, 0.00322908f, 0.38006765f, 
    -0.20777504f, -0.15346216f, -0.09077693f, 0.02992430f, 0.30826086f, -0.03520066f, -0.31212518f, 0.11361548f, 
    0.24546242f, 0.02398165f, 0.18035696f, 0.07120457f, -0.00183238f, -0.17954719f, 0.02754831f, -0.03173093f, 
    -0.15288535f, -0.30365691f, 0.07678542f, 0.02411096f, 0.06779200f, 0.11549050f, 0.04164753f, -0.29021540f, 
    0.11407313f, 0.10215414f, -0.20987238f, -0.25713748f, -0.07341197f, -0.37985724f, -0.09523429f, -0.01404815f, 
    -0.08619178f, 0.07249901f, 0.01884474f, -0.32288325f, -0.17953685f, 0.09749437f, 0.30026239f, 0.09020805f, 
    0.05132071f, -0.24718347f, 0.18529089f, -0.38545829f, -0.03338228f, -0.27052927f, -0.01214604f, 0.12237559f, 
    0.15056783f, -0.00473207f, 0.04360022f, -0.04048330f, 0.17251544f, -0.56024957f, -0.16272908f, 0.06636230f, 
    -0.10295007f, -0.23852396f, -0.06824663f, 0.18886553f, 0.05726437f, 0.08040537f, -0.29015896f, 0.17967892f, 
    0.20410252f, -0.03486779f, -0.00340611f, 0.08680984f, 0.16240539f, 0.05406773f, 0.69033903f, 0.16228355f, 
    -0.10700592f, -0.04531102f, -0.25150412f, -0.05111925f, 0.09779712f, -0.18675117f, 0.12190714f, 0.01904351f, 
    0.45160273f, 0.15262048f, -0.07208601f, 0.08494117f, -0.16015081f, -0.08919147f, 0.06826524f, 0.18076594f, 
    -0.28270662f, 0.29488632f, 0.03024591f, 0.13731571f, -0.06067672f, 0.06379007f, 0.10670048f, -0.08162826f, 
    -0.38935885f, 0.42298719f, 0.22495119f, 0.17573221f, -0.08086537f, 0.05165070f, -0.17766739f, -0.14875039f, 
    -0.18962047f, -0.00248435f, -0.21993193f, 0.61800265f, 0.30814147f, -0.05287646f, 0.26958218f, 0.07266045f, 
    0.01954325f, 0.10883143f, 0.15569884f, -0.16591862f, -0.40726969f, 0.06400985f, -0.23507166f, -0.07095427f, 
    0.03965736f, -0.13804913f, 0.07910410f, 0.08019042f, 0.15516132f, 0.41059226f, 0.07783351f, 0.19350876f, 
    -0.06520505f, -0.04532266f, 0.04522656f, 0.14386134f, 0.17632142f, 0.08280566f, 0.07696848f, 0.19921158f, 
    -0.13647477f, -0.02939085f, 0.00026921f, 0.28684455f, -0.02695952f, 0.38952583f, 0.11551858f, -0.21081978f, 
    0.02654650f, -0.05848037f, 0.10674734f, -0.06497835f, 0.32037440f, 0.04061067f, 0.10707079f, 0.35365960f, 
    0.30179921f, 0.16673888f, -0.03558606f, -0.08053185f, -0.09425611f, 0.02613571f, 0.09027568f, 0.08548272f, 
    -0.08549517f, 0.23603475f, -0.14960772f, -0.12932965f, -0.12968114f, -0.20181710f, 0.05217497f, 0.02970283f, 
    0.17523772f, 0.08495212f, 0.52060425f, 0.08666974f, -0.16852771f, -0.01903418f, -0.05913159f, -0.06736860f, 
    -0.26634163f, 0.43047374f, -0.27516001f, -0.49163985f, 0.07653908f, -0.13391614f, 0.03865710f, -0.00089736f, 
    0.13560432f, -0.02541855f, -0.05136647f, -0.11391942f, 0.36242691f, 0.02560277f, -0.00033019f, -0.12050207f, 
    0.02541591f, -0.14122739f, 0.16803698f, 0.05127433f, -0.36498392f, 0.49657682f, 0.17178302f, -0.13620430f, 
    -0.07672296f, -0.11947840f, 0.14610334f, 0.10883415f, -0.60850728f, 0.12197556f, 0.09146105f, 0.18138452f, 
    -0.00770447f, -0.03323027f, 0.00754898f, -0.07470790f, -0.15423317f, -0.08555283f, 0.07817695f, -0.35037771f, 
    -0.05736479f, -0.04577306f, 0.00747544f, 0.02458716f, -0.07972492f, -0.21889810f, 0.02664032f, 0.06601984f, 
    -0.13732199f, 0.00089647f, 0.05023159f, -0.23183784f, -0.06415054f, -0.07607158f, 0.30999902f, 0.18056265f, 
    0.11463173f, -0.16653223f, 0.03766908f, -0.07495837f, 0.35414127f, -0.10939405f, -0.00579644f, -0.04460571f, 
    0.40451732f, -0.26742333f, 0.13010357f, -0.19663657f, -0.04844025f, -0.02358723f, 0.09385198f, 0.15721539f, 
    -0.02955040f, -0.15877177f, -0.46489543f, -0.52712816f, 0.04977845f, 0.12648362f, -0.01617046f, -0.01246378f, 
    0.06084944f, -0.01383102f, -0.35519990f, -0.16467729f, -0.19150768f, 0.10949033f, 0.04613306f, 0.20762344f, 
    0.10929941f, -0.00624509f, -0.01832273f, -0.38875812f, 0.09442073f, 0.03709011f, 0.18123211f, 0.06656469f, 
    0.01583501f, -0.11004538f, -0.07294811f, 0.08397835f, -0.02696593f, -0.17349039f, -0.04199412f, -0.04315100f, 
    0.00556667f, 0.16109759f, 0.01925539f, -0.00687293f, 0.00099173f, -0.32321355f, 0.05988421f, 0.04877349f, 
    0.12469171f, 0.05786522f, -0.01477143f, 0.05678426f, -0.27127922f, -0.06343477f, -0.28717074f, 0.01879422f, 
    0.25803176f, 0.31019768f, -0.09319332f, 0.23867662f, 0.07438824f, 0.15471983f, 0.10301162f, -0.03644136f, 
    -0.25739917f, -0.04761180f, 0.01070095f, -0.03031814f, 0.01402643f, 0.02939919f, -0.09328274f, 0.11792770f, 
    -0.41968256f, -0.28122383f, -0.25554940f, -0.08006001f, 0.02125874f, 0.33111683f, 0.17682998f, 0.34005654f, 
    -0.09416651f, -0.13745220f, -0.39755869f, 0.43658227f, -0.02431939f, -0.04661296f, 0.04105876f, -0.13298841f, 
    -0.20844293f, 0.06495243f, -0.07784078f, -0.02284861f, -0.21138526f, -0.02580812f, -0.00714327f, -0.02914047f, 
    0.16040957f, 0.06307144f, 0.14355545f, -0.03616130f, -0.11302879f, 0.06119757f, 0.15726867f, 0.07011922f, 
    0.01170529f, 0.00432006f, -0.04198518f, 0.29565594f, -0.24371500f, -0.18352531f, -0.20316409f, 0.24309105f, 
    0.15374744f, 0.02354883f, 0.10936230f, -0.06982096f, -0.07731772f, -0.53837132f, -0.02934375f, -0.74082094f, 
    0.08965115f, -0.03013041f, -0.02227628f, -0.02164983f, -0.08348504f, 0.09976052f, 0.07927349f, 0.00290269f, 
    -0.02826114f, -0.24520428f, 0.04154576f, -0.18768287f, 0.17709342f, -0.09295944f, -0.04128439f, 0.11558329f, 
    -0.02695133f, -0.04863250f, -0.11686262f, 0.14485858f, -0.13577034f, 0.00902041f, -0.04908345f, -0.04274838f, 
    -0.58399218f, -0.43869874f, -0.35940218f, -0.00659697f, 0.23374005f, 0.25110558f, 0.12399332f, -0.14350741f, 
    -0.26530421f, 0.16503382f, 0.29027405f, 0.25925016f, -0.02305457f, -0.06390388f, 0.05887489f, 0.07787874f, 
    -0.05895842f, -0.02048028f, 0.32292646f, 0.22426128f, 0.14045453f, 0.22386716f, -0.19757216f, -0.03938401f, 
    -0.02557877f, -0.05111078f, 0.11764630f, 0.26947063f, -0.26811332f, -0.35355875f, 0.10904694f, -0.01373965f, 
    0.16815214f, 0.08575279f, 0.21276250f, -0.20460978f, -0.02382953f, 0.08485353f, 0.17263131f, -0.26955894f, 
    0.06397678f, -0.01418209f, -0.06985779f, -0.12322053f, 0.15275216f, -0.37714648f, -0.12360274f, -0.25471509f, 
    0.07996745f, -0.06330991f, -0.22844553f, -0.15331230f, -0.07116658f, 0.07969774f, 0.32328805f, 0.30386737f, 
    -0.05660805f, 0.10406628f, -0.27545524f, -0.09333447f, -0.00133640f, 0.12388607f, 0.23346689f, -0.24587959f, 
    -0.00894165f, 0.06638175f, 0.23488720f, -0.14236991f, 0.23579487f, -0.10283381f, 0.06785506f, 0.11205379f, 
    -0.10769584f, 0.22130740f, 0.15577868f, 0.22825842f, -0.01022188f, 0.17981884f, -0.03278089f, 0.08397543f, 
    0.14325815f, -0.00083577f, 0.13097437f, 0.00479241f, 0.00799916f, 0.02114925f, -0.00301053f, 0.12150568f, 
    -0.00531149f, -0.04426664f, 0.37331590f, 0.11946611f, 0.17078689f, -0.19221070f, -0.10444184f, 0.13064685f, 
    0.08197667f, 0.01736988f, 0.12753938f, -0.03949006f, 0.29821452f, 0.37482730f, -0.06477556f, -0.13442285f, 
    -0.09825550f, 0.02177751f, 0.19212744f, 0.13488039f, -0.21321286f, 0.12198415f, -0.00466177f, 0.12326800f, 
    -0.12193408f, -0.20314950f, 0.21038583f, -0.04627500f, -0.07547566f, -0.10544517f, -0.39598528f, -0.01856366f, 
    0.17420991f, 0.15838636f, -0.15791132f, -0.00489823f, -0.02202727f, 0.19053337f, 0.25491774f, 0.10258812f, 
    0.12293141f, 0.24372068f, -0.19129977f, -0.17669323f, 0.06440426f, 0.28423783f, 0.10730981f, -0.02274108f, 
    0.05024527f, 0.19199558f, 0.06403161f, -0.10031809f, -0.23601040f, -0.02965025f, 0.11858375f, 0.13410451f, 
    0.06000157f, 0.09204288f, 0.05211395f, -0.13943274f, -0.24597682f, 0.12253596f, 0.04844443f, -0.09449840f, 
    -0.22605708f, 0.09431145f, -0.27994809f, 0.09929541f, -0.02861670f, -0.17082830f, 0.13728225f, 0.32368520f, 
    0.18335342f, -0.15261355f, 0.20451441f, 0.21799631f, 0.12371226f, 0.05241527f, -0.20843078f, 0.09117879f, 
    0.19543970f, 0.19338088f, -0.04787264f, -0.19655833f, 0.25645083f, -0.06243745f, -0.01242349f, -0.14054601f, 
    0.02263642f, -0.01307007f, -0.06977783f, 0.00165982f, -0.16155063f, -0.10646421f, -0.14105870f, 0.15985645f, 
    0.18163894f, 0.06842628f, 0.06789795f, -0.06607296f, -0.09741157f, 0.15995464f, 0.37703270f, 0.13643394f, 
    -0.03330006f, -0.06434119f, -0.08929214f, 0.11251654f, -0.09927556f, -0.12170184f, -0.17615530f, 0.01272839f, 
    -0.10211304f, -0.24942367f, -0.01073532f, -0.15023214f, 0.19436672f, 0.19326983f, 0.09958359f, -0.14040521f, 
    -0.33512378f, 0.18179683f, 0.28363284f, 0.06798477f, 0.15883048f, 0.14048235f, 0.07698140f, 0.06093233f, 
    0.47233546f, -0.02375214f, -0.54652083f, -0.16696693f, 0.12655686f, -0.24466164f, 0.14954124f, -0.14779246f, 
    0.04181840f, 0.02531634f, 0.21389487f, 0.02718437f, -0.18728095f, -0.01283213f, 0.19270031f, 0.12934627f, 
    0.09097505f, 0.14645751f, -0.02524025f, 0.19715171f, 0.19013834f, -0.35082433f, -0.10388783f, -0.07187630f, 
    0.02520350f, 0.03834969f, 0.10971726f, -0.33511442f, 0.16189237f, -0.10309879f, -0.17379734f, 0.14729510f, 
    -0.02272024f, 0.18033567f, 0.04456234f, 0.11825275f, -0.03299526f, -0.14220971f, -0.05085915f, -0.13683139f, 
    0.02459291f, 0.14832999f, -0.10253082f, -0.03581599f, -0.01549417f, 0.13893805f, 0.04317142f, 0.08674350f, 
    0.09547114f, 0.11629351f, -0.00542607f, 0.00388566f, -0.12313493f, 0.06593429f, 0.17396091f, 0.31652254f, 
    0.19054863f, -0.32223928f, -0.08926819f, -0.14023739f, -0.03622686f, -0.00429658f, 0.18102193f, -0.15248308f, 
    0.34580326f, 0.21904831f, -0.38500938f, 0.07016131f, -0.06728515f, -0.07527735f, 0.07067269f, -0.00821337f, 
    0.10029662f, -0.22039762f, -0.25590315f, -0.15371820f, -0.06486816f, 0.03467078f, -0.10781430f, 0.00300387f, 
    0.06622805f, -0.01572030f, 0.14691369f, 0.05813868f, -0.19084205f, -0.20309640f, -0.02696637f, -0.13402587f, 
    -0.03648639f, 0.00401126f, -0.34024620f, 0.02156231f, -0.07273258f, 0.18757519f, -0.06045239f, -0.19287992f, 
    -0.27388686f, -0.07670808f, -0.06263673f, -0.02342234f, 0.17907047f, 0.33860323f, -0.15525931f, 0.07621832f, 
    -0.09347634f, -0.04378890f, 0.05558077f, 0.00829608f, -0.08835679f, 0.17142420f, -0.00538935f, 0.06091364f, 
    -0.03482741f, -0.16022609f, 0.00490195f, 0.09921097f, -0.09166696f, -0.34430370f, -0.10844865f, -0.11159461f, 
    0.06832637f, 0.22011669f, -0.04127471f, -0.11518022f, 0.03044923f, 0.02908715f, 0.14304110f, -0.31723762f, 
    -0.23372166f, 0.09030213f, 0.18831715f, 0.05726843f, -0.18932371f, -0.01097638f, 0.05156146f, 0.13848476f, 
    0.26764694f, -0.19694048f, -0.15174201f, -0.15912542f, -0.05177828f, -0.18066828f, 0.17651644f, 0.07963607f, 
    0.14662659f, -0.00774489f, -0.42989811f, 0.19241142f, -0.38196647f, -0.21914038f, -0.01694864f, -0.16898024f, 
    -0.16912360f, -0.32300350f, -0.07035744f, 0.12215751f, -0.11229535f, 0.07788060f, 0.14894190f, -0.06690354f, 
    0.12610060f, -0.14717962f, 0.45555282f, 0.25582850f, 0.30135584f, -0.61461610f, -0.12687770f, 0.12516589f, 
    -0.04775403f, -0.12094142f, -0.04795791f, -0.30197674f, 0.36753502f, -0.08674672f, 0.04189595f, -0.01298769f, 
    0.03965263f, -0.07361154f, 0.07579477f, 0.23626235f, 0.77039802f, 0.14879683f, -0.01170780f, 0.23728667f, 
    0.13727549f, -0.03306615f, 0.01440323f, 0.06166042f, 0.09276307f, 0.14729282f, -0.28969413f, 0.22792825f, 
    0.13485448f, -0.06684921f, -0.16422701f, -0.04071381f, 0.07568239f, -0.02073347f, -0.53738451f, 0.09136021f, 
    0.06449457f, 0.29562715f, 0.12263253f, 0.22882389f, 0.12511225f, -0.07498478f, -0.05538636f, -0.01391345f, 
    -0.38172927f, 0.16358499f, 0.19321451f, 0.08883672f, 0.13470300f, -0.29851389f, 0.04184712f, -0.07003091f, 
    -0.01618440f, -0.02699661f, -0.01949951f, -0.04632062f, -0.03103281f, -0.00897094f, 0.04759746f, 0.02474869f, 
    -0.02762686f, 0.00684197f, 0.00638874f, 0.03483991f, -0.03987128f, -0.04053760f, -0.04233807f, -0.01178814f, 
    0.03064730f, -0.02234321f, -0.04454865f, -0.03574200f, 0.02246630f, 0.04934318f, -0.03135660f, -0.06093619f, 
    -0.02439236f, 0.04627990f, 0.05138437f, 0.01262093f, -0.00679793f, -0.01296006f, -0.06053365f, -0.06104759f, 
    -0.06380752f, -0.06785227f, -0.05097751f, 0.01891716f, 0.03000162f, -0.05107636f, 0.03917779f, -0.01072887f, 
    -0.03572697f, 0.01343837f, -0.03322108f, 0.00466911f, -0.05389100f, 0.02885891f, 0.01213500f, -0.04597673f, 
    -0.03040800f, -0.04194874f, -0.00037223f, -0.02918124f, 0.02888857f, -0.03754216f, 0.04490515f, 0.04829346f, 
    -0.02214216f, -0.06085611f, -0.02702118f, 0.02441669f, -0.06354297f, 0.01798691f, -0.02348962f, -0.03488240f, 
    -0.03831517f, 0.00798888f, -0.01208235f, -0.06159717f, 0.02805825f, -0.02894090f, -0.02309507f, 0.02929499f, 
    -0.05796429f, -0.04970133f, 0.00254587f, 0.03861358f, -0.05487025f, -0.04962882f, -0.03591661f, -0.01228702f, 
    0.01531290f, 0.00436157f, -0.01621623f, -0.01119611f, -0.04074108f, -0.06156595f, -0.00269449f, 0.00740016f, 
    0.00897577f, 0.00069966f, -0.03075317f, 0.04306300f, -0.04806027f, 0.00797912f, 0.01877616f, -0.04199076f, 
    -0.06191674f, 0.03264151f, 0.01628575f, 0.03590511f, -0.02024595f, -0.00393772f, 0.03314896f, -0.06446600f, 
    0.02333544f, 0.00942108f, -0.05712843f, 0.04638897f, -0.03975358f, 0.04039039f, 0.04096991f, -0.01523744f, 
    0.02556757f, -0.03139473f, -0.02196635f, -0.04208568f, 0.02670505f, -0.02426318f, -0.04127026f, -0.00800671f, 
    0.03432102f, 0.03961766f, 0.04457030f, 0.03183772f, 0.03720570f, -0.01153956f, -0.04014279f, -0.05291983f, 
    0.01551709f, -0.01772428f, -0.06840326f, 0.04686393f, -0.01421572f, -0.05503991f, -0.03862732f, -0.02178661f, 
    -0.01504155f, -0.06636411f, -0.01531845f, 0.02103898f, 0.04056529f, -0.01284697f, -0.05794111f, -0.04742184f, 
    -0.05015583f, 0.00787552f, -0.03125982f, 0.03786422f, -0.03000264f, 0.04017201f, 0.04460389f, 0.01375816f, 
    0.00883231f, -0.05842281f, 0.05901004f, 0.00587076f, -0.05795119f, 0.04042447f, 0.01093531f, 0.03740317f, 
    -0.06764174f, -0.06579309f, 0.00676564f, -0.06742258f, -0.05458408f, 0.04038073f, -0.05704235f, -0.04924005f, 
    0.01618363f, -0.05880285f, -0.03799356f, -0.03786658f, 0.02939930f, 0.03133940f, 0.00515564f, -0.00816523f, 
    -0.05883939f, 0.01108047f, -0.05773066f, -0.01058434f, -0.00599102f, 0.04314281f, 0.04582693f, -0.04187557f, 
    0.00483578f, -0.00150526f, 0.03139037f, 0.03660485f, 0.02412522f, -0.01562159f, -0.01705259f, 0.01470280f, 
    -0.06765818f, 0.03823417f, 0.02222186f, 0.03653017f, -0.01629144f, -0.03065252f, -0.00573871f, -0.00741634f, 
    0.04344527f, -0.03118615f, 0.04627933f, 0.00424662f, 0.03670583f, 0.01800749f, 0.01044591f, 0.05328365f, 
    0.02430032f, -0.04944446f, 0.04092180f, 0.00899967f, 0.00939146f, 0.00999780f, -0.04233818f, -0.03097056f, 
    0.04935075f, 0.04476687f, -0.00139374f, 0.00396383f, -0.03767038f, -0.04775936f, -0.04363862f, 0.01565744f, 
    -0.04616543f, -0.06184066f, 0.01055572f, 0.02314095f, 0.02505831f, 0.02578789f, -0.03559116f, -0.04819311f, 
    -0.00583587f, 0.02379669f, -0.02555563f, -0.02913887f, -0.00939718f, -0.03361534f, -0.04323315f, 0.02374687f, 
    -0.04404096f, -0.05148234f, 0.04233798f, 0.03431943f, 0.00010067f, 0.00867083f, -0.04027707f, -0.01989135f, 
    0.06250532f, 0.04815724f, -0.03925444f, 0.01236037f, 0.02760471f, 0.01991670f, 0.04811291f, 0.00218655f, 
    0.04361763f, 0.01396904f, -0.04376225f, -0.01106041f, 0.05729862f, -0.02930642f, 0.03664672f, -0.02683887f, 
    -0.04094848f, -0.06683446f, 0.01962101f, -0.00445611f, -0.00160443f, -0.04235823f, 0.00902925f, -0.05689086f, 
    -0.03566002f, 0.02636452f, -0.00807805f, 0.02428852f, -0.01380369f, -0.01020543f, 0.00612762f, -0.00410583f, 
    -0.03050987f, -0.05930690f, 0.01393390f, -0.05096577f, 0.03417578f, -0.02870929f, -0.04437787f, -0.02807933f, 
    0.56483465f, 0.20743212f, -0.25433600f, -0.30473673f, 0.15968867f, 0.23630546f, -0.13128057f, 0.01973523f, 
    0.10260740f, 0.08453248f, 0.22306980f, -0.37052026f, -0.13211893f, 0.19221725f, -0.06293301f, -0.14747678f, 
    -0.09107483f, -0.22237369f, -0.23643741f, 0.09442277f, -0.39066601f, 0.03293489f, 0.04655280f, 0.08923298f, 
    0.01206040f, 0.12957214f, 0.08116394f, 0.02122866f, 0.10348734f, -0.02269200f, -0.18168300f, -0.11457620f, 
    0.15023501f, 0.00892553f, -0.12224930f, 0.07256316f, 0.05197501f, 0.26445401f, -0.13287647f, -0.13437323f, 
    0.01229098f, 0.04015855f, 0.14515357f, 0.08647676f, -0.00981641f, -0.09015539f, -0.20862943f, -0.13145658f, 
    -0.09442130f, 0.09288225f, 0.24990664f, -0.10522125f, -0.33192381f, -0.02133908f, 0.09950833f, -0.17550048f, 
    0.29361612f, 0.23554097f, -0.13856111f, 0.23694894f, 0.02956300f, 0.01811812f, -0.14212336f, -0.25493932f, 
    0.43472603f, -0.03273578f, 0.10572501f, 0.17172155f, 0.09836540f, -0.02049108f, 0.05572528f, -0.27593425f, 
    -0.41829678f, -0.20214169f, 0.04080655f, -0.05976125f, 0.08260559f, 0.11423606f, -0.04456826f, 0.12862620f, 
    0.09072477f, -0.01002953f, -0.47367159f, -0.15800254f, -0.00458508f, -0.25825688f, -0.22628196f, 0.06868787f, 
    0.00615960f, -0.14550620f, 0.16137125f, -0.16321893f, 0.27748734f, -0.00418062f, -0.04510094f, 0.14284199f, 
    -0.21664369f, 0.02448531f, -0.06439680f, -0.16308102f, 0.01184579f, -0.04104887f, -0.09328093f, 0.21515563f, 
    -0.02331145f, -0.23730560f, -0.03694284f, -0.05121292f, 0.01134406f, 0.01965933f, -0.22845365f, 0.03114836f, 
    0.09475317f, -0.00227392f, 0.00986847f, -0.08594862f, 0.10381687f, 0.43270299f, -0.67929560f, -0.23914841f, 
    0.01799671f, -0.05234217f, -0.10793500f, -0.37666127f, 0.14267653f, -0.06486525f, 0.27281463f, 0.10779013f, 
    -0.10385928f, 0.04383179f, -0.12217958f, 0.24676554f, 0.05457324f, 0.05217547f, -0.05889239f, 0.48943454f, 
    0.06049707f, -0.05024804f, 0.16520445f, -0.07529967f, 0.09322086f, -0.04735067f, 0.00098605f, 0.28696465f, 
    -0.08590543f, -0.12150232f, -0.38119391f, 0.22559711f, 0.07353937f, 0.06331678f, 0.04367878f, -0.19610386f, 
    0.20946242f, 0.24433234f, -0.09540504f, 0.21108063f, -0.23003276f, 0.02924862f, -0.10797600f, -0.04415365f, 
    0.09750037f, 0.03636740f, 0.27576953f, 0.44163114f, -0.29074028f, 0.04040217f, 0.04477907f, -0.03198547f, 
    -0.02859192f, -0.07363565f, -0.29889530f, -0.14331526f, -0.21320035f, -0.30592754f, -0.06098333f, 0.15441191f, 
    0.22850107f, -0.00817541f, -0.14407513f, 0.29322758f, 0.18678029f, -0.38843957f, -0.17663021f, -0.03231651f, 
    0.11976635f, 0.03097070f, 0.01736569f, 0.04725828f, -0.04651396f, 0.01301839f, -0.57688713f, -0.02271201f, 
    0.08788324f, 0.15389609f, -0.12390889f, -0.13112961f, 0.03473268f, 0.00829816f, -0.12613465f, -0.10161424f, 
    0.06596597f, -0.15960072f, -0.03136570f, -0.15696235f, 0.10407056f, 0.11364478f, -0.14577357f, 0.60807610f, 
    -0.31909665f, 0.09653792f, -0.07733285f, -0.00342244f, 0.14694810f, -0.04530106f, -0.04700471f, -0.15358277f, 
    -0.36537388f, -0.44954771f, 0.25458360f, -0.08245847f, 0.06057605f, -0.11324410f, 0.04935868f, 0.06521273f, 
    0.22184119f, -0.43421733f, -0.34159464f, 0.22322832f, 0.16666825f, 0.04596965f, -0.05104446f, 0.07710615f, 
    0.20840490f, 0.04758725f, 0.54642409f, 0.22936867f, 0.22305448f, 0.20239286f, 0.02471835f, -0.03995227f, 
    0.12337805f, 0.08025504f, 0.09253963f, 0.65165019f, -0.18208949f, 0.22577839f, -0.22698684f, -0.01352683f, 
    -0.05754573f, -0.18298744f, -0.04277056f, 0.02098725f, -0.55077845f, 0.02657902f, 0.01405048f, -0.04848480f, 
    0.12777542f, 0.01581689f, -0.02454576f, -0.15865280f, -0.04053947f, 0.12945752f, 0.24251930f, -0.07035014f, 
    -0.01734849f, 0.18640333f, -0.15875348f, -0.15331714f, 0.05141212f, -0.11387239f, 0.07101357f, 0.13350956f, 
    0.13068525f, 0.01431709f, -0.01060752f, 0.07230207f, -0.01730751f, 0.07291161f, 0.10162161f, -0.39413306f, 
    -0.25568759f, 0.12731732f, -0.03906199f, -0.10147834f, 0.04880403f, -0.07576952f, 0.02831320f, 0.19009633f, 
    0.12613527f, 0.29277116f, 0.47126770f, -0.00074512f, -0.04184908f, -0.16190939f, -0.13656439f, 0.05217100f, 
    -0.01409713f, 0.05806657f, 0.04057270f, -0.20550919f, -0.04735881f, -0.21711068f, 0.11912765f, -0.02701361f, 
    0.03682792f, 0.16231936f, -0.06186501f, 0.05515185f, 0.29864889f, 0.03302330f, 0.11802231f, 0.14323276f, 
    0.07150769f, -0.12616555f, 0.04517207f, 0.04202008f, -0.63708609f, -0.14141721f, 0.16001464f, 0.24186066f, 
    -0.06942676f, 0.02985293f, -0.05603133f, -0.08998397f, 0.14993122f, -0.20707254f, -0.19442292f, -0.44588566f, 
    -0.14133754f, -0.16308035f, -0.29016781f, 0.07584368f, 0.08024738f, -0.06067536f, 0.10621870f, 0.18926692f, 
    0.00987646f, 0.03888961f, -0.14181280f, 0.09362273f, -0.23068111f, 0.03066926f, 0.11412055f, -0.35959181f, 
    0.06652064f, 0.11935949f, -0.16552754f, -0.10741778f, -0.05600414f, -0.13005388f, -0.16751130f, 0.22499144f, 
    -0.08676348f, -0.06428979f, -0.20802233f, -0.10990570f, 0.24434625f, -0.21492639f, -0.06978237f, 0.03420685f, 
    -0.26745257f, -0.22245581f, 0.22447203f, -0.12748072f, 0.12557520f, -0.13891609f, 0.04258211f, 0.40111512f, 
    -0.10759194f, -0.60978544f, -0.00251742f, 0.06761412f, -0.14231192f, -0.07302935f, -0.02615301f, -0.06275030f, 
    0.25957716f, 0.16098760f, 0.35430905f, -0.11565544f, -0.59927976f, 0.04462515f, 0.21647871f, 0.14785658f, 
    0.12849015f, 0.12125672f, -0.03406318f, -0.01937540f, 0.27995476f, 0.26611167f, 0.03174526f, -0.15487590f, 
    0.10579928f, -0.00169735f, 0.03237712f, -0.05282671f, -0.20901465f, -0.09275077f, -0.08371781f, -0.02873715f, 
    0.04481461f, 0.08747020f, 0.17687012f, 0.04549138f, 0.02179964f, -0.27944025f, 0.57126731f, 0.17583169f, 
    -0.32529682f, -0.25003618f, 0.05754439f, -0.26014715f, -0.07499310f, 0.25150776f, 0.46659005f, 0.21178699f, 
    0.46245229f, 0.29076728f, -0.01128038f, 0.04257751f, -0.16939311f, 0.09750951f, -0.02928030f, 0.43497550f, 
    -0.01235035f, -0.40038276f, -0.04436060f, 0.04242279f, 0.07253532f, -0.22308064f, 0.13544399f, 0.02365652f, 
    -0.60311747f, -0.53500503f, -0.15251248f, 0.41983986f, -0.02424960f, 0.08166652f, 0.36210075f, -0.27292132f, 
    0.11993550f, 0.15706721f, -0.16840199f, 0.05626591f, 0.11656005f, 0.04601406f, 0.15968639f, 0.14391178f, 
    -0.10737921f, 0.08031783f, -0.14870755f, -0.25044730f, 0.13939123f, -0.10393174f, 0.22274196f, -0.07590052f, 
    -0.00275329f, -0.14983794f, -0.36968529f, 0.44877324f, -0.03380786f, -0.25162956f, 0.22502229f, -0.01612473f, 
    -0.03294473f, 0.18696843f, 0.18725935f, 0.16942535f, -0.35604608f, 0.50639760f, 0.50832820f, 0.18612899f, 
    0.10394028f, 0.10728026f, -0.25120971f, 0.03833891f, 0.12414515f, -0.36252141f, 0.19569567f, -0.01368926f, 
    -0.54473513f, -0.24689297f, -0.11801201f, 0.28763169f, -0.03464179f, 0.21373968f, 0.28772774f, 0.11097537f, 
    -0.07786366f, -0.00641301f, 0.30803135f, 0.20684373f, 0.23369601f, -0.15472421f, 0.04184100f, -0.32902810f, 
    0.02741616f, 0.22331883f, 0.01745324f, -0.03037207f, 0.01490270f, -0.03973236f, -0.22704954f, 0.21440627f, 
    -0.44955891f, 0.07081325f, -0.03171106f, 0.12342301f, 0.08969698f, -0.10971619f, 0.00904474f, 0.13954808f, 
    -0.04524530f, 0.53111392f, -0.04276679f, 0.16238569f, 0.04337995f, 0.09458008f, -0.09286042f, -0.06999109f, 
    0.36309603f, 0.12263210f, 0.50039190f, 0.21775542f, -0.00935177f, -0.04575005f, 0.21370371f, 0.03942942f, 
    -0.13219613f, 0.14402713f, -0.02108364f, 0.08164449f, -0.04698976f, -0.02284396f, 0.03107012f, 0.10019460f, 
    -0.08289864f, 0.01686950f, -0.22106284f, -0.10070737f, 0.28983676f, 0.33858836f, 0.08802950f, -0.47717565f, 
    -0.23486510f, 0.10085370f, -0.15038703f, 0.06242552f, -0.00115040f, -0.10816351f, 0.16616067f, 0.08654536f, 
    0.10980607f, -0.24622230f, -0.10059235f, -0.22202189f, 0.07402816f, 0.21390745f, -0.07675508f, -0.18011306f, 
    -0.16873422f, -0.09652215f, 0.02897021f, -0.12556024f, 0.17804684f, -0.02749574f, 0.03382720f, 0.00664879f, 
    0.27349868f, 0.14238781f, -0.29762998f, 0.13768446f, -0.07187884f, 0.22796348f, -0.01654145f, -0.02547423f, 
    -0.40191954f, 0.11416785f, -0.15295756f, 0.29984540f, 0.08205580f, -0.10169893f, -0.15667446f, 0.16379499f, 
    0.30493695f, -0.19852526f, -0.19765234f, -0.07762141f, -0.01678691f, -0.03694538f, 0.35313109f, -0.11962373f, 
    -0.10366771f, -0.14628413f, 0.41484922f, 0.39386624f, -0.14602418f, 0.08708681f, 0.17979622f, 0.15858735f, 
    0.13986380f, -0.49766538f, -0.11966500f, -0.09248653f, -0.10232361f, 0.15575282f, 0.11754108f, -0.03326753f, 
    -0.10242909f, 0.12132050f, 0.06065412f, -0.14860441f, -0.05836533f, -0.39625472f, -0.05980259f, 0.15156740f, 
    0.01903659f, -0.03381070f, 0.08333959f, -0.01449256f, 0.31424013f, 0.16565663f, 0.20031811f, -0.45333284f, 
    0.21221319f, -0.06104730f, -0.15066320f, -0.12168201f, 0.05450774f, 0.01831578f, -0.39653730f, 0.26548019f, 
    0.04132626f, -0.16139054f, 0.08867054f, 0.21986821f, -0.14759240f, 0.17521970f, -0.13276133f, 0.05326569f, 
    -0.43085605f, 0.05276944f, 0.19745767f, 0.06285433f, 0.32753533f, 0.01262961f, -0.04391211f, 0.06763243f, 
    0.11089048f, 0.06951552f, -0.04214864f, -0.12384544f, -0.42417225f, -0.07455493f, -0.08814684f, -0.10580176f, 
    0.12179331f, -0.10498945f, 0.06765102f, -0.05654340f, -0.10752752f, 0.11569267f, -0.04309876f, -0.05619249f, 
    0.08958612f, -0.21108784f, 0.39363825f, -0.02902702f, 0.01787795f, -0.16437578f, -0.05686332f, 0.05988429f, 
    0.18971704f, 0.11629912f, 0.10539376f, 0.03589577f, -0.05485548f, 0.09812060f, -0.11075243f, -0.03921294f, 
    0.08912931f, 0.06369406f, 0.03225478f, 0.06311723f, 0.22001092f, 0.17121118f, 0.19853781f, 0.25933290f, 
    -0.13958366f, 0.17084195f, -0.21062893f, -0.14066438f, -0.02545655f, 0.33122653f, -0.09083872f, -0.22583726f, 
    -0.14396086f, 0.12381393f, -0.15057597f, 0.03322454f, 0.19128671f, -0.06548171f, 0.07966887f, 0.26465246f, 
    0.08178055f, 0.14203197f, 0.09146176f, -0.10079250f, 0.04389909f, 0.00744522f, -0.13702185f, 0.47803399f, 
    0.13944145f, -0.08425887f, 0.01545629f, 0.26281935f, -0.21014524f, 0.27409136f, 0.05534170f, -0.03847353f, 
    0.16894911f, 0.00856943f, -0.18406297f, 0.04798434f, -0.18948026f, 0.15049782f, -0.02546823f, -0.22368948f, 
    -0.33864591f, 0.13019419f, 0.34206918f, -0.08463111f, -0.24665567f, -0.13131207f, -0.04134113f, 0.02148349f, 
    0.34606582f, 0.23140632f, -0.40182811f, 0.21417473f, 0.00946826f, 0.29020843f, -0.05236572f, -0.06734152f, 
    0.11218506f, -0.04399603f, -0.06741538f, 0.00857437f, 0.13380253f, 0.00161368f, -0.11864702f, 0.19972639f, 
    -0.01067483f, -0.14424787f, 0.13206688f, 0.00039973f, -0.14411207f, 0.22905798f, 0.19959405f, -0.26705220f, 
    -0.07403270f, 0.22127762f, -0.10609080f, -0.01248694f, 0.13764770f, 0.33041993f, -0.21292946f, -0.04398487f, 
    0.00124289f, -0.08488899f, -0.02172693f, -0.07181968f, -0.02935325f, -0.06137305f, -0.54574364f, -0.28006554f, 
    -0.10439488f, 0.01134590f, -0.10716971f, 0.06474965f, 0.05160133f, 0.01279579f, -0.02011279f, -0.21442343f, 
    0.10311802f, -0.18865316f, -0.01093383f, -0.00353980f, -0.01190954f, -0.08726351f, -0.04099915f, 0.04437575f, 
    0.09891207f, 0.16686492f, -0.29798818f, 0.07142072f, -0.11558869f, 0.10927452f, -0.09186821f, 0.03688461f, 
    -0.13757132f, -0.20693727f, -0.32398665f, -0.16665402f, 0.22044069f, -0.00691281f, 0.04196517f, 0.15593746f, 
    -0.09575821f, 0.21936497f, -0.00621732f, 0.16047004f, 0.01611712f, -0.08128519f, 0.16413598f, -0.22118470f, 
    0.19301838f, 0.11698419f, -0.07576053f, 0.01763605f, 0.42205697f, -0.05881959f, -0.02186780f, -0.11117589f, 
    -0.05113440f, 0.09131197f, 0.35411066f, 0.18394436f, -0.24817552f, -0.83295989f, 0.15104038f, 0.08103441f, 
    0.19815713f, 0.18352109f, -0.10910802f, -0.11870199f, -0.20551586f, 0.39107916f, -0.01797202f, 0.11787838f, 
    0.04439637f, -0.01196584f, 0.15431678f, 0.05229940f, 0.04796653f, -0.06662152f, -0.13794515f, -0.39006448f, 
    -0.10244316f, -0.18313506f, -0.22051594f, -0.10629966f, -0.03020842f, -0.01150186f, 0.32680449f, -0.48761496f, 
    -0.12325179f, -0.06231195f, 0.14653885f, 0.04694947f, 0.12179066f, 0.01966773f, -0.16035305f, 0.21435416f, 
    -0.26406199f, 0.62888712f, 0.02482370f, -0.02807905f, 0.00218463f, -0.05106287f, 0.01798937f, -0.07135215f, 
    0.29755935f, -0.02604206f, -0.02864231f, -0.31407613f, -0.37264428f, 0.12905465f, 0.20145291f, -0.10619012f, 
    0.00935379f, -0.08528110f, 0.26960400f, -0.24918611f, -0.20373908f, -0.00946292f, -0.06318064f, -0.19239467f, 
    0.01567652f, 0.08863256f, 0.28724808f, -0.43327469f, 0.04061648f, -0.33816212f, -0.06322945f, -0.11098468f, 
    -0.02514513f, 0.05734323f, 0.13872848f, -0.18740731f, 0.30635586f, 0.08018741f, 0.20169246f, -0.04501941f, 
    -0.17344792f, 0.00615988f, 0.23061721f, -0.03943907f, -0.17003307f, -0.41239023f, -0.33481950f, 0.20358330f, 
    0.09781898f, -0.04655964f, -0.29473880f, -0.17778772f, 0.02182392f, 0.02830387f, 0.36480752f, 0.40642318f, 
    -0.25985250f, -0.07401147f, 0.34317356f, 0.09267194f, -0.05609171f, -0.29527909f, -0.14978680f, 0.45004171f, 
    -0.58120263f, 0.26318896f, -0.17789634f, 0.04709142f, 0.12433256f, -0.01126790f, 0.14488655f, -0.00473862f, 
    -0.48295805f, -0.50206357f, -0.04854238f, 0.00387629f, -0.08965594f, 0.02558012f, 0.09710442f, -0.05758796f, 
    -0.11584193f, -0.12063052f, -0.29149082f, -0.19198325f, -0.12988414f, -0.01446158f, 0.16503587f, 0.00277504f, 
    -0.08528802f, -0.00725529f, -0.08374383f, -0.46963039f, -0.04120354f, 0.12021722f, 0.10486361f, -0.09109044f, 
    0.17062481f, -0.07415301f, -0.06786348f, -0.19825749f, -0.09350494f, -0.27060756f, -0.10146547f, -0.10725869f, 
    -0.00210680f, 0.00241515f, -0.11694236f, -0.29106283f, 0.20094113f, 0.07343508f, -0.26525083f, 0.04926979f, 
    0.10274134f, -0.12729065f, -0.03022036f, 0.10997748f, 0.02588566f, 0.11165079f, -0.31848446f, 0.13888991f, 
    -0.12996776f, 0.00392320f, -0.04144335f, -0.08845346f, 0.11960305f, 0.20174929f, 0.01376044f, 0.31766617f, 
    0.04429860f, -0.05010350f, 0.20455225f, 0.10243249f, -0.07312654f, 0.05113100f, 0.09105314f, 0.04840227f, 
    0.31586301f, -0.16557574f, 0.23097152f, -0.10799263f, 0.09600492f, -0.03452879f, -0.02108656f, 0.07111662f, 
    0.14356792f, 0.00993999f, -0.14655827f, -0.10554080f, 0.08844478f, 0.23381107f, 0.27349237f, 0.14756012f, 
    -0.30127880f, 0.29489985f, 0.18170609f, 0.04723270f, 0.17954925f, 0.07054866f, -0.15210962f, 0.42517310f, 
    0.27313590f, 0.07577524f, -0.33603847f, -0.13444066f, -0.00607320f, 0.06479100f, 0.16218543f, -0.02983264f, 
    -0.08850750f, -0.03870790f, -0.24816003f, 0.11703619f, 0.24988577f, 0.09276169f, -0.00853267f, -0.10617211f, 
    0.16567814f, 0.12081140f, 0.01727589f, 0.18345861f, -0.14615378f, 0.20584241f, 0.00853209f, -0.07816669f, 
    0.13170525f, 0.03769863f, 0.04256683f, -0.04610914f, -0.11225910f, 0.00762354f, -0.24305482f, 0.03963275f, 
    -0.14179869f, 0.11861894f, 0.04684372f, -0.07753522f, 0.03348734f, 0.20297538f, -0.20313823f, 0.21647696f, 
    0.19422100f, 0.16411124f, -0.16535421f, -0.00820794f, 0.06207521f, -0.03169627f, -0.18056290f, -0.08172844f, 
    0.26025477f, -0.32576418f, -0.07975219f, 0.18963496f, 0.23410125f, 0.00856960f, -0.19481836f, -0.16978231f, 
    -0.17196134f, 0.15352698f, -0.07936599f, -0.14174758f, -0.07316731f, 0.03691505f, 0.00815822f, 0.15578663f, 
    -0.26532057f, 0.05183283f, -0.09404236f, -0.37012503f, 0.05472787f, 0.23638257f, 0.00546906f, -0.02470363f, 
    0.09475707f, -0.19311957f, -0.39009491f, 0.20554759f, 0.02273672f, 0.10952606f, 0.32960066f, 0.01030437f, 
    0.22648108f, 0.15142186f, 0.04828931f, 0.20676735f, 0.31994912f, 0.18832386f, 0.08412193f, -0.06508814f, 
    -0.12481382f, 0.31624806f, 0.23860410f, 0.15163617f, 0.45713603f, -0.33917636f, 0.29547676f, 0.03346918f, 
    -0.21415775f, 0.10532963f, 0.19247051f, 0.00135650f, 0.11786631f, -0.13764921f, -0.24377057f, -0.07255206f, 
    0.01124947f, -0.04398264f, 0.08882670f, 0.04415744f, -0.10527951f, 0.06735392f, 0.10087991f, 0.01786977f, 
    -0.13323471f, -0.08057448f, -0.15639313f, 0.01318383f, 0.08637907f, -0.02499302f, -0.08114419f, 0.47614783f, 
    0.13883196f, 0.18527423f, 0.01015570f, 0.12694772f, -0.10112704f, -0.08396016f, 0.10532995f, 0.11676694f, 
    -0.04901400f, -0.03899280f, -0.01953717f, -0.02731665f, -0.06445923f, 0.02507369f, -0.04969341f, -0.01448839f, 
    -0.04251248f, -0.00558085f, -0.00053268f, -0.06519562f, 0.03655819f, -0.04276345f, -0.02620229f, -0.00005939f, 
    0.03493793f, -0.02707385f, 0.01685526f, -0.04238122f, 0.02840576f, -0.02962339f, 0.02508953f, -0.06667938f, 
    -0.03369443f, -0.06164140f, -0.05885229f, -0.01375591f, -0.00262283f, -0.06710648f, 0.03853444f, -0.05145541f, 
    0.04017263f, -0.06402098f, -0.02251604f, -0.02373669f, -0.06210934f, -0.00648307f, -0.02303455f, 0.04665738f, 
    0.01665997f, -0.01638678f, 0.04558070f, -0.04452940f, 0.01285004f, 0.04648826f, -0.02835248f, -0.05049996f, 
    -0.05211424f, 0.02781579f, -0.05778724f, 0.01485058f, 0.03198719f, -0.06254081f, 0.04671042f, 0.03898079f, 
    -0.01621551f, -0.01472507f, -0.03320006f, 0.01229677f, -0.04720975f, -0.06309510f, -0.03635348f, 0.02847829f, 
    -0.04480242f, 0.02948535f, -0.04648825f, -0.04506040f, -0.03435702f, 0.00425480f, 0.03160228f, 0.04906204f, 
    -0.01478066f, -0.01412267f, -0.04261110f, -0.04630433f, -0.02881566f, 0.00462150f, -0.04230759f, -0.01856295f, 
    0.00285219f, -0.03462042f, 0.03907309f, 0.03998263f, 0.03154811f, -0.06748681f, 0.04586211f, -0.02401174f, 
    0.01359983f, 0.00572352f, 0.04062235f, -0.00225456f, -0.01788318f, 0.02818524f, 0.03923352f, 0.02473964f, 
    0.03029092f, -0.03979226f, 0.04812431f, -0.02592117f, -0.01781114f, -0.05769507f, 0.03520411f, -0.01503926f, 
    -0.04254865f, -0.00147909f, 0.03382075f, 0.00389619f, 0.02196519f, 0.03612925f, 0.00650715f, -0.05764884f, 
    -0.05773764f, 0.00122663f, 0.04479814f, 0.04436860f, -0.04417199f, -0.03782693f, -0.01088241f, 0.03483531f, 
    -0.01851266f, -0.05258166f, -0.04468023f, 0.04937231f, -0.05578607f, 0.03000095f, -0.02599237f, -0.03024676f, 
    0.01649965f, -0.05000819f, 0.02340206f, 0.01279853f, -0.02733110f, -0.00479613f, -0.00349012f, 0.02471176f, 
    0.02442915f, 0.03783176f, 0.00414700f, -0.03359032f, 0.03949107f, -0.00351121f, -0.00191938f, -0.00957811f, 
    0.03530458f, -0.01858224f, 0.02438253f, -0.05289556f, 0.01438484f, -0.04186746f, 0.02718886f, -0.04223584f, 
    0.04167905f, 0.04163261f, 0.03483762f, 0.04285710f, -0.03028382f, 0.00285784f, 0.01813663f, -0.04013959f, 
    -0.06287178f, 0.03534901f, -0.05188688f, 0.04306404f, 0.00209240f, 0.00745188f, -0.04763656f, -0.00051286f, 
    -0.02208387f, 0.03244328f, -0.02060898f, -0.02613864f, 0.02839836f, -0.04194895f, -0.04323904f, -0.04849781f, 
    -0.03604753f, -0.04586542f, -0.02265408f, -0.00682461f, 0.02094917f, 0.01900796f, -0.02118718f, 0.02312683f, 
    -0.02993590f, 0.02920847f, -0.03306202f, -0.04178734f, -0.05725601f, 0.01020314f, -0.03608069f, -0.04248387f, 
    0.01350997f, -0.02422463f, -0.05834651f, 0.00669282f, -0.06434300f, -0.04070780f, -0.01047929f, 0.00079192f, 
    -0.04693985f, 0.00113255f, 0.03312177f, -0.01093498f, -0.01976903f, -0.05956336f, -0.02476160f, 0.01420517f, 
    0.04573519f, 0.00017257f, 0.04903693f, -0.02046520f, -0.06372010f, 0.01056302f, 0.02071110f, 0.02746566f, 
    0.02847615f, -0.05527752f, 0.02359747f, 0.03241759f, 0.02173916f, -0.02757676f, 0.01708475f, -0.04739402f, 
    -0.01435706f, 0.03268301f, 0.05006730f, -0.04897950f, -0.06288766f, -0.04887887f, -0.01760982f, -0.06280268f, 
    0.00172329f, -0.03747399f, -0.03427256f, 0.04903628f, 0.02770147f, 0.01958859f, -0.05851362f, -0.05977148f, 
    0.01749170f, -0.05754385f, -0.02926493f, -0.01070129f, -0.04609533f, 0.04338912f, 0.00135254f, -0.06153341f, 
    0.01050336f, -0.03144095f, -0.00850168f, 0.01415058f, -0.01893220f, -0.04934672f, 0.01711494f, -0.02554983f, 
    -0.06157223f, -0.03189478f, 0.03769543f, -0.02706258f, 0.02062142f, -0.02593383f, 0.02687694f, 0.03206497f, 
    -0.04170938f, -0.01072745f, 0.01976857f, -0.04907028f, 0.02176694f, 0.03596459f, -0.04893243f, -0.02806565f, 
    0.02699169f, 0.03481928f, -0.06491238f, -0.00770070f, 0.04334891f, -0.01786620f, -0.01598770f, 0.01184632f, 
    -0.01176041f, 0.03299309f, 0.04567603f, 0.00431055f, 0.03074513f, -0.02967140f, -0.06672762f, -0.02142484f, 
    -0.63497961f, -0.00519455f, 0.14667001f, -0.10626991f, 0.08574522f, -0.31829366f, -0.04491967f, -0.05324671f, 
    0.10689238f, -0.13034223f, -0.07918839f, -0.35413221f, 0.23099574f, 0.10089503f, 0.10192191f, -0.19772455f, 
    -0.18405506f, -0.11833864f, 0.22425213f, -0.09198487f, -0.12282580f, 0.31393212f, 0.00279126f, 0.23902108f, 
    0.17447424f, -0.01893789f, 0.13352609f, 0.05333742f, -0.15946724f, 0.48936221f, -0.16538773f, 0.13774954f, 
    0.00485920f, 0.14538893f, 0.11756895f, -0.08488844f, 0.36484921f, 0.36225671f, 0.19807296f, 0.04430622f, 
    -0.14940019f, -0.23193580f, -0.05447952f, 0.18549894f, 0.11690654f, 0.62005806f, 0.09913833f, 0.08569437f, 
    -0.01305206f, 0.06319665f, -0.03361901f, 0.03600300f, 0.05693400f, -0.14490105f, -0.25817075f, -0.29676884f, 
    0.00363746f, 0.08983574f, -0.06069666f, 0.16275948f, 0.18900257f, 0.11851931f, -0.00443266f, 0.42471468f, 
    0.54333013f, -0.23832001f, 0.08050224f, -0.12156788f, 0.02893823f, 0.19885179f, -0.12071972f, -0.02788424f, 
    0.24206494f, -0.02721195f, -0.45424190f, 0.18656613f, 0.03098227f, -0.19236016f, 0.11067735f, 0.12043995f, 
    -0.08615840f, 0.12773144f, -0.23401275f, -0.02256326f, -0.16525660f, 0.05393187f, -0.27807465f, 0.00750156f, 
    0.03738517f, -0.14456421f, 0.09258874f, -0.07786696f, 0.19115572f, 0.04425980f, 0.19512224f, 0.07842098f, 
    -0.21410628f, -0.21801622f, -0.18100923f, 0.34023535f, 0.11009598f, 0.10035411f, 0.03060391f, 0.04688295f, 
    -0.11201918f, 0.12697175f, 0.01984534f, -0.09684617f, -0.60534513f, -0.03967091f, -0.18614095f, 0.09823510f, 
    -0.08234613f, 0.05219398f, -0.13971983f, 0.07624722f, 0.09429265f, 0.33150813f, 0.58425051f, 0.28516477f, 
    -0.22466615f, -0.00079948f, 0.10615092f, 0.06148640f, -0.10072318f, 0.09846737f, -0.69780850f, -0.37926683f, 
    0.03522100f, -0.11614018f, -0.13046533f, 0.05284556f, -0.05725762f, 0.09108843f, 0.08821405f, -0.33440480f, 
    -0.32237396f, 0.09963231f, 0.04785993f, -0.17120636f, 0.36597723f, 0.00017846f, 0.05211008f, 0.03081954f, 
    -0.27235368f, -0.30801731f, -0.35696971f, 0.22725318f, -0.00819186f, 0.04410670f, -0.12532768f, 0.16500479f, 
    0.31797346f, -0.15967761f, -0.07089376f, 0.47225282f, -0.12669948f, -0.07504451f, -0.15397848f, 0.04478368f, 
    0.04331517f, -0.05437474f, 0.07629715f, -0.10538253f, -0.13562888f, -0.22132993f, 0.13358024f, 0.12568563f, 
    -0.02024401f, 0.05039321f, 0.06940599f, -0.33627751f, 0.24668725f, -0.36468589f, -0.28028789f, 0.00074365f, 
    -0.03529979f, -0.18458700f, 0.00648614f, 0.34833616f, -0.73181772f, -0.76509166f, -0.14431392f, -0.16505928f, 
    0.03698757f, 0.18092602f, 0.10994576f, 0.02697786f, 0.11051055f, 0.07192727f, 0.18384828f, -0.69793040f, 
    -0.08517408f, -0.20185585f, 0.16781399f, -0.03404192f, 0.15158771f, 0.08463556f, 0.42284718f, -0.08452288f, 
    0.10833945f, 0.15367068f, -0.11450399f, -0.22521025f, 0.08281466f, 0.11657087f, -0.03301519f, -0.01386630f, 
    0.23924296f, -0.13000594f, 0.27227801f, 0.10664492f, -0.04174135f, 0.00029488f, -0.10781321f, -0.15076557f, 
    0.55967349f, 0.05481453f, -0.14453185f, 0.04718573f, 0.15871651f, -0.04190100f, 0.09258635f, -0.05231128f, 
    0.04792206f, -0.23509859f, -0.20044838f, 0.05300661f, -0.09818441f, 0.25463802f, 0.10037178f, 0.15557389f, 
    0.05987584f, 0.21167189f, -0.37279251f, -0.28084865f, 0.07724888f, -0.06833708f, 0.06568847f, -0.08073014f, 
    -0.17957374f, -0.00032479f, 0.06315896f, 0.16766737f, -0.19807066f, 0.15573314f, -0.15941842f, -0.15168999f, 
    0.10409649f, -0.02230739f, -0.01921112f, -0.09335225f, 0.73989594f, 0.17235436f, -0.36663207f, 0.08639193f, 
    -0.05665344f, -0.26026794f, 0.07471902f, -0.08381753f, -0.14886937f, 0.17258638f, 0.47225443f, -0.61375731f, 
    0.19238959f, 0.12491374f, -0.00438203f, 0.22647287f, 0.00699539f, 0.00482933f, 0.45771903f, 0.05022555f, 
    0.33021975f, -0.12488674f, -0.10029521f, 0.19235876f, 0.05385068f, -0.06677713f, -0.04473528f, 0.35534450f, 
    0.01071145f, 0.10491826f, 0.17466378f, -0.10220762f, -0.09124565f, -0.02209345f, 0.01673885f, -0.03187367f, 
    0.01544417f, -0.06105372f, 0.00539829f, 0.01005870f, -0.03694537f, -0.02704993f, 0.00297606f, -0.03996440f, 
    -0.01792479f, -0.06687587f, 0.00172932f, 0.00111536f, -0.02342959f, 0.01331939f, -0.05377420f, 0.04613487f, 
    -0.04531569f, -0.02281498f, -0.03068969f, -0.02473012f, -0.00583691f, 0.03927380f, -0.03000088f, -0.06721357f, 
    -0.03454397f, -0.02750590f, -0.05081573f, -0.05468286f, 0.03252748f, -0.00430966f, 0.02232310f, -0.01733496f, 
    -0.01142830f, 0.02411855f, 0.04250209f, 0.00330146f, -0.06589792f, -0.03641744f, -0.02788690f, -0.01524106f, 
    -0.01866571f, 0.04498440f, 0.02603155f, -0.03922451f, 0.00271016f, -0.01875691f, -0.04957137f, 0.02736318f, 
    -0.06745770f, 0.03280490f, -0.00939967f, -0.00356609f, 0.00632713f, 0.04028754f, 0.00373363f, 0.00451193f, 
    0.04649312f, -0.06468810f, 0.01399571f, 0.00441801f, 0.02343548f, -0.01090798f, 0.03991476f, -0.06628633f, 
    -0.05786870f, -0.00541640f, -0.03525960f, -0.03443703f, 0.01506334f, 0.02880501f, 0.00849284f, 0.02035189f, 
    0.04680613f, 0.03552898f, -0.04713566f, -0.05752108f, -0.03204685f, 0.02167334f, 0.03546550f, -0.05065773f, 
    -0.05716198f, 0.02557234f, 0.03903040f, 0.03492936f, -0.02484884f, 0.03247986f, -0.05787474f, -0.04503592f, 
    -0.04018408f, 0.04171645f, -0.02487883f, -0.01953282f, -0.04278715f, -0.06287379f, 0.00483520f, 0.01799332f, 
    0.02299090f, -0.05507990f, -0.00517758f, -0.05533497f, -0.05248555f, -0.04902744f, 0.03389196f, 0.01759154f, 
    0.01267952f, 0.04106992f, 0.03049557f, -0.00576753f, 0.04943174f, -0.00756316f, 0.02327315f, -0.00057273f, 
    -0.05030882f, -0.04746689f, -0.00231927f, 0.00314220f, 0.00052545f, -0.06730949f, -0.04332176f, 0.02237482f, 
    0.01430000f, -0.02949696f, 0.01626665f, -0.00817998f, 0.00297210f, 0.01697565f, -0.02436418f, 0.03514472f, 
    0.03751758f, -0.04912670f, -0.01683647f, 0.00573183f, -0.05719583f, 0.01617864f, 0.03192128f, -0.04246058f, 
    -0.05016670f, -0.02093657f, -0.02567114f, -0.03220779f, -0.06143693f, -0.05698542f, -0.02554973f, -0.04959144f, 
    0.04385311f, -0.00999520f, -0.00093010f, -0.06586512f, -0.03689727f, -0.05603998f, 0.01672168f, -0.01689648f, 
    -0.01929958f, 0.01879422f, -0.05996485f, -0.00259752f, 0.03844852f, -0.02038030f, -0.06461877f, 0.00782367f, 
    -0.02569895f, 0.04530510f, 0.04708196f, 0.02638108f, 0.02849688f, -0.04446559f, 0.02046848f, 0.04739350f, 
    -0.06835900f, -0.02333502f, -0.04554725f, 0.02934820f, -0.04921657f, -0.02210116f, 0.03663908f, -0.03784578f, 
    -0.03404261f, 0.00972808f, 0.03488351f, 0.03869734f, -0.01287430f, 0.02817115f, 0.00002946f, -0.04163050f, 
    0.00491669f, -0.02765108f, -0.01205468f, -0.02214945f, -0.01218326f, -0.00971712f, -0.04869756f, 0.01000425f, 
    0.01505986f, 0.02988038f, -0.04921943f, -0.06960569f, -0.02539432f, 0.04130975f, -0.03325123f, 0.01745630f, 
    0.02491204f, 0.00125741f, -0.04660589f, -0.00281340f, -0.04159699f, -0.01494117f, -0.03198890f, -0.01703468f, 
    -0.00032234f, -0.01081463f, -0.05689044f, 0.00644411f, 0.00433001f, -0.07081735f, 0.02869326f, -0.06088741f, 
    -0.01577537f, 0.01134660f, 0.04793837f, -0.04435925f, 0.02554786f, 0.03846803f, 0.00156861f, -0.02220803f, 
    0.02150147f, -0.06994312f, 0.00352737f, 0.03848961f, -0.05657924f, -0.02130633f, 0.00250211f, -0.02741778f, 
    0.02078267f, -0.03033496f, 0.00611501f, 0.04025711f, -0.03569986f, 0.04312399f, 0.00627166f, -0.06259561f, 
    -0.02015402f, -0.02813927f, -0.06709153f, -0.04959661f, -0.05191739f, -0.00760180f, -0.03994091f, -0.06091275f, 
    -0.03119001f, 0.01248104f, 0.03304957f, -0.03750565f, 0.03778221f, 0.00107248f, 0.00451482f, -0.04148743f, 
    0.02940187f, -0.00407157f, -0.02557224f, 0.00301374f, -0.04026984f, -0.00692632f, 0.04883232f, -0.01069335f, 
    -0.02780535f, 0.03776563f, 0.04621301f, 0.04553009f, 0.02612429f, 0.03381706f, 0.04228010f, 0.03614201f, 
    0.01584462f, 0.01366551f, -0.06771544f, -0.01608184f, -0.02104610f, -0.04812826f, -0.02608918f, -0.03895287f, 
    -0.06829330f, 0.03932963f, 0.02524973f, -0.00564581f, -0.02461022f, 0.02585972f, -0.01183390f, 0.00383312f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02379923f, 0.05629346f, 0.21830785f, -0.10082366f, 0.02221666f, -0.01988957f, 0.02571243f, -0.04739064f, 
    -0.05375009f, -0.06971019f, 0.04836005f, 0.02519603f, 0.01964177f, 0.02231806f, -0.03344348f, 0.03205335f, 
    0.01021979f, 0.24338804f, -0.05696643f, 0.30614084f, 0.16771396f, -0.14285845f, 0.10758760f, -0.11609380f, 
    -0.04963144f, 0.09302807f, -0.00839808f, -0.01136975f, -0.06079564f, -0.00796553f, 0.20628849f, 0.03999631f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13048413f, -0.44988856f, -0.00259940f, 0.08926164f, 0.06961001f, 0.14532667f, -0.13809744f, -0.19630723f, 
    0.03782020f, -0.03231299f, 0.12489023f, 0.13170928f, -0.04969573f, -0.04140401f, 0.14203492f, -0.10443175f, 
    0.08371664f, -0.55812407f, -0.05472258f, -0.08560895f, 0.00004869f, -0.21515681f, 0.28139424f, -0.07185404f, 
    0.02796645f, -0.20753287f, 0.89566118f, -0.42935771f, 0.50371331f, -0.15023574f, -0.68847877f, -0.11173215f, 
    0.11670209f, 0.50803214f, -0.35176727f, -0.40447649f, 0.14107122f, -0.05874188f, -0.00188226f, -0.53454781f, 
    0.01446026f, 0.02873496f, 0.15671363f, 0.06006052f, -0.06324738f, 0.15301815f, 0.03881937f, -0.16249073f, 
    0.05428704f, -0.05567547f, 0.03541731f, -0.03361709f, 0.18792963f, -0.17526415f, 0.62846345f, -0.61677879f, 
    0.11103024f, 0.36525634f, 0.06271416f, 0.25689259f, 0.44507697f, -0.04070742f, -0.01134042f, 0.13994172f, 
    -0.01500257f, 0.40943247f, -0.16465482f, 0.26025674f, -0.15851757f, 0.07248104f, -0.08540160f, -0.19405386f, 
    0.01407485f, -0.15214019f, 0.14814568f, -0.01028386f, 0.12164731f, -0.02566984f, 0.10664292f, -0.08716989f, 
    -0.16014370f, -0.66395557f, 0.03547850f, -0.19402447f, -0.27012518f, -0.18587178f, 0.28764874f, 0.20183614f, 
    0.02839680f, 1.21024334f, -0.11598166f, -0.42656529f, -0.61519259f, 0.15349998f, 0.25258076f, -0.03034194f, 
    -0.07203127f, -0.20826456f, 0.21363874f, 0.49065694f, -0.05952076f, -0.06080896f, 0.09274327f, -0.32529870f, 
    -0.04604414f, -0.08849831f, -0.15818129f, -0.09696643f, 0.03591231f, 0.01288682f, -0.05798101f, -0.11447866f, 
    0.01100735f, -0.17610693f, -0.12340949f, -0.41302717f, 0.73287451f, 0.09147964f, -0.46195462f, 0.02676465f, 
    0.07794431f, -0.10455838f, -0.38917035f, 0.73455471f, -0.03230413f, -0.02180473f, 0.16425070f, -0.03091088f, 
    0.05585789f, -0.80925912f, 0.08649058f, 0.33118322f, -0.10935526f, 0.03176530f, -0.05104395f, 0.09481839f, 
    0.10307698f, 0.12146832f, -0.08749578f, -0.01855274f, 0.04288050f, -0.14437963f, 0.01745978f, -0.10327560f, 
    -0.08122258f, 0.44315460f, 0.08792058f, 0.08206342f, 0.47087356f, 0.29121158f, -0.09174267f, -0.20545171f, 
    0.01915939f, 0.22169879f, -0.30066693f, -0.56981105f, 0.05489914f, 0.03317248f, -0.26762816f, -0.15535302f, 
    -0.10748535f, 0.44912970f, -0.36796340f, -0.16155246f, 0.17771320f, -0.01384580f, -0.03923924f, 0.16793975f, 
    -0.15668212f, -0.03799590f, -0.14046238f, -0.10670878f, -0.10468661f, -0.10831404f, -0.01463586f, 0.12779336f, 
    -0.14961140f, 0.15764652f, -0.11639865f, 0.52617931f, -0.60510355f, -0.40416521f, -0.02246810f, -0.59808993f, 
    -0.02664958f, -0.75988245f, 0.11380518f, 0.18655939f, -0.16205500f, -0.03542649f, -0.60047078f, -0.12018801f, 
    -0.15184809f, 0.11251006f, -0.05829393f, 0.44143969f, -0.08622717f, 0.12873252f, -0.05161288f, -0.31840676f, 
    0.01528494f, -0.13664594f, 0.00670092f, -0.09725354f, 0.11261264f, -0.04127261f, -0.02312394f, 0.11438622f, 
    -0.12434378f, -0.17018767f, -0.13408834f, 0.31847656f, 0.39276993f, -0.75569379f, -0.91497523f, -0.12040594f, 
    -0.10813519f, -0.61068654f, -0.16899629f, -0.22711867f, 0.19245850f, 0.16308445f, 0.60381442f, 0.01191190f, 
    -0.05711980f, -0.04712315f, -0.00219453f, -0.11564698f, -0.12194943f, 0.16754635f, -0.11607338f, 0.18606468f, 
    0.01096348f, 0.05824463f, -0.10368404f, -0.08427393f, 0.11754023f, 0.10857398f, 0.04548011f, 0.09904929f, 
    0.07902440f, -0.18005556f, 0.12645975f, -0.38275850f, -0.68844509f, 0.90177077f, -0.02089581f, 0.30460104f, 
    0.10953778f, -0.15842728f, -0.06247266f, -0.00021843f, 0.42042866f, -0.09704462f, -0.82565379f, 0.04008158f, 
    0.01460661f, 0.03703682f, -0.72945380f, -0.86108989f, 0.14431399f, 0.11549693f, -0.06755603f, -0.08564291f, 
    0.11292461f, 0.10837441f, -0.11862916f, 0.03405108f, -0.04843017f, 0.01038952f, -0.04381257f, -0.06733254f, 
    0.01385416f, 0.75703114f, 0.16064551f, -0.21790574f, -0.70427763f, -0.07385214f, 0.61400390f, 0.48222467f, 
    -0.09276291f, -0.58134288f, -0.09976612f, 0.27019051f, -0.17715946f, -0.10384407f, 0.36220181f, -0.14791501f, 
    -0.16070424f, -0.83720022f, -0.10868978f, 0.19192733f, 0.13335814f, -0.09791645f, 0.03876574f, 0.03493270f, 
    -0.12868381f, -0.07565688f, -0.05596677f, 0.05590020f, 0.10135218f, -0.00049563f, 0.00509637f, 0.01429701f, 
    -0.10159373f, -0.20140922f, -0.16861747f, 0.18518957f, -0.85163820f, 0.48544651f, -0.21351674f, -0.28933206f, 
    0.04786438f, -0.25667253f, 0.38378426f, -0.49219719f, -0.75383025f, -0.02117078f, 0.61386406f, -0.06506407f, 
    0.00009743f, 0.44368571f, 0.88944721f, -0.56373560f, 0.12149292f, -0.09732274f, -0.06195710f, 0.16182819f, 
    -0.02522430f, 0.05793652f, -0.18085526f, 0.12818301f, 0.08676793f, 0.03728268f, -0.10817660f, 0.06411453f, 
    -0.10917376f, 0.12873080f, 0.12551618f, -0.43355381f, -0.01981595f, -0.26914790f, 0.25770256f, 0.44119927f, 
    -0.02847661f, 0.16815138f, -0.47215158f, 0.07245769f, -0.83890533f, -0.07832319f, 0.08443084f, 0.08194091f, 
    0.12645602f, 0.15009110f, -0.33391199f, 0.18251443f, -0.15325807f, 0.10818882f, -0.07505946f, 0.76772290f, 
    0.07691757f, 0.04277198f, -0.14837953f, -0.17224662f, 0.14760454f, -0.12757218f, -0.17818268f, -0.09553944f, 
    -0.05407112f, -0.26595315f, -0.01959129f, -0.30052826f, -0.07695257f, -0.90323097f, -0.29880708f, 0.54992795f, 
    -0.08688153f, -0.34163600f, -0.48268488f, -0.03681492f, 0.55011898f, -0.10027327f, 0.13484849f, -0.00925439f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18576516f, 0.01618085f, -0.10377703f, -0.32547083f, 0.30332649f, 0.21516564f, -0.00051760f, -0.59643137f, 
    -0.36791217f, 0.29974979f, 0.25234315f, 0.09747600f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
