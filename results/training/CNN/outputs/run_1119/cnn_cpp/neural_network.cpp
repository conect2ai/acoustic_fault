#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54508978f, -1.14076805f, 0.95841473f, -0.40040302f, -0.42577884f, -0.40347719f, -0.07886871f, -0.58026212f, 
    0.64890867f, 0.17593457f, -0.15007521f, -0.16537543f, 0.73186147f, 0.68240958f, 0.81652224f, -0.42256561f, 
    0.13335799f, -0.73550081f, 1.46360469f, -0.77343559f, -0.22454725f, -0.55657387f, 0.48222250f, -0.05919392f, 
    -0.14335896f, -0.03705509f, 0.44248515f, -0.23828994f, 0.08208285f, 0.04464792f, 0.32525972f, -0.71922547f, 
    -0.63241458f, 0.32175356f, 0.13571315f, 1.03873634f, -0.96687800f, -0.31257024f, 0.61067379f, 0.83662236f, 
    -0.34405595f, 0.45504791f, -0.72700757f, -0.58939338f, -0.80668199f, -0.32737434f, -0.91480905f, -0.91183949f, 
    -1.17094564f, -0.41811523f, -1.54247272f, 0.61426312f, 0.17634502f, 0.00191489f, 0.42846981f, 0.81165916f, 
    0.14443502f, -0.82592970f, -0.14413396f, 0.18227759f, -0.14425780f, 0.59105849f, 0.46595362f, -0.90922314f, 
    -0.58041501f, -0.23928888f, 0.53154677f, 0.71984172f, -0.96924502f, 0.62844223f, 0.40901309f, 0.36681664f, 
    -1.06940997f, -1.30762637f, 1.02691305f, -0.21881472f, 0.48816258f, -0.39550570f, -0.40878776f, -0.33686897f, 
    -0.54584855f, 0.57248694f, 0.38213485f, -0.36632127f, 0.45538709f, 0.07685711f, 0.85547787f, 0.77916789f, 
    -0.50730544f, 0.29200155f, -1.06443298f, 0.20923318f, 0.98127031f, -0.66564733f, 0.47077152f, 0.99521494f, 
    0.65207243f, -0.29463637f, -0.42634568f, 0.66823059f, 0.76201838f, 0.04272946f, 0.37498197f, -0.84050423f, 
    -0.61081594f, -0.49134877f, -0.17868406f, 0.98292130f, 0.53466499f, 0.56964654f, 0.51837987f, 0.43456540f, 
    -0.54836905f, -0.92484957f, -0.05485632f, -0.21092051f, -0.31514055f, 0.46948564f, -1.26205206f, -1.39299548f, 
    -0.52833414f, -0.20363931f, 0.07518312f, 0.05385947f, -0.05037032f, -0.02401210f, -0.83760715f, 0.38687590f, 
    1.19818008f, 0.68737072f, 0.38682890f, -0.75585562f, -0.83090556f, -0.09640653f, 0.07782768f, -0.61772907f, 
    -0.80113131f, -0.89017701f, 1.51483345f, 0.47834072f, -0.76005709f, -0.53922856f, -0.58774441f, -0.20151022f, 
    0.33462662f, -0.05008288f, 0.12686430f, 0.35276315f, -0.45614561f, 0.38824007f, 0.20141792f, 0.67163897f, 
    0.25031501f, -1.07953858f, -0.62793559f, -0.63918251f, 1.23375857f, -0.63648963f, -0.92564738f, -0.39140263f, 
    -0.32710600f, -0.19113567f, -0.20315716f, 0.04258989f, 1.01556206f, -1.10651660f, 0.21279244f, 0.39827228f, 
    -0.15490246f, 0.15754054f, 0.42630410f, 1.29500568f, -1.02383196f, -0.87889767f, 0.78896058f, -0.15031761f, 
    0.19498421f, -0.19444035f, 1.03209805f, -0.51231074f, 1.21595657f, 0.59332567f, -1.12281489f, 0.00016510f, 
    -0.51085711f, -0.23988271f, 0.43692786f, 0.56590641f, -0.06948226f, -0.67226648f, 0.42109811f, 0.09667062f, 
    -0.74206501f, 0.17897797f, -0.79481328f, 0.34650686f, 0.42237669f, 0.66671634f, -1.35130203f, -0.87309545f, 
    -0.51636082f, -0.02468051f, -0.02476227f, 0.52625775f, 0.38555726f, 0.03269034f, 0.00915064f, 0.46938762f, 
    0.54074526f, 0.74379843f, 0.47956151f, -0.24293168f, 0.74929422f, -0.16303268f, -0.53354645f, 0.18131571f, 
    -1.18611979f, 1.27872038f, -0.94974726f, 0.60648382f, 0.41325319f, 0.34984249f, 0.22048676f, 0.27194518f, 
    -0.26259628f, 0.39188001f, 0.39883891f, 0.81541312f, 0.03740236f, -0.03831704f, 0.53221291f, 0.21293855f, 
    0.02520971f, 0.54743427f, 0.85657531f, -1.30338502f, 0.80110806f, 0.41996196f, -0.34891605f, -0.39989576f, 
    -0.00509620f, -0.16776539f, -0.28820321f, -1.16081440f, -0.76597637f, -1.16803348f, 0.65524411f, -0.03957785f, 
    0.04649361f, 0.15698785f, 0.30810601f, 0.75939101f, 0.35087195f, 0.41004661f, -1.03355837f, -0.10584282f, 
    0.20310403f, -0.86898714f, -0.36143976f, -0.44323409f, 0.74488240f, -0.77585888f, -0.27986664f, 0.55308104f, 
    0.85955983f, 0.44671082f, 0.79360682f, 0.39177513f, -0.16762269f, 0.10544948f, 0.85510802f, 0.57027346f, 
    0.61078757f, 0.07935096f, -0.07541931f, -0.45147362f, 0.13020606f, 0.60127646f, -0.63354272f, 0.31787851f, 
    0.60743201f, 0.23665211f, -0.98164093f, -0.71528256f, -0.86510336f, -0.27215070f, -0.65044409f, -0.57318431f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.46140650f, 0.10631711f, 0.22203089f, -0.22907922f, 0.28414273f, 0.07544281f, 0.64534193f, 0.22106840f, 
    -0.17302357f, -0.37450966f, 0.44885755f, -0.34349224f, 0.21394427f, 0.80111259f, 0.32459289f, -0.19815668f, 
    0.19701520f, -0.29251850f, 0.56861216f, 0.16465260f, 0.69392991f, 0.41095713f, 0.01144969f, 0.25793231f, 
    0.12290690f, 0.28702515f, 0.27429011f, 0.59648538f, 0.58427024f, 0.13687065f, 0.64489287f, -0.21794783f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.11545413f, -0.11178385f, -0.04193269f, 0.14721937f, 0.10206380f, -0.01691576f, 0.14675543f, 0.17588194f, 
    -0.20961171f, -0.11354752f, 0.00209631f, 0.03455377f, 0.00362003f, -0.03145176f, -0.30577064f, 0.02781706f, 
    -0.25067225f, -0.10745863f, -0.23299156f, 0.36997771f, -0.13021934f, 0.05857031f, 0.05323947f, 0.11496636f, 
    0.01467918f, 0.06781790f, 0.05950704f, 0.08894195f, 0.40004796f, 0.14126742f, 0.03639721f, -0.00315624f, 
    -0.02412903f, 0.07333413f, 0.18685062f, 0.35578156f, 0.24114703f, 0.16579433f, -0.01523834f, -0.08678436f, 
    -0.01319095f, 0.12389446f, -0.08895138f, -0.08008287f, -0.28846952f, 0.34755978f, 0.32454184f, 0.09757137f, 
    0.00913371f, 0.09255837f, 0.06269781f, 0.01066918f, -0.04167563f, 0.18122423f, -0.24431962f, -0.29980320f, 
    0.04807949f, -0.29190087f, -0.02917464f, -0.15890637f, 0.15199770f, 0.24143192f, 0.10922911f, 0.10555309f, 
    0.26849115f, -0.16352887f, 0.09726179f, -0.05561333f, 0.17827341f, 0.00649422f, 0.19791389f, 0.09474026f, 
    0.72286528f, 0.33177286f, -0.12907325f, 0.17202196f, -0.00323638f, 0.30838701f, -0.06159342f, -0.14428729f, 
    -0.27704412f, -0.01089336f, 0.01504376f, -0.00490262f, 0.03098308f, -0.14995375f, -0.67670792f, -0.10850362f, 
    0.10339441f, -0.17837022f, -0.12519999f, 0.14749268f, 0.43122670f, 0.16869891f, 0.10394996f, -0.25693390f, 
    -0.36602408f, -0.08415812f, -0.07754281f, -0.02797259f, -0.31533310f, -0.07675081f, -0.00604659f, -0.10365291f, 
    -0.03711134f, 0.50130558f, 0.21170546f, 0.14304101f, -0.36261061f, -0.07528392f, 0.06709173f, 0.02396781f, 
    -0.02415285f, -0.07773551f, -0.12501487f, -0.07134837f, 0.01429530f, 0.21669061f, -0.05205006f, -0.19887795f, 
    -0.09149812f, 0.01152966f, 0.09070041f, 0.11818369f, -0.09743828f, -0.07844758f, -0.30013567f, -0.00268888f, 
    0.08627158f, -0.19175543f, -0.11032661f, -0.01257438f, 0.17676465f, -0.13891980f, -0.16666102f, 0.44091907f, 
    0.21461257f, -0.70429397f, -0.01820406f, -0.05353835f, -0.01457571f, -0.01536385f, 0.01568665f, 0.05180477f, 
    -0.03842614f, -0.00234220f, -0.00482462f, -0.11071923f, 0.05942481f, -0.26320234f, 0.07226386f, 0.07769100f, 
    0.12577260f, 0.57951897f, 0.28986299f, -0.52313221f, 0.03265554f, 0.08996978f, 0.13242218f, -0.03898729f, 
    0.03052910f, 0.14116178f, -0.12836604f, -0.38989952f, 0.29425198f, 0.02147374f, 0.15090267f, -0.03623329f, 
    0.17827363f, -0.28887707f, 0.07820751f, -0.03200381f, -0.16215609f, -0.31051534f, 0.07487430f, 0.11962949f, 
    0.23692122f, 0.09466886f, 0.17297360f, -0.01951868f, -0.07838226f, -0.04308406f, -0.19069715f, -0.19197340f, 
    -0.11270117f, 0.07359196f, 0.00073253f, 0.07252262f, 0.02855044f, 0.12089474f, 0.27717990f, 0.10232331f, 
    -0.19727074f, 0.14936082f, 0.08128478f, 0.00590396f, 0.02186902f, 0.19988781f, 0.44438359f, 0.10663147f, 
    0.08615895f, 0.02407244f, 0.03839812f, -0.07952902f, -0.00573226f, 0.07451276f, 0.02486235f, -0.05476814f, 
    -0.03431933f, 0.01538276f, -0.01609392f, 0.20026506f, 0.00164590f, -0.26009995f, -0.14817068f, -0.21421345f, 
    0.06934083f, 0.05752081f, -0.29678431f, -0.00129898f, -0.07507662f, 0.01470008f, -0.16266386f, 0.07428684f, 
    -0.10605715f, -0.10411130f, -0.09395862f, -0.00897171f, -0.06314658f, 0.08781653f, -0.02631273f, 0.14818078f, 
    0.07767127f, 0.04392706f, -0.35976717f, -0.29622185f, -0.06263766f, 0.13193546f, 0.10414062f, 0.22125582f, 
    0.06131669f, 0.14925876f, -0.25115359f, 0.23756398f, 0.30215698f, -0.32104483f, -0.00424977f, -0.02942587f, 
    0.02731057f, -0.05523952f, 0.14123298f, 0.07579288f, 0.00914951f, 0.03542314f, -0.48121011f, 0.05963627f, 
    0.04447674f, 0.07850504f, 0.22928938f, -0.02435304f, 0.06683568f, 0.05749431f, 0.00191562f, 0.12816133f, 
    -0.05199485f, -0.01153438f, -0.42062116f, 0.03157634f, 0.08385863f, -0.05525064f, -0.16967998f, -0.18121953f, 
    0.09802841f, 0.01930474f, -0.06034658f, -0.09647770f, -0.30219311f, 0.12442316f, -0.00784505f, -0.34668955f, 
    0.04932772f, 0.07107666f, 0.01172883f, 0.07543249f, -0.07900452f, 0.01570424f, -0.19112420f, 0.23490109f, 
    0.25569770f, -0.02236327f, 0.07216562f, 0.00094440f, 0.36807784f, -0.45206681f, 0.08139210f, 0.19144398f, 
    -0.01771928f, 0.03474829f, 0.02916622f, 0.13504639f, -0.16057900f, 0.00832536f, -0.09450915f, -0.12871774f, 
    -0.07060000f, 0.22740941f, -0.06966098f, 0.15498774f, -0.04321111f, -0.11880720f, 0.26575601f, -0.08038287f, 
    0.15182646f, 0.05837072f, -0.15238754f, -0.20200329f, 0.32716528f, -0.21038321f, 0.03232237f, -0.22326346f, 
    -0.20801252f, 0.25081441f, 0.40258187f, 0.01443067f, -0.09822109f, -0.24701722f, -0.19578695f, -0.08307326f, 
    -0.20483671f, 0.30435458f, 0.22046575f, 0.05218209f, -0.08553170f, 0.44837159f, -0.20613693f, -0.00345750f, 
    -0.29656383f, 0.20099950f, 0.07421395f, 0.01277115f, -0.07094854f, 0.14624782f, 0.21795994f, 0.03939427f, 
    0.05211741f, -0.03346110f, 0.15071455f, -0.06630770f, 0.18765405f, 0.07856908f, 0.11100981f, -0.01066234f, 
    -0.39953449f, -0.40086484f, 0.00035954f, 0.25162262f, 0.08516327f, 0.32198033f, 0.09820767f, -0.06505154f, 
    -0.07528769f, -0.54250354f, -1.49098396f, 0.06270968f, -0.00678268f, 0.40067694f, 0.25288469f, -0.00725155f, 
    -0.06610229f, -0.10127231f, 0.17752481f, -0.25347695f, -0.07385402f, -0.05480004f, -0.37221360f, -0.04024814f, 
    -0.07153879f, -0.09384393f, 0.17076424f, 0.24841826f, -0.27815878f, 0.01355901f, 0.19708844f, 0.10081016f, 
    0.10900933f, -0.09587233f, -0.08051152f, -0.00546087f, 0.44478333f, -0.19154193f, -0.08212818f, 0.00409759f, 
    0.03292146f, 0.06539978f, 0.04275470f, -0.06129615f, 0.02140468f, 0.22799803f, -0.07281929f, 0.01432355f, 
    -0.26011741f, -0.09314565f, 0.03535869f, 0.04823175f, 0.07395601f, -0.42590323f, -1.16484058f, -0.81481540f, 
    -0.00702980f, 0.43483722f, 0.13803446f, 0.10819753f, 0.02526421f, 0.03337228f, -0.05297244f, 0.04426112f, 
    -0.10355684f, 0.19904479f, -0.17099720f, 0.08499758f, -0.06894876f, -0.08145441f, 0.06719540f, -0.44957444f, 
    -0.16745387f, -0.60870886f, -0.44119525f, 0.05041763f, 0.24283607f, -0.18022715f, -0.34936744f, -0.09459671f, 
    -0.05411063f, 0.13124347f, -0.00036662f, 0.03101861f, -0.09675971f, -0.06748910f, -0.05393806f, 0.34587973f, 
    -0.11073335f, -0.05465781f, 0.70211977f, -0.73528552f, -0.16550213f, -0.13626552f, 0.37163317f, -0.00634128f, 
    -0.06021155f, -0.05476921f, 0.31704554f, -0.16946384f, 0.18046759f, 0.11268016f, 0.20750944f, 0.01250872f, 
    0.25119540f, 0.08815256f, -0.07252593f, -0.43979588f, 0.18369915f, -0.51160491f, 0.07551890f, 0.36543703f, 
    -0.04063012f, -0.00375150f, 0.31113309f, -0.10776968f, -0.33307129f, 0.21361446f, -0.19507091f, 0.03379846f, 
    -0.01502757f, 0.15502249f, 0.14136733f, 0.25859502f, 0.09789924f, 0.04771436f, -0.08954876f, 0.18651080f, 
    -0.02960950f, 0.21396917f, 0.09067147f, 0.17700225f, 0.18225878f, 0.25175458f, -0.17230688f, -0.53497869f, 
    -0.98249125f, 0.05504891f, 0.11049156f, 0.25583950f, -0.01393143f, -0.29089883f, -0.13772190f, 0.00597628f, 
    0.01650657f, 0.24560952f, -0.03308859f, -0.06494679f, -0.09909625f, 0.08298801f, -0.01018392f, 0.05808512f, 
    0.02175949f, -0.34263486f, -0.65491635f, -0.07380161f, 0.13242984f, 0.04735894f, 0.04302431f, -0.15478297f, 
    -0.13137713f, 0.24250852f, 0.08742990f, 0.12829572f, -0.01580994f, -0.17350222f, -0.08281346f, 0.04732830f, 
    -0.11173204f, -0.03297010f, 0.00263653f, -0.25517982f, -0.66343045f, 0.02040350f, 0.03938381f, -0.18620117f, 
    0.07536528f, 0.14960334f, -0.08963232f, -0.44126260f, -0.90497530f, -0.49333018f, 0.01096226f, -0.08735352f, 
    0.19094512f, -0.01875833f, -0.14316443f, -0.01687122f, -0.56398642f, 0.54043317f, -0.12608990f, 0.18903272f, 
    0.28945714f, 0.28874055f, 0.28236464f, 0.14562826f, 0.08113255f, 0.18105346f, -0.19185007f, -0.49249741f, 
    -0.06241941f, -0.03783990f, -0.04044953f, 0.26569998f, -0.03971956f, -0.14195558f, 0.14231089f, 0.32036981f, 
    -0.08443268f, 0.13176946f, 0.01330783f, -0.11476152f, 0.03292893f, 0.11198752f, 0.08960152f, 0.14357334f, 
    0.27444112f, 0.33689776f, -0.19347602f, -0.20088908f, -0.27469885f, 0.04820378f, 0.08296953f, 0.19873464f, 
    0.01618728f, -0.02942186f, -0.05806007f, -0.05349961f, -0.00158242f, -0.04986479f, 0.04461299f, 0.01213739f, 
    -0.05287901f, 0.05843297f, -0.02781682f, 0.02543537f, -0.04789448f, -0.01195510f, 0.04171692f, -0.02685094f, 
    0.04640094f, 0.03240035f, -0.05065531f, -0.00456831f, 0.00127283f, -0.04583591f, 0.04487419f, -0.00723101f, 
    -0.02431245f, -0.04314000f, -0.03255405f, -0.03515109f, 0.01526345f, 0.00178366f, 0.04594032f, -0.05101624f, 
    0.04786228f, -0.02842839f, -0.03792536f, -0.00456135f, 0.00293040f, 0.01920218f, -0.00748071f, -0.04484792f, 
    0.04458906f, 0.00457338f, -0.02803953f, -0.03612664f, -0.00737001f, -0.01351324f, 0.05885749f, 0.04853684f, 
    0.04783847f, 0.00505132f, -0.04190542f, -0.00805169f, 0.05870505f, -0.02630086f, 0.00559022f, -0.00219575f, 
    -0.05060824f, 0.04021104f, -0.04027157f, -0.00102944f, -0.04024383f, -0.03458243f, -0.00036867f, -0.00891869f, 
    0.03401536f, -0.02455835f, 0.01410692f, -0.01665728f, -0.00793166f, 0.05430426f, -0.01839213f, -0.01149523f, 
    -0.05794210f, -0.01454654f, -0.02675994f, -0.04395352f, -0.01058154f, -0.05152779f, 0.01196955f, -0.00715515f, 
    0.00216343f, -0.00936211f, -0.03847890f, -0.03360082f, -0.04298260f, 0.04716742f, 0.02902349f, 0.01342400f, 
    0.01147954f, -0.01099216f, 0.01515693f, -0.04788161f, -0.03930891f, -0.03362344f, 0.00728456f, 0.04916139f, 
    -0.00938851f, -0.04073220f, -0.04396269f, 0.04278203f, 0.01566181f, -0.02005249f, 0.02351364f, -0.01665197f, 
    0.02690138f, -0.03778883f, 0.01484213f, -0.04916823f, 0.02712745f, -0.00684520f, -0.02503673f, -0.03701945f, 
    0.01847480f, 0.01603115f, -0.00339311f, 0.01183014f, -0.01466388f, -0.05269788f, -0.04766332f, -0.03953042f, 
    -0.02654698f, 0.00162605f, -0.05283754f, -0.04177096f, -0.03218026f, 0.01026097f, -0.00022376f, 0.03634809f, 
    -0.02942030f, 0.01455793f, -0.01863944f, 0.03219847f, 0.00160976f, -0.00830874f, -0.02752970f, 0.00794301f, 
    0.01707516f, -0.05034771f, -0.05719632f, -0.00424964f, 0.03156899f, 0.02117240f, 0.05017927f, 0.03417563f, 
    -0.00067842f, 0.01346669f, -0.00484961f, -0.03998963f, -0.02802023f, -0.04317357f, 0.00659005f, -0.00845969f, 
    -0.01114096f, 0.01234148f, -0.03580598f, -0.02831603f, -0.05290576f, 0.05855040f, 0.00301691f, 0.01514992f, 
    0.01015351f, -0.05726231f, -0.04742667f, -0.03805423f, 0.02795971f, 0.04994668f, 0.02041128f, -0.04965693f, 
    -0.02006391f, 0.00854872f, -0.05103153f, -0.00138407f, -0.00592340f, -0.00634929f, -0.01031827f, -0.00283681f, 
    -0.02611379f, -0.05370783f, -0.01004792f, 0.03371975f, -0.03589758f, -0.02417632f, 0.04896940f, 0.02116901f, 
    0.04266680f, 0.04308104f, -0.01907427f, -0.04312994f, 0.02621251f, -0.04193994f, 0.02255672f, -0.03125765f, 
    -0.04756673f, -0.04813622f, 0.04761345f, 0.00973355f, 0.01691758f, -0.04582474f, -0.05603714f, 0.00259796f, 
    -0.05599288f, 0.01112437f, 0.01919481f, 0.05845856f, -0.05111020f, 0.01272929f, 0.03787054f, 0.02282044f, 
    -0.02376558f, -0.02774545f, -0.05545986f, 0.05587999f, -0.03738636f, 0.02425833f, -0.00241185f, 0.03026845f, 
    0.02206404f, -0.05692957f, 0.00478450f, -0.00386679f, 0.03816329f, -0.03587176f, 0.04765502f, 0.05262500f, 
    -0.05449883f, 0.00833456f, -0.02674850f, -0.01393875f, 0.05599004f, -0.04587827f, -0.00416208f, -0.04748034f, 
    0.03715796f, -0.00231050f, -0.01078053f, -0.00728711f, -0.04610339f, -0.03699555f, 0.04964906f, 0.01866682f, 
    -0.00745689f, 0.03411172f, -0.01462475f, -0.04794339f, -0.01123524f, 0.00198583f, 0.01075557f, -0.04317652f, 
    -0.05719449f, -0.00856384f, -0.04781509f, 0.03599771f, 0.03464280f, 0.01571324f, 0.04597201f, -0.00815536f, 
    0.01512825f, -0.03226983f, -0.03841187f, -0.05773660f, -0.00236721f, -0.03732626f, -0.04096637f, -0.05109528f, 
    0.00552424f, 0.02746640f, 0.03543659f, 0.00274002f, -0.03701048f, 0.05462845f, -0.04524074f, -0.00704654f, 
    0.05702936f, 0.03708591f, 0.02575701f, 0.03332083f, -0.04703419f, 0.04262497f, -0.02172121f, 0.03780100f, 
    -0.02678880f, 0.01441617f, 0.04997092f, -0.00141080f, 0.04930812f, 0.05380337f, 0.01146774f, -0.04155190f, 
    0.22241089f, 0.34160563f, -0.23664850f, 0.05142649f, 0.11984817f, -0.07837857f, 0.01350059f, 0.23450561f, 
    0.02979443f, 0.14222190f, -0.04493848f, 0.22700088f, 0.00857284f, -0.00397644f, 0.02197894f, 0.17946273f, 
    -0.09696921f, -0.05166697f, 0.46085617f, -0.36167458f, -0.28628853f, 0.09562647f, 0.21607761f, -0.35584322f, 
    0.05341467f, -0.03727127f, 0.08660506f, 0.01684843f, -0.42495680f, -0.37031630f, -0.06563251f, -0.26653633f, 
    -0.07705751f, 0.02559585f, 0.07537758f, 0.07487301f, -0.12129290f, -0.07507917f, -0.03235084f, -0.05048817f, 
    0.25509748f, 0.12550382f, 0.19758731f, -0.09094975f, -0.17930916f, -0.53727686f, -0.25992256f, -0.15316288f, 
    0.02198708f, 0.07312068f, -0.19238293f, -0.06621363f, 0.06347059f, 0.02863358f, 0.02217117f, -0.10649768f, 
    -0.06424943f, -0.11802796f, 0.02734022f, -0.01079082f, 0.13111286f, -0.00525651f, 0.21141686f, -0.30150914f, 
    -0.12069393f, 0.15825769f, -0.11415630f, 0.10864192f, 0.17139906f, 0.03032554f, 0.05253099f, -0.05785864f, 
    -0.06590137f, 0.03833321f, 0.09324985f, -0.28481323f, -0.07233901f, -0.21436173f, -0.09231316f, -0.17879033f, 
    -0.33541471f, 0.08192961f, 0.06643627f, 0.13080749f, -0.08777638f, -0.00191760f, -0.16890866f, -0.13449830f, 
    -0.22091743f, -0.24385761f, 0.01272479f, -0.14863203f, -0.05411400f, 0.00001196f, -0.04435859f, -0.03450416f, 
    -0.08175545f, -0.01172059f, 0.17534104f, -0.36082125f, 0.01581630f, -0.33051524f, -0.03551530f, 0.05072655f, 
    -0.14039630f, -0.05532320f, -0.30633983f, -0.17247012f, -0.24083811f, 0.12467775f, 0.21522285f, 0.12366991f, 
    0.04566696f, 0.00593683f, -0.05259517f, -0.03950211f, -0.01191281f, 0.53411162f, 0.44067034f, -0.18711442f, 
    0.20845534f, 0.10133705f, -0.16264237f, 0.12511623f, 0.11041606f, 0.07153577f, -0.14545161f, 0.32890782f, 
    0.24519540f, 0.05615948f, -0.18924470f, 0.03539926f, 0.03582575f, 0.02407219f, 0.11935136f, -0.47120529f, 
    0.13110474f, 0.14570147f, -0.19952431f, -0.26783457f, -0.27048069f, 0.10152395f, 0.06463054f, -0.23811322f, 
    0.22197571f, 0.10974198f, 0.11163956f, 0.14489867f, 0.09190006f, -0.19414288f, -0.01919903f, 0.06385483f, 
    0.05439255f, -0.18864298f, 0.17096090f, 0.38199532f, -0.11115839f, -0.15088938f, -0.29799315f, 0.03558970f, 
    0.13623133f, -0.10326848f, 0.02817917f, -0.20961778f, -0.03124768f, -0.03933269f, -0.03251050f, 0.04964693f, 
    0.48003668f, 0.09065485f, 0.05767111f, 1.02499962f, 0.02220896f, -0.52492952f, 0.07281450f, 0.11928715f, 
    -0.43878737f, 0.05759858f, -0.01392503f, 0.11168950f, 0.34538105f, 0.04118639f, -0.27038473f, -0.01206921f, 
    0.08289106f, -0.08275912f, -0.10790891f, 0.19587232f, 0.21158603f, -0.13030270f, -0.47465014f, -0.03493824f, 
    -0.03602681f, -0.22049429f, 0.00896540f, 0.18878323f, 0.11186021f, 0.16842800f, -0.31588086f, 0.17248271f, 
    0.10505348f, -0.21577129f, 0.13915148f, -0.09767849f, -0.01664579f, 0.00673961f, -0.07064059f, 0.08808111f, 
    0.18297897f, 0.13713712f, 0.09812769f, -0.08248935f, -0.04633579f, 0.07562401f, -0.18582353f, -0.05901014f, 
    -0.13991064f, 0.31019181f, -0.14436691f, 0.04349545f, 0.04056513f, 0.25287214f, 0.09983028f, -0.08986436f, 
    -0.26561734f, 0.04571552f, 0.09644755f, 0.19945472f, 0.01604918f, -0.16009328f, -0.00816545f, 0.05650222f, 
    -0.09482616f, -0.05679764f, 0.14805992f, 0.19367008f, -0.26513904f, 0.14288871f, 0.06513733f, 0.01682197f, 
    -0.12146740f, -0.08137877f, -0.07004148f, -0.06996823f, 0.31396472f, 0.25065237f, 0.07507237f, 0.32918656f, 
    0.12478399f, 0.09943204f, 0.03625133f, 0.03287093f, -0.21196918f, -0.45798311f, -0.18453625f, -0.00599834f, 
    0.09305998f, 0.16241153f, 0.16077393f, -0.07373036f, 0.18168719f, 0.08183013f, 0.12224060f, 0.07864013f, 
    -0.03116913f, 0.04887005f, 0.17566356f, 0.01481279f, -0.11617137f, 0.06096231f, 0.13637629f, 0.04128467f, 
    0.16785903f, 0.20887402f, -0.02406848f, 0.04642515f, 0.04097444f, 0.19293429f, 0.08189089f, -0.64442444f, 
    -0.21656542f, -0.25429636f, 0.03964636f, 0.00959098f, -0.04170254f, -0.06119984f, 0.03792757f, -0.15475778f, 
    -0.33247110f, 0.22024880f, 0.04718735f, 0.05570922f, 0.12988459f, 0.13742842f, 0.02791360f, -0.06948249f, 
    -0.37961084f, 0.04600487f, 0.05061724f, 0.08249587f, -0.22628351f, -0.20226081f, -0.13225131f, 0.05253457f, 
    0.08886143f, 0.33317989f, -0.26943418f, -0.04339586f, 0.22272786f, 0.05330908f, -0.01792051f, 0.19789220f, 
    -0.06159059f, 0.29664612f, -0.15137647f, 0.13931660f, 0.27392170f, 0.02380520f, -0.00470961f, -0.21437109f, 
    0.00318041f, -0.04152825f, -0.10401305f, -0.03222116f, 0.29469261f, 0.04369256f, -0.14385055f, -0.16768332f, 
    -0.11216840f, 0.00127741f, 0.13248846f, 0.22659270f, 0.18177707f, 0.48641545f, -0.04709738f, 0.71638793f, 
    0.13262600f, -0.15056013f, -0.11292402f, -0.02738367f, -0.22870883f, -0.03160883f, -0.14169887f, 0.33230942f, 
    -0.15553497f, 0.15809655f, 0.07926104f, 0.11045602f, 0.17688675f, -0.07137670f, -0.23748471f, 0.42271975f, 
    -0.21020612f, 0.13974176f, -0.20492110f, 0.06843034f, -0.34611019f, 0.04963331f, -0.03753472f, 0.07580946f, 
    0.62917095f, 0.15526992f, -0.26182538f, 0.14151494f, 0.09204908f, -0.11189146f, 0.13669127f, 0.35601851f, 
    0.13712396f, 0.07375019f, 0.13912235f, 0.20421006f, -0.09406044f, -0.21349679f, -0.34089515f, 0.12268220f, 
    0.41936195f, 0.08116220f, -0.04410129f, 0.22377017f, -0.10985544f, -0.37571755f, -0.22598164f, -0.07443351f, 
    0.00827888f, 0.00460840f, -0.04754772f, -0.73066539f, 0.46651062f, -0.14795466f, 0.32391444f, 0.00930681f, 
    -0.08994902f, -0.07237456f, 0.09857804f, -0.38136497f, -0.29751721f, 0.22415905f, -0.01356290f, 0.16197155f, 
    0.06922111f, -0.15321574f, -0.12493551f, -0.18656090f, 0.06049498f, 0.19903839f, -0.11894131f, 0.49337292f, 
    -0.01353195f, -0.18253615f, 0.15410274f, -0.16443226f, 0.07730963f, -0.02798148f, 0.24631725f, 0.10669907f, 
    -0.16248067f, -0.16217901f, 0.10837336f, -0.27492571f, -0.05528456f, 0.08042072f, 0.08067503f, 0.66885144f, 
    -0.66155964f, 0.14709622f, -0.28156057f, -0.01996209f, -0.39257249f, 0.05256993f, 0.06518450f, 0.12493907f, 
    -0.03491461f, 0.09972301f, 0.12787344f, -0.05885144f, -0.10561591f, -0.07331260f, 0.25839803f, -0.14945418f, 
    -0.08189578f, 0.32214391f, -0.43903029f, 0.08769000f, -0.16048025f, -0.01240653f, -0.08244801f, 0.19586349f, 
    -0.16435671f, 0.07666080f, -0.27599183f, 0.34351334f, -0.11786774f, -0.05844624f, 0.20668386f, 0.11612458f, 
    0.02150378f, -0.23135234f, 0.01227818f, -0.03047411f, 0.02709361f, 0.65281570f, -0.44855925f, -0.08956251f, 
    -0.04169918f, 0.12682189f, 0.06961241f, 0.36297110f, 0.22103418f, 0.01445932f, 0.28187475f, -0.05591757f, 
    0.02464367f, 0.11049199f, 0.05862504f, 0.13021982f, -0.17148244f, 0.33600205f, 0.18753168f, -0.04017136f, 
    -0.04486125f, 0.09044795f, -0.00519315f, 0.03569138f, -0.24218808f, -0.09800564f, -0.11606150f, 0.16452043f, 
    0.55509174f, 0.17934108f, -0.11109384f, 0.04749729f, 0.05372601f, -0.08354058f, 0.10124139f, -0.15343763f, 
    0.07731521f, 0.21057120f, 0.25492930f, 0.01224630f, 0.07241394f, -0.08225333f, 0.16052604f, 0.10758761f, 
    0.07190284f, 0.27196577f, 0.05180778f, -0.32172915f, 0.20626490f, 0.01077219f, 0.17924860f, 0.08000029f, 
    0.14472611f, -0.08978081f, 0.23639169f, -0.07169019f, 0.20802616f, 0.05876970f, -0.03558172f, 0.04019750f, 
    0.05128232f, -0.05322152f, -0.15823013f, 0.10596848f, 0.25848821f, -0.02792640f, 0.19095579f, 0.07970478f, 
    0.24167326f, 0.15903220f, -0.15159278f, 0.16561590f, -0.08816735f, 0.34603184f, -0.01361616f, 0.00713827f, 
    -0.11253569f, 0.02518576f, 0.01672484f, 0.15215863f, -0.08391878f, 0.21338820f, 0.21859224f, -0.15531191f, 
    -0.01629982f, -0.29460195f, -0.16201669f, -0.05740861f, -0.04582332f, 0.09425659f, 0.16761482f, 0.15744959f, 
    -0.31324908f, -0.24780218f, -0.41615862f, 0.05024790f, 0.05550110f, 0.05588494f, -0.24306168f, 0.14436044f, 
    0.12959690f, 0.11327782f, 0.08737756f, -0.07869166f, 0.03263122f, 0.02211137f, -0.04215405f, -0.25557655f, 
    0.51807773f, 0.36185417f, 0.25043467f, 0.13609613f, 0.01104297f, 0.09751882f, -0.01617314f, 0.20175226f, 
    0.00262103f, 0.02822986f, 0.02289424f, -0.01124632f, -0.04778950f, -0.00702261f, -0.06145472f, -0.00158528f, 
    0.03741004f, -0.02379639f, -0.00058693f, -0.06212867f, 0.01247814f, -0.01937685f, 0.04327630f, -0.02879986f, 
    -0.01235526f, -0.04430049f, -0.01366351f, -0.03632235f, -0.00284060f, 0.02697385f, -0.04166257f, -0.05014435f, 
    0.04028370f, 0.02780017f, -0.02726900f, -0.02295034f, 0.01763743f, 0.00161764f, -0.01438684f, 0.00146389f, 
    -0.01119199f, 0.00756065f, 0.02001534f, 0.03373333f, -0.04564267f, 0.03518227f, 0.00725066f, 0.01609415f, 
    -0.05525558f, -0.05289782f, -0.03492766f, -0.01194801f, -0.04621922f, -0.05226388f, -0.05321890f, -0.02928432f, 
    -0.00890494f, 0.04740391f, -0.03701469f, 0.00250072f, -0.05985181f, 0.00486516f, 0.02470298f, -0.01659245f, 
    0.01080375f, 0.02491148f, -0.05340082f, 0.05130100f, 0.05238092f, 0.05129560f, -0.03089635f, 0.05082704f, 
    -0.05339571f, -0.05872487f, -0.00062885f, -0.04371548f, -0.00602689f, -0.05029427f, -0.03538577f, 0.03890920f, 
    -0.01906934f, -0.02738550f, -0.06291699f, -0.03261082f, -0.00660086f, 0.02237496f, -0.01548829f, 0.01973413f, 
    0.01847347f, -0.05227879f, -0.06625471f, -0.05868638f, -0.05714057f, -0.04591799f, -0.03818731f, 0.05038186f, 
    -0.02397348f, 0.01814490f, -0.00749602f, -0.02834914f, -0.00243437f, -0.05834376f, 0.01846768f, -0.01693695f, 
    0.02488380f, -0.00959148f, 0.03488545f, 0.04742534f, -0.03695753f, -0.02894634f, 0.04628171f, 0.04584178f, 
    -0.06071911f, 0.02072150f, 0.00410994f, -0.00879668f, 0.01314059f, -0.01056876f, 0.02088889f, 0.02102332f, 
    0.02798275f, 0.04649775f, 0.03963204f, 0.04806092f, -0.02932357f, -0.02018030f, 0.03235097f, -0.01207420f, 
    0.05252494f, 0.02699316f, -0.01106503f, 0.02986104f, -0.00866934f, -0.00111274f, 0.02705840f, -0.00927126f, 
    -0.00398895f, -0.00723541f, -0.05048660f, -0.01324924f, -0.03545925f, -0.03119390f, 0.04275758f, 0.04748667f, 
    -0.05845521f, 0.02205491f, -0.03357440f, -0.01648864f, -0.03323705f, 0.02974522f, 0.04106339f, 0.01417059f, 
    0.04937163f, -0.06311957f, -0.03719100f, 0.00402683f, -0.05790947f, -0.05668125f, -0.03724786f, -0.02639852f, 
    0.00085308f, 0.02850926f, 0.00132839f, -0.04571441f, -0.04698680f, -0.03866235f, -0.01917682f, 0.02918621f, 
    -0.05403627f, 0.02773466f, -0.01173123f, 0.03322308f, -0.00460912f, -0.01756941f, 0.03724932f, -0.02881619f, 
    0.01731894f, -0.02654864f, -0.05106539f, 0.02948898f, -0.01830728f, -0.03194801f, -0.01743808f, 0.01520938f, 
    -0.06840836f, -0.00401229f, 0.03120911f, -0.02176007f, 0.04887998f, -0.01669573f, -0.06495120f, 0.01526869f, 
    -0.05113798f, 0.00917254f, -0.04621481f, 0.00739537f, -0.00234424f, 0.00262993f, 0.02592587f, 0.01085647f, 
    -0.04849698f, 0.01570593f, -0.02347739f, -0.00058409f, -0.04662939f, 0.05163352f, 0.01559959f, 0.01979841f, 
    0.03011092f, -0.05829740f, -0.05050300f, 0.05121898f, -0.03012587f, 0.00457012f, -0.00037584f, -0.03443889f, 
    0.05001498f, -0.00872966f, -0.00581028f, -0.00533380f, -0.02165480f, 0.02335653f, 0.02224794f, -0.02269772f, 
    -0.05838560f, -0.04090901f, -0.01177804f, 0.05425866f, -0.05735789f, 0.04128203f, 0.02394908f, 0.05335617f, 
    -0.06270987f, -0.03340632f, 0.04091379f, 0.00803314f, -0.02650910f, -0.00129051f, 0.03160699f, -0.01064324f, 
    -0.04930147f, -0.03531681f, -0.02203183f, -0.01174199f, -0.02049153f, 0.00615616f, 0.04050864f, 0.02027780f, 
    -0.05671021f, 0.04048208f, -0.05635836f, -0.02114872f, 0.01552593f, 0.02629941f, 0.04885275f, 0.00512134f, 
    0.01031649f, -0.04412679f, -0.02425555f, 0.05397681f, -0.02482562f, -0.01403224f, -0.01552513f, -0.04460665f, 
    -0.00527134f, -0.02430979f, 0.02303631f, -0.06089447f, -0.05194586f, -0.01703344f, 0.03707586f, -0.06295652f, 
    0.05020864f, 0.02808194f, -0.00565618f, -0.00599537f, -0.03653699f, -0.04511652f, -0.01752019f, 0.04169221f, 
    -0.04609429f, 0.00734207f, -0.05228814f, -0.00283672f, 0.01167452f, -0.06017544f, 0.03431467f, -0.00366871f, 
    0.04780267f, 0.05440746f, -0.05436084f, -0.01329410f, 0.00992167f, 0.05010739f, -0.01436553f, -0.04695293f, 
    -0.08876666f, 0.17113250f, -0.19824450f, 0.05031580f, 0.12505828f, 0.48290956f, -0.09835150f, -0.06010792f, 
    -0.02496789f, 0.07053300f, 0.15610632f, 0.54939932f, -0.07110100f, -0.08896253f, -0.12826832f, 0.16732641f, 
    0.04179687f, 0.16714096f, -0.24361357f, -0.49260366f, -0.11392438f, -0.02716456f, -0.03209110f, 0.12808175f, 
    -0.12588814f, -0.11757971f, 0.11791845f, -0.04630205f, 0.18120271f, 0.15177873f, 0.19076109f, 0.18306537f, 
    -0.04676783f, 0.02128182f, 0.36408597f, 0.57425892f, -0.44995457f, -0.19414276f, 0.34161079f, 0.01081934f, 
    0.16989759f, -0.24404564f, 0.08532033f, 0.04493903f, -0.16881490f, 0.16045016f, 0.09222163f, 0.17541605f, 
    -0.09854747f, -0.18790369f, -0.08218843f, 0.06380502f, -0.04157529f, 0.16601393f, -0.56613106f, -0.38707039f, 
    -0.03480574f, -0.06949813f, -0.05185861f, -0.12798490f, -0.14386447f, -0.02037823f, -0.08863163f, 0.35568526f, 
    0.13557489f, 0.45580685f, -0.10866637f, -0.02371588f, 0.13155513f, 0.03488691f, 0.12232588f, 0.24095099f, 
    0.12412333f, 0.02464213f, -0.05390802f, -0.14282219f, 0.05462808f, -0.07119808f, -0.02026537f, 0.00950059f, 
    -0.20203273f, 0.08940435f, 0.34864789f, 0.54981053f, 0.07369724f, -0.04779056f, -0.11869784f, -0.27012378f, 
    -0.14165647f, -0.11184571f, -0.93992901f, 0.08080245f, -0.40474880f, -0.38834372f, -0.09765515f, -0.25965592f, 
    0.04145651f, 0.15106870f, 0.25799125f, -0.88990778f, -0.09848601f, 0.27386597f, 0.10595646f, -0.12702785f, 
    -0.14941089f, 0.12806654f, 0.08400012f, 0.16013925f, -0.38381779f, -0.10020281f, 0.20835184f, -0.07630140f, 
    -0.18474948f, -0.31702131f, 0.07785340f, 0.01049964f, 0.16060381f, 0.12889020f, 0.07872158f, -0.09993194f, 
    -0.08149954f, -0.09139841f, -0.20124938f, 0.01042981f, -0.05851867f, -0.08704719f, -0.77177846f, -0.08000492f, 
    -0.22172359f, -0.18373783f, 0.02660231f, -0.04711826f, -0.11064410f, -0.07569522f, -0.16653776f, 0.11162708f, 
    0.51437843f, 0.65769130f, -0.09163994f, -0.10381178f, 0.03528475f, 0.23400182f, 0.08188593f, -0.25335854f, 
    -0.08362448f, -0.12444790f, -0.02511275f, -0.12273359f, -0.18064052f, 0.08421615f, -0.03745642f, 0.00926869f, 
    -0.13851310f, 0.24749006f, 0.34616423f, 0.34488723f, -0.00177964f, -0.06121163f, 0.03268785f, 0.01342374f, 
    0.09044477f, -0.03873322f, -0.27507755f, 0.16799222f, -0.15976813f, -0.07715562f, 0.09384739f, -0.17390192f, 
    -0.08911091f, 0.16480231f, 0.07069413f, 0.35261896f, 0.33040753f, 0.30875233f, 0.00466757f, -0.14887376f, 
    -0.23805995f, -0.14292978f, -0.01987013f, 0.04607112f, -0.22336072f, -0.31306642f, -0.16206308f, -0.09350751f, 
    -0.01779136f, 0.11579452f, -0.03799239f, 0.15180153f, -0.02082237f, -0.05103857f, 0.13739872f, 0.14612064f, 
    0.15657829f, -0.07146512f, -0.13973050f, -0.20999354f, 0.14924258f, 0.23833773f, 0.26266846f, 0.37966850f, 
    0.09169690f, 0.10767176f, 0.14941418f, 0.13594624f, 0.22778183f, -0.03228291f, -0.10111400f, -0.23457623f, 
    0.21510711f, -0.10819233f, -0.10173326f, -0.07468094f, -0.09475648f, 0.08699024f, 0.02146271f, 0.05084226f, 
    -0.94541425f, -0.19521755f, 0.45230851f, 0.03007602f, 0.27672961f, 0.15675601f, 0.03298656f, -0.12594360f, 
    -0.11938129f, -0.43064377f, 0.06373008f, -0.20924176f, -0.02969150f, -0.14928994f, -0.03463310f, -0.02082496f, 
    -0.08723347f, 0.06079989f, -0.26066193f, -0.61755520f, -0.87945902f, -0.04275611f, -0.03913308f, 0.32954946f, 
    0.15094128f, 0.07916962f, -0.12916620f, 0.40594429f, 0.14691687f, 0.38763422f, -0.05468197f, 0.16426766f, 
    0.21041359f, 0.11614794f, 0.20839769f, -0.07594610f, -0.30988556f, 0.29847574f, 0.25274020f, -0.01035114f, 
    -0.03955506f, -0.03507765f, -0.15218382f, 0.16967320f, -0.17490032f, -0.32914323f, -0.16592334f, 0.19693586f, 
    -0.27418029f, 0.06956692f, 0.02796793f, 0.01252361f, -0.01522976f, 0.21910016f, -0.50581467f, 0.37615913f, 
    0.03096830f, -0.09714360f, -0.10016894f, -0.10976657f, 0.08301015f, 0.11989819f, -0.11150809f, 0.21793298f, 
    -0.26122853f, 0.16422558f, 0.12348774f, -0.02022596f, -0.24997446f, 0.11980895f, 0.01197264f, 0.15510163f, 
    -0.05989701f, 0.02695514f, -0.02065056f, 0.03469623f, 0.03519615f, -0.04328514f, -0.05620638f, 0.00427688f, 
    -0.01600485f, -0.03881077f, 0.04959290f, -0.01746611f, 0.01006764f, -0.02950511f, -0.03728725f, -0.00830849f, 
    -0.00809635f, -0.05065490f, -0.06435818f, -0.02331014f, -0.00290492f, -0.01888740f, -0.01042366f, 0.00639869f, 
    -0.04601854f, 0.01285418f, 0.01994131f, 0.01802027f, -0.06322388f, -0.00926578f, 0.03558454f, 0.02397644f, 
    0.02014213f, -0.03559595f, 0.04249928f, -0.05962949f, -0.05186347f, -0.00243695f, 0.03498843f, -0.02927265f, 
    0.01502671f, 0.02988531f, -0.04245400f, -0.03882143f, -0.01438490f, 0.02115642f, -0.01189406f, -0.05801955f, 
    -0.05198253f, -0.02229063f, -0.05100746f, -0.05015522f, 0.04855622f, -0.04342800f, -0.06023884f, 0.03106109f, 
    -0.04141719f, -0.04407812f, 0.01440532f, 0.01024286f, 0.01418298f, 0.01382164f, -0.03898803f, -0.03387240f, 
    0.01597201f, 0.00957688f, 0.00360518f, 0.03515337f, 0.04522378f, 0.04748165f, -0.02611187f, -0.06353647f, 
    0.01564931f, 0.01260590f, 0.01909850f, 0.02994515f, 0.02849128f, 0.02422869f, 0.03584388f, -0.04780355f, 
    0.00501995f, -0.05363895f, -0.05358298f, -0.00129495f, 0.03653986f, -0.02532335f, -0.02969486f, 0.04152501f, 
    -0.03821306f, -0.01102349f, 0.02617330f, 0.02905823f, -0.00661234f, 0.04750378f, 0.03302353f, -0.04341758f, 
    -0.00763107f, 0.02735566f, 0.00378123f, 0.01276046f, 0.01629474f, 0.01469541f, -0.03919687f, 0.03508185f, 
    0.03256951f, 0.04960700f, 0.02840095f, 0.03895999f, 0.03336820f, 0.00914369f, -0.03454372f, -0.03139643f, 
    -0.02921362f, -0.04597492f, 0.01350021f, -0.01586835f, -0.05243944f, -0.04034871f, -0.00665886f, 0.02598052f, 
    0.01174794f, -0.06501865f, 0.04261729f, 0.03859807f, 0.04198116f, -0.01490957f, -0.00455518f, -0.02478506f, 
    0.02426918f, -0.03566345f, -0.01768168f, 0.00539237f, -0.05763206f, 0.00878192f, -0.01532269f, 0.01149424f, 
    -0.05998769f, 0.00376116f, -0.00851483f, 0.02488491f, 0.02901974f, -0.05789419f, -0.00623113f, -0.00448702f, 
    0.04702521f, -0.04064343f, -0.03300205f, 0.03410827f, 0.01329723f, 0.02409128f, -0.06294283f, -0.01562337f, 
    -0.02389336f, -0.03410104f, -0.00745515f, 0.00189186f, 0.04710406f, -0.04505536f, -0.03714059f, -0.02219923f, 
    -0.00935759f, -0.00486650f, -0.05565919f, 0.02964174f, 0.01172517f, 0.02779745f, -0.00780549f, -0.02070639f, 
    -0.02310142f, 0.04142784f, -0.03272669f, 0.05179312f, 0.01776374f, -0.00939575f, -0.04580030f, -0.04208742f, 
    -0.00014594f, 0.02717617f, -0.04088815f, 0.03341611f, 0.01429021f, -0.00226525f, -0.03557083f, -0.01157386f, 
    -0.01829147f, -0.00339301f, -0.01319281f, 0.02102020f, -0.02070937f, 0.03614983f, 0.02704660f, -0.04872729f, 
    0.02500328f, -0.04207744f, 0.02013528f, -0.04694254f, 0.00483293f, -0.02120784f, 0.00137598f, -0.01867332f, 
    -0.00870896f, -0.05591677f, -0.02859804f, -0.05338861f, 0.02477205f, -0.06425882f, 0.01870578f, 0.02898270f, 
    0.03071150f, 0.01520888f, 0.02375019f, -0.05207277f, 0.03798038f, -0.02956832f, -0.05049983f, 0.04251894f, 
    -0.01962240f, -0.03230004f, -0.05745644f, 0.00852573f, -0.01881844f, 0.01688635f, -0.03529961f, 0.00685420f, 
    -0.06240124f, 0.01241636f, 0.00447863f, 0.03269469f, -0.00409405f, 0.05317931f, -0.05782557f, -0.00282688f, 
    -0.06167669f, 0.00598510f, 0.01615484f, -0.01088158f, -0.00772777f, -0.01433665f, 0.00152632f, -0.05879993f, 
    -0.05775585f, -0.00396831f, 0.03818345f, -0.06292824f, -0.05176126f, 0.04589264f, 0.03008605f, -0.05533057f, 
    -0.00622491f, -0.06246575f, -0.02169162f, -0.05225541f, -0.05404129f, -0.02330845f, -0.05693482f, -0.05044518f, 
    -0.02735134f, -0.03470885f, -0.00919548f, 0.05655392f, 0.04184924f, 0.04443488f, -0.05920501f, 0.00235694f, 
    -0.00055544f, 0.01403033f, 0.05335661f, -0.00018411f, -0.01981809f, 0.00782601f, 0.02659591f, -0.04263820f, 
    0.01983231f, -0.04954866f, -0.02815521f, 0.00039500f, -0.03454405f, 0.03495600f, 0.04531965f, 0.01136810f, 
    -0.00311254f, -0.00902775f, 0.04126483f, 0.00286882f, 0.00824002f, 0.00737466f, 0.02293406f, -0.02766709f, 
    -0.05053114f, 0.00663993f, -0.02569529f, -0.03551806f, 0.03613055f, 0.00146688f, 0.01480328f, -0.04732189f, 
    -0.01538179f, 0.02343425f, -0.05055323f, -0.00536291f, 0.04083817f, -0.02917563f, -0.00572767f, -0.01781340f, 
    -0.01709589f, -0.02013334f, -0.01109335f, 0.02379031f, 0.03760831f, -0.05794484f, -0.01524129f, -0.03722670f, 
    -0.02754024f, 0.03168880f, -0.01012983f, -0.06376708f, 0.04283119f, 0.05754154f, -0.05802309f, 0.02401050f, 
    0.03584677f, 0.00232770f, 0.03589292f, -0.02862942f, -0.03249545f, -0.02786419f, -0.00710936f, -0.01375807f, 
    -0.00682763f, -0.03499212f, 0.01033165f, -0.01129079f, 0.02279291f, -0.03459502f, 0.05279216f, 0.05257142f, 
    0.00445305f, -0.01821226f, -0.00230830f, -0.02437540f, -0.06017899f, 0.03524087f, -0.02929685f, 0.04581591f, 
    0.00978390f, -0.03255000f, -0.05266025f, 0.02576247f, 0.03071174f, -0.05991117f, -0.06295471f, -0.01155059f, 
    0.02936693f, -0.00014163f, 0.01016182f, 0.00212927f, -0.02876138f, -0.00853847f, -0.01481941f, 0.03600710f, 
    0.05866444f, 0.03251707f, -0.01162673f, 0.02898313f, 0.03721484f, 0.00970124f, -0.03227666f, 0.02450310f, 
    -0.05133095f, 0.03477851f, -0.06647151f, 0.03180376f, 0.00105802f, -0.04496590f, 0.03054690f, -0.02591312f, 
    0.01052349f, -0.04343003f, -0.00161455f, -0.01266250f, 0.02053928f, 0.01931626f, 0.00617582f, 0.04660598f, 
    -0.02546400f, 0.03751324f, -0.03356557f, -0.01298768f, 0.03040662f, -0.03218665f, -0.06979632f, -0.05590734f, 
    -0.01478764f, 0.00719871f, 0.01711422f, 0.03141830f, -0.00106398f, -0.02587021f, -0.04510085f, 0.03284504f, 
    0.02277581f, 0.04731297f, -0.03321880f, 0.03257064f, 0.01775516f, -0.01661719f, -0.00249405f, -0.00770043f, 
    -0.02089156f, -0.00116164f, -0.04616138f, -0.04464211f, 0.01296621f, -0.05348825f, 0.01563401f, -0.02771467f, 
    0.00793871f, -0.00009373f, -0.00344711f, -0.01669223f, -0.02981775f, -0.06818523f, -0.01390848f, 0.05171559f, 
    0.03967376f, -0.02510472f, -0.08234208f, -0.06049890f, -0.04378090f, -0.07028574f, 0.03248806f, 0.04096092f, 
    -0.00079965f, 0.04051067f, -0.00100637f, -0.03366694f, -0.01607601f, 0.03529566f, 0.04060492f, -0.02474199f, 
    -0.03377245f, 0.04175993f, -0.00443119f, -0.01244931f, -0.01709383f, 0.01044681f, -0.04484714f, -0.02437804f, 
    -0.04866664f, -0.04050614f, -0.00124010f, -0.06286491f, 0.05085742f, -0.05612097f, -0.02634953f, 0.00530964f, 
    0.04663837f, -0.02786844f, -0.00256890f, 0.02695884f, -0.05931004f, 0.00191420f, 0.00620158f, 0.00110943f, 
    0.01161730f, -0.02231181f, 0.01837974f, -0.00196391f, 0.03811492f, 0.00259105f, -0.00851933f, -0.00123881f, 
    0.03736822f, 0.05042429f, -0.03902834f, -0.03177517f, -0.01659881f, -0.00136199f, 0.02716865f, 0.01173518f, 
    -0.02667945f, -0.00141507f, -0.02556488f, -0.04337942f, -0.02693061f, -0.05766119f, -0.03420381f, -0.01644564f, 
    -0.02188204f, -0.05862227f, -0.00309821f, -0.04744227f, 0.02336576f, -0.00179038f, 0.02051769f, -0.03822185f, 
    -0.06205234f, 0.02643602f, -0.03934205f, 0.03129167f, 0.04938789f, 0.04247760f, -0.00157406f, 0.02708088f, 
    -0.00526925f, -0.03271525f, -0.02624893f, -0.02359631f, 0.02595304f, -0.01284530f, 0.02674317f, -0.05738502f, 
    -0.05986862f, -0.00111725f, -0.06426735f, -0.02152152f, -0.01195963f, -0.05288594f, 0.04928682f, -0.06246456f, 
    0.03528560f, -0.02657323f, 0.04525667f, 0.03702082f, 0.01878249f, -0.03137270f, 0.04366968f, -0.05688441f, 
    0.03116710f, -0.04244737f, 0.04494355f, -0.03695310f, -0.00758973f, 0.03633159f, -0.02053472f, -0.05502830f, 
    0.04277681f, -0.05316337f, 0.04690327f, -0.02708053f, 0.02272527f, -0.06020641f, 0.04191086f, -0.06656968f, 
    0.00265709f, 0.00657605f, 0.03097420f, 0.01765256f, -0.02970471f, 0.01635251f, -0.03929096f, -0.03567676f, 
    -0.01245644f, -0.06184010f, -0.00158043f, -0.01652829f, 0.03459343f, 0.01933672f, -0.05495233f, 0.00890979f, 
    0.01310944f, -0.00669680f, 0.01341996f, -0.04520083f, -0.01126463f, -0.01455524f, 0.01207654f, -0.03881120f, 
    0.00412768f, 0.00508768f, 0.03859003f, 0.01835290f, 0.02950581f, -0.06684282f, 0.04571629f, -0.03169505f, 
    -0.06822005f, 0.12180741f, -0.35651994f, 0.03627740f, 0.02241951f, 0.05333772f, 0.03771959f, -0.09304354f, 
    -0.18173271f, 0.15463561f, 0.02356180f, 0.03808265f, -0.06616750f, -0.02121845f, -0.06114136f, -0.26797703f, 
    -0.03420170f, 0.23677385f, 0.46810958f, 0.40539783f, -0.22946143f, -0.05146784f, -0.13046017f, 0.06785144f, 
    0.47797841f, -0.03276282f, -0.40020096f, -0.15946008f, 0.13783805f, 0.13320005f, 0.04692494f, -0.07173432f, 
    -0.00953204f, -0.05302510f, -0.25089392f, -0.07715987f, -0.00560017f, -0.14428140f, -0.20712189f, -0.06357846f, 
    0.09361230f, 0.05513733f, -0.19922923f, 0.12960075f, 0.23791507f, -0.79821265f, -0.97991008f, -0.99608397f, 
    0.03922924f, 0.06222685f, -0.10003868f, 0.03201993f, -0.03429127f, -0.14693099f, 0.26566437f, -0.09383765f, 
    -0.12262262f, -0.05552912f, 0.12006607f, 0.07484458f, 0.07413300f, 0.12108330f, -0.05743075f, -0.25780198f, 
    -0.13504785f, 0.21741438f, -0.04366524f, 0.01040210f, 0.16234827f, 0.18068260f, 0.06587883f, -0.00110538f, 
    -0.13129930f, -1.11255920f, -0.92420286f, -0.15081452f, -0.03253635f, -0.09869449f, -0.25492361f, -0.07437500f, 
    0.07408851f, 0.20679852f, 0.00878254f, 0.15894321f, -0.04000438f, -0.24580382f, -0.14055689f, -0.18483131f, 
    0.01859660f, -0.10256670f, 0.19105950f, 0.09828782f, -0.03464760f, -0.36678252f, 0.05209903f, 0.01763849f, 
    0.13827564f, 0.10388539f, 0.14815161f, 0.49523690f, -0.01471328f, 0.12728281f, -0.12875111f, 0.02027622f, 
    0.04003418f, 0.07824688f, 0.15032759f, -0.01553341f, 0.34642634f, -0.29469034f, -0.21018493f, 0.08920455f, 
    0.10308895f, -0.02862233f, 0.01388584f, 0.12551238f, 0.21005228f, -0.41727760f, 0.69094819f, -0.64018017f, 
    -0.14051038f, 0.20004906f, -0.03833288f, 0.10122413f, -0.08249507f, -0.21910214f, 0.11326583f, -0.01435741f, 
    0.03415937f, 0.03038899f, 0.23875774f, 0.01148059f, 0.16581008f, 0.16189148f, 0.07530247f, -0.34265247f, 
    -1.20889556f, -0.51413417f, -0.05817569f, -0.09637138f, 0.03718129f, 0.01475882f, 0.12045466f, 0.20046277f, 
    0.18313457f, 0.05597102f, -0.03908438f, -0.16596468f, 0.02696968f, -0.07950778f, -0.06809862f, 0.10847262f, 
    -0.08795958f, -0.10627695f, -0.79738015f, -0.09310233f, 0.00505458f, -0.20538560f, -0.35382721f, -0.02255845f, 
    0.20480905f, -0.13056529f, -0.04306767f, -0.10215322f, -0.17536198f, -0.00172386f, 0.00874687f, -0.12595803f, 
    0.27449471f, -0.07090885f, -0.23561509f, 0.44926938f, 0.08068535f, -0.11164919f, -0.04057996f, 0.13449861f, 
    0.21727693f, 0.03392830f, -0.05641417f, 0.25961205f, 0.48430815f, 0.30775583f, -0.24543701f, 0.37969029f, 
    0.09573469f, 0.11319792f, 0.24641782f, -0.06504964f, 0.05005131f, -0.47151724f, 0.03650355f, 0.20772339f, 
    -0.02799812f, 0.10424177f, -0.00847181f, 0.13469788f, 0.03347794f, -0.08097515f, -0.63310939f, -0.14153546f, 
    -0.03043315f, -0.02379770f, 0.09891060f, 0.01321782f, 0.03700960f, 0.00177465f, -0.06383041f, 0.15268114f, 
    0.07459918f, 0.06711494f, 0.09449828f, 0.03525456f, -0.12984413f, -0.04643705f, 0.08086446f, 0.03318776f, 
    -0.13154414f, -0.01114892f, -0.28666800f, -0.33997330f, -0.17947204f, -0.07559092f, 0.01372597f, -0.15837352f, 
    -0.01756197f, 0.27347678f, 0.05676063f, 0.07478097f, -0.05394093f, -0.05133317f, -0.09411094f, 0.04660356f, 
    0.04020491f, -0.20563741f, 0.17582567f, -0.09619320f, -0.25577363f, 0.22471529f, 0.16116932f, 0.12193505f, 
    0.19268882f, -0.07081344f, 0.14024459f, -0.78025168f, 0.35199940f, 0.24302475f, 0.12512578f, 0.01894259f, 
    -0.01655280f, -0.05605056f, 0.03817421f, -0.04906324f, -0.00271318f, -0.02140925f, -0.36521834f, -0.06623335f, 
    -0.06891505f, 0.16479552f, -0.07468471f, 0.01930291f, 0.12313459f, 0.14740448f, 0.04562510f, 0.02156944f, 
    -0.16353251f, -0.15792142f, -0.08596300f, -0.03388982f, -0.16728994f, 0.12328983f, 0.23014137f, -0.15674983f, 
    -0.03742261f, 0.10587471f, 0.02507882f, -0.05334031f, 0.04720119f, 0.01122428f, 0.06797625f, 0.01219450f, 
    -0.29604131f, -0.56990898f, 0.01865989f, 0.06501044f, 0.01371869f, -0.15628211f, 0.03303429f, 0.31191558f, 
    0.05474439f, -0.07154742f, 0.04442522f, -0.02435124f, 0.04227302f, -0.06056355f, -0.01132036f, -0.05461966f, 
    -0.02497476f, -0.04126698f, -0.06048147f, -0.03026768f, -0.03228458f, 0.04303285f, 0.04238801f, 0.00298910f, 
    -0.03444900f, -0.06680328f, -0.03030297f, -0.01863146f, -0.07305858f, -0.05451623f, 0.03926242f, 0.04454881f, 
    -0.04269841f, -0.04644010f, -0.01871417f, -0.00093544f, -0.00144963f, -0.00466221f, -0.01911384f, 0.01163517f, 
    -0.00843161f, 0.02205475f, 0.04093000f, 0.04107983f, -0.06124576f, -0.06021976f, -0.04979841f, -0.04123844f, 
    -0.03807740f, -0.01095724f, 0.02301659f, -0.03474465f, 0.00674279f, -0.01829548f, -0.05223485f, -0.01039490f, 
    -0.03964989f, -0.05086021f, -0.03097722f, 0.05823966f, -0.01235099f, -0.05839567f, -0.02812043f, -0.03657063f, 
    0.00755499f, 0.03506814f, -0.03918296f, 0.00691349f, -0.07796451f, 0.02606306f, -0.03150495f, 0.03486799f, 
    -0.02585809f, 0.00797968f, -0.02564315f, -0.00702311f, -0.07911486f, 0.03054460f, 0.04712128f, 0.04890912f, 
    0.04421335f, 0.04039216f, -0.01380962f, -0.01924081f, -0.02579061f, -0.01799152f, 0.00768886f, 0.04808905f, 
    0.01535770f, -0.05375258f, 0.02703053f, 0.00236228f, 0.02228433f, 0.04413038f, -0.01495416f, 0.00301207f, 
    -0.04986059f, -0.02313533f, -0.03487260f, -0.03545703f, -0.03349736f, 0.01188402f, -0.03755782f, -0.01703260f, 
    -0.02000066f, -0.00848034f, 0.00942651f, 0.00582943f, -0.03576795f, -0.07648169f, 0.02694519f, -0.01128304f, 
    -0.04859694f, -0.01327429f, 0.03165810f, -0.02962300f, -0.00383249f, -0.06309353f, 0.03283818f, 0.03937227f, 
    0.05173494f, 0.03114393f, 0.01020898f, -0.00525855f, -0.01690993f, 0.01242248f, -0.00599831f, -0.00942061f, 
    -0.03177765f, 0.00946822f, -0.03653491f, 0.05098904f, -0.02944710f, -0.03320356f, -0.02467305f, 0.00902653f, 
    -0.00629039f, 0.00180952f, -0.04591402f, 0.00372239f, -0.05832412f, -0.00932236f, -0.02518370f, 0.00277096f, 
    -0.02545310f, -0.06623264f, 0.03898070f, -0.06605282f, -0.01829498f, 0.01184889f, -0.01125563f, -0.00215285f, 
    0.03918687f, -0.07334198f, -0.07271297f, -0.04343458f, -0.02377588f, -0.02046928f, -0.04023481f, -0.06064648f, 
    -0.03994729f, 0.04417302f, 0.03848824f, -0.00095247f, 0.04921473f, 0.00457170f, 0.03732871f, 0.01985127f, 
    -0.04550135f, -0.05255828f, -0.02441943f, 0.06548291f, -0.02528435f, 0.05312015f, -0.05275788f, 0.01334394f, 
    -0.03264269f, -0.06318896f, 0.04003591f, 0.03499968f, -0.01787939f, -0.03490336f, 0.03885399f, -0.00325320f, 
    -0.02049021f, -0.03351563f, -0.01222190f, -0.01153490f, -0.07081843f, -0.03821604f, 0.00382731f, -0.03826548f, 
    -0.06888411f, -0.04716424f, -0.05248375f, 0.05007813f, -0.06090535f, -0.00909071f, 0.04349061f, 0.03531128f, 
    0.00049567f, -0.04152848f, 0.01631996f, -0.05829613f, -0.03891076f, -0.00820222f, -0.03398321f, 0.02256770f, 
    -0.03847721f, 0.02646155f, -0.00615597f, -0.01134390f, 0.00021616f, -0.04390898f, -0.02259999f, -0.05927855f, 
    -0.07474706f, -0.06405162f, -0.02360252f, -0.01710445f, 0.00538873f, -0.06215405f, -0.02729080f, 0.00417356f, 
    -0.00466080f, 0.03542924f, 0.02355727f, -0.02858560f, 0.00821939f, -0.02199970f, -0.06873499f, -0.02522889f, 
    -0.00676081f, 0.02265417f, -0.03064094f, -0.01725076f, -0.04012795f, 0.04296382f, -0.02492262f, -0.00079170f, 
    0.02290938f, -0.03819341f, 0.01957563f, -0.03693221f, 0.00951059f, -0.02578649f, -0.00659626f, 0.01078883f, 
    -0.02468713f, -0.07206657f, 0.02232272f, -0.00080524f, -0.00584274f, 0.04220165f, -0.05626291f, -0.02791736f, 
    -0.07355461f, -0.02190290f, 0.01517237f, -0.02700743f, -0.03386635f, -0.04931255f, -0.03071812f, -0.04946192f, 
    -0.04612448f, 0.01332072f, -0.04150555f, -0.06405380f, -0.03316418f, -0.00560031f, 0.02688615f, 0.02786877f, 
    -0.06322581f, 0.00947669f, -0.01646922f, -0.05514009f, 0.02768740f, -0.02608428f, 0.01865920f, -0.00177558f, 
    0.03512750f, 0.01871253f, -0.06324468f, -0.02682561f, 0.00955665f, -0.06046012f, -0.01838936f, -0.01542009f, 
    -0.07704537f, -0.04262415f, 0.03414602f, 0.02973234f, 0.04552940f, 0.04161653f, -0.00592130f, 0.04127707f, 
    0.28651533f, 0.12839748f, 0.46928635f, 0.11161377f, 0.01898617f, 0.21044727f, -0.04969265f, -0.24248020f, 
    -0.07931502f, -0.11296113f, 0.00228461f, -0.08129068f, 0.31824917f, 0.17183231f, 0.02038959f, -0.08117849f, 
    -0.47984156f, -0.28253451f, -0.05583503f, -0.03834026f, 0.07143366f, 0.18796265f, -0.08951771f, -0.14130083f, 
    0.05847264f, -0.04786880f, 0.22030488f, 0.05275504f, 0.02926846f, 0.44950193f, 0.11036625f, -0.01491729f, 
    -0.00547249f, 0.20783186f, 0.26165739f, 0.21302322f, -0.29265097f, -0.10972014f, 0.00491013f, 0.23926350f, 
    0.05625558f, 0.06922180f, -0.17083769f, -0.45103848f, -0.58117378f, 0.35050896f, 0.56599683f, 0.39428264f, 
    -0.04710723f, 0.16058467f, 0.10069009f, 0.01464246f, -0.06575938f, 0.10231542f, -0.26399103f, -0.10719215f, 
    0.03213876f, 0.03327104f, 0.11305899f, -0.19150653f, -0.13525537f, 0.14081296f, 0.05898657f, 0.15393749f, 
    0.24693882f, 0.22945765f, -0.03847160f, -0.31181455f, 0.09395602f, 0.19670326f, 0.19923632f, 0.16141117f, 
    0.26195118f, 0.31501511f, 0.11996277f, 0.15496536f, 0.01284630f, 0.33429825f, -0.05421591f, 0.04250345f, 
    -0.22736390f, 0.15648074f, 0.03446711f, 0.02893738f, 0.30951911f, 0.22001806f, 0.06005818f, -0.22748286f, 
    -0.23354039f, -0.06029961f, -0.16956608f, -0.32977661f, 0.20456888f, -0.03632630f, -0.21168353f, 0.24039632f, 
    -0.10376157f, 0.00277725f, -0.03822812f, 0.08241936f, -0.24516255f, 0.28207478f, 0.14489715f, 0.02050096f, 
    0.07295745f, 0.06820291f, -0.07681991f, 0.02684444f, -0.11164533f, -0.16127847f, -0.19140483f, 0.01940906f, 
    -0.06440657f, 0.01392585f, -0.02110635f, -0.03448962f, -0.18793140f, 0.18632048f, -0.27163139f, -0.19619484f, 
    -0.13102174f, -0.04265736f, -0.05912189f, -0.01709751f, 0.02136727f, -0.03562232f, -0.06107680f, -0.36489549f, 
    -0.03883233f, 0.11062587f, -0.09551869f, 0.26640970f, 0.02330388f, -0.24316213f, -0.53182638f, -0.19653375f, 
    0.19186251f, -0.33493915f, 0.17314525f, 0.03301121f, -0.15225719f, -0.05543834f, -0.38638940f, -0.16424489f, 
    -0.09361662f, 0.06938106f, 0.05052016f, 0.10822012f, 0.09054402f, -0.12345636f, -0.00199271f, 0.26809072f, 
    0.19393060f, 0.12177481f, 0.49709538f, 0.07161520f, 0.11958716f, 0.14899518f, -0.03562617f, 0.01972282f, 
    -0.28748921f, 0.01952350f, -0.36507520f, -0.09938912f, 0.29310164f, 0.19442639f, 0.14882492f, -0.07105631f, 
    -0.08038197f, 0.12857613f, 0.01582018f, -0.05082071f, 0.21519287f, -0.04897490f, 0.36594009f, 0.29216161f, 
    0.00803631f, -0.03074216f, -0.36380094f, -0.21780691f, -0.05810520f, 0.04811386f, -0.19103456f, -0.14384997f, 
    -0.13223687f, -0.04307755f, -0.05041997f, 0.09330109f, 0.11004263f, -0.19543739f, 0.01986592f, 0.22638144f, 
    -0.14633460f, 0.08330246f, 0.02697989f, 0.14339243f, 0.26662764f, 0.14666809f, 0.13770978f, -0.11469457f, 
    -0.16238549f, 0.03891785f, -0.18816029f, 0.03501694f, 0.12859057f, 0.06938370f, 0.13149975f, 0.09444483f, 
    -0.04282390f, -0.03529249f, -0.00016804f, -0.03869288f, -0.01480779f, -0.15480427f, -0.35553935f, -0.17360811f, 
    0.01966854f, 0.12768866f, 0.11593537f, 0.15445212f, 0.01486670f, 0.31107554f, -0.04842984f, 0.17214404f, 
    -0.02542678f, -0.00397470f, -0.00296381f, 0.03781028f, -0.04309238f, 0.07303245f, 0.06643806f, -0.22336921f, 
    -0.21550514f, 0.06408988f, 0.44869426f, 0.02573015f, 0.18710579f, -0.02474980f, -0.05772325f, 0.29101405f, 
    -0.04158545f, -0.08139639f, -0.36319533f, -0.01531079f, 0.10226359f, -0.24301091f, -0.21653916f, -0.12145043f, 
    -0.11751154f, 0.08928886f, 0.03143704f, 0.21144596f, 0.08990108f, 0.47166860f, 0.11895449f, 0.04636463f, 
    0.11983794f, -0.00784305f, 0.03030542f, -0.29732931f, 0.00297535f, 0.04412334f, -0.05120112f, -0.03454283f, 
    0.21855244f, 0.08264334f, -0.14795996f, -0.03067746f, -0.01892969f, -0.03089475f, 0.01270356f, 0.06275082f, 
    -0.08263078f, 0.00266070f, -0.00467776f, 0.15523003f, -0.18324141f, 0.06984988f, -0.17460820f, 0.23143412f, 
    0.19558401f, -0.06565708f, 0.24425022f, 0.03093191f, 0.01467016f, -0.24989039f, -0.08369680f, -0.46143419f, 
    0.04493233f, -0.06519833f, -0.05104971f, -0.02157416f, 0.01007875f, 0.04880530f, -0.02313541f, 0.00348470f, 
    -0.00417884f, 0.01917467f, 0.02375841f, -0.03857777f, -0.02335776f, -0.00142553f, -0.06158378f, -0.04699954f, 
    0.00474116f, -0.04360804f, 0.03228329f, -0.01630881f, -0.00145239f, -0.04155254f, -0.06506045f, -0.02198401f, 
    -0.02994667f, -0.04704556f, -0.01441472f, -0.01135980f, 0.02133917f, 0.05674190f, -0.02570775f, -0.01840664f, 
    0.01187905f, -0.03860184f, -0.00861367f, 0.00689319f, -0.03801751f, -0.02647452f, -0.05572857f, -0.00205730f, 
    0.03930608f, 0.04639903f, -0.05668882f, -0.01748718f, -0.00789749f, 0.05840333f, -0.02955704f, 0.03507653f, 
    -0.00915962f, 0.00413687f, 0.00748481f, -0.06369922f, -0.03792412f, 0.01164519f, -0.04591588f, -0.04868449f, 
    -0.05077251f, -0.03458050f, -0.04381439f, -0.01362618f, 0.04485403f, 0.03403300f, -0.04662527f, 0.00464215f, 
    0.00289371f, -0.00278533f, 0.00281284f, -0.00970736f, -0.06497450f, -0.06119337f, -0.03727523f, -0.05619261f, 
    -0.00691645f, -0.02226665f, -0.02753764f, -0.01436626f, -0.01623929f, 0.01673947f, -0.02077423f, 0.04660381f, 
    0.01652503f, 0.04292154f, 0.04195006f, -0.02602182f, 0.00269467f, 0.04715283f, -0.04396063f, 0.05801274f, 
    -0.04068398f, 0.02705853f, 0.01803110f, -0.02341334f, -0.01862203f, 0.01254475f, -0.04726958f, -0.03748558f, 
    -0.02769984f, -0.04940157f, -0.02416516f, 0.02402700f, 0.02113336f, -0.05797008f, -0.01038167f, -0.00373739f, 
    -0.00627118f, -0.01687006f, 0.00738200f, -0.03320655f, -0.00359917f, -0.03532460f, 0.03519396f, -0.05876653f, 
    0.02193179f, -0.03691591f, 0.02046756f, 0.01099187f, 0.00156013f, 0.02303420f, -0.02155880f, -0.04942466f, 
    -0.00902406f, -0.05216212f, -0.01195069f, 0.05193417f, -0.01099129f, -0.06095161f, 0.03878957f, -0.01077798f, 
    0.02298514f, 0.00210949f, -0.06039581f, -0.03405245f, 0.03269783f, -0.01159527f, 0.03460116f, 0.01801685f, 
    0.04416238f, -0.00427942f, 0.01697187f, -0.05989112f, -0.01039030f, -0.01120613f, -0.02104715f, -0.00657226f, 
    0.00757587f, -0.05574494f, 0.00124010f, -0.03041512f, -0.03581065f, 0.01327736f, 0.05043100f, 0.03104618f, 
    -0.00916345f, 0.00232534f, 0.00477129f, -0.00987558f, 0.00998077f, -0.05776590f, 0.01340322f, -0.00031973f, 
    -0.06434195f, -0.01941027f, 0.02279451f, -0.06376926f, -0.02603419f, -0.04941210f, -0.06290176f, 0.04194684f, 
    -0.02041286f, 0.00749820f, 0.02594525f, -0.00434091f, 0.02246362f, 0.04130615f, 0.00746216f, -0.00131072f, 
    -0.00340973f, -0.03158408f, 0.00803656f, -0.02554043f, -0.04884882f, 0.03078845f, 0.01434172f, -0.02426671f, 
    -0.03351485f, 0.01060038f, 0.02149349f, -0.01279892f, 0.03345516f, -0.01429957f, 0.03800211f, -0.00994614f, 
    -0.04593996f, 0.00762313f, 0.01206119f, -0.01943846f, -0.01462639f, 0.03356382f, -0.00623942f, 0.03934264f, 
    0.03303124f, -0.04887197f, 0.02099763f, -0.03857029f, 0.02919464f, 0.01693973f, 0.02070463f, 0.00480695f, 
    -0.02683057f, -0.02923946f, -0.01315909f, -0.04224092f, 0.02285535f, -0.03982496f, -0.02722979f, -0.06165564f, 
    -0.06377506f, 0.03628337f, -0.05872820f, -0.06258909f, -0.02304571f, 0.03731848f, 0.03664833f, -0.03320281f, 
    -0.03850278f, -0.01844384f, -0.02435327f, 0.04174774f, -0.03487146f, 0.03571793f, 0.04903718f, -0.04925916f, 
    -0.00201270f, -0.04108322f, 0.05193287f, 0.04738211f, 0.03635643f, -0.05036801f, 0.03199545f, -0.05054258f, 
    0.01048759f, -0.01248964f, -0.02964505f, -0.04934604f, -0.02304788f, -0.02147173f, -0.02290408f, 0.00473212f, 
    -0.01588972f, 0.04936514f, 0.04527283f, 0.04118819f, 0.04973420f, -0.03408244f, -0.05499859f, 0.03421507f, 
    -0.03153257f, -0.01709543f, -0.06463787f, -0.04650754f, -0.03233367f, 0.03342135f, -0.02034701f, -0.02887046f, 
    -0.05016682f, 0.02553480f, -0.03234272f, -0.00843328f, -0.01276244f, 0.00570491f, 0.04294867f, -0.05156813f, 
    0.04212539f, -0.05053279f, -0.04399123f, -0.06435326f, -0.03394321f, -0.06429911f, -0.03522149f, -0.06299176f, 
    0.02336580f, -0.03447624f, 0.01021235f, 0.04454608f, -0.01759358f, 0.02866910f, -0.06047532f, -0.02961200f, 
    -0.00801714f, 0.21357913f, 0.45348716f, 0.23862067f, 0.28952545f, 0.01056228f, 0.13081667f, -0.15111405f, 
    0.22034675f, -0.24930105f, -0.47251144f, -0.42499435f, -0.00395877f, -0.04266619f, 0.09182210f, -0.07369145f, 
    0.12230711f, -0.65332919f, 0.19706546f, -0.16107430f, 0.31909007f, 0.14863130f, 0.10632631f, 0.26120436f, 
    0.00498364f, 0.19299501f, 0.45303392f, -0.20963797f, 0.03320098f, -0.30115759f, 0.04584472f, 0.15711619f, 
    -0.11863209f, 0.28265482f, 0.33252355f, -0.03401079f, 0.07450385f, -0.02277039f, -0.24275464f, 0.12903892f, 
    -0.19817014f, -0.01368324f, -0.22710058f, -0.26068544f, -0.40638739f, -0.24500293f, -0.06556151f, 0.00627264f, 
    -0.25215563f, -0.09718762f, -0.05943386f, 0.08012024f, 0.30324900f, 0.03729082f, 0.05009596f, 0.09264180f, 
    0.12019642f, 0.15098125f, 0.19539215f, 0.05429283f, -0.11194646f, 0.24193618f, 0.18772745f, -0.02994036f, 
    0.06194269f, 0.33723786f, 0.09944886f, 0.04261908f, 0.20352161f, -0.09775017f, -0.02024952f, 0.08510022f, 
    -0.15100959f, 0.21943642f, 0.23614191f, 0.26165777f, -0.23414971f, -0.02291775f, -0.28966671f, 0.16725135f, 
    -0.09983574f, -0.05672802f, -0.14420108f, -0.04859457f, 0.03744866f, 0.28437600f, 0.31574565f, -0.00938129f, 
    -0.04022646f, 0.00315376f, 0.13067113f, -0.07609589f, 0.06447849f, -0.01488634f, -0.15078244f, 0.02532581f, 
    -0.08515288f, -0.04756262f, 0.16911654f, -0.13545258f, 0.01434809f, 0.03722975f, 0.12509081f, 0.09149271f, 
    0.13350193f, 0.12556763f, 0.17544003f, 0.01802453f, -0.47780675f, -0.14210570f, 0.20106974f, 0.10765894f, 
    0.15675199f, 0.09679275f, 0.04579434f, 0.03522917f, -0.16372338f, -0.10163901f, -0.09094965f, 0.19757552f, 
    0.03127116f, -0.19519685f, -0.15540776f, 0.04146394f, 0.02105699f, 0.20669229f, -0.23415460f, 0.04110733f, 
    0.26006097f, 0.02685377f, 0.06918215f, 0.06941833f, 0.00187501f, 0.11387489f, -0.07357765f, -0.08237150f, 
    0.00426961f, -0.28441617f, -0.02845159f, 0.00977245f, -0.17761958f, -0.28227377f, -0.44467872f, -0.36962429f, 
    0.09686201f, 0.02485921f, 0.17153306f, -0.03531923f, 0.08239792f, -0.13557571f, 0.05508237f, 0.33855206f, 
    0.07272834f, 0.04254651f, -0.13625844f, -0.17045256f, 0.05184065f, -0.04703205f, -0.19078527f, -0.17885105f, 
    -0.31472003f, -0.00786711f, 0.21911100f, 0.39358056f, 0.51736689f, 0.09786560f, 0.17926475f, 0.03543429f, 
    0.06257428f, 0.29120192f, 0.27518165f, 0.04831395f, -0.36807173f, 0.14015880f, 0.22873297f, 0.33370656f, 
    0.04630925f, -0.17072487f, -0.38519663f, 0.01595512f, -0.13979819f, -0.07335700f, 0.03805229f, 0.09287728f, 
    0.07371885f, 0.12541512f, -0.05075613f, 0.29974714f, 0.04249835f, 0.00386621f, -0.05776640f, 0.12655592f, 
    -0.03140342f, 0.07390259f, -0.01351607f, 0.37835634f, 0.54742104f, 0.32109278f, -0.23596181f, -0.25227699f, 
    0.10566445f, -0.13565788f, -0.09149365f, -0.28339809f, 0.06811802f, -0.12596497f, 0.17483544f, -0.05562394f, 
    -0.06780964f, 0.03167509f, -0.00126973f, 0.00047548f, -0.00047960f, 0.09835476f, -0.05138083f, -0.21188363f, 
    -0.45380485f, -0.05541237f, -0.11683128f, 0.17051908f, -0.08119020f, 0.02042447f, 0.05097174f, 0.12840128f, 
    0.06011298f, -0.07128235f, 0.11786079f, 0.18766148f, 0.00592422f, 0.17092349f, -0.00878516f, -0.20534207f, 
    -0.05296228f, -0.05653922f, 0.04427110f, 0.33070478f, 0.69165492f, -0.01330609f, -0.02254265f, -0.09366964f, 
    -0.08011440f, -0.07744546f, 0.17307012f, -0.23486206f, 0.05124892f, 0.09486493f, -0.06965582f, 0.20255308f, 
    -0.13066864f, 0.03355815f, -0.19606662f, -0.03957174f, 0.03943188f, 0.17588727f, 0.03881397f, -0.06152385f, 
    0.18319891f, 0.11678784f, 0.30836704f, 0.24778202f, 0.08229121f, -0.15127631f, -0.11849964f, -0.07960677f, 
    0.28764126f, 0.07997160f, 0.12759976f, 0.06385194f, 0.18912193f, 0.04254780f, -0.33154610f, 0.11568188f, 
    0.19700149f, 0.21235868f, 0.28501186f, 0.08883377f, -0.16864236f, 0.06064540f, -0.04018724f, -0.27038592f, 
    -0.48082590f, -0.24769808f, 0.10525164f, 0.08052379f, 0.07387070f, -0.13698854f, -0.15006948f, -0.33379468f, 
    -0.00543283f, -0.01970298f, -0.01733409f, -0.00317210f, -0.06597181f, 0.02562598f, -0.06990835f, -0.04605689f, 
    -0.06064755f, -0.01215422f, -0.03959681f, -0.04495360f, 0.05074349f, -0.03624687f, 0.00831535f, -0.01535662f, 
    -0.02380251f, 0.03118608f, -0.04647301f, -0.06528872f, -0.00050497f, -0.01002778f, -0.05880427f, 0.04336001f, 
    0.01911845f, 0.02084354f, 0.02372641f, 0.04694192f, -0.01494684f, 0.03276765f, 0.02105910f, -0.02388254f, 
    0.04153973f, -0.00665495f, -0.01260044f, 0.01266317f, -0.06572324f, 0.02205621f, 0.00493576f, -0.01267854f, 
    -0.03994239f, -0.03801884f, -0.06550110f, 0.00935597f, 0.02838956f, -0.03513932f, 0.01381684f, -0.00619407f, 
    -0.00068732f, 0.02240953f, -0.05541516f, 0.01722379f, -0.03517750f, -0.06130898f, 0.03880403f, 0.03232191f, 
    -0.05449751f, -0.00804847f, -0.01174654f, 0.00511156f, -0.01252902f, 0.01066778f, -0.06099332f, -0.04701641f, 
    -0.06607649f, -0.06404053f, -0.06546770f, 0.00672506f, -0.05700237f, -0.03787028f, -0.00402129f, 0.04149641f, 
    -0.04564071f, -0.06294262f, -0.06151663f, -0.01844772f, 0.00611943f, -0.04069982f, -0.03546701f, -0.03364399f, 
    0.04317845f, 0.02072976f, -0.05392281f, -0.02271863f, -0.00834291f, -0.01732316f, 0.00651173f, -0.06781253f, 
    -0.04577058f, -0.04065812f, -0.02033792f, 0.00310702f, -0.04705780f, -0.04937210f, -0.04315279f, 0.00322623f, 
    0.02688508f, -0.03763494f, -0.02023395f, 0.01545090f, -0.07001098f, 0.01292812f, 0.02325593f, -0.02483373f, 
    0.04580088f, 0.03734129f, -0.03106849f, -0.05858494f, -0.05767963f, -0.06743019f, -0.02267578f, 0.03955201f, 
    -0.03880486f, 0.02356804f, 0.03446853f, -0.03515441f, -0.02793628f, 0.00548011f, -0.03667637f, -0.04662995f, 
    0.03667342f, 0.02129155f, -0.01772900f, 0.01475833f, 0.04125977f, 0.00465905f, 0.02791953f, 0.03212768f, 
    -0.02005698f, -0.02354442f, -0.03328963f, 0.03469975f, -0.06175945f, 0.01543749f, 0.02860941f, 0.02738814f, 
    0.02611582f, 0.01097586f, 0.00180785f, 0.02353445f, 0.02953142f, -0.05298514f, 0.04508184f, 0.02271923f, 
    -0.00078927f, 0.02176131f, 0.04059961f, -0.00332981f, 0.04539675f, -0.00132778f, -0.01407250f, 0.00770772f, 
    0.01640006f, -0.05259884f, -0.02468511f, 0.00746873f, -0.00513131f, -0.00805433f, -0.03951497f, 0.03632095f, 
    -0.04951593f, -0.01608521f, -0.06385068f, -0.06039477f, 0.01837270f, -0.03796485f, 0.02671027f, -0.02539300f, 
    -0.03843138f, -0.01791751f, -0.04436196f, 0.03629226f, -0.03424304f, 0.04215189f, -0.04890866f, 0.04648652f, 
    0.01654381f, -0.00457721f, -0.06824192f, -0.02793078f, 0.01888027f, -0.01038537f, -0.03354751f, 0.01111957f, 
    -0.05267690f, -0.04681425f, -0.00281809f, -0.00361455f, -0.05659086f, -0.04031280f, -0.05198795f, 0.04218631f, 
    -0.01422903f, -0.02401618f, 0.03828104f, -0.06610726f, -0.02156412f, -0.06836800f, 0.02920334f, 0.04011905f, 
    -0.00105779f, -0.05643502f, 0.02611213f, -0.01400984f, 0.01898743f, 0.00077164f, -0.06063383f, 0.04472667f, 
    -0.00209745f, -0.04790891f, 0.03064994f, -0.00749407f, -0.01606928f, -0.03312492f, -0.03332083f, 0.01483503f, 
    0.00687677f, 0.00099926f, -0.01263414f, -0.04220702f, -0.04162159f, -0.02330020f, -0.00822731f, -0.01477982f, 
    0.01380504f, 0.03613385f, 0.00845115f, 0.04112804f, 0.04883341f, -0.02223283f, -0.03562528f, 0.00001616f, 
    0.04336033f, 0.02889795f, 0.03101891f, 0.02768681f, 0.01451127f, -0.02215884f, -0.05372066f, -0.07002003f, 
    -0.05349775f, -0.01509135f, 0.00809737f, 0.01152321f, -0.06029677f, -0.04041874f, 0.00445951f, 0.00827311f, 
    -0.04427576f, 0.04081770f, 0.02418773f, -0.04549317f, -0.01057025f, 0.00603619f, 0.03984160f, 0.01713870f, 
    0.01589405f, -0.01925322f, -0.05354839f, 0.01885005f, -0.06635798f, 0.01410825f, -0.04649583f, -0.04654719f, 
    0.04073801f, -0.03315663f, 0.00424594f, 0.02425025f, -0.00400278f, -0.06314632f, -0.02170344f, 0.02904954f, 
    -0.00570151f, 0.04383885f, -0.00745797f, -0.02542781f, -0.04048170f, -0.02004783f, 0.03925286f, -0.00389158f, 
    -0.00948344f, 0.03709555f, -0.05457902f, 0.02610974f, 0.04329890f, -0.02104646f, -0.02284016f, -0.02738160f, 
    0.34146383f, -0.34529880f, -0.72014904f, 0.17279562f, 0.10982696f, 0.29798079f, 0.15072235f, 0.01552797f, 
    0.05923785f, 0.17522459f, 0.26832956f, 0.17765272f, -0.13674071f, -0.11351404f, -0.10903925f, 0.01412569f, 
    0.08574194f, 0.29792258f, 0.37926760f, 0.09728824f, -0.06949741f, -0.05523738f, -0.33386916f, 0.20952083f, 
    0.37705335f, -0.12876940f, 0.06741359f, 0.06390297f, -0.30428684f, -0.22940384f, -0.20704885f, 0.08268902f, 
    0.20618190f, -0.08080430f, -0.01522301f, -0.08402625f, -0.15528713f, 0.24261253f, -0.18913136f, 0.00949985f, 
    -0.01161921f, 0.09002949f, 0.15514769f, -0.07155324f, 0.40777123f, -0.31877142f, -0.00944610f, 0.02812480f, 
    -0.14762396f, -0.07565935f, 0.10084453f, -0.01723565f, 0.01375661f, 0.04541955f, 0.10158334f, -0.02579288f, 
    -0.20292546f, 0.08910594f, 0.04550274f, 0.22596912f, 0.16625254f, -0.03265268f, -0.04254859f, -0.41311112f, 
    -0.32453838f, 0.30250204f, -0.12561806f, 0.18904993f, -0.39400452f, 0.07478974f, 0.17586793f, 0.13061903f, 
    -0.27513072f, -0.03170337f, -0.80040771f, -0.04705338f, -0.24973035f, -0.00616724f, 0.06938866f, -0.08648290f, 
    -0.09029677f, -0.15668666f, -0.01006947f, 0.00673138f, 0.00552736f, -0.12633102f, 0.06811340f, -0.04678063f, 
    -0.02807252f, -0.18244053f, -0.41725782f, 0.15014109f, 0.18870996f, -0.12006313f, -0.01596461f, -0.22849897f, 
    0.06485523f, 0.16917758f, 0.24380866f, -0.06678931f, -0.65300143f, -0.07012852f, 0.03671578f, -0.12566441f, 
    0.09353792f, 0.08851030f, -0.10670506f, -0.11993589f, 0.31530336f, -0.59466070f, 0.04556711f, 0.06418709f, 
    0.10002059f, -0.02086332f, 0.01606972f, -0.04973650f, 0.05470312f, -0.15118060f, 0.17123386f, 0.53232133f, 
    -0.05956315f, 0.14017177f, 0.13969181f, 0.09661502f, -0.02285557f, -0.08295892f, -0.61384243f, -0.39066467f, 
    0.33289465f, 0.08111957f, -0.07647917f, -0.14150454f, 0.04960452f, 0.08013409f, -0.03133843f, 0.14841646f, 
    -0.35073426f, -0.48328078f, -0.35532656f, -0.20066895f, -0.21559848f, 0.03281444f, -0.01105271f, 0.11599507f, 
    0.05365666f, -0.00408548f, -0.03164897f, 0.19806361f, 0.05251845f, 0.09051588f, 0.07055523f, -0.11320631f, 
    0.09958769f, 0.38699323f, -0.15546234f, -0.59925580f, -0.31798324f, -0.07709907f, 0.01009768f, 0.10973082f, 
    0.14539471f, 0.00988043f, 0.00173847f, -0.30813524f, -0.51733088f, 0.27456433f, 0.13221480f, 0.13450369f, 
    -0.00076188f, 0.02676083f, 0.10529145f, 0.68511987f, -0.54150552f, 0.17529312f, -0.06593443f, -0.29537472f, 
    -0.03978772f, -0.05650271f, 0.13447185f, -0.18703127f, 0.30765256f, 0.22385190f, 0.02134204f, -0.04051612f, 
    -0.01497820f, 0.35139337f, 0.01488593f, 0.04070494f, 0.12997158f, -0.21424583f, 0.07474322f, -0.19333096f, 
    0.10471560f, 0.20129180f, 0.16405167f, -0.03450313f, -0.04026500f, 0.04921868f, -0.30204141f, -0.00917437f, 
    0.92435962f, -0.03764877f, -0.06746189f, -0.09967040f, 0.03996296f, -0.00171989f, 0.04157410f, -0.18563272f, 
    0.02059173f, -0.03059348f, -0.09559546f, -0.03347268f, -0.00604548f, -0.07077280f, 0.00659468f, 0.11026420f, 
    -0.22904444f, 0.12600870f, 0.06796034f, 0.03177788f, -0.00357337f, -0.04776165f, 0.23423152f, -0.03559027f, 
    -0.18833511f, 0.04383359f, -0.11361331f, -0.13732053f, 0.07192756f, 0.04721699f, 0.13186927f, 0.10903230f, 
    0.10835895f, -0.08476223f, 0.08527082f, -0.84619510f, -0.16169833f, -0.02606787f, -0.04767761f, -0.12591441f, 
    0.11412521f, -0.13793258f, 0.19041395f, -0.21259433f, 0.13349593f, 0.40428331f, 0.14242898f, 0.13175115f, 
    -0.18104392f, 0.03384265f, 0.09012374f, 0.20788328f, -0.01564220f, -0.14829293f, -0.42992258f, 0.02348178f, 
    0.05556040f, 0.17941728f, 0.13177267f, -0.06410991f, 0.03562780f, -0.00790450f, 0.21843532f, 0.14278550f, 
    -0.12602492f, -0.06830645f, -0.12441508f, 0.07067037f, -0.03649691f, 0.25815445f, 0.37141541f, -0.29847896f, 
    -0.19753620f, 0.04725123f, 0.07585179f, -0.03528981f, 0.09977960f, 0.19360523f, 0.11852914f, -0.38655582f, 
    -0.34584188f, -0.84673983f, -0.04909296f, -0.09188927f, 0.03315755f, 0.05290482f, 0.05475563f, 0.16351166f, 
    0.53259403f, 0.06657793f, -0.43420705f, -0.02482327f, 0.05820954f, 0.00745170f, -0.05360280f, 0.17024411f, 
    -0.11812638f, 0.00687168f, 0.09285358f, 0.12227365f, -0.32829928f, -0.02657717f, -0.42712009f, -0.05420474f, 
    -0.39905590f, 0.09707241f, 0.04462408f, 0.19447200f, 0.49696526f, -0.01600224f, 0.24149051f, 0.07062187f, 
    0.00189036f, 0.06723279f, 0.08620320f, -0.06169760f, -0.03930993f, -0.04586215f, 0.28836691f, 0.09049530f, 
    0.07397246f, 0.05899668f, -0.10057876f, -0.23519811f, -0.12679219f, -0.26896653f, -0.21138468f, -0.07966653f, 
    -0.11255514f, -0.09764814f, 0.18251120f, -0.14181884f, 0.17560023f, 0.03606416f, -0.80392337f, -0.30827275f, 
    -0.14200726f, -0.09147462f, 0.16531615f, 0.10518082f, 0.02070117f, -0.00405437f, -0.02962371f, 0.09070817f, 
    -0.07352802f, 0.10007327f, 0.09494532f, 0.01695674f, 0.06373136f, -0.09071992f, 0.13612315f, 0.34299737f, 
    -0.04902909f, -0.01966835f, -0.02114953f, 0.34068942f, 0.17308047f, 0.26737490f, 0.13276473f, -0.12414233f, 
    0.01661650f, -0.49283937f, -0.65460640f, 0.01119793f, -0.15802707f, 0.07104525f, 0.16795093f, 0.15730093f, 
    0.02669279f, -0.13686252f, 0.22089761f, 0.08349986f, -0.21948075f, -0.05093342f, -0.42251414f, 0.08212152f, 
    -0.16621049f, -0.00518386f, 0.23038390f, 0.30018747f, -0.11550609f, 0.04955548f, 0.28061232f, -0.20634258f, 
    0.01631773f, 0.07508024f, 0.08595583f, -0.48997587f, 0.02281823f, 0.05355602f, -0.03259840f, -0.06262555f, 
    0.02759469f, -0.05598024f, 0.01825378f, -0.08770835f, 0.02185018f, 0.07345316f, -0.03121100f, -0.03832534f, 
    -0.04872899f, 0.00686328f, -0.06563203f, 0.03473902f, -0.28823423f, -0.26147729f, -0.96818900f, -0.50779259f, 
    -0.01800559f, 0.20459990f, 0.06443885f, -0.03054993f, 0.03768217f, -0.09021421f, 0.00503682f, 0.18921509f, 
    0.05417962f, 0.10898225f, 0.09163643f, -0.02718389f, 0.14628492f, 0.00390914f, -0.07282314f, -0.20376123f, 
    -0.79436612f, -0.50984472f, -0.22004654f, -0.04228155f, 0.09768059f, 0.00163546f, -0.15922412f, -0.04659001f, 
    -0.09506656f, 0.17796822f, 0.05063336f, 0.11658948f, -0.17533314f, -0.06437639f, 0.08374490f, -0.10592090f, 
    0.05734178f, 0.27974194f, -0.00577356f, -0.16677186f, -0.17311673f, -0.03695410f, -0.03730675f, 0.12688057f, 
    0.11329636f, -0.12668584f, 0.12699446f, 0.20337270f, -0.34642187f, 0.10139105f, 0.05858731f, 0.02379256f, 
    0.13079450f, 0.09646785f, 0.04288634f, -0.23876384f, -0.12645723f, 0.58081990f, -0.41578275f, -0.05303954f, 
    -0.06409123f, 0.11812565f, -0.00361815f, 0.11765494f, -0.49167922f, -0.06272933f, 0.32493323f, -0.26268116f, 
    0.07635164f, 0.34691149f, 0.11761208f, 0.04611792f, 0.17649686f, 0.27706861f, 0.04787516f, -0.16881305f, 
    0.22000225f, 0.14519210f, 0.02303980f, 0.06794692f, -0.17988981f, -0.02360095f, 0.66919595f, 0.01840094f, 
    -0.13305694f, -0.04396642f, -0.15884376f, -0.03284143f, 0.04919001f, 0.08506001f, -0.09157477f, 0.04334591f, 
    0.17982048f, 0.17117833f, -0.09204715f, 0.04740993f, -0.07270239f, 0.24128287f, -0.05260371f, 0.08365437f, 
    0.23713502f, -0.14108545f, -0.18018556f, 0.04775215f, 0.24919292f, -0.21531977f, 0.16053252f, -0.15235698f, 
    -0.00389725f, 0.18737285f, 0.21338996f, 0.00480912f, 0.17534618f, -0.06008406f, -0.06442243f, 0.09455583f, 
    0.03887450f, 0.03706828f, 0.38006479f, -0.04190122f, -0.13571799f, -0.00780316f, -0.09189329f, 0.01848796f, 
    0.03220975f, 0.14214514f, -0.27770668f, 0.43221831f, -0.30465555f, -0.44445473f, -0.12517980f, -0.03047848f, 
    0.06627616f, 0.05747895f, -0.08293414f, -0.00618183f, -0.64550734f, 0.23228545f, -0.08902857f, 0.12197092f, 
    0.15085822f, 0.03680786f, -0.08474899f, 0.10640566f, 0.03712559f, 0.15128504f, -0.05776300f, -0.16324136f, 
    -0.15085974f, -0.00258792f, -0.38934869f, 0.13549939f, 0.06060000f, -0.02864170f, 0.02747761f, 0.28313223f, 
    0.07540956f, 0.10128176f, 0.09709635f, 0.04928150f, 0.00496430f, -0.04398860f, 0.13649881f, 0.03140541f, 
    0.05697835f, -0.05100935f, -0.08393843f, -0.08637694f, -0.09172923f, -0.16276750f, 0.16598767f, 0.06617593f, 
    0.33366162f, 0.11229998f, 0.32629317f, 0.04922610f, 0.06856627f, -0.14537545f, 0.10330281f, 0.06849194f, 
    -0.13121416f, -0.08863878f, 0.16986071f, 0.02941546f, -0.22061560f, -0.00921199f, 0.12670006f, -0.11856125f, 
    -0.02733848f, 0.15943439f, -0.10120959f, -0.24876715f, -0.22031878f, 0.04922386f, 0.14494841f, 0.36214700f, 
    0.16662537f, 0.12056315f, -0.10178541f, -0.30632761f, 0.10506113f, -0.20283024f, 0.03509460f, -0.15351629f, 
    -0.12532091f, 0.33651650f, 0.09877241f, 0.06534622f, -0.05230731f, 0.08217388f, 0.02759288f, 0.02910575f, 
    0.07765488f, 0.02109143f, -0.01702359f, -0.04700253f, 0.20044507f, 0.04774362f, -0.08172791f, 0.53143805f, 
    -0.05034821f, 0.05493988f, -0.06171905f, 0.04007883f, 0.10442508f, 0.25079608f, -0.02276764f, 0.08291081f, 
    -0.13159709f, -0.00052605f, 0.13391879f, -0.13348359f, -0.02970804f, 0.11256247f, 0.09714825f, -0.05975787f, 
    -0.26575777f, 0.00494875f, 0.24604268f, 0.21588482f, -0.05980370f, 0.00169221f, -0.01565605f, 0.08317938f, 
    -0.11721988f, -0.03149270f, -0.17340635f, -0.06274579f, -0.02888929f, -0.08542722f, -0.10969295f, -0.10021149f, 
    0.24474744f, 0.11068451f, 0.10481612f, 0.01435876f, -0.08096911f, -0.27683800f, -0.12982409f, 0.33588031f, 
    0.35601163f, 0.15912135f, 0.35199043f, -0.09119634f, -0.54095370f, -0.06954522f, -0.00967334f, 0.02701063f, 
    0.08480265f, 0.00758153f, -0.18495695f, -0.45158315f, 0.36874667f, 0.28872943f, -0.00585743f, 0.13352315f, 
    -0.13452011f, -0.15053265f, -0.05734849f, 0.04780558f, -0.05813137f, -0.01608975f, 0.33418199f, 0.00024946f, 
    0.12128147f, -0.25849313f, 0.04612612f, -0.10926542f, 0.05688429f, -0.03122160f, -0.21021715f, 0.38456559f, 
    0.02139321f, 0.13522431f, -0.14375886f, -0.16373803f, 0.13451760f, 0.13412523f, 0.03930208f, -0.00522565f, 
    0.11082006f, -0.01684998f, -0.06832325f, -0.47804457f, -0.06528571f, -0.32788920f, 0.00470517f, -0.38666824f, 
    0.06620775f, 0.20788118f, 0.04773425f, 0.03249250f, -0.06777167f, 0.08887265f, -0.04444215f, 0.11079691f, 
    -0.15282534f, -0.09117579f, -0.07674018f, -0.29988807f, 0.00732770f, 0.09797511f, 0.31499699f, 0.00483981f, 
    0.08426912f, -0.48247182f, -0.03673537f, 0.21800202f, -0.00475915f, -0.12881735f, -0.14066897f, -0.03040561f, 
    -0.04254623f, 0.31515545f, 0.03996668f, -0.20742397f, -0.44972169f, 0.03832041f, 0.01410189f, -0.14104219f, 
    0.04642396f, 0.05012816f, -0.26346391f, -0.39510497f, 0.37338811f, 0.39978132f, -0.06865273f, 0.24204732f, 
    -0.26969451f, 0.10886725f, -0.26120192f, 0.19446571f, -0.17508228f, 0.21952957f, 0.00162203f, 0.06747734f, 
    0.27168655f, -0.07096630f, 0.20508932f, -0.22687769f, 0.01629409f, 0.02291207f, 0.06934755f, 0.14723013f, 
    0.00346131f, 0.22676574f, -0.05945412f, 0.10790707f, 0.27434796f, -0.07752300f, -0.06141467f, -0.34937131f, 
    -0.00529803f, 0.23044533f, -0.05608726f, 0.08442590f, -0.20466943f, 0.00845673f, 0.13649012f, -0.07838123f, 
    -0.00265564f, -0.00453620f, -0.30293486f, -0.17763180f, 0.06496552f, -0.01283393f, 0.08229765f, 0.05165770f, 
    0.12919113f, -0.05778303f, -0.06257389f, 0.05201310f, 0.23567249f, 0.37335894f, 0.02098685f, 0.18142472f, 
    -0.08577498f, -0.05505613f, -0.06708831f, -0.02900412f, -0.15743795f, -0.11081798f, -0.03214845f, -0.06116994f, 
    0.10639278f, 0.14954685f, -0.09652527f, 0.26578826f, 0.22569005f, 0.00002696f, -0.06046265f, -0.08365285f, 
    0.19613767f, -0.14664625f, 0.06273693f, -0.15494516f, -0.41971397f, 0.08669656f, 0.25372076f, 0.12805122f, 
    0.09925483f, -0.08114366f, -0.03775271f, -0.00283335f, 0.28923365f, 0.30737907f, 0.51176733f, 0.01676719f, 
    0.16310509f, -0.00383657f, 0.26379931f, 0.01123952f, 0.09753234f, 0.10234045f, -0.01637242f, -0.22086474f, 
    0.10214309f, -0.02282898f, 0.15910080f, -0.06288260f, 0.12903172f, 0.05971948f, -0.24358232f, 0.10187248f, 
    -0.07479607f, -0.03165891f, 0.11074124f, -0.04812108f, -0.12940648f, 0.10608475f, 0.19129409f, 0.27787662f, 
    -0.15199372f, 0.42130560f, -0.10377635f, 0.11290138f, -0.03405853f, 0.14980671f, 0.07694424f, 0.12506856f, 
    -0.20087820f, -0.17281336f, -0.19234431f, 0.10762969f, -0.06328416f, 0.24435343f, -0.09279203f, 0.00582414f, 
    0.12582159f, -0.08455408f, -0.07633404f, -0.03946172f, -0.25026450f, -0.15694185f, -0.16793512f, 0.25043073f, 
    0.11547527f, -0.06814188f, -0.01559735f, 0.32648996f, -0.37714809f, -0.08107217f, -0.06687890f, -0.15698323f, 
    -0.13876460f, -0.15215470f, -0.24469295f, -0.15002058f, -0.21713960f, -0.27291986f, -0.03766402f, -0.22208384f, 
    -0.12544593f, -0.27787614f, -0.19552146f, -0.11132804f, -0.08890130f, -0.19004582f, 0.12095581f, -0.19416785f, 
    0.07062346f, 0.07035370f, 0.35750470f, 0.13633654f, 0.21357957f, -0.82374293f, -0.14566889f, -0.01668773f, 
    -0.00064356f, 0.21723162f, -0.00761501f, 0.08415488f, 0.05794566f, 0.09450938f, 0.38485152f, 0.22800933f, 
    0.08425708f, 0.04909107f, 0.07610796f, -0.02574546f, 0.02140868f, -0.20165144f, -0.14823993f, 0.01286425f, 
    -0.50307703f, 0.03479606f, -0.13949399f, 0.10164998f, -0.02269479f, 0.11494702f, -0.27764994f, 0.00494138f, 
    -0.31018883f, -0.74722910f, 0.28100222f, 0.17315568f, 0.14095178f, 0.15293713f, 0.18627682f, -0.00065382f, 
    0.20664133f, -0.39367008f, -0.03116509f, -0.08716200f, 0.01976952f, 0.06942955f, -0.06859449f, 0.04596704f, 
    0.15365264f, -0.01536810f, 0.10820670f, 0.08524443f, 0.00948732f, -0.01876543f, 0.27707711f, -0.19056894f, 
    -0.03488481f, 0.07522286f, -0.04740668f, -0.05885836f, 0.62571168f, -0.31138194f, -0.05818241f, -0.17502409f, 
    -0.06110290f, -0.10809018f, -0.11130736f, -0.12234117f, 0.18895644f, 0.48154420f, 0.23550415f, 0.03657709f, 
    -0.06542117f, -0.15416288f, -0.08518879f, -0.05685210f, -0.01651431f, -0.20777176f, 0.10923057f, 0.32185525f, 
    0.01677053f, 0.32904270f, 0.30269730f, 0.07210694f, 0.04465258f, 0.04034775f, 0.12585363f, 0.11941075f, 
    0.24729648f, -0.19846730f, -0.01553950f, -0.20463823f, 0.24658465f, 0.20595030f, 0.08586219f, -0.32489914f, 
    -0.25412777f, 0.51774120f, -0.01705727f, 0.06506466f, 0.10509242f, 0.13914561f, -0.02372565f, 0.13210712f, 
    -0.02429540f, 0.18263517f, -0.03908580f, 0.24949993f, 0.00479272f, -0.05778135f, 0.06220351f, -0.01953980f, 
    -0.40283230f, -0.06373563f, -0.08191387f, 0.65690809f, 0.06531012f, 0.12053102f, -0.04829804f, 0.22162452f, 
    0.04227306f, 0.12811257f, 0.68959880f, 0.03406491f, 0.01351605f, 0.25117832f, 0.16664582f, 0.19709298f, 
    -0.05961628f, -0.29831129f, 0.06680605f, -0.05669206f, -0.30037433f, 0.26601338f, -0.04760656f, -0.14880928f, 
    0.18592669f, 0.09308361f, -0.15576185f, 0.09307629f, 0.05522058f, -0.00298362f, 0.20818838f, 0.08526503f, 
    -0.01666887f, 0.01884132f, 0.22901791f, -0.06111185f, 0.12024200f, 0.05663523f, -0.18797223f, -0.40727058f, 
    -0.00986070f, 0.11640360f, 0.17244123f, 0.03882036f, -0.21433128f, -0.10312755f, -0.21486010f, -0.12351882f, 
    0.17654584f, -0.02310469f, 0.03733737f, 0.16793653f, 0.05058948f, 0.03172502f, 0.01900341f, 0.13510041f, 
    0.32719356f, 0.01029414f, -0.04891787f, 0.02873585f, 0.03407465f, 0.12242443f, 0.37087211f, -0.05838738f, 
    -0.27167833f, -0.51294631f, -0.45873523f, -0.10657900f, 0.01372875f, 0.03691327f, 0.12832010f, -0.11784226f, 
    -0.30784163f, 0.36122379f, 0.23497769f, -0.09507978f, 0.06498247f, 0.08407976f, 0.01926505f, 0.14175291f, 
    0.11074967f, -0.15579173f, -0.17907235f, -0.09528279f, -0.22681560f, -0.25872666f, -0.15548660f, 0.08125375f, 
    0.23163924f, -0.22444990f, 0.14496391f, -0.08948921f, -0.04986043f, 0.17581329f, -0.04054916f, 0.14507708f, 
    0.06207465f, -0.07765178f, -0.06457745f, 0.00085982f, -0.03336442f, -0.03384760f, -0.01446788f, 0.24204044f, 
    0.05635108f, -0.00462115f, 0.15692121f, 0.20185894f, -0.05950114f, -0.20492962f, -0.14177880f, -0.06746926f, 
    -0.05376576f, 0.11767139f, 0.10244136f, 0.06929559f, 0.10435688f, 0.07486366f, 0.28981653f, 0.31447956f, 
    0.27293187f, 0.06710342f, 0.04490092f, -0.09461831f, 0.15027803f, 0.06454263f, 0.03256198f, -0.06819965f, 
    0.14181128f, -0.19889377f, 0.01694496f, 0.04630550f, 0.00542663f, -0.05932673f, 0.06633478f, 0.07834044f, 
    0.00583894f, -0.03467992f, -0.00479839f, -0.06776646f, -0.06004514f, 0.04481833f, -0.04644335f, 0.00190479f, 
    0.03199376f, -0.04132792f, -0.04427288f, -0.03952249f, -0.05044124f, 0.03388440f, -0.05009118f, -0.01904736f, 
    -0.03271021f, -0.03607139f, -0.02353151f, -0.06495097f, -0.00250080f, 0.04584898f, -0.07055701f, -0.04547180f, 
    -0.03068697f, 0.03329547f, -0.02658659f, 0.01430881f, 0.05094207f, -0.07856730f, -0.04382581f, 0.03851668f, 
    -0.02693899f, -0.05956460f, -0.04675396f, -0.00930744f, -0.02139123f, -0.02671249f, -0.00878185f, 0.00004688f, 
    -0.01136397f, -0.00953860f, -0.03676243f, -0.02357962f, 0.04866290f, 0.00739535f, -0.03673823f, 0.02983211f, 
    0.01730169f, -0.01436817f, 0.02478808f, 0.04815134f, 0.00725567f, -0.03845960f, 0.00654135f, 0.01898982f, 
    -0.06539779f, -0.03416514f, 0.03399274f, -0.06639386f, -0.04432341f, 0.01402696f, 0.02268950f, 0.00166096f, 
    -0.05159630f, -0.03082160f, 0.01865909f, -0.00058260f, -0.05396248f, -0.05200200f, 0.04640572f, 0.02511414f, 
    -0.03873630f, -0.03054456f, -0.05029204f, 0.01996666f, 0.02600668f, 0.02278969f, -0.04538543f, 0.04692598f, 
    0.00506699f, -0.04496869f, -0.01981350f, -0.05503318f, 0.03561967f, 0.04444633f, 0.00988462f, 0.00714612f, 
    -0.04753675f, -0.01826877f, -0.03907534f, -0.00959644f, -0.02602418f, 0.01036339f, 0.03991640f, -0.03733110f, 
    -0.04568953f, -0.06745100f, -0.03172462f, -0.02169700f, 0.01750129f, -0.03148100f, 0.03312508f, -0.05506964f, 
    -0.04119905f, 0.03242153f, -0.02408793f, 0.01083672f, 0.02604496f, 0.04294765f, -0.03696238f, 0.04579495f, 
    -0.02435201f, 0.04372501f, -0.00343622f, -0.01606935f, -0.01998613f, 0.03333274f, 0.01168052f, 0.00659865f, 
    0.02855484f, -0.01239835f, 0.04346332f, -0.04494555f, -0.00227532f, 0.04716451f, 0.03459631f, -0.02162594f, 
    -0.01890368f, -0.05496458f, 0.00612673f, -0.06183971f, 0.01327240f, -0.02172915f, 0.00131503f, -0.02310229f, 
    -0.05638745f, 0.01680885f, -0.04841919f, -0.05761554f, 0.02918296f, -0.05475776f, -0.00034044f, 0.00849414f, 
    -0.01605248f, 0.04576735f, -0.04332170f, -0.04194644f, 0.00054843f, 0.00479748f, -0.04633241f, -0.00128779f, 
    -0.04855355f, -0.06798512f, -0.04982968f, 0.02318279f, -0.03862277f, 0.04371836f, -0.02133233f, 0.04455721f, 
    0.04374529f, 0.02890163f, 0.00590960f, 0.03981289f, 0.00814132f, -0.07130507f, 0.02078855f, -0.05592543f, 
    0.03640172f, 0.00638726f, 0.02568851f, -0.03824501f, 0.04362482f, 0.02118742f, 0.02489195f, -0.03936809f, 
    0.03331556f, 0.03960042f, 0.01817045f, -0.00307138f, -0.01636787f, 0.01769663f, -0.05444339f, -0.02046228f, 
    -0.05310947f, -0.05043773f, 0.01896766f, -0.02907961f, 0.01692629f, 0.01042470f, 0.01994582f, -0.05924610f, 
    -0.04489549f, -0.04851656f, -0.01406912f, -0.02268512f, -0.00180115f, -0.05487619f, 0.04246565f, -0.06325593f, 
    0.02328444f, 0.00964159f, 0.02637057f, -0.03152034f, -0.03930213f, 0.00523459f, -0.01405759f, 0.03048676f, 
    -0.04673447f, 0.01387148f, -0.03995374f, -0.05549815f, -0.03887130f, 0.00041367f, -0.01705501f, 0.00556664f, 
    0.02649954f, -0.01866890f, -0.03052996f, 0.02358920f, -0.05992666f, 0.03148489f, 0.03426341f, 0.03384321f, 
    -0.00732190f, -0.04392450f, 0.02693956f, -0.04504489f, 0.03945192f, -0.04087411f, -0.04764181f, -0.01903549f, 
    -0.02597858f, -0.01721850f, 0.03757082f, 0.02554878f, 0.01213863f, -0.05625058f, -0.04926652f, -0.00923788f, 
    0.00964218f, 0.01154202f, -0.04232902f, -0.06578028f, 0.01898594f, -0.06418502f, 0.01762862f, 0.01609810f, 
    -0.03883053f, 0.00035723f, -0.02431376f, -0.02341138f, -0.00430718f, -0.05265184f, 0.03279838f, 0.00169234f, 
    0.04699430f, 0.03230145f, 0.00194111f, 0.03866341f, 0.01418230f, 0.04651064f, -0.05801868f, -0.04829179f, 
    0.04393833f, -0.06586301f, 0.04681490f, -0.04535448f, -0.05589669f, 0.00702761f, 0.00741183f, 0.00476255f, 
    0.00395876f, 0.01577772f, 0.03622428f, 0.05316176f, -0.04881994f, -0.06286845f, -0.01620014f, -0.04917113f, 
    -0.00266630f, -0.04812765f, -0.03672099f, 0.02323518f, -0.05419080f, -0.03925371f, -0.02141856f, -0.04886191f, 
    0.03113517f, 0.02404706f, 0.03610967f, 0.04461977f, 0.03503653f, 0.02707644f, -0.05318246f, 0.03642776f, 
    -0.02511445f, 0.01927227f, 0.02931412f, -0.06058460f, -0.00844826f, 0.03344798f, -0.05966555f, -0.05549975f, 
    -0.02846532f, 0.01240034f, 0.00838067f, -0.00380426f, -0.00396885f, 0.02745702f, -0.00421841f, -0.05216188f, 
    0.01898300f, 0.00152859f, -0.03290767f, -0.00275000f, 0.02019672f, 0.00629323f, 0.00905438f, -0.01894701f, 
    0.03515824f, -0.04660613f, 0.00174998f, -0.01331752f, -0.00174259f, -0.07139925f, 0.02231959f, 0.04616453f, 
    0.00199022f, -0.06278760f, 0.02282401f, -0.02731799f, -0.04419646f, -0.06256815f, -0.05294543f, 0.03523352f, 
    -0.05596280f, -0.04565587f, 0.03601472f, -0.02393344f, 0.04532134f, 0.03233663f, -0.01491183f, 0.02520747f, 
    0.00180473f, 0.03274177f, -0.00752395f, -0.04490652f, -0.00646825f, 0.01433275f, -0.02855836f, -0.04878968f, 
    0.04437714f, 0.01606626f, -0.04630840f, 0.00430050f, -0.04188241f, -0.01159668f, 0.03514281f, -0.04416588f, 
    -0.01330192f, 0.01900303f, -0.03310706f, -0.01263667f, -0.05750410f, 0.00053544f, 0.00329995f, 0.02042352f, 
    0.00400975f, 0.00259644f, -0.03106433f, 0.00013769f, -0.02726764f, 0.03086420f, 0.04194674f, -0.00456961f, 
    0.01189951f, 0.02977988f, -0.03929314f, -0.02862080f, -0.01730962f, -0.03084807f, -0.06566808f, -0.00470274f, 
    0.01574107f, -0.03602843f, -0.04966356f, -0.06607072f, 0.01138584f, 0.00566284f, -0.06944158f, 0.00465882f, 
    -0.04889828f, -0.04254169f, 0.00127975f, -0.04530365f, -0.04372560f, 0.00126991f, 0.02800305f, -0.04916351f, 
    0.03208441f, 0.00903247f, 0.03424484f, -0.02013686f, -0.02790546f, 0.01546187f, 0.01106001f, -0.01243866f, 
    0.02347269f, 0.02963857f, -0.06308678f, 0.02434931f, -0.05041186f, -0.00020700f, -0.00524703f, 0.01997089f, 
    -0.04622913f, -0.02037273f, -0.06802916f, -0.07131561f, 0.00137248f, -0.03685778f, 0.04102973f, -0.01088717f, 
    -0.06182201f, 0.02430288f, 0.03935622f, 0.03620194f, 0.01710740f, -0.02099736f, -0.00794191f, -0.05756401f, 
    0.03556819f, -0.02311678f, -0.02873076f, -0.06937305f, 0.03978145f, 0.04463489f, -0.00753302f, 0.02661795f, 
    0.03698358f, -0.01671284f, -0.07076128f, -0.04075713f, -0.02452864f, 0.00676997f, 0.02111088f, -0.04411048f, 
    0.02576009f, -0.00953396f, 0.01510338f, 0.02256136f, 0.00303380f, 0.00139158f, -0.06398439f, -0.01041914f, 
    -0.01588314f, -0.05973214f, 0.02433492f, -0.02536484f, -0.01215246f, -0.04866496f, -0.00572453f, 0.03711344f, 
    -0.02878750f, -0.03421063f, 0.03799022f, -0.02689310f, -0.00376635f, -0.00296578f, 0.04562386f, -0.01543242f, 
    -0.07148028f, -0.05477513f, -0.05137356f, -0.06969289f, 0.01583615f, -0.04532688f, 0.03477740f, -0.06344751f, 
    -0.04764376f, -0.04208717f, 0.00220645f, 0.03896222f, 0.03655284f, -0.06940293f, -0.01059586f, 0.00402810f, 
    0.02618491f, -0.00945443f, -0.04816164f, -0.06073540f, -0.00398301f, 0.04418319f, -0.03331212f, -0.05824794f, 
    -0.05994684f, 0.02912072f, 0.01568686f, 0.00922892f, -0.05946546f, 0.01636129f, -0.00796830f, -0.00852993f, 
    0.03749214f, 0.01996041f, -0.03446482f, -0.00957725f, 0.04704358f, 0.01733933f, -0.02858907f, 0.03484143f, 
    0.03754891f, -0.00159355f, 0.02777922f, 0.02282517f, -0.03787297f, 0.00502388f, -0.03144502f, 0.01821881f, 
    -0.02793412f, 0.02560317f, 0.02561261f, -0.04436669f, -0.06612843f, 0.02739161f, 0.03281678f, -0.06245906f, 
    0.02758756f, -0.00024088f, -0.00925220f, 0.00817196f, -0.03203868f, 0.02023617f, 0.03639625f, 0.02877806f, 
    -0.01841376f, 0.01881454f, 0.00218965f, -0.03546908f, -0.01118950f, 0.02642847f, 0.04043977f, -0.05074978f, 
    -0.01672512f, -0.06321291f, -0.00943565f, 0.01261115f, -0.00641123f, 0.02037819f, -0.01824923f, -0.01889329f, 
    -0.06338429f, -0.06968120f, 0.00726339f, 0.03064074f, -0.04680945f, 0.00979995f, -0.00803107f, 0.02783367f, 
    0.02845135f, -0.01883906f, -0.05972989f, -0.01351190f, -0.00060812f, -0.02106967f, -0.05146303f, -0.04977106f, 
    0.02038412f, -0.02823347f, -0.02626071f, -0.03398219f, 0.01069558f, -0.03385190f, -0.02063262f, -0.01440099f, 
    -0.02696432f, 0.04201709f, -0.06194063f, 0.00875434f, -0.03390164f, -0.04408840f, -0.06453931f, -0.01134385f, 
    -0.00637506f, 0.01178786f, 0.03206694f, 0.01971703f, -0.00770106f, 0.00453394f, -0.03509266f, -0.00016220f, 
    -0.01696465f, 0.02267772f, 0.02900800f, 0.03084961f, -0.01698812f, 0.04769669f, 0.04780452f, -0.00116799f, 
    -0.01821404f, 0.00845039f, 0.02621906f, 0.01053303f, 0.03794013f, -0.01298989f, 0.00412721f, -0.02249769f, 
    -0.06299249f, -0.05645469f, -0.02401076f, -0.03647989f, 0.03011312f, -0.04924882f, -0.03693753f, -0.03323760f, 
    -0.02729257f, 0.01943947f, 0.01640462f, 0.04662796f, 0.00351742f, -0.06360695f, -0.03722272f, -0.01878799f, 
    0.04133726f, -0.06636338f, -0.03910458f, -0.01089369f, 0.02183586f, 0.00368589f, 0.04955688f, 0.00134420f, 
    -0.02101230f, 0.00228552f, -0.00564505f, 0.01609415f, -0.02167115f, 0.04575150f, -0.03014047f, 0.04878105f, 
    -0.06051525f, 0.03953996f, -0.03194115f, -0.05157468f, -0.01826726f, -0.03765893f, -0.01862014f, -0.03786127f, 
    -0.00820006f, -0.02217556f, -0.04306328f, 0.04573263f, -0.03131681f, 0.04653694f, 0.03967997f, -0.05732697f, 
    0.04665062f, -0.00192721f, -0.00436553f, 0.02108403f, 0.02575620f, 0.03132135f, -0.06797444f, 0.03815995f, 
    0.02267589f, 0.02360935f, 0.02445272f, 0.03873407f, -0.02729275f, -0.01260632f, 0.04491207f, -0.03400787f, 
    0.04650079f, -0.03067553f, -0.04806126f, 0.04342981f, 0.03445542f, -0.02380554f, 0.04405054f, 0.02500736f, 
    0.01625012f, 0.04513475f, 0.01732621f, -0.06713605f, 0.04153803f, -0.04352689f, 0.05346552f, -0.06120366f, 
    -0.06291116f, 0.04474906f, -0.04980338f, 0.03986866f, -0.00966640f, 0.03747532f, 0.02743472f, 0.03191660f, 
    -0.01281878f, 0.02024258f, 0.00841243f, -0.06042963f, 0.01745303f, -0.05218620f, -0.05860844f, 0.03838757f, 
    -0.02389300f, -0.01928446f, 0.04768923f, -0.05216563f, 0.04408992f, -0.01778398f, -0.00487693f, -0.02709504f, 
    -0.01909690f, -0.04045982f, -0.04214059f, -0.00153975f, -0.05031367f, -0.04284123f, -0.04832099f, -0.05691405f, 
    0.02848316f, -0.04589935f, 0.04241984f, -0.01942112f, -0.05101089f, -0.02189051f, -0.03529681f, 0.01563560f, 
    -0.00710876f, 0.04442166f, -0.02034621f, 0.04715704f, -0.05617886f, -0.05274256f, 0.04446195f, 0.03261763f, 
    -0.04386278f, 0.01776844f, 0.00821558f, -0.06798501f, -0.00600663f, -0.06692329f, 0.01105272f, -0.02403473f, 
    0.00320749f, -0.04906696f, -0.01812042f, -0.05067448f, -0.00092565f, 0.01382662f, -0.03506308f, -0.06126722f, 
    -0.02524834f, 0.03387371f, -0.04314104f, -0.06330569f, -0.00173576f, -0.01725893f, -0.03587764f, -0.04029494f, 
    -0.04293806f, -0.06705216f, -0.06285046f, 0.04464575f, 0.02525964f, 0.01628286f, 0.00606559f, -0.00019905f, 
    -0.04929006f, 0.04887651f, 0.03330318f, 0.03211485f, 0.01651594f, -0.06526545f, -0.04174303f, -0.03072667f, 
    -0.02286560f, 0.04351417f, 0.03285975f, -0.04363504f, -0.02758519f, -0.02396837f, 0.03462219f, 0.02150761f, 
    -0.04431373f, 0.03482004f, 0.02399644f, -0.06671757f, -0.00538597f, 0.04438998f, -0.06363607f, 0.03310835f, 
    -0.04296433f, -0.04920662f, 0.02275242f, -0.01187845f, -0.04083560f, 0.01413144f, 0.03240633f, -0.05022957f, 
    -0.06542887f, -0.03356816f, -0.05167535f, -0.04336514f, -0.04883825f, 0.00367536f, -0.03344714f, 0.01786912f, 
    0.03108200f, 0.03902983f, 0.04431327f, -0.02390572f, -0.03432320f, 0.01263767f, -0.03678361f, -0.02991214f, 
    -0.04315573f, 0.02614699f, -0.00336308f, 0.00105522f, -0.06317329f, 0.03745661f, 0.04565397f, -0.06968600f, 
    0.04071326f, -0.03509973f, -0.04902960f, -0.04293293f, -0.01555378f, -0.01240912f, -0.00299328f, 0.00830044f, 
    -0.05733603f, -0.06410220f, -0.04968050f, -0.03591748f, -0.02038516f, 0.03931758f, -0.01446852f, -0.00214189f, 
    -0.01362366f, -0.03405564f, -0.03989077f, -0.02929066f, -0.05858479f, 0.03448977f, -0.01752004f, -0.06550110f, 
    0.01823263f, -0.01769143f, -0.01472250f, 0.01956577f, -0.05366629f, 0.03786236f, 0.03469688f, -0.02042015f, 
    0.04938119f, 0.05496821f, -0.06364883f, -0.01620198f, -0.00448966f, 0.01632034f, 0.02047642f, 0.00703715f, 
    -0.04462062f, -0.05627539f, -0.01159000f, -0.01136532f, -0.05407273f, -0.05017268f, -0.02290930f, -0.05770425f, 
    -0.03028188f, 0.00820646f, -0.03677715f, -0.02221069f, -0.05673880f, 0.05257738f, -0.04672265f, -0.04614924f, 
    -0.05097480f, 0.02807884f, 0.05189298f, -0.00214639f, -0.00839749f, 0.03164205f, 0.03480205f, -0.04880044f, 
    -0.00749997f, 0.03621794f, -0.02944522f, 0.02485521f, -0.04716077f, 0.04548866f, -0.01703214f, 0.04508714f, 
    -0.02211578f, 0.00228050f, 0.02569580f, 0.01514171f, -0.01143277f, -0.05435005f, -0.05349665f, 0.01381533f, 
    -0.04810926f, 0.00606874f, -0.05862092f, -0.00446189f, 0.01048032f, -0.06293550f, 0.02374660f, -0.00524793f, 
    -0.00993299f, -0.05216045f, 0.00574042f, -0.05718895f, -0.04720898f, -0.01715872f, -0.05286588f, -0.05642545f, 
    -0.00421771f, -0.01718030f, -0.00081765f, -0.05685508f, 0.00522064f, -0.05838835f, -0.05822950f, 0.01552423f, 
    0.02787722f, 0.01550606f, 0.02612753f, 0.03881769f, 0.04177569f, 0.05226747f, -0.05183716f, -0.02711593f, 
    -0.05581994f, -0.06191057f, 0.00884246f, -0.05639074f, 0.01442201f, 0.01573885f, -0.03072801f, -0.04818455f, 
    0.02400685f, -0.04590138f, -0.06355838f, 0.01460640f, 0.03322065f, 0.04220038f, -0.04548971f, -0.05495217f, 
    -0.03843003f, -0.05832204f, -0.03302314f, -0.00256387f, -0.00442626f, -0.03366035f, -0.05326299f, 0.04822446f, 
    -0.05019959f, -0.00421653f, 0.01374153f, -0.05446527f, -0.00698987f, 0.04589517f, 0.02577347f, 0.02801543f, 
    -0.04269073f, 0.04203091f, -0.05372014f, -0.06051372f, -0.03737500f, -0.00593172f, 0.02229860f, 0.02560103f, 
    0.02258180f, 0.03949796f, 0.02468296f, 0.03702173f, -0.05157181f, -0.00293306f, 0.04068425f, -0.03758416f, 
    0.03782727f, 0.01759106f, 0.02905110f, 0.00229119f, 0.00775426f, -0.02778939f, -0.00014987f, -0.00392245f, 
    -0.02908284f, -0.05350457f, -0.01019084f, -0.00469861f, -0.06208207f, 0.00905755f, 0.00829847f, -0.05517622f, 
    0.04176547f, 0.00122058f, -0.04880700f, 0.02002558f, -0.00391957f, 0.05192184f, 0.04329330f, -0.05350215f, 
    -0.03726339f, 0.03812650f, -0.04412234f, -0.05230019f, 0.02175136f, 0.03804963f, -0.03525972f, -0.03429142f, 
    0.00708938f, 0.00397147f, -0.06413144f, -0.06046472f, -0.05388440f, -0.02265955f, -0.00123616f, -0.02174016f, 
    0.01609031f, -0.05589968f, -0.05745235f, -0.01894108f, -0.01090915f, -0.02045345f, -0.05260984f, -0.05956237f, 
    -0.02346216f, 0.04628224f, 0.04772190f, -0.02317904f, 0.04310817f, 0.03689178f, -0.05548391f, 0.02785598f, 
    -0.03096103f, -0.04425201f, -0.04832796f, -0.05816750f, -0.01947813f, -0.00113214f, 0.01824903f, 0.00325322f, 
    0.04832691f, -0.03512223f, -0.00550137f, -0.06339042f, 0.03824528f, -0.01540330f, -0.05531893f, 0.01357248f, 
    0.01659007f, 0.04979158f, 0.00957093f, -0.01131032f, -0.02783434f, 0.00034157f, 0.01888957f, -0.03854690f, 
    -0.04664556f, 0.02019041f, 0.05103634f, -0.01807532f, 0.00051849f, -0.03614139f, -0.01722877f, -0.02145581f, 
    -0.06152157f, -0.06063777f, -0.06444289f, -0.04190480f, -0.02190467f, -0.01707710f, -0.02400051f, -0.03703538f, 
    -0.05874918f, 0.04513893f, 0.02484067f, 0.00333074f, 0.01953618f, -0.05032883f, 0.03080351f, 0.05244552f, 
    0.01483383f, 0.04174437f, -0.06276238f, 0.04187553f, 0.00195709f, 0.00423357f, 0.03536769f, -0.03000603f, 
    -0.03202335f, 0.03890377f, -0.04947077f, -0.02003045f, 0.04318105f, 0.00519101f, 0.00741892f, -0.06245135f, 
    -0.00423939f, -0.05474832f, 0.00515358f, 0.05187937f, 0.00075144f, -0.00338285f, 0.00353674f, 0.03275239f, 
    0.03931986f, 0.03833954f, 0.01382606f, -0.01002727f, -0.04392304f, 0.03136044f, -0.06464630f, -0.05425484f, 
    -0.01089294f, 0.01866994f, 0.02325566f, 0.00046299f, 0.01763726f, 0.04923967f, 0.04768627f, -0.03315725f, 
    -0.01472142f, 0.01739392f, -0.05867676f, -0.05204687f, 0.00391023f, -0.04513910f, -0.05588792f, 0.00554295f, 
    0.05093142f, 0.05150934f, 0.02837557f, 0.01693742f, -0.04231979f, 0.04788146f, 0.00335807f, -0.03352012f, 
    -0.02996999f, 0.00340451f, -0.05055984f, -0.05847177f, -0.04728385f, -0.00525841f, -0.01755520f, 0.05106613f, 
    -0.03884733f, -0.00743012f, -0.00124372f, -0.04463360f, 0.03296156f, 0.03724504f, -0.02277111f, 0.04020817f, 
    0.04379705f, 0.03462128f, 0.04287265f, -0.00236825f, -0.02232282f, -0.01128488f, 0.01851767f, 0.04033027f, 
    0.00417997f, -0.00557844f, 0.00387503f, 0.00333466f, 0.01431526f, -0.03847806f, 0.03931277f, -0.00744637f, 
    0.00230746f, 0.01082798f, -0.00705614f, -0.00617388f, 0.00942476f, -0.01588419f, -0.00088596f, 0.00377713f, 
    -0.05973762f, -0.04380856f, 0.04300402f, -0.05478114f, -0.05061371f, 0.04550058f, 0.03264317f, -0.05481917f, 
    -0.00158194f, -0.01163912f, 0.03081396f, -0.03233283f, 0.01670748f, -0.02038897f, -0.01558609f, -0.04413125f, 
    -0.01216192f, -0.03230263f, 0.02956835f, 0.01546941f, -0.03863827f, 0.02456876f, -0.00729725f, 0.00285645f, 
    -0.01317034f, -0.01392059f, -0.00419629f, -0.02448507f, 0.04643797f, -0.03078116f, 0.02422158f, 0.03155302f, 
    -0.00263210f, 0.02299005f, -0.04135560f, -0.02427895f, -0.04451503f, -0.02153719f, -0.05632966f, 0.00279334f, 
    -0.02730731f, -0.05191678f, 0.01719991f, -0.06752086f, 0.04445175f, -0.01136851f, -0.04717124f, -0.05664649f, 
    -0.03985346f, -0.04961869f, -0.01314438f, 0.03237446f, -0.06755197f, -0.05474426f, 0.01958587f, -0.06721472f, 
    0.04284411f, 0.01221129f, -0.01627231f, 0.02669960f, -0.02780062f, -0.04840099f, 0.01773912f, -0.00782182f, 
    -0.05152478f, -0.01530641f, -0.00896410f, 0.01285978f, 0.01314070f, -0.02037924f, -0.04797535f, 0.03901507f, 
    -0.05903108f, -0.02849339f, -0.05282253f, 0.02264424f, -0.01751610f, -0.00058480f, -0.05612364f, 0.01393183f, 
    -0.00363425f, -0.04055908f, -0.03436703f, -0.05151286f, -0.04955006f, -0.01705651f, 0.04826748f, 0.03038982f, 
    0.05280272f, -0.02346096f, 0.00075753f, -0.02467817f, -0.06465361f, -0.03350473f, 0.03376159f, -0.01869475f, 
    0.00351527f, 0.04113673f, -0.06008608f, 0.03203285f, -0.04567790f, -0.02356555f, -0.00026618f, -0.01161717f, 
    0.04333492f, 0.00265130f, -0.04819825f, -0.02194069f, 0.00560638f, 0.04607873f, 0.03236677f, 0.02129702f, 
    -0.01574135f, -0.06034460f, 0.02860121f, 0.04435511f, -0.04997753f, 0.02280401f, 0.01389838f, 0.02113183f, 
    -0.00417457f, -0.00030139f, 0.03761837f, -0.06197688f, 0.02655215f, -0.02307981f, -0.02299245f, -0.02761206f, 
    -0.04610105f, 0.03678750f, -0.02256804f, 0.04791708f, -0.03213670f, -0.01834142f, 0.03306372f, 0.05071682f, 
    -0.01791569f, 0.05157683f, -0.02811255f, 0.00497736f, -0.00470160f, 0.05133377f, -0.05572338f, 0.04342203f, 
    0.00358110f, 0.00824920f, -0.02773244f, -0.02424468f, -0.06774849f, 0.03078201f, 0.04656993f, -0.04477238f, 
    -0.00369434f, -0.02287768f, -0.02177931f, 0.00107747f, 0.03323348f, -0.01179578f, 0.02181464f, 0.03747884f, 
    -0.02879711f, -0.04540440f, -0.00812159f, 0.02554580f, -0.05928462f, -0.03892589f, -0.05261048f, -0.02720123f, 
    -0.02100438f, -0.01224531f, 0.04629307f, -0.04322112f, 0.03489630f, 0.01427012f, 0.01834901f, -0.04567353f, 
    0.01760341f, 0.00736938f, 0.03939883f, -0.03225001f, -0.05591891f, 0.02118002f, 0.01035421f, -0.00377075f, 
    -0.05473546f, -0.00774509f, -0.01144644f, 0.03739866f, 0.00717879f, 0.02901974f, 0.00626562f, -0.02136417f, 
    0.01333451f, -0.06409433f, 0.02266692f, -0.05468936f, 0.01838469f, 0.04098012f, -0.04140558f, -0.05710557f, 
    0.02299801f, -0.02371603f, 0.02948707f, -0.02205085f, -0.05082339f, 0.04469824f, -0.00549280f, 0.01004925f, 
    0.01761479f, -0.03421658f, -0.00995604f, 0.03101481f, -0.01512318f, -0.02023856f, -0.02517176f, -0.03002895f, 
    0.01758298f, -0.04117370f, -0.05264525f, -0.03719608f, 0.03090443f, -0.00750313f, -0.02420614f, -0.01865663f, 
    0.00822012f, -0.00897059f, 0.01124657f, -0.01991588f, 0.03459686f, 0.04653205f, -0.04391900f, 0.03447962f, 
    -0.03313820f, -0.00040794f, -0.06371942f, 0.04129081f, 0.01331637f, -0.03292770f, 0.04037656f, -0.05752163f, 
    -0.00392850f, -0.01754244f, -0.04395844f, 0.00055274f, 0.04528971f, -0.02517920f, -0.03832533f, -0.01927127f, 
    -0.02469387f, -0.05850412f, -0.05816290f, 0.00129056f, -0.03592795f, 0.02361461f, 0.03144475f, 0.02723088f, 
    -0.07150970f, -0.00564295f, 0.01380590f, 0.04979409f, 0.04776736f, -0.04327274f, 0.03890334f, -0.01924266f, 
    0.02836676f, -0.01657414f, 0.01470374f, 0.03113135f, -0.03567025f, 0.03994540f, 0.00085003f, -0.04669524f, 
    0.05129328f, -0.01243547f, -0.04425094f, -0.00837182f, -0.03833508f, -0.02366133f, -0.05946527f, 0.01927054f, 
    0.04067217f, -0.05294296f, -0.01865229f, 0.01811012f, 0.02257444f, -0.05426714f, -0.05740989f, -0.01983338f, 
    -0.04413122f, 0.01638484f, -0.00573917f, 0.04504364f, -0.03778037f, 0.02715764f, -0.04672010f, -0.00602641f, 
    0.04091902f, -0.04832343f, -0.05724603f, 0.02630962f, -0.03441808f, -0.00612614f, -0.04390361f, -0.05262614f, 
    -0.00465476f, 0.02486312f, -0.05586522f, -0.04653627f, -0.01607074f, 0.00181387f, 0.02119463f, 0.00827829f, 
    0.05382855f, 0.03014508f, 0.02718556f, 0.00276457f, 0.04313247f, 0.00710857f, -0.03540562f, -0.01270303f, 
    0.03390308f, 0.03522263f, 0.01541889f, -0.02640275f, -0.04202607f, 0.02254638f, -0.02813281f, -0.04413799f, 
    0.01825172f, -0.01063097f, 0.04526082f, -0.05223110f, 0.01810754f, -0.03227970f, -0.00619748f, 0.00123218f, 
    0.01450831f, 0.04214801f, -0.01885837f, 0.05344370f, 0.01375938f, -0.05350858f, -0.06137798f, -0.05303699f, 
    -0.02891957f, -0.06881934f, 0.04720694f, -0.05569317f, -0.02480267f, 0.03304688f, -0.06132827f, -0.03076246f, 
    0.03865034f, -0.05323252f, -0.02537510f, -0.03936107f, -0.02679795f, -0.04195751f, -0.00931052f, -0.01761807f, 
    -0.03642403f, -0.01031882f, -0.00647904f, -0.03084147f, 0.00161217f, 0.04303228f, 0.01291799f, -0.02003836f, 
    0.04115097f, -0.05678056f, 0.01585540f, 0.01594030f, -0.06521942f, -0.06593749f, 0.00859484f, 0.03778535f, 
    0.02315951f, 0.01821036f, -0.06078348f, -0.04518678f, -0.06590982f, -0.00381202f, 0.03862350f, -0.03789286f, 
    0.04178878f, 0.01475327f, -0.00474362f, 0.04336677f, -0.02833947f, 0.02597579f, -0.00151256f, 0.02855857f, 
    -0.05015427f, -0.01593596f, 0.04024776f, -0.04552358f, -0.03534464f, -0.00782359f, -0.02824677f, 0.02758962f, 
    -0.02753545f, 0.02372779f, -0.03700106f, -0.02123366f, 0.03651156f, -0.05200160f, -0.06044869f, 0.00687093f, 
    -0.04005806f, 0.04174471f, -0.03998423f, -0.02609505f, -0.04933059f, 0.01876200f, 0.04341359f, 0.04016837f, 
    0.00837065f, -0.05879894f, -0.00138558f, 0.05239829f, -0.01099219f, -0.03560390f, 0.02635509f, -0.07297404f, 
    -0.04298539f, 0.04823150f, -0.00412575f, -0.06534787f, 0.00152157f, 0.04619533f, -0.01054778f, -0.03442739f, 
    -0.04764138f, 0.02164461f, -0.01658325f, 0.00554910f, -0.05107907f, -0.05510097f, -0.03404842f, 0.02347951f, 
    -0.00992341f, -0.03664704f, -0.03105757f, -0.06218127f, -0.01196193f, -0.03387901f, 0.01899133f, -0.00257742f, 
    0.02264282f, 0.00492954f, -0.01393277f, -0.01125547f, -0.05510555f, 0.00770522f, 0.02990000f, -0.01473452f, 
    0.02961090f, 0.01983420f, -0.05331216f, -0.01337067f, -0.01124075f, 0.03682409f, 0.03951297f, 0.01125717f, 
    0.00709513f, -0.04578467f, -0.05484733f, 0.04519201f, 0.01752308f, -0.01861265f, 0.03032890f, -0.03015643f, 
    0.04333236f, 0.05690674f, 0.01074985f, -0.03269312f, -0.00742598f, -0.03838275f, 0.01055930f, 0.04418107f, 
    -0.00265847f, -0.03812850f, 0.03857699f, 0.03877394f, 0.00184515f, -0.00825895f, -0.04173350f, 0.01693547f, 
    -0.06817681f, 0.02549079f, -0.06398388f, -0.03414290f, 0.00930799f, -0.01813743f, 0.02974438f, -0.04674905f, 
    -0.04818204f, 0.03356434f, -0.05424439f, -0.02886302f, 0.00731529f, 0.00637720f, -0.00484546f, -0.00388006f, 
    -0.01131640f, -0.00633299f, 0.03607734f, -0.05874369f, 0.01178538f, -0.03935230f, 0.05379330f, 0.01222893f, 
    -0.04392985f, -0.03155084f, -0.03424311f, -0.02156827f, -0.02109327f, -0.00821842f, -0.04854622f, -0.05896089f, 
    -0.00472736f, -0.03659537f, -0.06506381f, 0.02287388f, -0.05602751f, 0.02180236f, 0.04837405f, -0.03254731f, 
    0.01747620f, -0.03282052f, 0.04150904f, 0.04536227f, -0.05000263f, 0.03257724f, -0.05918450f, 0.02193205f, 
    0.04501445f, -0.00559433f, -0.01242860f, 0.03875503f, -0.04101020f, -0.05529566f, 0.04139822f, 0.01598892f, 
    0.02816475f, -0.05671689f, -0.04380343f, -0.06412407f, 0.02955333f, 0.03575489f, -0.04825782f, -0.06269186f, 
    0.02637541f, 0.04746096f, 0.00894306f, 0.02804990f, -0.01904462f, 0.02289317f, 0.01378966f, -0.03331800f, 
    -0.04925768f, 0.01732379f, -0.02415761f, -0.03762749f, 0.02456801f, 0.02055294f, -0.00473720f, 0.02389888f, 
    -0.01900441f, -0.00971891f, 0.04475865f, -0.01319684f, -0.02260325f, -0.03174587f, 0.00822187f, 0.01707686f, 
    -0.04226023f, -0.04207257f, 0.01118666f, 0.01724711f, 0.03984960f, -0.05709837f, 0.00133087f, -0.05678890f, 
    -0.03975232f, -0.05493198f, -0.03951016f, 0.00801425f, 0.02140667f, -0.03964512f, -0.06053384f, 0.02438394f, 
    -0.04822765f, 0.03386797f, -0.06250739f, -0.04226476f, -0.06127312f, 0.02604941f, -0.00186247f, 0.01729492f, 
    -0.03953211f, -0.02255621f, -0.05777910f, 0.02472485f, 0.00941162f, -0.04793123f, -0.02902556f, -0.05860142f, 
    -0.02304127f, 0.03976753f, -0.03980464f, -0.02062616f, -0.02300201f, 0.02282835f, -0.03327858f, -0.00484011f, 
    -0.05295280f, 0.01092536f, 0.03547530f, -0.05345755f, 0.00993950f, -0.05862588f, -0.02129316f, -0.03207367f, 
    -0.02812335f, 0.04877104f, -0.03786162f, -0.01251855f, 0.03575392f, -0.01579130f, 0.00796279f, -0.01632803f, 
    0.02351234f, 0.03003186f, -0.01919373f, 0.04804833f, -0.04282785f, 0.01342914f, -0.01410758f, 0.05204440f, 
    0.02361012f, -0.04750576f, 0.03689629f, -0.00244929f, -0.00754514f, -0.00544458f, -0.03794005f, 0.02851797f, 
    -0.00159482f, 0.05327045f, -0.00103591f, -0.05808071f, 0.01371156f, 0.02415324f, -0.04764164f, -0.02427872f, 
    -0.00028227f, -0.00748428f, -0.02367726f, -0.04468774f, -0.05815595f, -0.03462412f, 0.04700101f, 0.04838616f, 
    -0.02619685f, -0.03873981f, -0.03311066f, -0.05433552f, -0.03405578f, 0.00583101f, -0.00459089f, -0.02682856f, 
    -0.01176504f, -0.01020003f, -0.02510720f, 0.00257133f, 0.02448790f, 0.03823492f, -0.01206649f, -0.02620764f, 
    -0.05018622f, -0.04739860f, 0.03240432f, -0.06105316f, 0.01658800f, -0.03209372f, 0.03277541f, -0.05088503f, 
    0.03797525f, -0.03838195f, -0.06118428f, 0.03083349f, -0.00426806f, 0.00869082f, -0.01040909f, 0.05113881f, 
    -0.04110258f, 0.02387701f, -0.00463126f, -0.02868390f, -0.01166005f, 0.05360226f, -0.03038935f, -0.03061244f, 
    -0.04284538f, 0.03915755f, -0.04228670f, 0.01773697f, -0.06297158f, -0.02660064f, -0.05882980f, -0.01710183f, 
    0.02046306f, -0.03268577f, -0.05186522f, -0.00731646f, 0.00356301f, -0.05537596f, -0.05092980f, -0.01500530f, 
    0.04798634f, -0.01669967f, -0.03732568f, 0.01084124f, -0.01711446f, -0.00289713f, -0.05895339f, -0.01799226f, 
    -0.03705804f, 0.03420822f, -0.03591356f, 0.03317157f, -0.06473851f, 0.03662056f, 0.01402573f, 0.04993549f, 
    -0.02520395f, 0.03019895f, -0.00500963f, -0.05936055f, -0.05424968f, -0.00727180f, -0.05439961f, -0.05650283f, 
    0.03965728f, -0.01581036f, 0.01705755f, 0.05070902f, 0.02893727f, -0.01555292f, -0.00767810f, 0.04573530f, 
    -0.05587521f, 0.00625938f, -0.01346906f, -0.05295752f, -0.03137950f, -0.06024454f, -0.02153379f, 0.04372052f, 
    0.02532819f, 0.00398521f, -0.05214968f, -0.02924314f, -0.05418587f, -0.01724848f, -0.03542016f, 0.04937750f, 
    -0.02267757f, -0.00721953f, 0.01311238f, -0.00063406f, -0.05306397f, 0.00303700f, 0.04141406f, -0.01236801f, 
    -0.02139282f, 0.01260431f, -0.05882457f, -0.04512201f, 0.02700988f, -0.02176854f, 0.02553151f, -0.01558984f, 
    0.00657001f, -0.04033960f, 0.03817770f, -0.05764863f, 0.01627938f, -0.00909112f, -0.02271616f, -0.04269116f, 
    -0.00904503f, 0.04994261f, -0.05006711f, -0.03085767f, 0.03087250f, 0.02381373f, -0.00350194f, -0.05232372f, 
    0.04862058f, 0.02217389f, 0.03393262f, -0.01880086f, -0.00706415f, -0.06356792f, 0.05201051f, -0.02729690f, 
    -0.01291669f, -0.03448910f, 0.03356756f, 0.03257611f, 0.03491358f, -0.04454800f, -0.00367077f, -0.00712727f, 
    0.04877796f, -0.03555007f, -0.02481855f, -0.02287819f, -0.05636248f, -0.00201187f, 0.02598655f, -0.05143360f, 
    0.04600319f, -0.05463181f, -0.04359701f, 0.01497667f, -0.01143712f, -0.01143860f, -0.04768129f, 0.03400372f, 
    0.31707042f, 0.01682714f, -0.04133316f, -0.06015155f, 0.18695842f, 0.07996343f, -0.03698358f, -0.20115794f, 
    -0.23333636f, 0.32213104f, -0.27170008f, -0.57332307f, -0.10468595f, -0.03163636f, -0.12969203f, 0.06910744f, 
    -0.13413949f, 0.23351115f, -0.40917334f, 0.32934019f, -0.51509231f, -0.17733154f, -0.29916561f, 0.04430565f, 
    0.03698857f, 0.10424439f, 0.28966677f, 0.38927895f, 0.35766092f, 0.44837883f, -0.15155031f, -0.25663203f, 
    0.09472340f, -0.26851290f, -0.20211345f, 0.19030371f, -0.07173571f, -0.13591185f, 0.02061682f, -0.17630182f, 
    0.09568745f, -0.00358584f, 0.04871451f, 0.09203367f, -0.00251895f, 0.30558667f, 0.42657167f, 0.70626032f, 
    0.04532552f, -0.07792500f, 0.06917582f, 0.26590621f, -0.05678185f, -0.11701362f, 0.05507912f, -0.68305892f, 
    -0.65727443f, -0.08205649f, -0.01680380f, 0.00438958f, 0.02444139f, 0.19325799f, -0.00447810f, 0.07369412f, 
    -0.19699273f, 0.35970867f, 0.05135456f, -0.07708152f, 0.13696083f, 0.06675906f, 0.11265331f, -0.04438069f, 
    0.56261843f, -0.12041072f, 0.25840485f, 0.14920589f, -0.08363245f, 0.07759300f, 0.15224740f, 0.00140337f, 
    -0.08216359f, 0.01068637f, -0.24441212f, -0.41794893f, 0.07162505f, -0.06020746f, 0.19561611f, 0.17498776f, 
    0.10507374f, 0.15732808f, -0.55831277f, -0.75761604f, -0.04149677f, -0.05250194f, -0.19998880f, -0.10881949f, 
    0.02712175f, -0.09989350f, 0.13918018f, 0.34972212f, -0.54627222f, -0.04243976f, -0.40523142f, 0.24654871f, 
    0.17226787f, 0.20929214f, -0.12260895f, -0.04659282f, 0.09836626f, -0.10175214f, -0.23100117f, 0.21817665f, 
    0.09214921f, -0.16460326f, 0.09594606f, -0.11664259f, 0.06233194f, 0.09483039f, 0.19532900f, 0.12083151f, 
    0.22694342f, -0.02378321f, 0.19477145f, 0.07511988f, 0.01664907f, -0.12097648f, -0.82484132f, -0.50071067f, 
    -0.28443077f, -0.08869189f, -0.12943256f, 0.22880237f, 0.29592440f, 0.26363152f, -0.18467826f, 0.20563279f, 
    -0.14037700f, 0.06769869f, -0.11830431f, -0.13623680f, -0.07773758f, 0.04557797f, 0.06598794f, -0.02572332f, 
    0.10717423f, 0.04685432f, 0.05601973f, -0.14934622f, 0.08390436f, 0.04839625f, 0.23655728f, -0.03445108f, 
    0.41318467f, 0.26979017f, 0.10815337f, 0.24206893f, -0.05351883f, 0.02711772f, 0.13581972f, 0.09167842f, 
    -0.20123796f, 0.03127300f, -0.12249939f, -0.59902948f, -0.34407189f, -0.02922933f, -0.16499725f, -0.04899945f, 
    0.08668877f, 0.15094665f, -0.04799695f, -0.27504560f, -0.22809295f, -0.67385405f, -0.14758235f, 0.16933987f, 
    -0.23237441f, 0.03607449f, -0.28845584f, 0.02418773f, 0.29640990f, 0.02858124f, -0.63076645f, 0.07404480f, 
    -0.03138377f, -0.01244648f, 0.19165920f, 0.13870485f, 0.00917476f, 0.17172000f, 0.22490898f, 0.45005438f, 
    -0.18850756f, -0.14143892f, -0.11329482f, -0.13080765f, 0.10706088f, 0.00259485f, 0.17406575f, -0.08094060f, 
    0.11787939f, 0.20156409f, 0.10250495f, 0.27400073f, 0.14907363f, -0.02660099f, 0.35888913f, 0.20395878f, 
    -0.07401757f, -0.39797732f, 0.07441651f, 0.27384263f, 0.15591913f, 0.08110615f, -0.02928380f, -0.06362517f, 
    -0.43394211f, -0.04805507f, -1.18471205f, -0.13886267f, -0.27310172f, 0.10208443f, 0.07421181f, 0.03911294f, 
    0.22709420f, 0.04275282f, -0.53530198f, -0.48890084f, 0.06013483f, 0.23289032f, 0.28484005f, 0.00303693f, 
    0.02141527f, 0.08998603f, 0.66831136f, -0.48031843f, -0.43452665f, -0.14204806f, 0.31634578f, 0.11678986f, 
    0.16489120f, -0.09661024f, 0.11596710f, 0.01523515f, -0.00580103f, 0.11651588f, 0.15422928f, 0.06090141f, 
    0.22794203f, -0.09500945f, -0.18997066f, 0.21636784f, 0.21915066f, 0.28131816f, 0.19049431f, -0.26950428f, 
    -0.01828531f, 0.08606172f, 0.11590672f, -0.14599256f, 0.01650294f, -0.42670888f, -0.56406772f, -0.43547881f, 
    -0.17631929f, -0.25541264f, 0.01180810f, 0.06818873f, 0.36048019f, 0.42320821f, -0.21986620f, -0.42456076f, 
    0.06306703f, 0.28906918f, 0.05735603f, -0.15379919f, 0.06297755f, -0.10291582f, -0.02879307f, 0.16931878f, 
    0.17309757f, 0.20051406f, 0.26099211f, -0.12158905f, 0.02802206f, 0.03354000f, -0.14415015f, 0.05205115f, 
    0.00082663f, 0.18247764f, 0.22324559f, -0.16407916f, -0.13225029f, 0.34850305f, -0.02180676f, -0.03288893f, 
    0.04885011f, 0.15454552f, -0.29663637f, -0.01205572f, 0.01349348f, -0.09992175f, -0.11966095f, -0.27804226f, 
    0.03548505f, 0.19134282f, 0.50123668f, -0.22260988f, 0.17931014f, -0.30173129f, -0.15338281f, 0.37727579f, 
    -0.13790092f, -0.02747929f, 0.19353041f, -0.25999445f, 0.16036689f, -0.08220936f, -0.15045911f, 0.13185911f, 
    -0.06075571f, -0.20073092f, -0.02345112f, -0.02041128f, -0.64387125f, 0.10101595f, 0.26997873f, 0.17499451f, 
    0.07829287f, -0.14678007f, -0.15390062f, -0.24210639f, 0.02330679f, -0.22131589f, 0.37682137f, 0.20145895f, 
    -0.05158731f, 0.01398559f, -0.20128471f, 0.05971203f, 0.17110768f, 0.10303827f, 0.09564631f, 0.11135841f, 
    -0.06896826f, 0.08164683f, 0.11747832f, -0.07739199f, 0.06316810f, 0.13469231f, 0.08469374f, -0.10401998f, 
    -0.32622185f, 0.14958151f, 0.05030554f, 0.15038061f, 0.07668608f, -0.12861998f, 0.10418533f, 0.12831262f, 
    -0.60865802f, -0.19290623f, 0.19047947f, 0.19630207f, 0.06919384f, -0.00672581f, 0.13316156f, 0.00611505f, 
    0.10130093f, 0.01325049f, 0.02990271f, 0.15869141f, 0.06516472f, -0.07186431f, -0.02461672f, 0.11035292f, 
    0.15722805f, 0.11883942f, -0.65630293f, 0.19644612f, 0.11707960f, 0.04666039f, -0.22363268f, -0.13344164f, 
    -0.20644526f, -0.00794372f, -0.08654591f, 0.51936752f, 0.03998233f, -0.22552940f, -0.33891687f, -0.42277354f, 
    -0.01267935f, 0.02790179f, -0.01369607f, 0.02006427f, 0.35338086f, -0.10148464f, 0.13362716f, -0.01465740f, 
    0.07112379f, -0.18450987f, 0.00377277f, 0.13131669f, 0.19037180f, -0.16343942f, -0.22317140f, -0.00156609f, 
    0.09166271f, 0.00961514f, 0.30255803f, -0.11081183f, 0.02988954f, -0.00762022f, -1.12411726f, -0.26528251f, 
    0.38872364f, -0.00842586f, 0.03517209f, -0.27631968f, 0.02635266f, 0.13603717f, -0.11289372f, 0.14318295f, 
    0.05912508f, -0.23873675f, 0.01770591f, -0.05265579f, -0.16012865f, 0.00850505f, 0.20697288f, 0.00550596f, 
    0.07416963f, 0.02366922f, 0.05449469f, -0.00776234f, 0.10115376f, 0.02546567f, 0.27177942f, 0.08816513f, 
    -0.08078333f, -0.04666896f, 0.21189132f, 0.20420815f, -0.20699893f, 0.10270924f, -0.26341945f, 0.07267650f, 
    0.15435155f, -0.15423161f, -0.41708213f, 0.21619985f, -0.11495136f, 0.08622657f, 0.09851278f, -0.10246863f, 
    -0.02029925f, -0.01129059f, -0.12963162f, 0.62516367f, -0.31376725f, 0.27089077f, -0.19084345f, -0.01285718f, 
    0.38926572f, -0.29543820f, 0.00071490f, -0.15282133f, 0.22256784f, -0.23874247f, 0.09858738f, 0.09348521f, 
    0.16114868f, 0.25912267f, -0.14011018f, 0.08057445f, 0.08606365f, -0.46296677f, 0.02052222f, 0.09416050f, 
    0.16575098f, 0.14713129f, 0.08559249f, 0.12240767f, 0.20030798f, 0.12335657f, -0.10925315f, -0.04552003f, 
    -0.29427597f, 0.17554268f, -0.01614205f, 0.10016190f, 0.07925434f, 0.00783335f, -0.01105333f, -0.11201814f, 
    0.18691185f, 0.21483128f, -0.03016171f, -0.03139805f, -0.20243295f, 0.03840715f, -0.04459810f, -0.15849027f, 
    -0.21897873f, 0.03303707f, -0.47562006f, 0.01418225f, -0.14891937f, 0.05209402f, -0.12586465f, -0.19564237f, 
    0.07262261f, 0.05003934f, 0.19647563f, -0.05961518f, -0.04646514f, 0.03852693f, -0.14719555f, -0.02106392f, 
    0.04137466f, -0.02021994f, 0.36992359f, 0.02054029f, 0.22475664f, -0.24420308f, 0.20346646f, 0.23765044f, 
    -0.01652342f, -0.09286420f, 0.08688820f, -0.13835567f, -0.13503778f, -0.28358945f, 0.02563141f, 0.15250017f, 
    -0.07599726f, -0.00488917f, -0.00359027f, -0.01574347f, 0.45778257f, 0.20228219f, 0.14176442f, -0.00433887f, 
    -0.03769301f, 0.26078847f, 0.15445517f, 0.09894176f, -0.16042803f, -0.18823168f, 0.07233829f, -0.06214757f, 
    -0.06970511f, -0.15517436f, -0.22062926f, -0.00208477f, -0.06264461f, 0.07737061f, 0.13995665f, 0.12601197f, 
    0.24902698f, -0.10202488f, 0.11471293f, -0.11129745f, 0.01970110f, 0.19462441f, 0.16300744f, 0.09252121f, 
    -0.09981161f, -0.35596755f, -0.04161232f, -0.04381965f, -0.11219959f, 0.04563498f, 0.08902622f, 0.03335524f, 
    0.30352592f, 0.00543224f, 0.08457799f, 0.13140911f, 0.13154757f, -0.03232314f, 0.23335806f, 0.39596242f, 
    0.44547182f, -0.08680289f, -0.10155677f, 0.02476129f, -0.20117612f, -0.23478986f, -0.06911960f, -0.16854095f, 
    -0.13807885f, -0.04506314f, 0.29517272f, -0.01686560f, -0.26018584f, 0.07663939f, -0.04075845f, 0.06549392f, 
    -0.05288600f, 0.34460059f, 0.09190139f, -0.61146086f, -0.86385971f, 0.11331972f, -0.26334858f, -0.36896390f, 
    -0.29069719f, 0.06061751f, 0.08312457f, 0.43962616f, 0.04793369f, 0.07444871f, 0.07609907f, 0.08725198f, 
    0.15840083f, 0.06902166f, -0.04393628f, -0.19429354f, -0.20204625f, -0.63221318f, -0.59645146f, -0.05800205f, 
    0.01744924f, 0.02648267f, -0.09268544f, 0.02303071f, 0.03413806f, 0.29200533f, -0.04259362f, -0.42541802f, 
    -0.26317692f, -0.19848140f, 0.03708265f, 0.17686865f, 0.05370982f, -0.00220640f, 0.13762540f, -0.34174138f, 
    0.19162168f, 0.34544897f, 0.10941705f, 0.17091925f, 0.04312021f, 0.11826711f, 0.05902527f, 0.26576808f, 
    -0.29213253f, -0.23497950f, -0.13155895f, 0.02226795f, 0.06444218f, -0.03707875f, -0.11182561f, 0.04750726f, 
    -0.27964517f, -0.05964360f, -0.18377842f, -0.04908730f, -0.55797464f, -0.57011080f, -0.19346254f, 0.03488035f, 
    -0.09295417f, 0.06415556f, 0.21795265f, -0.18306364f, -0.47997463f, 0.03768023f, -0.05043381f, -0.07184560f, 
    0.12627235f, 0.13437018f, 0.20209703f, -0.59177458f, -0.34395868f, 0.09160638f, -0.19720072f, 0.09196039f, 
    -0.21371149f, 0.06855186f, -0.13648680f, 0.13948736f, -0.45412678f, -0.46757436f, 0.09929024f, 0.01669815f, 
    -0.06252498f, -0.12518948f, 0.00251667f, 0.12444708f, 0.07978527f, -0.03129617f, 0.12619150f, -0.08759598f, 
    0.21663082f, 0.19905762f, 0.12275979f, 0.10428987f, 0.14652258f, 0.08176683f, 0.02664506f, 0.02010387f, 
    0.29099599f, 0.04440907f, -0.14495693f, -0.27583709f, 0.05849940f, 0.21633653f, 0.02906559f, -0.43596327f, 
    0.12085376f, 0.26623037f, -0.01792217f, -0.11672095f, 0.04051820f, 0.09058207f, -0.08700184f, 0.10080063f, 
    -0.25569206f, -0.05966738f, -0.25281569f, -0.17218782f, 0.21637383f, 0.02719033f, 0.06919632f, 0.15022670f, 
    0.09522785f, -0.43203223f, -0.22037984f, 0.14968388f, -0.09513853f, -0.08486551f, -0.09018622f, -0.01695936f, 
    0.00882129f, 0.02964674f, 0.31949851f, -0.03952257f, -0.00777904f, -0.05963381f, 0.05480406f, 0.00096209f, 
    0.11819538f, 0.25604117f, 0.22388282f, 0.28153980f, 0.15890516f, 0.05215786f, 0.23524071f, 0.27684814f, 
    0.15480290f, -0.05042502f, -0.05079827f, 0.14756846f, 0.16300249f, 0.03709521f, -0.06271688f, 0.09880133f, 
    0.03830385f, -0.14653711f, 0.04972999f, 0.01239689f, 0.22178467f, -0.17644942f, -0.43017408f, 0.07929548f, 
    0.22246516f, 0.03397042f, -0.06746659f, 0.25899419f, 0.12597483f, 0.27551225f, -0.47687680f, 0.07579822f, 
    -0.29090762f, -0.02422752f, 0.19887058f, 0.12963507f, -0.06898124f, -0.01121217f, -0.02782853f, 0.00708685f, 
    -0.00782823f, -0.05633786f, -0.28934237f, -0.31118053f, -0.36426103f, 0.03265619f, -0.28082770f, 0.08966672f, 
    -0.13838957f, -0.28385076f, -0.07764377f, 0.12499923f, -0.05943116f, 0.16309069f, -0.00695673f, 0.10842905f, 
    -0.11245311f, 0.01894681f, -0.07587185f, -0.03862412f, -0.36945310f, -0.31034979f, 0.05020520f, -0.00494148f, 
    -0.17522590f, -0.00320546f, 0.16583352f, 0.13858931f, -0.12294355f, 0.04904537f, 0.00652748f, 0.11612983f, 
    0.12142607f, -0.29089689f, 0.03808395f, -0.23186760f, 0.35631669f, 0.28293827f, 0.03219352f, 0.19887343f, 
    0.10632664f, 0.09678148f, 0.11885461f, 0.17259724f, 0.11025246f, -0.13800924f, 0.29760242f, 0.27725968f, 
    0.13308498f, 0.31959209f, 0.35811320f, 0.18513095f, 0.47651401f, -0.06491108f, -0.08405977f, -0.28679135f, 
    -0.06134972f, -0.11189442f, 0.14972234f, -0.04509950f, 0.01089615f, 0.18645824f, -0.14739403f, -0.13683072f, 
    0.10088794f, -0.00953302f, -0.02695851f, -0.12724300f, -0.06465311f, 0.26098070f, 0.16836156f, -0.59450603f, 
    -0.51042342f, -0.13727827f, -0.14775752f, -0.05824561f, -0.13172941f, 0.00954548f, -0.07434979f, -0.18070684f, 
    0.28005239f, -0.06177067f, -0.21510585f, 0.14653178f, -0.05372188f, -0.30745545f, -0.03416262f, -0.01037660f, 
    -0.12617691f, -0.27306595f, 0.39451742f, -0.10944704f, 0.17726506f, 0.17178807f, 0.17175040f, 0.01004209f, 
    0.01831820f, 0.26203302f, -0.27014744f, -0.03237509f, -0.10753760f, 0.25823444f, 0.04014841f, 0.05287779f, 
    0.25142604f, -0.09582177f, -0.11133677f, 0.25660673f, 0.03283714f, 0.08679909f, 0.07597109f, 0.21253020f, 
    -0.20529358f, -0.28923145f, -0.20232585f, -0.66572714f, 0.01672502f, 0.01820117f, 0.20997471f, 0.04589757f, 
    0.04427185f, 0.01014420f, -0.17014399f, 0.16762748f, -0.07589311f, 0.05205680f, -0.02002261f, 0.13488816f, 
    0.27080849f, 0.15685724f, 0.15417813f, -0.04883625f, 0.00439546f, -0.11620132f, 0.05187901f, 0.02118914f, 
    -0.06354259f, 0.07395082f, -0.07454239f, 0.07114723f, -0.10057105f, -0.02494795f, -0.15889890f, -0.32630244f, 
    -0.16558909f, 0.09077343f, 0.18808439f, 0.02396967f, -0.00917184f, 0.26480064f, -0.32897177f, 0.09419578f, 
    -0.36822188f, -0.04455538f, 0.08553065f, -0.19088988f, -0.09715027f, -0.20661017f, -0.00975502f, 0.03294560f, 
    0.20632452f, 0.22963358f, 0.04004900f, -0.02233998f, 0.21265462f, 0.12985955f, 0.12612149f, -0.09986902f, 
    -0.05559056f, -0.45674974f, 0.08570106f, 0.00205599f, -0.12926219f, 0.15940586f, 0.01355444f, 0.12608388f, 
    0.03706485f, -0.06187358f, 0.21146238f, 0.12811671f, -0.08261571f, 0.04867114f, -0.07617997f, 0.12673767f, 
    -0.08949541f, 0.18924186f, -0.04505333f, 0.00810309f, 0.20848694f, -0.34407926f, -0.27087149f, 0.03656613f, 
    0.08214544f, 0.23782042f, 0.10507481f, 0.06790985f, -0.00215126f, -0.02128965f, 0.09788985f, -0.05490779f, 
    0.08858559f, 0.04698032f, 0.16607486f, -0.01378966f, 0.11761477f, -0.07267386f, 0.20410451f, -0.68924028f, 
    -0.18770951f, 0.03280363f, 0.02246198f, 0.03980489f, 0.16538526f, 0.03163776f, -0.16302961f, -0.21315834f, 
    -0.22785033f, 0.05435707f, 0.05165534f, 0.21053877f, -0.02299065f, 0.01104262f, 0.16919324f, 0.25196293f, 
    0.11585451f, 0.03944504f, 0.09506413f, 0.03081437f, 0.12026124f, -0.00823916f, -0.18288030f, -0.17815827f, 
    -0.16221079f, -0.41551334f, -0.34110638f, 0.31777725f, 0.12797326f, 0.08025907f, -0.11478970f, -0.07851364f, 
    0.10767204f, 0.17379801f, -0.04870895f, -0.23166077f, -0.27121669f, 0.01889658f, -0.20857827f, -0.18410738f, 
    0.03371220f, 0.03738440f, -0.15205216f, -0.39629155f, 0.13554394f, -0.18719257f, 0.03203778f, 0.05783721f, 
    0.17787217f, 0.02500767f, -0.17275609f, 0.50456131f, 0.45668125f, 0.14623275f, -0.08811034f, 0.07689796f, 
    0.00069075f, 0.09111515f, 0.24996650f, -0.22413877f, -0.22885449f, 0.03019051f, 0.00488020f, 0.06432990f, 
    0.10121565f, -0.22474894f, -0.19610934f, -0.23911935f, -0.35918406f, -0.30164805f, -0.41660404f, -0.11279556f, 
    -0.00653827f, 0.29729098f, -0.04978096f, 0.35564926f, 0.05790956f, -0.04632186f, 0.03709247f, 0.05174128f, 
    -0.03274250f, -0.30997190f, 0.08176959f, 0.15151568f, 0.02381301f, 0.11864229f, 0.01962730f, -0.02315708f, 
    -0.11556802f, 0.11661164f, -0.08580668f, 0.16961373f, 0.01508880f, 0.18463711f, -0.09061976f, -0.34620118f, 
    0.42471966f, 0.07392474f, -0.05069427f, -0.17693894f, 0.00394380f, 0.12764584f, 0.03366620f, 0.07735362f, 
    0.08292471f, -0.25738436f, 0.20704575f, 0.23073357f, -0.05094976f, 0.13239209f, -0.07383984f, -0.04559587f, 
    0.12642610f, 0.08951577f, 0.19482307f, -0.20766456f, -0.28001907f, 0.08227386f, 0.08355943f, -0.07646603f, 
    -0.12134010f, 0.18194322f, 0.03973318f, -0.13982333f, -0.03058404f, 0.20414767f, 0.02368230f, -0.14034443f, 
    0.31315410f, -0.27634928f, -0.04680098f, -0.12695435f, -0.13975345f, 0.00927418f, 0.10579104f, 0.04364884f, 
    0.13363566f, 0.13744870f, 0.13232958f, 0.02324638f, -0.21623652f, -0.16304602f, 0.06508435f, -0.05607183f, 
    -0.30401188f, 0.02931850f, 0.00665159f, 0.23553078f, 0.03900687f, 0.04009639f, -0.09694287f, 0.48511863f, 
    0.31998223f, 0.46986657f, 0.19760124f, -0.13251588f, -0.08422518f, 0.04765150f, 0.09221981f, 0.07849221f, 
    -0.13637935f, 0.22364858f, -0.30935669f, 0.06868413f, 0.16387767f, 0.00699859f, -0.02935348f, 0.11199082f, 
    -0.05558207f, 0.08148837f, -0.06899776f, 0.36020330f, 0.07128786f, -0.17173044f, -0.07201208f, -0.06829397f, 
    -0.01739618f, 0.11896046f, 0.17682463f, 0.18605632f, -0.15581636f, -0.07762706f, -0.02533423f, 0.28389186f, 
    -0.08187636f, -0.11473756f, 0.18152905f, 0.11034520f, 0.02059566f, -0.08467235f, 0.04574786f, -0.02504233f, 
    -0.14438069f, -0.15546234f, 0.13066587f, 0.01461025f, 0.24368565f, 0.36389804f, -0.11000931f, 0.11316921f, 
    -0.26703161f, -0.15980777f, 0.13108739f, 0.14264189f, -0.17467567f, 0.04818987f, -0.06762706f, -0.03961058f, 
    -0.13642308f, 0.02040621f, 0.08381165f, 0.10666485f, 0.13213505f, -0.30731547f, -0.16013947f, -0.05798877f, 
    0.22568662f, -0.16127348f, -0.04813747f, -0.04299144f, 0.05999624f, -0.01724897f, 0.20981026f, 0.03402701f, 
    -0.37452993f, -0.22799747f, 0.01590676f, 0.04371444f, 0.26936594f, -0.01368260f, 0.07982486f, 0.19261777f, 
    0.16834468f, 0.19920173f, 0.02710905f, 0.02142922f, -0.05201616f, 0.04916115f, 0.36607513f, 0.01426233f, 
    -0.29646662f, -0.10959809f, -0.53280413f, -0.28025112f, -0.14288275f, -0.04313358f, -0.22703971f, 0.16313630f, 
    0.07460527f, -0.14175831f, -0.08769995f, -0.36407971f, -0.37043634f, 0.19700055f, 0.28469035f, -0.30197021f, 
    -0.10026100f, -0.01560033f, 0.14025733f, -0.58399677f, -0.35342932f, 0.16648026f, -0.10661017f, -0.26427439f, 
    -0.07026284f, -0.04731081f, 0.16535941f, -0.06172034f, -0.57647932f, -0.52654701f, 0.50903481f, -0.36212975f, 
    -0.12832475f, -0.11994593f, -0.08289341f, 0.04536513f, 0.01398033f, 0.02856020f, 0.07469594f, 0.49586034f, 
    -0.12005097f, 0.12889801f, 0.01121676f, 0.07041922f, 0.18362068f, -0.17605563f, 0.06517585f, 0.20052192f, 
    0.21343781f, -0.03644074f, -0.10269409f, 0.37237436f, -0.13723178f, 0.29190221f, 0.02325248f, 0.25984046f, 
    0.02918210f, 0.34690025f, 0.09879903f, -0.23311046f, -0.10275432f, 0.05802834f, -0.09366103f, -0.02330323f, 
    -0.30489522f, -0.03159213f, -0.07548481f, 0.08439216f, 0.11091350f, 0.13666551f, 0.10418066f, -0.02828602f, 
    0.03498351f, 0.20358714f, 0.02923053f, 0.15434612f, 0.03022711f, -0.03530444f, 0.13101302f, 0.09546459f, 
    0.08576807f, -0.10450526f, 0.40250239f, 0.23952909f, -0.40304753f, -0.17413253f, -0.05439637f, 0.11149457f, 
    0.06471913f, 0.32169676f, 0.13544610f, 0.70766032f, -0.26839507f, -0.53974652f, -0.17247339f, -0.18552288f, 
    -0.01722298f, 0.35953644f, 0.28165507f, 0.18050386f, -0.40372363f, 0.08524992f, 0.24669278f, -0.01932678f, 
    -0.12590602f, 0.18673283f, 0.03307692f, 0.03195718f, 0.01690427f, 0.36682805f, 0.13342772f, 0.21966296f, 
    -0.03141049f, 0.06538457f, 0.11462924f, -0.30336568f, 0.00107209f, 0.33706710f, 0.04040360f, -0.24946314f, 
    0.21046977f, 0.27769992f, -0.01558642f, 0.16160482f, -0.00291212f, 0.17225099f, -0.04209350f, -0.42546785f, 
    -0.19040351f, -0.42707992f, 0.14851311f, 0.25576419f, -0.13824023f, 0.03057185f, 0.04812893f, -0.08194651f, 
    -0.19984791f, -0.48547864f, -0.71837008f, 0.01676436f, -0.15179774f, -0.03024687f, -0.05210122f, -0.05368748f, 
    0.04910674f, -0.53894144f, -0.27109310f, -0.39851367f, -0.06450262f, 0.11042515f, -0.03404242f, 0.24926458f, 
    0.13919257f, 0.06083931f, -0.56612319f, -0.12912738f, -0.36792353f, -0.14628223f, 0.21890140f, -0.17856035f, 
    -0.03991599f, 0.16657268f, 0.13544218f, -0.23517580f, -0.35536966f, 0.13426094f, 0.15958230f, 0.31265023f, 
    0.26856169f, 0.10392801f, 0.12367883f, 0.19350930f, 0.13254493f, -0.45826468f, -0.03779429f, -0.09789667f, 
    0.03502825f, 0.01065578f, 0.15778908f, 0.10512406f, -0.00220619f, -0.07733548f, -0.57231569f, -0.27299419f, 
    0.31688884f, 0.07281799f, -0.10079906f, -0.08324716f, 0.13659810f, 0.27049044f, -0.28293842f, -0.09299012f, 
    0.15532492f, -0.18384534f, 0.07100404f, -0.35828099f, 0.04301154f, -0.13397467f, 0.18953443f, -0.38205069f, 
    -0.47257063f, 0.10700274f, -0.16353856f, -0.22834729f, -0.23951557f, -0.20589970f, -0.00886129f, 0.12413769f, 
    -0.16598451f, -0.21595447f, -0.19182420f, 0.13846710f, -0.06526634f, 0.01379412f, -0.10957228f, 0.16355480f, 
    0.34734032f, -0.02926748f, 0.04427078f, 0.13898176f, -0.22139128f, -0.15540937f, -0.39162120f, 0.26539287f, 
    0.05125396f, 0.45474181f, -0.10881498f, -0.23272331f, 0.13928320f, 0.03003488f, -0.23114264f, 0.08065226f, 
    -0.16442901f, 0.06461354f, -0.21517511f, -0.17574109f, -0.02207073f, 0.00566997f, -0.22244772f, -0.44072911f, 
    -0.14213774f, -0.10525683f, -0.08586976f, 0.08038822f, 0.26767480f, 0.20566548f, 0.15864617f, -0.02058363f, 
    0.12377007f, -0.03499969f, 0.04007775f, 0.18472598f, 0.22818728f, 0.29604053f, 0.23262563f, -0.28985491f, 
    0.01362616f, -0.05328852f, -0.18649046f, 0.02909371f, 0.01100765f, -0.07871842f, -0.14273740f, -0.00314229f, 
    0.11225647f, 0.01257485f, -0.13013242f, -0.06499538f, -0.06515585f, 0.03394185f, 0.06189088f, -0.25187260f, 
    0.02833000f, -0.01814323f, 0.09996982f, -0.11600681f, 0.05576816f, 0.07915759f, -0.01236667f, -0.24302800f, 
    0.09344834f, 0.24189626f, -0.06622741f, 0.01868581f, -0.04936392f, 0.22806640f, -0.01177592f, -0.08247094f, 
    0.09623667f, 0.04043419f, -0.01435506f, -0.02136461f, -0.86572874f, -0.26563516f, -0.10420606f, 0.17675833f, 
    0.06002647f, 0.10021575f, -0.02005779f, -0.02908991f, 0.25433913f, 0.34285647f, 0.19165164f, -0.22033200f, 
    -0.04311103f, 0.02214801f, 0.04930275f, 0.42606732f, 0.25230250f, -0.10089484f, 0.03532797f, -0.04205288f, 
    -0.09329881f, 0.04278014f, 0.08874678f, 0.03944998f, -0.07595889f, 0.25920737f, -0.19295138f, 0.03137445f, 
    -0.06774337f, 0.00050947f, 0.05498981f, 0.04201047f, 0.25940537f, 0.33510593f, 0.50156575f, -0.06510181f, 
    0.07733930f, 0.11491061f, 0.01109497f, -0.04221421f, 0.04707263f, -0.02068169f, 0.10490653f, 0.11523321f, 
    -0.29267889f, -0.10993664f, -0.02679258f, -0.10100209f, 0.08104993f, 0.16528535f, 0.18259174f, -0.09214625f, 
    0.37723270f, 0.03657693f, 0.14100587f, 0.13083865f, 0.24149646f, 0.05093073f, 0.30037200f, 0.05057453f, 
    0.03709608f, 0.06012030f, 0.07492582f, -0.24234773f, -0.13631493f, -0.15564518f, -0.14115778f, -0.20456687f, 
    0.01394604f, 0.02564759f, 0.20683780f, 0.10234439f, -0.00566962f, 0.04997420f, 0.10472187f, -0.25554389f, 
    -0.01524871f, 0.05204223f, -0.17161703f, -0.03610106f, 0.05927578f, -0.08071188f, 0.09196904f, -0.07480474f, 
    -0.12190633f, 0.01263313f, 0.04912503f, 0.06653535f, 0.09100798f, -0.13496652f, -0.26283908f, -0.07622005f, 
    0.27015978f, 0.18301833f, 0.06803138f, 0.11479130f, 0.32531196f, -0.10836191f, -0.40512767f, 0.08825696f, 
    0.04227025f, -0.23854248f, 0.05280199f, -0.14647889f, -0.21340874f, -0.32210559f, -0.01718755f, 0.02084786f, 
    -0.12881497f, -0.22995484f, -0.08120555f, 0.03217213f, -0.07863919f, 0.02049591f, -0.01571626f, 0.22934987f, 
    0.27715343f, 0.18240853f, 0.11850737f, 0.25001177f, -0.12480549f, -0.02909082f, -0.11115449f, 0.22559346f, 
    0.09052350f, -0.09145994f, -0.01206589f, -0.03382297f, -0.11489445f, -0.03139678f, 0.01581969f, 0.11958502f, 
    -0.23251517f, 0.05536515f, -0.09943847f, -0.26411691f, 0.01397685f, -0.00312325f, 0.04820710f, 0.04383345f, 
    0.04060282f, 0.04005714f, 0.19112642f, -0.01540194f, -0.07790230f, -0.09613197f, -0.05238646f, -0.15477465f, 
    -0.09918855f, -0.00321202f, -0.02567428f, 0.02316056f, -0.14390177f, -0.12544090f, -0.02970628f, -0.00741914f, 
    0.10359135f, 0.17610541f, 0.50074071f, -0.17211244f, 0.32828906f, 0.19842564f, 0.18450005f, 0.02273743f, 
    0.25679076f, -0.12119215f, -0.02490273f, -0.13668852f, 0.12388036f, -0.00023932f, -0.15501924f, -0.09104913f, 
    -0.08101075f, -0.04894581f, -0.02898189f, -0.11037412f, -0.18595783f, -0.03085219f, 0.10987689f, 0.09346900f, 
    0.00294226f, -0.15664698f, 0.03790876f, 0.06831156f, 0.07387200f, 0.05696010f, 0.02536398f, 0.14784224f, 
    -0.12934294f, -0.08258753f, -0.02775794f, -0.10160469f, -0.17213809f, -0.25708818f, 0.01694396f, -0.48358425f, 
    0.33039328f, 0.08812012f, -0.04623964f, -0.10443509f, -0.08305615f, -0.11010565f, 0.20813525f, 0.25356844f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.14155409f, 0.21501029f, 0.01165177f, 0.45798656f, -0.05678535f, 0.00181521f, -0.04384163f, 0.02478930f, 
    0.03965676f, 0.20066063f, -0.02164146f, -0.11358548f, -0.02168712f, 0.11215647f, -0.03144716f, 0.35797679f, 
    0.16287754f, 0.14194070f, 0.36478272f, 0.01998327f, -0.06534569f, -0.05064075f, -0.05598072f, -0.04649730f, 
    -0.05772271f, 0.04739197f, -0.09607115f, 0.10719254f, 0.51382452f, 0.02275215f, 0.14420597f, -0.03540555f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.64585662f, -0.34132025f, -0.03304216f, -0.07320110f, 0.08997255f, -0.04718234f, 0.10835821f, -0.14940408f, 
    0.12535091f, 0.01404616f, -0.13280579f, 0.21689604f, -0.13523744f, -0.21317841f, -0.08878846f, 0.03647417f, 
    0.17129193f, -0.67501265f, -0.20579934f, -0.00603986f, -0.01247137f, -0.13529384f, -0.02938084f, 0.09388693f, 
    -0.14299707f, 0.08916476f, 0.37003776f, -0.47854567f, -0.75726485f, 0.05260415f, -0.02522021f, 0.25890034f, 
    0.12472229f, 0.09572605f, 0.04576058f, 0.31281596f, -0.32966933f, 0.05944629f, 0.39425465f, 0.05000787f, 
    -0.05094330f, 0.44808716f, -0.00968546f, 0.11992472f, 0.01019340f, 0.07771932f, 0.13100971f, 0.10049917f, 
    0.23167033f, -0.44222978f, 0.08626470f, -0.14584132f, -0.02326047f, -0.10142585f, 0.09664222f, 0.01019455f, 
    0.05321370f, 0.09969598f, 0.16325179f, 0.24081892f, 0.00888375f, -0.40701798f, 0.53755140f, -0.09774467f, 
    -0.68114924f, -0.74086273f, -0.06914576f, 0.42526200f, -0.00358325f, -0.13468437f, 0.17160074f, -0.08460020f, 
    -0.03443952f, -0.25252452f, -0.04973774f, -0.22635987f, 0.00337020f, -0.08894855f, -0.13108221f, -0.22530724f, 
    -0.06148689f, -0.05319143f, 0.12071545f, 0.04494681f, -0.14759539f, -0.15930578f, -0.11469787f, 0.00341506f, 
    -0.01009455f, 0.05629035f, -0.61981618f, -0.54698896f, 0.53321177f, 0.33756611f, 0.11367869f, 0.30391902f, 
    0.09578151f, -0.08280054f, -0.04587037f, -0.59695381f, 0.59795767f, -0.13762493f, -0.43668830f, 0.01500608f, 
    0.04235938f, -0.27486202f, 0.12713768f, -0.04528754f, -0.12018718f, -0.34179890f, 0.16077708f, -0.43327045f, 
    -0.14847520f, 0.51593423f, -0.22631805f, 0.11836876f, 0.04340304f, 0.01090104f, -0.05220025f, 0.01893088f, 
    0.13926509f, 0.01953319f, -0.28960380f, -1.02097619f, -0.28487912f, 0.20573375f, 0.45189136f, 0.02597579f, 
    -0.41614777f, -0.21843463f, 0.17058568f, -0.14037107f, 0.20209934f, 0.13089271f, 0.68561262f, -0.18028672f, 
    -0.13611700f, -0.00191869f, -0.12189139f, 0.18281771f, -0.02814220f, -0.39360547f, -0.17770453f, -0.21201105f, 
    0.18621984f, 0.15058187f, 0.01268982f, 0.01175485f, -0.16050652f, -0.01702812f, -0.08132371f, -0.09844051f, 
    0.14806037f, 0.12019400f, 0.35982901f, 0.08282414f, -0.56085938f, 0.33668894f, -0.27554229f, -0.42855284f, 
    0.05383828f, 0.20953777f, -0.12594053f, 0.18162331f, -0.26610765f, 0.13620441f, -0.43632317f, -0.00853288f, 
    0.00738544f, -0.01886891f, 0.10301531f, 0.44343075f, -0.07669236f, 0.23662066f, -0.13150528f, -0.31717607f, 
    -0.49208897f, 0.10479346f, -0.44145623f, -0.08572161f, -0.05558822f, -0.04670215f, -0.06651483f, -0.06982163f, 
    0.01881807f, 0.02337117f, 0.48512098f, 0.25909713f, 0.08510389f, 0.24719772f, -0.21438961f, 0.06399883f, 
    -0.40826526f, -0.52716583f, 0.07004741f, 0.19960040f, -0.25568044f, 0.15443963f, -0.66486830f, 0.13963421f, 
    0.00456200f, 0.59696329f, -0.15341444f, -0.35525173f, 0.02502158f, -0.25265661f, 0.05103526f, 0.53544492f, 
    -0.26355967f, 0.22513032f, -0.10020286f, -0.02900787f, 0.15005638f, 0.12902860f, 0.14476918f, 0.08600996f, 
    0.07653864f, 0.13472778f, -0.72942770f, -0.14351852f, 0.44570318f, 0.18408430f, -1.34382772f, 0.40447050f, 
    0.01693205f, 0.68795240f, 0.04936447f, -0.57840568f, 0.03028727f, -0.05845618f, 0.09489720f, 0.09711598f, 
    -0.13953134f, 0.09808304f, -0.15846285f, 0.03925141f, -0.08451744f, -0.17342716f, -0.12265688f, -0.37898701f, 
    0.46171382f, 0.10797791f, -0.27821445f, -0.10291679f, -0.06015431f, -0.08553239f, -0.08051058f, -0.11546383f, 
    0.16558374f, 0.04401267f, 0.00938814f, 0.17158797f, -0.23826459f, 0.10783849f, -0.62580097f, 0.04617744f, 
    0.28505558f, 0.68866849f, -0.08093221f, 0.00634854f, -0.43853670f, 0.01635678f, 0.10124988f, -0.12762028f, 
    -0.03190383f, -0.62480551f, 0.02151073f, 0.40673855f, 0.11037510f, 0.21363050f, -0.14864865f, 0.11069246f, 
    0.40374956f, 0.12594013f, 0.08688882f, -0.12198838f, -0.10835545f, -0.10711432f, 0.07810126f, 0.06492180f, 
    -0.14381723f, 0.05088851f, -0.61221933f, -0.45236498f, 0.20103320f, -0.42875367f, 0.11884446f, -0.38146189f, 
    0.12996331f, -0.35743773f, -0.16216752f, -0.05508879f, 0.16042539f, 0.00843977f, -0.58940786f, -0.01718756f, 
    0.11588211f, -0.38369867f, -0.18300706f, -0.55830163f, 0.05715073f, -0.46762091f, 0.08220713f, 0.99758977f, 
    0.18264544f, 0.05244947f, 0.46716702f, 0.12576516f, -0.11536526f, 0.07368650f, 0.09442986f, -0.13303255f, 
    -0.17197859f, 0.00236559f, -0.07978527f, 0.03785328f, -0.47511205f, -0.09574503f, -0.14808315f, 0.10256685f, 
    -0.23658189f, -0.84188753f, -0.01107467f, -0.15768211f, 0.27545789f, -0.15732366f, 0.67589247f, 0.10075129f, 
    0.16586761f, -0.38083977f, -0.06522302f, 0.35023350f, 0.06537841f, 0.44038969f, -0.02847705f, -0.30678266f, 
    -0.26098374f, 0.24346881f, -0.31837550f, -0.08235167f, 0.17184713f, -0.10638876f, -0.02729827f, 0.14693747f, 
    -0.03349018f, 0.11610829f, -0.81390870f, 0.39891979f, 0.34948862f, -0.68784058f, -0.53293395f, -0.58250940f, 
    -0.56474346f, -0.17341955f, -0.04071510f, -0.55236655f, 0.21467918f, -0.02708754f, -0.74311286f, 0.01528374f, 
    -0.16214323f, -0.04425716f, 0.07444014f, -0.32493371f, -0.01441519f, 0.35735619f, -0.17730840f, -0.39763820f, 
    -0.18522604f, 0.02525774f, 0.48456734f, 0.11390702f, 0.09989892f, -0.03741144f, 0.04446629f, 0.12072225f, 
    0.09677360f, 0.06781793f, -0.30417803f, 0.68455392f, -0.02788550f, -0.26131031f, -0.56506228f, 0.00877782f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39289096f, 0.06112411f, 0.13127406f, -0.04465943f, 0.00452288f, -0.08229668f, 0.19490559f, -0.52178866f, 
    -0.05090282f, 0.13409683f, 0.10613882f, 0.09350525f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
