#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49200717f, -0.04006957f, -0.20805143f, -0.48110315f, 0.21167454f, 0.73261929f, 0.02403010f, 0.12598127f, 
    -0.25420552f, 0.09271839f, -0.11534210f, 0.42494106f, 0.34027994f, 0.52467346f, 0.11948739f, -0.37867534f, 
    -0.00765629f, 0.23794496f, -0.58450395f, -0.47327238f, -0.31243619f, -0.42132643f, -0.63451612f, -0.49209914f, 
    -0.21934788f, 0.00174124f, 0.45068750f, -0.09325031f, -0.27243578f, 0.31993890f, -0.45061925f, -0.51320851f, 
    -0.94740558f, -0.14033289f, 0.62836921f, -0.29333857f, 0.71380180f, -0.13798329f, -0.37531742f, -0.46125525f, 
    0.35675418f, 0.38370565f, 0.08003147f, -0.36231652f, 0.38173535f, -0.75300026f, -0.38613498f, 1.00071561f, 
    -0.08076334f, -0.25171345f, -0.58564675f, 0.22978634f, -0.04311383f, 0.37631270f, 0.21381864f, 0.22388746f, 
    -0.97596735f, -0.35568243f, 0.45544037f, -0.53195959f, 0.02679950f, 0.42307898f, 0.49788237f, 0.83877921f, 
    -0.33583283f, -0.42533892f, 0.57487422f, 0.55519718f, 0.41172579f, -0.59773684f, 0.40805414f, -0.19702789f, 
    0.95952219f, -0.73720813f, 0.70270085f, -0.21840438f, -0.02233652f, -0.30918366f, 0.64388245f, -0.35817742f, 
    -0.03480918f, 0.31975454f, 0.30395123f, 0.33811247f, 0.06533436f, 0.30101478f, 0.19042440f, 0.27909753f, 
    0.32717597f, -0.16348962f, -0.29943782f, -0.21199714f, -0.02965821f, -0.48938668f, -0.44526774f, -0.82220542f, 
    0.50681144f, -0.17854209f, 0.54590899f, 0.33706918f, -0.07541568f, 0.18297932f, 0.00084639f, 0.60887867f, 
    0.41856122f, -0.28375813f, -0.13038072f, 0.15166099f, -0.85610294f, -0.39636976f, 0.08014233f, 0.07394994f, 
    0.40221927f, 0.27830309f, 0.23840183f, 0.27889147f, 0.44409207f, -0.75287503f, -0.47258386f, 0.35042742f, 
    0.16158554f, 0.13042714f, -0.18249242f, -0.40848351f, -0.41451651f, -0.61658072f, 0.45121932f, 0.86635596f, 
    -0.28341827f, 0.10848508f, -0.35127312f, -0.37840059f, -0.70074403f, 0.34567803f, 0.42828560f, -0.33856183f, 
    -0.51490873f, -0.56561857f, -0.28548017f, -0.43090281f, -0.49616110f, 0.44104606f, 0.56086105f, -0.08764920f, 
    -0.91578466f, 0.15576632f, -0.59558094f, -0.25851741f, 0.60004628f, 0.72571343f, -0.36955792f, -0.46913084f, 
    -0.32594848f, 1.14602542f, -1.26819229f, -0.32628962f, 0.31461778f, 0.54195684f, -0.37704366f, -0.18393198f, 
    -0.54872864f, 0.54634112f, 0.29238096f, -0.15202795f, 0.33178845f, -0.19390948f, 0.00385670f, -0.55037534f, 
    0.69302040f, -0.39129886f, 0.10559747f, -1.17430758f, -0.36767560f, 0.07446766f, 0.94711256f, -0.21403459f, 
    -0.62611252f, -0.17604184f, -0.18546072f, -0.17008711f, -0.22315750f, -1.09775960f, -0.99456686f, 0.59868336f, 
    0.50770694f, 0.75571352f, 0.47682944f, 0.35359091f, 0.05514242f, 0.27625102f, -0.87483042f, 0.67990512f, 
    -0.70827281f, -0.24988428f, 0.80080789f, -0.42945060f, -0.22957139f, 0.71965516f, -0.60840380f, -0.58077860f, 
    -0.38417068f, 0.13052998f, -0.54140466f, 0.35598025f, -0.14042366f, -0.29272568f, -0.52246141f, 0.65570945f, 
    0.48444125f, -0.87021810f, -0.45561540f, -0.25175077f, -0.26467162f, 0.40422991f, 0.26888195f, 0.36412480f, 
    -0.03997321f, -0.07191636f, 0.30345535f, 0.11881712f, 0.02968538f, 0.34885967f, 0.37049484f, 0.06999551f, 
    -0.53480381f, 0.33646211f, 0.61855829f, -0.60668641f, -0.72897929f, -0.75090504f, -0.48404744f, -0.34220397f, 
    -0.60342282f, -0.24699858f, 0.57466799f, 1.08531845f, -0.67058361f, -0.59693021f, 0.11022227f, -0.21289432f, 
    0.12190489f, 0.18176188f, -0.26624823f, -0.22995622f, 0.26972821f, 0.56129187f, -0.33449218f, -0.26591629f, 
    0.23659080f, -0.50169122f, -0.08351501f, -0.42929456f, 0.14059336f, 0.71869057f, 0.54856718f, 0.13798927f, 
    -0.30066726f, 0.32839543f, -0.31357563f, -0.23534168f, -0.02314377f, 0.63476646f, 0.75907552f, 0.37949356f, 
    -0.35931000f, -0.24302542f, -0.23298448f, -0.41520619f, -0.43843186f, -0.02642952f, -1.37325501f, 0.94772291f, 
    0.43462768f, -0.83567482f, 0.50223160f, 0.47674513f, -0.01390428f, -0.20494029f, 0.33818671f, -0.12766726f, 
    -0.07710228f, -0.36089987f, 1.01000190f, -0.79706424f, -0.34897000f, -0.56182230f, -0.21635818f, -0.14178954f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11146879f, -0.29257816f, -0.36933756f, -0.23317268f, 0.08598921f, 0.11321268f, 0.02001498f, -0.09970531f, 
    -0.00906947f, -0.06822738f, 0.09743381f, -0.30949751f, 0.06808143f, -0.16547030f, -0.06481134f, -0.06519979f, 
    0.13812228f, 0.00369045f, 0.13414165f, 0.01568739f, 0.08439384f, 0.32803053f, -0.23827390f, 0.00302272f, 
    0.12406758f, 0.10082923f, 0.14468230f, 0.19099678f, -0.23723897f, 0.20175917f, 0.19616191f, -0.32119903f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03399595f, -0.01296110f, 0.01086457f, -0.02735157f, 0.02547535f, 0.02463944f, -0.03867260f, -0.02070568f, 
    -0.02954525f, -0.03043745f, 0.01320423f, 0.01364355f, -0.01988240f, -0.03210768f, -0.01303216f, 0.02057486f, 
    -0.01201717f, -0.00471053f, -0.01478927f, -0.01249694f, 0.01819757f, 0.01068338f, -0.00633278f, 0.02479675f, 
    -0.03067653f, 0.01105832f, 0.02644736f, -0.02450663f, -0.00019521f, 0.01761816f, -0.01168330f, -0.02173583f, 
    0.00938565f, -0.02543775f, -0.00594560f, -0.00179354f, 0.00473461f, 0.01061269f, 0.00876829f, 0.01803889f, 
    0.01413823f, 0.00355031f, -0.03237746f, 0.00362343f, 0.01946802f, 0.01020820f, -0.04324964f, 0.00972412f, 
    -0.00793326f, -0.00848263f, 0.00489739f, -0.01253308f, 0.03657270f, -0.04165855f, 0.01459806f, 0.00396836f, 
    -0.01678808f, -0.02140817f, -0.03593198f, -0.00972109f, -0.00522265f, -0.04192502f, -0.00659112f, 0.01351331f, 
    -0.01640825f, -0.00653220f, 0.02832587f, -0.02781528f, 0.03279976f, 0.00882246f, -0.02351231f, -0.00458161f, 
    -0.00562371f, -0.02713671f, -0.00871511f, -0.00632303f, -0.04345141f, 0.02032712f, 0.00941799f, 0.01888753f, 
    0.00874390f, 0.02227771f, 0.01634525f, 0.00028246f, 0.01351726f, -0.00928865f, -0.04074595f, 0.01728572f, 
    -0.02879825f, -0.03648967f, 0.02342309f, -0.04936824f, -0.00454159f, 0.02095732f, -0.03988643f, -0.02760131f, 
    -0.02955765f, -0.04754396f, 0.00981971f, -0.00206068f, 0.00247683f, -0.02443470f, -0.02111151f, -0.03317768f, 
    -0.02369950f, 0.01450717f, -0.02273385f, -0.04036168f, -0.02895048f, -0.00353051f, -0.01812334f, -0.03360670f, 
    -0.00206707f, -0.03096740f, -0.02750337f, -0.01984119f, -0.02280850f, -0.02596267f, -0.00378358f, -0.04753953f, 
    -0.00004489f, -0.00524106f, -0.01559333f, -0.03461766f, 0.01976754f, -0.00048818f, -0.03217284f, -0.00979181f, 
    -0.03954917f, 0.02439537f, -0.00230025f, -0.02836710f, 0.00828849f, 0.01109073f, 0.00959265f, -0.04863579f, 
    -0.01756905f, 0.00294616f, 0.00927283f, -0.03842856f, -0.02461694f, 0.00421979f, 0.01609134f, -0.02924197f, 
    0.02078338f, 0.00122425f, -0.01924830f, -0.00712884f, 0.00639958f, 0.02317821f, 0.00644434f, -0.03369800f, 
    -0.03170263f, 0.00780631f, -0.01237314f, 0.04045723f, -0.01173091f, -0.04590705f, -0.03397723f, 0.00557348f, 
    -0.03671369f, -0.02739367f, -0.00335634f, 0.00804941f, 0.02676677f, -0.01091709f, -0.02510758f, -0.04388318f, 
    -0.02673702f, -0.00826318f, -0.00622623f, 0.01005490f, -0.03081560f, -0.00618774f, -0.05417832f, 0.01409211f, 
    -0.00409974f, -0.03046441f, 0.03089524f, -0.03114960f, -0.02072689f, 0.01303239f, 0.00933176f, -0.02738491f, 
    -0.03764725f, -0.03809837f, 0.00842091f, -0.02465972f, 0.03267677f, -0.05081788f, -0.01034214f, -0.02594734f, 
    -0.04492852f, -0.02702174f, 0.02391949f, 0.00667522f, 0.01224848f, -0.05014871f, -0.04537554f, -0.05033567f, 
    0.02924290f, 0.00625149f, -0.00869599f, -0.01550403f, -0.01914211f, 0.00521019f, -0.00704784f, -0.01483939f, 
    -0.04168592f, -0.01561545f, -0.00419569f, -0.02765237f, -0.02610511f, 0.02508252f, -0.00218517f, -0.05003420f, 
    -0.03116971f, -0.01942144f, -0.04448686f, -0.00705283f, 0.02043810f, -0.01283125f, -0.00220337f, -0.00346269f, 
    0.00651958f, 0.00101262f, -0.00975433f, -0.04084694f, 0.01577469f, -0.03935080f, -0.03784353f, -0.01062481f, 
    -0.04037084f, -0.01442603f, -0.04327774f, -0.02342428f, -0.01119492f, 0.00610497f, -0.01199119f, -0.01598399f, 
    -0.03200819f, -0.02469701f, 0.02680394f, -0.01829936f, -0.01260589f, -0.03503467f, 0.00693952f, 0.01607258f, 
    0.01633668f, -0.03128453f, -0.01154480f, 0.01326301f, -0.00319896f, -0.04821092f, -0.02814690f, -0.00466546f, 
    0.00552298f, -0.03062206f, -0.04035192f, 0.01070326f, 0.02798763f, -0.00975841f, 0.01662501f, 0.02648881f, 
    -0.01542282f, -0.03194325f, -0.00762620f, 0.02788550f, 0.00689981f, 0.00700045f, -0.00860897f, 0.00625080f, 
    -0.00626575f, -0.03422230f, -0.03562063f, 0.00482094f, 0.02635697f, -0.00497022f, 0.00870249f, -0.01559833f, 
    -0.03349071f, -0.00057056f, -0.01069224f, -0.04119345f, 0.01391150f, -0.02247806f, -0.05391448f, 0.02197352f, 
    -0.04502319f, 0.00755169f, -0.05165586f, 0.00175410f, 0.00948302f, 0.00084831f, -0.00970243f, -0.01874211f, 
    -0.01745401f, -0.01637490f, -0.03035435f, -0.00317976f, 0.01614953f, -0.04021855f, 0.02447657f, -0.02736234f, 
    0.03324063f, -0.02044009f, 0.01197699f, -0.00029737f, -0.03519093f, -0.00029529f, 0.01416983f, 0.03158472f, 
    -0.02854296f, 0.02173662f, 0.02053793f, 0.01225899f, -0.04415001f, 0.00675348f, -0.01641271f, -0.02657387f, 
    -0.01436076f, 0.02813471f, 0.02957705f, -0.00018856f, -0.02773596f, -0.00366562f, -0.00382845f, -0.01474634f, 
    -0.03959564f, -0.01855520f, 0.01909455f, 0.02526673f, -0.02572633f, -0.02501295f, 0.01980276f, 0.01578949f, 
    -0.01734289f, 0.01502956f, -0.04550087f, -0.03318990f, 0.02328253f, -0.03700531f, -0.03776066f, -0.00891679f, 
    -0.03345986f, 0.04438205f, 0.03536137f, -0.04243726f, -0.02072281f, 0.03799578f, -0.03878939f, -0.01185228f, 
    -0.04305653f, -0.02187886f, 0.00361118f, 0.02532055f, -0.04870624f, -0.04132725f, -0.02966252f, -0.02695633f, 
    -0.03762814f, -0.01500624f, 0.00660582f, -0.02934120f, -0.03014164f, 0.01704695f, -0.02425258f, -0.00378437f, 
    0.02887769f, 0.01110396f, -0.03804742f, -0.04111642f, 0.00292061f, -0.05134979f, 0.00553923f, 0.02403894f, 
    0.01148595f, -0.00838592f, -0.04243074f, -0.01869704f, 0.01048964f, 0.03353631f, -0.03682407f, -0.04136265f, 
    0.01000927f, 0.00483285f, -0.01439087f, 0.01830330f, -0.02067675f, 0.02910073f, 0.00214317f, -0.01658877f, 
    -0.01195295f, 0.02198043f, -0.02571306f, 0.00252526f, 0.02754864f, 0.02690812f, -0.01820297f, -0.02481992f, 
    -0.04311280f, 0.03250596f, -0.02292510f, -0.04109292f, -0.02455825f, -0.04125229f, -0.03659181f, -0.04094459f, 
    0.01226076f, -0.01708483f, -0.03248967f, -0.02251495f, -0.02265470f, -0.04735984f, -0.01618794f, -0.03878209f, 
    0.02374261f, -0.01540417f, -0.02415363f, -0.01165745f, 0.00197470f, -0.03270053f, 0.01786650f, -0.00086128f, 
    -0.01508551f, 0.00192821f, -0.00358086f, -0.03814615f, 0.00883341f, -0.01405919f, -0.03182409f, -0.00188960f, 
    -0.03912813f, 0.02212058f, 0.01489018f, 0.02175950f, -0.02351589f, -0.02399582f, -0.04990961f, -0.02998640f, 
    -0.01235610f, 0.01782580f, 0.00232094f, 0.03079881f, -0.03069178f, 0.02795194f, -0.00754457f, 0.03062420f, 
    -0.00666116f, 0.01990938f, -0.02488852f, -0.02906385f, 0.02296000f, 0.01951324f, -0.01700385f, -0.04509761f, 
    -0.03049861f, 0.01068657f, -0.01932348f, -0.04407552f, -0.02278954f, 0.01792244f, -0.02638434f, 0.00537061f, 
    -0.03864669f, -0.02358260f, -0.02979083f, 0.00029206f, -0.01780545f, 0.01444239f, 0.02963797f, -0.02426816f, 
    -0.04540550f, 0.00101530f, 0.00648595f, -0.01547771f, 0.00212633f, -0.01101455f, -0.03794554f, 0.00533801f, 
    -0.00466540f, -0.02703744f, -0.03086272f, 0.01454910f, -0.01515528f, -0.04782244f, -0.00212138f, -0.01920133f, 
    -0.03983583f, -0.03713638f, -0.02628142f, -0.02616216f, 0.02052927f, 0.02467211f, -0.00933378f, 0.02063368f, 
    -0.04070789f, -0.04240193f, -0.03691433f, -0.02261070f, -0.02218329f, 0.01816756f, 0.01057828f, 0.00018608f, 
    -0.00131413f, -0.03570459f, 0.00305039f, -0.00610751f, -0.00964794f, 0.00671607f, 0.02025660f, 0.00462930f, 
    -0.01400710f, -0.03800948f, -0.04000159f, -0.04743099f, -0.01858744f, -0.01858930f, -0.04364875f, -0.01604413f, 
    0.02938583f, 0.00657188f, 0.02089449f, -0.01719522f, -0.02082353f, -0.01337501f, -0.00874536f, 0.01581803f, 
    -0.00852656f, 0.02583565f, -0.01220996f, -0.00271935f, 0.02256442f, 0.01076060f, 0.01100412f, -0.00080572f, 
    -0.04409218f, 0.01514513f, 0.01492060f, -0.04730350f, -0.03267832f, -0.00392676f, 0.00264810f, -0.03501869f, 
    0.00713151f, -0.02985993f, 0.00191147f, -0.01265893f, -0.05106846f, -0.05078118f, -0.00685829f, 0.00556575f, 
    0.02413662f, -0.04047668f, -0.02709191f, -0.00723535f, -0.02284097f, -0.01417315f, -0.01715577f, 0.02359783f, 
    0.01294414f, -0.04387155f, -0.02522201f, 0.02905607f, -0.02042876f, -0.00438607f, -0.04707573f, -0.03321761f, 
    -0.01665404f, 0.01602436f, -0.01611101f, 0.01291516f, -0.03681817f, -0.00595171f, 0.00180799f, 0.01014051f, 
    0.03148794f, -0.03268621f, -0.04817559f, -0.03511285f, 0.00460786f, 0.00864289f, -0.02121963f, -0.00533535f, 
    -0.02079093f, 0.00196585f, 0.01838278f, 0.01974744f, -0.00754597f, 0.01793714f, -0.05325180f, 0.01169031f, 
    -0.02646592f, -0.00598790f, -0.00592987f, 0.01877188f, 0.00946890f, 0.02680353f, -0.04474111f, 0.01954669f, 
    -0.00780389f, -0.04790871f, 0.00982126f, 0.01090024f, -0.00291157f, 0.00646742f, 0.00305307f, -0.00947046f, 
    -0.00658774f, -0.02719875f, -0.02997705f, -0.04559198f, 0.02061601f, -0.04153978f, -0.03603888f, 0.02810782f, 
    0.01081796f, 0.00508475f, 0.00999689f, -0.00152764f, 0.00059614f, -0.04316722f, -0.00705429f, 0.04346298f, 
    -0.03949909f, -0.00502717f, 0.01942759f, 0.00041135f, -0.01636855f, 0.00775952f, 0.01262999f, -0.00022902f, 
    0.02519844f, 0.00321319f, -0.02922709f, -0.03348223f, -0.01213401f, -0.03015056f, -0.03926016f, 0.03501876f, 
    0.00569191f, 0.02569089f, -0.01433229f, 0.03033438f, -0.02770168f, -0.03722480f, 0.00383036f, -0.04360190f, 
    -0.02119210f, -0.01813543f, -0.00400055f, -0.03258254f, 0.02280108f, -0.02558630f, 0.01083137f, 0.03308254f, 
    -0.02349733f, 0.01968941f, 0.01127556f, -0.01905724f, -0.00943477f, 0.01371539f, -0.04048105f, 0.01880989f, 
    -0.03610129f, 0.01152815f, 0.00010844f, 0.03782776f, 0.01842589f, -0.02999315f, 0.00563664f, 0.00914576f, 
    -0.02179028f, 0.01661476f, 0.01401706f, 0.01981383f, 0.03052521f, -0.00277909f, 0.03234375f, -0.04545968f, 
    -0.03050507f, 0.00362945f, 0.01630928f, 0.03084005f, 0.03907280f, 0.00294007f, -0.02245428f, -0.00868249f, 
    -0.00638527f, 0.00497479f, -0.03156602f, 0.02478954f, -0.03676645f, -0.02497975f, -0.03049455f, -0.01059645f, 
    -0.02546419f, 0.01802059f, -0.02977143f, 0.02861469f, -0.03217394f, 0.03435986f, -0.02048622f, 0.02842757f, 
    0.03289278f, 0.02684543f, -0.02502433f, -0.01175018f, -0.01522515f, -0.02444047f, -0.03394027f, 0.02172559f, 
    -0.03144782f, 0.00643835f, 0.01575318f, 0.00168431f, -0.03646200f, -0.03488031f, -0.00205976f, 0.00351704f, 
    -0.03604214f, -0.00777336f, 0.03200060f, -0.01682652f, -0.03786645f, 0.03297763f, 0.02669626f, -0.03900788f, 
    0.01560050f, -0.01909790f, 0.02944111f, 0.00884954f, 0.01584492f, -0.01570659f, 0.00746074f, 0.02905229f, 
    -0.02467990f, -0.01656237f, 0.03093826f, -0.03003385f, -0.02116877f, 0.01728297f, -0.01488038f, -0.03886483f, 
    -0.00040556f, -0.01734170f, 0.02744184f, -0.02959144f, -0.00977711f, 0.00051408f, -0.03262038f, 0.02973095f, 
    0.02871554f, -0.00263501f, -0.02142045f, 0.03103255f, 0.02666261f, 0.01070702f, -0.00840224f, 0.00955843f, 
    0.01469406f, 0.01376049f, 0.03290988f, -0.03317502f, 0.01575632f, -0.01138094f, -0.00647765f, -0.03030154f, 
    0.00959926f, -0.02653841f, -0.01123388f, -0.03512430f, -0.02594121f, 0.01892655f, -0.04037167f, -0.01923111f, 
    0.02071840f, -0.00632338f, -0.01130329f, 0.03072843f, -0.03501760f, 0.00530203f, -0.00884086f, 0.02971719f, 
    -0.02475522f, -0.00015188f, -0.03320980f, -0.03662327f, -0.03303900f, 0.01450094f, 0.01252338f, 0.02256897f, 
    -0.03396796f, -0.02846549f, 0.02987226f, -0.01134216f, 0.02274021f, -0.03870822f, -0.04445153f, 0.01458536f, 
    0.03023489f, -0.02821852f, 0.01726995f, -0.02800050f, -0.02034256f, 0.00700505f, -0.03285357f, 0.02901246f, 
    0.00489632f, -0.04482616f, -0.00608811f, 0.02237376f, 0.02060134f, 0.01297351f, -0.00824657f, -0.01765850f, 
    0.00281441f, -0.04055559f, -0.03350014f, 0.01272081f, -0.02725297f, -0.03181709f, 0.02056126f, 0.03231495f, 
    0.00005627f, -0.04517050f, 0.02910303f, -0.03177964f, -0.00016348f, 0.02523496f, -0.03393366f, -0.01333458f, 
    -0.03817547f, -0.00059164f, -0.02060780f, -0.00795869f, 0.03289396f, -0.02822244f, -0.03715207f, -0.01101993f, 
    0.03006219f, -0.02986978f, 0.01730682f, -0.01468449f, -0.00730228f, -0.01498735f, 0.00582098f, -0.03284160f, 
    0.00824412f, 0.02369464f, -0.00954324f, -0.02370719f, -0.03409608f, -0.02156301f, 0.00772907f, -0.01718514f, 
    -0.04505472f, 0.01008283f, 0.02051319f, -0.01744014f, -0.04526976f, -0.01572200f, 0.03490431f, -0.01511560f, 
    0.00298781f, -0.00214456f, -0.02764560f, -0.03311557f, -0.03927550f, 0.00016019f, 0.00075400f, -0.00772797f, 
    -0.04114154f, 0.00452623f, -0.02191111f, -0.02034697f, -0.01200946f, -0.02436550f, -0.02431868f, -0.01680816f, 
    -0.03222699f, 0.03020239f, -0.02138212f, -0.04370507f, 0.02771316f, -0.04294454f, 0.01574321f, 0.01859882f, 
    0.00062988f, 0.01816437f, -0.03975407f, 0.00106580f, 0.02722142f, -0.04412057f, -0.00768774f, 0.00075746f, 
    0.02863085f, -0.03780708f, 0.02221618f, 0.01244454f, 0.02307819f, -0.02216026f, 0.01058442f, -0.02793739f, 
    0.01271214f, 0.01253242f, -0.03078556f, 0.03080036f, -0.02008914f, 0.01992605f, -0.03696245f, -0.02932632f, 
    -0.04135962f, 0.00002534f, -0.00333603f, 0.00094933f, -0.02714883f, -0.00351162f, -0.04019679f, 0.00742363f, 
    0.02592920f, -0.01282481f, -0.04468636f, 0.01118957f, 0.03300589f, -0.01957189f, -0.03836680f, -0.00266214f, 
    0.02943766f, 0.02667125f, -0.03251373f, 0.00966278f, 0.02744405f, 0.02727563f, -0.00602547f, -0.01773833f, 
    -0.00641756f, 0.02800657f, -0.02575085f, 0.01624726f, -0.03942313f, -0.04066206f, -0.00885197f, 0.04097029f, 
    0.00602868f, 0.02159572f, -0.00293966f, -0.02543777f, -0.01891829f, -0.03280186f, 0.00244308f, 0.01797786f, 
    -0.01374510f, -0.03657356f, -0.02381388f, -0.02246461f, 0.02690790f, 0.01880056f, -0.02613264f, 0.02037513f, 
    0.03198996f, -0.03356187f, 0.02676094f, 0.02239569f, 0.02870207f, -0.01164311f, -0.01800286f, 0.02781151f, 
    -0.03992889f, -0.01203553f, 0.00585244f, 0.02060189f, -0.04088078f, -0.02435531f, -0.04050793f, -0.00771127f, 
    0.00838650f, 0.03315568f, 0.00227766f, -0.01175858f, -0.00923229f, 0.00980665f, 0.03265590f, 0.01964471f, 
    0.01549863f, 0.00091580f, -0.03399044f, 0.01219262f, 0.03068752f, 0.02645690f, 0.00240326f, 0.01243137f, 
    0.00451154f, 0.00989836f, -0.04051767f, 0.00797963f, -0.00693867f, 0.01478147f, 0.01795162f, 0.00399576f, 
    -0.01572592f, -0.00661096f, -0.03284235f, 0.01849213f, -0.00434654f, -0.00412430f, -0.00033589f, 0.01891389f, 
    -0.01469912f, 0.02694628f, -0.00793426f, 0.01004294f, -0.01498378f, -0.00850280f, 0.01629041f, -0.02409213f, 
    -0.02952340f, -0.02446817f, 0.00552376f, 0.02896138f, -0.03402129f, -0.02283660f, 0.01929847f, -0.03015286f, 
    0.02322335f, 0.02640055f, -0.03055866f, -0.01482837f, 0.01730971f, -0.02662195f, 0.00069307f, 0.03165339f, 
    -0.04095168f, -0.00584157f, -0.03158791f, -0.03926892f, 0.02317777f, -0.00148326f, -0.02460540f, -0.03778596f, 
    -0.02383753f, 0.00148390f, -0.03130604f, -0.00201426f, -0.01357010f, -0.04201081f, 0.00086178f, -0.01374535f, 
    -0.00144691f, 0.01545308f, 0.03248544f, -0.02506718f, -0.01449189f, -0.01118320f, 0.02801480f, -0.00164360f, 
    -0.03181542f, 0.02267643f, 0.00268976f, -0.03670809f, 0.03269069f, -0.03231237f, -0.01813875f, 0.00569432f, 
    -0.03517617f, -0.01805241f, -0.04095569f, -0.01689216f, -0.01218396f, 0.00235715f, -0.03267486f, 0.00044201f, 
    -0.02781283f, -0.00485673f, -0.00319328f, -0.02112967f, -0.02976752f, -0.01870050f, 0.00652333f, 0.02224478f, 
    -0.02555586f, 0.00536179f, 0.00281753f, 0.03562256f, 0.01009306f, -0.00900898f, -0.01004838f, -0.02374117f, 
    0.01920098f, -0.02294053f, -0.01073067f, -0.02494819f, 0.00417649f, 0.01165853f, 0.01086110f, -0.02981972f, 
    -0.00642413f, -0.02447824f, 0.01522905f, -0.00111514f, 0.00657490f, -0.04454865f, 0.03115041f, 0.02189650f, 
    0.00518518f, 0.00612442f, -0.02539840f, 0.02016137f, -0.01068444f, 0.02523674f, -0.03392392f, 0.00649253f, 
    -0.03808304f, 0.01775087f, 0.01371297f, 0.01374916f, -0.01591492f, 0.02252149f, -0.02885529f, -0.00375004f, 
    0.03278235f, 0.00152267f, -0.04245367f, 0.00104818f, -0.02657966f, -0.02391455f, -0.04097157f, -0.04393366f, 
    0.00828501f, -0.01421280f, -0.03489036f, -0.00711367f, -0.01239847f, -0.02783302f, 0.01932240f, 0.02362049f, 
    0.02415798f, -0.04535070f, 0.02648249f, 0.02816830f, -0.02005233f, -0.02211491f, -0.01346290f, 0.02156847f, 
    0.00248103f, -0.01074383f, -0.00465117f, -0.00607318f, 0.02804783f, -0.02446872f, -0.03385223f, -0.02844557f, 
    0.01361856f, 0.00581325f, 0.00338201f, -0.00376760f, 0.03349703f, -0.02919677f, 0.03263886f, -0.04154287f, 
    0.02212612f, -0.00788189f, 0.01541267f, -0.03050344f, -0.00973481f, -0.01258120f, -0.00395895f, -0.04061086f, 
    0.01788621f, -0.02039788f, 0.02331001f, -0.02631731f, -0.03121444f, -0.00030640f, -0.02929234f, -0.00974722f, 
    -0.03961680f, -0.04082202f, 0.01689140f, -0.02673770f, -0.02716297f, -0.04194510f, -0.04276358f, 0.02295771f, 
    0.02137159f, -0.01535971f, -0.01521559f, -0.03942912f, -0.00432459f, 0.01335212f, 0.01559765f, -0.02852760f, 
    -0.04065757f, -0.03081073f, 0.00886552f, 0.03071645f, -0.01226240f, 0.02423322f, -0.00368210f, 0.01355864f, 
    -0.02870352f, 0.02018615f, -0.03329263f, 0.00027964f, -0.03709290f, -0.01417855f, -0.02682445f, -0.00141298f, 
    0.00844023f, -0.00370398f, 0.01511644f, -0.04463801f, -0.03973188f, 0.01389147f, 0.00581173f, -0.00460895f, 
    0.02365902f, -0.04375030f, -0.00663990f, -0.02969621f, -0.00677028f, -0.02561208f, 0.02109067f, 0.00397848f, 
    -0.00240104f, -0.03928070f, -0.03503389f, -0.03942388f, 0.02957577f, 0.00775349f, -0.02429695f, 0.01813856f, 
    0.02309044f, -0.02964303f, 0.00142655f, 0.02431092f, -0.02378989f, -0.03479421f, 0.01139210f, 0.00261879f, 
    -0.03395434f, -0.00444796f, 0.01537115f, -0.02169687f, -0.02023711f, -0.00399047f, 0.00605725f, -0.03532698f, 
    -0.01699042f, 0.00638801f, -0.02819557f, -0.01919648f, -0.04079115f, -0.01014600f, 0.00030506f, -0.03438941f, 
    -0.00591330f, 0.01652845f, -0.00365097f, -0.00518938f, 0.01769838f, -0.02300195f, -0.01419209f, 0.03059435f, 
    -0.00650899f, -0.01853153f, 0.03045598f, 0.04416589f, -0.03713911f, 0.01661505f, 0.00386392f, 0.02052059f, 
    -0.00791491f, 0.02602018f, -0.03703275f, 0.00758208f, 0.01852722f, -0.03795138f, -0.04170156f, 0.01038352f, 
    -0.00573225f, -0.01368789f, 0.00725061f, -0.00508537f, -0.02207068f, -0.02461892f, -0.03745719f, 0.00075445f, 
    -0.03872847f, -0.01586944f, -0.02732500f, -0.01109656f, 0.00872240f, -0.00100361f, 0.02521282f, 0.02244921f, 
    -0.03277634f, -0.02080515f, -0.01781421f, -0.03068860f, -0.02546608f, -0.02530057f, 0.00415303f, 0.00505667f, 
    -0.01583420f, -0.03479476f, -0.01400925f, 0.00159732f, -0.04283509f, -0.01613725f, -0.00536234f, -0.00036287f, 
    -0.02242099f, -0.03592758f, -0.03733012f, 0.01615437f, -0.00885376f, 0.01398322f, -0.00491707f, -0.03473304f, 
    -0.03038412f, -0.00100465f, -0.00064337f, 0.03092019f, 0.02662395f, 0.02689906f, -0.02770602f, 0.01144787f, 
    0.01661789f, 0.03201614f, 0.00053114f, -0.03767582f, 0.01100591f, 0.01428958f, -0.00330040f, -0.03579774f, 
    -0.00780645f, -0.03795003f, -0.04354988f, -0.00788958f, 0.01850072f, -0.03926361f, -0.00073229f, -0.01130195f, 
    0.02958957f, 0.02383634f, -0.03718879f, -0.03780256f, 0.01887295f, -0.01881291f, -0.00014225f, -0.01266313f, 
    0.01660590f, -0.03596942f, -0.03854978f, 0.00602222f, -0.04175300f, -0.01757951f, 0.01032134f, 0.01726282f, 
    0.02865018f, -0.02298217f, -0.03564746f, 0.01059122f, -0.01458041f, -0.00875887f, 0.03000829f, 0.00780552f, 
    0.02800574f, 0.02192566f, -0.01321722f, 0.00089047f, -0.02871573f, 0.01243452f, -0.01905473f, -0.04219445f, 
    -0.01916249f, 0.00342328f, 0.02660232f, -0.00570061f, -0.02954051f, -0.04340074f, 0.00805681f, 0.02705649f, 
    0.02755850f, -0.02543085f, 0.02297513f, 0.01596162f, 0.01528071f, 0.01713280f, -0.02792842f, -0.01229285f, 
    -0.03166702f, -0.03564557f, 0.02490564f, 0.02309392f, 0.00244506f, 0.02790255f, 0.02458911f, -0.02713315f, 
    -0.00627765f, -0.01421777f, 0.00409195f, 0.02389890f, 0.00854528f, -0.03796905f, -0.02556200f, 0.00344774f, 
    0.02983916f, -0.03938270f, -0.03964001f, 0.00980082f, -0.02502385f, 0.02267330f, -0.00178654f, 0.02595961f, 
    -0.01235935f, -0.03524798f, 0.01089764f, -0.01202034f, 0.02630364f, -0.02670233f, -0.03007820f, -0.02068139f, 
    -0.04518952f, -0.04256004f, -0.02439530f, 0.03067877f, 0.00625837f, -0.03758298f, 0.03237374f, -0.00458640f, 
    0.01357458f, 0.02337379f, -0.02180768f, 0.00631273f, 0.00927987f, 0.03046891f, -0.02088597f, -0.03783570f, 
    -0.04435075f, -0.02176485f, 0.02114187f, 0.00842787f, 0.01837319f, 0.03295315f, 0.00711834f, 0.00414051f, 
    0.01355507f, 0.02090813f, 0.01787075f, -0.02177327f, -0.02137144f, 0.02735269f, 0.02494986f, -0.03813517f, 
    -0.02333671f, 0.01105147f, -0.03234935f, 0.02870278f, -0.02431877f, 0.02874075f, 0.02453431f, -0.01995358f, 
    -0.02739632f, -0.03069271f, -0.02066443f, -0.02635394f, -0.00059202f, -0.02837914f, -0.02441034f, -0.02084443f, 
    0.02919380f, 0.01190941f, -0.04190867f, -0.02455483f, -0.01442566f, -0.01857771f, -0.04196513f, 0.00192275f, 
    0.02433445f, 0.02580503f, 0.00366631f, -0.03857464f, -0.01055633f, 0.00578938f, 0.00863490f, -0.01798322f, 
    0.00366399f, 0.01513046f, -0.03536119f, -0.02732679f, -0.03748676f, 0.00549662f, -0.03351955f, 0.01211404f, 
    -0.00850594f, 0.01947169f, -0.01588946f, -0.03345830f, -0.02967767f, 0.01331831f, -0.00025284f, 0.03264924f, 
    0.01224079f, 0.03896214f, 0.00712632f, -0.01467396f, -0.03187536f, -0.01870211f, 0.00308956f, -0.02666653f, 
    -0.00534326f, -0.02210615f, -0.03396795f, -0.02144593f, -0.02300481f, -0.02379306f, -0.03118260f, -0.01911055f, 
    -0.00901240f, -0.02190829f, -0.03980178f, 0.01491930f, 0.00804332f, -0.04254403f, 0.00442520f, -0.00958495f, 
    0.01475978f, -0.02734595f, -0.00660152f, -0.03480256f, -0.01484113f, -0.03084869f, 0.01985553f, 0.01904043f, 
    -0.01939713f, 0.01561499f, 0.01556651f, 0.03268942f, -0.00344437f, 0.00009965f, -0.02146544f, 0.01700533f, 
    -0.00130796f, 0.02176804f, 0.02085173f, -0.04446986f, -0.03510090f, -0.01673899f, 0.01247920f, -0.03963439f, 
    -0.02338954f, -0.01166148f, 0.00155621f, 0.01659947f, -0.00698361f, 0.02376547f, -0.01215652f, -0.00454394f, 
    0.01356077f, 0.02645749f, -0.02245635f, -0.00675563f, 0.00968121f, 0.00384972f, 0.02412315f, 0.00320606f, 
    -0.01266894f, 0.00996431f, -0.01030015f, -0.00189802f, 0.00128878f, -0.01860424f, 0.03157542f, -0.02016159f, 
    0.01400033f, -0.00237247f, 0.00365807f, 0.02758080f, 0.02989014f, 0.01608652f, -0.01694872f, 0.03184935f, 
    0.01312889f, 0.00069516f, -0.04183213f, -0.02416086f, 0.02014690f, -0.02163824f, 0.00547513f, -0.02247020f, 
    -0.03277747f, 0.03244201f, -0.03850506f, -0.03374862f, 0.00621382f, -0.00217488f, -0.03458004f, -0.02669818f, 
    0.01433860f, -0.03299684f, -0.01848384f, -0.02518936f, 0.00920616f, -0.04227094f, -0.00971844f, -0.00394668f, 
    0.00938809f, -0.02578771f, 0.02678223f, 0.02158803f, -0.04359035f, 0.03187940f, 0.02837054f, 0.01204925f, 
    -0.03464581f, 0.00973641f, -0.03321294f, 0.03073383f, -0.04240943f, -0.01568833f, -0.04541800f, 0.01609871f, 
    -0.02089211f, -0.03425476f, 0.01959718f, 0.00493830f, 0.00437066f, -0.04317626f, 0.03282633f, 0.00218042f, 
    -0.00200337f, -0.02261754f, -0.00469703f, -0.02061373f, -0.04007929f, 0.01447771f, 0.02923923f, -0.00263051f, 
    -0.03581567f, 0.02225702f, -0.02357652f, -0.04027243f, 0.02678598f, -0.02324300f, -0.02367532f, -0.03214798f, 
    0.02930261f, -0.03442036f, 0.01567166f, -0.01824519f, -0.00240883f, 0.02924218f, 0.00635991f, 0.01402900f, 
    -0.00397025f, 0.01931565f, 0.01342603f, 0.01051063f, 0.00051105f, -0.04070589f, 0.02554025f, -0.04042504f, 
    -0.02832375f, -0.01931365f, -0.02242304f, -0.01912691f, -0.02479582f, 0.02747389f, -0.01987650f, -0.01660495f, 
    -0.04309949f, -0.02498938f, 0.01988832f, -0.02529128f, -0.03711293f, -0.01407933f, 0.03002916f, 0.01153652f, 
    -0.00833437f, -0.02907078f, -0.01137953f, -0.00304405f, 0.03036138f, 0.02996334f, 0.00029132f, -0.00938721f, 
    0.01078784f, 0.00434030f, 0.01961692f, 0.02331044f, -0.00188717f, -0.03156054f, 0.00076278f, 0.02205233f, 
    0.00672388f, 0.00736145f, -0.02072007f, 0.02405525f, -0.00168103f, 0.00805463f, -0.02483141f, 0.02342929f, 
    -0.04279746f, -0.04225788f, 0.00198652f, -0.04380746f, -0.00296501f, 0.00256588f, -0.03026603f, -0.03242006f, 
    0.01482904f, -0.00678723f, -0.02652176f, -0.00990027f, -0.01034851f, 0.01095799f, -0.00296225f, -0.01472946f, 
    -0.01981468f, 0.01330198f, 0.02518819f, -0.02721534f, -0.00097353f, 0.01410350f, -0.00955768f, 0.00928940f, 
    0.02424589f, 0.00267781f, 0.02902959f, -0.01192844f, -0.04431286f, 0.02416556f, -0.03700194f, 0.02766009f, 
    0.02526708f, -0.00971892f, 0.01980073f, 0.02714104f, 0.03214424f, -0.03157810f, 0.00764315f, -0.01560874f, 
    -0.03234841f, -0.02558287f, -0.04548372f, -0.03784802f, -0.01629070f, -0.01162740f, 0.00432352f, -0.01829088f, 
    -0.02008883f, 0.02810196f, -0.03468481f, 0.00051983f, -0.04383548f, -0.01717524f, -0.01071252f, 0.01662965f, 
    -0.04030303f, -0.03208654f, 0.00468714f, -0.02471070f, -0.02294547f, -0.00588521f, -0.02014345f, 0.02090737f, 
    -0.02147717f, -0.01054998f, -0.00891892f, -0.02665515f, -0.00944366f, 0.02328769f, -0.03098740f, -0.03274821f, 
    -0.01450216f, -0.02403130f, 0.01579884f, 0.02348704f, -0.01472871f, -0.01193623f, 0.01757876f, -0.04260364f, 
    -0.03527327f, -0.00445193f, 0.01711343f, 0.00650095f, -0.02878576f, 0.01548008f, -0.03802011f, 0.01212816f, 
    -0.04260882f, 0.02744123f, -0.02488946f, -0.00749045f, -0.04291683f, -0.00433142f, 0.02136809f, -0.00950542f, 
    -0.02669469f, -0.03419278f, -0.00981631f, -0.04417143f, 0.00927466f, 0.02471626f, 0.00926884f, -0.03482309f, 
    -0.03166993f, -0.01334896f, 0.03094581f, 0.03119722f, -0.04437146f, 0.01226397f, -0.03176924f, -0.02733112f, 
    -0.00712810f, 0.00033885f, -0.03525399f, 0.02122968f, -0.00493672f, 0.01122563f, 0.01127809f, 0.02028284f, 
    0.00414287f, 0.01390313f, 0.01407144f, -0.00209594f, -0.02110778f, 0.01428291f, -0.00181803f, 0.02644719f, 
    -0.02082300f, -0.03364336f, 0.00888126f, 0.02230061f, -0.00551060f, 0.00117486f, -0.01909479f, -0.00381745f, 
    0.01317187f, 0.00196502f, 0.00441336f, -0.01945085f, -0.01479111f, 0.02463782f, 0.02754330f, 0.01309488f, 
    -0.03527611f, -0.02404884f, 0.02052757f, -0.01834995f, -0.00137290f, 0.01324762f, -0.00841072f, -0.03090645f, 
    -0.02813491f, -0.01384910f, -0.01187365f, 0.01898242f, 0.01137809f, -0.00085339f, 0.01189883f, -0.00556016f, 
    0.00612922f, -0.01291264f, 0.01988584f, 0.02247433f, -0.00368239f, 0.01230371f, -0.03969032f, -0.04012749f, 
    -0.02711952f, -0.01871963f, -0.01715394f, -0.04086759f, -0.00567599f, -0.00505169f, -0.04284675f, -0.00178365f, 
    0.00646017f, -0.00622622f, -0.00878627f, 0.02951010f, -0.04494023f, 0.03149050f, -0.00779196f, -0.03983243f, 
    -0.00875626f, -0.00338670f, -0.00372814f, 0.01100341f, -0.01337070f, -0.00985461f, -0.04030935f, 0.00561319f, 
    -0.02772647f, -0.03597659f, -0.02037103f, -0.00883181f, 0.00647496f, -0.01110743f, -0.04170739f, -0.03381506f, 
    -0.01007803f, 0.03043833f, -0.01011615f, 0.02171253f, -0.03138045f, -0.01205333f, 0.03327096f, -0.01957588f, 
    -0.02045559f, 0.03310394f, 0.02278157f, -0.03967590f, 0.01187835f, -0.02264119f, -0.01318414f, -0.00135854f, 
    -0.00233577f, 0.00785592f, 0.00630874f, 0.04531869f, 0.04251816f, 0.00746349f, -0.03225106f, 0.01624815f, 
    -0.02865884f, 0.00055597f, -0.03490673f, -0.01031320f, 0.00341486f, 0.00590534f, -0.04039519f, -0.04436702f, 
    -0.02814906f, -0.04496014f, 0.01587139f, 0.03070000f, 0.03570496f, -0.01727265f, -0.02631359f, 0.00679213f, 
    -0.01642484f, 0.02130066f, -0.00207663f, 0.03146814f, -0.01567158f, -0.02329376f, 0.00002238f, 0.01361282f, 
    -0.02967404f, -0.03669009f, -0.03232758f, -0.03022269f, 0.01837506f, 0.00821537f, -0.02537941f, -0.01968431f, 
    0.00191305f, 0.02882094f, 0.02783260f, 0.02940466f, 0.01096578f, -0.04521665f, 0.00887964f, 0.00999991f, 
    -0.03740676f, -0.03652966f, 0.03297453f, -0.02564997f, 0.00700070f, -0.02847716f, 0.03323476f, 0.00618771f, 
    -0.01958140f, 0.03182195f, 0.01079534f, 0.02793690f, -0.01612298f, -0.04103355f, -0.00365844f, 0.01720171f, 
    0.01544513f, 0.00392446f, -0.04051694f, 0.02914052f, -0.02479477f, -0.00152848f, 0.03926459f, -0.03855372f, 
    -0.02609053f, 0.00504825f, 0.03254984f, 0.01189225f, -0.03577510f, -0.02378575f, -0.02866823f, -0.01336812f, 
    -0.01629187f, -0.02289440f, -0.03448877f, 0.03411810f, 0.01294822f, 0.01533753f, -0.02346914f, -0.02815923f, 
    0.02126002f, -0.02425174f, -0.00520824f, -0.04401318f, -0.03707209f, -0.02446110f, -0.01982564f, 0.01028053f, 
    0.02910327f, -0.01950266f, 0.02690901f, 0.01623557f, -0.04625984f, -0.02277818f, -0.04050663f, 0.02135885f, 
    0.00883056f, -0.00928593f, -0.03141013f, 0.00747098f, 0.02279224f, 0.01926960f, -0.04360164f, -0.00638643f, 
    0.01397149f, 0.02541789f, 0.02763209f, -0.03991210f, 0.01504612f, -0.04537039f, -0.03706357f, 0.01771598f, 
    -0.03239120f, -0.01104651f, -0.01636841f, -0.04302696f, -0.04849593f, -0.03229610f, -0.01104012f, 0.01488454f, 
    -0.02498861f, 0.01881232f, -0.02314981f, 0.02563267f, -0.02392143f, 0.03025475f, -0.03229678f, 0.02596075f, 
    -0.03018103f, 0.00702591f, -0.02589602f, -0.01783516f, 0.00411719f, -0.02565064f, 0.01883459f, 0.00671850f, 
    0.00971596f, -0.02875189f, 0.00692841f, 0.03190911f, -0.00423332f, -0.04055321f, 0.00258394f, 0.00356154f, 
    0.00139467f, -0.00128685f, -0.00546894f, -0.02370561f, -0.04567077f, 0.01099975f, -0.00669607f, 0.02359581f, 
    0.00576476f, -0.00149108f, 0.04534169f, -0.02637494f, -0.04377899f, -0.00949886f, -0.02339276f, -0.04028957f, 
    0.02758186f, -0.03674240f, 0.02695124f, 0.00077510f, -0.03081346f, -0.01262234f, -0.01173021f, -0.03683038f, 
    -0.03283057f, 0.00753128f, -0.00090524f, -0.00232444f, 0.01687119f, 0.03660750f, -0.03082549f, -0.02166543f, 
    -0.00769756f, -0.00829018f, -0.02966822f, 0.00640679f, 0.02457477f, -0.03007318f, 0.02896115f, -0.01363653f, 
    0.01753891f, -0.00430496f, -0.01673266f, -0.02529870f, -0.00184629f, 0.02268481f, 0.00881663f, -0.00262558f, 
    0.00653849f, 0.01910107f, -0.03918445f, -0.04241281f, -0.01780544f, -0.02739595f, -0.03695497f, -0.02421062f, 
    -0.01915744f, 0.01219925f, 0.02061164f, 0.00563018f, 0.00845786f, -0.04594866f, 0.02136722f, -0.04164629f, 
    -0.02815408f, 0.02133909f, -0.01840095f, -0.03431793f, -0.02230217f, -0.01422501f, 0.01980807f, -0.02903898f, 
    0.01227894f, 0.03984327f, 0.04647388f, 0.01557389f, 0.02128296f, -0.01397734f, 0.02949725f, -0.00245881f, 
    -0.00525788f, -0.04219339f, 0.00139222f, 0.01432285f, -0.03832428f, -0.04747340f, -0.03859938f, 0.01985045f, 
    0.01640199f, 0.03529774f, -0.01999047f, -0.04436774f, 0.02605405f, 0.02425220f, 0.00538543f, 0.00984562f, 
    0.02758908f, -0.04097904f, 0.00331436f, -0.02806040f, -0.02365406f, 0.01087769f, -0.04727525f, -0.01626752f, 
    -0.02273364f, -0.04524375f, -0.00087589f, 0.00507630f, -0.00592522f, -0.00514037f, -0.03904863f, -0.04028127f, 
    0.01907777f, -0.04171688f, -0.04346508f, -0.00786407f, -0.02846236f, 0.01254009f, -0.01091502f, -0.03620865f, 
    -0.01583724f, -0.01254796f, -0.02805066f, -0.00842143f, -0.03348615f, -0.03777901f, 0.01695882f, 0.01776310f, 
    0.00956062f, 0.03915590f, -0.00415554f, 0.03122809f, -0.00948822f, 0.02945205f, 0.02879746f, -0.03613133f, 
    0.00414260f, 0.01723171f, -0.03015430f, -0.02760383f, 0.02170118f, -0.01287381f, 0.00262108f, -0.00606690f, 
    0.00934284f, 0.02528299f, 0.00629790f, -0.03834257f, 0.02826032f, -0.04736876f, 0.01171837f, -0.00866491f, 
    -0.01771750f, -0.03661040f, -0.01938250f, 0.01254227f, -0.02342149f, -0.03170860f, -0.01991244f, -0.03618882f, 
    0.01477141f, 0.02220036f, -0.04025617f, 0.01623636f, -0.03524795f, 0.00804746f, -0.03594219f, 0.02250254f, 
    0.00226661f, 0.01442024f, -0.02828703f, -0.02757950f, 0.02598098f, 0.03232665f, 0.01217566f, 0.02937468f, 
    0.02579981f, -0.02126325f, 0.00588501f, -0.02354160f, 0.00648720f, -0.00805939f, 0.01069599f, -0.01527098f, 
    0.02172331f, -0.00299444f, -0.02498302f, -0.01973459f, 0.01711516f, 0.00197197f, -0.00050875f, 0.00682766f, 
    0.00894316f, -0.01809956f, 0.02510944f, 0.02863273f, 0.01331886f, 0.02629344f, -0.02195198f, 0.03559903f, 
    -0.00114050f, -0.00388692f, -0.01059420f, 0.01057217f, -0.03161136f, -0.03947864f, -0.01877361f, 0.01833235f, 
    -0.03416865f, -0.03016244f, -0.01527039f, 0.00000204f, -0.01616713f, -0.03247904f, 0.02221462f, 0.01459658f, 
    0.00209542f, -0.02552236f, -0.03135287f, -0.00530777f, 0.00204725f, 0.00037651f, -0.02884344f, -0.03514230f, 
    -0.03921099f, -0.02037442f, 0.02309875f, 0.00730825f, -0.00118167f, -0.03351226f, -0.03970679f, 0.00368970f, 
    -0.02805640f, -0.04064602f, 0.00522064f, 0.00829803f, 0.02532172f, 0.01218542f, 0.02983988f, 0.00497812f, 
    -0.00488248f, -0.03314613f, 0.01726082f, -0.03471059f, -0.01023826f, -0.01343529f, -0.02807580f, -0.01877932f, 
    -0.03122189f, 0.00597122f, 0.03968380f, 0.01948816f, -0.02588334f, 0.02617551f, -0.01480955f, 0.00798204f, 
    0.02224035f, -0.04270633f, -0.00161463f, -0.03632405f, 0.00857784f, 0.01528175f, -0.01001999f, -0.01786070f, 
    -0.00954229f, 0.00359925f, 0.02003375f, -0.00835053f, 0.03680138f, 0.02686992f, -0.02955417f, -0.00866919f, 
    -0.00956164f, 0.01045801f, 0.00937847f, -0.02672564f, -0.00882390f, 0.00828827f, -0.03581901f, -0.01200615f, 
    -0.01818528f, 0.01743760f, -0.00424378f, -0.01726938f, -0.04652481f, 0.01411706f, 0.02893766f, -0.02260606f, 
    -0.02154884f, -0.01324624f, -0.02583470f, -0.03705351f, -0.00913339f, -0.00694698f, 0.00756093f, 0.00181010f, 
    -0.01179185f, 0.01893708f, -0.03780238f, 0.00152234f, -0.00990183f, 0.00385821f, -0.00092219f, -0.02027113f, 
    0.02001656f, -0.04439836f, -0.02033826f, 0.01835490f, -0.02103291f, -0.01080651f, 0.00473209f, -0.02844398f, 
    0.00751385f, 0.00658932f, 0.02383635f, 0.00939194f, -0.00491851f, -0.01220201f, -0.03363664f, 0.02807019f, 
    -0.03271654f, -0.03325009f, 0.02891330f, -0.03418964f, -0.01410983f, -0.01602032f, 0.01074598f, -0.02623964f, 
    -0.00806815f, -0.02399123f, -0.01587283f, -0.00578397f, 0.03533330f, -0.04684688f, 0.01546142f, 0.01820540f, 
    0.02687759f, -0.00334007f, -0.04921050f, 0.01681713f, 0.02844559f, -0.00997134f, -0.02863655f, -0.00257144f, 
    -0.00576318f, -0.03099744f, 0.02808252f, -0.00334415f, 0.00927673f, 0.02311018f, -0.04416281f, -0.03321852f, 
    -0.04203408f, -0.01095592f, -0.00041384f, -0.01553699f, 0.02763867f, 0.02591077f, -0.02576090f, 0.00617835f, 
    -0.02442450f, -0.03941042f, -0.02534031f, 0.00787777f, 0.00986283f, 0.02966208f, -0.03037601f, -0.02635676f, 
    -0.01574909f, -0.02569544f, -0.02253186f, -0.02497947f, 0.03228017f, 0.02603490f, -0.02458532f, -0.02222443f, 
    0.01408398f, 0.02238593f, 0.02870220f, 0.00382672f, 0.01615752f, -0.02359753f, 0.02019174f, -0.01885045f, 
    -0.01061255f, -0.01938737f, -0.01775317f, -0.01225590f, 0.02706816f, -0.04753041f, -0.02377766f, 0.02695622f, 
    -0.03201344f, 0.00742545f, -0.01373780f, -0.01881554f, -0.02586412f, -0.04036492f, -0.03306472f, -0.01599308f, 
    0.00848983f, 0.03685657f, -0.03151350f, 0.00402170f, -0.01718142f, -0.03148954f, -0.01506301f, 0.02826725f, 
    -0.02457177f, -0.01601596f, -0.01580568f, -0.01184386f, 0.00074787f, -0.03063920f, 0.01568911f, 0.02098755f, 
    0.03132001f, -0.04376094f, 0.00427403f, -0.01355182f, -0.01948401f, -0.03690892f, -0.00889593f, -0.01618439f, 
    0.02461929f, 0.00801589f, -0.00627994f, 0.02508498f, -0.02689394f, -0.03628507f, 0.03127448f, -0.03591701f, 
    -0.01544077f, 0.00516398f, -0.02434219f, -0.00314389f, 0.01452300f, -0.02397368f, -0.04218801f, -0.01739273f, 
    0.01956174f, -0.03926506f, 0.02302412f, -0.02568111f, 0.01190753f, -0.01378219f, 0.01121195f, 0.02176652f, 
    0.03082216f, -0.02237291f, 0.00661122f, 0.00459750f, 0.00785227f, 0.03613953f, 0.01161571f, 0.02780535f, 
    -0.01293917f, -0.00476824f, -0.02296561f, -0.01111693f, -0.02812608f, -0.02415465f, -0.02455085f, 0.01793106f, 
    0.02703023f, 0.03221987f, -0.02907298f, -0.00463239f, 0.00822297f, -0.00994322f, -0.03612611f, -0.02970052f, 
    0.02792352f, 0.01288252f, -0.04060135f, -0.02287845f, -0.00203530f, -0.04206555f, -0.01210687f, -0.04062885f, 
    -0.01726073f, -0.01048790f, -0.01611008f, 0.03602320f, -0.01022117f, -0.03205801f, -0.00912811f, -0.03230697f, 
    -0.03327437f, 0.02825112f, -0.02242386f, -0.04390320f, 0.00242028f, 0.00544682f, -0.02702280f, 0.00123502f, 
    -0.04104757f, -0.01307563f, -0.02608814f, -0.03830542f, -0.03883915f, 0.02216159f, -0.02819707f, 0.00551380f, 
    0.02022995f, -0.00187004f, -0.03984683f, 0.02233021f, -0.00371879f, -0.00030274f, -0.02456620f, 0.01198255f, 
    -0.03105335f, 0.02799837f, 0.01620450f, 0.01689192f, 0.00749552f, 0.00836619f, -0.03403736f, 0.00018973f, 
    0.01511090f, 0.03712548f, 0.00483638f, 0.01208533f, -0.04198055f, -0.02796549f, -0.04826421f, -0.03079986f, 
    -0.01408266f, -0.03620056f, 0.02153234f, 0.00363895f, -0.03203024f, 0.02710965f, -0.02926583f, 0.00459931f, 
    0.01284897f, -0.01221536f, -0.00811192f, -0.01776870f, -0.04372546f, -0.04786236f, -0.00669014f, 0.01958295f, 
    -0.03380214f, 0.00148099f, 0.03613228f, 0.03208945f, -0.03854840f, -0.02751279f, 0.03473443f, -0.03701870f, 
    -0.02933224f, -0.01954649f, -0.03137597f, 0.03194947f, 0.01327151f, 0.01051845f, -0.01240876f, 0.02627254f, 
    -0.03406209f, 0.01812945f, 0.01241652f, 0.02552850f, 0.03712954f, -0.03919458f, -0.03263351f, 0.02004000f, 
    -0.03082819f, 0.01999830f, -0.00412057f, -0.03831499f, -0.01317850f, 0.02752283f, -0.01083861f, 0.01674129f, 
    -0.04635655f, -0.00116172f, -0.00546695f, -0.04300595f, -0.00352692f, 0.02468386f, -0.03937369f, 0.01369063f, 
    0.02338681f, -0.04774895f, -0.01302016f, 0.02679637f, -0.03782830f, 0.03185838f, -0.01689188f, 0.02493198f, 
    0.02697713f, 0.00986429f, -0.02843728f, -0.04454766f, 0.01841858f, 0.02799287f, -0.03231691f, 0.02850931f, 
    0.02401182f, -0.03871901f, -0.01573842f, 0.02074239f, 0.02395172f, -0.01312872f, -0.04085910f, 0.00114374f, 
    0.01643264f, -0.01201447f, 0.00473849f, -0.02200907f, -0.02041674f, -0.04382754f, -0.02682434f, -0.02202035f, 
    -0.01188934f, -0.03353705f, -0.03483821f, -0.00623224f, -0.01491357f, -0.03283065f, -0.01904037f, 0.02487124f, 
    0.00341217f, -0.03089545f, -0.01074703f, -0.01121740f, 0.00991805f, 0.02782587f, -0.00822209f, -0.01528895f, 
    0.01425023f, 0.00424829f, 0.00748169f, -0.01373417f, -0.03823739f, 0.03751526f, -0.03246845f, -0.01191883f, 
    -0.01430266f, -0.01666674f, 0.00731182f, 0.02306772f, 0.01906759f, 0.00860565f, 0.00294567f, -0.03501168f, 
    -0.01457132f, -0.01355766f, -0.04309838f, -0.01267380f, 0.03115092f, -0.00347609f, 0.00635417f, 0.02140104f, 
    0.02086190f, 0.02259749f, -0.02901032f, 0.00920405f, -0.04183571f, 0.02251966f, -0.00649913f, 0.00543503f, 
    0.01820438f, 0.00269588f, -0.01339154f, -0.00266853f, -0.02359385f, -0.02019960f, 0.00747810f, 0.02746373f, 
    0.01695203f, -0.02002564f, -0.02059442f, -0.03454500f, 0.00304779f, -0.01290180f, -0.02406117f, 0.00533872f, 
    0.00673278f, 0.01604445f, -0.03802821f, -0.03067093f, 0.00672809f, -0.02383927f, -0.03870158f, -0.00305395f, 
    0.01557584f, 0.02130321f, -0.04004000f, -0.00056401f, 0.00589960f, 0.00648756f, -0.00591158f, 0.00509428f, 
    -0.00243770f, -0.01987451f, -0.02164797f, 0.01060961f, -0.03330304f, -0.03589519f, 0.00971147f, 0.01139289f, 
    0.01738266f, 0.00773223f, -0.02160143f, 0.02894336f, -0.01851704f, -0.00035562f, -0.00754549f, -0.03224478f, 
    -0.04745938f, -0.01309466f, -0.03661860f, 0.02782984f, -0.04535801f, -0.02431876f, -0.04525842f, -0.01171790f, 
    -0.00460833f, -0.00088473f, -0.01124575f, 0.00240426f, -0.02718344f, 0.01463779f, -0.02134517f, 0.02930426f, 
    -0.01837908f, -0.04764480f, 0.01632174f, -0.04009195f, -0.02299748f, -0.02218489f, 0.01438724f, -0.00556848f, 
    0.02740372f, -0.01841818f, 0.02288376f, -0.03578423f, -0.01075346f, -0.01437051f, 0.01230020f, 0.02624343f, 
    0.00804504f, 0.02330455f, -0.03771756f, 0.01249271f, -0.01982133f, -0.01300015f, -0.03551668f, 0.02972138f, 
    0.01897562f, 0.00599738f, 0.02205861f, 0.02472131f, 0.01529334f, 0.01284773f, -0.00658664f, 0.01134566f, 
    0.00540709f, 0.00653357f, 0.01609934f, -0.00885542f, -0.00646091f, -0.01983638f, 0.00372726f, 0.00171241f, 
    0.01262695f, 0.01949074f, -0.00221692f, 0.02115560f, -0.02729768f, -0.01603870f, -0.02371918f, -0.01049301f, 
    -0.01403185f, -0.01084264f, -0.03898006f, -0.00478461f, -0.04374900f, -0.00412390f, -0.00130166f, 0.01871374f, 
    0.00238883f, -0.00011551f, -0.04842579f, -0.01895442f, -0.04016175f, -0.01334692f, 0.02418423f, -0.03115946f, 
    -0.01346914f, 0.00145488f, 0.01437754f, -0.03862631f, 0.03080410f, 0.01294915f, 0.02455916f, -0.02106509f, 
    -0.02634778f, 0.00840137f, 0.02861071f, -0.04665664f, -0.01628014f, -0.00161959f, -0.03522930f, 0.00694134f, 
    0.00150659f, 0.00705869f, 0.01515727f, 0.01667873f, -0.00977499f, -0.00792228f, -0.04637552f, -0.03518158f, 
    0.00046704f, 0.01384794f, -0.01918905f, -0.02114457f, -0.03354309f, -0.02089306f, 0.01695669f, -0.04764950f, 
    0.02094983f, -0.04217473f, -0.02222266f, -0.01489724f, 0.01068218f, 0.00832461f, -0.03901920f, 0.01449067f, 
    0.02879907f, 0.00328249f, 0.01601952f, -0.01119390f, -0.01112821f, -0.00479107f, -0.03523846f, 0.01848197f, 
    0.00529853f, -0.01127161f, 0.02028843f, -0.04120209f, -0.00985493f, -0.02787357f, -0.03884982f, 0.02584509f, 
    0.00746365f, -0.02508675f, -0.01390120f, 0.01015557f, 0.00584459f, -0.02456267f, 0.01270496f, 0.01418933f, 
    0.01858219f, -0.04412053f, 0.00312544f, -0.00671444f, -0.04408855f, -0.02307222f, -0.01577501f, -0.04514180f, 
    -0.04768648f, -0.03611712f, 0.01416771f, -0.01484438f, -0.00940382f, -0.02847568f, 0.02735570f, 0.01368423f, 
    0.02673966f, -0.02483549f, -0.02971165f, 0.01601551f, -0.00727925f, -0.01172239f, -0.02992825f, -0.00771557f, 
    0.02282192f, 0.00491370f, 0.00754818f, -0.01370105f, -0.02134544f, -0.00142291f, -0.01298101f, 0.00664835f, 
    -0.02375441f, 0.00078349f, -0.04446834f, 0.01326637f, 0.00121722f, -0.01032072f, -0.00567007f, 0.02426995f, 
    0.02030921f, 0.03131815f, -0.02745530f, 0.02399356f, 0.02757889f, -0.01263391f, -0.04687833f, 0.00990281f, 
    -0.01140177f, -0.04695338f, 0.00401053f, 0.00083225f, -0.00958454f, -0.00289875f, -0.03210501f, -0.00662790f, 
    -0.00818256f, 0.00659023f, -0.00191630f, 0.02015185f, -0.04830924f, -0.00869420f, 0.01619979f, 0.00754624f, 
    0.02657453f, 0.02224101f, -0.02162373f, 0.02822536f, -0.03403084f, -0.04445338f, -0.02267832f, -0.03502064f, 
    -0.01721419f, 0.01873782f, 0.03323398f, 0.03410670f, -0.00793972f, -0.02976975f, -0.00991539f, 0.01942646f, 
    0.01934799f, -0.00684326f, -0.04131145f, -0.02506585f, -0.03172760f, -0.03743182f, 0.02607166f, -0.02774084f, 
    -0.01545355f, -0.01531477f, -0.02401810f, 0.01056123f, -0.02611960f, 0.00992577f, 0.02505640f, 0.02632930f, 
    -0.02157948f, -0.00818490f, -0.01384371f, -0.02666655f, 0.02645505f, 0.03027667f, 0.01609172f, -0.00326170f, 
    -0.03554292f, 0.02582963f, -0.04555383f, -0.04330663f, 0.00441361f, -0.00116418f, -0.03977394f, -0.01806026f, 
    -0.01860610f, 0.02983273f, 0.02955367f, -0.00446535f, -0.04582876f, -0.02736825f, -0.01746647f, -0.00303707f, 
    -0.02949092f, -0.04558637f, 0.00994561f, -0.00530259f, 0.02112620f, -0.04353804f, 0.00416455f, -0.00396459f, 
    -0.03824353f, -0.00068231f, 0.00257119f, -0.00631062f, -0.03381302f, -0.02881633f, -0.01106599f, -0.02446348f, 
    0.03687925f, 0.01109075f, -0.04756951f, -0.03495335f, -0.01642941f, 0.01050710f, 0.00210475f, -0.00721367f, 
    0.00187767f, -0.01312242f, -0.01255691f, -0.02940813f, -0.03974954f, -0.03800372f, -0.00784253f, -0.01532050f, 
    -0.03138141f, -0.03456591f, 0.00742697f, -0.01232384f, 0.00938819f, 0.01520558f, -0.00309540f, -0.03996679f, 
    -0.01289944f, 0.02985886f, -0.03395833f, -0.00593421f, 0.02302972f, -0.02778390f, -0.01325255f, -0.01498274f, 
    0.00862903f, 0.01344264f, -0.04017439f, 0.01525496f, -0.04752620f, -0.04673792f, -0.02413770f, 0.02120953f, 
    -0.04202233f, -0.04940509f, 0.01859052f, -0.03888565f, -0.04060287f, -0.03851893f, 0.02980994f, 0.03107190f, 
    -0.01572591f, -0.01340014f, -0.02837490f, -0.02122195f, 0.02559616f, -0.01842941f, 0.03122829f, -0.04754661f, 
    0.01667815f, 0.01901408f, -0.03539104f, -0.02897684f, 0.00617473f, -0.04283664f, 0.02524338f, 0.02292886f, 
    0.00209436f, 0.02328612f, -0.01812425f, 0.02374200f, 0.01288533f, 0.00014639f, -0.04138236f, -0.00573941f, 
    0.00868523f, -0.01966032f, -0.04061510f, -0.01266535f, -0.00284890f, -0.04551255f, 0.00913100f, -0.00058178f, 
    -0.03437870f, 0.02566907f, 0.01885038f, 0.02547690f, -0.02715518f, -0.00740656f, 0.01485120f, -0.02088685f, 
    0.01344099f, 0.01329923f, -0.03322605f, -0.03395948f, 0.02056927f, -0.04083269f, -0.03501735f, -0.01326963f, 
    -0.03914236f, -0.03214809f, 0.02095436f, -0.02518272f, -0.01091773f, -0.00854494f, -0.00770022f, -0.02462148f, 
    0.02953287f, 0.02284325f, 0.01087027f, 0.02736416f, -0.01744944f, -0.03919535f, 0.01105289f, -0.03897491f, 
    0.02848377f, 0.00905326f, -0.00974229f, -0.04145601f, 0.02341262f, -0.03192220f, -0.01482898f, -0.02167015f, 
    -0.02980703f, -0.03551108f, -0.00002285f, -0.00378131f, 0.02126997f, -0.01786626f, -0.00416601f, -0.01370941f, 
    -0.02510232f, 0.00930925f, 0.02285864f, -0.02736525f, -0.02997590f, 0.02585233f, -0.00478055f, 0.02771318f, 
    0.20106508f, -0.13375466f, 0.06036322f, 0.15797488f, -0.19216724f, -0.03092115f, -0.02444716f, 0.02592274f, 
    0.04840909f, -0.13877288f, -0.08929408f, 0.07896502f, -0.01684881f, 0.11628623f, 0.03314706f, 0.04720553f, 
    -0.08720162f, 0.09223206f, 0.03153302f, 0.13587640f, 0.03221163f, -0.09432791f, -0.02328594f, 0.05727037f, 
    -0.02234992f, -0.06207524f, -0.05299103f, -0.04858848f, -0.00395703f, -0.07765521f, 0.10548288f, 0.09365118f, 
    0.16650684f, 0.01441731f, 0.06819118f, -0.01822592f, 0.01023756f, -0.05416023f, -0.14889941f, -0.08925641f, 
    0.14938827f, 0.47806376f, 0.03774985f, 0.01986276f, 0.13574912f, 0.08133838f, 0.06198909f, 0.05319769f, 
    0.07252909f, 0.20111181f, -0.02907108f, 0.07878393f, -0.01249930f, -0.01722662f, -0.05666021f, -0.08486933f, 
    0.07982882f, 0.05573422f, -0.11312313f, -0.04370029f, 0.17675425f, 0.50313669f, -0.06984258f, 0.07042623f, 
    -0.00372261f, -0.03167581f, -0.08468902f, -0.12636609f, 0.12169999f, 0.30364567f, 0.02644286f, 0.07310834f, 
    -0.00258875f, 0.05450356f, -0.08475121f, -0.05708219f, -0.01053071f, 0.09746996f, -0.09395592f, 0.04950839f, 
    0.13540074f, -0.18495442f, 0.07025032f, 0.18824165f, -0.26521522f, -0.06129834f, -0.04396315f, 0.06415135f, 
    0.10903609f, -0.18556447f, -0.06450450f, -0.02486012f, 0.13320689f, 0.00173472f, 0.03405428f, -0.10322147f, 
    -0.10708193f, 0.08615844f, 0.00688336f, 0.04660703f, -0.20066087f, 0.62774795f, -0.10634409f, -0.28060475f, 
    0.13931330f, -0.00880949f, 0.05838528f, 0.22465149f, 0.05407944f, 0.12088002f, 0.12734076f, -0.01396037f, 
    0.06561875f, -0.12594678f, -0.07994265f, -0.03353005f, 0.01294945f, 0.02519548f, 0.09134714f, 0.08984106f, 
    -0.23182076f, -0.06835002f, -0.43318006f, 0.03916707f, -0.14761305f, 0.05537109f, -0.01409206f, 0.06232452f, 
    0.02412209f, 0.17569585f, 0.26332155f, 0.16632725f, -0.01302307f, 0.07577068f, 0.05506710f, -0.03718317f, 
    -0.02564123f, 0.00407339f, 0.09228981f, -0.07040908f, 0.64834267f, -0.07277849f, -0.22815511f, 0.14314897f, 
    -0.11821225f, -0.02477859f, -0.02277847f, 0.04844966f, 0.11727871f, 0.01861308f, -0.08808740f, 0.00131956f, 
    -0.01489192f, -0.00314649f, -0.02193317f, 0.03583335f, 0.08463020f, -0.06622190f, -0.00125340f, 0.05910437f, 
    -0.36545646f, 0.24817531f, 0.27153942f, 0.02531997f, 0.21195430f, -0.38372266f, 0.07254732f, -0.06932186f, 
    0.02405659f, -0.06397870f, -0.08113616f, 0.02592636f, 0.14695501f, -0.07766848f, -0.10053045f, 0.07129915f, 
    -0.07875040f, 0.11326683f, 0.04050992f, -0.01660985f, -0.01274796f, 0.01811124f, 0.03480354f, 0.10577893f, 
    0.03513473f, -0.13671553f, -0.04736283f, -0.03152753f, -0.08117463f, -0.12030071f, -0.06071833f, 0.07866537f, 
    0.01419190f, 0.02969259f, 0.13507237f, -0.08667307f, -0.01578428f, -0.08676366f, 0.00855875f, -0.00823531f, 
    0.04676234f, 0.41925755f, 0.07714165f, -0.01613916f, 0.12667836f, 0.07413952f, -0.03491685f, 0.14068945f, 
    0.14927344f, 0.28858703f, 0.02677396f, -0.01082309f, 0.02888124f, -0.03034074f, -0.04843451f, -0.10979146f, 
    0.02595986f, 0.04435369f, 0.01670988f, 0.02539808f, 0.17093046f, -0.09107380f, -0.02444677f, 0.04107565f, 
    -0.01103349f, 0.01543757f, -0.05059486f, -0.08882329f, 0.08438754f, -0.11640733f, 0.12887713f, -0.01732752f, 
    0.05940237f, 0.01920545f, 0.05650121f, -0.04969538f, -0.01522156f, -0.08402673f, -0.04033890f, -0.07461835f, 
    -0.15471949f, -0.15747328f, -0.38396588f, -0.21941392f, -0.14370790f, -0.00525720f, -0.02252783f, 0.10587130f, 
    -0.10039636f, -0.12312134f, -0.05841484f, 0.08103897f, -0.04119973f, 0.05417908f, 0.08852385f, -0.07352659f, 
    -0.02579149f, -0.00490263f, 0.08547921f, -0.06328963f, 0.44921568f, 0.26302516f, 0.10491880f, -0.23166347f, 
    -0.06398014f, 0.26010206f, 0.06433078f, 0.09997381f, 0.02828387f, 0.12957518f, 0.12860794f, 0.01939383f, 
    0.04551949f, -0.00851240f, 0.05350680f, 0.03945621f, -0.09775985f, 0.06659573f, 0.10703135f, -0.03315938f, 
    -0.01551513f, -0.11306281f, -0.14162911f, 0.25915882f, -0.28793073f, 0.08069559f, 0.01346209f, -0.00098503f, 
    -0.01887712f, 0.11034078f, -0.05596878f, 0.02221380f, -0.00960747f, 0.10666885f, 0.05991586f, 0.00476138f, 
    0.17809516f, 0.07907373f, 0.07145805f, 0.09820430f, 0.21386950f, 0.25879794f, -0.12965050f, 0.00960028f, 
    0.17154963f, 0.07082985f, 0.00650885f, -0.08945912f, 0.03462746f, 0.19368935f, 0.14817938f, 0.07904123f, 
    0.01197311f, 0.07221047f, 0.00381732f, -0.06166473f, -0.00550532f, 0.06319719f, -0.03897561f, 0.14843641f, 
    0.19167270f, -0.13076214f, 0.11872771f, 0.06273230f, -0.26021540f, 0.09943363f, 0.04659497f, 0.05951788f, 
    -0.20276222f, -0.16112986f, 0.01090982f, 0.14989106f, -0.01111075f, 0.00010705f, 0.03166889f, 0.20875120f, 
    0.08626430f, 0.02755579f, 0.06690437f, -0.01798297f, 0.30338073f, -0.07747193f, -0.08150403f, 0.23997353f, 
    -0.16619967f, 0.16577624f, -0.13410169f, 0.08271531f, 0.13594061f, -0.05667654f, 0.00918492f, -0.07619771f, 
    0.04426200f, -0.08888930f, -0.15124375f, -0.02345122f, 0.10647049f, 0.05397395f, 0.04139379f, 0.00300200f, 
    -0.06581563f, 0.27942964f, 0.17575210f, 0.01635448f, 0.05939706f, -0.16058242f, 0.01031819f, -0.02799748f, 
    0.01670717f, 0.07965995f, -0.09343893f, -0.01963248f, 0.13266781f, -0.05924499f, 0.01999169f, 0.05023424f, 
    -0.10494545f, 0.05962952f, 0.09430508f, -0.02546114f, 0.42453369f, 0.51725107f, -0.02891778f, -0.23958358f, 
    0.17313164f, -0.00521832f, 0.12069041f, 0.06619054f, 0.05535055f, 0.04693160f, 0.04369007f, 0.00901494f, 
    0.10202175f, -0.12272403f, 0.09954850f, -0.06194887f, 0.01024952f, -0.07541990f, -0.03454574f, -0.02714566f, 
    0.40309638f, -0.33834550f, -0.74846041f, 0.07765321f, -0.45365393f, 0.06890474f, -0.05999903f, 0.01751460f, 
    -0.18842192f, -0.13300985f, 0.06379904f, 0.03549102f, 0.09148017f, -0.04078779f, 0.05434345f, 0.00629325f, 
    0.00212171f, 0.02722638f, -0.07934736f, 0.05964399f, -0.49059132f, 0.12618239f, 0.37303525f, -0.17631014f, 
    0.05970677f, -0.01904666f, 0.17802434f, -0.02095675f, -0.06510390f, -0.15057398f, 0.02509099f, 0.03487739f, 
    -0.00361143f, 0.06360120f, 0.01471361f, 0.20772272f, 0.18487002f, 0.06288493f, 0.03623992f, -0.28336248f, 
    0.42787385f, 0.34119985f, 0.23913106f, -0.29393041f, 0.03475555f, 0.12406654f, 0.00248863f, 0.03173371f, 
    -0.00263695f, 0.03182014f, -0.07077499f, 0.08429340f, -0.03505227f, -0.03482464f, 0.16441165f, 0.08222724f, 
    0.00463358f, 0.06888612f, -0.08742311f, -0.08358303f, -0.21561699f, -0.27374178f, -0.06795778f, 0.14807488f, 
    -0.23519902f, -0.01974478f, -0.06957518f, 0.02631813f, 0.10106616f, 0.09909979f, 0.10276730f, 0.05295198f, 
    -0.00352720f, 0.15069756f, 0.11862904f, 0.01100529f, 0.03014568f, 0.00054312f, 0.03038506f, -0.01030605f, 
    0.00653342f, -0.11910812f, 0.06447669f, 0.06980129f, -0.02078045f, -0.03705412f, -0.07140783f, 0.07707386f, 
    0.04220983f, -0.08625789f, -0.04874295f, -0.00718330f, -0.00702213f, 0.00523659f, 0.09154688f, 0.00077108f, 
    -0.08117836f, -0.09930950f, -0.07214468f, 0.04030587f, -0.15320438f, 0.20345415f, 0.03758690f, -0.27523184f, 
    -0.24211946f, 0.09388716f, -0.11498039f, -0.09465269f, -0.00057119f, 0.18733944f, -0.14056532f, -0.02541190f, 
    -0.00597316f, 0.10390043f, -0.01160321f, 0.06367882f, -0.02613636f, -0.10160515f, -0.13600701f, -0.04015024f, 
    -0.29228932f, -0.13798125f, 0.26161316f, 0.21305393f, -0.27385816f, -0.17582648f, 0.01392527f, -0.09235823f, 
    0.03874080f, 0.05051550f, -0.10441620f, -0.01589929f, -0.16734004f, 0.06250493f, 0.01444473f, -0.01321456f, 
    0.18108633f, 0.04708720f, 0.04087013f, 0.21578287f, -0.07813016f, -0.06336717f, 0.15625955f, -0.22280881f, 
    0.09792827f, 0.04677895f, -0.11549069f, 0.00557938f, 0.01653262f, -0.05376548f, 0.01815232f, -0.03981800f, 
    -0.04713168f, -0.12460173f, -0.10044264f, -0.07434167f, 0.05601583f, 0.02997657f, 0.09206331f, -0.05529178f, 
    0.33531177f, -0.11833620f, -0.09856202f, 0.16384716f, -0.02662565f, -0.06213063f, -0.11628757f, -0.00846037f, 
    -0.00685663f, -0.09026676f, 0.04452872f, 0.06563552f, -0.07080980f, -0.10695089f, -0.03663458f, 0.11596822f, 
    0.04991074f, 0.11967625f, 0.07322273f, -0.07348081f, 0.23850316f, 0.04302365f, 0.09230251f, 0.04737329f, 
    -0.22006553f, -0.13952817f, -0.11951154f, -0.08233026f, -0.01898915f, -0.03265238f, -0.02619360f, -0.06068365f, 
    -0.00573654f, 0.01663879f, -0.09265234f, 0.15870646f, 0.09292167f, -0.10505583f, 0.06442353f, 0.17103685f, 
    -0.20317344f, -0.20191939f, 0.39250588f, -0.08652189f, 0.11292484f, 0.01468879f, -0.01058802f, 0.01375114f, 
    -0.02680188f, -0.14009528f, 0.07803879f, 0.20434611f, 0.03717771f, 0.05470349f, -0.00103345f, -0.13438457f, 
    0.10872925f, -0.15991871f, -0.00939280f, -0.02145199f, 0.22333543f, 0.53723270f, -0.28396377f, 0.13188799f, 
    0.08368897f, 0.03059248f, 0.17324536f, 0.08053979f, 0.00928927f, 0.11370154f, 0.01228001f, -0.03677441f, 
    0.02726940f, 0.05022433f, 0.08634085f, 0.02254875f, -0.07414568f, -0.10805251f, 0.07517021f, 0.00543196f, 
    -0.05993220f, 0.04569469f, 0.07376400f, 0.02283166f, 0.29080698f, -0.08945271f, 0.09014417f, -0.06572203f, 
    0.08490177f, 0.01224149f, 0.14519194f, -0.02863455f, 0.17268239f, 0.11573729f, 0.09074462f, 0.07237271f, 
    0.18639092f, -0.05471800f, 0.17190892f, 0.01798513f, -0.22453663f, -0.14838529f, 0.01214870f, -0.01347372f, 
    0.07662258f, -0.20687722f, -0.12076047f, -0.17160530f, -0.04687113f, -0.15222317f, 0.32268038f, 0.12630019f, 
    0.16227549f, 0.22484723f, 0.19279908f, 0.25001767f, 0.04500414f, 0.16635664f, 0.05159914f, 0.03926026f, 
    -0.20729764f, -0.11468060f, 0.25207835f, 0.01952342f, -0.38501340f, -0.12035765f, -0.16912973f, -0.07931925f, 
    -0.12429356f, -0.15178703f, 0.01026598f, 0.01579729f, 0.05732002f, 0.01235664f, 0.01845397f, 0.10742382f, 
    0.05603166f, 0.00233967f, -0.12623186f, 0.05872175f, -0.16212079f, -0.24217367f, -0.04298097f, -0.12615511f, 
    -0.27712956f, 0.08223589f, -0.09456653f, -0.08490117f, -0.00476093f, -0.23897989f, -0.19424042f, 0.01466934f, 
    0.00613067f, 0.00188496f, 0.02074479f, 0.11224347f, 0.05847878f, 0.01483177f, 0.23331457f, -0.02116477f, 
    0.06935948f, 0.04619640f, 0.15741299f, -0.04528239f, 0.08206318f, 0.02639407f, 0.11822963f, -0.05986951f, 
    0.11875696f, 0.16404508f, 0.10510439f, 0.14135991f, 0.18519139f, 0.20272838f, 0.04217547f, 0.18916345f, 
    0.13144793f, -0.06549924f, 0.12675506f, 0.04724729f, -0.06741289f, -0.22099628f, -0.18771470f, 0.39562035f, 
    -0.34924883f, -0.02577977f, 0.03489709f, -0.00942544f, 0.17010739f, 0.22827005f, -0.18096079f, 0.08972454f, 
    0.05595189f, 0.03512565f, 0.02729925f, 0.03354382f, 0.04200638f, -0.08504643f, 0.14765020f, 0.05020608f, 
    -0.04110349f, 0.05112134f, 0.18020324f, -0.04441982f, -0.07475448f, -0.14711232f, -0.13832466f, -0.26157358f, 
    0.23974493f, -0.21433267f, 0.01864495f, 0.05124064f, -0.05856907f, 0.00654056f, 0.05436729f, -0.12902071f, 
    0.10455099f, -0.03340093f, 0.06089768f, -0.02158264f, -0.15611725f, -0.01886341f, 0.08007233f, -0.20134106f, 
    0.14067845f, -0.16950582f, -0.16141522f, -0.20402068f, -0.10059759f, -0.14481774f, 0.10064428f, 0.21382728f, 
    0.17458329f, 0.20149252f, 0.23753442f, 0.13813654f, -0.00588561f, 0.13074552f, 0.01973559f, 0.01564678f, 
    0.55109394f, 0.01181967f, -0.32164216f, -0.18997265f, -0.14842676f, 0.13515514f, -0.10908189f, -0.01100946f, 
    0.12605938f, 0.22814904f, -0.04080154f, -0.20368448f, -0.06813075f, -0.02741969f, -0.02002989f, 0.06813847f, 
    0.02668715f, -0.05617038f, -0.04198243f, 0.19445889f, -0.01591195f, -0.05586143f, -0.01102478f, -0.04958270f, 
    0.11698299f, -0.05693746f, 0.01181782f, -0.02852251f, 0.05113967f, -0.00689028f, 0.04066097f, 0.03069619f, 
    0.04937632f, 0.06048707f, 0.02049775f, 0.08770859f, 0.12048610f, 0.06373137f, 0.03390699f, 0.00911910f, 
    -0.27497491f, -0.19128816f, -0.06712111f, 0.06727610f, -0.40131363f, -0.04098576f, -0.13764849f, 0.06881907f, 
    -0.06294212f, -0.09357139f, -0.07660367f, 0.05471415f, 0.07080568f, 0.03411092f, -0.00471303f, 0.02372669f, 
    0.02402925f, 0.02268651f, -0.05134197f, 0.02913582f, -0.17701194f, -0.13376078f, 0.06086911f, -0.11045489f, 
    0.13904741f, -0.19096518f, -0.12337205f, -0.15754586f, -0.07165366f, -0.16489463f, 0.03118285f, 0.15942173f, 
    0.13135962f, 0.16181037f, 0.14514959f, 0.22809823f, 0.05627376f, 0.14205991f, 0.02243502f, 0.02249688f, 
    -0.22526114f, -0.05778772f, 0.16332784f, 0.23741007f, -0.07718343f, -0.15728550f, -0.02495011f, -0.11581253f, 
    -0.05060109f, 0.01550408f, 0.29140228f, 0.07513000f, 0.15592179f, 0.14634730f, 0.08921169f, -0.02523638f, 
    -0.03638607f, -0.01817467f, 0.02260000f, 0.00264376f, -0.20476849f, -0.12382191f, 0.08107927f, 0.38447791f, 
    -0.01080930f, -0.01129372f, 0.12792218f, 0.14732689f, 0.21500327f, -0.02074453f, 0.05808784f, 0.03413806f, 
    0.09747642f, 0.06859893f, 0.02846126f, 0.08045778f, 0.10312876f, 0.06367121f, -0.00522274f, 0.00982976f, 
    0.16840260f, -0.05509514f, -0.34516037f, -0.02274151f, -0.09877127f, 0.02709533f, 0.07112353f, 0.07606494f, 
    0.16087131f, 0.05616504f, 0.01972890f, -0.02301420f, -0.09451032f, -0.01475317f, 0.13945113f, 0.03747861f, 
    0.21854837f, -0.11384555f, 0.14357567f, -0.02752403f, -0.43537590f, -0.33389175f, 0.13483849f, 0.05204447f, 
    -0.39277095f, -0.09666435f, -0.07596375f, -0.03314286f, 0.02411897f, -0.02289133f, -0.10118064f, 0.02063123f, 
    -0.02107999f, -0.07051563f, -0.01486545f, 0.04362307f, 0.08548196f, 0.01615864f, 0.06015921f, -0.11858878f, 
    -0.58940488f, 0.16335632f, 0.27140325f, 0.38695201f, 0.10319838f, -0.15950511f, -0.06415576f, -0.19105709f, 
    0.09790646f, 0.05456783f, 0.21201092f, 0.00459514f, 0.09330674f, 0.05697959f, 0.01871067f, 0.21224779f, 
    0.12467581f, 0.07280572f, 0.16245773f, 0.04069273f, 0.78866601f, -0.36692122f, 0.09954292f, 0.01304985f, 
    -0.62639296f, -0.07904443f, 0.04547484f, -0.16143861f, 0.31304941f, 0.23473199f, 0.14825316f, 0.15320243f, 
    -0.01481892f, 0.18877167f, 0.05497913f, 0.20405005f, -0.13527197f, 0.02513515f, 0.11886720f, 0.13768031f, 
    0.21190241f, 0.06408495f, -0.26999599f, -0.07546080f, -0.07079992f, 0.11810024f, -0.12791274f, 0.10228807f, 
    -0.00442142f, 0.16106308f, -0.04606476f, 0.08590811f, -0.01826150f, 0.03961314f, 0.02144838f, 0.06202861f, 
    0.04956395f, 0.04609010f, 0.06864852f, 0.25037932f, -0.31503063f, -0.27780682f, -0.04521306f, 0.33780536f, 
    -0.13341010f, -0.00782451f, -0.01730255f, 0.11994369f, -0.01257699f, 0.14994089f, 0.19204868f, 0.07903392f, 
    0.06885394f, 0.05039397f, -0.04911721f, 0.34247699f, 0.09406001f, -0.13470970f, -0.01958291f, 0.14080840f, 
    -0.12359941f, 0.05407011f, 0.45109457f, 0.07021841f, -0.21530423f, -0.24947686f, -0.16215168f, -0.24566913f, 
    0.06560560f, -0.16599205f, 0.16554105f, -0.00869256f, 0.05962298f, 0.11895626f, 0.11733733f, -0.00127029f, 
    -0.03682959f, -0.10183407f, 0.02871381f, -0.02991715f, 0.36486807f, 0.27703103f, -0.03974126f, 0.19882008f, 
    0.00953402f, 0.23188490f, 0.07331652f, 0.14044307f, 0.26463529f, 0.17287976f, 0.14311096f, 0.05644790f, 
    0.12179285f, 0.18843870f, 0.04349570f, -0.01083581f, 0.33861989f, -0.09670787f, 0.22190495f, 0.15589775f, 
    -0.08928455f, -0.00174871f, 0.14913513f, 0.47250757f, -0.35512072f, -0.11280574f, -0.08439127f, -0.02259555f, 
    -0.00117857f, 0.01474398f, 0.05978516f, 0.07222589f, 0.10417213f, -0.05935831f, -0.13477248f, -0.01704161f, 
    0.02357186f, -0.21737859f, 0.08810972f, 0.01181811f, 0.21919248f, 0.08245571f, 0.09207096f, -0.20664282f, 
    -0.17080815f, 0.03647212f, -0.09395992f, -0.12971337f, 0.00279482f, 0.00369501f, 0.09619299f, 0.26569569f, 
    -0.10300650f, 0.03212419f, 0.03798220f, 0.01774604f, 0.04382007f, 0.06667995f, -0.01711461f, 0.10546236f, 
    -0.01690100f, -0.00796663f, 0.02326544f, 0.17869586f, 0.21936861f, -0.06763107f, 0.03670242f, -0.02005608f, 
    -0.00059106f, 0.02975541f, 0.06633190f, 0.15828994f, 0.16528311f, 0.19064029f, 0.11976480f, 0.07153642f, 
    0.17275883f, 0.08337142f, 0.04105606f, 0.01845484f, 0.17352259f, 0.19208308f, -0.26523560f, -0.06977896f, 
    -0.29895723f, 0.19484332f, -0.04134603f, 0.04232958f, 0.02406779f, -0.10720868f, 0.01246534f, 0.09676118f, 
    0.09605639f, 0.02357352f, 0.08464964f, 0.08037628f, -0.01173375f, 0.16093500f, 0.07428297f, 0.07049961f, 
    0.40549594f, -0.06170543f, -0.39390284f, -0.28867114f, -0.10803467f, 0.24210735f, 0.02613295f, 0.08242197f, 
    0.14789145f, 0.24306859f, 0.02840357f, 0.09088540f, -0.04345887f, -0.02999747f, 0.03427918f, 0.26566657f, 
    -0.01607459f, -0.06179984f, 0.12953135f, 0.12781522f, -0.19282286f, -0.07585528f, -0.44890931f, 0.23894157f, 
    0.10956158f, 0.05286114f, 0.11034021f, 0.12068469f, 0.05298576f, -0.11044855f, -0.08768460f, -0.10758471f, 
    -0.04383254f, 0.04023341f, -0.04799025f, 0.03672089f, -0.03511519f, 0.08882769f, 0.00889022f, 0.07421024f, 
    -0.12131136f, -0.08968470f, -0.19890001f, -0.26538706f, 0.12965418f, 0.00159278f, -0.05023206f, 0.06435931f, 
    -0.02372363f, -0.04219747f, -0.12207882f, -0.15736848f, -0.16555846f, -0.05662036f, -0.08636029f, 0.13789518f, 
    0.08279940f, -0.08163316f, 0.14704317f, 0.09887353f, -0.04673199f, -0.02181810f, -0.45392349f, -0.15182133f, 
    0.07276659f, 0.15272489f, 0.05781046f, 0.16202202f, -0.01782886f, -0.03503687f, -0.14124689f, -0.02262082f, 
    -0.12886606f, -0.00663448f, -0.05503473f, 0.08125227f, -0.01226323f, 0.01467746f, 0.07346033f, 0.10626402f, 
    -0.74071580f, -0.10802897f, -0.29346195f, 0.20332912f, 0.39757085f, -0.11244625f, 0.27707309f, -0.30424520f, 
    0.14510430f, 0.08146833f, 0.26854220f, 0.07538612f, -0.06458535f, 0.08217137f, 0.11181916f, 0.09771508f, 
    0.26224536f, 0.00263415f, 0.17919795f, -0.08345236f, -0.19174497f, -0.05599881f, -0.28948098f, 0.23430599f, 
    -0.11670502f, 0.15334189f, 0.01885899f, 0.19860953f, -0.17912406f, 0.05863160f, 0.09718984f, 0.08422411f, 
    -0.00869486f, 0.06521153f, 0.05814555f, 0.28544676f, 0.03419995f, -0.09734184f, -0.02586135f, 0.00201382f, 
    0.01764981f, -0.02986774f, -0.02316357f, -0.02732364f, 0.01059313f, -0.03629987f, -0.00537066f, 0.01434661f, 
    -0.02679068f, -0.00421699f, 0.00786399f, -0.01247551f, -0.04359879f, -0.03083932f, -0.01690659f, 0.02680703f, 
    -0.00795248f, 0.02677210f, -0.00348606f, -0.02891642f, 0.03555633f, 0.01326725f, -0.02344075f, 0.02923747f, 
    0.03381058f, -0.01072155f, 0.01403135f, -0.01641634f, 0.03649255f, 0.01226656f, -0.00778713f, 0.01548409f, 
    -0.03707113f, -0.04225893f, -0.04142934f, 0.03172635f, -0.01850406f, 0.00599198f, -0.03142665f, 0.00167757f, 
    -0.03869418f, 0.02968599f, 0.01040745f, -0.03404258f, -0.02440170f, -0.01260319f, -0.02195809f, -0.03385559f, 
    0.03247428f, -0.03330984f, 0.03134952f, 0.02336277f, 0.01712846f, 0.03555897f, -0.02818671f, -0.01783033f, 
    -0.02084600f, 0.00593018f, 0.02209253f, -0.01042195f, -0.02287934f, 0.04116215f, -0.03601069f, 0.01700259f, 
    -0.04065547f, 0.01504684f, -0.02181502f, -0.02696474f, -0.00482755f, 0.03085903f, 0.00580477f, -0.01454490f, 
    0.00807810f, -0.00531338f, 0.03166522f, -0.04638588f, 0.01564681f, -0.01407005f, 0.04310843f, -0.03309625f, 
    -0.00548747f, 0.00934836f, -0.01010020f, -0.01983906f, -0.01437584f, 0.02106981f, 0.00388050f, -0.01198411f, 
    0.02089460f, 0.00554387f, -0.00449907f, 0.00039551f, -0.03006376f, 0.01724571f, -0.03768883f, -0.02719291f, 
    -0.01926774f, -0.01020369f, -0.00999609f, 0.01849472f, -0.00686643f, -0.00416051f, -0.02790038f, -0.02789388f, 
    -0.04044381f, 0.00362642f, 0.00454011f, -0.03995808f, 0.00060623f, -0.03923975f, -0.02247031f, 0.02876778f, 
    -0.02667225f, 0.01539100f, -0.01585049f, 0.03241565f, 0.01670268f, 0.00581348f, -0.00507754f, 0.02896029f, 
    0.00553297f, -0.01015254f, -0.01560752f, -0.01049048f, 0.00286739f, -0.03065800f, -0.04073909f, -0.00922198f, 
    0.02634473f, -0.01973458f, 0.00928405f, -0.01232278f, 0.01562759f, -0.01817691f, 0.00873961f, -0.02019745f, 
    0.02808942f, -0.02387228f, 0.01506696f, -0.01326121f, -0.02168541f, 0.01760261f, 0.00239404f, -0.00430697f, 
    0.00987859f, 0.01019245f, 0.02979458f, -0.00878748f, -0.01348910f, -0.00601636f, 0.00411557f, -0.00965439f, 
    -0.00548428f, 0.00916458f, -0.00899886f, -0.02353274f, -0.01901117f, 0.02778265f, -0.00159791f, -0.03822124f, 
    -0.00694265f, -0.00194235f, -0.03355834f, 0.03029821f, 0.01546700f, -0.02053521f, -0.03548387f, 0.00865963f, 
    -0.00670506f, -0.02263262f, 0.00626976f, -0.02436486f, -0.02127192f, 0.02915129f, 0.00392439f, 0.01283963f, 
    0.02473429f, -0.00446680f, -0.03987363f, 0.00677207f, 0.03192773f, -0.02214447f, -0.01332188f, -0.00440780f, 
    0.00117835f, 0.00282642f, -0.01102592f, -0.04098029f, 0.00145905f, -0.00267067f, 0.00752696f, -0.04312155f, 
    -0.03847173f, 0.02933580f, 0.01459065f, -0.00646233f, 0.02977762f, -0.02290603f, 0.01279764f, -0.02290396f, 
    -0.00894221f, 0.01025122f, 0.00428091f, 0.01027871f, -0.02406611f, 0.03593147f, 0.01274644f, 0.02036487f, 
    -0.04155906f, -0.02473315f, -0.03692559f, -0.02345227f, 0.00184160f, -0.02904461f, -0.01230060f, 0.04060578f, 
    0.04019669f, -0.01761238f, 0.00568191f, -0.02515675f, -0.02512000f, 0.03307226f, 0.01644146f, -0.03495188f, 
    0.01566729f, 0.01773093f, -0.01422521f, 0.03476917f, -0.03410323f, 0.00510758f, -0.02765670f, 0.00093423f, 
    -0.02871428f, -0.03259964f, -0.02753464f, 0.00427023f, -0.03156010f, -0.03220395f, -0.03728471f, 0.03169728f, 
    0.03202618f, -0.02603021f, -0.00913782f, 0.02014443f, -0.01386178f, -0.00607832f, -0.04441333f, -0.02983268f, 
    0.02117821f, -0.01779585f, 0.02494446f, -0.01491513f, 0.01576839f, 0.00188553f, 0.00885657f, -0.03809952f, 
    -0.03221442f, 0.02936812f, 0.00517268f, -0.03827494f, -0.04035535f, -0.00494689f, 0.01175773f, -0.03185081f, 
    0.03375030f, -0.01007335f, 0.01205447f, -0.00675773f, 0.02262270f, 0.02638607f, -0.03061222f, -0.01243837f, 
    0.03556059f, 0.00341491f, 0.03076698f, 0.02784472f, -0.03933779f, 0.01776871f, -0.01968249f, 0.03144655f, 
    -0.04528581f, -0.01651031f, 0.00866183f, -0.02280092f, 0.01015629f, -0.01208101f, -0.00240000f, -0.00931333f, 
    0.03576883f, 0.01870177f, -0.03853858f, -0.02500503f, -0.00411829f, 0.00116711f, 0.01321922f, -0.02989175f, 
    0.01265834f, -0.03098731f, 0.02971459f, -0.00102635f, -0.02721691f, -0.01088588f, -0.02996262f, -0.03433248f, 
    -0.00788655f, -0.03554578f, -0.02522857f, -0.04369058f, -0.03889274f, 0.01388518f, 0.01226269f, -0.02243792f, 
    0.02330587f, -0.01199282f, -0.01172420f, 0.03615068f, -0.00205248f, -0.01437047f, -0.04016855f, 0.00223567f, 
    -0.01443889f, 0.02186861f, -0.01281099f, 0.01984067f, 0.02235002f, -0.03600035f, -0.01692873f, -0.03903852f, 
    0.02346391f, 0.00814588f, -0.03222857f, -0.04078778f, -0.00965080f, 0.03610967f, -0.04206051f, -0.00219489f, 
    -0.02825350f, -0.01393471f, 0.00130656f, -0.03342422f, -0.00281647f, 0.00899725f, -0.00293052f, -0.03095783f, 
    -0.00573175f, -0.03564565f, 0.02068222f, -0.00297355f, 0.02999295f, 0.02517522f, 0.03241506f, 0.01492746f, 
    0.00167835f, 0.01770318f, 0.01388487f, 0.00347543f, -0.03241040f, 0.03235697f, -0.00202178f, 0.02928845f, 
    0.00774598f, 0.03390643f, 0.03341354f, 0.01752495f, 0.03224393f, -0.00083895f, -0.02954000f, 0.00750274f, 
    0.02369826f, -0.03184646f, -0.04633468f, 0.00818728f, -0.03561191f, -0.00319690f, 0.02940763f, -0.01194492f, 
    0.00407121f, 0.03281689f, -0.01661511f, -0.02048143f, -0.02118172f, 0.01638640f, -0.00821813f, 0.02620530f, 
    -0.00271142f, -0.02154961f, 0.03497932f, -0.00603331f, 0.01788328f, -0.00394069f, 0.04246736f, 0.01562821f, 
    0.02833146f, 0.02872642f, 0.00861119f, 0.02519049f, -0.03326749f, 0.01821932f, -0.02555660f, 0.01142368f, 
    0.02492789f, -0.04079694f, -0.03392104f, 0.02509737f, 0.01755293f, 0.03134826f, -0.02100795f, -0.01332836f, 
    -0.00927511f, -0.00853395f, 0.01313167f, 0.01644450f, -0.04570976f, 0.02050898f, -0.01702341f, -0.03409812f, 
    -0.03308246f, 0.00742740f, -0.02793964f, -0.03498087f, -0.00725372f, 0.02681485f, -0.01480066f, -0.02397122f, 
    0.02527128f, -0.01499184f, -0.01555144f, -0.00322546f, 0.01972005f, -0.00303707f, -0.02446022f, 0.01943452f, 
    0.01281937f, -0.00174578f, -0.03094958f, -0.02029564f, -0.01814515f, -0.03970665f, -0.04575971f, -0.02719047f, 
    -0.00718807f, -0.02416213f, -0.03140121f, -0.00440407f, -0.04139747f, -0.03580277f, 0.02037648f, 0.00469646f, 
    -0.02427820f, -0.01283493f, 0.03087737f, -0.01168182f, 0.04051223f, -0.01489203f, -0.03008250f, -0.00830404f, 
    0.00960436f, 0.01711928f, 0.01973268f, -0.03166476f, -0.02754139f, -0.04361098f, -0.01399007f, -0.01386799f, 
    -0.03688185f, -0.00712889f, -0.03352292f, -0.03753858f, 0.00180410f, -0.00208155f, -0.00323212f, -0.03042101f, 
    0.00960824f, -0.02050811f, -0.01488275f, -0.03800179f, 0.03417705f, 0.02564174f, 0.02459345f, -0.02233564f, 
    0.02887635f, -0.02846138f, 0.02203935f, -0.02066050f, -0.04375537f, 0.00018848f, -0.00908143f, -0.01049092f, 
    0.02776743f, 0.02384196f, 0.02111874f, -0.03393082f, 0.02451008f, 0.01880923f, 0.03135962f, -0.01016867f, 
    -0.00139516f, -0.00532374f, -0.04342085f, -0.01873222f, -0.04331339f, -0.04018337f, -0.02653788f, -0.02986326f, 
    -0.03226246f, -0.01461693f, 0.03530818f, 0.00904861f, -0.04000477f, -0.00164730f, -0.03549739f, -0.00917316f, 
    -0.02559085f, -0.02724681f, 0.01147172f, -0.01302076f, 0.01649031f, 0.01865207f, 0.01289002f, 0.00564659f, 
    -0.00443344f, -0.02355420f, -0.03396824f, -0.03120673f, -0.00879966f, -0.01230506f, -0.04329944f, 0.03035101f, 
    0.01427964f, 0.00812011f, -0.03064488f, 0.02574308f, 0.00673114f, -0.01959659f, -0.00515103f, 0.00879354f, 
    -0.00876701f, -0.01925056f, 0.02872408f, 0.01177641f, -0.01971725f, -0.00886784f, -0.00452286f, -0.01869282f, 
    0.00556977f, -0.01451342f, -0.00094266f, -0.00188453f, 0.02832451f, -0.03057624f, 0.00421635f, 0.00274351f, 
    -0.03787399f, 0.00038909f, -0.01080418f, 0.00504367f, 0.01483232f, -0.02550872f, -0.04277387f, -0.02614181f, 
    -0.01781232f, -0.03723633f, -0.00566136f, 0.01523871f, -0.03010750f, -0.03630222f, 0.04424439f, -0.01649576f, 
    0.02477360f, 0.01914733f, 0.01735348f, 0.01889457f, -0.03090294f, 0.00694167f, 0.02750905f, 0.00086807f, 
    0.01491390f, -0.00502427f, 0.01412085f, -0.03860308f, -0.02655107f, -0.03196439f, -0.02212684f, -0.02717844f, 
    0.00774398f, 0.00106728f, -0.02768086f, 0.00430395f, 0.00846999f, -0.03755333f, -0.01658684f, 0.01004855f, 
    0.00463328f, 0.02894849f, 0.01766409f, 0.01456293f, 0.02238061f, 0.00484934f, 0.01260615f, 0.02462295f, 
    0.00944316f, 0.02794728f, -0.01806887f, -0.01586003f, -0.01986864f, 0.01025306f, -0.02861065f, -0.00823381f, 
    0.00709279f, -0.00453094f, -0.04407918f, 0.00954181f, -0.01356406f, 0.01602372f, 0.01323685f, -0.00322846f, 
    -0.02266892f, -0.03767030f, 0.01964812f, 0.02355241f, -0.00257461f, 0.02372102f, 0.02745927f, -0.02981736f, 
    0.00688058f, -0.01862798f, -0.02595863f, 0.00604978f, 0.02309134f, 0.00122081f, -0.00730167f, 0.04343804f, 
    -0.01421775f, -0.02522736f, 0.00222799f, 0.00272730f, 0.01205138f, 0.01366506f, -0.03084947f, 0.01829909f, 
    0.02717419f, -0.03455181f, 0.07915048f, -0.04638023f, -0.02972529f, 0.08743822f, 0.01773896f, 0.01255839f, 
    0.03704324f, -0.01718486f, -0.10104961f, 0.32263342f, -0.08943186f, -0.11897775f, 0.00589193f, 0.06985063f, 
    -0.01510319f, 0.16434817f, 0.00128649f, 0.16306995f, 0.13054231f, 0.00426921f, 0.11921793f, 0.06821735f, 
    0.02980441f, 0.09657542f, 0.03257585f, 0.01441821f, 0.01230313f, 0.03892224f, 0.03293749f, 0.05767026f, 
    -0.02097152f, -0.13031270f, -0.15449160f, 0.00065242f, -0.04513697f, -0.03439812f, 0.01696356f, 0.00839840f, 
    0.11966616f, 0.30296320f, 0.16561586f, 0.08663925f, 0.24738094f, -0.09410962f, 0.00431497f, 0.18643826f, 
    0.10566787f, 0.29531941f, -0.05560867f, -0.05931980f, -0.05133237f, -0.03201550f, -0.01921121f, -0.11643019f, 
    -0.08729544f, -0.04161504f, -0.30176550f, -0.06305775f, -0.15414338f, 0.17924164f, 0.15128721f, 0.08496048f, 
    0.22676855f, -0.03128769f, -0.06428949f, 0.16500326f, -0.01947785f, 0.31216183f, -0.01909870f, -0.02932219f, 
    -0.02978904f, -0.03432453f, -0.08538574f, -0.07484625f, -0.01301959f, -0.10587909f, 0.04602900f, 0.19286463f, 
    0.02323685f, -0.02131529f, 0.16540234f, 0.01832866f, -0.07196184f, -0.00238799f, -0.16559716f, 0.03273457f, 
    0.02986523f, -0.04110181f, -0.09715841f, 0.11196870f, 0.01325980f, -0.12445888f, 0.05712540f, 0.00277236f, 
    0.15145525f, 0.19755632f, 0.01733496f, -0.02063656f, -0.12106607f, 0.30269670f, -0.20388339f, 0.14751412f, 
    0.03881323f, 0.08282731f, 0.24498136f, 0.16230085f, -0.17140134f, 0.00512015f, 0.18936904f, -0.13798581f, 
    -0.11602312f, 0.05062329f, -0.00881388f, 0.08267742f, -0.08561116f, 0.15496817f, -0.28755152f, 0.05240053f, 
    0.05450528f, 0.25074279f, 0.15688060f, -0.15370099f, -0.04733232f, 0.21100388f, 0.12713946f, -0.04555149f, 
    0.00137950f, -0.01963355f, -0.10356052f, 0.07099147f, 0.23225394f, 0.09031001f, -0.02553940f, 0.04529244f, 
    -0.10745998f, -0.09012662f, -0.06946606f, -0.00366753f, 0.28951755f, 0.07553891f, 0.05512989f, 0.02064887f, 
    -0.05559327f, 0.12891977f, -0.04758767f, 0.00704989f, 0.01367458f, -0.00194761f, -0.14339176f, 0.00455305f, 
    -0.13458715f, -0.02607675f, -0.06085540f, 0.06942000f, 0.10221803f, -0.12166898f, 0.05693502f, 0.03147063f, 
    -0.16546778f, -0.32594872f, -0.02796968f, -0.06872230f, 0.16029133f, -0.12997286f, -0.00569078f, 0.24611875f, 
    0.05509780f, -0.03437769f, 0.02304901f, -0.00933214f, -0.01121106f, -0.03851577f, 0.06911487f, 0.20540871f, 
    0.03127560f, -0.10085109f, 0.00111146f, -0.05854093f, 0.00845239f, -0.07052919f, -0.02701746f, 0.04094965f, 
    0.10745031f, 0.01347496f, 0.05382714f, 0.03706862f, -0.02212949f, -0.04306072f, 0.07877326f, 0.10924755f, 
    0.05702072f, -0.07449463f, -0.01263108f, 0.05559175f, -0.11427664f, -0.04263584f, -0.03094212f, -0.03210718f, 
    0.18865758f, 0.32818800f, 0.19236428f, 0.27383882f, 0.14291914f, 0.04374332f, 0.20284954f, 0.11222341f, 
    0.03498850f, 0.12793048f, 0.07351595f, -0.14820208f, -0.08353558f, -0.01929023f, 0.00137726f, -0.03930083f, 
    -0.05009108f, -0.09557438f, -0.11829387f, -0.28015071f, 0.10056792f, 0.01803074f, -0.02593371f, 0.03447474f, 
    -0.02541922f, 0.11074553f, -0.05707107f, 0.03410579f, 0.05242780f, 0.06824144f, -0.00206107f, 0.16324058f, 
    -0.11371604f, -0.23949476f, -0.17727982f, -0.06230358f, -0.11533242f, -0.11475858f, 0.03334309f, 0.04320879f, 
    0.07493641f, 0.12069470f, 0.13765147f, 0.09617043f, 0.12810375f, -0.00109084f, 0.00835918f, -0.02707391f, 
    -0.04691190f, -0.03223433f, -0.13383673f, -0.01998273f, 0.15367654f, 0.07982153f, -0.03655482f, -0.05791001f, 
    -0.11251711f, -0.03118079f, -0.14293146f, -0.08613129f, 0.04007563f, -0.20150389f, 0.03521730f, 0.10498995f, 
    -0.01619469f, 0.01994483f, -0.02679138f, 0.04040402f, -0.06551313f, -0.06233603f, -0.06315666f, -0.00037092f, 
    -0.01874250f, -0.10604565f, -0.02475190f, -0.07165134f, -0.08511154f, -0.08150182f, 0.16374929f, 0.25138715f, 
    0.09002297f, 0.12052844f, -0.17584661f, -0.08989121f, 0.05819219f, 0.19437194f, -0.09179492f, -0.10475257f, 
    -0.06205909f, -0.01455167f, -0.00534548f, 0.05211524f, 0.06508580f, 0.01647290f, -0.06233685f, 0.03903036f, 
    -0.14298227f, 0.00638506f, 0.05472813f, -0.16605154f, 0.21415490f, 0.31565836f, 0.26306444f, 0.10117795f, 
    0.12238058f, 0.15056291f, -0.03322371f, 0.05871540f, 0.07482285f, 0.11301287f, 0.03666223f, -0.00545665f, 
    -0.02252214f, 0.05859415f, -0.02396055f, -0.03590170f, -0.05464324f, -0.08690892f, -0.16055681f, -0.02418124f, 
    -0.04454146f, -0.04044011f, 0.25326067f, 0.14296536f, -0.37135279f, 0.28052151f, -0.15076327f, 0.06173422f, 
    -0.15823165f, 0.01519688f, 0.10104415f, 0.01345832f, 0.17627484f, 0.14090419f, 0.18324785f, -0.16092390f, 
    0.09717699f, 0.15160234f, -0.07380165f, 0.20088938f, 0.17539135f, -0.05201963f, 0.61843544f, -0.35465404f, 
    -0.32642826f, 0.20266306f, -0.04516723f, 0.07506566f, 0.09568673f, -0.11823526f, -0.06119492f, -0.02374423f, 
    0.31875947f, -0.00113347f, 0.07251682f, -0.10412098f, 0.21173185f, -0.05954789f, 0.10056528f, -0.08776222f, 
    0.04781250f, -0.11250301f, -0.01888849f, 0.23305568f, 0.02441343f, -0.04324490f, 0.12081456f, 0.07730180f, 
    0.16758400f, 0.14735436f, 0.01163427f, 0.04292605f, 0.01820421f, 0.07492772f, 0.02211987f, 0.08042604f, 
    -0.01542099f, -0.04338212f, -0.06250206f, -0.20060815f, 0.28307658f, -0.22678885f, 0.00824849f, 0.02891019f, 
    0.03950424f, -0.14989407f, 0.09601573f, -0.15423845f, 0.03611156f, 0.09904874f, 0.04881766f, -0.09837583f, 
    -0.01483765f, -0.01968456f, -0.08159382f, -0.04754062f, 0.03758117f, 0.15201217f, 0.08742674f, -0.11961493f, 
    0.47182646f, 0.11505642f, 0.22575347f, 0.17527167f, -0.01181808f, -0.00987616f, -0.08089880f, -0.12628733f, 
    -0.10298154f, 0.06305739f, -0.07311945f, 0.06929600f, 0.06282002f, 0.10380904f, -0.02143860f, 0.07230590f, 
    0.04505109f, 0.01852668f, -0.01938056f, 0.03449548f, -0.71252179f, 0.05818569f, 0.12506573f, -0.17312960f, 
    0.28890941f, 0.02493262f, -0.00664691f, 0.11127605f, -0.09840455f, -0.02760225f, -0.03476716f, -0.18025403f, 
    0.17024976f, -0.07906686f, -0.07110067f, -0.00417017f, -0.07087254f, 0.14690813f, -0.17719610f, -0.04731995f, 
    0.18096748f, -0.03679105f, 0.28864679f, 0.21313746f, -0.12294560f, 0.10915510f, 0.02629593f, -0.09140168f, 
    0.07735743f, 0.16233583f, -0.04397660f, -0.02987356f, 0.00440159f, -0.07966616f, 0.11790686f, -0.08579418f, 
    -0.02402332f, 0.01390538f, -0.20952392f, -0.01415047f, 0.07285015f, 0.04040544f, 0.10002702f, -0.12504451f, 
    -0.11727103f, 0.04968841f, 0.23692207f, 0.05443069f, 0.09173126f, 0.13585383f, 0.13204084f, -0.03915396f, 
    0.02216860f, -0.02307976f, -0.00186226f, 0.03301697f, -0.07114759f, -0.12312207f, -0.05939505f, -0.22826365f, 
    -0.03129265f, -0.00787663f, 0.01045558f, 0.04066922f, 0.06176359f, -0.01953804f, 0.04552992f, 0.04837300f, 
    0.01294152f, -0.00128211f, -0.00980145f, 0.01147363f, -0.06474952f, -0.09504817f, -0.06058899f, 0.10710513f, 
    -0.00409420f, -0.00711102f, -0.09647344f, 0.05300881f, -0.02837415f, 0.26918116f, -0.08638934f, 0.21384220f, 
    -0.03897526f, 0.01412775f, 0.02736374f, 0.07848161f, 0.00872221f, 0.17656395f, -0.01882920f, -0.08326761f, 
    -0.05963808f, -0.01119228f, 0.02902354f, -0.19787475f, 0.00582645f, -0.01407309f, 0.10308495f, 0.21453442f, 
    0.03520145f, 0.00146443f, -0.23459665f, -0.13046813f, -0.01089063f, -0.11300929f, 0.01051110f, 0.03554249f, 
    -0.02259138f, 0.14531377f, 0.10546301f, 0.02920820f, -0.00888399f, 0.05759507f, 0.04686772f, 0.05213403f, 
    0.19412719f, 0.06017404f, -0.02447728f, -0.00415891f, -0.00908214f, -0.05676489f, -0.36592343f, 0.13494292f, 
    0.18024214f, -0.03636155f, 0.00253159f, 0.04678492f, 0.01391467f, 0.03684398f, 0.09447395f, 0.02165844f, 
    0.04355136f, -0.01634741f, -0.00055362f, 0.08606065f, 0.21473305f, -0.07705590f, 0.24069497f, 0.30690649f, 
    0.17974107f, -0.07566681f, -0.40516797f, -0.02146448f, 0.04793136f, -0.09070466f, -0.01879610f, 0.08052372f, 
    0.03100037f, 0.11600944f, 0.13597788f, 0.05062421f, 0.05833881f, 0.04913978f, 0.05959564f, -0.04584731f, 
    0.02121569f, 0.23615232f, 0.17355949f, 0.03385271f, 0.33332065f, 0.19842194f, -0.30725944f, 0.00250791f, 
    0.13225722f, -0.02610353f, -0.12500452f, -0.02778196f, 0.06791904f, 0.13948536f, 0.11301974f, 0.01250847f, 
    0.03425793f, 0.02649887f, 0.06869800f, 0.07376461f, 0.16688143f, 0.04275551f, 0.01583395f, 0.00258337f, 
    -0.45373064f, 0.15220253f, 0.09626105f, 0.16866033f, 0.07350875f, 0.16479206f, -0.01815889f, 0.15934287f, 
    0.00013987f, 0.17692029f, 0.01059663f, 0.02317866f, 0.09627946f, -0.10403567f, -0.09561085f, -0.12609336f, 
    -0.27526179f, 0.14198843f, -0.07971859f, 0.03342542f, 0.03040093f, -0.14811333f, 0.31578556f, 0.01682481f, 
    0.07233188f, -0.10299061f, 0.10356775f, 0.15849619f, -0.08722281f, -0.25065601f, -0.11767577f, 0.00475619f, 
    -0.01675436f, -0.09867956f, 0.04301461f, -0.13039638f, 0.05243554f, 0.09685461f, -0.00051969f, 0.29454100f, 
    -0.04370356f, 0.01750395f, -0.02156574f, -0.00728149f, -0.02782373f, -0.04754975f, -0.04777005f, 0.01688508f, 
    0.02651877f, -0.04365541f, 0.01831831f, -0.03179757f, -0.00973052f, -0.01914507f, 0.00647328f, -0.00934970f, 
    0.01289641f, -0.00729607f, 0.01356852f, 0.01887324f, 0.00929438f, 0.01121379f, -0.02339788f, 0.01227832f, 
    0.02129389f, 0.01462492f, -0.03768729f, 0.01480198f, 0.00967154f, -0.02482264f, -0.00853565f, 0.00748162f, 
    -0.00118614f, -0.04147872f, 0.02288271f, 0.02733835f, -0.04301132f, 0.01382774f, -0.02351201f, 0.02080843f, 
    -0.01495779f, 0.00925420f, -0.00372386f, -0.01194601f, -0.00474940f, -0.02109976f, -0.00741314f, -0.04054109f, 
    -0.01945774f, -0.01101992f, -0.01691731f, 0.01496446f, -0.02757568f, 0.01217059f, 0.02836968f, 0.01486956f, 
    0.01385411f, 0.00169644f, 0.00423666f, -0.03894928f, 0.01460796f, -0.03413414f, -0.02243798f, -0.02923384f, 
    0.00703917f, -0.03665543f, 0.00970652f, 0.02962559f, 0.02327138f, 0.02285123f, 0.02017244f, -0.02013006f, 
    -0.04335281f, 0.02477106f, -0.00870083f, -0.04163649f, -0.03393401f, -0.04298994f, -0.02239447f, -0.02584968f, 
    0.00483813f, 0.02458498f, 0.02501556f, -0.01296530f, 0.00558327f, -0.03367697f, -0.03889291f, -0.02508137f, 
    -0.04724989f, 0.00985120f, -0.00335336f, -0.04029873f, -0.02844514f, 0.02615521f, -0.04269861f, 0.00203549f, 
    -0.01995506f, -0.00096513f, 0.00084552f, 0.01639243f, 0.01591317f, 0.02238718f, -0.00155769f, 0.00784185f, 
    -0.00329981f, -0.04205961f, -0.00288094f, 0.02496092f, -0.04681494f, -0.00204793f, 0.02152637f, -0.00099245f, 
    0.02344078f, -0.00128868f, -0.00337118f, -0.03780947f, -0.00541137f, 0.01945735f, 0.00513624f, -0.04149057f, 
    -0.02163728f, 0.00273553f, 0.01772421f, -0.00269954f, 0.00559990f, -0.03207197f, -0.03629581f, -0.04154442f, 
    -0.02802030f, 0.02197739f, 0.02227539f, 0.02258881f, -0.00265135f, -0.01009364f, -0.01553524f, 0.01121676f, 
    -0.03286878f, 0.02894183f, -0.00440985f, -0.04518498f, 0.00610793f, -0.02250985f, 0.01038819f, -0.03029396f, 
    -0.00681106f, 0.00864465f, 0.00719734f, 0.00393020f, -0.01312841f, -0.01610601f, -0.02791106f, 0.00728437f, 
    -0.03485934f, -0.00147877f, 0.02468004f, -0.01173789f, -0.02043924f, -0.04116552f, -0.01794005f, -0.04079651f, 
    0.00509273f, -0.02895305f, 0.01238337f, -0.00247746f, -0.03778529f, 0.02652827f, 0.01244062f, 0.01536097f, 
    0.00854155f, -0.03833841f, 0.01344774f, -0.02577970f, 0.02154589f, -0.03272697f, -0.03415268f, -0.04467775f, 
    -0.02454906f, -0.00032452f, 0.02613174f, -0.02129263f, 0.01265763f, -0.02934548f, 0.01865599f, -0.04225273f, 
    0.01761050f, -0.03195604f, -0.00403549f, 0.00559909f, 0.00378483f, 0.02438722f, -0.01260257f, -0.02499056f, 
    0.02765236f, -0.03764891f, -0.01483484f, 0.01855400f, -0.02851708f, -0.01437588f, -0.04332442f, 0.01471300f, 
    -0.01103485f, -0.01714076f, -0.02108713f, 0.02118535f, 0.00318080f, 0.01043216f, 0.02057189f, -0.03756591f, 
    -0.03201283f, 0.00172479f, 0.02153580f, -0.02602383f, -0.00997691f, 0.01744918f, 0.02249046f, -0.00479093f, 
    -0.04219443f, 0.00520783f, -0.03642311f, 0.01463244f, 0.00824480f, 0.00564118f, 0.01504844f, -0.00289672f, 
    0.02973836f, 0.02746237f, 0.01082330f, 0.01698988f, -0.01098913f, 0.02536688f, -0.04078892f, 0.01763360f, 
    0.02123688f, -0.01408319f, -0.00465869f, 0.00189072f, 0.00307477f, -0.04694039f, -0.01187152f, 0.00078132f, 
    0.02037897f, -0.04567690f, 0.02456101f, 0.00349886f, -0.00512863f, -0.02622486f, -0.02234032f, -0.04137091f, 
    -0.02092543f, -0.03518924f, 0.02132047f, -0.03578486f, -0.03788167f, 0.01089960f, 0.00581046f, -0.01907983f, 
    -0.02855540f, -0.03927102f, -0.03445548f, 0.00001407f, 0.03773706f, 0.01026627f, -0.03956151f, -0.00963792f, 
    0.02712423f, -0.00419258f, -0.03113934f, -0.01116100f, -0.01316702f, -0.00210253f, -0.02217722f, 0.03664900f, 
    -0.04693339f, -0.01172106f, 0.02042272f, -0.02772133f, 0.02524706f, -0.00066953f, 0.01546229f, 0.00337422f, 
    -0.04010438f, -0.00146729f, -0.01667119f, -0.04412150f, 0.01368891f, -0.03057339f, 0.02896260f, -0.01111591f, 
    0.02350329f, -0.00037404f, -0.03929571f, 0.01270089f, 0.02823290f, 0.00885271f, -0.00504665f, -0.02777960f, 
    0.00561520f, -0.02151210f, 0.00588723f, -0.04475066f, -0.02600194f, -0.04562357f, -0.04740092f, 0.02248307f, 
    -0.04187170f, -0.01312515f, -0.02046833f, -0.00516136f, 0.02594924f, -0.00562965f, 0.02320118f, -0.03403301f, 
    0.01667945f, -0.02429189f, -0.00457124f, -0.02910236f, 0.01270364f, -0.04727217f, -0.00243235f, -0.00803710f, 
    -0.03434135f, 0.02505229f, 0.02103019f, -0.03161651f, -0.03933320f, 0.02829412f, 0.02444089f, -0.03061293f, 
    0.01731633f, -0.02349268f, -0.03120724f, 0.02843899f, -0.00075910f, 0.01203640f, -0.04182753f, -0.00558339f, 
    -0.04641994f, -0.03545682f, 0.02618572f, -0.01738656f, -0.00766918f, -0.00702975f, -0.02605177f, -0.00525454f, 
    -0.00861550f, -0.00190103f, -0.01430696f, -0.02607149f, -0.04625174f, -0.04927706f, -0.00001657f, 0.01119672f, 
    -0.02191227f, -0.01624338f, -0.01269093f, 0.01693552f, 0.01974074f, -0.02286060f, -0.03031059f, -0.02985543f, 
    0.00006938f, 0.00383136f, -0.00928064f, -0.04028366f, -0.00131622f, 0.01452708f, 0.01043367f, -0.03947774f, 
    -0.04768762f, -0.01058640f, 0.02768283f, -0.01117961f, 0.02612652f, -0.03933882f, 0.02601198f, -0.02474794f, 
    -0.00001234f, -0.03351599f, -0.02487446f, 0.02866862f, -0.01876782f, -0.01657517f, -0.02655327f, -0.01207770f, 
    -0.02618137f, -0.01831775f, -0.01857646f, 0.01782165f, -0.03007527f, -0.02023975f, -0.02939148f, -0.00764985f, 
    -0.02061815f, -0.02268614f, -0.02646399f, 0.00753627f, -0.02472557f, -0.00187213f, 0.01229780f, -0.00757141f, 
    -0.00792870f, 0.01648308f, -0.04221613f, -0.04101516f, 0.02726976f, 0.02074612f, -0.01389515f, 0.00409302f, 
    -0.00515994f, -0.00549872f, -0.01030738f, -0.02693255f, -0.00631647f, 0.01152569f, -0.00985012f, 0.02881169f, 
    -0.02584481f, -0.01587887f, 0.02694273f, 0.02043982f, 0.01152022f, -0.03124135f, -0.00374617f, 0.02877034f, 
    -0.02036957f, 0.01043986f, -0.00731480f, -0.03604761f, 0.00554595f, -0.00867464f, -0.00673332f, 0.01710959f, 
    0.01021223f, 0.00544456f, -0.01614904f, -0.01053050f, 0.00377629f, 0.01635500f, 0.02055837f, -0.02829730f, 
    -0.02247232f, 0.00317141f, 0.02098768f, 0.00758220f, -0.03052755f, -0.01771377f, 0.02873181f, -0.01879961f, 
    0.01216494f, -0.04035563f, -0.01707373f, 0.00800053f, -0.01139612f, -0.01375040f, -0.00868136f, -0.01156154f, 
    -0.01942576f, -0.03185200f, 0.01885273f, -0.02009720f, 0.01627125f, -0.02805353f, -0.04377785f, 0.02036519f, 
    -0.00073255f, -0.03972295f, -0.02785649f, 0.01211987f, 0.02147543f, -0.01149417f, 0.02416497f, -0.01877036f, 
    -0.03086998f, -0.00935826f, -0.02766655f, -0.00923116f, 0.02596738f, 0.02965911f, -0.04681315f, -0.00928182f, 
    -0.01546188f, 0.00576322f, 0.00983369f, -0.04221782f, -0.04739935f, 0.01219596f, -0.01983286f, -0.03237791f, 
    0.01818702f, 0.00798824f, -0.02242650f, 0.01075216f, -0.00871711f, 0.01654115f, 0.02346523f, -0.04785008f, 
    -0.01502104f, -0.01856865f, -0.00365143f, -0.03105002f, 0.02187763f, -0.01211576f, -0.02166242f, 0.02103220f, 
    -0.01793257f, -0.00461734f, 0.01325387f, -0.04163288f, -0.02664373f, 0.01046132f, -0.04732406f, -0.00817607f, 
    0.01301734f, 0.01688118f, 0.00943483f, 0.00808175f, 0.02110888f, 0.01790456f, -0.01575813f, -0.02195639f, 
    0.01735415f, 0.00912326f, -0.01387859f, -0.04554359f, -0.01290462f, -0.01750015f, -0.02851171f, -0.02499070f, 
    -0.03611683f, -0.04328134f, -0.00623992f, 0.00562564f, 0.02977973f, -0.04737035f, 0.01950867f, -0.01453266f, 
    0.02587252f, 0.02169583f, 0.02126730f, -0.04297753f, -0.01454308f, -0.02083954f, -0.02437958f, -0.03935276f, 
    -0.00668811f, -0.00828652f, -0.02144049f, -0.04222691f, -0.01675388f, -0.02743327f, -0.01042560f, -0.00003004f, 
    -0.00904097f, 0.02288409f, 0.02076494f, -0.04622499f, 0.00563430f, 0.01520561f, 0.01855530f, -0.02331894f, 
    -0.02388084f, -0.00640227f, 0.02094706f, 0.00623097f, -0.04958128f, 0.01097291f, -0.02002189f, -0.00852172f, 
    -0.04139022f, 0.02374398f, -0.04283512f, -0.02197425f, -0.03910478f, 0.01408404f, -0.01184505f, -0.01281104f, 
    -0.03966478f, -0.03894852f, -0.01885661f, -0.01900750f, 0.00845700f, -0.03955016f, -0.02225711f, -0.02928421f, 
    0.02626770f, -0.03575020f, 0.00060227f, -0.03263626f, 0.01478316f, -0.04148460f, 0.02105787f, 0.01153939f, 
    0.02694438f, -0.00743979f, 0.01668696f, 0.00350842f, 0.02448076f, -0.04349157f, -0.01447608f, 0.00196200f, 
    -0.04671519f, -0.01868749f, -0.00969250f, 0.00074692f, 0.01250687f, 0.01496483f, 0.02569898f, 0.01412471f, 
    0.01359056f, 0.01559247f, 0.00505855f, -0.02749487f, -0.02621856f, 0.02823571f, 0.00835420f, -0.04054410f, 
    0.00484051f, -0.02624284f, 0.03045882f, 0.01902187f, 0.02285336f, -0.00761627f, 0.04019982f, -0.02997085f, 
    0.02476104f, 0.02127190f, 0.02923676f, -0.00059977f, -0.04775918f, -0.00746523f, -0.02394656f, 0.00116863f, 
    0.02219111f, -0.01324452f, -0.00354630f, 0.01397689f, -0.01000091f, -0.00351217f, 0.00575593f, 0.03018352f, 
    0.01666363f, 0.00048632f, -0.00020577f, -0.02906841f, -0.01847656f, -0.03623134f, -0.03528467f, -0.03954799f, 
    -0.03886132f, 0.02687647f, 0.00408314f, 0.02360764f, -0.00426280f, -0.02213308f, -0.03550790f, -0.01144802f, 
    -0.01736275f, -0.01957841f, -0.02644778f, -0.01980818f, -0.01978207f, 0.00855774f, -0.02527008f, 0.02944411f, 
    0.01465782f, -0.03402547f, 0.00973771f, -0.02845692f, 0.03344170f, 0.00623013f, -0.03235212f, 0.01092804f, 
    -0.00059839f, -0.00455997f, 0.00651475f, -0.00165436f, 0.01309149f, -0.04068957f, 0.01262303f, 0.00924041f, 
    -0.01567275f, -0.02380887f, 0.01195575f, 0.04021461f, -0.02818141f, 0.02741503f, -0.00088470f, -0.01959306f, 
    -0.03780019f, 0.03112071f, 0.02577360f, 0.04341878f, -0.01462322f, 0.00187304f, 0.02221813f, -0.02927022f, 
    -0.02400955f, -0.02214389f, 0.02292254f, -0.00382312f, -0.02120157f, 0.04632111f, 0.03135712f, -0.01648850f, 
    0.04077340f, -0.00974972f, -0.00348197f, -0.04070888f, 0.02525994f, 0.01459729f, 0.03013580f, -0.02562400f, 
    0.02098192f, 0.00985445f, -0.03104431f, -0.02301851f, 0.00754179f, -0.02753988f, -0.04409728f, 0.02347072f, 
    -0.03355583f, -0.00969763f, 0.02911475f, 0.02376089f, 0.02773172f, -0.01963133f, 0.02314870f, 0.01614244f, 
    -0.04046360f, -0.01879112f, 0.01660680f, -0.01257807f, -0.00510285f, -0.01728073f, -0.02576562f, -0.01439265f, 
    0.00653918f, -0.04263336f, -0.00111453f, -0.02700773f, 0.03074916f, -0.02596112f, 0.01568484f, -0.03465175f, 
    0.01135041f, -0.01750716f, -0.02622556f, -0.03906563f, -0.04252595f, -0.04514327f, 0.02686087f, 0.02342705f, 
    -0.00564589f, -0.01335758f, 0.02002570f, -0.02594534f, 0.02122083f, -0.01859031f, 0.03024298f, -0.00358881f, 
    0.01542086f, -0.02976841f, 0.01326484f, -0.02482463f, 0.01470814f, -0.03361971f, 0.01862210f, -0.01932872f, 
    -0.01757747f, 0.00156405f, -0.00487734f, 0.00857103f, -0.00645486f, -0.01547057f, -0.01864783f, 0.01049784f, 
    -0.01465517f, 0.01371894f, 0.03025833f, -0.01492208f, 0.03053248f, 0.01972084f, 0.00236332f, -0.03581747f, 
    0.00661824f, 0.03170473f, -0.01605189f, 0.00153686f, 0.01126568f, -0.01761296f, 0.02255917f, 0.04060744f, 
    -0.02249285f, 0.02056609f, 0.01909015f, -0.03942410f, 0.00407504f, 0.02650104f, 0.03479585f, 0.03127509f, 
    -0.00469120f, -0.01891119f, -0.04200832f, -0.03868892f, 0.01609680f, 0.02301741f, 0.02654989f, -0.04004836f, 
    -0.01079680f, 0.01975929f, 0.03887438f, -0.02007819f, 0.01241438f, 0.02101485f, -0.03049489f, 0.01552265f, 
    -0.03941262f, 0.03675341f, 0.01276898f, 0.01826583f, -0.02437125f, -0.03327870f, -0.01026539f, -0.02644139f, 
    0.01625399f, -0.00973831f, 0.02593134f, -0.00178261f, -0.02047194f, -0.00514244f, -0.00849325f, 0.00786833f, 
    -0.01363633f, 0.03147689f, 0.02249956f, -0.03594627f, -0.00427815f, -0.01497464f, 0.02213372f, 0.00496318f, 
    -0.02884264f, 0.03409138f, 0.03808527f, -0.02594515f, 0.02590324f, -0.02574078f, 0.02922841f, -0.02113756f, 
    0.02477554f, 0.01073900f, -0.02396031f, -0.00153587f, 0.00225986f, 0.02291618f, -0.03414585f, -0.01417908f, 
    0.03407934f, 0.01776253f, -0.03409530f, 0.01200083f, -0.00400563f, -0.00847258f, 0.01557616f, -0.01042887f, 
    -0.01726429f, 0.00437972f, -0.00790055f, -0.01665481f, 0.03526702f, 0.02630461f, -0.01372892f, -0.00636899f, 
    -0.00390463f, 0.02609817f, -0.00831975f, -0.03408721f, -0.00819734f, -0.01423387f, -0.03547782f, 0.03085171f, 
    0.01925587f, -0.02874942f, -0.01347700f, 0.01064092f, -0.02539955f, -0.01364939f, -0.02896309f, -0.00436419f, 
    -0.00805464f, -0.03222568f, -0.04186260f, -0.00157111f, 0.00099241f, 0.00193906f, 0.01929135f, 0.03682420f, 
    0.02780341f, -0.04129749f, 0.03527272f, -0.00630825f, 0.00559755f, -0.01532108f, 0.00737117f, 0.00184335f, 
    0.01873423f, 0.01353780f, -0.00367187f, 0.03940953f, 0.04343732f, -0.01185509f, 0.01470351f, 0.00274203f, 
    0.01498745f, 0.03367011f, 0.02389673f, -0.03358552f, -0.02652158f, 0.02558800f, 0.03088987f, -0.04100128f, 
    -0.00925334f, 0.01137129f, -0.01445806f, -0.04484254f, 0.03226190f, -0.02078062f, -0.03096367f, -0.04299384f, 
    -0.01732024f, 0.00774162f, -0.01114303f, 0.04534986f, 0.02189549f, -0.02849833f, -0.01016653f, -0.04407012f, 
    -0.00636385f, -0.03099317f, -0.01440406f, 0.01248817f, -0.02921352f, -0.00855186f, 0.04545804f, 0.02877330f, 
    -0.02189017f, 0.02211178f, 0.00896707f, -0.01060711f, -0.01081765f, -0.02763436f, -0.03886129f, -0.00587981f, 
    0.01472292f, -0.03431153f, -0.00097185f, -0.00000229f, -0.00411727f, -0.03158861f, -0.03203442f, -0.03631609f, 
    -0.00543934f, 0.04530267f, 0.01124771f, -0.00236239f, -0.02073619f, 0.01211870f, 0.03235020f, -0.03024966f, 
    -0.02706149f, -0.02807391f, -0.01096287f, -0.02240048f, -0.02599400f, 0.03061866f, -0.03142187f, 0.00815194f, 
    -0.03238446f, 0.02306971f, 0.04180530f, -0.01969261f, 0.02101816f, -0.03216095f, -0.04303313f, -0.03098620f, 
    -0.03156245f, -0.01348977f, -0.02451608f, -0.01465012f, -0.00630424f, -0.02639739f, 0.00861937f, -0.01075427f, 
    -0.03128462f, 0.03635907f, -0.03646056f, 0.01179609f, -0.02362398f, 0.00462291f, -0.03852159f, 0.01295969f, 
    -0.01851787f, -0.04616476f, -0.02372191f, 0.01114746f, -0.00875737f, -0.00660620f, 0.01461932f, 0.00931893f, 
    0.00989461f, -0.02544712f, -0.00170144f, 0.00320115f, -0.02181842f, 0.01374205f, -0.00965003f, -0.00373609f, 
    0.02116014f, -0.01683489f, 0.01402687f, 0.02979197f, -0.00543353f, 0.00711589f, 0.01968355f, -0.00556259f, 
    -0.00837918f, 0.02053667f, -0.02227022f, -0.01130655f, -0.00490923f, 0.01830803f, 0.04265520f, 0.00861617f, 
    -0.03121562f, 0.02683383f, 0.03532510f, -0.00460397f, 0.00702984f, 0.03605512f, -0.02316577f, -0.03937350f, 
    0.00837922f, 0.01027476f, 0.00518074f, 0.02800475f, -0.04088504f, 0.00307052f, -0.03052907f, 0.01778406f, 
    0.00961526f, -0.00396847f, -0.00249648f, 0.02909976f, -0.04176270f, 0.03117922f, 0.02304736f, 0.00509369f, 
    -0.03459459f, -0.00231422f, -0.01857244f, -0.03285806f, -0.03145511f, 0.02821494f, -0.01742667f, 0.00170578f, 
    0.00727592f, 0.01804555f, -0.01562207f, -0.00120775f, 0.00426119f, 0.00977557f, 0.00656018f, 0.03217636f, 
    -0.03327833f, -0.00905459f, 0.03616561f, 0.00242373f, -0.00547877f, -0.01037653f, -0.02713761f, -0.01803138f, 
    -0.01073293f, 0.04237004f, 0.02483645f, -0.00180683f, -0.03723014f, 0.02467781f, -0.02271545f, -0.02296337f, 
    0.01199178f, -0.00424512f, -0.01020657f, -0.00255984f, 0.02838840f, 0.01274927f, 0.02090037f, 0.02074804f, 
    -0.01802392f, 0.03039195f, -0.01090804f, -0.02314966f, 0.01097042f, -0.00507082f, 0.02935248f, -0.00467116f, 
    -0.03988155f, 0.02291898f, -0.00843325f, -0.04599726f, 0.00898197f, -0.04060989f, -0.02539643f, 0.00196714f, 
    0.00882380f, -0.00186487f, 0.02443235f, -0.00756118f, -0.01300649f, -0.03879689f, -0.00602451f, 0.00513098f, 
    -0.01426612f, -0.00753267f, -0.00690790f, -0.04087325f, 0.02577117f, 0.02056873f, -0.01932208f, -0.00128471f, 
    0.00176988f, 0.02241956f, -0.04745262f, 0.00260895f, 0.01860226f, 0.03262953f, 0.01924135f, 0.01096674f, 
    -0.01587149f, -0.04179507f, 0.03704746f, 0.01509902f, -0.03762834f, 0.01482992f, -0.00380758f, -0.00980264f, 
    -0.03027293f, 0.02700479f, 0.00101411f, 0.01723462f, 0.00973153f, -0.03047588f, 0.01619697f, -0.01688446f, 
    0.02650499f, 0.01182669f, -0.02711483f, -0.03228319f, -0.01762924f, -0.00567310f, -0.03792232f, -0.04472095f, 
    0.01283752f, 0.01994933f, -0.01465807f, -0.01122409f, 0.00544855f, -0.04534201f, 0.01265918f, 0.01350762f, 
    0.01392933f, 0.03166249f, 0.00161955f, -0.01732135f, -0.01198142f, 0.00255234f, -0.02112372f, -0.03624756f, 
    -0.01448642f, 0.00669915f, -0.02077072f, 0.01349545f, -0.04295681f, -0.00880276f, -0.01752542f, 0.00975713f, 
    0.02413967f, -0.01243365f, 0.03122959f, 0.03140040f, 0.02130838f, -0.03682900f, -0.01844939f, -0.03157557f, 
    0.00349532f, -0.00302189f, -0.03825047f, 0.03364937f, -0.03629792f, 0.01675515f, -0.02283156f, 0.00697678f, 
    -0.00872120f, 0.02565057f, 0.02462131f, -0.00762394f, -0.03242819f, 0.01104982f, -0.03415103f, 0.01818868f, 
    0.00340405f, 0.03679281f, -0.02697189f, -0.02237135f, -0.02844808f, -0.03732579f, -0.00186067f, 0.02497150f, 
    -0.01126642f, -0.00312244f, 0.02941685f, 0.00746799f, 0.00250188f, -0.02235479f, -0.03638378f, 0.03282961f, 
    0.01270273f, -0.00738744f, 0.01000447f, -0.02186456f, -0.02108205f, -0.03305200f, 0.03243771f, 0.02153887f, 
    -0.01185051f, -0.01385322f, 0.01539523f, -0.02694782f, -0.02916033f, -0.02005618f, -0.04223666f, -0.00208976f, 
    -0.01315526f, 0.01109658f, -0.02843541f, 0.00988733f, -0.01901078f, -0.04460259f, -0.04272557f, -0.03918768f, 
    -0.01726983f, -0.00416644f, -0.03249522f, 0.01531741f, 0.01411818f, -0.03323934f, -0.03957263f, -0.00095616f, 
    -0.02053021f, -0.01709980f, -0.00253588f, -0.04183979f, -0.00268780f, 0.02009666f, 0.00647725f, -0.02317411f, 
    -0.01692768f, -0.01070852f, 0.00052972f, -0.00804559f, -0.00636104f, 0.00747088f, 0.03053773f, 0.02336472f, 
    -0.03039898f, -0.02291929f, -0.00290140f, 0.02962046f, 0.01771385f, 0.01300900f, 0.01384469f, -0.01704347f, 
    0.17274053f, 0.08499232f, 0.04693918f, -0.04527086f, 0.08869561f, -0.05347095f, 0.12095428f, 0.01365421f, 
    0.08411912f, 0.00484513f, 0.02804886f, -0.08289033f, -0.06273255f, -0.14723435f, -0.12489246f, 0.01321105f, 
    0.05193065f, 0.01378169f, -0.08762902f, 0.07759773f, -0.10488184f, 0.06273665f, -0.11863368f, -0.20936264f, 
    0.06660757f, 0.04388243f, 0.04287056f, -0.00169755f, -0.01977695f, 0.01716388f, -0.09499248f, -0.08706371f, 
    -0.03692500f, -0.03698181f, 0.08405788f, 0.03917671f, -0.11605660f, -0.15449636f, 0.05732621f, -0.08740538f, 
    -0.15323706f, -0.18963434f, -0.05595697f, 0.02462147f, 0.07321434f, -0.30992565f, -0.21308543f, -0.07293639f, 
    -0.06473235f, 0.06454630f, -0.03175267f, 0.03468881f, -0.02809207f, 0.02083294f, -0.01894102f, 0.00365439f, 
    -0.07684410f, 0.02640475f, 0.19482163f, 0.07906033f, -0.21452463f, -0.29957098f, -0.14824153f, 0.16637926f, 
    0.31131321f, -0.03790445f, 0.05846772f, 0.10094341f, -0.02594859f, -0.12970680f, 0.01638531f, -0.02793985f, 
    -0.01934584f, -0.01076786f, 0.01163297f, -0.00537003f, -0.06832954f, 0.10098433f, 0.11162074f, 0.15114868f, 
    -0.01753482f, 0.17624639f, 0.05888527f, 0.00260124f, 0.03556227f, -0.08177326f, 0.22404286f, -0.03462825f, 
    0.14177656f, -0.12015452f, -0.05604337f, 0.02864042f, -0.09272081f, -0.14990041f, -0.01077614f, -0.00259174f, 
    -0.00312433f, -0.07605072f, -0.09328478f, -0.10681856f, -0.33957911f, -0.35514107f, -0.02240686f, 0.47520551f, 
    0.18901235f, 0.04741265f, -0.08043525f, 0.01424814f, -0.27746308f, 0.06637812f, -0.10993180f, -0.07542503f, 
    -0.04604781f, 0.05872184f, -0.13968545f, -0.03530128f, -0.09735276f, -0.09446351f, -0.02361658f, -0.05441241f, 
    -0.11727978f, 0.01830828f, -0.07844152f, 0.42196470f, 0.27555814f, -0.06154248f, 0.06112165f, -0.19752835f, 
    0.02311524f, -0.18123867f, -0.04468821f, 0.07042031f, -0.08939646f, -0.05729404f, 0.09276583f, -0.06488342f, 
    -0.23212902f, -0.04025658f, -0.08397283f, -0.24036987f, -0.18636982f, 0.07070122f, -0.09365373f, 0.07006996f, 
    0.13179615f, 0.02379069f, 0.00712591f, -0.01619322f, 0.04263989f, 0.04200852f, -0.14743750f, -0.07092812f, 
    0.04335682f, 0.19693962f, 0.00351421f, 0.04454651f, -0.05881941f, -0.07056025f, -0.11936213f, -0.11305037f, 
    0.18657370f, 0.24467994f, 0.27830479f, 0.21137267f, -0.33104154f, -0.00374600f, -0.06407844f, 0.14921911f, 
    -0.06206336f, -0.00717726f, -0.01053234f, -0.11246818f, -0.02890072f, 0.02896747f, 0.07296322f, 0.08385087f, 
    0.04294051f, -0.19378915f, 0.01038694f, 0.01248222f, 0.18254460f, 0.01007105f, 0.08648402f, -0.04349528f, 
    -0.01335138f, 0.00733636f, 0.05862337f, 0.02040929f, -0.00041705f, 0.03438807f, -0.08144617f, 0.01224610f, 
    -0.02324550f, -0.10157181f, -0.08184814f, 0.08946741f, -0.01801840f, -0.08263861f, -0.12222333f, -0.06678930f, 
    -0.24001473f, -0.35794410f, -0.17227869f, 0.20156017f, 0.12377904f, -0.20924523f, -0.12822537f, -0.06995158f, 
    -0.13326129f, -0.03334941f, 0.08928002f, -0.06465431f, -0.04166272f, -0.03498792f, -0.05219052f, -0.02010049f, 
    -0.09472078f, -0.04065193f, -0.01107883f, -0.27839133f, -0.05843332f, -0.00471413f, -0.13253027f, -0.13492209f, 
    -0.00567120f, 0.05221284f, 0.01618342f, 0.01965428f, 0.02758215f, 0.01817665f, -0.14973457f, -0.06677680f, 
    -0.02570478f, -0.19989924f, -0.03970419f, -0.04873933f, -0.07664517f, -0.17205843f, -0.05286893f, -0.00209000f, 
    -0.12357940f, 0.12488320f, 0.21330576f, 0.10041018f, 0.08121385f, -0.03222438f, -0.07726251f, 0.05139197f, 
    -0.16862045f, 0.11775463f, -0.00313915f, 0.02985481f, 0.00329211f, 0.02204833f, 0.04253352f, 0.04207049f, 
    -0.18261775f, -0.08213814f, -0.14384477f, -0.12066644f, -0.30057800f, -0.25311661f, -0.19822478f, -0.03518543f, 
    0.27805471f, 0.04703638f, 0.11191587f, 0.11573825f, -0.19443916f, 0.10382416f, -0.03487024f, 0.05868024f, 
    0.06961361f, 0.16469181f, 0.04209477f, 0.03234508f, 0.17187096f, 0.15396824f, 0.22617118f, 0.24822430f, 
    0.32030171f, 0.06724550f, 0.40222648f, -0.15765035f, 0.29825327f, 0.08848546f, -0.00182005f, -0.08863685f, 
    0.14216989f, -0.05630469f, 0.01143515f, 0.12821022f, -0.08049201f, -0.04262506f, 0.01354721f, -0.14160055f, 
    -0.06040418f, 0.17077865f, -0.05734059f, -0.13342707f, -0.26478690f, -0.15786789f, 0.02489398f, 0.17787625f, 
    0.02765917f, -0.25634751f, -0.07577181f, -0.09493117f, -0.16840832f, -0.06734436f, 0.07978279f, 0.07655463f, 
    0.01973211f, -0.03654103f, -0.05221954f, 0.03687186f, 0.00124900f, 0.04445957f, 0.00221901f, -0.31850117f, 
    -0.14527565f, -0.21902065f, 0.17620659f, -0.09427639f, 0.22995123f, 0.11291561f, 0.02929397f, -0.03298465f, 
    -0.05105904f, 0.05405052f, 0.04282984f, 0.07020634f, 0.13021150f, 0.07373201f, 0.11938699f, -0.03299441f, 
    0.14873970f, -0.01087615f, 0.12965930f, 0.21189982f, -0.68755215f, 0.21607040f, 0.05329411f, 0.31275159f, 
    -0.09298144f, 0.00743494f, 0.06780988f, -0.08653358f, 0.12924063f, -0.19572876f, -0.14454576f, 0.00552203f, 
    -0.01190550f, 0.06932147f, 0.12486867f, -0.00735135f, -0.04542089f, -0.03781357f, -0.09714168f, -0.18044776f, 
    0.02395612f, -0.01542199f, 0.01328881f, 0.18445989f, -0.08178490f, -0.01303966f, -0.06381325f, 0.01234788f, 
    0.02604423f, 0.00787847f, 0.13745829f, 0.02007684f, -0.04653304f, 0.01246399f, 0.07696614f, -0.06402355f, 
    0.03158215f, -0.13466467f, -0.00342215f, -0.03726645f, -0.20777185f, -0.37519968f, -0.08584129f, 0.42734030f, 
    -0.02441089f, 0.06179643f, -0.13019171f, 0.00503803f, -0.28159556f, 0.09244551f, -0.06320882f, 0.04882496f, 
    0.01378903f, 0.05648565f, -0.14620453f, 0.00883141f, 0.11538836f, 0.19935314f, 0.16952205f, 0.04715054f, 
    -0.44595125f, 0.43142745f, 0.49906743f, 0.12688817f, 0.19578046f, -0.14621878f, -0.02862704f, -0.10692608f, 
    0.05315828f, -0.02002482f, 0.04361904f, -0.04078035f, -0.04054853f, 0.01915646f, 0.08121985f, 0.06041531f, 
    -0.01009252f, -0.09172702f, -0.07395882f, -0.05548720f, 0.11688704f, 0.14092366f, -0.03885086f, -0.14716539f, 
    0.26857990f, -0.12530997f, 0.09699690f, 0.07441626f, 0.11345664f, -0.06013060f, -0.10703409f, 0.00556421f, 
    0.06808244f, 0.05531372f, 0.07055012f, -0.08675312f, 0.16113178f, 0.03615655f, 0.09722936f, -0.10358246f, 
    -0.18214665f, -0.30350968f, -0.04349652f, 0.02647456f, 0.01639694f, -0.03056761f, -0.04377888f, -0.09144288f, 
    -0.03015726f, 0.08972035f, 0.04631909f, 0.02839588f, 0.16923313f, 0.13083249f, -0.04654837f, 0.03133528f, 
    0.17597742f, 0.04148170f, 0.30220738f, 0.14652908f, 0.10451994f, 0.02338817f, 0.06400571f, 0.01847736f, 
    0.16457067f, 0.03709712f, 0.12102102f, -0.05669665f, -0.00918461f, -0.12187787f, 0.13283628f, 0.05461551f, 
    -0.07332607f, -0.05789617f, 0.05006278f, -0.16407444f, -0.13554099f, -0.06690901f, -0.14811812f, -0.20943497f, 
    0.07006432f, 0.12312201f, -0.00189721f, 0.03324102f, -0.03232701f, -0.06267440f, 0.00500228f, 0.08739430f, 
    0.03914038f, 0.13394567f, -0.01435965f, 0.05670187f, 0.09796752f, 0.04116549f, -0.08755524f, 0.04418579f, 
    0.03184255f, -0.06807507f, 0.00479528f, -0.01286952f, 0.16358170f, -0.22636873f, 0.00580012f, -0.02812734f, 
    0.27708343f, -0.09070528f, 0.09942940f, -0.06273976f, 0.05641570f, -0.20120405f, 0.00683423f, -0.04025704f, 
    -0.00198890f, -0.04784697f, 0.04236180f, 0.00214566f, 0.04763909f, 0.05786337f, 0.33046231f, 0.34580877f, 
    0.46252236f, -0.18981548f, 0.09929628f, 0.25291872f, 0.16570942f, 0.02369428f, 0.04905785f, -0.06150503f, 
    0.20597427f, -0.03099956f, -0.06137479f, -0.01102133f, 0.00758865f, 0.00142036f, 0.09585678f, 0.02427319f, 
    -0.06355768f, -0.05396210f, 0.03525015f, 0.15071669f, 0.26690149f, -0.06105673f, -0.11757191f, -0.16116361f, 
    0.18967280f, 0.02035075f, 0.09452213f, 0.06902745f, -0.05484517f, -0.01425475f, -0.04173296f, -0.00831345f, 
    0.03306875f, 0.06901705f, 0.00429658f, 0.11674462f, 0.21338315f, 0.04423075f, 0.02736553f, 0.21679679f, 
    0.38974896f, -0.11803125f, 0.22259337f, -0.43348849f, 0.09740797f, -0.03440366f, 0.09924953f, 0.00158191f, 
    0.11845853f, 0.02918564f, -0.01710284f, 0.03030504f, 0.02924937f, -0.12842806f, -0.03933509f, 0.10931976f, 
    0.15702461f, 0.01986139f, 0.05625793f, 0.08384587f, 0.50600481f, -0.06316444f, 0.28740796f, -0.26663512f, 
    0.11949591f, -0.03353679f, 0.04414637f, 0.06512965f, 0.12135313f, -0.08917589f, -0.08277238f, -0.02003821f, 
    0.02209298f, -0.06618182f, 0.02644918f, 0.06613112f, 0.12240295f, 0.04818469f, 0.08263558f, 0.21141998f, 
    -0.02301221f, -0.19222273f, -0.04247487f, -0.23115483f, 0.25143051f, 0.07835815f, 0.12176920f, 0.04389967f, 
    -0.01151183f, 0.20058833f, 0.11098179f, -0.00800311f, 0.03752991f, 0.12576537f, 0.13704568f, 0.04599665f, 
    0.05460310f, -0.07015647f, -0.02648525f, 0.01799484f, -0.23526071f, -0.41040152f, 0.23693655f, 0.24716401f, 
    -0.19362597f, 0.08470766f, 0.04072632f, 0.02180618f, 0.05114295f, -0.10227841f, -0.09979120f, 0.01909614f, 
    -0.01625807f, -0.03014467f, 0.14755689f, 0.18361358f, 0.18088412f, 0.43257469f, 0.18392739f, 0.17015064f, 
    0.02747045f, -0.11943402f, 0.00479318f, 0.10104526f, 0.11123875f, 0.15698817f, 0.02455689f, 0.01433188f, 
    0.05403734f, 0.02687427f, 0.03442638f, 0.12384771f, 0.01780535f, -0.00619192f, 0.00669180f, 0.04013018f, 
    -0.03377800f, -0.03812036f, -0.01636698f, -0.04633112f, 0.06027905f, -0.03299059f, 0.12409411f, 0.14952669f, 
    0.16228704f, 0.01185708f, -0.00794846f, -0.00762719f, -0.05586431f, 0.02347012f, 0.25362962f, 0.12973130f, 
    0.09901075f, 0.05112185f, 0.03660423f, -0.00729766f, -0.12824780f, -0.01851942f, -0.17972332f, -0.12430014f, 
    0.07670128f, 0.29948205f, 0.42251530f, 0.05095375f, 0.19542149f, 0.00367733f, 0.03274437f, -0.04787116f, 
    0.02455305f, 0.22016044f, 0.03004506f, -0.00238934f, 0.00834070f, -0.05186976f, -0.01710095f, -0.11657406f, 
    0.04911769f, -0.00191158f, 0.07752829f, 0.00469221f, 0.01377799f, 0.25030771f, 0.22948810f, 0.24422705f, 
    0.01536691f, -0.18294734f, -0.16011545f, -0.06826085f, -0.10828166f, 0.13822593f, -0.12348501f, 0.00431918f, 
    -0.03512902f, 0.03509099f, -0.05308761f, -0.06467409f, 0.01055988f, 0.15784235f, 0.07125793f, -0.01313151f, 
    0.21505815f, -0.21224269f, 0.29695255f, -0.07369366f, 0.02328734f, -0.01017257f, -0.00755888f, 0.11115481f, 
    0.09176067f, 0.02997279f, 0.04260824f, -0.00046266f, 0.03461466f, 0.02798990f, -0.05899643f, 0.02342889f, 
    0.04615836f, 0.01524338f, -0.06821474f, 0.02161102f, -0.29559189f, 0.34298700f, -0.09471145f, -0.06341580f, 
    -0.28945622f, -0.08510449f, 0.04372666f, 0.10962085f, 0.03537806f, 0.06180330f, 0.05584697f, 0.14132068f, 
    -0.06388472f, -0.05318660f, -0.00925439f, 0.01522741f, -0.07264671f, -0.00672591f, 0.10409436f, 0.01741019f, 
    -0.01147584f, 0.00591289f, 0.12635580f, -0.32524699f, 0.02439907f, -0.12113708f, -0.07012734f, 0.16223295f, 
    -0.01268126f, 0.10967641f, 0.17404337f, 0.09974124f, -0.09922628f, 0.02668165f, -0.10631423f, 0.01925324f, 
    -0.02798446f, -0.00085799f, -0.06428797f, 0.01288051f, 0.22700472f, -0.04535112f, -0.08038380f, -0.03385977f, 
    0.02655049f, 0.01903921f, -0.00067132f, -0.04339723f, -0.02476631f, -0.00322597f, -0.01219742f, 0.08929321f, 
    0.04321079f, -0.13707361f, -0.04064317f, 0.03216905f, -0.03938334f, 0.06453176f, -0.18422161f, -0.05773339f, 
    0.34449255f, 0.00751716f, 0.05569647f, 0.03335223f, 0.27460328f, 0.05110833f, 0.09169918f, 0.17921914f, 
    -0.12508433f, -0.07696647f, -0.05761633f, -0.12639824f, -0.11628249f, -0.04439905f, 0.01841938f, 0.11292978f, 
    -0.00409359f, -0.04699421f, -0.11715053f, 0.01387160f, 0.05275849f, 0.12229200f, 0.01804837f, 0.15448248f, 
    0.17599903f, 0.00878712f, 0.04192049f, 0.06485473f, 0.02411697f, 0.05027080f, 0.06083138f, 0.07437610f, 
    0.08687834f, 0.05230675f, 0.12152719f, -0.08682305f, 0.00427207f, -0.12270425f, -0.12943539f, -0.11885740f, 
    0.11988049f, 0.42709395f, 0.38003832f, 0.13579111f, 0.05640708f, -0.03329435f, -0.01701776f, 0.06607607f, 
    -0.08252584f, 0.06345195f, -0.05622756f, 0.12189795f, -0.00049485f, -0.08442244f, -0.02849449f, -0.14507899f, 
    -0.03317918f, 0.03164437f, 0.06276737f, -0.15433745f, 0.09658661f, -0.00487933f, 0.07486746f, 0.15497331f, 
    0.15619898f, -0.03051903f, -0.06778739f, -0.04833907f, -0.03214784f, -0.00369383f, 0.12916373f, 0.10233946f, 
    0.05050540f, 0.00468290f, 0.03061937f, -0.03254707f, -0.05740452f, 0.02168569f, -0.16021970f, -0.06636755f, 
    -0.02738159f, -0.02528354f, -0.28942519f, 0.06805331f, -0.13813804f, 0.00828110f, 0.03371884f, 0.04431858f, 
    -0.01062733f, -0.05115054f, -0.02163740f, -0.06838878f, -0.15665594f, -0.03134169f, -0.07917502f, -0.12938310f, 
    -0.04618007f, -0.04280720f, -0.15278849f, -0.02616147f, -0.08731417f, -0.26877204f, -0.03486563f, -0.06797200f, 
    -0.18401209f, 0.08101200f, -0.13351971f, 0.02073602f, 0.07582033f, 0.04689995f, 0.11280065f, -0.05112367f, 
    0.10341629f, 0.09965275f, 0.08678566f, -0.01139909f, 0.01269304f, 0.00048991f, 0.10004492f, 0.03693922f, 
    0.27816844f, 0.11271781f, -0.20413275f, 0.24066040f, -0.00274008f, 0.04708305f, 0.14378142f, 0.12370364f, 
    -0.06855666f, 0.13559125f, -0.10268091f, -0.09142619f, 0.07248085f, 0.02962520f, -0.09180816f, 0.18146615f, 
    0.03621504f, 0.00179477f, 0.01990334f, 0.11392528f, 0.13516150f, 0.19476962f, 0.31941864f, 0.07057287f, 
    -0.00034046f, -0.00902763f, -0.10485256f, -0.12812431f, -0.06533431f, 0.12979454f, 0.02116169f, 0.09404768f, 
    -0.11525880f, -0.09697343f, -0.10264009f, -0.09201363f, -0.04558988f, -0.03226658f, 0.04173305f, 0.13066229f, 
    -0.50613844f, -0.18479505f, -0.19216819f, 0.02150075f, -0.35953423f, 0.10426917f, -0.10535206f, -0.02605489f, 
    -0.16640675f, 0.03910308f, 0.07039521f, -0.05684451f, -0.05726023f, 0.04437029f, 0.09883181f, 0.05045804f, 
    0.00328706f, 0.06883779f, 0.12359767f, 0.09826791f, 0.68164885f, -0.87223828f, 0.17836055f, -0.37190402f, 
    -0.38508332f, -0.09579602f, 0.05621342f, 0.04171432f, 0.21022227f, 0.00905021f, 0.02849663f, -0.06880162f, 
    -0.03004005f, -0.03525229f, -0.13103576f, -0.05358644f, 0.05275107f, 0.04571947f, 0.01018566f, 0.16114670f, 
    0.16252960f, 0.27165291f, 0.06521315f, 0.18804167f, 0.05503093f, -0.02813547f, -0.03671318f, 0.01074694f, 
    0.00172541f, 0.06849364f, -0.15440954f, -0.00542621f, -0.06952603f, -0.03306345f, 0.06974385f, 0.18857503f, 
    -0.04884393f, 0.02496934f, -0.04037469f, 0.01716260f, -0.19009346f, -0.27724096f, -0.22948112f, -0.25625655f, 
    -0.19922848f, -0.20302385f, 0.04799555f, -0.02364988f, -0.02249553f, 0.09402031f, 0.24857901f, -0.12310965f, 
    0.02126008f, 0.03477183f, 0.00531879f, 0.08652410f, 0.07326886f, -0.05599384f, -0.02511222f, 0.01892798f, 
    0.24837399f, -0.42551824f, -0.51220071f, 0.04160142f, -0.42572063f, -0.00257626f, 0.00074079f, -0.03009345f, 
    -0.03264340f, 0.03597774f, -0.04681787f, -0.06551618f, 0.00824869f, -0.03046568f, -0.11920287f, -0.10944992f, 
    0.04174770f, -0.03874528f, -0.13919023f, 0.13004839f, -0.10534116f, -0.13948229f, 0.44407901f, 0.11496855f, 
    -0.01932184f, 0.24821156f, 0.03530286f, 0.01565519f, -0.09827492f, -0.06256805f, 0.05039142f, 0.02966296f, 
    0.01364661f, 0.11656606f, 0.06611933f, 0.00170474f, 0.16910842f, -0.11711370f, 0.09192354f, 0.19726188f, 
    0.10901657f, -0.03210091f, 0.11094504f, 0.04667837f, -0.18726282f, -0.04532060f, -0.08437338f, -0.10636774f, 
    0.00936313f, 0.12818193f, -0.09205803f, -0.09472036f, 0.03250371f, 0.04536759f, 0.12726782f, 0.02487110f, 
    0.08181401f, -0.09469872f, 0.10751642f, 0.08111046f, 0.09630766f, -0.04798869f, 0.19840959f, -0.10148177f, 
    -0.08721393f, -0.02748285f, -0.00454153f, 0.12627520f, 0.10325196f, 0.19197249f, -0.10153432f, 0.09738406f, 
    -0.05447268f, -0.15278596f, 0.04911678f, 0.05673712f, 0.04149355f, 0.00630975f, 0.02772026f, -0.08611624f, 
    -0.03696396f, 0.08287894f, 0.08817764f, 0.18356024f, 0.19132784f, 0.02553322f, 0.03236996f, 0.07674813f, 
    -0.01668918f, -0.03714120f, -0.01362487f, 0.10677598f, -0.01006491f, 0.05416017f, 0.01701625f, -0.09936641f, 
    -0.03380935f, -0.11342800f, -0.08121934f, -0.14145300f, 0.16059358f, 0.36126620f, -0.18330215f, 0.19878355f, 
    -0.09512472f, 0.08298201f, -0.13197693f, -0.01144037f, 0.05235970f, 0.20985310f, -0.08302186f, 0.03636825f, 
    -0.01006134f, 0.02366503f, -0.00931729f, -0.00894739f, -0.00163310f, 0.03084962f, -0.22032572f, -0.04585599f, 
    0.21013291f, 0.25119770f, -0.29589742f, 0.05232033f, -0.00515795f, -0.01123107f, 0.05992709f, 0.04163194f, 
    0.00858262f, 0.15738866f, -0.05289968f, 0.00346178f, -0.10899783f, -0.00610517f, -0.00421314f, 0.08977935f, 
    0.22856565f, 0.12413409f, 0.02376786f, 0.00814267f, 0.04332833f, -0.00419657f, -0.16685545f, 0.20137979f, 
    0.11892691f, 0.12610641f, -0.05519128f, 0.04836377f, -0.00723161f, -0.04423056f, 0.00976432f, 0.02521884f, 
    0.03983342f, -0.02204336f, 0.02551158f, -0.05931953f, -0.07009798f, -0.13581410f, -0.06569732f, 0.04429498f, 
    0.31524885f, 0.12046876f, -0.06120159f, 0.26655895f, 0.03091118f, -0.00092103f, -0.01565069f, 0.07071476f, 
    0.00025590f, 0.05032569f, 0.02901059f, -0.01843524f, -0.06167572f, 0.03115359f, -0.02517992f, -0.01629828f, 
    0.01824615f, -0.00781929f, -0.03503203f, -0.07159662f, 0.62965143f, 0.53690809f, -0.25336772f, 0.26870278f, 
    0.00406809f, 0.05592664f, -0.00666378f, 0.08650688f, 0.01315007f, 0.05874993f, 0.02205849f, -0.04912303f, 
    0.06953032f, 0.05890761f, -0.00562006f, -0.00084530f, 0.01373837f, 0.06761394f, 0.01500702f, 0.04240843f, 
    -0.68972933f, 0.03375981f, -0.01154574f, 0.35568327f, 0.02298518f, 0.12311962f, -0.04777044f, -0.02367409f, 
    0.10761156f, 0.07291087f, 0.19239651f, 0.02042700f, -0.07435683f, -0.05679179f, -0.07246083f, 0.04053599f, 
    -0.02292494f, -0.08236822f, 0.02657438f, 0.02479482f, -0.09842791f, -0.05151161f, 0.05892633f, 0.05045083f, 
    0.03146843f, 0.05720111f, 0.11502273f, 0.09471154f, -0.01617045f, 0.15057760f, 0.00523590f, -0.07123344f, 
    0.02038281f, 0.16194963f, 0.04101197f, 0.10239156f, 0.03069558f, -0.24599512f, 0.01127905f, -0.13448629f, 
    0.02824585f, -0.03949382f, 0.00862982f, -0.03186842f, 0.02310603f, 0.01128413f, -0.00964675f, 0.00921786f, 
    0.02245849f, -0.03784155f, -0.04632647f, -0.04583365f, -0.01304091f, 0.02402995f, 0.02457532f, -0.03788278f, 
    -0.03173672f, -0.01006547f, 0.01445582f, -0.03914839f, -0.01879525f, -0.01210839f, -0.04034617f, 0.01838822f, 
    0.02727659f, 0.02829327f, -0.04248790f, 0.01747940f, -0.02776068f, 0.02911012f, -0.04219978f, -0.01145966f, 
    0.01195558f, -0.02338186f, -0.01116617f, 0.02088855f, 0.02012563f, 0.01239093f, 0.02318609f, 0.02613549f, 
    -0.02657082f, -0.02771722f, 0.01336937f, -0.01730591f, 0.01786332f, -0.02572997f, -0.03690911f, 0.01063601f, 
    -0.00351143f, 0.02608349f, 0.00309415f, -0.03714991f, 0.02288402f, 0.00724329f, -0.01991350f, 0.00678649f, 
    -0.02584002f, -0.04108369f, -0.04003920f, 0.02688927f, -0.03089935f, -0.02706428f, 0.03156596f, -0.01268324f, 
    0.01051248f, 0.01142457f, -0.00316709f, 0.02464168f, -0.01805237f, 0.02288408f, -0.01481872f, -0.02180163f, 
    -0.04560008f, -0.00532555f, -0.02452890f, -0.04096546f, 0.03079619f, -0.02484863f, -0.01047310f, -0.01020318f, 
    -0.00732749f, 0.02135889f, 0.00587762f, 0.01022193f, -0.01849712f, -0.03031033f, -0.00443633f, -0.02355918f, 
    -0.02899100f, -0.00705863f, 0.03029584f, 0.01135517f, 0.01053982f, 0.01318000f, -0.04324996f, 0.01355216f, 
    0.02848326f, 0.03058038f, -0.04706379f, -0.00597530f, -0.00628090f, 0.00656183f, 0.02422187f, 0.00058611f, 
    0.01241373f, -0.00726871f, 0.00663878f, 0.01170499f, 0.02565546f, 0.02165777f, -0.01188116f, 0.00833340f, 
    0.02524849f, 0.01636649f, -0.00641537f, -0.01394443f, -0.02313445f, 0.02858296f, -0.00381230f, -0.00776450f, 
    -0.02723222f, -0.04650686f, -0.01718920f, 0.00701503f, 0.02734969f, -0.01730046f, -0.02380250f, 0.02964750f, 
    0.00283562f, -0.03676472f, -0.02854376f, 0.01057848f, -0.03599170f, -0.00875535f, 0.00425027f, -0.02144173f, 
    0.00314268f, -0.02838155f, 0.00111848f, 0.03056109f, 0.03188670f, -0.02906697f, -0.03695947f, -0.03458254f, 
    -0.01002954f, -0.00286231f, -0.04330935f, -0.03403795f, 0.01422514f, -0.01029990f, -0.02443974f, 0.00750251f, 
    -0.04301593f, 0.02692972f, 0.00929940f, 0.00775166f, 0.00672702f, -0.01561368f, 0.00958259f, 0.02720639f, 
    -0.03652654f, -0.02772323f, 0.01613953f, 0.00486589f, -0.03373008f, -0.03226313f, 0.00767687f, -0.00118306f, 
    -0.04215476f, -0.01825518f, -0.01960449f, -0.02229897f, 0.01797872f, 0.01146041f, 0.01875425f, -0.00557518f, 
    0.02764092f, -0.01720987f, 0.00119052f, -0.03568598f, -0.00071920f, -0.04477391f, -0.00229518f, 0.01965071f, 
    0.00844803f, -0.00454315f, 0.01930925f, 0.00353556f, 0.01133527f, -0.04248922f, -0.01153025f, 0.02917465f, 
    0.01988178f, -0.01790714f, 0.02218574f, 0.02773386f, -0.03336244f, -0.01824960f, 0.00025428f, -0.03674812f, 
    -0.03058151f, -0.02062069f, -0.00736210f, 0.01687370f, 0.02153835f, -0.00097446f, 0.02738353f, 0.00936568f, 
    0.02124634f, 0.00435324f, -0.03192797f, 0.01898625f, 0.02639920f, -0.02671158f, -0.00694180f, 0.02656738f, 
    0.02666746f, -0.03853326f, -0.00510026f, 0.01209014f, -0.03534143f, 0.00417908f, -0.02249430f, -0.02501296f, 
    -0.02436074f, 0.01468148f, -0.02728553f, -0.02628047f, 0.00968545f, 0.03232944f, -0.02713537f, 0.02664642f, 
    -0.03527790f, -0.04025605f, 0.02499984f, 0.01761229f, 0.00494242f, -0.01806380f, 0.00852531f, 0.01306924f, 
    0.02952803f, -0.03436003f, 0.00475338f, 0.02283549f, -0.04089879f, -0.01205372f, -0.01770554f, 0.02992479f, 
    -0.00619984f, 0.03056554f, 0.01741375f, 0.01697013f, -0.04699689f, -0.03539768f, 0.02527483f, -0.03694113f, 
    0.02420157f, 0.00160964f, -0.02324731f, 0.02967230f, 0.02912532f, -0.03877228f, -0.03443843f, 0.00858827f, 
    -0.02818170f, -0.03176254f, -0.03579355f, -0.00193310f, -0.04636698f, -0.01746971f, -0.03416125f, -0.02776206f, 
    -0.04397862f, -0.01300703f, 0.00759852f, -0.00501238f, 0.00855882f, 0.02139478f, -0.03291646f, 0.00397717f, 
    -0.03678746f, 0.00645858f, 0.02936932f, 0.00212692f, 0.00171032f, 0.02987416f, 0.01119242f, -0.02076648f, 
    0.00622737f, 0.02587336f, 0.02865280f, -0.00777271f, -0.03900027f, -0.03928796f, -0.04606526f, -0.04102106f, 
    0.00341867f, 0.02578788f, 0.02170316f, 0.00620936f, 0.02712654f, -0.04216783f, -0.04412773f, -0.03442201f, 
    -0.03854535f, -0.02542561f, -0.02338688f, 0.02834618f, 0.00920089f, -0.04026366f, -0.01967344f, 0.01792883f, 
    -0.01653454f, -0.01310522f, 0.00296728f, -0.02125658f, -0.00612324f, -0.03614390f, 0.01092975f, 0.02246252f, 
    -0.01872920f, 0.00497791f, -0.04133633f, 0.00044550f, -0.01688193f, 0.01030383f, -0.00116951f, -0.04263088f, 
    -0.03931953f, 0.00125619f, 0.01767204f, 0.00868502f, 0.00855968f, 0.02246230f, -0.00535915f, -0.00939796f, 
    -0.04234602f, -0.02271233f, -0.01300221f, -0.03401722f, 0.00977569f, -0.02810597f, 0.02082543f, 0.00386586f, 
    -0.03636869f, -0.02835312f, -0.04448352f, -0.01649149f, -0.03869900f, 0.01549906f, 0.01364242f, -0.03421059f, 
    -0.04627122f, 0.01210076f, -0.02287226f, 0.00830731f, -0.04465932f, -0.03142532f, 0.00220090f, 0.03172601f, 
    -0.03504184f, -0.00065873f, -0.03949967f, -0.00924175f, 0.00264590f, 0.01339857f, -0.03540115f, -0.03012956f, 
    -0.03735684f, -0.03568362f, -0.01127928f, 0.01121669f, -0.01986241f, -0.04478720f, 0.01133401f, 0.00012231f, 
    -0.02566902f, 0.01346606f, -0.01972344f, -0.02120654f, -0.00187948f, -0.00515546f, 0.02295851f, -0.01050925f, 
    -0.00649022f, 0.02590055f, -0.03921796f, -0.01624733f, -0.01482205f, -0.04591568f, 0.02506999f, 0.00741803f, 
    -0.00031635f, 0.00356748f, 0.00777278f, -0.03616823f, -0.00661960f, -0.01672438f, -0.01001487f, -0.02754368f, 
    0.00027156f, -0.01758357f, 0.01587980f, -0.02940713f, -0.04645549f, 0.00579013f, 0.01638931f, 0.00197792f, 
    -0.03610227f, 0.01335214f, -0.03164476f, -0.02153259f, 0.00851813f, -0.02670942f, -0.00920287f, -0.04442799f, 
    -0.04548055f, 0.02208410f, -0.00915740f, -0.03130036f, -0.02226952f, -0.02792830f, 0.01895797f, 0.02329762f, 
    0.02662258f, 0.01108211f, -0.01276212f, -0.02617435f, 0.00352397f, 0.03116675f, -0.01828567f, -0.00120294f, 
    0.02582332f, -0.00262810f, -0.02862719f, 0.02492367f, -0.03467400f, 0.00583726f, -0.00628752f, -0.00648600f, 
    0.01065284f, -0.00098331f, -0.01172500f, -0.02053302f, -0.01357012f, 0.01533362f, -0.04318384f, 0.00144102f, 
    -0.00343424f, -0.01088678f, -0.03815694f, -0.01340529f, -0.00391975f, -0.02054975f, -0.04269929f, -0.02875395f, 
    -0.02951844f, 0.02776477f, -0.04421971f, -0.00415735f, 0.01671997f, -0.03406561f, 0.00364036f, 0.03095957f, 
    0.01443086f, -0.01962396f, 0.00792970f, 0.02523081f, -0.00896495f, -0.03350350f, 0.00709075f, -0.03720935f, 
    -0.01499832f, -0.04649389f, -0.01158082f, 0.01059202f, 0.02015154f, 0.01588281f, -0.03816505f, -0.02872993f, 
    -0.03490707f, -0.03459323f, -0.03125961f, 0.01153391f, -0.03963304f, -0.02018264f, -0.04255886f, 0.02133356f, 
    0.02883624f, 0.00040382f, -0.01429971f, 0.01313943f, -0.01344830f, 0.00813911f, -0.00087847f, 0.00268135f, 
    -0.04646515f, 0.01421223f, -0.02522198f, -0.01760645f, -0.03357687f, -0.00493397f, 0.02770575f, -0.03043162f, 
    -0.00153461f, 0.02968904f, -0.01567216f, 0.00826831f, -0.01696214f, -0.01262497f, -0.00187181f, -0.02123326f, 
    -0.00002618f, 0.00135889f, -0.03676315f, -0.02167957f, -0.02938101f, -0.03577077f, 0.01542812f, -0.03042576f, 
    -0.04392653f, -0.03190439f, -0.02237524f, -0.03752515f, -0.03655711f, 0.02490852f, -0.00221745f, -0.00660758f, 
    0.03012929f, 0.03150281f, 0.02778933f, -0.02035232f, -0.00164430f, -0.02654231f, -0.02024076f, -0.04522535f, 
    -0.01416387f, -0.02019283f, -0.03400300f, 0.00215370f, -0.03197113f, 0.00328688f, -0.00734364f, 0.01520260f, 
    -0.00730202f, 0.02484561f, -0.03311531f, -0.01635910f, -0.04066997f, 0.00789793f, 0.00567929f, -0.02511768f, 
    -0.03450994f, 0.00054888f, -0.00701140f, -0.04300066f, -0.04376529f, -0.00103428f, 0.00394066f, -0.03655726f, 
    -0.02048963f, 0.03108748f, -0.00633430f, -0.04187046f, 0.01681385f, -0.02874337f, -0.01164498f, 0.02777591f, 
    0.02188563f, -0.02625569f, 0.02663260f, -0.00401811f, -0.03980807f, 0.01513002f, -0.03464300f, -0.02342301f, 
    0.02143714f, 0.00735593f, -0.04332461f, 0.01854740f, -0.03804881f, -0.00938530f, -0.02583655f, -0.02447612f, 
    -0.04387024f, 0.02521528f, 0.01836494f, -0.04656202f, 0.01494941f, 0.01930092f, -0.01679355f, -0.01124545f, 
    -0.00111766f, -0.04454588f, 0.00060875f, -0.04455461f, -0.01329138f, 0.02722196f, -0.02000696f, 0.01473414f, 
    0.02346174f, 0.02904054f, -0.00439241f, -0.03361228f, 0.00192742f, -0.01557410f, -0.04150102f, -0.04089564f, 
    0.00776505f, -0.02516435f, 0.00289863f, -0.02586930f, 0.02133779f, -0.04613110f, 0.00356970f, 0.01995735f, 
    -0.04271754f, -0.00536965f, -0.02814219f, -0.01019584f, -0.01262969f, -0.00593984f, -0.02014222f, 0.02267610f, 
    -0.00431538f, -0.00062944f, -0.03287343f, 0.00395059f, -0.01469272f, -0.04124480f, -0.01274839f, 0.00786337f, 
    0.01754011f, 0.01066347f, -0.02399693f, 0.00579531f, -0.02572500f, -0.02572487f, -0.00107817f, -0.02676110f, 
    -0.03489852f, -0.02948990f, 0.01872240f, -0.03269282f, -0.02561527f, 0.00640203f, -0.02692402f, 0.01473521f, 
    -0.04374924f, 0.02463249f, -0.01079891f, 0.00128046f, -0.04343283f, -0.01564282f, 0.01226362f, -0.02996585f, 
    -0.02339340f, -0.02910032f, 0.01981553f, 0.00609555f, -0.01705185f, 0.03022902f, 0.02441294f, -0.03552138f, 
    -0.00516920f, -0.04686434f, -0.03157571f, -0.04340411f, 0.02799656f, -0.00531592f, 0.03171953f, -0.00469434f, 
    -0.02510393f, -0.03469801f, -0.03163818f, 0.02533068f, 0.01725624f, -0.00994083f, 0.03153750f, -0.02479229f, 
    0.02214376f, -0.01660116f, -0.04124737f, -0.01458048f, -0.00539263f, 0.02215371f, -0.00287547f, -0.01028315f, 
    -0.00515665f, 0.01351866f, 0.03042834f, -0.01457336f, -0.02190223f, -0.01757549f, -0.01398513f, -0.04139230f, 
    -0.04285495f, -0.03393459f, 0.02044057f, -0.01843647f, -0.00064311f, -0.00081736f, -0.01197036f, 0.02035305f, 
    -0.00731467f, -0.02553971f, 0.02078471f, -0.03359282f, -0.02733789f, -0.01791351f, 0.02149523f, -0.03945519f, 
    0.00644805f, -0.00417753f, 0.02379256f, -0.01300018f, 0.00663987f, -0.02318304f, -0.04354393f, -0.01309822f, 
    0.02662428f, -0.04042023f, -0.00346785f, 0.00406340f, -0.04145890f, -0.02663818f, 0.02017742f, -0.02936322f, 
    -0.01375440f, -0.01187761f, -0.04234115f, -0.01627810f, 0.02613105f, -0.03034472f, -0.02844836f, -0.03030184f, 
    -0.04457072f, -0.01531672f, 0.02700419f, 0.02375473f, -0.03949234f, 0.02392947f, -0.00219521f, 0.01797142f, 
    0.01441205f, -0.04525927f, -0.01817289f, -0.00141339f, 0.02968113f, 0.03307958f, 0.01657045f, 0.00804845f, 
    -0.03000222f, -0.00571752f, -0.04101135f, 0.02942564f, -0.02581583f, -0.03693566f, -0.02375761f, 0.01348295f, 
    0.01579350f, -0.01574941f, 0.02840520f, -0.04324694f, -0.02078267f, 0.01102139f, -0.03942733f, -0.00388621f, 
    0.01648937f, 0.01065345f, 0.03435868f, -0.01866759f, -0.01622132f, -0.04534522f, 0.00579859f, -0.00032009f, 
    -0.02674146f, -0.00761013f, -0.03378519f, 0.00406537f, 0.01309786f, -0.04596079f, -0.02251196f, -0.00239520f, 
    -0.02483929f, -0.00068297f, -0.02286743f, -0.00072647f, 0.00191142f, 0.02961452f, 0.01268231f, -0.03905354f, 
    -0.02458493f, -0.01942781f, -0.01391696f, 0.02282421f, 0.00266026f, 0.01521363f, 0.02511840f, -0.04374726f, 
    0.01998769f, -0.03903376f, 0.00506102f, -0.04738361f, 0.00692995f, -0.03717074f, 0.00311351f, -0.03599038f, 
    -0.03506335f, 0.01422388f, -0.02467006f, -0.01296783f, -0.01145075f, -0.04472269f, -0.02526193f, 0.02047965f, 
    0.01644714f, 0.01572363f, -0.04283782f, 0.01757955f, 0.00082544f, 0.00454339f, -0.00881707f, 0.01356071f, 
    0.00929060f, 0.02329955f, -0.01842579f, -0.01687771f, 0.01057898f, -0.04204139f, -0.03385138f, -0.01158180f, 
    -0.02903714f, 0.01434904f, -0.03622096f, 0.00737613f, -0.02459573f, -0.01902840f, -0.00116941f, 0.00955860f, 
    -0.00529275f, -0.00017026f, 0.01132999f, -0.00346991f, -0.02573822f, -0.04461222f, 0.02452689f, -0.00897058f, 
    0.01427293f, -0.03673543f, 0.00265243f, 0.01358649f, 0.02564372f, -0.04542118f, -0.04456516f, -0.02724712f, 
    0.02071905f, -0.04060038f, -0.03337502f, -0.04213306f, -0.02849259f, 0.01769533f, -0.04613528f, 0.02730570f, 
    -0.00653231f, 0.00473547f, 0.02348447f, -0.01495572f, -0.02542252f, 0.01431534f, -0.02716902f, -0.02370084f, 
    0.03691192f, 0.01853902f, -0.04335646f, -0.02921721f, 0.01009393f, 0.00899890f, 0.00908985f, -0.02733698f, 
    -0.01321762f, -0.02292570f, -0.01174856f, 0.02944584f, -0.00627176f, -0.02824467f, -0.02984342f, 0.02775765f, 
    0.01879238f, -0.02657798f, -0.00179423f, -0.02664645f, 0.01440654f, 0.01176380f, 0.00861107f, 0.02720072f, 
    -0.01639107f, -0.02498914f, -0.03245291f, -0.01817816f, -0.03216220f, -0.02965943f, 0.00451540f, -0.00853766f, 
    0.02500507f, -0.03930698f, 0.02555565f, 0.01420908f, -0.02045966f, 0.03352629f, -0.03706898f, -0.01277418f, 
    -0.03459638f, -0.01682994f, 0.00125591f, -0.03513942f, -0.00410499f, -0.01282912f, 0.01234758f, 0.03468334f, 
    -0.00017933f, 0.03918332f, 0.02903002f, 0.01145966f, 0.01352774f, -0.03368772f, 0.03388110f, -0.00451070f, 
    0.02437796f, 0.01637264f, 0.02000811f, 0.00938113f, -0.01260413f, -0.01245241f, -0.04003689f, 0.00501404f, 
    0.01712390f, -0.02295477f, -0.01600150f, -0.03454285f, 0.02301284f, 0.00788384f, 0.03507606f, -0.00178776f, 
    0.02837152f, -0.04120779f, 0.01682286f, -0.01261449f, -0.02840548f, -0.03527066f, -0.00846903f, -0.02930498f, 
    -0.04228445f, -0.04098302f, 0.00922438f, -0.00094706f, 0.02566390f, 0.00937400f, -0.00848101f, -0.03737209f, 
    -0.00318316f, 0.03550262f, 0.00530723f, -0.01828446f, -0.00360122f, -0.03001861f, -0.00270634f, -0.00430541f, 
    -0.02560020f, -0.01128185f, 0.02873657f, 0.02317640f, 0.01092340f, 0.03324158f, -0.01338747f, 0.02071664f, 
    0.02824126f, 0.02250412f, -0.02048972f, -0.00240867f, 0.01244599f, 0.02361261f, -0.02002315f, 0.01259379f, 
    -0.02874617f, 0.00645422f, 0.02690158f, 0.02577515f, 0.01119545f, 0.01572216f, -0.02799070f, -0.01151774f, 
    -0.04100823f, -0.00554516f, 0.01430110f, -0.03883893f, -0.02509623f, 0.00255286f, -0.00039086f, -0.00822896f, 
    0.02106853f, -0.01584851f, -0.02158412f, -0.03307375f, 0.02523728f, 0.01149514f, 0.02020116f, 0.03243577f, 
    -0.01830081f, 0.01961699f, -0.02515509f, 0.02835901f, -0.03656841f, 0.03079314f, 0.00502544f, 0.00624581f, 
    -0.03558637f, 0.02780752f, 0.02689202f, 0.00355962f, 0.01828190f, -0.03901232f, -0.01633109f, -0.01145266f, 
    -0.03794106f, 0.01521896f, 0.00799895f, -0.00148319f, -0.03007893f, 0.00962455f, -0.01053125f, 0.02433587f, 
    -0.03463360f, -0.04252343f, 0.02591769f, 0.00557771f, -0.03579387f, 0.01826959f, -0.02865041f, -0.00021157f, 
    0.01068530f, 0.01866131f, -0.04204038f, -0.03579704f, -0.01048322f, -0.00877372f, 0.02032936f, 0.00118829f, 
    -0.04279425f, -0.01351573f, 0.02902099f, -0.03722125f, 0.02734007f, 0.00330936f, 0.00108440f, 0.03373009f, 
    -0.01886554f, 0.00834192f, 0.03096102f, 0.02998058f, -0.04262626f, -0.04256438f, 0.02202610f, -0.01094673f, 
    -0.03256003f, -0.03938903f, 0.01883529f, -0.01873731f, -0.02158034f, -0.00470719f, -0.04125622f, 0.01626918f, 
    -0.02604332f, -0.02603565f, -0.03441791f, 0.03093858f, -0.00470939f, -0.03254982f, 0.00263246f, 0.02837405f, 
    0.02002148f, 0.00303315f, 0.01957549f, -0.01753129f, 0.01505627f, 0.00121983f, -0.03861767f, 0.00400103f, 
    -0.03743321f, 0.01409111f, -0.04187617f, -0.00712350f, -0.00999330f, 0.00712525f, -0.02167900f, -0.01205394f, 
    0.02009913f, -0.01122946f, -0.04199472f, -0.01557704f, -0.01664506f, 0.01881951f, 0.02780896f, 0.01557263f, 
    -0.00480423f, -0.04359224f, -0.01741316f, -0.02049503f, 0.00827124f, 0.00431249f, -0.03056385f, -0.01205373f, 
    -0.00556316f, -0.04270211f, 0.02105986f, -0.03908891f, 0.00018483f, -0.03479345f, 0.00825041f, -0.02611399f, 
    -0.02372799f, 0.00419550f, -0.00584621f, -0.01589301f, 0.02350578f, -0.00252550f, 0.02200877f, -0.00030140f, 
    -0.03301895f, 0.00540977f, 0.00677079f, 0.00772918f, -0.01569997f, 0.00893694f, 0.01875690f, 0.01694658f, 
    -0.02760038f, -0.02642924f, -0.04538045f, -0.01206665f, 0.02795873f, 0.01440015f, -0.00289193f, -0.01991191f, 
    0.00339685f, 0.03213796f, -0.04322524f, -0.02317705f, 0.01414252f, -0.04224138f, -0.00019568f, -0.02063229f, 
    0.00705710f, 0.02049092f, 0.02471049f, 0.02036533f, -0.02949677f, 0.01566734f, -0.03832646f, 0.02125068f, 
    0.01133425f, 0.01256292f, -0.01838518f, -0.01870281f, 0.02462662f, 0.02133898f, -0.02782724f, -0.02981294f, 
    0.02639300f, -0.02958077f, 0.00995601f, 0.01198385f, -0.01915382f, 0.02765737f, 0.01388858f, 0.02787891f, 
    -0.03933213f, -0.02677146f, -0.01330137f, 0.01110866f, 0.02824789f, -0.02255922f, -0.03130142f, 0.01388049f, 
    -0.04182025f, -0.03155851f, -0.03489388f, 0.02144682f, 0.02864270f, -0.01662103f, 0.01837734f, -0.01962498f, 
    -0.02502662f, 0.00286437f, 0.01770685f, -0.01040655f, -0.00426160f, -0.01048413f, -0.02869809f, -0.01261926f, 
    -0.02966579f, 0.00134283f, -0.02952169f, 0.01324235f, 0.00145356f, -0.03495451f, -0.03427753f, 0.00793881f, 
    -0.03292197f, -0.01642098f, 0.00498095f, 0.00440670f, 0.02180307f, -0.00694402f, -0.02853286f, -0.00082021f, 
    -0.01709305f, -0.02955665f, 0.02442609f, -0.03562565f, 0.01723899f, -0.02076855f, 0.01057052f, 0.01372178f, 
    -0.02314875f, -0.01131757f, 0.00946845f, 0.01812370f, -0.02885159f, -0.03120166f, -0.00638408f, 0.01918721f, 
    -0.00176339f, -0.01480154f, -0.01728367f, 0.00556388f, -0.03633390f, -0.03245027f, 0.00148433f, -0.01430828f, 
    -0.00390800f, -0.01549179f, 0.00296278f, 0.02325433f, 0.01593745f, -0.02435745f, 0.00062968f, -0.02788589f, 
    -0.03053484f, -0.04196265f, -0.03991602f, -0.03089335f, -0.03568566f, 0.02002899f, -0.01719547f, 0.02195926f, 
    -0.03572933f, -0.02026442f, 0.01167169f, -0.02547705f, 0.03518751f, 0.02201800f, 0.02690954f, 0.01107171f, 
    0.02839195f, 0.03906429f, 0.01123826f, -0.03600524f, 0.02778497f, -0.02306705f, -0.00382572f, -0.00153861f, 
    0.02978262f, 0.01664539f, -0.02337535f, -0.00489016f, -0.03167850f, 0.01475326f, -0.00148988f, 0.02716027f, 
    -0.17017090f, -0.11554071f, 0.04307729f, -0.27762771f, 0.01030082f, 0.08799600f, -0.12983692f, -0.08526299f, 
    -0.02630655f, -0.12220872f, -0.01367393f, 0.10819127f, 0.10203753f, -0.12885050f, 0.15784828f, 0.11699985f, 
    -0.00707727f, 0.05577895f, -0.06049274f, 0.03508134f, 0.01544718f, 0.16745079f, 0.06720815f, -0.20551935f, 
    -0.08109631f, 0.12079460f, -0.14701034f, -0.05690518f, 0.07277597f, 0.06266607f, -0.16606800f, 0.13449858f, 
    -0.12378041f, 0.00002940f, -0.01678773f, -0.13450904f, -0.03617876f, 0.03533559f, 0.20410264f, 0.05944173f, 
    -0.08353222f, -0.13456661f, 0.18641286f, -0.03657875f, 0.19216131f, -0.07862989f, 0.04065361f, 0.04443753f, 
    0.09403960f, 0.13413081f, 0.06027737f, 0.09159165f, 0.00647023f, 0.06354734f, 0.05323450f, 0.10042388f, 
    -0.03893403f, -0.22706097f, 0.29768202f, -0.04247613f, -0.34961447f, -0.21735747f, 0.56587297f, 0.20092379f, 
    0.31730801f, 0.03575219f, -0.11444510f, 0.28560773f, -0.17608681f, 0.01165032f, -0.01913822f, 0.07013384f, 
    0.12997042f, -0.02042499f, -0.05871373f, 0.06517841f, -0.07065327f, -0.11378835f, -0.24216725f, 0.15461104f, 
    -0.19462480f, -0.04280743f, -0.03765133f, -0.03185109f, -0.02712046f, 0.08416630f, -0.18198347f, -0.14455767f, 
    -0.00002383f, -0.04967044f, -0.02703400f, 0.12155250f, 0.02230522f, 0.02704531f, 0.22933999f, 0.09359442f, 
    0.15350443f, -0.08852333f, 0.04387490f, 0.00378234f, -0.18993269f, -0.28340229f, 0.33011383f, 0.17279667f, 
    -0.14114714f, 0.13500121f, -0.01403445f, 0.21801516f, -0.07042241f, 0.09717303f, 0.02484598f, -0.03272847f, 
    -0.23558101f, 0.17033957f, 0.13025407f, -0.02523823f, 0.00531136f, -0.03944413f, 0.10108950f, 0.09543350f, 
    0.26959991f, 0.29287416f, 0.55691171f, 0.04298140f, 0.18025300f, 0.03136188f, 0.11775734f, 0.24964194f, 
    -0.01942683f, 0.09881805f, -0.26728112f, -0.24106008f, -0.06450700f, -0.17502724f, -0.04552659f, 0.06093376f, 
    0.00165426f, 0.25188798f, -0.19229273f, 0.11767742f, -0.73831213f, 0.40377691f, 0.14554751f, -0.01715504f, 
    -0.11428513f, 0.04191621f, -0.06566031f, -0.14100718f, -0.08808667f, 0.02202573f, -0.01789292f, 0.15487219f, 
    -0.05879955f, 0.05852641f, 0.05043741f, -0.21588758f, -0.00387036f, 0.16827196f, -0.01253353f, -0.13032101f, 
    -0.07884521f, -0.43385109f, -0.09554283f, 0.24011779f, -0.21690311f, 0.28485173f, 0.03380370f, 0.47835237f, 
    0.29115587f, 0.04741056f, -0.15555577f, 0.07038184f, -0.41099435f, -0.06178344f, 0.10717878f, 0.05699043f, 
    -0.01356565f, -0.04532388f, 0.06567363f, 0.16779862f, 0.05845058f, -0.17253524f, -0.03950410f, -0.23670612f, 
    -0.10670045f, 0.06512065f, 0.04571860f, 0.07376540f, -0.07931985f, 0.10216498f, -0.03270845f, 0.04778510f, 
    0.07174487f, 0.00903401f, 0.03692821f, 0.20331374f, 0.00736141f, 0.03998828f, -0.04209195f, -0.04728087f, 
    -0.14569528f, -0.00183329f, 0.35045010f, 0.25173801f, 0.07485985f, -0.05290379f, 0.16887757f, -0.11580095f, 
    -0.13525479f, 0.05944231f, 0.10808921f, 0.01738382f, -0.10981611f, 0.06388309f, 0.02713781f, 0.07691415f, 
    -0.05807006f, -0.25649416f, 0.04970289f, -0.14129579f, -0.09446171f, 0.08575353f, -0.00661870f, -0.24139766f, 
    -0.18515228f, 0.14325987f, -0.12231098f, 0.01403719f, -0.06242418f, 0.07258134f, -0.07688134f, 0.11489640f, 
    -0.14600612f, 0.00891394f, 0.05169212f, 0.00330599f, -0.05993885f, 0.09190899f, 0.07735399f, 0.02593258f, 
    0.35771489f, 0.23953266f, 0.47429579f, -0.12144899f, -0.06487749f, -0.07482069f, -0.16421954f, -0.07517772f, 
    0.00749902f, 0.01516755f, -0.02810412f, 0.01814091f, -0.10970805f, -0.02695245f, -0.06416975f, 0.05783862f, 
    -0.08871930f, -0.00856096f, -0.03595010f, 0.01826320f, -0.33290449f, -0.16672419f, -0.38789716f, 0.21636590f, 
    0.05836815f, -0.06305563f, 0.11753301f, -0.04139157f, 0.02675325f, 0.04576371f, -0.14412038f, 0.07399892f, 
    0.03430038f, -0.01878847f, 0.05291326f, -0.06336880f, 0.11561986f, -0.04409475f, 0.03358724f, 0.22414733f, 
    0.19424778f, 0.02648588f, 0.05859750f, -0.21479416f, 0.11202492f, 0.05168844f, 0.22203869f, 0.27975613f, 
    -0.14102474f, 0.05545479f, -0.08789410f, -0.12512429f, 0.02056032f, -0.07392525f, -0.11819547f, 0.04569085f, 
    -0.13439369f, 0.22656146f, -0.04521628f, -0.07488022f, -0.16068187f, 0.10640159f, 0.40487435f, 0.00296649f, 
    0.03529977f, 0.04821896f, -0.03583206f, 0.01615658f, -0.01553746f, -0.03241926f, -0.02241130f, -0.01796613f, 
    -0.02008552f, -0.09593904f, 0.05474987f, 0.04297332f, 0.00654751f, -0.15165991f, 0.01770783f, -0.06036928f, 
    0.04172202f, 0.03620347f, -0.01755385f, -0.02919438f, 0.02867838f, 0.11036024f, -0.09493557f, -0.01832694f, 
    0.14000222f, 0.17111781f, -0.10839952f, -0.06408527f, -0.10859055f, 0.10815047f, -0.01632577f, -0.28783989f, 
    -0.00396226f, 0.10163516f, -0.07057281f, 0.13797483f, -0.71776348f, 0.43129894f, 0.22231977f, -0.05816524f, 
    -0.00259463f, 0.01820762f, -0.06739327f, -0.16082938f, 0.49378645f, 0.07533972f, -0.10007849f, 0.04280759f, 
    0.02594941f, 0.13687305f, 0.30418715f, -0.11806403f, -0.06453461f, -0.05597831f, 0.33722049f, 0.08714207f, 
    -0.15234570f, -0.19410518f, 0.03641580f, 0.33701494f, -0.02266779f, 0.03429749f, 0.12747625f, 0.18887478f, 
    0.03162789f, 0.19819799f, 0.03259982f, 0.01038364f, -0.31351858f, 0.05814528f, 0.09282402f, -0.00047092f, 
    0.00401421f, -0.05482543f, -0.11722849f, 0.09302549f, -0.20012362f, -0.34686995f, -0.25239938f, 0.20687994f, 
    0.09799799f, -0.03590556f, 0.14223817f, -0.09653930f, -0.09636260f, 0.07226147f, -0.15291956f, 0.06813935f, 
    -0.07993686f, 0.03777641f, -0.05235585f, 0.03658630f, 0.07319511f, -0.18443421f, 0.19137780f, 0.15523860f, 
    -0.08278412f, 0.52762866f, 0.63611662f, 0.10501906f, 0.20701590f, -0.09343684f, -0.17500705f, -0.41120955f, 
    -0.03917343f, 0.00451107f, -0.09621385f, 0.00684408f, -0.07662441f, 0.02439583f, 0.04980366f, -0.05491469f, 
    -0.10707401f, 0.05459524f, 0.02996401f, -0.00469349f, -0.20109175f, -0.38434830f, 0.30820242f, 0.01829493f, 
    0.08020288f, 0.07476649f, -0.15383653f, 0.03290972f, 0.40396300f, -0.08665828f, -0.19683604f, -0.00121381f, 
    -0.02430521f, 0.15690729f, 0.08536226f, -0.10904221f, -0.05053649f, -0.01339317f, 0.14716484f, 0.10689777f, 
    -0.34597868f, -0.29431567f, -0.16774008f, 0.25277478f, 0.03136608f, -0.06267707f, 0.05444542f, -0.14617492f, 
    0.03676045f, 0.17105544f, -0.05702634f, 0.02493364f, -0.07972559f, 0.06034944f, 0.00463846f, 0.07705862f, 
    0.07752346f, -0.00752321f, 0.19504443f, 0.22520968f, 0.28696525f, 0.18048280f, 0.06768610f, -0.02556080f, 
    0.05487609f, -0.12754458f, 0.22554150f, 0.21925509f, 0.01112020f, 0.04850675f, -0.02505434f, -0.14441523f, 
    -0.01119368f, -0.19043264f, -0.08159387f, -0.02122110f, -0.01313782f, 0.04051421f, 0.02604108f, 0.00721968f, 
    0.09578603f, 0.07613438f, 0.13725704f, -0.04811901f, -0.12085564f, -0.06047275f, -0.04651482f, -0.06565797f, 
    -0.02794210f, 0.08739763f, 0.04066571f, 0.05450082f, 0.01479578f, -0.04380811f, 0.07348719f, 0.05246421f, 
    0.04124281f, 0.07193327f, 0.04837127f, 0.01989914f, 0.15507032f, -0.01169541f, -0.14105190f, 0.36510324f, 
    0.38231194f, -0.04387683f, 0.24359402f, 0.17365725f, 0.00913038f, 0.05755978f, 0.07440276f, 0.04642665f, 
    -0.04786250f, -0.08028210f, -0.10122738f, 0.15745634f, 0.00224263f, 0.08247451f, 0.02227246f, 0.10796075f, 
    0.40048712f, -0.01768571f, -0.03071841f, 0.10983024f, 0.20819338f, 0.20836286f, 0.12375758f, 0.39356276f, 
    -0.09065362f, -0.06014734f, -0.09347917f, 0.00212173f, 0.08306290f, -0.12938581f, 0.00339560f, 0.03981397f, 
    -0.02164881f, 0.18111354f, -0.14647117f, -0.03661862f, 0.11134689f, 0.02106604f, -0.03673673f, 0.32960692f, 
    0.14565115f, -0.06764252f, 0.09994093f, 0.09780901f, -0.17315672f, -0.07987377f, -0.02125009f, -0.06874731f, 
    0.04088273f, -0.00375166f, 0.08481858f, 0.14807779f, -0.01366531f, -0.12645209f, -0.10206457f, 0.34085768f, 
    0.10614546f, -0.14319251f, -0.09224322f, 0.00213640f, -0.06483643f, -0.14138655f, 0.11071228f, -0.05757533f, 
    -0.19227526f, 0.10267424f, -0.13927528f, 0.01215092f, -0.02277681f, 0.08591975f, 0.04710824f, 0.00143989f, 
    -0.08629788f, -0.12922543f, -0.04894916f, 0.11398335f, 0.17797647f, -0.04634085f, -0.05569650f, 0.13870035f, 
    0.28269109f, 0.00988536f, 0.11380564f, 0.05213531f, -0.04645455f, -0.06497658f, -0.09103727f, 0.03500628f, 
    -0.16464314f, -0.07107881f, 0.09001222f, -0.08905309f, -0.01860197f, 0.06588102f, -0.04597398f, -0.04957912f, 
    0.09628258f, -0.06709860f, 0.21238273f, 0.10744280f, -0.28776386f, -0.01198851f, -0.02688030f, 0.18038206f, 
    -0.10004121f, 0.04979368f, -0.02720442f, -0.09500797f, -0.13293487f, 0.04742797f, 0.11577142f, -0.05979839f, 
    -0.12011060f, 0.16366693f, -0.03733600f, -0.24484605f, -0.19688463f, -0.49402446f, 0.00093316f, 0.38816097f, 
    0.20458026f, -0.12827849f, 0.15282446f, -0.02118538f, -0.22754215f, -0.00754380f, -0.20693468f, -0.01504550f, 
    -0.10818871f, 0.02319954f, -0.08715454f, -0.06506111f, 0.16350664f, -0.06772886f, 0.05445649f, 0.18490067f, 
    0.01323132f, -0.04393181f, 0.00508991f, -0.01455488f, -0.00753093f, -0.01375019f, -0.01645369f, -0.00952252f, 
    0.01571107f, 0.02898042f, -0.02634690f, -0.01241704f, -0.01453207f, -0.04400895f, 0.01372376f, 0.02580150f, 
    -0.04096961f, -0.03061208f, 0.00179535f, 0.01488864f, 0.02644710f, 0.00175389f, -0.03407470f, 0.02986118f, 
    -0.03217743f, 0.00404426f, 0.02067229f, -0.01402655f, -0.00719139f, -0.03731634f, -0.01477097f, -0.02721448f, 
    -0.01456198f, -0.04413925f, -0.03129892f, 0.00910578f, -0.01286941f, 0.03186750f, -0.01895525f, 0.01693122f, 
    0.01703527f, 0.02304933f, -0.02875829f, -0.00314958f, 0.01903155f, -0.02475639f, -0.02124122f, 0.02167037f, 
    -0.02661400f, 0.02937282f, -0.04282793f, 0.02580844f, -0.02642749f, 0.02907396f, -0.01646317f, -0.00065513f, 
    -0.02392310f, -0.02469913f, 0.01195242f, 0.00884564f, 0.01260968f, -0.00120751f, -0.03746735f, -0.01024766f, 
    0.02153028f, -0.03596319f, -0.03358833f, 0.01470080f, -0.02546979f, -0.03135989f, -0.02488192f, 0.02341776f, 
    0.02851842f, -0.03536031f, -0.03366962f, -0.00576518f, -0.01889020f, 0.01798000f, 0.02745418f, 0.01307808f, 
    -0.01934408f, -0.00201568f, 0.01336491f, 0.01152166f, -0.01188068f, -0.01160181f, 0.01778343f, -0.03072405f, 
    0.02337171f, 0.02954570f, -0.02393295f, -0.01859701f, 0.02476961f, -0.02064623f, -0.04720585f, -0.02750306f, 
    -0.03821782f, -0.02189889f, -0.01121260f, 0.00760278f, 0.00873773f, -0.01915349f, 0.01858035f, 0.00949170f, 
    -0.00798107f, -0.02827669f, -0.01468867f, 0.01379655f, 0.01167978f, -0.00624451f, 0.00962315f, 0.02900340f, 
    -0.02147382f, -0.02597692f, -0.04181282f, 0.00211505f, 0.01144921f, -0.03714562f, -0.04438298f, 0.00601521f, 
    0.02878006f, -0.01983166f, 0.03908968f, -0.01508561f, 0.02146505f, -0.03717643f, -0.01484402f, -0.03411476f, 
    -0.01257665f, -0.03499198f, -0.04138301f, -0.01577300f, 0.00727334f, -0.03045460f, 0.00383415f, 0.02458324f, 
    -0.03811071f, -0.00838620f, -0.03982043f, 0.01994710f, -0.01428960f, 0.01418641f, 0.00326414f, -0.01887553f, 
    -0.02987335f, -0.01504732f, -0.01372231f, 0.00533665f, 0.00582522f, -0.01195343f, -0.01407634f, -0.04638175f, 
    0.02685638f, -0.03304877f, 0.03277160f, -0.01063212f, -0.01030301f, -0.02481181f, -0.04245955f, -0.00243592f, 
    0.02345031f, -0.01344854f, -0.01776711f, 0.02793169f, -0.02366398f, 0.00662806f, 0.02934308f, -0.00714884f, 
    0.00857447f, 0.00822723f, -0.01451057f, 0.02350096f, -0.03690730f, -0.04213212f, 0.01924592f, -0.03003565f, 
    -0.02424725f, 0.01302116f, 0.02149494f, -0.00387376f, 0.02195764f, -0.00459465f, -0.01670253f, 0.01598782f, 
    0.03247229f, 0.01375351f, -0.01687703f, 0.03748358f, 0.02074783f, -0.03268249f, -0.01895691f, -0.03866997f, 
    0.02787958f, 0.02786320f, -0.04178061f, -0.02274536f, -0.03690423f, -0.00107034f, 0.03015992f, -0.00746291f, 
    0.01820320f, 0.01344385f, -0.02507963f, 0.00881437f, -0.01354506f, 0.00239858f, 0.02732962f, -0.03909111f, 
    0.01497629f, 0.01410855f, -0.00479179f, -0.03074071f, 0.02244877f, 0.01992058f, -0.02715999f, -0.03316581f, 
    0.01841442f, -0.01776052f, -0.02803301f, -0.02961951f, -0.03779026f, 0.03815431f, -0.01135249f, 0.01382244f, 
    0.04012844f, -0.01023420f, 0.00555215f, 0.00814333f, 0.02029479f, -0.03395405f, 0.00207537f, -0.03250504f, 
    -0.00676203f, 0.01526928f, -0.02109731f, -0.01192461f, 0.00207412f, -0.02510270f, -0.03537045f, 0.03665563f, 
    0.00520328f, 0.02926973f, 0.00740768f, 0.00682872f, -0.04062940f, 0.02922356f, 0.03266774f, -0.02968467f, 
    -0.00321587f, 0.00625587f, -0.01452221f, -0.01475701f, 0.03072146f, -0.04744514f, -0.03143558f, 0.00323570f, 
    -0.00534512f, -0.01869292f, -0.03985483f, -0.03262492f, 0.01344052f, -0.03662311f, 0.02722886f, -0.01729471f, 
    -0.03405543f, -0.03072120f, -0.04541295f, -0.03840648f, -0.00718963f, -0.03111829f, -0.04474314f, -0.00576914f, 
    -0.02689967f, -0.03855219f, -0.04002758f, -0.00157896f, -0.04052616f, 0.00080758f, 0.00845982f, 0.02329006f, 
    -0.01711492f, 0.02970095f, 0.01592843f, -0.01854239f, 0.01947875f, 0.02854465f, -0.03605002f, 0.00057017f, 
    0.00404149f, 0.02794094f, 0.01525380f, -0.00623371f, 0.02869208f, -0.01587950f, 0.01743695f, -0.01720311f, 
    -0.03001136f, 0.00020493f, -0.04703249f, -0.02258741f, -0.00541462f, -0.01956022f, 0.00098543f, -0.04112279f, 
    0.01448733f, -0.00190359f, 0.01934137f, -0.02369745f, 0.01215896f, 0.02442049f, 0.01417760f, 0.03180096f, 
    -0.01039089f, 0.02882094f, -0.00851643f, 0.00975862f, -0.01478319f, -0.03353694f, -0.02811201f, -0.01323606f, 
    0.02273037f, -0.02781719f, -0.02953770f, -0.02502003f, -0.02886864f, 0.03094480f, 0.02335305f, -0.02002903f, 
    -0.00917882f, -0.00010705f, -0.04404480f, -0.01549056f, -0.03824214f, -0.00109995f, 0.01219331f, -0.00019087f, 
    0.02391978f, 0.02407747f, -0.00342055f, 0.02936430f, 0.01219161f, -0.00626860f, -0.02028003f, 0.00339203f, 
    0.00718756f, 0.02893288f, 0.02008387f, -0.03395977f, -0.00374931f, 0.02194588f, -0.02108573f, 0.00162765f, 
    0.00197740f, 0.01196377f, -0.01174557f, 0.00083783f, 0.01987761f, 0.02791250f, 0.02337614f, -0.00436009f, 
    -0.03249216f, -0.03216195f, -0.03160448f, -0.02286742f, -0.03199792f, 0.02150480f, -0.02200912f, -0.01490498f, 
    -0.01744700f, 0.01437096f, 0.02709461f, -0.01845548f, -0.04270751f, 0.01958143f, 0.01106410f, -0.01580019f, 
    -0.03807779f, 0.02837463f, -0.00722956f, 0.01521407f, 0.00647818f, -0.03994771f, 0.00327171f, 0.01573434f, 
    -0.01840585f, -0.00101972f, 0.00929733f, -0.02758019f, -0.02699675f, 0.02606348f, -0.02552527f, -0.02609384f, 
    -0.04163967f, -0.00270123f, 0.00360114f, -0.02514150f, -0.04215780f, -0.00302762f, 0.00649539f, -0.02819706f, 
    0.02396524f, 0.01273401f, -0.04069633f, 0.01734678f, -0.01913119f, -0.03590896f, 0.01157813f, -0.00827212f, 
    0.03315970f, -0.00907564f, -0.00198119f, 0.01665251f, -0.04397543f, -0.04016244f, 0.00454053f, -0.03373154f, 
    -0.03991359f, 0.02500275f, -0.00674983f, -0.03523836f, -0.01432102f, -0.02411597f, -0.00184321f, -0.01040529f, 
    -0.04706985f, 0.00003000f, 0.00318659f, 0.02134064f, -0.02797580f, -0.02579957f, -0.01910269f, -0.01793783f, 
    0.01788632f, 0.00702555f, 0.02226606f, 0.02128021f, -0.01444874f, -0.03646148f, -0.01676388f, -0.00925500f, 
    0.02153968f, 0.01822162f, -0.01953193f, -0.04487003f, -0.00984345f, -0.01541540f, -0.00591713f, -0.01735581f, 
    -0.00332279f, -0.00100395f, -0.03946224f, -0.00460530f, 0.01544550f, -0.00158999f, -0.00501580f, 0.02481663f, 
    0.01377135f, -0.01931554f, -0.01517637f, -0.00292724f, -0.02952436f, 0.02384286f, -0.01383842f, 0.00582812f, 
    -0.00323563f, -0.04572589f, -0.01183663f, -0.02033073f, 0.01430139f, -0.02888670f, 0.00659878f, 0.00987018f, 
    -0.01361357f, 0.02908132f, -0.04705173f, 0.00838996f, 0.02457913f, -0.04757394f, -0.01432969f, -0.00736866f, 
    -0.03885350f, -0.00298942f, -0.02223890f, -0.03927413f, 0.02117125f, 0.01985705f, -0.04328541f, 0.00993002f, 
    -0.02420011f, 0.02524097f, 0.00460163f, -0.00378659f, -0.01835082f, -0.04668735f, -0.04421254f, 0.01616240f, 
    0.03042189f, 0.03037652f, 0.00385552f, 0.00669436f, -0.03329465f, 0.00616529f, 0.02499382f, 0.00673917f, 
    0.03228037f, -0.03289702f, 0.00863263f, -0.00590157f, -0.03300828f, -0.03990079f, -0.03069155f, -0.01264114f, 
    0.01330868f, -0.00903041f, -0.01816733f, 0.00777241f, 0.01861380f, -0.00278279f, -0.01609070f, 0.00206826f, 
    -0.00993410f, -0.00803429f, -0.00292709f, -0.00452161f, -0.00164711f, -0.03147226f, 0.00239717f, -0.01299744f, 
    -0.02080463f, -0.03712859f, -0.00334868f, 0.02151158f, -0.02469802f, -0.02490684f, -0.00248459f, -0.00556180f, 
    -0.00711501f, -0.01822058f, -0.03045902f, -0.01133176f, -0.03155477f, 0.01747610f, 0.00021801f, 0.01619397f, 
    -0.00881612f, 0.02893200f, -0.02094157f, -0.00872310f, -0.03527186f, -0.00954886f, -0.02602603f, 0.01577758f, 
    0.00881965f, -0.01711423f, -0.01425652f, -0.02614678f, -0.02855542f, -0.04471626f, 0.02367308f, -0.03151708f, 
    0.02518222f, -0.03402242f, 0.00770753f, 0.01492089f, -0.01241203f, 0.00852056f, -0.01568179f, -0.02919252f, 
    -0.03301010f, -0.04113969f, -0.02740213f, 0.01810493f, -0.00273465f, -0.03080658f, 0.02836099f, 0.02032453f, 
    -0.00717737f, 0.00512979f, -0.00565268f, 0.01981017f, -0.03038206f, -0.02962412f, -0.03579838f, -0.00541446f, 
    -0.04583308f, -0.04053264f, -0.03544327f, -0.01152748f, -0.04105452f, 0.00533886f, 0.03114457f, -0.01615436f, 
    0.03022510f, 0.02468646f, 0.02871919f, -0.03301085f, 0.01023217f, -0.02545440f, -0.00648572f, 0.00511152f, 
    -0.04290589f, 0.01084298f, 0.00057307f, 0.02087141f, 0.02126069f, -0.04119074f, -0.02572685f, 0.01009257f, 
    -0.03368972f, -0.03000875f, 0.03106023f, -0.01707026f, -0.03765601f, -0.00004839f, 0.01723165f, -0.04447589f, 
    0.00880578f, 0.01613263f, -0.02405978f, -0.04594240f, 0.02463030f, -0.00268841f, 0.01905519f, 0.00987796f, 
    -0.01503432f, -0.00185451f, 0.00121320f, 0.02482723f, 0.03291383f, -0.01621679f, 0.04222099f, 0.00705363f, 
    0.02039578f, -0.02073237f, -0.04154256f, 0.01490613f, -0.00034495f, 0.01072648f, -0.01582911f, 0.00267510f, 
    0.19113655f, -0.30009586f, -0.18975206f, 0.24863483f, 0.14368360f, 0.02798795f, -0.00519289f, -0.16566439f, 
    0.03749733f, -0.01193733f, -0.02381027f, -0.13256116f, 0.13258857f, 0.16892891f, 0.12468147f, -0.03325600f, 
    -0.08063855f, 0.05761534f, -0.02105068f, -0.19153139f, -0.12044007f, -0.14000745f, -0.36669335f, -0.09773433f, 
    0.04098020f, 0.03135743f, -0.12982306f, -0.01766684f, -0.06970731f, -0.23238568f, -0.19179687f, 0.01885749f, 
    -0.08486145f, 0.00986666f, 0.13382453f, -0.00725397f, 0.09520671f, 0.28852579f, -0.09788381f, -0.09866077f, 
    0.22533610f, 0.24803773f, 0.20680803f, -0.05236969f, -0.09728251f, 0.44672680f, 0.10043218f, -0.09564088f, 
    -0.05704163f, -0.14111510f, 0.02243286f, -0.11205903f, 0.12427489f, -0.01763972f, -0.02468694f, -0.10072457f, 
    0.07092407f, -0.10995264f, -0.11156019f, 0.17842095f, 0.30951023f, 0.27758497f, 0.26026174f, -0.04063020f, 
    -0.18547659f, 0.02533439f, -0.05587669f, -0.04883295f, 0.03256104f, -0.18453257f, 0.00882880f, 0.00429238f, 
    0.18443896f, 0.08407363f, 0.07049755f, -0.10927522f, -0.14079562f, -0.07184333f, 0.01988100f, -0.04891441f, 
    0.14795527f, -0.20365931f, -0.07245122f, 0.01113073f, 0.07619368f, 0.00077349f, 0.07413791f, -0.14491369f, 
    0.06165978f, 0.05512162f, 0.06984917f, -0.07725021f, 0.15827061f, 0.09629136f, 0.04426681f, 0.07209989f, 
    -0.12941958f, 0.02441350f, 0.01221484f, 0.22204535f, 0.15314989f, 0.11475080f, 0.34105632f, -0.18398912f, 
    -0.09962936f, 0.24952988f, -0.17491093f, 0.18993650f, 0.01340138f, 0.07202777f, 0.24200059f, 0.03993336f, 
    0.20164335f, -0.03763712f, 0.17817272f, 0.08194202f, 0.13671423f, 0.03289275f, 0.07713207f, 0.16250362f, 
    0.08372264f, -0.22023983f, -0.16745597f, 0.13699904f, 0.07085095f, -0.03547595f, -0.03687062f, 0.13503475f, 
    0.13246644f, 0.20737994f, -0.09343600f, -0.14824861f, 0.03023590f, -0.10741504f, -0.03762851f, -0.00985255f, 
    0.28856507f, 0.22547887f, -0.00885922f, 0.09483618f, -0.43531826f, -0.08844246f, -0.50330156f, 0.00974614f, 
    0.10719163f, -0.05648014f, 0.05742775f, 0.00967779f, -0.07918169f, -0.25300571f, 0.00612356f, -0.00478014f, 
    -0.04819698f, -0.16689253f, 0.16094819f, -0.14762530f, -0.17348850f, 0.22132736f, 0.07881924f, -0.11617962f, 
    -0.08763256f, 0.36586097f, 0.09759410f, 0.22705728f, -0.14294298f, 0.07266009f, -0.01932297f, 0.11996874f, 
    -0.03769483f, -0.00240296f, -0.19300240f, 0.08980178f, 0.13194449f, 0.03589144f, -0.00246958f, -0.00865004f, 
    -0.00648038f, 0.20428208f, 0.10960392f, -0.06832977f, -0.15796736f, 0.03757980f, -0.16378027f, 0.06062393f, 
    -0.04181293f, 0.01717168f, 0.05135880f, -0.23430650f, -0.11398187f, -0.03958798f, -0.18834773f, 0.02121679f, 
    -0.01267284f, 0.19554125f, 0.05619512f, -0.09105905f, 0.11969699f, 0.15556201f, -0.08870146f, -0.10430709f, 
    0.08865334f, 0.12030096f, 0.24857327f, -0.09950181f, -0.05031949f, 0.22306439f, 0.01942109f, -0.00687814f, 
    -0.03354601f, -0.04606545f, 0.03561313f, -0.04726028f, 0.11324806f, 0.07507910f, -0.00437972f, -0.01075974f, 
    0.04943680f, -0.04947057f, -0.03469453f, 0.35207745f, 0.03026345f, -0.14316782f, -0.21988782f, -0.13822080f, 
    0.20649654f, -0.08699451f, -0.04436048f, -0.05622502f, -0.12661554f, -0.31490016f, -0.06255805f, -0.00624401f, 
    0.07642099f, 0.09824692f, 0.13980852f, 0.11181545f, 0.03830118f, 0.32781699f, -0.25904444f, -0.09095844f, 
    -0.24596471f, -0.25567311f, -0.47026163f, -0.16574626f, -0.24874212f, 0.13958764f, 0.07887499f, -0.08013016f, 
    -0.08812473f, -0.06418109f, -0.00270184f, -0.09018384f, 0.14117035f, -0.09615482f, -0.00080368f, -0.04608269f, 
    0.26911482f, 0.14458366f, 0.08420848f, 0.15675114f, 0.25026000f, 0.33702314f, 0.27639049f, -0.01954510f, 
    -0.10707737f, 0.08500275f, 0.04343871f, 0.21184215f, 0.02057420f, -0.11218608f, -0.05440069f, -0.05412166f, 
    -0.06820290f, 0.06718954f, 0.09232850f, -0.14207068f, -0.16950709f, -0.02069662f, -0.22368228f, -0.17164873f, 
    0.18309453f, -0.36098906f, 0.13607752f, 0.27162954f, -0.07033104f, -0.04081082f, 0.17609818f, -0.00361946f, 
    0.05444008f, 0.17248383f, 0.12188911f, 0.04029029f, 0.08007029f, -0.04552304f, 0.22433674f, 0.06336500f, 
    0.17224383f, 0.04285521f, 0.06713612f, 0.26508191f, 0.11827901f, 0.04861400f, -0.07615209f, -0.11836525f, 
    -0.00867811f, 0.13905254f, 0.07132919f, 0.10958616f, -0.00223203f, -0.05539040f, -0.08246180f, -0.05425294f, 
    0.01943479f, 0.03252713f, 0.08001452f, -0.10239575f, -0.00543937f, -0.02982007f, 0.07485013f, 0.27658123f, 
    0.27721873f, 0.30300987f, -0.12913997f, 0.01313842f, 0.07559077f, 0.08702551f, 0.15533671f, 0.09507797f, 
    0.11241644f, -0.05403006f, -0.02528178f, -0.07581268f, -0.11993943f, 0.09011316f, -0.08657604f, -0.11251694f, 
    -0.12793961f, 0.03874554f, -0.15233313f, -0.16771983f, 0.06129137f, 0.35681400f, -0.34464863f, 0.00280659f, 
    0.00492735f, 0.06040920f, -0.06606673f, -0.12932806f, 0.20886379f, 0.43261233f, -0.08128277f, 0.22170880f, 
    -0.03651054f, -0.23600405f, -0.12430628f, 0.21063714f, -0.18478823f, 0.16808534f, 0.20205590f, 0.46662787f, 
    0.04053671f, 0.32249859f, 0.27023697f, -0.03672621f, -0.00492321f, 0.01894666f, 0.07078349f, 0.09883315f, 
    -0.16184413f, -0.04072948f, -0.07466840f, 0.10617224f, 0.11599879f, 0.09567727f, -0.01154111f, 0.12355220f, 
    -0.02831061f, 0.15107977f, 0.06378217f, 0.21144164f, -0.05024873f, 0.57686114f, 0.25922018f, -0.08932693f, 
    0.00238200f, 0.09858355f, 0.08332696f, 0.16850294f, 0.12952243f, -0.03972839f, 0.01136521f, -0.05558015f, 
    -0.00406521f, 0.02027645f, 0.13490954f, -0.06015457f, -0.15412755f, -0.16110305f, 0.08355585f, 0.06587233f, 
    -0.38830274f, -0.32901093f, -0.74978817f, -0.22615300f, -0.33750254f, 0.18216605f, 0.07191110f, 0.09624664f, 
    -0.10722647f, -0.03829152f, -0.07390135f, -0.02866182f, 0.04759156f, -0.04967883f, -0.08424325f, -0.15090966f, 
    0.05773386f, -0.02687723f, 0.02712520f, -0.02030152f, 0.56591874f, -0.11035018f, 0.64754927f, 0.02480488f, 
    -0.09581085f, 0.21328595f, 0.01616414f, -0.00887297f, 0.14453498f, 0.12239319f, 0.17204358f, 0.11149841f, 
    0.07906795f, -0.07148585f, 0.19035730f, 0.28275910f, -0.02653963f, 0.13162123f, -0.11694514f, 0.27338445f, 
    0.21399368f, 0.33037773f, 0.20237331f, -0.15437303f, 0.03439480f, 0.14142071f, 0.11413098f, 0.19476666f, 
    -0.11369678f, -0.03441843f, -0.05680279f, -0.04460844f, -0.02399892f, -0.04684332f, -0.08919629f, -0.02031335f, 
    -0.20841412f, 0.07754418f, -0.18905939f, -0.12793261f, 0.23508240f, -0.21325867f, -0.03894760f, 0.21061961f, 
    -0.07942288f, -0.19545238f, -0.01207150f, -0.00346861f, 0.01438714f, -0.04897290f, -0.16781226f, 0.14713211f, 
    0.02164843f, 0.11784824f, -0.06179631f, 0.08457211f, 0.29185131f, 0.21992925f, -0.03250450f, 0.16722247f, 
    -0.11998045f, -0.05959033f, -0.13395029f, 0.10110480f, -0.05959118f, 0.05604266f, 0.03094847f, -0.01151271f, 
    -0.15394586f, -0.04408630f, -0.06975529f, -0.07266407f, -0.00539448f, 0.21550857f, 0.08731443f, -0.11077368f, 
    0.00040653f, 0.30624652f, -0.16321196f, -0.22704898f, 0.27012336f, 0.20447454f, 0.41197994f, -0.07680145f, 
    -0.00965161f, -0.03528618f, -0.13602839f, 0.00123955f, 0.08406351f, 0.04616098f, 0.11240482f, 0.18612382f, 
    0.05084753f, -0.03404306f, -0.05122282f, 0.04911467f, -0.11946803f, -0.03539321f, -0.15812945f, -0.13366015f, 
    0.30151519f, -0.00758305f, 0.20692854f, 0.27145746f, 0.01995717f, 0.13979501f, 0.02598042f, -0.09242004f, 
    -0.03512222f, -0.03501971f, -0.17725241f, 0.17713633f, -0.06322211f, -0.07685374f, -0.06002241f, 0.07344334f, 
    0.01117285f, 0.12170778f, 0.07566538f, -0.01851807f, -0.04716013f, -0.11135311f, 0.58715302f, 0.14522372f, 
    0.01170479f, 0.00679382f, -0.13935286f, 0.00821494f, 0.00203763f, -0.12457620f, -0.18712637f, 0.00029287f, 
    -0.07266931f, 0.12585832f, 0.00454063f, -0.14651154f, -0.14943124f, 0.10936874f, -0.10364468f, -0.22604856f, 
    0.05262792f, -0.21598293f, 0.22727717f, 0.06305039f, 0.04298610f, 0.08798863f, -0.03027002f, -0.15725483f, 
    -0.06230816f, -0.09106499f, -0.18715943f, -0.01418563f, -0.21331099f, 0.09802388f, -0.02794468f, -0.09306522f, 
    -0.10783916f, 0.13966072f, -0.01716631f, -0.13425833f, 0.13585849f, -0.06635515f, 0.30185282f, 0.14916863f, 
    -0.11380477f, 0.00955882f, -0.01151982f, -0.09047931f, 0.00824081f, -0.08056034f, -0.02888150f, 0.06821685f, 
    -0.04663933f, 0.01825150f, -0.04466169f, -0.07240207f, -0.13096967f, -0.02963110f, 0.06394511f, 0.05600256f, 
    -0.15279886f, -0.09362932f, 0.22586463f, 0.20863259f, 0.21239756f, -0.01934797f, -0.07362990f, -0.12770920f, 
    0.21891625f, -0.00750260f, -0.08145159f, 0.15161985f, -0.09071026f, 0.02128544f, -0.10154016f, -0.03019937f, 
    0.09270285f, 0.20454168f, -0.17103156f, 0.17182137f, 0.08702996f, 0.49155900f, -0.15247935f, -0.00238354f, 
    0.04026766f, -0.06994322f, 0.06109780f, 0.04980379f, -0.13956203f, 0.09493743f, -0.06285282f, -0.00343182f, 
    -0.05991301f, -0.06604102f, -0.11847614f, 0.03243810f, -0.12879200f, -0.19326127f, 0.13517985f, -0.24268338f, 
    -0.02529055f, 0.03406353f, -0.01982602f, -0.04202851f, -0.01714777f, -0.04114753f, -0.02311463f, -0.01187419f, 
    -0.04322084f, 0.02921398f, -0.03193714f, -0.03971626f, -0.02587709f, -0.03410343f, 0.02395914f, -0.03657385f, 
    0.00130482f, 0.02002131f, -0.02551490f, 0.00862517f, 0.03685304f, -0.00207849f, 0.00721534f, 0.03120120f, 
    -0.02868391f, -0.03067214f, -0.04781146f, -0.03359379f, 0.01751614f, -0.02252027f, -0.04773036f, 0.02395467f, 
    0.01362632f, -0.04621767f, -0.00848930f, 0.00375914f, -0.00463384f, -0.03999512f, -0.02311665f, -0.04262850f, 
    -0.02215927f, -0.00939934f, 0.01708079f, -0.00067409f, -0.03624762f, 0.02874977f, -0.02494898f, -0.02848045f, 
    -0.03143062f, 0.02427185f, -0.01595229f, 0.00437671f, -0.00894865f, 0.00468674f, 0.01639900f, -0.01029611f, 
    -0.03921801f, 0.01681739f, 0.00404620f, -0.01726623f, 0.00694670f, -0.03013226f, -0.00775136f, -0.02794533f, 
    -0.02974434f, -0.03701814f, 0.01584866f, -0.04036824f, -0.02440603f, -0.03922493f, -0.02642199f, 0.00628048f, 
    0.00216428f, 0.01858349f, -0.03876694f, -0.00697836f, 0.02092165f, -0.04043138f, -0.00409423f, 0.01152223f, 
    0.00684588f, -0.02299984f, 0.00533347f, -0.01264176f, -0.00081987f, -0.02420109f, -0.00521335f, -0.01571582f, 
    0.01897382f, -0.01520888f, 0.00977050f, -0.02137990f, 0.01776827f, -0.03552065f, 0.00027082f, 0.01803776f, 
    -0.03479119f, 0.01980400f, 0.00881301f, -0.03515711f, 0.02822540f, 0.01036358f, 0.02472192f, 0.02914385f, 
    -0.00735297f, 0.01649635f, -0.01002401f, -0.00341212f, -0.01604503f, 0.00300580f, -0.04296360f, 0.02773204f, 
    0.01541006f, -0.00693727f, 0.02859781f, 0.02133182f, 0.00783213f, -0.00787685f, -0.03785835f, -0.00621257f, 
    -0.01067136f, -0.04695252f, 0.00257227f, -0.01154155f, 0.02711372f, 0.01043573f, -0.02062437f, -0.01057073f, 
    0.02778437f, -0.01966333f, 0.02232430f, -0.04060479f, -0.03984718f, -0.03385512f, -0.02576747f, -0.03534108f, 
    0.00051840f, 0.01841147f, -0.04723563f, -0.03211828f, 0.01255114f, -0.01341123f, -0.02666273f, 0.02774681f, 
    0.00183535f, -0.03216004f, -0.01538235f, 0.01628563f, 0.01265461f, -0.03991414f, -0.02988548f, -0.03495614f, 
    -0.02516574f, -0.01238427f, -0.00139767f, 0.02261204f, -0.02848355f, -0.04709831f, -0.01581783f, -0.01774816f, 
    -0.03217374f, -0.01753097f, 0.03726344f, -0.01600575f, -0.04788176f, -0.02180808f, 0.02422125f, -0.03172554f, 
    -0.02210503f, -0.01382436f, 0.00693924f, 0.01031713f, -0.01983550f, 0.02251604f, 0.02107474f, -0.00730189f, 
    0.02262278f, -0.02990560f, 0.01523462f, -0.04732391f, 0.04563690f, -0.00208966f, -0.03072334f, -0.02135582f, 
    -0.02658328f, -0.03680534f, -0.03721820f, 0.01836658f, 0.02561563f, -0.03368919f, 0.01672859f, 0.00476904f, 
    0.01227768f, 0.02403126f, 0.01755697f, -0.01887367f, -0.02540896f, -0.01490787f, -0.01115872f, -0.04416907f, 
    0.02543823f, 0.02309781f, -0.00320886f, -0.00884404f, -0.04560185f, 0.00092652f, -0.00417014f, -0.03301660f, 
    -0.00520121f, 0.00881937f, -0.00980154f, 0.02636094f, 0.00060324f, -0.00828875f, 0.01653890f, 0.02058144f, 
    0.02962803f, -0.01568340f, -0.04255275f, 0.01390786f, 0.04008011f, -0.01390282f, 0.00342801f, -0.04292228f, 
    -0.01090014f, 0.00306810f, -0.00625956f, 0.02055256f, -0.00443961f, 0.03191203f, -0.00916752f, 0.00143873f, 
    -0.01075620f, 0.01050135f, -0.04373476f, -0.00290395f, 0.02317078f, 0.00141073f, -0.02238422f, -0.00049080f, 
    -0.04190701f, 0.01097432f, -0.00267043f, 0.00427994f, -0.03027228f, 0.02481089f, 0.02055715f, 0.01178077f, 
    -0.01402351f, -0.02789954f, 0.00466710f, -0.02657516f, -0.02952000f, 0.02263071f, -0.01118914f, -0.02612692f, 
    -0.04931746f, -0.01112022f, -0.02112214f, 0.02514343f, 0.00684323f, 0.01816478f, 0.01930706f, -0.00190627f, 
    -0.02621877f, -0.03685330f, 0.00493699f, -0.02991126f, 0.01787377f, -0.02502902f, 0.01595699f, -0.04606389f, 
    -0.03208376f, -0.03202685f, -0.04151474f, -0.02466245f, 0.01837688f, -0.02596574f, 0.01104068f, 0.01777898f, 
    -0.01122262f, -0.02715110f, -0.01308423f, 0.01129458f, 0.01067058f, -0.03268294f, 0.02294156f, 0.01581032f, 
    -0.02216788f, -0.04764177f, -0.02256867f, -0.01263645f, -0.04255764f, -0.00157129f, -0.02017983f, -0.03702966f, 
    -0.00597130f, -0.00644267f, -0.00606746f, 0.01856606f, -0.02211800f, 0.02686020f, -0.04475189f, -0.02293039f, 
    0.01494240f, 0.01464249f, 0.00671640f, -0.04696300f, -0.04379148f, -0.04256814f, -0.00962455f, 0.01445853f, 
    0.02745876f, -0.02167672f, 0.01644436f, 0.00253733f, -0.00204496f, -0.03453052f, -0.01878729f, 0.02621204f, 
    0.02545203f, 0.01334517f, 0.02085014f, 0.01102825f, -0.00073558f, -0.00686152f, 0.02385255f, -0.00871854f, 
    -0.00146134f, -0.02216733f, 0.00345975f, 0.00768392f, -0.03932393f, 0.00435658f, -0.02068743f, 0.00554163f, 
    -0.00953076f, 0.01596200f, 0.01000413f, -0.02642089f, 0.01057200f, 0.02213515f, 0.03036684f, 0.02088920f, 
    -0.03452109f, -0.00191270f, -0.03975106f, -0.03939701f, -0.03694876f, -0.00623882f, -0.01233127f, -0.02920795f, 
    -0.04930934f, -0.04640733f, 0.02823777f, 0.00035476f, -0.01830203f, 0.02724325f, 0.01581228f, -0.02869604f, 
    0.02472209f, -0.02415099f, -0.03060488f, 0.00161613f, -0.03626800f, 0.02649044f, 0.01729107f, 0.00834404f, 
    -0.03271016f, -0.04584120f, -0.02009057f, -0.03473228f, -0.02324453f, -0.00997731f, 0.00805635f, -0.02765198f, 
    -0.00097948f, -0.03915471f, -0.00381340f, -0.00721008f, -0.04754757f, 0.01708177f, 0.00359725f, 0.01364261f, 
    0.02061031f, -0.01177242f, 0.01164698f, 0.02053988f, -0.04544227f, 0.02511178f, -0.03586293f, -0.03333843f, 
    -0.00270802f, -0.00263982f, 0.02906974f, 0.03285943f, -0.02982314f, 0.00750836f, -0.02230900f, -0.00560899f, 
    0.00537441f, 0.00388081f, -0.00310248f, -0.00782308f, 0.02058514f, -0.04077724f, -0.00695287f, -0.00082984f, 
    -0.00763995f, -0.00146238f, -0.04859458f, 0.02809846f, -0.00514590f, -0.03338983f, 0.01215413f, -0.02185019f, 
    0.00657125f, -0.01048991f, -0.04215349f, -0.00745466f, 0.01230818f, 0.01599357f, 0.02919220f, 0.01897587f, 
    -0.02678022f, 0.02639073f, 0.00023180f, 0.00980375f, -0.02731431f, 0.02299626f, 0.00878047f, 0.00340056f, 
    0.01297320f, -0.03773668f, -0.03188862f, -0.01297469f, 0.02493005f, -0.02425771f, -0.02258051f, -0.02698976f, 
    0.01365654f, 0.02071173f, -0.04795012f, -0.00977624f, 0.00911129f, -0.04842710f, -0.05021615f, 0.01513861f, 
    0.00226198f, -0.00050050f, 0.00813404f, 0.00601655f, 0.03544264f, -0.02289110f, -0.03315913f, 0.01587416f, 
    -0.01150361f, -0.03598483f, 0.02125877f, 0.01076958f, 0.00966478f, -0.03312784f, 0.01680462f, -0.04803948f, 
    -0.02952564f, -0.01291849f, -0.00451655f, -0.03758915f, 0.00918260f, -0.04363604f, 0.00941177f, -0.03086045f, 
    -0.02916248f, 0.00251907f, 0.00707573f, 0.00204585f, 0.02266138f, -0.04197308f, -0.04137089f, 0.01771840f, 
    0.02737721f, -0.00637322f, -0.01265410f, -0.00568747f, -0.03848897f, 0.02380959f, -0.01275909f, -0.03969912f, 
    -0.00701318f, 0.00377943f, 0.01143739f, -0.04425929f, -0.00151722f, 0.02059554f, -0.04513942f, -0.03452978f, 
    0.00964580f, 0.02074992f, 0.01700968f, 0.02302707f, -0.00992972f, -0.04601388f, -0.00006630f, -0.02334924f, 
    -0.02211163f, -0.04116483f, 0.01504997f, 0.00576055f, -0.00852160f, -0.04114902f, -0.00795817f, -0.02378409f, 
    0.01128936f, -0.02634634f, -0.02025654f, 0.00382220f, -0.02639786f, -0.03540673f, 0.01442870f, 0.02729858f, 
    0.01549708f, -0.00673890f, 0.02202829f, 0.02053474f, -0.04043137f, -0.04923610f, 0.01497648f, -0.02162373f, 
    -0.04135320f, 0.00810844f, 0.00631368f, -0.01780085f, 0.00261695f, 0.02184250f, -0.01348782f, -0.02310292f, 
    -0.03409844f, -0.02365352f, 0.00149735f, 0.01159239f, -0.02591444f, 0.02136260f, -0.00896271f, -0.00346818f, 
    -0.04741731f, 0.01164418f, -0.02591836f, -0.00308442f, 0.00602347f, -0.01951449f, 0.00725888f, 0.00065412f, 
    -0.01179987f, 0.01581425f, 0.01551787f, 0.02377076f, -0.03023013f, 0.00222424f, 0.01155003f, 0.01828450f, 
    0.02714075f, -0.02600183f, 0.02468319f, 0.02926254f, -0.02076516f, 0.00955885f, -0.01149432f, -0.01276534f, 
    0.02311776f, -0.00109490f, -0.03087738f, 0.02622245f, -0.01376541f, -0.03235831f, -0.00287245f, 0.01753671f, 
    0.01585087f, 0.01464280f, 0.02874249f, 0.02175960f, 0.02763521f, -0.03193185f, -0.02551852f, 0.00440912f, 
    -0.00259469f, -0.00611175f, -0.01928873f, 0.00258927f, 0.00925544f, -0.01970048f, -0.03785234f, 0.00204011f, 
    0.01251143f, 0.00938611f, -0.02884788f, 0.00269839f, -0.03772867f, 0.01166310f, 0.00951257f, -0.03580727f, 
    0.02217662f, 0.02710239f, -0.02426707f, -0.00167772f, 0.01780402f, 0.01887720f, -0.00784046f, -0.00527169f, 
    0.01707716f, -0.04745538f, -0.01729234f, -0.01204596f, 0.01949710f, 0.02845587f, -0.01598518f, 0.02572978f, 
    -0.01631461f, 0.02524595f, 0.01029474f, -0.00908280f, -0.04739088f, -0.00435515f, -0.01461210f, -0.04614903f, 
    0.02165202f, 0.02671968f, -0.02183160f, -0.02082980f, 0.01752866f, -0.01024151f, 0.00830348f, -0.01221562f, 
    -0.02948307f, 0.00306089f, -0.04342286f, -0.02559659f, 0.02281502f, 0.02420286f, -0.00275635f, 0.00157207f, 
    0.03046442f, 0.14886232f, 0.33009589f, 0.05921143f, -0.14820106f, -0.01985593f, -0.01870945f, 0.04655642f, 
    -0.10366659f, -0.02584323f, -0.00236836f, -0.07065752f, 0.00252135f, 0.19551234f, 0.14500056f, 0.00894598f, 
    0.05512265f, 0.12107645f, 0.01808126f, -0.10402137f, -0.10553376f, -0.10632933f, -0.10299942f, -0.03865069f, 
    -0.23584464f, -0.10222417f, -0.05929147f, -0.05183028f, 0.00408264f, -0.13882381f, -0.02058104f, 0.02896020f, 
    0.05814067f, 0.05515975f, 0.20922415f, 0.06879198f, 0.04694138f, -0.04558907f, 0.01745632f, -0.02344834f, 
    -0.28577450f, -0.30232024f, -0.36976475f, 0.15811500f, 0.03753199f, -0.07211880f, -0.03751067f, -0.21594264f, 
    0.03969723f, -0.06513096f, -0.06056688f, 0.03050718f, -0.02407021f, -0.00465348f, 0.03413175f, 0.07151949f, 
    0.05512957f, -0.06063893f, -0.19296181f, 0.09623984f, -0.05229798f, -0.22401462f, -0.00009848f, 0.01976096f, 
    0.00646312f, 0.05919941f, -0.04629771f, -0.19123389f, 0.11424579f, -0.02150445f, 0.02209190f, 0.07214172f, 
    0.03514791f, 0.04586134f, 0.06447892f, 0.07455540f, 0.06437833f, 0.03902279f, -0.19745548f, -0.09997125f, 
    -0.08072017f, 0.01287397f, 0.11842623f, 0.12879463f, -0.07222749f, 0.00893766f, 0.08641988f, 0.06976285f, 
    -0.00951202f, -0.01409167f, 0.01680393f, -0.04762536f, 0.13385503f, 0.17888144f, 0.11727231f, -0.10405481f, 
    -0.05968470f, 0.05853394f, 0.05766574f, 0.00663211f, 0.20988065f, -0.04092939f, 0.18368223f, 0.09165262f, 
    0.23075168f, 0.06277274f, -0.07098775f, 0.02389522f, 0.14911717f, 0.12848994f, -0.01543930f, 0.05472330f, 
    0.22889933f, -0.00886756f, 0.08148374f, 0.01309832f, 0.06261824f, 0.00885693f, -0.00597889f, 0.19300699f, 
    -0.22623415f, -0.33612043f, -0.03936224f, 0.01808333f, -0.07452393f, 0.07076233f, 0.11345270f, 0.11311182f, 
    0.08042544f, 0.20442970f, -0.04719264f, -0.01947848f, -0.01775985f, -0.02568555f, -0.12541743f, -0.03384643f, 
    0.13004889f, 0.02085550f, 0.18024001f, 0.06143931f, 0.05389033f, -0.09841572f, 0.09967183f, 0.14871067f, 
    -0.09504744f, -0.14984933f, -0.01572485f, -0.01360120f, 0.03733400f, -0.02139201f, 0.10755754f, 0.01420795f, 
    0.04048382f, 0.10491692f, 0.02591985f, -0.11140072f, -0.00143168f, 0.00214854f, 0.10055975f, -0.04674815f, 
    -0.02916501f, 0.55587769f, 0.13074529f, 0.44245812f, -0.15885699f, -0.03134979f, 0.00500309f, -0.18467775f, 
    0.15790699f, 0.00526797f, -0.06881636f, 0.08278573f, 0.10763799f, -0.01967584f, -0.09302408f, -0.01221511f, 
    0.00818312f, 0.28972027f, 0.11644682f, -0.01153766f, -0.15780438f, 0.01494091f, 0.15641482f, -0.06316582f, 
    -0.21693210f, -0.09313903f, -0.14399798f, -0.12049190f, 0.01801077f, -0.09215935f, 0.10705036f, 0.02919102f, 
    0.01599812f, 0.10389293f, 0.14577569f, -0.02242667f, 0.02753890f, 0.04620487f, 0.12480282f, 0.03071226f, 
    -0.12727317f, -0.29828414f, -0.28307542f, 0.13822545f, 0.03580812f, 0.15272570f, 0.00337560f, 0.09749951f, 
    0.07951207f, 0.18797824f, -0.10871488f, -0.00947717f, 0.02933780f, 0.05361497f, 0.01915037f, 0.02971550f, 
    0.09302884f, 0.04237046f, -0.15337114f, 0.29339406f, -0.07037427f, -0.14038536f, 0.07812072f, -0.02719428f, 
    -0.19074531f, -0.08514660f, -0.07557927f, -0.00746799f, -0.00919155f, -0.17662540f, 0.07944909f, -0.02904842f, 
    0.14707001f, 0.14357960f, 0.20145890f, 0.01807331f, 0.07064060f, -0.10005848f, 0.04156687f, -0.06408222f, 
    0.19415912f, -0.25114721f, -0.08626887f, -0.08758419f, -0.01775503f, 0.02724290f, 0.00237956f, 0.04926347f, 
    0.05928811f, 0.07889352f, 0.10662906f, 0.11464204f, -0.00094461f, -0.08443014f, 0.00685923f, -0.01306784f, 
    0.07946587f, 0.03351385f, 0.15529084f, 0.02385728f, -0.10881752f, 0.16871683f, -0.11944244f, 0.05689239f, 
    0.01455207f, 0.03803075f, 0.12014454f, -0.07158045f, 0.10469524f, 0.02836193f, -0.02878432f, 0.01220136f, 
    -0.06325468f, 0.04566890f, 0.09840972f, 0.17257172f, -0.02451464f, 0.03565364f, -0.16474465f, -0.18610452f, 
    -0.36157084f, -0.06558197f, 0.55840999f, -0.15632272f, -0.09684213f, 0.00007063f, -0.08593584f, -0.02667252f, 
    0.02537709f, 0.09915483f, -0.02545560f, -0.00179300f, 0.08896797f, 0.00025678f, -0.00315931f, -0.00593435f, 
    0.14629203f, 0.07737302f, 0.04815458f, 0.13826922f, -0.13344765f, -0.23775519f, -0.30450174f, 0.17751391f, 
    0.16335192f, 0.08134933f, 0.07313947f, 0.04358660f, 0.16185361f, 0.12176354f, -0.11959306f, -0.09244403f, 
    -0.03585077f, 0.04724521f, 0.00917133f, 0.01292834f, 0.01325216f, 0.03632919f, -0.02876083f, 0.20664641f, 
    0.36085570f, 0.03547841f, 0.05484961f, 0.03005401f, 0.17819768f, -0.07287214f, 0.10432599f, -0.08145708f, 
    -0.10052819f, -0.12518510f, -0.06550241f, 0.00062102f, -0.15209366f, -0.00728110f, -0.05069015f, 0.14377585f, 
    -0.10581542f, -0.00727318f, -0.05184462f, -0.05553765f, -0.25076962f, 0.26854554f, 0.03622753f, 0.36409619f, 
    0.31213528f, 0.12907861f, -0.01747901f, 0.06241246f, -0.02157116f, 0.09775757f, -0.14452919f, -0.04683339f, 
    0.01489304f, -0.12281521f, -0.06421643f, 0.12390763f, 0.04138012f, -0.12916465f, 0.18089315f, -0.06376719f, 
    -0.04876832f, 0.08878601f, 0.05196497f, 0.17255887f, -0.03748557f, 0.07692800f, 0.00573405f, -0.02896450f, 
    -0.02005742f, -0.04903251f, -0.01765991f, -0.01871409f, 0.03426741f, 0.06709734f, -0.02750963f, -0.00101693f, 
    0.01147396f, 0.18418531f, 0.14265056f, 0.22717147f, -0.07316164f, 0.27051836f, 0.02610512f, 0.18920133f, 
    0.29967555f, 0.21664025f, 0.04169952f, 0.11990893f, 0.09325229f, -0.01738228f, -0.10587998f, 0.08977308f, 
    -0.07103588f, -0.04482533f, 0.05887776f, 0.08901981f, -0.00979804f, -0.04172887f, 0.10161088f, 0.02591132f, 
    -0.12257064f, -0.22384147f, -0.01688878f, -0.05161432f, 0.03840367f, -0.00802814f, 0.01249530f, 0.06468573f, 
    0.04280535f, -0.03335731f, 0.14613476f, 0.03870193f, 0.01238320f, -0.09193340f, -0.01572752f, -0.11265165f, 
    -0.01975535f, -0.02577048f, 0.07081586f, -0.03813872f, 0.30798554f, 0.17197362f, -0.09703955f, 0.31182158f, 
    -0.10028914f, 0.03272247f, 0.07437159f, 0.05030565f, 0.09624484f, 0.01339226f, 0.02502331f, 0.07093941f, 
    0.02170293f, -0.11800549f, 0.04166330f, 0.13649631f, 0.11330220f, 0.10370192f, 0.11909747f, 0.04449833f, 
    -0.29234421f, 0.11043178f, -0.25007936f, -0.03776665f, 0.18820065f, -0.02531099f, -0.02731532f, -0.02056834f, 
    0.11873727f, -0.05127845f, -0.07423682f, -0.01532255f, -0.05097895f, -0.07270051f, 0.00024840f, 0.14302301f, 
    0.07980997f, 0.13308395f, -0.16740194f, 0.09447312f, -0.42366573f, -0.28596029f, 0.01176163f, 0.27422833f, 
    0.04576418f, 0.11181230f, -0.04250774f, -0.01349191f, -0.14690341f, -0.05209090f, -0.00682440f, 0.00197646f, 
    0.09242065f, 0.15784666f, 0.00704503f, 0.08479729f, 0.06182790f, 0.02451470f, 0.08152190f, 0.20379025f, 
    0.07547962f, -0.00720969f, 0.12136208f, -0.07113340f, -0.14784759f, 0.00973473f, -0.11614180f, 0.07472651f, 
    -0.01408958f, -0.13248789f, 0.20696475f, 0.10319728f, 0.07816099f, 0.06253041f, 0.17616542f, -0.04999708f, 
    -0.04724439f, 0.06381929f, 0.12339472f, -0.01389032f, -0.08207341f, -0.34212548f, -0.03932870f, -0.02587871f, 
    0.13566577f, 0.10684519f, 0.06240051f, 0.11040706f, -0.12611929f, 0.03842475f, -0.04788139f, 0.02075500f, 
    -0.02059949f, -0.06764922f, 0.03434520f, 0.11838022f, 0.03311191f, -0.12267307f, -0.14105277f, -0.16071478f, 
    -0.39141148f, -0.00478618f, 0.76987493f, 0.14741939f, 0.12772487f, 0.03341836f, -0.13580436f, 0.00101084f, 
    -0.00526144f, -0.12874621f, -0.04255597f, -0.07076339f, 0.01576693f, 0.10672879f, 0.07731016f, 0.03853481f, 
    -0.00423984f, 0.09483124f, 0.08280725f, 0.05127361f, 0.32098112f, 0.05153649f, 0.30398342f, -0.14546295f, 
    -0.10135014f, -0.09208153f, -0.08636434f, 0.01527298f, 0.06002549f, -0.12482665f, -0.05271669f, -0.04684361f, 
    0.02712071f, 0.04156873f, 0.05244378f, -0.00173065f, -0.12399408f, 0.04589761f, -0.09063736f, -0.18098679f, 
    -0.11561741f, 0.13494357f, 0.37597165f, 0.10117516f, -0.11255818f, -0.13506311f, -0.10619065f, -0.08025320f, 
    0.00296578f, -0.12342717f, -0.01299856f, -0.02765821f, -0.01807015f, -0.02855669f, 0.07754166f, 0.08330262f, 
    -0.01111945f, -0.04817517f, -0.08645620f, -0.07539998f, -0.06427121f, -0.16872858f, 0.39083746f, -0.00701065f, 
    -0.06426729f, -0.18271336f, -0.02161891f, -0.02339104f, -0.11121927f, -0.11565652f, -0.02590175f, -0.00337343f, 
    0.00659063f, -0.02270473f, 0.00377549f, -0.03009615f, -0.14721136f, -0.20656434f, -0.08458988f, -0.05512745f, 
    1.06338191f, 0.05842771f, 0.06663459f, -0.38257349f, -0.13488436f, -0.10308552f, 0.05831303f, 0.08188143f, 
    -0.13307199f, -0.05693037f, -0.03767085f, 0.04747995f, 0.05836796f, 0.08997468f, 0.01862501f, -0.02935410f, 
    0.23475565f, -0.01818759f, 0.07774360f, 0.03354378f, -0.06746662f, 0.07091796f, -0.36117503f, 0.26398203f, 
    0.12117203f, 0.05077253f, 0.04767913f, 0.00793917f, 0.18070909f, 0.17036986f, -0.04211006f, 0.05215896f, 
    -0.16095223f, -0.15602182f, 0.00113583f, 0.05870992f, 0.00173673f, -0.13883163f, 0.15628891f, -0.11836404f, 
    -0.04717925f, 0.00509672f, -0.01548162f, -0.03118444f, -0.03203892f, -0.04105911f, -0.04541019f, -0.01442473f, 
    0.03038363f, 0.02648336f, -0.01687381f, -0.02608787f, -0.00849505f, -0.03329503f, -0.00603631f, 0.03128222f, 
    -0.01605905f, 0.01925104f, -0.01111718f, 0.00253805f, -0.01717739f, 0.02236461f, -0.01975540f, -0.01970884f, 
    -0.03037914f, 0.02504502f, -0.04393318f, 0.02862800f, -0.03686244f, 0.00892039f, -0.04488736f, 0.00070787f, 
    -0.01407128f, -0.02264896f, 0.00458648f, 0.01120050f, -0.04292641f, -0.04663685f, -0.00364932f, 0.01160998f, 
    0.01996547f, -0.03144892f, 0.00814641f, -0.00084432f, -0.03931821f, 0.01291041f, -0.01702782f, 0.02140616f, 
    -0.03086737f, -0.02399260f, 0.03119221f, -0.01172135f, -0.04455469f, -0.00219944f, 0.00970852f, -0.01611615f, 
    -0.00596270f, 0.02934412f, 0.00200515f, 0.01496026f, -0.03737872f, -0.03376532f, -0.02824812f, 0.02872214f, 
    0.02179773f, 0.01083755f, 0.00147160f, 0.02172768f, 0.00812326f, -0.00672992f, -0.02115560f, -0.00366300f, 
    -0.00909221f, 0.00303512f, -0.01384224f, 0.00326989f, 0.01349630f, 0.00665226f, -0.04404386f, -0.01294215f, 
    0.00825838f, 0.02334098f, -0.03138280f, 0.01541419f, -0.03114787f, 0.02213029f, -0.02287833f, -0.00641526f, 
    -0.04257724f, -0.04777323f, 0.02081691f, 0.02608113f, -0.02720995f, 0.03084186f, -0.01445668f, -0.03062394f, 
    0.00845047f, -0.00290579f, 0.00286921f, -0.00070590f, -0.00026412f, 0.00322733f, -0.02509261f, 0.02834916f, 
    0.01219214f, 0.01756356f, -0.04243563f, -0.00846440f, 0.02965627f, -0.00776284f, -0.03985326f, -0.04459878f, 
    0.02675732f, 0.02294059f, 0.02434442f, 0.01958787f, -0.04846825f, -0.01869138f, 0.00722038f, -0.01266742f, 
    0.01519732f, 0.00728128f, 0.00016226f, -0.01431535f, -0.04313925f, -0.04548203f, -0.03473272f, 0.02449767f, 
    0.00153947f, 0.02776014f, -0.02563510f, -0.01029242f, -0.01069766f, -0.00231334f, -0.00989772f, 0.01068205f, 
    -0.03394608f, -0.01157966f, 0.01361563f, -0.01657865f, 0.02106957f, -0.04122774f, -0.01973585f, 0.02309077f, 
    0.00162734f, -0.00244308f, 0.01956925f, -0.04239298f, 0.01469106f, -0.04763057f, 0.00372275f, -0.03640574f, 
    -0.02656673f, 0.02379747f, -0.00980963f, 0.01929180f, -0.03314781f, -0.00985515f, 0.02234009f, -0.04497844f, 
    -0.02734947f, -0.00748290f, 0.01582474f, 0.02422183f, -0.03436634f, 0.01119956f, -0.00146358f, -0.03532115f, 
    -0.03606263f, 0.00087610f, 0.02518965f, 0.02160884f, 0.02698906f, -0.03598850f, -0.02749880f, -0.02145159f, 
    -0.03252295f, 0.02565550f, 0.01881538f, -0.02080054f, -0.01512666f, -0.00096285f, -0.02677643f, 0.01598734f, 
    -0.01505866f, -0.01858193f, 0.02351885f, 0.00445302f, -0.02515240f, 0.02209685f, 0.01300587f, -0.02030789f, 
    0.02221286f, -0.00119084f, -0.03545346f, 0.00829974f, -0.01608176f, 0.02713255f, -0.04103073f, -0.02657298f, 
    -0.00214183f, -0.04075986f, -0.04355063f, 0.00328497f, -0.00379524f, 0.00199964f, 0.00950558f, -0.02263450f, 
    -0.01331948f, 0.00197439f, -0.01931586f, -0.04387575f, -0.00879487f, -0.03285459f, 0.02561455f, 0.00684535f, 
    -0.01806370f, -0.01811782f, 0.01183183f, -0.02282846f, 0.02145132f, -0.04369273f, 0.03013191f, -0.02548048f, 
    -0.01958794f, -0.03791537f, -0.00558920f, 0.02794410f, -0.00462053f, -0.03744101f, 0.00798186f, -0.00903219f, 
    -0.01417886f, 0.01856541f, 0.03166894f, -0.01550408f, -0.04000759f, 0.01835641f, -0.00076247f, -0.03872564f, 
    -0.02688676f, 0.02864590f, -0.01752507f, -0.01075623f, 0.00695981f, 0.02653249f, -0.01030155f, -0.01206123f, 
    -0.02338268f, -0.00662158f, -0.04724285f, 0.00268850f, -0.03787527f, 0.00295387f, -0.04160506f, 0.00959179f, 
    -0.00291012f, 0.00166636f, -0.02182393f, 0.02687212f, 0.00266306f, 0.02238533f, -0.04047674f, -0.01944947f, 
    -0.00925077f, 0.01051676f, -0.03684710f, -0.03412428f, -0.02278244f, 0.01068127f, -0.00037981f, -0.01819844f, 
    -0.01555596f, 0.00797057f, -0.04330495f, -0.03883429f, 0.00709652f, -0.01185008f, 0.01750078f, -0.04201313f, 
    0.00825683f, 0.00211949f, 0.02583008f, -0.02712051f, -0.01292012f, -0.03428359f, -0.03891638f, -0.04558262f, 
    -0.01902548f, 0.01520902f, -0.01325240f, -0.00121796f, -0.02045627f, 0.00100520f, 0.02462744f, -0.01847126f, 
    -0.02660289f, 0.00916539f, -0.04126127f, 0.01954693f, 0.02479609f, -0.00103870f, 0.01642478f, 0.03244200f, 
    0.03246855f, 0.01530884f, -0.04414359f, -0.02018856f, -0.03330664f, 0.03190640f, 0.01671187f, -0.00900295f, 
    -0.02452786f, -0.01140322f, -0.04291080f, -0.03117465f, 0.03208672f, -0.02811516f, 0.01752775f, -0.00264047f, 
    0.00835780f, -0.00430037f, 0.02973035f, 0.01059703f, -0.02810846f, -0.04469740f, 0.00109418f, -0.00450683f, 
    0.02655149f, 0.02213528f, 0.02513527f, 0.00137675f, 0.01529382f, 0.01578328f, -0.01235441f, -0.04514192f, 
    -0.01963404f, -0.02935775f, 0.00123520f, 0.02880054f, 0.01735242f, -0.02311355f, 0.00613063f, 0.00081941f, 
    -0.02985699f, -0.02619295f, -0.04248169f, 0.00770711f, 0.01810845f, -0.01924633f, 0.01056416f, 0.03171221f, 
    -0.02580993f, 0.01970367f, -0.02714599f, 0.00494899f, -0.00319250f, -0.00332508f, -0.02495865f, -0.00488560f, 
    0.00184018f, -0.03778909f, -0.00413023f, 0.01404514f, 0.01665065f, 0.00594811f, -0.03935297f, 0.01288688f, 
    -0.01395416f, -0.04173497f, -0.03824436f, 0.02054545f, -0.01982129f, 0.02100899f, -0.00529834f, 0.01549991f, 
    0.02679161f, -0.02654165f, 0.00281150f, -0.01544769f, 0.03259066f, -0.01829592f, 0.01668828f, -0.00665745f, 
    -0.04141227f, 0.00139720f, 0.00201937f, -0.01872008f, 0.00565066f, 0.02613803f, 0.01964695f, -0.02169613f, 
    -0.04592251f, 0.02916933f, 0.01287422f, 0.00371201f, 0.01529113f, 0.00260142f, -0.02332280f, -0.03003979f, 
    -0.04432516f, -0.03320836f, -0.00860077f, 0.00659676f, -0.00653965f, 0.02530589f, 0.01462929f, -0.03635885f, 
    -0.01425726f, -0.00409424f, 0.02828992f, -0.02463241f, -0.03322991f, -0.02087826f, -0.00369132f, 0.02532346f, 
    0.02597313f, 0.00270507f, 0.01763154f, -0.02080780f, -0.04495255f, 0.02484293f, -0.00195962f, -0.01816644f, 
    -0.03455670f, -0.01070698f, -0.03645121f, 0.01109730f, 0.00519951f, -0.02388410f, -0.00515349f, 0.00801639f, 
    -0.03672175f, -0.03741010f, 0.01004583f, -0.03871965f, 0.02250456f, -0.04363770f, -0.03682094f, -0.02989224f, 
    0.02793622f, -0.02594249f, 0.01473037f, -0.01214108f, -0.01195711f, 0.01925155f, -0.04177789f, -0.02106040f, 
    0.00195600f, -0.03586378f, -0.02063031f, 0.02219582f, -0.02596275f, -0.01111418f, -0.00603760f, -0.03358990f, 
    -0.01434942f, -0.00422872f, -0.04209999f, 0.02525792f, -0.00141033f, 0.02125602f, 0.02900298f, -0.03750758f, 
    -0.00964450f, -0.01239915f, -0.04043876f, 0.01280528f, 0.02828684f, -0.01260475f, 0.00413052f, 0.02138728f, 
    -0.02702384f, -0.01449018f, -0.04089636f, -0.02234412f, -0.03066566f, -0.01945691f, 0.02433907f, -0.00049407f, 
    -0.00477506f, -0.01567530f, 0.02440766f, 0.01062335f, 0.03037717f, -0.01334885f, 0.02545486f, -0.03440098f, 
    -0.00949797f, -0.01330935f, -0.03405970f, -0.00587696f, -0.04505186f, -0.00308739f, 0.02644832f, 0.02642819f, 
    0.00939419f, -0.00896051f, -0.01339247f, 0.00077835f, 0.03264147f, -0.03905745f, -0.03413386f, -0.01337107f, 
    0.02687994f, -0.04039565f, 0.00600166f, -0.03743247f, 0.00070977f, 0.00565741f, 0.00725388f, -0.03699077f, 
    0.00133978f, -0.00253433f, -0.02036339f, -0.04658319f, -0.01696578f, -0.02231694f, -0.03139857f, -0.03862052f, 
    -0.00478193f, -0.02717922f, 0.02260053f, -0.03205743f, -0.02235920f, -0.03752115f, -0.02755944f, -0.03561844f, 
    -0.01324267f, -0.02728194f, -0.04373402f, -0.01447649f, 0.01778156f, 0.01901834f, -0.01808148f, -0.00648104f, 
    0.02233168f, 0.02476661f, 0.00967928f, -0.04798310f, 0.01455433f, 0.00317367f, 0.02375214f, -0.01918122f, 
    -0.01837692f, -0.04482605f, 0.00433508f, -0.03765230f, 0.02969611f, 0.02856061f, 0.02033038f, 0.00139324f, 
    0.00531722f, -0.00586703f, 0.00609299f, 0.01957529f, -0.01908577f, -0.04230897f, -0.02336471f, 0.00925509f, 
    -0.01105655f, 0.00610854f, 0.03047841f, 0.00764313f, -0.01788400f, -0.02123795f, -0.02333034f, 0.02219966f, 
    -0.02406688f, -0.03379928f, -0.04433183f, 0.01751398f, -0.00365939f, -0.00352410f, 0.01225653f, -0.02439628f, 
    0.03214508f, -0.04072732f, -0.01311009f, 0.00096777f, 0.02791375f, -0.02713972f, 0.01832870f, 0.02600898f, 
    0.00963937f, 0.00826748f, -0.02629600f, -0.02266920f, 0.03074128f, 0.02169328f, 0.00345092f, -0.01569478f, 
    -0.02742764f, -0.02554935f, -0.00830744f, -0.04431902f, -0.04473632f, 0.02364066f, 0.01212914f, -0.04532430f, 
    -0.02583892f, 0.02236138f, 0.02051050f, 0.01123890f, -0.00973781f, 0.02006844f, -0.01849774f, -0.01112549f, 
    -0.03676387f, 0.01243673f, -0.02206937f, 0.01186182f, -0.03210311f, -0.04541505f, 0.03074277f, -0.00530857f, 
    -0.02845107f, -0.01977381f, -0.02328845f, -0.01207022f, -0.03960133f, -0.04439910f, -0.02966136f, -0.00582782f, 
    0.02873419f, -0.00616775f, -0.01261762f, -0.04616150f, -0.01537046f, 0.03245165f, 0.01139036f, -0.02353720f, 
    -0.02667709f, 0.02475789f, 0.03031259f, 0.01279378f, -0.04222311f, 0.01906973f, 0.02865648f, 0.01611719f, 
    -0.20562723f, 0.21631292f, -0.03085864f, -0.03777651f, -0.07217456f, -0.03982976f, -0.10173148f, 0.15777843f, 
    -0.11191059f, -0.14291371f, -0.04139876f, 0.07930902f, -0.02676223f, 0.04014594f, -0.05177502f, -0.11970477f, 
    0.06485675f, -0.07401267f, 0.00143748f, -0.02919065f, -0.18100122f, 0.14932817f, -0.07965179f, 0.00578072f, 
    -0.27625698f, 0.00659024f, 0.04604975f, -0.07824495f, 0.06790543f, -0.10570961f, -0.18382680f, -0.14438504f, 
    -0.05429816f, 0.00227119f, 0.07683550f, -0.04591974f, -0.04155676f, -0.26385453f, -0.02973990f, -0.06292802f, 
    -0.13619196f, -0.32985622f, -0.27547798f, -0.01151304f, 0.06275235f, 0.10923475f, -0.03433507f, 0.02630274f, 
    0.09557445f, 0.07365373f, -0.05750688f, -0.05773743f, -0.16746181f, -0.05605122f, -0.07016552f, -0.11521208f, 
    -0.04344590f, 0.16632266f, -0.03320822f, -0.00026447f, 0.09597287f, -0.18776388f, -0.16924234f, 0.14402568f, 
    0.16689436f, -0.00403631f, -0.00281201f, 0.11999931f, 0.03254111f, 0.03898732f, 0.12921260f, -0.01678271f, 
    -0.09176217f, 0.05048778f, -0.00282327f, -0.01553336f, -0.08250523f, 0.17802216f, -0.08919843f, 0.03958246f, 
    -0.30643690f, 0.22245394f, -0.14598323f, -0.10756134f, 0.01063470f, 0.16818511f, -0.13479619f, 0.00722111f, 
    -0.01142037f, -0.10028958f, 0.05921586f, 0.18267651f, -0.06885295f, -0.08532096f, 0.03995100f, 0.02853141f, 
    -0.08194020f, -0.01399637f, 0.09539848f, 0.16444784f, 0.21008119f, -0.20381337f, 0.18049428f, 0.11691733f, 
    0.24160437f, 0.05496604f, 0.09690470f, -0.12388163f, 0.10844196f, -0.15654695f, 0.19907926f, 0.09942771f, 
    -0.01040293f, -0.09136815f, -0.06154039f, 0.00709110f, 0.05410339f, -0.07608774f, 0.15745544f, 0.03952508f, 
    -0.16566405f, -0.05656224f, 0.07629102f, -0.00064365f, 0.21105267f, 0.04149985f, -0.04445909f, -0.00763749f, 
    0.10191210f, 0.07693312f, -0.11121245f, 0.15199050f, -0.06288377f, -0.14792641f, -0.10103156f, 0.05911380f, 
    -0.02747207f, 0.17967403f, 0.07743888f, -0.08203793f, -0.59102672f, -0.03578311f, 0.19775032f, 0.09498326f, 
    0.08407785f, 0.04508175f, 0.04005273f, 0.20795621f, 0.23476586f, -0.14435735f, -0.01790344f, 0.02312363f, 
    0.09732512f, 0.11515903f, -0.02464403f, -0.04614563f, -0.17874497f, -0.01375900f, -0.08058301f, 0.01860436f, 
    0.24659728f, -0.07242571f, 0.21450432f, 0.24233682f, -0.12140723f, 0.03919253f, 0.11007031f, -0.06786710f, 
    -0.27836633f, -0.18529694f, 0.11382911f, 0.15091936f, -0.08179315f, 0.02526835f, -0.08739928f, 0.00240095f, 
    0.26534453f, 0.11930548f, -0.16805908f, -0.17020129f, -0.22904339f, 0.02430034f, 0.08602863f, -0.03475611f, 
    -0.25002748f, -0.06537671f, -0.21786550f, -0.17996448f, -0.05928117f, -0.19546060f, -0.03641237f, -0.04531661f, 
    -0.08804427f, -0.06302385f, -0.02904318f, -0.03226706f, -0.13705753f, -0.07733675f, -0.06358032f, -0.09205147f, 
    0.15153030f, -0.36868557f, -0.23865893f, -0.00118507f, 0.08021704f, 0.13084258f, 0.02737443f, 0.08874530f, 
    0.07246124f, 0.03950532f, 0.13432150f, -0.09929783f, -0.03409887f, -0.12891746f, 0.03282883f, 0.00530008f, 
    -0.00334883f, 0.18238358f, 0.10452623f, 0.07957719f, -0.32245335f, 0.07612019f, -0.05294167f, 0.09638784f, 
    -0.34904447f, 0.06864545f, -0.05028882f, 0.14313126f, -0.03482537f, -0.17035927f, -0.15074982f, -0.07828856f, 
    -0.01488884f, 0.03275283f, -0.04412393f, -0.09464125f, -0.10317666f, -0.23040663f, -0.05381667f, 0.06809743f, 
    0.07101597f, 0.05006631f, -0.11797322f, -0.13211684f, 0.13391696f, 0.02950899f, -0.13450769f, -0.16570973f, 
    0.01752225f, -0.03402993f, 0.02751463f, 0.06779005f, 0.01270030f, -0.05749432f, -0.09766295f, -0.11217151f, 
    0.00713992f, -0.12102432f, 0.17539847f, 0.02451112f, -0.03646044f, 0.04920100f, -0.12107679f, -0.06715076f, 
    -0.02648434f, 0.01188928f, 0.01815110f, -0.10360332f, 0.03913790f, 0.09446560f, -0.05457361f, -0.07792289f, 
    -0.02476399f, 0.13514236f, 0.04445114f, 0.01468182f, 0.05239141f, 0.05227069f, 0.12207859f, -0.00834338f, 
    -0.41598377f, 0.22336872f, 0.66074610f, -0.23276600f, 0.23336984f, 0.00015671f, -0.14698458f, -0.04004705f, 
    0.00871473f, -0.11349675f, 0.12186175f, -0.00739460f, -0.04766318f, -0.01451809f, 0.13268921f, 0.10099445f, 
    -0.04407099f, 0.09733557f, -0.25497326f, 0.03547457f, 0.02981254f, -0.22853814f, -0.19546163f, 0.08425031f, 
    0.03602194f, 0.06907248f, 0.09573879f, 0.24359573f, 0.11869168f, 0.08406822f, 0.00717357f, -0.02293381f, 
    -0.00001882f, -0.10296376f, 0.03536314f, -0.06010753f, -0.02768628f, 0.12463313f, 0.15865579f, -0.02119885f, 
    0.48243651f, 0.15857279f, -0.16836765f, 0.03459407f, 0.15682268f, 0.17351861f, 0.02493216f, 0.10041696f, 
    0.14388373f, -0.06545407f, -0.15858155f, -0.06936271f, 0.08816285f, 0.15671693f, 0.01727286f, -0.11804273f, 
    -0.03326963f, -0.03306090f, 0.00016904f, 0.03604549f, -0.54864329f, 0.22090016f, -0.12335160f, 0.14828196f, 
    0.41108736f, 0.05703455f, 0.06755744f, 0.29402161f, -0.27558973f, 0.04996216f, 0.05486258f, 0.03468099f, 
    -0.22905646f, -0.08666424f, 0.13517867f, 0.17848767f, 0.06056701f, 0.17649674f, -0.19829798f, -0.02655664f, 
    0.16191471f, -0.20978418f, 0.07656638f, 0.06185763f, 0.06417314f, 0.10863175f, 0.12113270f, 0.06869342f, 
    -0.01609113f, -0.07394570f, 0.16919114f, -0.04063784f, 0.06492251f, -0.00693050f, -0.03654737f, -0.06562186f, 
    0.12784535f, 0.15798855f, -0.02600023f, 0.01489543f, -0.12088280f, 0.01668558f, 0.13268338f, 0.00675337f, 
    0.03354244f, 0.09721108f, 0.01601592f, 0.02567527f, 0.11406121f, 0.10522352f, -0.09852369f, -0.08466654f, 
    -0.14008117f, 0.19596100f, -0.03093377f, -0.13383448f, 0.03533336f, 0.15026431f, 0.15591611f, 0.02964180f, 
    -0.34823990f, 0.09749302f, 0.12648404f, -0.23345809f, 0.28845614f, 0.11093819f, 0.08335233f, 0.13435006f, 
    -0.01222577f, -0.07203592f, -0.05373787f, 0.06161460f, 0.12462680f, 0.03535662f, 0.12623583f, -0.11048888f, 
    -0.09785882f, 0.05747005f, 0.02040986f, -0.08882308f, 0.42026794f, 0.18623371f, -0.45474836f, 0.12449681f, 
    -0.07533071f, 0.16619021f, -0.01375256f, 0.04923322f, -0.01453936f, -0.03303289f, 0.07615598f, 0.15591301f, 
    -0.10088937f, -0.05174676f, -0.00719683f, 0.08850314f, 0.05852376f, 0.08220594f, -0.11317237f, 0.03528493f, 
    -0.08006023f, -0.16201530f, -0.12995982f, -0.14445369f, 0.07402048f, 0.10426521f, -0.05381911f, 0.02566048f, 
    0.22026587f, 0.06599915f, 0.08722147f, -0.10213452f, 0.11372413f, 0.14016049f, -0.03700835f, -0.13722678f, 
    0.08576228f, 0.07944532f, -0.03567497f, 0.03483612f, -0.17130174f, 0.08631938f, 0.05140854f, 0.17418011f, 
    0.31914335f, 0.05761278f, 0.04121722f, -0.08604029f, -0.03833206f, 0.02367000f, 0.04763933f, 0.08651233f, 
    0.00752920f, -0.13238162f, -0.08395114f, 0.04109032f, 0.04147422f, 0.06145509f, -0.02717394f, 0.05020398f, 
    -0.00139548f, 0.16183746f, 0.05754930f, -0.20851591f, -0.20200862f, 0.00429611f, 0.01589950f, 0.07957553f, 
    -0.06022510f, -0.08930781f, 0.08604050f, 0.09600929f, 0.07568052f, 0.02757643f, -0.01518628f, -0.12199132f, 
    -0.02389214f, 0.00753606f, -0.00279696f, -0.10743043f, 0.03447657f, -0.36297438f, 0.05993525f, 0.21208766f, 
    0.35995737f, -0.02345482f, 0.02525820f, 0.04414728f, -0.00143714f, -0.09121414f, 0.12630932f, -0.01160077f, 
    -0.01538686f, -0.08104878f, -0.00632225f, -0.03748316f, 0.12834764f, 0.01190207f, 0.16046329f, -0.00152905f, 
    -0.02200930f, 0.16798294f, 0.35342044f, 0.21965119f, 0.47802243f, -0.00218028f, -0.01830791f, -0.05411596f, 
    0.04766817f, -0.11446613f, 0.02275240f, -0.01432038f, 0.03079272f, -0.00542780f, 0.04451444f, 0.04271215f, 
    0.00555438f, 0.03062812f, 0.03624449f, -0.11177418f, 0.26394752f, 0.13069934f, 0.25308004f, -0.12191202f, 
    -0.04728825f, -0.04374425f, -0.02636329f, 0.02735464f, 0.03724324f, 0.05719799f, 0.00196321f, -0.02960622f, 
    0.02593985f, 0.11135718f, 0.04766783f, 0.02982815f, 0.04416871f, -0.04382034f, 0.07813016f, 0.03056270f, 
    -0.43119615f, 0.17080857f, 0.27685210f, -0.02801416f, -0.23424433f, -0.06623838f, -0.14223863f, -0.11800977f, 
    0.01693930f, -0.06644978f, -0.08541489f, -0.05643418f, 0.16401333f, 0.04618983f, -0.04019724f, 0.00607895f, 
    0.07256839f, 0.00220416f, -0.18828879f, -0.07443263f, -0.07682128f, -0.19719365f, 0.33041707f, 0.04471573f, 
    0.06225230f, 0.02948395f, -0.02681047f, 0.03869219f, 0.00195407f, 0.03090857f, 0.05309252f, -0.00577408f, 
    0.07219113f, -0.04173695f, -0.00928148f, 0.02079746f, 0.06896280f, 0.04171545f, -0.03038788f, -0.03678840f, 
    0.87290311f, 0.70318782f, -0.19948356f, -0.18970124f, -0.48734045f, 0.03621358f, -0.08445665f, 0.07174482f, 
    -0.17095295f, -0.13090876f, -0.04777729f, 0.02436831f, 0.03461855f, 0.06144322f, -0.08906290f, 0.01349187f, 
    -0.02919959f, -0.32261389f, 0.16294627f, 0.09490145f, 0.06190517f, -0.20504218f, 0.27795607f, -0.26699594f, 
    0.09251175f, -0.05352118f, -0.07266652f, -0.01168741f, 0.27774128f, 0.15832728f, -0.07422484f, -0.00714531f, 
    -0.06721972f, -0.10795719f, 0.03508895f, -0.01250723f, -0.01115701f, 0.32838133f, 0.03330342f, -0.05142959f, 
    0.37035191f, 0.02109567f, 0.02352564f, 0.01758752f, -0.17438118f, 0.09887881f, -0.07315028f, 0.00804995f, 
    -0.08752637f, 0.03103372f, -0.01506820f, -0.01973107f, -0.02176072f, 0.10705858f, -0.00985257f, 0.08891971f, 
    -0.04242812f, 0.11152162f, -0.03477101f, 0.14883953f, 0.28982714f, -0.01568310f, -0.08039322f, 0.07908289f, 
    -0.07170061f, -0.13506567f, -0.06048777f, -0.01661803f, -0.06489392f, -0.11904696f, 0.12419129f, 0.09564939f, 
    0.02133881f, -0.12907249f, 0.01072036f, 0.00714664f, 0.06029433f, -0.05879175f, -0.11125838f, -0.01491121f, 
    -0.15596586f, 0.09241708f, 0.21418776f, 0.73389280f, 0.22699919f, -0.17647143f, 0.05174026f, -0.21489277f, 
    0.14399499f, -0.04400988f, 0.01082695f, 0.07593004f, 0.01880666f, -0.06002615f, -0.01050396f, -0.04312585f, 
    0.09476084f, -0.00076077f, -0.14317566f, 0.12156074f, -0.30726570f, 0.10645501f, 0.34267482f, 0.48963907f, 
    -0.00598770f, -0.04542550f, -0.07804324f, -0.28043777f, 0.13298574f, 0.15752082f, -0.00326252f, 0.02672935f, 
    -0.03992599f, 0.06349248f, 0.07412841f, -0.08191173f, -0.01146703f, -0.07051738f, -0.08921380f, -0.08020434f, 
    0.26601756f, -0.05884415f, 0.02533318f, 0.09840534f, -0.17951150f, -0.11426165f, 0.06308272f, 0.10417791f, 
    -0.01731467f, -0.08231363f, -0.10031720f, -0.03242449f, 0.19789457f, 0.11334857f, 0.04776200f, -0.10287936f, 
    -0.03057272f, -0.03745465f, -0.06304254f, 0.03244078f, -0.05727735f, 0.34023958f, 0.06534972f, 0.21044755f, 
    0.18745837f, 0.10282522f, 0.02996040f, 0.09356388f, 0.16199593f, 0.22672510f, -0.07282335f, 0.01672601f, 
    0.06875160f, 0.01598812f, 0.08768147f, -0.01628302f, -0.02079217f, 0.05093350f, -0.08941076f, 0.15727104f, 
    -0.02684330f, -0.44368583f, -0.14544737f, -0.08471472f, -0.08244751f, 0.04610434f, 0.10466158f, -0.01533735f, 
    0.03191701f, 0.07034045f, 0.07881683f, -0.05451876f, 0.13127863f, 0.08321976f, -0.07766420f, 0.19299529f, 
    0.00013226f, -0.12946102f, 0.03295404f, 0.11200213f, 0.70437169f, 0.02059381f, -0.04976896f, 0.00536486f, 
    -0.23606712f, -0.05364254f, -0.01947361f, -0.07560903f, -0.01338552f, -0.02968613f, -0.02893289f, -0.08035111f, 
    -0.06703575f, -0.14132802f, 0.00746376f, 0.00114114f, 0.07262754f, -0.08896995f, 0.02073884f, -0.04904490f, 
    -0.29302481f, 0.44114354f, 0.22032526f, -0.03615451f, 0.17497011f, -0.10304984f, 0.10344151f, -0.20715475f, 
    0.03539299f, -0.02208986f, -0.12247664f, -0.09607158f, 0.05427992f, -0.02840536f, -0.07018606f, 0.06529047f, 
    -0.08456007f, 0.05785001f, 0.15867215f, -0.03203328f, 0.09136729f, 0.04579128f, 0.06919687f, 0.06398615f, 
    -0.00970930f, -0.10340078f, -0.16842496f, -0.11042089f, -0.05653748f, -0.05688430f, 0.01824420f, 0.04134852f, 
    -0.01671257f, -0.05412360f, 0.04455628f, 0.03589885f, 0.08465586f, -0.10379319f, -0.02096350f, -0.04626813f, 
    -0.23169546f, 0.09182939f, 0.11854301f, 0.43925846f, 0.21294880f, -0.02754707f, 0.10587966f, 0.00120914f, 
    0.12465645f, 0.04406296f, -0.10248087f, 0.01206068f, -0.06196189f, 0.03551375f, 0.04605733f, -0.00148002f, 
    0.01979828f, -0.02728709f, -0.08635180f, 0.13355389f, 0.36462483f, -0.02224877f, -0.07871777f, 0.12347137f, 
    -0.18404104f, -0.15770701f, -0.11415281f, -0.08436554f, -0.02595980f, -0.05826486f, -0.00265139f, 0.04662025f, 
    -0.02566855f, -0.15182185f, 0.01186037f, 0.01410606f, -0.01493932f, -0.09279195f, -0.12875615f, -0.04337471f, 
    0.24344465f, -0.14361081f, -0.32018924f, -0.15495408f, -0.04229810f, 0.02006136f, 0.01737524f, 0.08375815f, 
    -0.06413885f, -0.02379718f, -0.00880906f, 0.11091246f, -0.02807486f, 0.00141468f, 0.02537978f, -0.01224619f, 
    -0.05355380f, 0.05984021f, -0.07519870f, -0.01188769f, -0.17862149f, -0.14109860f, 0.26596212f, 0.09650864f, 
    0.05959167f, 0.02960209f, -0.08307179f, -0.05723176f, 0.04756505f, -0.04221050f, -0.00527521f, 0.04496265f, 
    0.03933309f, -0.04728559f, -0.01687018f, 0.00202947f, -0.07675982f, -0.13361014f, -0.03071931f, -0.06691012f, 
    0.12999400f, -0.00720570f, -0.01914381f, 0.03478367f, 0.05386861f, 0.03991831f, -0.01795544f, -0.10699433f, 
    0.06152423f, -0.03796823f, -0.11329894f, -0.00837706f, 0.09044746f, 0.06795263f, -0.06646143f, 0.02320134f, 
    0.06281955f, -0.12578750f, 0.04386999f, 0.12141949f, -0.00602346f, 0.09991359f, -0.01063875f, 0.46251374f, 
    0.29434341f, -0.00102041f, 0.17341740f, -0.07673979f, 0.06814867f, 0.12332545f, -0.08538584f, -0.01268283f, 
    0.03157226f, 0.08866148f, -0.02552986f, -0.03531686f, 0.03859735f, 0.03948583f, -0.12373948f, 0.07372156f, 
    -0.21547495f, -0.01738285f, 0.17852394f, 0.02920727f, -0.04781481f, 0.03796492f, -0.06440800f, -0.03588377f, 
    -0.18611535f, -0.08069010f, 0.12919562f, 0.04475283f, -0.14362352f, -0.11005728f, 0.15694909f, 0.12390851f, 
    -0.07508879f, 0.08764785f, -0.00169026f, -0.01847866f, 0.40973967f, -0.14124285f, 0.65926397f, -0.09762792f, 
    -0.09009040f, 0.06727589f, -0.04140117f, 0.06254464f, 0.16309558f, -0.12915543f, -0.04206918f, -0.06503122f, 
    0.24205957f, -0.06345484f, -0.08786245f, 0.02664925f, -0.01115131f, -0.13689438f, 0.25846156f, -0.09047461f, 
    -0.26084742f, 0.29723343f, 0.13744493f, 0.05684735f, -0.05329035f, -0.04020642f, 0.00610824f, -0.13123047f, 
    0.10111519f, 0.01158137f, -0.07641020f, -0.04260521f, -0.01098594f, 0.08220276f, -0.01146516f, 0.03537595f, 
    -0.07958940f, 0.07787079f, 0.12995526f, -0.03030604f, -0.06337485f, 0.06799955f, 0.54018271f, 0.34152368f, 
    0.28313932f, 0.18580456f, 0.05197827f, 0.02038972f, 0.19528928f, -0.06000269f, -0.03684350f, 0.08247007f, 
    0.05270608f, -0.17557308f, 0.00122452f, 0.02868514f, 0.00314735f, -0.12871602f, -0.06873965f, -0.03081025f, 
    0.20690559f, -0.25106353f, -0.26558688f, -0.06187983f, -0.23157035f, -0.10111126f, 0.00331906f, 0.00111816f, 
    -0.12745364f, -0.06205701f, 0.12738311f, 0.07824950f, -0.02522561f, -0.00184395f, -0.04358074f, -0.04552332f, 
    -0.01214135f, 0.05583008f, -0.00803420f, -0.06443010f, -0.23803474f, 0.06749036f, -0.04594940f, 0.21524256f, 
    0.11782110f, -0.08461770f, 0.18968615f, -0.02959777f, -0.08144567f, 0.15948665f, 0.03187259f, 0.09651305f, 
    0.02962871f, -0.09115537f, 0.06450658f, 0.15203096f, 0.09709603f, 0.12330110f, -0.00943628f, 0.27457497f, 
    -0.27132004f, 0.27019638f, 0.14435939f, 0.22681616f, 0.23381752f, -0.04301304f, -0.02541160f, -0.05854886f, 
    0.07063744f, -0.08059780f, -0.04074069f, 0.04268605f, -0.03616933f, -0.09527199f, 0.12099073f, -0.06993773f, 
    0.04428560f, -0.00361766f, -0.09298842f, -0.03864932f, -0.34779567f, -0.37126550f, 0.01650778f, 0.02291553f, 
    -0.12522990f, 0.05664198f, -0.01252759f, -0.02780196f, -0.02133724f, 0.01963505f, 0.02468365f, 0.00177149f, 
    0.09335205f, 0.08798881f, 0.03634329f, 0.12431581f, 0.08804241f, -0.11562651f, -0.07847273f, 0.08093344f, 
    0.16795044f, -0.15940776f, 0.07838938f, -0.08287927f, -0.06372875f, -0.00586394f, -0.08083852f, -0.05951124f, 
    -0.08531434f, 0.00306865f, 0.06633762f, 0.00345855f, -0.00570546f, -0.00632896f, -0.04091323f, 0.07369227f, 
    -0.06414454f, 0.00041963f, -0.00834423f, 0.00426776f, -0.10537694f, -0.04039153f, 0.04362543f, 0.15464377f, 
    -0.23302670f, 0.16020282f, 0.08918319f, -0.05258603f, 0.03146340f, 0.24341427f, -0.09662668f, 0.01011574f, 
    -0.03824697f, 0.01674981f, 0.00503069f, -0.14300402f, -0.01189076f, -0.23859204f, -0.15407558f, -0.13255304f, 
    -0.11244122f, -0.13762242f, 0.37921286f, -0.04069510f, -0.19542077f, 0.05017936f, -0.05968916f, -0.10407345f, 
    -0.11262330f, -0.00603191f, -0.04659348f, -0.06106916f, -0.03835734f, 0.08358687f, 0.08169904f, -0.01629447f, 
    -0.03172357f, 0.02246679f, 0.08720124f, -0.00499776f, 0.31723854f, -0.02312582f, -0.02220512f, -0.09957458f, 
    -0.16363995f, 0.07074072f, 0.02103743f, -0.02153376f, 0.06860358f, 0.01287040f, 0.03225401f, -0.00402517f, 
    0.02127254f, -0.02102572f, -0.01627582f, -0.02205008f, -0.02368328f, 0.14407760f, 0.02638256f, -0.06987860f, 
    0.29205537f, 0.20218882f, 0.03552209f, 0.20442174f, 0.08225526f, -0.03831165f, -0.05229219f, -0.08573256f, 
    -0.07278692f, -0.10079087f, 0.04361870f, 0.01489552f, -0.08889722f, -0.07527977f, 0.04632156f, -0.04652472f, 
    -0.08243333f, 0.07075306f, -0.03127535f, -0.22639924f, 0.40849662f, 0.16811249f, -0.01600431f, 0.01501472f, 
    -0.01853818f, -0.09828620f, -0.01450101f, -0.13159870f, -0.13011971f, 0.00613529f, 0.00347402f, -0.00251959f, 
    0.02268545f, -0.03082823f, 0.03403747f, -0.09641656f, -0.12019684f, -0.03750985f, -0.00800648f, -0.02587619f, 
    0.50777960f, -0.14918342f, -0.23419307f, -0.21313642f, -0.09149325f, 0.06926021f, -0.04031678f, -0.05612426f, 
    -0.13794152f, 0.04222597f, 0.11639866f, 0.00614320f, 0.06241602f, 0.08786288f, 0.07847427f, 0.01474409f, 
    0.13985987f, 0.01499262f, -0.03686303f, 0.08540819f, -0.09120526f, 0.41730219f, 0.25986436f, 0.30489457f, 
    0.11329197f, 0.11365286f, 0.08713129f, 0.01911238f, 0.03132443f, -0.06235265f, -0.02279599f, 0.12186255f, 
    0.00554625f, -0.10181894f, -0.01497130f, 0.01626685f, -0.00492862f, -0.24107142f, 0.11144461f, 0.07289416f, 
    0.02025193f, 0.02519810f, -0.03091979f, -0.04454914f, -0.04409726f, 0.00519568f, 0.02019870f, -0.01768609f, 
    -0.02498564f, 0.02728827f, 0.00977221f, 0.00819661f, 0.02865743f, -0.01777560f, 0.00078672f, -0.01159796f, 
    -0.04732626f, -0.03160378f, 0.02880028f, 0.01807040f, -0.01700985f, -0.04450449f, 0.00624453f, -0.01274219f, 
    0.00410070f, -0.01965249f, 0.00004765f, 0.00037169f, -0.03301823f, 0.01706981f, -0.01089411f, -0.03008042f, 
    0.02787232f, 0.02664554f, -0.00880563f, -0.03177416f, -0.00269796f, -0.02495516f, -0.04551763f, -0.04457620f, 
    -0.00152966f, -0.02927059f, -0.04252837f, -0.01414950f, -0.00832258f, -0.01081723f, -0.03674211f, -0.00114361f, 
    -0.03998428f, 0.00210872f, 0.01636663f, -0.00020738f, 0.02907263f, -0.03146133f, -0.01965369f, -0.02293653f, 
    0.00101521f, -0.01592462f, -0.00010071f, 0.02037274f, -0.00901685f, 0.01208529f, 0.02562104f, 0.00333601f, 
    -0.00142951f, -0.01669385f, -0.02160349f, -0.03166923f, -0.02650202f, -0.00740285f, -0.00109127f, 0.00845204f, 
    -0.00118659f, -0.03873141f, -0.03032053f, -0.04225671f, -0.04731300f, 0.01412983f, 0.01009569f, -0.04183201f, 
    0.03100356f, -0.04149298f, -0.00919994f, 0.00678395f, 0.03074349f, 0.00894047f, -0.04071798f, 0.00150960f, 
    -0.03483724f, -0.02807348f, 0.01102948f, 0.01057538f, -0.00903330f, -0.01061512f, -0.03044434f, -0.01495566f, 
    -0.01638107f, 0.02067814f, 0.01846643f, -0.02892094f, -0.02190776f, -0.03168770f, 0.02555028f, -0.04106615f, 
    -0.04469921f, -0.03709494f, -0.01976039f, -0.00464061f, 0.02860409f, -0.00642609f, 0.01045986f, -0.04229507f, 
    0.00148419f, -0.02646842f, -0.03210759f, -0.01420421f, -0.03466811f, -0.03825666f, -0.03899620f, 0.02738795f, 
    0.00064104f, -0.01650195f, -0.04515675f, 0.01429950f, -0.04095974f, -0.03172075f, -0.04032347f, -0.00524114f, 
    -0.00966374f, -0.00519199f, 0.00409243f, 0.01429353f, 0.01694176f, -0.04011592f, -0.04646238f, -0.00795257f, 
    0.01442850f, -0.00231052f, 0.02351986f, 0.02020239f, -0.03668689f, -0.03389870f, 0.02060253f, -0.02526502f, 
    -0.04251439f, -0.03429512f, -0.03900971f, -0.04561160f, 0.01131185f, -0.02084592f, 0.00576672f, -0.02690128f, 
    -0.04764780f, -0.02749489f, 0.03077089f, 0.00067956f, -0.02150033f, -0.00257061f, -0.04012295f, -0.03035445f, 
    0.02648809f, -0.04468348f, 0.02146593f, -0.04113867f, -0.04343178f, -0.03878805f, -0.00187875f, -0.00562424f, 
    0.02514448f, -0.04604292f, -0.03400610f, 0.01381598f, -0.03104085f, -0.04706056f, -0.02242418f, -0.01916911f, 
    -0.04739317f, -0.03350239f, -0.01936865f, -0.01454119f, -0.04182643f, 0.00102225f, -0.01469189f, -0.02339328f, 
    0.01513296f, -0.02217002f, 0.00434891f, 0.02689225f, -0.01729887f, -0.01980086f, -0.00973946f, -0.00999218f, 
    0.02495440f, -0.03849354f, 0.00414165f, -0.04770621f, 0.02122844f, 0.00706354f, 0.01184095f, 0.00345711f, 
    0.02686699f, -0.02218145f, 0.01943687f, -0.04029874f, -0.04505204f, -0.02505997f, 0.00938166f, 0.00366724f, 
    0.01909725f, -0.02426937f, 0.02142505f, -0.03405812f, 0.00200581f, 0.00687888f, -0.03342413f, 0.00337330f, 
    0.02456644f, -0.02837438f, -0.03613112f, -0.00999514f, 0.02281490f, -0.01344761f, 0.02033943f, 0.02740945f, 
    0.02090705f, -0.01352411f, -0.03822711f, -0.01013093f, -0.00293181f, 0.03109745f, 0.02927920f, 0.01582544f, 
    0.00821598f, -0.03416374f, -0.00538886f, -0.02266530f, 0.00704619f, -0.03444739f, -0.00116562f, -0.00612394f, 
    -0.04409506f, -0.02698432f, 0.00858532f, -0.00803029f, -0.03215664f, -0.02635573f, 0.00952002f, 0.02205063f, 
    0.00149904f, 0.02362780f, -0.03316326f, 0.01434105f, 0.01991288f, -0.03413435f, 0.00754265f, -0.02501707f, 
    0.02668465f, -0.01637304f, 0.00269667f, 0.02637889f, -0.00462908f, 0.00443905f, -0.02798531f, 0.00972319f, 
    0.00485868f, -0.03380126f, -0.02844165f, -0.01750585f, -0.03429739f, -0.03348456f, -0.03702814f, 0.01447150f, 
    -0.02619919f, 0.02460299f, -0.01298106f, 0.01420001f, 0.02916798f, 0.00869004f, -0.03476711f, -0.02103093f, 
    -0.03816161f, -0.02986849f, -0.01341509f, -0.04189364f, -0.04524950f, 0.01047892f, -0.03445676f, -0.04442360f, 
    0.01641874f, -0.04101793f, -0.03033370f, -0.01586736f, 0.02889631f, 0.00495836f, -0.03922480f, -0.00951402f, 
    0.02045203f, 0.02257345f, 0.01333490f, -0.03441669f, -0.00203131f, -0.03694595f, 0.01935805f, -0.03497989f, 
    -0.03084418f, -0.03442550f, -0.00728168f, 0.01922580f, 0.01259684f, 0.02187607f, -0.02443775f, -0.03919619f, 
    -0.03293809f, -0.01868602f, -0.01307711f, -0.01793311f, -0.00197366f, 0.00656510f, -0.00823114f, -0.04300456f, 
    -0.00116976f, 0.03059611f, -0.02204536f, -0.01523497f, 0.02933371f, 0.00435077f, -0.00568334f, -0.04777003f, 
    -0.02465878f, -0.02373408f, -0.02973022f, -0.04305093f, 0.00972877f, -0.03496952f, -0.00398485f, -0.03260237f, 
    -0.00257022f, 0.00094403f, -0.01255234f, -0.03888848f, 0.00894534f, 0.01888926f, -0.00147550f, -0.04790115f, 
    0.01714362f, -0.02205673f, -0.00654630f, -0.00329422f, -0.04341073f, -0.01748576f, -0.01840721f, -0.00879113f, 
    -0.00471042f, 0.01888222f, -0.00249386f, -0.00068891f, -0.01020809f, 0.02285688f, 0.02270311f, -0.04342312f, 
    0.00397380f, -0.01213004f, 0.02431114f, 0.01142828f, 0.01914281f, 0.01685899f, -0.00620407f, 0.00089767f, 
    0.01541316f, -0.00442177f, -0.04127590f, -0.00616012f, 0.02455353f, 0.00748853f, -0.00101825f, -0.03061916f, 
    0.01377163f, 0.01754034f, 0.01983451f, 0.02293123f, -0.02567902f, -0.04121239f, -0.00740646f, -0.02015096f, 
    -0.03782370f, 0.02827536f, -0.04424271f, -0.00721537f, -0.04422637f, 0.02167604f, -0.02694925f, -0.03693165f, 
    0.01150971f, 0.02890506f, 0.00366358f, -0.02672621f, 0.02546025f, -0.01576007f, -0.00057686f, 0.00765249f, 
    0.00218282f, 0.00986595f, -0.00020995f, 0.02727859f, -0.02677406f, -0.00960660f, 0.01800429f, -0.00003513f, 
    -0.00908040f, 0.03101263f, -0.02843522f, 0.00785168f, -0.01895409f, 0.00200897f, -0.04187038f, -0.03351155f, 
    0.00572422f, 0.02363440f, -0.03536443f, -0.04252274f, -0.00404118f, -0.03902369f, 0.02104003f, 0.01372849f, 
    -0.04661148f, 0.01618094f, -0.00008227f, -0.03980923f, 0.03043308f, -0.03623037f, 0.00611701f, -0.00551466f, 
    0.01560392f, -0.01922584f, -0.03020099f, 0.01066154f, 0.02835750f, 0.01707370f, -0.02759529f, -0.01167978f, 
    -0.04096946f, -0.01609251f, 0.01569329f, 0.00546548f, -0.00553238f, -0.01585903f, -0.01814696f, -0.03605776f, 
    -0.03437219f, -0.03146777f, 0.01300526f, -0.03823196f, 0.01816301f, 0.00687572f, -0.01446664f, 0.02300261f, 
    -0.03488145f, 0.02064655f, -0.00336043f, 0.01101934f, -0.00068996f, 0.00085951f, -0.04469096f, 0.00660648f, 
    0.00233381f, 0.00297324f, -0.01298469f, -0.03162048f, -0.03246701f, 0.03044675f, -0.01260565f, 0.01557428f, 
    0.02538741f, 0.00682274f, 0.01177293f, -0.00229267f, 0.00561448f, -0.03535298f, 0.00917574f, 0.02963834f, 
    -0.03852152f, -0.00799035f, -0.03195500f, 0.01900236f, -0.00436957f, -0.04454377f, 0.01722183f, -0.01366649f, 
    -0.01203392f, 0.02132636f, 0.02713117f, 0.00654107f, -0.01526120f, -0.03545704f, 0.03060966f, -0.00960714f, 
    -0.02633625f, -0.01711941f, -0.01657074f, -0.00519363f, 0.00135851f, 0.01436894f, -0.02517349f, -0.02241020f, 
    0.02858488f, 0.02957978f, -0.03038026f, -0.03063601f, 0.01915568f, -0.01249422f, 0.01812037f, -0.01356162f, 
    -0.02530884f, -0.02912006f, -0.04610342f, 0.02747357f, -0.00319262f, 0.00629878f, -0.01516015f, -0.02681706f, 
    0.01593880f, 0.00807795f, -0.00275332f, 0.02866869f, 0.00204039f, 0.02395591f, -0.00134332f, 0.02325658f, 
    0.01071892f, -0.02460377f, -0.02874886f, 0.00724109f, -0.00518306f, -0.01413412f, -0.00199919f, -0.04247131f, 
    0.02720761f, -0.00256056f, 0.01272213f, 0.00804420f, -0.02867002f, 0.02690900f, 0.01236558f, -0.01258562f, 
    -0.03137757f, -0.02491716f, 0.01532277f, -0.02771318f, -0.04088642f, -0.01874362f, -0.00649942f, -0.04057528f, 
    -0.01696633f, -0.04156181f, 0.01716192f, -0.01173580f, -0.02732546f, 0.02892626f, 0.00780400f, -0.01285403f, 
    0.00999260f, 0.00950064f, 0.02615755f, -0.04537750f, -0.01477472f, 0.02851437f, -0.01630690f, -0.01219968f, 
    0.00986225f, -0.04194050f, 0.01202171f, 0.02064762f, -0.02101862f, 0.02582061f, -0.00136004f, -0.02121182f, 
    0.01084115f, -0.01182074f, 0.02426333f, 0.02990737f, -0.01371679f, -0.03356035f, -0.03752648f, -0.03392392f, 
    -0.04117728f, 0.02026516f, 0.01171160f, -0.03728855f, -0.00968116f, -0.04457299f, -0.02649127f, -0.02765739f, 
    0.00198603f, -0.04206647f, -0.02858832f, -0.00592016f, -0.02933219f, -0.00259322f, 0.00125109f, 0.00882064f, 
    -0.01758949f, -0.02929663f, -0.00421277f, -0.04579541f, 0.01804131f, 0.02680350f, -0.04433500f, -0.03643019f, 
    -0.04018186f, 0.00189533f, 0.02113185f, -0.02188543f, -0.00513498f, -0.01735587f, -0.02941909f, -0.01698671f, 
    -0.01266659f, -0.03724050f, -0.01355540f, -0.00684073f, 0.01422500f, -0.00330617f, -0.03355470f, -0.03193668f, 
    -0.02887183f, -0.01841384f, 0.02151425f, -0.02275016f, 0.02408567f, 0.02925369f, 0.01717313f, 0.03111746f, 
    0.01310724f, -0.01766126f, -0.01438205f, 0.02316749f, 0.01796844f, -0.03118916f, -0.02349127f, -0.01746310f, 
    0.42136040f, 0.04827086f, 0.12093031f, 0.06317768f, -0.22995049f, -0.00052100f, 0.16139047f, 0.08705025f, 
    0.05454561f, 0.04429720f, 0.07802758f, -0.11687355f, 0.08634242f, 0.15331736f, -0.09092430f, -0.02672670f, 
    -0.05007284f, 0.15315598f, -0.09220122f, 0.12006291f, 0.19739340f, 0.16418627f, -0.00178176f, 0.00901717f, 
    -0.10140916f, 0.03481587f, 0.04435364f, 0.16883437f, 0.03097463f, 0.03976260f, 0.13616629f, 0.11796308f, 
    -0.06917133f, -0.01569592f, 0.06046580f, 0.00473779f, 0.01355785f, -0.09404323f, -0.06446209f, -0.16984425f, 
    -0.09458999f, 0.25771695f, 0.08756887f, 0.40935829f, 0.22671309f, -0.34194824f, -0.08229382f, -0.24186262f, 
    0.06633353f, 0.09605814f, -0.11030885f, 0.02469225f, -0.04777032f, -0.08878351f, -0.02734041f, -0.00175510f, 
    0.08536319f, 0.00619850f, 0.04212181f, 0.17487451f, -0.29899138f, 0.12571225f, 0.12457710f, 0.37604097f, 
    0.22368903f, -0.00264194f, 0.02682888f, -0.15365742f, 0.08115598f, 0.01241463f, -0.02991651f, -0.02346024f, 
    0.08051245f, 0.00805827f, 0.12346900f, -0.04623693f, 0.04357751f, -0.06288816f, 0.16962069f, -0.01267295f, 
    0.23478660f, -0.05276889f, 0.03584036f, 0.21287681f, -0.15188360f, -0.07152031f, 0.29886621f, 0.15010251f, 
    0.12887281f, -0.03322804f, -0.10364536f, -0.08105798f, 0.01180494f, 0.05545391f, 0.02024943f, -0.19527625f, 
    -0.06132020f, 0.12908086f, -0.14743164f, -0.09120844f, -0.52945817f, 0.12246642f, 0.10064442f, 0.17313547f, 
    0.22266640f, -0.01955828f, -0.14958261f, 0.12824355f, -0.07634781f, 0.13858145f, -0.05697567f, -0.10860385f, 
    0.14064409f, 0.08996820f, -0.04406252f, -0.07897263f, -0.01641192f, 0.13263762f, -0.07563832f, 0.05090583f, 
    -0.27380967f, -0.42899567f, -0.15157753f, 0.35233212f, 0.05649278f, -0.05295483f, 0.19229195f, 0.02306387f, 
    -0.06397965f, 0.04671871f, 0.18609416f, 0.07818823f, 0.02326143f, 0.11701488f, 0.02660210f, -0.01346341f, 
    -0.11820356f, 0.02522282f, -0.04710085f, 0.00984700f, 0.55442202f, 0.03444865f, -0.20442249f, 0.20763832f, 
    -0.06512421f, 0.02200129f, 0.07779109f, 0.09104966f, 0.11704494f, 0.06089795f, -0.14508729f, -0.10027155f, 
    -0.06443872f, -0.00663138f, -0.03118416f, -0.04162936f, 0.04038711f, -0.16040136f, -0.06244681f, -0.06479865f, 
    -0.06262327f, 0.36879173f, 0.41846889f, 0.27468807f, -0.00838527f, -0.15739794f, -0.04674727f, 0.06518444f, 
    0.14823681f, -0.00769710f, -0.00203475f, -0.03931881f, 0.09027105f, 0.00936294f, -0.04398436f, 0.07614898f, 
    -0.12101366f, -0.07089948f, 0.29176795f, -0.00760595f, 0.24821948f, 0.11263076f, 0.16505544f, 0.07454152f, 
    -0.10236540f, 0.00342903f, 0.03103634f, 0.03270386f, -0.03327543f, -0.03922265f, 0.04708754f, 0.07372225f, 
    0.02738747f, -0.04246412f, -0.00576511f, -0.08210870f, -0.01331482f, 0.05392313f, -0.06016517f, -0.03264528f, 
    -0.40801305f, -0.09533908f, 0.01119261f, 0.28148431f, 0.15460245f, -0.21320035f, -0.10867523f, -0.05735524f, 
    -0.07294998f, 0.03347832f, -0.08846335f, 0.02809489f, -0.01601846f, 0.05003231f, 0.01231469f, 0.00062216f, 
    -0.02012686f, -0.04430072f, 0.03425215f, -0.00673084f, 0.29836333f, 0.05895371f, -0.05559871f, 0.04648482f, 
    -0.14391933f, -0.01886500f, -0.02565281f, 0.07271189f, 0.06112055f, 0.01232861f, 0.11900351f, 0.02487995f, 
    0.05256481f, -0.04553635f, 0.03510987f, -0.12611338f, 0.04559576f, -0.13679999f, -0.07610433f, -0.09420344f, 
    0.10085690f, -0.03500084f, -0.07082887f, -0.20678872f, -0.14809963f, 0.01781736f, 0.03388882f, 0.12473933f, 
    -0.09207857f, 0.12761085f, -0.08837186f, 0.14862221f, 0.05626104f, -0.01239870f, -0.03907913f, -0.03596943f, 
    -0.04862146f, 0.00003516f, -0.12290142f, -0.12959816f, -0.06279876f, -0.25643614f, -0.05004242f, -0.11540015f, 
    0.20666298f, 0.03145701f, 0.03550123f, 0.11720279f, -0.13177176f, -0.03268212f, 0.01826190f, 0.00137929f, 
    0.02197072f, 0.07737096f, -0.06317738f, 0.03015596f, -0.03785128f, 0.02516330f, 0.13603240f, 0.02348628f, 
    0.13631433f, 0.06318621f, 0.19294116f, 0.08464741f, -0.03808303f, 0.14698422f, -0.07830084f, 0.00770757f, 
    0.20094731f, 0.04849948f, -0.08444139f, 0.09099979f, 0.05003200f, 0.07931489f, -0.08659470f, -0.12412515f, 
    0.13749985f, 0.21901256f, 0.12143665f, 0.07771835f, -0.20855750f, 0.06716661f, -0.10578097f, 0.29284969f, 
    0.16948850f, -0.25385293f, 0.07585341f, -0.23565748f, -0.03988630f, 0.05102035f, -0.06614292f, -0.00272187f, 
    0.02705209f, 0.02967475f, -0.00734523f, -0.03347299f, -0.03413088f, 0.01291322f, -0.05834291f, -0.00436987f, 
    -0.15025708f, -0.37059414f, 0.20185553f, -0.26920244f, -0.05511161f, 0.04050908f, 0.12130320f, 0.08131424f, 
    -0.13495089f, 0.05289023f, 0.02524103f, 0.11535504f, -0.13739283f, -0.03811666f, 0.01096203f, 0.07863868f, 
    -0.01742238f, -0.00220999f, 0.05635665f, -0.04690229f, -0.07609227f, -0.05628392f, 0.39413196f, 0.39636964f, 
    0.05287460f, 0.19594879f, 0.06411008f, 0.05270259f, 0.37583870f, -0.26600739f, -0.19730008f, -0.08333884f, 
    0.28983372f, -0.03200331f, -0.05076322f, 0.00142032f, 0.05311792f, -0.06893099f, 0.14924416f, -0.08389270f, 
    -0.15428339f, 0.18334882f, 0.16027310f, 0.26504949f, -0.11061303f, -0.17043646f, -0.08592049f, -0.15883809f, 
    0.11990501f, -0.03661866f, -0.07873176f, -0.08473348f, 0.04977674f, 0.00237717f, 0.03534382f, 0.00754516f, 
    -0.03285108f, -0.05459332f, 0.26936829f, -0.06438548f, 0.25354347f, -0.04796516f, 0.09234246f, 0.26892221f, 
    0.24778785f, 0.05495731f, -0.06257317f, 0.04670629f, -0.04069607f, 0.00721974f, -0.13879426f, 0.02334747f, 
    0.10737124f, -0.17343304f, -0.04274167f, 0.01153947f, 0.05035992f, 0.00788152f, -0.01665039f, -0.03560090f, 
    0.00504331f, -0.03500006f, -0.26424724f, -0.07238926f, -0.25112897f, -0.15671121f, -0.01748380f, 0.09010406f, 
    -0.03394214f, 0.21713081f, 0.10611202f, -0.04468919f, -0.05144185f, -0.07643162f, -0.08014559f, 0.02742762f, 
    -0.01147433f, -0.08388025f, -0.05215584f, -0.06817584f, -0.32433856f, 0.07016108f, 0.23099330f, 0.00226305f, 
    0.23583268f, -0.25775975f, 0.23962820f, -0.06136108f, 0.02986651f, 0.01585409f, -0.06654285f, -0.11166314f, 
    0.12747829f, 0.07095980f, 0.01747514f, 0.09933098f, 0.14817436f, 0.11734064f, 0.13641894f, -0.07943968f, 
    -0.02461050f, 0.14775768f, 0.00732883f, -0.02601486f, 0.17415293f, -0.12244423f, -0.02511586f, -0.10355329f, 
    0.02288923f, 0.07682684f, -0.10938042f, 0.03647168f, -0.01674258f, -0.14732417f, 0.04838271f, 0.11006502f, 
    0.10554496f, -0.07394257f, 0.04860730f, 0.00973653f, -0.24822210f, -0.36377150f, -0.02762748f, 0.18278158f, 
    -0.06928965f, 0.15678394f, 0.08783038f, 0.13854153f, 0.14235309f, 0.03723731f, 0.11879226f, -0.06878833f, 
    0.05531575f, 0.17691763f, 0.11162020f, -0.03177496f, -0.07535183f, -0.01928254f, -0.01282533f, 0.08503787f, 
    0.22416316f, 0.01939903f, 0.10447610f, 0.05019419f, -0.26130867f, -0.00970530f, 0.01410985f, 0.11818206f, 
    0.06505867f, 0.06383995f, 0.15041997f, -0.01012658f, 0.06212635f, -0.04514639f, -0.08359846f, 0.01529115f, 
    -0.04913579f, -0.10524813f, -0.01368083f, 0.04753993f, -0.08431704f, -0.08315139f, -0.14132370f, -0.14711533f, 
    -0.04880532f, 0.04045497f, -0.01955138f, -0.14923355f, 0.01195506f, 0.02254271f, -0.14538290f, -0.07232177f, 
    0.01727693f, -0.00879048f, 0.01772602f, -0.06859306f, -0.03954954f, -0.13847327f, -0.00809845f, 0.05858415f, 
    0.03922546f, -0.19480997f, 0.35447913f, 0.27226707f, -0.28418878f, -0.02109782f, -0.03650234f, -0.06405864f, 
    0.04470025f, 0.02503308f, -0.05693381f, -0.00408777f, 0.05936675f, 0.05731616f, 0.04661815f, -0.04933004f, 
    -0.05666704f, 0.08370561f, -0.02477263f, 0.16059794f, 0.22769463f, -0.24855994f, -0.13430107f, -0.20145127f, 
    0.03621554f, -0.11072092f, -0.05100442f, 0.00954201f, -0.10965838f, -0.08980821f, 0.00544725f, 0.01502957f, 
    -0.00433285f, -0.00844957f, -0.02624422f, 0.08397338f, 0.05002581f, -0.05779927f, -0.03318411f, -0.12169790f, 
    0.52063632f, 0.01260073f, 0.26383525f, 0.07227259f, 0.03496562f, -0.14638191f, 0.03651669f, -0.03130202f, 
    -0.02090350f, -0.07660488f, 0.05022011f, 0.09357837f, 0.06895176f, -0.07272528f, 0.05173538f, 0.03315480f, 
    0.05081710f, 0.01899672f, 0.07565586f, -0.15849458f, 0.56039506f, 0.08474918f, 0.17486659f, -0.15303980f, 
    -0.14587826f, -0.24453130f, -0.07179923f, -0.13622315f, -0.02634081f, -0.10926122f, -0.02638000f, 0.05695610f, 
    0.05444400f, 0.00824257f, -0.00990915f, 0.07975835f, 0.05624175f, -0.08420630f, 0.02657345f, 0.16975868f, 
    0.51884431f, -0.21639144f, 0.13314985f, -0.25308523f, 0.11898305f, 0.05137298f, 0.17137581f, 0.16481049f, 
    -0.03741160f, 0.08490317f, 0.06065154f, -0.06699032f, 0.12487520f, 0.21484634f, -0.01522387f, -0.05060407f, 
    0.12132199f, 0.05881682f, -0.01725595f, -0.11382420f, -0.04160412f, 0.30556190f, 0.17714871f, 0.46377987f, 
    -0.01503283f, 0.09157310f, 0.02599638f, 0.09810983f, 0.08867254f, -0.11832692f, -0.03225643f, -0.00979729f, 
    0.00984224f, -0.03824697f, 0.06013250f, 0.06267469f, 0.08212911f, 0.05253484f, 0.11643776f, 0.06685301f, 
    -0.36674279f, -0.18149947f, -0.16577297f, -0.26420352f, -0.07226015f, 0.05770431f, -0.11951998f, -0.07378215f, 
    -0.08676861f, -0.13793731f, -0.02641541f, 0.19393890f, -0.08484372f, -0.00426689f, 0.18527776f, 0.07904191f, 
    -0.11475538f, 0.07637364f, -0.10212094f, -0.01059998f, -0.03446569f, -0.22517909f, -0.48748928f, -0.34882739f, 
    0.01028427f, 0.18598972f, -0.02100605f, -0.05469233f, 0.05895278f, 0.09462026f, 0.00759484f, 0.06463933f, 
    0.05634107f, 0.05628910f, -0.01853496f, -0.08431008f, 0.15609919f, -0.12048656f, 0.08912788f, 0.06764525f, 
    0.23172778f, 0.19235182f, 0.05408796f, -0.02767104f, 0.28294268f, -0.07559700f, -0.04059185f, 0.26479936f, 
    0.05618932f, 0.27148950f, -0.06399620f, 0.07818854f, -0.05400245f, 0.14144200f, 0.00186831f, 0.10687880f, 
    -0.03779403f, 0.05833151f, 0.08962286f, -0.02272647f, 0.20384245f, 0.32675558f, 0.25127149f, 0.09497941f, 
    0.13657618f, -0.03737225f, 0.01572123f, 0.32301426f, -0.06443308f, 0.31790990f, -0.03512037f, 0.02866341f, 
    0.04493746f, 0.10137530f, -0.19441976f, 0.10105693f, -0.03331181f, 0.05289142f, -0.20355092f, 0.23869908f, 
    -0.26745161f, -0.08936761f, -0.07268547f, -0.10129796f, -0.25922877f, 0.05705382f, -0.28129882f, -0.01104925f, 
    -0.08164538f, -0.12335388f, -0.05362129f, -0.03000818f, -0.06334848f, 0.00825465f, 0.06231572f, -0.07928564f, 
    0.03670696f, 0.00971912f, 0.01186128f, -0.18039010f, 0.27097762f, 0.46389514f, -0.04407484f, -0.05203144f, 
    0.03095011f, -0.01276906f, 0.06657294f, 0.03124698f, 0.02079388f, -0.02051709f, -0.05204711f, -0.01618724f, 
    -0.11951248f, 0.07456981f, -0.10557927f, 0.08122372f, -0.15004762f, -0.01327834f, -0.14432941f, 0.05260510f, 
    0.24027690f, 0.42549309f, 0.11667278f, -0.00360817f, -0.02406057f, 0.16080287f, -0.06531300f, 0.16173823f, 
    -0.14639647f, 0.06963629f, 0.01790461f, 0.06628115f, 0.06551810f, -0.07196412f, 0.10115915f, -0.10214515f, 
    -0.15852657f, -0.22098106f, 0.03216810f, -0.14998914f, -0.01922537f, 0.23196764f, -0.15455900f, -0.46728230f, 
    -0.37691700f, 0.12419070f, -0.10178703f, -0.07464729f, -0.06071223f, 0.03559040f, 0.17724280f, 0.07275032f, 
    -0.03540539f, 0.08105953f, 0.12119117f, 0.01927491f, 0.06476377f, 0.11829877f, -0.01809932f, 0.01127940f, 
    -0.73420793f, -0.48731551f, -0.10887987f, -0.02486039f, 0.05806968f, -0.07638513f, -0.02358657f, 0.05351307f, 
    0.15269054f, -0.07918956f, 0.01707853f, 0.14363365f, -0.11664353f, -0.11469884f, 0.05094340f, 0.11905677f, 
    0.05139937f, -0.04538173f, -0.07878266f, 0.04428506f, -0.42820296f, -0.39412370f, -0.52196401f, -0.29666245f, 
    0.14835033f, 0.05880024f, 0.00702719f, 0.01540537f, -0.08682758f, -0.01970440f, 0.02275581f, 0.05233115f, 
    0.16086608f, 0.06472826f, -0.04542045f, 0.23005407f, -0.03623721f, -0.07267823f, -0.16937400f, -0.13880271f, 
    0.34414548f, 0.37463078f, 0.21559235f, 0.09089579f, -0.01437580f, 0.04207237f, 0.16325353f, 0.03183560f, 
    -0.00092260f, 0.21405226f, 0.06379999f, 0.02734492f, 0.01028667f, -0.00714023f, -0.00044248f, 0.02056747f, 
    -0.16851085f, -0.03384031f, -0.09070273f, -0.18568657f, -0.04045409f, -0.30294698f, -0.53104222f, -0.32353452f, 
    -0.16181201f, 0.29785171f, -0.03764734f, 0.03004008f, 0.10816238f, 0.18712465f, 0.13470702f, 0.02836500f, 
    -0.06809131f, 0.08760614f, 0.05124151f, -0.12366499f, 0.02778178f, 0.01065827f, 0.02995381f, 0.00708096f, 
    0.08312995f, 0.12826794f, 0.10523128f, 0.12197235f, 0.36209524f, -0.06601199f, -0.12850602f, 0.02064693f, 
    0.11059371f, -0.17686465f, -0.11380096f, -0.01859214f, 0.05524598f, 0.14358300f, -0.04535538f, 0.09194247f, 
    -0.07513491f, -0.19006918f, -0.12465475f, -0.08249559f, 0.11009536f, 0.06676193f, 0.13404410f, 0.22889604f, 
    0.00829862f, -0.04157824f, 0.06233772f, 0.08020867f, -0.06188665f, 0.06890177f, -0.05049454f, 0.02213820f, 
    0.00834338f, -0.02925158f, 0.09913074f, 0.10572115f, 0.20096697f, 0.18042152f, 0.08299544f, 0.37776199f, 
    -0.24405701f, 0.00654744f, -0.13894477f, -0.16655532f, 0.04095479f, -0.01341588f, -0.00831540f, -0.16781457f, 
    -0.15383263f, 0.24683081f, 0.08711646f, 0.14641158f, -0.08365960f, -0.17854075f, 0.04076301f, -0.07348491f, 
    -0.18970139f, -0.07693212f, -0.02577969f, -0.14981321f, 0.33894360f, 0.29220536f, 0.27647293f, 0.03352149f, 
    0.14833625f, 0.12071095f, -0.12959424f, 0.13398603f, -0.03948963f, 0.07260699f, 0.14042695f, 0.12314053f, 
    0.05477800f, 0.04434354f, -0.03947056f, 0.12752292f, -0.13939480f, -0.24115239f, 0.03496239f, 0.08480274f, 
    0.37357378f, -0.01887994f, 0.23268613f, 0.15926605f, -0.02991435f, 0.18308391f, -0.04360524f, -0.02371798f, 
    0.13783333f, 0.06320085f, -0.00644655f, 0.08048568f, 0.17119880f, 0.01879891f, 0.15862612f, -0.10003246f, 
    0.29304954f, 0.05488218f, 0.03090196f, 0.25309247f, -0.08214299f, 0.16692938f, 0.05965325f, -0.11532076f, 
    -0.05357244f, -0.02935041f, -0.03887713f, 0.08751795f, -0.06587424f, -0.10399744f, 0.05803594f, -0.03799121f, 
    -0.07490442f, 0.09465383f, 0.14703825f, -0.21815336f, 0.00020449f, -0.09848833f, -0.02838502f, -0.16290365f, 
    -0.10947448f, 0.03375046f, 0.22743216f, 0.03374197f, -0.07321031f, 0.04658201f, 0.09075921f, 0.02092221f, 
    0.07732283f, 0.14682414f, 0.07878055f, 0.09231100f, 0.02981708f, -0.11734307f, -0.06111673f, 0.00238965f, 
    -0.09967714f, -0.17237979f, -0.18029279f, -0.10915032f, 0.21014546f, 0.07015514f, -0.05725091f, 0.14873154f, 
    0.18002993f, -0.05202551f, 0.02741283f, -0.06509521f, -0.01399526f, -0.06694583f, -0.13783099f, -0.01686836f, 
    -0.00638021f, 0.10451044f, 0.01724941f, 0.06292431f, 0.06706376f, 0.10482639f, 0.08332194f, 0.07086311f, 
    0.54551673f, 0.21961994f, 0.25694153f, 0.27810368f, 0.20150906f, 0.04141899f, -0.17619358f, 0.03882306f, 
    -0.01429248f, -0.17058872f, -0.05297091f, -0.01334566f, -0.00966958f, 0.06712797f, 0.13926843f, 0.22662179f, 
    -0.02043976f, 0.10609941f, -0.10883629f, 0.02755484f, -0.45229897f, -0.15414783f, 0.10343469f, -0.10456786f, 
    0.11644756f, 0.05627633f, -0.12785827f, -0.02838848f, -0.00859380f, -0.26258329f, 0.03004021f, -0.09242681f, 
    -0.09261190f, 0.14724807f, -0.08768089f, -0.07595766f, 0.07029434f, -0.08251759f, -0.07664321f, -0.10454343f, 
    0.20953232f, -0.04443028f, 0.25449565f, 0.20659336f, 0.08456132f, 0.06006799f, 0.07103810f, 0.02908775f, 
    -0.01463830f, -0.07226740f, -0.03321163f, 0.04141079f, 0.03319969f, 0.20829272f, 0.12487026f, 0.21738477f, 
    0.21575595f, 0.07762858f, -0.01343079f, 0.21128492f, -0.00174463f, 0.34864905f, 0.25205392f, -0.04928731f, 
    -0.06811755f, 0.01042733f, 0.12063254f, 0.02812641f, -0.11605702f, 0.09053772f, -0.00733523f, -0.00429165f, 
    0.10771721f, -0.17162380f, 0.05783157f, -0.13081445f, -0.22029434f, -0.25521749f, 0.03521798f, -0.19874005f, 
    -0.21361595f, -0.24029131f, -0.29624560f, -0.23708086f, 0.00859249f, -0.00891511f, -0.04261150f, -0.01965466f, 
    -0.04020856f, -0.01099420f, -0.03802225f, 0.07688381f, 0.02304053f, 0.08245905f, 0.11163530f, 0.14876555f, 
    0.01948754f, 0.02863040f, 0.00442117f, 0.17254899f, 0.04778128f, 0.24313922f, 0.29702544f, 0.17532808f, 
    0.21520300f, -0.19139546f, 0.13130978f, 0.04490888f, 0.11807384f, 0.19320434f, -0.00944711f, -0.04896219f, 
    -0.03490844f, -0.04288220f, -0.02945813f, 0.01992979f, 0.12565421f, 0.13540511f, 0.07734910f, 0.32564554f, 
    -0.45009467f, 0.06102297f, 0.10321323f, 0.18554190f, 0.13097231f, -0.17572369f, 0.08696687f, 0.00809281f, 
    -0.00040875f, 0.11203542f, -0.01630339f, -0.08151841f, -0.01618472f, 0.06420953f, -0.04351812f, 0.02615896f, 
    0.11231165f, -0.13060677f, 0.01319455f, 0.11408844f, -0.03573022f, 0.16288488f, -0.05304922f, 0.10645552f, 
    0.01325975f, -0.17148283f, -0.05803367f, 0.05992583f, 0.07889432f, 0.12124255f, 0.16076435f, -0.05180307f, 
    -0.01326396f, -0.10514562f, -0.05248954f, -0.00174537f, 0.14355130f, 0.10048898f, 0.07607704f, 0.42981026f, 
    -0.29610258f, -0.50262743f, -0.53707534f, -0.02871805f, 0.01691222f, -0.16578928f, -0.14160785f, -0.07156808f, 
    0.02260263f, 0.04846488f, 0.11231416f, 0.02501447f, 0.12507288f, -0.05550009f, -0.02525905f, 0.05927572f, 
    0.10055493f, 0.05575466f, 0.08332448f, 0.20523466f, -0.26217544f, 0.04773217f, 0.12647586f, 0.14588940f, 
    0.17910641f, -0.15013139f, -0.15041892f, -0.14692535f, 0.14241247f, 0.19996653f, 0.11839239f, -0.01032933f, 
    0.08698091f, -0.17048983f, 0.00366601f, 0.05455300f, 0.14812000f, 0.05742384f, 0.06778628f, 0.13461575f, 
    -0.36998504f, -0.05901537f, 0.07784547f, 0.26963028f, -0.06833190f, 0.09043977f, 0.03230826f, -0.12808660f, 
    -0.03038499f, -0.04354860f, -0.08116866f, 0.08748901f, 0.00477386f, 0.05993934f, -0.01314235f, 0.04382358f, 
    -0.08943193f, -0.27862981f, -0.08734846f, -0.03892332f, 0.00685490f, -0.17930414f, 0.06722619f, 0.02794031f, 
    0.12044725f, -0.25821224f, 0.36922598f, 0.05658935f, -0.00461248f, 0.06491363f, 0.02457418f, -0.07910884f, 
    -0.04541804f, 0.06783231f, 0.00706761f, 0.14004506f, 0.14344177f, 0.09357398f, 0.18341401f, 0.24771957f, 
    -0.06806143f, 0.31579676f, 0.03630889f, -0.04536373f, -0.16615511f, -0.00796151f, 0.06225359f, 0.12475561f, 
    -0.05269958f, -0.13535798f, -0.13474748f, 0.01378625f, 0.01772161f, 0.00019146f, 0.07012676f, 0.02241230f, 
    0.02678499f, 0.13885754f, 0.06173443f, 0.03042035f, 0.15472922f, 0.28741425f, 0.08353990f, 0.08956731f, 
    -0.14991248f, 0.01885977f, 0.03828027f, -0.08117042f, -0.07022331f, -0.05598497f, -0.03935368f, -0.19263199f, 
    0.08451687f, -0.09715129f, 0.07470609f, 0.06461419f, 0.03223912f, -0.10518953f, -0.05235909f, -0.05478266f, 
    -0.01231011f, -0.15831821f, -0.07089264f, 0.25943244f, 0.16817597f, -0.07015034f, -0.13068898f, 0.06702043f, 
    0.09166689f, 0.09510576f, -0.04118042f, -0.02667568f, -0.05105077f, -0.11065575f, -0.12573066f, -0.05575965f, 
    -0.06001617f, 0.00423801f, -0.18178177f, 0.08387582f, 0.21117087f, -0.04763622f, -0.09780680f, 0.27277976f, 
    0.18107784f, -0.18195203f, -0.16066499f, 0.02541064f, -0.10268249f, 0.13865234f, 0.09259254f, -0.09580337f, 
    -0.08669307f, -0.05769408f, -0.03429633f, -0.06771424f, 0.04768345f, -0.01166081f, -0.02810165f, -0.00111570f, 
    0.01009875f, 0.13064075f, 0.02831670f, -0.18587653f, -0.15047814f, 0.10058425f, 0.00802941f, 0.15988132f, 
    -0.01186403f, -0.10940792f, -0.05541075f, -0.00349815f, 0.11068714f, -0.11126430f, 0.06166860f, -0.02037471f, 
    -0.06021833f, 0.09278615f, 0.10821535f, 0.00580226f, 0.16251901f, -0.07664485f, -0.23239197f, 0.10618762f, 
    0.04051937f, -0.00936161f, 0.07768391f, -0.08799716f, 0.00823559f, -0.13958216f, 0.02690102f, 0.14815035f, 
    0.05650197f, -0.08029934f, -0.03705585f, 0.10836311f, -0.06737570f, 0.23434730f, -0.15013601f, -0.01452130f, 
    -0.20188685f, -0.07488625f, 0.05587125f, -0.13463028f, 0.04379392f, -0.08098954f, -0.06683983f, -0.14186627f, 
    0.00239428f, 0.20655185f, 0.12465298f, 0.23713621f, 0.13221709f, 0.02840704f, -0.06279277f, 0.01320979f, 
    0.05336661f, -0.18211909f, -0.06174202f, -0.20045434f, 0.05810700f, 0.09554406f, 0.18074892f, -0.06227849f, 
    -0.06608602f, 0.00257348f, 0.03340293f, 0.07889660f, 0.09132209f, -0.04148581f, -0.07864611f, -0.16883889f, 
    0.02606985f, -0.00974255f, -0.05226083f, 0.05831721f, 0.06571842f, -0.11067661f, -0.00269375f, 0.09483824f, 
    0.35182714f, 0.04757053f, 0.32486728f, 0.13243428f, 0.13710727f, 0.06679392f, -0.02901838f, -0.18071200f, 
    -0.16753203f, -0.20079221f, 0.17626138f, 0.02664428f, -0.02797930f, -0.01393138f, -0.14318441f, 0.03051198f, 
    0.09854979f, 0.07251289f, -0.02503475f, -0.14031418f, -0.07633521f, 0.25297144f, 0.07919757f, 0.06816798f, 
    -0.00528236f, -0.00435318f, -0.01680513f, 0.00830131f, -0.03201945f, -0.10889217f, 0.11251353f, 0.07885639f, 
    0.02598329f, 0.05440878f, 0.02937965f, 0.11145814f, 0.02257227f, -0.02026767f, 0.07771768f, -0.01086535f, 
    0.17152900f, -0.18478873f, -0.27104798f, 0.07464049f, 0.02907955f, 0.02713293f, -0.13258643f, 0.06558786f, 
    0.04646207f, 0.14098479f, 0.01314371f, -0.01252810f, -0.02381899f, -0.10630722f, 0.00557048f, -0.05563230f, 
    0.04210476f, -0.03967663f, -0.09203654f, -0.08904356f, 0.08823439f, 0.27060133f, 0.01447878f, 0.13521920f, 
    -0.22824478f, 0.03432033f, 0.06901321f, 0.01032444f, -0.08519305f, -0.03084587f, -0.09253766f, -0.06384879f, 
    0.00220796f, -0.06431141f, 0.03395479f, 0.00763469f, -0.00857577f, -0.10994527f, 0.04639088f, -0.01454922f, 
    0.12288324f, -0.00188707f, -0.11368492f, 0.05380126f, -0.07440021f, -0.00274104f, -0.08295977f, -0.09445170f, 
    -0.06371099f, -0.15535051f, 0.12168678f, -0.07958806f, 0.19808809f, 0.07571857f, 0.06580445f, 0.01342861f, 
    0.04138954f, -0.00344229f, -0.00244860f, -0.06089069f, -0.13106568f, -0.03054181f, 0.05773013f, 0.05634101f, 
    -0.04570008f, 0.18288355f, 0.01156405f, -0.13030469f, 0.13223015f, 0.09098890f, 0.00219798f, -0.04024496f, 
    -0.12647906f, 0.22262415f, 0.13693498f, -0.04299132f, 0.13335627f, -0.00381633f, 0.09374803f, 0.05898333f, 
    -0.13603990f, 0.40911284f, 0.35547474f, -0.02891591f, 0.03068666f, -0.06311891f, -0.02563679f, -0.11876138f, 
    0.08833539f, 0.15086176f, 0.12991415f, 0.05324796f, 0.08694027f, -0.03123524f, -0.03177541f, 0.01525380f, 
    -0.14881711f, -0.10525543f, -0.11232613f, 0.07756467f, 0.02695433f, -0.18045606f, -0.08744218f, 0.18391195f, 
    0.07757080f, 0.07038161f, -0.03191913f, 0.06741478f, -0.00767759f, 0.20248668f, 0.11330327f, 0.00596819f, 
    -0.02803674f, 0.02605968f, -0.01642605f, 0.03019788f, 0.02572283f, 0.01073691f, -0.08729350f, -0.07748982f, 
    0.21108605f, -0.07666063f, -0.11829064f, 0.13941966f, -0.05517760f, 0.20896822f, 0.04660647f, -0.05113342f, 
    0.00895484f, 0.12561513f, -0.03123258f, 0.01091508f, -0.02236525f, 0.03084156f, 0.08913091f, -0.03214357f, 
    -0.01362144f, 0.11726850f, 0.11109664f, 0.23207891f, -0.10450502f, -0.51364756f, 0.13300984f, -0.22576812f, 
    0.13116971f, -0.09043394f, 0.14522278f, 0.33170748f, -0.37764031f, 0.18586871f, 0.09116272f, -0.10025450f, 
    -0.04966043f, 0.02084344f, -0.00736753f, -0.11434956f, 0.11658276f, 0.06902890f, -0.18334338f, -0.31056249f, 
    0.07399220f, -0.17673998f, 0.07375780f, 0.15564573f, 0.00646314f, 0.08745043f, -0.10158993f, 0.00523343f, 
    0.04750963f, 0.11919481f, 0.14421163f, -0.04857974f, 0.04897932f, -0.02790595f, -0.12508641f, 0.00187514f, 
    0.10503711f, 0.00251023f, 0.04834956f, -0.01308513f, -0.08739292f, -0.07958216f, 0.19672692f, 0.05422123f, 
    -0.00402085f, 0.03677620f, -0.06685334f, 0.03552034f, 0.11460164f, 0.06424121f, 0.06278402f, -0.05116275f, 
    -0.12951930f, 0.07454053f, 0.02087655f, -0.14777838f, 0.03691255f, 0.18727574f, 0.26748338f, 0.06260458f, 
    0.13881272f, -0.17240764f, 0.25804508f, -0.12178029f, -0.05653201f, -0.04059116f, -0.09802596f, 0.03264984f, 
    0.01306328f, -0.02003526f, -0.01615115f, -0.04714276f, 0.01749584f, 0.14443327f, 0.12340923f, 0.06608506f, 
    0.06048604f, 0.05653883f, 0.02205016f, -0.03618447f, 0.40146464f, 0.06378790f, -0.49709594f, 0.07474729f, 
    -0.05081332f, 0.20854999f, -0.02534550f, -0.02552457f, -0.29820672f, -0.06045109f, 0.16029778f, 0.07385201f, 
    0.06396863f, -0.15452057f, 0.03424309f, -0.06776544f, -0.08660941f, 0.09611600f, -0.20388570f, -0.00320955f, 
    -0.02394271f, -0.14620161f, 0.03198396f, 0.05841035f, 0.02494387f, 0.10600827f, -0.09119929f, -0.07190220f, 
    0.14336208f, -0.13352592f, 0.07356686f, -0.05405078f, -0.02568848f, 0.25468925f, 0.23814087f, -0.03871675f, 
    0.23985569f, 0.21496791f, 0.04655015f, 0.15555735f, -0.23666677f, 0.06927065f, 0.15811303f, -0.02165705f, 
    0.17919585f, 0.09481442f, -0.01309885f, -0.05896986f, -0.03598995f, 0.10498916f, 0.17186566f, 0.06306780f, 
    0.22995700f, -0.00061584f, -0.13472369f, 0.05894344f, 0.03218506f, -0.20606536f, 0.07456949f, 0.01209747f, 
    0.07447397f, 0.28099495f, 0.04945068f, -0.10277013f, 0.00536675f, -0.00714630f, -0.00970591f, 0.05642289f, 
    0.00421511f, -0.13062081f, 0.06793477f, 0.12231398f, -0.00950377f, -0.00372179f, 0.05724494f, 0.08114542f, 
    0.05819470f, -0.06542814f, 0.00241239f, -0.03788090f, 0.10912342f, -0.16643508f, 0.16603078f, 0.36077976f, 
    0.17496286f, 0.08645586f, -0.07613719f, -0.13046868f, 0.06193556f, 0.09370285f, 0.07813769f, -0.02048820f, 
    -0.00193764f, -0.01939776f, 0.04396874f, -0.01332217f, 0.22865938f, -0.10728872f, 0.08500849f, 0.08123969f, 
    -0.23650613f, 0.37168282f, 0.13440472f, 0.11089602f, 0.39795163f, -0.25774813f, 0.19007389f, -0.24400809f, 
    0.15285732f, 0.04376387f, 0.15287475f, -0.00655761f, 0.02574310f, 0.02975759f, 0.02843899f, -0.06421565f, 
    0.11611311f, -0.17766717f, 0.16713250f, 0.09167343f, 0.34599087f, 0.24488018f, -0.04524941f, -0.14432855f, 
    -0.20329010f, 0.10753613f, 0.02628929f, -0.05773062f, 0.09541481f, -0.00809598f, 0.02679535f, 0.07549952f, 
    -0.05264907f, -0.06245988f, 0.03352668f, -0.12415779f, 0.00563715f, -0.06391408f, 0.03025479f, 0.18751878f, 
    0.00078272f, 0.32270229f, 0.02020506f, 0.12595055f, -0.08470353f, 0.00846321f, -0.01758471f, 0.03494020f, 
    -0.00869404f, -0.05691691f, 0.03206669f, 0.00602193f, 0.05425503f, -0.07329242f, 0.01861400f, -0.04654469f, 
    0.10195088f, 0.18863030f, -0.05863990f, -0.02068417f, 0.09340706f, 0.06696214f, 0.05986778f, 0.07365582f, 
    -0.08557195f, 0.01794573f, -0.06177302f, -0.00512821f, 0.04715324f, 0.12399311f, 0.10078675f, 0.00260415f, 
    0.08517122f, -0.06102155f, 0.00342948f, -0.03684729f, 0.04853144f, -0.05521121f, -0.07032097f, -0.02798413f, 
    0.45358700f, 0.63963157f, -0.46449348f, -0.08344200f, -0.35005602f, 0.19442616f, 0.08583120f, -0.07192024f, 
    -0.21598472f, -0.22527629f, 0.05569270f, 0.11592662f, 0.25559768f, -0.01423656f, 0.11759473f, 0.10863572f, 
    -0.08529274f, -0.04382487f, -0.03485179f, -0.02895902f, 0.03465329f, -0.12778212f, 0.56790543f, -0.28720102f, 
    -0.08388320f, 0.23635170f, -0.00707040f, -0.05532949f, 0.48298091f, 0.06232015f, 0.01733513f, -0.02153135f, 
    -0.07719153f, 0.05127035f, 0.01805106f, -0.08524561f, -0.01676952f, 0.19804540f, 0.07755947f, -0.17401889f, 
    0.22507219f, -0.05124218f, -0.12629779f, 0.12891226f, 0.05782843f, -0.01471411f, 0.01122191f, 0.00066331f, 
    0.01132057f, 0.17554313f, 0.16435423f, -0.14414406f, 0.17094494f, 0.19948570f, -0.03724163f, -0.08064592f, 
    0.01426276f, -0.12890492f, -0.03949191f, 0.04585272f, 0.04554311f, -0.16946934f, -0.23441549f, -0.07744976f, 
    -0.01131344f, -0.03653421f, 0.03393990f, 0.06152878f, 0.02961502f, 0.00149928f, -0.19826207f, 0.02278349f, 
    -0.07144357f, 0.02560377f, 0.12833452f, -0.01643422f, 0.13628951f, 0.01264670f, -0.00836295f, 0.06305137f, 
    -0.05229266f, -0.21071167f, -0.04612157f, 0.25529084f, -0.31441155f, 0.09608673f, 0.05935736f, -0.17850335f, 
    -0.05802114f, -0.37596762f, 0.09923501f, -0.05673606f, -0.00647295f, 0.03175230f, 0.01796085f, 0.01666324f, 
    0.00324690f, 0.01256818f, 0.07740700f, 0.23506634f, -0.05489082f, -0.14905936f, -0.00623981f, -0.08793573f, 
    -0.38309821f, 0.14438087f, 0.20143409f, -0.21024537f, 0.16109867f, -0.29547498f, 0.08889447f, 0.00191355f, 
    -0.00075654f, 0.01952921f, 0.18938679f, 0.00142372f, 0.00871752f, -0.01721457f, 0.01857696f, -0.12582122f, 
    0.11335312f, -0.01180681f, -0.11937810f, 0.11667327f, 0.17736311f, -0.08275376f, 0.16611670f, -0.10080761f, 
    0.00672511f, 0.16128738f, 0.17596091f, 0.01803553f, 0.11795465f, 0.11580173f, 0.04458950f, -0.00676078f, 
    -0.06961712f, -0.14190893f, -0.05130386f, 0.04436274f, 0.30682337f, -0.01387552f, 0.32641870f, -0.01079625f, 
    0.14343162f, 0.18514508f, -0.15032481f, 0.05497025f, 0.13131557f, 0.08670691f, 0.14771296f, 0.10046446f, 
    0.14389840f, 0.06256992f, 0.08405244f, -0.07369733f, 0.12525943f, 0.01304709f, 0.01259118f, 0.08374015f, 
    0.13697340f, -0.25572729f, -0.34571528f, 0.26140249f, 0.12391482f, -0.04892273f, 0.18152340f, 0.06803316f, 
    -0.00653454f, -0.10601115f, 0.06457490f, -0.12882914f, -0.05501747f, -0.04011493f, 0.01836593f, 0.11123310f, 
    0.00101404f, -0.01751669f, 0.16582279f, 0.10712636f, 0.00925512f, -0.16221122f, -0.23213434f, 0.00980725f, 
    0.02075428f, -0.04917312f, 0.07072016f, 0.03438758f, -0.02285847f, -0.01225220f, 0.14315045f, 0.00704450f, 
    0.01372185f, 0.07066554f, 0.04661214f, -0.05064355f, -0.02397294f, 0.07359824f, 0.05712445f, -0.08389237f, 
    -0.22911595f, 0.51884782f, 0.00341820f, -0.17608640f, -0.05920696f, 0.11815425f, -0.09074284f, -0.20140105f, 
    -0.01861363f, 0.08736387f, -0.08074587f, -0.06417492f, 0.09132368f, 0.10309041f, 0.03844355f, -0.13688385f, 
    -0.06156324f, 0.16204993f, 0.25842419f, -0.01312316f, 0.01063929f, -0.06654622f, -0.09202844f, 0.02962310f, 
    -0.09158620f, -0.00628344f, -0.10377442f, -0.07093320f, 0.03242481f, 0.08935318f, -0.03515280f, -0.08808617f, 
    0.05832468f, 0.18404625f, 0.10664270f, -0.00314507f, 0.09653821f, 0.04770314f, 0.01341234f, 0.04780134f, 
    -0.09096308f, -0.05178978f, 0.11663900f, -0.02053847f, 0.11205103f, 0.03220536f, -0.02210370f, -0.05715074f, 
    0.00342413f, -0.24409097f, 0.05990975f, 0.05818492f, 0.02913632f, 0.07875882f, 0.05635629f, 0.02589516f, 
    0.04839174f, 0.13109595f, 0.03049610f, 0.27813798f, 0.06545962f, -0.14634682f, -0.11728914f, -0.05473956f, 
    0.10678389f, -0.10157130f, 0.05091783f, -0.01893739f, -0.03777716f, 0.00244948f, -0.02407720f, -0.04086500f, 
    0.16996932f, 0.09972268f, 0.05375597f, 0.02335371f, 0.13733301f, 0.02839781f, -0.00429842f, -0.02148954f, 
    -0.02922703f, -0.17841268f, -0.14758894f, -0.05799988f, 0.07989933f, 0.06330794f, 0.06278902f, 0.10720959f, 
    0.11763288f, 0.10637923f, 0.00790761f, 0.09175261f, -0.07512483f, -0.07468423f, 0.02724263f, 0.04711538f, 
    0.11615165f, 0.06929668f, 0.01264350f, 0.04383405f, -0.06738309f, 0.14344507f, 0.39136279f, -0.09836881f, 
    0.15821299f, -0.10751774f, -0.09929337f, 0.10587160f, -0.03272091f, -0.04446029f, -0.02758288f, -0.03795705f, 
    -0.05961955f, -0.12781979f, 0.05639366f, -0.02699102f, -0.04595749f, -0.06782544f, -0.23737808f, -0.10425512f, 
    0.15762872f, -0.31490025f, 0.08231780f, 0.03827382f, 0.22727619f, -0.03353601f, 0.15761797f, -0.18119271f, 
    0.04713563f, -0.06572051f, -0.10522162f, 0.00733060f, 0.02319898f, 0.13187899f, 0.15662509f, -0.02184474f, 
    0.08577651f, -0.10807104f, 0.00647539f, 0.02979251f, 0.02911560f, 0.09121450f, -0.11809859f, 0.17501841f, 
    0.20150587f, -0.09571923f, 0.17914604f, 0.01063610f, -0.08366103f, -0.22169051f, 0.03291065f, -0.00301062f, 
    -0.06471747f, -0.03192819f, 0.00137248f, 0.02892148f, 0.03333868f, 0.11617738f, 0.02314065f, 0.17319024f, 
    -0.17833091f, 0.17812979f, 0.07867475f, -0.18731183f, 0.43046480f, -0.13564286f, 0.21852769f, 0.24681577f, 
    0.06856947f, -0.08667839f, -0.04023847f, 0.04127187f, -0.10453464f, -0.06914382f, 0.01732348f, 0.06691711f, 
    -0.17186823f, -0.10738891f, -0.04977128f, -0.15468706f, 0.18945146f, 0.38461414f, -0.07561631f, 0.28395304f, 
    0.40303066f, -0.03551387f, 0.14861314f, -0.02561724f, 0.02144561f, -0.03343192f, 0.09942267f, -0.04424017f, 
    0.03479475f, -0.08676263f, -0.06727593f, 0.08701383f, -0.12067776f, 0.09547413f, 0.08935770f, 0.16241984f, 
    -0.15138364f, 0.38305497f, 0.13530646f, -0.29113343f, 0.08186551f, 0.12160733f, 0.05228754f, -0.03318398f, 
    0.06819554f, -0.10992223f, 0.00705990f, -0.00232618f, 0.01617683f, 0.14574966f, 0.09816316f, -0.06945481f, 
    0.00995122f, 0.24486591f, 0.21506952f, 0.03021911f, -0.04924561f, 0.26837596f, 0.50602788f, 0.19923604f, 
    0.09505588f, 0.27033260f, -0.10020731f, 0.11980168f, 0.09720008f, -0.12893851f, -0.00820279f, 0.01339119f, 
    -0.03973177f, -0.10048208f, 0.07836458f, -0.01941732f, -0.09558604f, -0.06423653f, -0.19918077f, 0.01642182f, 
    -0.40896446f, -0.03632211f, -0.21820025f, -0.12586185f, 0.23083228f, 0.06498480f, 0.20702948f, 0.23642151f, 
    0.08020749f, 0.08499210f, 0.13975626f, 0.02938075f, -0.11191884f, -0.13576995f, -0.05462193f, -0.02787788f, 
    0.01630444f, 0.05197192f, 0.01481957f, -0.07246488f, 0.53952396f, -0.13793226f, 0.20113984f, 0.10832436f, 
    0.08456875f, -0.20762472f, 0.18073753f, 0.10671874f, 0.01519671f, 0.34882620f, -0.04040869f, 0.14562595f, 
    0.04741259f, -0.06417354f, 0.02499057f, 0.21618325f, -0.13225162f, 0.10935127f, 0.11306649f, 0.29424554f, 
    -0.31060946f, 0.21404256f, -0.01150239f, -0.09417200f, 0.19848195f, -0.10543123f, 0.13376921f, 0.18674512f, 
    -0.08126224f, -0.10094016f, -0.00568062f, 0.00237589f, -0.11494518f, -0.07276618f, -0.14401935f, 0.06113544f, 
    -0.09501863f, 0.00586510f, -0.05225558f, -0.01627151f, 0.03323591f, -0.11167287f, -0.24746314f, 0.11947408f, 
    0.02892644f, -0.00650681f, 0.05908522f, -0.07236283f, -0.05302915f, -0.06990352f, -0.03273555f, 0.01728146f, 
    -0.03043572f, 0.18026036f, 0.00416825f, 0.02209566f, 0.05766611f, 0.07572860f, 0.03363244f, 0.20095269f, 
    0.02896332f, -0.17193219f, -0.18691017f, -0.05961055f, -0.07421972f, 0.09987309f, -0.11157073f, 0.00326502f, 
    0.08752766f, 0.12845893f, 0.09425760f, -0.09451231f, 0.05802932f, 0.18795678f, -0.03654834f, -0.01376190f, 
    0.02148246f, 0.12657765f, 0.08481911f, -0.03996370f, -0.12423541f, -0.06961830f, 0.36567491f, -0.26200479f, 
    -0.10564878f, -0.00250783f, 0.12282229f, -0.07824323f, 0.11062282f, -0.00459672f, 0.05969066f, -0.01703041f, 
    -0.00860971f, -0.00697122f, -0.03669291f, 0.02952866f, -0.09859306f, -0.02257361f, 0.02222261f, -0.11683243f, 
    0.18401302f, -0.18034630f, 0.11898161f, 0.09781831f, -0.14487439f, 0.26330459f, -0.05809911f, -0.15274362f, 
    -0.06963456f, -0.08152194f, -0.02474779f, 0.04091895f, 0.05809093f, 0.05840120f, -0.02302217f, -0.07205084f, 
    -0.22941478f, 0.08901007f, 0.10054646f, -0.12221125f, 0.08423936f, 0.01498265f, 0.40996531f, 0.02027750f, 
    -0.12828842f, -0.01481364f, -0.05021201f, -0.21555895f, -0.05755728f, 0.01492857f, -0.00308952f, 0.04656508f, 
    -0.01041639f, 0.05192221f, 0.04965468f, -0.05857704f, -0.06473916f, 0.24232271f, -0.04110994f, -0.25586796f, 
    -0.10430580f, -0.03443833f, 0.41290393f, -0.08989476f, 0.22819553f, 0.03026869f, -0.01236801f, -0.23772715f, 
    -0.03090581f, 0.01934826f, -0.02256079f, 0.03595989f, -0.06765980f, -0.01828271f, -0.01104236f, -0.09266300f, 
    -0.06367180f, -0.12675296f, -0.06756119f, -0.13192983f, -0.08494715f, -0.06428801f, 0.40926251f, 0.03971298f, 
    0.12934704f, -0.02730942f, 0.04475144f, -0.18040746f, -0.06643049f, -0.07462008f, -0.05746217f, 0.04947250f, 
    0.00288489f, -0.03675351f, 0.02292044f, -0.03054438f, -0.03861045f, 0.06275079f, 0.05755843f, -0.04020825f, 
    0.50002915f, -0.35590768f, -0.03523280f, -0.14883187f, 0.21539186f, -0.02745077f, -0.17607486f, -0.04266403f, 
    0.19398068f, 0.15885942f, -0.02317146f, 0.02325065f, -0.00596324f, 0.09760400f, 0.02988722f, 0.15013614f, 
    0.11507632f, 0.02695503f, 0.12058118f, 0.14370869f, -0.06516900f, 0.54234719f, -0.02383295f, 0.03153070f, 
    -0.11563571f, -0.00695629f, -0.24184704f, -0.17620921f, 0.04847216f, -0.15188266f, 0.04846804f, 0.00125730f, 
    0.02318195f, -0.04244604f, 0.06711382f, 0.01916008f, -0.12474579f, -0.13324024f, 0.06313567f, -0.02389213f, 
    -0.00402630f, -0.03499003f, 0.01118966f, -0.01940136f, 0.01546163f, -0.03132316f, 0.01695532f, 0.00612868f, 
    -0.03624878f, -0.02055463f, 0.00279784f, -0.00417588f, -0.04172125f, -0.02964705f, -0.00223655f, 0.00999898f, 
    0.00783639f, -0.00240922f, -0.00814986f, 0.02070659f, -0.01074707f, 0.00928358f, 0.01267146f, 0.01969947f, 
    0.03107507f, -0.00242589f, -0.03393943f, 0.02278017f, -0.04421528f, -0.03002283f, 0.01466531f, -0.00070554f, 
    -0.02968115f, 0.01020988f, -0.00850098f, 0.01523919f, -0.00016705f, -0.00253872f, -0.02207168f, 0.02477971f, 
    -0.01241847f, -0.00694912f, -0.02814989f, -0.02300115f, -0.02834095f, -0.03717059f, 0.02155275f, 0.02684960f, 
    -0.01804031f, -0.00019577f, -0.02936022f, 0.01431271f, 0.02490966f, -0.00241365f, -0.03558470f, -0.02595305f, 
    -0.03264923f, -0.00516555f, -0.03672732f, -0.00060086f, 0.00931548f, -0.02684022f, -0.02100661f, 0.02423372f, 
    0.02575234f, -0.04048710f, -0.03706719f, -0.02931398f, -0.01207426f, 0.01807906f, -0.01557292f, 0.00795753f, 
    -0.02633151f, -0.00542181f, 0.01245075f, -0.01698285f, -0.03041231f, -0.03707191f, -0.01644555f, -0.04002675f, 
    -0.00416064f, -0.03850093f, 0.00642517f, -0.00653384f, -0.04557897f, -0.04343111f, -0.04161436f, -0.00360317f, 
    -0.01774359f, 0.03250415f, 0.00768096f, 0.02412061f, -0.00960232f, -0.03869472f, 0.02595041f, 0.00822069f, 
    -0.01840905f, -0.03553955f, 0.01983457f, 0.00510259f, -0.01741162f, -0.03015496f, 0.01745228f, -0.03340966f, 
    -0.00537756f, -0.00918126f, 0.02696049f, -0.02202554f, 0.00057726f, -0.01845277f, -0.01523262f, -0.00203174f, 
    -0.00562938f, -0.04054761f, -0.04551975f, 0.02922468f, -0.01914644f, 0.01475806f, -0.01795229f, 0.00649275f, 
    -0.01469706f, 0.00555051f, 0.00848921f, -0.02027567f, -0.02184894f, -0.02317596f, -0.02216575f, 0.02433557f, 
    -0.03416874f, 0.00768153f, 0.02096559f, -0.00674937f, 0.02804589f, 0.03012397f, -0.00332135f, 0.01203254f, 
    0.00838671f, 0.03305266f, -0.03070254f, -0.03600768f, -0.04151243f, 0.00903814f, 0.02195586f, -0.04492088f, 
    -0.03749008f, -0.04126645f, 0.01867884f, -0.00143700f, -0.04187847f, 0.00316100f, -0.02430775f, 0.01957991f, 
    -0.02222954f, -0.02984224f, 0.03241822f, -0.02813716f, -0.02923256f, 0.00758540f, -0.02427825f, -0.00381985f, 
    -0.00602486f, -0.04120074f, -0.02005158f, 0.01955183f, 0.00452914f, -0.00493291f, -0.03601636f, 0.00281209f, 
    -0.02096668f, -0.02408176f, -0.01637112f, 0.04019945f, -0.01887350f, -0.02813814f, -0.02025940f, -0.01533011f, 
    -0.04529478f, -0.00295829f, 0.00693470f, 0.03231687f, 0.00993579f, 0.01991104f, -0.01250194f, 0.02091645f, 
    -0.04063671f, -0.00736754f, -0.00573170f, 0.00350565f, -0.00782581f, -0.00916103f, -0.00756224f, -0.03171353f, 
    0.02313994f, -0.04557722f, -0.00170358f, -0.03557996f, -0.03736712f, -0.03028145f, 0.02023659f, 0.01195808f, 
    0.01048672f, 0.01738292f, 0.04077002f, -0.02670486f, -0.02571618f, -0.00790816f, 0.03094950f, 0.00476259f, 
    -0.02024399f, -0.02864197f, -0.03573343f, 0.02254264f, 0.02170322f, 0.02982058f, -0.04501822f, 0.01891346f, 
    -0.03239239f, 0.00893113f, -0.03605368f, -0.02671565f, 0.00671599f, -0.03297823f, -0.04370042f, -0.02921707f, 
    0.02154343f, -0.00121227f, 0.00129381f, 0.03128641f, -0.01719241f, -0.02903308f, -0.03850740f, -0.00693338f, 
    0.02986539f, 0.01606858f, -0.04450429f, -0.02068571f, -0.00787522f, 0.00158392f, -0.03317183f, -0.02748091f, 
    -0.00354732f, -0.01830505f, 0.00637688f, -0.00868734f, -0.03184045f, -0.03969923f, -0.04117642f, -0.01943586f, 
    0.00230558f, 0.00464887f, 0.00246014f, 0.02516990f, 0.02768104f, -0.03490398f, -0.03983532f, 0.01088168f, 
    -0.01876905f, -0.04598998f, 0.02761309f, 0.00739652f, 0.03438476f, 0.00951986f, 0.01977403f, -0.02809929f, 
    -0.00904691f, -0.04194312f, -0.01708978f, -0.02430457f, -0.01721432f, -0.03298246f, 0.02605019f, -0.02044015f, 
    -0.02541101f, -0.03959763f, -0.00533553f, -0.00651480f, -0.01419904f, -0.01212147f, 0.01043983f, 0.00674680f, 
    0.00937854f, 0.00405208f, 0.00681678f, 0.01273279f, -0.00435635f, -0.03278913f, -0.01986240f, -0.04591452f, 
    -0.00398739f, 0.02883125f, -0.00625160f, -0.02655837f, 0.00916870f, -0.02684683f, -0.03609545f, -0.02478236f, 
    -0.03524138f, -0.00030024f, 0.02691654f, 0.03287139f, -0.03731544f, -0.01995848f, 0.03434978f, 0.02920111f, 
    0.00678238f, -0.02283641f, -0.03104502f, -0.03128071f, -0.02663980f, -0.01334056f, 0.00241439f, 0.02067617f, 
    -0.03243483f, -0.01533620f, -0.00592192f, 0.00099781f, 0.02609326f, -0.02848585f, -0.01416853f, 0.00732501f, 
    0.02349425f, 0.02267448f, 0.03340632f, -0.01035652f, -0.02229860f, 0.01789643f, 0.00789780f, -0.04525035f, 
    0.01293852f, -0.00438535f, 0.00570281f, 0.02939047f, -0.04218790f, 0.00592700f, -0.04054257f, 0.01042252f, 
    0.00826232f, 0.01504842f, -0.02473516f, 0.02050657f, -0.02862568f, 0.00551848f, -0.03649753f, -0.01486690f, 
    -0.01730082f, 0.01846690f, 0.00153558f, 0.00127487f, 0.02909146f, -0.04527440f, -0.00110800f, 0.02248547f, 
    0.00615523f, -0.02862996f, -0.04155672f, -0.02877391f, -0.02632185f, -0.01991860f, 0.02551275f, 0.02318572f, 
    -0.00834249f, -0.04138640f, 0.03056131f, 0.00750336f, -0.04725550f, -0.00440405f, 0.01874464f, -0.01355352f, 
    0.00801023f, -0.04398078f, -0.03015730f, -0.02667361f, -0.02803122f, -0.01199623f, 0.01907100f, 0.02841686f, 
    -0.02180419f, -0.03669055f, -0.00870548f, 0.02676769f, -0.04338469f, 0.01632562f, 0.02536032f, -0.02699561f, 
    -0.01321513f, 0.00897097f, -0.00782472f, 0.01528276f, 0.02349428f, -0.02375493f, -0.02514665f, -0.03850657f, 
    -0.03528467f, -0.02904990f, 0.01457017f, 0.00741188f, 0.02709638f, -0.01876362f, -0.01259477f, 0.00613084f, 
    0.02789849f, -0.00770219f, -0.03883116f, -0.00217347f, -0.01564667f, 0.03222684f, -0.00810054f, -0.00950437f, 
    -0.00346691f, 0.00595507f, -0.01260654f, -0.03791100f, -0.00081380f, 0.01215425f, -0.00814897f, 0.01018599f, 
    -0.03497090f, -0.01848855f, -0.02571757f, -0.01178365f, -0.00644059f, 0.01132342f, -0.04520655f, 0.00079113f, 
    -0.01247438f, -0.03751630f, -0.03786025f, -0.01677552f, -0.01085541f, 0.02179953f, 0.03187026f, 0.00124212f, 
    -0.04610420f, 0.01346387f, 0.01082857f, -0.03070687f, -0.02530459f, 0.00267117f, -0.02951118f, -0.03924700f, 
    0.03792638f, 0.01052990f, -0.04275963f, 0.01745999f, 0.01087638f, -0.02660417f, -0.02594255f, 0.02408460f, 
    -0.04382700f, -0.04404683f, 0.00681329f, -0.00796590f, 0.02001245f, -0.03140918f, 0.00739715f, -0.03934365f, 
    0.01918977f, 0.00619328f, 0.00478728f, -0.00472435f, -0.01537213f, -0.03134904f, 0.01482556f, -0.01914552f, 
    0.03104812f, 0.00212172f, 0.00788591f, 0.03192418f, -0.02377532f, -0.00165672f, -0.00586535f, -0.04016580f, 
    0.00948208f, 0.00678502f, 0.03030517f, 0.02535411f, -0.02633522f, 0.00590727f, 0.02042348f, 0.00241431f, 
    -0.00643166f, 0.02288070f, -0.00313436f, 0.02180890f, 0.02294334f, 0.01301212f, -0.01741511f, 0.01725115f, 
    0.03223152f, 0.02214076f, 0.01832692f, 0.01083037f, -0.03775639f, 0.01882524f, 0.01184580f, -0.04253950f, 
    -0.02231956f, 0.01156894f, -0.02436462f, -0.00868333f, -0.03550512f, 0.01735335f, 0.00425329f, 0.01442756f, 
    -0.01175153f, -0.02379666f, 0.00890688f, -0.01261854f, -0.02087763f, 0.02577276f, 0.02751499f, -0.00160930f, 
    -0.02349522f, -0.03096051f, -0.03651394f, 0.01302292f, 0.02110925f, 0.02710034f, 0.02473018f, 0.00729036f, 
    -0.03948620f, -0.02699940f, -0.02278618f, -0.03788589f, -0.02227835f, -0.00044853f, 0.01735307f, -0.02042951f, 
    -0.03512961f, 0.00342533f, -0.00551349f, 0.01639960f, 0.02397034f, 0.02778265f, -0.01039753f, 0.01060652f, 
    -0.04502426f, -0.03053750f, 0.01152342f, -0.01614533f, 0.02335018f, 0.02785910f, -0.04259090f, 0.00963932f, 
    -0.00140954f, -0.01394209f, -0.00667479f, -0.02580254f, -0.02047833f, 0.01453308f, -0.00955501f, -0.02817550f, 
    0.00237677f, -0.00873884f, 0.02604215f, -0.03867726f, -0.01375832f, -0.01162561f, -0.02423404f, -0.01142089f, 
    -0.01550274f, -0.03968276f, -0.01999061f, -0.02658158f, -0.00546853f, -0.03899468f, 0.00693127f, 0.02804753f, 
    -0.03907426f, 0.01186118f, 0.00460642f, -0.01730517f, -0.04425610f, 0.04071335f, 0.01531073f, -0.00403578f, 
    -0.03018599f, 0.01041055f, -0.02179278f, -0.01965909f, -0.02301001f, -0.02534485f, 0.02443798f, 0.01893990f, 
    0.00575311f, 0.02491822f, -0.03116065f, -0.03173055f, 0.01939463f, 0.02765016f, -0.01349093f, -0.04574927f, 
    -0.02943787f, 0.00885835f, -0.01632182f, -0.02944765f, 0.02018403f, 0.01707062f, 0.02892049f, -0.01488349f, 
    -0.01467418f, -0.00999016f, 0.02922606f, 0.02431234f, 0.00728552f, 0.00405306f, 0.02388758f, 0.01415341f, 
    0.02568497f, -0.02774071f, -0.04016896f, -0.00603034f, -0.00886636f, 0.02804380f, 0.00526879f, -0.03563890f, 
    0.01703711f, -0.02124008f, 0.01887452f, -0.04142797f, -0.01320686f, -0.02582582f, 0.00008988f, 0.01340298f, 
    -0.00838327f, -0.03071560f, 0.02247840f, 0.01384834f, 0.01384072f, -0.01979407f, -0.02289360f, -0.02693451f, 
    -0.00014012f, -0.04494540f, -0.03003294f, 0.02532027f, -0.03503046f, 0.02323162f, -0.00193052f, 0.01125581f, 
    -0.13433771f, 0.16750243f, -0.16770327f, -0.15843754f, 0.01648930f, 0.07342122f, -0.35826024f, 0.00303172f, 
    -0.19911717f, 0.14469934f, 0.11721899f, 0.13159975f, 0.05042776f, 0.05254227f, -0.01163296f, 0.02581428f, 
    0.05349854f, 0.08642861f, 0.11312540f, 0.01379495f, 0.34166977f, 0.12879238f, 0.01169722f, 0.28883833f, 
    -0.14178702f, -0.37552723f, -0.32114911f, -0.11459409f, -0.31311902f, -0.14704622f, 0.07954717f, 0.01301850f, 
    -0.01488974f, -0.05722193f, 0.01689420f, 0.01445489f, -0.00007267f, 0.11670734f, 0.15223956f, 0.25038177f, 
    0.08855897f, -0.24303232f, 0.37542623f, 0.24783634f, -0.05681213f, 0.10824931f, 0.17520730f, 0.03574268f, 
    -0.01732236f, -0.11215820f, 0.10133050f, -0.12505268f, -0.01007984f, -0.00912110f, 0.05619619f, 0.02940558f, 
    0.01330533f, 0.06085835f, 0.10041942f, 0.06313841f, -0.20984523f, -0.33384702f, 0.46188861f, 0.11102708f, 
    -0.15250039f, 0.02033539f, 0.10044623f, -0.11995124f, -0.13157929f, 0.07519992f, 0.07747690f, -0.05563678f, 
    -0.02447466f, -0.06723971f, 0.00551409f, 0.03353309f, 0.06085492f, -0.09892381f, 0.08568063f, -0.03867935f, 
    -0.14576030f, 0.12430561f, -0.11028207f, -0.26850539f, 0.18441111f, 0.08373976f, -0.30892831f, 0.14761403f, 
    -0.04287069f, 0.15762076f, 0.06801465f, 0.14461383f, 0.11750493f, 0.12785232f, 0.04461300f, 0.13286629f, 
    0.18413135f, 0.11837142f, 0.00156058f, 0.13481902f, 0.42808127f, -0.14464439f, 0.18271899f, 0.06522660f, 
    -0.17870477f, 0.08599001f, 0.13977017f, -0.05969182f, 0.07380226f, 0.02684478f, 0.06321276f, 0.04477112f, 
    0.03743161f, 0.03089856f, 0.01660968f, 0.04625489f, 0.01196227f, -0.03336806f, 0.04384887f, -0.05687966f, 
    0.30531901f, -0.11662435f, 0.40754429f, -0.38617212f, 0.05724587f, 0.01108814f, -0.12894210f, 0.00528987f, 
    0.12367678f, -0.02370660f, -0.06330067f, 0.01962136f, 0.06764314f, -0.05280768f, -0.18102524f, 0.14131124f, 
    -0.09488260f, -0.05011368f, -0.19371186f, 0.05987699f, -0.32738051f, 0.14470303f, 0.27978042f, -0.18251397f, 
    -0.19847532f, -0.13476147f, -0.31272095f, -0.13383323f, -0.14356722f, -0.06891187f, 0.14282662f, 0.07055942f, 
    0.06181206f, -0.09170493f, 0.10359336f, 0.06041770f, -0.00216413f, 0.18459707f, 0.07699727f, -0.12560946f, 
    -0.04219520f, -0.27657157f, -0.07403883f, -0.14553028f, 0.30217376f, 0.19303192f, 0.06898639f, -0.01882014f, 
    -0.12209164f, -0.08294187f, 0.11908430f, -0.22755629f, -0.22047682f, 0.12445105f, -0.04669384f, 0.07477438f, 
    0.13027352f, 0.02896875f, 0.11153337f, 0.20024963f, -0.10452657f, -0.08765753f, 0.06993005f, 0.06056305f, 
    0.02973101f, 0.04845852f, -0.33884013f, 0.00268398f, -0.07826906f, -0.08304013f, 0.14205311f, -0.02120259f, 
    -0.01398780f, 0.16223089f, 0.11750291f, 0.00232813f, -0.01095444f, 0.00514750f, -0.02324134f, -0.19362523f, 
    0.03801783f, -0.06594124f, 0.19847792f, 0.16328095f, -0.08622269f, 0.12172859f, 0.23149779f, -0.10645419f, 
    0.04824633f, -0.15395436f, -0.00141280f, 0.09344374f, 0.06651494f, -0.00995871f, -0.02787768f, -0.04452393f, 
    0.08935307f, -0.13377924f, 0.03215000f, -0.02206857f, 0.09160968f, 0.12338397f, -0.15165392f, 0.35758156f, 
    -0.23787574f, -0.35311505f, -0.32467994f, 0.03958048f, -0.31690529f, 0.20513612f, -0.07765769f, 0.04556897f, 
    -0.09980108f, 0.07410844f, -0.03140599f, 0.07592712f, 0.03983541f, 0.29708171f, -0.01220344f, 0.19761586f, 
    0.52419364f, 0.07556596f, 0.07021412f, 0.15312433f, 0.01734404f, -0.13347016f, -0.24319370f, -0.09683186f, 
    0.06869695f, -0.06161901f, 0.20566991f, -0.01646817f, 0.08406885f, 0.00524129f, 0.03496145f, -0.11468177f, 
    -0.12660001f, 0.02768151f, -0.18150462f, 0.01296691f, -0.30354950f, -0.26247504f, 0.27542505f, 0.03630999f, 
    -0.03779954f, -0.02367474f, -0.10033521f, -0.13769515f, 0.09664260f, -0.11039091f, -0.08644309f, 0.05653781f, 
    -0.09373087f, -0.02325748f, 0.02901771f, -0.02485008f, 0.11312571f, -0.03431151f, -0.08161290f, 0.04908660f, 
    0.01749815f, 0.16213641f, -0.18191417f, -0.04037520f, 0.12582371f, -0.14323662f, -0.10754702f, 0.01294727f, 
    0.16534857f, -0.20972316f, -0.13617349f, -0.15929060f, 0.06897648f, -0.04748457f, -0.11459429f, 0.16240875f, 
    -0.21327202f, -0.25774103f, -0.07641868f, 0.05361933f, 0.10954885f, -0.02637210f, 0.27676937f, 0.11379530f, 
    -0.02281350f, 0.13511840f, 0.19164191f, 0.05357620f, -0.04961515f, -0.00087034f, -0.04775697f, 0.00635433f, 
    -0.02624536f, -0.02775777f, 0.03879760f, -0.00796597f, 0.07389677f, -0.05353926f, 0.03822828f, -0.03594425f, 
    -0.30312645f, 0.17516786f, -0.13384736f, -0.04784914f, -0.02924735f, -0.00825302f, -0.01182120f, 0.11466683f, 
    0.08624493f, 0.11903993f, 0.05630440f, -0.02854683f, -0.04775123f, 0.06058304f, 0.05154436f, -0.15430005f, 
    0.00893399f, 0.06290204f, 0.05357033f, 0.07640584f, 0.34833178f, -0.31979918f, 0.60408813f, -0.57055491f, 
    0.38884488f, -0.15260528f, -0.05730813f, 0.27816477f, -0.09063357f, -0.03705876f, 0.15940274f, 0.13290268f, 
    0.14001568f, -0.04492819f, 0.05367044f, -0.05632488f, -0.07199987f, 0.02781234f, 0.08411165f, -0.09900877f, 
    -0.27539435f, -0.16882935f, 0.08967068f, 0.03138872f, 0.06496608f, 0.26476464f, 0.02626518f, 0.05942067f, 
    0.13613583f, 0.08249020f, 0.02961933f, -0.03424374f, -0.08764826f, 0.08530709f, -0.06516878f, 0.04344475f, 
    0.16036282f, -0.05347518f, -0.04032492f, -0.01557819f, -0.22418351f, -0.50118709f, 0.51073158f, 0.02280777f, 
    -0.12557976f, 0.05940638f, 0.04994234f, -0.14526902f, 0.24057443f, -0.04135792f, 0.09763414f, -0.05783411f, 
    -0.00108977f, 0.05235745f, -0.06598692f, 0.10330965f, 0.03097840f, 0.06455282f, 0.00769596f, 0.04146323f, 
    0.14061394f, -0.15897439f, 0.53302145f, -0.19908279f, 0.25361377f, -0.25135186f, -0.12630306f, 0.08689938f, 
    0.06629334f, 0.01612572f, 0.06494245f, 0.06172135f, -0.00958264f, -0.03526909f, 0.05764380f, -0.17714740f, 
    -0.03118954f, 0.18523800f, 0.14276707f, -0.16557841f, 0.27797329f, -0.11991746f, -0.29546657f, 0.22606212f, 
    -0.03950137f, 0.15574747f, -0.06640808f, 0.07762408f, -0.18431646f, 0.17779158f, -0.00493786f, 0.10240215f, 
    0.00933698f, -0.00213513f, -0.01429671f, -0.12363224f, -0.09666289f, 0.06680571f, -0.06976643f, 0.35346350f, 
    -0.33866164f, -0.18878318f, 0.03783363f, 0.23926024f, 0.05102898f, 0.03544695f, 0.09191754f, -0.00102387f, 
    0.07163537f, -0.04100256f, 0.08485958f, -0.07844626f, -0.10078783f, 0.10423615f, -0.03828015f, -0.05889410f, 
    0.04363797f, -0.00636553f, 0.08402249f, -0.03053634f, -0.13684376f, 0.01727306f, 0.04683850f, -0.24016699f, 
    0.02020200f, -0.00338514f, -0.09719616f, -0.10088082f, -0.10127701f, 0.01493929f, -0.04472888f, 0.07928411f, 
    0.03366015f, -0.20162807f, -0.19951235f, 0.10271657f, -0.05383291f, -0.16439128f, -0.15030573f, -0.03175186f, 
    0.14193842f, -0.04833505f, -0.00353565f, -0.23574214f, 0.07771710f, -0.04280837f, -0.11595838f, -0.08613311f, 
    -0.14595564f, -0.07744007f, 0.13966948f, -0.03120200f, -0.13499247f, 0.05910279f, 0.07993861f, 0.00735621f, 
    0.03026875f, 0.07760907f, 0.05521842f, -0.07626987f, 0.09673796f, 0.15026607f, 0.28554228f, 0.39979497f, 
    -0.07566221f, 0.15156350f, 0.27852330f, 0.05245024f, 0.02238710f, 0.23146266f, 0.12196414f, 0.05692677f, 
    0.03449957f, -0.06701915f, -0.11491515f, -0.04176360f, 0.18225613f, 0.11014584f, 0.03761772f, 0.03834496f, 
    0.14067633f, 0.07506221f, -0.34784895f, -0.29590005f, 0.14961667f, 0.09276233f, -0.17907824f, 0.05601022f, 
    -0.10873706f, 0.00743499f, 0.17195390f, 0.01858697f, 0.08762528f, -0.08777826f, -0.08699162f, 0.15857407f, 
    0.00535051f, 0.06397733f, -0.03849776f, -0.10922552f, 0.10306855f, 0.33333513f, 0.00367807f, 0.29766965f, 
    -0.18274079f, 0.04559827f, 0.07200944f, -0.08205677f, 0.03900494f, 0.04463093f, -0.03197521f, 0.05896189f, 
    -0.02009609f, -0.04254181f, -0.00411818f, -0.02491192f, -0.04753446f, 0.11506206f, 0.00862263f, 0.09974212f, 
    -0.26576254f, 0.29455870f, -0.04773223f, 0.15131061f, 0.09068724f, -0.11880385f, 0.05436800f, -0.06056264f, 
    -0.12750211f, 0.03876923f, -0.14163730f, -0.28737554f, -0.13121620f, 0.00371599f, -0.02020530f, -0.14925502f, 
    -0.01672962f, 0.03481380f, 0.06451416f, 0.04646939f, -0.04880835f, 0.28547844f, -0.19224890f, 0.19770762f, 
    0.15680955f, 0.07945119f, 0.08852080f, 0.01182708f, 0.03127066f, 0.20718803f, 0.09045720f, -0.17551170f, 
    -0.08805265f, -0.08577644f, -0.02008302f, -0.09316528f, 0.04148423f, 0.14613593f, -0.04915721f, -0.03284360f, 
    0.18880439f, 0.34534872f, -0.46752214f, 0.30216274f, -0.40748599f, 0.07206596f, -0.16687815f, 0.01334251f, 
    -0.10224091f, -0.04705776f, 0.08397753f, -0.07368969f, 0.03877959f, 0.09214731f, 0.02108314f, 0.15023150f, 
    -0.19336236f, 0.17077263f, -0.03592309f, 0.08994102f, -0.17244761f, -0.16458066f, 0.73979914f, -0.29416665f, 
    0.05348913f, 0.19419549f, -0.13671231f, -0.14326262f, 0.12100890f, -0.06553160f, 0.01260577f, 0.07929794f, 
    0.14579666f, 0.07956356f, -0.01283821f, -0.06347222f, 0.00172799f, -0.06619790f, 0.01730744f, -0.00797949f, 
    -0.03319977f, 0.03100188f, -0.03135791f, 0.00412597f, -0.03400536f, 0.02912993f, -0.03674750f, -0.01314292f, 
    -0.02178804f, -0.03716546f, 0.00633499f, 0.00768817f, 0.03096911f, 0.01221776f, 0.01081042f, 0.00795263f, 
    -0.01585906f, 0.01596376f, -0.02050550f, -0.02636124f, -0.04124191f, 0.02129917f, 0.01467278f, -0.00204821f, 
    0.03504962f, 0.03385675f, 0.00801499f, 0.02894836f, 0.00663887f, -0.01057786f, 0.03215819f, -0.00839802f, 
    -0.00337591f, 0.02907994f, 0.03480478f, 0.02720578f, -0.00816719f, 0.01044037f, -0.00984461f, -0.00000341f, 
    0.02438275f, 0.02360552f, -0.03323426f, 0.01657876f, 0.00194104f, -0.03515695f, -0.02768818f, 0.01223465f, 
    -0.02526764f, 0.00320896f, 0.02067312f, -0.02587389f, -0.01990173f, -0.00540147f, -0.04234418f, -0.03920731f, 
    -0.01964765f, 0.00912479f, -0.01604367f, -0.01119493f, 0.00446413f, 0.02186467f, 0.00894940f, -0.03560429f, 
    -0.01301642f, -0.03617309f, 0.01483214f, -0.00060834f, 0.04233787f, 0.03233857f, -0.01045698f, 0.02745178f, 
    0.01989824f, -0.00244773f, 0.01951165f, 0.03205580f, 0.03868468f, -0.02874954f, -0.01095968f, -0.02189927f, 
    0.00186066f, 0.01117796f, 0.01822036f, -0.02520973f, -0.00745631f, 0.01532081f, 0.01836923f, 0.01071314f, 
    -0.01836688f, -0.00467227f, 0.00196980f, -0.02413697f, -0.01419977f, -0.01707864f, 0.02170910f, 0.03387572f, 
    0.00864138f, 0.03041264f, 0.01946018f, 0.03145699f, 0.02261761f, 0.01461760f, 0.00069749f, -0.04229693f, 
    0.00884790f, 0.02751807f, -0.03494124f, 0.00140643f, -0.01569899f, 0.01096895f, 0.01917743f, -0.00688973f, 
    -0.01317499f, -0.00682564f, -0.01134644f, 0.01210119f, 0.03350561f, -0.03759814f, -0.01768477f, -0.03313895f, 
    0.00537069f, -0.03666389f, 0.02136220f, -0.02522769f, -0.02423968f, -0.01323245f, 0.00371841f, 0.01404102f, 
    -0.03417182f, 0.01472769f, 0.02212339f, -0.01459388f, 0.02825263f, 0.01803516f, -0.02283819f, 0.00876541f, 
    0.01421270f, 0.02503366f, -0.02645865f, -0.01330791f, 0.02490591f, -0.00906069f, -0.00546864f, 0.01660723f, 
    -0.01186439f, -0.01626511f, -0.00761854f, -0.00459953f, -0.01171430f, -0.02812518f, 0.02018052f, -0.01858124f, 
    0.00570425f, 0.01548379f, -0.00264365f, -0.01078704f, -0.02855559f, -0.04045088f, 0.01647641f, 0.00699569f, 
    0.02485791f, -0.01235845f, -0.02255872f, 0.01813437f, 0.03422423f, -0.01656544f, 0.03542057f, -0.00049461f, 
    -0.04280566f, 0.00850152f, 0.02358328f, 0.02640108f, 0.00988686f, 0.02756469f, -0.02152311f, 0.02063839f, 
    0.01135260f, 0.01615423f, -0.02773133f, -0.03554259f, -0.03449403f, 0.02405680f, -0.04402659f, -0.04492643f, 
    -0.02769572f, 0.00458430f, -0.03453626f, -0.01795580f, -0.04055693f, 0.01529218f, 0.01786714f, 0.01260947f, 
    -0.02405929f, 0.03176120f, 0.00200595f, -0.01095910f, -0.04365538f, 0.00002395f, -0.00678185f, -0.00077313f, 
    0.01795929f, 0.00579593f, 0.00092614f, -0.02777885f, 0.02672575f, -0.02945117f, -0.03025168f, 0.02618743f, 
    -0.02351211f, 0.02507569f, -0.03600194f, -0.00216693f, -0.03180810f, -0.01885451f, 0.01509710f, 0.03290362f, 
    -0.03740562f, 0.02316546f, -0.02548680f, -0.00925292f, 0.01428314f, -0.01672172f, -0.04229617f, 0.02873395f, 
    -0.02186305f, 0.02304660f, 0.02949662f, 0.01992144f, -0.03430918f, 0.01716997f, -0.01117681f, -0.00390041f, 
    0.03217818f, 0.02221370f, -0.02690459f, 0.02578931f, 0.02424996f, -0.00517792f, -0.00963532f, 0.00937885f, 
    -0.02903646f, 0.00467501f, -0.04057601f, -0.02244137f, -0.00575088f, 0.02688892f, 0.02604915f, -0.04065899f, 
    -0.03762552f, -0.01898909f, -0.00720649f, 0.00745689f, 0.01398325f, 0.01108735f, -0.04399481f, -0.00999170f, 
    0.02758319f, -0.02729610f, -0.00840786f, 0.02574621f, -0.03681418f, -0.00634578f, 0.01330914f, -0.02867413f, 
    -0.03527552f, 0.00206119f, -0.04259033f, -0.02548480f, -0.02240024f, -0.01849943f, -0.02748528f, -0.00148209f, 
    -0.00469311f, -0.01853031f, 0.01041159f, 0.02976071f, 0.01604090f, -0.03413538f, -0.03344508f, -0.01137577f, 
    -0.03707042f, -0.03270846f, -0.04413861f, 0.00176689f, -0.01264697f, 0.03653323f, 0.00490611f, -0.01784107f, 
    -0.00325193f, -0.02674827f, -0.01667167f, -0.01557435f, -0.01306844f, 0.01149820f, -0.00291793f, 0.03551519f, 
    -0.02373933f, -0.03789527f, 0.03257417f, 0.02023597f, -0.01594434f, 0.01860455f, 0.01692945f, 0.02045305f, 
    -0.01042225f, -0.03087456f, -0.02699135f, -0.01915201f, 0.02203654f, -0.00721991f, 0.02232070f, -0.03589919f, 
    -0.01359381f, 0.02313890f, -0.03895632f, 0.02473011f, -0.01500269f, -0.03362615f, -0.03977792f, 0.01131132f, 
    -0.00845400f, -0.03874715f, -0.02463386f, 0.02797996f, -0.03858142f, 0.02982591f, -0.01192477f, -0.00582365f, 
    0.02982519f, -0.02960606f, -0.02609164f, -0.02213909f, 0.03721989f, 0.02448480f, -0.01389069f, -0.03251575f, 
    0.01298546f, -0.03855423f, 0.00997077f, -0.00202036f, 0.01041286f, 0.02071751f, -0.03804191f, 0.02104178f, 
    -0.03910293f, 0.02199852f, 0.02707882f, -0.02606830f, -0.00188451f, -0.01010329f, 0.02877036f, 0.01493115f, 
    -0.03567867f, -0.01398723f, -0.00944765f, 0.01037577f, 0.01074124f, 0.02634861f, 0.00113453f, -0.02665365f, 
    -0.01402935f, 0.00156829f, -0.03421651f, -0.02244999f, 0.03109564f, -0.02464583f, -0.04246138f, 0.01344419f, 
    0.00880614f, 0.00464533f, -0.02296441f, -0.03744306f, 0.02927773f, 0.02032753f, 0.02622796f, -0.04197532f, 
    -0.01679948f, -0.00834941f, 0.00576638f, 0.03204998f, 0.01818012f, -0.03008334f, 0.02742053f, 0.02654533f, 
    -0.00688518f, 0.01269380f, -0.01997129f, -0.02878954f, -0.01669037f, -0.01151572f, -0.02577357f, -0.00360052f, 
    0.01278321f, -0.00036446f, 0.01855951f, -0.03932366f, 0.00228708f, -0.03645336f, -0.02856351f, -0.02841072f, 
    0.03432046f, -0.01487658f, -0.02909472f, -0.00352207f, 0.03363947f, -0.01449539f, 0.01375366f, 0.01214106f, 
    0.03011946f, -0.04764913f, 0.03132055f, -0.02121947f, -0.02509711f, -0.03820005f, -0.02945100f, 0.00940523f, 
    -0.01414811f, -0.01980625f, -0.03604431f, -0.03328541f, 0.01568091f, -0.03459515f, -0.00989923f, -0.02277395f, 
    0.01057269f, 0.02086260f, 0.01813070f, -0.02448705f, -0.03096654f, -0.03613608f, -0.04414023f, -0.03538148f, 
    0.02486761f, -0.03828241f, -0.03654754f, -0.04150928f, -0.01311677f, 0.03020548f, -0.00627463f, -0.03354737f, 
    -0.01208443f, -0.02405208f, -0.03696573f, -0.02028590f, -0.03485834f, 0.00849298f, 0.00675236f, -0.01163954f, 
    -0.02337905f, -0.00116149f, 0.00497299f, 0.00055167f, 0.00656010f, -0.02887930f, -0.02145461f, 0.00011157f, 
    -0.00174364f, 0.02556523f, -0.02834412f, 0.01583256f, -0.02291412f, 0.00513980f, -0.04513760f, -0.01941204f, 
    -0.02702806f, 0.00982899f, -0.02766736f, 0.02295782f, -0.00021017f, 0.02599440f, 0.01080757f, -0.02514933f, 
    -0.04255448f, 0.02269783f, -0.02217178f, 0.03230274f, 0.03624174f, -0.01373152f, -0.02439459f, -0.01174766f, 
    -0.02684336f, 0.01865404f, 0.01967762f, 0.00941093f, -0.01934280f, 0.00356945f, 0.02046418f, 0.02399451f, 
    0.01691312f, -0.02009716f, 0.01764579f, 0.00544798f, -0.03776954f, -0.00929285f, -0.01283720f, 0.02967346f, 
    0.03320009f, 0.01732472f, -0.01708686f, 0.01687528f, -0.00030026f, -0.02528416f, -0.00056227f, -0.02774054f, 
    -0.03264153f, -0.03670260f, -0.01555220f, -0.02889343f, -0.02245105f, -0.00173927f, -0.01474198f, -0.00210823f, 
    -0.03487305f, -0.03729143f, 0.01731923f, 0.03893261f, 0.03873006f, 0.00004342f, 0.02252480f, -0.00279872f, 
    -0.00817614f, -0.03290252f, 0.02663451f, -0.00645390f, 0.00265342f, -0.00222380f, 0.01827524f, 0.01456511f, 
    -0.03441467f, 0.03208953f, -0.00958975f, -0.00729327f, 0.01829847f, -0.04002226f, -0.02151990f, -0.03401599f, 
    0.01234142f, -0.03999409f, 0.00728969f, -0.01613777f, -0.02102106f, 0.02716400f, 0.01982140f, -0.00808557f, 
    -0.03826703f, 0.01063459f, -0.02383669f, -0.03854034f, -0.04435772f, -0.01440913f, -0.00937727f, -0.01432571f, 
    -0.01478511f, 0.01905165f, 0.02949422f, 0.02588136f, 0.02323880f, 0.01047308f, -0.04128573f, -0.00968142f, 
    0.02835062f, -0.00439082f, -0.02306251f, -0.00961996f, 0.02465338f, -0.02954026f, 0.00524617f, 0.01256014f, 
    -0.00825506f, -0.03504199f, -0.04576936f, -0.02905724f, 0.03283550f, -0.03690253f, -0.02353024f, 0.01357729f, 
    -0.02445897f, 0.01887354f, -0.02878720f, 0.03277123f, -0.01447867f, -0.03287065f, 0.02238426f, 0.03792017f, 
    -0.00075092f, -0.00616793f, 0.02420679f, 0.00948051f, 0.01637951f, -0.00630198f, -0.02461038f, 0.00519479f, 
    -0.04312738f, -0.03981744f, -0.03934485f, -0.03963665f, 0.02683403f, -0.01745116f, -0.04019617f, -0.03884202f, 
    -0.02558529f, 0.02433703f, -0.00752066f, -0.01691232f, -0.04075919f, 0.03636648f, -0.03077981f, -0.03073091f, 
    0.02849714f, 0.00741479f, 0.02360852f, 0.01203003f, -0.02493198f, -0.02660089f, -0.02776180f, -0.03224943f, 
    -0.00449899f, -0.04182827f, -0.02433744f, -0.00125758f, 0.03368488f, -0.00561686f, -0.03649260f, 0.00250578f, 
    -0.00278386f, -0.01892622f, 0.03403444f, -0.01565913f, 0.03241801f, 0.02761090f, 0.00566813f, 0.01904028f, 
    0.02600882f, 0.00641659f, 0.02315431f, -0.03992423f, 0.01142507f, -0.02864819f, 0.01965784f, 0.00202952f, 
    0.00265198f, 0.03685966f, 0.04802649f, -0.12735474f, 0.22289848f, -0.07921202f, -0.00380589f, -0.07384591f, 
    -0.00973583f, 0.01783249f, 0.17808640f, 0.00394840f, 0.13667716f, -0.04088352f, 0.04040887f, -0.11970700f, 
    0.10528022f, -0.07156696f, 0.11706000f, -0.12766606f, -0.16669123f, 0.09196585f, 0.18003257f, -0.03115194f, 
    -0.05400511f, -0.10218757f, -0.12136517f, -0.13796212f, -0.07971843f, -0.03614627f, -0.08229967f, -0.07577156f, 
    -0.00864451f, 0.09119406f, 0.12760817f, -0.05016718f, -0.22693561f, -0.10256188f, 0.12911250f, -0.10344888f, 
    -0.17036273f, -0.29541022f, 0.08483176f, -0.09573623f, -0.10931635f, 0.13960119f, 0.04297268f, -0.03107845f, 
    -0.04502752f, -0.04183023f, -0.01130595f, -0.13044548f, -0.02725049f, -0.10532606f, -0.11390406f, -0.00348535f, 
    -0.01756615f, -0.01350239f, 0.10271438f, 0.09045851f, 0.01315156f, -0.35913351f, -0.00624222f, 0.00056115f, 
    0.18985735f, 0.04060273f, 0.04186182f, 0.08593698f, -0.05827672f, -0.20836881f, -0.00386870f, -0.03889310f, 
    -0.03514552f, -0.06425074f, 0.02997799f, -0.07776790f, 0.00269163f, 0.15604202f, 0.14712882f, 0.08553862f, 
    0.05589510f, 0.14396030f, 0.08093557f, -0.19415046f, 0.24865438f, -0.01955125f, 0.06875541f, -0.13563471f, 
    -0.01752648f, 0.05738793f, 0.19745257f, 0.15366797f, 0.09438032f, -0.01139546f, 0.02556634f, 0.14497976f, 
    0.11291055f, -0.04614889f, 0.14009255f, 0.14933947f, -0.15807436f, -0.63280821f, 0.21966484f, 0.26036957f, 
    -0.07931780f, 0.08226940f, 0.13882919f, 0.04601953f, -0.05213677f, 0.00319452f, 0.08376785f, 0.04090775f, 
    -0.00125461f, -0.00434154f, 0.01931712f, -0.06576768f, 0.06253982f, 0.01721710f, 0.13471322f, 0.03653745f, 
    -0.06699578f, 0.06733870f, 0.23726316f, 0.07930808f, 0.09358443f, -0.05129058f, 0.15220918f, -0.01405132f, 
    0.18230294f, 0.02621204f, -0.11960450f, 0.06302707f, -0.19097234f, -0.08397779f, -0.20676987f, -0.11962967f, 
    0.03024805f, 0.10549988f, -0.09809634f, 0.08795899f, -0.60102266f, 0.05292339f, 0.20429644f, 0.03350559f, 
    0.23212340f, -0.05279061f, -0.13330340f, -0.07225700f, -0.05016181f, -0.12083654f, -0.00915692f, 0.12285208f, 
    0.21526368f, 0.07981953f, 0.04297075f, -0.12416256f, -0.13865569f, 0.04641456f, -0.07755185f, -0.06790756f, 
    0.79526472f, 0.02883386f, -0.06049628f, 0.22744307f, -0.15146443f, 0.20223247f, -0.10547936f, 0.20856823f, 
    -0.04457497f, 0.04881081f, -0.03592006f, -0.04599990f, -0.13157810f, 0.04974401f, 0.15551217f, -0.05925715f, 
    0.10669474f, 0.10031783f, -0.03425296f, 0.00650599f, 0.16642432f, -0.00755307f, 0.04283335f, -0.02329465f, 
    -0.07168370f, 0.02018895f, -0.03287435f, -0.02805807f, -0.04054065f, -0.02396617f, 0.04324742f, 0.04063181f, 
    -0.00636847f, 0.01353586f, 0.01933460f, -0.01639929f, -0.12164292f, 0.04026947f, -0.02415832f, -0.13618749f, 
    -0.06455352f, -0.31816068f, -0.11318554f, 0.03340147f, 0.04456715f, 0.07619771f, -0.03559467f, 0.06382800f, 
    -0.11786526f, -0.04424352f, 0.08918047f, -0.06616407f, -0.05070945f, -0.05767199f, -0.04417512f, -0.03861339f, 
    -0.00991119f, -0.01599837f, 0.00895816f, 0.01450347f, -0.24626298f, 0.06589859f, 0.24043818f, -0.12988122f, 
    0.06406487f, -0.13348775f, -0.08465258f, -0.07193259f, -0.17714249f, -0.03546444f, -0.12154605f, 0.05317963f, 
    0.09225591f, -0.03271767f, -0.00751765f, -0.01443683f, -0.10263336f, -0.03832594f, 0.11322013f, -0.09387195f, 
    -0.30631578f, -0.01685498f, 0.26594537f, 0.05805749f, -0.11566534f, -0.04861336f, -0.07477332f, -0.15134054f, 
    -0.05251357f, 0.18029337f, 0.09521682f, -0.00277334f, 0.02079978f, -0.00578431f, -0.04299950f, -0.13984719f, 
    -0.05907975f, -0.03163173f, -0.01469054f, -0.02448316f, -0.22406310f, -0.02327386f, -0.20840006f, 0.03818934f, 
    -0.00223780f, -0.08755691f, -0.01045173f, 0.05048009f, -0.00186265f, -0.01387381f, -0.08648677f, -0.08426512f, 
    0.03593569f, 0.07700665f, 0.04647274f, 0.07377890f, 0.06513762f, 0.09000900f, 0.11392225f, -0.06514286f, 
    0.25134933f, 0.14680713f, 0.32939008f, -0.11757464f, 0.21848376f, 0.04387509f, 0.02137817f, 0.14830866f, 
    0.00803040f, -0.10013279f, 0.03483321f, -0.11541013f, 0.02363332f, 0.03704608f, 0.01529718f, 0.00416659f, 
    0.06464128f, 0.06078947f, -0.10151327f, -0.07589804f, -0.19055428f, -0.27068633f, 0.12852485f, 0.01066097f, 
    -0.08012391f, 0.04960960f, 0.09881680f, 0.14759004f, -0.03093222f, -0.10586999f, -0.06609868f, -0.13153806f, 
    -0.12032402f, -0.14086457f, -0.06317133f, -0.03305954f, 0.01418639f, 0.04479346f, -0.00017483f, -0.10977808f, 
    -0.11306222f, 0.13785836f, -0.15166613f, -0.00674165f, 0.25842974f, -0.04604993f, 0.10681725f, -0.09267701f, 
    0.14849246f, 0.00758283f, -0.17161274f, -0.07369033f, 0.08295336f, 0.12313755f, 0.03756582f, -0.15910468f, 
    0.00570938f, 0.04505193f, 0.08531288f, 0.02627645f, -0.29135332f, 0.14018084f, -0.28617203f, 0.11009950f, 
    0.13072947f, -0.01144930f, 0.13434047f, -0.12279482f, 0.08837460f, 0.28486550f, -0.01845819f, 0.03813136f, 
    -0.09387553f, -0.05176477f, 0.03737602f, 0.12765469f, 0.08128335f, 0.07895479f, -0.06364894f, 0.23174971f, 
    0.34515664f, -0.13905247f, -0.05078943f, 0.15913071f, 0.13930637f, 0.16689041f, 0.13940416f, 0.18728630f, 
    -0.03215811f, 0.01304543f, 0.07791498f, 0.08758032f, -0.08880875f, 0.01699198f, 0.11312564f, -0.06431022f, 
    0.11076519f, 0.16360806f, -0.04637697f, 0.18553841f, -0.41057798f, -0.21787466f, -0.12342992f, 0.07733103f, 
    -0.18078135f, 0.06351729f, -0.00521022f, 0.12644815f, -0.08006717f, 0.17259644f, -0.03821664f, -0.06376737f, 
    -0.05434979f, 0.15647495f, 0.03573229f, 0.07296449f, 0.07874237f, 0.16606987f, 0.15752921f, 0.06913251f, 
    -0.57315379f, 0.15125434f, 0.46696517f, -0.11886009f, 0.04547288f, -0.02791426f, -0.05492973f, -0.18948092f, 
    0.00817134f, 0.21704210f, -0.01856921f, 0.02272878f, 0.12372652f, 0.07275840f, -0.00202774f, -0.20421399f, 
    -0.05240058f, -0.07638772f, -0.04066212f, -0.07715435f, 0.60274369f, 0.09777725f, -0.03547996f, 0.08285660f, 
    -0.01606724f, 0.10297415f, -0.10147966f, 0.15573794f, 0.24385992f, 0.23214306f, 0.06765798f, 0.09523988f, 
    0.01522742f, 0.04964680f, 0.13631578f, 0.03669972f, 0.06284063f, 0.06915865f, 0.08655350f, 0.23158732f, 
    -0.12933853f, -0.12895833f, -0.20558378f, 0.01838037f, -0.09536321f, 0.05178399f, 0.00100656f, 0.05901657f, 
    0.12790887f, 0.12732415f, -0.05516697f, -0.13042498f, 0.09807904f, 0.02732861f, -0.09131887f, -0.07766825f, 
    0.10665751f, 0.08125696f, 0.18903117f, 0.10213367f, 0.34087211f, 0.21943143f, -0.06178414f, -0.03911559f, 
    0.16630119f, 0.01310296f, 0.18021558f, 0.07120171f, -0.02616450f, -0.05404389f, 0.02417412f, 0.01086270f, 
    -0.05324573f, -0.08571753f, -0.14757073f, -0.08557922f, 0.04356180f, 0.11644185f, 0.04842091f, 0.01092953f, 
    0.04461812f, 0.26667958f, 0.09563586f, 0.14558287f, 0.00125750f, 0.03076786f, 0.07110182f, -0.03375350f, 
    -0.02852144f, -0.02086669f, 0.20377779f, 0.16244309f, 0.03555865f, 0.04879064f, 0.11102372f, -0.03235883f, 
    0.01845917f, 0.05190877f, 0.07322343f, -0.12747043f, 0.28741574f, -0.11775795f, -0.12940115f, 0.09562209f, 
    0.32630044f, 0.05001402f, 0.01798458f, 0.12917744f, 0.05611056f, -0.20511265f, 0.10061011f, 0.05387373f, 
    0.09931260f, -0.08384704f, -0.01235426f, 0.06735540f, 0.05476993f, 0.10240461f, 0.11528829f, 0.06097095f, 
    0.79545027f, 0.18916339f, -0.10855113f, 0.08649117f, 0.43690258f, 0.08133060f, 0.03780095f, 0.13732021f, 
    0.15728550f, -0.14172165f, -0.00750705f, 0.09384049f, 0.08161579f, -0.11421511f, 0.02178450f, 0.07219496f, 
    -0.01437711f, 0.03774252f, 0.05587812f, -0.08917435f, 0.19311184f, 0.15090844f, 0.15299694f, 0.14350481f, 
    0.08396372f, -0.07163616f, -0.01570074f, 0.02347908f, -0.01758581f, -0.04901433f, -0.12963842f, 0.04599407f, 
    -0.01283645f, 0.05884103f, 0.08924677f, 0.10305011f, -0.01913303f, -0.10368550f, 0.01299450f, 0.03313103f, 
    0.02662942f, 0.17496391f, 0.29447618f, -0.11131914f, 0.03246827f, -0.06308145f, -0.04485552f, -0.06753025f, 
    -0.00955109f, 0.09158920f, -0.16538157f, 0.02630976f, 0.04583537f, -0.06553490f, -0.08261248f, -0.03339246f, 
    -0.03320860f, -0.09199370f, -0.14813474f, -0.05579606f, 0.32171437f, 0.02020629f, 0.10565341f, 0.05145800f, 
    0.18666494f, 0.04136915f, -0.03094532f, 0.15065262f, 0.03149264f, -0.01058973f, -0.06879383f, 0.02707733f, 
    0.00180903f, -0.06456307f, 0.01948510f, -0.04844936f, 0.01146480f, 0.07697255f, -0.02939886f, -0.04440138f, 
    -0.13997376f, 0.17710957f, 0.00620078f, 0.00502015f, 0.01986169f, -0.06565102f, 0.04424521f, 0.09831618f, 
    0.06050283f, 0.09661307f, 0.15992989f, 0.03686240f, -0.05262792f, 0.01437348f, 0.12719122f, -0.02644460f, 
    0.01777865f, 0.17974754f, 0.10215457f, -0.09112092f, -0.03818350f, -0.32685491f, 0.08360824f, -0.04224130f, 
    -0.06907131f, 0.14867702f, -0.16089755f, 0.03787856f, 0.00866333f, 0.06760146f, -0.02349452f, 0.00242578f, 
    -0.04015737f, 0.06581393f, -0.06299488f, 0.06526075f, 0.07419799f, 0.19550681f, -0.03410013f, 0.09991342f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04709373f, -0.00649626f, -0.01900116f, -0.00868255f, -0.04537051f, -0.05099494f, 0.24129167f, 0.01852760f, 
    0.01852163f, -0.02277525f, 0.00830372f, 0.02538988f, 0.15978873f, 0.00336126f, 0.00254412f, -0.02038908f, 
    0.02581652f, 0.05457558f, 0.00345871f, 0.04549339f, 0.02286473f, -0.00940843f, 0.13350950f, -0.02947833f, 
    -0.01093887f, -0.02644760f, 0.05801797f, 0.05424812f, 0.01719409f, 0.08385160f, 0.01553092f, 0.14555696f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06192286f, 0.10661560f, -0.10464036f, -0.00768523f, -0.06728879f, 0.33684909f, -0.05456569f, -0.11326385f, 
    -0.02010208f, 0.04969781f, -0.16317217f, -0.21975593f, 0.34758705f, 0.02465672f, -0.03900767f, 0.23156263f, 
    -0.09986748f, 0.59149766f, -0.13697812f, 0.10422412f, -0.05875475f, -0.30320224f, 0.24783961f, -0.03100628f, 
    0.07777137f, 0.20985870f, -0.21905327f, 0.26043117f, 0.15216032f, -0.24823354f, 0.05692699f, -0.08075906f, 
    0.00331660f, -0.16092443f, -0.03721166f, 0.15204374f, -0.01756392f, -0.06665909f, -0.12395797f, 0.16537911f, 
    0.04990842f, 0.02309394f, 0.10504267f, 0.01809120f, 0.01219440f, -0.07564449f, 0.00493731f, -0.14812383f, 
    -0.09892032f, -0.10271653f, -0.09042203f, -0.10782614f, -0.16430902f, -0.00361725f, 0.06038840f, 0.06600747f, 
    -0.05912497f, 0.06109618f, -0.15747662f, -0.18662609f, -0.04592793f, -0.15994403f, 0.13294132f, -0.05242223f, 
    -0.01003549f, -0.11389034f, 0.06106460f, 0.07668598f, -0.00685346f, 0.04998908f, -0.22231020f, 0.06791677f, 
    -0.07309814f, 0.07803265f, 0.03829444f, 0.09311739f, -0.40076298f, 0.15084140f, 0.16499154f, 0.05427549f, 
    -0.09831289f, 0.24428102f, -0.02670442f, 0.24772443f, 0.16007338f, 0.59718221f, -0.14097272f, -0.13246535f, 
    -0.23166260f, 0.08423307f, 0.09466758f, -0.06134728f, -0.12984930f, -0.20417891f, 0.02795237f, 0.24276680f, 
    0.00389663f, 0.08416076f, -0.03130071f, 0.08502834f, 0.03851469f, -0.14758202f, 0.17896710f, 0.11400000f, 
    -0.28561279f, -0.13151748f, -0.08685677f, -0.11380737f, -0.07437520f, 0.11652619f, 0.03138606f, -0.00312151f, 
    -0.15265025f, 0.28061178f, -0.06557190f, 0.02151818f, -0.08417550f, 0.34776878f, 0.02703114f, 0.03701704f, 
    -0.05850504f, -0.35753125f, 0.35804227f, 0.12369222f, 0.10514125f, 0.30814505f, 0.13383964f, 0.37436619f, 
    0.13939305f, 0.11304347f, 0.16879915f, 0.15871266f, 0.04037493f, 0.05214727f, 0.12798579f, 0.04822363f, 
    0.19706035f, -0.12269267f, -0.05076296f, 0.41586426f, -0.04306876f, -0.07725932f, -0.12527917f, 0.31884786f, 
    0.08994351f, 0.00348147f, 0.06846725f, -0.06035678f, -0.11913155f, 0.04013335f, -0.11902644f, -0.06550366f, 
    0.13109230f, -0.35988522f, -0.30655318f, -0.03989530f, 0.06181030f, -0.60535342f, -0.14667478f, 0.31223381f, 
    0.04779861f, -0.14703585f, 0.00816474f, 0.08727333f, -0.14034033f, -0.41341656f, 0.27970305f, -0.16826622f, 
    -0.08267288f, -0.02452739f, -0.03157897f, 0.21880229f, 0.05818910f, -0.08694515f, -0.00527452f, 0.04098174f, 
    0.04497927f, 0.19208407f, 0.04984359f, -0.03603428f, -0.00668966f, -0.05164154f, -0.28255543f, -0.00899675f, 
    -0.44135982f, -0.06291070f, -0.14945152f, 0.15608886f, -0.00939306f, 0.07777958f, -0.05441383f, 0.45601317f, 
    0.01767523f, 0.00408342f, 0.08690018f, -0.14913544f, 0.14803499f, 0.32100868f, 0.20495543f, -0.05911333f, 
    0.28196400f, -0.13018636f, 0.12264913f, 0.41973281f, -0.04862814f, 0.12591285f, -0.10258096f, -0.38081467f, 
    -0.06722877f, -0.21112321f, -0.11107196f, -0.20103534f, -0.06609241f, 0.01944124f, 0.03741907f, 0.15813386f, 
    0.08380494f, 0.40558237f, 0.29847616f, -0.05910971f, 0.09156227f, -0.19202644f, 0.04909787f, -0.06857137f, 
    -0.09572167f, 0.00213320f, 0.05739513f, -0.11483503f, -0.09473252f, -0.20292200f, -0.15066834f, -0.00233942f, 
    0.13304026f, 0.17413679f, -0.01032537f, 0.00167409f, 0.02036291f, 0.13299851f, -0.13056192f, -0.08046122f, 
    0.10944556f, 0.02487659f, -0.08896934f, 0.11348011f, -0.12656562f, -0.16851789f, 0.08546364f, -0.15754128f, 
    -0.16647618f, -0.15996023f, -0.19658463f, -0.19347857f, 0.17458589f, 0.04003032f, 0.07812477f, -0.19024353f, 
    0.10683960f, -0.07909278f, 0.16140465f, -0.14703825f, 0.16596444f, -0.22053298f, 0.32314995f, 0.15080613f, 
    0.01275195f, -0.09141239f, -0.02630167f, 0.04180189f, -0.18532859f, -0.10924280f, 0.16180187f, 0.06999736f, 
    0.02670881f, -0.28777254f, 0.14974639f, -0.14915898f, 0.07970539f, 0.00785569f, -0.11721753f, -0.13630949f, 
    -0.09337462f, -0.19444716f, -0.08923796f, 0.01297894f, 0.08867146f, 0.09021795f, 0.01708443f, 0.36810988f, 
    -0.06102062f, -0.09349922f, 0.05130609f, -0.00778556f, 0.10971875f, 0.10768496f, -0.10354565f, -0.11164624f, 
    0.11449786f, 0.17757352f, 0.08599640f, -0.06401163f, 0.44308975f, -0.13746957f, -0.08436164f, -0.00764057f, 
    0.01983753f, 0.36504537f, -0.13449605f, -0.12002055f, 0.08999539f, 0.26657254f, 0.00211632f, -0.04663705f, 
    -0.17344922f, 0.41034901f, 0.23174205f, -0.34767219f, 0.04833106f, -0.08998176f, 0.15817745f, -0.08465754f, 
    -0.04268913f, 0.03262138f, -0.00204114f, -0.07042290f, -0.01481639f, -0.30920011f, -0.12461751f, -0.03319889f, 
    0.00667121f, 0.16251035f, -0.05639392f, 0.37306076f, -0.29781777f, 0.07588297f, -0.15795648f, 0.28396073f, 
    0.05142178f, -0.39467418f, 0.09186497f, 0.16267334f, 0.14472562f, 0.44149578f, 0.21851985f, 0.04936875f, 
    0.22112395f, 0.24264134f, 0.24608751f, -0.05259839f, 0.14201602f, 0.20220825f, -0.00165973f, 0.16060804f, 
    -0.11854347f, -0.12805232f, 0.00647907f, 0.11855984f, -0.13867112f, -0.15264492f, -0.02629314f, 0.07745982f, 
    -0.16209887f, -0.12597969f, 0.12310926f, -0.16199771f, 0.13167563f, 0.08525064f, -0.04675049f, 0.08810318f, 
    0.04363185f, -0.05748858f, 0.00473164f, -0.17311145f, -0.07082790f, -0.04974082f, 0.02586299f, -0.08860403f, 
    -0.06734265f, -0.01617762f, -0.13645604f, -0.11593068f, -0.09200187f, 0.03231161f, -0.02972478f, 0.09002703f, 
    -0.01245650f, -0.01701053f, -0.11057144f, 0.02588234f, 0.15186097f, -0.08791064f, -0.24111150f, 0.02927585f, 
    -0.10389877f, -0.07205762f, 0.10276472f, -0.05663387f, -0.02539897f, 0.00548000f, -0.09286253f, -0.03282585f, 
    -0.11546407f, 0.22158977f, 0.15566628f, -0.01415944f, -0.05226821f, 0.05057756f, -0.06054473f, -0.09071462f, 
    0.12844230f, -0.39183250f, 0.09631547f, -0.04146262f, -0.00354343f, -0.17480743f, 0.10302488f, 0.15956214f, 
    0.00298993f, -0.02318739f, 0.10327147f, 0.06710208f, 0.11906642f, 0.00603091f, 0.20773835f, 0.11188982f, 
    -0.06368916f, 0.00716215f, 0.03424101f, -0.32113290f, -0.03403043f, 0.03054592f, 0.06734303f, -0.41770002f, 
    0.11737227f, 0.15590180f, 0.05813859f, 0.32065925f, 0.10883615f, 0.09467356f, 0.37069863f, -0.11949809f, 
    -0.38672903f, -0.17160848f, 0.04247329f, 0.13673902f, 0.12447391f, 0.33952975f, -0.04429410f, -0.01288891f, 
    -0.10253324f, -0.02640769f, 0.10088012f, 0.06533302f, -0.02017642f, -0.13796417f, -0.08445147f, 0.12680261f, 
    -0.18166165f, 0.02203186f, 0.10789228f, -0.19943264f, 0.10121538f, 0.17060114f, 0.12052659f, -0.02161559f, 
    0.02158993f, -0.03932429f, 0.15212929f, 0.00009957f, 0.11327571f, 0.02105926f, -0.13060987f, 0.09815391f, 
    -0.00074599f, 0.00308101f, -0.14438666f, -0.14950122f, 0.04081444f, 0.11104795f, 0.12728645f, 0.10643058f, 
    0.09482066f, -0.11861372f, 0.11613089f, 0.15782917f, 0.01835752f, -0.00185191f, 0.11742942f, -0.02816059f, 
    0.14769368f, -0.13018031f, 0.14005761f, -0.04575606f, 0.48486125f, -0.18307245f, 0.08504639f, 0.19779845f, 
    -0.15447521f, -0.27057949f, -0.07080522f, -0.17334458f, 0.10608394f, 0.18324453f, -0.18865794f, 0.06741038f, 
    -0.32494903f, -0.06201274f, 0.08450299f, -0.40806767f, 0.14374639f, -0.06716708f, 0.00077046f, 0.33875227f, 
    0.02257444f, -0.15232491f, 0.00335251f, 0.16075341f, -0.05888446f, -0.15453042f, 0.15774728f, -0.07623459f, 
    0.19721439f, -0.12735055f, 0.12875287f, -0.12816541f, 0.51907283f, 0.03325653f, 0.03924741f, 0.04302949f, 
    0.06416980f, -0.08943351f, 0.05829402f, -0.49731326f, 0.16228406f, 0.03141293f, 0.05002979f, 0.08985323f, 
    -0.09674827f, 0.01313660f, 0.16881962f, 0.12639356f, -0.05086681f, 0.60170281f, 0.09792127f, -0.01532412f, 
    0.09863842f, -0.02974743f, -0.00666087f, -0.10509042f, 0.16956088f, 0.16384131f, -0.12608995f, -0.12794910f, 
    0.06577937f, -0.08761015f, 0.04098351f, -0.08140890f, 0.37032157f, -0.10347428f, 0.10001902f, -0.12360078f, 
    0.00456790f, -0.29354534f, -0.04626000f, 0.15382896f, 0.04160535f, -0.06480157f, 0.14667030f, -0.14055763f, 
    0.07230312f, -0.43804416f, 0.15344948f, -0.31906876f, -0.02876307f, 0.37459692f, -0.14469609f, 0.28759035f, 
    0.11920489f, 0.14193396f, -0.18041284f, 0.10084282f, -0.17093395f, -0.14164124f, 0.38021559f, 0.02040814f, 
    0.07422668f, -0.12631291f, 0.15359992f, -0.01724432f, -0.18013629f, 0.09984101f, 0.14983727f, -0.07521529f, 
    0.03529788f, -0.03934043f, -0.05162268f, 0.45285526f, 0.00703427f, 0.12041081f, 0.41364786f, -0.00037133f, 
    0.12327129f, -0.19480585f, 0.07256474f, -0.11198462f, -0.06475060f, 0.29990110f, 0.12840794f, 0.05734177f, 
    0.09102596f, -0.01308054f, -0.06058563f, -0.10276622f, 0.09409253f, -0.24976370f, 0.19363712f, 0.04846527f, 
    0.10755222f, -0.14423984f, -0.03670885f, 0.35631612f, 0.02588122f, 0.11007601f, 0.15427223f, 0.40316924f, 
    0.04074317f, -0.03131023f, -0.06730223f, -0.03359567f, 0.11260930f, -0.32564521f, -0.00422875f, 0.07648239f, 
    -0.09878528f, 0.36885604f, -0.20687279f, -0.11057504f, -0.16083799f, -0.20743123f, 0.13053715f, 0.32322416f, 
    -0.07261895f, -0.11242186f, -0.02405513f, 0.03126236f, -0.16393641f, 0.13227434f, -0.16995580f, -0.01635226f, 
    0.34410465f, -0.08581010f, 0.07215627f, -0.15853141f, -0.30448881f, 0.13050026f, 0.02604276f, 0.15462407f, 
    -0.11462253f, 0.01369523f, -0.09967048f, 0.21582790f, 0.09615983f, 0.14204997f, 0.23988615f, 0.03762673f, 
    0.00938188f, 0.39936143f, -0.17644687f, 0.19861811f, 0.16278477f, 0.42260194f, 0.10408939f, -0.19819537f, 
    0.14637229f, 0.11731280f, -0.13853140f, 0.05100804f, 0.16730291f, -0.06337761f, -0.03699782f, 0.04550891f, 
    0.22816180f, 0.16231027f, -0.07169437f, 0.07068033f, -0.13911930f, 0.15332322f, 0.11996046f, 0.45776853f, 
    -0.07754878f, -0.18767634f, 0.14764152f, -0.01726993f, -0.03163348f, 0.27209833f, -0.15299630f, 0.07150805f, 
    -0.45595837f, 0.38628241f, 0.16995700f, -0.19681813f, 0.07182487f, 0.49917281f, -0.03347539f, 0.02592180f, 
    0.10598785f, 0.02217187f, 0.14296263f, 0.15025543f, 0.13347770f, 0.37999204f, 0.12994541f, 0.02847414f, 
    -0.07527680f, 0.01399509f, -0.01592185f, -0.20794024f, 0.38445342f, 0.10602231f, 0.13218628f, 0.18053068f, 
    0.05572191f, 0.18160616f, 0.12821943f, 0.29070824f, -0.08685585f, -0.31617564f, 0.52905399f, -0.15570293f, 
    0.08643595f, 0.28855404f, 0.06792828f, -0.10755623f, -0.17997961f, -0.16633350f, -0.05684535f, -0.15334284f, 
    -0.02226884f, -0.01727119f, -0.05065440f, 0.00472837f, 0.14519715f, -0.20710696f, -0.22775003f, -0.14355993f, 
    0.14154646f, 0.00275482f, 0.11952837f, -0.05056579f, 0.30123830f, 0.00236525f, 0.10200644f, -0.07785829f, 
    -0.07751945f, 0.00971736f, -0.08007766f, -0.14942175f, -0.13533075f, -0.15129453f, 0.03062511f, 0.01604403f, 
    0.24766418f, 0.03239594f, -0.05132313f, -0.14431676f, -0.03984163f, -0.08585823f, -0.11525918f, 0.09105024f, 
    0.04302721f, 0.01448534f, -0.08503389f, -0.11844189f, 0.10568124f, 0.23713668f, -0.04240897f, 0.01504289f, 
    -0.10986665f, 0.04826604f, 0.14028855f, 0.23977967f, 0.35319939f, 0.15332869f, 0.01859609f, -0.11091477f, 
    0.13132973f, -0.13372657f, -0.01526138f, 0.15461044f, 0.09553508f, -0.23592357f, -0.03932814f, -0.00405699f, 
    0.14221363f, -0.28717488f, 0.19373474f, -0.20701069f, 0.14422075f, -0.09717267f, -0.04285543f, 0.15942577f, 
    0.06612054f, -0.05794559f, -0.16982469f, -0.09777853f, 0.07230105f, -0.19819464f, -0.08830135f, 0.07168690f, 
    -0.18887198f, 0.16993640f, 0.15924834f, -0.11851300f, 0.12431211f, 0.08906233f, 0.04484418f, -0.10515551f, 
    0.11877053f, 0.01872041f, -0.08089728f, 0.18037882f, -0.14496130f, 0.08899461f, -0.18887164f, 0.16911513f, 
    0.11549028f, -0.07088919f, -0.14913423f, -0.00630711f, 0.04730821f, -0.07907657f, -0.14326689f, 0.14946179f, 
    -0.14675279f, -0.00244381f, -0.14734167f, -0.04496712f, 0.14093286f, -0.03512012f, -0.14115328f, 0.00709780f, 
    0.06507751f, 0.02579728f, -0.07868055f, 0.42225379f, -0.01232549f, -0.04982680f, 0.11787677f, -0.25910857f, 
    0.11863453f, 0.04838735f, 0.01022952f, 0.19278038f, 0.12710871f, 0.16267027f, 0.34334588f, -0.07859509f, 
    0.31717777f, -0.20411403f, 0.09100495f, 0.24388821f, -0.15218128f, -0.01698007f, 0.02185118f, 0.01932240f, 
    0.12791644f, -0.04602833f, 0.00507356f, 0.14954826f, 0.12957874f, -0.33895656f, 0.02627589f, -0.00106819f, 
    -0.07375707f, 0.01037866f, 0.04692306f, 0.41458306f, 0.23321101f, -0.12067515f, 0.13521840f, 0.35737398f, 
    0.15066768f, -0.11608829f, 0.10773516f, 0.08279138f, 0.14571968f, 0.14527625f, 0.14008011f, -0.13303979f, 
    0.19658969f, -0.01701366f, 0.12385876f, 0.01112944f, -0.15805808f, 0.32861903f, 0.11763880f, 0.25325722f, 
    0.02769727f, -0.13814922f, 0.11859831f, 0.08718119f, 0.11429591f, 0.16624938f, 0.22752540f, -0.09628014f, 
    -0.24279946f, 0.17744666f, -0.08651347f, 0.21499011f, -0.40312222f, -0.13233480f, 0.00369273f, 0.05925398f, 
    0.07439119f, 0.12981810f, 0.09311849f, 0.42887387f, 0.12630826f, 0.37722817f, -0.01012993f, -0.06900903f, 
    0.22544973f, -0.21989489f, -0.07492062f, 0.10053636f, -0.02276707f, -0.69352251f, 0.05655875f, 0.20065111f, 
    -0.14362416f, -0.16342002f, 0.02795198f, -0.03308437f, 0.00706288f, 0.14182326f, -0.08030321f, -0.10495631f, 
    0.02923203f, -0.02264769f, -0.00579719f, -0.21145903f, -0.04912701f, -0.17427652f, 0.01886421f, -0.01216117f, 
    0.09693847f, -0.06465346f, -0.03466542f, 0.24782166f, 0.10401317f, 0.27660212f, 0.10676746f, 0.04523202f, 
    0.27909413f, -0.43713576f, 0.14010955f, 0.10989418f, 0.15376812f, 0.00028952f, -0.07701818f, -0.10185535f, 
    0.14497989f, -0.10550670f, 0.06299824f, -0.10489746f, 0.10920597f, 0.15415952f, 0.01718602f, 0.03129937f, 
    0.20902936f, 0.00955588f, 0.04764353f, 0.21677814f, 0.22450231f, 0.11638971f, 0.12853862f, 0.13286355f, 
    -0.12895431f, 0.22236834f, -0.05510702f, -0.31973138f, 0.04778794f, -0.34890166f, 0.24348308f, 0.06891733f, 
    0.26112705f, -0.13331398f, -0.23814797f, -0.07041574f, 0.12086969f, 0.31718934f, 0.14393605f, 0.17766263f, 
    -0.04146186f, 0.08681600f, 0.13701573f, 0.01088423f, 0.07672402f, 0.16185422f, -0.05728361f, 0.04311332f, 
    -0.15575652f, 0.08559193f, 0.05574016f, -0.03387648f, -0.10757846f, -0.06247164f, -0.02983453f, 0.14506264f, 
    0.17625284f, -0.14929676f, -0.14616734f, 0.05182888f, 0.01448328f, 0.07239231f, -0.03364505f, 0.04437819f, 
    -0.08051675f, -0.10404681f, -0.11180208f, -0.16057329f, -0.10194435f, 0.03513589f, 0.15315396f, -0.10784771f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09180526f, -0.03010350f, 0.04199299f, 0.10497579f, 0.06906512f, 0.22819586f, -0.06131956f, -0.17290273f, 
    0.06180846f, -0.07317258f, -0.08986491f, -0.11397734f, -0.11078803f, 0.13307467f, -0.08614144f, 0.21778236f, 
    0.09376604f, 0.02005971f, 0.33317021f, -0.09709814f, 0.11172403f, -0.11449032f, 0.11831120f, 0.43703675f, 
    0.20674802f, -0.05830587f, 0.09290155f, -0.07727475f, 0.04725523f, -0.43158025f, 0.01682179f, -0.04435258f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.23039825f, -0.14781179f, -0.09587799f, -0.65209854f, -0.02631462f, -0.02419563f, 0.28846064f, -0.14305000f, 
    -0.02515855f, 0.24015869f, -0.82142156f, 0.14675461f, 0.11564438f, -0.16539513f, 0.11004222f, -0.14301445f, 
    -0.06249868f, -0.17150618f, -0.65016532f, -0.10827943f, 0.19904827f, 0.14677572f, 0.11282617f, -0.28956932f, 
    -0.63082743f, -0.19000454f, -0.15679388f, -0.56913441f, -0.40617892f, 0.24286039f, 0.12251969f, -0.05293290f, 
    0.19283709f, -0.06107060f, -0.81014913f, -0.11559089f, -0.17590767f, -0.34857115f, 0.22568706f, -0.05960786f, 
    0.16478109f, -0.23716515f, -0.34628597f, -0.10963431f, -0.04005573f, 0.24676928f, -0.04996755f, -0.06182851f, 
    0.00403465f, 0.41072005f, 0.05293283f, -0.31834748f, 0.04325077f, -0.81722909f, 0.32780471f, 0.10639455f, 
    0.32596436f, -0.04060500f, 0.23776403f, -0.10225749f, -0.10144292f, -0.15000981f, 0.19977382f, 0.17384247f, 
    -0.30031937f, 0.15457328f, -0.07242874f, 0.06453684f, -0.17077221f, 0.12527791f, 0.09230111f, 0.12600115f, 
    0.00592574f, -0.81210762f, 0.16558282f, -0.14046472f, -0.18742000f, 0.10866690f, 0.10726824f, -0.60400116f, 
    0.00267432f, -0.59235209f, 0.26759765f, 0.00621796f, 0.22174495f, 0.24653587f, -0.19360191f, 0.15766342f, 
    -0.88324910f, -0.16876002f, 0.12566513f, 0.16888967f, -0.13640676f, -0.29837808f, 0.02744446f, 0.10815123f, 
    0.06480823f, -0.15195478f, 0.68249315f, -0.18356618f, -0.13966651f, -0.39607498f, 0.11465368f, 0.04632819f, 
    -0.44666335f, 0.13547677f, 0.31045327f, -0.07050114f, 0.04455264f, -0.13678651f, 0.01386348f, -0.31342191f, 
    -0.35464764f, -0.43489560f, -0.27795759f, -0.21633482f, 0.21078478f, 0.18264665f, -0.00134993f, -0.68976468f, 
    -0.53505284f, -0.05079556f, 0.16805747f, -0.05557153f, 0.13058060f, -0.04993515f, -0.23634392f, -0.13992226f, 
    0.01822247f, 0.06244894f, -0.58685422f, -0.38131949f, -0.51776230f, -0.25057060f, 0.24762982f, -0.05800015f, 
    -0.20019461f, 0.04196301f, 0.14453918f, 0.11742534f, -0.05118094f, -0.36244041f, -0.06851881f, -0.36300460f, 
    0.19182009f, -0.10609058f, -0.27232653f, 0.18686795f, 0.15541683f, 0.18065540f, 0.02069034f, -0.13377230f, 
    -0.24762338f, -0.14039993f, -0.00273497f, 0.26287815f, -0.51808894f, 0.13113172f, 0.04905383f, -0.05575463f, 
    0.22899330f, 0.03396000f, -0.10520852f, 0.32230797f, -0.34691849f, 0.28528994f, -0.40133005f, -0.20886974f, 
    -0.35787964f, 0.05782597f, -0.60771793f, 0.16794832f, -0.02863106f, 0.13708571f, -0.19369343f, -0.22459774f, 
    0.20607252f, -0.06712832f, -0.11006730f, -0.12398922f, 0.05414872f, -0.00141300f, 0.09851820f, -0.32299826f, 
    -0.15932193f, 0.00821587f, -0.03083771f, 0.09431626f, -0.25891054f, -0.36452276f, 0.23558794f, 0.11173213f, 
    -0.41515204f, -0.11239146f, 0.05395852f, 0.07326477f, 0.26811582f, 0.30870178f, 0.03181067f, 0.02377587f, 
    0.34721160f, -0.92408580f, 0.02267846f, -0.15649228f, -0.07408982f, -0.20492432f, 0.12683424f, 0.08832912f, 
    0.10201262f, -0.24722235f, -0.06541622f, 0.10549238f, -0.41865203f, -0.02014830f, -0.64501572f, 0.35363543f, 
    -0.27009162f, -0.33794436f, -0.02141002f, 0.09767688f, 0.11343987f, -0.21810736f, 0.04127576f, -0.11372747f, 
    -0.40478790f, -0.05410149f, 0.09866697f, 0.06685840f, -0.20595872f, -0.75747943f, -0.05506683f, 0.02232873f, 
    -0.38792020f, -0.00096056f, 0.23913734f, 0.07086920f, -0.23102796f, -0.04157693f, 0.15767048f, 0.13277300f, 
    0.12662405f, 0.19459516f, 0.21117555f, -0.69510615f, 0.07704342f, 0.13455229f, -0.12434265f, -0.21102108f, 
    -0.16510636f, -0.17992541f, 0.14068891f, 0.11081697f, -0.14306092f, 0.34233755f, 0.01798029f, 0.08448823f, 
    -0.08046190f, 0.04365638f, 0.26641402f, 0.37114480f, -0.25031850f, 0.08098705f, -0.20406149f, 0.10540346f, 
    -0.07856859f, -0.41800839f, -0.20840789f, -0.00546149f, -0.00871645f, 0.29329261f, -0.07221027f, -0.31357899f, 
    -0.23188172f, 0.01336770f, 0.22321735f, -0.69887590f, -0.41119999f, -0.47823191f, 0.03290808f, -0.15784469f, 
    0.16496563f, 0.20812993f, -0.07115884f, 0.00886240f, 0.33619609f, 0.09263615f, -0.64261568f, -0.07576587f, 
    -0.41238382f, -0.09784450f, -0.09046869f, -0.22090273f, -0.08273865f, 0.13271740f, 0.37135524f, -0.15614702f, 
    0.10688718f, 0.24307729f, -0.17480808f, -0.01509198f, 0.03600669f, -0.16512477f, 0.09227782f, 0.38700935f, 
    0.22958383f, -0.02866185f, 0.08726987f, 0.21581039f, -0.25077900f, 0.30314073f, 0.07355439f, -0.26588729f, 
    0.23760185f, -0.02199423f, -0.55837530f, -0.06569085f, -0.35250089f, -0.33955976f, -0.25193560f, -0.07916396f, 
    0.27897096f, -0.13218111f, -0.17297736f, -0.24915732f, 0.31972930f, -0.17703836f, -0.69705796f, -0.04980732f, 
    -0.20721452f, -0.62648797f, -0.10949469f, -0.08634766f, -0.14906375f, -0.21302627f, -0.15824632f, -0.53556275f, 
    -0.60860968f, -0.52711874f, 0.15078866f, 0.32465065f, 0.18258941f, -0.17043601f, 0.31304345f, -0.41744450f, 
    -0.39700952f, -0.21150358f, -0.21818866f, 0.01783762f, 0.23581918f, -0.03630608f, 0.08224141f, -0.07067824f, 
    -0.05674359f, -0.10355064f, 0.16382851f, 0.08590066f, 0.38376701f, 0.03909916f, 0.23782656f, -0.02989904f, 
    -0.13934851f, 0.25283113f, -0.17056414f, -0.11021852f, -0.19212089f, -0.48240668f, -0.12010364f, -0.24704111f, 
    -0.14441481f, -0.45107695f, -0.05526160f, 0.08651330f, -0.56844038f, -0.52947754f, -0.05018030f, -0.67059582f, 
    0.10668730f, -0.16544780f, 0.18690628f, 0.11940030f, 0.31535923f, -0.11214494f, 0.11295950f, 0.04299598f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.37040105f, 0.27601519f, -0.07700367f, -0.00991076f, 0.19555356f, 0.14943041f, 0.10160037f, -0.10146499f, 
    0.09419518f, 0.04536637f, -0.04504255f, -0.17490530f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
