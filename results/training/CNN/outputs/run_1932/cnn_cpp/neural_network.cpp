#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.39476007f, -0.41327077f, -0.25664017f, 0.19595876f, -0.09780385f, 0.20689960f, -0.59280694f, -0.46504486f, 
    0.26675144f, -0.20837571f, 0.23269202f, 0.19854823f, -0.02296284f, 0.02889364f, 0.00752989f, 0.24810965f, 
    0.12194429f, -0.13312899f, -0.18774258f, -0.27739102f, -0.20480716f, -0.01250279f, -0.07888453f, -0.29772857f, 
    -0.47022697f, -0.13557650f, -0.74827737f, -0.40475678f, -0.17162983f, -0.49113140f, 0.39041460f, 0.03432672f, 
    -0.33910877f, -0.02261665f, -0.32047492f, -0.29181671f, -0.23711583f, 0.23320304f, 0.54812998f, 0.35345572f, 
    0.00693433f, -0.27850991f, -0.20601569f, -0.25862539f, 0.03938444f, -0.38547322f, -0.09078539f, 0.12231128f, 
    -0.06662602f, -0.36488354f, -0.34399936f, 0.14138865f, -0.63352293f, 0.06195115f, -0.39794549f, -0.36254907f, 
    -0.50177103f, -0.55172521f, -0.38786447f, -0.58120596f, 0.15461060f, 0.42636803f, 0.33003873f, -0.07232003f, 
    0.02613199f, -0.06181203f, 0.21175323f, 0.03669048f, 0.01539372f, 0.20842667f, 0.00429766f, 0.10775550f, 
    -0.13640270f, 0.01067557f, -0.01329519f, -0.36385965f, 0.47038868f, 0.14508742f, -0.08190106f, 0.04545319f, 
    -0.25618482f, -0.32723001f, -0.11594727f, 0.13816555f, -0.23914871f, -0.03633783f, 0.33076885f, 0.04883090f, 
    -0.19649722f, 0.48289365f, 0.06855111f, 0.18396987f, -0.14214678f, -0.30396414f, -0.34970534f, -0.14879619f, 
    0.13539164f, 0.00155540f, 0.50176674f, 0.26314014f, 0.87527537f, -0.71002889f, -0.54467374f, 0.05660583f, 
    -0.52035028f, 0.92509210f, -0.09417967f, 0.13503434f, -0.33755925f, 0.30137885f, -0.16007629f, 0.31811941f, 
    -0.16682863f, 0.07424691f, 0.12141132f, 0.05628069f, 0.03897287f, 0.02741738f, 0.00317191f, -0.26597619f, 
    -0.00116766f, 0.18148316f, -0.15835916f, 0.10311375f, 0.00176742f, -0.39368799f, -0.68792778f, 0.21493593f, 
    0.29870343f, 0.10267786f, -0.09321985f, 0.61800927f, -0.79832506f, -0.62598473f, 0.48691678f, -0.07490826f, 
    -0.27954957f, -0.17754199f, -0.22072349f, 0.20860526f, -0.00816838f, 0.19730993f, -0.09086587f, 0.12489755f, 
    -0.07054950f, 0.05679244f, -0.15474655f, 0.18442835f, -0.05663372f, 0.17121348f, -0.63235670f, -0.33146569f, 
    -0.45523316f, -0.16904776f, -0.40701735f, 0.30299449f, 0.35284510f, -0.63864899f, -0.42614681f, 0.75946444f, 
    -0.14628915f, -0.42089862f, -0.21196930f, -0.04721830f, 0.28973827f, -0.04214770f, 0.24404673f, -0.31536299f, 
    -0.13288444f, -0.27116296f, -0.49533445f, -0.48819467f, -0.20748624f, -0.17349003f, -0.00034636f, -0.49623790f, 
    -0.31393093f, -0.46702594f, -0.22530486f, -0.08718932f, -0.20005940f, 0.05577156f, -0.52302969f, -0.61662942f, 
    -0.29417115f, -0.06375451f, 0.16645683f, 0.08175634f, -0.44003728f, -0.24261332f, -0.31491032f, -0.46424010f, 
    -0.40045860f, -0.17146805f, -0.06987014f, -0.07507418f, 0.05715679f, 0.11849723f, -0.09271334f, -0.39306569f, 
    0.60793680f, 0.60205585f, -0.02410402f, -0.31926510f, 0.29211321f, -0.38475528f, -0.19472839f, -0.13795480f, 
    0.00228715f, 0.14101510f, -0.15337954f, 0.01009258f, 0.18669370f, -0.17970781f, -0.16635975f, 0.05172992f, 
    -0.11268792f, -0.02186728f, 0.06031325f, -0.07448532f, -0.15278256f, 0.05851735f, 0.05454622f, 0.17760836f, 
    -0.19041371f, -0.82026589f, -0.27760366f, -0.17432822f, -0.30742195f, -0.11756889f, 0.17129168f, 0.10066906f, 
    0.31412935f, -0.24264947f, -0.26724645f, -0.33377308f, -0.22828650f, -0.08066422f, -0.25361055f, -0.13275622f, 
    0.32294363f, -0.18041380f, -0.20229121f, 0.06356195f, -0.41856101f, 0.03282170f, 0.35135069f, 0.10371307f, 
    -0.18389900f, -0.12650608f, -0.39896524f, 0.25186965f, 0.25188977f, -0.06942642f, -0.19503918f, 0.25405645f, 
    0.08578347f, -0.58270878f, -0.46091658f, 0.44409040f, 0.15463971f, -0.22567600f, 0.18516837f, 0.41791189f, 
    -0.42543244f, -0.41076472f, 0.29677907f, 0.05958709f, 0.12608124f, -0.26536056f, 0.32437029f, 0.24781691f, 
    -0.23833533f, -0.07926930f, -0.28846470f, -0.21674486f, -0.46917632f, -0.03990227f, 0.33994460f, -0.25809970f, 
    -0.68835312f, -0.61144435f, -0.62255895f, -0.19146475f, 0.18037274f, 0.57144791f, -0.06223639f, 0.33015162f, 
    0.42032319f, 0.37728560f, -0.32662129f, -0.05049870f, -0.20231174f, -0.19033694f, 0.04273768f, 0.03009073f, 
    0.15238817f, -0.00411827f, -0.05983923f, -0.14698477f, -0.38082996f, -0.55242479f, -0.20368952f, 0.08361460f, 
    -0.19071636f, -0.42719227f, 0.28872812f, -0.39081711f, -0.23428445f, -0.37798333f, 0.47098628f, -0.29716137f, 
    -0.01568509f, -0.17189811f, 0.19766560f, 0.01161237f, -0.24083467f, 0.18176928f, -0.04596367f, -0.09475488f, 
    0.09454759f, 0.07556793f, 0.17913242f, 0.23141205f, 0.04168470f, 0.27315903f, 0.70888692f, 0.26549342f, 
    -0.77040529f, 0.09861320f, 0.32738021f, 0.05438995f, -0.23211531f, -0.37328720f, 0.17025255f, 0.00228191f, 
    -0.02464255f, -0.44313368f, -0.46632046f, 0.65539974f, -0.02894546f, 0.63052481f, 0.07900946f, -0.04362061f, 
    -0.31792805f, -0.21784177f, 0.16521685f, -0.14603637f, -0.26932365f, -0.39891347f, -0.40636069f, -0.10367470f, 
    -0.36814344f, -0.49693879f, 0.03054920f, -0.09218899f, -0.13443899f, -0.32294634f, -0.10453133f, 0.37107840f, 
    -0.03858900f, -0.20186321f, -0.06013743f, -0.25515598f, -0.46877632f, -0.00952417f, 0.09722453f, 0.12290339f, 
    -0.03890507f, -0.20686880f, -0.15857662f, -0.13436419f, -0.28031120f, -0.23188350f, -0.31918147f, 0.40556782f, 
    0.13114314f, 0.57635665f, 0.00926808f, -0.87735587f, -0.54806954f, -0.75341415f, -0.43379736f, 0.04343820f, 
    -0.06261697f, 0.24949466f, 0.44570136f, -0.04658568f, 0.21105662f, 0.53183568f, -0.19965366f, 0.24757120f, 
    0.01954496f, -0.36575782f, -0.10310724f, 0.17077412f, 0.16428338f, -0.00291488f, -0.03653754f, -0.28071877f, 
    0.34680113f, 0.31439129f, 0.14939423f, 0.18980898f, -0.06000795f, -0.07591634f, -0.18819682f, 0.04001853f, 
    -0.04245177f, 0.14029236f, -0.05236141f, 0.03414683f, 0.11666653f, 0.08549727f, -0.20337673f, 0.11994024f, 
    -0.04382261f, -0.20336282f, 0.14191450f, -0.20533919f, -0.25313169f, -0.22821617f, 0.05217488f, -0.34693271f, 
    -0.48969114f, 0.18152954f, 0.30166972f, -0.20149846f, 0.19146620f, 0.02656850f, 0.19027282f, -0.01562357f, 
    0.10185701f, 0.14418830f, -0.06566463f, -0.13740923f, 0.05295389f, -0.16007653f, -0.32810003f, -0.34207863f, 
    -0.04179687f, -0.02313908f, 0.24750195f, 0.08712899f, 0.03431192f, -0.24590448f, -0.08751263f, -0.26339474f, 
    -0.25394729f, -0.22632138f, 0.62840301f, 0.00537780f, -0.67241472f, -0.52456945f, -0.13267694f, -0.04182285f, 
    -0.06483576f, 0.19345127f, 0.35085985f, -0.04764470f, -0.02070600f, -0.11212666f, 0.40367329f, -0.02103454f, 
    0.05587155f, -0.45097849f, -0.00664864f, -0.37840047f, -0.10157994f, -0.41074693f, 0.35447714f, 0.29690036f, 
    0.48096192f, 0.09062897f, 0.33474898f, 0.36460534f, 0.21179816f, 0.33652171f, 0.11900469f, 0.23094334f, 
    -0.22554745f, 0.05194498f, 0.32857063f, -0.21192449f, 0.19858235f, -0.13680153f, -0.04555916f, 0.00695660f, 
    0.02818309f, 0.00532612f, 0.19724217f, 0.06952404f, -0.23218654f, 0.05382682f, 0.12302729f, -0.27133840f, 
    -0.28535995f, -0.31974471f, -0.30841926f, -0.42052561f, 0.45097372f, 0.76379514f, -0.27973780f, -0.33973938f, 
    -0.68901646f, 0.13291122f, 0.37742767f, -0.03011812f, 0.00401931f, -0.28324628f, -0.06570786f, -0.01238704f, 
    -0.11668604f, 0.06144548f, -0.10164807f, 0.01569922f, -0.07377912f, 0.03887263f, 0.10047711f, -0.00380283f, 
    -0.10829849f, 0.28981844f, -0.04032861f, -0.45220935f, 0.19396938f, 0.26697826f, 0.85277182f, -0.04785013f, 
    0.05341715f, -0.52143359f, -0.50045866f, -0.34857327f, 0.00993045f, 0.01499485f, -0.03752910f, 0.30835259f, 
    -0.11265033f, -0.04640858f, 0.44491282f, -0.37805438f, 0.12658955f, -0.27965227f, 0.26788250f, 0.11295093f, 
    0.03333898f, 0.08860721f, 0.16922159f, -0.21448624f, -0.27542284f, 0.24877837f, -0.36564195f, -0.26030958f, 
    -0.37420055f, 0.11080452f, -0.42039946f, 0.28071174f, 0.34180355f, 0.08932073f, -0.22421806f, -0.06523734f, 
    0.32711509f, 0.05605910f, -0.09289419f, 0.32153627f, 0.07976820f, -0.00391893f, -0.39652523f, -0.48761025f, 
    -0.01414369f, -0.24009901f, 0.17220937f, -0.23281451f, -0.05835387f, 0.05110381f, -0.42226335f, -0.26468009f, 
    -0.58406150f, 0.19822077f, 0.07289578f, 0.28426337f, 0.73716980f, -0.38228807f, -0.59513217f, -0.63795710f, 
    -0.70686579f, 0.24840818f, 0.41903931f, -0.32921845f, -0.28863606f, -0.55720776f, -0.01083718f, 0.23770976f, 
    -0.25302470f, -0.46053720f, -0.22069618f, -0.03890194f, -0.09589315f, -0.20624390f, -0.12761572f, -0.17805701f, 
    0.50667560f, -0.46412575f, 0.18280660f, 0.08179988f, 0.40710410f, -0.39251199f, 0.23659851f, -0.06000030f, 
    -0.17976242f, -0.22924781f, -0.05082770f, -0.05875913f, 0.11540956f, -0.41055980f, -0.13048211f, 0.07250825f, 
    -0.01675681f, -0.11065675f, -0.01729688f, 0.09121666f, 0.10999152f, 0.24878708f, 0.09508672f, -0.06288937f, 
    0.24875738f, -0.25067213f, 0.36201432f, 0.17874451f, 0.10298174f, 0.31198931f, -0.43181884f, -0.16710825f, 
    0.36561626f, 0.21494834f, 0.18148963f, -0.16592583f, -0.04634390f, 0.12893373f, 0.09151047f, 0.19207199f, 
    -0.18909682f, -0.07924242f, -0.33505931f, 0.03094755f, 0.02284394f, 0.06283093f, -0.05125174f, -0.19056176f, 
    0.35188323f, -0.11250708f, -1.19688213f, 0.28409928f, -0.09212674f, -0.66671699f, -0.56472158f, 0.35408700f, 
    -0.03931734f, 0.12821729f, 0.34151053f, 0.63112640f, 0.17358793f, 0.10034394f, -0.06384742f, -0.00241886f, 
    -0.23420677f, 0.09350221f, -0.19818708f, -0.20971648f, 0.32951444f, -0.06744137f, 0.01815136f, 0.24924159f, 
    0.11338632f, 0.04383359f, 0.05725108f, -0.96455377f, 0.36366811f, -0.30128565f, -0.79468733f, -0.05415614f, 
    0.14390038f, 0.02054532f, -0.27092579f, 0.15213081f, 0.43765634f, -0.12342424f, -0.20705967f, -0.01030759f, 
    0.06273885f, -0.03587953f, -0.08158607f, 0.08529411f, -0.26274741f, -0.17885448f, -0.22184539f, -0.24652228f, 
    0.15575345f, -0.13286205f, -0.29517025f, -0.35408512f, -0.37844813f, -0.49762252f, -0.41788313f, -0.53355402f, 
    -0.32029805f, -0.04983477f, -0.22215013f, 0.11073875f, -0.19658923f, -0.22208883f, -0.44812304f, -0.20637065f, 
    0.09790115f, -0.25087011f, -0.27901769f, 0.16467099f, 0.10980365f, 0.02900725f, 0.07327953f, 0.16879702f, 
    0.04594925f, 0.16961800f, -0.05307819f, 0.16324672f, 0.10672764f, -0.65955579f, -0.05018484f, 0.34270969f, 
    -0.18837756f, -0.15731435f, 0.47202429f, 0.67401576f, 0.12208622f, -0.24037617f, -0.09799681f, -0.04766536f, 
    0.11438476f, -0.51992345f, -0.10813826f, 0.19130164f, 0.27838665f, 0.30691737f, -0.33976367f, -0.03792959f, 
    -0.21061711f, -0.10198326f, -0.05835207f, -0.02963420f, 0.30497977f, 0.20371944f, -0.97544187f, -0.18117654f, 
    0.55784702f, 0.23898385f, 0.36075807f, 0.62851185f, -0.61109948f, -0.39798179f, 0.21134917f, 0.23329510f, 
    0.02534027f, -0.07059906f, -0.20124552f, 0.06032421f, -0.28894240f, 0.07102251f, -0.30852953f, 0.21220995f, 
    0.22470255f, 0.25171837f, -0.44861314f, -0.01742208f, 0.32237092f, -0.14051333f, -0.05092935f, -0.95437622f, 
    -0.38399658f, 0.03405339f, 0.18689674f, 0.52836180f, 0.32131454f, 0.13696949f, 0.73590404f, 0.05019739f, 
    -0.29657668f, 0.24412566f, 0.33523732f, -0.01153411f, 0.42464301f, -0.54124153f, -0.01152930f, 0.16656740f, 
    -0.34149423f, -0.35390887f, -0.08720724f, 0.22256288f, -0.15823019f, 0.04364387f, 0.24215706f, 0.06485908f, 
    -0.16477731f, -0.00973207f, 0.07645705f, 0.00071122f, 0.29594558f, 0.08901013f, 0.23481175f, 0.02896041f, 
    0.13824932f, -0.01701625f, 0.00231741f, 0.22559513f, -0.04568421f, -0.15022624f, 0.00981512f, -0.36759004f, 
    0.17466936f, 0.09277671f, 0.04892873f, -0.24668661f, -0.12521660f, -0.04321997f, -0.28283039f, 0.07837205f, 
    0.32683489f, 0.93636894f, -0.03806832f, -0.11991963f, -0.58256996f, -0.87549639f, 0.18572973f, 0.18740216f, 
    0.13227507f, 0.09053599f, 0.18423373f, -0.02839159f, -0.19983974f, -0.27622887f, -0.14320922f, 0.10566811f, 
    -0.09781852f, -0.01615849f, 0.00027055f, 0.09912486f, -0.03842900f, -0.07201713f, 0.14819901f, -0.18988024f, 
    -0.29278004f, -0.32842705f, -0.99878424f, -0.76633340f, 0.09622957f, 0.73932838f, 0.49277690f, -0.35400793f, 
    -0.71267730f, -0.57964081f, 0.60436040f, 0.46961847f, 0.47058427f, 0.26581812f, -0.03388934f, 0.00125674f, 
    -0.08198775f, -0.22743927f, -0.00329394f, -0.12818725f, -0.26046208f, -0.06397399f, 0.26612437f, -0.16341290f, 
    -0.26467669f, 0.09382574f, 0.16699167f, -0.67423505f, -0.14132124f, -0.08071157f, 0.35008231f, 0.47048309f, 
    0.26701218f, -0.39662936f, -0.10648487f, 0.41524115f, 0.20918432f, -0.32728210f, 0.02766652f, -0.35768944f, 
    -0.00441746f, -0.09072181f, 0.00452454f, 0.17168806f, 0.11288694f, -0.08657452f, 0.21360955f, -0.33272928f, 
    -0.14250551f, 0.13000232f, -0.10117458f, -0.05751017f, 0.50387853f, -0.83126807f, -0.29251030f, 0.27692813f, 
    0.50323325f, 0.17368203f, -0.12924230f, -0.38674563f, 0.19839884f, -0.03994578f, 0.29290116f, 0.09186418f, 
    -0.12929749f, -0.37882099f, 0.17092763f, -0.13769041f, 0.04179725f, 0.20258448f, 0.23390450f, 0.17598833f, 
    0.10990828f, -0.31920218f, -0.30209690f, -0.06373700f, -0.13535497f, -0.04688667f, -0.04293719f, -0.59694880f, 
    -0.52057117f, -0.36015892f, -0.44326669f, -0.14048152f, 0.04019915f, -0.41856405f, -0.55143064f, 0.29503340f, 
    -0.39318958f, -0.20016071f, -0.06160036f, -0.10940748f, -0.13218796f, 0.06692671f, -0.30673376f, -0.22005779f, 
    -0.39612666f, -0.07976697f, -0.23911729f, -0.18551844f, 0.29626450f, 0.14722143f, 0.69283611f, 0.95829278f, 
    -0.56025243f, -0.92504686f, -0.63915223f, 0.13722201f, 0.25298759f, -0.22556138f, -0.49475181f, -0.11410190f, 
    0.15875062f, 0.24962664f, 0.12491185f, 0.00186874f, 0.29720423f, 0.04090174f, -0.51442045f, 0.02060758f, 
    0.07958759f, -0.27869719f, 0.32274345f, -0.07910795f, -0.23425166f, -0.03176553f, 0.23739049f, 0.78764623f, 
    -0.28356358f, -0.96101725f, -0.43298101f, 0.07739650f, 0.56323016f, 0.60300285f, 0.47324330f, -0.06289886f, 
    -0.42703527f, -0.12807551f, 0.49864677f, -0.52131301f, -0.21318565f, -0.12525785f, -0.12406556f, -0.25571066f, 
    0.14367364f, 0.08854913f, -0.26792642f, 0.24648814f, -0.02780446f, -0.17589960f, 0.06412793f, -0.07522081f, 
    -0.53629935f, -0.76045865f, -0.38011077f, -0.41375104f, -0.49440652f, 0.38019711f, 0.34526756f, 0.58803248f, 
    0.54131740f, 0.28849223f, -0.00326653f, 0.24405202f, 0.33953017f, -0.13038386f, 0.06543081f, -0.04032489f, 
    -0.17636514f, -0.14870283f, 0.08004935f, 0.18690528f, -0.13945515f, -0.13175030f, 0.23336107f, 0.06160183f, 
    0.06719497f, -0.00191643f, 0.25859487f, -0.10919323f, 0.19594464f, 0.09959668f, 0.30736756f, 0.07631624f, 
    -0.11125692f, -0.08294952f, 0.40745020f, 0.09412028f, 0.15969983f, -0.20475036f, -0.31625950f, -0.29178661f, 
    0.25676462f, 0.03945934f, -0.30627814f, -0.03008798f, -0.10411398f, -0.21342686f, -0.08583384f, 0.01353667f, 
    -0.16896157f, 0.10436870f, 0.18952855f, 0.29459503f, 0.21272844f, 0.11969151f, 0.13451186f, -0.12776853f, 
    0.12354614f, 0.30059898f, 0.17410192f, 0.25473917f, 0.09136385f, 0.32133117f, -0.11452509f, -0.13887514f, 
    0.07955989f, 0.13163824f, -0.13425393f, 0.02245446f, -0.14473198f, -0.27427098f, 0.09761174f, 0.17859878f, 
    0.05494430f, -0.23049220f, 0.02094841f, -1.10868752f, 0.86101049f, -0.23853408f, -0.77458626f, -0.23071431f, 
    -0.09507244f, -0.01256476f, 0.43459219f, 0.63027871f, 0.55278850f, 0.03057162f, -0.22817016f, -0.06083201f, 
    -0.48932883f, 0.08460839f, 0.07836820f, -0.19734982f, -0.10504199f, 0.03665155f, 0.20305784f, -0.16209421f, 
    0.05516439f, 0.08194457f, -0.02341725f, 0.29019126f, 0.58540732f, 0.82678401f, 0.37428871f, -0.15152392f, 
    0.44774309f, -0.63863879f, -0.20014620f, -0.36692643f, -0.54381120f, -0.36091864f, -0.06843247f, 0.05550541f, 
    0.13943101f, 0.20028590f, -0.00581575f, -0.04763920f, -0.12709405f, 0.22265983f, 0.16850346f, 0.26035392f, 
    -0.16707020f, 0.03973753f, 0.11768114f, 0.01940992f, 0.01382660f, -0.22945847f, 0.10714445f, 0.13145447f, 
    0.16321746f, 0.07555245f, 0.16802764f, -0.00922285f, -0.35153142f, 0.15622269f, 0.22384170f, 0.03575927f, 
    -0.12405330f, 0.50085670f, -0.33615530f, -0.32876584f, 0.12092046f, -0.25050157f, -0.12903951f, 0.08291694f, 
    0.08314402f, 0.17512873f, -0.10330383f, 0.09732589f, 0.02451638f, -0.23269890f, 0.86230195f, -0.51546961f, 
    -0.45745343f, 0.05369167f, 0.29957932f, -0.25242943f, -0.36255199f, -0.72351366f, -0.16161354f, -0.47161999f, 
    0.17720148f, 0.36419067f, 0.18167798f, -0.24435227f, 0.11017362f, -0.20368960f, -0.08587657f, 0.06299475f, 
    0.28083491f, 0.01703594f, -0.03043774f, -0.22803995f, -0.12552224f, 0.38463122f, 0.06779765f, -0.51166892f, 
    -0.34540951f, -0.23079492f, 0.18859819f, -0.40762001f, 0.22951972f, -0.16464671f, -0.02405561f, -0.07525807f, 
    0.23119600f, 0.20244732f, 0.25679618f, 0.16405949f, -0.17799890f, -0.16060068f, 0.00131344f, 0.15066697f, 
    0.01888808f, -0.09121197f, 0.17119072f, 0.27826574f, -0.01399350f, 0.03760279f, 0.17450662f, 0.00925352f, 
    -0.42132914f, -0.04861630f, 0.06976340f, 0.35595164f, 0.46620020f, 0.33995575f, 0.36576945f, 0.09185089f, 
    0.03650193f, -0.09371236f, -0.11733513f, -0.06446662f, 0.04349875f, -0.29886290f, -0.12756109f, 0.12101702f, 
    0.08608658f, -0.02145194f, 0.04540620f, -0.13151523f, 0.31785232f, 0.08357114f, -0.14673243f, -0.31899789f, 
    -0.39051297f, -0.79285657f, -0.34929311f, 0.62651044f, 0.02319976f, 0.11202548f, -0.38687471f, -0.27548951f, 
    -0.33788058f, 0.08106234f, 0.62562400f, 0.18537776f, -0.36665827f, -0.09326331f, 0.31423417f, 0.28191620f, 
    -0.24416627f, -0.17414397f, 0.07787322f, -0.22099237f, -0.18212350f, 0.13262036f, 0.26952097f, 0.03266493f, 
    0.25440285f, 0.20772244f, -0.78693885f, -0.78275305f, -0.49432671f, -0.23576488f, -0.06876297f, 0.25242916f, 
    0.15092918f, 0.24389003f, 0.49724394f, 0.63595015f, 0.21486154f, 0.16404405f, -0.05170967f, 0.14194733f, 
    -0.04225200f, -0.21215233f, 0.00867571f, 0.01020877f, 0.25633559f, -0.17297800f, -0.18193018f, -0.08236455f, 
    -0.03875381f, 0.19582744f, -0.20943901f, -0.59855920f, 0.14995357f, -0.25430822f, -0.63750309f, -0.64610487f, 
    0.03755203f, 0.10372471f, -0.11435135f, -0.02233029f, 0.32463819f, -0.21669531f, 0.67270190f, -0.42184830f, 
    -0.05916654f, -0.38763300f, -0.37296185f, -0.53669578f, 0.31035468f, -0.37810600f, 0.05975224f, 0.01654813f, 
    0.01620930f, 0.10021541f, 0.13872416f, 0.32462958f, -0.31386170f, -0.68335474f, 0.18197097f, 0.21041203f, 
    0.60128629f, 0.03843093f, -0.44827527f, -0.34428838f, -0.08221494f, 0.50516921f, -0.35776410f, 0.11005436f, 
    0.36050132f, -0.32675689f, 0.37704921f, -0.08345278f, -0.17467380f, 0.04768169f, 0.17143820f, -0.22204401f, 
    0.37865272f, -0.35412195f, -0.34570780f, 0.33428007f, 0.03802963f, 0.50855434f, -0.79151338f, -0.11004490f, 
    0.03650635f, -0.12102125f, 0.65709758f, 0.04909214f, -0.01167620f, 0.02819487f, 0.35420537f, -0.07098746f, 
    0.38850042f, -0.42777741f, -0.36736590f, -0.21131782f, -0.25841641f, 0.13582991f, -0.14304003f, 0.07392669f, 
    -0.34249598f, -0.06057957f, 0.08991550f, -0.12319466f, 0.09124485f, 0.40132400f, -0.23631494f, -0.28695884f, 
    -0.31232366f, -0.10389311f, 0.06702243f, 0.32320720f, -0.49528572f, -0.42867506f, -0.09021553f, -0.56639761f, 
    0.08680604f, 0.61881304f, -0.02378719f, 0.33683291f, 0.05286467f, -0.35818234f, -0.43848640f, 0.09767419f, 
    -0.39472145f, -0.30041072f, 0.11204258f, 0.26002732f, -0.37779188f, 0.05898822f, 0.36673683f, -0.54667282f, 
    0.05514264f, 0.48423666f, 0.29445660f, 0.05534175f, -0.57969093f, -0.15057868f, 0.09180612f, -0.02706621f, 
    0.22887933f, -0.00180017f, 0.22990990f, 0.06518689f, 0.03986996f, 0.10294905f, -0.01641621f, 0.02473017f, 
    -0.35599291f, -0.42399436f, -0.31047940f, 0.25528944f, 0.21203077f, 0.40147528f, 0.21408872f, -0.12626725f, 
    -0.01316714f, -0.85810608f, 0.17530860f, 0.60731536f, -0.12821569f, -0.56943244f, -0.27498201f, -0.25893953f, 
    0.66187292f, -0.34076962f, 0.16732393f, 0.24649876f, -0.03838764f, 0.03842981f, -0.13089399f, -0.18140112f, 
    -0.38658977f, 0.36524335f, 0.05810670f, -0.24948917f, -0.37846807f, -0.28710052f, -0.12712835f, 0.20959044f, 
    0.24735798f, 0.00161715f, -0.27770394f, -0.09078760f, -0.91229576f, -0.51493418f, -0.04970640f, 0.17050095f, 
    0.26229370f, 0.39803061f, 0.09225261f, -0.11999290f, 0.03775857f, 0.16358447f, -0.02804556f, -0.10948705f, 
    -0.00752189f, -0.07461286f, 0.06383086f, 0.07611593f, -0.13280684f, 0.04913908f, -0.25096712f, -0.15087281f, 
    -0.00730810f, -0.17603385f, 0.54408419f, 0.62944824f, 0.52535772f, -0.52481437f, -0.64166570f, -0.36067915f, 
    0.21579584f, -0.08792166f, 0.13335794f, -0.55619472f, -0.17029612f, -0.14202727f, 0.20367846f, -0.09223241f, 
    0.19855140f, 0.17701973f, 0.32165760f, -0.19274049f, -0.03148563f, -0.06043379f, -0.27683154f, 0.17028145f, 
    0.19356886f, -0.12593269f, 0.09519573f, -0.03842590f, 0.36822665f, -0.26410067f, -0.75984669f, -0.89516193f, 
    0.45088795f, 0.28271869f, 0.20728599f, 0.31238496f, -0.66210890f, -0.54438376f, -0.24502775f, -0.09760549f, 
    -0.03138191f, -0.11952081f, 0.16137217f, -0.39733997f, -0.22671743f, -0.19283810f, 0.03206703f, -0.10060277f, 
    0.05925750f, 0.16585208f, -0.20440225f, -0.15607941f, 0.41771340f, -0.48354930f, 0.03946514f, 0.39327168f, 
    -0.40258649f, 0.05480143f, -0.12597859f, -0.01083739f, 0.44735679f, -0.35975936f, 0.41395271f, -0.60468650f, 
    -0.15334980f, 0.18116614f, 0.12542365f, -0.31867617f, 0.03416511f, 0.12794128f, -0.19618733f, 0.28363717f, 
    -0.05892408f, -0.03134222f, 0.26466021f, -0.17255221f, -0.04897354f, 0.38682032f, -0.54322183f, 0.06183433f, 
    0.32179382f, -0.06708405f, 0.05995420f, -0.03287567f, 0.22675315f, -0.42626020f, -0.20725106f, -0.14303322f, 
    -0.25070083f, 0.53534842f, -0.47524402f, 0.23115095f, -0.38379940f, 0.10387479f, 0.36631101f, -0.29902956f, 
    0.14851582f, -0.03814613f, -0.03980039f, -0.15976360f, 0.32232082f, 0.23285808f, 0.22187816f, -0.00020778f, 
    -0.19636843f, -0.28890985f, 0.16970553f, 0.25353101f, -0.00148209f, -0.40302467f, 0.27832708f, 0.36586976f, 
    0.36097321f, -0.16853230f, -0.21756788f, 0.12141022f, -0.04295089f, -0.15726666f, -0.10438943f, 0.30910543f, 
    0.10278015f, -0.11728150f, -0.00427997f, 0.10675326f, -0.08644979f, -0.16104081f, 0.23419504f, -0.86357927f, 
    0.55507803f, -0.16094561f, -0.59970623f, -0.53784633f, -0.12166987f, 0.37439370f, -0.04631360f, 0.39076450f, 
    0.43554407f, -0.00151316f, -0.01500235f, -0.06016900f, -0.37610343f, 0.12248686f, 0.18421188f, 0.22226785f, 
    -0.04244361f, 0.27032819f, 0.14494048f, -0.18802485f, -0.32715520f, -0.18185385f, -0.09518819f, -0.34522632f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10267644f, -0.07469317f, -0.13730681f, -0.12055761f, 0.26682949f, 0.12439640f, 0.03669950f, -0.31348649f, 
    0.20821327f, -0.28203923f, 0.19596957f, -0.08224610f, 0.08002063f, 0.13079533f, -0.22507934f, -0.04102074f, 
    0.03845178f, -0.02457830f, -0.06242041f, -0.20475662f, 0.29590768f, 0.09112829f, 0.01340369f, 0.10947326f, 
    -0.01617069f, 0.18948574f, 0.07507437f, 0.03967403f, -0.18879870f, 0.13007849f, 0.08903226f, 0.00987297f, 
    0.04110144f, 0.15664180f, 0.14717768f, 0.08239646f, -0.02418066f, -0.33706236f, 0.36260989f, -0.02369662f, 
    -0.09155481f, 0.17414096f, -0.10615705f, 0.20874366f, 0.08426956f, -0.18994360f, 0.02300768f, -0.07679428f, 
    -0.08497562f, 0.12540185f, -0.13766144f, -0.01138798f, 0.39249277f, 0.06940430f, 0.02012600f, 0.00200376f, 
    0.19841102f, 0.10298839f, 0.18773749f, -0.23975554f, 0.22477171f, 0.13173984f, -0.01275063f, -0.08763550f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08686028f, 0.07489406f, 0.05233346f, -0.01621593f, -0.04859737f, 0.09637441f, -0.01403514f, 0.00497057f, 
    0.09108442f, -0.04749570f, 0.00287688f, 0.07310607f, 0.26026377f, 0.19174822f, -0.07492276f, -0.16265769f, 
    0.05416527f, 0.02792225f, 0.02629855f, -0.13856313f, 0.00331748f, -0.04977550f, 0.11640526f, 0.06895842f, 
    0.05145783f, 0.11540750f, 0.06551310f, -0.07403928f, 0.06735799f, 0.13535026f, 0.12020514f, 0.07264294f, 
    0.06628895f, 0.01518741f, 0.10238001f, 0.02055997f, -0.22188066f, -0.23253219f, -0.26730943f, 0.06612933f, 
    -0.23564409f, 0.11195274f, 0.21915101f, 0.01882632f, 0.06199275f, -0.15346912f, 0.05560695f, -0.09843684f, 
    0.54987091f, 0.16407701f, 0.08169500f, -0.37952974f, 0.04282962f, -0.03652415f, -0.19592817f, -0.03591610f, 
    0.16785452f, -0.08043194f, 0.01145891f, 0.17011727f, 0.03219069f, -0.26384446f, -0.03658033f, -0.09353966f, 
    0.07940760f, 0.03806594f, -0.07874574f, 0.15771009f, 0.05600298f, -0.01413421f, 0.05456192f, 0.01932355f, 
    0.20796749f, -0.05648270f, 0.16929896f, -0.01407402f, -0.05633483f, 0.05635104f, 0.05489824f, 0.14991832f, 
    0.05893275f, 0.01259229f, -0.04196935f, 0.09688886f, 0.00025384f, 0.30170444f, 0.16597003f, -0.16419868f, 
    0.12206157f, -0.00801525f, -0.00739268f, 0.08111185f, -0.02819122f, -0.03717748f, 0.11542974f, -0.02830940f, 
    -0.08022934f, -0.23099789f, -0.49521950f, -0.15094769f, -0.04899250f, 0.04519289f, 0.12356489f, -0.13283031f, 
    0.11535412f, -0.09448965f, -0.05999149f, 0.02795853f, -0.17558289f, 0.21951467f, -0.06604522f, -0.05503562f, 
    -0.04695229f, -0.02724601f, 0.02524363f, -0.05581971f, 0.12143269f, -0.05186286f, 0.01944812f, -0.04185737f, 
    0.08467474f, -0.23968454f, -0.07307066f, 0.00272766f, 0.30587706f, 0.19905800f, -0.10888293f, 0.09029316f, 
    0.11580940f, 0.10639147f, -0.05961532f, -0.11491342f, 0.07805265f, 0.12500167f, 0.13335671f, -0.25729460f, 
    0.04072159f, 0.06178492f, -0.14375356f, -0.03397886f, 0.07715014f, 0.01458646f, -0.00627207f, 0.07146675f, 
    0.03940585f, 0.08536817f, 0.17138918f, -0.13035433f, 0.12312508f, 0.03471423f, 0.11228325f, -0.01365177f, 
    0.03971419f, -0.02834245f, -0.07459933f, 0.03476068f, 0.25034708f, -0.04955774f, -0.20210327f, 0.02157459f, 
    0.02127511f, -0.04197531f, 0.06970397f, -0.11917201f, -0.02443895f, 0.01474674f, 0.16883408f, 0.11771432f, 
    -0.06053587f, 0.06376869f, 0.20467922f, 0.05291327f, 0.00014157f, 0.12719606f, 0.04156288f, 0.12269349f, 
    0.04689978f, 0.07148567f, -0.01639202f, 0.09294393f, 0.06003485f, 0.05530404f, -0.43628189f, -0.33356217f, 
    -0.06986240f, 0.12817848f, -0.00508159f, -0.09612274f, 0.18808912f, -0.05437005f, 0.05305295f, -0.04337780f, 
    0.06082282f, -0.17018689f, -0.11260783f, -0.01131819f, 0.00646652f, -0.03216100f, 0.09658246f, -0.10302512f, 
    -0.00472367f, -0.08306898f, 0.10010044f, 0.13097547f, 0.01668550f, -0.08933536f, -0.06939767f, -0.02693825f, 
    0.01428175f, 0.03173518f, -0.00904487f, 0.05395774f, 0.01045723f, 0.05135437f, 0.05230830f, -0.01443908f, 
    0.25314677f, 0.12519407f, -0.25392422f, -0.40339845f, 0.11659815f, -0.15607925f, 0.01991427f, 0.00272058f, 
    0.11911934f, -0.08038364f, -0.09824441f, -0.08176516f, -0.10114808f, -0.20529827f, -0.19345453f, -0.03850896f, 
    0.09076107f, 0.03256672f, 0.08592749f, -0.05390397f, -0.02367520f, -0.00006851f, 0.09872229f, 0.10988078f, 
    0.31419018f, 0.11139957f, -0.19444159f, -0.31808642f, 0.08392872f, -0.19690493f, 0.09222246f, 0.00978311f, 
    0.15871648f, 0.03432091f, -0.15164365f, 0.10773192f, -0.06185431f, 0.03376679f, -0.45172855f, -0.11239636f, 
    0.02572577f, 0.08941864f, 0.19485286f, 0.06121382f, 0.20507677f, 0.04699394f, -0.10106666f, 0.07910573f, 
    0.10792758f, 0.20427899f, 0.30384916f, -0.03844589f, 0.01555220f, -0.00948935f, -0.04324184f, -0.02386996f, 
    0.09388047f, 0.14212929f, 0.13894047f, 0.08641973f, 0.18348488f, -0.08624882f, 0.07578915f, -0.10007467f, 
    0.20101967f, 0.10828757f, -0.02604914f, -0.06697063f, 0.08919670f, 0.00233136f, 0.12198851f, -0.00839603f, 
    -0.08374026f, -0.44128671f, -0.09795460f, -0.12715015f, 0.07655066f, 0.10153337f, 0.13401902f, 0.11252039f, 
    0.11802725f, -0.09177807f, -0.09192539f, -0.00470254f, -0.43618611f, -0.09135093f, -0.15260181f, 0.24799201f, 
    0.02429109f, -0.06311046f, 0.00613480f, -0.00643337f, -0.07682872f, -0.13731639f, 0.00337864f, -0.08623830f, 
    -0.45214427f, 0.14395456f, 0.27411851f, 0.16553666f, -0.18103763f, -0.16625215f, 0.01351868f, 0.05043334f, 
    0.17975558f, -0.09287398f, -0.03305645f, 0.03495330f, -0.22060698f, 0.16921405f, 0.24646625f, 0.10331156f, 
    -0.07908796f, 0.05612344f, 0.10647721f, 0.09703790f, 0.18943357f, 0.01944406f, 0.05168809f, 0.25807750f, 
    -0.14760835f, 0.10737649f, 0.04536331f, -0.04707711f, 0.00969102f, 0.03769235f, 0.06478002f, 0.03343489f, 
    0.03186801f, -0.01432759f, 0.02377523f, 0.00761113f, -0.02501293f, 0.04464858f, 0.05218999f, 0.08334564f, 
    -0.10047931f, 0.04248003f, -0.11010791f, -0.03237782f, 0.32589561f, 0.03959057f, -0.02428480f, -0.03111747f, 
    -0.12455688f, -0.46661952f, 0.01744607f, 0.09925307f, -0.06058987f, 0.04763032f, -0.04849374f, -0.05151701f, 
    0.18655249f, 0.01658208f, -0.04177238f, 0.00086983f, 0.08525209f, -0.12889595f, 0.28713444f, 0.55370039f, 
    -0.13282546f, -0.11062758f, -0.16053711f, -0.03935005f, 0.01921134f, 0.11863161f, -0.03189386f, 0.02068098f, 
    0.03151235f, -0.08717584f, 0.15027221f, 0.15605333f, 0.01467526f, -0.05991361f, -0.07484195f, 0.03810490f, 
    0.07345018f, 0.02869564f, 0.01163659f, 0.04223748f, 0.32571518f, 0.17962591f, 0.04835478f, -0.25744185f, 
    0.08079082f, -0.12934959f, 0.14531074f, 0.08022982f, 0.11179768f, 0.02149407f, 0.19856893f, 0.19548950f, 
    -0.16781861f, 0.06530154f, 0.33447793f, 0.16938676f, 0.14817390f, 0.13037220f, -0.02804212f, -0.01938327f, 
    0.07476348f, -0.02990732f, -0.02982960f, 0.13763990f, -0.08142638f, -0.13051485f, 0.10882810f, 0.25540170f, 
    -0.04969721f, -0.08248635f, 0.01227174f, -0.01481014f, 0.04108765f, 0.04470219f, 0.01019964f, 0.03766185f, 
    0.00335081f, -0.45296362f, 0.02913202f, -0.06743383f, 0.11977922f, -0.13162251f, 0.01433168f, 0.05503685f, 
    0.20258686f, 0.05711743f, -0.00643599f, 0.09786452f, 0.04030229f, 0.31945115f, 0.11182459f, -0.19578204f, 
    0.10133680f, -0.00877013f, -0.10606392f, -0.00668098f, -0.10335322f, -0.04182690f, 0.02113427f, -0.02690414f, 
    0.32983780f, 0.32326356f, -0.18210739f, -0.60945296f, 0.01689533f, 0.00469768f, 0.17708023f, -0.06558537f, 
    0.12953623f, 0.04304952f, -0.03544635f, -0.01991088f, -0.01590408f, -0.10220094f, 0.19271685f, -0.50475872f, 
    0.00908271f, -0.15357190f, -0.16716993f, -0.00773557f, 0.13314904f, 0.08021940f, -0.02649315f, 0.07054004f, 
    -0.09071231f, 0.54034597f, 0.28351268f, 0.17150120f, -0.20668817f, -0.22943610f, -0.15338418f, -0.05433945f, 
    0.00218199f, -0.12955065f, 0.06971153f, 0.13920048f, 0.23086677f, -0.31067407f, 0.09997533f, 0.03327741f, 
    0.00264557f, -0.01604178f, 0.02951725f, 0.07249992f, 0.07693586f, 0.01838085f, 0.08946881f, 0.05807291f, 
    -0.11871564f, -0.14212529f, -0.21018007f, -0.02232024f, 0.03085673f, 0.00296212f, 0.02893220f, 0.03481603f, 
    0.21909548f, -0.01223334f, 0.05690889f, 0.12976709f, -0.56375456f, 0.11700901f, 0.06209992f, 0.33280146f, 
    -0.21779270f, -0.18086223f, -0.07445913f, 0.04175425f, 0.17216890f, -0.02132280f, -0.03298127f, 0.01552507f, 
    -0.33633775f, -0.29255503f, -0.59161729f, -0.05376517f, 0.06441655f, 0.08670618f, 0.21140569f, -0.14997423f, 
    0.01163251f, -0.06653547f, -0.11305065f, -0.09023747f, -0.08392594f, -0.42652315f, -0.14748837f, 0.20998238f, 
    -0.00726456f, -0.05802072f, 0.07828501f, -0.02050352f, 0.06676224f, 0.01549083f, -0.09120941f, -0.00459142f, 
    0.05635150f, -0.07464822f, -0.02736804f, -0.52182561f, -0.01705400f, 0.14090317f, 0.09521792f, -0.25183108f, 
    0.13196851f, 0.02129073f, -0.03472943f, 0.02949136f, 0.02089691f, 0.08030025f, 0.19392341f, -0.08742459f, 
    -0.06199735f, -0.02489498f, 0.09385726f, -0.08601797f, 0.18016031f, -0.05163267f, -0.01324769f, -0.01681414f, 
    -0.04936277f, -0.07590713f, 0.19093339f, 0.16150874f, 0.01271066f, -0.15827557f, -0.13476656f, 0.05953271f, 
    0.18238847f, 0.09127011f, 0.12803739f, 0.12433303f, -0.20592095f, -0.03267197f, 0.11179321f, 0.07306975f, 
    0.03427505f, -0.01568210f, -0.08469220f, 0.19591431f, -0.01093467f, -0.04625215f, -0.05504248f, 0.04913642f, 
    -0.16364171f, 0.42566854f, 0.47648820f, 0.28419888f, -0.20107467f, -0.18200646f, -0.09964930f, -0.03675092f, 
    0.05625540f, -0.10728811f, 0.13811795f, 0.21451138f, 0.00303008f, 0.09198170f, 0.09438581f, -0.11409419f, 
    -0.06734221f, 0.01948021f, 0.09336021f, 0.08265724f, -0.06974739f, -0.11474109f, -0.08448862f, -0.07706631f, 
    0.12614994f, -0.17311309f, 0.13802677f, 0.18161103f, -0.04780395f, 0.07391608f, 0.08603571f, 0.25878805f, 
    0.03969061f, -0.00049373f, 0.16847147f, 0.00343436f, 0.27658334f, -0.13257508f, 0.21967617f, -0.07340115f, 
    -0.15898514f, -0.06051725f, -0.11963759f, -0.03546913f, 0.10882989f, 0.08373427f, -0.03479477f, -0.00870915f, 
    0.16973627f, 0.21426114f, 0.02916379f, -0.21357770f, 0.16324626f, -0.04843008f, 0.07471856f, -0.16805395f, 
    0.07932995f, -0.10104754f, 0.02527276f, -0.02683884f, -0.31592152f, -0.24032754f, 0.05097326f, 0.16820712f, 
    0.07960402f, 0.20519046f, 0.04852051f, 0.05327975f, -0.01017726f, -0.15015455f, -0.17697774f, -0.14389689f, 
    -0.15644431f, 0.05978591f, -0.00293626f, -0.09334861f, -0.06062369f, 0.14919783f, 0.02770827f, -0.00026181f, 
    0.10302053f, 0.03613250f, 0.02932485f, -0.07878978f, 0.05084798f, 0.43623272f, 0.13028283f, 0.08843352f, 
    -0.13456425f, -0.12826756f, -0.02393175f, 0.03328585f, 0.00959314f, -0.00081521f, 0.08430316f, 0.09277706f, 
    0.03919679f, 0.08313656f, -0.45611420f, -0.20283301f, -0.08813980f, 0.01174912f, 0.16083121f, -0.02747160f, 
    0.15640491f, 0.04498663f, -0.03175173f, 0.02478572f, -0.19717135f, 0.11987168f, -0.18434335f, -0.20484646f, 
    0.21393600f, -0.08305228f, -0.05000278f, -0.01233766f, -0.00820606f, 0.01031906f, 0.06870159f, 0.01499646f, 
    0.18005961f, -0.15075131f, -0.20168166f, -0.25163403f, 0.06077122f, -0.18279381f, 0.03862321f, 0.02576225f, 
    0.18945162f, -0.00937609f, -0.04732100f, -0.03220135f, 0.11777191f, -0.34665304f, -0.10279313f, -0.10638940f, 
    0.05132574f, 0.13253476f, 0.19798712f, -0.00328046f, -0.02164024f, -0.14232220f, -0.10478885f, -0.09564669f, 
    0.19570433f, -0.06158301f, 0.00746505f, -0.08472864f, 0.07665446f, -0.12878065f, 0.05558153f, 0.02210004f, 
    0.06477533f, 0.00062015f, -0.03461309f, 0.04267847f, -0.27161860f, 0.19360553f, 0.00863215f, 0.12714495f, 
    -0.13589562f, -0.02168220f, -0.03107607f, 0.11724894f, 0.08181246f, 0.10008571f, 0.16443668f, 0.04403552f, 
    -0.01657328f, -0.01018400f, 0.01127727f, 0.00879066f, 0.00422019f, -0.00781400f, 0.01671821f, -0.00488395f, 
    0.00145440f, -0.01432902f, 0.02764959f, -0.00706684f, -0.03073781f, -0.01208782f, -0.00315818f, -0.00546456f, 
    -0.00985881f, 0.00993570f, -0.00259815f, 0.00936611f, -0.02562836f, 0.00452075f, -0.03371793f, -0.02980232f, 
    -0.03241784f, -0.01063095f, -0.00178077f, 0.00246036f, -0.01409107f, -0.02637079f, 0.02782484f, -0.00416949f, 
    -0.02732190f, -0.01788416f, 0.00767392f, 0.01173213f, -0.00700035f, -0.03377800f, -0.00946740f, 0.00671937f, 
    0.00350950f, 0.00325655f, 0.00920809f, 0.00126613f, -0.03358601f, 0.00456176f, -0.00046582f, 0.01352389f, 
    -0.03524131f, -0.00354484f, 0.01908629f, 0.02029197f, -0.03551034f, 0.00177436f, -0.03941752f, 0.00289637f, 
    -0.03371738f, 0.01795160f, 0.01213224f, -0.00020953f, -0.00099544f, 0.00363473f, -0.02157256f, 0.00500585f, 
    -0.00875741f, -0.01616445f, -0.02100719f, 0.01623736f, -0.01079338f, 0.00156888f, -0.02529321f, -0.03092724f, 
    -0.01794707f, -0.02647268f, -0.01010442f, -0.00807837f, -0.02617572f, 0.00932208f, 0.01496143f, -0.03143157f, 
    -0.02511133f, -0.01700899f, -0.02979638f, -0.00561096f, -0.03156089f, 0.02626630f, -0.01964248f, 0.01518049f, 
    0.02421833f, -0.01209281f, -0.00972882f, 0.00795378f, 0.00349675f, 0.01502607f, 0.00062366f, -0.00072724f, 
    -0.04172393f, -0.03815354f, 0.00004456f, -0.02889958f, -0.00695513f, -0.03782433f, -0.01273382f, 0.02032516f, 
    -0.01309093f, -0.00923779f, -0.01955057f, 0.00803726f, -0.00578935f, 0.01888214f, 0.02154102f, -0.03432489f, 
    0.02178191f, 0.00554299f, 0.03310408f, 0.03532958f, -0.00595037f, 0.03192683f, -0.02285657f, 0.03356482f, 
    -0.00884688f, -0.01759897f, -0.02104529f, 0.00071888f, 0.01897665f, -0.00217186f, -0.00428813f, 0.02557061f, 
    0.02768326f, -0.03245160f, -0.03730794f, -0.02269452f, -0.01027726f, -0.03155733f, 0.00822714f, 0.00263850f, 
    0.01175297f, 0.01270487f, -0.02569413f, 0.00101367f, -0.01348900f, -0.01528529f, -0.02500010f, -0.01755281f, 
    -0.02968246f, -0.02126563f, -0.01754363f, 0.01407467f, -0.02995620f, 0.02323695f, 0.00506334f, -0.02137442f, 
    -0.02931337f, 0.00951814f, -0.01843728f, 0.00333816f, -0.02233225f, 0.03462175f, -0.00595612f, 0.02314570f, 
    -0.00650805f, -0.04165957f, -0.02956621f, -0.01317364f, -0.01359432f, -0.00429318f, -0.02765977f, 0.01711878f, 
    0.01939972f, 0.02537325f, 0.01835594f, -0.00363014f, -0.02600744f, 0.01512531f, -0.03005653f, -0.02743573f, 
    -0.00554363f, 0.00230966f, -0.01107573f, -0.03264578f, -0.03548463f, -0.00003765f, -0.00313887f, 0.00750072f, 
    0.02459582f, 0.01059298f, 0.00198984f, -0.02297987f, 0.00431720f, 0.02760354f, -0.03186806f, 0.02449522f, 
    0.02218599f, 0.01434653f, -0.01440745f, 0.00867374f, -0.03175091f, 0.00926849f, 0.00227056f, 0.02649668f, 
    -0.02734231f, -0.02204325f, 0.02801347f, 0.01283823f, -0.03100376f, -0.01918698f, 0.01529393f, -0.00608899f, 
    -0.00715441f, -0.03508877f, 0.00475576f, 0.01468247f, 0.01688554f, -0.04093330f, -0.02094242f, 0.01636516f, 
    0.01541661f, -0.00081607f, -0.01881650f, -0.01120422f, 0.00097193f, 0.00299970f, -0.04188493f, 0.02458997f, 
    -0.02148427f, 0.02685162f, 0.01323622f, -0.01177479f, 0.01065074f, -0.02626254f, 0.00882888f, -0.03254968f, 
    -0.03383395f, 0.02333810f, -0.03269085f, -0.02767361f, 0.00313033f, -0.00700757f, 0.02158306f, -0.00556442f, 
    -0.03171355f, 0.02474459f, -0.03849183f, -0.02446750f, -0.03292033f, -0.02935747f, -0.01173230f, -0.00222806f, 
    -0.00307855f, -0.03403228f, -0.00546373f, 0.02576911f, -0.01784574f, 0.02725983f, 0.01682840f, 0.00849700f, 
    -0.00773502f, -0.02253490f, -0.00681340f, -0.01853779f, 0.02838046f, 0.00832049f, -0.03996757f, 0.01249128f, 
    -0.02250247f, -0.00752305f, -0.04162360f, 0.00280738f, -0.01210124f, 0.00039308f, -0.00598998f, 0.01484099f, 
    -0.03386764f, -0.01837990f, -0.01540565f, -0.02913674f, 0.01681838f, -0.03545902f, -0.00060383f, -0.03332091f, 
    -0.01106173f, 0.00285482f, 0.00508221f, -0.00117181f, -0.03524751f, 0.02398223f, -0.01564055f, 0.03507977f, 
    -0.03038656f, -0.03153199f, 0.01147084f, 0.01200077f, 0.01281348f, 0.02707480f, -0.00735960f, -0.00927478f, 
    -0.03555167f, 0.02971394f, -0.00593254f, -0.02925816f, 0.01302625f, -0.01432985f, -0.03650265f, -0.02578782f, 
    0.02755098f, -0.01817205f, -0.01296512f, -0.01536722f, 0.00127913f, 0.02247461f, 0.00368514f, 0.02533432f, 
    -0.02017569f, 0.01629657f, 0.01087068f, -0.00052876f, -0.03425174f, -0.02233825f, -0.03372791f, -0.00732962f, 
    0.00214252f, -0.00803364f, 0.02125039f, -0.01204970f, -0.03880049f, -0.03144513f, 0.00866322f, -0.01326775f, 
    0.00024014f, -0.01728648f, 0.01968872f, -0.02892881f, -0.01924386f, 0.01383322f, -0.02559816f, -0.04134426f, 
    -0.02112085f, 0.00149822f, -0.01678510f, -0.01378711f, -0.03221819f, -0.02180774f, 0.00232542f, 0.02642062f, 
    0.03386709f, -0.01993647f, 0.03608414f, -0.02837628f, -0.00458318f, 0.02539628f, 0.01112140f, -0.00668137f, 
    -0.01058274f, -0.01275622f, -0.03915143f, 0.01995421f, -0.00765595f, 0.02870769f, 0.00377489f, 0.00782008f, 
    -0.03898166f, -0.01962769f, -0.01799273f, 0.02379933f, -0.03770529f, 0.02641843f, -0.04002401f, -0.03901785f, 
    -0.03035174f, -0.04107095f, 0.01628738f, -0.00470436f, 0.01613301f, -0.03172355f, 0.00544973f, -0.02836762f, 
    -0.02062221f, 0.02386305f, 0.01042397f, 0.02717476f, 0.01536217f, 0.02209342f, -0.03691468f, -0.03630700f, 
    0.00175362f, -0.03602335f, -0.03575904f, -0.00597965f, 0.02506499f, 0.00767756f, -0.01236603f, 0.01533098f, 
    0.01627420f, -0.03500584f, -0.02320875f, -0.02177294f, 0.01979540f, -0.01266366f, -0.02614880f, 0.02120409f, 
    0.01925929f, -0.03825829f, -0.01678010f, -0.00030538f, -0.01828139f, 0.00665431f, -0.03987251f, 0.00600960f, 
    -0.01444054f, -0.02151372f, -0.01342356f, -0.03005238f, 0.01542197f, 0.00696921f, -0.00671726f, 0.01098011f, 
    -0.00390471f, -0.04031236f, -0.02318608f, -0.04013533f, -0.03346178f, -0.02881828f, -0.02225589f, 0.02708064f, 
    0.00811698f, 0.02246370f, 0.02083646f, -0.01629628f, -0.00708414f, 0.01667677f, 0.02377662f, 0.00368631f, 
    -0.00271072f, 0.00590660f, 0.00145436f, 0.02517112f, -0.02318295f, -0.01857648f, -0.01099371f, 0.02431384f, 
    -0.00819842f, 0.00627333f, 0.00983037f, 0.01901226f, -0.00990573f, -0.00812170f, 0.02614553f, 0.02668401f, 
    0.02419353f, 0.01925105f, 0.01349143f, 0.02450200f, 0.01550350f, 0.03153461f, -0.02030129f, -0.02701650f, 
    0.00159818f, 0.02790710f, -0.03051637f, 0.02485393f, 0.00297984f, -0.03223567f, 0.00594871f, -0.03339506f, 
    0.01598344f, -0.02973558f, -0.00715317f, -0.01896329f, 0.02226210f, 0.01432953f, -0.02023038f, -0.04027336f, 
    -0.02941475f, 0.00834294f, 0.02141829f, -0.02745190f, 0.01080760f, 0.01687352f, 0.00108069f, 0.00355839f, 
    -0.02980609f, -0.01209042f, -0.03353626f, 0.02351018f, -0.02050177f, 0.02325440f, -0.00413972f, 0.01385824f, 
    -0.03449960f, -0.00020541f, 0.01837561f, 0.01279613f, -0.00507011f, -0.01613140f, 0.02116648f, 0.00734845f, 
    0.01641185f, -0.03308646f, -0.04166051f, 0.02255127f, -0.01926398f, -0.02911791f, -0.03527807f, 0.02962973f, 
    0.02082255f, -0.02272307f, 0.01733065f, -0.03679637f, 0.01951112f, 0.00648599f, 0.01650769f, -0.00489985f, 
    0.01448978f, 0.00042248f, 0.01445060f, 0.02198701f, -0.04034276f, 0.01491797f, -0.02832453f, -0.02378445f, 
    -0.00117305f, 0.01470716f, -0.02665034f, -0.01280788f, -0.03419573f, -0.02573384f, -0.01070508f, -0.03204530f, 
    -0.02152868f, 0.02956034f, 0.00244748f, 0.02245217f, 0.01626395f, -0.00145305f, 0.00935972f, -0.03940165f, 
    0.02568976f, 0.02285564f, -0.01233647f, -0.02165482f, -0.00758238f, 0.02646941f, 0.02621325f, 0.02752653f, 
    0.00693616f, -0.03076827f, 0.01174948f, -0.01586816f, 0.00371290f, -0.00345433f, 0.02609707f, 0.02147776f, 
    0.01408698f, -0.00932122f, -0.03969182f, 0.00635724f, 0.00099492f, 0.01045842f, 0.02593257f, -0.00320223f, 
    0.01218841f, 0.00715297f, -0.02467128f, 0.03372898f, 0.02012601f, -0.02787762f, 0.02357637f, -0.03641229f, 
    -0.01227864f, -0.00064810f, 0.00125087f, -0.02667972f, -0.02965639f, -0.02233185f, -0.00767466f, -0.00658846f, 
    0.00574251f, 0.00971993f, 0.00615072f, 0.00034554f, -0.01945918f, -0.03971299f, 0.00519908f, -0.02058644f, 
    0.01753573f, -0.02839948f, 0.01225556f, -0.02223085f, -0.00122346f, -0.00921761f, -0.02332578f, -0.03458353f, 
    0.02695288f, -0.03650853f, -0.01776996f, -0.00452191f, -0.02654933f, 0.02271800f, -0.02663658f, -0.03321604f, 
    -0.00990130f, 0.02956898f, 0.00865199f, -0.00645326f, 0.00023970f, 0.00673827f, 0.02117739f, -0.02347667f, 
    -0.02432225f, -0.02412859f, 0.01232962f, -0.00331509f, 0.00121790f, -0.01814014f, -0.00400482f, -0.04068667f, 
    -0.01006248f, 0.00198537f, -0.04129249f, 0.00686042f, -0.02029775f, -0.02346290f, -0.01573588f, -0.01205743f, 
    -0.00793552f, -0.04136248f, -0.01920067f, 0.01406335f, 0.00415540f, 0.01174496f, -0.02600289f, -0.00852121f, 
    0.01135399f, -0.02522321f, -0.03062092f, -0.02266395f, -0.02650267f, 0.02781785f, 0.02078985f, -0.01115250f, 
    0.01441628f, -0.02940728f, 0.00979681f, -0.00944140f, -0.03913552f, 0.01118621f, -0.00781026f, 0.00578352f, 
    -0.02601686f, -0.02727066f, 0.01546889f, 0.00211473f, -0.03848740f, -0.00992103f, 0.02863557f, -0.02874567f, 
    -0.01131840f, -0.03837560f, -0.01228590f, 0.01344836f, -0.01755961f, 0.02701427f, -0.03381994f, -0.00085408f, 
    0.01440567f, 0.02890263f, 0.02135195f, -0.00690888f, -0.00780034f, 0.02147663f, -0.01663971f, -0.01687477f, 
    0.00831622f, 0.02209412f, 0.00386191f, -0.01535097f, -0.01068217f, -0.01202369f, -0.02877273f, -0.00400172f, 
    0.00138861f, -0.02551161f, 0.01059804f, -0.03885546f, 0.02549110f, -0.03909194f, 0.00226987f, -0.03659893f, 
    0.01779228f, -0.01923431f, -0.02282472f, 0.00868538f, 0.02815761f, -0.03181732f, 0.02266165f, -0.03775366f, 
    -0.04170756f, -0.01580537f, 0.02594516f, 0.01364798f, 0.00165488f, -0.03747029f, -0.03651689f, -0.02905819f, 
    -0.03957815f, -0.00367072f, -0.02220705f, -0.02607019f, -0.02105129f, -0.00750606f, -0.02020241f, 0.00074796f, 
    -0.02231026f, -0.03330315f, -0.02699122f, 0.00320175f, 0.00347299f, -0.02673762f, -0.00670921f, 0.01798759f, 
    -0.02788068f, -0.02488545f, 0.00047846f, -0.03054055f, -0.00422402f, 0.01331989f, -0.00254455f, -0.02647578f, 
    -0.03629752f, 0.02156927f, -0.02916438f, 0.01165827f, 0.02596004f, 0.02655097f, -0.01680377f, -0.03533790f, 
    0.00966326f, 0.02154955f, -0.01414098f, -0.02525806f, 0.00387034f, 0.02930392f, -0.01047357f, -0.01220192f, 
    0.00568877f, -0.02548510f, -0.01588936f, -0.02209038f, 0.00132378f, 0.02109083f, 0.01582462f, -0.01191574f, 
    0.02969586f, -0.02104933f, -0.03819070f, -0.02145246f, 0.02731165f, -0.01570382f, -0.00983039f, -0.00751341f, 
    -0.02993750f, -0.03873323f, 0.02991163f, -0.01025702f, -0.04167455f, -0.00328746f, 0.00689539f, 0.01512224f, 
    -0.01877415f, 0.01881490f, -0.01307941f, -0.03779127f, 0.01020470f, -0.00168685f, -0.02143173f, -0.00791212f, 
    0.01560830f, 0.01762326f, 0.01531285f, -0.02301952f, 0.00119373f, -0.00196520f, -0.00677660f, -0.03923340f, 
    0.00595663f, 0.02573646f, -0.00588006f, 0.02820741f, 0.00050670f, -0.01266682f, -0.02191202f, -0.01475948f, 
    0.01052679f, 0.02439522f, -0.01891223f, 0.01958639f, 0.01702532f, 0.01874084f, -0.02212980f, 0.02378423f, 
    -0.02805414f, 0.01275175f, -0.02415078f, 0.01723798f, -0.03968526f, -0.02310247f, -0.03843860f, -0.01898242f, 
    -0.02837069f, -0.02450931f, -0.02661253f, 0.02317147f, 0.02991565f, 0.01698851f, -0.00300498f, 0.01525873f, 
    0.01735442f, -0.02760224f, -0.02164412f, -0.03932884f, 0.01079316f, 0.01759364f, -0.01086024f, -0.03812195f, 
    -0.03485484f, -0.02640052f, -0.03866254f, -0.01598503f, -0.03360947f, 0.02064101f, 0.01435880f, -0.02445337f, 
    -0.00328417f, -0.00317801f, -0.00780728f, 0.02863021f, 0.01647598f, 0.01967727f, -0.01818272f, 0.01985686f, 
    -0.02381517f, -0.00101597f, -0.02733923f, 0.00705845f, -0.02176214f, -0.00495234f, -0.01246143f, -0.01855886f, 
    0.01582464f, -0.01213903f, 0.02547563f, 0.02679726f, 0.01050073f, -0.02027592f, -0.02654069f, -0.00579879f, 
    -0.01608149f, 0.02581474f, -0.00733340f, 0.01118592f, 0.00902096f, 0.02265507f, 0.02579963f, 0.02103382f, 
    -0.02594163f, 0.00097236f, -0.00905876f, 0.00179332f, -0.03162323f, 0.00331140f, 0.02876514f, -0.01524851f, 
    -0.03255811f, -0.04025704f, -0.01911567f, -0.01696856f, 0.00865920f, -0.01237344f, 0.00301313f, -0.02203438f, 
    -0.03158516f, -0.02008609f, -0.02951021f, -0.00570450f, -0.02673151f, 0.02699424f, -0.04063696f, 0.01350723f, 
    0.00511698f, 0.00960059f, 0.01804169f, 0.00228633f, -0.00081660f, 0.00340637f, -0.03524007f, -0.01205964f, 
    -0.03268061f, 0.02721721f, -0.02346263f, 0.02561019f, -0.02453390f, 0.00048200f, -0.04047052f, 0.00283128f, 
    -0.00473887f, 0.00411192f, 0.02427737f, -0.01175120f, -0.02770661f, -0.02344005f, -0.00752956f, 0.02525899f, 
    -0.01712034f, 0.02170037f, -0.01419270f, -0.03415794f, -0.00132065f, -0.02883809f, 0.00287621f, 0.02706564f, 
    0.01301805f, -0.03205283f, -0.02295004f, -0.02576231f, 0.01321676f, -0.02023435f, 0.01397365f, -0.03303868f, 
    -0.03664181f, -0.00916375f, -0.00777180f, 0.01915165f, 0.00298870f, -0.02600032f, 0.02989644f, -0.03616838f, 
    -0.00758619f, 0.00603483f, -0.00134345f, 0.02243893f, -0.00866639f, -0.03986228f, 0.00352094f, 0.01601521f, 
    -0.01231225f, -0.01585118f, -0.01486727f, 0.00692685f, 0.01872416f, 0.02186348f, 0.00782179f, -0.00886410f, 
    -0.00399249f, 0.00741629f, 0.01028938f, 0.01942934f, 0.00332013f, -0.03814562f, 0.00922192f, 0.00146592f, 
    0.01213888f, 0.00180904f, -0.00109157f, 0.00582469f, -0.03960080f, -0.00573660f, -0.03838277f, 0.01126478f, 
    -0.02139989f, 0.02915883f, -0.01462410f, -0.00776002f, -0.00807356f, 0.00900369f, 0.00838036f, -0.03320849f, 
    -0.02169281f, 0.00190877f, 0.01866134f, -0.03612411f, -0.04078015f, 0.00678935f, 0.02551730f, 0.02932975f, 
    -0.01185521f, 0.00883017f, 0.01712474f, -0.00042585f, 0.00876848f, -0.01655344f, 0.02778060f, -0.00996371f, 
    0.01031726f, -0.03115670f, -0.00582913f, 0.00649530f, -0.01601203f, 0.01195299f, -0.02834531f, 0.01532389f, 
    0.04195383f, 0.01813083f, -0.03432070f, -0.01678815f, -0.00380178f, -0.02348478f, -0.02707134f, 0.02681452f, 
    0.01294618f, -0.00113913f, 0.00700842f, 0.00721216f, -0.00314780f, -0.01911143f, 0.00466237f, -0.00305295f, 
    0.02662797f, -0.00264701f, 0.00953293f, -0.03405593f, -0.00435193f, 0.02597293f, -0.04190341f, -0.00873692f, 
    -0.01225679f, -0.00144456f, 0.01629653f, 0.02699168f, 0.02456653f, 0.02585007f, 0.02137921f, 0.03989514f, 
    -0.04053799f, 0.00272111f, -0.02942540f, -0.01883659f, -0.00914535f, -0.03386310f, -0.03296827f, -0.00424412f, 
    0.01236121f, 0.01275745f, -0.00389716f, -0.03155600f, 0.01951463f, 0.00404780f, -0.02829950f, -0.01381770f, 
    -0.00308188f, -0.02334809f, 0.01002767f, 0.02629594f, -0.00532735f, 0.02416462f, -0.02532090f, -0.01119692f, 
    -0.02128786f, 0.01360975f, -0.00623904f, -0.02277129f, -0.01395756f, -0.00360972f, 0.01948694f, -0.00851992f, 
    -0.00015404f, -0.00940368f, 0.00424935f, -0.00776612f, -0.00865223f, -0.00243865f, -0.00550578f, -0.03829804f, 
    -0.02540824f, 0.01720881f, -0.00753330f, 0.00732947f, 0.02608800f, -0.01024728f, -0.00061770f, 0.02109513f, 
    -0.00900908f, -0.03511202f, -0.03868370f, 0.01900092f, -0.02460331f, 0.01502632f, 0.01001355f, 0.01753907f, 
    0.02223432f, -0.00665674f, -0.02601404f, -0.00399100f, -0.02964436f, -0.03971107f, -0.00314460f, -0.01727325f, 
    -0.03590138f, 0.00471206f, -0.04027972f, -0.01768686f, -0.03554827f, -0.00253231f, -0.03302393f, -0.02276866f, 
    0.00783172f, 0.00460433f, -0.03519151f, -0.00369283f, 0.01306602f, 0.00918909f, -0.00436695f, 0.01131832f, 
    0.00413767f, -0.02506603f, 0.02306365f, -0.02520359f, 0.00142822f, -0.03977408f, 0.01165173f, 0.01128220f, 
    -0.01183123f, 0.02036716f, -0.00139368f, 0.00807386f, -0.01958858f, 0.02094710f, -0.01449009f, -0.03997924f, 
    0.01906486f, -0.01139617f, 0.02770350f, -0.03785361f, -0.04194481f, 0.00035803f, -0.00773608f, -0.00934372f, 
    -0.03426907f, 0.00130785f, 0.01244186f, -0.01295863f, 0.01580634f, 0.01108617f, 0.00785706f, -0.04041657f, 
    0.00674639f, -0.03559740f, 0.00775521f, -0.00668867f, 0.00080906f, -0.02233645f, 0.01211611f, 0.02609796f, 
    -0.00757043f, 0.02100681f, -0.01928671f, -0.01016602f, -0.02895306f, 0.01976814f, -0.04090863f, 0.02040356f, 
    -0.02115697f, 0.01905007f, -0.00573289f, -0.02380215f, 0.00034870f, -0.02109111f, 0.01484478f, -0.00357090f, 
    -0.01515090f, -0.02169430f, -0.03436842f, 0.00176158f, -0.04134379f, 0.02393035f, 0.00706742f, -0.02078305f, 
    -0.04077836f, 0.00541498f, 0.02240844f, 0.02410146f, -0.03327306f, -0.02294827f, 0.00192041f, 0.02198262f, 
    -0.03658385f, -0.03383132f, -0.01725889f, -0.00368009f, -0.01650623f, -0.00892686f, 0.01277144f, 0.01203750f, 
    0.01946933f, -0.02984733f, 0.00432594f, -0.01318483f, -0.03833953f, 0.02583148f, -0.04034600f, 0.00517344f, 
    0.00700758f, -0.03688430f, -0.03164501f, 0.00334555f, -0.00728539f, 0.01967925f, -0.03665686f, -0.00042832f, 
    -0.02881370f, -0.02463425f, -0.00741004f, -0.00051694f, -0.00746861f, 0.01755266f, -0.02223911f, -0.04000801f, 
    -0.02899780f, -0.02027991f, 0.02284198f, 0.00321103f, -0.01968634f, 0.02360420f, -0.00388859f, -0.00406789f, 
    0.02115302f, 0.00682614f, -0.01310635f, 0.00373129f, -0.04186541f, -0.03621317f, -0.02010009f, -0.03579377f, 
    0.02486227f, 0.00073213f, -0.01470370f, -0.04001453f, 0.01949388f, -0.03172430f, 0.01417051f, -0.00521960f, 
    -0.02788647f, 0.01837821f, 0.01305711f, -0.04115522f, 0.02315444f, -0.00238637f, 0.01366233f, -0.03355274f, 
    -0.03537900f, -0.04113622f, -0.02522577f, 0.01807282f, -0.01925708f, 0.02497702f, -0.03214721f, 0.00662814f, 
    -0.03147234f, 0.02208146f, -0.01378489f, 0.00730438f, -0.02375036f, -0.00992205f, -0.02500371f, 0.00274250f, 
    -0.00426935f, 0.00036117f, -0.03022561f, -0.00395559f, -0.00173569f, 0.01204495f, 0.00271345f, 0.02463222f, 
    0.02297384f, -0.00182013f, -0.00993853f, -0.03318011f, 0.03225716f, -0.00235584f, -0.01810368f, 0.00657514f, 
    -0.03416031f, -0.00952263f, -0.01670962f, -0.00567855f, -0.03067177f, -0.03922886f, 0.01752718f, -0.03507941f, 
    0.01705823f, -0.03973936f, 0.02738998f, -0.01691595f, -0.01494757f, -0.02074930f, -0.03225837f, -0.00385298f, 
    -0.01490472f, -0.03309835f, 0.02786811f, -0.00325043f, -0.01163213f, -0.03811720f, -0.03036793f, -0.02895734f, 
    -0.03870571f, -0.02061788f, -0.04061452f, -0.03718886f, -0.00363831f, -0.03540815f, 0.00248934f, -0.01207380f, 
    0.00538310f, -0.02617649f, 0.00781226f, -0.00532346f, -0.03141531f, -0.00632379f, -0.01152987f, 0.00236643f, 
    -0.01948546f, 0.00398724f, 0.00921127f, 0.00833401f, 0.02110635f, -0.03521719f, 0.03005976f, 0.02032408f, 
    -0.03216376f, -0.01224313f, 0.01669604f, -0.00853221f, 0.02279610f, -0.03850203f, -0.00805299f, 0.01211560f, 
    0.02646815f, 0.02676205f, -0.03528653f, 0.02601486f, -0.01841531f, -0.01711983f, -0.01386751f, 0.02089028f, 
    -0.02907276f, -0.01582165f, -0.00165251f, -0.01838951f, -0.00566300f, -0.00819059f, -0.01858188f, -0.04033120f, 
    0.00689291f, -0.01579558f, -0.02901900f, 0.02053558f, 0.02175372f, -0.02911192f, -0.00959848f, 0.00710518f, 
    -0.00088157f, -0.03914536f, -0.03722996f, -0.02985611f, -0.01532323f, 0.00750141f, -0.02266909f, -0.01043783f, 
    -0.00132960f, -0.02615456f, 0.02445821f, -0.00492925f, -0.02031877f, 0.01214756f, -0.02713654f, -0.01317512f, 
    0.01571465f, -0.02668321f, 0.01435369f, -0.02617202f, -0.01204662f, 0.02467188f, 0.00754954f, 0.00009972f, 
    -0.03704559f, 0.02467312f, 0.02863695f, -0.03011653f, 0.00154936f, -0.00933526f, -0.00242502f, 0.00330681f, 
    -0.03991553f, 0.01013692f, -0.00925370f, 0.02817540f, 0.00573772f, -0.00171978f, -0.02928069f, -0.02449211f, 
    0.02644776f, -0.01338797f, 0.02755982f, -0.01277102f, -0.03030766f, 0.01118690f, 0.00281531f, 0.02142967f, 
    0.00277389f, -0.02598401f, -0.00834093f, -0.02125840f, 0.00336657f, -0.02680897f, -0.02636296f, 0.00306206f, 
    0.00912198f, -0.03724804f, -0.01638422f, 0.00125538f, 0.01446082f, -0.03989693f, 0.02194992f, -0.03921632f, 
    0.01951556f, -0.03075602f, 0.03801962f, 0.01567801f, 0.00593732f, -0.02298208f, 0.02099823f, 0.00658156f, 
    0.02192029f, 0.01454952f, 0.02556485f, 0.02843321f, 0.00008199f, -0.00889762f, -0.00666280f, 0.00153591f, 
    0.00738862f, -0.01635902f, -0.00467400f, 0.01881868f, 0.01312539f, 0.01055178f, -0.01466319f, -0.01471364f, 
    -0.01015170f, 0.00903377f, 0.01719904f, -0.03415094f, 0.02470981f, -0.02921300f, -0.00346120f, 0.01110015f, 
    0.00312446f, -0.00338366f, 0.02634020f, -0.03802816f, -0.03717375f, -0.02920981f, -0.01739017f, -0.01310153f, 
    -0.03325570f, 0.01011793f, 0.02535656f, -0.03935814f, -0.03036848f, 0.01592697f, -0.03510914f, -0.02919163f, 
    -0.04000072f, -0.01977308f, 0.00995675f, 0.01515787f, 0.00429473f, -0.03325405f, -0.01981500f, -0.02909457f, 
    0.01969936f, 0.00082015f, 0.01035838f, 0.02426229f, -0.01171354f, -0.02359474f, -0.00127838f, 0.01872962f, 
    -0.02920408f, 0.02115650f, 0.02198267f, 0.01107277f, 0.02865755f, 0.01960679f, -0.01752295f, -0.00844357f, 
    0.00323122f, -0.02807953f, -0.04139519f, -0.01910505f, -0.03551806f, -0.03026212f, -0.01155591f, 0.01695125f, 
    -0.01224134f, 0.01758040f, 0.02483191f, 0.01502540f, -0.03455441f, -0.02362960f, -0.01366963f, 0.01161564f, 
    -0.00794486f, -0.03369762f, 0.02313124f, 0.01596842f, -0.03658928f, 0.01473998f, 0.00894143f, -0.04124379f, 
    0.01994013f, -0.00609856f, 0.00132658f, -0.02526949f, -0.03809441f, -0.03103880f, 0.01001362f, -0.00450838f, 
    -0.02886241f, -0.00200391f, 0.01521732f, 0.01038543f, -0.03398430f, -0.00781251f, -0.01829178f, 0.02999132f, 
    0.09808143f, 0.24707872f, -0.02813454f, -0.05605674f, 0.11112355f, 0.08850836f, 0.11582045f, 0.13654239f, 
    -0.05132631f, -0.04682862f, 0.00535781f, -0.06075059f, 0.22883937f, 0.23931353f, 0.13869435f, 0.16068934f, 
    0.12035926f, 0.04173388f, -0.04785006f, -0.01472117f, -0.01210312f, 0.03872367f, -0.00629565f, -0.17891297f, 
    0.22275487f, 0.30672389f, 0.23175083f, 0.18356308f, 0.21232212f, 0.18189539f, 0.23144732f, 0.21639167f, 
    -0.11710409f, -0.01452111f, 0.06188629f, 0.04617164f, 0.03367989f, 0.05608932f, 0.04576057f, 0.02417073f, 
    0.06882983f, 0.14692728f, 0.16857578f, 0.11433505f, 0.03516831f, 0.16631359f, 0.12377495f, 0.10687164f, 
    0.43301457f, -0.11703078f, -0.22971222f, 0.04981663f, 0.01495651f, 0.07443520f, -0.02995490f, -0.01440486f, 
    -0.06378184f, 0.10320478f, 0.19316204f, -0.13743673f, 0.29467872f, 0.31330931f, 0.19445054f, -0.14633624f, 
    0.13252641f, 0.03093441f, 0.12773283f, 0.30163965f, 0.02924768f, -0.03495475f, 0.10781723f, -0.00478518f, 
    0.26205876f, 0.22081397f, 0.05604956f, 0.00137308f, 0.15757357f, -0.01456705f, -0.02452516f, 0.04679587f, 
    0.04488990f, -0.06734591f, -0.13430978f, -0.21765253f, 0.34702328f, 0.31802660f, 0.17977105f, 0.23260260f, 
    0.24878971f, 0.05665252f, 0.04664965f, 0.20549811f, -0.04007592f, -0.05420961f, -0.04690561f, -0.02701829f, 
    -0.33715114f, 0.05502994f, -0.49582899f, -0.03394430f, -0.13546501f, -0.11117874f, -0.05011285f, -0.08076808f, 
    0.06440071f, -0.05144433f, -0.09484159f, 0.00255754f, 0.33040869f, 0.38362813f, 0.20151709f, 0.11641542f, 
    0.16450469f, 0.11872887f, 0.16640061f, 0.10404126f, -0.07631184f, 0.00343365f, -0.05316548f, 0.01125612f, 
    -0.12055540f, 0.14895456f, -0.10240781f, 0.05276495f, -0.14944024f, -0.09035203f, 0.12487726f, 0.01873483f, 
    0.00977661f, 0.08427394f, 0.06516154f, 0.02359146f, 0.04557319f, 0.28522214f, 0.23921765f, 0.02481130f, 
    0.09914519f, 0.10729838f, -0.07713199f, 0.06806191f, -0.02211140f, 0.02353727f, -0.03687930f, -0.01979659f, 
    0.25842690f, 0.32450852f, 0.17718741f, 0.16097268f, 0.15533336f, 0.24273129f, 0.05681557f, 0.06411824f, 
    0.00646324f, -0.03013067f, 0.05889006f, 0.05274871f, -0.09598516f, 0.11530706f, -0.07115899f, 0.08923824f, 
    -0.00044293f, -0.24189709f, 0.04417209f, -0.07089161f, -0.01117090f, -0.08870341f, -0.12542419f, -0.13197175f, 
    0.20276119f, 0.23521282f, 0.03819570f, 0.16514716f, 0.16490985f, 0.18305127f, 0.07067446f, 0.17108893f, 
    -0.05917466f, -0.22374214f, -0.03916046f, -0.00140098f, 0.02051060f, -0.03328522f, 0.16208242f, -0.06693360f, 
    0.08095980f, 0.08888002f, 0.09095501f, 0.18537903f, -0.07804411f, 0.06661332f, 0.05551545f, 0.03600806f, 
    -0.24034683f, -0.11276066f, -0.01556807f, 0.00261086f, -0.03365993f, -0.03227106f, -0.05566787f, -0.01319896f, 
    -0.07434150f, -0.03969605f, -0.14862552f, -0.22932345f, -0.00789532f, -0.04603286f, -0.16585898f, -0.05114616f, 
    -0.04611192f, -0.05952578f, -0.06054935f, -0.03244675f, -0.03314375f, -0.29602492f, 0.02597330f, -0.12396592f, 
    0.30659917f, 0.05979582f, -0.16658229f, 0.07850219f, -0.05550128f, 0.03498337f, 0.10748807f, -0.04828032f, 
    0.05462581f, 0.08711372f, 0.09162698f, 0.10177370f, -0.07220814f, -0.03261057f, 0.06326168f, -0.00041419f, 
    -0.07857969f, -0.12035123f, -0.12278447f, -0.04515376f, -0.12019362f, -0.12504624f, -0.03232651f, -0.19527376f, 
    0.17926641f, -0.22009395f, -0.18918969f, 0.10987238f, -0.14673042f, -0.07029954f, 0.07774359f, -0.09503176f, 
    0.15965478f, 0.06592240f, -0.13593458f, 0.05909047f, -0.04141831f, -0.08097495f, -0.12849283f, -0.02896070f, 
    -0.08390643f, 0.02429502f, 0.14360811f, -0.04239000f, 0.02857130f, 0.17064512f, -0.05822627f, 0.11925453f, 
    0.06141160f, -0.00505422f, -0.12826404f, -0.04802596f, 0.00709179f, 0.02375077f, -0.06679659f, -0.07729638f, 
    -0.01643592f, -0.03665562f, -0.02044713f, -0.12661581f, 0.33599329f, 0.17221236f, 0.09041924f, 0.09861396f, 
    0.00758744f, -0.00114604f, 0.02386567f, 0.13357218f, -0.06595110f, -0.17057808f, 0.05875855f, 0.00596524f, 
    -0.03286185f, -0.18059239f, -0.02166149f, -0.04400557f, -0.01501124f, -0.06961158f, 0.11625891f, 0.01474413f, 
    -0.04677656f, 0.05490436f, 0.09556645f, 0.03781376f, -0.38255966f, -0.24301727f, 0.05453199f, -0.08518443f, 
    -0.09478714f, -0.00848547f, -0.07835170f, -0.05003279f, 0.10748103f, 0.06239538f, -0.00872716f, 0.05819913f, 
    -0.13187225f, -0.13297790f, 0.00939128f, -0.32409859f, 0.05740771f, 0.11438116f, 0.05451988f, 0.05866422f, 
    -0.02153199f, 0.08072740f, -0.04258703f, 0.03192489f, 0.02374343f, 0.09473414f, 0.06509802f, -0.03273409f, 
    0.08017506f, 0.01247786f, 0.05124351f, 0.03202804f, -0.06581747f, -0.02245321f, -0.18897717f, -0.19337820f, 
    0.33463341f, 0.27412865f, 0.27497053f, 0.27930605f, 0.23882510f, 0.26196653f, 0.02647063f, 0.11755272f, 
    -0.02291557f, 0.00354569f, 0.00731169f, 0.01083954f, -0.01151608f, -0.14820383f, -0.06584135f, -0.00593885f, 
    0.07126226f, -0.11179079f, 0.04684518f, 0.01921628f, 0.18437259f, 0.12933566f, 0.12133415f, 0.08345307f, 
    -0.08518989f, 0.34014344f, 0.01401507f, -0.18792331f, -0.11337742f, 0.16551390f, 0.08864775f, 0.07373834f, 
    0.04446606f, 0.02891273f, -0.12179628f, -0.06597831f, -0.10059457f, -0.12316626f, 0.09654969f, -0.03277469f, 
    -0.11830900f, -0.09422753f, -0.02329228f, -0.07221918f, 0.06357713f, 0.07468224f, 0.03200896f, 0.08806039f, 
    -0.08765643f, -0.15474422f, -0.06239920f, -0.02741057f, -0.09665329f, -0.10100821f, -0.10882409f, -0.09601077f, 
    0.20645039f, 0.01225570f, 0.08102017f, 0.11061260f, 0.24237071f, -0.21037497f, -0.10590982f, -0.05250254f, 
    -0.05273089f, -0.12480513f, -0.08610459f, 0.08994634f, 0.07019093f, -0.12806140f, -0.06437930f, -0.19097315f, 
    -0.07478877f, 0.37727159f, 0.34022143f, -0.26025775f, -0.11052517f, 0.07096367f, -0.03997811f, 0.11469536f, 
    0.06951644f, -0.11606192f, -0.09053070f, 0.05811385f, -0.23900646f, 0.10219032f, 0.06792777f, -0.08102954f, 
    -0.12727223f, 0.08241249f, -0.02081024f, -0.00013042f, 0.03873240f, -0.06291084f, -0.03374424f, -0.06278246f, 
    -0.12513675f, -0.09423110f, -0.14133528f, -0.10155611f, 0.06477915f, -0.15846960f, -0.15242350f, 0.07250177f, 
    -0.10345481f, 0.06636966f, 0.01772600f, -0.14939485f, 0.36378413f, 0.13141882f, 0.18206215f, 0.24870363f, 
    0.18594660f, 0.30649355f, 0.03858645f, 0.00606976f, -0.04081180f, -0.11729879f, -0.05057585f, 0.01530982f, 
    0.25087315f, -0.11104661f, -0.12573110f, 0.21011876f, 0.06707712f, 0.02381071f, 0.18001270f, 0.02191045f, 
    0.08680715f, -0.04289701f, 0.00181586f, 0.03403753f, 0.60095209f, 0.26843578f, -0.31173500f, 0.08443607f, 
    -0.01457299f, -0.03270373f, -0.00451816f, 0.02347981f, 0.19700196f, 0.01539930f, -0.10046577f, -0.18721999f, 
    0.19645454f, -0.35680079f, -0.41914147f, -0.23612554f, 0.00253672f, 0.02495286f, -0.14047602f, -0.06684701f, 
    0.07952788f, 0.04132933f, 0.03240892f, -0.02032733f, -0.15927526f, -0.09928852f, -0.09998343f, 0.04827184f, 
    -0.10155158f, -0.10340341f, -0.07995136f, -0.10141147f, 0.00122734f, -0.12236700f, -0.02742525f, -0.00608293f, 
    -0.07992819f, -0.21637863f, -0.07759448f, -0.07707366f, -0.16885254f, -0.12289849f, -0.09859078f, -0.10267029f, 
    0.02427506f, 0.09088396f, 0.10693971f, 0.03936473f, -0.37959796f, -0.17248818f, -0.06834482f, -0.14002597f, 
    -0.02981194f, 0.06886788f, 0.00068950f, -0.18676502f, 0.09987896f, 0.01253696f, 0.02348537f, 0.10759250f, 
    -0.13715282f, 0.00352765f, -0.42024174f, -0.20889953f, -0.02266169f, -0.09016149f, -0.06408354f, 0.05725402f, 
    0.02379496f, 0.03986600f, -0.06452864f, 0.01478792f, -0.19146778f, -0.12846018f, -0.03020299f, -0.04593746f, 
    -0.16316444f, -0.16510856f, -0.12150808f, -0.07725590f, -0.03326931f, 0.12062190f, 0.05243699f, 0.17019834f, 
    0.18594955f, 0.30894852f, -0.07492299f, -0.02852076f, -0.01540618f, 0.06853174f, -0.04485573f, 0.20394768f, 
    -0.01629396f, -0.00653624f, 0.04621319f, 0.08997908f, -0.00291305f, 0.07975798f, 0.08800687f, -0.12014486f, 
    0.17225915f, 0.19618340f, -0.06984232f, 0.09748690f, -0.01717250f, -0.04443244f, 0.06498892f, 0.02825473f, 
    -0.01237827f, -0.10212446f, 0.00715640f, -0.03134099f, -0.08406581f, -0.09923072f, -0.09470575f, -0.08264881f, 
    -0.08387329f, -0.04722393f, -0.07505535f, -0.02491061f, 0.01707813f, 0.21266560f, 0.25127584f, -0.14259481f, 
    -0.03905684f, 0.09877530f, 0.03792187f, 0.19237943f, 0.05292571f, 0.01481592f, -0.04843049f, -0.01707615f, 
    0.09952578f, -0.11585077f, -0.21188360f, -0.32502040f, 0.02522786f, -0.03418612f, -0.11580867f, -0.07519180f, 
    0.00038839f, -0.00614497f, 0.02065176f, -0.05984922f, 0.25577193f, 0.12860999f, 0.16586557f, -0.03994076f, 
    0.08249959f, 0.19866912f, -0.00296546f, 0.08014497f, 0.02592752f, -0.11515433f, 0.07464335f, -0.03061653f, 
    -0.23561047f, 0.32691324f, 0.34159252f, -0.00720212f, -0.06019476f, 0.04900013f, -0.11027013f, 0.09688572f, 
    0.15229198f, 0.03974372f, 0.08513720f, 0.12186445f, 0.18324836f, -0.01257694f, -0.19512841f, -0.09829186f, 
    -0.09503072f, -0.06538688f, -0.01947985f, -0.11533219f, 0.13719462f, 0.07051146f, 0.16257569f, 0.03074930f, 
    0.32732207f, 0.43665221f, 0.21003465f, 0.09248050f, 0.04128058f, 0.15219469f, 0.12337255f, 0.06372650f, 
    0.03566930f, -0.05590443f, 0.11702191f, 0.00993669f, -0.20284027f, 0.06007870f, 0.49764198f, 0.10001137f, 
    -0.07594604f, -0.04567096f, 0.08661478f, 0.14062752f, 0.05173912f, 0.05112083f, 0.02492034f, 0.14097670f, 
    -0.07518313f, 0.36709136f, 0.27578428f, -0.28647032f, 0.06519070f, 0.28819183f, -0.10150809f, -0.10783996f, 
    0.00237781f, -0.09174223f, -0.02673329f, 0.07325372f, 0.11905120f, -0.29986867f, -0.08474895f, -0.13619410f, 
    0.05805919f, 0.01428686f, -0.13808729f, 0.01770237f, 0.17027703f, -0.02668950f, 0.00203792f, -0.01143828f, 
    0.19376719f, -0.24171078f, -0.15349811f, 0.05589112f, -0.05396631f, 0.09483934f, 0.19856633f, 0.05415556f, 
    -0.07615548f, 0.17572777f, 0.02285480f, 0.00645478f, 0.41138971f, 0.30395859f, 0.09209540f, 0.18113364f, 
    0.07201606f, 0.15822560f, 0.03193776f, 0.09249292f, -0.02662628f, -0.07541551f, -0.13214529f, -0.07181142f, 
    0.10446731f, 0.00608537f, -0.36704648f, -0.05621697f, -0.15257291f, 0.04726860f, -0.06336705f, 0.18975753f, 
    0.00599148f, 0.16635585f, 0.00759666f, -0.07114651f, 0.11029145f, -0.16599233f, 0.11129501f, 0.11019954f, 
    0.02975454f, 0.13536023f, -0.10129153f, 0.03888150f, 0.16209877f, 0.10761125f, 0.18515904f, 0.09400064f, 
    -0.13205293f, -0.08746046f, -0.23498575f, -0.11562324f, -0.13487124f, -0.08813218f, 0.01203175f, -0.14261641f, 
    0.18069060f, 0.03195848f, 0.08934056f, -0.01329736f, -0.20931815f, 0.00635751f, 0.08087155f, -0.15171997f, 
    0.04372728f, 0.02312417f, 0.04519837f, 0.08367631f, 0.11583141f, 0.00304813f, -0.09392509f, -0.05735074f, 
    -0.04739720f, 0.09550332f, -0.36259279f, 0.06042910f, -0.02272555f, -0.04803542f, -0.04850734f, 0.07771087f, 
    0.07246423f, 0.11935995f, 0.02853254f, 0.13220376f, -0.03896262f, 0.25377959f, -0.19143355f, 0.08013932f, 
    -0.13437153f, -0.14267033f, -0.11623097f, 0.04618889f, 0.04941406f, 0.04337308f, -0.06527768f, -0.04256551f, 
    -0.08134411f, -0.13879852f, -0.10882236f, -0.10820884f, 0.06228121f, 0.18039480f, 0.14644593f, 0.05170912f, 
    -0.00584159f, 0.09142876f, 0.08594683f, -0.07545952f, 0.00249487f, -0.05947217f, 0.00691897f, -0.05381057f, 
    -0.09236665f, -0.01745619f, 0.27576205f, -0.10050444f, 0.04161955f, 0.02450832f, -0.04711539f, -0.06819217f, 
    -0.01370388f, 0.11647061f, 0.00011359f, 0.03706180f, -0.06921232f, 0.06179913f, -0.13516872f, 0.10556927f, 
    -0.06041619f, 0.04911074f, 0.02662601f, 0.13043076f, -0.14689429f, 0.06310329f, -0.12813497f, 0.08739500f, 
    -0.03806768f, 0.07629330f, -0.04196413f, 0.02962946f, -0.08105886f, -0.05147158f, 0.09296242f, -0.05205397f, 
    -0.16594580f, 0.02978282f, 0.02262807f, 0.05111907f, -0.03205947f, 0.01803740f, 0.01573274f, 0.10631621f, 
    0.00477617f, 0.02961664f, 0.06786892f, 0.00909377f, -0.12439076f, -0.10956382f, -0.02616428f, -0.16125014f, 
    0.06692732f, 0.03641452f, -0.01297889f, 0.09749671f, 0.03145491f, 0.02247469f, 0.04260317f, 0.01643592f, 
    -0.12870955f, -0.03903611f, -0.12391444f, 0.03890094f, -0.09720286f, 0.09333502f, 0.07519966f, 0.00378363f, 
    -0.06694394f, -0.07424777f, -0.07195306f, 0.01388626f, 0.09275766f, -0.10328001f, -0.11168817f, 0.05817495f, 
    -0.08963857f, 0.09590235f, -0.18204446f, 0.13029405f, -0.07981935f, -0.03757505f, 0.00828938f, -0.03293357f, 
    0.00472932f, -0.03701062f, -0.14771508f, 0.07141975f, 0.09604835f, 0.10349151f, 0.00437150f, -0.13002312f, 
    0.12483261f, 0.14750355f, -0.14143448f, 0.03075160f, 0.13368198f, 0.25238898f, -0.03522308f, -0.18462057f, 
    0.01305451f, -0.05321681f, -0.16036338f, 0.00361453f, -0.03175367f, 0.13523518f, -0.02303970f, 0.02749392f, 
    -0.03679167f, 0.05725911f, 0.12532449f, 0.10106505f, -0.06181598f, -0.08178383f, -0.16677912f, 0.03091981f, 
    0.02596796f, -0.02942653f, -0.02279829f, -0.02778100f, 0.18825108f, -0.04745170f, -0.05913418f, 0.00682992f, 
    -0.19826700f, -0.10125126f, -0.01173067f, -0.00406432f, -0.05439835f, 0.16664420f, 0.05612983f, 0.21542037f, 
    -0.02297178f, -0.03281458f, -0.06558343f, -0.09192891f, 0.11391290f, -0.03407004f, 0.10122405f, -0.02013547f, 
    0.02807326f, 0.13311788f, 0.04308397f, 0.12439096f, 0.09804014f, 0.21471708f, -0.21454903f, -0.27610478f, 
    0.10144788f, 0.20448473f, 0.09703779f, 0.01494531f, -0.06706560f, 0.01017360f, -0.10484204f, 0.08639564f, 
    -0.02616320f, -0.13356018f, -0.03862894f, -0.01285241f, 0.02157545f, -0.00486080f, 0.04811367f, -0.05488930f, 
    0.03563787f, 0.03819744f, -0.02643880f, 0.10477889f, -0.06886697f, -0.06862652f, -0.00245477f, -0.02001564f, 
    -0.01081625f, 0.05156647f, 0.00180717f, 0.00374652f, 0.12417418f, 0.11028575f, 0.08109919f, 0.08460885f, 
    0.12830245f, 0.16034600f, -0.06650093f, -0.03518990f, -0.10015265f, -0.10740738f, -0.01444869f, 0.01928586f, 
    0.05365452f, -0.01949532f, -0.04713797f, 0.00840368f, -0.15819496f, -0.18450268f, -0.04638932f, -0.16307184f, 
    -0.02353050f, -0.00060421f, 0.05543746f, -0.07007063f, 0.16770504f, 0.12469221f, -0.04167580f, 0.14314422f, 
    -0.03274231f, -0.10296178f, 0.11270024f, -0.12607867f, -0.00167592f, -0.06131982f, 0.06530986f, 0.05897884f, 
    -0.00514185f, 0.09002814f, -0.10867417f, 0.07190969f, -0.13322881f, 0.09139203f, -0.24296236f, -0.01728720f, 
    -0.00968337f, 0.26359150f, 0.24994993f, -0.06697500f, 0.11515285f, 0.10247739f, -0.06382555f, -0.07026428f, 
    0.05065859f, 0.20590974f, 0.26582667f, 0.12949879f, -0.14252125f, -0.00343150f, -0.19565551f, -0.03569249f, 
    -0.07540730f, 0.02650619f, 0.06386913f, -0.05597791f, 0.02633934f, -0.02778136f, -0.06639722f, 0.14869429f, 
    0.20747916f, 0.05894453f, -0.08636415f, -0.00797268f, -0.06483441f, 0.02516640f, 0.00006743f, 0.05547505f, 
    -0.26411000f, -0.14454500f, -0.06473243f, 0.05472188f, 0.04013658f, 0.15250322f, 0.05003090f, 0.20648690f, 
    -0.05354196f, -0.17799717f, -0.02751726f, -0.06196928f, -0.13936165f, 0.01869401f, -0.01103156f, 0.16004033f, 
    -0.05506339f, 0.10774009f, -0.03103254f, -0.06442562f, 0.01303370f, -0.06071729f, -0.04851729f, -0.09273122f, 
    0.04020469f, 0.35680643f, 0.16484585f, 0.11381018f, -0.06551937f, -0.17052253f, 0.05330933f, -0.13188879f, 
    -0.02123483f, -0.05197022f, -0.00343188f, 0.03756697f, -0.02047594f, 0.10716773f, 0.07707086f, 0.14563806f, 
    -0.08409892f, -0.02036699f, -0.01096291f, 0.00116309f, 0.05680980f, 0.09915167f, 0.07517145f, 0.17026000f, 
    -0.25736034f, -0.22174984f, -0.01277129f, 0.00110821f, -0.12593964f, -0.04273875f, 0.07287116f, -0.01210869f, 
    -0.05384212f, 0.01615332f, 0.04422155f, -0.03172037f, 0.03727926f, 0.06004614f, 0.13601674f, 0.09564910f, 
    -0.05405170f, 0.02448393f, -0.06117189f, 0.00376798f, -0.07373427f, -0.03736638f, 0.17681131f, -0.10493483f, 
    -0.16662516f, -0.08943961f, -0.18616392f, 0.12750642f, 0.01563006f, 0.16587347f, 0.10684630f, -0.17857805f, 
    0.10943688f, -0.02935536f, -0.12588145f, 0.03025071f, -0.07134927f, 0.14864716f, 0.38246185f, 0.35207319f, 
    0.01860363f, -0.03548718f, -0.20716076f, 0.03793748f, -0.08505832f, -0.03329129f, 0.07070979f, 0.05331689f, 
    0.00178967f, -0.02339326f, 0.13218378f, 0.14109156f, 0.03951736f, -0.02749765f, -0.01750178f, -0.01294468f, 
    -0.04508107f, 0.00276524f, -0.02753275f, -0.03975659f, -0.07876039f, 0.18948330f, -0.00256287f, -0.24551570f, 
    -0.01951323f, -0.05948208f, 0.10311068f, 0.05643890f, 0.12741530f, 0.04948313f, 0.01186583f, 0.07653652f, 
    -0.39573953f, 0.27821833f, -0.02010239f, 0.02764954f, 0.14178258f, -0.06193400f, -0.18083698f, -0.13245189f, 
    -0.06523617f, -0.03577773f, -0.05352379f, 0.05262282f, -0.02458838f, 0.12915877f, -0.09679348f, 0.18902713f, 
    0.02552247f, 0.10352658f, 0.04563249f, 0.01951929f, 0.02065789f, 0.03885091f, 0.03449888f, 0.03134181f, 
    -0.11730470f, -0.03304617f, -0.03560701f, 0.07892840f, -0.09372681f, -0.00502964f, -0.10967993f, 0.10813551f, 
    0.15952857f, 0.05222396f, -0.03863989f, 0.03320603f, -0.02264443f, -0.13807146f, -0.14221224f, -0.08267623f, 
    0.13466509f, 0.06445582f, 0.05631302f, 0.02757478f, -0.06415418f, 0.06098957f, -0.01564456f, -0.05929041f, 
    0.06529370f, 0.05388348f, 0.07432883f, -0.26307040f, -0.17424241f, 0.16750757f, 0.19051771f, -0.09918767f, 
    -0.00054318f, -0.00210564f, 0.02507276f, -0.01838242f, 0.29393825f, -0.00832391f, 0.43232745f, -0.12956257f, 
    0.07135022f, 0.00743521f, -0.04053747f, 0.03223393f, -0.11555539f, 0.14644349f, -0.03289793f, 0.06777694f, 
    0.11436582f, 0.40635437f, 0.40154102f, 0.12190583f, -0.03926456f, -0.18434578f, -0.10846777f, -0.07607977f, 
    -0.09105145f, 0.04787008f, -0.04185055f, -0.01497788f, -0.07538291f, -0.16404410f, -0.01005166f, 0.03827422f, 
    -0.02097691f, 0.04927956f, -0.01799702f, 0.00643702f, 0.04039051f, 0.01239945f, 0.10464910f, 0.02091432f, 
    -0.14880726f, -0.01835771f, -0.14255394f, -0.02475742f, 0.01807520f, 0.06200356f, 0.11524873f, -0.00194932f, 
    0.05284990f, 0.05124713f, 0.04776448f, 0.08311398f, 0.03761921f, 0.09456953f, 0.15394081f, 0.12990266f, 
    0.02706568f, -0.09300978f, 0.08834504f, -0.05523865f, -0.06066189f, 0.00649770f, -0.02272936f, 0.00694096f, 
    0.02575509f, -0.20898794f, -0.10242651f, 0.02682129f, 0.08870731f, 0.20827590f, 0.19849049f, 0.14605182f, 
    0.00974781f, -0.06344350f, -0.06918473f, -0.14594968f, -0.15585697f, -0.22830749f, 0.01390193f, 0.12897806f, 
    -0.02054772f, 0.14113958f, -0.03306961f, -0.03810396f, 0.05861817f, -0.10165906f, -0.02693149f, 0.03789777f, 
    -0.01529832f, 0.03419067f, -0.01726275f, 0.01547133f, -0.05074267f, 0.04850193f, 0.06572370f, 0.15384407f, 
    -0.04394913f, -0.10992740f, 0.03542821f, -0.02738570f, -0.08641944f, 0.04489930f, 0.10462297f, -0.02599536f, 
    -0.01941358f, 0.03140356f, -0.02288396f, -0.08324417f, -0.09421437f, -0.02417195f, 0.03531032f, 0.02938734f, 
    -0.10016692f, -0.08801787f, 0.23076966f, 0.14462380f, -0.01710529f, 0.04289628f, -0.16751041f, 0.02296873f, 
    -0.02952708f, 0.09652938f, -0.05168737f, 0.16649069f, -0.07857689f, 0.21928394f, -0.08639819f, -0.12939693f, 
    -0.05267876f, -0.03165250f, 0.02219210f, -0.05020305f, -0.00143510f, -0.08477609f, -0.14956525f, 0.06992156f, 
    -0.10011700f, 0.31207636f, 0.39605370f, 0.23626377f, -0.01819424f, -0.17174971f, -0.08103102f, -0.08020367f, 
    -0.12425500f, -0.03516012f, 0.08058467f, 0.11150800f, 0.28817299f, 0.07181332f, 0.30673790f, -0.25380716f, 
    -0.03731744f, -0.18020423f, 0.05074374f, 0.02637462f, -0.06380911f, -0.07236145f, 0.00291804f, 0.05153284f, 
    -0.20415358f, -0.02425166f, -0.05478909f, 0.17123006f, 0.00085995f, -0.00389355f, 0.04372576f, -0.01284545f, 
    0.03562104f, -0.11508145f, 0.11240379f, 0.01703039f, 0.00205843f, 0.02434318f, 0.07125898f, 0.17012614f, 
    0.04845846f, -0.05240787f, -0.12731054f, -0.08202387f, -0.17763911f, 0.06866904f, 0.05797587f, 0.02439477f, 
    0.29300329f, 0.17569689f, 0.03023147f, -0.09902533f, 0.03309328f, -0.15585066f, -0.02869317f, -0.06210999f, 
    -0.02173927f, -0.04031363f, -0.01136760f, -0.04363684f, -0.06574620f, 0.02672459f, 0.08413643f, -0.03237424f, 
    0.18855703f, 0.09514465f, -0.01327453f, 0.04769605f, 0.00481677f, -0.09025446f, -0.13822220f, -0.00668952f, 
    -0.26695022f, 0.20781921f, -0.10585060f, -0.05588220f, 0.03473568f, -0.01258880f, -0.04117882f, 0.13746293f, 
    0.04785749f, 0.00409842f, -0.00698393f, -0.13883665f, 0.04186954f, 0.32473630f, 0.23028578f, 0.12049472f, 
    0.04145949f, -0.18316640f, -0.05623829f, -0.05450560f, -0.03146487f, 0.03872319f, 0.09214310f, 0.06057809f, 
    -0.06984212f, -0.05319364f, 0.09915681f, -0.12972924f, -0.02861942f, 0.06922352f, 0.02405745f, 0.08690071f, 
    -0.09345189f, -0.01826978f, -0.02532907f, -0.04163133f, -0.03607780f, -0.52737451f, -0.06391968f, -0.04562065f, 
    0.01639966f, -0.05599753f, -0.08192344f, 0.07508115f, -0.00291211f, 0.05623743f, -0.03410769f, 0.03898571f, 
    -0.14314599f, 0.03371997f, -0.21011642f, -0.06493826f, -0.05446597f, -0.15426609f, -0.02344390f, 0.14563680f, 
    0.07186909f, 0.06185310f, 0.02022349f, 0.00954140f, -0.15820016f, 0.02549024f, 0.02447674f, 0.07621351f, 
    0.06197201f, -0.02478952f, -0.00700199f, 0.08513627f, -0.05360457f, -0.15530790f, 0.04481171f, 0.07607125f, 
    0.11776401f, 0.03132599f, -0.03502185f, 0.10253659f, -0.05062677f, -0.10786659f, 0.10096373f, -0.09035642f, 
    0.03403046f, 0.04452311f, -0.11080069f, 0.06915122f, -0.06579875f, 0.06927183f, 0.12003063f, 0.04429908f, 
    0.04210204f, -0.13022545f, 0.02114606f, -0.03600260f, 0.03630113f, 0.20088449f, 0.14155750f, 0.08987203f, 
    0.01707221f, 0.02648919f, -0.02554078f, 0.00601722f, -0.01666599f, -0.02612800f, 0.02173657f, 0.02971096f, 
    -0.01051654f, 0.02429502f, 0.00727224f, -0.01375431f, -0.02570555f, -0.02798749f, -0.03246771f, -0.02330687f, 
    0.00591870f, 0.02403579f, 0.03047905f, -0.04129650f, -0.01272550f, -0.00259791f, -0.03040785f, 0.01425976f, 
    -0.00377510f, -0.01452227f, -0.00765251f, 0.00468566f, 0.02491070f, 0.00324935f, -0.00787554f, 0.01372401f, 
    0.01489454f, 0.00532691f, -0.01617582f, 0.00231684f, -0.00558809f, 0.01269232f, -0.02776697f, 0.00972026f, 
    -0.01944662f, -0.00191351f, 0.01989209f, -0.01312322f, 0.00939818f, 0.02181514f, 0.01909624f, 0.01603848f, 
    -0.02329617f, -0.01398125f, 0.02342533f, -0.03592442f, -0.01503266f, -0.02227695f, -0.03264182f, -0.01896549f, 
    -0.01883889f, -0.00490915f, -0.00340785f, -0.03263171f, -0.03021594f, -0.01931551f, 0.01338321f, -0.03932964f, 
    0.00578663f, 0.01158680f, -0.00656962f, -0.03733188f, -0.02979342f, 0.02015712f, -0.00910152f, -0.01793131f, 
    0.00066593f, 0.02222639f, 0.02044077f, 0.01653040f, 0.00119595f, 0.00285002f, -0.03376473f, 0.01370458f, 
    -0.03664300f, 0.02943398f, 0.02512806f, -0.03598222f, -0.03158525f, 0.01057650f, 0.01777098f, 0.02177062f, 
    0.00781434f, 0.02957125f, 0.00611870f, -0.00968721f, 0.00878280f, -0.00525829f, 0.01472555f, 0.02426011f, 
    0.02943080f, 0.01830344f, -0.02020628f, -0.03079532f, -0.03883464f, -0.03069163f, -0.00937525f, -0.01112497f, 
    -0.00474557f, -0.04078550f, -0.03944653f, -0.03741140f, -0.03162673f, -0.02796772f, -0.03854674f, -0.03626851f, 
    -0.02815091f, -0.00281337f, 0.00443817f, -0.03716305f, 0.00824826f, 0.00894724f, 0.01168388f, -0.01543797f, 
    -0.02844823f, -0.01767506f, -0.03329356f, -0.02252253f, 0.02526035f, 0.01298021f, -0.00013737f, -0.01300397f, 
    -0.03742186f, -0.04071593f, 0.02506360f, -0.00747237f, -0.01646141f, -0.02595734f, -0.01153110f, -0.02633522f, 
    0.02600420f, -0.02575350f, 0.02565947f, 0.01846047f, -0.02076345f, 0.00501910f, -0.01933999f, -0.00731205f, 
    -0.02187287f, -0.01786042f, 0.00727790f, -0.01887298f, -0.01325767f, -0.04014897f, -0.02104619f, -0.03462514f, 
    0.01081919f, -0.02790272f, -0.00829278f, 0.01548864f, 0.02573305f, 0.02214947f, -0.01869038f, -0.01182446f, 
    -0.00937069f, 0.00908915f, 0.00380480f, 0.03135861f, 0.02202255f, 0.02796243f, 0.03454214f, 0.00863130f, 
    0.01823650f, 0.00285406f, -0.01855108f, -0.03179578f, 0.00314892f, -0.02864903f, 0.01374168f, -0.02769924f, 
    0.00132960f, -0.02847222f, -0.02764750f, -0.03356513f, 0.01687730f, -0.03435462f, -0.01713847f, -0.01066661f, 
    0.01906650f, -0.03030399f, 0.01432226f, 0.02989369f, -0.03624952f, -0.02582471f, 0.00194695f, -0.03531472f, 
    -0.03876442f, -0.02354633f, 0.00811647f, -0.03222447f, -0.03128828f, -0.03910536f, -0.00103777f, 0.00334710f, 
    -0.02568091f, 0.02149955f, 0.01876934f, -0.02293614f, -0.00498875f, -0.01863841f, 0.00520667f, -0.00775380f, 
    -0.02507603f, -0.01611074f, -0.02516260f, 0.01539750f, 0.00332813f, -0.03882658f, -0.01256082f, -0.02091664f, 
    0.01978064f, -0.01114759f, 0.01553915f, -0.00647540f, -0.02935108f, 0.03606755f, -0.02109669f, -0.03896737f, 
    -0.01875903f, 0.02722083f, 0.03361528f, -0.02304137f, -0.01860888f, -0.03357024f, 0.02482742f, 0.03240743f, 
    0.02159317f, -0.01934328f, -0.01618868f, 0.01694318f, 0.01964471f, 0.02914465f, 0.00568317f, 0.02202070f, 
    0.01631529f, -0.01512681f, -0.02135794f, 0.00215095f, 0.01558121f, -0.00183365f, -0.01607473f, -0.03366249f, 
    0.00519186f, -0.01864260f, 0.01544264f, -0.00174946f, 0.01089990f, -0.03809120f, -0.02634885f, 0.02624566f, 
    -0.02131841f, 0.01040297f, 0.01709242f, -0.03902445f, -0.00743704f, -0.00924772f, -0.01300824f, -0.00091718f, 
    0.00899906f, -0.04103464f, -0.00299012f, 0.01389114f, -0.00346160f, -0.01259533f, 0.00231334f, 0.01889835f, 
    -0.00862697f, -0.04051428f, -0.02395706f, 0.00036715f, 0.02460839f, -0.00733716f, -0.03091574f, -0.03566248f, 
    -0.02772036f, 0.00668002f, -0.03231165f, -0.01389630f, -0.00124424f, -0.03928838f, -0.01794838f, 0.02389564f, 
    -0.03780106f, 0.00380692f, 0.02044829f, -0.03015504f, 0.00113036f, -0.02462229f, -0.01690724f, 0.02818681f, 
    -0.03537446f, -0.00146716f, -0.02227463f, 0.02326283f, -0.00229803f, -0.01869307f, 0.01477688f, 0.00517064f, 
    -0.03990684f, 0.00227686f, 0.02025896f, 0.00368252f, -0.03544981f, -0.01878477f, -0.00514328f, -0.02920820f, 
    -0.00229576f, 0.00316615f, -0.00788865f, -0.01747231f, 0.00830180f, -0.01784963f, -0.01195539f, -0.01924557f, 
    0.00246640f, -0.01022188f, -0.03410421f, -0.00152744f, -0.01280207f, -0.03265959f, -0.00904412f, 0.00663783f, 
    -0.02815523f, -0.01301424f, -0.00058288f, -0.02291954f, -0.04066809f, -0.00763482f, -0.02916273f, -0.00085837f, 
    0.01918916f, -0.01923765f, 0.02255064f, -0.03587588f, -0.01015303f, 0.01180405f, 0.00729952f, -0.01677400f, 
    0.00505044f, 0.02275350f, -0.00889053f, -0.00427451f, 0.00975590f, -0.00933009f, -0.00645555f, 0.01904785f, 
    0.00367295f, 0.01156465f, -0.00452508f, 0.01850876f, -0.01898082f, 0.00525009f, 0.02118434f, -0.00725859f, 
    -0.02546949f, 0.02947570f, 0.02030714f, -0.04082199f, -0.02557731f, -0.01161311f, -0.00402930f, 0.00792594f, 
    -0.00079388f, 0.00805501f, -0.00461564f, -0.01347844f, -0.02528360f, -0.01595043f, 0.00783358f, 0.01827353f, 
    -0.00491779f, 0.02858859f, -0.01513694f, 0.01559897f, -0.00424453f, 0.00743663f, 0.01129738f, 0.02699771f, 
    0.02003675f, -0.03132723f, -0.01064041f, -0.02274562f, -0.04077940f, 0.02650856f, 0.01777427f, -0.02216909f, 
    -0.00848422f, -0.02228456f, -0.01045616f, -0.02294315f, 0.01658020f, -0.00389065f, -0.00019954f, 0.00452392f, 
    -0.04050955f, 0.00802233f, 0.02378343f, -0.01675036f, 0.01325348f, -0.03777008f, -0.02777662f, -0.01306151f, 
    -0.01034931f, -0.01632988f, -0.01928836f, -0.00981938f, -0.00735646f, -0.02159669f, -0.00133834f, -0.02569018f, 
    0.00953417f, -0.03898509f, 0.00364670f, -0.02926565f, -0.02793656f, 0.01957157f, -0.03571571f, -0.04010790f, 
    -0.03254314f, -0.01400751f, 0.01458166f, -0.00753884f, 0.00188034f, -0.00176750f, 0.00689054f, 0.02984456f, 
    -0.01044814f, -0.03228109f, -0.03037000f, -0.01301681f, 0.00521154f, 0.01655867f, -0.00776755f, 0.02246078f, 
    -0.01940077f, -0.01720106f, -0.03210185f, 0.00889028f, -0.04140286f, -0.00629707f, -0.02864760f, 0.02851513f, 
    -0.03297840f, -0.00211954f, 0.00033863f, -0.02044046f, -0.01503683f, -0.00801270f, -0.01179153f, 0.02206558f, 
    -0.00540971f, 0.00718055f, -0.02883361f, -0.02318440f, 0.00581615f, 0.01070734f, -0.02089647f, -0.01431645f, 
    0.01772740f, 0.01848166f, 0.01699244f, 0.01879744f, 0.01983384f, -0.02411468f, 0.02836215f, 0.01615290f, 
    0.00954619f, -0.03512852f, 0.01625900f, -0.01015612f, -0.02041152f, 0.00260413f, -0.03544925f, -0.01937352f, 
    0.00101612f, 0.00318205f, 0.02401748f, -0.01349341f, -0.02327946f, 0.01127353f, 0.00405828f, -0.02079969f, 
    -0.00815571f, -0.02417406f, 0.01605619f, -0.01695840f, -0.02578031f, -0.01972166f, -0.00764368f, 0.00857356f, 
    -0.01633020f, 0.01950645f, -0.04127951f, 0.01676562f, 0.02331392f, 0.02994167f, -0.01280706f, -0.02693610f, 
    -0.01792374f, -0.03119922f, 0.01261172f, -0.00289923f, 0.02931095f, -0.03243381f, 0.02121415f, -0.02895621f, 
    0.02539022f, -0.03144435f, 0.00187838f, -0.00010973f, -0.02709226f, -0.03444856f, 0.00747769f, -0.03660598f, 
    -0.01859766f, 0.00079549f, -0.02210446f, -0.03206271f, -0.01770536f, -0.03651529f, 0.00815624f, -0.00110359f, 
    0.02679934f, 0.02769361f, -0.02655572f, -0.03932456f, 0.01704358f, -0.00976562f, 0.02089836f, -0.03332102f, 
    -0.03128482f, 0.01722956f, -0.03375753f, -0.01772631f, 0.03115821f, 0.01373662f, -0.04103543f, -0.00564891f, 
    0.02623977f, 0.02405934f, 0.01435967f, -0.00992316f, -0.00828020f, -0.02644137f, -0.01503041f, 0.01008990f, 
    -0.03197675f, 0.02534449f, -0.02486893f, 0.00036242f, -0.02797463f, -0.03736142f, -0.01926534f, 0.00522048f, 
    0.01130771f, 0.02638503f, -0.03971904f, 0.01690044f, -0.01238883f, -0.02503216f, -0.03705437f, 0.00548142f, 
    0.00163483f, -0.01183458f, 0.00034456f, -0.02310270f, -0.02765178f, -0.01691821f, -0.00103788f, -0.01350073f, 
    0.02476011f, -0.01641106f, 0.00704731f, 0.02067146f, -0.01308617f, -0.01184771f, -0.00684957f, 0.01187356f, 
    -0.00802763f, -0.01305616f, -0.03416295f, 0.01417885f, -0.00237397f, 0.00902268f, 0.00616386f, -0.02597958f, 
    -0.03384246f, -0.02834853f, 0.02016735f, -0.02018357f, -0.01609146f, -0.00794457f, 0.02956459f, 0.01906625f, 
    0.02675421f, -0.03720597f, -0.01543989f, 0.03025690f, 0.02737627f, 0.02816830f, 0.00851587f, 0.00202550f, 
    -0.02350131f, -0.00509413f, -0.03790665f, 0.00078037f, 0.01225949f, -0.00475907f, -0.00055673f, -0.02989232f, 
    -0.02159882f, 0.02086875f, -0.00965623f, -0.00379115f, 0.01478429f, -0.00476207f, 0.01877164f, -0.02072535f, 
    0.01701759f, 0.00881516f, 0.02191268f, -0.01300812f, -0.02009375f, 0.02595231f, -0.00488993f, -0.01878466f, 
    -0.02915267f, 0.01994881f, 0.01902111f, 0.01883634f, -0.00341560f, -0.01471491f, 0.02445513f, -0.03952595f, 
    0.00898555f, -0.03561736f, -0.00461152f, -0.01332618f, -0.01636419f, 0.02400933f, -0.02633897f, 0.00554608f, 
    -0.00884743f, -0.00814088f, -0.02300917f, 0.01447958f, -0.02607025f, 0.02475444f, -0.01770326f, 0.02314170f, 
    -0.03546804f, 0.02414272f, -0.01371448f, -0.03356117f, -0.02480651f, 0.02467140f, -0.03476508f, -0.00555615f, 
    0.01488737f, 0.01018921f, -0.03644877f, 0.01445676f, 0.03072795f, -0.03672613f, -0.00160263f, 0.02650649f, 
    -0.03809438f, 0.01944089f, -0.00277592f, 0.02334974f, 0.00471076f, -0.00408360f, -0.03377220f, -0.03784375f, 
    0.01060068f, 0.00441963f, -0.02737665f, -0.01553942f, 0.00464871f, 0.01771673f, 0.02984182f, -0.01443668f, 
    0.00169200f, 0.02280137f, -0.03683360f, 0.00148511f, 0.01252898f, -0.04086501f, -0.02418031f, -0.02255383f, 
    0.03043181f, -0.03526302f, -0.04049825f, -0.01961444f, 0.01234028f, -0.01848717f, -0.00091861f, -0.03518723f, 
    -0.01002843f, 0.00713044f, 0.01955875f, -0.01584441f, -0.01252205f, 0.00321262f, 0.00084086f, 0.00862598f, 
    0.00609734f, -0.00395697f, -0.01197798f, -0.01493925f, -0.03209968f, 0.02653932f, -0.00924928f, 0.00020276f, 
    -0.01628654f, 0.01643191f, 0.00839039f, 0.01707593f, 0.02024547f, -0.03138060f, -0.03512602f, -0.00513364f, 
    -0.01963280f, 0.02063639f, -0.01722901f, 0.01789393f, 0.01960836f, -0.03662843f, -0.02747490f, -0.03837082f, 
    0.01686678f, -0.01776613f, -0.00522154f, 0.00567009f, 0.00012132f, 0.02020064f, 0.02602633f, -0.02566688f, 
    -0.02455499f, 0.02085302f, -0.00282003f, -0.00515438f, 0.01995299f, -0.00302256f, -0.03092486f, 0.01780224f, 
    0.03195248f, 0.00630317f, -0.00583746f, -0.02250165f, -0.02584342f, -0.02508856f, 0.02901983f, -0.02920622f, 
    -0.01929984f, -0.02230985f, 0.01831368f, -0.03783693f, 0.02612439f, -0.03945346f, 0.01577603f, -0.00784688f, 
    0.20532110f, 0.03851481f, 0.31916657f, -0.05981262f, -0.02913816f, 0.05177135f, 0.05243946f, -0.02552639f, 
    -0.01125861f, -0.05809879f, -0.06672432f, 0.02935928f, 0.30799174f, -0.11835942f, -0.04779449f, -0.17481191f, 
    -0.00444354f, 0.01334482f, 0.06010634f, -0.06407104f, 0.10876941f, -0.05297516f, -0.01778508f, -0.02345488f, 
    0.21900913f, 0.29694688f, 0.11676165f, -0.07771739f, 0.10762846f, 0.04045944f, 0.08711809f, 0.17661224f, 
    0.00509635f, 0.00234748f, 0.09917071f, -0.01540672f, -0.19238789f, 0.08972838f, -0.10538660f, 0.19168645f, 
    0.07955935f, 0.11424229f, -0.03195817f, -0.05437785f, 0.06307041f, -0.13899046f, 0.10360867f, 0.06974863f, 
    0.15580001f, -0.36182007f, 0.20232463f, -0.45965734f, -0.11545735f, 0.06470782f, -0.01219781f, 0.03521403f, 
    0.10927078f, 0.04715552f, -0.06571054f, 0.03100841f, 0.28342310f, -0.20583488f, 0.16169344f, -0.28269783f, 
    -0.00764368f, 0.09349364f, -0.13483042f, 0.28657430f, -0.07369720f, -0.06782763f, 0.00816554f, 0.08380219f, 
    0.11128531f, -0.10014570f, 0.09053741f, -0.06912923f, -0.05961927f, 0.08553664f, 0.03400653f, 0.08164561f, 
    0.14650685f, -0.14196381f, -0.14276388f, -0.07912847f, 0.05671746f, 0.19253264f, 0.12832493f, -0.21910083f, 
    0.04097651f, -0.04339955f, 0.08466565f, 0.11635674f, 0.12986092f, -0.04531278f, 0.08355454f, 0.02546758f, 
    -0.14195715f, 0.04047120f, -0.19752420f, 0.09317007f, 0.08908370f, -0.05402377f, 0.02133116f, -0.09966231f, 
    0.19243242f, -0.12410764f, -0.03532292f, 0.03621012f, -0.08449972f, 0.19178995f, -0.12001708f, -0.11797176f, 
    0.05408800f, 0.03543937f, 0.15720403f, 0.08682641f, 0.10159215f, -0.05222807f, -0.06090432f, 0.02933931f, 
    0.10729954f, 0.13545047f, 0.21653256f, -0.00912333f, -0.10960591f, -0.02615009f, -0.13321882f, 0.16937430f, 
    0.09982412f, 0.03327144f, -0.09027230f, -0.16609937f, 0.39713311f, 0.11085153f, 0.23797855f, 0.03711943f, 
    0.05739601f, 0.13921405f, 0.12856057f, 0.08194112f, 0.07589296f, -0.04134684f, -0.08570436f, -0.03250627f, 
    0.06968935f, 0.00809534f, -0.05234748f, -0.20846403f, 0.14838350f, 0.07539066f, 0.16617288f, 0.13495381f, 
    0.01475238f, -0.05233520f, -0.06058552f, 0.06551782f, -0.29785037f, 0.11884882f, 0.05533545f, -0.05521803f, 
    -0.07327303f, -0.08016131f, -0.02276293f, 0.01130435f, 0.15464231f, -0.13979612f, 0.00844490f, -0.02403949f, 
    -0.10505766f, 0.14860007f, 0.26208934f, -0.12666786f, -0.02519733f, 0.05438122f, 0.06430118f, -0.00254639f, 
    -0.02721888f, -0.13166012f, 0.02618382f, 0.06598954f, -0.14168566f, 0.26395667f, 0.08851819f, 0.20458543f, 
    -0.06461606f, 0.11900678f, -0.00526732f, 0.05682008f, -0.03158533f, 0.04529174f, 0.09773470f, -0.17396402f, 
    -0.06999271f, -0.03348098f, 0.02655639f, 0.13141209f, 0.01176395f, -0.01057660f, -0.02712483f, -0.12750074f, 
    0.02943011f, -0.05566979f, 0.10315982f, -0.03756859f, -0.03867901f, -0.12310553f, 0.02651543f, 0.08702134f, 
    -0.03885604f, 0.00544811f, -0.00836110f, 0.08204965f, 0.00024915f, -0.07941903f, 0.03531250f, 0.05395348f, 
    -0.11078528f, -0.19600762f, 0.02815582f, -0.26412237f, 0.15690041f, 0.00037158f, 0.02273830f, -0.22483893f, 
    0.05914181f, 0.09264490f, -0.03521665f, 0.15102269f, -0.16350697f, -0.08675692f, -0.04863918f, 0.15808406f, 
    0.04670752f, -0.05578800f, -0.01608307f, -0.11116703f, -0.10479456f, -0.06582098f, 0.01052585f, -0.04370381f, 
    -0.03223271f, 0.10286073f, -0.29154941f, -0.05502161f, -0.06342071f, -0.07477225f, 0.08114178f, 0.00404045f, 
    0.09313338f, 0.01537933f, -0.09240281f, 0.20826969f, -0.13383256f, 0.21730532f, -0.23913793f, 0.12925322f, 
    -0.03241676f, -0.01687738f, -0.06815059f, 0.06025496f, -0.00923449f, 0.10901435f, -0.00153607f, 0.14619854f, 
    0.23878725f, -0.03776585f, -0.12977487f, 0.05763850f, 0.04263384f, -0.05034791f, -0.05438067f, -0.04964634f, 
    0.14844432f, 0.07154399f, -0.03559395f, -0.07426964f, 0.17703624f, 0.22338550f, 0.03935979f, -0.30864152f, 
    -0.12327065f, 0.07967485f, 0.00719982f, 0.19358590f, -0.02146956f, -0.08923738f, 0.09444380f, -0.12929805f, 
    0.17062494f, -0.25345162f, 0.12042734f, -0.09440340f, 0.08269946f, -0.09827485f, 0.08494730f, -0.04831654f, 
    0.00471516f, 0.18074927f, -0.04814979f, 0.04064694f, -0.09263191f, -0.09680981f, 0.02631336f, 0.22598481f, 
    0.03173660f, -0.04162338f, -0.04175683f, -0.11093087f, 0.05722031f, -0.04903243f, 0.09755148f, 0.00112332f, 
    -0.23456572f, -0.20495951f, -0.22332302f, -0.23320882f, -0.05621944f, 0.12342708f, 0.03671322f, 0.09307855f, 
    0.12962908f, -0.01104203f, -0.07790855f, -0.01614216f, -0.28627062f, -0.05658877f, 0.00614917f, 0.00255210f, 
    -0.03961806f, 0.06754425f, 0.09848253f, -0.07797382f, 0.07295975f, -0.02325267f, -0.07443439f, -0.01429073f, 
    0.09039511f, 0.11949678f, 0.06106597f, -0.16199489f, 0.08184714f, 0.00139475f, 0.09776068f, 0.18728508f, 
    0.02951871f, -0.02732894f, 0.02769647f, 0.12447654f, -0.16448082f, 0.07602903f, -0.17056620f, -0.09626483f, 
    -0.19600052f, -0.00146827f, -0.04140675f, 0.08246636f, 0.23997574f, -0.01351069f, -0.07511892f, 0.06051768f, 
    0.03503073f, -0.22519296f, 0.20454668f, -0.13831910f, -0.02084154f, -0.07081523f, -0.08681805f, 0.09891348f, 
    0.04553582f, 0.01756721f, -0.04753340f, -0.01920763f, 0.32630306f, 0.17174439f, -0.34337741f, 0.37516060f, 
    -0.12124879f, 0.05186536f, -0.04121096f, -0.02593842f, 0.03601121f, -0.05686062f, -0.01385055f, -0.05521677f, 
    0.13225740f, -0.04250541f, -0.01162601f, -0.02191073f, -0.15839992f, 0.02068071f, -0.15716156f, -0.07040343f, 
    0.10833348f, -0.06174750f, 0.08534003f, 0.06849010f, -0.07655171f, -0.08681232f, 0.13265678f, -0.15455702f, 
    -0.01170687f, 0.01631683f, -0.04250378f, 0.11180890f, -0.00694619f, 0.02106060f, -0.00981430f, -0.00694757f, 
    0.53423327f, -0.11773969f, 0.30435801f, 0.07910948f, 0.03449650f, 0.10699780f, 0.03043883f, 0.01376792f, 
    0.04596604f, -0.04038543f, 0.06546389f, 0.08190916f, 0.07853445f, -0.22723345f, 0.29120949f, 0.02783959f, 
    -0.04512227f, -0.13253905f, -0.02397326f, -0.18099961f, 0.03812499f, 0.04068769f, -0.06483614f, 0.01283925f, 
    0.12039991f, -0.38851687f, 0.12842500f, -0.42770413f, 0.04237863f, -0.08792945f, 0.09405579f, -0.05382400f, 
    -0.11780318f, 0.16341200f, 0.06842605f, 0.09441637f, -0.02966130f, 0.30598328f, -0.00846618f, -0.08457737f, 
    0.08158549f, 0.02949684f, -0.03927187f, 0.11460377f, 0.01374252f, -0.07101431f, 0.05898977f, 0.11204808f, 
    -0.20796105f, 0.23377311f, -0.06797598f, -0.22827590f, 0.03148526f, -0.02979792f, 0.01363265f, 0.07741456f, 
    0.02076180f, 0.03617965f, -0.03386767f, 0.03703703f, -0.10820953f, -0.07160979f, 0.03767573f, -0.39552242f, 
    -0.06952371f, -0.08454876f, 0.10463880f, 0.09099216f, 0.13288714f, 0.00348883f, 0.02046287f, -0.10499397f, 
    0.23058052f, -0.24985927f, -0.17766251f, -0.16103503f, -0.08880010f, -0.02247572f, -0.02011253f, 0.05501703f, 
    0.10990574f, -0.01727980f, 0.04556156f, -0.01616171f, -0.05512220f, -0.00138570f, 0.12654752f, 0.05012984f, 
    -0.09123659f, -0.07742009f, 0.05621391f, -0.03935033f, 0.05795738f, -0.00662126f, -0.07499310f, -0.09278373f, 
    -0.06380328f, 0.00588563f, 0.10998231f, 0.09099936f, -0.02915175f, -0.00499574f, -0.07710357f, -0.09260728f, 
    0.08562081f, 0.00466590f, 0.06938270f, 0.13537717f, -0.36664248f, 0.09676132f, -0.05393591f, -0.22067265f, 
    -0.13931246f, 0.06993555f, 0.05081240f, -0.16628754f, 0.09435491f, -0.08049124f, -0.04578144f, 0.17225410f, 
    -0.29544616f, 0.28746781f, -0.12630494f, -0.06541237f, 0.08659945f, -0.08843664f, 0.09229545f, 0.16840744f, 
    0.08832416f, 0.06566897f, -0.05988636f, -0.08346138f, -0.08926424f, 0.15638350f, -0.10446966f, 0.05128006f, 
    -0.06996810f, -0.12955289f, -0.00478573f, 0.02526204f, -0.03542527f, 0.05224395f, -0.01710669f, -0.03657544f, 
    0.29741612f, -0.09192770f, 0.19745353f, -0.45982680f, 0.07535052f, 0.08510407f, 0.06330847f, 0.12927428f, 
    -0.01672917f, 0.17019826f, 0.02299510f, -0.00206472f, 0.17465240f, -0.07048335f, -0.12592304f, -0.11560587f, 
    0.02081006f, 0.08165623f, 0.05744651f, 0.12269663f, 0.09469455f, -0.08491215f, 0.09829038f, -0.05960568f, 
    0.03909199f, 0.09895386f, 0.04375099f, 0.11059105f, -0.23693493f, -0.09540771f, -0.03119880f, -0.01461488f, 
    0.00874310f, 0.06997862f, 0.08416537f, 0.09642193f, 0.30758527f, -0.07406720f, 0.20342720f, 0.06390098f, 
    0.10049298f, 0.14112741f, -0.07415643f, 0.01172869f, 0.08689176f, -0.01797289f, -0.05279059f, -0.01794436f, 
    0.40598243f, -0.22581135f, 0.03325646f, 0.00534762f, -0.07578237f, -0.11560548f, -0.00412126f, -0.05801966f, 
    0.14505757f, -0.10661960f, 0.04865979f, 0.04809842f, -0.11096055f, -0.00637323f, -0.08478678f, -0.19399108f, 
    0.03647075f, 0.16320726f, 0.11294348f, -0.07948044f, 0.01068204f, -0.05531105f, 0.08357161f, 0.07008038f, 
    0.39275473f, -0.16355021f, 0.32863846f, -0.18784797f, 0.13461417f, 0.05966214f, -0.08842473f, 0.08909929f, 
    0.01968733f, 0.14729601f, 0.07411406f, -0.02462235f, 0.26701531f, -0.24900615f, 0.22773142f, -0.13847588f, 
    -0.26628277f, 0.00778483f, -0.14462276f, -0.09262510f, 0.20638773f, -0.01750735f, -0.06521571f, -0.02410662f, 
    0.22204959f, 0.06306939f, 0.01725179f, -0.21416064f, -0.08350710f, 0.18012738f, 0.18424788f, -0.01433765f, 
    0.00740185f, 0.09356797f, 0.01302564f, 0.05093887f, -0.00157349f, -0.11272604f, 0.15690604f, 0.41758811f, 
    -0.02231355f, 0.13806841f, 0.05297448f, -0.04656507f, 0.07056751f, 0.01081044f, 0.03062839f, 0.16149695f, 
    0.50103384f, 0.02549434f, 0.21872407f, 0.06658716f, 0.21866819f, -0.02680201f, 0.06626148f, -0.06178122f, 
    0.13018344f, -0.05132324f, 0.02361175f, 0.00520071f, -0.08289594f, -0.05075556f, -0.02563198f, -0.09546867f, 
    -0.02066285f, -0.03952667f, -0.02342258f, 0.07699866f, 0.01720962f, -0.04572029f, 0.07347105f, 0.01746325f, 
    -0.57126564f, 0.28157714f, -0.48285377f, 0.20106427f, 0.11953218f, 0.10875975f, 0.06057932f, 0.20533079f, 
    0.13541132f, -0.04223287f, 0.08908276f, 0.04634535f, -0.06202887f, 0.32187629f, -0.39724591f, -0.12363745f, 
    0.00901130f, 0.01595736f, 0.15336300f, 0.21629705f, -0.13168702f, 0.01036925f, -0.01675230f, -0.05917577f, 
    0.40495759f, -0.24181166f, -0.09432409f, -0.24247570f, -0.00119485f, 0.08590681f, 0.00977405f, 0.04933926f, 
    0.02532703f, 0.10925407f, -0.07644995f, 0.13282709f, 0.16827554f, -0.38389322f, -0.08363119f, -0.20421296f, 
    0.10151735f, 0.15417504f, 0.02922090f, -0.07335173f, 0.00791602f, 0.04032423f, -0.13778737f, -0.11419681f, 
    0.08235319f, -0.21324728f, 0.06776766f, -0.24371544f, -0.20475067f, 0.01942960f, -0.01954318f, -0.12946168f, 
    0.11515679f, 0.02468237f, 0.09974825f, 0.06182848f, -0.46892509f, 0.07115816f, -0.12114311f, -0.10492693f, 
    -0.12038870f, 0.04498111f, -0.00144352f, 0.04637183f, -0.00352858f, -0.08050996f, 0.03668177f, -0.04253008f, 
    0.01182126f, -0.04237200f, -0.04267502f, -0.01648332f, 0.00629773f, -0.02115629f, -0.03438195f, -0.02767566f, 
    -0.00247120f, -0.02463981f, 0.00927812f, 0.00805533f, -0.00482222f, 0.01026698f, -0.03005396f, -0.01036917f, 
    -0.04362860f, -0.02510763f, -0.04125441f, 0.02581707f, -0.03694119f, 0.02613261f, 0.01701106f, -0.01514771f, 
    -0.00560700f, -0.00540700f, -0.00286771f, -0.03046694f, -0.01631648f, -0.01044547f, 0.02026453f, -0.00028124f, 
    0.02414049f, -0.01832247f, -0.04330768f, -0.00682154f, 0.02356154f, -0.01295176f, -0.00794827f, 0.01262114f, 
    -0.01997897f, -0.04052386f, -0.00218151f, 0.00677419f, 0.02262548f, 0.01198830f, -0.04342974f, -0.01516537f, 
    -0.03067714f, -0.01635529f, -0.02010456f, -0.00480528f, -0.02201245f, 0.01730638f, -0.01006168f, 0.00823270f, 
    0.02087023f, -0.00660874f, -0.01040205f, 0.01177821f, -0.00934273f, -0.02440053f, 0.00638913f, -0.00667848f, 
    0.02602354f, 0.02386139f, 0.00106202f, -0.03873930f, 0.00037184f, -0.00603086f, -0.00872466f, 0.00499826f, 
    -0.04282920f, -0.00345265f, -0.01286206f, -0.04151471f, -0.03545064f, 0.01612982f, -0.03359637f, 0.01620738f, 
    0.00691706f, -0.02596154f, -0.00320958f, -0.04054864f, -0.00636096f, 0.02246828f, -0.01667492f, 0.02985939f, 
    -0.04211485f, 0.02308449f, -0.02237072f, 0.00342041f, -0.04607410f, -0.03211469f, 0.01639891f, 0.02410889f, 
    -0.01263575f, -0.02374374f, 0.01472355f, -0.03658183f, -0.00199657f, 0.00498637f, 0.00686251f, 0.01607394f, 
    -0.02441520f, -0.02202567f, 0.02160077f, -0.03232230f, 0.01608610f, -0.01814217f, -0.03533078f, -0.02001017f, 
    -0.00771866f, 0.01015129f, -0.04008229f, 0.00701100f, -0.02612396f, 0.00232930f, -0.01950824f, -0.02736911f, 
    0.01853675f, -0.00288142f, -0.03664882f, 0.02207176f, -0.02774396f, -0.00629524f, -0.00261820f, 0.00596684f, 
    0.01874957f, 0.00887364f, -0.03657737f, -0.00425977f, -0.00097978f, -0.03601111f, 0.00634629f, 0.01209970f, 
    -0.03455205f, -0.03757527f, 0.01655006f, -0.01945972f, 0.00752861f, 0.02381697f, 0.01011590f, -0.01178464f, 
    -0.03062164f, 0.01204824f, -0.04086253f, 0.01895805f, -0.03543918f, -0.00535545f, 0.01115386f, 0.01652348f, 
    0.00117310f, 0.01170425f, -0.02643872f, -0.02500430f, -0.00285559f, -0.00474882f, -0.01161107f, 0.00152303f, 
    0.02570816f, -0.00399425f, 0.01855702f, 0.02108526f, -0.00160869f, 0.02046444f, -0.00232782f, 0.00941243f, 
    -0.02818048f, -0.01865673f, 0.01186435f, 0.00780519f, -0.00878015f, -0.00992613f, -0.00489201f, -0.04055860f, 
    -0.03540624f, -0.01920997f, -0.01778788f, 0.02397376f, 0.02480144f, 0.00392244f, 0.00395044f, -0.03886373f, 
    -0.01941922f, -0.04407085f, -0.03088145f, -0.02534632f, -0.00738067f, -0.01362525f, 0.02548754f, 0.02064716f, 
    -0.02340289f, 0.01613894f, -0.03148245f, -0.02347636f, -0.04000365f, -0.03852496f, 0.01052980f, -0.02579474f, 
    0.01290724f, -0.02675890f, -0.01106436f, 0.00679351f, 0.00805263f, -0.03065967f, -0.02819790f, 0.01940549f, 
    0.01602330f, -0.02061109f, -0.03731346f, -0.00334640f, -0.00472522f, 0.01655454f, 0.02640146f, -0.01746234f, 
    0.01100126f, -0.01269739f, 0.01690418f, 0.01081801f, 0.02115228f, -0.00079860f, -0.02819582f, 0.02359705f, 
    0.01659423f, 0.00023015f, 0.00900942f, -0.02170476f, -0.03969324f, 0.00453463f, 0.01423617f, 0.01314339f, 
    -0.04378489f, -0.01550776f, -0.03373081f, -0.01570458f, -0.03774732f, 0.02077946f, 0.01613777f, 0.00805377f, 
    0.02332904f, -0.01798875f, -0.00826351f, 0.00190234f, 0.02271626f, -0.01472638f, 0.02748004f, -0.01691447f, 
    0.00238182f, 0.02360819f, 0.00281831f, 0.02349897f, -0.04403904f, -0.04445653f, -0.03854036f, 0.01800841f, 
    -0.02195277f, -0.00093263f, -0.01255997f, -0.00221336f, 0.00335832f, -0.00524564f, -0.02441413f, 0.00026477f, 
    -0.01460616f, -0.02434632f, 0.02336363f, 0.00770998f, 0.02136513f, -0.01970065f, -0.02660708f, 0.02003551f, 
    -0.01923698f, -0.02625448f, -0.00516031f, -0.02553006f, -0.01584269f, -0.03995538f, 0.00232900f, -0.03874314f, 
    0.02302105f, 0.02617358f, -0.03106783f, -0.00246527f, 0.00078118f, 0.01300041f, -0.01282156f, -0.01583278f, 
    -0.01612985f, 0.00545186f, 0.01806086f, 0.02588820f, 0.00966935f, -0.04076352f, -0.02415395f, 0.01144604f, 
    0.01775513f, 0.00909898f, 0.02037253f, -0.03861436f, -0.03446449f, -0.02667707f, -0.01390341f, -0.04215787f, 
    0.00042139f, 0.01416716f, -0.04313255f, -0.04174938f, -0.03396392f, 0.00435363f, 0.00973139f, -0.03083908f, 
    -0.01823379f, -0.00338484f, -0.04044990f, -0.04386833f, 0.01095706f, 0.00739617f, 0.00544122f, -0.01010518f, 
    -0.02606822f, 0.01716550f, -0.00067907f, -0.04476325f, 0.01010969f, -0.03755775f, -0.02134975f, -0.04373129f, 
    -0.01076490f, -0.03140746f, -0.03213776f, -0.00993162f, 0.00575634f, -0.00131847f, 0.02249702f, -0.01356685f, 
    -0.03859220f, 0.00153237f, 0.01777336f, 0.01827406f, -0.01472680f, 0.02372812f, -0.01177623f, 0.00044890f, 
    -0.01190152f, 0.00790740f, 0.02545481f, 0.02390214f, -0.03146112f, 0.01441533f, -0.02688273f, 0.00593611f, 
    -0.00228955f, -0.04237688f, -0.03039722f, -0.00890651f, -0.01097307f, -0.00316774f, -0.02601469f, 0.01159883f, 
    -0.00897178f, -0.00497175f, -0.01907992f, -0.03705260f, 0.00581284f, -0.04211539f, 0.02028304f, -0.01339182f, 
    -0.00701366f, -0.02555744f, 0.01729069f, -0.02507122f, 0.02918846f, -0.03608631f, -0.01103589f, 0.00788097f, 
    -0.02562308f, -0.04058354f, 0.00567972f, 0.02856057f, -0.01278025f, 0.01403240f, 0.01789450f, -0.02979803f, 
    -0.03434102f, 0.02392170f, -0.04402034f, -0.02140656f, -0.00274728f, -0.00346557f, -0.01854993f, 0.00427446f, 
    -0.01364218f, -0.02678051f, 0.00750934f, 0.00824668f, -0.02571985f, -0.01341779f, 0.01824876f, -0.00185317f, 
    -0.03001056f, -0.01069855f, -0.00622357f, -0.01912972f, -0.01607018f, -0.01441718f, -0.02616980f, -0.00766023f, 
    -0.03368714f, -0.00052724f, -0.01495554f, -0.03499397f, -0.00398388f, 0.01678551f, -0.00158234f, -0.00753730f, 
    -0.04027214f, 0.00782023f, -0.02507804f, -0.00080999f, 0.01628124f, 0.00630592f, -0.01270759f, -0.01613173f, 
    -0.04512462f, -0.00221563f, -0.01050118f, -0.00546671f, -0.04180723f, 0.01800085f, 0.00518987f, 0.01871129f, 
    0.01795378f, -0.01216142f, 0.00135136f, -0.00141795f, -0.04022695f, 0.01524234f, 0.01499895f, -0.00296844f, 
    0.01961617f, -0.00928729f, -0.01902327f, 0.00613896f, -0.01523084f, 0.00920377f, -0.02070341f, -0.03719875f, 
    0.00608992f, 0.00266727f, -0.01910998f, -0.00281925f, -0.01883304f, -0.03308325f, -0.02442721f, -0.00785021f, 
    0.01410881f, -0.02683096f, -0.04515059f, -0.03511452f, 0.01395480f, -0.02730604f, -0.02538398f, 0.02685529f, 
    -0.03021838f, -0.03384522f, 0.01144226f, 0.01969196f, -0.03492372f, 0.01784058f, 0.00481986f, -0.02827638f, 
    -0.00489029f, -0.01252541f, -0.02178442f, 0.02419466f, -0.00301471f, 0.00546050f, 0.01358152f, 0.00685766f, 
    0.01787769f, -0.00172682f, -0.02793009f, 0.02251499f, -0.02760397f, -0.00533383f, 0.00460349f, 0.00108512f, 
    0.00284376f, -0.04247900f, 0.02480880f, 0.00094337f, 0.03018556f, -0.00867939f, -0.01951333f, 0.02317612f, 
    0.00778065f, -0.02108230f, 0.00817405f, 0.01841984f, -0.02879502f, -0.00075213f, -0.00518908f, 0.01017989f, 
    0.02353455f, 0.00163678f, -0.00857329f, -0.01600039f, -0.01436004f, -0.04501214f, -0.00974644f, 0.02003818f, 
    -0.01198950f, 0.02007162f, -0.01925435f, -0.01380636f, -0.00119236f, 0.00984943f, -0.00312403f, 0.00260942f, 
    0.02369350f, -0.04000164f, -0.01212212f, -0.02029909f, -0.03894952f, -0.04515757f, -0.02607992f, 0.02391762f, 
    -0.01427081f, 0.00890710f, -0.01090977f, -0.03353577f, -0.03057501f, -0.02009430f, -0.01405704f, -0.00303669f, 
    0.00188352f, 0.00214965f, 0.01567987f, 0.02325063f, -0.02962167f, -0.01281792f, -0.00560963f, 0.01145131f, 
    0.02842953f, 0.02367552f, -0.00641693f, -0.02208632f, -0.01621123f, 0.01440782f, -0.01001009f, -0.01428026f, 
    -0.01632415f, 0.02392391f, -0.02289915f, -0.02005231f, -0.00622822f, 0.02425961f, -0.03898808f, -0.02574894f, 
    -0.03579446f, 0.01923763f, -0.01628883f, -0.00013753f, 0.02338000f, -0.02568869f, -0.02854404f, -0.00672042f, 
    -0.04195733f, -0.04490748f, 0.01736294f, 0.01202486f, 0.01241543f, -0.02395635f, -0.02178109f, 0.00062462f, 
    0.02150965f, -0.02616801f, -0.02689959f, 0.01023785f, 0.01502746f, 0.00655418f, -0.04211504f, -0.02473379f, 
    0.00223440f, 0.01364596f, 0.01686219f, -0.00155609f, 0.00157582f, 0.01344349f, -0.00388392f, -0.01654420f, 
    0.00645295f, 0.01203935f, -0.01445620f, -0.01754243f, -0.00421198f, -0.04039190f, -0.01104628f, 0.01022526f, 
    -0.03814111f, 0.00018671f, 0.02636105f, -0.04342065f, 0.01450975f, -0.01329757f, 0.02058555f, 0.01992017f, 
    -0.03584641f, -0.03649534f, -0.01366488f, 0.02336111f, -0.00910353f, -0.03559741f, -0.03510679f, 0.00979842f, 
    -0.01524959f, 0.02139245f, 0.00391813f, 0.00963154f, -0.02776979f, 0.02405737f, -0.01424092f, -0.04247800f, 
    -0.01048073f, -0.01289672f, 0.00114790f, 0.02067338f, 0.00365065f, 0.01601687f, 0.02406230f, 0.00743105f, 
    -0.03021899f, -0.00669372f, -0.03537278f, 0.01165506f, -0.02831246f, 0.00736920f, 0.02408922f, 0.01622242f, 
    0.01230536f, -0.03874823f, -0.02684818f, -0.01616654f, 0.00985271f, -0.02675745f, 0.00678833f, -0.03597198f, 
    -0.02286080f, -0.03197017f, 0.00465891f, 0.01163251f, -0.02462477f, -0.03674729f, -0.03889654f, 0.00303641f, 
    -0.01169823f, 0.02039595f, -0.03080067f, 0.00795403f, -0.00529196f, 0.00929587f, 0.01001159f, 0.01565831f, 
    -0.00345586f, -0.00022490f, 0.00904021f, 0.01160292f, 0.02257438f, 0.01088051f, -0.01054100f, 0.01940748f, 
    0.02665865f, -0.02768783f, -0.02131852f, 0.02153112f, -0.03199965f, 0.01956346f, -0.00084779f, -0.02373948f, 
    -0.03415675f, 0.01699255f, -0.03766545f, -0.04387210f, -0.02376495f, -0.02361581f, -0.02625960f, 0.02502315f, 
    -0.00178297f, -0.02273868f, 0.02162223f, -0.02030336f, 0.01306681f, 0.00085247f, 0.01548039f, -0.03644259f, 
    -0.03951341f, -0.03272091f, -0.02388979f, 0.00962322f, -0.01639319f, 0.02773265f, -0.03486627f, -0.03841912f, 
    0.01877563f, 0.01086535f, -0.02568290f, -0.04096984f, 0.00912414f, -0.02393082f, 0.01255476f, -0.00582121f, 
    0.01553923f, 0.01008144f, -0.04113871f, 0.00838849f, 0.01092259f, 0.00126233f, -0.00918605f, -0.04053800f, 
    -0.00096225f, -0.02347220f, -0.00195010f, 0.00386389f, 0.00396316f, -0.02095179f, 0.02026496f, -0.02994924f, 
    0.01971643f, 0.00144520f, 0.00317998f, -0.02671961f, -0.02981062f, 0.01885866f, 0.00476981f, 0.00605251f, 
    0.02192340f, -0.02424385f, -0.03171972f, -0.01361489f, -0.00054848f, 0.01800575f, -0.04399084f, -0.01185843f, 
    0.02069952f, -0.03332632f, -0.03355112f, -0.03456590f, -0.03196885f, -0.03220311f, 0.00262530f, 0.01301855f, 
    -0.00349428f, -0.00288248f, -0.00325279f, 0.02322815f, 0.01221475f, -0.02530573f, -0.01837324f, -0.00903352f, 
    -0.02989399f, -0.00127012f, -0.02016727f, 0.00930626f, 0.00729566f, -0.03001947f, 0.00203093f, 0.00761451f, 
    -0.02209479f, -0.01857279f, -0.00304362f, -0.01661091f, 0.02902267f, -0.00560212f, -0.01592916f, -0.03574959f, 
    0.02747165f, -0.00183202f, -0.01577802f, -0.00151624f, -0.00982245f, -0.02051114f, -0.01801663f, 0.01496184f, 
    0.00309498f, -0.03107388f, -0.02577418f, 0.02953057f, -0.02111115f, -0.00631430f, -0.03517706f, 0.02861268f, 
    -0.01654164f, -0.03359008f, 0.02330854f, 0.02067759f, -0.01786191f, -0.02245130f, -0.01230135f, -0.01815290f, 
    0.01081316f, 0.01695043f, 0.00923204f, 0.01649637f, -0.01691453f, 0.01406239f, -0.03140943f, -0.00729963f, 
    0.01744463f, -0.03461190f, -0.01479736f, 0.01730337f, 0.02353901f, -0.02010792f, -0.02063375f, -0.03901570f, 
    -0.02718143f, -0.03858248f, -0.02123147f, -0.01304251f, 0.01976438f, 0.00899859f, -0.00067909f, -0.03921619f, 
    0.02950586f, 0.01380805f, 0.01469962f, 0.01121721f, -0.01463595f, -0.03500826f, -0.00111912f, 0.00847124f, 
    0.01483449f, 0.01023770f, 0.01189854f, -0.02666499f, 0.02374114f, -0.03899267f, -0.02543829f, -0.03979856f, 
    -0.00729810f, -0.02603185f, -0.00774181f, 0.03082908f, 0.01736837f, -0.01366905f, 0.00931250f, -0.02344764f, 
    -0.01934364f, 0.00782754f, -0.02283330f, -0.00224244f, 0.02624380f, -0.02893172f, -0.01657591f, -0.02868549f, 
    0.02830225f, -0.02911836f, 0.00018613f, -0.02794017f, -0.03012535f, 0.01213325f, -0.01903163f, 0.01041709f, 
    -0.00564493f, -0.02135877f, 0.02152404f, -0.00283575f, -0.02929337f, 0.01945459f, 0.00367134f, 0.01093231f, 
    -0.03165280f, 0.02913917f, -0.03312957f, -0.01648710f, -0.03745277f, -0.02825794f, -0.01280973f, -0.01798604f, 
    -0.02010022f, 0.01209420f, -0.02754302f, 0.01384684f, -0.03217037f, -0.01654858f, 0.00023441f, -0.01197251f, 
    0.02477224f, -0.02433745f, 0.00511092f, -0.00622348f, 0.00505979f, -0.00724980f, -0.00145798f, 0.00022282f, 
    -0.02801570f, -0.01704669f, -0.03282281f, -0.02379324f, -0.00791324f, 0.00438443f, -0.02400632f, 0.00956311f, 
    0.00968996f, -0.01219433f, -0.00235790f, -0.01137979f, -0.03775071f, 0.00165225f, 0.01953575f, 0.02568179f, 
    0.01299107f, 0.00795577f, -0.02074341f, -0.02473432f, -0.02033388f, -0.01456112f, -0.00407798f, 0.01281912f, 
    -0.00634823f, -0.00475101f, 0.01425017f, 0.01682950f, -0.03437541f, -0.01228570f, 0.00706462f, 0.01955834f, 
    0.03033737f, -0.01251526f, -0.01193096f, 0.03161570f, 0.00206935f, -0.01807222f, -0.00612857f, -0.02088108f, 
    -0.00381132f, -0.03850723f, -0.00058139f, -0.02893127f, -0.00305440f, 0.00478524f, -0.03026646f, 0.02835154f, 
    0.03009418f, 0.00189620f, -0.01998684f, 0.01728759f, -0.04109336f, -0.00221890f, -0.03734557f, -0.02714268f, 
    -0.03718790f, -0.03550131f, 0.02616666f, -0.03088750f, 0.01662266f, -0.01131620f, 0.01659199f, -0.00260692f, 
    0.03009484f, -0.00247253f, 0.00219050f, -0.02476898f, 0.00633009f, 0.02632411f, -0.01734807f, -0.02582538f, 
    -0.00767948f, 0.00936940f, 0.02353370f, -0.01230255f, 0.00081732f, -0.00309466f, -0.00197447f, -0.01271776f, 
    -0.00522054f, 0.03016661f, -0.00023143f, -0.03307484f, -0.02392752f, 0.00368845f, -0.01092525f, -0.01011490f, 
    0.00822490f, -0.02429278f, 0.01817729f, -0.01702271f, 0.02374143f, 0.00809339f, 0.00314468f, -0.03937988f, 
    -0.01717069f, 0.01394780f, -0.03491810f, -0.02207273f, 0.00387034f, -0.02729374f, -0.01039886f, -0.00804844f, 
    -0.03402370f, 0.00494777f, -0.02540242f, 0.03149059f, -0.03134907f, 0.00066481f, 0.00959235f, -0.00457322f, 
    0.01851821f, 0.02031494f, -0.01564535f, 0.01847059f, -0.00181551f, -0.02114814f, -0.01653490f, -0.02433635f, 
    0.00526668f, -0.02164235f, 0.00327659f, 0.02942313f, -0.03012990f, -0.03053620f, 0.01439928f, 0.00775297f, 
    0.01119525f, 0.02687534f, 0.02152330f, -0.04141101f, -0.01315934f, -0.02729810f, -0.04007444f, -0.03853538f, 
    -0.03069494f, -0.02651574f, -0.03153786f, -0.01839364f, 0.00944172f, -0.00136727f, 0.00024826f, -0.02004065f, 
    0.01378836f, 0.02647503f, -0.02667455f, -0.03963285f, -0.03183447f, 0.00826230f, -0.03339753f, 0.02161639f, 
    0.02616581f, -0.03519618f, -0.02657491f, -0.01673939f, -0.00201496f, 0.02944082f, 0.02879965f, 0.02819698f, 
    -0.02713739f, -0.02231865f, -0.02437692f, -0.00363656f, 0.00308419f, -0.03381027f, -0.03674521f, -0.03622416f, 
    -0.00379918f, -0.02422305f, 0.00782930f, -0.03753728f, 0.01761680f, -0.02491365f, 0.01583509f, 0.01065590f, 
    -0.03332574f, -0.00733321f, -0.01130546f, 0.00123194f, -0.02627481f, 0.01306393f, -0.01329036f, 0.01819004f, 
    0.00546285f, -0.03690400f, -0.00809022f, 0.01734684f, -0.00261405f, -0.01908652f, 0.00836008f, -0.01525631f, 
    0.00887810f, -0.00833237f, -0.03669621f, -0.02869465f, -0.01725887f, -0.04092904f, 0.00186949f, -0.01276257f, 
    -0.02599245f, -0.01335912f, 0.01303065f, 0.02365861f, 0.02772094f, 0.01259156f, -0.02865873f, -0.01321520f, 
    -0.02097218f, 0.02741676f, -0.03511873f, 0.00818799f, -0.00266348f, -0.00905414f, -0.01908940f, -0.04114215f, 
    -0.01777505f, 0.01649862f, 0.00843190f, -0.02882737f, 0.02777612f, -0.01326527f, 0.02849231f, 0.01892863f, 
    -0.03104582f, -0.03464115f, 0.03459471f, -0.02021134f, -0.03600131f, -0.03383289f, -0.03581119f, -0.00948721f, 
    -0.02163103f, -0.03128606f, 0.01949983f, 0.00245338f, -0.02741179f, 0.00756265f, -0.00644168f, 0.01441782f, 
    -0.01443000f, -0.00571793f, 0.01677644f, 0.02244730f, -0.04068132f, -0.02707441f, 0.01689693f, 0.03116686f, 
    0.01068736f, -0.03434830f, -0.02773881f, 0.02390461f, -0.03105094f, -0.03915743f, -0.00825102f, 0.02199084f, 
    -0.01932162f, -0.01379237f, -0.00339251f, -0.02960079f, -0.00063332f, -0.00309464f, -0.01525855f, -0.01526269f, 
    -0.03590838f, 0.00866133f, -0.01062829f, 0.02237098f, 0.02149967f, 0.00468534f, -0.04032671f, 0.00354749f, 
    -0.02403123f, -0.02343494f, -0.00937352f, -0.00744362f, 0.03049639f, 0.00351317f, 0.01372390f, -0.02790428f, 
    -0.00572432f, -0.02244082f, 0.00354732f, -0.00653325f, -0.03041114f, 0.01329224f, 0.02815987f, -0.00912809f, 
    0.00779013f, 0.02230379f, -0.03370656f, 0.02252129f, 0.01618012f, -0.00485944f, -0.01020439f, 0.03032979f, 
    0.00636024f, -0.03878767f, -0.00245245f, -0.00232791f, 0.02973395f, -0.02623560f, -0.01362196f, -0.03738073f, 
    -0.00271382f, -0.02345171f, -0.01809750f, -0.00013123f, -0.03958020f, -0.03986274f, 0.02495277f, -0.00680817f, 
    -0.02206846f, 0.02152684f, 0.01065519f, 0.00218106f, -0.03270702f, -0.02358434f, 0.02058417f, 0.02906494f, 
    0.00327812f, 0.01960013f, 0.01577113f, -0.02518010f, 0.01637622f, -0.00863112f, -0.03897480f, -0.02923682f, 
    -0.03066046f, -0.03957089f, -0.02877783f, 0.03055388f, 0.02770051f, 0.00663065f, 0.02555915f, 0.02126634f, 
    -0.03276593f, -0.01990782f, 0.00921130f, 0.00469563f, 0.02538180f, -0.01022509f, 0.01140324f, -0.02926364f, 
    0.00015696f, 0.00137781f, 0.00835995f, 0.01452526f, -0.01201657f, 0.02943952f, -0.01607534f, 0.01575677f, 
    0.02389901f, 0.00099092f, -0.03909662f, 0.02073419f, 0.01775236f, 0.02264779f, 0.00524157f, -0.01920252f, 
    0.00923344f, -0.03778934f, -0.01900274f, 0.01933018f, 0.00744211f, -0.03979492f, -0.03249789f, -0.00851240f, 
    0.02731968f, -0.02243154f, 0.02616296f, 0.01255484f, -0.03493368f, -0.02928302f, -0.04002365f, 0.02241982f, 
    -0.01072938f, -0.00582771f, 0.00524000f, 0.01604399f, -0.03345761f, 0.02898384f, -0.03174842f, -0.00177125f, 
    0.02942694f, -0.01160702f, 0.00281361f, 0.02178091f, 0.02788989f, -0.02121526f, -0.03960375f, 0.00064507f, 
    -0.00394250f, 0.02502341f, 0.00744764f, 0.02688888f, 0.02864937f, -0.02554085f, 0.01621574f, 0.01761364f, 
    0.00460087f, -0.00707130f, -0.03872499f, 0.00066631f, 0.02627787f, -0.01488519f, 0.01869155f, -0.01243602f, 
    -0.01420009f, -0.00311892f, -0.03504981f, -0.03226757f, -0.01794887f, -0.01762534f, -0.02997240f, -0.01749964f, 
    -0.03625971f, 0.02521149f, -0.02682774f, 0.01491185f, -0.01149185f, -0.03936657f, 0.02977629f, -0.02324229f, 
    0.02495156f, 0.01810760f, -0.02375550f, -0.01422241f, 0.02797811f, -0.03023899f, -0.02598695f, 0.00096400f, 
    -0.02297397f, -0.01283608f, 0.01711460f, -0.03027214f, -0.03346878f, -0.00002447f, -0.01645195f, -0.02751557f, 
    0.00048038f, 0.00820277f, 0.02883203f, -0.00150123f, -0.00562569f, -0.00110981f, 0.00447576f, 0.01908421f, 
    0.00156239f, -0.03308471f, -0.00401842f, 0.02283060f, -0.04109731f, -0.01370181f, 0.01993728f, 0.01133292f, 
    0.01549516f, 0.02488002f, -0.01335061f, -0.03368123f, 0.02951654f, -0.02190761f, -0.02902037f, 0.01644622f, 
    0.01301516f, -0.00418332f, -0.02935035f, 0.00235475f, -0.01976366f, -0.04018351f, -0.03872026f, -0.03979759f, 
    -0.04114895f, -0.02934181f, 0.02747449f, 0.00304453f, -0.00922332f, -0.03055347f, 0.01095210f, -0.03324438f, 
    0.02025471f, -0.00744950f, -0.00564445f, -0.01724557f, 0.01314834f, 0.00284766f, -0.03617872f, 0.00755568f, 
    0.00772460f, 0.01845081f, -0.00886241f, 0.00119613f, -0.00216902f, 0.01366541f, -0.00030695f, -0.03401986f, 
    -0.01534675f, 0.02692176f, -0.02904077f, 0.00124961f, -0.00126865f, 0.02120228f, 0.02462747f, -0.01352355f, 
    -0.01990091f, 0.00298010f, 0.00045960f, -0.03325040f, 0.02779722f, 0.01444036f, 0.01925047f, 0.00555437f, 
    -0.00792578f, 0.00448118f, -0.02228038f, 0.00922011f, -0.00603503f, -0.01302223f, -0.02817082f, -0.03802533f, 
    0.02477895f, -0.00366833f, -0.02792932f, -0.02252423f, -0.02247968f, -0.04021866f, 0.00267289f, -0.00111671f, 
    0.00576747f, -0.01943339f, -0.01455657f, -0.03548369f, 0.00869893f, -0.03314777f, -0.03234007f, -0.01111192f, 
    -0.00649598f, 0.00206744f, -0.02033375f, 0.00051014f, -0.01868730f, -0.00909680f, 0.02695655f, -0.01587984f, 
    0.01345348f, -0.03517979f, -0.00475113f, -0.03392232f, -0.01075260f, -0.03082310f, 0.01803558f, 0.00023364f, 
    0.02289278f, -0.03882778f, 0.02270014f, -0.03949169f, -0.01131113f, 0.00437594f, -0.00626687f, -0.02302679f, 
    0.01668793f, 0.00094666f, 0.02959993f, -0.02351026f, 0.02545631f, 0.00327238f, -0.00729150f, -0.01315803f, 
    -0.02663477f, -0.03119305f, -0.01069528f, 0.01089133f, -0.01751695f, -0.02730928f, -0.03285269f, 0.02262273f, 
    0.00781028f, -0.04118858f, -0.02413117f, -0.01711201f, 0.02154404f, -0.00754829f, -0.04097583f, 0.00767746f, 
    0.02495968f, 0.02041705f, -0.02733124f, -0.02335114f, 0.02441114f, 0.02681263f, -0.00803775f, -0.03052359f, 
    -0.01678370f, 0.01635880f, -0.01367027f, 0.00456863f, -0.00973040f, -0.01010580f, 0.02656574f, 0.02471411f, 
    -0.02365821f, 0.01857361f, 0.01118626f, -0.03236922f, -0.01836852f, 0.00688612f, -0.00023970f, -0.03222614f, 
    0.00601535f, -0.03004001f, -0.02925239f, -0.03123578f, 0.00925239f, -0.01259469f, -0.02648432f, -0.03213227f, 
    -0.02733538f, 0.00302082f, 0.02484068f, -0.01708894f, -0.03617701f, -0.02786353f, -0.00781065f, -0.01239429f, 
    -0.03876770f, -0.03346346f, -0.01438862f, 0.01428839f, 0.00888870f, -0.00547577f, -0.03810204f, -0.03861416f, 
    0.03048235f, -0.01628332f, -0.01572576f, -0.00914991f, 0.00356599f, 0.01085089f, -0.02086933f, -0.03261938f, 
    -0.01799322f, -0.00726580f, -0.04123390f, -0.00733496f, -0.00515058f, 0.01817069f, -0.00924816f, -0.04301662f, 
    0.02424815f, 0.00457224f, -0.03939012f, -0.01750180f, 0.01316853f, -0.02864034f, -0.03904995f, -0.01613847f, 
    0.01012137f, 0.01870717f, 0.00518874f, -0.04007893f, -0.02485988f, 0.01391113f, 0.01412037f, -0.00866100f, 
    0.02301075f, -0.00426655f, -0.00262835f, 0.00048133f, 0.01674283f, -0.00866841f, -0.01408963f, 0.00153787f, 
    0.02760942f, 0.02351454f, -0.03120447f, -0.02952180f, -0.02440520f, 0.01240803f, 0.02276964f, -0.00575531f, 
    -0.01928273f, -0.01691700f, 0.02358184f, 0.00621145f, -0.03177636f, 0.01531154f, 0.01190152f, -0.02182706f, 
    -0.04346314f, -0.00138368f, 0.00319661f, -0.01758990f, -0.00025751f, 0.00883899f, -0.00959748f, -0.03870523f, 
    -0.02916197f, -0.00953232f, -0.03951069f, -0.01109714f, 0.02594991f, -0.01311007f, -0.03397211f, -0.03759974f, 
    -0.02112430f, -0.00709011f, 0.01492782f, -0.00846598f, 0.01007454f, -0.01737114f, -0.03830953f, -0.03773266f, 
    -0.03671172f, 0.00209659f, -0.03949847f, -0.01185558f, -0.00297702f, -0.02456426f, -0.03362937f, 0.00334047f, 
    -0.00463680f, -0.04381631f, 0.02063907f, -0.01882567f, 0.01530110f, -0.04046451f, 0.01256603f, 0.00757954f, 
    -0.04151479f, 0.01676689f, -0.00838630f, -0.03420028f, -0.01587636f, -0.03593890f, -0.04142484f, -0.00590289f, 
    0.01103851f, -0.03462520f, 0.02448794f, 0.02583361f, -0.02851888f, 0.02288898f, -0.03904936f, 0.01756663f, 
    -0.02195169f, 0.00340589f, -0.00104337f, 0.00292825f, 0.02443724f, 0.00309960f, 0.02375426f, -0.02399007f, 
    0.00979478f, 0.02491775f, 0.02486010f, 0.00731131f, -0.00893265f, 0.00123015f, 0.00496115f, 0.01897733f, 
    0.00757457f, -0.01236008f, 0.00890690f, 0.00961532f, -0.01429614f, -0.02593311f, -0.02757331f, -0.04281188f, 
    0.00001385f, -0.03755192f, 0.01355166f, 0.01957703f, -0.04133939f, 0.00970391f, -0.01500607f, 0.02597560f, 
    -0.02427978f, -0.00358969f, -0.03621183f, -0.04156793f, -0.01145055f, 0.02245141f, -0.03273282f, -0.01447531f, 
    0.00570368f, 0.01758454f, -0.01074722f, -0.03298334f, 0.02295487f, 0.02073877f, 0.01987502f, -0.02723292f, 
    -0.02145922f, -0.02315208f, -0.04008433f, 0.00439879f, -0.00370390f, -0.02030681f, -0.03809646f, -0.02007029f, 
    -0.03233489f, -0.01064816f, -0.00107245f, 0.01436097f, -0.00910249f, 0.02610859f, -0.00709150f, 0.02533443f, 
    0.02725481f, 0.02797684f, -0.04073472f, -0.00994638f, -0.03121229f, -0.00412178f, -0.03228089f, 0.00232073f, 
    0.02391529f, -0.03102276f, -0.02710591f, 0.00115367f, 0.00553808f, -0.04444017f, -0.04104492f, -0.01725645f, 
    0.00595262f, -0.01682314f, 0.01643071f, 0.00853616f, -0.02313063f, -0.02421760f, -0.01405172f, 0.01978065f, 
    -0.02181519f, -0.01901107f, -0.00870550f, 0.01633698f, 0.01398933f, -0.02743438f, -0.01988953f, -0.01991662f, 
    -0.02870247f, 0.02798908f, 0.00270124f, -0.01104399f, 0.00915239f, -0.02645477f, 0.00434919f, -0.03845896f, 
    0.00039875f, -0.00381714f, -0.02168060f, 0.00596637f, -0.00798251f, -0.00098417f, 0.00251589f, -0.03572771f, 
    -0.03167116f, 0.01832124f, -0.00506153f, -0.02819526f, 0.00364628f, 0.00295039f, -0.00553645f, 0.00195424f, 
    -0.00908843f, -0.03272868f, -0.01203224f, 0.00341229f, -0.02129840f, 0.00582984f, 0.03339569f, -0.02825846f, 
    0.01284039f, 0.02267309f, -0.03420758f, -0.03463363f, 0.01718426f, 0.01495943f, 0.00019842f, -0.02917393f, 
    0.00783352f, -0.02554581f, -0.00764933f, -0.02429186f, -0.00713543f, -0.00046094f, -0.02224269f, 0.00658771f, 
    -0.00418952f, -0.04255528f, -0.01654545f, 0.02430342f, 0.00692978f, -0.02543091f, -0.03480140f, 0.01912373f, 
    0.00520169f, -0.01052559f, -0.02448034f, -0.03591003f, 0.02348469f, -0.02640133f, 0.02061659f, 0.00572400f, 
    -0.00178280f, -0.02591062f, -0.01716401f, -0.03605679f, 0.00726803f, -0.00696502f, 0.00654493f, -0.02951621f, 
    0.00906363f, 0.01208896f, 0.00567563f, -0.01479831f, -0.00127588f, 0.02054268f, 0.01744598f, -0.00707363f, 
    0.01892610f, 0.02143405f, -0.03118055f, -0.02732595f, -0.01770291f, -0.02945079f, -0.01128765f, 0.01037146f, 
    0.01262118f, -0.04044482f, 0.00989583f, -0.02372965f, -0.01377382f, 0.01470116f, -0.00098508f, -0.03691916f, 
    0.00458755f, -0.04038744f, 0.00364652f, -0.03926750f, -0.02138311f, -0.03812800f, 0.00417098f, -0.01842634f, 
    0.01635837f, 0.01232819f, -0.01377426f, 0.02484578f, 0.00182859f, 0.02271478f, -0.00440681f, 0.00061213f, 
    0.02815051f, -0.02073221f, -0.00306207f, 0.00724363f, -0.03086546f, 0.02978052f, 0.00433450f, -0.00315433f, 
    -0.00894965f, -0.01575030f, 0.00328758f, 0.00455992f, 0.02285310f, -0.00479231f, -0.01216353f, -0.02616916f, 
    -0.01652805f, 0.02153987f, 0.01170425f, -0.04227703f, 0.01600283f, -0.04163988f, -0.04027857f, -0.03935242f, 
    -0.01424061f, -0.01502537f, 0.00853949f, 0.02343875f, 0.00616516f, 0.01471498f, -0.00563549f, 0.02333227f, 
    0.02493413f, 0.01745619f, -0.02354126f, -0.00158619f, -0.03521803f, 0.02161393f, -0.03923020f, 0.02691468f, 
    -0.03375199f, -0.02499769f, -0.00032197f, -0.03675819f, -0.02717324f, 0.02557394f, 0.02495165f, 0.00567044f, 
    -0.01488757f, -0.00991787f, -0.01112561f, 0.01331055f, 0.01501782f, -0.03263529f, -0.02290775f, -0.01163990f, 
    -0.02544766f, 0.01318046f, 0.02180812f, -0.02794782f, 0.03106462f, -0.00457228f, -0.00577983f, -0.04009411f, 
    -0.03504010f, -0.02678803f, -0.03320432f, -0.00608878f, -0.02882623f, -0.02046145f, -0.03308459f, 0.01647750f, 
    0.00203431f, -0.02380759f, 0.00508335f, 0.02023179f, 0.02358665f, -0.03339251f, 0.01459055f, -0.01659758f, 
    -0.00093722f, 0.02853631f, -0.03036248f, -0.04084649f, 0.02673629f, -0.00651880f, -0.02306493f, 0.00520809f, 
    -0.01883844f, 0.01047880f, -0.02829582f, -0.03003290f, 0.02804865f, -0.03499782f, 0.02545686f, -0.01207303f, 
    0.01097786f, 0.02098421f, -0.01419143f, -0.03323299f, -0.02797162f, 0.00289707f, -0.00365489f, -0.03096579f, 
    -0.01940848f, 0.01368044f, 0.00052219f, -0.00832185f, -0.02237839f, -0.00416560f, -0.00261589f, -0.03973516f, 
    -0.02899492f, -0.01048396f, 0.01072085f, -0.02099636f, -0.03329139f, -0.02625443f, 0.00982306f, 0.01091420f, 
    0.00683717f, -0.01781683f, -0.02542464f, -0.02553060f, -0.01434093f, 0.03001484f, 0.01960635f, -0.03527376f, 
    -0.01914076f, 0.03086506f, -0.01948068f, -0.03878749f, 0.01983242f, -0.03831908f, -0.03664121f, 0.00613411f, 
    0.02449833f, 0.02484801f, 0.01131421f, -0.00909839f, 0.00539400f, -0.02240476f, -0.00383225f, 0.02398803f, 
    0.02490948f, -0.01348238f, -0.01325174f, 0.02125660f, -0.01433813f, -0.01823050f, 0.01971356f, 0.02389970f, 
    -0.00419204f, 0.02654100f, 0.01585351f, 0.01293471f, -0.01932586f, 0.01672788f, -0.00193006f, -0.03651036f, 
    0.02006162f, -0.02653514f, -0.03313580f, -0.03320841f, 0.02344651f, -0.03161573f, -0.00952390f, -0.01981713f, 
    0.00436014f, -0.04163558f, -0.02642428f, 0.00151345f, 0.02168139f, -0.00192781f, 0.02216614f, -0.04311504f, 
    0.01917326f, 0.02520177f, -0.01902933f, -0.02349956f, 0.01898853f, -0.03388296f, -0.00419564f, 0.02028404f, 
    -0.01192485f, 0.01060252f, -0.00872802f, -0.02847433f, 0.02438380f, -0.04348145f, -0.03683404f, -0.01426281f, 
    -0.00918556f, 0.02504829f, 0.00292795f, -0.02132062f, -0.03510915f, -0.00457335f, 0.00072293f, 0.00894640f, 
    -0.01793649f, 0.02079601f, 0.02509243f, 0.00492734f, 0.02412138f, 0.01686791f, -0.04168286f, -0.02530629f, 
    0.01378953f, -0.00435363f, -0.00489650f, -0.03123099f, -0.02784082f, -0.02854733f, -0.01489975f, 0.00566086f, 
    -0.00955142f, 0.02141307f, -0.03674735f, 0.00717283f, -0.04146143f, -0.03553093f, 0.01656927f, 0.01208891f, 
    0.02614165f, -0.01773269f, -0.00266126f, 0.01476489f, -0.00190802f, -0.00089909f, -0.01237362f, -0.00903107f, 
    -0.00839606f, -0.02943486f, 0.01068688f, -0.02729375f, -0.04263420f, -0.01714058f, -0.01827900f, -0.01735412f, 
    0.01783917f, -0.03693448f, 0.00215610f, 0.00843855f, -0.00121467f, -0.00728371f, 0.01763108f, 0.01350194f, 
    -0.00332849f, -0.01446672f, 0.00811456f, 0.00616769f, -0.02578557f, 0.00225175f, -0.04190278f, 0.02099072f, 
    -0.02803623f, 0.02364264f, -0.02331868f, -0.03586087f, -0.03590096f, -0.02450505f, 0.00668897f, -0.00449034f, 
    -0.03765477f, 0.02490066f, 0.02634889f, -0.02226764f, 0.00698280f, 0.00955953f, -0.03734969f, 0.02440456f, 
    -0.00937914f, 0.00589271f, -0.02649135f, -0.03385406f, 0.01217486f, 0.02758895f, 0.00551569f, -0.01034532f, 
    0.00624733f, -0.00045285f, 0.03090637f, -0.02510841f, -0.03007746f, 0.00922378f, -0.01388473f, 0.01138981f, 
    -0.01603096f, -0.03240608f, -0.01605892f, -0.00712389f, -0.04063043f, -0.03990036f, -0.00086586f, -0.02275938f, 
    -0.02863931f, 0.01203849f, -0.03504267f, 0.00830790f, -0.01078448f, -0.03214644f, -0.00016969f, 0.01969269f, 
    -0.03320159f, 0.00104698f, -0.00163179f, 0.01496152f, 0.01602792f, -0.02318064f, -0.03238235f, -0.01159672f, 
    0.01294541f, -0.00442639f, -0.02339802f, -0.03511374f, 0.02666115f, 0.01677428f, -0.03593699f, 0.02455123f, 
    -0.01352228f, 0.02345309f, -0.00798411f, 0.01837214f, -0.01009926f, 0.01255722f, -0.00256943f, 0.00527816f, 
    -0.01415084f, -0.01148590f, -0.01583626f, -0.04097133f, -0.04206437f, -0.00368674f, -0.02781866f, 0.02177669f, 
    0.02438213f, -0.03866480f, -0.03869832f, 0.02568242f, -0.02964002f, -0.03115479f, 0.02128289f, -0.02402693f, 
    -0.04255800f, 0.00739804f, -0.03134471f, -0.02040817f, 0.02250570f, 0.02500699f, 0.00697681f, 0.00634411f, 
    -0.01503568f, -0.00563492f, -0.01016460f, -0.00506614f, -0.03369166f, -0.01373711f, -0.00761025f, -0.02281223f, 
    -0.03113319f, -0.00325538f, -0.01735532f, 0.02804573f, 0.01041090f, -0.03521043f, -0.03388177f, -0.03551463f, 
    -0.03708712f, 0.00894994f, -0.02105754f, 0.02809658f, 0.02328574f, 0.00469700f, -0.01182492f, 0.01959357f, 
    -0.01001866f, -0.02836723f, -0.04333432f, -0.02160456f, -0.02025989f, -0.01706969f, 0.00875877f, -0.03766828f, 
    0.01666374f, 0.00876356f, -0.00450702f, 0.01785985f, -0.02869656f, 0.02878127f, -0.02118339f, -0.01905768f, 
    -0.00103136f, -0.02320464f, -0.04371915f, 0.01888510f, 0.01334776f, -0.01265230f, -0.01984849f, 0.01301939f, 
    -0.00729067f, -0.03090077f, 0.01792679f, -0.04122783f, 0.02219005f, -0.01380664f, -0.02428781f, 0.00094262f, 
    -0.00803049f, -0.00194166f, -0.03057994f, 0.02315071f, 0.00660883f, -0.04050566f, -0.03274892f, -0.01060737f, 
    -0.04066982f, -0.02942073f, 0.00570638f, -0.00337970f, -0.00251114f, -0.01901936f, 0.01657598f, 0.02082724f, 
    -0.01612381f, -0.02587580f, -0.03241486f, -0.01805662f, -0.01990581f, -0.02102161f, 0.00039559f, 0.02121237f, 
    0.00558706f, 0.01209988f, 0.03433452f, -0.03374397f, 0.00460089f, 0.02560231f, 0.01842139f, -0.00087391f, 
    0.01509588f, 0.01148589f, 0.01291308f, -0.02521805f, -0.00083864f, -0.03857072f, -0.01477375f, -0.01164823f, 
    -0.02065100f, -0.00558412f, -0.02573538f, -0.01653879f, 0.02029668f, -0.00940042f, 0.01924015f, -0.01904737f, 
    -0.03680216f, -0.02486815f, -0.02145626f, 0.00147908f, 0.03064126f, -0.01189735f, -0.00089782f, 0.00271403f, 
    0.04275871f, 0.01362610f, -0.01511497f, -0.01764971f, 0.00563216f, 0.00934513f, -0.02523946f, 0.00219931f, 
    -0.03471348f, -0.02148097f, 0.01928322f, 0.01806116f, 0.03460512f, 0.00906458f, -0.01033632f, -0.00768903f, 
    -0.02867481f, 0.02007332f, 0.00906191f, 0.03088550f, -0.04142771f, -0.01074009f, 0.00788646f, -0.00146892f, 
    -0.02937824f, -0.01277429f, -0.00742495f, 0.02720991f, 0.03008074f, -0.03342025f, -0.02463274f, 0.02162246f, 
    -0.00909045f, 0.01365155f, 0.02336591f, -0.04322274f, -0.04338469f, -0.01176315f, 0.00306689f, 0.03304791f, 
    -0.02651037f, 0.02465161f, -0.01450128f, 0.01253484f, 0.00185393f, 0.00373705f, -0.00508508f, -0.02364898f, 
    -0.02148129f, -0.03700202f, -0.02591960f, -0.00318436f, -0.03438757f, 0.02397001f, 0.02806883f, -0.04060796f, 
    0.00578825f, -0.02294275f, -0.01804239f, 0.02357658f, -0.02951501f, 0.03644685f, 0.02881073f, -0.02179833f, 
    0.00869032f, -0.03646033f, -0.02678822f, 0.03008566f, 0.03477133f, 0.00704773f, 0.01962565f, -0.00203865f, 
    0.00254982f, 0.00331472f, -0.01766877f, 0.03758989f, -0.01082591f, -0.02667521f, 0.02512440f, -0.02604356f, 
    0.01090537f, -0.02984764f, 0.00727902f, -0.01866573f, -0.01473246f, 0.00216527f, 0.02449938f, 0.04233748f, 
    -0.03140043f, -0.00999316f, -0.02225877f, -0.04032941f, -0.00958343f, -0.03282801f, -0.03026353f, 0.02731092f, 
    0.01895230f, 0.02647862f, 0.02292468f, 0.00383278f, 0.00747148f, -0.01642453f, 0.00696823f, 0.01334500f, 
    0.01035521f, 0.03639383f, -0.01902728f, 0.02203600f, 0.03367567f, 0.01366719f, 0.02449850f, 0.03002487f, 
    -0.03022795f, -0.02757173f, 0.00791809f, -0.03379649f, 0.02491625f, 0.02923785f, 0.02045070f, -0.01850202f, 
    0.01507890f, 0.01125885f, 0.01967980f, -0.01627681f, -0.00640436f, 0.02927276f, 0.00136111f, -0.00375498f, 
    0.01233126f, 0.02471401f, 0.03098562f, -0.01908886f, 0.00858842f, 0.01832622f, -0.00216961f, -0.02423331f, 
    -0.02032722f, 0.01369475f, 0.01465125f, 0.00246095f, 0.01681309f, -0.01817618f, -0.01780385f, 0.00378054f, 
    0.00302889f, 0.00034435f, 0.02219613f, -0.02326250f, -0.02322317f, 0.01705631f, 0.00802630f, -0.00180682f, 
    -0.02175586f, 0.01047582f, 0.00512618f, 0.03097997f, 0.00103750f, -0.00807540f, 0.00850784f, -0.00646384f, 
    -0.01039719f, -0.03071325f, 0.02723093f, -0.01557867f, -0.02077914f, 0.01578359f, -0.01104142f, 0.03554950f, 
    -0.02824173f, 0.03191370f, 0.03304989f, -0.02498845f, 0.01457934f, -0.00176579f, -0.01214068f, -0.01039100f, 
    0.00480068f, -0.01613866f, 0.01588788f, -0.00114224f, -0.01221743f, -0.01526345f, -0.02817625f, 0.01256593f, 
    0.00417780f, -0.00081678f, -0.00205468f, 0.00261578f, 0.01462322f, 0.04109831f, 0.03367405f, 0.02978193f, 
    0.00398073f, -0.02781614f, -0.02643534f, -0.00688264f, 0.01266781f, 0.00400336f, -0.03323235f, -0.04242639f, 
    0.02660427f, -0.02538321f, -0.01067450f, 0.01805306f, 0.01740674f, 0.01710789f, 0.03045060f, -0.02474438f, 
    -0.00852277f, -0.00700853f, -0.01421763f, -0.00844061f, -0.03540578f, 0.03102857f, 0.02302170f, -0.02507155f, 
    -0.03557026f, -0.01344541f, 0.03521085f, -0.00768290f, 0.01658832f, -0.01632052f, -0.03779664f, -0.03359143f, 
    -0.02475298f, -0.00609776f, -0.02592602f, -0.02605128f, -0.00158685f, -0.02452003f, -0.03122312f, -0.03532667f, 
    -0.03136080f, -0.01509374f, 0.00262033f, 0.01366847f, -0.03304412f, -0.02798602f, -0.00472324f, -0.02259006f, 
    0.00847055f, 0.01580184f, -0.01802683f, -0.02024955f, -0.02015973f, -0.02560918f, 0.02256603f, -0.02586504f, 
    0.00950774f, 0.02568152f, -0.04622928f, 0.01807474f, -0.00607282f, -0.04281161f, 0.03414112f, -0.01586255f, 
    -0.01795327f, -0.01993114f, -0.01567965f, 0.00017194f, -0.00506998f, -0.02818762f, -0.00229541f, -0.02686588f, 
    0.01074730f, -0.01012674f, -0.02991876f, -0.02857168f, 0.00360540f, -0.00546284f, -0.03152273f, -0.03531926f, 
    -0.02388475f, -0.01490442f, -0.03793969f, -0.00674514f, -0.03105774f, 0.00723527f, -0.02176051f, -0.02758665f, 
    -0.03153415f, -0.03343408f, -0.01277629f, 0.02278930f, 0.02409679f, -0.00289735f, 0.01828649f, -0.02445907f, 
    0.00120142f, -0.01008326f, -0.02591296f, 0.02653471f, -0.01172234f, -0.02835614f, 0.01693441f, -0.03252076f, 
    -0.02524435f, 0.00514012f, -0.02895684f, -0.02115062f, 0.01634982f, -0.01158349f, -0.00816931f, -0.03046167f, 
    -0.00983806f, -0.01816568f, -0.02102370f, -0.02945918f, -0.03691777f, -0.02722877f, -0.02547333f, 0.00266797f, 
    0.01827611f, -0.00182024f, -0.00704664f, -0.01096612f, -0.04000886f, 0.00362907f, -0.00779318f, -0.02532088f, 
    0.03953751f, -0.01841988f, -0.02471867f, 0.02275610f, 0.00030843f, 0.00338597f, -0.03312937f, -0.04136795f, 
    0.00104345f, 0.00475449f, -0.02039598f, -0.01846422f, 0.01988336f, -0.02423853f, -0.02183248f, 0.02377758f, 
    0.02800755f, -0.01556145f, -0.01937445f, -0.01100320f, -0.02929996f, -0.02262855f, -0.02371308f, -0.03702126f, 
    0.01759648f, 0.01764205f, -0.01470322f, 0.01926549f, -0.00037755f, 0.02783604f, -0.03570005f, -0.00767730f, 
    0.01301900f, 0.02877231f, -0.03761567f, 0.01107244f, -0.03812709f, -0.01120679f, -0.01066868f, -0.02915405f, 
    -0.02759753f, 0.02826559f, -0.01918265f, -0.03686969f, 0.01167455f, 0.00710455f, 0.02348696f, -0.00913632f, 
    0.00413646f, -0.02238024f, -0.02323946f, -0.00843037f, 0.01586046f, 0.00682498f, -0.04181415f, 0.01065997f, 
    0.00585692f, 0.02587701f, -0.00673385f, 0.00880591f, -0.02562449f, -0.00151772f, -0.00612871f, -0.02544947f, 
    0.01710866f, -0.00410029f, -0.00250246f, -0.03445495f, 0.01088206f, -0.02208259f, -0.00656428f, -0.01380523f, 
    -0.01686565f, 0.01032315f, 0.01538816f, -0.01871230f, -0.04422301f, -0.01266067f, 0.03613913f, -0.02464673f, 
    0.00041075f, 0.01141049f, 0.02541804f, -0.02560300f, 0.00750394f, -0.02732211f, -0.02041491f, -0.02700388f, 
    0.04161937f, 0.00954383f, -0.02482859f, -0.02772026f, 0.00425067f, 0.01799686f, -0.03198884f, -0.02456665f, 
    -0.03549616f, 0.02701430f, -0.01054605f, 0.00926773f, 0.00283281f, -0.00286829f, 0.01554569f, -0.01916437f, 
    0.01204784f, 0.00135752f, -0.01997254f, -0.01680586f, 0.01489350f, -0.02716218f, 0.01077953f, 0.01368802f, 
    -0.02319078f, 0.01963320f, -0.03536220f, 0.01250164f, -0.01153264f, -0.02775224f, -0.00252862f, 0.00221467f, 
    -0.02139841f, 0.00563282f, 0.01885215f, 0.00856906f, 0.01899049f, 0.03179184f, -0.02788181f, 0.03258359f, 
    -0.04070902f, 0.00672745f, -0.03157016f, -0.02532997f, -0.03015976f, -0.02468234f, -0.02555989f, 0.03165588f, 
    -0.02022879f, 0.00282367f, -0.03221749f, -0.01154271f, 0.01848694f, 0.00673444f, -0.01237123f, 0.02212638f, 
    -0.02167075f, 0.03358496f, -0.02463405f, 0.00369095f, -0.00131905f, -0.00712843f, 0.03476854f, 0.01539421f, 
    -0.00011280f, -0.02074496f, 0.01735890f, 0.02396291f, 0.00461308f, -0.02039436f, 0.00165053f, -0.03636528f, 
    0.00279554f, 0.02691658f, -0.03088323f, -0.03781323f, -0.03811709f, -0.04041635f, 0.01825855f, 0.01781308f, 
    0.00500070f, -0.01066105f, -0.03554760f, -0.03482165f, -0.00621662f, 0.02342990f, 0.01663943f, 0.02470855f, 
    -0.03847847f, -0.01423150f, -0.02171014f, 0.03046414f, 0.02090145f, 0.02892914f, 0.02782075f, -0.01853006f, 
    -0.00401276f, 0.01103030f, -0.02891079f, -0.00540939f, 0.02654124f, 0.00831743f, -0.00449112f, 0.01625542f, 
    0.02166740f, -0.01932009f, 0.03020193f, -0.04077739f, -0.00706159f, 0.00190845f, -0.01573632f, -0.03007837f, 
    0.02417615f, 0.00037024f, 0.02037884f, 0.00855603f, 0.00207919f, 0.02420213f, 0.00810880f, -0.03636900f, 
    -0.02539779f, 0.02590782f, -0.03013152f, -0.00615770f, -0.03533305f, -0.00391531f, -0.03609209f, -0.00513276f, 
    0.00057180f, -0.01465643f, 0.01477332f, -0.00530837f, 0.02884145f, 0.00518961f, 0.01300834f, -0.02909726f, 
    -0.01788845f, -0.00824429f, -0.04362152f, -0.00961638f, -0.03699828f, -0.02156881f, -0.01521041f, -0.01334511f, 
    0.01666560f, -0.00291633f, -0.01008000f, -0.00779601f, -0.00124015f, -0.00320401f, -0.00809127f, 0.02718793f, 
    -0.03280565f, -0.00411372f, 0.00747445f, -0.02199664f, -0.02103643f, 0.02343916f, 0.01705625f, -0.00294835f, 
    0.01660316f, 0.00766503f, -0.02773595f, 0.01441593f, 0.00033207f, 0.01794865f, -0.03928896f, 0.01186363f, 
    0.00647625f, 0.01858625f, 0.01674667f, -0.02571235f, 0.01353628f, 0.01596696f, 0.00165059f, -0.00335143f, 
    -0.03200392f, -0.02267555f, -0.03599145f, -0.03820389f, -0.03335265f, -0.02627543f, 0.00777473f, 0.03452131f, 
    0.03544199f, -0.00335580f, -0.00540774f, -0.03773823f, 0.00206042f, 0.02433190f, -0.00415621f, -0.02052837f, 
    0.00997651f, 0.02243971f, 0.02668020f, -0.02372764f, 0.03491255f, -0.01608280f, 0.02779157f, 0.00927087f, 
    0.01860562f, -0.00022204f, -0.00884573f, 0.02587865f, 0.00171990f, -0.03142370f, -0.02362262f, 0.02654008f, 
    0.00738411f, 0.01312764f, -0.00421580f, -0.01169530f, -0.03771582f, -0.01308879f, -0.01511725f, -0.03678334f, 
    -0.02924314f, -0.01213942f, 0.00225198f, -0.03216593f, -0.00767540f, -0.00015101f, 0.01461407f, 0.01287809f, 
    0.00161670f, 0.01849413f, 0.02135972f, -0.02443838f, 0.00003241f, -0.03862961f, 0.02025613f, -0.02401840f, 
    0.03064079f, -0.00537463f, 0.02306090f, -0.01380655f, -0.01382487f, 0.00559261f, 0.01839038f, 0.03085825f, 
    0.00294900f, -0.01863665f, -0.02858295f, 0.01049066f, -0.02532096f, -0.01470254f, 0.00719423f, -0.02216855f, 
    -0.02570929f, -0.02515857f, 0.03526970f, 0.03245541f, -0.02040745f, -0.00976303f, 0.02867265f, -0.02546749f, 
    -0.01862630f, 0.01950865f, -0.02205189f, -0.03411480f, 0.01435692f, -0.00400461f, -0.01420892f, -0.04454446f, 
    -0.00394762f, 0.03344937f, -0.00902379f, -0.02546352f, 0.00197488f, -0.01795144f, 0.00144884f, 0.01953186f, 
    0.00042548f, -0.01337866f, -0.00485910f, -0.00385667f, 0.00141807f, -0.01097782f, 0.02789357f, -0.00590570f, 
    -0.03371590f, -0.01123072f, -0.03873649f, 0.01820520f, 0.00926332f, -0.02364217f, -0.00756091f, 0.01218554f, 
    0.01386614f, -0.01372200f, -0.01548549f, -0.00526532f, 0.01177012f, -0.00328397f, -0.02104084f, 0.00902589f, 
    0.03184076f, 0.00099787f, 0.02243054f, -0.02193952f, -0.00289042f, -0.00074870f, 0.02800188f, -0.00321114f, 
    -0.03256704f, 0.00245024f, 0.02282409f, 0.00874774f, -0.02983205f, -0.02626018f, -0.00115058f, -0.04453776f, 
    -0.00182525f, 0.00537278f, 0.02278875f, -0.04267148f, -0.03864393f, -0.02609855f, 0.02721600f, 0.01950523f, 
    -0.00557144f, -0.00381417f, -0.00710972f, -0.00353835f, 0.03108684f, -0.00783200f, 0.00776057f, -0.00828635f, 
    0.00645444f, -0.01018162f, -0.00015320f, 0.01412029f, -0.03931873f, -0.04217459f, -0.00131251f, 0.01238287f, 
    -0.04329080f, 0.00329135f, 0.00216322f, 0.00942420f, -0.00735360f, -0.03749518f, -0.00260245f, 0.03417580f, 
    -0.01876520f, -0.01900692f, 0.02106888f, -0.01833335f, -0.03835835f, -0.02113222f, -0.02217835f, 0.02652920f, 
    -0.12053083f, -0.01230984f, 0.07305919f, -0.00786641f, 0.00417330f, -0.03006288f, 0.08782501f, 0.23908488f, 
    -0.02780647f, 0.05572110f, 0.05726999f, -0.09767384f, -0.19384219f, 0.09902988f, -0.36645365f, -0.35651365f, 
    0.01145785f, 0.02658574f, -0.04361621f, 0.16148175f, 0.06315304f, -0.05203640f, 0.04792831f, -0.00528550f, 
    0.17141704f, 0.46580929f, 0.18570653f, 0.03705776f, 0.12991144f, -0.00565158f, 0.06902481f, -0.01832331f, 
    -0.08602315f, 0.01718711f, -0.06453592f, -0.02094756f, 0.02758249f, 0.11903512f, -0.07861643f, 0.00455951f, 
    0.05882042f, 0.10561755f, 0.10845461f, -0.11746547f, -0.12425398f, -0.06027707f, -0.08478177f, 0.04639157f, 
    0.54282463f, -0.24334183f, -0.24843717f, -0.19192201f, 0.03822736f, 0.07119869f, -0.06550197f, 0.08472256f, 
    0.13470414f, 0.09548031f, -0.11698148f, 0.03550035f, -0.30756378f, -0.09445146f, -0.34760970f, -0.34294885f, 
    0.08180758f, -0.01289206f, -0.22596337f, 0.01150927f, -0.09000172f, -0.08427998f, -0.05445050f, 0.05086331f, 
    -0.15768467f, 0.01055489f, -0.38779145f, -0.16771540f, 0.02029041f, 0.01455825f, -0.06399420f, 0.04597580f, 
    0.01253677f, 0.01110693f, 0.03488680f, -0.03906395f, -0.25268221f, -0.05205113f, 0.01486653f, -0.09292676f, 
    -0.03953557f, 0.15972270f, 0.06062695f, 0.13435674f, 0.13216272f, 0.05907633f, 0.11311812f, 0.18913765f, 
    0.33389890f, 0.27885336f, -0.04759981f, 0.17692173f, 0.07119887f, -0.06757843f, 0.08188543f, -0.01476268f, 
    0.00854767f, -0.07179523f, -0.04620676f, 0.02991377f, -0.41952372f, -0.07454725f, -0.33550566f, -0.09175833f, 
    -0.02097215f, 0.02710425f, 0.04975820f, 0.07522980f, -0.07298730f, -0.06829528f, -0.04708868f, 0.16460946f, 
    -0.05137397f, 0.09544134f, 0.20861468f, 0.12938420f, 0.02487501f, 0.25390109f, 0.12277791f, -0.05594466f, 
    0.11824469f, -0.02346640f, 0.13911556f, -0.08421301f, 0.23716249f, 0.40462393f, 0.19012035f, -0.09768629f, 
    0.00135526f, 0.00404307f, -0.09187437f, 0.05862491f, 0.10202714f, -0.05289172f, -0.01938611f, -0.00864998f, 
    -0.33488855f, -0.15760590f, -0.18916933f, -0.18346834f, 0.16761792f, 0.11808626f, -0.04413997f, 0.05384593f, 
    -0.08984214f, -0.09605452f, -0.02046162f, -0.01217516f, 0.17342213f, 0.17802987f, -0.06799185f, 0.03126878f, 
    -0.03560818f, -0.01816005f, 0.10165443f, 0.11712990f, 0.06777925f, -0.01990130f, -0.06313285f, 0.14548466f, 
    -0.16663615f, 0.01681829f, 0.15366502f, 0.00187955f, -0.10675175f, -0.10052670f, 0.06641863f, 0.01738968f, 
    0.02347654f, 0.01804002f, 0.06664186f, 0.10624512f, 0.33063555f, 0.32496703f, -0.07582339f, -0.16368805f, 
    0.03958242f, 0.30105245f, 0.03221871f, 0.15216723f, -0.13984799f, -0.06951574f, -0.08839959f, -0.02491544f, 
    0.16289048f, 0.06411333f, 0.08910957f, 0.14490862f, 0.05648448f, 0.08065896f, 0.01575881f, 0.04072131f, 
    0.15693566f, 0.14938764f, 0.20897377f, 0.13721122f, 0.14662419f, -0.04340340f, 0.09663364f, 0.09731122f, 
    -0.03085551f, 0.00840465f, 0.03738390f, 0.12933089f, 0.03808444f, -0.00146728f, 0.12254870f, 0.22506666f, 
    0.24601325f, 0.07164792f, 0.05921061f, -0.04913083f, -0.02430415f, -0.04696120f, 0.03310485f, -0.07568513f, 
    -0.02959653f, 0.05179776f, -0.09608700f, -0.20582673f, 0.01678929f, 0.07385173f, 0.11948388f, 0.12890977f, 
    -0.00053552f, 0.06011043f, 0.01204031f, 0.06974728f, 0.31459990f, 0.13289788f, 0.25593132f, 0.18336461f, 
    0.30637300f, 0.00279355f, -0.04085903f, 0.10783666f, 0.03712073f, -0.17349963f, 0.03535414f, 0.07709747f, 
    0.17913520f, 0.15898627f, 0.00405528f, -0.04880143f, 0.04350604f, 0.14761232f, -0.05389233f, 0.06257740f, 
    0.01874745f, 0.09861287f, 0.22148180f, -0.11672267f, -0.04371694f, 0.00861272f, -0.10942939f, -0.03533693f, 
    0.02006858f, 0.12330968f, -0.06952076f, -0.03908232f, -0.08560506f, -0.01241251f, -0.05131449f, 0.07040186f, 
    -0.12446006f, -0.04673162f, -0.05074591f, 0.02453096f, -0.26863125f, -0.28029841f, 0.01190408f, 0.13217872f, 
    0.02387957f, -0.00485933f, 0.12602037f, 0.14985238f, 0.02455653f, -0.07926263f, 0.09080260f, 0.06816448f, 
    0.03073303f, -0.01103673f, 0.06067732f, 0.05089550f, 0.19518209f, 0.16386418f, -0.08151944f, -0.05170963f, 
    -0.02979708f, -0.05243844f, -0.00498946f, -0.02593673f, 0.02221454f, 0.17913172f, 0.18708207f, 0.18112120f, 
    -0.05074374f, 0.02906548f, -0.04331980f, -0.05627331f, -0.02832179f, -0.07986759f, 0.04910222f, 0.02288811f, 
    -0.40393859f, -0.06059126f, -0.10256395f, -0.32153189f, -0.02903323f, 0.05141293f, 0.01173402f, -0.08364595f, 
    -0.12643847f, -0.00072909f, -0.12131073f, -0.09278194f, -0.47402218f, -0.14136654f, -0.10570691f, -0.21113777f, 
    -0.01117330f, 0.04875139f, -0.08068293f, 0.07262862f, -0.06367417f, -0.02154547f, 0.00523122f, -0.07114411f, 
    -0.23186314f, -0.18177451f, -0.26026961f, -0.33669460f, -0.08022815f, -0.09677571f, -0.10017994f, 0.03805318f, 
    -0.10889267f, -0.01070909f, 0.00091359f, 0.01564782f, -0.06266704f, 0.07463048f, -0.09039455f, 0.04252707f, 
    0.10854869f, -0.02494094f, 0.01540965f, -0.04554762f, 0.15493149f, -0.10755704f, -0.04569618f, 0.01286648f, 
    -0.10363591f, -0.06372752f, 0.09373224f, 0.00971241f, -0.13465717f, 0.30142188f, -0.04276618f, 0.06440338f, 
    0.11806087f, 0.02746137f, 0.00752266f, -0.05870874f, 0.05198582f, 0.15271336f, 0.19745649f, 0.23343693f, 
    -0.00235289f, -0.09118950f, -0.02365145f, -0.07214644f, -0.07306302f, 0.01084017f, -0.02266012f, -0.00705782f, 
    0.05829909f, 0.01507522f, 0.10617085f, 0.12548098f, -0.05023700f, -0.01023267f, 0.01392619f, -0.02327842f, 
    0.16964304f, 0.13330351f, -0.02663535f, 0.04272396f, 0.28857151f, -0.26074073f, -0.06443972f, -0.14567862f, 
    -0.05269831f, -0.05589611f, 0.01530313f, 0.19298400f, -0.02653889f, -0.20803170f, -0.01978352f, -0.04575366f, 
    -0.41937396f, 0.05173866f, 0.36250553f, -0.02431681f, -0.23712564f, 0.05413768f, -0.06257918f, -0.04680375f, 
    0.06831898f, 0.11126938f, -0.05626665f, 0.01627217f, 0.06718245f, 0.09359901f, 0.23553443f, 0.01321617f, 
    -0.07232609f, 0.04847176f, -0.05674279f, 0.00996768f, 0.15683812f, -0.08235424f, -0.04692518f, 0.14156802f, 
    0.07733375f, -0.06430697f, 0.09631477f, 0.04498208f, -0.01601340f, 0.14322425f, 0.02479590f, -0.12274615f, 
    0.26716366f, 0.10208067f, -0.10412759f, 0.12055938f, -0.27444357f, -0.07517954f, -0.10685696f, 0.06570036f, 
    0.10566940f, 0.18409248f, -0.02865436f, 0.14371699f, -0.01209757f, -0.00221577f, 0.08064340f, 0.05055308f, 
    0.11299351f, 0.12840770f, -0.22672121f, -0.17063843f, 0.01723602f, 0.08009178f, 0.08629364f, 0.10722008f, 
    0.08694573f, 0.05534010f, -0.13250773f, -0.03131921f, 0.39314398f, -0.18868542f, -0.15608779f, -0.15782712f, 
    0.08351087f, 0.05025344f, -0.03070969f, 0.06587273f, 0.08271281f, 0.06740155f, -0.12155601f, -0.02219557f, 
    0.01743342f, -0.09108979f, -0.16811995f, -0.15816753f, -0.05348822f, -0.08101006f, -0.05592191f, -0.02532347f, 
    -0.02609029f, 0.02507709f, -0.08145515f, -0.11024214f, 0.24190059f, 0.14834495f, 0.14236771f, 0.20469454f, 
    0.01494922f, 0.04231795f, -0.03605978f, 0.07714452f, 0.02871753f, 0.14921306f, 0.21521796f, 0.18076585f, 
    0.20046970f, 0.13989633f, 0.15883946f, 0.22053882f, 0.01964813f, 0.01528469f, 0.01686561f, -0.02759529f, 
    0.00581833f, -0.01537619f, -0.03781154f, -0.00202217f, -0.40738323f, 0.05500008f, -0.00187359f, -0.09064772f, 
    0.02637416f, -0.05691669f, 0.01526365f, -0.06325290f, -0.06433868f, -0.02411896f, 0.07536731f, 0.01377578f, 
    0.22978280f, 0.13595299f, -0.09996984f, 0.06833540f, 0.33190316f, 0.08630046f, 0.05223014f, -0.09186535f, 
    -0.06606606f, -0.05548942f, -0.03491567f, -0.01325450f, -0.01743689f, 0.09996011f, 0.03077760f, 0.10353256f, 
    -0.05067581f, 0.08131259f, -0.00129868f, -0.06375252f, 0.00280563f, -0.06063567f, -0.00557790f, -0.03053770f, 
    0.30671617f, 0.00254626f, -0.12435725f, -0.10310923f, 0.03476721f, 0.01477864f, 0.00229306f, 0.03066039f, 
    -0.09434861f, -0.02981214f, -0.12120506f, 0.03873362f, -0.17041762f, -0.02015178f, -0.14066158f, -0.12301084f, 
    0.04480927f, 0.09824701f, -0.11849351f, -0.11567491f, -0.09905578f, -0.00984708f, -0.06353725f, -0.03313997f, 
    0.05817339f, 0.10840207f, 0.17154016f, 0.11720915f, -0.06752737f, 0.09579954f, -0.05130360f, 0.06658890f, 
    0.23499265f, -0.04260369f, 0.04375518f, 0.14518194f, -0.28925851f, 0.10060046f, 0.08588147f, -0.11157029f, 
    -0.23377967f, 0.00724070f, 0.08653866f, 0.02140263f, -0.09975556f, -0.13752927f, -0.04292093f, -0.09419820f, 
    0.04331905f, -0.28403825f, -0.03710897f, -0.07509911f, -0.07567960f, 0.00020785f, -0.03041057f, -0.02255067f, 
    -0.00398668f, -0.02192153f, 0.08815861f, 0.10507321f, -0.41500583f, -0.34417349f, -0.10895920f, -0.63509125f, 
    -0.06190341f, -0.06047556f, 0.10828246f, 0.08386318f, -0.00272009f, 0.12335891f, -0.13119654f, 0.08141616f, 
    -0.26760751f, 0.13306369f, 0.20163400f, -0.09963841f, -0.13751696f, 0.01598088f, 0.10065397f, -0.12184370f, 
    0.11099496f, 0.13600510f, -0.03340993f, 0.20909719f, 0.34547594f, -0.02784476f, 0.00666431f, 0.08146335f, 
    -0.07245392f, 0.00465519f, -0.03243591f, 0.03540922f, 0.11776059f, 0.22109111f, 0.06759085f, -0.01999938f, 
    -0.07413200f, 0.15773420f, -0.08411414f, 0.06677703f, 0.11245476f, -0.04381472f, -0.00284895f, -0.04481401f, 
    0.11607028f, 0.03584321f, -0.00789458f, -0.00817296f, -0.14550489f, -0.07910715f, 0.18014139f, 0.16495420f, 
    -0.02958917f, 0.13453814f, 0.02119374f, 0.02610636f, -0.07423015f, -0.13595584f, -0.01210629f, 0.06215819f, 
    -0.30321917f, 0.00258443f, 0.13312423f, -0.13926752f, -0.02379606f, 0.14193627f, 0.05928059f, -0.13505617f, 
    0.18000937f, 0.07710586f, -0.10746647f, 0.01933612f, -0.18006729f, -0.30455738f, -0.09244554f, -0.27436119f, 
    -0.05532064f, -0.05078294f, -0.10833281f, -0.00124904f, 0.21694547f, 0.00455265f, 0.04194119f, -0.07459448f, 
    0.23251447f, 0.02077332f, -0.07475069f, 0.03372475f, 0.12466986f, 0.04692264f, 0.23139696f, 0.07223901f, 
    -0.01289769f, 0.02251749f, -0.03007215f, -0.10883693f, -0.23705858f, -0.23320317f, -0.35142723f, -0.33653763f, 
    -0.06154007f, -0.06452824f, 0.21696533f, 0.34391406f, 0.04700147f, -0.05722527f, 0.04523102f, 0.10842382f, 
    0.18902370f, 0.05828757f, 0.03719210f, -0.00586752f, 0.02199571f, 0.07536894f, -0.00250190f, 0.03385244f, 
    0.12245384f, -0.01526114f, -0.03567316f, -0.01743229f, -0.03459041f, -0.03194721f, 0.07668924f, 0.02551847f, 
    0.10540839f, -0.03015564f, -0.03105699f, -0.03243040f, -0.01188277f, -0.03165239f, -0.06495907f, 0.05338247f, 
    0.12131697f, 0.02768396f, 0.05703717f, 0.11185805f, -0.04400769f, 0.04580909f, -0.03001983f, -0.08934189f, 
    -0.00153086f, 0.07784016f, -0.05288148f, 0.01104616f, -0.41717011f, -0.14577188f, -0.17003933f, -0.17379378f, 
    -0.18093729f, -0.11141282f, 0.00899820f, 0.01265784f, 0.12584263f, -0.07897400f, 0.08981375f, 0.05133297f, 
    -0.10872328f, -0.06659260f, -0.01227814f, 0.08322645f, 0.18317369f, 0.07430057f, 0.05962186f, 0.06572483f, 
    -0.10976601f, -0.04913523f, -0.08038420f, 0.08018281f, -0.19965424f, -0.11681006f, 0.12842675f, 0.22431076f, 
    0.08747151f, 0.02197654f, 0.01634473f, 0.25415784f, -0.04392460f, 0.03099173f, -0.07607362f, -0.08848369f, 
    -0.06445703f, -0.10098369f, 0.12675332f, 0.16099361f, 0.01754396f, -0.01343210f, 0.00867644f, 0.11777119f, 
    -0.10845557f, -0.06108145f, -0.10722994f, -0.00418565f, 0.09167460f, -0.14847550f, -0.05046416f, -0.05701946f, 
    0.45513085f, -0.20160627f, 0.00839694f, 0.11198062f, 0.09130035f, 0.17300354f, 0.06627775f, 0.18006958f, 
    -0.14964071f, -0.20009659f, 0.15022276f, -0.01590029f, 0.04309081f, 0.10280713f, 0.09874617f, 0.20357825f, 
    0.04788882f, 0.12931056f, 0.03759142f, 0.08546315f, -0.12438793f, 0.03240322f, 0.10414521f, 0.08523025f, 
    -0.00772895f, 0.15951352f, -0.06193627f, -0.01651932f, 0.03475733f, 0.00162182f, -0.04209800f, 0.07551754f, 
    -0.19944848f, -0.03244259f, 0.01260250f, 0.16102584f, 0.19673942f, 0.15469812f, 0.05911335f, -0.01275575f, 
    0.08243673f, 0.03044518f, -0.03812309f, -0.23209719f, -0.08882711f, -0.13463940f, -0.06517958f, 0.01270563f, 
    -0.04829376f, 0.09972567f, 0.11067741f, 0.20213072f, 0.16158682f, 0.14028329f, 0.00503890f, 0.09911087f, 
    0.06399704f, 0.18469572f, 0.52392638f, 0.16640235f, -0.02107995f, -0.12104912f, -0.11387737f, -0.07941798f, 
    0.02633152f, -0.01781295f, 0.02210656f, -0.01981159f, -0.03072855f, -0.06361955f, 0.03019879f, 0.13684233f, 
    0.02835374f, -0.00112663f, 0.02687664f, 0.28029341f, 0.02601949f, 0.04077427f, -0.04683457f, 0.06497563f, 
    0.10275690f, 0.18743508f, -0.00674387f, -0.01076146f, 0.08448719f, -0.03173797f, 0.02462925f, -0.11256684f, 
    -0.08963877f, -0.12250066f, 0.10021953f, 0.11949143f, 0.10590475f, -0.08342358f, -0.09371176f, 0.13983734f, 
    0.11852884f, 0.11115789f, 0.15883632f, 0.07944011f, -0.08836910f, -0.03842655f, -0.01720637f, -0.03445260f, 
    0.00146516f, 0.00036007f, 0.09227074f, 0.15075302f, -0.00441545f, 0.18830800f, -0.00214374f, 0.20107543f, 
    -0.02779354f, 0.01374902f, 0.01385916f, 0.01403750f, -0.21653599f, -0.10525113f, 0.27413145f, -0.04595261f, 
    -0.05269981f, -0.08737282f, -0.00220954f, 0.00039203f, 0.04742813f, 0.04596123f, -0.35501334f, 0.03525227f, 
    -0.03375432f, -0.09517616f, -0.03646446f, 0.06989992f, 0.10764598f, -0.19402505f, -0.07224387f, -0.10497537f, 
    0.04028715f, -0.06692406f, -0.16760916f, -0.06875730f, -0.18429950f, 0.12238863f, 0.26498085f, 0.19830586f, 
    0.16801342f, 0.03239905f, -0.08799056f, 0.14431737f, -0.17252411f, 0.03890509f, -0.01113153f, -0.02428435f, 
    -0.16997316f, 0.05920786f, 0.13613175f, 0.00568798f, -0.09671135f, -0.04221155f, -0.08742575f, -0.14292881f, 
    -0.00560477f, 0.01879403f, -0.11509067f, -0.09281899f, 0.13895737f, -0.14620823f, 0.04561713f, -0.03967592f, 
    -0.05525625f, -0.05252717f, -0.09744093f, -0.04273603f, -0.11159587f, -0.09978968f, -0.11074680f, -0.04027903f, 
    -0.20357198f, -0.05238822f, 0.07474377f, 0.12091357f, 0.02894435f, 0.08510079f, 0.05208212f, -0.15342049f, 
    0.09881583f, 0.31076157f, 0.26998800f, 0.22802114f, -0.18365733f, -0.10439910f, 0.00575216f, -0.12838872f, 
    -0.11131983f, -0.03076009f, -0.11229649f, -0.11052629f, -0.10003584f, -0.20085622f, -0.12939458f, -0.18505751f, 
    -0.03395227f, 0.16717508f, 0.21815875f, 0.22587857f, -0.04325136f, 0.03291963f, -0.25303560f, 0.03966004f, 
    -0.01990582f, 0.16618142f, 0.10714287f, 0.12840065f, -0.09190579f, 0.10302438f, 0.13854544f, 0.12835129f, 
    0.16568863f, 0.10852236f, -0.16278569f, -0.02323399f, -0.05185552f, 0.01403443f, 0.08712640f, 0.04538146f, 
    0.06417722f, -0.01571105f, 0.00773240f, 0.08928875f, -0.02927264f, -0.04434456f, 0.00617330f, -0.01943326f, 
    -0.07953016f, -0.11044424f, -0.06530972f, -0.22900110f, -0.09114359f, 0.33403617f, -0.12658247f, 0.02126832f, 
    0.11458262f, 0.05293321f, 0.01525312f, 0.21451317f, 0.05360278f, -0.04304209f, 0.00185967f, 0.28371212f, 
    0.07886440f, 0.19573714f, 0.07825477f, 0.08279482f, 0.11364566f, 0.03313868f, -0.04412227f, -0.07501490f, 
    0.02224110f, 0.02379145f, 0.04138448f, 0.01611106f, 0.10496780f, 0.09694106f, 0.13933289f, -0.05835615f, 
    -0.05661615f, -0.04630055f, -0.03756556f, -0.07036123f, 0.12156409f, 0.07557724f, 0.02100056f, 0.16253534f, 
    0.17873734f, -0.00228617f, -0.30501953f, 0.00158023f, 0.05867255f, 0.15670057f, 0.13821085f, 0.07353532f, 
    -0.06315478f, -0.03201439f, 0.11934598f, -0.03018349f, 0.09835185f, -0.06217200f, 0.02043304f, 0.13522495f, 
    0.17124954f, -0.01770413f, 0.02460511f, 0.04711353f, -0.08207322f, -0.01789810f, -0.18175969f, -0.25747669f, 
    -0.07061721f, -0.06820500f, 0.06345188f, 0.27615047f, -0.03763019f, 0.00213553f, -0.00207848f, 0.04236280f, 
    -0.04184891f, -0.01529153f, -0.02711654f, 0.00659094f, 0.04121745f, -0.09299608f, -0.13876358f, 0.10663383f, 
    0.08538536f, -0.00481346f, -0.07456375f, 0.02888127f, 0.29467627f, 0.03984162f, 0.04138460f, 0.21042399f, 
    -0.07335747f, 0.23269340f, 0.00073263f, -0.09267506f, 0.00222542f, 0.03634134f, 0.09137326f, -0.02545008f, 
    -0.00798660f, 0.02686858f, -0.07213875f, 0.16198200f, 0.06374140f, -0.11886674f, -0.42036602f, -0.10771540f, 
    -0.05766869f, -0.04953557f, 0.00552750f, -0.03027065f, 0.10170568f, 0.05818547f, 0.13449319f, 0.13622317f, 
    0.03629964f, -0.04553675f, -0.13982415f, -0.06364366f, -0.03622320f, -0.07182174f, -0.01488352f, -0.11279660f, 
    0.06982189f, 0.07410005f, 0.15150809f, 0.16997930f, -0.14710324f, 0.01106328f, 0.21374680f, 0.02236697f, 
    -0.03338881f, 0.00271837f, -0.07141592f, 0.15059550f, -0.02858418f, 0.02588670f, -0.21066481f, -0.15073256f, 
    0.06551752f, -0.13072248f, -0.35791460f, -0.12069023f, 0.08639364f, -0.11445764f, -0.14947602f, -0.11204812f, 
    -0.02333086f, 0.05870828f, 0.12307380f, 0.17179045f, 0.13879195f, 0.12478192f, -0.15201302f, -0.22831224f, 
    -0.03327260f, -0.03298848f, -0.04744010f, -0.16108637f, 0.13340405f, 0.10038172f, -0.15100326f, 0.24355866f, 
    -0.10001218f, 0.02618186f, -0.19461276f, -0.13028586f, -0.12370691f, 0.12848966f, -0.19543712f, -0.08620060f, 
    -0.01064989f, 0.07783950f, 0.02939652f, -0.07701492f, -0.09614526f, -0.06525839f, 0.07190231f, 0.10243177f, 
    0.00677286f, 0.03772925f, 0.14682817f, -0.01161659f, 0.08179349f, 0.03107369f, -0.00284355f, 0.16068226f, 
    -0.43533957f, -0.05035820f, 0.26302314f, 0.16057384f, -0.00842517f, 0.26386839f, -0.06459829f, 0.21183626f, 
    -0.01178441f, -0.03165292f, 0.16953464f, 0.08607236f, 0.26070186f, 0.24878220f, 0.19354247f, 0.06446026f, 
    -0.08536016f, -0.00430624f, 0.03174720f, 0.01562309f, 0.08125741f, -0.07338873f, 0.01397346f, -0.06650040f, 
    0.08900571f, -0.35266960f, -0.13393261f, -0.16262026f, -0.03217259f, 0.05740815f, 0.05420822f, 0.10136952f, 
    0.13653824f, 0.11791525f, 0.07112922f, -0.17705332f, -0.09855933f, 0.01883193f, -0.02686688f, -0.04934093f, 
    -0.08555903f, -0.05530402f, -0.00292455f, -0.04289644f, -0.01889998f, -0.00205079f, -0.00579374f, 0.10724873f, 
    -0.09213998f, 0.05971889f, 0.18181038f, -0.01156033f, -0.05930062f, -0.04526856f, -0.08353133f, -0.10024723f, 
    0.00931838f, 0.10995678f, 0.15308179f, 0.24547349f, 0.35540676f, 0.20560813f, -0.20416948f, -0.18615586f, 
    0.11594181f, 0.04130832f, -0.00697507f, -0.13241139f, -0.03683077f, 0.07154145f, 0.01304505f, 0.08933730f, 
    0.09007743f, 0.17386080f, 0.38785699f, 0.10247459f, 0.03662357f, -0.07394850f, -0.05416398f, 0.06995771f, 
    -0.02205900f, -0.09365986f, -0.02982310f, -0.04110897f, -0.06454279f, 0.05639882f, 0.07335939f, -0.02517669f, 
    -0.15468340f, -0.02411095f, 0.03121029f, -0.07708123f, -0.05162483f, 0.05979237f, -0.05789856f, 0.03157246f, 
    -0.03480157f, 0.11633313f, 0.28359857f, 0.26273614f, 0.04987970f, 0.08354665f, 0.02703830f, 0.13243870f, 
    -0.02299621f, -0.04173301f, 0.03742531f, 0.06595123f, -0.05515755f, -0.08583989f, -0.09721993f, 0.07765885f, 
    0.15762311f, 0.04351181f, 0.06113849f, 0.20667648f, -0.01119335f, -0.02532267f, 0.02734758f, 0.06345208f, 
    -0.10597681f, 0.04387173f, -0.09520990f, -0.15583625f, -0.07179146f, -0.03911415f, -0.05706252f, -0.10834968f, 
    -0.05608473f, -0.03255546f, -0.11506936f, 0.03391648f, 0.23180328f, -0.03785338f, -0.29594180f, -0.15253143f, 
    0.10094091f, 0.07370618f, 0.02029538f, 0.15001167f, 0.12388729f, 0.10065795f, 0.05242739f, 0.04406101f, 
    0.04900571f, -0.29019928f, -0.34093279f, -0.15738957f, 0.03518257f, -0.03842710f, 0.06672970f, -0.09819817f, 
    -0.07268518f, -0.11968499f, -0.00222180f, -0.03617116f, 0.10527266f, 0.07267843f, -0.01725098f, 0.15316415f, 
    0.11687744f, 0.11993080f, 0.22738762f, 0.05896521f, -0.01687086f, 0.04153751f, 0.10814784f, 0.09653015f, 
    -0.07418241f, 0.01226122f, -0.03173718f, -0.17777057f, 0.25792238f, -0.07995095f, -0.15678251f, -0.33984774f, 
    0.03259638f, 0.16375351f, -0.08836719f, 0.18671168f, 0.10571702f, 0.03780498f, -0.01061601f, -0.08957508f, 
    -0.05505587f, -0.02657797f, -0.11620964f, -0.14280374f, 0.00148316f, 0.01746615f, -0.00805855f, 0.16988464f, 
    0.11947151f, -0.10306439f, -0.05749502f, 0.12430016f, 0.04589507f, 0.16878848f, 0.10907036f, 0.31484777f, 
    0.07060560f, 0.18700820f, 0.06641756f, 0.07785706f, 0.39981773f, 0.03624279f, -0.05504705f, -0.11676579f, 
    0.15730041f, -0.11769476f, -0.00227277f, -0.00358671f, 0.07759077f, 0.12480575f, 0.10110794f, 0.37660983f, 
    0.24981749f, -0.01094739f, -0.05292879f, 0.15723264f, 0.06329211f, 0.23713359f, 0.00452522f, -0.01708419f, 
    -0.02797444f, 0.04925194f, 0.07240419f, 0.07971959f, 0.01271154f, -0.11767786f, -0.02944386f, 0.08961817f, 
    0.08139644f, -0.00322656f, 0.00997787f, 0.10403941f, 0.02626317f, -0.06082594f, 0.12414254f, -0.09678993f, 
    -0.31117091f, 0.10353839f, 0.10082579f, 0.12985739f, 0.17101203f, -0.01129438f, -0.19756190f, 0.16544032f, 
    -0.01268593f, 0.01873309f, 0.05556490f, -0.01836359f, 0.23435533f, -0.08711576f, -0.08131763f, 0.19547948f, 
    -0.02869943f, 0.07649058f, 0.08317313f, 0.15927993f, -0.04527547f, 0.08966359f, 0.02044410f, -0.22296321f, 
    -0.08328400f, 0.09664805f, -0.05748989f, -0.08799413f, 0.03260208f, -0.07723241f, 0.05863899f, 0.18923715f, 
    0.06942219f, 0.21838918f, 0.11820260f, 0.06112810f, -0.03691908f, 0.10870448f, -0.05774345f, 0.05265490f, 
    0.02305792f, 0.07250850f, -0.10499902f, -0.11579642f, 0.07078769f, 0.08401509f, 0.16638845f, 0.04938736f, 
    -0.11739752f, -0.07518610f, -0.08423293f, -0.11327732f, -0.01991292f, 0.02900404f, -0.01160921f, -0.11442249f, 
    0.12289475f, 0.20901391f, 0.18852387f, 0.18638313f, 0.12153595f, -0.17352533f, -0.07039356f, -0.11626095f, 
    0.10136291f, -0.02358137f, -0.09305067f, -0.01489043f, -0.03327960f, -0.15022857f, -0.09552727f, -0.16836506f, 
    -0.01537783f, 0.01092129f, -0.02233938f, 0.02351671f, 0.02727672f, 0.02367906f, -0.03813699f, 0.02367440f, 
    -0.04168199f, -0.01715144f, -0.01128939f, -0.00549040f, 0.01632217f, -0.00079865f, -0.03739151f, -0.02404589f, 
    -0.03645291f, 0.01867271f, -0.01668075f, -0.00304818f, 0.00068402f, -0.00229528f, 0.00388911f, -0.03151356f, 
    0.01678239f, 0.02323936f, -0.00231905f, -0.00595860f, -0.01422897f, 0.02872278f, 0.02368579f, -0.00780077f, 
    -0.03698209f, -0.01429584f, -0.02877017f, -0.01102328f, 0.02117996f, -0.03946823f, -0.00103059f, 0.01329404f, 
    0.00439215f, 0.02412519f, 0.01010105f, -0.01186765f, -0.03770580f, -0.01069556f, -0.02552322f, -0.03982142f, 
    -0.00584411f, 0.01580052f, 0.00891143f, -0.01126556f, 0.01095912f, -0.01788058f, -0.03233069f, 0.01949346f, 
    0.03207752f, -0.00599731f, -0.01805748f, -0.01452390f, -0.03626006f, 0.00464235f, -0.03381166f, -0.01355597f, 
    0.00304931f, -0.01091135f, -0.03145593f, -0.02835431f, -0.02409487f, 0.01353603f, -0.02048598f, 0.01891976f, 
    -0.00536300f, -0.02470595f, -0.03092944f, 0.00170400f, -0.01672081f, -0.00100866f, -0.04169632f, 0.01370021f, 
    -0.03734904f, -0.01683546f, -0.03907043f, 0.01991075f, 0.01732849f, 0.01848487f, 0.02009491f, -0.03467739f, 
    -0.01687933f, -0.00536142f, -0.03981470f, 0.01955761f, 0.00972640f, 0.02637098f, -0.01939704f, 0.00466555f, 
    0.00953012f, 0.01608412f, 0.01183935f, -0.02144245f, 0.01662433f, 0.02136433f, -0.00353392f, -0.00415893f, 
    0.01897021f, -0.00149978f, -0.02566130f, -0.01997619f, -0.02490526f, -0.03708674f, 0.02138733f, -0.02519185f, 
    -0.03047206f, -0.00879626f, -0.04059709f, -0.00178105f, 0.01324478f, 0.00269158f, 0.02933512f, -0.01365982f, 
    -0.03474941f, -0.02315495f, 0.02445639f, 0.02648001f, 0.01934316f, -0.01518355f, -0.02783120f, 0.01565094f, 
    0.02982634f, -0.00768119f, 0.00983610f, -0.01456791f, 0.00691094f, -0.00733218f, -0.00787072f, -0.01978496f, 
    0.02927756f, 0.01988408f, 0.01525454f, -0.02321769f, -0.02099654f, 0.00276620f, -0.03702923f, 0.00733438f, 
    0.02604880f, -0.00926715f, 0.00188911f, -0.01792473f, -0.00500962f, -0.03655008f, -0.01967579f, -0.01884760f, 
    0.00622409f, 0.00206817f, -0.03566816f, -0.00440268f, 0.02511137f, -0.01846910f, 0.02719529f, 0.02217020f, 
    -0.03672913f, -0.00990874f, 0.02966293f, 0.01049039f, -0.02863233f, -0.00305209f, 0.00727337f, 0.01548869f, 
    0.01516297f, -0.01446610f, 0.00884635f, -0.03848220f, 0.02071147f, 0.00334969f, -0.00735031f, 0.01006503f, 
    -0.02905110f, -0.02909033f, -0.03009604f, 0.01758530f, 0.01403189f, -0.02127423f, -0.02991442f, -0.02402300f, 
    -0.01895647f, -0.03994035f, -0.00520471f, 0.01815007f, -0.02962762f, 0.01851312f, -0.01093574f, -0.03115429f, 
    0.02207004f, -0.03765155f, -0.02223985f, -0.01109149f, -0.00042676f, -0.00538460f, -0.03614827f, 0.00334354f, 
    -0.01491592f, -0.02651865f, -0.00404954f, 0.00575914f, -0.01902785f, -0.03758830f, -0.00753224f, -0.01673964f, 
    -0.00095542f, -0.02711491f, -0.04020832f, 0.02909080f, -0.03282341f, -0.01063690f, -0.01026862f, 0.00080731f, 
    0.02325817f, -0.03047133f, -0.01503718f, -0.04000528f, 0.00683706f, 0.02484003f, -0.02857897f, 0.00165942f, 
    0.02415564f, -0.03871433f, -0.01189940f, 0.02330213f, 0.01898543f, 0.00409178f, 0.00129403f, -0.01702697f, 
    -0.00355118f, -0.00063585f, -0.00770323f, 0.00097605f, -0.02085814f, -0.00020458f, -0.01234849f, -0.03647852f, 
    -0.01399292f, -0.03804002f, -0.00115703f, -0.03815207f, -0.02260177f, -0.00879492f, -0.03094677f, -0.02284931f, 
    -0.01032399f, -0.00094861f, -0.03660731f, -0.00938672f, -0.00279628f, 0.00063019f, -0.00300399f, -0.03562065f, 
    -0.01762547f, -0.00973525f, -0.02572013f, -0.00929157f, -0.01612115f, 0.02864814f, -0.01601368f, -0.03689822f, 
    -0.02776729f, -0.02423295f, -0.03455655f, -0.02394985f, 0.01000067f, -0.02767983f, -0.00662532f, -0.02905331f, 
    -0.00049930f, 0.00796368f, 0.00068980f, -0.00713831f, -0.03734363f, 0.00363465f, -0.02228587f, 0.00772391f, 
    -0.02936205f, -0.02881618f, 0.00964664f, -0.01985366f, -0.03994621f, -0.01529440f, -0.00369335f, 0.00871512f, 
    -0.00935180f, 0.01830523f, 0.00286161f, -0.01658281f, 0.03192754f, 0.02332762f, -0.03461052f, -0.01961116f, 
    -0.00740206f, -0.04158135f, 0.01021209f, 0.02406542f, 0.00105838f, -0.01545269f, -0.02580009f, -0.01362713f, 
    0.00301235f, -0.02862963f, -0.03716785f, -0.00519849f, -0.01602514f, 0.02125849f, -0.00588177f, -0.02140258f, 
    -0.01490439f, -0.04064640f, -0.02469070f, -0.03207968f, 0.00698575f, 0.01231740f, 0.02833300f, 0.00482498f, 
    -0.00347790f, -0.00511891f, 0.00332394f, 0.00801874f, 0.00388075f, -0.03810473f, 0.01505655f, -0.03159138f, 
    0.01046768f, 0.02032598f, -0.02541455f, 0.02252424f, 0.02170100f, -0.01540817f, -0.01570692f, 0.02386915f, 
    0.02414295f, -0.00390339f, 0.02190571f, -0.02137772f, 0.00501996f, -0.01764975f, -0.02839024f, -0.03253935f, 
    -0.01471561f, -0.00519452f, 0.00942869f, -0.01479726f, -0.00339536f, -0.02205617f, -0.03092334f, 0.01589098f, 
    -0.03936838f, -0.02461972f, -0.03384123f, 0.01787032f, -0.03742322f, -0.02157971f, 0.00098257f, 0.01632566f, 
    0.00043929f, 0.01289066f, -0.02678513f, 0.02279970f, 0.00904597f, -0.02465253f, -0.03041424f, -0.01663249f, 
    -0.00518404f, -0.00344558f, 0.02098616f, -0.04126454f, -0.03573514f, -0.01687306f, -0.02488437f, -0.01566987f, 
    0.00745796f, 0.01220208f, -0.01710596f, 0.01473003f, -0.00896397f, -0.02465436f, -0.01257847f, -0.00067811f, 
    -0.00098153f, -0.02760912f, -0.00955421f, -0.03996532f, 0.02779544f, -0.02131693f, 0.02814267f, -0.02681619f, 
    -0.00300719f, -0.02952716f, 0.01273403f, 0.01336722f, 0.01083753f, -0.03391730f, 0.00198660f, 0.02805847f, 
    0.00426821f, 0.01537409f, 0.01585644f, -0.01196892f, 0.01417674f, 0.02289368f, 0.02835512f, -0.01157371f, 
    0.01747136f, 0.00132597f, 0.00339230f, 0.00862569f, -0.04047620f, 0.01664643f, 0.00077529f, 0.02625234f, 
    0.02340372f, -0.01557641f, -0.02082078f, -0.01498253f, 0.02541132f, -0.03347824f, 0.00266485f, 0.01205794f, 
    -0.00384793f, 0.00123243f, 0.01999032f, -0.03268101f, -0.00610944f, -0.03713838f, -0.04070095f, -0.01980342f, 
    -0.00740897f, -0.03273765f, -0.03521805f, 0.00053213f, -0.02770313f, -0.03797859f, -0.03082529f, 0.01679467f, 
    0.00625928f, -0.03708142f, 0.00262590f, 0.00430922f, -0.03294719f, -0.02163919f, 0.00423874f, -0.01089138f, 
    -0.02403003f, -0.01336663f, 0.02573238f, -0.02461530f, -0.02746146f, 0.02369607f, 0.02497802f, -0.00626634f, 
    -0.01210256f, -0.02217119f, 0.01193771f, -0.00213199f, 0.00288085f, 0.00513575f, -0.00049195f, -0.01540224f, 
    -0.03927660f, 0.02427949f, -0.01612762f, 0.01514596f, 0.00546469f, 0.00741300f, 0.00287962f, 0.01243027f, 
    -0.02664245f, -0.03390684f, -0.00895403f, 0.00764270f, -0.02207445f, -0.00935713f, -0.03946045f, -0.03232413f, 
    0.02620308f, -0.01604817f, 0.02232805f, 0.02414503f, 0.01346601f, -0.01800876f, 0.00076009f, 0.00503627f, 
    -0.03308008f, 0.00232129f, -0.04017520f, 0.01649552f, -0.02430454f, -0.01526811f, 0.01669273f, -0.01320236f, 
    0.01907991f, -0.02759132f, 0.01759551f, -0.01984671f, -0.00472930f, -0.01576155f, -0.02184276f, -0.00358855f, 
    0.01004044f, -0.00157769f, -0.00002239f, 0.00573188f, 0.00323346f, 0.01350748f, -0.01085288f, -0.03014298f, 
    -0.03552419f, -0.01696617f, 0.02845482f, -0.02503622f, -0.03307717f, 0.01204246f, -0.01833590f, -0.00181755f, 
    -0.03608898f, 0.01863133f, 0.01858365f, -0.02549467f, -0.02233276f, 0.00157123f, -0.02165413f, -0.02451126f, 
    -0.03550598f, 0.00295751f, 0.01787364f, -0.00390198f, -0.02456922f, -0.01503474f, -0.02639603f, 0.00562706f, 
    -0.01168675f, -0.00412683f, -0.04036550f, 0.00087285f, -0.01328527f, -0.03605513f, 0.01164818f, -0.03114972f, 
    -0.01783404f, 0.01373376f, -0.00944360f, 0.00492373f, -0.00382771f, -0.00049102f, -0.01454065f, 0.00315874f, 
    0.00867745f, -0.00911090f, 0.02483691f, -0.01068675f, -0.00014093f, -0.00784496f, -0.02509935f, -0.02816387f, 
    -0.00914714f, 0.02786539f, -0.01657277f, 0.01233720f, 0.02264101f, -0.03923995f, -0.03639162f, 0.00207531f, 
    -0.03507417f, -0.00010905f, 0.00239319f, 0.00925595f, -0.03289495f, -0.00813737f, 0.01333339f, 0.00266350f, 
    -0.00669741f, -0.01818977f, 0.03416868f, -0.02556737f, -0.00646205f, 0.02138528f, 0.00942851f, 0.01734785f, 
    -0.00950495f, -0.01487878f, 0.01977304f, -0.03568468f, -0.02396205f, 0.01134987f, 0.02000498f, -0.00343427f, 
    0.01943503f, 0.01298336f, 0.02402361f, -0.01539368f, -0.02767001f, 0.01918424f, -0.02190162f, 0.02219456f, 
    -0.01931310f, 0.00753034f, -0.02671983f, -0.01579579f, 0.00426879f, -0.01665598f, -0.03606218f, 0.01571618f, 
    -0.00465131f, -0.02862786f, -0.03774222f, 0.01347323f, -0.01217971f, -0.00997321f, 0.01732884f, -0.02144541f, 
    0.00942567f, -0.01896008f, -0.02020435f, -0.00889336f, -0.00008231f, -0.00318978f, -0.02468972f, -0.01087920f, 
    -0.01889632f, 0.01053250f, 0.00242557f, 0.02124969f, -0.02169108f, -0.00617854f, -0.00593180f, -0.00061695f, 
    -0.02374848f, 0.02170282f, 0.00408382f, 0.02565171f, 0.00580340f, -0.02981383f, -0.01421899f, -0.00434482f, 
    0.00919356f, -0.01965147f, -0.03136121f, -0.02453029f, 0.00103390f, -0.00679756f, 0.02771598f, -0.03821899f, 
    0.02501508f, -0.02041660f, 0.00211325f, 0.01260739f, 0.02063512f, 0.01960854f, -0.02438929f, -0.04160866f, 
    0.01242440f, -0.01658539f, -0.00868507f, 0.02027683f, 0.02258374f, -0.03163039f, -0.00134926f, 0.03363891f, 
    0.02467635f, 0.01140517f, 0.02462154f, -0.00125142f, -0.03645871f, 0.00871796f, 0.00985071f, -0.03180356f, 
    -0.00510774f, 0.02598117f, -0.00936836f, -0.04208349f, -0.02636739f, 0.01373712f, -0.00735562f, 0.01731074f, 
    0.01572809f, -0.01524742f, 0.01709219f, -0.03863018f, -0.01002940f, -0.01239381f, 0.02261628f, -0.02304424f, 
    -0.03286950f, 0.02720219f, 0.02390013f, -0.02842261f, 0.00728952f, -0.02898140f, 0.02812996f, 0.01313687f, 
    0.00988971f, -0.02897763f, -0.00100919f, -0.00687835f, -0.00363898f, 0.01788682f, 0.01372184f, 0.00569937f, 
    -0.01853252f, 0.02715229f, 0.01091163f, 0.02291933f, -0.02450525f, 0.00614489f, 0.00039841f, -0.01302008f, 
    0.01905564f, -0.00606944f, -0.00006561f, -0.01013476f, -0.00511939f, -0.02938254f, -0.02936757f, -0.03036742f, 
    -0.00648197f, 0.01309436f, -0.00428300f, -0.01631758f, 0.02075595f, -0.02283695f, -0.00350924f, 0.00119025f, 
    0.01743489f, -0.01961367f, -0.03118233f, -0.02740073f, -0.03134634f, -0.00093975f, -0.02037816f, 0.00344542f, 
    -0.02009095f, -0.00681716f, -0.02633354f, -0.01372758f, -0.01692975f, -0.03803111f, -0.03135860f, -0.03809957f, 
    -0.00954717f, -0.03021972f, -0.00600908f, -0.01873080f, 0.00886945f, -0.02592558f, -0.01464001f, -0.00737255f, 
    0.02627938f, 0.02071682f, 0.00986734f, -0.01275323f, -0.03418013f, -0.00101421f, 0.02218513f, -0.01985061f, 
    0.01571537f, -0.00233662f, -0.02543546f, -0.02720041f, 0.02479147f, -0.01021420f, 0.01202753f, -0.00868612f, 
    -0.08112821f, -0.13333482f, 0.18727022f, 0.20382817f, 0.06230908f, 0.11929474f, -0.17020385f, -0.10276619f, 
    0.06689156f, 0.09824654f, 0.22481930f, 0.07914258f, -0.16525552f, 0.15896100f, 0.10319625f, -0.13805100f, 
    0.05955207f, -0.12542453f, -0.15821449f, 0.19905581f, 0.17954352f, 0.12949194f, 0.00839650f, 0.08513305f, 
    -0.22484323f, -0.18782932f, 0.12037237f, -0.00990314f, -0.13230491f, 0.03507688f, -0.07087536f, -0.15194994f, 
    -0.03111637f, -0.00583213f, 0.03869170f, -0.02248719f, -0.05447867f, 0.11516661f, 0.03991993f, -0.11097214f, 
    0.07537322f, 0.09106947f, 0.02902662f, 0.11649482f, -0.14282092f, 0.00894138f, 0.09338758f, -0.06918998f, 
    -0.11717456f, 0.41591451f, 0.00151467f, 0.17546147f, -0.09238982f, -0.16224213f, 0.10344968f, 0.12123254f, 
    0.00268025f, 0.03913083f, 0.10762122f, -0.22224060f, -0.40438235f, -0.00807838f, -0.00366247f, 0.23387299f, 
    -0.03021858f, -0.08438210f, 0.19520794f, -0.02577507f, -0.05352504f, 0.01928204f, -0.07006817f, -0.07606147f, 
    -0.20073563f, 0.13976626f, -0.18310711f, 0.07243653f, -0.08509869f, -0.12920812f, 0.05998268f, 0.26497218f, 
    0.08668762f, 0.13238566f, 0.15670291f, 0.25718358f, -0.25432304f, -0.19932723f, 0.19832999f, 0.03176005f, 
    -0.10515574f, 0.00046925f, -0.20390692f, -0.12754135f, 0.10646480f, -0.00708493f, 0.19120808f, 0.05095353f, 
    0.43226853f, 0.01572888f, 0.09843026f, -0.06202639f, -0.05510337f, 0.17362690f, -0.03249742f, 0.06545834f, 
    -0.00049514f, 0.04155143f, 0.03858089f, -0.13034062f, -0.23191808f, -0.19379990f, 0.08280925f, -0.01548860f, 
    -0.08672936f, -0.10925430f, -0.08594099f, -0.15525939f, 0.06158115f, -0.17427310f, 0.06702673f, -0.05819968f, 
    -0.09271075f, 0.16045345f, 0.07631227f, 0.21440673f, 0.08445015f, -0.02002139f, 0.09319715f, 0.09480052f, 
    0.02847575f, 0.20038928f, -0.01380292f, 0.03911631f, -0.23852521f, -0.07550897f, -0.06377652f, 0.35803086f, 
    0.03545715f, -0.01332710f, -0.06050155f, -0.11304359f, 0.13725559f, 0.05056789f, -0.01511164f, 0.11517192f, 
    -0.09251447f, -0.05296660f, 0.04487123f, 0.27018681f, -0.10649118f, -0.14860584f, -0.09418651f, 0.01962726f, 
    -0.02826767f, 0.04782704f, -0.08465781f, -0.03955547f, 0.22580011f, 0.32152069f, -0.03368010f, 0.07043867f, 
    -0.03589118f, -0.03250474f, 0.27896848f, 0.05499044f, 0.10340404f, 0.01393599f, 0.47713980f, 0.05118532f, 
    -0.18201056f, -0.06398606f, 0.00882560f, -0.13168597f, -0.04871035f, 0.03405467f, 0.03611191f, 0.01791775f, 
    0.02512897f, -0.01034136f, 0.17250155f, 0.05718713f, -0.16356315f, 0.07634712f, 0.03806806f, 0.34986401f, 
    0.22370942f, -0.22729421f, 0.17465094f, -0.08506725f, -0.03002677f, -0.05068084f, 0.15485489f, 0.04553857f, 
    0.26363021f, 0.05773088f, -0.03198978f, 0.01409214f, -0.06218209f, 0.01163107f, 0.06793307f, 0.00023457f, 
    0.12177987f, 0.07248664f, 0.00583301f, 0.08913856f, 0.10523590f, 0.14738020f, 0.02668868f, 0.04878772f, 
    0.06873712f, 0.00793036f, 0.01786957f, -0.09923633f, 0.09780034f, 0.10312265f, 0.12925130f, 0.03314613f, 
    0.25869837f, 0.01282806f, 0.24584001f, -0.12993687f, -0.13880379f, 0.00636333f, 0.04860353f, 0.27676091f, 
    -0.10015184f, -0.29425648f, 0.13755189f, -0.12273858f, 0.18741944f, 0.04044832f, -0.02763106f, -0.06034736f, 
    -0.03218067f, -0.01564415f, 0.02546516f, 0.00079746f, 0.03934686f, 0.16753204f, -0.13878246f, 0.09152776f, 
    0.20770191f, 0.15042995f, 0.06366532f, -0.01872402f, 0.01241818f, 0.04521113f, 0.29102412f, -0.15180379f, 
    0.06875455f, 0.05739145f, 0.24808758f, 0.02901996f, 0.16483071f, -0.07942156f, 0.02230490f, -0.04247368f, 
    0.03746028f, -0.01503548f, 0.11139760f, 0.12668025f, -0.02487815f, 0.05188728f, -0.07401286f, 0.03193947f, 
    0.07352971f, 0.16788237f, -0.00864097f, 0.15973507f, -0.00246430f, -0.08880841f, -0.03543963f, 0.06621213f, 
    0.09271067f, 0.04112116f, -0.12377894f, 0.27742320f, -0.13500497f, -0.23053338f, 0.30800286f, 0.21588945f, 
    0.22919306f, 0.14378409f, 0.07645515f, -0.08538664f, -0.09674215f, 0.07217263f, 0.23339392f, -0.11457081f, 
    -0.09341832f, -0.02802013f, 0.00236256f, -0.06226956f, -0.11051396f, 0.08879248f, 0.09012379f, 0.16739506f, 
    -0.03453521f, -0.10377870f, -0.03630259f, -0.02469149f, 0.19162777f, 0.10833821f, -0.09395051f, -0.15969889f, 
    0.04861425f, 0.07768674f, -0.07915917f, -0.05854502f, -0.00140184f, 0.04250399f, -0.15304689f, -0.14883609f, 
    0.28474221f, -0.02470654f, -0.05588276f, -0.14700449f, -0.11175133f, -0.41273594f, -0.00492188f, -0.07679054f, 
    0.10240392f, -0.04345828f, -0.01894956f, 0.04613996f, -0.09494491f, 0.04276399f, -0.06558730f, -0.05407968f, 
    -0.09995118f, -0.24245611f, 0.04042798f, 0.01308220f, 0.23747841f, -0.00042587f, 0.22298262f, 0.10747164f, 
    -0.22666204f, -0.07849076f, 0.12419832f, -0.08661708f, -0.16020307f, -0.11472541f, -0.08009004f, 0.03937317f, 
    -0.01994079f, -0.00530144f, -0.06110533f, -0.08141883f, 0.03192398f, 0.10013259f, -0.06984867f, -0.02580190f, 
    0.18210223f, 0.11967085f, 0.06668193f, -0.08482953f, -0.15506338f, 0.22027320f, -0.00430857f, -0.03436579f, 
    -0.17473805f, -0.45397025f, 0.10596044f, 0.47597158f, 0.18073434f, -0.09155251f, 0.09215072f, -0.32304406f, 
    -0.16925694f, 0.05406926f, 0.04089896f, 0.02577512f, 0.07484854f, 0.30386460f, 0.22393170f, 0.05205134f, 
    0.12239952f, -0.01149134f, -0.17007677f, -0.12160330f, 0.05424107f, 0.08048827f, 0.04991491f, 0.01093270f, 
    0.02794585f, 0.07740770f, -0.02023330f, -0.05026582f, 0.07041161f, 0.00234190f, -0.07940638f, -0.03144916f, 
    0.00787581f, -0.02576185f, -0.01535559f, -0.28689167f, 0.25928608f, 0.21576527f, -0.00572289f, -0.02278229f, 
    -0.02931130f, -0.02252829f, 0.22165468f, -0.07116074f, 0.07452520f, 0.06525994f, 0.18300821f, 0.07259402f, 
    -0.15983297f, -0.28515384f, -0.13431390f, 0.48943073f, 0.19892037f, 0.16303092f, -0.12920626f, -0.07115729f, 
    0.02944214f, 0.12338525f, 0.09097267f, -0.04841781f, -0.03174765f, -0.21329357f, 0.05710169f, 0.18222511f, 
    0.06080630f, 0.00980268f, -0.04020583f, -0.10194042f, -0.09721792f, -0.09386845f, 0.25636941f, -0.09841496f, 
    -0.04427221f, 0.00216501f, -0.01243568f, -0.01364595f, 0.15078673f, 0.09782968f, -0.00404932f, 0.21825628f, 
    -0.17300513f, 0.04287893f, -0.06357531f, 0.05952385f, -0.12417822f, 0.01141192f, -0.02014139f, 0.10980438f, 
    -0.09532236f, -0.09937157f, -0.10179419f, 0.07918199f, 0.03014569f, 0.03406969f, -0.03464038f, 0.04781873f, 
    0.05643745f, 0.26733339f, 0.17773511f, 0.03949133f, 0.04185608f, -0.02741720f, 0.24237014f, 0.15481818f, 
    0.04290904f, 0.14744544f, -0.02682371f, 0.01366147f, -0.44791725f, -0.02824814f, 0.07228189f, 0.27692318f, 
    0.10384403f, 0.05801319f, -0.04454770f, 0.07860746f, 0.03019426f, -0.05573301f, 0.15553640f, 0.10643234f, 
    0.14190860f, 0.06869560f, 0.12458955f, -0.17444856f, -0.09630116f, -0.18742411f, -0.16870803f, -0.09899160f, 
    -0.09199549f, -0.04731615f, -0.02901508f, 0.00758491f, 0.17610437f, 0.15571319f, 0.06891711f, 0.06114244f, 
    0.02257713f, 0.04775345f, 0.03649395f, -0.04305543f, 0.07415536f, -0.00411265f, -0.07293279f, -0.06654238f, 
    0.13155520f, 0.05613195f, -0.04364460f, -0.00350934f, 0.00915094f, -0.03158583f, -0.02390556f, -0.00686279f, 
    0.00448484f, -0.07857662f, 0.00119288f, -0.13311960f, 0.29411179f, -0.22857027f, 0.09429600f, -0.16640696f, 
    -0.04571308f, 0.05000686f, -0.02743197f, 0.11734061f, 0.04246479f, -0.06427967f, -0.00365468f, 0.01237882f, 
    0.32130399f, -0.03764455f, 0.03465725f, -0.06654969f, -0.04787867f, 0.21114668f, -0.07365709f, 0.14274043f, 
    -0.02845876f, 0.03857091f, -0.00929733f, -0.02464781f, 0.02250824f, 0.03966487f, 0.13645189f, -0.09343742f, 
    0.09285273f, 0.06203938f, -0.04069372f, 0.01112484f, -0.01727581f, -0.02596925f, -0.14189719f, -0.01580594f, 
    0.05634518f, -0.20484097f, 0.24522303f, 0.07427560f, 0.07118513f, -0.02255798f, -0.00575035f, 0.25542355f, 
    -0.02868332f, 0.01444536f, -0.03717436f, -0.06936023f, 0.04561498f, -0.00681651f, 0.15077093f, -0.12642363f, 
    -0.22770031f, -0.00190247f, 0.00453374f, 0.02079812f, 0.04135430f, -0.04832373f, -0.06940899f, -0.10155975f, 
    0.03686382f, 0.07883056f, -0.00045777f, -0.14483625f, 0.02921690f, -0.03356925f, -0.07291893f, -0.07939344f, 
    0.16216280f, -0.02459697f, 0.00813373f, -0.14331226f, -0.06841084f, 0.05176042f, -0.14533065f, 0.31933862f, 
    -0.03552279f, -0.11833207f, 0.28084835f, -0.17949237f, -0.07069188f, 0.09847393f, -0.08467146f, -0.02291546f, 
    0.12981156f, -0.03119938f, -0.06741259f, -0.09903812f, -0.12352768f, -0.14767174f, -0.12615445f, -0.05137221f, 
    -0.02001349f, 0.12807801f, 0.00855306f, 0.07051215f, -0.17740735f, 0.00439782f, -0.00196702f, -0.20626837f, 
    -0.02405863f, -0.14792003f, 0.13088426f, 0.13578536f, -0.02854494f, -0.11162561f, 0.10554832f, -0.03284322f, 
    -0.14695656f, -0.21078537f, 0.04017471f, 0.15976253f, 0.05045071f, 0.05966248f, -0.02751189f, 0.04504963f, 
    -0.10599201f, 0.07928346f, 0.13251919f, -0.19376744f, -0.11717378f, 0.10432194f, 0.04040324f, 0.18181172f, 
    0.15269382f, 0.03536179f, -0.05348552f, 0.00851593f, -0.14965655f, -0.10157491f, 0.01269391f, -0.06262528f, 
    -0.20522940f, -0.07748297f, 0.22238450f, 0.21398358f, 0.00133684f, -0.12163500f, -0.16123846f, -0.09637533f, 
    -0.09863033f, -0.01102635f, 0.06121932f, -0.06122808f, -0.08499483f, 0.10049616f, -0.13787323f, 0.04753906f, 
    0.09569108f, 0.10287492f, 0.07801009f, -0.04534317f, -0.05933416f, -0.10523701f, 0.02175635f, -0.17440867f, 
    -0.08843710f, -0.13012321f, 0.19873396f, 0.24854404f, 0.00005175f, 0.05869878f, -0.04046393f, 0.24711192f, 
    -0.13148855f, 0.14127222f, -0.00622578f, -0.10782394f, -0.08112042f, 0.10923982f, 0.15573044f, -0.24796672f, 
    -0.12355657f, -0.16494033f, 0.07620505f, -0.03969949f, 0.02030718f, 0.09044159f, -0.03004948f, 0.09874833f, 
    0.21784309f, 0.12235165f, -0.17276406f, -0.05935051f, 0.08375991f, 0.07769869f, 0.19710335f, 0.06516633f, 
    0.02785906f, -0.02442785f, 0.03775356f, -0.04889789f, -0.17675875f, 0.04846378f, 0.02879378f, -0.19629550f, 
    0.22931175f, -0.06305450f, 0.22046749f, -0.13512808f, 0.13258640f, 0.03784439f, -0.06490114f, 0.16283540f, 
    0.05101833f, -0.03378850f, 0.11856551f, 0.37487701f, -0.06721326f, 0.05451968f, -0.00389857f, -0.01174581f, 
    0.11365514f, -0.06313171f, 0.10049181f, -0.09375565f, -0.05481474f, -0.01090435f, 0.06395304f, -0.10770670f, 
    0.01053759f, -0.02511158f, 0.05619740f, 0.16529399f, -0.06313244f, -0.03719507f, 0.06277198f, -0.04987004f, 
    0.07830261f, 0.08439509f, 0.06002973f, 0.01293705f, -0.02605833f, 0.00470407f, -0.02447415f, -0.04489714f, 
    0.05171097f, -0.06981460f, -0.07460383f, 0.00968943f, -0.01367499f, 0.02755447f, -0.09741095f, -0.08608598f, 
    -0.07915969f, -0.32985741f, 0.10680878f, 0.10500412f, 0.08252922f, 0.09616639f, 0.17219342f, 0.18113030f, 
    -0.02735731f, 0.00240423f, -0.04012275f, -0.01045527f, -0.03370623f, -0.00022987f, 0.02565240f, -0.00061443f, 
    0.01632786f, 0.00331419f, 0.00452640f, 0.02394449f, -0.01904462f, -0.03509088f, 0.02318101f, -0.03160664f, 
    -0.03700192f, -0.02365231f, 0.02005766f, -0.02162030f, -0.01231872f, -0.00727275f, -0.01281709f, 0.00082294f, 
    0.02247038f, 0.01326554f, -0.01335513f, 0.00815883f, -0.00266262f, 0.01709813f, 0.00253817f, 0.00999843f, 
    -0.02366177f, -0.03127010f, -0.01554883f, -0.03073919f, -0.01488963f, 0.01654060f, 0.01497198f, -0.01272606f, 
    -0.03438273f, 0.02989441f, 0.02220322f, -0.00167141f, -0.02538540f, 0.02889740f, 0.02232161f, -0.04042948f, 
    -0.00971566f, -0.02494729f, -0.00546865f, -0.03544866f, 0.00823354f, 0.02081383f, -0.01602235f, 0.00925483f, 
    0.00536941f, -0.03114703f, 0.01244032f, 0.02086462f, -0.00901717f, -0.02482542f, 0.02557643f, 0.01791206f, 
    -0.01240099f, -0.03744339f, -0.03381813f, 0.00039674f, -0.03643502f, 0.02280459f, 0.02660717f, 0.01453050f, 
    -0.01496154f, -0.01031585f, -0.03916033f, 0.01815396f, 0.01520622f, -0.01787140f, -0.01862094f, -0.00132823f, 
    0.00240871f, -0.03458511f, 0.02608148f, -0.01275329f, 0.00636650f, 0.00869151f, 0.02059554f, -0.04039297f, 
    0.00243354f, 0.02411104f, -0.01085590f, -0.01850184f, -0.01762206f, -0.01162517f, -0.03533881f, -0.00199396f, 
    -0.00302694f, 0.01438586f, 0.02645619f, 0.01998212f, 0.01001170f, -0.03133805f, -0.02639332f, -0.02905156f, 
    -0.00519001f, -0.00435651f, 0.02575254f, -0.03806406f, -0.00330370f, -0.00712050f, 0.00168896f, 0.01411359f, 
    -0.00264790f, -0.00547174f, 0.01332698f, -0.01534323f, 0.01641284f, 0.01235482f, -0.03322277f, -0.01463250f, 
    -0.01824028f, -0.02414526f, 0.01846353f, 0.02664967f, 0.00964974f, 0.00329695f, -0.00197561f, 0.01597797f, 
    -0.03524687f, -0.03554150f, 0.00353087f, 0.02395484f, 0.00787942f, 0.01711108f, -0.01749814f, -0.00947191f, 
    -0.01105052f, 0.02815852f, -0.02286744f, -0.00643946f, 0.02357578f, -0.02414898f, 0.02610826f, 0.00760185f, 
    -0.02214568f, 0.01656246f, 0.00839949f, -0.02669190f, 0.02715673f, -0.04107269f, 0.01447619f, 0.00092709f, 
    -0.02637662f, 0.01508911f, -0.02087857f, -0.00590466f, 0.00206827f, 0.01743590f, -0.02991056f, -0.04037451f, 
    -0.01633714f, 0.00346666f, -0.01756606f, 0.00431637f, -0.01624832f, -0.01735431f, -0.03154301f, 0.00007476f, 
    0.02696608f, 0.02283068f, -0.03050270f, -0.03359098f, -0.03276217f, -0.00375147f, 0.00810714f, 0.00995537f, 
    0.01925216f, -0.03315703f, 0.00829064f, 0.02679227f, -0.03191699f, -0.02686582f, -0.03606590f, -0.03075592f, 
    -0.02666600f, 0.02367366f, 0.02277923f, -0.00659291f, -0.02039639f, 0.02651375f, -0.02461085f, 0.02339159f, 
    -0.03978677f, -0.01600419f, 0.00096245f, 0.00603476f, -0.03015721f, -0.03084847f, -0.00100220f, -0.03306835f, 
    0.02209157f, -0.00158865f, 0.00490121f, 0.00789747f, -0.01109365f, 0.02441890f, -0.00148964f, 0.01721378f, 
    -0.02836391f, 0.02756018f, -0.00577272f, 0.00414349f, -0.04064942f, -0.01571550f, -0.03733156f, 0.01445921f, 
    -0.01986220f, 0.01610761f, 0.01634714f, -0.00970369f, 0.01068688f, -0.03473820f, -0.00702544f, 0.02355035f, 
    0.01263273f, 0.01807052f, 0.01663649f, 0.00782096f, -0.01164298f, 0.00012057f, -0.02380174f, 0.00367095f, 
    -0.00087095f, 0.02087370f, 0.01158997f, 0.02079143f, 0.01457853f, 0.02672072f, -0.02321839f, -0.00570063f, 
    -0.02390821f, 0.01753544f, -0.04198989f, -0.03713150f, -0.01997243f, 0.00680827f, -0.01076271f, -0.00397952f, 
    -0.02630193f, -0.01290605f, -0.00276518f, 0.01640329f, 0.01926174f, -0.00961949f, 0.01125494f, 0.00150988f, 
    -0.04134566f, -0.01150158f, -0.03308547f, -0.00962622f, -0.02066165f, -0.02914573f, 0.02070965f, 0.02619700f, 
    -0.00984514f, 0.01924371f, -0.02160618f, -0.03570558f, -0.01670196f, 0.01019707f, -0.01803447f, 0.00950799f, 
    -0.02001197f, -0.02665807f, -0.00307249f, -0.03456731f, -0.00878130f, -0.01690079f, 0.01226673f, -0.00279767f, 
    -0.00522589f, 0.02469997f, -0.03847131f, 0.02075014f, -0.03222508f, -0.00524900f, -0.00942242f, 0.02691328f, 
    0.02302299f, -0.02302613f, -0.03720383f, 0.01942021f, -0.00728677f, -0.03730112f, -0.00253515f, -0.03966086f, 
    -0.00873123f, 0.02165604f, -0.00363970f, 0.01335236f, -0.04178539f, -0.02777610f, 0.01155176f, 0.01550848f, 
    0.02573244f, -0.02159565f, 0.02049256f, -0.03096628f, 0.00452868f, 0.01488584f, 0.01337425f, 0.00221860f, 
    -0.03656175f, -0.00773577f, -0.03513587f, 0.02009704f, -0.02030909f, -0.00301772f, 0.01486675f, 0.02938497f, 
    0.02804935f, -0.02593899f, 0.02667867f, -0.03437771f, 0.00331055f, 0.02693798f, 0.00121324f, -0.00951202f, 
    -0.03700814f, 0.02170385f, -0.03667768f, -0.01226570f, -0.01141641f, -0.01316427f, 0.00234524f, -0.01785668f, 
    0.00463575f, 0.01539387f, -0.01706684f, -0.02496154f, -0.00624301f, -0.01100695f, 0.00630639f, -0.02332171f, 
    0.00134729f, -0.01344021f, -0.03751835f, -0.03533378f, -0.00032888f, 0.01099047f, 0.01965188f, -0.03536102f, 
    -0.03921456f, -0.03137609f, 0.00111822f, 0.00079869f, 0.01569989f, -0.03181425f, -0.03435875f, -0.03001886f, 
    -0.02750454f, -0.02985782f, -0.00520156f, -0.01802569f, -0.02179916f, 0.02303138f, 0.01549879f, -0.02761378f, 
    -0.04066852f, 0.01189599f, 0.00308269f, -0.04017878f, -0.02778302f, -0.02155185f, -0.02867071f, -0.02901828f, 
    -0.03619194f, -0.03523258f, 0.01187743f, -0.01847972f, 0.02490633f, -0.01710884f, -0.01836981f, -0.00055821f, 
    -0.02051165f, -0.02937062f, 0.02323677f, -0.03306056f, 0.00456685f, -0.00071624f, 0.02958628f, 0.01922933f, 
    -0.00084305f, -0.02971667f, 0.02255646f, -0.01599463f, -0.00279319f, 0.01980437f, 0.01773321f, -0.02381722f, 
    0.00940583f, -0.02679612f, -0.03226744f, -0.02456956f, -0.03543292f, 0.02805416f, -0.03835581f, 0.00715235f, 
    -0.02398416f, -0.00544379f, -0.03523612f, -0.00422541f, 0.00650151f, 0.02370016f, 0.00521138f, -0.03397062f, 
    0.02689666f, -0.02356856f, 0.00203864f, 0.01127256f, -0.00587420f, -0.00974172f, 0.00122977f, -0.01936150f, 
    0.00626840f, -0.02400607f, 0.00432957f, 0.01759791f, -0.00875288f, 0.00235123f, 0.00860808f, 0.02587648f, 
    -0.04017459f, -0.02616124f, -0.02257629f, 0.01314436f, -0.03396248f, 0.00314755f, -0.02196322f, -0.02283088f, 
    -0.02119271f, -0.02792288f, -0.02385136f, -0.03078607f, 0.00073034f, -0.03751421f, -0.02991992f, 0.01145834f, 
    -0.01364135f, 0.00667282f, -0.03104169f, 0.00343451f, -0.02849727f, -0.00041686f, -0.03398099f, 0.00832583f, 
    0.02865847f, -0.01323406f, -0.03490042f, 0.02517818f, -0.01755751f, -0.00016906f, -0.03572452f, 0.01432039f, 
    0.01261649f, 0.00884847f, 0.01308742f, 0.00355568f, 0.02406791f, -0.03147169f, -0.03587970f, 0.02945201f, 
    -0.01765239f, -0.03940371f, 0.01816650f, -0.01442402f, 0.02402141f, -0.03181121f, -0.00278741f, 0.01828020f, 
    -0.01109422f, -0.04031174f, 0.01286086f, -0.01426435f, -0.00513470f, 0.00504218f, 0.00276048f, 0.02467993f, 
    -0.03653050f, -0.02912592f, -0.01832205f, -0.01825329f, -0.00696441f, -0.00883515f, -0.00559052f, 0.02450273f, 
    0.02882670f, 0.00329343f, 0.01624014f, -0.03585697f, -0.01763191f, -0.01668553f, -0.00254045f, 0.01013941f, 
    -0.01270296f, 0.01179533f, 0.02225742f, -0.00505280f, 0.02543947f, 0.02904313f, -0.02197592f, -0.04166877f, 
    0.02563697f, 0.01165768f, 0.00015576f, 0.01271426f, 0.02889257f, -0.00054676f, -0.04087351f, -0.02155966f, 
    0.02226771f, 0.03005547f, -0.00063090f, 0.01739027f, -0.00086174f, -0.00311330f, -0.00708242f, -0.03596739f, 
    -0.02362797f, 0.02560502f, -0.03644910f, 0.01737082f, 0.00005885f, 0.00425980f, 0.00356239f, 0.00698820f, 
    -0.03698204f, -0.03806109f, 0.00490053f, -0.03330920f, -0.03135152f, -0.00757364f, 0.00715451f, -0.02310191f, 
    -0.02891459f, -0.00019494f, 0.00528135f, -0.00247106f, -0.02291158f, -0.02538134f, 0.00505546f, -0.00375184f, 
    0.01669483f, 0.01903509f, -0.03522217f, -0.00974591f, 0.00152726f, 0.01354640f, -0.01674799f, -0.01690436f, 
    0.01415941f, -0.01183403f, -0.04082211f, -0.00851896f, -0.04085318f, -0.02681933f, -0.00825072f, -0.03339315f, 
    -0.00822830f, -0.01950361f, -0.02677341f, 0.02715702f, -0.03767042f, -0.02913114f, 0.02726901f, 0.00282300f, 
    -0.02631703f, -0.03870255f, -0.00341705f, -0.04182696f, 0.02529587f, -0.00349730f, -0.02162715f, -0.03822743f, 
    0.02866328f, -0.02000751f, 0.01906273f, 0.01545783f, 0.02056476f, -0.01099017f, -0.01845273f, 0.00337809f, 
    -0.00892415f, -0.01648994f, -0.02332599f, -0.00873471f, -0.01501738f, 0.00249298f, -0.04072412f, 0.00928008f, 
    -0.01615469f, 0.00921089f, -0.03857724f, -0.02894367f, 0.02089072f, 0.02664756f, 0.01070595f, -0.01685470f, 
    0.02653205f, -0.02859891f, -0.00939748f, -0.01969077f, -0.00966250f, 0.00900460f, -0.00782983f, 0.00234622f, 
    -0.01756947f, -0.02880747f, 0.01656882f, -0.02969845f, -0.01645392f, 0.02252296f, -0.01840076f, -0.03600222f, 
    -0.01127837f, 0.00879108f, 0.00359063f, 0.00868643f, -0.02935953f, 0.02588789f, -0.00065567f, -0.01001909f, 
    -0.00133114f, -0.00413318f, -0.01349242f, -0.03331459f, 0.01927236f, -0.02599617f, -0.03002261f, -0.02793379f, 
    0.01334469f, 0.01693403f, 0.01290317f, 0.01017443f, -0.01708080f, -0.02479174f, 0.01959498f, -0.02256102f, 
    -0.03739284f, -0.02994995f, -0.03140132f, -0.03278415f, 0.00709470f, 0.01803310f, 0.01915542f, -0.04030966f, 
    0.00178803f, -0.00198264f, -0.02598757f, -0.01256808f, -0.00661171f, -0.01467575f, -0.02855971f, -0.00451898f, 
    -0.03927321f, 0.01739508f, 0.00512746f, -0.01678578f, 0.00881110f, -0.02313549f, -0.03677139f, 0.01528958f, 
    -0.04109656f, -0.00859846f, -0.01859248f, 0.00100528f, -0.02302143f, -0.03979840f, 0.00163582f, -0.01537121f, 
    -0.00381608f, -0.03149662f, -0.00429826f, 0.01070093f, 0.02049352f, -0.03515626f, 0.00438720f, -0.01164563f, 
    0.01193206f, 0.02484065f, 0.01331212f, -0.02680200f, -0.01543403f, -0.04143392f, 0.01556956f, 0.00446157f, 
    -0.03411857f, 0.01694396f, 0.00436962f, 0.02814761f, 0.00506923f, -0.02425450f, -0.01413813f, -0.02880016f, 
    -0.02373669f, -0.03058677f, 0.00010753f, -0.00416662f, -0.03729721f, 0.00038661f, 0.01883429f, -0.03465289f, 
    -0.03438476f, -0.03598643f, -0.01206950f, -0.02726565f, -0.03668323f, 0.01936036f, -0.03897296f, 0.01934288f, 
    0.01896719f, -0.03679284f, -0.01779413f, -0.00907049f, -0.01850265f, 0.01733289f, -0.01764075f, -0.03295464f, 
    -0.01104737f, -0.03714224f, -0.02227851f, 0.01224199f, -0.04145747f, -0.00872557f, 0.02656224f, 0.02330337f, 
    0.00317948f, -0.02825361f, 0.00707876f, -0.03189819f, 0.02924853f, 0.00363480f, 0.02276498f, 0.02787470f, 
    -0.01113321f, -0.01333586f, 0.01049632f, -0.01729369f, 0.02347427f, -0.00563385f, -0.02822917f, -0.02010687f, 
    -0.00796895f, 0.01069665f, -0.02409768f, -0.01375529f, -0.00995537f, -0.00564829f, -0.01386462f, 0.02488928f, 
    -0.02512199f, -0.03756248f, -0.03814381f, -0.03175407f, 0.02579883f, -0.01560694f, 0.02844338f, -0.03525423f, 
    -0.10643258f, -0.07731573f, 0.04119271f, -0.06982051f, -0.03058283f, 0.03667900f, -0.04790699f, -0.17016414f, 
    0.14080188f, -0.07432742f, -0.00921910f, 0.08113080f, -0.11102434f, -0.08406039f, -0.06331304f, 0.00222652f, 
    0.11134807f, 0.04230272f, 0.10951336f, -0.18258753f, 0.02409672f, -0.04954706f, -0.07894822f, -0.07943165f, 
    -0.01553548f, -0.24875434f, 0.02008151f, -0.11229129f, 0.09574286f, 0.00525933f, -0.03201077f, -0.03720432f, 
    -0.01619980f, -0.07473224f, -0.00981621f, 0.04519095f, -0.07641145f, -0.09085819f, -0.10555580f, -0.02373670f, 
    -0.11636642f, 0.17336006f, -0.12112955f, 0.07678798f, -0.05017095f, -0.05651794f, -0.03046484f, 0.01642040f, 
    -0.27547392f, 0.33091626f, 0.16244952f, -0.13972758f, 0.04392046f, 0.13867138f, 0.14530684f, 0.16089983f, 
    0.25497177f, -0.01813902f, 0.02390269f, -0.03689697f, -0.20424548f, -0.09734914f, 0.07909488f, 0.08124498f, 
    0.00544888f, 0.07447867f, -0.01967374f, 0.11456627f, -0.00905995f, -0.06959032f, -0.05057863f, 0.09397395f, 
    -0.28726548f, -0.12676658f, 0.17176071f, 0.01538567f, -0.08679200f, 0.05209351f, -0.00212841f, 0.13988586f, 
    0.08863079f, -0.09152874f, -0.08473080f, 0.16952132f, -0.19967853f, 0.01253819f, -0.03857432f, -0.07964905f, 
    0.02380034f, 0.05866470f, 0.02206821f, -0.11042651f, 0.06037755f, 0.05634293f, 0.07924169f, -0.05677851f, 
    0.15183014f, 0.00321453f, 0.20971379f, 0.06626451f, 0.01622526f, 0.09025370f, -0.06180121f, -0.03007890f, 
    0.10670005f, -0.06027925f, -0.06615598f, -0.04790785f, -0.23605029f, 0.00204673f, -0.01907920f, -0.20420220f, 
    -0.00394007f, -0.12316779f, 0.18266945f, -0.05009604f, 0.08480337f, 0.00843287f, -0.04876139f, -0.02526991f, 
    0.28032076f, 0.04873072f, 0.45530528f, -0.19077298f, 0.12251488f, -0.01617362f, -0.03094950f, 0.37299058f, 
    0.16875912f, -0.00920917f, 0.08068123f, -0.10368527f, -0.09800784f, -0.27743053f, 0.02325138f, 0.09131466f, 
    0.10114125f, 0.03773040f, 0.02060292f, -0.07302819f, -0.05025141f, 0.01821240f, -0.08479434f, -0.09303305f, 
    -0.12478998f, -0.01250950f, 0.00814397f, 0.03839415f, 0.06545912f, 0.12613703f, 0.15130341f, -0.08563341f, 
    0.09432051f, 0.01287178f, -0.05924665f, -0.02316443f, -0.13757716f, 0.03607176f, 0.14108333f, -0.07594023f, 
    -0.02005611f, -0.01987083f, -0.07296409f, 0.19325221f, 0.28547135f, 0.07502606f, 0.12087142f, 0.08119089f, 
    -0.22443329f, -0.07894117f, -0.00018826f, -0.09834863f, -0.03578340f, -0.05258254f, 0.03357834f, 0.12392291f, 
    -0.08586169f, -0.11590941f, 0.02066936f, 0.00221805f, 0.03223170f, -0.13888513f, -0.00840813f, 0.16721699f, 
    0.01744786f, -0.01387903f, -0.00315167f, -0.02370199f, -0.02132403f, 0.03568896f, 0.00527116f, -0.20031148f, 
    0.06431657f, -0.02908346f, 0.03003465f, 0.04364146f, -0.00799438f, -0.03279467f, 0.08678128f, -0.01419063f, 
    0.06583961f, -0.07046887f, 0.03794929f, -0.13708673f, 0.19714819f, -0.05581965f, -0.09820102f, -0.03612332f, 
    -0.04061079f, -0.03861227f, -0.08699477f, 0.09210326f, -0.00957029f, 0.04113889f, 0.04379414f, -0.07641233f, 
    -0.07910786f, -0.09443519f, -0.07443246f, -0.14018913f, -0.10866946f, -0.04343007f, -0.25636050f, -0.22103855f, 
    0.16125286f, 0.01332312f, 0.03184108f, 0.02895103f, -0.03919416f, -0.09894297f, -0.03502776f, 0.03523289f, 
    -0.04972928f, -0.08431908f, -0.00607750f, -0.03102754f, -0.16495347f, -0.08254339f, -0.13541320f, -0.17448243f, 
    0.32767561f, 0.15444812f, -0.18148495f, -0.09381077f, 0.00876715f, 0.07109085f, -0.02348916f, 0.07824808f, 
    0.25650293f, -0.06309046f, 0.09554806f, 0.07263929f, 0.10321807f, -0.12976114f, -0.06620307f, 0.10192323f, 
    0.10508233f, 0.03768312f, -0.07020848f, 0.10526808f, -0.04394010f, 0.08429077f, 0.12965783f, 0.08077425f, 
    -0.13522540f, 0.14599857f, 0.04768444f, -0.08121993f, 0.09378541f, -0.02697685f, 0.05235900f, 0.02027954f, 
    0.11134540f, 0.25317952f, 0.14792140f, -0.04639523f, 0.00988302f, 0.29252160f, 0.16720207f, -0.16871125f, 
    -0.05831150f, 0.10225233f, -0.00606853f, -0.14680617f, 0.05003409f, -0.03324547f, 0.15558547f, 0.14296305f, 
    0.05493760f, -0.00678957f, -0.06285018f, 0.21367259f, -0.00851216f, 0.13057506f, -0.01851340f, -0.04985809f, 
    0.08546292f, 0.05696550f, -0.08111639f, 0.04882291f, -0.00429203f, -0.08028209f, 0.15621547f, 0.11490124f, 
    -0.04989721f, -0.07335845f, 0.05315858f, 0.02250478f, -0.08277910f, 0.05501995f, 0.03103306f, -0.10941500f, 
    -0.25453973f, -0.13637193f, -0.01068247f, 0.23176058f, 0.21765785f, -0.01823492f, 0.05879298f, 0.18351650f, 
    -0.04430367f, 0.03495935f, 0.07832193f, 0.01554258f, -0.10013826f, -0.06454895f, 0.10850830f, 0.03940352f, 
    0.03068697f, -0.01845061f, 0.07974102f, 0.04655828f, 0.09783192f, 0.02062648f, 0.04134638f, 0.06595004f, 
    -0.05644537f, -0.05685764f, -0.10362434f, -0.08320480f, 0.23834018f, 0.02216891f, -0.01051157f, 0.01745690f, 
    -0.04524386f, -0.05108764f, -0.02789374f, 0.04271200f, -0.10467479f, 0.02082619f, -0.01582679f, -0.08966820f, 
    -0.04403735f, -0.03281897f, -0.15561938f, -0.06582512f, 0.03010543f, -0.04511247f, -0.13567491f, 0.32336295f, 
    -0.12739992f, -0.06656885f, 0.29425639f, 0.08848055f, 0.12628916f, -0.07498354f, -0.03604989f, 0.18407430f, 
    0.10752436f, -0.00808375f, 0.08369594f, -0.00095483f, 0.17181385f, -0.17935525f, -0.15739083f, -0.03157574f, 
    -0.02203884f, -0.11503740f, -0.10728022f, 0.00796535f, 0.01537307f, 0.05164682f, 0.08236402f, -0.02312231f, 
    -0.09539209f, -0.02907776f, -0.10532869f, -0.07620241f, -0.03565063f, -0.01298660f, -0.14026257f, 0.04986213f, 
    -0.02680422f, -0.07371314f, 0.12218694f, 0.28034115f, 0.03602162f, 0.17772706f, -0.04332990f, 0.13519347f, 
    -0.02947924f, 0.06866083f, -0.07752465f, 0.04605100f, 0.12318712f, 0.00029065f, 0.00668254f, -0.02741001f, 
    0.16355382f, -0.29419306f, 0.08879473f, 0.10372744f, -0.05013037f, 0.03480056f, 0.12405316f, 0.23615304f, 
    0.17668688f, -0.00567580f, 0.11174337f, 0.02978970f, -0.00690690f, -0.17146114f, 0.04837238f, 0.05383146f, 
    -0.09223857f, -0.09163711f, -0.07710203f, 0.02491451f, 0.04748235f, -0.02319081f, -0.03740028f, 0.05349597f, 
    -0.11742119f, 0.02147373f, -0.16517706f, -0.09176426f, 0.02947510f, -0.00874026f, -0.00574137f, 0.02646566f, 
    -0.07727481f, 0.19322065f, -0.00099424f, 0.04222412f, -0.12378906f, -0.00156458f, -0.19477625f, -0.04424185f, 
    -0.00866493f, -0.04980383f, -0.09222341f, -0.21858263f, 0.07293367f, -0.03897396f, 0.07076868f, 0.10943831f, 
    0.12400213f, 0.05254664f, 0.01444640f, -0.22027132f, 0.16260877f, 0.00679568f, -0.12616403f, 0.09664912f, 
    0.00932042f, -0.06408675f, 0.01474747f, 0.00752056f, -0.45516694f, 0.23554565f, 0.01892621f, -0.32506004f, 
    -0.07826448f, 0.00951264f, -0.00457859f, 0.00060325f, 0.17891875f, -0.09903924f, 0.21486154f, -0.01323134f, 
    -0.26895988f, -0.00401444f, 0.00705132f, 0.07194781f, 0.03222157f, 0.01319623f, -0.06616311f, 0.06524054f, 
    0.04377844f, 0.00135094f, -0.00695139f, -0.05173753f, 0.24201225f, 0.03079312f, -0.01342811f, -0.07065648f, 
    -0.01695984f, -0.13618356f, 0.00411947f, 0.14287771f, 0.09359264f, -0.04011780f, -0.06160009f, 0.08310905f, 
    -0.02478150f, -0.14594780f, -0.10099420f, -0.02354577f, -0.07980021f, -0.23497297f, -0.18758173f, -0.03010644f, 
    -0.01319570f, -0.09144228f, -0.02719842f, 0.07859586f, 0.08874889f, 0.04217316f, -0.10114668f, 0.27709317f, 
    0.06266107f, 0.01305769f, -0.04708188f, 0.07691786f, 0.04554237f, -0.02253968f, -0.02955463f, 0.17256340f, 
    -0.44725159f, -0.31188679f, 0.19208510f, 0.06138777f, 0.10821571f, 0.07181483f, 0.00557229f, -0.10399041f, 
    -0.08709522f, -0.07367359f, -0.02787459f, -0.07083382f, 0.05358526f, -0.09237114f, -0.04252077f, -0.05726420f, 
    -0.03877461f, -0.28515813f, 0.02710187f, 0.00929748f, 0.02763184f, -0.05972987f, 0.08196862f, -0.12272525f, 
    -0.16504285f, -0.02886800f, 0.17729281f, -0.16350995f, 0.01064393f, 0.26566187f, 0.00539327f, -0.12382136f, 
    0.02963070f, 0.06254493f, 0.02120665f, -0.00030732f, -0.10836869f, -0.14921136f, -0.07213897f, 0.12915365f, 
    0.00697041f, -0.00151900f, 0.08139753f, 0.05379688f, 0.02274231f, 0.01434231f, -0.03581141f, -0.14153986f, 
    -0.03027427f, 0.08119379f, -0.26839742f, -0.22445557f, -0.05001938f, -0.16843440f, 0.07325879f, -0.08903696f, 
    -0.05013360f, 0.05909103f, 0.03493231f, -0.13333783f, 0.18166097f, -0.19223413f, 0.09725881f, 0.05326906f, 
    0.15996356f, 0.04442660f, -0.00220863f, 0.11549589f, 0.10159024f, 0.01665107f, -0.16061798f, -0.08874068f, 
    -0.55687284f, -0.07053358f, 0.05478654f, -0.04177763f, -0.02515178f, -0.01470783f, 0.00549628f, 0.08409310f, 
    0.02646905f, -0.00531325f, 0.12090193f, -0.10648928f, -0.17021914f, -0.01312962f, -0.11003420f, 0.31567699f, 
    0.01859800f, 0.14356405f, 0.09146601f, -0.10849912f, 0.03897113f, 0.04709389f, 0.16654532f, 0.00559407f, 
    0.31645837f, -0.16905427f, 0.23161641f, -0.00198724f, 0.11566422f, 0.05980615f, -0.03624307f, 0.26392069f, 
    0.13005005f, 0.14249966f, 0.06680840f, 0.11276754f, -0.28958663f, -0.06710576f, 0.17685565f, 0.02543405f, 
    -0.09765286f, 0.03212742f, -0.11213296f, -0.02056751f, 0.24037360f, -0.17091908f, 0.14004424f, 0.11294049f, 
    -0.03415082f, -0.09222571f, 0.00703085f, -0.26628587f, -0.01000395f, 0.13526164f, 0.04812402f, -0.10637099f, 
    -0.02104093f, -0.00020434f, -0.06418688f, 0.03648020f, 0.17575808f, -0.07201223f, -0.03616834f, 0.14231591f, 
    -0.05642165f, -0.13126217f, 0.07609700f, -0.03750545f, -0.08508467f, 0.00105074f, -0.06155051f, 0.05499531f, 
    0.27665806f, -0.03843717f, 0.04918005f, 0.43529752f, 0.01449359f, 0.07216346f, 0.15975904f, -0.18209913f, 
    0.03119912f, -0.01928047f, -0.08708961f, 0.03839022f, 0.12433820f, 0.11960787f, -0.14785746f, 0.08366083f, 
    0.02945909f, -0.03169511f, 0.06830862f, 0.18076728f, 0.04406581f, -0.10009827f, 0.05438688f, 0.01195845f, 
    -0.19205840f, 0.00257721f, -0.13116606f, 0.14603317f, 0.15145570f, 0.06596828f, 0.14479268f, 0.03500220f, 
    0.14723022f, -0.11249778f, 0.05686057f, 0.02912203f, 0.14959207f, 0.00219429f, -0.13045830f, -0.03409414f, 
    0.09274200f, 0.10805646f, 0.04622839f, -0.02783916f, -0.00394675f, -0.06619253f, -0.00945974f, -0.12703271f, 
    0.06728895f, 0.01919635f, -0.08080025f, 0.16524981f, 0.21467194f, 0.15773562f, 0.04279933f, -0.11699280f, 
    0.08752952f, 0.12345599f, 0.05621862f, 0.14315830f, 0.04968398f, -0.05765738f, -0.02896773f, 0.03939010f, 
    0.00811044f, 0.30002636f, -0.03638193f, -0.05698431f, -0.10916813f, 0.18312219f, 0.01612020f, -0.13725002f, 
    -0.22418499f, 0.09049080f, -0.10891568f, -0.10012936f, 0.02998301f, 0.05714740f, -0.05968237f, 0.06717501f, 
    0.06678441f, -0.07957414f, 0.17458494f, 0.22168601f, 0.05703654f, -0.06069295f, -0.12366172f, 0.11474232f, 
    0.01842275f, -0.00590356f, 0.06805135f, 0.25525200f, -0.08075437f, -0.07669625f, -0.03468760f, 0.01809338f, 
    -0.04596104f, 0.11627512f, -0.15581132f, -0.02640432f, 0.05653030f, -0.01060464f, 0.12250089f, 0.14725807f, 
    -0.07242728f, -0.04467977f, 0.00668669f, -0.04484675f, 0.05665471f, 0.03554153f, -0.05468833f, -0.03455423f, 
    0.16369060f, -0.00347172f, -0.07226493f, -0.00835567f, -0.04629147f, -0.01472075f, -0.02380955f, -0.04017283f, 
    -0.02730147f, -0.02193941f, -0.14002790f, -0.13928767f, -0.02960985f, -0.01082350f, 0.00006837f, 0.01738101f, 
    -0.08287714f, -0.06099790f, -0.03664491f, 0.05309414f, 0.06314918f, -0.21471271f, -0.01595850f, -0.32542983f, 
    -0.06848646f, 0.08307894f, -0.01909132f, 0.11976252f, 0.08900785f, 0.01810833f, 0.10446992f, 0.13419683f, 
    0.12444978f, 0.17033191f, -0.24060118f, 0.38321364f, 0.12150928f, 0.04092248f, 0.18471469f, 0.21751179f, 
    -0.03039592f, 0.18764639f, 0.12235478f, -0.04490982f, 0.20075636f, 0.19618222f, -0.11020015f, -0.09204182f, 
    0.09193214f, 0.05140761f, 0.18028404f, 0.11073013f, -0.02887921f, -0.05334491f, 0.07353417f, 0.07254280f, 
    -0.02570864f, 0.21015140f, -0.02002387f, -0.11393698f, 0.06454892f, 0.05783854f, 0.08899479f, 0.23923820f, 
    -0.03639049f, 0.00493206f, 0.15122484f, -0.07683171f, 0.11723836f, -0.04531799f, -0.18850811f, 0.00259348f, 
    0.04786165f, 0.08125276f, -0.11291052f, -0.08023699f, 0.03047525f, 0.07175893f, -0.00187926f, -0.00636020f, 
    0.15446950f, 0.23345800f, 0.19832815f, 0.16685139f, -0.04978595f, 0.04692634f, 0.09525753f, 0.18665077f, 
    -0.11541983f, 0.04763763f, -0.09008265f, 0.03224897f, 0.20434046f, 0.05123926f, 0.02305027f, -0.06758025f, 
    -0.01133964f, 0.05354353f, 0.03786952f, 0.01281355f, -0.08291813f, 0.08534109f, -0.05477976f, 0.11574273f, 
    0.03933964f, 0.15201308f, 0.15894346f, 0.16308093f, -0.10073889f, -0.06586246f, 0.25059500f, 0.17996727f, 
    0.03963032f, 0.09203544f, 0.16073908f, 0.13198751f, -0.01445700f, 0.00754814f, -0.02111355f, -0.19792186f, 
    0.00139562f, -0.06797136f, 0.00580367f, -0.11279296f, -0.03912021f, -0.08559926f, -0.04324383f, 0.00250222f, 
    0.04441001f, 0.03617897f, -0.10596622f, -0.05006899f, 0.03975707f, 0.07662710f, -0.10560171f, -0.00858280f, 
    -0.03867041f, -0.09319547f, 0.01285323f, 0.02793609f, -0.14097118f, 0.09013457f, 0.19723140f, 0.00819559f, 
    -0.05423105f, 0.08989231f, 0.16923268f, 0.18789396f, 0.05819753f, 0.12075448f, -0.11032201f, 0.05013771f, 
    0.08334511f, 0.16122787f, -0.11924072f, -0.05418894f, 0.13545243f, 0.06705981f, -0.02295926f, 0.00453848f, 
    -0.08456397f, 0.01648082f, 0.09411480f, -0.04940675f, 0.22157882f, -0.07116968f, -0.03483200f, -0.28179154f, 
    0.11587843f, -0.05537696f, 0.07237170f, 0.07788195f, -0.07183608f, 0.08999413f, 0.01087054f, 0.10574231f, 
    0.00088981f, 0.12390958f, 0.05841612f, 0.09333970f, 0.00305624f, 0.00696072f, 0.00297756f, 0.14117996f, 
    -0.11304156f, -0.05119183f, -0.09203707f, -0.15485069f, -0.14339329f, -0.05393415f, -0.09177164f, 0.07327429f, 
    -0.01583826f, -0.06856469f, -0.06849135f, -0.08728385f, 0.05592956f, -0.03929607f, -0.02954534f, -0.00526702f, 
    -0.04453535f, -0.01433962f, -0.26706773f, -0.11462444f, -0.00195671f, -0.06531374f, -0.12662168f, -0.05635926f, 
    -0.12474634f, 0.12365270f, -0.04185634f, 0.06995995f, -0.04370085f, 0.04031562f, 0.10865676f, -0.05014959f, 
    -0.07255328f, -0.02205977f, -0.06792115f, 0.05355233f, -0.04004942f, -0.15781140f, -0.13327771f, -0.30417311f, 
    0.13376568f, -0.21716487f, 0.31345347f, 0.10607804f, -0.15141732f, 0.09169301f, 0.06520300f, 0.10060679f, 
    0.10486481f, 0.16636659f, -0.02151051f, 0.13825451f, 0.04767831f, -0.14054376f, 0.00704338f, -0.08755578f, 
    0.06207044f, -0.02746708f, 0.17753017f, 0.04020541f, -0.16159485f, 0.14393483f, -0.04941567f, -0.02983837f, 
    -0.26864865f, -0.04313676f, 0.02886170f, -0.00937075f, 0.00164876f, 0.05822336f, -0.02613085f, 0.05122879f, 
    -0.00818822f, -0.11735786f, 0.05135781f, -0.07358280f, 0.07567598f, 0.00793604f, -0.08165912f, 0.02836372f, 
    0.04895649f, 0.15669808f, 0.10271446f, 0.06102679f, 0.00906178f, -0.02721246f, 0.10394841f, 0.14808580f, 
    -0.11054878f, -0.07618538f, -0.13208120f, 0.02472201f, -0.10561027f, 0.11272621f, 0.00890328f, 0.06133163f, 
    -0.06139835f, 0.02733958f, 0.06420023f, -0.01157477f, 0.15759966f, 0.09520856f, 0.33925894f, -0.03048225f, 
    -0.02357211f, 0.05801643f, 0.04536508f, 0.02472271f, 0.03123916f, 0.06175905f, 0.02212771f, -0.06638439f, 
    -0.33016792f, -0.19919200f, 0.14607432f, -0.27642915f, 0.04195411f, 0.20360941f, 0.08440392f, -0.03240712f, 
    -0.09376144f, 0.09665775f, -0.00895651f, -0.10095728f, -0.04160171f, 0.07258788f, -0.01854073f, -0.17717659f, 
    0.07398411f, 0.05653191f, 0.08655610f, 0.17068204f, -0.10887363f, 0.17273691f, -0.04030693f, -0.13045117f, 
    0.30272111f, 0.00120536f, -0.01206602f, -0.03247922f, 0.17612918f, 0.10014832f, -0.05457394f, 0.01659641f, 
    -0.06231430f, -0.02884859f, 0.01513683f, 0.01597146f, -0.10792606f, -0.10074469f, 0.20562932f, -0.00315957f, 
    -0.22413386f, 0.01998667f, -0.17197907f, 0.04589888f, 0.04635777f, 0.03259051f, 0.06677227f, 0.17953208f, 
    0.08518936f, 0.42259485f, -0.05515347f, 0.08214508f, 0.16650683f, 0.18583645f, 0.12734748f, -0.03979298f, 
    0.14387088f, -0.04404004f, 0.05434459f, -0.00121381f, -0.22790256f, -0.22229533f, 0.35607412f, -0.02929187f, 
    -0.04333105f, -0.09982175f, -0.06992082f, 0.00889157f, 0.10137893f, -0.19247104f, 0.13021235f, -0.00629837f, 
    -0.12294324f, 0.03181213f, 0.00576424f, 0.07109109f, -0.13073966f, -0.12264483f, -0.04535997f, -0.05216587f, 
    0.28235325f, 0.13624127f, 0.16723508f, 0.27266610f, 0.18933569f, -0.13576686f, 0.01633503f, 0.14599408f, 
    -0.09270201f, -0.06258976f, 0.08234468f, 0.17288978f, 0.12723185f, 0.12240282f, -0.08544566f, -0.16452083f, 
    -0.02784061f, 0.20353195f, 0.03270010f, -0.09719884f, 0.09371709f, 0.04779715f, 0.11617494f, 0.19270527f, 
    0.19360423f, -0.08243780f, 0.25196654f, -0.04600344f, -0.00315216f, 0.38921711f, -0.13190672f, 0.08730887f, 
    -0.07335909f, 0.07619544f, -0.08110191f, -0.05592471f, 0.16321991f, 0.02956450f, 0.07721370f, 0.07753542f, 
    -0.17944053f, 0.05757995f, -0.21528745f, 0.13587220f, 0.11910685f, 0.01415369f, -0.00190982f, 0.08780885f, 
    -0.14170207f, 0.18086745f, 0.08735485f, -0.21575060f, 0.13381030f, -0.20476042f, -0.20277554f, -0.14427958f, 
    -0.07430360f, 0.04789522f, -0.17880316f, -0.16539322f, 0.11315654f, -0.04499405f, 0.10518765f, 0.11424953f, 
    0.24053927f, -0.26160076f, -0.05140162f, 0.07291848f, 0.04280123f, 0.08210028f, 0.01227946f, 0.03438518f, 
    0.01256297f, -0.02509956f, -0.03921181f, 0.07892311f, 0.25285864f, 0.03105502f, -0.12414603f, 0.13504808f, 
    -0.05117844f, 0.06192981f, 0.04042393f, 0.07031479f, 0.01935850f, 0.08672062f, -0.01041526f, 0.07870891f, 
    -0.14503987f, -0.12475924f, -0.14583677f, -0.17594685f, -0.00534832f, 0.07033872f, -0.10419619f, -0.01211958f, 
    0.02286957f, 0.09802043f, 0.03834084f, -0.08297136f, -0.10571840f, 0.29881641f, 0.07279819f, 0.17172635f, 
    -0.07105052f, -0.02071386f, -0.08972573f, -0.02744864f, -0.00101405f, -0.05524869f, -0.01885970f, 0.12778489f, 
    0.04677593f, 0.12016904f, 0.01500298f, 0.00868983f, -0.18043336f, -0.06171768f, -0.11092456f, -0.06313562f, 
    -0.20211142f, 0.02803325f, 0.09169465f, -0.02817930f, -0.16679128f, 0.03825073f, 0.24184383f, -0.09290886f, 
    -0.03823197f, 0.05565984f, 0.01000695f, -0.05667701f, 0.15217651f, 0.05933774f, 0.02388832f, 0.06037837f, 
    -0.00155036f, -0.24129468f, 0.00380039f, -0.26919204f, -0.06346073f, 0.03077602f, -0.01870471f, 0.08860078f, 
    -0.10210115f, -0.02983927f, -0.10968986f, -0.01079373f, -0.00647142f, -0.07132139f, 0.11718884f, 0.08710225f, 
    -0.11947437f, -0.18512729f, -0.08467823f, -0.15372895f, -0.09639015f, 0.03474183f, 0.03429545f, 0.00018445f, 
    0.09219151f, -0.02571472f, -0.37346005f, 0.14012846f, 0.01220705f, 0.00151552f, -0.17760448f, 0.07929631f, 
    0.01153252f, 0.01211766f, 0.07785130f, 0.11712838f, -0.20073916f, -0.15709014f, -0.02880712f, -0.05780341f, 
    0.09684441f, 0.19785906f, -0.06907183f, 0.08328012f, -0.13997141f, -0.13946047f, 0.03547180f, -0.10526756f, 
    -0.03663620f, -0.02065210f, -0.05837065f, -0.05065373f, -0.08813852f, -0.14118527f, -0.01707099f, -0.24278232f, 
    -0.14364743f, -0.00090334f, -0.00587547f, 0.05406680f, 0.01574104f, 0.02421419f, -0.00054580f, -0.27705169f, 
    0.01411176f, 0.01255986f, 0.24021968f, -0.00352048f, 0.05537472f, -0.06869329f, -0.03599260f, 0.01666815f, 
    -0.33065635f, -0.04135868f, -0.11096688f, -0.22145499f, 0.03470869f, -0.00840359f, -0.05008642f, -0.02575538f, 
    -0.04104955f, 0.10466221f, 0.04808898f, -0.07784780f, 0.02848504f, -0.10456494f, 0.04413529f, -0.06570042f, 
    0.06549703f, 0.08788565f, 0.00497273f, 0.13339290f, 0.09215543f, 0.06042871f, 0.12904790f, 0.13680485f, 
    0.09921200f, 0.23260711f, 0.11261173f, 0.11777965f, 0.10414153f, 0.14607430f, 0.08056201f, 0.10933830f, 
    0.35730502f, 0.00952352f, 0.18501006f, 0.08203884f, 0.02724920f, 0.17902760f, -0.11727192f, 0.44191507f, 
    -0.10342099f, -0.11834320f, 0.00440425f, -0.04554025f, 0.13910836f, 0.04173556f, 0.14590570f, 0.19026509f, 
    -0.06924626f, -0.00910195f, -0.21183145f, -0.07339256f, -0.04323516f, 0.07921993f, -0.04608584f, -0.04959206f, 
    0.01923407f, 0.06575567f, 0.06644949f, 0.02288140f, 0.00390358f, 0.06463239f, 0.09169863f, -0.25736767f, 
    -0.03576685f, 0.02231062f, 0.05180903f, 0.03574795f, -0.04784317f, 0.09109018f, 0.08830715f, 0.08450418f, 
    0.25802639f, 0.32845256f, 0.01076627f, 0.05980799f, 0.28345075f, 0.05858434f, 0.04638992f, -0.06301207f, 
    0.27038971f, -0.09712169f, 0.09249403f, 0.18083206f, 0.18433012f, -0.12398572f, -0.07325844f, -0.20118365f, 
    0.03432260f, -0.02331175f, 0.02068904f, 0.20317832f, 0.16392504f, 0.04373775f, -0.00312078f, 0.03321956f, 
    0.09504449f, -0.38817418f, 0.21048881f, -0.06873655f, 0.07051985f, 0.09758545f, 0.11562558f, 0.19869204f, 
    -0.07945921f, 0.05752892f, 0.01386169f, 0.09881102f, 0.23122583f, -0.07231701f, 0.06569088f, -0.13507202f, 
    -0.04256394f, 0.15570319f, 0.04981910f, 0.10048243f, 0.07212307f, 0.08546966f, -0.05892505f, 0.03269101f, 
    0.02065434f, 0.26613131f, -0.13814543f, 0.31821790f, 0.09161032f, 0.16185930f, -0.00328183f, 0.18108897f, 
    0.07099632f, 0.13481590f, 0.06047723f, 0.11363301f, -0.07700160f, -0.05988360f, 0.12458085f, 0.09137726f, 
    0.08155049f, 0.27541733f, -0.16111912f, 0.04149595f, 0.21097755f, 0.11289947f, 0.15916984f, 0.14993036f, 
    -0.11317451f, 0.10510086f, -0.06208462f, 0.17591126f, -0.15318754f, -0.05082338f, -0.05874262f, -0.07935750f, 
    0.04303838f, 0.18728665f, 0.10182989f, 0.21791656f, -0.22518528f, 0.04626906f, 0.08311848f, -0.14611545f, 
    0.02173758f, 0.08845529f, 0.09141476f, 0.21984293f, 0.07556728f, -0.05007965f, -0.06097176f, -0.11081745f, 
    -0.19011229f, -0.02443667f, -0.05823064f, 0.00612289f, 0.06288186f, 0.03196918f, 0.12392927f, 0.15671982f, 
    0.05034634f, 0.07940744f, 0.14455079f, -0.08118983f, -0.09448318f, -0.27011025f, 0.12072864f, 0.14143150f, 
    0.01696006f, 0.11618497f, 0.16586435f, -0.09612301f, -0.09828284f, 0.04032222f, 0.07942012f, -0.00940917f, 
    -0.14546320f, -0.16555791f, -0.23656537f, 0.01462184f, -0.05195259f, -0.24835277f, -0.16356042f, -0.05755839f, 
    -0.09506661f, -0.14897226f, -0.17249559f, 0.01473031f, 0.11501975f, -0.23021936f, -0.05981975f, -0.11395873f, 
    0.25820884f, -0.17568089f, -0.09482994f, 0.01506845f, 0.10390389f, 0.05755104f, -0.10205895f, 0.00593395f, 
    0.18318699f, -0.09862971f, 0.08432163f, -0.13083492f, 0.02002669f, -0.11685532f, 0.10374883f, -0.00282968f, 
    0.00929156f, 0.13624376f, 0.08404242f, 0.03741616f, 0.06843439f, -0.06719267f, -0.02473980f, -0.06677270f, 
    0.06465922f, 0.05884346f, -0.02862742f, -0.08384870f, 0.05257286f, -0.07463835f, -0.09076079f, -0.05646934f, 
    0.23671196f, -0.12216585f, 0.14664547f, 0.06394154f, 0.14437719f, 0.06109460f, -0.13678013f, -0.10640417f, 
    0.03750480f, 0.13414064f, 0.15713783f, -0.01223175f, 0.04087928f, -0.14095831f, -0.20519005f, -0.00744830f, 
    0.02670981f, 0.13738167f, 0.15152799f, 0.04611635f, -0.12719637f, 0.02977396f, -0.13397814f, 0.05933472f, 
    0.02362904f, 0.14835526f, 0.56024575f, 0.09682587f, -0.00053303f, -0.28138632f, -0.06648223f, -0.01524811f, 
    -0.07248573f, 0.07622465f, -0.01861883f, 0.08820846f, 0.07521669f, 0.04305325f, 0.00214593f, 0.09575421f, 
    0.11827937f, 0.02479395f, 0.01809858f, 0.03788440f, -0.11558965f, 0.02130463f, -0.02032458f, 0.01817989f, 
    0.03316777f, -0.22108498f, 0.03357268f, -0.06929311f, 0.03517487f, 0.09780443f, 0.05921383f, 0.09335225f, 
    -0.09210733f, -0.16885705f, 0.25510272f, 0.23211701f, -0.04534508f, -0.27079561f, -0.26793206f, -0.08612840f, 
    0.05697910f, 0.01400677f, 0.12059039f, 0.11658436f, 0.09455314f, -0.17774163f, 0.15453359f, -0.04899954f, 
    -0.08172404f, -0.11107410f, -0.07604586f, -0.18290001f, 0.02690683f, -0.00003300f, 0.07134143f, -0.00842450f, 
    -0.15898989f, -0.09568330f, 0.01069699f, -0.11810503f, -0.03854793f, -0.41799831f, 0.39239368f, -0.05698325f, 
    -0.01454455f, 0.18225959f, -0.15944710f, 0.00621202f, 0.09162641f, 0.22976130f, -0.22766757f, -0.00556796f, 
    0.11864430f, -0.10595918f, -0.05588964f, 0.11264341f, 0.07214340f, 0.02073062f, -0.01904858f, 0.03209779f, 
    -0.02928010f, 0.03959044f, 0.01130752f, 0.08903911f, 0.08022636f, -0.13393603f, -0.16415004f, -0.09859463f, 
    0.03476325f, 0.00164776f, -0.08011579f, 0.13837026f, 0.15247740f, -0.01168550f, -0.13045621f, 0.10939758f, 
    -0.03783160f, 0.19515213f, 0.10962872f, -0.11126240f, -0.04967201f, -0.02803616f, -0.10821706f, -0.02969063f, 
    -0.06308129f, 0.05379285f, 0.11461747f, 0.04267569f, 0.08184876f, 0.23584658f, 0.14338703f, -0.10208822f, 
    -0.06633870f, -0.08434836f, -0.10891178f, -0.02170955f, -0.07296965f, 0.16224384f, 0.08278306f, 0.06441052f, 
    -0.13110924f, 0.21845905f, -0.03348102f, 0.13885835f, 0.05857587f, 0.01295328f, 0.16112040f, -0.08979324f, 
    -0.13753971f, 0.18484798f, -0.06679450f, 0.02657202f, -0.00326615f, 0.08541883f, -0.08155344f, -0.01293886f, 
    -0.07931475f, -0.10078342f, -0.05777402f, -0.04895166f, -0.01253586f, 0.02467698f, 0.24121661f, 0.01618086f, 
    -0.04353719f, 0.15883654f, 0.41494057f, 0.18457946f, -0.06301676f, 0.10236665f, -0.25785983f, 0.00815564f, 
    -0.04194313f, 0.09670114f, 0.10860506f, 0.03542476f, -0.11022377f, -0.07506948f, 0.16603380f, -0.21511959f, 
    0.08400047f, 0.00303590f, -0.20288795f, 0.04511769f, -0.18419686f, -0.15953428f, 0.10926011f, -0.07666558f, 
    -0.13414823f, -0.13447058f, 0.16605145f, 0.03690655f, -0.10496754f, -0.08305535f, 0.06699192f, 0.00497814f, 
    -0.05631782f, -0.10777749f, 0.27169520f, 0.10466380f, -0.22627173f, 0.04896875f, -0.25950819f, -0.06897602f, 
    0.04782229f, 0.13770951f, 0.08282229f, 0.14956744f, 0.05214487f, 0.21009250f, -0.11846127f, 0.14079140f, 
    -0.05671829f, 0.13846616f, -0.19334975f, 0.10103565f, 0.15376011f, 0.00592401f, -0.16416609f, -0.27280334f, 
    -0.11617908f, -0.00698164f, -0.06381633f, -0.12820666f, 0.38938946f, 0.18934326f, -0.01139540f, -0.01901364f, 
    0.02409849f, -0.07937092f, -0.00340702f, -0.03643423f, 0.02375739f, -0.07804861f, 0.00098162f, 0.13686420f, 
    0.31446964f, -0.01813458f, 0.11952725f, 0.16934206f, 0.03932014f, 0.16992511f, -0.06006208f, -0.03676563f, 
    -0.07304323f, -0.05561902f, 0.07385070f, 0.00702945f, 0.24991913f, -0.08182688f, 0.05168527f, 0.12516306f, 
    0.05825692f, 0.03712087f, -0.12204441f, 0.06666167f, -0.04359125f, 0.09408743f, 0.05095972f, 0.00360373f, 
    0.05015220f, 0.05298284f, -0.14275046f, 0.04937200f, -0.02411347f, 0.03390842f, 0.02449252f, -0.10301679f, 
    -0.07635748f, -0.07273956f, -0.12197913f, -0.13332334f, 0.03822897f, -0.02973159f, 0.00138622f, 0.18086436f, 
    0.01800166f, 0.11130052f, -0.10780049f, 0.00656482f, 0.01213417f, -0.02782156f, -0.01022621f, 0.02305427f, 
    0.14012223f, 0.52569389f, 0.03549358f, -0.18556757f, 0.03958340f, 0.19306034f, -0.15002406f, 0.17618322f, 
    0.04214870f, 0.01096185f, 0.17793863f, -0.09773861f, -0.16872974f, -0.12692346f, -0.18890208f, -0.36153367f, 
    -0.05116883f, -0.06140231f, 0.02260174f, 0.05086234f, -0.05046572f, 0.05976059f, 0.01165168f, 0.14103988f, 
    0.04758389f, 0.08273251f, 0.00563655f, -0.03060278f, -0.05742361f, -0.07819948f, 0.00311919f, -0.03597892f, 
    0.02950883f, 0.12560581f, 0.05533869f, 0.07193336f, 0.04669687f, -0.00282050f, 0.24477640f, 0.20589137f, 
    -0.05853304f, 0.05903648f, -0.01405518f, -0.05165863f, 0.00861898f, 0.14392693f, 0.07708199f, 0.05593497f, 
    0.10794563f, -0.06058745f, -0.20296098f, -0.01737588f, 0.19984424f, -0.11169476f, 0.04855404f, 0.16177134f, 
    0.13061918f, 0.10778757f, 0.10481471f, -0.00482460f, 0.17488110f, 0.46618783f, -0.19520383f, -0.24988654f, 
    0.02911489f, -0.01419968f, -0.00894219f, 0.06844590f, 0.10803045f, 0.11155660f, 0.07489183f, 0.10750765f, 
    -0.01368733f, 0.09338610f, -0.08196836f, 0.01030025f, -0.18342420f, -0.02213172f, 0.05300469f, -0.18654487f, 
    0.10673662f, -0.03484553f, 0.15982446f, 0.04234514f, -0.03527671f, -0.13828638f, 0.06953987f, -0.18817997f, 
    0.05856318f, -0.01355210f, 0.24492481f, -0.03952860f, -0.01395770f, 0.00636068f, -0.11904255f, -0.02528521f, 
    -0.07156132f, -0.03011828f, 0.20401779f, 0.06480476f, -0.05430964f, 0.11427604f, -0.09917798f, 0.07240615f, 
    0.01728582f, 0.04501282f, 0.04114863f, -0.04678804f, 0.46588874f, 0.22202198f, 0.00669513f, 0.18542776f, 
    -0.01275555f, -0.07271367f, 0.06059594f, -0.03255464f, -0.02308640f, 0.19266897f, 0.08065357f, 0.14673544f, 
    -0.02257916f, 0.00313792f, -0.11538591f, -0.04202978f, -0.10943079f, 0.08508778f, 0.07318696f, -0.05610444f, 
    -0.02343906f, 0.13080588f, 0.15639167f, 0.03188607f, -0.09398364f, 0.32017967f, 0.07090694f, -0.08687288f, 
    -0.03340022f, -0.02284929f, -0.10687358f, -0.07976520f, -0.11016788f, 0.10548940f, 0.14644459f, 0.12805852f, 
    0.13769162f, 0.13473152f, 0.10590035f, 0.07300001f, -0.07491735f, 0.02241289f, -0.10364635f, -0.08758644f, 
    -0.08785244f, 0.04599100f, -0.13045029f, 0.00008137f, 0.40590456f, 0.20830707f, 0.07374878f, 0.20774490f, 
    0.15251681f, 0.03131179f, -0.11665284f, -0.22461371f, -0.06004527f, 0.14265271f, 0.12972946f, 0.03646680f, 
    0.00879238f, 0.06686208f, 0.21716517f, -0.08401613f, -0.02825582f, -0.08863901f, -0.11236783f, -0.06319510f, 
    -0.12341565f, -0.04662152f, 0.01909546f, 0.05418566f, 0.03707947f, 0.07804169f, -0.03527460f, 0.01924033f, 
    0.05025277f, 0.05787658f, -0.05467730f, 0.01001630f, -0.08154944f, -0.00616077f, 0.01305245f, -0.04208428f, 
    -0.18422149f, -0.00482034f, -0.17599742f, 0.37246010f, -0.04375638f, -0.12776095f, 0.12264124f, -0.26684886f, 
    -0.05762468f, -0.07155322f, -0.08558256f, 0.04574345f, -0.15633918f, -0.02456387f, -0.09264260f, -0.00293186f, 
    0.12883344f, -0.11514039f, 0.01457278f, 0.01721872f, -0.12633944f, -0.11838460f, -0.06707646f, 0.02133860f, 
    0.12633738f, 0.03501047f, -0.16048239f, -0.03838104f, -0.02010292f, 0.03470654f, 0.01157276f, -0.04772778f, 
    0.04418127f, -0.03951983f, 0.16262686f, 0.06422607f, 0.18069880f, -0.19120990f, -0.12314607f, -0.05745611f, 
    0.09179061f, -0.02543252f, -0.05074720f, 0.21875954f, 0.06315017f, -0.00110788f, 0.16867407f, -0.02353355f, 
    0.27876762f, -0.16040584f, -0.04991079f, -0.04700161f, -0.03363112f, -0.07963165f, -0.09041143f, -0.01117840f, 
    -0.03843047f, 0.03513232f, 0.10632209f, 0.01990707f, 0.06047616f, -0.05590282f, -0.09260668f, 0.15868673f, 
    0.14233403f, 0.12917022f, -0.03841251f, 0.08430125f, -0.05596538f, 0.19147119f, -0.16511476f, 0.04628950f, 
    0.09047773f, 0.08202421f, -0.23294477f, 0.09886407f, 0.20486131f, -0.04581999f, 0.09089228f, -0.11055841f, 
    0.12211410f, 0.04562872f, -0.08988814f, 0.03773608f, 0.09052028f, 0.29063603f, 0.13630149f, -0.16488884f, 
    0.00584857f, -0.03583485f, 0.00794132f, -0.01545741f, 0.07346206f, 0.22451727f, 0.05993609f, 0.25020871f, 
    -0.19617288f, -0.18487547f, -0.19951382f, -0.01117366f, 0.17543216f, 0.06268075f, 0.06111128f, 0.24890697f, 
    -0.03292267f, 0.02809528f, -0.03533968f, -0.04880736f, 0.42647764f, 0.15783608f, -0.18628506f, -0.13489795f, 
    0.14265946f, -0.06495930f, -0.10303049f, -0.01495951f, -0.07701167f, 0.03941048f, 0.02157792f, 0.04758203f, 
    -0.06685985f, -0.15910324f, -0.34582657f, 0.05406892f, 0.14160068f, -0.00315186f, 0.07111183f, 0.03250174f, 
    0.07379994f, 0.00622667f, 0.20677771f, 0.10664171f, 0.19845845f, 0.02050319f, -0.03949606f, 0.12685265f, 
    -0.03732682f, 0.07549256f, 0.05250629f, 0.02527477f, 0.06407695f, 0.18710229f, 0.07395575f, 0.03585076f, 
    0.12371048f, -0.20751731f, 0.17189127f, -0.17272420f, -0.05669507f, -0.05047953f, -0.05562465f, -0.11660436f, 
    -0.07091880f, 0.06608835f, -0.13837829f, 0.01711682f, 0.06520437f, 0.01415488f, 0.10332847f, 0.09599178f, 
    -0.14455152f, 0.19758283f, 0.07553893f, 0.06090910f, -0.03285301f, 0.04735414f, 0.11319341f, 0.02051827f, 
    -0.20202874f, 0.12409969f, 0.15344791f, -0.11793677f, 0.03936290f, -0.02372432f, 0.07293203f, -0.08961213f, 
    0.12213920f, 0.00498745f, 0.10868412f, -0.00420717f, -0.03751983f, 0.30979812f, -0.21820517f, 0.12701705f, 
    -0.02004502f, -0.08116743f, -0.00941305f, -0.19683446f, 0.13340856f, 0.03244984f, -0.15377788f, 0.05218630f, 
    -0.06917831f, -0.05938544f, 0.04843652f, -0.07790080f, 0.01107288f, -0.02882480f, -0.07683855f, -0.04760609f, 
    0.03149964f, 0.09707173f, 0.16786270f, -0.09400140f, 0.34169832f, -0.08798283f, 0.05071260f, -0.08137735f, 
    0.03958274f, 0.08263501f, -0.02228910f, -0.15657054f, 0.07880140f, -0.02018432f, -0.03547110f, 0.04859327f, 
    -0.03467239f, -0.01496094f, -0.02244650f, -0.02455114f, -0.00306831f, -0.04172936f, -0.01085365f, -0.01796156f, 
    -0.03860362f, 0.01549464f, -0.00584172f, 0.01896251f, 0.01010201f, -0.01521982f, -0.00345176f, 0.02256111f, 
    0.01622140f, -0.03810030f, -0.00586029f, -0.03726627f, -0.00713966f, -0.02671017f, 0.00342950f, -0.02898195f, 
    0.03195461f, 0.00024794f, 0.03978530f, 0.00957122f, 0.00160515f, 0.02210705f, 0.00498396f, -0.03708444f, 
    0.00925764f, -0.01938559f, -0.02537716f, -0.01674432f, 0.03330045f, -0.03926901f, 0.00088530f, 0.00364617f, 
    0.02219399f, -0.00830885f, -0.00288087f, -0.00311511f, -0.00121646f, 0.00346592f, 0.00109713f, -0.03242454f, 
    0.00765313f, -0.02227840f, -0.02411809f, -0.03707619f, 0.02889203f, -0.00036634f, 0.03321806f, -0.00746797f, 
    0.02215012f, -0.03426630f, 0.02703596f, -0.03583359f, 0.03851509f, -0.01112434f, -0.01347516f, 0.03077613f, 
    -0.01852209f, -0.02393701f, -0.02428643f, -0.01142230f, -0.00038937f, -0.03381748f, -0.03163829f, 0.01723158f, 
    -0.01231279f, -0.01471337f, 0.01337375f, 0.02854517f, -0.03193802f, 0.02025682f, -0.00988572f, 0.00052940f, 
    0.00476111f, -0.03389871f, 0.00005960f, 0.01598559f, 0.00992534f, 0.02887785f, 0.01562774f, 0.02428349f, 
    0.00204001f, 0.00414782f, -0.03946507f, -0.01305981f, 0.00509999f, 0.00019063f, -0.02709478f, -0.01278044f, 
    -0.04402652f, -0.00502185f, -0.02382495f, -0.03750858f, -0.00474634f, 0.02194273f, -0.00956826f, -0.00997774f, 
    0.02233845f, -0.02683488f, -0.00085762f, -0.02217371f, 0.00387187f, -0.01973110f, -0.00749317f, 0.00893276f, 
    0.00478028f, -0.00676317f, 0.01374449f, -0.01718902f, -0.03544742f, -0.03444324f, 0.00998154f, 0.02408494f, 
    0.00375687f, -0.00150696f, 0.02922733f, -0.03028970f, 0.02350914f, 0.01661412f, -0.03469507f, -0.03583776f, 
    -0.04180049f, -0.02109760f, -0.03896271f, 0.01735275f, 0.02553320f, -0.00060835f, -0.03196542f, -0.00833801f, 
    -0.03134760f, -0.00002460f, 0.01825784f, 0.00520673f, -0.01827195f, -0.04484948f, -0.01665341f, -0.03374234f, 
    -0.00365911f, -0.01789487f, -0.00958584f, 0.00487412f, -0.01466316f, -0.03326910f, 0.02680065f, -0.02383144f, 
    0.00522995f, 0.01953044f, -0.00318720f, 0.01612017f, -0.04011392f, 0.01212929f, -0.00114212f, -0.00755443f, 
    0.00333844f, 0.01164117f, -0.02679693f, 0.02773915f, 0.01838373f, -0.03975537f, 0.00868777f, -0.04247250f, 
    0.00646373f, -0.01619332f, 0.01654300f, 0.01972128f, -0.04001671f, -0.00919791f, 0.00376140f, -0.02826847f, 
    -0.02315916f, -0.01472741f, -0.00252725f, 0.02241444f, -0.02953507f, 0.00707994f, -0.02090862f, -0.03299347f, 
    -0.00942231f, 0.02283376f, 0.01281134f, 0.00794390f, 0.01219687f, -0.01867134f, -0.02726544f, -0.03884496f, 
    0.02817959f, 0.02516259f, 0.00640403f, 0.02153114f, 0.00792857f, 0.00181021f, -0.02768420f, 0.01651550f, 
    -0.02491336f, 0.02405553f, -0.03745561f, 0.02545119f, 0.00862798f, 0.02341838f, 0.02338196f, 0.02532629f, 
    -0.01982952f, -0.03576127f, -0.01503578f, -0.00650952f, -0.00698603f, 0.01981537f, 0.00533876f, 0.01232778f, 
    -0.00466529f, -0.02773598f, 0.02047882f, 0.02135860f, -0.03177535f, 0.01379283f, -0.01774387f, -0.00077397f, 
    -0.02827647f, 0.00715340f, 0.01226815f, -0.01211589f, 0.01565107f, -0.01122910f, 0.02175037f, -0.01503190f, 
    0.01375808f, 0.02566037f, 0.02179191f, -0.01361575f, 0.01166569f, -0.00371031f, -0.01022077f, -0.00899883f, 
    -0.01106601f, -0.00377673f, -0.04182812f, 0.00236697f, 0.02779535f, -0.01672882f, 0.01891541f, -0.00496109f, 
    0.00321597f, 0.02603272f, -0.00711122f, 0.00070205f, -0.01367351f, -0.02959631f, -0.01130425f, 0.01785782f, 
    -0.01057079f, -0.02307155f, 0.01676503f, -0.02592324f, 0.00118537f, 0.01295565f, -0.01546335f, 0.00970797f, 
    0.02606328f, -0.00353020f, -0.00283674f, -0.02300818f, -0.00473657f, -0.00856927f, -0.03570450f, 0.01049194f, 
    -0.04321136f, -0.03723165f, -0.02981482f, -0.01522594f, 0.03295208f, -0.02871835f, 0.01433566f, -0.03212722f, 
    -0.03481943f, -0.00041263f, 0.01706286f, -0.04101089f, -0.03776359f, -0.03728274f, 0.01978162f, 0.02268583f, 
    -0.00155491f, 0.00150441f, -0.01826374f, -0.02334718f, 0.03268081f, -0.00020008f, 0.03577194f, -0.00657186f, 
    -0.00683948f, -0.04656642f, -0.04371961f, 0.00371572f, -0.02537113f, -0.03092831f, -0.02772460f, 0.02412288f, 
    -0.00832308f, -0.02725428f, -0.00883141f, -0.00631206f, -0.03019529f, 0.00915624f, -0.01169287f, -0.00359561f, 
    0.00025999f, 0.01431555f, 0.01584520f, -0.01551138f, 0.02332482f, -0.02262939f, 0.00448328f, -0.03443418f, 
    -0.00716083f, -0.01874279f, 0.02200595f, 0.02739721f, 0.01413996f, -0.00236393f, 0.01651245f, 0.02386653f, 
    0.02191491f, 0.00885270f, -0.03643712f, -0.02980508f, -0.04230406f, -0.01142389f, 0.01224074f, -0.00113338f, 
    -0.00708062f, -0.02941730f, -0.01560827f, -0.01574993f, 0.02393788f, -0.01901739f, 0.01206980f, 0.01508955f, 
    -0.00039663f, 0.00487836f, 0.02029705f, -0.00594548f, 0.01376017f, -0.03010187f, 0.02925149f, -0.02877863f, 
    -0.01837781f, -0.00131544f, 0.01276320f, -0.02422700f, -0.02362712f, -0.03452148f, 0.00304586f, -0.02977396f, 
    -0.01842332f, 0.01957562f, -0.02596254f, -0.01715718f, -0.02257108f, -0.01970067f, -0.01995472f, -0.03568980f, 
    -0.02678815f, 0.02234140f, -0.04769357f, -0.02926099f, 0.03547161f, 0.02494257f, -0.01766376f, -0.00768062f, 
    0.00736580f, 0.01066912f, -0.02671103f, 0.01454496f, -0.01196207f, 0.02710683f, -0.03898946f, 0.01333873f, 
    0.00924368f, -0.01344021f, -0.01909384f, -0.02546289f, -0.00787105f, 0.02296974f, -0.02278274f, 0.03116039f, 
    -0.02222587f, -0.00789364f, -0.01984631f, -0.03081965f, -0.03987518f, -0.03340429f, 0.00141511f, 0.00166644f, 
    0.01691342f, 0.01558825f, -0.00055003f, -0.01660597f, -0.02375840f, -0.03534836f, -0.04071671f, -0.01137509f, 
    -0.01601329f, -0.02108254f, 0.01569083f, -0.03725841f, -0.00065077f, -0.00802798f, 0.01344867f, 0.02521496f, 
    -0.02989314f, -0.02516578f, 0.01538831f, -0.00505759f, 0.01602882f, 0.00606299f, -0.02019679f, -0.00354520f, 
    -0.02359906f, -0.03028918f, -0.00456703f, 0.01320088f, 0.02601873f, -0.01732799f, -0.00933697f, -0.03736209f, 
    0.03482703f, 0.00851105f, -0.00315599f, 0.03115917f, -0.00967303f, -0.02685937f, 0.00969869f, 0.03747955f, 
    0.01117864f, 0.02390115f, -0.02234791f, 0.02871699f, -0.03082380f, 0.00609311f, 0.01053745f, 0.01533354f, 
    0.01175459f, 0.00890142f, 0.02135677f, 0.00755029f, -0.04380323f, -0.02672508f, -0.02783159f, 0.00803169f, 
    0.01135261f, -0.01126793f, 0.01086055f, -0.02127314f, -0.01563722f, -0.00484401f, 0.00355873f, -0.00982265f, 
    -0.00086116f, -0.01573794f, 0.02293034f, 0.00765296f, -0.03735514f, -0.00420201f, 0.00978671f, 0.01742164f, 
    -0.01307872f, 0.01881537f, -0.00035799f, -0.01902286f, 0.02290929f, -0.04652413f, -0.00938269f, -0.02905017f, 
    0.02562451f, -0.00143796f, -0.01740710f, -0.01931461f, -0.00560913f, 0.01205264f, -0.02493434f, 0.00741080f, 
    -0.02572214f, -0.00335390f, 0.02066393f, -0.01046733f, -0.02494141f, 0.02910499f, 0.01707838f, -0.00957381f, 
    -0.01091653f, 0.01517868f, 0.00397518f, -0.01290775f, -0.01608345f, -0.01388842f, -0.03295575f, -0.01227292f, 
    -0.01415020f, -0.01844796f, 0.02973285f, -0.03551262f, -0.03723733f, 0.01779002f, 0.03209420f, 0.02799655f, 
    -0.00870316f, 0.00256398f, -0.01752422f, -0.02275835f, -0.01827718f, -0.00795890f, -0.03802268f, -0.04074467f, 
    -0.03083308f, -0.03582222f, -0.01291746f, -0.02570366f, 0.01858844f, -0.03158857f, 0.02979045f, -0.00879726f, 
    -0.00863859f, 0.02532878f, -0.02296713f, -0.03544252f, -0.00789565f, 0.00117351f, -0.00968417f, 0.00768540f, 
    -0.00634689f, 0.00571369f, -0.01518620f, 0.00532949f, 0.01967426f, -0.00225825f, -0.02252264f, -0.01038273f, 
    -0.03106765f, -0.00298345f, 0.03734475f, 0.03408879f, -0.00329362f, -0.02413028f, -0.02220635f, 0.00038062f, 
    -0.03990760f, -0.01276296f, -0.01376700f, 0.03821587f, -0.01130304f, -0.03529086f, -0.00633642f, 0.02011844f, 
    -0.02736922f, 0.00139072f, -0.00009320f, 0.02058737f, -0.00832522f, -0.01572352f, 0.02430234f, 0.03269091f, 
    -0.03164223f, 0.00918646f, 0.01352512f, 0.01838817f, -0.03502830f, 0.02010304f, -0.00528040f, -0.03809348f, 
    -0.00377791f, 0.00050021f, -0.03988427f, -0.02767191f, -0.03331475f, 0.02352735f, 0.03571507f, 0.03287275f, 
    -0.02853009f, 0.00963738f, -0.00893030f, -0.00240404f, -0.02954188f, 0.01536891f, -0.02377670f, 0.01689590f, 
    0.00036429f, -0.00197502f, -0.01787125f, -0.00911239f, -0.02266393f, -0.02380197f, -0.00639859f, 0.00362384f, 
    0.02010784f, 0.00279796f, -0.00414048f, 0.00599345f, -0.02972317f, -0.01396319f, -0.02503078f, -0.00898813f, 
    0.02034089f, -0.03051579f, -0.03608225f, -0.01026337f, -0.00283567f, -0.01538698f, -0.01815449f, -0.00776902f, 
    0.01360001f, -0.00896232f, -0.02942604f, -0.01134886f, 0.01558097f, -0.02486138f, -0.01693296f, 0.01727405f, 
    -0.03991801f, -0.00917069f, 0.00704012f, 0.00396195f, -0.03952636f, 0.00776004f, 0.02526974f, -0.03023562f, 
    -0.03645540f, -0.00015048f, 0.02584100f, 0.01160067f, 0.01893939f, 0.00453051f, -0.01087075f, -0.02808223f, 
    0.03122176f, 0.00246829f, 0.02494466f, -0.02748531f, -0.01625429f, 0.02654341f, -0.02833370f, 0.02966079f, 
    0.02498003f, -0.03914234f, 0.01318573f, 0.03134961f, -0.00289456f, -0.04182266f, -0.03666595f, 0.02146891f, 
    -0.01757137f, -0.04079963f, 0.00998694f, 0.00004979f, 0.01843806f, -0.01137991f, -0.01773072f, 0.02482842f, 
    -0.03014341f, 0.01064656f, 0.00467793f, 0.02298500f, -0.02139602f, -0.01928212f, -0.04288058f, -0.02248252f, 
    0.02663821f, -0.02252546f, 0.00548813f, 0.00538766f, -0.00623918f, -0.04031826f, -0.00843704f, -0.03856422f, 
    -0.03457076f, 0.00461118f, -0.01177309f, 0.03186568f, -0.02666180f, -0.00891988f, -0.03494055f, 0.00009110f, 
    -0.03011041f, 0.01930393f, -0.03952796f, -0.02267804f, -0.00093181f, 0.00626048f, -0.01074567f, -0.01807160f, 
    -0.01781656f, -0.00827204f, 0.01681913f, 0.00419984f, -0.00194466f, -0.03063149f, -0.02315922f, -0.03473539f, 
    -0.01081343f, 0.00531103f, 0.00878238f, -0.01619043f, 0.00993029f, -0.02401210f, 0.00138829f, -0.02903566f, 
    0.02306581f, -0.03464738f, -0.04169296f, -0.00394285f, -0.01266775f, 0.00674916f, 0.02261948f, -0.02452951f, 
    0.00425502f, -0.03602818f, -0.01076709f, 0.00827529f, 0.02380141f, -0.01940899f, -0.00039655f, 0.02544346f, 
    -0.02593562f, 0.02104671f, 0.00597648f, -0.02799475f, -0.00969000f, 0.01366988f, 0.02502048f, -0.02411241f, 
    0.02553790f, -0.01352708f, 0.02437373f, -0.01880503f, 0.02031027f, -0.03657832f, -0.01556807f, 0.00934543f, 
    0.01894190f, -0.02916178f, 0.00621026f, -0.02314240f, 0.03461067f, -0.00365459f, -0.00418828f, 0.02961727f, 
    0.03241413f, 0.02194134f, 0.03134366f, -0.01014948f, -0.00070488f, -0.01764300f, -0.02489948f, 0.02662931f, 
    0.01891963f, -0.00865687f, 0.00243861f, -0.01708258f, 0.00226085f, 0.00068664f, 0.00316141f, -0.02314059f, 
    -0.09794046f, -0.04481147f, 0.11569660f, 0.11103026f, -0.00095112f, -0.10745212f, 0.03576345f, 0.05243260f, 
    -0.02768592f, 0.03184507f, 0.02445806f, -0.05413588f, -0.03619388f, 0.12271027f, 0.28706878f, 0.00387470f, 
    0.04600468f, -0.02369810f, -0.04210630f, 0.12189312f, 0.15486620f, 0.01073452f, 0.03269317f, 0.04567799f, 
    -0.13187058f, 0.03871601f, 0.16757780f, 0.10620579f, -0.22305065f, -0.05693679f, -0.12776640f, -0.12902021f, 
    -0.04377929f, -0.01099509f, -0.09423990f, -0.07152632f, -0.07795708f, 0.02690033f, -0.11394122f, 0.02414173f, 
    0.12919717f, -0.00376367f, -0.12637889f, 0.07077450f, -0.20183671f, 0.00892844f, -0.02721782f, -0.00553770f, 
    0.62516338f, 0.10182600f, -0.12540892f, 0.27414003f, 0.00577996f, -0.00020579f, 0.08999614f, 0.10796648f, 
    0.04677603f, 0.00447234f, -0.11568413f, 0.11615879f, -0.04714704f, 0.00587889f, 0.07509329f, 0.19091929f, 
    -0.00433280f, 0.07316708f, 0.19129933f, -0.01281928f, 0.02109186f, -0.01812718f, 0.02217630f, -0.08689399f, 
    0.04261322f, 0.15578994f, -0.05941775f, 0.07773105f, 0.13227725f, -0.07451784f, 0.08954241f, 0.01278577f, 
    0.05122528f, 0.16169757f, 0.04325024f, -0.12509385f, -0.03785361f, -0.11999562f, 0.11122925f, 0.04718515f, 
    -0.08752061f, -0.04860436f, -0.08200452f, 0.01860981f, 0.10328757f, 0.09620281f, 0.02613057f, 0.11802711f, 
    0.52540362f, 0.07439119f, 0.11560984f, 0.01408606f, 0.04478081f, 0.05156327f, -0.03504854f, 0.04811920f, 
    -0.00629008f, 0.06552126f, 0.03650683f, -0.05491119f, -0.15410551f, -0.09767065f, 0.23728216f, 0.10799306f, 
    -0.15109184f, 0.01602382f, -0.02376519f, -0.14779449f, 0.00495708f, -0.01753283f, -0.04734186f, -0.05378526f, 
    -0.06209931f, 0.18819985f, -0.06296276f, 0.35698530f, 0.12773673f, -0.00108129f, 0.08458649f, -0.13255459f, 
    -0.13166085f, 0.15830600f, 0.06835178f, 0.14631402f, -0.16115293f, 0.08282074f, -0.06683783f, 0.21894047f, 
    -0.05559163f, -0.04847329f, 0.04695475f, -0.13100569f, 0.12707528f, 0.06235209f, -0.04700701f, -0.03273984f, 
    0.02654317f, 0.06752761f, 0.12080198f, 0.16045934f, -0.08648039f, 0.02731218f, -0.07139062f, 0.06180168f, 
    -0.08463648f, -0.04802394f, -0.05470232f, -0.02236698f, 0.19346285f, 0.27377230f, -0.06156967f, -0.03263709f, 
    0.15982999f, 0.04050027f, 0.14141452f, -0.08069714f, -0.06960671f, -0.00153343f, -0.02835367f, -0.02275127f, 
    -0.04212593f, 0.08764844f, -0.01528778f, 0.06428167f, -0.00913779f, -0.02059034f, -0.16319568f, -0.11205689f, 
    0.12614138f, 0.08332931f, -0.05043345f, -0.05452878f, -0.26101503f, 0.05669956f, 0.15655936f, 0.02380779f, 
    0.10461796f, -0.00840893f, -0.00436592f, -0.05948623f, -0.06068521f, 0.01321505f, 0.01151864f, 0.06329080f, 
    0.11657441f, 0.06781849f, 0.04521199f, -0.04264172f, -0.01486820f, -0.02851837f, -0.05074659f, -0.14990477f, 
    0.01908610f, 0.21955128f, 0.03008682f, 0.14769718f, 0.06615624f, 0.06889977f, 0.07060949f, -0.01182237f, 
    -0.08213205f, -0.05839035f, 0.04591199f, -0.09561651f, 0.02245216f, -0.01556726f, 0.01748911f, 0.04420093f, 
    0.12310547f, -0.02518720f, 0.13919911f, -0.20960014f, -0.09265803f, 0.22541726f, 0.01735861f, 0.15631294f, 
    -0.09404010f, -0.10503959f, 0.05138641f, -0.13351750f, 0.07419135f, 0.06435506f, 0.06184342f, -0.06720051f, 
    -0.02746134f, -0.07294342f, -0.15764058f, -0.05947187f, 0.22883175f, 0.06945834f, 0.01917716f, 0.00127737f, 
    0.24570335f, 0.15557083f, 0.29447535f, -0.14961082f, -0.04315138f, -0.08207046f, -0.05147809f, 0.04872125f, 
    -0.04756935f, 0.10339053f, 0.06778028f, 0.01215930f, 0.08611518f, -0.06901448f, 0.19859800f, 0.01778988f, 
    0.09657815f, 0.00785646f, -0.03446092f, 0.00993918f, 0.00855511f, -0.12179778f, -0.14593516f, -0.05189463f, 
    0.13666672f, -0.13102058f, 0.06175474f, -0.05052065f, -0.13852255f, -0.09677970f, 0.04133495f, 0.07528734f, 
    0.04037040f, -0.02991031f, -0.10349216f, 0.11121546f, -0.02854475f, -0.22922903f, 0.11364157f, -0.00326417f, 
    0.11362837f, -0.06562986f, 0.03233019f, 0.09599818f, 0.11234154f, 0.06867614f, -0.10588919f, -0.00611864f, 
    0.17220026f, -0.01313550f, -0.00900510f, -0.16259557f, -0.14103585f, 0.11004116f, -0.04520591f, 0.05571909f, 
    -0.08259064f, -0.13324329f, -0.01779069f, -0.02366651f, 0.18902025f, 0.14648448f, -0.04401083f, -0.08794710f, 
    -0.03311677f, -0.00842520f, -0.06524837f, 0.03492000f, 0.07903323f, 0.00870283f, 0.06732861f, 0.19119008f, 
    -0.20867524f, 0.29546481f, -0.02498344f, -0.15535827f, -0.13124162f, -0.07131509f, -0.01015831f, -0.00474439f, 
    -0.11804769f, 0.07754656f, -0.10374608f, -0.02425464f, -0.14458604f, 0.15249492f, -0.05963761f, -0.04852247f, 
    0.02916268f, -0.08890888f, -0.03048364f, 0.07188648f, 0.05363014f, 0.02242639f, 0.03588164f, -0.12009581f, 
    -0.03633472f, 0.02700434f, 0.21446119f, 0.07820343f, -0.21554372f, -0.00372268f, -0.05436782f, -0.06120359f, 
    -0.04600072f, -0.09654889f, -0.04981518f, -0.09273873f, -0.02971925f, -0.23671335f, 0.04274193f, 0.15212438f, 
    0.12524870f, -0.08388209f, 0.15716487f, -0.07198699f, 0.16046146f, 0.04472247f, 0.11880808f, -0.07134560f, 
    -0.07976168f, -0.28747648f, -0.14478588f, 0.35283291f, -0.00543825f, -0.02133575f, 0.21941864f, -0.10221490f, 
    -0.05700450f, 0.16453516f, 0.06027230f, 0.11494856f, -0.13918129f, -0.23799963f, 0.13489616f, 0.16571271f, 
    -0.08651865f, -0.06123867f, 0.08442846f, -0.13136522f, 0.33716673f, 0.11019296f, 0.13919227f, 0.09890019f, 
    0.01246889f, 0.02853181f, -0.00717473f, 0.00155577f, -0.08457685f, 0.01114534f, 0.05127082f, 0.00187109f, 
    0.18413949f, 0.15161800f, -0.05891294f, -0.07891418f, 0.29307681f, 0.15220730f, 0.05362849f, -0.23155624f, 
    0.07426921f, -0.00238236f, -0.03434315f, -0.02624875f, -0.06161123f, 0.06091824f, -0.02031150f, -0.08640132f, 
    -0.26134780f, -0.00141788f, -0.49965054f, 0.39038768f, -0.03846177f, -0.06849512f, -0.02754901f, -0.01771880f, 
    0.11440931f, 0.07986060f, 0.12801450f, 0.07939591f, -0.18706331f, -0.18032260f, -0.00586973f, 0.25693792f, 
    0.05922641f, 0.00498416f, -0.00263748f, -0.05331792f, 0.16860399f, 0.02165858f, 0.00474479f, 0.13640700f, 
    0.07478628f, -0.10824960f, -0.07557832f, 0.04390768f, 0.02783139f, 0.11914459f, 0.00794320f, 0.04362314f, 
    0.16062476f, -0.11140011f, -0.18050434f, -0.00071556f, -0.05548585f, 0.04260538f, 0.19985640f, 0.02007308f, 
    -0.02832044f, -0.04431662f, -0.03881892f, 0.01936647f, 0.10697041f, -0.00547198f, 0.00908953f, 0.03973312f, 
    0.07671034f, -0.17069955f, 0.18102200f, -0.04762271f, 0.02880055f, 0.16618061f, 0.07339577f, 0.11200924f, 
    0.01211074f, 0.09323167f, -0.06944214f, 0.13186553f, 0.07857618f, -0.12740254f, 0.24085432f, 0.10520846f, 
    -0.05248537f, 0.10467948f, -0.06682182f, 0.07826229f, 0.00531880f, -0.01005431f, -0.18004341f, -0.05897660f, 
    0.01471898f, 0.17223802f, -0.06439230f, -0.07106927f, -0.15359634f, -0.07479243f, 0.01722545f, -0.02426506f, 
    0.06200427f, 0.05839759f, -0.03508230f, -0.08876817f, 0.17563118f, 0.10557360f, 0.02080278f, 0.11340399f, 
    -0.10493094f, 0.01566496f, -0.00282959f, -0.04963087f, 0.06378916f, 0.18677303f, 0.04441396f, 0.11456695f, 
    0.19471237f, 0.24900681f, 0.11424254f, 0.03997668f, -0.06277665f, 0.03092705f, -0.00287629f, -0.00698682f, 
    0.00731880f, 0.04775177f, 0.02647332f, 0.02354346f, -0.36737373f, 0.22385767f, 0.03610514f, -0.27217364f, 
    -0.04202625f, -0.02357064f, -0.05785749f, 0.02711192f, 0.07480985f, 0.11458576f, 0.04342104f, -0.00634058f, 
    0.50341928f, 0.26307109f, -0.05676957f, -0.13864614f, 0.02964645f, 0.03982214f, -0.15972339f, -0.04377040f, 
    -0.11870507f, -0.01718746f, -0.04109973f, 0.06426927f, 0.00975686f, 0.07109369f, 0.06257816f, 0.01166445f, 
    -0.10022274f, 0.00700569f, 0.08108707f, -0.01819490f, -0.08907875f, 0.01811107f, -0.14303105f, 0.03544009f, 
    0.21169841f, 0.02172674f, 0.02429249f, 0.05218151f, 0.03886402f, -0.02102325f, -0.09429248f, 0.19812548f, 
    -0.00890533f, -0.10228773f, -0.01954331f, 0.03771649f, -0.12731585f, 0.08676047f, 0.02061350f, 0.06951550f, 
    -0.10010828f, -0.00137433f, 0.10219838f, 0.02836336f, -0.11745212f, -0.12618680f, -0.08404648f, -0.05792888f, 
    -0.07187831f, -0.07538734f, -0.05049227f, -0.04521676f, -0.10161745f, -0.07614654f, -0.13213465f, 0.02248726f, 
    0.27577898f, 0.06127739f, -0.06065010f, -0.03596003f, -0.39506593f, 0.12036688f, -0.29570749f, 0.12239367f, 
    -0.03123268f, 0.02725731f, 0.23522872f, 0.11059268f, -0.10464692f, -0.02992051f, 0.15219605f, -0.02574108f, 
    -0.10462436f, 0.08014420f, -0.33310044f, -0.05620999f, -0.23793831f, -0.05541581f, 0.03340177f, 0.00354447f, 
    0.01140754f, 0.04226537f, -0.13703063f, -0.01245289f, -0.04317441f, 0.12341705f, 0.05634214f, -0.10835662f, 
    -0.03480378f, -0.03186422f, -0.01937129f, 0.17186980f, 0.01044546f, -0.11225085f, -0.04155119f, 0.05275734f, 
    -0.12492673f, 0.01144083f, -0.01523837f, 0.34988120f, -0.01402546f, 0.13075696f, 0.17104779f, 0.04634859f, 
    0.13637125f, 0.05045636f, 0.12566710f, 0.04658579f, 0.53559995f, 0.15006725f, -0.22715919f, 0.28233439f, 
    -0.04253880f, -0.02363067f, -0.05964310f, -0.01094780f, 0.01365139f, -0.02544335f, -0.19500686f, 0.06288434f, 
    -0.06527571f, -0.08953429f, 0.09926644f, 0.30181327f, -0.13187660f, -0.10943696f, -0.13319466f, 0.04667794f, 
    0.04127641f, 0.05049065f, -0.05665547f, 0.05958222f, -0.22125721f, -0.02967630f, -0.18943910f, -0.12259823f, 
    -0.02546697f, 0.13126221f, 0.00429067f, -0.00373584f, -0.05960245f, -0.05869973f, 0.15271868f, 0.02270862f, 
    -0.01442483f, 0.00328513f, -0.04262243f, 0.01133247f, 0.00466889f, 0.16909356f, 0.02118117f, 0.21525054f, 
    0.08204295f, 0.16159777f, 0.02860105f, 0.13187976f, -0.08934275f, 0.09666668f, 0.08846541f, -0.18205163f, 
    -0.05664368f, 0.00920375f, -0.04794917f, -0.08044118f, 0.08294134f, 0.08389462f, 0.00071971f, -0.10190012f, 
    0.28199264f, 0.17640330f, 0.07112355f, -0.03275817f, 0.08770940f, 0.05507647f, -0.01410161f, -0.09963688f, 
    -0.12283119f, 0.08174480f, -0.00371138f, -0.05126026f, -0.12483636f, 0.17898545f, 0.05764363f, -0.10796604f, 
    -0.00313980f, -0.13594863f, 0.04552240f, -0.22537731f, 0.08276877f, 0.09733250f, -0.08468290f, -0.00613412f, 
    -0.00412761f, 0.18098521f, 0.16410363f, 0.22611646f, 0.02674976f, 0.01183090f, 0.20181131f, 0.09841236f, 
    0.12014131f, -0.07127171f, 0.15810259f, 0.03020145f, 0.11734704f, -0.02504508f, 0.20419464f, -0.11457122f, 
    0.01481967f, -0.09401453f, 0.12657671f, 0.03783453f, 0.03925711f, -0.10094664f, 0.10908928f, 0.06112260f, 
    0.04500367f, 0.06097515f, 0.13457495f, 0.11333792f, 0.00232560f, -0.02136370f, 0.04048506f, 0.09281393f, 
    0.04501568f, 0.13006242f, -0.03658506f, -0.06218677f, -0.24051729f, 0.01965853f, -0.06576510f, -0.16285463f, 
    -0.08591598f, -0.12639186f, -0.13082808f, -0.02094979f, 0.07710724f, 0.00120411f, -0.02247819f, -0.08916639f, 
    0.10027549f, 0.00914021f, 0.12314305f, 0.29466647f, 0.04586486f, -0.01885428f, -0.01561667f, 0.11462069f, 
    0.03336336f, 0.08979879f, 0.20837654f, 0.20816913f, 0.09248720f, 0.13868865f, 0.32963490f, 0.20896935f, 
    -0.04931509f, -0.09913974f, 0.18309687f, 0.25762552f, 0.06435579f, 0.06178226f, 0.00179559f, 0.04168523f, 
    0.13254009f, 0.09346604f, 0.26788193f, 0.07050348f, -0.02478951f, -0.04270557f, -0.17849259f, -0.02713982f, 
    0.04880285f, 0.06297420f, -0.01347769f, -0.10253356f, 0.10874002f, 0.14054881f, 0.04977069f, 0.20035554f, 
    0.04189382f, -0.00971346f, -0.04772304f, -0.03853264f, -0.13167886f, 0.14195047f, -0.21309750f, -0.03096216f, 
    -0.03162244f, 0.20983444f, -0.15811324f, -0.00451711f, -0.00880548f, -0.10772605f, -0.08623780f, 0.06935576f, 
    -0.09955707f, -0.01837428f, -0.07476123f, 0.01139743f, -0.01178327f, 0.16910879f, 0.06134724f, 0.31952357f, 
    0.01380682f, -0.08309470f, -0.02128658f, -0.19930221f, 0.03307808f, 0.00624276f, -0.09785788f, -0.14973903f, 
    0.11367565f, 0.13962185f, 0.06565431f, 0.33098683f, 0.10772514f, -0.06760903f, 0.00793974f, -0.00435568f, 
    0.10554340f, 0.12585250f, 0.05222171f, 0.09178460f, 0.03258807f, 0.12998036f, 0.04353179f, 0.15110205f, 
    -0.01256245f, -0.03929378f, 0.10223147f, 0.08808636f, 0.01303483f, -0.03120976f, 0.04624932f, 0.09290821f, 
    0.15087664f, -0.13359745f, 0.39934689f, 0.03190760f, -0.06221838f, 0.06730761f, -0.13812615f, -0.02608314f, 
    -0.00356410f, -0.00066233f, 0.04509962f, -0.07125503f, 0.05243287f, 0.08381298f, 0.23383830f, 0.37230536f, 
    0.00814913f, 0.09904499f, -0.13757794f, -0.07667255f, 0.00603235f, -0.12377197f, 0.09611822f, -0.01134025f, 
    -0.25795895f, 0.25029120f, -0.22519965f, 0.19806246f, 0.24129719f, -0.05554333f, -0.05777497f, -0.23784554f, 
    0.04312394f, -0.04236715f, 0.15782139f, 0.07195798f, 0.05191423f, 0.31077316f, 0.12236124f, 0.29398519f, 
    0.01598026f, -0.10697553f, 0.05183370f, -0.05736029f, 0.14469115f, -0.01113640f, 0.00170509f, 0.02877906f, 
    0.17528869f, 0.24695021f, 0.31454667f, 0.17064001f, 0.03347019f, -0.05164873f, 0.07069936f, 0.00654384f, 
    -0.08332741f, -0.01781995f, -0.05694127f, -0.15085559f, 0.20840305f, 0.12366615f, -0.16437399f, -0.00003322f, 
    0.01963113f, -0.02705212f, 0.12366278f, -0.18890035f, 0.00274508f, 0.17000534f, -0.00504996f, 0.11671734f, 
    0.09379773f, 0.14866774f, 0.11252263f, 0.22900628f, 0.07937020f, -0.05292279f, -0.00258062f, -0.01450997f, 
    0.08298097f, 0.10183123f, 0.23820683f, 0.18229233f, -0.05339457f, 0.38906983f, 0.29535916f, 0.09709217f, 
    -0.03332574f, 0.00809985f, -0.01313454f, -0.01430239f, -0.01277980f, -0.05488923f, -0.15084837f, 0.21777779f, 
    0.00691301f, -0.10766082f, 0.00065468f, 0.01220760f, -0.10406937f, -0.03438819f, -0.06490345f, -0.16240402f, 
    0.08226352f, 0.01435355f, 0.11657476f, 0.26702732f, -0.08237886f, -0.16632400f, -0.12118989f, 0.00559665f, 
    0.02762150f, 0.01158733f, 0.03607292f, 0.05072153f, 0.01773042f, -0.03528216f, -0.04484112f, 0.11191300f, 
    0.03699281f, -0.13172440f, 0.20708920f, 0.12509216f, -0.02003184f, 0.28094134f, 0.04125293f, 0.06088721f, 
    -0.07233112f, -0.21084011f, -0.15702224f, -0.23587801f, 0.06492891f, -0.20276007f, -0.16315003f, -0.03923069f, 
    -0.07247952f, -0.00543205f, -0.07917048f, -0.04903715f, 0.21109870f, 0.10077634f, 0.10365828f, 0.21822941f, 
    -0.00572623f, -0.05543179f, -0.03063180f, -0.17761762f, 0.10996348f, -0.03483866f, -0.17166710f, -0.06179114f, 
    -0.02954569f, 0.07102063f, 0.06958316f, -0.10699669f, 0.04047026f, -0.07422465f, 0.28361905f, -0.03947949f, 
    0.02272502f, 0.09598114f, -0.24603282f, -0.02582089f, 0.15467075f, -0.21110676f, -0.11163105f, -0.16479941f, 
    0.07417849f, -0.12940343f, 0.04681839f, 0.23471336f, -0.04381760f, -0.12610945f, 0.06910798f, -0.02870889f, 
    -0.06986558f, -0.00022886f, -0.05963643f, 0.20368281f, 0.02509536f, 0.08934212f, -0.08574965f, 0.13387476f, 
    0.11611939f, 0.13445233f, 0.01948395f, 0.07715914f, -0.05850880f, 0.14420697f, -0.00909205f, 0.17359649f, 
    0.04101073f, 0.10297086f, -0.09396935f, -0.11439861f, 0.03055975f, 0.11772542f, 0.00700413f, 0.14315559f, 
    -0.02381346f, -0.16849007f, -0.12886493f, -0.20854929f, 0.01242282f, -0.01148530f, -0.06516477f, 0.02006914f, 
    0.02505088f, -0.07202828f, -0.09323987f, -0.00215412f, 0.03902131f, -0.08135422f, -0.21749586f, 0.08805358f, 
    0.41428223f, 0.50685030f, -0.05453009f, 0.11501764f, 0.12484092f, -0.04450114f, 0.11549480f, 0.04267276f, 
    0.03497707f, -0.06981426f, -0.01039628f, 0.11851593f, 0.02204344f, 0.18868816f, 0.13293639f, 0.35971433f, 
    0.04157269f, -0.08928135f, -0.02759300f, -0.02568056f, 0.08560833f, -0.02938782f, 0.08324217f, 0.13308965f, 
    -0.00491159f, 0.25046143f, 0.33654225f, 0.27048755f, -0.27010629f, -0.10434888f, 0.00648825f, -0.07867368f, 
    -0.04376398f, -0.06694969f, -0.07732830f, -0.16493002f, -0.04134029f, -0.08789703f, -0.15956707f, 0.05116673f, 
    0.27248982f, 0.02605847f, 0.11812478f, -0.15748008f, -0.18764748f, 0.01614222f, -0.04024472f, 0.03131784f, 
    -0.14285736f, -0.11156957f, -0.11760223f, 0.17565086f, 0.07171637f, -0.01640427f, 0.16613388f, -0.13909878f, 
    -0.05162442f, 0.03647281f, -0.04530007f, -0.03649424f, -0.31853646f, -0.26237491f, -0.22831929f, 0.16096699f, 
    0.05045210f, 0.13391969f, 0.10869736f, 0.07242075f, -0.09195995f, -0.00385325f, 0.00110455f, 0.14449202f, 
    -0.14439477f, -0.12447002f, -0.26836532f, -0.01513196f, 0.08498204f, 0.05450848f, 0.06124712f, 0.03331041f, 
    -0.12415458f, 0.04883583f, -0.07700759f, -0.19307032f, -0.08726381f, 0.20360866f, 0.01396636f, -0.18096757f, 
    -0.00889149f, 0.06035563f, 0.06220587f, 0.05553312f, -0.02563896f, 0.13850981f, 0.00132871f, 0.13584886f, 
    -0.31882650f, 0.21116588f, -0.14077906f, 0.21883300f, 0.17786770f, 0.02544455f, -0.17070766f, -0.12043394f, 
    0.07551682f, -0.00521239f, 0.01417939f, 0.05505233f, -0.22769426f, -0.28362516f, -0.11940323f, 0.12038130f, 
    0.11874121f, -0.01712098f, 0.08561905f, -0.10587276f, 0.06658779f, 0.10645922f, -0.04706538f, -0.04936744f, 
    -0.12252836f, -0.10615384f, -0.01146111f, 0.20723757f, -0.06996208f, 0.00028100f, -0.15240020f, 0.13338657f, 
    0.31138089f, 0.02607963f, -0.17781624f, 0.16976456f, 0.08135067f, 0.25567135f, 0.39441419f, 0.10039310f, 
    0.02231455f, 0.04651783f, 0.05498158f, 0.10157395f, -0.16189732f, 0.05787098f, -0.00228895f, 0.05941142f, 
    -0.16565901f, 0.05355188f, 0.11879877f, -0.00236907f, -0.03178746f, 0.15911826f, -0.01695934f, 0.00981810f, 
    0.04514223f, 0.21142495f, -0.04846771f, -0.06536993f, 0.13562782f, 0.11803702f, -0.07937369f, 0.25657395f, 
    0.04052104f, 0.09997985f, -0.01697161f, 0.02344036f, -0.09288453f, 0.00704341f, -0.01304147f, 0.03298467f, 
    -0.01308466f, 0.14107774f, 0.16192625f, 0.08049034f, 0.02773739f, -0.02084596f, 0.16071947f, -0.14323184f, 
    -0.05531120f, 0.06401869f, -0.01877667f, -0.04518244f, -0.16981776f, -0.21881782f, -0.26558751f, 0.04240454f, 
    -0.05876963f, 0.01379782f, 0.01884965f, -0.02900902f, -0.03878885f, 0.01089063f, 0.04338950f, 0.07643082f, 
    -0.07995006f, -0.14131175f, -0.04128671f, 0.15069960f, -0.03838041f, 0.10362815f, 0.03506954f, 0.00691138f, 
    0.01194728f, 0.00800391f, -0.06022549f, 0.05199697f, 0.14775291f, 0.10366919f, -0.04671294f, -0.26480418f, 
    0.12000889f, 0.10021383f, -0.10175474f, 0.02715238f, -0.01770861f, 0.06748623f, -0.10245783f, 0.04597344f, 
    0.47853518f, 0.29884404f, 0.13641366f, -0.07893042f, 0.04679467f, 0.09273620f, -0.02062340f, 0.09599944f, 
    0.01291094f, -0.01904645f, -0.03352141f, -0.10263368f, -0.18548717f, -0.13505897f, 0.06412787f, -0.06550650f, 
    0.10188189f, 0.13374773f, 0.03893616f, 0.08140745f, -0.03017032f, -0.10653780f, -0.05121314f, -0.06757649f, 
    0.02369573f, 0.22875085f, 0.28462720f, 0.08658368f, -0.09578950f, -0.02715402f, 0.06910143f, 0.15655948f, 
    -0.05245073f, -0.01118289f, -0.05306213f, -0.19372356f, 0.19102097f, 0.29057124f, 0.10177583f, -0.03346002f, 
    0.00442781f, -0.05045496f, 0.04357816f, 0.00020845f, 0.03110928f, -0.02148324f, -0.12328552f, -0.02731167f, 
    -0.25022653f, -0.09045152f, -0.25457302f, 0.07453493f, 0.13250829f, 0.16914269f, 0.04778909f, 0.07857613f, 
    0.02674942f, 0.04552973f, 0.09573092f, 0.14399497f, -0.15733278f, 0.21372662f, -0.04202893f, 0.27000746f, 
    0.08742674f, 0.01536104f, 0.00011862f, -0.04879927f, -0.00007573f, -0.09048762f, -0.11934272f, -0.14442834f, 
    0.16378683f, 0.19879329f, -0.00120801f, 0.24747147f, 0.08832429f, -0.03513434f, 0.05332104f, -0.17826118f, 
    -0.03055382f, -0.01798564f, 0.08037167f, 0.00439165f, 0.20684908f, 0.25460604f, 0.01058031f, -0.20392323f, 
    0.15429553f, 0.09296295f, -0.03567797f, 0.11027018f, -0.15983856f, -0.03388442f, -0.11075100f, -0.02517891f, 
    -0.36630002f, 0.22446790f, -0.12007090f, 0.22352491f, 0.09872603f, -0.03120859f, -0.00935930f, -0.19151820f, 
    -0.18284024f, -0.07885215f, -0.04909928f, -0.03819046f, -0.18649004f, 0.13836402f, -0.24549404f, -0.14020939f, 
    0.10579874f, 0.04864357f, -0.12192177f, 0.03111685f, -0.33520487f, -0.02219460f, -0.04341402f, 0.00251904f, 
    0.12604670f, 0.11178964f, 0.06629594f, 0.26303503f, 0.13071883f, 0.00983717f, 0.03713848f, 0.28459609f, 
    -0.06581843f, -0.10580703f, -0.08940643f, -0.11012223f, -0.20320049f, 0.09335999f, 0.11272676f, 0.02470030f, 
    0.11069649f, 0.09752598f, 0.08341040f, -0.05693870f, -0.11152367f, -0.23475657f, -0.13617209f, 0.04168362f, 
    -0.20525643f, -0.17669246f, 0.11171287f, -0.02139550f, 0.03073476f, 0.12366496f, -0.07702756f, 0.24112810f, 
    -0.10745045f, -0.05325467f, 0.08535702f, -0.17095289f, -0.12151777f, 0.14134645f, 0.15474619f, 0.03508877f, 
    0.01094864f, 0.01615007f, 0.07949752f, -0.08965851f, 0.06305551f, 0.09805647f, 0.06209659f, 0.09294879f, 
    0.26065928f, 0.06223851f, -0.03711833f, -0.30014050f, -0.05676101f, -0.01879415f, -0.03893254f, -0.05087030f, 
    0.03019474f, 0.13657227f, -0.02213431f, -0.17041852f, -0.06311789f, 0.19628201f, 0.10590455f, 0.12530494f, 
    0.12735575f, -0.11512680f, 0.04707157f, 0.00468164f, -0.00494811f, 0.07915761f, 0.05119241f, 0.04559401f, 
    -0.19834059f, -0.07295141f, 0.07957575f, 0.13739124f, -0.16555943f, -0.14495602f, 0.15325516f, 0.07715274f, 
    0.08769845f, 0.02545149f, 0.03194203f, 0.06128196f, -0.03662345f, 0.15384120f, -0.11899609f, -0.30486351f, 
    0.00499052f, -0.20103230f, 0.09630553f, 0.08446164f, -0.02123102f, -0.03869410f, -0.13549563f, -0.25639394f, 
    -0.02868582f, -0.11845779f, -0.10085773f, 0.01138661f, 0.04250032f, 0.04931547f, -0.06066489f, 0.04016371f, 
    -0.00659905f, -0.00724658f, -0.05124320f, -0.07570778f, 0.16677710f, 0.12720096f, 0.10125334f, -0.00442512f, 
    0.09923942f, -0.16753659f, -0.00263428f, -0.06764974f, 0.07865964f, 0.22845101f, 0.09380309f, 0.41170174f, 
    0.28104132f, -0.03496699f, 0.17070952f, 0.23209438f, 0.10186274f, 0.10466804f, -0.04770904f, 0.07574219f, 
    0.16349623f, 0.13046014f, 0.09437968f, 0.23336174f, 0.06951250f, 0.03994418f, -0.11411660f, 0.04268011f, 
    -0.16033791f, -0.00430170f, 0.02791592f, 0.21244338f, 0.12719961f, 0.02112204f, -0.10925639f, 0.08697469f, 
    0.22338618f, 0.09149487f, 0.14488965f, 0.13329567f, 0.14550544f, 0.10928825f, 0.09644295f, 0.15013099f, 
    0.08747582f, 0.08978086f, 0.04197794f, -0.04242453f, -0.02543987f, 0.23289633f, -0.02590553f, 0.07187492f, 
    -0.05679327f, 0.00513863f, 0.19767825f, -0.10209537f, -0.06470414f, -0.06277344f, -0.26264331f, -0.33569354f, 
    -0.59597689f, -0.15080944f, 0.20728193f, -0.30333152f, -0.09933317f, 0.00597162f, -0.20752972f, -0.09985214f, 
    -0.02668388f, -0.04503945f, -0.19589415f, 0.04624319f, -0.15425974f, 0.00602263f, -0.08955812f, 0.06221230f, 
    0.01023758f, 0.05270983f, -0.05652423f, -0.17883790f, -0.02572391f, -0.09846810f, -0.18036266f, -0.10468353f, 
    -0.02999474f, -0.08704797f, -0.00515923f, 0.06963384f, 0.01774283f, 0.06100471f, 0.01615085f, -0.07560581f, 
    0.07218050f, 0.09201857f, -0.02517887f, 0.31544518f, -0.11266539f, 0.11738379f, 0.16550985f, 0.07899058f, 
    0.02518340f, 0.03867073f, 0.10702275f, 0.14362477f, 0.07987247f, -0.01078089f, 0.20324610f, 0.08126589f, 
    -0.10784484f, 0.00981735f, 0.13856275f, 0.08867019f, 0.12931162f, -0.07721145f, -0.08160748f, -0.21488199f, 
    -0.03780474f, -0.07466756f, 0.05444146f, -0.03555429f, 0.10568678f, 0.00724700f, -0.08884362f, 0.12622172f, 
    0.16573821f, 0.06184426f, -0.05911218f, 0.19147174f, 0.03332637f, -0.10859438f, 0.18981996f, 0.07994984f, 
    -0.04011778f, 0.06986877f, 0.09000185f, -0.00926695f, 0.00472821f, 0.18888853f, -0.10979868f, -0.16092685f, 
    0.16112156f, -0.13007715f, -0.23070477f, -0.04845075f, 0.36101082f, 0.07833115f, 0.19689018f, 0.13979320f, 
    0.12805335f, 0.02048309f, 0.06710269f, 0.18933079f, 0.11111072f, 0.14974275f, 0.00451204f, 0.06952933f, 
    0.06583416f, 0.02465867f, 0.02980222f, 0.07061843f, 0.03506102f, -0.03593018f, 0.13509005f, 0.14908426f, 
    0.02464641f, -0.07855973f, -0.02318464f, -0.10371564f, 0.16413380f, -0.06098263f, -0.05364304f, 0.17164238f, 
    -0.22281703f, 0.01009081f, 0.02189974f, 0.01587114f, 0.18561989f, 0.07211067f, 0.04932040f, 0.15039775f, 
    0.04741579f, -0.16451371f, 0.09179293f, 0.07944079f, 0.04331926f, 0.03190016f, 0.15185942f, 0.04749390f, 
    0.10893989f, 0.15081531f, 0.15840347f, 0.24351844f, 0.13527685f, 0.36426350f, 0.08720887f, 0.34123516f, 
    -0.00439572f, 0.06245035f, 0.04198384f, 0.03941049f, 0.08609933f, -0.12892130f, -0.11852233f, 0.03658921f, 
    0.01387860f, -0.09402551f, 0.01977135f, 0.07264441f, 0.00978542f, 0.05137992f, 0.04930369f, -0.13139977f, 
    0.22960171f, 0.02625911f, 0.18451822f, 0.29726052f, 0.12196796f, -0.07329648f, 0.07987889f, 0.05947893f, 
    0.03075457f, 0.06126977f, 0.09287875f, 0.22993621f, 0.19468385f, 0.20317829f, 0.07448044f, 0.12705052f, 
    -0.08888119f, -0.13530383f, 0.15509318f, 0.22795346f, 0.06209657f, -0.05333019f, 0.05135979f, -0.13264704f, 
    -0.16478004f, -0.09637223f, -0.17716254f, -0.23929445f, -0.09791815f, -0.14446275f, -0.24172153f, 0.01953751f, 
    0.07750370f, 0.04964624f, 0.25978065f, 0.00614725f, 0.18259864f, 0.23986177f, 0.10620403f, 0.29566798f, 
    -0.24742779f, 0.06235430f, -0.13770169f, 0.13421263f, 0.12744316f, -0.11722928f, -0.12135113f, -0.01577511f, 
    -0.02097416f, -0.00604342f, 0.15782991f, -0.06592762f, -0.20493409f, 0.14325050f, -0.10665831f, 0.12423595f, 
    0.01263277f, 0.13455039f, -0.04182520f, 0.02724036f, -0.06420764f, -0.20242541f, -0.01836755f, -0.26525724f, 
    0.20885848f, 0.16865933f, -0.10690175f, 0.28408024f, 0.03345427f, -0.02250657f, -0.10798978f, -0.02710814f, 
    -0.01581907f, 0.07217877f, 0.02304434f, 0.12763990f, -0.03204199f, 0.15891591f, 0.10621166f, 0.26063624f, 
    -0.00208008f, 0.13985614f, 0.03803843f, 0.04657406f, 0.00842206f, 0.07526088f, 0.10412382f, 0.07422993f, 
    -0.25251380f, 0.11242560f, 0.13500535f, -0.02182366f, 0.38696870f, 0.03361595f, -0.08105847f, -0.06327248f, 
    -0.08026677f, -0.26812682f, -0.29090297f, -0.17859642f, -0.08781952f, 0.03217961f, -0.13600183f, -0.06623865f, 
    0.02430326f, -0.19833183f, -0.11951496f, -0.22405462f, -0.12504835f, -0.10939512f, -0.12582093f, -0.17529795f, 
    0.52825451f, -0.03425489f, -0.13541798f, 0.12202463f, 0.01801456f, -0.09112515f, -0.03882670f, -0.00997320f, 
    0.16366921f, -0.09030360f, -0.01469726f, -0.02938584f, 0.27110928f, -0.09311644f, -0.01350704f, 0.22364244f, 
    -0.01566840f, 0.03199829f, 0.05678775f, -0.13463069f, 0.21154192f, 0.00046417f, 0.03064432f, 0.19141084f, 
    -0.16375428f, -0.03101608f, -0.08466843f, 0.03490789f, 0.00327724f, -0.12484363f, 0.03618380f, 0.15317218f, 
    -0.08741582f, 0.02229660f, 0.00650346f, 0.03324907f, 0.01799765f, 0.30019894f, -0.28915980f, -0.24826257f, 
    0.03505548f, -0.03483092f, -0.12008142f, -0.17072237f, -0.19788916f, -0.17699820f, -0.15777333f, -0.07260463f, 
    0.00473529f, -0.05473530f, 0.19357908f, -0.18232283f, -0.14346370f, -0.01569513f, -0.11952410f, -0.04345722f, 
    0.07296510f, -0.09329849f, -0.07967620f, 0.04347840f, 0.23791794f, 0.54580212f, -0.30587292f, -0.12524305f, 
    0.09115689f, 0.08235703f, -0.23725232f, 0.05654959f, -0.13576235f, 0.04996906f, -0.09858064f, -0.11591231f, 
    0.04664180f, 0.00710769f, -0.09501226f, -0.22106837f, 0.02445154f, 0.00000670f, -0.11738607f, -0.16298862f, 
    -0.14631632f, -0.08987740f, -0.03872174f, -0.19707149f, -0.23151197f, 0.00266429f, -0.05382748f, -0.01834952f, 
    -0.12189999f, 0.08421663f, 0.07169509f, -0.03395372f, 0.14249900f, 0.14248116f, 0.07012558f, 0.29248756f, 
    0.24436109f, -0.04022236f, 0.38380668f, 0.04528912f, 0.06089669f, 0.08992560f, -0.04333674f, -0.10693402f, 
    -0.00137373f, 0.17465955f, -0.12614667f, 0.03315147f, 0.23044814f, -0.11108486f, 0.08532915f, -0.23680374f, 
    -0.04377424f, 0.02421950f, 0.04673352f, -0.08640007f, -0.02490237f, 0.16522858f, 0.09255110f, -0.06740471f, 
    -0.16464160f, -0.07738318f, 0.23334657f, -0.19563523f, -0.07843313f, 0.13541728f, 0.02066793f, -0.11261284f, 
    0.16408600f, 0.08824146f, -0.13686815f, 0.17430872f, -0.05254760f, 0.19049373f, 0.07126389f, 0.25543854f, 
    0.07352912f, 0.08340433f, 0.20108388f, 0.25464067f, 0.00040876f, 0.15533562f, 0.02272026f, -0.04416150f, 
    -0.32962257f, 0.52395135f, 0.01055604f, 0.21574500f, 0.04545511f, -0.01514288f, 0.02802921f, 0.00392365f, 
    -0.02257439f, -0.02222606f, 0.02350322f, -0.22208311f, -0.09737679f, 0.10268846f, 0.00133283f, 0.18782721f, 
    0.18264933f, -0.00890270f, 0.04860486f, -0.00562784f, 0.00146162f, 0.09430570f, 0.31760123f, 0.11728870f, 
    0.21289495f, -0.11246389f, 0.12553133f, -0.01220227f, 0.10125174f, -0.06320579f, -0.06455886f, -0.05576722f, 
    -0.00044641f, 0.01551503f, -0.06309529f, -0.00242673f, 0.01915496f, -0.01428418f, -0.01160207f, -0.07963215f, 
    0.06679226f, 0.05897170f, -0.08202797f, -0.01789124f, 0.06259057f, 0.04714059f, 0.13748775f, 0.00033928f, 
    -0.15241684f, -0.13112009f, -0.02979410f, -0.02225654f, 0.09494764f, -0.02749528f, -0.01607025f, -0.04594193f, 
    0.03927924f, -0.14520811f, -0.05380946f, -0.03116749f, 0.64503008f, -0.09017549f, -0.18158576f, -0.09349316f, 
    0.03084833f, -0.15536746f, -0.07393322f, -0.02974448f, -0.03506504f, -0.06300173f, 0.02561185f, -0.00949142f, 
    -0.09692211f, 0.10905174f, 0.30864584f, 0.31111631f, 0.14409155f, -0.01070765f, 0.03767994f, 0.03989117f, 
    0.08380544f, -0.17508452f, -0.10729188f, -0.24868591f, -0.23309414f, 0.07231223f, -0.04050102f, -0.19625276f, 
    0.14756569f, 0.18611981f, -0.14628345f, -0.15700926f, -0.02028253f, -0.29862812f, -0.09886208f, -0.12621647f, 
    -0.10581934f, 0.03148404f, 0.43143159f, 0.04719542f, 0.06580020f, 0.00172637f, 0.23301411f, 0.07029547f, 
    -0.13780951f, -0.01335682f, -0.11530709f, -0.19067867f, 0.13951728f, 0.03956919f, 0.00463645f, -0.06213961f, 
    0.02245563f, -0.05758948f, 0.04409689f, 0.00823902f, -0.00489549f, 0.15967970f, -0.22890700f, -0.07551362f, 
    -0.03768375f, 0.15879765f, 0.08234060f, -0.00050037f, 0.09914315f, 0.33940607f, 0.12624088f, 0.14506797f, 
    -0.03710365f, 0.01265705f, 0.13086779f, 0.21927170f, 0.18881358f, 0.07194969f, 0.08857010f, 0.13518484f, 
    0.04753153f, 0.02425498f, -0.02985827f, -0.19079290f, 0.03944304f, -0.10868158f, -0.33164608f, -0.20803289f, 
    0.48512927f, -0.13504140f, 0.22833131f, 0.28638518f, 0.08162536f, -0.01445202f, -0.01154849f, -0.08997600f, 
    0.12375262f, 0.07689449f, 0.11039071f, 0.18711452f, 0.17116211f, 0.02803538f, -0.00764560f, 0.08265052f, 
    0.06634840f, -0.07257566f, 0.10868794f, -0.04254577f, -0.13791318f, 0.17181273f, -0.03975054f, 0.03375567f, 
    -0.07989877f, -0.01504280f, -0.09319479f, -0.37877390f, 0.07069537f, -0.10782991f, -0.12454890f, -0.20911224f, 
    -0.22667010f, 0.10126185f, -0.18949290f, -0.04550343f, -0.23929062f, -0.00925219f, 0.20526943f, -0.29430556f, 
    0.03395683f, 0.02806808f, -0.04175533f, -0.00587761f, -0.11730235f, 0.06292839f, 0.10044323f, -0.07808715f, 
    0.17765591f, 0.12945722f, 0.14280559f, 0.05759732f, 0.13989189f, 0.04368228f, 0.07177097f, 0.26998273f, 
    0.02675757f, 0.04100339f, -0.09863975f, -0.16328412f, 0.12790702f, 0.01888935f, 0.01697971f, 0.13836692f, 
    0.22582813f, -0.01930666f, 0.05432146f, -0.07599192f, 0.00676323f, -0.24962017f, -0.27669650f, -0.02231182f, 
    0.03111425f, -0.13717842f, 0.22511880f, 0.12017715f, -0.04961557f, -0.12066554f, -0.00936720f, 0.12495080f, 
    -0.01190557f, 0.13240096f, -0.00100977f, -0.23862384f, -0.02984257f, -0.02734975f, 0.10015482f, 0.16880894f, 
    0.00289839f, -0.02322267f, 0.07522464f, -0.06937754f, 0.00305551f, 0.07712644f, -0.02208203f, 0.07713922f, 
    -0.35855356f, 0.33688655f, -0.06033850f, 0.16189609f, 0.11510681f, 0.02091031f, -0.05951660f, 0.16167933f, 
    0.05506876f, -0.11117926f, -0.08607549f, -0.16412672f, -0.00084273f, -0.12952006f, -0.06028701f, 0.29333332f, 
    0.11287632f, 0.04985100f, -0.02511974f, 0.24926408f, 0.00511385f, -0.00542730f, 0.22873478f, 0.14959818f, 
    0.00146827f, -0.29041404f, 0.11418293f, -0.29289964f, -0.23488331f, -0.00421526f, -0.17543487f, -0.16836852f, 
    -0.03887210f, 0.00856892f, -0.17800859f, -0.00208220f, -0.22188514f, 0.15073301f, -0.18794373f, -0.20608658f, 
    0.06837320f, -0.19904216f, -0.07927803f, 0.03169114f, -0.42914757f, -0.10390765f, -0.37946129f, -0.44931522f, 
    0.15402544f, -0.24724260f, 0.02009572f, -0.26580518f, -0.13092196f, -0.00734664f, -0.11018115f, -0.39757672f, 
    -0.11177683f, -0.09782718f, -0.06800979f, -0.09280840f, 0.31187880f, -0.14121665f, -0.09454422f, 0.07224270f, 
    0.01567974f, -0.03048855f, 0.15566868f, -0.07515621f, 0.02850058f, 0.15425815f, 0.15177940f, 0.32209438f, 
    -0.16356444f, -0.12690495f, -0.09323031f, 0.08576629f, -0.21448691f, -0.15144254f, 0.06968721f, 0.19445589f, 
    0.00939863f, 0.12058683f, 0.16943043f, -0.18059963f, -0.09440281f, -0.08016454f, 0.13979474f, -0.04263838f, 
    -0.11514628f, -0.13075677f, 0.04397187f, -0.00983910f, -0.04370862f, -0.08055242f, 0.10247704f, -0.21344925f, 
    -0.41987509f, -0.22108090f, -0.28531832f, -0.42130032f, -0.00948753f, -0.08926091f, -0.01348457f, 0.00388329f, 
    -0.06512198f, 0.04258033f, 0.01251492f, -0.05423992f, -0.16713555f, 0.04424584f, 0.03331080f, 0.02985910f, 
    0.02629503f, -0.11777866f, 0.18510403f, -0.31805366f, -0.10251587f, -0.09260041f, -0.05477390f, 0.01058062f, 
    0.55021179f, -0.02805830f, 0.02079301f, -0.20540275f, -0.00228698f, 0.01008698f, -0.06679226f, 0.15820390f, 
    -0.03767512f, 0.06251942f, -0.00575123f, -0.03231969f, -0.07580042f, -0.41457018f, 0.01793086f, -0.21664900f, 
    0.13375045f, 0.04641075f, -0.10482477f, 0.15045281f, -0.00065221f, -0.01718714f, 0.07195045f, 0.00319500f, 
    0.42244333f, -0.23008379f, 0.19101752f, 0.16963229f, -0.01330349f, -0.01257406f, -0.08229994f, 0.05270636f, 
    0.02293972f, 0.17279889f, 0.16345964f, 0.09411182f, -0.11571357f, -0.24148294f, 0.03588456f, -0.29736105f, 
    0.10243505f, 0.15156780f, 0.13313843f, 0.28375113f, -0.07163393f, -0.15253904f, -0.12727730f, -0.00145516f, 
    0.08236758f, -0.05160075f, -0.01728421f, -0.03169073f, 0.00205308f, -0.09257128f, 0.06329308f, 0.03753432f, 
    0.03791575f, 0.05434046f, 0.06733206f, 0.07252126f, -0.24978940f, 0.03779134f, 0.09833646f, 0.18067351f, 
    0.05033535f, -0.10197881f, -0.03253731f, 0.08653306f, 0.03545061f, -0.08512003f, -0.11711663f, -0.07597227f, 
    0.13663375f, -0.12007748f, 0.17404886f, -0.03213481f, 0.20089787f, 0.10892170f, 0.11337083f, 0.16167462f, 
    -0.09039802f, 0.01024474f, 0.21107468f, 0.17066796f, -0.14970528f, -0.19556257f, -0.21389958f, -0.03940054f, 
    0.01496044f, -0.11766952f, -0.11758454f, -0.02901311f, 0.09255555f, -0.12312634f, 0.12833169f, -0.02245712f, 
    -0.34070644f, -0.17248678f, -0.02960173f, -0.26745170f, 0.01801456f, -0.12896542f, 0.02196247f, 0.10184802f, 
    -0.11260597f, -0.06515867f, 0.02485629f, -0.03400799f, 0.25291160f, -0.27824289f, 0.09977552f, -0.11670457f, 
    -0.03431494f, -0.01408600f, 0.19390301f, 0.02157858f, 0.02967736f, 0.06460647f, 0.01293847f, 0.18426041f, 
    -0.04730762f, 0.01208135f, 0.13251899f, 0.10260673f, 0.04785627f, -0.05010715f, 0.08141613f, 0.13984168f, 
    0.01160043f, 0.08883020f, -0.09247956f, 0.09559979f, -0.00067408f, 0.03999334f, -0.30496001f, -0.13981669f, 
    0.10792246f, 0.12419624f, 0.04650766f, -0.01792613f, -0.07089032f, -0.27800173f, 0.01756782f, 0.14857957f, 
    0.00415774f, 0.10577809f, 0.01184880f, -0.01293955f, -0.01193810f, 0.09661936f, 0.05567141f, 0.01540354f, 
    0.14716007f, 0.06488989f, 0.18588531f, 0.20436749f, -0.09030487f, -0.05026845f, 0.07731453f, -0.01454571f, 
    -0.01583443f, 0.03978331f, 0.01321478f, -0.01305258f, 0.04159099f, 0.07293873f, 0.11231942f, 0.06223865f, 
    0.21156400f, 0.16508643f, 0.22100775f, -0.04632904f, -0.13662814f, -0.02578290f, 0.17783876f, -0.00709330f, 
    -0.05208903f, -0.01105847f, -0.12884527f, -0.17021418f, 0.00387642f, 0.09687692f, 0.03732499f, 0.06065813f, 
    0.01123753f, -0.00447475f, 0.01651493f, 0.01181302f, 0.33040321f, 0.11631352f, 0.16236778f, 0.16992974f, 
    0.24217802f, 0.03033868f, 0.22157006f, -0.07514793f, -0.00479442f, -0.27178818f, 0.29779935f, -0.00338302f, 
    0.22024624f, 0.23585321f, -0.11170446f, 0.18353707f, 0.06152763f, 0.13979222f, -0.08099263f, -0.15287556f, 
    -0.14121620f, -0.06240185f, 0.01072436f, -0.16550161f, -0.03102692f, -0.04419228f, 0.02189033f, -0.00819993f, 
    0.08074123f, -0.13143884f, 0.26650107f, -0.17146684f, -0.06453746f, -0.01418792f, 0.00493218f, 0.05676150f, 
    0.05780305f, 0.06804740f, 0.15498967f, 0.17024678f, -0.27226225f, -0.27917367f, -0.05771645f, -0.05154551f, 
    0.18877378f, 0.08197173f, 0.04964344f, 0.26773617f, -0.06105058f, 0.03563231f, -0.01195227f, -0.07646434f, 
    0.07703725f, -0.09313098f, -0.00551788f, -0.00770549f, 0.15278919f, -0.00107475f, -0.09149589f, -0.00267624f, 
    -0.02598408f, 0.04041482f, 0.01900359f, 0.01810620f, -0.05364975f, 0.15285747f, -0.00677173f, 0.12890400f, 
    -0.07691436f, 0.06439281f, 0.06359854f, -0.06492887f, 0.08213446f, -0.01783852f, 0.03529111f, -0.00603657f, 
    0.26581371f, 0.27368012f, 0.12908509f, 0.15409586f, -0.02936415f, -0.02577135f, -0.01174646f, -0.12863077f, 
    -0.09407393f, -0.13631937f, -0.16468927f, 0.08617351f, 0.11528917f, -0.00899765f, 0.04503760f, 0.19806010f, 
    -0.16597092f, -0.07964420f, -0.19202000f, 0.02761655f, -0.00941074f, -0.01990655f, 0.13890034f, 0.22648382f, 
    -0.24206454f, -0.04617323f, -0.02824661f, -0.10182806f, -0.16871572f, -0.10008544f, -0.00068586f, 0.05530614f, 
    -0.08187880f, -0.00137033f, -0.02835987f, -0.08208054f, 0.01973050f, -0.03861250f, 0.12653263f, 0.09551557f, 
    -0.03528749f, 0.05418507f, 0.07353567f, -0.04207882f, 0.04259937f, 0.00159691f, -0.14627999f, -0.11528344f, 
    -0.00368087f, -0.00169503f, -0.04082828f, 0.17705692f, 0.04219196f, 0.47365767f, -0.37593490f, 0.21372245f, 
    0.04043243f, 0.18148006f, 0.26690817f, -0.28022504f, 0.03189958f, 0.10601243f, 0.11808315f, 0.16233170f, 
    -0.03993750f, 0.01421238f, -0.05136213f, -0.06564928f, 0.00613220f, -0.02329569f, -0.11297879f, -0.01682353f, 
    0.06450825f, 0.01549607f, 0.15541631f, 0.01421636f, -0.02110255f, 0.04604318f, 0.06208108f, -0.01634852f, 
    0.21590936f, 0.06039752f, -0.03524740f, -0.12984906f, 0.08029719f, 0.13025627f, 0.07633697f, -0.10760122f, 
    -0.04465901f, 0.02537914f, 0.06920653f, -0.04178273f, 0.04652930f, 0.08213822f, 0.20262896f, 0.18916042f, 
    -0.23691018f, -0.17169084f, 0.02662267f, 0.21673667f, 0.24722154f, 0.17749880f, -0.20426776f, 0.01508348f, 
    -0.00718435f, 0.01938691f, -0.02585814f, -0.00217431f, 0.04743171f, 0.07407714f, 0.02786861f, 0.12180284f, 
    0.08355377f, 0.09764063f, -0.09401237f, -0.03317174f, 0.08915027f, 0.05697317f, 0.12391502f, -0.00533810f, 
    0.05409211f, 0.01765287f, 0.08467518f, -0.04198948f, 0.08495627f, 0.04316862f, 0.01626283f, 0.14224276f, 
    0.16727120f, 0.10345913f, -0.07096905f, -0.05086612f, -0.31468779f, 0.01241860f, -0.01818689f, -0.17991747f, 
    0.16072486f, 0.06637643f, 0.26960260f, 0.08855517f, -0.13079278f, -0.03539177f, -0.13997968f, -0.11600591f, 
    0.00448590f, 0.09750488f, 0.17286673f, -0.16570607f, -0.02011028f, -0.04654518f, 0.18117052f, 0.05805666f, 
    0.24448952f, 0.21043946f, -0.25014845f, 0.01015915f, 0.24704218f, -0.09397725f, 0.39346141f, -0.22920780f, 
    0.06340643f, -0.21640147f, 0.07833885f, 0.09127560f, 0.03855535f, 0.14568011f, -0.04901043f, 0.07372264f, 
    0.12426702f, 0.30582997f, 0.21823037f, -0.05722575f, -0.14992975f, -0.08679588f, 0.05333079f, -0.17824718f, 
    -0.19145052f, -0.10461005f, 0.05346736f, -0.10788525f, 0.07570140f, 0.07961977f, 0.04377786f, 0.11157152f, 
    0.08222935f, 0.10226122f, 0.00007880f, -0.00889487f, 0.18086508f, 0.18622057f, 0.23731339f, 0.05935610f, 
    0.06510330f, -0.03924836f, 0.09727155f, 0.10242254f, 0.01765892f, 0.08489444f, -0.00257822f, -0.01956951f, 
    0.08397622f, 0.00529494f, -0.03677469f, 0.06412494f, 0.03730006f, 0.30032697f, 0.21265140f, 0.08203220f, 
    0.09886650f, 0.12527324f, 0.08279349f, -0.27212206f, -0.07530726f, 0.02724462f, -0.06689091f, 0.00649155f, 
    0.04841314f, 0.03845395f, -0.10269221f, -0.12362118f, -0.04466590f, -0.15399595f, 0.22002849f, 0.13712385f, 
    -0.08347885f, -0.02675375f, -0.00164005f, -0.01526306f, -0.03743465f, -0.04500479f, 0.02706843f, 0.08937899f, 
    0.04305738f, 0.09210611f, -0.05600532f, -0.00426900f, 0.03062527f, 0.07419030f, 0.09087703f, -0.11432402f, 
    -0.28978702f, -0.18479511f, -0.09558485f, -0.09142698f, -0.07685230f, -0.14721927f, -0.01663351f, 0.05236088f, 
    0.00726468f, -0.05823851f, -0.08186562f, -0.01407207f, -0.04199822f, 0.05978600f, 0.19152282f, 0.01562836f, 
    -0.05094956f, -0.13472179f, -0.16630247f, -0.04681605f, -0.05751383f, -0.05058777f, 0.00936414f, 0.01174724f, 
    0.09149668f, -0.07249280f, 0.08703082f, 0.18308610f, 0.03563259f, 0.09109774f, -0.06968707f, 0.10968319f, 
    0.30583835f, -0.18426567f, 0.03999489f, 0.01990533f, 0.00038807f, 0.09489542f, -0.07282604f, 0.20790291f, 
    -0.06513530f, -0.12444987f, -0.21905118f, -0.00823351f, -0.13768992f, -0.06949857f, 0.10261060f, -0.06445161f, 
    0.17124602f, 0.10769632f, 0.28990668f, 0.09790102f, -0.13813099f, -0.11200550f, -0.04553021f, -0.06623930f, 
    -0.17106824f, -0.07932806f, -0.02847293f, -0.00764447f, -0.14117013f, -0.00717768f, 0.12320866f, -0.49216431f, 
    -0.11760844f, 0.00077170f, 0.06512163f, 0.01487725f, -0.05019305f, 0.15683277f, -0.31528920f, -0.05890252f, 
    -0.00719773f, -0.00931805f, 0.12687029f, 0.24419336f, 0.08014659f, 0.15732542f, 0.10723455f, 0.00006789f, 
    0.04516607f, 0.20406634f, 0.08212858f, -0.00475200f, 0.22762005f, 0.07100688f, 0.29293749f, -0.14154390f, 
    -0.02322516f, 0.05945695f, -0.02814665f, 0.00860037f, 0.02713706f, 0.14444685f, 0.01643720f, -0.04616580f, 
    -0.38835296f, -0.12460848f, -0.05612605f, -0.17975493f, 0.03732651f, -0.23454864f, -0.15995647f, -0.02862014f, 
    -0.01855525f, -0.12046994f, -0.03983925f, -0.09097064f, -0.10474911f, -0.10433664f, -0.02122274f, 0.16680670f, 
    -0.10051438f, 0.10592257f, -0.06759264f, -0.10084052f, -0.03046313f, -0.14962156f, -0.00291172f, -0.00365622f, 
    -0.52808589f, -0.04918174f, -0.20967594f, -0.07916843f, 0.11728407f, 0.09604397f, -0.12280958f, -0.03493021f, 
    0.13045523f, 0.00063369f, 0.00751255f, -0.12962431f, -0.09455032f, 0.26992062f, 0.07770203f, -0.08553313f, 
    -0.11395721f, 0.07474692f, 0.04436954f, -0.10636017f, 0.05227059f, 0.20015533f, 0.04652111f, 0.10892148f, 
    0.12982206f, 0.07540424f, 0.02056245f, -0.15043351f, -0.17766118f, -0.00097334f, 0.34257561f, -0.07232264f, 
    -0.09159134f, 0.03269337f, -0.07764938f, 0.02254237f, -0.37799844f, 0.15064394f, -0.05267382f, -0.06491325f, 
    -0.22086126f, -0.03023226f, 0.28803805f, 0.08081591f, -0.08429280f, -0.06877647f, -0.03214642f, 0.07582816f, 
    0.12337046f, 0.19830754f, -0.01543083f, 0.00195974f, -0.07576739f, 0.01110935f, -0.00814733f, 0.00579095f, 
    0.11215362f, 0.08419597f, 0.01981445f, -0.00150556f, 0.02729197f, 0.10662697f, -0.00919857f, -0.04327725f, 
    -0.05675887f, -0.06811453f, 0.02620832f, -0.00729852f, 0.06123287f, 0.00157803f, -0.06618778f, 0.03450119f, 
    0.10525814f, 0.00940099f, 0.14488164f, 0.00951696f, 0.01052909f, 0.04974540f, -0.05710155f, -0.01514846f, 
    -0.02848707f, 0.00950078f, 0.03493371f, -0.20136228f, -0.06960110f, 0.16686645f, 0.14680673f, -0.05787998f, 
    -0.14016768f, -0.00757283f, -0.16262922f, -0.22965609f, 0.00233663f, -0.00068680f, 0.08120555f, 0.11401867f, 
    0.01509548f, -0.01912165f, -0.03228580f, 0.00045972f, 0.00940729f, 0.00031927f, -0.03607373f, 0.00203211f, 
    0.00206376f, -0.03642840f, 0.01035531f, -0.01489866f, 0.00016239f, 0.01288338f, -0.04136894f, -0.04042263f, 
    -0.00022756f, 0.01500626f, -0.03156463f, 0.02144378f, 0.00606623f, 0.01356923f, 0.00660893f, 0.00597649f, 
    0.03812880f, 0.00675775f, -0.00130032f, 0.01188214f, -0.03344235f, -0.00838208f, 0.01983687f, 0.02587241f, 
    -0.01083182f, -0.00985156f, -0.03654688f, -0.03197811f, -0.03886076f, 0.01858005f, 0.01902701f, -0.03568640f, 
    -0.00636772f, 0.01712133f, 0.00360694f, 0.00440232f, 0.00147766f, -0.02040846f, 0.00966357f, 0.00835388f, 
    -0.01405136f, -0.00195710f, -0.03259677f, -0.01789203f, -0.00866527f, 0.02432034f, 0.01359875f, -0.00089000f, 
    -0.02417258f, -0.01358804f, -0.02076679f, 0.02556536f, -0.01437347f, -0.00028058f, 0.02662597f, 0.01695775f, 
    -0.02721800f, -0.03471239f, -0.00635349f, 0.00984973f, -0.00757065f, -0.00385986f, 0.02592711f, -0.00478365f, 
    0.00621542f, 0.01934622f, -0.00465535f, -0.00274467f, -0.00570860f, -0.02818914f, -0.03678777f, 0.00858370f, 
    -0.00657992f, 0.02171446f, 0.01067831f, 0.00407871f, -0.01252654f, -0.02922669f, -0.03844033f, -0.00906870f, 
    0.02334433f, 0.02108495f, 0.02187402f, 0.00467937f, 0.02657871f, -0.02011088f, 0.02113268f, 0.00862721f, 
    -0.04245469f, -0.04084849f, -0.02102848f, -0.00596522f, -0.03270104f, 0.02506680f, -0.02950553f, 0.01180830f, 
    -0.00254119f, 0.01655926f, -0.04278773f, -0.03755198f, 0.01292634f, 0.00987872f, 0.00311908f, 0.00908994f, 
    -0.02097667f, 0.02945807f, 0.01795851f, 0.01865587f, 0.02327437f, -0.03081094f, -0.02843921f, -0.00256811f, 
    0.00067070f, 0.02393981f, -0.00148427f, -0.00049524f, 0.00060247f, 0.01217419f, 0.02054779f, -0.03536247f, 
    -0.04366733f, -0.04144742f, 0.01707303f, -0.04359882f, 0.01335650f, -0.01561917f, 0.01318597f, 0.02388815f, 
    0.01703494f, -0.00173197f, -0.00803036f, 0.02626236f, 0.00535682f, -0.04170749f, 0.01473198f, 0.01733381f, 
    0.00389744f, -0.02279819f, 0.02997432f, 0.01527367f, 0.03132191f, -0.03567462f, 0.02568313f, 0.02382787f, 
    -0.02709702f, -0.00727911f, -0.01697383f, -0.01274035f, -0.04115591f, -0.00298064f, 0.01881010f, 0.00705403f, 
    0.00612968f, -0.02073964f, 0.00490810f, -0.02973730f, -0.02444977f, -0.00618795f, -0.00989704f, -0.01239100f, 
    0.00689229f, 0.00315696f, 0.01146513f, -0.01599303f, 0.01777270f, 0.01116031f, 0.02560356f, -0.02454328f, 
    -0.01238470f, -0.02108428f, -0.00002034f, 0.01007629f, 0.02533146f, -0.03665142f, 0.01183469f, -0.00242684f, 
    0.01938389f, 0.01134095f, 0.01770968f, 0.00852350f, -0.03068751f, -0.01743835f, -0.02971246f, -0.02158402f, 
    0.02112592f, 0.01305542f, -0.02289625f, -0.03041894f, -0.03035846f, 0.02689399f, -0.01596395f, 0.00094115f, 
    0.01477359f, -0.01601552f, 0.02639256f, -0.02881990f, 0.01330811f, 0.01464420f, 0.01785602f, 0.01330385f, 
    -0.04228408f, 0.02016566f, 0.01821586f, 0.01577380f, -0.02576695f, -0.00482852f, -0.03967895f, -0.00636881f, 
    -0.02122600f, -0.01642566f, -0.02900246f, 0.00022084f, -0.00621769f, 0.00762129f, -0.02289022f, -0.00202483f, 
    -0.01671108f, -0.03956913f, -0.02322945f, -0.01863721f, 0.02586842f, -0.03797656f, -0.02605858f, -0.03258019f, 
    -0.03925706f, -0.02412008f, 0.00391552f, -0.02735699f, 0.00853151f, -0.03238963f, -0.03210206f, 0.01819447f, 
    -0.02151505f, -0.03243728f, -0.04123186f, -0.00602870f, 0.01834977f, -0.00299189f, -0.02405800f, -0.02278549f, 
    -0.01786794f, 0.01169024f, 0.00622533f, 0.01854459f, 0.00183230f, -0.02719744f, 0.01901249f, 0.02325638f, 
    -0.00716239f, -0.01860710f, 0.01055480f, -0.03805885f, -0.02293191f, 0.00836905f, -0.01577132f, -0.00119170f, 
    -0.02223719f, -0.00019692f, 0.02353569f, -0.00028665f, -0.03516018f, 0.01232753f, -0.01759985f, 0.01330578f, 
    -0.00872583f, 0.02754864f, 0.01461646f, 0.02625895f, 0.00537978f, -0.01771876f, -0.03294027f, 0.02436627f, 
    0.00992761f, -0.00894077f, 0.01426135f, -0.02912824f, 0.00779529f, -0.01634135f, -0.01981330f, -0.00159474f, 
    -0.02868615f, -0.03328303f, 0.00973305f, -0.03061241f, 0.01558725f, 0.01261445f, 0.00020083f, -0.01120284f, 
    0.00252380f, 0.00283100f, 0.01999556f, 0.02437314f, -0.04133981f, -0.01820665f, 0.02789471f, 0.02677729f, 
    -0.01190577f, 0.00457781f, 0.01634332f, 0.00149742f, -0.04082907f, -0.02833944f, 0.01210315f, 0.02588315f, 
    0.01590125f, 0.02249772f, -0.01893299f, -0.03213918f, 0.02494497f, -0.02882139f, 0.01409530f, -0.03262281f, 
    0.01431705f, -0.03289248f, -0.02647738f, -0.02788481f, -0.02380039f, -0.02409919f, -0.01802211f, -0.03835656f, 
    -0.00675998f, 0.02255397f, 0.00965180f, 0.02573090f, -0.04354547f, 0.01612530f, 0.02047542f, -0.00694983f, 
    -0.00921575f, -0.03261359f, 0.00832566f, -0.03234341f, 0.03037756f, -0.00865587f, 0.02357142f, 0.00273572f, 
    0.00887420f, -0.00681209f, -0.02504832f, 0.00956233f, -0.01657626f, 0.01009258f, -0.01309240f, 0.00067959f, 
    -0.03083902f, 0.00294528f, 0.03017779f, -0.02703415f, -0.01212825f, -0.02237215f, -0.03193352f, 0.02126532f, 
    -0.03847113f, -0.00389174f, 0.00125370f, -0.03868622f, -0.04219847f, -0.03505056f, 0.01588303f, 0.01614998f, 
    -0.02747908f, 0.01055659f, -0.02706915f, -0.01180707f, -0.00977322f, 0.02125680f, -0.00777634f, -0.03965100f, 
    -0.01142993f, 0.00105109f, 0.02898270f, -0.02668759f, -0.02221979f, -0.03517851f, 0.01654260f, 0.00272688f, 
    0.01104038f, -0.01509415f, 0.02116764f, -0.02927939f, -0.04171021f, -0.02031535f, -0.00544140f, -0.00071858f, 
    -0.03720266f, 0.00120973f, -0.01105039f, -0.02150354f, 0.00238215f, 0.00463714f, 0.01221605f, -0.02630031f, 
    -0.01740912f, 0.00497006f, -0.04352688f, 0.02606552f, -0.02114127f, -0.01157578f, -0.01704113f, -0.03955631f, 
    -0.01605535f, -0.02113483f, -0.00658127f, -0.03237546f, 0.01483719f, -0.02311497f, 0.02021268f, 0.00369332f, 
    0.01963424f, -0.04067532f, -0.03536966f, -0.02073935f, 0.00729672f, -0.02041202f, -0.01269760f, -0.01672059f, 
    -0.01030939f, -0.02809015f, 0.02384411f, 0.01504015f, 0.00841253f, 0.00782077f, -0.01065779f, -0.01553553f, 
    0.01989958f, -0.00360662f, 0.01197571f, -0.04193176f, -0.01037683f, 0.02690170f, -0.02127967f, 0.00971702f, 
    -0.03576710f, -0.01298817f, 0.03095682f, -0.03149790f, 0.00634126f, -0.00553245f, 0.00329583f, 0.02618170f, 
    -0.00010635f, -0.02126848f, -0.02744300f, 0.00195610f, 0.02048437f, -0.03021447f, -0.03188509f, -0.04287578f, 
    0.00150558f, -0.00746600f, 0.01004587f, -0.01667990f, 0.01863570f, -0.03049406f, -0.04162955f, -0.03670732f, 
    -0.00471360f, -0.02793330f, -0.03245291f, 0.00408476f, 0.00639782f, -0.03467742f, -0.01760770f, 0.00328494f, 
    0.00622579f, 0.01529384f, -0.03716679f, 0.00814920f, 0.02807151f, -0.03553027f, -0.00471462f, 0.02967711f, 
    0.02125464f, -0.04391329f, -0.00773320f, -0.02957830f, -0.01765326f, 0.03446007f, -0.03467499f, 0.02247388f, 
    -0.00262302f, -0.02053227f, -0.00125727f, -0.02227640f, -0.01539609f, 0.00137759f, 0.02183903f, -0.03756316f, 
    -0.04268340f, 0.01134323f, 0.00421381f, -0.02405470f, 0.02054686f, -0.01685581f, 0.02770284f, -0.00531091f, 
    -0.01101534f, -0.02538064f, -0.01530011f, -0.00426985f, -0.03395098f, 0.02073621f, -0.00159055f, 0.00054735f, 
    -0.03559354f, -0.00517293f, 0.00058137f, -0.03799848f, 0.01950230f, -0.02718332f, -0.00103807f, 0.00170835f, 
    -0.02027930f, 0.00068413f, -0.01931700f, -0.02676119f, -0.00276388f, 0.01221700f, 0.02265680f, 0.02474484f, 
    0.00971495f, -0.01513317f, -0.00716573f, -0.00202366f, 0.01973483f, -0.00198876f, 0.01940704f, -0.00967747f, 
    0.00936205f, 0.00671686f, -0.01891032f, -0.00613885f, -0.01418526f, -0.03206483f, 0.00375488f, 0.00639360f, 
    -0.01501083f, 0.02091294f, 0.02702378f, -0.03341583f, 0.01103965f, 0.02830041f, 0.01856539f, 0.00422631f, 
    0.02560371f, -0.01389329f, -0.01833643f, -0.02653341f, -0.00229588f, -0.01303974f, -0.02455582f, -0.01212975f, 
    0.02510688f, 0.00567620f, 0.00801956f, 0.00438791f, -0.01301044f, -0.03292195f, -0.00739161f, -0.03043169f, 
    -0.02928487f, -0.02018180f, -0.00228636f, -0.02689102f, -0.00237490f, -0.01283637f, -0.03231750f, -0.00552049f, 
    -0.03609767f, -0.02247545f, -0.02089006f, 0.00298677f, -0.02086541f, 0.01626150f, 0.00340886f, -0.02306314f, 
    -0.00233341f, -0.02537815f, -0.00379441f, -0.02513967f, -0.00845452f, 0.02167575f, 0.00009786f, -0.02254550f, 
    -0.00795103f, -0.03328906f, 0.01047108f, -0.01438038f, 0.02655111f, -0.03849472f, -0.03403511f, -0.03309115f, 
    -0.02676548f, -0.00440680f, -0.02385742f, -0.03918033f, 0.02006011f, 0.00074195f, 0.00395554f, -0.03585400f, 
    -0.00944230f, -0.03611941f, 0.01547684f, 0.00676745f, 0.00455608f, -0.03697360f, 0.00811506f, -0.00705741f, 
    -0.00780310f, 0.02556426f, -0.00759972f, -0.03548200f, 0.00510121f, -0.02713974f, 0.02190936f, -0.01650708f, 
    -0.00757922f, -0.03521496f, -0.02199546f, -0.03647701f, -0.04260440f, -0.00679508f, -0.01476089f, -0.00911374f, 
    0.00134649f, 0.02003993f, 0.01295933f, -0.00651730f, -0.00207418f, 0.02271573f, -0.02278720f, 0.02455836f, 
    0.00731379f, 0.00932037f, 0.00437401f, 0.02824095f, 0.02070980f, -0.00141235f, 0.02129775f, 0.01123854f, 
    0.02897189f, 0.00836448f, -0.03163785f, 0.01252166f, 0.02518986f, -0.00626177f, -0.00478062f, -0.04435939f, 
    -0.02667451f, -0.01993036f, -0.04460244f, -0.02803946f, -0.04085902f, -0.02258428f, -0.03564216f, -0.02470974f, 
    0.00996212f, -0.01812137f, -0.04226496f, -0.03370514f, -0.01150417f, -0.01469718f, -0.00342922f, -0.01788597f, 
    -0.00927234f, 0.02473215f, 0.00084695f, 0.01163823f, 0.00347362f, 0.02229579f, -0.03908501f, -0.00349566f, 
    -0.03083741f, -0.01034862f, -0.01094199f, 0.00010910f, 0.00056442f, 0.02601247f, -0.00768310f, -0.03842251f, 
    -0.00355532f, -0.02315676f, -0.01629775f, 0.01239623f, -0.03538149f, -0.02956749f, -0.01773582f, 0.01315551f, 
    0.00523632f, 0.01127557f, 0.03193914f, -0.03610207f, -0.02145314f, 0.00353540f, 0.00557867f, 0.02537535f, 
    0.00170061f, 0.01331586f, 0.02871894f, 0.02152417f, 0.04292386f, 0.00329061f, -0.03388134f, 0.02953301f, 
    -0.00736014f, -0.01371039f, 0.00870586f, 0.00642504f, -0.03446640f, -0.02257327f, 0.02085196f, -0.03320841f, 
    0.02021466f, -0.00630445f, -0.04153653f, -0.01205514f, -0.01516565f, -0.02749182f, -0.03274204f, 0.01787207f, 
    -0.03982770f, 0.00947228f, 0.01940391f, -0.00642166f, 0.02355032f, -0.03060388f, -0.04133731f, 0.00695758f, 
    0.03022455f, -0.01108202f, -0.00615730f, -0.01554472f, -0.02367850f, 0.00689961f, -0.04308286f, 0.00784942f, 
    -0.00631298f, 0.02082889f, 0.01295963f, -0.00338024f, 0.01268469f, 0.01121926f, 0.00941458f, 0.02630217f, 
    0.00352611f, -0.00318741f, 0.01070625f, -0.03541749f, -0.00249638f, -0.00033113f, -0.00603993f, 0.00480617f, 
    -0.01353891f, 0.00751092f, -0.03994138f, -0.03547544f, 0.02309254f, 0.01983345f, -0.00222262f, -0.00785018f, 
    0.01345266f, -0.01727989f, -0.01448122f, -0.01754649f, 0.02657784f, -0.01632583f, -0.00284664f, -0.01002406f, 
    0.00412929f, 0.01478820f, -0.00600264f, 0.01603532f, -0.03229994f, -0.03825540f, -0.01463652f, 0.01650297f, 
    -0.00694972f, -0.02903632f, -0.04364099f, 0.01312179f, 0.02466385f, 0.00661654f, -0.01205443f, -0.01715819f, 
    0.02686071f, -0.00944135f, -0.04116337f, 0.01343023f, 0.00118713f, -0.00762742f, 0.01236212f, 0.01885584f, 
    -0.01343351f, -0.03827631f, -0.01714350f, 0.00199523f, -0.00339637f, 0.01174599f, 0.02626488f, -0.03206887f, 
    -0.00424697f, -0.03178215f, -0.01348702f, 0.02760498f, 0.03074834f, -0.00134321f, -0.00669396f, -0.02182921f, 
    -0.02504728f, 0.02061766f, -0.02819325f, 0.00940619f, 0.01898288f, 0.01880790f, -0.02234959f, -0.03175946f, 
    -0.00092977f, 0.02689770f, -0.00868100f, -0.03752431f, 0.00510534f, 0.00581638f, -0.01924915f, 0.02787596f, 
    -0.00375229f, -0.02376973f, 0.02688333f, 0.03798873f, -0.02176472f, -0.03734197f, 0.02413307f, -0.00382317f, 
    0.01886911f, -0.00189943f, 0.02165838f, 0.02321850f, 0.01769258f, -0.03582187f, -0.04221802f, -0.01999052f, 
    -0.00100746f, -0.03739135f, 0.01917007f, -0.02447594f, -0.00919920f, -0.00429237f, -0.01336972f, -0.03395410f, 
    -0.00995259f, 0.02138755f, -0.00716483f, -0.03615603f, 0.00114478f, -0.00323294f, -0.03378036f, -0.01400208f, 
    0.02361616f, -0.00983019f, -0.01209404f, 0.02317285f, -0.01236245f, 0.02667807f, 0.01107281f, -0.02833075f, 
    -0.03948322f, -0.00137700f, -0.01683990f, 0.02494040f, 0.00231534f, -0.02475940f, 0.00407031f, 0.00490675f, 
    0.01523820f, -0.02032694f, -0.02770939f, -0.04151681f, 0.00157759f, 0.02660294f, 0.02031670f, 0.02708446f, 
    -0.01087080f, -0.00129454f, -0.00359670f, -0.00492581f, -0.03881182f, 0.01195335f, -0.01924545f, 0.02937106f, 
    0.00095401f, 0.00087023f, 0.01438786f, -0.00979866f, 0.01852821f, -0.00342366f, 0.02198751f, -0.01042858f, 
    0.01139117f, -0.03434910f, 0.01677985f, 0.02308012f, -0.03832417f, 0.00464705f, -0.01532744f, -0.02806957f, 
    0.02591518f, -0.02726591f, -0.03966415f, -0.03450048f, 0.03383178f, -0.01654620f, 0.01053443f, 0.02419214f, 
    -0.03702931f, -0.02768419f, 0.02518667f, -0.01762371f, -0.01565815f, 0.00944108f, 0.00007775f, -0.04013176f, 
    0.00058046f, 0.00772901f, 0.01606393f, -0.04126889f, -0.02772224f, -0.02885196f, -0.00794765f, 0.00845815f, 
    -0.01127278f, -0.02125381f, -0.00043006f, -0.03261298f, -0.02615687f, 0.01558349f, 0.03111470f, -0.02209550f, 
    0.01646143f, 0.00306864f, -0.02756630f, 0.01190494f, 0.00619609f, 0.00763755f, 0.00978373f, 0.00940385f, 
    -0.01066395f, 0.00925047f, -0.02100811f, -0.00479882f, 0.02587270f, 0.02204578f, -0.03835057f, 0.02033590f, 
    0.00582007f, -0.02516485f, -0.01658973f, 0.00462480f, 0.02796981f, -0.04125671f, 0.01069752f, 0.00962843f, 
    0.00840489f, 0.01077324f, -0.03398692f, 0.01602882f, -0.02319702f, 0.01392383f, -0.01082477f, 0.02470510f, 
    -0.01867334f, -0.00927628f, 0.00989967f, -0.00510645f, -0.02012012f, -0.04504550f, -0.00624746f, -0.02558698f, 
    -0.03816704f, 0.02617368f, -0.00933663f, -0.02343528f, -0.02283165f, -0.00940596f, 0.00492732f, -0.02353957f, 
    0.02715409f, 0.03853681f, -0.03361723f, 0.00204227f, -0.01277611f, -0.00116274f, 0.00377371f, -0.03706771f, 
    -0.00091016f, -0.02928454f, 0.01188986f, -0.01751273f, -0.02180315f, 0.00749981f, -0.01924353f, 0.03480099f, 
    -0.01690556f, -0.03954567f, 0.01204640f, 0.00162991f, 0.01168638f, -0.01092359f, -0.03792979f, -0.02999993f, 
    -0.01774532f, 0.00733256f, 0.01924844f, 0.00802656f, -0.03144505f, -0.02552800f, -0.01526260f, -0.00239746f, 
    -0.02393409f, 0.02444499f, 0.01275818f, -0.01915453f, 0.02256338f, 0.00510597f, -0.03991961f, 0.01633753f, 
    0.00241345f, -0.02045472f, -0.00921229f, -0.03798866f, -0.00837416f, 0.01901811f, 0.00812512f, -0.03646781f, 
    -0.01060142f, -0.02883760f, 0.02713086f, 0.01649002f, -0.00449360f, 0.02486273f, -0.00937054f, -0.01307553f, 
    -0.02153030f, -0.02583497f, 0.02662383f, 0.00757363f, -0.00137993f, -0.00241150f, -0.02491805f, -0.01987762f, 
    0.00248754f, 0.00909104f, -0.03115799f, 0.00191466f, 0.02507729f, 0.01052112f, -0.00925056f, -0.00177657f, 
    -0.03815747f, 0.01266215f, -0.02147788f, 0.00601748f, -0.01214700f, -0.01575986f, 0.02522556f, -0.01544384f, 
    0.02543240f, -0.02008413f, -0.00270080f, 0.03090641f, 0.02390619f, 0.01599738f, -0.00784526f, -0.00952754f, 
    0.02131938f, 0.01864136f, 0.00976971f, -0.03655101f, 0.02095677f, 0.00447155f, 0.00592390f, 0.01056095f, 
    0.00032970f, -0.00446359f, -0.01091439f, 0.00860259f, 0.00969116f, -0.03195954f, 0.00778175f, -0.03985573f, 
    0.01424797f, -0.00969026f, 0.00686369f, -0.03075401f, -0.01157968f, -0.00708727f, 0.01918167f, 0.00705270f, 
    0.02697514f, -0.01153053f, 0.02895944f, -0.02846754f, 0.03872055f, 0.02298939f, 0.01972470f, 0.00530408f, 
    0.00695617f, 0.01827714f, 0.01110983f, 0.01017439f, -0.03950391f, 0.00513214f, -0.02015593f, -0.01880596f, 
    -0.03258297f, 0.02725417f, -0.02030994f, -0.02256514f, -0.01246632f, 0.03001799f, -0.03920783f, 0.04657358f, 
    -0.04174783f, -0.01417740f, -0.03992180f, -0.01919567f, -0.00820017f, -0.03503415f, -0.01755692f, -0.00995696f, 
    -0.00461166f, 0.02399711f, 0.02361097f, -0.00391822f, -0.03668639f, 0.00479138f, 0.01764392f, -0.00610648f, 
    -0.00867889f, -0.01708865f, 0.02408452f, 0.01699344f, -0.01453153f, -0.02442029f, -0.01947163f, 0.01479179f, 
    0.02930048f, 0.00038208f, 0.00090855f, -0.02055830f, 0.02825845f, -0.00851371f, 0.01914023f, -0.02361537f, 
    -0.01010591f, -0.03104335f, -0.02527743f, -0.00320736f, -0.02874698f, 0.00679884f, -0.04212970f, 0.02264876f, 
    0.02434318f, -0.02327967f, -0.03582699f, 0.02197771f, 0.02647409f, 0.00486317f, 0.02867123f, -0.00351441f, 
    -0.02736416f, -0.00140716f, -0.01330718f, 0.01428565f, 0.02809987f, 0.00245866f, -0.03573591f, -0.03834375f, 
    0.01068972f, -0.01504649f, 0.02648403f, -0.02663534f, 0.02479779f, 0.02488109f, -0.01610401f, 0.02993972f, 
    -0.00193466f, -0.01026798f, 0.01269480f, 0.02685553f, 0.00861434f, 0.01062171f, -0.03536459f, 0.02650979f, 
    -0.03339488f, 0.02685011f, 0.02020962f, -0.01359294f, -0.02400133f, -0.03159405f, -0.02259756f, -0.02994016f, 
    0.00028462f, -0.01837873f, 0.04376446f, -0.00572378f, 0.00373408f, -0.02988824f, -0.00831626f, -0.04074094f, 
    -0.03175405f, -0.00390845f, -0.02750563f, 0.00512370f, 0.02176283f, 0.01717535f, -0.00666300f, -0.02571686f, 
    0.03520514f, -0.02068326f, 0.03026309f, -0.01352900f, -0.00071320f, -0.00343641f, -0.00244181f, -0.03139056f, 
    -0.02383130f, 0.00494304f, -0.02550402f, -0.03631819f, -0.03026060f, -0.02689423f, -0.03216083f, -0.01577941f, 
    0.02053101f, -0.01312501f, -0.02921478f, 0.02650629f, -0.03775934f, -0.03198421f, -0.01113292f, 0.01282711f, 
    -0.03312090f, -0.03668518f, 0.00322068f, -0.01422557f, -0.00316764f, 0.00843028f, 0.00789500f, -0.03207231f, 
    0.00103653f, 0.02082666f, 0.02796577f, -0.01027233f, 0.02920616f, -0.00716896f, -0.04267620f, -0.01505955f, 
    0.00426915f, -0.02345883f, -0.00891233f, 0.00277096f, -0.03163390f, -0.01357688f, 0.03042846f, -0.01674643f, 
    -0.03938027f, 0.00370793f, -0.03208157f, 0.00635173f, -0.00221037f, 0.01804285f, 0.00777507f, -0.02874061f, 
    0.00548720f, -0.02074801f, -0.03482810f, -0.02336131f, 0.01492693f, -0.02434051f, -0.03759095f, -0.00756408f, 
    -0.01435342f, -0.03337099f, -0.00326295f, -0.03197714f, 0.01495958f, 0.03568386f, 0.02031415f, -0.00804059f, 
    0.00930326f, -0.03332577f, 0.03062143f, 0.02781204f, 0.00038634f, 0.00652266f, -0.03309026f, -0.03584566f, 
    -0.00383148f, 0.02260217f, -0.01805186f, 0.00506018f, 0.02832172f, 0.02658049f, 0.02031963f, -0.01613819f, 
    0.03361762f, -0.03741590f, -0.00836216f, -0.03266487f, -0.00142011f, 0.00268363f, -0.00374802f, -0.02863922f, 
    0.02779463f, 0.01470472f, 0.01674468f, -0.03683859f, -0.03962031f, -0.01031115f, -0.02939628f, 0.02912605f, 
    0.02115145f, 0.01589325f, -0.03780488f, -0.00247060f, -0.01894902f, -0.00988997f, 0.02079595f, -0.02695120f, 
    0.02014765f, -0.01849882f, -0.01039076f, 0.02758844f, 0.02971831f, -0.02209306f, 0.01046497f, -0.02491723f, 
    -0.01068897f, -0.00119205f, 0.01590355f, -0.03900565f, 0.01774758f, -0.03524034f, 0.02379631f, -0.00627413f, 
    -0.01891929f, -0.00728992f, -0.00227780f, -0.00923177f, -0.02659596f, 0.01180438f, 0.03047117f, -0.03826212f, 
    0.01036941f, 0.02596294f, -0.03881076f, 0.02282691f, 0.00078444f, -0.03997270f, -0.02001150f, -0.04162205f, 
    0.02293146f, 0.00580303f, 0.01165609f, 0.00625516f, -0.00804532f, -0.00633421f, -0.02661743f, -0.00565127f, 
    -0.01005061f, -0.00469315f, -0.01306930f, -0.01761202f, -0.00660003f, 0.02067596f, -0.03116660f, 0.02134349f, 
    0.03689272f, 0.01032327f, 0.02585983f, -0.04241993f, -0.01895858f, -0.02435140f, -0.01563911f, 0.02263184f, 
    -0.00861519f, -0.03248690f, 0.01955208f, 0.01721616f, 0.00384081f, -0.00843921f, 0.01595438f, 0.02267208f, 
    -0.02166354f, 0.02876169f, -0.02320225f, 0.02365981f, -0.03203666f, -0.01362853f, -0.02756686f, -0.01757419f, 
    0.00315053f, -0.03595136f, 0.02175956f, -0.03757104f, 0.02106221f, 0.03256373f, -0.00608900f, -0.00550082f, 
    -0.03558754f, -0.02737355f, -0.02023201f, -0.01912457f, -0.01700520f, -0.03093696f, -0.00216172f, -0.02972052f, 
    -0.00727064f, -0.02487649f, -0.01653909f, -0.00172807f, 0.01974331f, -0.02579600f, -0.03517121f, -0.02581329f, 
    0.01371085f, -0.02053954f, 0.00073278f, -0.03110586f, -0.01792245f, -0.00391317f, 0.00026760f, 0.02185794f, 
    -0.02446169f, 0.00431227f, 0.01016496f, -0.01181938f, -0.00676611f, -0.01674333f, 0.00173926f, -0.02274601f, 
    -0.04085312f, -0.01223379f, -0.01557747f, -0.04109487f, 0.02473456f, -0.00842230f, -0.00904573f, -0.00908019f, 
    0.01391826f, -0.02073631f, -0.00920635f, 0.02541682f, 0.01729112f, 0.02394971f, 0.02806209f, -0.02002884f, 
    0.01496993f, -0.02742548f, -0.01783360f, -0.00054864f, 0.04038871f, -0.01210069f, -0.01569171f, -0.01940215f, 
    0.00266289f, -0.03498219f, -0.03448462f, -0.03106451f, -0.03593927f, 0.02498876f, -0.03006141f, 0.01550151f, 
    0.00219657f, -0.02186304f, -0.00786346f, 0.02388915f, 0.02239011f, 0.00313287f, 0.02987543f, -0.02611354f, 
    -0.01898570f, 0.02369181f, -0.01919269f, -0.03893734f, 0.00801036f, -0.00149852f, -0.00583125f, 0.00612918f, 
    0.00212428f, -0.02802959f, -0.02227621f, 0.01262934f, 0.01107533f, 0.00997115f, -0.02509553f, -0.03358897f, 
    -0.01118206f, 0.03799667f, 0.01752004f, 0.01892941f, -0.01698640f, -0.03027918f, -0.00028715f, -0.02993369f, 
    -0.01310872f, -0.02014255f, -0.00916323f, -0.03258378f, 0.03249315f, -0.01810520f, -0.01472676f, -0.00819877f, 
    0.01152728f, -0.01594423f, -0.00791910f, 0.02019961f, -0.03234865f, -0.01923980f, -0.03349123f, -0.02772534f, 
    -0.00462760f, -0.01330884f, -0.03687629f, 0.00625629f, 0.02900730f, 0.02176683f, 0.03618026f, -0.03727508f, 
    -0.02217407f, 0.01769120f, -0.02897168f, -0.02345062f, -0.01115069f, -0.02842431f, 0.01992495f, -0.01964044f, 
    0.00606164f, -0.02811129f, 0.02335710f, 0.02672639f, 0.00655918f, -0.01833618f, -0.02416241f, 0.01743614f, 
    -0.01731536f, 0.00796197f, 0.00750515f, 0.00319889f, -0.00919793f, -0.00904922f, -0.02819418f, -0.02022425f, 
    0.00196174f, 0.00514578f, 0.04003208f, 0.01661429f, -0.01376600f, -0.02821605f, -0.02508423f, -0.01069313f, 
    -0.01894887f, 0.00866330f, -0.02678582f, -0.01507379f, -0.00432419f, -0.00432146f, -0.03565174f, -0.01866380f, 
    -0.01853107f, 0.00554896f, -0.03055918f, -0.03349401f, 0.02150846f, -0.01939308f, 0.02460998f, 0.01279527f, 
    -0.03551315f, -0.03683174f, -0.03497161f, -0.01372837f, -0.02689923f, 0.00548151f, 0.00716326f, 0.00291037f, 
    0.02689545f, 0.01830960f, -0.02000665f, -0.03103263f, 0.01790035f, -0.00478703f, 0.01360953f, 0.01774783f, 
    0.01273844f, 0.02465439f, -0.03775829f, 0.01112967f, 0.00506845f, 0.02754539f, -0.02148127f, -0.02876041f, 
    -0.00221632f, -0.03016520f, 0.02909526f, -0.00387637f, 0.02521680f, -0.03563975f, 0.02933794f, -0.03003477f, 
    0.02485490f, 0.01537834f, -0.00231593f, 0.02648328f, -0.03511878f, -0.00781047f, 0.02109816f, -0.03437978f, 
    0.00748024f, -0.03754342f, -0.00960565f, 0.00258657f, -0.03004370f, 0.02162359f, 0.00237770f, -0.01129359f, 
    0.02356594f, -0.04201274f, 0.00284604f, -0.02372714f, -0.02409081f, -0.00507059f, 0.03178817f, 0.00844729f, 
    -0.01502410f, -0.03862157f, 0.02945418f, -0.00122795f, -0.00150398f, -0.02521524f, -0.00323997f, 0.01217214f, 
    -0.02350821f, 0.03153313f, 0.01103321f, -0.02782856f, 0.00706991f, -0.01230153f, -0.00483804f, -0.01602845f, 
    0.00042343f, 0.00762676f, -0.02415220f, -0.04026945f, -0.00343590f, 0.02824946f, -0.00355531f, -0.01458769f, 
    -0.00002662f, 0.02331724f, 0.00672501f, -0.00175938f, 0.00448329f, -0.00729530f, -0.02109637f, -0.00668188f, 
    -0.01325873f, -0.03232482f, -0.03158670f, -0.01292973f, -0.00008100f, -0.03764468f, 0.00963421f, -0.01996210f, 
    -0.02475775f, -0.02853289f, 0.00363793f, -0.02893429f, 0.02441112f, -0.03286004f, 0.00436801f, 0.01014131f, 
    -0.03806150f, 0.02400558f, -0.03602388f, -0.01876880f, 0.00098337f, -0.00017776f, 0.01322595f, 0.00923495f, 
    0.00050491f, -0.02504246f, 0.02524678f, 0.02808840f, -0.03980703f, -0.02658925f, 0.00555383f, -0.01452193f, 
    0.00133635f, -0.04008953f, -0.02955738f, 0.03017454f, -0.01812867f, -0.01029917f, 0.01631031f, -0.03549610f, 
    -0.03322499f, -0.01065126f, -0.03819681f, 0.01278775f, -0.01487709f, -0.03177219f, 0.02384150f, -0.02178061f, 
    0.02525462f, -0.00749456f, -0.00166402f, -0.02147088f, -0.03226227f, -0.02812434f, 0.02163170f, 0.00598340f, 
    -0.00994919f, -0.01529599f, -0.01851550f, -0.01207541f, 0.00072371f, -0.01954120f, -0.03427093f, 0.01919620f, 
    -0.00525467f, -0.02201237f, 0.00040143f, -0.01955009f, -0.03563635f, -0.01428868f, 0.01162860f, 0.00132293f, 
    -0.02244119f, 0.01590359f, -0.03354700f, -0.00768478f, -0.03445353f, -0.03247554f, 0.01280626f, 0.02143862f, 
    0.02220601f, -0.00021268f, 0.00496683f, -0.00924871f, 0.01325016f, 0.02788017f, 0.00924867f, 0.00547785f, 
    -0.02220567f, 0.02772295f, 0.01887907f, 0.01067464f, 0.02221843f, 0.02349424f, 0.00860137f, 0.03550620f, 
    0.00341884f, 0.00287903f, 0.00081508f, 0.01764704f, -0.02474528f, -0.01851309f, 0.02322196f, 0.02704471f, 
    -0.04013693f, -0.00337699f, 0.01531223f, 0.01851968f, 0.02510711f, -0.01838192f, 0.00474421f, -0.03388268f, 
    0.01335066f, 0.02525907f, -0.00180427f, -0.01651816f, 0.00847275f, -0.00644084f, 0.01179499f, 0.00326892f, 
    0.00607665f, -0.02309896f, 0.00187867f, 0.02379782f, -0.02686158f, 0.01918235f, -0.03866157f, -0.02645491f, 
    0.01636239f, 0.01691790f, 0.01593139f, -0.03382142f, -0.01578061f, -0.04066549f, -0.03891542f, -0.00894389f, 
    -0.01533752f, 0.02940269f, -0.02750634f, 0.01014323f, -0.01149793f, -0.01862994f, -0.01067080f, 0.00306843f, 
    -0.02877746f, 0.03510723f, 0.03157423f, 0.00088977f, -0.02653320f, -0.00717373f, -0.00957344f, 0.01766691f, 
    -0.01259442f, 0.00369049f, 0.02118554f, -0.04054436f, -0.00014580f, 0.01025135f, 0.00317993f, 0.00856463f, 
    0.03943267f, 0.00718203f, 0.00356633f, -0.00229163f, -0.03554281f, -0.01247868f, -0.02958424f, -0.03727651f, 
    -0.03521348f, 0.00516343f, 0.01039900f, 0.01259666f, 0.01788984f, 0.02075096f, -0.01118707f, -0.03142390f, 
    0.01118051f, -0.01044861f, 0.01943050f, -0.04077256f, 0.01279716f, -0.02443547f, -0.03283713f, 0.02676954f, 
    0.02263204f, 0.00536636f, -0.01112403f, 0.00808914f, -0.03628325f, -0.00292635f, -0.00612801f, -0.03305017f, 
    -0.02919710f, 0.00561346f, -0.03413327f, 0.00187325f, -0.00620087f, 0.01793967f, -0.02650783f, 0.00275672f, 
    0.02612797f, -0.00751034f, 0.00175559f, 0.01259381f, 0.02408041f, 0.00425474f, -0.01671252f, 0.02322182f, 
    -0.03957934f, 0.01439478f, 0.03514851f, 0.02799363f, 0.02112422f, -0.04077652f, 0.00080524f, -0.02733836f, 
    -0.01027419f, -0.01896205f, 0.02386468f, 0.00366160f, 0.02018283f, -0.03539681f, -0.01746302f, 0.02483150f, 
    -0.01848512f, -0.00668404f, 0.02010276f, -0.02254359f, 0.03019344f, -0.00433530f, 0.00369324f, -0.03546287f, 
    -0.01077392f, -0.02592024f, 0.02353650f, -0.03274304f, -0.01120438f, 0.00630859f, 0.02722335f, -0.01382563f, 
    -0.04165107f, 0.00980760f, -0.01067494f, 0.02505438f, -0.02413711f, -0.02371519f, -0.03187907f, -0.02143407f, 
    -0.00022727f, -0.00320830f, -0.02816491f, 0.00135469f, 0.02456575f, -0.00523501f, -0.02051449f, -0.01178509f, 
    0.00958086f, 0.02527017f, 0.01464948f, -0.03709938f, 0.01368033f, -0.02249947f, -0.02600442f, -0.02721607f, 
    0.02766101f, -0.00921340f, -0.03070256f, -0.01723237f, -0.02079828f, 0.01200124f, 0.01722686f, -0.02540606f, 
    0.02035746f, -0.00110593f, 0.02982931f, -0.02741760f, -0.00311072f, -0.03101540f, -0.00895467f, -0.00852561f, 
    -0.01166779f, 0.01545809f, -0.01132619f, -0.03098913f, -0.03487185f, -0.02942152f, -0.01315543f, 0.01779687f, 
    -0.01140331f, 0.02117687f, 0.00011591f, 0.01790804f, -0.03579598f, -0.01071033f, -0.02958329f, -0.01198103f, 
    -0.03639292f, -0.00847280f, -0.01423175f, 0.00150796f, 0.00719808f, -0.01124253f, 0.02800830f, -0.01134913f, 
    -0.01846295f, 0.02977888f, 0.01415928f, -0.03881133f, 0.02052657f, 0.02305355f, 0.01061483f, -0.03349017f, 
    -0.02666430f, 0.02355454f, 0.00548265f, 0.01871429f, 0.01582000f, 0.00462352f, 0.00003295f, 0.02364727f, 
    0.00301168f, 0.02112144f, 0.01807383f, 0.00678822f, 0.02988754f, -0.00584303f, 0.02436808f, 0.01876035f, 
    0.02408361f, -0.03646948f, 0.02842068f, -0.03899498f, -0.03182376f, 0.01637989f, -0.00997070f, -0.00146318f, 
    -0.04009086f, -0.01305962f, 0.00178984f, -0.01006525f, 0.03047828f, 0.02631818f, 0.01751168f, 0.00149741f, 
    0.02814330f, -0.02293306f, -0.00543511f, -0.01473601f, 0.00228421f, 0.00935250f, -0.00775373f, -0.02403887f, 
    0.01037055f, 0.01109732f, -0.03643150f, -0.03357419f, -0.01210605f, -0.00167719f, -0.01577987f, -0.01761719f, 
    -0.02113565f, -0.01399296f, -0.01308735f, -0.01665530f, 0.01094260f, 0.02582934f, 0.02839673f, 0.00714772f, 
    -0.03060920f, -0.00993516f, 0.03098118f, -0.01665410f, -0.03910460f, 0.00870400f, -0.01723574f, 0.00092239f, 
    0.01744805f, 0.00282360f, -0.02005526f, -0.01169783f, -0.03340798f, -0.03008638f, -0.00561727f, -0.03347105f, 
    -0.03563427f, -0.01480846f, 0.00454684f, -0.01871224f, -0.01422267f, 0.03105882f, -0.01269306f, -0.02236187f, 
    -0.03952827f, 0.00421097f, 0.00954708f, 0.02383140f, -0.02027365f, 0.02966525f, -0.03298161f, -0.02344081f, 
    0.02715283f, 0.02109184f, 0.01153318f, 0.02126807f, 0.01648398f, 0.00814280f, 0.02822884f, -0.02370946f, 
    -0.04102933f, -0.02380011f, -0.03696771f, -0.02928736f, -0.02325901f, -0.01453659f, -0.00874215f, -0.02145857f, 
    0.02690413f, 0.01415902f, -0.01216304f, 0.02037554f, -0.00863468f, 0.00155250f, -0.03900280f, 0.01284738f, 
    -0.00706075f, 0.01785113f, 0.01383777f, -0.04007819f, -0.01168094f, 0.03140000f, -0.00182578f, -0.00557423f, 
    -0.02835978f, -0.02740547f, -0.01906641f, -0.01764709f, -0.02789287f, -0.00651894f, -0.03774625f, 0.02569405f, 
    -0.02199475f, -0.02482704f, -0.02927150f, -0.01457621f, 0.00313166f, -0.01220689f, -0.02098435f, 0.02484875f, 
    0.02944435f, 0.01488874f, -0.00417363f, -0.02096163f, -0.02071841f, -0.01179948f, -0.02326103f, -0.01987612f, 
    -0.01452944f, -0.03719224f, -0.01146693f, 0.00597316f, -0.03829620f, -0.02983182f, 0.00025232f, 0.00212461f, 
    -0.02488479f, 0.00840795f, -0.03752740f, 0.00553944f, -0.02199861f, 0.02336063f, -0.03083462f, -0.01682460f, 
    0.00654892f, -0.01864899f, -0.01993492f, 0.02660017f, 0.02209705f, -0.00702496f, 0.00455719f, 0.01106176f, 
    0.00232106f, -0.04143926f, -0.01721551f, 0.04081241f, -0.00375784f, 0.01105480f, -0.01675651f, 0.02745321f, 
    0.02101602f, -0.02530218f, -0.03028600f, -0.00069522f, 0.00263876f, 0.00903087f, -0.01210668f, -0.00675485f, 
    -0.03045752f, 0.00440269f, -0.01793562f, 0.02639434f, -0.00754109f, -0.03465580f, 0.00612670f, 0.01514651f, 
    0.03081059f, 0.03294987f, 0.02568248f, -0.02390052f, -0.03933777f, 0.02191152f, -0.01155249f, 0.01656775f, 
    0.00974304f, 0.01801058f, 0.01149599f, -0.00888533f, -0.03789686f, 0.00395421f, -0.01509568f, 0.01866522f, 
    -0.03349574f, 0.02215412f, -0.03907051f, -0.03653767f, 0.02879367f, 0.02984745f, -0.01002954f, -0.03642192f, 
    -0.03189947f, 0.02555436f, 0.02978729f, 0.01743439f, -0.01060587f, -0.00574225f, 0.02992861f, -0.01012608f, 
    -0.00562802f, 0.01153019f, 0.02046247f, 0.02470967f, 0.02264456f, 0.01960571f, 0.02062573f, -0.01326454f, 
    -0.02837767f, -0.02097675f, -0.02477413f, 0.02604415f, -0.02130775f, -0.00528223f, 0.02016087f, -0.03364721f, 
    -0.01850768f, 0.01261540f, -0.03408337f, -0.04122094f, 0.02121519f, 0.02697375f, 0.00042758f, 0.02736960f, 
    0.01325474f, -0.02885209f, -0.01697943f, -0.00361133f, -0.01247792f, 0.02524943f, 0.01873637f, -0.03418089f, 
    -0.03086650f, 0.01056861f, -0.01193248f, 0.02528121f, 0.01409086f, 0.02952261f, -0.00997584f, -0.00221469f, 
    -0.02040100f, -0.00933497f, -0.02641776f, 0.02000482f, 0.02738435f, -0.01622007f, -0.00526498f, -0.04021143f, 
    0.00170951f, -0.00646416f, -0.03207690f, -0.03564186f, 0.00802481f, 0.00180862f, -0.03148691f, 0.02046235f, 
    -0.02723736f, 0.00162739f, -0.02727338f, 0.01196268f, 0.02772833f, -0.01035032f, -0.00368923f, -0.00739135f, 
    -0.01218324f, -0.02417118f, -0.00417470f, 0.01031986f, -0.00097829f, -0.03252514f, 0.00482963f, 0.01993049f, 
    0.01123660f, -0.03332321f, -0.02269967f, 0.00295554f, -0.01083723f, 0.00355846f, -0.03596517f, -0.04060047f, 
    -0.00608553f, -0.03390966f, 0.01168761f, -0.03792523f, -0.00764046f, 0.01690312f, 0.00409313f, -0.00016970f, 
    -0.01639969f, -0.03717572f, -0.02951673f, -0.02316835f, 0.01041806f, -0.03310510f, 0.01060957f, 0.01536503f, 
    -0.05119224f, -0.12740730f, 0.25443083f, 0.09634970f, -0.07473927f, -0.04681290f, -0.10312718f, -0.14625534f, 
    0.05202862f, -0.10555197f, -0.06007278f, -0.10598267f, 0.05403511f, 0.10346715f, -0.14480947f, -0.11930535f, 
    -0.00621192f, -0.00603863f, -0.12066245f, 0.11273128f, -0.00816977f, -0.17210677f, -0.13225211f, 0.00738200f, 
    0.04580926f, 0.19411831f, 0.21301918f, 0.04945710f, -0.10916360f, 0.00876211f, 0.08754408f, -0.07307076f, 
    0.03004956f, -0.04158253f, -0.00256609f, -0.08970001f, 0.12272843f, 0.07822136f, -0.13326930f, -0.09278284f, 
    -0.02003033f, 0.08854453f, -0.09015798f, 0.18005009f, 0.09408732f, -0.15187500f, 0.08858915f, -0.00590437f, 
    -0.19799598f, 0.02754352f, 0.19986521f, -0.12286427f, -0.06213386f, 0.03242041f, 0.16037585f, 0.15340759f, 
    0.13029186f, 0.01782538f, -0.01789610f, -0.11638086f, -0.21777409f, -0.09866970f, -0.06850221f, 0.12574361f, 
    -0.03001497f, 0.07893761f, 0.01814760f, 0.12998664f, 0.00168265f, -0.08943140f, -0.08337786f, -0.00714128f, 
    -0.32924360f, 0.08444267f, -0.12926076f, -0.15187237f, -0.09709488f, 0.01759448f, 0.13927202f, 0.17061414f, 
    0.10314085f, -0.11001591f, 0.07677147f, 0.07599992f, -0.21730770f, 0.05708580f, 0.24346590f, -0.03557121f, 
    -0.06396949f, 0.10829517f, -0.08382824f, -0.15781611f, 0.14435169f, 0.06682300f, 0.11837825f, -0.06474160f, 
    0.40672222f, -0.03117355f, -0.23645274f, -0.12803358f, 0.12208013f, 0.14108357f, 0.15289970f, -0.01632902f, 
    0.03287444f, -0.03903765f, -0.08335914f, 0.05013457f, -0.27640659f, -0.04203103f, -0.10304406f, -0.17893475f, 
    0.01649643f, 0.00603411f, 0.05115990f, -0.05921454f, 0.06185834f, -0.01976344f, 0.03012015f, -0.02026743f, 
    -0.15627137f, 0.13539237f, 0.28523821f, -0.01493232f, 0.09895972f, 0.01699244f, 0.11442362f, 0.04494077f, 
    0.17390843f, 0.12321539f, -0.23781222f, -0.02073481f, 0.35814950f, -0.09715925f, 0.09967118f, 0.16535532f, 
    0.08140486f, 0.00937150f, 0.15476993f, 0.01588302f, -0.02408969f, -0.10062423f, -0.09310827f, -0.08560228f, 
    0.03968316f, 0.00702109f, -0.04504211f, 0.17240982f, 0.03871081f, 0.01960364f, -0.04294418f, 0.08481173f, 
    0.03880229f, -0.02085393f, -0.10098732f, -0.00600580f, -0.11408317f, 0.22442079f, -0.02624205f, -0.13227110f, 
    -0.19380318f, 0.04756792f, 0.05532771f, 0.20503771f, 0.18076921f, -0.05676175f, 0.18787977f, -0.00938258f, 
    -0.16477941f, 0.04654811f, 0.24637181f, -0.11680211f, 0.01677199f, -0.08520061f, 0.13035943f, -0.02196045f, 
    -0.00635155f, 0.03747632f, -0.03613812f, -0.08398260f, 0.32865533f, 0.28600532f, -0.11493147f, 0.28421563f, 
    0.11122449f, 0.05308294f, 0.08314792f, -0.09603466f, -0.15325196f, -0.06249614f, 0.04795995f, -0.19879344f, 
    0.16010858f, -0.10237100f, -0.15710072f, -0.13792452f, 0.04040395f, -0.00124640f, 0.17649008f, 0.03504434f, 
    0.03747534f, -0.01001249f, -0.04240417f, -0.06852905f, 0.06139982f, -0.26155919f, -0.04771977f, -0.00462627f, 
    0.00921273f, 0.04647533f, 0.10653359f, 0.09261769f, -0.04468886f, 0.10837845f, -0.06929518f, -0.04971563f, 
    0.00718929f, -0.02856825f, 0.12662813f, -0.22153232f, 0.05865524f, -0.30601987f, -0.17659943f, -0.06389955f, 
    0.13240744f, 0.21640603f, 0.01841409f, 0.09554936f, -0.19612364f, -0.18863581f, -0.13973081f, -0.15421210f, 
    0.01494797f, 0.05308113f, 0.09608649f, 0.00509995f, -0.06781448f, -0.01936915f, -0.11303277f, -0.09291289f, 
    0.08335180f, 0.15104257f, -0.18299687f, -0.06429161f, -0.05715906f, -0.01140789f, 0.17810881f, 0.13904577f, 
    0.09055817f, 0.04496190f, 0.14490335f, 0.17995986f, 0.12663178f, 0.19714451f, -0.19269784f, 0.29368949f, 
    0.04682745f, -0.02063590f, 0.13003767f, -0.02490019f, -0.11619870f, 0.11169476f, -0.05143742f, 0.05062734f, 
    -0.09777584f, 0.29072535f, 0.01879776f, 0.01700396f, -0.01289411f, 0.02591593f, -0.09594717f, 0.02606584f, 
    -0.01830207f, 0.08522796f, 0.03939812f, -0.10500153f, -0.13539053f, 0.10442120f, 0.41661906f, 0.03275650f, 
    -0.02196281f, 0.19528782f, 0.07125082f, -0.11926931f, -0.05363814f, -0.00419392f, 0.24533345f, -0.08053671f, 
    0.05672301f, -0.15510724f, 0.03033321f, -0.09830507f, 0.12107164f, 0.16510713f, -0.13358618f, -0.05237396f, 
    0.04946387f, 0.02410184f, -0.05981579f, 0.07604836f, 0.14035825f, 0.02514736f, -0.10744276f, -0.12921478f, 
    0.09105618f, 0.12242725f, 0.02498631f, -0.00922440f, -0.06005159f, 0.00787562f, 0.16614829f, 0.04114668f, 
    -0.67234433f, -0.35359588f, -0.01383840f, -0.04110011f, 0.04857587f, -0.10261804f, 0.09525857f, -0.04678872f, 
    0.00613403f, 0.11300831f, 0.02374563f, -0.06112333f, -0.30357888f, 0.03537565f, -0.01960545f, -0.17477174f, 
    -0.03102846f, -0.05298587f, 0.02225045f, -0.02042914f, 0.05378299f, 0.11144491f, 0.16380276f, 0.00835254f, 
    -0.04787221f, -0.01164255f, -0.01391997f, -0.19752428f, 0.11205082f, -0.08880591f, 0.04735978f, 0.05756665f, 
    0.00470415f, 0.03757336f, 0.00811483f, 0.07864743f, -0.48377371f, 0.18302274f, -0.15370329f, -0.06969545f, 
    -0.18230148f, 0.15699433f, -0.11249878f, 0.00959446f, 0.14181073f, -0.00302675f, 0.00302742f, 0.05245469f, 
    -0.23391952f, -0.43397397f, 0.20715861f, 0.19281676f, 0.07610847f, 0.02312185f, -0.10829422f, -0.02252363f, 
    0.17716360f, -0.03957939f, 0.09261084f, -0.01237848f, -0.06956285f, 0.14378537f, -0.02766058f, 0.21997494f, 
    0.03715500f, -0.05238099f, -0.25353664f, -0.08473841f, -0.01838401f, 0.06496209f, 0.13139287f, -0.09964669f, 
    -0.11464587f, -0.07025594f, -0.05949546f, -0.06307933f, -0.09264389f, 0.00649776f, -0.07927544f, -0.00844877f, 
    0.07331856f, -0.00372674f, 0.12575947f, 0.19498312f, 0.17011447f, -0.01895539f, -0.05255372f, -0.05179238f, 
    -0.06691032f, 0.01546865f, 0.12727799f, 0.06580722f, -0.02177296f, 0.00294021f, 0.09120067f, -0.10382271f, 
    0.15652217f, -0.49185020f, 0.25325200f, 0.45074135f, 0.10105050f, -0.06114316f, 0.00255926f, 0.01191969f, 
    0.16113442f, 0.11180318f, 0.24374333f, -0.12986407f, -0.01350423f, -0.25021207f, 0.11488081f, 0.11192103f, 
    -0.07257061f, -0.03683152f, -0.02264407f, -0.03488394f, -0.03384321f, -0.07897625f, 0.11008526f, 0.07784065f, 
    -0.12697794f, -0.26563621f, 0.00876337f, -0.23553126f, 0.18554282f, 0.16440760f, 0.12785153f, -0.03123770f, 
    -0.15719821f, 0.05653738f, -0.08308012f, -0.05327836f, -0.11698287f, 0.06877784f, -0.03562074f, -0.01880002f, 
    -0.06645803f, -0.04994706f, -0.02976478f, 0.06617953f, 0.14294545f, 0.03301371f, 0.12097084f, -0.03995088f, 
    0.01353825f, 0.40822935f, 0.00602810f, -0.18081307f, 0.00613128f, -0.14447257f, 0.05661962f, 0.12905963f, 
    0.00036563f, -0.00929595f, -0.15614721f, 0.03146384f, -0.62270647f, -0.11304668f, 0.12215159f, -0.29191661f, 
    0.03031562f, 0.04539068f, -0.01386998f, 0.00655328f, -0.06078495f, 0.08265241f, 0.31579566f, 0.05837750f, 
    -0.18968712f, -0.02349616f, 0.13813928f, -0.03117863f, -0.01049745f, -0.00833352f, -0.15320660f, 0.07711922f, 
    0.01060745f, -0.06825414f, 0.06671335f, 0.07511591f, 0.00557449f, -0.06026305f, -0.02736930f, -0.13106100f, 
    0.00747356f, -0.00611682f, -0.01263589f, 0.13886656f, 0.00684715f, 0.11608236f, -0.03821781f, -0.07986356f, 
    -0.07334486f, 0.05271645f, -0.15733725f, -0.14535983f, -0.00492719f, -0.02314008f, -0.02774292f, 0.12038784f, 
    0.09037615f, 0.05046833f, 0.16732438f, 0.02733769f, -0.18086028f, -0.10025664f, 0.09341246f, 0.05039887f, 
    -0.00651820f, -0.05898928f, 0.05833766f, 0.10271334f, -0.03495994f, -0.04474410f, 0.15090166f, 0.10507409f, 
    0.08613505f, -0.22505341f, -0.02574512f, 0.00680681f, 0.23686679f, 0.13858587f, 0.15420400f, -0.07252695f, 
    -0.09119038f, -0.12140783f, -0.11849621f, 0.04862370f, -0.01460914f, -0.05224813f, -0.08332179f, -0.03804435f, 
    0.01705255f, -0.05885288f, -0.09654646f, -0.12543628f, -0.06149865f, -0.04611431f, -0.13955933f, -0.06638058f, 
    0.32306245f, -0.24392290f, 0.24858987f, -0.15335768f, 0.00874383f, 0.09784812f, 0.11349976f, 0.06588500f, 
    -0.07524707f, 0.04712327f, 0.00424879f, 0.03352644f, -0.10029318f, -0.06287150f, 0.01669055f, 0.16991617f, 
    0.00552946f, 0.04763851f, -0.01831945f, -0.05323141f, 0.05808816f, 0.03189782f, -0.01768394f, -0.21945710f, 
    -0.28121844f, 0.00358021f, -0.06000725f, -0.18537480f, -0.10920633f, 0.01135402f, 0.00344648f, -0.01820228f, 
    -0.00594919f, 0.09472398f, 0.01492506f, -0.12278675f, 0.12729412f, -0.08431630f, 0.01885165f, 0.22030404f, 
    0.03297453f, -0.03629902f, 0.09711317f, -0.11993372f, 0.04301349f, -0.03249402f, -0.08242189f, 0.01915908f, 
    -0.15041952f, -0.18353149f, 0.18725160f, 0.04966754f, 0.03348609f, -0.05735869f, -0.06130851f, 0.01639436f, 
    -0.02404159f, 0.09208490f, 0.01280726f, 0.11781000f, -0.22224304f, -0.07915743f, -0.01880085f, 0.05305354f, 
    -0.00547521f, -0.15252142f, 0.14491354f, -0.01209127f, 0.11620455f, 0.18606840f, 0.25527009f, 0.11482160f, 
    0.29836625f, -0.33437705f, 0.22444730f, -0.06755137f, 0.20871121f, 0.06127965f, 0.02312088f, 0.10724636f, 
    0.05815909f, 0.10497107f, 0.10018016f, 0.13016228f, -0.03519310f, -0.30038503f, 0.23068319f, 0.18694112f, 
    -0.06373475f, 0.00823219f, -0.06844088f, -0.08283284f, 0.11694482f, 0.04141630f, 0.16208795f, 0.05165267f, 
    -0.04968539f, 0.03321019f, 0.09233422f, -0.06581357f, -0.08278331f, 0.03241264f, 0.01330436f, -0.16098076f, 
    -0.00350058f, 0.05950162f, -0.01145457f, 0.03183457f, 0.24439247f, 0.03770785f, -0.21268894f, 0.07546239f, 
    0.09758819f, 0.14270502f, -0.08947419f, -0.09978366f, 0.04758722f, 0.00899561f, 0.19695632f, -0.01750734f, 
    0.51362884f, -0.15272339f, 0.17238918f, 0.51733196f, 0.05273879f, -0.01895739f, 0.06780296f, 0.07215841f, 
    0.06377047f, 0.01697945f, -0.07733313f, -0.03358828f, 0.06607852f, 0.00971715f, 0.09755738f, -0.13245857f, 
    0.05630487f, -0.12112790f, 0.01612601f, 0.17614062f, -0.09722480f, -0.03945629f, -0.06079362f, 0.01577872f, 
    -0.17777555f, 0.24868172f, -0.29739109f, 0.12238805f, 0.20380242f, 0.06171255f, 0.23496948f, 0.20580122f, 
    0.08719707f, -0.24776530f, 0.00517151f, 0.08325424f, -0.02502465f, -0.03911059f, -0.08148681f, -0.22048254f, 
    0.12728699f, 0.06089162f, 0.16139451f, 0.00283753f, 0.01145897f, 0.00415308f, 0.04765396f, 0.02361224f, 
    0.25282213f, -0.12409765f, -0.03496925f, 0.27519673f, 0.13516961f, 0.26333970f, -0.07660455f, -0.08988667f, 
    0.00548090f, -0.12271501f, 0.03221896f, 0.13109443f, -0.07613710f, -0.14286616f, 0.07235534f, -0.04201267f, 
    0.07175864f, 0.01114282f, 0.01875740f, 0.09396515f, -0.19004069f, -0.00866066f, -0.08010850f, 0.11204289f, 
    -0.09811260f, -0.11310021f, -0.01000570f, 0.00198372f, -0.08578794f, 0.02279936f, 0.05328733f, -0.09145500f, 
    0.07800338f, 0.07612763f, 0.06641556f, 0.21514221f, -0.37773892f, -0.03289087f, -0.13274534f, -0.03114626f, 
    -0.09169086f, -0.08982718f, 0.08151915f, 0.19688474f, -0.07593235f, -0.07421748f, 0.08619146f, -0.11216191f, 
    -0.00929824f, -0.04144360f, -0.03164168f, 0.03352667f, -0.03379657f, -0.00003890f, -0.01717078f, -0.01773769f, 
    -0.00866279f, -0.00798035f, -0.00937182f, -0.00027573f, -0.00335117f, 0.01786776f, -0.01947264f, 0.02778644f, 
    0.02579416f, -0.00345360f, 0.03478542f, -0.02521826f, -0.04481945f, -0.02580550f, -0.00574039f, -0.01557038f, 
    -0.03531554f, 0.01492210f, -0.00298119f, -0.00747278f, -0.01515950f, 0.02365127f, 0.01237170f, -0.03947707f, 
    -0.00303272f, -0.03752134f, -0.01890893f, -0.02951312f, -0.01617664f, 0.00530668f, 0.03736464f, -0.01870389f, 
    0.01690933f, -0.03008270f, 0.01934103f, 0.02104258f, 0.02555318f, 0.00554772f, 0.00834788f, 0.02557861f, 
    -0.02780173f, -0.03675839f, -0.02815660f, -0.02299002f, 0.02573845f, -0.03704562f, -0.01381682f, -0.01454768f, 
    0.00288465f, -0.02995981f, 0.01319269f, -0.00815852f, 0.01245565f, 0.03406037f, 0.00295341f, -0.00343311f, 
    -0.02833828f, -0.02250349f, 0.02706405f, 0.02403070f, -0.01009386f, -0.01753930f, -0.02203538f, -0.03110571f, 
    -0.00568288f, 0.00482049f, -0.01142443f, -0.00745390f, -0.00706768f, -0.00047471f, 0.01163427f, 0.01891691f, 
    -0.01158425f, -0.00932988f, 0.02515232f, -0.01252823f, 0.02733807f, 0.02245197f, -0.01803198f, 0.01914761f, 
    -0.03071193f, -0.01794637f, 0.02249594f, -0.00389938f, 0.00874952f, -0.02159015f, -0.01364989f, 0.01240976f, 
    -0.02957886f, -0.01767915f, -0.04486981f, 0.01230519f, -0.02428873f, 0.02432926f, -0.01726188f, -0.02960092f, 
    0.01664984f, -0.02403725f, 0.00418407f, 0.02240711f, -0.00990917f, 0.03636776f, -0.01495729f, -0.02266261f, 
    0.02388526f, 0.00202674f, 0.01950167f, 0.01056624f, 0.01300726f, -0.02614725f, 0.02991121f, -0.02417655f, 
    0.01365646f, 0.02477768f, 0.00037946f, -0.00706846f, -0.00495568f, 0.00878758f, 0.00730482f, 0.00837726f, 
    0.03187774f, 0.02287024f, 0.01451936f, -0.03384464f, -0.00564475f, -0.01749382f, -0.02580338f, 0.04389353f, 
    -0.01496222f, 0.02139050f, -0.01004665f, 0.01220587f, 0.02375553f, 0.02121571f, -0.00759003f, 0.02146584f, 
    0.02751123f, -0.01107096f, 0.00718127f, 0.02948682f, 0.02458754f, -0.02568142f, 0.01523150f, 0.01589118f, 
    -0.00519612f, 0.02912629f, -0.02222006f, 0.02356111f, -0.02622768f, 0.02016464f, -0.01733160f, -0.03577342f, 
    -0.01442116f, -0.00730332f, -0.01636178f, -0.00583322f, 0.03785968f, -0.00922730f, 0.01517611f, 0.02079190f, 
    0.03047010f, -0.03118639f, 0.01725772f, -0.02318704f, 0.01429714f, 0.01700505f, 0.00360911f, -0.03803971f, 
    -0.01517264f, 0.00659491f, 0.00653323f, -0.01912076f, 0.02823682f, -0.02333489f, 0.01484381f, 0.02537353f, 
    -0.02912481f, -0.02800266f, -0.01434934f, 0.02506723f, -0.01702882f, 0.00425566f, -0.00144116f, -0.02377044f, 
    -0.03405755f, -0.01041916f, 0.02014442f, -0.01252577f, -0.01037359f, -0.02053992f, -0.03375723f, 0.00235411f, 
    -0.03854224f, -0.01656109f, 0.01909066f, -0.01707184f, -0.00733748f, -0.03114206f, -0.00872874f, -0.03715181f, 
    -0.03281642f, -0.00859569f, -0.01591469f, -0.03963675f, -0.00295852f, 0.01597063f, 0.02385700f, 0.02842763f, 
    0.00454458f, 0.01064322f, -0.02669211f, -0.02065039f, -0.03251179f, 0.01082484f, 0.03469754f, -0.01282117f, 
    -0.00137316f, 0.02041134f, 0.01370577f, -0.02004230f, -0.03886441f, -0.01302377f, -0.02184338f, 0.02392536f, 
    0.01799669f, -0.02849365f, -0.00617115f, 0.03237044f, -0.03888574f, 0.00797988f, 0.00435353f, 0.02079287f, 
    -0.00698610f, -0.00984578f, -0.03363991f, -0.04335898f, -0.01740093f, -0.01238591f, 0.02303412f, 0.01416571f, 
    0.01540244f, -0.02044262f, -0.00202242f, -0.00114098f, 0.02769293f, -0.00996173f, -0.00301258f, -0.01163274f, 
    0.01699089f, -0.03923977f, 0.01465660f, -0.03310356f, 0.01128388f, 0.00120215f, 0.02002988f, 0.02704173f, 
    -0.02306788f, 0.00018394f, -0.02834851f, -0.00099159f, -0.01572657f, -0.01273969f, -0.01495177f, -0.02906743f, 
    -0.02167184f, 0.00840749f, 0.02022459f, 0.01273920f, -0.03782127f, -0.01815867f, -0.02519591f, -0.00891948f, 
    0.02795159f, 0.02436233f, -0.02608586f, 0.00409198f, 0.01347734f, -0.03809283f, 0.00075045f, -0.02472036f, 
    -0.02309562f, 0.02549715f, 0.03764756f, 0.03445823f, -0.04033854f, 0.00223629f, 0.00457301f, -0.02383341f, 
    -0.03041782f, -0.01823820f, 0.01692743f, -0.03072308f, -0.03231814f, 0.02760184f, -0.01944281f, 0.01869319f, 
    0.01089995f, -0.00171033f, -0.01985748f, 0.01241176f, 0.01974491f, 0.01100668f, 0.00431153f, 0.02127378f, 
    -0.03095187f, 0.02896743f, -0.01799441f, -0.03911060f, 0.00724106f, -0.03241083f, -0.03465967f, 0.02847204f, 
    -0.01011532f, -0.04208142f, -0.02310570f, -0.03160246f, -0.01503764f, -0.03607915f, -0.03093324f, 0.02077152f, 
    -0.01786560f, 0.01516222f, -0.00262086f, -0.03556564f, -0.00000678f, -0.04086761f, 0.01243440f, -0.03463096f, 
    -0.00585672f, 0.03619234f, 0.01273826f, -0.02121342f, -0.03979636f, -0.00278743f, -0.04251496f, -0.03216902f, 
    0.02255749f, 0.01907092f, -0.03812048f, 0.02669007f, -0.00734288f, -0.01553795f, -0.02807262f, -0.00371221f, 
    -0.01612320f, 0.01450983f, -0.01972590f, -0.03113686f, -0.02739022f, 0.00104871f, 0.00163188f, 0.01765362f, 
    0.02426982f, -0.00795737f, -0.00081394f, -0.03773260f, 0.02343602f, -0.03541157f, -0.03309857f, -0.03981701f, 
    0.00535244f, 0.03264518f, 0.01963071f, -0.00313070f, 0.01014317f, 0.00852859f, 0.00036582f, -0.02179706f, 
    -0.00351451f, 0.02186783f, -0.03618220f, 0.01313319f, -0.02752379f, 0.01422207f, -0.01398461f, 0.00150742f, 
    0.00846484f, 0.01346224f, 0.01842805f, -0.02934902f, -0.00898583f, -0.00197457f, -0.02395693f, 0.00396145f, 
    -0.01990052f, 0.01617896f, -0.01167529f, 0.01353224f, -0.00795670f, 0.01354871f, 0.02218678f, -0.03416257f, 
    0.01432490f, -0.01716799f, -0.03199904f, 0.00488365f, -0.01665864f, -0.00882608f, -0.03457492f, -0.01703649f, 
    -0.04280154f, -0.03254949f, -0.02788214f, -0.00406707f, 0.00138911f, -0.00766399f, -0.03245666f, -0.00323148f, 
    0.02760069f, -0.00165684f, -0.01022105f, -0.03181203f, 0.02507960f, -0.02935884f, -0.01524952f, 0.01222234f, 
    -0.01288892f, 0.00719437f, 0.00410683f, 0.02501912f, -0.01931451f, -0.03329967f, -0.01903313f, 0.02520647f, 
    -0.00100091f, -0.00525809f, -0.00959420f, -0.02850339f, 0.00217231f, -0.00720576f, 0.03019652f, -0.03883612f, 
    0.01147025f, 0.01267685f, 0.02166691f, -0.01336783f, 0.00183106f, -0.00113171f, 0.02258355f, 0.02396310f, 
    0.02556134f, 0.02340521f, 0.02876110f, 0.00245101f, 0.02059210f, 0.03326747f, 0.02408617f, 0.00285074f, 
    -0.02722683f, -0.01651991f, 0.03410373f, -0.03554567f, 0.03062392f, -0.03049829f, -0.00687474f, 0.02009825f, 
    0.02637523f, 0.02890542f, -0.03043883f, 0.00700084f, 0.02390393f, 0.00132498f, -0.03022156f, -0.03936831f, 
    -0.00301354f, 0.00202095f, 0.02956320f, 0.01249896f, -0.00869123f, 0.01079648f, 0.01331883f, 0.01245976f, 
    -0.01612188f, -0.01547491f, -0.00263608f, -0.01546454f, 0.00513662f, -0.01734767f, -0.01000376f, -0.03336985f, 
    -0.00531252f, -0.04085921f, -0.02581665f, 0.00420143f, 0.02533069f, -0.01231758f, -0.02064036f, 0.01585159f, 
    0.02630646f, -0.03157470f, 0.03016665f, -0.03236302f, 0.02161193f, -0.00453149f, -0.04149551f, 0.02511949f, 
    0.00154679f, -0.02687454f, -0.02397561f, -0.03608943f, 0.01481008f, 0.01233665f, 0.01842345f, -0.01379863f, 
    -0.02725921f, 0.01238292f, -0.02839409f, -0.02277356f, 0.01159755f, -0.02276058f, -0.00587258f, 0.01588491f, 
    -0.03062939f, 0.00679769f, -0.02734675f, -0.04354772f, -0.01740888f, -0.02377679f, -0.02651353f, 0.00170597f, 
    -0.02673267f, 0.02179210f, 0.01699894f, -0.02760388f, -0.01472914f, -0.01552239f, -0.03175531f, 0.00406845f, 
    -0.01286343f, 0.01789416f, -0.00739143f, 0.00638463f, 0.01900445f, -0.03357340f, 0.02252117f, -0.02378655f, 
    0.02701206f, 0.02595598f, -0.01460940f, 0.01920344f, -0.01940439f, 0.03815367f, 0.01748156f, 0.02142888f, 
    -0.03744041f, -0.01414300f, 0.00214669f, 0.03619035f, -0.00777857f, -0.00637323f, 0.01760305f, -0.02847900f, 
    0.00065772f, 0.02519095f, -0.03090880f, 0.00118272f, -0.01601806f, -0.02757958f, -0.03555175f, 0.03231295f, 
    -0.02498849f, -0.01162708f, 0.00625183f, 0.00738392f, -0.04198960f, -0.00147396f, -0.00075724f, -0.01958518f, 
    -0.01930417f, 0.01218149f, 0.01311990f, -0.03856689f, -0.02334730f, 0.01458090f, -0.00591020f, 0.01223432f, 
    -0.03532297f, -0.00808450f, -0.00019200f, -0.01455650f, 0.01872020f, -0.02466648f, -0.01654381f, -0.00974308f, 
    -0.02241245f, 0.01772448f, 0.01474011f, -0.02049974f, -0.00484432f, -0.00269160f, 0.00797486f, 0.01156633f, 
    -0.02181317f, -0.00453384f, 0.00031409f, 0.01224297f, -0.03199074f, -0.01559539f, -0.01021042f, 0.02487102f, 
    0.01213218f, -0.01802368f, 0.03007497f, 0.00487327f, 0.01693632f, 0.03813902f, 0.01996785f, -0.03055047f, 
    0.01452855f, 0.00999093f, -0.02111790f, 0.02409398f, -0.03305455f, 0.01010461f, -0.00138189f, -0.04478637f, 
    0.00038702f, 0.01782825f, 0.02895012f, -0.00238074f, -0.00321154f, 0.01609321f, 0.01161315f, -0.02934984f, 
    -0.03311345f, -0.01621796f, -0.01649729f, -0.02349623f, -0.02112746f, -0.02390706f, -0.01291327f, -0.00408061f, 
    0.01852209f, -0.00396949f, -0.04134563f, -0.02590106f, -0.00158091f, 0.00714200f, 0.01219131f, -0.01877556f, 
    0.01801337f, 0.01481253f, 0.00078826f, 0.02371397f, 0.03033723f, -0.02566419f, 0.00708841f, 0.02857734f, 
    -0.01896958f, 0.01667252f, -0.01950631f, -0.01140229f, -0.01335561f, -0.03128145f, -0.02104600f, -0.00550798f, 
    0.02432929f, -0.04423772f, -0.01997875f, -0.00209655f, -0.03049096f, -0.02756808f, -0.00197996f, -0.02743977f, 
    -0.00795354f, 0.01943589f, 0.02741882f, 0.02796262f, -0.02916746f, -0.02167389f, 0.03119385f, -0.03507426f, 
    -0.03729964f, 0.02430460f, 0.02323963f, 0.02839889f, -0.01020960f, -0.00613209f, 0.01011689f, 0.02581580f, 
    -0.03433161f, -0.01702750f, -0.03067301f, -0.00976706f, 0.01895624f, -0.03409596f, -0.02565135f, -0.03238585f, 
    0.00369165f, 0.02011972f, -0.03754496f, -0.03367759f, 0.00580392f, 0.02471905f, -0.01463845f, -0.00541397f, 
    -0.01845918f, -0.03036129f, 0.02986151f, -0.01404615f, -0.00200844f, 0.00172087f, 0.00326100f, 0.02052551f, 
    0.01544221f, 0.00178515f, -0.00982220f, -0.04173880f, -0.02697285f, -0.01489452f, -0.02929174f, -0.03153281f, 
    0.00711184f, 0.02767678f, -0.00248546f, -0.00876269f, -0.02703228f, 0.01135890f, 0.00506025f, 0.03233248f, 
    -0.02682866f, 0.02135682f, 0.02671912f, -0.00874044f, -0.03372138f, -0.03043772f, 0.01449904f, 0.02753922f, 
    -0.04323104f, -0.00365540f, 0.00580812f, -0.02346926f, 0.00229640f, -0.02816559f, 0.00632445f, -0.01515968f, 
    -0.02158366f, 0.01292752f, -0.00529545f, -0.02113567f, -0.02249311f, -0.02923085f, 0.02061036f, 0.00785288f, 
    0.00681866f, -0.01245166f, 0.00518150f, 0.00664473f, 0.02499137f, 0.00560057f, -0.03668554f, -0.04157719f, 
    0.02887666f, 0.00747241f, 0.00050055f, -0.02921931f, -0.01739336f, -0.00024514f, 0.00474807f, -0.01298920f, 
    -0.06370512f, -0.06422149f, -0.29722616f, 0.08582927f, 0.06482251f, 0.22367667f, -0.02964257f, 0.02871579f, 
    0.16271055f, 0.03825562f, -0.07285969f, 0.09686577f, -0.23384634f, 0.11171374f, -0.18071981f, 0.06596934f, 
    0.01952928f, 0.03460180f, 0.01322498f, 0.10608102f, 0.04770216f, -0.00014603f, -0.14387476f, -0.02078641f, 
    -0.22257777f, -0.44506997f, -0.09596229f, -0.08208440f, 0.14993276f, 0.22641310f, 0.07543686f, -0.01225199f, 
    0.01979209f, 0.05562948f, -0.04674958f, -0.06028655f, -0.07797018f, -0.04493834f, 0.06287313f, -0.09276190f, 
    -0.23456921f, 0.04683434f, 0.20263799f, -0.07371937f, -0.01072269f, -0.04761505f, -0.03288566f, -0.20449223f, 
    -0.54860008f, 0.32214433f, 0.30143139f, 0.26973605f, 0.05948656f, 0.09589079f, 0.07278893f, -0.05147757f, 
    0.02258538f, 0.01712414f, 0.07792570f, 0.06325311f, -0.39828718f, -0.08744559f, 0.07046986f, 0.17108026f, 
    -0.07743976f, 0.00806177f, -0.04328220f, -0.03120932f, -0.20822798f, -0.02612200f, 0.01067867f, -0.05312944f, 
    -0.24529469f, -0.12079960f, 0.05078742f, -0.03824490f, -0.03581307f, 0.06304006f, 0.13165250f, 0.23859143f, 
    -0.07116602f, 0.08937412f, 0.06831188f, 0.15328810f, -0.23412265f, -0.28439867f, -0.02986074f, -0.05812819f, 
    0.11077510f, 0.04135945f, -0.04607369f, -0.05074006f, -0.02453718f, 0.05968843f, 0.08545847f, -0.06782546f, 
    -0.21603635f, -0.05293883f, -0.18090217f, -0.02739200f, -0.11616575f, -0.02617523f, -0.01399177f, 0.01325740f, 
    -0.03963473f, -0.01299655f, 0.06326362f, -0.05766710f, 0.02228704f, -0.33059558f, -0.18094267f, -0.17542474f, 
    0.05630353f, -0.09422631f, -0.02833311f, 0.10547069f, -0.01730554f, 0.02365570f, 0.07180228f, -0.02536983f, 
    0.32155791f, -0.07247329f, 0.04637589f, -0.17924672f, 0.11280170f, 0.08749494f, 0.05114431f, 0.04722617f, 
    0.10030019f, 0.28046739f, -0.11211727f, 0.02365013f, -0.24958126f, -0.14301842f, -0.13338734f, 0.14365837f, 
    0.18735819f, 0.27461833f, -0.05892810f, 0.04136722f, -0.15135354f, 0.02316498f, -0.06074958f, -0.01669482f, 
    -0.13571641f, -0.04084941f, 0.02924262f, 0.23603800f, -0.09716779f, -0.13645947f, -0.02758210f, -0.06660289f, 
    0.01882510f, 0.01867732f, -0.00354438f, 0.01159588f, 0.22798851f, -0.17565155f, 0.02731911f, 0.12398134f, 
    -0.11003365f, 0.01061996f, 0.06944197f, 0.04587387f, -0.00050606f, 0.13722304f, 0.33241963f, 0.07712366f, 
    -0.05845188f, -0.28064701f, -0.15951867f, -0.00552569f, 0.08009000f, 0.09489490f, 0.10817086f, 0.06994590f, 
    -0.02538944f, 0.02830304f, 0.02136598f, 0.01612587f, -0.00519494f, -0.30187160f, -0.06199316f, 0.17853335f, 
    0.12548895f, 0.16507359f, 0.13097465f, -0.08195470f, -0.00859653f, -0.07566869f, 0.02172655f, -0.09795410f, 
    -0.14873189f, -0.05468417f, -0.14085580f, -0.13483152f, -0.14628230f, -0.05337109f, 0.08135700f, 0.03039153f, 
    0.14218453f, 0.03787148f, -0.03299745f, 0.08477797f, 0.07837373f, 0.09395832f, 0.02491523f, -0.00604984f, 
    -0.02158573f, -0.07546044f, 0.02919236f, -0.05033664f, 0.19148324f, 0.20941076f, 0.05569788f, -0.02055357f, 
    0.01060037f, 0.25523695f, -0.14540705f, 0.15733890f, -0.08009113f, -0.11140277f, -0.18162961f, 0.03018083f, 
    0.04954397f, 0.08967713f, 0.03419351f, 0.16016324f, -0.15137823f, -0.09159142f, -0.16009705f, -0.15214291f, 
    -0.12370943f, -0.12600178f, 0.10915273f, 0.01501253f, 0.09423341f, 0.18057372f, 0.03019384f, 0.20133056f, 
    0.06627574f, 0.18479604f, 0.07512914f, 0.06943311f, 0.02628201f, -0.08326796f, 0.21548392f, 0.04101576f, 
    0.16381007f, 0.12727977f, 0.13029540f, 0.09636489f, -0.09242611f, -0.06076222f, -0.28560564f, -0.06494616f, 
    -0.01310684f, 0.14940150f, 0.25208411f, 0.08289175f, 0.00309149f, 0.11470116f, -0.04749839f, -0.09344380f, 
    0.08139740f, 0.29559791f, 0.20046058f, 0.04364109f, -0.00194911f, 0.07287447f, -0.08852638f, -0.00091102f, 
    0.07970934f, 0.12848531f, -0.02133024f, -0.07676249f, -0.08914565f, -0.05297607f, 0.21816835f, 0.22431374f, 
    0.15551648f, 0.06812370f, -0.05523429f, -0.11081363f, 0.00378937f, 0.05534354f, 0.17400871f, 0.06782701f, 
    -0.30982965f, -0.05592084f, 0.06177989f, 0.12660876f, -0.03485590f, -0.03830558f, 0.05095550f, -0.01895727f, 
    -0.03412044f, -0.11005084f, -0.11031929f, 0.00444966f, -0.16276945f, -0.01203598f, -0.16054142f, -0.09905393f, 
    -0.09910849f, -0.01845151f, 0.03098651f, -0.05286901f, -0.05516615f, -0.05760955f, -0.10669309f, -0.11622878f, 
    0.64489663f, 0.08711350f, 0.06753206f, 0.32465521f, 0.07851969f, -0.14758994f, 0.04745435f, 0.20369400f, 
    0.01327083f, -0.02991695f, 0.01901548f, -0.00182866f, 0.40610254f, -0.05598643f, -0.00893543f, 0.04009194f, 
    -0.02298918f, -0.02944178f, 0.20252301f, 0.10842536f, 0.08270029f, 0.03600606f, 0.07049753f, 0.18755810f, 
    -0.31749991f, -0.37281987f, -0.14508735f, 0.00806862f, 0.00164760f, -0.04493218f, -0.07560014f, -0.08427298f, 
    -0.11430404f, 0.00008462f, -0.04743394f, 0.02927820f, 0.27215669f, -0.03237484f, 0.16922937f, -0.10330624f, 
    -0.00474568f, 0.01253072f, 0.01034209f, -0.02243492f, -0.23059078f, 0.08708870f, 0.16685069f, 0.10204112f, 
    0.20097353f, -0.01127164f, 0.02711496f, 0.15397488f, 0.01842668f, -0.09139185f, -0.03413839f, 0.08969028f, 
    -0.09841216f, 0.09217833f, 0.03212141f, 0.00539282f, 0.22583885f, 0.32078040f, 0.22146560f, -0.27865615f, 
    -0.03129549f, 0.04856422f, -0.20048520f, -0.03746838f, 0.02283240f, 0.11523156f, 0.00475655f, 0.04413898f, 
    -0.07560821f, 0.05729620f, 0.09577684f, -0.20326526f, 0.07305525f, -0.04330403f, -0.04439457f, -0.00000716f, 
    -0.07495845f, 0.00400837f, 0.02396782f, 0.04890663f, -0.12609029f, 0.20934357f, -0.07573463f, 0.22463630f, 
    -0.04082541f, -0.02845912f, 0.15870979f, 0.08099207f, 0.11883441f, 0.06732495f, 0.07005355f, 0.12948595f, 
    0.08316157f, -0.06092326f, -0.05514195f, -0.02545433f, -0.01573765f, 0.20409589f, -0.02581999f, 0.04523461f, 
    -0.15782887f, 0.08966934f, 0.02735865f, 0.01918039f, 0.25824520f, 0.13795894f, -0.07639280f, -0.07319694f, 
    0.00139836f, 0.04602736f, -0.04052728f, 0.11747546f, -0.17658694f, 0.07117698f, 0.18046859f, -0.01030694f, 
    -0.26388887f, 0.20879824f, -0.09268514f, -0.06203824f, 0.06833486f, 0.06933909f, 0.02390432f, 0.13383973f, 
    -0.05964034f, 0.04439474f, -0.03601132f, -0.00344618f, -0.22544381f, -0.25915653f, -0.35294670f, 0.18125306f, 
    -0.04620135f, -0.01786060f, 0.07542185f, -0.03464671f, 0.00336498f, 0.01816026f, 0.01286450f, -0.04372207f, 
    0.18322842f, 0.20125677f, 0.13159159f, 0.11577281f, 0.08634423f, -0.14595294f, 0.11864192f, 0.04913968f, 
    -0.08667880f, -0.01506076f, 0.09329118f, -0.15815884f, -0.43288121f, 0.14485043f, 0.32294551f, 0.11932394f, 
    0.04444855f, -0.05998332f, -0.00007509f, -0.07939395f, 0.18494681f, 0.11903053f, 0.16062139f, 0.11271980f, 
    0.00408034f, 0.21479388f, 0.25136480f, 0.16578272f, 0.00214019f, -0.13358745f, -0.04371433f, 0.06243380f, 
    -0.04506055f, -0.01597650f, -0.07854512f, 0.00310565f, 0.16131699f, 0.00649132f, 0.08742259f, -0.08043786f, 
    -0.02254642f, -0.08182612f, -0.00169870f, 0.05136872f, 0.02317784f, 0.04528980f, 0.07986356f, -0.00442353f, 
    -0.09089506f, -0.26342386f, -0.21925083f, -0.26933154f, -0.05666215f, -0.15840854f, -0.00604577f, -0.01882727f, 
    -0.02691210f, -0.12124432f, 0.02633228f, 0.04219121f, 0.85567164f, -0.09490298f, -0.12009198f, 0.35119429f, 
    -0.00671382f, 0.00574882f, 0.19500549f, 0.23730603f, 0.02938351f, -0.08596838f, 0.07146206f, 0.05223590f, 
    -0.53498328f, -0.54552472f, -0.04071123f, 0.13561733f, 0.07080444f, 0.20609742f, 0.25413361f, 0.03768821f, 
    0.01777944f, -0.08822751f, -0.00625540f, -0.10380164f, 0.08223768f, -0.22403389f, -0.04957723f, -0.13604160f, 
    -0.01088803f, 0.06639113f, -0.09177104f, 0.01150410f, 0.05882867f, -0.09645157f, 0.03471681f, -0.02462089f, 
    -0.36433402f, -0.03071511f, 0.28020182f, 0.01599413f, 0.17611884f, 0.08263713f, 0.04530808f, 0.03679813f, 
    -0.03375877f, -0.05407662f, -0.01723876f, -0.11582672f, -0.05349940f, -0.11063103f, 0.05775009f, 0.10153324f, 
    -0.00923169f, 0.03349111f, -0.00736542f, -0.06660492f, -0.10351497f, 0.09898097f, -0.05066356f, -0.10057734f, 
    0.09063204f, -0.07802164f, 0.02434490f, -0.24133019f, -0.00996427f, -0.04139492f, -0.03614144f, -0.04679779f, 
    0.03840127f, 0.12639666f, -0.04908983f, 0.01676180f, 0.14670290f, 0.02883269f, -0.02486674f, 0.08954316f, 
    0.06174371f, 0.02791528f, 0.01004412f, -0.09714450f, -0.02280091f, -0.03026934f, -0.12667242f, 0.07880626f, 
    -0.38297507f, 0.19105977f, 0.17124733f, -0.01792858f, -0.04943729f, 0.04616773f, 0.00060795f, 0.16639352f, 
    -0.02309216f, 0.09937982f, -0.02658705f, -0.04863321f, 0.15478036f, 0.00662050f, 0.15780418f, 0.35089374f, 
    -0.07235837f, -0.04836032f, 0.21614520f, 0.14281940f, 0.01083339f, 0.01086122f, 0.20994063f, 0.03189170f, 
    0.03298151f, 0.03442943f, 0.01499490f, -0.07877320f, 0.01575855f, 0.17083943f, -0.02528081f, 0.05494155f, 
    0.04638666f, -0.01378446f, 0.00093286f, 0.00280346f, -0.31351331f, 0.03950432f, 0.16026719f, 0.00641181f, 
    0.11846033f, -0.06295753f, 0.03691391f, 0.05872326f, 0.02523680f, 0.20175412f, 0.18614548f, 0.03786250f, 
    0.00101629f, -0.03630418f, 0.20896272f, 0.00119155f, 0.02166573f, -0.01315819f, 0.10609510f, -0.03735535f, 
    0.01782255f, 0.04893210f, 0.01902203f, -0.05135738f, 0.31022260f, -0.01619714f, -0.07224716f, 0.13116835f, 
    0.05580759f, 0.11985501f, 0.01768340f, -0.06479517f, -0.06938966f, -0.12625599f, -0.08059784f, 0.01229351f, 
    -0.18462197f, 0.28323430f, -0.07653257f, 0.08383153f, -0.11117455f, -0.01885309f, 0.08419401f, -0.06598307f, 
    -0.10503171f, 0.08801458f, -0.01379329f, -0.18037669f, 0.06591932f, 0.16796029f, 0.03797941f, 0.26635337f, 
    -0.03117629f, -0.07727977f, 0.08953740f, 0.20140250f, 0.06650831f, 0.04333121f, -0.07570305f, 0.08671300f, 
    -0.07391036f, 0.03581376f, 0.14265439f, 0.09844904f, 0.01833313f, 0.02272159f, 0.08732914f, 0.05213292f, 
    -0.01751076f, -0.11569516f, 0.02656238f, -0.04279500f, 0.03664000f, -0.40423691f, 0.00675918f, 0.20433523f, 
    0.10386990f, 0.05768041f, 0.04066703f, 0.07019628f, 0.02498494f, -0.00870483f, -0.00204561f, 0.13653445f, 
    -0.15067774f, 0.24235725f, -0.02543502f, -0.05189522f, 0.06233527f, 0.04875230f, -0.04644139f, -0.07321920f, 
    -0.06978238f, 0.13263300f, -0.01442540f, 0.00273753f, -0.24980168f, 0.15245023f, 0.12965403f, 0.13869594f, 
    0.03110160f, 0.07004213f, -0.03165792f, 0.13959607f, -0.17230669f, -0.06121786f, 0.06564354f, 0.07335364f, 
    -0.11696906f, 0.03569146f, -0.14810571f, -0.12893711f, 0.09451788f, -0.04921206f, -0.01250439f, 0.01325027f, 
    -0.01883806f, -0.05654586f, -0.07869177f, 0.11886083f, 0.43805575f, -0.16397864f, -0.02123783f, 0.17551145f, 
    0.03777123f, 0.02977589f, 0.24893810f, 0.30498412f, -0.00738930f, -0.00596512f, 0.04185868f, 0.06404297f, 
    0.02068924f, -0.03789964f, -0.01709817f, -0.01893153f, -0.04161326f, -0.01709481f, 0.02595379f, -0.03979775f, 
    0.00281991f, -0.00087030f, -0.01380662f, 0.00569024f, -0.01400536f, -0.00521567f, -0.01547684f, -0.01565815f, 
    0.00789755f, 0.02042443f, 0.01034877f, -0.01761194f, -0.01628914f, 0.02211983f, -0.03748959f, 0.00106651f, 
    0.01972258f, -0.04291660f, -0.02233224f, 0.01957947f, 0.02644570f, 0.00615115f, -0.01447653f, 0.02832909f, 
    -0.01267807f, 0.00497711f, -0.01979569f, 0.01353463f, 0.02089441f, -0.03022765f, -0.04231580f, -0.02489225f, 
    0.01768863f, -0.02338557f, 0.01293568f, -0.01688307f, 0.00248284f, -0.04390461f, -0.03499529f, -0.01764554f, 
    0.00725650f, 0.01611163f, 0.02704638f, 0.00257868f, 0.01773910f, -0.02190789f, -0.03692008f, 0.00479556f, 
    0.02627389f, 0.01938603f, -0.03389931f, 0.01911577f, 0.00977439f, -0.02275976f, -0.00448089f, 0.00424174f, 
    0.02327652f, -0.00654819f, 0.00984305f, -0.04204978f, 0.01153627f, 0.00156128f, -0.02102406f, 0.01742607f, 
    -0.00147289f, -0.00645976f, -0.00177164f, 0.00957902f, -0.04288119f, -0.01882251f, -0.02706929f, 0.01213593f, 
    -0.02653070f, -0.04031038f, -0.00146654f, 0.00775556f, 0.00059621f, 0.00878242f, -0.02475685f, -0.02037054f, 
    -0.00638449f, 0.00843916f, 0.00591588f, 0.02676371f, -0.02650089f, -0.00372664f, -0.01517171f, 0.01113266f, 
    -0.03653712f, 0.02628400f, 0.00473262f, -0.03387333f, 0.01352413f, 0.00115908f, -0.03950545f, -0.02492910f, 
    -0.03902856f, -0.02756411f, 0.00293457f, -0.02341839f, -0.01238897f, -0.00635684f, 0.01393379f, 0.00394473f, 
    0.00340230f, -0.02182792f, 0.00066797f, 0.02189372f, 0.02612197f, 0.00719961f, 0.02051843f, -0.03529374f, 
    -0.03455200f, -0.03743720f, -0.04153540f, 0.01465386f, -0.02741417f, -0.00113165f, -0.02806653f, 0.00137939f, 
    -0.04204809f, 0.00864545f, -0.00322537f, 0.02189855f, 0.02360548f, -0.00762699f, -0.02356687f, -0.02278642f, 
    -0.02677707f, -0.01218774f, 0.04032649f, -0.02854477f, -0.03067757f, -0.04128649f, 0.02580992f, 0.00048374f, 
    -0.01844959f, 0.00712159f, -0.02014537f, -0.01085309f, 0.00460896f, 0.00888291f, -0.02253490f, -0.02501684f, 
    0.02197723f, -0.03896852f, 0.00918212f, -0.01238101f, 0.01255296f, -0.01492636f, -0.02772808f, 0.02852972f, 
    -0.00778914f, -0.00511051f, 0.02986446f, -0.01788264f, -0.00082611f, -0.02745044f, -0.00491541f, 0.01567604f, 
    -0.04211421f, -0.01724313f, 0.00725109f, -0.01446383f, 0.02309643f, 0.01126056f, -0.00434329f, 0.02268784f, 
    0.00574884f, 0.00081363f, -0.00396720f, -0.01844741f, -0.02185652f, -0.03508278f, 0.01085557f, 0.01678680f, 
    0.00777114f, 0.02439767f, 0.02462100f, -0.03615699f, -0.00240975f, 0.01453733f, -0.02477490f, -0.01665280f, 
    -0.03174175f, 0.00605666f, 0.01815658f, -0.02396664f, -0.00447492f, -0.02547858f, -0.00842712f, -0.03471747f, 
    0.01060538f, 0.02707354f, -0.00900019f, -0.00711893f, -0.00513230f, -0.03382561f, 0.02752919f, -0.01224234f, 
    -0.03509231f, 0.01409104f, -0.03884068f, -0.01742390f, 0.01460212f, 0.01658622f, -0.00356628f, 0.00193389f, 
    0.01598212f, 0.01137320f, -0.01437412f, -0.03566969f, -0.04232983f, 0.00488077f, -0.01538676f, -0.01191319f, 
    0.01826476f, -0.02068540f, 0.02066452f, -0.02377410f, -0.01207465f, 0.01463684f, -0.02964673f, 0.00097500f, 
    0.02119017f, -0.03618491f, 0.00855391f, -0.03152395f, -0.00081304f, -0.04143542f, -0.02620625f, -0.01301250f, 
    -0.04183840f, -0.03434232f, 0.01245965f, -0.03382281f, 0.01699094f, 0.02718157f, 0.02551048f, 0.00093231f, 
    -0.04264488f, -0.01249183f, 0.01316999f, -0.03508540f, -0.03094394f, -0.01405886f, 0.02597265f, 0.01986353f, 
    -0.00947236f, 0.02129208f, 0.02389820f, -0.02878014f, -0.01722677f, 0.01342493f, 0.00078118f, 0.00527095f, 
    0.01835503f, -0.00035916f, 0.00102442f, -0.02166000f, -0.00271832f, -0.02295207f, 0.02378821f, -0.02335501f, 
    -0.00138499f, 0.00271856f, 0.02319258f, -0.01292276f, -0.02981055f, -0.00343001f, 0.00861443f, 0.00906433f, 
    -0.02212176f, -0.03132097f, 0.01770068f, -0.02976193f, -0.03027785f, -0.01149412f, 0.00261215f, 0.00675032f, 
    0.01636068f, 0.00052429f, -0.02120625f, 0.01458465f, -0.03635863f, -0.00702742f, 0.00929369f, -0.04163452f, 
    0.00020200f, 0.02833390f, -0.00384223f, -0.02083548f, -0.00459083f, -0.00361749f, -0.04423710f, -0.03230685f, 
    -0.00003618f, -0.00868784f, 0.00740629f, 0.00915094f, -0.01722123f, -0.02578253f, 0.00583270f, 0.02029244f, 
    0.00043146f, 0.02597987f, -0.02277382f, -0.00192140f, 0.00961291f, 0.01891863f, -0.02102475f, -0.00892467f, 
    0.01776838f, -0.02386213f, -0.00617936f, 0.01031855f, -0.02956514f, -0.02001806f, -0.02781495f, 0.01812637f, 
    -0.02528918f, 0.02802252f, -0.03752949f, 0.01543041f, -0.02459037f, -0.04155151f, -0.01866109f, -0.00432230f, 
    -0.00430851f, -0.01507876f, 0.00058865f, 0.00374698f, 0.01910350f, -0.01146385f, -0.01621312f, -0.01892307f, 
    0.00691763f, -0.00391664f, 0.02042608f, -0.01304140f, 0.01021765f, -0.01301575f, 0.01584089f, 0.01548688f, 
    -0.00594169f, 0.00085591f, -0.00581744f, 0.02960358f, -0.01205224f, -0.01065422f, 0.02483016f, 0.03155028f, 
    0.00770459f, -0.04116127f, -0.01505503f, 0.01525886f, -0.02955876f, -0.00911112f, 0.00796569f, 0.00621984f, 
    0.00716857f, -0.04195170f, 0.00441887f, 0.02003293f, 0.03086134f, 0.00667384f, 0.02354953f, 0.03410104f, 
    -0.02334571f, -0.03413233f, 0.02087059f, 0.02865403f, -0.01591327f, -0.00342757f, 0.00590723f, 0.02473884f, 
    0.00812694f, -0.03814879f, -0.00535387f, -0.02815872f, 0.00358655f, -0.00484447f, -0.02270276f, 0.00022393f, 
    0.00069642f, -0.02896049f, -0.03103436f, -0.01188232f, -0.02053884f, -0.04042282f, -0.01950522f, -0.00449762f, 
    -0.03081801f, 0.01804645f, 0.00670717f, 0.02445095f, -0.00392067f, -0.01019126f, 0.01348630f, -0.00626401f, 
    0.02217121f, -0.04146912f, 0.02999208f, -0.01421166f, -0.02386587f, -0.00570725f, -0.00667708f, 0.00514074f, 
    -0.00644293f, -0.04087313f, -0.01812707f, -0.03831687f, 0.00469996f, -0.04235998f, -0.03420434f, 0.02521019f, 
    0.02685984f, -0.03519929f, 0.00962840f, 0.01469534f, -0.02609768f, -0.00807319f, -0.03455452f, -0.00666780f, 
    0.00786373f, -0.01683767f, 0.02613960f, -0.01398155f, 0.02664877f, -0.00506690f, 0.02170851f, -0.01483942f, 
    -0.00345497f, 0.00442289f, -0.03113586f, -0.01225162f, 0.02517258f, -0.00573479f, -0.01719034f, 0.01911457f, 
    0.03894120f, 0.02915088f, -0.00002843f, 0.01095089f, -0.03673919f, -0.03736763f, -0.04145410f, -0.02617899f, 
    -0.02002166f, -0.04415963f, 0.01656733f, -0.02951802f, -0.00571142f, -0.00039742f, -0.03299931f, 0.02020168f, 
    0.00673388f, -0.01159020f, 0.01192956f, 0.00821724f, -0.00424653f, 0.00526468f, 0.00348190f, 0.00305557f, 
    -0.02550529f, 0.00913716f, -0.00296257f, -0.03195163f, -0.02436711f, -0.02575520f, -0.01726086f, 0.02978603f, 
    -0.01883621f, 0.02364554f, -0.03305512f, -0.02751105f, 0.00485154f, -0.02002532f, 0.02460861f, -0.02465208f, 
    0.00088818f, 0.00414004f, 0.03042218f, 0.01777690f, -0.02003015f, 0.02016809f, -0.03400756f, 0.02491850f, 
    -0.02637988f, -0.01427823f, -0.01882615f, 0.00968798f, -0.02307588f, -0.04087298f, -0.03108395f, 0.02317054f, 
    0.01529308f, -0.02052654f, -0.00042518f, 0.03084827f, -0.02966948f, 0.02677451f, -0.03495949f, -0.01637750f, 
    -0.00936935f, -0.02543700f, -0.03411890f, 0.02595695f, 0.02254241f, -0.00505632f, -0.02572182f, -0.03839158f, 
    -0.03447296f, -0.03282790f, -0.03519976f, -0.02724399f, -0.02222343f, -0.01347465f, 0.00249524f, -0.02046981f, 
    0.01440164f, 0.01372115f, -0.03413587f, -0.03485429f, -0.03348117f, -0.02874298f, 0.02246495f, 0.01375575f, 
    -0.02273722f, -0.00690607f, -0.00339817f, -0.00162534f, -0.01099266f, 0.01726891f, -0.00170343f, -0.00671283f, 
    -0.03932174f, -0.01141555f, -0.02637993f, -0.03676051f, -0.00590743f, 0.02398468f, -0.01503343f, 0.00241814f, 
    -0.02222425f, -0.00081650f, 0.02288062f, -0.02498114f, -0.00808340f, -0.02727170f, -0.02525798f, 0.02213706f, 
    -0.00679111f, -0.00453241f, -0.03270306f, -0.01373190f, 0.00022274f, -0.02661300f, -0.00831068f, 0.01941648f, 
    -0.00084992f, 0.00596433f, 0.00471920f, 0.00304709f, 0.02591657f, -0.03082586f, 0.00879928f, -0.01966243f, 
    0.02607124f, -0.03908381f, 0.01216619f, -0.01734350f, 0.02175503f, -0.03324939f, 0.00104388f, 0.01198539f, 
    -0.01428938f, -0.03205131f, 0.02642318f, 0.00647374f, 0.01614588f, 0.00233130f, -0.00647355f, 0.02312533f, 
    0.02276464f, -0.02688420f, -0.03227768f, 0.02736034f, 0.00688878f, -0.00801209f, -0.01018736f, -0.01780723f, 
    0.01585086f, 0.02698484f, 0.00707641f, -0.00478456f, 0.02690457f, -0.01631472f, -0.02467714f, -0.01575530f, 
    0.01522020f, -0.03241255f, -0.01435987f, 0.00644320f, -0.03637361f, -0.02564771f, -0.02067715f, -0.02756407f, 
    -0.02266387f, 0.01508080f, -0.01220678f, -0.03695313f, 0.02921439f, -0.02937177f, 0.01184208f, -0.00366242f, 
    0.02219711f, -0.01507383f, 0.01924173f, 0.02526888f, -0.01063736f, -0.02670487f, -0.03427489f, -0.00566539f, 
    -0.03027245f, 0.00357559f, -0.01918060f, 0.00854879f, 0.01283595f, -0.00805648f, -0.02497884f, -0.00512873f, 
    -0.00023874f, -0.03313310f, 0.00664238f, -0.04091514f, 0.00612204f, 0.02262983f, 0.01832625f, 0.00674950f, 
    0.01685524f, -0.02786214f, 0.00873718f, -0.02202838f, -0.03976089f, 0.01089518f, 0.00298669f, -0.02531114f, 
    -0.02868002f, 0.01755286f, 0.01667413f, 0.02510819f, -0.03163265f, -0.02987043f, -0.00913061f, -0.00472221f, 
    -0.00067414f, 0.02328001f, -0.01209679f, -0.02798334f, -0.02779918f, -0.03886554f, -0.01512996f, -0.02250782f, 
    -0.03664633f, -0.03722610f, -0.03698649f, -0.02987785f, -0.01224651f, -0.00274653f, -0.02278133f, 0.00299882f, 
    0.00949835f, -0.00196506f, -0.03822529f, -0.00763377f, 0.00666642f, -0.03560792f, -0.02861526f, 0.02196852f, 
    0.00399881f, 0.02199275f, 0.00756817f, 0.02588309f, -0.03671413f, -0.01350138f, -0.02655146f, 0.02303756f, 
    -0.00539308f, -0.03253517f, -0.00611775f, -0.01978452f, 0.01448361f, -0.03259672f, 0.01422182f, 0.02703871f, 
    -0.00962972f, -0.04021045f, -0.00207547f, -0.01876189f, -0.02111304f, 0.00268674f, -0.03571053f, -0.03250463f, 
    -0.03818508f, -0.01904321f, -0.01355809f, -0.03797905f, 0.02595063f, -0.01988649f, 0.00203080f, 0.00807724f, 
    -0.03927010f, -0.04336988f, 0.02098534f, 0.00070197f, -0.03583669f, -0.03951886f, -0.02810813f, -0.02400822f, 
    -0.00255179f, 0.01579293f, 0.01190029f, -0.03945854f, 0.00362404f, 0.02508598f, -0.02811278f, -0.01994588f, 
    0.02274569f, -0.02240379f, -0.03043183f, 0.01474776f, -0.03748417f, 0.01775625f, 0.00698742f, -0.00112160f, 
    0.00161227f, 0.01223565f, 0.01724707f, 0.02131258f, -0.01197777f, 0.01437660f, -0.01220015f, -0.01235955f, 
    -0.00969489f, 0.02430229f, -0.00448551f, 0.00896794f, -0.00862451f, 0.01437517f, -0.02277915f, 0.01789855f, 
    -0.02739680f, -0.03255352f, -0.02427348f, 0.00090566f, -0.03967964f, -0.02969441f, -0.01406169f, 0.01353267f, 
    0.15239264f, -0.03770925f, 0.05401808f, 0.01619761f, 0.00495643f, -0.02941692f, -0.09815542f, 0.03985758f, 
    0.06045822f, 0.07847586f, 0.14490604f, 0.02913135f, 0.27240396f, 0.00106282f, -0.25555801f, -0.15636395f, 
    -0.15913732f, -0.06455258f, -0.02916853f, 0.13145025f, 0.02763285f, -0.07891489f, -0.02993158f, 0.13738453f, 
    0.23019697f, 0.29724035f, 0.04786929f, -0.04099300f, -0.09363680f, -0.14410026f, -0.05836068f, 0.00056449f, 
    0.01024139f, 0.00216639f, -0.06591811f, -0.14746928f, 0.35552210f, 0.00494127f, -0.06282949f, -0.13744986f, 
    -0.03310863f, 0.29276854f, -0.08523294f, 0.20250332f, 0.01975501f, -0.24101794f, 0.01933123f, -0.13419549f, 
    -0.26344913f, 0.00894161f, -0.18819630f, 0.11495800f, 0.02048536f, -0.13605314f, 0.05858325f, 0.08820032f, 
    0.08572023f, -0.07035372f, -0.04919069f, -0.09341736f, 0.23943573f, 0.07826351f, -0.38675401f, -0.01169359f, 
    -0.03390611f, -0.04871222f, 0.12468860f, -0.06949904f, -0.10768636f, -0.07498395f, -0.16784570f, -0.04158162f, 
    -0.10926911f, 0.20016715f, -0.25085521f, -0.07872372f, -0.09745006f, 0.04951497f, 0.14891760f, 0.17338067f, 
    0.06144928f, -0.00385121f, 0.19797041f, 0.21396263f, 0.20014666f, 0.24814533f, -0.05581864f, 0.01101972f, 
    -0.04065511f, -0.02157514f, -0.01832720f, -0.18405816f, -0.05980759f, 0.03154175f, 0.08246876f, 0.06541417f, 
    0.12358916f, 0.05184448f, -0.02226380f, 0.10920101f, 0.02106134f, 0.09638610f, 0.00959145f, -0.02102410f, 
    -0.16594200f, -0.04763092f, -0.11867253f, 0.02961662f, 0.13122880f, 0.00806119f, -0.13388857f, -0.17581044f, 
    -0.03196161f, 0.15820004f, 0.03590127f, -0.04699151f, -0.14582878f, -0.07716926f, -0.04449524f, 0.10322797f, 
    -0.27469039f, 0.03516492f, -0.00673103f, 0.17277445f, 0.05828579f, 0.05650247f, 0.01383514f, -0.00849286f, 
    -0.00337996f, 0.09433708f, -0.04948938f, 0.00399848f, 0.24074858f, 0.16012952f, 0.06153760f, -0.24321581f, 
    -0.02389392f, -0.10785358f, 0.08819614f, 0.10655619f, 0.09677250f, 0.02094911f, -0.04105673f, -0.04564307f, 
    0.23536101f, 0.02174267f, -0.18209939f, -0.05907400f, 0.06956719f, -0.07796613f, -0.02943768f, -0.10832129f, 
    -0.05470103f, -0.09216959f, -0.08390036f, -0.03439903f, -0.26241234f, 0.18147220f, -0.30478480f, 0.27145767f, 
    -0.11253177f, 0.08875723f, 0.03366728f, 0.04785635f, 0.02342659f, 0.13294813f, 0.37902990f, 0.01659258f, 
    0.08472419f, 0.08975290f, 0.00761470f, -0.02693270f, 0.06585710f, 0.22195083f, 0.21226788f, 0.13718569f, 
    -0.06027196f, 0.15036209f, 0.21641389f, 0.06653225f, 0.33844075f, 0.09646076f, 0.04846538f, -0.17742755f, 
    0.15239528f, 0.16510476f, 0.07977747f, 0.05126137f, -0.00843441f, 0.06584428f, 0.00451402f, -0.08445975f, 
    0.04532633f, -0.10893571f, -0.10577432f, -0.05166421f, 0.03782183f, -0.02862879f, 0.01355296f, 0.02078590f, 
    -0.08460300f, 0.05955229f, 0.09199663f, 0.24507548f, -0.20409302f, -0.07970042f, -0.05031140f, 0.02495976f, 
    -0.03543395f, -0.07864150f, 0.02429935f, 0.11555322f, 0.14254667f, 0.17559059f, 0.01025889f, 0.14820483f, 
    0.01481581f, -0.24278857f, -0.07230771f, -0.06446816f, 0.06150608f, -0.00943760f, -0.06019886f, 0.11278630f, 
    -0.03534383f, -0.16600919f, -0.03586911f, -0.12425888f, -0.11835817f, -0.12424772f, -0.11236341f, -0.13320449f, 
    0.06204937f, 0.02655168f, -0.01196792f, -0.00685452f, 0.11846711f, 0.07610033f, 0.03037029f, 0.12769485f, 
    -0.32487807f, -0.14576226f, 0.07110935f, 0.09527612f, -0.05594284f, 0.01291152f, -0.04425746f, 0.00893325f, 
    -0.01091633f, 0.02868527f, 0.14369237f, -0.01730436f, -0.02427745f, -0.11741957f, 0.07658508f, 0.15122578f, 
    0.09960936f, -0.06375647f, 0.04935315f, 0.11922651f, -0.03100624f, -0.11176124f, -0.05146994f, -0.16333860f, 
    -0.15441494f, 0.06502042f, -0.07781618f, 0.05351510f, -0.07759373f, -0.08765923f, -0.01289255f, -0.07125879f, 
    0.10983709f, 0.03505915f, -0.06774922f, 0.12338060f, 0.16944310f, 0.04593685f, 0.00773230f, -0.01509015f, 
    0.01421354f, 0.09875134f, 0.10921940f, -0.17589439f, -0.00733349f, 0.00108731f, 0.15566079f, 0.06205009f, 
    0.01477954f, -0.15838251f, -0.04018132f, -0.07090198f, -0.04344852f, 0.04604361f, -0.14262910f, -0.07354712f, 
    -0.07278761f, -0.13002717f, -0.10492392f, -0.12653357f, 0.29273829f, 0.02500059f, 0.02897074f, -0.04497432f, 
    0.09203771f, 0.12146271f, -0.05913883f, 0.01302368f, -0.10134405f, -0.07171884f, 0.07235358f, 0.04433088f, 
    -0.50964618f, -0.17361654f, 0.04344755f, -0.16212054f, -0.02343444f, 0.02016582f, 0.17269261f, 0.14989279f, 
    -0.00936618f, -0.00284759f, -0.04826049f, -0.18489188f, -0.24665111f, 0.06379066f, -0.01591840f, -0.12106344f, 
    -0.00251988f, 0.09564066f, -0.06224686f, 0.07187945f, 0.11499700f, 0.23258550f, 0.25648350f, 0.09488536f, 
    0.20195490f, -0.00226799f, -0.05875218f, -0.21878795f, 0.05454838f, -0.07676084f, -0.00223632f, -0.11068751f, 
    -0.10584419f, -0.05880601f, -0.04455285f, -0.06499036f, -0.35952154f, 0.15204778f, -0.13550207f, 0.01042497f, 
    -0.19257045f, 0.02416289f, 0.02203709f, -0.11041912f, -0.07268276f, -0.17174047f, -0.12221493f, -0.06815062f, 
    0.18083851f, -0.08557056f, -0.01529155f, -0.03385554f, 0.02188429f, -0.08839074f, 0.07790875f, -0.10630747f, 
    0.14981204f, -0.02287704f, 0.01919854f, 0.01197324f, -0.08131712f, -0.16120194f, 0.36482790f, -0.02137616f, 
    -0.04090882f, -0.01855361f, -0.01876005f, -0.02927375f, -0.02779245f, 0.06794088f, 0.05097805f, 0.03247696f, 
    -0.07843307f, 0.06170579f, -0.08863728f, 0.05053383f, -0.02512054f, -0.06256980f, 0.01953743f, 0.03031869f, 
    0.09303581f, 0.13007328f, 0.05548983f, 0.06661265f, -0.09730297f, -0.09316582f, -0.01425305f, 0.06180343f, 
    0.02552563f, -0.00728369f, 0.16468391f, 0.16968873f, 0.12234421f, 0.17180246f, 0.16776097f, 0.09343856f, 
    0.32156137f, 0.16122845f, 0.23576367f, -0.08709372f, 0.20942621f, -0.11928845f, 0.06536876f, -0.12659100f, 
    0.00350853f, -0.02305778f, 0.27247709f, -0.03274702f, 0.15778038f, 0.02839250f, 0.06299198f, 0.06833362f, 
    -0.06921072f, -0.10818227f, 0.05325866f, 0.05196379f, 0.02643535f, 0.06570956f, 0.11613118f, 0.05484902f, 
    -0.10984202f, -0.18564087f, -0.04920199f, 0.13359353f, 0.06279068f, -0.03832285f, 0.09243879f, -0.01867425f, 
    0.01870868f, 0.03956655f, 0.07085203f, -0.02341234f, 0.21492504f, 0.10925812f, 0.00839643f, -0.09198005f, 
    -0.02748999f, 0.03073601f, -0.09744659f, 0.17730747f, 0.02052715f, -0.01846160f, 0.08363577f, -0.03752605f, 
    0.05896384f, -0.04998004f, -0.26423460f, 0.09371921f, 0.01926111f, -0.05815835f, 0.08841448f, -0.00969552f, 
    -0.09748752f, 0.10359902f, -0.05234332f, -0.13490200f, -0.27548081f, -0.16049193f, -0.38064134f, 0.09078822f, 
    0.07403152f, 0.09592596f, -0.11010758f, -0.00132941f, -0.10751048f, 0.10159110f, 0.14193529f, 0.07598642f, 
    -0.11007208f, -0.05561167f, -0.08276048f, -0.05723440f, 0.03293460f, 0.01178072f, 0.00109839f, 0.07465389f, 
    -0.02532598f, -0.10753503f, -0.08018562f, 0.06948871f, -0.09732392f, -0.04794921f, -0.07100530f, -0.04064531f, 
    -0.07752217f, -0.03909563f, -0.06678674f, 0.05820836f, -0.05247091f, 0.06224776f, 0.07519937f, -0.01933771f, 
    0.06809306f, 0.25131652f, -0.05562255f, 0.00780796f, 0.03644660f, 0.10407539f, 0.03298083f, 0.04778906f, 
    -0.06012770f, 0.00976443f, 0.05798335f, -0.02367159f, -0.29468572f, -0.27682662f, 0.13891049f, -0.00183244f, 
    -0.00944418f, -0.04268302f, -0.00588936f, 0.19563447f, 0.03900468f, -0.09018288f, 0.16987437f, -0.11102500f, 
    0.20470117f, 0.10966265f, 0.04848303f, 0.08441575f, 0.12616640f, 0.15278316f, 0.15957524f, 0.02560223f, 
    -0.05150677f, -0.00535880f, -0.09244094f, -0.01340540f, 0.16600002f, -0.00371964f, 0.09850304f, 0.08909436f, 
    -0.02371752f, -0.06285207f, -0.00424435f, -0.13326247f, -0.03550447f, -0.10702618f, -0.04160881f, 0.05167345f, 
    0.45597336f, -0.14839861f, -0.16706586f, 0.00383299f, -0.10471154f, -0.00724021f, 0.01201638f, -0.07333145f, 
    -0.09841781f, -0.00307521f, -0.02702246f, -0.10031115f, 0.05147568f, 0.07232898f, -0.05001973f, -0.07112309f, 
    0.05770143f, -0.07054876f, 0.05483453f, -0.02946876f, -0.11524633f, -0.07142944f, -0.05401319f, -0.15756316f, 
    -0.19086199f, 0.09393197f, 0.02552612f, -0.13318036f, 0.00993665f, -0.00092382f, 0.16051525f, -0.04363947f, 
    0.02297566f, 0.23964415f, 0.10190406f, 0.22771601f, 0.00533169f, 0.07991579f, 0.05159045f, -0.14681460f, 
    0.10757233f, -0.05358935f, 0.14898613f, -0.06266899f, -0.00867986f, -0.12489007f, -0.02548774f, -0.04390909f, 
    -0.11874015f, 0.07996155f, -0.00172167f, -0.02641173f, 0.03519509f, -0.00926886f, -0.02729314f, 0.07525808f, 
    0.04701776f, 0.04263799f, 0.06030979f, 0.11126031f, -0.06700752f, -0.11410268f, -0.09631921f, 0.12826192f, 
    0.10276221f, -0.13499437f, 0.02651461f, -0.03424477f, -0.02605574f, 0.03348704f, 0.07234714f, 0.11658698f, 
    0.37163010f, 0.12702066f, -0.15629067f, -0.06431250f, 0.14924815f, -0.12185124f, 0.03798525f, 0.07151128f, 
    0.00261536f, -0.06237231f, 0.02309585f, -0.00666266f, -0.09663910f, 0.06795780f, -0.14560337f, 0.46639434f, 
    0.00983687f, -0.08182886f, 0.08454365f, -0.06932837f, 0.07367704f, 0.10884260f, 0.09025609f, -0.03696023f, 
    0.13765672f, 0.06445681f, -0.11972383f, -0.12536567f, 0.06976112f, 0.00591014f, 0.04340794f, -0.04241879f, 
    0.04372923f, -0.05403515f, -0.01581329f, -0.06039826f, 0.04770055f, 0.11931324f, 0.12147284f, -0.18235022f, 
    0.19636384f, 0.22852230f, -0.05139245f, -0.11822847f, -0.13180132f, -0.05203115f, 0.04186846f, -0.06913865f, 
    0.49770319f, -0.16065165f, 0.15667750f, 0.00955941f, 0.15568303f, -0.06635268f, 0.10100725f, 0.13066927f, 
    0.21208791f, 0.08901814f, -0.00189720f, 0.16135237f, 0.00331482f, -0.12308332f, -0.07517315f, -0.14986897f, 
    0.06906319f, -0.05595221f, 0.03543445f, 0.15238450f, -0.04908978f, -0.02948815f, 0.08326709f, 0.08560441f, 
    0.01149169f, -0.08941449f, 0.04127818f, 0.05619778f, 0.17112340f, 0.07048056f, 0.01000698f, 0.03096877f, 
    0.04812653f, -0.07181726f, 0.01717687f, 0.00548600f, -0.09747004f, -0.20247321f, 0.15784334f, -0.14016742f, 
    0.12400448f, -0.03978693f, -0.07312068f, 0.07089274f, 0.06872767f, 0.01361470f, 0.08432174f, 0.30248994f, 
    0.14941433f, -0.14809705f, 0.09776221f, 0.22009405f, 0.08520601f, -0.00375774f, -0.01653546f, 0.07828604f, 
    0.10725725f, -0.21133967f, -0.08573687f, 0.08461259f, -0.02532424f, -0.14507549f, 0.00177998f, -0.13232550f, 
    0.14421152f, -0.03941579f, 0.09283741f, 0.07032034f, -0.06491095f, -0.05516915f, -0.30148551f, -0.12976620f, 
    -0.01212400f, 0.00238721f, -0.02953635f, 0.11568275f, -0.04480466f, -0.06541620f, 0.03294905f, 0.06580840f, 
    0.00976965f, 0.04479222f, 0.06096649f, 0.10578375f, -0.40695071f, -0.04005967f, -0.16846721f, -0.07976380f, 
    -0.01557144f, 0.16342404f, 0.24518923f, 0.25253266f, -0.01237474f, 0.02182697f, 0.21471174f, 0.03613109f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07647573f, -0.03704930f, 0.02980992f, 0.05324465f, 0.03186467f, 0.00073697f, 0.07132258f, 0.00829059f, 
    -0.02292666f, -0.03650521f, 0.00181795f, 0.07266435f, 0.13935736f, -0.02004968f, 0.02457359f, -0.00650815f, 
    0.09590334f, 0.17500035f, 0.10160360f, 0.00549832f, 0.12071634f, 0.01730329f, -0.11220817f, 0.12529409f, 
    0.02395383f, -0.00502437f, -0.00644321f, 0.08242189f, -0.02588373f, -0.00172631f, -0.00211420f, -0.03571986f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19625048f, 0.08222187f, -0.09114078f, 0.16549920f, 0.11314218f, 0.01048290f, 0.19044936f, 0.03237500f, 
    -0.02811834f, 0.14992993f, -0.04020435f, -0.33117938f, -0.29371825f, -0.10785156f, -0.62906700f, 0.16814764f, 
    -0.47262794f, 0.19776994f, -0.03885930f, 0.05346186f, -0.41226929f, 0.02903405f, 0.05068424f, 0.04802791f, 
    0.07358029f, 0.08688475f, -0.04300535f, -0.59171760f, -0.12372313f, -0.25609642f, 0.13416864f, 0.41292650f, 
    0.01051409f, 0.17011000f, -0.00772696f, 0.18748209f, -0.09222131f, -0.00765194f, -0.04580348f, 0.04974053f, 
    -0.03833881f, 0.04979420f, 0.08238672f, 0.42105508f, 0.16258132f, -0.12005455f, -0.14784423f, 0.11263667f, 
    -0.28389233f, 0.14143983f, 0.25212154f, 0.11993899f, 0.33748594f, 0.03352830f, -0.68863106f, 0.27249095f, 
    0.00671169f, -0.12932834f, -0.11457045f, -0.36590073f, 0.11837340f, -0.53993899f, -0.16615079f, -0.29270196f, 
    0.19492194f, -0.00005825f, -0.00470360f, -0.53478038f, 0.12181371f, 0.01638122f, -0.09985176f, 0.10972863f, 
    0.07914694f, 0.15746227f, 0.00643998f, -0.82855147f, 0.07371531f, -0.10504258f, -0.14763193f, -0.02957653f, 
    0.37286717f, -0.07460319f, 0.25408900f, 0.16406323f, -0.00437148f, 0.15517589f, -0.01815176f, 0.17645523f, 
    0.10390147f, 0.16608168f, -0.11736742f, -0.26698813f, 0.11350206f, 0.24523033f, 0.17207998f, -0.52571148f, 
    -0.24993537f, -0.15379979f, 0.07549682f, -0.06396081f, 0.08034698f, -0.05233304f, -0.44557574f, -0.10490786f, 
    0.15465300f, -0.14713673f, 0.05490346f, -0.12014997f, 0.29852572f, -0.16894375f, -0.25683215f, -0.15223920f, 
    -0.09848597f, -0.09584841f, 0.31322759f, 0.13985582f, -0.51154238f, 0.11475057f, 0.38206458f, -0.35165855f, 
    -0.01890666f, -0.13261540f, 0.01004466f, -0.24727286f, 0.17146672f, 0.29169357f, -0.09033826f, -0.15722965f, 
    0.16459087f, 0.12396085f, -0.15797777f, -0.14796223f, 0.09714691f, 0.11020381f, 0.07048475f, -0.01935453f, 
    0.07602470f, -0.13375013f, 0.06327085f, -0.12636590f, -0.02635561f, 0.08814391f, 0.12147737f, -0.03374541f, 
    -0.23093595f, -0.41843221f, -0.42913264f, 0.09435195f, 0.10537049f, 0.23057789f, 0.21966608f, -0.26824132f, 
    0.01910630f, 0.07478437f, 0.04908405f, -0.02328274f, 0.08833314f, 0.09225689f, -0.17078273f, 0.10517135f, 
    0.12068801f, 0.00389955f, 0.00031267f, 0.11587531f, -0.06245012f, 0.16911156f, 0.40870237f, 0.13906154f, 
    0.11675096f, -0.04454257f, 0.02146651f, 0.22962332f, 0.08122608f, 0.05607768f, -0.11293113f, 0.09681059f, 
    0.34635973f, 0.12668473f, -0.26957932f, -0.14581393f, -0.13346362f, -0.22731924f, -0.25376928f, -0.43598896f, 
    0.12785988f, 0.09373660f, -0.14988272f, 0.37139153f, 0.15911829f, -0.21858285f, -0.12555154f, -0.07591587f, 
    0.21399929f, -0.14495561f, -0.09200808f, -0.67373782f, 0.02398823f, -0.10411151f, -0.69758689f, -0.12504369f, 
    -0.12927039f, 0.06465949f, -0.13397335f, -0.11491763f, -0.47497112f, -0.01879825f, 0.21038984f, -0.07053523f, 
    0.11024655f, 0.16025746f, 0.16731265f, 0.17073943f, -0.04251522f, -0.55085403f, -0.27177906f, 0.02240922f, 
    -0.09963676f, 0.15998743f, -0.07683954f, 0.26723427f, -0.08082582f, 0.42020664f, -0.10383995f, 0.17322989f, 
    -0.44379288f, 0.15040660f, -0.05563653f, -0.21621059f, -0.65588897f, -0.06296697f, 0.47759524f, 0.12224588f, 
    -0.03845443f, 0.01547394f, 0.06087564f, -0.03057009f, 0.06242759f, -0.09948485f, 0.32385001f, -0.10012425f, 
    -0.01408156f, -0.22868808f, 0.17864500f, 0.05431269f, -0.14029507f, -0.57637227f, 0.40982386f, 0.10672324f, 
    -0.12185471f, 0.06365616f, 0.08005648f, 0.06154643f, 0.09986731f, 0.11938410f, -0.00551465f, -0.45220578f, 
    -0.57576972f, 0.04945056f, -0.00830824f, -0.33355698f, -0.29880190f, -0.05191867f, 0.36915773f, -0.13879846f, 
    0.00799407f, 0.13390021f, 0.03982318f, -0.19351275f, 0.43014711f, -0.00404800f, -0.32345402f, -0.10539105f, 
    0.12088463f, 0.29769212f, 0.29761088f, -0.06799497f, 0.02529131f, -0.75574744f, -0.43554294f, -0.29935011f, 
    -0.08288819f, 0.10739408f, 0.14835332f, 0.28750923f, -0.08870656f, -0.06621239f, -0.15485665f, 0.14969376f, 
    0.37090850f, 0.15756966f, 0.00778777f, -0.36161691f, 0.27028722f, 0.04364912f, 0.26904470f, -0.12303851f, 
    -0.03187589f, -0.16442135f, 0.10352575f, 0.15473782f, -0.11284245f, -0.03561766f, 0.05820487f, 0.15956901f, 
    -0.40067467f, -0.14759952f, -0.03451689f, -0.15766773f, 0.00735780f, -0.07437979f, 0.22009382f, 0.08910207f, 
    -0.13880725f, -0.04008347f, 0.10895354f, 0.32267022f, 0.06894799f, -0.16526817f, -0.01468415f, -0.10438745f, 
    -0.31660679f, -0.14277039f, 0.02581813f, 0.10415304f, 0.26695168f, -0.05997617f, -0.54637653f, -0.09364083f, 
    0.07715151f, -0.09553619f, -0.15149890f, -0.32356319f, 0.13862590f, -0.14454824f, 0.07947361f, -0.07110683f, 
    -0.20902574f, 0.29765907f, -0.32255325f, -0.10294142f, 0.28283817f, -0.21687408f, -0.52698714f, -0.10387401f, 
    -0.03058787f, 0.03663816f, -0.08484624f, -0.11666751f, 0.09305698f, 0.42919657f, 0.06037007f, -0.49040350f, 
    -0.59552914f, 0.09004945f, 0.12298822f, -0.47274119f, -0.14786576f, -0.04266882f, -0.39895201f, 0.06356545f, 
    0.07594600f, 0.15848228f, -0.08204346f, -0.02451240f, -0.02653149f, -0.16241428f, 0.26052034f, 0.04338748f, 
    0.00099180f, 0.24737400f, 0.12881447f, 0.14712681f, 0.35788795f, 0.10854947f, -0.10309502f, -0.22622642f, 
    0.13144344f, 0.02417699f, 0.13049644f, 0.28988355f, 0.15143411f, -0.20720476f, 0.05613649f, 0.29213369f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.52930665f, 0.68112034f, 0.32265180f, -0.72527391f, 0.18020962f, 0.47716400f, -0.18212150f, -0.09552654f, 
    -0.53806442f, -0.76257461f, -0.89772326f, -0.86192185f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
