#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84153777f, 0.92989743f, 1.15454447f, -1.23424911f, -0.72137588f, 0.86006099f, 0.00365309f, 0.11871823f, 
    -0.15523447f, -1.53536379f, -1.00297475f, -1.08115339f, 0.80826700f, 0.63887131f, -0.27770823f, -0.43686858f, 
    -0.70352179f, -0.68946147f, -1.69653618f, 1.38804007f, -0.13829584f, -0.13998616f, -0.30556843f, 0.41048437f, 
    0.08858030f, -0.40273467f, -0.31662029f, 0.95695496f, -0.46788281f, -0.90036356f, -1.22080195f, -0.69582570f, 
    0.42482316f, 0.29050395f, 0.49326262f, 0.64629358f, 0.30032378f, 0.46450004f, 0.23944011f, -0.96433955f, 
    0.87270463f, 0.30962458f, 0.34554040f, -0.36683509f, -0.45458475f, -0.78402525f, 0.06412589f, 0.76256853f, 
    0.62922442f, 0.91915518f, -0.36306646f, -0.17811812f, 0.18554781f, -0.37228492f, 1.35978782f, 0.17328778f, 
    -0.94038755f, -0.25325519f, -1.05718124f, -0.99725175f, -0.83954424f, -0.39660019f, -0.78648633f, -1.10556507f, 
    -0.33871189f, -0.49035808f, 0.15304074f, -0.13614587f, -0.43854156f, 0.13435827f, 0.94023722f, 0.46270040f, 
    -0.80572748f, 0.73587942f, -0.18197657f, -0.12860037f, 0.48470134f, 0.85055238f, -0.56815410f, -0.49714756f, 
    0.54640132f, -0.59090799f, -1.23531759f, -0.21835035f, -1.23142481f, -1.48841155f, -1.10709250f, 0.63900554f, 
    -0.20138118f, 0.08700082f, 1.06575572f, 0.93073028f, -0.71777654f, -0.41886887f, -0.57495940f, -0.22270194f, 
    0.42388743f, 0.15742038f, 0.28364614f, -1.65588975f, 0.37347054f, -1.02150691f, 0.74285793f, -0.02893005f, 
    0.59629518f, 0.23428917f, 0.04283115f, 0.22095263f, -0.56580412f, 0.01668082f, -0.32147089f, 0.11148175f, 
    0.79879320f, -1.04675508f, 0.48541909f, -0.25364712f, 0.31883556f, -1.40848780f, -0.28965566f, 0.95193988f, 
    0.85091448f, -0.60985970f, 0.38789037f, -0.30453005f, -0.50853872f, -0.35021010f, -0.90475422f, -0.86688387f, 
    0.07486949f, 0.95511216f, 0.49346912f, -0.45185554f, 0.42553174f, 0.22330318f, 0.08940656f, 0.28556377f, 
    0.24098851f, -0.44205958f, -0.26878366f, 0.71558756f, 0.44257575f, -0.13310029f, 0.94322938f, 0.25385243f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30863157f, -0.13939908f, 0.37021339f, 0.27903998f, 0.48089367f, 0.61255008f, 0.06883286f, 0.52570844f, 
    0.42033800f, -0.22477604f, 0.29333535f, 0.15383440f, 0.48693019f, -0.35329008f, 0.05123503f, 0.15829670f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -1.00815773f, 0.17821847f, 0.67516971f, -0.35530847f, -0.06327307f, -0.29948518f, -0.24835689f, -0.17521067f, 
    0.12976024f, -0.27974400f, 0.12385337f, -0.05642861f, -0.06212114f, 0.03315160f, 0.06234775f, 0.00191353f, 
    0.17696279f, -0.14144665f, -0.23606938f, -0.20429176f, 0.64410013f, 0.21576536f, -0.18889420f, -0.23930398f, 
    -0.09187255f, 0.26690075f, 0.18956222f, 0.21369581f, -0.01651297f, -0.03444889f, -0.03609103f, 0.02578182f, 
    -0.04093141f, 0.01266513f, 0.09159797f, -0.03652980f, 0.01821688f, 0.03665466f, -0.04527550f, -0.01109910f, 
    -0.61739230f, 0.05845215f, 0.22986411f, -0.20683898f, -0.09478224f, -0.45562309f, -0.07592890f, -0.04575537f, 
    -0.01935219f, -0.24916294f, 0.02877590f, -0.05487446f, -0.01988951f, -0.19631365f, -0.04474522f, -0.22756235f, 
    -0.10012326f, -0.01121876f, -0.40939394f, -0.02067275f, 0.31311977f, 0.37409747f, -0.13145937f, -0.20201483f, 
    -0.14694537f, -0.35496315f, -0.03437747f, -0.10784821f, -0.16406327f, -0.29946598f, -0.06450681f, -0.04800187f, 
    0.01701029f, 0.08342183f, 0.08587709f, -0.01684263f, -0.07002688f, 0.00878503f, -0.15450561f, -0.06898965f, 
    -0.43231183f, -0.63031167f, 0.59289807f, 0.05505018f, -0.61041588f, -0.02899878f, 0.03788418f, -0.03044229f, 
    -0.00718213f, 0.00433766f, -0.07971189f, 0.00032019f, -0.05445479f, 0.10136376f, 0.05802894f, -0.13663365f, 
    -0.01736712f, -0.28575698f, -0.12928620f, -0.07280875f, -0.25066149f, -0.29400864f, -0.26388240f, -0.19273616f, 
    -0.14655825f, -0.08480887f, -0.02933975f, 0.10736258f, 0.14789680f, 0.03509967f, -0.26396054f, -0.08403418f, 
    -0.12550244f, -0.13652781f, -0.07073443f, 0.05744362f, 0.00468701f, 0.01569354f, 0.11651054f, 0.14259714f, 
    -0.03976958f, 0.28690392f, 0.02090258f, -0.31060004f, -0.24392539f, -0.11016284f, -0.10825318f, -0.14286797f, 
    -0.13823009f, 0.16550815f, -0.09295517f, -0.06813297f, -0.02620492f, -0.06235219f, 0.00735807f, -0.07465336f, 
    -0.06973278f, 0.18726751f, 0.12068018f, 0.25140321f, 0.37527594f, 0.34385794f, -0.03918474f, -0.11453237f, 
    0.00801204f, -0.01216216f, 0.08212303f, 0.15670763f, -0.19441774f, -0.09614785f, 0.01298936f, -0.31468746f, 
    0.00348048f, 0.00841519f, 0.01748400f, -0.06287997f, -0.10209245f, -0.09644334f, -0.03825421f, -0.04232120f, 
    -0.66830683f, -0.48270187f, 0.26322952f, 0.10874265f, 0.08108263f, 0.03663989f, -0.05878391f, -0.02582612f, 
    0.09414426f, -0.04575080f, 0.12087107f, -0.05254624f, 0.18403643f, -0.08172503f, -0.11606077f, -0.03999940f, 
    -0.04419953f, 0.02677464f, -0.00847919f, -0.10066345f, 0.61803991f, 0.51271707f, 0.36541834f, -0.77329379f, 
    -0.04515947f, 0.26830810f, 0.38566849f, -0.00234984f, 0.21778753f, 0.09371109f, 0.03619273f, -0.00710258f, 
    -0.04484074f, -0.07630377f, -0.03074905f, -0.01966094f, -0.02562667f, -0.09189795f, 0.01157679f, -0.00547128f, 
    -0.00222174f, -0.06891363f, -0.28247523f, 0.06694102f, -0.26431465f, -0.27579144f, -0.11987770f, -0.26894590f, 
    0.11889356f, 0.03650995f, 0.01398606f, 0.04928541f, 0.03941736f, -0.00758520f, 0.03757416f, -0.17632972f, 
    -0.01462147f, -0.08113048f, -0.14140029f, -0.30987218f, 0.24307564f, -0.22258922f, 0.11563634f, -0.13523136f, 
    0.20293759f, 0.09018344f, 0.27960509f, 0.16418611f, -0.02229160f, -0.16028459f, -0.08266622f, -0.02610320f, 
    -0.10959181f, 0.02623705f, 0.12506732f, 0.03558110f, 0.06991749f, 0.02641252f, -0.04876936f, -0.03252113f, 
    0.18144369f, 0.25251356f, -0.20637034f, -0.20400639f, -0.15915939f, -0.09332846f, -0.06317063f, -0.13737455f, 
    -0.33835468f, 0.01511561f, -0.05007483f, -0.22193854f, -0.18975998f, -0.11042485f, -0.02665711f, -0.14766401f, 
    -0.18620916f, -0.27704930f, -0.01906230f, -0.10565586f, 0.60122347f, 0.31877118f, 0.49633422f, -0.93736959f, 
    0.16879456f, -0.05109961f, 0.11452977f, 0.14755172f, 0.23734255f, -0.01980413f, 0.11489445f, 0.10985140f, 
    -0.04193006f, -0.18353763f, -0.14452051f, 0.17648827f, -0.15529171f, 0.19806927f, -0.01207004f, 0.27746847f, 
    0.33735672f, 0.29189712f, -0.19350913f, -0.10506999f, 0.15691282f, 0.13600716f, 0.14846091f, 0.09199139f, 
    0.02899576f, -0.01661171f, 0.10501432f, 0.07454311f, -0.18238784f, 0.08291036f, 0.06978665f, 0.01319103f, 
    0.10617603f, 0.10167711f, -0.00354869f, 0.09962329f, 0.01250656f, -0.04334658f, 0.05254316f, 0.07966191f, 
    0.05727220f, 0.02141731f, 0.00429356f, 0.03403224f, 0.13351583f, 0.08589561f, -0.06111014f, -0.10926693f, 
    -0.27349439f, -0.10836228f, -0.00045277f, 0.01804713f, -0.00086779f, 0.01241433f, -0.11276402f, -0.03347201f, 
    -0.25333861f, -0.55418962f, 0.42709827f, -0.24488996f, 0.13991675f, 0.05194020f, 0.11451442f, -0.05447101f, 
    0.00769477f, -0.02262484f, -0.03859469f, 0.02229206f, 0.05492269f, 0.05182302f, -0.00550729f, 0.00235820f, 
    0.13796309f, 0.10590740f, 0.10582633f, -0.04169646f, 0.61796790f, 0.17071448f, 0.55336678f, -0.04113607f, 
    -0.25433177f, 0.19506547f, -0.10277794f, 0.13816205f, 0.30199260f, -0.02741133f, 0.14311995f, -0.05154643f, 
    -0.04559087f, -0.28268579f, 0.00269492f, 0.17385690f, -0.00998532f, -0.30656216f, 0.01754912f, 0.06964877f, 
    -1.47427285f, -0.39298365f, -0.14683820f, -0.20997262f, 0.09939604f, 0.33904600f, -0.03746486f, -0.03618828f, 
    -0.06301525f, 0.03589751f, 0.01065301f, 0.15409733f, -0.06800790f, 0.04202458f, 0.13570863f, 0.05994205f, 
    -0.09071198f, 0.06082165f, 0.11747504f, 0.05370169f, -0.24644372f, -0.23243378f, 0.00930297f, -0.10368933f, 
    -0.11604492f, 0.16571243f, 0.22725596f, 0.07748976f, -0.37087610f, 0.14489956f, 0.09382110f, 0.02519657f, 
    0.07947209f, 0.13189991f, 0.00902907f, 0.00547045f, -0.03479335f, -0.00371090f, 0.02439318f, 0.21556115f, 
    0.57640421f, 0.10786711f, 0.36318895f, 0.13901937f, 0.20720692f, -0.02675143f, -0.01017624f, 0.04023355f, 
    -0.13632551f, 0.12937191f, -0.09020668f, -0.00723462f, 0.01024557f, -0.11312635f, 0.07916040f, 0.18974510f, 
    -0.05152442f, 0.11009731f, 0.14683698f, -0.00108048f, 0.41636992f, -0.03785332f, 0.15110607f, 0.24214239f, 
    0.34377620f, -0.08861446f, 0.10052249f, 0.05902230f, 0.00686030f, -0.05003814f, 0.08262137f, -0.12073910f, 
    -0.02717817f, -0.15319592f, 0.04758339f, -0.01742934f, -0.03780407f, 0.02122498f, -0.00375270f, -0.19714668f, 
    0.37811163f, 0.21315683f, -0.51629406f, -0.15874365f, -0.72119892f, 0.05899409f, -0.11489622f, -0.12671641f, 
    -0.27425757f, 0.01271163f, -0.07930911f, 0.02844804f, -0.04406384f, 0.00809933f, 0.00831051f, -0.21429659f, 
    -0.19343948f, -0.36297882f, -0.29427740f, -0.21097399f, -0.44396636f, -0.12815112f, -0.21964702f, 0.16875820f, 
    0.09049648f, 0.17845695f, 0.18347844f, 0.22229347f, 0.32343537f, -0.01936441f, -0.07881214f, -0.01973302f, 
    0.00052057f, 0.08434588f, -0.04775412f, -0.02260621f, 0.03645936f, 0.00034571f, 0.08062308f, -0.01451544f, 
    -0.42817539f, -0.24539810f, 0.26390213f, 0.18721341f, 0.15178603f, -0.04200451f, -0.08421224f, 0.15039591f, 
    -0.07913861f, -0.05354251f, 0.12447486f, -0.01078406f, -0.16299827f, -0.13738294f, -0.00703779f, 0.12424984f, 
    -0.00825188f, -0.20106149f, 0.04197418f, 0.11446837f, -0.38575619f, 0.38465607f, -0.01761358f, 0.20765527f, 
    0.34924224f, -0.20088336f, -0.17217772f, 0.02389503f, 0.00694366f, -0.04238736f, 0.03858556f, -0.00856129f, 
    0.11785956f, 0.00449319f, 0.08939154f, -0.04038458f, -0.01098073f, 0.15232643f, -0.42362183f, 0.05887851f, 
    -0.15709916f, -0.01927417f, 0.14744157f, -0.02913528f, -0.24709718f, 0.19656762f, -0.15222223f, -0.18876353f, 
    0.05472853f, -0.01711720f, 0.04310763f, -0.13007630f, -0.00186444f, 0.21196431f, 0.01083756f, 0.03625702f, 
    -0.06296303f, -0.10571983f, 0.20380476f, 0.01728556f, -0.52290040f, 0.05233927f, -0.35168496f, -0.27332324f, 
    -0.10412575f, -0.02485717f, 0.01662331f, 0.03372316f, -0.02945230f, -0.34311506f, -0.23917426f, 0.11283875f, 
    -0.10365798f, 0.08750723f, -0.11908250f, -0.05958781f, 0.00492820f, -0.04791930f, -0.05632921f, -0.00530703f, 
    0.05673242f, -0.16925690f, -0.29990515f, -0.25311977f, 0.13216741f, 0.02029126f, 0.15512165f, 0.14919648f, 
    0.30586252f, -0.11966084f, 0.07488561f, 0.02625425f, 0.09763876f, 0.04151246f, -0.05542587f, 0.04969385f, 
    0.12798052f, 0.03447855f, 0.05993596f, 0.00423232f, -0.68909848f, -0.05694622f, -0.44204766f, -0.19830634f, 
    0.18274844f, -0.07972026f, -0.06868473f, -0.11920246f, -0.02991424f, -0.18520671f, 0.12289482f, -0.01157740f, 
    0.08228512f, 0.00415627f, 0.07368670f, 0.11035081f, 0.02976578f, -0.08782490f, -0.15909559f, -0.37528092f, 
    0.44009930f, -0.06171053f, -0.21913899f, -0.15589224f, -0.12556370f, -0.13070613f, -0.08913148f, 0.08358752f, 
    0.19602969f, -0.14531113f, 0.00068029f, -0.12209026f, -0.04613383f, 0.01136319f, -0.12085204f, -0.03147599f, 
    -0.09360901f, 0.02403107f, -0.01803629f, -0.09063839f, 0.08385238f, -0.11372653f, 0.19330060f, -0.00266847f, 
    -0.07685565f, -0.11151990f, -0.09374572f, -0.04979440f, -0.09077612f, -0.04505214f, 0.25937673f, 0.10325364f, 
    -0.24379759f, 0.02941507f, 0.01755319f, -0.22460322f, -0.02416928f, -0.15367484f, 0.10847318f, 0.07108383f, 
    0.01137313f, -0.00215679f, -0.50326800f, -0.30931744f, -0.14393625f, 0.03259594f, 0.13965796f, -0.01940858f, 
    -0.06539670f, 0.15217429f, 0.07975987f, -0.04389957f, -0.03493161f, 0.07466019f, -0.09379297f, -0.06286734f, 
    -0.07341316f, 0.20260805f, -0.15685797f, -0.23868027f, -0.32567975f, -0.20761093f, 1.29394627f, 0.80995756f, 
    0.68348235f, -0.14205225f, -0.12092837f, -0.20023912f, 0.14841649f, -0.14881693f, -0.00722746f, -0.04258829f, 
    0.05496088f, -0.12472581f, 0.04836715f, -0.01842212f, 0.02335410f, 0.07276212f, -0.05374709f, -0.05701922f, 
    0.45620349f, 0.16068587f, -0.03502033f, 0.09481685f, 0.23033983f, 0.14832753f, 0.19163103f, -0.09991068f, 
    -0.19243345f, 0.25570187f, -0.16174118f, 0.03748676f, -0.03688911f, 0.18768002f, -0.07761520f, 0.15696061f, 
    0.11636013f, -0.11952545f, 0.14655598f, 0.32475242f, -0.47080246f, 0.28261036f, -0.18064860f, 0.16403292f, 
    -0.00463350f, -0.20832512f, 0.24980351f, 0.02148650f, -0.28618407f, -0.00640115f, 0.05615040f, 0.12300978f, 
    0.03248291f, 0.08380318f, -0.03157760f, -0.00500468f, 0.04376033f, -0.07964655f, -0.04547932f, -0.08141644f, 
    -0.11254052f, -0.35689721f, -0.31848168f, -0.20649742f, 0.32616338f, 0.12292203f, -0.03309487f, -0.07726921f, 
    -0.07205962f, 0.12263982f, 0.11892697f, 0.06799854f, -0.05683920f, 0.17901850f, -0.05387683f, 0.06305803f, 
    -0.07955942f, -0.00929216f, 0.24968578f, -0.13895543f, 0.19335279f, -0.02003239f, -0.31807947f, -0.21001431f, 
    0.26293343f, 0.04731539f, -0.06407184f, -0.04186184f, 0.01488773f, 0.04303819f, -0.18712917f, 0.11814503f, 
    0.14058428f, -0.22962582f, 0.07361947f, 0.16031633f, 0.04153020f, 0.06894919f, 0.08693908f, 0.05988510f, 
    -0.78339720f, 0.15072653f, 0.59139633f, 0.07283829f, -0.72443384f, -0.00133282f, -0.11718343f, -0.07447910f, 
    0.08952790f, 0.20717168f, -0.01179051f, -0.02797993f, -0.04378020f, -0.01861197f, -0.01684000f, 0.06342474f, 
    0.13884604f, 0.12395354f, 0.22475874f, 0.05024178f, 0.25238997f, -0.08109870f, -0.02923183f, 0.26279494f, 
    0.10540676f, 0.07152463f, -0.27520907f, -0.19704847f, 0.14202863f, -0.14882983f, 0.10393780f, 0.11969075f, 
    -0.04134906f, -0.04951232f, -0.03260296f, 0.00697481f, 0.00020015f, 0.03733349f, 0.06141095f, -0.04027464f, 
    -0.02028695f, -0.22324374f, -0.48088253f, 0.00413840f, 0.06957756f, -0.02127870f, -0.07967159f, 0.01576170f, 
    -0.12446085f, -0.06643239f, -0.01799309f, -0.05708629f, 0.09645472f, -0.17937098f, 0.23214354f, 0.00534698f, 
    0.14808697f, 0.17334920f, 0.07602923f, 0.07050186f, -1.06127405f, -1.03739774f, -1.32474291f, -0.05679638f, 
    -1.18760419f, 0.03096089f, 0.04204653f, -0.16791371f, 0.06863104f, -0.34641102f, -0.03561261f, 0.01332689f, 
    -0.00691267f, 0.04654396f, -0.10831606f, -0.06128648f, -0.02299708f, -0.01707767f, -0.35648209f, 0.08144735f, 
    -0.49157953f, -0.11597636f, 0.35174027f, -0.11345083f, -0.12776273f, -0.19576825f, -0.12509471f, -0.50409466f, 
    -0.35003635f, -0.01239466f, 0.06289963f, 0.00035623f, -0.01396438f, 0.11027625f, -0.09556726f, 0.12612639f, 
    0.01669401f, -0.22679298f, -0.03682740f, -0.09113855f, 0.07969286f, 0.23673078f, 0.34530899f, 0.41672188f, 
    0.17726067f, 0.05411858f, -0.08140714f, 0.02622356f, 0.04526922f, -0.19450334f, -0.03603077f, 0.04199537f, 
    0.12259725f, 0.05832683f, 0.12593935f, -0.01554878f, -0.03989061f, -0.00513545f, 0.01069061f, -0.04768254f, 
    0.36084294f, -0.30149853f, 0.11166934f, -0.00906620f, 0.25822353f, 0.14224572f, -0.23176420f, -0.22164175f, 
    -0.03243301f, -0.04796102f, 0.09931345f, 0.09405467f, 0.17014886f, -0.01325337f, 0.03932529f, 0.07371950f, 
    0.07847849f, -0.14363573f, 0.19686449f, -0.04592883f, 0.14002049f, 0.09470336f, -0.30923438f, 0.38768038f, 
    0.39172927f, 0.04919071f, 0.04454052f, -0.21370010f, -0.01673346f, -0.16977856f, -0.07890971f, -0.00843479f, 
    -0.07320178f, -0.18592355f, -0.09026086f, -0.30555475f, -0.09844429f, 0.12395015f, -0.46019432f, 0.04670978f, 
    0.09274435f, -0.17995620f, 0.38613227f, 0.05166331f, 0.17782497f, -0.00486257f, -0.13023175f, -0.05331712f, 
    0.28714666f, -0.17652336f, -0.04224098f, -0.14595698f, 0.03448514f, -0.02926709f, 0.00825697f, 0.03021983f, 
    -0.06967830f, -0.10771772f, 0.04830879f, -0.12641333f, -0.10997070f, 0.06111391f, 0.04363658f, -0.00008933f, 
    0.11289643f, -0.06614269f, -0.05914916f, 0.04947004f, 0.05376533f, 0.00756487f, -0.26633915f, -0.17110510f, 
    -0.16114008f, -0.05676422f, 0.15078594f, 0.05088465f, -0.11621425f, -0.04074739f, 0.01816890f, -0.14740622f, 
    0.59553260f, 0.26005459f, 0.19596922f, -1.19136858f, 0.02562931f, -0.16446498f, -0.11741138f, 0.03450191f, 
    -0.15946344f, -0.12665187f, 0.16168500f, 0.01778482f, -0.12488054f, -0.05130081f, 0.23851527f, -0.10183089f, 
    -0.08814333f, -0.15254751f, -0.07643709f, -0.01508446f, -0.14912333f, 0.17893147f, -0.13672197f, -0.00721899f, 
    0.47352263f, 0.11441735f, 0.06697538f, -0.09063950f, -0.06521374f, 0.04466926f, -0.25119513f, 0.12203480f, 
    0.09929953f, 0.14246686f, 0.28955793f, -0.10516703f, 0.03400876f, 0.08277673f, 0.14823696f, 0.07587172f, 
    0.86589688f, 0.00489137f, -0.01488822f, -0.45414475f, 0.08661819f, -0.13464382f, -0.00098557f, 0.15672247f, 
    -0.08171738f, -0.03794039f, -0.10166965f, -0.21721670f, 0.07802585f, 0.01792911f, -0.20114358f, 0.01436759f, 
    -0.06085564f, 0.00187184f, 0.11519860f, -0.00482776f, -0.27121404f, 0.00583596f, -0.27231121f, 0.39919698f, 
    0.29064366f, 0.05352785f, -0.08636473f, 0.31997171f, 0.05972309f, 0.14486513f, -0.01140278f, 0.12051564f, 
    -0.05582793f, -0.24444327f, -0.04319531f, 0.01697456f, -0.07866519f, -0.07808499f, 0.01163922f, -0.08201142f, 
    -0.21077438f, -0.42743942f, -0.26848641f, -0.25265223f, -0.74636346f, 0.03398921f, -0.06563967f, 0.13556240f, 
    0.15822169f, -0.06951335f, -0.10977452f, 0.00553427f, 0.07354549f, -0.16780353f, -0.29604706f, -0.40325460f, 
    -0.04742913f, -0.26090893f, 0.15815614f, 0.07951749f, 0.05707336f, 1.21512127f, -0.44217420f, -0.30911627f, 
    -0.65395707f, 0.18183035f, 0.11329830f, -0.05276294f, -0.35632676f, 0.15872368f, -0.24136846f, -0.23115902f, 
    0.01475576f, -0.29915258f, -0.05368235f, -0.16189650f, -0.08436761f, -0.28068978f, 0.06626220f, -0.03709312f, 
    -0.26987228f, -0.34437296f, -0.12382388f, 0.32904804f, 0.30027238f, -0.09825841f, 0.06146741f, 0.05295538f, 
    0.08080459f, -0.02522725f, 0.05325622f, 0.04728903f, -0.14874640f, 0.00029617f, 0.06983246f, -0.02146423f, 
    0.13432553f, -0.06573099f, 0.05206589f, 0.03287502f, -0.13554902f, -0.07653676f, -0.40526474f, -0.09007758f, 
    0.35831317f, 0.24027982f, -0.03916927f, 0.12815492f, 0.09653602f, 0.11143580f, 0.04544361f, 0.16732994f, 
    -0.16557559f, 0.18607390f, -0.04396462f, 0.21352310f, -0.05556777f, 0.07349918f, 0.09287991f, 0.08378984f, 
    1.01880455f, -0.11539061f, -0.34672377f, -0.01108943f, -0.62801760f, 0.24800451f, 0.27021968f, -0.13291268f, 
    -0.13664117f, -0.06811452f, -0.26655051f, -0.11989617f, 0.23239256f, -0.06116406f, -0.17994891f, 0.12069799f, 
    -0.02287462f, -0.24660270f, -0.15746327f, -0.05033518f, -0.05433091f, -0.15387183f, -0.32384896f, 0.05173962f, 
    0.22845018f, -0.03258649f, 0.02739272f, -0.11648357f, 0.12433077f, 0.07606488f, -0.02818024f, -0.11906646f, 
    0.01107944f, -0.08308513f, -0.08022206f, -0.10867907f, -0.11846613f, 0.11289856f, -0.29602528f, 0.08806355f, 
    -0.99649239f, -0.19122668f, 0.74605727f, 0.32592759f, 0.81852341f, 0.02237433f, 0.25618783f, 0.00854528f, 
    -0.00579645f, -0.15663517f, 0.02708384f, 0.10330455f, -0.01710489f, -0.12027449f, 0.06136672f, 0.01122500f, 
    0.10363082f, 0.20394148f, -0.16058061f, -0.12624498f, 0.52339888f, -0.32602957f, -0.24525784f, 0.04926966f, 
    0.32354420f, 0.32315668f, 0.18360041f, -0.02258923f, -0.25598481f, -0.42861223f, -0.21041824f, 0.00815852f, 
    0.20538823f, 0.14519751f, 0.06767866f, -0.04578108f, 0.01337937f, 0.21361901f, 0.11811871f, -0.06369493f, 
    -0.00459245f, -0.13400102f, -0.23421820f, -0.21706948f, 0.02156859f, 0.15362930f, 0.09361709f, 0.06236562f, 
    -0.10647583f, 0.04495707f, 0.04602916f, -0.23723835f, -0.11283066f, -0.15380818f, -0.29303604f, -0.08717705f, 
    -0.18516123f, 0.00318559f, 0.26807511f, -0.14230680f, 0.16427669f, 0.86233646f, 0.34843954f, -0.73566854f, 
    -0.04950752f, 0.28511930f, 0.28848952f, -0.07588307f, 0.15982223f, 0.21764822f, -0.11926723f, 0.04567362f, 
    -0.02031524f, 0.00122288f, -0.00749279f, 0.03249294f, 0.09083036f, 0.05819252f, -0.02538751f, -0.18397507f, 
    -1.14004612f, 0.61803490f, 0.00861445f, -0.09068485f, 0.43600586f, 0.36474329f, 0.09219469f, -0.02014071f, 
    0.06456483f, -0.06668855f, -0.26480222f, -0.00243290f, -0.05704028f, 0.04846589f, -0.02371234f, 0.12579343f, 
    0.02934361f, -0.12058273f, 0.20422581f, -0.07649840f, -0.30809146f, -0.46498907f, -0.63911700f, 0.06051501f, 
    -0.25444293f, 0.02102344f, -0.26659980f, -0.06404691f, -0.27300656f, -0.00499915f, -0.19123131f, 0.09884953f, 
    0.10001972f, -0.09855413f, 0.21022886f, 0.30837768f, 0.02941196f, 0.12079517f, -0.22388047f, 0.04449489f, 
    -0.18417546f, -0.50251621f, -0.46879458f, 0.53294820f, 0.04921395f, -0.15799721f, -0.12331907f, -0.11955936f, 
    -0.05669380f, -0.04063628f, 0.06255839f, -0.15081181f, 0.07194664f, 0.08367553f, 0.03564205f, -0.02578146f, 
    -0.06610769f, -0.13914470f, -0.36759272f, -0.08876889f, -0.23383816f, -0.24057753f, 0.07839776f, 0.23487316f, 
    0.28023201f, -0.30456609f, 0.11436337f, -0.04814895f, -0.33865055f, -0.00866354f, -0.06140817f, 0.09640950f, 
    -0.02376894f, -0.15419720f, -0.15052411f, -0.10111687f, -0.04953667f, 0.05885676f, 0.03360449f, 0.04707818f, 
    0.67713410f, -0.60647613f, -0.48982209f, 0.19288608f, -0.36813691f, 0.09068185f, -0.34818745f, -0.10490885f, 
    0.09291239f, -0.18358073f, -0.01847675f, -0.04323949f, -0.02893935f, -0.00387120f, -0.17294876f, 0.08381139f, 
    0.04234168f, -0.01940986f, -0.30419207f, -0.05092379f, 0.14852476f, -0.10480069f, 0.33398572f, -0.17585728f, 
    0.22659904f, 0.00374198f, -0.18469882f, 0.12629123f, -0.21096176f, -0.03627260f, -0.00515645f, -0.17476921f, 
    0.03823817f, -0.03050083f, -0.04602755f, 0.02162085f, -0.10802588f, 0.00708873f, -0.10450392f, -0.38372993f, 
    -0.37174863f, 0.45651522f, -0.09567043f, -0.41165397f, -0.38124540f, 0.13770016f, -0.16092366f, -0.00527809f, 
    0.13407585f, -0.01717935f, 0.20964269f, -0.04288960f, -0.03476583f, -0.00622311f, -0.00550433f, -0.00584179f, 
    -0.03781881f, 0.03034829f, -0.29719418f, 0.19314830f, 0.20861810f, -0.38219321f, 0.05749034f, -0.05030839f, 
    -0.21716268f, 0.09290853f, 0.00747356f, 0.07432240f, -0.11958395f, 0.20160809f, 0.00385041f, 0.03854015f, 
    -0.00442907f, 0.07599038f, -0.19529377f, -0.08554801f, -0.00210558f, -0.06426532f, -0.23654306f, 0.15812972f, 
    0.04636947f, 0.35147342f, 0.25289148f, -0.08961063f, 0.15980034f, 0.04945883f, 0.26577610f, 0.01358411f, 
    0.02920280f, 0.08667359f, 0.05349645f, -0.02341149f, 0.01384620f, 0.05771511f, -0.06449010f, 0.07163114f, 
    0.23948504f, -0.01925945f, 0.06812060f, 0.40940565f, 0.02785299f, 0.10150424f, 0.08581462f, 0.05867073f, 
    -0.12807496f, -0.04623467f, -0.16179818f, -0.14301503f, -0.13502593f, 0.10115464f, 0.10878519f, -0.02451046f, 
    0.02532321f, 0.09497710f, 0.04784948f, 0.07100461f, -0.20084253f, -0.03309289f, -0.15118858f, -0.15163843f, 
    0.25568891f, -0.06242340f, -0.05260631f, -0.47641516f, -0.18153219f, 0.14255473f, -0.03490401f, 0.00076447f, 
    0.21608181f, 0.09684080f, -0.08334741f, -0.19932513f, -0.02236453f, -0.31042266f, 0.17965093f, -0.07302520f, 
    -0.05976914f, -0.03234271f, -0.17375661f, -0.02507244f, 0.14518100f, 0.31349906f, 0.47846127f, 0.38571888f, 
    0.21223097f, -0.26916116f, 0.03111952f, 0.07380394f, 0.08489051f, 0.13554148f, 0.05576245f, 0.08419838f, 
    -0.00390593f, 0.05239303f, 0.05105458f, 0.05203951f, 0.02013766f, -0.21462971f, 0.18720862f, -0.04520340f, 
    0.06497453f, -0.03060747f, 0.07812101f, -0.05681850f, 0.18023635f, 0.19372328f, 0.24307141f, 0.28277144f, 
    -0.16005854f, 0.15673406f, 0.05562055f, 0.02740502f, 0.19268641f, -0.18009181f, -0.00072123f, -0.04256998f, 
    -0.02720270f, -0.12111696f, -0.09721066f, -0.10212734f, 0.18186678f, -0.21537338f, 0.14600079f, 0.15552379f, 
    0.05172686f, -0.23727733f, -0.09420632f, -0.17081025f, 0.13404842f, 0.14633060f, 0.27977690f, -0.11184958f, 
    -0.18469857f, -0.01152832f, 0.14634411f, 0.12076851f, 0.03215703f, -0.02475225f, -0.01961710f, -0.05288702f, 
    -0.16179405f, 0.11275037f, 0.02806011f, 0.22791837f, -0.26373783f, -0.00387482f, -0.20429830f, -0.08326748f, 
    -0.30212158f, 0.03435460f, -0.28431144f, -0.01404587f, 0.02606335f, 0.00769656f, 0.16963369f, -0.07023738f, 
    -0.04927890f, -0.03714887f, -0.36755332f, -0.11967167f, -0.41552335f, -1.10654175f, -0.34264803f, 0.23830338f, 
    -0.41273612f, -0.17603637f, -0.01495359f, 0.26055044f, -0.17346571f, 0.14023097f, -0.16323593f, 0.02139634f, 
    -0.07804527f, -0.07052911f, -0.14517945f, -0.34581849f, -0.09639773f, -0.08578416f, 0.16777915f, 0.27497515f, 
    0.22228502f, 0.09836188f, 0.04579355f, 0.19722374f, 0.01934584f, 0.00550990f, -0.03468085f, 0.05276776f, 
    -0.09219538f, 0.26786414f, 0.05900222f, 0.07816083f, -0.11986103f, -0.02779624f, 0.04886762f, 0.18137820f, 
    0.06806324f, 0.03328453f, -0.15175393f, -0.05931671f, 0.08197989f, -0.00449925f, -0.01406279f, -0.03075018f, 
    -0.01256186f, 0.16776752f, 0.08550952f, 0.12258940f, 0.05014551f, 0.04910544f, -0.07858718f, -0.16968839f, 
    0.04166107f, -0.20781717f, -0.05243793f, 0.19617875f, -0.04939893f, -0.03128977f, -0.09593451f, -0.03422277f, 
    -0.92869878f, -0.36806270f, -0.19565293f, 0.67388827f, -0.49201277f, 0.18535003f, -0.35685107f, -0.14040485f, 
    0.00669525f, 0.41543642f, -0.07134094f, 0.12614718f, -0.04769098f, -0.05127611f, 0.04926067f, -0.09096926f, 
    -0.14394605f, 0.22321641f, 0.04068982f, 0.09754393f, -0.69696987f, 0.21641652f, -0.23066297f, -0.33078748f, 
    -0.28043383f, -0.03038779f, -0.00835776f, 0.10520113f, -0.17719232f, -0.10732313f, -0.06950337f, -0.03680048f, 
    -0.04422417f, 0.05428500f, 0.08385249f, -0.11478460f, -0.22212516f, -0.02381646f, -0.11648984f, -0.15134200f, 
    -0.42843708f, 0.63989514f, 0.31469068f, 0.03357659f, -0.10636623f, -0.08432452f, -0.03779629f, -0.04725548f, 
    0.24825314f, -0.11609253f, 0.01834201f, -0.09338971f, -0.02982599f, -0.10187522f, -0.09600374f, -0.05550705f, 
    -0.08546226f, -0.02529628f, 0.11819877f, -0.07498979f, 0.44683066f, -0.11089429f, 0.06842296f, 0.04398022f, 
    -0.10288564f, 0.03908756f, -0.05270239f, -0.26295248f, 0.12646747f, 0.19099729f, -0.04769467f, 0.07586752f, 
    -0.09480768f, -0.08518966f, -0.02890339f, 0.05282742f, 0.16788416f, -0.02831188f, 0.02351776f, 0.34207717f, 
    -0.13958029f, -0.29911295f, -0.60379994f, 0.33291054f, 0.33426651f, 0.00457029f, -0.14344858f, -0.08930298f, 
    0.02360144f, -0.01613120f, 0.00207737f, -0.02172836f, -0.16054519f, 0.19569170f, 0.02099037f, -0.04524566f, 
    -0.03981194f, 0.31347662f, -0.09518904f, -0.21311776f, -0.42848489f, 0.10161062f, -0.23782361f, -0.06885090f, 
    -0.13646570f, 0.05389978f, -0.21936283f, -0.00795449f, 0.08775392f, -0.10623208f, 0.07805620f, 0.01510236f, 
    -0.04970111f, 0.17985266f, 0.10171741f, -0.08126748f, 0.00068942f, 0.06819963f, 0.09082409f, 0.08646212f, 
    0.25152516f, 0.16646795f, 0.21075742f, -0.05410923f, 0.38126406f, -0.00680341f, 0.18973948f, -0.04522502f, 
    0.18041621f, -0.08694720f, 0.19668601f, 0.12003852f, 0.06722556f, 0.04328298f, -0.08035649f, -0.11265191f, 
    -0.14918531f, -0.29064059f, 0.01886460f, -0.43683505f, 0.11653462f, -0.05898419f, 0.30960098f, -0.22326918f, 
    -0.16027771f, -0.03975490f, 0.05657544f, 0.07751949f, -0.10640524f, -0.21882097f, 0.00018377f, 0.03162438f, 
    0.00429590f, -0.03127951f, -0.05327763f, 0.09367636f, 0.05777474f, -0.01766741f, -0.06758711f, 0.18668681f, 
    -0.03916666f, 0.27985063f, -0.23106277f, 0.13879371f, 0.12313017f, -0.02821413f, 0.00408713f, -0.20603645f, 
    -0.04623020f, 0.19684121f, 0.08362266f, 0.02397131f, -0.14352158f, 0.13710566f, 0.11936772f, -0.07829458f, 
    -0.05477948f, 0.26104978f, 0.26426008f, 0.11698125f, 0.33929151f, -0.18187301f, 0.48738155f, 0.06054458f, 
    -0.38411403f, 0.36020163f, 0.14861928f, 0.14763391f, -0.31655532f, -0.16494624f, 0.07711038f, -0.00556664f, 
    0.03447380f, 0.07654445f, 0.00763909f, 0.06546321f, 0.05241097f, -0.07459633f, 0.07371433f, -0.05312376f, 
    0.64495474f, 0.11542404f, -0.40686741f, -0.26277697f, 0.19025651f, -0.13655904f, 0.14613649f, 0.13867414f, 
    -0.24700095f, 0.05508544f, -0.13218446f, -0.04019248f, -0.10146044f, -0.25165907f, -0.05248758f, 0.03904440f, 
    0.00965132f, 0.11919435f, -0.21767464f, -0.06454863f, -1.04966462f, 0.34280136f, -0.58547366f, -0.18927056f, 
    -0.22509442f, 0.00284069f, 0.03744672f, 0.06545471f, 0.00078656f, 0.34827811f, 0.22439905f, -0.15906931f, 
    0.06256881f, -0.17071807f, -0.11194813f, -0.12488639f, -0.07601302f, 0.09901762f, -0.03503098f, 0.05333487f, 
    -0.23480998f, 0.15730858f, 0.37807974f, -0.24637517f, -0.04755456f, 0.08051966f, 0.05230847f, -0.02577855f, 
    0.03584111f, 0.01467387f, 0.11376469f, 0.09530364f, -0.05173511f, -0.02033175f, 0.08512346f, 0.01206256f, 
    0.00526546f, -0.01851859f, 0.22821890f, 0.18788841f, -0.33194312f, -0.15839146f, 0.19834894f, -0.08101870f, 
    -0.39370018f, -0.01435655f, -0.01945486f, -0.02285218f, -0.02306165f, -0.10090920f, -0.02302578f, -0.07585816f, 
    -0.16008189f, -0.00892712f, 0.13670571f, 0.08896314f, -0.00773502f, -0.15688007f, -0.11911019f, -0.00858401f, 
    -0.47129646f, -0.15572606f, -0.10710128f, -0.27645293f, -0.22972192f, 0.06223791f, 0.14890853f, -0.06217289f, 
    -0.13976988f, 0.00787302f, 0.20636889f, 0.19951421f, -0.00250089f, -0.20144404f, 0.04267163f, -0.04315245f, 
    0.06315417f, -0.04487122f, -0.04826619f, 0.13555436f, 0.02058206f, -0.09771592f, -0.43094033f, 0.03256726f, 
    0.08506587f, 0.02174168f, -0.02500957f, 0.01343596f, -0.02666863f, 0.01715814f, -0.14342090f, -0.10837186f, 
    0.31336290f, 0.09915828f, -0.27650958f, 0.08218456f, 0.08912801f, 0.20467253f, -0.05900808f, -0.01223600f, 
    -0.04950768f, -0.14054713f, -1.16368365f, -0.32451820f, 0.39958242f, -0.14917952f, 0.23628715f, 0.22182858f, 
    0.08610436f, 0.10378132f, -0.02460919f, 0.08543904f, 0.02526703f, -0.00809070f, 0.08669303f, -0.03064947f, 
    -0.10605837f, -0.43846139f, 0.28479198f, 0.04125522f, -0.60076618f, -0.68766230f, -0.04565442f, -0.14707443f, 
    0.68517852f, -0.14348570f, -0.23739310f, -0.07872096f, -0.22206308f, 0.10055925f, -0.08906507f, 0.03876768f, 
    0.09511032f, 0.07277829f, -0.31657770f, 0.01388521f, 0.07016852f, 0.08366247f, 0.19996122f, 0.01900230f, 
    -0.19137099f, 0.06798704f, -0.15654555f, 0.24800818f, 0.30357260f, -0.19387846f, 0.04236107f, -0.00652308f, 
    0.04741423f, 0.16177307f, 0.17430049f, 0.03343213f, 0.19900586f, -0.03958203f, -0.01659261f, 0.04092546f, 
    -0.02780061f, -0.07951792f, 0.03652863f, -0.02263433f, 0.22624952f, 0.44232494f, -0.69942731f, -0.36500725f, 
    0.01001762f, -0.22737627f, 0.14901185f, -0.16932343f, 0.21262878f, -0.02828336f, 0.09024178f, -0.08432003f, 
    -0.15594931f, -0.00580510f, 0.03170860f, 0.00314602f, -0.05252953f, 0.11010609f, 0.11721780f, -0.41391602f, 
    0.13050053f, 0.14982009f, -0.36105707f, -0.12195878f, 0.12120936f, 0.06207595f, -0.13507782f, 0.16367376f, 
    0.04986916f, 0.06582223f, 0.16433832f, 0.08092550f, 0.07700016f, -0.14296505f, -0.08793396f, -0.09501841f, 
    0.01686021f, -0.40781015f, 0.05629450f, 0.10441829f, 0.03311264f, -0.07845128f, 0.22141826f, 0.04602263f, 
    -0.08402111f, -0.00920615f, 0.02865768f, -0.04964176f, -0.17286849f, 0.10942832f, 0.01235568f, 0.14973602f, 
    0.02916177f, 0.09656562f, -0.25420463f, 0.14143363f, 0.05418133f, -0.01284427f, -0.02129756f, 0.07696588f, 
    -0.38324484f, -0.58566594f, -0.67804879f, -0.22118697f, -0.43125361f, -0.10860583f, 0.18551268f, 0.16869344f, 
    -0.03219294f, -0.39521849f, 0.03595614f, -0.04071098f, 0.02609791f, 0.05202547f, 0.09279678f, 0.02315367f, 
    0.03658728f, 0.34024420f, 0.05109043f, 0.16667390f, -0.81056023f, 0.26352653f, 0.56852621f, 0.17995539f, 
    -0.20174392f, -0.19303311f, -0.12721920f, -0.30498001f, -0.34405595f, -0.09272499f, -0.10594544f, 0.10938163f, 
    0.01755346f, 0.05758820f, 0.00385261f, -0.03583800f, -0.03816744f, 0.09318262f, -0.05823213f, -0.07017655f, 
    -0.11320543f, 0.23719342f, -0.01805846f, -0.11736451f, 0.24027999f, -0.13566212f, -0.03978989f, -0.02949364f, 
    -0.02568747f, 0.09698363f, 0.12825070f, 0.23978248f, 0.07768453f, 0.15077384f, -0.04920499f, 0.07409064f, 
    0.03942055f, -0.06661871f, -0.02181863f, -0.02838602f, -1.78377116f, -1.53362966f, -1.41845715f, -0.45920163f, 
    0.21490707f, -0.24197912f, 0.06403849f, -0.30807564f, -0.21471128f, -0.68555266f, 0.01132487f, -0.03433464f, 
    -0.07622898f, -0.11270967f, 0.02368920f, -0.03468150f, 0.03644567f, 0.12630744f, 0.28078628f, 0.07437901f, 
    0.63159490f, 0.04665211f, -0.45531553f, -0.42155290f, 0.05696291f, 0.15504077f, -0.17132564f, 0.19925304f, 
    0.26222172f, -0.20074354f, 0.16677269f, -0.01065133f, -0.11520956f, -0.17769094f, 0.12057763f, 0.01034266f, 
    -0.07029349f, 0.12671681f, -0.04133001f, 0.11079343f, -1.39236999f, 0.54963815f, 0.89868623f, 0.00078130f, 
    0.27915877f, -0.15464792f, -0.15592998f, -0.05405109f, -0.32368016f, 0.53282487f, -0.05488263f, 0.13354543f, 
    0.09623655f, 0.17624250f, 0.20908110f, -0.02993910f, -0.01723718f, -0.04601101f, -0.07676660f, 0.04683851f, 
    -0.49599546f, -0.09955094f, 0.49857014f, 0.07134816f, -0.06686917f, 0.00389109f, -0.20436338f, 0.00597740f, 
    -0.01189552f, -0.27271381f, -0.03278207f, 0.13893294f, -0.01888791f, 0.06814194f, 0.15243077f, 0.06236675f, 
    -0.02920679f, 0.09781555f, -0.12387031f, -0.02316903f, 0.00817763f, 0.24146236f, 0.08159950f, 0.20330968f, 
    -0.10703743f, -0.06331769f, -0.06164228f, -0.13556014f, -0.01748564f, 0.24363047f, -0.20304613f, 0.06192299f, 
    0.18166989f, 0.13882700f, -0.05360602f, 0.05719995f, 0.15015261f, -0.08992934f, 0.18876870f, -0.07573540f, 
    -0.58764410f, -0.04542951f, 0.63326722f, -0.12922288f, -0.05946426f, -0.11958323f, -0.07679721f, -0.13176869f, 
    -0.23758937f, 0.07158740f, -0.07882392f, -0.04039145f, 0.13098478f, 0.11942849f, 0.09221137f, 0.02685641f, 
    0.06318069f, -0.10644887f, -0.16875991f, -0.02393172f, 0.07373321f, 0.12299952f, 0.12179156f, -0.09186957f, 
    -0.00343236f, -0.05820336f, -0.05119560f, -0.07679478f, -0.07221590f, 0.03540962f, -0.05393640f, 0.04372484f, 
    0.02357367f, 0.00247672f, -0.01963385f, -0.00336308f, -0.23196320f, -0.14985573f, -0.10747845f, -0.08065121f, 
    0.03639908f, 0.33325598f, -0.10059121f, 0.26985943f, -0.45680305f, -0.07401060f, 0.32007378f, -0.29369286f, 
    -0.19740359f, -0.22768810f, 0.08929717f, 0.12140936f, 0.00068901f, -0.00573074f, 0.00182596f, -0.16371593f, 
    -0.09253529f, 0.00073754f, -0.23599158f, 0.06313043f, 0.59191161f, -1.26426637f, -1.04026794f, -0.91868603f, 
    -0.68197578f, 0.05364991f, -0.04660401f, -0.49788207f, 0.49219120f, -0.01053760f, -0.03122702f, 0.10383353f, 
    0.01797616f, -0.07255553f, 0.05264143f, -0.24353696f, 0.04073885f, -0.19383474f, 0.04659848f, 0.11425634f, 
    0.60568875f, 0.14072169f, -0.02849193f, 0.21267503f, -0.56286108f, -0.17426179f, 0.03383728f, -0.14396955f, 
    -0.17777026f, -0.05280358f, -0.22873031f, -0.04313160f, -0.14690967f, -0.14916909f, 0.05054072f, -0.13042425f, 
    0.02725485f, -0.00946247f, -0.13782647f, -0.26664624f, -0.39859533f, -0.37190554f, -0.31920084f, 0.05790096f, 
    0.17032519f, 0.14459290f, -0.00247938f, 0.21867631f, -0.24733558f, 0.03025200f, -0.09127602f, 0.16092329f, 
    0.06191183f, 0.04851061f, 0.01547849f, 0.10232300f, 0.00697661f, 0.10137575f, -0.25500029f, -0.03004591f, 
    -0.07533550f, 0.23484041f, 0.04243568f, 0.07922699f, -0.36211497f, -0.13716903f, 0.09555957f, 0.01342443f, 
    -0.11902788f, -0.05785398f, -0.03366693f, 0.12602533f, 0.15780270f, -0.06969585f, 0.08072299f, -0.21883564f, 
    -0.12426459f, -0.03904275f, -0.04505733f, 0.11206526f, 0.06316262f, 0.17943850f, -0.02260526f, -0.02769882f, 
    -0.10828160f, 0.03486341f, 0.08170460f, -0.04115970f, 0.07413159f, -0.04155175f, -0.26300392f, 0.02755512f, 
    -0.06364996f, -0.44734415f, -0.35169744f, -0.12817709f, -0.01707155f, -0.11092567f, -0.01114903f, -0.00335553f, 
    -0.77838147f, -0.40652019f, 0.62073582f, -0.15062982f, 0.32912591f, 0.07979105f, -0.16461614f, 0.03438601f, 
    0.00622441f, 0.01734240f, 0.03515595f, -0.08298436f, 0.08349879f, 0.02909179f, -0.01527518f, 0.29588407f, 
    0.01169744f, 0.11536875f, -0.06055930f, -0.22001289f, 0.66231918f, -0.63848072f, -0.24270120f, -0.20157066f, 
    -0.21295007f, -0.01933848f, 0.10192495f, -0.02433869f, -0.10589267f, -0.03362699f, 0.03446235f, -0.11391845f, 
    0.13958700f, 0.02207781f, -0.02046965f, 0.02155665f, -0.06085289f, -0.03006631f, 0.02366402f, -0.06320678f, 
    0.21360104f, 0.32919928f, -0.51996613f, 0.07231808f, -0.35832739f, 0.06227911f, 0.10732272f, 0.11781655f, 
    -0.04976420f, 0.00284637f, -0.08471690f, -0.38000101f, 0.13816066f, 0.12705694f, -0.24080108f, -0.06973289f, 
    -0.16206364f, 0.04007567f, -0.10542479f, -0.00173391f, -0.52366310f, -1.00258672f, 0.11791286f, 1.05576599f, 
    0.29957616f, -0.16593535f, 0.36146086f, 0.00110930f, 0.19753610f, 0.22177526f, 0.01309289f, -0.06155157f, 
    -0.07790636f, -0.06862031f, -0.13517679f, -0.04978615f, 0.04069332f, -0.10552322f, 0.31363869f, -0.28205338f, 
    -0.22367825f, -0.03362904f, 0.07840476f, 0.08212235f, 0.06954911f, 0.05248905f, -0.04905130f, 0.07069653f, 
    0.11026847f, 0.10710979f, 0.10124580f, 0.00532917f, 0.03928894f, -0.00436085f, -0.00207904f, 0.05496987f, 
    -0.03597325f, -0.14972709f, 0.03834208f, 0.07308234f, 1.19665384f, -0.03776129f, -0.46601111f, -0.22191505f, 
    -0.34622782f, -0.07364001f, -0.13783634f, -0.10521660f, -0.01215356f, -0.13111536f, 0.05786902f, -0.14060122f, 
    0.11196670f, 0.05917443f, -0.06340922f, 0.06633850f, -0.04296795f, 0.00883412f, 0.05301312f, -0.06131698f, 
    0.37677100f, -0.28981391f, 0.15888926f, -0.34616601f, -0.13779528f, 0.05147300f, -0.02434911f, -0.08918045f, 
    -0.04123868f, -0.08830654f, -0.08457804f, -0.05853970f, 0.05046082f, -0.07248362f, -0.01475873f, -0.02494143f, 
    0.01401154f, -0.10668392f, -0.07959074f, 0.06130306f, 0.62359011f, -0.40934855f, 0.20536971f, -0.44037533f, 
    0.08999858f, 0.07755914f, 0.01943514f, -0.14811955f, 0.21970163f, 0.11675408f, 0.00851245f, 0.05557637f, 
    0.03752844f, 0.02521774f, -0.21526696f, -0.08887507f, -0.03532636f, 0.02207887f, 0.18584308f, 0.01816030f, 
    0.34040770f, -0.08668881f, 0.04810946f, -0.23957817f, -0.00151167f, 0.10073131f, 0.14936997f, -0.05875419f, 
    0.10960874f, 0.01660269f, 0.05643986f, -0.03391174f, 0.14819334f, 0.09164243f, 0.18244891f, -0.01131895f, 
    0.09770121f, 0.02485379f, 0.13488242f, -0.01579683f, 0.01405743f, 0.18989904f, -0.10477351f, 0.04848034f, 
    -0.14721787f, -0.01294495f, 0.04431923f, 0.02099316f, -0.01590021f, -0.04404065f, -0.30138829f, -0.21706791f, 
    0.11797514f, 0.02412852f, -0.11157579f, 0.02827932f, -0.08593021f, 0.07557856f, -0.08565289f, 0.04645615f, 
    1.19422722f, 0.75267065f, 0.09408827f, -0.01904680f, -0.15582448f, 0.19761726f, -0.05811183f, 0.06553695f, 
    0.08187070f, -0.29924637f, 0.05495691f, -0.03478922f, 0.11379986f, -0.08858279f, -0.10776774f, 0.03712260f, 
    -0.08263241f, -0.09202810f, 0.19773701f, 0.07199252f, -0.02802462f, -0.07633586f, -1.44755089f, -0.22677125f, 
    0.31480753f, -0.03336631f, 0.09803897f, 0.41313234f, 0.01827581f, -0.08957325f, -0.07909293f, -0.09978499f, 
    -0.11533038f, 0.13213435f, 0.07602344f, 0.24932654f, -0.08914434f, 0.20731732f, -0.13639238f, -0.21983935f, 
    0.95494932f, 0.28243950f, 0.00699287f, 0.03471987f, 0.22063257f, 0.04632538f, 0.22266139f, 0.02639677f, 
    0.03668272f, -0.08353890f, 0.08691910f, 0.10738207f, 0.04606426f, 0.08112464f, 0.20644030f, 0.01030910f, 
    -0.04283740f, -0.14461288f, -0.27519587f, 0.14854875f, 0.37089249f, -0.46776223f, -0.36597890f, 0.13883884f, 
    0.18673326f, -0.04593104f, 0.06897085f, -0.21990176f, -0.08321571f, -0.06600445f, 0.13477735f, -0.08410867f, 
    0.03937172f, 0.07848258f, -0.08169779f, -0.15929459f, 0.06899381f, 0.04647474f, 0.11509954f, 0.06895392f, 
    -0.32366300f, 0.44820192f, 0.16786472f, -0.27830005f, -0.19025487f, -0.11997847f, 0.11065434f, -0.12630811f, 
    0.15262069f, -0.05920974f, -0.04552796f, -0.13221613f, 0.13677484f, -0.16857873f, 0.14777677f, -0.04369569f, 
    -0.02039124f, -0.15210016f, -0.01357199f, -0.11353482f, -0.27848744f, 0.05922377f, 0.06192729f, -0.01977492f, 
    -0.41848704f, -0.15180828f, -0.01021321f, -0.16364057f, 0.15284784f, -0.08780497f, -0.03697271f, 0.11899453f, 
    0.06474172f, 0.04430384f, 0.15733469f, -0.04929977f, -0.03302598f, -0.03336844f, -0.02020398f, -0.00786603f, 
    0.05676682f, -0.64544737f, 0.18777457f, 0.06792365f, -0.02575285f, 0.25788960f, -0.03453248f, -0.02004990f, 
    -0.00259903f, -0.06083962f, 0.03751524f, -0.05977372f, 0.10327229f, -0.07150111f, 0.04421446f, 0.03579922f, 
    -0.17285487f, -0.05544372f, -0.09756126f, -0.51456094f, 0.19544294f, -0.35989228f, -0.54529303f, 0.13309291f, 
    0.03148477f, -0.17056969f, -0.06710976f, -0.03350754f, 0.07506180f, 0.13834549f, -0.09791412f, -0.16597748f, 
    -0.20487046f, -0.10938346f, -0.04289077f, -0.05429429f, 0.13802303f, 0.08583668f, 0.09845550f, 0.01167211f, 
    0.11820935f, -0.01713505f, -0.11237274f, -0.14917175f, -0.26172855f, -0.09303054f, 0.10170067f, -0.05463485f, 
    0.03134461f, -0.05654342f, -0.02990322f, 0.15157941f, -0.01263251f, 0.11216438f, 0.06767247f, 0.07959120f, 
    0.13814408f, -0.06106255f, 0.01584873f, -0.04437185f, 0.47916058f, -0.79252112f, -1.00683355f, -0.32131416f, 
    -0.31391832f, -0.19626939f, -0.43441868f, -0.10211316f, 0.09513442f, -0.22916697f, -0.06793317f, -0.02057046f, 
    0.00960501f, 0.04701007f, 0.03996019f, 0.04325961f, 0.10274712f, 0.24304117f, -0.14732365f, -0.00820984f, 
    -0.56404871f, -0.15487128f, 0.02041995f, 0.09313308f, 0.01819681f, 0.08201074f, -0.18247111f, -0.19324955f, 
    0.05880169f, -0.19230406f, -0.00994966f, 0.04337927f, 0.09046482f, 0.07597603f, -0.01623943f, -0.16178530f, 
    0.08272481f, 0.21577184f, 0.13197601f, 0.24089146f, 0.10200060f, -1.13899529f, -1.15753615f, -0.23893020f, 
    0.04839338f, 0.04461774f, 0.12077235f, 0.18662930f, 0.11541961f, 0.14342748f, -0.04694474f, 0.16102649f, 
    -0.24723972f, -0.10610721f, -0.14998521f, -0.00885641f, 0.00270549f, -0.05345179f, -0.07455808f, -0.00015139f, 
    0.19913644f, -0.21992150f, -0.31632453f, 0.09856448f, 0.01011836f, -0.22135711f, -0.09086018f, 0.18645896f, 
    0.07156572f, 0.08046553f, 0.01022964f, 0.06459842f, 0.04159570f, -0.07622173f, 0.06211479f, -0.00483863f, 
    0.07787871f, 0.16943820f, 0.00009119f, 0.03952862f, 0.15404621f, 0.37957183f, -0.66052854f, -0.21048972f, 
    -0.01972903f, 0.06689487f, -0.24692893f, -0.01498313f, -0.08263786f, -0.07020323f, 0.09547110f, 0.07414704f, 
    0.02032072f, 0.09600755f, -0.05835842f, -0.15095009f, 0.01275055f, -0.06866021f, -0.30718419f, -0.24316595f, 
    -0.39466077f, -0.35180700f, -0.42433357f, -0.10163670f, -0.08148791f, -0.18418117f, 0.00416280f, 0.13357601f, 
    0.07986727f, 0.09301475f, 0.01718897f, -0.02204848f, 0.09855749f, -0.05088510f, -0.03303417f, -0.12271397f, 
    0.06742384f, 0.05022876f, 0.07814766f, 0.11820033f, -0.43960908f, -0.19584389f, 0.01218658f, -0.01559857f, 
    -0.16000763f, -0.10064863f, 0.02437394f, 0.06879562f, 0.01569711f, -0.04123411f, 0.16212578f, 0.05762665f, 
    0.07744349f, 0.11671739f, 0.01975896f, -0.03284056f, 0.15272288f, 0.04149183f, 0.25464326f, 0.03674997f, 
    -0.78705209f, 0.08877043f, -1.66505134f, 0.39324841f, -0.11375757f, -0.14115365f, 0.13504472f, 0.18895569f, 
    -0.09835929f, -0.16947727f, -0.02771684f, -0.01769148f, -0.03870884f, -0.11760591f, -0.08395442f, -0.02150194f, 
    0.13736004f, -0.08747051f, 0.18381503f, -0.00251473f, 0.12189397f, 0.13330518f, -0.09506467f, 0.59393644f, 
    -1.01278627f, -0.02287617f, -0.04768673f, -0.33360761f, 0.15231612f, -0.07237832f, 0.04943468f, -0.08088167f, 
    0.10947061f, 0.12606269f, 0.02109580f, 0.02202846f, 0.23094453f, 0.23099032f, 0.16389610f, 0.18569845f, 
    -1.13130665f, -0.18902680f, -0.30706456f, 0.36674142f, -0.37123701f, 0.12859550f, 0.05511570f, 0.13896711f, 
    -0.40833637f, 0.09626967f, 0.10245120f, -0.08415950f, -0.07192318f, 0.05895414f, 0.06383584f, -0.05055857f, 
    0.06244189f, 0.04485360f, 0.10497895f, -0.00784289f, -0.17694330f, 0.41351715f, 1.04135501f, -0.33739001f, 
    -0.41134569f, 0.05813122f, -0.23562154f, 0.11849584f, -0.08312278f, -0.05365633f, -0.04389717f, -0.06093202f, 
    0.04131369f, -0.14297496f, -0.01637811f, -0.07543442f, -0.01046732f, -0.08195291f, -0.20668498f, -0.37949342f, 
    -0.85188210f, -0.34305671f, -0.67400801f, -0.22144248f, 0.28188443f, -0.07273172f, 0.23133084f, 0.24231905f, 
    0.01192127f, -0.12256248f, -0.04628392f, 0.05325026f, 0.03625704f, -0.20171885f, 0.07233183f, 0.12858817f, 
    0.18200153f, -0.16062596f, 0.00791185f, 0.05975902f, -0.44260737f, -0.05958576f, 0.06803217f, 0.15721194f, 
    0.41831243f, -0.05101347f, 0.23960881f, -0.36651480f, 0.11737248f, -0.00461602f, 0.17682719f, -0.04307361f, 
    -0.00725907f, -0.03700152f, -0.00767032f, 0.21824951f, 0.01837813f, -0.00694744f, -0.04030307f, 0.21898742f, 
    0.52994597f, -1.08555150f, -0.64667279f, -0.18594508f, 0.09442233f, 0.01896668f, -0.07511320f, 0.18877456f, 
    0.07640028f, 0.24141376f, -0.07735155f, 0.03829079f, 0.02479999f, -0.08413105f, -0.00804522f, -0.05264767f, 
    0.25411281f, 0.24756438f, -0.06580411f, 0.06073872f, 0.00777781f, -0.20404285f, 0.24800640f, -0.09641534f, 
    -0.12130032f, -0.07387218f, 0.08490319f, -0.12843549f, 0.00108209f, 0.15148254f, -0.02492892f, -0.03125593f, 
    0.02935794f, 0.05140861f, 0.05230188f, 0.05331602f, -0.09434004f, 0.10046618f, 0.01024743f, 0.00039926f, 
    -0.32465988f, 0.24031579f, -0.17968038f, 0.54939747f, 0.08107780f, 0.09536877f, -0.44198754f, -0.10687596f, 
    -0.24187341f, -0.09481289f, -0.06071389f, 0.14756468f, -0.02323699f, 0.10838229f, -0.29974329f, 0.01885813f, 
    -0.17562255f, -0.07078432f, -0.00537278f, 0.14196265f, -0.22365057f, -0.73134071f, 0.32742095f, 0.10330781f, 
    -0.52036440f, -0.07821263f, -0.57602942f, 0.28690055f, 0.20114346f, 0.38878495f, 0.04754336f, 0.09950693f, 
    0.04455052f, -0.00362909f, -0.02038105f, 0.01198833f, 0.00301414f, 0.09152061f, 0.25387907f, -0.16015969f, 
    0.02072202f, 0.61527640f, -0.38650098f, -0.25977695f, -0.34367308f, -0.00414843f, 0.16619311f, 0.22858693f, 
    0.14624052f, 0.20354320f, -0.06621125f, -0.02069878f, -0.19838190f, -0.26614359f, -0.14587437f, 0.12358545f, 
    0.10978418f, -0.18251830f, 0.06552359f, -0.37440157f, 0.12615059f, 0.31982225f, 0.38509187f, 0.33699477f, 
    -0.60166556f, 0.11422595f, -0.13056305f, -0.53602546f, -0.27993003f, -0.27471846f, 0.19963479f, 0.00574794f, 
    0.07451671f, 0.18118376f, 0.10377100f, 0.10711229f, -0.04230894f, -0.12464290f, -0.11488172f, -0.12958153f, 
    0.11213316f, 0.02807124f, -0.09148477f, -0.03791830f, -0.24748936f, -0.23155755f, 0.18643376f, -0.35223392f, 
    -0.20824930f, 0.12918465f, 0.02094010f, -0.22428630f, -0.02743969f, -0.00013177f, -0.07861792f, 0.00679502f, 
    -0.13929148f, -0.22223376f, -0.10230810f, -0.09573713f, -0.50215471f, -0.04271837f, -0.55373412f, 0.35145822f, 
    -0.02316252f, -0.14880428f, 0.11452271f, -0.37462777f, 0.09525669f, 0.16380854f, 0.15305908f, -0.16187960f, 
    0.05363265f, 0.03737412f, -0.01642637f, 0.15593129f, 0.11241055f, 0.02271404f, 0.18722582f, 0.26107299f, 
    -0.05636629f, -0.05636997f, 0.20216748f, 0.43207771f, -0.00154971f, -0.07634354f, 0.27081305f, -0.40617344f, 
    -0.13470753f, -0.29343873f, -0.00685058f, 0.00736397f, 0.08272053f, 0.07187699f, 0.15950501f, 0.12665194f, 
    -0.03890850f, -0.08478469f, -0.05646981f, 0.02523213f, -0.20681676f, 0.31508201f, 0.37965640f, -0.09812675f, 
    0.10979836f, 0.17216699f, -0.06466556f, -0.05071812f, -0.09050553f, -0.12495243f, 0.15515608f, 0.08234921f, 
    -0.06263351f, 0.15333512f, 0.11358708f, 0.10996844f, 0.06110656f, -0.13988961f, -0.01200344f, 0.10330220f, 
    -0.24895863f, -0.73724389f, 0.11915740f, -0.26940638f, -0.03345098f, -0.33233154f, -0.20630144f, 0.18142083f, 
    0.15596765f, -0.17421837f, -0.13066521f, 0.03539051f, -0.09366287f, 0.15359296f, 0.09743705f, 0.21882413f, 
    -0.25852263f, 0.10172164f, 0.11884547f, -0.05820144f, -0.26969346f, 0.14207615f, -0.43345413f, 0.18186793f, 
    0.07633390f, 0.11663994f, -0.22945715f, -0.13272195f, 0.07837471f, 0.09187779f, -0.12244950f, 0.16559663f, 
    -0.07678167f, -0.27390471f, -0.36926538f, 0.04036745f, -0.01903282f, -0.19144982f, -0.07268863f, -0.25004461f, 
    0.50341040f, -0.12242254f, 0.18009853f, 0.05139538f, 0.21653657f, -0.10544510f, 0.26311907f, 0.39648789f, 
    0.07434797f, 0.15150490f, 0.15599759f, -0.02579634f, -0.25324449f, -0.00042978f, 0.15543434f, -0.12797371f, 
    -0.18088903f, -0.07689262f, -0.05635580f, -0.19516419f, -0.74663234f, -0.32062092f, -0.09535348f, 0.20948727f, 
    -0.11494201f, -0.10826920f, 0.15320809f, -0.26263005f, 0.36039788f, -0.05839796f, -0.07234479f, -0.09967571f, 
    0.09224436f, 0.04783892f, 0.18712035f, 0.09583201f, 0.20277594f, -0.14138779f, 0.19800724f, 0.21778288f, 
    -0.04886249f, -0.78008223f, 0.20717371f, 0.23048471f, -0.00888140f, -0.06766252f, -0.08918645f, 0.11055870f, 
    -0.05515717f, -0.16026588f, -0.24672236f, -0.01964160f, -0.05452470f, 0.25396764f, 0.03510278f, 0.21664494f, 
    0.05199121f, 0.07385720f, -0.43050149f, -0.24200270f, 0.40937352f, -0.30168608f, 0.61132002f, -0.12459336f, 
    -0.34625313f, 0.15048957f, -0.25127110f, -0.00750509f, -0.22306173f, -0.22497599f, 0.08774316f, 0.04564300f, 
    0.02500047f, 0.15036461f, 0.10079402f, -0.04214336f, 0.03386859f, 0.15657946f, -0.11616050f, -0.23584592f, 
    -0.27792734f, -0.02217375f, -0.04956087f, 0.02512473f, -0.10392888f, 0.12246886f, 0.02614455f, 0.15114909f, 
    -0.14564127f, -0.11841901f, -0.04251339f, 0.13807602f, -0.13384080f, 0.00925483f, -0.16744615f, -0.01924955f, 
    -0.24336994f, -0.47932976f, -0.55508870f, 0.00241808f, -0.00918338f, 0.11046926f, 0.17750761f, -0.15098861f, 
    0.26709554f, -0.01530515f, 0.15444085f, 0.05976963f, 0.25196984f, -0.02984995f, -0.02598057f, -0.01374459f, 
    -0.02879592f, -0.15352468f, -0.06450399f, 0.10352012f, 0.21393135f, -0.12895840f, 0.23488395f, 0.19492039f, 
    0.51801139f, -0.58552885f, 0.36130467f, -0.27068749f, -0.21287832f, -0.15624005f, -0.13686164f, 0.13279489f, 
    -0.01036436f, 0.12234730f, -0.11590991f, 0.03254059f, -0.11336289f, 0.09060611f, -0.19191261f, -0.04095714f, 
    -0.09014750f, 0.19058691f, 0.01168192f, -0.11081363f, -0.88161606f, 0.03795020f, -1.10582566f, 0.07276939f, 
    0.21420507f, -0.02725696f, -0.21427514f, -0.38785231f, -0.12396435f, -0.03236306f, -0.08336041f, 0.30682978f, 
    -0.03276647f, 0.19995151f, 0.00761249f, 0.21272562f, -0.12815851f, -0.21378584f, -0.07236473f, -0.08326031f, 
    -0.17922394f, -0.57617569f, -0.91479331f, 0.29828647f, -0.32454789f, -0.04892074f, -0.20956928f, 0.27180183f, 
    -0.00774957f, -0.18667424f, -0.30750164f, -0.12187604f, 0.00988578f, 0.06131142f, 0.07746729f, -0.01828662f, 
    0.03111694f, 0.37921357f, 0.03015308f, 0.28386492f, 0.71928650f, -0.08897052f, 0.50395578f, 0.33012238f, 
    0.07440897f, -0.01229755f, 0.04840951f, 0.12551083f, 0.21598238f, 0.06408501f, -0.22367878f, 0.18864121f, 
    0.09077311f, -0.18212274f, -0.49420536f, -0.00808468f, -0.06326109f, 0.05608238f, 0.20652205f, 0.02436134f, 
    -0.04249161f, 0.07634310f, 0.45525074f, 0.24297494f, 0.12966044f, -0.12350302f, 0.19658068f, 0.10695621f, 
    0.11979345f, -0.13441665f, -0.21997836f, -0.04025471f, 0.07629823f, 0.16662741f, 0.17821297f, -0.05791264f, 
    0.11041180f, 0.30815968f, -0.14699522f, 0.18886091f, 0.24409485f, 0.10214499f, 0.39923158f, 0.61347580f, 
    0.32414889f, -0.09090640f, 0.12009984f, 0.14085232f, -0.19966488f, -0.07481980f, -0.09780016f, 0.14083791f, 
    -0.01932000f, -0.19426316f, 0.05034074f, 0.02554901f, -0.50681323f, -0.06935006f, 0.20297037f, -0.11288057f, 
    -0.08064949f, 0.36406705f, -0.17346103f, 0.04501091f, 0.09272951f, 0.13269873f, -0.15475774f, -0.13711290f, 
    -0.31387120f, 0.01812475f, -0.26057196f, 0.08225612f, -0.06413698f, 0.01024709f, -0.10357326f, 0.01542270f, 
    0.06919636f, -0.34856638f, 0.00811147f, 0.11880454f, -0.08246957f, -0.63815862f, 0.14706299f, -0.33240211f, 
    -0.27376547f, -0.22925560f, 0.10878688f, -0.14377211f, 0.01615609f, 0.07606347f, -0.12747294f, -0.33458430f, 
    0.03161192f, -0.04712057f, 0.06942063f, -0.10622113f, 0.19484541f, 0.13801755f, 0.16128664f, 0.20666392f, 
    0.74237627f, 0.06377911f, 0.69057655f, -0.36920244f, 0.30895779f, 0.15204194f, 0.16762379f, 0.06801874f, 
    0.05018809f, 0.00267588f, -0.10073240f, -0.17923629f, 0.04688151f, 0.12974088f, -0.11385760f, 0.29157278f, 
    0.24035953f, -0.09128042f, -0.29063672f, 0.14541610f, -0.25518310f, -0.23611458f, -0.25790471f, -0.06310580f, 
    -0.58178574f, 0.11693731f, -0.04022806f, -0.03297067f, -0.33908746f, 0.10709682f, -0.14460108f, -0.04908159f, 
    0.25970417f, 0.23359396f, 0.01495358f, 0.06988610f, 0.12204921f, 0.11875427f, 0.06983581f, 0.27011052f, 
    -0.23442844f, -0.53146267f, 0.26394486f, -0.49657080f, 0.30660954f, 0.16621816f, 0.05066542f, -0.06763484f, 
    0.33825716f, 0.15933290f, -0.08092334f, 0.17307003f, 0.04784978f, 0.15387343f, -0.06317686f, 0.05666254f, 
    0.09193905f, 0.10339508f, 0.17943291f, 0.02947872f, 0.34541795f, -0.57308656f, 0.15899408f, 0.30342507f, 
    0.04383482f, 0.04245538f, 0.04818529f, 0.02087818f, 0.30774856f, -0.41941133f, -0.01450678f, -0.03704380f, 
    -0.04189692f, -0.14423701f, 0.11772789f, -0.10613135f, -0.12927124f, 0.02346488f, 0.07600291f, -0.28447786f, 
    0.25049615f, -0.08870377f, -0.03128430f, 0.18343101f, 0.27685010f, -0.04801846f, 0.28533617f, -0.05059198f, 
    0.00926924f, -0.23849826f, 0.00201049f, -0.18969363f, -0.04813678f, -0.31905830f, -0.30449006f, 0.08843268f, 
    -0.09370630f, -0.02450458f, 0.17569911f, -0.02174051f, -0.64529222f, -0.17812665f, -0.46630681f, -0.22373335f, 
    0.13149206f, 0.06078135f, 0.20869188f, 0.20300789f, -0.37771127f, 0.02633168f, -0.05442408f, 0.12940432f, 
    -0.05747861f, 0.09910245f, 0.17480589f, -0.05792395f, 0.05630277f, 0.03787766f, 0.02211563f, -0.13719419f, 
    0.05515857f, -0.45518795f, 0.10598963f, 0.51950318f, 0.00380943f, -0.24185090f, -0.26178378f, -0.12652995f, 
    0.01383290f, -0.25720108f, 0.01575150f, 0.10411955f, 0.15539767f, 0.02131389f, 0.02409536f, 0.23390526f, 
    -0.06331195f, 0.27914131f, 0.32474679f, 0.05370413f, -0.21135309f, -0.09458100f, -0.32940379f, 0.26919183f, 
    0.11043679f, -0.00893861f, -0.15902808f, -0.04135179f, -0.24733195f, -0.07764015f, 0.09657758f, 0.09600732f, 
    -0.17480619f, -0.14376165f, -0.08564131f, 0.05372895f, -0.20016220f, -0.12214107f, -0.26753893f, -0.15451103f, 
    0.07023189f, -0.25451940f, 0.22136137f, -0.42956921f, 0.25120255f, 0.26527143f, 0.35019195f, -0.18702877f, 
    0.19813620f, -0.06703591f, 0.02530574f, 0.01037085f, -0.11984786f, 0.03182497f, 0.04764633f, -0.23702931f, 
    0.04251590f, -0.05079731f, -0.13629170f, -0.01033495f, 0.24774177f, -0.47382692f, -0.34464723f, -0.10200284f, 
    -0.02410134f, -0.25754809f, -0.72733504f, 0.07609848f, -0.48426569f, -0.36697584f, 0.03354972f, 0.03479010f, 
    0.09768540f, -0.08758907f, -0.11078080f, 0.10945428f, -0.11736365f, 0.09457462f, 0.03264326f, -0.12491336f, 
    0.66112816f, -0.01670907f, 0.63135844f, 0.47445437f, -0.12312012f, -0.20173547f, 0.22458728f, -0.17841554f, 
    0.16124639f, -0.07175501f, -0.32489726f, 0.03912710f, -0.03491790f, 0.09206995f, 0.06923271f, -0.23236306f, 
    0.12496457f, 0.08501514f, -0.03947995f, 0.06017265f, -0.92610496f, -0.28960329f, 0.02845859f, -0.01123597f, 
    -0.55128253f, 0.05311146f, -0.09629074f, -0.17449124f, 0.05764891f, 0.22633544f, -0.20516323f, -0.11109895f, 
    -0.16749606f, -0.16140652f, -0.15632065f, -0.05467457f, -0.15600854f, -0.14537838f, 0.14736623f, 0.01341478f, 
    -0.71480960f, 0.20281792f, -0.50575066f, 0.73976642f, 0.09334137f, 0.01947450f, 0.03380013f, -0.03564360f, 
    0.04010528f, 0.11756870f, 0.01113139f, 0.05035738f, -0.10348836f, -0.16223770f, -0.25038892f, 0.13257185f, 
    -0.09294968f, 0.16563089f, 0.06464519f, -0.12325163f, -0.22452502f, -1.25471878f, 0.28140923f, 0.31281528f, 
    0.17926760f, 0.27461430f, 0.23681389f, 0.49728271f, -0.38295275f, 0.00081325f, 0.11015801f, -0.21143962f, 
    0.15958455f, 0.18337965f, 0.31715697f, 0.09484828f, 0.06264245f, -0.01611791f, 0.15695228f, -0.10643242f, 
    -0.76260751f, 0.11807109f, -0.57584482f, 0.61296123f, -0.41349471f, 0.02056677f, -0.03802324f, 0.12748170f, 
    -0.24761541f, 0.05757617f, -0.10145593f, -0.18948150f, -0.07924407f, -0.05240742f, -0.22476462f, 0.06203286f, 
    -0.19761516f, -0.01453071f, -0.14675716f, -0.14657751f, -0.05054550f, -0.04501494f, -0.34629035f, 0.29860020f, 
    0.18361326f, 0.03004981f, 0.34608465f, 0.02105851f, 0.30196223f, -0.00715932f, -0.15934800f, 0.20405336f, 
    0.31178406f, -0.05183612f, 0.27102175f, -0.07641705f, -0.06180339f, -0.06156832f, -0.38395166f, -0.10988667f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30118379f, 0.19328514f, 0.03432351f, -0.20891573f, -0.10878060f, 0.11440966f, 0.05502921f, -0.17356499f, 
    0.03911819f, 0.03065088f, 0.03011943f, 0.03305773f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
