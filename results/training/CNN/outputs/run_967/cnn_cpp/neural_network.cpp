#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28412250f, -0.39617816f, -0.16470963f, 0.81941825f, -0.01679558f, -0.34044677f, -0.35329300f, 0.37872350f, 
    -0.44942155f, -0.02694087f, 0.03998096f, 0.16704184f, 0.11756632f, -0.37909937f, -0.23198156f, -0.23134941f, 
    0.25638252f, 0.26220390f, 0.27123451f, -0.11053540f, -0.12693699f, -0.24882482f, -0.16865809f, -0.01341758f, 
    -0.08833840f, -0.26713544f, 0.88807231f, 0.38669792f, -0.53013653f, -0.14931284f, -0.62809616f, 0.34934840f, 
    -0.14438173f, -0.13369535f, -0.10286120f, 0.12182691f, 0.20496207f, -0.09479710f, 0.03753877f, 0.26947579f, 
    -0.04559940f, -0.06719057f, 0.04647415f, -0.03995595f, -0.01990247f, 0.02966852f, 0.12854791f, -0.11557658f, 
    0.03552546f, 0.05944720f, 0.18091433f, -0.25746432f, -0.61637098f, -0.44692764f, 0.25667533f, 0.06106295f, 
    0.07787450f, -0.25582400f, -0.00960536f, 0.33696198f, -0.02451544f, -0.13165832f, 0.34045327f, 0.19562462f, 
    0.09837046f, 0.10416867f, -0.11457442f, 0.16131382f, -0.04483767f, 0.09019621f, 0.22263458f, -0.09271496f, 
    -0.02750603f, 0.32565734f, -0.04221853f, -0.70023251f, -0.03468912f, -0.29787472f, 0.05675511f, -0.07717045f, 
    0.27627414f, 0.54164940f, 0.14574671f, 0.26450336f, 0.44223824f, 0.21422398f, -0.06132437f, 0.34433484f, 
    0.06540748f, 0.10995090f, 0.18950753f, -0.04498675f, -0.10819533f, 0.08004905f, -0.01987088f, -0.05486664f, 
    0.17028801f, -0.15388530f, 0.12550913f, -0.07875661f, -0.32720935f, -0.56836772f, -0.14205688f, 0.05981385f, 
    0.04034343f, 0.09948373f, 0.52714765f, -0.39275900f, 0.45763487f, 0.39077511f, -0.09582491f, -0.30549285f, 
    0.07829145f, 0.02955974f, -0.13320921f, -0.20322262f, -0.04139689f, 0.01524685f, 0.24165188f, -0.20292166f, 
    0.02082609f, -0.17424884f, -0.21778800f, -0.09061299f, 0.22530653f, -0.44034600f, -0.22066510f, 0.27132764f, 
    -0.37848192f, -0.38273099f, -0.17597771f, -0.00581445f, -0.18567900f, 0.20999134f, -0.54764813f, -0.01389961f, 
    0.16332889f, -0.00022070f, 0.33316070f, 0.15099944f, 0.12347084f, -0.20892061f, -0.04962208f, 0.06914349f, 
    0.02892219f, 0.12757865f, 0.02118247f, 0.18778838f, -0.01210594f, 0.28048357f, 0.36925113f, -0.15760387f, 
    -0.59610915f, 0.01531023f, -0.27395266f, 0.30196577f, 0.20468844f, 0.28471512f, 0.14423050f, -0.32670942f, 
    -0.42620227f, -0.20293793f, 0.02280611f, -0.16359749f, 0.13967727f, -0.41463321f, -0.40825999f, -0.53158766f, 
    -0.13825247f, -0.18765840f, 0.28102669f, 0.16747519f, 0.13825577f, -0.03457075f, -0.13650955f, -0.71307707f, 
    -0.51935202f, 0.05958594f, 0.29113117f, 0.16080551f, 0.47890848f, 0.06262266f, 0.40921542f, 0.14835900f, 
    -0.01164613f, 0.04929752f, -0.04570889f, -0.09832941f, 0.25660902f, 0.14071219f, 0.10481814f, 0.00987557f, 
    -0.09839941f, 0.08503773f, 0.16780703f, -0.09220048f, 0.20057528f, 0.17898701f, 0.08968242f, 0.06865845f, 
    -0.46756396f, -0.65717995f, -0.31989083f, 0.29108131f, 0.39142624f, 0.33033630f, 0.66857553f, -0.27479577f, 
    0.09521800f, -0.22990003f, 0.10812993f, 0.22450338f, -0.33450818f, 0.17523165f, 0.42050812f, -0.00167740f, 
    -0.11406402f, -0.04633344f, -0.16850144f, 0.07427076f, 0.01962901f, 0.05071313f, -0.08825048f, 0.23038043f, 
    -0.30328801f, -0.36311230f, 0.61703038f, -0.27306497f, -0.30092859f, -0.43686208f, 0.52288747f, 0.24622469f, 
    -0.44965929f, 0.40820432f, -0.26743859f, -0.13075864f, 0.12557900f, 0.05328846f, 0.10953443f, 0.24808027f, 
    0.16629680f, -0.24895972f, 0.25381944f, 0.10828513f, 0.21209390f, 0.08770066f, -0.01320447f, -0.05394966f, 
    -0.10803542f, 0.15309431f, 0.49675971f, 0.63352883f, 0.54706150f, 0.05863740f, 0.40054199f, -0.30835429f, 
    -0.12244785f, -0.37515801f, 0.29831657f, -0.23450708f, 0.17635739f, -0.08306476f, -0.04408996f, 0.07263177f, 
    -0.19990440f, 0.20392115f, -0.02935132f, 0.03321723f, -0.06468517f, -0.19853227f, -0.14202309f, -0.00699015f, 
    0.08874176f, 0.21453446f, 0.44069356f, 0.31527466f, 0.58977413f, 0.16937150f, 0.27339631f, 0.02214485f, 
    0.22910549f, -0.45318010f, -0.32243693f, -0.37380397f, -0.35450321f, 0.21060297f, 0.00037168f, 0.23132589f, 
    -0.05378819f, 0.12382317f, -0.17362995f, -0.08979367f, 0.25472295f, 0.00147000f, -0.05303895f, 0.00493403f, 
    -0.04893341f, 0.00850038f, -0.00078164f, 0.05411076f, -0.15236533f, -0.38221598f, -0.29034314f, -0.44943023f, 
    -0.51640588f, 0.07275349f, 0.22967394f, -0.14828466f, -0.27400866f, 0.03220357f, 0.20708783f, 0.13032307f, 
    -0.19939674f, 0.06432374f, -0.13391729f, 0.24329914f, -0.27066180f, 0.14380588f, -0.19320160f, 0.01169633f, 
    -0.04975259f, 0.09710621f, -0.08794177f, 0.15807319f, 0.19493625f, -0.49486953f, -0.66298056f, -0.49574435f, 
    0.09797759f, -0.33493632f, -0.30485958f, -0.09041080f, -0.33180869f, -0.07032873f, 0.34482792f, 0.06524955f, 
    0.17808826f, 0.06999216f, -0.08576439f, 0.09144545f, -0.09555584f, -0.10922988f, 0.03409500f, 0.21070151f, 
    -0.32867670f, 0.07097479f, -0.16391648f, -0.00123802f, 0.09216674f, -0.01340508f, 0.07012608f, 0.56348592f, 
    0.57039982f, 0.37602380f, -0.42510024f, -0.46708602f, 0.25489649f, -0.06382118f, 0.02181315f, -0.16285272f, 
    -0.13429889f, -0.00296409f, 0.40278941f, 0.22266181f, 0.31383738f, 0.05559837f, -0.15249038f, 0.21866158f, 
    0.08116180f, -0.32652992f, -0.05708380f, -0.17038521f, -0.18633217f, -0.18009074f, -0.11938843f, -0.07302145f, 
    -0.09200614f, -0.29293740f, 0.80361652f, 0.07762934f, 0.42175180f, 0.38334933f, 0.23298138f, -0.26284522f, 
    -0.13530485f, -0.02857292f, 0.32859290f, -0.04349037f, 0.15837787f, 0.00999054f, -0.37441945f, -0.21081258f, 
    -0.44619215f, -0.07412682f, -0.33571574f, 0.04209828f, 0.08239320f, -0.16532822f, 0.24431451f, -0.03912404f, 
    0.46735722f, 0.13939908f, -0.46713027f, 0.49303186f, 0.43749607f, 0.06868631f, -0.54966563f, 0.17262040f, 
    0.41744989f, 0.17697264f, -0.26516536f, -0.18149677f, 0.11706051f, -0.22739516f, -0.18345228f, -0.08059821f, 
    -0.20053154f, 0.23932990f, 0.13120326f, 0.29848340f, 0.35490841f, 0.06008529f, -0.03924039f, -0.36869043f, 
    0.24293834f, 0.58909643f, -0.13066152f, -0.07693309f, 0.08453168f, 0.27645195f, 0.09461645f, -0.48900408f, 
    -0.13249724f, -0.33323923f, -0.08988601f, -0.37084329f, -0.14053839f, 0.30497995f, -0.18129343f, 0.11456490f, 
    -0.06205951f, -0.15453488f, 0.05830981f, 0.30317813f, -0.16551040f, 0.08227559f, 0.10156944f, 0.24655189f, 
    -0.26253092f, -0.16250303f, 0.60781449f, 0.32549679f, 0.22927906f, 0.67405272f, 0.17977141f, 0.52644014f, 
    -0.14302184f, -0.22910339f, -0.03408161f, -0.27342102f, -0.09710520f, 0.21119621f, 0.02855267f, 0.05040153f, 
    -0.29209423f, -0.16923699f, -0.02806635f, -0.08424819f, -0.24942704f, -0.03417156f, -0.24764924f, -0.09663025f, 
    0.02256905f, -0.06779514f, 0.15211143f, -0.33144736f, -0.54541790f, 0.22716655f, 0.31150669f, -0.06249936f, 
    0.11553872f, 0.45081088f, 0.14250404f, 0.46645507f, 0.26199615f, -0.14735405f, 0.08350514f, -0.28313646f, 
    0.28611171f, -0.38051713f, -0.06438353f, 0.10954878f, -0.40091297f, 0.32442376f, 0.15537968f, 0.02037491f, 
    -0.03517886f, 0.17036249f, -0.08927920f, -0.11417349f, 0.38103318f, 0.39884111f, 0.41571769f, -0.14103180f, 
    0.12752053f, -0.65221870f, -0.10923284f, -0.31540293f, -0.23262854f, -0.42898411f, 0.16156133f, -0.05673312f, 
    -0.17683491f, -0.17626405f, 0.20385531f, 0.08643803f, -0.27074197f, 0.10953598f, 0.12026080f, -0.00478545f, 
    -0.21486716f, -0.09531992f, 0.06361334f, -0.05172024f, -0.06617420f, -0.44997615f, 0.42481968f, 0.50034422f, 
    0.00844426f, 0.11383714f, -0.54479468f, 0.39498660f, 0.18001278f, 0.32368043f, 0.36558503f, -0.56989783f, 
    -0.00241829f, -0.04339785f, -0.08090023f, -0.05836926f, -0.09680330f, -0.12014497f, -0.30667248f, -0.11190370f, 
    0.05092508f, -0.14941782f, 0.21909440f, 0.00404285f, 0.29837662f, -0.01201906f, 0.35749796f, 0.33387437f, 
    0.16118219f, 0.04794515f, 0.60620952f, -0.19016747f, 0.01420631f, -0.17493375f, -0.12081142f, -0.17540219f, 
    -0.02684376f, 0.26299486f, 0.35561040f, 0.22654231f, -0.14400597f, 0.28699231f, 0.19992179f, 0.18826303f, 
    0.22319967f, 0.31605804f, -0.00747347f, 0.14848882f, 0.41544440f, 0.12893425f, -0.01687484f, 0.44831374f, 
    -0.27462777f, 0.30215201f, 0.49449840f, 0.39175537f, 0.54851520f, 0.19781765f, 0.03483491f, 0.03368886f, 
    0.19272444f, 0.03121784f, 0.22687612f, 0.00290299f, 0.14498927f, -0.10517178f, 0.03034020f, -0.30568293f, 
    -0.30300951f, -0.02239051f, -0.07845368f, 0.10743609f, 0.20055328f, 0.30341959f, 0.19149980f, 0.05563337f, 
    -0.21863602f, -0.33012369f, -0.13553703f, -0.27818334f, -0.37460282f, -0.35990852f, -0.09797179f, 0.46103013f, 
    0.24559414f, -0.40151790f, -0.29010004f, -0.32553154f, -0.20111479f, -0.32926393f, -0.12393008f, -0.11882807f, 
    -0.30294406f, -0.26005557f, 0.16215456f, 0.15324718f, 0.03487046f, -0.14485952f, 0.11404438f, -0.39527801f, 
    0.08318017f, 0.56386471f, 0.30247515f, 0.28899547f, -0.71683854f, 0.51153260f, -0.22167623f, 0.20326319f, 
    0.07436816f, 0.05032873f, 0.17058171f, 0.25778446f, 0.16130677f, 0.06776799f, 0.17671125f, 0.08449368f, 
    0.15794916f, 0.15762427f, -0.04403024f, 0.08137360f, 0.35094926f, 0.13299797f, 0.15803792f, -0.25703785f, 
    -0.11870359f, 0.03890948f, 0.32938823f, -0.14089735f, -0.28323337f, -0.71820742f, -0.11403643f, 0.31728259f, 
    0.37860352f, 0.49767542f, 0.26376188f, 0.23110102f, -0.20304714f, 0.33373427f, -0.40643024f, 0.10340781f, 
    0.06495292f, 0.07858546f, -0.09294046f, 0.06831690f, 0.19654247f, 0.16521490f, 0.00513280f, 0.15901540f, 
    -0.22550339f, -0.15801841f, 0.03783065f, 0.64932632f, 0.57200742f, 0.39883876f, 0.15471084f, 0.55339134f, 
    0.28777835f, -0.34225327f, -0.07127602f, -0.28582954f, 0.20785831f, -0.09384099f, 0.42827332f, -0.00737633f, 
    0.32579014f, -0.05109904f, 0.20693702f, -0.12341340f, -0.11676853f, -0.06455430f, -0.16833799f, 0.10232413f, 
    0.14944178f, -0.19721712f, -0.09364068f, -0.03762953f, 0.17865759f, 0.36784926f, 0.41894940f, 0.34508455f, 
    -0.02681653f, -0.32429621f, 0.04750996f, -0.40276855f, -0.49511984f, 0.22580519f, 0.12018090f, -0.22216018f, 
    -0.20992386f, 0.33865932f, 0.10652442f, -0.08225735f, -0.24826862f, -0.10672480f, 0.31404287f, 0.21987458f, 
    0.01843686f, 0.22794405f, 0.22252108f, 0.26352176f, 0.08651867f, -0.49499646f, -0.40698439f, -0.57972431f, 
    -0.08437500f, -0.02908240f, -0.46540517f, 0.25841296f, 0.43450743f, -0.29810190f, -0.02554584f, -0.16338849f, 
    -0.22224453f, -0.09793901f, 0.09330542f, 0.35285562f, -0.13510755f, 0.04042924f, 0.01165772f, -0.10189316f, 
    0.09664597f, -0.23343250f, -0.24475956f, -0.08719791f, -0.12516128f, -0.04846147f, 0.54286885f, 0.32671154f, 
    -0.22908199f, -0.67380172f, -0.47673309f, 0.15773620f, 0.45009628f, -0.09269748f, -0.33461782f, -0.08314332f, 
    0.23513404f, 0.03515711f, 0.36509445f, 0.20517050f, 0.08529072f, 0.14702442f, 0.17403446f, 0.25737160f, 
    0.32236898f, 0.23890442f, 0.16160731f, -0.20367113f, 0.01869079f, -0.14401460f, 0.05003077f, 0.56107575f, 
    0.32334194f, 0.41992107f, 0.45935535f, 0.49510899f, 0.39831597f, 0.13577367f, 0.01052659f, -0.20924005f, 
    -0.19036791f, -0.20431449f, -0.10670783f, -0.27703103f, -0.04844853f, 0.06211251f, 0.19483423f, 0.05772366f, 
    0.08496328f, -0.02869470f, -0.08565867f, -0.08464167f, 0.30498278f, -0.04606163f, 0.14992261f, 0.33692220f, 
    0.56959879f, 0.31639016f, 0.55009943f, 0.45604745f, -0.01238913f, 0.07087112f, -0.51986831f, 0.03033975f, 
    0.10407235f, 0.34836924f, 0.14131552f, 0.17744879f, -0.16676569f, -0.24543320f, -0.04975708f, 0.04771487f, 
    -0.06811630f, -0.17633894f, 0.01928985f, -0.09555157f, -0.07521585f, 0.03451787f, 0.24770896f, -0.47230530f, 
    0.08442444f, -0.17233206f, -0.41722170f, -0.51804799f, -0.49458879f, 0.01239879f, -0.28305411f, 0.12374313f, 
    0.30375543f, 0.05527676f, 0.24674527f, -0.17212397f, -0.08408172f, -0.21311550f, -0.20422216f, 0.06281701f, 
    0.22333857f, 0.15341252f, -0.06999712f, 0.03039649f, -0.26328424f, 0.01737149f, -0.14211711f, 0.43564594f, 
    -0.12245877f, 0.16891512f, -0.23256370f, -0.14088993f, -0.01967293f, -0.32591888f, -0.63567179f, 0.21550854f, 
    0.40374222f, 0.22934450f, -0.36651376f, 0.06934145f, -0.08749678f, -0.12190806f, -0.19811942f, 0.14971128f, 
    0.09923728f, -0.22673351f, -0.00422031f, -0.09488752f, 0.12056434f, 0.06229262f, -0.29772672f, -0.01940773f, 
    -0.08123891f, -0.27495074f, 0.00146548f, 0.21886191f, 0.37679088f, 0.40980318f, 0.54715425f, 0.15974325f, 
    0.10037187f, -0.28472352f, 0.51712310f, -0.03439206f, 0.50836009f, -0.44580746f, -0.14879134f, 0.26128754f, 
    0.22883505f, 0.12735124f, -0.17287789f, 0.14288479f, -0.01827311f, 0.07869237f, -0.09685396f, -0.18323061f, 
    0.10976283f, -0.15048228f, -0.10825121f, -0.05605366f, -0.45393664f, -0.00221710f, -0.40564609f, -0.24151537f, 
    0.25230929f, -0.13847369f, 0.14213654f, -0.18395151f, 0.29805303f, 0.04298699f, 0.23695292f, -0.25585395f, 
    -0.05390738f, -0.11021921f, 0.09333710f, 0.27445257f, 0.33974585f, -0.10418796f, 0.54244751f, 0.12979570f, 
    -0.05465332f, -0.40756354f, -0.20058161f, -0.32029736f, 0.29747000f, 0.00506737f, -0.08421604f, -0.28005034f, 
    -0.57940710f, 0.26570639f, 0.14386375f, -0.67028219f, -0.48759434f, -0.36310777f, -0.39233971f, -0.12251387f, 
    0.22529370f, 0.24163648f, 0.06554996f, -0.16761492f, 0.16107272f, 0.03963207f, 0.06785221f, 0.14476633f, 
    0.33942819f, -0.00842772f, 0.15286128f, 0.20705742f, -0.11224031f, -0.14442314f, 0.22804412f, 0.08004035f, 
    0.53273880f, 0.52823603f, 0.35866278f, -0.25753561f, 0.21578759f, -0.44536772f, -0.59705985f, 0.20254585f, 
    0.46589243f, 0.24824364f, 0.02435589f, -0.02172331f, -0.15018316f, -0.22788316f, 0.00391623f, 0.11992177f, 
    0.34819338f, -0.12025598f, -0.12109766f, 0.25628540f, 0.14143896f, 0.08314998f, 0.21398085f, -0.72273016f, 
    0.42326564f, 0.67290813f, 0.56505960f, 0.21716155f, -0.07547904f, -0.09450071f, -0.31916228f, 0.43049130f, 
    -0.20687479f, -0.01174581f, -0.44849649f, 0.01917027f, -0.10183579f, -0.15676846f, 0.01969630f, -0.03997294f, 
    0.04836304f, 0.09532696f, 0.15704556f, 0.01375189f, -0.17933698f, -0.18176720f, -0.09554210f, -0.07538010f, 
    -0.94753551f, 0.04535993f, 0.21157984f, 0.15793738f, 0.02456109f, 0.05543048f, 0.37631711f, -0.09964343f, 
    -0.52049899f, 0.17543571f, -0.27960297f, 0.34995151f, 0.34386852f, 0.07759663f, -0.29671061f, -0.17877159f, 
    -0.16593741f, 0.20042028f, -0.15388705f, -0.24710849f, 0.32630581f, 0.09038588f, -0.04732672f, 0.17191349f, 
    -0.25523618f, -0.01077645f, 0.16824064f, 0.03674144f, -0.21206610f, 0.58330303f, -0.46934494f, -0.53781122f, 
    -0.33900672f, -0.55680269f, -0.05018439f, 0.16691472f, 0.29907006f, -0.04442260f, 0.11273503f, -0.03964895f, 
    -0.27264374f, 0.19949588f, 0.06477876f, -0.06069337f, 0.28281337f, 0.04776390f, 0.07580970f, -0.07549401f, 
    0.20571148f, -0.13231720f, 0.20146990f, -0.31746265f, -0.29693776f, -0.37465093f, -0.15930147f, 0.35313576f, 
    0.63215387f, 0.05982562f, 0.22070646f, 0.46602538f, -0.32815236f, -0.23985809f, -0.19310474f, -0.05229209f, 
    0.06092081f, -0.21183571f, 0.07152347f, -0.01682149f, -0.18330310f, -0.11877487f, 0.04321954f, -0.01979341f, 
    -0.12993182f, 0.10582531f, 0.24895141f, 0.58116305f, 0.09442605f, 0.62103117f, -0.02714714f, -0.08563745f, 
    0.47094250f, -0.67086303f, 0.11183250f, 0.12881707f, -0.23157381f, 0.42212757f, 0.27043363f, -0.06042426f, 
    0.02761270f, 0.00525868f, 0.21728320f, 0.05259455f, -0.04542974f, -0.11240799f, 0.18909676f, -0.03325124f, 
    0.17744084f, 0.25154451f, 0.19611065f, 0.06231426f, 0.06692093f, -0.11815304f, 0.09621400f, 0.32403418f, 
    0.56334907f, -0.49568245f, -0.43322194f, -0.37212110f, 0.26546973f, -0.22906338f, 0.32873797f, 0.10473973f, 
    0.04569801f, 0.20295405f, -0.11470954f, -0.06876393f, 0.07490023f, -0.02207620f, 0.15551230f, -0.27354074f, 
    -0.07713304f, -0.05020975f, -0.15799513f, -0.20422272f, -0.12304907f, -0.22079682f, -0.72337478f, -0.50017554f, 
    0.51003808f, -0.02561531f, -0.66391259f, 0.53820455f, 0.39250931f, -0.43734577f, -0.01286686f, 0.07944226f, 
    -0.04093486f, 0.12544134f, -0.19073981f, 0.07770757f, -0.37533855f, 0.02059786f, 0.04823003f, -0.15474315f, 
    -0.08947860f, 0.13270882f, 0.16937643f, 0.00372561f, -0.05278759f, 0.15524994f, 0.41395360f, -0.06457362f, 
    -0.30749309f, 0.38344362f, 0.43143135f, -0.54503477f, -0.55872840f, -0.13534912f, -0.55260849f, 0.19073850f, 
    -0.24735588f, 0.11915084f, 0.21093042f, -0.24987261f, 0.26723430f, 0.15601650f, -0.01591792f, -0.06364108f, 
    -0.26089618f, -0.10598895f, -0.01836074f, -0.00497084f, 0.04582286f, 0.24837266f, 0.26922533f, 0.79522789f, 
    0.02320659f, -0.38176668f, 0.27247655f, 0.46177426f, 0.38441101f, 0.56163698f, 0.21741880f, 0.39649278f, 
    0.22853638f, -0.13586606f, 0.20110875f, -0.33436006f, 0.07767494f, -0.10140854f, 0.21057169f, 0.06886415f, 
    0.00004698f, 0.22190961f, 0.07897887f, 0.05148682f, -0.00588925f, 0.13828385f, -0.15354995f, -0.10338540f, 
    0.56691217f, 0.11717349f, -0.52295345f, -0.17943023f, -0.26443022f, -0.10513488f, 0.34992465f, -0.26786771f, 
    0.14374624f, 0.44999966f, 0.28751767f, -0.06401581f, -0.20884897f, -0.07111441f, 0.09885302f, 0.08379705f, 
    0.16612911f, -0.09428061f, -0.22064343f, 0.15763912f, -0.31444815f, 0.04747175f, 0.17605254f, -0.09600274f, 
    -0.36504602f, 0.49647155f, 0.09823147f, 0.25807256f, 0.37573668f, 0.60060078f, -0.33045045f, 0.20483606f, 
    0.18739471f, 0.31710732f, -0.15250200f, 0.13952376f, 0.12742078f, -0.05762661f, -0.28217331f, -0.16742091f, 
    -0.22721350f, -0.22150582f, -0.16064169f, 0.11418406f, -0.14873734f, 0.16633481f, -0.15134642f, -0.08752882f, 
    -0.06801990f, -0.16729827f, -0.13620162f, 0.05195268f, -0.50430423f, 0.73756105f, 0.34275904f, 0.14662813f, 
    -0.44118112f, -0.31551340f, -0.18058673f, -0.13171835f, 0.09868173f, 0.23884651f, -0.08422226f, 0.03163899f, 
    -0.02573176f, 0.25019041f, -0.16617422f, 0.25308046f, -0.20412761f, -0.18867449f, -0.02808427f, 0.29876903f, 
    -0.21991369f, 0.00787353f, -0.25678229f, -0.25028998f, 0.24087809f, -0.19114777f, -0.28066596f, -0.17334528f, 
    -0.19092318f, 0.08727942f, 0.45545289f, -0.15119714f, -0.40238690f, 0.00431123f, -0.23213071f, -0.27814645f, 
    -0.40616834f, -0.34589669f, 0.24942522f, 0.07028905f, 0.18201883f, -0.00792106f, -0.08873054f, -0.26381403f, 
    -0.12985076f, -0.40676001f, -0.19776021f, -0.16530731f, 0.64454174f, -0.28624955f, -0.37496132f, -0.51187932f, 
    -0.25353736f, -0.22250858f, -0.74743247f, 0.00870446f, 0.26182461f, 0.32682198f, -0.14383186f, -0.15245819f, 
    -0.03106231f, -0.07047185f, -0.03654695f, -0.01257314f, 0.22983342f, -0.14805423f, 0.10441320f, 0.20433694f, 
    0.11169732f, 0.04977753f, 0.07421023f, -0.04717510f, 0.10128066f, -0.50825530f, 0.36944833f, 0.04485461f, 
    -0.46113780f, -0.50086147f, 0.45952141f, 0.54579771f, -0.18665010f, 0.34563804f, 0.21600161f, 0.34631443f, 
    0.28418744f, -0.16381098f, -0.16515046f, -0.20007397f, 0.11328492f, 0.09013262f, 0.02675241f, 0.07387304f, 
    0.17345209f, -0.23712626f, -0.04869112f, -0.02351156f, 0.00593751f, 0.01998064f, 0.51369822f, -0.12208967f, 
    0.63490796f, 0.61756855f, -0.14036316f, 0.21716364f, -0.06979893f, 0.17570221f, -0.21645169f, -0.27245250f, 
    0.15415579f, -0.26981911f, -0.14620858f, 0.11632381f, -0.07363777f, -0.14069897f, 0.16267942f, -0.19207923f, 
    0.11254495f, 0.21816586f, 0.19277541f, 0.30298269f, -0.25167742f, 0.13161723f, -0.12235264f, -0.65596974f, 
    -0.22414416f, -0.40203041f, 0.15918332f, -0.06533137f, 0.10742474f, 0.16748975f, -0.07774504f, 0.31322831f, 
    -0.05036658f, -0.16101898f, 0.28570518f, 0.10131118f, -0.27129588f, 0.02324593f, -0.35255346f, 0.38104153f, 
    0.17321043f, 0.18426916f, -0.33054456f, 0.18505114f, 0.02816711f, -0.27297556f, -0.10526984f, -0.14526226f, 
    0.42967671f, -0.03436419f, -0.32092875f, -0.61257863f, 0.43046641f, -0.20683281f, -0.40446407f, 0.29414424f, 
    0.04536631f, -0.15202194f, -0.25312549f, -0.00805814f, 0.08214842f, 0.00299778f, 0.24220002f, 0.32839662f, 
    -0.38228157f, -0.29726252f, -0.24965739f, -0.14895713f, 0.09383164f, 0.25003824f, -0.22640187f, 0.07401088f, 
    0.11006361f, -0.47078672f, 0.18553834f, -0.28798544f, -0.11061793f, -0.22854732f, 0.54642618f, 0.74274778f, 
    0.14326823f, 0.06996904f, 0.32258025f, -0.11378479f, -0.30339581f, 0.12456135f, -0.08474783f, 0.25537890f, 
    -0.28646293f, -0.10057731f, 0.14656623f, 0.25147891f, -0.25439247f, 0.02378765f, -0.22884813f, -0.23454131f, 
    0.06890106f, -0.06101953f, 0.00341878f, 0.17904232f, -0.34412599f, -0.18558528f, -0.16516453f, 0.29479209f, 
    -0.52167076f, 0.02337243f, 0.20258887f, -0.44593984f, -0.07896194f, -0.36097747f, 0.18403491f, -0.01422678f, 
    -0.45992306f, -0.12559068f, 0.16141963f, 0.33267829f, 0.15470044f, -0.27625906f, -0.30066845f, -0.11108786f, 
    0.18397465f, -0.00269760f, 0.25916305f, -0.34655994f, -0.36202320f, -0.41299027f, -0.34568006f, -0.21839306f, 
    -0.22011989f, -0.55159432f, -0.07504258f, 0.27864230f, -0.24312985f, 0.07856753f, 0.11031831f, -0.19742729f, 
    0.05583163f, -0.28754643f, -0.10363560f, 0.04006732f, -0.29074550f, 0.02049269f, 0.09697577f, 0.16456124f, 
    -0.16789350f, 0.02405450f, -0.27690613f, -0.17467551f, 0.70675951f, 0.48059326f, 0.54502648f, -0.42395511f, 
    -0.66280156f, -0.23288827f, -0.32482332f, -0.39576292f, -0.09041788f, 0.10457191f, 0.05595863f, -0.13958816f, 
    -0.31356478f, -0.24634054f, -0.00751347f, -0.22376777f, -0.18104282f, -0.06589765f, -0.03876753f, 0.07039347f, 
    0.22475547f, 0.18977098f, -0.09748738f, 0.01909358f, -0.02639323f, 0.33638355f, -0.38047525f, -0.04317845f, 
    0.11114199f, 0.19203579f, 0.35002697f, -0.20062385f, 0.33920044f, -0.23487028f, 0.27437469f, 0.30475113f, 
    -0.23748074f, -0.28804931f, 0.16875365f, 0.14207682f, 0.31904069f, 0.26412040f, -0.10221951f, 0.15788706f, 
    -0.23458640f, 0.20896462f, 0.13000710f, -0.23420869f, 0.08224608f, 0.11246818f, -0.38228187f, -0.36707535f, 
    -0.60799563f, -0.05168030f, 0.18944402f, -0.04846312f, 0.15065622f, -0.13803114f, 0.30358088f, 0.14391902f, 
    0.38843057f, -0.01686731f, -0.01564134f, 0.19062747f, -0.21701080f, 0.06072416f, -0.04790867f, 0.14246789f, 
    -0.25337124f, -0.21530938f, -0.21553449f, 0.00911667f, -0.13718377f, -0.01110170f, 0.18194315f, -0.53769994f, 
    -0.45881811f, -0.52252477f, -0.22735673f, 0.00075387f, 0.39026660f, 0.34181377f, 0.28066084f, 0.35937962f, 
    0.18891047f, 0.16898574f, 0.14363833f, 0.23221155f, -0.03500718f, 0.25041679f, 0.05020500f, -0.08646399f, 
    0.00403186f, -0.22224557f, 0.03320132f, -0.07303084f, 0.07369327f, 0.29686958f, -0.23335640f, -0.06478975f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05747472f, 0.14993522f, 0.14513664f, 0.05737514f, 0.08311303f, 0.26081958f, 0.05791355f, 0.19473571f, 
    0.08778398f, 0.01324600f, 0.22473995f, -0.00898979f, -0.05915313f, 0.05752273f, 0.14252460f, 0.13277824f, 
    -0.01719520f, 0.14150527f, 0.16666472f, 0.13297766f, 0.22009170f, -0.01054006f, 0.03870711f, -0.09979099f, 
    -0.11958385f, -0.00426160f, 0.24495368f, -0.07132153f, 0.18946414f, -0.12145322f, 0.10330826f, 0.05258438f, 
    0.07786748f, 0.06517624f, 0.17928687f, 0.13067797f, 0.03950174f, 0.08092456f, 0.09727459f, 0.06190764f, 
    0.03174443f, 0.03849706f, -0.11447329f, -0.05082037f, 0.11802353f, 0.01327895f, 0.11707717f, -0.07649012f, 
    0.15407397f, -0.19384818f, 0.13248993f, 0.10032240f, 0.08276411f, 0.23273633f, 0.01775393f, 0.05428496f, 
    0.26657102f, 0.22783878f, 0.02826874f, 0.12690340f, 0.03530524f, 0.11135725f, 0.04411287f, 0.12939970f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02268287f, 0.02326583f, -0.00842944f, -0.00027166f, -0.00519242f, 0.00389351f, 0.02781964f, -0.02665103f, 
    0.01702888f, -0.01629281f, 0.02995009f, -0.03166795f, 0.00388732f, 0.01914423f, -0.01308644f, -0.01382549f, 
    -0.00572172f, -0.00969052f, -0.01139712f, -0.02648120f, 0.00998907f, -0.01778024f, 0.00617673f, -0.03963673f, 
    -0.02306552f, -0.00654419f, -0.02502049f, -0.00180476f, -0.02193400f, -0.00541464f, -0.02835681f, 0.00336641f, 
    0.01311927f, -0.00799615f, -0.01383908f, -0.02160170f, -0.03851652f, -0.00844159f, 0.00867386f, 0.02438519f, 
    -0.03107999f, 0.02597953f, -0.04152322f, -0.03179409f, -0.03679204f, -0.02318225f, 0.02341929f, -0.02559624f, 
    -0.02087258f, 0.00526566f, -0.01697123f, -0.00218266f, 0.01675937f, -0.03792834f, -0.03521389f, -0.02084094f, 
    -0.01806870f, 0.02418938f, -0.03856153f, -0.03194040f, -0.03519740f, -0.00628759f, -0.02265060f, -0.01331141f, 
    -0.01531563f, -0.01873250f, 0.02960199f, 0.00947920f, -0.03717152f, 0.00942708f, -0.02542646f, 0.03001531f, 
    0.02744527f, -0.00124494f, -0.01238012f, -0.01110440f, 0.01671075f, 0.02584222f, 0.01080846f, 0.03002453f, 
    -0.01627225f, -0.00930295f, -0.02828048f, -0.00434234f, 0.01270260f, 0.00487987f, -0.02538011f, -0.00224669f, 
    -0.00173571f, -0.04074311f, 0.01625707f, 0.02476766f, 0.01086916f, -0.00682358f, -0.00169869f, 0.00581444f, 
    0.01147720f, -0.00767026f, -0.03558146f, -0.01467473f, 0.02622449f, -0.00866330f, -0.03857148f, -0.01739810f, 
    -0.00945717f, -0.02827758f, -0.01436654f, 0.02428788f, 0.01099469f, 0.00293529f, -0.03477063f, -0.01356304f, 
    0.00358992f, 0.01354456f, -0.03743553f, -0.02083631f, 0.01938950f, -0.01762021f, 0.01360172f, -0.01305888f, 
    0.01881756f, 0.01440600f, 0.02725263f, -0.02328133f, -0.01918407f, -0.00461604f, -0.00130457f, -0.02251649f, 
    -0.00763781f, -0.02458474f, 0.00871130f, 0.00832562f, -0.03034954f, 0.01574842f, 0.00250265f, -0.00065301f, 
    0.00406293f, 0.02378763f, -0.02670173f, -0.03148840f, -0.02294758f, 0.02075084f, -0.03410222f, 0.00241426f, 
    0.00330227f, -0.00907054f, -0.04023742f, 0.02773204f, -0.00324593f, -0.03859552f, -0.00744827f, -0.01118411f, 
    0.02175220f, -0.01200116f, 0.02246259f, -0.01326950f, -0.02027733f, -0.03201659f, -0.02968273f, -0.01394336f, 
    -0.03383555f, 0.01186436f, -0.03360647f, 0.01714254f, -0.00793962f, -0.01829495f, -0.03362733f, -0.00769573f, 
    -0.03683865f, -0.00808609f, 0.01785757f, -0.02755123f, -0.01855782f, -0.02979613f, 0.00556461f, -0.00535627f, 
    -0.01803184f, 0.01479857f, -0.01170283f, 0.01160695f, 0.01494016f, -0.02811951f, 0.02871115f, 0.00102027f, 
    -0.00993657f, 0.00933848f, 0.02013809f, -0.02861455f, -0.01896905f, -0.00954874f, 0.00396773f, 0.00745559f, 
    -0.00971411f, -0.04041023f, -0.02423168f, -0.01950857f, 0.02736683f, -0.01444287f, -0.02376823f, -0.01993180f, 
    -0.02740477f, -0.02553856f, -0.02328503f, -0.01240402f, 0.01024808f, -0.00928876f, -0.00848432f, -0.02878350f, 
    -0.04088870f, -0.01150209f, 0.00363786f, -0.04106741f, -0.02246945f, -0.01663520f, 0.00036388f, 0.01799745f, 
    -0.01410522f, -0.02190219f, -0.02485771f, 0.01750041f, 0.00052774f, 0.01022773f, 0.01453532f, -0.02652271f, 
    -0.00429835f, 0.01391065f, 0.00666218f, -0.01105796f, -0.01507831f, -0.03015061f, 0.00102276f, 0.00331217f, 
    -0.00833075f, 0.00264805f, -0.04102460f, 0.00218546f, 0.02498478f, -0.00311211f, -0.02842191f, -0.01613269f, 
    -0.00016850f, -0.02398969f, -0.03626838f, -0.02796301f, -0.02129510f, -0.01950942f, -0.00554313f, 0.01788400f, 
    -0.01764010f, -0.00816528f, -0.02504859f, -0.03761169f, -0.01997804f, -0.03844492f, 0.00535030f, -0.00306585f, 
    0.02265000f, -0.02512694f, -0.00261777f, -0.02777951f, 0.02425911f, 0.00285270f, 0.00637597f, -0.02950301f, 
    -0.02571031f, -0.01409544f, 0.00829745f, 0.01064017f, -0.01108008f, 0.01395439f, 0.02628068f, -0.01994773f, 
    -0.00251568f, -0.00489690f, 0.01131877f, -0.03413076f, 0.01423454f, 0.01366075f, -0.02842297f, 0.02813836f, 
    0.02029821f, -0.00839319f, -0.02308423f, -0.01005023f, -0.01106218f, -0.02603572f, -0.02776288f, -0.03832740f, 
    0.01331660f, -0.03367154f, -0.03716182f, 0.00305090f, 0.02156045f, 0.02644601f, -0.02477553f, 0.02097823f, 
    -0.01466367f, -0.02977021f, 0.00723743f, -0.01535288f, -0.02161373f, 0.00354908f, 0.02356889f, -0.04076992f, 
    0.02507650f, 0.00475921f, -0.03843523f, -0.01333953f, -0.01448694f, -0.03336711f, 0.02436164f, 0.02624441f, 
    0.02000443f, 0.00137231f, -0.02957505f, 0.02278691f, -0.01290106f, 0.01737652f, 0.01226638f, -0.04083678f, 
    0.00898099f, -0.03601507f, -0.02144564f, 0.01645085f, -0.02595134f, 0.01605217f, -0.00676480f, -0.02862846f, 
    -0.00881498f, -0.02726351f, -0.00328844f, 0.01019087f, 0.02354822f, -0.01592037f, -0.01096519f, -0.00733711f, 
    0.01634086f, -0.02409045f, -0.01415929f, -0.01597906f, -0.01871223f, -0.00000745f, -0.03208875f, -0.03097290f, 
    0.02835983f, -0.02655478f, 0.00858816f, 0.00187458f, -0.03665383f, -0.03899646f, 0.02876075f, 0.00384675f, 
    -0.03957876f, 0.02908648f, 0.02840280f, 0.00482344f, 0.00813973f, 0.01246452f, 0.01021197f, -0.00657704f, 
    -0.04200654f, 0.02305664f, 0.01314446f, -0.00377159f, 0.00027901f, 0.00893190f, 0.02558179f, -0.00906301f, 
    0.00646618f, -0.01181244f, 0.01617490f, -0.00910787f, 0.00152125f, 0.01814129f, -0.01360205f, -0.01228402f, 
    -0.00983146f, -0.00336131f, -0.02809317f, -0.01746007f, -0.00408529f, -0.03482706f, -0.03391096f, -0.01012389f, 
    -0.01256596f, 0.00299602f, 0.01018957f, 0.02461873f, 0.01113534f, 0.01903635f, -0.00124009f, 0.00628377f, 
    -0.03373191f, -0.03174732f, 0.00364634f, 0.02071800f, -0.02540180f, -0.03835752f, 0.00269774f, -0.01443905f, 
    0.01766681f, -0.00728907f, 0.00444486f, 0.01010156f, -0.00263977f, 0.02684788f, 0.00465620f, -0.03990150f, 
    -0.02259826f, -0.02375635f, -0.01350415f, -0.03086526f, -0.02244977f, 0.00659863f, 0.02668114f, -0.03890558f, 
    -0.00356978f, 0.01059905f, -0.02515426f, 0.02601604f, 0.02879255f, -0.01626480f, -0.01053736f, -0.02876516f, 
    -0.04195979f, -0.01587100f, -0.00833979f, 0.02761581f, -0.03752375f, -0.02634891f, 0.02158651f, -0.02072980f, 
    -0.03563301f, 0.00930739f, 0.02572674f, 0.00998519f, -0.00228436f, -0.00671894f, -0.04106686f, 0.01366645f, 
    -0.01541290f, -0.00862868f, 0.02265450f, 0.02157693f, -0.03226458f, -0.01339514f, -0.02582129f, 0.00025547f, 
    0.01753750f, 0.00647655f, 0.01646472f, -0.00100307f, -0.00399775f, 0.00895937f, -0.02983432f, 0.00182894f, 
    0.01708839f, -0.00346585f, -0.00899052f, -0.03812136f, 0.02033567f, 0.02870571f, -0.03241767f, -0.00153273f, 
    0.01583511f, 0.00711106f, 0.01508532f, 0.02387255f, -0.00435898f, -0.00142304f, 0.02717610f, -0.00408706f, 
    -0.03111940f, -0.01751872f, -0.00344141f, 0.01983263f, -0.02978606f, 0.00803828f, -0.02340694f, 0.02196976f, 
    -0.03754769f, 0.02620267f, 0.01578761f, -0.00510471f, 0.02421180f, 0.01991368f, -0.03895107f, -0.01630790f, 
    0.01907963f, 0.02115902f, -0.00940293f, 0.02310332f, -0.03343260f, 0.01640420f, 0.01287007f, -0.01911951f, 
    0.02426603f, 0.00221204f, -0.02028056f, -0.00685722f, -0.03743199f, -0.02919816f, -0.02998821f, 0.00475988f, 
    0.00392136f, -0.01833634f, 0.02447486f, -0.04098402f, 0.00908724f, -0.02354946f, -0.01279595f, -0.02299056f, 
    0.01100105f, -0.02711730f, -0.01446201f, -0.00508862f, -0.00803545f, 0.00612706f, -0.03112504f, 0.00103900f, 
    -0.02797164f, -0.02297508f, -0.00480856f, 0.00981242f, -0.03172096f, -0.02252916f, -0.02882136f, -0.02915113f, 
    0.02188406f, -0.01745171f, -0.01402660f, -0.01710497f, 0.02702508f, -0.02774111f, -0.00706091f, -0.00473589f, 
    0.01413516f, 0.01017140f, 0.00882594f, -0.01043484f, -0.00841474f, -0.03241377f, 0.00349091f, -0.02644944f, 
    0.00898099f, -0.00602134f, 0.02594402f, 0.02301443f, 0.01323487f, 0.02361910f, -0.00648328f, -0.04183266f, 
    0.00377289f, -0.00059158f, -0.01642845f, 0.02546158f, -0.00210033f, 0.02929582f, 0.01751655f, 0.00104927f, 
    -0.02211247f, -0.00687263f, -0.02193753f, -0.03086563f, 0.01779370f, 0.02557682f, 0.00686367f, -0.03791052f, 
    -0.04005083f, 0.02554414f, -0.02866681f, -0.01474853f, 0.00978446f, -0.03298745f, -0.00417936f, -0.01358050f, 
    -0.00359900f, 0.02627728f, 0.02422844f, -0.00102237f, -0.01763503f, -0.03818548f, -0.01236188f, 0.01356867f, 
    -0.01754234f, 0.00625507f, 0.01143411f, -0.02761912f, 0.00090950f, -0.00281798f, -0.04133205f, 0.02900812f, 
    0.02916030f, -0.00795555f, 0.01190823f, -0.01607854f, -0.03550334f, -0.01469934f, 0.02410530f, -0.01935790f, 
    -0.01034163f, -0.00709210f, -0.01187886f, 0.01245211f, -0.03926324f, -0.01383430f, 0.00055904f, -0.01914526f, 
    -0.02087218f, -0.04083355f, -0.00626620f, 0.01419786f, -0.01165264f, 0.02521656f, -0.00022226f, 0.02438560f, 
    -0.01316141f, -0.02317574f, -0.01934948f, 0.02176470f, -0.00283234f, -0.04028757f, -0.00746389f, -0.00515133f, 
    -0.00177496f, -0.01773618f, 0.00188843f, 0.00490428f, -0.02456824f, -0.01368047f, -0.01791062f, -0.03273886f, 
    -0.02535220f, 0.00546318f, -0.02848736f, 0.01287538f, -0.01777782f, -0.03476841f, -0.01744253f, 0.02735654f, 
    -0.00125594f, 0.01516523f, 0.01562933f, 0.02116983f, -0.02342124f, 0.02585648f, -0.01823508f, -0.01652937f, 
    0.01348653f, 0.02739111f, -0.00198174f, -0.03794646f, -0.03343734f, -0.02722809f, -0.02940320f, 0.00912488f, 
    -0.00962213f, 0.02965125f, -0.01077232f, -0.03869125f, -0.01097623f, 0.02035752f, 0.02955785f, 0.00830723f, 
    0.01493791f, -0.02145917f, 0.02097407f, 0.02436986f, -0.01099022f, 0.00890195f, -0.00875580f, 0.02066067f, 
    -0.01514137f, -0.03435346f, -0.03049738f, 0.01402968f, -0.04012356f, -0.02730949f, 0.00187766f, 0.01322951f, 
    0.02960452f, 0.00677612f, 0.00731240f, 0.02190487f, -0.01863640f, -0.02893219f, -0.03699860f, -0.02400701f, 
    -0.00849741f, 0.00299785f, -0.01941830f, 0.02843566f, -0.03554647f, -0.03867320f, -0.00780505f, 0.01024688f, 
    0.01615436f, 0.00209293f, 0.00300921f, -0.00316743f, -0.01120475f, -0.02683401f, 0.02412273f, -0.03987576f, 
    0.00602331f, -0.00701744f, 0.01931479f, 0.00178416f, -0.02468605f, -0.02345125f, -0.02537602f, -0.01848764f, 
    -0.03519382f, -0.00251708f, -0.01956318f, -0.00288423f, 0.01681886f, 0.01617692f, 0.00052316f, -0.01877304f, 
    0.02858374f, 0.01075477f, -0.01566666f, 0.02764783f, -0.02186383f, -0.02786802f, -0.02270337f, -0.03911712f, 
    0.01728722f, -0.03263277f, -0.01920152f, -0.01705864f, -0.03429631f, -0.02834740f, -0.00659547f, 0.01633247f, 
    -0.02780076f, 0.02622828f, -0.03631703f, -0.03788204f, -0.02370119f, -0.02999243f, -0.00821526f, -0.03728361f, 
    0.01598107f, -0.02736734f, 0.03006429f, -0.00330125f, 0.01816601f, 0.01945484f, -0.04005485f, -0.00832734f, 
    -0.04172095f, 0.01055022f, 0.01079734f, -0.01199246f, -0.01449922f, -0.02641554f, 0.00224873f, 0.00658322f, 
    -0.00087261f, -0.01726524f, -0.03995290f, -0.00730382f, 0.01303512f, 0.02011734f, -0.00525190f, 0.02058977f, 
    -0.04018519f, 0.04185285f, -0.03214481f, 0.02597598f, 0.00738332f, -0.00953547f, 0.02547262f, 0.02373819f, 
    -0.03868753f, -0.02809033f, -0.02971192f, 0.00120032f, -0.03401358f, -0.00863573f, 0.01779211f, -0.01679288f, 
    0.02317864f, -0.00265688f, -0.02194449f, 0.01140099f, -0.01614557f, -0.01254184f, 0.02765413f, -0.00299245f, 
    0.01886678f, -0.00480008f, -0.00622152f, 0.01407294f, -0.00018819f, 0.01594600f, -0.03867585f, 0.00034610f, 
    -0.02781892f, -0.02613071f, 0.02729995f, 0.03439182f, 0.01297067f, -0.00273062f, 0.02229740f, 0.00538408f, 
    0.01033882f, -0.00068125f, -0.03586804f, -0.03159597f, 0.02334695f, 0.02292837f, 0.01782282f, 0.01738336f, 
    -0.01871517f, 0.02535713f, -0.03096506f, -0.03567509f, 0.02492506f, -0.00866569f, 0.01590326f, 0.00427042f, 
    -0.00306252f, 0.00925378f, 0.00036765f, 0.01571288f, -0.02353182f, 0.02483291f, -0.01201454f, -0.00084533f, 
    -0.00003339f, -0.00617648f, -0.01622273f, -0.03344411f, -0.04270475f, -0.01957832f, -0.00594824f, 0.00673248f, 
    0.00301615f, 0.01221885f, 0.01932763f, 0.00619613f, 0.03845899f, 0.01882589f, 0.01543340f, -0.02890448f, 
    -0.03414708f, 0.00860446f, -0.00454947f, 0.01143483f, 0.00414777f, -0.02241579f, 0.02625767f, -0.04000460f, 
    -0.02124556f, 0.02561573f, 0.04247464f, -0.02093399f, 0.00973730f, 0.02925565f, 0.00312542f, -0.00191137f, 
    -0.02857324f, -0.00869896f, -0.01506939f, 0.00680652f, -0.02072976f, -0.01628293f, 0.00052029f, -0.00081416f, 
    0.02267111f, 0.00739112f, 0.01547024f, 0.01855651f, -0.01226725f, -0.00633350f, -0.03401136f, -0.01713996f, 
    0.03006590f, 0.02574056f, -0.01276339f, 0.00957169f, -0.02820647f, 0.02985477f, 0.02400661f, 0.03036261f, 
    -0.00425817f, -0.01769027f, -0.00838645f, -0.00846933f, 0.00754152f, 0.00596729f, 0.02489099f, -0.03891774f, 
    -0.00852751f, -0.02753634f, 0.02115434f, -0.02251667f, -0.02271700f, 0.00387194f, -0.01298899f, 0.00989529f, 
    -0.03586539f, -0.03520820f, -0.03919242f, -0.00081999f, 0.01567835f, 0.02900225f, -0.00817170f, 0.00901004f, 
    -0.00668692f, -0.00575396f, 0.03022156f, -0.00729493f, 0.00121139f, -0.02414481f, 0.02499716f, -0.02726562f, 
    -0.01450676f, -0.01885881f, 0.01224492f, -0.00950273f, -0.01675227f, -0.00398706f, -0.04154792f, -0.02538991f, 
    0.00106219f, -0.01227051f, -0.00991021f, 0.00426870f, 0.01458476f, 0.02452892f, 0.01463689f, -0.01576727f, 
    -0.03233277f, 0.02167866f, -0.00334280f, 0.01297750f, -0.00189879f, -0.00544147f, -0.02216325f, 0.01819960f, 
    0.01439317f, 0.01396434f, -0.01653028f, -0.03269897f, 0.00090059f, -0.03618195f, -0.02563515f, 0.02035077f, 
    -0.01277561f, 0.02696639f, 0.01077625f, -0.03447947f, 0.01770253f, 0.02885859f, 0.01522122f, -0.01055784f, 
    -0.00951879f, -0.02954004f, -0.00671390f, -0.00203463f, -0.01537392f, 0.01659208f, -0.04011820f, 0.02341523f, 
    -0.02580603f, -0.02257151f, 0.01843251f, -0.02641727f, 0.00168241f, -0.02611420f, -0.03394148f, 0.00526712f, 
    -0.01635660f, 0.01600947f, -0.02438102f, 0.00798867f, -0.02140351f, 0.00108545f, -0.00097027f, -0.03125491f, 
    0.02876895f, 0.00966287f, -0.03916836f, -0.02036877f, 0.02180029f, -0.03518255f, -0.03779772f, 0.01943369f, 
    -0.01683816f, -0.02216543f, 0.01664628f, -0.04165994f, 0.00700389f, -0.03108021f, -0.02648907f, 0.01709038f, 
    -0.01684562f, -0.02757586f, -0.02413512f, -0.00576839f, -0.01031854f, 0.02430878f, 0.01490187f, -0.01483661f, 
    -0.00421837f, 0.00916927f, 0.01780176f, -0.03822981f, 0.02206556f, -0.03593820f, -0.02784138f, -0.00819256f, 
    0.01444268f, -0.04393873f, 0.00043459f, 0.02105105f, -0.01239959f, -0.00236507f, 0.01468061f, 0.01073404f, 
    0.02363592f, 0.03374449f, 0.02313849f, 0.00550823f, -0.03028624f, 0.00808254f, 0.00065891f, 0.02861065f, 
    -0.02695668f, -0.02820872f, -0.02137013f, -0.00547742f, -0.00058125f, -0.03809039f, 0.01524335f, -0.01468959f, 
    -0.00835315f, 0.02323750f, 0.00514324f, 0.02719316f, 0.00014477f, 0.02067805f, -0.02392285f, 0.01491541f, 
    -0.00257002f, 0.03430484f, 0.02670522f, 0.02336020f, -0.03030631f, -0.04252569f, -0.02889947f, -0.01717019f, 
    -0.00694381f, -0.02662450f, -0.03976630f, -0.02929032f, 0.02903474f, 0.02937859f, -0.03001865f, -0.02838471f, 
    -0.00293925f, -0.02658612f, 0.02715185f, -0.01733694f, -0.00347871f, -0.00233806f, 0.00116379f, -0.03502846f, 
    0.00831068f, -0.01214423f, -0.01219059f, 0.02082765f, -0.02582873f, -0.01306035f, -0.02009467f, 0.00763497f, 
    0.00526917f, -0.00141164f, 0.00775599f, 0.01614938f, -0.03149893f, -0.02561142f, -0.04349308f, 0.01082197f, 
    0.03220806f, -0.03342098f, -0.00288438f, -0.01137352f, 0.00030149f, -0.03685947f, 0.01951232f, -0.00477460f, 
    0.02846408f, -0.04067838f, -0.02656497f, -0.00953719f, -0.00526296f, 0.01046243f, -0.01501298f, 0.01378267f, 
    -0.02270906f, 0.00150176f, -0.03166822f, 0.01900572f, -0.02723298f, 0.01910915f, 0.02019672f, -0.01511999f, 
    0.02271327f, 0.01704648f, 0.03672147f, 0.02694029f, -0.00757095f, 0.00246742f, 0.02223427f, -0.00710665f, 
    0.02607373f, 0.00183033f, -0.02012374f, 0.01195578f, 0.00892579f, -0.03438127f, -0.00691341f, -0.02880740f, 
    -0.02253696f, -0.01427811f, -0.02473757f, -0.03753578f, 0.00530802f, -0.03200256f, -0.03895550f, 0.00878383f, 
    -0.02807381f, -0.00333718f, 0.01134101f, -0.00300789f, 0.02530220f, -0.01274061f, 0.01255434f, 0.02005495f, 
    0.01110084f, 0.01357461f, -0.03471167f, 0.00337642f, -0.02622451f, -0.02512642f, 0.00174781f, -0.01945720f, 
    0.02141264f, 0.02461218f, -0.01046159f, 0.00810891f, 0.00016629f, 0.02197809f, 0.00200166f, -0.01417566f, 
    -0.01154450f, -0.04187757f, -0.01833389f, -0.03178981f, 0.02119370f, -0.02185087f, -0.01856195f, -0.02729256f, 
    -0.00050579f, -0.02728003f, 0.00988200f, -0.01475230f, -0.00837636f, -0.00535536f, -0.00748436f, 0.00259247f, 
    0.01337951f, -0.02010386f, -0.01522219f, -0.03068367f, -0.01586009f, -0.01926342f, -0.03789675f, -0.02992561f, 
    -0.03139813f, 0.01553198f, -0.02769553f, -0.01550566f, -0.01938173f, -0.02962330f, 0.00235067f, -0.03520352f, 
    -0.00664382f, 0.01882958f, -0.01083316f, -0.02294560f, -0.02380079f, -0.02671907f, 0.02734352f, -0.01933148f, 
    -0.01717374f, -0.03302336f, -0.01250714f, -0.02972480f, -0.00811308f, -0.00741714f, -0.00266756f, -0.03623646f, 
    0.00443456f, -0.03734803f, 0.02511170f, 0.01023484f, -0.02153617f, 0.02105053f, -0.03135979f, -0.00427402f, 
    -0.00602836f, -0.01584154f, -0.02825913f, 0.00050844f, -0.00287722f, 0.03829685f, -0.03995221f, 0.00642284f, 
    -0.00824394f, 0.00575128f, 0.01591200f, 0.00536441f, -0.00438641f, 0.02705629f, 0.02133965f, -0.01997824f, 
    0.02320189f, 0.00597500f, 0.01272082f, 0.01763413f, -0.04068118f, 0.03686115f, 0.01560644f, 0.00624940f, 
    -0.01633249f, -0.02013596f, 0.01736214f, -0.04013056f, 0.01072568f, -0.00800411f, 0.01366748f, -0.00968288f, 
    -0.01644851f, -0.02087714f, 0.01749730f, -0.02318238f, -0.02132901f, 0.00484663f, 0.02109271f, 0.02381204f, 
    -0.02694624f, -0.02310055f, -0.02731905f, -0.00439585f, 0.02470225f, -0.01139904f, -0.01042348f, -0.02822562f, 
    0.01671547f, 0.02548738f, -0.03624813f, -0.00445188f, 0.01366247f, -0.03062931f, -0.03832107f, 0.00745815f, 
    -0.01937852f, 0.01235686f, 0.00853517f, -0.00345117f, -0.02733329f, 0.00081299f, 0.02709841f, 0.02369612f, 
    -0.03332886f, -0.03479303f, 0.01539133f, -0.02532732f, 0.00975162f, 0.00093436f, -0.03492767f, 0.01941895f, 
    -0.01789715f, -0.02711815f, 0.02586132f, -0.03349627f, 0.02957075f, -0.02626495f, 0.02345840f, 0.01695001f, 
    0.02741248f, -0.00644511f, -0.03005608f, -0.03106474f, 0.00789629f, -0.03248895f, -0.03153674f, 0.01100618f, 
    -0.01321663f, -0.01834843f, -0.02035805f, 0.00026801f, -0.01412189f, -0.01580197f, -0.03949637f, -0.01815954f, 
    -0.01903855f, 0.00572096f, 0.00919032f, 0.02804560f, -0.03360024f, -0.03251770f, 0.03016787f, -0.00113465f, 
    0.02698973f, -0.03155579f, -0.01653979f, 0.00011670f, 0.00752112f, -0.02369174f, 0.01759021f, -0.03952773f, 
    0.02596520f, 0.01148326f, 0.02026791f, -0.01241449f, 0.00036642f, -0.00877669f, -0.01336749f, -0.04232154f, 
    0.00744795f, 0.00818880f, -0.03591808f, 0.01684678f, 0.02850741f, -0.04060474f, -0.00968147f, -0.01401389f, 
    -0.01381216f, 0.02651660f, 0.01278309f, 0.02086412f, -0.01509109f, -0.03497645f, -0.00212489f, -0.03766935f, 
    0.01852741f, -0.02483598f, -0.00358806f, 0.00717168f, 0.00530813f, 0.01943480f, -0.02889039f, 0.00475216f, 
    -0.00347924f, -0.00181417f, 0.01368011f, 0.00529508f, -0.01154770f, 0.02385601f, 0.02368853f, -0.02316063f, 
    0.00458317f, 0.01331656f, 0.01321218f, -0.01740506f, -0.01153724f, -0.01553581f, -0.00988462f, -0.03759105f, 
    0.01193648f, 0.01704386f, 0.00389894f, 0.02275713f, -0.01015994f, 0.02433267f, -0.02160251f, -0.02855659f, 
    -0.02859147f, -0.00971979f, -0.04122033f, 0.01491521f, -0.01768113f, -0.00222963f, -0.00651628f, -0.02035186f, 
    -0.02534349f, 0.01674043f, 0.01050723f, -0.00234264f, 0.01771515f, -0.04173307f, -0.00835290f, -0.00099068f, 
    0.00374146f, 0.00250090f, -0.02062805f, 0.01070124f, 0.00076638f, -0.03536719f, -0.01497335f, -0.01673717f, 
    0.01042030f, -0.01251808f, 0.03292856f, -0.02848591f, 0.02442575f, -0.00697265f, -0.02748814f, -0.00410865f, 
    -0.02288285f, -0.03368210f, 0.02692249f, -0.01320857f, -0.00689853f, 0.01488976f, -0.01817363f, -0.04195705f, 
    0.00300735f, -0.03450209f, -0.02459102f, -0.01131351f, 0.02636262f, 0.00742410f, -0.00707648f, -0.00534713f, 
    -0.00165811f, -0.01294212f, 0.02899513f, 0.01313648f, -0.02520225f, -0.03587931f, -0.00604379f, 0.02809042f, 
    -0.02799506f, -0.02771705f, 0.02499005f, 0.00404473f, -0.00524927f, -0.01966818f, -0.02207198f, 0.00420994f, 
    0.01114731f, 0.01150314f, 0.00433205f, 0.02695684f, -0.03379249f, -0.03652540f, -0.03242259f, -0.00270101f, 
    0.01458583f, -0.02071219f, -0.02999921f, -0.03170376f, -0.03395875f, 0.02079978f, -0.01078241f, -0.04163794f, 
    0.01531259f, -0.03813430f, -0.01051675f, -0.03878734f, -0.01897935f, -0.02334013f, -0.01563886f, -0.01858500f, 
    -0.03162834f, 0.00790950f, 0.00432430f, -0.04002881f, -0.01939286f, 0.02664501f, -0.03434228f, -0.02462138f, 
    0.02071953f, 0.01371929f, -0.02516926f, -0.02377726f, -0.01432029f, 0.01447787f, 0.02178486f, 0.02395504f, 
    -0.03359422f, -0.00790488f, 0.01755621f, 0.02753830f, -0.03940530f, 0.00309469f, 0.00081908f, -0.00602729f, 
    0.04044183f, 0.01058915f, 0.00615673f, -0.00091089f, 0.01518162f, 0.01905542f, -0.03561102f, 0.00040290f, 
    -0.03993301f, -0.03673384f, 0.00595811f, 0.00094961f, 0.01372715f, -0.01994813f, -0.03562151f, -0.03437455f, 
    -0.01493553f, 0.02752675f, -0.04227749f, 0.01269980f, -0.00411900f, -0.03547313f, -0.00403133f, 0.00623939f, 
    -0.00706327f, -0.02224339f, 0.02598936f, 0.01661740f, -0.04204849f, -0.00193312f, 0.00226235f, -0.04239724f, 
    0.02699532f, 0.01492339f, 0.00474633f, -0.02357606f, -0.03668464f, -0.01955126f, 0.01620146f, 0.00204014f, 
    -0.26321119f, 0.05042194f, -0.18926364f, 0.09787297f, 0.02892160f, -0.00565670f, -0.17880401f, 0.09972481f, 
    0.05116846f, -0.04106533f, 0.11563541f, 0.01614346f, 0.10292311f, -0.07472353f, -0.05812231f, -0.12664293f, 
    -0.03933310f, 0.04925919f, -0.00343255f, 0.00993446f, 0.06725206f, -0.01888115f, 0.04264577f, 0.01657465f, 
    -0.06048416f, -0.07928658f, 0.03795905f, 0.07038149f, 0.10230331f, 0.03471201f, 0.09817302f, 0.04123252f, 
    0.07174172f, 0.05249461f, 0.01780151f, 0.02420491f, 0.14383334f, -0.12964875f, -0.05654354f, 0.02232840f, 
    -0.00096325f, -0.02893863f, 0.05493936f, 0.10766203f, -0.00717057f, 0.08310745f, -0.00858119f, -0.06580690f, 
    0.12222686f, -0.22055689f, -0.04909199f, 0.02692827f, 0.07785930f, 0.07886913f, -0.00049907f, 0.09357769f, 
    0.01048061f, 0.08689672f, 0.03056070f, 0.02498895f, -0.11576241f, -0.14045982f, -0.15343882f, -0.01159965f, 
    -0.00922550f, 0.01252331f, 0.05806578f, 0.06350994f, 0.01410964f, 0.09280147f, -0.01208406f, 0.12378950f, 
    -0.20370400f, 0.16443388f, 0.14432611f, -0.10356539f, 0.02503966f, -0.07364920f, 0.00032721f, 0.03127477f, 
    0.15161978f, 0.01435934f, -0.05403797f, -0.01953312f, 0.02306363f, 0.04944738f, -0.03118340f, 0.10709858f, 
    -0.00769127f, 0.04812089f, -0.00343922f, 0.05602396f, -0.00257014f, 0.04233553f, -0.03062759f, 0.04992764f, 
    0.04975747f, -0.09367614f, 0.02645314f, -0.01174302f, 0.11553375f, 0.00225389f, -0.00397810f, 0.06137225f, 
    0.06556971f, 0.06834336f, -0.01747786f, 0.01719204f, -0.11978453f, -0.14732848f, 0.12291565f, -0.03880905f, 
    -0.03676439f, -0.06842764f, 0.10424566f, 0.00916487f, 0.02231924f, -0.02651325f, 0.00531256f, -0.00335602f, 
    0.18600987f, 0.15211423f, 0.10178464f, 0.10029009f, 0.09413477f, 0.09724800f, -0.06850864f, -0.04957516f, 
    -0.10153589f, -0.11318026f, 0.08550189f, 0.10212178f, 0.02227096f, 0.06788130f, 0.05381428f, -0.05930321f, 
    0.01184328f, 0.07000440f, 0.04298696f, -0.01615664f, 0.10400598f, 0.05200934f, 0.00336021f, 0.00475161f, 
    -0.24077423f, -0.05084603f, -0.02733709f, -0.09412225f, 0.07225163f, 0.02232614f, 0.11721681f, -0.01960709f, 
    0.14256515f, -0.00933162f, -0.05389314f, -0.11231658f, -0.20900254f, -0.18601872f, 0.00449126f, 0.11573919f, 
    0.05063277f, 0.05075692f, 0.11663279f, 0.06339868f, 0.01523040f, 0.08174656f, 0.01906015f, -0.02205306f, 
    0.26202446f, 0.12771325f, 0.05498868f, 0.03576700f, 0.00582368f, 0.18884754f, -0.04826821f, -0.00512129f, 
    -0.00198730f, -0.00682120f, 0.04064744f, -0.03659403f, -0.02820300f, 0.01703778f, 0.10183163f, -0.04250967f, 
    0.19538829f, 0.07538627f, -0.13557172f, 0.01513074f, 0.00245772f, 0.00214852f, 0.07261130f, 0.03163388f, 
    -0.30944034f, -0.14252773f, 0.02868891f, 0.09789864f, 0.01193190f, -0.06328440f, -0.06639203f, 0.09309535f, 
    0.05587028f, -0.00188561f, 0.04970127f, 0.04364368f, -0.29074252f, -0.01786610f, -0.06923342f, -0.01233242f, 
    -0.00451303f, -0.10937686f, 0.06811114f, -0.05192731f, 0.11763006f, 0.08901999f, 0.04483772f, -0.00793589f, 
    -0.09697812f, 0.04912155f, 0.17212497f, -0.06113104f, 0.14378390f, 0.12471974f, 0.02899154f, -0.08389138f, 
    0.03829595f, 0.09765979f, 0.11704869f, 0.08339623f, 0.19615348f, -0.11373194f, -0.00523805f, 0.14605419f, 
    -0.00672887f, 0.10506454f, -0.05262469f, 0.03289994f, -0.01400712f, -0.01335324f, -0.11894347f, 0.15393086f, 
    0.11652970f, 0.04956713f, 0.02696645f, -0.01647055f, 0.01734641f, 0.03672514f, 0.01815876f, -0.04706230f, 
    0.03527079f, 0.02023428f, 0.03867531f, 0.18593080f, 0.36114734f, -0.12856667f, 0.01315549f, 0.07958920f, 
    -0.05816711f, 0.07848550f, 0.03107351f, -0.07023297f, 0.04249767f, 0.05636645f, 0.12010310f, 0.00156300f, 
    0.08569838f, 0.25805926f, -0.04375250f, 0.01561413f, -0.04494877f, -0.07973314f, 0.10194321f, -0.09155502f, 
    -0.06557433f, 0.04548314f, -0.00241753f, 0.12701319f, 0.20460275f, 0.09142655f, 0.11241844f, -0.02666519f, 
    0.02430108f, 0.03561448f, 0.05172971f, -0.06619711f, 0.01570220f, -0.00946589f, 0.08169650f, 0.03457242f, 
    -0.08671665f, 0.08242621f, -0.22451867f, 0.04156781f, 0.06970439f, 0.06233681f, -0.06193177f, 0.17794444f, 
    0.04613362f, -0.06343184f, -0.14935762f, 0.02156745f, 0.23829471f, 0.12661101f, 0.21293175f, 0.02278985f, 
    0.02939245f, -0.07804261f, 0.01197830f, 0.02135769f, -0.04856740f, 0.00039552f, 0.08124276f, -0.01663069f, 
    0.03406899f, 0.13249657f, 0.03493961f, 0.05818741f, 0.01502136f, -0.04760158f, 0.03093784f, 0.17082132f, 
    0.02495070f, -0.00503743f, 0.01919657f, -0.02478560f, 0.04314568f, 0.31664562f, 0.21787524f, -0.13597228f, 
    0.15263091f, 0.02587401f, 0.07254428f, -0.09005477f, 0.06583049f, -0.02563723f, 0.03305773f, 0.03190826f, 
    0.16547590f, 0.09112439f, -0.01238270f, 0.06355869f, 0.03360329f, 0.08400071f, 0.09744829f, -0.01746663f, 
    -0.01910373f, 0.08849870f, -0.06229929f, 0.09408202f, 0.01095212f, 0.10856382f, -0.18944657f, -0.02316649f, 
    -0.01622063f, -0.03024975f, -0.04502042f, 0.09321211f, -0.01471126f, 0.04935852f, 0.05759919f, -0.08218864f, 
    0.17197804f, 0.17500715f, 0.12006341f, -0.06331024f, -0.00810039f, 0.06103078f, 0.14411366f, -0.00023678f, 
    0.00857501f, 0.00839736f, 0.02011247f, 0.00588096f, 0.10016172f, 0.18451221f, 0.09821742f, -0.01965857f, 
    0.22928844f, 0.07735248f, -0.01390816f, -0.08556910f, 0.00225880f, 0.04815298f, 0.04485264f, 0.05647651f, 
    0.06023824f, 0.24502836f, 0.25163010f, -0.06736821f, 0.07419026f, 0.07774027f, 0.02280096f, -0.04118445f, 
    0.07554308f, -0.00647303f, 0.03749382f, 0.01113306f, 0.00925306f, -0.06434552f, -0.06691566f, 0.06775466f, 
    -0.02059608f, 0.03282139f, -0.04194408f, 0.05129566f, 0.05967347f, 0.02472510f, 0.00037197f, 0.07174939f, 
    -0.18672594f, 0.00106321f, -0.13928801f, -0.14332914f, 0.00329897f, 0.04602554f, 0.03506527f, 0.08778840f, 
    -0.00793453f, 0.03678566f, 0.02467932f, -0.12868540f, 0.05247378f, 0.17872985f, 0.08781527f, 0.03693314f, 
    0.11047039f, 0.09593008f, -0.06306996f, -0.04667877f, -0.07168609f, 0.06868563f, 0.00302217f, 0.04082836f, 
    -0.02419851f, -0.30694386f, -0.04586192f, 0.11421882f, 0.10713217f, 0.09987775f, -0.05100939f, 0.02868685f, 
    -0.01688103f, 0.00272689f, -0.07976595f, 0.05352773f, -0.31240180f, -0.09008396f, 0.03078821f, -0.12524778f, 
    -0.05197801f, 0.02216239f, 0.00886733f, -0.04060673f, 0.00418908f, 0.16183923f, 0.04246079f, 0.03573430f, 
    0.33652335f, 0.23640598f, 0.10874447f, -0.02824746f, 0.05398203f, 0.04299542f, 0.02407440f, -0.04294111f, 
    0.04912650f, 0.00405442f, 0.07281072f, 0.07499299f, 0.07447033f, -0.04497126f, 0.00095174f, 0.14983110f, 
    -0.02210641f, 0.07672780f, -0.07689241f, -0.05522146f, 0.01270321f, 0.03132902f, 0.04732524f, 0.03083170f, 
    0.20278201f, -0.11200108f, -0.26397485f, 0.03907029f, 0.07597458f, 0.02998812f, -0.00260603f, -0.05381674f, 
    -0.02321670f, -0.07676960f, 0.14886776f, -0.02281355f, 0.07054804f, -0.03768400f, 0.03713901f, -0.15663238f, 
    -0.00727562f, -0.08031549f, 0.07621859f, 0.09468906f, 0.01248405f, 0.03303298f, 0.18012787f, 0.09497373f, 
    0.13685456f, 0.01565345f, 0.08808780f, 0.01204633f, 0.03226490f, -0.02776141f, 0.08410169f, 0.10145913f, 
    0.05628410f, -0.02289468f, -0.02608460f, 0.03854133f, 0.06374658f, 0.35552838f, 0.22570889f, -0.15092011f, 
    0.05361588f, 0.01485487f, 0.03926082f, -0.11273678f, 0.03736563f, -0.04587713f, 0.04426432f, 0.11388763f, 
    -0.01639053f, 0.08607326f, -0.05057884f, -0.04986042f, -0.01093546f, -0.03102522f, -0.11424850f, 0.11167821f, 
    -0.00968402f, 0.06686093f, 0.10257051f, 0.05174739f, 0.13990344f, 0.03606702f, -0.18945636f, 0.05744959f, 
    0.06746027f, -0.00007680f, -0.04839781f, 0.08298369f, 0.03384112f, 0.00383023f, 0.14689369f, -0.07448158f, 
    -0.11435042f, 0.13048290f, -0.09898739f, -0.12514248f, -0.00892695f, 0.00512816f, 0.00458269f, 0.05919567f, 
    0.00127434f, 0.00312086f, -0.01356962f, 0.06097918f, 0.13278814f, 0.13848667f, 0.05759223f, -0.00641583f, 
    0.08361846f, -0.11069288f, 0.02324925f, 0.08290152f, 0.16449013f, 0.01953330f, -0.00005202f, 0.03616010f, 
    0.04149362f, -0.09021374f, 0.18669572f, -0.00457278f, 0.07740507f, -0.01874784f, 0.14999904f, -0.04834087f, 
    0.03586316f, 0.02064416f, 0.01011236f, 0.02177469f, -0.08665870f, 0.20511024f, -0.00901887f, 0.22958849f, 
    0.05946547f, -0.06904788f, -0.07469793f, -0.00103513f, 0.01576270f, 0.00494552f, -0.05141460f, 0.01811068f, 
    -0.18765652f, -0.06449088f, 0.02762202f, -0.09562565f, 0.06315318f, 0.01869345f, -0.11908212f, 0.03075533f, 
    0.07008639f, 0.08926035f, 0.08330058f, 0.10367730f, -0.03839359f, 0.04324473f, -0.22530466f, -0.03093815f, 
    0.10083883f, 0.09166316f, -0.06527346f, 0.11590417f, 0.07832173f, -0.07479584f, -0.02122777f, -0.06154715f, 
    -0.13431190f, -0.03542516f, 0.13485137f, 0.12899496f, 0.09262226f, -0.04181417f, 0.02626504f, 0.02172751f, 
    -0.02853743f, -0.09621434f, 0.09781418f, 0.01051974f, 0.06813473f, -0.20041931f, -0.00969427f, -0.06399666f, 
    0.03531782f, -0.04450547f, -0.00993168f, -0.04178796f, 0.01376536f, -0.09888769f, 0.00399942f, 0.02646889f, 
    -0.08639418f, 0.26597020f, -0.05702488f, 0.06598813f, 0.09756496f, 0.04056381f, 0.01276008f, 0.05836233f, 
    0.13161238f, 0.04736785f, 0.03419031f, 0.13458224f, -0.18866318f, -0.08790435f, -0.11849781f, 0.09313350f, 
    0.07568943f, 0.03236337f, -0.07942897f, -0.06629221f, 0.08018964f, -0.11501927f, 0.04144618f, 0.01566747f, 
    -0.20796444f, 0.05623644f, -0.01658251f, -0.03277434f, 0.08655503f, 0.10126541f, 0.04532291f, 0.11113813f, 
    0.12863795f, -0.00545748f, -0.06672348f, 0.06545582f, 0.18595101f, -0.01624860f, 0.07903072f, 0.01882181f, 
    0.06649453f, 0.08294335f, 0.05600669f, 0.07130873f, -0.02295909f, 0.00960957f, 0.04285919f, -0.09590264f, 
    -0.36433157f, -0.12445413f, 0.07510830f, -0.14028229f, 0.07452965f, 0.02772299f, 0.06867498f, -0.04952344f, 
    -0.02151262f, -0.02464591f, 0.02343862f, -0.04713996f, -0.24228567f, -0.21911329f, 0.03315207f, 0.05136477f, 
    0.11343526f, -0.02884417f, 0.02397343f, 0.08879052f, 0.04179246f, 0.02666743f, -0.01128017f, 0.09288777f, 
    0.08979448f, 0.12992966f, 0.16872606f, -0.09368502f, -0.05729762f, 0.05037740f, 0.02162488f, -0.00370287f, 
    0.04739230f, 0.03357990f, 0.08761830f, -0.00799080f, 0.17304166f, 0.12684667f, 0.00774587f, 0.05690480f, 
    0.06677370f, 0.01864132f, 0.02737537f, 0.11489548f, 0.14510407f, -0.12286044f, 0.05441564f, 0.07499590f, 
    -0.18120456f, -0.30520007f, -0.00908297f, 0.01755382f, 0.03361302f, 0.07638658f, -0.08200218f, 0.17955047f, 
    0.00355838f, 0.09378549f, -0.06690309f, -0.03721550f, -0.05400722f, -0.09418739f, 0.05555790f, 0.04873769f, 
    0.00405006f, -0.04941777f, 0.09106023f, 0.11085493f, 0.11844075f, -0.02839475f, -0.06120440f, -0.00729127f, 
    0.02604708f, -0.01095018f, -0.03302995f, -0.02217216f, -0.01315130f, -0.00377096f, 0.01632571f, -0.00580172f, 
    -0.01652185f, -0.01350594f, 0.00142961f, -0.03004283f, -0.02990796f, 0.01214081f, 0.02781433f, 0.01084930f, 
    -0.00833458f, 0.03133156f, -0.02520461f, 0.01144170f, 0.00121321f, 0.02659169f, -0.00387484f, -0.01169785f, 
    -0.01513922f, 0.01163219f, 0.00596553f, -0.00409713f, 0.01000777f, 0.02900882f, -0.02724966f, -0.03796822f, 
    0.02226961f, -0.02122404f, 0.03174859f, -0.04394911f, -0.01340007f, -0.01370161f, 0.01741832f, -0.01594653f, 
    0.01325569f, -0.03473446f, 0.03566768f, 0.03022649f, 0.02211005f, -0.01519602f, -0.02592664f, -0.00454574f, 
    0.01716110f, 0.01463107f, 0.01973057f, 0.02735988f, 0.01605521f, 0.03129496f, 0.02929201f, -0.03039330f, 
    -0.00225368f, -0.01570581f, 0.02991875f, -0.03949304f, -0.00664592f, -0.00322612f, 0.00924897f, 0.00267049f, 
    -0.00116194f, 0.01379451f, 0.01601977f, 0.02503516f, 0.01492951f, -0.01834408f, -0.03957552f, -0.02289431f, 
    0.00203684f, -0.02168613f, 0.02602011f, 0.01375445f, 0.01069447f, -0.00097838f, 0.00464991f, -0.03396070f, 
    -0.01143580f, -0.02299413f, -0.02762884f, -0.01132490f, 0.03237628f, -0.02026409f, 0.01073362f, 0.00355150f, 
    -0.01544380f, -0.02896761f, 0.00849575f, 0.01099683f, 0.03602069f, 0.00148537f, -0.03640944f, -0.02862722f, 
    -0.01576358f, 0.00377037f, 0.02031040f, -0.03475318f, -0.03560920f, 0.00366690f, -0.03188381f, -0.01547582f, 
    -0.00578631f, 0.00705270f, 0.01613706f, 0.00762268f, -0.00287514f, 0.01275784f, 0.00853405f, -0.00694682f, 
    0.03558621f, -0.03069673f, 0.00240441f, 0.02640681f, 0.00441908f, 0.00116758f, -0.00376755f, 0.01774587f, 
    -0.01378876f, -0.03528255f, 0.01259661f, 0.02845045f, 0.02415947f, 0.02734305f, -0.03967499f, -0.03451581f, 
    0.00388892f, -0.02993454f, 0.03129963f, 0.03253193f, 0.01987316f, 0.00211281f, -0.02238439f, -0.01121325f, 
    0.01576191f, 0.00981708f, -0.03679428f, 0.01277742f, 0.00519306f, 0.01338363f, 0.00073806f, -0.01729560f, 
    -0.00342293f, 0.02674265f, -0.03681459f, 0.02217310f, -0.02190650f, -0.02040564f, 0.00493049f, -0.00443097f, 
    -0.01516857f, 0.02807525f, -0.03063289f, 0.02254765f, -0.02339199f, 0.01829654f, -0.02217507f, -0.02289993f, 
    0.00415139f, -0.01922589f, 0.02804860f, 0.02793501f, -0.01925408f, -0.03402311f, -0.02156475f, -0.03957936f, 
    -0.03476426f, -0.03564100f, -0.03036186f, -0.03335061f, 0.03253056f, -0.02424234f, 0.00083392f, -0.02999697f, 
    -0.00284533f, -0.02225088f, 0.00039905f, -0.01980841f, 0.01189045f, 0.00872716f, -0.02805776f, -0.01439506f, 
    -0.04054591f, -0.03069990f, -0.01744405f, -0.03279659f, 0.00622307f, 0.01849802f, -0.02714907f, 0.00418029f, 
    -0.02641355f, -0.02608656f, -0.01602280f, -0.03226147f, 0.00659857f, -0.03713468f, -0.02404721f, 0.01186301f, 
    0.02537422f, -0.01726813f, -0.03897742f, 0.02323849f, -0.03302084f, -0.01255593f, -0.02669285f, 0.02270870f, 
    -0.00773564f, -0.02408208f, -0.00640474f, 0.02408749f, 0.01825354f, 0.02150251f, -0.00376995f, -0.03365548f, 
    -0.01273211f, -0.02172213f, 0.01366276f, 0.02773234f, -0.00262744f, -0.02187202f, -0.03777927f, -0.00771222f, 
    0.00355130f, 0.01377818f, 0.03055138f, -0.03574153f, -0.02470481f, -0.00017953f, -0.01704117f, 0.02316901f, 
    0.01322243f, 0.02233566f, -0.01590812f, -0.00909488f, 0.03760995f, -0.00082209f, -0.01057016f, 0.02285000f, 
    0.00747584f, -0.02957782f, -0.02134760f, -0.01327871f, -0.00938029f, 0.02802748f, 0.01504313f, -0.01524711f, 
    0.00742790f, 0.02948387f, -0.03579499f, -0.02783538f, -0.02771943f, 0.00081958f, -0.03496913f, -0.00084554f, 
    0.02802373f, 0.00723326f, 0.01147994f, 0.02649288f, -0.01403448f, -0.00697433f, -0.00351963f, -0.01217766f, 
    -0.02233595f, 0.03505799f, -0.02695550f, -0.00729531f, 0.00702674f, -0.00033513f, 0.02614615f, -0.00558232f, 
    -0.01150509f, -0.01864197f, 0.00761507f, 0.02995592f, -0.02475568f, -0.03491199f, 0.02148967f, -0.00358882f, 
    -0.03349489f, -0.03106541f, 0.03336444f, 0.00464384f, 0.01523126f, 0.03123761f, -0.01672753f, -0.03440639f, 
    -0.01963930f, -0.01848094f, -0.01827672f, -0.03911171f, 0.01949501f, 0.00452704f, 0.02721669f, 0.00222249f, 
    0.03328327f, 0.00684311f, -0.03024473f, 0.01560536f, 0.00720276f, 0.02193893f, 0.00232250f, -0.00535040f, 
    -0.02345729f, 0.02560426f, 0.04159078f, -0.01503233f, -0.03985379f, -0.00137092f, -0.02173429f, -0.01276980f, 
    -0.03018158f, -0.01249887f, -0.01698015f, -0.02994369f, 0.02186314f, 0.03422035f, 0.02437068f, 0.01737020f, 
    0.01302390f, 0.00521385f, -0.03656274f, 0.02949200f, -0.00612414f, -0.04081397f, -0.00853190f, -0.00347362f, 
    -0.02154787f, 0.01519385f, 0.02366478f, 0.00544010f, 0.00493719f, -0.02181629f, 0.00648022f, -0.00466984f, 
    -0.01395256f, 0.01714038f, -0.02788970f, 0.02545881f, 0.00324006f, 0.00878079f, -0.00474294f, -0.03093834f, 
    -0.00294749f, -0.01995377f, -0.00061401f, -0.04095372f, 0.00509094f, -0.01637782f, -0.04683263f, -0.00138156f, 
    -0.02593509f, -0.02873550f, -0.02274659f, -0.00917237f, -0.00897451f, 0.02577099f, -0.00801169f, -0.03086100f, 
    -0.01119218f, 0.00428060f, 0.02187085f, -0.02864791f, -0.01165659f, 0.02003125f, 0.01993959f, -0.02739097f, 
    0.02195380f, -0.01650542f, -0.00451961f, -0.00815063f, 0.01849819f, 0.00008706f, 0.02105742f, 0.00868655f, 
    -0.03185291f, 0.00002171f, -0.01962614f, 0.02492032f, 0.01049894f, -0.00278545f, -0.00799903f, 0.03127586f, 
    -0.03548773f, -0.03020061f, 0.02128662f, -0.02571573f, -0.01938522f, -0.01872731f, -0.02430410f, -0.00027052f, 
    -0.03266257f, -0.03352366f, 0.00103673f, -0.02914518f, -0.00426298f, 0.02893768f, -0.03918819f, -0.00996673f, 
    0.02623376f, -0.00550630f, -0.03147618f, 0.02322785f, 0.00138646f, 0.00224725f, -0.03076442f, -0.02178054f, 
    -0.02290011f, -0.00769663f, -0.00299907f, -0.01118964f, -0.03163741f, -0.03159663f, 0.02130505f, -0.01414317f, 
    -0.02212953f, 0.01852429f, -0.02425007f, -0.01666391f, 0.00927298f, 0.00104529f, 0.00958452f, -0.00169976f, 
    0.00521333f, -0.00172919f, 0.02420600f, -0.01181483f, 0.00529619f, -0.01473043f, -0.00255272f, 0.01121543f, 
    -0.00029136f, -0.02682014f, 0.03025305f, 0.01243322f, 0.03418036f, -0.02249370f, 0.02410695f, -0.03432919f, 
    -0.01903123f, -0.02469487f, 0.02088142f, 0.02242180f, 0.00612772f, 0.03235800f, -0.03935013f, 0.02693819f, 
    -0.01169850f, -0.02353995f, -0.00825985f, 0.01149368f, -0.01965345f, -0.04477446f, -0.00237797f, 0.02846274f, 
    0.00116564f, 0.03291699f, -0.02938500f, 0.01962666f, 0.02327022f, 0.02147535f, -0.00488071f, 0.00656115f, 
    -0.00693528f, -0.00712742f, 0.00881296f, 0.01347467f, -0.02839876f, -0.00168014f, 0.00895922f, 0.01761166f, 
    -0.00881913f, 0.02475334f, -0.02282894f, -0.00611777f, -0.01176943f, 0.00186622f, -0.00029223f, 0.01760234f, 
    0.00187270f, -0.03249374f, -0.00919695f, 0.01448416f, 0.02348831f, -0.02008790f, -0.02922758f, 0.03533594f, 
    0.01851043f, 0.01622496f, 0.00266093f, 0.01182713f, 0.01298195f, 0.00965106f, -0.02980998f, 0.01912600f, 
    -0.03515967f, 0.02483910f, 0.02257420f, -0.03566267f, -0.03757173f, 0.02768487f, 0.01866294f, 0.02985487f, 
    0.00272744f, -0.01834233f, -0.00339667f, 0.00426758f, -0.02094359f, -0.01544033f, -0.03468363f, 0.02175671f, 
    0.01860253f, 0.02618794f, -0.01829246f, 0.01616415f, -0.03095055f, 0.02277694f, 0.03872982f, 0.02156841f, 
    -0.03056891f, 0.00629962f, 0.03300314f, 0.01683237f, -0.01266291f, 0.02400585f, -0.00155286f, 0.00016850f, 
    -0.01161914f, -0.02579112f, -0.00922002f, -0.00334335f, 0.00012095f, 0.03181189f, 0.02179785f, 0.03008050f, 
    -0.03312528f, -0.00883810f, -0.01169605f, -0.01720738f, -0.03305787f, 0.02756774f, 0.00472450f, -0.02669766f, 
    0.00041629f, 0.03866295f, 0.01029868f, 0.00046148f, 0.00699570f, -0.00735551f, -0.03864535f, 0.01725492f, 
    -0.03688158f, -0.00546473f, -0.03428201f, 0.01005626f, -0.03687182f, 0.00866066f, 0.01557814f, 0.01208249f, 
    0.02027319f, -0.03974509f, -0.00242089f, 0.00190068f, 0.01607237f, -0.03243151f, -0.03464993f, 0.02629070f, 
    -0.02620002f, -0.04257722f, -0.00088504f, -0.00970171f, 0.02220874f, 0.03199144f, -0.03261339f, -0.01545255f, 
    0.01926951f, -0.01785305f, 0.01887607f, 0.01591894f, 0.01744058f, -0.01647444f, -0.03086660f, 0.00613595f, 
    -0.02128900f, -0.02373471f, 0.00923581f, -0.03026505f, -0.01552799f, 0.02289635f, -0.03652439f, -0.01211466f, 
    0.02397653f, 0.02988856f, -0.02203681f, -0.02132070f, -0.02018448f, -0.02372604f, 0.02326735f, -0.01246193f, 
    0.00860247f, 0.00166464f, -0.03476457f, -0.03385046f, -0.04453987f, -0.03875900f, -0.03198310f, -0.02091095f, 
    0.01270416f, 0.01315798f, -0.00690298f, 0.01794144f, -0.02270819f, -0.01930136f, -0.01215883f, -0.00044453f, 
    -0.00571974f, 0.02386340f, 0.01982920f, -0.01910399f, -0.01315570f, -0.03338634f, 0.02147445f, -0.00541213f, 
    0.02085254f, -0.01765651f, 0.01049739f, -0.02329198f, 0.02899706f, -0.02208486f, 0.02603695f, -0.02746947f, 
    -0.02989947f, -0.00250999f, 0.01072213f, 0.03066795f, 0.03037089f, -0.03448071f, 0.00045506f, 0.00759136f, 
    -0.01755414f, -0.02334550f, 0.00621685f, 0.01240717f, 0.00707725f, -0.02061632f, 0.00102370f, 0.01633812f, 
    -0.00042187f, 0.02499692f, 0.00849638f, -0.00810023f, 0.03447426f, -0.02303938f, -0.00250767f, 0.02436810f, 
    0.00926078f, 0.03216077f, -0.03236680f, -0.00948530f, 0.03239447f, 0.00900080f, 0.00483661f, 0.00953326f, 
    -0.02859521f, -0.02195964f, -0.03800858f, 0.01252311f, 0.01748880f, -0.02331542f, 0.01803992f, -0.01307794f, 
    0.00214018f, -0.01100335f, 0.01928453f, -0.00066601f, -0.03389323f, 0.02707859f, -0.00394555f, 0.01593679f, 
    -0.00237815f, 0.01714037f, -0.03952091f, 0.01673770f, 0.02237369f, -0.04108503f, 0.02938533f, -0.00391472f, 
    -0.03550021f, 0.02272988f, 0.03173384f, -0.01874543f, 0.02077515f, 0.01539741f, 0.03137419f, -0.02937098f, 
    0.01355315f, -0.03694034f, 0.03011063f, 0.02658197f, -0.03531360f, 0.03228893f, 0.00607135f, 0.00090019f, 
    0.01198506f, -0.01656290f, 0.01788157f, 0.00472667f, 0.00870401f, -0.03143233f, -0.00577204f, -0.00920381f, 
    0.00686948f, -0.01478595f, 0.02407498f, -0.03418956f, -0.01780682f, 0.03322523f, 0.00939584f, -0.03698807f, 
    0.01056307f, 0.02803757f, -0.00708772f, 0.02294991f, 0.02312487f, 0.00982577f, -0.03540938f, 0.02204520f, 
    0.00889140f, 0.03959832f, -0.02119604f, 0.02236579f, 0.01033764f, -0.03113991f, -0.02315828f, -0.02832714f, 
    0.00962566f, 0.00214015f, 0.03324395f, 0.02895708f, -0.03369381f, 0.00263095f, 0.01186655f, 0.03009143f, 
    0.01676655f, 0.02321181f, -0.00586025f, 0.01253877f, -0.01449535f, -0.03226529f, 0.00584457f, -0.01597882f, 
    -0.01009047f, 0.00716651f, 0.00694420f, 0.00641805f, 0.02026779f, 0.02481142f, -0.01949419f, -0.00954239f, 
    -0.00659266f, -0.02189438f, -0.01539722f, -0.02889302f, 0.02264377f, 0.00342789f, 0.00377851f, -0.00673233f, 
    0.22510798f, -0.10302831f, 0.06056537f, -0.15231900f, -0.09983207f, 0.04875982f, -0.07090330f, -0.03474329f, 
    0.11648760f, -0.07549777f, -0.02295328f, 0.03686529f, -0.23104386f, 0.30170745f, -0.05900463f, 0.00355622f, 
    0.10043167f, -0.07022676f, -0.03016513f, 0.11878943f, 0.04628945f, 0.11676560f, -0.04134820f, 0.03046772f, 
    -0.00070466f, -0.09442875f, -0.08071827f, -0.13741317f, -0.02008442f, 0.06827136f, 0.09544516f, -0.06280250f, 
    0.10487772f, 0.06650074f, 0.16091992f, -0.04899186f, -0.14291291f, 0.10893153f, -0.05437919f, -0.02417783f, 
    0.02056078f, -0.05505500f, 0.03233523f, -0.03304722f, -0.07591105f, 0.07535084f, 0.02396282f, -0.01975208f, 
    0.13718852f, 0.06460074f, -0.18003640f, 0.09369881f, -0.01742741f, 0.08881716f, -0.01639482f, -0.03252587f, 
    0.05640171f, -0.11545547f, 0.02290558f, -0.15252890f, -0.02443621f, 0.04926792f, 0.08998716f, -0.03300660f, 
    0.02377161f, 0.00775057f, 0.07581021f, 0.09205125f, 0.00429094f, 0.09894764f, 0.05266711f, 0.03574935f, 
    0.18711643f, -0.16965498f, -0.11773569f, -0.13581949f, -0.15445298f, 0.05359840f, 0.05776788f, 0.05773390f, 
    0.17055652f, -0.03250688f, -0.08388928f, -0.19228925f, -0.24162149f, -0.00468012f, 0.15022916f, -0.04347632f, 
    -0.03751704f, 0.08312997f, 0.10232572f, 0.02987495f, -0.00748563f, 0.09133441f, 0.00133541f, 0.12145124f, 
    0.11373924f, -0.03641983f, 0.05666302f, -0.22989205f, 0.12037714f, 0.00755416f, 0.05288855f, 0.04556314f, 
    -0.01125053f, 0.05324663f, -0.04453306f, 0.09886552f, 0.11523625f, -0.09694945f, -0.21676929f, -0.13020028f, 
    0.00396884f, -0.01248438f, -0.07408361f, 0.03041981f, -0.00094391f, 0.13151577f, 0.09502979f, 0.05885527f, 
    -0.03940124f, -0.02811836f, -0.01012884f, 0.20193544f, 0.06507906f, 0.06816873f, 0.14599119f, 0.04298772f, 
    0.12429110f, -0.07443687f, -0.00581192f, 0.19314995f, 0.00857682f, -0.11359344f, 0.11626337f, 0.30164400f, 
    -0.04526469f, 0.10242173f, -0.03461176f, -0.02201057f, 0.06367929f, 0.01884060f, 0.04803684f, 0.14985207f, 
    0.13038634f, 0.07987199f, -0.05198560f, -0.00824990f, 0.02927734f, 0.00624744f, -0.00248546f, -0.01614819f, 
    0.02542566f, -0.00188946f, -0.02870918f, -0.04565781f, 0.12311698f, 0.15884367f, 0.05358373f, 0.05529679f, 
    0.07851435f, -0.08971258f, -0.00755270f, 0.10093734f, 0.03292885f, -0.03383054f, 0.11430009f, 0.07097248f, 
    -0.09519477f, 0.00510203f, 0.02320173f, 0.01200633f, 0.06427655f, 0.09183922f, -0.15410201f, -0.02350312f, 
    0.00687081f, -0.06977995f, 0.08065525f, 0.00289947f, 0.23868816f, 0.01385992f, 0.12210682f, -0.08382490f, 
    -0.08395114f, 0.03544196f, 0.03355647f, 0.09408000f, 0.04373234f, -0.08223853f, -0.13039947f, -0.06741461f, 
    0.07138417f, -0.15665922f, -0.05148076f, -0.07577182f, -0.02771527f, -0.07577939f, 0.07395879f, 0.14349803f, 
    0.06476473f, 0.06318551f, 0.08267727f, -0.01668201f, 0.08912611f, -0.03900269f, 0.15438432f, 0.02314553f, 
    -0.02370795f, -0.13055119f, -0.00734585f, 0.03555667f, 0.10478582f, 0.07869048f, 0.12769540f, -0.03961445f, 
    -0.06579838f, -0.17974979f, 0.10689354f, 0.10545987f, 0.01017128f, 0.09178397f, 0.03480347f, -0.15358889f, 
    -0.02536928f, -0.04628170f, -0.02724851f, 0.01645330f, 0.06929434f, 0.02163737f, -0.15613906f, -0.04160591f, 
    -0.01541019f, -0.08009712f, 0.04449966f, -0.01895417f, 0.01730760f, 0.00146731f, -0.07992341f, -0.00559754f, 
    0.00907332f, 0.16355391f, 0.08735228f, 0.14680319f, 0.03987103f, 0.01643012f, 0.09057051f, 0.04104105f, 
    -0.04680781f, -0.02186775f, 0.01882645f, 0.19347745f, -0.24356382f, 0.13670000f, -0.24353842f, -0.03501923f, 
    -0.04400769f, 0.05498636f, 0.04079837f, 0.03059506f, 0.09362406f, 0.08303872f, -0.15120402f, -0.05972234f, 
    0.02620553f, -0.09684668f, 0.07672741f, 0.02283255f, -0.03326512f, -0.05391688f, 0.21118210f, -0.01354212f, 
    0.10613701f, 0.16009364f, 0.17818740f, 0.31698099f, -0.09462617f, -0.20284466f, 0.19462109f, 0.02683988f, 
    -0.03631938f, -0.10098541f, 0.06941735f, 0.10826179f, 0.14060540f, 0.10119516f, -0.08101475f, 0.08158501f, 
    -0.04385974f, -0.18320146f, -0.03228259f, -0.06899282f, 0.01992179f, 0.20904212f, 0.13247697f, 0.01865746f, 
    0.01109375f, 0.09638453f, -0.12382395f, -0.06436886f, 0.00174782f, 0.11466182f, 0.13062504f, -0.03906592f, 
    0.01619518f, -0.15399043f, 0.04652015f, 0.06625146f, 0.13533060f, 0.15146545f, 0.01548528f, 0.08157866f, 
    0.07335167f, -0.00915583f, -0.07034844f, -0.02632105f, 0.01478874f, 0.03775797f, -0.02765237f, -0.04573640f, 
    0.04121299f, 0.03145142f, 0.03827315f, -0.00451393f, -0.12738264f, -0.21564132f, 0.15663938f, 0.05854089f, 
    0.09883741f, -0.10904489f, -0.05107893f, -0.02139159f, 0.05151314f, -0.01576689f, -0.01340074f, 0.02652994f, 
    0.02422971f, 0.01721259f, 0.04896257f, 0.03487044f, 0.10560942f, 0.02824429f, 0.14522678f, -0.01684470f, 
    0.00251985f, 0.21343067f, 0.04006836f, 0.10698950f, -0.01744074f, -0.05661954f, -0.01123528f, -0.01672945f, 
    0.06909420f, -0.01937845f, -0.13662855f, -0.06164229f, 0.02334078f, 0.11609914f, -0.02139141f, 0.10128429f, 
    0.05274554f, -0.04704916f, -0.06069505f, 0.09863261f, -0.00022087f, -0.05104891f, -0.02860661f, 0.01741881f, 
    0.03896936f, 0.03514996f, 0.11964670f, 0.03520454f, -0.09347113f, -0.08899119f, 0.12466101f, 0.05292314f, 
    -0.05221490f, 0.09293889f, 0.01303150f, 0.06245760f, 0.08992798f, 0.11574819f, 0.06834412f, 0.19659954f, 
    -0.11788610f, -0.07025014f, 0.02279195f, 0.19557035f, 0.18021432f, -0.03397733f, 0.01194833f, -0.02354911f, 
    0.02860940f, -0.04748170f, 0.02221450f, 0.06003734f, 0.06181523f, -0.03409339f, 0.13416719f, -0.11419611f, 
    -0.00976244f, 0.13544562f, 0.03708232f, -0.06353294f, 0.08484945f, 0.05886469f, -0.14863935f, 0.03124351f, 
    0.07769991f, -0.08074949f, -0.12778834f, 0.05720801f, -0.09630534f, -0.02480684f, 0.00446316f, 0.00527548f, 
    -0.09090557f, 0.03504347f, 0.01182258f, -0.13650315f, -0.02043053f, -0.09433358f, 0.13782626f, 0.06215584f, 
    0.04819525f, -0.00432659f, -0.02497059f, -0.00136543f, -0.03551798f, -0.05377601f, 0.04638434f, -0.16978641f, 
    -0.01974542f, 0.18187404f, 0.07484568f, -0.11403576f, 0.08057784f, -0.00440031f, -0.13023415f, -0.07380649f, 
    0.02154331f, 0.09544603f, -0.01930897f, 0.14712249f, 0.19141498f, 0.06713023f, 0.05025255f, 0.00836619f, 
    0.02882440f, -0.06503348f, 0.03306265f, -0.06891020f, 0.00987414f, 0.05698124f, 0.11520100f, 0.02007589f, 
    0.05906226f, -0.00553338f, 0.15752743f, 0.08081375f, -0.06732481f, 0.08503525f, 0.07512833f, -0.00921128f, 
    -0.04039732f, 0.03871473f, 0.16294715f, 0.09081167f, 0.02477028f, 0.00525457f, 0.16113080f, -0.04427222f, 
    0.15038350f, -0.01203215f, -0.05874348f, -0.04906342f, -0.00511228f, 0.05141409f, 0.06264849f, 0.04730157f, 
    -0.23429818f, 0.13121809f, 0.02008272f, 0.08286837f, -0.06632783f, 0.02330150f, -0.04092265f, 0.03566849f, 
    0.09153897f, 0.01152182f, 0.20086800f, -0.08534189f, 0.15924399f, 0.26201445f, 0.08204524f, 0.09433321f, 
    0.00368449f, 0.01505657f, 0.08381805f, 0.05881263f, 0.02876712f, 0.10439020f, 0.09620401f, 0.18555756f, 
    0.23150402f, -0.10325532f, -0.15738632f, -0.16002305f, -0.05408362f, 0.17769441f, 0.03578082f, 0.05716985f, 
    0.01133742f, -0.07444096f, 0.00649071f, -0.13204081f, -0.43341660f, 0.09587421f, 0.09598887f, 0.25861144f, 
    0.06726676f, 0.00572817f, 0.06347267f, -0.06493361f, 0.09518741f, 0.06919695f, 0.00348801f, 0.17120481f, 
    0.19697998f, 0.04524662f, 0.02619595f, 0.01340775f, 0.10804847f, 0.00370992f, 0.02337747f, 0.12782229f, 
    -0.08380064f, 0.01725760f, 0.11020232f, 0.02949226f, 0.16352934f, -0.04917890f, -0.02800069f, 0.08043716f, 
    0.04851682f, 0.01877126f, -0.05342992f, 0.11997421f, 0.20503804f, -0.00498205f, 0.04001163f, -0.10213348f, 
    0.20668665f, -0.01519190f, 0.09331091f, 0.08210554f, 0.05115311f, 0.11398994f, 0.00567104f, 0.07264223f, 
    -0.03242004f, -0.03747222f, -0.03039841f, 0.10650359f, 0.15908110f, -0.26048803f, 0.05706758f, -0.12822276f, 
    -0.03511135f, -0.13705792f, 0.00496753f, 0.00812912f, 0.10879637f, -0.06250142f, -0.04314499f, 0.06315768f, 
    0.04023439f, -0.13079895f, -0.15003163f, -0.04012740f, 0.10635757f, -0.00884300f, 0.03873183f, -0.08010352f, 
    -0.00722374f, 0.05592532f, -0.11943210f, -0.00501753f, 0.06557344f, 0.01379050f, -0.02937326f, -0.08300296f, 
    0.00750932f, -0.07313658f, -0.06344771f, 0.10027973f, -0.03933253f, 0.01564732f, -0.09807650f, -0.01908774f, 
    0.36255741f, -0.02712118f, 0.06375651f, -0.09805050f, 0.02017844f, 0.01103006f, -0.12520140f, 0.04404061f, 
    0.07519548f, 0.00629234f, 0.12092587f, 0.14349131f, -0.00159805f, 0.07646326f, 0.13685599f, -0.04957487f, 
    0.11988322f, 0.07430166f, -0.01311643f, -0.07223786f, 0.08963065f, -0.03614415f, -0.05213145f, 0.06250221f, 
    -0.28238010f, -0.16659929f, 0.06636435f, 0.01875746f, 0.11564830f, 0.00013436f, -0.03359757f, -0.10956569f, 
    0.15905227f, -0.04096798f, 0.03402853f, -0.00829354f, 0.00088822f, 0.00207413f, -0.12963800f, 0.02499297f, 
    -0.04850405f, -0.05469888f, 0.00524886f, -0.09693206f, 0.02165028f, -0.02507881f, 0.05399454f, 0.09705683f, 
    -0.31626529f, -0.13820814f, 0.09511852f, 0.13440885f, 0.07183971f, -0.09274492f, -0.09856103f, -0.04770468f, 
    0.04338060f, 0.16919738f, 0.07581730f, 0.08095952f, -0.02423351f, 0.00830972f, -0.06798310f, -0.19682726f, 
    0.13186496f, 0.09844279f, -0.07197859f, 0.11934787f, 0.05461651f, -0.03888971f, 0.12060858f, -0.11623508f, 
    -0.02259874f, 0.01103484f, 0.19108561f, -0.07215104f, 0.07437294f, -0.01060616f, -0.01627866f, 0.00914290f, 
    0.05696090f, 0.04733080f, 0.01371249f, 0.11178245f, 0.06030949f, 0.19460131f, -0.12385757f, 0.03072343f, 
    -0.01069623f, 0.04994727f, -0.08896893f, -0.03915120f, -0.01071206f, -0.02984686f, 0.05019535f, -0.16305366f, 
    -0.05563571f, 0.06343880f, -0.03726450f, 0.05467707f, 0.06907408f, 0.06716633f, -0.01676009f, -0.05809873f, 
    -0.01412896f, -0.19785146f, 0.02324123f, 0.04318407f, 0.00837030f, 0.04848141f, 0.19090268f, -0.04893987f, 
    0.13345209f, -0.06707750f, 0.09059700f, -0.06602789f, -0.07336220f, 0.02900846f, -0.10508572f, 0.09785686f, 
    -0.35883668f, 0.05610044f, 0.07034671f, 0.07195183f, 0.14756018f, 0.02143426f, 0.00424494f, 0.02845736f, 
    0.01431153f, 0.01940412f, -0.03506958f, -0.09984717f, -0.20624974f, 0.03425075f, 0.02484124f, 0.17213461f, 
    0.08815189f, -0.03201348f, -0.04716748f, 0.09079792f, 0.11743944f, 0.14270788f, -0.10385448f, 0.13008432f, 
    0.09151670f, 0.01761533f, -0.13672836f, -0.16969372f, 0.03788435f, 0.02844349f, -0.00952779f, -0.01196710f, 
    0.03920017f, -0.12580436f, 0.08284004f, 0.04184725f, -0.04609421f, 0.03067827f, -0.04511820f, -0.18188608f, 
    -0.05622332f, -0.02194885f, 0.12128332f, -0.07161459f, -0.00995434f, 0.03041050f, 0.00592442f, 0.10969222f, 
    -0.05995382f, 0.16198254f, 0.05416562f, -0.01364482f, 0.01694385f, -0.09241667f, 0.06668923f, 0.02446469f, 
    -0.05048616f, 0.03085779f, 0.03546426f, 0.03488703f, 0.23618753f, -0.07904366f, 0.01374259f, 0.04547838f, 
    -0.02494533f, 0.05445989f, 0.02790547f, -0.08240682f, -0.02426312f, -0.01463537f, -0.04053795f, -0.01123090f, 
    0.15449996f, 0.09605956f, 0.03750139f, 0.22393283f, 0.06430547f, -0.03629925f, 0.00373584f, 0.08578142f, 
    0.02827294f, -0.04695224f, -0.02443944f, -0.01568226f, 0.16690525f, 0.06654956f, 0.08918892f, 0.05497341f, 
    -0.00650170f, 0.09063277f, 0.00994043f, 0.10811152f, -0.01266457f, 0.00279657f, 0.03124020f, 0.00861411f, 
    -0.01230649f, 0.11209865f, 0.11730246f, 0.11898976f, -0.06143520f, -0.02510295f, 0.08446168f, 0.04002153f, 
    0.03839964f, -0.00245697f, -0.06449738f, 0.06149960f, 0.24076892f, 0.04357039f, 0.04756318f, -0.05190746f, 
    0.04463696f, 0.09697448f, 0.06529151f, -0.07922964f, -0.01275091f, -0.01908369f, 0.00606471f, -0.00098909f, 
    -0.02368231f, 0.03590035f, 0.15792403f, 0.05898607f, -0.00814854f, 0.01590532f, 0.07328673f, 0.02401939f, 
    -0.02874012f, -0.00908934f, 0.06208929f, 0.15832643f, 0.15778783f, -0.04569080f, 0.04966113f, 0.02778895f, 
    -0.01259664f, 0.01808751f, -0.02647500f, 0.09933551f, 0.00083690f, 0.04555935f, -0.00070629f, 0.02950613f, 
    0.11893835f, 0.04707563f, 0.08597235f, 0.03248930f, -0.12301661f, -0.09985173f, 0.01758611f, 0.11235032f, 
    0.04567252f, -0.03650502f, -0.03830839f, 0.04816001f, 0.09348752f, 0.14530019f, -0.17059197f, 0.09257605f, 
    0.07975200f, 0.07945316f, 0.04708723f, -0.04002926f, 0.05449457f, 0.03965689f, 0.02547851f, -0.01238114f, 
    -0.04346003f, -0.06225280f, 0.04711613f, -0.06400423f, -0.04398336f, 0.01224484f, -0.08522914f, -0.03903924f, 
    0.07821445f, 0.11800848f, -0.01303770f, 0.03266913f, -0.18914856f, 0.08941580f, -0.07655903f, 0.00686161f, 
    0.04936342f, -0.09508172f, -0.08454839f, -0.03509238f, 0.11226887f, 0.06655760f, -0.00811457f, -0.07540589f, 
    0.13661526f, 0.15921906f, 0.19283484f, 0.01042243f, 0.06157080f, 0.09945082f, 0.00524487f, 0.02494625f, 
    -0.02188164f, -0.01584877f, 0.10113295f, 0.02752413f, 0.28907657f, 0.11983550f, 0.17917980f, -0.04382903f, 
    -0.00141850f, 0.06425992f, 0.04194701f, 0.05447221f, -0.04168171f, -0.02606149f, -0.05105700f, -0.08376940f, 
    -0.10272044f, -0.19327614f, -0.06584238f, 0.03821071f, 0.03463239f, 0.00324806f, -0.00725077f, -0.12258628f, 
    0.07828694f, 0.08336221f, 0.01098332f, -0.09174831f, -0.02863306f, -0.04556117f, -0.09555475f, -0.01203641f, 
    -0.02956641f, -0.12787566f, 0.04748677f, -0.01378471f, 0.03666319f, -0.03248908f, -0.10064569f, 0.09701541f, 
    0.05311644f, -0.05410088f, -0.02438659f, 0.09643123f, 0.05685154f, -0.03451162f, 0.03474640f, 0.02998553f, 
    0.06803408f, 0.06934422f, 0.03826035f, 0.01042053f, -0.09989247f, 0.09458639f, 0.01116829f, 0.15896678f, 
    0.03310499f, -0.01015650f, 0.08167781f, 0.03286893f, 0.02538900f, 0.06053125f, -0.05502431f, -0.05679461f, 
    0.05345605f, 0.11921362f, 0.06234969f, -0.18125083f, 0.01934935f, -0.11429513f, -0.10443606f, -0.01334847f, 
    0.05466976f, 0.03103233f, 0.08189551f, -0.00288737f, 0.06042254f, -0.01988370f, 0.10309695f, -0.01465513f, 
    -0.03798347f, 0.03683045f, -0.03579283f, 0.13909262f, 0.06995892f, 0.09639584f, -0.00361421f, 0.04248474f, 
    0.01389284f, -0.10180713f, 0.03618717f, 0.00347899f, 0.03682028f, -0.07681391f, -0.05369362f, -0.02765651f, 
    0.06950928f, 0.06814866f, 0.00384661f, -0.06891911f, -0.00797470f, -0.00315987f, -0.06387535f, -0.04467376f, 
    0.10736464f, -0.03936264f, -0.15053062f, -0.00602762f, 0.01216920f, 0.06648193f, -0.06339139f, 0.12419808f, 
    -0.07402707f, -0.03308396f, -0.15756948f, 0.11664805f, 0.07727220f, -0.00642132f, -0.02173053f, 0.01302083f, 
    -0.01179938f, 0.00281814f, 0.04207581f, -0.11836395f, -0.00456051f, -0.02314948f, -0.11030928f, -0.04877668f, 
    0.07154636f, -0.05832011f, -0.02474446f, -0.14070097f, -0.03085723f, 0.03947742f, -0.02789802f, 0.02653305f, 
    0.13973561f, 0.11396486f, 0.15797858f, -0.07094014f, 0.00973472f, 0.00693792f, -0.15604395f, -0.04542299f, 
    0.04789559f, -0.00640914f, 0.03935347f, -0.02499229f, -0.09942497f, -0.19884612f, -0.17483422f, 0.24297850f, 
    0.02607640f, 0.02254499f, -0.00426185f, -0.04061682f, 0.09530322f, 0.04283356f, 0.08692215f, 0.02499607f, 
    0.02789639f, 0.15509506f, 0.05503183f, 0.12938820f, -0.11427396f, 0.07717579f, 0.06872699f, -0.01809530f, 
    0.05828394f, 0.06319379f, 0.03433250f, 0.01677476f, -0.11824533f, -0.03753642f, -0.14680150f, -0.08429558f, 
    0.01276607f, -0.05187701f, -0.05964456f, -0.05788305f, 0.03062045f, 0.06195908f, 0.11671147f, -0.02969596f, 
    0.07765639f, 0.03581340f, -0.02129971f, 0.08608540f, 0.06406055f, -0.02657602f, -0.10459817f, 0.00158878f, 
    0.16990882f, 0.03153971f, 0.02378502f, 0.05529544f, 0.20744969f, -0.03604551f, 0.16448812f, 0.01252351f, 
    0.03329436f, 0.09389351f, 0.04953444f, 0.00735998f, -0.00361904f, 0.04566805f, -0.06236603f, 0.05232272f, 
    -0.05300556f, 0.08958913f, -0.09258471f, -0.00086859f, -0.03283215f, 0.03674751f, -0.02187594f, -0.10184635f, 
    0.00361152f, -0.04366244f, -0.12477130f, -0.01603053f, -0.01048024f, 0.01656722f, -0.03977720f, -0.10444130f, 
    0.01659299f, -0.04494346f, -0.08136333f, -0.06603429f, -0.00045925f, 0.03064942f, -0.00271891f, 0.00903041f, 
    -0.02499909f, -0.06427349f, -0.05322571f, -0.14428627f, 0.02582821f, -0.07611368f, -0.06039148f, -0.07328290f, 
    0.02940523f, 0.04182266f, 0.07552951f, 0.05965843f, 0.07040468f, 0.13461384f, 0.16631112f, 0.19129971f, 
    -0.01514700f, -0.03475645f, 0.06289192f, -0.02314631f, -0.07942037f, 0.01522373f, 0.05886790f, 0.02185019f, 
    0.12489359f, 0.06809189f, 0.12660109f, 0.12534527f, 0.04224743f, -0.01149676f, 0.12629925f, 0.00724566f, 
    0.00279553f, 0.04842571f, 0.00587556f, 0.00977904f, -0.03082316f, -0.09633932f, -0.12689875f, -0.11368191f, 
    -0.00756636f, -0.02494339f, -0.05989626f, -0.05280849f, 0.04143435f, 0.01144617f, -0.01431732f, 0.01395160f, 
    0.06984248f, 0.00921181f, 0.09347777f, 0.05841529f, -0.03792418f, -0.00095080f, 0.09638538f, 0.13379803f, 
    0.02190043f, 0.00787701f, -0.02651847f, 0.12319408f, 0.12646839f, 0.16338794f, -0.08141983f, 0.17032909f, 
    0.11726207f, 0.02464002f, 0.06758228f, 0.10379256f, -0.05989053f, -0.09092326f, -0.06527457f, -0.06626883f, 
    0.06138931f, -0.05697471f, -0.19405697f, -0.00508602f, 0.05626876f, -0.05324206f, -0.03734007f, -0.06311219f, 
    0.04535422f, 0.08268569f, -0.05206010f, 0.03256578f, -0.25605422f, 0.04275984f, -0.07322622f, -0.05665160f, 
    0.00519319f, -0.05892799f, -0.08117765f, 0.10754419f, 0.03565237f, -0.01505413f, -0.04407122f, 0.06322409f, 
    0.03205404f, 0.07024255f, 0.04453017f, -0.11732479f, -0.07083030f, 0.05192237f, 0.07332747f, 0.06579251f, 
    0.01962168f, -0.00980767f, -0.02998951f, -0.02256150f, 0.05681037f, -0.10842632f, -0.12067466f, 0.05624424f, 
    0.04151355f, -0.07524417f, -0.07369816f, 0.08927799f, 0.13446628f, 0.05435816f, -0.07463547f, -0.03656965f, 
    0.01163732f, 0.18780647f, 0.01171507f, 0.07438807f, -0.09177490f, -0.04615143f, 0.13270651f, -0.00970908f, 
    -0.07078755f, -0.00970891f, -0.00156605f, 0.01896112f, 0.08747205f, -0.09889694f, -0.00908516f, -0.14714764f, 
    0.07608631f, -0.06046567f, -0.11686236f, 0.00266631f, 0.01851799f, 0.07921744f, -0.02571751f, 0.05683070f, 
    -0.10471647f, -0.07037065f, 0.01117977f, 0.00771736f, 0.04612076f, -0.03471555f, -0.05418152f, 0.03609895f, 
    0.04652852f, -0.07425739f, -0.03251515f, -0.05401742f, 0.16215038f, 0.01019466f, 0.13912004f, -0.04681177f, 
    -0.00158087f, -0.00566647f, 0.02983186f, -0.01422070f, 0.01881396f, 0.07099167f, -0.04858696f, 0.02458216f, 
    -0.03031707f, 0.01477992f, -0.05292238f, 0.04859193f, 0.06196114f, -0.06962395f, 0.09077091f, 0.00493559f, 
    0.13666436f, 0.03221640f, 0.01933764f, 0.03576141f, -0.22709532f, 0.00959028f, -0.08462015f, 0.08375719f, 
    -0.01604484f, 0.08766791f, 0.14649063f, 0.00898875f, 0.00967684f, 0.02919462f, 0.07310265f, -0.02487758f, 
    -0.08703250f, 0.20117289f, 0.04292368f, 0.02402791f, 0.05086684f, 0.00795533f, 0.09264659f, -0.00841227f, 
    0.09176117f, -0.02819721f, 0.02243674f, -0.02605333f, -0.05487836f, -0.14429237f, -0.10830047f, -0.12977192f, 
    0.06477290f, 0.04870558f, -0.09201577f, -0.09725499f, 0.00580309f, -0.02686545f, 0.02952771f, -0.03467282f, 
    -0.03446855f, -0.04490976f, 0.06104032f, 0.04013811f, -0.01181021f, -0.10404774f, 0.10372238f, 0.01200525f, 
    0.03685070f, -0.04545823f, 0.02460168f, -0.11779664f, 0.05713781f, 0.07207846f, 0.12129582f, 0.05657541f, 
    -0.06001589f, 0.00742578f, 0.02970470f, -0.03507818f, -0.12927805f, -0.07244333f, 0.07345606f, -0.04043803f, 
    -0.00990862f, 0.13237894f, -0.07783632f, 0.02867423f, -0.03480412f, 0.02049651f, -0.05493494f, -0.00742524f, 
    0.04998668f, 0.05404920f, 0.02701512f, 0.07494690f, 0.13468055f, 0.21814813f, 0.07057069f, 0.10847102f, 
    0.00246046f, 0.00659797f, 0.12361544f, 0.08381797f, -0.01237089f, 0.03327668f, -0.01282053f, 0.00303907f, 
    0.01615038f, 0.07326975f, 0.04837107f, -0.05055866f, 0.05530651f, -0.01037995f, 0.03966360f, -0.09610035f, 
    0.06605833f, 0.00898831f, 0.08737794f, -0.05531522f, 0.25146654f, 0.06527868f, 0.16760235f, 0.02921547f, 
    -0.13647583f, -0.11426102f, 0.09290336f, 0.03340475f, 0.00084528f, 0.03853307f, 0.02531998f, -0.08705468f, 
    0.10793599f, 0.08185247f, -0.07454574f, 0.11258125f, -0.03429965f, -0.02456852f, 0.01223763f, 0.03987001f, 
    -0.00754376f, 0.00327040f, 0.09225160f, 0.05381157f, 0.12006690f, 0.01690616f, -0.04476906f, 0.11064255f, 
    -0.08557220f, -0.05135415f, 0.01843187f, 0.08193532f, -0.04117794f, 0.04172825f, 0.04263379f, 0.09645793f, 
    0.09962646f, 0.15504237f, -0.01041638f, 0.06735331f, -0.01892210f, 0.06648127f, -0.01177667f, 0.01033557f, 
    0.04264691f, 0.19296826f, 0.00161302f, 0.05140010f, 0.21155433f, 0.04303227f, 0.04373880f, -0.10438063f, 
    0.00881876f, 0.11947558f, -0.01555139f, 0.02465088f, -0.01661502f, -0.04596608f, 0.04434301f, -0.08337406f, 
    0.17705800f, -0.00383891f, 0.02684912f, -0.02782086f, -0.01898318f, -0.05544296f, -0.06228049f, -0.14145736f, 
    0.05674666f, 0.06559810f, -0.02369433f, 0.06674199f, -0.08619324f, -0.11138183f, 0.02050737f, 0.00621567f, 
    -0.00131371f, -0.00335191f, 0.06962533f, -0.01020236f, -0.06379592f, 0.04642421f, 0.08895957f, 0.00165535f, 
    0.09520798f, 0.05719120f, 0.18223454f, 0.00788118f, 0.03598271f, 0.02517334f, 0.03298340f, 0.04644804f, 
    0.08102076f, 0.01276552f, 0.04704905f, 0.04285413f, 0.14790197f, 0.04304259f, 0.16930823f, 0.09758478f, 
    0.01250112f, -0.02982408f, 0.05502846f, 0.07827362f, -0.04257044f, 0.01663886f, 0.02086227f, -0.07417028f, 
    -0.03470819f, -0.00462529f, -0.02472998f, 0.03463709f, -0.03430236f, -0.01397109f, 0.03332743f, 0.00589412f, 
    -0.00151174f, 0.00682173f, -0.02889609f, 0.01055536f, 0.02158506f, -0.00449496f, 0.03483341f, 0.02870734f, 
    0.01646648f, 0.00293421f, -0.01464800f, -0.03544080f, 0.00157801f, 0.00105262f, -0.03596979f, -0.00640831f, 
    -0.03817010f, -0.01666447f, 0.01670621f, -0.02102299f, 0.02106084f, -0.02751477f, -0.01100466f, -0.01951055f, 
    0.00484142f, 0.01357157f, -0.02948173f, 0.00012575f, 0.01466737f, -0.02748090f, 0.01901834f, -0.00355233f, 
    -0.00371341f, -0.00313640f, 0.01959070f, -0.02789550f, 0.00939816f, 0.00785865f, -0.03109729f, -0.02872443f, 
    -0.01005605f, 0.01314687f, -0.03330877f, -0.01721991f, -0.01861741f, -0.03648729f, -0.00166468f, -0.01783783f, 
    -0.00350081f, 0.00775957f, -0.01030815f, 0.00265731f, 0.00411526f, 0.00315437f, 0.02145297f, -0.01001778f, 
    -0.01742292f, -0.02259405f, -0.02894447f, -0.00482752f, 0.01383206f, 0.00126500f, 0.02875141f, -0.01201509f, 
    0.00674961f, 0.00277246f, -0.01766666f, -0.00616715f, -0.02286230f, -0.02076587f, -0.01212143f, 0.00675402f, 
    0.01552472f, -0.02671857f, -0.00031280f, -0.03813096f, -0.02335035f, -0.02983308f, -0.01031481f, 0.00543412f, 
    0.01624839f, 0.01266120f, -0.02080822f, 0.01277863f, 0.00631848f, -0.03135826f, 0.01485231f, -0.00988719f, 
    0.01180224f, -0.01127981f, -0.02726316f, -0.00279916f, -0.03906091f, -0.01035254f, -0.02980815f, -0.00759070f, 
    0.01496527f, -0.03352607f, 0.01081313f, -0.01305327f, -0.01331959f, -0.00352396f, -0.00859675f, 0.03603838f, 
    -0.00449476f, 0.01475553f, -0.02551846f, -0.00001943f, 0.02058523f, 0.02168531f, -0.03341128f, 0.01739564f, 
    -0.00918193f, -0.03400252f, 0.03130301f, -0.01741116f, -0.01997012f, 0.00143624f, -0.02325754f, 0.00750387f, 
    -0.00931554f, -0.03529990f, -0.01149945f, -0.03894011f, -0.02157663f, -0.03143638f, 0.00042267f, 0.00094187f, 
    -0.01869137f, -0.03889928f, -0.00139791f, -0.01899404f, 0.01735846f, 0.02951302f, 0.01105800f, -0.03993113f, 
    -0.01589800f, 0.03378381f, -0.00869508f, 0.02151786f, 0.00322778f, -0.03241523f, 0.01124812f, -0.00027250f, 
    -0.03550813f, 0.01767363f, -0.01224211f, 0.00260084f, -0.03999291f, 0.01071510f, -0.03575849f, 0.02024151f, 
    -0.03479268f, -0.01237538f, -0.01179953f, 0.02728940f, -0.01732984f, -0.01397141f, 0.00273734f, -0.00448755f, 
    0.01751961f, 0.02523488f, -0.01865495f, -0.02509732f, 0.01959626f, 0.00569612f, 0.02478365f, 0.02747017f, 
    -0.02337212f, -0.01617208f, -0.00942934f, -0.03533477f, -0.00740626f, -0.01300719f, -0.02037679f, 0.00768471f, 
    0.00486461f, -0.04066290f, -0.02315927f, -0.00180996f, 0.00885882f, -0.03025203f, -0.01868968f, -0.03898311f, 
    0.01814495f, -0.01143456f, -0.04199079f, -0.02566466f, 0.01589360f, -0.03980584f, -0.00481294f, 0.02246535f, 
    -0.03032110f, 0.02359049f, -0.03319409f, 0.00581348f, 0.01454222f, 0.02431907f, 0.01752851f, 0.00156136f, 
    -0.04127510f, -0.04652476f, 0.00338953f, 0.00542053f, -0.01167818f, 0.02540821f, 0.00639593f, 0.01399940f, 
    -0.01194047f, 0.00995924f, -0.01677164f, 0.01947940f, -0.03609130f, 0.00259010f, -0.02740549f, 0.00157013f, 
    -0.01015872f, 0.02953695f, -0.01630427f, 0.03143291f, -0.01059780f, -0.04323190f, 0.03383754f, 0.01000356f, 
    0.00704844f, 0.01470027f, -0.02080655f, 0.01811076f, 0.02728611f, -0.03395642f, -0.01823776f, 0.01158864f, 
    -0.02319399f, -0.01417935f, -0.00750179f, -0.04039898f, -0.00185518f, 0.02945627f, 0.02047647f, 0.01956108f, 
    -0.01474697f, -0.00404579f, 0.01691713f, -0.03490138f, 0.01557970f, 0.00842460f, 0.00150053f, -0.01935348f, 
    -0.01276096f, 0.02218981f, -0.04622554f, -0.00042246f, 0.01502997f, -0.03941391f, 0.01933515f, -0.01990071f, 
    0.03309202f, 0.00831078f, -0.01530848f, 0.02480787f, 0.00798522f, 0.01892758f, -0.04123445f, 0.00829944f, 
    -0.03495374f, -0.04208569f, -0.00904819f, 0.02840612f, -0.03069418f, -0.04273670f, 0.02091781f, 0.01243622f, 
    -0.02682569f, -0.00503491f, 0.00431011f, -0.01721008f, 0.00740351f, 0.02913139f, -0.02124384f, -0.00870141f, 
    0.00419639f, -0.00764276f, -0.02560380f, -0.01046492f, 0.00960561f, -0.02034210f, 0.00831513f, 0.02378962f, 
    0.03571868f, -0.03505547f, -0.01880952f, 0.00080843f, 0.00703257f, -0.01874783f, 0.01314310f, 0.02054363f, 
    -0.03249359f, 0.01927425f, -0.04554826f, -0.00938835f, -0.03381436f, -0.03743351f, -0.02057858f, -0.02629705f, 
    0.00296909f, 0.01900140f, -0.02561318f, -0.01985499f, -0.00131261f, -0.02388822f, -0.01771801f, -0.01911208f, 
    0.01964355f, 0.01604698f, 0.02382031f, 0.01717354f, -0.00775696f, -0.00626493f, -0.02837313f, -0.01092616f, 
    0.00816851f, -0.04554264f, -0.04122071f, 0.01144185f, 0.02524085f, -0.02876894f, -0.02480689f, -0.00563420f, 
    0.02086616f, -0.03432023f, 0.01499738f, 0.01287405f, -0.01587559f, 0.00608771f, -0.01161282f, 0.02097072f, 
    -0.01210490f, -0.03400559f, -0.03747200f, 0.01304404f, -0.03565253f, -0.02154125f, -0.01119903f, 0.00198492f, 
    -0.03872532f, 0.01307171f, 0.00620970f, 0.01061006f, -0.03821817f, 0.03354668f, 0.00512917f, -0.00441692f, 
    0.00717691f, -0.01853353f, -0.02712961f, 0.03120041f, 0.00037822f, 0.01386582f, 0.00737784f, 0.00038262f, 
    -0.03822078f, -0.03219771f, -0.00732407f, 0.01359737f, -0.02646622f, -0.03475032f, -0.03136289f, -0.02347250f, 
    0.02575419f, -0.04632923f, 0.01476750f, 0.02015381f, 0.01615779f, 0.01636169f, -0.00445426f, 0.01532313f, 
    -0.02974639f, -0.02283132f, -0.00218706f, 0.00416959f, 0.01747721f, -0.02392756f, 0.02523416f, -0.02640545f, 
    0.01864073f, 0.00575191f, -0.00659702f, -0.00367133f, 0.02994950f, 0.01960049f, -0.01919548f, -0.00636174f, 
    -0.01044510f, 0.00353983f, 0.01300440f, 0.02665715f, 0.00050117f, -0.04003168f, -0.02484310f, 0.02250592f, 
    0.01724184f, 0.00005314f, -0.02426599f, -0.02758908f, -0.01165108f, 0.02147514f, 0.00288939f, -0.02881830f, 
    -0.03509038f, 0.01132545f, -0.00820637f, -0.00854019f, 0.01471555f, -0.03662039f, -0.00078604f, 0.03338913f, 
    -0.01672586f, 0.01665784f, 0.00159983f, -0.03809051f, 0.01918499f, 0.01681781f, -0.03115897f, -0.04234308f, 
    -0.02448342f, -0.01069388f, 0.01440535f, -0.00204438f, 0.01260828f, 0.00518325f, -0.03981403f, 0.01141866f, 
    -0.03706539f, 0.00983726f, -0.02238977f, 0.00325350f, 0.03228299f, 0.00342600f, -0.01528781f, 0.01945911f, 
    0.01387776f, -0.02547543f, 0.02498564f, 0.02144046f, 0.00274272f, -0.02246254f, 0.00740723f, -0.04014222f, 
    0.01007514f, 0.01177530f, -0.02025062f, -0.00220811f, 0.01936753f, -0.00979710f, 0.02544705f, 0.00237123f, 
    0.01956882f, 0.00416137f, 0.00318640f, -0.01736882f, 0.02188230f, -0.00618549f, -0.01801960f, -0.01482342f, 
    0.02973872f, 0.00882108f, 0.00833931f, 0.01660276f, -0.02308610f, -0.03587560f, -0.02070939f, 0.02741143f, 
    0.01206985f, -0.02313503f, -0.01492505f, 0.02362685f, 0.02885775f, 0.01864224f, 0.01229867f, 0.01470201f, 
    -0.04350164f, -0.02020180f, 0.00136273f, 0.02334110f, 0.00580464f, -0.03837721f, 0.02196651f, 0.01398107f, 
    -0.03084256f, -0.00869478f, -0.00555743f, -0.00838281f, -0.00389912f, 0.00746100f, -0.01974668f, -0.01831831f, 
    0.01773454f, -0.01263939f, 0.00571306f, -0.02440843f, -0.02640810f, -0.02095296f, -0.02289949f, -0.03030562f, 
    0.01345434f, -0.03838040f, -0.02869919f, 0.00376837f, 0.01378692f, -0.01347848f, 0.02628050f, 0.02433168f, 
    -0.02639695f, 0.01287081f, 0.01996923f, -0.00592961f, -0.01329266f, -0.03727374f, 0.00897673f, 0.01836479f, 
    -0.01324440f, -0.02953066f, 0.01709909f, -0.01128744f, -0.01925619f, -0.03864472f, -0.02797234f, 0.01579354f, 
    -0.03011760f, -0.01634635f, 0.02997657f, -0.00702795f, -0.04250298f, 0.00054974f, -0.03641271f, 0.00153564f, 
    0.01380043f, 0.03059678f, 0.00761866f, 0.00283244f, 0.00783745f, 0.00819413f, 0.00418363f, -0.02260600f, 
    0.00330520f, 0.00108936f, -0.01283932f, -0.01526657f, 0.02179957f, -0.00521692f, 0.02806838f, -0.02851738f, 
    0.01641500f, -0.03169654f, 0.02402385f, 0.02147076f, -0.03340653f, 0.00726000f, 0.02524262f, 0.01619386f, 
    0.02859579f, -0.00715991f, -0.04264735f, 0.02283519f, -0.01769010f, -0.02751185f, -0.01299419f, 0.00885236f, 
    0.02559631f, -0.03695030f, -0.03359888f, 0.02513477f, 0.02433099f, -0.02558231f, 0.02069752f, 0.02659996f, 
    -0.00278641f, -0.02760507f, 0.01873401f, 0.01024904f, 0.00408053f, 0.02380341f, -0.00487071f, 0.00259219f, 
    -0.01135577f, -0.02878589f, -0.01893902f, -0.01257118f, 0.01157813f, 0.01335622f, 0.02751432f, 0.02738645f, 
    -0.02150767f, -0.01832523f, -0.00195009f, -0.00633548f, -0.03513880f, -0.00156971f, -0.02788096f, -0.02181374f, 
    -0.00892098f, -0.03735642f, -0.00156301f, -0.02392506f, 0.00643963f, 0.03306701f, -0.02533890f, 0.02202477f, 
    0.00089254f, 0.00766210f, 0.01418405f, 0.01725091f, 0.00045556f, -0.01843707f, -0.00564012f, -0.03492894f, 
    0.02751977f, -0.02884478f, -0.02473065f, -0.00502767f, -0.00241718f, 0.00690172f, -0.00977051f, 0.00782391f, 
    -0.03714088f, -0.02489455f, -0.00346259f, -0.01020111f, 0.02198675f, -0.01441901f, 0.02505634f, -0.02836141f, 
    0.01726131f, -0.00001424f, 0.00539601f, 0.02392503f, -0.02161476f, 0.02261625f, -0.00570530f, 0.03046304f, 
    0.02968354f, -0.00151515f, -0.03545444f, 0.00711555f, -0.02156227f, -0.02063867f, -0.04086800f, 0.02831144f, 
    0.01251794f, -0.04412770f, -0.03823846f, 0.02840962f, -0.03847993f, 0.02196744f, -0.00921496f, -0.00333815f, 
    0.01454125f, 0.03768760f, -0.02713384f, -0.01520214f, -0.04213160f, 0.03349465f, -0.02624928f, -0.03115763f, 
    0.03576938f, 0.01424144f, 0.00248487f, 0.00135640f, 0.03384048f, 0.00252199f, -0.02551912f, -0.02188281f, 
    -0.03576632f, -0.00875523f, -0.01341354f, -0.03399584f, -0.03199229f, 0.00957485f, 0.02834986f, 0.02615570f, 
    -0.01693925f, -0.00908176f, -0.04211419f, 0.01371290f, 0.02297006f, 0.03021278f, -0.02739669f, -0.03663406f, 
    0.02050823f, -0.01645732f, 0.01251389f, -0.01531874f, 0.02532926f, -0.01833805f, 0.00770200f, -0.02387748f, 
    -0.02391465f, -0.00852745f, 0.02414056f, -0.01519015f, -0.03107166f, 0.02529412f, 0.02379694f, -0.01037540f, 
    0.02424349f, 0.01790802f, -0.03003258f, -0.00240496f, -0.02296635f, 0.03388348f, 0.03648225f, 0.00246790f, 
    -0.00849160f, 0.01764132f, 0.01712325f, -0.03346626f, 0.00411179f, -0.00985064f, 0.02918069f, -0.00368042f, 
    -0.03437649f, -0.02631537f, -0.01739715f, 0.02502885f, -0.04282618f, -0.02917703f, -0.03205393f, 0.01564744f, 
    -0.00817835f, 0.01810584f, -0.02385093f, -0.03732735f, -0.04153590f, -0.01867579f, 0.01105190f, -0.03507202f, 
    0.02071906f, -0.01866682f, 0.01792207f, -0.00306755f, -0.00374873f, 0.00822705f, 0.00420719f, -0.01696785f, 
    -0.03041423f, 0.03364309f, -0.02903902f, -0.04142697f, 0.00314152f, -0.03512198f, -0.02237580f, 0.00459155f, 
    0.00638150f, -0.02068388f, 0.01417038f, -0.01397383f, 0.02666226f, -0.00958458f, 0.01192506f, 0.01781992f, 
    0.03048729f, 0.00441029f, -0.03027899f, -0.01754476f, -0.02145005f, -0.01761607f, 0.02260678f, 0.00173038f, 
    0.01619911f, 0.00063096f, 0.02155629f, -0.01632808f, -0.02976818f, -0.00333595f, 0.01982095f, 0.01608451f, 
    -0.02725280f, -0.02808492f, 0.01348284f, -0.02093057f, -0.00118312f, -0.03540237f, 0.00248971f, -0.00116536f, 
    -0.01139887f, -0.01865025f, -0.01459912f, -0.00237055f, 0.01757328f, -0.00694967f, 0.01008498f, -0.03040051f, 
    0.02868899f, 0.02923563f, -0.01913239f, -0.03559502f, 0.02906027f, -0.00309487f, -0.02477220f, -0.03418416f, 
    -0.00679343f, 0.00726283f, 0.01390421f, -0.01729251f, -0.01814625f, 0.01167465f, -0.00153433f, 0.01520476f, 
    0.01201439f, -0.04164130f, -0.03900987f, 0.00134596f, 0.01502892f, 0.02636653f, -0.01638834f, -0.02432745f, 
    -0.02885049f, 0.01526682f, -0.01887216f, 0.00956452f, -0.03565875f, -0.02404675f, -0.01376809f, -0.00813820f, 
    -0.03112318f, 0.00457691f, -0.02941493f, 0.02850965f, 0.02013149f, -0.00968688f, -0.03689710f, 0.02383311f, 
    -0.01005310f, -0.01171567f, -0.02765231f, -0.01249086f, 0.01806635f, -0.04089429f, -0.01564687f, -0.02131367f, 
    0.02149795f, 0.00355766f, -0.01741222f, -0.02758878f, -0.00428582f, 0.02053246f, -0.02787928f, -0.03952635f, 
    0.02758827f, -0.03433363f, 0.02136490f, -0.01590585f, -0.02579187f, 0.02082290f, 0.00132506f, 0.00499696f, 
    -0.02910698f, -0.03865788f, -0.01279959f, 0.00622760f, -0.01241563f, -0.02018229f, 0.00186423f, -0.02451780f, 
    0.00018391f, 0.02770302f, -0.00168149f, -0.02851253f, 0.01508541f, -0.01197656f, -0.01587118f, 0.01299754f, 
    0.03256359f, -0.01696190f, 0.02286202f, 0.00635412f, -0.02278598f, -0.02979382f, -0.01058287f, -0.01569113f, 
    -0.03490005f, -0.03988247f, -0.02854832f, -0.03053235f, -0.02196783f, -0.02072562f, -0.00370707f, 0.00127917f, 
    -0.01849802f, -0.01775494f, 0.00208826f, 0.00653952f, -0.03912814f, -0.03522716f, -0.01241038f, -0.00187634f, 
    -0.01301287f, -0.02450512f, 0.00703266f, -0.00018550f, -0.03423166f, -0.00654205f, 0.02595049f, -0.00595772f, 
    -0.01802086f, 0.02639741f, -0.02242953f, -0.02518983f, 0.00943713f, -0.03038265f, -0.02404658f, -0.03954518f, 
    0.01712069f, -0.01520449f, 0.02712264f, 0.01260969f, 0.02719128f, -0.03515030f, 0.00673004f, -0.00518835f, 
    0.00831689f, -0.01672981f, 0.00291139f, -0.02556252f, -0.03678140f, -0.02067161f, 0.02734486f, -0.02836491f, 
    -0.00821362f, 0.00624892f, -0.01833534f, -0.01595104f, -0.00900546f, 0.01061627f, 0.01643992f, -0.03763416f, 
    -0.03765016f, -0.04080673f, 0.01790321f, 0.01772146f, -0.00559294f, -0.01766014f, 0.01036879f, -0.01028563f, 
    -0.01559332f, 0.01860379f, -0.01703360f, 0.00821026f, 0.02210592f, 0.00683245f, -0.00172968f, -0.03113793f, 
    -0.01625196f, -0.00726988f, 0.03157888f, 0.02432482f, -0.01496506f, 0.01456176f, -0.03000161f, 0.01942880f, 
    0.01603239f, -0.00734967f, -0.02672506f, -0.03491008f, -0.01236173f, -0.03521166f, -0.00021917f, -0.03992116f, 
    0.00860409f, 0.02345978f, 0.01333311f, -0.02589071f, 0.01332337f, -0.03217729f, 0.01896889f, -0.02299003f, 
    -0.03109619f, 0.01084711f, -0.00295823f, 0.01407547f, 0.02289033f, -0.01501088f, -0.03243763f, 0.01015746f, 
    -0.03026406f, -0.02439322f, 0.01508548f, 0.01555878f, -0.04065897f, 0.01915296f, -0.02321204f, -0.01714769f, 
    -0.00434296f, -0.02781994f, 0.02590950f, 0.02545022f, 0.00015990f, 0.00189275f, -0.00055464f, -0.02824604f, 
    -0.00959579f, -0.02571626f, 0.01116871f, 0.01089818f, 0.00678124f, -0.03807252f, 0.00556285f, 0.00178543f, 
    0.02257120f, -0.01717585f, -0.03188978f, -0.00121121f, 0.00709274f, 0.01658540f, -0.01344163f, 0.01880373f, 
    -0.00512933f, -0.03549118f, -0.01306234f, -0.03181953f, -0.02002140f, -0.00985305f, -0.00100546f, -0.00452364f, 
    0.00702818f, -0.02585321f, -0.02892166f, -0.01199904f, 0.02325086f, -0.00320811f, -0.01669440f, -0.02549606f, 
    -0.00322713f, -0.00465422f, 0.01275095f, 0.02238426f, -0.01588573f, 0.00909369f, 0.00750361f, -0.03126915f, 
    -0.02789099f, -0.03334615f, -0.03951786f, -0.02473635f, -0.02713677f, -0.03525710f, -0.02965919f, -0.01491931f, 
    0.01367171f, -0.01881330f, 0.02354916f, -0.04184483f, -0.04087707f, 0.02725527f, -0.04133333f, -0.03320987f, 
    -0.02216345f, 0.00080408f, -0.02480024f, -0.01859472f, -0.03913460f, -0.02687801f, 0.01834282f, -0.00224498f, 
    -0.02153258f, 0.02397474f, 0.02574814f, -0.00808004f, -0.02657676f, 0.03408702f, 0.00616675f, 0.00128987f, 
    -0.03974617f, -0.02382571f, -0.03112692f, -0.02617230f, -0.02259626f, -0.00480097f, -0.03286773f, 0.02798958f, 
    -0.01625021f, -0.03850335f, 0.00707322f, -0.01263286f, -0.03731157f, -0.00919383f, 0.02109462f, -0.02997606f, 
    0.00658458f, -0.01287203f, 0.00948993f, -0.02011839f, -0.04205835f, -0.01887798f, 0.01313285f, 0.01699665f, 
    -0.03092843f, 0.01030724f, -0.03381442f, 0.01325887f, 0.02029067f, 0.00523896f, 0.02127231f, 0.02963162f, 
    -0.00100810f, -0.03267304f, -0.03782765f, -0.03448088f, -0.00574234f, 0.01188530f, -0.03007078f, -0.02126123f, 
    0.00962356f, 0.01301899f, -0.02277087f, -0.00762423f, 0.00907648f, -0.00181921f, 0.02272125f, -0.00989054f, 
    0.01865556f, -0.02577033f, -0.03907111f, -0.01501216f, 0.01161902f, 0.02691408f, 0.02997300f, 0.01774376f, 
    -0.00425076f, 0.01537878f, 0.01996837f, 0.02741856f, -0.03257816f, 0.02557320f, -0.02999077f, -0.02400690f, 
    -0.00668653f, 0.01585907f, 0.02103228f, -0.00246151f, -0.01108968f, -0.00707082f, -0.01612386f, 0.01619007f, 
    -0.00734081f, -0.03839535f, -0.03015709f, -0.00757009f, 0.02089770f, -0.01270927f, -0.00612134f, 0.00735294f, 
    -0.01706583f, -0.02170408f, -0.03154762f, -0.01973041f, 0.01474420f, -0.03688304f, 0.02260596f, 0.01674667f, 
    0.02409247f, -0.01201319f, -0.00307539f, -0.02442262f, -0.01050444f, 0.02682094f, -0.00063822f, 0.02929912f, 
    0.02410096f, 0.01769968f, -0.03438167f, -0.03483852f, 0.00028106f, 0.02065716f, 0.01878165f, -0.03926308f, 
    0.02400442f, 0.00981813f, -0.01311490f, -0.00310200f, 0.02073610f, -0.03050235f, -0.00597015f, -0.00828706f, 
    -0.00023483f, -0.00073386f, -0.01520003f, -0.02983405f, -0.01004205f, 0.01267651f, -0.03625047f, -0.04165756f, 
    -0.01656679f, -0.04163541f, -0.03563297f, 0.00256204f, -0.01856090f, -0.03780505f, 0.02198480f, -0.02131051f, 
    -0.02165439f, 0.01966668f, -0.02531221f, 0.00445055f, -0.03991712f, 0.02294730f, -0.00493678f, 0.00748996f, 
    -0.01638332f, 0.00587178f, 0.00917539f, 0.00842719f, -0.01222572f, -0.03657572f, -0.01479685f, 0.02846147f, 
    -0.02385251f, -0.02317709f, -0.01398223f, 0.00270088f, 0.01213047f, 0.01103674f, -0.02715124f, -0.03911312f, 
    0.02669739f, -0.01173823f, -0.03916138f, -0.00281274f, 0.02168399f, 0.01811818f, 0.00402841f, -0.03120778f, 
    -0.02616634f, -0.03196060f, 0.00536535f, -0.02383634f, -0.03575759f, -0.02081763f, 0.01648988f, -0.01865922f, 
    0.02470857f, 0.00655378f, -0.02897198f, -0.04036350f, 0.00521363f, -0.01547269f, 0.02890215f, 0.00642337f, 
    -0.02456225f, 0.02985336f, -0.01426659f, 0.02818840f, 0.01125951f, -0.02334898f, 0.02229225f, 0.02403930f, 
    -0.01774238f, 0.00687770f, -0.02759144f, 0.02717883f, 0.00795277f, 0.01489381f, -0.00258977f, 0.00611713f, 
    -0.03346104f, 0.02930319f, -0.00298615f, 0.00820735f, -0.01163168f, 0.01403936f, 0.00793670f, 0.00266516f, 
    0.01102102f, -0.03284987f, 0.00915390f, -0.03192616f, 0.02208927f, -0.02615368f, -0.02606371f, -0.01999983f, 
    -0.00276356f, -0.01424135f, -0.00493903f, 0.02389624f, -0.02581875f, -0.01589912f, -0.02232014f, 0.02685715f, 
    -0.00647995f, 0.00109980f, 0.02827078f, -0.00713288f, -0.00637159f, -0.03157312f, -0.01515285f, -0.03687339f, 
    0.02758413f, -0.00185644f, -0.03905954f, -0.01572349f, -0.01211589f, -0.00470023f, 0.00970864f, 0.02516671f, 
    -0.00031903f, -0.01651621f, 0.02723772f, 0.02735618f, 0.00338735f, -0.01867174f, 0.02063598f, -0.03166065f, 
    -0.03367171f, -0.01837201f, -0.02907337f, -0.01947211f, 0.01104881f, -0.03636717f, -0.02348013f, -0.03079624f, 
    -0.00313023f, -0.00481948f, -0.02056933f, 0.02607684f, 0.01956717f, -0.02901099f, -0.03073708f, 0.02165710f, 
    -0.02192616f, -0.01562605f, 0.00852983f, 0.02059412f, -0.00630708f, -0.02365622f, 0.00243267f, -0.02630570f, 
    0.00668450f, -0.00488811f, 0.02829919f, -0.02513391f, -0.01649587f, 0.00855140f, 0.02092792f, -0.00699680f, 
    -0.01153836f, -0.03535841f, -0.02550452f, -0.02696075f, 0.00237261f, -0.02118127f, 0.00452733f, -0.01384346f, 
    -0.01434466f, 0.02845878f, 0.00445659f, 0.00366983f, -0.03221173f, 0.02723981f, -0.01943650f, -0.02947194f, 
    -0.02514852f, 0.01159875f, -0.01818339f, -0.01334993f, 0.02836834f, -0.01001307f, 0.02114747f, 0.00591060f, 
    -0.03593493f, 0.01811969f, 0.02897295f, -0.02700563f, -0.02545405f, 0.00739113f, -0.00812789f, -0.02911261f, 
    -0.03393665f, -0.03741376f, 0.00906310f, -0.03579853f, 0.02964245f, -0.03212909f, 0.00516174f, 0.00275837f, 
    0.01735615f, -0.03775383f, 0.02594004f, -0.03000124f, -0.02198567f, -0.01752830f, -0.02349457f, 0.01423186f, 
    -0.04077717f, -0.04057048f, 0.00741338f, 0.01305061f, 0.01194753f, -0.03579694f, 0.03006698f, 0.00566811f, 
    0.02390787f, -0.03069906f, 0.00461484f, -0.02725882f, -0.00069375f, 0.01654840f, 0.00096761f, 0.02283396f, 
    0.00017458f, -0.01997837f, 0.01374703f, 0.00271960f, -0.03355349f, -0.00156922f, 0.01751769f, 0.02781605f, 
    -0.00533571f, 0.01866750f, -0.00550297f, -0.02049097f, 0.00673087f, -0.00070989f, -0.03802411f, -0.02332998f, 
    0.01115757f, 0.00512715f, -0.01040769f, 0.00658163f, -0.03226578f, -0.01785245f, -0.03766456f, -0.01491950f, 
    -0.00136666f, -0.02191566f, -0.02676492f, -0.00023742f, -0.01685302f, -0.01315019f, -0.01542312f, -0.00301952f, 
    -0.01823670f, 0.01386696f, 0.01362851f, 0.02627396f, -0.00182209f, -0.03670550f, -0.02674448f, 0.00781047f, 
    -0.01683947f, -0.00287044f, 0.00002150f, 0.02497633f, 0.00348303f, -0.03795727f, 0.02776584f, -0.03004141f, 
    -0.03142117f, -0.02328120f, -0.01922140f, -0.03728077f, -0.01456448f, 0.01543120f, -0.00902811f, -0.01507992f, 
    0.01153652f, -0.03896585f, 0.02629813f, 0.01857929f, 0.02464531f, 0.02796922f, -0.03794471f, -0.01197009f, 
    -0.00929594f, 0.00338185f, -0.03175913f, 0.02933086f, 0.02780883f, 0.00742333f, 0.02247366f, -0.01948744f, 
    0.00634055f, 0.00114520f, -0.00970538f, -0.03367040f, -0.01589848f, -0.01991850f, -0.04164341f, -0.02263802f, 
    -0.01606793f, -0.00589319f, -0.01032155f, 0.01435411f, 0.02801636f, 0.00291081f, -0.02513619f, -0.02557030f, 
    -0.03911402f, -0.00317849f, -0.00667561f, -0.01984425f, -0.00948474f, -0.04201345f, 0.00322869f, -0.02505217f, 
    -0.02721049f, -0.03290412f, -0.01113807f, -0.01262695f, 0.02121835f, -0.03387622f, -0.03500869f, 0.02947042f, 
    0.01381833f, -0.04201084f, 0.00593017f, -0.02677754f, -0.00379472f, 0.01908669f, -0.01566503f, 0.02790183f, 
    -0.01187766f, 0.01800990f, 0.00958966f, -0.00982150f, -0.01542042f, 0.01924670f, 0.01023223f, -0.02265087f, 
    0.12921716f, 0.05128018f, 0.02193766f, -0.07188255f, 0.03677585f, 0.09737460f, -0.00753832f, 0.09470759f, 
    0.05161265f, 0.13297489f, -0.04119837f, 0.02321850f, -0.02542223f, -0.10427695f, 0.06333867f, 0.08162145f, 
    0.00836813f, 0.05595750f, -0.01908707f, 0.04052280f, -0.01748592f, -0.02667974f, -0.07138548f, -0.01895799f, 
    -0.14567037f, -0.03180623f, 0.04174032f, 0.01452312f, 0.06611900f, 0.05777286f, -0.00912812f, -0.07004030f, 
    0.01824542f, 0.06785181f, -0.00323772f, 0.03134578f, 0.17871593f, -0.14709763f, -0.00681106f, 0.00331189f, 
    -0.09994563f, 0.00914892f, 0.06607032f, 0.02117692f, -0.03583935f, 0.12121576f, -0.04618903f, -0.00333486f, 
    0.28433543f, -0.13784489f, -0.01140416f, -0.01734744f, -0.05268897f, 0.00400379f, -0.02248422f, -0.02002252f, 
    -0.01960063f, 0.04179327f, 0.01649450f, 0.15543307f, 0.03429501f, -0.06259552f, -0.08819946f, -0.08736581f, 
    -0.01407579f, -0.01733025f, 0.04869654f, 0.00385654f, -0.02050912f, -0.00492140f, 0.08201470f, 0.00550293f, 
    -0.18367550f, 0.08830776f, 0.10657372f, 0.03724129f, -0.04292956f, -0.07820156f, 0.02680569f, -0.07763644f, 
    0.03570443f, 0.00463996f, -0.00251482f, 0.15593700f, 0.09749077f, -0.15724607f, 0.04499339f, 0.04054590f, 
    -0.05442387f, -0.08172058f, 0.03309033f, 0.01526237f, -0.03484095f, -0.01754339f, -0.03059567f, -0.02504943f, 
    0.31119150f, -0.10023503f, 0.07426756f, 0.08320404f, 0.06282918f, 0.05799556f, 0.00176575f, 0.11371984f, 
    0.09997456f, -0.02150748f, -0.02263447f, -0.10329200f, 0.16626428f, -0.05292824f, -0.01093370f, 0.18357480f, 
    -0.02887239f, 0.03346460f, 0.07826230f, -0.04387819f, -0.00845122f, -0.03351072f, -0.02137731f, -0.03160617f, 
    -0.08377619f, 0.17289321f, 0.06036703f, -0.16774037f, 0.05218137f, 0.04993270f, -0.04179399f, 0.03960207f, 
    0.03429556f, 0.03279129f, 0.04401222f, 0.00606217f, -0.03853184f, 0.01822698f, 0.01533207f, -0.14758334f, 
    0.01303393f, 0.08452967f, 0.05132516f, -0.00522323f, 0.04853810f, 0.01437823f, 0.00287595f, 0.10154091f, 
    -0.11923349f, 0.00316434f, -0.08562344f, -0.11847998f, -0.06432647f, -0.08859058f, 0.08336917f, -0.11012594f, 
    0.01006050f, 0.06253519f, 0.07566345f, -0.08912891f, -0.05483748f, -0.05141964f, -0.08367496f, -0.02891821f, 
    -0.13956475f, 0.00364944f, 0.01833311f, -0.07552484f, 0.05114932f, 0.04083706f, -0.08021109f, -0.02438707f, 
    -0.09602371f, 0.12129848f, 0.14166521f, -0.05215932f, -0.02006964f, 0.03187243f, -0.01279488f, -0.03742177f, 
    0.01657710f, 0.06736446f, -0.08203705f, -0.01785666f, 0.11410859f, -0.16194297f, 0.05751171f, 0.04839933f, 
    0.01488170f, 0.03235883f, -0.01167532f, -0.03691266f, 0.11162096f, 0.03296614f, 0.13075884f, -0.00690992f, 
    -0.28776580f, 0.00393535f, 0.05435485f, -0.11152834f, 0.02449605f, 0.13426617f, 0.03226699f, -0.05226588f, 
    0.08029337f, -0.07656971f, 0.08175419f, 0.00036145f, -0.07255813f, 0.07018242f, -0.03058513f, -0.06423931f, 
    0.02696956f, 0.13972540f, 0.00823542f, 0.04785895f, -0.01166849f, 0.09566183f, 0.02562759f, 0.00817845f, 
    -0.14286272f, -0.03107490f, -0.03438782f, -0.17044224f, -0.02784034f, 0.00638207f, -0.01838655f, -0.05089051f, 
    0.06223954f, 0.00821201f, 0.03434058f, -0.01979865f, 0.09776384f, -0.21197943f, -0.00484275f, -0.03291679f, 
    -0.00620153f, 0.04699888f, -0.02713638f, 0.13202310f, 0.02900103f, -0.08746707f, 0.02871419f, 0.11045126f, 
    0.04297255f, 0.24184795f, 0.11581813f, -0.08891565f, 0.09070155f, 0.05191310f, 0.01725715f, 0.03029793f, 
    0.04035656f, 0.01682899f, -0.06297757f, 0.05870068f, 0.11703768f, -0.14180088f, 0.00002891f, 0.08411198f, 
    -0.04129905f, 0.08667827f, 0.06841963f, 0.03898674f, 0.05129826f, -0.03889692f, -0.00031411f, 0.05238887f, 
    -0.08703455f, 0.09760633f, -0.04462952f, -0.10595740f, -0.00191141f, 0.05864440f, -0.08423140f, -0.03943148f, 
    -0.05606680f, 0.10161442f, 0.05961393f, -0.08807784f, 0.13039832f, -0.10142803f, 0.01541539f, -0.04317117f, 
    -0.00561260f, -0.09144650f, 0.00838863f, -0.04636329f, 0.06674652f, 0.02016379f, 0.18746290f, -0.04862672f, 
    0.03052397f, 0.09230242f, -0.09570571f, 0.02875515f, 0.07089476f, 0.00339722f, 0.10822361f, -0.05747719f, 
    0.02169607f, 0.05333666f, -0.02121837f, 0.07432895f, -0.14169425f, 0.09123328f, 0.14687166f, 0.20853840f, 
    0.10673942f, 0.03718380f, 0.02780000f, 0.09501757f, 0.05512590f, -0.08249324f, 0.06128762f, 0.03583212f, 
    -0.12624986f, 0.10498998f, -0.09748152f, 0.02696178f, -0.11978117f, -0.08663558f, 0.04656854f, 0.11093617f, 
    -0.00003005f, -0.08200268f, 0.00023323f, -0.01948050f, -0.12173689f, 0.11781181f, 0.04734946f, -0.17455895f, 
    0.01049343f, 0.03287324f, 0.04244765f, 0.00369771f, 0.03771387f, -0.01288579f, 0.11946660f, -0.03409796f, 
    0.04029653f, 0.18167230f, 0.01349742f, -0.12500691f, 0.07663330f, 0.08094072f, 0.00171307f, -0.01575610f, 
    0.00678406f, 0.05590107f, -0.03220242f, -0.05244556f, -0.01751984f, 0.13271196f, -0.07879214f, -0.09431096f, 
    -0.04180407f, -0.01874191f, -0.00843490f, 0.02616935f, 0.02717282f, 0.01503275f, 0.01240228f, -0.04799486f, 
    -0.17839028f, -0.00278741f, -0.03919998f, 0.16539688f, 0.02932118f, -0.03955838f, 0.06669899f, 0.09209316f, 
    -0.03183534f, -0.11781494f, 0.01944356f, -0.00124373f, -0.25447723f, -0.02384259f, 0.01176648f, -0.16091353f, 
    0.14649585f, -0.01995973f, -0.04050540f, -0.02332692f, -0.02237878f, 0.00295599f, 0.05725740f, -0.00525475f, 
    -0.15624841f, 0.18461715f, 0.05592867f, -0.09320017f, -0.01679876f, 0.15943368f, 0.04580458f, 0.02263421f, 
    0.07795969f, 0.11433599f, 0.01942983f, -0.00245130f, -0.04928392f, -0.03889823f, -0.06405110f, -0.03018664f, 
    -0.10124150f, -0.05615555f, -0.03510819f, -0.00268802f, 0.05736389f, -0.01920226f, 0.02476335f, -0.00058302f, 
    0.11237694f, -0.06915934f, -0.06383737f, -0.07683387f, -0.11411647f, -0.02789500f, 0.01179540f, 0.01518070f, 
    -0.00269547f, 0.04685472f, 0.02273895f, -0.00578303f, -0.28602633f, 0.08439690f, 0.09075898f, -0.05542206f, 
    0.19934988f, 0.07774479f, -0.00643076f, 0.02482418f, 0.06576280f, 0.07608210f, -0.08869585f, 0.03813800f, 
    0.07648447f, -0.08051041f, 0.00801464f, 0.08450249f, -0.06273968f, 0.01969939f, -0.02754675f, -0.01623163f, 
    0.03395440f, -0.02839271f, -0.04505274f, -0.00831219f, -0.03553631f, -0.10609081f, -0.03692867f, -0.15673077f, 
    -0.02773175f, 0.01984666f, -0.00516670f, 0.02111775f, 0.02816141f, -0.05065028f, -0.02385422f, 0.02266301f, 
    0.23970322f, 0.17096542f, 0.00055995f, -0.08674832f, 0.14276528f, 0.08549415f, 0.05155760f, -0.06969179f, 
    0.00847562f, 0.07341643f, 0.01866649f, 0.07937565f, 0.36216176f, 0.06409790f, 0.11376570f, 0.00126818f, 
    -0.14228576f, 0.00371227f, 0.01101632f, 0.01656217f, 0.04950359f, -0.01581932f, 0.01869973f, -0.05924239f, 
    0.38017738f, -0.10883449f, -0.03754498f, 0.01234694f, 0.08701962f, -0.00845781f, 0.05707134f, 0.00535689f, 
    0.06555531f, 0.00927487f, 0.02805758f, 0.10779935f, 0.25853428f, 0.19604330f, 0.01186897f, -0.09176104f, 
    0.00194531f, 0.12696941f, 0.06764154f, 0.04896553f, -0.06101838f, -0.03235769f, 0.01049483f, 0.03325569f, 
    -0.01363843f, -0.00688538f, -0.01329499f, 0.03060892f, -0.05428654f, 0.03375605f, 0.11775159f, -0.09094897f, 
    0.01103814f, -0.01050357f, 0.06772012f, 0.04689503f, -0.14255938f, 0.09772612f, -0.09848630f, -0.01801887f, 
    0.06260406f, 0.02574192f, 0.08728612f, 0.02879455f, 0.00741145f, 0.01849960f, 0.01762072f, 0.02321250f, 
    0.16784310f, 0.25099105f, 0.07881417f, -0.12917256f, 0.01381526f, 0.07622781f, -0.03522291f, 0.06846756f, 
    0.04002731f, 0.09370866f, 0.05315067f, 0.00973953f, 0.37587753f, 0.05891623f, -0.05905286f, 0.08955145f, 
    0.07900401f, -0.04556406f, 0.13391866f, -0.00293879f, 0.01737258f, 0.02768251f, 0.15445291f, -0.01954580f, 
    0.08249335f, 0.11549640f, -0.05278516f, -0.19722544f, 0.09942394f, 0.06012511f, 0.02199132f, 0.00678379f, 
    -0.03292296f, 0.07109065f, 0.12617500f, -0.05888815f, -0.28070706f, -0.06645007f, 0.00119715f, -0.12975840f, 
    0.00536253f, 0.00858626f, 0.02895895f, 0.18974972f, 0.08933090f, -0.10356860f, 0.02457097f, 0.06587289f, 
    -0.35351250f, -0.04546418f, 0.12231825f, 0.05107099f, 0.07746170f, 0.10039297f, 0.03729711f, 0.04429667f, 
    -0.00846006f, -0.09603368f, 0.03975842f, -0.00731334f, -0.06899335f, 0.17339210f, -0.05387425f, -0.17938040f, 
    -0.05220368f, 0.02687551f, -0.05147432f, 0.07421169f, -0.00340474f, -0.04761751f, 0.09343643f, 0.08987162f, 
    0.13777439f, 0.06598255f, 0.01867656f, 0.01070444f, 0.05660564f, 0.00898404f, 0.05033103f, -0.03037000f, 
    -0.01820131f, 0.01082257f, 0.01476054f, -0.13223244f, -0.14628837f, -0.08319426f, -0.10086842f, 0.08723769f, 
    -0.07281082f, -0.00674340f, -0.02353450f, -0.00708833f, 0.01613929f, -0.12487443f, 0.03553961f, 0.01842402f, 
    -0.27347830f, -0.03644239f, 0.09534407f, 0.22017922f, 0.05723224f, 0.04508749f, 0.02026403f, 0.06816813f, 
    -0.00694154f, -0.11910652f, 0.08809926f, -0.04085243f, 0.10661123f, -0.13462447f, -0.04060815f, 0.08180846f, 
    -0.00977964f, 0.04538056f, 0.01056136f, 0.05640553f, -0.05292526f, -0.01865503f, -0.00852385f, -0.04827595f, 
    -0.12499218f, 0.00983358f, -0.04324438f, -0.18543796f, 0.06969780f, -0.00910438f, -0.05223689f, 0.00888215f, 
    -0.01585399f, -0.06845044f, 0.04902688f, 0.07830888f, 0.15309280f, -0.02368449f, 0.02501266f, 0.03155130f, 
    -0.09627937f, -0.06853829f, 0.04346381f, -0.04930180f, 0.04013967f, 0.01311333f, -0.03101039f, 0.06159915f, 
    -0.13122816f, 0.08973927f, 0.11784489f, -0.00082833f, 0.08089389f, 0.01953011f, 0.07508179f, 0.09256032f, 
    0.12274901f, -0.03388080f, 0.00092464f, -0.00492361f, 0.23150240f, -0.08842343f, 0.01426714f, 0.03904456f, 
    -0.04479496f, 0.05468843f, -0.00300540f, -0.00776800f, -0.08148950f, -0.01910144f, -0.02775167f, 0.02978721f, 
    -0.11072908f, -0.13741410f, 0.06958325f, 0.02841603f, 0.02256425f, -0.02267256f, 0.02953496f, -0.14036641f, 
    0.05890068f, 0.05129045f, -0.05842574f, -0.02633909f, -0.07172571f, 0.00184735f, 0.04281672f, -0.12489641f, 
    0.11389852f, -0.04944446f, -0.04028372f, 0.03160573f, 0.00524198f, 0.02038536f, 0.04579875f, 0.00650809f, 
    -0.26262653f, 0.12489868f, 0.16524115f, 0.10798459f, 0.04013943f, 0.02617518f, -0.06650417f, 0.05604320f, 
    0.00339805f, 0.00450059f, -0.02256323f, -0.00053526f, 0.06128009f, -0.01785533f, 0.12040070f, 0.06924243f, 
    0.09086521f, -0.04439908f, 0.07451238f, -0.03236809f, 0.02542534f, -0.04277702f, 0.08081052f, -0.01985797f, 
    -0.01910077f, -0.12258205f, 0.00285261f, -0.06361037f, -0.03192661f, -0.07672915f, 0.00284622f, 0.06652904f, 
    -0.03258340f, 0.08899039f, -0.00204008f, 0.05793636f, 0.04659318f, -0.13051763f, 0.01334850f, 0.00537427f, 
    -0.12232821f, -0.02845748f, -0.03886239f, 0.10421980f, -0.01112974f, 0.02819174f, -0.00169504f, -0.03031157f, 
    -0.25190797f, -0.11928234f, -0.07789142f, 0.26868829f, -0.00570606f, -0.07845086f, -0.02878905f, -0.09043884f, 
    -0.03517255f, -0.12129918f, 0.12808958f, 0.00286822f, -0.09727987f, 0.02095837f, -0.17497395f, -0.20179312f, 
    -0.03632154f, 0.01039784f, 0.08172717f, 0.09502596f, 0.05836256f, -0.01244207f, 0.03413180f, 0.06844982f, 
    0.11836024f, 0.01563990f, -0.02642160f, 0.00437540f, -0.00467352f, 0.00047887f, 0.08511207f, -0.06539939f, 
    0.02066052f, 0.00644267f, -0.02628086f, 0.00643392f, -0.01514686f, 0.07323518f, 0.04166354f, 0.06276613f, 
    0.04171469f, -0.03085628f, 0.02310888f, 0.01616854f, -0.04463478f, -0.00898490f, 0.00789457f, 0.06158512f, 
    -0.01391022f, -0.02889992f, -0.02604880f, 0.05703867f, 0.04973704f, 0.02119498f, 0.01497441f, 0.16874833f, 
    0.05944893f, 0.01849812f, 0.02655127f, -0.03747489f, -0.06679542f, -0.07227589f, 0.04883489f, -0.06466265f, 
    0.04028660f, 0.02970953f, 0.09262996f, 0.02911935f, 0.05126337f, 0.02445762f, -0.05593761f, 0.09931206f, 
    0.02582726f, -0.10724483f, 0.13217935f, -0.06142530f, -0.01117055f, -0.04082880f, -0.00719499f, -0.00515275f, 
    0.03378429f, -0.00567447f, -0.14825040f, -0.08033599f, 0.03868409f, 0.06986620f, -0.01817964f, 0.04134386f, 
    0.03826694f, 0.02408067f, -0.00664803f, -0.02310086f, 0.02364267f, 0.04664338f, -0.06358185f, 0.05105731f, 
    0.18280163f, -0.01848932f, -0.18063791f, 0.03860741f, -0.03123365f, -0.09828493f, -0.00959407f, -0.05931623f, 
    -0.02835503f, 0.09382603f, -0.10228612f, 0.11795704f, -0.18144125f, -0.08510825f, -0.00734200f, -0.08053199f, 
    0.06585275f, -0.02725138f, 0.02349871f, 0.14964361f, -0.01866751f, 0.03961272f, -0.04261915f, 0.05597763f, 
    0.04890602f, -0.12391428f, 0.08379710f, 0.18882556f, 0.07566424f, 0.09163847f, 0.09163758f, 0.01053020f, 
    -0.05202706f, -0.00153531f, 0.03143622f, 0.12301493f, -0.05050755f, -0.03964915f, 0.03420722f, 0.09051006f, 
    0.01549047f, 0.03679315f, -0.04899720f, -0.01956361f, 0.03960756f, -0.03684592f, 0.01111823f, -0.08524977f, 
    0.07725848f, 0.05146539f, -0.03776050f, -0.00149312f, 0.04479472f, 0.01655403f, -0.04052415f, 0.01997055f, 
    0.00516704f, -0.04199640f, -0.03339675f, 0.02597719f, 0.13697986f, 0.12255587f, 0.10664462f, 0.07804070f, 
    -0.04125522f, 0.00042187f, -0.01399016f, 0.08061658f, -0.00365902f, -0.00910411f, 0.06759620f, 0.07015134f, 
    0.05160372f, -0.17525725f, -0.06834108f, 0.02237009f, -0.03794648f, 0.05457000f, -0.08872815f, -0.00818065f, 
    0.04566723f, -0.10829119f, 0.05152989f, 0.14310192f, 0.10713346f, 0.01392714f, -0.09125928f, 0.15637593f, 
    0.03107113f, 0.03827028f, -0.06213709f, 0.04481849f, 0.03946538f, 0.01576292f, -0.16581807f, 0.09700144f, 
    -0.07061364f, -0.14127755f, -0.03896532f, 0.16605981f, -0.03747516f, -0.10625912f, 0.02710722f, 0.08388022f, 
    0.00266943f, -0.04588975f, -0.02619275f, -0.02000394f, -0.03195828f, -0.01915895f, 0.04445172f, 0.01319908f, 
    -0.05937604f, -0.08206280f, 0.12261147f, -0.03763208f, 0.09960484f, -0.02953822f, -0.00452269f, -0.08533056f, 
    0.08002047f, 0.08044903f, 0.13237037f, 0.11302639f, 0.05937732f, 0.10273287f, 0.01829270f, 0.00265471f, 
    -0.00907208f, 0.05221373f, 0.08558047f, -0.05940593f, 0.19584030f, -0.11495714f, 0.03810498f, 0.11095513f, 
    -0.00895344f, -0.01700847f, 0.02050014f, -0.08287629f, 0.04588810f, 0.02271146f, -0.01368277f, 0.00404424f, 
    -0.14177525f, -0.13138956f, -0.08422709f, 0.05188841f, 0.02170792f, -0.00381742f, -0.00112989f, 0.01753518f, 
    -0.04280161f, -0.02001133f, 0.01277388f, 0.07277782f, 0.02560264f, 0.09827833f, 0.02357072f, -0.06217231f, 
    0.00359821f, -0.07198863f, 0.07372218f, -0.10145359f, -0.07641508f, 0.02697061f, 0.03713080f, -0.05757982f, 
    -0.03217651f, 0.04745410f, -0.03756382f, 0.04370537f, -0.02232215f, -0.02618192f, 0.07967581f, -0.02270807f, 
    0.10392941f, 0.02989845f, -0.05474391f, 0.07201688f, 0.07413241f, 0.05759520f, 0.10694312f, 0.06252171f, 
    0.02271080f, 0.10776912f, 0.06774141f, -0.05552693f, -0.08242551f, 0.00300506f, -0.13048203f, 0.09178971f, 
    -0.14509155f, -0.17149410f, 0.02306219f, -0.20583978f, 0.00044007f, -0.03859774f, -0.05570736f, 0.05943855f, 
    -0.01868964f, -0.06027052f, -0.02122945f, 0.06122041f, -0.00324237f, -0.03101690f, -0.08732415f, 0.03521586f, 
    0.03023714f, -0.10584223f, -0.07270834f, -0.02752913f, -0.06422482f, 0.05360746f, -0.04516084f, -0.08041890f, 
    0.17364527f, 0.04390526f, 0.07412858f, -0.02287568f, 0.04230187f, 0.05078769f, -0.02675645f, 0.07804240f, 
    -0.00928337f, 0.02422183f, 0.05779259f, -0.04370999f, 0.05923814f, -0.03257875f, -0.04374835f, 0.09560942f, 
    0.06332396f, 0.00860297f, -0.06207607f, -0.03116766f, 0.06936580f, -0.09710916f, -0.05689758f, -0.01039657f, 
    -0.16059175f, 0.00634695f, 0.00623951f, 0.11703081f, 0.01157163f, 0.02021704f, 0.06115577f, 0.02187855f, 
    0.04208437f, -0.01707088f, 0.00329492f, 0.04133689f, 0.21647513f, -0.12373356f, 0.12068912f, -0.02434551f, 
    0.00085785f, 0.03686157f, -0.08467092f, -0.05002131f, -0.00306782f, 0.05734467f, 0.09531335f, 0.00423533f, 
    0.27803496f, 0.03289675f, 0.02307185f, -0.08309674f, -0.00633182f, 0.06423213f, 0.04631809f, -0.06662165f, 
    -0.01574388f, -0.00504944f, 0.01767801f, -0.02239360f, 0.15579385f, 0.04868094f, 0.03364237f, 0.11241253f, 
    0.01670726f, 0.10766911f, 0.00095640f, -0.00441633f, 0.02986565f, -0.05506590f, 0.03473811f, 0.03491173f, 
    0.03559019f, -0.02198924f, 0.12694795f, 0.10348646f, 0.08158904f, -0.11821411f, 0.06339663f, -0.02365060f, 
    0.00783174f, -0.07426389f, -0.04570611f, 0.06109507f, 0.13573876f, -0.01816101f, 0.12298913f, 0.00376962f, 
    -0.10934134f, 0.01651283f, -0.11367173f, -0.01666932f, -0.01260881f, 0.01357014f, 0.00961054f, -0.01959924f, 
    -0.04644539f, -0.02436321f, -0.06234568f, 0.00618135f, -0.06070090f, -0.05741520f, 0.01227944f, 0.01296510f, 
    -0.10037740f, -0.01973982f, 0.03718486f, -0.10172595f, 0.14131191f, -0.03278784f, 0.03365717f, 0.15410796f, 
    -0.07970268f, -0.07690571f, -0.00490445f, -0.01018089f, 0.02469346f, -0.01203802f, 0.01510900f, -0.11948974f, 
    0.02754484f, -0.03662873f, -0.09815352f, -0.01872254f, 0.19205512f, 0.03760680f, 0.01600431f, 0.06767413f, 
    -0.02766687f, 0.07374185f, -0.08538467f, 0.02753973f, -0.05811301f, 0.07393755f, 0.04827802f, -0.18488371f, 
    0.00439209f, 0.03891756f, 0.07248288f, -0.00417968f, -0.04881679f, 0.12334097f, 0.04172590f, -0.11806774f, 
    -0.14552209f, -0.10672361f, -0.00098095f, 0.02116639f, -0.03385795f, 0.01350348f, -0.04832940f, 0.05760468f, 
    -0.03819120f, -0.08307960f, 0.06911507f, -0.10350869f, -0.16926679f, -0.06358703f, -0.19663018f, 0.00070171f, 
    0.16738874f, 0.02541246f, -0.04718445f, 0.06292759f, -0.04801065f, 0.02529653f, 0.08754546f, 0.02071065f, 
    -0.06092308f, 0.01027732f, -0.20126750f, -0.00276941f, -0.09525370f, 0.02632624f, -0.00010082f, 0.05247803f, 
    -0.02496173f, 0.00423864f, 0.02315996f, -0.06867182f, -0.12883680f, -0.01233862f, -0.07734011f, -0.18918329f, 
    0.07539582f, -0.07505023f, -0.06827368f, 0.02615309f, 0.14173415f, 0.03016583f, 0.11369647f, -0.07303863f, 
    0.12763748f, -0.05883077f, 0.01282628f, -0.05535992f, -0.00214692f, -0.04806288f, -0.04191321f, 0.10986482f, 
    0.00523510f, -0.02863023f, -0.02693851f, -0.03199254f, -0.05550479f, 0.19668992f, 0.15827224f, -0.03025166f, 
    0.03413256f, -0.02668068f, 0.00266251f, -0.08109126f, -0.06905571f, 0.12262126f, 0.09643639f, 0.02314705f, 
    -0.13668355f, -0.11068478f, -0.06904826f, 0.09465556f, -0.00981750f, -0.01239572f, -0.06197976f, 0.09764366f, 
    0.00046012f, -0.00950445f, 0.03074018f, -0.04071570f, 0.27722916f, -0.14611824f, -0.05562662f, 0.11044550f, 
    -0.06128680f, 0.03561386f, -0.03250042f, 0.04177991f, 0.03924398f, -0.01826793f, 0.03289529f, -0.01414240f, 
    -0.09844490f, -0.04477207f, -0.11102358f, 0.00956750f, 0.00765062f, 0.03898571f, 0.01415352f, 0.02486087f, 
    0.08608697f, -0.07947964f, -0.12555292f, 0.08774866f, 0.35882452f, -0.01233040f, -0.00065715f, 0.10968406f, 
    0.03260873f, -0.06800989f, -0.00011152f, -0.04880825f, 0.09475021f, 0.06117906f, -0.01591509f, 0.03450152f, 
    0.28186792f, 0.02645187f, -0.10954522f, -0.05185056f, 0.00026748f, -0.05904112f, 0.07298316f, -0.05148466f, 
    0.01089057f, -0.03534929f, -0.02664736f, 0.07069351f, 0.01625399f, -0.06224142f, 0.11918568f, 0.28405482f, 
    0.11548738f, -0.04261763f, -0.00525201f, 0.03271491f, -0.13068996f, 0.02094413f, -0.12411904f, -0.03544512f, 
    -0.09778235f, -0.20375712f, -0.16440624f, -0.03735601f, 0.02228072f, -0.01372684f, -0.07343769f, 0.17509921f, 
    0.04606905f, 0.02126265f, 0.05085160f, 0.05275173f, 0.00702578f, 0.03442963f, -0.16243213f, -0.08947128f, 
    0.15957510f, 0.01133233f, -0.01438435f, -0.05086052f, -0.02335096f, -0.03892660f, 0.01314572f, -0.00548476f, 
    0.04494775f, -0.02823869f, -0.02584036f, -0.15798749f, -0.00574004f, 0.05822455f, 0.00108092f, 0.02867850f, 
    -0.03636544f, 0.05522460f, 0.01183017f, 0.06102175f, -0.22895636f, -0.07851490f, -0.06852358f, -0.01768366f, 
    -0.05655954f, -0.09677685f, -0.01727599f, -0.00332890f, 0.03455751f, 0.04659178f, 0.01580499f, 0.04478409f, 
    -0.09973859f, 0.13948098f, 0.04813125f, 0.19369708f, 0.03730121f, 0.00662556f, 0.05821752f, 0.03689705f, 
    0.06340679f, 0.08814151f, 0.08472095f, -0.04399704f, -0.06323735f, -0.07346443f, -0.03392734f, 0.08717241f, 
    0.01498247f, 0.00532660f, -0.04578772f, 0.07792868f, 0.07094498f, -0.08694542f, 0.00583583f, -0.02283507f, 
    -0.10354913f, -0.00702926f, -0.05578046f, -0.04255411f, -0.03335071f, 0.02500632f, -0.06232554f, -0.05394572f, 
    -0.02107391f, 0.00351134f, -0.11775057f, 0.13895920f, -0.03329102f, 0.05156342f, -0.04910380f, 0.04178891f, 
    -0.01522654f, 0.00667816f, -0.07072814f, 0.03758387f, -0.03520558f, 0.03403515f, 0.04372853f, -0.04856947f, 
    -0.19348444f, -0.12818763f, 0.00159724f, -0.18475325f, 0.01018324f, 0.03541366f, -0.05882971f, 0.13307646f, 
    0.01118973f, 0.07122123f, 0.01928591f, -0.01771457f, -0.02488859f, -0.04344466f, 0.17453805f, -0.06325434f, 
    -0.05193274f, 0.03137273f, 0.02175398f, 0.08461119f, -0.01630288f, 0.02552112f, -0.01800506f, 0.06039874f, 
    0.09453957f, -0.05441621f, -0.12484579f, -0.20254569f, -0.00174301f, -0.04313086f, 0.05170926f, 0.01484403f, 
    0.03801630f, -0.04248434f, -0.01401033f, 0.04733156f, 0.02679953f, 0.07535098f, -0.07890423f, 0.05120974f, 
    -0.14560446f, 0.08371332f, -0.05752685f, 0.07964610f, 0.04991098f, 0.02760193f, -0.03769090f, 0.04779011f, 
    0.07625629f, -0.07757060f, -0.02954539f, 0.06239793f, 0.03062185f, 0.16695130f, -0.08349687f, 0.11422922f, 
    0.08303472f, -0.06201977f, -0.01492580f, -0.00933984f, 0.10200773f, 0.09683108f, 0.04920740f, 0.07640535f, 
    0.04655921f, -0.01197287f, 0.00502268f, 0.02642547f, 0.04108365f, -0.07021025f, -0.04320958f, 0.02347318f, 
    0.13619497f, -0.21880101f, -0.08411567f, 0.24085470f, -0.07991727f, 0.08227693f, 0.00773532f, -0.05707660f, 
    0.02997242f, -0.04202874f, -0.04538817f, 0.05702855f, -0.32274893f, 0.21567854f, -0.12682487f, -0.20044252f, 
    0.06155982f, 0.01635122f, 0.05661285f, 0.03182379f, -0.00549660f, 0.00306760f, 0.05961930f, 0.01275716f, 
    -0.09853765f, -0.04567246f, 0.07810988f, -0.24726570f, 0.00401882f, 0.00470663f, 0.12501532f, 0.00002621f, 
    -0.09682725f, 0.02773920f, 0.08138685f, -0.01299972f, 0.20708916f, 0.14952797f, 0.02312349f, 0.00160220f, 
    -0.00612472f, 0.01246962f, -0.03885965f, -0.11307929f, 0.01282371f, -0.01707554f, -0.01099672f, 0.04365291f, 
    0.06701373f, -0.00200206f, -0.03087762f, 0.10091353f, 0.00198641f, -0.01190435f, -0.03698098f, 0.11599232f, 
    -0.00191549f, -0.03988529f, -0.01492379f, -0.09519255f, -0.25258812f, -0.00847841f, 0.09818695f, -0.03784595f, 
    0.01882882f, 0.02826468f, -0.02835203f, 0.11627153f, 0.12168986f, 0.02167611f, -0.06239055f, 0.00377420f, 
    0.18402778f, -0.03035233f, -0.08800614f, -0.04173016f, -0.05057117f, 0.03874354f, 0.02705023f, -0.08599203f, 
    0.00299717f, 0.00970731f, -0.05019966f, -0.08385888f, -0.02617277f, 0.13255231f, 0.04623951f, 0.12245248f, 
    -0.01169437f, 0.05093397f, -0.08114255f, -0.07617752f, 0.02097030f, 0.02011116f, 0.01677528f, -0.05053919f, 
    -0.09333924f, 0.06343438f, 0.00391378f, -0.00596096f, 0.08807135f, 0.08358706f, -0.06771682f, -0.07478679f, 
    0.03004587f, -0.02075864f, 0.03303037f, 0.00056181f, 0.22384471f, -0.04465846f, -0.03419793f, -0.22176838f, 
    -0.05226028f, 0.00818809f, 0.07709900f, -0.01111593f, -0.04402963f, 0.04499185f, -0.04210851f, 0.07384765f, 
    0.13786873f, 0.02011376f, 0.00936606f, 0.14388105f, -0.01966911f, -0.14416946f, -0.00784797f, 0.06281926f, 
    0.02256597f, -0.03029332f, 0.07267383f, -0.08767447f, 0.14865127f, 0.07315415f, 0.04401512f, -0.05947575f, 
    -0.16954271f, 0.00570148f, 0.07677098f, 0.04972952f, 0.01454935f, 0.00280851f, -0.00387544f, 0.06388173f, 
    -0.00651766f, 0.01406986f, 0.01298698f, -0.07987478f, -0.07886069f, -0.01791606f, 0.03854840f, 0.04784349f, 
    -0.03212677f, -0.02131382f, -0.05434619f, -0.01804619f, -0.03232165f, -0.07416613f, -0.07301834f, 0.05003731f, 
    0.07636040f, -0.08773735f, 0.00932615f, 0.08564128f, -0.01507099f, -0.04065551f, -0.04253718f, 0.07402342f, 
    0.04836413f, 0.18291421f, -0.16508219f, -0.01028582f, -0.14941086f, 0.02939514f, 0.00499240f, 0.05826682f, 
    -0.08582626f, -0.03744501f, 0.01436853f, 0.06264948f, 0.13764502f, 0.09904203f, -0.00390982f, 0.16356592f, 
    -0.02376366f, 0.07113053f, -0.09590363f, -0.05321671f, 0.06556343f, -0.04917478f, 0.03052514f, -0.03180354f, 
    0.10935049f, -0.06321746f, 0.08686588f, 0.25101680f, -0.03115020f, 0.07074117f, -0.10135747f, 0.10396727f, 
    -0.00542576f, -0.03805699f, 0.00245466f, 0.04987551f, 0.09932517f, -0.05355298f, 0.14983803f, -0.07412618f, 
    -0.07398451f, -0.02265438f, -0.08173420f, -0.03104919f, -0.02410164f, 0.03417069f, -0.09081107f, 0.02548378f, 
    0.16983084f, -0.01208271f, -0.04902307f, 0.29227984f, -0.07076061f, 0.04459132f, -0.00241972f, 0.06445576f, 
    -0.02469813f, 0.06559153f, -0.04632667f, -0.01880378f, 0.08011117f, 0.06821958f, -0.08084575f, 0.17072709f, 
    -0.02456742f, -0.00415824f, -0.00711719f, -0.06198782f, -0.00261231f, 0.01156889f, 0.05134971f, -0.02991721f, 
    0.05580103f, 0.13538022f, -0.06899647f, -0.03102776f, 0.01822989f, -0.05083728f, 0.02537004f, 0.10463510f, 
    -0.05002936f, 0.00654014f, 0.00030609f, -0.04822326f, 0.03203913f, 0.08055098f, -0.02559598f, 0.23914441f, 
    -0.15173563f, -0.00713593f, 0.04115706f, -0.06797096f, -0.01697501f, -0.06659098f, -0.00308988f, -0.09168971f, 
    0.10656071f, -0.05229259f, 0.03406673f, -0.13295726f, -0.06466919f, 0.05516174f, 0.05179783f, 0.01493617f, 
    0.05470442f, 0.00096164f, -0.01607428f, 0.09495407f, 0.16523626f, 0.05331625f, 0.07403935f, 0.27640763f, 
    -0.06283167f, 0.06425499f, -0.00757835f, 0.05869411f, 0.01574469f, 0.07653012f, 0.01084087f, 0.00371256f, 
    -0.11673078f, -0.02369725f, -0.04923112f, -0.00735558f, -0.16968715f, -0.04000121f, 0.04958458f, 0.07788537f, 
    0.08151642f, -0.01118064f, 0.01455621f, 0.08069161f, 0.12896252f, 0.11624309f, -0.03692554f, -0.34431091f, 
    -0.05623847f, 0.05799692f, -0.08255868f, 0.01146936f, 0.03799052f, 0.04198803f, 0.00311972f, 0.01047545f, 
    0.24593464f, -0.07951879f, -0.02246464f, -0.32275513f, 0.17568152f, -0.07018989f, -0.00454985f, -0.10176333f, 
    -0.01198440f, 0.05152417f, 0.05318321f, 0.02934194f, 0.26956600f, -0.05958547f, 0.12529328f, -0.02525364f, 
    -0.04800712f, -0.01731559f, -0.03650378f, 0.06684492f, 0.02975642f, 0.06220601f, -0.05713943f, -0.01830098f, 
    0.01598042f, 0.03950409f, -0.04278379f, 0.06643323f, -0.02431665f, -0.01095522f, 0.05999841f, 0.02923325f, 
    -0.03424449f, 0.00461355f, -0.01350017f, -0.01097576f, -0.05528441f, 0.08872228f, -0.02958149f, 0.08402483f, 
    0.03694971f, 0.03204188f, -0.12815729f, 0.00278257f, 0.10346878f, 0.07318822f, 0.00442716f, 0.02966736f, 
    0.06017743f, 0.12179393f, 0.11261618f, -0.29174855f, 0.00799080f, 0.07751724f, 0.04588528f, 0.00607008f, 
    0.00379111f, 0.02422404f, 0.09415692f, 0.10966322f, 0.20091403f, 0.00813182f, 0.02662903f, 0.19090363f, 
    -0.16560601f, -0.00145061f, 0.05123816f, 0.08535088f, 0.01750237f, -0.02166151f, -0.00024189f, -0.02629983f, 
    0.18304946f, -0.03471150f, 0.04101875f, 0.28614709f, -0.08576747f, -0.11373932f, -0.02985185f, 0.00683354f, 
    -0.10242964f, 0.00788720f, 0.01866929f, -0.05277222f, 0.03221148f, 0.00917092f, 0.05096082f, -0.15271567f, 
    -0.00068332f, 0.06434730f, 0.02466751f, 0.03114442f, 0.03050192f, 0.04729693f, -0.07025121f, -0.01882858f, 
    -0.02273807f, 0.07257272f, 0.11269953f, -0.14957559f, -0.00991259f, -0.00301314f, 0.03842320f, -0.02142450f, 
    -0.03155316f, -0.06268127f, -0.03276803f, -0.08215728f, 0.15708263f, 0.02698596f, 0.05428484f, 0.25893059f, 
    -0.11738551f, -0.09747492f, 0.02075285f, -0.00521238f, 0.02364196f, -0.00546706f, 0.01233064f, -0.01407897f, 
    -0.04857433f, 0.11081372f, 0.03530387f, -0.12800059f, 0.05921071f, 0.13355613f, -0.07316577f, 0.03661910f, 
    0.01635723f, 0.00032947f, -0.01049691f, 0.03545819f, -0.21362682f, -0.03638151f, 0.22110033f, -0.30334949f, 
    0.04379546f, 0.03746418f, 0.10370080f, -0.04603961f, -0.01324568f, 0.02342056f, 0.03757480f, -0.00652784f, 
    -0.02089044f, -0.02986631f, 0.09355310f, 0.22989711f, -0.14256917f, -0.06667289f, -0.00147695f, 0.02703306f, 
    0.00460742f, -0.00612844f, -0.01273068f, -0.06838957f, 0.10357713f, 0.01382814f, -0.10264093f, 0.16584635f, 
    -0.04652847f, 0.06977797f, 0.02843441f, -0.02795184f, -0.05394987f, 0.02498680f, -0.00167393f, -0.04497227f, 
    -0.22772692f, 0.11209556f, 0.03295704f, 0.14963327f, -0.01896980f, -0.09832122f, -0.02033107f, 0.03091209f, 
    -0.00657448f, -0.01075406f, 0.02475473f, -0.10260793f, -0.10244090f, 0.02317847f, 0.19714946f, -0.08926866f, 
    -0.04546951f, 0.03457045f, 0.02043546f, -0.03371892f, 0.01016298f, -0.04886929f, 0.05206190f, -0.00962775f, 
    0.18537144f, 0.00150493f, 0.14432016f, -0.15286520f, 0.10941920f, 0.01473122f, -0.00255433f, 0.05648207f, 
    0.09320361f, 0.03922723f, 0.01236486f, 0.03581141f, 0.02326281f, 0.01064991f, 0.09397653f, 0.05845162f, 
    -0.13627172f, -0.00473941f, 0.03039586f, -0.03551377f, 0.04586726f, 0.05811331f, 0.00218703f, 0.03210904f, 
    0.06757330f, -0.13070706f, 0.03245796f, 0.16548543f, -0.03195288f, -0.02006405f, -0.05394470f, 0.05336477f, 
    -0.02991441f, 0.11356021f, 0.05422315f, 0.00521212f, 0.03883590f, 0.14666411f, -0.09586798f, 0.20460363f, 
    -0.08879552f, 0.05533922f, 0.01777303f, 0.03355683f, 0.07543883f, -0.08541559f, -0.04744517f, 0.03331422f, 
    0.20267075f, -0.06803007f, 0.14499377f, 0.13623205f, 0.04644175f, 0.07822672f, -0.06873430f, 0.11200360f, 
    -0.09820335f, -0.01400309f, 0.00312451f, -0.02867865f, 0.47948873f, -0.12012048f, 0.12694339f, 0.10972562f, 
    -0.13092910f, -0.05569023f, -0.18203029f, 0.00742471f, -0.04097704f, 0.05200597f, -0.01242571f, 0.00131698f, 
    0.10847842f, -0.08698457f, 0.01167008f, -0.08922290f, -0.10006655f, -0.00816635f, 0.05311960f, -0.04738545f, 
    -0.01053634f, -0.02141638f, 0.06994250f, -0.00878827f, 0.27494237f, 0.12045249f, 0.05123333f, 0.25843433f, 
    -0.06509802f, -0.01749115f, 0.00965623f, 0.01924679f, 0.02469732f, 0.06421246f, -0.01979400f, 0.01676876f, 
    0.10936216f, -0.08198303f, -0.05900847f, 0.05935064f, 0.07161551f, 0.02045175f, -0.02863248f, 0.01932222f, 
    0.01757693f, -0.01269805f, -0.02873391f, 0.04985224f, 0.01758854f, 0.11923319f, 0.05205040f, -0.22279039f, 
    -0.02055098f, 0.01739416f, -0.06821840f, -0.10053421f, 0.03421587f, 0.00960415f, -0.04163923f, 0.01087191f, 
    0.06723889f, -0.11621419f, 0.16665563f, -0.26864049f, 0.09412376f, -0.03624412f, 0.00675928f, 0.00277255f, 
    -0.03831785f, -0.04806798f, 0.07868873f, -0.00852196f, 0.16782026f, -0.07341136f, -0.00345357f, -0.22551012f, 
    -0.06024886f, -0.01353576f, -0.09441780f, -0.06110088f, 0.01543303f, -0.03234544f, 0.01872533f, 0.00616345f, 
    0.07364163f, -0.03700260f, -0.09087924f, 0.28309956f, -0.13147092f, -0.05510373f, 0.04531045f, -0.03031033f, 
    -0.01962661f, 0.00684859f, 0.02159047f, -0.02723069f, -0.09787932f, 0.05016267f, -0.11702438f, -0.03842198f, 
    0.15542464f, 0.03064810f, -0.01649305f, 0.07770184f, 0.01738370f, -0.02287718f, -0.12002783f, 0.07975841f, 
    -0.04409919f, -0.04211739f, 0.10269450f, -0.29755652f, 0.03709036f, -0.00580070f, 0.02492889f, -0.01377078f, 
    0.01555735f, -0.03252475f, -0.07029067f, -0.03447488f, 0.17392045f, 0.17630592f, 0.06554713f, -0.08605599f, 
    0.04332743f, 0.05636273f, -0.04530268f, -0.00353814f, 0.04492203f, -0.01861680f, -0.04288786f, 0.04624406f, 
    0.00854523f, -0.03919124f, 0.04631755f, -0.15987135f, 0.04578240f, -0.01211602f, 0.01446509f, 0.06525163f, 
    -0.01967423f, -0.07021458f, 0.02517058f, 0.01788051f, -0.26992849f, -0.10068081f, 0.11209882f, 0.04529491f, 
    0.00598309f, -0.00769392f, 0.04720000f, 0.07623482f, -0.06796166f, -0.04296029f, -0.02697949f, -0.06880314f, 
    -0.12530483f, 0.11074323f, -0.08608265f, -0.12675920f, -0.01989752f, -0.01706568f, 0.07679167f, 0.08876278f, 
    -0.01138980f, -0.01611113f, -0.01218472f, -0.02032355f, 0.05435548f, -0.00769717f, -0.01445309f, 0.03014248f, 
    -0.08799957f, 0.00876387f, -0.02709795f, -0.00730165f, 0.00205172f, 0.02929913f, 0.03116674f, 0.06935287f, 
    -0.03113502f, 0.06629369f, -0.04121375f, -0.03618213f, -0.00001672f, 0.03620300f, 0.01587149f, 0.04807469f, 
    -0.02678570f, -0.03021009f, -0.00720230f, 0.00619102f, 0.11250997f, 0.10697682f, 0.00065638f, -0.09521613f, 
    0.03279098f, 0.04336260f, -0.01968953f, -0.03417905f, 0.05806494f, 0.03908021f, 0.03029716f, 0.04046536f, 
    0.02724278f, -0.03324993f, -0.01219384f, 0.02323290f, -0.00774336f, -0.03650369f, 0.00876183f, -0.01217788f, 
    -0.02205555f, -0.00860341f, -0.00287110f, -0.03342117f, 0.01003237f, -0.02640003f, -0.00862835f, -0.00933210f, 
    -0.02953824f, -0.03624554f, -0.00145350f, -0.03516151f, 0.01392702f, -0.03834025f, 0.01541177f, -0.01087498f, 
    -0.01968608f, -0.02283617f, -0.01069842f, 0.02913816f, -0.02969084f, -0.02051276f, 0.02707123f, -0.04021416f, 
    0.02579998f, 0.01504703f, -0.00056458f, 0.02515270f, -0.01947006f, -0.00764546f, -0.02531863f, 0.02452522f, 
    0.00701094f, 0.01405586f, -0.01095333f, -0.00626782f, -0.00342383f, 0.00582067f, -0.01390639f, -0.01634185f, 
    0.00639861f, 0.01712864f, 0.01221509f, 0.03000919f, -0.03192877f, -0.00892544f, 0.01209275f, 0.02645309f, 
    -0.03417943f, 0.00386607f, -0.01790341f, -0.02809907f, -0.01452021f, 0.01511125f, 0.01893159f, -0.02651309f, 
    -0.02790821f, 0.01708917f, -0.01198928f, -0.01484037f, -0.00200571f, -0.03399795f, -0.01620029f, -0.03175738f, 
    -0.00522519f, -0.03333122f, 0.01291761f, -0.00151506f, -0.03779921f, -0.01545788f, 0.02557546f, -0.02825268f, 
    0.00101780f, 0.00204959f, 0.02678861f, -0.02314510f, -0.04015687f, -0.00475556f, -0.02947488f, -0.00445578f, 
    0.02737210f, -0.02648942f, -0.00825660f, 0.01419813f, 0.01762460f, -0.03927896f, 0.00820132f, -0.03281835f, 
    -0.02103589f, -0.00220631f, -0.03968175f, 0.02657654f, -0.00520730f, 0.02804093f, -0.02959614f, 0.01591099f, 
    0.02183437f, 0.02216527f, 0.01661888f, -0.02726486f, 0.01788163f, -0.01160782f, -0.02357425f, 0.02942549f, 
    -0.01897494f, -0.00783355f, 0.01829769f, 0.00031723f, 0.01165671f, -0.03913090f, -0.00044876f, 0.02866397f, 
    0.00737690f, -0.02784337f, -0.02580725f, 0.02360731f, -0.02033012f, -0.01616588f, 0.02588430f, -0.01333841f, 
    0.02464163f, -0.00472429f, 0.01185605f, -0.03770219f, 0.01943448f, 0.00606880f, 0.02989697f, -0.01950207f, 
    -0.00382396f, 0.00352598f, 0.00628300f, -0.00680323f, -0.02638328f, -0.02283888f, 0.00328313f, 0.01431304f, 
    0.02047269f, 0.02068973f, -0.03890019f, 0.02074543f, 0.01859886f, 0.00988351f, 0.02627886f, -0.03866770f, 
    -0.03565779f, 0.02455427f, -0.02795622f, -0.01328469f, 0.00211803f, -0.01263573f, 0.01127914f, -0.03037507f, 
    0.00057683f, -0.03915246f, 0.01705307f, -0.02253981f, 0.01570822f, 0.01850658f, 0.00254013f, -0.00734629f, 
    0.01119632f, -0.04075265f, 0.00712597f, -0.03588868f, -0.02678943f, 0.01790471f, -0.00024221f, 0.01749257f, 
    0.00867498f, 0.00965754f, 0.00576938f, -0.03133261f, 0.01133197f, -0.01624321f, -0.01276125f, -0.00800762f, 
    -0.04065668f, -0.00394703f, -0.00526260f, -0.03437810f, 0.01306289f, 0.02321186f, 0.02026122f, 0.00418439f, 
    0.02301101f, -0.02060000f, -0.00074106f, -0.00635489f, 0.00390564f, 0.01471302f, -0.01134120f, -0.01172511f, 
    -0.00493974f, 0.01638737f, 0.00385273f, 0.02402579f, -0.02965208f, 0.02729908f, -0.02018545f, 0.00376767f, 
    0.02592777f, -0.03638606f, 0.01647911f, 0.02500373f, -0.02482465f, -0.02308403f, 0.00334413f, -0.01137260f, 
    0.02567434f, 0.02202658f, 0.01028372f, -0.04017453f, -0.02029141f, -0.01515140f, -0.02717029f, 0.01612816f, 
    -0.00326587f, -0.01476951f, -0.02727981f, -0.03828786f, 0.00556698f, -0.00401156f, 0.00496462f, 0.00521652f, 
    -0.01111906f, -0.04044770f, -0.04173091f, 0.00431662f, 0.00762660f, 0.01698481f, -0.04091311f, -0.03889609f, 
    -0.00375183f, -0.01949584f, -0.02479602f, -0.02103914f, 0.00010125f, -0.00832155f, -0.03739871f, -0.03765549f, 
    -0.00469743f, -0.01160284f, -0.01522017f, -0.03709365f, -0.00899760f, 0.02986931f, 0.02119154f, -0.01869495f, 
    0.00320377f, 0.00068141f, -0.03414210f, 0.02294597f, -0.03104959f, -0.00693263f, -0.02214679f, -0.04134895f, 
    0.00572621f, -0.03690493f, 0.02554029f, 0.01014720f, 0.02284206f, 0.02534695f, -0.03587671f, -0.03309581f, 
    0.01409954f, -0.01635337f, -0.00687587f, 0.00796284f, 0.01934441f, -0.02526626f, 0.01618239f, -0.01424944f, 
    -0.01163163f, 0.01139170f, -0.02221925f, -0.02880667f, 0.02807034f, 0.02628816f, -0.01171486f, 0.00845229f, 
    0.00054764f, 0.00773668f, 0.00389164f, 0.02699156f, 0.01605141f, 0.02052335f, -0.00481244f, 0.00814310f, 
    0.00567618f, 0.01167197f, 0.01683941f, -0.00304751f, -0.00837858f, -0.02180520f, 0.00083419f, -0.03789777f, 
    -0.01233851f, -0.01877728f, 0.00312938f, -0.03801362f, 0.02758753f, -0.00005976f, -0.01738950f, 0.02909918f, 
    -0.02331340f, 0.01320065f, 0.00521997f, 0.02071773f, 0.02897063f, 0.00924375f, -0.00834502f, 0.02669883f, 
    0.02353812f, -0.02272618f, 0.00031256f, -0.02452660f, -0.01860624f, 0.00502926f, 0.02795867f, 0.02562653f, 
    -0.03735831f, 0.02365550f, 0.00890702f, -0.01820193f, -0.02247722f, -0.03011488f, 0.01358465f, 0.00019989f, 
    -0.00999627f, 0.00744330f, -0.02375148f, -0.00054914f, 0.01893458f, 0.00985126f, -0.02496509f, -0.00573307f, 
    0.02260315f, 0.00136332f, -0.01482864f, -0.02224422f, -0.00296371f, -0.02814076f, -0.03460629f, 0.01772358f, 
    0.01427469f, -0.02469611f, -0.03465128f, -0.00361273f, 0.00193376f, -0.00188727f, 0.01540698f, -0.01515772f, 
    0.02861670f, 0.01538686f, 0.02949347f, -0.02501580f, 0.02229607f, -0.01346185f, 0.01357062f, 0.02946086f, 
    0.00387023f, 0.02787822f, -0.01475099f, -0.03632392f, -0.02148490f, -0.02588820f, -0.02386783f, 0.01581510f, 
    -0.03722962f, -0.02481632f, 0.02160486f, 0.02226301f, -0.00100535f, 0.01042371f, 0.01974743f, -0.03305251f, 
    -0.03055545f, -0.01310102f, 0.02697631f, -0.00432575f, 0.01638227f, -0.04165317f, -0.00151730f, 0.00343900f, 
    -0.02298662f, 0.02982174f, 0.00475080f, -0.03673495f, -0.01146138f, 0.00771933f, 0.03512470f, 0.00942296f, 
    0.01325707f, -0.00564282f, -0.00486750f, 0.01100455f, 0.02351719f, -0.03032271f, -0.01484985f, 0.02495168f, 
    -0.03136293f, -0.03581547f, 0.00509897f, 0.00307782f, -0.00350723f, -0.02976526f, -0.01776626f, 0.00932744f, 
    -0.03287739f, -0.02495021f, 0.02868498f, 0.00398900f, -0.00089310f, 0.01994666f, -0.03803490f, 0.01618900f, 
    0.02624367f, -0.01020518f, 0.01484628f, -0.03393840f, -0.00659928f, 0.01898204f, -0.03992299f, -0.00216016f, 
    -0.00081485f, 0.01714218f, -0.00424450f, 0.02502435f, -0.01387540f, -0.03077029f, 0.02448348f, -0.01975291f, 
    -0.01399679f, -0.00440177f, 0.00318461f, 0.00447358f, 0.02464416f, -0.01450057f, -0.00446604f, 0.02907095f, 
    0.01037080f, -0.02345008f, -0.03341951f, 0.02917832f, 0.01735771f, 0.04192636f, 0.00199475f, -0.02018394f, 
    -0.03063915f, -0.03370382f, -0.03815364f, 0.02790834f, -0.01517526f, -0.00747671f, -0.03255209f, -0.04165221f, 
    0.00023082f, -0.01770809f, -0.03726491f, 0.02572390f, -0.01819620f, -0.02770981f, -0.03015368f, 0.00580485f, 
    0.01615283f, 0.02151619f, -0.00773463f, 0.02348695f, 0.01456207f, -0.01451698f, -0.03323736f, 0.01688991f, 
    -0.02389140f, -0.00660145f, -0.03888631f, -0.01271138f, -0.02297143f, 0.00878884f, -0.00595556f, 0.01405507f, 
    -0.02442143f, 0.02816409f, -0.03505522f, 0.02636963f, -0.01799663f, 0.00895920f, -0.00264068f, -0.02186777f, 
    -0.03964823f, 0.02832550f, -0.01114570f, -0.03784638f, 0.02513305f, -0.00423457f, 0.01195853f, -0.02551594f, 
    0.01549716f, -0.03825846f, -0.02458511f, -0.00822146f, -0.00363733f, -0.02277789f, -0.00365202f, -0.00878764f, 
    0.03246628f, -0.02518868f, -0.01938663f, 0.02644437f, 0.01293929f, -0.02661413f, 0.00635361f, -0.04189475f, 
    0.02628333f, 0.02110756f, -0.02964297f, 0.00250053f, -0.02390944f, -0.03221786f, -0.03401451f, -0.02050743f, 
    0.01829007f, 0.02497245f, -0.02177788f, -0.03410645f, -0.02803806f, 0.02415256f, 0.02054153f, 0.01503077f, 
    -0.00468151f, -0.00876643f, -0.01722180f, 0.00445868f, 0.00632125f, -0.02922574f, 0.01446408f, 0.00212668f, 
    -0.02589974f, 0.00834903f, 0.00483946f, 0.02583853f, -0.03066242f, -0.03873206f, 0.00749191f, -0.01488861f, 
    -0.02393899f, -0.01714111f, -0.02509242f, 0.02039153f, 0.00718414f, -0.02540636f, 0.01550356f, 0.01746397f, 
    -0.03900696f, -0.01585281f, 0.01454192f, -0.02450055f, 0.02792787f, 0.01767838f, -0.04142120f, 0.00504491f, 
    -0.00508696f, -0.03989778f, -0.01259774f, -0.00648199f, -0.02185473f, -0.03347161f, -0.01903439f, 0.00976535f, 
    0.01080890f, -0.03713150f, 0.00985271f, 0.02752323f, -0.01920606f, -0.03025844f, 0.02195678f, 0.02025726f, 
    0.01304782f, -0.01202221f, -0.00324768f, -0.01413857f, -0.03157400f, 0.01537907f, -0.03845635f, -0.01227154f, 
    -0.00878731f, 0.00063228f, 0.02055246f, 0.00906128f, -0.00977449f, -0.02887731f, -0.02729145f, 0.01078987f, 
    0.01665859f, -0.03974597f, -0.03811967f, -0.03808026f, 0.01183120f, -0.00717991f, -0.02086746f, 0.01998852f, 
    0.01055198f, -0.00263441f, -0.01765624f, -0.03745319f, -0.03311814f, 0.01550139f, 0.02097112f, -0.02391215f, 
    -0.01155530f, 0.02629971f, 0.01191809f, -0.00846836f, 0.02249696f, -0.01129188f, 0.02018857f, 0.00412300f, 
    0.02535682f, 0.02740888f, -0.03433718f, -0.02280837f, -0.03882826f, -0.02193758f, -0.02015757f, 0.01418561f, 
    -0.02554188f, -0.02656145f, -0.03601339f, -0.00943847f, 0.00555111f, 0.00538713f, 0.02820682f, 0.02274001f, 
    -0.03650392f, -0.01064775f, 0.00125131f, -0.00046533f, 0.01089172f, -0.02339894f, -0.00376767f, 0.02058184f, 
    -0.03622011f, -0.01517469f, -0.02247306f, 0.01489936f, -0.00575435f, -0.02885922f, -0.03728385f, 0.00109899f, 
    0.00034092f, -0.01638133f, -0.01403045f, 0.00001529f, -0.03842188f, -0.00690588f, 0.00622644f, 0.00050646f, 
    0.00071088f, -0.00127086f, -0.03887105f, -0.03142366f, -0.01907216f, -0.03820132f, -0.00723056f, 0.00734313f, 
    0.00555739f, 0.01727014f, -0.02397813f, 0.01836423f, -0.00796919f, 0.00100688f, -0.04165619f, -0.04015169f, 
    0.00237910f, -0.04144056f, 0.00359788f, 0.01769499f, -0.03516021f, 0.00760740f, 0.00070017f, 0.00050058f, 
    -0.01823624f, -0.00772918f, 0.02780517f, 0.02246206f, -0.03126979f, 0.00669507f, -0.03268372f, -0.02739986f, 
    -0.00766097f, 0.02592582f, 0.02621821f, -0.03081066f, -0.00059905f, 0.02878612f, 0.01775027f, -0.04171962f, 
    -0.00732569f, -0.04066877f, -0.02232133f, -0.02042751f, -0.02695231f, 0.00039171f, -0.02042967f, 0.02603791f, 
    0.01379730f, -0.01272212f, -0.02454655f, -0.01684058f, 0.00665424f, -0.03617066f, -0.00287969f, -0.03474576f, 
    -0.01785614f, -0.02034382f, -0.02995985f, -0.00516477f, -0.01842265f, -0.00362387f, 0.00924576f, -0.02404233f, 
    -0.00326265f, -0.00193923f, 0.00262575f, -0.00645986f, 0.00401171f, -0.04176062f, 0.01998292f, -0.02525510f, 
    -0.01556996f, 0.00008315f, -0.04013249f, -0.02327754f, 0.02223773f, 0.01849291f, -0.01113751f, -0.01836062f, 
    -0.02567140f, 0.00179537f, -0.00009412f, -0.03505728f, -0.01615472f, 0.00108437f, 0.00508104f, -0.03344655f, 
    0.01787871f, -0.01960796f, 0.00272637f, -0.01207723f, 0.00388460f, -0.03102050f, -0.02637489f, -0.02373082f, 
    -0.02774469f, -0.03602492f, 0.02846056f, -0.02963251f, -0.02661631f, 0.00978254f, -0.00950901f, 0.02735625f, 
    0.02201077f, -0.02992278f, -0.02353829f, -0.01369124f, -0.03337751f, 0.01686210f, 0.01057654f, 0.00352078f, 
    -0.01064620f, 0.02069570f, -0.00175873f, -0.00051009f, 0.00651346f, -0.04005747f, 0.00680604f, 0.01845110f, 
    -0.02483229f, -0.00108829f, -0.02761380f, -0.02270536f, -0.02024801f, 0.02678074f, 0.00588580f, 0.01863538f, 
    -0.00123510f, -0.02913560f, 0.02735430f, 0.01551859f, -0.01828212f, 0.01220054f, -0.02377422f, -0.00228393f, 
    -0.02695622f, -0.01478978f, -0.00880838f, 0.02809907f, 0.02327579f, -0.03678307f, -0.01422502f, 0.01913299f, 
    -0.04106519f, -0.01872925f, -0.02747124f, -0.01569251f, -0.02764515f, 0.01319898f, -0.01851836f, -0.02687749f, 
    -0.02757599f, 0.02628421f, -0.02850821f, -0.01007522f, -0.01861907f, -0.02533739f, -0.03367802f, -0.02090519f, 
    -0.02429300f, 0.00893884f, -0.01095411f, -0.00430420f, 0.00860566f, -0.02808368f, 0.01324528f, -0.02787922f, 
    -0.01897262f, -0.00865275f, 0.01320075f, 0.01508540f, 0.01448075f, -0.04184821f, -0.02622028f, 0.00168430f, 
    0.01413692f, 0.00126632f, -0.00183956f, 0.02331638f, -0.01004793f, -0.02097849f, 0.01572395f, 0.01964117f, 
    0.02389508f, 0.02722394f, 0.00903208f, -0.00439842f, -0.03386656f, -0.03589381f, -0.00529244f, -0.00430862f, 
    0.02959090f, -0.03173420f, 0.01642184f, -0.02850915f, 0.02016833f, -0.03676185f, -0.03493167f, -0.03618117f, 
    -0.03916718f, -0.03922961f, -0.03993121f, -0.01480492f, -0.01133000f, -0.02424253f, -0.01514974f, 0.02320237f, 
    -0.01860929f, -0.04091718f, 0.01296726f, 0.00356586f, -0.01626279f, -0.02189958f, -0.00040594f, 0.01624687f, 
    0.00777050f, -0.02255030f, 0.00533582f, -0.01278885f, 0.01985752f, 0.01678153f, -0.00539268f, 0.02807516f, 
    -0.01368295f, -0.01983817f, 0.02856101f, -0.03529983f, -0.00369719f, -0.00220725f, 0.01204959f, 0.01075732f, 
    -0.00018985f, 0.00477701f, 0.01522330f, -0.00713328f, 0.00725517f, -0.02964299f, 0.01480480f, -0.00590797f, 
    0.00369505f, 0.01950665f, -0.00033126f, -0.00967927f, -0.03918384f, -0.04017249f, -0.00755923f, -0.02470260f, 
    0.00009994f, 0.01337758f, -0.03075144f, 0.02981930f, 0.01622801f, 0.02295410f, -0.03902232f, -0.02606679f, 
    0.02315731f, -0.01861734f, -0.00265496f, 0.03039824f, -0.01974499f, -0.01909606f, 0.00248107f, 0.02565197f, 
    -0.01256631f, -0.00582679f, -0.01037235f, -0.00263038f, 0.00032015f, -0.03711896f, -0.04062279f, 0.00224977f, 
    0.00358619f, -0.03823850f, -0.00134524f, 0.00417680f, -0.02715161f, 0.02515065f, -0.02783689f, -0.04095595f, 
    0.00455854f, -0.03033747f, 0.01959244f, 0.00906116f, -0.03454237f, -0.02583974f, 0.00213232f, 0.00779841f, 
    0.01762205f, 0.01684983f, -0.02793228f, -0.01990880f, 0.02175765f, 0.02569071f, -0.00725406f, -0.02178739f, 
    -0.02001096f, -0.03236668f, 0.02165822f, 0.01546817f, 0.00180896f, 0.02859313f, -0.02644127f, 0.01960359f, 
    -0.01627098f, -0.04069338f, -0.00756955f, -0.01190065f, 0.01308491f, 0.01003360f, -0.01088879f, -0.03455398f, 
    0.00606753f, 0.02613906f, -0.00895408f, 0.00899173f, -0.04074905f, 0.00677281f, -0.00644270f, 0.02230934f, 
    -0.00276073f, 0.02359486f, -0.01546675f, 0.01639140f, 0.00740345f, 0.01429147f, 0.01402058f, 0.02004618f, 
    -0.03287335f, -0.01175311f, -0.00476345f, -0.03850695f, -0.03349812f, -0.03299486f, 0.00544551f, -0.04062285f, 
    -0.03427805f, 0.01844871f, 0.00595100f, -0.00439773f, -0.01478294f, -0.02217434f, -0.00469882f, 0.00648745f, 
    -0.01012957f, 0.01812584f, 0.02945433f, 0.00108358f, 0.00258601f, -0.03138950f, -0.01375070f, -0.00545033f, 
    -0.02772222f, -0.00929698f, -0.02157679f, 0.02022471f, -0.01816493f, -0.00793013f, -0.00065072f, -0.01599428f, 
    0.02815990f, -0.02985586f, -0.03122495f, 0.01582189f, 0.00035433f, 0.00425634f, -0.03426396f, -0.01955506f, 
    -0.02662169f, 0.01326152f, 0.02516629f, -0.01132997f, 0.00896846f, -0.00956120f, -0.02736873f, 0.02768785f, 
    -0.04123243f, 0.01424761f, 0.01455574f, 0.00333015f, 0.00458052f, -0.00028793f, -0.01113346f, -0.01667996f, 
    0.01889592f, -0.00818083f, 0.02628726f, -0.00141582f, 0.01129378f, 0.02123408f, 0.01330543f, 0.02123369f, 
    -0.03063025f, -0.02336167f, 0.00754033f, -0.02713820f, -0.03266438f, -0.01134517f, -0.02635698f, -0.00300032f, 
    0.00942051f, -0.02959764f, -0.00464197f, 0.01558479f, -0.00767574f, -0.02925920f, -0.01550381f, -0.01342092f, 
    0.02812150f, 0.02079770f, -0.01221563f, -0.03388388f, -0.02433161f, 0.01480654f, 0.00338077f, 0.02840321f, 
    0.02301326f, -0.01973407f, -0.02427134f, -0.01743843f, 0.01512618f, -0.02642824f, -0.03152970f, 0.01776438f, 
    -0.00618834f, 0.00603714f, 0.02297056f, -0.01002384f, -0.03609198f, -0.03558725f, 0.01159714f, -0.03918010f, 
    0.02428577f, -0.00076975f, -0.02841373f, -0.02810960f, 0.00609608f, -0.00062214f, -0.03998145f, -0.03954193f, 
    -0.03682074f, 0.01581954f, -0.04054060f, 0.02001591f, 0.02233441f, -0.01379751f, -0.00550419f, -0.00031025f, 
    -0.00144115f, 0.00838242f, -0.03635218f, -0.02844911f, -0.02739386f, -0.00659493f, -0.03462570f, -0.00883618f, 
    -0.00456605f, 0.00643152f, -0.03659415f, 0.01718247f, 0.02680049f, -0.03350760f, -0.00166625f, -0.00694582f, 
    -0.03465105f, 0.01689161f, -0.02417720f, 0.00215032f, -0.00589524f, 0.02042667f, -0.01525486f, -0.02019680f, 
    0.00736385f, -0.00430541f, 0.00576772f, -0.04092688f, -0.03795603f, 0.00731243f, 0.01352553f, -0.02258851f, 
    0.01415171f, 0.00814810f, -0.02160520f, -0.00000662f, -0.03589993f, 0.00202352f, 0.00209174f, 0.01250358f, 
    -0.04058441f, 0.00899603f, -0.02908171f, -0.02583385f, -0.03984657f, -0.01356100f, -0.03608237f, -0.04007137f, 
    -0.02578369f, 0.00223852f, -0.03621770f, 0.01272410f, 0.01852107f, 0.02090316f, 0.02217280f, -0.03503028f, 
    0.00729607f, -0.01052226f, -0.01302110f, 0.02466435f, -0.00168358f, 0.01331341f, 0.02343359f, 0.01892282f, 
    -0.00123960f, 0.01733894f, 0.00543320f, 0.02117129f, -0.01912356f, -0.03533836f, 0.00185386f, 0.02227913f, 
    -0.00620670f, -0.00635655f, -0.03565170f, -0.00273837f, 0.01373428f, -0.00294624f, -0.01759671f, -0.00198940f, 
    0.02863545f, 0.00700182f, -0.03778753f, -0.01103641f, -0.01130828f, 0.00472355f, -0.02012604f, -0.01170029f, 
    0.01657601f, 0.00655418f, 0.03385332f, 0.01116322f, -0.03295816f, 0.02129224f, -0.04171250f, -0.01344336f, 
    -0.04061548f, -0.00338955f, -0.04143142f, -0.00653162f, -0.00081348f, -0.01493903f, -0.03245015f, 0.00827185f, 
    -0.01777540f, -0.01326053f, -0.03149732f, -0.03031447f, -0.00379850f, -0.02945944f, -0.02281656f, -0.00291285f, 
    0.01195905f, -0.04136933f, 0.00580677f, -0.00863362f, -0.00943275f, -0.03583893f, -0.00905605f, 0.00808398f, 
    -0.03194275f, -0.03414407f, -0.03420315f, -0.00618314f, -0.02733008f, -0.02555355f, -0.02778619f, -0.00985457f, 
    -0.04114454f, 0.02341332f, 0.00908358f, -0.01537917f, 0.00181311f, -0.01901605f, -0.02262564f, -0.03742221f, 
    -0.03942836f, 0.02462568f, 0.01405802f, -0.04097888f, -0.02025170f, 0.00075254f, -0.01051483f, -0.01885835f, 
    0.02225045f, 0.02531702f, -0.01635301f, -0.02966125f, 0.01612727f, -0.02665641f, 0.03402410f, 0.01763972f, 
    0.00697766f, -0.01893940f, -0.00692480f, 0.00960890f, 0.01647665f, -0.00598275f, -0.02626214f, 0.02234058f, 
    0.02364989f, -0.00949628f, 0.02878952f, 0.02147134f, 0.02532845f, -0.03599756f, 0.00135426f, -0.00748328f, 
    -0.02872721f, 0.00210849f, 0.03271823f, -0.00812214f, -0.01725129f, -0.00697947f, -0.02624360f, -0.03428624f, 
    0.02413941f, 0.01484391f, 0.00485659f, -0.02183459f, 0.00187040f, 0.00925701f, -0.01817960f, 0.01785666f, 
    0.00955515f, 0.01090624f, -0.02327287f, -0.01790086f, -0.02749638f, 0.02718002f, -0.02754512f, -0.00322451f, 
    -0.02694317f, -0.00394202f, 0.01388828f, -0.03733343f, -0.03454081f, 0.00476813f, -0.01865938f, 0.02616353f, 
    -0.02445588f, -0.00213911f, 0.01915813f, 0.00617075f, -0.02135267f, 0.01729395f, 0.00802073f, 0.02150556f, 
    0.00699823f, -0.01581044f, 0.02620364f, -0.02583792f, 0.03006427f, 0.02748359f, -0.03586666f, -0.02100832f, 
    -0.01818608f, -0.03560825f, -0.03752022f, 0.01387557f, 0.01554338f, 0.02775399f, -0.01828396f, -0.02128444f, 
    0.02990547f, 0.01408871f, -0.02657776f, -0.02463814f, -0.00668354f, 0.02207155f, -0.00712595f, -0.03021976f, 
    0.02523131f, -0.01086325f, 0.00688587f, -0.02227743f, -0.03352705f, -0.02404644f, -0.03108542f, -0.02582096f, 
    0.01435599f, 0.00538482f, -0.00778639f, -0.00843001f, -0.01099530f, -0.02659909f, -0.03669650f, 0.01792008f, 
    -0.01910865f, 0.02843216f, -0.01247335f, -0.02800189f, 0.00910165f, 0.01969940f, 0.00055784f, -0.01737588f, 
    0.01895338f, 0.02079595f, -0.03138145f, -0.03785798f, -0.02389977f, 0.00226015f, -0.02792117f, -0.00484120f, 
    -0.01568204f, -0.00595011f, 0.01309191f, -0.00105874f, 0.02812424f, -0.03774307f, 0.01075722f, -0.02463625f, 
    -0.04204246f, -0.04062137f, -0.03499668f, -0.01495473f, 0.01351184f, 0.01124968f, -0.00752359f, 0.02830294f, 
    -0.01070477f, 0.00198677f, 0.00431614f, 0.00095099f, -0.03185584f, -0.04148851f, 0.02724643f, 0.00772388f, 
    -0.00470960f, 0.02078086f, -0.03777680f, -0.01373030f, -0.03211277f, -0.00071717f, 0.01690975f, 0.00848536f, 
    -0.04049085f, -0.01471250f, 0.01202110f, 0.00213751f, 0.01883695f, -0.03510314f, -0.01597538f, -0.01087558f, 
    -0.03861986f, 0.02283494f, -0.03439233f, 0.02112300f, -0.00758122f, -0.00114244f, 0.01842070f, 0.02197699f, 
    -0.02189294f, 0.01153941f, -0.01577216f, -0.01961071f, -0.01097316f, 0.02957177f, 0.00281348f, 0.01929162f, 
    -0.01693003f, -0.02008881f, -0.01460798f, -0.00336398f, -0.03972553f, -0.03496715f, 0.00131721f, -0.02484441f, 
    -0.00678934f, -0.00344894f, 0.00999293f, 0.00876238f, 0.00130490f, -0.01986611f, 0.00037108f, 0.02009584f, 
    -0.00698810f, -0.03259217f, 0.00693804f, -0.03944410f, 0.02118191f, 0.00752574f, -0.01914138f, 0.02949033f, 
    0.00350096f, 0.02506576f, -0.02723336f, -0.03780857f, 0.02733677f, -0.03459697f, 0.01615032f, -0.00853838f, 
    0.00555058f, -0.01295320f, 0.00027209f, -0.02539678f, 0.02249797f, -0.03167070f, -0.01046855f, -0.01573511f, 
    0.00360639f, 0.02992630f, -0.01965657f, -0.02571787f, -0.03090233f, -0.03643346f, -0.01138247f, 0.01211941f, 
    -0.00318344f, -0.01633428f, 0.02853030f, -0.04068589f, 0.02851775f, 0.00536006f, 0.01291072f, -0.03524883f, 
    -0.02518732f, -0.02144607f, 0.00011710f, 0.01865348f, -0.02399944f, 0.01098802f, 0.00712265f, 0.00157824f, 
    0.02698027f, 0.00917476f, 0.01855832f, -0.01015674f, -0.01376621f, -0.00388816f, 0.00115264f, -0.00256265f, 
    0.01548050f, -0.00305018f, 0.00795720f, -0.01735239f, 0.02654201f, 0.02662995f, 0.00445662f, 0.00067671f, 
    -0.01999158f, -0.01258842f, -0.02944113f, 0.00416619f, -0.03305469f, -0.00726698f, -0.03581199f, 0.00632804f, 
    0.02643504f, -0.02976743f, 0.00423164f, -0.02751478f, -0.00314962f, 0.00224611f, 0.01883856f, -0.01013486f, 
    -0.01712941f, 0.00284254f, -0.00404043f, -0.00429034f, -0.00317291f, -0.00419379f, 0.00092155f, -0.01363876f, 
    0.12854926f, -0.10764334f, -0.02928857f, -0.10464052f, -0.04651888f, 0.02149985f, 0.02746051f, 0.09873299f, 
    0.16696252f, 0.05569902f, -0.06228511f, -0.01008455f, -0.15972431f, 0.08358805f, -0.01055021f, 0.01085937f, 
    0.13299365f, -0.10386017f, 0.00174718f, 0.00328538f, 0.04519173f, 0.04700646f, -0.00840569f, 0.00288180f, 
    -0.26647237f, -0.00007187f, 0.03387582f, -0.11928675f, -0.02159250f, 0.05704628f, 0.01822757f, 0.02383030f, 
    -0.00616404f, -0.00367699f, 0.06636566f, -0.06619793f, -0.15100384f, -0.07407611f, -0.07201832f, 0.02005148f, 
    0.00601799f, -0.06587093f, 0.02327794f, -0.09505373f, 0.04393607f, -0.00245194f, -0.00297075f, 0.00051238f, 
    -0.12004894f, -0.07966195f, -0.03173777f, 0.04606071f, 0.05157889f, 0.07469229f, -0.11361808f, -0.08627335f, 
    0.06125709f, -0.00536628f, 0.04884985f, -0.05933713f, -0.09328803f, -0.11090300f, -0.02457687f, -0.04261211f, 
    0.00311119f, 0.05762520f, 0.02666122f, 0.00673761f, -0.06890405f, 0.02080108f, -0.02595519f, -0.02349656f, 
    0.06408394f, 0.07422630f, -0.08853527f, -0.14139833f, -0.08633361f, 0.09920992f, 0.02410742f, -0.04109709f, 
    0.03277512f, 0.04993150f, -0.06917167f, -0.12277363f, -0.19621277f, -0.11201029f, 0.01435480f, 0.03027996f, 
    0.06191760f, 0.03324886f, 0.04173687f, -0.06790432f, 0.01703327f, 0.05425182f, -0.03330345f, -0.04288965f, 
    -0.25367486f, 0.02885912f, -0.08101672f, -0.21338290f, 0.12432904f, 0.03251812f, 0.02518044f, 0.04650801f, 
    0.03306277f, 0.00881188f, -0.05454332f, -0.03264029f, 0.08706016f, -0.13257615f, -0.10070024f, -0.06955264f, 
    -0.02273198f, -0.06803364f, 0.02559294f, -0.05623137f, 0.06065758f, 0.04653716f, 0.04630928f, 0.10056947f, 
    -0.10494460f, 0.14379549f, 0.16108824f, 0.10857473f, 0.04356414f, -0.05999553f, -0.02511453f, -0.00933306f, 
    0.05787529f, -0.06342071f, 0.08351088f, 0.08838858f, -0.04045583f, 0.07610084f, 0.07875531f, 0.05201931f, 
    -0.12363481f, 0.06073370f, 0.07586286f, 0.10538254f, -0.05212111f, -0.03251500f, 0.11431482f, 0.15913865f, 
    -0.17505969f, 0.08792029f, -0.10386250f, -0.12973092f, 0.01473120f, 0.02141325f, 0.10487889f, -0.01562839f, 
    -0.03232582f, 0.02399182f, -0.07835557f, -0.04638937f, -0.36636806f, -0.09960471f, 0.04316078f, 0.10592240f, 
    0.12437591f, 0.04260546f, 0.00087674f, 0.10112578f, 0.03008113f, 0.01965598f, 0.06066587f, 0.02727508f, 
    0.23042269f, 0.12331342f, 0.15652326f, -0.00104437f, 0.05066056f, 0.04961026f, -0.05048421f, 0.06989216f, 
    0.03851799f, -0.02290594f, 0.02866474f, -0.04470107f, 0.22406232f, 0.12240893f, 0.00896371f, 0.04918708f, 
    -0.09852310f, 0.10751890f, -0.04491824f, 0.05892456f, 0.03771190f, -0.01726286f, 0.01567963f, -0.03949147f, 
    0.04505872f, -0.11432425f, 0.19288242f, 0.03558613f, -0.05810585f, 0.02632972f, 0.02161764f, 0.08809660f, 
    0.00014768f, -0.02787623f, 0.07120480f, -0.04501665f, 0.06284481f, -0.08674961f, 0.01806685f, -0.06079596f, 
    -0.07547075f, -0.00418580f, 0.02650854f, 0.05655786f, -0.02889286f, 0.04958226f, 0.05617447f, 0.07485677f, 
    0.02880087f, 0.12230802f, 0.17409985f, 0.12529640f, -0.12633449f, 0.10504554f, 0.06134177f, -0.05576413f, 
    -0.02593089f, -0.06146881f, 0.05921017f, 0.01675428f, 0.00843400f, -0.04459687f, -0.09403148f, 0.12046790f, 
    0.02298754f, -0.01224612f, 0.08923154f, -0.03441603f, -0.00181017f, -0.13668798f, 0.02690966f, 0.05976822f, 
    -0.04847766f, 0.03536931f, 0.12549639f, -0.05059128f, -0.01427130f, -0.06329667f, 0.04453098f, 0.03588259f, 
    -0.01309102f, 0.04801228f, 0.00679406f, 0.13185415f, 0.12232192f, -0.03629763f, 0.03525231f, 0.27372268f, 
    -0.03267371f, 0.07996333f, 0.04992986f, -0.11445015f, 0.10238438f, 0.01784552f, 0.02323329f, -0.07661162f, 
    0.08396707f, -0.00331007f, 0.16816072f, -0.09617453f, -0.11642113f, -0.02153570f, 0.02146612f, 0.00854903f, 
    0.02664286f, 0.00533190f, -0.01273920f, 0.12160313f, 0.17824173f, 0.11433487f, 0.12661168f, 0.15550299f, 
    -0.10935888f, -0.07231621f, 0.04841617f, 0.06431541f, 0.07982557f, -0.07136346f, 0.03395224f, -0.02009264f, 
    -0.02417036f, -0.18938033f, -0.16175270f, -0.00420218f, -0.02003849f, 0.10174046f, 0.09658884f, 0.00997715f, 
    -0.02696834f, -0.08783769f, -0.04731982f, 0.04695304f, 0.11855622f, 0.22592250f, 0.14334680f, -0.14259924f, 
    -0.00820926f, -0.02045354f, -0.06566375f, 0.08667478f, 0.00045450f, 0.02062436f, 0.01187732f, -0.01431107f, 
    0.01773487f, -0.04651882f, -0.11675063f, -0.06174562f, 0.08769442f, -0.02121639f, -0.06937949f, -0.05083932f, 
    0.07722553f, -0.02679820f, 0.02611555f, 0.07985608f, -0.00747605f, 0.13534468f, 0.25844336f, 0.03546322f, 
    0.01823758f, -0.04174785f, -0.00793017f, 0.01935809f, 0.01245394f, 0.02397869f, -0.00007015f, 0.02088288f, 
    -0.15938470f, 0.05383145f, 0.12556875f, 0.01736458f, -0.02452648f, 0.01353550f, 0.07795434f, 0.04576300f, 
    -0.10341110f, 0.07452617f, 0.02541988f, -0.01730345f, -0.32246801f, -0.04958656f, -0.13164338f, -0.10927337f, 
    0.01715522f, -0.02370152f, -0.01253786f, 0.06093821f, 0.04327483f, -0.01696824f, 0.00221202f, 0.04061245f, 
    0.05352259f, 0.03439910f, -0.06082310f, -0.00296958f, 0.02406811f, 0.08347480f, 0.03047917f, 0.01157005f, 
    0.05982792f, 0.04017553f, 0.12186777f, 0.00255033f, 0.13134871f, 0.20648262f, 0.12646425f, 0.18074791f, 
    -0.01146522f, -0.01994642f, 0.03948879f, 0.04868644f, 0.02992108f, 0.08586848f, 0.01837981f, 0.08014005f, 
    -0.11311144f, 0.09830187f, 0.13282204f, 0.21024404f, 0.01869320f, 0.02610303f, 0.03769374f, 0.04272512f, 
    -0.00800222f, 0.09452928f, -0.01340373f, 0.02146135f, -0.23286533f, -0.08004494f, -0.00453073f, -0.20582981f, 
    -0.00042564f, 0.12641563f, 0.04393401f, 0.02470799f, 0.05693881f, -0.02824950f, -0.06127286f, 0.00624383f, 
    -0.01513636f, -0.04942149f, -0.10054585f, -0.10022683f, -0.02374861f, 0.05142694f, -0.03071980f, -0.00157514f, 
    -0.09850208f, -0.03666591f, 0.02844049f, 0.00633154f, 0.11768769f, 0.09020908f, 0.15736656f, 0.19793256f, 
    0.06350121f, -0.04085783f, -0.01572616f, -0.04184226f, -0.03807054f, 0.11332289f, 0.03298064f, -0.05896636f, 
    -0.24691373f, -0.07605880f, -0.05646886f, -0.11728150f, 0.03891784f, 0.05834977f, -0.10685535f, -0.01048421f, 
    0.07257508f, 0.02051985f, 0.08909747f, -0.00436176f, -0.16088055f, -0.12140132f, 0.11285721f, -0.19854499f, 
    -0.02675286f, 0.04847218f, 0.07646874f, 0.02422832f, 0.05803487f, -0.00993954f, 0.10555667f, 0.07589645f, 
    0.07167645f, 0.09442285f, 0.21573411f, -0.04754813f, -0.10246138f, 0.00441284f, 0.02935940f, 0.07344100f, 
    0.08473928f, -0.02574223f, 0.05488146f, -0.02490397f, 0.13515976f, 0.04619704f, 0.16574688f, 0.13466014f, 
    0.05096461f, -0.00662332f, -0.03672356f, -0.03582231f, 0.06962647f, 0.12851745f, -0.03506670f, -0.09453949f, 
    -0.09219228f, -0.11289296f, 0.07167246f, 0.17465743f, 0.12251414f, -0.01957527f, 0.01342758f, -0.07539677f, 
    0.05290828f, -0.00871696f, 0.06822437f, -0.04122113f, -0.08537354f, 0.07658137f, 0.20903389f, -0.20753433f, 
    -0.09537025f, 0.03658362f, 0.04532148f, 0.00137121f, 0.03466194f, 0.03278032f, 0.04751413f, 0.08715001f, 
    0.07866028f, 0.03154423f, -0.05831641f, -0.06269856f, 0.02372585f, 0.08428081f, -0.06232375f, -0.03907704f, 
    0.01207511f, -0.02540010f, 0.01106022f, -0.04612441f, -0.04895178f, 0.31946513f, 0.17262462f, 0.17436494f, 
    -0.02726823f, 0.04324448f, 0.01687211f, -0.07840449f, 0.06003948f, 0.03397186f, 0.01828394f, 0.05843231f, 
    0.01720315f, -0.00229993f, 0.06368880f, -0.08715370f, -0.03655722f, -0.06657583f, 0.04160128f, 0.09539104f, 
    -0.01825542f, 0.13281408f, 0.10310148f, 0.08277800f, -0.23401026f, 0.07553247f, -0.09488790f, -0.12321808f, 
    0.00606780f, -0.00756880f, -0.06301234f, 0.09303813f, 0.06319758f, -0.06235886f, -0.01663889f, -0.00672390f, 
    -0.02477564f, 0.01790986f, 0.12330578f, 0.05198843f, -0.15218139f, -0.00130628f, -0.01240961f, 0.01169598f, 
    0.00168013f, 0.00750801f, 0.02637313f, 0.05579795f, 0.24149112f, 0.02408317f, 0.14544171f, 0.01508123f, 
    -0.07911532f, -0.10412193f, -0.14098647f, 0.00840657f, 0.00220934f, 0.02416088f, -0.06039137f, 0.05350453f, 
    -0.13473605f, -0.10217838f, -0.01511349f, 0.05551960f, 0.02840579f, 0.10639219f, -0.12674281f, 0.01239182f, 
    -0.02959828f, 0.10487915f, -0.07991594f, -0.00748490f, 0.32189199f, 0.09303790f, 0.15298162f, 0.21896239f, 
    -0.09539365f, -0.10506902f, -0.00182144f, 0.10072776f, -0.06512787f, -0.01251467f, 0.03735231f, 0.12549013f, 
    0.00560120f, 0.02634129f, 0.05034138f, 0.01689381f, -0.05040399f, 0.03875596f, -0.11331653f, 0.07347980f, 
    0.05357388f, 0.06567968f, -0.00667838f, 0.11566257f, 0.06802082f, -0.04457430f, 0.06547559f, -0.08018882f, 
    0.05906239f, 0.00116580f, 0.03259056f, 0.05339732f, 0.14363112f, 0.04256533f, 0.04017379f, 0.08070215f, 
    -0.17647971f, -0.13369770f, 0.09664846f, 0.00503442f, 0.05983720f, 0.07219877f, 0.00076491f, 0.00113012f, 
    0.00444100f, -0.14530903f, 0.06376306f, -0.02135717f, -0.00480456f, -0.07539401f, -0.15594903f, 0.01705141f, 
    -0.01346055f, 0.00883663f, -0.03031283f, -0.12369713f, 0.08199345f, 0.00358786f, 0.05831711f, 0.13951519f, 
    0.10028211f, 0.09846561f, 0.03112769f, 0.11784345f, -0.01522892f, -0.05110311f, -0.05761034f, 0.04341251f, 
    -0.01017022f, 0.01575736f, -0.02511733f, 0.06586869f, -0.25754949f, -0.09030102f, -0.05307298f, -0.07308935f, 
    0.23531078f, 0.14823297f, 0.00768401f, 0.08524191f, 0.02249730f, 0.04412783f, 0.03712180f, -0.01331690f, 
    -0.09322649f, -0.06410925f, 0.10563618f, -0.15239674f, 0.03904365f, 0.05276156f, -0.04939700f, 0.06234496f, 
    0.09425606f, -0.07185069f, 0.01411412f, -0.07068163f, 0.03228289f, 0.06860564f, -0.05149246f, -0.00957479f, 
    -0.00065848f, 0.07717595f, -0.01844145f, -0.06924799f, 0.03112142f, -0.02646316f, 0.00448005f, -0.03103378f, 
    -0.08205148f, 0.10489916f, -0.04610535f, -0.03601671f, -0.00051145f, -0.04969899f, 0.13254231f, -0.01777809f, 
    0.00301003f, -0.14264846f, 0.03153701f, 0.00839960f, -0.29623199f, -0.07810394f, 0.01264434f, 0.12094220f, 
    0.14571303f, -0.10864417f, 0.02108746f, 0.07605238f, -0.09458220f, 0.02792762f, -0.10391487f, 0.13443160f, 
    -0.27818647f, -0.04004577f, 0.03096782f, 0.10351747f, 0.11102523f, 0.03260765f, 0.06433783f, 0.02943475f, 
    -0.06590762f, -0.08000851f, 0.04518375f, -0.07948661f, -0.06809495f, 0.11434212f, 0.01148969f, 0.01196062f, 
    0.03771539f, 0.03971200f, -0.02132400f, -0.01145230f, 0.13765478f, 0.02808297f, 0.00063954f, 0.06658034f, 
    -0.30536181f, 0.07067686f, -0.06284838f, -0.12723845f, 0.08407398f, 0.07559317f, -0.05509849f, -0.01584738f, 
    -0.01040307f, -0.02038472f, 0.08104996f, 0.04453063f, -0.24645756f, -0.07255428f, -0.07640081f, -0.14992079f, 
    0.00851459f, -0.00072379f, 0.07272562f, -0.01487829f, 0.04065912f, 0.08120459f, -0.06553006f, 0.12488887f, 
    0.35565403f, -0.13604687f, 0.18490271f, 0.04864886f, -0.08955555f, 0.04996578f, 0.03368410f, -0.06994266f, 
    0.03304174f, 0.01084548f, -0.08100989f, 0.03060860f, -0.03243989f, 0.27354363f, -0.10829497f, -0.06178853f, 
    0.03763708f, 0.04291602f, 0.03566624f, 0.02198401f, 0.00041797f, 0.00493136f, -0.00481044f, -0.06465670f, 
    -0.04886540f, 0.08302931f, 0.01352971f, -0.05915828f, -0.04911979f, 0.01698581f, 0.05718927f, -0.08284157f, 
    -0.03851495f, 0.01710538f, -0.03334622f, -0.02463820f, 0.17868167f, 0.14565288f, 0.05579073f, 0.03714533f, 
    -0.02151129f, -0.00809096f, -0.00393840f, -0.02123616f, -0.00959444f, 0.05640149f, 0.00584874f, -0.07365959f, 
    0.18076071f, 0.06675846f, -0.05014368f, 0.15430099f, -0.13142331f, 0.00163660f, 0.07949606f, 0.04561760f, 
    -0.00056999f, -0.04535671f, -0.02221237f, -0.01606547f, 0.10476954f, 0.06590813f, 0.02192113f, -0.16912508f, 
    -0.03998645f, 0.03072610f, -0.01963417f, 0.09710730f, 0.03776095f, -0.01697678f, 0.02344154f, -0.06868304f, 
    0.13901144f, -0.08715316f, -0.12671262f, 0.04084893f, -0.07185210f, 0.02212281f, 0.08324633f, -0.08171344f, 
    0.01593129f, 0.02684031f, 0.02977612f, 0.06241919f, 0.01809454f, -0.00170327f, 0.16697796f, 0.01123450f, 
    -0.06880821f, 0.04403428f, -0.09988738f, -0.03461986f, -0.03044914f, 0.03743444f, -0.02101602f, -0.07727912f, 
    0.23796219f, -0.10240539f, 0.10854393f, -0.03542431f, 0.03420259f, 0.06455704f, -0.05869460f, 0.04452197f, 
    -0.04473451f, -0.08118518f, 0.03153086f, -0.01359041f, 0.40373161f, 0.03955921f, -0.23281062f, -0.03567133f, 
    -0.01493388f, 0.03491539f, -0.02825952f, -0.01592144f, -0.02531025f, -0.00129077f, -0.04046918f, 0.09545315f, 
    0.05926431f, -0.04850936f, -0.12334514f, 0.07965924f, 0.04635315f, -0.06778477f, 0.07842668f, 0.02056606f, 
    0.11324634f, 0.12168267f, -0.03804414f, -0.03984258f, 0.11134784f, -0.04145306f, -0.03342944f, 0.17424317f, 
    0.02544455f, -0.02608528f, 0.01388030f, -0.03506968f, 0.14317051f, 0.02169953f, -0.07894610f, 0.06904875f, 
    0.09636282f, 0.01786785f, 0.09528614f, -0.06173705f, -0.09968106f, -0.06432994f, -0.00193548f, -0.00986387f, 
    -0.02288864f, -0.07597549f, 0.04557250f, -0.06043053f, 0.27373725f, 0.04976134f, 0.06061121f, -0.03378783f, 
    -0.02722410f, -0.07683085f, -0.01407675f, 0.08181870f, 0.01478050f, -0.07888657f, -0.05806186f, 0.01759100f, 
    -0.12788604f, 0.03324683f, -0.15393731f, 0.02257579f, -0.02785642f, 0.03061904f, -0.01445093f, -0.08214506f, 
    0.01826330f, -0.00017719f, 0.03572726f, 0.01014253f, 0.27565163f, -0.01869912f, 0.02990683f, 0.06332828f, 
    -0.00684083f, 0.01312558f, 0.08995217f, -0.04587284f, 0.14917774f, -0.05850665f, -0.05308358f, -0.03319836f, 
    0.10806765f, -0.01680193f, -0.07780094f, 0.16041073f, 0.03345753f, 0.04615488f, 0.06090535f, 0.07659357f, 
    0.09297012f, 0.00739085f, 0.01590619f, 0.02847026f, 0.08157118f, 0.04078567f, 0.19564167f, -0.02896002f, 
    0.01059411f, 0.02845171f, -0.08422462f, 0.03201842f, -0.04365797f, 0.02536281f, -0.00749297f, -0.05093497f, 
    0.15502860f, -0.12992950f, 0.02654631f, 0.26985773f, -0.09733066f, -0.00087765f, -0.08062512f, 0.00185805f, 
    0.08070758f, 0.10979136f, -0.07146232f, -0.00614977f, 0.10367781f, -0.05692982f, -0.00363863f, 0.03059089f, 
    -0.15937880f, -0.02408254f, -0.04459931f, 0.03474722f, 0.00986862f, 0.01226119f, 0.04382740f, -0.03411236f, 
    0.06971789f, 0.16544142f, -0.02637941f, 0.10325221f, 0.06603970f, -0.00394549f, 0.08324981f, 0.00813057f, 
    0.00798089f, -0.02044068f, -0.08953289f, -0.11355691f, -0.05988364f, 0.18530427f, -0.16605887f, 0.08867358f, 
    -0.12744854f, 0.05393582f, -0.00640886f, 0.02887468f, -0.05771155f, 0.07325322f, -0.07721566f, -0.02063337f, 
    -0.03733202f, -0.03118051f, -0.00150925f, 0.08285096f, 0.02831135f, 0.03340528f, 0.07341194f, -0.08044665f, 
    -0.01238667f, 0.01659059f, 0.01204560f, -0.00786391f, 0.08038408f, -0.15055674f, 0.11821347f, 0.14378068f, 
    -0.02670964f, -0.05893718f, -0.09712296f, 0.05713863f, 0.06227939f, 0.11132386f, -0.00341185f, 0.01823000f, 
    -0.13857833f, -0.01298293f, 0.04502268f, -0.03758781f, -0.16147515f, 0.00117981f, 0.11494230f, -0.01036097f, 
    0.06396449f, 0.08687975f, 0.11032824f, 0.05826281f, -0.09930250f, 0.03896666f, -0.12457376f, 0.04767762f, 
    0.04388330f, 0.02436995f, 0.06691217f, 0.03760744f, 0.17914888f, 0.04757112f, -0.01514758f, 0.03060724f, 
    -0.01436733f, 0.05141179f, -0.02728544f, -0.04929213f, 0.01014923f, -0.09238812f, 0.06285729f, -0.10462998f, 
    -0.07046641f, -0.01686192f, 0.03705365f, 0.02178960f, 0.07281755f, -0.21209908f, -0.01035779f, 0.16624239f, 
    -0.00776254f, -0.06944741f, -0.04060135f, -0.02475736f, 0.10117336f, 0.05545046f, 0.00399405f, -0.02921293f, 
    0.11041441f, 0.03654155f, -0.06726272f, 0.09607684f, 0.03076442f, -0.02102746f, 0.00419933f, -0.02309489f, 
    -0.00159659f, 0.06934225f, 0.04299526f, -0.02220740f, 0.14112155f, -0.12049310f, 0.04935744f, 0.10166375f, 
    -0.03156804f, -0.06366096f, -0.07138894f, -0.01035756f, 0.03290504f, 0.09558221f, 0.01115054f, 0.08869842f, 
    -0.10643202f, -0.00994325f, -0.04290150f, -0.05460360f, 0.00210248f, -0.03175245f, 0.01903455f, -0.05805415f, 
    -0.03092534f, -0.04435932f, 0.00152717f, 0.03574112f, -0.05179399f, -0.15759401f, 0.03855971f, 0.06754569f, 
    -0.04851545f, -0.10571191f, -0.03627348f, 0.01610743f, 0.06353737f, 0.02076344f, 0.03728031f, 0.03835871f, 
    0.07811752f, -0.04330739f, -0.04362026f, 0.12736879f, -0.00605572f, 0.01017443f, -0.01792829f, 0.01436591f, 
    -0.02736596f, 0.04285261f, 0.02331312f, -0.02053856f, -0.02804382f, 0.06298299f, 0.20285867f, -0.01774533f, 
    -0.07444251f, -0.06755324f, 0.04889454f, -0.04608232f, -0.02236228f, 0.02973997f, -0.05349625f, -0.01426236f, 
    0.16740608f, -0.11407810f, 0.09310841f, -0.03108840f, -0.12255733f, -0.01079902f, 0.04142154f, 0.01301713f, 
    -0.02800846f, -0.06351921f, 0.02950942f, -0.05700950f, -0.03615027f, -0.03830536f, 0.02443301f, 0.10748069f, 
    -0.05153418f, -0.04408465f, -0.03103899f, 0.05460014f, 0.09102910f, -0.03330218f, -0.03262317f, -0.04101484f, 
    0.00859908f, 0.25107175f, 0.05927749f, -0.10460903f, -0.05896538f, 0.00967711f, 0.00814913f, 0.03542092f, 
    0.01424259f, -0.02293403f, -0.00188586f, 0.05465809f, 0.02829070f, 0.06290046f, 0.01704663f, -0.04520146f, 
    0.03467531f, -0.04023113f, 0.01407642f, -0.04374355f, -0.02342788f, -0.11532791f, 0.00889880f, -0.06505267f, 
    0.06611054f, -0.11885644f, 0.04196207f, 0.29325870f, 0.05154351f, 0.00740089f, -0.02955231f, 0.00329936f, 
    -0.03804040f, 0.06267668f, -0.10822410f, 0.04310807f, 0.18781064f, -0.00052258f, -0.00398612f, 0.04535463f, 
    -0.01054247f, 0.00230875f, -0.02267538f, -0.01955185f, -0.02180244f, -0.01172416f, 0.01227650f, 0.00933978f, 
    -0.07848725f, 0.16411088f, 0.09703906f, -0.01405642f, -0.12028443f, -0.06304141f, 0.01345770f, 0.04591414f, 
    0.13575459f, 0.02577916f, 0.08043100f, -0.06570660f, 0.09212752f, 0.14927395f, 0.04598445f, 0.15259726f, 
    0.01985895f, 0.11881813f, 0.01825877f, -0.03508949f, 0.02021949f, 0.00449191f, -0.01969767f, -0.04377031f, 
    0.13277696f, 0.05263656f, 0.04421431f, -0.02790099f, -0.05944228f, 0.00967655f, 0.14283603f, -0.01382141f, 
    -0.04406345f, -0.00438263f, 0.05051874f, 0.02626077f, -0.16157296f, -0.01161021f, 0.00406498f, 0.14972030f, 
    0.01706797f, 0.05082416f, -0.03535125f, 0.00823669f, 0.00863716f, 0.07350493f, -0.06300179f, -0.05617386f, 
    0.17546552f, -0.01153553f, 0.08740830f, 0.15633896f, 0.05012911f, 0.06008279f, 0.06253954f, 0.04060559f, 
    -0.04532678f, 0.07570213f, -0.05121871f, -0.01895492f, 0.41703403f, 0.00295514f, 0.07848353f, 0.11258966f, 
    0.03084922f, 0.05644753f, 0.11965306f, -0.01337490f, 0.15176101f, -0.01276088f, 0.08795844f, 0.05775056f, 
    0.25666901f, 0.02882026f, 0.00137555f, 0.08395892f, 0.11674502f, 0.00982958f, -0.03187958f, 0.06827497f, 
    0.02039205f, 0.09152082f, 0.02379306f, -0.04673124f, 0.21819414f, -0.17628357f, 0.09926482f, -0.03079413f, 
    -0.12967947f, -0.02179931f, 0.02275704f, 0.01923722f, -0.02555165f, -0.01103295f, -0.06278302f, -0.01608672f, 
    -0.00609329f, 0.03012502f, 0.01263666f, -0.00459466f, -0.02270870f, 0.04402848f, 0.06128737f, -0.02686260f, 
    -0.04074021f, -0.01521300f, 0.02059568f, -0.03770753f, 0.15127012f, 0.10973579f, -0.06046621f, -0.02426881f, 
    0.02756665f, 0.05596774f, 0.01095035f, 0.04282874f, 0.05217974f, 0.07199335f, 0.08077754f, 0.09269593f, 
    0.25596294f, -0.07428989f, 0.02602326f, 0.07434136f, 0.10077943f, -0.09433896f, -0.02250680f, -0.02684685f, 
    0.03214179f, -0.05678621f, -0.05211433f, -0.05327254f, -0.16998181f, 0.09544159f, 0.12919953f, -0.14386556f, 
    -0.03600414f, -0.01909604f, -0.01442387f, -0.19841559f, -0.05628753f, 0.01702267f, 0.01177792f, 0.05020946f, 
    -0.21283196f, 0.05104671f, 0.04481611f, -0.09579544f, 0.07569145f, 0.02248015f, -0.01110571f, -0.06094532f, 
    0.05297744f, 0.04401040f, 0.04939038f, -0.02959786f, 0.33033288f, 0.06138940f, 0.02326638f, -0.01384634f, 
    -0.10543833f, 0.00187060f, -0.01019874f, 0.01232121f, -0.00858230f, 0.02195702f, 0.02468122f, -0.01943122f, 
    -0.11498642f, -0.16166396f, 0.02935007f, 0.16020380f, 0.01478495f, -0.03235245f, -0.06831580f, -0.03974206f, 
    0.04848769f, 0.00561655f, 0.06279690f, -0.02706480f, 0.24254648f, 0.06629834f, -0.04626099f, -0.15363398f, 
    -0.05441805f, -0.04066284f, 0.05979906f, 0.10630175f, 0.00437444f, 0.05108912f, -0.08831916f, -0.04676527f, 
    -0.08388103f, 0.04427234f, 0.01607963f, -0.12768918f, 0.07770376f, -0.09720589f, 0.06545573f, -0.03378515f, 
    0.06990070f, 0.01400798f, 0.01548918f, -0.00234848f, 0.17740607f, 0.14988978f, -0.06827736f, 0.04060250f, 
    -0.01201348f, 0.00482445f, -0.01721879f, 0.05542622f, -0.05229837f, 0.01611907f, -0.01846030f, 0.04313511f, 
    0.07950860f, 0.02286493f, -0.15004830f, 0.05142417f, 0.04469763f, -0.01175940f, -0.07714150f, -0.02568322f, 
    0.02412856f, 0.00599106f, -0.03378237f, 0.00029843f, -0.09381012f, 0.08132280f, 0.13265878f, -0.17529868f, 
    -0.04581022f, 0.00213711f, -0.00312532f, -0.00323145f, 0.00152742f, 0.05569311f, 0.08115241f, 0.00944502f, 
    -0.17209846f, 0.10130798f, -0.15647015f, -0.04201009f, -0.00113544f, 0.01423782f, -0.02828464f, -0.01672383f, 
    0.06658735f, 0.02033076f, -0.03273262f, -0.06010583f, -0.13881750f, -0.06047647f, 0.07445693f, 0.08048838f, 
    -0.03001561f, -0.02914895f, 0.00966391f, 0.02358397f, -0.11106683f, 0.06543744f, -0.06681095f, 0.01891940f, 
    0.12409315f, 0.08632702f, 0.00962787f, -0.07351240f, 0.01752331f, -0.04120769f, 0.03672751f, -0.00171746f, 
    0.05160315f, 0.05198091f, 0.04826546f, 0.05004039f, 0.19272368f, 0.09733463f, 0.08352609f, -0.03317988f, 
    -0.13079417f, -0.00744887f, 0.02131112f, 0.02523479f, 0.01062053f, 0.07931023f, 0.07827180f, -0.00971666f, 
    0.21386498f, -0.07109638f, 0.03436080f, -0.01314936f, -0.12305039f, -0.03874442f, 0.13755478f, 0.00388453f, 
    -0.09880420f, -0.07296786f, 0.12914470f, 0.02375825f, 0.06730049f, 0.03291345f, -0.05597594f, -0.10690448f, 
    0.04558705f, -0.01186375f, 0.00921715f, 0.03877393f, -0.00578894f, 0.00420390f, -0.02386863f, 0.01909101f, 
    -0.10096067f, 0.16296574f, 0.00255187f, 0.13299213f, -0.04619500f, 0.05463656f, -0.03531021f, -0.11796591f, 
    -0.06754170f, -0.07452171f, 0.00869442f, -0.03670417f, 0.06027068f, 0.10584572f, 0.12671214f, 0.12527390f, 
    -0.04814743f, -0.13628808f, -0.00472526f, 0.06769513f, 0.00887473f, -0.07593787f, 0.06741419f, -0.00237857f, 
    -0.01489315f, 0.05402251f, 0.09447046f, 0.15846148f, -0.03923543f, 0.06616500f, 0.00066356f, -0.01129374f, 
    0.06376359f, -0.02636920f, 0.04713225f, -0.08949610f, 0.26583228f, -0.05717930f, 0.10395589f, -0.06970209f, 
    0.02037145f, 0.01984682f, -0.00160353f, -0.05443161f, -0.00309911f, -0.01320800f, 0.04404737f, 0.11419227f, 
    0.12753727f, 0.05146160f, 0.09190974f, -0.02825585f, -0.17260757f, 0.01971080f, 0.03300905f, 0.04572938f, 
    0.05764464f, 0.03564936f, -0.11005615f, -0.12541220f, 0.13714202f, -0.04992764f, 0.14273697f, 0.07135484f, 
    -0.10199471f, -0.06358781f, -0.04061657f, -0.05051193f, 0.05403461f, 0.02208478f, -0.00209031f, -0.02603211f, 
    0.11075612f, 0.05553835f, -0.01251922f, -0.03418323f, -0.16961026f, -0.03120399f, -0.03154705f, 0.04222920f, 
    0.04046643f, 0.03541481f, -0.09373084f, 0.06160034f, -0.00881184f, 0.14829627f, -0.00545256f, -0.11082710f, 
    0.02925894f, -0.06129083f, -0.04488241f, 0.13278095f, 0.02726213f, -0.03828066f, 0.05473115f, 0.06085941f, 
    -0.22610693f, -0.23728266f, -0.09082256f, 0.05706300f, 0.12088124f, 0.11571843f, 0.05508357f, 0.01604154f, 
    -0.06349179f, 0.04994050f, 0.08249122f, 0.12486267f, -0.18081674f, -0.02975126f, -0.08744808f, 0.11449145f, 
    0.09150025f, 0.00734432f, 0.01450932f, -0.01250899f, -0.00026252f, 0.00487903f, -0.00828087f, -0.06736272f, 
    0.24696814f, 0.21279903f, 0.19233404f, 0.04612917f, 0.00071229f, 0.01847740f, -0.06646974f, 0.01103585f, 
    0.08516967f, -0.04997194f, 0.00194572f, 0.09826544f, 0.37497503f, 0.08646108f, 0.24779363f, 0.06935487f, 
    -0.04630909f, -0.01233414f, -0.10105393f, 0.08454624f, -0.08923553f, -0.06863018f, 0.02383352f, 0.06549133f, 
    -0.08537159f, -0.28665322f, -0.09712683f, 0.02324205f, 0.05195305f, 0.11239611f, -0.04424795f, -0.03512786f, 
    -0.01050560f, -0.04177125f, 0.05734549f, -0.05386443f, 0.09809222f, -0.02967198f, -0.06727525f, 0.03784413f, 
    -0.03273779f, -0.06314460f, -0.01062492f, 0.01263214f, -0.03434101f, 0.02992484f, -0.21306375f, -0.05097146f, 
    0.12443891f, -0.08148411f, -0.03751091f, 0.01066973f, -0.04061133f, -0.12597917f, 0.05406451f, 0.00107989f, 
    -0.02382992f, 0.02673876f, 0.06890000f, -0.00896142f, -0.06882954f, -0.04259106f, 0.04194679f, 0.02828500f, 
    -0.04529917f, 0.00062762f, 0.06904519f, -0.00463435f, 0.03340904f, 0.01765882f, 0.02980460f, -0.13073693f, 
    -0.08945691f, 0.00739941f, 0.15706781f, 0.10743378f, 0.08727930f, 0.03341246f, 0.02625191f, -0.04814154f, 
    -0.00544997f, 0.01978097f, 0.01416145f, -0.12511922f, 0.22278576f, -0.13990024f, 0.10399519f, 0.11206824f, 
    -0.04939428f, -0.06235160f, 0.07171229f, -0.06239600f, 0.07252833f, -0.01515582f, 0.04443737f, -0.03462328f, 
    -0.21112992f, -0.16757050f, -0.03449331f, -0.00312106f, 0.10908835f, 0.04223875f, 0.07855088f, -0.01883702f, 
    -0.03782702f, 0.00431134f, 0.05299689f, -0.01722636f, 0.09444746f, -0.02891920f, -0.09321581f, -0.02075299f, 
    0.06098013f, -0.05336156f, 0.03013647f, -0.04804832f, -0.00725050f, 0.04093187f, -0.07707898f, 0.04956951f, 
    -0.09671894f, -0.11019619f, -0.06697364f, 0.07696457f, 0.17944647f, 0.01462522f, 0.12435972f, 0.00988760f, 
    0.00707090f, 0.03056125f, 0.03895385f, 0.12840180f, -0.01547348f, 0.04762262f, 0.00038080f, 0.00865919f, 
    0.06132527f, 0.03561757f, 0.07213789f, -0.09791802f, 0.01949291f, -0.00825679f, -0.06411558f, 0.00545416f, 
    0.21117750f, -0.11259226f, 0.10581400f, -0.07515877f, -0.01211124f, 0.07905092f, -0.01033596f, 0.08461870f, 
    -0.06915104f, 0.01031488f, -0.00295944f, -0.02353996f, -0.09294364f, -0.02111070f, -0.02479976f, 0.06891595f, 
    0.09638111f, -0.01411364f, 0.03462566f, -0.08441905f, -0.01499689f, 0.08573748f, 0.08525079f, -0.01039624f, 
    0.17404279f, 0.12719646f, 0.03440817f, 0.15528122f, -0.07331057f, 0.02883518f, 0.00168443f, 0.04579844f, 
    0.07359894f, -0.00440718f, 0.02575498f, 0.02501499f, -0.18922630f, -0.07268877f, -0.13204968f, 0.17111333f, 
    0.09963957f, 0.05052887f, -0.02204416f, -0.05065744f, -0.06120357f, -0.00285755f, -0.04379382f, -0.06880402f, 
    -0.23895483f, -0.09456857f, -0.03458059f, 0.03229533f, -0.01012564f, -0.04116585f, 0.09538438f, -0.01874544f, 
    0.06948084f, 0.03320266f, 0.06935331f, 0.03109836f, 0.41217259f, -0.06908088f, 0.15204526f, 0.02286487f, 
    0.00915112f, 0.02848008f, 0.02728494f, -0.05421292f, -0.07014243f, 0.02133079f, 0.03234978f, 0.03024462f, 
    0.03802557f, 0.08939012f, -0.11954127f, -0.09886848f, -0.08352929f, -0.07014177f, 0.00055865f, -0.11698636f, 
    0.06396837f, 0.02329927f, 0.04788159f, -0.05022799f, -0.13591430f, -0.03471361f, -0.00330692f, 0.05422563f, 
    0.03939835f, 0.04532996f, -0.06532743f, -0.08519450f, 0.03667958f, -0.00810436f, 0.09808837f, 0.10165387f, 
    -0.17370425f, -0.07598270f, -0.08874591f, 0.13147518f, 0.15028140f, -0.00029635f, 0.05079709f, -0.03704992f, 
    -0.10722043f, 0.01959730f, -0.03061215f, -0.06017765f, 0.15394892f, 0.08488578f, 0.25540572f, 0.19332239f, 
    -0.09606604f, 0.07989388f, 0.02477897f, -0.07598041f, -0.04808218f, -0.03871272f, -0.10833229f, 0.07377396f, 
    0.26287600f, 0.10549223f, -0.01378275f, -0.00794274f, 0.05404948f, -0.06408443f, -0.05096385f, 0.05795620f, 
    -0.08374858f, -0.09139609f, 0.05931219f, -0.06215296f, 0.00058654f, -0.07890211f, -0.07679095f, 0.03495484f, 
    -0.00664620f, -0.02045415f, -0.02122047f, -0.04580788f, 0.00323739f, -0.03324623f, 0.04253906f, -0.05245360f, 
    -0.04255993f, 0.04224573f, 0.02611174f, -0.07471202f, 0.03532830f, 0.02521485f, 0.01271145f, -0.01028495f, 
    0.02048277f, 0.06385664f, 0.01265193f, 0.12036001f, 0.04896265f, 0.21967553f, -0.06455935f, -0.06211911f, 
    0.04981727f, -0.01390708f, -0.05707072f, -0.01542715f, 0.03578270f, 0.09369855f, -0.00238706f, -0.15258861f, 
    -0.18779944f, -0.18650801f, -0.02297676f, 0.01816796f, 0.03968910f, 0.06198177f, 0.01583054f, 0.03452804f, 
    0.02123459f, -0.08537677f, -0.00867890f, -0.01660047f, -0.14044282f, -0.04854349f, -0.05178214f, 0.04949882f, 
    0.17363302f, -0.03106762f, -0.03707624f, -0.00666216f, -0.00098052f, 0.10751503f, 0.04104134f, 0.00987539f, 
    0.20044911f, -0.06724076f, -0.00850641f, -0.00267916f, -0.07224247f, 0.00512270f, 0.02953683f, 0.14046581f, 
    0.01086699f, -0.00449931f, -0.04809056f, -0.15238389f, -0.02735062f, 0.02618401f, -0.09776353f, -0.11044739f, 
    0.11038028f, 0.00920716f, 0.06926200f, -0.01447657f, 0.08525349f, 0.05517284f, -0.00259050f, 0.04147832f, 
    0.16595943f, 0.21677835f, 0.02748107f, 0.10802948f, -0.09759694f, 0.07456577f, -0.03476747f, 0.03303362f, 
    -0.03152048f, -0.03605600f, -0.04515240f, -0.07984872f, -0.11266587f, 0.22348148f, 0.09736001f, 0.05666354f, 
    0.05346766f, -0.00804109f, 0.01050972f, -0.03593579f, -0.02317996f, 0.13862436f, 0.01114375f, 0.01010976f, 
    -0.10338280f, -0.09058648f, -0.03089061f, 0.03943408f, 0.05016303f, 0.06783824f, 0.02229109f, -0.04172152f, 
    -0.04549108f, -0.06375519f, -0.04235539f, -0.00670043f, 0.62993079f, -0.14415447f, 0.12112985f, -0.00381730f, 
    -0.02296323f, 0.03293541f, -0.04336809f, 0.12056030f, 0.02245799f, 0.08696163f, -0.14487074f, 0.00477445f, 
    0.10761018f, -0.00255280f, -0.13834490f, -0.11383177f, -0.01227896f, 0.05225106f, -0.01802825f, -0.06331007f, 
    0.06657404f, -0.04413854f, 0.03619264f, -0.05519613f, 0.21052793f, 0.01304188f, 0.00816877f, 0.11008380f, 
    0.03812836f, -0.07914270f, 0.09053349f, -0.04304535f, -0.01244961f, -0.00020030f, 0.02551014f, 0.02921245f, 
    -0.04550486f, 0.13281098f, -0.04885506f, 0.04411469f, -0.02766356f, 0.09817671f, 0.02750815f, 0.04408460f, 
    0.03686240f, -0.04681430f, -0.09063772f, 0.00107908f, -0.05674033f, -0.12235980f, 0.07809539f, 0.03832415f, 
    0.20286001f, -0.00873544f, -0.01633676f, 0.02547952f, -0.15912896f, -0.01524098f, -0.06160438f, -0.02101000f, 
    -0.07993911f, -0.12571955f, -0.03333481f, 0.01275452f, -0.05176776f, -0.00485440f, 0.02939991f, 0.10335489f, 
    -0.02415123f, 0.04202020f, 0.02554665f, 0.00684640f, 0.11003067f, 0.04651978f, 0.01782312f, -0.03663284f, 
    0.07525180f, 0.02347209f, -0.01316025f, 0.06598517f, -0.03648993f, -0.01134860f, 0.03401024f, 0.01265601f, 
    -0.14016549f, 0.06400166f, 0.00640584f, 0.01663092f, -0.00076292f, 0.07301743f, -0.06558363f, 0.01329099f, 
    0.06780390f, 0.00815503f, -0.02111756f, 0.01190890f, 0.08005279f, 0.21107294f, -0.07669280f, 0.07877042f, 
    -0.04678681f, -0.02879116f, 0.04274489f, 0.09131233f, 0.02309113f, -0.02607481f, 0.07568657f, 0.08061823f, 
    -0.19682398f, 0.02861322f, -0.00251386f, 0.16699708f, 0.05574302f, 0.00343076f, 0.05802958f, 0.04323670f, 
    -0.00037370f, 0.13869254f, 0.07376453f, -0.04211698f, 0.07136465f, -0.06292312f, 0.17770758f, 0.04403138f, 
    -0.09731109f, -0.00755982f, -0.03761232f, 0.04950824f, 0.00246337f, -0.10074107f, 0.01681485f, -0.01813127f, 
    -0.10561868f, 0.07519641f, -0.07127338f, 0.08256309f, -0.01862814f, 0.02398614f, -0.14316739f, -0.05521132f, 
    -0.03104258f, 0.01955003f, 0.00634872f, 0.05677697f, 0.05469826f, 0.17825326f, -0.05455130f, 0.08577367f, 
    -0.02447818f, -0.01973595f, -0.00555777f, 0.05681551f, -0.09794799f, -0.00846641f, 0.03646470f, -0.05636922f, 
    -0.00595506f, 0.16644049f, -0.02498101f, 0.00832428f, 0.02851707f, -0.00722035f, -0.04997417f, 0.18346430f, 
    0.02391123f, 0.01492858f, 0.06681767f, 0.02393010f, 0.08654275f, 0.03137848f, 0.18511687f, 0.04371247f, 
    0.00313605f, 0.05784279f, -0.04989091f, -0.02526022f, -0.11192475f, -0.03380843f, -0.06708318f, 0.06435152f, 
    -0.22703469f, -0.14957055f, -0.06258548f, -0.10321985f, 0.06481674f, -0.03476404f, 0.07717242f, -0.01362172f, 
    -0.01500768f, 0.04608463f, -0.05782676f, -0.09396925f, -0.09664752f, 0.07657921f, 0.00681911f, 0.03067760f, 
    -0.09805793f, -0.00892551f, -0.03391896f, 0.02643269f, 0.06547886f, -0.01480501f, -0.03801453f, 0.03745860f, 
    -0.04122061f, 0.03616528f, 0.13462855f, 0.12944262f, -0.01249606f, 0.15025276f, -0.05493621f, 0.03583679f, 
    0.06160143f, -0.10883610f, 0.05631007f, -0.00531462f, 0.11156891f, 0.07441022f, 0.12921470f, 0.13158199f, 
    -0.10879154f, -0.07955304f, 0.03297422f, 0.00415363f, 0.00828263f, -0.01651632f, -0.04227848f, -0.00809272f, 
    0.01398060f, -0.00950941f, 0.02799007f, -0.00136165f, -0.03870402f, 0.00296426f, -0.03356669f, 0.00169722f, 
    -0.00273802f, -0.02521355f, -0.00962801f, 0.01776833f, -0.04007986f, -0.03297896f, 0.00645852f, 0.02586830f, 
    0.00636927f, -0.04092045f, 0.01043575f, -0.00611864f, -0.03226529f, -0.01526920f, -0.01095182f, 0.00235358f, 
    0.00168819f, 0.00269053f, -0.03980904f, -0.00197571f, -0.00643793f, -0.03651013f, -0.00494415f, -0.02807531f, 
    -0.02789183f, 0.00393129f, 0.02273216f, 0.02937654f, -0.03702173f, -0.00798125f, -0.00568017f, -0.02195475f, 
    -0.03824999f, 0.00906576f, -0.00316054f, 0.02507287f, -0.01300877f, -0.02725231f, 0.00489648f, -0.03943932f, 
    0.01348561f, 0.01596890f, -0.00380182f, 0.01715467f, -0.01051902f, 0.02614684f, -0.00810638f, -0.03747465f, 
    -0.02795200f, -0.03404827f, 0.00717690f, 0.01506599f, 0.00445280f, -0.03404193f, 0.00589790f, -0.02534850f, 
    0.02208746f, -0.00611325f, -0.03093127f, -0.01931952f, 0.01842616f, -0.00981236f, -0.02774528f, -0.02310209f, 
    -0.02203850f, -0.03458420f, 0.00096423f, 0.01389013f, -0.01637277f, 0.02085965f, 0.02126762f, -0.02922772f, 
    -0.02350591f, 0.02278540f, -0.02920349f, -0.00557715f, -0.03750943f, 0.01789012f, -0.02253898f, 0.02223349f, 
    -0.03122381f, 0.01173014f, -0.02870212f, 0.01016213f, -0.01215653f, 0.00708379f, -0.00096138f, -0.01315917f, 
    -0.00040200f, -0.00602010f, 0.01112199f, -0.02725385f, -0.03579359f, -0.01199630f, -0.04118470f, 0.02292191f, 
    -0.01066280f, -0.00172532f, -0.00155097f, 0.00336866f, -0.04048248f, -0.03520621f, -0.03023991f, 0.00940217f, 
    0.02135440f, 0.01532075f, -0.00584142f, -0.00747541f, 0.02050247f, -0.02321665f, -0.02518978f, 0.02100677f, 
    -0.00650534f, -0.01035835f, 0.01770664f, -0.03282867f, 0.02034982f, -0.02944328f, -0.03065055f, -0.03191038f, 
    -0.00227536f, -0.01938189f, -0.02638080f, -0.02693839f, -0.01330065f, -0.04032450f, 0.02512665f, 0.02721830f, 
    -0.04126951f, -0.02359874f, 0.01374492f, -0.01570284f, -0.03312903f, 0.01608741f, -0.00341982f, 0.00015630f, 
    -0.02261037f, -0.01179383f, -0.00803886f, 0.01057676f, -0.03801658f, 0.00767442f, -0.00005728f, -0.00923560f, 
    -0.00409564f, 0.00606249f, -0.03064064f, -0.04145389f, -0.02217553f, -0.01800613f, -0.02833305f, -0.01813409f, 
    0.01426610f, 0.02538548f, 0.00462776f, 0.02190406f, -0.00698704f, -0.03491879f, -0.01511715f, -0.01844516f, 
    0.02681642f, -0.00031426f, 0.00117842f, 0.02724477f, -0.03241950f, -0.02352145f, 0.02213706f, 0.00245454f, 
    0.02938073f, 0.01921218f, -0.01809752f, 0.02363857f, 0.02054302f, -0.01188919f, -0.03053417f, 0.01557377f, 
    0.02654880f, -0.00488325f, -0.02445626f, 0.00321335f, 0.01213328f, 0.00909301f, -0.03189263f, -0.00149744f, 
    -0.01532261f, 0.00338609f, 0.00827522f, -0.03824201f, -0.00784879f, -0.01035100f, 0.00664133f, 0.02923160f, 
    -0.03308260f, 0.00090517f, 0.00402539f, 0.01494051f, 0.01690776f, -0.02322444f, -0.01104237f, 0.00620244f, 
    0.00813263f, 0.01243330f, -0.03930296f, 0.01160671f, -0.03992918f, -0.01636624f, -0.03134036f, -0.01529719f, 
    -0.03276291f, -0.01477125f, 0.01297339f, -0.04040715f, 0.00136591f, -0.03841214f, -0.01705500f, -0.02561704f, 
    -0.01866170f, -0.03380424f, 0.00385851f, 0.02932111f, -0.02463397f, 0.02545456f, -0.00062612f, -0.02215716f, 
    -0.02676004f, -0.01817221f, -0.02608093f, 0.01117968f, -0.01166523f, 0.02204235f, -0.00536639f, -0.04060847f, 
    0.02857535f, 0.02496993f, -0.01063207f, -0.00477870f, 0.00523141f, 0.01053201f, -0.02810668f, 0.02879695f, 
    0.00229376f, -0.03212682f, -0.01134182f, -0.02203842f, -0.01409299f, -0.03598876f, 0.01479121f, 0.02007816f, 
    -0.02460096f, -0.02427527f, 0.01517710f, -0.03432539f, 0.01952459f, -0.00016372f, 0.02246476f, 0.01176372f, 
    0.01688725f, -0.03628529f, -0.03603404f, -0.03830853f, 0.02939543f, -0.00587480f, -0.01977758f, -0.03194344f, 
    0.02673990f, -0.00555645f, -0.04168400f, 0.01994643f, -0.03578247f, 0.01738774f, -0.00887727f, 0.00915542f, 
    0.02406644f, -0.02873093f, -0.00380653f, -0.00422745f, 0.00689808f, 0.00821646f, 0.03357584f, -0.01886581f, 
    -0.02621987f, 0.01024306f, 0.00002054f, -0.00311871f, -0.01026697f, 0.02746047f, -0.01108489f, -0.03757009f, 
    0.02131766f, 0.00312716f, -0.02451668f, 0.02292955f, 0.02521808f, 0.01879909f, -0.00370876f, 0.00751400f, 
    -0.00118428f, -0.03993459f, -0.00840927f, -0.01841086f, -0.00890234f, -0.01674712f, 0.02873468f, -0.02443940f, 
    -0.02559824f, 0.00132404f, 0.01028645f, -0.02034166f, 0.00874189f, -0.01628423f, -0.03225411f, 0.00577410f, 
    0.00681678f, -0.02945845f, 0.01304836f, 0.00015158f, -0.00212877f, -0.01525214f, 0.02929541f, -0.02972323f, 
    -0.02849664f, -0.03757905f, -0.00229718f, -0.03231896f, 0.00258598f, 0.02712228f, -0.04126590f, -0.02201930f, 
    0.02000142f, 0.01280477f, -0.04134055f, -0.01219381f, -0.01498827f, -0.03396591f, -0.01144723f, -0.03286507f, 
    -0.00559710f, -0.02218555f, -0.00533501f, -0.01748539f, -0.01893686f, -0.00970253f, -0.04000772f, -0.02499746f, 
    0.01427048f, 0.02008496f, -0.02575436f, -0.02510145f, 0.02763426f, -0.00712012f, 0.02894912f, -0.02330207f, 
    -0.03102165f, 0.00073933f, 0.01875507f, 0.00930977f, 0.00598649f, -0.01121325f, -0.00664174f, 0.01741678f, 
    0.01200523f, 0.01760610f, -0.03522331f, 0.00856945f, -0.04052148f, -0.04003978f, -0.00627818f, 0.02897231f, 
    0.02690293f, -0.02451938f, -0.01094612f, -0.04013642f, -0.02531432f, -0.01340954f, 0.02143700f, 0.00595516f, 
    0.00890118f, 0.02384618f, 0.00337982f, -0.00228048f, -0.00938021f, 0.01086861f, -0.03988040f, 0.01905437f, 
    0.02978464f, 0.01948519f, -0.03316648f, 0.01796269f, 0.00769022f, 0.02759580f, -0.04108733f, -0.00883073f, 
    0.00296162f, 0.01538197f, -0.03027958f, -0.03578695f, 0.01628125f, -0.01464751f, -0.03158568f, 0.02236208f, 
    -0.01121897f, 0.01237782f, -0.03565740f, 0.00637313f, -0.00387598f, 0.02136803f, -0.00997328f, -0.01484104f, 
    0.01583990f, -0.03481027f, -0.01420742f, -0.03564069f, 0.02355292f, 0.00086809f, 0.02679602f, 0.00117783f, 
    0.01985906f, -0.04022963f, -0.01828456f, 0.02740489f, -0.02076896f, 0.00874748f, 0.00082570f, -0.04168772f, 
    -0.02695343f, 0.00312407f, -0.03393893f, -0.01569328f, 0.01097207f, 0.00118542f, 0.00435050f, 0.00815628f, 
    -0.02770000f, 0.02930903f, 0.01801690f, 0.02809739f, -0.01533327f, 0.02957366f, -0.02581906f, 0.01379565f, 
    -0.00027635f, -0.01809496f, 0.00195089f, -0.02084567f, 0.02864059f, 0.02319310f, -0.00495274f, 0.00559764f, 
    -0.03318752f, -0.03379940f, 0.00972629f, 0.02090890f, -0.03666980f, -0.03219597f, 0.00339495f, -0.03277084f, 
    0.01163789f, -0.04037153f, -0.02100204f, -0.01134148f, 0.00456612f, 0.02214685f, -0.01034248f, 0.01142752f, 
    -0.01750028f, 0.01707304f, -0.02968448f, 0.02734793f, -0.01719520f, -0.01793805f, 0.00035233f, -0.00407377f, 
    0.01044059f, -0.01680720f, -0.00363824f, 0.00532163f, -0.03322009f, -0.02223847f, 0.01561089f, 0.01559514f, 
    -0.02552747f, -0.01696336f, -0.02235595f, 0.02472080f, 0.01438648f, -0.01320133f, 0.00711363f, 0.00601703f, 
    0.02043263f, -0.00962845f, 0.01817276f, -0.02321157f, 0.01956603f, -0.00508377f, -0.01507433f, 0.01946934f, 
    0.02026797f, -0.02614812f, 0.01183135f, -0.00114549f, -0.03989354f, -0.03465880f, -0.03862738f, -0.03360625f, 
    -0.02138033f, -0.03391346f, 0.02631814f, 0.00026635f, -0.00694294f, -0.01673114f, -0.00341975f, -0.01132191f, 
    -0.02392701f, 0.00623656f, -0.02000665f, -0.03963555f, -0.02549042f, -0.01015749f, -0.02355998f, -0.00987236f, 
    -0.00432220f, -0.03835847f, 0.00055489f, 0.01057081f, -0.04024062f, -0.02191769f, -0.00583099f, 0.01606390f, 
    -0.01602053f, 0.00969329f, -0.00290558f, -0.03507224f, -0.01158124f, 0.01386748f, -0.03521684f, 0.01789143f, 
    -0.00510136f, -0.03570275f, -0.04111588f, -0.00978193f, -0.01551725f, -0.04123771f, 0.01502770f, -0.02982957f, 
    -0.03653660f, -0.03825534f, 0.00357651f, 0.02283781f, -0.00042421f, -0.02015121f, 0.01887258f, 0.02836731f, 
    0.00263681f, -0.02772972f, -0.00155426f, -0.02243960f, -0.03818305f, -0.02695830f, -0.02956349f, -0.01675172f, 
    0.01668946f, 0.02811135f, 0.02327676f, 0.02679345f, 0.02988999f, 0.02125846f, -0.02152274f, -0.00784985f, 
    -0.02782084f, 0.02438392f, 0.00382353f, -0.01252781f, 0.00792085f, 0.01066738f, -0.04180381f, -0.00979067f, 
    -0.03408384f, -0.01919950f, -0.01892672f, -0.00458085f, -0.00875234f, 0.00492776f, 0.02901697f, 0.02670999f, 
    -0.00776947f, -0.02756868f, -0.01889952f, -0.02788939f, -0.03474055f, -0.03379615f, 0.01108256f, 0.00299737f, 
    -0.03896622f, -0.01079590f, 0.00563017f, -0.03593883f, 0.01950745f, -0.03652787f, -0.02610880f, -0.01640235f, 
    0.02778335f, 0.00319981f, -0.03305853f, 0.01332744f, -0.03790821f, -0.03505128f, 0.01903206f, -0.01066604f, 
    0.00598197f, -0.00329211f, 0.02789897f, 0.00154102f, -0.01340557f, -0.03120127f, 0.01805174f, 0.01480522f, 
    0.01223902f, -0.03445769f, -0.00120636f, -0.02973796f, -0.01444802f, 0.00253184f, 0.02555809f, 0.01901404f, 
    0.02006068f, 0.00869533f, -0.01661813f, -0.00200120f, 0.00718253f, -0.03562370f, -0.02662610f, -0.02416722f, 
    0.01888963f, 0.02527046f, -0.00753738f, -0.02175031f, -0.03335410f, -0.01590104f, -0.02409978f, -0.02016002f, 
    -0.03723394f, -0.04045245f, 0.00763499f, 0.02675113f, -0.01279303f, -0.00442423f, -0.02231684f, 0.00645063f, 
    0.01569898f, -0.01890385f, -0.01424311f, -0.01502407f, -0.00630288f, -0.03326620f, 0.02231438f, 0.02707834f, 
    -0.01675998f, 0.02283307f, 0.01839231f, 0.02190073f, 0.00862120f, 0.01590577f, 0.02215634f, -0.04172353f, 
    0.00739603f, -0.04161525f, 0.00995902f, -0.01528424f, -0.02407192f, -0.03105021f, -0.01420680f, -0.01461178f, 
    0.01910749f, 0.00191925f, -0.00703576f, -0.00332838f, -0.02182554f, -0.03009864f, 0.02064491f, -0.00796491f, 
    -0.00421502f, 0.01998402f, 0.00911859f, -0.01541952f, 0.00779758f, 0.02875439f, -0.04157688f, -0.00673347f, 
    0.00094179f, 0.00746149f, 0.01395471f, 0.00160769f, -0.01241998f, 0.01723789f, -0.01871501f, -0.01568856f, 
    0.02351387f, -0.04021220f, 0.02169885f, 0.02406959f, 0.00589595f, -0.01387234f, 0.01489804f, -0.01351647f, 
    0.00031213f, -0.02601857f, 0.01435042f, -0.01757172f, 0.01392805f, 0.00547476f, 0.01835811f, -0.03070974f, 
    0.00054668f, -0.02989892f, 0.02716229f, 0.00880419f, -0.02400640f, -0.03756899f, -0.03024321f, -0.00592186f, 
    -0.00530910f, 0.02451224f, 0.00429468f, -0.03539617f, -0.03803217f, -0.02507364f, -0.01719321f, -0.03541889f, 
    -0.00089736f, -0.03977754f, 0.00855152f, -0.01981042f, -0.00826650f, -0.03328455f, -0.02841603f, 0.00992190f, 
    0.02367072f, 0.01441718f, -0.02295643f, 0.02412012f, -0.00488126f, 0.00993271f, -0.02268594f, 0.00576130f, 
    -0.03982410f, -0.04177966f, -0.00814494f, -0.01002611f, 0.02990717f, -0.02532266f, -0.04174836f, -0.00287719f, 
    -0.00916808f, 0.01338245f, -0.00105306f, -0.00994582f, 0.00451328f, -0.01723804f, 0.02747626f, -0.01806110f, 
    0.02630885f, -0.08140267f, 0.13535634f, 0.03996141f, 0.09193364f, -0.00552984f, 0.01034761f, 0.00896878f, 
    -0.02648677f, 0.00847016f, -0.08614435f, 0.04725875f, -0.04813023f, -0.00247536f, -0.08791310f, 0.02218238f, 
    -0.01767923f, 0.10435031f, 0.00112489f, 0.02569511f, 0.02665610f, 0.00036383f, -0.00277872f, 0.03810943f, 
    0.16926301f, 0.03039546f, 0.03509179f, -0.08696002f, -0.01806879f, -0.00196193f, 0.06255639f, -0.09825629f, 
    0.00132508f, 0.02112097f, -0.05468280f, 0.03136380f, 0.04719368f, -0.06298690f, -0.01768071f, -0.04504559f, 
    -0.02089175f, 0.02248954f, 0.03190450f, 0.01827395f, -0.08295244f, 0.09782264f, -0.07922619f, -0.03119181f, 
    0.32567102f, -0.05218256f, -0.04425354f, -0.08383679f, -0.03703490f, 0.01504012f, 0.06984294f, 0.14734660f, 
    -0.02346686f, -0.01400433f, -0.06037583f, 0.09370824f, -0.05254947f, 0.01694199f, -0.04334969f, -0.06331707f, 
    -0.01144263f, -0.00333342f, 0.08141725f, 0.05684705f, 0.04401084f, 0.04677137f, 0.02161643f, -0.09137605f, 
    -0.06121210f, -0.16601714f, 0.06468289f, 0.01788989f, -0.00047674f, -0.06166065f, -0.00004714f, -0.11284473f, 
    0.00107900f, -0.04646664f, 0.03020032f, 0.15101345f, 0.00006252f, -0.11415616f, 0.06974111f, 0.00360209f, 
    -0.01817109f, -0.01479788f, -0.02098134f, -0.03122535f, -0.08267260f, 0.01610039f, -0.05137800f, 0.01390082f, 
    0.51743525f, -0.09588461f, 0.04197846f, 0.13235402f, 0.15427360f, 0.10059694f, -0.02289791f, -0.01770358f, 
    -0.02846497f, -0.07869601f, 0.02349967f, -0.08725424f, 0.22027215f, -0.13816936f, -0.10041956f, 0.18987381f, 
    -0.01161084f, 0.09923273f, 0.08462586f, 0.01876461f, 0.03167108f, 0.01912459f, -0.04609944f, -0.01918284f, 
    0.12771837f, 0.07336386f, -0.02274114f, -0.06788458f, 0.08066233f, -0.01564560f, 0.07851994f, 0.04405213f, 
    0.05493440f, 0.03958614f, -0.03766142f, -0.02137722f, 0.21338254f, -0.10400904f, -0.03435792f, 0.03836245f, 
    0.03480394f, 0.05737781f, -0.04188353f, -0.02453491f, 0.14505321f, 0.02642949f, -0.07438100f, 0.08095739f, 
    -0.00235667f, -0.00783059f, -0.15060998f, -0.09493843f, -0.14340268f, -0.05669773f, 0.00591015f, -0.11319465f, 
    -0.06438940f, 0.04623682f, 0.05752542f, -0.10727007f, 0.06276432f, 0.15760441f, -0.13296686f, -0.07848709f, 
    -0.09192672f, -0.05052399f, 0.06176735f, -0.07141860f, 0.01224558f, 0.01509028f, -0.12025782f, 0.08145880f, 
    -0.08731723f, 0.02848590f, 0.02600595f, -0.03530875f, -0.06349731f, -0.02980586f, -0.05240624f, -0.04089716f, 
    0.10727584f, 0.03682468f, -0.09376645f, 0.14338298f, 0.30415106f, -0.16770072f, 0.09257282f, 0.17998749f, 
    0.07607780f, 0.00954605f, 0.04167360f, -0.04471892f, 0.16841561f, -0.00408951f, 0.09087279f, -0.02633412f, 
    -0.32932472f, 0.06065262f, -0.05980566f, -0.02113133f, 0.04744465f, 0.02948283f, 0.04461536f, -0.01552715f, 
    0.11479016f, -0.05344698f, 0.01091052f, 0.00564924f, 0.03423521f, 0.00682064f, 0.07670603f, 0.01240663f, 
    0.04921850f, 0.07584541f, 0.00166357f, 0.07000843f, -0.01236898f, 0.05402321f, 0.00853167f, 0.01683060f, 
    0.02110668f, -0.23458305f, -0.08816214f, -0.03351570f, -0.02111778f, 0.00898247f, -0.02421209f, -0.00766790f, 
    0.12215819f, 0.10968023f, 0.02396292f, 0.02391707f, 0.04576936f, -0.15108278f, 0.00032723f, -0.09189755f, 
    -0.06449656f, 0.05573318f, -0.00799808f, 0.05908119f, 0.02617987f, -0.02240593f, 0.09018646f, 0.10717648f, 
    0.10011809f, 0.28930485f, -0.04432118f, 0.02290036f, 0.08255849f, 0.03856856f, 0.04851098f, 0.09039176f, 
    0.08112241f, 0.06289519f, -0.07387013f, 0.08032902f, -0.19225329f, -0.00224783f, -0.00661666f, -0.05591247f, 
    -0.07983323f, 0.05605456f, 0.05305712f, 0.11515708f, -0.00612776f, 0.01366068f, 0.05025060f, -0.00900758f, 
    -0.01829136f, 0.02002438f, -0.02360011f, -0.02495018f, 0.00166228f, -0.01575393f, -0.04059233f, -0.11987241f, 
    -0.02142198f, 0.06716002f, -0.03293152f, -0.12460519f, 0.16477086f, -0.35015321f, 0.03260809f, -0.02155262f, 
    -0.05176566f, 0.00355163f, -0.02766370f, -0.08319831f, 0.04909175f, 0.08864301f, 0.05990590f, -0.04817430f, 
    -0.19634935f, 0.01403737f, 0.00851648f, -0.10490464f, -0.00902403f, -0.06011520f, 0.09244735f, -0.03572267f, 
    0.09181009f, 0.06078110f, 0.11403880f, 0.12578900f, -0.12596634f, 0.05303124f, -0.01110249f, 0.21650434f, 
    0.05011217f, 0.00528657f, 0.03795828f, 0.10841787f, 0.06486350f, -0.05875408f, -0.01714991f, 0.00286956f, 
    -0.11118893f, -0.02917725f, -0.11431879f, -0.11241402f, -0.00458172f, -0.06007644f, 0.09005615f, 0.05415253f, 
    -0.09376369f, -0.01027872f, -0.01245975f, -0.08406014f, 0.10276628f, -0.09298694f, -0.06590852f, -0.13670242f, 
    -0.09238501f, 0.00068387f, -0.01933203f, -0.03413659f, 0.09527547f, -0.03170770f, 0.02909403f, -0.06424197f, 
    0.19260503f, 0.09368270f, -0.01996943f, 0.00526087f, 0.10020611f, 0.04312020f, 0.04770999f, -0.03002844f, 
    -0.00164703f, 0.03933831f, 0.05929978f, -0.04401814f, 0.06082627f, 0.00597083f, 0.01010664f, -0.08112288f, 
    -0.11600145f, 0.01089961f, -0.08197301f, -0.00246583f, 0.02263869f, -0.00245598f, 0.05488966f, 0.02525199f, 
    0.11675195f, -0.06701652f, -0.04672834f, 0.16947116f, 0.08044308f, -0.04295729f, -0.00405422f, 0.01267982f, 
    -0.11509571f, -0.05751391f, -0.02516408f, 0.02368493f, -0.13464327f, -0.26877424f, -0.03597671f, -0.11340660f, 
    0.02188653f, -0.02285653f, -0.04192321f, 0.01342748f, -0.03653153f, 0.00507821f, 0.11032302f, -0.10178210f, 
    0.08418499f, 0.03504546f, -0.00163019f, 0.03985455f, -0.02077696f, 0.04778743f, 0.00489330f, 0.01765443f, 
    0.05502008f, 0.08830509f, 0.02909143f, -0.01709030f, 0.05273475f, 0.03181577f, -0.01813236f, -0.17731141f, 
    -0.11424499f, -0.09633141f, -0.12472156f, -0.02696750f, 0.04182557f, 0.01766398f, 0.04151276f, -0.01266136f, 
    0.09758469f, -0.15478395f, -0.07816240f, 0.04949629f, -0.16458979f, 0.05500956f, 0.08856350f, -0.05683056f, 
    0.00468357f, 0.00845081f, 0.01513990f, 0.04067375f, -0.21772568f, -0.00571367f, 0.11563733f, -0.01749226f, 
    0.02168288f, -0.02489935f, -0.00466492f, 0.00520974f, 0.14455970f, 0.00183832f, -0.12731935f, -0.01121372f, 
    0.07070280f, 0.12368554f, 0.06338575f, 0.03349868f, -0.11718544f, -0.03087709f, 0.03782852f, 0.03518296f, 
    -0.00831064f, -0.08774619f, -0.07704367f, -0.02206472f, 0.15162100f, -0.02500226f, -0.01854664f, -0.04777742f, 
    -0.02465313f, -0.03501132f, 0.03753402f, -0.02728939f, -0.08955593f, -0.01657328f, -0.01428629f, -0.02436996f, 
    0.27702501f, 0.01772913f, -0.10490047f, 0.07499053f, 0.06761434f, 0.04288771f, 0.00219723f, -0.03459536f, 
    -0.00752894f, 0.08852239f, -0.01481408f, 0.01792160f, 0.36417773f, -0.00501214f, 0.07256004f, -0.14651980f, 
    -0.13339566f, -0.00718762f, 0.05344224f, -0.00769724f, -0.03827977f, -0.02999853f, 0.09507218f, -0.02053393f, 
    0.05898226f, 0.10772354f, -0.04810587f, 0.01780250f, 0.00321502f, -0.00678590f, 0.03306528f, 0.01922159f, 
    0.07704172f, 0.04921420f, 0.08276072f, 0.07069151f, 0.24745479f, 0.16957732f, 0.00225026f, -0.00958016f, 
    0.02279381f, 0.13509780f, 0.02320879f, 0.14226925f, -0.01177643f, 0.01895795f, 0.06181564f, 0.00358688f, 
    0.06273572f, -0.19214971f, -0.06666002f, -0.08598627f, -0.01814887f, -0.05369458f, 0.09648778f, -0.02886960f, 
    -0.04841021f, -0.01385235f, 0.10002146f, 0.06699764f, -0.09217384f, -0.13045238f, -0.09486847f, -0.02819997f, 
    0.08476253f, -0.04351766f, 0.01594311f, 0.07070089f, -0.03649532f, 0.03931250f, 0.03339357f, -0.09711472f, 
    0.21294460f, 0.15553658f, 0.09969512f, -0.01652192f, 0.03588488f, 0.05848346f, -0.03718269f, 0.08063527f, 
    0.03017717f, 0.11357745f, 0.03878025f, -0.05769923f, 0.36367485f, 0.08903626f, 0.02852940f, 0.16041422f, 
    0.04571977f, -0.03553864f, 0.11117759f, -0.03981461f, 0.04104132f, 0.00232671f, 0.22225805f, 0.02729419f, 
    0.06375627f, 0.13055177f, 0.01502653f, -0.10536281f, 0.17667268f, 0.05732319f, -0.04126753f, 0.09967735f, 
    -0.00319614f, 0.02985137f, 0.09368581f, 0.03196177f, -0.12875120f, -0.33678815f, 0.00472288f, -0.11743173f, 
    -0.04786095f, 0.05945854f, -0.00448211f, 0.14528009f, -0.01263102f, -0.09897336f, -0.05589958f, -0.00837724f, 
    0.06912151f, -0.03599848f, -0.00295843f, -0.02095976f, 0.07908168f, 0.04971867f, 0.04443325f, 0.01186738f, 
    -0.03762302f, -0.04639468f, 0.04820471f, -0.06306740f, -0.07090769f, 0.14943528f, -0.09839203f, -0.11038254f, 
    -0.12434550f, 0.14815593f, 0.01549840f, 0.06171409f, 0.02851092f, 0.00549560f, 0.13623862f, 0.09821574f, 
    0.24768187f, 0.10482476f, -0.06072458f, 0.03174646f, 0.11255328f, -0.00013251f, 0.01566132f, -0.02891347f, 
    0.02904780f, -0.02723522f, 0.03297450f, -0.07714577f, -0.19023204f, -0.02783061f, -0.05467290f, 0.01178663f, 
    -0.04845323f, -0.03345635f, -0.07429790f, -0.08735185f, -0.00949660f, -0.06358567f, 0.01529115f, 0.04741704f, 
    -0.10283600f, 0.03165766f, -0.01115089f, 0.00608623f, 0.04003300f, -0.00790293f, 0.03892481f, -0.00858364f, 
    -0.01498175f, -0.04192073f, 0.05775439f, -0.06408200f, 0.01392291f, -0.14937297f, -0.03201360f, 0.02156133f, 
    -0.06481314f, 0.08338823f, -0.01395807f, 0.03450559f, -0.01904404f, 0.04329585f, -0.00540292f, -0.05881526f, 
    -0.08077948f, -0.24442084f, 0.02606986f, -0.04843434f, 0.03627551f, -0.02982529f, -0.00247737f, -0.05092034f, 
    0.00612239f, 0.02850442f, 0.04018496f, -0.02401574f, 0.21972415f, 0.07443886f, 0.00466944f, -0.06068410f, 
    -0.02219472f, -0.08281954f, 0.10554676f, 0.03257636f, 0.01914437f, 0.03274791f, -0.01257433f, 0.03317478f, 
    -0.05631679f, 0.14481406f, 0.14605227f, -0.11096026f, 0.06570027f, -0.00954522f, 0.12557204f, 0.03134882f, 
    0.07858922f, 0.00338293f, 0.01175069f, 0.06813200f, 0.18075001f, -0.07049786f, -0.05203710f, 0.07346880f, 
    -0.04040242f, 0.10635123f, -0.02876366f, 0.07645469f, -0.06882232f, 0.00264326f, -0.05622611f, 0.12844190f, 
    0.01203151f, -0.18616644f, 0.03101035f, 0.01223121f, -0.01074960f, 0.03167879f, -0.00534098f, -0.07595152f, 
    0.11600272f, 0.05407365f, -0.11350978f, -0.01304648f, -0.01031046f, 0.05063950f, 0.09260684f, -0.17141335f, 
    0.02942073f, -0.04759299f, 0.00321062f, 0.01759354f, 0.02433199f, 0.02520272f, 0.12802805f, 0.03512092f, 
    0.02601750f, 0.19928817f, -0.05652146f, 0.13325091f, -0.02865720f, 0.00617360f, -0.05409639f, 0.10268908f, 
    0.03469595f, -0.00421040f, 0.02166587f, 0.04290064f, -0.00788707f, -0.13165201f, 0.06541172f, 0.09518721f, 
    0.00040006f, 0.06493262f, 0.07593479f, 0.02679191f, -0.10665771f, -0.00452747f, 0.01528410f, -0.00282847f, 
    0.17675406f, -0.00714143f, -0.01471317f, -0.10959709f, -0.01812664f, -0.12513758f, 0.00899624f, 0.06729110f, 
    0.03677033f, 0.11050496f, -0.02201444f, 0.01545100f, 0.22125880f, -0.04182836f, -0.04877089f, -0.09274525f, 
    -0.10933635f, -0.01696677f, -0.01831128f, 0.07922731f, 0.00375152f, 0.05856863f, 0.05524181f, -0.02609170f, 
    -0.14990161f, 0.06324776f, -0.04880557f, -0.08044662f, 0.11614712f, -0.00860945f, -0.03138961f, 0.03458021f, 
    0.08720223f, 0.02511472f, 0.06127565f, -0.01760471f, 0.17844212f, 0.07090130f, 0.02460442f, 0.17668736f, 
    0.03109982f, -0.04556619f, 0.01290572f, 0.06838787f, 0.13176110f, 0.02198932f, 0.07283463f, 0.02744428f, 
    0.16232322f, -0.04955399f, -0.06705934f, 0.01325409f, 0.05028463f, 0.04377425f, 0.05247211f, 0.13213706f, 
    0.08393294f, -0.01376748f, 0.02187382f, 0.01164143f, -0.23633651f, 0.04870474f, -0.03892244f, -0.07359995f, 
    0.13790160f, -0.00117561f, 0.06053208f, 0.02991438f, 0.06088825f, -0.02090864f, 0.00274347f, -0.04197006f, 
    -0.18872406f, 0.10908964f, -0.03488684f, -0.06623222f, 0.11672355f, 0.09360291f, 0.01791734f, -0.04282067f, 
    0.04506480f, -0.00673918f, 0.06245300f, -0.04103765f, -0.11696389f, 0.07697818f, 0.01660633f, 0.26144052f, 
    0.06251844f, -0.01522127f, -0.02409538f, 0.01604608f, 0.01523668f, -0.02932235f, -0.04459617f, 0.09152716f, 
    0.12674180f, 0.03348392f, -0.10839298f, -0.04970168f, 0.10644885f, 0.13616736f, 0.03916942f, 0.12236153f, 
    0.04046288f, 0.02646045f, 0.04433652f, -0.02163193f, -0.24477303f, 0.09743538f, -0.04121230f, -0.01815411f, 
    0.12899804f, 0.10227064f, 0.10856756f, 0.01695388f, 0.07776877f, 0.02512080f, 0.05360796f, 0.00290519f, 
    -0.33153215f, 0.07456935f, 0.09731164f, -0.15777639f, 0.08646411f, -0.00861188f, 0.05674487f, -0.02797217f, 
    -0.07083859f, 0.11446869f, 0.08308497f, 0.03881458f, -0.12141516f, -0.01195239f, 0.09821472f, 0.02753657f, 
    0.01629249f, 0.05911573f, 0.00996449f, 0.06997149f, 0.00526697f, 0.05487916f, 0.02404695f, -0.01729859f, 
    0.28741413f, 0.13626137f, 0.03640334f, 0.28574839f, 0.02361077f, 0.03092863f, 0.01026304f, -0.05959365f, 
    -0.03942792f, -0.07663223f, 0.06600033f, 0.13020712f, 0.15967584f, 0.06248387f, 0.06270057f, 0.21844168f, 
    0.00466701f, -0.02982253f, 0.02004136f, 0.03565188f, -0.03111207f, 0.00086441f, 0.06018677f, 0.06832909f, 
    -0.03304523f, 0.01765888f, 0.06461206f, 0.20944600f, 0.17029817f, 0.16772231f, 0.09367670f, 0.16195647f, 
    0.07056147f, 0.02371243f, -0.09922511f, 0.01862105f, -0.16101168f, 0.06059933f, -0.04119272f, 0.05093233f, 
    0.20047864f, 0.06049710f, 0.05647502f, 0.05486954f, 0.10815149f, 0.06415602f, 0.11853502f, 0.04220445f, 
    0.41344979f, 0.17768984f, 0.06407927f, 0.13077664f, 0.05944901f, 0.06198863f, 0.02895259f, 0.08041272f, 
    0.03900984f, -0.03281517f, 0.03848473f, 0.02365189f, -0.15908718f, 0.13966236f, 0.19875410f, -0.22625668f, 
    0.03524130f, 0.09549342f, 0.02843150f, 0.09149772f, -0.03422363f, 0.07002786f, 0.10349133f, 0.08020414f, 
    0.24696794f, 0.11138860f, 0.08278588f, -0.04037026f, 0.00167651f, -0.01446890f, -0.01714961f, 0.03140974f, 
    -0.03138009f, 0.05994894f, 0.02347235f, 0.00679698f, 0.02350163f, 0.00852216f, -0.05838726f, 0.12579703f, 
    0.01049137f, -0.15367880f, 0.01679449f, 0.04369117f, 0.03853101f, -0.11894277f, 0.08125333f, 0.09247297f, 
    0.22061092f, 0.07785705f, 0.16331196f, 0.08008743f, 0.07757133f, -0.00930801f, 0.07983807f, -0.00669247f, 
    -0.01153808f, 0.00589798f, 0.01012516f, 0.13036241f, -0.23546019f, 0.25202903f, -0.10447013f, -0.01780010f, 
    0.12403589f, 0.00872154f, 0.08676162f, -0.02996477f, -0.06990657f, 0.05367472f, -0.00833701f, -0.02597456f, 
    0.22612885f, -0.10352970f, 0.04841663f, 0.19958769f, -0.07795453f, 0.02266273f, 0.01803029f, -0.07261258f, 
    0.01258717f, -0.06078759f, 0.03592730f, 0.05778535f, 0.02457143f, 0.18072523f, 0.05728239f, -0.03948763f, 
    0.06191221f, 0.10158110f, 0.02458995f, 0.08570073f, 0.00181357f, 0.04541843f, 0.12950052f, 0.05807650f, 
    0.17841472f, 0.11201832f, 0.13584030f, 0.16389342f, 0.00375527f, -0.06587995f, 0.02275848f, 0.02649346f, 
    0.00643996f, -0.09914318f, -0.06520719f, 0.13879545f, -0.05661053f, 0.07464383f, 0.14034359f, 0.03844999f, 
    0.02463905f, 0.02429669f, 0.00320553f, 0.04524896f, -0.01688627f, -0.01966575f, -0.08102742f, 0.06906702f, 
    -0.05190720f, 0.10296615f, -0.05170736f, 0.22549127f, 0.06739785f, 0.13250542f, -0.01722836f, 0.13671084f, 
    -0.00534040f, 0.01477833f, -0.02646449f, -0.00159753f, 0.36637017f, 0.16531844f, 0.11213767f, -0.06615243f, 
    0.00311408f, -0.00150923f, 0.11649546f, -0.02811226f, -0.07437897f, 0.01207768f, -0.05972276f, -0.02993021f, 
    0.01917666f, 0.01293849f, 0.05617309f, 0.09639917f, 0.11348996f, 0.08132394f, -0.01348363f, -0.04106971f, 
    0.08404044f, 0.03796544f, -0.01672889f, 0.10001735f, 0.26190102f, 0.15032695f, 0.11021686f, 0.19704522f, 
    0.08665022f, 0.00779574f, 0.11163162f, 0.09017681f, -0.05616590f, 0.06384210f, -0.01730715f, 0.06283572f, 
    0.22411406f, -0.03491110f, 0.09784745f, 0.08750911f, 0.00701699f, -0.01548705f, -0.02958231f, -0.01657274f, 
    -0.05766697f, -0.02954532f, 0.04939250f, 0.03980128f, -0.20684229f, 0.10285043f, -0.04125014f, 0.03469604f, 
    0.16744831f, 0.03770412f, 0.07670432f, 0.10229991f, 0.11165863f, -0.07383305f, 0.00958309f, 0.03825121f, 
    0.17315830f, 0.04124312f, 0.10538311f, 0.11803306f, 0.01397302f, 0.06492154f, 0.05027795f, 0.04497979f, 
    0.05967614f, 0.07184079f, 0.01830730f, 0.01202828f, 0.37963226f, 0.19543725f, 0.14659013f, 0.15497971f, 
    -0.01831677f, 0.06522495f, 0.11851536f, 0.02441859f, 0.05473253f, 0.09829489f, -0.02344746f, 0.09659220f, 
    0.26994804f, 0.07635939f, 0.05264711f, 0.02798470f, 0.02559534f, 0.01357594f, -0.01154829f, 0.07021505f, 
    0.01696604f, -0.06953029f, 0.03136650f, 0.09637178f, -0.08981208f, 0.07190649f, -0.05778456f, 0.06133271f, 
    0.20245254f, 0.15219669f, 0.07493503f, 0.05847824f, 0.06387238f, 0.10301233f, 0.03722896f, -0.03706830f, 
    -0.18424124f, 0.05126500f, 0.07272661f, 0.17707959f, 0.10923553f, 0.08833546f, 0.03082540f, 0.07222266f, 
    0.04985350f, 0.05202048f, 0.09396018f, 0.04131611f, 0.27447426f, 0.13110229f, 0.10174481f, -0.11338001f, 
    -0.01493869f, 0.01489262f, 0.06717896f, 0.03458815f, -0.00731375f, 0.00862521f, 0.13035111f, 0.01532282f, 
    -0.12019723f, -0.05083216f, 0.03458517f, 0.02232413f, 0.16187963f, -0.05710174f, 0.06298786f, -0.01970669f, 
    -0.00108582f, 0.07853248f, 0.11537058f, -0.06968911f, -0.06861383f, -0.04629669f, 0.02766139f, 0.42900327f, 
    0.03887274f, 0.00826713f, 0.04933156f, 0.00733129f, 0.06646886f, 0.12392943f, 0.09373685f, 0.15354532f, 
    0.13398527f, -0.02117985f, 0.16843779f, 0.08504051f, -0.03566341f, 0.01557149f, 0.08044346f, 0.01736494f, 
    -0.00050145f, -0.03729735f, 0.03984425f, 0.06768686f, -0.09369507f, 0.02611062f, 0.15812761f, 0.10944315f, 
    0.12380502f, 0.11325609f, -0.04932483f, -0.03639717f, 0.05276245f, 0.10645218f, 0.04437012f, 0.10386750f, 
    -0.34764227f, 0.00844779f, 0.07296382f, 0.07097393f, 0.10590018f, 0.11730656f, -0.01964352f, -0.02239489f, 
    -0.05714580f, 0.12721907f, 0.03991314f, 0.04562015f, -0.15493642f, -0.17652391f, 0.08768950f, 0.32876074f, 
    -0.00449423f, -0.09388939f, 0.02235496f, 0.01174373f, -0.08590075f, 0.00607806f, -0.02037899f, 0.11367581f, 
    0.01402737f, 0.00447960f, -0.06318038f, -0.02884110f, 0.09148856f, 0.01916929f, 0.00916239f, 0.07108121f, 
    0.00864973f, 0.03318474f, -0.06954142f, -0.02034316f, 0.15686177f, 0.05807675f, 0.07735078f, 0.13719334f, 
    -0.01276136f, 0.01613712f, -0.04047253f, 0.01913491f, 0.00149778f, -0.15482821f, -0.03440914f, 0.04451660f, 
    -0.03465438f, -0.08195706f, -0.05742060f, -0.01257678f, 0.03991961f, 0.01068347f, 0.03989731f, -0.03214961f, 
    0.03251225f, -0.06667009f, 0.07014250f, 0.10262636f, -0.52254164f, 0.10509584f, 0.02492771f, -0.14989835f, 
    0.07197221f, -0.00588558f, -0.08245731f, 0.06098965f, 0.02736403f, -0.04154504f, -0.03549467f, -0.00586294f, 
    -0.15298487f, 0.05073063f, 0.13181585f, 0.14142747f, -0.09479970f, -0.08282191f, 0.01162766f, 0.00670584f, 
    -0.01647715f, -0.03069215f, -0.05697724f, 0.14399207f, 0.07341719f, 0.14168565f, 0.05613733f, -0.01910779f, 
    0.14003971f, -0.01146887f, 0.05898083f, -0.11426096f, 0.06523503f, 0.03610467f, -0.05886800f, -0.01247653f, 
    0.33193210f, -0.07499147f, -0.02030781f, 0.05761693f, 0.04849180f, -0.04038920f, -0.05638685f, 0.01528395f, 
    0.03019972f, 0.10613371f, -0.02174874f, 0.04147555f, 0.21613567f, 0.00043570f, 0.15654443f, 0.05179661f, 
    0.03024337f, -0.04668688f, 0.10674439f, -0.02880084f, 0.09792653f, 0.08276275f, 0.06630770f, -0.00536620f, 
    -0.15104209f, -0.03605335f, 0.13812757f, -0.08067543f, 0.04765738f, 0.14163582f, -0.06216388f, 0.00006252f, 
    -0.00074066f, 0.08846633f, 0.07051615f, 0.18619245f, 0.11786784f, 0.01255160f, 0.09595206f, 0.09166691f, 
    0.15295871f, 0.08754671f, 0.07179791f, 0.14309371f, 0.15992327f, 0.19119106f, 0.02302530f, 0.06234092f, 
    0.26690200f, 0.11878194f, -0.01636580f, 0.08861478f, -0.00746206f, -0.10117397f, 0.05472460f, -0.01018172f, 
    0.03399549f, 0.03653418f, -0.03810648f, 0.03040864f, -0.06401197f, 0.04379094f, 0.07657158f, 0.04012121f, 
    0.11137851f, 0.01642157f, 0.01186178f, -0.01096982f, 0.03377419f, 0.03199474f, -0.03379354f, 0.02568029f, 
    0.23432660f, 0.11653858f, 0.13075005f, 0.06515991f, -0.02875876f, 0.03127709f, -0.00648387f, -0.00051100f, 
    0.05714205f, 0.05101362f, -0.05637262f, 0.08715884f, -0.23755318f, 0.11513615f, -0.02995577f, -0.06213940f, 
    0.15187784f, 0.20276164f, -0.00130374f, 0.03521518f, 0.03166658f, 0.11077612f, 0.16813555f, -0.01494516f, 
    0.12505718f, 0.09338581f, 0.00282445f, 0.16110295f, 0.04157383f, 0.05790493f, 0.06671230f, -0.01820587f, 
    -0.00112455f, 0.01443046f, 0.11509630f, 0.03670812f, -0.14898688f, 0.09102412f, 0.05032437f, -0.06202767f, 
    0.09655342f, 0.06381929f, 0.08367705f, 0.06910256f, 0.14064169f, 0.01109231f, 0.04963040f, -0.07233392f, 
    0.10718895f, 0.15485878f, -0.00757519f, 0.14713240f, -0.00173475f, 0.06263322f, 0.06554995f, 0.05436205f, 
    -0.05536810f, -0.05936516f, 0.09207279f, 0.07044579f, -0.00667914f, -0.02371258f, -0.09980483f, 0.24256678f, 
    0.00479870f, 0.01355990f, 0.10335314f, 0.04651459f, 0.06084702f, 0.07247283f, -0.00028297f, 0.10074124f, 
    0.36795110f, 0.08015592f, 0.03176800f, 0.11326247f, 0.02249470f, 0.00489753f, 0.04951870f, 0.00743571f, 
    0.05089902f, -0.05578866f, 0.17463547f, 0.02451001f, 0.05584998f, 0.10695788f, -0.03113411f, -0.06181948f, 
    0.05318885f, 0.01373831f, 0.00286439f, 0.04497495f, 0.08256012f, -0.03155532f, -0.12011277f, -0.05814834f, 
    -0.05264731f, 0.00419712f, 0.00051977f, 0.01506431f, 0.12431958f, 0.06895689f, 0.11739532f, -0.02284802f, 
    0.02479663f, 0.01766972f, 0.05761996f, 0.01235980f, -0.16358653f, 0.02286440f, 0.00166521f, -0.00213812f, 
    0.17420702f, 0.10404793f, 0.12804972f, -0.00363782f, 0.05329076f, 0.01067578f, 0.03138209f, 0.02493723f, 
    -0.27468967f, 0.19161344f, -0.02891410f, 0.09585301f, 0.12112846f, -0.05385575f, 0.03877053f, 0.00272693f, 
    -0.09318739f, 0.03108714f, 0.13211039f, -0.01454189f, 0.27797461f, -0.14138909f, 0.11217824f, -0.03180527f, 
    -0.04855008f, 0.07707670f, 0.05740737f, -0.02060379f, -0.02186451f, 0.01372284f, 0.05074779f, 0.01124941f, 
    0.21581857f, -0.00622192f, 0.03033751f, 0.38630629f, 0.07636347f, -0.07479866f, 0.00903879f, 0.12479657f, 
    0.03418784f, -0.01940249f, -0.09633978f, 0.02276528f, 0.19323060f, 0.08785754f, 0.07246137f, 0.09448890f, 
    0.08648534f, 0.11935679f, 0.00347813f, 0.18251662f, 0.01336379f, -0.06223048f, 0.07619018f, 0.01952571f, 
    -0.13382351f, 0.00994343f, 0.13208310f, 0.14375840f, 0.04739610f, -0.02704059f, 0.10348178f, 0.03014681f, 
    0.05202524f, 0.11196332f, -0.01567224f, 0.12103545f, 0.22681448f, 0.07007226f, -0.01881704f, 0.02438421f, 
    0.07344736f, 0.01720973f, -0.00655711f, -0.10164406f, 0.03437271f, -0.03999106f, -0.02500676f, 0.07780764f, 
    -0.14061807f, 0.10981070f, 0.14707606f, 0.10139453f, 0.21912141f, -0.00025638f, -0.01307431f, 0.08776422f, 
    -0.07396064f, 0.03052839f, 0.14808750f, 0.17731832f, 0.26467320f, 0.12816896f, -0.06533992f, 0.02792011f, 
    0.11576004f, -0.01356692f, -0.03009622f, 0.19717078f, 0.06068619f, -0.02374116f, 0.03707401f, 0.05772880f, 
    0.03075657f, 0.03824014f, -0.03667453f, 0.20399226f, -0.07641607f, -0.06243644f, 0.03995790f, 0.04535884f, 
    0.03708100f, 0.00528319f, 0.03606550f, 0.09206748f, -0.11034760f, 0.16051874f, 0.22069874f, 0.06206508f, 
    0.07133805f, -0.00274941f, -0.04521854f, 0.02702056f, 0.02026485f, 0.00072332f, 0.01541363f, -0.02932301f, 
    0.04860809f, -0.02832711f, -0.00109738f, -0.01911108f, -0.00608152f, 0.10602701f, -0.09592608f, -0.06188609f, 
    -0.00187481f, 0.08925300f, 0.06998497f, 0.00903934f, -0.06414201f, 0.06284552f, -0.00532724f, -0.08666808f, 
    0.21281138f, 0.00880136f, 0.00585016f, -0.00475812f, 0.04097892f, -0.02711052f, 0.00965087f, -0.16518024f, 
    0.07537419f, -0.03791327f, 0.19240597f, 0.11175323f, 0.13038158f, -0.01360455f, -0.03803885f, 0.08840410f, 
    0.08385712f, -0.00659203f, 0.11867174f, 0.14321943f, 0.21564430f, 0.02346904f, 0.10447028f, 0.02427680f, 
    0.01995595f, 0.13383715f, -0.01766957f, 0.04725530f, -0.00931600f, 0.02492618f, 0.04202702f, -0.04901501f, 
    -0.03887562f, -0.13826935f, -0.05870454f, -0.00050924f, 0.08534531f, 0.04773825f, 0.11115386f, -0.01740590f, 
    0.06417996f, 0.10838355f, 0.01753589f, 0.04627258f, -0.19014825f, 0.11293565f, -0.09007878f, -0.06954618f, 
    0.18480517f, -0.05748770f, 0.07266632f, 0.07702168f, -0.09081566f, 0.10444111f, 0.01594701f, 0.09868412f, 
    -0.01302384f, -0.00293671f, -0.13058943f, 0.13298513f, 0.06865842f, -0.10756637f, -0.00972718f, -0.01968798f, 
    0.04263015f, 0.05913502f, -0.03079212f, 0.04073504f, -0.09784187f, 0.10822836f, -0.04688678f, 0.16272371f, 
    0.05561522f, 0.10035779f, 0.05950139f, -0.04787068f, 0.07837743f, -0.02706013f, -0.01575642f, 0.08775157f, 
    0.01087995f, 0.18311794f, -0.04744048f, -0.12202124f, 0.16559514f, -0.05744020f, -0.02466940f, 0.09127904f, 
    0.05096402f, 0.01639737f, 0.13709679f, 0.06930353f, 0.00418961f, 0.11347616f, 0.14695066f, 0.04909729f, 
    0.02782266f, 0.02876550f, -0.04866607f, 0.15646380f, 0.01727716f, 0.09497310f, -0.01808619f, 0.01391835f, 
    0.00677720f, -0.12386714f, 0.02531810f, 0.02071289f, 0.06159146f, 0.09691082f, 0.00887416f, -0.09111437f, 
    0.09758607f, 0.00760821f, 0.10904932f, -0.05926854f, 0.11021405f, 0.00285288f, 0.08749881f, -0.07949843f, 
    0.08762238f, -0.03520749f, -0.01852356f, 0.09695574f, -0.03448031f, 0.09725729f, 0.08817631f, 0.15096636f, 
    -0.01827344f, 0.07704091f, -0.12402230f, 0.22430027f, 0.12627773f, 0.07066891f, -0.07196467f, 0.10530781f, 
    0.00878309f, -0.02379582f, -0.03337186f, -0.06283695f, -0.12813108f, 0.25222960f, -0.17951033f, -0.12639140f, 
    0.26615614f, 0.06383227f, 0.03415933f, -0.03074625f, -0.03619778f, -0.00752869f, -0.00424175f, 0.07776126f, 
    0.15562418f, 0.11857843f, 0.16316541f, 0.10445523f, 0.03390434f, -0.10413793f, -0.20163862f, 0.05051679f, 
    -0.03513853f, 0.02615610f, 0.08680974f, 0.05198112f, -0.03605611f, -0.16894580f, -0.10229329f, 0.16877943f, 
    0.10367181f, 0.08045146f, 0.03170722f, -0.09368393f, -0.05347020f, -0.06343088f, 0.02085238f, 0.01826618f, 
    -0.01239830f, 0.15798077f, 0.23780650f, 0.20146897f, -0.04177063f, 0.09100434f, 0.05398685f, 0.09760393f, 
    0.01276761f, 0.05064771f, 0.03986938f, -0.01285442f, -0.03196446f, 0.04263639f, -0.17540787f, 0.03795139f, 
    0.12422262f, 0.11699837f, 0.01629649f, -0.06445577f, 0.02082210f, 0.00633066f, 0.07108594f, 0.02496509f, 
    -0.08926485f, -0.05210298f, 0.09441283f, 0.06717392f, 0.05220088f, 0.06020256f, -0.09940367f, 0.00165159f, 
    0.15582362f, -0.08473643f, -0.00508924f, 0.08649059f, 0.19991499f, 0.02798984f, 0.02182804f, 0.20209374f, 
    -0.02484123f, 0.00630382f, 0.15334152f, 0.07922123f, -0.07670480f, -0.02383934f, 0.05711307f, -0.01099551f, 
    -0.00388057f, 0.05918462f, 0.12469792f, 0.03593312f, -0.03939913f, 0.09521139f, 0.07991873f, 0.00952348f, 
    0.05339668f, 0.00366183f, -0.12600487f, -0.03062108f, 0.07256310f, 0.13564511f, -0.06237556f, -0.05711640f, 
    0.19360790f, 0.06506064f, -0.04193404f, -0.06115857f, 0.02153659f, -0.02111992f, 0.02286031f, 0.00352930f, 
    0.04863613f, -0.07243917f, -0.04572527f, -0.11808798f, 0.06060016f, 0.08668751f, 0.03288054f, 0.00734073f, 
    0.14815553f, 0.02240211f, 0.08416928f, 0.02281411f, 0.12634461f, 0.02641214f, 0.00320665f, 0.40387318f, 
    0.03868911f, -0.09783512f, 0.08500519f, 0.11962519f, -0.12588027f, 0.00297207f, 0.16747098f, 0.02147532f, 
    -0.04312184f, 0.13508154f, 0.17449723f, 0.08234806f, 0.09795296f, 0.00141760f, 0.03889466f, 0.10102408f, 
    0.10375853f, 0.03362455f, 0.02771144f, 0.13520022f, -0.04764688f, -0.02872594f, -0.17500553f, -0.09362013f, 
    -0.00537251f, 0.13383423f, 0.02879584f, 0.02245381f, 0.08191748f, 0.07064059f, -0.00031089f, 0.14375418f, 
    0.22178236f, -0.14840521f, 0.07174379f, 0.15498269f, -0.01267015f, -0.02399919f, 0.20790404f, 0.11326327f, 
    0.00881391f, 0.04227498f, 0.00093321f, -0.01906458f, 0.04622800f, 0.14976442f, -0.08590595f, 0.15443911f, 
    0.09346998f, 0.08803638f, -0.06305151f, 0.06516156f, 0.01702821f, 0.03517443f, -0.06219710f, 0.00604962f, 
    -0.14504187f, 0.02652584f, -0.05227228f, 0.00616306f, 0.13391787f, 0.03963514f, -0.06017240f, 0.01660817f, 
    0.07905052f, -0.02478472f, 0.03945888f, -0.03080926f, -0.18326665f, 0.02496430f, -0.14791043f, 0.07475761f, 
    0.01484883f, 0.04723194f, -0.04600038f, 0.08625460f, -0.02939203f, 0.01040488f, -0.05141593f, 0.12306600f, 
    0.16194569f, 0.11261476f, -0.02392802f, -0.16252092f, -0.03556162f, 0.15333672f, 0.01798559f, 0.10070621f, 
    -0.05372591f, 0.02868422f, -0.02674072f, 0.08718479f, -0.03155932f, -0.11434348f, -0.06576079f, 0.13588676f, 
    0.06459936f, -0.04474626f, -0.03743136f, -0.02352658f, 0.08207078f, 0.03153598f, 0.01468254f, -0.08636543f, 
    -0.22225426f, 0.09820155f, 0.11333779f, 0.24509713f, 0.08006149f, -0.13938493f, 0.04900524f, 0.11576279f, 
    -0.02608128f, 0.05001158f, -0.02467861f, 0.03240428f, 0.21313125f, -0.04581678f, 0.00195879f, -0.19191001f, 
    0.09324976f, 0.00343954f, -0.03775591f, 0.06720767f, 0.01375997f, -0.06467438f, 0.05701433f, -0.03234060f, 
    -0.16165328f, -0.02363472f, 0.00680059f, 0.08761069f, 0.01349944f, 0.03024466f, 0.03627716f, -0.01973003f, 
    0.09849470f, -0.03099794f, -0.01706741f, -0.00216586f, 0.01255193f, -0.04480255f, 0.02734533f, 0.02489561f, 
    0.01084624f, -0.02449504f, 0.01911933f, 0.00190120f, -0.09418802f, 0.05980895f, -0.05785688f, 0.07063444f, 
    -0.06655864f, 0.01988581f, -0.08121140f, 0.05954980f, 0.02393007f, -0.07006455f, 0.10779729f, -0.03230734f, 
    0.15173997f, 0.01873734f, 0.00128971f, 0.06974389f, -0.14009246f, 0.20960467f, -0.17365901f, 0.12370636f, 
    0.20724589f, 0.07724218f, 0.23819669f, -0.06709649f, 0.05396111f, 0.04017549f, 0.10162283f, 0.00175899f, 
    0.04028963f, 0.07094835f, 0.16150449f, 0.12685816f, 0.01210636f, -0.02491390f, 0.16981630f, 0.08201795f, 
    0.07613342f, 0.02901594f, 0.05159903f, 0.01413221f, -0.14836515f, -0.13989089f, -0.06644206f, 0.05670189f, 
    0.21223183f, 0.03147023f, 0.06813447f, -0.07465288f, 0.06446493f, 0.03589068f, 0.06110163f, -0.06469443f, 
    -0.19623700f, 0.09025530f, 0.03245620f, 0.09424468f, 0.07817696f, -0.02468157f, 0.09711202f, 0.04090792f, 
    0.00762146f, -0.02813892f, -0.00130120f, 0.04684735f, 0.10494152f, 0.01350146f, -0.03405942f, 0.05415866f, 
    -0.08574656f, 0.00457750f, 0.09228866f, 0.10983244f, -0.09541103f, 0.10061907f, 0.11325064f, -0.01475536f, 
    0.09588890f, 0.15006237f, -0.01975518f, 0.12248499f, -0.00538294f, 0.03145382f, 0.11720079f, 0.05564011f, 
    -0.01169627f, 0.14995322f, -0.00707187f, 0.05130479f, 0.03989070f, 0.15048729f, 0.23839103f, 0.03388786f, 
    0.11672784f, 0.02334479f, 0.09998439f, 0.17322396f, -0.00688788f, 0.06389311f, 0.04411167f, -0.03715979f, 
    0.11585134f, 0.17867632f, 0.01878653f, -0.11639304f, 0.14211586f, 0.16093242f, 0.07987925f, 0.01036945f, 
    0.01263656f, 0.00219585f, 0.04379729f, 0.01259665f, 0.09566922f, -0.03110374f, 0.13519172f, 0.13359086f, 
    -0.18688561f, -0.03214993f, 0.04799228f, 0.01517545f, -0.04256514f, 0.02095576f, 0.02051012f, 0.01657196f, 
    0.11135611f, -0.02551368f, -0.18857625f, 0.24147603f, -0.04801248f, -0.00245448f, -0.03694784f, 0.07875025f, 
    -0.03794928f, 0.06758469f, 0.04654609f, 0.06023030f, -0.02709346f, -0.08938199f, 0.15581639f, 0.14909035f, 
    0.05462925f, -0.02304526f, 0.10093626f, 0.10569870f, 0.01374700f, 0.05273020f, 0.05820458f, 0.10165792f, 
    -0.01153599f, 0.06709818f, -0.02307704f, 0.01908905f, -0.06934027f, 0.01843998f, -0.00617078f, 0.08316361f, 
    -0.03513518f, 0.16573772f, 0.07944287f, 0.00223098f, 0.23719528f, 0.02409270f, -0.03580498f, 0.07188484f, 
    -0.00480169f, 0.13598943f, 0.01102218f, 0.02767139f, 0.13574500f, 0.07827748f, 0.05263199f, 0.04234395f, 
    0.28896406f, -0.10323959f, 0.09477323f, -0.16009888f, -0.00415620f, 0.08413099f, 0.04278446f, -0.11494263f, 
    0.03027946f, 0.08691833f, 0.07188141f, 0.14413419f, 0.18173467f, -0.00169944f, 0.04763636f, -0.04808337f, 
    0.02059676f, -0.02965959f, 0.12424491f, 0.00010177f, 0.06531774f, -0.06592730f, 0.07611731f, -0.08513644f, 
    0.14116251f, -0.03403207f, 0.09953690f, 0.26185051f, -0.03364616f, -0.01280332f, 0.08520970f, 0.03146869f, 
    0.06148870f, 0.00043908f, -0.02633419f, 0.02264303f, 0.15404220f, 0.05844635f, 0.11511306f, 0.30003360f, 
    0.13227271f, 0.03158369f, -0.06162484f, 0.13445753f, 0.00761720f, -0.03557816f, 0.04182958f, -0.05323809f, 
    0.02816221f, -0.06161721f, -0.04253327f, 0.33302608f, 0.16253471f, 0.08329389f, 0.04232028f, -0.07527206f, 
    0.02579134f, 0.12341623f, -0.10346664f, 0.01315621f, -0.29846922f, -0.02338069f, 0.03169272f, -0.13720155f, 
    -0.03844420f, 0.05350126f, 0.11614637f, -0.07550868f, -0.01466222f, -0.04649865f, 0.02031129f, -0.05502433f, 
    0.02565092f, -0.11514307f, 0.09998448f, 0.03918984f, 0.09703262f, -0.07704172f, 0.02715622f, 0.00015060f, 
    -0.12187020f, -0.04312652f, -0.08142331f, 0.04734938f, 0.28123114f, 0.00251227f, -0.01362532f, 0.04638233f, 
    -0.01473639f, 0.13607211f, 0.01532673f, 0.02646976f, 0.00111961f, -0.01752479f, -0.01947157f, 0.02511786f, 
    0.03114219f, -0.04430457f, -0.01251567f, 0.04465867f, 0.00633615f, -0.08161680f, 0.06784789f, 0.11091907f, 
    -0.04931914f, 0.14105527f, -0.10335024f, 0.14054948f, -0.05863481f, 0.01240829f, -0.10472200f, -0.13373522f, 
    0.02318602f, -0.00088434f, -0.03887673f, 0.05900789f, 0.06851943f, -0.01391343f, -0.02648619f, -0.06111952f, 
    -0.05230488f, -0.06179468f, 0.00568500f, 0.13812685f, 0.11919514f, -0.05690964f, 0.06122524f, -0.13984010f, 
    -0.10962539f, 0.02579049f, 0.12103727f, 0.25838137f, 0.36108345f, 0.09606586f, -0.16875581f, 0.04357031f, 
    0.05959870f, -0.02219418f, -0.11391357f, 0.07635953f, -0.00744486f, -0.10308778f, -0.03302363f, -0.08141635f, 
    0.16945802f, -0.06620070f, -0.14462480f, 0.24880101f, 0.09458792f, 0.04875397f, -0.09578796f, -0.02684066f, 
    -0.02469689f, -0.08955729f, 0.06845845f, -0.08946300f, 0.13172911f, 0.00817083f, 0.11579153f, -0.00758234f, 
    0.01660862f, 0.05025632f, 0.13334157f, 0.00464400f, -0.04545563f, -0.01892539f, -0.16790527f, -0.05905284f, 
    0.12546261f, 0.14735352f, 0.15758610f, -0.10374387f, -0.08605350f, -0.09252498f, -0.03269631f, 0.11007418f, 
    0.07902662f, 0.12450314f, -0.01794490f, -0.26840609f, 0.10022637f, 0.14990850f, 0.15364343f, -0.27007002f, 
    -0.01995230f, -0.02017999f, 0.09732698f, -0.04595665f, -0.06089093f, 0.03244134f, -0.05593243f, -0.00511994f, 
    -0.09437092f, -0.13926549f, -0.02266463f, -0.12388381f, -0.14797792f, -0.11372453f, 0.00048242f, 0.04232182f, 
    -0.11182723f, 0.01998279f, 0.01294232f, 0.02405366f, -0.04544175f, -0.16102338f, -0.15073337f, -0.06635492f, 
    -0.06882313f, 0.00941547f, 0.04167056f, -0.02691169f, -0.07351212f, -0.01531905f, -0.12664087f, 0.04831493f, 
    -0.14570175f, 0.15110940f, 0.04990887f, -0.01126004f, -0.06318005f, -0.00603391f, 0.12638631f, 0.05076255f, 
    0.03395726f, 0.02139714f, -0.07763266f, 0.11407649f, 0.10282908f, 0.02685230f, -0.13599624f, 0.22855845f, 
    0.11392709f, 0.05726977f, 0.06732406f, 0.05028425f, 0.07198749f, -0.02754972f, 0.13365674f, 0.12892693f, 
    -0.10688012f, -0.01226741f, -0.06499939f, 0.27524084f, 0.01939994f, 0.11478868f, 0.06250574f, -0.00031801f, 
    0.01744573f, -0.07060940f, -0.10244217f, 0.13199164f, 0.10645295f, 0.10821264f, 0.12787613f, -0.06655300f, 
    0.02080674f, 0.18322015f, -0.00581785f, -0.03208207f, -0.04038250f, 0.02767242f, -0.13778549f, 0.13565081f, 
    0.13449450f, 0.14962406f, -0.15382557f, -0.00151023f, -0.06383952f, -0.01310466f, -0.01347911f, 0.15137531f, 
    0.02624601f, 0.08093172f, 0.11703862f, -0.00368082f, 0.03842277f, 0.03424890f, 0.01862196f, 0.12746185f, 
    -0.07669948f, 0.07065417f, -0.02545223f, 0.15143874f, -0.03102645f, 0.05296335f, 0.09228194f, -0.02421253f, 
    -0.06616545f, 0.20267771f, 0.11707757f, -0.05445593f, 0.04390939f, 0.00579777f, -0.02109071f, -0.02318276f, 
    0.07545532f, 0.02399295f, 0.04026600f, -0.11664494f, 0.11242375f, 0.03780105f, 0.05478945f, 0.14216442f, 
    -0.05049298f, 0.04814306f, 0.05027780f, 0.04465203f, -0.08260817f, -0.02697171f, 0.14503160f, -0.01075955f, 
    0.00075027f, 0.07956939f, 0.11473346f, -0.03806814f, -0.09328205f, 0.08578917f, -0.09870179f, 0.01829372f, 
    0.04172900f, 0.01910633f, -0.06087351f, -0.11315484f, 0.10923548f, 0.18346103f, -0.00176465f, 0.10542677f, 
    0.07715366f, 0.08032475f, -0.01350643f, 0.12420318f, -0.07007945f, -0.00466154f, 0.06516017f, 0.05315273f, 
    -0.09519926f, -0.04363824f, 0.01599585f, 0.00978407f, -0.09141133f, -0.19288169f, -0.01434384f, -0.07203663f, 
    0.15902229f, -0.03901650f, 0.20315142f, 0.15991026f, -0.27236521f, -0.05187390f, -0.04196672f, -0.08928175f, 
    0.02403704f, 0.09132081f, 0.03575077f, 0.04802904f, 0.04489991f, -0.12910542f, -0.00250624f, -0.00107144f, 
    -0.09157994f, -0.09515736f, 0.15549150f, -0.11142368f, 0.11082907f, -0.04285917f, 0.07063556f, 0.10910054f, 
    -0.09022800f, 0.01922809f, 0.05745632f, -0.10121722f, 0.07870808f, 0.03090760f, 0.06556384f, -0.03667429f, 
    -0.11138052f, 0.04328439f, -0.01650548f, 0.06303278f, 0.06104758f, 0.01553855f, 0.05790943f, 0.00766859f, 
    -0.13310559f, 0.17104650f, 0.11208057f, 0.07134634f, -0.03423494f, 0.08259691f, -0.00825385f, 0.05328735f, 
    0.04327295f, -0.06950879f, -0.05697078f, -0.07303935f, 0.06382802f, 0.03317027f, -0.08065729f, 0.21420789f, 
    -0.03922610f, -0.02936495f, -0.01957605f, 0.11771678f, 0.03202579f, -0.03003032f, 0.08516670f, -0.07058893f, 
    -0.17013118f, -0.08136458f, 0.28165975f, -0.04794987f, 0.01152001f, 0.08705938f, 0.13781276f, 0.06710279f, 
    -0.02403870f, -0.03548516f, -0.06578871f, -0.01592544f, 0.06951176f, 0.05109982f, -0.02191066f, -0.04791120f, 
    0.01597958f, -0.03408909f, 0.01391735f, 0.07823165f, -0.06118309f, -0.05328131f, 0.00704027f, -0.14289144f, 
    0.05996111f, -0.01646052f, 0.10122189f, 0.07456647f, -0.20252714f, 0.06044759f, -0.00945042f, 0.06276400f, 
    0.05831584f, 0.08195082f, 0.03335641f, -0.02262591f, 0.00521469f, -0.12222338f, -0.08301812f, 0.00269836f, 
    -0.12280808f, -0.16322069f, -0.06269850f, 0.19253373f, -0.07728676f, -0.03015526f, 0.12872978f, -0.01676982f, 
    -0.00504318f, -0.02670109f, 0.18654123f, -0.08718544f, -0.07518487f, -0.03940788f, 0.02518281f, 0.03838288f, 
    0.05174738f, 0.03117544f, -0.09377615f, 0.10438584f, -0.08626211f, 0.05003646f, -0.01353969f, 0.25158593f, 
    -0.06738200f, 0.03904522f, 0.11215702f, 0.09156857f, 0.18304059f, 0.06099078f, -0.11158520f, 0.17494869f, 
    0.15689458f, 0.00614707f, -0.02494338f, 0.17725649f, -0.03061841f, -0.03551395f, 0.07815884f, 0.25404930f, 
    0.01878274f, -0.01551093f, -0.02552814f, -0.06791773f, -0.04859436f, -0.12508151f, 0.13328810f, -0.33456454f, 
    0.03117098f, 0.06874401f, 0.04112092f, 0.02217238f, -0.03249007f, -0.08500320f, -0.05140412f, -0.01016086f, 
    -0.20057213f, 0.13841876f, 0.12860955f, 0.06373852f, -0.03973553f, 0.00384055f, -0.05411551f, 0.02308452f, 
    0.04657921f, 0.10032700f, -0.03559442f, -0.11261027f, 0.31856608f, 0.26601377f, -0.16787037f, -0.00512562f, 
    -0.10556763f, 0.08867201f, 0.11439696f, 0.07357721f, -0.02311027f, -0.08057254f, -0.01684184f, -0.04191239f, 
    0.24134713f, 0.22674277f, -0.02633398f, -0.06743877f, -0.00109010f, -0.10313177f, -0.06313458f, 0.03159475f, 
    -0.01404057f, -0.02437239f, -0.03756532f, 0.12487687f, 0.05563677f, 0.07835457f, 0.15789525f, -0.10148935f, 
    0.00869937f, 0.13209353f, -0.06350353f, -0.09748971f, 0.10496090f, -0.08502223f, 0.07601988f, -0.18188269f, 
    -0.23284079f, -0.13081048f, 0.20856638f, 0.09562773f, 0.11882560f, -0.20713827f, -0.03998850f, 0.00083902f, 
    0.04860977f, 0.01092261f, 0.14765564f, 0.13468753f, 0.00260958f, -0.05706013f, 0.00326689f, -0.09466735f, 
    -0.10815867f, -0.01063536f, 0.04405720f, 0.07379179f, -0.05001141f, -0.03608860f, 0.09028848f, -0.13358372f, 
    0.09907626f, 0.02006263f, 0.16808695f, 0.20582952f, -0.07067969f, 0.09436774f, -0.00503831f, -0.01961432f, 
    0.11028450f, 0.13797745f, -0.07842910f, 0.03921577f, 0.13820143f, -0.07848541f, -0.11451923f, 0.21678631f, 
    -0.05692080f, 0.05071355f, 0.09819702f, -0.09824409f, -0.11159860f, -0.01468029f, 0.08339122f, 0.12984213f, 
    0.12857071f, -0.06924096f, 0.16421837f, 0.05814769f, 0.01929076f, 0.00781040f, -0.02679598f, 0.01288427f, 
    0.01277303f, 0.04587759f, 0.00726314f, -0.07920457f, 0.09636368f, -0.02459915f, 0.03401908f, 0.05500550f, 
    -0.01276481f, 0.15940112f, -0.02480623f, 0.08999031f, -0.06254121f, -0.01429652f, 0.05564862f, -0.04800615f, 
    -0.10039958f, -0.07715045f, 0.18859564f, 0.01713290f, -0.08794591f, 0.02878964f, 0.17319907f, 0.07592747f, 
    -0.03188349f, -0.10927150f, 0.12610213f, -0.04208605f, 0.03859082f, 0.14706658f, 0.01191489f, 0.15023927f, 
    -0.13022248f, 0.07777843f, 0.10166712f, 0.04299105f, 0.13333267f, 0.07229781f, 0.10675997f, 0.10874501f, 
    0.08172353f, 0.12924710f, -0.07131703f, 0.19605440f, 0.18659723f, 0.03773033f, 0.08569434f, -0.01260365f, 
    0.00897938f, -0.14673887f, -0.10090977f, -0.04309420f, -0.05581436f, -0.01717649f, -0.11803205f, -0.05995081f, 
    -0.10181142f, -0.08684430f, 0.08929729f, -0.09192723f, 0.01428706f, 0.04665858f, 0.04415673f, 0.05158473f, 
    0.00283300f, -0.08137932f, 0.14429696f, 0.04484404f, 0.07035587f, -0.00277700f, 0.20910370f, 0.10373760f, 
    -0.07879239f, 0.02472921f, 0.05724253f, -0.05923824f, -0.06235878f, -0.14910021f, 0.19725059f, -0.09918249f, 
    -0.04169403f, 0.07288779f, -0.01733939f, 0.11860356f, -0.10180693f, 0.11936607f, -0.01338502f, -0.14817609f, 
    0.07190815f, 0.09817595f, -0.00505017f, 0.01618711f, -0.06945739f, 0.16888227f, 0.09976000f, 0.04450491f, 
    -0.10219620f, -0.10760567f, 0.03916569f, -0.05895631f, 0.17564312f, -0.04945558f, -0.04586548f, 0.12677935f, 
    -0.07609175f, -0.11735709f, 0.10901545f, 0.03461018f, -0.06084907f, 0.06009158f, -0.14199102f, 0.16000199f, 
    0.07639796f, -0.20826013f, -0.06112339f, -0.13050780f, -0.06891272f, -0.00897468f, 0.08122214f, 0.02114372f, 
    -0.03816753f, 0.03243982f, -0.03071174f, -0.03970812f, 0.09067649f, -0.06588585f, 0.09500625f, 0.01194908f, 
    0.05252124f, 0.02189203f, 0.08723459f, 0.05115319f, -0.00167052f, 0.07586054f, -0.02338706f, 0.23689364f, 
    -0.10857280f, -0.17661025f, 0.08160520f, -0.23688608f, -0.00981817f, -0.14479695f, 0.02487568f, -0.03418733f, 
    0.04121752f, 0.20521349f, -0.04741608f, -0.00356182f, -0.09475501f, -0.00200576f, -0.01358927f, -0.09683600f, 
    -0.06439680f, 0.04218025f, -0.04753377f, 0.08501469f, 0.11699118f, -0.01269928f, 0.21955782f, -0.12295918f, 
    -0.19496100f, 0.01902460f, 0.03857637f, -0.01777319f, -0.08071731f, 0.04208548f, 0.07000566f, 0.05406692f, 
    0.01567324f, -0.01201501f, -0.01914632f, 0.12192628f, 0.12457874f, -0.03338541f, 0.06976309f, 0.03661976f, 
    -0.01951038f, 0.02043120f, 0.03222312f, -0.09873694f, -0.13933042f, -0.06457215f, 0.13707678f, -0.07581508f, 
    0.09868889f, -0.03050459f, -0.09717300f, 0.10883600f, -0.05603213f, 0.00413749f, 0.02452276f, 0.10868897f, 
    -0.00889295f, 0.12155248f, -0.06451543f, -0.04166385f, 0.20991285f, 0.06568365f, -0.08214238f, 0.03542367f, 
    -0.00389916f, 0.03195740f, -0.11010768f, 0.15206903f, -0.02302651f, -0.00818382f, 0.08738367f, -0.01273083f, 
    0.42201826f, -0.01727524f, 0.13605411f, 0.12407196f, -0.03057869f, 0.01960180f, 0.06194867f, 0.02588126f, 
    0.04345617f, 0.13204283f, 0.00719798f, 0.01024452f, -0.07829567f, 0.05646851f, 0.10346850f, -0.06829634f, 
    -0.05648497f, 0.02430125f, 0.02170867f, -0.09808578f, -0.05320384f, 0.02003957f, -0.13340417f, -0.05681904f, 
    -0.16685569f, -0.05730169f, 0.03057502f, 0.09226840f, -0.04567371f, -0.05909541f, -0.05061740f, -0.00038451f, 
    -0.05365182f, -0.01220283f, -0.07204275f, -0.06131724f, 0.20313486f, 0.09252968f, -0.01708131f, -0.13163862f, 
    0.04624141f, 0.05803706f, -0.04373425f, 0.13659832f, 0.10568316f, -0.10189384f, 0.02516275f, -0.02771762f, 
    -0.11297454f, 0.15914302f, 0.10498820f, 0.10048357f, 0.02972823f, -0.00289597f, 0.06002508f, 0.02375290f, 
    -0.00351211f, 0.10182949f, 0.02420533f, 0.13055618f, 0.19870928f, 0.08973365f, 0.07549427f, -0.00929013f, 
    0.02958865f, -0.08653425f, -0.13494335f, -0.11876779f, 0.00477911f, -0.05176528f, 0.03140416f, -0.04736866f, 
    0.13967669f, -0.00018494f, -0.18647365f, -0.02291287f, 0.05809871f, 0.04257437f, 0.13599505f, -0.01836101f, 
    -0.05021470f, 0.12708478f, 0.19317387f, 0.07468570f, 0.25237179f, 0.00302854f, -0.10235593f, -0.04656238f, 
    0.06662461f, -0.02173326f, -0.09427524f, 0.02906621f, 0.03230882f, -0.08412281f, 0.12768859f, -0.07939219f, 
    -0.23323371f, 0.11980117f, 0.01156645f, -0.06071821f, -0.00662665f, 0.04347076f, 0.04810437f, 0.03161689f, 
    0.06578336f, -0.13457997f, 0.08929505f, 0.01441403f, 0.19050640f, 0.20228338f, 0.02526019f, -0.27245453f, 
    -0.03640527f, -0.04033963f, 0.00665500f, 0.03524371f, 0.00409011f, -0.14737189f, -0.08603182f, 0.02296646f, 
    -0.18699957f, -0.11999684f, 0.06798477f, -0.13873066f, -0.09991311f, -0.11528850f, -0.18234065f, -0.08273330f, 
    0.04887015f, 0.12000719f, 0.06389882f, -0.05990088f, -0.03850653f, 0.09980906f, 0.05302486f, -0.17484990f, 
    -0.00183550f, -0.03280560f, 0.05249491f, -0.03341510f, 0.00324831f, 0.00256881f, -0.02614043f, -0.12487531f, 
    0.08963615f, -0.02845213f, 0.18489717f, -0.01080019f, -0.00817055f, -0.05283447f, -0.06143031f, 0.10517762f, 
    0.00806196f, 0.04489595f, 0.02836018f, 0.18063846f, 0.09374449f, -0.19833951f, 0.03861536f, -0.08928270f, 
    0.00237421f, 0.01987518f, -0.06901599f, -0.02736527f, -0.03346545f, -0.03551863f, 0.01956818f, -0.04885236f, 
    -0.25029168f, 0.02585769f, -0.16334932f, -0.01810446f, 0.08832770f, 0.00707375f, 0.18183851f, -0.04006272f, 
    -0.03836108f, 0.04969780f, -0.08879195f, -0.01008287f, -0.06441665f, 0.19089630f, -0.09986750f, -0.10231017f, 
    -0.02007181f, -0.01708723f, 0.06202047f, 0.08326072f, 0.06853960f, 0.04495696f, 0.06546497f, 0.01511315f, 
    0.36043519f, -0.08265082f, -0.00335273f, 0.15447362f, 0.12311938f, -0.02682910f, 0.03081721f, -0.13256498f, 
    -0.02430341f, 0.03917216f, 0.00172634f, 0.02145112f, 0.22414713f, 0.04892047f, 0.04086321f, 0.01088597f, 
    0.04492578f, 0.17326406f, -0.06880725f, -0.05163142f, -0.01701622f, 0.02454792f, -0.06077109f, 0.10232677f, 
    0.09169079f, 0.15893523f, -0.08302868f, 0.05189264f, 0.01146407f, -0.05848823f, -0.00705269f, 0.09184685f, 
    0.06989209f, -0.03219403f, 0.01865648f, 0.00729812f, -0.00779914f, 0.09423843f, 0.01260998f, 0.03959978f, 
    0.00306517f, 0.02845318f, 0.00797737f, 0.14922518f, 0.07517769f, -0.05670711f, 0.16193914f, -0.07302797f, 
    -0.12678933f, 0.00332716f, 0.13568845f, 0.00866710f, -0.03025817f, 0.07216706f, -0.02377842f, -0.09539792f, 
    0.06792916f, -0.00372932f, 0.12073547f, -0.15050624f, 0.03125976f, -0.06614351f, -0.04064103f, 0.08316025f, 
    0.00598962f, 0.08462019f, -0.13030191f, -0.06585024f, 0.03839630f, -0.08570628f, -0.03970437f, 0.10233171f, 
    -0.01548280f, -0.09426795f, 0.09740735f, -0.05723234f, 0.00565835f, 0.04487669f, -0.11498567f, 0.02138829f, 
    -0.00095941f, -0.01382085f, 0.06484158f, -0.09458126f, -0.25904861f, 0.19221832f, -0.19939058f, -0.07794804f, 
    0.04907683f, -0.03324920f, -0.07913280f, 0.00979348f, 0.03859138f, -0.04216475f, 0.13031659f, -0.09052748f, 
    0.22494867f, -0.03856731f, 0.06989506f, 0.12089006f, -0.06357200f, -0.06647307f, 0.12585510f, -0.01113834f, 
    0.02421434f, 0.00630831f, 0.23207521f, 0.12640214f, -0.20379654f, -0.10129248f, -0.10191420f, -0.23415808f, 
    0.09987973f, 0.07925929f, -0.02110661f, -0.12836267f, 0.04887725f, -0.13969891f, -0.07256123f, -0.00978047f, 
    -0.00919748f, 0.03839988f, 0.02902704f, -0.06132212f, -0.00494352f, 0.04620275f, 0.07241005f, 0.04246379f, 
    0.08505379f, 0.03241944f, 0.04998948f, 0.12774576f, -0.15786125f, -0.15507312f, -0.08716460f, 0.01287025f, 
    -0.06443301f, -0.04133161f, -0.07652401f, -0.06939647f, -0.01292406f, -0.08723778f, 0.00166729f, 0.05602795f, 
    -0.25589457f, -0.05173140f, 0.10221592f, 0.02642216f, -0.06292160f, -0.04639688f, -0.15365778f, -0.02585843f, 
    0.08224805f, -0.09776267f, 0.03033703f, 0.00440685f, -0.07726031f, -0.01996524f, -0.06114028f, 0.13209872f, 
    -0.02681160f, 0.07882805f, 0.20216180f, 0.11057189f, 0.02296492f, -0.05927516f, 0.00855061f, 0.07420424f, 
    -0.34802604f, -0.00580935f, 0.11364346f, -0.13154523f, -0.12189804f, -0.00648743f, 0.01321760f, 0.04287616f, 
    0.03347617f, -0.01330382f, -0.05983173f, 0.00883830f, -0.12295284f, 0.02840115f, -0.05655612f, 0.00183614f, 
    -0.03739481f, -0.14011359f, -0.14526658f, -0.09001727f, 0.06165152f, -0.04915895f, 0.03096871f, 0.03564106f, 
    -0.19088541f, -0.22349097f, -0.16151889f, 0.13047092f, 0.00891747f, 0.11887521f, -0.07263840f, -0.03486518f, 
    0.00189858f, 0.06427441f, -0.00131870f, 0.02896877f, 0.00108740f, 0.01485768f, -0.04841421f, 0.09539633f, 
    0.05323170f, 0.07035990f, 0.12163951f, 0.14926802f, -0.01685089f, 0.00536732f, 0.01729424f, -0.03744932f, 
    0.09440045f, 0.09762338f, 0.27246028f, -0.07874847f, 0.10617457f, -0.00203780f, 0.04745311f, 0.12154663f, 
    0.07613964f, -0.02517602f, -0.03535668f, 0.20486054f, -0.04823491f, -0.10455108f, -0.27105808f, 0.12167297f, 
    0.03681803f, 0.02824064f, 0.02384800f, -0.02154583f, 0.06897066f, 0.02724423f, -0.04285628f, 0.17524078f, 
    0.06063255f, 0.07553389f, 0.11228710f, -0.10328441f, -0.02569921f, -0.07206137f, 0.02677368f, 0.16214594f, 
    0.16576456f, -0.09915646f, 0.09567716f, -0.05008574f, 0.00882533f, 0.09281599f, 0.08357528f, -0.10933603f, 
    0.02579348f, -0.01021430f, -0.06972627f, 0.01336178f, 0.08501223f, -0.09419838f, -0.06514339f, -0.10408220f, 
    -0.44604033f, -0.05375819f, 0.08345711f, 0.06771026f, -0.06549767f, -0.03213970f, -0.14052235f, 0.00636127f, 
    0.01363896f, 0.03917941f, -0.07789546f, -0.00218705f, 0.09348106f, 0.22052281f, -0.01082202f, 0.17245381f, 
    0.03590801f, -0.08085217f, -0.03627507f, 0.01675661f, 0.01954984f, 0.02238089f, -0.04978623f, -0.02304226f, 
    0.12626661f, 0.05514074f, 0.33254483f, -0.07752978f, -0.03491883f, -0.03898846f, -0.03441340f, 0.08197896f, 
    -0.03671612f, 0.06254350f, -0.12871175f, 0.02430551f, -0.00837539f, 0.04672262f, 0.14142147f, -0.05226764f, 
    0.03965508f, 0.06133190f, -0.05151538f, -0.21225761f, 0.06491818f, -0.03878087f, -0.07413276f, -0.09835235f, 
    -0.13825932f, 0.12414405f, 0.03298409f, -0.00580305f, -0.00690209f, 0.02548356f, 0.06450249f, 0.04676491f, 
    0.06963689f, 0.16190939f, 0.02504700f, 0.11703439f, -0.04636762f, -0.18962446f, -0.07241384f, -0.06410323f, 
    -0.03906642f, 0.05052885f, -0.10294985f, -0.05825528f, 0.01631707f, -0.00298562f, -0.02696896f, -0.04784945f, 
    0.08515164f, -0.03762855f, 0.11016913f, 0.09161542f, 0.06499554f, 0.04157520f, 0.05956664f, -0.08781490f, 
    0.10286406f, -0.01130661f, -0.05704700f, -0.05493170f, -0.07175606f, 0.04936873f, -0.00186397f, -0.11755423f, 
    -0.06295731f, 0.02345330f, 0.04961378f, 0.03645587f, -0.05884960f, 0.04603254f, -0.11957474f, 0.19495085f, 
    0.32231238f, -0.16927272f, 0.14722754f, 0.14313306f, -0.01438972f, -0.14250702f, -0.04485676f, -0.15083934f, 
    0.11147598f, 0.08247905f, 0.09328933f, -0.08313885f, 0.00731015f, 0.05127512f, -0.08422802f, -0.08321474f, 
    -0.04054107f, 0.01657917f, 0.00165691f, -0.06377864f, -0.06323603f, -0.01348181f, 0.14875869f, 0.00235738f, 
    -0.32219195f, -0.06315679f, 0.06842893f, 0.03625372f, -0.08066081f, 0.14413105f, 0.08301755f, 0.05695153f, 
    0.03874618f, 0.01007089f, -0.00197515f, -0.00658116f, 0.01707582f, -0.09225854f, 0.01556454f, -0.11208457f, 
    0.00893328f, 0.00915477f, -0.04916134f, -0.09934661f, 0.08026942f, 0.05643532f, 0.13998565f, -0.03903749f, 
    0.05352321f, 0.14584775f, 0.03837492f, 0.17009777f, 0.03266268f, -0.08807166f, 0.11627955f, -0.02786167f, 
    0.01977059f, -0.07287416f, -0.11091596f, -0.06163890f, 0.11575380f, 0.00905293f, 0.18028621f, 0.01441028f, 
    -0.13201617f, -0.00069785f, 0.15053421f, 0.06938569f, 0.00353855f, 0.09722858f, 0.07726921f, -0.01915834f, 
    0.08407982f, -0.15242709f, 0.03257298f, 0.09739913f, -0.00406475f, 0.04676048f, 0.09564551f, -0.00104394f, 
    0.11455196f, 0.09438444f, -0.10702971f, -0.01800460f, 0.20340326f, 0.22414689f, 0.10442588f, -0.11425516f, 
    0.11123560f, 0.11235249f, 0.08792214f, 0.08517836f, 0.05508998f, -0.00301947f, -0.01840658f, -0.03459307f, 
    0.08794106f, 0.06865223f, -0.04370992f, 0.04404273f, -0.05735082f, 0.08575934f, -0.05618042f, -0.10796443f, 
    -0.07612047f, -0.09643478f, -0.00596651f, 0.03580510f, 0.15108539f, 0.06041918f, 0.01901595f, -0.01920061f, 
    -0.07450511f, 0.03308430f, 0.08806165f, 0.11227531f, -0.09831134f, 0.09328372f, -0.06953985f, 0.03699310f, 
    0.11782897f, -0.13151895f, -0.08788931f, 0.10460468f, -0.01917562f, -0.09141640f, -0.01757860f, -0.06214207f, 
    0.03714453f, 0.09977674f, 0.04074689f, -0.06246202f, 0.02197826f, 0.07480582f, -0.02788195f, -0.18216790f, 
    0.00828247f, 0.01233235f, 0.18977776f, -0.02336201f, 0.03129363f, 0.03131666f, -0.04967387f, 0.19436851f, 
    0.12231602f, 0.12949973f, -0.03484126f, 0.07905626f, 0.03927276f, -0.14290093f, -0.00226795f, 0.09297138f, 
    0.07372434f, 0.13450913f, -0.03838427f, 0.07259574f, 0.07685034f, 0.07241230f, -0.00874828f, 0.10911983f, 
    -0.02859569f, 0.12013535f, 0.02482898f, 0.08924101f, -0.04106532f, -0.04182617f, 0.10708585f, -0.04626262f, 
    -0.23303251f, -0.13107350f, 0.08670839f, 0.04594260f, -0.00276917f, 0.06907298f, 0.08234534f, -0.15626149f, 
    -0.01830628f, 0.11148549f, 0.00391211f, 0.12098005f, 0.02212474f, -0.09746341f, 0.02261835f, -0.10790499f, 
    0.10724846f, -0.14746854f, 0.08552313f, -0.06077881f, 0.00294480f, -0.06346055f, 0.04752403f, -0.03858672f, 
    0.01828311f, 0.19197695f, 0.00140305f, 0.11607537f, 0.03878361f, 0.02756496f, 0.03613925f, -0.03812436f, 
    -0.01484610f, 0.04844015f, 0.07343233f, 0.00063428f, 0.07639957f, 0.13732290f, -0.00079356f, -0.00111636f, 
    0.00693098f, 0.02630223f, 0.01798513f, 0.09211121f, -0.05659540f, 0.08487236f, 0.11786163f, 0.00994095f, 
    -0.06917201f, 0.17380475f, 0.17397819f, -0.14827962f, 0.07477639f, -0.05382578f, 0.19245155f, 0.08958807f, 
    -0.00635352f, 0.10849018f, 0.02108924f, 0.05159420f, 0.39373368f, -0.21874583f, 0.12003132f, 0.15601443f, 
    0.03837126f, 0.07435638f, -0.00900965f, 0.04710910f, 0.03269849f, -0.01614563f, 0.01953321f, 0.05015318f, 
    -0.07130658f, 0.23878725f, 0.09135420f, -0.00607983f, 0.00160762f, -0.01804746f, -0.10436484f, 0.06647450f, 
    -0.01001533f, 0.04882056f, -0.03088892f, 0.05072818f, -0.00911487f, -0.12054366f, 0.01447453f, -0.03852827f, 
    0.03584299f, 0.04124119f, 0.07958655f, 0.10447706f, 0.03581333f, 0.04290302f, -0.00782218f, 0.04882881f, 
    -0.03329556f, -0.04006756f, 0.11001299f, -0.13285223f, 0.03152503f, 0.06494608f, 0.04839556f, -0.00554377f, 
    0.01037103f, 0.05032104f, 0.07648756f, 0.18719459f, 0.08460931f, -0.09854628f, 0.04769654f, 0.04588130f, 
    -0.04076096f, -0.01151958f, 0.05203393f, -0.08885158f, -0.02272188f, -0.02592260f, 0.12181818f, 0.02388447f, 
    -0.14470044f, 0.19001311f, 0.15126336f, 0.03111443f, 0.10548708f, 0.02308784f, 0.00617010f, 0.06024435f, 
    0.02290261f, 0.04270187f, 0.05687262f, 0.17732175f, 0.08260728f, -0.14749162f, 0.04359681f, 0.04895610f, 
    0.07266484f, -0.05519869f, 0.02876791f, 0.00503180f, 0.01913089f, -0.01753597f, 0.07337157f, -0.01945130f, 
    0.01067419f, 0.12832090f, -0.00604521f, 0.16697705f, -0.01191515f, 0.05266643f, 0.00655918f, 0.04050071f, 
    0.06051426f, 0.07151067f, 0.01494758f, -0.04636293f, 0.12473337f, 0.00135388f, 0.09349198f, 0.20070608f, 
    -0.02328506f, 0.07346090f, 0.09478420f, -0.03863773f, 0.11240249f, -0.04533581f, 0.00428531f, -0.05684174f, 
    -0.00467041f, 0.06292462f, 0.05910932f, -0.05516658f, 0.07704577f, -0.01499541f, -0.07928433f, -0.05034784f, 
    -0.00880640f, 0.02514669f, 0.05049030f, 0.04294396f, 0.14532943f, -0.02526810f, -0.20100978f, -0.01623621f, 
    0.13535413f, 0.03086056f, -0.01976728f, 0.05699028f, 0.04051064f, 0.02354998f, 0.03404708f, 0.01076519f, 
    -0.03366425f, 0.06001567f, -0.16887797f, -0.07399548f, -0.00748339f, 0.05988641f, 0.05074238f, -0.03793482f, 
    0.02722600f, 0.06295572f, 0.13366586f, -0.00433405f, -0.18104047f, 0.10166173f, 0.01751439f, -0.19951269f, 
    -0.08031210f, 0.04309565f, 0.04040058f, -0.15214641f, 0.03342606f, 0.07502828f, -0.04642711f, -0.07814578f, 
    0.24008539f, -0.05531378f, 0.12835935f, 0.11093041f, 0.04000535f, -0.07672930f, 0.04982789f, -0.01575154f, 
    0.08352011f, 0.11077425f, 0.00747486f, -0.01434326f, -0.01790202f, 0.00853161f, 0.04331756f, 0.11493541f, 
    0.01328190f, -0.00878467f, 0.02401307f, -0.04343972f, 0.09834932f, 0.17066002f, 0.08809497f, 0.01733628f, 
    -0.25010052f, 0.28023443f, 0.18352096f, -0.11687913f, -0.00844073f, 0.01550225f, 0.06128563f, -0.10322333f, 
    -0.03931607f, 0.02226032f, 0.04946702f, -0.00299277f, -0.08689426f, 0.08101001f, -0.19461255f, -0.02127684f, 
    0.06285589f, 0.14205195f, 0.08102126f, 0.05929663f, 0.03569566f, 0.03475888f, 0.01495625f, 0.09407856f, 
    -0.06637523f, 0.02395557f, -0.05504944f, -0.12065751f, 0.03962099f, -0.02401370f, 0.00456731f, -0.00009123f, 
    0.10008086f, 0.07155144f, 0.06473432f, 0.04250390f, -0.09907755f, -0.12240400f, 0.17202584f, -0.08422506f, 
    0.09589399f, 0.03254479f, 0.04670813f, 0.04106034f, 0.06236226f, -0.02459932f, 0.13974205f, 0.12986848f, 
    0.11302007f, 0.01976899f, -0.06904513f, -0.05270272f, 0.07025335f, 0.08464380f, 0.02256140f, 0.01943346f, 
    0.10025521f, 0.01349269f, -0.02942830f, -0.01294796f, 0.07892792f, -0.18534936f, 0.26528829f, -0.01448745f, 
    0.14062147f, 0.02251502f, -0.05545552f, 0.04872031f, 0.10594807f, -0.04840833f, 0.07225338f, 0.18870321f, 
    0.02323202f, 0.08812879f, -0.10623303f, 0.06315484f, 0.16448814f, 0.03629154f, -0.09374596f, 0.00309128f, 
    -0.08104642f, 0.01179387f, -0.01936436f, -0.17673580f, 0.15116480f, -0.02383693f, -0.10655897f, -0.05727378f, 
    0.00027015f, 0.00396067f, -0.04882719f, -0.06561503f, 0.00179697f, -0.05040215f, 0.12884411f, -0.06056018f, 
    -0.03112981f, 0.13160165f, 0.03040740f, -0.02910131f, 0.06653422f, -0.04192369f, 0.08586428f, -0.00610049f, 
    -0.00669649f, -0.01021893f, 0.07982720f, 0.08003190f, 0.12015641f, 0.05029002f, 0.02216335f, 0.29212588f, 
    0.06308055f, 0.14623716f, -0.01825497f, 0.09723178f, -0.07028698f, -0.04435140f, 0.10861128f, 0.01362198f, 
    -0.12093179f, 0.02165633f, -0.17415372f, 0.00814420f, -0.04553712f, 0.05132591f, 0.05454714f, 0.11972637f, 
    0.02029117f, 0.02656234f, -0.03151120f, 0.03081622f, 0.12956099f, 0.12763128f, -0.16163953f, 0.04086533f, 
    -0.01698746f, 0.10122861f, 0.00536316f, 0.01331507f, -0.02712946f, 0.01099581f, 0.04456482f, -0.07182097f, 
    0.12152673f, -0.01929788f, -0.06197867f, -0.07254873f, 0.03699008f, 0.02380603f, -0.05744734f, -0.01408191f, 
    0.02035659f, -0.05695343f, 0.02844156f, -0.01471899f, -0.18891241f, -0.01761213f, 0.02771545f, -0.22509952f, 
    -0.00826273f, 0.02376599f, 0.14985554f, 0.02795700f, 0.05213279f, -0.02850401f, 0.04678894f, -0.02809582f, 
    0.05457187f, 0.09214782f, -0.19471203f, 0.12410949f, 0.06406665f, 0.08308964f, -0.04085079f, 0.10162797f, 
    0.03421305f, -0.02504908f, -0.07987031f, -0.00931110f, -0.05593455f, 0.03394265f, -0.06350110f, 0.05736389f, 
    0.11270919f, -0.03309261f, 0.00134147f, -0.05304820f, -0.02863154f, -0.00852541f, -0.05223825f, -0.07405581f, 
    0.13467455f, 0.11891996f, -0.06227006f, -0.08827686f, 0.07426219f, 0.09317832f, 0.00906161f, -0.00709643f, 
    0.07660513f, 0.13077192f, 0.01465621f, -0.02554653f, -0.15527152f, 0.07255016f, -0.09136381f, -0.10468977f, 
    0.02398088f, -0.02719401f, 0.04987646f, 0.01812459f, 0.03563840f, 0.04536629f, 0.12594490f, 0.00701266f, 
    0.05248904f, -0.04908336f, -0.02886724f, -0.02579989f, -0.01148812f, 0.09925532f, 0.04063011f, 0.01388687f, 
    0.10632665f, -0.00775481f, 0.11867326f, 0.13897696f, 0.00532241f, 0.07435957f, 0.06289598f, -0.17182107f, 
    0.09686198f, -0.01066966f, -0.01156206f, -0.03343410f, 0.08179142f, 0.08846267f, -0.04342526f, 0.11696471f, 
    -0.10236156f, -0.01162703f, -0.00871422f, 0.04455763f, -0.06381276f, 0.00710307f, 0.08840736f, 0.00781852f, 
    0.00086481f, -0.05656223f, 0.01999969f, -0.10577668f, 0.04469805f, 0.03958973f, -0.15814796f, 0.09564649f, 
    -0.04623454f, 0.05815791f, -0.08781514f, 0.10457902f, 0.04833150f, -0.03035046f, -0.06971233f, 0.02563944f, 
    0.21660303f, 0.03973878f, -0.13267440f, -0.01180768f, 0.14000627f, -0.04212851f, 0.00756635f, -0.05242878f, 
    0.02742921f, 0.02299701f, -0.03696964f, 0.02104472f, 0.01336063f, -0.13371062f, 0.20945248f, 0.06393549f, 
    -0.02711309f, -0.09246090f, 0.05642480f, 0.05289098f, 0.05533407f, 0.08902881f, 0.07174646f, -0.02779196f, 
    0.16115139f, -0.16299848f, 0.06264742f, 0.07842335f, 0.16550510f, 0.06289221f, 0.10092462f, -0.04750589f, 
    0.05826228f, 0.08140919f, -0.00936948f, 0.18981650f, -0.00300794f, -0.04698621f, -0.14896977f, -0.04470337f, 
    -0.01932793f, 0.05777496f, 0.00861741f, 0.08659739f, 0.00652509f, -0.00855729f, -0.02040353f, 0.00255476f, 
    -0.06674474f, 0.10175242f, -0.12894854f, -0.01873956f, 0.04995003f, 0.09148233f, 0.02757066f, -0.06115631f, 
    -0.04355590f, 0.09698159f, 0.05130803f, 0.07734507f, 0.37990582f, -0.02880565f, -0.17421325f, -0.07365476f, 
    0.09222949f, 0.08061010f, 0.05193046f, 0.08267124f, 0.02027029f, -0.01820120f, -0.05568013f, 0.00257933f, 
    -0.06027740f, 0.09559767f, 0.08747416f, -0.15677580f, -0.03474838f, 0.01329979f, 0.06308421f, -0.03051529f, 
    0.07497825f, 0.06088457f, 0.07887189f, -0.01036655f, -0.20631173f, 0.19133374f, 0.13154000f, -0.09548592f, 
    0.02510244f, -0.06701566f, 0.12696265f, 0.00160118f, -0.00720197f, 0.07322635f, -0.00192397f, 0.06957851f, 
    -0.20090650f, 0.16906741f, -0.14658123f, -0.20495994f, 0.02800498f, -0.08849887f, 0.06990469f, -0.04061718f, 
    0.06871990f, 0.02619806f, 0.07972472f, 0.01592276f, -0.30988833f, 0.20019205f, -0.02640367f, 0.05232301f, 
    0.06575554f, 0.09232272f, 0.07353666f, -0.00545462f, 0.01765450f, -0.03098163f, 0.10306337f, 0.06498522f, 
    -0.17024489f, 0.27057230f, 0.03615474f, 0.02879735f, 0.06426152f, 0.14536522f, -0.06853598f, 0.09851267f, 
    0.02840014f, 0.04326817f, 0.05270118f, 0.02558311f, -0.07174081f, 0.02688577f, 0.04501705f, -0.11673228f, 
    -0.01607947f, 0.02516572f, -0.02791666f, -0.03026595f, 0.05068160f, 0.03289697f, 0.12144773f, 0.10527379f, 
    -0.19262184f, 0.14493436f, 0.07258616f, 0.10465985f, -0.04781786f, -0.00217089f, 0.12971526f, -0.00944892f, 
    -0.00445470f, 0.07868310f, -0.02207228f, -0.08989710f, -0.07151415f, -0.10516738f, -0.04916510f, 0.13738242f, 
    -0.05094739f, 0.02999180f, 0.07297327f, 0.15700614f, -0.00802803f, 0.02515524f, 0.08715001f, -0.00712160f, 
    0.10036922f, 0.24280517f, -0.15826279f, 0.03884084f, -0.10783625f, 0.05865182f, -0.06548136f, 0.13630259f, 
    -0.01980557f, -0.03181140f, 0.02185659f, 0.03202159f, 0.03496968f, 0.03769663f, -0.03611840f, 0.13155942f, 
    0.10312353f, 0.14773190f, 0.03347826f, 0.15992215f, 0.06323927f, 0.00676007f, -0.00780974f, 0.01780192f, 
    0.30818820f, 0.01078659f, 0.01640701f, -0.16984706f, 0.06590298f, 0.02219757f, 0.03602129f, 0.05631802f, 
    -0.01338369f, -0.08420029f, -0.05655459f, 0.05994065f, 0.01935882f, -0.02036525f, 0.09597745f, -0.01163367f, 
    -0.09289175f, 0.02357688f, 0.06662370f, -0.08128338f, 0.07379559f, 0.08528455f, 0.00351933f, 0.13073780f, 
    -0.10490990f, 0.21340428f, -0.04754012f, 0.13618289f, -0.01761597f, 0.11251024f, -0.00212382f, 0.13121718f, 
    0.09174731f, 0.03575640f, 0.06506250f, -0.01056104f, 0.05553768f, -0.15772359f, 0.02008882f, -0.00861076f, 
    -0.04501645f, 0.07135934f, -0.02440203f, 0.08141775f, 0.02401095f, -0.03081448f, 0.05869275f, 0.12170036f, 
    0.20536008f, 0.03488854f, 0.03770093f, 0.10522984f, -0.06974892f, 0.02694008f, 0.00757068f, 0.01227805f, 
    0.07577315f, 0.10163964f, 0.04451687f, 0.04897750f, 0.05847374f, 0.02583786f, -0.13911636f, -0.06381464f, 
    -0.01127529f, 0.03484414f, -0.04269368f, -0.01274059f, 0.03726272f, 0.00851685f, 0.07944636f, 0.03971349f, 
    0.37763703f, 0.10750244f, -0.09300198f, 0.11361172f, 0.06292128f, 0.03641229f, -0.10560966f, 0.04416647f, 
    0.02333413f, 0.06966154f, 0.05846547f, 0.04223107f, 0.12727183f, -0.03439278f, 0.04968743f, -0.08201972f, 
    -0.04105934f, 0.07534199f, 0.09333199f, -0.00128882f, -0.00088485f, 0.00381576f, 0.11159614f, -0.02533901f, 
    -0.13993950f, 0.09773020f, 0.14275397f, -0.06151776f, -0.02265744f, -0.02286550f, 0.02633683f, -0.02840001f, 
    -0.00100009f, 0.10795216f, -0.02785729f, 0.09616223f, -0.07386721f, -0.13956153f, 0.01677437f, -0.00000357f, 
    0.05049239f, 0.03774875f, -0.02785883f, 0.06502280f, 0.04981013f, 0.05541040f, 0.01690441f, -0.00107930f, 
    0.09073872f, 0.08998408f, 0.06152299f, -0.29505035f, 0.04981204f, 0.07091288f, 0.03498675f, 0.09434390f, 
    0.07681023f, 0.10374007f, -0.00521899f, -0.03731288f, 0.05795165f, -0.07510553f, 0.16186827f, 0.21574061f, 
    0.09844317f, -0.07255001f, 0.01778452f, -0.03262376f, 0.00383690f, -0.01272111f, -0.05921778f, -0.01759388f, 
    -0.07334779f, -0.02470105f, -0.03968174f, 0.15359840f, 0.02192543f, -0.00237861f, -0.10749835f, 0.07647948f, 
    0.03356575f, -0.01614286f, 0.00196622f, -0.03531723f, -0.26842001f, -0.12479530f, -0.01093213f, 0.03037602f, 
    0.02360271f, -0.03966951f, 0.05075140f, -0.00537941f, 0.04670404f, -0.01788178f, -0.00159848f, -0.00318265f, 
    -0.17387915f, 0.02885106f, -0.02293470f, -0.04074920f, 0.07238609f, 0.01535298f, -0.01031134f, -0.15805669f, 
    0.04765032f, 0.01314573f, 0.09547774f, 0.05206539f, 0.15442435f, 0.00757391f, 0.01307128f, 0.07175674f, 
    0.03373221f, -0.00142530f, -0.04894338f, -0.12034170f, -0.07601589f, -0.04694087f, 0.03580294f, 0.02087977f, 
    -0.00881459f, 0.09042034f, -0.07780582f, 0.00538154f, 0.02694745f, 0.02935863f, 0.04108632f, 0.07996593f, 
    0.00138694f, -0.00635881f, 0.04699333f, -0.00926772f, -0.05651685f, -0.10305782f, -0.04418908f, -0.12866656f, 
    0.02815161f, 0.00160260f, 0.10491076f, 0.06054113f, 0.04298401f, -0.03277425f, -0.02812854f, -0.06443565f, 
    -0.29881972f, 0.01192579f, 0.00168008f, -0.12447442f, -0.00336201f, -0.01889888f, 0.07317612f, 0.01811399f, 
    -0.02657103f, 0.03622874f, 0.00394434f, -0.04681757f, -0.11808565f, 0.05546990f, 0.03942545f, 0.07814819f, 
    0.03234213f, -0.00372354f, -0.07624631f, -0.01871415f, 0.04571231f, -0.02184276f, -0.01066195f, -0.01720678f, 
    -0.19676021f, 0.08753114f, 0.11921224f, -0.01604938f, -0.07248786f, -0.01226256f, -0.00147805f, -0.02017237f, 
    0.00742422f, 0.00784083f, 0.01639095f, 0.00915100f, -0.15021433f, -0.01133363f, 0.08050580f, 0.04965432f, 
    -0.04657717f, -0.00956061f, 0.00105923f, 0.03161917f, -0.09809110f, -0.08567725f, 0.01561721f, 0.04424972f, 
    -0.00268060f, 0.05360809f, 0.05030106f, 0.12069182f, 0.14089015f, 0.05467534f, 0.02861854f, 0.04651987f, 
    0.03083283f, 0.07058450f, 0.03252060f, 0.00384759f, -0.18331112f, -0.05865238f, 0.04481374f, -0.02950542f, 
    0.07524434f, 0.11541570f, -0.04058099f, -0.02216585f, 0.03635133f, 0.05661715f, 0.13122751f, -0.04590287f, 
    0.05218054f, 0.08765033f, 0.16966864f, 0.01181889f, 0.12066191f, -0.03639579f, 0.05169805f, 0.05439279f, 
    0.03824329f, 0.04828208f, -0.00196105f, -0.06119658f, -0.12278287f, 0.10449015f, 0.08813056f, -0.19358371f, 
    -0.03212997f, 0.02115778f, 0.05878973f, 0.07485148f, -0.07927378f, 0.03883096f, 0.06889850f, -0.01553212f, 
    0.17678322f, 0.05302133f, 0.05043073f, -0.21987978f, -0.03341775f, 0.02610456f, 0.09420213f, -0.01689531f, 
    -0.03803551f, -0.00119043f, -0.01794236f, -0.06024319f, 0.05884109f, 0.02110673f, -0.09387558f, 0.01004932f, 
    0.05747133f, -0.01057631f, -0.00404891f, 0.06963643f, -0.05867569f, 0.00796449f, 0.10448067f, 0.10361321f, 
    -0.02829017f, 0.10890389f, 0.11054346f, -0.11422753f, -0.01879239f, -0.03541159f, 0.10225983f, 0.03814660f, 
    -0.06924388f, -0.12755080f, 0.03361194f, 0.06053351f, -0.11819918f, 0.05147124f, -0.00362150f, -0.02102740f, 
    0.07782685f, 0.01390570f, 0.07371773f, 0.06282347f, -0.01835991f, -0.00527862f, -0.01653581f, -0.05391190f, 
    -0.05054598f, -0.05200342f, 0.15583341f, 0.10394947f, -0.03065077f, -0.00610593f, -0.01476128f, -0.05112398f, 
    0.01006601f, -0.06625839f, 0.05479238f, 0.04104873f, -0.03649665f, -0.02675020f, 0.07960267f, 0.02187028f, 
    0.04954483f, 0.02972802f, -0.00893900f, 0.04220239f, 0.05283516f, -0.01295958f, -0.00130474f, 0.06162098f, 
    0.01389688f, -0.00388172f, 0.07290503f, 0.03525883f, 0.02369247f, 0.03395373f, -0.03375325f, 0.03656649f, 
    0.00624953f, -0.03812750f, -0.00755308f, -0.05500582f, -0.13639656f, 0.04622100f, 0.01669765f, -0.12402695f, 
    -0.03905695f, -0.07347061f, -0.00713646f, 0.08634249f, 0.00097355f, -0.09429110f, -0.00102528f, 0.01923924f, 
    0.19293430f, -0.06759597f, 0.02183958f, 0.08272184f, 0.03512460f, 0.07867363f, 0.03916023f, -0.03296366f, 
    -0.11521455f, -0.00425567f, 0.01561649f, 0.01844260f, -0.03968853f, 0.03857407f, 0.15385677f, 0.03375313f, 
    -0.02561860f, -0.01173171f, 0.06189971f, -0.00390128f, 0.00283453f, -0.08710857f, -0.05404345f, -0.08459220f, 
    -0.19681016f, -0.05180251f, -0.02267170f, 0.21239524f, -0.02701501f, -0.01730395f, -0.00434098f, -0.03488273f, 
    0.11308721f, -0.05394705f, -0.04728574f, 0.04913820f, -0.12103888f, 0.08156621f, 0.07764206f, 0.13199314f, 
    -0.04562032f, -0.04294961f, 0.01081224f, 0.02545309f, -0.08141868f, 0.04229474f, 0.03322472f, 0.04196366f, 
    -0.11718859f, 0.01299495f, 0.15272719f, -0.08293215f, -0.04027057f, 0.02960394f, -0.04268804f, 0.04722911f, 
    0.00368000f, 0.01054619f, 0.02893224f, -0.02988665f, -0.22864473f, -0.01547128f, -0.00947743f, 0.03428632f, 
    0.01838376f, 0.02967674f, 0.11669022f, 0.09668206f, 0.01376868f, -0.07103766f, -0.01132696f, 0.09523021f, 
    -0.17273760f, -0.09048171f, -0.02549224f, 0.19566293f, 0.02207205f, 0.03522001f, -0.07037280f, 0.03101928f, 
    0.10981329f, 0.03567206f, -0.00599325f, -0.03726810f, -0.05997907f, 0.15155582f, 0.09576087f, -0.02899723f, 
    -0.02554433f, -0.03077708f, 0.06614722f, 0.04153628f, -0.02007194f, 0.04550983f, -0.09653614f, 0.00702182f, 
    -0.12100542f, 0.09289971f, 0.02483487f, -0.02530087f, 0.02517909f, 0.10302942f, 0.00868171f, 0.06683219f, 
    0.00782328f, -0.00082495f, -0.01004417f, 0.05300716f, -0.15956059f, -0.06133537f, -0.02989225f, 0.10563886f, 
    0.11598234f, 0.07834783f, 0.05257934f, 0.09775630f, -0.00054325f, 0.02357649f, 0.04675043f, 0.00611601f, 
    -0.01639881f, -0.04305891f, -0.01095350f, 0.14516479f, 0.04483678f, 0.02633210f, -0.04664361f, 0.04817130f, 
    0.06311245f, 0.02438814f, 0.01344996f, 0.12623850f, 0.00899444f, 0.08377843f, 0.05917008f, -0.11151380f, 
    0.09388290f, 0.01681698f, 0.05228399f, 0.01476024f, -0.05526743f, 0.06483097f, 0.03846356f, 0.02542276f, 
    -0.12048343f, -0.04173872f, 0.01490433f, 0.04677821f, 0.03903086f, -0.04917464f, 0.01373487f, 0.01242936f, 
    0.05180211f, 0.02358910f, 0.14700428f, -0.07590319f, 0.06111690f, -0.04806923f, -0.07636067f, 0.21955612f, 
    -0.02575512f, 0.04587317f, -0.02726044f, 0.04816816f, 0.08501246f, -0.00746305f, 0.04374646f, 0.08866649f, 
    -0.07357910f, 0.06078022f, 0.12164795f, -0.15182059f, 0.01092765f, -0.02869081f, 0.05152925f, 0.03810652f, 
    0.04700409f, -0.06560307f, -0.04529073f, -0.01699483f, 0.01635315f, 0.05625525f, 0.17776954f, -0.03396934f, 
    0.03012514f, 0.01418096f, 0.02412364f, 0.03588234f, 0.09520494f, 0.04100674f, -0.05287008f, -0.01152400f, 
    0.06711935f, -0.06523044f, 0.14263543f, -0.01263269f, 0.09622922f, 0.07499029f, 0.02995817f, -0.00451813f, 
    -0.04556133f, 0.09965254f, -0.04792622f, 0.08310103f, -0.04884117f, -0.03560612f, -0.01441794f, 0.07580411f, 
    -0.03757260f, -0.01116757f, 0.03588333f, -0.10083818f, -0.06905656f, -0.01223417f, -0.12965445f, 0.06931262f, 
    -0.22776160f, 0.03342090f, -0.03999984f, 0.10077674f, -0.04287742f, 0.04630176f, 0.01659383f, -0.08897418f, 
    0.00616523f, -0.00161463f, -0.03553740f, 0.00916253f, -0.05810788f, 0.02293151f, -0.06004332f, 0.08546719f, 
    -0.00075578f, 0.07898725f, -0.01432516f, -0.00691491f, -0.01977036f, -0.02626158f, -0.04660494f, 0.00167260f, 
    0.00289027f, 0.02955457f, -0.02192978f, -0.05019257f, 0.01460181f, 0.02126526f, 0.09006170f, -0.03938142f, 
    0.05367617f, -0.04688820f, 0.02691502f, 0.08643414f, -0.34067613f, -0.04407534f, 0.01808353f, -0.25829193f, 
    0.01731457f, 0.02353307f, -0.04005463f, 0.02079491f, -0.06454346f, 0.03825416f, -0.10330792f, -0.01290695f, 
    -0.02005298f, 0.02584533f, 0.04539470f, 0.00519978f, -0.14703962f, -0.06726106f, 0.01535381f, -0.06280624f, 
    0.05420569f, -0.01634045f, 0.04404189f, 0.00697367f, -0.26476645f, 0.12047256f, 0.02000063f, -0.10799636f, 
    0.03090069f, 0.01893406f, 0.04374293f, -0.06250012f, -0.00914379f, -0.03607664f, 0.02890957f, -0.02999424f, 
    -0.23369649f, 0.02046788f, -0.00678883f, 0.13676335f, 0.09388752f, 0.06768065f, -0.09416900f, 0.10986500f, 
    -0.05682180f, 0.03749428f, -0.05412332f, 0.04357907f, 0.05712468f, -0.04419718f, 0.08263595f, -0.12959418f, 
    -0.04565710f, -0.06849928f, 0.07336859f, 0.06852535f, 0.06005866f, -0.03122350f, 0.04333699f, 0.00880644f, 
    -0.11138228f, 0.07857554f, 0.14511068f, -0.00800562f, -0.06502283f, 0.08066840f, 0.00596206f, 0.01009894f, 
    -0.03428094f, -0.03030372f, 0.00495470f, 0.04303086f, 0.11785682f, -0.04201527f, 0.11499692f, 0.13338277f, 
    0.07043872f, -0.01891019f, 0.11889316f, 0.12199852f, 0.06205398f, 0.09134360f, 0.05946488f, 0.04349859f, 
    -0.03295929f, 0.05370670f, -0.05686760f, 0.22970608f, -0.05162675f, -0.02284715f, 0.01084966f, 0.04311530f, 
    0.09426794f, -0.00406766f, -0.06804359f, -0.02347558f, -0.04600017f, 0.13374846f, -0.01247991f, 0.14752185f, 
    0.12703526f, -0.00581764f, 0.04324905f, -0.00634630f, 0.02843155f, 0.02520394f, 0.02128950f, 0.01849976f, 
    0.08603486f, 0.06797860f, 0.12277596f, -0.13287012f, -0.02945337f, 0.06894593f, -0.04079354f, 0.05296887f, 
    -0.08302439f, -0.05035190f, -0.03189379f, 0.08128414f, -0.06204896f, -0.05124579f, 0.10599251f, -0.00396610f, 
    0.02680423f, 0.12523955f, 0.04646939f, -0.00136911f, -0.00469958f, 0.13154337f, 0.10414543f, -0.00755478f, 
    0.12005246f, -0.07854515f, -0.01128449f, 0.21214233f, -0.08601974f, 0.00286566f, -0.01812535f, -0.02190925f, 
    0.01010061f, -0.00163174f, 0.08315983f, -0.03065729f, -0.19097278f, -0.01765646f, -0.04983462f, 0.01371609f, 
    -0.00353450f, -0.00598967f, 0.10542480f, -0.04007913f, 0.09435645f, 0.02877664f, -0.00213318f, -0.00566643f, 
    0.12420250f, 0.13532165f, -0.03592586f, 0.17199193f, -0.02157513f, -0.00845027f, 0.06423271f, 0.00649078f, 
    0.01175301f, -0.06265682f, -0.00219463f, 0.10001363f, 0.11596182f, 0.08084715f, -0.04566411f, 0.17190306f, 
    0.04807408f, -0.04083367f, 0.06852116f, -0.01506384f, -0.01162389f, 0.05211459f, -0.00279770f, 0.15119103f, 
    -0.09266751f, -0.18957299f, 0.14819176f, 0.20918155f, 0.05356658f, 0.04831657f, 0.03603819f, -0.01819003f, 
    -0.05087477f, 0.00786329f, 0.02421586f, -0.05993161f, -0.03808793f, 0.01911899f, 0.02612084f, -0.10137554f, 
    0.10355729f, -0.03946516f, 0.04944740f, 0.00623488f, 0.10773965f, 0.01582881f, -0.01750046f, -0.07691783f, 
    -0.11178529f, 0.03854768f, 0.03103022f, 0.04057952f, 0.04434044f, -0.02267074f, 0.02104436f, -0.10215636f, 
    -0.07175194f, -0.05161371f, 0.09595578f, 0.01208892f, -0.23353250f, -0.13017175f, -0.03153219f, 0.02871782f, 
    0.03482109f, 0.04682575f, 0.03053853f, -0.02865164f, 0.02389152f, -0.01474143f, 0.04209679f, 0.05151862f, 
    -0.02370817f, 0.02865011f, -0.00271857f, -0.00452348f, -0.03128299f, 0.00987374f, 0.00331338f, 0.02803763f, 
    -0.02897613f, 0.02968905f, -0.03076776f, 0.00166193f, -0.01688902f, 0.00297323f, -0.03900720f, 0.00144532f, 
    0.00895951f, 0.00354055f, -0.00292857f, -0.00111503f, -0.00620586f, -0.00360288f, -0.01491932f, 0.02087864f, 
    0.01164532f, -0.01342254f, -0.01417577f, 0.00495386f, -0.03193248f, -0.03333149f, -0.03418263f, -0.02061695f, 
    -0.01869510f, -0.03127662f, -0.02450400f, -0.03746605f, 0.01838354f, -0.02045362f, -0.02109914f, 0.02224603f, 
    -0.03685663f, 0.00783736f, 0.00962915f, -0.00589624f, 0.00717968f, 0.01795725f, 0.00463666f, -0.02972643f, 
    0.02070900f, 0.02816517f, 0.02541046f, 0.02319016f, -0.01567643f, -0.01711991f, 0.02296663f, -0.03842452f, 
    0.02731900f, -0.00918738f, 0.01046267f, -0.00495847f, 0.01723573f, 0.01133663f, -0.02302001f, -0.00756764f, 
    -0.00930516f, 0.00426043f, 0.00134213f, -0.01999103f, -0.03810079f, 0.02832294f, -0.00450951f, -0.03190817f, 
    -0.01587191f, -0.00108819f, -0.01256635f, 0.02555179f, -0.00031502f, -0.00973487f, -0.01491613f, -0.03237096f, 
    0.02500632f, -0.00154945f, 0.02106165f, -0.03613782f, -0.02072953f, 0.02856241f, -0.02699907f, -0.02414176f, 
    0.02906939f, 0.00431923f, 0.00584298f, 0.00081690f, -0.00875350f, 0.02195540f, 0.00352417f, -0.00587096f, 
    0.00378736f, 0.00982498f, -0.02224738f, 0.00479963f, 0.02856344f, 0.02973256f, 0.02600973f, 0.00973054f, 
    -0.02453023f, -0.01765982f, -0.01829910f, 0.01068629f, -0.03577765f, -0.00806061f, -0.01491349f, 0.01338784f, 
    0.00813118f, 0.01433458f, 0.02308430f, -0.00244339f, -0.01719218f, -0.03318204f, 0.02444980f, 0.00048584f, 
    -0.03165099f, -0.01457300f, -0.03339462f, -0.03967274f, -0.02193246f, -0.01305333f, 0.01788693f, 0.02233337f, 
    -0.00762504f, -0.01576827f, -0.00161551f, -0.03224533f, -0.03821580f, -0.03794663f, -0.02590647f, -0.01168943f, 
    0.01442007f, 0.02110483f, -0.00010757f, 0.01129533f, -0.00205818f, 0.01632876f, -0.00978619f, -0.02813236f, 
    -0.03427244f, -0.03610409f, 0.02746569f, 0.01810816f, 0.02922032f, -0.00409877f, 0.00760403f, 0.00880957f, 
    -0.00651491f, -0.00820101f, 0.00441921f, 0.00007568f, -0.01615225f, -0.01556575f, -0.00470699f, -0.01735207f, 
    0.02841395f, -0.01321611f, 0.01268364f, -0.00604429f, -0.02562324f, 0.02092871f, -0.00516591f, -0.01626192f, 
    -0.03827154f, 0.01243405f, -0.03658172f, -0.01262396f, 0.00562756f, -0.01993316f, 0.00059620f, 0.00625913f, 
    0.02321820f, 0.01142505f, 0.02597384f, 0.02525290f, -0.00000557f, 0.02372731f, -0.03118767f, -0.02241404f, 
    -0.02483059f, 0.01101138f, -0.03532218f, -0.01557696f, 0.00080420f, -0.02229005f, 0.00505938f, 0.00185691f, 
    0.01254986f, -0.00459770f, -0.01318772f, -0.03362546f, 0.02087361f, 0.01968765f, 0.01983170f, -0.04450049f, 
    -0.01634173f, -0.03087359f, 0.01119613f, -0.03006382f, -0.02506530f, -0.03009968f, -0.03705132f, -0.00645685f, 
    0.00304949f, -0.03473486f, 0.00229728f, 0.02924284f, 0.02672832f, -0.01650541f, -0.00227772f, 0.02648079f, 
    0.02289945f, 0.01073203f, -0.02301575f, 0.02134949f, -0.04068654f, -0.03487666f, -0.00595189f, -0.03482049f, 
    0.01100345f, 0.01248851f, -0.02268558f, -0.00352062f, 0.02686167f, -0.01378727f, -0.01015262f, -0.01043657f, 
    0.01877938f, -0.03628734f, -0.00571667f, 0.00995819f, 0.01393957f, 0.00527709f, -0.03372901f, -0.02987792f, 
    0.02508702f, 0.03316427f, 0.02819917f, 0.01315077f, 0.02290790f, -0.00158620f, 0.02948035f, -0.02904634f, 
    -0.01157578f, -0.00398169f, 0.02984135f, -0.03678073f, -0.00679250f, -0.03033029f, -0.03666629f, 0.00816183f, 
    0.01931009f, -0.01560200f, -0.00148764f, -0.02277763f, 0.01070485f, -0.02462690f, 0.00184072f, 0.02715520f, 
    0.00346299f, -0.02068438f, 0.02269224f, -0.03929823f, -0.03316940f, 0.01073095f, -0.02856348f, -0.03981854f, 
    0.03087639f, 0.00749131f, -0.02547592f, 0.01696610f, 0.00648726f, 0.00064024f, 0.03177471f, -0.03250705f, 
    0.00615628f, 0.00298136f, 0.01801356f, -0.03936502f, 0.01223717f, -0.01425735f, -0.03726662f, 0.01904793f, 
    -0.03559437f, 0.02088472f, 0.00798237f, 0.01052873f, -0.03441650f, 0.02852918f, 0.01702766f, 0.02799077f, 
    -0.00394778f, -0.00910940f, 0.00215497f, -0.02383567f, 0.01420201f, -0.01127279f, 0.00439556f, -0.04117738f, 
    -0.03370468f, -0.00384906f, 0.02724172f, -0.03686208f, -0.01128859f, 0.01656031f, -0.04313598f, -0.03056403f, 
    -0.04581599f, -0.02960328f, -0.01615043f, 0.00668976f, -0.01779014f, -0.00174908f, 0.01529223f, -0.03465297f, 
    -0.02073414f, 0.00878183f, -0.03591514f, -0.03577367f, 0.01579434f, -0.01863271f, 0.03004038f, -0.01004123f, 
    -0.02580052f, 0.00725650f, 0.02741902f, -0.02423807f, -0.01305508f, 0.02735760f, 0.00197207f, -0.01844688f, 
    -0.02229168f, -0.02176349f, -0.03367160f, -0.03055304f, -0.00668791f, 0.02368654f, 0.00121732f, -0.02052583f, 
    0.01967637f, 0.01743104f, -0.03276838f, 0.02417568f, -0.02111942f, 0.02263380f, -0.03238733f, -0.02643663f, 
    -0.01993719f, 0.02826719f, 0.02199375f, 0.00508246f, 0.00331534f, -0.03907146f, -0.00694779f, 0.02193158f, 
    -0.03625702f, 0.01654405f, 0.02403444f, 0.02074440f, 0.01863396f, -0.03238467f, -0.01140169f, -0.00176087f, 
    0.02278972f, 0.02576361f, -0.01995946f, 0.02555772f, -0.02575278f, -0.02485998f, -0.02889032f, 0.02606136f, 
    0.03181121f, 0.00369364f, -0.00271560f, -0.02830247f, 0.01367146f, -0.02291163f, -0.00846192f, -0.03072361f, 
    0.00580090f, -0.02535514f, 0.02174923f, 0.00229316f, 0.02074941f, 0.01077346f, 0.03117323f, 0.01012826f, 
    -0.00767563f, -0.00835655f, -0.03754019f, 0.02095873f, 0.01248970f, 0.01294359f, -0.02656469f, -0.01539825f, 
    -0.01498425f, -0.00705036f, -0.00744470f, 0.00452924f, 0.02567503f, -0.01942598f, -0.03589198f, -0.00421242f, 
    -0.02668111f, 0.00683089f, -0.03276855f, -0.00926292f, 0.02052360f, -0.01676026f, -0.01381036f, -0.01624777f, 
    0.01369363f, 0.00545665f, 0.00671412f, -0.01057949f, 0.03114970f, 0.01028186f, 0.02110257f, -0.00796526f, 
    0.00639412f, 0.01996552f, -0.03686337f, 0.02583789f, 0.00244381f, -0.03241031f, 0.00468064f, -0.01260537f, 
    0.01152410f, -0.02778944f, 0.02274971f, -0.00064895f, 0.01920994f, -0.01387736f, -0.01864680f, 0.01846341f, 
    -0.00471475f, 0.01444736f, -0.01999577f, -0.02663586f, -0.03914058f, 0.00121360f, -0.00510061f, 0.02265668f, 
    -0.01293940f, 0.01487784f, 0.00218629f, -0.01078393f, 0.02614760f, 0.02160214f, 0.02028128f, -0.03828545f, 
    0.01328102f, -0.00267129f, -0.01461816f, 0.01593994f, -0.03976279f, 0.01548161f, -0.00980665f, -0.00006222f, 
    0.02156459f, 0.01036472f, -0.03227365f, 0.00038164f, 0.00229769f, 0.00718113f, 0.01178532f, 0.03467064f, 
    0.01364066f, -0.00381502f, -0.01023844f, 0.02793409f, -0.01917103f, 0.00010229f, 0.01076888f, -0.03587545f, 
    0.01759616f, 0.01378159f, -0.00315337f, 0.02452262f, -0.03913421f, -0.02625928f, 0.00943314f, -0.02693684f, 
    -0.00190537f, -0.00760449f, 0.02614165f, 0.00533901f, -0.00058906f, -0.02103539f, 0.01209007f, -0.01464375f, 
    -0.01956034f, -0.01895231f, -0.01001977f, 0.02617711f, -0.01125671f, 0.01524954f, -0.03536977f, -0.03657514f, 
    -0.01797785f, -0.01881137f, -0.00282273f, 0.01672352f, 0.01353631f, 0.01404221f, 0.01756874f, -0.00218331f, 
    -0.02819779f, -0.00695758f, -0.03854970f, -0.02075681f, -0.02569224f, -0.00861516f, -0.01416751f, 0.00032952f, 
    0.01540584f, -0.01999168f, -0.01061886f, -0.00959081f, -0.02328046f, -0.01075658f, 0.02691113f, 0.00910167f, 
    -0.03267870f, -0.02900423f, -0.02373723f, 0.03000838f, 0.01405397f, 0.01299722f, 0.01658573f, -0.03784521f, 
    -0.00204747f, -0.00779062f, 0.02175952f, -0.03905464f, -0.03064625f, -0.00246174f, -0.03163652f, -0.03595047f, 
    0.00087021f, 0.02600812f, -0.03991173f, 0.01218292f, 0.00080997f, -0.01365269f, -0.02413332f, 0.00330088f, 
    -0.00846037f, -0.01931823f, -0.01168985f, 0.00800934f, -0.03963850f, 0.02300079f, 0.01909577f, -0.02965046f, 
    0.03009375f, -0.02173219f, -0.03646456f, -0.00236277f, -0.02877123f, -0.01592519f, -0.01834289f, 0.00546864f, 
    0.00449107f, 0.01957859f, -0.01320806f, 0.00687353f, -0.02187779f, 0.02284930f, -0.00025853f, 0.00532996f, 
    0.02005336f, 0.03153437f, -0.04012486f, 0.00777854f, 0.01468025f, -0.02920333f, 0.02462811f, -0.00822553f, 
    0.02039261f, -0.03443155f, 0.01843186f, -0.00645479f, -0.02821156f, -0.00329523f, 0.01542420f, -0.00193383f, 
    -0.02148623f, -0.00343188f, -0.01997610f, -0.00435983f, -0.01454676f, 0.02883221f, 0.01139060f, 0.03005002f, 
    0.00646691f, -0.01295184f, 0.00593458f, 0.02693268f, -0.00306391f, 0.00489202f, -0.01559522f, -0.01886186f, 
    -0.01284442f, 0.03231083f, -0.03180388f, -0.04441654f, -0.01433255f, -0.03342666f, 0.02157472f, 0.02222886f, 
    -0.02336298f, 0.03002576f, -0.00128439f, 0.02638931f, 0.02734679f, -0.01147091f, 0.02731822f, -0.03576640f, 
    0.00272950f, -0.00949493f, -0.02647762f, 0.01587848f, 0.01649770f, -0.00506156f, 0.01874785f, -0.01176740f, 
    -0.03703455f, 0.00574064f, 0.00228753f, -0.02542734f, 0.01241706f, -0.01444237f, -0.01069196f, -0.02528438f, 
    -0.01401165f, -0.03620889f, 0.00839488f, -0.00206213f, -0.00093806f, -0.02955261f, 0.02775262f, -0.02436933f, 
    -0.02466962f, 0.01750860f, -0.03250424f, 0.02958168f, 0.02722080f, -0.02987999f, -0.02171566f, 0.02012125f, 
    -0.01622855f, -0.00278332f, -0.03568965f, -0.00184948f, 0.03342691f, -0.01008136f, 0.02783677f, -0.01736035f, 
    -0.03914013f, 0.02325267f, 0.02020523f, -0.00587641f, -0.03891562f, -0.01003495f, 0.02745708f, -0.02599022f, 
    0.02651944f, -0.00255804f, 0.02949477f, -0.00539818f, 0.01197862f, 0.02704569f, 0.00382335f, 0.03019818f, 
    -0.00655371f, -0.02873158f, 0.00096057f, 0.02438778f, 0.02044538f, -0.01097125f, 0.02072864f, -0.02959748f, 
    0.01439486f, 0.00077936f, -0.00921224f, -0.01684149f, -0.02954421f, -0.03160422f, -0.03293970f, 0.00331074f, 
    -0.03779481f, 0.02558905f, -0.01654492f, -0.01135700f, -0.04065991f, 0.01571886f, -0.03987442f, -0.02862833f, 
    0.01904890f, 0.02140228f, -0.01416105f, 0.01866776f, -0.01615669f, -0.01873595f, -0.00311945f, -0.00000436f, 
    0.00889961f, 0.03290217f, 0.01681251f, -0.00573023f, -0.02960725f, 0.02918536f, -0.00115340f, 0.02241489f, 
    -0.01771114f, -0.00384237f, 0.02764147f, 0.02725268f, -0.01083560f, 0.01944499f, -0.03263148f, 0.01769308f, 
    -0.00042771f, -0.01770124f, -0.00909707f, 0.01105754f, -0.02107876f, -0.00679736f, 0.00413832f, -0.00867958f, 
    0.01566833f, -0.00851918f, -0.02130206f, -0.00914125f, -0.02798445f, -0.03332075f, 0.00009404f, 0.01425783f, 
    0.01243714f, -0.01627940f, 0.02514362f, -0.02435763f, 0.02104116f, -0.02598127f, -0.00781550f, 0.01067783f, 
    0.01736901f, -0.03645450f, 0.02490462f, -0.01829456f, 0.01678871f, 0.01365469f, -0.03665799f, -0.02566966f, 
    -0.00821527f, 0.00438387f, 0.03007591f, -0.01252994f, 0.01899523f, -0.02771674f, 0.02328990f, -0.02286843f, 
    0.00851631f, 0.02465101f, -0.00614021f, 0.01929272f, -0.03947493f, 0.02202193f, -0.01775745f, 0.01052810f, 
    0.03124510f, 0.02880593f, -0.02192473f, -0.00072863f, -0.03882076f, 0.03037154f, -0.02816989f, -0.03492582f, 
    -0.04079932f, -0.03281431f, -0.02707874f, -0.02003168f, -0.02834983f, -0.00857392f, -0.03825971f, -0.02452206f, 
    -0.02214592f, -0.00220789f, 0.00914830f, -0.02378419f, 0.02754840f, -0.00001589f, 0.00061520f, -0.00455698f, 
    -0.01694766f, 0.02845862f, -0.03220146f, 0.01025046f, 0.01464879f, 0.01992186f, 0.00122348f, 0.02787857f, 
    0.01014725f, 0.00113933f, 0.00811161f, 0.01930268f, 0.01787363f, 0.01003807f, -0.03710357f, -0.01243422f, 
    -0.00862602f, -0.00849816f, 0.02994583f, -0.00703160f, -0.01204723f, 0.00092862f, -0.03075062f, 0.01693580f, 
    -0.02317875f, -0.03249731f, -0.00890035f, -0.00699156f, -0.03202331f, 0.02989723f, -0.01003459f, -0.00778094f, 
    -0.03770795f, 0.02814705f, 0.01470230f, 0.01860993f, -0.02380654f, 0.00035817f, -0.03272026f, -0.00971727f, 
    -0.01902882f, 0.02267011f, -0.03783861f, 0.00480840f, -0.00080529f, 0.01184461f, -0.02829329f, -0.02381671f, 
    -0.03226886f, -0.02426733f, -0.02893082f, -0.01062594f, -0.03940642f, 0.02137208f, -0.03107515f, -0.03597933f, 
    0.02916774f, 0.00800366f, -0.02871151f, -0.02307091f, -0.00117757f, -0.00602419f, -0.04016386f, -0.02520997f, 
    -0.04051847f, 0.02949634f, -0.00597787f, 0.01988681f, 0.00166169f, -0.02913946f, -0.00932929f, 0.01439581f, 
    -0.01906930f, -0.03576663f, -0.01908349f, 0.01176171f, -0.00254764f, -0.02080121f, -0.03038760f, -0.02874392f, 
    -0.02329565f, 0.03520069f, -0.01304661f, -0.01000232f, -0.00444096f, -0.00849266f, -0.00562536f, 0.00351075f, 
    -0.03501908f, -0.03708214f, 0.00214486f, -0.02563443f, -0.03802638f, -0.02481374f, -0.03281465f, -0.01353545f, 
    0.02331042f, 0.00157003f, -0.03198555f, -0.01392261f, 0.02213918f, -0.01046964f, 0.01136939f, 0.01090809f, 
    0.00501301f, -0.02853957f, 0.01211543f, -0.00807413f, -0.01847829f, -0.01486050f, -0.00035860f, 0.03513758f, 
    -0.00475775f, -0.00840578f, 0.02363946f, 0.01123536f, -0.02893418f, 0.01358714f, 0.02242365f, -0.03977403f, 
    -0.01135917f, -0.03480035f, 0.02836978f, 0.02328081f, -0.01222660f, 0.02236990f, -0.04112130f, -0.02536984f, 
    0.00326491f, -0.00917436f, -0.00305239f, -0.03631865f, -0.01986166f, 0.01297756f, 0.00453603f, 0.01733271f, 
    -0.01000995f, -0.02237616f, 0.02707669f, 0.01583228f, 0.02613997f, 0.02308980f, 0.02990525f, 0.01594052f, 
    0.01399093f, -0.02832081f, -0.03562212f, 0.02564154f, 0.01597276f, -0.02924597f, 0.01277326f, -0.04060429f, 
    0.01351765f, 0.02551485f, 0.00231179f, -0.04073225f, -0.02732683f, -0.03014791f, -0.00298726f, -0.01288182f, 
    -0.02745497f, 0.01119860f, -0.02235080f, -0.00488952f, -0.02212585f, 0.01343817f, -0.03895604f, 0.00746623f, 
    0.01335212f, -0.01860155f, 0.01431490f, -0.02398827f, -0.02055237f, 0.02211056f, -0.01679204f, 0.02597855f, 
    -0.00937319f, 0.01746158f, -0.01578623f, -0.03961148f, 0.01329625f, -0.03760336f, 0.00627650f, -0.03327202f, 
    -0.03776374f, 0.00356076f, -0.00859131f, 0.01023965f, 0.01284452f, -0.01294232f, 0.00771674f, -0.00364665f, 
    -0.03326056f, -0.02291130f, -0.00760458f, -0.04010591f, -0.03953491f, 0.01255683f, 0.00703531f, 0.02214278f, 
    -0.02032938f, 0.01183762f, -0.01634097f, 0.01177542f, -0.03558503f, -0.02308935f, -0.02327891f, -0.00963868f, 
    -0.01277728f, 0.01571704f, -0.03693745f, -0.03028990f, 0.02166877f, -0.00438475f, 0.00733414f, 0.02662255f, 
    -0.02973607f, -0.04118015f, -0.03369739f, 0.01932579f, -0.02423292f, -0.02508304f, -0.00073357f, -0.03669974f, 
    0.01426588f, -0.00102204f, 0.01629085f, -0.01842528f, 0.01302398f, -0.03065691f, 0.02596333f, -0.01584473f, 
    -0.01709264f, 0.03425278f, 0.01350068f, -0.03034581f, -0.00631698f, 0.00664806f, 0.02095052f, -0.02004950f, 
    -0.03441082f, 0.03064436f, -0.00888074f, -0.02849081f, -0.00394873f, -0.01754620f, 0.00757827f, -0.02862705f, 
    -0.01965050f, -0.02163675f, -0.00961257f, 0.01748444f, 0.00840885f, -0.04003854f, 0.01378023f, -0.03536866f, 
    0.01955971f, -0.02727530f, -0.03648012f, -0.00320317f, 0.03021245f, -0.04023230f, -0.00864064f, -0.02386183f, 
    -0.02180211f, -0.02908031f, -0.03832756f, -0.02494673f, -0.03588691f, -0.01442921f, 0.03083463f, 0.03534992f, 
    -0.02403362f, 0.00334775f, -0.02544315f, -0.00369423f, -0.02918256f, -0.00580261f, 0.01823842f, -0.00112396f, 
    0.02017816f, -0.04121336f, -0.00796272f, -0.01109563f, 0.01036436f, -0.01811203f, -0.04126891f, -0.03826189f, 
    -0.00829174f, 0.01462341f, 0.00128026f, 0.01583419f, -0.02049816f, 0.00789318f, 0.00123547f, 0.03247832f, 
    0.03275955f, 0.01429829f, -0.03347846f, -0.01819583f, 0.01019918f, -0.03840908f, -0.03415808f, 0.01061782f, 
    -0.00197170f, 0.01161715f, -0.03696416f, 0.01665976f, 0.02077122f, 0.02088104f, -0.02051320f, -0.02633953f, 
    0.02324419f, 0.00960593f, -0.03360509f, -0.03054218f, 0.00171290f, -0.01394770f, -0.02559631f, 0.01970651f, 
    -0.01532560f, 0.03025912f, -0.02906561f, 0.02684273f, -0.00881142f, -0.00197512f, 0.02261585f, -0.03717168f, 
    -0.01911312f, -0.04027129f, -0.01813441f, -0.00674286f, -0.00645124f, 0.02879599f, 0.02694592f, -0.02589775f, 
    -0.00714896f, -0.02772409f, 0.03061606f, 0.02986060f, 0.00098835f, -0.02152575f, -0.02233185f, -0.01179542f, 
    -0.02757116f, -0.01395599f, -0.03042732f, -0.00949013f, -0.00872897f, -0.03798385f, 0.00694303f, -0.03034765f, 
    -0.02716048f, 0.02466038f, -0.00629394f, -0.01328830f, 0.02011119f, 0.01994085f, 0.00728041f, 0.01838294f, 
    -0.03810751f, -0.01145950f, -0.03419055f, 0.02766461f, -0.02057087f, -0.00000866f, -0.02784095f, 0.01663593f, 
    0.00136713f, 0.03053956f, 0.00218584f, 0.02631214f, 0.01739205f, 0.02500576f, -0.03254681f, -0.03999753f, 
    -0.03925902f, -0.02755470f, 0.01043797f, -0.00989320f, 0.01059175f, -0.02794589f, 0.00471544f, -0.01940344f, 
    -0.00751419f, -0.02983668f, 0.02714147f, -0.03171254f, -0.01154325f, -0.01941144f, -0.03648372f, 0.02291221f, 
    -0.01469107f, -0.03895712f, -0.00161891f, -0.01034068f, -0.00321757f, 0.02349619f, -0.02100156f, 0.01087360f, 
    -0.00740052f, -0.01955033f, -0.03029484f, 0.00342459f, -0.01430695f, -0.03180714f, -0.02953164f, 0.01656097f, 
    0.01452818f, -0.02070405f, -0.03876021f, -0.00595015f, -0.01180894f, -0.04065223f, -0.00761127f, 0.00417831f, 
    -0.03356061f, -0.01886951f, 0.01782840f, 0.01384745f, 0.03057621f, -0.04059942f, -0.00198548f, -0.02203470f, 
    0.01076801f, -0.02505376f, -0.00911394f, 0.01887723f, -0.03874489f, 0.01966489f, -0.02250727f, -0.02252463f, 
    -0.02970397f, -0.01706083f, -0.03364360f, 0.00632571f, 0.00742024f, -0.03729326f, 0.02856726f, 0.01442149f, 
    -0.02915557f, -0.03792662f, -0.03576517f, -0.00248286f, 0.02176053f, 0.01895367f, -0.04002237f, 0.02891599f, 
    -0.02736198f, 0.01489655f, -0.02821468f, -0.00660338f, -0.02241999f, -0.01906943f, 0.01280509f, -0.03101172f, 
    0.03000173f, 0.02466493f, 0.01794427f, -0.03127331f, 0.01908097f, 0.02816472f, 0.02837502f, 0.01990318f, 
    -0.01524443f, -0.01588017f, -0.00072064f, 0.00101687f, -0.02475747f, 0.01685678f, 0.02890596f, -0.03787742f, 
    -0.01275941f, 0.02109956f, 0.00895906f, -0.00562878f, -0.01559807f, 0.01756100f, -0.04128797f, 0.02040259f, 
    0.00981923f, -0.00851851f, -0.02684031f, -0.00341984f, -0.02599698f, 0.01549835f, 0.01201897f, -0.01362851f, 
    0.01538593f, 0.01850894f, 0.00704497f, -0.03402326f, -0.01640848f, -0.03538183f, -0.03561560f, -0.02269189f, 
    -0.02877604f, -0.01979073f, 0.01964562f, 0.02091352f, -0.02113429f, -0.00139065f, -0.00516294f, -0.03585188f, 
    -0.02765941f, 0.01491278f, 0.01364830f, 0.00512464f, -0.00609112f, -0.01424951f, 0.02877126f, -0.03415740f, 
    0.01338842f, -0.01804760f, 0.02912907f, -0.02671535f, -0.03295276f, 0.00251880f, -0.03224850f, 0.03052154f, 
    -0.01904520f, -0.01041624f, -0.02840085f, 0.00867859f, 0.01512272f, -0.00501131f, -0.03789046f, 0.02665295f, 
    0.00151958f, 0.02947864f, 0.02102604f, 0.01187443f, 0.00192787f, -0.02754142f, 0.01210805f, -0.02214758f, 
    -0.00008285f, 0.01212215f, 0.01907730f, 0.00744833f, -0.02838230f, -0.02220437f, 0.02626823f, -0.00183581f, 
    0.00320949f, -0.00963804f, -0.00590037f, -0.01427815f, -0.00937984f, -0.01855198f, 0.01983212f, -0.01989960f, 
    -0.00502684f, 0.00668293f, -0.02785289f, -0.02032083f, 0.01769432f, 0.00436391f, -0.02101024f, -0.03107741f, 
    -0.02206624f, 0.00009957f, -0.01373888f, 0.00451013f, 0.02508276f, -0.02594973f, -0.03311465f, -0.01707085f, 
    -0.00694030f, -0.01997003f, -0.02726316f, 0.01119986f, -0.00230263f, -0.00329380f, 0.00619649f, 0.02919341f, 
    0.01059666f, -0.02183723f, -0.02571032f, -0.00279597f, 0.01309532f, -0.03242781f, -0.00179167f, 0.01738060f, 
    0.00869395f, -0.03214704f, 0.00804103f, -0.00069429f, 0.02613618f, -0.00940119f, 0.02415280f, -0.01054392f, 
    -0.04068073f, -0.00223081f, 0.01557890f, -0.01190192f, -0.02248850f, 0.02173514f, 0.00896340f, 0.02620015f, 
    0.01907780f, -0.03920573f, 0.02452631f, 0.02078700f, 0.00582697f, 0.01491149f, 0.01233237f, -0.03524823f, 
    0.00337895f, -0.00429360f, -0.03021897f, -0.00433613f, -0.04117822f, -0.00506853f, 0.02918540f, 0.02111064f, 
    -0.01395188f, -0.02876307f, -0.00327501f, -0.00783923f, 0.02117456f, 0.02123737f, 0.02581444f, -0.02838102f, 
    -0.02519806f, -0.00984754f, -0.04019987f, 0.00649009f, 0.00057960f, 0.02619002f, -0.00649834f, 0.02624367f, 
    0.02526276f, -0.01611224f, -0.03145121f, -0.03640646f, -0.01086177f, -0.00356144f, 0.00470069f, 0.00403671f, 
    0.01497318f, -0.00364133f, -0.01035109f, -0.03761762f, -0.00249852f, -0.03369313f, -0.04004181f, -0.02806845f, 
    -0.00041278f, -0.00322088f, -0.01345936f, -0.01205599f, -0.02358988f, -0.03520327f, -0.03447061f, 0.02047100f, 
    0.00197798f, -0.00623974f, 0.02965988f, -0.01158617f, 0.02628720f, -0.02465203f, 0.00039304f, 0.02610713f, 
    -0.00898456f, 0.01204462f, -0.02532008f, 0.02648074f, -0.01883903f, 0.00645345f, -0.01504831f, -0.02401857f, 
    -0.03080928f, 0.01849599f, -0.02062891f, 0.02760006f, 0.00792847f, -0.00423618f, 0.00528262f, 0.02496218f, 
    0.00611980f, 0.00364653f, 0.02259671f, -0.03550488f, -0.03154747f, 0.00960187f, -0.02972000f, -0.00400321f, 
    0.00915777f, -0.00993181f, 0.00790248f, -0.02676304f, 0.00546212f, 0.00847104f, -0.02310722f, -0.00700034f, 
    -0.01051917f, 0.02448378f, -0.02962493f, -0.01438235f, -0.00095211f, -0.02406706f, -0.00869785f, 0.02290869f, 
    0.02303298f, 0.00658434f, -0.02459634f, -0.03474147f, -0.03666804f, -0.03071114f, -0.02374902f, 0.02970866f, 
    0.00605602f, -0.00533665f, 0.02957493f, -0.01208870f, -0.03407734f, -0.03059826f, 0.01857442f, -0.03554888f, 
    -0.00482603f, -0.01574824f, -0.02821664f, 0.02969171f, -0.00587209f, -0.00366985f, 0.02849988f, 0.02184179f, 
    -0.01326383f, -0.02249471f, -0.00241133f, -0.02057082f, 0.01497255f, 0.02294014f, -0.01343276f, 0.00795939f, 
    0.06891793f, 0.05655148f, 0.02785022f, 0.25526989f, -0.03429843f, 0.06837530f, -0.02718723f, -0.07887567f, 
    -0.00995061f, -0.02088937f, 0.04034603f, 0.04597547f, -0.02451005f, 0.13986453f, -0.02269394f, -0.03889054f, 
    -0.02472409f, 0.09255454f, -0.00263121f, 0.04514087f, -0.07011048f, 0.01550825f, 0.03406651f, 0.03077271f, 
    0.19123329f, 0.01938320f, 0.07054624f, -0.08016836f, -0.00827179f, -0.04234389f, 0.13187820f, -0.02013937f, 
    0.03486802f, 0.01345942f, -0.03250605f, 0.03526827f, 0.23971038f, 0.26436666f, 0.03002472f, -0.14622614f, 
    0.02353249f, 0.02430277f, -0.04297732f, 0.04329947f, 0.02218866f, -0.00979692f, 0.02422891f, 0.03324164f, 
    0.15873097f, 0.15004528f, -0.01701592f, -0.05305318f, 0.02705849f, -0.04546304f, 0.05955178f, 0.07987705f, 
    -0.02814212f, 0.00738885f, -0.11305594f, -0.03609366f, -0.18530791f, 0.12399214f, 0.08510147f, 0.14563727f, 
    -0.00560332f, 0.03457560f, 0.01787059f, 0.09793454f, 0.15270263f, 0.05759419f, 0.01893977f, 0.02209438f, 
    0.12788002f, -0.03796383f, -0.00189580f, 0.02937570f, -0.01874886f, 0.02500436f, 0.02004537f, -0.02670336f, 
    -0.02866949f, 0.05218219f, 0.01298237f, 0.01171478f, 0.09012318f, 0.16165872f, 0.02735174f, 0.02890399f, 
    0.02070465f, -0.01121235f, 0.03786413f, -0.01687738f, 0.04871585f, 0.02115725f, 0.07146537f, 0.01586985f, 
    0.02360672f, 0.13149969f, 0.08939927f, 0.11723428f, 0.03291499f, -0.00887753f, -0.00321786f, 0.00770411f, 
    0.00971480f, -0.04772310f, 0.10404575f, -0.03614791f, 0.09229103f, 0.16328061f, 0.11426141f, -0.12781003f, 
    0.00977384f, 0.04791506f, 0.12015478f, 0.10931633f, -0.02508314f, 0.01383647f, 0.01701552f, 0.04698293f, 
    0.14465427f, -0.08742949f, -0.09210505f, -0.06867992f, 0.02739558f, -0.03753600f, -0.00319848f, 0.00887146f, 
    -0.04131068f, -0.02487017f, 0.01620319f, 0.03707841f, 0.15965582f, 0.01467491f, -0.01032635f, -0.08184322f, 
    0.04841632f, -0.02373281f, 0.07444359f, -0.06720658f, -0.04474779f, 0.06765173f, -0.07312808f, -0.05802640f, 
    0.14864708f, -0.00444844f, 0.09619846f, 0.04382486f, -0.10608687f, -0.02393029f, -0.03665638f, 0.10335045f, 
    0.06546728f, 0.00694905f, -0.03283850f, 0.00633190f, 0.31586456f, 0.00011468f, -0.04381983f, 0.03383595f, 
    -0.01475131f, -0.11505268f, 0.06533141f, 0.00028233f, 0.01304642f, -0.07531654f, -0.08338573f, 0.04416062f, 
    -0.13180360f, 0.04457510f, -0.16354083f, -0.03284374f, -0.09025848f, 0.01976551f, 0.00093919f, -0.04373749f, 
    -0.09287351f, -0.01398261f, 0.06285378f, 0.14213879f, -0.07391759f, 0.08618059f, -0.04269490f, -0.01386029f, 
    0.02393841f, -0.02285417f, -0.03061957f, -0.02758512f, 0.01500759f, -0.01109766f, 0.02500335f, -0.01983092f, 
    0.08892483f, 0.05828032f, -0.08569683f, 0.14277461f, 0.08018035f, -0.03480830f, -0.10461088f, -0.01784122f, 
    -0.00340775f, 0.02548958f, -0.01342950f, 0.08966415f, 0.08295806f, -0.01927912f, 0.10470587f, 0.08161567f, 
    -0.00243521f, 0.00893085f, 0.00555756f, -0.05828372f, -0.00679545f, 0.00664480f, -0.04707417f, -0.08072524f, 
    0.03712751f, -0.10949952f, -0.16081958f, 0.11945929f, 0.09735902f, -0.01659579f, -0.04594320f, 0.00683344f, 
    -0.04580287f, 0.11427937f, -0.01700136f, 0.05773595f, 0.03055689f, 0.14391868f, -0.01335313f, -0.02918182f, 
    0.06679475f, 0.03272639f, 0.01973167f, -0.01405204f, 0.03817922f, 0.10434963f, -0.03224277f, -0.05512176f, 
    0.16314910f, 0.04803742f, -0.12623200f, 0.00985999f, 0.05683770f, 0.00769423f, -0.06822953f, 0.02627668f, 
    -0.00890706f, -0.01903384f, 0.00598759f, -0.09142884f, -0.11247530f, -0.02995876f, -0.03485828f, -0.13925742f, 
    -0.04921873f, -0.03149311f, -0.01893886f, 0.06330725f, 0.00269986f, 0.02272738f, -0.00402806f, 0.08312069f, 
    0.01403172f, -0.05196321f, -0.00140544f, -0.09582684f, -0.01868859f, 0.01986395f, 0.01523749f, -0.01082991f, 
    0.07485565f, 0.05359256f, 0.06828479f, 0.10547046f, -0.13140461f, -0.06652491f, -0.09208683f, 0.02122567f, 
    0.05268613f, 0.09761331f, -0.02440352f, -0.08170295f, -0.00016345f, 0.12167982f, 0.01033600f, 0.01838518f, 
    0.05174328f, 0.21929997f, 0.06033976f, 0.09624354f, -0.05293053f, -0.04370447f, 0.00456876f, 0.02267417f, 
    0.06751179f, 0.04118067f, 0.03213290f, -0.02040463f, 0.12936647f, -0.08510436f, -0.02439182f, -0.23354635f, 
    0.00687460f, 0.13411699f, 0.01675015f, 0.01706632f, 0.04254378f, 0.07626504f, 0.06454618f, 0.10745817f, 
    0.25903437f, 0.01393796f, 0.06259831f, -0.30036211f, 0.05989365f, 0.07774094f, 0.06979359f, 0.05172770f, 
    -0.03636019f, 0.11474093f, -0.01955105f, 0.00155426f, 0.17725687f, -0.09302004f, -0.03614580f, -0.16597337f, 
    0.03969231f, 0.03918086f, 0.01993887f, -0.02886421f, -0.05783239f, 0.05044666f, -0.01567855f, -0.02074290f, 
    0.23028256f, -0.03860847f, -0.08119917f, 0.03386772f, 0.06003234f, 0.00925753f, -0.00943421f, -0.06246474f, 
    0.00870628f, -0.03732324f, 0.06071013f, 0.13376501f, 0.18742010f, 0.04794773f, 0.04931599f, 0.05245376f, 
    0.01244015f, -0.01560194f, -0.04110722f, 0.00896207f, 0.00016424f, 0.09933283f, 0.00541707f, -0.03327088f, 
    -0.04560161f, 0.04131771f, 0.13726161f, -0.14765690f, -0.06687713f, -0.02844462f, 0.06820009f, 0.09156944f, 
    -0.05514865f, 0.09565790f, 0.07565723f, 0.13630918f, 0.01477324f, -0.20276241f, -0.09827461f, -0.03733017f, 
    -0.11069708f, 0.00019909f, -0.03322171f, -0.00737457f, -0.04716539f, -0.03897290f, 0.10305268f, 0.04092191f, 
    0.21941134f, -0.15936475f, -0.14848946f, 0.02865797f, 0.00579906f, -0.04476238f, 0.01252743f, -0.02643185f, 
    -0.06680629f, -0.09003226f, 0.04692992f, 0.01114610f, 0.27170372f, 0.11720397f, 0.06469987f, -0.04321280f, 
    0.00422862f, -0.00246947f, 0.01078290f, -0.00666930f, -0.00408950f, 0.01556084f, -0.08392554f, -0.02839433f, 
    0.06142304f, 0.21201216f, 0.18412432f, -0.04959033f, 0.04587742f, 0.01103267f, 0.02666619f, 0.06282476f, 
    0.09698501f, -0.00129491f, -0.08868758f, -0.05128776f, 0.02341651f, -0.05837462f, -0.14975405f, 0.02399712f, 
    -0.11215418f, -0.01025735f, 0.03388198f, 0.02143494f, 0.01278531f, -0.05689039f, 0.02865214f, 0.06209951f, 
    0.14708224f, 0.14054032f, 0.09141998f, -0.01902873f, 0.01182601f, 0.02767172f, 0.08478452f, 0.01689719f, 
    -0.03555031f, 0.03572895f, -0.02119245f, 0.04900637f, 0.08308710f, 0.07656074f, 0.15047452f, 0.00380203f, 
    0.05598200f, -0.02729625f, 0.06870446f, -0.08528025f, -0.02275909f, 0.07912832f, -0.00305096f, -0.00603981f, 
    -0.01113411f, -0.05183478f, -0.03757576f, 0.11845763f, -0.03073040f, -0.02786748f, -0.03165033f, -0.02003567f, 
    -0.09475917f, 0.04166877f, 0.04689746f, 0.07808149f, -0.09876662f, -0.02782321f, -0.15025961f, 0.07551538f, 
    0.01918842f, -0.03013120f, -0.01818666f, -0.03094178f, -0.09773829f, -0.03102975f, 0.09003524f, 0.08721446f, 
    -0.22219966f, 0.18514034f, -0.02937098f, 0.05553207f, -0.05541513f, -0.02345583f, -0.04771183f, 0.15802670f, 
    -0.00501363f, -0.05152259f, -0.04420332f, -0.05584834f, 0.13240841f, 0.01626841f, 0.02410537f, 0.05903111f, 
    0.10494298f, 0.03766513f, -0.02130157f, -0.01133172f, -0.00808924f, -0.03191799f, 0.07133356f, 0.03437789f, 
    0.24541613f, -0.01522759f, 0.03714511f, -0.21029723f, 0.03021098f, -0.03640984f, 0.03274772f, 0.10424077f, 
    0.08468249f, 0.05894832f, -0.04574829f, 0.06862619f, 0.03832131f, -0.28336683f, -0.02667167f, -0.07702078f, 
    -0.00770119f, -0.07557390f, 0.06973732f, 0.06970193f, 0.00550715f, -0.00612957f, -0.03120986f, 0.07806738f, 
    0.08311886f, -0.00071760f, -0.01867546f, 0.07462377f, 0.05903113f, -0.00984860f, -0.03339997f, 0.01417339f, 
    0.02299025f, -0.05025448f, 0.05236432f, -0.04565625f, 0.06266822f, 0.09006963f, -0.00518519f, 0.26949993f, 
    -0.02656802f, 0.01500494f, -0.08230890f, 0.02732740f, 0.03902812f, 0.03308720f, -0.03106744f, -0.00813723f, 
    0.13820580f, -0.02666472f, 0.05433463f, 0.08370494f, 0.11742356f, 0.04547980f, -0.06898011f, 0.04147097f, 
    -0.08297520f, -0.03117892f, 0.04747401f, 0.00650933f, 0.01655161f, -0.02214199f, -0.06129935f, -0.00306909f, 
    -0.01956569f, 0.05228696f, 0.02201227f, -0.02382828f, -0.05380950f, 0.06897404f, 0.07334857f, -0.01044167f, 
    0.17405497f, -0.03721624f, -0.06160409f, -0.11701219f, -0.09632833f, -0.04309445f, 0.14839399f, -0.08716524f, 
    0.06212378f, -0.02527906f, 0.02185376f, -0.03681576f, -0.13741039f, 0.01691844f, -0.08013751f, -0.05323749f, 
    0.01747283f, 0.12209598f, -0.06727419f, -0.11213215f, 0.04851627f, 0.00988438f, -0.01354328f, -0.06643013f, 
    0.16508414f, 0.03194516f, -0.04958463f, 0.00468812f, 0.07773562f, 0.02245196f, 0.01483820f, -0.06876414f, 
    -0.01629013f, 0.06952482f, 0.10007439f, 0.03417869f, -0.05813255f, 0.11500093f, 0.10869566f, 0.01856679f, 
    -0.08429927f, 0.08045518f, -0.13603711f, -0.00265004f, -0.06679490f, 0.01113990f, -0.05265066f, -0.07846312f, 
    0.21112435f, -0.10998762f, 0.05831955f, -0.15157932f, 0.07965516f, -0.00199906f, -0.00514766f, -0.00780599f, 
    -0.08555484f, -0.00410051f, 0.02502823f, 0.07612897f, 0.08142119f, 0.03522856f, 0.09069131f, -0.21981303f, 
    -0.00284669f, 0.05814257f, -0.01693850f, 0.05202784f, 0.03526422f, -0.00920640f, -0.02143474f, -0.03662673f, 
    -0.00607431f, -0.16709921f, -0.17356776f, 0.09758474f, -0.05767400f, -0.03602738f, 0.01252292f, -0.12022514f, 
    0.00904098f, 0.01787828f, 0.02468655f, -0.03536177f, 0.12273225f, 0.20190333f, -0.07388183f, 0.01992263f, 
    0.04226969f, -0.02645429f, 0.00044156f, 0.03127708f, 0.01504454f, -0.06779423f, -0.05202772f, 0.02684730f, 
    0.14239955f, 0.01985917f, 0.13953987f, -0.07978279f, 0.07874728f, 0.02275891f, 0.02525937f, 0.02485146f, 
    -0.06653326f, 0.08307171f, 0.02898335f, 0.03977391f, 0.07538408f, 0.18293595f, 0.10603385f, -0.18366098f, 
    0.07098777f, -0.02232889f, 0.04873773f, 0.06010870f, 0.07622194f, -0.01986588f, 0.04531820f, 0.02273296f, 
    -0.00366737f, 0.01266349f, 0.16339363f, -0.03665005f, 0.09996608f, 0.05987152f, -0.07318838f, 0.08587013f, 
    0.01147433f, -0.00030422f, -0.04512196f, -0.02202746f, 0.05635449f, -0.00281056f, 0.03165206f, 0.02833249f, 
    -0.10579904f, 0.05173524f, 0.00679791f, -0.06106144f, 0.02419067f, -0.06784090f, -0.00788354f, -0.17486802f, 
    0.12702943f, 0.16132218f, 0.02186974f, -0.08130755f, 0.00848790f, -0.01594163f, -0.03041753f, 0.01912213f, 
    -0.03228878f, 0.05786646f, -0.02547043f, 0.11490247f, 0.07734904f, -0.06804346f, -0.04420266f, 0.06651714f, 
    0.02649502f, 0.00569948f, 0.07164188f, -0.00903917f, -0.06213356f, 0.06458972f, 0.04660809f, 0.05982344f, 
    0.13576747f, 0.10535747f, -0.02304440f, -0.01413099f, -0.06232312f, -0.06161436f, 0.08354538f, 0.05890192f, 
    0.03175183f, -0.00771687f, -0.08913303f, -0.00190070f, 0.24192631f, 0.19539945f, -0.00229096f, -0.05750017f, 
    0.07797473f, 0.01014443f, 0.05179648f, 0.04539903f, 0.00976116f, -0.00492439f, 0.04471473f, 0.00274707f, 
    0.26181152f, -0.12575154f, 0.11947692f, -0.05082832f, 0.10777999f, 0.08734434f, 0.06248229f, -0.03205772f, 
    0.07774489f, 0.16240972f, -0.14224592f, 0.04629193f, -0.07997700f, 0.18102393f, 0.04895969f, 0.05079870f, 
    0.03296125f, 0.01380574f, 0.06693105f, -0.03599146f, 0.00946396f, 0.05740624f, 0.00764251f, -0.05145846f, 
    0.01931945f, -0.02717430f, -0.07305635f, -0.01066630f, -0.04090953f, -0.05480345f, -0.01744280f, 0.03374171f, 
    -0.03276858f, -0.05532581f, -0.02308439f, -0.02530185f, -0.07573745f, 0.15939616f, 0.04127977f, -0.05177603f, 
    0.05606570f, 0.12874283f, 0.00683888f, -0.03238733f, 0.04105939f, -0.05759069f, -0.01191569f, -0.04248830f, 
    -0.08638559f, 0.17090496f, -0.01015566f, -0.01055818f, -0.11650840f, -0.04348046f, 0.04350006f, -0.08347906f, 
    0.01039601f, -0.06739221f, 0.03634475f, -0.00145491f, 0.02995927f, 0.15621062f, 0.01050657f, -0.01553905f, 
    -0.03213665f, -0.02143151f, -0.17608830f, -0.07929789f, -0.00917030f, -0.08995898f, 0.02056267f, -0.09623076f, 
    0.11338884f, -0.13107292f, -0.23520477f, 0.04332815f, 0.10597204f, 0.04989959f, 0.02976979f, -0.00432756f, 
    -0.07947359f, -0.00635450f, 0.10315772f, 0.09366571f, -0.08593971f, 0.04255904f, 0.03543577f, -0.07233655f, 
    0.01809774f, 0.01892563f, -0.03214507f, 0.03887360f, 0.00569229f, -0.06479545f, 0.03393524f, -0.09613532f, 
    -0.25818193f, 0.07962947f, 0.15844062f, -0.05679382f, 0.09371958f, 0.08147053f, -0.02519868f, 0.01082629f, 
    -0.05610608f, -0.07476463f, 0.12691277f, -0.08647426f, 0.36263093f, 0.01812481f, -0.07742795f, -0.04709176f, 
    -0.06853881f, 0.12894192f, -0.11811340f, -0.11058943f, -0.05306890f, 0.00260401f, -0.01487268f, -0.00875965f, 
    0.19492643f, 0.03305572f, -0.13625447f, 0.11906123f, -0.10656957f, -0.10747801f, 0.06204753f, 0.03508218f, 
    0.10553110f, 0.06578965f, -0.00811367f, -0.17494097f, 0.22701630f, -0.00644679f, 0.02453407f, 0.14477460f, 
    -0.00986321f, 0.02232068f, 0.06076211f, 0.01863261f, -0.05775496f, -0.04996502f, -0.00374972f, 0.01499782f, 
    -0.01534016f, -0.18087624f, 0.06831616f, -0.00223965f, -0.08765848f, -0.05768586f, -0.02099800f, 0.07049783f, 
    -0.03532297f, -0.01676827f, 0.05192518f, 0.03322069f, -0.14808689f, 0.01493924f, -0.12970020f, -0.11776213f, 
    0.02574578f, -0.10005782f, -0.10507052f, 0.01721309f, 0.04177380f, -0.01587068f, 0.00303056f, -0.02463295f, 
    -0.05952030f, 0.14851288f, -0.04418530f, 0.05614214f, 0.03088753f, -0.04409503f, 0.09702776f, 0.04349731f, 
    0.00787101f, 0.10793521f, 0.00893451f, -0.03329750f, 0.03533363f, 0.03500227f, 0.10840277f, -0.01750399f, 
    -0.00190939f, -0.01666332f, 0.15839507f, 0.01007687f, 0.00197739f, 0.04130469f, 0.09023407f, 0.00046258f, 
    0.25705725f, 0.09887988f, -0.11485808f, 0.07673933f, 0.07408302f, 0.15405592f, 0.05213078f, -0.03177842f, 
    -0.01553887f, 0.02650941f, -0.04204020f, -0.02408055f, 0.21784994f, 0.03076175f, 0.04920837f, 0.04555958f, 
    0.04535358f, 0.02838670f, -0.15013300f, 0.00175607f, -0.02363222f, -0.08709409f, -0.00015330f, 0.15249608f, 
    0.23616596f, -0.08175288f, -0.06971386f, 0.18378511f, -0.05485370f, -0.09023597f, 0.02432154f, 0.13180518f, 
    0.03661205f, -0.00187002f, -0.04961116f, 0.08970372f, -0.26226300f, 0.25660989f, -0.01978299f, -0.04774070f, 
    -0.01140208f, 0.00274761f, 0.01868065f, 0.01940319f, -0.04826927f, -0.01626999f, 0.08434749f, -0.14604430f, 
    0.03788743f, 0.10014054f, 0.03534845f, 0.13672212f, -0.00734434f, 0.05071113f, 0.01574310f, 0.00229870f, 
    0.01745932f, -0.04953064f, -0.00993269f, -0.19069430f, -0.19256696f, 0.21365310f, -0.01538694f, 0.06534703f, 
    -0.05560946f, 0.03939595f, -0.03830878f, 0.11675096f, -0.03909795f, 0.00067128f, 0.01656898f, -0.03700563f, 
    0.01473082f, -0.05702249f, 0.11974046f, 0.14220332f, 0.00072444f, 0.08444269f, -0.06738901f, 0.08577918f, 
    0.03807715f, -0.07784328f, -0.04972558f, -0.07615162f, -0.03323874f, -0.06516148f, 0.04087254f, 0.09212982f, 
    0.04619351f, -0.01110667f, -0.06786268f, 0.12850487f, 0.05018129f, -0.01850319f, 0.05610779f, 0.00347891f, 
    -0.21143189f, -0.03690267f, 0.03967047f, 0.04466185f, -0.13008741f, -0.06461086f, 0.06569540f, -0.11620981f, 
    0.01332717f, 0.07946759f, 0.16171387f, 0.05086648f, -0.00362541f, 0.02598637f, -0.07672369f, -0.14726359f, 
    -0.03758537f, 0.05642379f, 0.14334871f, -0.01003964f, 0.11556102f, -0.10506835f, -0.05347563f, -0.01142466f, 
    -0.15404484f, -0.07616799f, -0.04206852f, -0.01208355f, -0.01146103f, -0.04720556f, -0.02545694f, -0.15848315f, 
    -0.05896906f, -0.06551506f, 0.02745079f, 0.00521607f, 0.23593935f, -0.26389804f, -0.00897502f, 0.29002720f, 
    -0.06749292f, -0.05647533f, 0.01749215f, 0.14135098f, 0.03743836f, 0.10238270f, 0.04497785f, 0.00846539f, 
    0.02817619f, -0.04639074f, 0.07573757f, 0.08416051f, 0.05295948f, 0.00709234f, -0.04207818f, 0.03502423f, 
    -0.04152351f, -0.07146209f, 0.08763418f, -0.10124116f, -0.36475971f, 0.05712654f, -0.08619169f, 0.06933656f, 
    -0.02766854f, -0.09979117f, 0.04032948f, 0.05409719f, 0.08211780f, -0.05805233f, -0.02108618f, 0.06535011f, 
    -0.08760045f, -0.07072013f, 0.02331688f, 0.10871232f, -0.01256803f, -0.01820392f, 0.03731759f, 0.04384119f, 
    0.00712063f, -0.02647762f, -0.06096170f, 0.08365097f, 0.11252063f, -0.09752195f, 0.08476471f, 0.12952174f, 
    -0.10639689f, -0.11037345f, 0.09719357f, 0.14531206f, 0.04235140f, 0.00550979f, -0.00696341f, -0.01711334f, 
    0.19044465f, -0.17448434f, -0.11393929f, 0.14393625f, -0.08538974f, 0.08097895f, -0.01436560f, 0.13327244f, 
    0.05251810f, 0.02337123f, 0.05530766f, 0.05033411f, -0.21255937f, 0.08516029f, -0.09606427f, 0.03025821f, 
    0.02686913f, -0.07690744f, 0.10498716f, 0.04618602f, -0.03226862f, 0.01845879f, 0.00980020f, -0.01949605f, 
    -0.01799761f, -0.12515159f, 0.16839673f, 0.02097042f, -0.03936971f, 0.04107767f, 0.02359722f, 0.02233263f, 
    0.04931140f, -0.00921337f, 0.00833995f, 0.09430977f, 0.06101280f, -0.05377571f, -0.04130381f, 0.06329328f, 
    -0.07503878f, -0.00960384f, 0.06089395f, 0.06005855f, 0.10285043f, 0.02370521f, 0.00950189f, 0.08111640f, 
    0.01169469f, 0.19778439f, 0.09402867f, -0.02350190f, -0.13955201f, -0.12102996f, -0.03398532f, 0.00138201f, 
    0.03302194f, -0.07245365f, 0.08278845f, -0.08465318f, 0.05331038f, -0.07909314f, 0.04569053f, 0.24754599f, 
    -0.04453477f, -0.03079033f, -0.01001287f, -0.03140058f, 0.02773609f, -0.22064355f, -0.01313949f, 0.02133809f, 
    -0.15402675f, -0.09660694f, 0.14041795f, 0.28522116f, 0.02365183f, 0.00090302f, 0.04306592f, 0.00958280f, 
    0.00992919f, 0.04817264f, -0.07840543f, 0.03963412f, 0.15663551f, 0.05524595f, 0.11195425f, 0.08723128f, 
    -0.04172739f, 0.06116727f, 0.03944894f, -0.00376172f, 0.02112454f, -0.00501412f, -0.06565655f, -0.03992094f, 
    -0.33187193f, 0.20983368f, 0.30869818f, -0.05858132f, -0.07903959f, -0.01781939f, -0.04080812f, 0.05739891f, 
    0.02799614f, 0.08163086f, -0.06908394f, 0.10026357f, -0.09326877f, 0.06393656f, 0.12914729f, 0.37213752f, 
    -0.06274395f, 0.08927797f, 0.01563038f, -0.13540712f, -0.09909528f, -0.07688102f, -0.16394743f, -0.03302815f, 
    -0.20759711f, -0.08733268f, 0.06440406f, 0.03645894f, 0.01887528f, 0.02183954f, 0.00183759f, 0.00880327f, 
    -0.02696410f, -0.02360872f, 0.03420842f, 0.02318899f, 0.04576930f, -0.23626684f, -0.10278821f, 0.21014501f, 
    -0.07010835f, 0.09606034f, -0.08424456f, 0.10084952f, 0.00841934f, -0.11837138f, -0.06792647f, -0.06499898f, 
    0.08321875f, -0.05388875f, 0.10609723f, 0.17009616f, 0.01364351f, 0.10562024f, 0.08459452f, -0.11438897f, 
    0.00342916f, 0.03925862f, -0.05526515f, 0.06811085f, -0.46791673f, 0.07121275f, 0.01548233f, -0.12192677f, 
    0.01192285f, -0.03181816f, 0.06063618f, -0.06575052f, -0.02632328f, -0.04205370f, -0.03244759f, 0.11786609f, 
    0.15986866f, -0.04303750f, 0.20318642f, 0.24282084f, 0.03950454f, -0.12839228f, -0.00026319f, -0.03977755f, 
    -0.00553612f, 0.03695906f, -0.03676676f, -0.03243836f, -0.01142635f, -0.04312555f, 0.04216540f, -0.04137050f, 
    -0.00756393f, 0.09005070f, 0.03300153f, -0.00316229f, -0.03402868f, -0.04403461f, -0.04706819f, -0.06126997f, 
    0.05190581f, -0.05394698f, 0.03414802f, 0.04100778f, -0.06326958f, 0.05077733f, -0.04387678f, 0.10339355f, 
    -0.04694200f, 0.06953129f, 0.01575467f, -0.02657601f, 0.21134724f, -0.01479958f, 0.01897842f, -0.07695443f, 
    -0.01305940f, 0.03231144f, 0.10563915f, 0.07146599f, 0.15364654f, 0.15044311f, 0.15286846f, 0.04693298f, 
    0.16755329f, 0.10859652f, 0.13916864f, 0.21627530f, 0.07314002f, -0.00768728f, 0.08244547f, -0.10023293f, 
    0.04782164f, -0.11978436f, -0.08952338f, 0.00292435f, -0.09912416f, -0.03259009f, 0.19476783f, -0.04107671f, 
    -0.11953884f, -0.10773439f, 0.07585396f, -0.09357597f, 0.01772019f, 0.15657072f, 0.00002421f, 0.09344617f, 
    0.09465090f, 0.03518916f, 0.01909674f, -0.01832729f, -0.07992064f, -0.04019656f, 0.07439653f, -0.04395763f, 
    0.05980623f, 0.08354160f, -0.04652688f, 0.00444702f, 0.22561365f, 0.05762488f, 0.11270146f, 0.01743206f, 
    -0.03620340f, 0.09068923f, -0.00959547f, -0.00353594f, -0.02549968f, 0.04774396f, -0.03115189f, -0.05171505f, 
    0.23243997f, -0.16171663f, 0.06391142f, -0.00947308f, -0.05328896f, 0.02661300f, -0.02707616f, -0.00061898f, 
    -0.04711752f, -0.10428455f, -0.00046794f, 0.02816430f, 0.04448565f, 0.15160127f, -0.03801495f, -0.15141508f, 
    -0.03339517f, 0.08272188f, 0.09006841f, 0.09736747f, -0.07474038f, 0.13230231f, -0.00697808f, 0.06317431f, 
    0.14069881f, -0.03184101f, -0.03476296f, -0.04729876f, -0.02364367f, -0.11083762f, 0.06901667f, -0.09095380f, 
    0.01543709f, 0.08278202f, 0.06795103f, -0.07114713f, -0.02140437f, -0.01135584f, -0.01798614f, -0.03683627f, 
    -0.00478079f, 0.02229214f, 0.10888872f, -0.01257393f, 0.06625890f, -0.00265610f, -0.01316358f, 0.07757059f, 
    0.25343710f, 0.01748855f, -0.21366766f, 0.19537538f, -0.08914217f, -0.03997677f, -0.02079763f, -0.07573321f, 
    0.07663479f, -0.08084760f, -0.03430004f, 0.09860186f, -0.01127302f, 0.08692224f, -0.13051902f, -0.08335169f, 
    -0.06969298f, -0.03358353f, 0.02729527f, -0.04646225f, -0.02253448f, 0.02494962f, 0.07758953f, 0.00981851f, 
    0.03977966f, 0.02395541f, -0.10097656f, 0.04226464f, 0.03014901f, 0.06366093f, 0.01894443f, 0.00178591f, 
    0.03757378f, 0.02209649f, 0.02476171f, -0.00115910f, -0.00390690f, -0.04323455f, 0.04523592f, -0.04104043f, 
    0.07997419f, -0.04270568f, 0.05722447f, -0.05054948f, -0.02096273f, 0.02739463f, -0.10445942f, -0.13153480f, 
    0.11973844f, 0.17101853f, -0.09005649f, -0.04106786f, -0.04093322f, -0.12515786f, 0.15351538f, -0.16370709f, 
    -0.00086654f, -0.00147461f, 0.01318439f, 0.03517267f, -0.10456285f, 0.10286379f, -0.07687372f, -0.06637543f, 
    0.07153018f, 0.08559414f, -0.06689583f, -0.00648140f, -0.04507913f, 0.00957285f, 0.08710361f, -0.02714660f, 
    0.00948003f, -0.00686309f, -0.03409467f, -0.01965241f, -0.00423227f, 0.00622274f, -0.02551653f, 0.00853943f, 
    0.02758737f, -0.03220777f, 0.00976272f, -0.04370660f, -0.04064056f, -0.01784423f, 0.02572425f, -0.00282218f, 
    0.01949559f, -0.01521131f, -0.01366407f, -0.03366986f, -0.03331108f, -0.04206676f, -0.00326369f, 0.02636909f, 
    -0.01187945f, 0.00786836f, -0.02633171f, -0.03577448f, -0.02095592f, -0.00734286f, 0.02512189f, -0.00826543f, 
    -0.01250169f, -0.03771009f, -0.01668427f, -0.02130709f, 0.00704643f, -0.01071919f, 0.02942963f, -0.01891937f, 
    0.01178490f, 0.00687180f, 0.02277187f, -0.00463533f, 0.01225070f, -0.04091451f, 0.01705140f, 0.03802241f, 
    0.02207847f, -0.01768025f, -0.01446154f, 0.00320364f, -0.00882458f, -0.02188158f, -0.03845411f, 0.02001122f, 
    0.01525836f, -0.02646010f, -0.01273405f, -0.02835993f, -0.02262236f, -0.00679041f, -0.04000622f, 0.00592392f, 
    -0.02766250f, 0.01686379f, -0.00664457f, 0.00492765f, 0.01087778f, -0.02457371f, -0.00314181f, -0.03172167f, 
    -0.00192516f, 0.00285925f, -0.00587201f, 0.01667892f, -0.03732739f, 0.01684495f, 0.02431444f, -0.00100091f, 
    0.01396598f, -0.01753597f, 0.02700147f, 0.02204203f, -0.03735025f, 0.00811435f, -0.03630321f, -0.01106587f, 
    0.02495711f, 0.01448443f, 0.02538852f, -0.02642120f, -0.02718233f, -0.02271136f, 0.01216743f, 0.01258459f, 
    -0.00565530f, -0.00439355f, 0.02187784f, 0.00124393f, 0.02265972f, 0.01774073f, -0.01049578f, -0.03180866f, 
    -0.00402095f, -0.02318010f, -0.02453445f, -0.03391152f, 0.01372564f, 0.01743221f, -0.02157266f, -0.01568687f, 
    -0.01497555f, 0.00889853f, 0.02156582f, 0.00962920f, 0.01548830f, -0.02283414f, 0.00397271f, -0.01049621f, 
    0.00679435f, 0.00266556f, -0.03719635f, -0.03158303f, -0.03580398f, -0.00936469f, 0.02843370f, 0.01140996f, 
    0.00469766f, 0.02033836f, -0.00792443f, -0.02609231f, 0.01250667f, -0.04142028f, 0.01980383f, 0.01874998f, 
    0.02093607f, 0.00089531f, -0.02471849f, 0.02556377f, 0.00311296f, 0.00450312f, -0.04125492f, -0.01979130f, 
    0.00745625f, 0.00709928f, -0.03245198f, -0.03672325f, 0.02306642f, -0.01347498f, 0.00537735f, -0.02817249f, 
    0.01067117f, 0.01473420f, -0.00224642f, -0.04046188f, -0.01950138f, 0.00217695f, 0.01718745f, 0.00362472f, 
    0.02065957f, -0.01301492f, -0.00496988f, -0.03273910f, 0.02388246f, -0.00797194f, -0.03158664f, 0.02597451f, 
    0.00514340f, 0.00374050f, -0.00745367f, -0.01518096f, 0.01376345f, -0.01631453f, -0.01341407f, -0.00111155f, 
    -0.01953858f, -0.01093678f, -0.01094430f, 0.01360816f, -0.00744111f, -0.02327429f, 0.01717125f, -0.04298864f, 
    -0.00381896f, 0.00876653f, -0.02220349f, -0.02892962f, -0.00112783f, -0.00706611f, 0.00954523f, -0.02208181f, 
    -0.01486311f, -0.03719985f, -0.03782846f, 0.00072609f, 0.01591916f, -0.01156561f, 0.00373631f, 0.02535432f, 
    0.00576206f, 0.00548384f, -0.01446554f, -0.03453712f, 0.01470797f, -0.02485626f, -0.00372268f, -0.02517732f, 
    -0.02009444f, -0.03915666f, 0.00059697f, -0.00631768f, 0.00140507f, -0.03113447f, -0.03351588f, -0.03845970f, 
    -0.00107649f, -0.03882780f, 0.00240179f, -0.01595345f, -0.02227621f, -0.02074321f, -0.03867052f, -0.00780414f, 
    -0.01848865f, 0.02591094f, -0.03045099f, -0.03056246f, -0.02463521f, -0.00434580f, 0.00928024f, -0.01517354f, 
    -0.02828773f, -0.01155421f, 0.01694524f, -0.00179744f, 0.02853225f, -0.01141926f, -0.01758557f, 0.01187419f, 
    0.00321354f, 0.01119951f, 0.02479433f, 0.01670669f, 0.01431940f, 0.00761425f, 0.02398470f, -0.00226290f, 
    -0.03761462f, 0.02112311f, 0.00881885f, 0.01520409f, 0.02694655f, 0.00250308f, 0.02544797f, -0.04190033f, 
    -0.00337259f, 0.01129326f, -0.03057672f, -0.02221725f, -0.03327135f, -0.00489114f, -0.02564879f, -0.02562121f, 
    -0.01086865f, -0.03307370f, -0.01211096f, 0.02425910f, -0.02430196f, -0.02772054f, 0.02015498f, -0.01423557f, 
    0.00671517f, -0.00696253f, 0.02550742f, 0.00902571f, -0.02624559f, 0.02653908f, -0.02694626f, -0.01965467f, 
    -0.03550288f, -0.02999637f, -0.01162531f, -0.01909953f, 0.00611541f, -0.02255318f, -0.03588008f, 0.01569923f, 
    0.00068911f, -0.00951019f, 0.00916619f, 0.02292930f, -0.01203740f, -0.03918275f, -0.00451522f, 0.01537400f, 
    -0.03327610f, 0.00522345f, -0.01381650f, 0.00972446f, 0.00745912f, 0.02475056f, -0.02332014f, -0.00903863f, 
    0.02646406f, -0.03923036f, -0.01694425f, -0.00083968f, -0.03502011f, 0.02166285f, -0.01997907f, 0.02225422f, 
    -0.02649243f, 0.00459817f, -0.02272088f, -0.03249145f, 0.00740641f, 0.01460601f, -0.00012371f, 0.01568417f, 
    0.02520864f, -0.02480539f, 0.02425704f, -0.00376002f, -0.01517141f, 0.00882671f, -0.01292979f, 0.03009012f, 
    -0.04071669f, 0.00535394f, 0.02579678f, 0.00234472f, -0.02729645f, 0.01988746f, -0.04068648f, 0.02279970f, 
    0.02085445f, 0.02768742f, -0.02864607f, -0.01570134f, -0.02419051f, 0.01609333f, 0.02175021f, 0.02488119f, 
    -0.01995690f, 0.00832991f, -0.02438995f, 0.01905453f, -0.01128192f, 0.00646645f, 0.01966701f, 0.02349569f, 
    -0.03338861f, 0.01417260f, 0.03336232f, -0.03392078f, -0.03034011f, -0.01134935f, 0.02311304f, -0.02717824f, 
    -0.03347215f, -0.04063798f, -0.02307334f, -0.03363613f, -0.01499513f, -0.03067133f, -0.02436565f, 0.01247532f, 
    -0.01093281f, 0.02095293f, -0.03340313f, -0.00595179f, -0.02021671f, -0.04035741f, -0.03491531f, -0.01327201f, 
    -0.00812743f, 0.01939643f, -0.03346425f, -0.03153732f, -0.03723449f, -0.03511328f, -0.01101207f, -0.01459014f, 
    0.01883816f, -0.02755636f, -0.03760333f, 0.02879648f, 0.00793871f, -0.00752102f, 0.02034063f, 0.00700257f, 
    -0.01593474f, -0.02660930f, -0.00552583f, -0.03095675f, -0.03024255f, -0.02211849f, -0.01934537f, -0.01831631f, 
    -0.02491754f, -0.00527147f, 0.02093384f, 0.02454096f, -0.00599776f, -0.03149049f, -0.01879779f, -0.01058477f, 
    -0.03857695f, 0.00681839f, -0.00857401f, -0.03111538f, -0.04104863f, -0.02907591f, -0.02066242f, -0.00556023f, 
    -0.01233838f, -0.04297794f, -0.00821647f, 0.00634812f, -0.03184129f, -0.02438695f, -0.01947119f, -0.04022067f, 
    0.01475040f, -0.00747419f, -0.02173131f, -0.03223779f, 0.01665184f, 0.02557749f, -0.02006987f, 0.01288533f, 
    -0.01910458f, 0.01223729f, 0.01967072f, -0.03690494f, -0.01021783f, -0.00918695f, 0.01250890f, 0.00368877f, 
    0.00655280f, 0.00233628f, 0.00692043f, -0.00207785f, -0.01277664f, -0.00117916f, -0.00391180f, -0.02175333f, 
    -0.00632450f, -0.02898781f, 0.02496938f, -0.01268954f, 0.02575669f, 0.01475049f, 0.02603161f, 0.02662666f, 
    0.02786372f, 0.02378509f, 0.02772423f, 0.00054555f, 0.02452352f, 0.02413009f, -0.03903965f, 0.01623335f, 
    0.01378262f, -0.00720106f, -0.03178035f, 0.01462537f, 0.00017212f, 0.01359743f, -0.03276444f, -0.02264236f, 
    0.02098091f, -0.03040314f, -0.01697016f, -0.01066094f, 0.02915088f, -0.02293952f, 0.02519197f, 0.02619786f, 
    0.01441284f, 0.00051015f, 0.02554497f, -0.02962638f, 0.00347662f, -0.02574539f, -0.00386471f, -0.01098713f, 
    -0.00975687f, 0.00346461f, 0.00600882f, 0.02756855f, -0.01558003f, 0.01779833f, -0.03192730f, 0.01851436f, 
    -0.02304260f, -0.03421766f, -0.02543042f, 0.00430251f, -0.03969919f, 0.00590480f, -0.02212629f, 0.02780614f, 
    -0.00096180f, -0.02501086f, -0.02802937f, -0.04035275f, 0.00690594f, -0.01374134f, 0.00557412f, -0.01182786f, 
    0.01537588f, -0.03525600f, -0.00687390f, -0.01658056f, -0.00194271f, 0.02048681f, -0.00630109f, 0.00810810f, 
    0.00808395f, -0.00404600f, 0.01523348f, -0.03491607f, -0.02681686f, 0.02579361f, -0.04005129f, 0.01209184f, 
    0.01382277f, -0.02065994f, -0.01707760f, -0.03747201f, 0.01577061f, 0.01282132f, -0.03975637f, -0.02430736f, 
    0.01256818f, -0.03951886f, 0.02208536f, -0.02253049f, 0.02358160f, -0.03970320f, -0.00780878f, 0.02264837f, 
    0.02520777f, 0.00836632f, -0.03256880f, -0.01484112f, 0.02680654f, -0.00391582f, 0.00442645f, -0.03916720f, 
    0.03272201f, -0.01962886f, 0.01417838f, -0.01879541f, -0.01382042f, 0.00414740f, 0.02107518f, -0.03526302f, 
    -0.03568999f, -0.00151361f, -0.02104696f, -0.01407791f, -0.00652804f, 0.01784360f, 0.01267397f, -0.02455862f, 
    -0.02660262f, 0.01958148f, 0.01269038f, 0.01142975f, -0.02823261f, 0.01979383f, 0.01856062f, 0.02781691f, 
    -0.04261264f, -0.00023447f, -0.01126166f, -0.00634961f, 0.01664673f, -0.03559148f, -0.03528611f, 0.00884972f, 
    -0.01818453f, 0.02374640f, -0.00470399f, -0.00245183f, -0.02164117f, -0.01558771f, -0.02200305f, 0.00438383f, 
    0.02848711f, -0.02900177f, 0.00676759f, 0.01686284f, -0.01657175f, -0.01531715f, -0.00737270f, -0.01319860f, 
    0.00928148f, -0.01388551f, -0.00560858f, -0.03613539f, -0.03709540f, -0.02581191f, 0.01859073f, 0.00675586f, 
    -0.01188369f, -0.01587064f, -0.01680686f, 0.00405030f, -0.00757355f, 0.00870445f, 0.01126613f, 0.00208342f, 
    0.03501920f, 0.02418454f, -0.04194819f, -0.02434266f, -0.01860697f, -0.03893403f, -0.01003566f, 0.00132286f, 
    -0.02089467f, -0.03149861f, -0.00303079f, -0.00123908f, -0.03010055f, -0.00985382f, 0.01033289f, 0.01774380f, 
    -0.02255264f, -0.02299484f, 0.00636486f, -0.01679262f, -0.02407116f, 0.01507801f, 0.02847418f, -0.04163723f, 
    -0.00607100f, -0.03936816f, 0.01291760f, 0.01536647f, -0.01832531f, -0.01228220f, -0.02593570f, -0.00024942f, 
    -0.00239329f, -0.01687361f, -0.03227871f, 0.02923376f, 0.02304732f, 0.01595464f, 0.00069922f, 0.00699076f, 
    -0.03346818f, 0.00883153f, -0.02717425f, -0.02321242f, 0.01345844f, -0.00195617f, -0.02386199f, 0.01821051f, 
    0.00790654f, -0.02924960f, 0.00915224f, -0.00948459f, -0.02156809f, -0.00267930f, 0.00567721f, -0.02552696f, 
    0.02221800f, -0.03952790f, 0.00136317f, -0.00223588f, -0.00986022f, 0.00993846f, -0.03188344f, 0.02181931f, 
    0.02340847f, -0.01202960f, 0.00349136f, 0.00397709f, 0.01221957f, 0.01940141f, 0.01034144f, 0.01382763f, 
    -0.02484329f, 0.02529147f, 0.02658834f, -0.02648322f, -0.01573170f, 0.02342645f, 0.01891443f, -0.01721747f, 
    -0.02960528f, -0.02735502f, -0.03029433f, -0.01566540f, -0.00358199f, -0.01507109f, 0.00495693f, -0.02696551f, 
    0.02829379f, -0.00739040f, -0.00557318f, -0.00480563f, -0.02654283f, 0.02217869f, 0.02031199f, -0.03099588f, 
    0.03519986f, -0.01508878f, -0.03721139f, 0.00688621f, 0.02273430f, 0.01335787f, 0.00996198f, -0.04186467f, 
    -0.03386289f, 0.02380976f, -0.01214120f, -0.04207646f, -0.03844836f, 0.00432588f, -0.02202735f, -0.01809035f, 
    0.02450561f, -0.03089559f, 0.00993348f, 0.02015058f, -0.03631283f, -0.01039803f, -0.00179349f, -0.01323083f, 
    0.01727162f, 0.01098473f, -0.00187017f, -0.00503676f, -0.01868734f, -0.01755053f, 0.02625632f, -0.00367483f, 
    0.03101809f, -0.02621491f, 0.01511229f, 0.01871024f, 0.00075105f, -0.03839115f, -0.01121600f, 0.02639785f, 
    -0.03919017f, -0.00996996f, -0.01100407f, 0.01988431f, 0.00962945f, -0.02604078f, 0.02575747f, -0.02553537f, 
    0.01797534f, -0.01719496f, -0.03225491f, 0.01810650f, -0.01009935f, 0.02285247f, -0.00421700f, -0.01202718f, 
    0.00311495f, -0.00040706f, -0.03107881f, -0.01201898f, -0.02888440f, -0.01805718f, -0.02397694f, -0.00944660f, 
    0.02408065f, -0.00764056f, 0.00110162f, 0.00101038f, 0.01755163f, -0.04158156f, 0.01811014f, -0.03049383f, 
    -0.03509253f, -0.03530807f, 0.01130843f, 0.02330399f, 0.02532774f, 0.00375829f, -0.00308159f, 0.00825730f, 
    0.02143727f, 0.01835995f, 0.02932354f, -0.02135899f, -0.03432828f, 0.02605634f, -0.00482066f, -0.01104219f, 
    0.02470407f, -0.03276572f, 0.01198711f, 0.01330080f, 0.01843537f, 0.03790256f, 0.01915225f, -0.01659403f, 
    0.03114964f, 0.00980941f, -0.00756698f, -0.00063666f, -0.03536139f, 0.01932130f, 0.00105821f, -0.02675080f, 
    -0.01695310f, 0.01556039f, 0.02442389f, -0.00461960f, -0.00235796f, -0.01356036f, -0.01403979f, 0.00774025f, 
    0.02694944f, -0.01768419f, 0.00529703f, 0.02779541f, -0.01738073f, 0.02858365f, -0.01782682f, -0.02020123f, 
    -0.01562948f, -0.00766393f, 0.01704295f, 0.00717212f, 0.02363549f, 0.00774149f, 0.00696247f, -0.02481078f, 
    0.02081420f, -0.02691431f, -0.04225139f, -0.02416837f, 0.02519207f, -0.00704020f, -0.02498837f, -0.02413064f, 
    0.01922986f, 0.00815372f, 0.01874837f, 0.01079064f, 0.00297952f, -0.00690076f, 0.01873469f, -0.03017197f, 
    -0.03815040f, 0.03377468f, -0.00360498f, 0.01265535f, -0.02892472f, -0.02591313f, -0.02723237f, -0.00291213f, 
    -0.00128828f, -0.03517545f, 0.00518084f, -0.03768218f, 0.02464435f, -0.02341646f, 0.01951148f, 0.00896923f, 
    0.01200708f, 0.02469814f, -0.03808049f, 0.00148771f, -0.02371468f, 0.00807025f, -0.00532504f, -0.03132432f, 
    -0.01426917f, -0.01992115f, -0.00445480f, 0.01531046f, -0.01941817f, 0.01370420f, -0.02574638f, -0.03688613f, 
    0.00009434f, -0.01449347f, 0.01093467f, -0.00412153f, 0.00613196f, -0.02118943f, -0.00722710f, -0.01419360f, 
    0.00026741f, -0.02478980f, 0.00887513f, 0.00761581f, -0.02431791f, -0.03727148f, 0.01397481f, -0.02116586f, 
    0.00608506f, -0.01297226f, -0.02782205f, 0.00978185f, 0.02154825f, -0.01513502f, 0.02871025f, 0.00269336f, 
    0.02144742f, 0.00159813f, -0.00216746f, 0.02386700f, -0.03073511f, 0.02788476f, 0.01047029f, 0.00306901f, 
    -0.01395561f, -0.01300344f, -0.03559343f, 0.01201186f, -0.03439318f, 0.03491829f, 0.01432894f, -0.00085201f, 
    -0.01386613f, 0.00844861f, -0.02942981f, -0.02713928f, -0.01446811f, -0.00175620f, -0.03356071f, 0.01308667f, 
    -0.03483107f, 0.01709202f, -0.00049687f, 0.03295793f, -0.01136597f, -0.01617134f, -0.01353145f, -0.02151701f, 
    0.03083646f, -0.00132623f, -0.02059319f, -0.01101949f, -0.00593409f, 0.01064080f, -0.01535415f, -0.02826805f, 
    0.01080861f, 0.02433406f, 0.01320591f, -0.03154641f, 0.00676027f, 0.02255123f, 0.00958865f, -0.00696659f, 
    -0.04121437f, 0.03240329f, -0.03750070f, -0.01631621f, 0.02988364f, 0.03203037f, -0.02668707f, 0.02076878f, 
    0.02655658f, -0.00476669f, -0.02444952f, -0.01761983f, -0.02037207f, -0.01239488f, -0.01322991f, -0.00574832f, 
    -0.03031428f, -0.00530418f, -0.00894776f, 0.00525822f, 0.01533193f, -0.00262388f, 0.00926053f, 0.01195645f, 
    -0.01729353f, -0.03587227f, 0.02188783f, -0.02819458f, 0.00883665f, -0.02463238f, -0.00776187f, 0.02883098f, 
    -0.02812857f, 0.01078794f, 0.00165985f, 0.02233938f, 0.02983306f, -0.01595829f, -0.01642418f, 0.02297574f, 
    -0.03177859f, -0.01950293f, -0.00815690f, 0.02989965f, -0.02106967f, -0.00878425f, 0.01603202f, 0.02618275f, 
    0.02835557f, 0.01969207f, 0.01653835f, -0.01425276f, -0.02372261f, 0.03022899f, -0.02106070f, -0.03054177f, 
    -0.02280798f, 0.02617876f, -0.00202079f, -0.02998110f, -0.01771554f, -0.02067577f, -0.04075646f, 0.02069297f, 
    0.00993605f, 0.02324756f, -0.02139512f, -0.00972011f, -0.01006462f, 0.01960244f, 0.02732284f, -0.00196406f, 
    0.03178585f, 0.00250993f, 0.00024432f, -0.02152657f, 0.02600501f, 0.02814792f, -0.02457917f, -0.03374724f, 
    -0.01656387f, 0.02685995f, 0.00077278f, -0.01970654f, -0.02327961f, 0.01254917f, 0.01405824f, 0.03646242f, 
    -0.01766376f, -0.02735371f, 0.01685980f, 0.02407325f, -0.04009284f, 0.00627726f, -0.01152669f, 0.02418044f, 
    -0.01840241f, 0.01966250f, -0.00883921f, 0.01777208f, -0.02800986f, 0.02249373f, -0.01355542f, -0.02086969f, 
    0.01785840f, -0.00987009f, -0.02351836f, -0.01554831f, -0.00454547f, -0.03384547f, 0.02541622f, 0.02771846f, 
    -0.01334801f, 0.03568533f, 0.03792369f, 0.01369024f, -0.03270528f, -0.02403637f, -0.00156707f, -0.03107104f, 
    -0.01618025f, 0.03836077f, -0.00799563f, -0.03435535f, -0.02807619f, -0.02564746f, 0.00935182f, -0.03699596f, 
    -0.00684491f, -0.01049251f, 0.02093135f, -0.00342490f, -0.01446612f, 0.02893215f, 0.00440526f, 0.01263304f, 
    0.03649851f, 0.00758919f, 0.01576206f, -0.03258815f, -0.02401930f, -0.02100633f, -0.01760361f, 0.00948025f, 
    -0.01641360f, 0.01788636f, -0.00717056f, 0.02164751f, -0.03420488f, 0.01938293f, -0.01418607f, 0.02245871f, 
    0.01264816f, 0.02197218f, -0.01961338f, -0.01950862f, -0.01219994f, -0.00793145f, 0.00703063f, -0.03518042f, 
    0.02014239f, -0.02296537f, -0.02294207f, 0.02965329f, -0.03491233f, -0.02595787f, -0.02051734f, -0.02178130f, 
    0.00112543f, -0.00264027f, 0.01932425f, -0.03717282f, -0.00019094f, 0.02124695f, -0.01385256f, -0.00390890f, 
    -0.02864888f, -0.00196449f, 0.02780601f, -0.02484059f, -0.02846198f, -0.00599158f, -0.02049913f, -0.03264567f, 
    0.02851449f, 0.01346988f, -0.02284479f, 0.00764081f, 0.00693249f, 0.03072887f, 0.01609478f, 0.00015822f, 
    0.02471541f, -0.01505923f, 0.02368548f, 0.00585150f, 0.00856876f, -0.02186013f, -0.03228872f, -0.01926376f, 
    0.01719741f, -0.03875977f, -0.03335016f, 0.00076073f, -0.00624038f, 0.01685649f, 0.01023120f, 0.01950340f, 
    0.01354848f, -0.03906814f, -0.02947604f, -0.01993608f, -0.00853191f, -0.02570190f, 0.00663834f, -0.02211581f, 
    -0.01692360f, 0.01132610f, -0.03596004f, -0.02231111f, -0.02020163f, 0.02996233f, -0.03891979f, -0.03642530f, 
    -0.00532184f, -0.02499011f, -0.00886947f, -0.01493668f, 0.00417560f, 0.00308816f, 0.00661675f, 0.03263888f, 
    -0.03138873f, -0.02379945f, 0.01051860f, -0.01396046f, 0.00703195f, 0.02896127f, -0.01977241f, 0.01948856f, 
    -0.02986768f, 0.02851968f, -0.01659240f, -0.02531528f, 0.02454742f, -0.01838373f, -0.03143908f, -0.02934136f, 
    -0.02401824f, -0.03638803f, 0.00732213f, -0.03660332f, 0.00192239f, -0.02174285f, 0.02942913f, -0.00833381f, 
    0.01434565f, -0.00309992f, 0.01058606f, -0.00891539f, -0.01804404f, 0.01300179f, 0.02284403f, -0.00572532f, 
    0.00326024f, -0.01085595f, 0.03789968f, -0.01519175f, 0.01240234f, -0.01255356f, -0.03542154f, -0.01680017f, 
    0.02845692f, 0.03116343f, -0.03326660f, -0.03683024f, -0.01562665f, 0.01853464f, -0.01640520f, -0.03365981f, 
    -0.02021090f, 0.01670470f, 0.01300029f, 0.00271653f, -0.02355063f, 0.00720857f, 0.01123680f, 0.01162726f, 
    0.01959180f, -0.02983739f, -0.00653813f, -0.02214751f, 0.02724456f, -0.01543356f, -0.02322054f, 0.00400336f, 
    0.00035569f, -0.03630534f, 0.02543576f, -0.01592586f, 0.01906745f, -0.03185901f, -0.03249525f, 0.01694352f, 
    0.02875628f, 0.01995453f, 0.03207134f, 0.00806802f, 0.01493342f, -0.00558163f, 0.02343015f, -0.03811218f, 
    -0.02352099f, 0.00532238f, -0.02776259f, 0.02490751f, -0.01636844f, -0.00225036f, -0.03236436f, -0.02583594f, 
    0.03035250f, -0.03677008f, -0.02086693f, 0.03010227f, 0.03269025f, -0.01856415f, -0.00859388f, 0.03524902f, 
    0.03170562f, -0.03069748f, 0.03351596f, 0.00596529f, -0.00671451f, -0.02058564f, -0.00167064f, -0.01241466f, 
    -0.02599523f, -0.03200498f, 0.00312464f, -0.02476613f, -0.01237401f, 0.00930667f, 0.02401629f, -0.01765800f, 
    0.01333553f, 0.00682022f, -0.02790165f, -0.00879969f, 0.00210283f, -0.00582562f, 0.02733850f, -0.03026547f, 
    0.02172508f, -0.01119180f, 0.01958469f, -0.00385899f, -0.01941204f, -0.00449933f, 0.01041503f, -0.01320399f, 
    -0.02873534f, 0.00971245f, 0.01576254f, -0.00295072f, -0.01506276f, -0.02533561f, 0.00478320f, 0.03164585f, 
    -0.03592443f, -0.02398688f, -0.01015952f, 0.02234762f, -0.01509889f, -0.00634048f, 0.03561812f, -0.01832401f, 
    0.01531285f, -0.02533813f, 0.03134918f, -0.03263610f, -0.01195095f, 0.03201263f, -0.02027443f, -0.03826435f, 
    0.02854036f, 0.01493084f, -0.01624908f, -0.00569544f, 0.01771226f, -0.01531944f, -0.00610366f, 0.02813189f, 
    -0.01948561f, -0.03974035f, -0.00414615f, 0.01268373f, -0.02693947f, 0.02833753f, 0.01492597f, 0.01847259f, 
    0.03194156f, -0.01451255f, -0.00510503f, 0.01783875f, 0.00851811f, -0.01006895f, -0.00410100f, 0.03475047f, 
    0.02162939f, -0.03221914f, -0.01695739f, 0.02674228f, -0.03575114f, -0.00185494f, 0.00538279f, -0.00874254f, 
    -0.02299451f, -0.03498419f, -0.02388899f, 0.02513196f, 0.01829590f, 0.01355249f, -0.02424262f, -0.03331118f, 
    -0.03534729f, -0.02044801f, -0.02154496f, -0.01105705f, 0.00582241f, -0.02070873f, 0.01664219f, 0.01940111f, 
    0.01144669f, 0.00990857f, -0.01124683f, 0.00123714f, -0.02127214f, -0.02686733f, 0.02626532f, 0.00248806f, 
    -0.02079147f, 0.01903883f, 0.02111908f, -0.01870961f, 0.00807048f, -0.03418647f, -0.01506325f, -0.02396298f, 
    0.01330000f, -0.00796446f, 0.03125307f, 0.00141235f, 0.00224632f, -0.01284545f, -0.00377350f, 0.01665056f, 
    0.01135563f, 0.01844548f, 0.01723957f, -0.00323033f, 0.01908026f, -0.02042941f, 0.03339767f, 0.02664563f, 
    -0.00276113f, -0.00950066f, -0.02061968f, 0.01275029f, 0.02331951f, -0.02264782f, 0.02051588f, 0.02453802f, 
    -0.02540389f, -0.03953970f, 0.02854023f, 0.03262288f, -0.01332547f, -0.01216345f, 0.01254328f, -0.03112878f, 
    -0.01530373f, -0.03153361f, -0.02193932f, -0.00547154f, -0.00164081f, 0.02762729f, -0.02585937f, -0.01164771f, 
    -0.01444178f, -0.02491246f, -0.03819832f, -0.01859821f, 0.02171140f, -0.01566417f, -0.03285282f, -0.00378941f, 
    -0.01334684f, -0.01017905f, -0.01288666f, 0.02223524f, 0.02184394f, 0.00162555f, -0.03103515f, 0.02180310f, 
    -0.01124527f, 0.02909928f, 0.01236653f, -0.00399079f, -0.02117586f, 0.02708391f, -0.00285561f, -0.02024214f, 
    0.02779539f, -0.02175008f, 0.01680100f, -0.02642577f, -0.03294913f, 0.00271106f, 0.02833636f, 0.00231186f, 
    -0.00335537f, -0.01965974f, -0.02410100f, -0.01365953f, 0.00021530f, 0.01544068f, -0.00430898f, -0.02715267f, 
    -0.01344247f, -0.02104954f, 0.00743564f, -0.02646368f, 0.03052665f, 0.02699826f, -0.00510477f, -0.03789579f, 
    -0.04031463f, 0.02694734f, -0.01633466f, -0.02873456f, 0.03396054f, -0.01158026f, -0.02019145f, -0.01813996f, 
    0.00303423f, 0.01255061f, 0.02420436f, -0.02667588f, -0.00859784f, -0.02552290f, -0.02148307f, 0.02375396f, 
    0.00193887f, -0.03598801f, -0.02615760f, -0.03741055f, -0.02410554f, 0.03001570f, -0.03583259f, -0.00358580f, 
    0.01135529f, 0.01865236f, 0.01812260f, -0.01080227f, 0.03601822f, -0.00514901f, -0.00239361f, -0.01913180f, 
    -0.01749537f, 0.00886341f, -0.02092261f, 0.01480120f, 0.00058113f, -0.03655417f, 0.00472640f, 0.01751920f, 
    -0.30565593f, -0.00181611f, -0.07013924f, 0.14913827f, 0.01426288f, -0.05605226f, -0.07570483f, -0.09505108f, 
    0.08872467f, -0.04571248f, 0.01291037f, 0.06498540f, -0.34946200f, 0.12273785f, -0.02609789f, 0.00174552f, 
    0.00439620f, -0.00831011f, 0.02802059f, 0.00051937f, 0.09340848f, 0.06593637f, 0.01439771f, 0.06261016f, 
    0.27531677f, -0.11660100f, -0.06082436f, -0.03629502f, -0.00182297f, -0.03156627f, 0.09426457f, 0.05091595f, 
    0.08219504f, 0.08485043f, 0.05091129f, -0.02394361f, -0.11938653f, 0.11253724f, -0.04848173f, -0.02084449f, 
    0.03509804f, 0.05863011f, 0.03855540f, -0.04879214f, -0.05877628f, 0.01695518f, 0.04421207f, 0.08037021f, 
    -0.05001201f, 0.11413933f, -0.10544743f, 0.05648674f, 0.03404741f, -0.05342773f, 0.02550839f, 0.04427649f, 
    0.11052744f, 0.00344061f, -0.08165736f, -0.10064988f, -0.05100130f, 0.10470247f, 0.07219750f, -0.01477153f, 
    0.03312015f, 0.02128828f, 0.12294487f, 0.08275229f, 0.06400448f, 0.06417574f, -0.04802503f, 0.02961242f, 
    0.02693608f, -0.29145825f, -0.05242284f, 0.00076533f, 0.01713130f, 0.08456604f, 0.02671957f, -0.00690742f, 
    0.06907246f, -0.01168285f, -0.00990043f, -0.10759255f, -0.07681566f, 0.14443064f, -0.07275649f, -0.10742620f, 
    0.07585955f, 0.07867767f, 0.07106063f, 0.07346472f, -0.01127970f, 0.06462465f, -0.01955066f, 0.08639127f, 
    0.05578747f, -0.05060918f, -0.17169937f, 0.00811839f, 0.06408674f, -0.10594594f, 0.10570122f, 0.01468589f, 
    -0.05334582f, 0.01998631f, 0.03751769f, 0.08701598f, -0.18297239f, -0.06506079f, -0.10161664f, -0.08473922f, 
    0.12007736f, 0.10944504f, 0.00815839f, 0.05556757f, -0.01258722f, 0.12780221f, -0.02745066f, 0.05496930f, 
    0.11037200f, 0.04161019f, 0.13278119f, -0.03020317f, -0.07138241f, 0.04627894f, 0.09441181f, 0.09417724f, 
    0.11396922f, 0.01898995f, -0.06031393f, 0.04421462f, -0.00872031f, -0.03638916f, 0.18440875f, 0.08814944f, 
    -0.04307831f, 0.05748382f, -0.04618554f, -0.05771853f, 0.05265180f, -0.02259449f, 0.01199372f, 0.02143947f, 
    0.11532432f, 0.05248444f, -0.05489317f, 0.03013528f, 0.01596493f, 0.07693179f, 0.01688877f, 0.06251832f, 
    -0.02606517f, 0.00581576f, -0.03311884f, -0.01775312f, 0.09097663f, 0.19286913f, -0.12144026f, 0.05243711f, 
    0.07263757f, -0.03641670f, 0.04943961f, 0.09074744f, -0.05273146f, -0.04109114f, 0.06862375f, 0.07205962f, 
    -0.20103438f, -0.06842446f, 0.01023990f, 0.03280960f, 0.05446021f, -0.02202101f, -0.09379034f, -0.00842441f, 
    0.08699616f, -0.08737136f, 0.00164600f, 0.09818448f, 0.12626195f, 0.07018826f, -0.10693112f, 0.04185111f, 
    -0.05294942f, -0.02079166f, 0.04288245f, 0.08224674f, -0.03040350f, -0.05651097f, -0.12700403f, 0.10586399f, 
    0.02750132f, -0.20467749f, -0.14044461f, 0.05873252f, 0.01529935f, -0.07830368f, 0.06698761f, 0.14979912f, 
    0.06797936f, -0.00679467f, 0.01663218f, 0.04322823f, 0.14680710f, -0.00402056f, 0.11630917f, 0.17247207f, 
    0.06008720f, -0.08118496f, 0.07975137f, 0.01206483f, 0.05659339f, 0.05635268f, 0.01029484f, 0.01385150f, 
    0.10798755f, -0.03451320f, -0.03522749f, -0.10091066f, 0.00789240f, -0.00793822f, 0.02443819f, 0.05324861f, 
    -0.04024176f, -0.02486785f, 0.02657926f, 0.04462251f, 0.03704708f, 0.14377312f, -0.08843369f, -0.08775936f, 
    0.03420488f, -0.01307295f, -0.03283152f, 0.04049908f, -0.00237374f, 0.12529486f, -0.12393645f, -0.05826991f, 
    -0.06082752f, 0.04978771f, 0.10927363f, 0.07022354f, -0.03231540f, -0.05569921f, 0.01857918f, 0.01509708f, 
    0.02441138f, 0.01585354f, 0.05847865f, 0.12438437f, -0.38030872f, 0.21071465f, -0.07558506f, -0.10074539f, 
    -0.00355795f, -0.07949957f, 0.00370911f, 0.00729223f, 0.01377649f, 0.12241624f, -0.10025604f, -0.09968405f, 
    0.02131092f, -0.13242571f, 0.02883566f, 0.00866718f, -0.11011481f, -0.13084055f, 0.06596401f, 0.03231322f, 
    0.19279999f, 0.10795446f, 0.04177973f, 0.15435055f, -0.09943815f, -0.05550088f, 0.02287630f, 0.01498390f, 
    0.00707546f, -0.02846057f, 0.02902184f, 0.03647892f, -0.00469669f, 0.09847556f, -0.09274466f, 0.15350674f, 
    -0.02819854f, -0.14018527f, 0.13171864f, -0.19322555f, -0.00659108f, 0.04925928f, -0.05649511f, -0.02042859f, 
    0.07562741f, 0.03674838f, -0.05353928f, -0.06754905f, -0.07143812f, -0.14616050f, -0.01230802f, -0.13076371f, 
    -0.06595256f, -0.13020602f, -0.05412469f, -0.01558064f, 0.08541340f, 0.10980505f, -0.04871033f, 0.09028346f, 
    0.09834034f, -0.09131677f, 0.10055996f, -0.11844495f, 0.07885451f, 0.13337266f, -0.04836053f, -0.04128453f, 
    0.06107555f, 0.05751360f, 0.01938635f, -0.06595429f, -0.05015646f, -0.22224766f, 0.03867809f, -0.07128825f, 
    -0.02982965f, -0.11521574f, -0.09515898f, 0.04853353f, 0.02559548f, -0.01251473f, -0.03956413f, 0.09593344f, 
    -0.00604217f, 0.00331151f, 0.13003948f, 0.10123326f, 0.02785734f, -0.03103062f, 0.03180517f, 0.05047970f, 
    0.11696786f, 0.10535786f, -0.02162571f, 0.10232685f, 0.03546421f, -0.04977503f, 0.15366381f, 0.16342451f, 
    0.03785385f, 0.08223145f, -0.10700178f, -0.06436865f, 0.01855266f, 0.02979949f, 0.00072880f, 0.10453478f, 
    0.17006503f, -0.13161075f, 0.07093989f, 0.06385975f, 0.04076862f, 0.08467453f, -0.05348174f, 0.00067619f, 
    0.00574364f, 0.04007546f, -0.00218399f, -0.01112502f, 0.16795236f, -0.04701767f, -0.03452153f, -0.08811192f, 
    -0.12617446f, 0.02933997f, 0.01578096f, 0.03669825f, 0.05765701f, 0.04444937f, 0.05579918f, 0.07517385f, 
    -0.00645818f, -0.14515139f, 0.08213569f, 0.00046700f, 0.02430291f, -0.17315520f, -0.02419229f, -0.03700706f, 
    0.03587056f, -0.07931297f, 0.02202043f, 0.13225599f, 0.12451780f, -0.02735387f, 0.06743836f, -0.17803873f, 
    -0.03993956f, 0.01111075f, -0.00290763f, 0.02588394f, 0.00827216f, 0.03769710f, -0.00663722f, 0.00968870f, 
    -0.04053095f, -0.08658394f, 0.01606017f, 0.08984076f, -0.03051025f, 0.08520655f, 0.03766287f, -0.08234702f, 
    0.01136162f, 0.07736136f, -0.09510878f, -0.02898570f, 0.04442657f, -0.13548526f, -0.02398514f, 0.13645937f, 
    -0.08881131f, -0.07139861f, 0.03199745f, 0.04017015f, 0.02597009f, -0.04224297f, 0.01146356f, -0.10634784f, 
    0.17681623f, 0.13317816f, 0.07007604f, 0.02312393f, 0.11289091f, -0.07850798f, 0.08989064f, 0.07794444f, 
    0.00945096f, 0.14668757f, -0.03399915f, 0.09254656f, 0.28709984f, 0.06879194f, 0.07970610f, 0.02448194f, 
    0.10578785f, -0.00682384f, 0.19657348f, 0.11104065f, -0.02776101f, 0.10351510f, 0.08974864f, -0.01067534f, 
    -0.18721712f, -0.01785349f, -0.02926957f, -0.05675811f, -0.09584789f, -0.00767794f, 0.00591405f, 0.02911991f, 
    0.02664786f, 0.00197460f, 0.10648761f, 0.00223238f, -0.22223306f, 0.10735677f, -0.07840556f, -0.24552317f, 
    0.09582927f, 0.02439285f, -0.03696539f, 0.08182262f, -0.01687535f, -0.00956591f, 0.03230999f, 0.07592715f, 
    -0.35189602f, 0.21634705f, -0.12239302f, -0.02602629f, -0.11649470f, 0.04172669f, -0.01842386f, 0.03213151f, 
    -0.01222609f, 0.05183112f, 0.07160223f, -0.03019686f, 0.07704520f, 0.01351307f, 0.04872801f, -0.01598562f, 
    0.00144640f, -0.05673026f, -0.04045958f, 0.06702751f, 0.11388680f, 0.16537946f, 0.04967192f, 0.03790451f, 
    -0.02988937f, -0.20814668f, -0.11949389f, -0.09175370f, 0.00079371f, 0.00816399f, -0.04564295f, 0.11888998f, 
    0.06046956f, -0.11258423f, 0.00654535f, -0.12332493f, -0.21946584f, -0.14724053f, 0.09091440f, -0.04680715f, 
    0.04568028f, -0.06645185f, -0.05381066f, 0.01423466f, 0.04183968f, 0.04526244f, 0.03686608f, 0.07536191f, 
    0.05561690f, -0.01824738f, 0.07389342f, 0.04357049f, 0.00824291f, -0.09561337f, -0.00148799f, 0.12228616f, 
    -0.01240820f, -0.03617615f, 0.00638520f, 0.00164273f, -0.25319141f, -0.06972227f, -0.13870455f, 0.14265369f, 
    0.03513653f, 0.04185672f, -0.07025944f, -0.02664652f, 0.04366874f, -0.06600302f, 0.01805996f, -0.06038935f, 
    -0.00037527f, -0.08655705f, 0.18032941f, 0.29918545f, 0.00175358f, 0.11795928f, 0.04163477f, 0.09667405f, 
    0.07252322f, -0.07287187f, -0.03891997f, 0.14398843f, 0.06518549f, -0.17912883f, -0.10975818f, 0.03948624f, 
    0.03501686f, 0.02618375f, 0.00514531f, -0.04580926f, 0.03163313f, 0.02511417f, -0.06221130f, -0.03737107f, 
    0.21232729f, -0.16089518f, -0.17181674f, -0.02998566f, 0.02290362f, -0.11996012f, 0.11971726f, -0.10967591f, 
    0.01370721f, 0.04217750f, -0.00775263f, 0.04456577f, 0.06669395f, -0.17568585f, -0.02799239f, -0.00350112f, 
    -0.08046280f, 0.01621199f, -0.03665795f, 0.00090938f, 0.06185732f, -0.03717776f, -0.09899385f, -0.05570297f, 
    0.25590876f, 0.03481612f, -0.02171529f, -0.03976120f, 0.07188780f, -0.02047967f, -0.05104706f, 0.09657066f, 
    0.01231381f, -0.05359078f, 0.13858010f, 0.15074308f, 0.07131956f, 0.03099340f, 0.14305176f, -0.12529607f, 
    0.06534663f, -0.01369892f, 0.05174587f, -0.12613977f, 0.00833553f, -0.04432273f, 0.00818436f, 0.06324255f, 
    0.00551920f, -0.18929127f, 0.01845656f, -0.05672529f, 0.05229343f, 0.03811504f, 0.06127319f, -0.09199320f, 
    0.03628151f, 0.12167832f, -0.02806456f, 0.05494878f, -0.23459293f, -0.00121456f, -0.01176957f, -0.02834182f, 
    -0.02556823f, -0.00988472f, 0.03016260f, -0.09890888f, 0.03081913f, 0.11726071f, 0.00588989f, 0.04222110f, 
    -0.14846960f, -0.04253255f, 0.13824321f, 0.06045292f, -0.00439007f, 0.00048551f, -0.01510503f, -0.09007293f, 
    0.01368383f, 0.17174055f, 0.06501399f, -0.06268078f, 0.05503977f, 0.09576879f, -0.09997641f, -0.05057475f, 
    0.09540022f, -0.02450703f, 0.05614384f, 0.08628608f, 0.03710504f, -0.07180391f, 0.05993204f, -0.11942014f, 
    0.23131119f, -0.13593958f, 0.13383266f, -0.06786889f, -0.06096879f, -0.01751579f, 0.01976725f, -0.01245835f, 
    -0.09096767f, 0.03577518f, 0.03432620f, 0.08384422f, -0.08014111f, 0.06717114f, -0.02155124f, 0.03696127f, 
    0.06631014f, 0.03237229f, -0.04049810f, -0.04402734f, 0.02714997f, 0.05449995f, 0.03448442f, -0.04385125f, 
    -0.01202461f, -0.07245748f, 0.05568378f, -0.15558691f, 0.03666736f, 0.08026308f, 0.01876296f, 0.04088199f, 
    0.02371703f, 0.05266112f, -0.02933245f, 0.01514395f, 0.22775272f, 0.13051201f, 0.10603240f, -0.12071358f, 
    -0.05874882f, -0.02370797f, 0.10051388f, 0.06104783f, -0.01630384f, -0.03007331f, -0.01399167f, 0.01820904f, 
    -0.06134917f, -0.01909257f, 0.12342245f, -0.06022022f, 0.05170267f, -0.00070351f, 0.03803913f, 0.00236072f, 
    0.03523989f, -0.01866245f, -0.05463916f, 0.12195887f, -0.08547106f, -0.01226277f, -0.04434429f, 0.14763503f, 
    0.08767869f, -0.01860925f, -0.04367040f, 0.02940299f, -0.00521007f, 0.08909442f, -0.03553224f, 0.01044067f, 
    0.21991627f, 0.01116831f, -0.14689861f, -0.06029808f, 0.04756037f, 0.06432923f, 0.03590406f, 0.12011572f, 
    0.04155828f, -0.05389194f, -0.00776992f, -0.07501597f, 0.10333899f, 0.12651737f, -0.08558238f, -0.10256308f, 
    0.06155155f, 0.05169268f, 0.09063942f, -0.09784663f, -0.03641145f, 0.01441751f, 0.03027273f, 0.07668937f, 
    0.01125782f, -0.00298648f, -0.02196770f, -0.01667747f, -0.01566198f, 0.02987491f, -0.01201397f, -0.02600768f, 
    -0.01852600f, -0.02388918f, -0.02128472f, 0.00024472f, 0.03240995f, 0.00419855f, 0.00345638f, 0.00683257f, 
    -0.01338406f, -0.01725329f, 0.00185357f, -0.00491948f, -0.03734869f, -0.01452549f, -0.02781862f, -0.04057360f, 
    0.00607044f, 0.00530975f, 0.01162395f, -0.01945035f, -0.03407083f, 0.01034281f, 0.03085023f, 0.01590909f, 
    0.01659384f, -0.02358627f, -0.02248829f, -0.03706594f, -0.03339084f, 0.00839736f, -0.02251733f, -0.00045919f, 
    0.00549085f, -0.00775614f, -0.03678238f, -0.02546302f, -0.00468786f, -0.01012338f, -0.03542835f, 0.02587739f, 
    -0.00394322f, -0.03447353f, -0.00237098f, -0.01924645f, -0.01018760f, -0.02276461f, -0.01848480f, -0.00421418f, 
    -0.00884764f, 0.01879062f, 0.00974187f, -0.00065592f, -0.00616499f, 0.01958075f, -0.02526969f, 0.01140694f, 
    -0.00755324f, -0.00341808f, 0.01030941f, -0.02340234f, -0.02561270f, 0.01327631f, 0.02472197f, -0.03509587f, 
    -0.04051765f, -0.00122769f, 0.00369298f, -0.02586178f, 0.01912437f, 0.02267321f, -0.01885599f, 0.01069566f, 
    -0.01931895f, -0.03143091f, -0.03331183f, -0.03188583f, 0.02758936f, -0.04453946f, -0.03063454f, 0.02545227f, 
    -0.00763544f, -0.01462114f, -0.01488443f, 0.01624262f, -0.00035294f, -0.01314078f, -0.00334711f, 0.02276076f, 
    -0.01303474f, 0.02336983f, -0.00118768f, -0.01136469f, 0.01124307f, 0.02267732f, -0.00638497f, 0.02401366f, 
    0.02229555f, -0.03785056f, 0.00483108f, -0.02568504f, 0.01814823f, 0.01841038f, -0.02525750f, 0.00234393f, 
    -0.02947694f, -0.02688602f, -0.03443246f, -0.00042397f, -0.02942593f, -0.02443003f, -0.03429532f, -0.01524237f, 
    0.02227839f, -0.03224047f, 0.02090124f, 0.02507537f, -0.02272288f, 0.02642975f, 0.00591556f, 0.02804522f, 
    -0.02339307f, -0.01387502f, -0.02635945f, 0.02079426f, 0.02463432f, -0.03903529f, -0.01800201f, -0.01455286f, 
    0.02415882f, -0.01504924f, -0.00616330f, -0.03107602f, -0.02931918f, 0.01024237f, -0.02709691f, 0.00886599f, 
    -0.02044966f, 0.00173894f, -0.02649031f, 0.02024855f, -0.00056169f, 0.00932531f, 0.01940406f, -0.03943271f, 
    0.00026763f, -0.02101094f, -0.02101793f, -0.00664261f, 0.00273655f, -0.01524118f, 0.02598843f, -0.00150590f, 
    -0.03786434f, -0.00688371f, 0.01018337f, 0.01910630f, 0.00605696f, 0.00262787f, -0.03119390f, 0.02040765f, 
    -0.01576516f, 0.01961052f, 0.01655025f, 0.01023843f, -0.04039304f, 0.01558636f, -0.03332112f, 0.00910999f, 
    -0.02365177f, -0.01178636f, 0.02262431f, -0.03335642f, -0.02320682f, -0.01171708f, -0.02781122f, 0.01563869f, 
    0.00155326f, -0.01282790f, 0.00831878f, -0.01522602f, -0.01542745f, -0.02818169f, 0.01063801f, 0.01933756f, 
    0.00460322f, 0.02881995f, -0.02554129f, -0.04055488f, -0.03043888f, 0.01704030f, -0.04181743f, 0.03131947f, 
    0.00801503f, 0.01467314f, -0.04083728f, 0.02427765f, -0.00219916f, -0.03609853f, -0.00958343f, 0.02677617f, 
    -0.00307894f, -0.01911836f, -0.03367915f, 0.01469694f, -0.02596083f, -0.02392964f, -0.03883694f, -0.02168957f, 
    -0.01593309f, 0.02563390f, 0.00277356f, -0.01819761f, 0.00070957f, 0.02524300f, -0.01559628f, -0.00099944f, 
    -0.02899724f, -0.02748017f, -0.00347338f, -0.01005099f, 0.00579145f, -0.00062114f, -0.04029796f, 0.00434376f, 
    0.02400924f, -0.03771136f, 0.01323016f, -0.00058321f, -0.00611937f, -0.01950111f, 0.00480933f, -0.02730433f, 
    -0.01918649f, -0.00247170f, 0.02384672f, 0.00632157f, -0.01010722f, -0.02380883f, -0.01113900f, 0.01668931f, 
    -0.01726230f, 0.01374228f, -0.02722878f, -0.03308795f, 0.01768410f, -0.03097016f, 0.00396263f, 0.01882441f, 
    0.01244868f, 0.00721566f, -0.01214908f, -0.03094264f, -0.01867118f, 0.00048527f, -0.02672068f, 0.01228251f, 
    0.01832059f, 0.00294977f, -0.04409083f, -0.01392074f, -0.01687365f, 0.03548092f, 0.00167964f, -0.03232650f, 
    -0.03489227f, 0.02821049f, 0.00881345f, -0.04318175f, 0.02138445f, -0.01186826f, 0.01134496f, 0.00655312f, 
    -0.03627235f, -0.00574276f, -0.00226321f, -0.02664362f, -0.03793937f, 0.00570144f, 0.02316686f, -0.00988627f, 
    -0.03580540f, 0.00882133f, 0.00642585f, -0.03597540f, -0.01572625f, -0.01449147f, -0.03461545f, 0.01563527f, 
    0.02642799f, -0.00998870f, 0.02154282f, 0.02360922f, -0.04165719f, 0.02828754f, -0.01448218f, -0.00129528f, 
    0.01301313f, 0.00211015f, -0.01898768f, 0.01822132f, -0.00033410f, 0.00567156f, -0.02181667f, 0.00781479f, 
    -0.00763856f, 0.01207441f, -0.01816034f, -0.02378689f, -0.01604168f, 0.00320592f, 0.02902110f, 0.01704679f, 
    0.00229268f, 0.00492515f, -0.03793414f, 0.02249781f, -0.02772859f, -0.03188183f, -0.00415142f, -0.00283647f, 
    -0.02240464f, -0.03892051f, -0.02941802f, 0.01561957f, 0.02227485f, 0.02191463f, -0.03532416f, -0.03280352f, 
    -0.01815486f, -0.01361907f, 0.01928516f, -0.01048852f, -0.01093851f, 0.00601531f, 0.02822261f, 0.01454152f, 
    -0.02841850f, -0.02967827f, -0.01641101f, 0.00823358f, 0.02535201f, -0.01448358f, -0.00238430f, 0.00693413f, 
    0.02113695f, -0.03284143f, -0.02402415f, 0.00619892f, 0.00362439f, 0.02865749f, -0.04290957f, -0.02603615f, 
    -0.03822558f, 0.01349914f, 0.00898916f, 0.00008414f, -0.02065353f, 0.00925163f, 0.02527303f, 0.02086360f, 
    -0.02214258f, 0.01622292f, -0.00672365f, -0.03451809f, -0.01065501f, -0.04172547f, 0.01730879f, 0.03580404f, 
    0.02767883f, 0.00026365f, -0.03628729f, -0.03150712f, 0.01491091f, -0.01161952f, 0.02886169f, 0.00961386f, 
    0.00419312f, 0.01703846f, 0.01745854f, 0.00992051f, -0.01576301f, -0.02908187f, 0.00803428f, -0.01346319f, 
    -0.01576439f, -0.00636675f, -0.00669105f, 0.00027293f, 0.02377487f, 0.02728761f, -0.03517394f, -0.04029347f, 
    0.00170739f, -0.03629249f, 0.01701650f, -0.01075909f, -0.01709833f, -0.01655745f, -0.01153837f, 0.02297644f, 
    -0.01968605f, 0.01308097f, 0.01513366f, 0.01332221f, -0.00167899f, -0.03606870f, 0.00422997f, 0.01123853f, 
    0.00115717f, 0.02853422f, 0.01284387f, 0.00703270f, 0.00218170f, 0.02402585f, -0.00452730f, -0.03338789f, 
    -0.03635103f, 0.02547184f, -0.03435927f, -0.01963386f, 0.01127778f, -0.00312673f, 0.01624005f, -0.03348719f, 
    -0.01368152f, 0.01871525f, -0.02056521f, 0.01439871f, 0.00129344f, 0.02823956f, -0.01511982f, -0.02344484f, 
    0.02832972f, -0.02572953f, 0.01990650f, -0.00440750f, -0.02273680f, -0.01840605f, 0.01273309f, -0.00177976f, 
    -0.00862126f, -0.01492015f, -0.01711592f, 0.01271314f, -0.00403318f, -0.03920437f, -0.01732405f, -0.02393384f, 
    0.00709021f, -0.01590280f, 0.00267645f, -0.01354220f, 0.01149012f, 0.02332878f, -0.00040291f, 0.00509532f, 
    -0.02383009f, -0.01869742f, 0.02998257f, 0.01650745f, -0.03213409f, 0.02750793f, 0.01495898f, -0.02510192f, 
    -0.01839602f, 0.00581921f, -0.00311566f, -0.00810087f, 0.00346887f, -0.02722188f, -0.01882810f, -0.02207037f, 
    -0.02228266f, -0.00833947f, -0.01787566f, -0.02079391f, -0.04214809f, 0.00239834f, 0.00254588f, 0.02789939f, 
    0.00743991f, -0.02301180f, -0.02638471f, -0.02083749f, 0.02996910f, -0.01576108f, 0.02473305f, -0.04011203f, 
    0.02394105f, 0.00575702f, 0.03012841f, -0.04203027f, -0.04340906f, 0.00329759f, -0.01089758f, -0.03800931f, 
    -0.03412781f, -0.01318332f, -0.00110780f, -0.01658666f, -0.02903661f, 0.01093507f, -0.01180238f, 0.00856139f, 
    -0.01198529f, 0.02058670f, -0.02418938f, 0.02460662f, 0.01101675f, -0.02610534f, -0.04064088f, 0.01314745f, 
    0.00389375f, -0.00709468f, -0.02074115f, -0.00556733f, 0.02479187f, 0.02267451f, -0.01382796f, 0.01122330f, 
    -0.00960931f, -0.04073422f, 0.00792539f, -0.01596913f, 0.02976000f, 0.00275145f, -0.00641243f, 0.00647897f, 
    -0.03301846f, 0.02556614f, 0.01073524f, -0.02056135f, 0.02859882f, -0.00384224f, -0.03436258f, 0.02560178f, 
    0.02728790f, -0.04116252f, 0.00442832f, 0.01814605f, -0.01260460f, 0.01650961f, -0.02560746f, 0.02460002f, 
    -0.01546911f, -0.03320436f, -0.00625161f, 0.02025592f, 0.02480980f, -0.03059684f, -0.00073207f, 0.03053715f, 
    0.00115664f, -0.03415415f, 0.01073720f, 0.01807792f, -0.00693565f, -0.00431594f, -0.03197810f, 0.02088611f, 
    -0.02966936f, 0.02722795f, -0.00171689f, 0.01045380f, 0.00247688f, -0.01034000f, -0.03091963f, -0.02951572f, 
    0.00504704f, 0.01891585f, -0.02628505f, -0.01136689f, 0.01596581f, -0.02589520f, -0.02604948f, -0.00390817f, 
    -0.01209658f, 0.02941861f, -0.03804512f, 0.01307284f, -0.04188397f, 0.01356314f, 0.01943624f, -0.01816770f, 
    -0.03236021f, 0.02499116f, -0.00809172f, -0.00556127f, -0.02688216f, 0.02085285f, 0.01522262f, 0.01617839f, 
    -0.03900626f, -0.03630760f, -0.03280358f, 0.02155686f, -0.00926260f, 0.02495182f, -0.03103933f, 0.01879987f, 
    -0.00290891f, 0.01066489f, -0.01635658f, 0.02401574f, -0.02911610f, -0.02682309f, 0.00038544f, -0.01621076f, 
    -0.00102294f, 0.01747696f, -0.02885525f, -0.00358815f, -0.02046533f, 0.00520078f, 0.02746108f, -0.01456207f, 
    -0.00896498f, 0.01917901f, -0.02253132f, 0.02473616f, -0.02248230f, -0.01782928f, -0.01677597f, 0.01731020f, 
    -0.00300870f, -0.02966561f, -0.01910881f, -0.00587624f, 0.01835208f, -0.01704713f, -0.02873566f, 0.01463757f, 
    -0.00413445f, 0.01798036f, -0.01579262f, 0.02540539f, -0.00027701f, 0.00335594f, -0.03002165f, -0.02570785f, 
    0.00507372f, 0.01959589f, -0.03701736f, 0.00060731f, 0.01634702f, -0.00106862f, 0.00288478f, -0.02071831f, 
    -0.03307233f, -0.02432952f, -0.03803539f, -0.01221287f, -0.01917597f, -0.00006731f, -0.01938687f, -0.02992001f, 
    -0.01034601f, 0.02079500f, -0.02174686f, -0.02063496f, 0.03453475f, -0.00359176f, -0.03444843f, -0.01385139f, 
    0.02073410f, -0.01076868f, 0.01461595f, 0.01277037f, -0.00552553f, 0.02843125f, 0.01231149f, 0.01799779f, 
    0.01064654f, 0.00096962f, 0.00744614f, -0.00381471f, 0.01714650f, -0.03851088f, 0.00770468f, 0.00326950f, 
    -0.00651786f, -0.02988678f, -0.00087977f, -0.03311254f, -0.03806129f, 0.02294781f, -0.04414590f, 0.00448295f, 
    0.00216415f, 0.00713644f, -0.02227729f, -0.02795812f, -0.03939720f, 0.00862813f, 0.02461543f, -0.02780478f, 
    0.02296807f, -0.03124014f, 0.03091704f, -0.01234873f, -0.00210636f, 0.01570269f, 0.00209722f, 0.02896633f, 
    -0.01350410f, 0.01462278f, -0.02108016f, 0.01066480f, -0.00653742f, -0.02175756f, -0.02515632f, -0.03577732f, 
    -0.00136548f, -0.01437795f, -0.02510850f, -0.04090199f, 0.02312287f, -0.02359945f, 0.01724583f, -0.01344515f, 
    0.02132174f, 0.02111368f, -0.03066532f, -0.02497726f, 0.02132450f, -0.03127789f, 0.02099851f, 0.00291994f, 
    -0.01631997f, -0.02572023f, 0.01613134f, -0.02101755f, -0.02374218f, 0.02358192f, 0.00003505f, -0.01727485f, 
    0.01892073f, -0.03659725f, 0.01643141f, -0.02135030f, -0.00834565f, 0.02224687f, -0.03155705f, 0.02715582f, 
    -0.00239580f, 0.02301294f, 0.01226242f, -0.02315750f, 0.02979930f, -0.03999675f, -0.01962881f, -0.03096644f, 
    -0.00386913f, 0.00771790f, -0.02040642f, 0.00713119f, 0.00323615f, -0.01627633f, -0.03117913f, -0.01939390f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00477978f, -0.02619111f, 0.07762521f, 0.01032670f, 0.05054702f, 0.02206845f, 0.00656630f, -0.01425024f, 
    0.04798790f, 0.02435334f, -0.03403287f, 0.01080095f, -0.03731656f, -0.01103894f, -0.01358403f, 0.04088385f, 
    0.00353258f, 0.06195684f, 0.07586775f, 0.03318493f, 0.03115862f, 0.01183876f, 0.02143599f, 0.01841345f, 
    -0.03999626f, 0.00344795f, -0.00811788f, -0.01930023f, -0.00920039f, 0.01352048f, 0.06432977f, -0.03976738f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02847322f, 0.00584213f, -0.08196659f, -0.04158469f, 0.30239689f, -0.33795142f, 0.05050381f, 0.08429077f, 
    0.01421418f, -0.16815940f, 0.11103982f, -0.15599568f, -0.01237419f, 0.37977800f, -0.27042717f, -0.11224652f, 
    0.02281522f, 0.02553271f, 0.25518778f, -0.20331208f, 0.02891710f, 0.16349733f, -0.04010513f, 0.38457251f, 
    0.15221547f, 0.03198841f, -0.01495694f, 0.31077942f, -0.09155619f, 0.14834721f, 0.24976167f, -0.08427526f, 
    0.09333099f, 0.01719022f, -0.21855108f, 0.13712086f, -0.18790592f, 0.20192504f, -0.03324446f, 0.01386045f, 
    -0.11367434f, -0.19774248f, -0.10121772f, -0.17341435f, 0.00158162f, -0.25350690f, 0.07998428f, 0.27803010f, 
    -0.03129759f, -0.18826060f, 0.12726390f, 0.06266613f, -0.17538685f, 0.13149783f, 0.14025699f, 0.17272539f, 
    -0.16473502f, 0.14089170f, 0.05482662f, -0.34113619f, -0.14702182f, 0.08200441f, -0.37612221f, 0.04582325f, 
    -0.01572421f, -0.16432962f, 0.02171887f, -0.03845881f, 0.23394242f, -0.03329574f, 0.05314804f, -0.13600639f, 
    -0.22757982f, -0.19771823f, -0.20158872f, -0.02043612f, 0.02277702f, -0.07455264f, -0.13473055f, 0.10079965f, 
    0.05695108f, -0.40038243f, 0.21912165f, 0.16398700f, -0.21326743f, 0.21562709f, -0.23546045f, 0.28844199f, 
    -0.11784889f, -0.04996964f, 0.19445950f, -0.00677754f, 0.02533959f, -0.03529869f, 0.22351994f, 0.10238424f, 
    -0.07266214f, 0.16022249f, -0.11363398f, -0.07346265f, 0.14205286f, 0.11192439f, 0.00726771f, -0.06322607f, 
    -0.18504463f, -0.06764984f, -0.07583532f, -0.16319408f, -0.17487454f, -0.12126993f, -0.09457505f, -0.10091845f, 
    0.07464696f, 0.06164460f, -0.20273410f, 0.02456823f, -0.05750063f, -0.16805153f, 0.02593451f, -0.07707667f, 
    0.15053365f, -0.17029035f, -0.07312720f, 0.14946380f, 0.06423734f, -0.08792439f, -0.05506156f, -0.05709396f, 
    -0.05566220f, 0.11511628f, -0.23987193f, 0.05073961f, -0.18033788f, -0.10193350f, 0.03116051f, 0.17580232f, 
    -0.38970906f, 0.14164896f, 0.04285600f, 0.12577613f, 0.01680473f, -0.41528967f, -0.07731351f, 0.07855011f, 
    -0.02881829f, 0.07480779f, 0.17661110f, 0.18942191f, -0.03567674f, 0.06701350f, 0.03454224f, -0.14317384f, 
    -0.06817636f, 0.11351847f, 0.22478433f, 0.25323442f, -0.04809229f, 0.17458653f, -0.07472642f, 0.14043784f, 
    -0.14883463f, 0.04507725f, 0.12475796f, 0.02522534f, -0.30368575f, 0.10339528f, -0.14375572f, -0.09130173f, 
    0.16750807f, -0.41598240f, -0.13604999f, -0.14984837f, -0.08495299f, -0.28634328f, -0.00955431f, -0.26587734f, 
    0.04068103f, -0.12630200f, 0.08852438f, 0.25614703f, 0.38926595f, 0.54823941f, 0.04055202f, 0.09957103f, 
    -0.05942422f, 0.05390380f, 0.16706231f, 0.24618767f, -0.10894193f, -0.02030357f, -0.34145671f, -0.06159165f, 
    0.16788998f, -0.17722034f, 0.31554130f, -0.14595583f, -0.20281465f, -0.29338750f, -0.14080675f, 0.14673409f, 
    0.15977670f, -0.21006933f, 0.00699247f, 0.15007083f, 0.04081789f, -0.06655569f, -0.18898983f, -0.29723030f, 
    0.05206573f, 0.04269842f, 0.17191921f, 0.11902724f, 0.35640839f, 0.00172718f, 0.05922599f, 0.06200311f, 
    -0.00958945f, -0.10301920f, 0.12523305f, 0.13883065f, -0.13440672f, -0.01479934f, -0.32282495f, 0.04088947f, 
    -0.14161325f, -0.10564440f, -0.16638313f, 0.10801656f, -0.14415084f, -0.02766517f, -0.11808002f, -0.06748302f, 
    0.03380955f, -0.01401220f, 0.11327433f, -0.08375441f, -0.00900286f, -0.15680560f, -0.13156648f, -0.07001442f, 
    0.16282210f, -0.13287117f, 0.04157890f, -0.15682888f, 0.02569390f, 0.11143976f, -0.07596428f, -0.03484484f, 
    -0.00764363f, 0.00994868f, -0.00839816f, -0.10769611f, -0.17190558f, 0.01847423f, -0.00346512f, 0.03564154f, 
    0.10264274f, 0.15243182f, -0.15379995f, 0.05279073f, -0.00180834f, -0.05895990f, -0.00091463f, 0.01781307f, 
    0.01209220f, -0.09563196f, -0.05975544f, 0.16622968f, -0.02516933f, -0.06540717f, -0.15370418f, 0.02809818f, 
    -0.03238373f, -0.06250802f, 0.04540097f, -0.09248029f, 0.01959113f, 0.05747177f, -0.04964585f, -0.12215481f, 
    0.04652062f, -0.11981510f, 0.06164568f, -0.02152971f, 0.14714348f, 0.14055489f, 0.02332602f, 0.04272153f, 
    -0.00282323f, 0.02959076f, 0.22298686f, -0.13398068f, -0.34568575f, 0.27931273f, 0.12809870f, -0.14140356f, 
    -0.02869984f, 0.21969838f, -0.16242754f, 0.10397515f, -0.15873440f, -0.22037886f, -0.25435227f, 0.26276672f, 
    -0.04032809f, -0.11958185f, 0.16265306f, 0.14166698f, -0.13993540f, -0.06425700f, 0.22585566f, -0.00433947f, 
    0.13584040f, -0.08343365f, 0.06904777f, -0.29582399f, -0.15097663f, 0.01606325f, -0.34473982f, -0.04387857f, 
    -0.04248573f, -0.16664591f, -0.08254352f, 0.14087100f, -0.05073871f, 0.22796333f, -0.03591204f, -0.16364640f, 
    0.34748593f, -0.31952459f, -0.40847117f, 0.05040833f, -0.08616423f, -0.05658974f, -0.05213631f, 0.14337869f, 
    0.09245283f, 0.06945726f, 0.01761033f, 0.14869855f, 0.20026524f, 0.11530967f, 0.29318944f, 0.29787922f, 
    -0.00598031f, -0.09415890f, -0.27730745f, -0.17768475f, -0.10136724f, 0.04889847f, -0.12703831f, -0.04540574f, 
    0.09443114f, -0.03874346f, 0.12714148f, -0.05389171f, 0.00711431f, 0.06915719f, -0.03322489f, -0.14377110f, 
    -0.34659630f, 0.38702986f, 0.14706025f, 0.00616788f, -0.10688801f, -0.01567481f, 0.05503634f, 0.05709840f, 
    -0.13619956f, -0.18622434f, 0.26649424f, 0.00112596f, -0.18815756f, -0.48826936f, 0.10716239f, -0.27400383f, 
    -0.08136759f, 0.04967864f, 0.17119695f, -0.18689647f, -0.12730400f, -0.02258990f, 0.07702344f, -0.15185116f, 
    0.16635756f, 0.00191397f, 0.27599743f, 0.09912079f, -0.06846101f, 0.06499544f, 0.12097920f, -0.01739162f, 
    -0.10146637f, 0.38273910f, -0.07836488f, -0.16853465f, 0.00192449f, 0.23375903f, -0.30467430f, 0.24214292f, 
    0.04446543f, -0.24322212f, -0.04928655f, 0.18719076f, -0.00079383f, 0.14073351f, 0.13050701f, 0.06938124f, 
    -0.16319691f, 0.13770364f, 0.00123674f, -0.39859813f, -0.04577659f, 0.09960783f, -0.12814398f, 0.09520525f, 
    0.11373990f, 0.04001479f, 0.13953330f, 0.16265455f, 0.24818465f, 0.10668946f, -0.13123688f, -0.00246363f, 
    0.02084395f, 0.33367500f, -0.15611340f, -0.06179477f, -0.00929450f, -0.18221551f, 0.23400134f, 0.05081861f, 
    -0.11256430f, 0.20153961f, -0.03434620f, 0.13774011f, 0.03587622f, -0.23064768f, -0.10521087f, -0.24183515f, 
    0.06792101f, 0.00632507f, -0.15913214f, 0.20499809f, 0.06064278f, 0.15837406f, 0.18492304f, 0.13137506f, 
    0.08002898f, -0.16748059f, 0.23556110f, -0.13887160f, 0.01719723f, -0.10713288f, -0.18132800f, -0.05780963f, 
    0.22270906f, -0.40838149f, 0.37222490f, 0.06003749f, 0.05177009f, 0.37158909f, 0.06376039f, -0.40909165f, 
    0.13378693f, 0.18527810f, 0.21342818f, -0.20984200f, 0.20440273f, -0.29433131f, -0.00757011f, -0.07352573f, 
    -0.11180937f, -0.05794061f, 0.03488768f, 0.11067604f, 0.03235559f, 0.16492102f, -0.13504575f, 0.05256822f, 
    -0.15184340f, 0.01905430f, 0.09114699f, -0.05702551f, 0.16000266f, -0.07607008f, 0.16092873f, -0.09070269f, 
    -0.01211683f, 0.29497635f, 0.04583587f, 0.01910584f, 0.06872118f, 0.19125964f, 0.11109616f, -0.21804361f, 
    0.14655992f, 0.32809511f, 0.17263807f, -0.21037564f, 0.14890467f, -0.44917998f, -0.09967179f, -0.11900138f, 
    0.15204589f, -0.03779611f, -0.08246986f, -0.15214084f, -0.09542480f, -0.13480531f, 0.31276149f, -0.11270655f, 
    -0.12453852f, -0.08030690f, 0.05894218f, 0.09729382f, 0.23049091f, 0.03865605f, -0.10971203f, -0.03080662f, 
    0.14402875f, -0.15126075f, 0.40034494f, -0.14773488f, -0.10067904f, 0.19771843f, 0.44560280f, 0.27408567f, 
    -0.07172218f, 0.29046100f, 0.08444272f, 0.08031780f, 0.10236610f, 0.35192984f, 0.24673967f, -0.14675915f, 
    0.02852530f, 0.11096825f, 0.19301780f, 0.27058882f, 0.18218406f, 0.13411905f, -0.19687843f, -0.02509499f, 
    0.02560186f, -0.10857008f, 0.23073697f, -0.00778467f, -0.11195961f, 0.08866713f, 0.16973969f, -0.09046627f, 
    0.03724078f, 0.09744398f, 0.20402052f, 0.00515113f, -0.02197714f, -0.27863321f, -0.09373643f, -0.23693210f, 
    -0.14826775f, 0.22423165f, -0.01660918f, 0.19633132f, 0.33177632f, 0.04297967f, -0.21530540f, -0.27850431f, 
    0.05347124f, 0.07649025f, 0.17978737f, -0.14144924f, 0.05409274f, 0.16345093f, 0.40581983f, 0.01578878f, 
    -0.11620389f, 0.04842251f, 0.09287804f, -0.14249340f, -0.04004255f, -0.01478306f, 0.10179454f, 0.07160113f, 
    -0.11496694f, -0.07419684f, -0.05654398f, -0.06698739f, 0.06687561f, -0.16006577f, -0.18890646f, 0.14411113f, 
    -0.15856057f, 0.12655881f, -0.12737407f, 0.03375608f, 0.08606806f, -0.00567279f, 0.04487235f, -0.08894646f, 
    -0.15541820f, -0.12414493f, -0.16339494f, -0.12415122f, -0.01247752f, -0.00901985f, 0.14601222f, -0.13638642f, 
    -0.16860048f, 0.05299829f, -0.12183016f, -0.16264905f, 0.12029085f, -0.15994860f, 0.06893773f, -0.10410126f, 
    0.01007177f, 0.04451766f, 0.10792018f, -0.07627641f, 0.15295762f, 0.09640932f, -0.07567640f, -0.08114421f, 
    0.10690002f, -0.08666544f, 0.04519559f, 0.02014075f, -0.07600462f, -0.16689116f, -0.07999184f, -0.12785484f, 
    -0.05427302f, 0.02836742f, -0.14494008f, -0.16833356f, -0.05342069f, 0.03138261f, 0.03087727f, -0.10931288f, 
    -0.07926928f, -0.03817582f, 0.06669296f, 0.15146177f, -0.09392688f, 0.17198639f, -0.14605913f, 0.08518670f, 
    0.03208783f, -0.30536631f, -0.05870280f, 0.09856917f, 0.18268950f, -0.05117362f, -0.31048545f, -0.24422199f, 
    0.09530634f, -0.19264343f, 0.23207474f, 0.05113202f, -0.22614570f, -0.04199626f, 0.28834695f, 0.04952125f, 
    -0.08714249f, 0.12180540f, -0.00564141f, 0.17142890f, 0.02470239f, -0.00489001f, -0.04044574f, 0.02191362f, 
    -0.11564507f, -0.02164738f, -0.13584076f, 0.13990186f, 0.11926513f, 0.13740079f, -0.05646103f, 0.05769257f, 
    0.10069332f, -0.07488966f, 0.17487410f, 0.04119279f, -0.08674407f, 0.06527421f, -0.01178321f, -0.11407128f, 
    -0.12894142f, -0.11538386f, -0.04885582f, -0.15144113f, 0.17375216f, -0.11397911f, -0.13849451f, 0.12166160f, 
    -0.13651493f, 0.16309968f, -0.14805153f, -0.09713189f, -0.11162159f, -0.17564876f, -0.04244922f, 0.15233681f, 
    -0.09935855f, 0.17940474f, 0.16922933f, 0.05282745f, 0.24983121f, 0.13649814f, -0.13500603f, -0.06796521f, 
    -0.27442557f, 0.35027483f, 0.37564719f, -0.08159528f, -0.06214968f, 0.28817868f, 0.00836555f, 0.39938673f, 
    -0.12060072f, -0.35788578f, 0.11759171f, 0.02889738f, 0.04133430f, 0.21827246f, -0.29904014f, -0.08035529f, 
    0.18212913f, -0.13631436f, 0.10551456f, -0.10562971f, -0.15070379f, 0.10520844f, 0.15028644f, -0.00809631f, 
    -0.16208434f, 0.12032961f, 0.27322295f, 0.15052724f, 0.39943656f, 0.05112832f, -0.13195555f, 0.09251159f, 
    0.38685250f, -0.15908144f, -0.29623100f, -0.05218128f, 0.14879711f, -0.02157219f, 0.06732170f, 0.10551623f, 
    -0.15197860f, 0.37019682f, 0.04174953f, -0.04320105f, -0.30543682f, -0.37521186f, -0.01486858f, 0.17766227f, 
    -0.06227975f, -0.16817164f, 0.03761879f, -0.30114365f, -0.09292740f, 0.15041518f, -0.02087690f, 0.11866286f, 
    -0.15693389f, 0.02124388f, -0.28290311f, -0.00334990f, 0.01651354f, 0.17036539f, 0.04597158f, 0.15204391f, 
    -0.20402262f, -0.01580936f, -0.01341235f, 0.16632055f, -0.02618430f, -0.02884355f, -0.01391574f, -0.29514834f, 
    0.12057102f, 0.04994987f, 0.07083986f, 0.03520792f, 0.22386941f, 0.10145450f, 0.10673005f, 0.01023466f, 
    0.00498533f, -0.01044416f, 0.27322814f, 0.05602565f, 0.15542758f, -0.00207363f, 0.53054637f, -0.15697810f, 
    0.03015328f, 0.09437369f, -0.16712977f, 0.17829934f, 0.04142445f, 0.32774481f, 0.13089304f, -0.12068602f, 
    0.09375499f, 0.05116547f, -0.41332754f, -0.09389944f, -0.05184402f, -0.47948703f, -0.11574021f, 0.06064815f, 
    0.06909470f, 0.27252242f, -0.03522723f, 0.07961544f, 0.01209482f, 0.00692552f, 0.20423676f, -0.10337429f, 
    -0.10433912f, -0.03633560f, 0.20002529f, -0.02723481f, -0.13727197f, 0.06279680f, 0.33849978f, 0.10815749f, 
    -0.08242084f, 0.09686222f, -0.26440397f, 0.17061105f, 0.14720081f, 0.18801092f, -0.02790605f, -0.08065452f, 
    -0.42530051f, -0.04856794f, 0.07629516f, -0.13405380f, 0.09035848f, -0.12745745f, 0.22454238f, 0.01855749f, 
    -0.09844740f, -0.29006046f, 0.24672379f, 0.06739722f, -0.20060103f, 0.20423110f, -0.07187092f, 0.21626538f, 
    -0.08782039f, 0.13556761f, 0.01764307f, 0.37351140f, 0.07261264f, -0.03397792f, 0.19139712f, -0.05403272f, 
    0.04516238f, -0.10507995f, -0.19353338f, 0.03360707f, -0.11587307f, 0.17649844f, -0.13519405f, 0.14917529f, 
    -0.06712957f, 0.26984957f, -0.20121287f, 0.09848680f, 0.06704721f, 0.05427442f, -0.08167639f, 0.24527645f, 
    -0.07371715f, -0.26872844f, 0.00439584f, 0.17604895f, 0.14638557f, 0.29891711f, -0.12281173f, 0.30434152f, 
    -0.17023100f, 0.12294813f, -0.19175297f, 0.07940421f, -0.00133941f, -0.14516403f, 0.19783387f, 0.11756677f, 
    0.10098126f, 0.05091097f, -0.01890030f, 0.04675664f, -0.14445794f, 0.16990693f, 0.17513268f, -0.04546210f, 
    -0.03963489f, -0.39693236f, -0.27561450f, -0.07139289f, 0.05814682f, -0.04900688f, 0.08934386f, -0.21603473f, 
    0.02447000f, 0.19177812f, 0.13920811f, 0.12662315f, -0.11469176f, 0.03038380f, 0.28747392f, 0.35948750f, 
    -0.01860318f, 0.12620035f, -0.16006994f, 0.36632326f, 0.14365591f, -0.10051879f, -0.23899217f, -0.12989973f, 
    0.15568300f, 0.17403495f, -0.15065424f, -0.02914998f, -0.04608560f, -0.04988847f, -0.10369279f, 0.01459061f, 
    0.14642502f, 0.10519981f, -0.15481232f, -0.05103201f, 0.10126807f, -0.13795035f, 0.00355821f, -0.06184633f, 
    0.03924445f, -0.14202361f, -0.06535408f, 0.02693666f, -0.14010052f, -0.11982223f, -0.15377007f, -0.14697072f, 
    -0.13609268f, -0.02162683f, 0.08036011f, -0.00902248f, 0.12681590f, -0.03750827f, -0.12643671f, 0.05145654f, 
    -0.17067195f, -0.01724701f, 0.29198217f, -0.15535910f, -0.05127145f, -0.24913774f, -0.04548195f, -0.08158220f, 
    -0.09459149f, 0.14506993f, -0.04703460f, -0.04276946f, 0.06536280f, 0.33808413f, -0.32804987f, -0.24021298f, 
    0.10352142f, -0.19888772f, 0.26426867f, 0.13090500f, -0.02357965f, -0.23971169f, 0.19181058f, 0.25780675f, 
    -0.12549208f, -0.16598624f, -0.25425616f, -0.03955763f, 0.14412680f, -0.13392486f, 0.07369238f, -0.13914946f, 
    0.03685645f, 0.04395130f, -0.16595624f, 0.09039180f, 0.04849680f, -0.06293353f, 0.07622032f, -0.03549738f, 
    -0.09971827f, -0.02214501f, -0.01334074f, 0.11318886f, -0.07181197f, -0.13767263f, -0.09873601f, 0.09844850f, 
    0.00203761f, -0.02676784f, -0.10015433f, -0.09818570f, 0.11987858f, 0.00812899f, -0.05344092f, -0.14265071f, 
    -0.10900648f, -0.10954082f, -0.12905143f, -0.02743943f, 0.06867361f, -0.04990263f, -0.10984670f, -0.13580245f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10640350f, -0.11359683f, -0.01799678f, -0.07733864f, -0.17214134f, 0.12206043f, 0.11754434f, -0.00753522f, 
    0.14776386f, 0.07120550f, 0.14505029f, 0.14483002f, 0.07421494f, -0.03358559f, -0.14055531f, -0.09655695f, 
    -0.05103547f, 0.12229284f, -0.00855493f, -0.11667936f, 0.07878288f, -0.17326981f, -0.08360089f, 0.02030706f, 
    -0.04350271f, 0.10856652f, -0.13137823f, 0.01227358f, 0.09810483f, -0.01576081f, 0.20226929f, -0.09026002f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02358017f, -0.50189799f, -0.26858342f, -0.04595572f, -0.19222985f, 0.18847740f, 0.04746516f, 0.04915899f, 
    -0.13139610f, -0.63508224f, -0.44094270f, -0.16549307f, -0.35835907f, -0.19771336f, 0.26437148f, -0.22844000f, 
    0.28422827f, 0.17633638f, 0.09824230f, 0.00608687f, 0.04763248f, -0.21797308f, 0.15995057f, -0.41440856f, 
    0.15296465f, -0.54444420f, -0.00700171f, -0.38866347f, -0.07324767f, -0.02236455f, -0.21167667f, 0.11267591f, 
    0.07100990f, 0.02485917f, -0.26803225f, 0.09917647f, 0.42163947f, -0.36503142f, 0.08074878f, 0.12614857f, 
    0.13887165f, -0.10706914f, -0.44323945f, 0.29309675f, -0.00422992f, 0.19610786f, 0.11769374f, 0.47675222f, 
    -0.15296221f, 0.23019512f, 0.01238027f, -0.04438199f, -0.41334382f, 0.05339072f, 0.18588585f, -0.01532526f, 
    0.01951070f, 0.04264577f, 0.05271107f, 0.05541459f, -0.53468907f, -0.11190540f, 0.23020567f, -0.11006854f, 
    -0.44999239f, -1.10281074f, -0.19994770f, 0.05776541f, -0.30394137f, 0.25052410f, 0.25915658f, 0.06697524f, 
    0.02609280f, 0.09128071f, 0.04172603f, -0.13249762f, -0.07246414f, 0.27913731f, 0.06795536f, -0.45640761f, 
    0.20799983f, 0.11732101f, 0.01219749f, 0.12691632f, -0.54340643f, 0.05935469f, 0.13494024f, 0.19673602f, 
    -0.54537272f, -0.28342646f, -0.31604955f, -0.42139924f, -0.26946563f, 0.10883541f, -0.31475079f, -0.14942813f, 
    0.09969765f, -0.27740288f, -0.03316013f, -0.04875889f, 0.24606234f, 0.15639117f, -0.14767104f, -0.08899408f, 
    -0.01270907f, -0.34502855f, -0.00144402f, -0.31273019f, -0.54189795f, 0.02601723f, -0.51623529f, -0.88171417f, 
    0.29956603f, -0.16987216f, -0.03052643f, -0.08385167f, -0.15935856f, 0.05250692f, 0.02770811f, -0.37849399f, 
    0.12013438f, 0.05130027f, 0.23138879f, -0.04591031f, 0.08488412f, 0.05873102f, -0.61351079f, -0.11211926f, 
    0.12040668f, -0.56167489f, 0.16295685f, -0.09456383f, -0.26610833f, 0.10370805f, 0.04200368f, -0.13461828f, 
    -0.09324849f, -0.12880945f, 0.01882819f, -0.18449545f, -0.06108315f, 0.11571655f, -0.12413642f, -0.54005212f, 
    -0.18575755f, 0.03028264f, 0.00093803f, 0.11856183f, 0.08223406f, 0.04418510f, 0.11702119f, -0.44761467f, 
    0.04768128f, -0.31685060f, 0.14422673f, 0.51296073f, 0.23288636f, -0.12328387f, 0.16610321f, 0.04212350f, 
    0.30736697f, 0.03665492f, 0.35030255f, 0.17509918f, -0.17932113f, -0.21405834f, 0.09244411f, -0.06819993f, 
    0.07809788f, -0.18913561f, -0.14573474f, 0.05666352f, -0.06236867f, -0.09211648f, 0.12861072f, -0.12017223f, 
    -0.15974584f, -0.31121624f, 0.01970879f, -0.04131152f, 0.23827301f, -0.16872516f, 0.08104048f, 0.23794298f, 
    -0.17311892f, -0.54491085f, 0.09412601f, -0.49476379f, 0.00670210f, 0.03605096f, 0.25090307f, -0.12161563f, 
    0.08953283f, -0.18074916f, -0.65071970f, -0.03428702f, -0.14275576f, -0.03344785f, 0.09680008f, 0.00822614f, 
    0.12160927f, -0.26945567f, 0.37828353f, -0.60455525f, -0.19945186f, -0.10715082f, 0.23283064f, -0.07625996f, 
    0.09910726f, -0.27037200f, 0.15534337f, 0.04710144f, 0.09844751f, -0.16458966f, -0.25285259f, 0.28209314f, 
    -0.12516510f, -0.17036670f, -0.55759031f, -0.24147674f, 0.32275227f, 0.11609022f, 0.04123313f, -0.16130166f, 
    -0.24338472f, 0.52848428f, 0.26846552f, -0.01028662f, 0.13995609f, -0.04286877f, -0.41449529f, 0.15824866f, 
    0.02249632f, 0.25016817f, 0.15232006f, 0.10234198f, 0.16619802f, -0.37176815f, -0.12603557f, -0.29468325f, 
    -0.24115506f, -0.40250483f, 0.14361510f, -0.01813392f, 0.21112335f, -0.02509717f, 0.12169731f, -0.18725260f, 
    0.02348240f, -0.09495746f, 0.24338503f, 0.23813745f, 0.14921071f, 0.04553716f, -0.29828441f, 0.14933529f, 
    -0.34782952f, -0.35502777f, -0.20913638f, -0.05561664f, -0.34215197f, -0.43447798f, -0.47600222f, 0.13963303f, 
    -0.10154681f, 0.29937077f, -0.10559963f, 0.31666815f, 0.38475761f, 0.15191774f, -0.12654571f, -0.30810004f, 
    0.13775043f, -0.37466401f, 0.05768767f, 0.09523533f, 0.10280790f, -0.08276667f, 0.23244944f, 0.16197038f, 
    -0.44736794f, -0.16803387f, -0.08649767f, 0.06160972f, -0.16209646f, -0.08171429f, 0.20214733f, 0.01767129f, 
    -0.22219825f, 0.00587793f, -0.15627632f, 0.12628351f, -0.04179129f, 0.21299458f, 0.24948803f, 0.05366661f, 
    -0.16530521f, 0.37436751f, 0.28766516f, -0.20089102f, 0.45343095f, -0.37131709f, -0.12964016f, -0.78981036f, 
    -0.21897376f, 0.15622608f, 0.00846635f, 0.10783005f, 0.23956816f, -0.06964641f, -0.26388800f, -0.18223155f, 
    -0.09515568f, 0.01466511f, -0.52197993f, -0.12659274f, -0.02891237f, 0.10745600f, 0.28362346f, 0.07130941f, 
    -0.31037083f, -0.55411100f, 0.13814287f, 0.15233141f, -0.38593417f, -0.16052616f, -0.59160954f, 0.02979917f, 
    -0.16231477f, -0.18732248f, 0.10781310f, -0.21516418f, -0.03417053f, 0.24519715f, -0.33900794f, 0.12231646f, 
    0.06475253f, 0.31952283f, -0.16471924f, -0.09504346f, -0.12465993f, 0.01753802f, 0.04049359f, 0.42450178f, 
    0.16867971f, 0.36328000f, -0.08421994f, -0.03371932f, -0.38253170f, -0.12015849f, -0.44470906f, -0.14270809f, 
    -0.27974108f, -0.29587618f, -0.22193104f, -0.06884231f, 0.21894734f, 0.03857278f, 0.11166225f, -0.00637827f, 
    -0.05389852f, 0.08155207f, -0.06916978f, 0.22619011f, -0.57521755f, 0.20985807f, -0.01897844f, -0.09785551f, 
    -0.19607344f, 0.16335402f, 0.14363389f, 0.09527386f, 0.32687506f, 0.05862098f, -0.38778448f, 0.13123573f, 
    0.15707049f, 0.28395694f, 0.02977325f, -0.61229706f, 0.32335708f, 0.00659455f, -0.02470645f, -0.11195227f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13026948f, 0.13078167f, -0.09964068f, -0.06537884f, 0.10318179f, 0.16473718f, 0.13144018f, -0.21750002f, 
    0.13313559f, 0.10704809f, 0.14292644f, -0.07912005f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
