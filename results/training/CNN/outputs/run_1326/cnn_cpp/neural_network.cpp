#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.40379739f, 0.06637505f, 0.51266986f, 0.55430627f, 0.62117857f, -0.01559857f, -0.05138570f, -0.01338628f, 
    0.05980606f, 0.50505161f, 0.08023892f, 0.01581660f, -0.19646145f, -0.12647517f, 0.12124817f, -0.06388073f, 
    0.00351932f, 0.03610591f, 0.10709166f, -0.04938021f, -0.14924227f, -0.36380357f, -0.29825240f, -0.29813683f, 
    -0.13739491f, 0.77549422f, -0.00698542f, -0.61874098f, -0.79117262f, -1.08336544f, 0.89082021f, 0.21906826f, 
    0.44296676f, -0.26500699f, 0.19950862f, -0.03639448f, 0.32099563f, -0.24572176f, 0.13565280f, 0.29075152f, 
    0.27125472f, 0.07895045f, -0.15079731f, -0.06567494f, 0.05088510f, 0.17602015f, -0.22134441f, -0.20893562f, 
    0.04835820f, 0.04121731f, 0.93628395f, 0.46830079f, -0.24386032f, 0.41415885f, -0.30561176f, -0.26843786f, 
    -0.10379550f, -0.32605234f, 0.27305996f, 0.60127902f, 0.10628264f, 0.26600644f, -0.42981410f, -0.14934282f, 
    0.13171430f, 0.23163019f, -0.26866388f, 0.10300468f, 0.16409944f, -0.40246594f, 0.04329677f, 0.20598982f, 
    -0.03503368f, 0.23999752f, -0.20965427f, 0.55681252f, 0.60567164f, -0.03853305f, 0.09849393f, 0.57261747f, 
    -0.29257515f, 0.00346321f, -0.12759703f, -0.41777456f, -0.54051167f, 0.01917568f, 0.54167050f, -0.03529529f, 
    0.12486922f, -0.28449780f, 0.27311859f, 0.25767875f, 0.31641603f, -0.16532454f, -0.01092402f, -0.10258055f, 
    0.13662770f, 0.30108532f, -0.12050134f, 0.04162140f, 0.27794912f, 0.42174217f, 0.66711658f, -0.04662807f, 
    0.08805270f, -0.26710799f, 0.31283075f, 0.38760769f, 0.03452827f, -0.08643932f, -0.10744428f, -0.14834191f, 
    -0.00153992f, 0.12714775f, -0.01465163f, -0.30920735f, 0.02822261f, -0.10543899f, -0.05376548f, 0.28804803f, 
    0.30893493f, 0.40680528f, -0.01753430f, -0.31120101f, -0.32751879f, -1.52690709f, 0.15500265f, -0.36519071f, 
    -1.17877865f, -0.25046954f, 0.86986172f, 0.18471733f, -0.35579407f, 0.03304000f, 0.26270139f, -0.12650712f, 
    -0.42622498f, -0.36878437f, -0.53632867f, -0.29169172f, 0.06377214f, -0.03419380f, -0.15496448f, -0.04758335f, 
    -0.04125136f, 0.01260380f, 0.03281113f, -0.11743519f, -0.07026803f, -0.11348749f, -0.18024367f, 0.10724165f, 
    -0.41190112f, -0.53481394f, -0.63424855f, -0.37557217f, -0.24796535f, -0.55561924f, -0.61446965f, -0.39954942f, 
    -0.14190181f, 0.10314552f, 0.39981604f, -0.27914551f, -0.02784644f, 0.10139153f, 0.02845796f, -0.08035681f, 
    0.28226125f, 0.08541659f, -0.04858608f, 0.01635773f, -0.12906656f, -0.34911734f, 0.34135166f, -0.66398412f, 
    0.31515819f, 0.10808960f, -0.43383357f, -0.01928934f, 0.03929296f, 0.11149043f, -0.50570011f, -0.25894645f, 
    0.49226233f, -0.31289732f, -0.32607388f, 0.07082985f, -0.18213427f, 0.35700950f, 0.44851336f, 0.19266908f, 
    -0.16741388f, 0.01615195f, -0.41724968f, -0.20380579f, -0.24909316f, -0.15826808f, -0.22848946f, -0.35606509f, 
    -0.75344062f, -0.56492090f, -0.02633078f, -0.11501099f, 0.05619429f, -0.16557862f, 0.24389257f, -0.82453752f, 
    -0.56242847f, -0.46590424f, -0.25694507f, -0.18080789f, -0.19174758f, -0.17297387f, -0.24095738f, -0.04398124f, 
    0.13497201f, 0.06306487f, 0.32433572f, 0.10565026f, 0.27627429f, 0.19419740f, 0.25905693f, 0.13110141f, 
    0.13546552f, -0.11845521f, 0.03504918f, -0.27355647f, 0.17296973f, 0.25397471f, -0.21074635f, -0.37764186f, 
    -0.31568494f, 0.50251812f, 0.37151805f, -0.13610074f, 0.67053151f, -0.29033083f, -0.39644116f, 0.37935629f, 
    -0.05825414f, -0.09322026f, -0.00242672f, -0.09805857f, -0.04436206f, -0.02452005f, 0.13368145f, 0.01368895f, 
    0.17123286f, 0.32891244f, -0.21334690f, 0.67133063f, 0.47732615f, -0.44466916f, 0.14381240f, -0.57319701f, 
    -0.05734939f, 0.23813961f, 0.27189001f, 0.32615891f, -0.21504089f, 0.00480146f, 0.52998632f, -0.48690498f, 
    -0.06027791f, 0.17259145f, 0.15471014f, -0.48358825f, 0.08949862f, -0.25799811f, -0.23139383f, 0.31038237f, 
    0.01753290f, 0.19651048f, -0.05408823f, 1.25294435f, -1.41596699f, -0.35448802f, 0.37043032f, 0.24801290f, 
    0.01578472f, 0.07480073f, 0.04098449f, -0.18214177f, -0.27592921f, -0.38719192f, 0.08441484f, 0.39215362f, 
    -0.30665517f, 0.05893119f, 0.20701548f, 0.13128793f, -0.10479953f, 0.01911212f, -0.18270919f, 0.07207674f, 
    -0.17737161f, -0.03222454f, -0.12158983f, -0.19820470f, 0.69990313f, 0.45718494f, 0.25308737f, -0.84562665f, 
    -0.56383294f, 0.03019032f, -0.08029187f, -0.15159512f, 0.02638296f, -0.05562442f, 0.16413945f, 0.11620290f, 
    0.23295180f, -0.02508261f, -0.25084001f, 0.05629156f, 0.06009093f, 0.00095482f, -0.30071944f, -0.18786585f, 
    -0.29874092f, -0.19052225f, -0.26380426f, -0.37990493f, -0.73286730f, -0.26511016f, -0.73519731f, -0.36243832f, 
    -0.17577800f, -0.34072205f, 0.37212992f, 0.28164139f, 0.51239562f, 0.54840279f, 0.68017304f, -0.21355489f, 
    0.27128690f, -0.31428239f, -0.11761046f, 0.61032689f, -0.39137033f, -0.02500585f, 0.05476716f, -0.06666175f, 
    -0.33992976f, 0.13779622f, 0.04706038f, 0.24517387f, -0.03214586f, -0.01551745f, -0.14130914f, -0.52550852f, 
    -0.50620764f, -0.08209102f, -0.16801462f, -0.00710183f, 0.16125318f, 0.02677397f, -0.62712842f, -0.68808174f, 
    0.41046861f, -0.07337678f, -0.14135380f, -0.17414504f, 0.55971426f, -0.20296121f, -0.19016936f, -0.25849241f, 
    -0.69144410f, -0.47650582f, 0.04052135f, -0.16445409f, 0.27187607f, 0.28041542f, 0.06316780f, 1.17551112f, 
    0.84635663f, -0.08157957f, -0.62433445f, 0.27963910f, 0.33120018f, -0.11158876f, 0.03858277f, -0.26198927f, 
    -0.44526437f, -0.18392092f, 0.03261997f, 0.19844343f, -0.24716775f, -0.24416837f, -0.07985143f, -0.22200717f, 
    -0.10980976f, 0.06917358f, 0.03306088f, 0.02873771f, 0.00206308f, -0.30886549f, 0.11311664f, 0.36704120f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.33631167f, 0.31238741f, 0.40112159f, 0.02182849f, 0.06377888f, -0.07874542f, 0.15383187f, 0.04266238f, 
    0.08291004f, 0.13689013f, 0.30498612f, 0.11248817f, 0.15800042f, 0.33771306f, 0.05733341f, 0.24912843f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13998751f, 0.13099134f, 0.17809226f, 0.00499763f, -0.07272454f, -0.04603961f, -0.04445441f, -0.03075504f, 
    0.25106439f, 0.20827818f, 0.19337487f, 0.16654085f, -0.16348326f, -0.17470917f, 0.07826651f, 0.27323461f, 
    -0.03234451f, 0.14090075f, 0.07695042f, -0.09938947f, -0.10017706f, 0.04954281f, -0.13462839f, -0.06520148f, 
    -0.45942298f, -0.05406391f, 0.36324599f, 0.01217087f, -0.03269472f, 0.14186290f, -0.18289198f, 0.02595001f, 
    -0.17178938f, -0.04794345f, 0.05679804f, 0.12526831f, 0.16190805f, 0.21914355f, 0.09673592f, 0.07564509f, 
    -0.21521334f, -0.33746493f, -0.07572141f, -0.11697862f, -0.02872681f, -0.00542732f, 0.09914704f, -0.01419313f, 
    0.10925493f, 0.07190780f, 0.13360994f, -0.06364515f, -0.04028174f, -0.06490211f, -0.01359791f, -0.00588936f, 
    0.04103059f, 0.15967287f, 0.05268917f, -0.05625570f, 0.53018743f, 0.25850374f, -0.13103770f, -0.07429008f, 
    -0.01352948f, 0.26266971f, -0.13186616f, 0.11316913f, 0.06614693f, 0.05194623f, -0.07325646f, 0.03762521f, 
    0.22948794f, -0.04551153f, -0.21034835f, 0.02079708f, -0.05559498f, -0.02973685f, -0.08096702f, -0.03622015f, 
    -0.01568269f, 0.01295016f, -0.01811495f, -0.01362837f, 0.06477611f, 0.18429571f, -0.00497099f, -0.00121875f, 
    0.01372346f, 0.05795002f, -0.10372521f, 0.01227648f, -0.09587194f, 0.09388360f, -0.02079383f, 0.04881627f, 
    0.48803493f, 0.29525739f, -0.07932351f, -0.14869669f, 0.04881198f, -0.05599987f, 0.05811708f, 0.18974558f, 
    0.06153584f, 0.03444457f, -0.00470267f, 0.04562414f, 0.14670736f, 0.23787944f, 0.26558673f, -0.23410864f, 
    0.00381182f, 0.16530597f, -0.23053475f, -0.13253678f, -0.06659424f, 0.03330011f, -0.03067515f, -0.17925775f, 
    -0.06061650f, -0.06129698f, 0.54006284f, -0.01864092f, -0.05978530f, 0.10585203f, 0.00031315f, 0.00694070f, 
    -0.03884062f, 0.04270613f, -0.01762033f, 0.04317604f, 0.04197903f, -0.01385444f, -0.00848798f, 0.24208656f, 
    -0.15434422f, -0.20829119f, 0.07208645f, -0.00848852f, -0.01983480f, -0.00028958f, 0.03397289f, 0.01193437f, 
    -0.19865996f, -0.28298303f, 0.16558339f, 0.14567989f, -0.07432279f, 0.01287611f, -0.07863899f, 0.13064994f, 
    -0.03208856f, -0.09039910f, 0.01124571f, 0.11277229f, 0.25062859f, -0.04916885f, -0.12544659f, -0.10473833f, 
    0.07584163f, 0.03321088f, 0.03641365f, -0.04015923f, -0.09849511f, 0.16103026f, -0.12180141f, -0.20315467f, 
    0.21014620f, 0.11563160f, -0.08630107f, 0.11276548f, 0.01415051f, 0.11240388f, 0.13556489f, -0.15046617f, 
    -0.12293223f, 0.11210673f, -0.07675207f, 0.19863997f, 0.15088654f, 0.15959838f, -0.03904537f, 0.28122681f, 
    -0.08011441f, 0.06760789f, -0.15477900f, 0.10099783f, 0.01470537f, 0.02525309f, 0.02306654f, 0.01757354f, 
    -0.23301870f, -0.19010930f, -0.13864328f, 0.13485160f, 0.07997368f, 0.15571524f, 0.02989943f, 0.16377199f, 
    -0.10562751f, -0.04406078f, 0.10546482f, 0.24816370f, 0.41169405f, 0.41858131f, 0.23909360f, -0.13850169f, 
    0.23447190f, -0.06802526f, -0.02827000f, -0.20389344f, 0.02270976f, 0.16705643f, 0.06428548f, 0.02398865f, 
    0.18008767f, -0.19071752f, -0.34075704f, -0.01454392f, 0.03276219f, 0.04400118f, 0.13780692f, 0.02178059f, 
    0.21884234f, 0.01830546f, -0.05751254f, -0.12357298f, -0.11059014f, -0.33463249f, -0.07197285f, -0.09301569f, 
    0.07512362f, -0.01690499f, 0.16610044f, 0.06363668f, -0.02001463f, -0.08138204f, -0.06086937f, 0.04973675f, 
    -0.07839456f, -0.06032735f, -0.29783854f, -0.06571794f, 0.11685137f, -0.00960231f, -0.02720170f, 0.08902999f, 
    0.20867132f, -0.09875442f, 0.03999325f, 0.13580537f, -0.12930110f, -0.13715556f, 0.22976539f, 0.34905860f, 
    -0.08432466f, -0.07968453f, 0.04329865f, -0.01953144f, 0.11955101f, 0.02551522f, -0.08883619f, 0.07876554f, 
    -0.16457622f, -0.05733041f, -0.02750620f, -0.02519515f, -0.01283577f, -0.14104100f, 0.12570684f, -0.01763423f, 
    0.08793860f, 0.05820346f, 0.13993205f, -0.02771831f, 0.14992638f, -0.11089452f, -0.32791072f, 0.16970447f, 
    -0.09199866f, 0.11091539f, 0.02136315f, -0.26276630f, -0.04983038f, 0.15276590f, -0.00095201f, 0.13552137f, 
    -0.37443763f, -0.34768546f, -0.03117903f, 0.08512769f, 0.13199756f, 0.08133961f, -0.11533732f, -0.07635880f, 
    0.02025529f, 0.02374268f, -0.01601188f, -0.10343786f, -0.16546750f, -0.24642465f, -0.43882501f, 0.08986979f, 
    0.11736663f, 0.12086831f, 0.27488434f, 0.13395217f, 0.06355455f, -0.03813118f, -0.03853493f, -0.00812114f, 
    0.08805584f, -0.16005650f, -0.24482550f, -0.05064975f, -0.06533077f, -0.00265584f, 0.05436169f, 0.00589601f, 
    0.06475657f, -0.06111068f, -0.28936967f, -0.10828200f, 0.09342001f, -0.02105200f, 0.06081540f, -0.32644844f, 
    0.22195236f, 0.12812953f, -0.08154169f, -0.16532016f, 0.17627300f, -0.02743554f, 0.07132904f, 0.19281687f, 
    0.21797419f, 0.17696296f, -0.09372064f, 0.00768269f, 0.00866717f, -0.06646269f, 0.03691606f, -0.01009691f, 
    0.20820071f, 0.16960131f, 0.24616760f, 0.35024419f, 0.02217725f, 0.36313325f, 0.43856749f, 0.22961116f, 
    -0.10786359f, -0.01623513f, -0.03018944f, -0.02613601f, -0.00069532f, 0.03179655f, 0.04169861f, 0.12604173f, 
    -0.03604808f, -0.21600145f, 0.13629906f, -0.10196020f, -0.19334146f, -0.04504995f, 0.02323289f, -0.13115788f, 
    0.03967283f, -0.06339224f, -0.05512944f, -0.11924938f, 0.06444094f, -0.02929928f, -0.06463748f, -0.38540184f, 
    0.07455292f, 0.01047136f, 0.11904745f, 0.01025091f, 0.02277861f, -0.04985490f, 0.02950243f, -0.11272424f, 
    -0.23042786f, 0.05049390f, -0.21794283f, 0.02424409f, -0.13991643f, 0.08004876f, 0.07920568f, -0.10698609f, 
    0.21861824f, 0.11431859f, 0.10874379f, 0.05211474f, 0.03593401f, 0.11252850f, 0.07089727f, 0.21289101f, 
    -0.05614645f, -0.06019476f, 0.05267380f, -0.06552601f, -0.02978979f, 0.03320161f, -0.01827632f, -0.11055851f, 
    -0.23351716f, -0.16562194f, -0.24936040f, -0.01735345f, -0.12719263f, 0.16617985f, 0.20108666f, -0.00910385f, 
    -0.10082446f, 0.03380407f, 0.10748179f, -0.06610931f, 0.43868318f, 0.10711541f, 0.14228372f, -0.00300767f, 
    0.10991669f, 0.04500183f, -0.02744940f, -0.09876685f, 0.04418876f, 0.01783631f, -0.16386394f, -0.14664072f, 
    0.07438911f, -0.28333449f, -0.09798559f, -0.11019769f, -0.11084926f, 0.15839462f, 0.15561451f, -0.12314696f, 
    0.03730529f, -0.07881489f, 0.06114028f, 0.06101592f, 0.54356432f, -0.43443340f, -0.07605359f, 0.08091079f, 
    0.28225291f, 0.10300741f, -0.13500416f, 0.10944203f, -0.06018560f, 0.10816688f, 0.16412216f, -0.14326678f, 
    0.05667743f, -0.04156736f, 0.09463378f, 0.06334886f, -0.15798882f, -0.14129752f, 0.02707863f, -0.00725587f, 
    0.14148556f, 0.02589504f, -0.00678210f, 0.00139007f, 0.14443372f, 0.23015925f, -0.03129575f, 0.01058820f, 
    -0.08193196f, -0.05180467f, 0.02777437f, 0.05125499f, 0.00910819f, 0.21028352f, -0.05018320f, 0.24936560f, 
    -0.07070383f, -0.09249046f, -0.02080109f, 0.26384580f, -0.09793546f, 0.05979377f, -0.05604685f, -0.03533923f, 
    0.00564186f, -0.03478418f, 0.04668679f, -0.01524326f, -0.21786383f, 0.28945696f, 0.07620729f, 0.11705595f, 
    0.10951857f, -0.09862522f, 0.17499995f, -0.10034931f, -0.19790488f, -0.19143449f, 0.19952410f, -0.22571172f, 
    0.15520154f, -0.05456015f, 0.36976758f, -0.35063231f, -0.03760199f, 0.00758854f, -0.01367304f, -0.11563535f, 
    -0.05458784f, 0.07838284f, -0.19744602f, -0.09627419f, -0.29447827f, 0.14585046f, 0.02866229f, -0.14702950f, 
    0.01070801f, 0.02008360f, -0.02788738f, 0.26360103f, -0.11949304f, -0.00926615f, 0.05082201f, 0.36921689f, 
    0.21210635f, -0.03474895f, 0.12755370f, 0.11825613f, 0.15564634f, -0.13598603f, 0.06578001f, 0.06488860f, 
    -0.02868367f, -0.06464591f, -0.07879823f, 0.27892271f, 0.18891737f, 0.55783558f, -0.21774054f, -0.17990282f, 
    -0.00851131f, -0.12294276f, 0.04459280f, 0.07842692f, 0.01509036f, 0.11942351f, 0.01399172f, 0.10950122f, 
    0.16836491f, 0.18702953f, -0.04650971f, 0.28955299f, -0.06101216f, -0.14937039f, 0.13269578f, 0.20352307f, 
    0.00398568f, 0.04226174f, 0.17198315f, 0.04401150f, 0.31365928f, -0.08629277f, -0.36536440f, 0.21947502f, 
    -0.12976052f, -0.10004331f, 0.02072419f, -0.08401372f, 0.02539284f, 0.00724273f, 0.01515850f, -0.12910861f, 
    -0.02125094f, -0.00357773f, 0.02019563f, 0.02945158f, -0.04615312f, 0.04566218f, -0.02026452f, -0.02379542f, 
    -0.04575239f, -0.05281314f, 0.00806747f, 0.05544307f, 0.03469507f, -0.00500574f, -0.04771164f, 0.03765749f, 
    -0.01617771f, -0.04921208f, -0.04184531f, 0.04872751f, 0.00507946f, -0.04210197f, -0.01833932f, -0.06026013f, 
    -0.04169669f, 0.05025929f, 0.01261217f, 0.02526888f, -0.06320342f, -0.07762156f, 0.04152690f, 0.05883849f, 
    -0.03527671f, -0.05396355f, -0.07576977f, 0.04156966f, -0.06804129f, 0.00871241f, 0.04367642f, -0.04699411f, 
    -0.02831768f, 0.03617246f, -0.03953987f, -0.00183260f, -0.03725656f, 0.03272166f, 0.03970226f, 0.01140613f, 
    0.05479128f, 0.01924072f, 0.03219041f, -0.05785240f, 0.01548402f, -0.04616915f, -0.03572054f, -0.00045773f, 
    0.05484166f, -0.00173097f, -0.04832415f, -0.01830515f, -0.05189100f, 0.03651147f, -0.01338503f, 0.03658353f, 
    -0.04095377f, 0.03504551f, 0.02781006f, -0.05768140f, -0.05939782f, 0.02129932f, -0.00555966f, -0.02445232f, 
    0.00297310f, -0.03659578f, 0.05347806f, 0.03309026f, -0.07291765f, 0.00383686f, -0.06329773f, -0.06049510f, 
    -0.05685298f, -0.07243515f, -0.03005678f, -0.05733172f, -0.05135010f, 0.06831005f, 0.02321866f, 0.00824553f, 
    0.02251602f, -0.04737443f, -0.02829945f, 0.05488257f, 0.03128606f, 0.00321863f, -0.03994309f, 0.00058449f, 
    -0.03477853f, -0.00662881f, -0.05826015f, -0.06075230f, 0.04714264f, -0.03214788f, 0.00245983f, -0.05113238f, 
    -0.03986185f, -0.00744884f, -0.03546854f, 0.00068833f, 0.02276665f, -0.02739630f, 0.02323006f, 0.05910182f, 
    -0.03940995f, -0.05479878f, -0.00928483f, -0.07024527f, 0.02377090f, -0.03691355f, -0.03416528f, 0.05618560f, 
    -0.04609302f, -0.04471197f, -0.02728154f, -0.04771470f, -0.05140097f, -0.02139152f, -0.00367098f, -0.00770151f, 
    -0.03312651f, 0.04884640f, 0.05728045f, 0.01162035f, 0.04620860f, 0.03958861f, 0.05655433f, 0.00040231f, 
    -0.05596478f, -0.07571317f, -0.02770918f, 0.05291168f, -0.06460875f, -0.01417066f, -0.02501489f, 0.00701937f, 
    -0.02094934f, 0.00850867f, 0.00114965f, -0.05043507f, 0.02773841f, -0.01966515f, -0.01308623f, 0.04065618f, 
    -0.03693160f, 0.01098671f, 0.02610646f, -0.00146463f, -0.02099746f, 0.05887335f, -0.07540938f, -0.03898726f, 
    0.05986146f, -0.03804002f, 0.04161130f, -0.00220342f, 0.03050493f, -0.01835026f, 0.06573434f, -0.02214221f, 
    -0.01703772f, -0.05656205f, -0.02243626f, -0.01716848f, -0.05741677f, -0.01431473f, -0.06582866f, -0.02371721f, 
    -0.01929496f, 0.05881613f, -0.05535014f, 0.02065049f, 0.04878952f, 0.04795565f, 0.01634488f, 0.06225372f, 
    0.04795495f, 0.05655646f, 0.03304456f, -0.03702485f, -0.07029080f, 0.01263268f, 0.02812124f, -0.07157565f, 
    -0.08693291f, 0.14960815f, 0.00857178f, -0.07307985f, -0.06410955f, -0.11275230f, -0.18618841f, -0.13143510f, 
    -0.01491837f, -0.17164016f, -0.19042687f, -0.25518116f, 0.23143369f, -0.30008748f, -0.08665428f, 0.05858654f, 
    0.04106629f, 0.04562519f, 0.10191889f, -0.02566015f, 0.02869695f, 0.04036959f, 0.17182194f, -0.03485631f, 
    -0.16224128f, 0.36135307f, 0.25244933f, 0.03711690f, 0.02285468f, 0.04588362f, 0.04233082f, -0.01259749f, 
    -0.10387912f, 0.07350219f, 0.09828825f, 0.10652345f, -0.20787005f, 0.08985349f, -0.00879309f, -0.02495035f, 
    0.12032299f, 0.11569416f, 0.02710234f, -0.14158940f, -0.08565730f, 0.15440691f, 0.01632517f, -0.00738300f, 
    0.07901848f, -0.01060455f, 0.08293238f, -0.05911450f, -0.14983860f, -0.27776593f, -0.12573530f, -0.08287006f, 
    -0.14633805f, 0.09981236f, -0.08660095f, 0.10130449f, 0.25770637f, 0.32515556f, 0.02002179f, 0.01269855f, 
    0.02875543f, 0.02536463f, -0.05987713f, -0.03335967f, -0.05911360f, -0.08592509f, 0.07972701f, -0.13835607f, 
    0.06448530f, -0.27576017f, 0.11163685f, 0.06026867f, -0.08262819f, 0.05304147f, -0.16112404f, -0.08492836f, 
    -0.09700242f, -0.03302931f, 0.05378322f, -0.01165139f, -0.12309679f, -0.02756973f, 0.22101799f, -0.05530034f, 
    0.20673598f, -0.02428680f, -0.02869755f, 0.18387468f, -0.05146600f, -0.02457332f, 0.06058973f, -0.22556105f, 
    0.00291139f, 0.13063441f, 0.00677630f, 0.06237076f, 0.03509991f, -0.10496493f, 0.09519745f, 0.10686812f, 
    -0.10381188f, -0.00268884f, 0.06254666f, 0.08398754f, -0.15332590f, 0.16535029f, -0.02340163f, 0.14580631f, 
    0.06152918f, 0.20302358f, 0.05011852f, 0.01261416f, -0.07081961f, -0.09939034f, 0.05097710f, 0.24068883f, 
    0.33342397f, -0.11325198f, 0.13572489f, 0.13193694f, 0.05972927f, -0.12937550f, 0.07072002f, -0.05867524f, 
    0.05273931f, 0.04257426f, 0.13349113f, 0.29558057f, 0.40419629f, 0.20603676f, -0.25113294f, 0.18495488f, 
    -0.00427347f, 0.17273925f, -0.07806073f, 0.14502671f, 0.01203129f, -0.01965526f, 0.28688237f, -0.05385513f, 
    0.14130494f, -0.13187149f, -0.04884638f, -0.10067242f, 0.09216382f, -0.05092612f, -0.10334035f, 0.17906901f, 
    -0.19717117f, -0.09398372f, -0.26303241f, -0.30658126f, -0.36028808f, 0.32363153f, 0.01428435f, -0.26055127f, 
    -0.13097674f, 0.08474975f, -0.00227430f, 0.03881354f, 0.06431832f, 0.07668763f, 0.00548683f, 0.00140340f, 
    -0.08062464f, 0.06874964f, 0.14841932f, 0.06511977f, 0.01768767f, 0.19039686f, 0.07254618f, 0.13871899f, 
    0.10908425f, 0.03525189f, 0.00721918f, 0.19849955f, 0.15169238f, 0.02003357f, -0.09436084f, 0.12594698f, 
    -0.21058980f, 0.08302092f, -0.13501471f, 0.00571581f, -0.11236052f, 0.01005297f, 0.08626153f, 0.13257657f, 
    0.18917215f, -0.07839962f, 0.01504715f, -0.21626888f, -0.24283041f, -0.08950726f, 0.20484217f, -0.01485551f, 
    0.14075169f, 0.16297314f, 0.12027379f, 0.20323257f, -0.46733224f, 0.24328977f, -0.14067955f, -0.08651543f, 
    -0.16833527f, -0.05546966f, 0.14429419f, 0.19210340f, -0.06395931f, 0.01701733f, 0.01545006f, 0.01171707f, 
    -0.05877758f, -0.28195655f, 0.01939398f, 0.03027395f, -0.05022053f, -0.03789379f, -0.18215968f, -0.22844954f, 
    -0.10260638f, -0.09019661f, -0.05061384f, 0.13741490f, 0.25024712f, -0.04491130f, 0.00140179f, -0.05670648f, 
    0.04780779f, -0.03234524f, -0.11305931f, 0.18682195f, 0.06545553f, -0.20682462f, -0.23298930f, -0.31899124f, 
    -0.01920567f, 0.11850443f, 0.06161465f, -0.12500709f, 0.19551286f, 0.24297866f, 0.22160317f, -0.12392320f, 
    0.01275910f, -0.17408019f, -0.03793963f, -0.03910640f, 0.25132519f, -0.37333229f, 0.08139716f, 0.14003362f, 
    0.00814874f, 0.12858903f, 0.24090898f, 0.14317428f, 0.15651342f, 0.03158340f, 0.13547441f, 0.28085187f, 
    -0.04024357f, 0.01737044f, 0.03757755f, -0.03287297f, -0.03043794f, -0.09603474f, 0.17541546f, 0.14522761f, 
    0.06467874f, -0.02334140f, -0.01279682f, -0.03052941f, 0.13538876f, -0.07833746f, -0.04832324f, 0.10825676f, 
    -0.02699696f, 0.03352537f, 0.10004463f, -0.05447344f, 0.15944856f, 0.34331185f, 0.02690167f, 0.22641729f, 
    -0.17604989f, -0.24990888f, -0.09225585f, 0.02328703f, -0.05558932f, 0.09652685f, -0.14108326f, 0.02055441f, 
    -0.09730565f, -0.15435137f, -0.27768615f, -0.18085490f, 0.11092965f, -0.45581982f, -0.02337782f, -0.18454079f, 
    0.11673825f, -0.03500211f, -0.09336340f, -0.35283291f, 0.04196689f, -0.11879871f, -0.27644065f, -0.42361340f, 
    0.03135448f, 0.30235445f, -0.07689734f, -0.10969313f, -0.07181140f, -0.03227054f, -0.17913841f, -0.18496899f, 
    -0.04277675f, 0.06500150f, -0.06223950f, -0.08134939f, -0.42057815f, 0.13647629f, 0.21410148f, 0.19155322f, 
    -0.13363789f, 0.04729030f, 0.30668005f, 0.03377700f, -0.03364253f, 0.12671778f, 0.05714286f, 0.24362057f, 
    -0.14600907f, 0.20456326f, 0.24641758f, 0.06448416f, -0.14183293f, 0.08461075f, 0.20493838f, 0.05674050f, 
    0.16435993f, 0.27922818f, 0.34142971f, 0.26045454f, 0.28731325f, -0.11407591f, 0.09089805f, -0.02081818f, 
    0.27256677f, -0.05108800f, 0.08722267f, -0.26552528f, 0.08164117f, 0.03414653f, 0.06502123f, 0.13805607f, 
    -0.23620117f, 0.12608179f, 0.10235001f, 0.15900885f, 0.07030545f, -0.15755461f, 0.36300269f, 0.03740559f, 
    0.02477146f, 0.02356059f, 0.23814392f, -0.05275817f, 0.15728211f, 0.23846325f, 0.57823604f, -0.02287768f, 
    0.20271283f, -0.22057697f, -0.07222106f, 0.18458922f, -0.32607040f, -0.09617965f, 0.06849087f, -0.27564755f, 
    -0.38077718f, -0.56236559f, 0.18119717f, 0.14854859f, 0.03968761f, -0.05660201f, 0.16999982f, -0.17922667f, 
    -0.03827520f, -0.06493465f, -0.01911894f, 0.23482922f, -0.35787687f, -0.56262743f, -0.58415270f, -0.04034639f, 
    0.04221145f, -0.11761852f, -0.08577047f, -0.05427350f, 0.11382385f, 0.05970844f, -0.07048996f, 0.09896519f, 
    0.07232721f, -0.30797577f, -0.24303594f, -0.02271571f, -0.02338167f, 0.00995357f, -0.04066281f, -0.29314974f, 
    -0.04393482f, -0.05820971f, -0.04833561f, 0.12576109f, -0.25551447f, 0.07670930f, -0.24654801f, 0.30462545f, 
    -0.00697249f, -0.22500584f, -0.00137441f, 0.30716884f, -0.05712741f, -0.02575210f, -0.09133175f, -0.48188081f, 
    -0.33770698f, -0.42115748f, -0.07527177f, 0.46004486f, -0.16518076f, 0.26923841f, 0.14164735f, -0.08117938f, 
    0.11940646f, -0.28253034f, -0.11103173f, 0.00008088f, 0.13880308f, 0.15871315f, -0.16122612f, -0.09263951f, 
    0.01277994f, 0.20797136f, 0.00234397f, 0.08272890f, 0.02061796f, 0.15120409f, 0.07463923f, 0.20717233f, 
    0.30124047f, 0.28846321f, -0.08477882f, 0.16812670f, 0.25866577f, 0.15662472f, 0.06594293f, 0.10939090f, 
    0.05162849f, 0.17785558f, 0.03733817f, 0.07608222f, 0.19425207f, 0.28104866f, -0.10936285f, 0.03771568f, 
    0.02221266f, 0.15271457f, 0.20351009f, 0.18710686f, 0.04349785f, 0.05899006f, 0.10478557f, 0.18150619f, 
    0.40362397f, 0.29080808f, -0.13646236f, -0.25029385f, 0.20973153f, 0.19808260f, 0.04062386f, -0.00837587f, 
    -0.14681964f, -0.13454100f, -0.09342134f, 0.01521375f, -0.04684681f, 0.14953090f, -0.18513516f, -0.53283119f, 
    0.10506968f, 0.12424050f, -0.17711149f, -0.06684601f, 0.21991180f, -0.03623532f, 0.15592960f, -0.06461874f, 
    -0.58305049f, -0.13339563f, -0.13089038f, 0.22839376f, -0.14690049f, 0.11712876f, -0.06760052f, 0.10952541f, 
    -0.09954561f, 0.00259677f, -0.01306905f, 0.09316631f, 0.15496181f, -0.07580809f, 0.07510100f, 0.02704811f, 
    0.16044824f, -0.07885512f, 0.20990875f, 0.06973629f, 0.09818670f, 0.22856861f, 0.05583335f, 0.00761965f, 
    -0.12784386f, -0.32832819f, -0.30185190f, 0.42402199f, -0.16094172f, 0.08124088f, 0.03232068f, -0.03580057f, 
    0.00716096f, 0.06581214f, 0.10435751f, 0.23779024f, 0.17131940f, -0.39310363f, -0.10503224f, 0.11054102f, 
    0.02328516f, 0.02315765f, -0.19875124f, -0.28900805f, 0.13916993f, -0.09407859f, 0.04143843f, 0.05536344f, 
    0.34376520f, 0.01497390f, -0.21820992f, -0.08122193f, 0.11928793f, 0.12721004f, -0.10111079f, -0.17894797f, 
    -0.01130546f, 0.05056389f, 0.10729813f, -0.07165931f, -0.20371327f, 0.15360513f, -0.53259444f, 0.53527743f, 
    0.22091739f, 0.03840038f, 0.00289781f, -0.15365078f, 0.16762079f, -0.12721132f, -0.21049395f, -0.06367023f, 
    0.19696306f, 0.04968812f, 0.23189881f, -0.16317131f, -0.17065956f, -0.20724960f, -0.23885037f, -0.25524864f, 
    -0.15340956f, -0.11380662f, -0.01015358f, -0.12909326f, -0.15977974f, -0.30283904f, -0.35025859f, 0.10162168f, 
    -0.18749893f, -0.07030977f, 0.13580544f, 0.17260301f, 0.21569471f, 0.01517864f, 0.12644260f, 0.03442961f, 
    -0.12809829f, 0.23035853f, 0.35085526f, -0.10630479f, -0.09907618f, -0.10301759f, -0.25623849f, -0.10539453f, 
    0.19723532f, -0.07036160f, -0.01645667f, 0.10956406f, -0.60957974f, -0.10796509f, 0.04163464f, -0.06057996f, 
    -0.03253735f, -0.10766717f, -0.03440392f, 0.00192970f, 0.11871031f, -0.04237422f, -0.04317207f, 0.18996727f, 
    -0.00876142f, 0.30796605f, 0.30186117f, -0.00775481f, -0.07975336f, -0.19436483f, -0.22136971f, -0.01528518f, 
    -0.00588678f, 0.11318570f, 0.04221021f, 0.04242069f, 0.21529901f, 0.18094930f, -0.06634662f, -0.06577868f, 
    0.09811142f, 0.07533310f, 0.19362605f, 0.07773072f, -0.02006935f, -0.03953112f, -0.00836666f, 0.14621128f, 
    0.07887286f, -0.10059496f, -0.31734052f, -0.03315555f, 0.19797240f, 0.16645806f, -0.01875123f, -0.10093521f, 
    -0.27647960f, -0.15667371f, 0.06433176f, 0.06975713f, -0.07593817f, -0.10658917f, 0.08925395f, 0.00961963f, 
    0.14510645f, 0.04059667f, 0.06590467f, 0.16847070f, -0.05391054f, -0.00995208f, -0.05377413f, -0.10810903f, 
    0.21829128f, 0.11431452f, -0.10334548f, -0.25259978f, 0.08910481f, 0.01191121f, 0.07544112f, 0.18207102f, 
    0.05134753f, 0.14440677f, 0.08433664f, 0.17076474f, 0.22085889f, -0.28335783f, 0.00130114f, -0.37827265f, 
    0.21941501f, -0.01397322f, -0.18313168f, 0.24408308f, 0.28062999f, 0.21595104f, 0.01465463f, 0.41445363f, 
    0.28722715f, 0.14411046f, -0.15474567f, 0.32057443f, 0.02111442f, -0.11661910f, -0.16464297f, 0.03962891f, 
    0.06553277f, 0.08875244f, 0.11636095f, 0.25007257f, 0.07633381f, 0.36575520f, -0.28137383f, 0.69380772f, 
    0.09168041f, 0.06662336f, 0.24083364f, -0.38111150f, 0.06708617f, 0.13531439f, -0.02256322f, -0.17114940f, 
    -0.39582804f, -0.05810341f, 0.04414748f, 0.12709533f, -0.18991034f, 0.24112421f, -0.02232827f, 0.19575362f, 
    0.03763833f, -0.07051402f, -0.09409909f, -0.18720256f, 0.02098010f, -0.49920261f, -0.09561826f, -0.16589694f, 
    0.13045385f, 0.17895693f, 0.18155678f, -0.03585465f, -0.01179926f, 0.14250897f, 0.13127412f, 0.02416992f, 
    -0.21814528f, -0.19088930f, -0.07209078f, -0.17341299f, 0.28466651f, 0.21500456f, 0.11541715f, -0.00865568f, 
    0.04385770f, 0.06773572f, -0.03344747f, 0.12268146f, -0.09421426f, 0.28055277f, 0.53591454f, 0.19365461f, 
    0.01919777f, -0.08435767f, -0.17079151f, -0.17172246f, 0.08113526f, 0.10378507f, 0.00898026f, 0.24204043f, 
    0.02340579f, -0.08709095f, 0.11653046f, 0.11768880f, -0.15270756f, 0.00301843f, -0.05148634f, 0.04812390f, 
    0.24506173f, 0.40468216f, 0.25618017f, 0.34861240f, 0.51499671f, 0.22785155f, 0.03515245f, -0.23136318f, 
    0.06524774f, -0.03123330f, 0.05641968f, 0.04818606f, -0.00548383f, 0.16009563f, -0.13231559f, -0.09617753f, 
    0.25179806f, -0.04381879f, 0.19578241f, -0.07410376f, -0.05856604f, 0.05278441f, -0.13053440f, -0.12671581f, 
    0.14927596f, -0.04474453f, 0.04820700f, 0.03471784f, -0.03196668f, -0.19282299f, -0.04618089f, -0.12436264f, 
    0.15753654f, -0.28206506f, 0.07597464f, 0.07319783f, 0.06910878f, -0.18494046f, -0.09852745f, 0.02830037f, 
    0.17317462f, 0.19296752f, -0.01639161f, 0.08188432f, 0.02465323f, 0.00200645f, -0.02443919f, -0.03270797f, 
    0.11392120f, -0.02838302f, 0.14012899f, 0.15960672f, 0.28060010f, -0.22670625f, 0.19399601f, 0.35541642f, 
    -0.01998674f, -0.01557494f, 0.03355605f, 0.24455562f, 0.10766679f, 0.05637072f, -0.09319355f, -0.00568968f, 
    -0.07424311f, 0.17636767f, -0.01661299f, -0.15529405f, -0.12052144f, -0.13531180f, 0.10971137f, 0.05313807f, 
    0.09685368f, -0.04246491f, 0.02777360f, -0.01212987f, 0.05489580f, -0.27869430f, -0.10631073f, 0.22936592f, 
    0.18135192f, 0.07227553f, -0.03674667f, -0.16456404f, -0.11877881f, 0.01419916f, -0.09532978f, 0.16033708f, 
    -0.44845232f, -0.52830529f, -0.02137226f, -0.30688468f, 0.04725448f, 0.02274267f, -0.12959915f, 0.20461179f, 
    -0.17495996f, -0.10157325f, -0.00253793f, -0.20366651f, -0.14525165f, -0.19040543f, 0.00135409f, -0.20987082f, 
    -0.00050519f, -0.10355929f, -0.12217274f, -0.15898637f, -0.05928653f, -0.08439344f, -0.13180265f, -0.04098104f, 
    -0.05983883f, 0.17184724f, -0.12327532f, 0.10251754f, -0.19534695f, -0.11986543f, 0.21525493f, -0.17738447f, 
    -0.00141877f, -0.08352921f, -0.10441042f, -0.18217203f, 0.05989900f, -0.12716663f, 0.13947876f, -0.30380559f, 
    -0.10925183f, -0.02524240f, 0.02502153f, -0.09989074f, 0.09578813f, -0.02466855f, 0.20358129f, 0.16693701f, 
    0.07613914f, 0.24317142f, 0.09635694f, -0.23546895f, -0.03781627f, -0.05105567f, 0.23252365f, 0.06900991f, 
    0.20310265f, 0.05593590f, 0.01464921f, 0.26287216f, 0.51009876f, 0.21913521f, 0.35721484f, -0.09477936f, 
    -0.19160743f, -0.05907374f, -0.09201410f, -0.15435505f, -0.03863472f, 0.13851988f, 0.02469790f, -0.02872629f, 
    -0.23483096f, -0.20834026f, 0.28476328f, -0.03594933f, 0.10883006f, 0.00176880f, 0.09165204f, 0.09281584f, 
    0.07492571f, 0.13475472f, 0.08672215f, -0.06790958f, 0.44527000f, 0.37711763f, -0.03244194f, -0.23375316f, 
    0.02850950f, -0.37059551f, 0.07406220f, -0.09774437f, 0.09850078f, -0.00766388f, -0.08863657f, -0.04547346f, 
    -0.01477906f, 0.24044740f, -0.15321769f, 0.00595332f, -0.15085734f, -0.03404823f, 0.02480911f, -0.02447495f, 
    0.08863524f, -0.03394986f, -0.00375580f, -0.11785606f, 0.20953366f, -0.24671195f, -0.26409173f, -0.01045606f, 
    -0.02777444f, 0.11312637f, -0.03566149f, 0.07114697f, 0.04384927f, -0.04078782f, -0.14758803f, 0.07451979f, 
    0.20617191f, 0.33699718f, 0.02127664f, 0.43994206f, 0.04086873f, -0.00541865f, 0.11680713f, 0.10563364f, 
    -0.16275744f, 0.06897011f, 0.12764657f, 0.00001928f, -0.03514443f, -0.00586914f, -0.05622396f, 0.02982100f, 
    0.02801185f, 0.11870290f, -0.13173416f, 0.13591792f, -0.01014538f, 0.21743102f, -0.09077458f, 0.08992540f, 
    0.23351271f, 0.17888980f, 0.24072985f, -0.14667529f, -0.15160261f, 0.00896748f, -0.09394155f, 0.02121238f, 
    -0.18032773f, -0.04083456f, 0.09128933f, 0.13874471f, 0.17805174f, 0.27280134f, 0.14044182f, -0.03657138f, 
    0.03303730f, -0.00304345f, 0.00777737f, -0.16183655f, -0.26483527f, 0.07623127f, 0.10099502f, 0.03060250f, 
    0.12790856f, -0.19455303f, -0.05913275f, -0.09142318f, -0.09398785f, 0.04364052f, -0.25704414f, -0.34510896f, 
    -0.04640993f, -0.08264041f, -0.13413560f, -0.02810813f, -0.02236080f, 0.00630149f, 0.17541488f, 0.07883114f, 
    0.30717570f, 0.06445180f, -0.01348948f, 0.18884668f, 0.15326561f, 0.07985839f, 0.09742507f, -0.11626651f, 
    0.19426344f, 0.16817214f, -0.17454731f, -0.11196759f, 0.01414454f, 0.07145123f, 0.09828803f, -0.26216412f, 
    -0.23418976f, 0.01727342f, -0.07081975f, -0.01251036f, 0.07380838f, 0.26674259f, -0.10819533f, 0.43594125f, 
    0.36362389f, 0.41846392f, -0.14590701f, 0.15661132f, -0.07384870f, 0.07950483f, 0.00901968f, 0.11939535f, 
    0.47610274f, -0.01037070f, 0.49759200f, -0.06062745f, 0.07666001f, 0.06942026f, -0.08744425f, 0.07462496f, 
    -0.11823360f, 0.12182745f, 0.29401812f, 0.25543240f, 0.26989946f, 0.26575890f, -0.44960487f, 0.49749938f, 
    0.00547974f, 0.00766322f, 0.18749769f, -0.02726534f, 0.07045744f, 0.15810427f, 0.14143264f, 0.04105697f, 
    -0.01423834f, -0.41944358f, -0.04302233f, -0.22251382f, 0.07819570f, 0.02525681f, -0.25542223f, 0.20225576f, 
    -0.23905300f, 0.09988518f, 0.01682660f, -0.18993002f, -0.75758970f, 0.05402399f, -0.22952907f, 0.16711381f, 
    0.02481295f, 0.23859084f, 0.14935645f, 0.09394255f, 0.06730971f, 0.12701021f, 0.14780137f, 0.03999031f, 
    -0.36757275f, -0.14152145f, -0.08663802f, -0.10753037f, -0.14464262f, 0.23943827f, -0.15307960f, -0.09572910f, 
    -0.02802449f, 0.02139060f, 0.12468350f, -0.08092134f, 0.44588798f, -0.00899033f, 0.38867110f, 0.06379502f, 
    -0.11017156f, -0.03648632f, -0.04530731f, 0.00477043f, -0.07598940f, -0.03142183f, -0.05989355f, 0.18824007f, 
    0.27628356f, -0.05512912f, 0.00548469f, 0.09873877f, 0.07743763f, 0.17296529f, 0.06978460f, -0.11560553f, 
    0.11729988f, 0.19574392f, 0.20939520f, 0.10225035f, 0.01321158f, -0.06934518f, -0.00511256f, -0.47645658f, 
    -0.29928714f, -0.07795397f, -0.03883147f, 0.18384551f, -0.18983893f, 0.31698573f, 0.06037639f, -0.07252297f, 
    0.52250385f, 0.10859749f, -0.07466133f, 0.17149182f, -0.11824472f, 0.00374986f, -0.00133848f, -0.10627092f, 
    -0.00324150f, 0.08413009f, -0.09387637f, 0.10485323f, 0.30807033f, -0.00788405f, -0.02803717f, 0.09588760f, 
    0.15126741f, 0.07274683f, -0.12452328f, 0.13142164f, -0.15314160f, 0.00384666f, -0.01856391f, 0.01824696f, 
    0.05456670f, 0.19244078f, 0.12345925f, -0.03324277f, 0.08312185f, 0.15400445f, 0.09875675f, 0.01048240f, 
    0.18816313f, -0.00843997f, 0.08063240f, 0.14340284f, -0.21476659f, -0.21573809f, -0.05498440f, -0.24929002f, 
    0.11490702f, -0.01116924f, -0.13865156f, -0.06430359f, -0.01663867f, 0.10519699f, 0.15608701f, 0.02893058f, 
    -0.09340414f, 0.67066211f, 0.10071432f, -0.35025790f, -0.29414698f, -0.20805779f, 0.15974416f, 0.15804918f, 
    0.04006872f, 0.15408312f, -0.01323031f, -0.04040582f, -0.10764445f, 0.21623200f, -0.36504313f, -0.02970985f, 
    0.00737049f, -0.04416092f, -0.05282560f, 0.00873702f, 0.31849986f, 0.28473514f, 0.21847175f, 0.04526402f, 
    -0.19849609f, -0.45559520f, -0.19908032f, -0.05033617f, -0.21019199f, 0.02287311f, -0.22906354f, -0.00065753f, 
    -0.01712085f, -0.12790816f, -0.05675879f, -0.03847821f, 0.00271330f, 0.00677906f, 0.06697530f, 0.00807280f, 
    0.02673668f, -0.04981659f, -0.08357316f, 0.00207338f, -0.01023291f, -0.08465625f, -0.07458211f, -0.07545457f, 
    -0.20838396f, 0.38289419f, 0.11584178f, -0.17762612f, 0.10714795f, -0.05046522f, -0.00201122f, -0.08601419f, 
    -0.02995599f, -0.01144323f, -0.13605623f, -0.12305090f, -0.41162089f, -0.15749788f, 0.21617241f, -0.26088807f, 
    0.18354003f, -0.20867430f, -0.01947355f, 0.10457482f, -0.17923224f, 0.07059371f, -0.06325834f, 0.04391118f, 
    -0.03893432f, 0.09709483f, 0.37969220f, -0.35045102f, -0.03264738f, 0.08499862f, 0.18496118f, 0.16943027f, 
    -0.08555347f, 0.15973105f, 0.14093460f, 0.17670844f, 0.26997644f, 0.03056179f, 0.10648331f, 0.11524937f, 
    -0.01521823f, -0.22849190f, -0.25334942f, -0.14437236f, -0.43468681f, -0.10732908f, 0.22982290f, -0.07368062f, 
    -0.19084205f, -0.38895848f, -0.07521480f, -0.06285264f, -0.06355820f, -0.14407262f, -0.09972209f, 0.20745859f, 
    0.00868912f, 0.06050321f, -0.01826414f, -0.19018824f, 0.50957036f, 0.01738768f, 0.10693587f, 0.23279658f, 
    0.01901532f, -0.03761215f, 0.22054635f, 0.05365134f, -0.06322692f, 0.10545258f, -0.16285945f, 0.02990793f, 
    -0.58342081f, -0.21459347f, -0.17371365f, 0.04816628f, 0.07129973f, -0.11431301f, -0.12748635f, -0.05567396f, 
    0.02321922f, 0.12525755f, -0.08942367f, 0.29699352f, -0.68606913f, 0.64843798f, 0.38290939f, 0.04050527f, 
    0.08141677f, 0.07815181f, -0.02396557f, -0.13099915f, 0.20325065f, -0.08407686f, -0.09224273f, 0.29570091f, 
    -0.28175631f, -0.14311913f, -0.06358913f, 0.07751618f, 0.07088193f, 0.11894568f, -0.17925493f, -0.10807074f, 
    0.21913166f, -0.02809358f, 0.13325943f, 0.16710551f, -0.07699540f, -0.09552979f, 0.02885421f, 0.14391905f, 
    -0.00598603f, -0.08453367f, -0.21999528f, -0.01970377f, -0.03854148f, -0.10257386f, 0.07922284f, -0.18229781f, 
    -0.22377537f, -0.16249755f, -0.18780428f, -0.00910785f, 0.05730485f, 0.06688634f, -0.14455378f, -0.26286355f, 
    0.16841672f, -0.06560539f, -0.17320633f, 0.07582275f, 0.09385189f, -0.02313443f, 0.33472738f, 0.45606896f, 
    0.19847260f, -0.14715032f, 0.11518078f, -0.02264084f, 0.00006100f, 0.05573044f, 0.13858981f, 0.29933432f, 
    -0.01623561f, 0.01446714f, 0.17040350f, 0.22901472f, 0.07346632f, 0.18812428f, 0.05130621f, 0.14324445f, 
    -0.00179303f, 0.00462078f, -0.12486000f, 0.00057378f, 0.21853656f, 0.01985456f, 0.15519835f, 0.09134170f, 
    -0.17270759f, -0.03805861f, 0.27617699f, 0.01144313f, -0.12903722f, -0.08978550f, -0.12896334f, 0.06845861f, 
    -0.26405182f, 0.12090376f, 0.38873082f, 0.39094868f, -0.12179129f, 0.14296527f, 0.09119431f, -0.00786181f, 
    0.05405217f, 0.07156942f, -0.07352361f, 0.04784714f, -0.12852567f, -0.21558681f, -0.15956937f, 0.04323318f, 
    -0.00647534f, -0.09055921f, 0.00159227f, 0.10736877f, -0.07822122f, 0.03950013f, -0.22593667f, 0.19531128f, 
    0.22236976f, -0.02977478f, -0.10939523f, 0.28130800f, -0.18045165f, 0.01659315f, -0.37816575f, -0.12878554f, 
    0.09513805f, 0.04127017f, 0.09119080f, 0.11004230f, -0.14509282f, 0.22927582f, 0.26473349f, 0.20013654f, 
    0.04680667f, 0.13178222f, 0.19384493f, -0.04333462f, 0.07436937f, 0.17843468f, -0.16499086f, -0.05696793f, 
    -0.21625899f, 0.40926588f, -0.20104508f, 0.10954491f, 0.12160292f, 0.14510137f, 0.01093047f, -0.41708139f, 
    0.34092924f, 0.07190254f, 0.00199249f, 0.01197643f, 0.05782453f, 0.38737929f, 0.61113274f, 0.37334013f, 
    -0.01398176f, -0.02757786f, 0.09174261f, 0.06788503f, 0.01281081f, 0.01130383f, -0.02618420f, 0.22651583f, 
    0.09608763f, 0.21232744f, 0.29959330f, 0.25749496f, 0.12292138f, 0.01658902f, 0.04263641f, 0.01652533f, 
    0.08479180f, -0.04863189f, -0.09836409f, -0.10263535f, -0.55807650f, 0.07419825f, 0.36571860f, 0.09575269f, 
    0.04983404f, 0.08593924f, -0.08411921f, -0.14007595f, 0.08108507f, 0.01822353f, 0.19057535f, -0.07844175f, 
    -0.04678952f, 0.10857503f, -0.19708021f, -0.12993667f, -0.12327629f, -0.19550124f, -0.12470704f, -0.06278326f, 
    0.11677510f, 0.01777883f, -0.21861394f, -0.07072551f, -0.15845399f, 0.19875066f, -0.11019910f, 0.07658305f, 
    -0.03814530f, 0.02989734f, 0.00369621f, -0.24543349f, 0.21419592f, 0.05836241f, 0.01242223f, 0.23462260f, 
    -0.30298546f, 0.09526715f, 0.12091158f, 0.19171351f, -0.04804844f, -0.04408349f, -0.12721896f, -0.15005474f, 
    -0.05764892f, 0.04416911f, 0.08592124f, 0.03243174f, 0.40920734f, 0.22058149f, -0.00233419f, -0.01793557f, 
    -0.13725352f, 0.00311827f, -0.23339772f, -0.04803401f, 0.10897141f, 0.14018950f, -0.03284716f, -0.00865315f, 
    0.23463537f, 0.01592825f, 0.07473528f, -0.11289535f, 0.01205011f, -0.15084238f, -0.16606697f, -0.01591253f, 
    0.01212350f, 0.10576480f, 0.14854166f, -0.08683535f, 0.41640896f, 0.09386149f, 0.19970039f, 0.36541799f, 
    0.23371299f, 0.04965509f, -0.13318008f, -0.04553859f, -0.14316361f, 0.09463251f, 0.09005060f, 0.16245525f, 
    0.13665245f, -0.02326301f, 0.12988408f, 0.27303803f, -0.11263783f, -0.04398672f, -0.23772565f, -0.10094989f, 
    -0.08320075f, -0.06008616f, -0.07777479f, -0.03328386f, 0.22284535f, 0.18692738f, 0.40363723f, 0.33633503f, 
    0.14739323f, 0.01375089f, 0.07610143f, 0.01376212f, -0.07866633f, 0.09982640f, 0.04751037f, 0.12531383f, 
    0.00684013f, 0.26627284f, 0.24491845f, 0.29553470f, -0.08934046f, 0.07848667f, -0.04180167f, 0.10161037f, 
    0.07107756f, 0.01220281f, -0.11518946f, -0.04556292f, 0.05712895f, -0.06498443f, 0.10508878f, 0.23328534f, 
    0.19316332f, 0.00271201f, -0.19779699f, 0.13169749f, -0.02503761f, 0.15979926f, -0.26750377f, 0.10924137f, 
    0.42492798f, -0.14630398f, 0.44373426f, -0.15457523f, -0.00585715f, 0.04198322f, -0.31534654f, -0.01792658f, 
    -0.08414241f, 0.14394362f, -0.09188120f, 0.02031638f, 0.06543953f, 0.38711640f, -0.05829204f, 0.35272577f, 
    -0.13699131f, -0.00293439f, 0.19562474f, 0.03345305f, -0.09464349f, 0.20872676f, 0.06526453f, 0.09432619f, 
    -0.13013607f, 0.11427359f, 0.33268017f, 0.00832379f, 0.02899888f, 0.03395762f, -0.12756696f, -0.08000667f, 
    0.17493135f, 0.03185653f, 0.06691110f, -0.01376805f, -0.13913563f, 0.20811991f, 0.05736930f, 0.11137452f, 
    0.05822103f, 0.14759764f, 0.24592315f, 0.04588884f, -0.08598018f, 0.07273971f, -0.06500170f, 0.04887870f, 
    -0.16833743f, 0.13973503f, 0.43407834f, 0.37051940f, -0.00606016f, 0.07396953f, 0.19438484f, 0.04279778f, 
    -0.11713479f, 0.11268803f, 0.01399683f, 0.05461973f, 0.44499946f, 0.22360837f, 0.47571298f, 0.17332804f, 
    -0.04662592f, -0.18922307f, -0.29068878f, 0.04845595f, 0.08255532f, 0.17918521f, 0.02957904f, 0.06874602f, 
    0.07025442f, 0.22152311f, -0.07342052f, 0.00224934f, 0.08544542f, -0.09982826f, -0.21019311f, 0.01237005f, 
    -0.05369402f, -0.17023793f, -0.02407625f, -0.14110374f, -0.13511425f, -0.07666420f, -0.09060713f, -0.46740791f, 
    -0.13696693f, -0.15289651f, -0.09515296f, 0.17380796f, 0.12017491f, -0.01180788f, -0.12480347f, 0.09156510f, 
    0.45170745f, 0.21899332f, 0.06014695f, 0.24984491f, 0.10193907f, -0.03709813f, 0.00447939f, 0.10434495f, 
    -0.06485341f, 0.07932967f, 0.08510331f, -0.11277455f, 0.38397744f, 0.13412279f, -0.11771925f, -0.08986189f, 
    -0.02629235f, 0.10703227f, -0.13008666f, -0.05342954f, -0.25084504f, -0.05528210f, 0.17231171f, -0.05313732f, 
    0.03293027f, -0.16708353f, 0.14802302f, -0.05874682f, -0.17655316f, -0.04850238f, -0.03881600f, 0.02004234f, 
    -0.03508011f, 0.00553551f, 0.03499733f, -0.12882851f, -0.71983916f, 0.26885760f, 0.11800812f, -0.06997213f, 
    0.06568786f, -0.05859469f, -0.06019982f, 0.06955048f, 0.03064932f, -0.16859974f, 0.10581034f, 0.07438332f, 
    -0.01043237f, 0.31302676f, 0.38732481f, -0.07526945f, -0.09923729f, 0.09573852f, -0.04887689f, 0.11097040f, 
    0.11049236f, 0.08256739f, 0.03764171f, 0.01602678f, -0.14513969f, 0.30503580f, 0.13240196f, 0.13406631f, 
    0.13620605f, -0.15140221f, 0.09778209f, 0.05188978f, 0.29431757f, -0.11739054f, 0.22884500f, 0.03380636f, 
    -0.16760293f, 0.12933457f, 0.43925685f, 0.20323084f, 0.03047483f, 0.00740435f, 0.03832178f, 0.07014850f, 
    0.06489743f, -0.03541281f, 0.07467660f, -0.01658578f, -0.03637889f, 0.13467525f, 0.09610191f, 0.29251909f, 
    0.07873864f, 0.30079848f, -0.07923263f, -0.00140782f, -0.08807606f, 0.11625859f, -0.32417569f, 0.07222963f, 
    -0.06617498f, 0.07378700f, 0.50919908f, -0.04855289f, 0.17047274f, 0.06601385f, -0.07821707f, 0.12868543f, 
    0.01997129f, 0.21639736f, 0.03848239f, -0.04330021f, 0.19670728f, -0.31404209f, 0.37017086f, -0.19598687f, 
    0.04467755f, -0.12050749f, -0.11449942f, 0.44921532f, -0.12587510f, -0.04398227f, 0.24324316f, -0.09613100f, 
    -0.03054815f, -0.06658135f, 0.24488306f, -0.26151305f, 0.06911443f, 0.10282961f, -0.00612693f, -0.05652573f, 
    -0.01617955f, -0.14377092f, 0.04411577f, -0.17786463f, -0.18294989f, 0.06593108f, -0.05078400f, 0.05086918f, 
    -0.11947398f, -0.16237533f, -0.15401143f, 0.08996312f, -0.00558803f, -0.16526686f, 0.01576741f, -0.04762940f, 
    -0.09019939f, 0.25981694f, 0.30616006f, 0.10309038f, -0.07213369f, 0.04556327f, -0.01051613f, 0.16618899f, 
    0.08061238f, 0.03383661f, 0.04135549f, 0.11691687f, 0.57282752f, -0.03328187f, -0.04736115f, 0.08975420f, 
    -0.31106037f, 0.16720298f, -0.13827880f, 0.08094955f, -0.01393378f, -0.09062880f, -0.12845854f, 0.04203101f, 
    -0.27916005f, -0.09985312f, 0.03390041f, -0.02418522f, 0.12672456f, 0.03468269f, -0.07816240f, -0.05513721f, 
    -0.25593317f, -0.03988734f, 0.00279328f, -0.03426796f, -0.01862194f, -0.22434038f, 0.08391390f, 0.05166878f, 
    0.13439597f, 0.16236490f, 0.12276912f, 0.08843965f, -0.07429370f, -0.14384596f, 0.05100360f, -0.05036834f, 
    -0.22273363f, 0.14810579f, 0.06259304f, -0.33708081f, 0.01013346f, 0.02022686f, -0.00061688f, -0.00255771f, 
    0.12537511f, -0.05173833f, 0.06344326f, 0.03978956f, -0.26823318f, -0.12294440f, -0.24359542f, -0.15382344f, 
    0.07360869f, 0.08274315f, 0.14472204f, -0.25852492f, 0.00168267f, -0.01432991f, 0.08758383f, -0.10417858f, 
    -0.30214185f, -0.37070280f, -0.20950709f, 0.01107583f, -0.01666742f, -0.12810871f, -0.10225762f, -0.01646613f, 
    -0.15803707f, 0.07018903f, 0.00192010f, 0.04502646f, -0.22613843f, 0.11474514f, -0.20768599f, -0.21806102f, 
    -0.07815341f, 0.05131627f, 0.02456595f, 0.11400475f, 0.23904586f, -0.03353177f, -0.05781049f, -0.07507753f, 
    0.01440366f, 0.08912203f, 0.09631876f, 0.11018930f, 0.07782999f, 0.10972313f, 0.25292072f, 0.34553015f, 
    0.04240173f, 0.05222390f, 0.14660582f, 0.12383019f, -0.21839529f, -0.06295294f, 0.03630968f, -0.14254670f, 
    0.00345484f, -0.14979944f, 0.09421612f, 0.02080228f, 0.27806890f, -0.19001682f, -0.09502520f, -0.10309622f, 
    -0.11227068f, 0.09377618f, 0.23164733f, 0.09135565f, 0.06713541f, 0.01161603f, 0.25283238f, 0.33227473f, 
    0.00372221f, 0.15540479f, 0.15182847f, 0.08551642f, -0.15080278f, 0.06225216f, 0.20387734f, -0.17942654f, 
    -0.24230729f, 0.22465681f, 0.19768481f, -0.07852792f, 0.13309759f, 0.00817264f, 0.17900822f, 0.27091214f, 
    -0.29301929f, -0.02740377f, -0.17761850f, 0.27558550f, 0.12929578f, -0.14392079f, 0.05543652f, -0.08389101f, 
    0.15718535f, -0.01794741f, 0.21695131f, 0.08638027f, 0.34921059f, -0.23555437f, 0.06324787f, -0.18956886f, 
    0.15975130f, 0.16105221f, -0.13536558f, 0.15330635f, 0.12181303f, -0.30245799f, 0.07697894f, 0.04055108f, 
    0.24233389f, 0.03561571f, -0.15503258f, 0.07867476f, 0.08212570f, 0.03818204f, 0.05899544f, 0.01904431f, 
    -0.23817316f, -0.22023891f, 0.03807252f, -0.09854625f, 0.09977171f, 0.15491134f, 0.08135250f, -0.01289693f, 
    -0.02731306f, 0.03500556f, -0.09577670f, -0.00288177f, 0.33292478f, 0.18923001f, -0.00749181f, 0.16141024f, 
    0.14562894f, 0.30206448f, -0.11095771f, 0.06093459f, 0.11884715f, -0.01052800f, 0.16979663f, 0.21006306f, 
    0.33055195f, -0.08625088f, 0.05003550f, 0.11903696f, -0.40309450f, -0.07293710f, -0.47932869f, 0.09765239f, 
    0.06069910f, 0.15062302f, 0.00247566f, -0.12754349f, 0.00459146f, -0.16959551f, 0.09412966f, 0.01108700f, 
    -0.04706204f, 0.04028730f, 0.03816740f, 0.05915895f, -0.01283635f, -0.00746306f, -0.01261426f, 0.00466297f, 
    0.01017472f, 0.03719588f, 0.02390251f, 0.03444802f, -0.02138904f, -0.07424906f, 0.03457464f, -0.07626605f, 
    -0.04849627f, -0.05794406f, 0.02915524f, -0.03433058f, -0.03433266f, 0.02739802f, -0.05887793f, 0.05089442f, 
    -0.04527294f, 0.01031790f, -0.03505963f, 0.02914493f, -0.00589564f, -0.03113245f, -0.04212127f, 0.02582317f, 
    -0.00530774f, 0.01404097f, -0.05904333f, -0.03143725f, -0.03202787f, 0.03501828f, -0.03337346f, -0.06790343f, 
    0.02326894f, -0.04425439f, -0.01506405f, -0.03154592f, 0.01463402f, 0.04330267f, -0.02451305f, -0.03873889f, 
    -0.04283391f, 0.02736318f, 0.04414381f, -0.03527429f, -0.07325457f, 0.03057703f, 0.05165525f, -0.06375658f, 
    -0.02475904f, -0.04507991f, -0.04739328f, -0.07675888f, 0.02948617f, 0.06150025f, -0.04488578f, 0.00673576f, 
    0.02960088f, 0.00698252f, 0.00574452f, -0.00319499f, 0.05849700f, 0.03139488f, -0.06538085f, -0.00280452f, 
    -0.03057367f, 0.01939682f, -0.07128724f, -0.03231458f, -0.02650547f, -0.02219537f, -0.06484962f, -0.03935796f, 
    0.04990903f, -0.00792308f, -0.03894288f, 0.04952454f, 0.00174259f, 0.05188206f, 0.03268112f, -0.00884811f, 
    -0.01852614f, 0.03475121f, -0.00042120f, 0.06092696f, -0.01401416f, 0.03548270f, 0.05360174f, 0.02852370f, 
    -0.04681516f, 0.02867150f, 0.02943694f, 0.02190304f, 0.06471889f, 0.03204640f, -0.05222167f, -0.06734131f, 
    -0.03488125f, -0.06636480f, -0.06742592f, 0.05571566f, -0.02514972f, 0.01027749f, 0.02576992f, 0.03531844f, 
    0.03859817f, 0.04039123f, 0.02769681f, -0.05787820f, -0.06814972f, -0.03067318f, 0.05564591f, 0.06557269f, 
    0.01764426f, 0.02660670f, 0.01326674f, -0.07043461f, -0.02811892f, 0.01206111f, 0.06437607f, -0.03207007f, 
    -0.03725512f, 0.03566044f, 0.02250541f, 0.01993486f, -0.06182247f, -0.06166879f, -0.07654051f, 0.05345484f, 
    -0.04395791f, 0.01183982f, -0.01910675f, 0.01614708f, -0.06256329f, 0.04229176f, 0.02515239f, -0.05380111f, 
    -0.04483987f, 0.01814960f, -0.00520947f, -0.04208899f, 0.01179085f, -0.06782437f, 0.04442663f, 0.00333624f, 
    0.02057529f, -0.03064498f, -0.00362180f, -0.07032304f, 0.02846837f, 0.06561998f, 0.01517142f, 0.00156368f, 
    -0.05163388f, 0.03378932f, 0.00046207f, 0.01845265f, 0.02486735f, -0.05364227f, -0.00987084f, -0.06210491f, 
    -0.00145633f, -0.05637703f, -0.05803142f, -0.03198847f, -0.04161289f, 0.00462990f, -0.04855731f, -0.02795295f, 
    -0.03557607f, -0.04886150f, -0.07434870f, 0.06299969f, 0.00486616f, 0.00457331f, 0.01965157f, 0.00975437f, 
    0.02888564f, -0.01976372f, -0.04635624f, 0.03982725f, -0.07113013f, -0.03695437f, -0.04558965f, 0.04472203f, 
    -0.03746778f, 0.04387057f, 0.04103915f, -0.01919387f, -0.00058017f, 0.05916099f, 0.05904333f, -0.05913225f, 
    -0.03706455f, 0.04126607f, 0.01455588f, -0.01931000f, -0.03479837f, 0.03628055f, 0.01361465f, -0.05861388f, 
    0.04695313f, 0.05301626f, 0.04123296f, 0.01848217f, -0.07631238f, -0.08023822f, 0.04217258f, 0.05147668f, 
    0.04615160f, 0.02450860f, -0.05318269f, -0.01971247f, -0.01441176f, -0.07558294f, 0.04051671f, -0.01749379f, 
    -0.01460968f, -0.04301346f, 0.05178547f, 0.05803228f, -0.01690851f, -0.00094893f, 0.02956600f, -0.01180097f, 
    -0.00203049f, -0.00558354f, -0.08514214f, -0.07307349f, 0.00018051f, -0.04155331f, -0.07605118f, -0.02175171f, 
    0.01753844f, -0.02977926f, -0.06259830f, 0.04094640f, 0.00149876f, 0.01646084f, 0.01325180f, 0.02444777f, 
    0.01053625f, -0.06965769f, -0.07893074f, -0.05544381f, 0.02788499f, 0.01766711f, 0.04545715f, 0.04561512f, 
    0.04029927f, -0.00927927f, -0.01187071f, -0.03560402f, 0.03833481f, -0.00636720f, 0.01614810f, -0.00418574f, 
    -0.01672708f, 0.05883612f, -0.02678423f, -0.06274667f, -0.02362450f, -0.00876340f, -0.04912384f, -0.05347785f, 
    -0.05709106f, 0.01067952f, -0.06473479f, -0.01680778f, -0.01635486f, 0.02281079f, -0.02334758f, -0.05808680f, 
    -0.04499597f, 0.03372720f, -0.05635951f, -0.01808291f, 0.05995024f, -0.00534080f, -0.04977389f, -0.01048601f, 
    -0.04658624f, 0.05026847f, -0.04767503f, 0.04453661f, -0.02025438f, -0.03935728f, 0.03366073f, 0.03968681f, 
    0.02993786f, -0.04868177f, 0.02660610f, -0.07688998f, 0.02221097f, -0.06118346f, -0.05191574f, -0.09220909f, 
    0.02760302f, 0.00587139f, 0.02226195f, 0.02955290f, 0.02368427f, 0.00266365f, -0.01385780f, 0.04143331f, 
    -0.06339200f, 0.04002425f, -0.07164508f, -0.04700924f, 0.03305835f, -0.00022051f, 0.05154182f, -0.02452260f, 
    0.01584358f, -0.02497335f, 0.01550788f, -0.04627302f, 0.04873097f, -0.00272441f, -0.03935604f, 0.02876236f, 
    -0.08080112f, -0.07837050f, -0.01963029f, 0.05424479f, -0.04672600f, -0.06545120f, -0.03443086f, 0.03282264f, 
    -0.04758203f, -0.05097609f, -0.03808962f, 0.03456547f, 0.02401735f, -0.03617543f, -0.02199261f, -0.04654890f, 
    -0.03133421f, -0.04390592f, 0.03645273f, -0.05773328f, 0.01620723f, -0.01272449f, 0.00279598f, -0.01166913f, 
    -0.02047068f, 0.03840355f, 0.03428483f, -0.05511034f, 0.00080035f, -0.00450593f, -0.07103306f, 0.02034215f, 
    -0.00207968f, -0.03127685f, 0.01755465f, -0.00292883f, -0.02327417f, 0.00279311f, -0.02777995f, -0.04827008f, 
    0.06452636f, -0.05946699f, -0.03877859f, -0.01071974f, -0.03479716f, -0.05074091f, -0.02305089f, -0.06558899f, 
    -0.06402064f, -0.01463234f, -0.02894851f, -0.07353449f, 0.05599584f, 0.02102598f, -0.07539871f, -0.07269339f, 
    0.16676269f, -0.00527403f, 0.02230661f, -0.12428977f, 0.06144582f, -0.07358988f, 0.11250419f, 0.04250517f, 
    -0.24769875f, -0.15859050f, -0.03982487f, -0.23757985f, -0.24844456f, 0.20970224f, -0.02359863f, 0.06160944f, 
    -0.07149297f, -0.00484804f, 0.06760833f, 0.29999197f, 0.20854892f, -0.08377743f, 0.11052386f, 0.04756156f, 
    0.37774560f, 0.12884878f, -0.08318310f, 0.06289910f, 0.14447385f, -0.07154583f, -0.00925795f, -0.03483378f, 
    0.21296246f, 0.19901037f, -0.00226513f, -0.03305195f, -0.16040304f, -0.08245641f, 0.17494929f, -0.01693115f, 
    0.14379558f, 0.31094456f, 0.23759095f, 0.28755340f, 0.09119887f, -0.02918829f, -0.02111647f, -0.02229244f, 
    -0.10888972f, 0.09546061f, 0.10838863f, 0.11583281f, -0.09540763f, 0.15690945f, 0.13121274f, -0.05358646f, 
    -0.08281025f, -0.02884596f, -0.09190067f, -0.12455545f, -0.42560861f, -0.30708286f, 0.02940342f, -0.19314456f, 
    0.09334958f, -0.07646166f, 0.35635465f, 0.14934584f, -0.08069751f, 0.05337809f, 0.17448339f, -0.06393162f, 
    -0.17872392f, -0.06913311f, -0.00939615f, 0.04487781f, 0.23050433f, 0.09583737f, 0.20514451f, 0.11167701f, 
    -0.03302206f, -0.08751506f, -0.04360515f, -0.04592654f, -0.01112884f, -0.15766194f, 0.01648433f, -0.07249894f, 
    -0.13504381f, 0.01919262f, 0.27467442f, 0.42832348f, -0.08835395f, -0.11212758f, -0.01173714f, -0.03986039f, 
    -0.12933497f, -0.19338520f, -0.07634905f, 0.11030578f, 0.24127239f, 0.01404605f, 0.04987253f, -0.21081828f, 
    -0.04309389f, 0.03168363f, 0.04481835f, 0.03460688f, 0.16815768f, -0.33662197f, 0.08014134f, -0.08459141f, 
    0.08462961f, -0.20318678f, -0.01301283f, 0.13589601f, 0.11174633f, 0.10062662f, 0.24774261f, 0.12352744f, 
    0.17144950f, 0.22033639f, -0.10107222f, 0.04049422f, -0.11827100f, 0.04568322f, -0.09332930f, -0.04261138f, 
    -0.04954528f, 0.13258077f, 0.22932033f, -0.04090807f, -0.32771000f, 0.19869813f, 0.04959108f, 0.24605894f, 
    0.07055977f, 0.10274440f, 0.05013303f, 0.20608078f, 0.08205508f, 0.26018199f, -0.11874091f, -0.07781338f, 
    0.05813214f, 0.20099843f, -0.06379441f, 0.18690243f, -0.17193064f, 0.02795023f, 0.22119823f, -0.08812075f, 
    0.04631057f, 0.06533474f, -0.00204897f, -0.14046948f, 0.14720894f, -0.41275284f, -0.13481091f, 0.14555140f, 
    0.08541409f, -0.01860478f, 0.03518625f, 0.00331497f, 0.21757537f, 0.05653735f, 0.29186329f, 0.18329725f, 
    -0.13966076f, 0.07736871f, -0.23827702f, -0.01716594f, 0.11565465f, -0.16461834f, -0.13025305f, -0.02267661f, 
    0.08174098f, 0.07732346f, 0.19751300f, 0.04948832f, -0.39002961f, 0.04576859f, 0.33019045f, 0.05002971f, 
    0.05934222f, -0.00412776f, 0.06401382f, -0.04611323f, 0.08492131f, -0.04865382f, -0.12463618f, 0.01305226f, 
    0.25887853f, -0.18124922f, 0.07245287f, 0.12781258f, 0.10185003f, -0.01914188f, 0.15123491f, 0.10723325f, 
    0.19528110f, 0.18709731f, 0.12723544f, 0.20014231f, -0.17024517f, 0.16467838f, -0.19791709f, 0.17217046f, 
    0.03636966f, 0.04133870f, -0.03178240f, 0.15213798f, -0.03947033f, 0.00094484f, 0.06525224f, -0.14075510f, 
    0.46229595f, -0.07734104f, -0.19455260f, -0.03455153f, 0.12295726f, -0.08481579f, 0.12377070f, 0.06450601f, 
    0.11259897f, 0.04441345f, -0.02493259f, -0.07690252f, 0.28865993f, 0.19774435f, 0.03310056f, 0.06839963f, 
    -0.13762623f, -0.11834584f, -0.01313259f, 0.22320108f, 0.04295444f, -0.03919817f, 0.03866073f, -0.17624006f, 
    -0.03044244f, -0.04840082f, 0.00123811f, 0.18852444f, 0.05565004f, 0.08807676f, 0.03154096f, -0.11822038f, 
    0.08039837f, 0.01274696f, -0.00160816f, -0.11840434f, -0.27474433f, -0.36218640f, -0.23466137f, -0.26224324f, 
    -0.11983103f, 0.12853785f, 0.13542125f, 0.24428341f, 0.04540142f, 0.08416817f, 0.03036137f, 0.07848430f, 
    0.14333075f, 0.22848053f, 0.05545301f, 0.08198614f, 0.26670647f, -0.02372343f, 0.14974277f, 0.13151155f, 
    0.12050030f, -0.03477138f, -0.04210667f, -0.01401226f, -0.07563931f, 0.26327983f, -0.09714442f, -0.11086972f, 
    -0.30056542f, -0.01109023f, 0.11844911f, 0.12423338f, -0.05321564f, 0.02116909f, -0.03336681f, 0.18004943f, 
    0.14920971f, 0.10891515f, 0.02876907f, 0.22010086f, 0.16354373f, 0.04501029f, -0.02169803f, -0.15675591f, 
    -0.02557709f, -0.00180328f, 0.07172859f, -0.04867680f, -0.03097685f, 0.14288320f, 0.20335869f, -0.02774649f, 
    -0.10993705f, -0.10088784f, 0.05786846f, 0.02269062f, -0.08731077f, -0.20567653f, 0.12871748f, -0.14017570f, 
    -0.23905580f, 0.32710990f, -0.00074298f, -0.22299086f, -0.06605513f, 0.12057877f, 0.09475474f, 0.09933859f, 
    0.00233633f, 0.00158235f, 0.06075914f, -0.22249934f, -0.23995431f, -0.33020049f, 0.28306624f, -0.31742895f, 
    -0.16640067f, -0.01850921f, 0.06898809f, 0.15262336f, 0.04371238f, -0.01600470f, -0.09343096f, 0.12883112f, 
    0.19523977f, -0.05480350f, -0.08959832f, 0.23784214f, -0.05941468f, 0.11616413f, 0.17275150f, -0.00971121f, 
    -0.01913233f, -0.07319433f, 0.13300087f, -0.00279674f, 0.43445581f, -0.13344628f, -0.34578913f, -0.07267318f, 
    0.12790851f, -0.12651101f, -0.12874901f, 0.05204711f, 0.06392168f, -0.01177864f, 0.04678837f, 0.10745129f, 
    0.33705154f, 0.22743413f, -0.26977196f, 0.13699068f, -0.03433341f, -0.11998046f, 0.02138829f, -0.05605470f, 
    -0.05940952f, 0.10953043f, 0.14359915f, -0.07146282f, 0.13733575f, 0.14605978f, -0.45655137f, 0.07060801f, 
    0.18754114f, 0.06094592f, 0.06114119f, -0.03124273f, 0.11999317f, -0.05110276f, 0.03219916f, -0.05071002f, 
    0.06847955f, -0.05841747f, -0.07994071f, -0.02148481f, 0.01263294f, 0.04732051f, 0.06509636f, 0.04774375f, 
    -0.01226037f, -0.07440978f, -0.03739360f, 0.01771710f, -0.04615377f, 0.02070992f, 0.05650189f, -0.04905153f, 
    -0.03605337f, -0.04185449f, 0.01229820f, -0.04550880f, -0.02006923f, -0.07570459f, -0.05598056f, 0.03865889f, 
    -0.02522337f, -0.04336656f, 0.05279313f, -0.02696860f, 0.04318279f, -0.02642388f, 0.07008454f, 0.04104175f, 
    0.03194217f, -0.07204664f, 0.01243667f, -0.02473995f, -0.07708295f, -0.04552676f, 0.04943255f, -0.07144129f, 
    -0.06312181f, -0.00163156f, -0.04001713f, 0.03012954f, -0.06513523f, 0.00505966f, -0.05909199f, 0.00145932f, 
    0.00631239f, -0.02678414f, 0.05417165f, 0.01316097f, -0.07301620f, -0.06188127f, -0.03414426f, -0.03541436f, 
    0.01998145f, 0.03582506f, 0.05955689f, -0.05855509f, 0.02015320f, 0.00632443f, -0.03945984f, 0.06353278f, 
    -0.01555746f, -0.07073649f, -0.03264766f, -0.01338193f, -0.07628293f, 0.00464023f, -0.00746873f, -0.00445002f, 
    -0.02156378f, -0.02402601f, 0.06106320f, -0.06001728f, 0.04782734f, 0.06088363f, 0.05748376f, 0.01050584f, 
    -0.07656953f, -0.01093094f, 0.02119338f, -0.04275700f, -0.04115494f, -0.00109731f, 0.05746549f, 0.03173360f, 
    -0.03194760f, 0.01436292f, -0.00824783f, -0.06903195f, 0.01174631f, 0.04903690f, 0.00207851f, -0.04801116f, 
    -0.01092877f, -0.00413874f, 0.06219409f, -0.03486644f, 0.05514617f, -0.02934024f, -0.06035297f, -0.01335334f, 
    0.01839998f, -0.01139011f, -0.00481688f, 0.00503378f, 0.00648979f, -0.05442595f, -0.02350836f, -0.06906319f, 
    -0.01239179f, 0.05821455f, 0.03466117f, -0.02085214f, -0.03086936f, 0.00493191f, -0.00535259f, 0.04131197f, 
    -0.02501949f, 0.04206138f, 0.01509610f, -0.01734998f, -0.06964806f, -0.02688243f, 0.03302889f, 0.03883633f, 
    -0.06192876f, -0.05272328f, 0.05786748f, -0.05131845f, -0.01133385f, 0.05787842f, -0.04744604f, -0.00109771f, 
    -0.07887816f, 0.00462834f, 0.05537773f, 0.01939048f, 0.03856149f, 0.01207412f, -0.06387594f, -0.01332611f, 
    0.03899140f, -0.06776431f, 0.04435170f, -0.06535456f, 0.00325198f, -0.07003450f, -0.04923683f, -0.00457588f, 
    0.05303555f, 0.06068684f, 0.01045838f, -0.06474967f, -0.02985091f, 0.03408612f, 0.04791347f, -0.05666909f, 
    -0.05586984f, -0.02643739f, -0.03637620f, -0.03599980f, 0.02448639f, -0.05802778f, 0.03186104f, 0.04637898f, 
    0.01204516f, -0.06073784f, -0.05203844f, 0.05276978f, -0.06718298f, 0.04657720f, 0.04226407f, 0.02899718f, 
    -0.04619426f, -0.03676026f, 0.06537513f, -0.06812882f, 0.04360450f, 0.05644216f, 0.02860929f, -0.07022679f, 
    0.00547180f, -0.02180633f, -0.05536327f, 0.05944662f, -0.02798923f, -0.01939298f, -0.00996707f, -0.05496781f, 
    -0.29989114f, -0.17166959f, -0.33886734f, -0.00045552f, -0.16522877f, -0.13170148f, -0.14377761f, -0.00107084f, 
    -0.08626588f, -0.08913453f, 0.09414269f, -0.18400235f, 0.60752660f, 0.18611401f, 0.04198408f, -0.49731004f, 
    -0.09598520f, -0.16512854f, 0.14388920f, 0.09167695f, 0.14483374f, 0.13665633f, 0.21692474f, 0.05840467f, 
    0.38851571f, 0.00120676f, -0.19966194f, 0.07615290f, 0.01763352f, -0.00472981f, -0.00444852f, 0.00011403f, 
    0.19750208f, 0.12908888f, 0.04100183f, -0.03801453f, -0.10298420f, -0.24452646f, -0.23188241f, -0.35520297f, 
    0.07730264f, 0.14795581f, 0.11100061f, 0.02366061f, 0.15597896f, 0.02305416f, -0.01174526f, 0.13450740f, 
    0.07197262f, -0.06658040f, -0.16492149f, -0.05444691f, 0.00528212f, 0.03148956f, 0.01577516f, 0.00928536f, 
    0.10281885f, 0.05613112f, 0.20145629f, 0.16225652f, -0.38751161f, 0.27002439f, 0.30021960f, 0.17905913f, 
    0.13667171f, -0.08850847f, -0.03817196f, -0.05088177f, -0.01372164f, -0.08446636f, -0.03726693f, 0.08134191f, 
    -0.18608943f, 0.07418698f, 0.02681092f, -0.17539753f, -0.15975517f, -0.06877839f, -0.00295570f, -0.07461838f, 
    0.08345371f, 0.07462731f, 0.12641171f, 0.05112074f, -0.14929599f, -0.18275528f, 0.00411070f, 0.21254262f, 
    0.14104244f, 0.08185148f, 0.03737590f, 0.05984628f, 0.15398774f, -0.12024391f, 0.16012672f, 0.02850601f, 
    -0.38536319f, -0.24854080f, 0.08615216f, -0.04282594f, 0.03314662f, 0.02951486f, 0.03692766f, 0.08852683f, 
    -0.03840600f, 0.02313739f, 0.03740234f, -0.03069617f, -0.04668352f, -0.35462195f, -0.34503150f, 0.26155254f, 
    0.12923525f, 0.14782003f, 0.13190162f, 0.31920621f, 0.16538103f, 0.06569976f, -0.06842796f, 0.22713484f, 
    0.01215093f, -0.05579451f, -0.02822953f, 0.09852218f, 0.16345067f, -0.18024386f, -0.01587197f, -0.11688203f, 
    -0.01438187f, 0.08162917f, 0.03712628f, -0.02824922f, 0.34836024f, -0.02499428f, 0.02365204f, -0.18146971f, 
    0.06543913f, 0.02386007f, -0.20747468f, 0.04193064f, 0.00052531f, 0.11918498f, 0.24272603f, 0.28634241f, 
    0.24964663f, 0.25792310f, 0.08420456f, -0.27379838f, -0.10518212f, -0.10035665f, 0.17111841f, 0.03251589f, 
    0.11049956f, 0.16599426f, 0.04761127f, 0.08424165f, 0.05919032f, 0.38332441f, 0.38873792f, 0.30594406f, 
    -0.11262789f, -0.08067098f, -0.18240786f, 0.04907138f, 0.14501138f, 0.03253520f, 0.13213517f, 0.04487009f, 
    -0.24801075f, -0.13321915f, 0.28176382f, -0.37699524f, 0.00673906f, 0.02497264f, -0.13032994f, 0.06641029f, 
    0.06490757f, 0.08971543f, 0.10132194f, -0.01740468f, 0.27225974f, -0.03203832f, -0.00065777f, -0.30329412f, 
    -0.23408175f, -0.00344623f, 0.05809616f, -0.03903477f, -0.02586424f, -0.11740804f, -0.04461873f, 0.07109852f, 
    -0.13629003f, 0.03071497f, 0.11130944f, 0.20687932f, 0.03897220f, 0.07914018f, -0.07243466f, -0.06133031f, 
    0.10354810f, -0.02105297f, 0.09709519f, 0.04749715f, 0.21924882f, -0.20601447f, -0.03229181f, -0.24903847f, 
    0.03246444f, -0.14112154f, -0.12895070f, 0.12028860f, 0.10629029f, 0.10718079f, 0.05499789f, -0.03546140f, 
    0.41522139f, 0.23562437f, 0.02221447f, 0.13244636f, -0.07872287f, 0.00344964f, 0.09478910f, 0.02340600f, 
    0.01232637f, -0.02573456f, 0.04916359f, -0.00144885f, 0.12380885f, -0.04462637f, -0.20996870f, -0.08422555f, 
    0.25900248f, 0.05907499f, 0.08071317f, -0.03880831f, -0.11180367f, -0.06683607f, 0.03377432f, -0.05347209f, 
    0.12266883f, -0.07070268f, 0.01695890f, 0.14112444f, -0.05299807f, 0.00529803f, 0.00741084f, 0.14293560f, 
    -0.00306553f, -0.07489599f, 0.04449851f, -0.00706405f, -0.46363902f, 0.08938269f, -0.03826459f, -0.18251047f, 
    0.02591552f, 0.04373207f, -0.04688229f, 0.05476164f, 0.07067625f, -0.17365220f, -0.20724802f, 0.01296708f, 
    -0.01785611f, 0.24419731f, 0.21745929f, 0.09473798f, 0.03657253f, 0.10936996f, 0.10899989f, 0.18928593f, 
    -0.03885175f, 0.02052659f, 0.09161857f, 0.14027371f, -0.22102940f, 0.19003572f, 0.03075238f, 0.05929380f, 
    0.14539830f, 0.07324215f, 0.18195502f, 0.16105586f, -0.03294516f, -0.09805416f, 0.07338391f, -0.05080448f, 
    -0.13995814f, 0.08883939f, 0.30569783f, -0.01271364f, 0.10340678f, 0.03534950f, 0.14978136f, 0.15206350f, 
    -0.15627357f, -0.14861631f, -0.03087707f, -0.03407294f, -0.32867554f, 0.22069752f, 0.03217835f, -0.07374269f, 
    -0.16120961f, 0.16188619f, 0.14499912f, -0.08892610f, -0.05000841f, -0.11169125f, -0.02396318f, 0.06738170f, 
    -0.19236389f, 0.00958050f, 0.10936583f, 0.28075540f, 0.08460349f, -0.12401906f, 0.20854533f, 0.10257907f, 
    0.15207914f, -0.03929557f, 0.05924204f, 0.09221139f, 0.28404394f, -0.36614645f, 0.38815105f, -0.37248293f, 
    0.15245049f, -0.03933358f, -0.29169464f, 0.25185567f, 0.12609753f, -0.21382925f, 0.15423523f, -0.15589048f, 
    0.10016842f, -0.19204116f, -0.06475508f, -0.08951941f, -0.04419192f, 0.01515885f, -0.09532160f, -0.00940539f, 
    -0.06356198f, -0.19378583f, -0.24617788f, -0.21198033f, 0.03220527f, 0.14810070f, 0.06987237f, -0.28352901f, 
    -0.22559376f, -0.14724588f, -0.17094886f, 0.05254930f, 0.02753303f, -0.03009178f, 0.03078058f, -0.04228735f, 
    0.19116764f, 0.22830196f, 0.06078202f, 0.03461641f, 0.02281071f, 0.04673014f, 0.11764068f, 0.28759199f, 
    0.12387015f, -0.00664763f, -0.05527559f, 0.04967141f, 0.31872788f, 0.10987589f, -0.53302348f, 0.14781739f, 
    -0.23922727f, 0.02971261f, 0.08440812f, 0.06932815f, 0.08279179f, -0.10137037f, -0.01293327f, 0.15032192f, 
    0.05919635f, -0.07195614f, -0.07163041f, -0.00914018f, -0.01959048f, 0.04062958f, -0.03179839f, -0.02384090f, 
    0.03225345f, -0.06803615f, 0.02176617f, 0.04862965f, 0.04059588f, -0.05666107f, 0.02143751f, -0.00521447f, 
    -0.00428248f, -0.00545506f, 0.02184513f, -0.02295890f, 0.03703204f, -0.00121196f, 0.03423087f, -0.07501236f, 
    -0.03108452f, 0.02353782f, -0.03108517f, -0.00986451f, -0.04565320f, 0.00002189f, -0.03822372f, -0.06249231f, 
    0.03518703f, -0.06526829f, -0.02159279f, 0.01554331f, -0.05643251f, -0.03493005f, 0.01097920f, 0.00585042f, 
    0.03224196f, 0.00614233f, 0.01867628f, 0.06039983f, 0.02742419f, 0.03540972f, -0.04119587f, -0.07496817f, 
    0.01160185f, 0.00780422f, -0.01382131f, -0.05975707f, -0.04106664f, -0.01328138f, -0.01576700f, 0.00256161f, 
    0.04572381f, -0.00864954f, -0.06865118f, 0.02903306f, -0.06070799f, 0.01781463f, 0.06042863f, 0.02398488f, 
    0.06590847f, 0.05701477f, 0.00641828f, -0.00010093f, 0.03868503f, -0.02207114f, 0.00512118f, -0.06824759f, 
    -0.02961913f, -0.04617874f, -0.05540875f, -0.06388031f, 0.06349126f, -0.02826037f, 0.04405002f, 0.03624966f, 
    -0.02273352f, -0.03907745f, -0.00941280f, 0.06160189f, 0.03454835f, -0.02390955f, 0.00608754f, -0.04262941f, 
    -0.01516431f, 0.03191341f, 0.01407540f, -0.04343845f, 0.01013687f, -0.05589919f, -0.04534279f, -0.02328209f, 
    0.00822141f, -0.01556282f, 0.02482218f, -0.00783175f, 0.05042943f, -0.07701102f, 0.02761691f, -0.07893319f, 
    -0.03273258f, -0.07323843f, 0.04946136f, 0.02341294f, 0.05695765f, -0.00326729f, -0.00119909f, -0.01981656f, 
    -0.05560052f, -0.07047608f, -0.04737150f, 0.03644667f, 0.01937527f, 0.04743013f, -0.02915100f, -0.07575991f, 
    0.06223660f, 0.03443279f, 0.00906892f, 0.02342542f, 0.01782728f, 0.02506027f, 0.02991168f, 0.00074878f, 
    -0.05730459f, -0.05538344f, 0.05138440f, 0.05295266f, -0.04543962f, -0.02157743f, 0.00858391f, -0.06519056f, 
    0.00265949f, -0.04867253f, -0.01051596f, 0.03187685f, -0.05620563f, -0.00017630f, -0.01389193f, -0.07391415f, 
    -0.04709359f, -0.06729849f, -0.06752816f, -0.03393565f, -0.00997803f, 0.01303824f, 0.06778760f, 0.04535388f, 
    -0.01236968f, -0.00285280f, 0.05515144f, -0.02147998f, -0.00288052f, -0.04527105f, -0.07369114f, 0.01663505f, 
    -0.03042609f, 0.05548549f, 0.06770943f, 0.01951110f, -0.04644092f, -0.05759811f, 0.01563591f, -0.02405321f, 
    -0.05343617f, -0.07293891f, 0.05475784f, -0.01071009f, 0.00353013f, 0.00384789f, 0.02423717f, -0.00464144f, 
    0.02593431f, -0.06046870f, -0.02695360f, -0.03113697f, 0.01685967f, 0.02541171f, 0.04799439f, 0.02734219f, 
    -0.05743467f, -0.01562046f, -0.02177834f, -0.05153430f, -0.06081833f, -0.02320822f, -0.06969110f, -0.02516757f, 
    0.03016621f, -0.07061744f, 0.06906669f, 0.01511474f, -0.07400972f, -0.04177006f, 0.04216335f, -0.04296317f, 
    -0.01592213f, 0.06347574f, -0.06314974f, -0.01991255f, 0.06512377f, -0.03726754f, -0.02441833f, -0.06773991f, 
    -0.04262510f, -0.03113043f, -0.03600939f, 0.04971907f, -0.01043244f, -0.02621330f, -0.01903969f, -0.05927695f, 
    0.03790359f, -0.04965700f, -0.03342099f, -0.06197828f, -0.06386986f, 0.05857437f, 0.06524692f, -0.05982816f, 
    -0.00598550f, -0.04403449f, -0.02692232f, -0.04459292f, 0.04518120f, -0.05079680f, -0.03726714f, -0.02877999f, 
    0.06331358f, 0.06242789f, 0.05122693f, 0.04201731f, 0.06834861f, 0.05714600f, 0.01733900f, -0.03189910f, 
    -0.02766262f, -0.06853595f, 0.00101951f, -0.00767938f, 0.05659461f, -0.06664397f, 0.04500711f, -0.04391088f, 
    -0.01315410f, -0.05079308f, 0.03166309f, 0.06961878f, -0.03599229f, -0.02107917f, 0.00480305f, 0.02175815f, 
    -0.00608604f, 0.04347226f, -0.03500046f, 0.05518202f, 0.06211537f, -0.04113964f, -0.03652623f, -0.05140589f, 
    -0.02249132f, 0.04699133f, -0.06511293f, -0.06199649f, 0.06954188f, 0.01096898f, 0.01532369f, 0.02862081f, 
    -0.02468411f, 0.06369234f, 0.05219499f, -0.00350535f, 0.00272695f, -0.06508940f, -0.00931718f, -0.03758134f, 
    -0.03465086f, 0.00589441f, -0.06553701f, -0.04108704f, 0.00116490f, -0.00651334f, -0.02911698f, 0.01275252f, 
    0.06876586f, 0.02683046f, 0.05318380f, -0.05962401f, 0.04402595f, -0.07119813f, -0.04337648f, -0.07650768f, 
    0.01281557f, -0.05527864f, 0.06268375f, 0.02663597f, -0.02180091f, 0.01838525f, 0.00818493f, -0.06380946f, 
    -0.02659745f, -0.06546469f, -0.05636267f, -0.04638726f, -0.00115155f, -0.05547206f, 0.03649538f, -0.06094814f, 
    0.00976267f, 0.03664695f, 0.05739559f, -0.06983760f, 0.00372792f, -0.03175643f, -0.05042764f, 0.05237663f, 
    -0.00935146f, -0.06661543f, -0.02880259f, -0.02119026f, -0.01762088f, -0.01787749f, -0.01647202f, -0.01656541f, 
    -0.06790182f, 0.04682498f, -0.03860835f, -0.01134928f, -0.00873823f, -0.03538467f, -0.00570991f, 0.06433211f, 
    -0.03698980f, -0.01587676f, 0.04103036f, -0.04911897f, 0.04403053f, -0.05703471f, 0.02996428f, 0.01753220f, 
    -0.06398460f, -0.01061058f, -0.05347252f, -0.06898296f, 0.00395335f, 0.02948753f, -0.05202714f, 0.04318780f, 
    0.01394723f, -0.02646349f, 0.04837263f, 0.05787348f, 0.06508373f, -0.00443242f, -0.02821981f, -0.06874990f, 
    -0.00216030f, -0.07314970f, 0.02411663f, 0.00597533f, 0.01670142f, -0.06698351f, -0.00741717f, -0.03490259f, 
    -0.06591700f, -0.03323550f, -0.05229888f, 0.01006089f, -0.04825453f, -0.03930223f, -0.02383753f, -0.00845579f, 
    -0.03409044f, -0.01431468f, 0.03033781f, 0.03262080f, 0.00858260f, -0.03475740f, -0.04488254f, 0.04349070f, 
    0.05494119f, -0.01600386f, -0.06942529f, 0.01668688f, 0.04151245f, 0.02492646f, 0.05409092f, 0.01234836f, 
    -0.07354973f, -0.07511086f, -0.06280557f, 0.00726446f, 0.02679411f, -0.00197995f, 0.01909121f, -0.00418373f, 
    -0.02752945f, -0.02981258f, -0.00690283f, -0.04694290f, -0.07429934f, -0.02713629f, 0.04304382f, -0.06783274f, 
    0.05457142f, 0.00158075f, 0.05669295f, 0.03898664f, 0.01137659f, 0.05724013f, -0.01124099f, -0.03360982f, 
    -0.01616155f, -0.00320348f, 0.03352049f, -0.01576434f, 0.03413363f, -0.07161176f, 0.05309250f, 0.00056434f, 
    0.04843443f, 0.06552651f, 0.00396640f, -0.05639484f, -0.05169771f, 0.03177416f, 0.04361635f, 0.01933415f, 
    -0.01515725f, 0.05334546f, -0.05613457f, -0.04418088f, -0.07013120f, -0.04330576f, 0.00272249f, -0.04857671f, 
    -0.05351699f, 0.01963908f, 0.04862523f, 0.00068533f, 0.05258895f, -0.06688434f, -0.04705444f, -0.07302283f, 
    -0.03073708f, -0.01610226f, -0.07488541f, 0.01796548f, 0.05552545f, -0.03156095f, 0.02265067f, -0.00750653f, 
    -0.00171067f, -0.06805052f, -0.04518981f, 0.01664205f, 0.01328282f, -0.00355272f, 0.01325122f, 0.02185794f, 
    -0.05279017f, -0.04559990f, 0.00486668f, 0.06118546f, 0.00764079f, 0.01829772f, -0.05657186f, 0.00690370f, 
    0.03196603f, -0.02898916f, -0.06608201f, -0.06143467f, 0.05809300f, -0.07072627f, -0.05009665f, 0.02786432f, 
    0.04093479f, -0.01676034f, -0.04288606f, -0.01387072f, -0.00288751f, 0.00731040f, -0.01906653f, -0.03419589f, 
    0.02414337f, 0.01337812f, 0.02472602f, 0.00848804f, -0.00828170f, -0.04389574f, -0.06574676f, -0.03665075f, 
    -0.02387643f, 0.04742812f, -0.01431085f, 0.00132580f, 0.06250563f, -0.03225560f, -0.01841284f, -0.05212201f, 
    -0.06750189f, -0.06012578f, -0.06793807f, -0.06785972f, -0.02532176f, 0.01881344f, 0.01556004f, 0.02371820f, 
    -0.02651601f, -0.07646076f, 0.04846856f, -0.00918289f, -0.03336238f, 0.00555981f, -0.02179157f, -0.04534004f, 
    0.05239299f, 0.00549663f, -0.01921679f, 0.06180064f, -0.03878730f, -0.07684545f, 0.01710575f, -0.01482149f, 
    0.01411745f, -0.06219852f, 0.01159525f, -0.03971202f, -0.06378368f, 0.03318591f, -0.04761223f, -0.06488833f, 
    0.00209408f, 0.04039518f, 0.03853260f, 0.00433876f, 0.04308707f, 0.04176255f, 0.01434597f, -0.04247126f, 
    -0.03259372f, 0.02570172f, -0.03149392f, -0.03092468f, -0.04620797f, 0.05062807f, 0.06266695f, -0.01604472f, 
    -0.05011364f, -0.05632615f, 0.04726914f, -0.04755867f, -0.02025379f, 0.05680604f, -0.07717100f, -0.03912927f, 
    -0.02345631f, -0.02385365f, 0.04839247f, -0.04865495f, 0.02865548f, -0.01715817f, -0.06720968f, -0.07364116f, 
    -0.05487682f, -0.00361730f, -0.07238591f, -0.03142532f, -0.07130955f, 0.06809580f, 0.02422843f, -0.02278745f, 
    -0.09860630f, 0.09305626f, -0.10326789f, -0.01386356f, -0.08294604f, -0.02953746f, 0.00298167f, -0.03054963f, 
    -0.22281864f, -0.23629975f, -0.03632997f, -0.08457395f, 0.20651878f, 0.00325086f, 0.01395245f, -0.08490344f, 
    -0.00984568f, 0.03820121f, 0.09666690f, 0.33494222f, 0.08478694f, -0.15020353f, 0.11823947f, 0.18256010f, 
    0.16413115f, 0.39310968f, -0.08705254f, 0.09972025f, -0.00518473f, -0.03169702f, 0.12243360f, 0.02086823f, 
    -0.13470750f, 0.12447392f, 0.00722920f, -0.12156586f, -0.34030989f, -0.13866192f, -0.00848575f, -0.12436824f, 
    -0.04691121f, 0.24848464f, 0.05120502f, 0.02101470f, -0.05632664f, -0.04869985f, -0.14734857f, -0.05715771f, 
    -0.09248455f, 0.01745874f, 0.03601658f, -0.14526244f, -0.13178764f, 0.02684522f, -0.08527001f, -0.08083595f, 
    -0.23059122f, -0.05604424f, 0.00260032f, 0.00484574f, -0.16622517f, -0.16892515f, 0.14572144f, 0.25511143f, 
    -0.06132855f, -0.15125401f, 0.19600035f, -0.18528903f, -0.04385200f, 0.05621511f, 0.09019447f, -0.07124884f, 
    -0.19129939f, -0.40711620f, -0.05235802f, -0.09111988f, -0.02579780f, 0.07463688f, 0.03100609f, -0.11546654f, 
    0.05192338f, 0.05694806f, 0.05644927f, 0.01276545f, 0.03105453f, -0.30849037f, 0.03723542f, -0.24844311f, 
    0.10833830f, -0.07906736f, 0.09520458f, 0.27557549f, -0.04036812f, -0.02357102f, 0.15906312f, -0.02583497f, 
    -0.22057064f, -0.24780977f, -0.13765086f, 0.22968426f, 0.08313563f, 0.07391183f, 0.18548784f, -0.19130960f, 
    0.01159223f, 0.14619596f, 0.09972253f, 0.04464483f, 0.02255121f, -0.05938489f, -0.03971775f, 0.14936681f, 
    0.11637475f, -0.12568861f, 0.18316512f, 0.15780301f, -0.01735942f, -0.01700726f, 0.05636429f, 0.10275061f, 
    0.50416082f, 0.19860364f, 0.00963881f, -0.01679778f, 0.04117323f, 0.02922498f, 0.02346361f, -0.03032572f, 
    -0.15068994f, 0.16593800f, 0.28670830f, 0.11718471f, 0.13917163f, 0.34567589f, -0.33768660f, 0.26980925f, 
    -0.04178197f, 0.21154614f, 0.06268174f, 0.18641783f, 0.19212510f, 0.05842497f, 0.05076096f, 0.05713163f, 
    0.34171462f, 0.12079643f, -0.11905960f, -0.09188654f, 0.10393199f, 0.00748639f, 0.10763519f, 0.13290326f, 
    -0.09159025f, 0.12425464f, -0.02600885f, -0.10933960f, -0.39368975f, 0.29901001f, 0.19988103f, 0.12606059f, 
    -0.03471246f, 0.09888438f, -0.02302077f, 0.06570649f, 0.07233711f, 0.12722386f, 0.16622952f, 0.23395145f, 
    -0.27666512f, -0.00955598f, -0.02514130f, -0.05476840f, -0.20585477f, -0.04877195f, -0.18517940f, -0.06247887f, 
    0.31683555f, 0.05171748f, 0.34309956f, 0.08200201f, -0.32462037f, -0.24993794f, 0.25439146f, -0.08144397f, 
    -0.09065665f, 0.05717565f, 0.05717231f, -0.03681035f, -0.09401279f, 0.00822565f, 0.07051026f, 0.13645095f, 
    -0.26517475f, -0.30912548f, 0.04686354f, -0.04029451f, 0.20176291f, 0.06859562f, 0.11083307f, -0.00485980f, 
    0.07305855f, -0.10188684f, 0.03178051f, 0.04701098f, -0.35384557f, -0.10194629f, 0.02854705f, -0.32423580f, 
    0.05945697f, 0.06806889f, -0.00808905f, -0.12046387f, 0.01369529f, 0.11059689f, 0.04924219f, -0.11102098f, 
    -0.16379556f, -0.01841512f, -0.03481138f, -0.01952360f, 0.09722655f, 0.25565955f, 0.00959637f, -0.07643149f, 
    -0.04909336f, 0.15932308f, 0.10814272f, 0.08351975f, 0.14171776f, 0.26439592f, -0.19318978f, -0.01596553f, 
    0.17397746f, 0.29742515f, 0.03899625f, 0.20403025f, 0.07589235f, 0.16787970f, 0.12813571f, -0.11002856f, 
    -0.22329222f, -0.25079104f, -0.14156978f, 0.14934106f, 0.13182156f, 0.15587275f, 0.14106423f, 0.03045482f, 
    0.11348481f, 0.02568269f, -0.03406547f, 0.10721830f, -0.28536573f, 0.26140139f, -0.10316017f, -0.20203657f, 
    -0.01337753f, 0.34089822f, 0.02362349f, 0.13983105f, 0.07685289f, -0.13725685f, 0.03739573f, 0.14982744f, 
    0.25196090f, 0.46878505f, 0.21892934f, -0.07995457f, 0.08080271f, 0.03530186f, 0.08413378f, 0.22800766f, 
    -0.18396382f, 0.08585271f, 0.06808031f, -0.07401151f, -0.24563938f, 0.33401302f, 0.03498201f, -0.05714743f, 
    -0.08887975f, 0.01652977f, 0.07965160f, 0.09292736f, 0.11495712f, -0.14502613f, 0.11432548f, 0.07294512f, 
    0.25449955f, 0.34420422f, 0.11546130f, -0.10003028f, -0.14587510f, 0.07844450f, 0.06422033f, 0.19369848f, 
    -0.09472115f, -0.09979770f, 0.07910853f, -0.01446722f, -0.13378452f, 0.18985014f, 0.22393399f, -0.21840920f, 
    -0.03471183f, 0.01147671f, 0.08155995f, -0.20312087f, 0.03323404f, -0.09203689f, 0.11707857f, 0.21553591f, 
    -0.44252664f, -0.14186852f, -0.14542787f, 0.14650434f, 0.10630593f, 0.09944316f, 0.00758180f, -0.03106633f, 
    0.16511232f, -0.03671401f, 0.23534134f, 0.20965329f, -0.04685651f, -0.35492206f, 0.40726072f, -0.32970464f, 
    0.03116078f, -0.07114966f, -0.13263839f, 0.12932016f, -0.03274072f, 0.06993497f, -0.11033625f, -0.03990014f, 
    -0.16852280f, -0.06397174f, 0.02867327f, 0.00943293f, -0.16720450f, 0.01689336f, 0.06006078f, -0.16856281f, 
    -0.05773143f, -0.01080882f, -0.00677217f, 0.01340365f, 0.31572241f, -0.03645115f, 0.09404463f, 0.08150594f, 
    0.12126008f, -0.08796491f, -0.05754530f, -0.07455297f, 0.13493107f, -0.16139182f, 0.02624222f, -0.07048748f, 
    0.35642558f, 0.07261128f, -0.04600015f, 0.04775333f, 0.16768499f, 0.05846907f, 0.13326448f, 0.14302698f, 
    -0.03523194f, -0.06865552f, -0.03602624f, -0.04151710f, -0.18178074f, -0.00058573f, -0.48104069f, 0.38515154f, 
    -0.07993750f, 0.18254589f, 0.13383704f, 0.11641180f, -0.02638079f, -0.10073549f, -0.09850343f, -0.12862082f, 
    0.13057043f, -0.33597526f, 0.21439494f, 0.08577894f, 0.13331886f, 0.01711043f, -0.09103832f, 0.01468827f, 
    -0.07188635f, 0.00541083f, 0.14686641f, 0.10315912f, -0.11526944f, 0.07217288f, -0.30164975f, -0.41176158f, 
    -0.02721061f, 0.05738217f, -0.08216867f, 0.24053441f, 0.10800410f, -0.05467566f, -0.08125587f, 0.02180324f, 
    0.44251916f, -0.26071709f, -0.03546763f, -0.08901267f, 0.10155640f, 0.00827400f, -0.19740584f, 0.01767382f, 
    0.15086646f, 0.08099269f, -0.01440955f, 0.09297132f, -0.21066393f, -0.05515586f, -0.23029242f, 0.00417078f, 
    0.07140329f, -0.02972350f, 0.14406472f, 0.22715674f, 0.10732114f, -0.03576003f, 0.04302241f, -0.06064259f, 
    -0.25723568f, -0.03212637f, -0.01824114f, 0.28475493f, 0.06344410f, 0.17196265f, 0.11632920f, 0.04856857f, 
    0.04021707f, -0.07031546f, -0.08919091f, -0.00210421f, -0.58964902f, 0.21926567f, 0.12913969f, -0.30992186f, 
    -0.14398067f, 0.16155961f, 0.01990229f, 0.08013679f, 0.11892630f, -0.13748008f, 0.00161704f, 0.17140812f, 
    0.14756063f, 0.60916913f, 0.14920461f, -0.14344232f, 0.22049758f, 0.08587646f, 0.16489606f, 0.17668188f, 
    0.02265787f, -0.02699765f, -0.05445452f, 0.04498116f, -0.07688025f, 0.03110090f, -0.09102435f, 0.07994331f, 
    -0.12578745f, 0.01949169f, -0.03956865f, 0.00293839f, 0.10887004f, -0.25673687f, -0.03171445f, 0.04472861f, 
    0.01592613f, 0.17275710f, 0.04713943f, -0.18062738f, 0.19422805f, 0.06599107f, 0.13709916f, 0.18942982f, 
    0.07777622f, -0.07937905f, 0.04592337f, 0.04604601f, 0.05597315f, -0.32291543f, 0.08965746f, -0.19580114f, 
    0.01994638f, 0.03765331f, -0.09794570f, -0.03396730f, 0.15828730f, -0.06332459f, -0.09779566f, 0.00573178f, 
    -0.48746598f, 0.11578779f, -0.32529140f, 0.36512437f, 0.06872172f, 0.06874853f, -0.08986239f, -0.09218590f, 
    0.01149477f, -0.04163270f, 0.15411761f, -0.05493817f, 0.13754919f, -0.35747620f, 0.36779693f, -0.25180298f, 
    -0.08703838f, 0.05851514f, 0.04836764f, -0.06600430f, 0.12553528f, 0.08765551f, -0.03165812f, 0.03145961f, 
    -0.06765683f, 0.18287027f, -0.13094479f, -0.02521457f, -0.17660700f, 0.22386278f, 0.15983462f, 0.01227288f, 
    -0.03824843f, 0.08694566f, 0.24863994f, 0.06072784f, 0.49556482f, -0.46577433f, 0.01065240f, 0.12942050f, 
    0.11163813f, -0.10510234f, -0.18590491f, -0.06685995f, 0.16098861f, -0.13341813f, 0.15255412f, 0.00381246f, 
    0.27382278f, -0.01328755f, -0.03398196f, -0.30875653f, 0.28331539f, 0.02431969f, 0.02764891f, -0.04222698f, 
    0.05572999f, -0.03070356f, -0.05567028f, -0.15178256f, -0.03801051f, 0.07118443f, -0.28332230f, -0.03106608f, 
    0.03116520f, 0.08900327f, 0.10699788f, -0.03023508f, 0.09273762f, -0.04440743f, -0.12434361f, -0.09057624f, 
    0.02171764f, 0.02832924f, 0.00870964f, -0.01848588f, 0.05291574f, 0.00327169f, 0.01406725f, -0.05110901f, 
    0.04963812f, 0.02412633f, 0.03492511f, -0.08052196f, -0.02832930f, 0.00393368f, 0.00995110f, -0.00855889f, 
    -0.05216382f, -0.00143743f, -0.03122188f, 0.02609442f, 0.00328531f, 0.01306795f, -0.00304150f, -0.00250993f, 
    0.01446676f, 0.00409239f, -0.04202272f, -0.07744532f, -0.05112718f, 0.03529302f, -0.04290254f, 0.02473553f, 
    0.00776153f, 0.04523519f, -0.02979914f, -0.02640484f, 0.04952580f, -0.04342208f, -0.04764540f, 0.04316678f, 
    0.02010475f, 0.01846994f, -0.07258530f, -0.01542974f, 0.03544638f, 0.03207116f, -0.06430154f, -0.04492968f, 
    -0.00594957f, 0.04903154f, -0.04896853f, -0.07412513f, 0.06066190f, -0.02974807f, -0.06901906f, 0.05720911f, 
    0.01084286f, -0.05301894f, -0.00845346f, -0.07880270f, -0.05118763f, -0.07823421f, -0.04911920f, 0.06313659f, 
    0.04275263f, -0.05986293f, -0.02864562f, -0.03298456f, -0.02227180f, -0.05197846f, -0.01953656f, -0.05438240f, 
    0.07571117f, -0.04583814f, -0.06524326f, -0.06512737f, 0.00072573f, 0.05235441f, -0.00656882f, -0.00240892f, 
    -0.06418421f, -0.07588713f, -0.06036555f, 0.02969065f, 0.00280513f, -0.03694074f, -0.01983654f, -0.06531919f, 
    0.01753779f, 0.05489711f, 0.00439438f, -0.00515989f, 0.04800409f, -0.04499386f, -0.04993559f, 0.02868950f, 
    -0.03808258f, -0.00750001f, -0.05961234f, -0.02626150f, 0.04558766f, -0.06242013f, 0.01814513f, -0.02500579f, 
    0.02915086f, -0.07079586f, -0.03714156f, 0.04979404f, 0.03526758f, -0.03656473f, 0.00280677f, 0.02853003f, 
    -0.08091386f, 0.03402941f, 0.04372856f, -0.03007327f, -0.04405014f, -0.04924752f, 0.03081290f, -0.06269710f, 
    0.02286986f, -0.04718585f, 0.05499192f, 0.01161393f, 0.06602143f, -0.06603968f, -0.05149938f, -0.03488363f, 
    -0.08125307f, -0.00214001f, -0.07500729f, 0.00013835f, 0.04678288f, 0.01581468f, -0.00503409f, 0.02752823f, 
    0.03981242f, 0.04511756f, 0.05222579f, -0.05363756f, 0.00875935f, 0.04722203f, -0.03101135f, 0.01004971f, 
    0.00034091f, -0.06441787f, -0.01750447f, 0.05413735f, -0.07359865f, 0.00112208f, -0.06422594f, -0.01518242f, 
    -0.03475473f, 0.04243840f, -0.07913281f, 0.03922079f, -0.07017594f, -0.00602040f, 0.04773714f, -0.04592290f, 
    0.04754028f, 0.05274452f, 0.01957723f, 0.04828678f, -0.02974554f, -0.07309534f, -0.03612586f, -0.02567889f, 
    -0.00817511f, 0.01675716f, 0.06328819f, 0.02737401f, -0.02268294f, 0.05736899f, -0.00415287f, -0.04317670f, 
    -0.00009502f, -0.02724234f, -0.05887156f, -0.04052991f, -0.07718447f, -0.00530383f, -0.03725202f, -0.06718238f, 
    0.04683064f, -0.01337559f, 0.02904062f, 0.03711946f, 0.02515519f, 0.03544030f, 0.05782606f, -0.02837491f, 
    -0.43408674f, -0.46110922f, -0.00289517f, 0.04017869f, 0.05931557f, -0.03000669f, -0.14582267f, -0.20268004f, 
    -0.08166584f, 0.01782718f, -0.01414795f, 0.19511369f, 0.13681820f, -0.32247955f, 0.06265409f, -0.27183479f, 
    -0.00324101f, 0.02503393f, 0.15350837f, -0.12715125f, -0.00066908f, 0.11199789f, 0.00389327f, 0.23054287f, 
    -0.60768712f, -0.57319814f, 0.24626034f, -0.12918720f, -0.20235266f, 0.08236323f, -0.17707103f, -0.09501728f, 
    -0.15802629f, -0.13474281f, 0.07330777f, 0.08858379f, -0.09762322f, -0.17799051f, -0.34472489f, -0.18754269f, 
    0.18864138f, -0.12367570f, 0.14493769f, 0.00010203f, -0.09349000f, 0.01416473f, -0.15231524f, 0.10323707f, 
    -0.18742995f, -0.09599940f, -0.46372202f, 0.02839473f, 0.23338716f, -0.05916499f, -0.07101642f, 0.07324283f, 
    0.17795148f, -0.02462427f, 0.14016297f, 0.25088310f, 0.39505655f, 0.47041234f, 0.08274274f, 0.15157032f, 
    0.00249751f, 0.11277322f, -0.26794389f, -0.02246402f, 0.00942807f, 0.00641022f, -0.02666626f, 0.10399211f, 
    0.34471905f, 0.39310923f, 0.14719583f, 0.09198830f, -0.16589119f, -0.03934279f, 0.02097373f, 0.17061457f, 
    0.09127931f, -0.00812727f, 0.14580297f, 0.03589297f, 0.10668451f, 0.05119269f, -0.06830693f, 0.26015428f, 
    0.07136032f, 0.17647399f, -0.10749716f, -0.06594838f, 0.06885301f, -0.00803000f, 0.07331978f, 0.10561007f, 
    0.21028787f, 0.17273419f, 0.16904937f, -0.04947244f, -0.08422989f, 0.15616529f, 0.02682244f, 0.28120598f, 
    0.22580138f, -0.19640276f, -0.05257413f, -0.17734239f, -0.02759345f, -0.10767879f, -0.09690560f, -0.14700922f, 
    0.20297158f, 0.24929340f, -0.03399906f, -0.04690279f, 0.03613289f, -0.10211393f, -0.22346802f, -0.12849148f, 
    -0.40852511f, -0.43493941f, -0.08611839f, 0.22141173f, 0.17072491f, -0.03686472f, 0.01380945f, -0.15083215f, 
    0.02951087f, -0.11974773f, -0.18824989f, -0.09154500f, 0.45773992f, -0.28769946f, 0.13473575f, -0.03339525f, 
    -0.08360094f, 0.10582828f, 0.14541155f, -0.09076353f, -0.00100650f, 0.02546721f, 0.00368791f, 0.32612562f, 
    -0.05377352f, 0.12653230f, 0.25195846f, 0.13968238f, -0.04087168f, -0.09830686f, -0.01634114f, -0.00503496f, 
    0.15118250f, 0.22374010f, 0.18400165f, 0.38590384f, 0.41570452f, 0.15388466f, 0.21108314f, 0.09159516f, 
    -0.13800393f, 0.00520884f, -0.13288866f, -0.22536419f, 0.10206207f, 0.00308426f, -0.10169544f, 0.10601725f, 
    0.37593889f, -0.00600091f, 0.33830625f, -0.08131471f, -0.13834591f, -0.00555206f, 0.11995486f, 0.03844362f, 
    -0.06210282f, -0.06850761f, -0.02360424f, -0.00302607f, -0.16225220f, -0.21676606f, -0.25421754f, 0.09177290f, 
    0.06158929f, -0.01846500f, 0.04881401f, 0.12519264f, -0.26595336f, -0.02766218f, -0.08260369f, -0.16775399f, 
    -0.11951482f, -0.12065154f, -0.26999757f, -0.18335350f, -0.17194684f, -0.08598396f, 0.10484801f, 0.00518160f, 
    0.02316153f, 0.12866151f, 0.05983137f, 0.00521508f, -0.44809458f, 0.62704915f, 0.22898145f, 0.23874053f, 
    -0.03803447f, -0.13707177f, 0.03870220f, 0.18618101f, 0.05744313f, -0.11481131f, -0.11864411f, 0.26524696f, 
    0.05800860f, -0.04322234f, -0.34499329f, 0.12055766f, -0.08855294f, 0.02602972f, -0.04391577f, -0.05573499f, 
    0.12624185f, 0.12607171f, 0.03856683f, 0.11379947f, 0.05344097f, -0.20957857f, 0.19512972f, 0.08954477f, 
    0.05514437f, 0.15703380f, 0.03467250f, 0.17669211f, 0.03258391f, -0.11944966f, -0.04395501f, -0.13878138f, 
    -0.04430959f, -0.07492153f, -0.03453733f, -0.18573135f, -0.07042231f, 0.07549769f, 0.16225074f, -0.26550567f, 
    0.09428917f, -0.05780363f, -0.01133012f, -0.08710128f, -0.01426900f, -0.54785579f, 0.15524906f, 0.39154711f, 
    0.28109637f, -0.18811335f, 0.18029904f, -0.00342389f, 0.00090896f, 0.08134769f, 0.17020586f, -0.03806470f, 
    -0.31703210f, -0.25527641f, 0.22963372f, 0.15304385f, 0.03358259f, 0.05458457f, 0.21014105f, 0.06262973f, 
    0.15626307f, -0.07772622f, -0.12612395f, -0.12072878f, 0.10698407f, -0.04644311f, -0.05199366f, 0.07419484f, 
    -0.13398427f, -0.09595738f, 0.24885525f, 0.11441684f, -0.04761361f, 0.02936154f, 0.01967281f, 0.23223853f, 
    -0.39856929f, -0.14927799f, 0.23008880f, 0.53168774f, -0.05272176f, 0.07141248f, 0.02098651f, -0.15985569f, 
    -0.03423627f, -0.00326831f, -0.09553730f, -0.16436826f, 0.05113664f, -0.22815746f, -0.07414165f, 0.07197224f, 
    0.02643113f, -0.02065495f, 0.09389438f, 0.10072123f, -0.18114731f, 0.00364686f, 0.08298141f, -0.15294355f, 
    0.45094761f, 0.16780923f, 0.03564470f, -0.10389340f, -0.14175026f, -0.00857376f, -0.20611821f, -0.00277092f, 
    0.09191635f, 0.18195927f, 0.02837159f, -0.00848592f, -0.46030965f, 0.45805827f, 0.05249660f, 0.12399982f, 
    0.11629754f, 0.09576588f, 0.11585456f, 0.34802416f, -0.11012524f, 0.24735212f, -0.01767083f, 0.06794363f, 
    0.09800120f, 0.28544030f, 0.04122714f, 0.09431441f, 0.03794292f, 0.12007564f, 0.09434528f, -0.14009911f, 
    0.32537088f, 0.01260340f, 0.07129261f, 0.17414573f, 0.10469836f, 0.33270851f, -0.01179742f, 0.25017855f, 
    0.05935887f, -0.13125809f, 0.07183664f, 0.13426347f, -0.00671930f, -0.00360577f, 0.16901515f, 0.33287638f, 
    -0.19836274f, 0.11111375f, 0.22341967f, 0.36431199f, -0.00056212f, -0.17541960f, -0.00460741f, 0.21257474f, 
    0.06816085f, 0.04493277f, 0.04442149f, -0.07347690f, -0.03852689f, 0.04800283f, 0.60933858f, -0.03021440f, 
    -0.01694332f, -0.13826407f, -0.09158105f, 0.11568711f, 0.05089829f, 0.07853907f, -0.02509353f, -0.02218998f, 
    0.30435669f, 0.20056051f, 0.37683928f, -0.17494422f, -0.28699875f, -0.04256525f, -0.14819469f, -0.31263131f, 
    -0.07101641f, -0.24098220f, -0.23355460f, -0.28062648f, 0.22051269f, -0.39696497f, 0.07332822f, 0.14095438f, 
    0.01245033f, 0.01429790f, 0.03873939f, -0.21689303f, -0.00295748f, 0.18392709f, 0.07502366f, 0.02130004f, 
    -0.18887158f, 0.37581718f, 0.55882072f, -0.14096609f, -0.26779634f, -0.02743175f, -0.14819439f, -0.23385732f, 
    -0.04246168f, -0.07698879f, 0.04228950f, 0.06382528f, -0.28507695f, 0.13911946f, 0.01190334f, -0.15966995f, 
    0.02964630f, -0.11249621f, 0.17568018f, -0.08925087f, -0.02360320f, 0.11052375f, -0.00971535f, 0.30250156f, 
    0.30247897f, 0.19983213f, 0.22161385f, 0.09545071f, -0.22399068f, -0.38214600f, -0.14914954f, 0.03355270f, 
    -0.09900100f, 0.09913686f, 0.09125453f, 0.08595939f, 0.55095124f, 0.06097727f, -0.12271091f, -0.16703953f, 
    0.03916162f, -0.04180339f, -0.01874353f, 0.09987448f, 0.03122043f, -0.00556562f, 0.02049655f, -0.22787957f, 
    0.10953408f, -0.16530204f, -0.08693930f, 0.04008406f, -0.07998088f, 0.00791580f, -0.11142679f, -0.03424984f, 
    0.00361386f, -0.05800749f, -0.04812682f, -0.10422328f, 0.09164707f, 0.03714468f, 0.11151776f, -0.05321922f, 
    0.22771455f, -0.07324582f, -0.06061991f, -0.05241123f, -0.18237218f, -0.03698020f, -0.09885703f, -0.11150297f, 
    0.14442551f, 0.04154636f, -0.06902309f, -0.18239895f, 0.12049258f, -0.04793167f, 0.05773282f, 0.29203135f, 
    0.12195212f, 0.02489509f, -0.05395674f, 0.08001705f, -0.09201568f, 0.08482020f, 0.36328861f, -0.16968517f, 
    0.06954192f, 0.11587299f, 0.07304919f, -0.13348806f, 0.13688155f, 0.10912264f, 0.30868617f, 0.13904257f, 
    0.21908677f, 0.09355658f, 0.22266735f, 0.24222912f, -0.10071616f, -0.20730299f, 0.22208172f, -0.23913734f, 
    0.06043908f, 0.00932991f, -0.00312128f, 0.28559127f, 0.25954646f, 0.24150054f, -0.22138955f, 0.33665207f, 
    -0.05105033f, 0.02086824f, -0.04809989f, 0.10010262f, -0.13819566f, -0.04859913f, 0.00600589f, -0.18624562f, 
    -0.01145202f, -0.16874823f, 0.09140345f, 0.05604567f, -0.14814988f, -0.27525097f, -0.15167305f, 0.17097764f, 
    -0.05382489f, -0.23310046f, -0.27560833f, -0.12711203f, 0.11760770f, 0.05546414f, -0.15866660f, -0.42648783f, 
    -0.14511274f, 0.15570231f, 0.09659973f, -0.19450183f, -0.06614652f, 0.23312216f, 0.07044142f, 0.06870586f, 
    -0.15511717f, 0.08683714f, 0.02062853f, 0.18370953f, 0.09489758f, 0.12614468f, 0.14538807f, 0.09664506f, 
    0.08905742f, -0.00416014f, -0.14377095f, 0.01099989f, 0.29002109f, 0.25159261f, -0.06442717f, 0.25796491f, 
    -0.14874385f, -0.22815365f, -0.00520228f, 0.08401950f, 0.16210000f, -0.05323775f, 0.04857057f, 0.15868805f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17512430f, 0.16748925f, -0.14273901f, -0.05847057f, 0.09120540f, -0.06032930f, -0.05917561f, 0.04897306f, 
    -0.01721736f, 0.17550990f, -0.01889473f, 0.20897220f, 0.02921202f, 0.19709355f, 0.09860338f, -0.03012265f, 
    0.03034226f, 0.17057410f, -0.17697698f, 0.00110792f, 0.41669893f, 0.16178070f, -0.07085887f, -0.03058294f, 
    0.02466989f, 0.26816472f, 0.07190007f, 0.08461248f, -0.07299019f, -0.01141208f, 0.13516778f, -0.01336799f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01905692f, 0.17677848f, 0.49376306f, 0.08567868f, 0.05656201f, -0.00356813f, 0.12886868f, -0.52007890f, 
    -0.06720791f, -0.14868167f, -0.21711792f, 0.30225167f, 0.12769060f, -0.01515137f, 0.07044604f, -0.12022416f, 
    0.04343780f, -0.16212822f, 0.16104756f, 0.00641983f, 0.10198516f, 0.15653221f, -0.03923878f, -0.01152176f, 
    -0.02958739f, -0.14697883f, 0.15222035f, -0.17759053f, -0.06882289f, 0.15585302f, 0.37230924f, 0.06988059f, 
    -0.22602339f, -0.37789124f, 0.07096018f, -0.05608005f, 0.28586224f, -0.49844396f, -0.26901585f, -0.18812050f, 
    -0.28832400f, 0.33352953f, 0.26857567f, -0.02776810f, -0.01685566f, 0.48697552f, 0.08396481f, 0.04262345f, 
    -0.14657502f, 0.05477693f, -0.03516044f, 0.01368586f, 0.24839030f, 0.36441141f, 0.17393351f, 0.11357135f, 
    -0.11814041f, 0.26294464f, 0.21464601f, 0.01072116f, -0.08208627f, -0.18045843f, 0.09711038f, -0.00085904f, 
    -0.09227957f, -0.26481038f, 0.10368875f, -0.03068079f, 0.21818584f, -0.08255342f, -0.39542034f, -0.04001504f, 
    -0.42014599f, 0.41580102f, -0.07622009f, 0.01663999f, 0.35669616f, 0.45827529f, -0.42988363f, -0.04333478f, 
    -0.11649105f, -0.17663874f, -0.28585559f, 0.05425179f, -0.01059556f, 0.01685344f, 0.06845248f, 0.08910036f, 
    0.03249212f, 0.00105703f, 0.04143301f, -0.31436506f, 0.16797692f, -0.16927212f, 0.14861234f, -0.01827374f, 
    0.18318492f, -0.29551825f, 0.17593168f, -0.12896402f, 0.06926547f, -0.05590088f, -0.15861700f, 0.11461811f, 
    -0.46237403f, 0.06646588f, -0.17144273f, 0.12789583f, 0.03293938f, -0.25533229f, 0.03557552f, 0.13646922f, 
    0.07654765f, -0.19555010f, 0.09595518f, -0.06609559f, -0.36661914f, -0.03438532f, -0.14937451f, -0.15951429f, 
    0.00056308f, 0.12773988f, 0.17145604f, -0.23195398f, -0.06685229f, -0.02279033f, 0.06081434f, -0.06937090f, 
    -0.17430231f, 0.17874500f, 0.29961419f, 0.14405869f, 0.17380437f, -0.12773927f, -0.08070786f, -0.27703723f, 
    0.05076666f, -0.32308367f, 0.10203203f, 0.05078181f, 0.21340862f, 0.25753629f, 0.35180897f, -0.02826532f, 
    0.04808355f, -0.32367247f, -0.14491294f, 0.00306749f, 0.12399034f, 0.23737571f, -0.11422440f, -0.16204944f, 
    0.10644943f, -0.09538762f, 0.28788367f, -0.01813013f, 0.10524048f, 0.25654900f, 0.16940017f, -0.01012975f, 
    -0.09482547f, -0.30389431f, -0.06884050f, 0.11083763f, 0.35583591f, -0.39825320f, -0.39917433f, 0.30287108f, 
    -0.17592613f, 0.04983440f, -0.15604629f, 0.30779475f, -0.05974176f, -0.29603639f, 0.37509775f, -0.09255713f, 
    -0.13823725f, 0.11579919f, -0.33358952f, 0.13648640f, 0.02065992f, 0.09790385f, 0.07322393f, -0.06085992f, 
    0.10603930f, 0.28106430f, 0.10701116f, -0.30102533f, 0.10452209f, -0.16859296f, 0.14776884f, 0.63850838f, 
    -0.15609862f, 0.04672273f, 0.00530500f, -0.16226999f, -0.04493415f, 0.12029126f, -0.12779669f, -0.10460650f, 
    -0.12040318f, -0.20866911f, 0.05940275f, -0.09486736f, -0.00107565f, 0.06413566f, -0.21487217f, 0.11233950f, 
    -0.17464221f, 0.03483599f, 0.06616405f, 0.12520777f, -0.03337614f, -0.14630297f, 0.03147968f, 0.14443178f, 
    0.13952672f, 0.00598873f, -0.21200751f, -0.17115209f, -0.00555685f, 0.16838884f, -0.14519362f, 0.04124198f, 
    0.15070425f, -0.06327564f, -0.14611866f, 0.09391910f, -0.03463047f, 0.32413140f, 0.25150421f, -0.04839173f, 
    0.48091915f, -0.24470633f, 0.30475813f, 0.06701286f, -0.02186580f, 0.14953154f, 0.01103085f, -0.09596591f, 
    0.12998673f, -0.30392411f, -0.21881555f, -0.12444267f, 0.21685301f, 0.17220229f, -0.15440257f, 0.12519048f, 
    -0.00727201f, -0.19041784f, 0.12788272f, 0.37374416f, -0.16033353f, 0.51096880f, -0.10812893f, 0.39765838f, 
    -0.57255667f, 0.40081933f, 0.02566868f, 0.11815566f, -0.38646635f, 0.30815491f, 0.06151805f, -0.27831873f, 
    0.36398521f, -0.44356260f, 0.20081903f, 0.34436971f, -0.03776942f, -0.08198353f, 0.01122283f, -0.07566933f, 
    -0.15145892f, 0.14932437f, -0.14152342f, 0.02486648f, 0.35453397f, 0.09540533f, -0.11700194f, 0.08243675f, 
    -0.01861582f, 0.17264925f, -0.02905904f, 0.25429812f, -0.05031789f, 0.12282185f, 0.31611273f, -0.73743218f, 
    -0.27839351f, -0.20271938f, -0.21878618f, -0.07573982f, 0.27436578f, -0.69828284f, 0.17137431f, 0.17244203f, 
    -0.31888831f, -0.14906876f, -0.32823297f, 0.03906284f, -0.12764439f, 0.48030791f, 0.27817529f, -0.13568135f, 
    0.16868183f, 0.19005533f, -0.31869599f, -0.13636330f, 0.33244494f, 0.56794465f, 0.09369493f, 0.16569611f, 
    0.17386797f, -0.04564080f, 0.17977680f, 0.31029037f, 0.07998164f, 0.00431325f, 0.01887631f, 0.05734771f, 
    -0.00978525f, 0.10789887f, -0.07882064f, 0.01056354f, -0.11776891f, 0.02203928f, 0.13402124f, -0.01134522f, 
    -0.11890987f, 0.03526212f, -0.13879248f, -0.06562159f, 0.10449537f, 0.01519799f, 0.01349804f, -0.16071221f, 
    -0.10677264f, -0.01049174f, -0.17738053f, 0.08948324f, -0.16469273f, 0.10618058f, 0.11806992f, 0.07697136f, 
    0.14506747f, -0.19150843f, -0.11066480f, -0.19568895f, -0.12736087f, -0.02123128f, -0.16616426f, 0.12553720f, 
    0.00377041f, -0.18686402f, -0.05396188f, 0.02528354f, -0.16840535f, 0.11865550f, -0.16789606f, 0.00337767f, 
    -0.08814817f, -0.13331617f, -0.04067858f, -0.08354591f, -0.16355318f, -0.12935373f, -0.00518789f, 0.06364862f, 
    0.17354575f, -0.17401809f, 0.03753018f, -0.12889618f, 0.07794183f, -0.03351087f, -0.05819870f, 0.10893137f, 
    -0.09163570f, -0.04594834f, -0.09158707f, -0.05948688f, 0.05253095f, 0.15951061f, 0.04972787f, 0.02810621f, 
    0.10886578f, 0.11013763f, -0.02450996f, -0.03522522f, -0.21673994f, 0.12229303f, -0.04085258f, 0.28690541f, 
    0.29330790f, 0.27666762f, 0.15509059f, -0.38023478f, -0.02004863f, 0.22239886f, -0.23860180f, -0.14598416f, 
    0.07646392f, 0.00056193f, 0.15367807f, 0.15753818f, 0.07794306f, 0.32947829f, -0.00575992f, 0.17656663f, 
    -0.02563152f, 0.04347163f, -0.66062689f, 0.14992116f, -0.10649294f, -0.86149287f, 0.03945861f, 0.32212096f, 
    0.23439112f, 0.10280121f, -0.11989668f, 0.14182143f, -0.28545022f, 0.08405370f, 0.55980438f, 0.23863696f, 
    -0.08477820f, -0.05855589f, -0.03601884f, 0.24285857f, 0.21817130f, 0.25528732f, -0.21801117f, -0.07269735f, 
    -0.05000968f, -0.11693487f, 0.05107865f, 0.08789000f, 0.15429877f, -0.06313424f, 0.10460702f, -0.10848633f, 
    0.16323589f, -0.49785978f, 0.34636533f, 0.45980957f, 0.09187208f, 0.28031623f, -0.08287838f, -0.24082525f, 
    -0.19091897f, 0.31696436f, -0.32354465f, -0.03907347f, 0.20752606f, -0.27264133f, -0.52857316f, 0.21967426f, 
    0.02739115f, 0.49674177f, 0.36439401f, 0.08559620f, 0.12088636f, 0.32087591f, -0.35095251f, 0.04638632f, 
    -0.13184342f, -0.23707241f, -0.27104801f, -0.05747933f, 0.55472016f, -0.01116450f, -0.03469992f, -0.15111838f, 
    -0.04665532f, 0.09836910f, -0.19151953f, 0.10903227f, 0.03939371f, 0.28667456f, -0.05273993f, -0.27273375f, 
    -0.44930631f, 0.03958204f, -0.02012343f, -0.11764236f, -0.21633597f, 0.10801658f, -0.34576046f, 0.24471448f, 
    0.23213837f, -0.07816899f, 0.27801701f, 0.01235628f, 0.18555413f, 0.17810400f, -0.00085578f, 0.05920313f, 
    0.02410742f, 0.47213712f, 0.03682410f, -0.04139808f, 0.32197529f, 0.08425986f, -0.12941544f, -0.18144411f, 
    -0.12209740f, 0.00103265f, 0.07227611f, 0.29059780f, -0.13702118f, -0.13294418f, 0.33088464f, -0.00263198f, 
    0.03570928f, -0.18676044f, 0.04715356f, -0.05993027f, 0.34605446f, -0.37240747f, -0.38364124f, 0.00195502f, 
    -0.01674159f, 0.25062975f, -0.58172023f, -0.01757559f, 0.15585358f, -0.07757831f, 0.12356601f, 0.02066951f, 
    -0.11564954f, -0.55759716f, -0.62876636f, 0.12931614f, 0.09560600f, -0.08100561f, 0.11528204f, 0.04084118f, 
    0.00181054f, 0.04199241f, -0.06260998f, -0.28017256f, -0.08293649f, 0.21855560f, -0.10958895f, 0.22960939f, 
    0.32731310f, -0.36159769f, 0.26083416f, -0.10398640f, -0.05067921f, -0.13028528f, 0.07215565f, 0.16727708f, 
    0.13805242f, 0.20580536f, 0.10179984f, 0.02735211f, 0.33034876f, 0.29458973f, -0.20105308f, 0.05476855f, 
    -0.06704886f, -0.23436265f, -0.17202346f, 0.09218331f, -0.01691054f, 0.06754146f, -0.03770593f, -0.14352028f, 
    0.07925826f, -0.02053628f, 0.25607431f, -0.28008163f, 0.16142772f, 0.30158582f, -0.05838160f, 0.28159657f, 
    0.16996394f, -0.14584041f, -0.21993652f, -0.11375114f, 0.21931440f, -0.55068451f, -0.13761666f, -0.14575082f, 
    0.19237193f, -0.08113468f, -0.12793465f, 0.02106627f, 0.06115035f, 0.37179381f, 0.21185519f, -0.12777576f, 
    -0.16540094f, -0.11319770f, 0.26035389f, 0.08251141f, 0.03951870f, 0.57070166f, 0.16559492f, -0.09190466f, 
    -0.02193762f, -0.16337331f, 0.15270750f, 0.28081760f, -0.16601585f, 0.16060431f, -0.20535439f, -0.01637618f, 
    -0.09577093f, 0.35180280f, 0.09141403f, -0.13522710f, -0.07522377f, 0.09179983f, 0.08478338f, -0.17362186f, 
    0.10180061f, -0.03448547f, -0.34695342f, -0.55608857f, -0.64357555f, -0.32477844f, 0.27162439f, -0.11809572f, 
    0.00190000f, 0.03925354f, 0.09413218f, -0.11431862f, 0.16419423f, -0.02525219f, 0.14483699f, -0.11880878f, 
    0.17571068f, 0.06307106f, 0.39366686f, 0.00749902f, -0.00084521f, -0.18628407f, -0.40440676f, -0.22216834f, 
    0.21276692f, -0.23854740f, -0.36870518f, 0.02773324f, 0.02399020f, 0.17535710f, -0.12411268f, 0.67038971f, 
    0.18133177f, -0.16416605f, -0.12882960f, 0.11373025f, 0.21597046f, 0.08140360f, -0.13990314f, 0.13345788f, 
    0.01051825f, 0.09565546f, -0.48756304f, -0.05080972f, 0.11193964f, -0.19709404f, -0.00770399f, -0.02701514f, 
    -0.16718361f, -0.18932836f, -0.13359897f, -0.00013753f, 0.10791192f, -0.06301837f, 0.15380043f, 0.31153899f, 
    0.02622962f, -0.04229243f, 0.52218568f, -0.11975624f, -0.09308565f, -0.03455331f, 0.41258210f, -0.07484502f, 
    -0.40294480f, -0.22392669f, -0.78589010f, 0.33099645f, 0.23287018f, -0.31231713f, 0.09677746f, 0.04446684f, 
    0.06040313f, -0.29199922f, 0.09802200f, -0.17423823f, -0.37119186f, -0.17567301f, -0.06605598f, -0.11507399f, 
    0.09040488f, -0.41891176f, 0.13669899f, -0.12994595f, 0.13137081f, 0.35903594f, 0.14947820f, -0.47317836f, 
    -0.14617085f, 0.31766668f, -0.15779097f, -0.04230658f, 0.18226139f, -0.14575087f, -0.39490405f, 0.17506935f, 
    0.22686492f, -0.19049977f, -0.53504252f, 0.38929123f, 0.24721138f, 0.04662417f, 0.06993660f, 0.02415062f, 
    0.17162855f, -0.12635604f, -0.54659915f, 0.15931004f, 0.19458985f, 0.00757300f, -0.16183698f, 0.03597035f, 
    -0.16072485f, -0.00069617f, -0.26196456f, -0.41698003f, -0.07062402f, 0.01825668f, 0.29023239f, 0.37279901f, 
    -0.11597855f, -0.00642712f, 0.33968109f, 0.07314108f, -0.01792953f, -0.27636990f, -0.04179084f, -0.37630701f, 
    0.06323608f, -0.05156066f, 0.13085292f, -0.05619225f, -0.02141312f, 0.51918113f, -0.04867254f, -0.00730268f, 
    -0.02584971f, 0.09396898f, 0.04085287f, 0.04326266f, 0.36692020f, 0.54274005f, 0.03966221f, 0.10667416f, 
    0.13430685f, 0.02919973f, -0.01253848f, -0.13195309f, 0.06804229f, -0.12515485f, 0.14390397f, 0.11301966f, 
    0.11126668f, -0.16510949f, -0.16147943f, -0.07367391f, -0.04060507f, -0.39679551f, -0.10563984f, -0.01959857f, 
    0.31614810f, 0.25562182f, 0.09911006f, -0.18638371f, 0.22982268f, -0.11401280f, -0.51459277f, 0.11015852f, 
    0.12519839f, 0.00284169f, 0.12297010f, 0.16963750f, -0.13254514f, 0.28935474f, -0.07697921f, 0.02684025f, 
    -0.15448412f, -0.47328693f, 0.29900980f, -0.18317373f, 0.07050667f, 0.06069202f, -0.35975343f, 0.15555149f, 
    -0.09756220f, -0.45282558f, -0.38215318f, 0.14838518f, 0.21115360f, -0.14966205f, 0.26641163f, 0.49352267f, 
    -0.48409474f, 0.18307737f, -0.19603725f, 0.13605306f, 0.06413320f, -0.11803096f, 0.14806506f, -0.16749528f, 
    0.11769895f, 0.31118155f, 0.07504075f, 0.13892886f, -0.26253515f, 0.02126672f, -0.10688435f, -0.15382992f, 
    0.05031193f, 0.15187298f, 0.19515660f, 0.38647377f, -0.03404191f, -0.23611043f, 0.06990469f, 0.09745166f, 
    -0.34253091f, 0.18149808f, 0.43490249f, 0.00738859f, -0.08852515f, 0.53435665f, -0.10457818f, 0.16126575f, 
    0.42121941f, 0.12341207f, 0.17654026f, -0.14129235f, 0.11779965f, -0.21130560f, -0.13950041f, 0.07330669f, 
    0.12571780f, 0.18591022f, 0.02468765f, -0.04537339f, 0.28399023f, -0.21612726f, 0.13581131f, -0.17527111f, 
    0.03606327f, -0.04655384f, -0.42652524f, -0.01816632f, 0.08580042f, -0.03129633f, 0.41771752f, 0.15485445f, 
    -0.24818966f, 0.38700882f, -0.31073824f, -0.11646082f, -0.04688876f, -0.24387649f, -0.35601655f, -0.06780988f, 
    0.08422449f, 0.24299046f, -0.09990397f, -0.07075343f, 0.09487261f, 0.10944749f, 0.30275014f, -0.15233624f, 
    -0.01920621f, -0.02512502f, 0.03873061f, 0.10510798f, 0.37916249f, 0.13335340f, -0.06620642f, -0.12436210f, 
    0.05215823f, 0.16249990f, 0.08655552f, 0.40642178f, 0.08958422f, 0.26784518f, -0.24216409f, -0.35124496f, 
    0.02319981f, -0.22680368f, 0.10277345f, 0.10756112f, -0.26400518f, 0.60126507f, -0.08619962f, -0.25572744f, 
    -0.23713228f, -0.08264231f, 0.18356504f, 0.21772224f, 0.14519042f, 0.29642928f, -0.23150988f, 0.11145475f, 
    0.00621557f, 0.18623477f, 0.26927811f, -0.14415829f, -0.32342321f, -0.05120882f, 0.10291738f, -0.06839695f, 
    0.02858489f, -0.14931262f, 0.03188633f, 0.15766481f, -0.03464964f, -0.03951540f, 0.43310189f, -0.38330883f, 
    0.01529311f, 0.04094085f, 0.18905406f, 0.06555285f, 0.29917714f, -0.10536562f, -0.38832101f, 0.13418579f, 
    0.09006972f, 0.20404066f, -0.43625513f, 0.23666678f, 0.23860815f, -0.06314933f, -0.14344999f, -0.11065373f, 
    0.08019845f, 0.03234337f, -0.21494879f, 0.12706880f, 0.12299888f, -0.26446229f, 0.16513292f, 0.06296092f, 
    -0.16762304f, 0.35527515f, -0.35357237f, -0.38145742f, -0.12968652f, -0.09135893f, 0.25976440f, 0.31698084f, 
    0.31071422f, -0.21814193f, 0.22349665f, 0.01350747f, 0.22870681f, -0.01549324f, 0.49866578f, 0.59158897f, 
    0.16110982f, 0.02849114f, -0.07123620f, -0.29846281f, 0.15603086f, -0.29226950f, 0.07920931f, -0.12206321f, 
    -0.12220759f, 0.08466659f, 0.10459697f, 0.08585763f, -0.28174192f, 0.17354438f, -0.12398886f, -0.15135877f, 
    -0.12230942f, -0.31860009f, 0.06606744f, 0.12340972f, 0.13234772f, 0.16679339f, -0.13093868f, 0.74734229f, 
    0.13031487f, 0.05460759f, -0.17498922f, -0.13937953f, -0.02276418f, 0.42419544f, -0.44226629f, 0.10640238f, 
    -0.14344306f, 0.13399428f, -0.16488463f, 0.25837648f, 0.14578135f, -0.09957829f, -0.11153588f, 0.10250961f, 
    0.06211284f, 0.26171580f, -0.10550604f, -0.06951696f, -0.00473241f, -0.30617288f, 0.00524414f, 0.11942945f, 
    -0.03624617f, 0.14773242f, -0.28778833f, -0.06064186f, 0.11203358f, -0.40044430f, 0.29372889f, -0.01800949f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00065927f, 0.08946013f, 0.09777515f, -0.11797662f, -0.03190191f, 0.12808183f, -0.20319124f, 0.02723712f, 
    0.16540246f, 0.11352619f, 0.03810862f, -0.08816588f, 0.06370054f, -0.02536359f, 0.27081531f, 0.30676231f, 
    -0.26656276f, -0.00811185f, 0.14149462f, 0.12067997f, 0.16605493f, -0.05718764f, 0.03811078f, 0.22865480f, 
    0.07824906f, -0.00714955f, -0.11226913f, 0.19983244f, -0.18684559f, 0.08178369f, -0.00100570f, 0.17738645f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10967818f, -0.24438322f, -0.22130956f, -0.14787726f, -0.07699440f, -0.33712849f, 0.05304755f, 0.36039162f, 
    -0.28229278f, -0.11886838f, -0.14036128f, -0.12320959f, -0.12684523f, 0.31039742f, -0.42850819f, -0.66647291f, 
    -0.06994406f, 0.18223222f, 0.02294692f, 0.03766288f, -0.55899358f, 0.20805955f, -0.23631905f, -0.35720643f, 
    -0.45642003f, 0.04668535f, -0.47489208f, -0.14074627f, -0.39860979f, -0.83688200f, 0.32053259f, -0.26418710f, 
    -0.16862541f, 0.14564462f, 0.14632253f, -0.18346085f, 0.16821410f, -0.12099551f, 0.02890622f, 0.14349087f, 
    -0.53013450f, 0.00321029f, 0.01374082f, 0.01640947f, 0.35450563f, -0.21308371f, 0.32026735f, -0.02576254f, 
    0.84784484f, 0.10345376f, 0.19390711f, 0.02784103f, -0.05636436f, -0.17454995f, 0.09497885f, -0.05071063f, 
    0.12555324f, -0.33787256f, 0.09752608f, 0.24850960f, -0.53931105f, 0.06756049f, 0.14872359f, -0.38673925f, 
    -0.03170130f, -0.39928871f, -0.02624250f, -0.41586623f, -0.18269803f, -0.01211032f, 0.03741917f, 0.24998261f, 
    0.18528895f, -0.66836679f, -0.00666928f, 0.03299574f, -0.65054590f, 0.12561356f, 0.31850472f, -0.13744961f, 
    -0.37698209f, -0.13204451f, -0.17243311f, 0.18787278f, 0.23382105f, -0.71538842f, 0.57462341f, -0.34144482f, 
    0.25699362f, -0.27301729f, -0.06791428f, 0.21728458f, -0.16320699f, 0.30012202f, -0.39750835f, 0.21284576f, 
    0.07825152f, -0.62120974f, 0.18332468f, 0.23445690f, -0.03460606f, -0.08802404f, -0.08530640f, -0.14719561f, 
    0.12649250f, -0.48901546f, 0.15411836f, -0.11432362f, -0.34954083f, 0.10096676f, -0.29282174f, -0.08362298f, 
    0.04622259f, 0.12993436f, -0.42064926f, -0.67493379f, 0.11555768f, 0.19780645f, 0.17290543f, -0.51961219f, 
    -0.30793604f, 0.18411744f, 0.14171015f, -0.62230080f, 0.09508646f, 0.17508724f, 0.18085906f, -0.11608276f, 
    0.25732735f, -0.01125789f, -0.16976273f, -0.12605314f, 0.23276554f, -0.40560311f, 0.11632535f, 0.14983411f, 
    0.39269665f, -0.14422570f, -0.12666637f, 0.05261893f, 0.20079966f, -0.06386621f, -0.34041220f, -0.08556625f, 
    -0.44838920f, -0.19926742f, 0.07195715f, -0.72721523f, -0.62385815f, 0.21811254f, 0.07262095f, -0.04763522f, 
    -0.00396718f, -0.14154024f, -0.25168833f, -0.06125423f, 0.26296592f, -0.27815419f, -0.06987426f, -0.33290830f, 
    -0.08856460f, 0.18880811f, -0.04420216f, -0.11170281f, 0.00301048f, -0.01166691f, -0.01874905f, -0.06442296f, 
    -0.03017817f, 0.55860442f, -0.11971585f, -0.00904113f, -0.05937010f, 0.11739472f, -0.02215624f, 0.12931232f, 
    -0.71010667f, -0.13872930f, 0.29269114f, -0.26727030f, -0.08454026f, -0.22397012f, 0.02484647f, -0.00027227f, 
    -1.06443238f, 0.29868349f, -0.50422007f, 0.19082056f, -0.11105038f, -0.39126283f, 0.05078678f, -0.16297480f, 
    -0.12135740f, 0.00262670f, -0.29738012f, -0.50351655f, -0.62354738f, -0.27069542f, -0.02237595f, -0.72973078f, 
    0.37986624f, -0.62445021f, 0.15691005f, 0.05610794f, 0.14133975f, -0.52390522f, 0.23700286f, 0.23414145f, 
    0.09498079f, -0.93648446f, -0.14086607f, -0.11861262f, -0.30652615f, -0.14192227f, -0.36404756f, -0.05824147f, 
    -0.14789164f, -0.29466116f, 0.29329363f, 0.18535469f, -0.12521003f, 0.35683650f, -0.43491799f, 0.15536909f, 
    -0.39852744f, -0.39876777f, -0.50124836f, -0.49131197f, -0.82952517f, -0.33273089f, -0.04292041f, 0.37603751f, 
    -0.28262958f, -0.57324821f, -0.13315269f, -0.16047366f, 0.09087440f, 0.11965224f, -0.43914339f, 0.19415234f, 
    0.02109926f, -0.24939078f, 0.05378818f, -0.33842382f, 0.25694770f, -0.46495289f, -0.59898216f, -0.27334598f, 
    0.01920825f, 0.02085395f, 0.12560561f, -0.29822016f, 0.22237530f, -0.25671044f, 0.31169996f, 0.14735059f, 
    -0.66520965f, 0.26479480f, 0.06840172f, -0.04924025f, -0.65659142f, 0.46317762f, -0.06900588f, -0.67027313f, 
    -0.12532584f, -0.24067788f, -0.05358583f, -0.14270322f, -0.32574531f, -0.61135328f, -0.08008389f, 0.00328914f, 
    0.07563435f, -0.17010632f, -0.27459139f, 0.13818286f, 0.20611742f, -0.55950308f, 0.10315698f, -0.62463635f, 
    0.20464900f, 0.55920649f, -0.07740925f, 0.02372216f, -0.19629788f, 0.25183111f, 0.11197612f, 0.16533920f, 
    -0.14881447f, 0.00176386f, -0.67481250f, -0.67316324f, 0.19782458f, -0.33855438f, -0.07575215f, 0.50337362f, 
    0.44986403f, -0.02998524f, -0.11116263f, -0.14217789f, -0.25688222f, 0.15341598f, 0.10636954f, 0.21262254f, 
    -0.24454421f, -0.11022760f, -0.51489764f, 0.15262245f, -0.06457709f, -0.55748886f, -0.43824360f, 0.02926430f, 
    -0.57843065f, -0.61334056f, 0.06299966f, 0.06087189f, 0.12358510f, -0.87331599f, -0.24798566f, -0.17715275f, 
    0.27640733f, 0.26819235f, 0.15782514f, 0.37221220f, 0.18429264f, 0.31225345f, 0.08432594f, -0.56461591f, 
    -0.29284424f, -0.12257428f, 0.03193970f, 0.10665698f, -0.65861118f, -0.73419839f, -0.57295281f, -0.07788903f, 
    0.17000926f, 0.07681972f, 0.05825805f, -0.44674608f, -0.29779199f, -0.18540686f, 0.25866413f, 0.46594247f, 
    -0.70658416f, -0.20223305f, 0.10083646f, -0.61811090f, -0.33827284f, 0.32736099f, 0.12139122f, -0.08959969f, 
    -0.04353663f, 0.34901372f, 0.79296136f, -0.73473352f, -0.07041031f, -0.37144488f, 0.00318149f, -0.52463508f, 
    -0.25786823f, -0.79519391f, -0.16640593f, 0.16516107f, -0.08103897f, 0.13786505f, 0.16959368f, 0.02469640f, 
    -0.23502710f, 0.24700108f, -0.46208900f, 0.05313648f, -0.13177486f, -0.68791872f, -0.57951891f, 0.10795610f, 
    -0.67885315f, -0.03365623f, -0.02751995f, -0.32083100f, 0.41346779f, -0.04448985f, -0.34414592f, 0.14841117f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.21799286f, -0.00965369f, 0.08640289f, -0.06282993f, -0.04707932f, 0.12461305f, -0.06606962f, -0.12978312f, 
    0.37845033f, -0.07193690f, 0.19137198f, 0.04994595f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
