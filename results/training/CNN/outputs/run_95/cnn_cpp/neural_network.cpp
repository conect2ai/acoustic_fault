#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.52992886f, -0.67270160f, 0.48447749f, 0.89247006f, 0.01496760f, -0.18030471f, 0.22339298f, -0.29724452f, 
    0.11205245f, -0.14456855f, 0.47145411f, -0.06956257f, 0.03794582f, -0.26243526f, -0.31261763f, -0.43924373f, 
    0.14874434f, 0.38894215f, 0.34408718f, -0.36638698f, -0.22540300f, 0.11998639f, 0.08761092f, 0.31251961f, 
    0.06732071f, 0.05659587f, 0.92207778f, 0.60560054f, -0.15450607f, 0.05066866f, -0.55009878f, 1.10790253f, 
    -0.33102208f, -0.44860271f, 0.33248845f, 0.01453997f, 0.20144001f, 0.05804076f, -0.27196160f, 0.15442038f, 
    0.09591001f, -0.10778482f, -0.16021392f, 0.05766052f, -0.04586078f, 0.02761120f, 0.18832952f, -0.06760323f, 
    -0.07584204f, 0.27526250f, -0.14784217f, -0.24470356f, 0.57697678f, 0.58687675f, 0.74581373f, 0.72211885f, 
    0.40789312f, 0.44307199f, -0.18610099f, -0.41088346f, 0.29790431f, -0.02113688f, 0.16923429f, 0.28002441f, 
    0.16517577f, -0.05218848f, 0.24966468f, 0.34169242f, 0.08938752f, 0.15654722f, -0.41995925f, -0.32009202f, 
    0.21238248f, -0.03396250f, -0.08648343f, -0.66934377f, -0.79980773f, 0.31497693f, 0.73272198f, -0.17289917f, 
    0.53733820f, 0.47604740f, -0.01270240f, 0.37667233f, -0.18957083f, -0.45390931f, -0.06430862f, -0.12439613f, 
    0.22475834f, 0.16982813f, 0.03358731f, -0.14741175f, -0.46058711f, -0.59878552f, -0.29736555f, 0.02859693f, 
    0.18906769f, -0.20926425f, 0.02570893f, -0.33352461f, -0.04456359f, -1.33896446f, -0.08469605f, 0.43171614f, 
    -0.21433617f, -0.62414753f, 0.60471880f, 0.85661715f, -0.35870606f, -0.31773037f, 0.08106841f, -0.03077202f, 
    -0.32213196f, 0.09258939f, -0.02734148f, 0.15790899f, -0.01600485f, -0.36234772f, 0.03461392f, -0.19501251f, 
    0.13929364f, 0.14931025f, -0.08999652f, 0.15151370f, 0.38459107f, -0.37066403f, -0.70384210f, -0.45346507f, 
    -0.17368053f, -0.14186621f, -0.16951291f, -0.49690020f, -0.23782881f, -0.11732962f, 0.33549762f, -0.31126571f, 
    0.42985582f, -0.18702456f, -0.09171946f, -0.27520797f, 0.20676494f, 0.14729391f, 0.40300080f, -0.24601017f, 
    0.20045473f, 0.16306312f, 0.47441849f, -0.18535696f, -0.08463874f, -0.19404797f, 0.90580487f, 0.56024969f, 
    0.08939313f, 0.69740552f, -0.52997214f, -0.03958270f, -0.13501568f, 0.13492556f, -0.42609021f, 0.06047349f, 
    -0.41654491f, 0.17511220f, 0.04647318f, 0.52969968f, -0.27276820f, -0.12951426f, 0.05753903f, -0.07687950f, 
    -0.07242605f, -0.10254571f, 0.00595474f, -0.04851351f, -0.11838544f, 0.20904471f, -0.11528551f, 0.57237697f, 
    0.03017078f, -0.64680386f, -0.60240114f, 0.33905637f, 0.01750766f, -0.30455479f, -0.64046448f, 0.32962304f, 
    0.28842372f, 0.12021296f, -0.47141919f, 0.33567038f, 0.19295008f, -0.13631935f, 0.03459216f, 0.17424627f, 
    -0.39040154f, -0.11278429f, 0.41629982f, 0.22716522f, -0.05387609f, 0.13696305f, 0.01082277f, -0.08614337f, 
    0.54684746f, -0.12306724f, 0.34908554f, 0.03483812f, -0.37305897f, 0.28938988f, -0.59098345f, -0.36912155f, 
    -0.17135020f, -0.02548576f, -0.38760561f, -0.63132435f, -0.24220629f, -0.54772371f, -0.42090198f, -0.56559134f, 
    -0.02472313f, -0.12672000f, -0.28822196f, 0.06697574f, 0.49516469f, -0.28263825f, 0.36108845f, 0.20747791f, 
    -0.10184035f, -0.42487368f, 0.38396049f, -0.76890844f, -0.48794192f, -0.62168252f, 0.56373316f, 0.25001770f, 
    0.21902291f, 0.27016681f, 0.56901991f, -0.39653686f, -0.45300081f, -0.38655081f, -0.29625458f, -0.73277313f, 
    0.07925940f, 0.09782480f, 0.13374022f, 0.03956896f, 0.24419703f, -0.03476176f, -0.15218496f, -0.29870921f, 
    -0.12109831f, 0.26907977f, -0.40968552f, -0.67440736f, -0.95253205f, -0.30714142f, -0.09499434f, -0.80961657f, 
    0.53861475f, 0.79583955f, 0.01014359f, 0.41212031f, 0.20472117f, 0.08053801f, 0.40200093f, -0.10833554f, 
    -0.07362334f, -0.30246025f, 0.03200674f, 0.08191300f, -0.07991300f, -0.19261909f, -0.09071391f, 0.05314622f, 
    -0.13782510f, -0.18628995f, -0.08499723f, -0.41921493f, 0.26424617f, -0.10423353f, -0.52162486f, -0.45611477f, 
    -0.52444899f, -0.20579048f, -0.64810276f, -0.70109248f, -0.41935626f, 0.24663290f, 0.15135857f, 0.46529594f, 
    0.23436783f, 0.03310410f, -0.12031312f, 0.07354118f, 0.27508539f, 0.09160578f, 0.10935144f, 0.42768320f, 
    0.12954399f, -0.24523006f, 0.08323650f, 0.15641542f, 0.58383828f, 0.23866440f, 0.38711086f, 0.37126309f, 
    0.02238037f, -0.56172115f, -0.67195874f, 0.04312291f, -0.18591338f, 0.04056576f, -0.15310745f, -0.55790675f, 
    -0.25198174f, -0.00793862f, -0.07096794f, -0.17422682f, 0.00556438f, 0.35301480f, -0.11747211f, 0.01419703f, 
    0.18718825f, 0.01106139f, -0.03660180f, 0.06644073f, 0.18928628f, -0.39110786f, 1.07739711f, 0.23103695f, 
    -1.03028452f, 0.46225059f, -0.13101587f, -0.45400497f, -0.57027978f, -0.12361062f, -0.52165556f, 0.04313982f, 
    0.57530993f, 0.20228361f, 0.04085569f, 0.16045080f, -0.06712315f, 0.22451137f, -0.28827128f, -0.04798241f, 
    -0.00984354f, 0.07892226f, -0.22052839f, -0.14540315f, 0.29439273f, -0.05268874f, -0.81324631f, -0.49528331f, 
    -0.88767523f, -0.37179235f, -0.02392025f, -0.41509023f, 0.31686154f, 0.14212988f, -0.01031984f, 0.78751957f, 
    -0.23550619f, 0.27843076f, 0.50157380f, -0.24976720f, -0.29891664f, -0.14422686f, -0.21001904f, 0.14210320f, 
    0.07889590f, -0.11579396f, 0.28692618f, -0.01181902f, -0.33018410f, 0.11061788f, 0.05174574f, 0.43606979f, 
    0.16179679f, -0.85393357f, -0.67546481f, -0.28426388f, 0.17546996f, -0.18827893f, 0.20828560f, 0.44905475f, 
    0.40511358f, -0.14391622f, 0.03555045f, -0.32780105f, -0.11042888f, -0.26384202f, 0.09507485f, 0.01959691f, 
    0.13422501f, -0.06471847f, 0.38134879f, -0.00254258f, 0.17008960f, -0.38086116f, 0.24418932f, -0.45454010f, 
    0.98097247f, 0.50925004f, 0.81105399f, 0.34032837f, 0.32376525f, 0.63752037f, 0.09408675f, -0.52634525f, 
    0.18951364f, -0.02035884f, 0.07989198f, 0.45569307f, -0.26931483f, -0.30047944f, -0.04278329f, -0.19486824f, 
    -0.08865431f, 0.07816119f, -0.35731864f, -0.22221039f, -0.00612440f, 0.23109062f, 0.23754159f, 0.05750945f, 
    0.16738017f, 1.00026500f, 0.48825634f, 0.83398211f, -0.34802717f, 0.27723402f, -0.26600230f, -0.19452588f, 
    -0.13209517f, -0.01049177f, 0.18613908f, -0.20709856f, -0.10486337f, 0.03044014f, 0.19652121f, 0.27294597f, 
    0.06689073f, -0.21860465f, -0.12941812f, 0.27427956f, -0.22184271f, 0.35037726f, 0.18279986f, 0.12618893f, 
    -0.04100188f, 0.32229397f, 0.95431173f, 0.80354714f, -0.21406215f, -0.18225098f, -0.12663457f, -0.36778593f, 
    0.19952668f, 0.05436796f, 0.25155118f, 0.00594488f, -0.08912461f, 0.23564534f, 0.21675085f, -0.02981267f, 
    0.11458734f, 0.21419054f, -0.22576463f, 0.25331652f, 0.10842653f, 0.15866268f, -0.04167844f, 0.03989499f, 
    -0.24774915f, -0.30047894f, -0.01780019f, 0.99851209f, 0.62321204f, -0.19295771f, 0.55707067f, 0.87353408f, 
    0.15439188f, -0.08824337f, 0.21289718f, 0.29159486f, -0.01248065f, 0.03521064f, 0.33644900f, 0.14286801f, 
    0.15517156f, 0.05947949f, 0.35964575f, 0.06437764f, -0.02208189f, 0.12907623f, 0.29789877f, -0.06110625f, 
    -0.18305789f, -0.23548613f, 0.03626202f, 0.50402629f, -0.08050530f, 0.50713259f, 0.53422892f, 0.47279415f, 
    -0.22774746f, -0.93212247f, 0.09733379f, -0.12797596f, -0.51545054f, 0.06491931f, 0.51368988f, 0.35198155f, 
    -0.07165592f, -0.00434537f, 0.24292542f, 0.33303684f, 0.04938688f, 0.45779967f, 0.26635313f, -0.09778894f, 
    -0.18734008f, 0.20715284f, 0.01170158f, -0.15276760f, 0.12706347f, 0.68136638f, 0.57994264f, -0.05927435f, 
    0.11274172f, -0.46909627f, 0.37545621f, 0.56233770f, -0.57234466f, -0.06317173f, -0.40211889f, -0.02953585f, 
    -0.04367568f, -0.59253603f, 0.09383045f, 0.24325165f, 0.31938112f, 0.18805121f, 0.48186088f, 0.47998586f, 
    -0.02998468f, -0.08449518f, -0.44727138f, -0.27963448f, -0.33061939f, -0.21953979f, 0.95048320f, 0.06411566f, 
    0.37907377f, 0.54982984f, 0.17649925f, 0.36831844f, 0.04818885f, 0.00782270f, 0.49285600f, 0.05930667f, 
    -0.51037771f, 0.00940520f, -0.25131726f, 0.29976299f, -0.12387574f, 0.56568903f, 0.19581638f, -0.33181804f, 
    -0.30751702f, 0.20225897f, -0.19813918f, 0.12515691f, -0.03363974f, 0.04308627f, 0.11403698f, 0.04815413f, 
    -0.00101549f, -0.04991504f, -0.54299438f, -0.16602550f, 0.04973447f, -0.91581988f, 0.26236355f, 0.34139287f, 
    0.18923213f, 0.32267395f, -0.13182737f, -0.46845189f, -0.22422528f, -0.14597039f, 0.21240430f, 0.26341903f, 
    0.22061346f, 0.24187756f, 0.29491273f, 0.58051437f, 0.27907309f, -0.08268714f, 0.02939069f, 0.32190990f, 
    0.52944052f, -0.15527825f, -0.50044620f, -0.76740402f, -0.56483060f, -0.48618597f, 0.33070955f, 0.27085018f, 
    -0.02982366f, 0.17136021f, 0.22354433f, -0.37265700f, -0.31050476f, -0.46980232f, -0.32232574f, -0.22929385f, 
    -0.01550171f, 0.06073383f, -0.07746145f, -0.29797897f, 0.07137155f, 0.13283505f, -0.10095595f, -0.00231055f, 
    -0.06305198f, -0.51019287f, 0.27932978f, 0.69083834f, 0.28214720f, 0.66422153f, -0.70449138f, 0.00448334f, 
    0.18944952f, -0.59445268f, 0.10042381f, 0.30387932f, 0.08481598f, 0.44662443f, 0.28680462f, -0.02333802f, 
    0.42052776f, 0.29104486f, 0.17520829f, -0.15878642f, 0.35815340f, -0.00847077f, -0.11273633f, -0.40655234f, 
    -0.01859126f, -0.12528810f, -0.84408772f, 0.03155582f, 0.40801454f, 0.23760399f, -0.81167340f, -0.35791197f, 
    -0.43063048f, 0.10865441f, 0.11948165f, 0.07000269f, 0.03562260f, 0.19365118f, 0.03624169f, 0.09402665f, 
    0.24161333f, -0.03443751f, -0.33001727f, 0.04833681f, 0.22953825f, -0.34016067f, -0.13453197f, 0.10982065f, 
    -0.20050064f, -0.17475536f, -0.30047327f, -0.44895408f, -0.08608589f, 0.94261283f, 0.31904018f, -0.71923351f, 
    -0.67607951f, 0.11280501f, 0.31145564f, 0.21572904f, -0.34494627f, -0.09656291f, 0.28506723f, -0.08174880f, 
    -0.29948148f, -0.06676024f, 0.06702117f, 0.09363941f, -0.04660642f, -0.21657330f, 0.15091495f, 0.05717629f, 
    0.08257665f, -0.06953029f, 0.12542008f, -0.13512996f, 0.04127787f, 0.58262479f, 0.77798706f, 0.57319641f, 
    0.27987245f, -0.01380532f, -0.41636831f, 0.14769091f, 0.42973807f, 0.15418032f, 0.26846743f, 0.10295445f, 
    -0.35700789f, 0.23534907f, -0.32286972f, 0.34737787f, 0.23935388f, 0.10104208f, 0.36068144f, -0.29144168f, 
    0.20949715f, -0.37656611f, -0.40982535f, 0.06707133f, 0.33291972f, 0.18572757f, 0.31373286f, -0.41540468f, 
    -0.23481609f, -0.53481227f, 0.04564387f, -0.37361842f, -0.27871260f, -0.57769489f, -0.45610353f, 0.51446760f, 
    -0.10014866f, -0.21649058f, 0.26900846f, -0.14855680f, 0.18520857f, -0.04591479f, -0.39975852f, -0.43035585f, 
    0.06142858f, -0.16992168f, 0.36322215f, -0.05392796f, 0.17628457f, -0.30984920f, 0.31020397f, 0.34518501f, 
    -0.12416871f, 0.74116725f, 0.18547133f, -0.90568417f, -0.73095548f, -0.72571045f, 0.36528146f, -0.36326501f, 
    0.10044619f, -0.07173957f, 0.20613894f, -0.04986946f, -0.18072309f, -0.10314236f, 0.23934762f, -0.18161078f, 
    -0.06766216f, -0.00759955f, -0.27070230f, -0.02131075f, 0.12195058f, -0.13267721f, 0.00974232f, 0.24930882f, 
    -0.58157086f, -0.32503110f, -0.45551869f, -0.56039071f, 0.52545565f, 0.81920433f, 0.06949692f, 0.20531724f, 
    0.25139922f, -0.01350921f, -0.21140663f, -0.31923005f, -0.22736467f, -0.20372887f, -0.15954053f, 0.01612602f, 
    0.04985717f, 0.05489969f, 0.07252497f, 0.03564298f, 0.03084243f, -0.21466339f, -0.24864037f, 0.16370013f, 
    0.61557460f, -0.03677605f, -0.20639592f, 0.84795219f, -0.38120410f, -0.65250236f, 0.43728289f, 0.57562900f, 
    -0.38889346f, -0.19944862f, -0.24857678f, -0.15913191f, -0.25078115f, -0.28756762f, 0.31791064f, -0.08571465f, 
    -0.19101304f, 0.10790630f, 0.11967250f, 0.19682308f, 0.41975275f, -0.23041898f, 0.23686926f, -0.20277712f, 
    0.08517848f, 0.93855971f, 0.52662051f, -0.17350419f, 0.46209857f, 0.49334726f, 0.45837435f, 0.29815239f, 
    0.31299052f, 0.38129303f, 0.46357927f, -0.41984516f, -0.40714860f, 0.11110521f, -0.57124668f, -0.14926979f, 
    -0.35642880f, -0.28911358f, -0.17962667f, -0.28657857f, 0.11249733f, 0.21999209f, -0.23519002f, 0.21335444f, 
    -0.20590091f, -0.24006388f, -0.23539865f, -0.50036287f, 0.69653845f, -0.31846359f, -0.81209379f, 0.60716474f, 
    -0.05918940f, 0.56256455f, -0.35691488f, 0.08038508f, 0.31834528f, -0.35318625f, -0.58280551f, 0.25618187f, 
    0.34521091f, -0.22556590f, 0.03626683f, -0.31373888f, -0.31331283f, 0.04934933f, -0.09803846f, 0.30374733f, 
    0.33927262f, 0.34348017f, -0.32354611f, 0.64463335f, 0.26544312f, -0.56260890f, -0.74750906f, -0.64057958f, 
    -0.50302321f, 0.23794948f, 0.34566864f, -0.02304963f, 0.12484389f, 0.12683026f, -0.24699275f, -0.04211323f, 
    -0.37490836f, 0.18083876f, 0.21428724f, 0.30331784f, -0.20255193f, -0.01861736f, 0.03462576f, -0.33893922f, 
    -0.01271482f, 0.18999636f, 0.09692261f, 0.01470679f, 0.10502589f, -0.55046350f, -0.53629661f, -0.35090309f, 
    -0.64564633f, -0.00122161f, 0.68132514f, 0.55961806f, 0.22104886f, 0.54724419f, -0.36594966f, -0.32960263f, 
    -0.22989468f, -0.30149099f, 0.06049182f, -0.37789366f, 0.04709897f, -0.23114367f, 0.09602487f, -0.19747716f, 
    -0.42184475f, -0.26485169f, 0.00072381f, -0.20795193f, 0.12574662f, -0.69402635f, -0.56482518f, -0.55995560f, 
    -0.46104270f, -0.72323304f, 0.23201402f, 0.74939317f, -0.56706828f, -0.27854192f, 0.25769895f, 0.08606158f, 
    -0.27066317f, 0.30437419f, -0.03182445f, 0.34858787f, -0.04864594f, 0.19799358f, 0.02599597f, 0.11415311f, 
    -0.03424369f, 0.04524906f, -0.08022785f, 0.05470046f, -0.30662546f, 0.06565151f, 0.55168593f, -0.20226346f, 
    0.69941610f, 0.13951673f, 0.78975964f, -0.04630579f, 0.50122297f, 0.14109361f, -0.36298555f, 0.58051986f, 
    0.09491854f, -0.12155437f, -0.04742222f, -0.08486478f, -0.34158149f, -0.23958926f, -0.20994228f, -0.18421037f, 
    0.15764709f, -0.19243149f, 0.40899882f, 0.29589075f, 0.24476027f, -0.16384403f, 0.19406487f, -0.66451448f, 
    -0.39067021f, 0.06425831f, -0.03482922f, 0.17581242f, -0.71121359f, 0.17345746f, -0.25399452f, -0.50400221f, 
    -0.55608875f, 0.06178533f, 0.13290627f, -0.19172515f, 0.06018145f, 0.07506098f, 0.33039519f, 0.30560270f, 
    0.05448389f, -0.21528052f, 0.11212109f, -0.42116284f, -0.21125302f, 0.58651590f, 0.29668808f, 0.44644994f, 
    0.64967769f, -0.29947942f, -0.07804732f, 0.29470456f, 0.36591694f, 0.18588482f, 0.04223867f, 0.37965170f, 
    0.55288339f, 0.58712178f, -0.21610609f, -0.05992890f, -0.51568270f, 0.20702134f, -0.17752281f, -0.00252750f, 
    0.12251362f, 0.31819820f, -0.04974679f, 0.08471716f, 0.20167331f, 0.11891359f, 0.20870540f, -0.14416565f, 
    0.30763909f, 0.12155575f, 0.06187772f, -0.39145446f, 0.40581673f, -0.21741986f, 0.58598518f, 0.11574450f, 
    -0.33147722f, 0.20815861f, -0.19010888f, 0.43921763f, 0.42694458f, -0.35185313f, 0.36779007f, -0.29866976f, 
    0.31211784f, -0.27398726f, -0.51890492f, 0.19349107f, 0.29606491f, 0.47599605f, -0.39721164f, 0.31003419f, 
    -0.08949347f, -0.25895146f, -0.01433296f, -0.59848386f, -0.01450538f, 0.87975359f, 0.49326631f, 0.53652167f, 
    0.84818333f, -0.21022585f, 0.05242625f, 0.07028037f, -0.25975749f, 0.00878109f, -0.06194267f, 0.20934349f, 
    0.34032008f, -0.27452570f, -0.00264692f, -0.42023170f, -0.19221075f, 0.15583444f, 0.18544756f, 0.11830293f, 
    0.17940238f, -0.13531464f, -0.03522384f, 0.28546292f, -0.33367881f, 0.30715933f, 0.28252265f, 0.58361048f, 
    -0.61892629f, 0.09304883f, -0.50684804f, -0.62253469f, 0.59831321f, 0.48760322f, 0.54767346f, -0.25506440f, 
    0.28206202f, -0.27028891f, -0.17676423f, -0.45127887f, -0.34272549f, 0.02943463f, -0.18824185f, 0.07188108f, 
    0.07909590f, -0.12423797f, -0.07283965f, -0.05886498f, -0.34573770f, -0.56023079f, -0.67142260f, 0.42451093f, 
    0.58385259f, 0.65835661f, 0.83786428f, -0.44177279f, 0.38991627f, -0.19815347f, 0.13978732f, -0.02041587f, 
    -0.36230129f, -0.26738456f, -0.19186012f, 0.09947694f, -0.03091093f, -0.30071336f, -0.25118688f, -0.07777172f, 
    0.11843967f, 0.06405624f, 0.25664932f, 0.18221270f, 0.06432085f, 0.36694044f, -0.93596911f, 0.42501453f, 
    0.81649888f, 0.32455236f, 0.36835623f, 1.02522135f, 0.35971937f, 0.14332126f, 0.55595100f, -0.36525857f, 
    0.25377825f, 0.06263400f, 0.27892974f, -0.01143204f, -0.30699134f, -0.09372201f, -0.00540508f, 0.15702996f, 
    -0.09209125f, 0.07055142f, -0.08760985f, -0.07345702f, -0.12442375f, -0.07009371f, 0.84302509f, 0.37999514f, 
    -0.51048374f, 0.82549536f, 0.30517164f, 0.65344870f, 0.07301207f, -0.65619284f, 0.24233590f, -0.17314635f, 
    -0.46372813f, -0.25831026f, -0.19548315f, 0.06201497f, -0.42288104f, -0.06570718f, 0.14576162f, -0.20614411f, 
    -0.04096935f, -0.19065507f, -0.16254741f, -0.14382182f, -0.21800312f, -0.12965737f, -0.03602767f, 0.15788887f, 
    0.01774074f, -0.71975070f, -0.95348769f, -0.12007706f, 0.49708098f, 0.14546107f, 0.17792639f, 0.63944185f, 
    -0.02178374f, -0.12352444f, 0.02878517f, 0.06664704f, -0.18891209f, -0.15322730f, 0.21771555f, -0.30437958f, 
    0.16418703f, -0.07187353f, -0.08687194f, -0.19851820f, -0.29912174f, -0.32685870f, -0.23584904f, 0.29192370f, 
    -0.40315139f, 0.27835527f, 0.61286497f, -0.75309438f, 0.12060487f, -0.73422742f, 0.06461037f, 0.42242408f, 
    0.09467675f, -0.51620108f, 0.25666204f, -0.03005278f, 0.07698358f, 0.24204013f, 0.15600903f, 0.31189865f, 
    -0.45272419f, 0.02157274f, -0.33809307f, 0.39380240f, 0.28001073f, 0.00012295f, -0.07967061f, -0.03736555f, 
    0.05390601f, -0.40575483f, -0.45853913f, -0.82813418f, -0.00749799f, 0.42494565f, -0.53098524f, 0.07962092f, 
    -0.14017569f, 0.67699105f, -0.20371135f, -0.13041621f, -0.08089914f, 0.03510338f, -0.02277416f, -0.35507125f, 
    0.06985743f, -0.32686386f, 0.15436403f, 0.22229683f, 0.15648551f, 0.17216493f, 0.18510976f, -0.32309687f, 
    0.03507056f, 0.27498806f, 0.28628638f, 0.65028733f, 0.78073442f, 0.26342848f, -0.54756433f, -0.72610950f, 
    0.24753132f, -0.02569533f, -0.27948385f, -0.48367554f, 0.12486176f, 0.23856221f, -0.21202612f, 0.28914410f, 
    0.06726761f, -0.19237384f, -0.16170669f, -0.13640209f, -0.18024936f, -0.26346573f, -0.33214718f, 0.17998293f, 
    0.05307595f, 0.16635324f, 0.21713684f, 0.67110437f, 0.53265673f, 0.50893015f, 0.44276354f, -0.17879030f, 
    0.05332349f, 0.10794827f, 0.11476115f, 0.14079776f, 0.46645105f, 0.08579780f, 0.23054679f, 0.13265920f, 
    0.02658806f, -0.23993938f, 0.17518893f, 0.12877497f, 0.54595143f, -0.43173480f, 0.34380221f, -0.23436227f, 
    -0.48082489f, 0.23527214f, 0.02195193f, 0.24658108f, 0.89801908f, -0.56221098f, 0.63243020f, 0.90336448f, 
    0.59187663f, -0.19935915f, 0.24235348f, 0.38335192f, 0.44863439f, -0.07053605f, -0.23904648f, -0.37499353f, 
    -0.44886369f, -0.22202566f, -0.02711674f, -0.09676648f, 0.05666421f, -0.05344340f, 0.24706450f, -0.06203609f, 
    0.05356035f, 0.00485642f, -0.23648348f, -0.11979351f, -0.20484354f, 0.84332323f, 0.51773852f, 0.29858309f, 
    -0.16327167f, -0.05441949f, 0.15860854f, -0.84489387f, 0.06435110f, -0.04300746f, 0.48339733f, 0.44449019f, 
    0.38176280f, 0.02936796f, 0.20200665f, -0.30378339f, 0.08323461f, 0.27785248f, -0.18305345f, -0.07304977f, 
    0.30293140f, -0.05623489f, 0.30597010f, 0.18357164f, -0.27751842f, -0.18680760f, 0.62423646f, -0.10365277f, 
    0.70049763f, -0.80305898f, -0.76740825f, 0.33986831f, -0.59361607f, -0.25720221f, 0.38032150f, -0.24645673f, 
    0.35074666f, 0.07741835f, -0.39066374f, 0.52322352f, -0.13923587f, -0.04192390f, -0.25218570f, 0.08626128f, 
    -0.09232072f, 0.12166409f, -0.16265093f, 0.11394288f, -0.11357128f, 0.03288912f, 0.22608066f, -0.57070822f, 
    0.12227823f, -0.59949028f, 0.54104692f, -0.08798484f, 0.56864154f, 0.00432064f, 0.07710083f, -0.42775884f, 
    0.00278866f, 0.19377254f, 0.14657888f, 0.16588105f, -0.16560274f, 0.47046438f, -0.04838255f, -0.42842269f, 
    0.17734103f, 0.02527326f, -0.05100137f, 0.46436408f, 0.42497474f, -0.42306867f, 0.25824082f, 0.03343994f, 
    0.33923414f, 0.60741270f, 0.90300429f, 0.80595189f, 0.54853112f, 0.01923273f, -0.03686099f, -0.40839502f, 
    -0.72612351f, -0.14183600f, 0.22641979f, 0.01137945f, -0.14342023f, 0.37893119f, -0.09966502f, 0.25630555f, 
    -0.25873709f, -0.15177113f, 0.24487989f, 0.05347612f, 0.10836285f, 0.26938665f, 0.25398424f, 0.04704273f, 
    0.05888828f, 0.31628856f, 0.45726258f, -0.55144882f, -0.62687880f, 0.45254204f, -0.29306999f, -0.80398726f, 
    -0.16422668f, -0.59413719f, -0.26615188f, 0.15620711f, -0.16308156f, 0.28722900f, -0.01061528f, 0.17537071f, 
    0.22032851f, -0.35726970f, -0.45195347f, -0.03066808f, -0.01392742f, 0.36900261f, 0.34261373f, 0.19473502f, 
    0.06792718f, -0.18706618f, -0.78942782f, 1.30588210f, 0.44797099f, -0.50870639f, -0.04004306f, -0.62844670f, 
    0.63970095f, 0.10704373f, 0.05557617f, -0.26011875f, -0.30694661f, 0.07807139f, -0.05475587f, -0.16836670f, 
    0.34240225f, 0.09570682f, -0.05389190f, 0.21503609f, 0.13579486f, -0.21762358f, 0.25808403f, 0.14237985f, 
    0.00704109f, 0.33893591f, 0.35114810f, -0.35271731f, 0.78060377f, -0.62003952f, -0.64077377f, -0.39143679f, 
    0.84826988f, -0.44246700f, 0.12484515f, -0.10294651f, -0.39161450f, 0.16419229f, -0.25845385f, 0.12233566f, 
    0.27851406f, 0.21426368f, 0.09760504f, 0.04884768f, 0.03673408f, -0.25496221f, -0.10860121f, 0.17559566f, 
    0.16849016f, 0.05580064f, -0.08923730f, 0.22905262f, 0.73144835f, 0.70848179f, -1.15204692f, -0.42794204f, 
    -0.60274589f, -0.41693535f, 0.18294649f, 0.09959453f, 0.11257461f, -0.53793287f, -0.00049685f, 0.05368379f, 
    0.15686090f, -0.17820983f, -0.09583160f, 0.14180648f, -0.20788738f, 0.13279234f, -0.19738469f, 0.15465480f, 
    -0.13327134f, -0.09193523f, 0.28556338f, 0.25229526f, 0.13281527f, 0.86680484f, 0.40602636f, -0.67501104f, 
    -0.35370624f, -0.04686077f, -0.37537748f, 0.58899820f, 0.36753932f, 0.20584111f, 0.46762896f, -0.17321871f, 
    0.11688606f, 0.32078871f, -0.29788435f, 0.40279561f, -0.25920847f, -0.20696031f, -0.27866194f, 0.13216996f, 
    -0.19937979f, 0.41431883f, -0.02133700f, -0.30052340f, 0.14651003f, -0.10457924f, 0.28913626f, 0.00965506f, 
    -0.23319468f, -0.04932248f, -0.69379747f, -0.17074037f, 0.57112134f, 0.12417518f, -0.02791499f, 0.36969829f, 
    0.40168571f, 0.58405310f, 0.08519299f, 0.26918191f, 0.54523629f, 0.03472922f, -0.18512437f, 0.31676057f, 
    -0.06813232f, 0.14586817f, -0.03354777f, 0.14091830f, 0.31885272f, 0.20625852f, -0.13420083f, 0.70121896f, 
    -0.83525771f, 0.84234303f, -0.24575433f, 0.45575884f, -0.74019510f, -0.07510393f, -0.11059523f, -0.29240942f, 
    0.08649929f, 0.09278928f, 0.16635333f, -0.15462594f, -0.08304237f, 0.21396589f, -0.19955003f, -0.08899216f, 
    0.22760551f, 0.08856847f, 0.16924654f, -0.46458128f, -0.17418844f, -0.20009449f, -0.22291741f, -0.21954058f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20185307f, 0.14371997f, 0.11441369f, 0.07197217f, 0.18114819f, 0.16071811f, 0.08667827f, 0.07522549f, 
    0.19724154f, -0.21911110f, 0.16516247f, 0.17421812f, 0.11045743f, 0.10123569f, 0.23283851f, 0.19033773f, 
    0.21484403f, 0.21819949f, 0.12263023f, 0.30201447f, 0.16155660f, 0.15004992f, 0.31759277f, 0.15948151f, 
    0.08863856f, 0.34993330f, 0.25050652f, 0.15626900f, 0.06894304f, 0.09360628f, 0.24442711f, 0.19132714f, 
    0.08634597f, 0.23536789f, 0.13240223f, 0.03915792f, 0.21432477f, 0.35111645f, 0.24756710f, 0.40907401f, 
    -0.00642378f, 0.14058727f, 0.13336314f, 0.01153459f, 0.29641342f, 0.02791903f, 0.11287442f, 0.02806414f, 
    0.11540315f, 0.15597150f, 0.04984919f, 0.26949021f, -0.02397887f, 0.16150154f, 0.14661889f, 0.19897945f, 
    0.12997365f, 0.11400650f, 0.24378261f, 0.21824189f, -0.04443987f, -0.05254167f, -0.05140443f, 0.01417965f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21180548f, -0.16595948f, -0.30727178f, 0.26602668f, -0.00622443f, -0.05597050f, -0.02618572f, -0.07494841f, 
    0.04825730f, 0.00982511f, -0.12609047f, 0.12995240f, 0.04931404f, 0.01947140f, 0.14971457f, -0.10475635f, 
    -0.05934245f, 0.06327070f, 0.02481418f, -0.06217223f, 0.01448886f, -0.01860330f, -0.09732023f, -0.02291119f, 
    -0.12531684f, 0.04738446f, -0.07833246f, 0.03111625f, -0.07259438f, 0.08032312f, 0.06797054f, -0.00627213f, 
    0.03106785f, 0.02539125f, -0.07786937f, -0.02856070f, -0.09862487f, 0.17962235f, 0.06968538f, 0.23078634f, 
    0.11624158f, 0.07329981f, 0.02152181f, 0.09675103f, 0.04269098f, -0.08827573f, 0.01352440f, -0.10385859f, 
    -0.24750452f, 0.05941343f, -0.10076611f, 0.11434572f, -0.07461671f, 0.03192415f, 0.03419897f, 0.01791439f, 
    0.10628591f, 0.10901356f, -0.04457387f, -0.01415524f, 0.02116753f, -0.27843860f, 0.11709027f, 0.00483420f, 
    -0.04657246f, -0.13358879f, 0.04619292f, -0.01725226f, -0.15438274f, -0.06667247f, -0.00721886f, -0.05741750f, 
    0.20792361f, 0.13057254f, -0.02529613f, 0.09317769f, -0.04158314f, -0.18843623f, -0.17417701f, 0.05752770f, 
    -0.05991242f, -0.00451417f, -0.04067250f, 0.02702488f, -0.09503385f, -0.10019878f, 0.12733473f, -0.26832774f, 
    -0.04533053f, 0.04656430f, 0.08722154f, -0.00794484f, 0.00261837f, -0.03043737f, 0.11500049f, 0.02403051f, 
    0.07551274f, -0.17998326f, -0.00641104f, 0.11020748f, 0.02238583f, -0.05823535f, -0.03968032f, -0.01771358f, 
    -0.24197565f, 0.04704791f, -0.02658342f, 0.03826673f, 0.43519607f, 0.07810844f, -0.00093090f, -0.27656680f, 
    0.13336490f, -0.06534000f, 0.05075812f, -0.01902033f, -0.03885542f, 0.11344106f, -0.00898145f, 0.02829160f, 
    -0.35322291f, 0.25817794f, -0.15715700f, -0.15837224f, -0.01025067f, -0.03033916f, -0.01552805f, 0.04889261f, 
    0.02956882f, -0.03538381f, 0.03549384f, 0.10658030f, -0.44818527f, 0.04057157f, 0.07075739f, 0.01847962f, 
    -0.02011188f, 0.02400863f, 0.05220670f, 0.01961130f, -0.05107876f, -0.06745499f, 0.00604233f, -0.00479111f, 
    0.20695707f, 0.00071980f, 0.02171080f, 0.15640293f, -0.13092704f, -0.04270579f, -0.05524535f, -0.01335341f, 
    -0.12749141f, 0.00746515f, -0.01422073f, -0.00559958f, -0.44310755f, 0.13700570f, 0.22059681f, -0.19653562f, 
    -0.09287398f, 0.03786305f, 0.04697783f, -0.08430801f, -0.00140605f, -0.06663631f, -0.02098494f, 0.05777224f, 
    0.16578212f, 0.15131271f, -0.22326818f, -0.25336459f, 0.02594223f, -0.05003965f, 0.02713938f, 0.10841646f, 
    -0.04123870f, -0.00883672f, -0.06433154f, -0.07516934f, 0.18685131f, -0.09535237f, -0.08269050f, -0.23732544f, 
    0.03671748f, -0.00353144f, 0.00987917f, -0.09108625f, -0.10107972f, 0.01946055f, 0.03110131f, 0.06270112f, 
    0.13031830f, -0.00877729f, 0.05691719f, 0.02553648f, -0.12845129f, -0.15478669f, -0.02301736f, 0.06525890f, 
    -0.08781175f, 0.06917957f, -0.03508998f, -0.01133631f, 0.17527731f, -0.03000909f, -0.07934091f, -0.25064245f, 
    0.01000809f, -0.04535209f, -0.04622600f, 0.02198417f, 0.01473260f, 0.05298697f, -0.06954287f, -0.05295542f, 
    -0.05341370f, 0.14430656f, 0.13917693f, -0.33723357f, -0.14709528f, -0.04242520f, -0.03203186f, 0.12255112f, 
    0.03187151f, 0.00738590f, -0.05647450f, 0.00582621f, 0.20923771f, -0.08266412f, 0.08848152f, -0.05090972f, 
    -0.11997947f, -0.00877762f, 0.05095045f, 0.12248617f, 0.09693202f, 0.01375988f, 0.06558421f, -0.01853120f, 
    -0.09577507f, 0.16100268f, -0.08281968f, 0.11482883f, -0.01358635f, -0.02476962f, -0.02677419f, -0.01779190f, 
    -0.02383469f, 0.08533280f, -0.02176690f, -0.00850959f, 0.01772560f, 0.22659028f, 0.08644547f, -0.12594602f, 
    -0.24000107f, 0.05215022f, -0.00704322f, 0.01908341f, 0.10723002f, 0.03161046f, -0.01061623f, 0.03149103f, 
    0.19321208f, -0.09143976f, -0.14415348f, 0.21020815f, 0.02879107f, -0.07798319f, -0.02645485f, 0.05813941f, 
    0.01138193f, 0.02095487f, 0.00819208f, -0.02054928f, 0.19590521f, -0.06832155f, 0.07523199f, -0.10761701f, 
    -0.02025775f, -0.05043338f, -0.02691448f, 0.05583499f, 0.00504236f, 0.02877359f, 0.07777631f, -0.01111558f, 
    -0.34460509f, -0.06873671f, -0.05507871f, -0.22443433f, 0.03183757f, -0.04912648f, -0.03235323f, -0.04225083f, 
    0.02434406f, 0.03089120f, 0.00719349f, 0.08583864f, -0.13618842f, 0.00348470f, -0.12655759f, 0.04736274f, 
    -0.04878522f, -0.07070068f, 0.05970921f, 0.00739406f, 0.01260745f, -0.16319615f, 0.07613911f, -0.06163809f, 
    -0.21034203f, 0.02426142f, -0.28960115f, 0.10379292f, -0.05199745f, -0.02018689f, 0.05221638f, -0.03210393f, 
    0.02007597f, 0.10210903f, -0.00445850f, -0.03601161f, 0.00057718f, 0.09796477f, 0.01409609f, 0.35007674f, 
    0.02503830f, -0.04761046f, 0.03776965f, -0.05502386f, 0.09303128f, 0.02546071f, -0.07074706f, -0.09580167f, 
    -0.11372369f, 0.06372724f, -0.09666324f, 0.16724873f, -0.14732175f, -0.08116931f, 0.05688747f, -0.06928816f, 
    0.03592107f, 0.07545161f, 0.00848829f, -0.10575904f, -0.17245725f, -0.05918454f, -0.02087724f, -0.03378088f, 
    -0.10354482f, 0.14075139f, -0.08564826f, 0.05486730f, -0.00863248f, -0.04040596f, -0.03675966f, 0.01653634f, 
    -0.00447154f, -0.07179260f, 0.03911448f, 0.12913120f, -0.02107525f, -0.08121736f, -0.11522954f, -0.03794981f, 
    0.06937645f, -0.04031352f, 0.01543110f, -0.01181904f, 0.09443671f, 0.10856114f, 0.17027605f, -0.17864741f, 
    0.05792796f, -0.06296881f, 0.03129069f, 0.02394025f, -0.05694898f, 0.08908854f, -0.02166416f, 0.09353872f, 
    0.04143413f, 0.08550022f, -0.06916967f, 0.23556887f, -0.21873601f, 0.04763862f, -0.14400731f, -0.13314141f, 
    0.10527818f, -0.06371891f, 0.10927085f, -0.00327255f, 0.08212347f, -0.02681621f, -0.02169858f, 0.19334371f, 
    -0.20404834f, 0.06231951f, 0.03290736f, 0.02828634f, -0.01989927f, 0.08838910f, 0.02049395f, -0.05214429f, 
    -0.12817261f, -0.01729868f, 0.09380125f, -0.04707905f, -0.03176920f, 0.09373391f, -0.02446959f, -0.07423718f, 
    -0.03157420f, 0.00851730f, 0.08249961f, -0.00016861f, -0.41244522f, -0.03885679f, 0.00056173f, -0.21519221f, 
    -0.09995497f, 0.00247968f, 0.04872674f, -0.07841051f, -0.02084473f, -0.00190768f, 0.06291883f, -0.11449990f, 
    0.08834478f, 0.04397338f, -0.00912358f, -0.19259962f, 0.02387724f, 0.04851244f, 0.11615013f, -0.02296018f, 
    -0.00371811f, -0.04344281f, 0.01678414f, 0.06205714f, 0.34499222f, -0.03891779f, 0.10034198f, -0.24422206f, 
    -0.00429498f, 0.00770354f, -0.04525921f, 0.03037314f, 0.02279545f, -0.06052848f, -0.06865048f, 0.11416442f, 
    0.15296030f, 0.02491991f, 0.11189859f, -0.06155556f, 0.03958678f, -0.03736212f, -0.07410451f, -0.05796608f, 
    -0.10779041f, 0.10027745f, -0.11698610f, 0.00444863f, -0.29300180f, -0.20691893f, -0.13469350f, 0.04361287f, 
    0.10075667f, 0.04635779f, 0.00283284f, 0.07848156f, -0.00955452f, 0.02518594f, 0.04134864f, -0.13176996f, 
    0.20217301f, 0.03033450f, -0.07213983f, 0.19593479f, -0.02283292f, 0.05166227f, -0.12552917f, 0.02985560f, 
    -0.08558730f, 0.10077509f, -0.00978647f, -0.02176563f, 0.04511992f, 0.17829093f, -0.10019251f, 0.00944395f, 
    -0.00261339f, -0.02997353f, 0.02746877f, -0.04776465f, 0.07976077f, -0.04686457f, 0.10864329f, -0.13596866f, 
    -0.13224119f, 0.15043113f, 0.04062367f, 0.24819252f, -0.07357538f, -0.03129829f, -0.07224054f, -0.08461492f, 
    0.00576393f, -0.04895497f, 0.05053686f, 0.11238220f, 0.18378456f, -0.06951927f, -0.05071664f, 0.12689757f, 
    -0.05396447f, -0.03085561f, -0.08202533f, 0.03988275f, -0.06402136f, 0.09289861f, 0.01227147f, 0.04051208f, 
    -0.08530947f, 0.26595062f, 0.15200058f, 0.04718466f, -0.01036268f, 0.05983559f, -0.00313767f, 0.04486281f, 
    -0.02701005f, 0.04629993f, 0.03928593f, -0.13353962f, -0.16284227f, 0.06390449f, -0.09577595f, 0.15239416f, 
    -0.06866462f, -0.03405425f, 0.12332947f, -0.01574532f, 0.01366491f, 0.00982923f, -0.00098942f, 0.04255386f, 
    0.11063351f, -0.16902600f, -0.04690310f, 0.23026757f, -0.01918333f, -0.02094948f, -0.03581316f, 0.07376823f, 
    -0.01098171f, -0.01849608f, 0.01778646f, 0.05781326f, 0.26730707f, 0.08611993f, -0.03258606f, -0.33981618f, 
    0.00176244f, -0.01150189f, 0.05894125f, -0.03136424f, 0.04980131f, -0.06788555f, -0.10056960f, 0.01640960f, 
    -0.27254111f, 0.00966936f, -0.03684895f, -0.12892550f, -0.04161258f, -0.04589529f, -0.07010423f, 0.05671830f, 
    0.07162190f, -0.01773235f, 0.01266480f, 0.06004631f, -0.25366166f, 0.27586520f, -0.12402455f, -0.08611467f, 
    -0.00036552f, -0.04047161f, 0.15292409f, 0.03309849f, 0.06950466f, -0.03377928f, -0.00738939f, 0.04016369f, 
    -0.09395882f, 0.11767225f, -0.11820932f, 0.20895763f, -0.04642943f, -0.01077663f, -0.13825656f, -0.08668123f, 
    -0.09361010f, 0.03335969f, -0.01181484f, -0.05079257f, 0.05173427f, -0.00734570f, -0.12136535f, 0.09246691f, 
    -0.17272097f, -0.11726378f, -0.04772275f, 0.05777252f, 0.03698334f, 0.08895582f, -0.05069695f, -0.05547363f, 
    0.21261255f, -0.08793349f, -0.16752690f, 0.33795685f, -0.12361477f, -0.03219153f, 0.06136347f, 0.00722012f, 
    -0.00775817f, -0.10052379f, -0.00687482f, 0.03001010f, 0.10608058f, -0.07200515f, 0.02532718f, -0.16007088f, 
    -0.03123733f, -0.07050262f, -0.02886550f, 0.02647383f, -0.03284198f, -0.00096912f, 0.02452621f, -0.05390956f, 
    -0.01189297f, 0.03773028f, -0.00492376f, -0.02478081f, 0.00842007f, -0.05582571f, -0.08191367f, -0.13443510f, 
    -0.01393691f, 0.05093671f, -0.10861796f, 0.12025057f, 0.04326851f, 0.02251819f, -0.02165072f, -0.09626405f, 
    -0.10884515f, -0.06342506f, 0.10896982f, -0.12506059f, 0.02823736f, -0.07293425f, -0.02146745f, 0.00771200f, 
    0.11048385f, 0.06053285f, -0.12102777f, 0.02374189f, -0.12149909f, -0.01896204f, -0.09129397f, 0.08857166f, 
    -0.04609069f, -0.03189629f, -0.01560823f, -0.14859106f, 0.03071213f, -0.00483651f, 0.19939521f, -0.10741027f, 
    0.02927252f, -0.00084261f, -0.00683589f, 0.03369953f, 0.10658211f, -0.01659875f, 0.05167552f, -0.01894969f, 
    0.00951048f, 0.11303502f, 0.16105010f, -0.06943128f, 0.03400777f, -0.00604027f, 0.05742976f, -0.07980427f, 
    -0.09947014f, -0.02329468f, -0.09000012f, -0.08100087f, 0.26259372f, -0.06573382f, -0.03963788f, -0.13594083f, 
    -0.13146587f, -0.05841467f, 0.05602237f, 0.05624714f, -0.02006724f, 0.06348682f, -0.02098596f, -0.00798446f, 
    -0.31014559f, 0.09038102f, 0.08720554f, -0.16054210f, -0.15233964f, -0.05430151f, -0.04019477f, -0.01028712f, 
    -0.05590911f, 0.08874043f, 0.05109902f, -0.00219589f, -0.20524801f, -0.10569928f, -0.12879337f, -0.35191107f, 
    0.15394281f, -0.12314902f, 0.02022187f, 0.01634732f, -0.00885734f, 0.02874684f, 0.07933080f, 0.11365087f, 
    -0.35857409f, -0.10443655f, -0.02055535f, 0.03715707f, 0.00909508f, 0.01131254f, 0.00250039f, -0.02149557f, 
    0.03218326f, 0.02973221f, 0.06951653f, 0.02290361f, 0.24289684f, -0.15789108f, -0.05268022f, -0.10776560f, 
    -0.10357885f, -0.01107153f, 0.08266364f, 0.10758015f, -0.02700500f, -0.03886144f, -0.09859022f, 0.04609587f, 
    -0.08845469f, -0.12477560f, -0.05535480f, 0.06436040f, -0.11608612f, 0.00631878f, 0.04080756f, 0.01660961f, 
    0.13984549f, -0.09698293f, 0.07316294f, -0.00088584f, -0.03766184f, 0.20020382f, -0.04710634f, -0.17896788f, 
    -0.06505866f, -0.02443741f, 0.05724859f, -0.08248839f, 0.13910788f, -0.03064742f, 0.07107460f, -0.09854963f, 
    0.03358871f, 0.08807915f, 0.00507205f, 0.11372223f, -0.02451671f, 0.10441785f, -0.07078374f, -0.03245355f, 
    -0.06027328f, 0.01755994f, 0.15256059f, 0.01399059f, 0.16152479f, 0.04554854f, -0.15684907f, 0.03126983f, 
    -0.11272648f, 0.10755646f, -0.06220245f, -0.06369141f, -0.05474012f, -0.08123452f, -0.00406833f, -0.02386259f, 
    -0.16202496f, -0.19323848f, -0.14117020f, 0.26110253f, -0.23239577f, -0.01789012f, -0.08375056f, 0.02076584f, 
    0.11943589f, 0.00438162f, -0.09643286f, -0.00336869f, -0.01177577f, 0.05287825f, 0.00027878f, -0.14459261f, 
    0.01517199f, 0.05536745f, -0.01280575f, 0.05949266f, 0.12556839f, 0.04709955f, 0.07631946f, 0.07229318f, 
    0.04305662f, -0.06916804f, -0.01519759f, 0.16872013f, -0.00928978f, -0.00684729f, 0.01849640f, 0.00870358f, 
    0.12504682f, -0.10586426f, -0.02680087f, 0.00132003f, 0.12175447f, -0.09406691f, 0.09479431f, -0.18568969f, 
    0.04821963f, -0.19443858f, 0.00196431f, -0.06086527f, -0.23477115f, 0.08630107f, -0.11893825f, -0.09671803f, 
    0.01938757f, 0.08300008f, 0.02327108f, -0.11294632f, -0.03349124f, 0.00188166f, 0.10554746f, 0.08122393f, 
    0.04327588f, 0.02845488f, -0.01290669f, -0.14235209f, -0.28096557f, -0.13334768f, 0.04566927f, -0.07648870f, 
    -0.01762295f, 0.00552937f, -0.00354520f, 0.07938469f, 0.23061457f, -0.04149201f, -0.03496097f, -0.05933350f, 
    0.36597583f, -0.16619180f, -0.00578359f, -0.07537504f, -0.01343170f, -0.08287390f, -0.02771176f, -0.03659964f, 
    0.04753483f, -0.14990957f, -0.03059265f, -0.10418323f, -0.06710956f, -0.00454524f, 0.04868353f, -0.04244528f, 
    -0.07985407f, 0.09003903f, 0.04576319f, 0.04382880f, 0.05877060f, 0.07605293f, 0.16883887f, -0.04721624f, 
    0.00100641f, 0.05624131f, -0.08744524f, 0.05254287f, -0.04067095f, 0.00427344f, 0.04505513f, 0.01962314f, 
    0.01664317f, -0.07816219f, 0.02857115f, 0.01838904f, -0.19473203f, 0.16424218f, 0.00853257f, -0.26262522f, 
    -0.08523203f, -0.04419608f, 0.04935359f, 0.04523956f, 0.14946832f, 0.09355110f, -0.04582890f, -0.12270793f, 
    0.20515583f, -0.10908859f, 0.06615958f, -0.19754840f, 0.03867295f, -0.08905230f, 0.09488392f, 0.03064798f, 
    0.01283841f, -0.04835302f, 0.01191268f, 0.00702918f, 0.04551017f, -0.19292717f, 0.03477309f, -0.32120600f, 
    0.04182813f, -0.07809553f, 0.01598938f, 0.04328638f, 0.07820307f, -0.01601548f, 0.02734268f, 0.06334388f, 
    0.08748177f, 0.00405789f, 0.25010258f, 0.14235948f, -0.24059087f, 0.02018226f, 0.04501970f, -0.00248204f, 
    -0.11736815f, -0.11711799f, 0.08039014f, -0.01118519f, 0.15169294f, 0.03811375f, 0.02387200f, 0.18885343f, 
    0.03327784f, -0.06494573f, 0.06137009f, 0.07920343f, 0.01151676f, -0.06840018f, -0.09125853f, 0.04022585f, 
    0.27375957f, -0.08727974f, 0.05432071f, -0.14765809f, 0.07962941f, -0.03929565f, -0.01326441f, -0.01761722f, 
    0.02633818f, 0.00867791f, -0.07862159f, 0.12109789f, 0.17400752f, -0.12828439f, 0.04446749f, 0.25467789f, 
    -0.02036696f, -0.05999850f, -0.14437634f, 0.01317150f, -0.03976041f, 0.05786385f, -0.11225401f, 0.08894330f, 
    -0.17016421f, -0.06193393f, -0.09417170f, -0.06400543f, -0.08421332f, -0.05520438f, -0.04079611f, 0.01875653f, 
    0.03842792f, 0.05804529f, 0.02882764f, 0.05401985f, 0.23390365f, -0.07157850f, 0.01793413f, -0.06612516f, 
    0.15434790f, 0.01191941f, -0.08534511f, 0.01985715f, -0.11415280f, -0.04193272f, -0.16260858f, -0.03173701f, 
    0.26702106f, -0.10632109f, 0.06093235f, 0.08265437f, -0.08174452f, -0.00564320f, -0.05843625f, -0.02885398f, 
    -0.04069090f, 0.01878193f, 0.02678363f, -0.06082121f, -0.16539638f, 0.04818065f, 0.01784147f, -0.16195242f, 
    -0.02015639f, 0.07060808f, -0.00958536f, 0.11437406f, 0.13519005f, 0.03615538f, -0.00248317f, 0.10051376f, 
    0.32252988f, -0.09113319f, -0.14622743f, -0.08944755f, -0.07089569f, -0.06737642f, 0.04253277f, 0.07007023f, 
    0.11003799f, -0.12086459f, -0.09530596f, -0.05587247f, -0.02236887f, 0.01718596f, 0.01361707f, -0.15010051f, 
    0.00671156f, -0.06089470f, -0.05470096f, -0.09487762f, -0.03553949f, 0.11699777f, 0.07051934f, 0.09355939f, 
    -0.26094979f, 0.02762723f, -0.10729437f, 0.00410712f, 0.05702277f, -0.09051529f, -0.13698699f, -0.02138774f, 
    -0.10740700f, -0.04569477f, -0.11060834f, 0.13077600f, -0.42736146f, 0.02697584f, -0.23998730f, -0.12509917f, 
    -0.08328146f, -0.11743753f, -0.08398287f, -0.08141551f, -0.10307083f, -0.10055781f, -0.02720725f, 0.01186355f, 
    0.19957981f, 0.02840399f, 0.02810522f, 0.23578134f, 0.01626756f, 0.03059885f, -0.06460129f, -0.00152907f, 
    -0.01274769f, 0.02042643f, -0.10608569f, -0.03629521f, 0.06408639f, -0.03233565f, -0.20351514f, -0.02063622f, 
    0.00691305f, -0.11670081f, 0.07492736f, -0.05461993f, -0.08435706f, 0.11838815f, -0.04388802f, 0.00230679f, 
    0.15467258f, -0.28209949f, -0.25394064f, 0.00254645f, -0.02491782f, -0.02592568f, -0.00775422f, 0.02780656f, 
    -0.10113038f, 0.01901064f, -0.01082105f, -0.01851843f, 0.05113224f, -0.30349600f, -0.12165143f, -0.09562416f, 
    0.14929736f, -0.02653236f, -0.01540388f, 0.01100801f, 0.00320486f, 0.03081604f, 0.01827470f, -0.06892155f, 
    0.01836796f, -0.12401722f, -0.00609150f, 0.15882693f, -0.09769630f, -0.02756949f, -0.06292644f, 0.06203359f, 
    0.01263520f, 0.02004839f, -0.06730707f, 0.18050170f, 0.15909000f, 0.00738895f, 0.17712709f, 0.10541555f, 
    -0.02600415f, 0.00301834f, 0.04299907f, 0.02601062f, 0.01388079f, -0.01394123f, -0.07928236f, 0.06237080f, 
    -0.43045288f, 0.05381680f, -0.09693522f, 0.13083445f, 0.07268159f, -0.11430638f, -0.08573300f, -0.10700187f, 
    -0.02321043f, 0.05919770f, -0.09510652f, 0.01234913f, 0.33470514f, -0.06626832f, -0.10655215f, -0.22630048f, 
    0.02422195f, -0.01206550f, -0.10133363f, 0.07587519f, -0.12444189f, 0.04496448f, 0.00052752f, -0.02520334f, 
    0.17658457f, -0.17627546f, 0.04944937f, -0.10336562f, 0.07383677f, -0.02580217f, -0.13614479f, -0.05164241f, 
    -0.06497940f, 0.00983179f, -0.00430847f, -0.15795830f, -0.00046989f, 0.01448501f, -0.09577730f, 0.11607479f, 
    0.03378163f, 0.00592196f, 0.12403858f, 0.04148335f, -0.08809523f, 0.09685794f, 0.00497020f, -0.03013303f, 
    0.08793640f, 0.11353728f, 0.04145989f, 0.15418412f, -0.06508245f, 0.10195809f, 0.02182347f, 0.18551232f, 
    0.11620048f, 0.06413396f, 0.08645838f, -0.06037544f, -0.08637112f, 0.14537577f, -0.04499489f, -0.06980787f, 
    -0.03555088f, 0.07427669f, -0.02686105f, -0.01102445f, 0.04749797f, 0.05601415f, 0.08337256f, 0.08951869f, 
    0.34833279f, 0.02594715f, 0.09161682f, 0.06756404f, -0.09335677f, -0.06798801f, -0.03115791f, 0.00573463f, 
    0.10740239f, -0.02782400f, 0.11290754f, -0.06662274f, 0.00126857f, -0.26137504f, 0.12808052f, 0.03649596f, 
    -0.08670450f, -0.02019339f, -0.07097992f, -0.04271003f, -0.05277672f, 0.04764169f, -0.23151448f, 0.07957320f, 
    0.28526491f, -0.13779837f, -0.05574051f, 0.05957185f, -0.03002513f, 0.08251477f, 0.04146751f, -0.00067428f, 
    -0.17879471f, 0.14379431f, 0.04857758f, -0.00244612f, -0.10758334f, -0.11470836f, 0.12221444f, -0.02870463f, 
    -0.07146011f, -0.00946099f, -0.00082630f, 0.11606516f, -0.00058576f, -0.05329234f, -0.23400782f, -0.16862595f, 
    0.11327287f, -0.21982460f, -0.12312971f, -0.00404730f, 0.12579255f, 0.11192900f, -0.05734099f, -0.03286662f, 
    0.03261273f, 0.08831716f, -0.08149947f, 0.00108472f, 0.38897493f, 0.04027025f, 0.05748790f, 0.11117925f, 
    -0.04145708f, 0.14540833f, -0.02328988f, 0.01577075f, 0.09341178f, -0.01969307f, -0.00014698f, -0.06369290f, 
    0.06606100f, -0.17151307f, -0.02901083f, -0.02436255f, -0.02756010f, 0.05422262f, -0.06294876f, 0.05803317f, 
    -0.02771258f, -0.00135866f, -0.04453673f, -0.18010317f, -0.08402805f, -0.28474393f, 0.10346414f, -0.18136916f, 
    0.10183543f, -0.01218184f, -0.12143530f, 0.04604255f, -0.08920584f, -0.07867377f, 0.11002951f, 0.02097024f, 
    -0.39244476f, 0.19146043f, -0.08032367f, -0.07837403f, 0.09796899f, 0.01306261f, -0.01368399f, 0.07785352f, 
    -0.05632243f, -0.03554536f, -0.05142542f, -0.05802394f, 0.18680808f, -0.16309047f, -0.14586519f, 0.08944779f, 
    -0.02186786f, 0.03613987f, -0.04077178f, 0.16301195f, -0.03861500f, 0.00142392f, -0.04071820f, 0.06665039f, 
    -0.18152711f, 0.06714734f, -0.12639183f, 0.01044590f, -0.11651388f, 0.04942593f, 0.00219819f, 0.05318086f, 
    0.06537303f, 0.00939457f, -0.05762215f, 0.06486310f, 0.07839596f, 0.14032628f, 0.09512328f, 0.06818164f, 
    -0.06626531f, -0.00779726f, 0.02857008f, -0.06841557f, -0.02785505f, -0.08167561f, 0.09164672f, 0.10565075f, 
    0.10126260f, -0.06242273f, 0.02412011f, 0.21005459f, -0.06608652f, 0.06892036f, 0.04726763f, -0.01360367f, 
    0.10468724f, 0.08224855f, -0.11451087f, -0.10917410f, -0.03018371f, 0.02844585f, 0.14405681f, -0.13868937f, 
    -0.02292818f, -0.14210007f, 0.09428870f, -0.01178875f, -0.01036709f, -0.04020070f, 0.18195674f, -0.01708996f, 
    -0.06361269f, 0.01555549f, -0.05750511f, -0.08772939f, -0.02186720f, 0.04804249f, -0.03245411f, 0.00865498f, 
    -0.12241939f, -0.00806734f, 0.11715887f, -0.08556028f, 0.08220233f, 0.11249665f, -0.21291238f, 0.16348533f, 
    0.00408247f, -0.00666524f, -0.06054569f, -0.05176280f, -0.01136418f, -0.00732495f, -0.01092416f, 0.04001848f, 
    0.08383580f, -0.00712691f, 0.20911206f, 0.18224381f, -0.09788048f, 0.01437561f, 0.01744954f, 0.00618420f, 
    0.06627779f, 0.09175128f, -0.02653660f, 0.09587790f, -0.07305002f, -0.08854911f, -0.13876854f, -0.37792951f, 
    0.01655116f, -0.07611945f, 0.14751934f, -0.03337254f, -0.04398000f, 0.15080343f, -0.07805413f, 0.07812139f, 
    -0.38036186f, 0.10450631f, -0.31268692f, -0.24984787f, 0.00975924f, 0.10049579f, -0.01642995f, 0.09095121f, 
    0.06457333f, -0.03138403f, 0.03701865f, 0.08838128f, -0.20196766f, -0.09978408f, 0.01264508f, -0.20197327f, 
    -0.04798035f, -0.04640802f, 0.06200943f, -0.05283784f, 0.02373807f, 0.04860659f, -0.01210067f, -0.08103395f, 
    0.32319519f, -0.38241234f, 0.03036566f, -0.12675111f, -0.05534327f, 0.04123047f, 0.03233941f, 0.10760365f, 
    -0.12171305f, -0.14723869f, 0.06149610f, 0.14125034f, 0.36995888f, -0.08644088f, 0.11764872f, -0.17978896f, 
    0.00003798f, 0.06114082f, -0.10987287f, 0.08816653f, -0.01612265f, 0.00344325f, -0.18936540f, 0.04524281f, 
    0.18932034f, -0.17156632f, -0.05245304f, 0.01676455f, -0.05205917f, 0.02511598f, -0.02530414f, 0.01690610f, 
    -0.03927430f, 0.08131142f, -0.11092299f, 0.05344985f, -0.11551498f, -0.23327300f, -0.01328227f, 0.10983389f, 
    0.09632494f, -0.05630412f, -0.14389776f, -0.05300760f, -0.04624926f, 0.06880657f, 0.09339419f, -0.00346262f, 
    -0.10241002f, -0.00199927f, 0.00705061f, 0.01070614f, -0.12691797f, 0.02813450f, -0.07866110f, 0.07251563f, 
    0.01105527f, 0.02421987f, -0.06502315f, -0.02495892f, 0.15060905f, 0.05989599f, -0.02316388f, -0.08875737f, 
    0.01967882f, 0.05983790f, -0.09138100f, 0.01295894f, -0.08821203f, -0.04080494f, -0.00925163f, -0.02876063f, 
    0.09842779f, -0.04088444f, 0.11173955f, 0.01587264f, 0.02245039f, 0.03339561f, -0.06441203f, -0.00493844f, 
    -0.10972165f, -0.05592747f, -0.17380011f, 0.07650964f, 0.20765200f, -0.11051753f, -0.07962773f, -0.01659639f, 
    -0.07378507f, 0.02197626f, -0.02242783f, -0.05723788f, 0.16529785f, 0.04445184f, 0.00685401f, -0.00959599f, 
    0.47871125f, -0.02894965f, -0.19000228f, 0.07891059f, -0.00815749f, -0.04548859f, 0.02475669f, 0.06587742f, 
    0.05552769f, 0.04735885f, 0.06205945f, -0.07726423f, -0.09278303f, -0.26637745f, 0.08568009f, -0.05956047f, 
    -0.09199346f, -0.04806724f, 0.04759908f, -0.07413760f, -0.00278224f, -0.00583699f, -0.12104085f, 0.04926640f, 
    -0.27825245f, 0.08718529f, -0.07844035f, -0.19207937f, -0.02356501f, 0.02445040f, 0.04496059f, 0.03545865f, 
    -0.14218323f, 0.15467875f, -0.06357989f, 0.03516631f, -0.11816059f, -0.03693586f, 0.13871537f, -0.10549884f, 
    0.06589852f, -0.02595516f, 0.13502195f, -0.06578773f, -0.01616806f, 0.03430350f, 0.03588191f, -0.05755638f, 
    -0.27419969f, -0.11884523f, 0.04855414f, -0.19601588f, -0.02395886f, 0.01382414f, -0.09194987f, -0.14904942f, 
    -0.01772428f, 0.01835160f, 0.03926034f, 0.10425280f, 0.07909337f, 0.04708435f, 0.16375901f, 0.24436468f, 
    0.07296309f, 0.01235992f, 0.11068194f, -0.01501180f, -0.12636223f, 0.00320217f, 0.05396229f, 0.00163081f, 
    0.33013314f, 0.12683566f, 0.00270421f, 0.27539277f, -0.16007765f, -0.03909379f, 0.10433590f, 0.03239938f, 
    -0.00665070f, 0.01464248f, -0.02001271f, -0.02562048f, -0.16479880f, 0.05186059f, -0.27893341f, -0.35562992f, 
    0.00026463f, 0.07213102f, -0.00984004f, -0.05293000f, -0.06136360f, -0.00314095f, -0.18653640f, 0.03149012f, 
    -0.29650733f, 0.01379532f, -0.11067801f, -0.02309465f, 0.03601187f, -0.02690654f, 0.01279916f, -0.07279763f, 
    0.00847595f, 0.02217101f, -0.00894092f, -0.01273102f, -0.01893921f, -0.02780900f, -0.11501887f, -0.21039385f, 
    0.15350027f, 0.03900325f, 0.12122697f, -0.05328713f, -0.03277199f, 0.00497391f, -0.03505252f, -0.07453208f, 
    0.32550663f, 0.00681902f, 0.02178295f, 0.11513861f, -0.09216832f, -0.03169087f, -0.07300121f, 0.06177701f, 
    0.03642635f, 0.01532452f, -0.03048278f, -0.02308365f, -0.02986180f, -0.00325405f, 0.11856238f, 0.12756489f, 
    -0.08535169f, -0.01594496f, 0.08808984f, 0.04126085f, -0.03842701f, -0.11526819f, 0.01172240f, -0.02419131f, 
    0.12431203f, 0.00517970f, -0.00783566f, -0.04113627f, 0.10758056f, 0.01724496f, -0.01359546f, -0.01755936f, 
    0.02765524f, 0.13711320f, 0.06650802f, 0.04674475f, -0.30778533f, 0.10684527f, -0.07672863f, -0.17110346f, 
    0.01642280f, 0.00841579f, 0.09512024f, -0.08938804f, -0.02496457f, -0.01913204f, 0.02162206f, 0.03594310f, 
    0.00410567f, 0.07984775f, -0.06058460f, -0.03266269f, 0.04113203f, 0.06062772f, 0.05022041f, 0.01718516f, 
    0.01047871f, -0.03967177f, 0.01560304f, -0.04463071f, 0.07322893f, 0.02965388f, 0.00046056f, -0.03226384f, 
    0.05463555f, -0.05263219f, 0.11284907f, -0.01779280f, -0.04028416f, 0.03450570f, 0.07095233f, -0.08606867f, 
    0.20215246f, 0.07101028f, 0.02914446f, -0.01668708f, 0.09411400f, 0.08999830f, -0.02299066f, -0.03387136f, 
    -0.11889667f, -0.04918067f, -0.09363862f, -0.07133722f, 0.00547897f, -0.09727849f, -0.04833446f, -0.10244367f, 
    0.16232489f, -0.03537546f, 0.07065099f, -0.03645364f, -0.01049583f, -0.07113823f, -0.05653279f, -0.09033509f, 
    -0.14211021f, 0.03354260f, -0.01474507f, 0.09612017f, 0.14613962f, -0.05831588f, -0.01321173f, -0.01730580f, 
    -0.04272261f, 0.01495729f, 0.01951607f, -0.08278050f, -0.36888048f, -0.02861559f, 0.17422046f, 0.10503939f, 
    -0.02006373f, -0.09031758f, 0.02776089f, -0.03462052f, -0.05682477f, -0.16110551f, 0.01828367f, 0.03350601f, 
    -0.02778164f, -0.01074153f, 0.07043860f, 0.10279940f, 0.03057731f, -0.10760160f, 0.08170684f, -0.01709875f, 
    -0.02895873f, -0.00930554f, 0.01634264f, 0.01949906f, 0.22524492f, 0.09124444f, -0.18258207f, 0.24146970f, 
    0.04140215f, 0.03304095f, 0.03084093f, -0.13402706f, -0.06309912f, -0.11222500f, -0.05495750f, -0.00719541f, 
    0.06928238f, 0.03370768f, -0.11786688f, -0.20223722f, -0.03727492f, -0.03102105f, 0.01554845f, -0.08638833f, 
    -0.01027921f, -0.00977979f, 0.00891086f, -0.06782801f, 0.08326682f, 0.07276893f, -0.22703540f, -0.00798692f, 
    -0.17297731f, 0.03264178f, 0.09928868f, 0.07855546f, 0.03078944f, 0.00465123f, 0.02091287f, -0.06517828f, 
    0.11954564f, -0.01005694f, -0.12887417f, 0.19167392f, -0.06512813f, 0.03095756f, 0.01538385f, -0.05541561f, 
    -0.00562335f, 0.02587093f, -0.11604010f, -0.09117681f, -0.28439069f, -0.06085088f, -0.07622012f, -0.19252388f, 
    -0.05119874f, 0.11914722f, 0.06872226f, -0.07836128f, 0.17179993f, -0.04002421f, -0.05841280f, -0.02828052f, 
    -0.03332066f, 0.05325565f, -0.22755903f, -0.14095290f, 0.05725222f, -0.03254481f, -0.08593871f, -0.05416442f, 
    -0.05778818f, 0.08711137f, 0.05315054f, -0.11234953f, 0.06754558f, -0.00916827f, 0.17942229f, 0.08150359f, 
    -0.07342301f, -0.03586487f, 0.03172138f, 0.01206581f, -0.03409625f, -0.02964003f, 0.04920090f, -0.00396973f, 
    0.19852893f, 0.06061326f, -0.20664838f, -0.06688789f, -0.02621283f, -0.02727946f, 0.03249521f, 0.04981618f, 
    -0.04912427f, -0.03345145f, 0.08773761f, 0.00123714f, 0.11392489f, -0.11710866f, -0.01191849f, -0.11293279f, 
    0.06929395f, -0.01941963f, 0.01526122f, 0.02351965f, -0.03509966f, 0.00038542f, 0.04807737f, 0.02967179f, 
    0.06793783f, 0.09694771f, 0.10960589f, -0.18847910f, -0.09561267f, 0.01560933f, -0.03853333f, 0.03671318f, 
    0.07533325f, -0.12145866f, 0.07154667f, 0.00846847f, -0.24846622f, -0.05212284f, -0.02465278f, 0.10359654f, 
    -0.01628783f, -0.12846358f, 0.07398891f, 0.07662513f, -0.07864728f, -0.01953038f, 0.09453465f, -0.01295146f, 
    0.17186028f, 0.12899040f, 0.15890963f, 0.22798526f, -0.03755975f, -0.11752147f, 0.10820747f, 0.14238626f, 
    -0.07517016f, 0.01005837f, 0.00765699f, -0.13012150f, 0.20098372f, -0.02477899f, 0.11541255f, -0.09902504f, 
    -0.00724143f, -0.11638882f, -0.05819011f, -0.00561374f, 0.02892452f, -0.02541482f, -0.03098895f, -0.07855975f, 
    -0.10660571f, 0.03061784f, 0.02047566f, -0.00648260f, 0.04804001f, -0.06779577f, 0.02556384f, -0.02279864f, 
    0.00483172f, 0.04330176f, -0.02366145f, 0.13621375f, 0.35314628f, -0.10644508f, -0.29604205f, -0.12451138f, 
    0.01969808f, -0.08895846f, -0.11312650f, -0.07416028f, -0.12131336f, -0.01957960f, 0.04952972f, -0.01584083f, 
    -0.01889177f, 0.10789990f, -0.04290576f, 0.11522291f, -0.01567928f, -0.04373961f, 0.07468970f, 0.06560324f, 
    -0.05288132f, -0.03578338f, -0.03360362f, 0.01279172f, 0.14040700f, -0.09801378f, 0.02833458f, -0.09860469f, 
    -0.05536406f, 0.03897139f, -0.02068476f, 0.05975175f, -0.01021630f, -0.04717849f, -0.00059338f, -0.12574963f, 
    0.13230689f, -0.19628845f, 0.03799931f, -0.02746019f, 0.00806417f, 0.05540201f, -0.10450156f, -0.02264402f, 
    0.10092003f, 0.04418508f, 0.04380778f, 0.04973770f, 0.14462717f, 0.11059922f, 0.05190203f, 0.01224648f, 
    0.03189856f, 0.07799570f, -0.00391666f, -0.03275163f, 0.00379805f, 0.04597620f, 0.09666532f, 0.02470222f, 
    0.16719200f, -0.30544755f, 0.12014779f, -0.04754213f, -0.05043967f, -0.06685197f, -0.12482892f, -0.08396973f, 
    0.05083023f, -0.01591538f, -0.00616273f, 0.04653906f, 0.02151048f, -0.04967909f, 0.15418477f, -0.08490257f, 
    -0.07891352f, 0.03928082f, 0.12817819f, 0.04494969f, -0.00673472f, 0.02812988f, 0.07134368f, 0.05384888f, 
    0.12007694f, -0.37148297f, 0.02217294f, -0.12454811f, 0.16258112f, -0.02855051f, 0.02446632f, -0.01743596f, 
    -0.04713508f, 0.10574526f, -0.05345020f, -0.01699738f, -0.08958672f, 0.16356675f, -0.02663436f, 0.19292751f, 
    -0.04032736f, -0.12251927f, 0.07580198f, 0.10865215f, -0.07183475f, 0.04177869f, -0.08102651f, 0.05907850f, 
    0.04213706f, -0.05645601f, -0.33476672f, -0.07950817f, -0.06511544f, 0.00336788f, 0.01802737f, -0.05012809f, 
    -0.07851408f, -0.05251949f, -0.15336919f, -0.00610380f, -0.13828529f, -0.11886387f, -0.19552121f, -0.01638521f, 
    -0.10069896f, -0.02594139f, 0.05123249f, -0.01741073f, 0.01307276f, -0.01354640f, -0.01109465f, 0.01596677f, 
    0.00323786f, 0.13626853f, -0.29828954f, -0.16836156f, -0.03480802f, 0.07062946f, -0.01371014f, -0.04260618f, 
    -0.00405800f, 0.12267374f, -0.08897419f, -0.04203630f, -0.01271700f, 0.01118154f, 0.02498610f, 0.04452115f, 
    0.03193096f, 0.05789893f, 0.02519634f, 0.05644821f, -0.10990308f, -0.03127220f, -0.13487931f, -0.06493872f, 
    -0.39698505f, 0.33051956f, -0.14200364f, -0.11233898f, 0.10828660f, 0.02444287f, -0.02007596f, 0.10923887f, 
    0.01284033f, -0.04599011f, 0.01054024f, -0.01579846f, -0.18446545f, 0.10376152f, 0.02781358f, -0.05892517f, 
    0.01379647f, 0.03251908f, 0.13970380f, 0.00933988f, -0.08486748f, -0.07498618f, -0.03028247f, -0.09575009f, 
    -0.58686292f, 0.01805201f, -0.10315243f, -0.08790609f, 0.10578769f, 0.06430908f, -0.03944726f, -0.02694217f, 
    -0.03623505f, -0.02039234f, -0.08768702f, -0.01668914f, 0.00465369f, 0.06831901f, 0.08941212f, -0.05730128f, 
    0.06499760f, -0.12177718f, 0.05316269f, 0.01322402f, 0.05774416f, 0.01782587f, -0.06071723f, -0.01185805f, 
    0.09555720f, 0.06924640f, -0.12041787f, 0.05378874f, 0.07134655f, 0.07353707f, -0.01886644f, -0.12564316f, 
    0.03141640f, -0.00458985f, -0.01318984f, -0.11655678f, -0.33474866f, -0.06392709f, -0.02826149f, -0.39453611f, 
    0.11223705f, -0.04507803f, 0.04626056f, -0.09854434f, 0.11382437f, 0.01915638f, -0.03029216f, -0.12920611f, 
    0.17480823f, 0.03968957f, -0.33417428f, -0.13548130f, 0.00900463f, 0.03797160f, 0.03575691f, 0.01012308f, 
    -0.07210785f, -0.08765047f, 0.01064201f, -0.00147253f, -0.13534980f, 0.15705754f, -0.04609253f, -0.01506711f, 
    0.01317616f, -0.12604271f, 0.00802729f, -0.05321103f, 0.03494184f, -0.05074562f, -0.07962846f, 0.09195710f, 
    -0.16389452f, -0.01125732f, -0.21240593f, -0.01704291f, -0.08723029f, -0.00580342f, 0.12182266f, 0.04571230f, 
    -0.00585867f, 0.03198062f, 0.03184025f, -0.06445455f, 0.05209138f, 0.20205136f, -0.00019198f, 0.03131758f, 
    0.01778792f, -0.08279873f, 0.10934831f, -0.02453384f, -0.01740154f, -0.02944110f, 0.05784223f, 0.00541940f, 
    0.11188003f, 0.03614377f, 0.18057555f, -0.07710639f, -0.06677566f, -0.01250911f, 0.04994803f, 0.07108293f, 
    -0.02973022f, -0.11610556f, -0.01712173f, -0.14050947f, 0.13603204f, 0.15984105f, -0.12946126f, -0.09530356f, 
    0.09607636f, 0.12425745f, -0.03468000f, 0.06350441f, -0.04088002f, 0.01448715f, -0.12487432f, -0.19204491f, 
    -0.11507457f, -0.20472175f, -0.02085996f, 0.17138292f, -0.07962135f, 0.06780951f, 0.02732738f, 0.04365709f, 
    -0.05503543f, 0.11297982f, -0.07150040f, -0.00662314f, -0.35842165f, 0.12312569f, 0.10942532f, 0.08408984f, 
    0.05618454f, -0.00273597f, -0.07154084f, 0.05000535f, -0.03081755f, -0.03965869f, 0.00914718f, 0.03077877f, 
    -0.32183152f, -0.04368791f, 0.22011976f, 0.01001904f, 0.01363557f, -0.08646286f, 0.03350101f, -0.08913294f, 
    0.00614673f, -0.03231347f, -0.09650557f, -0.04221316f, 0.11807275f, 0.01079251f, -0.06388950f, -0.01360145f, 
    -0.06765240f, -0.06724796f, -0.01688326f, -0.02946484f, 0.07633941f, 0.02094330f, -0.02104275f, -0.05208343f, 
    0.21354318f, 0.06166870f, 0.23203242f, 0.01411087f, -0.01439742f, -0.15121004f, 0.01103820f, -0.09204663f, 
    -0.10418908f, -0.02443572f, -0.03883683f, -0.03012042f, 0.10286120f, 0.11798066f, -0.06056260f, 0.02600946f, 
    -0.09469549f, 0.05845399f, -0.08330971f, 0.15868554f, -0.04718620f, 0.02380581f, -0.01742217f, 0.06607913f, 
    0.25443569f, -0.50565565f, -0.09659906f, 0.13586815f, -0.07872631f, 0.01794188f, 0.08162569f, 0.00215774f, 
    0.05998096f, -0.07145901f, -0.04362001f, 0.15583430f, 0.17840156f, 0.17145532f, 0.00772330f, -0.04233233f, 
    -0.00230375f, -0.00922464f, -0.00145985f, -0.15788370f, 0.00275715f, -0.08764090f, 0.08571748f, -0.03326876f, 
    -0.02080016f, -0.14389029f, -0.04030983f, 0.01676923f, 0.11399658f, 0.00125933f, -0.02428742f, 0.04738849f, 
    0.04417261f, 0.07529762f, 0.03313279f, 0.03750982f, -0.25663337f, 0.13698289f, -0.06017346f, -0.18521917f, 
    -0.13920222f, 0.01513490f, 0.00739096f, 0.05646174f, -0.05177533f, 0.04378719f, 0.02052866f, 0.02612392f, 
    0.01955409f, -0.17166176f, -0.07591574f, -0.03444630f, -0.03314469f, -0.04770732f, 0.05478780f, -0.07953489f, 
    -0.07131573f, 0.09013817f, -0.07899491f, 0.03929782f, -0.00318890f, 0.13939990f, 0.09045701f, 0.03090211f, 
    0.04704622f, 0.00506698f, -0.01880081f, -0.07086769f, -0.03022600f, -0.08650623f, -0.03587580f, 0.03689143f, 
    0.15676434f, -0.25939274f, -0.05197398f, 0.09974503f, 0.04106544f, 0.08830994f, -0.04263300f, -0.07675803f, 
    -0.03832839f, 0.00895890f, 0.01132667f, 0.04711949f, 0.45632067f, 0.04479288f, 0.17066059f, 0.05353450f, 
    0.06744044f, 0.02277020f, 0.09348100f, 0.06556175f, -0.01939839f, -0.00645598f, 0.01350615f, -0.04878378f, 
    -0.07410628f, 0.17015709f, 0.01422966f, -0.10201802f, -0.01972401f, -0.04541751f, -0.03003399f, -0.03334384f, 
    -0.05385844f, -0.04176527f, 0.00901580f, 0.03249510f, -0.02764021f, 0.00174891f, 0.04391650f, 0.00757592f, 
    -0.23137519f, 0.11524908f, 0.08503119f, 0.05439105f, -0.05142771f, 0.00071394f, 0.00444063f, 0.04294962f, 
    -0.11798525f, -0.51691347f, -0.24409622f, 0.10458143f, -0.10646769f, -0.02937449f, -0.08084739f, 0.01725649f, 
    -0.00740631f, 0.02855877f, -0.09046418f, 0.03653045f, -0.21101433f, -0.27613795f, -0.19018514f, -0.01717900f, 
    -0.05580099f, -0.00243593f, 0.16035916f, -0.13232507f, -0.06219254f, 0.01499806f, 0.07917259f, -0.07764188f, 
    0.07392210f, -0.20254977f, -0.21086921f, -0.09134945f, -0.04090529f, -0.06707318f, 0.05206755f, 0.05370715f, 
    0.10734610f, 0.05313521f, -0.00861248f, -0.01852121f, -0.04999076f, -0.17397995f, -0.23979782f, -0.07428324f, 
    -0.13326244f, -0.10485411f, 0.08603997f, -0.01914146f, 0.05452714f, -0.09588994f, 0.01883711f, -0.03605444f, 
    -0.32382745f, -0.00130860f, 0.01713538f, 0.07831055f, 0.09715299f, 0.01353467f, -0.04103864f, 0.04969683f, 
    -0.08910998f, -0.02426042f, -0.11963753f, -0.08996282f, 0.02935694f, -0.01379590f, -0.07761478f, 0.01176090f, 
    0.00197986f, 0.02157445f, -0.03091904f, -0.00702227f, 0.03981759f, 0.02264396f, 0.16132814f, 0.17053881f, 
    -0.05993903f, -0.25933489f, -0.22667053f, -0.05204987f, -0.14179955f, -0.09057780f, 0.03313240f, -0.00605398f, 
    0.03180891f, -0.07271969f, 0.00771755f, 0.02237580f, -0.02979869f, -0.02865797f, -0.00751681f, 0.04571380f, 
    0.00523696f, 0.06857853f, 0.00057056f, -0.07461871f, -0.01214505f, 0.05857794f, -0.06217592f, 0.02309819f, 
    0.02306768f, -0.10799981f, 0.06952368f, 0.11098290f, 0.03202881f, 0.06139966f, -0.05715072f, 0.09966853f, 
    -0.05855372f, 0.07535591f, -0.11690056f, 0.10492913f, -0.45504212f, -0.09011628f, 0.24386123f, 0.19245610f, 
    0.01278750f, 0.01450934f, 0.12804085f, -0.01581447f, 0.00240297f, 0.02060355f, -0.15553802f, -0.01652588f, 
    -0.02715220f, 0.06366636f, 0.05381419f, -0.14393981f, -0.10930497f, 0.05291055f, -0.03761774f, 0.07312303f, 
    -0.01039448f, -0.02656315f, 0.02362830f, 0.14396314f, -0.08294651f, 0.34354246f, 0.03838335f, -0.08281117f, 
    0.07113191f, -0.03246700f, -0.01842497f, 0.11382487f, -0.11912379f, -0.03747630f, -0.07035780f, 0.10646414f, 
    -0.15193623f, -0.07159021f, -0.13804461f, 0.14004822f, 0.00349270f, -0.08371989f, 0.15913120f, -0.02252445f, 
    -0.05777036f, 0.04361518f, -0.01158263f, -0.10096014f, 0.22719687f, 0.06008318f, 0.03743407f, -0.00338562f, 
    -0.04645745f, 0.03998176f, -0.05837926f, 0.22844730f, 0.04364914f, 0.02173761f, 0.08885764f, -0.14561941f, 
    0.30596203f, 0.02326975f, 0.05773143f, 0.04574178f, 0.02109295f, 0.12963694f, 0.13933185f, -0.03994697f, 
    -0.01129032f, -0.08731689f, -0.03524992f, -0.20132817f, -0.11936419f, -0.10003790f, -0.07789927f, -0.00485683f, 
    -0.04618309f, -0.04911619f, 0.04840698f, -0.00834345f, -0.03080606f, -0.04965707f, -0.00560530f, -0.01655108f, 
    -0.01324390f, -0.16702132f, 0.20387854f, -0.10203714f, 0.02376397f, 0.08579223f, 0.01471059f, -0.01900456f, 
    -0.06258886f, 0.00066845f, 0.03433633f, -0.02868952f, -0.21507622f, -0.25673789f, -0.24427269f, -0.03287289f, 
    0.01694901f, -0.09650534f, -0.03630731f, -0.01756916f, 0.08332068f, 0.04317062f, -0.02314675f, 0.00541019f, 
    0.26010349f, -0.03419001f, 0.09784487f, -0.18751663f, 0.03316472f, 0.04698478f, -0.01862044f, 0.03761706f, 
    -0.02046080f, -0.09463950f, -0.04071999f, -0.01856277f, 0.10535751f, -0.21791343f, -0.00554712f, 0.06012081f, 
    -0.08350097f, 0.06088376f, -0.06659670f, 0.03703663f, 0.01540612f, 0.00786649f, -0.06968144f, 0.03614021f, 
    -0.04812400f, -0.20308612f, 0.03473432f, 0.03584423f, 0.01851201f, 0.05239301f, 0.03086816f, -0.05694687f, 
    -0.02635978f, -0.01457878f, 0.03083106f, -0.01639674f, -0.04760172f, -0.04042111f, -0.05882002f, -0.04862249f, 
    -0.03745980f, -0.09044582f, 0.05961945f, -0.03565528f, -0.03131906f, -0.08161645f, 0.00186537f, 0.07280803f, 
    -0.56038278f, -0.19485831f, 0.05226726f, -0.00520571f, 0.05059581f, 0.03499198f, -0.03587061f, -0.07721184f, 
    -0.04242690f, 0.04163624f, 0.06578975f, -0.03973619f, -0.00517634f, 0.17031795f, 0.15957810f, 0.09485506f, 
    0.01616589f, -0.07430847f, -0.03637897f, 0.00042849f, -0.01253806f, -0.04629830f, -0.08435632f, -0.04082585f, 
    -0.28071484f, -0.00312761f, -0.17483313f, -0.27071011f, -0.06181150f, 0.05631224f, -0.09310824f, -0.12348688f, 
    0.01360330f, -0.00458764f, -0.15035321f, -0.03714491f, 0.17797559f, 0.06250357f, -0.14474338f, -0.03878800f, 
    0.07733221f, 0.01974663f, 0.02694716f, 0.00277335f, 0.00330861f, 0.07397189f, 0.11146622f, 0.00921512f, 
    -0.25504476f, -0.02950037f, 0.04193632f, 0.07018022f, 0.00467176f, -0.03542285f, -0.03550923f, -0.02070231f, 
    -0.01665413f, -0.04943426f, 0.00651215f, -0.05060114f, -0.28048924f, 0.13095078f, 0.08680019f, 0.23046929f, 
    0.12314004f, 0.08445122f, -0.01853589f, -0.07433062f, -0.09720315f, 0.09689809f, 0.07568488f, -0.05093196f, 
    0.03000202f, 0.05329973f, -0.10333120f, 0.07207930f, -0.05980874f, -0.10207905f, 0.08758391f, 0.03307382f, 
    -0.02024420f, 0.08521112f, 0.08205659f, -0.04867836f, -0.23906960f, -0.14189093f, -0.16854590f, -0.16403742f, 
    -0.02886185f, 0.03056345f, -0.07283428f, -0.08087403f, -0.10490941f, 0.04228631f, 0.00583863f, 0.09299789f, 
    0.15592156f, -0.19477308f, -0.03755586f, 0.09343003f, 0.03367397f, -0.00970625f, 0.08403616f, -0.02487711f, 
    0.05324978f, -0.00853457f, 0.11472586f, 0.07408831f, -0.05491222f, 0.03490563f, 0.07744408f, -0.02704821f, 
    -0.19605334f, 0.08116359f, 0.05011939f, -0.00655809f, 0.03776278f, 0.03144347f, 0.00194817f, 0.00570250f, 
    -0.05159706f, 0.29170233f, 0.10698866f, 0.02244911f, 0.11824964f, -0.02690061f, 0.18743514f, -0.09494691f, 
    0.08622339f, -0.01330872f, 0.08547106f, -0.09420771f, 0.16141017f, 0.13243254f, 0.10745147f, 0.04661835f, 
    -0.11236573f, -0.05822257f, 0.11320125f, -0.04298694f, -0.05620050f, 0.00571367f, 0.03180606f, -0.03020479f, 
    -0.32906699f, 0.12728161f, -0.07626922f, -0.06345405f, 0.01434219f, 0.03353043f, 0.09313414f, -0.01620560f, 
    -0.00966544f, -0.03854535f, 0.05930754f, -0.01828320f, -0.23262747f, -0.29535326f, -0.27847075f, -0.00591244f, 
    -0.10541890f, 0.01565437f, 0.00170046f, 0.06645660f, 0.00876082f, 0.02950919f, 0.03658608f, 0.04076973f, 
    -0.17342414f, -0.26995021f, 0.12599777f, -0.09326493f, -0.03660806f, 0.04857118f, 0.03754258f, -0.01385656f, 
    -0.01444952f, 0.08192042f, 0.06326634f, -0.07022307f, 0.00664495f, -0.06434731f, -0.40383300f, 0.14347473f, 
    -0.02349623f, 0.03400726f, -0.03626393f, 0.10035998f, -0.00778708f, -0.03664208f, -0.08857989f, -0.06107557f, 
    0.06958139f, -0.07029656f, -0.00442216f, -0.12913412f, 0.00357929f, 0.00380869f, 0.00160707f, 0.10030834f, 
    0.03807193f, 0.00272467f, 0.07765113f, 0.02710728f, 0.01273215f, 0.17962928f, -0.05681496f, -0.02134692f, 
    -0.02717178f, -0.14965591f, 0.05411867f, -0.02376048f, -0.03129486f, -0.09352234f, -0.05770861f, -0.02259650f, 
    -0.28895354f, -0.35277507f, 0.08261530f, 0.19992703f, -0.02724728f, -0.02508567f, -0.08390669f, -0.07584649f, 
    0.00530896f, -0.13064180f, -0.03934712f, -0.10558202f, 0.21600689f, 0.08003636f, 0.04254119f, 0.05613089f, 
    0.07408229f, 0.00518302f, -0.02068761f, 0.04894776f, 0.05821475f, 0.06749770f, 0.09618938f, -0.08493426f, 
    -0.30218571f, 0.25457177f, 0.15759857f, -0.17774408f, 0.02847888f, 0.04657142f, -0.00098437f, 0.11731844f, 
    -0.05068456f, 0.03236134f, 0.04770673f, 0.03787295f, 0.16053292f, 0.20240481f, -0.06087592f, -0.00497640f, 
    -0.01332668f, -0.06751241f, 0.09350484f, 0.03587920f, -0.00922929f, 0.00181416f, -0.11470947f, -0.07639390f, 
    0.20188431f, -0.01914901f, 0.02914711f, -0.02733699f, -0.05638742f, 0.06364606f, -0.00255803f, 0.11237833f, 
    0.00432502f, 0.02351986f, -0.05045461f, -0.01883054f, 0.08865147f, -0.26899695f, -0.06247685f, 0.05472942f, 
    0.03192545f, -0.05093412f, 0.10278945f, -0.01075392f, -0.20239487f, 0.06262512f, 0.11945812f, 0.01796387f, 
    -0.13044287f, -0.15510961f, -0.05551082f, -0.05809708f, -0.01898411f, -0.15350777f, -0.14998640f, 0.05891195f, 
    0.03489163f, -0.04288062f, 0.00222858f, 0.02550641f, 0.01902321f, 0.38259590f, -0.03117850f, 0.27897868f, 
    0.09381281f, 0.16752911f, 0.08313349f, 0.08523567f, 0.06661198f, -0.04994798f, 0.01687449f, -0.00868001f, 
    -0.02694219f, 0.07251130f, 0.07352086f, -0.04028218f, 0.01848066f, 0.03020695f, -0.01753798f, -0.00682678f, 
    -0.02233241f, 0.01125096f, -0.05679866f, -0.00499336f, -0.64434540f, 0.13950761f, 0.06552815f, 0.01286861f, 
    -0.11750524f, -0.09913266f, -0.01438596f, 0.02635218f, 0.00563631f, -0.05709504f, -0.04232695f, -0.09180006f, 
    -0.09126841f, -0.01716140f, -0.23773363f, -0.14059393f, -0.00504184f, -0.16105923f, 0.06596486f, 0.13139412f, 
    -0.03975176f, -0.11653154f, 0.08916262f, 0.03607984f, -0.28792414f, 0.03906190f, -0.17902051f, -0.17969631f, 
    0.05171611f, 0.02160545f, 0.08470805f, 0.18498613f, 0.02955624f, 0.01132188f, 0.02748963f, 0.12560529f, 
    -0.52833337f, 0.11819042f, -0.01420577f, -0.19781132f, 0.01111642f, -0.02973797f, -0.06744240f, 0.03244411f, 
    -0.14898553f, -0.06617548f, 0.02617969f, -0.03977354f, 0.04380216f, 0.00240363f, 0.07342050f, 0.14397590f, 
    0.06584103f, 0.03762352f, -0.04544904f, 0.09579040f, 0.10427557f, 0.05664200f, 0.01075279f, -0.05829647f, 
    -0.02360307f, 0.11309014f, 0.07031211f, 0.03732738f, -0.06979606f, 0.12672500f, 0.09507535f, -0.01461095f, 
    -0.06206892f, 0.09621318f, 0.05061420f, 0.03023082f, 0.19487393f, -0.16825366f, -0.12281369f, 0.18412179f, 
    -0.00650592f, -0.06906604f, -0.01921901f, 0.10676984f, 0.10741443f, -0.06419387f, -0.05979304f, -0.07530390f, 
    -0.04471289f, 0.07001303f, 0.22249261f, 0.14971128f, -0.05485672f, 0.00288581f, 0.06232990f, -0.12993474f, 
    0.02253479f, -0.04211419f, 0.03558791f, 0.13779993f, -0.07154191f, -0.30833763f, 0.01806045f, 0.22549026f, 
    0.05785171f, -0.10409489f, 0.00642467f, 0.03276314f, -0.12633730f, 0.03949210f, 0.12326729f, 0.05817050f, 
    -0.07736822f, 0.17265224f, 0.13355418f, 0.11000684f, 0.02318608f, 0.14193819f, 0.06142918f, -0.03626028f, 
    0.01547001f, -0.01399958f, 0.01122564f, 0.06958906f, -0.07521686f, -0.11534246f, 0.13395891f, 0.01418958f, 
    0.04525508f, -0.01907442f, 0.04157130f, -0.01705847f, 0.10013696f, -0.05038385f, -0.15387088f, 0.11262381f, 
    0.02898702f, -0.05676577f, 0.18548982f, 0.17644937f, -0.02294714f, 0.03439023f, 0.01851038f, -0.03323952f, 
    0.10833174f, 0.10553062f, -0.04588158f, -0.07083210f, -0.03977586f, 0.00342305f, -0.02933271f, 0.03969604f, 
    -0.07717624f, -0.00657763f, 0.00960396f, -0.17908120f, 0.01455965f, 0.10062038f, 0.03351179f, 0.00437653f, 
    -0.10439079f, 0.07415009f, 0.07003598f, 0.23495612f, 0.11967600f, 0.03897813f, -0.10143444f, 0.02673673f, 
    -0.02635150f, 0.03588828f, 0.04111367f, -0.09673841f, -0.03918875f, -0.10614292f, 0.02895301f, 0.19068462f, 
    0.02863835f, 0.04919580f, -0.01179373f, 0.07879979f, 0.05214756f, -0.01245679f, 0.07501134f, 0.04918976f, 
    -0.06224461f, 0.10350166f, 0.04294094f, -0.08604992f, 0.04245596f, -0.05725211f, -0.03341024f, 0.06019113f, 
    0.09146282f, -0.04415077f, -0.08324105f, 0.10118626f, -0.02602534f, -0.03929718f, 0.04506293f, 0.06024158f, 
    -0.01770324f, -0.07305369f, -0.05488345f, -0.04943181f, 0.20057736f, -0.00267558f, 0.03018605f, -0.10419829f, 
    0.03726530f, -0.15254247f, 0.03251660f, 0.05070355f, -0.15324982f, -0.10380635f, 0.06882193f, -0.01177644f, 
    0.03744460f, 0.05598544f, -0.02918046f, -0.12584370f, 0.15848199f, -0.10310535f, -0.14877269f, 0.02982054f, 
    -0.14315690f, -0.05241846f, 0.07524103f, 0.04029322f, 0.02064877f, -0.01837801f, 0.04683217f, -0.11280458f, 
    -0.19932100f, -0.31490338f, 0.18527618f, 0.07220928f, 0.07956183f, 0.10661353f, 0.11854486f, 0.03408672f, 
    0.06422722f, 0.06791073f, -0.15471123f, -0.07523604f, -0.02150191f, 0.11859085f, 0.17423302f, -0.25721297f, 
    0.02667776f, -0.03750170f, 0.12647586f, 0.09469190f, 0.00089588f, 0.07907221f, -0.05143536f, 0.08343415f, 
    0.03431046f, 0.16578461f, 0.01389623f, 0.02662206f, -0.03614732f, 0.10883337f, 0.05801111f, 0.09045798f, 
    0.03744484f, -0.01661612f, 0.02627733f, 0.11132582f, 0.14607850f, 0.04231139f, -0.07607390f, 0.05697611f, 
    -0.02451420f, -0.11145779f, 0.00433748f, -0.00297661f, 0.03506552f, -0.10670781f, 0.02421855f, -0.08965896f, 
    -0.25796676f, -0.06634854f, 0.19600542f, -0.03781885f, -0.08767574f, 0.06449287f, 0.04687875f, 0.05489236f, 
    -0.02828830f, 0.00273562f, 0.14941537f, 0.01116478f, -0.16441438f, 0.04526258f, -0.02579999f, 0.12064748f, 
    -0.09181970f, -0.07162167f, -0.00999957f, 0.05082471f, 0.01241134f, 0.06808086f, -0.11726347f, -0.04742223f, 
    0.26316154f, -0.21236649f, 0.08256236f, -0.18738249f, -0.01022547f, 0.04846722f, 0.02363594f, 0.03590187f, 
    0.02255503f, -0.05867087f, -0.05880859f, 0.04629635f, 0.03678318f, -0.15088868f, -0.06739605f, -0.21219374f, 
    0.00557435f, 0.01478911f, 0.05905145f, -0.00686967f, -0.11693090f, 0.05454580f, 0.06742989f, 0.05231154f, 
    0.01588416f, -0.01511913f, -0.09446470f, -0.07590538f, -0.03140115f, -0.03685298f, 0.06981402f, 0.10728779f, 
    0.01469469f, 0.08493786f, -0.10223999f, -0.12741470f, -0.02981739f, 0.06907690f, 0.06711490f, -0.09765559f, 
    -0.02970397f, 0.01037976f, 0.05763889f, -0.02992654f, -0.18200760f, 0.08319615f, 0.04920563f, 0.10210474f, 
    -0.19076928f, -0.05198945f, 0.12282469f, 0.22923903f, -0.06635065f, 0.05090399f, -0.11910450f, -0.13384810f, 
    0.07423460f, -0.04801439f, -0.00132980f, -0.00313475f, -0.44113567f, 0.05267404f, 0.23564845f, 0.16661844f, 
    -0.06989278f, 0.06998138f, 0.06889167f, -0.04130321f, 0.04838198f, 0.06588405f, 0.04464005f, 0.04084586f, 
    0.09764960f, -0.00625185f, 0.17655674f, -0.09031279f, 0.05467175f, 0.04096145f, 0.04363355f, -0.14485881f, 
    -0.00975845f, -0.07605521f, -0.04366301f, -0.08974420f, 0.24645893f, -0.06953294f, 0.01877241f, 0.11721209f, 
    0.06460282f, 0.04729277f, 0.09631722f, 0.08540167f, -0.04107706f, -0.02974515f, 0.09257855f, 0.04424421f, 
    -0.01989337f, -0.13993721f, 0.04746745f, -0.23345008f, -0.01434945f, 0.07319600f, -0.11786258f, 0.10509177f, 
    -0.01201695f, -0.09131456f, -0.09442733f, 0.01129499f, -0.02311805f, -0.04752638f, 0.07157858f, -0.01653812f, 
    -0.04823505f, 0.02732427f, 0.03262817f, -0.01574893f, 0.18081214f, 0.06179458f, 0.08871265f, 0.02253175f, 
    -0.63271892f, 0.04722228f, 0.11085597f, 0.18650995f, -0.05422206f, 0.04515320f, 0.03265646f, 0.10886232f, 
    0.03440863f, -0.01419097f, 0.08652049f, 0.07854231f, -0.24638708f, -0.05244130f, 0.18618321f, 0.12330016f, 
    -0.00456156f, -0.04285032f, 0.06433010f, 0.01922061f, 0.02475851f, -0.01773452f, -0.02199636f, 0.03101995f, 
    -0.12090036f, 0.11145552f, -0.15796500f, -0.01097420f, 0.05764360f, -0.04106709f, 0.02658431f, 0.00848700f, 
    0.10355441f, -0.17680779f, 0.00905469f, -0.13410127f, -0.11442698f, -0.04537015f, 0.14519262f, -0.05177407f, 
    0.03969104f, -0.02695427f, 0.01529869f, 0.13472782f, -0.04013802f, -0.01006873f, -0.01352332f, -0.01738779f, 
    -0.18931139f, -0.09642003f, 0.02509083f, 0.05793059f, 0.09567559f, -0.03015985f, 0.13641527f, -0.20602037f, 
    0.01187746f, -0.03621666f, -0.01184831f, 0.01602329f, -0.11584154f, 0.16064961f, 0.01807415f, -0.15590920f, 
    -0.03176872f, 0.01005665f, 0.09451980f, -0.11744017f, -0.08916907f, -0.00328909f, 0.01795139f, -0.05456055f, 
    -0.24981552f, 0.28767154f, -0.09573364f, -0.08009465f, -0.01113969f, -0.09860354f, 0.06522739f, 0.06200143f, 
    -0.08061620f, -0.03791365f, -0.07506108f, -0.00741861f, -0.48921946f, -0.14942697f, 0.14699079f, 0.00043121f, 
    0.09467748f, -0.14390169f, 0.02181858f, -0.07439932f, 0.02836927f, 0.02658751f, 0.06382997f, -0.05006790f, 
    -0.21068698f, -0.04171145f, -0.06440728f, -0.15944491f, -0.05303074f, 0.00481188f, -0.02994775f, 0.01276866f, 
    0.04621519f, -0.02076401f, 0.03097182f, 0.00459808f, -0.48167220f, 0.37501872f, -0.09716377f, 0.02337660f, 
    0.04458703f, -0.06287084f, 0.06113601f, 0.07746217f, -0.07675036f, 0.05710743f, -0.06657056f, 0.00598826f, 
    0.34196556f, 0.16420370f, -0.08052797f, 0.02927046f, -0.02129282f, 0.06826211f, 0.06061627f, 0.09402366f, 
    -0.07312123f, -0.08525854f, 0.01978947f, 0.12366641f, -0.13177447f, -0.06019030f, -0.01807341f, 0.15965311f, 
    -0.05068336f, -0.08890861f, 0.09385221f, 0.06436945f, -0.07180925f, 0.01034736f, 0.03863252f, -0.02073991f, 
    0.11177178f, 0.05481468f, -0.13851136f, -0.06748817f, 0.04502411f, -0.07449870f, 0.03163002f, -0.20106237f, 
    -0.10244237f, -0.06120872f, -0.04030141f, -0.01106690f, 0.04638707f, 0.00501990f, -0.16462599f, 0.08989789f, 
    0.12546740f, 0.00835722f, -0.00896588f, 0.00080270f, 0.04251276f, 0.00057811f, 0.08463948f, -0.03767484f, 
    -0.21301188f, -0.15922216f, 0.17485489f, -0.03583515f, 0.05814124f, -0.05475931f, 0.12314729f, -0.04874869f, 
    0.03341332f, -0.05157383f, 0.03189900f, 0.05452912f, -0.09906261f, -0.16711321f, -0.04489243f, -0.07871948f, 
    -0.07427762f, 0.05571106f, 0.00373558f, 0.07294939f, -0.09379441f, 0.00185335f, -0.12132383f, -0.04090896f, 
    0.06031553f, 0.15663402f, 0.02815884f, -0.05291213f, 0.01270800f, 0.01160842f, 0.10806398f, 0.03170453f, 
    0.01180711f, 0.08370034f, 0.02084986f, 0.07437167f, -0.20540670f, -0.35133037f, -0.02396585f, 0.06227811f, 
    -0.12052789f, 0.05642251f, -0.12702315f, -0.11383827f, 0.05285918f, 0.04828539f, -0.04390316f, -0.03008213f, 
    0.18788508f, 0.11621805f, 0.23630773f, -0.17446637f, 0.03684380f, 0.09004734f, 0.02919185f, -0.10064924f, 
    0.09453268f, -0.00707689f, 0.04671586f, -0.01491577f, -0.13207301f, -0.09096586f, 0.01594940f, -0.21965683f, 
    0.11769323f, -0.07213588f, 0.00580167f, -0.06306142f, -0.01262932f, -0.16720665f, 0.00777272f, -0.12373325f, 
    -0.35200214f, 0.16454805f, 0.19791707f, 0.12165394f, 0.05002026f, -0.07506854f, 0.00048372f, 0.01269452f, 
    -0.04154947f, 0.01480997f, 0.02565520f, -0.01880442f, 0.07069959f, -0.12361903f, -0.09382744f, 0.22643983f, 
    -0.16658279f, -0.09441131f, -0.10698671f, -0.06078884f, -0.11590578f, -0.04741802f, -0.01195926f, -0.08591346f, 
    0.03697524f, 0.14441797f, 0.12472241f, 0.04251242f, -0.07503589f, -0.23326659f, 0.11388926f, -0.06398195f, 
    0.06495895f, -0.06135499f, -0.08067596f, -0.03724220f, 0.20047535f, -0.00337671f, -0.20330752f, 0.09223241f, 
    0.13080467f, 0.01911286f, -0.01624659f, -0.02779026f, -0.11417963f, -0.00990963f, 0.02990635f, -0.05149153f, 
    0.13040352f, 0.03364150f, -0.27502483f, -0.13570429f, 0.01219737f, -0.04804724f, 0.08203691f, -0.09564529f, 
    -0.06034003f, 0.14052609f, -0.09827168f, -0.09925198f, 0.06997077f, -0.17754747f, -0.01188185f, -0.12174780f, 
    -0.10396839f, 0.06785356f, -0.11910509f, -0.23089206f, -0.00023973f, -0.06397725f, 0.08250909f, -0.05938801f, 
    -0.23413663f, 0.05241474f, -0.03398595f, -0.04417064f, 0.07069596f, 0.07422110f, -0.10887531f, 0.06253545f, 
    -0.05221088f, -0.05132664f, 0.01893907f, 0.08651936f, -0.15727289f, -0.18659437f, 0.09338689f, -0.18850292f, 
    0.02579268f, 0.15250337f, -0.04733675f, -0.04064101f, 0.14389819f, 0.11523741f, -0.01277357f, -0.05608565f, 
    -0.21045952f, 0.17554426f, 0.12390553f, 0.04192408f, -0.02978848f, 0.07331134f, -0.00029241f, -0.01043550f, 
    -0.00876320f, -0.07354878f, 0.17967840f, -0.10628032f, -0.03171996f, -0.19610655f, -0.00107344f, -0.00955097f, 
    -0.01552873f, -0.00592367f, -0.04914415f, -0.00958715f, -0.05404630f, 0.10513987f, 0.05033089f, 0.12695234f, 
    -0.09911116f, 0.13486142f, 0.31414816f, 0.06348905f, 0.04137456f, 0.00679538f, 0.02150916f, -0.17889395f, 
    0.18160193f, 0.00533791f, 0.05402235f, 0.07794546f, -0.50685233f, 0.08988591f, 0.06619252f, -0.12547258f, 
    -0.07125255f, -0.04584311f, 0.00270772f, 0.06881122f, -0.16396695f, 0.12055802f, -0.14737979f, -0.09207101f, 
    -0.41389114f, 0.10962214f, -0.17712350f, -0.14015198f, 0.19107783f, 0.13438068f, -0.00585961f, 0.09320202f, 
    -0.02511676f, -0.08058141f, -0.25020182f, -0.02328693f, -0.06783483f, 0.05387736f, -0.20800263f, 0.12115563f, 
    0.14916879f, 0.04442388f, 0.01773844f, -0.02400913f, -0.00889676f, -0.03490705f, 0.05243235f, -0.11450269f, 
    0.08991179f, 0.12492465f, -0.04482550f, -0.03828574f, 0.00680051f, -0.04396484f, -0.04504747f, 0.12002744f, 
    -0.12706125f, -0.12326819f, 0.05981741f, 0.00030505f, -0.15531348f, -0.00707705f, -0.11352158f, -0.07532979f, 
    -0.14139451f, 0.01698686f, 0.00426024f, -0.01679065f, 0.02438154f, 0.00446355f, -0.10139083f, 0.06299013f, 
    0.13491113f, -0.13601449f, -0.11775973f, 0.12151948f, 0.11970505f, -0.09410989f, 0.07974414f, 0.13481861f, 
    0.02212616f, 0.01902599f, -0.00382577f, -0.30327997f, 0.28264478f, 0.24509996f, -0.10950182f, -0.08934842f, 
    0.08004804f, 0.09251878f, -0.18896276f, 0.00340686f, 0.03347161f, -0.02147981f, -0.05719342f, -0.08093971f, 
    -0.53700203f, -0.18860768f, -0.15141571f, -0.07679537f, 0.09007575f, 0.00391796f, -0.11227712f, -0.08230804f, 
    0.02513427f, -0.03084194f, 0.00883478f, -0.02675246f, -0.00250108f, 0.03423065f, 0.03152818f, 0.21221380f, 
    -0.01000505f, -0.21306653f, -0.02355012f, 0.03622488f, 0.07312898f, 0.20263596f, 0.14674132f, 0.14104259f, 
    0.08467612f, -0.07139125f, -0.11147642f, -0.02755379f, -0.05335758f, 0.02211517f, -0.04908743f, 0.05705396f, 
    -0.00818107f, 0.00620802f, 0.14257838f, 0.02963727f, -0.20244357f, -0.09421417f, 0.10975084f, 0.20999801f, 
    0.02435035f, -0.07773632f, -0.00053309f, -0.01422181f, -0.16447987f, -0.11885788f, 0.06103973f, 0.14465737f, 
    -0.39916345f, -0.21766137f, -0.35222176f, -0.05269501f, 0.02399988f, 0.14661185f, 0.09527776f, 0.00228592f, 
    0.00578475f, -0.05319101f, 0.14180134f, -0.05401486f, 0.17281249f, -0.12946720f, -0.17750216f, -0.01343905f, 
    0.00106012f, -0.06944992f, -0.17158946f, -0.08414306f, -0.06507230f, -0.02329211f, -0.09160795f, -0.05959624f, 
    0.01025700f, -0.13568985f, -0.00851462f, 0.20604478f, 0.13686590f, 0.05704192f, 0.00118641f, 0.06620932f, 
    0.10497125f, 0.00684629f, -0.10321991f, -0.08639974f, 0.08360213f, 0.08403368f, 0.19445886f, 0.02734683f, 
    -0.14144054f, -0.00286075f, -0.07839323f, 0.04457868f, 0.00118080f, -0.02679122f, 0.08960559f, 0.01097174f, 
    0.09762522f, 0.02179585f, 0.00795288f, 0.01079545f, -0.00718838f, 0.01277913f, -0.00719150f, -0.08717880f, 
    -0.12360348f, 0.03123048f, 0.14327514f, 0.02520285f, -0.07889506f, 0.10294677f, 0.12852088f, -0.22622693f, 
    0.04265586f, 0.13892405f, -0.03329751f, -0.15341221f, -0.03027823f, -0.01451396f, 0.01659989f, 0.16708112f, 
    0.14338544f, 0.00130403f, -0.10307293f, -0.08783274f, -0.16343932f, -0.07468444f, -0.00670745f, 0.02080523f, 
    0.09400385f, -0.10438911f, 0.13255470f, 0.08642353f, 0.02203307f, 0.08044545f, -0.13960622f, 0.11654025f, 
    -0.00674711f, 0.00613278f, -0.10045225f, -0.05993560f, -0.04873864f, 0.08921737f, 0.18535700f, -0.03370284f, 
    -0.00784558f, 0.10079274f, 0.08516566f, -0.00201802f, -0.05352052f, -0.05756660f, 0.06924164f, -0.08135017f, 
    0.01101364f, 0.05474865f, -0.07595163f, 0.09672071f, 0.03347392f, -0.23290175f, 0.01427103f, 0.04720938f, 
    0.05098047f, 0.04608869f, -0.08361426f, 0.04878563f, 0.09125125f, 0.11316764f, -0.07463378f, 0.15222172f, 
    0.00061448f, -0.24259116f, -0.03266604f, 0.05825986f, 0.10225324f, 0.11075801f, -0.07562343f, -0.01343301f, 
    0.03843930f, -0.07637965f, -0.03785324f, -0.07643728f, 0.11899834f, -0.01298876f, -0.02865773f, -0.02527582f, 
    0.09306152f, 0.06952244f, -0.04284300f, 0.00186988f, 0.00836568f, 0.03845296f, 0.04359033f, 0.12087980f, 
    0.05408109f, -0.08175619f, -0.02132512f, 0.04138048f, 0.07160524f, -0.09662468f, -0.00548814f, 0.13565578f, 
    0.05784779f, -0.04305705f, 0.08101121f, -0.10882097f, -0.02946511f, -0.03828849f, -0.04692981f, 0.04926840f, 
    -0.03126214f, 0.00005017f, 0.02874018f, 0.08148522f, 0.07927266f, 0.05442732f, 0.03566187f, 0.01172934f, 
    0.01338961f, -0.02027907f, 0.05113044f, 0.01677412f, 0.06519006f, 0.13918400f, -0.00534071f, -0.07949458f, 
    -0.06225662f, -0.08918201f, 0.14177154f, 0.24205102f, -0.02239071f, 0.00709942f, 0.25265482f, 0.15701558f, 
    0.05241818f, -0.03395161f, 0.02867786f, 0.11522214f, 0.07635016f, 0.03956738f, -0.06562407f, -0.01149681f, 
    0.04693939f, 0.00071116f, 0.07774474f, -0.06836729f, -0.05457212f, -0.01969544f, 0.06788778f, 0.01068617f, 
    -0.05916289f, -0.10245625f, -0.03397411f, 0.12820476f, 0.05382362f, -0.04937618f, -0.24022935f, 0.02160401f, 
    -0.05282841f, -0.03378742f, -0.15202090f, -0.00005626f, 0.06674110f, 0.00388427f, -0.03046378f, -0.02453287f, 
    0.00695367f, 0.15959479f, -0.06417196f, -0.05941866f, -0.10911041f, 0.03072363f, -0.04421496f, 0.12579596f, 
    0.03590749f, 0.05976639f, -0.11286848f, -0.23623425f, 0.19993846f, 0.11638725f, 0.15503201f, -0.18259421f, 
    -0.14078769f, -0.14448164f, -0.12010300f, -0.02240726f, 0.03735022f, -0.08397615f, -0.10339379f, -0.20801318f, 
    -0.20500271f, -0.08602939f, -0.13118815f, 0.11273843f, 0.02358411f, -0.17697117f, 0.19619767f, 0.08768104f, 
    0.01428141f, 0.12828466f, -0.06968369f, -0.21016964f, -0.06059934f, -0.11710864f, -0.05660375f, 0.01398075f, 
    0.15842867f, -0.09770048f, 0.07557723f, -0.02168957f, 0.01464123f, 0.04541179f, -0.20751075f, 0.12817177f, 
    0.06417578f, 0.16711824f, -0.32258958f, -0.06272886f, -0.02793708f, 0.05734118f, -0.05785929f, -0.08262445f, 
    -0.16457997f, 0.00305287f, -0.15082447f, -0.00826187f, -0.62743199f, -0.14354977f, -0.11643402f, 0.04498499f, 
    0.05801012f, 0.07458534f, -0.10765076f, -0.01487652f, 0.05842757f, -0.12228903f, 0.20219886f, -0.04113563f, 
    -0.02831201f, -0.02785181f, 0.18781851f, -0.16291609f, -0.12673625f, -0.09328718f, -0.00799679f, 0.04261080f, 
    0.02476839f, 0.01179452f, -0.05224567f, -0.01378872f, 0.01073428f, -0.02542025f, -0.01003612f, 0.02140420f, 
    0.01810635f, -0.05437816f, 0.14649704f, -0.04543402f, 0.13332814f, -0.00401562f, -0.02896625f, 0.17411841f, 
    -0.11586761f, 0.09259953f, -0.08286402f, -0.13779391f, 0.03486073f, 0.03877018f, -0.05221618f, 0.09307802f, 
    0.06640943f, -0.05165186f, 0.04797938f, 0.11007712f, -0.12433375f, -0.15285258f, -0.06081747f, 0.00186565f, 
    0.08932983f, -0.09168707f, -0.03216037f, -0.04351292f, 0.04762252f, 0.06460176f, -0.13976358f, 0.05427521f, 
    -0.27128109f, 0.11449203f, 0.14488694f, -0.26300308f, -0.01722500f, 0.09271198f, -0.01015250f, 0.17146060f, 
    0.02767730f, 0.00406206f, 0.01508510f, -0.07189403f, 0.11638855f, -0.12272576f, 0.08370113f, 0.05495251f, 
    -0.05857798f, -0.04468901f, 0.12641074f, -0.02206340f, -0.04859470f, -0.09721702f, 0.01550494f, 0.08284801f, 
    -0.23501608f, 0.16337451f, 0.05788117f, -0.19098759f, -0.03798149f, 0.08780105f, 0.08246080f, -0.03814615f, 
    0.06975461f, 0.01786008f, -0.15647946f, -0.00732303f, -0.21875247f, 0.14113295f, 0.18146314f, -0.14516614f, 
    0.14564300f, -0.05564294f, -0.16246772f, 0.01597977f, -0.01235163f, -0.06867507f, 0.03206505f, -0.14952251f, 
    -0.03460500f, 0.10547055f, 0.12438677f, -0.04147440f, -0.09287398f, -0.07198846f, 0.03707929f, -0.19119450f, 
    -0.00772816f, -0.06601247f, -0.17102656f, -0.03280952f, 0.13190053f, -0.05320187f, -0.15130839f, -0.05285947f, 
    0.06783389f, 0.13847013f, -0.13786271f, -0.25911462f, -0.06009240f, 0.02082244f, -0.00642581f, 0.01280597f, 
    0.12390436f, -0.02913576f, 0.06335858f, 0.16499853f, 0.05731713f, -0.04854811f, 0.12114976f, 0.03083593f, 
    0.04037175f, 0.20650791f, -0.02686128f, 0.10545339f, -0.06585346f, -0.06204845f, -0.05030312f, -0.15818374f, 
    0.06459083f, 0.09478066f, -0.16031656f, -0.06948012f, 0.01093172f, 0.07037877f, 0.07844199f, -0.09464755f, 
    0.12490876f, 0.06905568f, 0.01359310f, 0.12914442f, -0.17054170f, 0.00384551f, -0.06172597f, 0.10738862f, 
    -0.03630620f, -0.04395555f, 0.01556391f, -0.04207242f, 0.12883367f, -0.01057340f, 0.02180940f, -0.00506730f, 
    0.08159433f, 0.08841991f, 0.04683328f, -0.09058989f, 0.05611854f, -0.08949305f, 0.12525101f, 0.02123522f, 
    -0.17481980f, 0.10493404f, 0.13185401f, -0.03615450f, -0.00541122f, -0.00890046f, -0.18734600f, -0.04815025f, 
    0.02818196f, -0.02537834f, -0.00507146f, -0.04102404f, 0.06780586f, 0.14954530f, -0.02662215f, 0.04511298f, 
    0.00285458f, -0.12490521f, 0.03631385f, 0.00185678f, 0.04796961f, -0.01287409f, -0.04818351f, 0.07925043f, 
    -0.31101382f, 0.00573626f, -0.09202594f, 0.11144561f, -0.10466577f, -0.03239174f, 0.07062993f, 0.12116995f, 
    0.06173865f, -0.13366552f, 0.05216922f, 0.01308422f, -0.34477943f, -0.06049298f, 0.13345486f, -0.09577007f, 
    0.03674177f, 0.13923392f, -0.14157251f, 0.10933687f, -0.04489942f, 0.02230478f, 0.06248639f, -0.11532318f, 
    0.01335444f, 0.01249934f, 0.13451621f, 0.14280288f, -0.06635152f, -0.01048757f, 0.03501832f, -0.00512644f, 
    -0.03677506f, -0.01164819f, 0.04035389f, 0.18581764f, -0.11434165f, -0.02743497f, 0.27435872f, 0.23562028f, 
    -0.05280431f, -0.06240235f, 0.00664026f, 0.03684632f, 0.00044526f, -0.03853251f, 0.02585018f, -0.02192166f, 
    -0.12617132f, -0.14730196f, 0.03897225f, 0.15377031f, -0.09118149f, 0.00946530f, -0.09208703f, 0.00320142f, 
    0.18005794f, 0.11373641f, 0.10658458f, -0.02603468f, -0.28013024f, -0.04957508f, 0.15719004f, 0.03393860f, 
    0.04129323f, 0.12225663f, -0.00726984f, 0.03578874f, 0.12708341f, 0.14352535f, 0.03330842f, 0.03830242f, 
    -0.11670976f, 0.06274063f, -0.03202187f, 0.09345802f, 0.08413098f, 0.03341334f, 0.07689355f, -0.11385075f, 
    0.09730957f, -0.11826585f, -0.04545564f, -0.02245780f, 0.02147720f, -0.03479548f, -0.00280014f, -0.04162479f, 
    -0.12950966f, -0.01481235f, 0.05378202f, -0.02883847f, 0.12669960f, -0.13036852f, -0.06301910f, -0.16143531f, 
    0.05091101f, 0.11963993f, -0.01784409f, -0.08117504f, 0.04711706f, -0.19338804f, 0.11727292f, -0.04104674f, 
    0.05084475f, 0.08901484f, 0.01120100f, -0.04317035f, -0.14642853f, 0.05747817f, 0.01072250f, 0.05081427f, 
    -0.19119796f, 0.00648116f, 0.12325219f, -0.08752653f, -0.02080773f, -0.08023304f, 0.13622025f, 0.00300901f, 
    0.29457903f, -0.05554947f, 0.13685229f, -0.40794310f, 0.05570679f, 0.04103708f, 0.10702639f, 0.00373307f, 
    0.05617163f, 0.08705997f, -0.02544629f, -0.04948983f, -0.16737738f, -0.08589789f, 0.05843883f, 0.09261751f, 
    0.09145994f, -0.00320428f, 0.06526922f, -0.01480584f, 0.01566974f, -0.09567306f, 0.00789078f, 0.01018823f, 
    0.13826112f, -0.34358898f, -0.05816073f, -0.06721725f, -0.07988549f, 0.00005353f, 0.08247852f, 0.09200575f, 
    0.09339442f, 0.03891972f, -0.12009893f, -0.16316196f, 0.34050655f, -0.30914968f, 0.11793937f, -0.00775309f, 
    0.11594570f, 0.02002770f, -0.05150276f, -0.08657857f, -0.01020521f, -0.05000251f, 0.10641262f, -0.04121380f, 
    0.41305208f, -0.12548384f, 0.08765730f, -0.10739402f, 0.01104239f, -0.06548789f, 0.11256545f, -0.27861530f, 
    -0.00059482f, -0.00433614f, 0.22145185f, 0.00886261f, -0.15450497f, 0.03089456f, -0.05305632f, -0.17971258f, 
    -0.02391392f, -0.07500660f, 0.09221970f, -0.09641869f, -0.09148773f, 0.04019281f, 0.02674714f, 0.04946603f, 
    -0.05465918f, 0.13113865f, 0.14677030f, 0.00169987f, 0.01248273f, 0.03529806f, -0.04849575f, -0.01271253f, 
    0.08259985f, 0.10138563f, -0.01062283f, 0.06548626f, -0.20539342f, 0.03831809f, 0.08756330f, -0.13700679f, 
    0.06982861f, 0.02036104f, -0.04612631f, 0.00850494f, 0.01613618f, -0.02985497f, 0.19352271f, -0.00675062f, 
    -0.24735643f, 0.04718277f, -0.06804541f, -0.07596800f, 0.02436326f, 0.09318759f, 0.01612738f, 0.07153671f, 
    -0.00907184f, -0.04715886f, 0.08685073f, 0.08403526f, -0.24642497f, 0.04756044f, -0.12618144f, 0.09701436f, 
    -0.21571356f, -0.08055376f, 0.09958093f, -0.13803641f, -0.01818599f, 0.00716846f, -0.02791535f, 0.11059465f, 
    -0.31319875f, -0.20845175f, 0.05637395f, -0.14322211f, 0.02290736f, -0.00712973f, 0.08958075f, -0.03776947f, 
    0.04820633f, -0.07848461f, 0.06495152f, 0.11177234f, -0.01272711f, -0.19736980f, -0.14486228f, 0.03748455f, 
    0.01732439f, 0.05050777f, -0.07264550f, 0.04876526f, -0.10640271f, -0.09823459f, -0.15074931f, -0.06013880f, 
    0.01414206f, 0.10211666f, 0.05172784f, -0.19964418f, 0.15987542f, 0.09864057f, 0.03992580f, 0.04173344f, 
    -0.01934566f, -0.05781107f, -0.17062877f, 0.09790283f, -0.07914812f, -0.15326607f, -0.07566337f, 0.07829581f, 
    0.06683046f, 0.08273428f, -0.07213839f, -0.00891193f, -0.04517322f, -0.01585369f, -0.12469604f, 0.12649867f, 
    -0.35920283f, -0.00169795f, -0.04515765f, -0.23692568f, -0.03590076f, 0.00260567f, -0.04298083f, -0.25276923f, 
    -0.13778970f, 0.04205005f, -0.03643821f, 0.14676583f, -0.34977803f, -0.07531869f, -0.10490107f, 0.10763302f, 
    -0.01306070f, 0.06547429f, 0.12765273f, 0.06568130f, 0.06984199f, 0.00332055f, 0.00794304f, -0.03656630f, 
    -0.33130774f, 0.10044423f, -0.05916160f, -0.04612059f, -0.11382062f, -0.08991735f, 0.05944031f, 0.04063781f, 
    -0.00816262f, 0.08283438f, 0.12520230f, 0.06790645f, -0.21405604f, 0.14324550f, 0.05740758f, 0.10157952f, 
    -0.03546770f, 0.06714264f, -0.06542476f, 0.05287362f, -0.06930206f, 0.03058499f, -0.02244928f, -0.04359647f, 
    -0.15153776f, 0.17188825f, 0.00680847f, 0.19225389f, 0.00003881f, 0.00645663f, 0.03356948f, 0.10474873f, 
    0.03112897f, -0.11459769f, -0.01848072f, 0.02890570f, -0.05016901f, 0.11937858f, 0.18832916f, -0.17719518f, 
    -0.15093072f, -0.05174001f, -0.04420481f, -0.01442566f, 0.03213901f, -0.05266159f, -0.00549904f, -0.26364797f, 
    0.01563235f, 0.04669551f, 0.06521565f, -0.03562106f, -0.00620146f, 0.06289446f, 0.05689687f, 0.02513164f, 
    -0.02050515f, 0.04707142f, -0.14636235f, -0.10339401f, 0.13529649f, -0.01928460f, 0.01023735f, 0.18393475f, 
    0.05155295f, 0.01146230f, 0.04046409f, 0.03897244f, 0.04769688f, 0.01315674f, -0.14434874f, -0.02877772f, 
    -0.26486585f, 0.13991675f, 0.10666947f, -0.01133464f, -0.04696964f, 0.06653003f, 0.04474369f, 0.04037352f, 
    -0.00390652f, 0.05569757f, -0.03122260f, -0.08646057f, -0.23433582f, 0.12081200f, -0.13052943f, 0.03181387f, 
    -0.02493698f, 0.00764605f, 0.12373483f, -0.15717515f, -0.06592536f, -0.11580399f, 0.10077924f, -0.20357335f, 
    -0.05251835f, 0.01457100f, -0.11841876f, 0.05364858f, 0.05918917f, -0.08999860f, 0.07064428f, -0.01438861f, 
    -0.02705362f, 0.02035356f, 0.02966738f, -0.04409190f, 0.15119024f, 0.09542748f, 0.06495722f, -0.09661567f, 
    -0.04519372f, -0.01104998f, 0.11049571f, 0.02997960f, 0.01300054f, -0.10108614f, -0.00570476f, -0.20793727f, 
    -0.00894278f, 0.02989539f, 0.15821838f, -0.02332124f, 0.07487585f, -0.00807057f, 0.07158039f, 0.00097919f, 
    0.00216912f, 0.05612779f, 0.03910721f, -0.01005708f, 0.03044041f, -0.18581641f, 0.07923703f, -0.12362181f, 
    0.10213540f, 0.02782453f, 0.03986350f, 0.01951561f, -0.05902803f, -0.04819673f, 0.03343244f, -0.08359378f, 
    0.10085727f, 0.19468755f, 0.04534082f, -0.25116387f, -0.05112737f, -0.16949761f, 0.04624536f, 0.01473454f, 
    0.03886670f, 0.05411142f, 0.04249299f, -0.07616806f, -0.11662038f, 0.02067303f, -0.21986893f, 0.04361111f, 
    -0.00171565f, 0.01987517f, -0.12501177f, -0.04229510f, -0.15115473f, -0.07847886f, 0.00930334f, 0.01348798f, 
    0.00498373f, 0.25221139f, -0.02253354f, 0.00179723f, 0.09693564f, 0.07080586f, 0.02036223f, -0.06033385f, 
    0.05056202f, 0.06857644f, -0.04597859f, 0.02131400f, 0.04932686f, -0.09924891f, -0.16873954f, 0.00665804f, 
    -0.02024106f, 0.00072792f, 0.01190929f, -0.02515240f, -0.05427921f, -0.02795880f, 0.08189519f, 0.01574453f, 
    0.13192634f, -0.02334063f, 0.14345373f, -0.15942232f, 0.10269532f, -0.09634365f, 0.01065471f, -0.04310000f, 
    -0.12654212f, 0.05658033f, 0.02771824f, 0.07599290f, -0.35286966f, 0.14202417f, 0.03220890f, -0.04680140f, 
    -0.07761074f, -0.03548547f, -0.01242843f, 0.04575074f, -0.02168393f, -0.05107233f, 0.09310528f, 0.18058619f, 
    0.12898076f, -0.11970362f, -0.18398960f, 0.07267746f, 0.07663165f, 0.14090200f, -0.00413180f, -0.06897675f, 
    -0.12397981f, -0.08965269f, 0.06319600f, 0.05113248f, -0.27173445f, -0.08366669f, -0.08164565f, 0.23211065f, 
    0.01897150f, 0.03088676f, -0.05972335f, 0.04045767f, 0.12993334f, -0.00643912f, -0.01087951f, -0.06876339f, 
    -0.15155490f, -0.12212364f, -0.06532541f, -0.11663137f, 0.09997378f, 0.08220522f, -0.11350267f, -0.13650776f, 
    0.14566331f, -0.05297207f, 0.09097700f, 0.15834139f, 0.09957409f, 0.01091116f, -0.20988993f, -0.15579818f, 
    -0.08098265f, 0.00862093f, 0.01116849f, 0.00592498f, -0.01631375f, 0.09764723f, 0.03974212f, 0.01140375f, 
    0.29504591f, 0.02546810f, 0.15776606f, 0.12354112f, -0.03501187f, 0.03445594f, -0.07252025f, 0.07481553f, 
    0.06119737f, -0.02452777f, 0.07627140f, 0.14680296f, 0.06240868f, -0.03722557f, -0.17049523f, -0.07313956f, 
    -0.07530522f, 0.01625149f, -0.09544948f, 0.00431674f, -0.05815398f, 0.07318572f, -0.08792350f, -0.28146884f, 
    -0.12146828f, 0.01943615f, 0.24898748f, -0.15583353f, -0.03134211f, -0.03018963f, 0.12358029f, 0.01001724f, 
    -0.13104828f, -0.07761487f, -0.04429862f, -0.06189157f, 0.02692160f, 0.06506381f, 0.04254061f, 0.04605760f, 
    -0.04792482f, 0.15881835f, -0.00283505f, 0.08233771f, 0.06835349f, -0.07602314f, 0.07806034f, -0.02020840f, 
    0.29440585f, -0.37826160f, 0.05329022f, 0.03301529f, 0.00538623f, -0.11579933f, 0.06127047f, -0.00348310f, 
    0.11879259f, -0.14341439f, -0.01123146f, -0.06879414f, 0.25375009f, 0.17405024f, -0.03337710f, -0.01644397f, 
    -0.00184023f, 0.06006567f, -0.14057852f, -0.07138244f, 0.04315850f, -0.07164685f, 0.04133017f, 0.05447044f, 
    0.23850086f, -0.22025040f, -0.05244096f, -0.04067310f, 0.01881182f, 0.03998357f, -0.11764926f, 0.04961934f, 
    0.01444224f, 0.01857099f, 0.04572811f, 0.01250817f, 0.28307155f, -0.50733548f, 0.08715369f, -0.02266766f, 
    -0.09658850f, 0.05670770f, -0.01494819f, 0.01417122f, 0.14122038f, 0.02303156f, -0.05325234f, 0.10688785f, 
    -0.11804504f, -0.00225557f, -0.03391667f, -0.09502156f, 0.00210305f, 0.09196497f, 0.00781631f, 0.05300492f, 
    0.10049874f, 0.08124406f, 0.03678569f, -0.04888783f, -0.06983942f, -0.27142406f, -0.25260603f, -0.01422892f, 
    0.00926733f, 0.02771588f, 0.03001540f, -0.06768393f, 0.06356847f, 0.13383807f, 0.02703805f, 0.04079799f, 
    -0.01366342f, -0.00714763f, -0.00272809f, 0.10849431f, 0.04479005f, 0.12978499f, -0.14330459f, -0.00218562f, 
    0.01460817f, -0.17176059f, 0.04871986f, -0.17193915f, -0.19459569f, -0.04509504f, 0.12579501f, -0.14304762f, 
    -0.00593282f, -0.01593856f, 0.11803634f, -0.06078048f, -0.01033650f, -0.05316625f, -0.02304664f, 0.00353342f, 
    -0.02155827f, 0.03010559f, 0.12698081f, -0.07300735f, 0.11628577f, -0.15655948f, 0.05387077f, 0.06691010f, 
    0.00707851f, 0.04946222f, 0.04188721f, 0.01994400f, 0.00861000f, 0.16163334f, 0.08888298f, 0.05463270f, 
    -0.03178559f, -0.09704123f, -0.01674981f, 0.05074149f, 0.05015354f, 0.04936952f, 0.01444997f, -0.07157901f, 
    0.18202229f, -0.01250107f, 0.17010698f, -0.24530210f, -0.02468276f, 0.00937640f, 0.06765001f, 0.08307649f, 
    -0.13436005f, 0.00614830f, 0.01941274f, 0.02275025f, -0.08200093f, 0.16413569f, -0.10820279f, 0.16182318f, 
    -0.05852118f, 0.11909649f, -0.06425927f, 0.04938699f, 0.00657229f, 0.04409799f, -0.04137718f, -0.10685199f, 
    -0.22054385f, 0.04895547f, -0.24932484f, 0.29859823f, 0.02945754f, -0.03248908f, 0.09453611f, -0.13260521f, 
    -0.05271779f, 0.04398537f, -0.03748611f, -0.13973190f, 0.21643651f, -0.00259415f, 0.04198994f, 0.10089412f, 
    -0.09510201f, 0.00271570f, -0.00007812f, 0.04729011f, -0.03031013f, -0.02366038f, 0.03602837f, -0.06777495f, 
    0.09673459f, 0.13201259f, 0.02441838f, -0.35408083f, -0.03447158f, 0.01422529f, 0.06356936f, 0.08768110f, 
    -0.07396477f, -0.02791764f, -0.02193819f, -0.14156418f, -0.13713244f, -0.11608331f, -0.27950385f, -0.16630484f, 
    -0.00655536f, 0.07475964f, -0.08631884f, -0.02073966f, 0.07098082f, -0.17239410f, 0.05158774f, -0.05189729f, 
    -0.01929308f, -0.02419859f, 0.00446537f, 0.11761670f, 0.11788152f, -0.15884446f, 0.10615268f, -0.01265274f, 
    -0.03883391f, -0.02306680f, -0.19933031f, -0.07201965f, 0.24634108f, 0.05619166f, -0.13473509f, 0.22238673f, 
    -0.03594331f, -0.03376267f, -0.17048790f, -0.06532039f, -0.10282999f, -0.10125460f, 0.04302882f, -0.01001420f, 
    -0.10879126f, -0.08106134f, -0.12462398f, 0.28810763f, 0.03594506f, -0.03024861f, -0.08655729f, -0.03548548f, 
    0.02351678f, -0.03675623f, 0.00840534f, 0.05238397f, -0.46523529f, 0.00385576f, 0.04543381f, 0.10288066f, 
    0.08670507f, 0.07326268f, 0.01289930f, 0.04170929f, -0.06538084f, -0.02332740f, 0.08501105f, -0.05959392f, 
    -0.15744306f, -0.03993882f, -0.02280308f, 0.05726426f, -0.00238066f, 0.08680075f, -0.03501347f, -0.11709623f, 
    -0.10256675f, -0.02552759f, -0.09513050f, -0.24277277f, 0.31269860f, 0.19201949f, 0.12477715f, 0.25953567f, 
    0.06747543f, -0.12892415f, 0.01798607f, 0.12354571f, -0.05095815f, 0.02123430f, -0.08997926f, 0.11297896f, 
    0.17996290f, 0.06408296f, -0.08907111f, -0.05957011f, -0.07157236f, -0.08761945f, -0.03408571f, -0.08942849f, 
    -0.05620136f, -0.00944009f, 0.00559578f, -0.08807704f, 0.22142501f, -0.36217824f, 0.08190456f, 0.04168534f, 
    0.03253134f, 0.05680327f, -0.07096162f, 0.03571568f, -0.04164333f, -0.06023146f, -0.08516831f, -0.00635084f, 
    -0.16418460f, -0.10670307f, 0.03380825f, -0.13678484f, -0.07521986f, 0.02199935f, -0.00827087f, -0.09002794f, 
    -0.04307612f, -0.02242191f, 0.02511575f, -0.05456480f, -0.08777675f, -0.04620374f, 0.13111316f, -0.01853326f, 
    0.03831495f, -0.01079853f, 0.01743725f, -0.13578233f, -0.02412705f, 0.01697925f, 0.02295703f, -0.04119018f, 
    0.29714182f, -0.08233926f, 0.24586242f, -0.03888199f, -0.00389311f, 0.10817347f, -0.01247851f, 0.00741803f, 
    -0.00594620f, 0.06951120f, 0.00959141f, 0.02096269f, 0.08440205f, 0.04162708f, 0.18520607f, 0.13191369f, 
    -0.01248588f, 0.02722415f, -0.03753841f, -0.02153701f, 0.01842460f, 0.04069867f, -0.05056987f, -0.01491779f, 
    -0.14902498f, -0.00258855f, 0.01949093f, -0.11230188f, -0.14930797f, 0.00351674f, 0.00628332f, -0.01363819f, 
    -0.01936532f, 0.01251024f, -0.03300843f, -0.05826995f, -0.10253904f, 0.12003426f, -0.11853795f, 0.06996629f, 
    -0.00782066f, 0.03498487f, -0.14907889f, 0.00845533f, 0.04373568f, -0.05515628f, 0.07847456f, -0.03431529f, 
    0.06892996f, -0.01536543f, -0.07693957f, -0.00462520f, -0.01649507f, -0.06764537f, -0.05659147f, -0.09517013f, 
    -0.03031861f, 0.06620333f, -0.02540611f, 0.04646707f, 0.03953733f, 0.17996906f, 0.06019847f, 0.04620944f, 
    0.12977661f, 0.00087012f, 0.08465239f, 0.00690212f, -0.01248620f, 0.11436575f, 0.05358528f, -0.02329015f, 
    0.23298398f, 0.09458199f, 0.16320547f, 0.01721486f, -0.01901070f, -0.00207063f, -0.04839090f, -0.08518630f, 
    0.02873706f, 0.04326992f, -0.04414767f, 0.04134620f, 0.21344955f, 0.07959833f, 0.07120710f, 0.18878724f, 
    0.06313494f, -0.10530187f, -0.07842974f, 0.01797589f, 0.04263144f, -0.07743456f, -0.03199452f, -0.12118877f, 
    0.05116548f, 0.04205964f, -0.12406081f, 0.03987770f, -0.06127696f, -0.09760029f, -0.05112054f, -0.01036642f, 
    -0.07973693f, 0.02802417f, 0.00591925f, 0.07813391f, 0.03350099f, 0.01141740f, 0.03761132f, 0.17582549f, 
    0.03526318f, -0.07797530f, -0.13511574f, 0.02285145f, 0.01036521f, -0.04491508f, 0.06320813f, -0.02667862f, 
    0.08881296f, 0.08937623f, 0.17789118f, 0.11208611f, 0.06483594f, -0.02397916f, -0.00183250f, -0.04386933f, 
    -0.01516224f, 0.05946789f, -0.06290209f, -0.01962583f, 0.06176257f, 0.11925451f, -0.06367470f, 0.07558873f, 
    0.01318153f, 0.00040246f, -0.04472139f, -0.02435729f, -0.01425604f, 0.03895500f, 0.01817149f, -0.14123395f, 
    -0.26144674f, 0.02917161f, -0.16698839f, -0.07701077f, 0.04211482f, -0.00463845f, -0.06230022f, -0.06444100f, 
    -0.06939338f, 0.04891762f, -0.07916703f, -0.00343478f, -0.08469596f, -0.21420303f, -0.25720137f, -0.03946609f, 
    -0.00109871f, -0.07670097f, -0.03121745f, -0.00090331f, -0.05664332f, -0.05478950f, 0.04917588f, -0.01445423f, 
    -0.20569254f, -0.08195248f, -0.01286514f, 0.03307104f, 0.03935546f, 0.02529617f, -0.06545662f, 0.01760506f, 
    -0.00183849f, -0.03284901f, 0.03312016f, -0.07688735f, -0.19674097f, 0.11101305f, 0.00565685f, -0.03925530f, 
    0.08216619f, 0.01790061f, -0.01307174f, 0.00553688f, -0.10315610f, -0.03839971f, 0.03131596f, -0.04845341f, 
    0.08360474f, -0.19906968f, -0.05463712f, 0.01742060f, 0.01901929f, -0.03821180f, -0.03123603f, -0.00321657f, 
    -0.04276608f, 0.01596344f, -0.01913850f, -0.05040839f, -0.17140742f, 0.02535454f, -0.11770288f, 0.17519417f, 
    -0.03248738f, -0.04776897f, 0.14256316f, -0.00314621f, 0.00900795f, 0.01164654f, -0.06188532f, 0.00032718f, 
    -0.03373286f, -0.02384290f, -0.08259072f, -0.10194244f, -0.02526257f, 0.01312609f, 0.03427125f, -0.03583011f, 
    -0.03772290f, 0.03451717f, -0.04363488f, -0.04496386f, 0.02448141f, 0.17788707f, -0.03268026f, 0.12046580f, 
    0.04210169f, 0.00046085f, -0.04644749f, 0.00627562f, -0.02662375f, 0.02119134f, -0.01997573f, -0.01662655f, 
    0.10137546f, 0.19104649f, 0.06087254f, 0.08694578f, -0.04373950f, -0.02672926f, -0.01479060f, -0.06958048f, 
    0.03127117f, 0.02819862f, -0.04266431f, -0.06294489f, 0.02264332f, -0.28306058f, 0.00862497f, 0.04762096f, 
    -0.01088767f, -0.01317840f, -0.00845788f, 0.00549369f, 0.05124901f, -0.01998436f, -0.03915288f, -0.08264767f, 
    0.17112172f, -0.01870119f, -0.00506688f, 0.10133434f, 0.17513375f, -0.01235047f, 0.02589739f, -0.03388781f, 
    -0.02010680f, 0.04821543f, 0.02000337f, -0.13160263f, 0.27065778f, -0.20173325f, 0.06842083f, -0.03363126f, 
    0.10582822f, 0.02333058f, -0.00632328f, -0.05044859f, 0.03831581f, 0.03949357f, 0.04703331f, -0.10743243f, 
    -0.39109808f, -0.00292673f, -0.06143973f, -0.29132971f, 0.06462190f, 0.02595862f, -0.00211657f, -0.05957429f, 
    -0.03398804f, -0.13347478f, 0.00520176f, 0.02455546f, -0.08085078f, -0.00221344f, 0.02670400f, 0.13172962f, 
    -0.11782548f, -0.10318446f, -0.09690330f, -0.04552523f, -0.06767869f, -0.04861924f, 0.00182943f, -0.05721707f, 
    -0.03376995f, 0.03567224f, -0.02506077f, 0.00439448f, -0.00373640f, -0.01900214f, -0.12977223f, -0.03381890f, 
    -0.03958181f, 0.05808736f, 0.02862226f, -0.03898779f, -0.02267678f, 0.22286716f, 0.03423459f, 0.07108670f, 
    -0.03531509f, -0.00730723f, 0.04390917f, -0.00604926f, 0.02092360f, 0.06036745f, -0.03547266f, -0.04552893f, 
    0.23257172f, -0.01206123f, 0.08880901f, -0.11703072f, -0.06976207f, -0.07070762f, 0.00450715f, -0.07331943f, 
    0.02701661f, 0.03205972f, 0.03716585f, -0.03655549f, -0.12544738f, 0.04255589f, -0.00279987f, -0.15626539f, 
    0.00092992f, -0.00212615f, -0.04669568f, -0.13158901f, 0.00879078f, 0.01263871f, -0.03008957f, -0.02058742f, 
    0.04799450f, 0.15720476f, -0.03022201f, 0.17103431f, 0.04382845f, -0.01901990f, -0.01211508f, -0.02700953f, 
    0.03521566f, -0.01901780f, -0.00369947f, -0.03524775f, 0.00050590f, 0.13048868f, 0.09889837f, 0.00627766f, 
    0.06846931f, 0.03614760f, -0.01889190f, 0.02036493f, 0.00715570f, -0.05406133f, -0.00926728f, -0.09934986f, 
    0.01458238f, 0.13992597f, 0.07890098f, 0.00421839f, -0.05559728f, 0.02824003f, 0.05194003f, 0.03603738f, 
    -0.06550106f, -0.01549212f, -0.06425798f, -0.05092431f, 0.11399812f, 0.19509725f, 0.08922527f, 0.11359677f, 
    0.07931126f, 0.04252377f, 0.01249616f, 0.02266552f, -0.05984531f, -0.00910049f, -0.00205056f, -0.05887846f, 
    0.04099806f, -0.20756677f, -0.14120501f, -0.05495850f, 0.00168046f, -0.03881318f, -0.01578061f, -0.09612598f, 
    -0.01308420f, 0.00315338f, -0.03855934f, -0.05420854f, 0.15744223f, -0.06487419f, 0.16507280f, 0.01081830f, 
    0.03250693f, 0.00106576f, -0.00057514f, -0.04536017f, -0.09127169f, 0.06660335f, -0.01441132f, -0.06090263f, 
    -0.15853566f, -0.00552886f, -0.01424705f, -0.02933948f, -0.05241629f, 0.09924928f, -0.03536770f, -0.06303391f, 
    0.01187228f, 0.08030270f, 0.02971902f, -0.15678716f, -0.25492141f, 0.05599771f, -0.05839371f, 0.02192790f, 
    -0.17561264f, 0.04500081f, -0.02458744f, -0.05261620f, 0.01923732f, -0.03958353f, 0.01219539f, -0.00579712f, 
    -0.06875899f, -0.09898175f, -0.02478687f, -0.13351704f, 0.06192197f, -0.05113484f, -0.01539297f, -0.00535035f, 
    0.01165964f, 0.00910949f, -0.15640849f, 0.02059439f, 0.00595192f, -0.16894773f, -0.21481234f, -0.02895942f, 
    -0.04734461f, -0.05013800f, 0.00284806f, -0.03078970f, -0.09490124f, -0.11791504f, -0.03123361f, 0.02462166f, 
    -0.27520260f, 0.06038125f, 0.13576531f, -0.02670755f, 0.02443544f, -0.03280858f, -0.04472197f, 0.02974951f, 
    -0.03733290f, 0.03962081f, 0.05290134f, 0.02335348f, 0.11779162f, -0.05514899f, -0.01972000f, -0.09441161f, 
    -0.01969612f, 0.03546923f, 0.02591327f, -0.05178370f, -0.03851224f, 0.03882271f, -0.13638280f, -0.09555499f, 
    0.02399824f, 0.20028973f, 0.03375118f, 0.00522113f, -0.13914341f, 0.01088426f, -0.02165114f, -0.05165219f, 
    -0.10973226f, 0.00700978f, -0.00804536f, 0.00537108f, 0.18093377f, 0.17933941f, -0.05265227f, 0.16372758f, 
    0.05913066f, -0.01775246f, 0.03225799f, 0.03696808f, 0.12483785f, -0.00477193f, -0.00395350f, -0.06196935f, 
    0.28715134f, -0.21140489f, 0.05927948f, 0.15033628f, -0.03516022f, -0.00531494f, -0.08182531f, 0.01497352f, 
    -0.05132028f, -0.08971188f, 0.02381231f, -0.03567407f, 0.04529689f, 0.09341990f, 0.14960043f, 0.00759862f, 
    0.03920607f, -0.01457552f, 0.06449612f, -0.11152843f, -0.07997719f, 0.05745114f, 0.06205549f, -0.06142543f, 
    0.14592694f, -0.36006710f, 0.08555155f, 0.02615105f, 0.04873984f, -0.03394049f, 0.02849007f, -0.03732361f, 
    -0.05703979f, -0.02993229f, -0.01103527f, 0.02360426f, -0.16859969f, -0.01355233f, -0.02529655f, -0.20282722f, 
    -0.03667177f, 0.00497998f, 0.02279480f, -0.03202644f, -0.00280449f, 0.02947702f, -0.05991454f, -0.07062662f, 
    0.11736646f, 0.02889813f, -0.09987584f, -0.09617819f, -0.03416603f, 0.02152484f, -0.00662361f, -0.05734165f, 
    -0.04095352f, -0.07774526f, 0.01205843f, -0.06900004f, -0.33163708f, -0.02100143f, -0.09799594f, -0.15683661f, 
    -0.02995525f, -0.01537764f, -0.12802334f, -0.04340988f, -0.10642251f, 0.10082787f, 0.03818142f, -0.03239957f, 
    0.04009685f, 0.08024710f, -0.13477312f, 0.20681266f, -0.00999959f, -0.05667624f, 0.02431796f, 0.03057678f, 
    -0.04334919f, -0.03143492f, -0.04296489f, -0.00840414f, -0.02664733f, -0.09414491f, -0.05187742f, -0.08162691f, 
    -0.03820008f, -0.09107529f, 0.04457864f, -0.00132037f, 0.01545658f, -0.00514143f, 0.03223705f, -0.02736054f, 
    -0.11382934f, -0.24317761f, -0.19239141f, -0.07053710f, -0.04006547f, -0.00531307f, 0.00053616f, -0.05951815f, 
    -0.04628441f, -0.00902652f, 0.01160828f, 0.01240091f, -0.13106263f, 0.10794223f, -0.00810433f, 0.14658917f, 
    -0.01407881f, -0.13247941f, -0.08090673f, -0.06968894f, -0.08139287f, -0.00289131f, 0.02033181f, -0.03459304f, 
    0.22178942f, -0.25833863f, 0.12673149f, 0.06069625f, 0.11865237f, -0.03816744f, -0.03795367f, -0.05365260f, 
    -0.02626980f, -0.05534977f, -0.03869133f, 0.02124042f, -0.02228647f, 0.12807934f, 0.00755487f, 0.13534153f, 
    0.09656222f, -0.04903330f, -0.05525681f, 0.01931831f, -0.00519339f, -0.05216569f, -0.05192802f, 0.03529608f, 
    0.02404323f, 0.08267726f, -0.05029174f, 0.09398600f, 0.08309696f, -0.03344879f, 0.00976748f, 0.04289613f, 
    0.03971693f, 0.07599463f, -0.01446155f, -0.06511591f, -0.14787292f, 0.00495662f, -0.06059470f, -0.00179810f, 
    -0.10901065f, -0.00927868f, -0.04427974f, 0.00745050f, 0.06145852f, 0.04367175f, 0.05640292f, 0.00733967f, 
    0.13444735f, 0.15752862f, 0.00076847f, -0.03016775f, -0.12932420f, 0.05878522f, 0.00986142f, 0.00200012f, 
    0.05300188f, -0.06573703f, 0.05925614f, -0.02144870f, 0.11967994f, -0.13461968f, -0.08675901f, 0.02242275f, 
    -0.12643558f, -0.10067823f, 0.01686086f, 0.00661111f, -0.22548774f, -0.04882414f, -0.07718439f, 0.01982665f, 
    0.01918260f, -0.11640683f, 0.02718962f, 0.06151195f, 0.10208749f, -0.07462159f, 0.00771248f, -0.07803261f, 
    -0.05268543f, -0.04804516f, 0.06391864f, 0.04219959f, 0.19594513f, 0.09688631f, -0.27224383f, 0.11480413f, 
    -0.00983147f, 0.00259840f, -0.02252082f, -0.09416211f, -0.05845425f, 0.04530998f, 0.03890609f, 0.06670691f, 
    0.10623255f, -0.01774670f, 0.07045821f, 0.12233009f, -0.08238330f, 0.00319249f, -0.02340730f, -0.07616290f, 
    0.00681960f, 0.04341557f, 0.02471358f, 0.07160424f, 0.02426950f, -0.17423007f, 0.17508337f, 0.04102222f, 
    -0.06453114f, -0.08290336f, -0.09075539f, 0.05343082f, 0.03493646f, -0.00044119f, -0.12648752f, -0.20630011f, 
    -0.19297981f, -0.11493625f, 0.09020082f, -0.36048171f, 0.07731900f, -0.00624937f, -0.03823674f, 0.07173812f, 
    0.01607908f, -0.09238993f, -0.22003138f, 0.09183136f, -0.26977661f, -0.10081849f, 0.08012877f, -0.05976681f, 
    -0.06890982f, -0.08770552f, -0.09198111f, 0.03250448f, 0.08519515f, -0.07823547f, -0.08557685f, 0.02417102f, 
    -0.02344633f, -0.23551640f, -0.05567513f, 0.06962866f, 0.05816893f, -0.06562683f, -0.04498531f, -0.03292847f, 
    0.05395827f, -0.05951863f, 0.06809694f, -0.11572921f, -0.21037632f, 0.04191458f, -0.03758221f, -0.01165261f, 
    0.03574653f, -0.04260632f, -0.04492162f, -0.01295090f, 0.05275163f, 0.09106600f, -0.11759961f, 0.03583080f, 
    -0.07605235f, -0.09830845f, -0.03992043f, -0.07135875f, -0.03393691f, -0.06705666f, 0.12663339f, 0.04176073f, 
    0.07284471f, -0.01289762f, -0.10229670f, -0.13576023f, -0.04359680f, 0.17414175f, -0.07216462f, 0.09621500f, 
    -0.08180399f, 0.05433809f, -0.12118879f, -0.04565591f, -0.06045053f, -0.08702490f, 0.06053593f, -0.06631916f, 
    0.00584598f, 0.16361398f, 0.18348207f, 0.07232830f, -0.02960683f, 0.01759925f, -0.13892099f, -0.02060360f, 
    -0.03940208f, -0.04292211f, 0.05783841f, 0.05177107f, 0.11577338f, 0.04357466f, -0.12484586f, -0.25114956f, 
    -0.04765864f, -0.17300563f, -0.02294252f, -0.03720748f, -0.02680317f, 0.06270934f, 0.11028473f, 0.07472958f, 
    -0.22106986f, -0.18469524f, 0.02699803f, -0.04612771f, 0.04579132f, 0.01549423f, -0.00285998f, 0.05130627f, 
    0.10192667f, -0.00421638f, 0.09446947f, -0.08095289f, 0.17929058f, 0.02863403f, -0.20928858f, -0.14748259f, 
    0.06805310f, -0.15568291f, -0.09712546f, 0.01792609f, 0.06272728f, 0.00440430f, 0.02862878f, 0.04327159f, 
    -0.22095555f, 0.04932468f, 0.15589800f, 0.22618644f, -0.07040805f, 0.02093768f, -0.13705347f, -0.02244586f, 
    0.00827261f, -0.04982781f, 0.06084302f, -0.01128451f, -0.08727617f, 0.23808710f, -0.00550730f, 0.07692374f, 
    -0.12491999f, -0.05100701f, -0.09901027f, 0.05061370f, 0.05047720f, -0.12176221f, -0.01957401f, -0.00923620f, 
    0.11644414f, 0.06385601f, 0.06304614f, 0.08935463f, 0.11470283f, 0.09993112f, -0.00007614f, -0.04632675f, 
    0.04998395f, -0.09916531f, -0.05096416f, 0.00396725f, -0.09367827f, -0.02856797f, -0.17291085f, 0.00845892f, 
    0.05025427f, 0.08053402f, 0.05015197f, -0.03764983f, 0.01703434f, 0.02549960f, 0.10984763f, -0.01439054f, 
    0.01764438f, 0.05064145f, -0.28443027f, 0.03385376f, 0.08000895f, -0.00853693f, -0.19320635f, -0.09272362f, 
    0.00779998f, 0.05048686f, 0.04035764f, 0.05286285f, 0.00129472f, -0.07180873f, 0.01088122f, 0.09730715f, 
    0.08406535f, 0.02452083f, -0.05715516f, -0.09484853f, -0.07878936f, 0.09370507f, 0.06669242f, 0.09854080f, 
    0.16961284f, -0.18262160f, -0.14451334f, -0.02496815f, 0.03853942f, -0.07306951f, 0.03391618f, -0.05353669f, 
    0.01652153f, 0.01975655f, 0.07255144f, 0.11782899f, 0.06632503f, -0.06840477f, -0.17716292f, 0.03471163f, 
    -0.07924890f, 0.05138416f, -0.07001587f, -0.03960376f, -0.04354747f, -0.04732603f, 0.09739754f, 0.03314630f, 
    0.09134029f, 0.00632934f, 0.13668725f, 0.10017520f, -0.03641904f, -0.01886199f, -0.08241831f, -0.02722271f, 
    -0.01900800f, -0.00962349f, -0.02084100f, -0.00664437f, -0.17672384f, 0.11795902f, -0.08463696f, -0.05540740f, 
    -0.05813692f, 0.07673448f, -0.02941495f, 0.06176221f, 0.04480073f, 0.01421135f, 0.04304064f, 0.00356260f, 
    -0.05622531f, 0.14332114f, -0.17739162f, -0.19047835f, 0.05838853f, -0.00163247f, -0.08667640f, 0.03031582f, 
    0.05433235f, -0.00051122f, -0.14391597f, -0.12352618f, 0.07670765f, -0.08576278f, 0.02543738f, 0.07456598f, 
    0.01916119f, -0.08259746f, -0.09688944f, 0.01988963f, -0.03614762f, 0.04916916f, 0.03240346f, -0.02840408f, 
    0.01359478f, -0.25808606f, 0.15756030f, -0.16884990f, 0.00669231f, -0.08278053f, -0.02219857f, 0.06035392f, 
    0.06337873f, -0.00161571f, -0.02182894f, -0.00961291f, 0.14513013f, -0.16641073f, 0.09346775f, -0.08972262f, 
    0.05675067f, 0.00243141f, -0.00345958f, 0.03184205f, 0.05286618f, -0.02227645f, -0.06570847f, 0.05872014f, 
    -0.05465419f, -0.15146627f, 0.05324347f, 0.09143814f, 0.04326142f, 0.01472138f, -0.07851238f, -0.01153014f, 
    -0.02400236f, -0.02455272f, 0.12824365f, 0.07608572f, 0.01006289f, 0.11182859f, -0.30169800f, -0.20156270f, 
    0.04530613f, -0.11517360f, 0.01300527f, -0.04324459f, -0.00118472f, -0.04178823f, -0.03437446f, 0.10410266f, 
    -0.18497279f, -0.25002098f, -0.06337757f, -0.08026281f, 0.05030734f, -0.06056807f, -0.05337020f, -0.03642932f, 
    0.03271943f, 0.01432847f, -0.00259195f, -0.00708269f, 0.15437995f, 0.15300578f, 0.01994609f, -0.00120319f, 
    -0.08186760f, 0.01824932f, -0.11551752f, 0.00347351f, 0.00195001f, -0.07372408f, 0.00347096f, -0.05492910f, 
    0.08739520f, -0.08224519f, -0.10900030f, -0.05675872f, 0.01542750f, -0.04941560f, -0.00914864f, 0.03519238f, 
    -0.05936757f, 0.10574075f, -0.11203451f, 0.04227402f, 0.17005378f, 0.00803052f, 0.07206606f, 0.09103906f, 
    0.05085310f, -0.09871165f, -0.03493003f, -0.09800034f, -0.04011064f, 0.04754773f, -0.05457060f, -0.09407772f, 
    0.10415243f, 0.04465657f, 0.04034461f, -0.23508045f, -0.12569527f, -0.20107572f, 0.10100763f, -0.04032808f, 
    -0.01162180f, 0.07581812f, -0.07103101f, 0.05438097f, -0.06695142f, 0.27510244f, -0.10341271f, -0.09843162f, 
    0.00698441f, -0.01696223f, -0.00354307f, -0.05569020f, 0.04056095f, -0.05499831f, -0.06611529f, 0.06572883f, 
    -0.07985338f, 0.11044636f, -0.00040341f, 0.03910321f, -0.03405989f, -0.03945221f, -0.05461857f, 0.01628981f, 
    -0.06572184f, 0.04561875f, -0.15219855f, -0.11573245f, -0.11636615f, 0.00765771f, 0.08611883f, -0.15383005f, 
    -0.06611495f, -0.08559041f, -0.00032266f, -0.12507865f, -0.04438437f, -0.02820807f, 0.09204736f, -0.02525236f, 
    0.17699340f, 0.00922800f, -0.10824087f, 0.10040531f, 0.07827896f, -0.04291116f, -0.03351833f, -0.05289877f, 
    0.00612835f, 0.01946531f, -0.00058474f, -0.03033437f, -0.10043543f, -0.13152502f, -0.10657795f, -0.23974763f, 
    -0.07495766f, 0.03868674f, 0.04324401f, -0.26388595f, 0.02694027f, -0.02026232f, -0.04406973f, 0.10067897f, 
    0.04539029f, 0.02719931f, 0.06694123f, 0.14669406f, -0.04451790f, 0.07199617f, -0.01285100f, 0.00632276f, 
    0.19790579f, -0.09789791f, -0.04546761f, -0.05067161f, 0.17422238f, -0.07182734f, 0.00622201f, 0.00888040f, 
    -0.00970505f, -0.05119121f, -0.03141201f, -0.00266507f, -0.10226633f, -0.05154539f, 0.01944441f, 0.07711970f, 
    0.14288409f, 0.07771737f, -0.02311039f, 0.10719449f, -0.05641533f, 0.01404634f, 0.01461784f, 0.04970477f, 
    -0.02903249f, -0.01728781f, -0.06820561f, -0.00940343f, -0.03298100f, -0.04387000f, -0.25561598f, 0.02389486f, 
    0.08752848f, -0.01951655f, -0.05237491f, 0.01019120f, 0.08348219f, 0.04807772f, 0.13723516f, 0.06657391f, 
    0.06145024f, -0.05046444f, 0.03615755f, 0.05296439f, -0.04362016f, 0.00281477f, 0.01419186f, 0.02257437f, 
    0.00915088f, -0.08237799f, -0.21520269f, 0.05570608f, 0.20479998f, 0.00905468f, 0.00102024f, 0.10166058f, 
    0.02215491f, -0.04884611f, -0.00607836f, 0.01535902f, -0.02549790f, -0.08077389f, 0.05156152f, -0.09919814f, 
    0.09632772f, -0.16602547f, 0.12367068f, 0.15360257f, -0.01758448f, -0.09338950f, 0.00148119f, -0.04743532f, 
    0.08499045f, -0.04685128f, 0.07095134f, 0.00162282f, -0.14079712f, 0.29669887f, -0.01182484f, 0.08411966f, 
    -0.01350313f, 0.14417008f, -0.25617066f, -0.08162148f, -0.02464269f, -0.08398909f, -0.03232893f, -0.11603654f, 
    0.12271352f, -0.08611669f, 0.04987578f, -0.21424808f, 0.13037984f, -0.00469615f, -0.09735529f, 0.05133065f, 
    -0.01622223f, 0.13904607f, 0.04748944f, 0.10989017f, -0.19725640f, -0.09950808f, 0.15165742f, -0.12337318f, 
    -0.05513851f, -0.01400901f, -0.13561870f, 0.02108142f, -0.03237289f, -0.08590102f, 0.04037552f, 0.00810497f, 
    0.11548038f, -0.30258590f, -0.19129677f, -0.01212585f, 0.06396657f, -0.01663456f, 0.03156349f, -0.03074033f, 
    0.00784900f, 0.00981069f, -0.03912159f, 0.05406483f, 0.13373733f, 0.00002033f, -0.00170908f, 0.05306146f, 
    0.09444834f, -0.06386639f, -0.07330476f, -0.06499448f, -0.05569617f, -0.10241399f, 0.05208017f, 0.04215746f, 
    0.05939370f, 0.00184448f, 0.15703325f, 0.18259683f, 0.03728066f, -0.07280088f, -0.05289931f, -0.04434713f, 
    -0.06646028f, -0.00653941f, 0.12826574f, -0.08101916f, 0.09374983f, 0.09602643f, -0.02071619f, -0.02875572f, 
    -0.04934993f, 0.02856060f, -0.03030159f, 0.04135073f, 0.04614750f, 0.05314941f, 0.01023247f, 0.12634139f, 
    0.16419020f, 0.05932357f, -0.09272767f, -0.12603843f, 0.00043418f, 0.02876502f, -0.11118446f, -0.04407205f, 
    0.00729072f, 0.05115974f, -0.01288030f, 0.01925615f, 0.03060137f, -0.04035553f, 0.00602403f, 0.01948273f, 
    -0.09562037f, -0.08408961f, -0.00774212f, 0.08127611f, 0.03042096f, 0.02433006f, -0.02614841f, 0.05613547f, 
    -0.03227479f, -0.10141841f, -0.07424824f, 0.20214500f, 0.09580563f, 0.03230337f, 0.03858494f, -0.02637826f, 
    0.01308234f, 0.07027332f, 0.07894014f, 0.06936280f, -0.09037444f, 0.15325111f, -0.20980245f, -0.28422722f, 
    -0.13552655f, 0.01896840f, -0.06499683f, 0.05602529f, 0.08260898f, -0.00730962f, 0.03274199f, 0.03213474f, 
    0.04585878f, 0.07655792f, -0.14517289f, -0.08322979f, -0.09493516f, 0.04578621f, -0.03699816f, -0.05349698f, 
    -0.04355665f, 0.02207610f, 0.08739975f, 0.02758549f, -0.04870206f, 0.26651368f, -0.03240041f, -0.19547883f, 
    -0.03267966f, -0.06219232f, -0.09642782f, 0.04861847f, 0.07499824f, 0.01358125f, 0.01142187f, 0.04840334f, 
    -0.08173227f, 0.17473474f, -0.27589598f, -0.08249072f, 0.12095628f, -0.03104583f, -0.13448264f, 0.00757791f, 
    0.05318513f, -0.04917393f, 0.00762860f, 0.04534965f, 0.03976380f, 0.19171782f, -0.18982123f, 0.14736955f, 
    -0.05978285f, 0.06879013f, -0.03849057f, 0.00556476f, 0.02972904f, 0.08374842f, 0.03655168f, 0.02525585f, 
    0.12746631f, 0.08693859f, -0.14602913f, 0.05115415f, -0.00146123f, 0.03688784f, 0.08922389f, -0.16419777f, 
    -0.01572916f, 0.04328915f, 0.07249404f, 0.03840373f, -0.15386282f, -0.05485781f, -0.22303253f, -0.32060751f, 
    0.05429583f, 0.02973424f, -0.16671956f, -0.28583682f, 0.04209781f, 0.00448580f, 0.07236814f, -0.08949450f, 
    -0.05166822f, 0.04640949f, -0.14561389f, -0.10674138f, 0.01698996f, -0.08026175f, -0.07661414f, 0.06652705f, 
    -0.06903260f, 0.06969913f, -0.07561165f, -0.03039070f, 0.37072569f, -0.33496681f, 0.15116097f, -0.04860572f, 
    0.04335676f, -0.02178723f, -0.05034253f, 0.03629390f, 0.00825403f, 0.04143518f, -0.07362697f, 0.05063413f, 
    0.25204593f, 0.26571929f, -0.40055999f, -0.08036406f, 0.11761641f, 0.00053536f, -0.08404510f, 0.09231616f, 
    0.00150542f, 0.02102331f, -0.15721703f, 0.01150140f, 0.15090318f, 0.08931340f, -0.03211528f, 0.12420569f, 
    0.06044899f, -0.03983863f, 0.00042576f, -0.06809618f, 0.14665510f, 0.00511094f, 0.05228405f, 0.21158826f, 
    0.29330015f, -0.08672341f, -0.18296717f, 0.06580485f, 0.00802792f, -0.04786076f, -0.02778452f, -0.01618798f, 
    -0.09646905f, 0.08149812f, 0.06188567f, 0.05359649f, -0.14779995f, -0.18125460f, -0.10318674f, -0.12458915f, 
    -0.02286565f, 0.12981388f, -0.01272461f, -0.11415337f, -0.06973193f, 0.00868736f, -0.09142529f, 0.01958177f, 
    -0.21793808f, 0.00912939f, -0.00867265f, -0.11903988f, 0.10284288f, 0.04252793f, 0.01687811f, -0.02008776f, 
    -0.00646315f, 0.00838755f, -0.06292989f, 0.01455950f, -0.25197148f, 0.23739107f, 0.11748557f, 0.08330429f, 
    0.06631786f, 0.21066034f, -0.03217143f, 0.03442273f, -0.03166954f, 0.02920604f, -0.01576521f, 0.01307290f, 
    0.14332691f, 0.05569080f, -0.08381773f, -0.03430981f, -0.12184445f, 0.14232068f, -0.11367302f, -0.08960649f, 
    0.00515256f, -0.03754032f, -0.02130129f, -0.00452669f, -0.09005236f, -0.26398334f, 0.20764129f, -0.18795152f, 
    0.05109451f, 0.06549530f, 0.05927848f, 0.04199475f, 0.02805381f, -0.01220668f, 0.02233250f, 0.05907470f, 
    -0.00513121f, -0.42159307f, -0.04836204f, 0.07662890f, -0.04065257f, -0.05694257f, -0.01004488f, 0.10173973f, 
    -0.12217411f, 0.14830080f, -0.10837992f, -0.02424356f, -0.00941142f, -0.08929890f, 0.03586274f, -0.11530998f, 
    0.04463696f, 0.00517771f, 0.01003373f, -0.04890104f, 0.01076260f, -0.09860536f, -0.07184587f, -0.10850316f, 
    -0.10481254f, -0.11392426f, -0.00059795f, -0.09416081f, -0.07844192f, -0.02259607f, 0.00502764f, -0.07979413f, 
    0.00428465f, 0.00072655f, 0.02108950f, -0.12261769f, 0.12943920f, -0.15923359f, -0.01543357f, -0.32660839f, 
    -0.18116082f, 0.03750501f, -0.07922588f, 0.07460290f, 0.00564416f, -0.12821032f, 0.17912881f, -0.11735635f, 
    0.17716974f, -0.64456642f, 0.19697946f, -0.11038005f, -0.08871775f, 0.00961462f, 0.04149136f, 0.05997267f, 
    0.03897606f, 0.06389745f, -0.09982803f, 0.04986441f, -0.09450094f, 0.13163875f, 0.13774835f, 0.03297945f, 
    0.09101299f, 0.01515480f, 0.01121744f, 0.07906893f, -0.11563221f, 0.02998462f, 0.06438489f, 0.04332451f, 
    -0.08098541f, 0.25030753f, 0.00080397f, -0.33671090f, 0.10663629f, 0.05702078f, -0.09226225f, 0.01391343f, 
    -0.07174396f, 0.02171102f, 0.07816908f, -0.06234945f, 0.08230490f, -0.11512291f, 0.09273353f, 0.02011750f, 
    0.02795096f, 0.16122228f, -0.09231207f, -0.09166423f, -0.25563166f, 0.00538122f, -0.09213907f, 0.02616829f, 
    -0.11479516f, -0.03677482f, 0.15057667f, 0.07910794f, 0.08397567f, 0.01334430f, 0.06056261f, -0.03215376f, 
    -0.01074743f, 0.04373946f, -0.16471857f, -0.06306770f, -0.19582240f, 0.22235367f, -0.17278799f, -0.04158197f, 
    0.08561058f, -0.05369068f, 0.03086565f, 0.00973289f, -0.03819685f, -0.09845831f, 0.00824969f, -0.07335575f, 
    -0.07792276f, 0.03478186f, 0.12049396f, -0.07772620f, 0.01145589f, 0.01083985f, -0.10511810f, -0.05844438f, 
    -0.00553212f, -0.04730028f, 0.00866321f, -0.15490706f, -0.29638994f, 0.12461627f, 0.09820262f, 0.06512677f, 
    -0.06749867f, -0.01345479f, -0.01615256f, 0.03067529f, 0.07484736f, -0.04794148f, 0.03400324f, -0.06313674f, 
    0.03315388f, 0.13599788f, -0.03437455f, -0.20787390f, 0.22102225f, 0.10234614f, -0.02439809f, 0.03490967f, 
    0.05873714f, -0.15798870f, 0.09932578f, -0.03474383f, 0.18227077f, -0.15881357f, 0.04648328f, -0.19869047f, 
    -0.06660198f, 0.04406163f, 0.04251334f, -0.00282229f, -0.14938627f, -0.01404065f, -0.05723390f, -0.00946552f, 
    0.02594130f, 0.05441469f, -0.04986089f, 0.15978254f, -0.06412371f, -0.04274769f, -0.04406818f, 0.02928106f, 
    -0.12770383f, 0.12085334f, 0.09137079f, 0.07467015f, 0.10571063f, -0.12048328f, 0.03740693f, -0.21358173f, 
    -0.02051757f, 0.08929753f, 0.02615045f, 0.05985798f, 0.04040372f, -0.06847288f, -0.01716045f, 0.05181680f, 
    -0.07309322f, -0.04761930f, -0.08473305f, 0.19062845f, -0.04341708f, 0.15027471f, -0.04190920f, -0.04142430f, 
    0.06490703f, 0.02195523f, 0.06420304f, -0.02799478f, 0.15672745f, 0.06100237f, 0.12429028f, 0.17442115f, 
    -0.09807541f, 0.09735933f, -0.01213525f, 0.03025104f, 0.01042325f, -0.07648909f, -0.01784660f, 0.04572525f, 
    -0.00281118f, -0.07975931f, 0.19761594f, -0.08256070f, -0.11151843f, -0.03207895f, -0.00477610f, -0.04592613f, 
    0.04819010f, 0.01740644f, 0.06411645f, -0.06975251f, -0.08365368f, 0.04736065f, 0.19301169f, 0.02628157f, 
    0.08966240f, 0.00766806f, 0.03644526f, -0.02757716f, 0.11516804f, -0.04913211f, 0.09996442f, 0.02647055f, 
    -0.24214314f, 0.00497907f, 0.05113877f, -0.27937052f, -0.04873115f, -0.09882886f, 0.00658860f, 0.03009550f, 
    0.00379780f, 0.00514701f, 0.02308603f, -0.03241907f, -0.07084221f, 0.02281736f, -0.07126623f, 0.02599307f, 
    0.19183432f, 0.02671959f, -0.00446265f, 0.02574942f, 0.01885587f, -0.01152090f, -0.00051738f, 0.02967740f, 
    -0.33369732f, -0.01141868f, -0.14441636f, 0.14138038f, 0.11370953f, -0.00765973f, 0.08019060f, 0.00184084f, 
    -0.01559929f, -0.09099829f, 0.09574581f, 0.10584003f, -0.19671775f, 0.22192360f, -0.11961425f, -0.05455518f, 
    -0.00356119f, 0.09893250f, -0.02925148f, -0.03659600f, 0.02998160f, 0.05438134f, 0.02100793f, 0.01596207f, 
    0.33721325f, 0.20923737f, 0.07678477f, -0.01931613f, -0.03154262f, 0.01129666f, -0.03126995f, 0.07290541f, 
    0.08128303f, -0.09992690f, 0.07608418f, 0.09997965f, 0.04796209f, 0.03359485f, 0.03133156f, 0.16378425f, 
    -0.03255568f, -0.05288668f, 0.01198350f, 0.00303536f, -0.08201930f, -0.07143062f, 0.06104335f, 0.04024717f, 
    -0.01797131f, -0.09555086f, -0.01499738f, -0.05713814f, 0.04089812f, -0.05216198f, 0.08167630f, 0.10599072f, 
    0.02360394f, 0.06183119f, -0.01451883f, -0.04212897f, -0.18190296f, -0.21266091f, -0.04809897f, 0.01478800f, 
    0.04973320f, 0.04340160f, -0.02401044f, 0.01542674f, -0.01516219f, -0.00144939f, -0.10046124f, -0.05773279f, 
    -0.18939474f, 0.06888618f, -0.08069932f, -0.16598773f, 0.01119682f, 0.04099933f, 0.04529315f, -0.17655309f, 
    -0.19411890f, -0.02533222f, -0.06269056f, 0.00854179f, 0.08328272f, -0.12403546f, -0.09294926f, 0.16669729f, 
    0.02394673f, 0.07024092f, -0.03858298f, -0.02043144f, -0.02017636f, -0.04377477f, 0.04943732f, -0.05261093f, 
    0.07349727f, 0.15282746f, -0.07789037f, -0.03446934f, 0.00280493f, 0.01699249f, -0.06204771f, -0.09483756f, 
    -0.00634415f, 0.09276748f, 0.00629681f, -0.03088091f, -0.23569861f, 0.19093446f, 0.01117374f, 0.08986662f, 
    0.08264805f, 0.02373930f, -0.07553726f, -0.05198259f, 0.03135422f, 0.02461600f, 0.07991084f, -0.08469055f, 
    -0.20641650f, 0.12396810f, -0.22463372f, -0.09145369f, 0.02652103f, 0.05174084f, -0.07043011f, -0.17158246f, 
    -0.03448160f, 0.00145026f, 0.05204070f, -0.05938950f, -0.42186752f, 0.12788038f, -0.03557131f, -0.33812186f, 
    -0.05731894f, -0.00863111f, 0.07859756f, -0.03555859f, 0.04124397f, 0.04617159f, 0.07553887f, -0.09111669f, 
    -0.27901545f, 0.06765194f, -0.20519443f, 0.21656165f, 0.14839183f, -0.01311227f, -0.00837901f, -0.06884819f, 
    -0.02074200f, 0.05363697f, 0.04925055f, -0.06981023f, -0.01778751f, -0.03547612f, -0.14360151f, -0.09348214f, 
    0.06044430f, 0.00686169f, 0.07931905f, -0.14258985f, -0.05828997f, 0.09107228f, 0.04935962f, 0.05488670f, 
    -0.53320450f, 0.24676931f, -0.06255667f, -0.13298170f, 0.11401214f, -0.01338713f, 0.02399117f, 0.02110696f, 
    -0.06591876f, 0.06988790f, 0.03186124f, 0.07025759f, -0.39844713f, 0.06028663f, 0.23816001f, 0.06841829f, 
    -0.02821792f, -0.09590662f, 0.01799930f, 0.20137869f, 0.12564674f, 0.08028371f, 0.02271027f, 0.00248880f, 
    0.10712618f, -0.40577611f, 0.05691228f, 0.11327977f, -0.11322617f, -0.00130989f, 0.02394631f, -0.08059247f, 
    0.03485654f, -0.00771679f, 0.05469503f, -0.04036113f, -0.02843098f, -0.22681294f, 0.12032025f, 0.21123226f, 
    -0.06676217f, -0.04695351f, -0.03156315f, -0.08456910f, -0.04439643f, 0.09482167f, -0.10822169f, 0.13554265f, 
    0.10044134f, -0.09984810f, 0.11827224f, -0.11540023f, 0.00764669f, -0.00080379f, -0.17343897f, -0.02969158f, 
    0.01886800f, 0.01714889f, 0.06585379f, -0.00645017f, -0.11181315f, 0.06709018f, 0.13541761f, -0.07476136f, 
    0.09525867f, 0.06668919f, -0.01052310f, 0.02680633f, 0.15851176f, -0.01104487f, -0.05213556f, -0.07547173f, 
    0.11011020f, -0.05119141f, -0.10306536f, 0.02218567f, 0.09170058f, -0.09679178f, 0.05357048f, -0.13734144f, 
    -0.01294188f, -0.12953267f, 0.02125796f, 0.08516741f, 0.15432929f, 0.03493395f, 0.13175136f, -0.11866708f, 
    -0.01727736f, 0.08139812f, 0.07463679f, -0.02451084f, -0.05058330f, -0.11092696f, -0.13366833f, -0.09739336f, 
    0.42894921f, -0.00177980f, 0.13424578f, -0.21494789f, -0.02911231f, -0.03572066f, 0.03789405f, 0.04634473f, 
    0.03789844f, 0.02346035f, -0.03077183f, 0.11876311f, -0.07016562f, -0.05830562f, -0.02092816f, -0.04291537f, 
    0.03166364f, 0.01394367f, 0.06629650f, -0.05955975f, -0.02143351f, 0.04863594f, 0.00730365f, 0.14041622f, 
    -0.05909675f, 0.07449557f, -0.17713068f, -0.38140196f, 0.07547748f, 0.02507329f, -0.06306149f, 0.01635994f, 
    -0.00712392f, -0.14855315f, -0.16349369f, -0.06242699f, -0.06806393f, -0.10390136f, 0.05118533f, -0.07129697f, 
    -0.01952155f, 0.16708791f, 0.05235833f, -0.01504098f, -0.08446269f, -0.02405383f, 0.11510430f, 0.09791243f, 
    0.41332427f, -0.55104131f, 0.18613333f, 0.03908814f, 0.03663912f, 0.09019304f, 0.00719378f, 0.02737251f, 
    -0.14218339f, -0.04161915f, 0.04355700f, 0.01295459f, -0.23454502f, -0.13166857f, 0.34549701f, -0.06068768f, 
    -0.05578701f, -0.01387649f, 0.02426716f, 0.01362685f, 0.00820011f, -0.17427026f, -0.05307480f, -0.02876598f, 
    -0.08011226f, 0.02022153f, 0.34276736f, -0.05260766f, -0.04891071f, -0.08733491f, -0.08919502f, 0.05553740f, 
    0.08926997f, -0.02499171f, 0.05773710f, 0.04024572f, -0.21479784f, 0.10737539f, 0.16848105f, 0.21431133f, 
    0.08007479f, -0.07863592f, 0.00732126f, 0.00120611f, 0.04464538f, 0.12070324f, -0.06944761f, 0.10109875f, 
    -0.12285304f, 0.03999132f, 0.10791202f, 0.07633530f, -0.02333156f, 0.03969264f, -0.00624808f, -0.02506367f, 
    0.01113793f, -0.07557923f, 0.00454291f, -0.00192603f, 0.01829052f, -0.18292916f, 0.04121541f, -0.21368447f, 
    0.03464218f, -0.05466115f, 0.05611454f, 0.00871366f, 0.05223485f, -0.12935401f, -0.00679798f, 0.10279683f, 
    -0.07122574f, -0.00296345f, 0.11962095f, -0.10805166f, 0.02812963f, 0.11443487f, 0.03866021f, 0.00848891f, 
    -0.02310750f, 0.06209676f, 0.06296427f, -0.00188648f, -0.43942332f, -0.00771009f, -0.24366203f, -0.06982933f, 
    0.01905401f, 0.09937331f, -0.03242644f, -0.05803436f, 0.08638815f, 0.08508255f, -0.03571270f, 0.03890649f, 
    -0.21069847f, -0.04228854f, -0.16471036f, 0.05716588f, 0.00617381f, -0.01926428f, -0.02873860f, 0.06939885f, 
    -0.12420005f, 0.05344311f, -0.00002923f, -0.04541734f, 0.18753910f, 0.07888529f, -0.01002922f, 0.12203036f, 
    0.00875103f, -0.12061713f, -0.05910360f, -0.02112882f, -0.08653712f, -0.08887535f, -0.04519340f, -0.10397045f, 
    0.12840185f, -0.08274031f, -0.04458399f, 0.00780004f, 0.03087993f, 0.05246687f, -0.04766886f, -0.00883496f, 
    0.04068266f, 0.05361913f, -0.00556597f, 0.03345254f, 0.11751353f, 0.08248790f, -0.00684364f, 0.05738525f, 
    0.01975435f, -0.08961923f, 0.02774106f, -0.17916484f, 0.07386591f, 0.01701835f, 0.09864353f, -0.00830194f, 
    -0.60408765f, -0.26172814f, -0.04428044f, 0.00121161f, 0.16901138f, -0.00898191f, -0.01329436f, -0.08820281f, 
    0.02005547f, -0.03721865f, -0.03964305f, -0.07583104f, -0.04326808f, -0.19707443f, -0.05591524f, 0.03191986f, 
    0.04580940f, 0.05004649f, -0.01345592f, 0.11809060f, 0.12419047f, 0.00243946f, -0.11924924f, 0.03694560f, 
    -0.10233735f, 0.15605856f, 0.11754607f, 0.05376767f, -0.03574068f, 0.01746236f, 0.06808041f, -0.05065244f, 
    0.04007740f, 0.08750033f, -0.04459667f, -0.10408250f, -0.05853686f, -0.13287738f, -0.07387266f, 0.09836303f, 
    -0.10795709f, 0.00151117f, -0.03262491f, -0.12647396f, -0.00074442f, -0.08138739f, -0.11958436f, -0.08686542f, 
    0.21635430f, 0.10800166f, -0.01753405f, -0.14989455f, 0.00742329f, 0.07516885f, -0.03425509f, -0.02317858f, 
    -0.02749637f, -0.11606989f, 0.06583422f, -0.05356864f, 0.21098962f, 0.11207006f, -0.09756717f, -0.11464987f, 
    -0.04907490f, 0.10010258f, 0.03128846f, 0.02094855f, -0.04817282f, 0.09388059f, 0.11971468f, 0.02224415f, 
    -0.34345412f, 0.13517499f, 0.13482128f, -0.07833344f, -0.00206499f, 0.00746622f, 0.01033607f, 0.04323567f, 
    -0.01917060f, 0.05185388f, 0.06032873f, -0.01336158f, 0.04048836f, -0.00790999f, -0.15407130f, -0.14545259f, 
    0.13768728f, 0.05573097f, -0.12444369f, 0.12289792f, -0.06846420f, 0.03457563f, -0.06237845f, -0.06425361f, 
    0.22934996f, 0.06390143f, -0.04391975f, 0.09426713f, -0.09487901f, 0.00814624f, 0.01305925f, 0.00572322f, 
    -0.00203787f, -0.00535434f, 0.09757786f, -0.10200549f, -0.05329479f, -0.10376203f, 0.00382856f, -0.00294974f, 
    0.02033020f, -0.05496941f, -0.01148242f, -0.02768931f, 0.10086400f, -0.01115537f, -0.03451782f, -0.00066076f, 
    -0.52182776f, -0.21482706f, -0.15471974f, -0.30730650f, 0.08287157f, 0.12657128f, 0.09230290f, -0.02362160f, 
    0.11660828f, 0.01377942f, 0.12299102f, 0.09074263f, -0.33614182f, -0.13295136f, 0.18805952f, -0.02908926f, 
    0.09748748f, -0.01718254f, 0.03345036f, 0.06787280f, 0.09214768f, 0.07271136f, 0.00094761f, 0.15674794f, 
    -0.47540325f, -0.30179012f, 0.13499765f, 0.06949257f, 0.09500669f, 0.03688740f, -0.19615227f, -0.06945755f, 
    -0.09680537f, -0.05568215f, 0.04839314f, 0.06888991f, -0.26923829f, -0.38315687f, -0.15945654f, -0.06709213f, 
    0.05648953f, 0.06386203f, 0.01325369f, 0.03806669f, 0.10080371f, 0.08679911f, 0.04947511f, 0.13080579f, 
    -0.21445657f, 0.15409423f, -0.09043215f, -0.02366740f, 0.02317376f, 0.04178889f, 0.02006502f, -0.03515003f, 
    -0.01442653f, 0.06481999f, 0.11381462f, 0.12371359f, -0.44514808f, -0.25023490f, -0.02299193f, -0.02525862f, 
    0.02990676f, -0.04941621f, -0.04758279f, -0.05705923f, -0.03691507f, -0.00315880f, 0.08053701f, -0.04791424f, 
    -0.42577326f, -0.33965009f, 0.03281108f, -0.13298716f, 0.02904629f, -0.02380876f, 0.02753313f, -0.02138165f, 
    0.03689874f, 0.05933941f, 0.06361769f, 0.04070619f, -0.08529855f, 0.06736647f, 0.07393789f, 0.05571477f, 
    0.12576960f, -0.01049982f, -0.02801147f, 0.10580432f, 0.15200990f, 0.17531827f, 0.04886708f, -0.01309169f, 
    0.04155921f, 0.03329450f, 0.05544872f, -0.08853513f, -0.01604775f, 0.05118569f, 0.06134405f, -0.12369088f, 
    0.02242259f, -0.10788924f, -0.00976893f, -0.10964862f, -0.04305946f, 0.10234399f, -0.14994094f, -0.19403651f, 
    0.01794301f, -0.02141466f, -0.03440960f, 0.01554911f, 0.01197386f, 0.06122495f, 0.20580812f, 0.14571615f, 
    0.06214198f, 0.09249711f, -0.04138085f, 0.19737564f, 0.06051624f, -0.05591254f, 0.01245231f, -0.09582434f, 
    -0.05994941f, 0.00887051f, -0.00613063f, 0.02462102f, -0.31593823f, 0.04361866f, -0.01678990f, 0.01999451f, 
    -0.01246424f, 0.04633199f, -0.04805317f, -0.03692938f, 0.05926566f, 0.08402333f, 0.00844601f, 0.08000807f, 
    -0.40725040f, -0.06678713f, -0.00998593f, -0.16232535f, 0.03603324f, 0.01395373f, -0.22402585f, -0.07238878f, 
    0.01863721f, 0.01388710f, 0.02448475f, -0.03824950f, 0.02150913f, -0.00334513f, 0.06636506f, -0.03394628f, 
    0.14800942f, 0.06700259f, -0.02385697f, -0.10636976f, 0.02672797f, -0.00892104f, -0.02318134f, 0.06542224f, 
    0.14639547f, 0.01633118f, 0.20763242f, 0.10902538f, 0.10552751f, -0.00034467f, -0.00783969f, 0.12455512f, 
    -0.01377816f, 0.04160181f, 0.01239378f, 0.10135186f, 0.16839874f, 0.05444022f, -0.10669269f, -0.08640294f, 
    -0.05182359f, 0.03545080f, 0.01189967f, -0.02443707f, 0.08510672f, -0.02298434f, -0.03208645f, -0.01277841f, 
    -0.30685717f, -0.12179299f, -0.03663497f, 0.03236077f, -0.01848731f, -0.00680595f, -0.07909855f, 0.13012496f, 
    0.09435700f, 0.09108259f, -0.00023805f, 0.08577027f, -0.32313594f, -0.26743507f, -0.22902283f, -0.16160078f, 
    0.03314406f, 0.06060614f, 0.01263001f, -0.01600499f, 0.05963835f, -0.05104322f, -0.07818189f, 0.06336720f, 
    -0.07617977f, -0.04818881f, 0.03213719f, 0.16232972f, -0.01821230f, -0.00308861f, 0.07409862f, -0.07586792f, 
    -0.06302124f, 0.18683940f, 0.03319027f, 0.03493925f, -0.07488680f, -0.05297726f, 0.09048966f, -0.09546299f, 
    0.05942855f, 0.08160786f, 0.09724525f, -0.14835186f, -0.02020904f, -0.05295037f, 0.01391255f, -0.04937915f, 
    0.25831985f, 0.04050784f, 0.02387234f, -0.07152849f, -0.12329481f, -0.01846510f, 0.09764272f, -0.08318400f, 
    0.09062624f, -0.01055246f, -0.15613924f, -0.04406879f, 0.17158024f, 0.07257924f, -0.08460462f, 0.02795509f, 
    -0.00328821f, -0.03413488f, 0.06709812f, 0.00899095f, -0.01987287f, 0.05291032f, 0.02495943f, -0.04544526f, 
    0.02420865f, -0.10906808f, -0.03077862f, -0.03334258f, -0.07682480f, 0.03524308f, 0.02433311f, 0.04774223f, 
    0.06865501f, 0.00580969f, 0.02917527f, 0.05701441f, 0.17092599f, 0.07181811f, -0.01763270f, 0.02374659f, 
    0.00329999f, 0.14695337f, 0.08693577f, -0.04353485f, 0.10832836f, 0.08018864f, 0.06347467f, 0.06412754f, 
    -0.10099225f, -0.28160483f, -0.09205079f, 0.13611250f, 0.07421389f, -0.05443162f, 0.02102254f, 0.04509233f, 
    0.06345154f, 0.02209925f, 0.12846307f, 0.11776205f, -0.03720796f, -0.06663787f, 0.03706212f, 0.12136246f, 
    0.03908710f, 0.00230662f, 0.07774323f, 0.05885836f, 0.02919305f, 0.02179641f, 0.02114837f, 0.10521439f, 
    0.22303759f, 0.00058417f, -0.14711738f, 0.06694470f, -0.12600596f, -0.10465447f, 0.05803151f, 0.12312759f, 
    0.03475409f, 0.04294323f, -0.03158670f, -0.03072993f, 0.27928370f, -0.02149537f, -0.02441814f, -0.13374837f, 
    -0.00775290f, 0.01053605f, -0.06517345f, 0.11456185f, 0.06504247f, -0.05264714f, -0.20518501f, -0.07474951f, 
    0.26048851f, 0.02744325f, -0.05102814f, 0.11293656f, -0.03645434f, -0.04012829f, 0.06863219f, 0.06445992f, 
    0.00186994f, -0.05786616f, -0.05567203f, 0.04873980f, 0.18703084f, 0.02341896f, -0.06399375f, 0.01932460f, 
    -0.07146844f, -0.02290792f, -0.10044350f, 0.03619215f, -0.01173258f, -0.06412646f, 0.04797297f, -0.14196953f, 
    -0.42447940f, -0.22761287f, 0.02784654f, -0.18406983f, 0.05807282f, -0.07681175f, -0.00713970f, -0.04516770f, 
    0.02187943f, -0.12632014f, -0.12816012f, -0.09245154f, 0.11356477f, -0.04267627f, -0.01255506f, -0.15508667f, 
    -0.14423950f, 0.00589817f, -0.11816121f, -0.05243152f, -0.03287202f, -0.26535574f, 0.02586817f, -0.01486310f, 
    0.08371368f, 0.06619631f, 0.05631638f, -0.20574217f, 0.02255336f, -0.00100188f, 0.00323939f, 0.10657941f, 
    -0.01996908f, 0.08713280f, -0.05209979f, 0.11708169f, 0.14053917f, -0.04888278f, 0.05310282f, 0.05743897f, 
    0.16621046f, 0.02519302f, -0.07717554f, 0.08849788f, 0.00936381f, -0.00046057f, 0.02542217f, 0.02568524f, 
    -0.42331222f, 0.03985732f, 0.09472324f, -0.00487315f, 0.15218334f, -0.00803826f, 0.03192682f, -0.08118028f, 
    0.07028689f, -0.01279648f, -0.14194790f, -0.06568980f, -0.35224861f, -0.17430979f, -0.02683721f, -0.04052414f, 
    0.08051138f, -0.04103448f, -0.01436773f, -0.08800600f, 0.05193933f, 0.04530612f, 0.03830894f, 0.14293729f, 
    -0.42483884f, -0.34645492f, -0.18956651f, -0.26129344f, 0.00923473f, -0.04234132f, -0.07854445f, -0.05085105f, 
    -0.12998565f, 0.00258356f, -0.15854350f, -0.14417785f, -0.26565975f, -0.18370289f, -0.02632546f, 0.03769207f, 
    0.14589332f, 0.01947930f, 0.02301317f, -0.07338830f, -0.06102166f, 0.02073953f, 0.12350647f, 0.15581596f, 
    -0.22980224f, -0.16513875f, 0.13796426f, 0.13179454f, 0.11559028f, 0.00319572f, -0.01733742f, 0.04762521f, 
    -0.03880960f, 0.04813165f, -0.10155725f, 0.01122884f, 0.20941268f, -0.08791512f, -0.05127130f, 0.09730931f, 
    -0.01129820f, 0.09696093f, 0.01271339f, 0.12734284f, 0.05038909f, 0.14896967f, 0.03500597f, 0.11825551f, 
    -0.28327373f, 0.04576432f, -0.15715849f, -0.27805185f, 0.05159487f, -0.06159186f, -0.01356241f, 0.05637896f, 
    0.05082992f, 0.12477667f, 0.07444648f, 0.01766414f, 0.20198177f, 0.12831239f, 0.02842325f, 0.01184225f, 
    0.09605528f, 0.11225926f, 0.00699695f, 0.05983248f, -0.00269400f, 0.00860965f, -0.07060923f, 0.09236179f, 
    -0.39377102f, 0.01812329f, -0.14574413f, 0.08297966f, 0.02378909f, 0.05069359f, -0.02622029f, -0.02444480f, 
    0.07694380f, 0.06915317f, 0.02943165f, 0.03187123f, -0.04098260f, -0.13816114f, -0.01388250f, -0.02141954f, 
    -0.00620251f, 0.10317045f, 0.01782172f, 0.01133262f, 0.00439657f, 0.10772309f, 0.00201498f, 0.04478060f, 
    -0.26074475f, -0.15845096f, 0.17330496f, -0.06138745f, -0.03229101f, 0.03711770f, -0.03125008f, -0.14108315f, 
    0.05175598f, -0.04853699f, 0.00962262f, -0.01265914f, -0.00293612f, -0.08947548f, 0.02461094f, 0.11810451f, 
    -0.06355545f, 0.10801103f, 0.06289349f, 0.04688279f, 0.09453621f, 0.01854869f, -0.10424647f, -0.02220838f, 
    -0.12878829f, 0.05003892f, -0.06074608f, -0.01531505f, -0.01958423f, 0.00140685f, 0.09996364f, -0.00190796f, 
    0.09406676f, 0.08924332f, 0.06153246f, 0.05840784f, -0.21247840f, -0.02864081f, 0.09487157f, -0.16907872f, 
    -0.04135832f, -0.01784018f, -0.04231995f, -0.08490181f, -0.05344126f, 0.09760093f, -0.03498627f, -0.10519547f, 
    0.02986803f, 0.04440769f, 0.04747032f, -0.10993923f, 0.26066774f, -0.04142896f, -0.01566732f, -0.00805023f, 
    -0.02561076f, -0.00160898f, -0.01238533f, 0.09938134f, 0.35348451f, 0.03366339f, -0.20810971f, 0.11587762f, 
    -0.04474341f, -0.05683420f, 0.09040368f, 0.07138492f, -0.09176101f, 0.00332151f, 0.14461601f, -0.05848892f, 
    -0.06046492f, -0.29646200f, 0.07935307f, -0.06596772f, -0.02439397f, -0.01666620f, 0.03542849f, -0.06496847f, 
    -0.08979519f, 0.05739925f, 0.06328459f, 0.07806534f, -0.14682561f, -0.10249819f, 0.05351996f, -0.07082946f, 
    0.06200457f, -0.10012414f, 0.05199054f, -0.05900628f, -0.00128816f, 0.05687238f, 0.10210882f, 0.15718991f, 
    -0.41046813f, 0.19002676f, 0.04910651f, 0.03117692f, 0.02189342f, -0.05669845f, 0.04265441f, -0.07037663f, 
    0.05716304f, -0.04460512f, 0.08403344f, -0.03040329f, 0.24641185f, 0.07663199f, -0.16147080f, -0.02511864f, 
    -0.06879037f, -0.04346455f, 0.04916316f, -0.14443277f, -0.08858524f, -0.01480318f, -0.03270977f, -0.00597221f, 
    0.30771342f, 0.02557604f, -0.06715839f, -0.14660788f, -0.03125517f, 0.04182515f, 0.00295729f, 0.00500632f, 
    0.03188207f, 0.03962598f, -0.00638318f, -0.12497581f, 0.41349193f, -0.07733298f, -0.13576777f, 0.18719947f, 
    0.03972052f, -0.08029093f, 0.04066054f, 0.03371573f, -0.04781224f, 0.07312394f, 0.01881609f, -0.00855830f, 
    0.13564803f, 0.01714948f, -0.09565302f, -0.14596348f, -0.00337434f, -0.09038091f, -0.07237494f, -0.00150241f, 
    -0.07959627f, -0.06040341f, 0.04080502f, 0.04357583f, -0.10320885f, -0.13835335f, -0.15337315f, -0.00974493f, 
    -0.16585481f, 0.07840955f, 0.07082188f, -0.06073930f, -0.04492379f, -0.03392110f, -0.06916698f, -0.09622179f, 
    -0.29180762f, 0.24169831f, -0.03062465f, 0.06384151f, 0.00250347f, 0.00791434f, 0.10430911f, -0.00987617f, 
    0.02455098f, 0.05092822f, 0.06996349f, -0.18673903f, 0.04286280f, -0.12104788f, -0.18575743f, 0.11740385f, 
    -0.18405566f, 0.07539070f, -0.03922296f, -0.09672944f, 0.01768827f, -0.11121622f, -0.11450326f, -0.10429383f, 
    0.14219111f, 0.22501366f, -0.13421200f, -0.22833508f, 0.12514359f, -0.01967285f, 0.06102157f, 0.01825988f, 
    -0.01658649f, -0.08514324f, -0.11948636f, -0.09826390f, 0.01874943f, -0.09433631f, -0.06063994f, 0.40431574f, 
    -0.03583743f, 0.00951281f, 0.01176094f, 0.09126735f, 0.08342887f, 0.02097587f, -0.04003218f, -0.04290788f, 
    -0.01878968f, 0.11733832f, -0.21755843f, -0.03817907f, -0.06673620f, -0.00059072f, -0.05494056f, -0.01118470f, 
    0.17845422f, -0.05100847f, -0.02300070f, 0.01474387f, 0.07711460f, 0.07789676f, -0.02433717f, -0.02255520f, 
    0.01905009f, 0.00070236f, -0.01177061f, -0.21645187f, -0.02751126f, 0.12876545f, -0.01396729f, 0.04735148f, 
    0.43042013f, -0.23075612f, -0.14389320f, 0.07414153f, -0.00940556f, -0.04777346f, -0.02366673f, -0.06092377f, 
    0.09543205f, -0.03885729f, 0.03380987f, -0.01253724f, 0.32900003f, 0.19877541f, -0.20152602f, 0.01635548f, 
    -0.04018896f, -0.09997220f, 0.07794181f, -0.05247837f, 0.11904493f, 0.04835135f, -0.00599962f, 0.01143351f, 
    0.04198087f, 0.16808741f, -0.11909597f, 0.05193159f, -0.04347986f, 0.11834361f, 0.02557413f, -0.03987772f, 
    -0.03625318f, -0.00273821f, -0.05578017f, -0.00342818f, -0.11283051f, -0.03506428f, 0.05533263f, 0.12950411f, 
    0.11871496f, 0.03579960f, -0.03246207f, -0.02658050f, -0.11778581f, 0.10143635f, -0.02363977f, -0.07133736f, 
    0.25807622f, 0.01090643f, -0.06533764f, 0.01478691f, 0.02286929f, -0.05248192f, 0.05873262f, -0.04249865f, 
    -0.08615178f, -0.02839539f, 0.02593056f, -0.00676142f, 0.13908392f, -0.25454262f, -0.09406590f, 0.02219270f, 
    -0.05561527f, 0.00577135f, 0.02227319f, -0.12429985f, 0.04489681f, -0.04026781f, -0.10351139f, 0.00455487f, 
    -0.07863653f, -0.10145013f, -0.01122089f, -0.15482500f, 0.02499897f, 0.00103402f, 0.02685163f, 0.08873745f, 
    -0.05793121f, 0.03969116f, -0.05694736f, -0.06744558f, 0.12304822f, 0.06522626f, -0.08355136f, 0.03496907f, 
    0.04527408f, 0.03276712f, 0.03987213f, -0.10502546f, -0.16357142f, -0.01391078f, -0.12965319f, -0.06345524f, 
    -0.03472853f, 0.13284217f, -0.00883788f, -0.05842607f, 0.01398086f, 0.03306302f, 0.00208386f, -0.12214730f, 
    0.00370921f, 0.04566352f, 0.01760305f, 0.14370236f, -0.25614867f, 0.07338846f, -0.02461691f, -0.00014104f, 
    0.01885783f, 0.01545371f, -0.04712253f, 0.01920052f, -0.08487096f, 0.00619705f, 0.00361822f, 0.03035640f, 
    -0.01413837f, 0.13340199f, 0.03755744f, -0.04339952f, -0.03662719f, 0.10689632f, 0.05945932f, -0.04274686f, 
    0.06917590f, 0.03356158f, -0.03989727f, 0.02888190f, 0.00406374f, 0.14009359f, 0.12952828f, -0.01346672f, 
    -0.06342601f, 0.04389701f, -0.12031536f, 0.06860144f, 0.01633857f, 0.02029726f, -0.04155694f, -0.03475590f, 
    0.12023050f, -0.10465331f, -0.01545411f, -0.24640483f, -0.01227254f, 0.11395907f, -0.03834243f, 0.06498232f, 
    -0.01053729f, 0.00437290f, -0.11528024f, 0.08096997f, 0.14153658f, -0.14589433f, -0.00133658f, -0.10620604f, 
    0.01059912f, -0.08068129f, -0.07514542f, -0.09812173f, 0.07423124f, 0.05018853f, 0.03242305f, -0.10719867f, 
    0.03356057f, 0.15515311f, -0.17877467f, -0.12984315f, 0.08874626f, -0.02362596f, 0.04601028f, 0.09161317f, 
    0.05646208f, 0.01119939f, 0.05430663f, -0.04540076f, -0.04826959f, -0.19857511f, -0.07173779f, -0.02398820f, 
    -0.08611465f, 0.06206540f, 0.03175194f, 0.00521395f, -0.05526389f, -0.05638901f, -0.03303980f, -0.04965483f, 
    -0.27532172f, 0.07870125f, 0.00515094f, 0.09925913f, 0.11478184f, -0.01696819f, 0.04727279f, 0.03244356f, 
    0.05564022f, -0.03876321f, -0.10916143f, -0.03345238f, -0.25694561f, -0.09667177f, -0.09896755f, -0.16397485f, 
    0.10292479f, 0.03920844f, 0.10175594f, 0.02783110f, 0.05041322f, 0.02820470f, 0.11741245f, 0.00047415f, 
    -0.16805345f, -0.21485557f, 0.10387492f, 0.05471724f, -0.05489317f, 0.05831958f, -0.02264075f, 0.05969197f, 
    0.00347398f, -0.01773559f, 0.09240153f, -0.07407068f, 0.01721016f, 0.14211828f, 0.04983906f, 0.00610385f, 
    0.01947177f, -0.04900699f, -0.04535063f, -0.13783686f, -0.04795441f, 0.06367503f, -0.00728173f, -0.00109947f, 
    -0.08122578f, -0.01674721f, 0.01046207f, 0.09206284f, -0.04452154f, -0.05039731f, 0.02990568f, 0.13299611f, 
    0.07419922f, 0.03241261f, 0.02571400f, 0.00790994f, 0.27178699f, -0.05850965f, 0.01045784f, 0.09855834f, 
    -0.00773529f, 0.08631136f, -0.08654121f, -0.01976331f, -0.05200140f, -0.03793701f, -0.03481021f, -0.07471497f, 
    -0.03075017f, 0.00718161f, -0.36995190f, -0.02258839f, -0.04933303f, 0.00544870f, 0.05931072f, 0.03873964f, 
    -0.02868092f, 0.03928698f, 0.05465153f, 0.05358763f, -0.12866184f, 0.14352374f, 0.03114149f, 0.08768208f, 
    0.04536836f, -0.17516619f, 0.00423892f, -0.00703283f, -0.10970668f, -0.06217143f, -0.02229191f, -0.00938832f, 
    -0.15779325f, -0.11467339f, -0.14475244f, -0.19005048f, -0.03332331f, -0.02181584f, 0.03723847f, 0.10535979f, 
    -0.08808473f, 0.02167316f, -0.13456427f, -0.09265486f, 0.11340690f, -0.21251220f, 0.07446694f, -0.03053763f, 
    0.01904152f, 0.05232574f, -0.05612668f, -0.04732723f, 0.01671495f, -0.09987716f, 0.12259717f, 0.05923418f, 
    0.00551659f, -0.21525067f, 0.11355793f, 0.02527448f, 0.07695173f, -0.01408819f, 0.01283094f, -0.12174758f, 
    -0.01588711f, -0.03997532f, -0.02283062f, 0.09698583f, 0.19816828f, 0.04551256f, -0.37422875f, 0.05745533f, 
    0.11019595f, 0.02146011f, 0.00321792f, 0.13718201f, 0.01158102f, -0.02321877f, -0.01827997f, 0.04980868f, 
    0.04095899f, -0.11015788f, 0.09782304f, -0.03124668f, -0.04049254f, -0.11338121f, 0.13094473f, -0.03034735f, 
    -0.08011534f, -0.07146251f, 0.09326360f, -0.02939420f, -0.36298570f, -0.26925677f, -0.18094994f, -0.08490658f, 
    0.11405277f, 0.01358506f, 0.03539276f, 0.04883017f, -0.01065630f, -0.06560559f, -0.01465554f, 0.03177986f, 
    -0.05873777f, -0.15038522f, 0.00890434f, -0.12079564f, -0.00777771f, 0.02179188f, 0.03929716f, -0.07295720f, 
    -0.03730057f, 0.01292131f, 0.08173884f, -0.02830978f, 0.02186218f, -0.17487369f, 0.01145606f, 0.15021415f, 
    0.00020782f, -0.09230185f, 0.06119187f, -0.05013662f, -0.07923518f, 0.03752078f, -0.11353272f, -0.01605090f, 
    -0.18511406f, 0.05912282f, 0.12438034f, 0.06929909f, -0.17531703f, 0.07436923f, -0.04245253f, 0.07361992f, 
    -0.04752034f, -0.05177623f, -0.03757169f, -0.04170005f, 0.13716541f, 0.14057833f, -0.05194618f, -0.10722879f, 
    -0.13627860f, -0.13530396f, 0.04456660f, -0.08918856f, 0.07565656f, 0.04063806f, -0.07183395f, -0.02597081f, 
    0.44635487f, 0.00035882f, 0.00765030f, 0.00858233f, -0.00946765f, -0.09206668f, -0.05219236f, 0.08118376f, 
    0.05156825f, 0.05851604f, 0.02470832f, -0.09192925f, 0.15038818f, -0.01941357f, -0.02358616f, -0.12667525f, 
    0.06181501f, 0.04616109f, 0.01083687f, 0.02815280f, -0.02307403f, 0.02048258f, -0.13287678f, -0.04164455f, 
    -0.36390877f, -0.13190348f, -0.10174742f, -0.40357730f, 0.05288583f, -0.03962308f, 0.00650613f, 0.11324254f, 
    0.04219385f, -0.01972080f, -0.06505880f, 0.11213703f, 0.30547681f, -0.06644885f, -0.03046172f, 0.00784649f, 
    0.10997678f, -0.03591440f, -0.06251577f, 0.15378423f, 0.01386896f, 0.06577229f, 0.05694145f, 0.02112252f, 
    0.10426591f, -0.21050730f, -0.02325972f, -0.04432349f, -0.01552758f, -0.03621446f, -0.09480170f, 0.06376523f, 
    0.03939307f, -0.03919248f, 0.00975844f, -0.02708474f, -0.04442170f, -0.13864614f, 0.05271061f, 0.15176935f, 
    0.03071362f, 0.07064494f, -0.02628507f, -0.13457865f, -0.04441443f, 0.01272449f, 0.03687459f, -0.00823698f, 
    0.35043928f, -0.22292271f, -0.24136899f, 0.00256977f, 0.01790091f, 0.01294418f, -0.03912623f, -0.04701837f, 
    0.00916273f, -0.03088074f, 0.08273904f, -0.01135419f, 0.10089058f, 0.16364029f, -0.15579000f, 0.25731644f, 
    0.15393098f, 0.05192940f, 0.04069640f, 0.05610552f, 0.02832671f, -0.00554641f, -0.02683759f, -0.01723745f, 
    0.02849250f, 0.16779140f, -0.04115682f, 0.05539048f, -0.13463119f, -0.03598352f, 0.01012385f, 0.06930441f, 
    -0.10250579f, -0.01555069f, 0.04788277f, 0.02392763f, -0.02578226f, -0.25461602f, -0.01602628f, 0.07947801f, 
    0.03369897f, 0.11338620f, -0.06413002f, -0.09165393f, -0.01860272f, -0.01544847f, 0.10522720f, -0.02110874f, 
    -0.05491215f, 0.03118961f, -0.01201055f, 0.04543822f, 0.06669354f, 0.09038694f, -0.07597746f, -0.09102470f, 
    -0.06271970f, 0.10499587f, -0.00684221f, -0.04835084f, -0.18874556f, 0.25645366f, -0.07413144f, 0.12591121f, 
    0.11773831f, -0.01792625f, 0.03399460f, 0.17235941f, -0.03957924f, -0.02561182f, -0.03897178f, 0.04390746f, 
    0.11698415f, -0.04176240f, 0.03299006f, 0.03483032f, 0.13435099f, 0.03243517f, -0.10103394f, 0.02630093f, 
    -0.08161415f, -0.07498080f, 0.00883911f, -0.06016774f, -0.08896382f, 0.07186554f, -0.16109566f, 0.15784495f, 
    -0.02572074f, -0.22146665f, -0.00597163f, -0.00678647f, -0.02471683f, 0.01335516f, -0.00619862f, 0.05863683f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01388258f, 0.00516725f, -0.02700948f, -0.00399215f, 0.03624604f, -0.02045233f, -0.01935171f, -0.04178360f, 
    -0.01984978f, 0.00879850f, 0.04206606f, -0.01007636f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
