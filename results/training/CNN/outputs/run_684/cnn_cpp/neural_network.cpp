#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.07351172f, 0.47894093f, 0.83616316f, 0.49747774f, 0.32336560f, 0.63221425f, -0.64735526f, 0.22832109f, 
    0.32373738f, 1.16270828f, -0.48852959f, -0.84982514f, -1.01212502f, -0.42937952f, 0.19079696f, 0.09357051f, 
    0.57160956f, 0.50720489f, -0.57991850f, -0.04527806f, -0.63842720f, 0.70642692f, 0.90507460f, 0.79179734f, 
    0.27993408f, -0.14233012f, -0.20199348f, -1.53272212f, 0.99733126f, 1.22370255f, -0.02504044f, 0.67423034f, 
    0.35467008f, -0.08532023f, -0.22704676f, 0.29085898f, -0.64217699f, -0.94576246f, -0.43719748f, -0.23159361f, 
    1.09076488f, 0.35389477f, -0.14533119f, -0.63122165f, -0.60224545f, -0.93990195f, 0.89290369f, -0.46883371f, 
    -1.02593887f, -0.45647359f, -0.79827791f, -0.47815761f, -0.02377842f, 0.10851078f, -0.78378594f, -0.91497552f, 
    -1.12739229f, -0.90375459f, 0.12166577f, 0.34457210f, 0.29029998f, -0.44951904f, 0.33470497f, 0.78930259f, 
    0.99194074f, 1.03827906f, 0.65789217f, 0.15374979f, 0.01300300f, 0.73615748f, 0.53925437f, 0.10211758f, 
    0.99372339f, -0.32598069f, -0.66034478f, 0.72969443f, -1.13674521f, -0.85242534f, 0.35408139f, 0.24073811f, 
    0.42441794f, -0.89442211f, -0.60337985f, -1.04465222f, 0.42902881f, -0.36117142f, 0.24037862f, -0.36164492f, 
    -0.00243146f, -0.50139421f, 1.19136691f, 0.93183464f, -0.09569640f, -0.30833697f, 0.81657225f, 0.33930829f, 
    0.33646753f, -0.08691441f, -0.36115256f, 0.41611731f, -1.65703666f, 0.67145526f, 0.94865906f, 0.52965194f, 
    0.47298133f, -0.59225786f, -0.19917339f, -0.12912686f, -0.24585682f, 1.65005517f, -1.06235492f, 0.11660375f, 
    0.12532838f, 0.34126207f, 0.40726951f, -0.31986031f, -0.28380635f, 0.55241537f, 0.83590317f, 0.86246371f, 
    -1.48975110f, 0.74693233f, -0.61335641f, -0.01047202f, -0.12334919f, -0.03290812f, 0.67998558f, 0.87700742f, 
    0.90924418f, -1.16764307f, -0.52903128f, -0.30463576f, 0.62412566f, 0.05464692f, -0.40695533f, -0.74829823f, 
    -0.42706084f, 0.38808960f, -0.95852798f, 0.31338403f, 0.58310282f, -0.38904309f, -0.36089253f, 0.50259036f, 
    0.78818446f, -0.43790266f, -0.20867465f, 0.85539770f, 0.53504801f, -0.23997477f, -0.18960384f, 0.48891947f, 
    -0.36524519f, 0.22435144f, 1.17328322f, -0.49416819f, -1.04947221f, -0.79802984f, 0.06402630f, 0.22931020f, 
    0.23982897f, -0.33588171f, -0.35563621f, -0.61545533f, 0.80025578f, -0.94533432f, 0.65664965f, -1.22219741f, 
    0.11663505f, 0.42967048f, 0.09791056f, -1.19541109f, 0.74949300f, -0.61187029f, 0.89344257f, 0.24421662f, 
    -1.16322649f, 0.12928262f, -0.02630792f, 0.71837986f, -0.57154447f, -0.89755929f, -0.44418201f, -0.41629884f, 
    -1.15702331f, -0.44517159f, 0.46968132f, -0.39943367f, -0.43084547f, -0.29174185f, -1.34279203f, -0.12588760f, 
    0.36933824f, 0.68999332f, -0.94871873f, -0.06470035f, 0.22415183f, -0.17891744f, -0.77824408f, -0.91562033f, 
    -0.99236137f, 0.68184787f, -0.26830444f, -0.23310721f, -0.17366314f, 0.41169053f, 0.18967088f, -0.82731599f, 
    1.18049908f, 1.12424052f, 0.39141485f, 0.43152153f, -0.92405885f, -0.08099700f, 0.39361134f, -0.25038937f, 
    0.70502055f, 1.00369906f, 0.90750933f, 0.47453555f, 0.53030753f, -0.32850844f, -0.43299156f, 0.16535114f, 
    -0.58094049f, -0.07501214f, -1.23154604f, -0.76459956f, -0.11815039f, 1.03837466f, 0.86634380f, -0.30856210f, 
    0.44082722f, -0.23947191f, -0.81059796f, -1.40386224f, 0.53346050f, 0.86060476f, 0.24352972f, 0.79024684f, 
    0.13648653f, 0.04204736f, -0.06557082f, 0.04612264f, 0.13082096f, -0.73146546f, 1.07658291f, 0.73880744f, 
    -0.59554720f, 0.01146482f, -0.52654296f, -0.35357773f, 0.20695496f, -1.37321436f, 0.64368176f, -0.77325797f, 
    0.71871036f, 0.54195780f, 0.03913086f, 0.16299251f, 0.09739102f, 1.38327408f, -0.22789089f, -1.00744319f, 
    -0.03583100f, 0.83837473f, -0.48648480f, -0.37819332f, -0.32981637f, 0.06282511f, -0.85851359f, -0.50893039f, 
    -0.44602180f, -0.60449189f, 0.39922744f, 0.31385562f, 0.00001563f, 0.53834116f, 0.50984883f, 0.96947831f, 
    0.26132396f, 0.90815371f, 0.62806505f, -1.27222383f, 0.61507064f, 0.39406019f, 0.19607760f, -0.16855410f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24205668f, -0.11612348f, 0.10543198f, 0.27197471f, -0.20228878f, 0.00645684f, 0.33953327f, 0.24059173f, 
    0.01149585f, -0.11868859f, 0.33808196f, 0.04362955f, -0.10961904f, 0.20214617f, 0.30090809f, 0.30253384f, 
    0.14394827f, -0.01626444f, -0.04007494f, -0.04943763f, 0.40549946f, 0.39506519f, 0.24279855f, -0.14958088f, 
    0.10369874f, -0.11921472f, 0.19924070f, -0.02136657f, 0.10144798f, 0.13504075f, 0.27087739f, 0.24709417f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16976215f, -0.11141014f, -0.17175931f, 0.00235337f, 0.07138851f, -0.03521844f, -0.22471191f, -0.04933170f, 
    0.09830289f, -0.07112224f, -0.09576727f, 0.04386889f, -0.00544234f, 0.08701657f, -0.04524852f, -0.01980917f, 
    0.02989016f, -0.01213837f, -0.07050474f, 0.02367145f, -0.08953957f, -0.49156973f, 0.18016128f, 0.10991994f, 
    0.02131591f, 0.01716973f, 0.00378006f, -0.11603846f, 0.09926713f, 0.06012230f, -0.10161202f, -0.02014409f, 
    0.09369777f, 0.09392076f, 0.07150823f, 0.04211549f, -0.17653403f, -0.17152634f, 0.16740918f, 0.01370681f, 
    0.22772507f, 0.10385252f, 0.13818932f, -0.24872559f, -0.23508143f, 0.15994444f, 0.11871383f, -0.06307059f, 
    0.03405587f, -0.14917514f, -0.04333568f, -0.01682140f, -0.07072240f, -0.01251958f, 0.04819538f, 0.05297721f, 
    0.10869218f, -0.03823518f, 0.10962354f, -0.09439039f, 0.10474544f, -0.05597446f, 0.24368379f, 0.11335628f, 
    0.26494423f, -0.13301277f, -0.13601033f, 0.07696342f, -0.09369539f, -0.02584376f, 0.07358612f, -0.09431466f, 
    0.08872022f, 0.00226290f, -0.02611731f, 0.06149673f, -0.00797144f, -0.02135945f, 0.05419474f, 0.02711509f, 
    -0.18392861f, 0.30439091f, 0.12459177f, -0.29196197f, -0.25097212f, 0.04002846f, 0.21921796f, -0.04613784f, 
    0.02870069f, 0.05014894f, 0.03837033f, 0.02559434f, 0.00721651f, 0.12855908f, -0.00171875f, 0.08626237f, 
    0.02873202f, 0.04711450f, 0.04237279f, 0.02133628f, -0.20038538f, -0.18984778f, -0.08966935f, 0.01777383f, 
    0.02880613f, 0.07382396f, -0.06002323f, -0.00919515f, -0.13187277f, 0.10847587f, 0.00738265f, 0.06415574f, 
    -0.11773469f, -0.02093536f, -0.09904032f, -0.09149987f, -0.04399926f, 0.16999280f, 0.08519445f, -0.05500522f, 
    -0.36006188f, 0.17829056f, -0.13857217f, 0.09143265f, -0.21577919f, 0.05064829f, -0.00437042f, 0.03425045f, 
    0.07768514f, 0.05932778f, -0.02004625f, -0.06092322f, -0.04870886f, 0.07364006f, -0.02095552f, -0.02328136f, 
    -0.07904749f, -0.03639966f, 0.04890734f, -0.05478425f, -0.04403969f, 0.08011627f, -0.03661027f, -0.16162804f, 
    0.05790000f, -0.07824904f, -0.10387392f, 0.13026465f, -0.02825652f, -0.01047917f, 0.07370210f, 0.00829117f, 
    -0.04267850f, 0.05989818f, 0.02533581f, -0.10534801f, -0.07685567f, 0.05907239f, -0.01462651f, -0.00449506f, 
    0.07695404f, -0.64169222f, 0.12756591f, 0.04756943f, 0.22618684f, -0.19978343f, 0.04113334f, 0.11875943f, 
    0.08879938f, -0.00823117f, -0.14685357f, 0.01831030f, 0.02715411f, 0.07889477f, -0.02094390f, 0.18920496f, 
    -0.04059093f, 0.12080103f, -0.01546573f, -0.13879861f, 0.27708888f, -0.07860702f, -0.09085453f, -0.07858502f, 
    -0.46518511f, 0.13834804f, 0.00193351f, 0.03322838f, 0.04776263f, -0.02923455f, 0.05605166f, -0.13053530f, 
    -0.03009505f, 0.00806451f, -0.09172970f, 0.08726537f, -0.07371376f, 0.05606450f, -0.01790113f, -0.03320445f, 
    -0.00145273f, 0.07229369f, 0.05033462f, -0.23660004f, 0.32534635f, -0.30517864f, -0.06906034f, 0.04704894f, 
    0.10719132f, 0.00909995f, -0.06554653f, -0.05728903f, 0.01250928f, -0.02538237f, 0.05422719f, -0.01609215f, 
    0.03567135f, -0.03161252f, -0.02766387f, 0.06693628f, 0.11369410f, 0.17936063f, 0.20073813f, 0.11635356f, 
    -0.38278615f, 0.15889643f, 0.00089858f, 0.13098954f, -0.03543950f, -0.13632852f, -0.01516752f, -0.00643303f, 
    -0.09031161f, -0.12751514f, 0.06779253f, 0.04287179f, 0.14754729f, 0.03959049f, -0.10692716f, 0.08140860f, 
    0.36781695f, 0.03443689f, 0.28471327f, -0.30189759f, 0.42401093f, -0.14151399f, -0.03831189f, 0.19371010f, 
    0.01788007f, -0.01543231f, -0.05889317f, 0.08783333f, -0.08479406f, 0.02446148f, 0.20320430f, -0.03139549f, 
    -0.06120345f, 0.10901686f, -0.17797513f, -0.06885389f, 0.15395509f, -0.01449781f, -0.00729986f, -0.09381088f, 
    0.00457349f, -0.25601739f, -0.05112638f, -0.15576425f, -0.01234650f, 0.02678395f, 0.04123525f, -0.02604078f, 
    -0.08624249f, -0.13388552f, -0.00948989f, -0.08210777f, 0.01905312f, 0.01999103f, -0.05116006f, -0.04671027f, 
    0.08891478f, 0.08746006f, -0.10608860f, 0.01426999f, 0.17181639f, -0.17594375f, -0.24127267f, -0.07929231f, 
    -0.01783049f, 0.01373286f, -0.03916050f, 0.00096895f, -0.01095236f, -0.01960332f, 0.03538682f, 0.02993151f, 
    -0.00511136f, -0.02805708f, 0.02302072f, 0.01981683f, -0.16964704f, 0.13204132f, -0.17114979f, 0.20164636f, 
    -0.00391022f, -0.01168381f, 0.00123635f, -0.01552040f, 0.08139002f, -0.05082470f, 0.06258947f, 0.01064701f, 
    0.01165336f, -0.00582444f, 0.05628774f, -0.04603868f, -0.04670229f, -0.04269852f, 0.06846710f, 0.05218193f, 
    0.12381715f, 0.08615565f, 0.03481588f, 0.01470271f, 0.18511783f, -0.02759612f, -0.10749397f, -0.10657249f, 
    0.07026799f, -0.09245287f, 0.02033481f, 0.11309575f, 0.11850523f, -0.00829239f, -0.04951735f, -0.08999198f, 
    0.04601582f, 0.04343272f, -0.00501259f, 0.06703947f, 0.16318236f, 0.06762722f, 0.35410514f, -0.21736853f, 
    0.33574423f, -0.06015764f, -0.08527847f, 0.00166641f, -0.10306735f, 0.05668493f, -0.09103575f, -0.07572871f, 
    0.03445213f, -0.11931770f, 0.02690922f, -0.08514743f, -0.00200353f, -0.00287220f, 0.02287013f, -0.07652269f, 
    0.01560148f, -0.62199879f, 0.09431943f, 0.26335713f, -0.34181860f, -0.10631868f, -0.10510661f, 0.02395436f, 
    0.11631218f, 0.09643722f, -0.02132934f, 0.15751882f, -0.06204542f, -0.00401860f, -0.05435752f, 0.00724742f, 
    -0.08842000f, -0.03068200f, 0.05280742f, -0.08714695f, 0.75547302f, -0.27162671f, 0.00283800f, -0.14722835f, 
    -0.04846167f, -0.04597631f, -0.09558492f, -0.04944738f, -0.14445777f, 0.01907475f, 0.09464414f, 0.05765162f, 
    0.01871057f, 0.14081480f, 0.10957186f, 0.01031792f, -0.08686036f, 0.10954052f, -0.09231247f, -0.02026869f, 
    -0.19039690f, -0.42869505f, 0.02197406f, 0.12941578f, -0.10841496f, -0.01437855f, -0.05958273f, -0.03037924f, 
    0.16303319f, -0.01552700f, 0.07210479f, -0.08080992f, -0.07225854f, -0.05293657f, -0.04799996f, 0.09086253f, 
    -0.05530168f, 0.03168553f, -0.03214503f, -0.04257676f, -0.40833077f, -0.01298584f, 0.09525581f, 0.13031727f, 
    -0.42617071f, -0.01721675f, -0.06135888f, 0.00106926f, 0.04620793f, -0.04799225f, -0.04601777f, -0.01270675f, 
    -0.00554736f, -0.04437938f, 0.02507224f, -0.04056351f, 0.00389836f, 0.09550891f, -0.10070191f, -0.04785553f, 
    0.11806444f, -0.23956287f, -0.04756035f, -0.02933107f, -0.26288804f, 0.07678778f, -0.13158326f, 0.02198620f, 
    -0.00991914f, -0.00639904f, -0.03446421f, -0.03303582f, 0.00702309f, 0.00671610f, 0.01930840f, 0.04287477f, 
    -0.03324767f, 0.10861810f, -0.03949435f, 0.00020744f, -0.34637243f, 0.09385072f, 0.27182212f, -0.07572490f, 
    0.09334453f, 0.08702639f, -0.13661447f, 0.09883738f, -0.06925038f, 0.05908551f, -0.00965248f, 0.13771085f, 
    -0.01794760f, 0.06830975f, -0.03387629f, -0.05234954f, -0.06693334f, 0.00235283f, -0.01352298f, -0.12400471f, 
    0.08142310f, 0.07615300f, 0.09955196f, -0.03541458f, 0.25383624f, -0.20834050f, -0.19220214f, 0.07967249f, 
    0.06155800f, 0.02790757f, 0.04235505f, 0.08058938f, -0.03033085f, 0.07322237f, -0.01081438f, 0.06842355f, 
    0.01398447f, -0.07440553f, 0.00064386f, 0.01015311f, -0.10237525f, 0.21831113f, -0.16120611f, -0.30460140f, 
    -0.19322301f, -0.03206184f, -0.01050350f, 0.00837475f, -0.04315754f, -0.00092702f, -0.01579739f, 0.00587252f, 
    0.10461244f, -0.03550960f, -0.01631184f, 0.05842969f, 0.07309302f, 0.07137369f, -0.08730143f, 0.07220776f, 
    -0.16660932f, 0.11443785f, 0.22036670f, -0.13235961f, -0.35327899f, 0.14779907f, 0.07192270f, 0.01340706f, 
    0.00544800f, -0.05693503f, 0.00459876f, 0.02631897f, -0.03455349f, -0.01170703f, -0.07420082f, -0.00500739f, 
    -0.01311529f, -0.03194992f, 0.08744872f, -0.01312166f, 0.40241137f, 0.04073716f, 0.20742521f, -0.00231136f, 
    0.19483124f, -0.07549629f, -0.01067535f, 0.03510669f, 0.01557903f, -0.30076149f, 0.21626560f, 0.10650656f, 
    -0.02337391f, -0.02230786f, 0.02446155f, 0.03799200f, 0.03483130f, 0.10990475f, -0.03727385f, 0.02085678f, 
    -0.08577249f, -0.01142057f, -0.12145456f, 0.08536999f, -0.41503456f, -0.13972767f, 0.04551308f, 0.06060473f, 
    0.02539449f, 0.03164395f, 0.05784843f, -0.07854320f, -0.10334638f, -0.01930308f, 0.13184468f, -0.17156273f, 
    -0.05560977f, -0.03568832f, -0.07251295f, 0.07121097f, -0.14984646f, -0.08846358f, 0.15001944f, 0.09354908f, 
    0.42031288f, -0.08434145f, -0.04987537f, -0.00589135f, 0.05305817f, -0.05964447f, -0.03709289f, 0.09817479f, 
    0.12195931f, 0.01669727f, -0.14011411f, -0.02615214f, 0.06709361f, 0.00879933f, -0.03876169f, -0.03107078f, 
    -0.17682245f, 0.07489713f, -0.10740781f, 0.02275106f, -0.11934770f, 0.09945092f, -0.02859256f, -0.04057107f, 
    0.04993032f, -0.00004481f, 0.05142958f, 0.00519970f, -0.03167762f, 0.00176581f, 0.08105642f, -0.00853417f, 
    -0.03088099f, 0.05057455f, -0.06752030f, -0.07889323f, 0.12906483f, -0.24546665f, 0.02150296f, -0.09455615f, 
    -0.23274843f, -0.20705746f, -0.03403214f, 0.03139070f, -0.02682790f, 0.14427002f, -0.04696099f, -0.02537036f, 
    -0.04264554f, -0.04124977f, -0.01159157f, -0.04367223f, -0.04520290f, -0.05306758f, -0.00551077f, 0.05775849f, 
    0.37276158f, 0.34011614f, 0.04096066f, 0.08125632f, 0.14215997f, -0.11535383f, -0.05217541f, 0.00220263f, 
    -0.00550864f, 0.10888953f, 0.18116494f, -0.03346673f, 0.05727101f, -0.07710877f, -0.01084610f, 0.06304665f, 
    0.09267416f, 0.09873954f, 0.05805995f, 0.03632828f, 0.20496950f, -0.56961662f, 0.07438210f, 0.05446713f, 
    0.02264462f, -0.09610793f, -0.05129696f, -0.01615601f, 0.22256956f, -0.06229791f, -0.11240412f, 0.05017695f, 
    -0.01967975f, -0.00374606f, -0.07898968f, 0.10133719f, -0.17047893f, 0.05632099f, -0.14101492f, -0.10768475f, 
    0.02451364f, 0.11215737f, -0.13753860f, 0.01428813f, -0.09456228f, 0.01738757f, 0.07451963f, -0.20770161f, 
    -0.10613123f, 0.03017891f, 0.13641334f, -0.00703324f, -0.03712942f, -0.01272573f, -0.02774405f, 0.03699815f, 
    0.03191073f, 0.00561017f, -0.01046361f, 0.14373498f, -0.39448014f, 0.13762335f, -0.21148102f, -0.20000838f, 
    -0.00700421f, -0.00712853f, 0.23311745f, 0.03487896f, -0.05405536f, -0.01155314f, -0.05144002f, -0.01247355f, 
    0.04255417f, -0.01422614f, 0.00584580f, 0.06821335f, -0.11919224f, 0.06139302f, -0.04162619f, -0.01517180f, 
    0.19850205f, -0.19527762f, -0.14079195f, 0.07724806f, -0.14889503f, -0.10741900f, -0.08942514f, -0.07228554f, 
    -0.04393745f, 0.03007701f, 0.17045289f, 0.13350430f, -0.19886486f, -0.11333987f, 0.07990899f, 0.03462013f, 
    -0.16481601f, -0.03028299f, -0.12956315f, -0.00694923f, -0.05379480f, -0.05528478f, -0.20033522f, -0.55675596f, 
    -0.12457918f, 0.00756258f, -0.02343703f, 0.11463542f, 0.18068013f, 0.06261856f, -0.09411030f, -0.16155812f, 
    0.09795529f, 0.05558677f, 0.17204699f, -0.17058316f, -0.00964753f, -0.18471490f, -0.23110561f, -0.12082742f, 
    0.34593794f, -0.03745284f, -0.01631675f, 0.04696126f, -0.14721256f, -0.03095929f, 0.03615185f, 0.09044421f, 
    0.10270612f, 0.08212052f, -0.02514545f, -0.03700616f, -0.02856281f, 0.08288169f, 0.01005846f, 0.01936923f, 
    0.02195463f, 0.09469880f, -0.07010470f, -0.10473244f, 0.05436382f, 0.14731164f, 0.25948307f, 0.03901409f, 
    0.19740784f, -0.23685832f, -0.05705796f, 0.04346272f, -0.05392883f, 0.02415497f, -0.05336326f, -0.00915565f, 
    -0.01833373f, -0.02944830f, -0.02617420f, -0.06178975f, 0.07116020f, -0.02408942f, -0.09652581f, 0.06212782f, 
    0.02508942f, -0.02968377f, 0.23016572f, -0.23181248f, 0.10696796f, 0.12067043f, -0.11528981f, 0.04515863f, 
    -0.08420244f, -0.15522672f, 0.01321909f, -0.00316173f, 0.06275819f, -0.01837196f, -0.11482125f, 0.05569920f, 
    -0.02280373f, -0.45501021f, 0.10817501f, -0.14382097f, -0.03822472f, 0.04647541f, -0.10321375f, -0.04905439f, 
    -0.12684803f, 0.00338998f, -0.01834515f, -0.01308652f, -0.01055345f, 0.04173989f, 0.08039818f, 0.01190562f, 
    -0.02684085f, -0.05657735f, -0.01477204f, -0.17258507f, 0.14633207f, -0.08117840f, -0.14723745f, -0.04434200f, 
    0.38048437f, 0.06752028f, 0.10055126f, 0.11787812f, 0.17101651f, -0.16918376f, -0.08600817f, -0.03427365f, 
    -0.01397363f, -0.07839350f, 0.13564500f, 0.05300346f, -0.07875217f, 0.19493780f, -0.05746307f, -0.01147060f, 
    0.05923149f, 0.05967283f, -0.07317975f, -0.01530681f, 0.29860386f, -0.19102001f, -0.02248210f, 0.05992987f, 
    -0.16540362f, -0.05683231f, 0.20526890f, -0.00296118f, 0.00734532f, 0.20337747f, 0.17695951f, 0.06192702f, 
    0.07573595f, -0.00395346f, 0.00276804f, 0.04505632f, 0.08762565f, 0.00702711f, 0.07786135f, 0.03202075f, 
    0.02947080f, -0.06510992f, -0.23766841f, -0.26966050f, 0.38559803f, -0.15348275f, -0.01955641f, -0.04668451f, 
    -0.11427682f, -0.05532350f, 0.32077572f, -0.01499010f, -0.04848834f, 0.03014148f, 0.06796237f, -0.13695928f, 
    0.00561260f, -0.03042548f, 0.08848926f, 0.04139401f, 0.20018300f, 0.16385567f, -0.25070778f, 0.03823650f, 
    0.18962477f, 0.17918256f, -0.02669919f, 0.00938833f, 0.06576068f, -0.03679335f, 0.08775058f, -0.01963739f, 
    0.01316700f, 0.09168871f, 0.00185211f, 0.00594236f, 0.02145568f, 0.00763121f, -0.11856781f, 0.02411515f, 
    -0.05499279f, 0.03517472f, -0.18825586f, 0.01172192f, -0.07572959f, 0.06073070f, 0.00255064f, 0.00484942f, 
    0.03578478f, 0.01219308f, 0.00391576f, -0.01800978f, 0.05283946f, 0.08102138f, -0.08648176f, -0.00661723f, 
    0.02836170f, -0.00267397f, -0.10421090f, 0.01659387f, -0.12343661f, 0.07128268f, -0.00943379f, -0.10511712f, 
    -0.26398635f, -0.16012281f, -0.00779196f, -0.23794101f, -0.03199933f, -0.00715501f, -0.11940056f, -0.03699714f, 
    -0.17891978f, 0.01914841f, 0.07235075f, -0.00868598f, -0.08893514f, 0.00396347f, -0.05192616f, -0.04832133f, 
    0.44613403f, -0.30806148f, 0.07856070f, -0.04259653f, -0.07552434f, -0.04402260f, 0.03825669f, -0.06744552f, 
    -0.05757895f, 0.00182442f, -0.07146318f, -0.03223218f, -0.04035389f, 0.02335095f, -0.07127386f, 0.10098157f, 
    0.04023562f, 0.00789346f, 0.08681638f, 0.12606244f, -0.12337951f, -0.16048299f, -0.27853835f, -0.17790905f, 
    -0.06362395f, -0.04900008f, -0.06269896f, 0.00064426f, 0.09046782f, -0.10273290f, 0.12374318f, -0.04918005f, 
    0.04322972f, 0.15678123f, -0.11409603f, -0.12884676f, -0.04898992f, -0.14795674f, -0.04607296f, -0.12506911f, 
    -0.26496935f, -0.08915082f, -0.01439390f, 0.04467798f, -0.04202105f, -0.05508981f, -0.05010699f, -0.02527521f, 
    -0.04724139f, 0.05851768f, 0.14281936f, -0.02879863f, 0.09577401f, -0.05894370f, -0.02044405f, -0.11407689f, 
    0.06134659f, -0.01363386f, -0.16771139f, 0.17253938f, -0.70791906f, -0.16520582f, 0.06846352f, -0.01305436f, 
    0.17624985f, 0.18436092f, -0.11578523f, -0.01307668f, -0.00628087f, -0.02567561f, -0.07349592f, -0.02316457f, 
    0.05492134f, -0.11439907f, 0.00471255f, 0.09288418f, -0.06329919f, -0.23996271f, 0.06225843f, -0.22496103f, 
    -0.02698646f, 0.21153989f, -0.05421820f, -0.06550809f, -0.20136353f, 0.11249547f, -0.00487500f, 0.03674114f, 
    0.07960678f, 0.04081843f, -0.09243493f, -0.12685251f, 0.07096182f, 0.11399303f, -0.11969712f, -0.08282027f, 
    0.01864110f, -0.26474136f, -0.12080619f, -0.14505328f, 0.37359211f, -0.22062230f, -0.26461065f, -0.00002486f, 
    -0.16556521f, -0.05752064f, 0.06653520f, 0.11521058f, 0.08266880f, 0.08149748f, -0.04945368f, -0.09827866f, 
    0.09078392f, 0.04749139f, 0.02709304f, 0.02717662f, 0.07913820f, -0.01342046f, 0.11037971f, 0.10556857f, 
    0.07372189f, 0.11507207f, -0.13557774f, -0.00156073f, 0.01466297f, 0.06257664f, -0.05457170f, 0.10305116f, 
    0.01701894f, 0.13111378f, -0.02685664f, -0.11529598f, 0.12173407f, -0.05453001f, -0.09756303f, -0.01053486f, 
    0.18448251f, -0.06896182f, -0.05927980f, 0.00062289f, -0.17029671f, 0.09842085f, 0.03877312f, 0.02111779f, 
    0.19544825f, -0.25326562f, 0.12623779f, 0.01239521f, -0.09524199f, 0.11487028f, 0.08113194f, -0.05679439f, 
    0.03124535f, -0.09450833f, -0.00994694f, -0.12193739f, -0.08708066f, 0.04796881f, -0.05903589f, 0.12089404f, 
    0.15864480f, 0.36600551f, 0.14195076f, 0.02175891f, 0.33688724f, -0.12773779f, -0.00953978f, 0.02816327f, 
    -0.04181181f, 0.04834583f, -0.03376186f, -0.04187086f, 0.05474675f, 0.00571244f, 0.05185251f, -0.04170515f, 
    0.05833535f, 0.01800321f, 0.01990374f, 0.11723510f, 0.29450890f, -0.31054866f, 0.03165014f, -0.05749412f, 
    -0.14134784f, -0.07977205f, 0.09997030f, -0.00805493f, 0.09231142f, -0.04488177f, 0.04830740f, -0.03662008f, 
    -0.00760701f, 0.12902045f, -0.14540131f, 0.22751990f, -0.01787943f, -0.02063144f, -0.04693391f, 0.07150684f, 
    0.04815955f, 0.09524970f, -0.16486603f, 0.11208852f, -0.39324251f, -0.00753211f, 0.03750205f, 0.03402368f, 
    -0.08267792f, 0.01663955f, -0.00631393f, 0.04280260f, -0.00737563f, 0.10234410f, 0.10292967f, 0.13037829f, 
    0.14286098f, 0.03250362f, -0.01366091f, 0.02207754f, -0.20991816f, -0.39863676f, -0.10248766f, -0.09439525f, 
    -0.01645767f, 0.16322598f, -0.09670629f, -0.13243835f, 0.07503226f, 0.00706310f, -0.10987058f, 0.10586038f, 
    -0.08725773f, -0.16795892f, 0.03985314f, -0.06673541f, 0.01597268f, -0.12525028f, 0.05911002f, -0.09252123f, 
    -0.14720707f, -0.05520615f, -0.02709595f, 0.10862125f, -0.05619111f, -0.01830782f, -0.05788114f, 0.02821583f, 
    -0.07825363f, -0.04487592f, 0.04300951f, -0.00984170f, -0.03640666f, 0.00702708f, -0.18290384f, 0.09287577f, 
    -0.08032890f, 0.04015519f, -0.03730477f, 0.03571058f, 0.44182181f, -0.55965108f, 0.01605764f, -0.42694074f, 
    -0.16212361f, -0.01483932f, -0.03482405f, -0.00641060f, -0.00756936f, -0.00791256f, 0.00056233f, 0.01863551f, 
    -0.14826350f, 0.06305528f, 0.04409567f, -0.14491057f, 0.03806208f, -0.10290620f, 0.02719782f, 0.00299706f, 
    0.06499781f, 0.04019528f, -0.07341065f, -0.00997187f, -0.03513892f, -0.05353404f, 0.05904716f, 0.02374871f, 
    0.06784254f, 0.07115842f, -0.09622850f, -0.14802830f, 0.02957351f, -0.01370420f, -0.03148554f, 0.09749309f, 
    0.07550698f, 0.02465827f, -0.02253357f, 0.00679265f, -0.01655637f, 0.32172471f, 0.16708209f, 0.14539587f, 
    0.12227868f, -0.06201074f, -0.12343904f, 0.08637901f, 0.00519582f, 0.10662609f, 0.04241788f, -0.06044054f, 
    0.20217378f, 0.08640630f, -0.00073555f, 0.07690456f, 0.01765174f, 0.02040138f, 0.07199336f, 0.11476196f, 
    -0.21158451f, -0.02708123f, 0.08454663f, -0.08978817f, -0.04491040f, 0.13778895f, 0.04311564f, 0.09519024f, 
    0.01905186f, 0.05143539f, -0.06393164f, 0.05585375f, -0.03011099f, 0.05759295f, 0.12173351f, -0.19111855f, 
    -0.08366206f, -0.00340520f, 0.01055766f, 0.07710922f, 0.38017216f, 0.07920941f, 0.09228503f, -0.19428353f, 
    -0.30150160f, 0.03364946f, 0.06744023f, 0.19851102f, -0.01368471f, 0.05744563f, -0.01569123f, 0.00993400f, 
    0.03881215f, -0.21614298f, -0.09045946f, 0.04063008f, 0.08040952f, 0.09477616f, 0.14830613f, 0.02818412f, 
    0.21155496f, 0.17899917f, 0.22300652f, 0.14123444f, 0.21182474f, -0.00460344f, -0.10074165f, -0.10111749f, 
    0.10576244f, 0.10639874f, 0.06408717f, -0.03703584f, 0.00659803f, -0.04436064f, -0.09142301f, -0.00088768f, 
    -0.06244427f, -0.04120726f, -0.02401501f, 0.02810636f, 0.30929929f, 0.10054916f, -0.32303366f, 0.04495163f, 
    -0.12896553f, 0.00598517f, 0.09290548f, 0.02547335f, 0.02920879f, -0.01402132f, 0.01363035f, 0.06629627f, 
    0.03398309f, -0.01801339f, 0.08328559f, -0.04536472f, -0.03764742f, -0.09685216f, 0.10972430f, 0.01226926f, 
    0.23886982f, -0.09579974f, 0.08347096f, 0.17283171f, 0.23889501f, 0.02800450f, -0.08536770f, -0.04547215f, 
    0.09468134f, 0.09122416f, 0.11680557f, 0.15994887f, 0.09224746f, 0.08334399f, -0.03201858f, 0.02181685f, 
    -0.11331423f, 0.04831766f, -0.06431744f, -0.13314274f, -0.39959252f, -0.06508275f, -0.38761029f, -0.36611849f, 
    -0.31739220f, 0.06743227f, 0.04254225f, -0.01246939f, -0.10589709f, -0.07894668f, 0.04386605f, 0.00319186f, 
    -0.04507750f, -0.00249223f, -0.04830310f, -0.13592350f, 0.09206650f, 0.12764205f, 0.02659939f, 0.02589806f, 
    0.44145209f, -0.29413623f, -0.09818880f, 0.16198342f, -0.23839650f, -0.21509025f, 0.01245291f, -0.18173361f, 
    -0.11087606f, -0.00860291f, 0.01327645f, 0.02827916f, 0.01219071f, -0.01160690f, 0.04123660f, -0.05979598f, 
    -0.05518754f, -0.02471874f, 0.01393023f, 0.06041785f, 0.11462380f, -0.00815954f, 0.06083960f, -0.03751735f, 
    0.12744784f, 0.04637688f, 0.12251479f, 0.10187988f, -0.05180149f, -0.09848462f, 0.02673968f, 0.09042441f, 
    -0.01250631f, -0.01066719f, 0.00208292f, -0.00020192f, -0.13098593f, -0.03105010f, -0.10276674f, 0.03680391f, 
    -0.40894970f, -0.42636102f, 0.03252202f, -0.32377249f, -0.24333064f, 0.07095910f, -0.09037201f, 0.00901706f, 
    -0.14597555f, 0.06063597f, -0.08973605f, 0.13915679f, 0.03906861f, -0.07020713f, -0.13235071f, 0.03300201f, 
    -0.01029279f, 0.17225529f, -0.11758670f, 0.07484138f, -0.01639916f, -0.25564390f, 0.03181385f, 0.12663268f, 
    0.05522652f, -0.10957630f, -0.06569981f, -0.16512732f, -0.02953260f, 0.04403555f, 0.04197346f, -0.04992700f, 
    -0.10784718f, -0.03125315f, 0.04043834f, -0.03726955f, 0.00993792f, -0.02511697f, 0.04483565f, 0.03583171f, 
    0.18795660f, -0.03840901f, 0.08602034f, -0.14655149f, 0.08640962f, 0.07709729f, -0.07499478f, 0.13212381f, 
    0.08858515f, -0.08901214f, -0.09668652f, -0.04237859f, 0.03412782f, -0.03655777f, -0.04629705f, -0.06855506f, 
    -0.00298711f, -0.00269782f, 0.01371139f, -0.04866740f, -0.26001945f, 0.02831777f, 0.24102899f, -0.00053927f, 
    0.14710467f, -0.07184342f, 0.01916188f, -0.03760706f, 0.02408041f, 0.02614561f, 0.07961290f, -0.05543584f, 
    -0.00924724f, -0.10266066f, 0.07703023f, -0.13507007f, 0.03335574f, -0.10318220f, 0.03313129f, 0.06145789f, 
    0.14893919f, -0.05800421f, -0.20149979f, -0.23334640f, -0.09077257f, 0.00453969f, -0.04232652f, 0.13835083f, 
    -0.24048540f, 0.02604766f, -0.06261197f, -0.00251051f, 0.10514757f, 0.07274908f, -0.11769288f, -0.06979418f, 
    -0.07241698f, 0.14374155f, -0.03251309f, -0.01038025f, 0.09930994f, 0.24843217f, -0.13390979f, -0.27291566f, 
    -0.02884082f, 0.08102620f, 0.04956870f, 0.00235146f, -0.07005548f, -0.08549637f, -0.06884459f, 0.00277030f, 
    -0.10728066f, -0.09333252f, 0.00528017f, -0.03283557f, 0.03081199f, -0.06430467f, -0.06072615f, -0.05283149f, 
    -0.01627290f, 0.08113699f, -0.15188934f, 0.00194863f, 0.09659334f, 0.03462023f, 0.09396966f, 0.03930030f, 
    -0.07025076f, -0.10718598f, 0.02479068f, 0.03777571f, -0.07284724f, 0.01739257f, -0.04786139f, -0.05565065f, 
    0.04250388f, -0.03540301f, -0.06879348f, -0.04402974f, 0.34823006f, -0.11722408f, -0.32869303f, 0.01909059f, 
    -0.09869900f, -0.10720634f, -0.04042351f, 0.00023026f, 0.03339543f, 0.04373498f, 0.04588889f, 0.08864348f, 
    -0.00979552f, -0.03365602f, -0.02807764f, 0.03197823f, -0.03027314f, -0.05230704f, 0.09316161f, -0.01798085f, 
    -0.06697536f, -0.08432329f, 0.22116427f, -0.11235090f, 0.02338232f, -0.00981758f, -0.09876391f, 0.02606909f, 
    0.09419575f, 0.05184100f, 0.02536294f, -0.03260799f, 0.03629181f, 0.01212346f, 0.00771564f, 0.02900156f, 
    -0.14464490f, -0.12150764f, -0.08143965f, -0.04834939f, -0.02111162f, -0.22733162f, -0.01499616f, -0.23257139f, 
    -0.14041404f, 0.09026267f, 0.01116116f, 0.20000750f, -0.11484341f, 0.05490480f, -0.00047816f, 0.06389219f, 
    0.06525316f, -0.08703016f, -0.12559085f, 0.01871539f, -0.08507674f, 0.19414856f, -0.05421906f, 0.03156701f, 
    0.40417412f, 0.10335536f, -0.20217374f, -0.11626785f, -0.26713511f, -0.11528298f, 0.04974303f, -0.05681964f, 
    0.03694085f, 0.03965081f, 0.01974408f, -0.11074930f, 0.00961284f, 0.00791034f, -0.01316999f, 0.03207523f, 
    0.00849851f, 0.03633164f, 0.20021819f, -0.20875493f, 0.24320191f, 0.09007518f, 0.04762127f, -0.18051089f, 
    -0.11180867f, 0.14036983f, 0.03304788f, -0.08369871f, 0.18860920f, -0.05430170f, -0.00973212f, 0.11043388f, 
    -0.02207585f, 0.04652543f, -0.03902204f, -0.01113142f, -0.09774491f, 0.02441128f, 0.07797729f, 0.01861804f, 
    -0.25278947f, -0.37373585f, -0.05263749f, 0.01023419f, -0.37725666f, -0.25558886f, 0.03622286f, -0.08205979f, 
    -0.04187769f, -0.05729542f, 0.04219411f, 0.01808739f, 0.09095263f, -0.03537763f, 0.02914720f, -0.01413636f, 
    -0.01621329f, 0.04058487f, 0.01009205f, -0.06415973f, 0.24215910f, -0.53576326f, 0.18178561f, -0.13604257f, 
    0.05469052f, 0.00133623f, -0.03840730f, 0.00368770f, -0.00046830f, 0.01522648f, 0.05879161f, -0.06612136f, 
    -0.01601723f, 0.04681264f, 0.05419012f, 0.01165632f, -0.01868663f, 0.05850244f, 0.09091116f, -0.03974555f, 
    0.06162554f, -0.29315519f, 0.15885550f, -0.02867938f, 0.06386351f, -0.08440340f, -0.09046911f, -0.21677254f, 
    0.05053530f, 0.03591863f, 0.03809642f, -0.03965943f, -0.10949948f, -0.00190317f, 0.07118072f, -0.11786365f, 
    0.03902800f, 0.02150766f, 0.02110570f, -0.02801081f, 0.30244070f, -0.14107567f, -0.30737728f, -0.05480403f, 
    -0.11472017f, 0.03707799f, 0.08192073f, 0.02528898f, -0.09782198f, 0.01984145f, -0.06278918f, -0.07137244f, 
    -0.04350621f, -0.07378948f, 0.03745790f, 0.00360897f, -0.12207660f, -0.10840456f, 0.07318261f, -0.05129325f, 
    0.00646742f, -0.14596988f, -0.11008020f, -0.22293127f, 0.04961903f, 0.11737576f, 0.02379591f, 0.11926658f, 
    -0.06630271f, 0.02908897f, -0.02586369f, 0.10360602f, 0.02849877f, -0.09265484f, 0.02391567f, -0.05060387f, 
    -0.03979080f, -0.05948970f, -0.13284226f, -0.03004655f, 0.32169774f, 0.16064949f, 0.11549304f, 0.23254806f, 
    0.09249669f, -0.13784543f, -0.09331528f, 0.01039481f, 0.02193559f, 0.06937598f, 0.09875311f, 0.01815849f, 
    0.02828978f, 0.01563968f, -0.09459119f, 0.00042276f, -0.07766483f, -0.03303471f, -0.05142052f, 0.00180959f, 
    0.11210778f, 0.02535606f, 0.23017731f, -0.02755015f, 0.21416475f, -0.23197538f, -0.05636639f, -0.15010919f, 
    -0.00110855f, 0.02189265f, 0.05642411f, -0.03779330f, -0.04821350f, -0.19035780f, 0.06938738f, -0.00783031f, 
    -0.02471120f, -0.03144621f, 0.08517867f, 0.08713101f, 0.26326093f, -0.21821058f, 0.22039962f, -0.01568515f, 
    0.05503714f, 0.08826069f, -0.12403673f, -0.02069578f, 0.01674595f, 0.16287731f, -0.02300129f, -0.03801351f, 
    0.03015088f, 0.03859849f, -0.08610987f, -0.06430443f, -0.13574220f, 0.03857543f, -0.02867102f, -0.11342169f, 
    0.42930308f, 0.02709604f, -0.12071177f, -0.05661950f, -0.00965851f, -0.09964664f, 0.05270305f, 0.03880727f, 
    0.00513260f, 0.01493333f, 0.00043610f, -0.00196812f, -0.08054745f, -0.03254494f, -0.07102375f, 0.01442643f, 
    0.00529604f, -0.09876353f, 0.08292159f, 0.06863804f, -0.09547728f, -0.31715438f, -0.05927424f, -0.15535083f, 
    -0.14624783f, -0.07580689f, -0.13288473f, 0.03572413f, 0.09083428f, 0.03086950f, -0.02210493f, 0.01350771f, 
    0.02526939f, 0.08841267f, -0.05994138f, 0.06028284f, -0.13837591f, 0.09083527f, 0.01577590f, -0.05995416f, 
    0.38627237f, -0.03535828f, -0.02361310f, -0.04837605f, -0.03035750f, -0.10006471f, 0.02365762f, -0.22454597f, 
    -0.00158493f, 0.02169107f, 0.02562405f, -0.04804287f, -0.06271335f, 0.00431592f, -0.03849376f, -0.03815325f, 
    0.02831149f, 0.02383347f, 0.04384414f, 0.00853633f, -0.38865644f, 0.15117043f, 0.12293345f, -0.04881702f, 
    0.11045034f, 0.02567034f, 0.06177276f, -0.00349760f, 0.10675111f, 0.03723031f, -0.00850383f, -0.04165982f, 
    -0.04266712f, -0.04054762f, 0.06770600f, -0.01110170f, -0.02459636f, -0.14647432f, -0.14128123f, 0.01740594f, 
    -0.33677924f, -0.67779779f, -0.22083089f, -0.05512676f, -0.14323109f, -0.09906470f, -0.08682439f, 0.09912809f, 
    -0.01781291f, -0.14865752f, -0.08324371f, -0.07850874f, 0.00571622f, 0.05595578f, 0.08468856f, 0.03541330f, 
    -0.05541607f, 0.04824568f, -0.09017940f, -0.02059891f, 0.16098748f, 0.09960882f, 0.12978145f, 0.08115163f, 
    0.04978080f, -0.04626134f, -0.03645853f, -0.01871813f, -0.02146866f, -0.12728764f, 0.13541281f, -0.01872225f, 
    0.04256220f, -0.07267957f, 0.00252414f, 0.03351723f, -0.03667695f, -0.04214262f, 0.08551067f, 0.12064808f, 
    -0.16996650f, -0.02695648f, -0.06845360f, -0.26554728f, -0.21438050f, -0.03257841f, -0.18191206f, 0.14776579f, 
    -0.07100860f, -0.00038879f, -0.06115905f, -0.06840707f, -0.03126558f, 0.02459072f, 0.00647718f, 0.04363808f, 
    -0.03824259f, 0.07768596f, 0.03526022f, 0.02644787f, -0.36469710f, 0.13924700f, 0.05755907f, -0.09085939f, 
    -0.12033610f, 0.00442491f, -0.06579986f, -0.01153281f, 0.03843755f, -0.07580923f, 0.00404086f, -0.07300034f, 
    0.01587615f, 0.07600444f, -0.03579784f, -0.01040007f, 0.06408135f, -0.14484109f, 0.02198486f, 0.00998986f, 
    -0.20400968f, -0.05228541f, 0.07024942f, 0.05634571f, -0.07249261f, -0.07529677f, -0.22516151f, 0.15392052f, 
    -0.00252789f, -0.04730761f, -0.05048654f, -0.00398161f, 0.01529077f, -0.05362356f, -0.05060682f, 0.11494192f, 
    0.09338520f, 0.08715799f, 0.19380148f, 0.07453796f, 0.13897170f, 0.37854725f, 0.00208383f, 0.02311704f, 
    0.13700889f, 0.03985718f, 0.15652704f, 0.02568769f, 0.00798175f, -0.00967555f, -0.12859282f, 0.05268875f, 
    0.03505882f, 0.02455876f, -0.05690953f, 0.02762058f, 0.07428367f, 0.18879350f, 0.17279792f, 0.13038848f, 
    0.07691501f, -0.03766165f, -0.02416984f, -0.00668022f, -0.03790237f, -0.07700642f, -0.12843820f, 0.06086340f, 
    -0.05893413f, -0.00417849f, -0.13315697f, -0.01261443f, -0.10152584f, -0.07961655f, 0.06805561f, 0.06910580f, 
    0.02059805f, 0.13592733f, 0.01909492f, 0.04076421f, -0.30216607f, -0.62569404f, -0.14720644f, 0.10523022f, 
    -0.04960105f, -0.08425687f, -0.14254913f, 0.02796114f, 0.10888837f, -0.07281609f, -0.04942404f, -0.04151427f, 
    0.00986282f, -0.05895617f, 0.00523635f, -0.05644149f, -0.01632434f, 0.09142568f, -0.01972182f, -0.07441823f, 
    0.21594773f, 0.27585810f, -0.11344168f, 0.18870395f, 0.03725823f, -0.01228689f, 0.11745035f, -0.06861479f, 
    0.04229308f, -0.06321303f, -0.01835051f, 0.06241289f, -0.10114591f, -0.10140851f, -0.02711824f, -0.06702659f, 
    0.08954508f, 0.11137386f, -0.02004919f, 0.01917996f, 0.05709564f, 0.07658282f, -0.11242536f, -0.04254335f, 
    0.04498830f, -0.18630984f, -0.14362781f, 0.00941380f, 0.04256995f, 0.10467246f, -0.03285109f, -0.03870449f, 
    0.03966551f, -0.06924617f, 0.07878139f, -0.06575177f, -0.00670656f, 0.08336332f, 0.01513819f, 0.01874069f, 
    -0.36433345f, -0.42091146f, -0.24995887f, -0.18689352f, 0.07733883f, -0.13533936f, -0.00261449f, -0.08511239f, 
    0.08202540f, 0.01617715f, -0.01773469f, 0.01997551f, 0.03354255f, 0.01715010f, 0.03114542f, -0.06756878f, 
    -0.02625070f, -0.11052959f, -0.01169628f, 0.03800859f, 0.02701179f, -0.20538265f, -0.21516165f, -0.07679372f, 
    -0.26789936f, 0.06164825f, 0.07065863f, -0.05102173f, 0.02792604f, -0.04627525f, -0.01015425f, 0.02540154f, 
    -0.00298791f, -0.01110679f, 0.04368900f, 0.02228665f, -0.05031021f, -0.01266942f, 0.00329634f, 0.03375726f, 
    0.20457596f, 0.41924313f, -0.19772559f, -0.13371149f, -0.03704913f, -0.04926791f, 0.18506572f, 0.11371934f, 
    0.14320442f, 0.08001480f, 0.06519274f, -0.07401889f, -0.09512493f, -0.03195431f, -0.03519422f, -0.06787691f, 
    -0.00033548f, -0.02377394f, 0.12413029f, 0.05253476f, -0.64297807f, 0.28823039f, -0.19060875f, 0.10120922f, 
    0.28153431f, -0.00161723f, 0.15600643f, 0.01371002f, 0.00722602f, 0.01409710f, -0.09782087f, -0.02776776f, 
    0.07948563f, -0.04980272f, 0.00001716f, 0.07238641f, -0.02497362f, -0.03053952f, 0.05237745f, 0.14347227f, 
    -0.42907035f, -0.12369972f, -0.23624621f, 0.25747409f, 0.27354047f, 0.00711220f, 0.12162723f, 0.06710760f, 
    0.00311345f, -0.00044185f, -0.04690658f, 0.05570433f, 0.00889805f, -0.14317414f, -0.02009066f, -0.02618405f, 
    0.07793973f, -0.02024932f, 0.06200417f, -0.13196079f, 0.02170485f, 0.11158666f, 0.10786811f, 0.03664790f, 
    -0.02295002f, -0.02136749f, -0.10053466f, 0.02808948f, 0.00961414f, -0.05709972f, -0.05859501f, -0.00931202f, 
    -0.03329384f, 0.10310760f, 0.01714418f, 0.08270760f, 0.05122652f, 0.06755004f, -0.00592452f, -0.10382750f, 
    -0.15082051f, -0.04260486f, -0.24388589f, -0.01090109f, -0.14233260f, -0.03523428f, 0.00388896f, -0.00579516f, 
    -0.02449686f, -0.02591526f, -0.07450397f, -0.04131052f, 0.07664920f, 0.13606764f, 0.02620113f, 0.06627457f, 
    -0.10582262f, -0.00399510f, -0.07482918f, -0.01724040f, 0.04154642f, -0.06615996f, -0.09867129f, 0.08525712f, 
    0.27708620f, -0.00716048f, 0.19142020f, 0.05451924f, 0.02328394f, 0.12207697f, 0.07082231f, 0.04985240f, 
    -0.07469016f, -0.08147935f, 0.04398770f, -0.04324529f, 0.06338312f, 0.08570958f, 0.09767008f, 0.00072917f, 
    -0.59183836f, 0.47910485f, 0.10725462f, 0.19524884f, 0.03202985f, -0.00759037f, 0.02861140f, 0.02295848f, 
    0.00401589f, -0.03761931f, -0.01306081f, -0.07307997f, 0.03450375f, -0.00637455f, -0.17936708f, 0.06263620f, 
    -0.04689803f, -0.01315479f, 0.02156613f, 0.05804436f, 0.55064315f, 0.29660466f, 0.05546654f, 0.06258468f, 
    -0.06923964f, 0.17129545f, -0.02574368f, -0.05254029f, 0.12889856f, -0.05755631f, -0.04456660f, 0.01198994f, 
    -0.14748809f, 0.08528821f, 0.03782414f, -0.03645392f, -0.02894625f, -0.08405495f, -0.06202503f, 0.03618795f, 
    0.05228205f, 0.18950523f, 0.08441193f, 0.10922305f, 0.02431966f, -0.09602520f, 0.02174995f, -0.01120981f, 
    -0.07451616f, -0.08028052f, -0.05192554f, -0.03518892f, -0.06173848f, -0.05205694f, -0.04514774f, -0.06152300f, 
    -0.01121418f, 0.07517453f, 0.13444893f, -0.04961722f, -0.06285550f, 0.05294341f, 0.05168986f, 0.09289820f, 
    0.05082910f, -0.01232293f, -0.10768410f, -0.05595370f, -0.04399847f, -0.03957428f, 0.03422950f, 0.02912452f, 
    -0.01946969f, 0.00616184f, 0.01499945f, -0.00995186f, -0.03389872f, -0.02922206f, 0.00897467f, -0.02174308f, 
    0.11079025f, 0.11106727f, -0.19553621f, -0.09479396f, 0.02954359f, -0.11363792f, -0.09177206f, -0.00965386f, 
    0.06368695f, -0.01119566f, -0.01851712f, 0.00022299f, 0.08358683f, -0.05845311f, 0.06026027f, 0.01450319f, 
    -0.10559037f, 0.06120695f, -0.06462442f, 0.00263412f, 0.41437638f, -0.00515986f, 0.02344805f, 0.15806252f, 
    0.12915079f, 0.06611884f, 0.02305818f, -0.01582636f, 0.16688776f, -0.06641775f, -0.02450987f, -0.00746539f, 
    -0.00888358f, -0.05649492f, -0.09622117f, -0.13272302f, 0.07954843f, -0.06200228f, 0.07290915f, 0.03918916f, 
    -0.18387514f, -0.32853755f, -0.29047415f, 0.06632844f, -0.07327393f, -0.15263799f, -0.06113364f, -0.02395357f, 
    0.05806981f, -0.05304409f, -0.03059804f, -0.10626735f, 0.10481107f, -0.01852173f, -0.02598250f, 0.01680075f, 
    -0.01342441f, -0.00040176f, -0.00698885f, 0.12302105f, -0.00502297f, -0.12253753f, -0.04492582f, 0.01048740f, 
    -0.27443430f, 0.01490009f, -0.13003646f, -0.01813273f, -0.05827340f, -0.00940390f, -0.04975194f, 0.10835697f, 
    -0.00290379f, 0.05201487f, 0.06360722f, 0.01119009f, -0.00780743f, 0.00250313f, 0.03059276f, 0.06214525f, 
    0.30695021f, -0.15137836f, 0.09671099f, -0.19381633f, -0.11226141f, -0.01231314f, -0.07230119f, -0.10028446f, 
    0.00639030f, -0.06549548f, 0.04434206f, -0.02548105f, 0.07987021f, -0.01868987f, -0.09411704f, -0.05402019f, 
    -0.00386952f, -0.08717961f, -0.00119878f, 0.01528462f, 0.02682813f, 0.01890966f, -0.28713551f, 0.05786024f, 
    0.00607748f, 0.00817282f, -0.05788075f, 0.08292177f, -0.02573432f, 0.00497915f, -0.05703438f, -0.10876042f, 
    0.00434638f, 0.07092083f, 0.02230589f, -0.05847057f, -0.01701596f, 0.14454438f, -0.02521216f, -0.01303800f, 
    0.12288742f, 0.11097880f, 0.10634866f, 0.07502515f, 0.04094217f, 0.03926405f, -0.04481887f, -0.10343068f, 
    0.01141190f, -0.12667547f, -0.04031178f, -0.01988932f, -0.02722083f, 0.06251112f, 0.13412875f, 0.01439842f, 
    0.10702829f, -0.03571162f, -0.04721664f, -0.02199259f, 0.14614695f, -0.09107406f, 0.18990611f, 0.04434316f, 
    -0.07398410f, 0.00866410f, 0.10923415f, 0.00275192f, -0.08930700f, 0.09196644f, -0.03903508f, 0.09779419f, 
    -0.05018247f, 0.10838691f, -0.02669360f, 0.06577950f, -0.03216374f, -0.00677572f, 0.01020314f, 0.02577425f, 
    -0.10113622f, 0.08357456f, 0.04976111f, -0.01003074f, -0.06856030f, -0.03199856f, -0.13204500f, -0.09498993f, 
    -0.00365197f, 0.04302302f, 0.02715177f, 0.02134229f, -0.06255481f, 0.03883819f, 0.07186824f, 0.05039418f, 
    0.04723542f, -0.02474231f, 0.06681365f, -0.08470823f, -0.16863152f, -0.58920157f, -0.47643036f, 0.22662485f, 
    0.15559450f, -0.00141086f, 0.03124402f, 0.01216940f, -0.03118238f, -0.07088784f, -0.03189957f, 0.03767603f, 
    -0.06074326f, -0.10745248f, 0.02627062f, 0.00970531f, -0.05978329f, 0.05163105f, -0.03134597f, -0.08083366f, 
    -0.00828907f, 0.05893527f, 0.02762248f, -0.08149234f, -0.06192291f, 0.06238875f, -0.08709619f, -0.07272642f, 
    0.07983927f, 0.01949553f, 0.02366018f, 0.01364649f, 0.10888670f, 0.02031921f, -0.11330787f, 0.07751138f, 
    0.08132402f, -0.07852726f, 0.00591983f, -0.01039674f, 0.07439944f, 0.00286556f, -0.31859025f, 0.18568635f, 
    -0.26079240f, -0.17390665f, -0.06030795f, -0.00393414f, -0.18334568f, -0.11689212f, -0.06084067f, 0.12120613f, 
    0.09431960f, 0.00928449f, -0.02320303f, -0.18042076f, 0.04321798f, 0.11103392f, -0.09112244f, -0.18516019f, 
    -0.17150733f, -0.23264375f, -0.16969237f, 0.17205437f, 0.24285211f, 0.10005593f, 0.08488759f, 0.10810785f, 
    0.01376299f, 0.04441336f, 0.02700339f, -0.02966175f, 0.14718103f, 0.02619014f, 0.02199352f, -0.00858512f, 
    0.01349317f, 0.03357416f, 0.03431834f, -0.09180965f, 0.21763979f, 0.40150979f, -0.27212840f, -0.18688785f, 
    0.00604905f, 0.11164102f, -0.07667623f, 0.17480533f, 0.11122193f, 0.00885536f, -0.03215983f, 0.01867093f, 
    -0.08744309f, -0.01564059f, -0.02543022f, 0.07033851f, 0.11625662f, -0.17739613f, -0.07244415f, -0.04790584f, 
    -0.87492961f, -0.33935231f, -0.00157391f, 0.16112497f, 0.26738766f, -0.00819857f, 0.03441242f, -0.04163722f, 
    0.03951409f, 0.03870994f, -0.08344955f, -0.13888524f, 0.19922309f, 0.06053968f, 0.08874853f, -0.17961460f, 
    0.27745971f, 0.16976802f, 0.14905690f, -0.08837567f, 0.12384606f, -0.01080369f, 0.32473481f, 0.11445944f, 
    -0.12586994f, 0.12618072f, 0.14950408f, 0.01319122f, -0.05480789f, -0.17062852f, 0.11985578f, 0.06020333f, 
    0.03860107f, 0.05352569f, 0.00883278f, 0.00045269f, 0.03025661f, 0.02277878f, 0.05621034f, 0.03939967f, 
    0.05068847f, -0.00791373f, -0.10554635f, 0.10753818f, 0.08910345f, 0.14994010f, -0.03004301f, -0.00645077f, 
    0.07183304f, 0.02882563f, 0.06342331f, 0.03535632f, -0.03253094f, -0.07967476f, 0.01903025f, -0.05332227f, 
    -0.08918967f, 0.05327484f, 0.12201960f, -0.02000239f, -0.29917583f, -0.03422407f, -0.01333493f, -0.06167424f, 
    0.19442531f, 0.01368367f, -0.07482058f, -0.12721287f, 0.17924510f, 0.10454705f, 0.00898622f, -0.10265337f, 
    0.05622033f, -0.00353989f, -0.00654473f, 0.10947423f, -0.00231147f, -0.08280692f, 0.04319330f, 0.03122658f, 
    -0.17282715f, 0.15322188f, -0.03679270f, 0.20950641f, -0.33250093f, -0.17745717f, 0.03082333f, -0.02061827f, 
    -0.10107548f, -0.05436964f, 0.04135551f, -0.21408708f, 0.00498107f, 0.09874643f, 0.09795462f, -0.22805068f, 
    -0.00197113f, 0.06379157f, -0.13290051f, 0.05599105f, -0.09840410f, -0.16828258f, -0.22398868f, 0.06760674f, 
    0.13433973f, 0.09979450f, 0.07674117f, 0.06169477f, 0.17354444f, 0.13874181f, 0.12419597f, -0.02245346f, 
    0.09078581f, -0.03111758f, 0.02858404f, 0.09839160f, 0.05735495f, -0.00747061f, 0.10989635f, 0.12140005f, 
    0.10237850f, -0.15690473f, 0.16562653f, -0.11835460f, -0.07148575f, -0.04407712f, 0.03140448f, -0.00772042f, 
    0.05066349f, 0.09789784f, 0.07192063f, -0.03235741f, -0.03549289f, -0.11423694f, 0.05582873f, 0.00783005f, 
    -0.05763816f, -0.13072376f, 0.02961955f, 0.01197078f, -0.67737567f, 0.20230263f, -0.09372961f, 0.00397823f, 
    0.01135438f, 0.11397697f, -0.10238270f, -0.07512120f, 0.00685103f, -0.05461233f, 0.03709822f, -0.05886413f, 
    -0.04237517f, 0.15549260f, 0.01182780f, 0.05143600f, -0.06236508f, 0.04074078f, -0.06013768f, 0.02336807f, 
    0.18009143f, -0.24895845f, -0.42323971f, 0.02828113f, -0.18693058f, 0.09776284f, -0.03665414f, 0.14445043f, 
    -0.04552249f, -0.06403485f, -0.12173546f, 0.05025188f, 0.10519482f, -0.03860304f, -0.15326980f, 0.09666053f, 
    0.00332467f, 0.00360106f, -0.01928477f, 0.09830768f, -0.48291010f, -0.03059357f, 0.29447603f, 0.26769665f, 
    -0.01277404f, -0.08908716f, -0.13529782f, 0.06445108f, -0.07237522f, -0.00305297f, 0.09910464f, -0.02305461f, 
    0.02760579f, -0.10373329f, -0.00173477f, -0.07343852f, 0.03077247f, -0.11242514f, -0.00654688f, -0.04344827f, 
    -0.37773216f, -0.42701256f, 0.22603846f, 0.24034889f, 0.09503069f, -0.05791787f, -0.00816292f, 0.05880824f, 
    -0.07614225f, 0.04587530f, 0.01395282f, 0.06111357f, -0.10209595f, -0.11446681f, 0.00691492f, 0.00492224f, 
    -0.08444263f, 0.03198753f, 0.04422863f, 0.00457741f, -0.27566004f, -0.07908362f, -0.00599836f, 0.05210787f, 
    0.09696303f, -0.01790252f, 0.03349422f, -0.01481659f, 0.03764386f, 0.10122149f, 0.00854599f, -0.09293979f, 
    0.02558212f, 0.08293253f, -0.02015984f, -0.02935367f, 0.11460260f, -0.11717074f, 0.01685552f, -0.03944533f, 
    -0.13925643f, 0.19477321f, 0.06399541f, 0.06391888f, -0.11874039f, 0.07365137f, -0.10547292f, 0.05363796f, 
    -0.14460699f, -0.06765903f, 0.04276199f, -0.03622450f, -0.08572524f, -0.00488854f, 0.09551158f, -0.02134367f, 
    -0.05346494f, 0.01784139f, -0.09720568f, -0.04683056f, -0.02645233f, -0.26692849f, -0.11217308f, 0.17315254f, 
    -0.15033995f, -0.18292731f, -0.05743147f, 0.17384243f, -0.16695802f, -0.03188978f, -0.00053678f, -0.02174130f, 
    -0.03682207f, -0.15307398f, 0.15572168f, 0.07612230f, -0.04024258f, 0.19813690f, -0.09200983f, 0.10292593f, 
    -0.47959593f, -0.14238858f, 0.00108510f, -0.11897253f, -0.03539091f, 0.10662702f, -0.04137769f, -0.12663378f, 
    -0.08430184f, -0.04619624f, -0.10055698f, -0.04744549f, -0.08370132f, -0.01053178f, -0.02199590f, 0.06442200f, 
    -0.00165371f, -0.04950559f, 0.04798109f, -0.04626805f, -0.10113053f, 0.13186930f, 0.13647786f, -0.29984888f, 
    -0.16191691f, 0.05713873f, 0.14501919f, -0.04761390f, 0.03513400f, 0.05055711f, 0.05342589f, -0.10863364f, 
    0.02000983f, -0.00891672f, 0.15185148f, -0.15883042f, 0.05057662f, -0.02408877f, -0.00721920f, 0.08430462f, 
    0.02739293f, -0.00718151f, -0.11444523f, 0.06979483f, 0.12594962f, 0.08300807f, 0.12328645f, -0.03280927f, 
    0.11666435f, -0.01133170f, 0.10235880f, 0.09492983f, 0.00338143f, -0.01237875f, 0.03949936f, 0.01538349f, 
    0.03415814f, -0.00517137f, 0.01744246f, 0.12353031f, -0.22019450f, 0.23466003f, 0.14103431f, -0.08387772f, 
    -0.08738723f, 0.00961458f, -0.04936684f, -0.05185380f, 0.03694274f, -0.13429378f, 0.00124775f, 0.15240045f, 
    -0.16180292f, 0.09474864f, 0.02136927f, -0.01372009f, -0.05000479f, -0.02049718f, 0.02402651f, -0.04180628f, 
    -0.25219154f, 0.04541365f, -0.03851163f, -0.01740627f, 0.03039443f, 0.07260736f, 0.07664514f, 0.04595595f, 
    0.11305318f, 0.01657739f, 0.11794807f, 0.09305222f, -0.07682893f, -0.02515425f, -0.02943603f, 0.09505939f, 
    -0.02662830f, 0.00802904f, 0.04135770f, 0.12078521f, -0.11243622f, 0.42620179f, 0.02951824f, -0.20086890f, 
    -0.08431619f, -0.08915434f, -0.00914024f, -0.02534672f, 0.01184701f, -0.07473318f, 0.02426798f, 0.11852033f, 
    -0.06438951f, 0.07188012f, 0.05212004f, 0.08523037f, 0.13366111f, 0.08003593f, 0.04908199f, -0.00925141f, 
    -0.02725204f, 0.17654891f, 0.11914973f, -0.09376916f, -0.04172421f, -0.00728826f, -0.01264179f, 0.00500196f, 
    0.08908920f, 0.12067743f, 0.04256129f, 0.03688754f, 0.03249869f, -0.01723044f, 0.03221187f, 0.10800340f, 
    0.01797245f, 0.01612386f, -0.01066712f, 0.07298514f, -0.66663057f, 0.19348523f, 0.14594367f, 0.13754913f, 
    0.11414880f, 0.07381533f, -0.09553777f, 0.03277346f, -0.10287317f, 0.18929274f, -0.09197216f, -0.00365258f, 
    0.04930551f, 0.05041375f, 0.00742544f, 0.07897961f, -0.02909677f, 0.07051360f, 0.04052268f, -0.18141064f, 
    -0.19273579f, 0.07593597f, -0.14147478f, -0.11978833f, 0.23615818f, -0.02277302f, 0.02422272f, -0.04535201f, 
    0.11910327f, 0.01061661f, -0.01398853f, -0.05327127f, -0.05625941f, -0.00917222f, 0.04252947f, 0.01798003f, 
    -0.02658152f, -0.12587154f, 0.03646716f, 0.01410313f, -0.35552004f, -0.06180998f, -0.05891302f, 0.13391076f, 
    -0.09332345f, -0.01388853f, -0.06184331f, 0.13032536f, -0.02903875f, 0.01781144f, -0.09082549f, 0.00184404f, 
    0.08274882f, 0.17512177f, -0.01181151f, -0.12671703f, 0.09569646f, 0.09092419f, 0.07009059f, 0.00947030f, 
    -0.64097589f, 0.11267668f, -0.01285469f, -0.17266098f, 0.04964202f, 0.04432049f, -0.01998325f, -0.02713558f, 
    0.08310524f, 0.04281507f, -0.04147968f, 0.01701956f, 0.16179770f, 0.01629628f, -0.06564178f, 0.05553337f, 
    0.07465912f, 0.04671790f, 0.06471028f, -0.16752708f, 0.33339298f, 0.28216156f, 0.10010514f, 0.04960217f, 
    -0.34578776f, 0.00481363f, -0.05140740f, -0.00378342f, 0.06206419f, -0.07699720f, -0.15482640f, -0.03273014f, 
    -0.00253135f, 0.01517552f, 0.05866909f, -0.07889508f, -0.05633692f, 0.02894896f, 0.06866788f, -0.02859416f, 
    -0.10062592f, 0.12625661f, 0.13559431f, 0.05350576f, 0.15551545f, 0.09032344f, -0.00557444f, 0.09300280f, 
    -0.00814861f, 0.07415796f, -0.06414477f, 0.08722313f, -0.03202020f, 0.00723535f, -0.03531509f, -0.05453937f, 
    -0.04735877f, 0.06525840f, 0.05836767f, -0.09494295f, 0.03700370f, -0.18127921f, 0.10919485f, -0.09197001f, 
    0.13970579f, 0.04434587f, 0.02039340f, -0.20358011f, -0.12017721f, 0.02920130f, 0.11096832f, 0.01430062f, 
    -0.03572208f, -0.01826426f, -0.11059440f, -0.09458622f, -0.03909755f, -0.11079331f, -0.08175423f, -0.03811385f, 
    0.19938706f, 0.09170990f, 0.30382854f, 0.06271621f, 0.09124476f, 0.11478432f, 0.02715839f, -0.01934512f, 
    -0.05190288f, 0.02278056f, 0.04000710f, -0.04364619f, -0.08581112f, 0.11893386f, 0.05492907f, 0.07442983f, 
    -0.11457292f, 0.04854628f, -0.00115634f, 0.09533887f, -0.07382253f, 0.00276468f, 0.08101668f, 0.04426270f, 
    0.11490760f, -0.13671879f, -0.16896391f, 0.06729999f, -0.02385310f, 0.07007769f, -0.04313159f, -0.34843230f, 
    -0.08528856f, 0.01761069f, 0.07566132f, 0.09072356f, 0.06696259f, -0.16912450f, -0.12047423f, 0.09196797f, 
    -0.28059840f, 0.27149010f, 0.00733953f, -0.13221854f, -0.05825574f, 0.12259641f, -0.08034004f, 0.16710602f, 
    -0.09844804f, -0.07442182f, 0.14867815f, -0.00516171f, -0.07372949f, -0.03718475f, 0.04277715f, 0.06626201f, 
    0.08243251f, 0.04684821f, -0.01646507f, 0.05609133f, -0.34094065f, -0.14377111f, 0.12924509f, 0.21913581f, 
    -0.56596595f, 0.04868391f, -0.02459802f, -0.14705713f, -0.04193055f, 0.04346306f, 0.06892859f, 0.04632583f, 
    -0.02121300f, 0.00673633f, -0.02193313f, -0.12065253f, 0.02848815f, 0.22361478f, 0.02908220f, 0.01349051f, 
    -0.10804626f, 0.30446786f, -0.31934214f, -0.09697405f, -0.08288973f, 0.08120959f, 0.09982573f, 0.16019747f, 
    -0.09519710f, -0.02737447f, 0.02991860f, -0.04439352f, -0.18942234f, -0.02127135f, -0.04421104f, -0.00952366f, 
    -0.12254592f, -0.02935988f, -0.07002995f, -0.06978632f, 0.21072872f, 0.02645155f, 0.10522109f, 0.39129251f, 
    -0.04940757f, -0.01960976f, -0.11197380f, 0.03079692f, -0.08963722f, 0.09690750f, -0.03815322f, -0.02102759f, 
    -0.03426786f, 0.12336425f, 0.08205462f, -0.05626379f, -0.07542232f, -0.18554275f, -0.14836271f, -0.11240639f, 
    -0.56644714f, -0.22757088f, -0.26947248f, -0.07525481f, 0.18010168f, 0.09703849f, 0.07411030f, -0.14378285f, 
    -0.02659203f, -0.13707413f, -0.01814854f, 0.04830336f, -0.05080710f, 0.09629950f, -0.03269274f, -0.01185644f, 
    0.07265937f, -0.10046770f, -0.25997689f, 0.04958105f, 0.12335473f, -0.01760522f, 0.11638764f, 0.25239062f, 
    -0.05313069f, 0.09022970f, 0.18923666f, 0.03273236f, 0.00858345f, 0.09413797f, 0.02098626f, -0.03202599f, 
    -0.01266432f, -0.07441349f, 0.09941150f, 0.05699174f, 0.15952589f, 0.07640138f, 0.07607393f, -0.00822066f, 
    0.01998935f, -0.13791290f, -0.05912821f, 0.21490161f, 0.17147431f, -0.04606503f, -0.01854372f, -0.04208601f, 
    0.12763019f, 0.07142211f, 0.08833085f, 0.01688829f, 0.08541770f, -0.04568432f, 0.00368015f, -0.00007501f, 
    0.06310254f, -0.25215587f, 0.13818705f, -0.03491535f, -0.26054457f, 0.15118700f, -0.06300784f, -0.21448982f, 
    0.02619092f, 0.12039296f, 0.16660573f, 0.20798048f, -0.14610171f, 0.03732329f, -0.08582320f, 0.13063738f, 
    -0.06607968f, -0.07277869f, 0.03652622f, 0.06018523f, 0.09886328f, 0.01104359f, -0.04193494f, -0.09185919f, 
    0.10504995f, 0.07333990f, 0.02564085f, 0.04942825f, 0.02296461f, 0.10690433f, -0.02475019f, -0.10667288f, 
    -0.13514267f, 0.07557150f, -0.09744786f, 0.06629528f, 0.06553142f, -0.06695232f, -0.01128320f, 0.01082905f, 
    0.01703697f, 0.14843690f, 0.22655703f, 0.05879932f, -0.25363073f, 0.35731548f, -0.03610634f, 0.06688445f, 
    -0.07179719f, -0.11015795f, -0.08785466f, 0.00432683f, -0.09715407f, -0.08688179f, -0.02409541f, 0.05587509f, 
    -0.03322156f, -0.06362358f, 0.01833284f, -0.05499960f, -0.01330828f, 0.10288741f, 0.10100651f, 0.06462146f, 
    -0.22312962f, 0.34079832f, 0.15763102f, 0.28601217f, -0.23696677f, 0.02147680f, -0.09230749f, -0.16539501f, 
    -0.00955556f, 0.25597832f, -0.04060494f, -0.09697746f, -0.08762521f, 0.09575703f, -0.10849126f, 0.04435927f, 
    -0.02502832f, -0.12714535f, 0.06897631f, -0.03581848f, 0.13175027f, -0.01591180f, 0.02676155f, -0.00954419f, 
    -0.04389253f, -0.14793566f, -0.01196309f, 0.10298437f, 0.00287967f, 0.14202896f, -0.04483920f, -0.00022188f, 
    0.16330574f, 0.05416048f, 0.11142398f, -0.12703741f, -0.17607610f, -0.00692702f, 0.10416722f, 0.04427044f, 
    0.14520368f, 0.03830048f, 0.00448845f, 0.06930388f, -0.01455678f, -0.25468564f, 0.04691751f, -0.01291419f, 
    0.14694993f, 0.07428718f, -0.07173923f, -0.11308507f, 0.09777093f, 0.07471003f, 0.23213555f, -0.04659796f, 
    0.14510036f, 0.03014412f, -0.05263162f, 0.04860007f, 0.02151052f, -0.14822732f, -0.29719627f, -0.06474704f, 
    0.00614202f, 0.21326162f, 0.07195768f, 0.01840052f, 0.04241581f, -0.01626924f, 0.03303935f, 0.05246757f, 
    0.11719772f, -0.11715353f, -0.08108287f, -0.00689618f, -0.18095618f, 0.10908134f, -0.01505524f, 0.05424805f, 
    -0.13000132f, 0.04315801f, 0.06800631f, 0.01221762f, 0.09327325f, 0.06910474f, -0.01321966f, 0.08409624f, 
    -0.01917220f, 0.01871162f, 0.12176505f, -0.11183768f, 0.02411124f, 0.02718116f, 0.04589214f, 0.04392492f, 
    0.08635727f, -0.10338479f, 0.07023663f, -0.08255585f, 0.12218124f, 0.08831866f, 0.10295581f, 0.22398362f, 
    0.06619062f, -0.06341770f, -0.02811559f, -0.20683056f, 0.05798905f, 0.01848845f, 0.00900333f, -0.10930867f, 
    -0.16234036f, 0.22947790f, 0.09521330f, 0.04211621f, 0.02898539f, -0.08276733f, -0.01308393f, -0.05499700f, 
    -0.06785109f, -0.04829653f, -0.00414842f, 0.00703729f, 0.01825014f, 0.04890688f, -0.01293216f, 0.04863664f, 
    0.07754523f, -0.08692937f, -0.05525988f, -0.00866541f, 0.01266825f, 0.06300570f, 0.21256167f, -0.05380885f, 
    0.03132324f, -0.05981504f, -0.22640245f, -0.05668486f, -0.41333392f, -0.11860920f, 0.01719807f, 0.07825399f, 
    -0.05876675f, -0.24687506f, -0.00258737f, 0.15966970f, -0.23176458f, 0.06440068f, -0.07949327f, 0.01202965f, 
    0.07080688f, -0.10801508f, -0.11463380f, -0.10537952f, 0.03620140f, -0.10036364f, 0.03436828f, 0.08307002f, 
    -0.01392867f, -0.09685604f, -0.29174384f, 0.18121888f, 0.22009329f, 0.04485930f, 0.02070734f, -0.09966510f, 
    -0.08490790f, 0.16963412f, 0.08440153f, 0.01211650f, 0.03399228f, 0.14665462f, 0.09925561f, -0.01767804f, 
    0.05031027f, 0.18414664f, -0.21906789f, 0.03147072f, -0.43582690f, 0.14445062f, -0.27497172f, -0.08148882f, 
    0.24517973f, 0.17796509f, 0.10200372f, 0.01096900f, -0.01772428f, -0.03795246f, -0.01947235f, 0.01182674f, 
    0.07558896f, -0.13648739f, 0.03536617f, -0.03743661f, 0.10028359f, -0.06446332f, 0.04283338f, -0.00335804f, 
    -0.60439789f, -0.17005345f, -0.18618128f, -0.18804783f, -0.08196857f, 0.04578269f, 0.20033304f, -0.02890357f, 
    -0.06085558f, -0.01943732f, -0.07468078f, 0.11284483f, 0.12417146f, -0.05155734f, 0.00275883f, -0.04210388f, 
    0.01208649f, -0.08210142f, 0.06883340f, -0.15891659f, -0.20071484f, -0.19684711f, 0.09096880f, 0.19646882f, 
    -0.25749964f, 0.05707054f, -0.05793823f, -0.12623319f, -0.02243504f, -0.19609497f, -0.08802895f, 0.05779144f, 
    0.00210373f, -0.00776193f, 0.20946850f, -0.05354532f, 0.01264960f, 0.05817408f, 0.06661028f, -0.09326341f, 
    0.07602935f, -0.11416257f, 0.06420889f, 0.13755468f, -0.03282344f, -0.02176732f, 0.04139857f, -0.01040018f, 
    -0.05309911f, -0.09081043f, -0.03664279f, 0.10614371f, 0.06807484f, 0.04208427f, 0.04473881f, -0.06923710f, 
    -0.01216369f, 0.09693588f, 0.08091668f, -0.06655657f, -0.46347478f, 0.12060867f, -0.18450461f, -0.07651159f, 
    0.00602681f, 0.09445054f, -0.01013948f, 0.00901169f, -0.00628925f, -0.23317483f, 0.02267154f, 0.02069665f, 
    -0.07922170f, -0.07895511f, 0.04468444f, -0.07957391f, 0.08156403f, 0.04283663f, 0.13074198f, 0.07242421f, 
    -0.57301199f, -0.02406755f, -0.16276497f, 0.10785567f, -0.17735238f, 0.02390565f, -0.02004230f, 0.12043095f, 
    -0.04220343f, -0.05799010f, 0.06350788f, 0.04525007f, 0.04124258f, 0.00529916f, -0.07212878f, 0.05975564f, 
    -0.00976617f, 0.07243235f, -0.03309086f, -0.04270406f, 0.06988757f, 0.28573540f, -0.10220069f, -0.20138800f, 
    -0.05247569f, 0.00399718f, 0.00730523f, 0.06369486f, 0.06426378f, -0.12679473f, 0.14491379f, -0.03149361f, 
    0.05265688f, -0.12076952f, 0.02244766f, 0.04202862f, 0.01085381f, -0.13309756f, 0.04796823f, 0.02530039f, 
    -0.26909599f, 0.13759467f, -0.00613194f, -0.05269640f, -0.21024352f, 0.08365765f, -0.01320114f, -0.02582690f, 
    -0.03113894f, -0.12524648f, 0.02405946f, -0.01307146f, -0.10915282f, -0.11753755f, -0.10732614f, -0.00151966f, 
    -0.11839885f, 0.07340910f, 0.05780590f, 0.00203737f, -0.02605569f, -0.14124586f, -0.11910495f, -0.05661054f, 
    0.16795838f, 0.02236699f, -0.01475441f, 0.04830750f, -0.12257151f, 0.03621772f, 0.12924992f, 0.08423572f, 
    0.07138848f, -0.04252182f, 0.02204390f, -0.11915966f, 0.02609556f, -0.02601033f, -0.12272257f, -0.09251770f, 
    -0.35532975f, -0.22610910f, -0.29617923f, -0.10320732f, 0.00420977f, 0.11206364f, -0.00525026f, -0.02256545f, 
    0.02806688f, -0.03514013f, 0.11846848f, 0.06332090f, 0.06124790f, 0.10517184f, -0.05089293f, -0.03207209f, 
    0.00424915f, -0.01357031f, -0.07140309f, 0.19177166f, -0.04581381f, -0.04887547f, 0.00349696f, 0.25642186f, 
    0.04224546f, -0.00546956f, 0.03524926f, -0.06363380f, 0.06344409f, -0.04675883f, 0.08987135f, -0.07819515f, 
    -0.01317858f, -0.02535461f, 0.02810886f, 0.04776409f, -0.01458733f, 0.16493841f, -0.04442749f, -0.07281005f, 
    -0.43074498f, 0.16562338f, 0.03536278f, 0.20780692f, -0.00841249f, -0.20255262f, 0.03825228f, 0.07486432f, 
    0.09531220f, 0.14885963f, -0.17755367f, 0.01449950f, 0.06374437f, -0.15162061f, 0.19207351f, -0.01364731f, 
    0.08504006f, -0.18958364f, -0.06625708f, -0.22129083f, 0.12048303f, -0.03161241f, 0.10064657f, -0.17469952f, 
    0.13611573f, 0.10675424f, 0.06083363f, -0.08779886f, 0.01274293f, 0.14171207f, 0.02166690f, 0.07360484f, 
    0.06175717f, -0.02994465f, -0.19789451f, -0.07874709f, 0.20143010f, 0.08625431f, 0.12976675f, -0.17520700f, 
    0.00107773f, -0.39465871f, -0.12373172f, 0.03004617f, -0.05739962f, -0.11930214f, 0.02620586f, -0.03838004f, 
    0.06639880f, 0.03505800f, -0.03720815f, 0.09853522f, 0.07072518f, 0.13516000f, 0.08302938f, -0.13541195f, 
    -0.02902894f, -0.08996738f, -0.00528866f, -0.05453846f, 0.41400015f, -0.27388284f, 0.05099495f, 0.05966648f, 
    0.19719285f, -0.06038963f, -0.09093532f, 0.02229685f, 0.04539903f, 0.10487278f, 0.01822775f, 0.03054652f, 
    -0.16577297f, -0.17590180f, 0.02683574f, -0.13039924f, -0.00415799f, 0.03409100f, 0.06528760f, -0.07399952f, 
    0.22352090f, -0.51822615f, -0.11556691f, -0.42907330f, -0.12812212f, 0.04704379f, 0.04441568f, 0.11031493f, 
    -0.00188842f, -0.22365548f, -0.15501864f, 0.00722926f, 0.25314537f, 0.11385825f, -0.08616620f, 0.10430628f, 
    0.00209807f, -0.00266451f, -0.13224702f, 0.13301665f, -0.14114615f, -0.02798090f, 0.03742922f, -0.15524377f, 
    0.27350697f, 0.01437621f, 0.04325408f, 0.05437379f, -0.05461960f, 0.00404096f, -0.16554710f, 0.08041601f, 
    -0.05135907f, -0.09063081f, -0.08711296f, 0.10211459f, -0.00839978f, 0.16348265f, 0.28586596f, 0.03956671f, 
    -0.41168681f, 0.04197589f, 0.02446414f, -0.38635641f, 0.18083146f, -0.05437125f, 0.03645607f, 0.15166901f, 
    -0.18000211f, 0.07253922f, 0.03599507f, -0.11728191f, 0.03071509f, 0.03991947f, -0.00905773f, -0.02753546f, 
    0.02079755f, -0.07654803f, 0.15031466f, 0.10196800f, -0.14884424f, 0.35604322f, -0.11366789f, 0.27403465f, 
    -0.23734473f, -0.12426180f, -0.11166634f, -0.00941704f, 0.03256856f, 0.01109891f, 0.07316018f, 0.08954769f, 
    0.00615870f, -0.04405861f, -0.03136415f, -0.06119401f, -0.05060825f, -0.10239659f, -0.20771423f, -0.17910770f, 
    0.01274801f, -0.21992739f, -0.44843453f, -0.07258067f, 0.06462093f, -0.05445717f, 0.01413452f, -0.00552998f, 
    -0.13391693f, 0.11655825f, 0.06372158f, 0.00508249f, -0.12158027f, 0.01177106f, -0.10100369f, -0.04075614f, 
    0.00405557f, 0.29084212f, -0.05802054f, 0.13352807f, -0.29973900f, 0.05838615f, 0.14042856f, -0.39780498f, 
    0.10904965f, -0.23571992f, -0.20479599f, -0.22927205f, 0.09199934f, -0.12484902f, 0.00434891f, 0.00547732f, 
    0.08149228f, 0.10523178f, -0.00772729f, 0.06039445f, 0.00129488f, -0.07494304f, -0.00004698f, -0.03883668f, 
    -0.42392930f, 0.25710231f, -0.00578701f, 0.10075694f, -0.12765703f, 0.08897978f, -0.05014603f, 0.03651791f, 
    0.16233751f, -0.06282394f, 0.03836778f, 0.01308681f, 0.06737809f, 0.01148377f, -0.12680587f, -0.03113583f, 
    0.05534307f, -0.16202366f, -0.05609060f, -0.03921800f, 0.12477829f, -0.44374263f, -0.08041568f, -0.07561295f, 
    0.44373322f, 0.03100910f, 0.03796286f, 0.00502627f, 0.11169349f, 0.08816351f, -0.08155393f, -0.02736722f, 
    0.12228504f, 0.09047653f, 0.12424538f, 0.01136711f, 0.00251978f, -0.07152693f, -0.12890254f, -0.03335091f, 
    -0.34696668f, 0.20297977f, -0.01043304f, 0.31300774f, -0.26640493f, 0.01699680f, -0.16527192f, -0.01559974f, 
    -0.03699962f, -0.12444980f, 0.07304459f, 0.01721622f, 0.05666275f, 0.05514441f, 0.02840955f, 0.01969155f, 
    -0.05081561f, 0.02938101f, 0.02875184f, -0.04811050f, -0.00374439f, 0.19202082f, 0.30295134f, -0.02873270f, 
    -0.35252652f, 0.15974101f, -0.00209286f, 0.04894538f, 0.05563113f, -0.08715928f, -0.07422039f, 0.01174484f, 
    0.00428274f, 0.10876729f, -0.04819446f, 0.14079507f, 0.01576077f, 0.03517221f, 0.12813962f, -0.09449579f, 
    -0.03582083f, 0.24575698f, 0.17587774f, -0.06144168f, -0.27483791f, 0.08174437f, -0.01630568f, 0.01948908f, 
    0.00288674f, -0.03252178f, 0.03378658f, 0.09759799f, -0.10914622f, -0.03365857f, -0.15066957f, 0.07628801f, 
    -0.04051450f, -0.11938462f, 0.04843567f, -0.07702847f, 0.02033129f, -0.20567001f, -0.05357885f, -0.16151010f, 
    -0.01311571f, 0.01658989f, -0.06061603f, 0.11424834f, -0.11385879f, -0.04389795f, 0.04037907f, -0.06895220f, 
    -0.01624127f, 0.03033700f, 0.09577661f, -0.00161341f, 0.05971955f, -0.10152609f, 0.10904107f, -0.08391871f, 
    -0.07369793f, -0.23157480f, -0.09214280f, -0.08593870f, 0.20826484f, -0.03674761f, 0.03255050f, -0.00456725f, 
    0.15531401f, 0.05386644f, -0.06959633f, 0.03897037f, -0.00772750f, 0.03650415f, 0.03365235f, -0.17756893f, 
    0.07736125f, 0.01174835f, -0.12458636f, 0.03664222f, -0.28771102f, 0.22946690f, 0.00686155f, 0.11849525f, 
    -0.26211309f, 0.11182310f, 0.04459553f, 0.03424330f, -0.12881958f, 0.04449364f, 0.04684039f, 0.07189154f, 
    0.02571231f, -0.10046276f, -0.14497051f, 0.07449850f, -0.06172253f, 0.08754124f, 0.05496260f, 0.16822879f, 
    0.33310702f, 0.01198292f, -0.08434232f, -0.01974636f, 0.00443719f, 0.01746419f, 0.10730873f, -0.04307100f, 
    -0.18475562f, -0.06517041f, -0.01246975f, 0.01779827f, 0.10625798f, -0.06073913f, -0.02496092f, 0.02076361f, 
    -0.13126339f, 0.09114641f, 0.01315428f, 0.03338952f, 0.19361760f, 0.01485261f, 0.00754845f, 0.20309459f, 
    0.23161738f, -0.06291207f, 0.09462225f, -0.08514574f, 0.06472428f, -0.13256244f, -0.02736094f, 0.01660465f, 
    -0.12170342f, 0.02123196f, -0.00593396f, 0.07293453f, 0.22948931f, 0.10837175f, -0.02020277f, 0.04509043f, 
    -0.20974492f, 0.04239901f, -0.01987050f, -0.51206827f, 0.02819264f, 0.03282145f, -0.01940206f, 0.02402375f, 
    -0.08332613f, -0.03300152f, -0.06072159f, -0.09139382f, -0.10684601f, -0.03395421f, 0.05670371f, -0.05168716f, 
    -0.01864355f, 0.09232966f, 0.09109134f, 0.10220865f, 0.22758313f, -0.03128297f, -0.13438946f, -0.23886684f, 
    -0.02993857f, 0.04007258f, 0.10362294f, -0.04776645f, 0.01956770f, -0.05697810f, 0.02134732f, -0.00868637f, 
    0.01008612f, -0.04898597f, -0.06596889f, 0.01992092f, -0.06440501f, 0.04132808f, -0.01333463f, 0.12098247f, 
    0.07849575f, 0.09047865f, -0.00306559f, -0.36399457f, 0.12039737f, -0.11715575f, -0.07501232f, -0.05206546f, 
    -0.13014719f, -0.13931936f, 0.05662124f, 0.01668306f, -0.06242361f, 0.05388045f, 0.04388506f, -0.03250617f, 
    0.00021605f, -0.04789063f, -0.00782457f, 0.00790747f, 0.25797060f, 0.04517730f, -0.03445258f, -0.09214504f, 
    0.06841462f, 0.09376525f, 0.01486219f, 0.12323109f, 0.09982529f, -0.00562295f, 0.09394297f, -0.03432262f, 
    0.04711769f, -0.07826241f, -0.15833741f, -0.00370452f, -0.04990633f, 0.05768076f, -0.13582315f, 0.01521480f, 
    -0.25163549f, 0.19340533f, -0.01589559f, 0.25055197f, -0.52176774f, -0.06339985f, -0.00053416f, 0.11277954f, 
    0.11514067f, 0.05387199f, -0.03746314f, -0.08086774f, 0.09461317f, -0.03590562f, 0.09529053f, -0.01226659f, 
    -0.01797284f, -0.09302619f, -0.07119839f, 0.03217957f, 0.04916390f, -0.42596766f, 0.10832040f, -0.34767136f, 
    0.17989680f, 0.10362271f, 0.02130403f, -0.05395342f, -0.03549926f, -0.05698875f, 0.01314344f, -0.03396763f, 
    0.14096656f, 0.01236820f, 0.00063140f, -0.01870592f, -0.09440187f, -0.08230923f, -0.06091183f, 0.03066660f, 
    0.04226906f, -0.49847877f, -0.11404873f, -0.01306965f, 0.00561602f, 0.02472444f, 0.03423804f, 0.03035131f, 
    -0.01939153f, -0.01979544f, -0.10862597f, 0.05246633f, 0.00750038f, -0.00782319f, 0.15431926f, -0.10096554f, 
    -0.02109610f, 0.02629309f, -0.02169083f, 0.07645597f, 0.00226849f, -0.27951336f, -0.07348126f, 0.09481870f, 
    0.09589677f, -0.13882038f, 0.16311529f, -0.10203193f, -0.00185683f, 0.07485474f, -0.11281851f, 0.04867693f, 
    0.09223016f, 0.00666036f, 0.11110992f, 0.00430273f, 0.04257701f, 0.22180964f, -0.17806575f, 0.05590344f, 
    0.57742429f, -0.16343983f, 0.09211444f, 0.18822654f, 0.11144107f, -0.04065726f, -0.04446952f, -0.01129106f, 
    -0.03211194f, 0.01598235f, 0.04546235f, -0.06194915f, 0.12908748f, -0.02241348f, 0.09387735f, 0.00231105f, 
    -0.01824891f, -0.02097118f, -0.09699099f, -0.03872445f, -0.26046368f, -0.22184640f, -0.15865523f, 0.09546661f, 
    -0.02172934f, 0.05822425f, 0.07229949f, -0.09088399f, 0.04909417f, -0.14105101f, -0.05305906f, -0.15596204f, 
    0.05851707f, 0.01535097f, -0.19677149f, 0.32482302f, 0.00333609f, 0.03560028f, 0.09357790f, 0.10249773f, 
    -0.12005456f, -0.07651057f, -0.00451254f, -0.06965014f, 0.08784567f, -0.03830347f, 0.12100749f, 0.06164918f, 
    -0.12891537f, -0.06619038f, 0.03512299f, -0.04843917f, 0.00442754f, 0.06804287f, 0.04275518f, -0.05950895f, 
    -0.02849054f, -0.03625265f, 0.03235125f, -0.04338939f, -0.22874443f, 0.26594514f, 0.02100144f, 0.07170036f, 
    0.02702527f, 0.01597201f, -0.00063208f, 0.03140453f, 0.04183084f, -0.06287033f, -0.09447540f, 0.08256246f, 
    -0.01107566f, -0.09257108f, 0.02470696f, 0.02621306f, -0.01271918f, 0.01611227f, 0.07249928f, -0.06260357f, 
    -0.08086224f, -0.00546135f, -0.07472026f, -0.17006931f, -0.16592517f, -0.06865359f, -0.06370316f, -0.02794749f, 
    -0.07283343f, -0.11951883f, 0.00590428f, -0.01250833f, 0.04664761f, -0.03115621f, -0.11294654f, -0.00990888f, 
    -0.03758389f, -0.08306614f, -0.00324105f, 0.01455225f, 0.15316436f, 0.26973057f, 0.07480811f, -0.06298253f, 
    0.18445267f, -0.02522866f, 0.15641643f, -0.13921505f, 0.01740796f, -0.00731538f, -0.06542949f, 0.00792116f, 
    -0.02131104f, 0.06741447f, -0.01059461f, 0.01636901f, -0.02360960f, 0.15957384f, -0.07624464f, 0.13143298f, 
    -0.02633614f, -0.02458035f, 0.09974679f, 0.01676589f, 0.01026509f, -0.06409939f, -0.00787653f, -0.01402580f, 
    0.05396958f, -0.04184692f, -0.03832636f, 0.01312198f, 0.05364574f, -0.00992091f, -0.07336388f, -0.01061959f, 
    -0.07376481f, 0.00931679f, 0.04134683f, -0.03793667f, 0.28359070f, -0.32957962f, 0.15524957f, 0.05006482f, 
    -0.20141979f, 0.05780911f, -0.06722830f, -0.06087643f, -0.00626585f, 0.03126442f, -0.00241956f, -0.02176681f, 
    -0.06211552f, -0.09677199f, -0.08959161f, -0.00370955f, 0.07050698f, -0.05477828f, 0.01812248f, -0.01309267f, 
    0.24325517f, 0.26768491f, 0.27247006f, 0.00752011f, 0.14099498f, 0.03824025f, 0.15611860f, -0.06449473f, 
    0.11361985f, -0.02057839f, -0.07698056f, 0.08620705f, 0.11555853f, -0.08516233f, -0.01761006f, -0.02441348f, 
    -0.11083832f, -0.04844449f, 0.08514316f, -0.05632401f, 0.03212672f, -0.03049346f, -0.00686811f, 0.05209481f, 
    0.20505729f, 0.18606314f, -0.20525219f, -0.16694114f, 0.01134991f, 0.02953213f, -0.04228952f, 0.10167573f, 
    0.04004835f, -0.09309547f, -0.07921657f, -0.06169150f, -0.05018786f, -0.06390858f, 0.01837755f, -0.03019200f, 
    0.08408073f, 0.11388645f, 0.17854735f, -0.07151666f, 0.09073427f, 0.06695761f, 0.03865322f, -0.09007786f, 
    -0.05285597f, -0.00870848f, -0.03854349f, 0.01818429f, -0.04558035f, -0.06261914f, 0.00011427f, 0.00418473f, 
    0.02076981f, -0.03837336f, 0.05959707f, -0.03405607f, -0.09606815f, -0.07208753f, 0.00321266f, -0.19858651f, 
    -0.15624751f, 0.03948951f, -0.06311901f, 0.05430404f, -0.00454530f, -0.11326118f, -0.05775390f, -0.02977950f, 
    -0.05687319f, -0.04268688f, -0.02730712f, 0.03587057f, -0.00019852f, 0.01332708f, 0.04491805f, -0.01330949f, 
    -0.13079102f, 0.20598222f, -0.33163849f, -0.00924465f, 0.02393845f, -0.05656860f, 0.03892609f, -0.21608059f, 
    -0.00489946f, 0.02867000f, -0.13198467f, 0.05514729f, -0.03885532f, -0.09802675f, 0.00389291f, 0.00791920f, 
    -0.06457108f, 0.17243816f, 0.00575746f, -0.07915153f, 0.03242989f, 0.17292897f, 0.22178844f, 0.18196230f, 
    0.17903180f, 0.17803073f, 0.12331971f, 0.08883226f, 0.05121937f, -0.05860546f, -0.08116134f, -0.02213307f, 
    -0.04059358f, 0.01864415f, -0.05647337f, -0.02314708f, -0.02879980f, 0.05605422f, 0.00215400f, -0.06733174f, 
    -0.19942939f, -0.14964147f, -0.02434541f, -0.09414295f, -0.22764830f, -0.05757754f, 0.03697378f, -0.03746243f, 
    -0.06526400f, -0.07862483f, -0.00326848f, -0.03389686f, 0.06039025f, -0.04269167f, -0.04485536f, 0.03234012f, 
    0.06319615f, -0.04335518f, -0.01791388f, 0.01490128f, -0.03402874f, -0.10554389f, 0.01697353f, -0.06329373f, 
    0.10942417f, -0.11119065f, 0.00613890f, -0.06924635f, 0.00468546f, -0.04011935f, 0.02113990f, -0.01762509f, 
    -0.10240129f, -0.02020472f, 0.08519698f, -0.00134750f, -0.05619293f, -0.02243496f, -0.03452142f, 0.02049840f, 
    -0.55817270f, 0.12816639f, 0.34042403f, 0.03415589f, -0.08324403f, 0.20138985f, -0.09988365f, -0.11986759f, 
    0.13191222f, 0.03492574f, 0.08720613f, -0.00258324f, -0.00720261f, -0.01281790f, -0.14437743f, 0.05196830f, 
    -0.05497152f, 0.02263108f, -0.05839607f, -0.08366431f, 0.19351076f, -0.60350537f, 0.05371813f, -0.10673822f, 
    -0.10117641f, -0.04803697f, -0.05682740f, -0.06084919f, 0.04590696f, -0.01909929f, -0.09232216f, -0.00605000f, 
    -0.08353650f, 0.00860340f, -0.04854273f, -0.04641937f, 0.02737223f, -0.06512053f, 0.00751927f, -0.05522454f, 
    -0.10514126f, -0.34840649f, -0.11437243f, -0.15770654f, -0.06385444f, 0.01428476f, -0.16277230f, -0.04112364f, 
    -0.04775135f, -0.08819734f, -0.05194395f, 0.03074905f, -0.00950830f, -0.05018719f, -0.10639285f, -0.12984985f, 
    0.06127235f, -0.02515228f, -0.01545230f, 0.08700693f, 0.19939010f, -0.09917247f, 0.10994527f, -0.01817619f, 
    0.06511308f, 0.01957400f, 0.05454963f, -0.02240441f, -0.06518067f, -0.02081168f, -0.02702441f, 0.07441486f, 
    -0.04572467f, -0.00331954f, -0.03384825f, -0.06169976f, -0.03000990f, -0.04413698f, -0.02323947f, -0.06520154f, 
    -0.14129201f, 0.03130531f, -0.06797070f, -0.00640041f, -0.08268216f, -0.12886874f, 0.00052574f, -0.07308212f, 
    0.00929382f, -0.03681019f, 0.01525943f, 0.06874803f, -0.16163169f, 0.00278984f, -0.06244935f, -0.03931493f, 
    0.02569711f, 0.07217639f, -0.05372399f, -0.01879223f, -0.13555661f, 0.13050379f, -0.07547582f, -0.10954975f, 
    0.10148452f, 0.05520104f, -0.17305146f, -0.18019460f, 0.03644826f, 0.01647306f, -0.01231159f, -0.01673727f, 
    0.05846832f, -0.10715591f, -0.06527141f, -0.05780569f, 0.00602058f, 0.02348908f, -0.01699332f, 0.05679756f, 
    0.29727036f, -0.13974324f, 0.20186545f, -0.00960668f, 0.10130564f, -0.01312436f, 0.06775974f, 0.01791099f, 
    0.04993152f, 0.01352967f, -0.07371603f, -0.02753931f, -0.02616140f, 0.00396412f, 0.05494804f, 0.05160955f, 
    0.06636870f, 0.03321497f, 0.01906540f, -0.11381244f, -0.28587836f, 0.06803431f, -0.00458101f, 0.12107666f, 
    -0.05540153f, 0.03010535f, -0.08334566f, 0.05641449f, 0.17281106f, 0.02191239f, -0.06938884f, 0.05255953f, 
    0.04533107f, -0.09859901f, -0.03407939f, 0.10079880f, 0.00525384f, 0.09739298f, 0.03111757f, 0.09122231f, 
    0.00661756f, 0.15832762f, 0.12621519f, 0.06608528f, 0.17373812f, 0.05019151f, 0.04787726f, -0.13394020f, 
    -0.06046471f, -0.00524466f, 0.00107162f, -0.01463594f, 0.01301394f, -0.23165053f, -0.04210337f, 0.12553628f, 
    -0.04364046f, -0.01369470f, 0.02672123f, -0.05565641f, -0.08104750f, 0.17194675f, 0.30351347f, -0.02476799f, 
    0.21165405f, 0.00482530f, 0.19514675f, -0.03335228f, 0.03517217f, 0.04201509f, -0.06997535f, 0.01060186f, 
    -0.08094078f, 0.03260694f, 0.00376234f, -0.00907800f, 0.01832073f, -0.03058308f, 0.02101807f, -0.04962765f, 
    -0.00109264f, 0.13193104f, 0.20020518f, 0.15436693f, 0.20982365f, 0.03882889f, 0.08027695f, 0.01560304f, 
    -0.02660062f, -0.06488477f, -0.07749990f, 0.00055659f, -0.12751874f, -0.04468354f, -0.04115960f, -0.03076526f, 
    0.00034080f, 0.08459715f, 0.00415757f, -0.03718067f, 0.05815598f, -0.17648804f, -0.03596504f, 0.08479180f, 
    -0.21656659f, 0.14225397f, -0.06071734f, -0.01428935f, 0.02130065f, -0.05847768f, -0.01191825f, -0.01522805f, 
    0.01433775f, -0.03269223f, -0.09524926f, 0.09506793f, 0.05056704f, 0.02475117f, 0.04072673f, -0.11260120f, 
    -0.09598150f, -0.16343759f, -0.18848202f, -0.07903801f, -0.18690366f, 0.02202103f, -0.11358051f, -0.02142801f, 
    -0.07411586f, -0.18777978f, -0.00156379f, -0.00003718f, -0.07485627f, 0.06229556f, -0.13708422f, 0.01812083f, 
    -0.10731631f, -0.07654507f, 0.01701418f, -0.09962617f, 0.30741608f, -0.19904076f, 0.25732878f, 0.00128199f, 
    0.14339203f, -0.08472738f, 0.10606186f, 0.01625274f, 0.06035357f, 0.05325472f, 0.01869589f, 0.08569428f, 
    -0.12384898f, -0.03024390f, -0.04428418f, -0.06949832f, 0.08968119f, 0.04751272f, 0.02462436f, -0.10866171f, 
    0.03216819f, -0.08817045f, 0.11928580f, 0.05331914f, 0.18516599f, 0.06330197f, 0.00086129f, -0.15263420f, 
    0.01828230f, -0.02381201f, -0.04352342f, -0.05195786f, 0.00435939f, -0.14721122f, -0.00610902f, -0.08999787f, 
    -0.08889620f, -0.04029247f, 0.03468926f, -0.04255312f, -0.24158959f, 0.21991818f, 0.16854449f, -0.01513122f, 
    0.02511692f, -0.10039323f, 0.10056815f, -0.10182343f, 0.03224654f, -0.02680786f, -0.01390413f, 0.00508648f, 
    -0.00695256f, 0.05308033f, -0.13384055f, 0.06523100f, 0.02533383f, 0.00132056f, 0.09494722f, 0.01256090f, 
    0.27700672f, -0.15511633f, 0.03226198f, -0.13958699f, 0.20541404f, -0.12780936f, 0.02176152f, -0.03219014f, 
    -0.00402969f, -0.03228419f, 0.00734322f, 0.04618053f, -0.12522165f, 0.02961117f, -0.00156201f, -0.00044021f, 
    0.03065543f, 0.01695997f, -0.04798043f, -0.04925219f, -0.06002283f, 0.13283128f, -0.00938834f, -0.01483298f, 
    0.17263982f, 0.05802839f, 0.11977018f, -0.01191606f, 0.07135838f, -0.02190243f, -0.09122945f, -0.02012393f, 
    -0.11092584f, -0.04156779f, -0.08353673f, -0.00674745f, -0.03690749f, 0.03157624f, 0.04061406f, 0.04515892f, 
    0.19280685f, -0.14521413f, 0.18386830f, 0.02423325f, -0.02770879f, 0.07146894f, 0.09863292f, -0.03549572f, 
    -0.08093422f, -0.04873038f, -0.10881883f, 0.04328153f, -0.07380222f, 0.07631877f, -0.00916814f, -0.08004124f, 
    -0.00421731f, 0.01655940f, 0.02569677f, 0.00062775f, -0.16095874f, 0.09084330f, -0.32652682f, -0.21527173f, 
    -0.13825780f, 0.04376084f, -0.05530528f, -0.05140664f, 0.02249618f, -0.05615177f, -0.12069944f, 0.05366380f, 
    -0.05867942f, -0.08063600f, 0.02615797f, 0.00517339f, -0.11585768f, -0.02140077f, -0.01108827f, 0.03977444f, 
    0.16761805f, 0.08144920f, 0.05716251f, 0.07785869f, 0.19443093f, 0.06777451f, 0.06269654f, -0.14781879f, 
    -0.11940253f, -0.03901989f, 0.02332132f, 0.07448397f, 0.00951134f, -0.06330372f, -0.03407473f, -0.11498667f, 
    -0.08103687f, 0.14283067f, 0.06890389f, 0.00804024f, -0.23822658f, 0.25324249f, -0.15681380f, -0.24958216f, 
    -0.29210666f, -0.04376658f, 0.06924526f, 0.00632689f, 0.07240649f, -0.05910731f, 0.20430295f, 0.01339107f, 
    0.00469726f, 0.17964686f, -0.01616128f, 0.00830430f, 0.05872662f, -0.05710537f, 0.10159760f, 0.17956325f, 
    0.04852225f, 0.05173098f, 0.09440176f, 0.07560956f, 0.18965212f, -0.19165646f, -0.12572463f, 0.01988808f, 
    -0.12525450f, 0.07322919f, -0.16602385f, -0.07039189f, -0.13038261f, 0.02164509f, 0.09672432f, 0.08857834f, 
    0.06941260f, 0.08196724f, -0.01281757f, 0.10980748f, 0.11753345f, -0.05311263f, 0.02406464f, 0.03299544f, 
    0.14864300f, -0.04350492f, -0.04087267f, -0.10167333f, -0.05434537f, 0.03612368f, -0.02090199f, 0.08207849f, 
    -0.00321434f, -0.08353202f, 0.02230976f, 0.04780688f, 0.01268388f, 0.04708857f, 0.03629957f, 0.04977853f, 
    0.02868398f, -0.02297307f, 0.07748303f, -0.05572668f, 0.18767194f, -0.00103120f, -0.10570424f, 0.14765173f, 
    -0.12374189f, 0.11815236f, 0.10086499f, -0.00771082f, -0.19570984f, -0.07837075f, 0.07861121f, -0.00210044f, 
    0.05908625f, -0.02705283f, -0.01585375f, -0.00734800f, -0.25831181f, 0.01052021f, -0.29563767f, -0.37879932f, 
    -0.23627196f, -0.07135886f, -0.15729161f, -0.28741154f, -0.04851516f, -0.06916726f, 0.14021531f, 0.08336854f, 
    0.09040757f, -0.08963346f, 0.07709197f, -0.12498585f, -0.01990832f, -0.14015634f, -0.12423803f, -0.00268710f, 
    -0.26685074f, -0.04615846f, 0.23946705f, -0.20136511f, -0.10728070f, -0.04941102f, -0.05639541f, 0.02411678f, 
    0.01954661f, -0.04096419f, -0.04033657f, -0.01696361f, 0.08880308f, -0.00279684f, -0.00034150f, -0.00460921f, 
    -0.00033877f, 0.01651073f, -0.27811885f, -0.02659908f, 0.18581134f, 0.10241360f, -0.13470717f, 0.06234390f, 
    0.14095391f, 0.17579091f, 0.03122241f, -0.01715431f, -0.03966083f, 0.03902005f, 0.01829793f, 0.01173457f, 
    0.00016938f, 0.03765554f, -0.12786807f, 0.01573848f, 0.03987215f, 0.11478864f, 0.05282984f, -0.00166588f, 
    -0.07308082f, 0.10398814f, -0.00414346f, -0.01769806f, -0.28240302f, -0.16403523f, 0.04178469f, -0.05441633f, 
    -0.02118219f, -0.08276578f, 0.09119718f, 0.13303781f, 0.11081272f, 0.03633337f, 0.05176463f, -0.08253343f, 
    0.09261162f, -0.31733620f, 0.08755338f, 0.02052071f, -0.27435508f, -0.20924062f, 0.31619498f, -0.01174548f, 
    -0.08247337f, -0.04244587f, -0.02760249f, -0.01669133f, -0.03621807f, -0.06281172f, 0.00634363f, 0.00656019f, 
    -0.18673599f, 0.02940742f, -0.06738405f, -0.05713967f, 0.13390601f, -0.01982530f, -0.07773875f, 0.02366894f, 
    0.14854245f, 0.05223880f, -0.21327843f, 0.13531955f, 0.05522936f, 0.09580144f, -0.00331160f, 0.01200118f, 
    -0.15714005f, -0.04204337f, -0.00036854f, 0.06617565f, -0.02582471f, 0.00849047f, -0.01912458f, -0.06320968f, 
    -0.05699122f, 0.03894667f, 0.03945331f, -0.06311719f, 0.02860293f, 0.20571631f, 0.15787786f, -0.02221475f, 
    0.09117971f, -0.11572591f, -0.08802128f, -0.10972778f, -0.04207715f, -0.13262932f, 0.00856795f, 0.05271169f, 
    -0.08835490f, -0.04241267f, -0.01203123f, -0.03729611f, -0.04040378f, -0.03597684f, 0.12575790f, -0.03289672f, 
    -0.08819333f, 0.26338980f, -0.24753582f, 0.07981519f, -0.03273504f, 0.03289320f, 0.08797536f, -0.25344962f, 
    -0.04976009f, 0.02803034f, -0.13819662f, 0.05834507f, 0.03999090f, -0.00359161f, 0.02518175f, 0.02217050f, 
    0.03362696f, -0.00365445f, 0.10384692f, -0.08529013f, -0.10385957f, -0.24786918f, -0.38481387f, 0.15594108f, 
    0.07621046f, -0.01756984f, 0.05124740f, 0.00925670f, -0.06936149f, -0.03019308f, 0.00900056f, 0.07611011f, 
    0.05675264f, 0.03067168f, 0.11545634f, -0.00519237f, -0.03996693f, 0.00130644f, 0.04857939f, -0.03186208f, 
    -0.06413922f, -0.18763374f, -0.01579525f, -0.11098693f, 0.07271746f, 0.17964789f, 0.01819669f, -0.00527486f, 
    -0.01266437f, -0.08559165f, 0.05998350f, 0.00084668f, 0.08311995f, 0.01447870f, -0.05171689f, 0.01047523f, 
    -0.00401651f, 0.10575595f, 0.01526412f, -0.09249629f, 0.04728302f, -0.14915836f, 0.25922698f, -0.18080583f, 
    0.12491482f, -0.11007646f, 0.03220997f, -0.00358485f, -0.08237850f, 0.06634424f, -0.06161801f, -0.00551245f, 
    0.09445947f, -0.01787320f, -0.01501219f, 0.01540321f, -0.02424448f, 0.02419115f, -0.10365994f, 0.05436113f, 
    0.20272674f, 0.18995412f, 0.09093183f, 0.00401802f, 0.00667572f, -0.15552177f, -0.00552877f, 0.09211247f, 
    -0.09437849f, -0.06034248f, 0.04112876f, -0.08401135f, 0.00659850f, -0.07826962f, -0.05839879f, -0.04098530f, 
    0.00817759f, -0.08106712f, 0.07692053f, -0.06736086f, -0.23444785f, 0.09341617f, -0.35370412f, -0.13247752f, 
    -0.11931657f, 0.15464622f, -0.02211139f, -0.11610878f, 0.06447866f, 0.00575604f, 0.01140150f, 0.06293539f, 
    0.02148185f, 0.06260685f, 0.05026943f, 0.06443215f, -0.07675751f, -0.08927891f, 0.04544837f, -0.03779202f, 
    -0.02226198f, -0.21590506f, -0.19093941f, -0.18129216f, -0.15977502f, -0.10652654f, 0.04062371f, -0.00219658f, 
    -0.16647218f, -0.04880181f, -0.04170253f, 0.09752049f, 0.06552339f, 0.08460872f, 0.00711535f, 0.01175060f, 
    -0.00876968f, -0.04866192f, -0.09705591f, 0.09520356f, -0.11701191f, -0.05234842f, -0.19013295f, -0.11440868f, 
    -0.29676777f, -0.03867250f, -0.02212475f, -0.10980491f, -0.08584923f, 0.02949707f, 0.10532772f, 0.07218586f, 
    0.09656540f, 0.00517069f, 0.04999106f, -0.06923837f, -0.00338484f, -0.17275111f, 0.15815154f, 0.00974740f, 
    -0.26810008f, -0.09878886f, 0.21628417f, -0.25780734f, -0.21551548f, 0.06772922f, -0.10835184f, -0.01916063f, 
    0.02313432f, -0.02296376f, 0.01614355f, 0.08769114f, -0.09348898f, 0.01842961f, -0.08974803f, -0.04926338f, 
    0.05585181f, 0.03825282f, -0.31769824f, -0.10567588f, -0.09093108f, -0.11186101f, 0.17911218f, -0.09977590f, 
    -0.11451559f, -0.17657438f, -0.04956394f, 0.02939289f, -0.07696573f, 0.04296213f, -0.02076885f, -0.03838527f, 
    -0.02041290f, 0.06860028f, -0.02618508f, -0.01066951f, -0.06595442f, -0.10894951f, 0.00797339f, -0.04669296f, 
    -0.26018971f, -0.06066405f, 0.20163266f, -0.04853278f, -0.09277816f, -0.03142524f, -0.02663275f, -0.00859672f, 
    0.00346423f, -0.11383554f, -0.01439417f, -0.03144890f, -0.00897050f, 0.02254148f, -0.02425577f, 0.01489070f, 
    0.02815428f, -0.05428198f, 0.02882095f, -0.00650748f, -0.00460983f, -0.01661635f, -0.30492851f, 0.03586582f, 
    0.07097339f, 0.06988627f, -0.04927272f, -0.07983401f, -0.02724667f, -0.03207543f, 0.12940077f, -0.07411973f, 
    -0.02248030f, 0.00344252f, 0.13085869f, 0.05154981f, 0.05945655f, 0.00606710f, 0.04054160f, -0.02398311f, 
    0.21427540f, 0.05708447f, -0.09052457f, 0.23172955f, 0.21841027f, 0.05394611f, 0.07401405f, -0.11470913f, 
    -0.08980689f, -0.02396301f, -0.02012239f, -0.01820093f, 0.01172966f, -0.06114847f, 0.03109172f, -0.08843347f, 
    0.06528679f, 0.07308776f, 0.10944352f, -0.05861573f, -0.10490086f, 0.14342514f, 0.10258824f, 0.10339188f, 
    0.15419562f, -0.09824688f, -0.00594920f, 0.12750123f, 0.03164109f, 0.04668827f, 0.10039383f, 0.04361285f, 
    -0.12335037f, 0.04988988f, 0.00759035f, 0.00223869f, 0.07484730f, 0.03874991f, 0.09524854f, 0.10381533f, 
    -0.13902897f, -0.04548907f, 0.21380787f, 0.08602217f, 0.18206470f, -0.17115982f, -0.09006651f, -0.02785440f, 
    -0.09001324f, -0.04356086f, -0.04631393f, -0.00792426f, 0.02314306f, -0.00327572f, -0.04166878f, 0.02024163f, 
    -0.03761835f, 0.07413848f, 0.00754408f, 0.00628861f, 0.17773327f, 0.02516571f, 0.00326983f, 0.06621303f, 
    -0.09755450f, -0.08860311f, -0.09381840f, 0.00786668f, -0.09883251f, 0.11295843f, 0.01503308f, -0.00813508f, 
    -0.01485113f, 0.03880189f, 0.03584954f, 0.06792235f, 0.06735238f, -0.09070588f, 0.11660578f, -0.11402938f, 
    -0.13511977f, -0.13615198f, 0.13404414f, -0.09064761f, 0.05018044f, -0.02973947f, 0.05564367f, -0.06561270f, 
    -0.06244574f, 0.01553203f, 0.03698540f, 0.00020507f, 0.06978723f, 0.01168626f, 0.01052653f, 0.06398430f, 
    -0.01223984f, 0.05303589f, -0.05681251f, 0.01366608f, 0.03803071f, 0.18802437f, -0.20648661f, -0.03016899f, 
    -0.20942503f, -0.11796216f, -0.03811155f, 0.00197639f, -0.08099741f, -0.03818223f, 0.14229473f, -0.07223900f, 
    -0.02784774f, -0.17534333f, 0.05940976f, -0.14168257f, -0.18429807f, -0.10840480f, 0.01108750f, -0.03050845f, 
    -0.04223414f, -0.03922312f, 0.16048367f, 0.06953336f, -0.01978849f, -0.02497052f, 0.09473796f, 0.02028115f, 
    -0.05576863f, -0.09188066f, 0.07633881f, -0.03671448f, 0.06441793f, 0.09208061f, 0.00882602f, 0.06397185f, 
    -0.04296860f, -0.07055563f, -0.09816297f, 0.01192964f, 0.02335824f, 0.10803369f, -0.05858665f, 0.01215776f, 
    0.04649307f, 0.06485175f, 0.04471909f, -0.03834632f, -0.01389865f, -0.02549082f, 0.10419320f, 0.04544903f, 
    -0.03844377f, 0.10172752f, -0.05382786f, -0.07052117f, 0.03636466f, 0.07692074f, 0.01513792f, -0.08779074f, 
    0.02328790f, -0.02465537f, -0.12968042f, 0.02220283f, -0.11981470f, 0.05057924f, 0.12981848f, 0.08810505f, 
    -0.01183309f, -0.30563429f, -0.05623212f, 0.02876773f, -0.09863720f, -0.05459134f, -0.07532024f, -0.10091107f, 
    0.02154150f, -0.12695901f, 0.01387491f, -0.09929995f, -0.51725858f, -0.03704200f, -0.12589642f, 0.16158170f, 
    -0.22362521f, 0.00233485f, 0.14341204f, 0.01699485f, -0.14040166f, -0.03283202f, 0.00706572f, -0.04779632f, 
    -0.15936799f, -0.00078741f, 0.08607042f, -0.06461842f, 0.02146235f, 0.01881157f, 0.09069948f, 0.08310817f, 
    -0.16862932f, -0.11404254f, 0.07707942f, -0.03145399f, -0.02115742f, 0.05242486f, 0.15497991f, -0.06492938f, 
    0.08900966f, 0.05355605f, -0.08718397f, 0.06429883f, -0.01329229f, 0.02400358f, -0.05968170f, -0.14305867f, 
    -0.08479398f, -0.01011071f, -0.12328400f, 0.05998503f, 0.22815487f, -0.22386752f, 0.20157801f, -0.04701683f, 
    0.09896877f, 0.06270191f, -0.01323501f, 0.06083991f, -0.04105373f, -0.03056490f, 0.09986940f, -0.06214591f, 
    0.01977355f, 0.13533032f, 0.07869396f, 0.00608867f, -0.04682333f, -0.05231072f, -0.06589825f, 0.03531940f, 
    0.10404202f, 0.09482576f, 0.00138769f, 0.16065031f, -0.00403739f, -0.02384194f, 0.03508921f, -0.06933131f, 
    0.02537035f, 0.19826683f, -0.06830794f, -0.04612787f, 0.05233312f, 0.04715326f, 0.00531701f, -0.02290442f, 
    0.08706098f, -0.08689412f, 0.03808009f, -0.00037655f, 0.09509806f, -0.43982905f, -0.00613718f, -0.00141619f, 
    -0.11666420f, -0.19808114f, 0.04756798f, 0.06499455f, 0.07440912f, -0.04329951f, 0.01458078f, -0.14462578f, 
    -0.05611473f, -0.03219393f, -0.16269876f, 0.12456429f, 0.08143260f, 0.14954127f, -0.06636319f, 0.15713127f, 
    0.00201824f, -0.10314539f, 0.05877735f, 0.14922009f, -0.04014435f, -0.16648036f, -0.05054281f, -0.05638128f, 
    0.06721073f, 0.01462775f, -0.10243896f, 0.11248570f, -0.03252453f, -0.07010400f, 0.01029757f, -0.00567843f, 
    0.02630123f, 0.03178423f, 0.09728696f, 0.04309384f, 0.11157104f, 0.03163863f, 0.12834711f, -0.36884612f, 
    -0.24816835f, 0.11074559f, 0.02314316f, -0.02805366f, -0.06378385f, -0.03263427f, -0.06676899f, 0.01022014f, 
    0.03075199f, 0.05959982f, 0.06347367f, -0.01287520f, 0.02579312f, 0.05727668f, 0.05890465f, 0.02453802f, 
    -0.04432838f, 0.33106884f, 0.19476128f, -0.21786650f, -0.11187808f, 0.07565781f, -0.01514375f, -0.02797320f, 
    -0.02660410f, -0.07056672f, -0.14106995f, 0.02188423f, -0.07736544f, -0.06305198f, 0.09012227f, 0.05027929f, 
    0.06407999f, 0.00249418f, -0.12335942f, 0.00409290f, -0.29603952f, -0.25602642f, -0.09799545f, 0.25691772f, 
    -0.02685288f, -0.10985544f, 0.09363710f, -0.02408635f, -0.01306359f, -0.05111360f, -0.17774433f, 0.02977363f, 
    -0.01985991f, 0.10733635f, 0.17668597f, -0.02751750f, -0.16433385f, 0.05331365f, 0.04156051f, 0.05171460f, 
    -0.28612477f, 0.02746285f, 0.12076498f, 0.14874323f, -0.12264257f, 0.07834396f, 0.01592199f, 0.03625361f, 
    -0.05114093f, -0.05699356f, -0.04991834f, -0.09534461f, -0.01250612f, -0.05988202f, -0.06273767f, 0.11788728f, 
    -0.10400167f, 0.04109195f, -0.18189360f, -0.06680994f, 0.62287444f, -0.07560073f, -0.18219456f, -0.17926250f, 
    0.03169484f, 0.04433229f, 0.01000385f, 0.10926426f, 0.00086754f, 0.06822059f, -0.13263898f, -0.00841832f, 
    -0.00824947f, 0.13779981f, -0.13397361f, 0.01026383f, 0.03316047f, -0.08224246f, -0.04148257f, -0.02470740f, 
    0.13343698f, -0.81186712f, 0.31467625f, -0.31544301f, -0.00915064f, -0.04582388f, 0.04780105f, 0.01380140f, 
    0.19234696f, -0.07532655f, -0.16421644f, 0.02842909f, 0.11204532f, -0.32042471f, -0.05358937f, 0.04043071f, 
    0.09070323f, 0.02201770f, -0.13286746f, 0.07540916f, -0.02041551f, -0.30972785f, 0.09469732f, -0.22773519f, 
    -0.29904529f, -0.04468602f, 0.00694608f, -0.05398406f, -0.02007213f, 0.00884124f, 0.03359384f, -0.02180228f, 
    0.04156710f, 0.00047909f, -0.07988879f, -0.02551040f, 0.06015972f, 0.06134419f, 0.06075575f, 0.03774706f, 
    0.10361525f, -0.01574799f, 0.19630942f, -0.34228566f, -0.43272990f, -0.01861941f, -0.01533166f, -0.01315686f, 
    -0.03895397f, 0.10317820f, 0.06943969f, -0.05073985f, 0.11795536f, -0.12001012f, -0.10420683f, -0.06223669f, 
    -0.05251694f, 0.04366883f, 0.02125477f, -0.08282802f, 0.33221653f, -0.10824286f, 0.14572105f, 0.12136621f, 
    0.03711896f, 0.03570920f, 0.02367786f, 0.13343090f, 0.00397539f, -0.00082524f, 0.02503386f, 0.04478439f, 
    -0.03933039f, -0.01351651f, -0.04750555f, 0.10499378f, -0.04980628f, 0.05970068f, -0.01439545f, 0.00974349f, 
    -0.28307554f, 0.35601518f, -0.14263684f, 0.18089476f, -0.06162408f, 0.11451414f, 0.08029256f, 0.00863825f, 
    0.12290026f, -0.01607687f, -0.04371217f, 0.10243902f, 0.08470542f, -0.02642771f, 0.09956557f, 0.09410812f, 
    -0.07993418f, 0.14867896f, 0.02804993f, 0.00311937f, 0.03563224f, -0.43724331f, 0.29067728f, -0.21444558f, 
    -0.20865601f, 0.06727888f, -0.04162836f, 0.00125880f, 0.13310534f, 0.08463524f, -0.00090656f, 0.05566093f, 
    0.15118188f, -0.04769723f, -0.05997201f, -0.01029261f, 0.00469748f, 0.01229774f, 0.05620869f, -0.14039709f, 
    -0.17315346f, -0.07574297f, 0.06598589f, -0.23225759f, 0.20380440f, 0.03198246f, 0.04690724f, 0.11933184f, 
    0.08281983f, 0.00544821f, 0.01523505f, 0.08340185f, -0.08650926f, 0.13286471f, -0.09322535f, -0.17967904f, 
    0.05645027f, 0.14903738f, 0.09534926f, 0.13743201f, -0.27049419f, -0.24097390f, 0.06210424f, 0.00943294f, 
    0.11773232f, -0.06977025f, 0.01218482f, 0.02462082f, 0.12459644f, -0.02710585f, 0.02463331f, 0.02302434f, 
    -0.04843410f, 0.01668574f, -0.06807069f, 0.03283376f, -0.09196731f, 0.20743948f, -0.05640396f, 0.07425997f, 
    0.07912505f, -0.12682769f, 0.05069740f, 0.05393062f, -0.10186798f, -0.08090203f, 0.08513370f, 0.10170860f, 
    -0.00058654f, -0.04704294f, 0.03434037f, 0.05159295f, 0.08441492f, -0.05381967f, 0.05018375f, 0.02647511f, 
    0.02212611f, -0.07289643f, 0.07096909f, 0.03330081f, -0.05538613f, -0.22708440f, -0.19039419f, 0.05943262f, 
    0.17741212f, 0.14089531f, 0.05491095f, -0.01852557f, -0.06720245f, 0.19484468f, 0.01242003f, 0.01460773f, 
    -0.00748249f, 0.05895183f, 0.02878464f, 0.03851900f, -0.00910566f, 0.07663490f, 0.01360359f, -0.10277525f, 
    -0.30064610f, -0.26109940f, -0.02352964f, 0.29043710f, 0.09973243f, -0.00111195f, 0.02759799f, -0.07977122f, 
    -0.10498810f, 0.01459357f, -0.04849296f, 0.04629844f, -0.01152049f, 0.02844327f, -0.07309302f, -0.04145696f, 
    -0.18624303f, 0.07609415f, 0.00633286f, 0.02631519f, -0.19833387f, -0.21619117f, 0.21369468f, -0.31058133f, 
    0.19580895f, 0.01593898f, -0.02591131f, -0.08683360f, 0.06700475f, 0.02904959f, -0.02638149f, -0.09324438f, 
    -0.08412559f, 0.06329915f, -0.01083541f, 0.09336894f, 0.01071238f, -0.21988273f, -0.11072089f, 0.03173939f, 
    -0.11633866f, 0.00120716f, 0.12963565f, -0.08567271f, -0.01875255f, 0.15451077f, 0.07032209f, -0.17614156f, 
    -0.02845262f, -0.18098710f, -0.02170070f, 0.07229766f, -0.10643270f, 0.01475492f, -0.04937189f, 0.01314333f, 
    0.04788747f, 0.00306297f, -0.01880826f, -0.06841521f, -0.07287044f, -0.09766084f, -0.23277031f, 0.08618367f, 
    -0.12334750f, 0.01845952f, 0.14811140f, -0.09272198f, -0.01659726f, 0.00707878f, 0.01300613f, -0.00429794f, 
    -0.07603602f, -0.05595243f, 0.18326847f, 0.03060257f, -0.06630593f, -0.03541314f, -0.06909592f, -0.06279907f, 
    0.55554140f, 0.05778506f, -0.18603474f, -0.06193168f, 0.20224190f, 0.16603635f, -0.15291494f, -0.00840264f, 
    -0.09336792f, 0.05822650f, 0.01667358f, 0.02896749f, 0.12643905f, 0.09840844f, -0.01177420f, 0.01634683f, 
    0.05448357f, -0.08448703f, 0.03918295f, -0.11077737f, -0.69471085f, 0.28664622f, 0.11936174f, 0.04475509f, 
    0.23626579f, 0.20033488f, 0.02937838f, -0.08630735f, -0.10911746f, 0.18330719f, -0.02952204f, -0.04182214f, 
    -0.04620225f, 0.05860240f, -0.00016796f, 0.12285279f, -0.02544799f, 0.01856495f, -0.01481803f, 0.14312908f, 
    0.19282189f, -0.36040425f, 0.03097241f, 0.04366075f, -0.11827058f, 0.05241758f, 0.05616565f, -0.02279731f, 
    -0.08113585f, -0.03858742f, -0.17728084f, 0.04948883f, -0.02048410f, 0.09691870f, 0.04230365f, 0.07110029f, 
    0.04555126f, -0.03937480f, -0.04015931f, 0.03825727f, -0.66652435f, 0.39492059f, -0.07167716f, 0.01769530f, 
    0.03049261f, 0.05950975f, -0.07532775f, -0.02057145f, -0.03742931f, 0.06022550f, -0.02792495f, 0.01566111f, 
    0.05523223f, 0.02974268f, 0.13051000f, 0.16911207f, 0.00422529f, 0.13965206f, -0.11624632f, 0.02773800f, 
    0.20858474f, -0.38795269f, -0.02087171f, 0.18936488f, 0.04343125f, -0.03038949f, -0.04799385f, -0.03196887f, 
    -0.03176445f, 0.02600582f, 0.05065623f, -0.01594706f, -0.04018153f, -0.13175452f, -0.00123238f, -0.05507367f, 
    -0.02050054f, 0.00322415f, -0.02054181f, 0.06841197f, 0.37112486f, 0.06696225f, -0.02048535f, -0.24534710f, 
    -0.39815494f, -0.06683046f, -0.02113784f, 0.15628235f, 0.10722472f, -0.07250936f, 0.01854529f, -0.02172758f, 
    -0.05930504f, -0.12002385f, 0.10998692f, 0.10837803f, 0.12837736f, -0.13991949f, -0.01627473f, 0.06964470f, 
    -0.63205069f, -0.47882050f, -0.13535583f, -0.09583453f, -0.13661525f, 0.10986260f, 0.12135341f, -0.05955129f, 
    -0.10642107f, 0.04982015f, 0.09501182f, -0.13955356f, 0.00502131f, 0.01277721f, 0.01624999f, -0.05111900f, 
    -0.03772239f, 0.14563963f, 0.09286938f, 0.08804604f, -0.26337120f, -0.33414730f, -0.03679419f, 0.03609813f, 
    0.18907580f, 0.15842079f, 0.06996618f, -0.01653276f, 0.00748488f, 0.05602924f, 0.00357089f, -0.05760933f, 
    0.06083939f, 0.03756875f, -0.01552673f, 0.17123716f, 0.03688110f, -0.06774692f, -0.02953336f, 0.00751840f, 
    0.31498501f, 0.05960590f, -0.05748124f, -0.00288211f, -0.06627674f, -0.07612954f, -0.06967182f, -0.01864378f, 
    0.09149561f, -0.09317477f, -0.03355150f, 0.07572226f, -0.13828592f, -0.05103524f, 0.01239970f, 0.02183844f, 
    0.11640153f, 0.05041260f, -0.01050104f, -0.00556484f, -0.53935552f, 0.10031506f, -0.30588543f, -0.10915808f, 
    0.18605217f, 0.05273644f, 0.07590569f, -0.08161712f, 0.00177703f, 0.08035306f, 0.07341242f, -0.05416666f, 
    0.03812771f, -0.06786611f, 0.10444250f, -0.00267168f, 0.02692506f, 0.14623126f, -0.00060801f, 0.08210126f, 
    0.35166198f, -0.27975136f, -0.31638682f, 0.04640739f, -0.01753580f, -0.25913566f, -0.12948117f, -0.06387685f, 
    -0.05518410f, -0.15134709f, 0.00121642f, 0.05503873f, -0.22633968f, -0.18095009f, -0.14412840f, -0.21153870f, 
    -0.01439935f, -0.14017138f, -0.20571792f, -0.00661215f, 0.26817882f, 0.16249023f, 0.11541770f, 0.18649615f, 
    0.12545539f, -0.05017078f, 0.03585809f, -0.04624764f, 0.01114097f, 0.07875500f, -0.01737468f, 0.09704843f, 
    -0.00000744f, -0.02068944f, 0.05508806f, 0.04511539f, -0.11800167f, -0.34642521f, -0.30809924f, -0.06687871f, 
    0.15700115f, 0.02654747f, 0.02636346f, -0.02404124f, -0.04567042f, -0.00969554f, 0.02394616f, 0.06181361f, 
    0.03027778f, -0.00080140f, 0.04317687f, 0.12632002f, 0.05045766f, 0.05229414f, -0.01131267f, 0.00815216f, 
    0.04575148f, -0.07595354f, -0.16720811f, 0.00850600f, -0.58809018f, -0.37520528f, -0.14552556f, -0.22716641f, 
    -0.12556906f, 0.11769149f, 0.02975458f, -0.10321323f, -0.01473911f, 0.02101176f, 0.03905238f, -0.00867217f, 
    -0.03880930f, 0.02182503f, 0.00574574f, 0.07374591f, 0.05023365f, 0.07369310f, 0.06066284f, 0.08145852f, 
    -0.07140973f, -0.22782078f, 0.03196389f, -0.08676832f, 0.12058783f, 0.14356922f, -0.00462531f, 0.12353460f, 
    0.04050421f, 0.10130521f, 0.10701017f, 0.00279716f, 0.01433195f, 0.08582623f, 0.03521047f, 0.05225594f, 
    0.02824307f, -0.16088244f, 0.07233869f, 0.11362687f, 0.26419809f, -0.01273096f, 0.08076566f, -0.05373579f, 
    -0.14369623f, -0.00951136f, -0.18018876f, 0.08014089f, 0.00828839f, -0.00619050f, 0.00682673f, 0.02412326f, 
    -0.15322274f, -0.04335300f, -0.08952580f, -0.08526935f, -0.04703091f, -0.12880035f, -0.10234494f, -0.06438908f, 
    -0.43068454f, -0.32290927f, -0.27424675f, -0.02392449f, -0.07438842f, 0.06390067f, 0.05595944f, -0.01638829f, 
    -0.06171909f, 0.01514021f, 0.04553465f, -0.04139796f, -0.08549938f, 0.05472494f, -0.01980678f, 0.01586642f, 
    0.04788668f, 0.15607110f, 0.00615329f, 0.06817380f, 0.13697194f, 0.12400390f, 0.14830852f, 0.13076544f, 
    -0.01459312f, -0.11133932f, -0.05186980f, -0.01532885f, 0.05458618f, 0.00909339f, -0.01964101f, -0.07169801f, 
    0.03891873f, -0.16047995f, -0.04287272f, -0.13348524f, -0.05502876f, 0.12343688f, 0.01484383f, -0.05093491f, 
    -0.49663359f, -0.26025879f, -0.20597892f, 0.05969268f, 0.14111695f, 0.07020151f, -0.02469704f, -0.14835897f, 
    0.06663789f, -0.06673743f, 0.02331555f, 0.08262970f, -0.00012863f, 0.10487104f, 0.16203922f, -0.05567412f, 
    0.04805311f, 0.07855927f, 0.04992042f, 0.03564955f, -0.40173131f, -0.20271246f, 0.12920459f, -0.01886089f, 
    -0.11641836f, 0.04775427f, 0.05754837f, 0.02540477f, 0.07896331f, 0.06727596f, 0.03083472f, 0.02675661f, 
    -0.04792763f, 0.06606685f, 0.05727216f, 0.10955964f, -0.10592055f, 0.06835740f, -0.06290308f, 0.00291036f, 
    -0.20577024f, 0.18812013f, 0.10851934f, -0.16406229f, -0.08196171f, 0.14937200f, -0.05694562f, 0.00619793f, 
    0.00152867f, 0.02415465f, -0.05058463f, 0.08676460f, 0.01967823f, 0.16560115f, 0.05405336f, 0.07963680f, 
    0.04247694f, 0.02025509f, -0.12087313f, 0.08074398f, -0.00854365f, 0.06351266f, -0.03991455f, 0.00823670f, 
    0.00859913f, -0.04104685f, 0.09905214f, 0.07168260f, 0.11117011f, -0.00236533f, 0.09801918f, 0.04433596f, 
    0.05027473f, 0.01832011f, 0.03264022f, 0.09903557f, 0.09744880f, 0.03335417f, -0.13160866f, 0.16288619f, 
    -0.06876977f, 0.06754734f, -0.08482124f, -0.01453252f, -0.02215611f, 0.05096794f, 0.07804682f, 0.03691087f, 
    0.03706447f, 0.01888715f, 0.08569965f, -0.02500980f, 0.06700561f, -0.05448556f, -0.03178820f, -0.00371356f, 
    0.07190291f, 0.07223625f, 0.19185655f, 0.00593342f, -0.03968822f, 0.12641437f, 0.07231730f, 0.12314575f, 
    0.03024968f, 0.09768599f, 0.02362249f, -0.05489873f, 0.02019362f, -0.09504288f, -0.06519942f, -0.01253945f, 
    0.00595331f, 0.17452581f, 0.05712042f, -0.03925029f, 0.04689161f, -0.15526697f, -0.11692684f, -0.03846068f, 
    0.18025695f, 0.12883879f, -0.06199829f, 0.03576256f, -0.06983458f, -0.00796819f, 0.03477392f, 0.08770755f, 
    0.07620391f, 0.09276521f, 0.06233820f, 0.00844433f, 0.04005957f, 0.00686370f, 0.00623778f, 0.12680253f, 
    0.06039072f, -0.03365075f, -0.04841912f, 0.13045835f, -0.02384672f, 0.07653356f, -0.35970843f, 0.17298971f, 
    0.04477973f, 0.03952605f, -0.03567683f, 0.03487139f, 0.00357227f, 0.05519495f, 0.05104927f, -0.07534631f, 
    0.09041880f, -0.07630635f, 0.10873210f, 0.04048470f, 0.03368382f, 0.03917005f, 0.10871910f, 0.06677130f, 
    0.18009700f, 0.03871657f, 0.09323744f, -0.06125959f, 0.00098683f, 0.03365279f, -0.09669354f, 0.10592736f, 
    0.01345448f, 0.00924235f, -0.01743278f, -0.04524744f, 0.01528017f, 0.11184048f, -0.10346943f, -0.00410810f, 
    -0.03743284f, -0.16137680f, -0.13222869f, -0.00637825f, 0.19089000f, 0.12821479f, -0.11396534f, 0.07129727f, 
    -0.17230585f, -0.04083753f, -0.08857080f, 0.04806052f, 0.01626491f, 0.03312232f, 0.07501890f, -0.01488136f, 
    0.03170865f, 0.00440431f, -0.05369251f, 0.06735239f, -0.00310061f, -0.09270160f, 0.02031127f, 0.05033509f, 
    0.21283980f, 0.11751643f, -0.03464849f, 0.06950232f, -0.07963904f, -0.00869348f, -0.19195168f, 0.12677249f, 
    -0.04070095f, 0.01174188f, -0.01395511f, -0.05565776f, 0.01092129f, -0.01134594f, -0.05384995f, -0.01655909f, 
    0.02652876f, -0.04173994f, -0.00044483f, -0.02488640f, -0.73419714f, 0.00706869f, -0.32852724f, -0.15256581f, 
    0.07129977f, 0.06300972f, -0.03622743f, -0.13181777f, -0.04186777f, 0.10541180f, 0.09769808f, 0.04434519f, 
    0.05324572f, -0.01464016f, -0.05170167f, -0.00912233f, -0.13097361f, -0.01395615f, -0.03544634f, -0.04887087f, 
    -0.79942364f, -0.39366901f, -0.37500146f, -0.29346693f, -0.34885207f, 0.03842321f, 0.14108515f, -0.15443164f, 
    -0.09778708f, 0.01421867f, 0.00497168f, -0.11077624f, -0.05625673f, -0.02790089f, -0.09394339f, -0.04343848f, 
    -0.11199825f, -0.01040102f, 0.03473420f, 0.01680993f, 0.25106803f, -0.02028523f, -0.13696145f, -0.07875326f, 
    0.04079576f, -0.16107859f, -0.07822800f, -0.06938022f, 0.05127655f, -0.11426480f, 0.00695405f, -0.06483981f, 
    -0.05760131f, -0.12944864f, -0.06369559f, -0.17629051f, 0.03479011f, -0.06423200f, 0.07937449f, 0.03060835f, 
    0.08715275f, 0.19240376f, 0.00725722f, -0.01792047f, -0.02666408f, -0.05311929f, -0.01645862f, 0.06161725f, 
    0.07070999f, 0.06213544f, -0.01796744f, -0.03268379f, -0.05077930f, -0.02153831f, -0.07138944f, -0.07186503f, 
    0.06643579f, 0.21872658f, 0.00258430f, 0.02825285f, 0.16483085f, -0.01650626f, -0.11198678f, 0.01065842f, 
    -0.21477902f, 0.00583758f, -0.05491934f, 0.05756635f, 0.09624134f, -0.01292450f, 0.08892727f, 0.00273651f, 
    0.02586702f, -0.10530210f, 0.01469665f, 0.04588533f, -0.05011291f, -0.05205187f, 0.06710762f, -0.02116864f, 
    -0.00362110f, -0.10955625f, 0.00854852f, -0.08140871f, 0.00797756f, 0.01838268f, 0.07863910f, 0.06884523f, 
    0.00239156f, 0.02739291f, 0.08478831f, 0.02454599f, 0.02194910f, -0.06912097f, -0.01402018f, -0.08344086f, 
    0.02487843f, 0.07995210f, -0.03363195f, 0.11829133f, -0.23550995f, -0.09220465f, 0.00731167f, 0.10664731f, 
    -0.03876859f, -0.01018947f, 0.15058199f, 0.16386662f, 0.04808737f, -0.04027011f, 0.11483922f, -0.00486095f, 
    0.06319791f, -0.22282209f, 0.02978683f, -0.01529642f, 0.05424185f, -0.11401244f, 0.06090002f, 0.03928126f, 
    0.07463856f, 0.09616889f, -0.05794635f, -0.04327242f, -0.03904708f, -0.00052465f, 0.01381920f, 0.00304122f, 
    0.05112136f, 0.01530824f, 0.01200799f, 0.02202018f, 0.07308573f, -0.00693109f, -0.01066443f, 0.06382168f, 
    0.11392755f, 0.06746651f, -0.01512384f, 0.08911631f, -0.63970464f, -0.23325698f, 0.11554153f, -0.05958403f, 
    -0.05431973f, 0.12749293f, 0.03464892f, 0.00829704f, -0.01964959f, 0.05999503f, -0.02849285f, 0.03388329f, 
    -0.02562577f, 0.07686162f, 0.03450113f, 0.07795336f, 0.03492236f, 0.08134957f, 0.08650366f, 0.09188558f, 
    -0.13529368f, -0.18846184f, -0.25455204f, -0.25475237f, -0.31922004f, -0.02099883f, 0.02555273f, 0.00316730f, 
    0.04620485f, 0.13512753f, 0.06347001f, 0.02088668f, -0.06496535f, -0.07746871f, 0.02317860f, -0.00860663f, 
    -0.03508538f, 0.02677251f, -0.07009942f, -0.04217428f, -0.34319809f, 0.33703375f, -0.13969445f, -0.12935498f, 
    0.18350352f, 0.22255991f, -0.06897830f, 0.01771045f, -0.10449994f, -0.07346932f, 0.11126575f, 0.22384271f, 
    -0.07797984f, 0.00008057f, 0.11208458f, -0.04429018f, 0.05245913f, -0.00092058f, -0.15314171f, 0.01416265f, 
    -0.17225236f, -0.17667735f, 0.07230970f, -0.01528550f, -0.07327866f, -0.02833511f, -0.02703421f, 0.03957269f, 
    -0.00909641f, 0.03934827f, -0.11582621f, 0.02532152f, 0.08302980f, -0.05773643f, -0.20774680f, -0.00559852f, 
    -0.14742038f, -0.04702997f, -0.07826120f, -0.10810547f, -0.32016528f, -0.06368994f, 0.09682439f, 0.04676330f, 
    0.11687364f, -0.07453347f, 0.05289373f, -0.15810476f, 0.02202869f, -0.03806184f, -0.07963426f, 0.07167186f, 
    0.09490052f, 0.11404055f, -0.01750997f, 0.03743649f, 0.06956258f, -0.04866644f, 0.02938827f, 0.05695837f, 
    -0.12951726f, 0.10484535f, 0.15109538f, 0.00051314f, -0.19208187f, 0.07023931f, -0.26843783f, -0.07828087f, 
    0.05076324f, -0.11200308f, -0.07201298f, -0.02841759f, 0.05977027f, -0.13701926f, 0.09449960f, -0.06599696f, 
    -0.02201789f, 0.01280968f, 0.00973345f, 0.04432417f, -0.32310140f, 0.02722965f, -0.24360324f, -0.05700080f, 
    -0.07971179f, -0.22445676f, -0.12398311f, -0.08578935f, 0.08369713f, -0.20206378f, 0.17981057f, 0.03313204f, 
    0.01329822f, 0.03953291f, -0.01278281f, 0.13485684f, 0.01356387f, -0.00718921f, -0.03545208f, -0.02260602f, 
    0.02862069f, 0.16372013f, 0.06921182f, -0.09710883f, 0.00786698f, -0.12691367f, -0.14038332f, 0.02096260f, 
    -0.15709512f, -0.13951227f, 0.09023273f, -0.07656456f, 0.03075479f, -0.09718584f, 0.00419253f, 0.09398086f, 
    0.03561724f, -0.09708035f, 0.13688830f, 0.04833986f, 0.54104626f, -0.29831055f, -0.20877817f, -0.01323878f, 
    -0.09053577f, 0.01188178f, 0.03813316f, -0.01203230f, -0.00648097f, 0.02574562f, 0.12519597f, -0.02961958f, 
    0.03170428f, 0.07637449f, -0.03757160f, 0.04912053f, -0.09711923f, -0.07214706f, 0.08714610f, -0.00796180f, 
    0.22781098f, -0.14358215f, -0.14997131f, 0.00205742f, 0.13652274f, 0.19637075f, -0.23192544f, -0.13303265f, 
    0.18564367f, 0.08676433f, 0.03424153f, 0.00897351f, -0.05298875f, -0.03973694f, -0.00974722f, 0.08963884f, 
    -0.02239185f, 0.09191480f, -0.09273516f, -0.05578128f, 0.33451861f, -0.00563115f, -0.07899725f, -0.17721039f, 
    0.04080149f, -0.14467068f, -0.07031032f, -0.13254373f, -0.18354134f, -0.22395982f, -0.00045929f, -0.04590386f, 
    0.14101326f, 0.06671135f, -0.08591808f, 0.00886064f, -0.06485208f, 0.03978610f, 0.07021263f, -0.01051738f, 
    0.08845066f, 0.09547660f, -0.11933166f, 0.12689829f, -0.31390849f, 0.05411255f, 0.16939089f, 0.03602034f, 
    0.02776500f, 0.07173812f, 0.04829917f, 0.09762377f, 0.05348609f, -0.02935806f, 0.06022600f, 0.00572764f, 
    -0.02151308f, -0.01509456f, -0.13805857f, 0.07228291f, -0.35526952f, -0.33545995f, -0.04374615f, -0.05682828f, 
    0.07597875f, -0.01693931f, -0.06795468f, 0.07354585f, 0.06079853f, 0.06185995f, -0.06936976f, 0.06142562f, 
    -0.00213379f, 0.03061615f, -0.02860848f, 0.08095072f, -0.06900372f, 0.01191920f, -0.12038236f, -0.01112891f, 
    -0.14373454f, -0.14404684f, 0.11247043f, 0.09505673f, -0.01627197f, 0.03678896f, 0.22550178f, -0.07899047f, 
    -0.00116564f, -0.05326788f, -0.07605747f, 0.04931108f, -0.06088690f, -0.01374254f, -0.04421760f, 0.08625215f, 
    0.11108471f, -0.11067375f, -0.13195714f, 0.04024371f, 0.48478723f, 0.08911452f, -0.19405283f, -0.03274011f, 
    0.11190160f, 0.00723150f, -0.08497939f, -0.10388424f, 0.01872306f, 0.01882412f, 0.00256095f, 0.16042934f, 
    -0.07995070f, 0.07876900f, -0.02499388f, 0.03452363f, 0.07821417f, 0.04509163f, 0.02553391f, 0.02630480f, 
    0.50789040f, 0.01477985f, -0.19107293f, -0.07555642f, 0.17516011f, -0.01100259f, 0.04064190f, -0.05841338f, 
    0.06125383f, -0.06545558f, 0.17774448f, 0.00087339f, 0.00958982f, 0.02473751f, 0.12047191f, 0.02567636f, 
    -0.05369145f, 0.01891767f, 0.06506234f, 0.08690326f, -0.51609570f, 0.32809031f, 0.03210208f, -0.03175982f, 
    0.11688857f, -0.06419408f, -0.08203553f, -0.04621709f, -0.06638195f, 0.06203209f, 0.06525887f, 0.06856942f, 
    0.01681107f, -0.09025536f, -0.05958213f, -0.08691086f, -0.03629258f, -0.06698932f, 0.07635928f, -0.01598268f, 
    -0.12336615f, -0.34057346f, -0.05349063f, 0.03789236f, -0.05504062f, -0.00936594f, 0.15205002f, 0.02945876f, 
    -0.06244637f, 0.08345974f, -0.08788266f, -0.00412670f, -0.11920627f, -0.03332468f, -0.07928399f, -0.02904006f, 
    0.07571912f, -0.05391759f, -0.09061163f, -0.02606329f, 0.23318340f, 0.37756908f, -0.11827629f, -0.08244328f, 
    -0.00388170f, 0.05546867f, 0.20418917f, -0.08739266f, 0.05257690f, -0.03268150f, 0.12500244f, 0.10036989f, 
    -0.00197517f, -0.05707652f, 0.01203853f, -0.00675494f, 0.02874593f, -0.01920106f, 0.04028089f, 0.17666189f, 
    0.02601600f, 0.20469467f, -0.21310617f, 0.10417398f, 0.34544569f, 0.06780060f, -0.10658523f, -0.01517069f, 
    -0.00087211f, -0.06134021f, 0.06255926f, 0.02825228f, -0.00045271f, -0.02444026f, -0.06841826f, 0.03367185f, 
    0.02603328f, 0.03633670f, 0.11808671f, -0.03979654f, 0.04225319f, -0.12266500f, -0.01159514f, 0.09747749f, 
    -0.03598247f, 0.02420153f, 0.18047568f, 0.01070220f, 0.00166869f, -0.07673442f, 0.04554529f, -0.10041659f, 
    -0.02225089f, 0.08827806f, -0.05350122f, 0.04227803f, -0.05023649f, 0.08241554f, -0.11324660f, -0.12879395f, 
    0.12436443f, 0.02578181f, -0.06115506f, -0.11253683f, 0.06354228f, -0.17911756f, -0.10095138f, 0.13682880f, 
    -0.01286977f, -0.12500493f, -0.00479416f, -0.03510448f, -0.07625932f, -0.01547515f, 0.09918116f, 0.06335139f, 
    -0.06374453f, -0.04493298f, 0.23445608f, 0.12704726f, 0.03260770f, 0.03513340f, 0.01937276f, 0.09370773f, 
    0.11958808f, -0.02156654f, -0.08244908f, 0.14526223f, -0.04015451f, -0.03473389f, -0.02664390f, -0.03753159f, 
    -0.02269382f, 0.04666159f, -0.04152076f, 0.03704831f, 0.01732420f, 0.06482973f, -0.03445570f, -0.04282331f, 
    0.32359305f, 0.03833836f, 0.02457504f, -0.03379855f, -0.02629796f, -0.03891062f, -0.02166822f, 0.01293475f, 
    -0.08253404f, -0.15585345f, 0.03412274f, -0.07803173f, -0.02079490f, 0.03776936f, -0.08508932f, -0.02504629f, 
    0.01939653f, 0.05722336f, -0.02146446f, -0.05914782f, 0.26419643f, -0.11531793f, -0.11344087f, 0.26141095f, 
    -0.19995530f, -0.11914463f, -0.04824973f, 0.04523031f, -0.04951658f, -0.03404001f, 0.05215455f, -0.12561466f, 
    0.10617303f, 0.10626788f, -0.06320838f, 0.12441858f, 0.06449073f, -0.14344521f, -0.02446309f, 0.04510526f, 
    0.39380747f, -0.25083381f, -0.32037199f, -0.13866052f, -0.34549803f, -0.02941085f, -0.07810182f, 0.15547386f, 
    -0.04319764f, 0.07135020f, 0.10249412f, 0.03270424f, 0.00321911f, -0.06639425f, -0.09025590f, -0.01647824f, 
    -0.03536778f, 0.01521954f, -0.07161708f, 0.01423478f, -0.28786373f, 0.04513701f, -0.09288575f, 0.12292790f, 
    -0.02467624f, 0.14194939f, -0.05113055f, 0.07297476f, -0.00901233f, 0.09863351f, -0.00374438f, -0.11157809f, 
    0.04603132f, -0.15143703f, -0.00847858f, -0.03577998f, 0.09780522f, -0.12275875f, -0.10046773f, -0.11005069f, 
    -0.28899041f, 0.03224518f, -0.00798937f, -0.08450015f, 0.08882170f, -0.03765838f, 0.02784167f, -0.01677189f, 
    0.06577647f, -0.12421928f, 0.00933843f, -0.00407783f, 0.11112669f, 0.02584964f, -0.05360698f, 0.00157992f, 
    -0.10670880f, 0.02677094f, -0.19191605f, -0.06864122f, 0.23602109f, -0.33799860f, 0.03069380f, 0.02225794f, 
    -0.09507988f, -0.08076122f, 0.05953934f, 0.11102393f, -0.12358755f, 0.11528829f, -0.09428849f, -0.04939464f, 
    -0.01502703f, 0.04892129f, -0.17259471f, -0.16156979f, -0.07411087f, -0.11440892f, -0.00870826f, -0.01487181f, 
    -0.57870811f, 0.34451106f, -0.10786679f, -0.01995767f, 0.24367605f, 0.05935749f, -0.01791831f, 0.07401112f, 
    0.01626431f, 0.21996579f, -0.00176243f, 0.01528034f, 0.10087211f, 0.03031237f, 0.09835906f, 0.05136241f, 
    0.00081255f, -0.01290437f, -0.03383126f, -0.17807300f, -0.06498286f, 0.05567455f, -0.06934963f, 0.12399137f, 
    -0.16093680f, 0.16363657f, 0.05503540f, 0.00742849f, -0.02658284f, 0.04189383f, 0.02749319f, 0.03728566f, 
    -0.07919315f, -0.02805999f, 0.07388701f, -0.11370463f, 0.11478985f, 0.01384573f, 0.02246639f, 0.02030675f, 
    -0.17539319f, 0.19737400f, -0.06812506f, -0.05708584f, -0.07232163f, -0.05358035f, -0.08803242f, 0.04662372f, 
    -0.11421943f, -0.03937929f, -0.04898073f, -0.05218022f, -0.02866902f, -0.09184778f, 0.04114736f, 0.02328192f, 
    0.04079763f, 0.07650819f, -0.01521580f, -0.10060562f, 0.34812176f, -0.26462388f, -0.07157473f, -0.22218187f, 
    -0.08685793f, 0.15035222f, -0.08897075f, -0.08253391f, 0.06364134f, 0.07920292f, 0.05055218f, -0.02548638f, 
    0.07813765f, 0.04379203f, 0.05839285f, 0.03513978f, 0.04210794f, -0.04154712f, -0.00807450f, -0.01995825f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03326964f, 0.06681606f, -0.04296666f, 0.01936917f, 0.05263773f, 0.04662666f, -0.04617529f, -0.07274696f, 
    -0.04821485f, 0.00107107f, 0.04143296f, 0.03955233f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
