#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12914908f, 0.06374181f, -0.16986862f, -1.16966343f, -0.96577495f, -0.97070521f, 0.23576725f, 0.70067036f, 
    0.97568691f, 0.27461281f, 0.71644264f, -0.07622657f, 0.22491612f, 0.70870364f, -0.11844775f, 0.39643282f, 
    0.31147987f, 0.21812764f, -1.29417765f, 1.66126585f, -0.45622617f, -0.53084338f, 0.13306837f, 0.72752291f, 
    -0.26055035f, -0.16591445f, 0.68643552f, -0.45782059f, -0.62307006f, -0.19062454f, -1.15302134f, 1.51662779f, 
    -1.96073675f, 0.01780695f, 0.01176079f, 0.13917308f, 0.66404271f, 0.95052958f, 0.95538199f, -0.31014207f, 
    -0.96176642f, -0.91286731f, 0.04106496f, 0.21098202f, 0.25910062f, 0.32821780f, 0.00346450f, 0.01689738f, 
    0.24408153f, 0.84120351f, 0.76314783f, 0.82454330f, -0.71133631f, -0.30160558f, -1.99778593f, 0.17485662f, 
    0.78592110f, -0.54279685f, -0.78717297f, 1.09718478f, 0.25978366f, -0.13365465f, -0.06807102f, -1.38797474f, 
    -0.35476190f, -0.26776570f, -0.78866017f, -0.94830763f, -1.03712916f, -0.26421118f, -0.41413942f, -0.76372379f, 
    0.71842784f, -0.03308578f, -0.00612283f, 0.29653454f, 0.15039708f, -0.42908913f, 0.25967392f, -0.36689603f, 
    1.30910242f, -0.21286868f, 0.34150037f, 0.74622411f, 1.38930488f, 0.58340091f, 0.29918036f, 0.30970576f, 
    0.56701851f, 0.16907826f, -0.16728818f, -1.86889708f, -1.63423181f, 0.33822364f, 0.71250570f, 0.62585086f, 
    0.49954262f, 0.28420812f, -0.01743532f, -0.47694764f, 0.00961311f, 0.66439742f, 0.59728384f, 0.19395308f, 
    0.25966075f, -0.91996336f, -0.62666982f, 0.44875273f, 0.25825700f, -1.00781929f, -1.38998389f, -0.37450233f, 
    -0.33915403f, 0.81469053f, -0.74193329f, -0.63629007f, -0.94812018f, 1.11036777f, -0.68927687f, 0.70815599f, 
    -0.07572408f, 0.06405900f, -0.35081995f, 0.36078766f, -0.81232899f, -0.19032814f, -0.82088792f, -0.38762754f, 
    0.62031633f, -0.44311750f, -0.02644765f, -0.31360522f, 0.57506990f, 0.41431877f, 0.92771387f, 1.08768392f, 
    0.77386141f, -1.18002903f, -0.11219120f, -0.44972792f, -0.39002067f, -0.41294312f, 0.05825802f, 0.26598427f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08479723f, 1.04703164f, 0.52104604f, 0.12343939f, 0.26494250f, 0.35079345f, 0.01682779f, -0.66582662f, 
    0.46617642f, -0.55018926f, 0.50874305f, 0.70226109f, 0.53700107f, 0.62859869f, 0.42425996f, 0.70875156f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02127133f, -0.04947675f, 0.03307728f, 0.05931843f, -0.02524189f, 0.02808939f, 0.06364197f, -0.07203212f, 
    0.05769511f, -0.08350798f, -0.00945846f, 0.02674357f, -0.08200658f, 0.04120147f, 0.02922055f, -0.07768790f, 
    -0.05214017f, -0.01496674f, -0.08019714f, 0.05405666f, -0.06300130f, 0.03474678f, 0.04450116f, -0.08370838f, 
    -0.02333382f, -0.07814141f, -0.06329411f, 0.04851910f, -0.09128458f, 0.00583886f, -0.04758999f, -0.06727886f, 
    0.00610708f, 0.04268279f, -0.08187404f, 0.01730198f, -0.00262892f, 0.06883974f, -0.00348230f, 0.01485362f, 
    0.05105918f, -0.00417155f, -0.01816433f, -0.03593871f, -0.00007725f, -0.07964994f, -0.00478528f, 0.06575670f, 
    0.04412497f, 0.02187409f, 0.05120115f, -0.01236127f, -0.05248233f, 0.05512171f, -0.04594290f, -0.07134707f, 
    0.06211511f, 0.02127120f, 0.01407527f, 0.01145851f, 0.04308121f, -0.00163346f, -0.00024714f, -0.00435470f, 
    -0.05355298f, -0.03147923f, -0.07233362f, -0.04389765f, -0.01769565f, -0.04254328f, -0.03857896f, 0.01974824f, 
    0.00022921f, 0.03431563f, 0.05357653f, -0.03181520f, -0.02991466f, -0.02827051f, 0.04213315f, -0.03065667f, 
    -0.03593516f, 0.04256718f, -0.08325568f, 0.05451249f, -0.07950625f, -0.04349332f, -0.03631522f, -0.03488195f, 
    -0.02955698f, 0.03152648f, 0.06077564f, -0.06545848f, -0.07796627f, 0.03520614f, -0.04012354f, 0.06657682f, 
    -0.05240916f, 0.04762599f, -0.05253021f, 0.01635294f, -0.02787284f, -0.00910721f, -0.05716552f, -0.06345776f, 
    -0.08813734f, 0.00594602f, -0.02124949f, 0.04235211f, 0.01758439f, -0.00208466f, -0.01059672f, 0.02284851f, 
    -0.02475400f, 0.04925707f, -0.08368651f, -0.04304045f, 0.01963760f, -0.05120359f, -0.07262505f, -0.04549832f, 
    -0.03722405f, 0.07068620f, 0.04178048f, -0.03864092f, -0.09097106f, -0.01706309f, -0.02393736f, -0.01401390f, 
    -0.00068981f, 0.05999858f, -0.04426261f, -0.01593461f, -0.05242681f, -0.02410547f, -0.00129181f, -0.02516657f, 
    -0.01875885f, -0.00905977f, -0.07951391f, -0.05922290f, 0.03463491f, -0.04910646f, -0.01758419f, -0.02393661f, 
    0.22240618f, 0.24176887f, 0.27956325f, -0.01802406f, -0.20589115f, 0.19804896f, 0.17802262f, 0.04050215f, 
    0.11939241f, 0.04547216f, 0.14042175f, -0.03919199f, 0.08518748f, 0.01746144f, -0.10943107f, 0.10368372f, 
    -0.00900095f, 0.02428513f, -0.77982634f, 0.26434189f, -0.06584227f, 0.00952162f, 0.24903299f, -0.04682103f, 
    -0.21698211f, -0.03676576f, 0.16509788f, 0.19661969f, 0.82696986f, 0.74273509f, -0.19359928f, -0.39901283f, 
    -0.02369360f, 0.04623307f, 0.10175852f, -0.13558531f, -1.13728893f, -0.31483430f, 0.22847892f, -0.16571604f, 
    0.15093598f, -0.11514968f, 0.00045007f, -0.00937817f, 0.11106113f, -0.04292596f, 0.04474836f, 0.41383165f, 
    -0.18767036f, -0.28545144f, -0.08379146f, -0.16127346f, -0.20048156f, 0.10832366f, -0.29185268f, 0.70455974f, 
    -0.81986982f, -0.06376871f, -0.18017401f, 0.05608162f, 0.16097391f, -0.30932224f, -0.14559487f, 0.22106624f, 
    -0.29491678f, 0.49866834f, -0.22089107f, 0.01599084f, -0.27708289f, 0.16322397f, 0.12555401f, 0.11485081f, 
    -0.34245792f, 0.32723266f, 0.30247083f, -0.11155111f, 0.07194986f, 0.15986657f, 0.06128764f, 0.31823176f, 
    -0.00037621f, 0.47347358f, -0.07343452f, 0.24485765f, -0.06287026f, 0.03036988f, -0.13654090f, 0.20532900f, 
    -0.02938668f, -0.04530336f, -0.10756528f, 0.15499011f, 0.25213692f, -0.14043282f, -0.25145516f, -0.14377369f, 
    0.21446200f, -0.22369520f, -0.20129709f, -0.17487961f, 0.25749964f, 0.06379177f, -0.17087330f, -0.01115767f, 
    -0.25318280f, -0.02370379f, -0.09927107f, -0.00585420f, 0.12437393f, 0.00204185f, -0.11130627f, 0.16769513f, 
    0.08928062f, -0.05581082f, 0.04155106f, -0.21362419f, 0.10983996f, -0.08957652f, -0.06913466f, 0.50406832f, 
    -0.22320747f, 0.19234945f, 0.19883899f, 0.45205182f, -0.00964133f, 0.07697936f, 0.01383140f, 0.42028925f, 
    0.09661068f, 0.36477709f, 0.13777667f, 0.16785784f, 0.04488108f, -0.04786634f, 0.01430284f, -0.49881348f, 
    -0.17433126f, -0.04071144f, -0.11861381f, 0.11806154f, 0.02348966f, 0.02077468f, 0.09781343f, 0.00756021f, 
    -0.07630770f, -0.14091286f, -0.86047447f, 0.00589185f, 0.08748805f, 0.02281085f, -0.12915054f, -0.17358252f, 
    -0.01875931f, 0.14769606f, 0.08706008f, 0.18226495f, 0.10009103f, 0.07086645f, 0.09068726f, 0.00563086f, 
    0.02028291f, -0.14322597f, -0.53318447f, 0.21106665f, -0.12944029f, 0.22588080f, 0.07160668f, 0.22134425f, 
    0.20851098f, -0.15944655f, -0.16486046f, -0.15868668f, -0.18550792f, -0.42267329f, -0.12463218f, 0.14650519f, 
    -0.33781403f, -0.06596114f, -0.06413424f, -0.08818413f, 0.58630919f, -1.04199088f, -0.17114304f, 0.05465773f, 
    0.22798704f, 0.03895485f, 0.10987113f, 0.00289506f, -0.11900699f, -0.09585866f, 0.36485907f, 0.25640562f, 
    -0.11444953f, -0.06787098f, -0.15314013f, 0.09052502f, 0.05593015f, 0.20217341f, -0.79018849f, -0.35815606f, 
    0.03258738f, -0.02407498f, -0.34278402f, 0.13098139f, 0.05504998f, 0.01473344f, -0.06448582f, 0.28877568f, 
    -0.01914741f, -0.16412109f, -0.04822064f, 0.08105928f, -0.13473710f, -0.16813208f, 0.22565420f, 0.05900570f, 
    0.33548239f, 0.24363637f, -0.05891569f, 0.18125391f, -0.14881098f, 0.14423753f, 0.21042474f, -0.12495529f, 
    -0.46120113f, -0.29341346f, 0.02959073f, 0.07209913f, -0.20865451f, -0.21086673f, -0.17168081f, 0.02930650f, 
    -0.05394625f, -0.08521731f, -0.36519796f, 0.43358827f, 0.35627267f, -0.06752767f, 0.16403553f, -0.37947157f, 
    -0.06913782f, 0.03850992f, 0.12855266f, -0.15785356f, 0.32298246f, 0.23535466f, 0.05304888f, 0.21363544f, 
    0.10730447f, 0.13495447f, 0.35445854f, 0.23937005f, 0.07469986f, -0.72439492f, -0.64695442f, -0.18343347f, 
    0.01995396f, -0.07162875f, 0.11864448f, 0.06601028f, 0.15508822f, -0.06497110f, -0.12999053f, -0.00467900f, 
    0.23332168f, 0.13892455f, 0.19788416f, 0.10915659f, 0.01097847f, 0.50295126f, -0.02881994f, 0.11399882f, 
    0.07233603f, -0.00763179f, 0.17569001f, 0.07957061f, -0.08841245f, -0.04979244f, -0.19016074f, 0.68113953f, 
    0.05205655f, -0.30349541f, 0.01438117f, 0.05729686f, 0.26204985f, 0.29187599f, -0.07885230f, 0.00847723f, 
    0.15753931f, 0.35710603f, 0.18860297f, 0.02839954f, 0.23769690f, 0.01444290f, 0.07316385f, -0.03604751f, 
    0.11724092f, -0.12351350f, -0.17812467f, 0.00434186f, 0.13113068f, 0.02520995f, 0.23924820f, 0.00449283f, 
    0.07288571f, 0.20090048f, -0.47684878f, -0.39344734f, 0.23917313f, -0.00794348f, -0.33162794f, -0.20567134f, 
    0.22376496f, 0.09444319f, 0.11552197f, 0.46541449f, 0.35582823f, 0.09436619f, -0.00537452f, -0.05179271f, 
    0.04892070f, -0.00339674f, 0.13504435f, -0.01415128f, -0.65779734f, -0.07415144f, -0.59932804f, -0.01838103f, 
    0.12120266f, 0.00284300f, 0.00670606f, 0.07937914f, 0.06328214f, 0.13502803f, -0.21223694f, 0.04815576f, 
    -0.02866519f, -0.00746829f, -0.17471841f, -0.02287986f, -0.05997277f, -0.03792038f, -0.22865024f, 0.07778787f, 
    0.95042908f, 0.12554584f, 0.00967820f, 0.06373706f, -0.03094948f, -0.10111471f, -0.03342718f, 0.37237018f, 
    0.58609182f, 0.03913971f, 0.02398907f, 0.07268238f, 0.11970997f, -0.01047315f, 0.03667443f, -0.15848796f, 
    -0.03867329f, -0.07254638f, -0.25965300f, 0.21083519f, 0.10090235f, -0.18302606f, 0.22148378f, 0.01336234f, 
    0.02077462f, -0.11778784f, -0.17888175f, 0.00291432f, 0.08355560f, -0.05127558f, 0.13162495f, -0.02415562f, 
    0.09607981f, -0.12128092f, 0.85496515f, 0.19390577f, -0.39128795f, -0.07735044f, -0.17378697f, 0.12406539f, 
    0.09505561f, -0.04696789f, -0.05169226f, -0.03253739f, -0.20549613f, -0.12086108f, 0.06275199f, 0.11188099f, 
    -0.14240097f, 0.18834409f, 0.00133539f, -0.17722289f, 0.42853880f, -0.05310632f, 0.21447448f, 0.00568219f, 
    0.12502255f, 0.02512632f, 0.06061170f, -0.01553948f, -0.31273255f, -0.22052246f, -0.40674901f, 0.15379825f, 
    -0.00946729f, 0.08163881f, -0.01912033f, -0.33561110f, 0.13822618f, -0.26389199f, -0.07655291f, 0.23071630f, 
    0.35307100f, -0.17627943f, 0.04762267f, -0.07606333f, 0.07954808f, 0.27203619f, 0.11441252f, -0.10259976f, 
    -0.33388904f, -0.32713175f, 0.08727349f, -0.03647861f, 0.37855983f, 0.07891588f, 0.10156129f, -0.16289712f, 
    -0.41013676f, 0.02537747f, 0.09765020f, 0.46656123f, 0.33173877f, 0.02043448f, -0.23266387f, -0.40925312f, 
    -0.24727674f, 0.05644611f, -0.08116128f, -0.03040545f, 0.11165878f, 0.04214655f, 0.18689218f, -0.17896736f, 
    -0.02263175f, -0.29425496f, -0.00522471f, -0.04517611f, -0.04501679f, 0.12019923f, 0.06936007f, -0.07808515f, 
    0.09629737f, -0.16111788f, 0.08653418f, -0.00860724f, 0.16560575f, -0.18099920f, 0.21604890f, -0.06378752f, 
    -0.09098631f, 0.02041209f, 0.15131056f, -0.02526199f, 0.51367915f, 0.45841628f, -0.24607967f, -0.16895023f, 
    -0.01345190f, 0.26996100f, 0.04099976f, 0.09296284f, -0.19457074f, -0.09065656f, -0.01191640f, 0.15622830f, 
    0.17679743f, 0.11148385f, 0.17230156f, 0.06087919f, -0.01022237f, -0.13214466f, 0.46069348f, 0.34096897f, 
    -0.15301129f, 0.07857536f, -0.08592408f, 0.46068332f, 0.16877930f, 0.15937606f, 0.25626430f, -0.09724778f, 
    0.25852570f, 0.31672826f, 0.12940255f, 0.04353720f, 0.07346331f, -0.05826247f, -0.06440404f, 0.18461590f, 
    -0.08015609f, 0.26364550f, -0.12862504f, 0.21024597f, 0.17198643f, -0.14714175f, 0.06545082f, -0.31265828f, 
    -0.09851816f, 0.00059812f, 0.02903558f, -0.03128306f, 0.16136891f, 0.19392489f, 0.32681656f, 0.00205282f, 
    -0.58378327f, -0.14760439f, -0.00932371f, -0.19323955f, 0.44647440f, 0.14274831f, 0.02616497f, 0.12204606f, 
    0.04583048f, -0.01531734f, 0.16402172f, -0.03203036f, -0.48909339f, -0.44174439f, 0.15795894f, 0.17844570f, 
    -0.02945001f, -0.08127967f, -0.04874415f, -0.24392244f, -0.30827358f, -0.31738469f, 0.00884844f, 0.05713620f, 
    0.04890992f, 0.32078987f, -0.02766773f, 0.15306784f, 0.38804236f, -0.22721457f, -0.25354409f, -0.10858358f, 
    0.12062771f, -0.09690053f, -0.07910983f, 0.16290025f, 0.17160276f, -0.02765986f, 0.05688448f, -0.00444454f, 
    -0.02232865f, 0.05429260f, 0.04370691f, -0.34308851f, -0.18290901f, -0.38044780f, -0.99029016f, -0.29771170f, 
    0.25150096f, 0.40851137f, 0.04756663f, 0.25526494f, -0.35309756f, 0.13488747f, 0.12581608f, -0.03014864f, 
    0.28031981f, -0.07789233f, -0.02483729f, 0.04080235f, -0.08895931f, 0.15131874f, 0.15499960f, 0.07421847f, 
    0.26510242f, 0.12052885f, -0.02471039f, 0.29228756f, 0.02509861f, 0.00366562f, 0.09255128f, 0.20252673f, 
    0.01663937f, 0.14947996f, -0.03535902f, -0.15031554f, 0.16751605f, -0.10082058f, 0.22104734f, 0.01207837f, 
    0.21440530f, 0.14439228f, 0.00374164f, 0.28724819f, 0.39141527f, -0.12296090f, -0.16405602f, 0.26128632f, 
    -0.08537699f, 0.04953438f, -0.02904210f, 0.08211864f, -0.57414758f, -0.25961703f, -0.01311037f, 0.05244198f, 
    -0.15716031f, 0.17331435f, 0.13652006f, 0.21158281f, 0.13097857f, 0.29825929f, -0.00670468f, 0.09009719f, 
    0.01710164f, 0.02815370f, -0.27828193f, -0.00144035f, -0.24551579f, -0.10481635f, 0.55388379f, 0.50998473f, 
    -0.56371081f, 0.22930047f, -0.25589949f, -0.13276818f, 0.12662311f, 0.05399411f, -0.23889454f, 0.79485494f, 
    0.53709084f, -0.27636620f, 0.01390580f, -0.31276128f, 0.18724298f, -0.10585097f, 0.15721516f, 0.17081740f, 
    0.35456777f, 0.08432835f, -0.16249254f, 0.02254983f, 0.19945621f, -0.40190804f, 0.30965540f, -0.09526950f, 
    0.30859879f, 0.18010704f, 0.03942259f, 0.17433549f, 0.03991431f, 0.03882952f, -0.12666257f, 0.00316268f, 
    -0.12705201f, -0.05855843f, -0.00736918f, -0.51384270f, -0.40475753f, -0.24072100f, -0.02216941f, -0.03166686f, 
    -0.05629561f, -0.15234205f, 0.04988572f, 0.05910274f, 0.07004718f, 0.15312946f, 0.20816958f, 0.01478384f, 
    0.01888020f, -0.01269922f, -0.16146936f, -0.08948241f, 0.32905143f, 0.17497346f, -0.30508849f, 0.01251464f, 
    -0.21069892f, -0.17344676f, -0.22157063f, -0.03531204f, -0.37845469f, 0.04173117f, 0.02780543f, -0.43768907f, 
    0.05122523f, 0.23175268f, 0.02668745f, -0.01330176f, 0.34700936f, -0.13360371f, 0.04967236f, -0.04057790f, 
    -0.05398048f, -0.19239332f, -0.00173101f, -0.03503063f, 0.25941420f, 0.34724274f, 0.18631686f, -0.28432864f, 
    -0.51707542f, -0.44661334f, -0.37034857f, 0.22326092f, 0.10577498f, -0.06810802f, -0.04001947f, 0.11929676f, 
    0.03859523f, 0.31525937f, 0.02933403f, -0.23630685f, -0.08705615f, -0.20639001f, 0.04883582f, -0.06037503f, 
    -0.27902916f, -0.01057803f, 0.16849808f, -0.08216751f, 0.20734982f, 0.31084135f, 0.25689334f, 0.19613054f, 
    0.18873790f, 0.11925586f, -0.14447127f, -0.02657116f, -0.34249556f, -0.15334614f, 0.23941760f, -0.04739358f, 
    0.08732545f, -0.14285091f, -0.10274775f, -0.61709273f, 0.55186200f, 0.07979979f, -0.01056831f, -0.23762479f, 
    -0.01606703f, -0.00920031f, 0.23675837f, 0.00148300f, -0.20742489f, -1.23910534f, -0.17093040f, 0.02297260f, 
    -0.02883413f, -0.26816386f, -0.04167436f, 0.04030658f, -0.00488753f, 0.00165006f, 0.26863712f, 0.28516176f, 
    0.03966115f, -0.08513112f, -0.37497562f, 0.28043461f, 0.08745766f, 0.16558206f, -0.60485929f, -0.48163590f, 
    0.48708057f, -0.04056339f, 0.06613997f, -0.13603529f, 0.08116887f, -0.18240559f, 0.05325135f, -0.03654036f, 
    0.19085325f, 0.44125175f, 0.11966176f, -0.28721318f, -0.02404134f, 0.29245937f, -0.05676683f, 0.15323803f, 
    -0.12393457f, -0.11370276f, -0.02239720f, -0.25468278f, 0.02918806f, 0.16765346f, -0.11927227f, -0.10677028f, 
    0.03939761f, 0.05643566f, 0.21867849f, -0.25924161f, -0.40885487f, -0.25709525f, -0.38451600f, 0.40634963f, 
    -0.02434788f, 0.07466482f, 0.08881465f, -0.14328089f, 0.25795731f, -0.03294023f, -0.28374401f, 0.08353025f, 
    -0.00708805f, 0.09025662f, 0.08775830f, -0.42510679f, 0.05409142f, 0.35674316f, -0.10255412f, -0.16502708f, 
    -0.12146346f, 0.16535781f, 0.29687163f, 0.13407306f, -0.15850624f, -0.21770205f, -0.32851791f, 0.05038777f, 
    -0.03134388f, 0.18161292f, 0.07882131f, 0.06466067f, 0.19077849f, 0.47691634f, -0.22697555f, 0.00568908f, 
    0.13833506f, 0.26408541f, 0.16619605f, 0.01535718f, -0.10414826f, -0.05590923f, 0.06431335f, 0.04431872f, 
    -0.14523555f, -0.09468277f, 0.29103333f, 0.08552647f, -0.06872169f, 0.01726326f, 0.00617118f, 0.84430051f, 
    0.00869382f, -0.70608395f, -0.04274615f, 0.23302352f, 0.08913200f, 0.04850347f, -0.23949911f, 0.04972985f, 
    0.24924029f, 0.41007641f, 0.64672345f, -0.17864098f, -0.06494167f, -0.05539668f, 0.03244155f, 0.10434987f, 
    0.23709783f, -0.27871928f, -0.36535057f, -0.11679120f, -0.12850733f, 0.03450102f, 0.14292647f, 0.07563599f, 
    0.08900294f, 0.24509738f, -0.98022676f, -0.61099088f, -0.35972846f, 0.06604663f, -0.17965531f, 0.27314776f, 
    0.19577922f, 0.16162029f, 0.20583609f, -0.11142160f, 0.11476466f, 0.49733239f, -0.30491430f, 0.05736400f, 
    -0.05875904f, 0.07438513f, 0.05943225f, 0.15274565f, -0.10692177f, -0.80212337f, -0.38235182f, 0.06347767f, 
    -0.21687676f, -0.02222869f, -0.07961436f, 0.12502578f, 0.03776064f, 0.01655578f, 0.07089636f, 0.19592410f, 
    -0.31717908f, -0.15120259f, -0.23448776f, -0.07059316f, -0.34526509f, 0.08091768f, -0.74612284f, -0.17567749f, 
    0.09979098f, -0.29471445f, -0.00483370f, 0.06841502f, -0.07042097f, 0.13256507f, 0.16868460f, 0.39231160f, 
    0.37871549f, 0.37351158f, -0.19285119f, -0.10149430f, -0.10694641f, 0.01334154f, 0.06597536f, 0.14392889f, 
    -0.08157158f, -0.29112414f, 0.16728796f, -0.22548181f, 0.09774541f, -0.02392794f, -0.11025065f, 0.03506375f, 
    0.41945192f, 0.20157833f, -0.03268615f, -0.22970809f, -0.53532088f, -0.16442648f, -0.04754084f, 0.18869516f, 
    0.14180301f, 0.22909525f, 0.46819094f, -0.02313164f, 0.00935778f, 0.08358782f, 0.03150361f, -0.02925657f, 
    0.13427146f, 0.01926110f, 0.00959099f, -0.55729169f, -0.04817126f, 0.04577656f, -0.41071150f, -0.05698501f, 
    0.11634368f, 0.39657739f, 0.02205629f, -0.06844477f, 0.12201735f, 0.27848393f, 0.23485766f, 0.03613175f, 
    0.10269100f, 0.01165880f, 0.13969700f, -0.11359524f, -0.28533384f, 0.36625767f, -0.53887004f, -0.24855655f, 
    -0.38886997f, -0.04001551f, 0.09891282f, 0.05879531f, -0.20493916f, -0.22767988f, 0.26336595f, 0.27159938f, 
    0.07277784f, 0.12548052f, 0.15065764f, 0.00603740f, -0.11659119f, 0.13595279f, 0.26854372f, -0.22614738f, 
    -0.39099085f, -0.43754071f, -0.12090907f, 0.04987982f, -0.03934386f, -0.08124233f, 0.11555968f, -0.07772932f, 
    -0.08403528f, -0.22770949f, 0.31992537f, -0.00305641f, 0.07287398f, -0.23284371f, 0.17873496f, 0.04891194f, 
    0.01936347f, -0.05970098f, -0.33304888f, -0.20312086f, 0.25893709f, -0.09934743f, -0.08502962f, 0.09706497f, 
    0.29156831f, 0.20954713f, 0.05413480f, 0.40428236f, -0.51665533f, -0.00331132f, -0.17822634f, 0.24514557f, 
    0.10089882f, 0.20849989f, 0.01207562f, -0.32312748f, -0.11849005f, 0.80179197f, 0.17005570f, -0.05346620f, 
    0.00261026f, -0.00153750f, -0.12618761f, 0.12835675f, -0.17212272f, 0.27369073f, 0.14508016f, -0.07524675f, 
    -0.14387757f, -0.28723508f, 0.08972105f, 0.11013787f, 0.11454959f, -0.36407945f, -0.23778601f, 0.38866037f, 
    0.10582564f, -0.09075611f, -0.21454769f, -0.10182749f, 0.13923869f, 0.05508944f, -0.17392612f, 0.05743484f, 
    -0.13919944f, -0.14782819f, -0.42898846f, -0.28441554f, 0.04486482f, 0.07380860f, 0.02827934f, -0.13462564f, 
    -0.13455522f, 0.65141058f, -0.08500111f, -0.16375910f, -0.35426173f, -0.02517275f, 0.14463121f, -0.02883116f, 
    0.02414803f, 0.34030572f, -0.40589735f, -0.28559917f, 0.04671699f, -0.08228991f, 0.00406765f, -0.12641661f, 
    -0.06887908f, 0.13248651f, 0.10886009f, 0.23151839f, -0.04899031f, -0.03199750f, -0.30380297f, 0.16903111f, 
    0.02272537f, 0.27512944f, -0.53842711f, -0.25036088f, 0.00297881f, 0.13321087f, -0.13176470f, 0.00252042f, 
    -0.00776340f, 0.00680436f, 0.11349440f, -0.35760847f, -0.12450138f, 0.15869866f, 0.12802884f, -0.01193547f, 
    0.07979243f, -0.04705074f, 0.12777223f, -0.27461696f, 0.18559159f, 0.32293385f, -0.48914167f, 0.05522830f, 
    -0.11796001f, -0.03659480f, -0.20658702f, 0.05493584f, 0.15604696f, 0.48595718f, -0.02229438f, 0.25989947f, 
    -0.06268873f, -0.05044658f, -0.00971184f, -0.08721762f, 0.11769886f, -0.00229616f, -0.12783089f, -0.45900267f, 
    0.04481388f, -0.01414039f, -0.06403019f, -0.17872685f, -0.01115718f, 0.00863426f, -0.08407082f, 0.89739949f, 
    0.38381612f, -0.13259411f, 0.05283421f, 0.40401056f, 0.31916827f, 0.15634939f, 0.09116521f, 0.08594871f, 
    -0.31109250f, -0.15953290f, -0.26242420f, -0.04803179f, -0.03104903f, -0.12244833f, 0.09594243f, 0.25492766f, 
    0.14131072f, 0.02571847f, 0.08865831f, 0.06076898f, 0.26366040f, 0.17798948f, -0.00300091f, 0.11940503f, 
    0.30340266f, 0.17185099f, 0.24306077f, -0.04702254f, 0.28403261f, 0.25740898f, 0.00083867f, -0.07117642f, 
    0.49461877f, 0.09820995f, 0.11393560f, 0.12983321f, -0.19726880f, 0.19003843f, 0.09278373f, 0.16219971f, 
    -0.14462990f, 0.34586990f, 0.12490246f, 0.24873403f, -0.09836905f, -0.98266429f, 0.19892927f, 0.13998593f, 
    -0.00238464f, 0.21324067f, 0.10176406f, 0.11552642f, 0.12631285f, -0.07107822f, 0.07066644f, 0.06809819f, 
    0.05499393f, 0.03737117f, 0.06784496f, -0.28499675f, -0.08948344f, -0.09450854f, 0.12677467f, -0.39164260f, 
    0.20481583f, 0.19129552f, -0.25006425f, -0.00459103f, 0.08644804f, -0.08466993f, -0.04833752f, -0.31604356f, 
    -0.34021303f, -0.00380989f, 0.01132578f, 0.05198563f, 0.01477692f, 0.10220444f, 0.05912235f, -0.28370351f, 
    0.33046439f, -0.14740494f, 0.60795784f, -0.23813738f, 0.09434203f, 0.01748535f, 0.30581194f, 0.14830606f, 
    0.41631711f, -0.22856924f, -0.17230155f, -0.33102944f, 0.21766008f, 0.06020901f, -0.09978002f, -0.05330766f, 
    -0.06394375f, -0.23657452f, -0.26820824f, -0.23360084f, -0.08184234f, -0.25989491f, 0.21449344f, 0.09646016f, 
    -0.05832213f, -0.15337080f, 0.16503459f, -0.01506130f, 0.27318314f, 0.34991983f, 0.13838218f, -0.14090823f, 
    0.02633230f, 0.11438553f, -0.10008290f, -0.05228189f, -0.14001858f, -0.24355809f, -0.09957102f, -0.10806056f, 
    -0.16641018f, -0.18555892f, 0.03407721f, 0.06470214f, 0.44359511f, -0.21159942f, -0.05943630f, 0.16660164f, 
    -0.11677672f, -0.05073403f, 0.31763461f, -0.04840520f, -0.00386823f, 0.05109627f, -0.25522387f, 0.10738567f, 
    0.08642419f, -0.18087269f, 0.03586049f, -0.02897123f, 0.37822798f, 0.38884017f, 0.18008459f, 0.35378319f, 
    -0.49562073f, 0.28200567f, 0.03518850f, 0.34853756f, 0.19436964f, 0.21195969f, -0.13600537f, 0.35491207f, 
    -0.48682299f, -0.15812470f, -0.19167632f, 0.19902094f, 0.01004653f, 0.01568029f, 0.00728894f, -0.10720161f, 
    -0.04839438f, 0.39706388f, 0.09898786f, 0.30849493f, -0.00459425f, -0.08849885f, -0.00078286f, 0.20656897f, 
    -0.23458961f, 0.09210723f, 0.26758671f, 0.19119927f, -0.34304333f, -0.15347154f, 0.11769948f, -0.23538323f, 
    0.03799086f, -0.14814454f, 0.31700584f, -0.34547335f, 0.06088331f, -0.27045393f, -0.08482219f, 0.03734843f, 
    -0.06515684f, -0.12604159f, -0.23175450f, -0.04185807f, -0.46176511f, -0.48701555f, 0.74219328f, -0.08947320f, 
    -0.11794984f, -0.10148183f, 0.03810759f, 0.06442109f, 0.10335607f, 0.06796572f, 0.20064574f, 0.01868416f, 
    -0.20179307f, -0.11562870f, -0.27715510f, -0.11470269f, -0.33145013f, -0.11032670f, -0.01074414f, -0.11599809f, 
    -0.23451583f, 0.21328124f, -0.13064122f, -0.38201654f, 0.08134383f, 0.00397540f, -0.11747548f, -0.22613946f, 
    0.34237772f, -0.13207638f, -0.03934961f, -0.11462435f, -0.20371224f, 0.03643192f, 0.08404841f, -0.13824615f, 
    -0.20044005f, 0.02741014f, 0.25496781f, 0.05694875f, 0.33935869f, -0.19303592f, 0.02634796f, 0.14464000f, 
    0.16596808f, 0.18302603f, 0.17985874f, 0.19979098f, -0.66870898f, -0.43306369f, -0.54759425f, -0.03646437f, 
    -0.05813558f, 0.01624447f, -0.26196378f, -0.02128550f, 0.08115425f, -0.31173503f, -0.13481349f, 0.11587738f, 
    0.03844506f, 0.01724243f, 0.00692692f, -0.02561205f, 0.04586999f, 0.05889168f, 0.27803823f, 0.09289438f, 
    -0.14668041f, 0.04268690f, 0.00504678f, -0.06356049f, -0.28055280f, 0.41127875f, -0.05874882f, -0.09069099f, 
    0.02082901f, 0.06981055f, -0.13511686f, 0.09640892f, -0.04473086f, 0.33746886f, 0.15102021f, 0.19498311f, 
    -0.06151966f, 0.12075687f, -0.03782020f, 0.09658632f, -0.08373975f, 0.28874385f, 0.00475366f, -0.05265187f, 
    -0.07940996f, 0.35568500f, -0.00450095f, 0.19776119f, -0.02015801f, 0.15180512f, 0.18535036f, -0.16075709f, 
    0.31949905f, 0.40425894f, 0.18479837f, -0.00250516f, 0.26364440f, 0.18488996f, 0.09555294f, 0.10794024f, 
    -0.23610817f, -0.43406233f, 0.12213664f, -0.19764695f, -0.02150381f, -0.00209577f, -0.09541495f, -0.12125689f, 
    0.16879325f, -0.15631215f, 0.22270018f, 0.07927425f, -0.13718300f, 0.04704818f, -0.07159873f, 0.19408190f, 
    0.11837471f, -0.09438367f, 1.02161443f, 0.22639725f, -0.44588131f, -0.11187002f, 0.09100600f, -0.20281425f, 
    -0.12476286f, 0.04238486f, -0.14059520f, 0.05345194f, -0.27839196f, 0.48796925f, 0.05908426f, 0.07588951f, 
    -0.11671943f, -0.03386947f, 0.20346346f, -0.04280439f, 0.10765366f, 0.54948986f, 0.41953409f, -0.15911379f, 
    -0.05740860f, -0.34059003f, 0.11195181f, 0.28053191f, 0.02809090f, -0.09332178f, -0.19327317f, 0.18961327f, 
    -0.20507379f, 0.17786267f, -0.06190452f, -0.14234506f, -0.19922653f, 0.11973032f, 0.89938146f, -0.40867749f, 
    -0.08278821f, 0.08097570f, 0.00032923f, 0.24604687f, 0.14153618f, -0.13497841f, 0.11236417f, 0.12078271f, 
    0.32773176f, -0.07907709f, 0.06720248f, -0.19307670f, 0.13680679f, 0.02836452f, 0.04824966f, 0.06066874f, 
    -0.02369281f, 0.16236301f, 0.42104295f, 0.12951618f, 0.10782866f, -0.06826479f, 0.22493890f, 0.21400338f, 
    0.27742672f, -0.08957001f, -0.00275387f, -0.16808012f, -0.28714898f, 0.02383522f, -0.21997088f, 0.33711684f, 
    -0.10203994f, -0.11944887f, 0.47050369f, -0.95574963f, -1.03591776f, -0.28653589f, -0.00216314f, 0.21942301f, 
    0.08123428f, -0.28394416f, 0.01161626f, -0.19884968f, 0.00124347f, -0.61684543f, 0.02449431f, 0.08049230f, 
    -0.06519111f, 0.00836028f, -0.15457825f, 0.31622076f, 0.11972553f, -0.46924695f, -0.72675264f, 0.21099807f, 
    -0.18319492f, 0.11440503f, 0.05623506f, -0.03943463f, -0.16392675f, 0.09466532f, -0.08431029f, 0.55106324f, 
    -0.17473605f, -0.05707139f, -0.02334084f, 0.01728312f, -0.08498674f, 0.22768459f, 0.04944514f, -0.05272044f, 
    -0.14927711f, 0.13535987f, 0.12674704f, -0.06155584f, 0.28570005f, 0.05042688f, 0.03123038f, -0.45162433f, 
    -0.48429698f, 0.36168176f, -0.00352502f, 0.04250721f, 0.16265699f, 0.20589016f, 0.19811776f, 0.20768048f, 
    0.54357773f, 0.33173531f, 0.01213667f, -0.09321604f, 0.12365433f, 0.06264655f, -0.00104720f, -0.31579673f, 
    -0.25616035f, 0.04062104f, 0.04616545f, 0.13656218f, -0.45935124f, -0.15445583f, -0.35160762f, 0.04284787f, 
    0.10155871f, -0.04870468f, -0.11049160f, 0.04118166f, -0.29903778f, -0.36815348f, -0.04163055f, -0.07731078f, 
    -0.12085371f, 0.38628474f, -0.05957879f, 0.20951961f, -0.15846846f, 0.24273570f, -0.00566542f, -0.23122545f, 
    -0.16910875f, -0.24225882f, 0.00058945f, -0.09320250f, -0.32103291f, -0.06442657f, 0.06933807f, -0.10903277f, 
    0.14134595f, -0.04269096f, 0.19493206f, -0.30164412f, -0.07414909f, 0.16902505f, 0.08736417f, 0.16822934f, 
    -0.17965367f, -0.36799127f, -0.05258595f, 0.18511789f, 0.05399082f, 0.00172204f, 1.14033806f, 0.40427971f, 
    0.29290557f, -0.07683103f, -0.02271253f, -0.18154597f, -0.08927136f, 0.01716268f, -0.10496670f, 0.74557638f, 
    0.37480998f, 0.06199211f, 0.06413457f, -0.17134796f, -0.17987917f, -0.13327631f, -0.11771931f, 0.06721966f, 
    -0.03442631f, -0.23609470f, 0.04554192f, -0.33580607f, 0.20442577f, -0.24189970f, -0.06084704f, 0.06166452f, 
    0.24537675f, 0.33564961f, 0.19003735f, 0.25014257f, -0.38594362f, -0.35297325f, -0.29682010f, 0.21031111f, 
    0.10917971f, 0.11733244f, -0.08935613f, -0.30508441f, 0.23232074f, 0.26106468f, -0.21531337f, -0.11338214f, 
    -0.04860411f, 0.26379010f, 0.12901448f, 0.22660783f, -0.06888126f, -0.13886802f, -0.05335353f, -0.07905488f, 
    0.10821148f, 0.06824648f, 0.35314414f, -0.24597025f, 0.05021803f, 0.03797470f, 0.00451205f, 0.20382515f, 
    0.01068040f, 0.08104931f, -0.00951363f, 0.09151039f, -0.00282643f, -0.37682250f, -0.06363962f, -0.05829904f, 
    -0.08144639f, 0.30862066f, 0.06314315f, 0.03727496f, -0.06678232f, 0.18416445f, 0.33325815f, 0.33428764f, 
    0.08543587f, -0.12561175f, 0.05392388f, 0.03991685f, -0.02094952f, -0.08527767f, -0.26527235f, 0.14315698f, 
    0.16293605f, 0.41051811f, -0.19578207f, -0.06546506f, -0.23013306f, -0.14935051f, 0.01866145f, -0.20018214f, 
    -1.23008657f, -1.21583951f, 0.25951034f, -0.08093745f, -0.12801620f, -0.23424022f, 0.05397433f, -0.10060951f, 
    0.03771815f, -0.07338302f, -0.03800907f, 0.00415752f, -0.15362953f, -0.04536343f, 0.04409437f, -0.02894812f, 
    -0.01380820f, -0.08450083f, 0.30449751f, -0.04770932f, -0.55954963f, -0.07987306f, 0.10223701f, 0.09769476f, 
    0.03866846f, 0.27665600f, -0.03372976f, -0.56667417f, -0.02975429f, 1.05345535f, 0.10639925f, -0.01175517f, 
    -0.02571166f, 0.06878716f, -0.01385275f, 0.11241721f, -1.15627050f, -0.45943943f, -0.13234383f, -0.05129559f, 
    -0.05760022f, -0.16090401f, 0.04188013f, 0.11045541f, 0.11270263f, 0.03914870f, 0.10779199f, 0.02358399f, 
    0.06439136f, -0.11788148f, -0.10490730f, 0.11004587f, 0.13785934f, 0.11752490f, 0.72708118f, -0.15805492f, 
    -0.85135812f, -0.35853842f, -0.07321123f, 0.09666879f, -0.20843592f, -0.01357695f, 0.05783695f, -0.01591635f, 
    -0.10134229f, -0.56749463f, -0.20690012f, -0.09431186f, -0.13216797f, 0.03955442f, -0.01065319f, 0.12298653f, 
    0.07950935f, -0.15595973f, 0.20159538f, 0.07294873f, -0.11788256f, 0.01140582f, 0.09286285f, 0.12835163f, 
    0.25845480f, -0.06917088f, -0.08817953f, -0.07494549f, -0.61325502f, 0.03193185f, -0.00629812f, 0.07155432f, 
    0.06648129f, 0.14221169f, 0.72186476f, 0.57528174f, -0.40383568f, -0.07633120f, 0.26040187f, 0.14543769f, 
    0.01961641f, -0.05929066f, -0.00399774f, -0.01627972f, -0.06707822f, -0.16390459f, 0.22055353f, 0.04400644f, 
    0.08897965f, 0.25139314f, -0.00181169f, 0.23520495f, 0.22885774f, 0.02793114f, -0.34900048f, 0.19044758f, 
    0.08769238f, 0.19669339f, -0.06217213f, -0.01085551f, -0.04725447f, 0.34930947f, -0.22260369f, -0.13770673f, 
    -0.11648284f, 0.01528898f, -0.09802179f, 0.11408948f, 0.10355475f, 0.22051418f, 0.05715732f, -0.05286825f, 
    -0.05783001f, 0.01841195f, -0.23098446f, 0.11635035f, 0.06837970f, 0.03789854f, 0.24710833f, 0.04627347f, 
    0.11627924f, 0.07247384f, 0.12229892f, 0.12607749f, 0.03643350f, -0.07648139f, -0.00200081f, 0.24677841f, 
    0.01093877f, -0.03111237f, 0.20468286f, -0.11515581f, -0.21526021f, -0.26046443f, 0.09607895f, -0.02614304f, 
    -0.00716834f, -0.04162655f, 0.07758924f, 0.02252289f, 0.12784410f, 0.23503125f, 0.21923672f, 0.17090239f, 
    0.20322302f, 0.06571262f, 0.05762005f, 0.09578785f, -0.37384257f, -0.00961513f, -0.04109270f, -0.02387395f, 
    0.10517257f, 0.19449942f, 0.19638355f, -0.22980814f, -0.51982605f, 0.05160552f, -0.09390277f, -0.15081170f, 
    -0.11641120f, -0.03397698f, 0.11403259f, -0.03198094f, -0.62402618f, -0.13317999f, -0.19751154f, -0.11088077f, 
    0.01462703f, -0.10003128f, 0.01009777f, -0.06975914f, -0.05317779f, -0.04934287f, -0.12203967f, -0.01519455f, 
    -0.15890987f, -0.19375177f, -0.19148910f, 0.23720245f, 0.18087198f, 0.12797073f, 0.01875769f, -0.13501243f, 
    -0.69481111f, -0.18902913f, -0.14815111f, -0.09576555f, 0.04425361f, 0.09254414f, 0.29518655f, -0.48118821f, 
    -0.80538994f, -0.19351931f, -0.06821455f, -0.04559267f, 0.12376823f, 0.10174705f, -0.08367525f, 0.14959784f, 
    -0.54345500f, -0.04390533f, 0.07824597f, 0.00804161f, -0.07055163f, 0.05831739f, 0.13292700f, 0.36052698f, 
    0.52420992f, -0.30001771f, -0.42681316f, -0.19841294f, -0.08319046f, -0.08332852f, -0.20606853f, 0.09121005f, 
    -0.04040344f, 0.07487272f, 0.00866616f, 0.17660065f, 0.89863205f, -0.02096374f, -0.30874059f, 0.00435639f, 
    -0.02644775f, 0.00811776f, 0.14961457f, 0.10908420f, 0.02256256f, -0.06300614f, -0.33029360f, -0.07604080f, 
    -0.01299689f, 0.52285117f, 0.35240915f, 0.33538935f, 0.11684696f, -0.22892320f, 0.58762056f, 0.00674894f, 
    0.00626510f, 0.31202698f, 0.19121975f, 0.24380700f, -0.11677932f, -0.02054155f, -0.24727650f, 0.08842888f, 
    -0.10018418f, 0.06647365f, -0.06658608f, 0.40702936f, 0.27746484f, -0.03654392f, 0.15779209f, -0.26791787f, 
    -0.34185213f, -0.02957924f, -0.14274482f, -0.14207186f, 0.10008481f, 0.16410108f, 0.14309096f, -0.22340299f, 
    0.69928098f, 0.02498838f, 0.17448328f, 0.27065626f, 0.00841361f, 0.10444105f, 0.25516030f, 0.00933999f, 
    0.72452223f, 0.29827380f, 0.35012004f, -0.08145706f, -0.15524623f, 0.09956495f, -0.15583587f, -0.21836002f, 
    -0.16099331f, 0.23888816f, -0.27591231f, -0.59523481f, 0.15932395f, 0.04186719f, -0.16481753f, -0.05629017f, 
    0.03451879f, -0.00086859f, -0.18114349f, -0.30377257f, -0.98851031f, -0.02528092f, -0.21857664f, -0.16277850f, 
    0.04757680f, -0.06387498f, 0.32929721f, 0.01535693f, -0.02742818f, 0.36782083f, -0.15286580f, -0.10673770f, 
    0.11119268f, 0.05411913f, -0.04371659f, -0.13218758f, 0.15590934f, -0.31887206f, -0.00082551f, -0.10012114f, 
    -0.27215600f, 0.03105253f, 0.06195939f, 0.02013269f, 0.07871662f, 0.01760990f, -0.83869010f, -0.42576227f, 
    -0.10005570f, 0.17289306f, 0.04865859f, -0.09879497f, 0.03845622f, 0.04233788f, -0.02181193f, -0.09986374f, 
    -0.16899160f, 0.18625210f, -0.00922332f, -0.13350801f, 0.08860572f, 0.18555678f, 0.06181792f, 0.21562840f, 
    0.14154583f, 0.52859420f, 0.34291264f, -0.00636466f, 0.03774251f, 0.03656355f, -0.06059710f, -0.14512804f, 
    -0.16177198f, -0.07011589f, -0.46103626f, 0.07884107f, -0.18185289f, 0.05092740f, -0.09109531f, -0.02955505f, 
    -0.02928123f, 0.01140635f, 0.06284432f, -0.48780355f, 0.18502660f, -0.10245895f, 0.13986793f, -0.06254472f, 
    -0.04838413f, 0.27120358f, -0.08156893f, -0.00949941f, 0.34562171f, 0.24387491f, 0.26174027f, 0.24317436f, 
    0.12295653f, 0.13343309f, 0.23357262f, 0.09358187f, -0.12188559f, -0.26537853f, 0.29705572f, 0.11515398f, 
    0.16023655f, 0.06861113f, 0.05594324f, 0.01770891f, 0.27797076f, 0.19064897f, -0.09095150f, 0.15001249f, 
    0.17315975f, 0.09632061f, 0.00114575f, 0.14037675f, -0.11404838f, -0.23365828f, -0.00187505f, -0.66344583f, 
    0.08146764f, 0.02877831f, -0.37485236f, -0.07199918f, -0.13860546f, 0.05604655f, 0.25031728f, 0.18153173f, 
    -0.10764492f, 0.12245240f, -0.14583065f, -0.16662966f, 0.03578560f, -0.30255634f, -0.17999569f, 0.25887224f, 
    0.06572709f, 0.07817748f, -0.04212137f, -0.24692179f, -0.18995678f, 0.05983336f, 0.06164176f, -0.05734951f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03895156f, 0.00078343f, 0.33863610f, 0.09372552f, -0.28741071f, 0.02474095f, 0.34358019f, 0.00254803f, 
    0.24795371f, 0.41239715f, 0.25404063f, 0.00109143f, -0.36887193f, 0.11303194f, 0.70933706f, -0.02314756f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20046204f, 0.04752839f, 0.22378628f, 0.65909922f, -0.19663425f, 0.41547760f, -0.37761223f, 0.30299488f, 
    -1.65960920f, -0.54246479f, 0.10646500f, -0.54349238f, 0.25722033f, -0.04685002f, -0.34358966f, 0.10068136f, 
    -0.10176222f, -0.07546454f, 0.26915100f, 0.16235383f, -0.74165213f, 0.22307229f, 0.02628580f, 0.57578832f, 
    0.06869207f, 0.19290207f, 0.37546274f, -0.09997353f, -0.44854766f, -0.25595546f, -0.23475213f, 0.23436280f, 
    -0.16496590f, -0.20197742f, -0.43189815f, -0.08922106f, 0.38121286f, -0.24736834f, -0.17701921f, -0.90108025f, 
    -0.57619888f, -0.08939383f, 0.45985392f, -1.01553810f, 0.16803917f, 0.63500297f, 0.78511202f, -0.34472620f, 
    0.01962139f, 0.32187232f, -0.73015720f, -0.06746136f, 0.45076635f, 0.28618670f, -1.13889551f, -0.57858407f, 
    -0.01205763f, -0.17031954f, -0.99846715f, 0.18994741f, 0.56900871f, 0.20045796f, 0.05353033f, 0.38745511f, 
    -0.04876771f, 0.36652049f, 0.11159639f, -0.03850792f, 0.32274520f, -0.42761403f, 0.30715266f, 0.55007243f, 
    -0.40192109f, -0.34084064f, -0.07298833f, 0.20283909f, -0.08858743f, -0.52046669f, -0.10582504f, 0.27924892f, 
    -0.16130549f, -0.27548030f, -0.27707008f, 0.08375502f, -0.26350114f, 0.25292289f, 0.21967427f, 0.04794918f, 
    0.80357140f, 0.27012166f, -0.09197889f, -0.20846221f, -0.16759740f, -0.26391530f, -0.14650506f, 0.24281855f, 
    -0.13025489f, -0.71417516f, 0.89968860f, -0.72685176f, 0.39301857f, -0.34541926f, 0.36190206f, -0.76377088f, 
    -0.34955829f, 0.20760332f, -0.35872725f, -0.59223711f, -0.45034432f, 0.97339058f, -0.15283041f, -0.36687264f, 
    -0.06704021f, -0.41536972f, -0.37196413f, -0.48303869f, 0.19944769f, -0.27754158f, 0.13684203f, 0.22564903f, 
    0.02166742f, -0.17546740f, 0.45041126f, 0.85655999f, 0.18399709f, 0.74176252f, -0.58449548f, 0.12589051f, 
    -0.20190465f, -0.34858438f, -0.39777115f, 0.55734348f, -0.26442859f, 0.37739867f, -0.71046066f, -0.34848467f, 
    -0.13459721f, 0.09191016f, -0.13732708f, 0.91494668f, -0.80394870f, 0.10494964f, 0.17656641f, -0.94853586f, 
    0.04891521f, -0.30460769f, 0.49029055f, -0.36311209f, 0.41218221f, -0.48151621f, 0.70871603f, 0.02028566f, 
    -0.53715611f, 0.03196324f, -0.39783138f, -0.22836696f, -0.15274370f, -1.18476832f, 0.60961258f, -0.05803999f, 
    -0.15415607f, 0.81609797f, -0.47937250f, 0.18163200f, -0.76415873f, -0.45435080f, 0.16963686f, 0.21125036f, 
    -0.54596919f, 0.06903398f, -0.38922325f, 0.14161938f, 0.14669780f, 0.41686222f, 0.15459354f, -1.14872015f, 
    0.13978776f, 0.14137460f, 0.09660410f, -0.25132096f, 0.17273489f, -0.70374984f, -1.14161932f, -1.53211486f, 
    1.32665169f, 0.46683249f, -0.57892829f, 0.06347749f, -0.56628722f, -0.65241033f, 0.01821522f, -0.20775931f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.53332180f, 0.45057958f, 0.46095189f, -0.00131785f, -0.30421042f, -0.28948227f, -0.08833650f, -0.90359390f, 
    -0.04345703f, 0.30984950f, -0.07219512f, 0.13817793f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
