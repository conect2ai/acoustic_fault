#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.26999629f, 0.11766907f, 0.75545740f, -0.27715015f, -0.42732134f, -0.66624522f, -0.00281561f, -0.12761767f, 
    0.39731359f, 0.27753523f, 0.65191007f, -0.19568235f, -0.08571460f, -0.58854938f, 0.45543218f, 0.24595591f, 
    -0.69156581f, 0.71340239f, -1.50915432f, -0.79986447f, 0.73793578f, 0.15048438f, 1.16212904f, 0.65512639f, 
    -0.04094046f, -0.32054597f, -0.25034025f, -1.07224679f, -1.40229726f, -0.46308199f, -0.64424956f, -0.41730350f, 
    -0.09402767f, 0.29114068f, -0.57503146f, -0.46209213f, 0.59044975f, 0.48164457f, 0.08277589f, 0.42162395f, 
    1.00574088f, 0.70245183f, -0.32764062f, 0.55193543f, -0.12586230f, -1.46851027f, 0.76757139f, 0.39052105f, 
    0.53413337f, 0.79122978f, 0.14050891f, -0.47204229f, -0.01092678f, -0.77363455f, 0.10451742f, -0.56418312f, 
    1.21506882f, -0.70376116f, -0.50564885f, -0.08630246f, 0.39702174f, 0.09759337f, 0.11584038f, -0.24861582f, 
    -0.88324088f, 0.57008302f, -0.99753284f, -1.39504635f, -1.08349061f, 0.76339144f, 0.07970569f, 0.16568221f, 
    0.90471572f, -0.44027117f, -0.75094223f, -0.55966395f, -0.62675446f, -0.01031034f, 0.62250686f, 0.35406098f, 
    0.79657054f, 0.65277505f, 0.94854510f, 0.26933840f, -0.82244074f, -1.14986837f, -0.58677906f, -0.39466470f, 
    -0.70779496f, -0.47976413f, -1.18966961f, -1.24880338f, -1.10730278f, -0.13136587f, 0.52049381f, 0.81615508f, 
    0.38979575f, 0.42059201f, 0.26856557f, -0.22095765f, -0.69142020f, -0.92523849f, -0.16789722f, -0.69390607f, 
    -0.49963868f, -0.19410087f, 1.22624731f, -0.53634232f, -1.46041393f, -0.98440802f, 0.81205738f, 0.24547455f, 
    -0.56595635f, -1.48037219f, -0.65839398f, 0.15284736f, -0.79333591f, 0.04916248f, 0.30725437f, -0.57239395f, 
    -0.53521776f, 0.72199297f, -1.14172447f, -0.75409955f, -0.36634099f, -0.94555575f, -1.03402698f, -0.09962401f, 
    -0.61933017f, -0.25606617f, -0.79363191f, 0.21943943f, -0.55268985f, -0.68081838f, 0.42780313f, 1.41828954f, 
    -1.02319515f, -1.80702567f, 0.99686807f, 0.69311827f, 0.12718822f, -0.31727123f, 0.31369945f, -0.33441317f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27809989f, 0.50359267f, 0.11045061f, -0.00105464f, 0.09044044f, 0.17767559f, 0.53555143f, 0.12543626f, 
    0.38222620f, 0.08017844f, 0.33432505f, 0.15129954f, -0.11542428f, -0.07351545f, 0.29316035f, 0.54831725f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27280739f, -0.19652943f, -0.09947626f, -0.26423922f, -0.16660483f, -0.05368502f, 0.06324659f, -0.22589755f, 
    -0.07156377f, -0.01315898f, 0.09725829f, 0.04467085f, 0.05509761f, 0.14527021f, 0.06146958f, -0.02168529f, 
    0.04876146f, -0.33078682f, -0.27880684f, -0.07519798f, -0.27712670f, -0.33473909f, 0.13297972f, 0.00179633f, 
    -0.16188098f, -0.01804711f, -0.08073838f, -0.04206344f, -0.00134679f, 0.05568727f, -0.04365882f, -0.06269194f, 
    -0.20374092f, -0.08603664f, -0.06206304f, -0.24085563f, -0.17045909f, -0.26832134f, -0.05011551f, -0.29633969f, 
    0.57691765f, -0.57743979f, -0.05426871f, -0.13405453f, -0.13140841f, -0.10130024f, 0.03801809f, 0.17755973f, 
    0.21858269f, -0.02596715f, -0.01015000f, 0.01507373f, 0.10119620f, 0.11271727f, -0.11093823f, 0.07396924f, 
    0.12140074f, 0.02927895f, 0.04369874f, 0.03504973f, 0.48394462f, 0.22832912f, 0.14096355f, -0.46549407f, 
    -0.04616665f, 0.17951672f, 0.25250304f, 0.17025116f, 0.01111301f, 0.02131483f, 0.02943801f, -0.01146422f, 
    -0.01086788f, -0.05592635f, 0.06430394f, 0.02176201f, -0.08353458f, 0.01204384f, -0.06818857f, 0.12797126f, 
    -0.09385292f, -0.07243520f, 0.03912750f, 0.06038115f, 0.09845046f, -0.00510993f, 0.04279600f, 0.05636891f, 
    0.10054488f, 0.08315454f, 0.00031042f, -0.13137025f, 0.03424984f, -0.29990914f, -0.28213635f, -0.05940163f, 
    -0.03939769f, -0.00116213f, -0.01572786f, 0.02252799f, -0.12911989f, 0.02920047f, -0.30342534f, -0.27763847f, 
    -0.21724431f, 0.03459141f, 0.03417789f, 0.12441900f, 0.24904446f, 0.03240526f, -0.10587998f, 0.20140316f, 
    -0.08215811f, -0.00420689f, 0.01244409f, -0.05343559f, 0.02828526f, 0.05622155f, -0.02365025f, 0.17620486f, 
    -0.15507771f, 0.01574324f, 0.17516169f, -0.53501910f, 0.00038853f, -0.26004049f, 0.03756050f, -0.01288185f, 
    -0.31987622f, -0.21114287f, 0.00843816f, -0.05227179f, 0.02373507f, -0.03652771f, -0.12796725f, -0.02468506f, 
    -0.01296349f, -0.12278032f, -0.13400036f, -0.46307966f, 0.32063207f, 0.55662501f, 0.21808507f, -0.86483228f, 
    -0.23334977f, 0.05948706f, 0.26102844f, -0.08748327f, 0.08815949f, 0.17087449f, 0.09479061f, -0.00729961f, 
    -0.02803444f, -0.03653089f, -0.03386845f, -0.00357996f, -0.05612430f, -0.01876494f, 0.05553220f, -0.02024507f, 
    0.31805959f, 0.22987552f, -0.09082422f, -0.13712102f, -0.05305402f, -0.15057999f, -0.04430474f, -0.04520020f, 
    -0.06363755f, -0.29336450f, -0.13939373f, 0.12645864f, -0.06667639f, 0.02809820f, 0.03852065f, -0.07611275f, 
    -0.10426195f, -0.09503790f, -0.10381150f, -0.00092729f, -0.35540906f, 0.38456148f, 0.21038428f, -0.39685133f, 
    -0.11067018f, -0.20426942f, -0.31796861f, -0.39539379f, 0.00565855f, -0.04103303f, -0.01270737f, -0.05147844f, 
    0.05460076f, 0.04258983f, 0.09296034f, 0.10129703f, 0.03030104f, 0.12788779f, 0.25263414f, 0.09871037f, 
    0.55834091f, 0.38308477f, -0.08566017f, -0.01529934f, 0.06067210f, 0.21119103f, 0.14870246f, 0.27957210f, 
    -0.13185087f, -0.35681787f, -0.08847873f, -0.23563275f, -0.02764440f, 0.08590450f, 0.10954031f, 0.06471395f, 
    0.01036230f, 0.00181635f, 0.00792919f, 0.00351166f, 0.40164569f, 0.19232133f, -0.06474247f, -0.35563785f, 
    -0.31817001f, 0.21842937f, 0.03741916f, 0.17794320f, -0.03688911f, 0.10487743f, -0.05658574f, 0.06700929f, 
    0.06793636f, 0.00109147f, -0.02322422f, -0.05688480f, -0.12308528f, -0.05260277f, 0.03403991f, 0.18380721f, 
    0.70518935f, 0.36043176f, -0.06186987f, -0.55613351f, -0.05685658f, 0.16479219f, 0.10421269f, 0.28298333f, 
    0.12308641f, 0.17405047f, 0.01858350f, -0.07339779f, -0.04228574f, -0.10579650f, -0.18733957f, -0.03354286f, 
    -0.14630671f, -0.14106874f, -0.01489247f, 0.15298784f, 0.04618860f, 0.18646240f, 0.12716573f, -0.17599428f, 
    -0.18469879f, -0.19705249f, -0.12963080f, -0.21726492f, -0.22570936f, -0.02520982f, -0.13468170f, 0.00210651f, 
    -0.08165845f, -0.01498428f, 0.00168424f, -0.27489993f, -0.19476549f, 0.01713732f, 0.02795384f, 0.22250594f, 
    0.28485206f, 0.24322084f, 0.17074670f, -0.16431974f, -0.06730477f, -0.09335057f, 0.17047586f, 0.14932103f, 
    -0.05698308f, -0.12065122f, -0.10472484f, -0.04206194f, -0.05517894f, -0.10411318f, -0.08250713f, -0.07792996f, 
    -0.11013791f, 0.02736236f, -0.10709748f, -0.14232937f, 0.06487079f, -0.50404400f, -1.49412978f, 0.33007205f, 
    0.03220822f, 0.13156156f, -0.08192486f, -0.08028675f, -0.32983509f, 0.09651886f, -0.14012080f, -0.04384211f, 
    -0.26627430f, -0.31624928f, -0.15686777f, -0.08647565f, 0.05009847f, -0.18760128f, -0.03772238f, 0.08762556f, 
    0.40909454f, 0.19685070f, -0.06032917f, -0.22917259f, 0.04405952f, -0.06657586f, -0.10616669f, -0.29984283f, 
    -0.18370466f, -0.11578882f, -0.12316196f, -0.02123726f, -0.03003323f, 0.09302942f, 0.01795488f, 0.03691288f, 
    0.14112987f, 0.01498610f, 0.18258159f, 0.01697565f, 0.00919724f, 0.11407810f, 0.06955685f, -0.05910056f, 
    0.09585345f, 0.02456479f, -0.09861326f, 0.09529164f, -0.01216554f, -0.06664143f, -0.08855210f, 0.09704806f, 
    -0.04283617f, 0.09204900f, -0.10458619f, 0.01597865f, 0.06315047f, -0.01264604f, 0.02789712f, 0.23568349f, 
    0.02114317f, -0.81282163f, 0.06326126f, 0.14401872f, -0.03633238f, 0.01337551f, 0.01531495f, -0.06765631f, 
    -0.11441159f, 0.02724325f, 0.05696725f, -0.00188220f, -0.01765146f, -0.09104545f, -0.10506351f, 0.13977179f, 
    0.00262344f, -0.13507000f, 0.08685770f, -0.05266239f, -0.01684436f, 0.37734833f, 0.23330592f, 0.06332019f, 
    0.14504638f, 0.07592793f, 0.00248673f, 0.23768450f, -0.19964665f, -0.09165238f, -0.05094678f, -0.02627828f, 
    0.00676140f, -0.04200980f, 0.02111963f, 0.02628238f, 0.04301014f, 0.06618831f, -0.14579697f, 0.06304270f, 
    0.27984908f, 0.14382803f, 0.21309435f, 0.17002758f, 0.17511904f, -0.06960321f, 0.00336557f, 0.02556440f, 
    -0.03739601f, -0.06392656f, 0.08723997f, 0.10930104f, 0.01784063f, 0.03231451f, -0.02896706f, -0.20632195f, 
    -0.09721582f, -0.16958141f, 0.01574732f, -0.00850764f, -0.30686560f, -0.61886752f, 0.34106448f, 0.34537798f, 
    0.36472484f, -0.06518028f, -0.02353657f, -0.09867445f, -0.03353938f, -0.08008470f, 0.15827782f, -0.01692440f, 
    -0.09970705f, 0.01842633f, 0.27599984f, 0.24914727f, 0.03812313f, -0.10718507f, 0.19446671f, -0.25151742f, 
    -0.13635626f, 0.24729642f, -0.00007369f, -0.19191422f, 0.25829613f, -0.05942755f, 0.25350273f, -0.02171927f, 
    0.13711189f, 0.19401592f, 0.04678675f, -0.10718527f, 0.09733572f, 0.14195020f, -0.03420870f, 0.03998161f, 
    -0.00290888f, 0.05216445f, -0.03875961f, -0.07904755f, -0.56558698f, 0.31038660f, -0.06014151f, -0.09781443f, 
    0.10734487f, -0.11049628f, -0.15028621f, -0.11563618f, 0.15449911f, -0.24509586f, -0.08236690f, -0.00663451f, 
    0.10689706f, 0.06358714f, 0.09888139f, 0.01074859f, -0.01194767f, 0.18697633f, -0.10072032f, -0.06524085f, 
    -0.28525037f, -0.14554486f, -0.17774166f, -0.13514763f, -0.17134134f, 0.08822852f, 0.09697039f, 0.08856439f, 
    -0.14102679f, 0.18650343f, 0.31299576f, 0.05896802f, 0.10543332f, 0.15148225f, 0.06376697f, -0.02830443f, 
    -0.08221381f, 0.00895552f, 0.07327603f, 0.04608257f, 0.05210120f, -0.02975850f, -0.35441282f, -0.41073218f, 
    -0.72636634f, 0.18102080f, -0.30261868f, -0.20487915f, -0.18132363f, -0.08825383f, -0.06613775f, -0.06784491f, 
    0.03265733f, -0.01397764f, -0.04354565f, -0.05267850f, -0.13853826f, -0.39425251f, -0.14649881f, -0.20951016f, 
    -0.44477224f, -0.30584046f, -0.29502985f, 0.06133116f, -0.09413169f, 0.05524410f, 0.19094580f, 0.34404829f, 
    -0.09498365f, -0.12294553f, -0.06890301f, 0.00281364f, -0.07637908f, -0.04550098f, -0.08894664f, -0.05942381f, 
    0.05822812f, -0.06641745f, -0.01785739f, 0.04798788f, -0.23083718f, 0.13717619f, -0.39527443f, 0.22131489f, 
    -0.13138320f, -0.20904578f, 0.32563850f, -0.19772649f, 0.23353621f, -0.11461306f, -0.02820141f, -0.01680881f, 
    -0.12861247f, -0.03586067f, 0.01194405f, -0.01299909f, 0.07576464f, 0.05696954f, -0.10462002f, 0.09103894f, 
    0.05234530f, 0.10843616f, -0.12768881f, 0.43958592f, -0.04577552f, 0.25680506f, -0.07338298f, -0.16692227f, 
    0.26847315f, -0.00818807f, 0.14230958f, -0.03085625f, 0.03034750f, 0.08631016f, 0.00388171f, -0.11256304f, 
    -0.02923749f, -0.04472838f, -0.13487832f, -0.20215707f, 0.08577766f, -0.21840961f, -0.19114627f, -0.32049868f, 
    -0.20830867f, 0.12743340f, 0.06062133f, -0.01590192f, 0.00496884f, 0.07920276f, -0.01008204f, 0.14348662f, 
    -0.04270760f, 0.01775504f, 0.00840678f, -0.36467135f, -0.35212529f, -0.31732559f, -0.13244359f, -0.11071090f, 
    -0.25410676f, 0.22397602f, 0.04511898f, 0.26757565f, -0.17601196f, 0.11652823f, 0.23931241f, 0.02476484f, 
    -0.12804535f, -0.15654896f, -0.04139253f, 0.13336909f, 0.02046988f, -0.13521929f, 0.04541046f, -0.05913270f, 
    0.11206494f, -0.06469054f, -0.09692962f, 0.10010076f, 1.69681180f, 0.05041486f, -0.35649475f, -0.06039681f, 
    -0.54807985f, -0.05704977f, 0.04083648f, 0.00638222f, 0.03871379f, -0.10436679f, 0.19025932f, -0.11555219f, 
    -0.07281050f, -0.19272725f, 0.00380887f, 0.03557243f, 0.03070747f, -0.19368301f, 0.06550652f, 0.14631352f, 
    -0.88805729f, 0.05097018f, 0.31063223f, -0.33525196f, -0.08848907f, -0.04725000f, -0.12775953f, -0.14723045f, 
    -0.25640339f, 0.14747763f, 0.04385157f, -0.04366655f, 0.04567781f, -0.01488473f, -0.00643802f, -0.03763666f, 
    -0.34082347f, -0.15617409f, -0.11723598f, -0.03968298f, -0.18615602f, -0.11712552f, -0.09341872f, -0.03662133f, 
    0.09541941f, 0.00108199f, 0.01749260f, 0.02118242f, -0.11407337f, 0.11643535f, 0.05055698f, -0.03819408f, 
    0.00835586f, 0.10194826f, -0.01618105f, 0.00155064f, -0.07868717f, -0.13374141f, -0.01730383f, 0.00654324f, 
    0.29776326f, -0.31596485f, 0.37087309f, 0.06706659f, 0.45324084f, -0.03957380f, 0.04440553f, 0.02799544f, 
    0.11243213f, -0.14771946f, -0.01413336f, -0.07542403f, 0.01490328f, -0.05422403f, 0.17105708f, 0.00533616f, 
    0.04962937f, 0.01537457f, -0.07541965f, 0.06676233f, -0.38169670f, -0.10211451f, 0.23106334f, 0.40623403f, 
    0.26690876f, -0.01454206f, 0.13676049f, -0.03854298f, 0.21824954f, 0.09874395f, -0.00301152f, -0.02781595f, 
    0.03939229f, -0.02331857f, -0.10911708f, -0.06950388f, 0.06697454f, -0.02338280f, -0.16279459f, 0.10663091f, 
    -0.13453878f, -0.24640284f, -0.20155491f, -0.16031969f, 0.00459771f, -0.03061050f, -0.09903956f, -0.00520744f, 
    0.05946875f, 0.08925300f, 0.08648501f, -0.13802145f, -0.09366982f, 0.12186962f, 0.03972619f, 0.07642755f, 
    0.01308389f, 0.00518264f, 0.08444938f, -0.02936855f, 0.00492426f, -0.36057237f, -0.18039244f, 0.00083076f, 
    0.42258632f, 0.05118709f, 0.04380766f, 0.01355658f, -0.02330650f, 0.03310416f, -0.15922940f, 0.11847168f, 
    -0.16432787f, 0.00093199f, -0.18102527f, 0.15714064f, 0.11441515f, 0.00137467f, 0.08279591f, 0.04464447f, 
    -0.04117639f, 0.06179944f, -0.02796508f, -0.05172579f, -0.04132358f, -0.16984698f, -0.20209558f, -0.40507534f, 
    -0.05537668f, 0.15899685f, 0.08771408f, -0.02797100f, 0.06854260f, -0.02598082f, -0.12865123f, 0.06533341f, 
    0.04756624f, 0.05947651f, -0.28511950f, -0.02452651f, -0.67996150f, -0.86571157f, -1.04020441f, -0.23050371f, 
    -0.84224164f, 0.06338055f, 0.23134983f, -0.23891604f, 0.11575878f, -0.11388317f, -0.05453043f, 0.04822244f, 
    0.00816211f, 0.03086551f, -0.13703810f, -0.06770686f, -0.02317924f, 0.00157376f, -0.32473364f, -0.04828021f, 
    -0.18354037f, 0.21043375f, -0.05170935f, 0.24220340f, 0.06162269f, -0.08570622f, 0.05826952f, -0.27017584f, 
    -0.22583154f, -0.43119264f, 0.03508217f, -0.11625604f, 0.08426667f, 0.01289003f, -0.02974334f, 0.03625913f, 
    -0.00933993f, -0.05453664f, -0.02955413f, 0.03518740f, -0.71785593f, -0.32885453f, 0.84285581f, -0.27137828f, 
    -0.19983143f, -0.08527473f, 0.11330511f, 0.00732450f, -0.03554878f, -0.05989728f, -0.00625614f, -0.00836102f, 
    -0.01430984f, 0.03197187f, -0.03930927f, -0.07000931f, 0.01016379f, 0.21697640f, 0.02000308f, 0.06860078f, 
    0.06899431f, 0.38678381f, 0.58199197f, 0.28018761f, 0.50664061f, -0.19501752f, -0.10980944f, 0.16971835f, 
    0.28835905f, 0.05218337f, -0.02916668f, 0.12659985f, -0.04539157f, 0.02997357f, 0.07019465f, 0.09593461f, 
    -0.08335324f, -0.05204774f, -0.05275345f, 0.00153427f, 0.14653385f, -0.64343792f, -0.17014067f, 0.29861343f, 
    -0.62381130f, -0.07335494f, 0.01975250f, 0.00027378f, 0.15085581f, -0.27816707f, 0.02271721f, 0.08531427f, 
    -0.06129982f, 0.06494387f, -0.02164985f, -0.03098073f, -0.00951626f, 0.05507270f, 0.12500237f, -0.05274590f, 
    0.26861790f, -0.75856787f, -0.25254184f, 0.36893415f, -0.31895533f, -0.00496809f, -0.03802283f, -0.36700734f, 
    0.18265213f, -0.11360927f, -0.06723913f, -0.00749707f, -0.09045629f, -0.02900359f, -0.01986972f, -0.00814411f, 
    0.06511024f, 0.00856300f, -0.07930088f, 0.13514391f, 0.45942563f, -0.48738295f, -0.10372021f, -0.03909039f, 
    -0.41547593f, 0.03025765f, -0.07148487f, 0.02217503f, -0.00382554f, 0.09336501f, -0.05150433f, -0.09641875f, 
    0.02775607f, 0.01914689f, 0.04180270f, 0.24882375f, 0.19746175f, -0.12433060f, 0.32521501f, 0.11085734f, 
    -0.08120622f, -0.01788911f, -0.20657785f, 0.67492360f, 0.16625424f, 0.00067213f, 0.05490799f, 0.09354582f, 
    0.03548005f, -0.08400840f, -0.00477565f, -0.03543095f, -0.00749668f, -0.06267286f, -0.01398230f, 0.01356576f, 
    0.04606782f, -0.02035412f, -0.24514267f, 0.09327555f, -0.39181754f, 0.51145977f, 1.04831541f, -0.15765515f, 
    0.10690039f, -0.01980912f, -0.14930607f, 0.09593710f, 0.01043831f, 0.31408775f, 0.13865630f, 0.06100574f, 
    -0.08071319f, -0.08231049f, 0.13868780f, 0.12771258f, 0.00626852f, 0.10140844f, 0.24418455f, -0.17546394f, 
    -1.23037302f, -0.57775754f, 0.59491313f, 0.45410544f, -0.14262880f, -0.01680153f, -0.15220223f, 0.29131603f, 
    -0.15758941f, -0.12759013f, -0.01104370f, 0.27910492f, -0.06496059f, 0.11164369f, 0.19547099f, 0.00400621f, 
    0.01238497f, 0.06530096f, -0.03871540f, -0.23830535f, -0.48295951f, -0.04477623f, 0.10668249f, -0.64932859f, 
    -0.02439779f, -0.36500263f, -0.04375462f, -0.59281230f, -0.30750889f, -0.18350410f, 0.09983350f, 0.09360430f, 
    0.14626417f, -0.08804840f, 0.02833891f, 0.03511612f, 0.08052218f, 0.24847017f, -0.27281421f, -0.45327631f, 
    -0.04483064f, 0.82731497f, 0.09694023f, -0.55523789f, 0.13625179f, 0.46141130f, 0.23499238f, -0.26375139f, 
    0.04721502f, -0.00676030f, -0.24150223f, -0.12615664f, -0.04682047f, -0.07511242f, 0.11910189f, -0.27197808f, 
    0.09583823f, -0.27033305f, 0.07910941f, -0.00196468f, -0.09985405f, -0.02144814f, -0.18262334f, -0.17666568f, 
    0.33333346f, 0.03669731f, -0.01508167f, -0.18632202f, -0.00482231f, -0.02794712f, -0.12383222f, 0.01289017f, 
    0.00985531f, -0.05916585f, 0.10274757f, -0.09173960f, 0.00470523f, 0.16467766f, -0.06794896f, 0.06116915f, 
    -0.80905592f, -0.54093349f, -0.14926603f, -0.12354944f, -0.48585093f, 0.37700343f, -0.01997602f, 0.10308036f, 
    0.08682703f, 0.05115251f, -0.07877881f, -0.05144834f, -0.00921616f, -0.11442450f, -0.13172643f, 0.00185248f, 
    0.00221656f, -0.30873039f, -0.05031235f, -0.17288089f, 1.41407359f, 0.99990469f, -0.60317302f, -0.23935527f, 
    -0.43573427f, 0.27948695f, 0.27288887f, 0.09955275f, -0.10663667f, 0.23941015f, -0.47316119f, -0.22397678f, 
    0.15028858f, -0.21813390f, 0.04267689f, -0.23818740f, -0.05707592f, -0.08058794f, 0.13143463f, 0.06528024f, 
    0.10841521f, -0.30574882f, 0.04718328f, -0.02039817f, 0.15600172f, 0.01999480f, 0.02189937f, -0.12052301f, 
    -0.01278983f, -0.01346994f, 0.16774067f, 0.03678551f, -0.19941190f, -0.11890978f, -0.03221840f, 0.07708585f, 
    -0.00591474f, 0.03752120f, -0.34072608f, -0.09048924f, 0.20955491f, -0.19954853f, -0.25370005f, -0.01360580f, 
    0.46114722f, 0.22733249f, 0.18476878f, -0.01893435f, 0.15451896f, 0.09067319f, 0.10657393f, -0.08941185f, 
    -0.06459227f, -0.10911246f, -0.01541284f, -0.03872122f, -0.06511572f, -0.02067579f, -0.31449625f, 0.00905785f, 
    -0.32631403f, -0.03706020f, -0.22903889f, 0.32757688f, 0.27162984f, -0.00894374f, -0.14203644f, 0.24175344f, 
    0.05074227f, 0.16226989f, -0.13207351f, 0.17084922f, -0.08095201f, -0.14421082f, -0.08523351f, 0.12923014f, 
    -0.09404282f, 0.13829282f, -0.13903162f, -0.24011113f, 0.19236983f, -0.48574543f, 0.49069664f, 0.01690378f, 
    0.44465461f, -0.39401108f, 0.05037546f, 0.03618992f, 0.18979490f, 0.13096048f, 0.00318813f, 0.02609425f, 
    -0.04648648f, -0.08682299f, 0.10645583f, -0.08596928f, 0.02963656f, 0.00595059f, 0.06701183f, -0.00328240f, 
    -0.09169418f, 0.05079894f, -0.22050641f, -0.07887197f, 0.52050120f, 0.14937212f, -0.11401317f, 0.00369953f, 
    -0.27650800f, -0.04213412f, -0.19707002f, 0.08636836f, 0.06819309f, 0.07452428f, 0.10173328f, 0.09032346f, 
    -0.08453200f, 0.05043609f, 0.10780861f, 0.17800227f, 0.10845345f, -0.20334294f, -0.41366774f, -0.04095020f, 
    0.32875213f, 0.12892355f, -0.02546795f, 0.08400555f, 0.08232112f, 0.04470647f, 0.18819916f, -0.00949076f, 
    0.21161188f, -0.05651739f, -0.05772336f, 0.05452084f, -0.06873357f, 0.18329591f, -0.18824171f, 0.15765753f, 
    -0.36620480f, 0.43614125f, -0.22933941f, -0.00260046f, 0.43021384f, 0.01989489f, 0.00116223f, -0.01332993f, 
    -0.02770148f, 0.01798021f, -0.18767956f, 0.10716721f, -0.30970135f, 0.07582165f, -0.08517426f, 0.01355355f, 
    -0.23202226f, 0.27388707f, -0.04672145f, -0.02910154f, 0.21767204f, -0.07567041f, -0.19958705f, 0.14316984f, 
    0.11548416f, -0.29669282f, 0.02461223f, -0.03628416f, 0.13186157f, 0.16464004f, -0.09384141f, 0.05931166f, 
    0.09702714f, -0.01898409f, -0.01505010f, 0.33441189f, 0.09236122f, -0.00451308f, 0.17437580f, -0.08757258f, 
    0.14346395f, -0.19844948f, -0.39031112f, -0.11649980f, 0.23014989f, 0.00685014f, -0.08772883f, -0.19808277f, 
    -0.09498321f, -0.01307771f, -0.11594234f, -0.02172441f, -0.03218170f, 0.13797425f, -0.13393332f, -0.07433800f, 
    -0.02569427f, 0.09320520f, -0.08954053f, -0.14701247f, -0.31443954f, 0.65799940f, -0.15211627f, 0.32223919f, 
    0.43238556f, 0.08683399f, -0.13400853f, -0.05907691f, -0.28423598f, -0.12393648f, -0.22393322f, 0.00595389f, 
    0.23303047f, 0.00125978f, -0.04896445f, -0.08163877f, 0.00565907f, 0.00385264f, -0.00748763f, -0.08966091f, 
    0.17803906f, 0.02805171f, -0.09185688f, 0.17228562f, 0.45923191f, -0.02708367f, 0.23364131f, 0.13099605f, 
    0.04436950f, 0.09726056f, 0.12369870f, 0.10673371f, -0.06137856f, 0.00211520f, 0.12044661f, 0.11783817f, 
    -0.11057937f, -0.14463513f, -0.12588461f, -0.15635534f, -0.04351442f, -0.17080052f, -0.15219945f, 0.00201514f, 
    -0.07843869f, -0.11810599f, 0.18459745f, -0.15587668f, 0.04069963f, -0.06891539f, 0.14539605f, -0.08157672f, 
    -0.13034934f, -0.16879581f, 0.01718292f, -0.19058962f, -0.21639822f, -0.14720385f, -0.02172541f, -0.06727168f, 
    -0.08048713f, -0.47544956f, 0.08648732f, -0.18914771f, -0.07786221f, -0.18166974f, -0.24733774f, 0.03733234f, 
    -0.10411359f, 0.24987759f, -0.01886466f, -0.06511322f, 0.00968541f, -0.17802870f, -0.19183411f, -0.02867456f, 
    0.00643576f, 0.04445355f, -0.07693779f, 0.05919998f, -0.08789242f, -0.00765947f, 0.04274895f, 0.20243922f, 
    0.07089192f, -0.25813469f, 0.01310439f, -0.12338890f, -0.16526803f, -0.09185071f, -0.03607650f, 0.03102968f, 
    -0.01957945f, 0.11605380f, -0.01339085f, 0.05390620f, 0.04988996f, -0.10434681f, 0.02830883f, 0.10883848f, 
    0.11659762f, 0.16697608f, -0.08643673f, -0.14650391f, -0.13625382f, 0.19298251f, 0.12265199f, 0.05561857f, 
    0.07505813f, 0.17832355f, 0.18946743f, 0.01770680f, 0.02680452f, -0.16248977f, 0.12734599f, 0.08171631f, 
    0.10117562f, 0.00840671f, -0.06754057f, 0.09873411f, 0.18940626f, -1.28115153f, -0.04069060f, -0.27884141f, 
    -0.46455851f, 0.20892975f, -0.00538890f, 0.07903048f, 0.03618142f, 0.18225403f, 0.06744692f, 0.02708054f, 
    -0.00883502f, -0.22246990f, -0.22017042f, -0.13180883f, -0.03742488f, 0.07017261f, -0.40141904f, 0.10501399f, 
    -0.32295033f, -0.04303619f, 0.07699730f, 0.21216083f, 0.00990334f, -0.19190952f, -0.04033314f, -0.28704941f, 
    -0.23334016f, 0.11021156f, -0.02203075f, 0.05203830f, -0.05151011f, -0.07093564f, -0.08936501f, -0.00268343f, 
    -0.07581908f, -0.27501285f, -0.26944298f, -0.05472295f, 0.01765839f, 0.33806169f, 0.42319930f, 0.37850025f, 
    0.16984589f, -0.06994179f, 0.03117768f, 0.04496087f, 0.11052977f, 0.18230976f, -0.05873175f, 0.01502270f, 
    -0.01517277f, 0.05167070f, 0.03443739f, 0.00737953f, -0.01536754f, -0.23985866f, 0.02118519f, -0.11312463f, 
    0.21039239f, 0.00355456f, 0.33204946f, -0.12722130f, 0.15210362f, 0.07799829f, 0.06761007f, -0.03515716f, 
    -0.14750940f, 0.07762467f, -0.05154150f, -0.17054330f, 0.08337615f, -0.11358824f, -0.03341127f, -0.00646334f, 
    -0.10945013f, -0.07836926f, -0.09967522f, -0.32213199f, 0.14371437f, 0.29823905f, -0.25432518f, 0.29417595f, 
    0.25472814f, -0.01530535f, 0.01678685f, 0.12236178f, 0.27184740f, 0.19555952f, 0.02261390f, -0.08767118f, 
    -0.02227443f, 0.02947856f, -0.07531051f, 0.02829440f, 0.24048743f, 0.04295127f, 0.14257653f, 0.27746683f, 
    0.24861538f, -0.10029685f, 0.26878509f, 0.00970820f, 0.09958811f, -0.33818460f, -0.19400518f, -0.21589264f, 
    -0.09717846f, 0.07747263f, 0.14046904f, -0.00396804f, -0.05819128f, 0.01796595f, 0.01724882f, 0.02996463f, 
    0.05399981f, 0.13912725f, 0.01632113f, -0.07948585f, 0.16566648f, 0.30721441f, 0.54445195f, 0.16227089f, 
    0.13619889f, -0.28337181f, -0.12413796f, -0.10817651f, -0.11995450f, 0.21349528f, -0.00209204f, 0.02131416f, 
    0.04731878f, -0.00841825f, 0.04403745f, -0.00104453f, -0.03280195f, -0.01939376f, -0.00947080f, -0.14904793f, 
    -0.06351025f, -0.37206626f, 0.28173327f, 0.12929346f, -0.03173549f, -0.05444471f, 0.17170301f, 0.15384361f, 
    -0.38181704f, -0.05678146f, -0.12334269f, 0.03313579f, 0.05413086f, 0.06439050f, -0.08164236f, 0.06305046f, 
    0.05423627f, -0.02530333f, -0.17654525f, 0.12346488f, -0.24641056f, 0.25999764f, 0.03170220f, 0.00729715f, 
    0.01039307f, 0.08553147f, -0.07334470f, 0.02399288f, -0.04497586f, -0.09674736f, 0.03806403f, -0.00966470f, 
    -0.00521913f, 0.02987482f, -0.06591627f, 0.03712172f, 0.20011897f, 0.20598646f, -0.04481989f, 0.39677212f, 
    -0.06340812f, -0.13698864f, 0.14441629f, 0.10397910f, 0.04253967f, -0.27841255f, 0.02156275f, -0.02634578f, 
    0.15175660f, -0.18896182f, 0.07774375f, -0.07150413f, -0.02797704f, -0.03185549f, -0.00170667f, -0.06176221f, 
    0.03518483f, -0.04400389f, -0.03980760f, 0.10801762f, -0.42029643f, -0.53137445f, 0.15147866f, -0.09752888f, 
    -0.20934831f, -0.20341416f, -0.05790127f, -0.28312612f, -0.17673354f, -0.06588730f, -0.03939285f, -0.12566666f, 
    -0.14128305f, 0.23106240f, 0.05210844f, -0.04357775f, 0.02020123f, -0.13712230f, -0.11558092f, -0.08779603f, 
    -0.34291095f, -0.33982491f, -0.34779227f, 0.20845342f, 0.24162805f, -0.08701389f, 0.20780855f, -0.10681713f, 
    -0.08873072f, 0.05605961f, 0.08415113f, -0.18604235f, -0.01152905f, -0.05222764f, -0.03420347f, -0.14291051f, 
    0.15255453f, -0.00099127f, -0.24040852f, 0.06664255f, 0.36974394f, -0.02490830f, -0.31296426f, 0.23197757f, 
    0.17982250f, 0.12378825f, 0.09261775f, -0.01937592f, -0.16174257f, 0.35776758f, 0.04161612f, -0.01687336f, 
    0.27409166f, 0.10849375f, -0.00837581f, 0.18651895f, -0.01518428f, 0.01873429f, -0.04972537f, 0.09639593f, 
    -0.54277420f, 0.17712964f, -0.38952726f, 0.09612178f, -0.14029050f, 0.07040470f, -0.23343979f, -0.02674581f, 
    0.05977316f, -0.15957026f, 0.08618984f, 0.01163716f, -0.32949698f, 0.06692300f, 0.35982323f, -0.08274490f, 
    -0.13862443f, 0.14431198f, -0.10122717f, 0.02228185f, -0.00477278f, -0.01136603f, 0.13550118f, 0.13022819f, 
    -0.20298788f, 0.12157986f, 0.12474724f, -0.01517970f, 0.07573548f, -0.03306802f, 0.12225598f, -0.03394493f, 
    -0.01892357f, 0.02962177f, -0.00491335f, -0.14420718f, -0.00082717f, -0.05273800f, 0.17477693f, -0.27773607f, 
    -0.04284096f, -0.17404097f, -0.43243259f, 0.06934369f, 0.20655109f, 0.02816373f, -0.01581474f, -0.13745596f, 
    -0.14427255f, -0.00231055f, 0.09089380f, 0.03203385f, -0.06406536f, 0.17063862f, -0.03511646f, -0.04552957f, 
    -0.03198749f, 0.39637396f, 0.07104492f, -0.06356500f, -0.88030392f, 0.76536387f, -0.05314429f, -0.16163340f, 
    -0.05879898f, -0.00921621f, -0.14661753f, -0.04611164f, 0.04463485f, -0.11287697f, 0.17082617f, -0.13289031f, 
    -0.15340987f, 0.04282566f, -0.16559169f, -0.18032657f, -0.20412736f, 0.16983105f, -0.03029309f, -0.19987756f, 
    0.01073452f, -0.15799853f, 0.05533499f, 0.18123242f, -0.49048844f, 0.16049065f, -0.13985512f, 0.15224564f, 
    0.18924443f, -0.03534316f, -0.04626546f, 0.08150890f, -0.14372134f, -0.06282507f, 0.23345700f, -0.06972650f, 
    0.03923650f, 0.25742510f, 0.21355322f, 0.31843388f, 0.26309299f, -0.14901973f, 0.42765117f, -0.08589754f, 
    -0.44035098f, 0.11112016f, -0.04178512f, 0.01123509f, -0.29928052f, -0.07533671f, 0.01429063f, 0.01181729f, 
    0.03542692f, 0.00045549f, 0.04125630f, 0.00035773f, -0.01016031f, -0.04072703f, -0.03767665f, 0.13069861f, 
    0.31908944f, -0.06107470f, 0.03940374f, -0.13702743f, -0.11442755f, -0.09227568f, 0.03626928f, -0.02561926f, 
    0.02523007f, 0.11026923f, -0.16619673f, 0.03975715f, -0.15640479f, -0.08105347f, -0.07042792f, 0.08197307f, 
    0.21174344f, -0.03604332f, 0.02210170f, 0.32024783f, 0.14549817f, 0.14509967f, 0.05587773f, 0.10885356f, 
    -0.00485744f, 0.16622514f, 0.12110042f, -0.08973969f, 0.02068044f, 0.20971817f, 0.12821682f, 0.14606006f, 
    0.00965848f, -0.07098999f, 0.00096255f, -0.08723835f, -0.15522376f, 0.25838086f, -0.13263741f, -0.21330272f, 
    -0.35432824f, -0.17971925f, -0.43195239f, -0.03297656f, -0.33082581f, 0.08016485f, -0.00157404f, -0.08142065f, 
    0.12457724f, 0.21526463f, 0.13651167f, 0.05331510f, 0.02846827f, 0.03616922f, -0.14189704f, -0.03831980f, 
    0.04753369f, 0.07466387f, -0.07796926f, 0.11286890f, 0.05034682f, 0.00402373f, 0.25254989f, -0.11452489f, 
    0.05950462f, 0.20004211f, 0.07742620f, 0.16367365f, -0.26780578f, -0.11032324f, 0.03741751f, 0.00242663f, 
    0.04205978f, 0.05027667f, 0.05996445f, -0.01630002f, 0.02899132f, -0.15259707f, 0.15727809f, 0.00306222f, 
    -0.08317704f, -0.13183954f, 0.48999506f, -0.31126124f, -0.37798262f, -0.02614041f, 0.00954896f, -0.10197683f, 
    0.15527898f, -0.10027362f, 0.00301227f, -0.05688841f, 0.02100149f, -0.10382482f, 0.12824011f, 0.00768843f, 
    0.08554286f, -0.12060130f, 0.02686221f, 0.04950891f, 0.03636405f, 0.24800231f, 0.17377010f, 0.03082970f, 
    0.19184464f, -0.05929008f, -0.10551209f, -0.08539875f, -0.05657296f, -0.27346581f, 0.05686972f, -0.07726323f, 
    0.02306031f, 0.08018441f, 0.02746457f, -0.12371247f, -0.07782657f, -0.20279256f, -0.24664980f, -0.73064327f, 
    -0.08541567f, 0.21115538f, 0.32513380f, -0.03875476f, -0.13921838f, 0.14265497f, -0.12999076f, 0.11333891f, 
    0.02453361f, 0.16304713f, 0.01278103f, 0.04491230f, 0.01341204f, 0.14480759f, 0.08333294f, 0.05861480f, 
    -0.05690072f, -0.06207745f, -0.01319474f, 0.00268824f, -0.53199220f, 0.04041669f, -0.33628428f, -0.86211300f, 
    0.04173527f, 0.05681559f, 0.08814032f, 0.03469998f, -0.07023605f, 0.10791730f, 0.11836184f, 0.06492896f, 
    -0.04302105f, -0.20132799f, 0.03766081f, 0.00588905f, -0.16912378f, 0.20135485f, 0.06977553f, -0.04652517f, 
    0.46039504f, -0.53669584f, -0.66013914f, -0.15267585f, 0.17445622f, -0.13638084f, 0.06465705f, 0.30285680f, 
    0.04532894f, -0.05997375f, -0.06759347f, -0.00697202f, -0.16841941f, -0.00729720f, 0.11858867f, -0.09584842f, 
    -0.06448379f, 0.08228190f, -0.05330141f, 0.02766779f, 0.26413128f, 0.13414121f, -0.22227553f, 0.00911744f, 
    0.28670999f, -0.13124461f, -0.07013091f, 0.14140645f, 0.22448185f, 0.07289024f, 0.05211839f, -0.01486589f, 
    0.04323267f, -0.08876251f, 0.06800739f, -0.03530390f, 0.10712392f, -0.36272961f, -0.04355754f, 0.05917046f, 
    -0.39340183f, -0.07345889f, 0.04843370f, 0.06124803f, 0.29380849f, -0.17379814f, 0.04011968f, -0.09342893f, 
    -0.22523792f, 0.36999241f, -0.15408401f, 0.14082353f, 0.28145549f, 0.15394859f, -0.06979059f, -0.00306168f, 
    0.10324147f, -0.10534496f, 0.13427216f, 0.04550315f, -0.64749992f, -0.79421484f, -0.25972646f, 0.02840986f, 
    -0.34183609f, -0.34688970f, -0.07285402f, 0.04734655f, -0.28625673f, -0.26149565f, 0.00812065f, -0.00230412f, 
    0.02119127f, -0.05147328f, 0.02274944f, 0.02182687f, 0.00724954f, -0.03464020f, 0.08411570f, -0.13455106f, 
    0.00913519f, -0.03219062f, 0.02730685f, -0.15523793f, -0.03071041f, 0.02924817f, 0.01527894f, -0.03820092f, 
    -0.05789904f, -0.00525487f, -0.19438258f, -0.05678602f, 0.00697502f, -0.08972664f, -0.03008422f, -0.04936279f, 
    -0.05515134f, -0.09500524f, -0.09576507f, 0.05983539f, -0.13003975f, -0.20479338f, 0.38291144f, 0.13600010f, 
    0.09983975f, -0.08221114f, -0.01584832f, -0.04289575f, -0.02135054f, 0.16193193f, -0.10435612f, 0.07523448f, 
    0.15935647f, 0.05950737f, -0.14061081f, 0.08301690f, 0.16264887f, 0.05768634f, 0.04057986f, 0.18242167f, 
    0.23225604f, -0.43721762f, -0.37703392f, -0.16643895f, 0.22149394f, -0.04287192f, 0.14314885f, 0.00962712f, 
    0.08704927f, 0.12234634f, -0.04716647f, 0.06433912f, 0.02635554f, 0.01447727f, 0.11631779f, -0.03666932f, 
    0.05535919f, -0.06699155f, 0.23728131f, -0.03416907f, -1.01084483f, -1.32950449f, -0.81358033f, -0.38140902f, 
    0.53353482f, -0.16097148f, 0.06788537f, -0.51398849f, -0.24843256f, -0.51548135f, -0.00194166f, -0.07958048f, 
    -0.10447339f, -0.12941977f, 0.07909583f, -0.01258073f, 0.00124480f, 0.01264191f, 0.30715001f, -0.00454810f, 
    0.18891291f, 0.32344154f, -0.26714215f, -0.16594714f, 0.00806378f, -0.13983230f, -0.06460466f, -0.34875232f, 
    0.04275057f, -0.10214096f, 0.01040190f, -0.09619150f, -0.21375586f, -0.03476949f, 0.09916104f, -0.01587623f, 
    -0.03352080f, 0.06023883f, -0.11670565f, -0.20849666f, -0.26124573f, -0.49780303f, -0.92143232f, -0.16611056f, 
    0.08614431f, -0.10327180f, 0.22697638f, 0.27178979f, 0.08437545f, -0.14276810f, 0.02233782f, -0.05186297f, 
    0.05751096f, 0.05632821f, 0.05913872f, -0.10627382f, 0.04401442f, 0.14500117f, 0.09191028f, 0.06243169f, 
    -1.00375664f, 0.92062718f, 0.59170747f, -0.14569800f, 0.05447535f, -0.36400089f, -0.09639496f, -0.14521503f, 
    -0.16948415f, 0.30374172f, -0.03199940f, 0.18434240f, 0.09516570f, 0.10123564f, 0.06662591f, 0.00969187f, 
    -0.06661130f, -0.04642495f, 0.04904275f, -0.09146389f, -0.96136814f, -0.48214713f, 0.29896313f, 0.58139837f, 
    -0.31251633f, -0.05331873f, 0.02131900f, 0.04043937f, -0.22755729f, -0.37653685f, 0.03974131f, -0.03916027f, 
    0.03718739f, -0.06851249f, -0.02674007f, -0.03157596f, -0.05497511f, 0.19907194f, -0.04523397f, -0.26377296f, 
    -0.30518204f, -1.07027483f, -0.93890685f, 0.38683805f, 0.13735881f, -0.21351120f, -0.18065229f, -0.09930512f, 
    -0.25579908f, -0.09846513f, -0.05632382f, 0.03910422f, 0.00310083f, -0.05320734f, -0.08185826f, -0.00020089f, 
    -0.01692205f, 0.16875789f, 0.16032712f, 0.15105306f, -0.15595047f, -0.30235887f, 0.06378242f, 0.39482403f, 
    -0.27784383f, 0.01550681f, 0.17066817f, 0.10250347f, 0.11788427f, -0.08309532f, -0.06068853f, -0.05537004f, 
    0.06599926f, 0.02944570f, 0.05627811f, 0.07189666f, 0.12300060f, 0.24916664f, 0.22392690f, 0.15866202f, 
    -0.15675303f, -0.69110835f, -0.58872861f, -0.02904346f, 0.23610367f, -0.09289209f, -0.02219199f, -0.11647356f, 
    -0.11065298f, 0.04088648f, -0.04821579f, 0.03120743f, -0.07467369f, 0.04501250f, -0.01911341f, -0.08738065f, 
    0.02380140f, -0.00127739f, 0.05927343f, 0.00232802f, -0.30990455f, 0.56926566f, 0.18455842f, 0.15612514f, 
    0.27171412f, 0.12499648f, 0.02254412f, -0.01859067f, 0.07976461f, -0.19244164f, 0.20531306f, 0.12358558f, 
    0.17258377f, 0.09689857f, 0.03250182f, 0.07836762f, 0.02181864f, 0.06555359f, -0.15745090f, 0.04087354f, 
    -0.14584965f, 0.05162288f, 0.12906402f, -0.05187365f, -0.13928586f, 0.14749636f, -0.02424296f, -0.24543037f, 
    -0.07461479f, 0.01186079f, 0.09647082f, 0.09646812f, 0.03792609f, 0.05407088f, -0.05985991f, 0.12571967f, 
    -0.17762420f, -0.20442803f, 0.13707446f, 0.08206907f, -0.03357486f, 0.13016377f, 0.00176958f, 0.01948369f, 
    -0.10714242f, 0.08311958f, 0.05814414f, -0.04614929f, -0.04386511f, -0.07225950f, 0.01089384f, -0.08516026f, 
    0.02248736f, -0.18349923f, -0.02631111f, -0.16474016f, -0.28769013f, 0.09013936f, 0.01350924f, -0.05122189f, 
    0.38955724f, 0.68594247f, -0.63456655f, -0.06228588f, -0.66434151f, 0.08568193f, 0.05445959f, -0.06095238f, 
    0.04485003f, -0.00424467f, -0.03243321f, 0.03665231f, -0.10421910f, -0.14567909f, -0.11601619f, 0.02096790f, 
    0.01395902f, -0.04233854f, 0.00419914f, 0.05855540f, 0.65760112f, -0.81704628f, -0.76351112f, -0.56128895f, 
    -0.25700712f, 0.08162500f, -0.01793159f, 0.04580039f, 0.25147346f, 0.12988085f, -0.03614486f, 0.04039959f, 
    -0.06447614f, -0.08179953f, 0.02966068f, -0.10365518f, 0.05768581f, -0.00211475f, 0.04709347f, -0.05235245f, 
    0.01695219f, 0.14814436f, 0.01388413f, 0.11716621f, -0.17909196f, 0.10097306f, 0.04103463f, 0.06671189f, 
    -0.04479352f, -0.14515528f, 0.07203668f, -0.17442076f, -0.02444601f, -0.16690114f, -0.11813894f, -0.04892668f, 
    -0.03427575f, 0.03937849f, -0.00672417f, 0.03600667f, 0.29287791f, 0.12814067f, -0.29632679f, -0.03442723f, 
    -0.52311319f, -0.02075893f, 0.03069517f, 0.06471805f, 0.10214221f, 0.00001354f, -0.24905413f, -0.12529638f, 
    0.14545712f, -0.21447191f, -0.08950578f, -0.12137003f, -0.06259035f, -0.06988805f, 0.12329680f, 0.13407502f, 
    -0.16878369f, -0.30442798f, -0.15994431f, 0.26533374f, 0.01047990f, 0.01194354f, -0.08476093f, 0.12416702f, 
    0.00301367f, -0.09429150f, 0.04902994f, 0.11449470f, 0.01592103f, -0.01115336f, -0.05000327f, -0.05464322f, 
    0.02868076f, 0.01052004f, -0.03666067f, 0.06171244f, -0.77471441f, -1.62298179f, 0.55591154f, 1.05388057f, 
    0.39664322f, -0.11077967f, 0.14380592f, 0.12907228f, -0.00440788f, 0.21703610f, 0.08650166f, 0.04009230f, 
    -0.05705722f, 0.05632857f, 0.00011407f, 0.02547512f, 0.07172486f, -0.20342033f, 0.09971362f, -0.11347546f, 
    -0.29904953f, -0.41184485f, -0.14220503f, 0.08029275f, 0.13279143f, 0.09341885f, -0.01664668f, 0.14348415f, 
    0.03478452f, 0.07292418f, -0.12099834f, 0.10700692f, 0.03228173f, 0.03461801f, 0.03975605f, 0.06342950f, 
    0.00673269f, 0.06218971f, -0.21513376f, -0.05122315f, -0.71721697f, 0.18618600f, -0.00502392f, 0.10827548f, 
    -0.15495816f, 0.17311180f, 0.06383733f, -0.11847369f, -0.24860092f, -0.13374007f, 0.06847293f, -0.07402433f, 
    0.09674286f, 0.03110834f, -0.00645088f, 0.04482070f, 0.08203975f, -0.13946809f, -0.16396034f, -0.18819447f, 
    0.92286295f, -0.83819032f, -0.30521622f, -0.25870693f, -0.45291412f, 0.16773218f, -0.25158179f, 0.03966434f, 
    0.18674248f, -0.19038948f, -0.05606768f, 0.02585399f, 0.14705239f, 0.09537259f, 0.05677822f, 0.02875053f, 
    -0.02449551f, 0.05050009f, 0.00400120f, -0.01480382f, -0.13895489f, -0.88413113f, -0.04082911f, -0.63726997f, 
    0.12893929f, -0.06307630f, 0.16278358f, 0.01774651f, -0.02810325f, 0.16712952f, -0.02649202f, -0.02769405f, 
    0.12839414f, -0.07976791f, -0.02072522f, 0.03032773f, 0.02810295f, -0.04018061f, -0.01411028f, -0.08336785f, 
    0.37252542f, -1.09581935f, 0.82597232f, -0.06156252f, 0.54785115f, 0.12507397f, -0.00496981f, -0.15211755f, 
    0.36440670f, 0.16883004f, 0.04300446f, 0.12415604f, -0.03670536f, -0.17881809f, 0.12727085f, -0.03821170f, 
    0.01394008f, -0.22627099f, 0.23080903f, -0.03863575f, -0.33735090f, -0.51285863f, 0.44064909f, -0.14501373f, 
    0.12922914f, -0.04820311f, -0.25386587f, -0.15149252f, -0.14029421f, -0.17359884f, -0.02154892f, -0.09664770f, 
    -0.07800629f, -0.00931462f, -0.01436963f, -0.07844544f, -0.00273767f, -0.09199781f, -0.03485240f, -0.04773168f, 
    0.27261946f, -0.77785850f, -0.35979649f, -0.16334166f, -0.32800850f, 0.22602136f, 0.13883054f, -0.06437946f, 
    0.02521092f, -0.03840467f, -0.06387232f, 0.02303584f, 0.06224642f, -0.07379312f, -0.02432279f, -0.12528858f, 
    -0.02308252f, 0.05377945f, 0.00219188f, -0.06097584f, -0.59372550f, -0.51069826f, 0.24330778f, -0.16283007f, 
    0.26835725f, 0.01738553f, -0.17189659f, 0.21532823f, 0.01011758f, 0.03611296f, -0.05994545f, 0.11734952f, 
    0.17172220f, 0.08868451f, -0.03666765f, -0.10637823f, -0.03806867f, -0.06838056f, 0.14201160f, 0.02941784f, 
    0.10831290f, 0.05621628f, 0.12146325f, 0.24369328f, -0.39099339f, -0.07760765f, -0.09965429f, -0.21795151f, 
    -0.13539439f, -0.06437188f, -0.09554538f, -0.08058096f, 0.04168016f, -0.05813804f, -0.07084423f, 0.04117899f, 
    0.13489923f, 0.16298154f, -0.06260207f, 0.11597276f, -0.18774508f, 0.01293387f, 0.02019542f, 0.21606266f, 
    -0.02759882f, 0.09027071f, 0.07868772f, -0.00326740f, 0.07093892f, -0.13184640f, -0.08995818f, -0.07574018f, 
    -0.01399678f, 0.03042949f, 0.13288961f, 0.22174414f, 0.07273190f, 0.12217188f, 0.11600819f, 0.21470614f, 
    0.01132657f, -0.18864873f, -0.36848834f, -0.37648058f, -0.25745904f, -0.17358479f, 0.20953789f, 0.10961474f, 
    0.28490391f, -0.07593689f, 0.14097126f, -0.02414381f, 0.12818214f, -0.05719788f, -0.05401721f, 0.01790662f, 
    -0.06832568f, -0.03893778f, 0.05834205f, -0.20567384f, -0.11111663f, -0.52125871f, -1.22314322f, -0.71832186f, 
    -0.13647887f, -0.00659034f, -0.21005566f, 0.04453227f, -0.00960166f, -0.06139697f, -0.06330390f, -0.06376748f, 
    -0.08348213f, 0.07091062f, 0.02030183f, 0.06860973f, 0.02452685f, 0.09957711f, -0.02457328f, 0.14429152f, 
    -0.57441455f, 0.02003889f, 0.30566412f, -0.13232441f, -0.30801579f, -0.23940285f, -0.00316651f, -0.08236665f, 
    -0.00965173f, -0.07413799f, -0.07940479f, 0.07347576f, 0.01040419f, 0.14421512f, 0.14340958f, 0.06220099f, 
    0.00308708f, -0.04644351f, 0.12844470f, 0.06359243f, 0.00639345f, 0.15016395f, -0.06128636f, 0.15178774f, 
    -0.41737291f, -0.22723497f, 0.01717054f, -0.14166519f, -0.06538741f, -0.29548633f, 0.03426716f, 0.15285556f, 
    0.09227242f, -0.01911404f, -0.00319248f, -0.12263366f, -0.14947926f, -0.14090616f, -0.13422266f, -0.17096700f, 
    0.73177761f, 0.29029834f, 0.09057737f, 0.04893228f, -0.21382596f, 0.13554211f, -0.08822997f, -0.17885867f, 
    -0.06574299f, -0.28733063f, 0.11559674f, 0.04258551f, 0.15589389f, 0.02559861f, 0.07885920f, -0.11732537f, 
    0.12297164f, 0.12383813f, 0.42019126f, 0.10762501f, 0.92058784f, -0.24928282f, -0.40918681f, -0.31863126f, 
    -0.20296571f, 0.09182443f, -0.19208084f, 0.03909124f, 0.09752825f, 0.03614268f, -0.04759039f, 0.08384114f, 
    0.13968308f, 0.00015558f, 0.01240508f, -0.00091684f, 0.12436362f, 0.14197399f, 0.26470211f, 0.19329263f, 
    0.14649995f, -0.34198585f, -0.29609993f, 0.10131274f, 0.09363067f, -0.02921766f, -0.09958748f, -0.17050076f, 
    -0.04581363f, 0.20250979f, -0.01079981f, 0.07367651f, 0.04699150f, 0.02872552f, -0.02446506f, 0.01639611f, 
    0.14892903f, 0.19889940f, 0.11684006f, 0.24337596f, -0.36851606f, 0.13959213f, 0.50246656f, 0.18343133f, 
    -0.03671114f, 0.16136970f, -0.17697896f, -0.04910382f, -0.07825286f, -0.17971255f, -0.04637353f, -0.05974323f, 
    0.02627907f, -0.03819458f, -0.02430226f, -0.04111861f, -0.22534947f, -0.20254850f, -0.26566711f, -0.29512212f, 
    -0.12329864f, -0.90659827f, -0.76217741f, -0.44544768f, -0.08243442f, -0.10600458f, 0.20061320f, 0.21702029f, 
    0.06209775f, 0.20140636f, 0.09011558f, -0.21151456f, -0.17766100f, -0.05149175f, -0.06564651f, 0.02789356f, 
    0.06500666f, -0.08868392f, 0.11266004f, -0.06552850f, 0.09639351f, -0.68739152f, -0.80328572f, 0.15460993f, 
    0.03674755f, -0.12148658f, 0.11504565f, 0.03342640f, 0.00360053f, 0.32482645f, -0.07031095f, -0.07738421f, 
    -0.08589801f, -0.04951610f, 0.06415948f, 0.01900905f, 0.07826483f, 0.06339546f, 0.09227240f, 0.01932007f, 
    0.25098360f, 0.24569143f, -0.26469496f, -0.63125694f, -0.10085043f, 0.16799460f, -0.38970289f, -0.12849678f, 
    -0.26192823f, -0.28320971f, 0.04882189f, -0.01638673f, -0.01737050f, 0.05530923f, 0.10299968f, 0.14617652f, 
    0.03181511f, 0.05916968f, -0.17585512f, -0.57969940f, 0.14398874f, -0.01817040f, 0.39400530f, 0.09365357f, 
    -0.05247623f, 0.11799230f, 0.17438579f, -0.01309982f, 0.06561334f, 0.20801285f, 0.06330103f, 0.09511211f, 
    0.05773542f, 0.02137172f, 0.05623480f, -0.03573071f, -0.23208238f, 0.03484682f, -0.34338954f, -0.74460632f, 
    0.30325064f, -0.20896342f, -0.97310662f, -0.39797592f, 0.12618901f, 0.19301866f, -0.00215105f, 0.22440186f, 
    0.17245114f, -0.04873478f, 0.02711253f, -0.01366583f, -0.02122343f, 0.01184563f, 0.01752643f, 0.10787357f, 
    0.01616585f, -0.01968784f, 0.05857547f, -0.10694323f, -0.63962317f, -1.04611576f, 0.26501760f, 0.33518177f, 
    0.39978817f, -0.06210539f, 0.24918975f, 0.19304724f, 0.06982946f, 0.16706251f, 0.01778675f, -0.00328431f, 
    0.09508889f, 0.09227636f, 0.04784599f, -0.13357732f, 0.05357935f, -0.00946361f, 0.03148052f, 0.05489712f, 
    0.14174479f, -0.19462563f, -0.74288046f, -0.16503561f, -0.10265731f, 0.31700546f, 0.13099734f, 0.23782928f, 
    -0.10009476f, 0.18743135f, 0.03291880f, -0.09548242f, -0.02946901f, -0.09367440f, -0.12779163f, -0.02878147f, 
    0.00885799f, 0.00359765f, -0.20740968f, -0.02668080f, -0.35954586f, 0.20235781f, -0.65060377f, -0.17775109f, 
    -0.20427610f, -0.01732149f, -0.11159796f, 0.19430842f, -0.10689954f, -0.10468773f, 0.07757362f, 0.08842319f, 
    -0.26351508f, -0.15086228f, 0.02562531f, -0.12235948f, 0.02072507f, -0.09536957f, 0.02122267f, 0.04367347f, 
    -0.39448765f, 0.37936151f, 0.13356207f, 0.88848466f, -0.06384055f, -0.09477170f, 0.00161636f, -0.45716122f, 
    0.09857631f, -0.32685682f, 0.15018986f, -0.19173962f, 0.15338276f, -0.19551460f, -0.11557238f, 0.19888525f, 
    0.06342150f, -0.16751462f, 0.00458657f, 0.13153788f, -0.24194564f, 0.06971981f, 0.61833638f, 0.57525051f, 
    -0.78376263f, 0.15783703f, -0.20496343f, -0.06855361f, 0.12463135f, 0.16216734f, 0.10813790f, 0.04946130f, 
    0.07110437f, 0.06789403f, 0.03738665f, -0.05749765f, -0.01311615f, 0.00838230f, 0.03608740f, 0.02415521f, 
    -0.33568734f, 0.00512211f, -0.05879831f, -0.19121790f, 0.25704476f, 0.01575479f, 0.05984735f, 0.17087376f, 
    0.09825192f, -0.04842027f, 0.05637818f, 0.19592933f, 0.13717180f, 0.02330019f, -0.04147586f, 0.23014951f, 
    0.00205556f, 0.01607562f, -0.04293072f, 0.11929817f, -0.38252607f, 0.26613531f, -0.06405988f, 0.29954761f, 
    0.32047719f, -0.08866189f, 0.05201717f, -0.12557296f, -0.00718711f, 0.04489935f, 0.19203953f, -0.15835999f, 
    -0.04476987f, 0.03246000f, 0.17655529f, 0.25480667f, 0.11371657f, 0.04346114f, -0.04536268f, 0.14785123f, 
    0.02978971f, 0.13780415f, -0.57860196f, 0.12954178f, -0.11196275f, 0.09924669f, 0.02637300f, -0.11208529f, 
    -0.03551216f, -0.15202771f, 0.13300051f, -0.01801385f, -0.12586221f, -0.11676345f, -0.15351772f, 0.11967350f, 
    -0.00418925f, -0.23958966f, -0.13466996f, -0.11078350f, 0.36478081f, -0.11825410f, -0.20342053f, 0.18740360f, 
    -0.42200372f, -0.03348308f, -0.19331957f, 0.34453544f, 0.09169286f, 0.07171220f, -0.07646502f, -0.08090923f, 
    -0.06123408f, -0.04526338f, -0.02993729f, 0.08036154f, -0.05323774f, 0.02080655f, 0.15313846f, -0.35219267f, 
    0.00766902f, 0.34858724f, 0.59202874f, -0.19268695f, -0.25616977f, 0.08343494f, -0.13108137f, 0.27871954f, 
    -0.09108410f, 0.09884595f, -0.06387505f, 0.01011121f, 0.02086483f, -0.09631744f, -0.00849885f, 0.00720242f, 
    -0.06640131f, -0.04363971f, -0.07206594f, -0.34584704f, 0.04541411f, -0.20600411f, -1.04922903f, 0.29695278f, 
    -0.02833890f, 0.00814887f, 0.08985126f, 0.32086489f, 0.00509068f, 0.19446325f, -0.01068137f, 0.02182882f, 
    -0.08314706f, 0.04217321f, 0.06769155f, 0.02154338f, 0.05223098f, -0.04251468f, 0.14910090f, 0.14364570f, 
    -0.20661482f, -0.03725313f, 0.44373649f, 0.51128918f, -0.79710943f, 0.24161591f, -0.36646745f, -0.58001375f, 
    -0.15239200f, -0.36541384f, 0.07321619f, -0.01653825f, 0.09959330f, 0.15527186f, 0.06446034f, -0.00663877f, 
    -0.05058334f, -0.02924523f, 0.01759963f, 0.00363067f, -0.37767208f, -0.45656273f, 0.35112381f, -0.51824307f, 
    -0.28024259f, -0.17574389f, -0.46115959f, 0.08465478f, 0.26625010f, 0.15669975f, -0.08317725f, 0.01335824f, 
    -0.11355989f, -0.04591724f, -0.23046006f, -0.01558848f, 0.11845107f, 0.07052857f, -0.16707629f, 0.00453276f, 
    -0.61667311f, -0.39985687f, -0.33512333f, 0.14215219f, -0.26930934f, -0.40008917f, 0.20761144f, -0.01280389f, 
    -0.03762793f, 0.08422648f, 0.08441009f, 0.04666916f, 0.04941556f, 0.02721518f, -0.02475602f, 0.02006212f, 
    0.09585708f, -0.06044357f, 0.18390331f, 0.11434602f, -0.19967958f, -0.47684506f, -0.36694562f, -0.65617603f, 
    0.01844846f, 0.09790286f, 0.07262047f, 0.13417752f, 0.15262128f, 0.19691527f, -0.04288880f, 0.05455609f, 
    0.06236613f, -0.08911669f, 0.02200704f, -0.03782407f, 0.17881607f, 0.14107193f, 0.13060902f, 0.17968610f, 
    -0.08750512f, 0.18999082f, 0.01506270f, 0.25023589f, -0.48430136f, -0.01902521f, -0.13639984f, -0.03725956f, 
    -0.06941359f, 0.07946391f, 0.10418403f, 0.03285099f, 0.01532038f, 0.04692106f, -0.01871523f, -0.17014594f, 
    -0.04842502f, 0.21388030f, 0.06841884f, -0.04253079f, 0.12077044f, -0.51234061f, 0.39544272f, -0.41007167f, 
    -0.39274305f, -0.22900400f, -0.31768847f, -0.18113688f, 0.18223427f, -0.20481451f, -0.23890494f, 0.05495576f, 
    0.08218080f, 0.13369042f, -0.06665153f, 0.08653965f, 0.07626882f, 0.13695382f, -0.07319085f, 0.14905468f, 
    -0.71111226f, -0.67320800f, -0.20849754f, -0.06836906f, -0.36051422f, 0.00037896f, -0.33533996f, 0.20795096f, 
    0.45716503f, 0.10725493f, -0.30802566f, 0.15028493f, 0.08228032f, -0.15498260f, -0.15816364f, 0.07045324f, 
    -0.10471390f, 0.05013538f, 0.25624222f, 0.19176906f, -0.10440125f, -0.28582302f, 0.23669684f, 0.67394465f, 
    0.04121340f, 0.02241259f, -0.19860545f, 0.25726393f, -0.05022509f, -0.05421501f, -0.24913831f, -0.00928013f, 
    0.10362213f, 0.21157081f, 0.16399734f, 0.07406899f, 0.07574683f, 0.19390918f, 0.08944394f, 0.33733609f, 
    0.44942051f, -0.06178768f, 0.31747940f, -0.49711254f, -0.03259777f, 0.03778815f, -0.27981603f, 0.14824843f, 
    0.04811662f, -0.14447375f, -0.20357336f, 0.16476093f, -0.26691419f, 0.10933918f, -0.14509425f, -0.19146697f, 
    -0.23652178f, 0.07501976f, -0.17814051f, -0.18068382f, -0.57070547f, 0.08448405f, -0.66725266f, 0.02280255f, 
    0.18579477f, -0.14767110f, -0.21833403f, -0.35679987f, 0.03952982f, 0.10157607f, -0.08908447f, 0.06259245f, 
    0.04138034f, 0.06535867f, -0.01895223f, 0.04407486f, -0.05027831f, -0.08899840f, 0.02565455f, -0.08373310f, 
    -0.19868423f, -0.60843927f, 0.07641862f, -0.44134924f, -0.44383952f, -0.10804528f, -0.24262333f, -0.09273627f, 
    0.00454320f, 0.00342850f, -0.01726627f, 0.13718605f, -0.10845246f, -0.09134667f, -0.03898532f, 0.03407532f, 
    0.04460114f, 0.11100414f, 0.03749865f, -0.24009050f, 0.73584980f, -0.33375445f, 0.52282161f, -0.20981993f, 
    -0.31155133f, -0.00946493f, -0.13716698f, 0.06314480f, 0.11612862f, -0.30325285f, -0.05803992f, 0.17489275f, 
    0.10229081f, -0.04607176f, -0.07360062f, 0.05007996f, -0.21263219f, 0.06127190f, -0.21683127f, -0.35201800f, 
    -0.65040272f, -0.34348115f, -0.00277664f, -0.03655059f, 0.09859170f, 0.00522615f, 0.02586546f, 0.34835213f, 
    0.27567896f, 0.18316863f, -0.07913288f, 0.02188892f, -0.07617640f, 0.10113943f, 0.08839522f, 0.06285650f, 
    -0.00037881f, 0.16728717f, 0.27114245f, 0.13426980f, -0.73501754f, -0.04001682f, -0.74103421f, 0.00781765f, 
    0.10788392f, -0.05770528f, -0.08421219f, 0.16561475f, -0.17225084f, 0.14076224f, -0.18561317f, 0.26057899f, 
    -0.05152727f, 0.15970547f, -0.02223491f, 0.15627228f, -0.00735569f, -0.02315034f, 0.03481190f, 0.15594472f, 
    -0.49441341f, 0.04639617f, -0.12791239f, 0.42109397f, 0.04262091f, -0.04349656f, 0.13178019f, 0.02826801f, 
    0.25235465f, 0.01455794f, -0.04672405f, -0.27588066f, 0.08357668f, 0.11894963f, 0.05866911f, 0.14344180f, 
    0.18335915f, -0.17921877f, 0.32872874f, 0.36653361f, 0.11959773f, -0.10667167f, -0.52487308f, 0.08384795f, 
    0.16502599f, -0.13902776f, -0.12107160f, 0.18688539f, -0.40043697f, -0.16508789f, -0.06046574f, 0.17817841f, 
    -0.14176352f, 0.03970246f, 0.05741854f, 0.20007400f, -0.33312997f, -0.33545688f, -0.39153844f, -0.17612344f, 
    -0.16781685f, 0.00038158f, 0.17270547f, -0.01509537f, 0.09500232f, -0.04050785f, 0.04716691f, -0.50827211f, 
    0.14266971f, 0.05363609f, 0.03402074f, 0.17311132f, -0.16504337f, -0.08807148f, -0.02960460f, -0.02343670f, 
    0.07711671f, 0.00788699f, 0.12897688f, 0.01736534f, -0.44555974f, 0.24486703f, 0.38387665f, -0.04919674f, 
    0.14061101f, -0.03939392f, -0.06140601f, -0.08894364f, -0.08931488f, -0.31562322f, -0.13986340f, -0.01525011f, 
    0.20216438f, -0.00939218f, -0.03065665f, -0.03238823f, 0.02436443f, -0.16299470f, -0.03622105f, 0.08534866f, 
    -0.27730027f, 0.28497002f, -0.43198058f, 0.18627614f, 0.14824349f, 0.04404588f, -0.01625162f, 0.27796727f, 
    -0.27674353f, 0.02228105f, -0.10974360f, 0.06432666f, 0.22079098f, -0.00221184f, 0.06384730f, 0.12902936f, 
    -0.08482608f, -0.39485627f, -0.22506011f, -0.18813571f, 0.01150158f, 0.07264561f, 0.61916262f, 0.19781986f, 
    0.04054609f, 0.07113116f, 0.10878187f, 0.08490227f, -0.41142860f, -0.27969137f, 0.05609336f, -0.04483779f, 
    0.03262919f, 0.05215403f, -0.01067048f, -0.01822761f, -0.14999071f, 0.25500312f, -0.64483166f, -0.22196390f, 
    -0.17909193f, 0.03472649f, -0.03482839f, 0.10398724f, 0.32186955f, -0.20743038f, -0.04410715f, -0.08536375f, 
    0.15657632f, 0.11387227f, -0.05780063f, 0.11460490f, -0.12606062f, -0.03330294f, 0.04361306f, 0.12356596f, 
    -0.05189813f, -0.00059291f, -0.03118535f, -0.17800048f, -0.06584258f, 0.39726022f, -0.02975422f, 0.28013003f, 
    0.14506617f, 0.26800203f, -0.11412793f, 0.09512405f, 0.12012599f, 0.09170128f, -0.07276554f, -0.05854566f, 
    -0.04918012f, 0.02213660f, -0.05629764f, -0.15194638f, 0.01434105f, -0.01187469f, 0.00148432f, -0.02898524f, 
    0.55749708f, 0.49141717f, 0.73178172f, -0.02449962f, -0.63305920f, 0.06888656f, 0.01113707f, 0.21966481f, 
    0.16101992f, -0.15235390f, -0.25508341f, -0.02428422f, 0.03442721f, -0.03079724f, -0.02586871f, -0.01135962f, 
    -0.10726681f, 0.14689422f, 0.16199452f, 0.06741359f, 0.46623728f, -0.15227869f, 0.65246433f, -0.13488987f, 
    -0.25962979f, 0.01757143f, 0.18874142f, -0.21730368f, 0.30860677f, -0.04665380f, 0.03010324f, 0.03256711f, 
    -0.11537401f, 0.05718789f, -0.15304683f, -0.16613883f, 0.30616543f, 0.09408414f, 0.05486305f, -0.20119081f, 
    -0.45509458f, -0.15070681f, -0.01621894f, 0.02909552f, 0.05151184f, 0.12872696f, 0.25318608f, 0.14681804f, 
    -0.19443044f, 0.15595897f, -0.11265188f, -0.03677864f, -0.05570842f, 0.23896039f, 0.07354568f, -0.14817624f, 
    0.08639958f, 0.10817658f, -0.07239795f, 0.21922964f, 0.11292643f, -0.28486919f, 0.07435695f, -0.14673743f, 
    -0.27858251f, -0.15562701f, -0.09176835f, -0.04651632f, 0.02620019f, -0.10336500f, 0.00249082f, 0.06455393f, 
    0.14548372f, -0.03932300f, -0.17591384f, 0.03613007f, 0.00598178f, 0.02624133f, 0.09336796f, -0.07021017f, 
    0.14284848f, -0.02876556f, -0.22868699f, 0.12230161f, 0.07489807f, -0.20860665f, 0.07912323f, -0.11828748f, 
    0.16064709f, 0.05624329f, -0.39467195f, 0.07158275f, 0.12053521f, 0.02424786f, 0.01061420f, 0.03457743f, 
    0.03134330f, -0.00550800f, -0.35822356f, -0.08475832f, -0.63329548f, -0.12531438f, -0.50468057f, -0.25254315f, 
    0.21341221f, 0.02106429f, 0.11448820f, 0.02062301f, -0.33047706f, 0.16186588f, -0.02532793f, 0.14989214f, 
    0.02518395f, 0.36492541f, 0.26449108f, 0.09459572f, 0.13203485f, 0.19696192f, 0.07354806f, 0.26616806f, 
    0.04600903f, 0.31323451f, 0.41923147f, 0.08815033f, -0.06480175f, 0.17254612f, -0.05707958f, 0.17039448f, 
    -0.16192977f, -0.20587461f, -0.11888164f, -0.15390824f, 0.07705560f, 0.03491573f, -0.04161762f, 0.10166895f, 
    -0.14280668f, -0.16043715f, -0.10170751f, 0.07950770f, -0.36784995f, -0.64192712f, -0.27695915f, 0.18069726f, 
    0.07244649f, -0.24031621f, -0.62907636f, 0.12110792f, -0.34653395f, -0.23780914f, 0.06079204f, 0.01749113f, 
    0.12359697f, -0.07266592f, -0.12381241f, 0.09868979f, -0.15126133f, -0.06790324f, -0.11622873f, -0.03831001f, 
    0.09923550f, -0.40051198f, 0.22867745f, 0.07003258f, 0.05533541f, -0.05140333f, -0.09682062f, 0.07553987f, 
    0.21326430f, -0.34695700f, -0.01385606f, 0.02303190f, 0.01074755f, -0.09722390f, 0.07186057f, -0.05348355f, 
    -0.15171306f, 0.07550177f, -0.05064660f, -0.44365260f, 1.00068891f, -0.41685238f, 0.62480026f, 0.03857381f, 
    -0.01936487f, 0.03298370f, -0.20965315f, -0.23835829f, 0.21051468f, -0.13383219f, -0.11993555f, 0.00957578f, 
    0.01264608f, -0.13767540f, -0.08781704f, -0.04488227f, 0.06675757f, -0.01706270f, 0.13485049f, 0.03414722f, 
    -0.42195213f, -0.32980135f, 0.00279301f, 0.04952591f, -0.51257372f, 0.04038295f, 0.04104864f, -0.15647413f, 
    0.03494373f, -0.01835292f, 0.01150468f, -0.01733285f, -0.03704458f, -0.18125601f, -0.00867719f, -0.02483279f, 
    -0.16057026f, -0.10720256f, -0.08713289f, -0.05090396f, 0.05247945f, -0.01812795f, -0.27681583f, 0.41713318f, 
    -0.19685088f, 0.13365614f, -0.14915024f, -0.10202743f, -0.07590099f, -0.09362542f, 0.01799161f, 0.06262952f, 
    -0.14430660f, -0.01084746f, 0.05931657f, 0.09755774f, -0.00212304f, 0.11312264f, 0.09542265f, -0.21925780f, 
    -0.34422857f, -0.54084659f, -0.37979820f, 0.35297024f, -0.16330992f, 0.00997376f, -0.34865433f, 0.28232193f, 
    -0.49108878f, -0.05301243f, 0.02451899f, -0.03616644f, 0.15135656f, 0.16311792f, 0.02843021f, 0.18561225f, 
    -0.10717291f, 0.13379997f, -0.00859255f, -0.03189140f, -0.41398743f, -0.06978217f, -0.65072429f, 0.69199479f, 
    0.36147118f, 0.11346982f, 0.04499046f, 0.06479727f, -0.13317953f, -0.01164603f, 0.09431226f, 0.11982200f, 
    -0.03844545f, -0.04569262f, 0.03522469f, 0.29790431f, -0.00309165f, 0.21798128f, 0.15084857f, 0.11345167f, 
    0.23688245f, -0.09712102f, 0.20542267f, -0.67695791f, -0.17413925f, -0.00048804f, -0.46328175f, -0.04267782f, 
    0.02277372f, -0.04170924f, -0.02799723f, 0.00379152f, 0.16195309f, 0.01503181f, -0.09103699f, 0.16716316f, 
    0.08546932f, -0.08342337f, 0.14293376f, 0.01790919f, -1.21491694f, 0.39047006f, -0.81319457f, 0.67357779f, 
    -0.16713023f, -0.07419184f, 0.24776305f, -0.08361457f, 0.45366991f, 0.05452818f, -0.31507069f, -0.12936231f, 
    0.02282077f, 0.07353263f, 0.07376194f, -0.05768991f, 0.06005830f, 0.16830692f, -0.05283335f, 0.10615498f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28776067f, 0.23506796f, 0.09069895f, -0.12873197f, -0.04179932f, 0.10603377f, 0.02696446f, -0.16660704f, 
    0.12335192f, 0.01041284f, 0.02656796f, 0.01710793f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
