#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20797192f, -0.29579216f, 0.80241817f, -0.01741786f, -0.27224010f, -0.81189328f, -0.77704477f, -0.20128903f, 
    0.56442517f, 0.19614707f, -0.01907062f, -0.58740354f, -0.66863632f, 0.92390132f, -0.09122512f, -0.49882424f, 
    -0.22252201f, -0.01889200f, 0.20944883f, -0.40583080f, 0.13476649f, 0.49459413f, 0.25245970f, -0.21947348f, 
    -0.28901076f, 0.16434255f, -1.36755002f, -0.44893411f, -0.00463201f, -0.10399535f, -1.00355089f, -0.75283599f, 
    -0.20152172f, 0.20919256f, -0.71753484f, -0.00039703f, -0.25838560f, 0.15838672f, 0.14329357f, 0.47080421f, 
    -0.21139045f, -0.14144884f, -0.31746483f, -0.26177391f, -0.20818572f, -0.04029290f, 0.07190968f, -0.10697695f, 
    -0.15488890f, 0.38159934f, -0.12383164f, -1.25115383f, -0.76848882f, -0.44094911f, -0.35310426f, 0.77859944f, 
    -0.01715049f, 0.00759456f, 0.07213555f, 0.55532587f, 0.18371038f, -0.07865824f, -0.04033969f, -0.27588210f, 
    0.25827101f, -0.37080899f, -0.22003461f, -0.10327727f, 0.13640891f, 0.20089330f, -0.09225333f, -0.35683528f, 
    -0.12616782f, 0.06668231f, -0.55600041f, 0.57557684f, -0.89278418f, -0.97265768f, -0.72369462f, -0.80702931f, 
    0.40080965f, 0.37534308f, 0.45090759f, 0.18550283f, -0.05509207f, 0.31009933f, -0.07817154f, 0.30447218f, 
    0.15021136f, 0.31699964f, 0.05855751f, 0.05499817f, -0.04874593f, -0.13289724f, -0.02369151f, -0.23321787f, 
    -0.09580731f, 0.04344381f, -0.00681839f, 0.21054015f, -0.01411160f, -0.03664488f, -0.41395533f, -0.45590517f, 
    0.13665973f, -0.12921625f, 0.31474885f, 0.38764966f, 0.50443012f, -0.08296381f, 0.01044532f, 0.16423985f, 
    0.19259156f, -0.54606950f, 0.02678055f, -0.53995633f, -0.01337477f, -0.16403554f, -0.20472014f, -0.12102188f, 
    0.22285601f, 0.27087238f, -0.35747734f, 0.28436112f, 0.38957494f, -1.13454676f, -0.64291924f, -0.18294142f, 
    -0.07815183f, -0.37471047f, 0.20776244f, -0.77321780f, -0.89292544f, -1.03320205f, -0.59953356f, -0.33199632f, 
    -0.17136075f, -0.08958076f, -0.24667458f, -0.58331114f, 0.12032223f, -0.07926442f, -0.28455681f, -0.20709471f, 
    -0.44884101f, 0.00802069f, -0.21000934f, -0.33446491f, -0.13519190f, 0.18204142f, -0.51737243f, 0.21113563f, 
    0.41249245f, -0.26427788f, 0.10097995f, -0.32717964f, 0.05162164f, -0.19381127f, 0.33291471f, 0.08244646f, 
    0.07223057f, -0.51332873f, -0.25800025f, -0.31571031f, 0.47367844f, -0.15469822f, -0.00033820f, -0.00253228f, 
    0.11190046f, 0.08424358f, -0.44749486f, -0.46790323f, -0.41206563f, -0.39030501f, -0.73463494f, 0.26992035f, 
    -0.50348568f, 0.12557811f, 0.68864626f, 0.06587859f, -0.54175663f, -0.95060152f, -0.14886293f, 0.76471859f, 
    0.42071718f, 0.44720697f, -0.16437019f, -0.16789041f, -0.23158930f, -0.09177746f, 0.04446314f, 0.26606333f, 
    0.24259651f, -0.17353031f, -0.30820411f, -0.09595970f, -0.26377484f, 0.10563362f, 0.18514928f, 0.29449931f, 
    -0.57542503f, -0.68625391f, 0.05902730f, -0.53260422f, -0.64316267f, 0.26888585f, 0.44417766f, -0.34434170f, 
    -0.10494325f, 0.81280541f, -0.22278252f, -0.14329709f, 0.25726506f, 0.01302447f, -0.09090696f, -0.29644701f, 
    -0.05158346f, -0.35355288f, -0.57158482f, -0.63364345f, -0.13826820f, -0.43293756f, -0.04491413f, 0.01213647f, 
    -0.15395103f, -0.51547593f, 0.47520378f, 0.04604391f, -0.00186534f, -0.08311444f, -0.18781649f, -0.21623422f, 
    0.00451112f, 0.03083054f, -0.05571802f, -0.15967222f, -0.09169627f, 0.39894059f, -0.67893636f, 0.45237258f, 
    -0.16563582f, 0.12981962f, -0.19050521f, 0.32730621f, -0.09634575f, -0.18622333f, 0.29029673f, -0.16391689f, 
    -0.07924240f, 0.51757586f, -1.35691822f, -0.33573070f, -0.90454775f, -0.46595046f, -0.13878942f, -0.54337728f, 
    -0.33878526f, 0.19378248f, 0.10224847f, 0.06051618f, 0.21439587f, -0.44758713f, -0.36070529f, -0.53568655f, 
    -0.20258328f, 0.01548281f, -0.10203645f, 0.11905298f, -0.03093871f, -0.24899523f, -0.30843726f, -0.00299946f, 
    0.19601031f, -0.33711445f, -0.07917795f, 0.51727080f, 0.75396055f, 0.53513509f, -0.44200942f, -0.41374397f, 
    -0.96230870f, -0.67103148f, -0.18035723f, -0.55858451f, -0.52919018f, -0.05696439f, -0.09036265f, -0.28939897f, 
    0.00147224f, 0.25697494f, -0.01606345f, 0.30381867f, 0.45035359f, 0.18317227f, 0.26500648f, 0.06768698f, 
    -0.00915442f, -0.28114477f, -0.37044317f, -0.41581678f, 0.73611116f, 0.09038906f, 0.02584872f, 0.20217837f, 
    0.17548963f, 0.45751330f, 0.04904078f, -0.29149914f, -0.31039411f, 0.34032413f, 0.08421219f, -0.10442691f, 
    -0.27749887f, -0.25457084f, 0.13751869f, -0.20455226f, -0.25415331f, 0.36565813f, 0.14508435f, -0.14351279f, 
    -0.25370577f, 0.14399493f, -0.01265802f, -0.40951133f, -0.28709090f, 0.44784653f, 0.09571441f, 0.19352813f, 
    0.38982144f, 0.33826438f, 0.03662887f, 0.30825001f, 0.20013522f, 0.11422263f, 0.32629460f, -0.32609439f, 
    -0.05208037f, 0.03315258f, 0.05753069f, -0.20969248f, -0.26523665f, -0.37454975f, 0.10615776f, 0.02754882f, 
    -0.26750356f, -0.13889565f, 0.19899890f, 0.21648961f, 0.11593470f, 0.05169401f, 1.39605820f, -0.14173302f, 
    -0.49313250f, -0.82739043f, -0.88786525f, 0.10374589f, 0.20022473f, 0.23549418f, 0.01615364f, 0.17620155f, 
    -0.36910182f, 0.75796825f, 0.22571838f, -0.34354505f, 0.11867492f, -0.11724795f, 0.02524180f, 0.05560509f, 
    -0.21684562f, 0.07295598f, 0.09561865f, -0.34961703f, -0.17731728f, -0.22407226f, -0.55444098f, 0.06483676f, 
    0.52508801f, -0.19565634f, 0.06471269f, 0.05683935f, -0.32412159f, -0.43964845f, -0.36375415f, 0.39222494f, 
    0.44220683f, 0.04034072f, -0.06770898f, 0.09624754f, 0.00980318f, 0.09446666f, -0.00460213f, -0.26207578f, 
    0.04698681f, -0.01146427f, -0.05169182f, 0.08336233f, -0.16579014f, -0.25099531f, 0.51138920f, -0.32829002f, 
    1.18648052f, 0.77682036f, -0.05774437f, -0.27071488f, -0.38995737f, -0.16939934f, 0.02012911f, 0.18106179f, 
    -0.11893465f, -0.61804664f, 0.16239029f, 0.20865801f, -0.18402860f, -0.36471283f, -0.24597962f, 0.12943421f, 
    0.15775299f, 0.04399611f, -0.15432730f, -0.06896443f, 0.04508255f, 0.03822926f, -0.10861965f, 0.08779903f, 
    -0.21246110f, -0.59457088f, -0.14929098f, -0.31643954f, -0.59429890f, -0.74836731f, 0.14237455f, -0.50657171f, 
    -0.42144778f, -0.62935132f, -0.56042874f, -0.43831247f, 0.24276868f, -0.30721703f, -0.25708386f, 0.02049632f, 
    0.03939226f, 0.16434845f, -0.08054290f, -0.05994556f, -0.02379168f, 0.18899859f, 0.26037341f, 0.22094157f, 
    0.32313982f, 0.41982728f, 1.34166121f, -0.77206564f, -0.79853380f, -0.45073706f, 0.20372435f, 0.15913738f, 
    0.13914292f, 0.28999025f, 0.20838854f, 0.11485583f, -0.41040254f, 0.14413993f, -0.00555480f, -0.02641986f, 
    -0.01440873f, 0.14831381f, -0.19370799f, -0.14610638f, 0.15833195f, -0.00413755f, 0.23410700f, -0.20760910f, 
    -0.02615886f, 0.03328472f, 0.09909368f, 0.41710308f, 0.48000172f, 0.16617005f, 0.30441999f, -0.22565012f, 
    0.03615855f, 0.01909624f, 0.13642466f, 0.12015112f, 0.25162044f, 0.29399499f, 0.30606619f, -0.08639841f, 
    -0.13744262f, 0.42665529f, 0.07340953f, 0.38762808f, 0.03250950f, 0.08470466f, -0.18503590f, 0.13044253f, 
    0.23573962f, -0.08759928f, 0.16883241f, -0.23510036f, -1.45498896f, -0.35003564f, -0.62151921f, -1.32908666f, 
    -0.72671080f, 0.64264023f, -0.02603563f, -0.35670552f, 0.24434781f, 0.52320910f, -0.43213660f, -0.36561835f, 
    -0.08639088f, -0.10994671f, -0.29435876f, 0.47534811f, 0.23178744f, -0.04735614f, 0.29585701f, 0.25708082f, 
    -0.10539243f, 0.19313607f, 0.13269168f, -0.08977465f, -0.05201913f, -0.80449486f, -0.53143167f, -0.31614783f, 
    0.39351961f, 0.46982920f, 0.44083089f, 0.51974463f, 0.31390625f, -0.29829657f, -0.07919627f, -0.51971877f, 
    -0.49350742f, -0.49708402f, -0.01328004f, 0.20549513f, 0.35653040f, -0.08845049f, -0.42672777f, -0.06568748f, 
    -0.33854371f, -0.52398515f, -0.22699350f, -0.17674665f, -0.30341315f, -0.61240089f, 0.74018663f, -0.31741685f, 
    -0.09780882f, -0.18280675f, 0.18403663f, -0.15384959f, 0.30453980f, -0.48202249f, -0.33992958f, 0.33263552f, 
    -0.02667570f, 0.13671681f, -0.11425660f, -0.28707677f, 0.57103997f, 0.07185556f, 0.13792117f, -0.21828870f, 
    0.07024641f, 0.00948608f, -0.07752662f, 0.37481639f, 0.14938959f, -0.00849034f, 0.28238720f, 1.17916012f, 
    -0.12108942f, -0.19717127f, -0.37174860f, -0.16753408f, 0.32466376f, 0.21595296f, 0.13363358f, -0.17173901f, 
    -0.05854150f, -0.17625330f, -0.07336381f, -0.00775995f, -0.46372601f, 0.35176730f, -0.01699649f, 0.04043242f, 
    -0.04698936f, -0.33212981f, -0.23418312f, -0.34591585f, -0.37789944f, -0.30491176f, -0.24682567f, -0.16308692f, 
    -0.57895005f, -0.96422243f, 0.16129409f, 0.92549086f, 0.12081760f, 0.60133910f, 0.47700310f, 0.32438529f, 
    -0.26749191f, -0.23896550f, 0.11254616f, -0.23670398f, -0.23276803f, 0.44256911f, -0.14144428f, -0.20577820f, 
    -0.07713322f, -0.38004285f, 0.04088921f, -0.20386872f, 0.01666425f, -0.06893322f, 0.13536005f, 0.19726112f, 
    0.28989795f, 0.28940445f, 0.10920782f, 0.44238612f, -0.42045292f, 0.08646301f, -0.65767491f, -0.15444814f, 
    0.63796669f, -0.09776258f, 0.07806767f, -0.18559353f, 0.08653654f, 0.23403661f, 0.25474271f, -0.28565633f, 
    -0.17748873f, 0.02771837f, -0.27279118f, 0.14278020f, -0.03425684f, 0.41251916f, -0.34167829f, -0.41565403f, 
    0.47868624f, -0.07435900f, 0.58615935f, 0.71787369f, 0.61769038f, -0.46017712f, -0.94710332f, -0.48796126f, 
    0.45751086f, -0.23956516f, -0.20096265f, -0.52526802f, 0.04061857f, -0.20122622f, -0.34152827f, -0.14303070f, 
    0.35074252f, 0.11234029f, -0.39343166f, 0.36543027f, 0.19469729f, 0.28295749f, -0.22687878f, -0.30800438f, 
    -0.21053486f, 0.04715234f, 0.34961489f, -0.01154402f, 0.30139774f, 0.26425943f, -0.06505243f, -0.06466905f, 
    -0.72502589f, -0.34039253f, 0.12193562f, 0.30663368f, 0.22235355f, -0.40296733f, 0.29561150f, -0.27905193f, 
    0.06282387f, 0.26644075f, 0.19561574f, -0.05948066f, -0.22957139f, -0.26434010f, 0.14138095f, -0.18861401f, 
    -0.07307225f, -0.19149825f, 0.00270073f, 0.10946763f, 0.33586442f, -0.16906020f, -0.65229934f, -0.46519798f, 
    -0.41118881f, 0.72666198f, 0.56234586f, -0.11413150f, -0.52537966f, 0.42731038f, 0.23927608f, 0.19835877f, 
    -0.36000824f, 0.27111837f, 0.21481128f, -0.12220410f, -0.28735158f, -0.07285228f, -0.11440714f, -0.44210008f, 
    0.61023968f, -0.21671465f, -0.30685204f, 0.13789491f, 0.25478077f, 0.81047797f, 0.63501894f, 0.35109410f, 
    -0.19777247f, 0.05845992f, -0.07078972f, -0.18040624f, -0.25455940f, -0.01681681f, -0.73739558f, -0.00812863f, 
    -0.22493026f, -0.08645146f, 0.33776155f, 0.23476383f, 0.04554923f, 0.10041486f, -0.19228314f, -0.24128662f, 
    0.29999310f, -0.08205323f, 0.15328470f, -0.10179074f, -0.25227058f, -0.02616301f, -0.28385887f, -0.10360624f, 
    0.22115324f, 0.16733815f, -0.42222917f, -1.00271952f, -1.15377116f, -0.27416417f, -0.54312950f, -0.66830623f, 
    0.34727347f, 0.61680824f, 0.35639668f, 0.21173403f, 0.27117640f, 0.03051453f, -0.29631725f, -0.19985114f, 
    -0.38050660f, -0.37237611f, -0.24454436f, -0.01411212f, 0.23809275f, -0.02011129f, -0.29364461f, -0.68853879f, 
    -0.40708679f, 0.13621788f, 0.02152214f, 0.26071376f, -0.38483462f, -0.12655364f, 0.44820353f, -0.69593936f, 
    -0.87964886f, -0.09471216f, 0.48941454f, -0.10386615f, 0.15603229f, -0.38499299f, 0.11964479f, 0.13445145f, 
    0.14965655f, 0.37537444f, 0.06354873f, -0.16218132f, -0.18838467f, -0.29925120f, 0.14473203f, 0.13279715f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35153484f, 0.22155716f, 0.45255965f, 0.52479321f, 0.26539782f, -0.42236209f, -0.01063416f, 0.55881292f, 
    0.03258544f, 0.21735160f, 0.29371002f, 0.24854665f, 0.06695785f, -0.16709664f, 0.15155980f, 0.08544430f, 
    0.78627336f, -0.16861539f, 0.33096069f, -0.06170797f, -0.32452103f, -0.21415289f, 0.30885002f, 0.05679990f, 
    0.36828783f, 0.15241204f, 0.31440645f, 0.56548995f, 0.17491461f, 0.33226377f, -0.13879764f, 0.33196130f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00711807f, 0.17320099f, 0.23986861f, -0.39444843f, -0.05357679f, -0.04414040f, -0.15617891f, -0.18703707f, 
    0.01950020f, -0.26233116f, -0.14733313f, -0.09896059f, 0.41160861f, 0.20014034f, 0.02627544f, -0.43852818f, 
    -0.00974010f, -0.13147391f, 0.10196651f, -0.25716540f, -0.14855999f, -0.12202533f, -0.06912573f, -0.13998704f, 
    0.37558261f, 0.04124970f, -0.21071354f, -0.12467054f, 0.09497998f, 0.05511593f, 0.06965025f, -0.25855589f, 
    0.02106931f, 0.01319940f, -0.04104106f, -0.00280205f, 0.29429615f, -0.07514539f, -0.29341066f, 0.11840623f, 
    0.10093512f, 0.01162050f, -0.00935434f, -0.04255527f, -0.03524108f, -0.10554631f, -0.01631075f, -0.02856223f, 
    -0.14932594f, -0.11957991f, -0.26648682f, 0.02378738f, 0.01678596f, 0.05949979f, -0.03621448f, -0.02987836f, 
    -0.15928723f, -0.28417593f, -0.04301754f, -0.14849070f, 0.55997616f, 0.45580849f, -0.19862436f, -0.28147310f, 
    0.04266520f, 0.02143941f, 0.21629554f, 0.20307069f, -0.06235215f, -0.15013994f, 0.01023569f, -0.08952951f, 
    -0.17865509f, 0.08670960f, 0.16278622f, -0.09607760f, -0.03076113f, 0.03513717f, 0.00412512f, -0.01190391f, 
    0.04575313f, -0.10708792f, 0.11251786f, 0.27838391f, -0.30363479f, 0.27186188f, 0.34127358f, -0.84016007f, 
    -0.03842716f, 0.11920094f, -0.00286943f, 0.00418283f, -0.10604502f, -0.08755188f, -0.07860891f, -0.00070082f, 
    0.15171120f, -0.00343584f, -0.09677856f, -0.03935085f, 0.02061583f, 0.05021089f, -0.04807343f, -0.08903962f, 
    0.00222879f, 0.04774567f, -0.06267599f, 0.10499655f, -0.08403187f, 0.24055998f, 0.12480221f, -0.06500110f, 
    -0.11992650f, -0.17366238f, -0.03013986f, -0.29497138f, 0.14492381f, -0.13455401f, -0.03548213f, -0.03979111f, 
    0.31991598f, 0.31394875f, 0.10411354f, -0.21694490f, 0.20405614f, 0.23931594f, 0.05039893f, 0.08137710f, 
    -0.04394219f, -0.04999743f, -0.05823708f, -0.07363655f, 0.07507847f, 0.11038108f, 0.03916192f, -0.11562024f, 
    0.12843227f, 0.02252915f, -0.07002579f, 0.05756423f, 0.11316008f, 0.10865837f, 0.02583711f, 0.02046028f, 
    -0.54731089f, -0.07036795f, -0.08283149f, 0.08181325f, -0.00815942f, -0.01774648f, 0.10140115f, 0.01719163f, 
    -0.04775338f, 0.04811030f, -0.01581574f, 0.10181441f, -0.22366035f, -0.52973330f, -0.27662587f, 0.21900758f, 
    0.10190596f, 0.05740195f, 0.08835135f, 0.07137192f, 0.04836241f, 0.04324914f, 0.00735846f, 0.01661319f, 
    -0.07948727f, -0.15554099f, -0.02494233f, 0.19936955f, 0.03882251f, 0.04859475f, -0.14084540f, -0.00362197f, 
    -0.05863457f, 0.03204078f, -0.23860770f, 0.00469148f, -0.10002476f, -0.04077478f, 0.12946546f, 0.03509627f, 
    0.08372328f, 0.00267383f, -0.03336569f, 0.09285370f, -0.01887914f, -0.01485889f, 0.02454356f, 0.07251628f, 
    -0.41209710f, -0.79746801f, -0.72787285f, 0.19024257f, -0.07146679f, 0.03540049f, -0.10739598f, -0.07665243f, 
    -0.10690901f, 0.04464130f, -0.06862228f, -0.03200300f, 0.31435439f, 0.27505115f, -0.29229498f, -0.24692799f, 
    -0.10859387f, 0.21061625f, -0.07541680f, 0.11740069f, -0.03459232f, -0.08889687f, 0.06162023f, -0.06069300f, 
    -0.29144934f, 0.06144702f, -0.49661872f, 0.17769194f, 0.04264141f, -0.00196690f, 0.00143011f, -0.22411214f, 
    -0.09248114f, -0.23938259f, -0.10267649f, -0.09549680f, 0.00046138f, 0.06289424f, 0.08017875f, 0.02905450f, 
    -0.06088111f, -0.02004130f, 0.07652966f, 0.07322922f, -0.20560648f, -0.19446006f, 0.04560068f, -0.03675601f, 
    0.32341447f, 0.20836344f, -0.08150142f, -0.26955569f, 0.07380055f, 0.43300092f, 0.07410245f, 0.10115356f, 
    0.03634636f, 0.08030289f, 0.09863300f, 0.05653281f, 0.45737171f, -0.14104049f, -0.09167408f, 0.03507076f, 
    -0.06332863f, -0.00917808f, -0.00447354f, -0.04725873f, 0.00357464f, 0.01448616f, 0.20206638f, 0.19791728f, 
    0.08260441f, 0.19615105f, -0.01645265f, 0.07012384f, -0.10116769f, -0.07484415f, -0.04108384f, -0.16318963f, 
    -0.07559611f, 0.03838920f, -0.03800742f, -0.07868834f, -0.35721612f, -0.34633523f, -0.27427092f, 0.22300857f, 
    -0.00029168f, 0.04282283f, 0.00230377f, -0.05731673f, 0.09003323f, -0.13184462f, 0.04096693f, -0.00153681f, 
    0.13289255f, -0.64020270f, -0.08346026f, -0.08647819f, 0.06370709f, 0.00233086f, 0.11345188f, 0.00598239f, 
    0.10554373f, -0.49116468f, -0.37265596f, -0.18874779f, -0.09282757f, -0.10502400f, 0.04690075f, 0.03760787f, 
    -0.02893543f, 0.00295314f, -0.12515488f, -0.01101906f, -0.05303919f, 0.00733025f, -0.02535210f, 0.12214608f, 
    -0.11314441f, -0.08485167f, 0.04722152f, -0.25391218f, -0.01318557f, -0.10954313f, -0.34653881f, -0.19245431f, 
    -0.07462601f, 0.06779762f, 0.02897011f, 0.03773811f, -0.59806693f, -0.02593285f, 0.12511148f, -0.07089931f, 
    -0.00559899f, -0.03608419f, -0.03551430f, -0.03682129f, -0.03984126f, 0.00722897f, -0.12569545f, -0.04623555f, 
    -0.08879184f, 0.00767724f, -0.70066595f, -0.06775567f, 0.04847951f, -0.00254814f, 0.06622369f, -0.17917828f, 
    -0.16689101f, -0.09090913f, -0.25440463f, -0.14111537f, -0.09056353f, -0.33290017f, -0.27666599f, 0.04631893f, 
    0.03209488f, -0.02590016f, -0.11651818f, -0.01102293f, -0.01421244f, 0.06027061f, 0.01633336f, -0.07011604f, 
    0.35008430f, 0.20653915f, -0.03769876f, -0.34947383f, -0.22797181f, 0.03472083f, -0.20243494f, 0.11593046f, 
    0.03169956f, 0.17761932f, -0.03258620f, -0.00787905f, 0.41417319f, 0.13779631f, -0.15297671f, -0.09847587f, 
    0.01448942f, -0.10034101f, 0.16775192f, -0.02033109f, -0.02989811f, 0.01626375f, 0.02829683f, 0.00574896f, 
    -0.28734395f, 0.01455823f, -0.26290455f, -0.32126528f, -0.10116664f, -0.17895941f, -0.10324720f, 0.36025876f, 
    0.09255947f, -0.12113394f, -0.00870635f, -0.20029530f, -0.54859346f, 0.35360479f, 0.00432849f, -0.02493391f, 
    -0.04007883f, 0.07013945f, 0.22248185f, -0.35840219f, -0.01990711f, 0.09587208f, 0.10035283f, -0.00360434f, 
    0.16259019f, -0.00308373f, -0.20430593f, -0.15242124f, -0.04959768f, 0.02450772f, -0.05025609f, -0.19277190f, 
    -0.03762623f, -0.00313928f, 0.03427726f, -0.01790632f, 0.06902885f, -0.22914310f, -0.14216687f, -0.13011639f, 
    0.02202618f, 0.13568385f, 0.07771337f, -0.35154122f, 0.18369734f, -0.05652134f, 0.10214701f, -0.01294441f, 
    -0.12372011f, 0.07980032f, -0.11078513f, 0.06516793f, 0.05697743f, 0.06658962f, 0.07215030f, 0.07842230f, 
    0.15040043f, 0.30719152f, -0.14853120f, -0.03737995f, 0.03853775f, 0.01542466f, 0.18240720f, 0.32204476f, 
    0.13121136f, 0.02018929f, -0.06329143f, -0.05661259f, 0.07104307f, 0.03184032f, 0.02442251f, 0.01737010f, 
    -0.08825580f, -0.06536133f, -0.02666491f, 0.05404419f, 0.01251425f, 0.04448640f, -0.10965312f, -0.00614732f, 
    -0.37743890f, -0.09756235f, 0.01822331f, -0.31208259f, -0.52595168f, 0.36044750f, 0.19603139f, 0.00494180f, 
    0.05854874f, 0.06086221f, -0.04704916f, -0.13574581f, -0.00262482f, -0.00908630f, -0.00883968f, 0.13433318f, 
    0.32484606f, -0.33696964f, -0.08351135f, -0.20563024f, 0.03518761f, 0.08893946f, 0.00539720f, -0.06704656f, 
    -0.33758456f, -0.15670761f, 0.17880747f, -0.41170621f, -0.02766663f, 0.03652368f, -0.11661737f, 0.06652267f, 
    -0.09592642f, 0.17833602f, -0.16967130f, -0.23118943f, -0.05258253f, 0.14720841f, -0.08302941f, -0.01340826f, 
    -0.05727770f, 0.13710575f, -0.06324390f, -0.10126552f, 0.17421505f, 0.00669199f, 0.11698265f, -0.27691793f, 
    -0.01248225f, 0.02422917f, -0.21449254f, -0.09310792f, 0.11486843f, 0.01123134f, -0.01389018f, -0.43115380f, 
    0.18895534f, -0.34541467f, -0.13642982f, 0.01601359f, -0.08522199f, 0.03071607f, -0.04560798f, 0.00453678f, 
    0.23123078f, 0.24997717f, 0.14908944f, 0.23513544f, -0.07630335f, -0.03301090f, -0.09691267f, 0.01723897f, 
    -0.01304222f, 0.06694789f, 0.02706599f, -0.08128331f, 0.28364983f, 0.23340881f, 0.22501765f, 0.17399758f, 
    -0.08611085f, 0.00265307f, -0.05569940f, -0.02776293f, -0.01593375f, 0.03551092f, -0.04384356f, -0.07090064f, 
    0.37526387f, -0.29851961f, -0.08598109f, -0.20899518f, 0.08628993f, 0.03428643f, -0.09403890f, 0.00700620f, 
    0.15125595f, -0.03052106f, 0.06482032f, 0.00499834f, -0.12067119f, 0.07765654f, 0.14121370f, 0.07881255f, 
    -0.06235977f, -0.05539282f, -0.09394048f, 0.02611551f, 0.08134737f, -0.05649610f, 0.02499640f, -0.00077916f, 
    0.50252938f, -0.09182781f, 0.61589241f, -0.04703517f, 0.04830154f, -0.19472933f, 0.10877997f, -0.05158921f, 
    -0.10518274f, -0.00178892f, -0.07657597f, 0.21890156f, 0.07265241f, 0.22781116f, 0.31188285f, 0.20910582f, 
    -0.08414480f, -0.03329581f, -0.06089380f, 0.23894125f, -0.04021643f, 0.06011685f, -0.06925938f, 0.00992361f, 
    1.06821144f, 0.05281776f, -0.46353438f, 0.20569323f, -0.09326206f, 0.10031093f, -0.02092071f, -0.09179977f, 
    0.03020944f, -0.06906263f, 0.08026565f, -0.01569880f, 0.01342113f, 0.08781069f, 0.06920260f, 0.04646471f, 
    -0.02746942f, 0.00084586f, 0.03070448f, -0.06237716f, 0.03044119f, -0.08696819f, -0.08483644f, -0.07241695f, 
    0.25399828f, 0.46211243f, 0.13913773f, 0.15936661f, -0.11204680f, 0.07070711f, -0.35073772f, -0.18532322f, 
    -0.10195943f, -0.08949845f, -0.08103841f, -0.15530366f, -0.08184338f, -0.44703797f, 0.30180123f, 0.29402587f, 
    -0.00769458f, -0.01609152f, -0.06902567f, -0.02517261f, -0.05585167f, -0.14355057f, -0.26340669f, -0.43841523f, 
    0.12424434f, -0.05875519f, -0.05173238f, -0.02320522f, -0.00104356f, 0.05104825f, -0.05682685f, 0.07334191f, 
    -0.16110353f, 0.03127122f, -0.01355945f, 0.05586403f, 0.64393401f, -0.04340237f, 0.16833080f, -0.03722566f, 
    0.05365991f, 0.01982401f, -0.00782620f, -0.08271774f, -0.17754015f, -0.05095463f, -0.45161477f, -0.24171521f, 
    0.07549334f, -0.37457827f, 0.11152548f, 0.03937375f, -0.14746861f, -0.00680660f, 0.10103971f, -0.01164503f, 
    0.02023842f, 0.20118608f, 0.23498414f, -0.01673651f, 0.07638951f, 0.01650883f, 0.14399724f, 0.07302123f, 
    -0.01166677f, 0.04461582f, 0.00086611f, -0.08896737f, 0.13797450f, -0.07370090f, 0.24044658f, 0.07351327f, 
    0.44223192f, -0.34876630f, 0.23598953f, -0.47392690f, -0.11255575f, 0.09579471f, -0.13881253f, 0.06270038f, 
    -0.00986686f, 0.05161390f, -0.01252850f, -0.06930373f, 0.02935934f, 0.00859421f, 0.11352568f, -0.04056694f, 
    0.15284055f, 0.07559402f, 0.01902872f, 0.09244523f, 0.11429721f, 0.05057593f, -0.02858892f, 0.02517116f, 
    0.31792814f, -0.65070796f, 0.09193667f, -0.30690765f, -0.14051367f, 0.00906146f, -0.09772683f, 0.10586675f, 
    0.10665736f, -0.11995029f, 0.17266735f, 0.01322731f, 0.27464551f, 0.11820429f, -0.21437629f, -0.07065532f, 
    -0.03566634f, -0.28921384f, -0.29080778f, 0.15940446f, -0.08345354f, 0.05169882f, -0.02770714f, 0.03012511f, 
    -0.31329533f, -0.09639573f, -0.18314770f, -0.15199099f, -0.15328488f, 0.08009955f, -0.00499120f, 0.53236961f, 
    -0.15716444f, 0.09164377f, 0.03608687f, 0.09840254f, -0.31285930f, -0.19002433f, -0.11435448f, -0.20747979f, 
    -0.18030973f, 0.12954040f, 0.14409147f, -0.12973621f, -0.01895396f, -0.02457515f, 0.02724961f, 0.06578389f, 
    -0.11887525f, 0.21963239f, -0.01680828f, -0.11144447f, 0.08070880f, 0.13820063f, -0.25222337f, 0.04861807f, 
    0.04136373f, -0.11642312f, 0.03200777f, -0.02886373f, -0.35043639f, -0.14532895f, -0.43533632f, 0.13387755f, 
    -0.04647027f, 0.31522691f, -0.04584352f, -0.11549123f, -0.05818000f, 0.07510321f, -0.04923349f, -0.09218362f, 
    -0.03814527f, -0.03929790f, 0.33834153f, 0.21856579f, -0.00571882f, -0.06945559f, 0.05626297f, 0.16071138f, 
    -0.07914802f, 0.12625863f, -0.01859736f, -0.11639942f, -0.06852657f, 0.39938614f, 0.41689220f, 0.03917519f, 
    -0.11213660f, 0.05553219f, 0.14299563f, -0.06166842f, 0.06439155f, 0.07788143f, -0.03752194f, 0.11477163f, 
    -0.04784488f, 0.29344365f, 0.08327315f, 0.07298428f, 0.03015979f, 0.05746214f, 0.02744125f, 0.07346279f, 
    -0.02263800f, -0.04807382f, -0.29866257f, 0.02602446f, -0.74500704f, -0.71197301f, -0.20226748f, -0.08833242f, 
    -0.01084576f, -0.02531520f, -0.27893293f, -0.04665357f, -0.01228370f, -0.01520277f, 0.01096604f, 0.02746364f, 
    0.08593513f, -0.03036542f, -0.09508829f, 0.01319754f, 0.03128980f, -0.02232632f, -0.06208540f, -0.01718822f, 
    0.07571619f, 0.25488940f, -0.11475650f, 0.23668355f, -0.50185966f, 0.00337654f, -0.02374781f, 0.11510676f, 
    0.06234187f, 0.01348590f, 0.02462591f, -0.03225379f, 0.00147172f, 0.03579541f, 0.06242936f, 0.06777512f, 
    0.20698537f, -0.05239319f, 0.68075746f, 0.36623484f, -0.04398677f, 0.07524633f, 0.03649742f, 0.03325421f, 
    -0.08162567f, -0.13980533f, 0.03380681f, 0.06925693f, -0.05110953f, 0.02058264f, 0.01785799f, 0.00982197f, 
    -0.02049860f, 0.36900666f, -0.12872344f, 0.13829283f, -0.08671102f, -0.08406559f, 0.03980252f, -0.04266268f, 
    -0.21795569f, 0.63265181f, 0.16689752f, 0.15073387f, 0.04996821f, -0.09859302f, 0.03813564f, -0.05432943f, 
    -0.02079757f, -0.02213233f, -0.01359875f, 0.09843036f, -0.31107020f, -0.27928695f, 0.20330253f, -0.33287695f, 
    -0.01304437f, -0.16230267f, -0.28892425f, -0.12515141f, 0.04633959f, 0.06475960f, -0.02501497f, -0.01171459f, 
    -0.12205090f, -0.11902744f, 0.04242305f, -0.23733127f, 0.01284009f, 0.02270661f, -0.00187314f, -0.00023399f, 
    0.02413620f, -0.04680737f, 0.01626816f, -0.01119908f, -0.48112532f, -0.20013051f, -0.21223617f, -0.26561436f, 
    -0.04235972f, 0.04451248f, 0.02071407f, 0.05361332f, -0.07082483f, -0.07868824f, 0.09910750f, -0.07868288f, 
    -0.12863448f, 0.27398428f, -0.02068510f, 0.07060170f, -0.02975480f, 0.03403252f, 0.02848439f, -0.39009160f, 
    -0.03482711f, 0.12288917f, -0.14673586f, 0.18137321f, -0.11123136f, 0.04281028f, 0.11954091f, 0.13692014f, 
    -0.05627480f, -0.02479730f, 0.08203373f, -0.05807079f, -0.02737558f, 0.09818051f, 0.03568028f, -0.01713203f, 
    -0.41337073f, 0.08607845f, 0.27022657f, -0.21902710f, 0.06313585f, -0.10063436f, -0.02904796f, 0.06241204f, 
    0.11626176f, 0.00608647f, -0.10731454f, 0.18664742f, -0.58644289f, -0.50375921f, -0.22686867f, -0.40522152f, 
    -0.05091909f, 0.16328451f, 0.02969855f, 0.02197685f, -0.05636410f, -0.01542294f, -0.04758821f, 0.02560480f, 
    -0.31957510f, 0.51972198f, 0.11704985f, 0.33547261f, -0.08284856f, 0.03412995f, -0.12684402f, 0.07112525f, 
    -0.01747760f, 0.04507025f, 0.14199731f, -0.08426210f, -0.19184193f, -0.15397602f, 0.09213670f, 0.03812945f, 
    0.04080908f, -0.01302741f, 0.02765585f, 0.05112564f, -0.06087213f, -0.11010661f, -0.07461510f, 0.04976101f, 
    -0.08059404f, 0.25422654f, 0.54481727f, 0.95950633f, 0.07560311f, -0.05261987f, 0.08366092f, 0.23886500f, 
    0.02006842f, 0.02106970f, 0.02380617f, 0.06520734f, -0.06133208f, -0.31073290f, 0.16227497f, 0.02741252f, 
    0.06270504f, -0.09119036f, 0.04891791f, -0.03618706f, 0.22400746f, 0.18329959f, 0.04708117f, 0.05297160f, 
    -0.10176214f, -0.12564403f, 0.04445064f, 0.14051038f, -0.11247520f, 0.01220501f, -0.07499499f, 0.05640614f, 
    0.18274213f, -0.02589228f, -0.08509457f, 0.03743588f, -0.15443556f, 0.09322233f, 0.14685577f, -0.09948296f, 
    0.03157483f, -0.00688957f, -0.06258132f, -0.06076432f, 0.08646353f, 0.25344190f, -0.09405579f, 0.06398919f, 
    -0.07955883f, 0.07610054f, -0.04325378f, 0.20286128f, 0.00974190f, -0.02315203f, 0.02073829f, 0.05134127f, 
    -0.22521389f, 0.03096182f, 0.02180086f, -0.22667961f, -0.06154361f, 0.03404285f, -0.04369053f, 0.09589906f, 
    -0.24176009f, -0.00267422f, 0.10458867f, 0.10172910f, -0.00750884f, -0.06075180f, -0.02786506f, -0.06971612f, 
    -0.42672610f, 0.07518402f, 0.20168889f, -0.58235556f, 0.03231232f, 0.06029514f, -0.07176573f, -0.18955985f, 
    0.05281115f, 0.02424252f, -0.11450172f, -0.07000534f, 0.04253701f, 0.01886801f, 0.07857471f, 0.01409514f, 
    -0.12410647f, 0.04478541f, 0.00219919f, -0.03426199f, 0.02041465f, 0.06525914f, -0.25075150f, 0.19176163f, 
    -0.17572404f, -0.23476219f, 0.29871684f, -0.21230297f, 0.05692913f, 0.03707561f, 0.01145150f, 0.06855407f, 
    0.05364152f, -0.19829625f, -0.13287289f, 0.17986917f, -0.40150577f, 0.04742929f, 0.12183693f, -0.44647366f, 
    -0.04457366f, -0.06966399f, -0.03256497f, -0.09697331f, 0.02429794f, 0.01621767f, -0.09371725f, 0.12020474f, 
    -0.63551283f, -0.54779989f, -0.65236992f, -0.22154951f, 0.00648040f, -0.12766430f, 0.17929555f, -0.43635684f, 
    0.01884020f, -0.04749018f, -0.05341962f, -0.02399648f, -0.18155032f, -0.12954010f, -0.34306076f, -0.19727136f, 
    -0.20804878f, 0.23853895f, 0.14605962f, 0.03522760f, 0.02334145f, 0.04065799f, 0.04336476f, -0.02211063f, 
    0.13314711f, -0.17162254f, 0.09734418f, -0.12299080f, -0.11314389f, 0.14029500f, 0.06667806f, -0.11888740f, 
    -0.02184701f, -0.11446469f, 0.23673142f, 0.07018124f, -0.08011858f, -0.09475823f, -0.18442011f, 0.02015805f, 
    -0.03904218f, 0.07730206f, -0.04850698f, 0.37217814f, -0.07675663f, -0.02321753f, 0.07666986f, -0.20801115f, 
    -0.40029523f, 0.00359141f, -0.05020854f, 0.03981518f, 0.21037234f, 0.00264389f, 0.10149533f, -0.18669058f, 
    0.02507829f, -0.04853030f, -0.03291310f, 0.06258500f, -0.37680006f, -0.04651828f, -0.05733320f, 0.36900061f, 
    0.10350198f, 0.11779056f, 0.04250379f, -0.07694174f, -0.03225677f, -0.04949427f, -0.10949025f, -0.12506951f, 
    0.38297728f, 0.18470141f, -0.16885737f, 0.19800039f, 0.28747314f, -0.20160574f, 0.28861618f, -0.00293438f, 
    -0.23860613f, 0.26239836f, -0.11709287f, 0.21262801f, -0.28870028f, -0.03747785f, -0.11179192f, 0.23164271f, 
    0.12573597f, -0.01047407f, 0.00709333f, 0.05103865f, -0.14683340f, 0.04265379f, -0.08874147f, -0.00610746f, 
    0.50682563f, 0.07462122f, 0.11811164f, -0.19242255f, -0.04325754f, 0.10921088f, -0.01224244f, 0.01175632f, 
    -0.02121612f, 0.14687437f, -0.09313951f, -0.11021781f, -0.02913587f, -0.22238895f, 0.20005386f, -0.26286995f, 
    -0.19639778f, -0.29559547f, -0.01459218f, -0.15024601f, -0.12464740f, 0.24251503f, -0.18293531f, -0.10368234f, 
    -0.05974251f, -0.17516382f, 0.09262211f, 0.20819822f, 0.07392579f, 0.05098902f, -0.08075203f, -0.03523216f, 
    0.02057356f, -0.00927687f, -0.08898398f, 0.01227323f, 0.34896040f, -0.14634247f, 0.11007187f, -0.28526315f, 
    -0.07618323f, 0.12952098f, -0.46138614f, -0.07611376f, -0.12880360f, -0.03338172f, 0.00931466f, -0.11377119f, 
    0.21024705f, -0.21042700f, -0.16763732f, 0.03404123f, 0.10395038f, -0.07111189f, 0.06761017f, -0.14468545f, 
    0.01401594f, 0.16080905f, 0.07585347f, 0.11020610f, -0.00921013f, -0.32732949f, 0.31068793f, 0.06472846f, 
    -0.14116533f, 0.11235480f, 0.08956398f, 0.06188263f, 0.14605732f, -0.05405077f, -0.12863038f, 0.11097128f, 
    -0.51393431f, 0.18684912f, -0.18115018f, 0.03780404f, 0.04936365f, -0.08184663f, -0.19558805f, -0.08920786f, 
    0.26734096f, 0.31443420f, 0.22086480f, 0.05905215f, -0.27190462f, -0.09371231f, -0.03007190f, 0.04806921f, 
    0.43510547f, 0.05318911f, -0.03147187f, 0.06475672f, -0.07524048f, 0.09269264f, -0.00828446f, -0.00145969f, 
    -0.43803489f, 0.09219196f, -0.10358989f, 0.39054477f, -0.18554953f, 0.07413831f, 0.03802552f, -0.07028146f, 
    0.05330598f, -0.04437592f, 0.00582873f, 0.22276489f, -0.36131430f, 0.04851841f, -0.35867208f, -0.57078606f, 
    -0.00322006f, 0.05911762f, -0.11671484f, -0.02560494f, 0.03132302f, 0.12138467f, -0.15099339f, -0.08615701f, 
    -0.33460742f, 0.04499222f, 0.52099055f, 0.23986390f, -0.11335552f, -0.19574732f, -0.20856526f, 0.02630004f, 
    -0.20221600f, 0.20660381f, 0.00190580f, 0.06984160f, 0.11952373f, -0.17929420f, -0.00898895f, 0.21072972f, 
    -0.00200996f, -0.00642975f, -0.01453125f, 0.01824951f, -0.02850248f, 0.11614376f, -0.20648251f, -0.06897952f, 
    -0.08575267f, 0.55569041f, -0.01826802f, 0.15835410f, 0.08664844f, -0.07990710f, 0.22008602f, -0.26283228f, 
    -0.06322907f, -0.19377275f, 0.26997340f, -0.08985123f, -0.02687509f, -0.10238277f, -0.11870092f, 0.25564176f, 
    -0.44029707f, 0.06570835f, -0.10948377f, -0.13277455f, -0.04421061f, 0.11401727f, -0.26080897f, -0.06810346f, 
    0.57085425f, -0.29774460f, -0.09567603f, 0.21886919f, 0.13041186f, -0.03990606f, 0.01843694f, -0.13032755f, 
    -0.00012731f, 0.02231943f, 0.07999018f, 0.31637716f, -0.05842845f, 0.55786598f, -0.25363180f, 0.03820278f, 
    0.06086611f, 0.14104481f, 0.11604839f, 0.00598281f, -0.27677643f, -0.07388252f, -0.14768188f, 0.04887136f, 
    -0.41070274f, 0.12493147f, -0.15296769f, 0.00562377f, -0.12659043f, -0.13952945f, -0.24659626f, -0.40427658f, 
    -0.03731403f, -0.04977289f, 0.02015911f, -0.03371710f, -0.53294003f, 0.30083415f, -0.20254111f, 0.22836852f, 
    -0.00662351f, -0.01499057f, 0.07003348f, -0.00361486f, 0.04236909f, 0.26638532f, -0.01479032f, -0.02961774f, 
    -0.46296790f, 0.96755046f, -0.12803060f, -0.38672721f, 0.24419671f, -0.12999281f, -0.12439886f, 0.06716189f, 
    -0.37378857f, -0.00943235f, 0.08995163f, 0.09812628f, -0.30667874f, 0.08355532f, -0.02134465f, -0.25923011f, 
    -0.14052053f, -0.21861610f, -0.09890708f, -0.02794927f, 0.19326563f, 0.07996597f, -0.16923653f, -0.16645084f, 
    0.05905926f, -0.36119777f, 0.37386480f, 0.35251695f, -0.28676689f, -0.18276054f, -0.11860735f, 0.06913931f, 
    -0.01037474f, -0.30706221f, 0.02808991f, -0.40459019f, 0.27424869f, 0.13430949f, 0.09896514f, -0.84288269f, 
    -0.41384298f, -0.23594122f, 0.03797779f, -0.10518347f, -0.00739117f, -0.26538488f, 0.00677317f, -0.03234599f, 
    -0.23168071f, -0.12316548f, -0.20565076f, 0.43119282f, 0.25144973f, 0.03180237f, 0.21495812f, -0.01206943f, 
    -0.07304312f, -0.08097535f, 0.21946026f, 0.01749426f, -0.18607855f, -0.76920611f, 0.58300507f, 0.14761887f, 
    0.01938554f, 0.11792853f, -0.16589120f, 0.05296880f, 0.05914100f, -0.15689006f, 0.11231659f, -0.06123673f, 
    0.18476023f, 0.09874357f, -0.06383077f, 0.04179101f, 0.26342231f, 0.04317142f, 0.20548758f, 0.21997626f, 
    -0.14629696f, -0.15611152f, -0.08528329f, -0.12921502f, -0.12624268f, 0.03417160f, -0.08073921f, -0.03590703f, 
    0.01725628f, 0.15007333f, -0.08586100f, -0.18044128f, 0.08162960f, -0.19663765f, -0.03915941f, 0.12324143f, 
    -0.25364971f, -0.01102832f, -0.21863441f, 0.09075519f, -0.17269151f, 0.08356082f, 0.07138846f, -0.10304436f, 
    -0.11620108f, -0.05232975f, -0.11356565f, 0.06649027f, 0.19819599f, -0.09595172f, 0.35413581f, 0.06878021f, 
    -0.19515252f, 0.03754206f, -0.01879620f, -0.04021993f, 0.01074828f, -0.12067832f, -0.01386842f, 0.08418075f, 
    -0.13772731f, 0.16910394f, 0.00586800f, 0.06047355f, -0.21978104f, -0.00125768f, -0.04484284f, -0.01404186f, 
    -0.02150592f, -0.21735458f, -0.23092450f, 0.10855181f, 0.06923237f, 0.03465273f, 0.09390078f, 0.02325937f, 
    -0.05335250f, -0.13411234f, -0.06198699f, -0.07395803f, -0.05490856f, 0.02931441f, 0.04083026f, 0.10265097f, 
    0.00736071f, 0.01101543f, 0.23907402f, 0.01550744f, -0.07293470f, -0.00805112f, -0.10789950f, 0.06587310f, 
    -0.20365191f, -0.23145416f, -0.39367017f, -0.47026622f, 0.15096623f, -0.05612079f, 0.13802665f, 0.07990132f, 
    -0.06027932f, 0.04422486f, 0.07209002f, -0.02117323f, -0.06924763f, 0.03234410f, 0.02266207f, 0.06439690f, 
    -0.01885709f, 0.06696334f, -0.16583592f, 0.09227216f, -0.01806930f, -0.12353218f, 0.05738351f, -0.17145541f, 
    0.08153512f, 0.09886809f, 0.15959917f, 0.34604505f, 0.07710935f, -0.35506150f, -0.32377720f, -0.22765154f, 
    -0.20523673f, -0.07907450f, 0.04002567f, 0.28640369f, -0.01645525f, 0.00040036f, -0.03722024f, -0.07590862f, 
    0.00039884f, 0.18448302f, -0.06854466f, 0.23025715f, -0.02744793f, -0.16373865f, -0.03227084f, -0.03094210f, 
    0.05058646f, -0.23821715f, 0.09411262f, 0.12198881f, -0.04907746f, -0.01417524f, 0.03298229f, -0.00225511f, 
    0.00788229f, -0.50979477f, 0.24785438f, -0.04181857f, -0.01121711f, -0.05730343f, -0.09740988f, -0.30782455f, 
    -0.14858840f, -0.18321520f, -0.00838957f, 0.07155052f, -0.15189424f, 0.01766987f, -0.14485875f, -0.05481220f, 
    0.05656731f, -0.01871430f, 0.02248335f, 0.13256595f, 0.26721150f, 0.34704089f, -0.04409548f, 0.34142396f, 
    0.12745132f, 0.09964775f, -0.07872212f, -0.15156582f, 0.16828357f, -0.13059498f, 0.00288893f, -0.03350601f, 
    0.26111332f, -0.13373064f, -0.27494466f, 0.05086051f, 0.14299834f, 0.00666553f, 0.06327545f, -0.07891123f, 
    -0.04378741f, -0.02084145f, 0.06850831f, 0.05733451f, 0.09391240f, 0.04236991f, -0.03382508f, 0.24047060f, 
    0.12828979f, 0.06995402f, 0.05701815f, 0.07367226f, 0.02642847f, -0.07489473f, -0.04783090f, -0.01830309f, 
    -0.02550730f, -0.00618492f, -0.04494108f, -0.10442728f, 0.23277219f, -0.15541320f, 0.00892655f, -0.12226240f, 
    0.07542596f, 0.01113958f, -0.05351290f, 0.03549892f, -0.12140469f, -0.17135698f, -0.05444740f, 0.06983595f, 
    0.00627673f, -0.00056250f, -0.14466682f, 0.06750281f, -0.06530177f, 0.09879470f, 0.03641038f, 0.06645573f, 
    -0.01421179f, 0.22764641f, -0.66366625f, -0.20008545f, 0.08274837f, 0.05351828f, 0.07052919f, 0.02583418f, 
    0.13744429f, -0.02486220f, 0.01039102f, -0.15164939f, 0.10463789f, 0.04556311f, 0.06671803f, 0.16694191f, 
    -0.03847588f, -0.09931658f, 0.11858071f, -0.13128856f, 0.05272558f, 0.04768404f, 0.06806483f, -0.10023645f, 
    -0.22666804f, -0.45006260f, 0.06638508f, -0.26868933f, -0.03103912f, -0.01162790f, -0.33643600f, 0.01311885f, 
    -0.11790013f, -0.17278574f, -0.25566381f, 0.13463679f, 0.11966775f, -0.00480965f, 0.05239734f, 0.04790566f, 
    0.23413195f, 0.11731591f, 0.11523127f, 0.05106788f, 0.10427654f, -0.04984163f, -0.04591177f, -0.03559153f, 
    -0.23555231f, -0.11514062f, 0.15602140f, 0.27501631f, -0.17728932f, -0.12318191f, -0.06057830f, -0.03037747f, 
    0.07619626f, 0.02095332f, 0.05798549f, 0.02157243f, -0.25855440f, -0.06424130f, -0.12299798f, -0.19030656f, 
    0.02255836f, 0.01324195f, -0.04674181f, 0.01614632f, 0.16052836f, 0.29305005f, 0.02945142f, 0.21955548f, 
    0.07097465f, -0.06925554f, -0.01158387f, -0.00018378f, -0.08795482f, 0.19688763f, 0.06900256f, 0.17370695f, 
    -0.10630574f, -0.04348860f, -0.10277339f, -0.15852639f, -0.00815195f, -0.01313371f, -0.04674136f, -0.20686641f, 
    0.01013907f, -0.00060081f, -0.04698443f, -0.07146033f, -0.11189894f, 0.15839794f, 0.20785885f, 0.33570254f, 
    0.44868660f, -0.70021743f, 0.03954558f, -0.02629250f, -0.03355434f, 0.00003010f, 0.01896143f, -0.06554512f, 
    0.02146580f, -0.09021589f, -0.24933504f, -0.23178792f, -0.05690750f, -0.27502322f, -0.15194157f, -0.05472010f, 
    -0.02612473f, 0.05068382f, -0.22208835f, -0.02153830f, -0.02113820f, 0.03306910f, -0.22922575f, -0.18640499f, 
    -0.10409489f, 0.44739893f, -0.46456927f, 0.23357089f, 0.21523334f, 0.05209328f, -0.11929840f, 0.07740428f, 
    0.13596299f, -0.00036403f, -0.02229977f, -0.05935822f, -0.37728870f, -0.25609779f, -0.26326996f, 0.12798534f, 
    -0.10544873f, 0.07405718f, -0.08218113f, -0.06394585f, -0.00084953f, 0.01536239f, -0.06456681f, -0.14002603f, 
    0.32908869f, 0.18729621f, -0.08016568f, 0.30622554f, -0.04413255f, 0.01245459f, -0.00984442f, -0.00413542f, 
    -0.01735192f, 0.12094077f, -0.10377550f, -0.17785107f, 0.00640472f, 0.41247863f, -0.19932789f, 0.17134093f, 
    -0.05205382f, 0.08070488f, -0.17845717f, 0.06139623f, 0.07062978f, -0.02240330f, -0.01837338f, -0.01761068f, 
    0.15125209f, 0.28560135f, 0.48916498f, 0.35239461f, -0.04930471f, 0.00068442f, -0.06686860f, 0.05727702f, 
    0.03168793f, -0.07827195f, 0.10940743f, -0.02323137f, 0.04781334f, -0.03135943f, 0.29085851f, 0.25821164f, 
    -0.25105396f, -0.12259249f, -0.15243270f, 0.01975152f, 0.01961552f, 0.01935932f, -0.02233923f, -0.10378384f, 
    0.20174350f, 0.02332239f, 0.45146742f, 0.21338317f, 0.12429521f, -0.17051759f, 0.06436940f, 0.05263412f, 
    -0.01312964f, 0.23286444f, -0.05647221f, -0.07378680f, 0.34118444f, -0.07575154f, 0.09198028f, 0.22094487f, 
    0.23663327f, 0.19829455f, -0.09389172f, 0.09819181f, 0.18804798f, -0.01800230f, -0.00743736f, 0.10514399f, 
    -0.01026933f, -0.24629647f, 0.14677098f, -0.25860599f, 0.06785784f, 0.01064903f, -0.07200278f, 0.10578363f, 
    -0.02379707f, 0.14109157f, 0.16281180f, -0.07314709f, 0.02720256f, -0.17732571f, -0.35688934f, -0.28028134f, 
    0.02602078f, 0.06275579f, -0.12759192f, 0.13393019f, -0.05809636f, -0.06067353f, -0.16137914f, -0.05591464f, 
    -0.08668890f, -0.44718775f, -0.17479286f, -0.08410968f, -0.25958019f, 0.02568810f, -0.02346872f, -0.11119132f, 
    0.10876514f, -0.25487331f, 0.37423658f, 0.34468010f, -0.11523458f, 0.23080179f, 0.29586044f, -0.27337694f, 
    0.10943733f, -0.03577241f, -0.18838273f, 0.11538032f, 0.08197919f, -0.01178751f, 0.03340205f, 0.05823043f, 
    -0.19750738f, -0.06280884f, 0.02806891f, 0.11576024f, -0.03998097f, -0.01888372f, 0.01356021f, 0.13550071f, 
    -0.17899917f, -0.21210077f, -0.38556865f, -0.41519055f, 0.47936019f, -0.22966459f, 0.12508167f, 0.32240620f, 
    0.00915695f, -0.06917745f, -0.03644720f, -0.07215241f, 0.13886721f, 0.00602418f, 0.09826200f, -0.00338991f, 
    -0.18492502f, -0.05125037f, -0.05968980f, -0.25041008f, -0.00897515f, -0.00078577f, 0.01319975f, 0.04757394f, 
    0.17871866f, 0.02629350f, -0.05718619f, -0.09337703f, -0.16671124f, -0.05691737f, -0.06152643f, 0.24838397f, 
    0.09412764f, 0.12870516f, 0.13138603f, 0.27930468f, 0.01222020f, -0.03682366f, 0.19598594f, 0.29958412f, 
    -0.17246385f, 0.16212478f, 0.16018566f, 0.11503064f, -0.24359918f, -0.03219745f, 0.07674637f, 0.12929232f, 
    0.08355398f, -0.13698941f, 0.06701698f, -0.10405490f, -0.08904959f, 0.06614845f, -0.02375593f, 0.13148090f, 
    -0.03793669f, 0.04348002f, 0.01504717f, 0.27332059f, -0.13258421f, 0.00525341f, 0.08379058f, -0.18133992f, 
    -0.07819922f, -0.03757749f, -0.07844633f, -0.18308388f, 0.06925172f, -0.01799945f, 0.10344982f, 0.03471671f, 
    0.04584939f, -0.10736187f, -0.21054052f, -0.05128412f, -0.11330052f, -0.36884606f, 0.08041339f, 0.18197845f, 
    -0.01673638f, -0.04621178f, -0.06041133f, -0.05217911f, 0.03414424f, -0.02451258f, -0.08484514f, 0.09372761f, 
    0.12257648f, -0.16011353f, -0.23113234f, -0.00721621f, -0.10790987f, -0.03940063f, 0.01078952f, -0.04205407f, 
    -0.14893290f, -0.25835454f, 0.20860492f, -0.33611128f, -0.15613702f, 0.06770894f, -0.13812199f, 0.07036182f, 
    -0.03190191f, 0.05501415f, 0.16651271f, 0.00500962f, -0.06851713f, -0.00943383f, 0.05075779f, -0.06397989f, 
    0.30397496f, 0.02804955f, -0.81583416f, -0.01383234f, 0.09246515f, 0.27420524f, -0.11358024f, 0.02631778f, 
    0.05611756f, -0.09682273f, 0.02966285f, -0.08807894f, 0.00813315f, 0.24683706f, 0.01549831f, -0.05996769f, 
    0.21339968f, 0.14344600f, 0.12028150f, -0.00924178f, 0.07133836f, 0.06510274f, 0.11626916f, 0.09999435f, 
    -0.18860382f, -0.25262344f, 0.31302395f, -0.30360883f, 0.12895943f, -0.02064105f, 0.08851646f, 0.03745619f, 
    0.24739255f, 0.23788820f, -0.14776412f, -0.05748333f, -0.11586894f, -0.16959342f, -0.07451920f, 0.04548718f, 
    0.10153724f, -0.08774008f, -0.09656314f, 0.01584200f, 0.05589451f, 0.15807796f, 0.22084604f, -0.00417458f, 
    -0.69675332f, -0.12842925f, -0.10783779f, -0.47905788f, 0.19047901f, -0.13292749f, 0.15846445f, 0.03471402f, 
    -0.04719849f, -0.03962032f, -0.02183854f, 0.02965674f, -0.05977172f, 0.16852573f, 0.11324004f, -0.33218515f, 
    -0.01532815f, -0.07428763f, 0.02575846f, 0.02765781f, -0.16742958f, -0.35720879f, -0.34605965f, -0.43336686f, 
    -0.10971206f, 0.01656880f, 0.10151388f, -0.13181983f, 0.07175935f, -0.20210421f, 0.06615607f, -0.10396680f, 
    0.16801108f, -0.09320287f, 0.04926568f, 0.03798700f, -0.12752898f, -0.15709567f, -0.30050468f, 0.00738903f, 
    0.05151038f, 0.06561276f, 0.12257440f, 0.03188607f, 0.14582872f, -0.29251763f, -0.22130415f, -0.40843895f, 
    -0.15105407f, 0.18117662f, 0.14224754f, 0.20197237f, -0.02384419f, -0.08050358f, -0.08140443f, -0.03706057f, 
    0.12532969f, 0.03827571f, -0.18378651f, 0.05329266f, 0.01505098f, -0.13188663f, -0.25042138f, 0.19725874f, 
    0.04296524f, -0.01617606f, -0.10453915f, 0.08416713f, -0.16785958f, 0.06219831f, -0.08593644f, -0.04991327f, 
    -0.00719987f, 0.09092841f, -0.66718286f, 0.09241979f, 0.18189263f, -0.04528828f, 0.04762805f, 0.03692277f, 
    -0.04921157f, 0.00108366f, 0.04107154f, 0.19065751f, -0.22029097f, -0.19920215f, 0.02182367f, 0.41283512f, 
    0.03334280f, -0.08103036f, -0.04832482f, 0.00132183f, 0.02166388f, -0.02053665f, 0.06919125f, 0.06248038f, 
    -0.42349964f, 0.30006671f, -0.07548363f, -0.54031700f, 0.01519692f, -0.04873988f, -0.07608048f, 0.05066620f, 
    0.18156895f, 0.09244614f, -0.20036218f, -0.01406858f, -0.10855053f, -0.20298232f, -0.40258884f, 0.20172074f, 
    0.05710293f, 0.27118510f, 0.29771507f, -0.27995032f, 0.06555708f, -0.00427461f, 0.03236656f, -0.00633548f, 
    -0.04277893f, 0.11695825f, 0.00195432f, -0.01680881f, 0.14791514f, -0.12903526f, 0.04586887f, -0.50119698f, 
    0.09217636f, -0.07003266f, -0.01266076f, -0.14647430f, 0.14564899f, 0.18329380f, -0.06681371f, 0.05853405f, 
    0.43115979f, 0.09890053f, 0.11547467f, 0.13977551f, 0.01555317f, 0.13730194f, 0.07021897f, 0.13999000f, 
    0.09411769f, -0.09709780f, -0.72583354f, -0.28831333f, 0.11280496f, 0.09746217f, -0.00184687f, -0.10755707f, 
    -0.07540765f, 0.04211854f, 0.03998310f, 0.04616797f, -0.70736355f, -0.30006155f, -0.88044727f, -0.48069575f, 
    -0.18843177f, -0.14886969f, -0.00927449f, -0.08780979f, 0.06162437f, -0.12371051f, 0.04826447f, 0.05318626f, 
    -0.35470593f, 0.29168117f, 0.30427387f, 0.27539739f, -0.04297520f, 0.16303794f, 0.07698566f, 0.04247454f, 
    -0.01158412f, 0.05118907f, 0.17268904f, 0.11394392f, 0.06948989f, 0.68280554f, 0.16593210f, 0.11339194f, 
    -0.06038195f, -0.07634105f, -0.04520674f, 0.11320893f, 0.18341117f, -0.06705159f, 0.15996590f, -0.03959147f, 
    -0.18424599f, 0.05771299f, -0.03203749f, 0.21843429f, 0.07973136f, -0.15107670f, 0.03508405f, 0.00246991f, 
    -0.04844366f, 0.05073484f, 0.01888446f, 0.09744945f, -0.67705649f, -0.73857760f, -0.67365593f, 0.16048409f, 
    -0.19171740f, -0.37839448f, 0.08496551f, -0.50673735f, -0.08648141f, 0.05641990f, 0.03243998f, -0.01261355f, 
    -0.03384261f, -0.02783139f, -0.02460462f, 0.13683628f, 0.05243715f, 0.09712925f, 0.03368630f, 0.04208899f, 
    0.12086205f, 0.14425465f, 0.32536128f, 0.07030414f, 0.10789455f, -0.13526425f, -0.33646595f, 0.03783995f, 
    -0.04217260f, 0.00810221f, 0.00285685f, 0.19237429f, -0.04234227f, 0.19582626f, -0.14917864f, -0.12553272f, 
    0.08569007f, 0.18159156f, 0.24413125f, -0.19908528f, -0.04292785f, -0.01448516f, 0.06107593f, 0.08173268f, 
    0.02846214f, 0.11333545f, 0.11768229f, 0.19151267f, -0.11385407f, -0.10491139f, -0.01121476f, 0.08377950f, 
    -0.03960508f, -0.00777881f, 0.15738389f, -0.02283907f, 0.03458050f, -0.12425540f, -0.06274888f, -0.00166695f, 
    -0.74412888f, -0.89488608f, -0.14302291f, 0.26622045f, -0.32345274f, 0.05688937f, 0.01550138f, -0.00701589f, 
    -0.01375468f, 0.02586420f, 0.10888602f, -0.14575617f, -0.08785912f, -0.61799204f, -0.37432614f, -0.09568115f, 
    -0.21001528f, 0.37106088f, 0.30671337f, -0.11214341f, 0.08855555f, -0.03282984f, 0.07442957f, 0.09173349f, 
    -0.02775466f, -0.15444058f, -0.13384417f, 0.18790086f, 0.04095517f, 0.04045997f, 0.01568303f, 0.04367971f, 
    0.00927423f, -0.10313204f, 0.01410918f, 0.05606670f, -0.20404451f, -0.05788665f, -0.36904597f, -0.31922892f, 
    0.07290454f, 0.01338832f, -0.02028306f, 0.04933111f, -0.07223815f, -0.04536819f, -0.11293203f, 0.07066537f, 
    0.39660543f, 0.24876812f, -0.28744236f, -0.02950143f, -0.01080754f, 0.02492964f, 0.10595423f, 0.00262161f, 
    -0.00472276f, 0.03947096f, 0.04627086f, 0.06700632f, 0.23227268f, -0.15528806f, -0.18604128f, -0.02097623f, 
    -0.01637456f, -0.02364580f, 0.12702216f, 0.12858340f, 0.05513893f, 0.02455419f, -0.17252636f, -0.18058553f, 
    0.43120655f, -0.06904639f, -0.01353231f, -0.83863074f, 0.01348633f, -0.01994726f, 0.17486954f, -0.12382673f, 
    0.07447309f, 0.13208786f, 0.02476880f, -0.05267501f, -0.59851462f, -0.75408447f, -0.66139787f, -0.15948221f, 
    -0.06402699f, -0.46470442f, -0.21634305f, -0.52976769f, 0.02944242f, -0.05286103f, -0.00616134f, -0.10002813f, 
    0.10244766f, 0.32253319f, -0.30821988f, -0.01448563f, 0.08995508f, 0.06852151f, 0.21607605f, 0.18111911f, 
    0.16662146f, 0.16866040f, 0.17613336f, 0.08058851f, 0.28051949f, -0.16496238f, -0.19586864f, -0.03209745f, 
    -0.11958452f, -0.09000675f, 0.05118886f, -0.04474228f, -0.26151350f, -0.17391624f, -0.12992404f, -0.21469647f, 
    -0.67270148f, -0.42227837f, 0.10919233f, 0.18482217f, 0.10919178f, -0.04271189f, -0.02271197f, -0.00958230f, 
    -0.06243378f, 0.02871996f, -0.00446475f, -0.03960006f, 0.06499115f, -0.02030611f, -0.12847213f, -0.15744135f, 
    -0.03159605f, 0.06048349f, 0.03252467f, 0.11733468f, 0.12737674f, 0.11472508f, 0.25870147f, 0.07272103f, 
    0.10096269f, -0.09053579f, -0.03560077f, 0.11024193f, -0.04195218f, 0.14064902f, 0.15878777f, 0.17993507f, 
    0.06786771f, -0.10591754f, -0.02656787f, -0.20066008f, 0.21348102f, 0.14500256f, 0.02615312f, -0.03563831f, 
    -0.04207892f, -0.04185468f, 0.06809551f, 0.09248462f, 0.07665206f, -0.01106470f, 0.35072884f, 0.28736433f, 
    -0.45447740f, 0.06063187f, 0.22038716f, -0.27127549f, 0.01624087f, -0.14202042f, -0.04713967f, 0.01837476f, 
    0.01067911f, 0.09955160f, 0.19948965f, 0.07341947f, 0.21796989f, -0.07359291f, -0.24120969f, -0.24094495f, 
    0.05584125f, 0.04408198f, 0.12398603f, 0.15440436f, -0.10888996f, -0.00504325f, 0.04620791f, -0.05888211f, 
    0.14257371f, -0.54113632f, 0.23516189f, -0.21053393f, -0.02801645f, -0.05576224f, 0.34577242f, -0.17162639f, 
    -0.04450355f, -0.05733863f, 0.01101968f, 0.14787664f, 0.32260162f, 0.10068434f, -0.32481730f, -0.07532740f, 
    -0.15296923f, 0.04058599f, 0.14125142f, 0.22253469f, -0.10322194f, -0.05512344f, 0.03262259f, -0.16118698f, 
    0.32083240f, 0.24354982f, 0.38799053f, 0.22846007f, 0.04779942f, -0.14647317f, 0.07847551f, -0.13684238f, 
    -0.22666715f, 0.20928985f, 0.10415978f, -0.01760240f, 0.20576724f, -0.21333838f, 0.25678295f, -0.16244446f, 
    0.13002437f, 0.18987980f, 0.13803746f, -0.04113139f, -0.05250698f, -0.10532774f, 0.02226162f, 0.05524306f, 
    -0.71543479f, -0.69482499f, -0.51562011f, -0.35023490f, -0.28099251f, 0.03807252f, -0.19503559f, -0.40519407f, 
    0.06280003f, -0.05618214f, -0.04958160f, 0.00389819f, -0.78216475f, -0.51536918f, -0.05443981f, 0.05806147f, 
    -0.11928367f, -0.25074166f, -0.10143115f, -0.54787725f, -0.09398013f, 0.04739903f, -0.11602215f, -0.07128223f, 
    -0.15596065f, -0.21082300f, 0.02775668f, 0.48680338f, -0.33572859f, 0.32898405f, -0.01750277f, -0.13920161f, 
    0.03048052f, 0.07009166f, -0.01036824f, -0.07228345f, -0.59368777f, -0.72206235f, -0.10666192f, 0.54782277f, 
    0.06224543f, -0.04079247f, 0.27564576f, 0.01386927f, -0.07752585f, 0.07295625f, -0.03062798f, -0.07451767f, 
    0.35136887f, -1.03254879f, -0.28012580f, -0.47429985f, -0.12815905f, -0.19898610f, -0.09382269f, 0.07091348f, 
    0.00291501f, -0.02425978f, 0.02342516f, -0.07410233f, -0.15075926f, -0.58500260f, -0.41776022f, -0.24686666f, 
    -0.08966296f, -0.04891020f, 0.04450851f, 0.05577206f, -0.00119028f, 0.10415855f, -0.01108305f, 0.04813273f, 
    0.18443990f, -0.06366856f, -0.12086940f, -0.27468395f, 0.02365838f, 0.07380594f, 0.14391688f, -0.07343416f, 
    -0.10279910f, -0.10153167f, -0.15929332f, -0.01121285f, -0.07084385f, -0.67001891f, 0.72816694f, -0.07959920f, 
    0.01577891f, 0.01132062f, 0.04282035f, 0.25150481f, -0.02576163f, -0.02818743f, -0.12457986f, -0.04884285f, 
    0.23783620f, -0.03822641f, 0.05835231f, -0.02932931f, -0.04380432f, -0.08628026f, -0.03449905f, -0.17034604f, 
    0.09651578f, -0.10041122f, -0.20793943f, 0.15187675f, 0.23034763f, -0.32803026f, 0.17440246f, -0.13808683f, 
    0.02666250f, 0.06269624f, -0.07309241f, -0.13487391f, 0.03543598f, -0.15070459f, -0.08643743f, 0.00710695f, 
    0.50257248f, -0.79086190f, -0.18109575f, -0.25876543f, -0.09181692f, 0.07115747f, -0.09274811f, 0.03021074f, 
    0.21604259f, 0.09085903f, -0.08623164f, 0.02529616f, 0.17968915f, 0.06289821f, -0.03592660f, -0.03397992f, 
    -0.11719735f, -0.11310904f, 0.09380484f, -0.30418772f, -0.01012347f, -0.00308852f, 0.07966603f, -0.02902335f, 
    0.70533353f, -0.49346673f, -0.74948764f, -0.01024963f, 0.02230649f, -0.12363224f, -0.04583242f, 0.19414209f, 
    -0.00222884f, 0.05331914f, -0.14650016f, -0.00450489f, -0.33759281f, 0.21397737f, -0.51651579f, 0.15685238f, 
    0.08871739f, 0.07231006f, 0.14192109f, -0.00982768f, 0.00330372f, -0.09193894f, 0.04867945f, 0.08732474f, 
    0.11515462f, -0.01268505f, 0.24528874f, -0.07063042f, -0.02276455f, -0.01550586f, -0.08046605f, 0.03305987f, 
    0.10558537f, -0.04255624f, 0.06914343f, 0.00897711f, 0.08141384f, -0.00502217f, -0.01796145f, -0.12760949f, 
    0.07310624f, -0.00052531f, 0.06627078f, -0.02110614f, 0.09846364f, -0.02596463f, 0.07183973f, -0.02755139f, 
    -0.23823600f, 0.10141072f, -0.04753543f, 0.18759388f, -0.13896534f, -0.03747202f, 0.10396264f, 0.10803748f, 
    -0.00504111f, -0.04315535f, -0.11402653f, 0.01774348f, 0.10933965f, -0.08446351f, 0.05060764f, -0.11330917f, 
    -0.04577434f, 0.04542785f, -0.07727664f, -0.04954199f, 0.08520418f, 0.00983443f, -0.01949305f, -0.09596907f, 
    -0.35294288f, 0.23412324f, -0.00363803f, 0.11740655f, -0.07849201f, 0.05074931f, 0.03502682f, -0.11048979f, 
    0.03406004f, -0.02531796f, 0.01539803f, -0.05741152f, -0.69730449f, -0.71736169f, -0.14735250f, 0.26861233f, 
    0.07753576f, -0.02632775f, -0.02000938f, -0.01503630f, 0.09429520f, -0.03096114f, 0.04721545f, -0.03345540f, 
    -0.74067593f, -0.41592452f, 0.19479406f, 0.18364848f, -0.03079434f, -0.07380870f, 0.21759170f, -0.09709840f, 
    -0.11870566f, 0.18285803f, -0.03989070f, -0.07857090f, 0.04601567f, -0.05632706f, 0.03005445f, -0.08976814f, 
    0.05010679f, 0.02311864f, -0.02639908f, 0.02840414f, -0.08349001f, -0.01842090f, 0.02425956f, 0.00453189f, 
    0.38855457f, -0.46836555f, -0.45635179f, -0.33472589f, -0.01925559f, 0.14911206f, -0.16714488f, 0.18686546f, 
    0.13922918f, 0.00578085f, -0.00471907f, 0.03525744f, 0.38374645f, -0.23095195f, -0.29283389f, 0.17333826f, 
    0.05149654f, -0.19197674f, -0.03521347f, -0.12856945f, 0.08607817f, 0.16033734f, 0.13643996f, 0.12127007f, 
    -0.06083005f, -0.07696705f, 0.15380085f, -0.13762495f, -0.19799037f, -0.24404487f, 0.06438869f, -0.07203656f, 
    0.04395572f, 0.02983267f, 0.01893475f, 0.04767774f, 0.00171845f, 0.07102489f, 0.09079594f, 0.21377365f, 
    -0.01678226f, -0.00908601f, 0.02890524f, 0.00897060f, -0.03728682f, -0.10385847f, 0.02412472f, -0.21873772f, 
    0.29907697f, 0.16197267f, -0.18122701f, -0.32043570f, 0.05789097f, 0.10386449f, 0.06919473f, 0.00569388f, 
    0.00468878f, 0.06127309f, -0.18049017f, 0.00457575f, -0.04614127f, 0.17546180f, -0.34400418f, -0.03835544f, 
    0.02706135f, -0.14760397f, 0.06667508f, -0.09044430f, -0.05896139f, 0.13790116f, -0.06282660f, 0.02095865f, 
    -0.24074979f, 0.78944564f, -0.26715603f, 0.13265912f, 0.05507435f, -0.01210456f, -0.02770174f, 0.04925186f, 
    -0.15448762f, 0.09275006f, 0.06319144f, -0.01898571f, 0.01248813f, -0.04347878f, -0.13447309f, -0.14138953f, 
    -0.05797024f, 0.03375316f, -0.09263749f, -0.05811592f, -0.02041333f, 0.09454961f, -0.13166736f, -0.07659728f, 
    -0.09301268f, 0.01512118f, 0.18278815f, 0.09753112f, 0.03846346f, 0.04318191f, -0.02425935f, -0.02069978f, 
    -0.08594329f, 0.16670935f, -0.14998530f, 0.00217271f, -0.06132033f, 0.21897358f, 0.03958389f, -0.08115223f, 
    -0.08504601f, -0.06633864f, 0.16046563f, 0.06978947f, 0.09407727f, 0.06979614f, 0.07145277f, -0.03178358f, 
    -0.58161336f, -0.56885332f, 0.17775679f, 0.76921600f, 0.20081665f, 0.02566039f, 0.05173317f, 0.06556782f, 
    0.08997269f, -0.14127146f, 0.15608352f, 0.01747230f, -0.13092278f, -0.19357631f, -0.52789450f, -0.06771988f, 
    0.03389041f, -0.14758943f, -0.13869229f, 0.22468151f, 0.02665732f, 0.01222858f, -0.04571369f, 0.02091134f, 
    0.49151069f, 0.23216678f, 0.00420464f, -0.02466697f, 0.32908112f, -0.02338041f, 0.01521752f, 0.21927702f, 
    -0.01069868f, 0.07250367f, 0.20962919f, 0.14932032f, 0.58429873f, -0.73415780f, -0.31512254f, -0.25589940f, 
    0.06147436f, 0.17654115f, 0.00251923f, 0.19259247f, 0.02206777f, 0.05862943f, 0.06428684f, 0.10030112f, 
    -0.08656443f, -0.33282423f, -0.15335226f, 0.17110990f, 0.06788600f, 0.07072313f, 0.18286717f, 0.14644305f, 
    0.04641210f, -0.14755891f, 0.06664231f, -0.13409041f, -0.33042702f, -0.50434965f, -0.04159391f, -0.07895345f, 
    0.07986514f, 0.08924732f, 0.07513565f, 0.22463627f, 0.07238612f, 0.04294776f, -0.09754208f, 0.04765370f, 
    -0.23559844f, -0.05304338f, 0.00916106f, -0.00117558f, 0.03063507f, 0.01975762f, 0.11357356f, 0.01404836f, 
    0.13867964f, 0.02249076f, 0.13246536f, 0.15666224f, -0.03937161f, -0.07752720f, -0.51293153f, -0.67005926f, 
    -0.21772972f, -0.22849177f, 0.07182737f, -0.34894729f, 0.03468093f, -0.00661701f, -0.05107241f, -0.03831655f, 
    0.02139601f, -0.04657383f, 0.00718190f, -0.12010458f, 0.11530188f, -0.01735482f, -0.00344389f, 0.09144797f, 
    -0.24103029f, -0.05785048f, -0.18252975f, -0.45234182f, 0.41159409f, 0.23689084f, -0.13161796f, -0.17635760f, 
    0.11442611f, -0.17638020f, 0.02269088f, 0.02122237f, 0.07329072f, 0.12558426f, 0.11766414f, 0.05823701f, 
    -0.33670557f, -0.36282054f, 0.01362737f, 0.06747887f, 0.00776319f, 0.21061392f, 0.12281431f, 0.04704298f, 
    -0.00126720f, 0.04345517f, -0.02136887f, -0.47959644f, 0.27543375f, 0.10877441f, -0.09557710f, 0.02709591f, 
    0.11657623f, -0.38159722f, -0.05195708f, 0.13228911f, 0.18663748f, 0.09721337f, 0.10211506f, 0.11607862f, 
    0.05986456f, -0.29010835f, -0.77831966f, -0.44202292f, 0.05852904f, -0.01096477f, 0.11444768f, 0.04534417f, 
    -0.02624459f, 0.03897164f, -0.14407489f, 0.05868306f, -0.20614563f, -0.18627954f, 0.15629615f, 0.28310251f, 
    0.11937007f, 0.15761140f, -0.05599341f, -0.12438326f, -0.15401544f, -0.07257792f, -0.02906810f, -0.04817932f, 
    -0.24732170f, 0.09500853f, 0.18095456f, -0.05940729f, -0.07405938f, -0.11452286f, 0.01633714f, -0.13178575f, 
    -0.24307248f, -0.22205377f, -0.38115111f, -0.08064632f, -0.14105138f, 0.28065896f, 0.07756269f, -0.09256383f, 
    -0.11408509f, -0.16038267f, -0.03207203f, -0.07963493f, 0.04967765f, 0.10839096f, 0.04779003f, 0.20159727f, 
    -0.45933223f, -0.13116477f, 0.17389499f, 0.12699087f, -0.01747811f, 0.09043547f, -0.07236015f, 0.17575908f, 
    -0.12362678f, -0.07871351f, -0.25442076f, -0.19030157f, 0.26007852f, -0.04473930f, 0.00550180f, -0.15225723f, 
    0.08024081f, -0.09458783f, 0.03184427f, -0.06110856f, -0.06783661f, -0.05316109f, 0.04827056f, 0.03743178f, 
    -0.87216091f, 0.16713114f, 0.17577066f, 0.31316882f, -0.03796879f, -0.02856931f, -0.15242068f, 0.08581247f, 
    -0.05911358f, -0.23122980f, -0.06595701f, -0.03160645f, -0.53854686f, -0.57240295f, -0.26030827f, 0.21752462f, 
    0.26496139f, 0.08389635f, -0.22877306f, -0.17607626f, -0.01502387f, 0.01686531f, 0.09678438f, 0.12736039f, 
    0.21324110f, -0.38365358f, 0.18666168f, -0.13144296f, 0.00407057f, -0.10653071f, 0.04239747f, -0.20518871f, 
    0.07864100f, 0.14990978f, 0.24284440f, 0.27642375f, -0.24033415f, -0.00017431f, 0.12370899f, 0.01830016f, 
    -0.11874291f, -0.03902530f, -0.12005948f, 0.04895379f, 0.05649066f, 0.06529459f, 0.07548962f, 0.07987190f, 
    -0.24150200f, -0.66169429f, -0.67644793f, 0.17938071f, 0.01955967f, 0.13038802f, 0.19134092f, 0.10789201f, 
    -0.07645087f, -0.07335479f, -0.05893389f, -0.11023379f, 0.17522079f, -0.07982988f, -0.08231872f, -0.04049940f, 
    0.04452127f, 0.00711011f, 0.06448552f, 0.08645066f, -0.09753825f, -0.32604635f, 0.01578262f, -0.52549738f, 
    -0.00926393f, -0.13836487f, 0.12986995f, 0.02705661f, 0.05899866f, 0.12565708f, -0.08573239f, -0.10773094f, 
    0.02596995f, 0.19488591f, 0.11959287f, 0.19056015f, -0.42273471f, -0.21220759f, 0.06586871f, 0.07612485f, 
    -0.07734069f, 0.03448968f, -0.10833959f, -0.00640743f, -0.08410238f, -0.18360777f, 0.04262022f, -0.21237104f, 
    -0.01900547f, -0.13877606f, -0.24399704f, -0.37995559f, -0.15411875f, 0.11334270f, 0.03651839f, -0.03902788f, 
    0.23791778f, 0.06936389f, 0.16040966f, 0.09157251f, 0.05358135f, -0.01126647f, 0.14380650f, 0.15676059f, 
    0.04407144f, -0.10104668f, -0.01269647f, 0.07203276f, 0.05032782f, -0.10439124f, 0.14306585f, 0.09859999f, 
    -0.66283637f, -0.16094302f, 0.40040687f, 0.24519005f, 0.03560018f, 0.04104744f, -0.17307349f, 0.06344116f, 
    -0.01993040f, -0.07323522f, 0.03433726f, -0.05631446f, 0.29117876f, 0.21485503f, 0.12495010f, -0.11409687f, 
    0.14115395f, -0.11656759f, -0.04810144f, 0.00163707f, 0.01623813f, -0.11251562f, 0.11274289f, 0.00115411f, 
    -0.65633708f, -0.55730474f, -0.07216007f, -0.18703674f, -0.00103545f, 0.09305929f, 0.17518409f, 0.05753966f, 
    0.00198016f, -0.00964290f, -0.00722353f, 0.00026063f, -0.56472909f, 0.10217712f, 0.20449610f, -0.07748200f, 
    0.06274597f, -0.14080390f, -0.07415948f, 0.12117502f, -0.03529532f, -0.08774870f, 0.01598253f, -0.08587635f, 
    0.30347127f, -0.19708937f, -0.27547896f, -0.19788875f, 0.00961447f, 0.09126775f, -0.09268507f, 0.25072199f, 
    0.12896843f, 0.18320288f, 0.04336600f, 0.01146342f, 0.27995399f, 0.16488001f, -0.33371094f, -0.07252443f, 
    0.04745125f, 0.04830352f, 0.08307646f, 0.12476874f, 0.17984316f, -0.09192535f, -0.04326535f, -0.02961211f, 
    0.10391452f, 0.08422503f, -1.05875993f, 0.22838053f, -0.06170359f, -0.12805723f, 0.03015025f, -0.07141496f, 
    0.07570793f, -0.05562732f, 0.02065939f, 0.13888648f, -0.20864260f, 0.07928863f, 0.20981598f, 0.02550240f, 
    0.05576789f, -0.66970652f, 0.00412022f, -0.01007961f, 0.00687358f, 0.02517219f, 0.05397552f, -0.02542055f, 
    0.24275172f, -0.07264635f, 0.47304952f, -0.08929353f, -0.07607761f, -0.06239079f, -0.15097240f, -0.01403063f, 
    -0.02066093f, -0.12664905f, -0.02174947f, 0.20262896f, 0.27836844f, 0.14348213f, 0.46168774f, -0.18120225f, 
    -0.02453908f, -0.26869965f, -0.26230556f, -0.07199058f, -0.04872695f, 0.11493940f, 0.12783128f, 0.11909299f, 
    0.34369946f, 0.09658779f, 0.34501100f, -0.09296263f, 0.10786575f, -0.38735774f, 0.04609304f, -0.08668106f, 
    0.03070875f, 0.00732649f, -0.08816219f, -0.24362838f, -0.33751470f, -0.15372099f, 0.04917120f, -0.30063394f, 
    -0.17432995f, 0.10691258f, 0.07418904f, 0.22700180f, 0.12926790f, 0.16275862f, 0.02469403f, -0.18644702f, 
    -0.08891258f, -0.16411974f, 0.04332862f, 0.10746673f, -0.08535544f, 0.11255717f, 0.03824678f, -0.01498541f, 
    0.12929170f, -0.02374697f, 0.28074539f, 0.16447979f, -0.07349934f, -0.27811334f, -0.11684764f, 0.11181822f, 
    -0.08534412f, 0.12543197f, 0.10796163f, -0.05822390f, -0.00699664f, 0.00277918f, 0.07143608f, -0.12646197f, 
    0.03412574f, 0.13425586f, -0.18523987f, -0.16438553f, -0.06782469f, -0.02288866f, -0.06832331f, -0.09618419f, 
    -0.03476205f, 0.12469760f, -0.11640580f, 0.20426367f, -0.14765564f, -0.13428603f, -0.43422279f, -0.10994227f, 
    -0.06630228f, -0.23502317f, 0.09340616f, -0.02736399f, -0.03977305f, -0.22303875f, -0.18444245f, -0.00016064f, 
    -0.15738621f, -0.07879734f, 0.61412692f, 0.22993600f, 0.20408812f, -0.17723645f, -0.12487176f, -0.04813200f, 
    0.07890293f, 0.08873244f, 0.02735115f, 0.06882185f, 0.10327779f, 0.37442100f, -0.59890383f, -0.22621854f, 
    -0.02932247f, -0.08011100f, 0.08245750f, -0.02298893f, -0.13367257f, 0.08435614f, -0.09231092f, 0.06696394f, 
    0.15413532f, -0.61113405f, 0.12776689f, -0.12002006f, -0.07350671f, 0.07582182f, -0.04384437f, -0.00402526f, 
    -0.05366794f, 0.13938443f, 0.12303739f, -0.00755115f, -0.14013281f, -0.29311007f, 0.23692757f, 0.12255241f, 
    0.16379635f, 0.10282153f, 0.10718608f, -0.00375025f, -0.02175397f, 0.00166261f, 0.02166384f, -0.08480468f, 
    -0.10928344f, 0.23861362f, 0.62929660f, -0.68097425f, -0.06647413f, -0.01140078f, 0.00501293f, -0.02905314f, 
    -0.02672968f, -0.11032173f, 0.17274565f, 0.06184067f, -0.21944582f, 0.04984614f, -0.15685219f, 0.08193645f, 
    0.07396486f, 0.12167684f, -0.02974850f, -0.19021192f, 0.08614940f, -0.12264178f, -0.10088118f, 0.05534002f, 
    -0.31961554f, 0.04908290f, -0.25048524f, 0.16060293f, -0.00446859f, 0.14971215f, 0.16281892f, 0.17118439f, 
    0.14143391f, -0.03816945f, -0.02106871f, -0.09016854f, -0.30714422f, -0.01698489f, 0.17048945f, -0.76529098f, 
    -0.17636725f, -0.13534781f, 0.04626658f, 0.26934123f, 0.08034407f, 0.00596632f, 0.07831392f, -0.10070979f, 
    -0.01816477f, -0.20762317f, 0.76108831f, -0.77865338f, 0.15120041f, -0.40773049f, -0.15811735f, -0.24242662f, 
    -0.23865730f, 0.06808870f, -0.02478820f, -0.00607301f, -0.02423383f, 0.03004806f, -0.20111972f, -0.06229694f, 
    0.06609870f, 0.14352937f, 0.10314303f, 0.00020222f, 0.30755100f, 0.10688836f, 0.05502407f, 0.16052695f, 
    -0.57533288f, -0.23358002f, -0.15630895f, -0.47706553f, -0.37193546f, 0.08646856f, 0.00456833f, -0.01850384f, 
    0.12583821f, 0.01986443f, 0.08697695f, 0.06715937f, -0.20067841f, 0.06941362f, 0.11200882f, 0.41796488f, 
    0.08759326f, 0.09984116f, -0.05307181f, 0.05633701f, 0.04529979f, 0.13161087f, 0.14795940f, 0.08824363f, 
    0.13077140f, -0.24021816f, 0.04813886f, -0.30762684f, 0.14483204f, 0.05487605f, 0.12460873f, 0.02817763f, 
    -0.09748968f, -0.05534850f, -0.07916804f, -0.06081135f, 0.12815362f, -0.08769432f, 0.08213425f, -0.23864497f, 
    0.10073473f, 0.05317158f, 0.12983820f, 0.13824791f, 0.05900114f, -0.02698560f, 0.19511396f, 0.21394268f, 
    0.16123514f, -0.12013192f, 0.04006931f, 0.46910685f, 0.07687326f, 0.08150393f, -0.26155815f, 0.03255514f, 
    -0.23972081f, -0.07840886f, 0.06851410f, -0.18436575f, -0.56666154f, 0.35750681f, -0.29628128f, 0.11073936f, 
    0.22947086f, -0.12528254f, 0.15533847f, -0.16670151f, 0.22430730f, -0.13853942f, -0.09378919f, -0.01801345f, 
    -0.22536550f, -0.03278779f, -0.53767276f, -0.24924590f, -0.13881417f, 0.03196418f, 0.12911552f, 0.19885598f, 
    -0.10756508f, -0.07008141f, -0.07100587f, 0.01418987f, -0.34129637f, 0.09773772f, -0.33492038f, -0.00901193f, 
    0.14498393f, -0.00861637f, 0.06105944f, -0.13067706f, 0.12652238f, -0.04795332f, 0.20409119f, -0.02973250f, 
    0.39400181f, 0.00771869f, 0.18090864f, -0.23532139f, -0.04734072f, -0.03809690f, -0.24006820f, -0.19368769f, 
    -0.00194556f, 0.01506427f, -0.00438223f, -0.06360515f, -0.01708728f, -0.08520395f, -0.48923835f, 0.02136170f, 
    0.18986572f, 0.02274251f, 0.29599357f, 0.04992243f, -0.03980176f, -0.07508670f, -0.02566072f, 0.02240935f, 
    0.49987358f, 0.45817965f, -0.72775912f, 0.04803412f, -0.13438238f, -0.23426649f, 0.11479241f, 0.08778116f, 
    0.12098254f, -0.02784535f, -0.03709521f, -0.06972948f, -0.62631553f, -0.01939870f, -0.26365140f, -0.10876288f, 
    0.05338391f, -0.35815218f, 0.01950901f, 0.23567414f, 0.02500252f, -0.11668766f, -0.04148574f, -0.11725836f, 
    -0.17376955f, 0.22022541f, -0.13694656f, -0.19558960f, -0.15741768f, -0.23610874f, 0.20848107f, 0.07176895f, 
    -0.02691218f, 0.10305574f, -0.16191953f, 0.03680469f, -0.67455238f, 0.32368213f, -0.23659146f, 0.18207489f, 
    0.09318041f, -0.11450561f, -0.32461026f, 0.32392627f, -0.01360433f, 0.14670458f, -0.02897193f, 0.04799125f, 
    -0.23498173f, 0.47486326f, -0.41375357f, 0.27094558f, 0.19670784f, -0.01023792f, -0.14351502f, 0.05107393f, 
    -0.02081640f, 0.05232470f, -0.24805035f, -0.45099062f, -0.04248869f, 0.22191148f, -0.16129328f, 0.24874538f, 
    -0.00575658f, -0.01586081f, -0.08477636f, 0.14197937f, -0.04417077f, 0.18880147f, 0.01793617f, -0.06385366f, 
    -0.02467572f, 0.40564719f, 0.27145252f, 0.10007106f, -0.34048745f, -0.03312754f, 0.20584467f, 0.02608874f, 
    0.36199313f, -0.25065547f, 0.26799610f, 0.15103309f, 0.08114709f, -0.14854868f, -0.45848438f, 0.05196880f, 
    -0.11864103f, 0.16202199f, -0.15844586f, 0.03098739f, 0.10306906f, 0.09993491f, -0.00682054f, -0.13337712f, 
    -0.13152933f, 0.20600219f, 0.16933954f, -0.16500187f, -0.11583838f, 0.16004458f, -0.02334286f, -0.06532574f, 
    -0.08818462f, -0.11637226f, -0.09786729f, -0.45445737f, -0.46971604f, 0.29066801f, -0.70111614f, -0.00161528f, 
    0.08517145f, 0.17145617f, 0.15364881f, 0.08127081f, -0.10656868f, -0.09542296f, -0.01598861f, -0.01923219f, 
    -0.24896340f, 0.29627883f, 0.01518058f, -0.09714887f, 0.01351359f, -0.09852698f, -0.04735462f, 0.05875707f, 
    -0.15587330f, 0.03796009f, -0.29811117f, -0.41830319f, -0.04946811f, -0.32291856f, 0.68920600f, 0.00749351f, 
    0.08713505f, 0.33968425f, 0.20775849f, 0.09702286f, 0.13119319f, 0.16958958f, 0.41194054f, 0.16709453f, 
    -0.08322678f, -0.33804664f, -0.11353234f, 0.08875788f, -0.08875792f, 0.05687041f, -0.05798014f, 0.27043650f, 
    -0.04117920f, 0.09801776f, -0.12822853f, -0.30461562f, -0.00396834f, -0.26247120f, -0.20389543f, -0.02216820f, 
    -0.01105262f, -0.29074943f, -0.00493983f, -0.17913218f, -0.17192216f, -0.02941499f, -0.05928890f, -0.12008076f, 
    -0.22073364f, 0.33431810f, -0.27343601f, 0.19658598f, -0.14601003f, -0.02736633f, -0.04301778f, 0.12042584f, 
    -0.06443797f, -0.07697565f, -0.19753228f, -0.10183708f, -0.44314417f, 0.00543609f, -0.38924211f, -0.25616124f, 
    -0.50574052f, 0.06234154f, -0.06918846f, -0.04681374f, 0.10727789f, 0.27329847f, -0.04045401f, 0.24920061f, 
    -0.22452195f, 0.05560367f, 0.09547453f, 0.27510849f, -0.01943974f, -0.08418350f, -0.14468820f, 0.13447985f, 
    -0.18774016f, -0.03928864f, -0.39108726f, -0.25577852f, -0.47924107f, 0.19700813f, -0.39076808f, -0.32606703f, 
    -0.13410270f, 0.16672853f, 0.25046378f, -0.23896591f, 0.13192540f, -0.02158964f, 0.04884305f, 0.03456817f, 
    0.04707703f, -0.22662009f, 0.10729759f, 0.10587123f, -0.13200147f, -0.01837168f, 0.05248119f, 0.12663732f, 
    -0.34938318f, -0.14424618f, 0.12129844f, 0.04978568f, 0.05405952f, -0.47957444f, 0.06941385f, 0.19014363f, 
    -0.11246399f, 0.02300308f, 0.17310628f, 0.20780620f, 0.06460728f, 0.03370599f, 0.21953346f, 0.19114313f, 
    -0.41551355f, 0.30138192f, -0.22460985f, 0.06773147f, -0.17838176f, -0.01578918f, -0.05575133f, 0.31383061f, 
    0.14764859f, -0.02567404f, -0.11438939f, -0.07634425f, -0.05493770f, -0.61123210f, -0.47342837f, -0.60317343f, 
    -0.09357092f, -0.00911667f, -0.02921569f, -0.16959397f, -0.42551538f, 0.06462239f, 0.02353408f, -0.04344909f, 
    0.07573655f, -0.17551085f, -0.05121355f, 0.00125477f, 0.02796141f, -0.45771062f, 0.04738696f, 0.21274975f, 
    -0.19513902f, 0.18243469f, -0.01802271f, -0.26091912f, -0.00297774f, -0.03194194f, 0.19510801f, -0.27377495f, 
    -0.10072998f, 0.07523377f, -0.09761118f, 0.00782829f, -0.04072491f, 0.12723860f, -0.43672159f, -0.26706254f, 
    -0.10395362f, 0.46286660f, 0.19866522f, 0.06126489f, 0.00228150f, -0.23765074f, 0.10925246f, 0.07013687f, 
    -0.27226642f, 0.30547392f, 0.46483886f, 0.28196800f, -0.27196389f, 0.57846886f, -0.08376566f, 0.04446594f, 
    0.08190364f, -0.25897169f, -0.29627898f, 0.28119567f, -0.40008119f, -0.39179811f, -0.01608517f, -0.25610200f, 
    0.06084155f, 0.53824139f, 0.01441778f, -0.01219527f, 0.08150364f, 0.10058868f, -0.08394375f, 0.12827255f, 
    0.24371962f, 0.18827111f, 0.20032269f, 0.25723335f, -0.14397909f, -0.21395232f, 0.27960718f, 0.14150128f, 
    -0.31794989f, 0.01300218f, 0.09364539f, 0.23327111f, 0.11866261f, 0.10248940f, 0.15799162f, 0.02340255f, 
    0.09190582f, -0.42493606f, 0.55167103f, -0.03294725f, -0.12131762f, 0.13133398f, 0.03351193f, -0.08201152f, 
    0.13792855f, -0.15237592f, 0.06372034f, 0.08069704f, -0.35221276f, 0.00842352f, 0.15550233f, 0.04727845f, 
    0.01815530f, -0.05399512f, 0.20359471f, 0.00877196f, -0.08991479f, -0.02351853f, 0.23231852f, 0.00229510f, 
    0.44991088f, 0.27837211f, 0.12563846f, 0.11502530f, -0.08633141f, -0.04406757f, 0.09993335f, -0.03583597f, 
    -0.15792473f, 0.06031637f, 0.10729823f, -0.03214889f, 0.03985871f, -0.02777202f, -0.11657147f, -0.03661888f, 
    -0.24755247f, -0.32307094f, 0.10771652f, 0.09506712f, -0.16982396f, -0.04952497f, -0.26988390f, -0.24299119f, 
    -0.62297708f, -0.58801454f, 0.11372798f, -0.13502759f, 0.00312666f, 0.12590553f, 0.13052428f, 0.02859755f, 
    -0.14511162f, 0.24708806f, -0.01955122f, 0.03832786f, -0.01746940f, 0.19355334f, 0.39823389f, 0.12847833f, 
    -0.05191231f, 0.04188707f, -0.02462497f, 0.15081306f, -0.27375168f, 0.10336906f, 0.17149860f, -0.07606154f, 
    0.31121036f, -0.94391400f, 0.49797869f, 0.42125055f, 0.33075938f, -0.09524096f, 0.28898436f, -0.03763456f, 
    0.08837687f, 0.09210394f, 0.12339548f, 0.09436148f, -0.10197782f, -0.67219073f, 0.14802028f, -0.09472279f, 
    0.09860556f, -0.35932750f, -0.31601748f, -0.05898390f, 0.09519658f, -0.09489163f, -0.06831387f, -0.06200561f, 
    -0.22954732f, 0.12481482f, -0.28340787f, 0.02234557f, 0.02243879f, -0.27243835f, 0.12513140f, 0.06637505f, 
    -0.00270739f, 0.14456284f, 0.04857978f, 0.09437694f, -0.46727246f, -0.27581954f, 0.31454027f, 0.08254292f, 
    -0.12880938f, -0.02639569f, -0.00966342f, 0.17539009f, -0.12136824f, -0.08601169f, -0.20882356f, -0.03677678f, 
    -0.00573259f, -0.30773774f, 0.19285171f, -0.40877768f, 0.07003965f, 0.00482615f, -0.25795448f, 0.16541719f, 
    -0.26340422f, 0.09764864f, 0.09698081f, -0.31820410f, -0.36225346f, -0.51305765f, -0.09235051f, 0.45594314f, 
    -0.02246894f, -0.09420904f, -0.04182499f, -0.46182024f, 0.01832228f, 0.08495758f, 0.01327897f, -0.05694274f, 
    0.03634207f, 0.03915480f, -0.12292354f, -0.07167895f, -0.01793192f, -0.03501954f, 0.12906893f, 0.10604496f, 
    0.28868419f, 0.10930602f, 0.10902622f, 0.02640199f, 0.18536995f, 0.00751263f, -0.04064743f, 0.47454426f, 
    0.03062022f, -0.27932176f, 0.09099134f, 0.05926090f, -0.12004366f, -0.15251639f, -0.07610149f, -0.30585438f, 
    -0.91425419f, 0.57257867f, -0.65503991f, -0.17897595f, -0.00499242f, -0.17136870f, 0.02327144f, -0.10599629f, 
    -0.12283025f, 0.01346766f, 0.01501797f, 0.07192306f, 0.10842930f, 0.21580647f, 0.35012579f, -0.26703078f, 
    0.24806547f, -0.05944473f, -0.21129371f, 0.24584146f, -0.12434446f, -0.14956015f, -0.07547966f, -0.17809005f, 
    0.05122608f, -0.14386696f, 0.06749787f, -0.36450803f, 0.06842617f, 0.17592286f, -0.05028122f, 0.09003730f, 
    -0.00402631f, 0.11598031f, 0.20913157f, 0.01559905f, 0.23748828f, -0.18029541f, 0.39225018f, -0.40885514f, 
    -0.05397389f, -0.22797491f, -0.13315593f, 0.02526647f, -0.05527687f, 0.00124394f, -0.04193296f, -0.05977942f, 
    -0.12216570f, 0.28087401f, -0.35728216f, 0.08944365f, -0.13470705f, -0.04543296f, 0.01132798f, -0.05158217f, 
    -0.00652835f, 0.05185005f, 0.27136379f, -0.06348009f, 0.19284190f, 0.04609846f, -0.29470110f, -0.00463852f, 
    -0.01864395f, 0.02249845f, -0.09698015f, 0.05879946f, -0.06378894f, -0.05946237f, 0.02716764f, -0.26516455f, 
    -0.10938069f, -0.21092096f, 0.07939810f, 0.32458168f, -0.07820722f, 0.10558528f, 0.12926374f, 0.15542740f, 
    0.01452806f, 0.16021025f, 0.08779016f, -0.02176215f, 0.53593105f, -0.14722365f, 0.05594959f, 0.13752568f, 
    0.17825346f, 0.05451436f, -0.05556685f, 0.17158946f, -0.20070195f, 0.16842306f, 0.01290287f, 0.07535289f, 
    0.30272761f, -0.09284505f, 0.19975145f, 0.19939789f, -0.16136411f, 0.03233040f, -0.11939027f, 0.00261140f, 
    -0.28177828f, 0.03575353f, 0.07295862f, -0.01453505f, -0.46330264f, -0.05057942f, 0.04428839f, -0.00706427f, 
    0.00990530f, -0.12590984f, -0.08504412f, -0.33100566f, -0.02096197f, -0.00294457f, -0.25921550f, -0.08933853f, 
    -0.47230887f, -0.58373266f, -0.10548627f, 0.52826709f, 0.11847016f, 0.21595618f, 0.05720330f, 0.25478470f, 
    -0.26901492f, -0.03836558f, -0.02530504f, -0.05784916f, 0.06358300f, 0.34549296f, -0.05232665f, 0.06135490f, 
    -0.04474021f, -0.03014381f, 0.11565772f, -0.01211749f, -0.01613973f, 0.04743531f, 0.00312677f, -0.04025240f, 
    -0.12101823f, 0.29539359f, 0.08847243f, -0.58151674f, 0.03190187f, 0.07129121f, 0.16222171f, -0.11831315f, 
    0.01080586f, -0.00629484f, 0.00005644f, -0.03281265f, -0.11937245f, 0.03557754f, -0.10622402f, 0.08309940f, 
    0.07464851f, 0.04485936f, -0.03531897f, -0.07792187f, 0.05502824f, -0.08080905f, 0.26045716f, 0.19971950f, 
    -0.01194535f, 0.22244036f, -0.23035204f, 0.21570097f, 0.23165742f, 0.11050341f, 0.10114974f, -0.00545073f, 
    -0.18747394f, -0.11262543f, 0.02954051f, -0.10853478f, -0.20723076f, 0.04898934f, 0.02976748f, -0.09114119f, 
    0.03699029f, 0.01202813f, 0.02124144f, 0.02668240f, 0.00801286f, 0.14894813f, 0.12557839f, 0.07934434f, 
    -0.77960175f, 0.01608973f, -0.36604059f, 0.36073762f, 0.17088197f, -0.09530592f, 0.10347522f, 0.06718535f, 
    -0.06182292f, -0.20511636f, -0.04573490f, 0.13264969f, 0.40236238f, -0.22351059f, 0.48574859f, -0.38846990f, 
    0.02014667f, 0.13225651f, 0.23618452f, 0.02405800f, -0.26706055f, -0.02762830f, -0.03026335f, 0.01252484f, 
    0.26749811f, 0.12697013f, 0.14257820f, 0.16259548f, 0.16771816f, -0.01123083f, 0.04087840f, -0.07196152f, 
    0.06586836f, -0.01299925f, 0.01939335f, -0.02866981f, 0.33267149f, -0.12872982f, 0.01194453f, 0.07954206f, 
    0.01489341f, 0.08651911f, -0.01377321f, -0.01178552f, -0.09028385f, -0.01388119f, 0.05202519f, 0.10771194f, 
    -0.89232004f, 0.45668498f, -0.39930049f, 0.15002993f, -0.05389890f, -0.08893916f, 0.10552359f, 0.00810884f, 
    -0.16416089f, -0.18448040f, -0.00632745f, 0.26710165f, 0.51306659f, -0.05521314f, 0.47073376f, -0.06570849f, 
    -0.10780479f, 0.08386295f, -0.24529444f, -0.02106991f, -0.04921061f, -0.04865867f, 0.04868489f, 0.12592182f, 
    -0.29759282f, -0.57424337f, 0.07312007f, -0.18855622f, -0.13139531f, 0.00110855f, -0.06264481f, -0.13125591f, 
    -0.14972956f, 0.06478578f, 0.02088752f, 0.10771533f, 0.08254912f, 0.15321404f, 0.66593802f, -0.23989408f, 
    0.02966633f, 0.06311437f, -0.16879903f, -0.10705192f, -0.00603754f, -0.10618765f, -0.05914961f, 0.03550073f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15228017f, 0.12334218f, 0.10954703f, -0.13925412f, -0.13371882f, 0.02949804f, 0.03505786f, -0.18622339f, 
    0.14538048f, 0.08018680f, 0.05871983f, -0.06461709f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
