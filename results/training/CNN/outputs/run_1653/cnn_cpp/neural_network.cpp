#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49567521f, -0.63136190f, -0.40521964f, 0.27995962f, 0.21176575f, 0.27613041f, -0.26356038f, -0.46701008f, 
    -0.20017260f, 0.11348250f, 0.05172918f, 0.18437666f, -0.09418392f, 0.34584442f, -0.14293516f, -0.14061831f, 
    -0.00803620f, -0.13976535f, -0.10151998f, -0.13337108f, -0.24218090f, 0.28856862f, 0.28829685f, -0.00640095f, 
    0.19599813f, -0.03118478f, -0.07026879f, -0.67371845f, -0.50310594f, -0.61876935f, 0.07178829f, 0.28601819f, 
    0.55953133f, -0.02773674f, -0.18380496f, -0.08705878f, 0.68736184f, -0.36350456f, -0.15693271f, -0.37345001f, 
    -0.23877546f, 0.30168039f, -0.00796984f, -0.29745817f, 0.30957749f, 0.05469421f, -0.11274426f, 0.30231586f, 
    -0.03811821f, -0.25129488f, 0.65320426f, 0.17621377f, -0.08514985f, 0.39240217f, 0.08736625f, 0.14386280f, 
    0.11728878f, 0.05169818f, 0.02844940f, 0.24158256f, -0.05725025f, 0.32070118f, -0.15057699f, -0.40752837f, 
    -0.13192962f, -0.08035236f, 0.18338032f, -0.06575197f, -0.02797808f, 0.03013082f, -0.25184655f, -0.16769636f, 
    -0.15873742f, -0.26430723f, -0.53486598f, 0.95088679f, -0.89194047f, -0.53060442f, 0.29207695f, 0.17402719f, 
    0.05090881f, 0.54152298f, 0.67339408f, -0.57030189f, -0.48771727f, -0.16698730f, -0.07286800f, 0.03132797f, 
    -0.22978608f, -0.03414761f, -0.02991556f, -0.02263834f, 0.23160914f, 0.07275344f, -0.10481780f, 0.18152483f, 
    -0.05358204f, -0.32104066f, -0.00675600f, -0.03458707f, 0.59022892f, -0.10531919f, -0.17214519f, -0.19255994f, 
    -0.45738152f, 0.27663425f, -0.24241596f, -0.01223776f, 0.23845723f, 0.48432308f, 0.53412277f, 0.13517062f, 
    -0.28768045f, -0.34118408f, -0.18119048f, 0.15037809f, 0.06481783f, 0.27795050f, -0.19936821f, -0.10604282f, 
    0.01348870f, 0.18921976f, -0.23179694f, -0.14512362f, -0.37530324f, 0.25039107f, 0.24475795f, 0.49974841f, 
    -0.23201829f, 0.50345385f, -0.58449090f, -0.38220379f, 0.14837664f, 0.33237505f, 0.07897029f, -0.00692097f, 
    -0.09899190f, 0.22768073f, -0.21676220f, -0.04645214f, 0.23942968f, 0.04311454f, -0.25739273f, -0.11834285f, 
    0.16827098f, -0.19490433f, 0.24332662f, 0.01046751f, 0.14125751f, 0.37645733f, -0.60464257f, 0.48743281f, 
    0.80354744f, -0.25370005f, 0.26393643f, -0.58457303f, -0.44198042f, -0.29465601f, 0.06990086f, 0.15141100f, 
    -0.19654006f, -0.21869962f, -0.39665979f, -0.25024959f, 0.37943372f, -0.01737660f, -0.08493726f, 0.13526197f, 
    0.04127599f, 0.36178559f, 0.04201724f, -0.03330819f, -0.09196024f, -0.39514908f, -0.29983100f, -0.31229070f, 
    0.04653306f, -0.31634074f, -0.38591272f, -0.28896350f, -0.30509284f, -0.08875290f, -0.12504026f, -0.36792487f, 
    -0.08283430f, 0.07208315f, 0.13115206f, -0.09422324f, -0.40746838f, -0.26993018f, -0.01726015f, 0.12265999f, 
    0.14408563f, 0.12730701f, 0.00188024f, -0.16186187f, -0.16240497f, -0.25115988f, -0.03912936f, -0.25194046f, 
    0.10863752f, 0.33627951f, -0.25527975f, -0.42276108f, -0.42459822f, -0.37169111f, -0.45062113f, -0.11858667f, 
    -0.46839029f, -0.79549372f, 0.03851840f, -0.13891284f, 0.45647967f, -0.15043768f, 0.21432935f, 0.23274715f, 
    0.13598092f, 0.22319089f, -0.03175760f, -0.00593343f, -0.22131506f, 0.02915895f, 0.00466556f, -0.08690034f, 
    0.54965770f, -0.38303196f, -0.65358758f, 0.30708298f, 0.15800551f, -0.12116360f, -0.22982720f, -0.21228927f, 
    -0.41030824f, 0.04566341f, -0.04921547f, 0.17666595f, 0.13900614f, 0.07169402f, 0.27194318f, -0.36853033f, 
    0.06492373f, -0.00739463f, -0.19599594f, -0.13557664f, -0.34736177f, -0.28786588f, -0.16335875f, -0.20083474f, 
    -0.00015110f, -0.25895414f, 0.36225304f, 0.11594359f, 0.74127924f, -0.32358319f, 0.12619826f, -0.51144916f, 
    -0.31479359f, 0.12161246f, 0.16237277f, 0.16522098f, 0.04607077f, -0.13209613f, 0.40589380f, 0.07315395f, 
    -0.16476466f, -0.06837041f, 0.06096461f, 0.09550122f, 0.12023168f, -0.39393261f, 0.10176835f, -0.10976094f, 
    -0.28816947f, 0.26976597f, -0.09465445f, 0.41780370f, 0.07268535f, -0.17842928f, 0.43656027f, -0.10825625f, 
    -0.11425070f, -0.09278561f, -0.06772586f, 0.30868092f, 0.24098907f, 0.18351170f, -0.23927367f, -0.12178440f, 
    0.44591632f, -0.16759822f, -0.33832982f, 0.12064528f, 0.09367170f, -0.08896256f, -0.06210217f, 0.22735944f, 
    -0.03462581f, 0.37702066f, -0.21489996f, -0.21665274f, 0.84113562f, 1.10150421f, -0.09105986f, -0.29891679f, 
    -0.17984903f, 0.16750665f, -0.28020751f, -0.14368798f, -0.42757961f, -0.30044523f, -0.04105713f, -0.04886701f, 
    0.06219370f, -0.12881503f, -0.24704932f, -0.01498869f, 0.13353190f, -0.15213926f, 0.38193074f, -0.20645474f, 
    -0.10736530f, 0.11913016f, 0.02203299f, 0.00620362f, 0.02800918f, -1.11074269f, -0.00919185f, -0.44635537f, 
    -0.78993946f, -0.31299713f, 0.69131786f, 0.29259533f, 0.06783693f, 0.05673472f, 0.21385588f, 0.18671004f, 
    -0.06260387f, 0.17597498f, 0.01692839f, 0.04915159f, -0.11757550f, -0.09164172f, -0.25625166f, 0.09445553f, 
    -0.07132182f, -0.12929337f, 0.12055539f, 0.20540330f, -0.21106906f, -0.30584016f, -0.53163004f, -0.00237592f, 
    0.60624003f, -0.31937921f, -0.00623382f, -0.04846044f, 0.14733166f, -0.38173017f, -0.29187521f, -0.17235595f, 
    0.23138225f, -0.15993316f, 0.07975033f, -0.01912841f, -0.19342969f, 0.19208664f, -0.31189609f, -0.15813063f, 
    0.11636687f, -0.25316682f, 0.11067355f, 0.27874127f, 0.23466472f, 0.22683273f, 0.40154564f, -0.81844622f, 
    -0.12558210f, 0.00810842f, 0.16132173f, 0.22565317f, 0.67585260f, -0.15085520f, 0.25380003f, 0.57497722f, 
    0.37493646f, 0.05556212f, 0.16663709f, -0.00946388f, 0.46631551f, -0.29689798f, -0.22348708f, 0.05573786f, 
    -0.02515846f, -0.35832751f, 0.16562510f, 0.13289717f, -0.08106278f, 0.08894903f, 0.26346934f, -0.23432674f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22786102f, 0.27793872f, -0.02452573f, 0.12325366f, 0.20134534f, -0.06020769f, 0.15098846f, -0.32714510f, 
    -0.03943098f, -0.03496067f, -0.00482342f, 0.20298694f, 0.31744444f, 0.30559045f, -0.07842450f, 0.04037913f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02342357f, -0.02147761f, -0.05811967f, -0.05102021f, -0.07708582f, -0.00542866f, 0.00743852f, -0.06953863f, 
    -0.02174113f, -0.05996695f, 0.03417733f, -0.06346226f, 0.01455827f, 0.03638645f, -0.00761681f, 0.01795475f, 
    -0.07172365f, 0.04100547f, -0.00736459f, -0.01384262f, 0.00597003f, 0.00788588f, -0.05470591f, -0.05020770f, 
    -0.07816833f, -0.04008110f, 0.02301309f, 0.05027118f, 0.05610310f, -0.04059207f, -0.05251836f, -0.05199087f, 
    -0.01920228f, -0.06611674f, -0.01700705f, 0.01926669f, -0.03916036f, -0.07048184f, 0.03394415f, 0.01260371f, 
    0.05930055f, 0.05711212f, -0.07334652f, -0.04367493f, -0.04325248f, 0.02739092f, -0.02316414f, 0.04826753f, 
    0.00180270f, 0.05219708f, -0.02104652f, 0.05278891f, -0.05750554f, 0.02198876f, -0.07023677f, -0.05989685f, 
    -0.01370216f, 0.04786021f, -0.01133818f, 0.01433445f, -0.03839876f, -0.06178090f, 0.04077753f, -0.06767230f, 
    -0.05328662f, 0.00379029f, -0.05561248f, -0.01644852f, -0.02602313f, -0.01393482f, -0.07761830f, -0.00477978f, 
    -0.07204641f, 0.00467765f, -0.07545141f, 0.03902440f, 0.04524743f, -0.00647988f, 0.01879650f, -0.04673179f, 
    0.03606426f, -0.00243887f, 0.05850407f, -0.07273855f, 0.00381030f, -0.06063532f, 0.01341958f, 0.04950802f, 
    -0.04316379f, 0.01092697f, -0.05737820f, -0.03428612f, 0.05689915f, -0.06113407f, 0.03193814f, -0.02561853f, 
    -0.03386002f, 0.06445903f, -0.04838288f, 0.05107190f, -0.03836546f, 0.03719172f, -0.03090259f, 0.01321397f, 
    0.04161451f, 0.04896449f, -0.04136370f, 0.04978783f, 0.02877340f, -0.06481954f, -0.04024920f, 0.01431488f, 
    0.05788999f, -0.00028453f, 0.05186538f, 0.05770662f, -0.06063819f, -0.01293889f, 0.00642414f, 0.05975758f, 
    -0.05453623f, -0.01771257f, -0.02720665f, -0.05535973f, -0.00571884f, -0.06955543f, -0.02290769f, -0.01716858f, 
    -0.03365207f, -0.03986867f, 0.00658025f, 0.01113894f, 0.06365222f, -0.01174251f, -0.01610241f, -0.03365894f, 
    0.04579166f, 0.05392295f, 0.01442834f, -0.06653138f, -0.06692351f, 0.01567855f, -0.05972544f, -0.05543810f, 
    0.02287074f, 0.06262390f, -0.03257943f, -0.05712097f, 0.04993802f, -0.01423520f, -0.02990668f, 0.03694488f, 
    -0.00324610f, -0.07224044f, 0.05721977f, -0.03589501f, -0.00824293f, -0.04421189f, 0.04582978f, -0.03158154f, 
    -0.07384650f, 0.02570761f, -0.02581919f, -0.01498462f, 0.01931954f, -0.05473223f, 0.02751327f, -0.01088499f, 
    0.00851858f, -0.03495291f, -0.01876078f, 0.00186687f, 0.02231932f, 0.04263184f, 0.05042859f, -0.01589945f, 
    -0.03853773f, -0.07792870f, 0.05591081f, -0.03249216f, 0.04252587f, 0.03810393f, -0.00897382f, -0.01756701f, 
    0.02266124f, 0.05559415f, 0.03080544f, 0.05669701f, -0.05295094f, 0.04472138f, 0.03301656f, -0.05023919f, 
    0.08039083f, 0.21624349f, 0.16350356f, -0.06975357f, 0.05742166f, 0.09294900f, 0.14076394f, -0.01459315f, 
    0.12655494f, 0.04130121f, -0.01201858f, -0.08110613f, -0.02439581f, -0.18153678f, -0.01566280f, 0.14698526f, 
    0.03391352f, -0.00364149f, 0.07703062f, 0.14060721f, -0.06039476f, -0.09318537f, 0.10284922f, -0.02429787f, 
    0.11660970f, -0.04274600f, 0.09064033f, -0.14322327f, 0.00712622f, -0.01270760f, -0.16765012f, -0.10400969f, 
    0.00714407f, -0.26218832f, 0.03719983f, -0.17463216f, -0.31587148f, -0.06677100f, 0.00343580f, -0.19215263f, 
    -0.04290994f, -0.12021507f, -0.12332025f, 0.27569491f, -0.01523141f, 0.22244757f, 0.00267892f, -0.02725280f, 
    -0.02892771f, -0.00436414f, -0.14188386f, -0.23612598f, 0.03431525f, -0.04652027f, 0.03086903f, 0.01564743f, 
    0.02210013f, -0.11630959f, 0.03407042f, 0.09549230f, -0.58318633f, -0.15847455f, -0.14615099f, 0.31393644f, 
    0.11629891f, 0.09833632f, 0.08094727f, -0.14629731f, 0.04014623f, 0.07538871f, 0.04426232f, 0.26179779f, 
    -0.15933202f, 0.08466388f, 0.15043604f, 0.23832260f, 0.06235441f, 0.08024906f, 0.01684062f, 0.24347039f, 
    -0.19151765f, 0.10017094f, -0.13976444f, -0.18100724f, -0.07150662f, 0.09089758f, 0.05706483f, 0.08638767f, 
    0.11746226f, 0.04026945f, -0.00270591f, 0.07423857f, -0.12812050f, -0.19600633f, -0.08692791f, -0.04598123f, 
    -0.07228852f, 0.08177132f, 0.09214672f, 0.45974776f, 0.17181896f, 0.26046532f, 0.10083216f, 0.20765106f, 
    -0.18641673f, -0.00843820f, 0.09090806f, 0.08277783f, 0.04761217f, 0.21124829f, 0.21367890f, 0.02852192f, 
    -0.08051566f, -0.05136400f, 0.01019977f, 0.05356940f, 0.05525052f, -0.09377415f, -0.08403327f, -0.23640579f, 
    -0.30929348f, 0.08326745f, -0.15745644f, 0.28815922f, 0.00916865f, 0.24358226f, 0.00308178f, 0.04809253f, 
    -0.09131125f, 0.08797482f, -0.03476879f, 0.09311543f, 0.09257602f, -0.06221864f, -0.17717996f, -0.21898425f, 
    0.00022116f, 0.07883187f, -0.05463469f, 0.08747333f, -0.08140891f, 0.27705988f, 0.04637700f, -0.01809088f, 
    0.04803529f, 0.38750452f, -0.47879657f, 0.22641566f, -0.10352112f, 0.16727713f, -0.05335913f, 0.08590375f, 
    0.05377628f, -0.13057107f, -0.05206200f, -0.07014786f, 0.08899891f, 0.02173133f, -0.08960628f, -0.08155461f, 
    -0.02146692f, -0.13893726f, 0.19867344f, 0.00309651f, 0.08599701f, 0.07388210f, -0.19784205f, -0.09250799f, 
    -0.06048373f, 0.02174832f, 0.09036732f, 0.10429215f, 0.13802467f, 0.13609691f, 0.00106706f, 0.05336822f, 
    0.35024494f, 0.23157230f, 0.00349113f, 0.27952805f, 0.33459729f, 0.30095124f, 0.03759904f, 0.13484056f, 
    -0.19991855f, 0.01645261f, -0.33186057f, -0.15214376f, 0.03397480f, 0.05929856f, 0.07359271f, 0.06221957f, 
    -0.23564471f, -0.15034658f, 0.07683922f, 0.20848669f, -0.15354002f, -0.11301569f, -0.06707083f, 0.02381363f, 
    0.01320458f, 0.07499987f, 0.01202153f, -0.02300279f, -0.17025709f, 0.20397349f, 0.36508876f, 0.14279060f, 
    -0.02797388f, 0.00471676f, -0.05696769f, 0.03137017f, 0.04963744f, 0.09584603f, 0.10448740f, -0.04425441f, 
    -0.09396118f, 0.08941569f, -0.01771119f, -0.10407694f, -0.05873854f, -0.05401159f, -0.02610802f, -0.02957052f, 
    0.12978373f, 0.24999854f, 0.09543702f, -0.03429515f, -0.45919541f, 0.40012413f, 0.16597146f, 0.00713695f, 
    0.06232158f, 0.10299321f, -0.06145567f, -0.04542577f, 0.04107356f, 0.04101261f, -0.04706398f, 0.07789354f, 
    0.10575382f, 0.21689165f, -0.16847380f, 0.13636516f, 0.15691945f, 0.13687457f, 0.03434904f, -0.07962551f, 
    0.08221942f, 0.02930182f, -0.00775654f, -0.04498856f, -0.02485264f, -0.23180038f, -0.19818175f, -0.14397831f, 
    -0.26510346f, 0.06095831f, 0.22134531f, 0.10172752f, -0.06340186f, -0.08762132f, 0.01942909f, -0.08970006f, 
    0.14398682f, -0.35271445f, -0.04362701f, 0.21435490f, -0.00230604f, 0.14324343f, 0.10076009f, -0.05412871f, 
    0.01029245f, 0.09959019f, 0.05255345f, 0.15110654f, -0.25446001f, -0.19831702f, 0.00720682f, -0.05325840f, 
    -0.14208578f, -0.03663493f, 0.19655582f, -0.04837056f, 0.15303007f, 0.04597918f, 0.04863679f, -0.07884685f, 
    -0.33865541f, -0.21802562f, -0.02188824f, 0.07456222f, -0.04036484f, -0.00005553f, -0.00958157f, -0.10961489f, 
    0.10347977f, 0.00020482f, 0.00826174f, -0.01524310f, -0.16652296f, -0.10947115f, 0.07936204f, -0.00222464f, 
    0.13576262f, 0.17998846f, 0.01262664f, -0.03844098f, -0.03261414f, 0.12304986f, 0.05909000f, 0.04745235f, 
    0.16463725f, -0.05541764f, -0.23895773f, -0.19565132f, -0.11524676f, 0.01555607f, 0.02207714f, 0.11521614f, 
    -0.22500204f, -0.00335978f, -0.08028392f, -0.08976058f, -0.08494540f, 0.09366251f, -0.18251985f, 0.06570360f, 
    -0.04000265f, 0.02845301f, -0.09641481f, -0.01196244f, -0.04819995f, 0.09511919f, -0.16829947f, 0.08104777f, 
    0.19501200f, -0.09638838f, 0.35696474f, -0.21028242f, 0.12846133f, 0.09284467f, 0.01711508f, -0.05210697f, 
    0.09043784f, 0.06165469f, 0.01332310f, -0.07332072f, 0.01969081f, 0.03168182f, 0.29382172f, 0.16833472f, 
    -0.03899588f, -0.09000178f, 0.02323431f, 0.05054876f, 0.06074085f, 0.12880279f, 0.13999566f, 0.12284317f, 
    -0.12850285f, -0.18579170f, -0.02162193f, 0.03714957f, -0.03336789f, -0.16017675f, -0.03006096f, 0.03493720f, 
    0.02167249f, -0.03575990f, 0.02649176f, -0.06376541f, -0.20123850f, -0.01099759f, -0.00006636f, 0.18531235f, 
    0.01000299f, 0.01652224f, -0.02234170f, -0.02220422f, -0.08190487f, 0.13363256f, 0.10260299f, 0.19169647f, 
    0.06687314f, -0.47938257f, -0.03368254f, -0.05251788f, 0.01087585f, -0.12897241f, 0.09045864f, 0.19756985f, 
    -0.00540209f, -0.00768853f, 0.11950299f, -0.06296430f, -0.02542183f, 0.01139147f, -0.13716397f, 0.17387506f, 
    -0.15942450f, 0.11866605f, 0.04987587f, 0.08348432f, 0.00114458f, 0.00834748f, 0.06195833f, 0.02259291f, 
    -0.12829192f, 0.12625942f, 0.00142235f, 0.00885061f, 0.02958704f, 0.04248424f, -0.00146550f, -0.06819661f, 
    -0.08403034f, 0.19510901f, -0.05541476f, 0.15306407f, -0.27534941f, 0.04665794f, 0.21661524f, 0.11116791f, 
    0.03796097f, 0.14427963f, 0.30588034f, 0.09796442f, -0.10810773f, 0.13296556f, 0.17066810f, 0.18457325f, 
    -0.17021528f, 0.00675645f, 0.35031945f, 0.15376069f, -0.19272631f, 0.16804917f, 0.20856503f, -0.07385925f, 
    -0.04317911f, 0.05414067f, 0.06023243f, 0.00874936f, 0.06787457f, 0.04651890f, -0.00586517f, -0.11575677f, 
    -0.04703036f, -0.09242409f, -0.01371292f, -0.08679873f, 0.09347666f, 0.03427253f, -0.06687342f, -0.07689491f, 
    0.07354807f, 0.02909509f, -0.00838081f, -0.10376836f, 0.21649246f, 0.10039139f, 0.10041390f, -0.06462939f, 
    0.09819341f, 0.10498598f, 0.08789341f, -0.03556771f, -0.03970485f, -0.08948608f, -0.07451414f, -0.16815087f, 
    -0.02698133f, 0.05691909f, 0.12716269f, 0.05256312f, 0.16092463f, 0.04049074f, 0.01890428f, 0.09327944f, 
    -0.24051611f, -0.09776696f, -0.29650298f, -0.15569538f, -0.17319946f, -0.10909137f, 0.14232028f, 0.26730523f, 
    0.08286314f, -0.00394709f, 0.01144896f, -0.04524211f, -0.04109299f, -0.24190325f, -0.28534624f, -0.01085915f, 
    0.09502976f, 0.02278982f, -0.03742442f, 0.22390047f, 0.12074187f, 0.06694423f, 0.15128818f, 0.03757492f, 
    0.09394196f, 0.12026653f, 0.09731579f, -0.13057968f, 0.13580161f, -0.06786776f, 0.03397420f, -0.13596199f, 
    0.00992843f, -0.14364371f, 0.07911284f, -0.00480392f, 0.02756724f, 0.01204060f, 0.25491285f, -0.00208892f, 
    0.15617174f, -0.10157032f, -0.03477539f, -0.07366020f, 0.00344300f, -0.05842117f, 0.12089452f, 0.10426613f, 
    -0.51674610f, 0.06298705f, 0.32397062f, 0.12594377f, -0.04433989f, -0.08798455f, 0.11304603f, -0.02594236f, 
    -0.08168589f, 0.06449094f, -0.04601678f, 0.11579568f, 0.13318656f, -0.16128705f, -0.07835732f, 0.01098356f, 
    -0.19759294f, 0.11742483f, -0.08121712f, 0.09391614f, -0.00165921f, 0.07913486f, 0.07242838f, 0.21845153f, 
    -0.15789898f, -0.23167355f, -0.03166462f, 0.06343149f, -0.15790980f, 0.09118272f, -0.02870800f, 0.20046377f, 
    0.02850020f, 0.01591111f, -0.14649850f, -0.14227399f, 0.17288008f, 0.08683895f, -0.20208330f, -0.31320971f, 
    -0.04132964f, 0.01607361f, -0.14992002f, 0.02661358f, 0.12902230f, -0.00943596f, 0.07402460f, -0.00518469f, 
    -0.04396758f, -0.05891281f, -0.01981790f, -0.04111275f, -0.01873662f, -0.02836912f, -0.05463530f, -0.00449365f, 
    -0.00446009f, 0.04120881f, 0.01063661f, -0.00111660f, -0.07257489f, -0.07404060f, 0.01474594f, -0.04843510f, 
    0.01670333f, 0.01350269f, 0.01168511f, -0.02217421f, 0.01996533f, 0.00375558f, -0.05434909f, -0.05174891f, 
    0.04683224f, 0.00217314f, -0.06248302f, 0.03488620f, -0.01494978f, 0.04121695f, 0.02812704f, -0.00960646f, 
    0.05895444f, 0.03092846f, -0.02500756f, -0.00246834f, 0.00129546f, 0.04827545f, -0.00125788f, 0.03102760f, 
    -0.01995458f, 0.02973393f, 0.00687520f, -0.04850989f, -0.07249288f, 0.02360571f, -0.04379951f, 0.04413263f, 
    -0.06746727f, 0.02055808f, 0.05741821f, -0.07339004f, -0.04637504f, -0.05348652f, -0.05655222f, 0.01022088f, 
    -0.02331578f, -0.04184770f, -0.00007862f, 0.05833827f, -0.02705768f, -0.05020996f, -0.07340752f, -0.04931386f, 
    0.05489057f, -0.06550896f, 0.02612175f, -0.05282575f, -0.02144012f, 0.04283198f, -0.04141348f, -0.05198082f, 
    -0.00496128f, -0.05215524f, -0.02767930f, 0.05367814f, 0.05004395f, -0.05373712f, -0.00408947f, 0.02951968f, 
    -0.02171478f, -0.03870588f, 0.04526820f, -0.04605108f, 0.04643358f, -0.04446847f, -0.04067516f, 0.00763177f, 
    -0.07110825f, -0.07217755f, -0.03470594f, 0.01827542f, -0.02787331f, -0.02643214f, 0.01471853f, -0.04733464f, 
    0.01688941f, 0.06463201f, -0.02589931f, -0.03602377f, -0.01965812f, -0.05233980f, -0.04908014f, 0.01317311f, 
    -0.00533635f, 0.02224652f, -0.00688458f, -0.03774685f, 0.05240778f, -0.02922619f, 0.04793133f, -0.04986731f, 
    -0.02084890f, -0.03566674f, -0.05083818f, -0.06103909f, 0.03736501f, -0.03476996f, -0.04869370f, -0.00543741f, 
    0.03100266f, 0.04074537f, -0.02145813f, 0.04190162f, -0.03759598f, 0.01077441f, 0.00053233f, -0.04018254f, 
    -0.04153368f, -0.06574840f, 0.00350574f, 0.02013496f, 0.01894915f, 0.05127065f, 0.04035859f, -0.04648475f, 
    -0.03688873f, 0.06032670f, 0.02919548f, -0.04929934f, 0.04241382f, -0.02548220f, -0.07882906f, -0.00734521f, 
    -0.03192106f, -0.02455387f, -0.00032800f, 0.06283964f, 0.05014112f, 0.02321433f, 0.05855308f, -0.05490421f, 
    -0.03667956f, -0.04888374f, -0.01780902f, 0.04622645f, 0.05650687f, -0.06221374f, 0.00148722f, -0.03852756f, 
    -0.04750104f, -0.01252748f, -0.02544615f, -0.05571258f, 0.02200687f, -0.05850346f, -0.03928300f, -0.04314695f, 
    -0.03901504f, 0.00888741f, -0.03536458f, -0.06445265f, 0.06212223f, -0.00409497f, -0.01047184f, 0.03949397f, 
    -0.00130874f, -0.06924541f, -0.03572763f, -0.07200126f, -0.08106374f, 0.03424121f, 0.02150742f, -0.04648679f, 
    -0.07007384f, -0.07107355f, 0.00810459f, -0.05198153f, 0.00013131f, 0.05845857f, -0.05216227f, 0.01984051f, 
    0.06921101f, -0.04790090f, -0.08519778f, 0.16966178f, 0.08361157f, 0.15718180f, 0.01673413f, 0.00489874f, 
    -0.10173646f, -0.00104365f, 0.06303194f, 0.04462476f, -0.13250616f, -0.05260242f, 0.30728766f, -0.17062658f, 
    0.02172594f, -0.00544192f, 0.01931155f, -0.10847241f, -0.01331852f, 0.00163466f, -0.16751267f, -0.07707547f, 
    0.24219772f, 0.09503908f, 0.11597373f, 0.15850335f, -0.02773933f, -0.06873368f, 0.03214676f, 0.03962098f, 
    0.07438405f, 0.18832648f, 0.12806006f, 0.17157240f, 0.36003596f, -0.27563983f, 0.29235569f, -0.09196920f, 
    0.11510808f, -0.03230821f, -0.07647589f, 0.04122347f, 0.12023281f, -0.05327959f, 0.07602168f, 0.01609161f, 
    0.24903624f, -0.16262966f, -0.00623956f, 0.04851193f, -0.07259675f, -0.13152319f, 0.02612731f, 0.06393779f, 
    0.09193350f, -0.11706360f, -0.05908140f, 0.07823710f, 0.21512713f, 0.21493693f, 0.08280695f, -0.00832849f, 
    -0.01707724f, -0.00755499f, 0.00710526f, -0.04464671f, -0.12373175f, -0.06247523f, -0.10074304f, -0.02766276f, 
    -0.14617619f, -0.05536332f, -0.25717685f, 0.08715650f, -0.13334505f, -0.06258559f, -0.09094433f, -0.02638314f, 
    0.03312232f, -0.16040404f, 0.05952980f, 0.00402734f, -0.03194538f, 0.01748203f, -0.01688976f, -0.17682306f, 
    0.02615932f, -0.06301863f, -0.01250140f, 0.06244698f, 0.08346593f, 0.07127222f, -0.01895852f, -0.16966408f, 
    0.10623601f, 0.06252505f, 0.11995027f, -0.31377488f, 0.06676447f, -0.04138746f, -0.06104775f, -0.26059359f, 
    -0.04321909f, -0.10902964f, -0.11687440f, -0.17882231f, -0.00294967f, -0.04100710f, -0.00426984f, -0.14174408f, 
    0.01568424f, 0.07672250f, 0.13365379f, -0.02720409f, 0.06445646f, 0.14832842f, 0.05637876f, 0.04884336f, 
    0.21407917f, 0.00317769f, 0.12644331f, -0.02365509f, -0.09976514f, -0.03980903f, 0.03566295f, -0.03152426f, 
    -0.11783347f, 0.01159061f, -0.04288318f, 0.00539595f, 0.09549338f, 0.22658937f, 0.17004676f, 0.13569547f, 
    -0.07866936f, 0.02346821f, -0.00781040f, 0.03732373f, -0.12203677f, -0.02467517f, -0.04076038f, 0.06541714f, 
    0.82148361f, 0.02417368f, 0.29490235f, 0.19047536f, -0.00108197f, -0.25251248f, -0.05894181f, 0.04339139f, 
    -0.13354142f, 0.01059198f, 0.06919190f, 0.01873510f, -0.16672197f, 0.09535776f, 0.09852178f, -0.11596169f, 
    0.00171365f, -0.00404495f, -0.10796230f, 0.21446376f, 0.04679773f, 0.00011000f, 0.06559019f, -0.04672646f, 
    -0.03400157f, -0.06116712f, -0.07628456f, -0.07631923f, 0.01439346f, -0.06166975f, 0.11522478f, -0.15870462f, 
    -0.26195097f, -0.10681143f, -0.02308256f, -0.10993101f, 0.03086976f, 0.07541693f, 0.07405219f, 0.19175766f, 
    -0.10813962f, -0.19284943f, 0.08947930f, -0.04755725f, 0.05107100f, -0.11483325f, 0.02508353f, -0.12737404f, 
    -0.02002449f, -0.20752707f, 0.01261753f, 0.12255569f, -0.04069326f, -0.05793566f, 0.00132245f, 0.19248138f, 
    0.01850009f, -0.15634179f, -0.10243436f, -0.08623123f, -0.12241835f, 0.36150849f, -0.00748337f, -0.06579234f, 
    0.01354415f, 0.01916589f, 0.13685240f, 0.02504921f, -0.05401176f, 0.12547800f, -0.02572674f, -0.01661612f, 
    0.01039624f, -0.03573587f, 0.07794156f, 0.03852910f, -0.19224069f, -0.02029655f, 0.04826550f, 0.10568731f, 
    0.22976233f, 0.34008548f, 0.10943352f, 0.27435380f, 0.03047557f, 0.40988994f, 0.09870639f, 0.26127857f, 
    0.02116870f, -0.05965320f, 0.21185173f, 0.09877513f, -0.04318475f, 0.01601721f, 0.03093222f, -0.16778089f, 
    -0.01590114f, 0.00881289f, 0.35520875f, -0.06435242f, -0.22026215f, 0.03688782f, 0.14819255f, -0.17468931f, 
    0.16629878f, 0.14819928f, 0.11630215f, 0.22624369f, 0.09510994f, 0.05115700f, 0.03804571f, -0.12999171f, 
    -0.03430508f, -0.05538885f, -0.16929176f, 0.03691597f, -0.17550708f, 0.00357039f, 0.07729214f, -0.15324335f, 
    0.19568919f, -0.04238367f, -0.09845498f, -0.24151893f, 0.15357424f, 0.04073142f, 0.06240862f, -0.12093586f, 
    0.14267500f, -0.04070472f, 0.04006742f, 0.09644441f, 0.04664426f, -0.00642189f, 0.02436245f, -0.18388711f, 
    -0.00490347f, -0.14028883f, 0.04306404f, 0.09781961f, 0.10657975f, 0.17660536f, -0.08670105f, 0.08858843f, 
    -0.03354491f, 0.06172008f, -0.12123482f, -0.22230895f, -0.18152848f, -0.11920142f, -0.06608222f, -0.08521566f, 
    0.09290708f, -0.02422093f, -0.03281457f, -0.14673510f, -0.22129534f, -0.30154952f, -0.13715248f, 0.14354113f, 
    0.08513813f, 0.03389956f, -0.09372003f, -0.04511074f, 0.03343781f, 0.03782585f, 0.14407191f, 0.22599488f, 
    0.01178986f, 0.00268978f, 0.22432517f, -0.25619608f, -0.13643116f, -0.01217958f, 0.05494571f, -0.27932981f, 
    0.10060684f, 0.08526386f, 0.20415001f, 0.06628068f, 0.06678217f, 0.02315981f, 0.30753791f, 0.11530211f, 
    -0.01334290f, 0.05559827f, 0.22134241f, -0.01453120f, 0.11524475f, -0.17448811f, 0.15377678f, 0.18086018f, 
    0.08462323f, -0.09890264f, 0.45667100f, -0.18546085f, -0.07748557f, -0.28294730f, -0.17946807f, 0.04006436f, 
    -0.05921566f, 0.06674094f, 0.17654891f, 0.07599475f, 0.13418922f, 0.11868885f, 0.18670331f, 0.23328435f, 
    -0.05781116f, -0.06856845f, -0.11794766f, -0.08571447f, 0.10468675f, -0.01255047f, 0.19224817f, 0.17180797f, 
    -0.16442508f, -0.04963660f, 0.01620600f, 0.06823488f, 0.04243619f, 0.10187311f, -0.12810521f, 0.15420033f, 
    -0.14911996f, -0.11970689f, -0.08093774f, -0.16564327f, -0.05653538f, 0.21044771f, -0.04784436f, -0.01843841f, 
    0.12719284f, -0.01739659f, -0.02461606f, 0.03614158f, -0.09704835f, -0.12865715f, -0.04217855f, 0.15698411f, 
    -0.13419454f, 0.10090680f, 0.03149519f, 0.15711008f, -0.08760259f, -0.01508220f, -0.17858118f, 0.04020774f, 
    0.04516267f, 0.07041252f, -0.02782589f, 0.01315288f, -0.01100339f, 0.05834714f, 0.23644692f, 0.04052826f, 
    0.12056208f, -0.12445521f, -0.09454340f, 0.02478513f, -0.05329869f, 0.11158942f, 0.27278593f, -0.06519662f, 
    -0.14950724f, -0.08057068f, -0.21400189f, -0.08873567f, -0.08640989f, 0.12004595f, -0.00576196f, 0.13955696f, 
    0.21591960f, 0.35623419f, 0.13452396f, 0.14497389f, -0.68608773f, 0.27784124f, 0.14635116f, -0.08734271f, 
    0.07565518f, 0.13865075f, 0.09422632f, 0.18043421f, -0.17609328f, -0.05084800f, -0.00832506f, 0.10294588f, 
    -0.06992219f, 0.11838868f, -0.01028363f, -0.03354767f, -0.04387837f, 0.08442703f, 0.23051520f, 0.07662410f, 
    -0.00924141f, 0.10968336f, 0.02974978f, 0.04378378f, -0.03222337f, -0.10684024f, -0.14959119f, -0.31721449f, 
    -0.03620514f, 0.07329497f, 0.00049114f, 0.15997659f, -0.14835115f, -0.11315452f, 0.13510190f, -0.40795031f, 
    0.13172728f, -0.26039952f, -0.02253667f, 0.37048557f, 0.00261226f, 0.12415834f, 0.18306102f, -0.17058943f, 
    -0.02879054f, 0.00288169f, 0.00024103f, 0.03091637f, -0.07802705f, -0.13310647f, 0.07593192f, 0.05647448f, 
    -0.03669846f, -0.16798225f, 0.25887775f, 0.09068830f, 0.15129595f, 0.15543954f, 0.05285843f, -0.06816632f, 
    0.00116385f, 0.05364327f, 0.13286971f, 0.26440266f, -0.17089978f, -0.05021678f, 0.04822154f, 0.19947250f, 
    -0.14146139f, -0.19538851f, -0.13492772f, -0.21063402f, -0.16389947f, -0.02936508f, 0.15457565f, 0.23436297f, 
    0.07990614f, 0.01306663f, -0.06370423f, -0.17543930f, 0.07622905f, 0.27719721f, 0.08826248f, 0.20530586f, 
    0.08403287f, -0.13824034f, -0.28413197f, -0.26013935f, -0.07715452f, 0.07423166f, 0.17942084f, -0.01490694f, 
    0.03355668f, 0.19013864f, -0.06330163f, -0.09228304f, 0.04358570f, -0.11147844f, -0.11294197f, 0.00793654f, 
    0.03364240f, 0.06069575f, 0.01774681f, 0.01114061f, 0.02474229f, 0.16201399f, -0.04937615f, 0.06618319f, 
    0.25112432f, 0.00026070f, 0.29796278f, 0.10124543f, 0.06657405f, 0.10630323f, 0.05019072f, 0.02124507f, 
    -0.00990972f, 0.05107038f, -0.01775487f, -0.07860719f, 0.04077453f, 0.05131514f, 0.14620331f, 0.09629335f, 
    0.03284771f, -0.14485091f, -0.18839255f, 0.00739466f, -0.03852100f, 0.09641936f, 0.18251699f, 0.05163877f, 
    -0.02599849f, 0.14330572f, 0.01871503f, 0.12131499f, -0.15196605f, -0.02539356f, 0.03539829f, -0.19687083f, 
    0.05900503f, -0.18779059f, -0.07643899f, -0.22329704f, -0.08524156f, 0.25944099f, 0.00740127f, 0.03161585f, 
    0.41600159f, 0.06837139f, -0.08007970f, -0.08941554f, -0.18204893f, 0.09529144f, -0.03131266f, 0.08398338f, 
    0.02216654f, -0.06213417f, -0.05359226f, -0.03876070f, 0.00485940f, 0.02977317f, 0.01310141f, -0.06969337f, 
    -0.01671606f, 0.00474369f, 0.00827897f, -0.05218507f, 0.03422616f, 0.04611032f, -0.05862423f, 0.02457107f, 
    0.03190272f, 0.01573623f, -0.02014257f, 0.04275237f, 0.05822662f, -0.05591188f, 0.02682911f, 0.01146554f, 
    -0.01814022f, -0.00624799f, -0.05797523f, 0.01485873f, -0.07621474f, -0.01644825f, 0.04347046f, -0.00178269f, 
    0.00052539f, 0.01700626f, 0.02675672f, 0.04477910f, -0.05844397f, -0.05865217f, -0.05699475f, -0.06587172f, 
    -0.07482912f, -0.04551789f, -0.05361266f, 0.00498770f, 0.02181577f, 0.02838426f, 0.06085598f, -0.04852036f, 
    -0.05493672f, 0.06045035f, -0.03394089f, 0.06243691f, -0.03545102f, -0.06266602f, 0.01290193f, -0.04481386f, 
    -0.00477389f, -0.04694950f, 0.00127650f, -0.03231434f, -0.06928118f, -0.02090261f, -0.05833102f, -0.02753411f, 
    0.05993084f, -0.05960728f, 0.06165508f, -0.03705471f, -0.00204431f, -0.02145206f, -0.05965095f, 0.01896004f, 
    -0.06804651f, -0.05446134f, -0.02885216f, -0.03181538f, 0.05289483f, 0.01526665f, -0.05039404f, -0.05640014f, 
    -0.01929329f, 0.04079787f, -0.05071199f, 0.00796659f, 0.00401654f, -0.06596857f, 0.02127224f, 0.00608535f, 
    0.01331309f, -0.00499443f, 0.05409998f, -0.05173513f, 0.03496137f, -0.06444101f, -0.04056235f, 0.07083256f, 
    -0.05701418f, 0.02674139f, 0.02034308f, -0.06824276f, 0.02960355f, -0.02657368f, 0.00212615f, -0.01430286f, 
    -0.07606344f, -0.03892905f, -0.02967943f, -0.03370827f, -0.04560264f, 0.05532930f, 0.02841563f, -0.04347078f, 
    -0.06371279f, -0.02745387f, 0.04886294f, -0.07255244f, 0.00547113f, -0.06563845f, 0.04003339f, 0.05324133f, 
    -0.02848826f, -0.07459038f, -0.05394499f, -0.01578481f, -0.05752769f, 0.01513038f, 0.05645459f, -0.07146689f, 
    -0.04590268f, -0.00659217f, -0.06257106f, -0.00415742f, 0.00727009f, -0.06073261f, -0.01408534f, -0.05480247f, 
    -0.06700551f, -0.06863105f, -0.00344273f, 0.04758744f, 0.05603258f, -0.04869017f, -0.04271840f, 0.04545516f, 
    0.05531623f, 0.03748927f, 0.02693998f, -0.03355397f, -0.05286639f, 0.04712190f, 0.00149918f, -0.02860820f, 
    0.05356919f, -0.00820816f, 0.03126869f, 0.03497551f, 0.02177943f, 0.04440016f, -0.02303322f, 0.00879127f, 
    0.02993441f, -0.07214683f, 0.06183647f, -0.05978430f, -0.06621550f, -0.06879479f, -0.02207268f, -0.05271246f, 
    -0.04220330f, 0.02392521f, -0.06543278f, 0.04333846f, -0.00613546f, 0.03866136f, -0.01419057f, -0.05796225f, 
    -0.06726128f, 0.00172023f, 0.02445372f, -0.01604867f, -0.01975679f, -0.05403224f, -0.00431242f, 0.06509897f, 
    -0.00579718f, -0.04030201f, -0.04468646f, 0.04307589f, -0.06805409f, 0.02669317f, -0.02908878f, -0.06361656f, 
    0.10325050f, -0.09871047f, -0.09905976f, 0.00179683f, 0.11460995f, 0.01101733f, 0.14169443f, 0.05408236f, 
    -0.12319215f, 0.06140786f, -0.00227463f, 0.04367705f, 0.21999730f, 0.04052931f, -0.23348792f, -0.05516528f, 
    0.03605917f, 0.12949483f, 0.07176865f, -0.11272030f, -0.01149119f, -0.09709358f, -0.18669227f, -0.02224462f, 
    0.04379082f, 0.13941364f, 0.24992579f, 0.13973503f, -0.18005662f, 0.00323118f, -0.02627666f, -0.01119092f, 
    -0.04319440f, 0.04398158f, -0.08630618f, 0.13183597f, 0.73522246f, 0.14748240f, -0.05091546f, 0.37726769f, 
    0.05097546f, -0.15108077f, 0.24619254f, -0.12290860f, -0.01439609f, -0.03543089f, 0.09123316f, -0.06746563f, 
    -0.18611631f, -0.11062676f, 0.38132823f, 0.04203250f, -0.05913299f, 0.02833451f, -0.09921892f, -0.03239118f, 
    0.02898424f, 0.04713768f, -0.02929181f, 0.11939076f, 0.17489795f, 0.19949415f, 0.00704847f, 0.07772768f, 
    0.15781830f, -0.19895841f, -0.00542818f, -0.03849767f, -0.05818759f, 0.00409349f, -0.06718691f, 0.00208792f, 
    0.02807635f, 0.20296173f, -0.01346286f, -0.49057245f, 0.22234976f, 0.03541676f, -0.00924381f, 0.14393926f, 
    -0.06029214f, -0.05726414f, -0.05998620f, -0.11956871f, 0.26137063f, 0.18303993f, -0.07852750f, 0.01503762f, 
    0.00087678f, 0.15753490f, -0.12140981f, -0.07953022f, 0.00243206f, -0.05297205f, -0.03217093f, 0.12654303f, 
    0.10848002f, -0.01964048f, -0.19799837f, -0.26732695f, 0.01199114f, -0.08942867f, -0.05183616f, -0.24585277f, 
    -0.05619340f, 0.05628355f, -0.20691979f, -0.02791280f, 0.26511872f, -0.07317306f, -0.19061743f, -0.13222523f, 
    0.11893478f, 0.03490934f, 0.05244737f, 0.17947368f, -0.06834627f, -0.07924163f, -0.03631643f, -0.08645448f, 
    0.00893756f, 0.24396607f, 0.30104256f, 0.05668915f, 0.06307134f, -0.17843455f, -0.03668463f, -0.06283887f, 
    0.14993526f, -0.10973945f, 0.04313950f, 0.10156969f, -0.15050374f, 0.20322280f, 0.24413976f, 0.06394532f, 
    -0.09375530f, -0.00812554f, 0.01145362f, -0.21098845f, 0.01336620f, -0.09844337f, 0.05262692f, 0.00034980f, 
    -0.34358022f, -0.09064736f, 0.03525971f, -0.01535313f, -0.17911164f, -0.24705012f, -0.02888356f, -0.06879547f, 
    -0.12761025f, -0.03196733f, 0.03010840f, 0.16721809f, 0.30187836f, -0.05347573f, 0.12072895f, 0.14091128f, 
    0.02943510f, 0.16777289f, -0.00356573f, -0.02005984f, -0.10105361f, 0.02472814f, 0.06074509f, 0.17419036f, 
    0.02503304f, -0.14881060f, 0.04201947f, -0.05095269f, 0.02245213f, 0.05497951f, -0.02566520f, 0.22700860f, 
    -0.14187074f, 0.08788425f, 0.13886175f, -0.22029458f, 0.24740037f, -0.09298827f, 0.04029175f, -0.23069714f, 
    -0.18724638f, -0.10499015f, 0.15323846f, 0.02550125f, -0.05950289f, -0.05782565f, -0.04155459f, 0.08305643f, 
    0.09429900f, 0.21035199f, -0.11520880f, -0.20633534f, 0.01918807f, -0.02954087f, 0.03052841f, -0.04073576f, 
    0.09148274f, 0.05410669f, -0.03199647f, 0.05611967f, 0.13942204f, -0.29960427f, -0.19660155f, 0.15372559f, 
    -0.07773830f, 0.28330192f, 0.00955478f, 0.20373650f, -0.05799290f, 0.05225278f, 0.11726016f, 0.02056233f, 
    -0.24616207f, -0.11945861f, -0.25187346f, -0.10722962f, 0.01786495f, 0.03748848f, -0.01736797f, -0.00409819f, 
    0.06705771f, -0.04480456f, -0.05209900f, -0.18914494f, -0.21329090f, -0.21569578f, -0.20306394f, -0.02429673f, 
    -0.07536373f, 0.12688823f, 0.18393792f, 0.39040136f, -0.23068836f, 0.17138554f, 0.10799092f, 0.06236158f, 
    -0.31188709f, -0.14072865f, -0.24896686f, -0.00225149f, -0.04331813f, 0.03607359f, 0.15605177f, -0.02092649f, 
    -0.06465670f, 0.09744954f, 0.16130967f, -0.10975443f, -0.02544217f, 0.15052116f, 0.05560135f, 0.11392242f, 
    0.26648214f, -0.08848012f, -0.14473236f, -0.10609172f, 0.02983168f, -0.00569904f, 0.13417718f, 0.05695165f, 
    -0.01075602f, 0.24861008f, 0.47171384f, 0.00244289f, 0.04138660f, -0.05436760f, 0.24258523f, 0.27098975f, 
    0.05096288f, 0.11172913f, -0.09234336f, -0.02977675f, 0.07601900f, 0.12541346f, -0.01985723f, -0.07000948f, 
    0.09755251f, 0.17369589f, 0.17449005f, 0.02866217f, -0.04689778f, -0.14201935f, -0.01818394f, -0.11195032f, 
    0.07389396f, 0.04174536f, 0.08316246f, 0.24155405f, 0.10307382f, 0.06533787f, -0.03384672f, 0.41138005f, 
    -0.07688572f, -0.04734412f, -0.03532976f, 0.07181071f, 0.02859070f, 0.13692524f, 0.07733023f, -0.06429684f, 
    0.04653771f, -0.03142092f, -0.00995656f, 0.10976487f, 0.16394050f, 0.03902870f, 0.07655646f, -0.03963467f, 
    0.10101433f, -0.02527288f, 0.06600813f, 0.15367585f, 0.24971318f, 0.02978995f, -0.05935143f, 0.06723770f, 
    -0.08387687f, 0.08926625f, -0.10189106f, 0.01244185f, 0.21873659f, -0.04497939f, 0.25796166f, -0.15220821f, 
    0.19451027f, 0.07805787f, -0.10762331f, 0.06203590f, -0.14053519f, 0.24268998f, -0.05240991f, 0.01900592f, 
    -0.13684121f, 0.21921656f, -0.18836211f, 0.45089364f, 0.03721222f, 0.08459067f, -0.06324527f, 0.01789646f, 
    0.05256946f, -0.07347383f, -0.08789879f, -0.08812794f, -0.19324063f, -0.09526680f, -0.45575288f, -0.33316410f, 
    0.00814272f, 0.21234867f, 0.01307915f, 0.00582735f, 0.02218725f, 0.20116109f, -0.02897563f, -0.09379812f, 
    -0.08422537f, 0.09843034f, -0.14491023f, -0.08232155f, 0.00400156f, 0.02922316f, -0.05772957f, -0.15403126f, 
    0.10005228f, 0.15780672f, -0.17522417f, 0.09474517f, -0.14838603f, -0.27904108f, 0.04964085f, -0.04004171f, 
    0.05306109f, -0.02472440f, -0.21467546f, -0.08910549f, 0.25968719f, 0.20601051f, 0.16988260f, 0.13118394f, 
    -0.06131007f, 0.06431270f, -0.04845634f, -0.05479538f, -0.01522976f, -0.03215206f, -0.05203970f, 0.00478179f, 
    0.05295631f, 0.04499657f, -0.05423753f, -0.02761128f, 0.01093845f, 0.03072680f, -0.01666821f, -0.02372510f, 
    -0.00374005f, 0.02527006f, -0.06606378f, 0.00910067f, -0.04886869f, 0.05572209f, 0.06082488f, -0.05525494f, 
    -0.04531594f, -0.05779087f, -0.02835129f, -0.04399123f, 0.00072309f, -0.05440570f, 0.02713316f, 0.02225882f, 
    0.04167810f, 0.05647961f, -0.03133515f, -0.00835622f, -0.03732734f, 0.01281968f, -0.07285862f, 0.05703797f, 
    -0.07144285f, -0.03864477f, -0.03279059f, -0.02523437f, -0.00027921f, -0.06979993f, 0.00919011f, 0.00581131f, 
    -0.03412936f, -0.02097390f, -0.05450377f, -0.03990615f, 0.00983272f, 0.06260549f, -0.03614524f, -0.03571899f, 
    -0.03127911f, -0.05216458f, -0.06995559f, -0.00780299f, 0.06208904f, 0.03687556f, 0.05209651f, -0.05596902f, 
    0.06558380f, 0.02486360f, -0.01749422f, -0.05418856f, 0.03578674f, -0.04460084f, 0.00337480f, 0.02817111f, 
    -0.06132277f, -0.01936030f, 0.01029225f, -0.01568140f, -0.05561359f, -0.00285837f, -0.03012248f, -0.02036097f, 
    -0.01280213f, -0.03451407f, -0.01924786f, -0.00428694f, 0.02966237f, 0.00083319f, 0.01877230f, -0.01263345f, 
    0.05942557f, 0.02155755f, 0.02423765f, -0.06401295f, 0.07036389f, -0.06078136f, -0.06824712f, -0.02941374f, 
    0.04098469f, -0.07194577f, -0.05620801f, -0.05694102f, 0.04048462f, 0.03862628f, -0.04618727f, 0.02473729f, 
    0.03514656f, -0.05335858f, -0.01581935f, -0.04578154f, 0.00265742f, -0.03072151f, -0.06289693f, -0.03398861f, 
    -0.00256743f, -0.06738362f, -0.01344143f, -0.04402020f, -0.07231344f, 0.01246236f, 0.00438867f, -0.06913070f, 
    -0.04947791f, 0.05030825f, 0.03738791f, -0.03143343f, 0.01027670f, 0.02230710f, -0.04562002f, -0.00265855f, 
    0.03868755f, 0.04187031f, -0.03079756f, -0.00250754f, 0.00424124f, -0.01487878f, -0.04677810f, 0.01353223f, 
    0.05477116f, -0.05409282f, -0.02010307f, 0.00856613f, -0.04029960f, 0.06458657f, -0.01493284f, 0.02168364f, 
    -0.05611338f, 0.00992003f, 0.01578848f, -0.07221452f, 0.04977181f, -0.03937924f, 0.05443600f, 0.06542750f, 
    -0.05288522f, 0.04703428f, -0.06176134f, -0.05561668f, -0.02415550f, 0.06451144f, 0.04757574f, -0.06079136f, 
    0.03881202f, -0.00038927f, -0.01967228f, 0.05606081f, 0.02262761f, -0.06705519f, -0.00642229f, -0.01377836f, 
    0.01303572f, 0.02389493f, 0.02300775f, 0.03875275f, -0.07148968f, 0.04290522f, -0.05340740f, -0.01807827f, 
    0.00575481f, -0.05763972f, -0.03205512f, -0.02490949f, -0.00160847f, -0.00834392f, -0.02632003f, 0.05620893f, 
    0.06832376f, 0.00087335f, -0.03593194f, -0.05122078f, -0.04502649f, -0.05557372f, -0.02000408f, 0.03296324f, 
    -0.25493139f, -0.32361570f, 0.26345319f, 0.08587457f, 0.00838553f, 0.07127913f, 0.07714148f, 0.11876938f, 
    0.09682504f, -0.00852881f, -0.01228204f, 0.10787731f, -0.14959429f, 0.39105052f, 0.00158167f, 0.14466603f, 
    0.17527506f, 0.13603902f, 0.16309379f, 0.06559056f, 0.04151563f, -0.07251494f, -0.03361329f, 0.01099202f, 
    0.19563746f, -0.15001936f, -0.01560047f, -0.01649662f, 0.02358935f, -0.08559330f, -0.07133900f, -0.02473015f, 
    0.11656902f, -0.02336537f, 0.08190256f, 0.06658928f, 0.11248238f, 0.06979163f, -0.00916737f, 0.04484054f, 
    0.09107642f, -0.02120328f, -0.09222322f, -0.15544955f, 0.25335726f, -0.04215349f, 0.00903089f, -0.03698286f, 
    0.34444764f, -0.04930014f, -0.12734789f, 0.01259425f, 0.07590674f, 0.08448385f, -0.21044709f, 0.13749006f, 
    0.18588692f, 0.15191413f, 0.09286214f, -0.01468451f, -0.27077067f, -0.03322384f, -0.17691274f, 0.01453796f, 
    -0.00014230f, 0.18191321f, 0.08527459f, -0.15349904f, -0.09735119f, -0.00183404f, -0.07484791f, 0.09616665f, 
    -0.32638943f, -0.17935449f, -0.08632973f, 0.12459535f, -0.01466378f, 0.07932232f, -0.04396186f, 0.12913100f, 
    0.03497752f, 0.13642192f, -0.03511661f, 0.05810389f, -0.35182104f, 0.06163855f, -0.08986362f, -0.15805577f, 
    0.05850996f, 0.07317133f, 0.03103573f, -0.19804761f, 0.06636252f, -0.04346427f, -0.00617815f, -0.07959341f, 
    -0.41968730f, -0.07574350f, -0.39735371f, -0.24000539f, 0.25023472f, -0.01244047f, 0.16785291f, -0.36115241f, 
    0.01735356f, -0.09363528f, 0.02626251f, 0.09532794f, 0.01575427f, -0.10088613f, 0.08818658f, -0.20542453f, 
    -0.10341464f, 0.09832249f, 0.04948532f, 0.01244432f, 0.12375323f, 0.03356174f, 0.07104883f, -0.08398601f, 
    -0.08941653f, -0.03716697f, -0.31826681f, -0.11507801f, -0.05033902f, 0.02513420f, -0.01661013f, 0.00668580f, 
    -0.09651929f, -0.09538498f, -0.10363029f, 0.04769239f, 0.08539064f, 0.08696020f, -0.18576363f, 0.03537706f, 
    -0.01080021f, 0.09936668f, 0.00757049f, 0.03231455f, 0.09747843f, 0.01634170f, -0.01390609f, 0.03804877f, 
    0.53629142f, -0.00527289f, -0.11828487f, -0.37928683f, 0.01956207f, -0.06597453f, -0.02305734f, -0.19518095f, 
    0.10508135f, -0.09595618f, -0.05615008f, 0.11759652f, -0.40551567f, 0.42793569f, 0.33125073f, -0.04960537f, 
    0.06201797f, -0.14564882f, -0.05337589f, 0.13886788f, 0.16273014f, -0.02763310f, 0.06170155f, 0.05492699f, 
    -0.31239420f, -0.24307625f, -0.00950178f, -0.19135378f, 0.29632801f, -0.21556401f, 0.05851756f, 0.22000457f, 
    0.05408676f, 0.05446714f, -0.04232259f, -0.01040970f, -0.06541523f, -0.06241915f, 0.27388102f, 0.22680983f, 
    -0.12065506f, -0.16034545f, -0.13885726f, -0.01413803f, 0.18555540f, 0.04371260f, 0.32332134f, 0.24312906f, 
    -0.01999377f, -0.05830688f, -0.06011105f, 0.03755170f, -0.07017974f, 0.00135209f, -0.04959299f, 0.00204037f, 
    0.03762590f, -0.01441386f, 0.03700915f, -0.06400664f, -0.00649521f, -0.01662057f, -0.03257938f, 0.00800308f, 
    -0.03260982f, -0.04419282f, -0.05333005f, 0.00638331f, 0.05049238f, -0.03532902f, -0.03042461f, -0.03187530f, 
    -0.07364945f, 0.05570651f, 0.03989363f, 0.02833777f, 0.03641285f, -0.06957225f, 0.04137537f, -0.01334761f, 
    -0.01077619f, 0.03950501f, -0.00777880f, -0.02716044f, -0.02747583f, -0.05114692f, 0.03377822f, -0.05080450f, 
    -0.05616793f, 0.01704250f, -0.03130533f, -0.01917697f, -0.00379940f, -0.06220656f, -0.02719583f, 0.02419140f, 
    -0.01486944f, 0.01379497f, 0.05762239f, -0.00841985f, -0.02872934f, -0.04173479f, -0.01858705f, -0.06524288f, 
    -0.02933790f, 0.04901367f, 0.00529555f, -0.05255441f, 0.00703864f, -0.06344590f, 0.00932414f, -0.05199419f, 
    -0.01658052f, -0.00886426f, -0.01738403f, 0.06432623f, 0.04860623f, -0.04283842f, -0.03425404f, -0.00016951f, 
    -0.01036940f, -0.00720476f, -0.01784837f, 0.02857775f, 0.04401477f, -0.04568349f, 0.05636669f, -0.05418651f, 
    0.00403617f, -0.01970756f, -0.05992764f, -0.03906258f, -0.04478840f, 0.04314171f, -0.01744682f, -0.06172421f, 
    0.04131443f, 0.04038201f, -0.07601598f, -0.03859632f, 0.02900552f, -0.06080982f, 0.00057924f, -0.06406128f, 
    -0.04363848f, 0.02871185f, -0.06884749f, -0.06758614f, -0.05664056f, 0.04464412f, -0.00934414f, 0.02816795f, 
    0.00042298f, -0.05039540f, 0.02568400f, -0.02089012f, 0.02542267f, 0.03568107f, 0.02621296f, 0.04107111f, 
    -0.02082004f, 0.01739378f, -0.06563891f, -0.02675134f, 0.01725497f, 0.05204009f, -0.05195422f, 0.06482247f, 
    0.00264129f, -0.07505316f, 0.00255355f, 0.05673971f, -0.04356199f, -0.05937795f, 0.01987773f, -0.05908177f, 
    -0.03366500f, 0.05880114f, -0.04006373f, 0.00565483f, 0.03148277f, -0.05572686f, -0.03653943f, 0.01428874f, 
    0.06527399f, -0.00273868f, -0.05184584f, -0.07088450f, -0.03219893f, 0.05737100f, 0.00801253f, -0.05936428f, 
    0.04234762f, -0.01060984f, 0.03998430f, 0.03377857f, 0.02277016f, -0.02973497f, 0.00674344f, 0.01757299f, 
    -0.01915725f, 0.00567017f, -0.02761350f, -0.02408892f, -0.02448794f, -0.06989869f, -0.03300771f, -0.05222344f, 
    -0.01943482f, -0.01968690f, -0.06252985f, 0.06143311f, 0.02635954f, 0.01545897f, -0.07564549f, 0.04004075f, 
    0.06518388f, -0.06581160f, 0.02989992f, -0.03574312f, -0.05661996f, 0.00009112f, 0.03604320f, -0.02448324f, 
    0.00579202f, 0.02377330f, 0.01574033f, -0.04532506f, 0.05911171f, -0.02214908f, -0.06773613f, -0.02494699f, 
    0.06264408f, 0.01416933f, -0.02432762f, 0.05121433f, -0.06733994f, 0.00149536f, -0.07802903f, 0.04531659f, 
    -0.22151762f, -0.18805841f, 0.00935471f, 0.01008528f, 0.05849924f, -0.02023237f, 0.01382608f, 0.01875532f, 
    0.01919867f, 0.12997842f, -0.13019980f, 0.07153542f, -0.00586623f, -0.06518453f, -0.13097055f, 0.37402627f, 
    0.04736377f, 0.13040939f, 0.18793716f, 0.04428100f, 0.05695228f, -0.11057027f, 0.10030439f, 0.05194144f, 
    -0.07429085f, 0.09943679f, -0.13466631f, -0.06729350f, 0.02895495f, -0.03071133f, -0.04128595f, -0.03965198f, 
    0.05766562f, 0.06337955f, -0.03481850f, -0.01023291f, -0.07098603f, 0.73464978f, -0.19099702f, 0.33901227f, 
    -0.04922536f, 0.00490954f, 0.21169277f, -0.07269543f, -0.11708077f, 0.14521050f, 0.04339242f, -0.06937818f, 
    -0.13373977f, -0.04233350f, -0.16417459f, 0.01396780f, 0.15138830f, 0.05898582f, 0.07765286f, 0.02871352f, 
    0.00513795f, 0.14578696f, -0.00793838f, -0.05023585f, -0.01962576f, 0.08524564f, 0.14733575f, -0.07276540f, 
    0.01195368f, 0.09342287f, 0.01815937f, -0.01327388f, -0.03494855f, -0.02401385f, 0.07826322f, 0.01931785f, 
    0.25240138f, -0.00351630f, 0.31439847f, 0.07157603f, -0.00644748f, 0.07685387f, 0.19114427f, 0.06419398f, 
    0.00199861f, 0.09694158f, -0.11784122f, -0.07490882f, -0.00128017f, -0.14600362f, 0.02997071f, -0.00498658f, 
    0.08438071f, 0.02817477f, 0.12192149f, -0.02753171f, -0.08772475f, -0.10002397f, -0.14289764f, 0.01794767f, 
    -0.03594195f, -0.24258153f, -0.07965344f, 0.20154805f, 0.06375413f, 0.17997679f, -0.06837512f, 0.05989191f, 
    -0.02969679f, -0.07946052f, -0.08688372f, -0.04634077f, -0.11295740f, -0.09072547f, 0.13263184f, 0.09272758f, 
    0.11141926f, 0.10742381f, 0.03238268f, -0.00350472f, 0.06552169f, -0.01658009f, 0.03608112f, 0.01634287f, 
    0.27758670f, -0.15326998f, 0.12233379f, -0.15602751f, 0.00158362f, -0.02686007f, 0.00759611f, 0.00995869f, 
    -0.07636112f, 0.06513847f, 0.01489770f, -0.04744905f, 0.11280032f, 0.04991544f, 0.21194755f, -0.04050684f, 
    -0.09130664f, 0.10329152f, -0.18858892f, 0.06220802f, 0.06529376f, 0.22141340f, -0.02437319f, 0.00397348f, 
    0.05929518f, 0.03649692f, 0.26513657f, -0.16192974f, 0.02153009f, 0.01338881f, -0.04310624f, -0.06312995f, 
    0.07460527f, -0.05942474f, -0.00502808f, -0.00385564f, -0.05805622f, -0.15847434f, 0.02456363f, -0.00347985f, 
    0.10851850f, -0.03200196f, 0.14433320f, 0.03872959f, 0.05547296f, 0.09923034f, 0.07593381f, 0.04458735f, 
    -0.00085071f, 0.04997808f, -0.10802511f, -0.06854158f, 0.18301634f, -0.14473490f, -0.16839111f, -0.10577346f, 
    0.00006730f, 0.06598602f, -0.02702927f, -0.04552968f, 0.06973130f, -0.22402187f, -0.05987678f, -0.35461426f, 
    0.04812650f, 0.06943306f, -0.08563121f, -0.00094414f, 0.05217328f, 0.24786283f, 0.12619747f, 0.22773665f, 
    0.24377811f, 0.09338178f, 0.02559398f, -0.17853171f, 0.07671656f, 0.12098139f, -0.08580746f, -0.05112680f, 
    0.26092142f, -0.08899069f, -0.07537729f, -0.18381889f, 0.15162048f, 0.03468698f, -0.10166456f, 0.00704659f, 
    0.08935548f, -0.02589425f, 0.01553855f, 0.01237096f, -0.01996717f, 0.06336570f, -0.04806130f, 0.18665163f, 
    -0.15831500f, -0.35951185f, -0.18185024f, -0.01635865f, 0.01345572f, 0.02899874f, 0.03590857f, -0.03634197f, 
    0.12324901f, -0.03170757f, 0.08265348f, 0.11863942f, 0.08901863f, -0.30646914f, -0.22038400f, -0.03063092f, 
    0.08282331f, -0.03746516f, 0.19696470f, 0.03738549f, 0.01453298f, 0.21651562f, 0.06865613f, 0.06117858f, 
    -0.10850491f, 0.02787972f, -0.11870990f, -0.24278870f, 0.04420809f, 0.09584359f, -0.10265572f, 0.10517316f, 
    0.03819259f, 0.13045886f, 0.14058684f, 0.27826956f, -0.43231699f, -0.36968681f, 0.20111525f, 0.15784883f, 
    -0.06962745f, 0.10785192f, -0.26963836f, 0.07146876f, 0.00923907f, -0.30154532f, -0.08749485f, -0.11043513f, 
    0.18373737f, 0.24043705f, 0.14638907f, 0.04821737f, -0.06038532f, -0.06438322f, -0.04972713f, -0.04092880f, 
    0.19457760f, 0.07560003f, -0.11467512f, -0.00031963f, 0.11669976f, 0.11141325f, -0.13576685f, 0.10208654f, 
    0.23427831f, 0.15089592f, 0.04381609f, 0.14990149f, -0.02139019f, 0.06486345f, 0.04233266f, 0.04829251f, 
    0.18305247f, 0.28352675f, -0.01375653f, 0.12247709f, 0.01597316f, 0.10667720f, 0.01360662f, 0.23034768f, 
    0.03007152f, 0.05821794f, 0.00479188f, 0.00789099f, 0.15602750f, 0.05006757f, -0.04233484f, 0.11363523f, 
    0.06814093f, 0.01430511f, 0.03952402f, -0.05874100f, -0.01968608f, -0.01669059f, 0.07630593f, 0.11864656f, 
    -0.55871731f, -0.23355825f, 0.27117395f, 0.20009899f, -0.11008619f, 0.04758102f, -0.21903947f, -0.14856660f, 
    -0.00661583f, -0.10312656f, -0.04993166f, -0.05857881f, -0.02531773f, -0.36729646f, 0.08530105f, 0.00841114f, 
    -0.03362448f, -0.04434707f, 0.01503308f, -0.12311841f, 0.05604056f, -0.14952931f, 0.02802259f, 0.03287139f, 
    -0.15340215f, -0.05716804f, -0.12369721f, 0.07729363f, -0.01264105f, -0.06571139f, -0.25808650f, 0.12349208f, 
    -0.00615087f, -0.03646610f, -0.02003230f, -0.13797614f, 0.04509062f, 0.07244235f, -0.04164184f, 0.26972908f, 
    -0.05705367f, -0.09671154f, 0.06863145f, -0.05518539f, 0.05923480f, -0.02535483f, -0.01512129f, 0.10802840f, 
    0.02422125f, 0.26573986f, -0.17123181f, -0.17936154f, 0.22806804f, -0.00874714f, -0.12953086f, 0.03587730f, 
    0.04129190f, -0.13314247f, -0.23604345f, -0.24426919f, -0.02078896f, -0.18040936f, -0.09081835f, 0.13431098f, 
    -0.05154146f, -0.00031822f, -0.12622868f, -0.02948931f, 0.04369006f, 0.03088370f, -0.05860881f, -0.04705199f, 
    0.05540618f, -0.19005869f, 0.05896967f, -0.14846115f, -0.13619620f, 0.03577049f, 0.07917666f, 0.18951672f, 
    -0.04803199f, -0.06019565f, -0.00274831f, -0.18802679f, -0.20982331f, 0.01212206f, -0.23291644f, -0.20278455f, 
    0.17059048f, -0.14174110f, 0.08764835f, -0.00657270f, 0.04896611f, 0.05098016f, -0.04067425f, 0.06993490f, 
    0.08557118f, -0.01476871f, 0.23238133f, -0.08644310f, -0.05274343f, 0.23023242f, -0.11542317f, 0.08442879f, 
    0.21355154f, -0.02861241f, 0.08809072f, 0.14036903f, -0.06100524f, 0.11461587f, 0.06779609f, -0.02108444f, 
    0.20130111f, 0.02983431f, 0.11753491f, 0.02292496f, -0.02730161f, 0.01590304f, 0.06320394f, 0.08488773f, 
    -0.07952616f, -0.09776940f, 0.36540097f, -0.28512034f, -0.21929161f, 0.13714735f, -0.19653174f, -0.26472875f, 
    0.16324615f, 0.05216087f, -0.06047082f, 0.16097718f, -0.41404009f, 0.14765751f, -0.35530096f, 0.03760194f, 
    0.12551790f, -0.23194478f, -0.02528056f, -0.13991131f, 0.14654377f, -0.01520473f, 0.02031724f, -0.29103923f, 
    0.14634237f, -0.10946504f, -0.00271672f, -0.00848921f, 0.22910103f, 0.01428691f, 0.07507119f, 0.02138962f, 
    0.07517155f, 0.17269316f, -0.08188347f, 0.06851076f, -0.04736953f, -0.12665604f, -0.09470002f, 0.11865816f, 
    0.02913723f, -0.05091496f, 0.07739721f, 0.03260938f, 0.06151034f, 0.06194486f, 0.03040800f, 0.15257496f, 
    -0.10334677f, 0.03120903f, -0.17826784f, 0.17103168f, -0.07117976f, 0.00729844f, 0.16011350f, 0.19733885f, 
    -0.06567072f, -0.02833375f, -0.04354028f, -0.06365290f, -0.12948827f, -0.11602655f, -0.09430978f, 0.36664969f, 
    0.08186437f, 0.04442042f, 0.06234854f, 0.12205893f, 0.08195727f, 0.12382729f, -0.03681096f, 0.06163748f, 
    -0.29864997f, 0.08896208f, -0.07049430f, 0.10280995f, -0.06677144f, -0.10985684f, -0.05160423f, -0.22417122f, 
    0.13198008f, -0.08661455f, 0.08929428f, -0.10445791f, -0.08014891f, -0.01834338f, -0.12160023f, -0.08605634f, 
    -0.02881441f, -0.14333434f, -0.06831553f, -0.34733713f, -0.04349791f, -0.04585167f, 0.00124168f, 0.01312965f, 
    -0.00332190f, 0.32025638f, -0.01205138f, 0.20922296f, 0.06048679f, -0.06919768f, 0.16025466f, 0.09825926f, 
    0.01995480f, 0.02640627f, 0.00144784f, -0.10065385f, 0.40916497f, -0.09943803f, 0.06379405f, 0.28805578f, 
    0.05634443f, -0.09056044f, -0.05914409f, -0.12245315f, 0.07485810f, -0.12043445f, -0.04677916f, 0.09101625f, 
    -0.15035914f, -0.09839749f, 0.11221694f, -0.01886644f, -0.17219761f, 0.32918829f, -0.18998252f, 0.20485052f, 
    -0.08783938f, -0.15718658f, -0.06598683f, -0.10545847f, 0.15860793f, 0.28656793f, -0.10971621f, -0.00743824f, 
    0.00447425f, -0.00825566f, -0.31124073f, -0.18003869f, -0.00500552f, -0.03035935f, 0.05932303f, 0.09045979f, 
    0.02188428f, 0.05329417f, 0.00479969f, 0.24506246f, 0.08783942f, 0.15862800f, 0.18701871f, -0.03401703f, 
    0.03869287f, -0.15293756f, 0.05557132f, 0.05615076f, 0.09835526f, 0.09479050f, 0.10934225f, -0.16715214f, 
    -0.16052033f, -0.00201334f, 0.13322245f, 0.05976500f, -0.04499846f, -0.01057664f, -0.16956182f, -0.09729269f, 
    -0.08705539f, -0.11612584f, -0.07429300f, -0.02068889f, -0.00537946f, -0.05881029f, 0.03260507f, 0.04199932f, 
    -0.27692354f, -0.24695241f, -0.04812015f, -0.13363126f, 0.41881990f, -0.30629951f, 0.20377050f, -0.06412525f, 
    -0.10573884f, 0.07081759f, -0.08993377f, 0.00657398f, 0.04907230f, -0.13376886f, -0.16306746f, 0.15471736f, 
    -0.07621624f, -0.11461166f, -0.05681536f, 0.11619056f, -0.03829578f, -0.09751654f, -0.07245254f, 0.17019287f, 
    0.14290042f, -0.07893997f, -0.02309162f, 0.13092251f, 0.07131157f, 0.01635585f, 0.08558936f, -0.09260322f, 
    0.06559215f, 0.09617706f, -0.06881309f, 0.04252155f, 0.00500377f, 0.05072543f, -0.00194676f, 0.23395042f, 
    -0.18427844f, 0.18538372f, -0.06782456f, -0.21969385f, 0.17396924f, -0.14487851f, -0.06557930f, 0.13446540f, 
    0.07794832f, 0.01453858f, 0.02652816f, -0.11661676f, 0.04181417f, 0.09743517f, -0.00467860f, -0.00766957f, 
    -0.08197271f, 0.04502604f, -0.14862922f, 0.06582253f, -0.06008163f, 0.02966608f, -0.26829425f, -0.15179284f, 
    0.09303893f, -0.01568876f, 0.33054385f, -0.01689437f, 0.12552819f, -0.00988776f, 0.06615938f, -0.08955000f, 
    -0.09673783f, 0.04888641f, -0.03155134f, 0.11006614f, 0.12762113f, -0.03140008f, -0.14465021f, -0.16996039f, 
    -0.06610060f, -0.06856849f, 0.09179063f, -0.04436114f, 0.10402922f, -0.05448521f, -0.03956096f, 0.00736595f, 
    -0.01030114f, -0.06520816f, 0.28168806f, 0.10229088f, -0.04738735f, 0.08474976f, 0.01009381f, 0.07633998f, 
    0.04815726f, -0.15059444f, 0.20359571f, 0.11984341f, -0.15546130f, -0.09638578f, 0.04246208f, -0.00411183f, 
    0.00939279f, -0.06173272f, 0.11238120f, 0.11189861f, -0.08350182f, 0.03799880f, 0.18089367f, 0.08091443f, 
    -0.01844191f, -0.26453850f, 0.15437917f, -0.06941289f, -0.03501956f, -0.15540507f, -0.03880242f, 0.08017038f, 
    -0.09834479f, -0.04883054f, 0.15379946f, 0.04365890f, -0.08045929f, -0.03737908f, -0.00340641f, 0.01780254f, 
    -0.02761244f, 0.04835870f, 0.09006378f, 0.23279226f, 0.09164058f, 0.13072374f, -0.19762287f, -0.10593621f, 
    0.01318394f, 0.05919595f, 0.06362858f, 0.10144705f, 0.11415499f, -0.02630874f, 0.26511133f, -0.09157806f, 
    -0.05781831f, 0.00082395f, 0.15691067f, 0.11841249f, -0.34634835f, -0.29539630f, -0.16417260f, 0.09697395f, 
    -0.11553412f, -0.10056424f, 0.10242340f, 0.13026735f, 0.17961052f, -0.08630604f, -0.01938602f, -0.07913567f, 
    -0.07532730f, -0.31697044f, 0.24096414f, -0.01606256f, -0.01824155f, -0.04885992f, 0.06086040f, -0.06007231f, 
    0.12806118f, -0.07722518f, -0.00536283f, 0.02004274f, -0.07374868f, 0.38392654f, 0.17316039f, 0.08911511f, 
    -0.06004957f, 0.27533299f, 0.06457268f, 0.06815314f, 0.14039165f, 0.10243199f, -0.03140610f, -0.10008509f, 
    -0.01660729f, -0.04654747f, 0.03970228f, 0.03045262f, -0.06118248f, -0.08161074f, 0.09035390f, 0.03311143f, 
    -0.00038289f, 0.01391161f, 0.21820553f, 0.18169966f, -0.12619241f, -0.55995232f, -0.03358992f, -0.19152749f, 
    0.20403665f, -0.06056193f, 0.00623487f, -0.18562764f, 0.27136445f, 0.02482779f, 0.02676953f, 0.20660661f, 
    0.26400682f, -0.06066471f, 0.08004330f, 0.03985147f, 0.06140642f, 0.06943545f, -0.02281744f, -0.05596817f, 
    0.23160267f, 0.19574521f, 0.04366488f, -0.10087788f, -0.02006689f, -0.17956327f, -0.27345657f, -0.02491229f, 
    0.09161375f, 0.06548176f, 0.09581424f, -0.04412497f, -0.02788265f, 0.00123479f, 0.07581173f, -0.05786575f, 
    -0.19974057f, -0.05114553f, -0.24887474f, 0.21195640f, -0.03379573f, 0.20913145f, -0.05768850f, 0.16846232f, 
    0.00126608f, 0.05947577f, 0.02141652f, 0.13396895f, -0.13528135f, 0.21744113f, 0.01984954f, -0.30325660f, 
    -0.09334715f, 0.11880881f, 0.11259995f, -0.04407355f, 0.05986935f, 0.03108200f, 0.12366256f, -0.08725926f, 
    -0.45479065f, 0.15759186f, -0.32432416f, -0.32464319f, 0.34267896f, -0.13227537f, 0.23002426f, -0.22715744f, 
    0.01145140f, -0.04377482f, -0.06642035f, 0.06791048f, 0.25052211f, -0.06589544f, 0.15673824f, -0.13406347f, 
    -0.06661155f, 0.09593800f, -0.03986612f, 0.15063436f, 0.06471118f, 0.03637948f, -0.04202883f, -0.11272143f, 
    0.12370915f, 0.01103555f, -0.32564709f, -0.11839442f, 0.11716993f, -0.04446126f, 0.09340061f, 0.17301810f, 
    -0.11088845f, 0.02114878f, -0.26028532f, 0.02686741f, 0.02875514f, -0.00136472f, -0.07227528f, 0.15577261f, 
    -0.00560436f, 0.03165604f, 0.04141274f, -0.09405610f, 0.01215034f, 0.02404772f, -0.05600119f, -0.01220288f, 
    0.16375700f, -0.10335395f, -0.20707710f, -0.41033423f, 0.14345819f, 0.05600764f, 0.28931755f, 0.03542545f, 
    -0.02976103f, -0.04669045f, -0.08709393f, 0.16946633f, -0.43279365f, 0.44466501f, 0.12472513f, -0.16135359f, 
    0.01118326f, -0.03219524f, 0.02114781f, 0.05215950f, 0.23992720f, 0.06829062f, 0.08568507f, 0.15569757f, 
    -0.29068580f, -0.26219583f, -0.16983242f, -0.24956857f, 0.07414751f, -0.18083972f, -0.04698481f, 0.29740596f, 
    0.05144406f, 0.08588855f, 0.09280628f, 0.02167938f, -0.10465283f, -0.12274402f, 0.25989717f, 0.44327766f, 
    -0.11952024f, -0.12715101f, 0.00564924f, 0.01860894f, 0.25054055f, 0.06766876f, 0.25605795f, 0.18775713f, 
    0.22614932f, -0.04399160f, -0.12905349f, -0.05267692f, 0.15522902f, 0.22796023f, 0.16778280f, 0.05320363f, 
    0.00716276f, -0.00256091f, 0.01028458f, 0.09877310f, 0.17302138f, 0.01729802f, -0.32200968f, -0.11486043f, 
    0.02171395f, -0.00963004f, 0.14995188f, -0.11735716f, -0.05040345f, -0.02165814f, -0.17496008f, 0.03508889f, 
    0.10068090f, 0.09596305f, 0.07393005f, 0.11374392f, -0.00215159f, 0.03049548f, -0.12189921f, -0.05228195f, 
    -0.01922117f, -0.16547951f, -0.17680526f, -0.05661681f, 0.54684561f, 0.24817784f, -0.00369555f, 0.10914286f, 
    0.01953093f, 0.07366067f, 0.12305609f, 0.01421386f, 0.08693660f, 0.19045198f, 0.07776364f, -0.05150481f, 
    -0.15088470f, -0.05638991f, 0.09118581f, -0.19651200f, 0.05098348f, 0.06105958f, -0.02623074f, 0.05690125f, 
    -0.03612806f, 0.03954466f, 0.00829250f, 0.04778343f, 0.04542561f, 0.10056628f, 0.15906349f, 0.16810352f, 
    0.18067765f, -0.09905763f, -0.21448660f, -0.17105903f, -0.04407302f, -0.07305314f, -0.11483081f, 0.15872394f, 
    0.11100974f, 0.38211498f, 0.32664767f, -0.20519893f, 0.22520036f, -0.14244109f, -0.04726371f, 0.19033393f, 
    -0.04967083f, -0.02605271f, -0.16299753f, -0.10681093f, 0.26845238f, 0.06728760f, -0.00460060f, 0.11043629f, 
    0.08277596f, -0.03102204f, -0.07935193f, 0.11138663f, -0.04905075f, -0.04177561f, 0.06464671f, 0.06141372f, 
    0.19486524f, 0.03842254f, -0.01001668f, 0.08105160f, 0.02322321f, 0.11126591f, 0.01220844f, 0.00546738f, 
    -0.08157561f, -0.01448627f, -0.01943229f, -0.07055209f, 0.14893161f, 0.02557307f, -0.03297088f, 0.07826652f, 
    0.10581014f, 0.04399769f, 0.12997788f, 0.02546240f, 0.13866441f, -0.14754289f, -0.03864801f, 0.03164599f, 
    0.02530170f, 0.10229151f, 0.48046947f, 0.16177751f, 0.14243595f, -0.10191181f, -0.21323225f, -0.11142325f, 
    -0.00607694f, -0.22188106f, 0.11231051f, -0.07007995f, -0.00185050f, 0.05957635f, 0.31017599f, -0.06003739f, 
    0.08294815f, -0.00602923f, 0.00057221f, -0.16150519f, 0.00329108f, -0.00956888f, 0.06346107f, 0.09415435f, 
    -0.04866131f, 0.23772708f, 0.04551950f, 0.15852751f, -0.02891379f, 0.02049523f, -0.10076847f, -0.02025142f, 
    0.07837908f, -0.08997848f, 0.09031622f, -0.14686158f, 0.12260712f, -0.13136916f, -0.08948810f, 0.02088037f, 
    0.00476154f, 0.01879671f, 0.11524536f, 0.01919572f, 0.04437963f, 0.07070994f, -0.11904461f, -0.05538629f, 
    -0.01936147f, 0.00449379f, -0.04863829f, 0.01476056f, 0.06962540f, 0.22870786f, 0.01745954f, 0.15403900f, 
    0.11206173f, 0.06816517f, 0.09148994f, 0.05817391f, 0.17848793f, 0.10124658f, -0.25867498f, -0.19006610f, 
    -0.16067812f, 0.00142556f, -0.04122190f, -0.01161892f, 0.01885990f, 0.03625284f, -0.01666416f, 0.04650550f, 
    0.01535278f, -0.06579552f, 0.04284702f, -0.06048454f, -0.04534870f, -0.06393921f, -0.02990486f, 0.01152891f, 
    -0.04392310f, 0.00447423f, 0.01338131f, -0.07779671f, 0.02573759f, -0.03096796f, 0.02285399f, -0.06228523f, 
    0.04917621f, 0.00864992f, 0.00003984f, 0.02944067f, -0.02499424f, 0.05609124f, 0.01176493f, -0.04697861f, 
    -0.02438056f, -0.07379189f, -0.04935619f, -0.04387399f, -0.07119156f, 0.06268979f, -0.06466424f, 0.06260631f, 
    -0.03238229f, 0.05581003f, -0.02850016f, 0.00561755f, 0.05044148f, -0.00190028f, -0.03613704f, 0.02213240f, 
    0.06208473f, 0.01352772f, -0.05765737f, 0.03409648f, -0.07221873f, -0.02447348f, 0.04943668f, -0.03184832f, 
    0.03457606f, -0.04871747f, 0.00744693f, -0.03413934f, 0.05192881f, -0.02647313f, 0.02576726f, -0.03431058f, 
    0.05592365f, -0.00926983f, -0.07693082f, 0.02118489f, -0.00275835f, -0.03660873f, -0.05157543f, -0.00040078f, 
    -0.06511134f, 0.00488271f, 0.06160231f, -0.01561982f, -0.05703535f, -0.06528442f, -0.00026168f, -0.03276031f, 
    0.06089973f, -0.07226738f, -0.05870764f, -0.01946587f, -0.06268457f, 0.02988004f, 0.06156442f, -0.01684694f, 
    0.03438763f, -0.06603200f, -0.04754701f, 0.03013342f, -0.05613983f, -0.02704439f, 0.06397413f, 0.03809000f, 
    -0.06352171f, 0.04913710f, 0.05423935f, -0.00727243f, -0.05931060f, 0.00997213f, 0.04780032f, -0.04023902f, 
    -0.00348591f, 0.01092335f, -0.07724909f, 0.03796287f, -0.07331701f, 0.03656973f, -0.07673027f, 0.04130003f, 
    -0.03981460f, -0.03401985f, -0.04687683f, 0.03610194f, 0.00164048f, -0.06036571f, -0.05498972f, 0.05694626f, 
    -0.06205809f, 0.01497528f, 0.00357944f, -0.05081996f, -0.03447394f, 0.02972361f, 0.04350528f, -0.04655356f, 
    0.06134563f, -0.04980642f, 0.01805186f, 0.05781524f, 0.05135657f, -0.01226530f, -0.03381553f, -0.07001773f, 
    0.05163699f, 0.00304859f, 0.00384946f, -0.01974169f, 0.00249528f, 0.03118843f, 0.05477565f, 0.00160641f, 
    -0.00507971f, 0.01538462f, -0.02292538f, 0.01352638f, -0.06917062f, 0.05970691f, -0.03101885f, 0.03270289f, 
    -0.06132370f, 0.06308287f, 0.01691758f, -0.04753254f, 0.03969713f, -0.08028787f, -0.07908019f, 0.06425765f, 
    -0.07011519f, -0.04799119f, -0.01247294f, 0.01073458f, -0.04398888f, 0.01682891f, 0.00105439f, 0.02850537f, 
    -0.01941851f, 0.03177698f, 0.04196938f, -0.05365067f, -0.03015109f, -0.07210088f, 0.01170520f, 0.01178560f, 
    -0.00862289f, 0.00820120f, 0.05111783f, 0.04457366f, -0.01933771f, -0.07554277f, 0.02450704f, -0.06228742f, 
    0.05105325f, 0.04282732f, -0.04778379f, 0.03712630f, -0.06484673f, -0.04174798f, -0.03670648f, -0.00102101f, 
    0.03205322f, 0.04961957f, -0.03882528f, -0.07832533f, -0.00443185f, 0.01364113f, -0.07776180f, 0.03629024f, 
    -0.20899194f, -0.20704645f, -0.23814656f, -0.01099683f, -0.00847417f, -0.02250098f, -0.07369780f, 0.02615846f, 
    -0.17160864f, -0.43496260f, -0.07281644f, -0.13613398f, 0.01026057f, -0.03920549f, -0.03406344f, -0.36973727f, 
    0.06747615f, -0.17067440f, -0.04181423f, -0.04941083f, -0.16316666f, 0.00881936f, -0.04420931f, 0.02732237f, 
    -0.09653301f, -0.14958350f, 0.04752487f, 0.02023935f, -0.06623075f, 0.04270162f, 0.00465622f, 0.06136659f, 
    0.37734023f, 0.21547957f, 0.07826406f, 0.39452600f, 0.35716692f, -0.35277119f, 0.23203722f, 0.05655643f, 
    0.00371623f, -0.03073928f, 0.20713523f, 0.02910849f, -0.04374272f, -0.05333710f, 0.14457886f, -0.04611832f, 
    0.00494322f, -0.08800380f, 0.08277990f, -0.03817337f, -0.10479432f, 0.20517446f, -0.05957113f, 0.25058380f, 
    0.06379130f, 0.27291882f, -0.04683179f, -0.06824192f, 0.07484709f, 0.15840423f, -0.01306393f, 0.10693207f, 
    0.08649766f, -0.12843530f, 0.00662977f, 0.10289989f, 0.04578117f, 0.01043592f, -0.04748600f, 0.09897652f, 
    0.04424131f, -0.02156502f, -0.20075411f, -0.25391212f, 0.06027142f, 0.02419132f, -0.00337834f, 0.07424103f, 
    -0.04461447f, -0.41898885f, -0.06772256f, 0.13068584f, -0.31837118f, -0.37254921f, 0.30768898f, -0.26729566f, 
    -0.53608477f, -0.36459309f, -0.28592139f, -0.07988174f, -0.18910480f, -0.26619890f, -0.34285641f, -0.19212580f, 
    -0.13503705f, -0.19997871f, -0.43467236f, -0.32141066f, -0.01601388f, -0.10460681f, 0.20538616f, -0.01225332f, 
    -0.31565580f, -0.31212115f, -0.19929217f, -0.16863461f, 0.02607203f, -0.40749848f, -0.40221277f, -0.09277803f, 
    -0.18773912f, -0.29222986f, -0.09114189f, -0.16739249f, 0.16302629f, -0.07449602f, -0.03788429f, 0.01327942f, 
    -0.00840290f, 0.16887473f, 0.08350708f, 0.17323110f, -0.00444869f, -0.15653008f, 0.12337893f, -0.09927879f, 
    0.18019462f, 0.06764380f, -0.03277953f, 0.15649614f, 0.06986395f, 0.17873092f, -0.06750163f, 0.03315578f, 
    0.05514767f, 0.06960294f, -0.00083032f, -0.01959869f, 0.04247289f, 0.01365794f, 0.07209405f, 0.02271444f, 
    0.21117309f, 0.09274070f, 0.00338508f, 0.14113079f, -0.08916151f, -0.08767413f, 0.00517721f, 0.00114382f, 
    0.00276349f, 0.14949505f, 0.08151714f, 0.11222407f, 0.21191934f, 0.27764055f, -0.11307136f, -0.13022587f, 
    -0.16618878f, -0.16053601f, -0.18192130f, 0.06389201f, -0.07465450f, 0.04057683f, 0.15403667f, -0.06576040f, 
    0.03371455f, -0.02169424f, 0.22714353f, 0.19533946f, 0.07254464f, 0.16656476f, 0.10463938f, 0.06994584f, 
    -0.10553075f, -0.02914210f, -0.10223977f, -0.13198219f, 0.11946146f, 0.17049305f, 0.12773466f, 0.05911647f, 
    0.06927938f, 0.08090221f, 0.04675029f, -0.06402428f, 0.04471966f, -0.06039271f, 0.09714535f, 0.10691091f, 
    0.01830213f, 0.10696544f, -0.23701200f, 0.20219110f, 0.00289723f, 0.07580210f, 0.07151812f, 0.18486364f, 
    -0.13362914f, 0.04471945f, 0.10824449f, 0.11286160f, 0.01041317f, 0.00117627f, 0.28386596f, 0.03375648f, 
    -0.00797946f, 0.01399437f, 0.08188481f, -0.00202074f, 0.00492175f, 0.04763024f, -0.23465076f, 0.10503444f, 
    -0.16789165f, 0.05688601f, 0.10011757f, -0.06963804f, -0.06367441f, -0.05741031f, -0.20044693f, -0.20215321f, 
    -0.03576709f, 0.12761885f, -0.25758585f, 0.05611301f, 0.39711088f, 0.23883300f, 0.28007835f, 0.34643739f, 
    -0.05413090f, 0.03233438f, 0.06223528f, -0.04626302f, 0.10148656f, -0.14523411f, -0.02322668f, 0.09652308f, 
    -0.23296458f, 0.11556033f, 0.19231060f, 0.11693133f, -0.09271806f, -0.03713381f, -0.19966963f, -0.05863482f, 
    0.05719285f, -0.04456048f, -0.04352087f, 0.19613011f, 0.13864914f, 0.06586802f, 0.03550004f, -0.04643052f, 
    -0.06350891f, -0.18299176f, -0.02017616f, 0.00959367f, -0.05353128f, 0.07131542f, 0.02660671f, -0.10660257f, 
    0.21548949f, -0.02626213f, -0.17473452f, -0.42424339f, 0.06940368f, 0.07801075f, 0.07043114f, -0.02026315f, 
    0.05814789f, -0.00192865f, 0.03482175f, -0.04430485f, 0.16342874f, -0.24211076f, -0.07924981f, 0.09206756f, 
    0.05930329f, 0.07122522f, -0.12600593f, 0.03399260f, 0.04862919f, 0.07656394f, -0.14450549f, -0.01499268f, 
    -0.03997011f, -0.48732340f, 0.07970163f, -0.11532572f, -0.09376788f, 0.00579512f, 0.04987688f, -0.30152634f, 
    0.06823815f, 0.17898816f, -0.06168911f, -0.15271458f, 0.05513416f, 0.11854177f, -0.25782594f, 0.01492407f, 
    0.24480006f, 0.02145957f, 0.13512605f, 0.12875956f, -0.17524552f, 0.03930832f, -0.07815106f, -0.04839581f, 
    -0.13096942f, 0.01031935f, 0.07719646f, -0.03389144f, -0.12948008f, -0.22958989f, -0.05139717f, -0.07491313f, 
    0.06626171f, -0.10556872f, 0.08455070f, -0.02856750f, -0.36500618f, 0.34853438f, -0.04684661f, -0.03403081f, 
    -0.13511842f, -0.11189502f, 0.08454961f, -0.16480651f, -0.00542287f, -0.10661460f, 0.11688612f, 0.13749342f, 
    -0.44714847f, -0.22291735f, 0.30951545f, 0.14138526f, -0.01124793f, -0.17720835f, -0.05481451f, -0.04285769f, 
    -0.14202766f, -0.12923527f, 0.05910622f, 0.12890986f, 0.61934638f, -0.07779306f, 0.33939579f, 0.32925025f, 
    -0.01168706f, 0.01360895f, -0.00964521f, 0.13365093f, -0.17628261f, 0.18022910f, 0.08146156f, 0.18244007f, 
    0.11103933f, -0.16662757f, -0.00983021f, 0.02442302f, -0.15173575f, 0.08309651f, 0.09501248f, 0.25715882f, 
    -0.13906512f, 0.05878783f, 0.23627526f, 0.03259246f, 0.01116489f, 0.09681786f, -0.23990645f, -0.24529053f, 
    -0.05915552f, 0.00427572f, 0.11304040f, 0.04041668f, -0.03032163f, 0.07277743f, 0.04637517f, 0.00018805f, 
    0.29409644f, 0.32980081f, 0.13091055f, 0.08374795f, -0.01657511f, 0.07664997f, -0.01581340f, -0.03324019f, 
    -0.02512161f, 0.00955201f, 0.07090667f, -0.04985735f, 0.08980371f, 0.01025659f, 0.07259110f, -0.02852189f, 
    0.09779664f, 0.02014035f, -0.06821904f, -0.03050374f, -0.01344339f, 0.03248126f, -0.13954183f, -0.10816670f, 
    -0.07176377f, -0.12036575f, -0.08224390f, -0.04694566f, -0.07320540f, -0.02665256f, -0.11592487f, -0.13371956f, 
    -0.07796116f, 0.09846658f, 0.08702185f, 0.16031848f, 0.28018793f, -0.33477405f, 0.06444284f, -0.02807275f, 
    -0.19187662f, -0.10607641f, -0.05877058f, 0.04107411f, 0.08120961f, 0.08567400f, -0.07860395f, 0.14962204f, 
    0.05684109f, -0.19743475f, 0.21160284f, -0.04370965f, 0.03300159f, -0.01697065f, -0.04938326f, 0.01683963f, 
    -0.02180092f, 0.04891641f, 0.02810608f, 0.00491777f, -0.21031275f, -0.36999595f, -0.10941171f, -0.10282308f, 
    0.01944489f, 0.08263133f, -0.02339853f, 0.02903706f, 0.04001199f, -0.03834767f, -0.02396634f, -0.04029386f, 
    -0.02849403f, 0.07028844f, -0.30201221f, 0.13447717f, -0.04190743f, 0.17117304f, -0.00960565f, -0.18040827f, 
    0.12849884f, 0.03834695f, 0.15446471f, -0.00592876f, 0.13273093f, 0.25204939f, -0.01533700f, 0.07555580f, 
    0.15635069f, 0.14577734f, -0.08280618f, 0.12679933f, -0.06955834f, 0.07720471f, 0.14110619f, -0.07109094f, 
    0.34741673f, 0.25538805f, 0.24281614f, -0.00308595f, -0.04261025f, -0.03027213f, 0.05348658f, 0.06485894f, 
    0.09640792f, 0.09990476f, -0.09184510f, -0.00883263f, 0.07178792f, 0.24092719f, -0.04573179f, 0.05723323f, 
    0.09404895f, -0.09647062f, 0.03454857f, 0.12815954f, -0.11428216f, 0.07059643f, -0.15526296f, -0.03351058f, 
    -0.49624887f, -0.28424117f, -0.24347812f, -0.12899874f, -0.05217078f, 0.19850433f, -0.04756417f, -0.02424490f, 
    0.08465890f, 0.07425825f, 0.06624763f, 0.10542247f, -0.24119942f, -0.36123216f, -0.30377555f, -0.12847772f, 
    -0.10538233f, 0.07461119f, 0.11431024f, -0.00401755f, -0.12701568f, -0.07396279f, -0.05588336f, -0.07662904f, 
    -0.38260078f, -0.31114528f, -0.40613875f, 0.08428447f, -0.07115542f, -0.16222581f, 0.12572786f, 0.04779880f, 
    -0.20233594f, 0.02543022f, -0.11017894f, 0.08425836f, 0.37082759f, 0.21670216f, 0.03195808f, 0.14039126f, 
    -0.02237962f, 0.13277450f, -0.01234033f, 0.10154501f, -0.06743336f, -0.08328982f, -0.04387117f, 0.09832920f, 
    0.11231868f, 0.16928807f, 0.13167723f, 0.10597537f, -0.10703778f, 0.13971488f, 0.16560994f, 0.12326451f, 
    -0.09379277f, 0.05893308f, 0.03254226f, 0.02487584f, 0.04541763f, 0.28361768f, -0.04567871f, -0.21449725f, 
    -0.10161455f, 0.08252674f, 0.01476445f, -0.00390362f, 0.05201358f, 0.12088767f, -0.09511194f, -0.04012159f, 
    -0.18515822f, 0.31810606f, 0.07164966f, -0.02989923f, 0.04003877f, 0.00529544f, 0.00287213f, -0.04602206f, 
    0.04044749f, 0.16119029f, 0.04012035f, 0.08214023f, 0.10348132f, -0.17332952f, 0.19555661f, 0.22438046f, 
    0.04717017f, 0.04277729f, -0.02892472f, 0.29197499f, -0.04154767f, 0.03620003f, 0.21334161f, -0.10832227f, 
    -0.13088402f, -0.11944769f, -0.18804236f, -0.05331047f, -0.04489340f, -0.04510519f, -0.14734437f, 0.00828690f, 
    -0.03526300f, 0.01177546f, 0.08815116f, -0.18387602f, -0.40714520f, 0.15091233f, 0.02022893f, -0.00396720f, 
    0.05938577f, 0.01497867f, -0.28252846f, 0.25680944f, -0.10990554f, 0.12342062f, 0.01672604f, 0.12781247f, 
    0.13498306f, -0.04058126f, -0.39928278f, 0.09388401f, 0.08138482f, 0.02771003f, 0.08870593f, 0.12739892f, 
    -0.09232118f, -0.05118672f, 0.03366999f, -0.00728551f, -0.29742914f, -0.10625210f, -0.29561874f, 0.04203736f, 
    0.01194812f, 0.15457855f, 0.27878177f, -0.01076200f, -0.04719179f, 0.04900150f, 0.07609497f, 0.01590413f, 
    -0.00896611f, -0.23982756f, 0.22241642f, 0.23238130f, -0.12523136f, 0.10825939f, 0.09218944f, 0.18245535f, 
    -0.15437348f, 0.11771889f, -0.05022827f, -0.07521760f, -0.06601219f, -0.20578763f, 0.06922805f, -0.03705560f, 
    0.00284773f, 0.09851446f, 0.17618516f, -0.01755223f, -0.04831266f, 0.06679883f, -0.03613001f, -0.14912350f, 
    -0.15019198f, -0.29097617f, -0.03085907f, 0.30202624f, 0.07043269f, 0.12069030f, 0.05773624f, 0.12152353f, 
    -0.12411556f, -0.07068133f, 0.08272417f, 0.17642847f, -0.14952375f, 0.16616556f, 0.24815281f, -0.10293912f, 
    0.08604474f, 0.04833441f, 0.02736552f, 0.04041960f, -0.01915888f, 0.09181205f, -0.15138656f, -0.12056375f, 
    0.02407502f, -0.06694952f, -0.42785984f, 0.02092053f, -0.03878267f, 0.02635701f, 0.18124907f, 0.22692609f, 
    -0.12874863f, 0.01747554f, -0.08915623f, -0.08120269f, 0.12162226f, 0.16747001f, -0.25540236f, -0.10867680f, 
    0.03563477f, 0.08852111f, -0.04782061f, 0.16115265f, -0.09373205f, 0.34246120f, -0.10030818f, 0.03377835f, 
    0.14505701f, 0.04303176f, -0.17763926f, 0.20243378f, -0.04293012f, 0.06513402f, 0.10687523f, -0.09521671f, 
    0.03984936f, -0.01509305f, -0.20894541f, -0.04728002f, -0.10989911f, 0.16341840f, -0.01255309f, -0.06093977f, 
    0.04228842f, -0.06271696f, 0.10128999f, 0.13562536f, -0.03552624f, 0.20383461f, -0.02918951f, -0.09412405f, 
    -0.04264056f, -0.13443241f, -0.01138251f, -0.08128120f, 0.05798487f, -0.10319928f, 0.11323413f, -0.07328406f, 
    0.08691244f, 0.17785503f, -0.00713003f, 0.15025564f, -0.11849275f, 0.19662103f, 0.36070547f, 0.26530579f, 
    -0.04075329f, -0.05238505f, -0.17650984f, -0.14538348f, 0.05063386f, 0.13137421f, 0.17760167f, 0.08804934f, 
    -0.09555284f, 0.06952693f, -0.00465778f, 0.40637204f, 0.01417337f, 0.06818419f, 0.17497818f, 0.17932916f, 
    -0.10601299f, 0.04158986f, 0.05428238f, 0.12749885f, -0.00182845f, 0.22163261f, 0.42234963f, -0.07252761f, 
    -0.04993081f, 0.01775687f, 0.17975076f, 0.12001996f, 0.01593814f, 0.09028637f, 0.00272597f, -0.09598441f, 
    0.04511809f, 0.07937942f, -0.01523133f, -0.03343736f, -0.11356691f, -0.05418729f, -0.05336383f, -0.10188930f, 
    -0.01719281f, 0.01677603f, -0.10686075f, -0.07891639f, 0.14533122f, 0.05128232f, 0.35163760f, 0.14070164f, 
    -0.06657889f, 0.11038043f, -0.26444626f, 0.17019860f, 0.07335319f, -0.06171824f, 0.05428996f, 0.12277271f, 
    -0.02124022f, 0.26487407f, 0.00597930f, 0.10576187f, -0.10419743f, -0.19426425f, -0.05217834f, -0.07447159f, 
    0.15258130f, -0.07339410f, 0.04580391f, 0.24298422f, 0.35924643f, 0.04825683f, -0.06567131f, -0.14422131f, 
    -0.14444819f, -0.06794623f, -0.01968084f, 0.13435730f, -0.12945409f, 0.02126352f, -0.00176789f, 0.05201463f, 
    0.10045650f, -0.24571188f, -0.28453091f, -0.16184005f, 0.08213097f, -0.07120602f, 0.11182521f, 0.00531460f, 
    -0.10207972f, -0.00565763f, 0.02326057f, -0.04044203f, -0.11565275f, -0.10841086f, 0.11128537f, -0.16235438f, 
    -0.08535019f, -0.13464966f, -0.03096439f, 0.06715202f, -0.00742943f, 0.14708970f, -0.11357509f, -0.06731933f, 
    -0.17729066f, -0.29001844f, 0.15692526f, -0.19818492f, -0.04524841f, -0.11682991f, -0.01009110f, -0.18548796f, 
    0.01144182f, 0.07035566f, -0.03914766f, 0.00685560f, -0.05769327f, 0.06546815f, -0.12596741f, 0.01045321f, 
    0.13384721f, 0.11563682f, 0.08468260f, 0.03618156f, -0.03808025f, 0.01173316f, -0.05062253f, 0.12026446f, 
    -0.04317287f, 0.05577031f, 0.16836408f, -0.05866587f, -0.04968205f, -0.21599212f, 0.09143115f, -0.04673706f, 
    0.03026947f, -0.03744488f, 0.06412512f, -0.15352151f, -0.13341215f, 0.22452827f, 0.06709390f, 0.09545907f, 
    0.03032742f, -0.12387848f, 0.14494383f, -0.05663059f, -0.04818865f, -0.12381438f, 0.25322047f, 0.16425891f, 
    0.13366647f, -0.06761756f, 0.45117223f, -0.06378634f, -0.10761216f, -0.19893667f, -0.12326078f, -0.01366340f, 
    -0.11699769f, 0.01117425f, 0.13073902f, 0.01147700f, 0.08594904f, 0.20102793f, 0.39650804f, 0.17143770f, 
    0.02027114f, 0.02993810f, 0.02947383f, 0.07013477f, -0.05482195f, 0.16489100f, 0.08397194f, 0.08277147f, 
    -0.02056925f, -0.22634879f, 0.06604637f, 0.03814264f, -0.13515155f, -0.08540615f, 0.27592805f, 0.14588386f, 
    -0.09393226f, 0.04930551f, 0.08775811f, 0.11618893f, -0.36649171f, -0.05198223f, -0.19189258f, 0.18910052f, 
    -0.02611585f, -0.12276096f, 0.00110955f, -0.02900304f, -0.09397269f, -0.08484358f, 0.02408307f, 0.03209301f, 
    -0.05929857f, -0.07867735f, -0.02966180f, 0.01407425f, 0.03226025f, -0.02530009f, -0.02728341f, 0.05138997f, 
    0.03797267f, 0.01731472f, 0.02362313f, 0.00052735f, -0.05952417f, 0.03193501f, -0.07872558f, 0.02191935f, 
    -0.06556854f, 0.02716935f, -0.01602921f, 0.05663069f, -0.06749184f, -0.02180976f, -0.02599194f, 0.03083592f, 
    -0.01850857f, -0.00111656f, 0.02528180f, 0.04001191f, -0.08293888f, -0.07430603f, -0.04367111f, -0.08111279f, 
    -0.06084923f, 0.03292518f, -0.04460492f, 0.03351633f, -0.04951707f, -0.09827903f, -0.07689881f, 0.04492233f, 
    -0.04988512f, 0.05778438f, -0.08084641f, -0.04701178f, 0.05651230f, 0.00085427f, -0.08045553f, 0.04306237f, 
    -0.03619108f, -0.06989685f, 0.04054967f, -0.06981281f, -0.02961614f, 0.00519184f, -0.10444336f, 0.01462874f, 
    -0.06025258f, -0.04052543f, -0.04897698f, -0.01451938f, 0.00983939f, -0.05670246f, -0.05513583f, -0.06308705f, 
    -0.07473816f, 0.01393690f, -0.04929771f, -0.02840544f, -0.01091978f, 0.00219103f, -0.07503653f, -0.03815380f, 
    -0.04706678f, -0.04643059f, -0.07240296f, -0.04753239f, -0.02942247f, -0.04178282f, -0.03944583f, -0.07976271f, 
    0.04240298f, -0.06099675f, -0.06893850f, -0.05145757f, -0.05419993f, 0.00543538f, -0.07801103f, 0.03522927f, 
    -0.00902812f, -0.02779141f, -0.05830701f, -0.02813711f, 0.03046575f, 0.04541899f, -0.06522905f, 0.03197697f, 
    -0.07204881f, -0.06069523f, 0.05061888f, 0.01319960f, 0.03187159f, -0.05975686f, 0.04428701f, 0.02927360f, 
    -0.06160299f, 0.01322800f, -0.02433698f, 0.03713260f, -0.00927371f, -0.01479606f, 0.03272201f, -0.01424064f, 
    -0.06385226f, -0.04268904f, 0.01614295f, 0.06056962f, 0.00495542f, -0.04510364f, -0.04465036f, -0.03474412f, 
    -0.05423207f, -0.04904364f, 0.01517797f, 0.01933869f, -0.01899391f, -0.03549509f, -0.05193938f, -0.00824762f, 
    0.03629195f, -0.03938303f, 0.00292616f, 0.00587416f, -0.10021057f, -0.09848238f, -0.06238059f, -0.01212423f, 
    0.01606740f, -0.05832036f, -0.06435116f, -0.00381134f, 0.01202400f, 0.02267306f, -0.01828772f, -0.10166459f, 
    -0.06119789f, -0.07246904f, 0.00505558f, -0.08129541f, -0.03342767f, -0.07212706f, 0.03278822f, -0.00665236f, 
    -0.02071490f, -0.06433565f, -0.09984998f, -0.01287986f, 0.04804761f, -0.01724825f, 0.04021557f, -0.02677569f, 
    -0.07140250f, -0.00141031f, -0.07708483f, 0.03543762f, -0.09112969f, 0.01390856f, 0.06514286f, 0.06357444f, 
    0.00403886f, -0.05682537f, -0.04759904f, -0.01736308f, 0.07537508f, -0.08679798f, 0.03765495f, 0.01178105f, 
    -0.05008437f, -0.03722347f, -0.10834564f, 0.01271387f, -0.04377753f, -0.00313839f, 0.01107459f, -0.00015127f, 
    -0.04597893f, 0.00678959f, -0.11064365f, 0.02771925f, -0.01945893f, -0.00204142f, -0.07941445f, -0.01111832f, 
    0.15464479f, 0.28810486f, -0.13426238f, 0.03372555f, -0.06586810f, -0.04714078f, -0.05142301f, -0.01837659f, 
    -0.13092168f, -0.02496472f, 0.14625497f, 0.14295433f, 0.05904643f, -0.22791341f, 0.20655699f, -0.34433940f, 
    -0.06055280f, -0.12459441f, -0.15434526f, 0.04646676f, -0.07309829f, -0.00994133f, 0.17452285f, -0.12235475f, 
    0.02628293f, 0.08432592f, 0.19693743f, -0.07978278f, -0.00328373f, -0.03967369f, -0.07001381f, -0.05833902f, 
    0.05263345f, 0.01862528f, 0.10907109f, 0.02307972f, -0.03291920f, -0.59718388f, 0.22235359f, -0.13003515f, 
    0.17806140f, 0.17916228f, -0.27962291f, 0.04962230f, 0.02116937f, -0.20221971f, 0.17605078f, 0.16512245f, 
    0.01352456f, 0.18481949f, 0.20655844f, -0.07655974f, 0.03755752f, -0.03581168f, -0.06518981f, 0.05266605f, 
    -0.02853350f, -0.21956052f, -0.03098309f, 0.00683948f, -0.08243585f, -0.00366729f, -0.16334666f, -0.03004270f, 
    0.06900059f, -0.06561014f, 0.08424392f, 0.12039942f, 0.13112278f, 0.03776239f, -0.01398684f, 0.06867772f, 
    -0.02531640f, 0.05226621f, -0.43115103f, 0.05415157f, 0.02154500f, 0.02417005f, -0.04200394f, -0.07221216f, 
    -0.09327780f, -0.04022327f, 0.09629387f, 0.04877480f, 0.10730014f, 0.02295364f, 0.00316164f, 0.09422999f, 
    -0.05812502f, -0.08053610f, -0.10567959f, 0.18106325f, -0.02597584f, 0.07002191f, 0.12674327f, 0.02826321f, 
    0.12543601f, 0.16655847f, 0.27600545f, 0.02637737f, -0.14518526f, 0.01792897f, 0.15924707f, 0.17073731f, 
    -0.12670541f, -0.01622627f, -0.07738885f, -0.12465560f, 0.06447472f, 0.32668504f, -0.13236699f, -0.00167664f, 
    0.10201561f, 0.06303561f, 0.03052723f, -0.06241179f, -0.00738524f, 0.03748029f, -0.22239533f, 0.08465336f, 
    -0.20035343f, 0.33866084f, -0.18336390f, 0.07779675f, -0.02790198f, 0.01200391f, 0.10255422f, 0.03081939f, 
    0.13692819f, -0.08614168f, -0.07905910f, -0.00215226f, -0.09267487f, 0.20537066f, -0.28190589f, -0.01568702f, 
    0.11054377f, -0.05633977f, 0.12897089f, -0.00365467f, -0.05341428f, 0.06097255f, -0.09190397f, -0.16791281f, 
    -0.25991142f, 0.10988993f, -0.41866788f, 0.31535509f, -0.11928930f, 0.02732109f, 0.18929686f, -0.03913616f, 
    -0.05492002f, 0.01465235f, -0.02324467f, -0.03535892f, 0.37678951f, 0.04512202f, -0.03574593f, 0.07572610f, 
    0.03640093f, 0.02646214f, -0.09357933f, 0.08308825f, -0.02840686f, -0.07233352f, 0.07179639f, 0.17110732f, 
    0.18838899f, -0.10726339f, 0.06029564f, 0.12520696f, -0.29519346f, 0.10309194f, 0.26291874f, 0.07755109f, 
    0.01893284f, 0.07909569f, 0.04846640f, 0.16224352f, 0.28461486f, 0.38928810f, 0.07203338f, 0.01342612f, 
    -0.06517261f, 0.07748589f, -0.00219566f, -0.04733620f, -0.04155068f, 0.01335146f, -0.11648765f, -0.13021117f, 
    -0.05750582f, -0.19376720f, -0.09036158f, 0.08127996f, -0.06339438f, 0.06845535f, -0.07578994f, 0.11705775f, 
    -0.02809436f, -0.07381137f, -0.13340607f, -0.02224932f, -0.06440966f, 0.19537295f, -0.01716557f, 0.36810654f, 
    0.01961262f, 0.04729110f, 0.06559575f, -0.04421027f, 0.02245135f, 0.00896683f, 0.04682024f, 0.07353735f, 
    -0.25702375f, 0.03239157f, -0.13080764f, -0.06206309f, -0.11041304f, 0.11511656f, 0.07702699f, 0.10620726f, 
    0.10182972f, 0.20658338f, -0.03295168f, 0.16470104f, -0.23687142f, 0.68987757f, -0.12098572f, 0.14266974f, 
    0.02964813f, 0.16500147f, 0.36162052f, -0.03365571f, -0.10427676f, 0.12616235f, 0.01436937f, -0.04289695f, 
    -0.34661254f, 0.07817812f, 0.05927026f, 0.00417576f, -0.12270433f, 0.22332183f, 0.11799019f, -0.07169662f, 
    0.01364017f, 0.22420016f, -0.04187852f, 0.03658507f, 0.15227927f, 0.12260102f, 0.24235542f, -0.24409865f, 
    -0.00925987f, -0.22957534f, -0.26537234f, -0.11723134f, -0.10649332f, -0.08591944f, 0.02539003f, -0.07364821f, 
    0.32795468f, -0.07901763f, 0.33736607f, -0.05430997f, 0.12150884f, 0.01329318f, 0.10166661f, -0.06786855f, 
    0.16585389f, -0.05389827f, -0.17238866f, 0.00987417f, -0.01335498f, -0.08811363f, 0.07728664f, -0.03173772f, 
    -0.07379439f, -0.02336242f, 0.21557944f, 0.00492469f, 0.03660154f, -0.08093636f, -0.20536049f, 0.10853989f, 
    -0.14888567f, -0.12261292f, 0.07379163f, 0.10111082f, -0.12853855f, -0.03608804f, -0.16107488f, 0.16192640f, 
    0.04625933f, -0.18634945f, -0.03047969f, -0.10778855f, -0.08798950f, -0.21363349f, 0.02904669f, 0.23943064f, 
    0.04926256f, 0.03778935f, -0.07493968f, 0.00363631f, 0.01204094f, 0.01106083f, 0.18327676f, -0.01113595f, 
    0.24686514f, -0.19579923f, 0.26607519f, -0.16730312f, 0.09149384f, -0.24249680f, -0.10831650f, -0.13451694f, 
    0.01978675f, -0.09851433f, 0.11762997f, -0.00216425f, -0.00675728f, -0.06693150f, 0.34703568f, -0.05462587f, 
    0.05061515f, 0.02273053f, -0.07823577f, -0.12921543f, 0.01724703f, -0.01049479f, 0.03585529f, 0.11121859f, 
    -0.16116378f, 0.04700095f, 0.58816290f, -0.09433057f, -0.01949119f, 0.12554498f, -0.24747498f, -0.06745194f, 
    0.03035950f, 0.00818462f, 0.08392773f, 0.00934040f, 0.01208812f, -0.29142836f, 0.13939311f, 0.10751850f, 
    0.05544990f, 0.06093140f, 0.05477685f, 0.02228174f, 0.09048434f, 0.04856275f, 0.01507318f, 0.08316009f, 
    0.06611579f, -0.01565538f, -0.07967903f, -0.00553033f, 0.02360458f, 0.03580203f, -0.24711798f, -0.07736403f, 
    0.09522027f, -0.12971823f, 0.00742328f, -0.17680469f, 0.02624170f, -0.06196780f, -0.28749311f, -0.36385813f, 
    0.22398734f, 0.07778608f, -0.09697080f, 0.04673862f, -0.05908653f, 0.04585884f, -0.06897788f, 0.06878843f, 
    0.04166342f, -0.06332091f, 0.13574103f, 0.09810623f, -0.10852614f, 0.00496878f, 0.05693742f, 0.11492757f, 
    0.07369605f, 0.01835144f, -0.17198493f, -0.05501525f, 0.03662427f, 0.36519459f, 0.09111656f, 0.13750526f, 
    0.21869366f, 0.02795684f, 0.09253412f, 0.00767873f, -0.01482297f, -0.00973147f, 0.00783025f, 0.18249236f, 
    -0.03364812f, -0.29381263f, -0.21340391f, -0.20823771f, -0.01523053f, 0.04554445f, -0.03864298f, -0.13514362f, 
    0.21613048f, -0.04970775f, -0.01364493f, -0.05788879f, -0.22962672f, 0.21160497f, -0.12453858f, -0.14461181f, 
    0.07910014f, 0.10297175f, 0.00664404f, 0.04791728f, 0.01856802f, 0.03574374f, 0.06702723f, -0.01149499f, 
    0.17236806f, 0.21327044f, -0.07372397f, -0.11126801f, -0.04009908f, 0.18019532f, -0.08326756f, 0.04046902f, 
    0.17441486f, 0.12655917f, -0.03341725f, 0.21667995f, -0.37593514f, -0.37986737f, -0.14425834f, 0.12918185f, 
    -0.08816674f, 0.09920561f, -0.06231746f, -0.02205030f, 0.06995881f, -0.06981701f, -0.08289130f, -0.12358160f, 
    0.14001897f, -0.12280878f, 0.09450360f, 0.20766473f, 0.02189852f, -0.09176088f, -0.09565905f, -0.09007747f, 
    0.05622365f, 0.09559123f, -0.08669281f, 0.02969235f, -0.16942839f, -0.06471513f, 0.00932014f, 0.08795983f, 
    0.07716542f, -0.03611469f, -0.02317848f, -0.05693364f, -0.04270283f, 0.03453625f, 0.06548759f, -0.11223901f, 
    -0.24662311f, 0.05573476f, -0.09420583f, 0.15271378f, -0.07746505f, 0.04926620f, -0.04864438f, -0.00061325f, 
    0.06918193f, -0.03281141f, 0.02616993f, 0.08708933f, -0.03630586f, -0.00974332f, 0.13044578f, 0.08284114f, 
    0.03348127f, 0.13763182f, -0.12339487f, -0.07815280f, -0.06094817f, -0.02579481f, 0.13742922f, 0.07120686f, 
    -0.51275712f, -0.33064660f, -0.37809342f, -0.01556214f, -0.06389561f, 0.02364678f, -0.05937671f, -0.22082998f, 
    -0.00519077f, 0.03472480f, -0.05433340f, 0.03681510f, -0.10670046f, -0.12218285f, -0.31587657f, -0.00185344f, 
    0.01428037f, 0.04933061f, -0.01194984f, -0.07559388f, 0.10469682f, 0.00404769f, 0.02912071f, 0.14737646f, 
    0.07790700f, -0.00218844f, 0.05297616f, -0.31707862f, 0.08912994f, 0.21248364f, -0.16140597f, -0.09457555f, 
    0.15037221f, -0.04526101f, 0.01207017f, -0.11014706f, 0.06490590f, 0.16117606f, 0.34208167f, 0.28822175f, 
    0.00693875f, -0.06441312f, 0.08232480f, 0.01956267f, 0.06931563f, -0.00452362f, 0.02170546f, -0.05122510f, 
    -0.09432625f, 0.07304217f, -0.01408394f, -0.02461134f, 0.16284564f, 0.01983466f, -0.00752571f, 0.23530734f, 
    0.06919093f, -0.13273092f, -0.01482711f, -0.21405914f, 0.01092677f, 0.09923151f, -0.02514091f, 0.32069913f, 
    0.04965027f, -0.05936780f, -0.02328647f, 0.10486199f, -0.07841632f, 0.03951244f, 0.01278901f, 0.21550509f, 
    0.04676319f, -0.07650286f, 0.18247119f, 0.18583387f, 0.01200942f, 0.05512770f, 0.09392260f, 0.27164230f, 
    -0.00110094f, -0.10372686f, 0.04069884f, 0.04771266f, 0.00519047f, 0.51448750f, 0.00459940f, 0.06402435f, 
    0.18373194f, 0.04133382f, 0.20282975f, 0.04169053f, 0.07729729f, 0.03440720f, 0.01894351f, 0.19889963f, 
    -0.11766406f, -0.32083708f, -0.11847100f, -0.09857816f, -0.00258839f, 0.02463230f, -0.12504114f, -0.17045209f, 
    0.07900422f, 0.02774640f, -0.03841336f, 0.03050038f, 0.27653685f, 0.49963444f, -0.05509017f, 0.02418416f, 
    0.02016200f, 0.03623835f, 0.06928485f, 0.03419374f, 0.10743058f, 0.04217777f, 0.09154224f, -0.08137335f, 
    0.02455759f, 0.17163689f, 0.16270813f, -0.09469309f, -0.00922987f, 0.10640853f, -0.00198193f, -0.16217168f, 
    0.03875853f, 0.03102059f, 0.05393269f, 0.29381871f, -0.22121947f, -0.30067471f, -0.22690354f, 0.11464497f, 
    -0.06631581f, -0.19446515f, -0.16286908f, -0.14054997f, -0.01936273f, -0.05889159f, -0.12582406f, -0.08507116f, 
    0.20273405f, -0.07714295f, 0.10199989f, -0.02933129f, 0.11052763f, -0.07371815f, -0.02409679f, 0.06157024f, 
    0.19941565f, 0.09469952f, -0.07350332f, -0.12019717f, -0.07392523f, -0.02501994f, 0.25097969f, 0.08497987f, 
    -0.04197716f, -0.04262091f, -0.07499322f, 0.06386600f, 0.08646438f, -0.00333168f, 0.06699803f, 0.05071818f, 
    -0.16104200f, -0.02715607f, -0.12506160f, 0.05581554f, -0.03657532f, 0.02026291f, 0.01804353f, -0.02446520f, 
    0.10122120f, 0.06280013f, 0.07234068f, 0.00138996f, -0.05448062f, -0.13583429f, -0.00931145f, 0.25984401f, 
    0.05076764f, 0.21457988f, -0.07823543f, -0.02189980f, 0.08769624f, -0.04158428f, 0.10416543f, 0.10771549f, 
    -0.61633557f, -0.38258424f, -0.01423093f, -0.12900266f, -0.03078377f, -0.21966328f, -0.26307604f, -0.32228625f, 
    0.13708852f, -0.15462074f, 0.17037401f, 0.02414543f, -0.12592453f, -0.14080709f, -0.05239409f, -0.06135565f, 
    -0.02958691f, -0.00546407f, -0.19324511f, -0.24703668f, 0.19107962f, -0.07583981f, 0.25401002f, 0.12525909f, 
    -0.12676644f, -0.26557139f, 0.30794847f, -0.28174317f, 0.05953549f, -0.03990423f, -0.20158920f, -0.01216153f, 
    0.14929479f, -0.04224001f, 0.03743791f, -0.02555614f, 0.04541105f, 0.12421105f, 0.33975598f, 0.31215206f, 
    -0.00087115f, -0.00166487f, 0.00427841f, 0.02144289f, -0.03295298f, 0.00278293f, 0.06356800f, 0.07303906f, 
    0.03078729f, 0.07458242f, 0.10323293f, -0.09490906f, 0.04636185f, 0.05142109f, -0.08441339f, 0.17845441f, 
    0.07005116f, -0.14948082f, -0.05595404f, -0.11703592f, -0.30264068f, -0.25751075f, -0.37403879f, 0.02852610f, 
    0.02762786f, -0.07374880f, -0.01282854f, -0.00437770f, -0.09341123f, -0.00359681f, -0.10742105f, 0.19022816f, 
    -0.24932347f, 0.45804304f, -0.18120910f, 0.06603003f, 0.04360344f, 0.02303994f, -0.01059558f, -0.00162901f, 
    0.07692030f, 0.11295872f, 0.00695925f, 0.00137947f, 0.16984220f, -0.01299863f, 0.40652516f, -0.12100901f, 
    0.06477535f, -0.02054178f, 0.05763518f, 0.02584255f, 0.01076647f, 0.20306771f, 0.14911146f, -0.00491751f, 
    0.09914053f, -0.08232389f, -0.19844213f, 0.11911555f, -0.01724982f, -0.03215658f, 0.00329926f, -0.05181961f, 
    0.18205701f, 0.16387387f, 0.06826431f, -0.06523728f, -0.36798751f, 0.02788804f, 0.05342219f, -0.09036052f, 
    0.00677411f, 0.20525026f, -0.12977506f, 0.38318479f, -0.16676511f, 0.01965684f, 0.13308536f, 0.09552776f, 
    0.08888555f, 0.01019559f, -0.24308054f, 0.10975748f, 0.03647543f, -0.16452909f, 0.07562845f, -0.00228004f, 
    0.01281061f, 0.00295265f, 0.09516682f, 0.13897653f, 0.26747450f, -0.08970629f, 0.20623855f, -0.08742056f, 
    -0.22113262f, 0.10830867f, -0.00828841f, 0.10008498f, -0.09836813f, -0.18603586f, -0.10439500f, -0.12259506f, 
    0.13678764f, -0.02613650f, 0.09343056f, 0.13271637f, -0.20668593f, 0.00146272f, 0.16313224f, 0.17186937f, 
    0.04870885f, 0.06217432f, -0.03851315f, 0.00229866f, -0.14411087f, -0.10581298f, 0.18549967f, -0.13252489f, 
    0.11264946f, -0.08403617f, 0.16349098f, -0.05787706f, 0.08084524f, 0.12246350f, 0.08420312f, -0.11596614f, 
    0.09031063f, -0.04941742f, 0.24399966f, -0.01118911f, -0.06836621f, 0.17996922f, -0.11352762f, 0.10559006f, 
    0.03640584f, -0.05556557f, 0.09912609f, 0.01356512f, -0.09321781f, 0.23010950f, 0.24445131f, -0.02613043f, 
    0.24844842f, 0.14204943f, 0.08499806f, -0.00851846f, 0.09912452f, 0.21732736f, 0.28068015f, 0.31173611f, 
    0.08646277f, -0.06114912f, 0.18560663f, 0.03125675f, 0.03919333f, 0.01441881f, 0.07022723f, -0.04691634f, 
    -0.07499314f, 0.05042394f, -0.08093162f, -0.17341962f, 0.18829334f, 0.06657363f, 0.18234971f, 0.28352860f, 
    0.07215165f, -0.03725189f, 0.09937634f, 0.16640012f, -0.11237264f, 0.09018550f, -0.03544784f, -0.01511485f, 
    0.55998188f, -0.08235530f, 0.27299908f, 0.02895536f, -0.06857736f, 0.11009609f, -0.08744423f, 0.02541984f, 
    0.02114834f, 0.03023879f, -0.01584193f, -0.16323502f, -0.41321829f, 0.16103092f, -0.02433322f, -0.08167409f, 
    -0.03416528f, -0.08185074f, -0.05849816f, 0.12770097f, -0.02560817f, 0.06229463f, 0.07840044f, -0.11229016f, 
    -0.15167274f, -0.04084911f, -0.08135360f, -0.26114255f, 0.00543691f, 0.08392654f, 0.31376660f, -0.07716317f, 
    -0.04920520f, -0.12617123f, -0.28461498f, 0.01063990f, -0.36911255f, -0.01579482f, 0.14328587f, 0.48909017f, 
    0.07789131f, -0.18566158f, -0.12076198f, -0.08323838f, -0.06956910f, -0.22024377f, -0.09336393f, 0.08037177f, 
    0.04808689f, -0.06377614f, 0.20508136f, -0.00352839f, -0.00242087f, 0.04436796f, -0.01504732f, 0.04106783f, 
    0.07751250f, -0.22849897f, 0.01759153f, -0.11431692f, -0.09128168f, 0.36235157f, 0.01548508f, -0.13523512f, 
    0.09749838f, -0.06155216f, 0.09660754f, 0.02592227f, -0.04005854f, 0.03996133f, -0.10290657f, 0.07710495f, 
    0.21314318f, -0.07868028f, 0.03758226f, -0.16057670f, 0.03411927f, -0.01099740f, 0.10594547f, -0.02068005f, 
    0.16229363f, -0.01334432f, 0.22004212f, 0.17394482f, 0.13190596f, -0.30728754f, -0.03765310f, -0.07775735f, 
    0.01306530f, 0.03638063f, 0.04707554f, -0.07367756f, 0.20164096f, -0.09772663f, 0.05530438f, -0.06230942f, 
    0.37646237f, 0.19711117f, 0.07794116f, -0.28570783f, -0.05879241f, 0.03974244f, -0.00538790f, 0.09866440f, 
    0.11757636f, 0.06828846f, 0.04202197f, 0.22185974f, -0.36056435f, -0.18653940f, -0.24431595f, 0.13981418f, 
    0.13570249f, 0.09375894f, -0.04424663f, -0.08946600f, -0.01838033f, -0.06817942f, -0.03250212f, -0.22480656f, 
    -0.14125082f, 0.04892553f, -0.08735941f, 0.24042913f, 0.13415220f, 0.01778151f, -0.15733187f, 0.03488254f, 
    0.14251934f, 0.02307924f, 0.01897503f, 0.08894993f, -0.22001669f, 0.10036717f, -0.01254199f, 0.02812762f, 
    0.07387447f, -0.07307851f, -0.09997369f, -0.02313450f, 0.01754234f, -0.00030445f, 0.21742158f, 0.12493944f, 
    -0.08049539f, 0.20412306f, -0.15233395f, -0.15493457f, -0.03903516f, -0.05820935f, 0.02231238f, 0.02560346f, 
    -0.02365523f, 0.06809450f, -0.03157154f, -0.08693705f, 0.08099563f, -0.07380765f, 0.00874121f, 0.06017933f, 
    -0.02595158f, 0.00031424f, -0.00083150f, -0.00570537f, 0.11146570f, 0.04019818f, 0.06589093f, 0.12965244f, 
    -0.25396806f, 0.04834414f, -0.22888382f, 0.17593448f, -0.05754177f, -0.00823910f, -0.12213822f, -0.12753262f, 
    0.03059077f, 0.02435958f, -0.08625129f, -0.11846662f, 0.04731398f, -0.07240470f, -0.18811221f, 0.05293804f, 
    0.05275657f, -0.00923187f, 0.16597697f, -0.05780754f, -0.02788414f, -0.18508627f, -0.02616673f, -0.05253704f, 
    0.15775062f, 0.04634281f, -0.11873914f, -0.11860099f, 0.05704440f, 0.06325499f, -0.01527628f, 0.03766784f, 
    -0.12143008f, 0.04739180f, -0.00043184f, -0.10790831f, -0.10680963f, 0.26000938f, 0.06532774f, 0.10554535f, 
    -0.06304638f, -0.04056601f, 0.01682523f, 0.02529807f, 0.11406938f, -0.05255738f, 0.09340543f, -0.02705769f, 
    -0.19931266f, 0.01596531f, -0.05451652f, -0.06390986f, 0.09831705f, 0.12077621f, 0.02587127f, 0.18808860f, 
    -0.13766758f, -0.22697818f, -0.02235395f, -0.14698061f, 0.18809099f, 0.14553834f, -0.01299893f, 0.26068062f, 
    -0.02113661f, -0.11097728f, 0.14726745f, 0.16259378f, -0.00867575f, -0.05544914f, -0.01659090f, 0.08910088f, 
    -0.01235816f, -0.01027543f, -0.01712368f, 0.04458560f, -0.03788662f, -0.01895116f, 0.01961860f, -0.06838798f, 
    -0.01592617f, -0.01775106f, -0.02986917f, -0.00083167f, -0.01951403f, 0.02171895f, -0.04052868f, 0.01585231f, 
    -0.00995739f, -0.06390004f, -0.03198634f, -0.00143233f, 0.05381323f, 0.03527683f, 0.04319962f, -0.06961536f, 
    -0.06335986f, -0.01605875f, 0.00524667f, 0.04219808f, -0.05711749f, 0.02536735f, -0.02014695f, 0.01888566f, 
    0.00816702f, 0.00110583f, -0.03329026f, 0.02359100f, -0.01246417f, 0.01123612f, 0.00970744f, -0.07779890f, 
    0.04489847f, 0.00477977f, -0.05455423f, -0.00588718f, -0.04077279f, -0.05820970f, 0.03954443f, 0.02702295f, 
    0.01242721f, 0.02354460f, -0.00620877f, 0.03520513f, -0.05227141f, 0.02182545f, -0.07827770f, 0.05274794f, 
    0.04648957f, -0.06752199f, -0.02368391f, -0.06957744f, -0.05092257f, -0.01024853f, 0.01988252f, 0.00640591f, 
    0.03270362f, -0.00558181f, -0.02782768f, -0.05676163f, 0.00480701f, -0.04037441f, -0.03848128f, 0.02895733f, 
    0.02863798f, -0.03608380f, 0.00774074f, 0.01378499f, 0.00593213f, -0.04259263f, -0.06625398f, -0.07131866f, 
    0.04227781f, -0.07875274f, -0.04648495f, -0.05328946f, 0.01846761f, -0.07574621f, 0.04736910f, -0.08045889f, 
    0.06280762f, -0.07900897f, 0.05146853f, 0.04806862f, -0.05769158f, -0.06339348f, -0.06481139f, 0.03285616f, 
    -0.07187380f, 0.03248470f, -0.00210453f, -0.08011831f, 0.01844936f, 0.05397104f, 0.01527969f, 0.00271408f, 
    0.04018737f, 0.00142771f, -0.04480280f, 0.05791512f, -0.04120950f, -0.04116298f, 0.00237096f, -0.03989197f, 
    0.03198735f, 0.00046195f, -0.03111640f, -0.01233424f, -0.02477980f, 0.04010479f, 0.01133958f, -0.06087365f, 
    -0.00180130f, 0.00436341f, -0.02618024f, -0.03360871f, -0.04302853f, -0.06734488f, 0.00509648f, -0.03448231f, 
    0.03808539f, -0.03662870f, -0.04841024f, 0.01710961f, 0.05003973f, 0.01345623f, -0.05564208f, -0.01747549f, 
    -0.03971196f, 0.04997833f, 0.02982523f, 0.01820330f, 0.02292221f, 0.04087808f, -0.07766716f, -0.01440703f, 
    0.02020928f, -0.02403048f, 0.03329488f, -0.05500463f, -0.07685363f, -0.01220405f, -0.01581269f, -0.00842054f, 
    -0.01951923f, -0.06141191f, -0.02345494f, 0.00827510f, -0.01012328f, -0.08103535f, -0.03662078f, 0.01551851f, 
    0.02809446f, -0.02040086f, -0.04850922f, 0.04636208f, -0.05536770f, -0.07412262f, -0.00300657f, -0.00866189f, 
    0.01578689f, 0.00427663f, -0.06075823f, 0.04029309f, 0.04585417f, 0.04173608f, 0.03885515f, 0.05385689f, 
    -0.07137952f, -0.06291274f, -0.06276794f, -0.03043019f, -0.03028380f, -0.05194682f, 0.02974139f, -0.00914008f, 
    -0.03278534f, 0.01298135f, 0.03004267f, 0.01133643f, 0.00869618f, -0.02989249f, 0.01569461f, 0.02789644f, 
    -0.18312864f, 0.10498400f, -0.28526172f, 0.18163592f, 0.06636493f, 0.04784958f, -0.10518617f, 0.23628107f, 
    -0.15796943f, 0.07639123f, -0.06682012f, 0.11803075f, 0.16938338f, -0.11273821f, 0.14207102f, 0.10718752f, 
    -0.09558363f, 0.07955065f, 0.02926324f, 0.06918386f, 0.04093242f, 0.00027764f, -0.04058748f, 0.04728973f, 
    -0.04269570f, 0.05440344f, 0.00446138f, 0.16714901f, -0.17786589f, -0.02054521f, -0.00834085f, 0.03973901f, 
    0.02795513f, 0.20558415f, -0.11294323f, 0.02784573f, 0.24473070f, 0.63185227f, 0.01800190f, 0.29739699f, 
    -0.01823497f, 0.10915542f, 0.01976676f, 0.05069214f, 0.03390883f, -0.06391702f, -0.03264919f, -0.01749243f, 
    -0.05431591f, -0.09510207f, -0.02294261f, 0.13320717f, -0.01754196f, -0.02940910f, 0.04683518f, -0.03434459f, 
    -0.01491996f, 0.03014188f, -0.01491310f, 0.08975664f, 0.49908626f, 0.20949624f, 0.17722058f, -0.22716422f, 
    -0.07079463f, -0.04898961f, -0.04406615f, 0.11937638f, -0.17641449f, -0.03717449f, -0.06715503f, -0.03551012f, 
    0.31437281f, 0.04025646f, 0.11589348f, -0.28917554f, -0.08387849f, -0.05408317f, 0.16609319f, -0.04197535f, 
    0.10426266f, -0.01339494f, -0.02913072f, -0.06433942f, 0.09348879f, -0.22569703f, 0.15022494f, -0.05035869f, 
    0.01033460f, -0.00489164f, -0.02035449f, -0.01946872f, 0.02834051f, 0.01821585f, -0.14635697f, -0.12359039f, 
    0.07891839f, -0.17251720f, 0.17876042f, -0.04647855f, -0.15833627f, 0.00795365f, -0.24329875f, -0.10584519f, 
    -0.03676848f, -0.19137834f, -0.04207554f, -0.15424661f, -0.19870804f, -0.06475755f, -0.11859146f, 0.05247948f, 
    0.13466737f, 0.15627050f, 0.09844133f, -0.03597051f, -0.03988133f, -0.01861949f, -0.04456892f, 0.01768882f, 
    0.38358730f, -0.04265316f, 0.29983860f, -0.14614795f, -0.00679646f, -0.01022304f, 0.05308620f, 0.02733876f, 
    0.04745954f, 0.05245766f, 0.07492801f, 0.04812200f, 0.11329018f, 0.18107958f, 0.27778029f, 0.20995370f, 
    0.06620720f, 0.08065011f, 0.11286334f, 0.10439617f, 0.02841360f, -0.00863449f, 0.19472934f, 0.16405711f, 
    0.41712999f, -0.06182061f, 0.59765637f, 0.08933873f, -0.06965347f, -0.11888655f, -0.10744098f, 0.04822427f, 
    0.00280313f, -0.02498309f, -0.03787142f, 0.02611674f, -0.07449675f, -0.05855969f, 0.08763663f, 0.01983337f, 
    -0.02765148f, -0.06407283f, -0.23674528f, 0.04003303f, -0.08097980f, 0.15262944f, 0.12582989f, -0.01091599f, 
    -0.00175211f, -0.12437035f, -0.09813684f, -0.02614425f, -0.12811708f, -0.09146819f, 0.11158983f, -0.15059313f, 
    -0.10221668f, -0.14153019f, -0.12112956f, -0.11429780f, -0.22598460f, 0.03441613f, 0.02983857f, -0.04149165f, 
    0.07858948f, -0.04559538f, 0.12975720f, -0.04271559f, -0.07523071f, 0.01932810f, -0.05274502f, 0.07134629f, 
    0.09421048f, 0.15058933f, -0.00355667f, 0.14684997f, -0.07451706f, 0.01986257f, 0.05629728f, 0.10843494f, 
    0.03471897f, -0.03815240f, 0.09383066f, 0.06779942f, 0.13066345f, 0.15004967f, 0.25746754f, 0.13262525f, 
    0.01043779f, -0.07018801f, 0.16960816f, -0.08480754f, -0.04412305f, -0.13057449f, -0.13872401f, 0.09062739f, 
    -0.20289840f, 0.09025680f, 0.10260381f, -0.00349536f, 0.03263959f, -0.02249854f, -0.18126889f, -0.22811206f, 
    0.05419220f, -0.03231729f, 0.02635033f, -0.01110610f, 0.44681743f, 0.34581268f, 0.00377428f, 0.27846593f, 
    -0.08207198f, 0.05970002f, -0.00540693f, -0.16428865f, 0.05000117f, 0.05977346f, -0.03990371f, -0.05779946f, 
    -0.08398740f, 0.20530508f, 0.05579368f, -0.02518280f, 0.01543545f, 0.08225536f, -0.08792102f, 0.01474996f, 
    0.11240896f, -0.20487152f, -0.00285700f, 0.07333799f, 0.06583104f, -0.05694097f, 0.15080506f, 0.05673594f, 
    -0.11118641f, -0.03454100f, -0.19960634f, -0.01426352f, -0.08369316f, -0.01399184f, -0.05327312f, 0.06337886f, 
    0.22927792f, 0.03355014f, -0.08399970f, -0.24331352f, 0.16459365f, -0.00273315f, -0.14551139f, -0.01114841f, 
    -0.03389334f, 0.03458241f, -0.02640834f, 0.02287314f, 0.19041395f, -0.10899526f, -0.05856983f, 0.19617084f, 
    0.00857927f, -0.02170425f, -0.06911384f, 0.00087734f, -0.02902937f, 0.00706167f, -0.04918491f, -0.04220642f, 
    -0.08078525f, -0.49116880f, 0.11796075f, 0.01531774f, 0.11310594f, 0.20793048f, 0.02107356f, -0.30734274f, 
    0.04849559f, 0.05336957f, -0.08758055f, 0.02363532f, 0.11862353f, 0.15434285f, -0.20073117f, 0.02189392f, 
    0.06218806f, -0.05767401f, 0.08953801f, 0.07217308f, -0.10139380f, -0.09491317f, 0.00352276f, 0.02268102f, 
    -0.20500770f, -0.11042297f, 0.22646387f, -0.07985379f, -0.17335843f, 0.07361465f, -0.26727501f, -0.16777229f, 
    0.01805670f, 0.01505488f, 0.21566154f, -0.09660164f, -0.49311203f, 0.19126841f, -0.05704528f, -0.05547533f, 
    -0.08976321f, -0.15378124f, -0.06858586f, -0.27961108f, 0.05135652f, -0.07368793f, 0.14103799f, 0.03786457f, 
    -0.62661594f, -0.24898434f, 0.17488840f, -0.00508659f, -0.00757221f, -0.09681445f, -0.30501989f, -0.23918192f, 
    -0.03171702f, -0.07285268f, 0.08223912f, 0.05411883f, 0.55826557f, 0.01183750f, 0.41178077f, 0.39124161f, 
    0.09339854f, 0.00924154f, 0.16879076f, 0.07055005f, -0.08440156f, 0.06572881f, -0.03070186f, 0.02552249f, 
    0.22928348f, 0.01544211f, 0.12734273f, 0.06149458f, 0.11878532f, 0.11099295f, 0.08559196f, 0.33392066f, 
    -0.08250596f, 0.00041730f, 0.23771855f, 0.12169043f, -0.04645690f, 0.00719187f, -0.22422913f, -0.39888149f, 
    -0.01536263f, -0.02661231f, 0.13873091f, 0.20242250f, -0.01884496f, 0.10556445f, -0.03126436f, -0.00592743f, 
    0.02513195f, 0.22185186f, -0.02023484f, 0.23164774f, -0.06887377f, 0.13857447f, 0.15031952f, 0.12304749f, 
    -0.23491448f, 0.11472899f, 0.01709670f, 0.00850809f, 0.01264903f, 0.01335174f, 0.30965087f, 0.11106277f, 
    -0.06303147f, -0.07120895f, 0.17784514f, -0.05932225f, 0.02767777f, -0.10532349f, -0.05614316f, -0.17199756f, 
    0.05412497f, 0.15435940f, -0.01393538f, -0.00309325f, -0.06479326f, -0.09828693f, -0.09981120f, -0.06923961f, 
    -0.10875677f, -0.18282451f, -0.20862629f, -0.16631043f, 0.07805032f, 0.17968652f, 0.24516599f, -0.06484746f, 
    -0.06282087f, 0.20774822f, -0.15679178f, -0.02347679f, -0.14262487f, -0.20140675f, 0.06326902f, 0.04174140f, 
    -0.14356746f, 0.30440339f, -0.08707375f, 0.09827499f, 0.07124405f, -0.08357274f, -0.13236561f, -0.13173795f, 
    -0.02468829f, -0.17360717f, -0.13227953f, -0.00373252f, 0.31753644f, 0.06888362f, 0.11569212f, -0.00678105f, 
    0.00683454f, 0.04633628f, 0.04879901f, -0.02507020f, 0.04889664f, 0.03235750f, -0.07973092f, 0.03438419f, 
    0.19642949f, -0.15874238f, -0.12324711f, 0.06498659f, 0.00036964f, -0.18674873f, 0.02981475f, 0.07482556f, 
    -0.33545139f, -0.13906993f, -0.03851579f, 0.01045702f, 0.07149586f, 0.00731638f, 0.10209350f, 0.08085487f, 
    -0.10932252f, -0.02468573f, 0.12450951f, 0.21857144f, -0.13233916f, -0.29272217f, 0.02937779f, -0.11619388f, 
    -0.08495458f, -0.10023766f, 0.27140710f, 0.11733292f, -0.02413269f, 0.18633017f, 0.05698380f, -0.15094858f, 
    -0.06854528f, -0.12029482f, -0.19936115f, -0.15664580f, 0.02773278f, 0.14466712f, 0.02018581f, 0.09143145f, 
    -0.04783897f, -0.02304421f, 0.02383969f, 0.08246055f, -0.01925669f, 0.06058578f, -0.02129590f, 0.02251370f, 
    0.16160242f, 0.20255855f, 0.23690836f, 0.13658357f, -0.00599151f, 0.01621314f, 0.02205146f, 0.13045365f, 
    0.03603107f, -0.00383323f, 0.16798943f, -0.04860747f, -0.11261548f, 0.38247782f, 0.20473094f, -0.01779253f, 
    -0.02361540f, 0.05341542f, 0.07671597f, -0.08079716f, 0.07062627f, 0.03777361f, 0.09784200f, 0.11899412f, 
    0.09905201f, 0.12092587f, 0.24708971f, 0.04022302f, 0.03101335f, 0.06271599f, -0.18022543f, -0.03263174f, 
    0.03663596f, -0.17935476f, 0.04765569f, -0.21476986f, 0.21582511f, -0.06295988f, 0.23197687f, 0.06627861f, 
    -0.09248564f, -0.25658706f, -0.05851312f, 0.00514914f, 0.10530913f, 0.06085340f, 0.01628049f, 0.03638100f, 
    0.00170853f, -0.16751315f, 0.03317848f, 0.05363201f, -0.19095005f, -0.06392550f, 0.07781713f, 0.03103752f, 
    -0.17738585f, -0.00157283f, -0.01341554f, 0.00681054f, 0.01712138f, 0.24014845f, -0.06661183f, -0.06741694f, 
    0.03772463f, 0.01252540f, 0.10762537f, -0.00260244f, -0.06736099f, 0.04411848f, -0.01669007f, -0.05042750f, 
    0.02029489f, -0.03427120f, -0.05037607f, -0.05634915f, 0.03686075f, -0.04341081f, -0.06584787f, 0.03145884f, 
    0.00305063f, -0.06674688f, 0.02032568f, -0.08124295f, -0.05768911f, 0.01739787f, 0.04867906f, -0.06113835f, 
    0.03916627f, -0.06936554f, -0.04339368f, -0.04399645f, 0.04514353f, -0.04486225f, 0.05240578f, 0.01406277f, 
    -0.02394915f, 0.00893624f, 0.00281138f, -0.06264737f, -0.05089949f, -0.00388975f, 0.01690327f, -0.07945564f, 
    -0.00275534f, -0.02573874f, -0.03511398f, 0.04287097f, -0.07918721f, 0.05011013f, -0.02501662f, 0.02766839f, 
    0.01863947f, 0.01044108f, 0.05050870f, -0.00144359f, -0.07114083f, -0.04301241f, -0.04614219f, -0.00674974f, 
    -0.02133916f, 0.03061766f, -0.07648746f, 0.01558395f, -0.02937023f, 0.02368576f, -0.02899549f, 0.03929454f, 
    -0.05652769f, -0.02621663f, -0.05714034f, -0.07701737f, -0.04470433f, 0.02704062f, 0.02219519f, -0.01067191f, 
    0.02566790f, 0.00762697f, 0.04439721f, 0.03241892f, -0.06986071f, 0.05618507f, 0.03273695f, 0.00305672f, 
    0.00425642f, -0.06159940f, -0.03109450f, -0.06020207f, -0.00163974f, -0.06629001f, -0.05568097f, -0.05051224f, 
    -0.00997420f, -0.04822576f, 0.02257239f, 0.06244406f, 0.01199363f, 0.02936758f, 0.03069941f, -0.04827206f, 
    -0.04247676f, -0.02454589f, -0.06013194f, -0.01816669f, 0.05019925f, -0.04260042f, 0.00039533f, 0.05664911f, 
    -0.07044540f, 0.05916094f, -0.00920327f, -0.00174726f, 0.05143870f, -0.05320314f, -0.03149435f, 0.01018894f, 
    0.00656449f, -0.05814399f, -0.05207633f, -0.00927542f, -0.03191902f, -0.04547755f, 0.02984046f, -0.04897912f, 
    0.05717885f, 0.04759172f, 0.03406281f, 0.04630751f, -0.00068063f, 0.04931009f, 0.06452330f, -0.00280675f, 
    -0.01939078f, 0.01773961f, -0.00903281f, -0.00259125f, 0.04754608f, -0.01863202f, -0.04078780f, 0.00081271f, 
    0.05765365f, -0.01099847f, -0.06909895f, 0.03454318f, 0.00438175f, -0.05383828f, -0.04928068f, 0.02562884f, 
    -0.01129066f, -0.04381024f, 0.01449393f, -0.01797112f, 0.03351118f, -0.01744655f, -0.07864276f, -0.03370620f, 
    -0.05629222f, -0.00668663f, -0.06917308f, 0.05008361f, 0.03162323f, 0.04661494f, 0.04762363f, 0.03691030f, 
    -0.05055752f, 0.01119707f, 0.02211612f, 0.02224419f, -0.07462734f, -0.03307617f, -0.07143168f, -0.04888209f, 
    -0.06401028f, 0.04693052f, -0.04209748f, -0.08121231f, 0.04596176f, 0.03732684f, 0.03294433f, -0.00380854f, 
    0.03400597f, 0.04264048f, 0.02148112f, -0.07341225f, 0.01932604f, -0.03463336f, -0.06711908f, -0.03365302f, 
    0.02622814f, -0.04686270f, -0.00008480f, 0.05585625f, -0.02765321f, -0.05385164f, -0.02019566f, 0.04637975f, 
    -0.04544803f, 0.00722598f, 0.03875665f, 0.04111280f, -0.07504552f, 0.00017795f, -0.06386717f, -0.07229536f, 
    -0.07792775f, -0.20741536f, -0.10314146f, 0.09831467f, 0.02798795f, 0.12076036f, 0.08504324f, 0.08684848f, 
    -0.02757390f, 0.18571413f, 0.03147551f, 0.12743860f, 0.00881226f, -0.05094212f, -0.08200393f, 0.34969279f, 
    -0.09069827f, 0.06548154f, 0.22714551f, -0.10835028f, 0.00090190f, 0.03435334f, -0.07947825f, 0.03122049f, 
    -0.08193249f, 0.20312364f, -0.06602572f, 0.08464994f, 0.03877489f, -0.08319128f, -0.02908453f, -0.03493745f, 
    -0.24986939f, -0.19965948f, -0.12630638f, -0.06480006f, 0.07110353f, 0.52031839f, 0.07455802f, 0.25281814f, 
    -0.20213489f, 0.03537308f, 0.19975941f, -0.09197132f, -0.03774545f, -0.05644144f, -0.03123171f, 0.00989585f, 
    -0.17024100f, 0.09124479f, -0.08155397f, 0.23685613f, 0.07289162f, 0.00673446f, 0.09829903f, -0.10828012f, 
    -0.06013099f, -0.08374308f, -0.01955742f, -0.01547651f, 0.33487779f, 0.11608844f, 0.33307222f, -0.13513072f, 
    0.06331309f, -0.08350340f, -0.18834285f, 0.04910456f, 0.02660637f, 0.11696855f, 0.05537343f, 0.01813980f, 
    0.11934068f, -0.09191624f, 0.21973671f, -0.05893095f, -0.00796128f, -0.11315110f, 0.02404365f, -0.01318243f, 
    -0.03674089f, -0.04364524f, -0.08271535f, -0.07298940f, -0.03280881f, -0.14359429f, -0.04160323f, 0.02448147f, 
    -0.10072739f, -0.02403739f, 0.05891784f, -0.01840769f, 0.00658384f, -0.08070605f, -0.09456913f, -0.07202828f, 
    -0.01650105f, -0.19832771f, 0.02557137f, 0.01954136f, 0.12876645f, 0.11235098f, -0.22539566f, -0.10255426f, 
    0.00565815f, -0.08098579f, -0.09892695f, 0.05871207f, -0.07975660f, -0.24272181f, -0.01280120f, 0.00302943f, 
    0.01402653f, 0.00248309f, 0.03848181f, 0.11178647f, 0.01694532f, -0.04915296f, 0.10951468f, 0.01015711f, 
    0.48825777f, 0.09045999f, 0.28818282f, 0.01207534f, 0.10791277f, -0.01732857f, -0.03350888f, 0.06264377f, 
    -0.03974690f, 0.01805397f, 0.16942705f, -0.00742347f, -0.03995077f, 0.17558978f, 0.20789869f, 0.10290156f, 
    0.01805791f, 0.00859092f, -0.16510828f, 0.04177491f, -0.00248774f, 0.08313019f, 0.19964856f, 0.03606790f, 
    0.13546667f, 0.01320887f, 0.37784961f, -0.00246945f, -0.04505168f, 0.03425212f, -0.20929877f, -0.03312417f, 
    0.01089276f, -0.14138328f, 0.03547611f, 0.00922663f, -0.17400421f, -0.22471817f, 0.05220352f, -0.08616803f, 
    0.07519573f, 0.14314236f, 0.23887570f, -0.00048252f, -0.00818219f, 0.14450555f, 0.03765781f, -0.02909882f, 
    -0.00840427f, 0.00610139f, -0.05071715f, -0.04687823f, 0.00696482f, -0.08871180f, 0.04008067f, -0.12951265f, 
    0.01384802f, 0.16341232f, 0.16559465f, 0.07412076f, -0.02766743f, -0.25624126f, -0.11749423f, -0.27298167f, 
    0.09473637f, 0.04746944f, 0.06957006f, 0.04066332f, 0.08988524f, 0.09296449f, 0.08223575f, 0.08977905f, 
    -0.01332186f, 0.31022501f, 0.30936259f, 0.34644815f, -0.00407232f, -0.02206455f, 0.16455626f, 0.25743377f, 
    0.15863578f, 0.07497705f, 0.02064303f, 0.11096888f, 0.15616547f, 0.25576985f, -0.03919401f, -0.03738885f, 
    0.04538136f, 0.07827850f, 0.20636991f, 0.06547344f, 0.11320166f, -0.01296020f, 0.08388770f, 0.01338901f, 
    0.20175469f, -0.03228502f, -0.13216098f, -0.18879808f, -0.07976875f, -0.02496293f, -0.13806237f, -0.28318661f, 
    -0.06443816f, -0.15650661f, 0.01195466f, -0.28580210f, 0.22033441f, 0.33397499f, 0.10388245f, 0.18011227f, 
    -0.20659287f, 0.08886882f, -0.04083481f, 0.21356319f, -0.11132697f, 0.03548541f, 0.25649318f, 0.02682278f, 
    0.14211637f, 0.00134711f, 0.00372678f, -0.25844511f, -0.09058969f, -0.03466800f, -0.01818627f, -0.01204463f, 
    0.11868388f, -0.08581073f, 0.05435036f, 0.06997528f, -0.03667203f, -0.23215683f, -0.11147180f, -0.02761132f, 
    -0.05517911f, -0.06864076f, -0.11234182f, -0.05198773f, 0.10582666f, 0.12696286f, -0.10017813f, 0.10048141f, 
    -0.03653267f, -0.10391459f, -0.02627952f, 0.01355362f, 0.10610437f, -0.11590607f, -0.06597578f, 0.13053888f, 
    -0.18732737f, 0.09821820f, -0.15063155f, -0.19487971f, -0.00504917f, 0.07550812f, 0.18508764f, 0.17781201f, 
    -0.08905755f, -0.04514537f, -0.06074632f, 0.04684035f, -0.03645445f, -0.15326425f, -0.18553880f, -0.13156843f, 
    0.02356188f, 0.21622387f, 0.19669779f, 0.23738496f, 0.17759611f, 0.14617693f, 0.12151609f, -0.03249334f, 
    -0.23625067f, -0.05976805f, 0.01243887f, 0.15873004f, -0.06113324f, 0.02485824f, 0.09292079f, 0.20936416f, 
    -0.01941599f, -0.02509684f, 0.04200754f, 0.00800369f, 0.14376947f, -0.06944183f, -0.19225210f, -0.14139377f, 
    -0.28170568f, -0.11421373f, -0.00074189f, -0.17259787f, -0.09151918f, 0.15441835f, -0.11017442f, -0.09119214f, 
    0.07115895f, 0.10244919f, 0.18485513f, 0.08912028f, 0.02941353f, -0.19119291f, -0.21780387f, -0.15736657f, 
    0.02306466f, -0.00261514f, -0.03603347f, 0.05074754f, 0.11447256f, 0.12804399f, 0.19195670f, -0.00743683f, 
    0.38907558f, 0.05180496f, -0.30633911f, -0.25437874f, -0.06515020f, 0.05567786f, 0.00662113f, -0.14919084f, 
    0.06016034f, -0.12043277f, 0.05329527f, -0.08515579f, 0.02258806f, 0.16805018f, 0.13848822f, 0.01705363f, 
    -0.00825440f, -0.10841925f, 0.11847894f, -0.00684522f, -0.03233062f, 0.05643094f, 0.07331788f, -0.02510967f, 
    0.04032672f, 0.15725337f, 0.39820537f, 0.15536548f, -0.00686285f, -0.11521587f, 0.14481598f, 0.20433767f, 
    0.09603996f, 0.09092095f, 0.09240067f, 0.28499421f, -0.35088652f, -0.08200391f, -0.25566506f, -0.20737877f, 
    -0.09295666f, -0.08044205f, -0.26647359f, -0.20194919f, -0.06660771f, -0.05536620f, 0.00287781f, 0.11402506f, 
    -0.05118689f, -0.07336371f, 0.06075589f, 0.02248702f, 0.02319893f, 0.01631336f, -0.04816225f, -0.06170571f, 
    -0.04278434f, -0.01493752f, -0.06360047f, 0.00995013f, -0.07096913f, -0.02941562f, -0.02188366f, -0.03353635f, 
    -0.06860749f, 0.04251651f, 0.03358213f, 0.03962459f, 0.06849328f, 0.06323473f, -0.01211902f, 0.00622041f, 
    -0.02797544f, -0.05727516f, -0.05636793f, -0.06468873f, -0.03184221f, 0.04532517f, 0.02013086f, 0.06438360f, 
    -0.00589815f, 0.04432074f, 0.04055461f, -0.06063065f, -0.04775578f, -0.05370761f, 0.04922019f, -0.02536530f, 
    0.01079013f, -0.07675199f, 0.06031379f, 0.01715986f, -0.06187388f, -0.05935249f, -0.03312871f, -0.02411253f, 
    0.02246213f, -0.05027026f, 0.00445914f, -0.01155078f, 0.06223305f, -0.05730150f, 0.00755718f, 0.05081160f, 
    0.03672807f, -0.04551369f, 0.01200567f, -0.07610057f, -0.07636625f, -0.05017073f, 0.05830000f, 0.03919181f, 
    -0.01276015f, 0.04824175f, -0.06467737f, -0.06897388f, -0.07317574f, 0.03545509f, -0.03745931f, 0.01979607f, 
    0.05038973f, -0.02384521f, -0.02652672f, 0.03252223f, -0.06738246f, 0.02892127f, -0.05382206f, -0.03041133f, 
    -0.03999516f, 0.03709356f, 0.03229110f, 0.03338848f, 0.00201799f, 0.03865661f, -0.07350676f, -0.06428351f, 
    0.05633046f, 0.01425116f, 0.06069884f, 0.03339452f, -0.03960803f, -0.05725904f, -0.03858864f, 0.00138143f, 
    -0.00285520f, -0.05960984f, -0.06678968f, 0.06362519f, 0.04670323f, -0.03293400f, 0.00174044f, 0.01534373f, 
    0.03657045f, 0.05857106f, -0.05471365f, 0.05588098f, 0.01066760f, -0.04076150f, -0.01093914f, 0.00338256f, 
    0.03625963f, -0.04826089f, 0.06231145f, -0.03103711f, -0.03352399f, 0.01975569f, 0.03634353f, -0.02110665f, 
    0.05437377f, -0.00020990f, 0.03353209f, 0.06075360f, -0.01259306f, -0.07235554f, -0.01390558f, 0.01452793f, 
    0.02125598f, 0.01129423f, 0.01196704f, -0.07725894f, -0.04154675f, -0.03835341f, -0.02809790f, -0.01192261f, 
    0.02425462f, -0.07718045f, -0.02899063f, -0.01281218f, 0.01614301f, -0.06410389f, -0.03946814f, -0.02286339f, 
    -0.07639079f, 0.03023424f, -0.06483411f, -0.07217786f, -0.03740827f, -0.01209100f, -0.04768134f, -0.03312377f, 
    0.05790430f, -0.01439619f, -0.07493475f, -0.02825042f, -0.04256535f, -0.01350678f, -0.05354641f, 0.05063692f, 
    -0.06210623f, -0.00849756f, 0.03891278f, -0.06080352f, 0.01680437f, 0.03582567f, 0.03262186f, 0.03412052f, 
    -0.05600247f, 0.05772192f, -0.04843772f, 0.03380624f, -0.05369660f, -0.00174958f, -0.01824986f, 0.01704408f, 
    -0.04608413f, 0.00457917f, 0.05682300f, 0.00376066f, 0.05714662f, -0.02854419f, 0.04366101f, 0.00169524f, 
    -0.01201709f, -0.02019600f, -0.07017705f, -0.00007354f, -0.03658964f, -0.08010606f, -0.05332964f, -0.03486068f, 
    0.18943366f, 0.25946593f, 0.06208688f, -0.08825365f, 0.00945148f, 0.04465329f, 0.00751598f, 0.03656922f, 
    0.01989435f, -0.05239380f, -0.02745413f, -0.01506245f, 0.07624076f, -0.00837178f, 0.04012987f, -0.21676014f, 
    0.23633504f, -0.01379178f, -0.05778942f, 0.10206799f, -0.01144315f, 0.06750386f, -0.10278354f, 0.14700615f, 
    0.17751975f, -0.05684945f, -0.01722044f, -0.05951969f, -0.05828215f, 0.06733841f, -0.04939419f, -0.04113114f, 
    0.14656106f, -0.00992672f, 0.08053690f, 0.03869575f, 0.17600299f, -0.38490865f, -0.03364044f, -0.02264760f, 
    0.12896436f, 0.03112670f, -0.02402987f, 0.10407017f, 0.15569511f, 0.07266406f, 0.01996851f, 0.02705031f, 
    0.18583025f, 0.04482414f, -0.01158845f, -0.18427345f, 0.07382254f, 0.00680969f, -0.05897692f, 0.09098963f, 
    0.16554490f, 0.01058582f, 0.09429915f, 0.12166861f, -0.37096092f, -0.18968540f, -0.05652629f, 0.12549862f, 
    -0.03431654f, 0.12469786f, -0.06146097f, 0.14158764f, 0.08106629f, -0.14200719f, -0.06980259f, -0.05587067f, 
    -0.05292461f, 0.05453939f, -0.05533118f, 0.13626036f, 0.10180782f, 0.04078206f, -0.07852791f, 0.03954086f, 
    0.07996171f, 0.03343520f, 0.01022948f, 0.09706482f, 0.11572509f, 0.17820057f, -0.08233041f, -0.01887858f, 
    0.13834563f, 0.03111636f, -0.02541891f, 0.09791192f, 0.07567492f, 0.07352052f, 0.12728454f, 0.02466420f, 
    0.12440114f, 0.25605211f, 0.06261943f, 0.06751589f, -0.08051211f, 0.14614376f, 0.09893575f, 0.12943722f, 
    0.03919101f, 0.03768080f, 0.04480233f, -0.08471436f, 0.05807985f, 0.21035367f, 0.02991133f, -0.06758738f, 
    -0.02520211f, -0.03653627f, 0.07073012f, 0.02445455f, 0.03830596f, 0.08696519f, -0.03761061f, 0.23039983f, 
    -0.39947030f, 0.01375172f, -0.15733361f, 0.11563110f, -0.12194365f, 0.06786640f, -0.04400485f, 0.00989161f, 
    0.03769941f, -0.06419077f, -0.07564807f, 0.02504637f, -0.00286759f, -0.15437050f, -0.25961837f, 0.01976120f, 
    0.06124758f, -0.05613827f, 0.18345957f, 0.01028907f, 0.01677146f, -0.16644478f, -0.04722913f, -0.04705868f, 
    -0.08938243f, 0.06769365f, -0.20805614f, 0.20759140f, -0.03354099f, 0.02222452f, -0.01058557f, 0.07500996f, 
    -0.06050559f, -0.02897376f, -0.01042891f, -0.04285786f, 0.25591463f, 0.22315656f, 0.05484445f, 0.08679494f, 
    0.02899152f, -0.02400650f, -0.02245450f, 0.07722630f, 0.05218571f, -0.09878694f, 0.05475204f, 0.09631760f, 
    0.13802908f, 0.16461580f, 0.01434376f, 0.03304502f, 0.00989596f, 0.12113193f, 0.08985118f, 0.10954359f, 
    -0.03568840f, -0.14669760f, -0.03357020f, -0.11002792f, 0.17177965f, 0.37993583f, 0.14789400f, 0.19731699f, 
    -0.00101956f, 0.01417667f, -0.06801723f, 0.04003436f, -0.10735016f, -0.10816342f, -0.19753517f, -0.06003308f, 
    0.11186491f, 0.19663575f, -0.01695635f, 0.11425322f, 0.15308602f, 0.03345990f, 0.10205189f, 0.02379928f, 
    0.04252968f, -0.02068932f, 0.04842075f, 0.06605001f, 0.33750990f, 0.19929597f, 0.02972090f, 0.24814983f, 
    -0.11910184f, 0.12956968f, 0.08216482f, 0.03458605f, 0.01836971f, 0.00680885f, 0.02399451f, 0.03794622f, 
    -0.09536527f, -0.02393715f, -0.19273803f, 0.17540550f, 0.02424289f, -0.15551160f, -0.14283440f, -0.14348088f, 
    -0.14543723f, 0.07264019f, -0.04945470f, 0.02119279f, 0.04630731f, 0.16562977f, -0.18597819f, 0.04968689f, 
    -0.15546843f, 0.02711759f, 0.12730983f, 0.19049768f, -0.04005919f, 0.31170359f, 0.03221287f, 0.00700605f, 
    -0.14940485f, 0.06247455f, -0.27284300f, 0.06715791f, 0.05084581f, -0.11352212f, 0.09492226f, 0.07065246f, 
    0.03794790f, 0.09412276f, 0.14331353f, 0.20629519f, 0.27494469f, 0.04240566f, 0.47637403f, 0.04712347f, 
    -0.15012643f, 0.10133068f, -0.15583731f, -0.01875644f, -0.21303223f, -0.10917308f, -0.22218971f, 0.09671612f, 
    0.17554012f, 0.26116586f, 0.23660466f, -0.20427743f, -0.06353649f, -0.01053598f, -0.02747909f, 0.14327179f, 
    -0.03994997f, 0.03940145f, -0.08885774f, -0.05708988f, 0.01681611f, 0.13730952f, 0.02035284f, -0.15881814f, 
    0.12432960f, 0.08033158f, -0.01457323f, 0.05510767f, -0.09866317f, -0.21940412f, -0.01612242f, -0.08759198f, 
    0.12065224f, -0.16864617f, 0.16618277f, -0.11523338f, 0.14105734f, 0.16966820f, -0.13305001f, -0.02109884f, 
    0.03043220f, 0.02402186f, 0.03128286f, 0.02444369f, 0.20881949f, 0.14082308f, 0.07834263f, -0.07971292f, 
    0.03709162f, -0.04567893f, -0.03741112f, -0.07586814f, -0.00582321f, -0.11835035f, 0.00738706f, 0.13439511f, 
    0.15810028f, -0.10457814f, 0.54114473f, 0.07674166f, 0.19345260f, 0.05738244f, -0.03855218f, 0.01717324f, 
    -0.14989296f, -0.08848941f, 0.15032536f, 0.03131140f, -0.02020856f, -0.07094360f, 0.33077559f, 0.06717568f, 
    0.05139322f, -0.11216652f, 0.01447494f, 0.17226398f, -0.01434205f, 0.07789340f, 0.14714243f, 0.11253657f, 
    -0.01449998f, -0.09895577f, 0.21648355f, -0.06459811f, -0.00083089f, 0.03624356f, -0.18386935f, -0.10115955f, 
    -0.08018965f, -0.07784759f, 0.16241546f, -0.02034478f, -0.18115434f, 0.05933128f, 0.07369424f, -0.01724118f, 
    -0.01679447f, -0.05128161f, 0.08435493f, 0.06461397f, 0.08203653f, 0.11714438f, -0.02756017f, -0.04192808f, 
    -0.05195534f, -0.00876279f, -0.04159830f, -0.03342805f, 0.25777724f, -0.02462382f, 0.14828153f, 0.08341730f, 
    0.06931487f, -0.14874505f, -0.10362690f, 0.00153967f, -0.24737708f, -0.37100437f, -0.04608562f, 0.15283825f, 
    -0.14039834f, -0.11372516f, -0.16888180f, -0.07320397f, 0.04563906f, -0.04389465f, 0.00079020f, 0.04068298f, 
    -0.02139519f, -0.26095060f, 0.14711070f, -0.03189811f, -0.15788683f, -0.03307453f, -0.09140066f, -0.01673268f, 
    -0.13837865f, 0.15211137f, -0.03691663f, -0.08556572f, -0.18852212f, 0.09666763f, 0.03704698f, 0.10089129f, 
    0.14372838f, -0.12050593f, -0.07373545f, -0.05398693f, 0.08558970f, 0.06165643f, 0.06445730f, 0.04179036f, 
    0.08268449f, 0.14676711f, 0.21487090f, 0.00779782f, 0.01305054f, -0.01774462f, 0.05774717f, -0.07116211f, 
    0.05664707f, 0.01090374f, 0.09092665f, 0.11125702f, -0.28712749f, 0.33866006f, 0.07259883f, 0.22558355f, 
    0.21986914f, 0.06172164f, -0.05400033f, -0.17725506f, -0.01086397f, -0.02858118f, 0.04818915f, -0.19115742f, 
    0.04772273f, 0.22873269f, 0.27381086f, 0.01245331f, -0.03432235f, -0.00480783f, -0.01806482f, -0.23008035f, 
    0.05511062f, 0.02024426f, -0.02505753f, -0.02767082f, 0.03416773f, -0.06020582f, -0.08228214f, 0.03283866f, 
    -0.02036858f, -0.00149730f, 0.19352488f, 0.00732210f, 0.05748158f, -0.00484551f, 0.03567687f, -0.12743369f, 
    0.19521311f, -0.23467915f, -0.09071159f, 0.17958789f, -0.15034908f, -0.03274501f, 0.12097019f, -0.15416253f, 
    -0.08212736f, 0.05394286f, -0.00286201f, 0.15810256f, 0.09055087f, -0.12634374f, 0.08505543f, 0.07076634f, 
    -0.08069260f, -0.09873199f, 0.11848909f, 0.04490364f, -0.04494907f, 0.00462014f, 0.06954961f, 0.09488866f, 
    -0.14571810f, 0.09637627f, -0.11336327f, 0.05268442f, -0.04589196f, 0.02377885f, -0.07661109f, 0.04406213f, 
    0.07311656f, -0.00305933f, -0.11664691f, -0.20943099f, -0.05831348f, -0.07708094f, 0.09854186f, 0.34391251f, 
    -0.02820979f, 0.11600510f, -0.11744980f, -0.18098772f, -0.06868311f, 0.08074842f, -0.02825093f, 0.04167611f, 
    0.07481082f, 0.06891510f, -0.15843412f, -0.06728742f, -0.00137755f, 0.01041002f, 0.01628720f, 0.00849944f, 
    0.08379364f, 0.01651162f, -0.08812805f, -0.10579789f, 0.00087552f, 0.18993416f, -0.04389850f, 0.03391637f, 
    -0.09486452f, 0.09107372f, -0.02992778f, -0.10689735f, 0.14996418f, -0.13954665f, 0.01302882f, -0.08276076f, 
    0.02817276f, 0.12399654f, 0.00177511f, -0.08215488f, 0.06609894f, 0.08954155f, 0.08029552f, -0.00932711f, 
    0.12183517f, 0.06336288f, -0.02329898f, -0.01868189f, 0.03282024f, 0.05072939f, 0.17187214f, 0.23357207f, 
    0.01804976f, -0.14311779f, -0.08426473f, -0.19719860f, 0.00469446f, -0.13831703f, 0.16820474f, 0.24540381f, 
    -0.08099492f, -0.09179481f, -0.07535403f, -0.04833781f, -0.08611593f, -0.07881983f, 0.07973288f, 0.13760060f, 
    0.02736692f, -0.08776864f, -0.04286695f, -0.09304092f, 0.35652563f, 0.26079133f, -0.01857102f, -0.02067786f, 
    0.20661260f, -0.01397335f, -0.08671457f, -0.09844424f, -0.15352540f, -0.02163306f, 0.01697128f, 0.02250760f, 
    -0.05670581f, 0.03993120f, -0.00712940f, 0.02321868f, -0.03729986f, -0.00845268f, 0.00871020f, -0.04763020f, 
    -0.01170478f, 0.01354824f, -0.00594991f, -0.04692489f, 0.02950601f, 0.04033341f, -0.03646478f, -0.00917416f, 
    -0.04188569f, 0.05894183f, -0.01220957f, -0.01734049f, -0.01755530f, -0.02515401f, -0.03912885f, -0.05824248f, 
    -0.00711791f, -0.06211010f, 0.01323531f, -0.05070024f, -0.03144648f, 0.06263989f, 0.04366650f, -0.02433222f, 
    -0.06020552f, 0.02480271f, -0.06014575f, 0.05837345f, -0.05458442f, 0.04644572f, -0.06361000f, -0.02569464f, 
    0.00907910f, 0.02058955f, 0.02531949f, -0.02745037f, 0.00775905f, 0.03964987f, -0.05220238f, 0.01710457f, 
    -0.01542924f, 0.06141821f, -0.05408738f, 0.02422911f, 0.01807579f, -0.04493366f, 0.00731262f, -0.04512117f, 
    0.03704694f, 0.01233707f, -0.00180590f, -0.03847384f, 0.03829120f, 0.06036324f, -0.04412048f, -0.06278358f, 
    0.06035086f, -0.06578058f, -0.02907226f, 0.01496313f, -0.00104685f, -0.00311284f, -0.04237578f, -0.05454835f, 
    -0.03118052f, 0.03210420f, 0.05700498f, -0.07239157f, -0.06305693f, -0.03592556f, -0.02982498f, -0.04688039f, 
    -0.00499770f, 0.01531059f, 0.00983675f, 0.00421646f, 0.02573062f, 0.00396652f, -0.00106380f, -0.07307248f, 
    -0.07682253f, -0.01021035f, -0.04195266f, -0.07224306f, 0.03122284f, -0.05939024f, 0.00627059f, -0.04666778f, 
    -0.05742664f, 0.05236520f, 0.06452988f, -0.05187827f, 0.04492769f, 0.04403263f, -0.00892130f, -0.07184156f, 
    -0.05673058f, -0.03341475f, 0.02811072f, -0.02214103f, -0.01594889f, -0.04929271f, 0.03148572f, -0.05162067f, 
    -0.00375909f, -0.01398907f, -0.06628331f, -0.07297008f, 0.05652494f, 0.00906980f, 0.02765856f, -0.00822623f, 
    -0.07401055f, -0.02073815f, 0.04245009f, 0.00708823f, -0.04968729f, -0.04726263f, -0.01937568f, -0.03218006f, 
    0.03554599f, 0.00620298f, 0.03745085f, -0.02276446f, 0.05002850f, -0.06156723f, 0.00681543f, 0.05013258f, 
    -0.00064379f, -0.05707891f, -0.06382024f, -0.02913342f, -0.05445360f, -0.07503644f, 0.02856322f, -0.05187234f, 
    -0.05581816f, -0.01829003f, 0.05699997f, -0.06597433f, 0.06211230f, 0.04186597f, -0.06433868f, -0.07569793f, 
    -0.02550118f, 0.02373101f, -0.03976737f, -0.02206716f, -0.07375670f, 0.01481766f, 0.02634165f, -0.03261991f, 
    -0.02024436f, 0.04610860f, 0.03159834f, 0.02135419f, -0.02648331f, 0.01632500f, 0.01242555f, -0.04395776f, 
    0.01329597f, -0.02688159f, 0.04015569f, -0.01055499f, -0.01012608f, -0.02704024f, 0.00143541f, 0.04041596f, 
    0.06912917f, 0.03081699f, 0.00058711f, -0.00293536f, 0.04245835f, -0.05510845f, -0.04089404f, -0.01101522f, 
    -0.03410540f, 0.05668939f, 0.05298090f, -0.06524127f, 0.00670695f, 0.03710894f, 0.00767558f, 0.01828004f, 
    0.01176418f, 0.00563788f, 0.00988347f, -0.04491188f, -0.06220627f, -0.06318065f, 0.00767063f, 0.05523835f, 
    0.02160716f, 0.01050131f, -0.05665797f, 0.02034801f, 0.06144154f, 0.00887571f, -0.07595143f, 0.00880605f, 
    0.06954306f, 0.02616741f, -0.06848618f, 0.02898251f, -0.01408358f, 0.05664284f, -0.07228207f, -0.05962132f, 
    0.06282524f, 0.06663372f, -0.05454517f, -0.05385657f, -0.08679463f, 0.00721127f, 0.02308093f, 0.03509481f, 
    0.04484928f, 0.00229799f, 0.02538256f, -0.00201440f, -0.05808742f, -0.07818257f, 0.02367715f, 0.05043512f, 
    -0.04558440f, 0.01183290f, -0.00551509f, 0.02841802f, 0.04067484f, -0.04948375f, 0.03812553f, -0.02296944f, 
    -0.01938714f, 0.02963934f, 0.06486025f, -0.02659706f, 0.00681079f, -0.07369800f, -0.03352110f, 0.00068119f, 
    0.00465955f, 0.00107502f, -0.02302759f, -0.02837891f, 0.04491138f, 0.00169362f, -0.03380590f, -0.00551423f, 
    0.06382620f, -0.01236819f, 0.03623131f, 0.04782777f, 0.03473466f, 0.05478170f, -0.01831014f, -0.01064895f, 
    0.00879542f, -0.05184929f, 0.03109985f, -0.03140401f, -0.00494491f, 0.01531673f, 0.07136285f, -0.01228547f, 
    0.06083776f, -0.03799028f, -0.02596559f, -0.00252813f, 0.04686301f, -0.06765136f, -0.05523975f, -0.07821277f, 
    0.00500734f, 0.06979914f, -0.00969832f, -0.05146645f, -0.07908595f, -0.07521445f, 0.01765939f, -0.07586029f, 
    0.02310186f, -0.05785896f, -0.01709868f, -0.00627553f, -0.06643269f, -0.06564833f, -0.06071455f, -0.05339335f, 
    -0.04148125f, 0.03252523f, -0.08423211f, 0.02536779f, -0.07186176f, -0.00671946f, -0.03056916f, -0.07270439f, 
    -0.01865493f, -0.05683776f, -0.04212521f, -0.02419612f, -0.01042759f, 0.02688323f, -0.01276715f, -0.00011174f, 
    -0.02802280f, 0.02862295f, 0.00483733f, -0.06167062f, -0.07797545f, -0.05073960f, -0.06919229f, -0.05846432f, 
    0.01988175f, -0.03053715f, 0.01142752f, -0.06582838f, 0.04075266f, 0.04844880f, -0.07550886f, -0.06447077f, 
    -0.03997913f, -0.03437312f, 0.03689831f, 0.02120098f, 0.04909874f, 0.03382169f, 0.01710238f, -0.00086716f, 
    0.01906911f, -0.06495664f, 0.00312631f, -0.05684666f, -0.01883532f, -0.05948337f, 0.04511884f, 0.04090895f, 
    -0.04852139f, 0.01820319f, -0.05405938f, 0.01384796f, -0.00506251f, 0.06306736f, -0.01597146f, -0.00059593f, 
    0.04779726f, -0.06424341f, -0.00348034f, -0.01224554f, -0.02837159f, -0.03745680f, -0.02113357f, -0.06088698f, 
    0.00545547f, -0.00070829f, -0.08326773f, 0.03427935f, -0.01953494f, -0.06413925f, 0.00982396f, -0.01542949f, 
    0.00604254f, 0.03223772f, 0.00844675f, -0.01231579f, 0.03066227f, -0.01920880f, -0.08197924f, -0.05351516f, 
    0.03815378f, -0.01943792f, -0.02372511f, -0.04713197f, 0.02979788f, -0.06641923f, -0.05749752f, 0.00085460f, 
    0.02396351f, 0.02621285f, 0.03491409f, -0.06167346f, -0.03981571f, 0.04066745f, -0.03643273f, -0.06117399f, 
    -0.01131734f, 0.03173266f, -0.02975115f, -0.01155572f, 0.01709159f, 0.04494028f, -0.01980987f, -0.06847996f, 
    -0.03341099f, 0.04608656f, -0.02353356f, -0.03734733f, -0.05933694f, -0.01766003f, 0.05582230f, -0.00109171f, 
    -0.05477585f, 0.04072367f, 0.03330943f, 0.00899330f, 0.04909860f, 0.05684017f, 0.03655317f, 0.00232618f, 
    -0.04236375f, 0.00969180f, 0.01843169f, -0.00005046f, 0.02830704f, -0.02113839f, 0.05026826f, 0.03566079f, 
    -0.04210567f, 0.03347386f, 0.06118216f, 0.05679153f, -0.07383110f, 0.01023658f, 0.00100347f, 0.02718458f, 
    -0.01126538f, -0.02677697f, -0.00648280f, -0.02899488f, 0.03215112f, 0.00233116f, -0.03976364f, 0.06311228f, 
    -0.02337608f, -0.02556787f, -0.02707237f, -0.05918942f, -0.06937483f, -0.03928408f, -0.00815941f, -0.00216710f, 
    0.01452897f, 0.01726686f, 0.06565977f, -0.01784934f, -0.04103962f, -0.00787776f, 0.02570487f, -0.05517038f, 
    0.06000670f, 0.03934943f, -0.01761867f, -0.02116074f, -0.01678863f, 0.04076002f, -0.02058359f, -0.01717009f, 
    0.00531012f, -0.07066893f, 0.02192922f, -0.07585764f, -0.04019657f, -0.06591017f, 0.00823931f, 0.05628645f, 
    -0.02691020f, -0.05908569f, 0.01554357f, 0.01070490f, -0.05552893f, -0.04316220f, 0.04411916f, 0.00537627f, 
    -0.01075493f, 0.04955183f, -0.00261201f, -0.03520815f, 0.02438200f, 0.02892414f, 0.05981985f, 0.03694051f, 
    0.02831303f, -0.07356656f, -0.00302757f, -0.02921510f, -0.04824344f, -0.05737441f, 0.02004422f, -0.01507260f, 
    0.01019823f, -0.01066676f, -0.00419388f, -0.06406066f, 0.03647206f, 0.01621799f, 0.03734052f, -0.08027518f, 
    0.04247248f, 0.01088178f, -0.01873027f, -0.05788823f, -0.04709490f, 0.00215487f, 0.00001506f, 0.03878613f, 
    0.04255747f, -0.04847288f, -0.04152820f, -0.03784468f, -0.05589657f, -0.00769128f, -0.05576678f, -0.02969443f, 
    -0.06956254f, -0.02234804f, 0.02865377f, 0.00178654f, -0.03039864f, -0.01594854f, -0.01608178f, -0.06971432f, 
    0.05777343f, -0.03665382f, -0.05046484f, -0.03519447f, 0.04385708f, 0.05442557f, -0.00668846f, 0.04554253f, 
    -0.03511695f, -0.04983420f, -0.00790982f, -0.01382624f, 0.01053500f, -0.01102534f, -0.07774711f, 0.03366942f, 
    -0.07493287f, -0.01963846f, -0.00990749f, 0.00141619f, 0.00294581f, 0.00755281f, 0.01006446f, -0.00303335f, 
    -0.04238938f, -0.00085748f, -0.02471426f, 0.04602224f, 0.01613391f, -0.07096852f, -0.04313654f, 0.04457545f, 
    0.03112925f, -0.01058131f, -0.06897947f, -0.00495251f, 0.02687299f, -0.03876153f, -0.00873660f, -0.05337343f, 
    0.03353675f, 0.02099895f, -0.03795663f, 0.05292015f, 0.06304033f, 0.01731341f, -0.06429780f, 0.00497070f, 
    -0.08299836f, -0.29760891f, 0.17538401f, -0.20713198f, 0.03467106f, -0.05661840f, -0.15282026f, -0.09425330f, 
    0.11041311f, -0.10298444f, -0.07726675f, -0.05431672f, -0.19410717f, 0.22039679f, 0.03322148f, 0.15520553f, 
    0.09553027f, 0.09727122f, -0.11008887f, 0.15407492f, -0.06297644f, 0.10511293f, 0.22735144f, -0.02591154f, 
    -0.15720835f, -0.13538730f, 0.07587700f, -0.15071027f, -0.13361359f, 0.00788647f, 0.22949980f, 0.05730627f, 
    0.20946787f, 0.22496808f, 0.18611133f, 0.18668184f, -0.43757394f, 0.09538335f, 0.05820342f, 0.10370953f, 
    0.06577777f, -0.03198647f, 0.22508141f, -0.08886375f, 0.05696916f, 0.10370222f, 0.06911765f, -0.09529694f, 
    -0.01155949f, 0.00085470f, 0.13151307f, -0.06028363f, -0.05024262f, 0.12767273f, 0.21592911f, -0.00604346f, 
    0.02140011f, 0.14548698f, 0.08244575f, -0.09108497f, -0.22750430f, 0.07832228f, -0.32414609f, -0.01439838f, 
    0.16582942f, 0.10426515f, 0.01423443f, -0.09192210f, -0.13378513f, -0.11872448f, 0.19995399f, -0.23815948f, 
    0.08809589f, -0.10184164f, 0.00837614f, 0.19858491f, 0.07102933f, 0.20173900f, 0.11401962f, -0.08002298f, 
    0.17910728f, 0.13563943f, 0.09945506f, 0.20533614f, -0.06483475f, -0.04422544f, 0.01819742f, 0.04289255f, 
    0.12636666f, 0.07556841f, 0.03878845f, -0.02858377f, -0.00785326f, 0.11976531f, 0.15145881f, 0.06086057f, 
    -0.19426876f, 0.14546804f, -0.19911665f, 0.13166392f, -0.09308116f, -0.17889547f, 0.01433008f, -0.01540335f, 
    -0.09450361f, -0.17234732f, -0.05469614f, -0.11465839f, -0.08797061f, -0.23075305f, 0.03152102f, 0.14899331f, 
    0.01886433f, 0.03985663f, 0.06045824f, -0.02325299f, 0.09518094f, 0.13906933f, 0.04439643f, 0.04420523f, 
    0.01469528f, -0.01287978f, -0.36823693f, -0.12242363f, 0.00929869f, -0.01180060f, 0.07358098f, 0.04797816f, 
    0.01584701f, 0.12580118f, -0.12014788f, 0.04182704f, 0.13214709f, -0.05680169f, -0.09591852f, -0.10149147f, 
    0.07940928f, 0.14149441f, 0.01833282f, -0.06518492f, 0.02912540f, -0.04740759f, -0.20082372f, 0.00295321f, 
    -0.06866664f, 0.11310654f, -0.02195647f, 0.14579032f, 0.07826927f, 0.06837361f, 0.08164554f, 0.04495522f, 
    -0.20688297f, 0.07951204f, -0.01309562f, -0.10775384f, -0.05538654f, 0.08884592f, 0.13852550f, 0.14040916f, 
    0.02913877f, -0.03041469f, -0.09607253f, 0.03263039f, 0.15677463f, -0.01000556f, 0.13666259f, 0.04319906f, 
    -0.10071254f, -0.08842907f, -0.07575400f, 0.04777810f, 0.04733782f, -0.14568757f, -0.28160563f, -0.12874003f, 
    -0.03840847f, -0.09631834f, -0.09865633f, -0.11843710f, 0.12614089f, 0.15933438f, 0.09329676f, -0.06755326f, 
    0.08121513f, 0.08344038f, -0.10990305f, -0.07276597f, -0.00864635f, -0.01309403f, -0.02208982f, 0.03381016f, 
    -0.07355030f, -0.01227153f, -0.13643479f, -0.02974433f, -0.08555931f, 0.00306182f, 0.04189843f, 0.07562899f, 
    0.04904975f, 0.17874457f, 0.04289688f, 0.14274582f, -0.05663621f, -0.37531534f, -0.00500338f, 0.45439252f, 
    -0.04162838f, 0.08918323f, 0.00868591f, -0.02675510f, -0.06690498f, -0.09628189f, 0.09551317f, 0.08058684f, 
    -0.33630461f, 0.13059105f, 0.09115221f, -0.04872943f, -0.10628881f, -0.07217340f, -0.04627084f, 0.09467497f, 
    0.12813604f, 0.14915606f, -0.01925264f, 0.02590907f, -0.20419623f, 0.60634601f, -0.11747196f, 0.48104969f, 
    -0.11116388f, -0.01077221f, 0.07421938f, -0.03369574f, 0.04103570f, 0.19764124f, 0.01094309f, 0.02323784f, 
    -0.38350233f, -0.20106190f, -0.09574795f, 0.08635868f, -0.04889850f, 0.04599923f, 0.15207134f, -0.02123205f, 
    -0.06850322f, -0.03396449f, -0.05199885f, -0.12972261f, -0.24312782f, 0.08013812f, -0.28631768f, -0.08033352f, 
    -0.08647321f, -0.11054172f, 0.04444566f, -0.00291523f, -0.02494619f, 0.03225398f, 0.00078230f, -0.02726957f, 
    0.28548643f, -0.13037004f, 0.22350723f, -0.05808129f, 0.01784353f, 0.05896346f, 0.14996059f, -0.06429811f, 
    0.00774153f, 0.01602103f, -0.02681362f, 0.00579547f, 0.05528648f, -0.44870520f, -0.14510573f, 0.19320872f, 
    0.02597021f, 0.08647547f, 0.14263622f, -0.11551739f, -0.03520560f, -0.17060512f, -0.13331425f, 0.02893641f, 
    -0.12817003f, -0.53693384f, 0.01262566f, 0.35133013f, 0.19245353f, 0.18451656f, 0.06393246f, -0.13524035f, 
    0.03288518f, -0.00891097f, -0.02036878f, 0.10272960f, -0.09360095f, -0.08644745f, -0.07823875f, -0.03875317f, 
    0.15951653f, 0.10575684f, 0.07343706f, 0.20280249f, 0.01014912f, 0.07818425f, -0.16047809f, -0.14027455f, 
    0.01872154f, 0.01822149f, -0.12355282f, -0.19782344f, -0.19150743f, 0.00133208f, 0.04593401f, 0.03359435f, 
    -0.01937472f, 0.05416028f, -0.07046109f, -0.02408305f, -0.06818949f, 0.25270078f, -0.14132577f, -0.27388203f, 
    -0.22318585f, 0.15208556f, -0.18362975f, -0.07529587f, 0.01526851f, 0.13318814f, -0.15815078f, 0.07674948f, 
    -0.62360895f, 0.10269123f, 0.23212695f, 0.17500533f, -0.09908897f, 0.00666845f, -0.05591040f, -0.11383050f, 
    0.03483390f, -0.03118602f, 0.05490019f, 0.10404541f, 0.39773241f, -0.24038014f, 0.01692718f, 0.07422812f, 
    0.08288058f, 0.01508343f, -0.00946306f, 0.25090003f, -0.00163328f, 0.17828919f, 0.05235920f, 0.00922216f, 
    0.17195965f, -0.14125495f, -0.07355379f, 0.00704606f, 0.07458448f, 0.03786918f, -0.13746153f, -0.05817910f, 
    0.06710441f, 0.15019090f, 0.09434468f, 0.19281213f, 0.16795518f, 0.02590413f, 0.12934403f, -0.48088118f, 
    -0.12073845f, 0.05667024f, -0.01858041f, -0.06373157f, 0.02326186f, 0.22281139f, 0.10976508f, 0.14626248f, 
    -0.02113454f, -0.11376745f, -0.10527445f, -0.33221617f, 0.25072473f, 0.09320104f, 0.05591305f, 0.05789634f, 
    0.00501042f, -0.01496156f, 0.03886440f, 0.02665932f, -0.06291579f, -0.32865489f, -0.55022687f, -0.02072045f, 
    0.14629993f, 0.07544189f, 0.14580946f, 0.09655007f, -0.09318344f, -0.02640893f, 0.04015025f, 0.07640670f, 
    -0.06958275f, -0.01349274f, 0.18070918f, -0.00657823f, -0.09118680f, 0.03423056f, -0.05603822f, 0.01068205f, 
    0.00780259f, -0.13253750f, -0.02150081f, -0.18897003f, 0.43711576f, 0.00311716f, -0.06961271f, 0.22463854f, 
    0.02600787f, -0.10805965f, 0.22154029f, 0.02972858f, -0.03069984f, 0.18821675f, 0.10624381f, -0.00109644f, 
    -0.17024997f, -0.21115270f, 0.13817261f, -0.17674549f, -0.04685237f, 0.04571027f, -0.04055583f, 0.00407180f, 
    -0.11004780f, 0.01340359f, -0.02607764f, -0.11040977f, -0.18288818f, 0.13947611f, -0.01537138f, 0.16617407f, 
    0.14987601f, -0.09797038f, -0.11706033f, -0.17924236f, 0.01309370f, 0.02947712f, -0.06251056f, 0.01257580f, 
    -0.00769179f, 0.31861010f, 0.39203233f, -0.09453665f, 0.16694218f, -0.01133659f, 0.04632267f, 0.28212437f, 
    -0.00817237f, 0.13823776f, -0.01544282f, -0.05293379f, 0.23532870f, 0.14478706f, -0.04968721f, 0.05933201f, 
    0.12853152f, 0.08935898f, -0.03270468f, 0.10994127f, -0.11369256f, -0.17901076f, -0.00936846f, 0.18504830f, 
    0.11235274f, 0.19035837f, -0.18071882f, 0.10297787f, 0.16619031f, 0.12170059f, 0.07894686f, 0.15849097f, 
    -0.10193823f, -0.02443910f, 0.02756987f, 0.01412551f, 0.14066672f, -0.12452052f, 0.00320213f, -0.01997061f, 
    0.11118148f, 0.08290748f, 0.22594400f, 0.11986431f, 0.15976912f, -0.07151779f, -0.05743663f, -0.01454310f, 
    -0.00469100f, 0.15175091f, 0.07986955f, 0.15522957f, 0.07389038f, -0.11546453f, -0.14046542f, -0.16875117f, 
    0.07338705f, -0.06119057f, 0.04870350f, 0.12227958f, 0.11726455f, -0.09020340f, 0.15843205f, -0.17001323f, 
    -0.01645554f, -0.06798389f, -0.19247115f, -0.01419111f, -0.01336279f, 0.05005117f, -0.01767873f, -0.09669980f, 
    -0.02171404f, 0.32879454f, -0.33816609f, 0.43047851f, -0.04138964f, -0.04093497f, 0.05687847f, 0.08911659f, 
    0.12098300f, -0.01351837f, 0.00918776f, 0.01843355f, -0.00088814f, -0.19013520f, -0.35220650f, -0.18934399f, 
    0.07105828f, 0.01200917f, 0.05203195f, 0.04474393f, 0.01962212f, 0.13218510f, -0.09966028f, 0.03003317f, 
    0.01511963f, -0.03996389f, -0.02129411f, 0.01115731f, 0.05097495f, 0.23122008f, 0.00929087f, 0.00811940f, 
    0.07237177f, 0.14084361f, -0.03765325f, 0.04381094f, 0.21422930f, 0.07245951f, -0.08906926f, -0.25022453f, 
    -0.05733689f, 0.04679615f, -0.13272810f, -0.08279125f, 0.12174464f, 0.00263760f, 0.09962092f, 0.11092111f, 
    0.06494508f, -0.07322458f, 0.28028753f, -0.00263732f, 0.11825956f, 0.15109038f, 0.10633563f, -0.12308552f, 
    0.20590766f, -0.05235089f, -0.10999665f, -0.11492196f, -0.04389235f, 0.18278661f, -0.12261168f, -0.01701913f, 
    0.12365916f, 0.05207142f, 0.09260930f, -0.02271551f, -0.04043132f, -0.11712631f, 0.07199392f, 0.05061844f, 
    0.03928063f, -0.17288554f, -0.15103820f, -0.14000639f, 0.02722399f, -0.01757952f, 0.08313741f, 0.09042466f, 
    -0.00373723f, -0.17598578f, 0.20128696f, 0.00199385f, -0.21943255f, -0.35822374f, -0.11754231f, -0.25083846f, 
    0.04826642f, -0.04195834f, 0.07833827f, 0.06432721f, 0.01357588f, 0.10400534f, 0.04792150f, 0.03154078f, 
    0.17017448f, -0.15057419f, -0.09514210f, -0.29209119f, -0.08093719f, 0.03524436f, 0.03036243f, 0.15418306f, 
    0.09996786f, 0.15219487f, 0.09628671f, 0.04886125f, -0.55098689f, -0.22279687f, -0.08310363f, 0.23893695f, 
    0.01129781f, 0.07021559f, -0.17269525f, -0.15565880f, 0.09368497f, -0.08042791f, -0.00089282f, 0.02029387f, 
    -0.00336939f, 0.10422986f, 0.07295971f, 0.37579402f, 0.02992068f, 0.05799617f, -0.08040455f, 0.10119403f, 
    0.16299561f, 0.01890851f, -0.09100651f, 0.05082609f, -0.09067228f, 0.22593185f, 0.09825679f, 0.14709862f, 
    0.22687799f, 0.06118680f, -0.02220478f, 0.06635761f, 0.05528660f, -0.04494967f, 0.10909235f, 0.12028617f, 
    -0.02596845f, 0.42643914f, -0.04633537f, 0.14635280f, 0.08405849f, 0.00284181f, 0.14616443f, 0.21470635f, 
    -0.11470217f, -0.02696285f, 0.07565212f, 0.13638091f, 0.08781887f, -0.11089467f, 0.10387721f, 0.07688557f, 
    -0.08274928f, 0.01867278f, 0.00499805f, 0.00523646f, 0.09951055f, 0.03458704f, 0.15008886f, 0.01005891f, 
    -0.37832201f, -0.02533341f, -0.20274100f, 0.06202885f, -0.01228759f, 0.10315713f, -0.16125873f, -0.01965714f, 
    -0.08287861f, -0.04830502f, -0.12704127f, 0.01159103f, 0.20838937f, -0.36012948f, -0.11326890f, -0.01120531f, 
    0.06668880f, 0.01859160f, -0.03435913f, -0.07677381f, -0.01758509f, -0.07610882f, -0.01475656f, -0.15365985f, 
    0.28196928f, 0.18927856f, -0.26380602f, -0.00423364f, 0.03132205f, -0.04011680f, -0.06828760f, 0.09781240f, 
    0.07164381f, 0.02134814f, -0.03203826f, -0.02305108f, -0.16776244f, 0.23449683f, -0.02580616f, 0.06227059f, 
    -0.09423462f, -0.08876872f, 0.06296495f, 0.02057147f, 0.18881631f, -0.02732758f, -0.11085456f, 0.01677466f, 
    -0.25819838f, 0.13601251f, -0.06856237f, 0.01622649f, 0.24734847f, -0.06090938f, -0.09241690f, -0.10738857f, 
    0.09310741f, -0.05324450f, -0.26055291f, -0.05482458f, 0.23188445f, -0.10580011f, 0.10616588f, 0.30609897f, 
    -0.25703678f, -0.10291910f, -0.25570941f, -0.17359167f, 0.13231471f, 0.00568472f, 0.07341298f, 0.04911213f, 
    -0.03236916f, -0.07553333f, 0.01970234f, 0.00366949f, 0.08296337f, -0.06194297f, -0.01955182f, -0.04754096f, 
    0.06482019f, 0.04256349f, -0.02261031f, -0.01333281f, 0.00538010f, -0.03374122f, -0.04377302f, 0.00646805f, 
    -0.05342506f, 0.01420798f, 0.01295924f, -0.07503258f, -0.03118656f, 0.01011097f, -0.04790555f, 0.04237575f, 
    0.01612413f, 0.02239543f, 0.06517937f, -0.03110118f, 0.04328918f, -0.00686437f, -0.04719629f, 0.03982604f, 
    -0.02591666f, 0.03239912f, -0.01319082f, 0.00370773f, 0.01519890f, 0.03531164f, -0.04763861f, 0.00578975f, 
    -0.05105456f, 0.05575904f, -0.01042225f, -0.08764230f, 0.01222645f, -0.04556279f, 0.03714889f, -0.05935192f, 
    0.05557378f, -0.05829125f, 0.01902507f, 0.01875928f, -0.02565621f, -0.05623479f, -0.04102537f, -0.00725055f, 
    -0.05484619f, -0.06259083f, 0.01896679f, -0.05924265f, -0.02397151f, 0.02956422f, 0.02451529f, -0.03051475f, 
    0.04312994f, 0.00122009f, 0.01803409f, -0.07413840f, -0.05392254f, -0.03203216f, -0.04488993f, 0.05232731f, 
    -0.00091868f, -0.00188935f, -0.08444147f, -0.02034654f, -0.02069802f, -0.05806692f, -0.06275085f, 0.03605257f, 
    0.04232570f, 0.00511767f, -0.06644152f, 0.06162089f, -0.02175847f, -0.00484999f, 0.00649559f, -0.00090709f, 
    -0.05213898f, -0.01157312f, -0.03871671f, -0.00217531f, -0.04370055f, -0.07744695f, 0.02579549f, 0.01041434f, 
    -0.07464094f, 0.01325042f, 0.02892243f, -0.00690852f, -0.02087039f, -0.01230138f, -0.02182008f, -0.00056035f, 
    -0.05772579f, -0.07872043f, -0.05344430f, 0.05661586f, -0.02272035f, 0.00307492f, -0.06766626f, -0.00431744f, 
    -0.00359557f, -0.05944444f, 0.06169936f, -0.06456384f, 0.01209164f, -0.05198630f, -0.05297391f, 0.01893948f, 
    -0.07412530f, -0.04814037f, -0.05297914f, 0.02868507f, -0.01208851f, 0.04985514f, -0.03489403f, 0.00156909f, 
    0.05613288f, 0.05525089f, 0.04699109f, 0.02018507f, -0.06042625f, -0.01789645f, -0.06097860f, -0.07481272f, 
    -0.02118465f, -0.06677119f, 0.00893610f, -0.00908350f, 0.03535036f, 0.00290693f, -0.06515659f, -0.06892238f, 
    0.07641038f, -0.00210933f, 0.04492974f, 0.01032611f, 0.05515807f, 0.00952127f, 0.02998098f, -0.07053223f, 
    -0.07052580f, -0.07544517f, -0.04747634f, -0.01742296f, -0.05507197f, 0.03378164f, -0.03218431f, 0.05295096f, 
    0.04332364f, -0.03228515f, 0.04125411f, -0.05554780f, 0.05921375f, -0.05674794f, -0.05957606f, 0.03652412f, 
    -0.02121365f, 0.00668483f, -0.06451523f, -0.07627786f, -0.04087975f, -0.02932687f, -0.01328905f, -0.03279456f, 
    0.01911574f, -0.02363926f, -0.07248680f, 0.01529375f, -0.01619560f, -0.01788332f, -0.04264665f, -0.02300718f, 
    -0.05736295f, -0.03244197f, -0.05545429f, -0.01669257f, 0.04597900f, -0.00827887f, 0.05950409f, -0.07766157f, 
    -0.04585872f, -0.25007534f, 0.11345810f, 0.06799738f, -0.15680967f, 0.02777287f, -0.03535100f, 0.09709249f, 
    -0.05122863f, -0.08986292f, -0.16595228f, -0.09696198f, -0.13534366f, 0.41744462f, 0.25788701f, 0.07846902f, 
    -0.03489466f, 0.04113280f, 0.04326579f, -0.00253949f, -0.00331377f, -0.10565883f, 0.03584708f, 0.02656829f, 
    0.02565826f, -0.19150838f, -0.13234857f, -0.03970002f, -0.10927999f, 0.02001766f, 0.11558983f, 0.01021332f, 
    0.12134236f, 0.33958060f, 0.14912252f, 0.21885590f, -0.32894778f, 0.03395631f, 0.11531023f, -0.10779016f, 
    0.04523312f, 0.12047647f, 0.01768971f, 0.01367818f, 0.03655718f, -0.03655691f, -0.04781750f, 0.10609874f, 
    0.09767180f, 0.20998231f, -0.03861466f, -0.02962792f, -0.02243370f, 0.11933514f, 0.08183659f, 0.06194986f, 
    0.25616944f, 0.15656112f, 0.01751590f, 0.03435992f, 0.07936185f, -0.05058101f, -0.11733322f, -0.18752579f, 
    -0.05446417f, 0.15893047f, -0.13128911f, -0.07896065f, -0.13018304f, -0.15320508f, 0.05232664f, -0.32021397f, 
    0.10566453f, -0.16350527f, -0.17861032f, 0.31779507f, 0.04659653f, 0.17042263f, 0.10330606f, -0.08768322f, 
    0.16394027f, -0.03502212f, 0.08501267f, 0.15709554f, -0.20755309f, -0.02016783f, 0.06869007f, -0.01015637f, 
    -0.05728787f, -0.05585651f, 0.14059258f, -0.04457401f, 0.08779520f, 0.13153335f, 0.05230564f, 0.04680462f, 
    -0.28886798f, 0.10752508f, -0.10516666f, 0.02479185f, -0.16335188f, -0.12187279f, 0.03858661f, 0.00481524f, 
    0.12698488f, -0.09760284f, -0.09276289f, -0.06578308f, -0.18277659f, -0.18735464f, 0.05488427f, 0.27283657f, 
    -0.07141999f, 0.01407064f, -0.03395090f, -0.05796365f, 0.14022608f, 0.20654464f, 0.26172176f, 0.24386004f, 
    0.05842257f, -0.15179697f, -0.16624895f, -0.14630678f, 0.06428947f, -0.05887016f, -0.01311125f, -0.19850291f, 
    -0.09877703f, 0.07688655f, 0.00888356f, -0.12483757f, 0.03961389f, 0.07652149f, 0.00124325f, 0.08276965f, 
    0.12992127f, -0.00769436f, 0.06183081f, -0.06700732f, 0.06315494f, -0.20545641f, -0.03721639f, 0.08393653f, 
    0.27118900f, 0.07022422f, 0.47867015f, -0.27813938f, 0.20065120f, -0.01761889f, -0.05368923f, 0.03807311f, 
    -0.16468978f, 0.10578027f, -0.01894123f, 0.05566414f, -0.02257511f, 0.23700848f, 0.32227954f, 0.27559081f, 
    -0.12175531f, -0.17123351f, -0.12838940f, -0.00669023f, 0.04953772f, -0.13964127f, 0.18698509f, 0.06931319f, 
    -0.08342616f, -0.04210106f, -0.09249135f, 0.01337436f, 0.03128172f, -0.16112310f, -0.09076282f, -0.14902803f, 
    -0.23738115f, -0.35039809f, -0.12877724f, -0.26271313f, -0.04486543f, 0.06130826f, -0.01929380f, 0.15852426f, 
    0.02938212f, -0.15280809f, 0.08927246f, 0.10417116f, -0.00445978f, -0.06422721f, 0.00685791f, 0.02491865f, 
    -0.18242724f, -0.03193459f, -0.04093112f, 0.04781209f, 0.00349110f, -0.02247863f, -0.10207645f, 0.20751758f, 
    -0.16276364f, -0.10199176f, -0.06878959f, -0.09558907f, -0.26894429f, 0.24567060f, 0.01127632f, -0.17191571f, 
    -0.02221466f, -0.14164604f, -0.03891437f, 0.01391874f, 0.01535426f, 0.07667055f, 0.05382811f, -0.03890171f, 
    0.04248914f, -0.03609236f, 0.05448348f, 0.09624957f, -0.13795893f, 0.10443443f, 0.10084721f, 0.17432754f, 
    0.22332275f, 0.24875626f, 0.10993085f, 0.27254608f, -0.25503170f, 0.24118330f, 0.04344399f, 0.08601109f, 
    -0.00638100f, -0.01055973f, 0.09002292f, 0.02548331f, -0.00823804f, 0.03788821f, 0.09880327f, -0.12903517f, 
    0.06130632f, -0.03930745f, 0.22697552f, -0.08531272f, -0.17701709f, -0.01917652f, 0.09809819f, -0.07175446f, 
    0.10850412f, 0.06864369f, 0.03417460f, 0.00964930f, 0.14424820f, 0.04410669f, 0.02868894f, -0.07712810f, 
    -0.10750320f, 0.00145556f, -0.11854870f, 0.04947312f, -0.05147703f, -0.11872123f, -0.04845178f, -0.23462890f, 
    0.22844039f, -0.14878446f, -0.13033889f, 0.12801132f, 0.02341822f, 0.06682580f, 0.12863974f, -0.08076773f, 
    0.08141491f, -0.07557786f, 0.01107350f, 0.17154358f, -0.12179910f, -0.13732740f, 0.06129986f, -0.00159167f, 
    -0.04249776f, -0.06663806f, 0.11823155f, -0.04780800f, 0.15045768f, 0.21166870f, 0.08125208f, 0.00828860f, 
    -0.01664417f, 0.14872797f, 0.09297874f, -0.00358788f, -0.07469735f, 0.01493709f, -0.03072158f, 0.06934875f, 
    0.01741800f, -0.13653542f, 0.02690631f, -0.04069645f, -0.21678667f, -0.11622542f, -0.05469453f, 0.20647487f, 
    0.13689822f, 0.05909665f, -0.02866417f, 0.00589477f, 0.01792832f, 0.11284041f, 0.10742296f, 0.17859305f, 
    0.12388771f, 0.08911917f, 0.02407043f, -0.07270885f, -0.01040062f, 0.10415955f, 0.08290931f, -0.22490986f, 
    -0.06422655f, 0.00588198f, -0.05801457f, -0.02086377f, 0.18840590f, 0.04457802f, 0.11562666f, 0.14993460f, 
    0.03822439f, 0.02013814f, 0.11235520f, 0.02784566f, 0.05583340f, -0.13586941f, -0.01049794f, 0.01136873f, 
    0.37430793f, 0.08134006f, 0.28111652f, -0.09570783f, -0.06740110f, -0.17611228f, -0.11214600f, 0.03375098f, 
    -0.16440564f, 0.07545957f, 0.02888891f, -0.04747054f, 0.02270269f, 0.04955721f, 0.07537285f, 0.08943879f, 
    -0.16974631f, -0.15753883f, -0.16189684f, -0.12494323f, 0.03152034f, -0.09850961f, 0.13527516f, 0.05810532f, 
    -0.12617110f, -0.03368707f, 0.00110080f, 0.00245419f, -0.00826077f, 0.08583708f, -0.04648025f, -0.08455490f, 
    -0.24496669f, -0.27702501f, -0.02706015f, -0.15342288f, 0.06173684f, 0.33736765f, 0.01657291f, 0.13637407f, 
    -0.05392576f, -0.04620449f, 0.01089813f, 0.07864475f, -0.10819661f, -0.12529010f, -0.18990834f, 0.05414122f, 
    0.19063026f, 0.03634881f, -0.04402583f, 0.03845834f, 0.01371924f, -0.02019433f, -0.02951450f, -0.03317910f, 
    0.17696403f, -0.11848754f, -0.02391624f, -0.07021080f, -0.05510468f, -0.02480564f, 0.00227475f, -0.27120546f, 
    0.15291706f, -0.07094836f, -0.05296512f, -0.09556719f, -0.05791109f, 0.04395215f, 0.18040347f, 0.01542869f, 
    -0.04938491f, -0.23276538f, -0.05671659f, -0.08234860f, 0.08755355f, 0.11149003f, 0.02223981f, 0.14055751f, 
    -0.04905561f, -0.11385170f, 0.00899349f, -0.03282129f, -0.24370377f, -0.42912108f, 0.03878307f, -0.52884907f, 
    0.16190799f, 0.10868001f, -0.13678476f, 0.14198962f, -0.11968294f, -0.15710136f, -0.12511693f, -0.10451846f, 
    -0.00665527f, 0.08069418f, 0.01265476f, -0.04925311f, -0.02015041f, 0.08047791f, 0.04723518f, 0.10322034f, 
    -0.06683627f, 0.13323136f, 0.03684999f, 0.09330361f, -0.11246292f, -0.05133752f, 0.07519715f, 0.00491060f, 
    -0.02916138f, 0.02512261f, 0.01254495f, 0.18601468f, 0.13919839f, 0.03034277f, 0.02528948f, 0.04032057f, 
    0.19073208f, 0.13467814f, -0.06328470f, 0.27417096f, -0.01263057f, -0.22194360f, 0.04472544f, -0.08564044f, 
    0.06474777f, -0.06339286f, 0.05934485f, -0.05956421f, 0.00488543f, 0.08951432f, 0.11440521f, 0.18621865f, 
    -0.00438478f, -0.17243797f, 0.07442316f, 0.15665378f, -0.00141344f, -0.00410135f, 0.08700642f, 0.01955066f, 
    0.22524010f, 0.43345115f, 0.28619367f, 0.35555619f, -0.19583482f, -0.06080703f, 0.09487707f, 0.30261347f, 
    -0.01658954f, 0.02565805f, 0.09481271f, -0.04520548f, -0.00685794f, 0.02919228f, 0.08237755f, 0.22300522f, 
    -0.08063202f, -0.07141400f, 0.01326028f, -0.21553756f, -0.01350370f, 0.13223815f, 0.12127467f, 0.20150436f, 
    -0.29421040f, -0.12814873f, -0.03871261f, -0.01236586f, -0.04766426f, 0.07841033f, 0.00362387f, -0.04602702f, 
    0.12962371f, -0.01054545f, 0.01160046f, 0.06239203f, -0.05170546f, -0.24251896f, -0.16175257f, -0.02621332f, 
    0.18021029f, -0.06087433f, 0.12829113f, 0.04851614f, 0.01484097f, 0.07026148f, -0.00568675f, 0.02376765f, 
    0.02291368f, -0.00444016f, -0.19197604f, 0.00856932f, -0.08575654f, 0.12476704f, -0.00376579f, 0.06809989f, 
    -0.02733427f, 0.14255942f, 0.04022546f, -0.12151147f, -0.06909220f, 0.03357721f, -0.08568707f, 0.08401443f, 
    -0.03915954f, -0.02932206f, -0.01979711f, -0.10376629f, 0.03183835f, -0.09671903f, -0.07685462f, -0.12929004f, 
    0.17511722f, 0.31749326f, 0.09183268f, 0.19435330f, -0.08759916f, 0.16163592f, 0.07016538f, -0.23186637f, 
    0.10838488f, 0.01926229f, 0.02103946f, -0.01898322f, -0.06405026f, -0.03060917f, -0.19356841f, 0.10179698f, 
    0.07053529f, 0.14217594f, 0.07977574f, -0.01714977f, -0.08804967f, -0.12668258f, -0.25972497f, -0.00542083f, 
    0.08984918f, -0.01726722f, -0.03733619f, 0.03741375f, 0.16603997f, 0.00509697f, 0.20305708f, 0.14702187f, 
    -0.10910185f, -0.05337381f, 0.15109645f, 0.19162115f, 0.14111288f, -0.02007339f, 0.02528217f, -0.07772923f, 
    -0.08694834f, 0.16922748f, 0.10025090f, 0.04393658f, 0.02349755f, 0.06605103f, -0.01085911f, 0.00130115f, 
    -0.15115200f, -0.04615645f, 0.13014691f, 0.07170104f, -0.03853036f, -0.11442434f, -0.12642458f, -0.21756738f, 
    -0.24641795f, -0.12368877f, -0.13478860f, -0.10611707f, 0.48798904f, -0.18323748f, 0.23589411f, 0.15553667f, 
    -0.10040633f, 0.10991544f, 0.02530991f, 0.14673501f, 0.09015068f, 0.09086157f, 0.05469224f, 0.12552238f, 
    -0.16007230f, -0.04267656f, -0.01096731f, 0.05890753f, 0.05421888f, -0.04427505f, 0.01225377f, 0.11653572f, 
    0.07192910f, 0.03555019f, 0.04512602f, 0.12959906f, 0.17622241f, 0.14906199f, -0.00867133f, -0.06681612f, 
    0.08349131f, -0.21465914f, -0.07764050f, -0.10708876f, 0.06028161f, 0.04937765f, -0.12859103f, 0.26689816f, 
    -0.04809759f, 0.17954989f, -0.00329122f, -0.26659095f, 0.06167710f, 0.06470669f, -0.01420773f, 0.27733257f, 
    -0.07647640f, 0.07576083f, 0.04141079f, -0.09987173f, -0.00946528f, 0.13312982f, -0.00912710f, -0.12251453f, 
    -0.02351057f, 0.06529526f, -0.10291702f, -0.03558039f, -0.12721755f, -0.06982465f, -0.14869456f, -0.02040090f, 
    0.06565761f, -0.04477245f, -0.02435854f, -0.21066761f, 0.09049425f, -0.00415877f, 0.08409078f, -0.17328143f, 
    -0.00300806f, 0.13313593f, 0.04160023f, 0.11648836f, 0.15829514f, 0.05101586f, -0.08270808f, -0.25981486f, 
    0.10657220f, -0.06124568f, 0.05265721f, 0.16615699f, 0.01246316f, -0.18921363f, -0.06751016f, -0.06420121f, 
    0.13698418f, 0.27313387f, 0.21576603f, 0.06865159f, 0.13123108f, -0.08900017f, -0.05357379f, -0.03752723f, 
    0.06717576f, -0.10217747f, 0.11817156f, -0.06392972f, -0.14186800f, 0.28045747f, 0.07874113f, 0.04674855f, 
    0.04345975f, -0.19488436f, 0.06609263f, -0.05503087f, -0.00608292f, 0.06410669f, 0.20972413f, -0.07364429f, 
    -0.04681353f, 0.05997314f, 0.09686944f, 0.06570913f, -0.11509825f, -0.11559800f, 0.01451100f, 0.03364852f, 
    -0.09126968f, -0.07246302f, 0.04781531f, 0.07702985f, 0.01424061f, 0.09496901f, -0.04305943f, -0.07932153f, 
    -0.02728099f, 0.07990865f, 0.13301575f, 0.07383353f, -0.05545895f, 0.19648987f, -0.03963847f, -0.03615926f, 
    -0.02578561f, -0.17697701f, -0.00458468f, -0.03616604f, -0.03848502f, -0.05447565f, 0.14751226f, 0.16632755f, 
    -0.00595419f, 0.13509576f, 0.14190893f, 0.12514448f, -0.14178418f, -0.38918722f, -0.23143908f, -0.06001961f, 
    -0.28713620f, -0.14480573f, -0.06817645f, -0.15499727f, 0.14599384f, 0.04077342f, 0.13556848f, -0.00059683f, 
    -0.09356610f, -0.48852271f, -0.31211364f, -0.20146626f, -0.00707371f, 0.12749365f, 0.01618873f, -0.00333362f, 
    -0.10779966f, 0.00577244f, 0.05094733f, -0.01386260f, -0.61209017f, -0.30399749f, -0.50967371f, -0.37333965f, 
    0.16865267f, -0.40918633f, 0.17686731f, -0.15566128f, -0.06108297f, 0.02156310f, 0.00425863f, -0.06813537f, 
    0.10094230f, 0.14937021f, 0.21099728f, 0.04345110f, 0.00871044f, -0.03075160f, -0.01324400f, 0.05416004f, 
    0.50297058f, 0.12781747f, 0.10885697f, 0.20580575f, 0.50256932f, 0.22304195f, 0.17316402f, 0.21896726f, 
    0.09503668f, -0.14363734f, 0.06116970f, 0.09117471f, 0.29323795f, 0.02321068f, 0.13203038f, -0.09932829f, 
    0.22605072f, -0.16397636f, 0.07737524f, -0.19407703f, 0.28049383f, -0.00512120f, 0.00341693f, 0.37789971f, 
    0.12040445f, 0.09602589f, -0.06937529f, -0.05035182f, -0.06459416f, 0.18739009f, 0.10027093f, 0.06097589f, 
    -0.17847405f, 0.05069390f, -0.01498987f, -0.16971865f, -0.00380426f, 0.01993403f, -0.06037108f, -0.07608615f, 
    -0.15766594f, -0.13026601f, -0.10800908f, -0.16607912f, -0.09016419f, -0.02441011f, 0.00491111f, 0.01466780f, 
    -0.12683570f, 0.06745183f, 0.15018585f, -0.00783790f, -0.23175806f, -0.28297314f, 0.09618044f, 0.26329932f, 
    0.10129395f, 0.02526613f, 0.00289752f, -0.01027511f, -0.00262157f, -0.14390880f, -0.21095085f, 0.04900742f, 
    -0.25998601f, -0.53017706f, -0.64104331f, -0.25929171f, 0.09873098f, 0.07731881f, 0.01543418f, -0.18640020f, 
    -0.09570190f, -0.03748028f, -0.02510818f, 0.03005391f, 0.12358698f, -0.20196865f, 0.01979278f, 0.21506926f, 
    -0.06139059f, 0.11135467f, -0.00451845f, -0.05072273f, 0.02792616f, -0.01602453f, 0.01533675f, 0.12709956f, 
    0.16673715f, 0.10313145f, 0.02981839f, -0.03269403f, -0.15323290f, 0.07427604f, -0.09781113f, -0.03717642f, 
    0.04162508f, -0.00062797f, 0.11271363f, 0.15415461f, 0.19677196f, 0.10077258f, 0.01301124f, 0.06871184f, 
    -0.09480063f, -0.04061611f, -0.09068489f, 0.05483365f, 0.18153799f, -0.06730052f, 0.05629077f, 0.00862818f, 
    0.64384627f, 0.24844249f, 0.10792666f, 0.06698095f, -0.14488880f, -0.34696913f, -0.01857789f, -0.04360738f, 
    0.15228671f, 0.09554875f, 0.11104384f, 0.13446608f, 0.28549275f, -0.10486499f, -0.06930740f, -0.33621353f, 
    -0.03518566f, -0.27386037f, -0.06395719f, 0.25264940f, 0.09819809f, -0.13850383f, -0.14612174f, -0.05559551f, 
    -0.03916816f, 0.04757008f, -0.03895540f, 0.10333940f, -0.01493666f, -0.01945752f, 0.17023724f, -0.11788159f, 
    -0.24614762f, -0.07103539f, 0.03350021f, 0.00098303f, 0.37595910f, 0.28087932f, 0.13549735f, -0.07013006f, 
    -0.17497300f, 0.00886641f, 0.03346145f, -0.07981414f, -0.08215727f, -0.12832128f, -0.15381570f, -0.12777637f, 
    0.24470907f, -0.04742723f, 0.15025336f, -0.12137079f, -0.11927669f, -0.00216893f, 0.01487113f, -0.07863528f, 
    0.01771737f, -0.16199175f, -0.07234567f, -0.20295551f, -0.05723874f, 0.03274644f, 0.01775388f, -0.14783238f, 
    0.00588894f, -0.12500128f, -0.07913499f, 0.13514911f, 0.01878735f, -0.02530537f, 0.04378560f, -0.00341130f, 
    -0.00058669f, -0.13565110f, 0.11543633f, -0.20989370f, -0.07070237f, 0.11541510f, 0.09399499f, -0.02882848f, 
    0.20988916f, 0.09903942f, 0.11162345f, 0.23847251f, -0.26064488f, -0.44881666f, 0.01181103f, -0.12964861f, 
    0.15870014f, 0.01634996f, 0.12852934f, 0.08951335f, 0.07501028f, -0.09674660f, -0.08964901f, 0.01155909f, 
    0.04352088f, -0.08034445f, 0.33888558f, -0.20443705f, -0.23009641f, 0.05322306f, -0.03426532f, -0.09099281f, 
    0.17939749f, 0.12019613f, -0.03139669f, 0.03894623f, -0.44638905f, -0.06026737f, -0.23427761f, 0.03571001f, 
    0.17073898f, -0.01999554f, -0.07983365f, -0.02560699f, -0.01382484f, -0.11186183f, 0.10939916f, -0.39717239f, 
    0.05410510f, 0.04639634f, -0.17113981f, 0.21085471f, 0.07081357f, 0.05975721f, 0.05577106f, -0.03857176f, 
    0.13099352f, -0.07927835f, 0.03775803f, 0.16027710f, 0.02444876f, 0.15851952f, -0.00395647f, 0.12611721f, 
    -0.02175494f, 0.00024464f, -0.04364998f, 0.15653795f, 0.17914201f, 0.14287615f, 0.18890120f, 0.10976676f, 
    0.05961531f, 0.32074285f, 0.00472254f, 0.05832705f, -0.10319280f, -0.07670145f, 0.12733588f, 0.23338230f, 
    -0.02218016f, -0.00170230f, -0.03963631f, -0.11136640f, 0.10819400f, 0.06068007f, 0.02322607f, 0.14029841f, 
    0.03230198f, -0.05331239f, 0.06014896f, -0.04018110f, 0.08359227f, 0.09023336f, 0.05046429f, 0.18894666f, 
    -0.23606746f, 0.08929598f, -0.19501014f, 0.14537348f, 0.08532007f, 0.05875032f, -0.02690917f, -0.22807263f, 
    0.00756386f, 0.03352796f, 0.02094380f, -0.02559079f, 0.07517020f, -0.10996602f, -0.12296597f, -0.11310502f, 
    0.05951280f, 0.04252693f, 0.14935468f, -0.27470782f, -0.07637010f, -0.06106741f, -0.17016834f, -0.04058318f, 
    -0.10013185f, 0.15271167f, -0.03799730f, 0.14340910f, 0.14249787f, 0.03561396f, 0.07725713f, 0.09997866f, 
    -0.18029946f, 0.13221465f, 0.04536684f, -0.05385273f, 0.25819394f, 0.12614703f, 0.04911707f, 0.20343971f, 
    -0.08081871f, 0.00043034f, -0.24450515f, -0.12122775f, 0.11198048f, -0.07088002f, 0.06626730f, 0.18713275f, 
    -0.13247935f, 0.03852485f, -0.07331710f, 0.17950886f, -0.05998752f, 0.17290591f, -0.17496476f, -0.02269659f, 
    -0.17056178f, -0.20185141f, -0.06954383f, -0.47889152f, 0.29211611f, 0.23417152f, 0.07708890f, 0.05074033f, 
    -0.05486168f, -0.07035515f, -0.25246239f, -0.18467237f, 0.06148845f, -0.06309772f, 0.03131745f, -0.09613125f, 
    -0.28858155f, 0.00295635f, -0.11711164f, 0.01228701f, -0.02760812f, -0.00416078f, 0.08214505f, 0.01896998f, 
    0.20348077f, 0.37015396f, 0.09321405f, 0.16863555f, 0.04797718f, -0.07706998f, 0.07293322f, 0.28494599f, 
    -0.09003125f, 0.20036392f, 0.01395337f, -0.01690240f, 0.11530878f, 0.05684822f, 0.07760588f, 0.05582019f, 
    0.04735489f, 0.07005186f, -0.04406020f, 0.04192707f, 0.01048323f, -0.00486909f, -0.10680825f, -0.03943931f, 
    -0.06922633f, -0.02393330f, -0.07079307f, -0.10508809f, 0.00669156f, 0.26430368f, -0.06871720f, 0.09014905f, 
    -0.13467146f, -0.01877397f, 0.10705389f, -0.00158587f, 0.02415889f, 0.02533238f, -0.01499232f, 0.13894932f, 
    0.06086971f, -0.08486993f, -0.12192432f, 0.16268365f, -0.02433975f, 0.00740782f, 0.05177461f, -0.02957886f, 
    -0.15391570f, -0.01084731f, -0.00009674f, -0.12181291f, 0.01603945f, 0.11368304f, 0.12660514f, -0.02271875f, 
    -0.01336861f, -0.05242143f, -0.11323611f, -0.07338435f, -0.15408520f, -0.07170574f, 0.05547311f, 0.02061823f, 
    0.00005991f, -0.14366060f, 0.23652066f, 0.06890294f, 0.15468417f, -0.00448484f, 0.08849610f, 0.25675035f, 
    0.07332607f, 0.12454368f, 0.07528902f, -0.02686532f, -0.00818771f, -0.05039430f, -0.06578879f, -0.16678199f, 
    -0.05213414f, 0.07707410f, 0.05205537f, -0.11863173f, 0.15242907f, 0.07706893f, 0.18713686f, -0.00149164f, 
    -0.12910053f, -0.11301604f, -0.20366697f, -0.07639726f, 0.05032991f, 0.03673483f, -0.12763418f, -0.01289267f, 
    0.07855660f, 0.02562858f, 0.04913183f, 0.10995197f, -0.19051456f, -0.10844934f, 0.14243020f, -0.06454002f, 
    0.03871058f, 0.19555923f, 0.24901693f, 0.29927108f, 0.08701114f, 0.01272927f, 0.05912059f, -0.03988979f, 
    0.22728406f, 0.00334122f, -0.02828938f, 0.01894912f, -0.02299275f, -0.01694731f, 0.04237400f, 0.11695940f, 
    -0.29507509f, 0.08639643f, -0.03115458f, -0.12717788f, 0.18897896f, 0.00760103f, 0.05598633f, -0.05473310f, 
    -0.08846194f, 0.09208376f, -0.14242193f, 0.06495098f, -0.16306771f, 0.15842271f, -0.06893875f, 0.00770047f, 
    0.43506995f, 0.06918947f, 0.11480027f, 0.08800432f, 0.12183634f, 0.14900456f, -0.07826534f, -0.11555292f, 
    0.02332432f, -0.07113566f, -0.08999742f, 0.05027145f, -0.41330668f, -0.01385842f, -0.06635333f, -0.28085101f, 
    0.07609626f, 0.20177472f, 0.26265392f, -0.04271814f, -0.06640034f, 0.22808456f, -0.05738252f, -0.21834391f, 
    -0.26154560f, -0.02915024f, -0.00326535f, -0.21258931f, 0.02558845f, -0.09867384f, -0.02528388f, 0.02892982f, 
    0.02903139f, 0.17066859f, -0.04183333f, 0.03256362f, -0.23841038f, -0.23944260f, 0.00896625f, -0.02375624f, 
    -0.02695275f, -0.08721576f, -0.12546870f, -0.08844707f, 0.04921429f, 0.06626161f, 0.22353560f, 0.16561165f, 
    -0.07349832f, 0.00554892f, -0.00001291f, -0.01627401f, 0.05283992f, -0.06440132f, -0.03430106f, 0.02469336f, 
    -0.05495964f, 0.02117893f, -0.07234535f, 0.02612605f, 0.04455027f, -0.02925468f, 0.01672843f, -0.07877710f, 
    -0.02115605f, 0.01516989f, 0.04604743f, -0.01876311f, -0.04455969f, 0.06093076f, -0.02885033f, 0.03357713f, 
    -0.07521184f, 0.00802222f, -0.07512190f, 0.00446135f, -0.08232389f, -0.01929830f, -0.04613627f, 0.05993829f, 
    -0.06330111f, -0.00928077f, 0.01773000f, -0.07740650f, -0.07213210f, 0.04946955f, -0.00514137f, 0.04026074f, 
    -0.04914654f, -0.00713931f, 0.03484087f, -0.08105424f, 0.03731567f, 0.02183209f, -0.04592285f, 0.04479006f, 
    -0.01275104f, -0.01469818f, 0.02880683f, -0.06615715f, -0.04138266f, -0.00606616f, 0.03849893f, -0.00490253f, 
    -0.06737648f, -0.03222363f, -0.08075012f, 0.04526931f, -0.02730975f, 0.06204928f, 0.05604378f, -0.05526152f, 
    0.04293565f, -0.01592611f, 0.03080971f, 0.03422983f, 0.01721347f, 0.00403972f, -0.03476875f, -0.03556372f, 
    0.00335704f, -0.05327176f, -0.03184515f, 0.04162892f, -0.05090211f, 0.05897334f, 0.00236280f, -0.06678081f, 
    0.00558694f, 0.06086743f, -0.06446590f, -0.01219591f, 0.04328302f, -0.02487739f, 0.03220208f, -0.00808753f, 
    0.04833864f, 0.05246498f, 0.05526981f, -0.01746063f, -0.02505493f, -0.04144768f, 0.04809491f, -0.00924840f, 
    0.02663767f, -0.00753269f, -0.03365945f, -0.01325505f, 0.00548430f, -0.07665280f, 0.05716685f, -0.01602339f, 
    0.01467136f, 0.04665383f, -0.04380163f, 0.04452188f, -0.04075476f, 0.03463773f, 0.01342060f, -0.04951995f, 
    -0.06675778f, 0.01476330f, 0.01699375f, -0.01364691f, -0.05260904f, -0.04174249f, -0.02917426f, -0.06354671f, 
    0.01113099f, -0.07676572f, -0.03263013f, 0.05567984f, -0.02547566f, -0.05322910f, 0.05248085f, -0.05328628f, 
    0.03699341f, -0.08559602f, 0.01315208f, -0.03791429f, -0.01157862f, 0.02254606f, 0.02035587f, -0.07289268f, 
    0.00625626f, 0.03261698f, -0.06346536f, -0.05164469f, -0.05701169f, 0.05717897f, 0.01120754f, -0.07264055f, 
    -0.02787174f, 0.00252148f, -0.02690134f, -0.05157484f, 0.01878269f, 0.05155620f, 0.04998184f, -0.05652455f, 
    0.00602998f, 0.04320231f, -0.02805405f, 0.04828386f, 0.04560709f, -0.07401091f, 0.00778753f, -0.06666704f, 
    0.01614677f, 0.00930371f, 0.00111897f, 0.01997542f, 0.05896886f, -0.02001847f, -0.03479810f, -0.02508924f, 
    -0.03759066f, -0.06888068f, 0.00998246f, 0.06525238f, -0.03357557f, -0.02327179f, -0.08481879f, 0.00834415f, 
    0.03637493f, -0.05787755f, 0.04703075f, 0.04627663f, 0.01313045f, 0.02020888f, 0.00275168f, 0.05240323f, 
    -0.07702465f, 0.00675784f, -0.07551762f, -0.04591451f, -0.01032868f, 0.00923066f, -0.00138594f, -0.03310228f, 
    0.03698641f, 0.08714088f, 0.09000889f, 0.02094706f, 0.06194469f, -0.13001394f, 0.04875664f, 0.14109084f, 
    -0.07554495f, -0.12842843f, 0.10689505f, -0.01150456f, 0.15290894f, 0.18965697f, -0.11120527f, -0.15943700f, 
    0.09830917f, 0.27237958f, 0.06484821f, 0.11898841f, -0.05957180f, 0.01879759f, -0.06787742f, -0.06123536f, 
    -0.10340457f, -0.17281409f, 0.05014272f, -0.02335018f, 0.03274272f, 0.04674143f, 0.10964364f, 0.00162008f, 
    -0.08764166f, -0.01708774f, 0.07052795f, -0.05209448f, 0.53489172f, -0.11139832f, -0.01553934f, 0.20334226f, 
    0.11435658f, -0.10634732f, 0.11576669f, 0.06875481f, -0.00675081f, 0.08836684f, 0.21388401f, 0.14856251f, 
    0.14506024f, -0.09419247f, 0.48210239f, -0.23188107f, -0.06340659f, 0.05986967f, 0.03020158f, -0.04007062f, 
    -0.02790161f, 0.07727401f, 0.06672259f, 0.00279256f, 0.03598583f, -0.23788810f, -0.45311236f, 0.09885073f, 
    0.28843325f, -0.07639375f, -0.12087435f, -0.14533944f, 0.01047218f, -0.07693234f, 0.04897470f, -0.03635588f, 
    -0.14287850f, 0.08757895f, -0.11905928f, -0.27075183f, -0.01819204f, 0.06316146f, 0.07894369f, 0.24002418f, 
    -0.06882645f, -0.00308069f, 0.04300685f, -0.05441299f, 0.04937050f, 0.22088648f, 0.10514611f, -0.11032449f, 
    0.12167522f, 0.25062865f, -0.05638267f, 0.11730624f, -0.03213645f, 0.13597076f, 0.02779724f, 0.09522233f, 
    0.29440656f, 0.27887174f, -0.15072076f, -0.26945490f, -0.06632580f, -0.20364299f, 0.08194368f, -0.17772174f, 
    -0.11369117f, 0.01759129f, -0.10157193f, 0.01936679f, 0.10843226f, 0.09241836f, -0.01034210f, -0.11759511f, 
    0.00938460f, -0.07378227f, 0.00674760f, 0.17866021f, -0.00578602f, -0.06547263f, 0.04901395f, 0.05579603f, 
    -0.43493584f, 0.04253353f, -0.17704722f, 0.06858495f, 0.27041948f, 0.08355749f, 0.02496764f, 0.06276565f, 
    0.12465885f, -0.12154640f, 0.03175969f, -0.05530268f, 0.13456894f, -0.33461356f, 0.15877138f, 0.05434650f, 
    0.12301655f, -0.02984930f, 0.07862752f, 0.01710111f, 0.06215755f, 0.14186327f, 0.13789546f, -0.09726966f, 
    -0.21286522f, -0.28281233f, -0.54978383f, -0.06913498f, -0.05538789f, -0.08954732f, 0.16687892f, -0.01220313f, 
    -0.20610902f, 0.14067356f, -0.06297647f, 0.22636950f, 0.01871844f, 0.10704641f, -0.02004184f, -0.04352711f, 
    -0.00087259f, 0.12654237f, -0.06807403f, -0.11366428f, -0.15107150f, 0.06150927f, 0.14153446f, 0.02563133f, 
    -0.04401899f, 0.00810508f, 0.07140461f, -0.11548918f, -0.16736053f, -0.14855121f, -0.06956926f, 0.21800648f, 
    -0.04257815f, 0.07721318f, -0.18028063f, -0.08190682f, -0.35431525f, -0.40125522f, 0.19958122f, 0.06188628f, 
    -0.01992195f, -0.21194445f, -0.13013703f, -0.08754343f, -0.03864559f, 0.03624174f, -0.02865116f, 0.14998457f, 
    0.00429462f, 0.04536938f, -0.04392871f, -0.03889784f, -0.07965853f, -0.07120451f, 0.03733412f, -0.01787197f, 
    -0.02676935f, 0.03980299f, 0.03856980f, -0.05090038f, 0.06077344f, -0.00990686f, -0.07070938f, 0.00567203f, 
    -0.04481758f, 0.03807466f, -0.05283180f, 0.01636791f, -0.01696689f, -0.00415341f, 0.03813829f, -0.07749337f, 
    -0.01216704f, 0.00766524f, -0.05373015f, -0.04265742f, 0.04711188f, 0.03885360f, -0.02235886f, -0.06624550f, 
    0.03851474f, -0.01755588f, -0.00589294f, 0.05520576f, -0.02580300f, 0.03081230f, 0.04383001f, -0.04349777f, 
    -0.07367799f, -0.06785852f, 0.05541189f, -0.05838791f, -0.05591360f, -0.06747469f, 0.02531191f, -0.05909939f, 
    -0.04580011f, 0.02734730f, -0.05642948f, 0.03880665f, -0.02410785f, 0.04901784f, -0.03699866f, -0.05813097f, 
    -0.03442500f, 0.00943016f, -0.06982422f, -0.05742589f, 0.01481813f, 0.03746526f, 0.04457171f, -0.04194048f, 
    -0.00981850f, 0.03075490f, 0.03251284f, -0.01502379f, -0.05308349f, 0.02502153f, 0.02443929f, -0.00133367f, 
    -0.00800752f, 0.00415225f, -0.04907229f, -0.02401617f, -0.01360332f, -0.00390200f, 0.02292485f, 0.04211832f, 
    -0.01686346f, 0.03033718f, 0.03144589f, 0.03569095f, 0.04103547f, 0.03807854f, -0.03023564f, 0.05346542f, 
    -0.06559338f, -0.06205017f, 0.03147728f, 0.01679648f, -0.05296920f, 0.01776367f, 0.05150077f, 0.06206383f, 
    -0.02095546f, -0.02296985f, 0.04749178f, 0.03648595f, 0.01819031f, -0.04807113f, -0.02296455f, -0.03134850f, 
    -0.06669795f, -0.02759560f, -0.05421037f, -0.06964636f, -0.02331242f, 0.05460549f, 0.01015643f, 0.05424395f, 
    -0.02439700f, -0.02244134f, 0.04688026f, -0.00565566f, 0.00119042f, -0.02930663f, -0.01568999f, -0.00894305f, 
    -0.05882706f, 0.04802801f, -0.03330467f, -0.06914707f, -0.05058677f, -0.02095484f, 0.02228088f, -0.06321409f, 
    -0.07796330f, 0.03622903f, 0.00712808f, 0.05664068f, 0.05855237f, 0.01642086f, 0.01809746f, 0.01405715f, 
    0.03349986f, -0.07449524f, 0.03598545f, 0.03147374f, 0.01826224f, -0.04209206f, -0.05516048f, -0.01879910f, 
    0.00047320f, -0.00403364f, -0.00109616f, -0.06808221f, -0.06077293f, 0.03518309f, -0.01844186f, -0.01708344f, 
    0.03587287f, -0.01484929f, -0.03870051f, 0.05384319f, 0.00430842f, -0.06380609f, -0.00437468f, -0.03115331f, 
    -0.05416359f, -0.06595053f, 0.02175402f, 0.04774385f, -0.07951320f, -0.00512074f, -0.02785455f, -0.03193079f, 
    0.02047571f, -0.06634897f, -0.07883662f, 0.05831391f, -0.03347331f, 0.06440502f, 0.02564624f, -0.04699892f, 
    -0.00171317f, -0.07460779f, 0.05918159f, 0.03688093f, -0.01264568f, -0.05801374f, 0.00042694f, -0.06426972f, 
    0.04660174f, -0.01209662f, -0.02469770f, 0.00531033f, -0.00048351f, -0.06123034f, 0.03149879f, 0.03893806f, 
    0.30498555f, 0.26231739f, -0.00909789f, -0.07855954f, 0.04000832f, 0.00295643f, -0.00551373f, -0.15802564f, 
    0.03955354f, -0.06725069f, 0.01526520f, -0.12271716f, 0.18193069f, -0.06765974f, 0.00378659f, 0.03973319f, 
    0.14731830f, 0.01947886f, -0.09853439f, 0.00107930f, 0.09842619f, 0.02191029f, -0.08078081f, 0.15946558f, 
    -0.29386386f, -0.33381042f, -0.16029549f, 0.15641867f, -0.09723431f, -0.01176503f, 0.05996199f, -0.08816261f, 
    0.08461025f, 0.20285416f, 0.07518436f, 0.26276445f, 0.03250068f, -0.53927350f, -0.32784197f, -0.06434181f, 
    0.22489926f, -0.00489565f, 0.17751503f, -0.02374969f, 0.08120079f, -0.06027931f, -0.10640179f, 0.18357839f, 
    -0.24737732f, -0.12384825f, -0.12640963f, -0.06746275f, -0.03677218f, 0.05611369f, 0.01719478f, 0.09685650f, 
    0.15810485f, 0.18972923f, 0.07145213f, 0.13370432f, -0.30092633f, -0.25262797f, 0.32704708f, -0.19468483f, 
    -0.01220920f, -0.00535799f, -0.10036026f, 0.07303196f, -0.25001493f, -0.53295201f, 0.07374123f, -0.53964674f, 
    0.17959130f, 0.25475791f, 0.06731580f, 0.15253422f, -0.03496726f, 0.13178058f, 0.15294202f, -0.07492930f, 
    0.09082285f, -0.08383699f, 0.16803297f, 0.14966953f, 0.10780035f, 0.13528979f, -0.05308747f, 0.19209333f, 
    0.19925562f, 0.09063567f, 0.04880814f, 0.06470655f, 0.11254927f, 0.10011847f, 0.21973008f, 0.05715077f, 
    0.28756362f, 0.28077254f, 0.12963310f, 0.01678827f, -0.06406586f, 0.06981710f, -0.03033163f, 0.21813357f, 
    0.01462576f, 0.02008307f, 0.08043861f, -0.20123109f, 0.22360574f, 0.15075861f, 0.03171598f, 0.04983352f, 
    -0.00853211f, -0.09175431f, 0.10193671f, -0.01674807f, 0.00031058f, 0.17035660f, 0.25405848f, 0.26571381f, 
    -0.05400865f, -0.04258242f, 0.15194112f, 0.24546006f, -0.18713225f, 0.04861324f, 0.04837063f, -0.00376637f, 
    -0.08612679f, -0.16746737f, -0.13781919f, -0.04803326f, -0.06498306f, -0.34090805f, 0.10792238f, 0.11953279f, 
    -0.12588587f, 0.04052004f, 0.02448844f, -0.19751038f, -0.09593556f, -0.16807714f, -0.21389827f, -0.00098547f, 
    -0.27108744f, -0.01189709f, -0.09866086f, 0.31709704f, -0.04508306f, -0.11309353f, -0.07380299f, 0.05569721f, 
    -0.17987894f, -0.07972128f, -0.14843015f, -0.13617226f, 0.25765723f, -0.08919231f, -0.11919978f, 0.10144817f, 
    -0.08145850f, 0.12418608f, -0.08867126f, 0.00157111f, 0.06520322f, 0.00685125f, -0.00743550f, 0.17788532f, 
    0.10671569f, 0.25111818f, -0.34431282f, -0.12333408f, 0.06921162f, 0.02879241f, -0.02125413f, -0.10786367f, 
    -0.31468529f, -0.28750047f, -0.16286549f, -0.54445779f, 0.00465530f, -0.08963362f, 0.21804459f, 0.03095416f, 
    0.00921991f, 0.03773089f, 0.03612173f, -0.14209546f, 0.06772742f, -0.00054267f, -0.12076371f, -0.17058593f, 
    0.13592522f, 0.19390619f, 0.15867516f, 0.12387121f, 0.01849209f, 0.00728805f, 0.00740039f, 0.14803708f, 
    0.03978698f, -0.01835312f, 0.16211657f, 0.05664093f, 0.23407455f, 0.18590829f, -0.06721216f, 0.03220876f, 
    0.09390799f, 0.01358706f, 0.11624768f, -0.04270912f, 0.11828691f, -0.05324817f, -0.08053993f, 0.12587059f, 
    0.18685593f, -0.06632194f, 0.04828834f, -0.07590351f, 0.12677892f, -0.00975920f, -0.06214596f, -0.17141542f, 
    -0.03312072f, -0.00418220f, -0.02548935f, -0.04976812f, 0.51617926f, 0.39582264f, -0.13791165f, 0.10720881f, 
    -0.10694801f, -0.06886213f, 0.11951978f, -0.00063677f, 0.02711681f, 0.04814848f, -0.04065138f, -0.01838948f, 
    0.05384633f, -0.05027616f, 0.20683359f, -0.32018957f, 0.03244595f, 0.09626066f, -0.11050801f, -0.04034712f, 
    0.03789072f, 0.01378279f, 0.10942288f, 0.05965871f, -0.14708462f, -0.32027954f, 0.11284328f, 0.14276320f, 
    0.07750743f, -0.04480678f, -0.22586232f, -0.06443205f, -0.03609138f, 0.07299357f, -0.14254847f, 0.03105074f, 
    0.07738838f, 0.04102056f, -0.06800070f, 0.04008985f, 0.10674696f, -0.10249268f, -0.09364504f, -0.05199935f, 
    0.02922969f, -0.09965330f, 0.03098086f, -0.00064770f, 0.16970098f, 0.17627488f, 0.07616909f, 0.27085063f, 
    0.17881818f, -0.03728306f, 0.01812306f, 0.07393505f, -0.04043381f, -0.08301155f, 0.13597283f, 0.05620244f, 
    0.25957361f, 0.18706901f, 0.21597718f, 0.15468039f, 0.00236262f, 0.06971923f, 0.08853241f, 0.01051195f, 
    0.01482488f, 0.08076899f, -0.01407098f, 0.08156493f, 0.04376018f, 0.02932544f, -0.00392389f, 0.14827466f, 
    0.02130539f, 0.01578678f, -0.00539469f, 0.10199914f, -0.02810784f, -0.12820481f, -0.02945321f, -0.03621362f, 
    -0.49790415f, -0.15224059f, 0.30028579f, 0.03926647f, -0.04237765f, 0.15669356f, -0.27344739f, -0.24651973f, 
    0.03924057f, -0.04662161f, 0.06800234f, 0.01537135f, -0.13163775f, -0.28524706f, 0.01035028f, -0.13693662f, 
    -0.10425151f, -0.11644722f, 0.00421191f, -0.10786798f, 0.05215510f, -0.18248446f, 0.15058656f, -0.13201106f, 
    -0.07771687f, -0.03390548f, -0.13520229f, -0.11717101f, 0.03027187f, -0.07156371f, -0.10316185f, -0.00767461f, 
    0.00236575f, -0.12906714f, 0.00977472f, -0.01236681f, 0.25213176f, 0.07570253f, 0.09743649f, 0.21134660f, 
    0.08995326f, 0.06477842f, 0.14243779f, -0.04940029f, -0.07188891f, -0.00060793f, 0.09200104f, 0.08519602f, 
    0.08297031f, 0.17159607f, 0.18093389f, 0.07450688f, 0.04171148f, 0.11230643f, -0.03663711f, 0.28774393f, 
    -0.05831921f, -0.09085284f, 0.14313726f, 0.09493167f, -0.07201934f, -0.15083854f, -0.32499838f, -0.30692458f, 
    -0.14303815f, 0.04972946f, 0.07585790f, 0.14125775f, 0.01702425f, 0.10151631f, -0.03980481f, 0.03031002f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04585770f, 0.05890764f, 0.18457814f, 0.05694807f, -0.06739619f, 0.09673070f, 0.04206355f, 0.03277796f, 
    0.01814246f, 0.02043610f, 0.07104533f, 0.00430636f, 0.23659103f, 0.03611718f, 0.05244351f, -0.08666332f, 
    -0.03908263f, 0.02487507f, 0.28747183f, 0.07344358f, -0.03416786f, 0.09842434f, 0.08764157f, -0.16452257f, 
    0.09055420f, 0.17070371f, -0.06533312f, -0.02709216f, 0.09998355f, 0.09828860f, 0.05468886f, 0.19881956f, 
    0.03367274f, 0.04009699f, 0.00966453f, -0.04151627f, -0.00290321f, 0.01218007f, 0.07194644f, 0.10225362f, 
    -0.07344795f, -0.07216085f, 0.09616741f, -0.04476399f, 0.03366106f, -0.01771249f, -0.00292830f, 0.02202431f, 
    0.02755546f, -0.00385214f, 0.11123491f, -0.01906256f, 0.06094119f, -0.03705793f, -0.16773471f, 0.22762996f, 
    0.13930245f, -0.06987002f, 0.14674422f, -0.06336292f, 0.06950887f, -0.06789443f, -0.10145906f, -0.10487609f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02503613f, -0.00595203f, 0.01250989f, 0.03499405f, -0.12364690f, -0.14282063f, 0.00591370f, 0.02493617f, 
    0.11225706f, -0.02115577f, -0.06707545f, -0.04692608f, -0.09200241f, -0.01150528f, -0.05287370f, 0.00049426f, 
    -0.10381179f, -0.01555880f, -0.03094080f, -0.02659467f, -0.03929520f, -0.00730368f, -0.10411343f, 0.06886651f, 
    -0.03338622f, -0.08772732f, -0.09544232f, -0.06884576f, 0.03279032f, -0.06214222f, -0.09824108f, -0.04434562f, 
    0.09211493f, 0.01698650f, 0.01816832f, 0.04710485f, -0.05755486f, -0.04188972f, -0.04574605f, -0.12807159f, 
    0.11974409f, -0.10350658f, -0.05545084f, -0.03997132f, 0.05555512f, -0.10975446f, -0.10571302f, -0.07086233f, 
    0.07357717f, -0.00383326f, -0.04084944f, 0.10495770f, -0.10594337f, -0.00806939f, -0.01794879f, 0.07799338f, 
    0.02919414f, 0.00146172f, -0.13968870f, 0.05492978f, -0.09323999f, 0.10093626f, 0.08622269f, -0.06887574f, 
    0.11017984f, 0.11127316f, 0.01676351f, -0.04185574f, -0.01014866f, 0.01337233f, -0.10639571f, -0.11142670f, 
    0.00994542f, 0.07947212f, -0.01736629f, 0.05502315f, -0.07868362f, -0.10341276f, 0.11814023f, -0.09423187f, 
    -0.01134373f, -0.12368559f, -0.13153046f, 0.05544752f, 0.09700312f, 0.12376779f, -0.01744140f, 0.03388574f, 
    0.08974394f, 0.07957430f, 0.07056633f, -0.11817313f, -0.00888650f, 0.04388605f, 0.01592632f, 0.01395488f, 
    -0.09994069f, 0.08569235f, 0.08679402f, 0.08460353f, -0.03921709f, -0.12657484f, -0.08648036f, 0.10484239f, 
    -0.11558691f, 0.01291330f, -0.04828916f, 0.12421983f, 0.05060443f, 0.05871984f, 0.06060484f, -0.15323836f, 
    0.02721661f, -0.06914172f, -0.06354709f, -0.11985046f, -0.20295769f, 0.02432565f, -0.06280003f, -0.00298070f, 
    0.08725502f, -0.05521262f, 0.05723502f, 0.03746282f, 0.05687517f, -0.04358425f, -0.00010646f, 0.13019374f, 
    0.08574483f, 0.02403140f, 0.11307837f, -0.00581987f, -0.01631715f, 0.04456620f, -0.03613224f, -0.15537171f, 
    0.04405999f, 0.16765648f, 0.17479281f, -0.01260791f, 0.22960243f, -0.08238496f, 0.18911391f, -0.24338984f, 
    -0.32477546f, 0.18544404f, 0.16596393f, 0.02219388f, -0.12387487f, -0.15701479f, -0.01510087f, -0.33371535f, 
    0.15084544f, 0.23160671f, 0.09502038f, -0.07926585f, 0.02824182f, 0.15121424f, 0.18913233f, 0.06248768f, 
    -0.02955119f, -0.02287912f, 0.11236034f, 0.21975443f, 0.00691135f, -0.09071308f, -0.04339503f, 0.13197240f, 
    -0.03787833f, -0.03687526f, 0.18698372f, -0.19827285f, 0.09710814f, 0.01280434f, -0.11136046f, -0.09612025f, 
    0.31278411f, -0.14918619f, 0.03467886f, -0.01342822f, 0.03501841f, -0.12687737f, -0.01859202f, 0.39365482f, 
    0.00601916f, -0.37958118f, 0.20793675f, 0.12694380f, 0.16302478f, -0.06220880f, -0.60120893f, -0.16441233f, 
    0.05522617f, 0.05604525f, 0.06925491f, 0.17754588f, 0.10480110f, -0.15633646f, -0.03448383f, 0.22067070f, 
    -0.00266218f, -0.18783125f, 0.12974153f, -0.02860879f, -0.22280233f, 0.06627290f, 0.19095302f, 0.10826510f, 
    0.07486878f, -0.13235819f, -0.51779819f, 0.17079218f, -0.07146496f, -0.02559033f, 0.09857609f, -0.15818278f, 
    0.20054719f, 0.00828834f, -0.03150607f, -0.01383999f, 0.27482957f, 0.03337337f, 0.00428953f, 0.14970063f, 
    -0.22829717f, 0.01113572f, 0.29182059f, 0.24395986f, 0.20674968f, 0.07748663f, 0.14413255f, 0.09617955f, 
    0.06925260f, 0.10958263f, -0.07080955f, -0.00081239f, -0.03289159f, -0.07322724f, 0.05798510f, -0.00992195f, 
    0.60469842f, 0.00384747f, -0.19917363f, -0.11837617f, -0.11609259f, 0.01676698f, 0.11200619f, -0.19268455f, 
    -0.14059491f, -0.06151563f, 0.08703613f, 0.10642764f, -0.46725628f, -0.12038895f, 0.10758737f, 0.06785943f, 
    0.05602159f, 0.09563675f, -0.24622066f, 0.08690424f, -0.01931719f, 0.07461906f, 0.07058417f, -0.21578987f, 
    -0.05236746f, 0.42469123f, -0.00676538f, 0.09772576f, 0.12018177f, 0.01740013f, -0.05531281f, 0.06728239f, 
    0.53398228f, -0.07038857f, 0.00291486f, 0.28525963f, 0.07640932f, 0.02793198f, 0.14285040f, 0.09796415f, 
    -0.29717618f, 0.03656410f, -0.06494105f, -0.12553166f, 0.22045805f, 0.09520218f, 0.15194394f, -0.26672924f, 
    -0.02627890f, 0.11702259f, 0.02962868f, 0.18527864f, -0.05717746f, -0.10613238f, 0.03839241f, -0.02514347f, 
    0.00674626f, 0.07922002f, -0.10944069f, 0.04941823f, -0.05190900f, 0.03433096f, 0.12097494f, 0.03725421f, 
    -0.05733856f, 0.29641420f, 0.02851750f, 0.06777573f, -0.04474973f, 0.12863848f, 0.06806472f, 0.07900339f, 
    0.09994078f, 0.04867269f, 0.00663004f, -0.06574395f, 0.35499731f, -0.04464483f, 0.00629643f, 0.20972209f, 
    0.07522321f, 0.30304742f, -0.28437027f, 0.04254462f, 0.06668015f, -0.12480090f, 0.02610488f, 0.13012472f, 
    -0.07697112f, 0.03482895f, 0.19323564f, 0.08419762f, 0.02935232f, 0.06910422f, -0.07800587f, 0.42476445f, 
    0.31041777f, -0.13880272f, -0.06419387f, 0.14446674f, -0.03751273f, 0.16965742f, -0.09840696f, 0.07929638f, 
    0.06124281f, -0.05829427f, 0.04801981f, 0.22757247f, -0.12765308f, 0.12564257f, 0.22959690f, 0.01932069f, 
    0.03840721f, 0.11773884f, -0.17155780f, 0.01127523f, -0.19495177f, 0.07448649f, -0.23405318f, -0.03485055f, 
    0.04291286f, 0.19721699f, -0.09626143f, -0.06410043f, -0.01851428f, 0.08467571f, 0.06620941f, 0.11001694f, 
    -0.18771632f, 0.31051245f, 0.20257093f, -0.04111306f, -0.06088557f, -0.01083744f, 0.15503773f, -0.21976696f, 
    -0.03752416f, 0.29675630f, -0.17194676f, 0.10263574f, 0.03679542f, -0.09498300f, 0.55972540f, 0.17308205f, 
    0.08497559f, -0.02821660f, -0.27338493f, -0.19884367f, -0.01786821f, -0.01336344f, -0.05589420f, 0.13347453f, 
    -0.00280233f, -0.24530640f, -0.00015523f, 0.05947781f, -0.22909963f, -0.06922512f, -0.11656474f, -0.18141913f, 
    0.02484141f, 0.10571136f, 0.11747205f, 0.00416433f, 0.09635802f, -0.30567059f, -0.02536923f, -0.10057157f, 
    -0.05382835f, -0.05078511f, 0.01756298f, 0.10430755f, 0.17124310f, -0.13418186f, 0.07809789f, -0.05670737f, 
    0.03900418f, 0.03995620f, -0.10495840f, -0.30084699f, -0.04063610f, 0.04838258f, 0.10688202f, -0.25281206f, 
    -0.06154580f, -0.14164752f, -0.03648899f, -0.07752975f, -0.06713584f, 0.09857494f, 0.02472395f, -0.27494925f, 
    -0.29993638f, -0.06537739f, 0.03029291f, 0.05481733f, -0.13922830f, -0.09493730f, 0.20234941f, -0.00591786f, 
    -0.17500803f, -0.02231866f, -0.04283293f, -0.04058991f, 0.29782793f, -0.11643617f, 0.00862844f, -0.40590823f, 
    0.09625416f, 0.20370203f, 0.25641924f, -0.20123364f, 0.02637261f, -0.01662155f, 0.00727593f, 0.40363336f, 
    0.04737522f, -0.53884953f, -0.06689669f, 0.02439450f, 0.01470810f, -0.11281459f, -0.00536924f, -0.07069485f, 
    0.37476209f, -0.12455475f, 0.09312107f, -0.18644829f, 0.08239402f, 0.20061517f, -0.02159695f, -0.05316298f, 
    0.22785066f, 0.15398104f, -0.04734486f, 0.23163629f, -0.02131507f, 0.20441858f, 0.05655689f, 0.07610838f, 
    0.09766096f, -0.00859742f, 0.07542508f, -0.05111165f, 0.18745108f, -0.07445420f, -0.14338516f, 0.07262394f, 
    -0.05184988f, 0.01201766f, -0.15112039f, 0.33141884f, -0.01114542f, 0.01771631f, -0.06620356f, 0.10422967f, 
    -0.21378426f, -0.20934023f, -0.01166488f, 0.10677922f, 0.33942434f, 0.13186777f, 0.13471617f, -0.22167750f, 
    0.01017568f, 0.20599695f, 0.17477857f, -0.05700754f, -0.14255959f, -0.06586466f, -0.00766280f, 0.02598876f, 
    -0.10457996f, 0.14522606f, 0.14909424f, 0.06659569f, -0.05361813f, -0.14823268f, -0.01969295f, -0.04589460f, 
    0.08121929f, 0.00676519f, 0.24052320f, -0.06677280f, 0.14356665f, -0.03796685f, 0.01770491f, -0.07779135f, 
    -0.38548371f, 0.11241545f, 0.15572020f, 0.16798314f, -0.08851884f, -0.01638304f, -0.11801656f, -0.37209862f, 
    0.05022840f, 0.12214512f, -0.07555971f, -0.34977439f, 0.27837324f, 0.02168584f, 0.01099262f, -0.04634764f, 
    -0.06016891f, -0.10318598f, 0.17529668f, 0.07778338f, -0.06747969f, 0.04542893f, 0.10536568f, 0.00923663f, 
    0.10598733f, -0.01482399f, 0.24377489f, -0.08263329f, 0.07086006f, 0.12803331f, 0.07749933f, -0.04578566f, 
    0.11648671f, 0.05229926f, -0.04915023f, -0.01097550f, -0.15302806f, -0.10856587f, -0.12239347f, 0.20817648f, 
    -0.25815886f, -0.48701319f, 0.24484900f, 0.02792449f, -0.13203712f, 0.00924779f, -0.50144738f, -0.01033973f, 
    0.04771349f, 0.23301882f, 0.23464304f, -0.21529633f, 0.07830487f, -0.11501241f, 0.00513521f, -0.05858580f, 
    0.00051337f, -0.08065423f, 0.00674334f, -0.10453199f, 0.30814958f, -0.00654937f, 0.08243455f, 0.09701816f, 
    -0.10782693f, 0.03456041f, -0.08518355f, 0.04790330f, -0.06776037f, -0.05376484f, 0.04365928f, 0.05832050f, 
    0.39954248f, 0.10784037f, 0.06510291f, -0.24183096f, -0.12195776f, 0.15836185f, 0.10362291f, 0.11634696f, 
    0.04393299f, 0.01360016f, -0.06148585f, 0.15377781f, 0.09503285f, -0.02138791f, -0.10719486f, 0.20377192f, 
    -0.08458697f, 0.06779400f, 0.18104154f, -0.09861570f, -0.06440511f, -0.10618712f, 0.09306859f, -0.05747217f, 
    0.33752671f, -0.13897160f, -0.00051062f, 0.05270215f, -0.02140865f, -0.14672436f, -0.18986833f, 0.09842123f, 
    -0.07778318f, -0.19516857f, -0.00195354f, -0.09775127f, -0.20273779f, -0.04506964f, -0.31972143f, 0.10284460f, 
    0.10484634f, 0.01814829f, 0.02092693f, 0.04681360f, 0.03718118f, -0.13595490f, -0.15258293f, -0.06598684f, 
    -0.10632014f, -0.01477303f, -0.01294314f, 0.05533016f, -0.07539599f, -0.07636982f, 0.08655378f, -0.10591372f, 
    -0.13030578f, -0.11897629f, 0.03750006f, -0.12984349f, 0.11353731f, 0.05853945f, -0.12774910f, -0.00771511f, 
    -0.14418021f, -0.10312701f, 0.09632736f, -0.10078758f, 0.07764527f, -0.06975354f, -0.06828549f, 0.02290325f, 
    -0.06233035f, 0.00583959f, 0.01629185f, 0.08308846f, 0.04918488f, -0.01609017f, -0.11562745f, -0.02046938f, 
    -0.10283391f, 0.03091750f, -0.08480182f, -0.04042358f, 0.00502335f, 0.04904258f, 0.09545083f, 0.06178726f, 
    -0.04113947f, 0.07619441f, -0.10649471f, 0.06107917f, -0.08041594f, 0.05891934f, -0.14064811f, -0.11741330f, 
    -0.03288999f, 0.08013023f, -0.11819421f, -0.12826368f, -0.09996322f, 0.08385138f, -0.10489812f, -0.09933381f, 
    0.05327627f, 0.04980329f, 0.10868499f, 0.03100375f, 0.06930501f, 0.20933235f, 0.17570153f, 0.24608384f, 
    -0.05034398f, -0.16308951f, 0.10683254f, 0.00348281f, 0.20211545f, -0.09570654f, -0.09769341f, -0.14308812f, 
    0.09680335f, -0.15716773f, 0.07016698f, -0.27036145f, 0.11444144f, 0.13905425f, -0.39582714f, -0.08994447f, 
    0.11045054f, 0.06353696f, -0.11725404f, -0.17436896f, -0.01599229f, -0.09193724f, -0.15649673f, 0.00043547f, 
    -0.01293509f, -0.01060057f, 0.08954754f, -0.52107817f, -0.16648965f, 0.02739686f, -0.19845346f, -0.13558498f, 
    -0.08061107f, 0.07591043f, 0.06056012f, -0.01001455f, -0.09340736f, 0.11554040f, -0.02691685f, 0.33374545f, 
    -0.42165422f, 0.05741861f, 0.07520054f, -0.01211294f, 0.04792100f, 0.26112285f, -0.13767540f, -0.09563734f, 
    0.19257778f, 0.09638716f, 0.09537188f, -0.01616322f, 0.62999386f, 0.08863955f, -0.16645372f, -0.09988378f, 
    0.01224533f, -0.10274636f, -0.14357373f, 0.06227802f, -0.10161332f, -0.02714844f, -0.24861850f, -0.07429036f, 
    0.11919700f, 0.05534618f, 0.03930542f, -0.03747885f, -0.16077854f, -0.01469763f, 0.04190008f, -0.03448490f, 
    -0.21060202f, -0.00543795f, -0.01497984f, 0.08510803f, -0.08975784f, -0.10128556f, 0.00767491f, -0.04229642f, 
    -0.08902084f, 0.00396973f, -0.01799881f, 0.17551175f, -0.00313852f, -0.02420853f, 0.03354365f, -0.07207882f, 
    -0.09002703f, 0.01322494f, 0.02122937f, 0.05988479f, 0.07467397f, 0.03524851f, -0.07765280f, -0.06257323f, 
    -0.01845746f, 0.00661604f, -0.14113958f, -0.10257329f, 0.01809973f, -0.12072720f, -0.07321307f, -0.06571174f, 
    0.10836930f, 0.14124863f, -0.08578219f, -0.03475118f, -0.23340775f, -0.11275604f, 0.03123816f, 0.15614952f, 
    -0.22773309f, -0.09975247f, -0.00310407f, 0.03092183f, -0.17590097f, -0.11067387f, -0.16984676f, -0.04843831f, 
    0.05639106f, 0.08201671f, 0.29376566f, 0.18033163f, -0.08849861f, -0.26317778f, 0.14242406f, 0.35038090f, 
    -0.06812790f, -0.40883189f, 0.11268895f, -0.06356722f, 0.15499566f, -0.06083739f, 0.08923169f, -0.05610792f, 
    0.40976518f, -0.25187546f, 0.15995811f, 0.11757316f, 0.09760254f, -0.05914292f, -0.11622346f, -0.18717399f, 
    0.06071896f, -0.05922508f, -0.01396520f, -0.06832124f, 0.42817321f, 0.20575845f, 0.12672892f, -0.02979064f, 
    0.00586793f, -0.03458779f, -0.07948809f, -0.04948433f, 0.07119223f, 0.07385764f, -0.14458679f, 0.13900442f, 
    -0.07653771f, -0.07159560f, 0.04673026f, 0.22396041f, -0.03005640f, -0.07870532f, -0.02005112f, 0.31987303f, 
    0.18251908f, -0.03586304f, 0.04632931f, 0.08532766f, 0.21741728f, 0.04387512f, 0.00590411f, -0.15936585f, 
    -0.22164935f, 0.09134129f, -0.03996566f, -0.12121880f, -0.20369451f, 0.05797656f, -0.17271031f, -0.01515446f, 
    -0.08578008f, -0.07146731f, 0.27484098f, 0.40961924f, -0.00803163f, -0.09935631f, 0.22329377f, 0.02010238f, 
    -0.11551527f, 0.21948507f, 0.06300696f, -0.00669587f, 0.33688712f, 0.02981420f, -0.03341154f, -0.06266087f, 
    -0.00114171f, -0.09916001f, 0.43983135f, -0.19321835f, -0.03033627f, 0.08373881f, 0.26448211f, -0.48440877f, 
    -0.02668389f, 0.15511024f, -0.00854680f, -0.15395106f, 0.13229334f, 0.12546344f, 0.23281807f, -0.07521278f, 
    0.14854319f, -0.06187863f, -0.09457283f, -0.12478402f, -0.26393232f, 0.07789457f, 0.00848014f, -0.27457923f, 
    0.08863998f, -0.09720595f, 0.07359424f, -0.01799016f, -0.08067837f, -0.00972457f, -0.02305904f, 0.37688699f, 
    0.10590438f, -0.14141729f, -0.04889089f, -0.05643439f, 0.40563339f, -0.04759850f, -0.15696040f, 0.10920261f, 
    -0.18948650f, 0.16615643f, 0.16241094f, 0.10830586f, 0.14451480f, 0.10705731f, -0.42550540f, -0.35708898f, 
    0.06239996f, 0.13531037f, 0.02905941f, -0.21823321f, 0.00269692f, 0.03761761f, -0.02210123f, 0.14724167f, 
    0.05067195f, -0.11806283f, -0.19538878f, -0.04304172f, 0.12122806f, -0.11696422f, 0.15186349f, 0.11593852f, 
    0.21496864f, -0.12950453f, -0.24290048f, 0.16006476f, 0.04396531f, -0.23413441f, -0.02828804f, 0.02659904f, 
    -0.16896734f, -0.15273033f, -0.10885832f, -0.15265591f, 0.23249200f, -0.01892781f, 0.19396505f, -0.21819273f, 
    0.15614727f, -0.03035501f, -0.00214884f, 0.14860241f, 0.09378665f, -0.12136698f, 0.17962660f, 0.11820752f, 
    0.07317088f, 0.07279024f, -0.01738486f, 0.21479028f, 0.03169225f, 0.02656160f, 0.12569007f, 0.04326241f, 
    0.22044264f, 0.18306267f, 0.14685370f, 0.08960241f, 0.19918470f, 0.10498401f, -0.03415643f, -0.35325649f, 
    0.50239480f, 0.09485886f, -0.12746595f, 0.05251557f, -0.14511874f, -0.02947560f, -0.12287316f, 0.12494119f, 
    -0.08331020f, -0.02803414f, -0.04257465f, 0.42487982f, 0.05281302f, -0.22844134f, 0.13692559f, -0.00866955f, 
    -0.07800888f, 0.34205711f, 0.19347458f, 0.01541695f, -0.06825446f, 0.04238022f, 0.24796648f, -0.02668814f, 
    0.16239758f, -0.04707639f, -0.23981397f, 0.30156225f, 0.03121958f, -0.15319382f, 0.13648959f, -0.13874844f, 
    -0.19653860f, 0.04621967f, -0.02788104f, -0.24482562f, 0.40725067f, -0.18539235f, -0.01124679f, 0.00203552f, 
    -0.32696983f, 0.09044146f, 0.12693274f, 0.22016382f, 0.06971761f, -0.01180958f, 0.12987949f, 0.09147190f, 
    0.02596384f, -0.27091503f, 0.16574290f, 0.01469516f, 0.08974433f, 0.13454768f, -0.07619453f, -0.13452560f, 
    0.53360224f, 0.30752355f, -0.25679275f, -0.00506193f, -0.17711158f, -0.01879462f, -0.20311083f, 0.26047936f, 
    -0.07366839f, -0.02606128f, 0.04070466f, 0.05935463f, 0.32066450f, -0.10073779f, -0.06906351f, 0.06648689f, 
    0.06715298f, 0.19620970f, 0.25630647f, -0.16118360f, -0.00720997f, -0.26343289f, 0.02586990f, 0.20153728f, 
    -0.03052878f, -0.33321643f, -0.01153025f, -0.00675578f, -0.12554424f, -0.03777950f, 0.05389807f, -0.15698053f, 
    0.09093874f, 0.03806198f, -0.19804107f, -0.02036465f, -0.00489784f, -0.07712364f, -0.00104111f, 0.00868087f, 
    0.17070472f, 0.20782530f, 0.05292978f, -0.05556800f, -0.12265168f, 0.21811247f, 0.15679663f, -0.07355660f, 
    0.03431131f, -0.09260777f, -0.21327122f, 0.01134740f, -0.01674358f, 0.10354444f, -0.00992271f, 0.28576088f, 
    0.06163500f, -0.02148208f, 0.10183784f, -0.26898205f, 0.01475926f, -0.12383079f, 0.06780072f, -0.24319886f, 
    0.10626727f, -0.06446777f, 0.15139806f, -0.05722847f, 0.00140583f, -0.08539713f, 0.18189231f, -0.01110412f, 
    0.00463434f, -0.20503409f, 0.10740107f, 0.08395815f, 0.08064175f, -0.01650913f, -0.06452563f, 0.21994717f, 
    0.12499739f, -0.23889697f, 0.25065696f, 0.06762864f, -0.04425726f, -0.03926085f, 0.29677525f, 0.08355081f, 
    -0.05820720f, 0.45812842f, -0.18097864f, 0.11395762f, 0.21496730f, 0.03928282f, 0.18710175f, -0.06429277f, 
    0.21427621f, -0.22010876f, -0.02756213f, -0.15085489f, 0.07120150f, 0.27243817f, 0.39010119f, -0.06086192f, 
    -0.10194528f, 0.04896977f, 0.04387185f, -0.42378700f, 0.27417994f, 0.18529002f, 0.11463912f, 0.00769163f, 
    0.10990316f, 0.02645284f, 0.36128393f, 0.05751318f, -0.09378086f, 0.02415782f, -0.06619167f, -0.14289622f, 
    0.00706497f, 0.02224580f, -0.08725127f, 0.13318336f, 0.10685825f, -0.04211544f, 0.01367836f, 0.31002316f, 
    0.30832729f, -0.10119329f, -0.03271772f, -0.01113684f, 0.30838820f, 0.17082077f, -0.26857138f, 0.01518677f, 
    0.24582344f, -0.09011019f, -0.15379788f, -0.10293621f, 0.15131368f, 0.03182005f, -0.01963369f, -0.05156649f, 
    0.09883125f, -0.08218038f, -0.01998319f, -0.13619934f, -0.08605288f, 0.02783721f, 0.01508235f, 0.00532080f, 
    -0.07475589f, 0.01561657f, -0.13481595f, 0.04583043f, -0.15710227f, -0.00691763f, -0.07010188f, -0.08361438f, 
    0.10886502f, -0.13177532f, -0.08451521f, -0.07480246f, -0.04141335f, -0.00626688f, -0.10511918f, -0.03914671f, 
    -0.02670731f, -0.02821691f, -0.09437339f, -0.03119938f, -0.00520007f, -0.11881517f, 0.07021014f, -0.07509576f, 
    -0.09811312f, -0.08618408f, -0.06796380f, -0.01770763f, -0.16755868f, -0.05622765f, -0.04739480f, 0.07732594f, 
    -0.08368477f, 0.02933843f, 0.03926292f, 0.03033175f, -0.09716348f, 0.11232692f, 0.00295031f, -0.00099860f, 
    0.11882210f, -0.10684478f, -0.00766191f, 0.07394704f, -0.08466162f, -0.12669513f, -0.14211309f, 0.06113616f, 
    -0.01287191f, 0.00066975f, 0.00307585f, -0.06641607f, 0.02496384f, -0.02578948f, -0.07407783f, -0.11311407f, 
    -0.05521368f, 0.11442312f, -0.16995315f, -0.00482003f, -0.06367264f, -0.02387539f, 0.09184217f, -0.16857143f, 
    0.02906492f, 0.15012890f, -0.07249222f, -0.06187247f, -0.03240576f, 0.06099914f, -0.03352365f, 0.32268462f, 
    0.39452285f, -0.16741610f, -0.15308687f, 0.13736874f, 0.00235506f, 0.12280675f, -0.06040314f, 0.24577016f, 
    -0.06064360f, 0.02984670f, 0.03497747f, -0.04366470f, 0.01285030f, 0.12084921f, 0.01180091f, -0.02036921f, 
    0.21514685f, -0.05155417f, -0.23333864f, -0.14351036f, -0.32421163f, 0.02728429f, -0.10745259f, 0.04347500f, 
    0.04700897f, 0.06741053f, -0.14486256f, 0.09186578f, 0.10013039f, 0.01016301f, -0.10264787f, 0.09444965f, 
    -0.03394114f, 0.31619385f, 0.25273791f, -0.04954712f, -0.04993713f, 0.01862177f, 0.01135960f, -0.00886455f, 
    0.29511935f, 0.17278920f, -0.14864443f, -0.05601002f, 0.39595145f, -0.09207280f, 0.29272512f, 0.07187455f, 
    0.10223375f, 0.24927160f, 0.15317476f, -0.05589977f, -0.06700735f, 0.06405608f, 0.01913557f, 0.28937635f, 
    0.06594283f, -0.15951160f, 0.13802987f, 0.11329909f, 0.01959253f, -0.00520589f, 0.15398200f, -0.37494096f, 
    0.00151532f, -0.16326600f, -0.10061415f, -0.06067024f, 0.12009170f, -0.10428726f, 0.37706199f, 0.09299587f, 
    0.34576747f, 0.07566231f, 0.11205976f, 0.34255317f, -0.02552591f, -0.00077718f, -0.30176556f, -0.13083068f, 
    -0.25108188f, -0.01556023f, -0.04369278f, 0.02004208f, 0.30358198f, 0.05374086f, 0.12016966f, -0.08217024f, 
    0.11584708f, -0.01672087f, -0.18468532f, 0.19885911f, 0.08428234f, -0.06611920f, 0.07622788f, 0.28012806f, 
    0.79106927f, 0.01456757f, -0.09920416f, 0.05731347f, 0.00396066f, -0.02170483f, -0.20570418f, -0.06897264f, 
    0.20284961f, 0.29172984f, -0.12276538f, -0.06526618f, -0.35861087f, 0.03161934f, 0.31895983f, 0.04841474f, 
    -0.09471302f, -0.11641090f, 0.14051375f, 0.01591492f, 0.07677460f, 0.07328736f, 0.27838466f, 0.09712207f, 
    -0.07844321f, -0.14446898f, -0.16533317f, -0.03190496f, 0.27462569f, -0.08393379f, 0.07550324f, -0.08053120f, 
    -0.30351683f, 0.14085235f, 0.08754624f, -0.07827884f, -0.12061005f, -0.27103305f, 0.05184722f, -0.14335267f, 
    0.20626743f, 0.36235911f, 0.11416772f, -0.35386211f, -0.01733687f, 0.15977795f, 0.25129279f, 0.38200477f, 
    0.20317471f, -0.11117125f, 0.15625075f, -0.05927511f, -0.07996792f, -0.10591982f, 0.08004303f, 0.22272043f, 
    -0.06983323f, 0.00043084f, 0.05495432f, -0.08197767f, -0.11694185f, -0.10430509f, -0.07412764f, 0.01123447f, 
    -0.35481113f, -0.34539133f, 0.02441717f, -0.07488066f, 0.37452209f, 0.12825784f, -0.09685791f, 0.26274392f, 
    0.04167689f, -0.14253142f, 0.05246155f, -0.05682236f, 0.10253155f, -0.07191510f, -0.47557557f, 0.04827922f, 
    0.08012123f, -0.11157231f, 0.07690220f, 0.04852051f, 0.10457875f, 0.13819627f, 0.17703539f, 0.13621645f, 
    -0.03115717f, 0.38801178f, -0.00003763f, 0.02270826f, -0.24396332f, 0.04540533f, 0.07916439f, 0.17864257f, 
    -0.27203822f, 0.14291224f, -0.30582035f, 0.17987910f, 0.06493124f, 0.06171724f, 0.44520062f, -0.10908380f, 
    -0.23801985f, 0.26155689f, -0.01920259f, -0.28223795f, 0.31650609f, 0.10339524f, 0.13359989f, 0.14627373f, 
    -0.18445222f, -0.07610520f, 0.34453240f, 0.35512576f, 0.24267200f, -0.06156537f, 0.11381141f, -0.10916906f, 
    0.11395083f, 0.00915876f, 0.34025609f, -0.15174066f, 0.12442750f, 0.02305784f, -0.04654589f, -0.19190732f, 
    -0.06002863f, -0.14313771f, -0.30866617f, 0.01967828f, 0.01976481f, 0.17633870f, -0.00684775f, 0.05620774f, 
    -0.06225923f, -0.19435239f, -0.20487866f, 0.11765765f, -0.40078554f, -0.08233054f, 0.38143545f, 0.10579232f, 
    0.06679482f, 0.01238901f, -0.03607615f, 0.10620124f, -0.08629438f, -0.09252052f, -0.04487099f, 0.02183251f, 
    -0.02383480f, 0.03081961f, -0.16417339f, 0.10695922f, 0.05793426f, 0.09426550f, 0.06419539f, -0.10646106f, 
    -0.11677421f, -0.20201106f, 0.09402063f, -0.12819789f, 0.02705287f, -0.00012551f, 0.04801830f, -0.16536862f, 
    -0.09469698f, 0.06226638f, 0.08083301f, 0.02537625f, 0.01705391f, -0.13602701f, 0.07928330f, -0.09471425f, 
    -0.07791746f, 0.09604324f, -0.09148446f, -0.04932728f, 0.03603949f, -0.00695385f, 0.03143229f, 0.01793359f, 
    -0.08978367f, 0.02185250f, 0.06195828f, -0.16350375f, -0.05959863f, -0.01886687f, -0.04018506f, -0.07962788f, 
    -0.09359587f, -0.16423205f, -0.05266696f, -0.00145142f, -0.09658378f, -0.10365399f, -0.18197267f, -0.01721107f, 
    -0.09362403f, -0.06182595f, -0.05439670f, 0.03316110f, 0.09447144f, 0.11461233f, 0.05220562f, -0.04607741f, 
    0.00432891f, 0.03093210f, -0.05221581f, 0.15934357f, -0.02711987f, -0.01155024f, 0.18066573f, 0.00359067f, 
    -0.06375480f, -0.32726622f, 0.07731394f, 0.01482187f, -0.03241657f, -0.10722004f, 0.25742209f, 0.05256353f, 
    -0.08714848f, -0.02680073f, -0.12467987f, 0.11501569f, 0.03351153f, -0.85381436f, -0.33627829f, -0.22090055f, 
    -0.05023407f, -0.00749086f, 0.09630451f, -0.21573479f, 0.22122890f, 0.09956429f, 0.07443043f, 0.20498978f, 
    -0.06777347f, 0.10412823f, 0.08839563f, -0.07191758f, 0.09155758f, -0.03681009f, 0.13826479f, 0.10173712f, 
    -0.06380981f, -0.07805485f, 0.20912328f, 0.13680278f, 0.10051675f, -0.10382153f, -0.01195489f, -0.06060333f, 
    -0.05701199f, 0.07146672f, 0.07775519f, -0.08881605f, 0.14622404f, -0.01102721f, -0.04186855f, -0.10265051f, 
    0.22384419f, -0.20564117f, 0.22372326f, 0.11253533f, 0.08673824f, 0.10832669f, -0.33473891f, 0.17191553f, 
    0.10009108f, 0.03292710f, -0.09462691f, 0.05101430f, 0.05135122f, 0.09087291f, 0.09300300f, 0.12595329f, 
    0.08753958f, 0.01222411f, 0.15521494f, -0.08831768f, -0.29661781f, -0.04384157f, -0.06057795f, 0.20593818f, 
    0.10746294f, 0.05889824f, -0.33112237f, 0.16695850f, 0.03004258f, 0.05276303f, 0.07849228f, 0.22767106f, 
    -0.04349426f, 0.13631375f, 0.05242511f, 0.10839394f, 0.19889961f, 0.01434230f, 0.05789153f, 0.30378693f, 
    -0.00845887f, 0.03045368f, 0.37647980f, -0.08681160f, 0.11748000f, 0.02928283f, -0.07933993f, -0.14442554f, 
    -0.08536980f, 0.13749629f, 0.19510539f, -0.13068426f, 0.02138604f, 0.09765557f, -0.08475859f, -0.11160397f, 
    -0.34030434f, -0.04359007f, -0.11472732f, -0.11886519f, 0.12832996f, 0.08294065f, 0.19881400f, 0.02796818f, 
    -0.22093816f, 0.28655356f, -0.19627520f, -0.10434275f, -0.02038302f, -0.04171875f, 0.51789367f, 0.00240667f, 
    -0.11798127f, 0.17648773f, -0.20687474f, -0.21454425f, -0.04810135f, -0.46606371f, 0.04727473f, 0.13810244f, 
    -0.02022275f, 0.06725066f, 0.14261538f, 0.06994904f, -0.03814712f, 0.11725938f, 0.18815586f, 0.19716583f, 
    0.07406841f, -0.23486879f, -0.33411551f, 0.01213491f, 0.07863650f, 0.09903637f, -0.11299996f, 0.21188281f, 
    0.23787795f, -0.10689508f, 0.06324716f, -0.06738667f, -0.10273647f, 0.14995787f, 0.17595807f, -0.00395073f, 
    -0.10865153f, -0.10060694f, 0.08822836f, 0.05733961f, -0.26590964f, -0.11645086f, -0.21117578f, 0.14404780f, 
    -0.03817990f, 0.16875486f, -0.00986150f, -0.12810630f, -0.11619106f, -0.05725448f, 0.10080821f, -0.06360035f, 
    0.11930751f, 0.21148184f, 0.08200478f, -0.02952183f, -0.08643828f, -0.12798946f, 0.01979538f, -0.11913136f, 
    -0.25457713f, -0.05615898f, 0.00158062f, -0.06681805f, 0.43396389f, 0.06386960f, 0.07348987f, 0.13221768f, 
    0.02067798f, 0.03571302f, 0.13021913f, 0.19211338f, 0.11877742f, -0.12024803f, 0.25581616f, 0.10946558f, 
    -0.03934245f, 0.13624789f, -0.12539306f, -0.06773594f, 0.01894089f, -0.02141835f, 0.06767330f, 0.09107944f, 
    0.34702072f, -0.36403391f, -0.05346370f, -0.01879595f, 0.04498301f, 0.04866852f, 0.15994835f, 0.07146547f, 
    0.00067329f, -0.10016753f, -0.05075208f, -0.16332607f, 0.16436157f, 0.12259105f, 0.12181304f, -0.04122947f, 
    0.24030496f, -0.10368404f, -0.08088225f, 0.25119799f, -0.32296926f, -0.01157851f, -0.25040728f, -0.27774206f, 
    -0.09031779f, 0.23797257f, 0.05933589f, 0.17170988f, 0.07711783f, 0.12105706f, -0.11300549f, 0.47580266f, 
    0.43999037f, -0.14230457f, 0.09435420f, 0.05653967f, 0.22033979f, 0.10608935f, -0.15724674f, -0.40825787f, 
    0.00926703f, 0.48042879f, -0.15317291f, -0.06791368f, -0.31707928f, -0.07916547f, 0.50518590f, 0.15728685f, 
    0.11323158f, 0.17214024f, -0.09326818f, -0.05286156f, 0.06226519f, -0.12158693f, 0.13178378f, -0.09793616f, 
    0.04625472f, 0.07277526f, -0.15934512f, 0.02730510f, -0.04107879f, -0.05805042f, 0.12669842f, 0.03240386f, 
    0.13233697f, -0.09532018f, -0.22351965f, -0.10436577f, -0.01737024f, -0.15536334f, -0.00121921f, -0.04928994f, 
    0.20642260f, 0.09340776f, -0.06451628f, 0.07117510f, 0.03574570f, -0.13743083f, -0.22303976f, -0.07524081f, 
    -0.08597118f, -0.07386421f, -0.23777893f, -0.05026407f, 0.02794887f, 0.01752447f, -0.02755244f, -0.33709624f, 
    0.07506996f, 0.00069360f, 0.10069761f, 0.16404864f, -0.10546853f, 0.04778889f, -0.07094269f, 0.17987643f, 
    0.27786723f, 0.12585963f, 0.05714928f, -0.02479284f, 0.12744921f, -0.18365958f, -0.06171871f, 0.01423591f, 
    0.15015531f, 0.06570153f, -0.13043657f, -0.03327340f, -0.10399844f, -0.07605535f, 0.12484185f, -0.14001149f, 
    -0.01030061f, -0.25735173f, -0.19555913f, 0.11157610f, -0.00885994f, 0.17729659f, -0.13087597f, 0.03244700f, 
    0.00004521f, -0.02273247f, 0.00560002f, -0.01908017f, -0.15732349f, 0.02966593f, 0.02559116f, 0.02761632f, 
    0.06858835f, 0.04690319f, -0.02937769f, -0.01033506f, -0.00344735f, 0.46384028f, -0.21282914f, 0.12980165f, 
    -0.31648847f, -0.15561567f, -0.08241859f, -0.12014857f, -0.08359163f, -0.09773894f, -0.07443251f, 0.00415807f, 
    0.10750417f, 0.03274995f, 0.10661203f, 0.05404128f, -0.12193906f, -0.03287822f, 0.13577285f, 0.03530199f, 
    0.06475140f, 0.15937141f, -0.13915987f, 0.08100776f, 0.06596099f, 0.06297978f, 0.03821974f, -0.16923164f, 
    -0.29468855f, 0.13541946f, 0.04428680f, 0.09860343f, -0.15141970f, 0.13570371f, -0.06941321f, -0.21967752f, 
    0.06739892f, -0.19855736f, 0.21250026f, 0.00212375f, -0.01826741f, -0.06128357f, -0.23689489f, -0.13923596f, 
    0.03994386f, -0.04604949f, -0.00612572f, -0.14173338f, -0.07961572f, 0.12186925f, 0.01616927f, 0.09187642f, 
    -0.12357171f, 0.10194645f, 0.11515141f, 0.04810305f, -0.00837358f, 0.08639923f, 0.20306158f, -0.16699417f, 
    -0.01287271f, 0.00116991f, -0.01282583f, 0.18386568f, -0.03491622f, 0.10848273f, -0.05279253f, -0.11923912f, 
    0.12317806f, 0.10505773f, 0.07597430f, -0.10694510f, -0.03624890f, -0.03302583f, -0.32820046f, 0.00873006f, 
    0.06754063f, -0.02336172f, 0.14973070f, -0.43520591f, -0.11379112f, 0.10057797f, -0.04480346f, 0.03645634f, 
    0.10507099f, -0.15492013f, -0.09201349f, 0.02780258f, 0.08237365f, -0.06289887f, 0.11875602f, -0.25882867f, 
    -0.15246335f, 0.00893567f, -0.23671086f, -0.06045252f, 0.12056401f, 0.21487579f, -0.13480283f, 0.01190391f, 
    0.09683011f, -0.10721749f, -0.01168054f, -0.05947266f, -0.27043134f, -0.00581105f, -0.02190684f, -0.07023857f, 
    -0.07918791f, 0.20487678f, -0.02531129f, -0.40609112f, -0.06243932f, 0.05032304f, 0.07031681f, -0.04985122f, 
    -0.01164946f, -0.19855891f, -0.03147551f, -0.03027661f, 0.10270777f, -0.00501994f, -0.03659700f, 0.00353748f, 
    -0.11520306f, 0.26563168f, 0.08581021f, 0.09907135f, 0.10213766f, -0.26498675f, -0.10216098f, 0.11906953f, 
    -0.08003276f, 0.25891998f, 0.06592512f, -0.13118473f, -0.02407818f, 0.10516006f, 0.05699866f, 0.05038187f, 
    0.17734313f, 0.02009363f, 0.04512463f, 0.05658580f, 0.11341137f, 0.11099817f, -0.13034651f, 0.26382363f, 
    0.09026895f, -0.01171791f, 0.19337146f, -0.26404294f, -0.03203239f, -0.00208674f, 0.11421492f, -0.06852914f, 
    -0.42324054f, -0.27997538f, 0.11718712f, -0.03124311f, 0.09837754f, -0.09935199f, -0.09726435f, 0.25137827f, 
    0.02148940f, -0.05272014f, -0.12653896f, 0.06765887f, -0.00008350f, -0.05837552f, 0.02078417f, 0.25816292f, 
    0.12048790f, 0.06977722f, 0.19402063f, -0.15992901f, -0.05489101f, 0.17910329f, -0.05904222f, 0.17713267f, 
    -0.08199218f, -0.53369045f, 0.14823651f, -0.07458322f, 0.30333391f, 0.12483463f, -0.06440537f, 0.06084374f, 
    -0.35306126f, -0.13760234f, 0.31514269f, -0.09317524f, -0.04195568f, -0.00774261f, -0.39950463f, 0.08127816f, 
    0.14242998f, 0.10678892f, 0.03502696f, -0.08879759f, -0.15412299f, 0.10138170f, 0.11840729f, 0.31834865f, 
    0.21575515f, -0.10157575f, -0.04060856f, -0.07189891f, -0.28896785f, -0.00704795f, -0.00163974f, 0.04471819f, 
    0.08104034f, 0.24253318f, 0.03263070f, -0.09950976f, 0.06750771f, -0.01460166f, -0.02541967f, 0.09007092f, 
    -0.27337596f, -0.04003379f, 0.26472139f, -0.01534517f, 0.16755877f, 0.08485351f, 0.15361075f, -0.06606694f, 
    -0.08273192f, 0.19018467f, 0.26536509f, -0.10688760f, -0.04920618f, -0.06282912f, 0.01248293f, -0.05452346f, 
    -0.01226325f, -0.04893096f, 0.02163392f, -0.02379007f, -0.05833305f, 0.01484334f, 0.12247963f, -0.06786489f, 
    0.00701961f, 0.24616478f, -0.14277476f, -0.09170635f, 0.14088452f, 0.02595541f, -0.07896297f, 0.16033201f, 
    0.29546675f, -0.09327954f, 0.09255548f, -0.05077842f, -0.01658549f, 0.27649638f, 0.34440714f, 0.34340155f, 
    -0.10490898f, 0.15991850f, 0.09015687f, 0.34484723f, -0.13435380f, 0.19473933f, 0.03433074f, -0.11350990f, 
    0.23052552f, 0.07140487f, -0.20925961f, 0.22010787f, -0.01259254f, 0.02021057f, -0.19675952f, 0.00004583f, 
    -0.06060538f, 0.21576439f, 0.03801884f, 0.03413665f, 0.01015399f, 0.07688513f, -0.09095636f, -0.00383837f, 
    -0.19793333f, -0.24162857f, -0.09767947f, 0.01883554f, 0.23298232f, -0.07048403f, 0.16216719f, 0.02144350f, 
    -0.25453278f, 0.23183672f, 0.00547851f, 0.09142784f, 0.01773535f, -0.01280366f, 0.26842034f, -0.00303872f, 
    0.03412869f, -0.17650689f, 0.06600755f, 0.09125914f, 0.01540862f, 0.09559640f, 0.27405778f, 0.40388682f, 
    0.03799258f, -0.23086034f, 0.05590369f, -0.08048937f, 0.06396165f, -0.08669946f, 0.04121923f, 0.01634140f, 
    -0.43128234f, 0.11326570f, 0.24068430f, -0.29940066f, -0.08177395f, -0.07150787f, -0.32215250f, -0.22969803f, 
    0.05666670f, -0.05203328f, -0.09150410f, -0.14369065f, -0.00518330f, -0.01611963f, -0.09950154f, 0.12822106f, 
    -0.06585711f, -0.08144986f, 0.34578204f, -0.53272653f, -0.22361644f, -0.10802380f, -0.01126879f, -0.05162979f, 
    -0.05061390f, 0.01613849f, 0.06953862f, 0.10447472f, -0.10762566f, -0.01310718f, -0.05646474f, 0.39019868f, 
    -0.32457036f, -0.19610250f, 0.13300769f, 0.08421268f, 0.32727429f, 0.20146601f, 0.00702077f, -0.15222840f, 
    -0.10197711f, 0.27941644f, -0.00228373f, 0.04455251f, 0.09921286f, -0.01298462f, 0.11455071f, -0.33040839f, 
    0.03131109f, 0.14936753f, -0.12628023f, -0.03785999f, 0.11394898f, 0.15163450f, -0.07363112f, -0.29335278f, 
    -0.03431739f, 0.17470586f, 0.21750821f, -0.05348153f, 0.06471245f, 0.11604619f, 0.08530818f, -0.02415527f, 
    0.12488735f, -0.01216765f, -0.04592603f, 0.25778064f, 0.06228975f, -0.03569864f, 0.17505790f, 0.19530307f, 
    0.28411916f, -0.06420030f, -0.01760691f, 0.06985672f, -0.30368188f, 0.12998439f, 0.00320363f, 0.12698533f, 
    -0.03105322f, -0.06066935f, -0.05567431f, 0.23266123f, -0.06064689f, 0.10174572f, -0.10427869f, 0.14940789f, 
    -0.10440554f, 0.15838364f, 0.11948074f, -0.09748802f, 0.00960935f, -0.04812200f, -0.09407764f, -0.35490292f, 
    0.20070283f, 0.23705728f, -0.15176147f, 0.06798790f, -0.45444360f, -0.23903313f, -0.37843007f, 0.20242666f, 
    0.24020293f, -0.37598675f, -0.04849505f, 0.10180373f, 0.03928662f, 0.06252118f, -0.10289281f, 0.18149225f, 
    -0.05527447f, -0.20845377f, -0.06758433f, -0.09697799f, -0.05313979f, -0.14095925f, 0.04035826f, -0.21678534f, 
    -0.09977746f, -0.15468028f, -0.18369868f, -0.07223766f, -0.06516121f, 0.00271550f, -0.10572398f, -0.02601878f, 
    0.03410633f, 0.22759753f, 0.06922337f, -0.13644242f, 0.11284213f, -0.08582591f, -0.05511077f, -0.24948183f, 
    -0.26371393f, -0.12052871f, -0.09684347f, 0.04033694f, 0.40962628f, -0.28272563f, 0.07648881f, -0.17891285f, 
    -0.03829425f, 0.11609122f, -0.13671453f, -0.02867045f, 0.02796039f, 0.02396704f, 0.14113452f, -0.09274470f, 
    -0.02806821f, -0.25993958f, 0.14150745f, 0.00679123f, -0.08853036f, -0.03325272f, 0.03940910f, 0.02189301f, 
    -0.02834436f, -0.09093839f, -0.09534642f, 0.04834225f, -0.08369178f, 0.07363313f, 0.22000137f, -0.12080325f, 
    -0.37453160f, -0.04373853f, -0.11856592f, -0.09449932f, -0.16265202f, 0.06488444f, 0.04390822f, -0.19145924f, 
    -0.06231027f, -0.03580614f, 0.04363672f, -0.07279913f, -0.01512714f, -0.09887902f, -0.01865433f, -0.13670547f, 
    0.02027625f, 0.08610213f, -0.03035151f, 0.05805549f, 0.04254044f, 0.08543978f, -0.03468507f, 0.02759362f, 
    -0.10618602f, 0.00548061f, -0.04596796f, -0.01420578f, 0.00852628f, 0.00120927f, 0.02986595f, -0.03161873f, 
    -0.01488860f, 0.00043063f, 0.08852130f, -0.06253445f, 0.03546463f, 0.07331039f, -0.09738309f, -0.00852568f, 
    -0.05394850f, -0.06373999f, -0.12535860f, -0.06551003f, -0.11284635f, -0.10045149f, -0.07890563f, -0.12524492f, 
    0.01379438f, 0.01173859f, -0.04229581f, 0.00368714f, -0.08952172f, -0.06159502f, -0.11296863f, 0.07471883f, 
    0.07276415f, -0.10523628f, -0.04106395f, -0.02468996f, 0.04018660f, -0.07205638f, -0.06149165f, -0.03635854f, 
    0.05672819f, -0.00384001f, -0.07294762f, 0.06983162f, -0.05851154f, 0.10573307f, -0.03265359f, 0.04746150f, 
    -0.02747928f, -0.09452184f, 0.32146332f, 0.03789586f, -0.06971730f, 0.01825548f, 0.08443840f, 0.40303627f, 
    -0.07423366f, -0.17235669f, -0.12823834f, 0.09689813f, 0.17247486f, 0.05742096f, 0.09841394f, 0.02287389f, 
    0.36980790f, -0.16234717f, 0.06777910f, -0.03682878f, 0.01036102f, 0.19115002f, 0.08845972f, -0.11360662f, 
    0.01537717f, 0.14246383f, 0.10433511f, -0.09921299f, 0.41961288f, 0.16567233f, 0.22478522f, 0.10796907f, 
    -0.03501379f, 0.01238286f, 0.09608246f, -0.01942306f, 0.20350236f, 0.11251904f, 0.03125490f, 0.09785732f, 
    -0.08491949f, -0.15400818f, -0.15553269f, 0.18834452f, 0.04935696f, -0.05842317f, 0.04672050f, 0.18480434f, 
    0.08062064f, -0.28223267f, 0.04627949f, -0.03573469f, 0.53066987f, 0.26223069f, -0.00884830f, -0.25275582f, 
    0.10552257f, 0.19029997f, -0.08349586f, -0.07062588f, -0.28740221f, -0.07633173f, -0.20424621f, 0.01843563f, 
    0.03469786f, 0.02525831f, -0.07677652f, -0.08050597f, -0.00261962f, -0.15194219f, 0.15876824f, 0.11683212f, 
    0.06894137f, -0.09686697f, 0.14356010f, -0.07872647f, -0.01129590f, 0.06401685f, 0.01494382f, 0.19795749f, 
    0.04499820f, 0.01948017f, -0.26935202f, 0.14127871f, 0.13036306f, 0.08444949f, -0.22988816f, 0.21804430f, 
    0.05215493f, -0.04749291f, 0.15535663f, 0.01506981f, -0.10433068f, -0.04141176f, 0.10683476f, 0.12900193f, 
    0.18716061f, -0.02323575f, 0.01135576f, -0.07800245f, -0.07612345f, 0.01544761f, -0.16387253f, 0.27441949f, 
    -0.11360151f, 0.24262339f, 0.09382486f, -0.15059111f, -0.00594324f, -0.11765480f, -0.02046540f, 0.08086468f, 
    -0.21178256f, 0.29767334f, 0.26202556f, 0.05944338f, -0.07346004f, 0.05622742f, 0.20097241f, 0.03959180f, 
    -0.07843379f, 0.17173432f, 0.04147207f, -0.05597969f, 0.68860596f, -0.08146238f, 0.42158902f, 0.28725627f, 
    -0.02938166f, 0.16797635f, 0.00591636f, 0.08827049f, 0.01316223f, -0.01466275f, 0.01724563f, -0.04962541f, 
    0.12287535f, 0.08354029f, 0.03609265f, -0.12244287f, 0.00697049f, 0.05726578f, 0.07065614f, 0.03954731f, 
    0.04186701f, -0.03558253f, 0.08627869f, -0.00679918f, 0.01101771f, 0.08077349f, -0.04665418f, 0.04802568f, 
    0.15536657f, -0.07997955f, 0.05595754f, -0.00779999f, 0.08706596f, 0.02575048f, -0.08525252f, -0.16056532f, 
    0.01338458f, -0.03738684f, 0.07059439f, -0.07947855f, 0.09901312f, -0.04848983f, -0.10461890f, -0.01862232f, 
    -0.11489645f, 0.18661909f, 0.06458166f, -0.06058203f, 0.06387435f, 0.11145503f, 0.03925958f, -0.07686424f, 
    0.01188404f, -0.00666756f, 0.14168501f, 0.07753347f, 0.01200517f, -0.07066973f, -0.09297218f, -0.04196176f, 
    0.10886240f, 0.19552462f, -0.14841942f, 0.07568122f, 0.00918327f, 0.04858572f, 0.06206774f, 0.06448165f, 
    0.09311827f, 0.17914116f, 0.01173431f, 0.27404678f, 0.02077009f, 0.01415059f, -0.08105034f, 0.09320086f, 
    -0.05295652f, 0.24940827f, 0.23990126f, -0.05205830f, -0.22841291f, 0.07857200f, -0.08592231f, -0.08345440f, 
    0.34988222f, -0.13548602f, -0.35673666f, 0.08534089f, -0.03210840f, 0.11583725f, 0.43495613f, 0.19178045f, 
    0.19348365f, 0.15545207f, 0.08666801f, 0.32159057f, 0.06324943f, -0.20584749f, -0.08561391f, 0.09019548f, 
    -0.34861687f, 0.09749241f, 0.17017518f, 0.24248661f, 0.09645037f, -0.07014244f, -0.11585537f, -0.00200507f, 
    -0.06855742f, 0.03731206f, -0.04062101f, -0.11467858f, -0.12352449f, 0.02850280f, -0.06112897f, -0.20101584f, 
    0.61277330f, 0.28878614f, -0.47599295f, 0.01194394f, -0.24181752f, 0.03318891f, -0.05297793f, 0.19246137f, 
    0.00670989f, 0.10388068f, 0.09879438f, 0.03394842f, 0.02039986f, -0.07645201f, 0.09406280f, -0.06734969f, 
    -0.04797357f, -0.16633742f, 0.10331256f, 0.10969127f, 0.08582157f, -0.06292821f, 0.05053572f, 0.01564069f, 
    -0.09377097f, 0.02630658f, 0.07685916f, -0.08009809f, 0.03742126f, -0.03474580f, 0.04165983f, -0.07157528f, 
    -0.08057471f, 0.02369454f, -0.09874180f, -0.10922004f, 0.03515440f, 0.11337468f, 0.03026620f, -0.15565608f, 
    -0.00746905f, 0.01283504f, 0.01851541f, -0.13012727f, -0.08943055f, -0.15012339f, 0.08327235f, -0.02194715f, 
    0.03923505f, -0.09992291f, -0.04037890f, -0.14477558f, 0.03211326f, -0.09912153f, -0.07460099f, -0.12374412f, 
    0.10890460f, -0.10451967f, -0.12856355f, -0.08200678f, -0.10818195f, 0.04349552f, 0.04411821f, -0.04845589f, 
    -0.08321746f, -0.12348589f, -0.12777013f, -0.00701277f, 0.01800258f, -0.07221042f, 0.00886957f, -0.10356402f, 
    -0.18716992f, -0.07857045f, -0.13316193f, 0.08723812f, -0.10909078f, 0.10388319f, -0.05160927f, -0.08826437f, 
    0.11721310f, -0.17856021f, -0.10900360f, 0.12645824f, -0.04747653f, -0.20606934f, 0.21894865f, 0.06741076f, 
    0.03535582f, 0.24310289f, -0.05263247f, -0.04438722f, -0.18641436f, -0.10398979f, -0.13050954f, 0.11693814f, 
    0.34270015f, -0.11893314f, -0.11583803f, 0.17795169f, -0.05480068f, -0.02578037f, 0.06750531f, 0.14410260f, 
    -0.22631784f, 0.01390512f, -0.11315393f, 0.11304512f, 0.19233017f, 0.19005124f, 0.20808373f, 0.00419137f, 
    0.18645686f, -0.08785152f, -0.10922641f, 0.17908734f, -0.14329407f, 0.06130990f, -0.00932220f, 0.13883792f, 
    0.02299715f, 0.15151663f, 0.01548659f, 0.11084837f, 0.09571798f, -0.04167221f, 0.03572387f, 0.08817460f, 
    -0.32132283f, -0.07310858f, 0.11604557f, -0.01888897f, 0.08575243f, 0.22648865f, 0.22826503f, -0.04980872f, 
    -0.08549865f, 0.41059154f, -0.25101829f, 0.05178196f, 0.02692262f, 0.02980310f, 0.38186693f, 0.20010082f, 
    0.04789060f, -0.02955369f, 0.10573949f, 0.06823450f, -0.00534948f, 0.03473317f, 0.11667297f, -0.00257865f, 
    -0.01992627f, -0.16549075f, -0.09067295f, 0.06331359f, 0.04159822f, -0.07637245f, 0.06101235f, -0.01282130f, 
    -0.05803396f, -0.00701964f, -0.00149760f, -0.08241916f, 0.02790095f, 0.10563505f, -0.03666990f, -0.16379409f, 
    0.05668212f, -0.09757319f, 0.07241380f, -0.02260119f, -0.03962759f, 0.17951161f, -0.13360325f, -0.08243002f, 
    -0.04784572f, 0.05512122f, -0.06387841f, -0.23707040f, -0.05985076f, 0.02080040f, -0.18296240f, -0.13054508f, 
    -0.00849529f, -0.06586887f, -0.04004589f, -0.08449930f, -0.06553265f, -0.07718132f, 0.00210168f, 0.16905653f, 
    -0.12345759f, -0.06529604f, -0.05931807f, -0.05384143f, 0.03070831f, 0.10802285f, -0.03216704f, -0.05322518f, 
    0.00333630f, 0.01726020f, -0.11139154f, -0.04475642f, -0.10560560f, -0.05519999f, 0.03297808f, 0.01905274f, 
    -0.12243326f, 0.02760419f, 0.02247296f, 0.06323206f, 0.11288603f, -0.00957166f, 0.08980347f, 0.02587436f, 
    -0.06552558f, 0.04027298f, -0.04962742f, -0.11625162f, -0.10656619f, 0.04961045f, -0.07495856f, -0.00670310f, 
    0.06490498f, -0.09076179f, -0.16689739f, 0.17114194f, 0.05218527f, 0.22829971f, 0.04570976f, -0.15154697f, 
    -0.07196185f, -0.25598490f, 0.06326558f, -0.07568838f, -0.06764866f, -0.14958107f, -0.13414985f, -0.02012200f, 
    -0.10473792f, -0.07302646f, 0.02577534f, -0.00795394f, 0.06215588f, -0.04663685f, -0.20596893f, -0.21020792f, 
    -0.05397174f, -0.00842791f, -0.27813154f, 0.13023308f, -0.10762176f, 0.08878188f, 0.01560241f, 0.00480485f, 
    0.10589603f, 0.07640439f, -0.04986824f, 0.05836829f, -0.16437486f, 0.14037815f, -0.03284612f, -0.03533085f, 
    0.09092823f, 0.11802639f, -0.15862836f, 0.09735297f, -0.21883699f, 0.09486926f, 0.12390739f, -0.05340840f, 
    -0.07445831f, 0.05259606f, -0.07904394f, -0.11914401f, 0.06723026f, 0.01285307f, -0.01165129f, -0.10067063f, 
    -0.08660016f, 0.02035779f, -0.12957576f, -0.09381001f, -0.00875654f, -0.03039489f, 0.05036529f, -0.04587293f, 
    0.00324123f, -0.11126626f, -0.01428536f, -0.12169932f, -0.00992086f, 0.01222237f, -0.04350577f, 0.07885141f, 
    -0.03130839f, 0.06496124f, 0.09438575f, -0.05183528f, -0.04458249f, 0.02675014f, 0.07366346f, 0.08719027f, 
    0.04797220f, 0.06412022f, -0.01319924f, -0.08000524f, 0.05824663f, 0.04620576f, -0.05251451f, -0.11751860f, 
    0.06786308f, -0.06783489f, -0.06193376f, -0.09795348f, 0.10165080f, 0.00091977f, 0.09211903f, -0.13753562f, 
    0.07930285f, 0.04535575f, -0.09503780f, -0.09026690f, 0.07381397f, -0.12435319f, -0.08707868f, -0.12855501f, 
    -0.06101578f, -0.05082801f, -0.04934847f, 0.01774604f, -0.09435711f, -0.10240890f, -0.02746273f, -0.12854990f, 
    -0.07996088f, 0.00529487f, 0.22062041f, -0.22144389f, 0.07535343f, 0.04657699f, -0.12726805f, 0.22517817f, 
    0.05321789f, -0.24000269f, 0.01787160f, -0.00998589f, 0.03772607f, -0.02149621f, 0.05536147f, -0.25367671f, 
    0.16356993f, -0.15844873f, -0.16361278f, -0.14013837f, 0.03421731f, 0.07408240f, 0.10549254f, 0.13202262f, 
    0.19284303f, 0.19656578f, -0.09632661f, 0.17400765f, -0.38198632f, 0.11208515f, -0.21980835f, 0.11711705f, 
    0.01268729f, -0.12305163f, 0.02805752f, 0.01931444f, 0.03429722f, -0.08673282f, -0.22789150f, 0.13509731f, 
    0.08834034f, 0.07082866f, -0.02101794f, -0.12055817f, 0.04275499f, 0.10379237f, 0.11025824f, -0.19377951f, 
    0.19280013f, -0.05552062f, -0.25654200f, -0.01993272f, -0.04624252f, -0.06760839f, -0.09397535f, -0.05295578f, 
    -0.06975968f, 0.00684034f, 0.12229092f, 0.04988016f, -0.11805537f, -0.11786540f, 0.16778375f, -0.12738098f, 
    0.00331657f, -0.03636394f, 0.20342366f, -0.07023440f, 0.08018339f, 0.15140344f, 0.24641237f, 0.19318870f, 
    0.06855689f, 0.06654123f, 0.03337676f, 0.10715066f, -0.02353828f, -0.07319226f, 0.22441456f, -0.31378770f, 
    -0.32291159f, -0.02593044f, -0.14841835f, -0.09480502f, -0.04967136f, -0.01488593f, 0.42852020f, 0.08023848f, 
    0.07677463f, 0.30415332f, -0.03072950f, -0.12599996f, 0.18458843f, -0.03996144f, 0.00229650f, 0.26794624f, 
    -0.18848991f, -0.04770393f, 0.45555526f, 0.17806137f, 0.04114236f, -0.05845890f, -0.01507220f, 0.04548812f, 
    -0.09083655f, -0.09151645f, 0.17126372f, -0.10942356f, 0.11403339f, -0.06916988f, -0.04217995f, -0.17705847f, 
    0.35339218f, -0.23275658f, -0.44654351f, 0.05882895f, 0.14992173f, 0.28440762f, -0.10813298f, 0.02066925f, 
    -0.03757249f, -0.39249578f, 0.16961783f, 0.06406733f, -0.16042306f, -0.08767754f, -0.23101005f, -0.11623742f, 
    -0.01634816f, 0.10981368f, -0.17745627f, -0.17007884f, -0.11721324f, 0.03706226f, -0.03627687f, 0.04447031f, 
    -0.05194975f, 0.06249997f, 0.01761647f, 0.09975167f, -0.06952204f, -0.02374691f, -0.05867364f, 0.16432723f, 
    -0.37707865f, -0.08978673f, 0.10722142f, 0.06088518f, 0.01461357f, -0.09355817f, -0.07018890f, 0.07179547f, 
    0.08480715f, -0.17167242f, 0.09800199f, 0.19435956f, -0.29704732f, 0.02964935f, -0.03802961f, -0.06766041f, 
    0.01681414f, -0.09324482f, -0.31417733f, 0.03717755f, -0.08459907f, 0.00462548f, -0.70965302f, -0.08882044f, 
    0.04773264f, 0.25995323f, 0.15529850f, -0.47813848f, -0.09555960f, 0.02468464f, 0.04400389f, 0.02168431f, 
    -0.09307384f, -0.12639345f, 0.19697309f, 0.03340408f, -0.04602844f, -0.09581840f, 0.04256039f, 0.10791635f, 
    -0.24908870f, 0.33528107f, -0.38675523f, 0.10314942f, 0.04173371f, 0.02616367f, 0.24171263f, -0.00296041f, 
    0.10174197f, -0.07577026f, 0.12799394f, 0.10537940f, -0.09095888f, -0.10154009f, 0.07201164f, 0.02614131f, 
    0.01009127f, 0.05270787f, -0.07280326f, -0.04280372f, -0.04674081f, 0.03675418f, 0.00925241f, 0.04353585f, 
    -0.06198767f, -0.08289353f, -0.00750811f, -0.10218927f, -0.02553340f, 0.07690754f, -0.12428566f, 0.07036347f, 
    0.03214907f, 0.02381830f, 0.01548271f, -0.01971693f, -0.05345428f, 0.06921470f, -0.06554341f, -0.09461775f, 
    0.03852962f, 0.05122619f, 0.07556910f, -0.04595513f, 0.02309204f, -0.08013660f, -0.07729241f, 0.11068159f, 
    0.07083765f, -0.08238292f, 0.02772822f, -0.07620031f, 0.08849053f, -0.10661045f, 0.02014601f, -0.05502524f, 
    0.00356761f, -0.14236709f, -0.08896340f, 0.00174543f, -0.08632118f, -0.10276554f, -0.14496550f, -0.02293518f, 
    0.02937832f, 0.07103077f, -0.06355547f, 0.08691265f, -0.05223673f, 0.02228632f, 0.10640275f, 0.02683182f, 
    0.04251555f, -0.09803599f, -0.07619824f, 0.10491868f, -0.06570359f, -0.06461613f, -0.02693868f, -0.11153418f, 
    -0.10554555f, -0.03646200f, -0.12020534f, -0.02797297f, 0.02455310f, -0.10664341f, -0.08787688f, -0.11348666f, 
    -0.00479324f, -0.09993974f, -0.17308114f, -0.15550359f, -0.01132078f, -0.12541428f, 0.11805566f, 0.05055783f, 
    0.07174985f, 0.06781539f, -0.01328997f, -0.03640881f, 0.11805739f, -0.13381626f, 0.04850738f, 0.05301348f, 
    -0.11056888f, -0.03815295f, -0.11027324f, -0.00053664f, -0.17662132f, -0.01448217f, 0.03235213f, 0.08502116f, 
    0.11310847f, -0.09276197f, -0.04856372f, -0.05393377f, -0.07860245f, -0.02376093f, -0.01696731f, -0.09792351f, 
    0.01246647f, -0.04221377f, 0.10688401f, 0.09578370f, -0.09298667f, -0.07607637f, -0.09293203f, -0.02030930f, 
    -0.12703435f, 0.00026633f, -0.14084798f, -0.11968340f, 0.07411162f, -0.09465384f, 0.14072220f, 0.02205341f, 
    0.05528137f, -0.06214477f, -0.15606968f, 0.09899097f, 0.05959124f, -0.18824424f, -0.04963093f, -0.01516136f, 
    -0.04674683f, 0.39601406f, -0.01810990f, -0.00592243f, -0.07696681f, 0.09168383f, -0.07029583f, 0.11068636f, 
    -0.32332197f, 0.02947618f, -0.09240229f, -0.00134567f, -0.10331096f, -0.05385017f, 0.28580031f, 0.37212953f, 
    -0.14876850f, 0.08159102f, -0.09654551f, 0.13034883f, 0.09866550f, -0.00691663f, 0.24418166f, -0.17977825f, 
    0.02857268f, 0.04997920f, -0.14160801f, 0.11890578f, -0.28111979f, 0.09764848f, -0.29323962f, 0.13374680f, 
    0.04365794f, 0.13547412f, 0.17662601f, -0.10381869f, 0.09562736f, 0.09458376f, -0.11176549f, -0.14687933f, 
    -0.10305791f, -0.17996086f, -0.08582199f, -0.12922333f, -0.06562083f, -0.06229640f, -0.06883021f, -0.01104752f, 
    -0.41875228f, -0.06830780f, -0.37039796f, -0.02654471f, 0.35738873f, 0.12870845f, 0.11322870f, 0.28188327f, 
    -0.10242158f, 0.00852354f, 0.14241241f, -0.07355595f, 0.04298700f, 0.22728795f, 0.14872389f, -0.05988525f, 
    0.11438135f, 0.22565916f, -0.37090296f, -0.06091174f, 0.02872858f, -0.05447137f, -0.07708428f, 0.06443106f, 
    0.41737372f, 0.13563538f, -0.17594679f, 0.01713379f, -0.04624973f, 0.09430044f, 0.50024998f, 0.09119246f, 
    -0.17366919f, 0.17660280f, -0.00138818f, 0.05410812f, -0.24165675f, 0.09278951f, 0.11164359f, -0.09643090f, 
    0.18664750f, -0.02098060f, 0.04089535f, 0.35631841f, 0.21322186f, -0.06365599f, -0.11856570f, 0.11933143f, 
    0.00585507f, 0.13603446f, 0.05147574f, 0.01645906f, -0.09519235f, -0.01135130f, -0.04195916f, -0.29465377f, 
    -0.08559292f, -0.11125173f, -0.15032527f, 0.07613074f, 0.09838513f, 0.27676982f, -0.06806587f, 0.04550573f, 
    0.22457953f, -0.11086009f, -0.18520612f, -0.07251372f, -0.01062453f, -0.05438873f, -0.36651292f, 0.10031622f, 
    0.04162580f, 0.24105027f, 0.01391727f, -0.11973709f, 0.11581150f, 0.00499883f, 0.00611248f, 0.03278466f, 
    0.08214344f, -0.44839093f, 0.26680729f, -0.08697235f, 0.23645458f, 0.02233397f, -0.00318989f, 0.19907190f, 
    -0.17032743f, 0.00345309f, 0.30064860f, 0.00505430f, 0.03816700f, 0.14824030f, -0.43417650f, 0.10700426f, 
    0.16376027f, -0.02613349f, 0.04280139f, 0.12579876f, -0.23268948f, 0.14928801f, 0.07592619f, 0.29369470f, 
    0.13739890f, 0.10335888f, -0.22569488f, -0.05411869f, 0.01370616f, 0.09130453f, -0.35851806f, 0.15948030f, 
    0.06279224f, 0.28146669f, 0.14820655f, -0.08935900f, 0.03433107f, -0.06433756f, 0.05436736f, 0.02163576f, 
    -0.49091867f, 0.10095365f, 0.31019849f, -0.04940539f, 0.01425774f, -0.06898259f, -0.04097670f, 0.14688767f, 
    -0.15905082f, 0.12234178f, -0.04395965f, -0.03633898f, -0.01728837f, -0.04753460f, 0.18931872f, -0.07086208f, 
    -0.04137997f, 0.02691576f, -0.05590992f, -0.10314874f, 0.00258103f, -0.05805003f, -0.23143265f, -0.30534321f, 
    0.08166736f, 0.28427091f, 0.20830919f, 0.05717552f, -0.01761973f, 0.02381629f, 0.07228708f, -0.16008963f, 
    0.21134681f, 0.03644048f, 0.12398899f, 0.08525035f, 0.06681828f, 0.18164364f, 0.17625208f, -0.59677434f, 
    -0.06871487f, -0.03883276f, -0.10903272f, 0.26939395f, 0.12008388f, -0.15989015f, -0.43448269f, -0.15835959f, 
    -0.33698195f, -0.10017163f, 0.06608348f, -0.13561714f, 0.15106355f, 0.09867384f, 0.00473686f, -0.49382281f, 
    -0.03010297f, -0.03016781f, -0.09992985f, -0.08302904f, 0.12495966f, 0.12044382f, -0.02994345f, -0.14836004f, 
    0.14213026f, 0.19149087f, -0.11173834f, -0.19565214f, -0.17854580f, -0.27606699f, 0.17731483f, 0.37955147f, 
    -0.07136454f, 0.24691677f, 0.05567726f, 0.09167941f, -0.28130776f, -0.06970944f, 0.11981601f, -0.23870648f, 
    -0.10799135f, 0.13494647f, -0.28446203f, -0.14451051f, -0.02430153f, 0.00623025f, -0.22410025f, -0.12950225f, 
    -0.01269364f, -0.00640449f, 0.28740427f, -0.10798871f, 0.02634399f, -0.02761234f, 0.12959607f, 0.15311405f, 
    -0.02888433f, 0.13274409f, -0.13800552f, 0.26229474f, -0.11335763f, -0.03866041f, -0.12760182f, 0.29547128f, 
    -0.00604752f, -0.23031089f, -0.02337968f, -0.09534130f, -0.15818296f, 0.11969299f, 0.00735636f, 0.07551149f, 
    -0.01095839f, 0.03986925f, -0.14976399f, 0.16922286f, -0.07349215f, -0.01745935f, 0.10042726f, 0.09254878f, 
    -0.09973531f, 0.07391731f, 0.02080274f, -0.27761975f, 0.09507693f, -0.04189390f, -0.02409864f, -0.22090441f, 
    0.21852298f, 0.44700736f, 0.12994473f, 0.00846208f, -0.19182430f, -0.14334838f, 0.05847571f, 0.11753457f, 
    0.05299742f, -0.11628009f, 0.05220385f, -0.06269840f, 0.14998448f, 0.11123382f, 0.33179054f, 0.24556430f, 
    -0.07108242f, 0.10446469f, -0.21431045f, 0.16777010f, -0.04150861f, 0.10946946f, 0.12256476f, -0.35148013f, 
    -0.02564175f, 0.23709245f, 0.18201898f, -0.02617477f, 0.03754212f, -0.02784808f, 0.18507671f, 0.21232557f, 
    0.10852034f, 0.23253731f, -0.03380440f, 0.35355282f, -0.11015727f, -0.17184564f, 0.01025177f, 0.08246016f, 
    -0.22341670f, -0.14220612f, 0.11165974f, -0.22115277f, 0.21222688f, -0.15590370f, -0.03110359f, -0.11787122f, 
    0.01476666f, -0.10813189f, -0.23141949f, -0.00894345f, 0.10941338f, -0.09543587f, 0.16646470f, -0.06493162f, 
    -0.12163935f, -0.08229198f, 0.09928240f, -0.13236918f, -0.11298688f, -0.06556210f, -0.08040772f, -0.06854498f, 
    -0.04671380f, 0.39280453f, 0.17828615f, -0.03853998f, -0.30376595f, -0.00329502f, 0.08257984f, 0.15166333f, 
    0.13136272f, 0.00973502f, 0.05923361f, 0.05606659f, 0.17937139f, 0.01207943f, 0.07716134f, 0.07379142f, 
    -0.01723771f, -0.03024962f, -0.07753661f, 0.16862471f, -0.06827371f, 0.10817729f, 0.03812160f, -0.03416273f, 
    0.02902386f, 0.35047778f, -0.00013527f, -0.01830609f, 0.04739944f, -0.01685508f, 0.04254722f, -0.14683425f, 
    -0.28413242f, 0.02302992f, 0.08370455f, 0.25713301f, -0.06067483f, 0.36619160f, 0.27628183f, 0.06060316f, 
    0.18831754f, 0.17519981f, 0.03473703f, -0.25871173f, -0.01302687f, 0.10882735f, 0.09061784f, 0.08071090f, 
    -0.12479948f, -0.01111890f, 0.20157149f, 0.23474647f, -0.00333846f, 0.12643041f, 0.00531043f, 0.13461806f, 
    0.02605397f, -0.07854263f, 0.16966389f, -0.12468676f, 0.00718175f, -0.07461865f, 0.01932582f, -0.27301273f, 
    -0.20361128f, -0.00028676f, -0.06268992f, -0.05201751f, -0.14657125f, 0.11153028f, -0.34960398f, 0.43600866f, 
    0.17132300f, -0.47556356f, 0.11699765f, -0.08844143f, 0.22783253f, 0.03087600f, -0.58051211f, -0.00466062f, 
    -0.10806063f, 0.23560064f, 0.14480871f, 0.08466084f, -0.09113159f, -0.08656776f, 0.10196801f, 0.21652138f, 
    0.06211769f, -0.21139176f, 0.11815175f, -0.12435494f, 0.09701918f, 0.10938262f, 0.17082453f, 0.30882910f, 
    0.09675632f, -0.14252856f, 0.03150789f, -0.05693590f, -0.11285796f, -0.11638904f, -0.31816563f, -0.13871309f, 
    0.11897925f, -0.03544677f, 0.11000518f, -0.30106232f, 0.31680372f, 0.20374054f, -0.00320519f, -0.02676164f, 
    0.21190123f, -0.09693837f, -0.10590785f, -0.19900706f, -0.25380674f, 0.06416629f, -0.09394746f, 0.00069883f, 
    0.10724597f, 0.05032882f, 0.14848848f, -0.03314520f, 0.08065012f, 0.06926025f, 0.10218967f, 0.44974205f, 
    0.07791880f, 0.03398813f, 0.43804953f, -0.05846667f, 0.30590561f, 0.16156884f, 0.05846516f, -0.12485833f, 
    -0.08716224f, 0.48468813f, -0.12176362f, 0.07315148f, -0.06085701f, -0.05907467f, 0.54556668f, -0.11739985f, 
    -0.09752943f, -0.12575825f, 0.00551435f, -0.19421917f, -0.10680796f, 0.25766629f, 0.15695874f, -0.06772859f, 
    0.11351201f, 0.24830712f, -0.18735492f, -0.10429203f, 0.16648062f, -0.11511166f, -0.18290679f, 0.07977981f, 
    -0.03003143f, 0.20961471f, 0.07210898f, 0.11501554f, 0.03494750f, 0.22868727f, 0.16956893f, 0.25482282f, 
    -0.26788047f, 0.16846812f, 0.00668782f, 0.16745774f, -0.23929726f, -0.04966665f, -0.11261616f, 0.08291841f, 
    0.11476556f, -0.05976942f, 0.09600230f, 0.14373690f, 0.18127488f, -0.04637908f, -0.09759230f, 0.03132950f, 
    0.06639745f, 0.15280698f, -0.09901744f, -0.08503618f, 0.08462074f, -0.05255809f, 0.01680447f, -0.33047512f, 
    -0.29367337f, -0.15594076f, 0.09025855f, 0.08186794f, 0.19432509f, -0.01846327f, 0.10823267f, 0.07696009f, 
    0.24160798f, 0.11257027f, -0.09294525f, -0.04868104f, 0.03549016f, -0.05497224f, 0.07626276f, 0.16794544f, 
    -0.04470930f, 0.26691732f, -0.18116742f, 0.19362150f, -0.03788978f, 0.13366139f, 0.14217499f, -0.15191652f, 
    -0.06558239f, 0.45764163f, -0.03306346f, 0.04179586f, 0.16068375f, -0.04706378f, 0.02894566f, -0.09506849f, 
    0.18927109f, 0.03755606f, 0.25422150f, 0.14960338f, 0.02432082f, 0.45801297f, 0.00459832f, 0.16589284f, 
    0.11811618f, 0.21239895f, -0.00283816f, 0.03849431f, -0.26475275f, -0.16700518f, 0.06839529f, -0.03704855f, 
    -0.07921522f, -0.06474241f, 0.02240716f, 0.00103328f, 0.00792932f, 0.03008671f, -0.20766245f, 0.15569097f, 
    0.11267578f, -0.07818618f, -0.06258101f, -0.15327705f, -0.12850577f, -0.04392869f, 0.04888112f, 0.03405217f, 
    -0.21679346f, 0.30985656f, -0.06449258f, -0.06014166f, -0.26780707f, -0.00958101f, -0.28620860f, 0.38024628f, 
    0.31680825f, -0.14555430f, 0.00932459f, 0.04713533f, 0.53074294f, -0.03743612f, -0.26307341f, 0.09189980f, 
    -0.02844273f, -0.06408444f, 0.01424526f, 0.04843348f, 0.12417161f, 0.25103188f, 0.11653528f, 0.12501478f, 
    -0.08488099f, 0.08127178f, 0.12214591f, 0.04260250f, 0.22104876f, 0.05001223f, 0.24114648f, -0.45396292f, 
    0.18657386f, 0.00998454f, 0.06908150f, 0.15577872f, -0.09737207f, 0.18151318f, -0.26126295f, 0.18085974f, 
    0.06984679f, 0.01635141f, 0.09446464f, -0.08714900f, -0.16509770f, -0.18725097f, -0.38025618f, 0.22994027f, 
    0.08944526f, -0.07499394f, 0.24711823f, -0.66110605f, -0.21591160f, -0.05138247f, 0.07908709f, -0.11647698f, 
    -0.05859154f, 0.04538885f, -0.10323117f, 0.02806127f, 0.04158807f, 0.04699869f, 0.09106916f, 0.04749781f, 
    -0.33783868f, 0.30193555f, -0.13261157f, 0.11285613f, -0.11099321f, 0.34335369f, -0.03506371f, -0.10936184f, 
    0.45807076f, 0.05780105f, 0.16990620f, 0.12702188f, 0.32389933f, -0.04998462f, 0.07068755f, -0.36001995f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13134587f, -0.07467104f, 0.17402007f, -0.06621701f, -0.04165418f, 0.07236069f, -0.14553922f, 0.19721796f, 
    0.03141748f, 0.27809006f, 0.03792929f, 0.01470941f, -0.04354418f, 0.00456693f, 0.15178774f, 0.08554052f, 
    -0.08063048f, 0.00767082f, 0.05746376f, -0.00565703f, 0.02920715f, 0.00862825f, 0.15855339f, 0.00272251f, 
    0.06915247f, 0.10010356f, -0.15809382f, 0.06332848f, 0.10197002f, 0.00732076f, -0.05401767f, 0.21629344f, 
    -0.03095917f, 0.06831549f, -0.00619779f, 0.00126632f, 0.11953699f, -0.06836975f, -0.00555559f, 0.24113649f, 
    -0.08503588f, -0.12324038f, 0.09829284f, -0.10190717f, -0.22760807f, 0.07526864f, -0.10899933f, 0.01607503f, 
    -0.06084845f, 0.15949181f, -0.10521109f, -0.05998907f, -0.20551068f, -0.10990744f, 0.00534815f, 0.23496982f, 
    0.32966274f, -0.04235869f, -0.00383015f, 0.03731743f, 0.09005476f, -0.11465524f, 0.12934776f, 0.08042399f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11035581f, -0.06405368f, -0.41665655f, -0.06743085f, 0.04911825f, 0.16441734f, 0.11818697f, -0.30239064f, 
    -0.27764839f, -0.08568612f, 0.06643505f, 0.14134923f, -0.01806391f, -0.48244309f, 0.10721786f, -0.22205327f, 
    -0.11589910f, -0.15035617f, -0.10041875f, 0.00757549f, 0.11545747f, -0.16019931f, -0.31878975f, 0.13544510f, 
    0.03841263f, -0.38857377f, 0.16729470f, 0.14294457f, 0.01946654f, -0.15606548f, -0.16215822f, -0.02508865f, 
    0.04353127f, -0.08837163f, 0.09497210f, -0.05866243f, 0.14103018f, 0.20190173f, 0.06675565f, -0.53055257f, 
    0.15879634f, 0.01640677f, 0.04525692f, 0.04775503f, 0.07338659f, -0.04854599f, -0.14467423f, 0.05212972f, 
    -0.02394559f, -0.31664726f, 0.36475161f, -0.06419150f, -0.08980101f, 0.22695796f, -0.16935536f, 0.12471289f, 
    0.01128515f, 0.19859342f, 0.21042216f, -0.16689658f, 0.01665339f, 0.04710780f, 0.00499396f, -0.40261704f, 
    -0.00255013f, 0.06878447f, 0.09971115f, -0.22969334f, 0.12329030f, -0.09687825f, 0.05200807f, -0.13319258f, 
    -0.00937098f, 0.06143666f, -0.09186937f, 0.12260825f, -0.09136565f, -0.26998273f, -0.13221630f, 0.05923370f, 
    0.01137341f, 0.20175584f, 0.11281410f, -0.03513546f, -0.07361372f, -0.30363709f, 0.14843588f, -0.09168814f, 
    -0.08993860f, -0.00295312f, -0.18226366f, 0.00487556f, -0.65765887f, -0.17503552f, 0.02495074f, 0.10201377f, 
    0.17807075f, -0.06713530f, 0.10409369f, -0.07653238f, 0.17467229f, -0.02718025f, -0.12859811f, -0.08361305f, 
    0.04514074f, -0.18230027f, -0.07024746f, -0.11155568f, -0.00485745f, 0.03515271f, 0.16921237f, 0.01813812f, 
    -0.16558424f, -0.00386041f, -0.56683809f, -0.03734538f, 0.08492174f, 0.35946232f, 0.25106558f, -0.13225785f, 
    0.04692420f, 0.08996642f, 0.08676068f, 0.25976640f, -0.60439491f, 0.21514088f, 0.29161349f, 0.27139214f, 
    0.09943740f, -0.07643732f, 0.06843290f, -0.04903105f, 0.07099301f, -0.01595078f, 0.12637566f, 0.05103434f, 
    0.12893350f, 0.19158632f, -0.05932724f, -0.25198278f, 0.06587496f, 0.03279738f, 0.20993178f, -0.03215364f, 
    -0.07572401f, -0.34945947f, 0.28567490f, -0.06454375f, -0.08767747f, -0.39465052f, 0.24789310f, 0.27491263f, 
    0.00333791f, -0.06769624f, -0.05901838f, -0.75803751f, 0.19650590f, -0.14104980f, -0.12104278f, -0.31053200f, 
    0.17777565f, 0.04133154f, 0.21601212f, -0.15264755f, -0.03843633f, -0.01124433f, -0.09992120f, 0.08754046f, 
    -0.52737671f, -0.00632926f, -0.32713300f, -0.07313059f, 0.04576793f, -0.07955502f, -0.19885108f, 0.01786458f, 
    -0.25559729f, -0.01197181f, -0.06679153f, 0.05088285f, -0.05523891f, -0.37428305f, 0.35886234f, -0.00151517f, 
    0.22295474f, -0.41476974f, 0.00640465f, 0.13433760f, 0.12892692f, 0.21484303f, -0.24086644f, -0.56238848f, 
    -0.06392808f, -0.01668439f, -0.24090785f, 0.27363053f, 0.16039187f, 0.10433283f, -1.09149837f, -0.01614673f, 
    -0.09992892f, 0.05872909f, -0.06223803f, -0.49697047f, -0.04888415f, 0.09842619f, -0.21191978f, 0.25706434f, 
    0.13314067f, 0.05223962f, 0.26374850f, 0.12443051f, 0.01968176f, 0.10207273f, -0.20054041f, 0.13632718f, 
    -0.05087259f, 0.02007654f, 0.06699520f, 0.16794269f, 0.17995360f, -0.41742545f, -0.75812030f, -0.23396292f, 
    -0.16888870f, -0.21917209f, 0.01177576f, -0.54648870f, 0.00300652f, -0.72933817f, 0.02619353f, 0.09531324f, 
    0.06652395f, -0.16514009f, 0.17019288f, -0.09432134f, 0.06577154f, -0.01969035f, -0.25631294f, -0.11180948f, 
    -0.05427202f, 0.13458519f, -0.39424720f, 0.04344934f, 0.03472629f, 0.06046537f, -0.00048167f, -0.22605923f, 
    -0.60735619f, 0.06368855f, -0.05093100f, -0.18423447f, -0.00357585f, -0.20715965f, -0.43128434f, -0.40461966f, 
    -0.13009988f, -0.10786215f, -0.42123258f, 0.02632887f, -0.02779542f, 0.14801352f, -0.17066930f, 0.12886992f, 
    -0.19792485f, -0.02945528f, -0.10114232f, -0.27507183f, 0.09472638f, 0.03728482f, -0.61894190f, 0.17239837f, 
    -0.47513431f, 0.10345478f, -0.38965791f, -0.04790437f, 0.02308974f, 0.07622052f, -0.04484195f, 0.03850310f, 
    -0.13557880f, -0.11092196f, 0.08944729f, -0.08064490f, 0.07044064f, -0.08114491f, 0.20179245f, -0.01579484f, 
    0.15367264f, 0.21294262f, 0.12340350f, -0.15856306f, -0.16103204f, -0.61728156f, 0.06983094f, 0.09965546f, 
    0.07339723f, -0.13157520f, -0.14974435f, 0.02164454f, 0.07717554f, -0.20163834f, -0.10095713f, 0.05360739f, 
    0.04746498f, -0.15043557f, -0.01922214f, -0.08394095f, 0.02020590f, -0.04371035f, -0.00026092f, 0.20124479f, 
    -0.06938329f, 0.09199956f, 0.00084209f, -0.40496305f, 0.09559906f, 0.17479573f, -0.51511157f, 0.23398092f, 
    -0.06762908f, 0.00693814f, 0.05210115f, 0.00394077f, -0.00464979f, 0.11546972f, 0.06571964f, -0.05239482f, 
    0.14342956f, 0.19446363f, 0.00520944f, 0.05469166f, -0.06438246f, 0.05808279f, -0.06193167f, 0.00100274f, 
    -0.09680421f, 0.16568869f, -0.67916715f, 0.00321694f, -0.00347138f, -0.21743436f, 0.06539841f, -0.26900470f, 
    -0.10895821f, 0.20679577f, -0.11988439f, 0.16431764f, -0.34868518f, -0.05127978f, 0.16947341f, -0.42062533f, 
    0.15249482f, 0.24242298f, -0.22488989f, -0.20658650f, 0.11810436f, -0.08163401f, -0.04198851f, -0.16394149f, 
    0.16476732f, -0.03409370f, -0.14114676f, -0.06990951f, -0.21119057f, -0.00920378f, -0.25623542f, -0.11121941f, 
    -0.09866427f, -0.24973026f, 0.09880589f, -0.07371797f, 0.01034052f, -0.09740876f, -0.27852872f, 0.24822535f, 
    -0.25271016f, 0.16879566f, 0.16303684f, -0.00584763f, 0.08132329f, -0.23211911f, 0.05298077f, 0.06413795f, 
    -0.11038738f, -0.12266778f, 0.07512593f, -0.24980544f, -0.32701179f, -0.43646455f, 0.16918574f, 0.06626852f, 
    -0.03908502f, 0.07098891f, -0.05210871f, 0.19569948f, -0.03997840f, 0.07590295f, 0.23609574f, 0.02304610f, 
    -0.26630291f, -0.51356107f, 0.35052693f, -0.11164336f, -0.29851261f, 0.18529145f, 0.23665443f, -0.39514405f, 
    0.06188862f, -0.07544260f, -0.47267374f, -0.28388184f, 0.12168948f, -0.39381003f, 0.06903914f, -0.03281209f, 
    -0.49960998f, 0.16055645f, -0.26572439f, 0.31231299f, -0.38733613f, -0.18724757f, 0.07544750f, 0.11934918f, 
    -0.80589932f, -0.07366163f, -0.57797003f, -0.11385787f, -0.67272770f, 0.15040056f, 0.01405857f, -0.02794234f, 
    -0.13942069f, 0.12171086f, -0.23393506f, 0.10361194f, -0.08226610f, -0.06469794f, -0.25651142f, -0.13478909f, 
    0.02502505f, -0.47274509f, -0.41525677f, -0.11365192f, 0.18859616f, -0.19598249f, -0.12418870f, 0.06450680f, 
    -0.02489981f, -0.06036606f, -0.17436068f, -0.08756470f, 0.19451582f, 0.18929015f, -0.05551008f, -0.04647927f, 
    -0.20305596f, -0.39285865f, -0.09593388f, 0.04256037f, 0.00419475f, 0.08830932f, 0.01147241f, 0.31548923f, 
    0.21508890f, -0.44019219f, 0.03141079f, 0.04352353f, 0.21057013f, 0.32502514f, -0.47484466f, -0.40181652f, 
    -0.11631186f, 0.13625693f, -0.42315134f, -0.25278285f, 0.28656688f, 0.12535733f, -0.28861478f, -0.08335937f, 
    -0.21181613f, -0.59255666f, -0.37587282f, -0.18366547f, -0.03216176f, -0.27433488f, -0.06593619f, 0.02951421f, 
    -0.21318460f, 0.07304405f, 0.06283638f, -0.04266282f, 0.10100167f, 0.05649246f, -0.01464632f, -0.02504569f, 
    -0.16768624f, -0.29866397f, -0.22838669f, 0.02679686f, 0.02571209f, -0.14836758f, 0.04593266f, -0.42286548f, 
    0.02180792f, 0.07122657f, 0.19399819f, -0.27563971f, 0.22808874f, -0.04721404f, 0.11504643f, -0.04012872f, 
    0.05109995f, 0.05063320f, 0.29017949f, 0.07243271f, 0.03112249f, -0.46470010f, -0.13098714f, -0.19802698f, 
    0.24939501f, -0.03500959f, -0.06065425f, -0.17952423f, 0.11485091f, 0.04554892f, 0.27145362f, -0.31998524f, 
    0.29263157f, -0.28589717f, -0.05077457f, 0.05692187f, -0.38656908f, 0.17031753f, -0.27249596f, 0.17162380f, 
    -0.12649986f, -0.17471074f, -0.20253420f, -0.38155308f, -0.16793697f, -0.07946906f, -0.06597066f, -0.12341006f, 
    -0.64967424f, -0.38891259f, -0.20792152f, -0.15022238f, 0.09757937f, -0.13464789f, -0.04342137f, -0.02073551f, 
    -0.47756568f, 0.01550885f, 0.29438946f, -0.09135333f, -0.54991615f, -0.07353701f, -0.04605471f, 0.00749733f, 
    -0.27080771f, 0.03843197f, -0.18517430f, 0.04514071f, 0.02539092f, -0.38600397f, -0.34454003f, -0.53297102f, 
    0.27480537f, 0.07822949f, 0.19097826f, 0.23095165f, -0.22685930f, -0.28618303f, 0.11972059f, -0.26558068f, 
    -0.08884060f, -0.10811759f, -0.24238801f, -0.35258684f, 0.08946595f, 0.23027889f, -0.42952159f, 0.16615336f, 
    -0.23793456f, -0.18921596f, 0.03482050f, 0.17915396f, -0.09273160f, 0.13403155f, 0.13324828f, -0.16136138f, 
    -0.19223833f, -0.23482305f, 0.04095487f, -0.01911539f, 0.14734878f, -0.11173634f, -0.02681809f, -0.56825513f, 
    -0.05474155f, -0.30270016f, 0.06173477f, -0.08449516f, 0.00447622f, -0.22838159f, -0.09960642f, -0.06053671f, 
    -0.17198005f, 0.04578782f, 0.25040317f, 0.10684039f, -0.42354709f, -0.62922096f, -0.04809080f, 0.10019352f, 
    0.07138634f, 0.01856782f, -0.10153662f, -0.01013214f, 0.08569026f, 0.02297298f, -0.24212994f, 0.01723640f, 
    -0.11317483f, -0.31676525f, -0.63275921f, -0.15861520f, -0.05745687f, -0.08817996f, -0.06545984f, 0.19677164f, 
    0.04499487f, -0.47161943f, -0.36033711f, -0.15742946f, 0.08577120f, 0.03686647f, 0.20157871f, 0.06963721f, 
    -0.05174300f, 0.03280312f, -0.02697996f, 0.25599778f, -0.43463707f, -0.06722235f, -0.76527750f, 0.21107119f, 
    -0.03708873f, 0.23485966f, 0.05372290f, 0.10554590f, 0.13969924f, -0.02903898f, -0.07673378f, -0.32234013f, 
    -0.14112927f, 0.13021749f, -0.31712186f, 0.05560827f, -0.37914962f, 0.37669668f, 0.04243593f, -0.02780369f, 
    -0.02074546f, -0.28618917f, 0.04817893f, 0.02413021f, -0.15578590f, -0.18933748f, -0.37445384f, -0.22318958f, 
    -0.00387684f, 0.07798449f, 0.09505265f, -0.27804190f, 0.19126292f, -0.64572579f, -0.00050415f, -0.03282169f, 
    -0.09808277f, -0.20515220f, 0.39665151f, -0.17338161f, -0.56015658f, -0.06448019f, -0.05161304f, 0.04275197f, 
    0.43214113f, 0.26903230f, -0.04543043f, 0.12864752f, 0.04675369f, -0.15753998f, 0.19047171f, 0.08229034f, 
    -0.64972615f, -0.04124336f, -0.49789357f, 0.13521598f, -0.34226772f, 0.07223599f, 0.05248774f, -0.29794574f, 
    -0.08952457f, -0.08793599f, 0.01478536f, 0.08186022f, -0.18581647f, -0.23211050f, -0.57560217f, -0.05342904f, 
    0.08292926f, -0.32477084f, 0.03780654f, 0.15438746f, -0.03322659f, -0.04097515f, 0.06010569f, -0.17300883f, 
    0.26393551f, -0.46496043f, -0.09595785f, -0.09732646f, -0.33070168f, -0.22036889f, 0.26779950f, 0.46051276f, 
    0.02627062f, 0.30466560f, 0.44137147f, -0.35932750f, -0.44732839f, -0.37305659f, -0.03830261f, 0.00382912f, 
    0.00116578f, -0.01147203f, -0.47797209f, 0.29947019f, -0.39773867f, -0.52987546f, 0.00179592f, 0.04398148f, 
    0.05954422f, -0.10024972f, -0.01253824f, 0.04514563f, 0.11911258f, -0.03731718f, -0.30344215f, 0.05596298f, 
    -0.25600252f, 0.29436386f, -0.01311338f, -0.02838553f, -0.14046665f, -0.27138904f, -0.33996528f, -0.08630481f, 
    -0.62382770f, -0.53228694f, -0.09749480f, 0.09738447f, -0.08562858f, -0.13786680f, -0.10759698f, 0.15026346f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14253232f, 0.03660535f, 0.12374384f, -0.10863259f, -0.13721940f, 0.18492316f, 0.09625029f, -0.04390378f, 
    0.16784203f, 0.01800652f, -0.04207719f, -0.01882462f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
