#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31857911f, -0.98010343f, -0.74041659f, -0.62717396f, -0.30216217f, 0.55652976f, -0.00007238f, 0.45781857f, 
    0.30384499f, 0.33853564f, 0.14683667f, 0.08308689f, -0.29968375f, -0.04019140f, 0.41782391f, -0.19846420f, 
    0.07469098f, 0.18385932f, 0.02367204f, -0.16320227f, -0.31921995f, -0.17850663f, -0.12948146f, 0.03918335f, 
    0.02983515f, -0.74665582f, -0.47940192f, -0.60439903f, 0.21857654f, -0.13766596f, -0.43125990f, 0.18434888f, 
    0.23930861f, 0.52275920f, -0.17249492f, 0.35064220f, -0.00072941f, 0.27715141f, -0.33195943f, -0.16064620f, 
    -0.07536157f, -0.19617441f, -0.30714527f, -0.12879968f, -0.18719144f, -0.39354038f, 0.14429520f, 0.25641403f, 
    -0.31365770f, 0.39185515f, -1.06816709f, -0.57607102f, -0.03603867f, 0.59471774f, 0.32417631f, 0.10845666f, 
    -0.24071249f, -0.72953975f, -0.50536394f, 0.34785065f, -0.40379483f, -0.16356772f, -0.46162659f, -0.22304912f, 
    -0.53101754f, 0.13217086f, -0.03747945f, -0.10912144f, 0.01695762f, -0.13274558f, -0.14801262f, -0.24860343f, 
    -0.27899662f, -0.14974324f, -0.44117779f, 0.39468285f, 0.63693774f, 0.46824771f, 0.05517345f, -0.30734083f, 
    -0.48725358f, -0.41224694f, 0.01154306f, 0.33159778f, 0.17917664f, 0.34431365f, -0.10810479f, -0.29859120f, 
    -0.19674894f, 0.23315294f, -0.11586956f, 0.21282820f, -0.11889745f, 0.06871732f, -0.15738343f, -0.01160823f, 
    0.04880740f, -0.09013305f, 0.15304992f, -0.06395703f, 0.03348611f, 0.31586218f, 0.52095371f, 0.22191061f, 
    0.77444929f, -0.73925298f, -0.68612510f, -0.39692628f, 0.03250013f, -0.13101998f, -0.13200629f, -0.49183410f, 
    -0.02974017f, 0.16796643f, 0.52361733f, 0.01182927f, -0.16287872f, -0.05802710f, 0.08251336f, -0.01496651f, 
    -0.23128316f, 0.09876890f, -0.20388527f, 0.16040903f, -0.30856213f, 0.25265300f, 0.27628964f, -0.08080620f, 
    0.26720473f, 0.12391012f, -0.23800412f, 0.36573571f, 0.32208264f, 0.07929736f, 0.43332466f, -0.24005373f, 
    0.27561018f, -0.06824035f, -0.44203651f, 0.04860750f, 0.13569297f, 0.18136643f, -0.14378794f, -0.13789918f, 
    -0.18595333f, -0.35339198f, -0.16255337f, 0.19059564f, -0.23303010f, -0.12175613f, -0.59885287f, -0.63377696f, 
    0.08143600f, 0.40737495f, 0.58895910f, 0.33036882f, 0.30391672f, 0.72117144f, -0.65828550f, -0.40243155f, 
    0.11359061f, 0.23304282f, 0.07677671f, -0.24282533f, -0.19033988f, -0.22019473f, 0.17041443f, -0.17492621f, 
    0.08983228f, 0.16535708f, 0.31901264f, -0.27486202f, -0.09084374f, -0.00753044f, 0.24450178f, -0.11271756f, 
    0.25490758f, 0.28783798f, 0.35040355f, -0.39099631f, 0.24556161f, -0.18515851f, -0.20738879f, 0.55320656f, 
    -0.57939827f, -0.18533543f, 0.24615692f, 0.30212083f, -0.30331498f, -0.04332004f, 0.07643222f, 0.04548576f, 
    -0.32198772f, -0.41822320f, 0.43938386f, 0.16768788f, 0.15242210f, -0.07796353f, -0.22296102f, 0.18433151f, 
    -0.00461167f, 0.33697304f, 0.52507269f, -0.16683251f, -0.49892271f, -0.54034048f, -0.39824760f, -0.44357392f, 
    -0.29027736f, -0.58630580f, 0.31123784f, -0.39250168f, -0.01854284f, 0.28530467f, -0.12124386f, -0.04288270f, 
    0.00658960f, 0.31651542f, 0.13207223f, -0.33593920f, 0.04268660f, -0.20365602f, -0.08698050f, 0.38713664f, 
    0.32071802f, 0.75250393f, -0.50613809f, -0.00473752f, -0.09325749f, -0.76541108f, 0.09215354f, 0.11985746f, 
    -0.60078418f, -0.90709102f, -0.84712386f, 0.33764166f, -0.22844049f, 0.07791360f, -0.40208656f, -0.47349650f, 
    0.05063934f, -0.18793605f, -0.06641833f, -0.10359944f, -0.03758812f, -0.46845913f, 0.28451669f, -0.01467089f, 
    -0.08862161f, -0.25554201f, -0.28002340f, 0.71657169f, 0.30525139f, -1.17184699f, -0.96927613f, 0.03711394f, 
    0.11845335f, 0.42627275f, 0.35315049f, 0.02353919f, 0.03446517f, 0.03569202f, 0.09093938f, -0.14182748f, 
    0.15339746f, 0.14882445f, -0.06912316f, -0.20707811f, -0.23467542f, -0.09427026f, 0.07656115f, 0.03887809f, 
    -0.04424003f, -0.26815867f, 0.15687481f, -0.63631940f, -0.68682915f, -0.60834247f, 0.07627883f, -0.44880852f, 
    0.38888001f, 0.27369913f, -0.39946908f, -0.40877819f, 0.04208102f, -0.17541312f, -0.34993130f, 0.31444424f, 
    0.11586178f, -0.18505853f, 0.12568013f, 0.18418235f, -0.06273682f, -0.20081756f, -0.10522001f, -0.11633477f, 
    0.25513467f, 0.27735832f, 0.19743545f, -0.00856318f, -0.19135128f, -0.33499607f, 0.08279887f, 0.61017478f, 
    0.01531466f, 0.48778209f, -0.47276628f, -0.01831776f, -0.34317753f, 0.13661440f, 0.07853401f, -0.29232517f, 
    -0.12745085f, 0.02251394f, 0.42101419f, -0.19556355f, 0.09797747f, 0.02324609f, -0.15102957f, 0.34629682f, 
    -0.17884003f, -0.21333686f, 0.08770569f, 0.40778306f, 0.10649517f, 0.82168627f, -0.53379172f, 0.12882669f, 
    -0.10572392f, 0.06856339f, 0.18647395f, 0.21035682f, -0.03731471f, -0.06947879f, 0.25276515f, -0.17252913f, 
    0.40530390f, -0.34464303f, -0.48113841f, 0.48755202f, -0.15689360f, -0.18826756f, -0.21319056f, 0.27059177f, 
    -0.06554064f, 0.30709276f, 0.00890240f, -0.06200710f, -0.26393363f, 0.06208675f, 0.73214012f, 0.35459220f, 
    0.08732948f, 0.16476876f, 0.06383801f, -0.12147275f, 0.40385333f, -0.23894536f, -0.01479203f, -0.39123592f, 
    -0.32890627f, 0.05123498f, -0.02689944f, -0.15144502f, 0.17097758f, -0.08555421f, 0.26968917f, -0.03588173f, 
    0.02171365f, -0.24538083f, 0.12064804f, 0.06137989f, 0.23250233f, -0.09248754f, -0.14592236f, -0.53717989f, 
    -0.34638536f, 0.10494847f, 0.39126894f, -0.18089943f, 0.45217240f, -0.27515239f, 0.09566323f, 0.26854780f, 
    0.38316733f, -0.00181566f, 0.35144848f, -0.18754409f, -0.33622813f, 0.06653249f, -0.57386059f, 0.14790227f, 
    -0.07294195f, 0.00709224f, -0.38326707f, 0.22549447f, 0.45632848f, 0.32106608f, 0.11518141f, 0.20647737f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09441522f, 0.21957232f, 0.10545904f, 0.06483705f, -0.01353873f, -0.08012896f, 0.13959922f, 0.25556919f, 
    0.21665090f, 0.12427825f, 0.26919186f, -0.07313649f, 0.28160891f, 0.44069007f, 0.11039448f, 0.11698306f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43776226f, -0.19851035f, 0.05563140f, -0.10192215f, 0.00761152f, 0.05133363f, 0.09253747f, -0.01844033f, 
    0.07598995f, -0.03447686f, 0.03907925f, 0.11865871f, -0.10260156f, 0.00599150f, -0.27594346f, -0.10809755f, 
    0.17219345f, -0.02598010f, 0.00100353f, -0.07184397f, 0.03193476f, 0.13273004f, 0.00168437f, 0.12797025f, 
    0.06043128f, 0.07353789f, 0.18153369f, 0.02125385f, 0.08706760f, -0.05209441f, -0.09512982f, 0.13847190f, 
    0.12023401f, -0.07759850f, -0.08420102f, 0.06627218f, -0.24340989f, 0.03955894f, 0.38288280f, 0.05063967f, 
    -0.11626235f, -0.05870929f, -0.14024131f, 0.07651748f, 0.10797545f, 0.00654523f, -0.17358792f, 0.01336495f, 
    0.15375282f, -0.05394617f, -0.03947167f, -0.00254917f, 0.13593526f, -0.07184694f, -0.20017624f, 0.09860963f, 
    0.00178920f, -0.07623886f, 0.06613407f, -0.14445102f, 0.14046983f, 0.00578301f, 0.05297430f, 0.16310218f, 
    -0.03773788f, -0.04553960f, -0.01125863f, -0.22802284f, 0.05121700f, 0.02784019f, -0.20507064f, -0.06664316f, 
    0.05861830f, 0.25930277f, -0.31795824f, -0.03552826f, 0.09315705f, -0.01484839f, 0.13784212f, 0.10107522f, 
    0.15113011f, 0.15929875f, 0.02152729f, 0.07505985f, 0.03369136f, 0.12673455f, -0.13582750f, 0.01305853f, 
    0.01953765f, -0.20950657f, 0.00622110f, 0.10792295f, 0.06408879f, 0.14291847f, -0.13950872f, 0.08191605f, 
    -0.16366811f, 0.00633352f, 0.12130237f, 0.03705078f, 0.01052643f, 0.08144114f, 0.04088284f, 0.15745756f, 
    -0.02040307f, 0.03161455f, 0.09267655f, -0.02842794f, -0.16164567f, 0.10380471f, 0.07405651f, -0.11577430f, 
    -0.00319802f, 0.01773367f, 0.16079137f, -0.09941030f, 0.06456143f, -0.00561551f, 0.02595735f, 0.00500819f, 
    -0.29196054f, 0.38861388f, -0.11645789f, 0.17371257f, 0.06762239f, 0.07978666f, 0.05754626f, -0.04071463f, 
    0.04697656f, -0.02598720f, -0.04987509f, 0.02042224f, 0.01391598f, -0.12575445f, 0.18816660f, 0.04255158f, 
    0.11562610f, 0.15099202f, 0.03102099f, 0.04482313f, 0.02676849f, -0.09232318f, -0.03592613f, -0.11471210f, 
    0.16184607f, -0.05037389f, -0.16791026f, -0.32225776f, -0.11688137f, -0.02831134f, 0.03546265f, 0.10433488f, 
    0.11623423f, 0.01888624f, 0.06604701f, 0.18584368f, 0.23624913f, -0.04426862f, 0.24467663f, 0.00480788f, 
    -0.10525814f, 0.03701372f, -0.33828938f, -0.07599764f, 0.08897057f, 0.13247503f, -0.09056084f, -0.00092615f, 
    0.09390465f, -0.00377422f, -0.01414936f, 0.02237698f, -0.25551230f, -0.23021859f, -0.11111404f, -0.04947903f, 
    -0.06124429f, -0.08882188f, 0.00131207f, -0.00103786f, 0.09391114f, -0.14588812f, -0.02423842f, -0.14486152f, 
    -0.04205064f, 0.08885849f, -0.14246328f, 0.14003958f, 0.05071960f, -0.00323165f, 0.03348188f, 0.17300715f, 
    -0.01854573f, 0.04420571f, -0.03179001f, -0.00644197f, -0.05723718f, 0.05174645f, -0.05780692f, -0.03705406f, 
    -0.06074984f, -0.01334124f, 0.04687673f, 0.04437919f, -0.00108446f, 0.02618082f, -0.02309679f, -0.04444090f, 
    0.04249928f, -0.02424285f, 0.05852415f, -0.01083016f, -0.00396669f, -0.08136924f, 0.01122105f, -0.00789470f, 
    0.01833117f, -0.06913716f, -0.05288281f, -0.03994955f, 0.04957825f, -0.00116626f, -0.05706676f, 0.05658732f, 
    0.01909070f, -0.07616735f, -0.03258076f, 0.00180152f, -0.04728574f, -0.08366361f, 0.02498952f, 0.00166709f, 
    0.00204194f, -0.00956335f, -0.02473281f, 0.06002354f, 0.01962028f, 0.03008379f, 0.00338616f, 0.04619149f, 
    -0.03748984f, -0.01879410f, -0.02134638f, -0.04684934f, 0.01657505f, -0.01776653f, 0.02047231f, -0.07735117f, 
    0.01148559f, -0.06634565f, -0.01081786f, 0.00408007f, 0.04776949f, 0.00165525f, -0.07898942f, 0.05525810f, 
    -0.05567233f, -0.07198839f, 0.00374973f, -0.06682607f, 0.02956282f, -0.03505280f, -0.08076335f, -0.00895465f, 
    -0.05815911f, 0.05648934f, -0.00990926f, 0.05829470f, 0.03044262f, 0.06348468f, 0.03021969f, -0.08181567f, 
    -0.01201523f, -0.00869374f, -0.03300120f, -0.02446008f, -0.05297211f, 0.04755397f, 0.01084473f, 0.05798416f, 
    -0.06835158f, -0.02468896f, -0.02455710f, 0.01469115f, -0.06750626f, -0.05847484f, 0.02086542f, -0.00202364f, 
    -0.05030816f, 0.04612880f, 0.04105376f, -0.07886346f, 0.03581347f, -0.01296520f, -0.00923063f, -0.05631246f, 
    -0.02392966f, -0.04955616f, -0.04417745f, -0.07084747f, 0.04679493f, 0.03929299f, 0.03772815f, 0.05910360f, 
    -0.01200121f, 0.00796076f, 0.05167553f, 0.00041024f, -0.05043624f, -0.05513563f, 0.01630425f, -0.02460121f, 
    -0.06621645f, -0.08062151f, 0.04225044f, -0.05210744f, 0.03623838f, -0.07648763f, -0.01704825f, -0.07750992f, 
    0.01171050f, 0.01942734f, -0.05693274f, 0.01208972f, 0.01445167f, 0.00026145f, -0.05024806f, 0.04809104f, 
    0.01820853f, 0.03821300f, 0.05999305f, -0.05051986f, 0.01228495f, 0.04592736f, 0.04796043f, -0.05854083f, 
    0.00573332f, 0.02257811f, -0.05589806f, -0.08291315f, 0.02360479f, -0.00842668f, 0.00636801f, -0.03517106f, 
    0.04243918f, -0.07558891f, -0.05794498f, 0.01368097f, -0.05219077f, -0.00866798f, 0.01999552f, 0.04791139f, 
    0.04123286f, -0.06519066f, 0.00323512f, -0.00087972f, 0.00595430f, -0.03054550f, 0.03438395f, -0.00413877f, 
    0.03964364f, 0.00427659f, 0.05750154f, -0.05027007f, 0.03237975f, -0.04506695f, -0.05212986f, -0.05201064f, 
    0.04330390f, 0.02660552f, 0.00027000f, 0.00674316f, -0.08431301f, 0.05236785f, 0.00556517f, -0.08307604f, 
    0.06616830f, -0.03551717f, 0.02207446f, -0.04414916f, -0.05973249f, -0.07973375f, -0.04201752f, -0.06829817f, 
    0.00686131f, -0.05369708f, 0.02953850f, 0.04401029f, -0.00132392f, -0.00994325f, -0.06870467f, 0.03543843f, 
    0.00128432f, 0.04349105f, -0.02943097f, 0.05844637f, 0.01239995f, -0.07684485f, 0.04270583f, -0.05253286f, 
    0.05078488f, -0.00645174f, -0.01892049f, 0.02639480f, 0.00872660f, -0.04177828f, -0.07049790f, -0.02530428f, 
    0.05624623f, -0.06935268f, 0.01588645f, 0.06089043f, -0.07114325f, -0.06008014f, -0.00336729f, -0.01565261f, 
    -0.04530887f, -0.02634900f, -0.03284600f, -0.05439434f, -0.06448249f, -0.06445900f, 0.03434764f, -0.03061442f, 
    -0.04485371f, 0.00386765f, -0.00817122f, 0.03932168f, -0.04767989f, -0.01928897f, 0.01782512f, -0.04336882f, 
    0.02493313f, -0.05478886f, -0.04925044f, 0.04541235f, -0.05776288f, 0.03758602f, 0.04236161f, -0.04913057f, 
    0.06308098f, -0.01726016f, -0.01975241f, 0.01530060f, -0.02608144f, -0.04687460f, -0.06766224f, 0.00820335f, 
    0.05345340f, -0.01034430f, -0.02964651f, -0.06959023f, -0.00435637f, -0.04128671f, 0.01821677f, -0.02758622f, 
    0.06093539f, -0.07035486f, -0.05649778f, 0.04293057f, 0.00534176f, 0.04447912f, -0.04796226f, -0.04959273f, 
    0.04145419f, -0.01707997f, 0.05294443f, 0.02861719f, 0.03683971f, 0.01610999f, -0.00797063f, 0.01513343f, 
    0.03788555f, -0.03644611f, -0.03279452f, 0.06745799f, 0.06429487f, 0.01931120f, -0.00177782f, -0.00191611f, 
    0.01019026f, -0.00080844f, -0.05749699f, -0.07209706f, 0.02413003f, -0.04466921f, -0.01432449f, -0.03393753f, 
    0.01124885f, -0.06417995f, -0.03684656f, 0.04816884f, 0.03495790f, 0.03569115f, -0.02076466f, -0.02261170f, 
    0.01362329f, -0.02746689f, 0.04688986f, 0.03791584f, 0.06377970f, -0.06967332f, 0.01046694f, -0.05768914f, 
    0.03997539f, 0.03291508f, -0.06087804f, -0.05608005f, 0.05104125f, -0.03746840f, 0.04256603f, 0.03333727f, 
    -0.00489363f, -0.00430536f, 0.00714577f, -0.06680065f, -0.06080378f, 0.01103106f, 0.05087851f, 0.00869795f, 
    -0.06611421f, 0.03170989f, -0.06497935f, 0.01836314f, 0.02006326f, -0.02738478f, -0.02517724f, -0.01527331f, 
    -0.01165264f, 0.01090314f, -0.01866048f, -0.04180587f, -0.01186703f, -0.07528718f, 0.05066636f, -0.00558617f, 
    -0.01382479f, 0.02916812f, 0.02025631f, -0.03329947f, -0.07361265f, -0.06975447f, -0.01302783f, -0.07180616f, 
    0.00961816f, 0.00144600f, 0.05225131f, 0.03582802f, 0.01381123f, -0.00717040f, 0.01588084f, 0.01652993f, 
    -0.06992935f, -0.06149397f, -0.06159919f, 0.00004997f, -0.06130880f, -0.05663116f, 0.00279419f, -0.05057410f, 
    0.00242448f, -0.04768371f, 0.01111262f, 0.02182522f, -0.03879393f, -0.02130827f, 0.03571995f, -0.06883186f, 
    0.00003700f, -0.03357632f, -0.00694271f, -0.03864551f, -0.07782134f, 0.00959653f, 0.00859977f, 0.01905511f, 
    -0.04810561f, -0.05356089f, -0.05478363f, -0.05852339f, -0.00809216f, -0.06057191f, -0.01232953f, 0.06057726f, 
    0.02661675f, -0.07308003f, 0.05924577f, 0.02816317f, 0.05482439f, 0.06296283f, -0.01792093f, -0.00944743f, 
    0.04504288f, -0.01354397f, -0.06256907f, -0.04361569f, 0.03819287f, 0.01158927f, -0.07391996f, 0.05287112f, 
    -0.02331510f, 0.00792540f, 0.02369595f, -0.06330620f, -0.01565118f, -0.02227017f, -0.03284686f, -0.02477970f, 
    0.06772599f, -0.01493534f, -0.06934900f, 0.03865142f, 0.03455982f, -0.01990247f, 0.04717890f, 0.05289425f, 
    -0.07387865f, -0.00979593f, 0.01163415f, -0.05257880f, 0.04912321f, 0.03294918f, -0.04798592f, -0.04337879f, 
    -0.01940903f, -0.06146735f, -0.03900247f, -0.00826952f, 0.04197595f, -0.04071009f, -0.01031727f, -0.05817916f, 
    -0.03311954f, -0.04465784f, -0.00894582f, 0.04799766f, -0.05480045f, -0.05267103f, 0.01672722f, -0.03015058f, 
    -0.03113262f, 0.03820225f, 0.04024808f, -0.01443965f, -0.01995974f, -0.03381901f, -0.01464314f, -0.04167547f, 
    -0.00285092f, 0.03371469f, 0.02244057f, -0.08028777f, -0.02249872f, 0.07088172f, 0.03557773f, -0.06436662f, 
    0.00370648f, -0.05445853f, 0.01030638f, 0.00887309f, -0.05141485f, -0.02486080f, 0.05613712f, 0.01488160f, 
    0.02201883f, 0.05249799f, -0.03436676f, 0.04798210f, -0.05908603f, -0.05029441f, 0.00020196f, 0.00205048f, 
    0.00244713f, -0.00726490f, 0.06221538f, -0.07186164f, -0.06107499f, 0.05243837f, 0.06790918f, -0.01149856f, 
    -0.01463320f, 0.00729652f, -0.04352373f, -0.05300511f, -0.02856660f, 0.07169857f, -0.03247514f, -0.05270032f, 
    -0.03188649f, 0.05899387f, -0.04251172f, 0.05409264f, -0.05217198f, -0.00306337f, -0.05833319f, -0.00353958f, 
    0.01745567f, -0.04277914f, 0.01891234f, -0.06631377f, -0.02007817f, 0.01465577f, -0.03185437f, -0.00633042f, 
    -0.03155096f, 0.00542375f, -0.00897894f, 0.03981581f, -0.06085974f, -0.00506657f, -0.02999010f, -0.05492621f, 
    -0.03858133f, 0.01532206f, 0.04508319f, 0.01837963f, -0.06682673f, -0.06502485f, 0.05162005f, -0.07136279f, 
    -0.04107682f, 0.00929043f, -0.05214849f, 0.03852120f, 0.01700961f, -0.00632264f, -0.03948376f, -0.01639350f, 
    -0.00155099f, -0.03327857f, -0.00902084f, 0.00743243f, 0.03846643f, -0.03546606f, 0.06608194f, -0.04693634f, 
    -0.01648499f, -0.06629163f, -0.04213048f, 0.00224955f, -0.05718782f, 0.03621442f, 0.02579505f, -0.07700814f, 
    0.04188279f, -0.05726167f, -0.07353768f, -0.02587219f, -0.00308757f, -0.04968584f, -0.04757041f, -0.04834140f, 
    -0.06448811f, 0.03990626f, -0.07492469f, -0.01255633f, 0.06372561f, 0.05545320f, -0.07549582f, -0.03064393f, 
    0.04753638f, -0.06336398f, 0.03944666f, 0.04577692f, -0.04033065f, 0.03168000f, -0.03857328f, -0.02350628f, 
    -0.02288962f, -0.04561595f, -0.09269392f, 0.03314453f, 0.09131944f, 0.05377154f, 0.02300665f, 0.00022266f, 
    -0.10081275f, -0.05188258f, -0.02151359f, 0.08308864f, -0.11428860f, 0.00156702f, -0.09923743f, -0.06522373f, 
    0.13072011f, 0.11973716f, -0.05499822f, -0.04208512f, 0.06134084f, 0.16156676f, 0.12034992f, -0.03602151f, 
    -0.11507288f, 0.03285722f, 0.00555412f, 0.04317433f, 0.10925933f, 0.01486706f, 0.05282496f, 0.00880777f, 
    0.07052083f, -0.00827532f, -0.02559518f, 0.01241383f, -0.04896706f, 0.25582561f, 0.46219891f, -0.24288839f, 
    -0.04382403f, -0.10811310f, -0.23079616f, 0.03415081f, -0.03480431f, 0.05121680f, -0.27729461f, -0.08780075f, 
    0.47154969f, -0.28071827f, 0.03049830f, -0.08836274f, 0.11459208f, -0.10982262f, -0.10669688f, 0.01627559f, 
    -0.07082520f, 0.03987266f, -0.02225558f, -0.04278969f, 0.11145990f, -0.02658289f, 0.02525428f, -0.03920627f, 
    -0.00394906f, -0.00065489f, -0.05469372f, -0.13374345f, -0.09160332f, 0.08680675f, -0.23682985f, -0.02200268f, 
    -0.19716801f, 0.42564297f, -0.40738881f, -0.11819105f, 0.09196685f, 0.06000001f, 0.01741340f, -0.01401265f, 
    0.20013840f, 0.06128967f, 0.23661728f, 0.13730282f, 0.02041980f, -0.02756906f, 0.22113287f, -0.14374682f, 
    0.04263313f, -0.02814812f, -0.10314464f, -0.00430261f, 0.00073038f, 0.17890105f, -0.05587283f, 0.16127765f, 
    0.02816895f, -0.16666807f, 0.20598745f, -0.04184954f, -0.02635380f, -0.03164414f, 0.03063660f, 0.06878296f, 
    -0.03526765f, -0.04705640f, 0.05236000f, 0.03340506f, -0.31238827f, 0.00619209f, 0.02459758f, 0.19320393f, 
    0.03066368f, 0.12805711f, -0.01490944f, -0.20409572f, -0.01731215f, 0.01048163f, -0.08602374f, 0.05974889f, 
    0.02803155f, 0.10807137f, 0.04379508f, 0.22674201f, 0.14509451f, 0.00775070f, 0.00001284f, -0.00577507f, 
    -0.00979296f, 0.11507194f, -0.01790179f, -0.03198277f, -0.09218143f, -0.00778108f, 0.12557331f, 0.10425976f, 
    0.04925994f, 0.00829558f, 0.00158886f, 0.08067303f, 0.00282648f, 0.06759559f, -0.01356043f, -0.03905979f, 
    -0.09661869f, 0.28894514f, -0.09665935f, -0.11277747f, -0.02605503f, -0.15251875f, 0.02286610f, 0.02682364f, 
    0.09973081f, 0.02904178f, 0.10786425f, 0.21722896f, 0.12359277f, 0.29765138f, 0.12304211f, 0.16049977f, 
    -0.03046747f, 0.07266999f, -0.26427719f, -0.06890952f, 0.15986374f, 0.09063905f, 0.00459355f, 0.08102549f, 
    -0.20781253f, 0.09704473f, -0.03096968f, 0.05459609f, -0.06985679f, -0.15600860f, -0.13154610f, -0.13560469f, 
    -0.01907200f, -0.00485644f, -0.16502871f, -0.11818090f, -0.09193509f, -0.02478579f, -0.25284621f, 0.00625821f, 
    -0.03927436f, -0.13448338f, -0.04778888f, 0.06493407f, 0.06694005f, 0.00010132f, 0.08883818f, 0.18519379f, 
    -0.02248937f, -0.05580900f, 0.03786205f, 0.01128584f, 0.02329175f, -0.02598383f, 0.03045014f, 0.04850224f, 
    -0.06838260f, 0.05036445f, -0.03103976f, 0.03391818f, 0.06498316f, -0.07127202f, -0.01510666f, 0.03752296f, 
    0.00700305f, 0.05776642f, 0.00278572f, 0.00616876f, 0.05141507f, -0.01858691f, 0.05378631f, -0.00914123f, 
    0.02781791f, -0.06457298f, -0.06675261f, 0.01554690f, -0.01870205f, 0.03374119f, 0.05608065f, -0.00873972f, 
    0.06152019f, -0.03052477f, 0.05676062f, -0.01441548f, -0.00976923f, 0.05093200f, -0.01909578f, 0.06137655f, 
    0.04398438f, -0.01043015f, -0.05535104f, -0.03831247f, -0.03593487f, -0.00483107f, -0.04752862f, -0.06020195f, 
    0.03407809f, -0.01602601f, 0.05330417f, -0.06448675f, 0.04133329f, -0.07993077f, 0.00365388f, 0.02031598f, 
    -0.05911762f, -0.07082020f, 0.00212069f, -0.06706785f, -0.03710363f, -0.02399209f, 0.04675803f, 0.05891040f, 
    0.00472790f, 0.03885812f, -0.00446993f, 0.00242001f, -0.03119221f, 0.04534099f, -0.01003490f, -0.05948722f, 
    -0.06733490f, -0.06895732f, -0.00225286f, -0.01580299f, -0.02353508f, -0.06987166f, 0.03901046f, -0.00067202f, 
    0.00958217f, -0.04793910f, -0.03252666f, -0.05635625f, 0.05286505f, -0.05528929f, 0.04927592f, -0.07550360f, 
    -0.01621331f, -0.03202510f, 0.02373355f, -0.07106238f, 0.03203848f, -0.06250218f, -0.03597275f, -0.06526046f, 
    -0.01432734f, -0.01728215f, -0.04111281f, -0.02680997f, -0.02461403f, 0.04279970f, -0.06657929f, -0.03581211f, 
    -0.05387300f, -0.02033644f, -0.02647488f, -0.01587619f, 0.00573820f, -0.06181656f, -0.03874960f, -0.00749797f, 
    -0.06585384f, -0.02917722f, 0.00331789f, -0.03336404f, -0.03601267f, 0.05988708f, -0.07654398f, 0.04803873f, 
    0.03082530f, -0.05437054f, -0.07743046f, -0.07360084f, 0.01289434f, -0.03215807f, 0.03481777f, 0.04557551f, 
    0.06360904f, -0.00371887f, 0.01798407f, -0.05136922f, 0.01031217f, -0.02131372f, 0.04969512f, 0.03119732f, 
    -0.07101496f, -0.06962896f, 0.01562184f, 0.03285694f, -0.05601289f, -0.05406279f, 0.06220673f, -0.06878641f, 
    -0.04415759f, -0.06093845f, -0.07512940f, 0.03119464f, 0.02897334f, -0.07485407f, -0.04181868f, 0.04117993f, 
    0.00721569f, 0.02959966f, 0.00717089f, 0.04772512f, -0.05905293f, -0.06442104f, 0.04577454f, 0.06161926f, 
    -0.07186296f, -0.07359250f, 0.00481192f, 0.00312159f, 0.00856256f, -0.03290699f, -0.04126386f, 0.03288250f, 
    -0.01771378f, -0.02716014f, 0.01915898f, -0.03838501f, 0.00190476f, 0.03146288f, -0.01776697f, -0.05303900f, 
    0.00251057f, -0.03186734f, -0.03345336f, -0.00918544f, 0.03321302f, -0.06784331f, 0.01582866f, 0.02160691f, 
    -0.01726426f, -0.03020269f, -0.07616952f, -0.03859710f, 0.03153106f, -0.07185619f, 0.04946658f, -0.00167346f, 
    -0.41066107f, 0.23521799f, -0.08158787f, 0.12704088f, -0.03927077f, -0.06160722f, -0.10448413f, 0.04213571f, 
    -0.05726572f, 0.10631374f, 0.07010275f, -0.11600704f, 0.02712685f, -0.07358485f, 0.19859551f, 0.10422968f, 
    0.00588637f, -0.01852010f, 0.06178726f, 0.02497440f, -0.02589072f, -0.02880436f, 0.19577320f, 0.04161219f, 
    -0.12694636f, -0.05874186f, -0.23668225f, 0.08633065f, 0.07257533f, 0.07495970f, 0.13821384f, -0.10379771f, 
    0.04205072f, 0.04669919f, 0.13318521f, 0.00625967f, 0.22614358f, 0.01687244f, -0.14586668f, 0.06762888f, 
    0.00889628f, -0.09014297f, 0.01257787f, -0.02349393f, -0.12278572f, 0.01155005f, -0.00499101f, -0.16555794f, 
    0.26433927f, 0.14779767f, 0.00143039f, -0.02176666f, 0.06924769f, 0.19001399f, 0.03918685f, 0.08463829f, 
    -0.03650252f, -0.01886923f, 0.00034875f, -0.00349948f, -0.01155563f, 0.08013798f, -0.05063536f, -0.10478602f, 
    -0.00601201f, -0.04815987f, -0.01694483f, 0.10499252f, -0.01649886f, 0.18701817f, 0.26296923f, 0.02723854f, 
    -0.25947657f, -0.21961756f, 0.43841290f, 0.08456896f, 0.02136097f, 0.07270205f, -0.08463583f, -0.03624466f, 
    0.02364083f, -0.06318712f, 0.12599517f, 0.01829400f, -0.00360484f, -0.02037194f, 0.15917441f, 0.07966191f, 
    0.04047273f, 0.14277489f, 0.01463376f, -0.10210416f, 0.01455018f, -0.05591347f, 0.01845122f, -0.08623579f, 
    0.28435576f, -0.03519083f, 0.10621123f, -0.01463981f, 0.08995601f, -0.07643338f, 0.10842594f, -0.02572051f, 
    -0.05592069f, 0.05480697f, -0.08251669f, -0.01588319f, 0.04136910f, -0.24298488f, -0.07161766f, 0.20381980f, 
    -0.02961298f, 0.00411326f, -0.22139502f, 0.13414243f, 0.00795679f, 0.05345616f, 0.08289692f, 0.01304906f, 
    0.38106728f, -0.46859804f, 0.35400960f, -0.29995406f, -0.02195280f, -0.01606999f, 0.02087284f, 0.13079076f, 
    -0.03060760f, 0.04239972f, 0.06073747f, 0.00894181f, 0.11785797f, 0.30092701f, -0.01307424f, 0.05679254f, 
    -0.16462742f, -0.18337163f, 0.18145476f, 0.01371003f, -0.12732089f, -0.05145575f, 0.02864025f, -0.00089709f, 
    -0.16607675f, 0.13193701f, 0.10618731f, 0.22451308f, 0.15948416f, 0.02230306f, -0.00860651f, 0.08251581f, 
    -0.01704893f, 0.05306787f, -0.00872912f, -0.02870258f, -0.03446434f, 0.30690926f, -0.11919454f, 0.26691371f, 
    -0.04071107f, 0.02747982f, 0.11691041f, 0.09366222f, -0.17264818f, -0.06452916f, 0.00804325f, 0.11658617f, 
    0.11797136f, -0.01706600f, -0.02842275f, -0.03436008f, 0.06657696f, 0.04654010f, 0.01244843f, -0.11070117f, 
    -0.11771507f, 0.00508487f, -0.02405903f, -0.01181502f, -0.12098646f, 0.15892828f, -0.10551344f, 0.13022768f, 
    -0.04179181f, -0.01391368f, 0.18794769f, -0.00475247f, -0.08445226f, -0.00512431f, -0.12204590f, -0.12389051f, 
    -0.15432280f, 0.08447246f, 0.13974637f, -0.03782148f, -0.18289778f, 0.03209113f, 0.00222717f, -0.12396108f, 
    0.07693064f, 0.12273231f, 0.09003802f, 0.00356204f, -0.12330888f, -0.09745469f, 0.09941790f, 0.11592757f, 
    -0.11419275f, 0.05522494f, 0.01736006f, 0.00950005f, 0.12577501f, -0.01893341f, 0.09580220f, 0.07682597f, 
    -0.09111313f, -0.27184477f, 0.12379225f, -0.00047117f, 0.03789467f, -0.09015156f, -0.01818334f, -0.02921927f, 
    0.05982722f, 0.06574599f, 0.09385067f, -0.07387263f, 0.47514364f, 0.06314667f, -0.09036931f, 0.06850592f, 
    -0.09309766f, -0.04596386f, 0.07554021f, -0.02270278f, 0.00611309f, -0.08156388f, -0.00573843f, -0.15374532f, 
    0.13356505f, 0.05369465f, -0.39129436f, 0.07545294f, 0.13575892f, 0.07463086f, 0.08126940f, 0.26098022f, 
    -0.08166256f, -0.07619770f, 0.00690456f, 0.01021873f, 0.12511763f, 0.07022704f, -0.00879742f, 0.06912289f, 
    -0.04050963f, -0.06466641f, -0.15427800f, 0.01964391f, 0.03240621f, 0.04581287f, 0.19000609f, -0.08113762f, 
    -0.17072488f, -0.25009409f, 0.18651377f, 0.00617941f, 0.13231291f, -0.00667684f, 0.04903907f, -0.00661472f, 
    0.02591004f, 0.19938979f, -0.03879844f, -0.06613184f, 0.06339378f, 0.02170745f, -0.12322451f, 0.22041708f, 
    -0.05003881f, 0.09567720f, 0.03272500f, -0.09562378f, -0.02038428f, -0.09548382f, 0.11292873f, -0.07515794f, 
    -0.08484884f, 0.04474687f, -0.08757224f, -0.06287216f, 0.07636748f, -0.20749468f, 0.12905802f, -0.06157469f, 
    -0.02236045f, -0.00069090f, -0.04007104f, 0.16597739f, 0.07372512f, 0.09060699f, 0.17323360f, -0.12863988f, 
    -0.11418969f, 0.01083846f, -0.02460545f, -0.09709961f, 0.05199975f, 0.08603185f, -0.04455632f, 0.10131477f, 
    -0.09135120f, 0.12720862f, -0.07777666f, -0.43846047f, -0.01433953f, 0.05360538f, 0.02781441f, -0.00291728f, 
    0.13410246f, 0.11037460f, 0.12537831f, 0.00302822f, -0.03911397f, 0.05535578f, 0.19127677f, -0.02931966f, 
    -0.10417894f, -0.14524016f, 0.15644982f, 0.10341460f, 0.01334124f, 0.01954800f, 0.06273033f, 0.01498373f, 
    -0.07353660f, -0.02098601f, 0.06882401f, 0.20790929f, 0.11606991f, 0.04913074f, 0.17881452f, 0.13348112f, 
    0.00878412f, 0.03252250f, -0.06219479f, -0.11317270f, 0.53042424f, -0.10359664f, -0.23263015f, 0.16410786f, 
    -0.06538881f, -0.00647440f, 0.09311946f, 0.01564444f, -0.03720792f, -0.07767469f, -0.00154663f, -0.04035965f, 
    0.36289236f, -0.04467724f, -0.01047936f, -0.10727594f, 0.06234147f, 0.04918975f, 0.05289036f, -0.02605902f, 
    -0.07070127f, -0.04671910f, 0.01317190f, -0.12385874f, -0.23654789f, 0.11587118f, -0.08685935f, 0.12112605f, 
    -0.09490273f, 0.02846830f, -0.12772289f, 0.01690912f, -0.07069585f, -0.06779481f, -0.12804787f, -0.20757689f, 
    -0.21808475f, 0.07878288f, -0.24796170f, 0.02675556f, -0.06207004f, -0.06314251f, -0.05840634f, -0.06611005f, 
    -0.05629558f, 0.13936612f, -0.02435692f, -0.13911109f, -0.06430995f, -0.05632874f, -0.01089324f, -0.02700955f, 
    -0.10299575f, 0.02534444f, -0.06371564f, 0.01147669f, 0.00757409f, 0.00151966f, 0.05858942f, -0.09539259f, 
    -0.06708397f, -0.08804873f, -0.25539646f, 0.16323905f, -0.05719223f, 0.02792103f, -0.03894908f, 0.00340567f, 
    -0.05952204f, -0.03439229f, -0.03614150f, 0.04623302f, 0.21681456f, 0.07597733f, 0.11909775f, -0.18105027f, 
    -0.06301790f, -0.16367428f, 0.00973820f, -0.03786174f, -0.18251897f, -0.05977914f, -0.05276776f, -0.10217572f, 
    0.15316445f, -0.08002466f, -0.21437186f, 0.05830413f, -0.11691646f, -0.14054303f, 0.01132940f, 0.09964097f, 
    -0.03676512f, -0.00298528f, 0.00139831f, -0.08165942f, 0.10184439f, -0.00268150f, 0.07682478f, -0.09715593f, 
    -0.01168407f, -0.12078158f, -0.05819188f, -0.12910989f, -0.21606767f, 0.10682030f, -0.11512133f, -0.10221077f, 
    -0.23062435f, 0.11949485f, 0.13810571f, 0.09220509f, 0.03944683f, 0.04930387f, 0.00266880f, -0.10018458f, 
    0.03700839f, 0.12105233f, 0.02199648f, 0.09316044f, 0.14865081f, 0.19890550f, 0.27884042f, -0.30748257f, 
    -0.05299167f, 0.07614656f, -0.06868246f, 0.06127764f, -0.10154967f, 0.06551962f, -0.19020490f, -0.00339378f, 
    -0.10047582f, -0.12957676f, 0.08842998f, 0.02378431f, -0.07799595f, 0.05062561f, 0.00785243f, -0.04214527f, 
    -0.09199085f, -0.05842827f, -0.09713902f, -0.01223436f, -0.26096183f, -0.08336569f, 0.23033586f, 0.28696963f, 
    -0.01394906f, 0.11335943f, -0.13110867f, 0.07922184f, 0.02106078f, -0.10900946f, -0.01374067f, -0.10937902f, 
    0.30494389f, -0.10592527f, 0.08038034f, 0.13940611f, 0.00940466f, 0.07413444f, 0.03479337f, -0.01952294f, 
    -0.15503640f, -0.00676308f, 0.01736088f, -0.04501361f, -0.03716098f, 0.10653634f, 0.12266873f, 0.24301629f, 
    0.02460143f, -0.03843147f, 0.08193435f, 0.18361203f, -0.19376311f, 0.09691669f, -0.04945746f, -0.08121289f, 
    -0.25555846f, 0.15443760f, 0.15214157f, -0.13458984f, -0.09234286f, -0.17035368f, 0.00538546f, 0.02895545f, 
    -0.07943741f, 0.04819369f, 0.03705950f, 0.02908158f, 0.06826393f, 0.23719923f, 0.01303546f, 0.04321458f, 
    -0.08507509f, 0.01015668f, -0.07337594f, -0.19619069f, -0.17597425f, -0.05397906f, -0.06962561f, -0.15147902f, 
    0.03714607f, 0.19925520f, 0.14975107f, -0.04785325f, -0.02035711f, -0.21194217f, -0.11058566f, -0.08863486f, 
    -0.13766378f, 0.03991149f, -0.06631713f, -0.12604262f, 0.11678962f, 0.14492637f, -0.07189715f, -0.10324001f, 
    0.03255396f, -0.02694515f, -0.05288696f, 0.06545200f, -0.17489989f, 0.04983030f, -0.11010585f, 0.01718158f, 
    0.17903078f, 0.26343822f, 0.05637972f, -0.04698328f, 0.14448349f, 0.09454070f, 0.04209236f, 0.00171095f, 
    0.05566623f, 0.00174889f, -0.02777367f, 0.18162332f, -0.03737754f, 0.28450266f, 0.07197521f, 0.07298355f, 
    0.05496060f, 0.07437136f, 0.00856074f, 0.04705827f, -0.08447363f, 0.09733739f, -0.04802736f, 0.05576715f, 
    0.07793785f, 0.27651981f, 0.16897230f, 0.01819188f, 0.11705924f, 0.02655747f, 0.04644904f, 0.14539602f, 
    0.00308976f, -0.07287591f, -0.04146316f, -0.03169337f, -0.65574652f, -0.39092898f, 0.07709856f, 0.02823491f, 
    -0.23772044f, -0.12638283f, -0.25618890f, -0.15863775f, -0.00397402f, 0.04635969f, -0.11020289f, 0.05914211f, 
    -0.25461170f, -0.08438800f, 0.29537320f, 0.09095513f, -0.07348629f, -0.09211544f, -0.13685690f, -0.05321484f, 
    0.04731630f, 0.09474032f, 0.00563148f, -0.02842853f, 0.12339434f, -0.21680398f, -0.22503218f, 0.05593145f, 
    -0.12094574f, -0.05025923f, 0.02339412f, -0.16772637f, -0.07222366f, -0.11094771f, -0.13791633f, 0.20930800f, 
    -0.07813082f, 0.28698045f, -0.18915983f, 0.01863075f, 0.04487526f, -0.03589528f, 0.03613665f, 0.01396023f, 
    0.04630320f, 0.08863688f, 0.10101637f, 0.23884128f, 0.07275287f, -0.16311646f, -0.07212610f, -0.05971456f, 
    0.08807749f, -0.00257304f, -0.00773360f, 0.01290577f, 0.08369331f, -0.13594554f, -0.03363613f, -0.02961838f, 
    0.19866164f, 0.02999376f, 0.25749412f, 0.02460720f, 0.02500406f, 0.11705816f, -0.11064888f, 0.10288019f, 
    -0.02461672f, -0.04677818f, 0.03748807f, 0.06905681f, 0.10142777f, 0.21755794f, -0.09835827f, 0.06827059f, 
    0.04309161f, -0.02234665f, 0.08060996f, 0.07003982f, -0.02037143f, -0.06653958f, 0.01266691f, 0.04119671f, 
    0.35870123f, -0.09608310f, 0.14018805f, 0.22397690f, -0.01306832f, 0.09017719f, -0.01218001f, 0.01160650f, 
    0.05547626f, 0.07918856f, 0.02894747f, 0.08987400f, 0.10810653f, 0.20881294f, 0.25240353f, 0.25135559f, 
    0.09459656f, 0.05019510f, 0.04489256f, -0.02416210f, -0.04697813f, -0.01851896f, -0.07215081f, -0.01531304f, 
    -0.17324254f, 0.10077273f, -0.02558046f, -0.03780703f, 0.13936232f, 0.02710269f, -0.01646297f, 0.13177328f, 
    0.17794941f, 0.07790682f, 0.03695174f, 0.17306051f, -0.18537588f, 0.05720824f, -0.11340654f, 0.07405135f, 
    -0.07133243f, -0.10173843f, -0.30718547f, 0.18689641f, 0.09891481f, -0.00347042f, 0.01814838f, -0.09653424f, 
    -0.11090940f, -0.16697398f, -0.34103075f, 0.15235320f, -0.26201063f, -0.15339132f, -0.13737714f, -0.01996682f, 
    -0.06906198f, 0.01406548f, 0.04974951f, 0.00159917f, -0.08640528f, -0.15931004f, 0.05621947f, -0.22045477f, 
    -0.03951205f, -0.03906017f, 0.11450151f, -0.05861929f, 0.03555518f, 0.10978778f, -0.13958669f, -0.05310195f, 
    -0.20862582f, -0.10659153f, -0.10101642f, -0.11804689f, 0.07111543f, -0.02889617f, -0.06455797f, -0.06264321f, 
    -0.01292042f, -0.11090326f, 0.00889457f, 0.08586317f, -0.22187176f, -0.22535613f, -0.17996700f, 0.05335191f, 
    0.11123574f, 0.14663887f, 0.10820135f, -0.13057101f, 0.02585340f, 0.00758056f, 0.05291703f, 0.04364117f, 
    0.00648799f, 0.32927316f, 0.10085481f, 0.00674561f, 0.10201053f, 0.00894346f, 0.25388852f, 0.05184640f, 
    -0.07899055f, -0.19734403f, -0.04020768f, -0.02328875f, 0.03551346f, 0.15451790f, 0.18684223f, 0.02710735f, 
    0.07875419f, -0.08856018f, -0.20030436f, -0.04870204f, -0.15121858f, -0.08042225f, -0.08743220f, -0.10883503f, 
    0.38057345f, -0.23041488f, 0.22837576f, -0.18232016f, 0.20976210f, 0.01712021f, -0.13833719f, 0.01172852f, 
    -0.23940578f, 0.02533340f, -0.03099118f, -0.02668698f, 0.08351918f, -0.02303441f, -0.08272894f, 0.04001410f, 
    -0.03094824f, 0.04268603f, -0.02313837f, -0.02215732f, 0.01057231f, -0.06208394f, -0.04168881f, 0.02393222f, 
    -0.17035253f, 0.05621699f, -0.05705465f, -0.13436164f, 0.03342826f, 0.04650337f, 0.19737917f, -0.05153023f, 
    0.12033770f, 0.06194045f, 0.24737430f, 0.14953528f, 0.11591212f, -0.17199820f, 0.14425807f, 0.22922495f, 
    0.04111777f, -0.02816075f, 0.11777379f, -0.10403284f, 0.10643782f, 0.11851628f, 0.01609784f, 0.07550587f, 
    0.25536653f, -0.02432019f, 0.23816039f, -0.00173195f, 0.13534378f, -0.01262047f, 0.04771376f, 0.00617326f, 
    -0.00385844f, 0.05712264f, 0.03271483f, 0.04581494f, 0.13421804f, 0.06099113f, -0.02413199f, 0.07875891f, 
    0.03416684f, 0.12933521f, 0.09204917f, -0.19384490f, -0.06791764f, 0.04820522f, 0.02202533f, 0.07293614f, 
    -0.20034115f, -0.06291228f, 0.06626059f, -0.08607606f, 0.22503495f, -0.00700043f, 0.05562479f, 0.13013113f, 
    0.00606456f, 0.02000174f, -0.12436529f, 0.01758678f, 0.00953083f, 0.10708849f, 0.17913713f, 0.12413962f, 
    0.22774518f, 0.06805896f, 0.24551013f, 0.10315645f, -0.01340535f, -0.10104460f, -0.00379370f, -0.12007360f, 
    -0.05264390f, 0.10696447f, -0.06400048f, -0.00396958f, 0.06925240f, 0.15803704f, -0.00609067f, 0.10121084f, 
    0.32506505f, 0.03665405f, 0.09953512f, 0.11013221f, 0.03118563f, 0.20519617f, -0.10485920f, 0.24121954f, 
    -0.09248360f, -0.04107689f, -0.07017382f, 0.04841634f, 0.07752915f, -0.00854077f, 0.10084780f, 0.04920846f, 
    0.00701567f, -0.06128398f, -0.12158479f, 0.15576097f, -0.00905190f, 0.06278002f, -0.00437770f, -0.08628338f, 
    -0.06897650f, 0.06254234f, -0.04339579f, -0.12770478f, -0.31139261f, -0.14574581f, -0.06987603f, 0.13039288f, 
    -0.01165145f, -0.00036893f, 0.08039917f, 0.04890335f, 0.03678740f, -0.03154116f, 0.11608820f, 0.03041394f, 
    -0.11014376f, -0.00541566f, 0.09335714f, -0.04626415f, -0.08711415f, -0.10371058f, -0.03366603f, 0.10679643f, 
    -0.01791150f, -0.16921699f, 0.06463242f, 0.00716654f, -0.00898061f, -0.04527226f, -0.01529675f, 0.13884705f, 
    0.04546652f, 0.11388768f, 0.00985119f, 0.02215530f, 0.14691737f, 0.11692853f, 0.10340771f, 0.05203694f, 
    -0.22895557f, -0.16061601f, 0.05022130f, 0.00241460f, -0.00269411f, 0.00640832f, 0.15050876f, 0.13562892f, 
    0.13936076f, 0.10573632f, 0.12258062f, 0.07981208f, 0.22899161f, 0.10997342f, -0.25886911f, 0.22967778f, 
    0.02735883f, -0.06291842f, 0.01484291f, -0.00070615f, -0.10564466f, 0.05671737f, 0.01086710f, -0.23821592f, 
    0.37077099f, -0.20509537f, -0.17156127f, 0.08926336f, 0.19349974f, 0.13584733f, 0.13864619f, 0.21092135f, 
    -0.03054278f, 0.00111141f, 0.02686859f, 0.01373008f, 0.12339903f, -0.00186173f, -0.17832260f, 0.10426882f, 
    0.05872381f, -0.02300997f, 0.01224332f, 0.04646658f, -0.06484088f, -0.16069032f, 0.09027888f, -0.26476446f, 
    -0.18980801f, -0.26661143f, 0.19699539f, 0.06770144f, 0.03308509f, 0.07729404f, -0.14679569f, -0.05161097f, 
    -0.04593307f, -0.01131832f, -0.11695476f, 0.02007262f, 0.09042662f, -0.27786955f, -0.17947491f, 0.44481525f, 
    0.00121051f, 0.09347025f, 0.18458267f, -0.12873550f, -0.03117463f, -0.02486273f, -0.01228450f, 0.01085891f, 
    0.09777334f, 0.13686393f, 0.01786852f, 0.10877532f, 0.20832010f, 0.05315977f, 0.08969655f, -0.00973453f, 
    0.06192011f, 0.07882043f, -0.08163239f, 0.02884566f, 0.07717793f, 0.24149826f, 0.13539171f, -0.22775713f, 
    0.05220988f, 0.05754867f, 0.18560182f, -0.21510686f, 0.04014339f, 0.06088198f, 0.08736746f, 0.00461967f, 
    -0.29359111f, 0.08808488f, -0.01109380f, -0.32357568f, 0.06058578f, 0.04070973f, 0.07257172f, 0.01763635f, 
    0.15671161f, 0.07698978f, 0.05222940f, -0.12075595f, -0.01815909f, 0.07682901f, -0.01721702f, -0.18237597f, 
    0.04923227f, -0.05819052f, 0.00385882f, -0.08658419f, 0.10544940f, 0.08927454f, 0.09651919f, -0.05926035f, 
    0.12023594f, -0.15308854f, -0.05436058f, 0.17959851f, 0.04169862f, 0.03930553f, -0.08477169f, 0.11558744f, 
    0.00761030f, -0.11725271f, -0.17969784f, -0.09554514f, 0.32882541f, -0.13548152f, -0.11906937f, 0.14795120f, 
    -0.01249018f, -0.05436626f, 0.15567340f, 0.01987011f, -0.15907115f, -0.05071792f, 0.00122883f, 0.00821517f, 
    0.46760604f, 0.04580438f, -0.18921858f, 0.07919269f, 0.04846688f, 0.17219643f, -0.00811165f, -0.03124085f, 
    -0.05787713f, -0.02675015f, -0.04554092f, -0.13985747f, -0.27674565f, -0.07692754f, -0.24120663f, 0.08703132f, 
    0.00897193f, -0.09344637f, -0.06008171f, -0.12720832f, -0.19394091f, -0.06726875f, -0.00435151f, -0.15484628f, 
    -0.04584686f, 0.02231944f, 0.02085471f, -0.01574358f, -0.07117616f, -0.05113567f, -0.07539770f, -0.08446672f, 
    0.05644603f, -0.03902201f, -0.02368303f, 0.02832025f, -0.06543631f, 0.06462400f, 0.02399281f, -0.01971189f, 
    -0.01387245f, 0.04713556f, -0.02865895f, 0.04242939f, -0.03710105f, 0.01229876f, -0.03162812f, 0.02851709f, 
    0.03144925f, -0.07206841f, -0.06627773f, -0.00076504f, 0.00866842f, -0.01304550f, 0.00997926f, -0.01787925f, 
    -0.02788263f, -0.01919271f, -0.02026355f, 0.05539618f, -0.05090208f, -0.02317651f, -0.01805888f, -0.02799563f, 
    -0.01892666f, 0.02719012f, -0.02389979f, -0.01229985f, -0.07945149f, 0.02121627f, -0.03230816f, -0.07028835f, 
    -0.00713989f, -0.04294225f, 0.04112244f, -0.04107675f, -0.00372728f, 0.02552707f, -0.02160094f, 0.00619865f, 
    -0.07542811f, -0.03748154f, 0.00757419f, -0.04845290f, -0.07319424f, 0.00725265f, 0.00437599f, 0.03363806f, 
    -0.05307420f, -0.05987614f, -0.05401016f, -0.07135788f, -0.03674569f, -0.01045938f, 0.02866212f, -0.07137243f, 
    0.03339307f, 0.04540604f, 0.04038578f, -0.05927937f, -0.02390159f, -0.06220129f, -0.08257980f, 0.00677521f, 
    0.02169078f, -0.00033008f, -0.07742310f, -0.03761989f, -0.07655139f, -0.00010587f, 0.01508269f, 0.04883675f, 
    -0.01735588f, 0.02615627f, -0.01805916f, -0.07885932f, 0.00080406f, -0.04241397f, -0.07788034f, 0.04117291f, 
    -0.02626238f, 0.01202518f, -0.07066321f, -0.05668599f, -0.03393942f, -0.05653556f, -0.07574993f, 0.00462357f, 
    -0.01227451f, -0.06483474f, -0.05990997f, -0.01591705f, -0.01165095f, 0.06484424f, -0.02919226f, 0.03498838f, 
    -0.01182934f, 0.06214152f, -0.04313730f, -0.02799748f, 0.04061709f, -0.02513238f, -0.04340521f, 0.02749768f, 
    -0.03656467f, 0.00751588f, -0.03568612f, -0.00906937f, 0.03503684f, -0.03017342f, 0.04049249f, 0.04990859f, 
    0.04516092f, -0.07663338f, 0.04067297f, 0.02820601f, -0.01240763f, -0.01349074f, 0.03611340f, 0.02357277f, 
    -0.06385951f, 0.04328742f, -0.06729444f, -0.05016334f, 0.06065241f, 0.04090402f, -0.01450059f, -0.02213783f, 
    0.00209038f, -0.03509102f, 0.03115049f, -0.01958557f, -0.06828668f, -0.05196381f, 0.03366639f, 0.00351182f, 
    0.00662910f, -0.06937458f, -0.04898609f, 0.02716261f, -0.05677126f, -0.08314023f, -0.05931315f, -0.08883667f, 
    -0.08594152f, -0.00922379f, -0.09894982f, -0.02337058f, -0.04453942f, -0.00590777f, 0.04078291f, -0.01364379f, 
    0.02078749f, 0.01305753f, -0.02044987f, -0.00986577f, -0.04558688f, -0.07179204f, 0.01896068f, -0.05637516f, 
    0.03087318f, 0.04143821f, -0.07320257f, -0.05148474f, 0.00829030f, -0.02013296f, -0.01287961f, -0.00475253f, 
    -0.07752720f, -0.04648113f, -0.02875761f, -0.05996874f, -0.08151159f, -0.06329890f, 0.04730208f, -0.05365441f, 
    -0.22815277f, 0.19727388f, 0.09990897f, 0.04691379f, 0.08274228f, -0.02889766f, -0.09142067f, 0.15723184f, 
    -0.12178577f, 0.17073783f, 0.02464363f, -0.09647328f, 0.29441464f, 0.27744174f, 0.12443370f, 0.03491184f, 
    -0.03732149f, -0.03806737f, -0.00695182f, 0.13624756f, -0.01588137f, -0.00825792f, -0.08483845f, -0.02644541f, 
    0.01367961f, 0.21829216f, -0.14296807f, 0.10712751f, -0.10220579f, 0.01464982f, 0.00813132f, -0.01084871f, 
    -0.25497466f, -0.17449901f, -0.12872303f, 0.00119566f, -0.16320658f, -0.26313230f, -0.13836178f, -0.15063080f, 
    0.02797782f, 0.03468278f, -0.00091564f, 0.05636390f, -0.07964253f, 0.15734208f, -0.03448983f, 0.06936546f, 
    -0.31728482f, -0.12146340f, 0.12046363f, 0.00937400f, -0.19056176f, 0.08979404f, 0.08869385f, -0.03057614f, 
    0.11545730f, 0.13507868f, 0.03599578f, 0.06821854f, -0.08407549f, 0.01271986f, 0.10294545f, -0.04038936f, 
    -0.06207550f, 0.05311757f, 0.06595543f, 0.07880372f, -0.11120948f, -0.24976094f, -0.27350950f, -0.18739228f, 
    -0.06054388f, 0.16928142f, 0.10629491f, 0.11203004f, 0.02809276f, 0.25105619f, -0.01935188f, 0.10182728f, 
    -0.08915875f, -0.23915742f, 0.02254714f, 0.02453844f, -0.00471389f, 0.07222874f, 0.18543650f, -0.10757315f, 
    0.06801502f, 0.10829553f, 0.00158905f, 0.11344837f, -0.11939957f, -0.01231851f, 0.04995812f, -0.03816529f, 
    0.06953771f, -0.15612312f, -0.01478295f, -0.03914086f, -0.01702237f, 0.07996845f, -0.01948113f, -0.07767763f, 
    0.02154323f, -0.02668715f, -0.05135024f, -0.04116873f, -0.10255945f, -0.25827947f, 0.00133279f, 0.15423970f, 
    0.08767167f, 0.05012467f, 0.06815360f, 0.21646154f, -0.10537542f, -0.01245284f, -0.06566902f, -0.08666836f, 
    0.69685286f, -0.19328076f, 0.15576787f, 0.26665512f, -0.08127873f, -0.05184370f, 0.02660660f, 0.02931866f, 
    0.08286945f, -0.15084513f, -0.16686065f, 0.10033330f, 0.09008595f, 0.27953842f, 0.12161106f, 0.06167821f, 
    0.05496532f, 0.07893680f, -0.10991457f, -0.08783870f, -0.06692009f, 0.04375131f, 0.05277798f, -0.00682283f, 
    -0.02833427f, 0.12139696f, 0.05992139f, 0.02339763f, -0.01870969f, -0.13858931f, -0.08204904f, -0.00088766f, 
    -0.05259618f, -0.06046603f, -0.11317458f, -0.10056917f, -0.32171211f, 0.23256081f, -0.07691892f, -0.08531746f, 
    0.06525932f, -0.08761100f, 0.09987846f, 0.05903402f, 0.01020262f, -0.00946437f, 0.09204536f, -0.06476949f, 
    -0.12530170f, 0.00012075f, -0.12046987f, -0.12310101f, -0.00244355f, 0.01190635f, -0.01914140f, 0.01523504f, 
    0.04154077f, 0.04308747f, 0.02634722f, 0.04119950f, 0.12638524f, 0.06658849f, 0.01890714f, -0.00250619f, 
    0.19353928f, 0.06068773f, -0.00886574f, -0.04776890f, -0.06638524f, 0.14742781f, 0.19772209f, 0.13786779f, 
    -0.00110792f, -0.05329627f, -0.02052208f, 0.01770445f, -0.02972394f, -0.02546137f, -0.03108250f, -0.03150163f, 
    0.05170735f, -0.02804701f, -0.06700439f, 0.00095990f, -0.00821432f, -0.07627343f, -0.00540307f, 0.00146281f, 
    0.05122640f, 0.00406283f, 0.03106721f, -0.01448529f, 0.02858256f, -0.05221275f, 0.02085501f, 0.01976742f, 
    -0.00934307f, -0.03139658f, 0.04519524f, -0.00766828f, -0.03278387f, 0.04368757f, -0.07507668f, 0.05054868f, 
    0.01418247f, -0.02782611f, 0.00646694f, 0.00193858f, 0.01270007f, 0.02510093f, 0.00899638f, 0.05516825f, 
    0.00824025f, -0.06345369f, -0.03414082f, -0.06122114f, -0.06809183f, 0.03280597f, -0.02229544f, 0.03632760f, 
    -0.06815793f, 0.00295746f, 0.01791112f, -0.02768829f, 0.03023455f, -0.04392839f, -0.07170128f, -0.02755401f, 
    -0.07633997f, 0.05603483f, -0.07593030f, 0.00698464f, 0.01600819f, -0.02634668f, -0.06244065f, 0.04663234f, 
    -0.07989132f, -0.00089657f, -0.06295743f, -0.06257773f, 0.04580055f, 0.03606910f, -0.02789325f, 0.00670251f, 
    0.01372605f, -0.01085808f, -0.05722028f, 0.00355244f, -0.04805062f, 0.03343041f, -0.07886665f, -0.07074404f, 
    0.00504982f, -0.02374824f, -0.05848753f, 0.03937621f, -0.05560613f, 0.04468981f, 0.01286473f, -0.07286186f, 
    -0.05922296f, 0.00403207f, -0.02689701f, -0.05339045f, 0.01843233f, -0.06272867f, -0.04013501f, -0.04532161f, 
    -0.06261238f, -0.06936999f, -0.06067311f, 0.03664688f, -0.01389250f, -0.03529756f, 0.04419328f, -0.03656491f, 
    -0.00161574f, 0.02293121f, 0.00063207f, 0.00607805f, 0.01052464f, 0.03273408f, 0.02538729f, -0.05972332f, 
    0.01957246f, -0.07307979f, 0.00298431f, -0.02230112f, 0.01281699f, -0.06300323f, -0.07336657f, 0.02544800f, 
    0.05909826f, -0.04907511f, -0.08046494f, -0.01209174f, 0.05452848f, 0.01712526f, -0.07238430f, -0.03984964f, 
    0.05811046f, -0.00966751f, -0.08031523f, 0.04268549f, -0.04511527f, 0.05801985f, -0.03157624f, 0.02562442f, 
    -0.05507275f, -0.03392018f, -0.02200229f, -0.00323005f, -0.07090654f, 0.06164908f, -0.06247260f, -0.03941257f, 
    0.03929503f, 0.05377175f, -0.03860647f, 0.05729821f, -0.02490804f, -0.03960284f, 0.05967945f, -0.00741742f, 
    0.02762785f, -0.07605614f, -0.02349960f, -0.06940875f, 0.00162716f, -0.01427385f, -0.01533642f, 0.01288950f, 
    0.05816208f, -0.05656048f, -0.05141292f, -0.04973567f, -0.01971627f, 0.00790943f, -0.07418074f, 0.02876227f, 
    0.05768487f, 0.02701440f, -0.02991055f, -0.04804861f, -0.00344101f, -0.03749172f, 0.00626355f, -0.06474143f, 
    0.03865606f, -0.02300099f, -0.08130486f, -0.02372161f, -0.05819815f, 0.03451591f, 0.05792468f, -0.00858885f, 
    -0.00203201f, -0.04231111f, -0.02771486f, 0.01082872f, -0.05725115f, 0.02864379f, -0.07502090f, -0.07972937f, 
    0.06898575f, -0.13007715f, 0.11177624f, -0.08194870f, -0.02406578f, -0.08210879f, 0.04185361f, 0.24863975f, 
    -0.13043956f, 0.14090428f, 0.08743426f, 0.21959598f, 0.08831537f, -0.15374261f, -0.14232247f, 0.00434681f, 
    -0.01525584f, -0.16300924f, -0.06425875f, 0.03770195f, -0.03729564f, 0.16795692f, 0.24557860f, -0.03332835f, 
    -0.00823148f, -0.12163732f, -0.15606861f, 0.17687164f, 0.07733070f, 0.07961635f, 0.10039002f, 0.04279053f, 
    0.00553487f, 0.05369831f, 0.07567393f, 0.08895488f, 0.19403173f, 0.15545362f, 0.20297897f, -0.06834437f, 
    -0.07142796f, 0.02177341f, -0.00617736f, 0.01781134f, -0.02351915f, 0.04167786f, -0.06118117f, 0.01296795f, 
    0.52539337f, 0.09852654f, -0.08421145f, 0.08316851f, -0.04760953f, 0.26770854f, 0.13876122f, 0.06930596f, 
    -0.00017832f, 0.10101568f, 0.05621529f, 0.03382657f, 0.07832944f, 0.08383817f, -0.06876821f, -0.00999532f, 
    0.00677849f, 0.05071547f, 0.07999218f, -0.04445749f, -0.08419085f, 0.15498783f, -0.03028360f, 0.09690926f, 
    0.00819611f, 0.38287881f, -0.17578447f, -0.27923983f, -0.00380863f, 0.11496116f, 0.00217743f, 0.04667386f, 
    0.19686727f, 0.21835019f, -0.01962998f, -0.02044799f, 0.10037186f, 0.04463132f, 0.21121794f, -0.25670278f, 
    -0.03067163f, -0.02067878f, 0.07736307f, 0.11719942f, -0.05598143f, 0.14497997f, -0.11076708f, -0.01694042f, 
    -0.08772374f, -0.14257379f, 0.14507869f, 0.12335262f, 0.05160426f, -0.08158114f, 0.01547393f, 0.04955631f, 
    -0.06086269f, -0.05475585f, -0.04835904f, -0.04085880f, -0.49144131f, -0.04020679f, 0.21629171f, 0.06824061f, 
    -0.04228778f, 0.10077352f, 0.11071392f, -0.12423109f, -0.04253707f, -0.13793404f, -0.01818746f, 0.01051076f, 
    -0.07423331f, 0.22583842f, 0.05503764f, 0.28674313f, -0.09851576f, 0.12616390f, 0.23160037f, -0.13871562f, 
    -0.06842774f, 0.03957252f, 0.02888701f, 0.12535715f, -0.24333940f, -0.20949322f, 0.05517736f, 0.13391718f, 
    -0.04231295f, -0.09888379f, -0.01241852f, -0.01602396f, 0.04759774f, -0.06979182f, -0.07555915f, -0.12928875f, 
    0.08887908f, 0.13761063f, -0.08489980f, -0.17919323f, 0.16315542f, 0.01141784f, 0.14609180f, 0.05815741f, 
    0.05600921f, -0.01003131f, -0.05780583f, -0.00810474f, -0.13215852f, -0.01016965f, -0.04816090f, 0.03488788f, 
    -0.01812321f, 0.04163015f, -0.01186905f, -0.09967824f, 0.07328150f, -0.07505354f, 0.00072241f, -0.02020226f, 
    -0.02600145f, 0.13751721f, 0.04776040f, -0.08051226f, 0.03506676f, 0.01571895f, 0.07942692f, -0.03381050f, 
    0.01574596f, -0.07247432f, -0.07611684f, -0.01737125f, 0.08404197f, 0.06968740f, -0.11160382f, -0.03524509f, 
    0.27783909f, -0.01013137f, -0.03731833f, -0.03754294f, -0.10170718f, -0.15201738f, 0.07709706f, -0.01068280f, 
    0.02252624f, -0.00493548f, -0.01423038f, -0.05409032f, -0.01043088f, -0.05299206f, -0.01897110f, -0.05040580f, 
    0.03266448f, -0.01556359f, 0.06047842f, -0.05938430f, -0.02907393f, 0.05175614f, -0.05165994f, -0.05400176f, 
    -0.00407059f, -0.00289388f, 0.00464060f, 0.01112171f, 0.05578912f, -0.03004666f, -0.07873885f, -0.02548337f, 
    -0.05317944f, -0.08131611f, 0.03506272f, -0.01002099f, -0.07985451f, -0.06690522f, -0.06423721f, -0.06144134f, 
    -0.00311243f, -0.07889142f, 0.03478210f, -0.02247428f, 0.00920587f, 0.05258068f, 0.00939010f, 0.02762827f, 
    -0.03973324f, -0.00718421f, 0.01433495f, 0.00080698f, 0.05614449f, -0.03825350f, -0.07464490f, -0.03659521f, 
    -0.05692740f, 0.00609008f, -0.07209525f, -0.08322708f, -0.06962680f, 0.01362574f, 0.01519571f, 0.02525045f, 
    0.04106250f, -0.05724749f, -0.06362292f, -0.06531328f, 0.01993478f, 0.03046163f, -0.05251525f, 0.00426893f, 
    -0.08403666f, -0.07154874f, 0.05659199f, 0.04942252f, -0.05746406f, 0.02680901f, 0.02535435f, -0.00168621f, 
    0.05062280f, -0.06635452f, 0.03548902f, 0.03477469f, -0.03125348f, -0.07035518f, -0.03099932f, 0.00445750f, 
    0.02671168f, -0.07920851f, 0.05659558f, -0.04748478f, 0.02590290f, 0.00512403f, 0.03094426f, -0.08333577f, 
    0.04796570f, -0.06694121f, 0.02946952f, -0.06242408f, -0.02956623f, -0.04059800f, 0.00296738f, -0.06552817f, 
    -0.00463598f, -0.06790390f, -0.06030848f, 0.04984256f, 0.05874720f, 0.02857953f, -0.06165659f, 0.05239967f, 
    -0.02462622f, -0.04409845f, 0.04439691f, 0.03799916f, 0.02498438f, 0.03919382f, -0.03883827f, 0.01925316f, 
    -0.00756983f, 0.05294523f, 0.01707022f, 0.02325144f, 0.05795806f, -0.02390629f, 0.02689448f, 0.03842177f, 
    -0.08198345f, -0.06936613f, 0.03252715f, -0.03966212f, 0.00703286f, -0.01604303f, -0.03991638f, 0.03852400f, 
    0.02815146f, 0.05651878f, 0.05341945f, -0.03456331f, -0.03348797f, -0.06981655f, -0.00687941f, 0.02341895f, 
    0.04981047f, -0.03321397f, -0.05956669f, -0.07186004f, 0.02255335f, -0.03733004f, -0.06089120f, -0.05081798f, 
    -0.05691836f, -0.03143260f, 0.05152633f, -0.07793126f, 0.04612248f, 0.05507606f, 0.01391982f, -0.02618405f, 
    -0.05565852f, 0.01638056f, -0.01348639f, -0.05484714f, -0.01209573f, 0.02293297f, -0.02319949f, -0.00819177f, 
    -0.04956438f, -0.04925463f, -0.04838983f, 0.01134435f, 0.04257295f, -0.05917196f, -0.07522949f, -0.00166384f, 
    0.03167185f, -0.00068143f, 0.04695723f, 0.02301471f, 0.04689571f, -0.08166398f, -0.06628655f, -0.02060311f, 
    0.05238665f, -0.06917673f, -0.01921632f, 0.06025155f, 0.03848144f, 0.01249605f, -0.01274992f, 0.02125910f, 
    0.05033993f, 0.05574311f, 0.03520437f, -0.02730860f, -0.05603301f, -0.04424218f, -0.01650495f, 0.01596781f, 
    -0.12225090f, 0.16002941f, -0.03016781f, 0.03713592f, -0.02957712f, 0.03017952f, -0.02449677f, 0.03547040f, 
    0.00590751f, 0.19771364f, -0.01998364f, -0.04803562f, -0.01776090f, 0.18811986f, -0.00319187f, 0.00405014f, 
    0.00769034f, 0.06055050f, -0.11416661f, -0.10258900f, 0.02809804f, -0.00248807f, 0.14999908f, 0.03984242f, 
    -0.07814061f, 0.06189708f, -0.14549606f, 0.19011852f, 0.16018598f, -0.02658873f, -0.12321431f, 0.04844741f, 
    0.01343637f, -0.08381948f, -0.01749464f, 0.01855108f, 0.05052757f, -0.02568989f, 0.36787871f, -0.05290211f, 
    -0.25000957f, -0.14968470f, -0.02702869f, -0.05241019f, -0.08260775f, -0.06125988f, -0.18847626f, 0.12601073f, 
    0.00394010f, 0.23688352f, -0.24245529f, 0.00749580f, -0.30498067f, -0.10354964f, -0.12815706f, 0.05674644f, 
    -0.00018883f, 0.09412109f, 0.01100155f, -0.10488703f, 0.02610497f, 0.00416370f, 0.15479830f, 0.03273129f, 
    -0.00015613f, -0.07852889f, -0.06514964f, -0.09998254f, -0.01729441f, 0.04979567f, -0.15234800f, -0.23372291f, 
    -0.02258023f, -0.05932981f, 0.05983608f, 0.02738436f, 0.13776276f, 0.06208514f, 0.11665341f, 0.16362186f, 
    0.12146065f, 0.10328665f, 0.06612550f, 0.02144329f, 0.23556860f, 0.48939657f, 0.07592690f, -0.22679272f, 
    0.02510921f, -0.04472688f, -0.03153308f, 0.12612018f, -0.10285505f, 0.10026658f, -0.14777175f, 0.03213676f, 
    -0.17002921f, -0.15047522f, 0.18492395f, -0.09519582f, 0.00942338f, -0.07469046f, -0.04270630f, -0.09673460f, 
    -0.03883440f, -0.09248296f, 0.04499937f, -0.11065256f, -0.23803930f, -0.14271033f, 0.03948515f, 0.05477880f, 
    -0.00754101f, 0.06374298f, -0.04027618f, 0.20989244f, 0.04822148f, -0.01283946f, 0.02000808f, 0.01697749f, 
    0.34941572f, 0.04720805f, 0.15295316f, 0.09588125f, -0.03859290f, 0.03833179f, 0.05524615f, -0.06600013f, 
    -0.09957889f, -0.08616783f, 0.05542493f, -0.01759825f, 0.03367595f, 0.05203148f, 0.34261763f, 0.31687298f, 
    0.01073437f, 0.06200973f, 0.13356803f, 0.10707559f, -0.06383297f, 0.09137657f, 0.10169591f, -0.04142151f, 
    -0.27189928f, 0.32247102f, -0.02658354f, -0.14148256f, -0.02797433f, -0.06405381f, 0.01650117f, -0.02976844f, 
    -0.06046075f, 0.21119708f, 0.06048587f, -0.07818472f, 0.28979209f, 0.31661701f, 0.12168238f, 0.01412410f, 
    -0.10480966f, 0.08805018f, -0.06828140f, -0.08549429f, -0.12279156f, 0.13675354f, -0.15634887f, -0.06539550f, 
    0.37064934f, 0.17053202f, 0.10604435f, -0.10552327f, -0.17117010f, -0.29206508f, -0.17509602f, -0.00443392f, 
    -0.13091831f, 0.06643989f, -0.02235596f, -0.08247483f, -0.00790023f, 0.25763497f, -0.12290802f, -0.24018787f, 
    0.17329629f, 0.11868318f, 0.04280308f, 0.09530472f, -0.14448620f, -0.03524205f, 0.01076950f, 0.04850945f, 
    -0.01281660f, -0.03462151f, -0.05552315f, -0.07804818f, -0.07267012f, -0.01787739f, -0.05104365f, -0.03537155f, 
    0.03389438f, 0.04170518f, 0.01803716f, -0.04610957f, -0.07550399f, -0.02034735f, -0.06426856f, -0.02839139f, 
    0.04381502f, -0.05156386f, -0.07233835f, 0.01017464f, 0.01604087f, -0.06816797f, 0.04111773f, 0.04402858f, 
    0.05826002f, 0.06044422f, 0.02876389f, -0.03467147f, 0.00209033f, 0.05520060f, 0.00045391f, -0.07033247f, 
    -0.05598909f, -0.03402032f, -0.07484653f, 0.01625398f, 0.03277173f, -0.06050625f, 0.05879250f, 0.01843445f, 
    -0.07881369f, -0.07918310f, 0.00745162f, -0.07475427f, 0.01527945f, 0.00994919f, -0.08048775f, -0.01178260f, 
    -0.01275868f, -0.01418191f, 0.00290460f, 0.06288663f, -0.05650688f, -0.03225614f, -0.02394054f, 0.01991979f, 
    -0.01173715f, 0.00943298f, 0.03646849f, -0.07099136f, -0.00734602f, 0.02780653f, -0.03334145f, -0.01808727f, 
    0.00642882f, -0.06303974f, 0.00610731f, 0.01377741f, 0.05342249f, -0.02667290f, 0.05651462f, -0.07372831f, 
    -0.00173796f, -0.06318469f, -0.00233015f, -0.00672083f, -0.03338980f, -0.01775843f, -0.06723142f, -0.00934987f, 
    -0.01100417f, -0.04205549f, -0.04118563f, 0.05607639f, -0.04459278f, -0.05913549f, 0.04344561f, 0.04882945f, 
    -0.02918908f, -0.05216549f, 0.05013646f, 0.01295970f, -0.04160330f, -0.00426453f, -0.00419575f, 0.00407872f, 
    -0.03042804f, 0.01092893f, 0.01275500f, -0.00382492f, -0.05302237f, -0.00495535f, -0.07896301f, 0.01881838f, 
    0.03985288f, 0.02258573f, 0.00293091f, 0.01389426f, -0.05582279f, 0.01347288f, 0.03711590f, -0.06821495f, 
    0.03886892f, -0.03591201f, 0.02295758f, 0.04299960f, 0.02828640f, 0.05894657f, -0.07278442f, -0.05477215f, 
    0.05038881f, 0.04838644f, -0.04184042f, 0.05377214f, 0.00686725f, -0.05483159f, 0.05100412f, -0.00966524f, 
    0.04753321f, 0.01568099f, 0.05943323f, -0.05286451f, 0.00948146f, 0.03413492f, 0.03329490f, -0.07942024f, 
    -0.04076962f, -0.05127506f, -0.04239963f, 0.05769866f, -0.06717909f, -0.03797956f, -0.03098513f, 0.04093787f, 
    0.05348275f, -0.02325074f, 0.02134018f, -0.01403643f, 0.00442398f, -0.00948485f, -0.00852286f, -0.01085218f, 
    -0.04552381f, -0.01635724f, -0.03938702f, 0.04817845f, -0.00681056f, -0.05130262f, -0.05534190f, -0.00458545f, 
    0.01342695f, -0.02203528f, 0.05087975f, 0.05541708f, 0.03340074f, -0.06126825f, -0.06818391f, -0.01061613f, 
    0.03261181f, 0.00217654f, 0.04565007f, -0.02143038f, -0.02648093f, 0.02624425f, -0.06548162f, -0.00230718f, 
    -0.07621177f, -0.06365976f, -0.04986420f, -0.02896455f, -0.03332791f, -0.04793165f, -0.05197900f, -0.02604699f, 
    -0.02611727f, -0.01511689f, 0.04474286f, -0.06703478f, 0.03971246f, -0.07270991f, 0.04273341f, -0.01793081f, 
    -0.32073018f, 0.37863886f, 0.00950247f, -0.06958617f, -0.03321512f, -0.08528958f, -0.01574901f, 0.01325087f, 
    0.00745596f, 0.04831161f, 0.02467825f, -0.03950129f, -0.09809481f, -0.00473918f, 0.11484524f, 0.13087429f, 
    -0.10873141f, 0.08113109f, -0.08825742f, -0.07996543f, 0.03360354f, -0.07023523f, 0.11111744f, -0.11348767f, 
    -0.21412329f, 0.30219087f, -0.19148362f, 0.22658159f, 0.09706274f, 0.03487552f, 0.26894498f, -0.11327469f, 
    -0.00625092f, -0.04305080f, -0.02783640f, 0.08034348f, 0.15744683f, -0.03179944f, 0.21255909f, 0.10699154f, 
    -0.02077964f, -0.15936714f, -0.02950427f, 0.02023362f, -0.10078391f, -0.00918010f, -0.21755107f, -0.02297984f, 
    0.11039613f, 0.11546169f, 0.25109524f, -0.02463054f, 0.02509992f, 0.03886611f, -0.12817653f, -0.05199073f, 
    0.01151647f, 0.17361562f, 0.09247118f, 0.01593693f, 0.06063800f, -0.08416744f, -0.15763076f, 0.01874910f, 
    -0.03544350f, 0.02599463f, -0.00578123f, 0.08834101f, -0.09668329f, 0.16781946f, -0.08285046f, 0.10791647f, 
    -0.29739112f, 0.08967083f, 0.27127007f, 0.11954737f, 0.15250573f, 0.24315567f, 0.14158021f, 0.11228255f, 
    -0.02682249f, -0.04607288f, 0.17313091f, 0.11600931f, 0.13583641f, -0.09477133f, 0.26340860f, -0.03417156f, 
    0.02084973f, 0.05601669f, -0.02456632f, 0.15061469f, 0.05306302f, 0.06670398f, -0.11212773f, 0.00769346f, 
    0.27263945f, -0.22860873f, 0.35663816f, -0.04511062f, 0.10507713f, -0.07993599f, -0.00166797f, -0.04648747f, 
    -0.15027925f, -0.00735245f, -0.02690044f, -0.12449618f, -0.37328413f, -0.07055380f, -0.10394944f, 0.23960534f, 
    -0.02148567f, 0.14332591f, -0.00639740f, 0.03102230f, 0.05473274f, -0.10854977f, -0.00620873f, -0.05610950f, 
    0.43537065f, -0.28239349f, 0.34355369f, -0.12485717f, 0.04927842f, 0.02227954f, -0.00459391f, 0.01698482f, 
    0.01316918f, -0.06882578f, -0.07060551f, -0.00768840f, 0.01709060f, 0.33670640f, 0.18358353f, 0.36160249f, 
    0.01555314f, -0.16493496f, 0.11010154f, -0.02249767f, -0.10384130f, -0.01692845f, -0.03648669f, -0.04574725f, 
    -0.15962258f, 0.25339589f, -0.09624530f, 0.22447903f, 0.10368591f, 0.04928449f, 0.08888958f, 0.01826736f, 
    0.11877943f, 0.21221861f, -0.04822885f, 0.09875385f, -0.14453213f, 0.36631125f, -0.33952966f, 0.33183888f, 
    -0.01971698f, 0.00285361f, 0.09596246f, 0.07129969f, -0.07874864f, -0.01548696f, -0.02625293f, -0.05246229f, 
    0.30836549f, 0.04408586f, -0.18084627f, 0.07076631f, -0.06399024f, 0.01790965f, -0.03505220f, 0.01383336f, 
    -0.13952684f, 0.12734026f, -0.03099653f, -0.13932084f, -0.23224393f, 0.16636945f, -0.13311017f, 0.12300345f, 
    0.12043095f, 0.10957868f, 0.13149455f, -0.05641548f, -0.08426561f, -0.14135560f, -0.07433537f, -0.13684960f, 
    -0.03583059f, 0.04392475f, -0.06208869f, 0.00455765f, 0.05945337f, 0.02670814f, -0.03234711f, -0.05258329f, 
    -0.07529418f, -0.05636627f, -0.06397125f, -0.01322465f, -0.00140213f, 0.06174186f, 0.04996395f, -0.05092884f, 
    0.05558094f, 0.01045383f, -0.03664253f, 0.02210357f, -0.01881847f, 0.04319838f, -0.05575345f, 0.05092416f, 
    -0.05586031f, -0.07929272f, -0.00270645f, -0.01617826f, -0.02072523f, 0.03017365f, 0.05302898f, -0.03795630f, 
    -0.06604798f, -0.06797517f, -0.02773190f, -0.00085412f, 0.03266491f, 0.00131929f, -0.07711949f, -0.00084675f, 
    0.03071877f, 0.06278504f, -0.05866275f, -0.01415633f, -0.01987400f, 0.00287623f, 0.03463873f, 0.06337041f, 
    0.02440475f, -0.04948181f, -0.02087372f, -0.08467253f, 0.03481725f, 0.00879668f, 0.03257445f, -0.01367521f, 
    -0.07349478f, -0.05342519f, 0.04072467f, 0.03458579f, 0.05725197f, -0.02508264f, -0.04278809f, -0.06075367f, 
    0.03507718f, -0.02501646f, -0.06830075f, -0.05315474f, -0.06079629f, 0.01631733f, -0.04317057f, 0.00699407f, 
    -0.00318358f, 0.03237952f, -0.07702231f, -0.03543803f, -0.04278013f, -0.00360110f, 0.00097812f, 0.04634248f, 
    0.02714672f, -0.03005636f, 0.00676980f, 0.00011066f, -0.03175845f, -0.02906050f, 0.03656899f, -0.05322674f, 
    0.04505140f, -0.02809238f, -0.03624805f, 0.01799542f, 0.02421772f, 0.03714182f, 0.00770318f, 0.01258243f, 
    0.02112399f, -0.02428375f, -0.04870496f, -0.02858302f, 0.02300499f, 0.01456532f, -0.06533102f, -0.06897157f, 
    -0.02867869f, 0.05650867f, 0.02576768f, 0.03084741f, 0.00399847f, -0.04251312f, 0.05461683f, 0.02289653f, 
    0.04691448f, -0.01435896f, 0.00132545f, 0.03297394f, -0.02074172f, -0.05807133f, 0.06474557f, -0.06605851f, 
    0.00911494f, -0.04664849f, 0.03071326f, 0.01889890f, -0.05131751f, -0.03494914f, 0.06032102f, -0.04697433f, 
    -0.06282901f, 0.06440517f, -0.01976530f, -0.02234030f, -0.04392888f, 0.01808911f, 0.02827161f, 0.04911916f, 
    -0.08001284f, 0.02330823f, -0.04499860f, -0.02938249f, -0.02265999f, 0.04024331f, -0.03181662f, -0.00526464f, 
    0.01393283f, 0.04009182f, -0.07369391f, -0.03903148f, -0.07015385f, -0.05267604f, -0.03151409f, -0.04719842f, 
    -0.03187395f, -0.03218688f, 0.02085517f, 0.00358895f, 0.06219053f, 0.03214916f, -0.01595826f, -0.00086097f, 
    -0.05190570f, 0.01412993f, -0.03661470f, 0.06359726f, 0.01929803f, 0.02508232f, 0.05420028f, -0.07571712f, 
    0.05309834f, 0.01339551f, 0.01977121f, 0.00829126f, -0.06656115f, -0.05149481f, 0.00627745f, 0.03087291f, 
    -0.03919155f, -0.03272023f, -0.03022340f, 0.00288870f, 0.03672688f, 0.02459584f, -0.02778592f, 0.00613379f, 
    -0.06943237f, -0.04600852f, -0.01008845f, -0.08114009f, 0.04738583f, -0.03442985f, -0.07109789f, -0.00715979f, 
    -0.01148891f, -0.06443693f, -0.05221807f, -0.02781112f, -0.04423560f, 0.05745934f, 0.02806228f, -0.04436811f, 
    -0.02192419f, 0.06201668f, -0.00321075f, -0.02962527f, -0.07410683f, -0.00835782f, 0.01016966f, 0.04899035f, 
    -0.07273957f, 0.03380941f, -0.02676110f, -0.03864069f, 0.03174132f, 0.01613403f, -0.02368219f, 0.05994325f, 
    -0.05442709f, -0.01265918f, 0.05284065f, 0.05362521f, -0.05167361f, -0.00856945f, 0.06243707f, -0.07355142f, 
    -0.04428679f, 0.06159303f, -0.05296589f, -0.05542367f, -0.06669014f, 0.04887507f, 0.00952193f, 0.03696991f, 
    -0.06752636f, 0.04516370f, -0.03146288f, 0.04251894f, 0.01667415f, -0.08160412f, -0.02725557f, 0.02392691f, 
    -0.04528244f, 0.02592135f, -0.06340546f, -0.02458546f, 0.02215752f, 0.01096626f, 0.03653124f, -0.06992518f, 
    0.00959259f, -0.02467703f, 0.00782152f, -0.06490266f, -0.00510047f, 0.01102987f, 0.00627921f, -0.01392121f, 
    0.03291698f, -0.02146188f, -0.06675129f, -0.04660883f, 0.04247490f, -0.03382209f, 0.05325468f, -0.05445779f, 
    0.00110505f, -0.02265804f, -0.00006842f, -0.01309619f, -0.02327117f, -0.00795364f, 0.04092370f, -0.03279770f, 
    -0.00133302f, 0.01426443f, -0.01484918f, 0.02387064f, -0.07667135f, -0.01171783f, 0.03227565f, -0.00889298f, 
    0.02175455f, -0.04469805f, -0.02789100f, 0.02530116f, -0.00040708f, 0.05031659f, 0.00152099f, -0.04199030f, 
    -0.04589724f, -0.04316648f, 0.00819089f, -0.06961796f, 0.03719549f, 0.03965018f, -0.01287631f, 0.00365297f, 
    0.00743908f, 0.05763032f, 0.01009476f, -0.00300266f, -0.00327317f, -0.05687401f, -0.05041490f, 0.04291434f, 
    -0.03523795f, -0.06476482f, 0.00288674f, 0.04235015f, 0.01039149f, -0.07855062f, 0.03875146f, 0.03180439f, 
    0.02833216f, 0.03209645f, 0.03156504f, -0.07417517f, -0.06920499f, 0.03389015f, 0.00135866f, -0.00282345f, 
    0.01699199f, -0.02001686f, -0.06370274f, -0.04341822f, 0.05450862f, -0.06986172f, 0.02744173f, 0.05749546f, 
    0.02771998f, 0.01835356f, -0.07146791f, -0.06501359f, 0.01946421f, 0.05254344f, -0.00903552f, 0.03538998f, 
    -0.02926542f, 0.02744336f, -0.07613418f, 0.03203438f, 0.00929361f, -0.01912647f, -0.03906460f, 0.04420917f, 
    0.02368100f, 0.01487110f, 0.01306104f, -0.00258236f, -0.02654352f, -0.06349921f, -0.07614536f, -0.04862431f, 
    -0.00570481f, -0.06488002f, 0.03300110f, 0.00737385f, -0.07289721f, 0.04840094f, -0.06195638f, 0.03223760f, 
    -0.03324793f, 0.02766968f, 0.05652644f, 0.04191601f, -0.06610343f, 0.03734402f, -0.05076280f, -0.07080151f, 
    0.01701881f, -0.06261055f, -0.07191395f, -0.07641570f, -0.05475334f, -0.02738100f, -0.03556615f, -0.04390502f, 
    0.01208325f, -0.00516010f, 0.04976326f, 0.03669783f, 0.04507020f, -0.01747024f, -0.08192442f, 0.04091711f, 
    -0.02742508f, -0.10785741f, -0.46639493f, -0.18495506f, -0.01849413f, 0.07759456f, 0.02546431f, 0.07403900f, 
    0.09519543f, -0.08187220f, -0.23412356f, -0.01263896f, 0.09133926f, -0.34159884f, -0.39034268f, -0.12270328f, 
    0.05707579f, 0.05246687f, 0.14023876f, -0.07474079f, 0.16144897f, -0.06698042f, 0.15308355f, 0.04890071f, 
    0.17235985f, 0.21452555f, 0.02324717f, -0.03378225f, 0.24501693f, -0.06790725f, 0.09260546f, 0.03180146f, 
    0.11760325f, 0.05612139f, -0.06900465f, 0.10500662f, -0.03099860f, 0.24711087f, 0.44364232f, 0.03900500f, 
    -0.10681217f, -0.07408743f, -0.12716708f, -0.03749172f, -0.03305538f, -0.00551323f, 0.05134818f, 0.02487898f, 
    0.24916124f, 0.28296828f, 0.20395456f, -0.15659566f, -0.02684964f, -0.11231520f, -0.29133281f, -0.14566651f, 
    -0.07774162f, -0.00144422f, 0.01069647f, -0.14274089f, -0.00611462f, -0.00387668f, -0.05619389f, -0.03603674f, 
    -0.13754492f, 0.02719114f, -0.00651930f, -0.06557068f, -0.04134589f, 0.05963692f, -0.13136615f, 0.02020254f, 
    0.30756849f, 0.09577686f, -0.10112573f, -0.09821642f, -0.06556749f, -0.08624008f, 0.11404503f, 0.01519700f, 
    0.18137307f, 0.14689307f, 0.05473444f, 0.14810078f, 0.05755999f, 0.25100312f, 0.31258392f, -0.06114661f, 
    -0.10335777f, -0.07988095f, -0.14121933f, 0.17859882f, -0.07625590f, 0.09167217f, -0.05078145f, 0.12666053f, 
    -0.02909276f, -0.02213458f, 0.31723666f, 0.06108300f, 0.06461391f, -0.06019106f, -0.00845466f, 0.17307666f, 
    0.05828226f, -0.03869636f, 0.02744439f, -0.09920811f, -0.24822898f, 0.12313170f, 0.05565732f, 0.13354915f, 
    -0.04613845f, -0.01652211f, 0.09478817f, 0.06512844f, 0.00465406f, 0.01497586f, 0.00586477f, 0.07901395f, 
    -0.33929595f, -0.24186203f, 0.16059595f, 0.13363089f, 0.05946310f, 0.17546816f, 0.18485448f, 0.09059373f, 
    -0.02689172f, 0.01458281f, 0.02622533f, 0.08186273f, 0.15931170f, -0.10842712f, 0.26817843f, 0.21644717f, 
    0.02010157f, -0.04193518f, 0.27482101f, 0.10267474f, -0.00808164f, 0.00935591f, 0.01883741f, -0.08873385f, 
    -0.03548738f, 0.18348829f, -0.01682117f, -0.08984419f, 0.04271487f, -0.04234978f, 0.02002876f, -0.11825401f, 
    0.19241913f, 0.11556737f, -0.07604343f, -0.06732781f, 0.04905020f, 0.09532411f, -0.06644883f, 0.18452629f, 
    -0.10310566f, 0.05204830f, -0.14670557f, 0.07016313f, -0.07269845f, 0.11652125f, -0.07927138f, -0.03674078f, 
    -0.00875735f, 0.19348887f, 0.13175593f, 0.03865928f, -0.17696898f, -0.10590033f, -0.06420866f, -0.02363689f, 
    -0.08900165f, 0.12428328f, -0.00219095f, -0.03384139f, -0.04155868f, 0.14709687f, -0.04269725f, -0.10257541f, 
    -0.09680413f, 0.02699131f, 0.06772918f, 0.06610908f, 0.00478241f, -0.01928762f, 0.13354903f, 0.04641976f, 
    -0.01240676f, -0.03797835f, -0.05254072f, 0.04683365f, -0.05543432f, -0.05843510f, -0.04549690f, 0.04418210f, 
    0.01675385f, 0.03777467f, 0.00821416f, -0.02557642f, 0.03511886f, -0.07095367f, -0.03990332f, 0.01731175f, 
    0.03617293f, -0.07791273f, -0.07305876f, 0.05200149f, -0.06984568f, 0.01215304f, -0.04685563f, -0.05759195f, 
    0.00221513f, -0.03582182f, 0.01358140f, 0.04416536f, -0.02321137f, -0.04017459f, -0.01450698f, 0.06055408f, 
    -0.00630031f, 0.03019141f, -0.06939913f, -0.00645258f, 0.03360662f, -0.01546256f, -0.02822768f, -0.01144020f, 
    0.06659213f, 0.00964344f, -0.07154567f, -0.05020534f, -0.02257296f, -0.05584284f, -0.06277125f, 0.05179800f, 
    -0.00250944f, -0.05241135f, -0.03855949f, 0.04621191f, -0.03712079f, 0.03617631f, -0.01698439f, 0.05200925f, 
    -0.03035177f, -0.07520442f, 0.04449819f, 0.00278764f, 0.03724202f, -0.05992944f, 0.03094553f, 0.04894669f, 
    -0.03647146f, 0.03741086f, -0.01457355f, 0.00276621f, -0.06925131f, -0.03258847f, -0.01339370f, 0.03859476f, 
    0.03399793f, 0.01632038f, 0.02173454f, -0.08141910f, 0.01817550f, -0.07025610f, -0.03513565f, -0.03663586f, 
    0.04553957f, -0.02446137f, 0.03388679f, 0.02601070f, 0.00612061f, -0.07689902f, -0.01054264f, -0.00916497f, 
    0.00524477f, -0.03267391f, 0.00907504f, 0.01733040f, 0.01328239f, 0.03489759f, 0.05984866f, -0.06511241f, 
    -0.03964462f, 0.05743611f, 0.01141458f, 0.03170655f, 0.00303226f, 0.02184573f, -0.04181753f, -0.00198433f, 
    -0.00019148f, -0.03216353f, 0.04418874f, 0.00379226f, -0.04118812f, -0.02168681f, -0.03177840f, 0.01646576f, 
    0.01627830f, -0.04488036f, -0.03393082f, -0.03916434f, 0.01458487f, -0.01031521f, -0.05842157f, 0.02961903f, 
    0.05002242f, 0.04631021f, 0.05151230f, -0.06255633f, 0.05544054f, -0.02411704f, -0.06521773f, -0.04153694f, 
    -0.05009412f, -0.07783722f, 0.02264690f, 0.03272596f, -0.00678798f, -0.05281110f, -0.02445755f, -0.00310167f, 
    0.04496554f, -0.05907947f, -0.06550987f, -0.01696239f, -0.02691434f, 0.02271572f, -0.06458676f, 0.03299618f, 
    -0.04107034f, -0.03585917f, -0.07754570f, -0.01032103f, 0.04017791f, -0.06165963f, -0.08000109f, 0.01201400f, 
    0.00109417f, -0.08039144f, 0.01773961f, 0.04894939f, -0.04486246f, 0.06236545f, 0.00674468f, -0.00890372f, 
    -0.03731262f, 0.03149853f, -0.00329786f, 0.04566745f, 0.05105055f, -0.06857757f, -0.01002714f, -0.06449927f, 
    -0.05691078f, -0.02788056f, -0.05239239f, -0.00858704f, -0.02594947f, -0.02057851f, -0.03574445f, 0.02447963f, 
    -0.02379628f, -0.04150360f, -0.05201085f, 0.04038637f, 0.06238464f, -0.05628341f, 0.00346424f, -0.01805299f, 
    -0.05403833f, -0.03026535f, -0.07332334f, -0.00040863f, 0.04312492f, -0.03560358f, 0.01298224f, -0.02441199f, 
    -0.04661225f, -0.02145396f, 0.04268868f, -0.01890373f, 0.01855740f, -0.00026695f, 0.02853683f, 0.00629466f, 
    0.00011691f, 0.05398468f, 0.04108986f, -0.03103076f, -0.06912653f, -0.05918641f, 0.03620304f, -0.06134257f, 
    0.02989336f, -0.01261929f, -0.01227171f, 0.04429180f, -0.04978768f, 0.00290856f, 0.04593066f, -0.04077639f, 
    0.00707356f, 0.02493538f, 0.00211902f, 0.00073103f, 0.04077222f, -0.07113349f, -0.07356300f, 0.00392821f, 
    -0.07779385f, -0.07554078f, 0.01440695f, 0.02687534f, -0.05408697f, 0.04888144f, -0.03328451f, -0.01015253f, 
    -0.03000072f, 0.05168068f, -0.00087784f, 0.04961631f, 0.01389405f, 0.04260082f, 0.05224480f, -0.00799659f, 
    -0.04549179f, -0.05824014f, -0.04632222f, 0.03188528f, -0.03101541f, 0.04286991f, -0.00716857f, 0.05697818f, 
    -0.02542150f, -0.04243499f, -0.02402246f, 0.05048086f, -0.07600705f, -0.03279342f, 0.02133146f, -0.00491386f, 
    -0.04972708f, -0.08492264f, -0.05336686f, -0.03196010f, -0.00761347f, -0.00906959f, -0.02422144f, 0.01335025f, 
    -0.04412007f, -0.00862442f, -0.00834553f, -0.05175217f, -0.04588404f, 0.03001515f, -0.02663474f, 0.04557477f, 
    0.00329217f, -0.01409964f, 0.05123061f, -0.01212673f, -0.04397100f, -0.02338887f, -0.03104622f, -0.02906199f, 
    0.00730815f, 0.03269262f, -0.08763129f, -0.02113169f, 0.01526600f, -0.00668257f, -0.04159940f, 0.05264601f, 
    -0.00463737f, -0.06185275f, 0.02150900f, -0.05284953f, -0.02372653f, 0.01774494f, -0.07717241f, -0.05999314f, 
    0.02722455f, -0.04934509f, -0.00158018f, -0.02244614f, -0.02220900f, -0.05378745f, 0.07332067f, -0.06718543f, 
    0.01261746f, 0.03574643f, 0.07238136f, -0.06708949f, -0.00343624f, -0.01103681f, -0.01550741f, 0.02488277f, 
    0.02137113f, -0.01853169f, 0.05246230f, -0.03773925f, 0.04761420f, 0.02818504f, 0.02118118f, -0.01846928f, 
    0.03689934f, 0.02600530f, -0.03362680f, -0.02621613f, 0.01342799f, 0.02061893f, -0.07204949f, -0.01564075f, 
    0.02146396f, 0.03560534f, 0.06444487f, 0.02649784f, -0.04805500f, -0.07828321f, 0.03698831f, -0.07396332f, 
    -0.07909621f, -0.07511083f, -0.07074055f, 0.03185309f, 0.03067188f, -0.01362662f, 0.00838068f, 0.00908808f, 
    0.01444812f, -0.06031309f, 0.01603197f, 0.04896085f, -0.01011175f, -0.04678266f, -0.02822464f, 0.00136555f, 
    -0.07298163f, 0.03885579f, 0.03087343f, -0.04658598f, -0.01676359f, -0.06805517f, -0.04467148f, -0.03580960f, 
    0.04871543f, 0.04659517f, 0.01691641f, -0.02091528f, 0.00715780f, -0.03548659f, 0.01974288f, 0.03750065f, 
    -0.02850564f, 0.02024993f, -0.03513068f, -0.02380267f, 0.00771176f, -0.02952729f, -0.06776915f, 0.01100318f, 
    -0.01848537f, -0.01374738f, 0.02366046f, -0.00782052f, -0.07786892f, 0.03864559f, 0.00427123f, -0.04010611f, 
    0.09404869f, -0.07024433f, -0.10698123f, 0.01765601f, 0.00435092f, 0.15055877f, -0.01629227f, -0.10234935f, 
    0.01433667f, -0.02907228f, 0.07860809f, 0.00719472f, -0.28636944f, -0.12186139f, -0.20827194f, -0.24354842f, 
    -0.03675991f, 0.28123617f, 0.05133889f, -0.12790939f, -0.05340922f, -0.38079765f, 0.07740544f, 0.06847630f, 
    0.12656799f, -0.00978720f, 0.03395392f, 0.00376327f, -0.16507432f, -0.07502378f, -0.38241223f, -0.05643247f, 
    -0.23125687f, -0.06764080f, -0.21077377f, 0.04665950f, 0.04182148f, 0.07991500f, 0.15960246f, 0.09197740f, 
    -0.04849316f, 0.04759006f, 0.06521209f, 0.12879768f, 0.04029514f, 0.08828245f, 0.02732517f, 0.07425226f, 
    0.00062098f, 0.48903513f, -0.01522651f, -0.06503721f, -0.39306709f, -0.20016302f, 0.06711614f, -0.02506492f, 
    -0.03593026f, -0.02129356f, 0.05383474f, 0.00263906f, -0.08783398f, -0.04354210f, 0.02775431f, 0.03713581f, 
    -0.06415956f, 0.07909369f, 0.07761177f, 0.08569586f, 0.20211193f, 0.24977902f, -0.05164222f, -0.02560939f, 
    -0.10578360f, -0.31003362f, 0.05848824f, 0.12164645f, 0.01667483f, 0.11136607f, 0.10278521f, 0.00929158f, 
    0.26508561f, 0.11117574f, 0.11771473f, -0.11514239f, 0.08792637f, 0.21892671f, -0.28639057f, -0.03713578f, 
    -0.30847281f, 0.01421115f, 0.00836225f, -0.08890437f, 0.06027124f, -0.11538619f, 0.05924434f, -0.03100499f, 
    0.16485584f, -0.11498354f, -0.06980290f, -0.05833925f, -0.19242251f, -0.29881325f, 0.12804955f, 0.09209513f, 
    -0.05072734f, -0.00913987f, -0.12988730f, -0.01514690f, 0.14812711f, -0.25737211f, -0.19018357f, 0.05178072f, 
    0.16649961f, -0.32362917f, -0.34976384f, 0.05837382f, -0.18340895f, -0.14743282f, -0.03449541f, -0.40197766f, 
    -0.33097574f, -0.10535555f, 0.01860619f, -0.13370560f, 0.03413659f, -0.07880274f, -0.20529288f, -0.09171596f, 
    0.20371029f, 0.06158279f, 0.00949189f, -0.03141106f, 0.26253086f, -0.05537545f, -0.21237464f, -0.26180601f, 
    0.22669765f, -0.00056209f, -0.00338341f, -0.07711379f, -0.23946854f, -0.21401116f, -0.16196643f, -0.05545639f, 
    0.03272947f, 0.11148400f, 0.07714359f, 0.07051872f, 0.11204426f, 0.02265183f, 0.00412425f, -0.02683470f, 
    -0.09494158f, 0.16901040f, 0.05095848f, 0.07139371f, 0.16043817f, 0.22872613f, -0.02419086f, -0.09225471f, 
    -0.10586149f, -0.00595053f, 0.07789899f, 0.07458185f, 0.07602731f, 0.07976484f, 0.09745900f, -0.00265559f, 
    0.01693202f, 0.04703679f, 0.10469680f, 0.01391405f, -0.03002947f, -0.01066594f, 0.12134006f, 0.08229130f, 
    0.05973493f, 0.03169211f, -0.04252229f, 0.01674880f, 0.01562828f, 0.11973962f, 0.00273563f, -0.05222864f, 
    0.05126961f, 0.22467747f, -0.14182448f, -0.03046776f, -0.09620020f, -0.20945065f, 0.07001409f, 0.12365057f, 
    0.05795107f, 0.09215801f, 0.18239944f, 0.01817051f, -0.07448968f, -0.26121834f, -0.18304950f, -0.08765128f, 
    0.10373939f, 0.06916191f, 0.03955079f, -0.08690073f, 0.10482886f, 0.12421545f, 0.13218670f, 0.25203571f, 
    -0.09191776f, 0.03842302f, -0.01765106f, -0.08578419f, 0.03334249f, -0.25998223f, -0.15209192f, 0.07063858f, 
    -0.13633841f, -0.16326085f, 0.26517761f, -0.04530386f, 0.05541456f, 0.03260905f, -0.09918195f, -0.05231240f, 
    -0.06960250f, -0.15022078f, -0.25892758f, -0.24309519f, -0.23931442f, -0.11088180f, -0.10645182f, 0.07926094f, 
    -0.04711203f, -0.08627313f, -0.02167787f, -0.13866557f, -0.02020175f, 0.01083171f, 0.06626495f, 0.05648998f, 
    -0.21384735f, 0.06329128f, -0.12433510f, 0.06495046f, -0.04649327f, -0.02803821f, 0.03704573f, -0.15097785f, 
    -0.01926826f, 0.02959098f, -0.02597467f, -0.07454510f, -0.07115014f, -0.04206210f, 0.18800889f, 0.03919664f, 
    -0.15363647f, -0.20011504f, -0.14469969f, -0.16590077f, 0.17116141f, -0.16671853f, 0.05792954f, -0.05766344f, 
    0.22071108f, -0.22901425f, 0.27880231f, 0.28415650f, -0.01957428f, -0.00064464f, -0.06020169f, 0.02862510f, 
    0.11955824f, -0.01170023f, -0.05674247f, 0.04235742f, 0.04659938f, 0.22045055f, -0.14065392f, 0.33544326f, 
    0.08121058f, 0.05498672f, -0.02793510f, -0.09321564f, -0.04621267f, -0.09397206f, 0.06848001f, 0.15363114f, 
    0.01454742f, 0.15277013f, 0.17172819f, 0.23058164f, 0.01194113f, -0.00855090f, 0.15868804f, 0.05871745f, 
    -0.01146423f, -0.05064491f, -0.08736283f, -0.04317581f, 0.29363561f, 0.25396153f, 0.23165840f, 0.06191088f, 
    -0.07292780f, -0.03967254f, -0.00130426f, 0.21863571f, 0.12825422f, -0.15209745f, -0.17843683f, -0.11702290f, 
    -0.16556603f, 0.19832867f, -0.07199876f, -0.13425894f, -0.01792840f, -0.07442176f, 0.03615859f, 0.08083902f, 
    0.07199071f, -0.07311225f, -0.02900726f, -0.00722528f, -0.09557642f, 0.04697454f, 0.26574838f, 0.17025883f, 
    0.11003764f, 0.17279524f, 0.22875440f, 0.13150455f, 0.04583114f, -0.05503851f, -0.02580818f, -0.19496751f, 
    -0.05089791f, -0.13978446f, 0.00832958f, 0.09719094f, -0.04743305f, 0.04718897f, 0.08736003f, 0.07665308f, 
    0.15229298f, -0.01010200f, 0.03599751f, 0.10232020f, 0.38773802f, -0.12885146f, 0.09197202f, -0.14305653f, 
    -0.05921577f, -0.03031019f, 0.01021991f, 0.09067929f, 0.00718589f, 0.11729748f, -0.01359823f, 0.00458504f, 
    0.07060288f, 0.07858573f, 0.07093903f, -0.01842458f, -0.09843220f, -0.05708535f, -0.15491942f, -0.00298066f, 
    0.09870895f, 0.04789180f, 0.16403358f, 0.03414467f, -0.07719578f, 0.02744609f, -0.08655057f, 0.08186607f, 
    -0.11378531f, 0.08961324f, -0.08426659f, -0.01687793f, -0.00739746f, -0.05838606f, 0.13884570f, 0.22666812f, 
    0.04249556f, 0.09760904f, 0.10922971f, -0.02225271f, 0.00339691f, 0.09541371f, -0.00799807f, -0.17887416f, 
    0.13231590f, 0.01369474f, -0.07165605f, -0.09096794f, -0.29607555f, -0.13152353f, -0.06599583f, 0.03590252f, 
    0.00408318f, 0.00734680f, 0.09663936f, 0.00486763f, -0.13585058f, -0.00812410f, -0.22300103f, -0.05373811f, 
    -0.22645268f, -0.09528962f, 0.00326218f, -0.13110155f, 0.04151365f, -0.09590594f, -0.10806428f, -0.14133660f, 
    0.03431382f, -0.06776440f, -0.15611948f, -0.10522415f, -0.03863526f, 0.06394426f, 0.05650367f, -0.01602983f, 
    0.02646526f, 0.04189182f, 0.02548144f, 0.02438276f, 0.07272317f, 0.02517025f, -0.06369274f, 0.06890401f, 
    -0.26868978f, 0.15033139f, 0.00735571f, 0.12772189f, 0.05087852f, -0.07865928f, 0.03846630f, 0.02507105f, 
    0.04691666f, -0.08101293f, 0.11682614f, 0.09295339f, -0.05784839f, -0.07785609f, 0.10081170f, 0.19938549f, 
    0.00786338f, 0.05579316f, 0.03221374f, 0.08330768f, 0.08681969f, 0.02577810f, 0.04759030f, -0.08753084f, 
    0.07831707f, -0.11073595f, -0.03950607f, 0.24168165f, 0.11359552f, -0.05170024f, 0.05454478f, 0.01479806f, 
    0.05531974f, 0.09384212f, -0.04597193f, 0.11559863f, 0.09167847f, 0.05933183f, -0.16568977f, 0.02840338f, 
    -0.05341478f, -0.08211073f, 0.05610370f, 0.01762871f, 0.11740419f, -0.03135795f, -0.07307190f, 0.03244451f, 
    -0.04979524f, 0.05070679f, -0.25787714f, -0.30604464f, 0.09925069f, 0.19275212f, 0.21546277f, 0.08273448f, 
    -0.07611347f, 0.04719931f, 0.00721090f, -0.02138515f, 0.03231768f, -0.18688031f, -0.50887090f, -0.17327814f, 
    0.19911911f, -0.28973740f, 0.25319660f, 0.29095918f, -0.00970798f, 0.03489933f, -0.04754640f, -0.07925420f, 
    -0.21710776f, 0.20224220f, -0.18284635f, -0.14925653f, 0.12129210f, -0.03426804f, -0.19019130f, -0.07097153f, 
    0.22351946f, -0.10962723f, -0.17112419f, -0.15166615f, -0.13859482f, -0.16397169f, -0.20223244f, -0.13116753f, 
    0.02482850f, 0.25762847f, -0.02515031f, -0.03588678f, 0.04585506f, -0.12773564f, 0.02427541f, -0.05845596f, 
    -0.03838840f, -0.03947185f, 0.00931790f, 0.15987261f, 0.06486046f, 0.01565383f, 0.04084012f, -0.03726771f, 
    -0.15483128f, 0.09160384f, 0.00355159f, 0.09659436f, 0.36768803f, -0.00238266f, 0.02665967f, -0.06230886f, 
    0.07732803f, 0.11515634f, 0.06398846f, 0.13935874f, 0.18343011f, -0.02790673f, -0.02477821f, -0.04259135f, 
    0.24428859f, -0.07742539f, -0.01078855f, 0.08748510f, -0.01665556f, 0.06821858f, 0.06410350f, 0.07086423f, 
    -0.00479865f, 0.08251797f, 0.00816047f, 0.08102442f, -0.08869419f, -0.02506517f, -0.00559836f, 0.10766209f, 
    -0.02607987f, 0.12965623f, -0.00799054f, 0.06701085f, -0.06109795f, -0.03338682f, -0.04298894f, -0.05482511f, 
    0.28598887f, -0.02575918f, 0.31712383f, -0.07703796f, 0.15816958f, -0.13407233f, -0.06711417f, -0.09281834f, 
    0.07913379f, -0.07996808f, -0.00934359f, 0.12382967f, -0.16672707f, 0.16831222f, 0.11391006f, 0.04335891f, 
    0.13006909f, -0.00997766f, 0.02254929f, 0.01274590f, -0.05887012f, 0.07255642f, -0.11034104f, 0.15092851f, 
    -0.12711205f, 0.29176661f, 0.20728140f, 0.07015685f, 0.16062929f, 0.07876826f, 0.02018554f, 0.07648279f, 
    0.04599502f, -0.03552025f, -0.03041593f, -0.03215379f, -0.52132332f, -0.35934922f, -0.24340892f, 0.16871274f, 
    -0.18985800f, -0.08898418f, -0.19283624f, -0.02028172f, 0.10739115f, 0.08931749f, -0.12007503f, 0.01248468f, 
    -0.37341204f, -0.28878722f, 0.10811178f, 0.06967704f, -0.08486209f, -0.12017802f, -0.06971071f, -0.02447842f, 
    -0.01731383f, -0.12700088f, -0.14292030f, -0.21190071f, -0.03694233f, -0.16595262f, -0.22712782f, 0.20955861f, 
    -0.03557855f, -0.07342863f, -0.08589051f, -0.13435799f, 0.09725513f, -0.04923338f, -0.10200592f, 0.16477452f, 
    -0.09362809f, 0.15958717f, -0.12670277f, 0.14504573f, 0.24404652f, 0.08606859f, -0.08385660f, 0.11768407f, 
    0.07532053f, 0.02477294f, 0.02080174f, 0.13888189f, -0.06802016f, -0.18370248f, -0.25342235f, 0.26715520f, 
    0.11512628f, -0.03680354f, 0.02982961f, 0.06781406f, 0.10492565f, -0.09990697f, -0.07474153f, 0.10366765f, 
    0.17800269f, 0.02366855f, -0.02074971f, -0.04315543f, 0.06464301f, 0.02463230f, -0.05108296f, 0.06005390f, 
    -0.00798759f, -0.07263973f, 0.10852307f, 0.03098702f, 0.21247281f, 0.13154329f, -0.07277732f, -0.19308852f, 
    0.04241525f, 0.12594189f, 0.15526214f, 0.08120290f, 0.05034371f, 0.06068352f, 0.00837294f, 0.05561855f, 
    -0.02395812f, 0.16156685f, -0.13316685f, -0.10205472f, -0.03199834f, -0.04507361f, 0.01158878f, 0.02224070f, 
    0.12524301f, 0.03086734f, -0.03366228f, 0.14625347f, -0.07119409f, 0.09797166f, 0.07107645f, -0.02308207f, 
    0.07969736f, 0.19073813f, -0.08941686f, 0.17123351f, 0.08078843f, -0.09492327f, -0.04101061f, -0.06094112f, 
    0.12313999f, -0.18739191f, -0.03045477f, 0.10409289f, -0.01480014f, 0.01389612f, 0.08128826f, 0.20564939f, 
    0.23823327f, 0.01493608f, -0.00748631f, 0.14635196f, -0.03227767f, -0.11332720f, -0.03517926f, 0.02615872f, 
    -0.12640463f, -0.09378798f, -0.12991688f, 0.15603483f, 0.21030036f, 0.11879434f, 0.06401516f, -0.05113131f, 
    0.16906397f, -0.23854460f, -0.28618360f, 0.06160898f, -0.12889373f, -0.00640267f, -0.02520602f, 0.06257552f, 
    0.06802118f, -0.05898969f, 0.08118880f, -0.09205314f, -0.08479950f, -0.22558716f, 0.13448451f, 0.00410177f, 
    -0.16127796f, 0.03129658f, 0.01990627f, 0.03168150f, 0.10490688f, 0.18331063f, 0.01983707f, 0.01356876f, 
    -0.15341803f, 0.20613310f, 0.08100922f, 0.10732174f, -0.03735763f, 0.14684372f, -0.03485888f, -0.05593694f, 
    -0.11674260f, -0.08863862f, -0.00369403f, 0.08531844f, -0.36757854f, -0.10992611f, -0.05405160f, -0.14427195f, 
    -0.09028854f, -0.00881209f, 0.02437818f, -0.00869693f, -0.04190968f, 0.19527346f, -0.04236349f, -0.06231197f, 
    -0.16943076f, -0.20772994f, -0.13330670f, 0.05195417f, 0.05995867f, 0.00562593f, 0.11423779f, -0.25138122f, 
    0.12861897f, 0.13693573f, 0.06291378f, -0.01624499f, 0.27128375f, 0.20435350f, -0.05974382f, -0.03051050f, 
    -0.00592573f, -0.03730226f, -0.01633489f, 0.03297585f, -0.03924001f, -0.09588560f, -0.00043842f, -0.03202651f, 
    0.07470918f, 0.13946034f, -0.24703301f, 0.10458437f, -0.07866523f, -0.13746922f, -0.23817722f, 0.27698633f, 
    -0.02879858f, -0.01935448f, 0.08035208f, 0.04774245f, 0.08443172f, -0.05000060f, -0.01342812f, 0.00270837f, 
    -0.07281154f, 0.02766746f, 0.02991291f, 0.05648898f, -0.03524147f, 0.36227643f, 0.18847907f, -0.05977900f, 
    -0.18377361f, -0.07241824f, 0.13755865f, 0.01644599f, -0.04655131f, -0.01804914f, 0.05534286f, -0.17637834f, 
    0.10778803f, 0.24977104f, 0.03790952f, -0.16340925f, 0.16299778f, 0.13560055f, -0.08825952f, 0.07627986f, 
    -0.16493611f, -0.02506801f, -0.01862828f, -0.07995073f, 0.06044824f, -0.04844743f, 0.06894567f, -0.00339922f, 
    0.24161246f, 0.01473616f, 0.02935578f, -0.03868039f, 0.06210334f, -0.03879847f, 0.15401451f, 0.20179683f, 
    -0.06781982f, -0.02291735f, -0.00240104f, 0.05449039f, -0.02721752f, -0.04028943f, 0.09004833f, -0.07677901f, 
    0.06536233f, -0.11091168f, -0.04370422f, -0.08873956f, -0.04514084f, 0.05646225f, -0.06004163f, 0.07446543f, 
    0.12985855f, -0.06729937f, -0.01402206f, -0.41960368f, 0.05987407f, -0.08377351f, -0.14007172f, -0.03266716f, 
    0.06342402f, -0.01937666f, 0.07993889f, 0.04335428f, 0.10274479f, 0.19880410f, 0.11215766f, -0.11475984f, 
    -0.14597294f, -0.17039528f, 0.04557326f, -0.15877296f, -0.09092503f, -0.05185539f, -0.00959264f, 0.03202815f, 
    -0.10683258f, 0.03279036f, -0.03207800f, 0.10239945f, 0.14795430f, 0.13516523f, -0.00158638f, 0.08297747f, 
    -0.02373099f, 0.06977943f, -0.05136226f, 0.07390826f, 0.35957271f, 0.21245307f, -0.26027900f, 0.17104556f, 
    -0.03545352f, 0.05988101f, -0.05569198f, 0.04687483f, 0.09409750f, 0.06327228f, 0.07829924f, 0.10597545f, 
    0.24620554f, 0.00570972f, 0.10525029f, 0.09335057f, 0.02876932f, 0.03770157f, 0.01443265f, -0.01290736f, 
    -0.08224452f, -0.03262540f, -0.11380655f, -0.06066325f, -0.03937233f, 0.14347674f, -0.00587412f, 0.12212142f, 
    -0.10935353f, 0.07876249f, 0.00695667f, 0.06609675f, 0.07044998f, 0.05684775f, -0.28008860f, -0.29906857f, 
    -0.03738277f, -0.05328163f, 0.00931609f, 0.08737762f, -0.04268420f, -0.07002974f, 0.04210997f, -0.01611809f, 
    0.04718055f, 0.03113583f, 0.03793509f, 0.07346678f, -0.06223508f, -0.07268195f, -0.04998901f, -0.09162396f, 
    -0.04007130f, 0.06930797f, -0.06848475f, 0.00989450f, -0.07959905f, -0.00709837f, -0.02999957f, -0.02269791f, 
    -0.04884914f, -0.06391106f, 0.01326126f, -0.00002370f, -0.03964514f, -0.06492530f, -0.00489730f, -0.03444536f, 
    -0.00210035f, -0.08876624f, 0.06387039f, -0.04828110f, 0.01940524f, -0.01175965f, -0.05146172f, -0.09896373f, 
    0.06382778f, 0.04793915f, -0.05440481f, 0.01538594f, -0.01603239f, -0.04502999f, 0.06469694f, -0.04916886f, 
    0.01040584f, -0.00541191f, -0.07601319f, -0.00096152f, 0.02867414f, -0.06448290f, -0.04861118f, -0.07650607f, 
    0.06633868f, 0.08223122f, 0.07314725f, 0.07294010f, -0.07003718f, 0.02853689f, -0.05913405f, 0.01269075f, 
    -0.00397821f, 0.05676618f, 0.08259932f, 0.06654102f, -0.06642894f, -0.08838248f, -0.05111443f, -0.05392665f, 
    -0.07256582f, 0.01696227f, 0.04982191f, -0.08460678f, -0.04662444f, 0.07925871f, -0.08755172f, -0.00146558f, 
    -0.03807162f, 0.01059007f, 0.06250775f, -0.02346235f, 0.00393752f, -0.03719911f, -0.01817169f, -0.10507498f, 
    -0.02299598f, -0.00520943f, -0.00617637f, -0.01876621f, 0.04074762f, -0.01045949f, 0.00711113f, 0.01397125f, 
    -0.02234426f, -0.06721683f, -0.03395157f, -0.06580197f, -0.00108088f, -0.01867229f, -0.00033992f, -0.08684838f, 
    0.02939452f, 0.01646985f, -0.04337884f, 0.06081979f, 0.01407311f, -0.02969913f, 0.01709130f, 0.00028070f, 
    0.02552062f, -0.07646045f, 0.04916290f, 0.05823035f, 0.03488860f, -0.06268352f, 0.02169210f, 0.01845494f, 
    0.02283975f, 0.03272761f, -0.00348820f, -0.08240718f, 0.05226045f, -0.04196689f, -0.04707493f, -0.07574610f, 
    0.03974168f, -0.02159155f, -0.09415114f, 0.03669909f, -0.07057475f, -0.02313651f, -0.00199713f, -0.06349289f, 
    0.01956240f, -0.05293760f, -0.08271087f, -0.01130239f, -0.05608324f, -0.02074303f, 0.06179285f, 0.00822498f, 
    -0.02270170f, 0.02832513f, 0.02851228f, -0.03593046f, -0.07290407f, -0.05622236f, 0.01032011f, -0.09084408f, 
    -0.01081133f, 0.02127154f, -0.07542609f, 0.00906126f, -0.03034203f, 0.04354982f, -0.09232555f, -0.05354848f, 
    -0.06186565f, -0.06170504f, 0.02798594f, -0.02933445f, -0.01677658f, 0.05674555f, -0.05389643f, 0.01519255f, 
    -0.02096436f, 0.04938351f, 0.04807940f, -0.03615953f, -0.01455894f, -0.05846822f, -0.00855832f, -0.05722903f, 
    0.04875575f, 0.07223822f, -0.03610867f, -0.04555616f, -0.06457193f, -0.02904909f, -0.05986924f, -0.01876947f, 
    0.01063879f, -0.06180442f, 0.01051497f, 0.04809478f, -0.05355650f, 0.01894520f, 0.00605011f, 0.02820629f, 
    -0.11651886f, 0.04706189f, 0.20340055f, 0.17372932f, -0.14141718f, -0.17059790f, -0.01859439f, 0.26943693f, 
    -0.03296360f, 0.03307213f, 0.19630851f, -0.05775239f, 0.17199834f, 0.08812542f, 0.28657886f, 0.20417480f, 
    -0.03003149f, 0.04381283f, -0.02345262f, 0.20851910f, 0.03827636f, 0.00572678f, 0.00002567f, 0.11302883f, 
    -0.19850338f, -0.27267084f, -0.04993491f, 0.04031099f, -0.02684565f, 0.22503024f, -0.03211211f, 0.02556150f, 
    0.12165818f, 0.13180126f, 0.06527846f, 0.10003021f, -0.10158394f, -0.04895174f, -0.39055654f, -0.17834342f, 
    -0.02865071f, -0.04085727f, 0.13672753f, -0.06811536f, -0.06856277f, 0.00582789f, 0.01417204f, -0.09281109f, 
    -0.02825757f, 0.05205175f, -0.04158918f, 0.17309728f, -0.01960983f, 0.19354388f, 0.19411394f, 0.12036214f, 
    -0.03212554f, -0.06499783f, -0.07920367f, 0.05521868f, -0.18109484f, 0.02934458f, 0.08545134f, -0.15973321f, 
    -0.00089292f, -0.07818522f, -0.09259885f, -0.05616897f, 0.21705243f, 0.17097713f, 0.14341906f, -0.00414441f, 
    -0.02778714f, -0.23729436f, 0.15214072f, 0.16008407f, 0.00177542f, -0.00368673f, -0.19924140f, -0.05068759f, 
    -0.03992335f, 0.02892619f, -0.06877048f, -0.10999625f, -0.03450530f, 0.10733681f, -0.01802837f, 0.01245307f, 
    0.07472502f, 0.19385032f, 0.05401268f, -0.03857877f, 0.14180607f, -0.11154437f, 0.04306460f, 0.06454623f, 
    -0.15949756f, 0.07680979f, -0.20322065f, 0.31223935f, 0.05816813f, 0.03041809f, 0.02552784f, 0.00821681f, 
    0.07752801f, 0.12891872f, 0.05552269f, 0.07665787f, -0.18740213f, -0.12991010f, 0.09190589f, 0.03772678f, 
    0.03862540f, 0.21845569f, -0.04473166f, 0.06225399f, 0.20668931f, -0.01940874f, 0.04451822f, 0.05367180f, 
    0.01001745f, 0.20675974f, -0.05574356f, 0.18492468f, -0.03756917f, -0.14602596f, 0.08177701f, 0.05856024f, 
    0.13320209f, 0.06386002f, 0.03616406f, -0.03207920f, -0.24585968f, -0.10965203f, -0.11522087f, -0.01140743f, 
    -0.13037232f, 0.15256588f, -0.19540578f, -0.00039772f, 0.10657217f, 0.04196211f, 0.05936284f, 0.11566233f, 
    0.01448042f, -0.12435290f, -0.06642725f, -0.02878870f, -0.01197995f, 0.04842598f, 0.02647011f, 0.03076294f, 
    -0.12747508f, 0.03364339f, 0.03995119f, 0.01742038f, -0.04024100f, 0.12033494f, 0.40259618f, -0.16526979f, 
    -0.05648288f, -0.00538513f, 0.03770734f, -0.01324253f, 0.02444460f, -0.07698484f, -0.03400757f, 0.14465508f, 
    -0.51362538f, 0.00409119f, 0.25443625f, -0.19102961f, 0.01648516f, -0.00276680f, -0.00835160f, -0.00685002f, 
    -0.03945604f, -0.07332210f, -0.11962783f, -0.07775110f, -0.00679747f, 0.01346211f, -0.18133050f, 0.02444190f, 
    -0.08981147f, 0.01350105f, -0.06179010f, -0.14727224f, 0.14310208f, -0.05218890f, 0.13602345f, 0.28350687f, 
    -0.04962561f, 0.09240951f, -0.03308038f, -0.14469786f, 0.08640169f, 0.04459029f, -0.00173471f, 0.00014137f, 
    0.11598775f, 0.04261217f, 0.06381673f, -0.18533963f, 0.04671986f, 0.09056098f, 0.09714743f, -0.05096009f, 
    0.09417642f, 0.16700250f, 0.04980095f, 0.08795041f, 0.18838075f, -0.07528360f, -0.11263749f, 0.06919608f, 
    0.14478412f, 0.18290873f, 0.05301429f, -0.22033177f, 0.06931014f, -0.01703575f, -0.04979969f, 0.01217672f, 
    -0.02279767f, -0.02276860f, -0.14780599f, -0.08002665f, -0.28735933f, -0.10043882f, -0.13071871f, -0.04980558f, 
    0.01712808f, -0.11089235f, -0.10466676f, -0.07412525f, -0.15789169f, -0.03145582f, 0.11569881f, 0.09677154f, 
    -0.25822917f, -0.07293935f, 0.37744039f, -0.20448817f, 0.06510732f, 0.08941089f, -0.03909434f, -0.14446351f, 
    -0.16568479f, 0.02007553f, -0.18517233f, -0.00545979f, -0.22488272f, 0.05405549f, 0.09874240f, -0.12487065f, 
    -0.02811056f, -0.07947940f, -0.06785190f, 0.02954529f, 0.05157446f, -0.15119898f, 0.05101016f, 0.06551038f, 
    0.08070448f, -0.09866089f, 0.02131664f, 0.07433975f, -0.13210820f, -0.07539786f, 0.04220972f, 0.11213522f, 
    -0.02114064f, -0.10637708f, 0.14252497f, 0.09742273f, -0.15295197f, 0.15416658f, 0.20105402f, 0.21801451f, 
    0.05927375f, 0.10265578f, -0.06419582f, -0.13731854f, 0.05088209f, -0.00004777f, 0.20334937f, 0.10032244f, 
    0.04744433f, 0.02527451f, 0.04430578f, -0.11279415f, 0.13189630f, 0.19105791f, -0.03278489f, -0.00898708f, 
    0.02268646f, 0.08009189f, 0.08956849f, 0.12941021f, 0.17330223f, -0.13273665f, -0.02796833f, 0.09493126f, 
    0.06979055f, 0.07726908f, 0.02229170f, 0.02574217f, -0.01145499f, 0.08093689f, -0.11323213f, 0.01397159f, 
    0.26906449f, -0.24777704f, 0.06221109f, 0.07228285f, 0.06415886f, -0.00384952f, 0.05649079f, 0.03701483f, 
    0.15827778f, 0.00594491f, -0.16683461f, -0.05099384f, -0.13539205f, 0.03535124f, -0.07161050f, -0.11598339f, 
    0.16923724f, 0.17515591f, -0.05405863f, -0.08608253f, -0.05898847f, 0.14139989f, -0.08070070f, 0.00629611f, 
    -0.00836606f, 0.02309796f, 0.06611179f, 0.14844565f, -0.05396332f, -0.03463819f, -0.03360984f, 0.07512803f, 
    0.15287392f, 0.00126249f, 0.17109175f, 0.11979094f, -0.13148831f, 0.05076728f, 0.18594328f, 0.04342214f, 
    -0.07358440f, -0.14657266f, 0.08313695f, -0.05710470f, -0.02221005f, -0.02425811f, 0.15049244f, 0.03593493f, 
    -0.45689505f, -0.07681987f, 0.11483736f, 0.07824678f, -0.04438169f, 0.03359518f, -0.10005429f, -0.09744855f, 
    -0.03206610f, -0.04484931f, 0.02016801f, 0.01569626f, -0.29799631f, -0.17261921f, -0.04092026f, 0.07757974f, 
    -0.12933357f, -0.00826287f, -0.09045844f, -0.03257721f, 0.03062208f, 0.08853757f, 0.23500133f, 0.17741597f, 
    0.39820707f, 0.08714587f, 0.11566665f, 0.15513165f, 0.20905215f, 0.18568695f, 0.10943347f, -0.06650170f, 
    -0.06234210f, -0.15859610f, -0.09724309f, -0.00425776f, -0.16072154f, 0.16354187f, 0.07433527f, 0.06526244f, 
    0.00393652f, -0.08359056f, 0.03177882f, -0.10403997f, 0.00310205f, 0.25572553f, 0.07731403f, -0.04949747f, 
    0.07601590f, 0.25537026f, 0.28235871f, 0.16268438f, -0.03189415f, -0.18918552f, 0.12249323f, 0.14507653f, 
    0.07463308f, -0.03268331f, -0.07906079f, -0.13897713f, -0.56212872f, -0.47809789f, -0.12902428f, -0.02574448f, 
    0.00308636f, 0.01577021f, -0.07422585f, 0.01801711f, 0.22662814f, 0.06145266f, 0.12246095f, 0.13150102f, 
    -0.16392346f, -0.21542826f, -0.08062436f, 0.07892907f, 0.05602181f, -0.22314458f, -0.06095038f, 0.09437763f, 
    0.07230984f, -0.05345953f, 0.16868529f, 0.09534915f, -0.12727924f, -0.37587902f, -0.20778690f, 0.03167362f, 
    0.01347002f, 0.04555509f, 0.09589293f, 0.03632561f, 0.03943969f, 0.14320675f, -0.03199199f, 0.00265653f, 
    -0.22878806f, 0.30383313f, -0.15326916f, -0.03928849f, 0.15457581f, 0.00067274f, 0.11529866f, 0.06683400f, 
    0.00509252f, 0.21913652f, -0.10466085f, 0.24327587f, -0.05944341f, -0.19944638f, -0.23338032f, -0.06720720f, 
    -0.03341954f, -0.08358065f, -0.03602516f, 0.05209053f, -0.01123731f, 0.04616939f, -0.01261882f, 0.07690761f, 
    0.16572300f, 0.20730470f, 0.27841002f, 0.17080350f, 0.02530541f, 0.03140044f, 0.02762358f, 0.20692021f, 
    -0.13946070f, -0.01104588f, -0.01439878f, -0.12353832f, 0.21981478f, 0.23914142f, 0.01648914f, -0.09180089f, 
    -0.07966147f, -0.13661201f, 0.07181110f, 0.24211003f, 0.05650723f, -0.05032741f, -0.12715068f, -0.16836052f, 
    -0.01634753f, 0.07175723f, 0.18806952f, 0.04431448f, 0.03313211f, 0.01904089f, -0.15938756f, -0.01340936f, 
    0.14869753f, 0.06644263f, 0.05508859f, 0.01037235f, 0.36563280f, 0.37561989f, 0.34520668f, 0.23240200f, 
    0.05173205f, -0.02584604f, 0.06165753f, 0.20330754f, -0.03395415f, -0.01685616f, 0.01468990f, -0.14347437f, 
    -0.08608411f, -0.10246257f, -0.09456985f, -0.09551833f, -0.07340687f, 0.01624027f, 0.10429475f, 0.12109984f, 
    0.01685369f, 0.04799388f, -0.01618368f, -0.01860861f, -0.02962019f, -0.40500724f, -0.23144519f, -0.22675392f, 
    -0.04397751f, 0.00285182f, -0.05714608f, -0.01774595f, -0.03611529f, 0.08311176f, 0.07958513f, -0.17162962f, 
    0.01724763f, -0.37510884f, -0.42882779f, -0.11686043f, 0.03619624f, -0.07859819f, -0.06117960f, 0.09111525f, 
    0.03738890f, 0.07430802f, -0.01149701f, 0.00172081f, 0.03935025f, 0.05696986f, 0.15809490f, -0.00190140f, 
    0.06522183f, 0.12508507f, 0.08335897f, 0.08889118f, 0.10192181f, 0.18154112f, -0.05365540f, -0.05364475f, 
    -0.17071061f, -0.19601266f, -0.11466409f, -0.03979919f, -0.05551158f, -0.08863440f, 0.04447412f, 0.22723375f, 
    -0.01024346f, -0.03648561f, 0.02823983f, 0.20991403f, 0.23648618f, -0.04040939f, -0.09252958f, 0.02303500f, 
    -0.08741083f, -0.00977853f, 0.07995638f, -0.00198323f, -0.02589516f, 0.08223107f, 0.01369762f, 0.07288292f, 
    -0.07875194f, -0.24428394f, 0.12377582f, -0.07026435f, -0.19593050f, 0.04501871f, -0.04787037f, 0.03998363f, 
    -0.13610075f, -0.14178710f, -0.00473137f, 0.13518198f, -0.10712636f, -0.10524151f, 0.07335535f, -0.00277441f, 
    0.08160501f, 0.03601322f, -0.05512657f, 0.06765015f, 0.15559506f, 0.09626200f, -0.01993244f, -0.02158074f, 
    0.03125644f, -0.20255277f, 0.10159671f, 0.22875361f, -0.01579128f, 0.09792657f, 0.19326255f, -0.16847365f, 
    0.04061273f, -0.05259271f, 0.05487289f, 0.09430265f, 0.06322478f, 0.11214946f, -0.00609630f, -0.09783059f, 
    0.04468652f, 0.02828116f, 0.01005475f, 0.04286545f, 0.04374686f, -0.22788171f, -0.02937097f, -0.03056222f, 
    0.34872794f, 0.21622333f, -0.26629272f, -0.09195078f, -0.09622776f, -0.02460524f, -0.04893034f, 0.06748234f, 
    -0.01115072f, -0.03348585f, -0.06649274f, -0.00604594f, 0.09130638f, -0.05472677f, 0.09244727f, -0.13305007f, 
    0.12547046f, -0.06348316f, 0.07149179f, 0.00264609f, -0.06674777f, 0.05911746f, 0.06481904f, -0.00933806f, 
    -0.05725001f, 0.07406848f, 0.06815508f, 0.45689127f, 0.04793905f, 0.13036619f, -0.08834658f, 0.00958041f, 
    0.05571786f, -0.02136176f, -0.00783742f, -0.14061195f, -0.31010339f, 0.19463070f, 0.19866095f, 0.11144891f, 
    0.12375215f, 0.03581800f, 0.13421664f, -0.21991748f, -0.12512255f, -0.11118246f, 0.06504980f, 0.07401208f, 
    -0.05190959f, 0.28644237f, -0.27617478f, 0.60002601f, -0.03662053f, -0.00274898f, 0.05238904f, -0.02960912f, 
    -0.06917774f, 0.13023780f, 0.09815929f, 0.07057644f, 0.01902279f, -0.11080001f, 0.08488040f, 0.07344765f, 
    0.01367125f, 0.04089786f, -0.02700007f, -0.12662275f, -0.05782340f, 0.09378669f, -0.00337224f, 0.01503389f, 
    0.15684958f, -0.15905873f, 0.05906948f, -0.08239950f, 0.05705579f, 0.01109770f, -0.10719621f, -0.01489852f, 
    -0.02442882f, -0.13304557f, -0.03609210f, 0.07062805f, -0.08159468f, -0.07124167f, 0.28980461f, -0.16040084f, 
    0.04548288f, -0.07477941f, 0.01655525f, -0.09256817f, 0.09445417f, -0.04891603f, -0.04095694f, 0.02921464f, 
    -0.19200170f, 0.09933196f, 0.16555920f, 0.01573816f, 0.04219260f, 0.09189083f, 0.04540585f, -0.08305704f, 
    0.07591249f, -0.00992899f, -0.06443338f, 0.01011384f, 0.26923868f, -0.01383147f, -0.07013436f, -0.11847436f, 
    0.22484526f, -0.07224831f, 0.03246297f, -0.11988660f, 0.04583179f, -0.02432645f, 0.07022020f, 0.17705810f, 
    -0.13166843f, 0.19330263f, 0.26214594f, 0.12952247f, -0.18522389f, -0.07194221f, -0.00042574f, -0.02101017f, 
    -0.21172065f, 0.25461558f, -0.04443675f, 0.05688502f, -0.14994040f, 0.04323224f, 0.18619294f, 0.05924637f, 
    -0.00838637f, -0.12967971f, -0.00916502f, 0.08910730f, 0.00288702f, 0.04694754f, 0.21649992f, 0.04680525f, 
    -0.11863658f, -0.17651175f, -0.11494343f, 0.26317981f, 0.10999623f, 0.14978512f, 0.11229167f, -0.05769422f, 
    0.06921363f, 0.11146184f, 0.15793581f, 0.00200051f, 0.38680291f, 0.20519093f, 0.06819223f, -0.04988533f, 
    -0.07842103f, -0.03328929f, 0.08419687f, 0.04719183f, -0.00494019f, -0.11741135f, -0.14720578f, -0.09907955f, 
    0.50120765f, 0.18022498f, -0.40831539f, -0.00671105f, -0.01018106f, 0.13825285f, 0.01197940f, 0.07336544f, 
    -0.06918845f, 0.05559262f, 0.00834347f, -0.11636800f, 0.17343929f, 0.06444914f, -0.05488240f, -0.05813120f, 
    -0.06259583f, -0.07663724f, -0.02891061f, -0.10071669f, -0.10420382f, 0.34145105f, 0.08962128f, 0.05047196f, 
    -0.32738140f, -0.09007702f, 0.16009364f, -0.02285062f, -0.01783592f, 0.10109852f, -0.04116485f, 0.06998733f, 
    0.21358041f, 0.17633523f, 0.11644783f, -0.12212283f, 0.14983904f, 0.11171753f, -0.02411972f, -0.23393241f, 
    -0.08720054f, 0.10613406f, 0.01014036f, 0.09352627f, 0.02494339f, 0.00529241f, -0.10613009f, -0.05842198f, 
    -0.08921558f, -0.22166909f, 0.05601563f, -0.03847588f, 0.03390571f, -0.17984138f, 0.07555527f, 0.08303452f, 
    -0.00242964f, -0.01664508f, -0.09383918f, 0.02516584f, -0.20431226f, -0.14239480f, 0.03369397f, 0.07060268f, 
    -0.11125176f, 0.11625301f, -0.18511952f, -0.00187466f, 0.13295238f, 0.04109129f, -0.03469102f, 0.03175954f, 
    0.17479867f, 0.13556810f, 0.20644315f, -0.35527253f, 0.01144104f, -0.08476265f, 0.02461611f, -0.00957476f, 
    -0.12332740f, 0.03097001f, 0.13696675f, 0.12150254f, -0.00742775f, 0.00215698f, 0.27895880f, 0.23349907f, 
    -0.22769904f, -0.16091910f, 0.07258367f, 0.20262250f, -0.04364532f, -0.07498117f, 0.03322053f, -0.09454001f, 
    -0.21700594f, 0.21068652f, -0.06494164f, 0.09570238f, 0.21809624f, -0.07453386f, 0.19508778f, 0.09593437f, 
    -0.02352187f, 0.06072250f, -0.02448414f, 0.03591342f, 0.32173136f, 0.17993127f, -0.19263096f, 0.21674582f, 
    -0.01713284f, 0.06208608f, 0.03643978f, -0.03853736f, 0.02249478f, 0.03995014f, -0.00044517f, 0.04164637f, 
    0.15578443f, 0.09742051f, -0.06021719f, -0.05833541f, -0.01891352f, -0.13618626f, -0.05462402f, -0.00533800f, 
    -0.11612267f, -0.01543820f, -0.01725423f, -0.10264072f, -0.27620986f, 0.20819004f, -0.12492222f, 0.12242801f, 
    0.06090161f, 0.04276006f, 0.02787409f, 0.11562020f, -0.04503432f, -0.16290553f, -0.17677815f, -0.04913261f, 
    0.03450064f, -0.25916153f, -0.35393643f, -0.18874115f, -0.01054622f, -0.07796517f, -0.05921969f, 0.07430374f, 
    0.18456559f, -0.18919443f, -0.03273778f, 0.08298605f, 0.09365717f, -0.41015589f, -0.29360709f, 0.08305769f, 
    -0.00198291f, 0.00243904f, 0.02832092f, -0.07183374f, 0.11822644f, 0.07776471f, 0.06166919f, 0.00564725f, 
    -0.03918117f, 0.00698263f, 0.12574279f, -0.01507572f, -0.02351865f, -0.02085246f, 0.12367222f, 0.03162190f, 
    -0.05080769f, -0.02034280f, -0.04990821f, 0.01709234f, 0.01958487f, 0.19610307f, 0.13708548f, 0.10331127f, 
    0.02726988f, -0.09194019f, -0.08263759f, 0.01649906f, -0.09020957f, -0.05370320f, -0.00487347f, -0.04989399f, 
    0.32206151f, -0.24709049f, 0.20338371f, -0.10552689f, 0.21961503f, -0.05836223f, 0.07157457f, -0.01205540f, 
    -0.05640290f, -0.00517167f, 0.00653652f, 0.03286345f, 0.05834951f, 0.11739194f, -0.19107065f, 0.01912289f, 
    -0.02679671f, -0.00866614f, -0.14414255f, -0.00634618f, 0.18000618f, 0.02586899f, 0.13631752f, 0.04128304f, 
    -0.03476548f, 0.20603433f, -0.15703802f, -0.12366357f, 0.04612644f, 0.05080742f, 0.10040765f, -0.09893117f, 
    -0.01558653f, 0.02216178f, 0.08863994f, 0.15801847f, 0.00486318f, -0.26272747f, 0.12193832f, 0.17895791f, 
    0.02714795f, -0.13201754f, 0.06448334f, -0.04164589f, 0.00247532f, 0.01823509f, 0.09952240f, 0.02706130f, 
    0.19559221f, 0.10414565f, 0.11340697f, 0.27094319f, 0.13026077f, 0.08614080f, 0.07045130f, 0.04305277f, 
    -0.10094620f, 0.01461780f, -0.03217557f, 0.01764870f, 0.26241618f, 0.28980595f, 0.14249587f, 0.12144220f, 
    0.02831175f, -0.02839299f, 0.13743213f, -0.21052040f, -0.03022750f, 0.03522776f, -0.01176738f, -0.00176516f, 
    -0.47163332f, 0.00026595f, -0.20475709f, -0.04993571f, 0.16683839f, 0.08666875f, 0.07506210f, 0.11409425f, 
    0.02880849f, 0.00672362f, -0.10359517f, -0.02677977f, -0.01709391f, 0.12870412f, -0.06711663f, -0.13892882f, 
    0.08245087f, -0.10145541f, 0.02780247f, -0.05874516f, 0.06948122f, -0.06654623f, 0.00430328f, -0.12503850f, 
    0.03494762f, -0.06938802f, -0.10421884f, -0.02126066f, 0.01645765f, 0.07450680f, -0.02758987f, 0.00738073f, 
    0.04952542f, -0.02768076f, -0.11227293f, 0.08333690f, 0.00009104f, -0.08390348f, -0.13645422f, 0.10699004f, 
    -0.01759636f, -0.08332795f, -0.07699502f, -0.05604549f, 0.08999482f, 0.05239866f, 0.02397566f, 0.07606973f, 
    0.03041030f, -0.05365598f, -0.11277957f, -0.02304469f, -0.02358424f, 0.07304907f, -0.01228497f, -0.08034971f, 
    -0.01612085f, -0.11055146f, -0.03013476f, -0.07278794f, -0.07339720f, -0.11162357f, -0.05233794f, -0.01644758f, 
    -0.00173346f, -0.02130961f, 0.01444533f, -0.15648799f, 0.04914778f, 0.04256868f, 0.15781370f, 0.03862572f, 
    0.18425255f, 0.10699385f, 0.25089633f, 0.23901094f, -0.06048995f, 0.04351724f, 0.14033629f, 0.00126778f, 
    -0.02584842f, 0.06860480f, -0.03203744f, 0.10802656f, 0.11801571f, 0.12580454f, 0.02515786f, 0.09403931f, 
    -0.10829078f, -0.06413502f, 0.03014081f, -0.04571452f, 0.11190081f, 0.09892663f, 0.19516344f, 0.18122163f, 
    0.05083910f, -0.27244046f, 0.08435204f, 0.13745844f, -0.07087072f, -0.04107274f, -0.06581017f, 0.06434061f, 
    0.08337656f, 0.16604318f, 0.17095248f, 0.13307555f, -0.11693092f, -0.03004394f, 0.30391940f, -0.08454402f, 
    -0.06645029f, 0.13880518f, 0.27554369f, -0.04684754f, 0.12620890f, -0.11938025f, -0.16442378f, 0.07442858f, 
    -0.02984696f, 0.38609767f, -0.18950894f, 0.27090073f, -0.00566243f, 0.06727252f, 0.00384760f, -0.04150902f, 
    0.09983653f, -0.10992680f, 0.03399467f, 0.09642453f, -0.12544240f, -0.18664160f, 0.16996460f, -0.15821423f, 
    -0.20299727f, -0.04214400f, 0.11888821f, -0.35666591f, 0.13312875f, 0.15950887f, 0.05012394f, 0.11485333f, 
    0.11615890f, -0.09542982f, -0.11344388f, 0.04324240f, -0.00984773f, -0.06661502f, 0.02094412f, 0.10151570f, 
    0.04812443f, 0.29113328f, -0.19300312f, -0.11023965f, 0.00930919f, 0.19168353f, -0.12771054f, -0.35374135f, 
    0.07437088f, -0.11326831f, 0.04942175f, 0.15509115f, -0.15226881f, 0.09169231f, -0.13961186f, 0.16765840f, 
    -0.36776248f, 0.02172930f, 0.10240693f, 0.06473211f, 0.04701550f, -0.04897548f, 0.08879422f, 0.08696590f, 
    -0.05135579f, -0.05029357f, -0.03741623f, -0.19691496f, -0.21813381f, 0.20903683f, 0.11941717f, -0.27298772f, 
    0.03656933f, 0.12379391f, 0.02760617f, 0.07724769f, 0.09279402f, -0.02137782f, 0.09672636f, 0.07021323f, 
    0.00378141f, 0.45574400f, -0.00332341f, 0.23558919f, -0.12763773f, 0.06692632f, 0.03396950f, -0.24020424f, 
    0.05370453f, 0.07851987f, 0.22921391f, 0.16872442f, 0.09211512f, -0.22582790f, 0.25763845f, 0.19573292f, 
    -0.07127209f, -0.06043839f, 0.05612542f, 0.09112994f, -0.03672476f, -0.13194759f, -0.05981717f, -0.18420158f, 
    -0.08002219f, 0.07077882f, -0.12115582f, -0.14117084f, 0.11646400f, -0.06839206f, 0.09974554f, -0.04955500f, 
    -0.07923467f, 0.03209682f, -0.12438954f, -0.21795900f, 0.26875904f, -0.04255041f, 0.09259959f, -0.16233797f, 
    -0.00770898f, 0.22417037f, -0.04592107f, -0.27118587f, 0.04378824f, 0.00411098f, -0.17730269f, 0.04310594f, 
    0.29324466f, 0.13914801f, 0.08138045f, -0.02684567f, -0.05439194f, -0.36247754f, -0.10896551f, -0.14281102f, 
    -0.08531870f, -0.18583137f, -0.03935955f, -0.09331245f, 0.01819423f, 0.28845784f, -0.08628200f, -0.25555009f, 
    0.16740502f, 0.03860353f, -0.14393206f, 0.02671998f, -0.21209964f, -0.28414008f, -0.28593385f, -0.24096064f, 
    0.04862295f, 0.00179117f, -0.04823584f, -0.03601868f, -0.07904709f, -0.05117924f, -0.05702120f, -0.05402210f, 
    0.06279732f, 0.05617495f, -0.07714401f, -0.05144013f, 0.05432848f, 0.01696880f, -0.06988291f, -0.02860164f, 
    0.04055113f, 0.02387470f, -0.03909900f, -0.06993936f, -0.06985322f, 0.04596475f, -0.01037699f, -0.03511074f, 
    -0.04934491f, -0.00839018f, -0.07042508f, -0.00375403f, -0.01951666f, 0.01974383f, -0.05410716f, 0.06081738f, 
    -0.06083104f, 0.04228861f, 0.06137037f, 0.06278973f, 0.04312169f, -0.06679706f, -0.07188055f, 0.02500811f, 
    -0.04574021f, 0.00614380f, 0.01606586f, -0.06954535f, 0.05129149f, -0.00309433f, -0.05767988f, -0.05199756f, 
    0.06304059f, 0.06134218f, 0.04106663f, -0.06566931f, -0.00896957f, -0.07341922f, -0.06652348f, -0.07368909f, 
    0.03482599f, -0.02984864f, -0.04874137f, -0.02658491f, -0.04525772f, -0.00097952f, -0.05998112f, -0.06588744f, 
    -0.00827160f, -0.00483129f, 0.00966481f, -0.03675538f, -0.05886641f, -0.06768533f, 0.02221859f, 0.05456425f, 
    -0.01108654f, 0.00621026f, 0.00672430f, -0.04611224f, -0.05585901f, 0.02955970f, 0.00385939f, 0.02896091f, 
    -0.05466346f, -0.04244519f, 0.02095941f, 0.02979183f, 0.01000741f, -0.01943761f, 0.04764408f, 0.05379826f, 
    -0.07983557f, -0.02868476f, -0.06874218f, -0.03658000f, -0.02628973f, -0.05580903f, 0.03304984f, -0.04250155f, 
    0.03822576f, -0.02867038f, 0.04903004f, -0.00694607f, -0.07382467f, 0.04992100f, 0.04917048f, -0.04804431f, 
    -0.06955400f, 0.01176343f, 0.00858500f, -0.01397467f, 0.05399957f, -0.00819843f, -0.07858485f, -0.04000014f, 
    0.00475550f, -0.00165967f, 0.02717554f, -0.05558579f, -0.06885580f, 0.03047920f, 0.02165703f, -0.04812647f, 
    0.00185425f, -0.06994257f, -0.01160540f, -0.03566104f, -0.00995430f, 0.03572086f, 0.00632444f, 0.06087373f, 
    -0.00709502f, 0.04535903f, -0.04282984f, -0.01027990f, 0.00208214f, -0.06349465f, 0.02997113f, 0.02290229f, 
    -0.03746409f, 0.03384399f, -0.01038173f, 0.01905536f, 0.01633101f, -0.05832926f, 0.05472818f, -0.01420603f, 
    -0.06433074f, 0.05252882f, 0.05743066f, 0.00975279f, 0.05018214f, -0.02868315f, -0.02618513f, -0.06159481f, 
    -0.05008719f, -0.03578633f, -0.00881007f, -0.01354921f, 0.04932743f, -0.03111608f, -0.01826417f, -0.00941106f, 
    -0.06143512f, -0.05281705f, -0.01815439f, 0.04612822f, -0.03104983f, -0.00289512f, 0.01648520f, -0.05518719f, 
    0.07061948f, 0.01299058f, -0.02683299f, -0.02698853f, 0.02799630f, -0.01357735f, -0.03700070f, -0.03292777f, 
    0.07270064f, -0.04905767f, 0.03844982f, -0.03588892f, 0.00501552f, 0.03331791f, 0.04429100f, 0.04979731f, 
    -0.02428317f, -0.07021412f, -0.02137198f, 0.05196178f, -0.05971262f, -0.05620165f, -0.00687925f, 0.03346430f, 
    0.03019585f, -0.06234397f, 0.03916878f, -0.05262687f, -0.01934109f, 0.05008218f, -0.00306338f, -0.03308546f, 
    -0.00794053f, 0.03435479f, -0.05838862f, -0.04201075f, -0.05815471f, 0.03249561f, 0.05026880f, -0.07109080f, 
    0.04321713f, -0.04051437f, 0.05982986f, 0.00651063f, 0.05693019f, 0.04217814f, 0.06470934f, -0.03536619f, 
    0.05239691f, -0.01550379f, -0.07545437f, -0.01447474f, -0.05204854f, 0.03306147f, -0.04558307f, -0.07140507f, 
    -0.04058032f, 0.05926458f, -0.01611507f, 0.03773078f, -0.06064180f, -0.06999297f, 0.02927923f, 0.01165447f, 
    -0.04779295f, 0.03290405f, 0.03445740f, -0.06014363f, -0.01611065f, -0.00175475f, -0.04461906f, -0.05996011f, 
    -0.04412103f, -0.05619499f, 0.02018468f, 0.02169901f, 0.04588174f, -0.06546936f, -0.00225012f, 0.03354655f, 
    -0.01003582f, 0.04560839f, 0.03859673f, 0.03211654f, -0.06612326f, 0.01666002f, -0.07200088f, -0.02560907f, 
    -0.02088278f, 0.01350524f, 0.06186553f, -0.06064212f, -0.05699356f, -0.03878806f, 0.01997872f, -0.04198417f, 
    0.06345700f, -0.04081452f, -0.02206938f, -0.07097528f, 0.04441113f, -0.05447398f, -0.04614197f, 0.01212232f, 
    0.04142135f, -0.03102479f, 0.00051202f, 0.02487588f, 0.01487690f, -0.05515542f, 0.00506060f, -0.05478626f, 
    -0.07799666f, 0.02433695f, 0.04400952f, 0.03132627f, 0.00995299f, -0.06527646f, -0.01186364f, -0.07463102f, 
    -0.05800100f, 0.04777081f, -0.01005380f, -0.02325490f, -0.03479792f, -0.07283577f, 0.02759629f, -0.04413038f, 
    -0.04254502f, 0.04277964f, 0.02522736f, 0.06298286f, -0.00018339f, -0.06268604f, 0.00468147f, -0.05918464f, 
    0.03895723f, 0.02514264f, -0.03242059f, -0.05148178f, -0.04722683f, -0.07525372f, 0.02483299f, 0.03770405f, 
    -0.01753408f, -0.03959996f, -0.06300872f, 0.03932108f, -0.01758956f, -0.04851910f, -0.07321983f, -0.03688106f, 
    0.02967993f, -0.02989748f, -0.03958197f, 0.04478640f, 0.06289533f, 0.06374583f, -0.02972507f, 0.03510486f, 
    -0.05143207f, 0.00817620f, -0.05427776f, -0.01526225f, -0.02218724f, -0.05201826f, -0.04636964f, 0.02203272f, 
    -0.00779386f, -0.03488746f, 0.01566471f, -0.06746478f, -0.04489921f, 0.03609695f, 0.02799286f, -0.07037904f, 
    -0.03039231f, -0.03064330f, -0.07241044f, 0.05608646f, 0.05784925f, -0.07727667f, 0.00303497f, -0.07782333f, 
    0.05075496f, 0.03495862f, -0.04265723f, -0.05012505f, 0.00125659f, -0.00387394f, -0.07169379f, 0.03474626f, 
    -0.00400382f, 0.01472786f, -0.05851840f, -0.01765884f, 0.01317073f, -0.05655947f, -0.05750234f, 0.00098721f, 
    0.04011260f, -0.00160271f, -0.06448946f, 0.04924811f, -0.06229693f, 0.02954812f, -0.05809981f, 0.01817946f, 
    0.04958064f, 0.01262740f, -0.04520135f, -0.06199988f, 0.04923782f, 0.02174438f, -0.05917023f, -0.00030721f, 
    -0.15432662f, 0.02784956f, -0.02107785f, 0.18222527f, 0.03826104f, -0.16892716f, -0.04509425f, 0.21786070f, 
    -0.13299333f, 0.09023654f, 0.11071957f, 0.01366849f, -0.01765030f, 0.04316868f, 0.13329026f, 0.01354481f, 
    -0.02386104f, -0.09498540f, -0.08461257f, 0.13234295f, 0.07880288f, 0.06016983f, 0.02171505f, 0.02048971f, 
    -0.11248789f, -0.03624057f, -0.31856024f, 0.12982421f, 0.04753414f, 0.16963239f, 0.10873822f, -0.01155618f, 
    0.09158429f, 0.09948074f, 0.14159256f, 0.17323607f, 0.31011489f, 0.05374027f, -0.15892586f, -0.34370846f, 
    -0.17962125f, -0.01840990f, 0.03434653f, -0.06935995f, 0.03056910f, 0.15842134f, 0.06738927f, -0.09552862f, 
    0.30840680f, -0.24704260f, -0.18478101f, 0.01711967f, -0.01568084f, 0.08709086f, 0.09786323f, 0.00947915f, 
    0.03519027f, -0.04801005f, 0.01377222f, 0.04472656f, -0.02328960f, 0.25216651f, 0.14965910f, -0.31759179f, 
    -0.07822461f, -0.04545998f, -0.00839580f, -0.05956200f, 0.02119306f, 0.34171999f, 0.06638636f, 0.00101271f, 
    -0.38160679f, 0.24686576f, 0.14060114f, -0.03190737f, 0.17268850f, 0.04716671f, -0.07093130f, 0.02282149f, 
    -0.02746490f, 0.01780433f, 0.17519097f, -0.01380149f, -0.01159106f, 0.12823561f, 0.37651414f, -0.16547222f, 
    0.05736794f, 0.08014028f, 0.15863815f, -0.02394167f, -0.05476521f, 0.09631514f, 0.00405126f, -0.03426038f, 
    -0.08322876f, -0.25281069f, -0.09241365f, 0.05027364f, -0.14765571f, 0.06514931f, 0.19582559f, -0.04210871f, 
    0.03242636f, 0.00801200f, 0.03648522f, -0.03833737f, -0.45295304f, -0.31237665f, 0.09966195f, 0.41290110f, 
    0.05678723f, 0.12941863f, 0.03828987f, 0.02653613f, -0.01868771f, -0.00657961f, -0.03495292f, -0.01058778f, 
    0.37160563f, 0.04238012f, 0.17493547f, 0.25937569f, -0.04860887f, -0.08824068f, 0.10658348f, 0.00894366f, 
    -0.08864349f, 0.13944019f, 0.10713693f, 0.04140901f, -0.12322582f, -0.06614460f, -0.09150757f, 0.06441397f, 
    -0.05097245f, 0.02547579f, -0.07690072f, 0.04739251f, -0.08921971f, 0.08436248f, 0.03814403f, -0.04023821f, 
    -0.07533322f, 0.18442571f, 0.07959240f, 0.04572055f, 0.02050748f, -0.02916248f, -0.09565330f, -0.00294158f, 
    -0.02421107f, 0.01032901f, 0.11647801f, 0.06193599f, -0.15035954f, 0.26216218f, 0.23562533f, -0.02926660f, 
    -0.08476360f, -0.06256901f, -0.05732931f, -0.04976670f, -0.01713259f, 0.06690583f, 0.10829250f, 0.10460120f, 
    -0.48225510f, 0.12436794f, 0.13053206f, -0.04570438f, -0.02846710f, -0.08094483f, -0.04122036f, -0.09458634f, 
    -0.07953406f, 0.11868242f, 0.02366167f, 0.03360818f, 0.08609466f, 0.13954683f, 0.03342743f, 0.04519964f, 
    0.19043750f, -0.05243675f, 0.05539620f, 0.07329585f, 0.09783185f, 0.07286842f, 0.09076491f, 0.19844668f, 
    0.08087917f, -0.25307021f, 0.10258317f, 0.14310497f, -0.03261385f, -0.09858179f, 0.00635363f, 0.05842126f, 
    -0.18160029f, -0.03619410f, 0.03734866f, 0.14488643f, -0.08172845f, -0.14659369f, -0.01644698f, 0.07138839f, 
    0.01587933f, 0.00627337f, 0.03087666f, 0.01239050f, -0.00584702f, 0.00257947f, -0.00117154f, 0.06186577f, 
    -0.28094828f, -0.14262605f, -0.11070153f, 0.18598923f, 0.14323464f, 0.19896975f, 0.08804421f, -0.01578371f, 
    0.29320264f, 0.19394869f, 0.03030881f, 0.16951378f, -0.12796614f, 0.13826059f, -0.01133664f, -0.02632151f, 
    -0.01257693f, -0.09180181f, 0.05369750f, -0.06290296f, 0.02167122f, 0.02108707f, -0.09255758f, 0.05435500f, 
    0.71681154f, -0.07565028f, -0.19358607f, -0.05002882f, 0.17192882f, 0.06001307f, -0.00742090f, -0.10626564f, 
    -0.04440960f, -0.06418397f, 0.02926778f, 0.01872887f, -0.11643415f, -0.05917625f, -0.12839752f, -0.14696671f, 
    -0.08162615f, -0.03436013f, -0.06168308f, -0.05294068f, 0.09631883f, 0.28745005f, 0.02197449f, 0.09516659f, 
    -0.20369834f, -0.06464855f, -0.12166911f, -0.02745664f, 0.01464077f, -0.07534532f, -0.06452357f, 0.02135115f, 
    0.15425749f, 0.09380317f, 0.09280124f, -0.07814349f, -0.11185299f, -0.02247253f, 0.04480734f, -0.11676739f, 
    -0.00884820f, 0.10366624f, -0.12540314f, 0.06642932f, 0.00887416f, 0.04855842f, -0.11241800f, 0.14118028f, 
    -0.10995664f, 0.02203944f, 0.06466182f, 0.21215415f, 0.00439220f, -0.14478399f, 0.14983410f, 0.08586621f, 
    -0.00195237f, 0.03837857f, 0.07589543f, -0.02600242f, -0.35916975f, -0.15736887f, -0.03224880f, 0.07966849f, 
    -0.17307299f, 0.17691867f, -0.07871380f, -0.01645987f, 0.15258504f, 0.07411724f, 0.14182937f, 0.09445131f, 
    -0.28375545f, 0.31785396f, 0.18695828f, 0.07657698f, 0.04539296f, -0.04981835f, 0.07313677f, 0.09366013f, 
    -0.07187592f, 0.03572654f, 0.07268651f, 0.04669817f, -0.31116995f, -0.10014754f, -0.01819114f, 0.09409716f, 
    -0.15725376f, 0.03516994f, 0.01205962f, 0.06941018f, 0.06538084f, 0.04889501f, -0.01032969f, 0.01028769f, 
    -0.00331667f, 0.01555350f, -0.19170052f, -0.14035740f, 0.05596464f, -0.02025650f, 0.11105277f, 0.08673221f, 
    0.00395071f, -0.00907744f, 0.03581076f, 0.12010162f, -0.04454832f, 0.08530757f, 0.21519908f, -0.16752681f, 
    -0.13483770f, 0.11494546f, -0.15807648f, -0.14166248f, 0.11641343f, 0.03968506f, -0.01615824f, 0.15095405f, 
    -0.24496494f, -0.08174340f, -0.04244005f, -0.04014789f, 0.02981552f, 0.00025053f, -0.03819131f, -0.00139988f, 
    0.01609055f, -0.01842399f, -0.09893886f, 0.02244299f, -0.10086683f, 0.15788007f, -0.19078173f, 0.05626414f, 
    0.08710368f, -0.07213627f, 0.01034685f, -0.01323642f, 0.13033499f, -0.02045766f, -0.05446448f, 0.12167495f, 
    0.03573950f, -0.04661192f, 0.02830023f, 0.04853349f, 0.01474270f, 0.04850428f, -0.00342409f, -0.02441372f, 
    -0.01026716f, -0.02816514f, 0.05629282f, -0.06687897f, 0.03222131f, -0.07643083f, 0.02197219f, 0.03298644f, 
    -0.03881861f, 0.00240396f, 0.05814604f, 0.02806417f, -0.03417991f, -0.02084268f, -0.03601252f, 0.00063936f, 
    0.01134299f, -0.05488133f, 0.02764818f, 0.00638896f, 0.05199623f, -0.02764259f, -0.03016086f, -0.05836729f, 
    -0.07624620f, -0.05167758f, -0.03796504f, 0.05669637f, -0.02927856f, 0.06470719f, -0.04319768f, 0.05041827f, 
    0.04203540f, -0.05019749f, -0.04080145f, -0.03003161f, -0.06914005f, 0.01185652f, 0.00524837f, -0.07238548f, 
    -0.01464892f, -0.02078222f, 0.00133087f, 0.03084167f, -0.01099142f, 0.01128387f, 0.03695314f, -0.06040965f, 
    -0.05844675f, 0.05245410f, -0.04955954f, -0.05561906f, -0.07300572f, 0.01687317f, 0.00498044f, 0.02910697f, 
    0.06319694f, 0.00033137f, 0.03622219f, -0.04064424f, -0.07369013f, 0.00489414f, -0.05293524f, -0.02966219f, 
    -0.02665289f, 0.02378685f, -0.03359351f, 0.05414583f, 0.05893195f, 0.02707226f, -0.01248443f, 0.05095834f, 
    0.05473670f, -0.00441045f, -0.06472030f, 0.01644175f, 0.04949488f, 0.05329014f, 0.02410353f, 0.03362445f, 
    -0.05406962f, -0.02713693f, 0.04340507f, -0.03996928f, -0.04538034f, 0.02571147f, -0.05120763f, 0.00784919f, 
    -0.07465308f, 0.04595684f, 0.00828839f, -0.06542818f, -0.04682650f, 0.03421951f, 0.02649588f, 0.04126440f, 
    0.05986100f, 0.05756849f, -0.07583119f, 0.01531806f, -0.06014991f, 0.02389302f, -0.00924107f, 0.02427055f, 
    -0.03183471f, -0.03028625f, 0.00607988f, -0.05115696f, 0.04710865f, -0.06150065f, -0.01114858f, -0.05491687f, 
    0.04200513f, 0.03849468f, -0.05332340f, 0.02538426f, 0.02069964f, -0.02643315f, -0.07199337f, -0.01222081f, 
    -0.04011491f, -0.07185993f, -0.03676106f, 0.00017202f, -0.02697844f, -0.02736360f, -0.02188033f, 0.02538573f, 
    0.06504016f, -0.06479669f, -0.04968130f, 0.05140984f, 0.03154919f, 0.05425880f, 0.06131042f, 0.00905692f, 
    0.05693747f, -0.01906789f, 0.03102367f, -0.07534853f, -0.04892571f, -0.05608966f, -0.06791577f, 0.06536870f, 
    -0.02699021f, -0.06592876f, -0.00820934f, 0.01826613f, 0.06604461f, -0.06528708f, -0.02603213f, -0.06733675f, 
    0.01457720f, -0.03544048f, -0.04807170f, -0.02618866f, -0.06601364f, 0.03573783f, -0.02071293f, -0.01985686f, 
    -0.07660840f, -0.05272640f, 0.06323896f, -0.07124801f, -0.04194273f, -0.05327568f, 0.00504011f, -0.07792671f, 
    0.05573482f, -0.01951174f, -0.07048033f, 0.03339876f, -0.00768968f, -0.03619032f, 0.04211219f, -0.03656006f, 
    0.00098556f, -0.05552473f, -0.02843028f, -0.04441827f, -0.04031815f, 0.06499873f, -0.01187161f, 0.06263756f, 
    0.08678548f, -0.26546180f, 0.20352982f, -0.06842566f, 0.20127182f, -0.12386806f, 0.04529215f, 0.17417264f, 
    -0.05767320f, -0.04686069f, 0.10877862f, 0.18474148f, 0.26607606f, -0.20724398f, 0.17745475f, 0.18053485f, 
    0.16617309f, -0.10125238f, -0.03991970f, 0.08270677f, 0.09663118f, 0.21812370f, 0.11291060f, -0.14207891f, 
    -0.27377602f, -0.03649261f, 0.07680740f, 0.24918279f, 0.04819201f, 0.06749945f, -0.06971161f, 0.09433322f, 
    -0.03229262f, 0.16231208f, 0.01088012f, 0.10307005f, -0.10862308f, -0.00086448f, -0.05731094f, 0.02446707f, 
    -0.27282226f, -0.05838766f, -0.20775551f, 0.06773036f, -0.01350474f, 0.13053718f, -0.03185957f, -0.06617683f, 
    0.05208537f, -0.32485977f, 0.13898696f, 0.21366985f, 0.08825446f, 0.00758893f, -0.08492516f, -0.10657153f, 
    0.19300960f, 0.06923819f, 0.03680331f, 0.02626768f, 0.01676735f, 0.06681104f, -0.41371840f, -0.07334490f, 
    -0.06089155f, -0.15880252f, 0.08246811f, 0.14294662f, 0.02534762f, 0.15774851f, 0.17158996f, 0.08137809f, 
    -0.31255227f, 0.52107871f, -0.15635274f, -0.21547696f, 0.20689075f, 0.17605639f, -0.05119077f, 0.12515827f, 
    -0.21606152f, -0.07798395f, 0.02247431f, -0.13111368f, -0.02916912f, -0.06824236f, 0.15971178f, -0.03407501f, 
    0.04214459f, 0.10707915f, -0.09039410f, -0.09229878f, 0.03865324f, -0.11732797f, -0.11198073f, -0.09201115f, 
    0.02333248f, 0.07397169f, 0.09312367f, 0.44041592f, -0.02540491f, 0.07099301f, -0.07044111f, -0.04305285f, 
    0.01221610f, -0.03687893f, 0.05195538f, -0.09316508f, -0.22101340f, 0.08395893f, 0.19495468f, 0.20302624f, 
    0.05197334f, -0.02596350f, 0.14452110f, 0.11053837f, 0.21568348f, -0.10403802f, 0.07135032f, -0.04416447f, 
    -0.02079348f, 0.17307474f, -0.20508347f, 0.25257441f, -0.03605527f, -0.02275587f, 0.02367968f, -0.13436304f, 
    0.14703469f, -0.02534246f, -0.01810278f, 0.28426376f, -0.26327166f, -0.03672813f, -0.01821505f, -0.04742920f, 
    0.00842862f, 0.01807289f, -0.12529714f, 0.04177345f, -0.06230653f, -0.03823748f, -0.02283471f, -0.05615051f, 
    0.25278082f, -0.03268912f, -0.04055029f, -0.16962354f, 0.03956704f, 0.02535453f, 0.02336070f, -0.03114282f, 
    -0.20356274f, 0.04235476f, -0.20100284f, -0.22000924f, -0.21205826f, 0.10367113f, -0.08309965f, -0.07180586f, 
    -0.02011715f, -0.12211971f, 0.05475347f, -0.02222203f, 0.08940393f, 0.09629738f, 0.00350104f, 0.15573105f, 
    0.12358426f, 0.00587612f, -0.05416215f, -0.15418199f, -0.02399056f, -0.04285549f, -0.13938293f, 0.17065963f, 
    -0.06485309f, -0.09746782f, 0.04460581f, -0.06842455f, 0.20153703f, -0.11202385f, 0.00182069f, -0.16005115f, 
    0.02678287f, 0.07183434f, -0.13117100f, -0.31812072f, 0.16966499f, -0.01850380f, -0.02152838f, -0.15933830f, 
    0.11853641f, -0.38226917f, -0.11775100f, -0.13879080f, 0.08859108f, -0.07193078f, -0.07609693f, -0.01249795f, 
    0.03667050f, -0.04616581f, -0.08061613f, 0.06906530f, 0.02203641f, -0.15831997f, -0.17796206f, 0.02814586f, 
    0.16088486f, -0.03082473f, 0.06694594f, 0.04671444f, 0.15271360f, 0.06636580f, -0.15116709f, 0.00181275f, 
    -0.09601600f, 0.06886856f, 0.17850153f, -0.03132081f, 0.02240917f, 0.10070498f, 0.09044080f, 0.07979773f, 
    0.05549981f, -0.12735985f, -0.09482425f, -0.01615378f, -0.04143662f, 0.11866996f, 0.07209004f, 0.08061456f, 
    0.03194311f, -0.13291346f, -0.06505715f, 0.05855816f, -0.07188462f, -0.06077463f, 0.00819485f, 0.01448715f, 
    0.31204590f, -0.35511711f, 0.04880025f, -0.05272465f, 0.26501626f, -0.05140920f, -0.00817643f, -0.08273978f, 
    -0.05084591f, -0.13141431f, -0.06803909f, -0.14315027f, -0.01829234f, 0.11973768f, 0.02577745f, 0.09861171f, 
    -0.01461785f, -0.11386724f, -0.10915269f, -0.08666290f, 0.03484329f, -0.11699917f, -0.10655550f, 0.03097175f, 
    -0.15232936f, 0.37444824f, -0.23010813f, -0.02084136f, 0.10121297f, -0.01587568f, -0.04132639f, -0.00843082f, 
    0.02251479f, -0.08233091f, 0.21064523f, 0.13277332f, 0.04618957f, -0.10716713f, 0.03601206f, 0.32813817f, 
    0.04416858f, -0.07158867f, 0.00988607f, -0.16504464f, -0.04667875f, 0.04692241f, 0.01737070f, 0.11578454f, 
    0.10316512f, 0.03039401f, 0.02670454f, 0.11823379f, -0.01075815f, 0.07370398f, 0.13884033f, 0.14395005f, 
    0.01262230f, 0.00187047f, 0.09847251f, 0.03029095f, 0.11845730f, 0.05975396f, 0.11358462f, 0.09721821f, 
    -0.05560057f, 0.09553038f, 0.06213851f, 0.06353351f, 0.05568238f, 0.07807025f, -0.02048566f, -0.00564600f, 
    -0.31306627f, 0.15924262f, -0.10179100f, -0.00118635f, 0.06611697f, 0.07516865f, 0.08403147f, 0.12415591f, 
    0.06583611f, 0.01835376f, -0.04799588f, -0.01821092f, -0.28300852f, 0.01163257f, -0.01088117f, -0.05712446f, 
    0.24235114f, 0.14178152f, -0.01537830f, 0.15575640f, 0.14961646f, 0.05875165f, 0.01136546f, -0.01430291f, 
    0.14363760f, -0.05798853f, 0.00656488f, -0.22149965f, -0.09290779f, 0.05817268f, -0.09549741f, 0.00429063f, 
    0.19769926f, 0.03792878f, 0.15155189f, 0.05459806f, 0.07658544f, -0.04451593f, 0.26612070f, 0.04395284f, 
    -0.04962088f, -0.04306759f, -0.17138270f, -0.14110915f, 0.05831774f, 0.14779244f, -0.01685865f, 0.07657887f, 
    -0.04016144f, -0.07304011f, 0.04568065f, 0.06729154f, 0.00173093f, -0.03648831f, -0.03301221f, 0.06460791f, 
    -0.03463964f, -0.04884050f, -0.03546032f, 0.02188526f, 0.03979302f, -0.15537781f, 0.00432103f, 0.01769541f, 
    -0.10645370f, 0.00404607f, -0.08288617f, -0.10747659f, 0.13341077f, 0.09467501f, 0.25128210f, 0.32382905f, 
    0.09423112f, 0.07958291f, 0.19274467f, -0.04509867f, -0.10958993f, -0.08639759f, -0.02212356f, -0.05453202f, 
    0.15481697f, -0.04893812f, 0.08597698f, -0.11545926f, -0.07718907f, 0.20531531f, 0.06307086f, 0.09033576f, 
    0.06461761f, 0.06002283f, 0.06050864f, 0.05802589f, 0.02026918f, -0.08659679f, -0.18215448f, 0.09214756f, 
    0.03910591f, 0.03634414f, 0.21608403f, -0.19181879f, 0.08823187f, 0.00843804f, -0.05843352f, 0.09005059f, 
    0.13736746f, -0.05927753f, -0.06436010f, -0.03830314f, -0.11708290f, -0.09957523f, -0.39164504f, 0.01026012f, 
    -0.12835671f, 0.00828947f, 0.02452804f, -0.12441619f, 0.08948258f, -0.08308899f, 0.08224994f, 0.04661842f, 
    -0.34862536f, -0.21725956f, -0.11750434f, 0.02323791f, 0.08138573f, 0.03501854f, 0.13368043f, -0.06651057f, 
    -0.10949656f, -0.16692857f, -0.17035100f, -0.08249372f, 0.03427368f, -0.00334682f, 0.22715245f, 0.14132026f, 
    -0.09139507f, -0.19088250f, -0.00095455f, -0.07408828f, 0.18408532f, -0.11446658f, 0.11459179f, 0.14664914f, 
    0.25580636f, -0.16350828f, 0.04026705f, 0.23410800f, -0.06383781f, -0.10189349f, -0.08404470f, 0.02527581f, 
    0.12426720f, 0.03431861f, 0.05635890f, 0.09412997f, -0.01355378f, 0.15972863f, -0.31111088f, 0.38409430f, 
    0.12971458f, 0.08744137f, 0.01064768f, -0.06696267f, 0.01923380f, -0.10124405f, 0.15417787f, 0.14790301f, 
    -0.04346587f, 0.06716227f, -0.14855979f, -0.25013033f, 0.12496917f, 0.10060987f, 0.01001624f, -0.02836110f, 
    0.13784264f, 0.01700911f, 0.14118449f, 0.18618245f, 0.35298759f, 0.02409089f, -0.11096067f, -0.33196464f, 
    0.09774820f, 0.12693071f, 0.04451443f, 0.08180039f, 0.03844827f, 0.01354494f, -0.03645066f, 0.01602029f, 
    -0.08177524f, 0.14386876f, -0.19300440f, -0.24353573f, -0.06545785f, -0.02940442f, 0.17138179f, 0.12109554f, 
    0.04948935f, 0.00484137f, -0.03195412f, 0.06948037f, -0.02536851f, -0.00021050f, -0.01238870f, -0.21692866f, 
    0.05119384f, 0.17214894f, 0.03162068f, 0.15901117f, 0.07521599f, 0.00012876f, 0.05203309f, -0.04808616f, 
    0.18532492f, -0.39751834f, -0.08347961f, 0.25366548f, -0.02511013f, 0.21113867f, 0.04725512f, 0.05333958f, 
    0.06290063f, -0.03989663f, 0.25577074f, 0.18098043f, 0.39557561f, -0.16843610f, 0.26339996f, -0.01440261f, 
    0.04048751f, -0.15557958f, -0.12431580f, 0.11379343f, 0.09186631f, 0.13624942f, 0.14692949f, 0.08167522f, 
    -0.02700051f, -0.22185513f, 0.11184692f, 0.03864631f, -0.02734222f, 0.00539256f, -0.02450292f, -0.06443596f, 
    0.04699025f, -0.07807069f, 0.01838086f, 0.02284082f, -0.11480207f, -0.28450933f, 0.06433510f, 0.14926134f, 
    -0.34921038f, -0.07056447f, -0.18673040f, 0.04461057f, 0.08423995f, 0.16595939f, 0.23238285f, 0.19731173f, 
    -0.07209686f, -0.08257368f, -0.00922929f, -0.04656253f, -0.02060670f, 0.02401295f, -0.03404837f, 0.02595012f, 
    0.03815389f, 0.00656053f, -0.03345934f, 0.04917561f, -0.01488402f, -0.03993801f, -0.07990575f, -0.03263518f, 
    -0.01837352f, 0.03450255f, -0.09669547f, -0.09546137f, -0.08492482f, -0.07409122f, -0.07128564f, 0.01683290f, 
    0.01594109f, 0.02427110f, -0.05408511f, -0.09145959f, 0.03002216f, -0.01959673f, 0.00322798f, 0.00440740f, 
    -0.00949184f, 0.02340989f, -0.05935654f, -0.07209889f, 0.01093106f, 0.03746039f, -0.05714671f, -0.08126203f, 
    -0.01474363f, -0.03466922f, 0.00991265f, -0.05584723f, -0.07038251f, -0.01725718f, -0.06887345f, 0.01807294f, 
    -0.04325378f, 0.04208380f, -0.04908494f, -0.09943496f, -0.02885742f, -0.06571586f, 0.03831528f, -0.01304683f, 
    0.03276158f, -0.09214609f, -0.04495106f, 0.03450685f, 0.02663830f, -0.01213163f, -0.00878276f, -0.02052597f, 
    -0.07492101f, 0.03077993f, -0.06845628f, -0.02315636f, -0.08985375f, 0.04873429f, 0.00885084f, 0.05106407f, 
    -0.01073754f, 0.00941206f, 0.00974725f, 0.01852000f, 0.02430988f, -0.02030358f, -0.00126334f, 0.02834817f, 
    -0.09877389f, -0.01213496f, 0.00258218f, -0.04672417f, -0.05675370f, -0.08140557f, -0.04004026f, -0.06982235f, 
    -0.03144509f, 0.03918079f, -0.02100478f, -0.07857945f, -0.02296150f, -0.03887097f, -0.05767601f, -0.09611274f, 
    -0.04111769f, -0.04683597f, -0.08531564f, 0.00742683f, -0.01318178f, 0.04549865f, -0.02101359f, -0.02962472f, 
    -0.06077401f, -0.02818007f, -0.00236723f, -0.08266231f, -0.03485686f, 0.01788553f, -0.05595000f, 0.02735799f, 
    -0.02243686f, -0.02616631f, 0.02216814f, 0.00072032f, 0.01351240f, -0.01933121f, -0.04014408f, -0.08634990f, 
    0.04165672f, -0.07250033f, -0.02721583f, 0.03746711f, -0.09755911f, -0.09317992f, -0.05388209f, -0.04551601f, 
    0.01584599f, -0.01303603f, -0.00360240f, -0.08805583f, -0.05889051f, -0.00926044f, 0.00853796f, 0.04396444f, 
    0.03793881f, -0.04468340f, -0.07197464f, -0.09703407f, -0.02263898f, -0.03688501f, -0.08233092f, -0.01451132f, 
    -0.08063679f, 0.05557333f, -0.02583036f, -0.00962533f, -0.07335981f, -0.04910034f, 0.01853252f, 0.00344011f, 
    -0.05509055f, 0.01056442f, 0.03641803f, 0.05354243f, -0.00285499f, 0.03890512f, 0.03420891f, -0.06965902f, 
    0.00016999f, -0.07768788f, -0.07709663f, -0.04505853f, 0.03941770f, -0.02599639f, 0.01554844f, -0.06149688f, 
    -0.03788117f, -0.07638748f, -0.06457276f, -0.06080525f, 0.01627642f, 0.05637576f, -0.07554301f, -0.08738871f, 
    -0.09065848f, -0.02552285f, -0.00923324f, 0.04631409f, -0.04311263f, -0.00188884f, -0.04377577f, -0.00537070f, 
    -0.06727536f, -0.02342950f, -0.00229548f, -0.08606066f, -0.05900196f, -0.02057006f, 0.02498641f, -0.04653837f, 
    0.10511781f, -0.03501903f, -0.14083046f, 0.10415713f, 0.13967858f, 0.03344076f, -0.01128142f, -0.00387073f, 
    -0.11860353f, 0.01482908f, -0.12960148f, -0.05360925f, 0.07795449f, -0.09797566f, 0.06071257f, -0.01538329f, 
    0.03001470f, 0.07820503f, 0.13161270f, 0.04185014f, 0.04197537f, -0.06043626f, 0.12819111f, 0.04431313f, 
    -0.09670405f, 0.12214812f, -0.21245098f, 0.09676962f, -0.12193786f, 0.00474049f, 0.05461199f, -0.22699971f, 
    0.08337682f, 0.05297779f, 0.09142188f, 0.03445103f, 0.00776284f, -0.06403697f, -0.10506585f, -0.11513302f, 
    -0.08127870f, 0.01052632f, 0.04955835f, 0.01691254f, -0.01649630f, 0.10154871f, -0.00607904f, -0.01714402f, 
    0.52253723f, 0.28871155f, 0.07914802f, -0.21072488f, -0.09936554f, 0.08252308f, -0.02576818f, -0.00176231f, 
    0.02211685f, 0.01215045f, 0.04252934f, -0.00896463f, -0.25906208f, -0.24439590f, -0.17514297f, -0.15347496f, 
    -0.02311752f, -0.00048128f, -0.02965495f, 0.00947314f, -0.03941742f, 0.11474491f, 0.16316795f, -0.00193677f, 
    -0.28436756f, -0.06562245f, 0.26627564f, 0.16367562f, 0.08688225f, 0.21257508f, -0.01549519f, -0.07514609f, 
    0.05540431f, 0.01774814f, 0.04750225f, 0.00651232f, 0.03370589f, -0.03257960f, 0.10222353f, -0.04884556f, 
    -0.03014973f, 0.07942680f, 0.13112678f, 0.05676703f, -0.07360768f, -0.02721310f, 0.00703380f, -0.05449564f, 
    0.26908281f, 0.30592346f, 0.21034032f, 0.28052893f, -0.14722052f, -0.07871513f, 0.08308153f, 0.02738094f, 
    0.04503044f, -0.12161611f, -0.03546042f, -0.13418812f, 0.00229820f, -0.09529639f, 0.05872379f, 0.33446220f, 
    -0.09442184f, -0.03733953f, -0.13913424f, 0.31323412f, -0.02804192f, -0.01588360f, 0.09235379f, 0.06434603f, 
    0.05830399f, -0.25163445f, 0.24033059f, -0.13248785f, -0.02984736f, 0.04916773f, -0.01774223f, 0.00926232f, 
    -0.08160125f, -0.03367566f, 0.13415675f, 0.04017869f, 0.39281121f, 0.35239762f, -0.02752773f, 0.23340431f, 
    -0.07779448f, -0.19838916f, 0.08320379f, 0.01103697f, -0.10280795f, -0.08565575f, -0.01594394f, -0.06356269f, 
    0.00127706f, 0.16034336f, -0.01596892f, -0.18532296f, 0.02419342f, -0.03580777f, 0.08169316f, -0.06133853f, 
    -0.03065606f, 0.11364534f, -0.09147246f, -0.03024016f, -0.25962526f, 0.18407577f, -0.26460764f, 0.03941028f, 
    -0.09576646f, 0.00838271f, -0.08051312f, -0.05582296f, -0.05853055f, 0.13548015f, -0.06543934f, 0.04932349f, 
    0.12296192f, 0.06725042f, -0.20769991f, -0.18931191f, -0.00737929f, -0.09571193f, 0.07516544f, -0.03290063f, 
    -0.01614041f, 0.06851906f, 0.03490140f, -0.04987626f, 0.06765514f, 0.25251940f, 0.04043901f, 0.08297940f, 
    0.08716676f, 0.14382748f, 0.24764356f, -0.05927391f, 0.04907165f, -0.02198537f, -0.05771762f, 0.03142285f, 
    -0.27833158f, 0.24225748f, -0.05380622f, 0.13738714f, 0.05461583f, 0.07654535f, 0.03919889f, 0.07550049f, 
    -0.00155739f, 0.11022371f, 0.07823784f, -0.03358429f, -0.14637728f, 0.13464601f, 0.05099519f, -0.05626481f, 
    -0.07099923f, 0.16720128f, -0.01970581f, 0.11296953f, 0.16945593f, 0.14113714f, 0.14534557f, 0.08937977f, 
    -0.04755957f, 0.02262520f, -0.24685349f, 0.10396940f, 0.04024930f, 0.03464805f, 0.10932134f, 0.03448210f, 
    0.03943889f, 0.01429024f, -0.02384069f, 0.00598833f, 0.19158910f, 0.21813767f, 0.21209188f, -0.38541627f, 
    -0.18551655f, -0.14969240f, -0.04682690f, -0.02742585f, -0.08935897f, 0.07317041f, -0.19530095f, -0.05663016f, 
    0.25551865f, -0.23101215f, -0.19723353f, -0.07640301f, -0.10348321f, -0.12515144f, -0.03157356f, -0.05917864f, 
    -0.03965973f, -0.04237943f, -0.02538736f, 0.01929430f, -0.06990916f, -0.03638525f, 0.05585148f, -0.16814572f, 
    -0.11616857f, -0.08090790f, -0.06727235f, -0.07390115f, -0.15777627f, 0.19248554f, -0.03463740f, -0.04599277f, 
    -0.10619269f, 0.02929753f, -0.00444593f, -0.02924592f, -0.07112274f, -0.05034618f, 0.07838276f, 0.03486499f, 
    0.11552071f, 0.04538369f, 0.19525421f, 0.04603566f, 0.03851930f, 0.37735918f, 0.25318199f, -0.29161763f, 
    0.12340565f, 0.04459254f, 0.03824176f, 0.01129781f, 0.02791487f, 0.19090296f, -0.04505906f, 0.06497217f, 
    -0.09038440f, -0.33413014f, 0.19699463f, -0.13583635f, 0.07068046f, -0.02021022f, -0.01240108f, -0.08135416f, 
    0.03331221f, -0.06082494f, 0.11664391f, 0.11203974f, -0.50509185f, -0.22845727f, 0.04988838f, 0.22598113f, 
    0.04483849f, 0.03342532f, -0.03794103f, -0.23144571f, -0.05595849f, -0.04848594f, -0.02021602f, 0.05598633f, 
    0.42387417f, 0.10903274f, 0.30017295f, 0.29965174f, 0.07329489f, -0.02885205f, 0.12923203f, 0.13305034f, 
    -0.08480296f, 0.19426233f, 0.00902740f, 0.10165706f, -0.20907092f, -0.06370759f, 0.09481876f, 0.17751601f, 
    -0.00057356f, 0.05926138f, 0.18561405f, 0.04058059f, -0.10506304f, 0.14176722f, -0.06328694f, 0.00117864f, 
    -0.24681947f, 0.24039018f, -0.03729297f, 0.15572222f, 0.08604144f, -0.25991297f, -0.06447846f, -0.05671965f, 
    0.16126569f, 0.08650842f, 0.11401820f, 0.09488197f, 0.19802694f, 0.31475434f, 0.09652197f, 0.08814247f, 
    -0.12618357f, 0.09904489f, -0.17348179f, -0.01070230f, 0.04208268f, 0.01617309f, 0.03018367f, 0.01466220f, 
    -0.26141047f, 0.11412563f, 0.20685384f, 0.09084608f, -0.16500044f, -0.13350402f, -0.13656393f, -0.18077251f, 
    -0.11480339f, 0.03757317f, -0.05861019f, 0.02385812f, -0.19836202f, 0.08196210f, -0.25041938f, 0.03750397f, 
    0.02547765f, -0.07756593f, -0.13275339f, 0.10301639f, -0.03617878f, 0.07386350f, -0.06381517f, 0.18704861f, 
    0.12380783f, 0.15662949f, 0.45977950f, 0.25392413f, 0.04513226f, -0.01764416f, 0.04991554f, -0.11215977f, 
    -0.03238294f, 0.04061897f, 0.06026633f, 0.17939630f, -0.13467325f, 0.36909550f, 0.07523672f, 0.02137044f, 
    -0.03990341f, -0.10171594f, -0.14818959f, 0.09535547f, -0.15383291f, 0.02707375f, 0.08340897f, 0.06660180f, 
    -0.00250147f, -0.17449741f, 0.00460923f, 0.05174936f, -0.14892378f, -0.03484316f, 0.01691401f, 0.04272230f, 
    -0.01825787f, -0.01978499f, 0.16400804f, 0.07426334f, -0.00812130f, -0.22024025f, -0.27111802f, 0.02949977f, 
    0.03518632f, 0.05909134f, 0.09633277f, 0.00603161f, -0.01255873f, -0.10069621f, -0.07579967f, 0.00799398f, 
    -0.10934601f, 0.00589853f, -0.27682877f, 0.16702683f, 0.04328033f, 0.13060346f, 0.01598139f, 0.04486275f, 
    -0.09815134f, -0.16008128f, -0.07422427f, 0.04166559f, -0.13527903f, -0.16292903f, -0.07398243f, 0.03784062f, 
    0.04648025f, -0.06278500f, 0.00322641f, 0.00964767f, -0.02840703f, 0.09154751f, 0.07118630f, 0.21137147f, 
    -0.08321011f, -0.28399637f, -0.01708156f, -0.06802408f, 0.05097465f, -0.07680722f, -0.08194993f, 0.03774637f, 
    0.06367494f, 0.14220721f, -0.12832083f, -0.11846017f, -0.05773945f, -0.13460387f, -0.39242598f, -0.04899243f, 
    0.08522303f, 0.03916646f, -0.15803371f, 0.01541891f, 0.09413428f, -0.07834070f, -0.07842481f, -0.03194528f, 
    -0.17918779f, -0.04451703f, -0.37457818f, -0.28982443f, 0.18655124f, -0.01985649f, 0.01273082f, 0.01381523f, 
    -0.08192649f, -0.02384675f, -0.02393933f, 0.03663788f, 0.11223843f, 0.00307033f, -0.27413654f, -0.47735158f, 
    0.02762722f, 0.08755571f, -0.07140140f, 0.06759592f, 0.06004147f, 0.00619953f, 0.04497390f, 0.08801271f, 
    0.06581823f, 0.32352111f, -0.00070950f, -0.22495869f, -0.05578550f, -0.10650767f, -0.13961928f, -0.01000874f, 
    0.11234434f, 0.07580890f, 0.06148483f, 0.03658750f, 0.07225968f, -0.12316650f, -0.06886752f, -0.08917625f, 
    -0.08735257f, -0.02250099f, 0.00994960f, 0.12115012f, -0.01392584f, -0.12853442f, 0.01109674f, -0.11602277f, 
    0.00059968f, -0.18120666f, -0.07052805f, 0.04136885f, 0.13684814f, -0.06924395f, 0.08635845f, -0.00498006f, 
    -0.03725294f, -0.05055786f, -0.06781448f, -0.05581718f, 0.18278456f, -0.16599792f, -0.14690930f, -0.02911010f, 
    0.02795633f, 0.00739584f, -0.04716018f, -0.03327034f, -0.01392487f, -0.10952613f, -0.00483656f, -0.03360509f, 
    -0.06478284f, -0.17805284f, -0.08220252f, -0.05355394f, 0.09096144f, -0.00423390f, 0.11144001f, -0.05827926f, 
    -0.01873783f, -0.10720880f, -0.16579895f, -0.07909468f, -0.08821043f, -0.01738493f, -0.10990691f, 0.08788534f, 
    0.05649490f, -0.09370132f, -0.07453891f, -0.03205442f, -0.03798250f, -0.08087268f, -0.24745780f, -0.15585171f, 
    0.20067680f, 0.09278382f, 0.12812012f, -0.25605854f, -0.20981991f, -0.14909613f, -0.05614670f, 0.19529641f, 
    0.25661305f, 0.06530851f, 0.09889935f, -0.03526345f, 0.24002030f, -0.08145269f, 0.02443842f, 0.07855391f, 
    -0.00605184f, 0.06789259f, 0.11284587f, -0.05459096f, 0.09754191f, -0.17765725f, -0.01743557f, 0.02619822f, 
    -0.00954449f, -0.04878458f, 0.21477818f, -0.07150193f, 0.06242011f, -0.05204323f, -0.05431065f, 0.06839465f, 
    -0.03068651f, -0.15872364f, -0.09134906f, 0.04445130f, -0.13771647f, -0.19322017f, 0.07749274f, -0.02261606f, 
    -0.12306120f, -0.08480152f, -0.07467540f, 0.03569203f, -0.03213153f, 0.01833779f, -0.00205101f, 0.11721157f, 
    -0.53095978f, 0.32603195f, 0.28672957f, 0.10498052f, -0.13084532f, 0.00315812f, 0.08980396f, 0.01440656f, 
    0.04595158f, 0.02450697f, -0.14529344f, -0.07796446f, 0.10709544f, -0.01922786f, -0.08423823f, 0.14965563f, 
    -0.09877237f, -0.09600975f, 0.05769983f, -0.05547182f, 0.10137004f, -0.25396222f, -0.03266985f, 0.01441951f, 
    0.30233738f, 0.03694385f, 0.07135896f, 0.10673861f, 0.05326663f, 0.03430974f, -0.10894846f, 0.15602408f, 
    -0.01194795f, -0.01910028f, -0.12444379f, -0.08399542f, 0.05990870f, 0.15925311f, -0.06178633f, 0.15432718f, 
    -0.05482233f, -0.01983585f, 0.02201831f, 0.02281646f, -0.00898486f, 0.04632244f, -0.07122443f, -0.07653878f, 
    0.00799149f, 0.13084568f, 0.12430812f, 0.03939948f, 0.09888572f, 0.09513133f, -0.12124707f, -0.00073004f, 
    0.01932347f, -0.02209358f, -0.00836195f, 0.02126149f, 0.23178141f, 0.24171582f, 0.03710233f, -0.23399068f, 
    -0.01644862f, -0.16273761f, 0.16242543f, 0.25132421f, -0.03382960f, 0.05650802f, -0.02897394f, 0.02161250f, 
    -0.14540090f, 0.02450133f, -0.12682733f, -0.18001997f, -0.11872015f, 0.05214772f, 0.24473044f, 0.01890339f, 
    0.14364545f, -0.03068526f, -0.14450616f, 0.16402462f, 0.00289476f, -0.03919174f, 0.16089612f, -0.07016741f, 
    0.02179436f, 0.04788150f, -0.06060445f, 0.04800068f, 0.03152940f, -0.07157350f, 0.07680994f, 0.02736436f, 
    0.04355535f, -0.21409297f, 0.01049745f, -0.01156050f, 0.05699521f, 0.18500397f, 0.08807279f, -0.11164824f, 
    0.06587226f, -0.00609785f, -0.02310280f, -0.16132340f, 0.02624989f, -0.13998251f, -0.01558654f, 0.02829817f, 
    -0.01784043f, -0.11187544f, 0.06162245f, 0.10388846f, 0.03956491f, 0.09329406f, -0.04922167f, -0.09496281f, 
    0.25144714f, 0.05418537f, -0.08948606f, -0.02464280f, -0.11938436f, -0.08104780f, 0.05484947f, 0.04904794f, 
    -0.02093969f, -0.09248205f, 0.09951618f, -0.01330771f, -0.00589533f, -0.15577611f, 0.03222235f, -0.18135077f, 
    -0.17081508f, 0.10023858f, -0.03136136f, -0.04061866f, -0.10953134f, -0.04806337f, 0.17529345f, -0.08917232f, 
    0.01007766f, -0.04693467f, 0.03311767f, 0.01090629f, -0.06078871f, -0.03657476f, -0.07315248f, 0.05759007f, 
    -0.02314561f, -0.01150589f, -0.00737280f, -0.02870299f, 0.04245046f, -0.00267546f, 0.04069914f, 0.02741322f, 
    -0.01331786f, -0.01375435f, -0.00180577f, -0.02234161f, -0.07230939f, -0.02560640f, -0.03382104f, 0.03509175f, 
    -0.04595035f, 0.03803156f, -0.08042169f, -0.00914316f, 0.04309679f, 0.00609551f, -0.05827002f, 0.00174277f, 
    -0.00133955f, 0.01946360f, -0.00814915f, 0.01038076f, 0.00757619f, 0.01864524f, -0.06013089f, -0.03068976f, 
    -0.05802009f, 0.00330764f, -0.01453508f, -0.01267661f, -0.06323335f, 0.00993249f, 0.01672132f, -0.06331259f, 
    -0.02051432f, 0.00550538f, 0.02773859f, -0.00755013f, 0.06813817f, 0.00442325f, 0.02892272f, -0.06605890f, 
    0.03591479f, 0.04351028f, 0.06072827f, -0.04360052f, -0.02121845f, -0.00245641f, -0.07130142f, 0.02060882f, 
    -0.03263495f, 0.05877401f, -0.02033062f, 0.03815860f, 0.03420305f, -0.01166349f, -0.04976292f, 0.06183516f, 
    -0.08447848f, -0.00780692f, 0.02819992f, -0.05922583f, 0.00370882f, 0.04315560f, -0.07095502f, -0.01722364f, 
    0.01806309f, 0.05137939f, 0.01643805f, -0.02547711f, -0.07250165f, -0.03889075f, -0.00919843f, -0.02022360f, 
    -0.07952876f, 0.02525885f, 0.04077485f, 0.04998437f, -0.02073609f, 0.05490920f, -0.07420714f, -0.03763659f, 
    -0.04454830f, -0.01988243f, 0.01231157f, 0.01486760f, 0.03956270f, 0.01636755f, -0.01819639f, -0.05070632f, 
    0.05038565f, 0.01758542f, -0.07674777f, -0.04805635f, 0.04524758f, -0.01086714f, -0.04394509f, 0.00990751f, 
    -0.07201848f, -0.03882717f, 0.06258625f, -0.07287863f, -0.00370672f, -0.05118052f, 0.00781433f, 0.05466403f, 
    0.00177498f, -0.03200462f, 0.03709358f, -0.04878176f, -0.02711456f, -0.01158712f, 0.00163049f, -0.02341608f, 
    -0.04637476f, 0.01679049f, -0.04654585f, -0.05185512f, 0.05540257f, -0.07511690f, 0.01509449f, -0.01008627f, 
    0.04495456f, -0.05584736f, 0.04534161f, -0.00956605f, 0.03027770f, 0.03510406f, 0.02617696f, -0.01202001f, 
    -0.06005664f, 0.01580797f, -0.05143265f, -0.02827373f, -0.04781799f, -0.07984736f, 0.01891727f, 0.05381114f, 
    0.04648359f, -0.00212954f, 0.04413845f, -0.06459504f, -0.04737777f, -0.03559575f, -0.00836309f, -0.02744545f, 
    -0.03743130f, -0.07180551f, 0.02340024f, 0.01537899f, -0.08460838f, 0.03465382f, -0.02125817f, -0.03988042f, 
    0.02531701f, -0.05923721f, 0.04307894f, -0.02958983f, -0.05055390f, -0.03558107f, -0.05121071f, -0.01344155f, 
    -0.00172655f, -0.04613589f, -0.06234840f, 0.00675014f, -0.02661152f, 0.04915584f, -0.04252808f, -0.05738906f, 
    0.03835560f, -0.02422428f, -0.01540477f, 0.03326052f, -0.06041050f, -0.06989358f, 0.04956828f, -0.07612775f, 
    -0.32109627f, 0.08783831f, 0.00606695f, -0.08154855f, -0.14816067f, -0.02535869f, 0.09600399f, 0.10841776f, 
    0.00341691f, 0.00831907f, 0.05326058f, -0.04150821f, -0.11783643f, -0.20194888f, -0.11862431f, 0.05805189f, 
    -0.07525684f, 0.01493648f, 0.11752249f, -0.05737467f, 0.19981323f, 0.01024147f, 0.15030579f, 0.06431960f, 
    -0.06597106f, -0.29946947f, 0.07777378f, -0.01061609f, 0.08276951f, -0.06249474f, -0.00615507f, -0.02172563f, 
    -0.00637783f, 0.06667607f, 0.05466487f, 0.02229006f, 0.53505969f, 0.22974463f, 0.23428063f, 0.13003281f, 
    -0.00459429f, 0.03869036f, -0.02757821f, -0.02516654f, 0.04560848f, -0.02091668f, -0.00313879f, 0.01020691f, 
    0.34184679f, 0.17395209f, -0.03438807f, 0.10837815f, 0.14063700f, 0.20017555f, 0.08256979f, 0.04631293f, 
    -0.06720799f, -0.02562592f, -0.02574515f, -0.09652547f, 0.14243013f, -0.05455269f, -0.11432135f, -0.04427734f, 
    0.02727353f, -0.09422677f, 0.00094868f, 0.01629695f, -0.05204067f, -0.05929409f, 0.15908386f, 0.00124291f, 
    0.16052435f, -0.21160291f, 0.12792499f, -0.11355141f, -0.09270592f, 0.07596823f, 0.24862705f, 0.05511259f, 
    0.13533536f, 0.24249996f, 0.00851275f, -0.03906745f, 0.31101316f, 0.12743998f, 0.01595727f, 0.13107547f, 
    -0.10823726f, 0.05939848f, 0.10207232f, -0.01382301f, -0.01107432f, 0.02846982f, 0.12494885f, 0.10324933f, 
    -0.03857638f, 0.11395031f, 0.18384302f, 0.16399089f, 0.09065720f, -0.16483629f, -0.01348514f, -0.02824822f, 
    0.02103892f, 0.01780084f, -0.15137157f, 0.11260695f, 0.10134767f, 0.17335443f, 0.15864895f, -0.04511086f, 
    -0.14418179f, -0.08943763f, -0.08019736f, -0.18457901f, 0.05627733f, 0.07760599f, 0.03867456f, 0.17894067f, 
    -0.24850334f, 0.05643735f, -0.06503722f, -0.20607632f, 0.08060328f, 0.20132637f, 0.21649568f, -0.08158438f, 
    0.03432382f, 0.10627860f, -0.05012126f, 0.08336261f, -0.05038603f, -0.04158623f, 0.19414516f, 0.08199683f, 
    -0.07471666f, -0.10359623f, 0.21234077f, 0.01600748f, 0.01379831f, -0.03004247f, 0.05351909f, -0.01082943f, 
    -0.07668328f, -0.02631453f, -0.00869421f, 0.20696172f, 0.18500729f, 0.04542374f, 0.18238041f, 0.06726456f, 
    0.11217953f, 0.12345771f, -0.02966781f, -0.04376189f, 0.38504303f, -0.00457394f, -0.12840246f, 0.10993272f, 
    -0.00627374f, 0.00894039f, 0.06942275f, 0.09628566f, -0.06045649f, -0.00451082f, -0.13222326f, 0.04054805f, 
    0.28317946f, 0.19671336f, 0.09000215f, 0.00343046f, 0.01732797f, 0.04549095f, 0.07137612f, -0.09485300f, 
    0.04925144f, 0.01161714f, -0.04335415f, -0.15630166f, -0.28814068f, 0.12115710f, -0.20048445f, -0.01558700f, 
    -0.09854895f, 0.01404649f, 0.00694990f, 0.02484860f, -0.04511680f, -0.23195016f, -0.00054925f, -0.12628560f, 
    0.22482505f, -0.30083933f, 0.00330404f, 0.12430269f, 0.14719170f, -0.06744776f, -0.05802074f, 0.02190035f, 
    0.12080704f, 0.18141018f, 0.00888499f, 0.16541541f, 0.32528400f, -0.09853846f, 0.13205561f, -0.01161512f, 
    0.03127301f, -0.15181153f, -0.09391659f, 0.09192392f, 0.03820601f, 0.04312514f, 0.05592513f, -0.10045098f, 
    0.05293598f, 0.11505347f, -0.11783615f, 0.04144022f, 0.03768552f, 0.09324729f, -0.00660349f, -0.03193934f, 
    -0.04126220f, 0.04717357f, 0.04454162f, 0.12309044f, -0.15631330f, 0.07084221f, 0.06466693f, -0.01299994f, 
    -0.04557377f, 0.14796516f, -0.02831738f, -0.14442752f, -0.04527077f, -0.05760005f, -0.11163057f, 0.08393962f, 
    0.19157057f, 0.17171395f, 0.23650169f, 0.06619449f, 0.04476827f, 0.17043158f, 0.11803640f, 0.08401903f, 
    -0.00547213f, -0.08437109f, 0.08455120f, 0.01656592f, -0.08763346f, 0.11369877f, 0.00335725f, -0.00242003f, 
    -0.03764657f, -0.11000223f, 0.06991173f, -0.19233510f, -0.05280027f, 0.02560805f, 0.05809024f, -0.04235094f, 
    -0.22808853f, 0.32699364f, -0.14692739f, -0.26366013f, -0.02426592f, -0.05244650f, -0.03734984f, 0.02542663f, 
    -0.16676298f, -0.21097261f, -0.06620744f, 0.04583247f, -0.00761552f, -0.06552927f, 0.17582349f, -0.26893428f, 
    -0.08640888f, 0.12429914f, -0.13907260f, 0.01889124f, 0.06805073f, -0.14822170f, -0.31871015f, -0.14132397f, 
    -0.03690542f, 0.11802707f, 0.06434259f, 0.25415078f, -0.16381565f, 0.20891389f, -0.03003003f, 0.18010174f, 
    -0.03061448f, -0.02498322f, -0.04351124f, -0.19946592f, -0.11648425f, -0.03336074f, 0.00790049f, 0.28930548f, 
    -0.01204069f, 0.05696883f, 0.02839778f, 0.23550051f, 0.04074733f, -0.00608853f, -0.01924661f, -0.04443687f, 
    0.05296423f, 0.16582933f, 0.05162904f, 0.35105556f, -0.09428346f, -0.08180365f, -0.15845722f, -0.29822332f, 
    0.03894352f, 0.02670286f, -0.05008527f, 0.20514555f, 0.00168033f, -0.09901386f, -0.13375990f, 0.02009388f, 
    0.03476299f, 0.08096862f, -0.18155244f, 0.12869833f, -0.06840827f, -0.01108059f, -0.12076936f, -0.04993827f, 
    0.23123294f, 0.13757618f, 0.01932368f, -0.52554834f, 0.07228187f, -0.02225810f, -0.07062650f, -0.13154392f, 
    -0.27224249f, 0.09983929f, -0.25874174f, -0.10557117f, -0.33442914f, 0.15659685f, 0.17309561f, -0.19578426f, 
    0.04151183f, -0.01516753f, -0.11921041f, -0.26867494f, 0.10061447f, -0.04199823f, -0.18383630f, 0.08430516f, 
    -0.13134484f, 0.03067861f, 0.07227384f, 0.04315443f, 0.20769008f, -0.09058383f, 0.09073146f, -0.00474708f, 
    -0.18494967f, -0.12127035f, -0.16679278f, 0.01965734f, 0.35977969f, -0.04731823f, 0.21586160f, -0.12494914f, 
    0.02249574f, 0.04373414f, -0.03673657f, -0.29292428f, 0.14118619f, -0.05398624f, -0.10223357f, 0.00425543f, 
    0.32650158f, -0.18021014f, -0.18549311f, -0.31964311f, -0.01007351f, 0.03571894f, 0.11756629f, -0.02067084f, 
    0.21494366f, -0.16587514f, 0.05341035f, 0.04327576f, -0.08448778f, -0.13721415f, -0.30180705f, -0.03741386f, 
    0.15079971f, 0.08945742f, 0.12055743f, -0.00732157f, 0.13024661f, 0.07747522f, -0.11614691f, 0.16452381f, 
    0.11961446f, 0.14969520f, 0.29964992f, -0.17360102f, 0.07560363f, -0.06450679f, -0.05074796f, 0.22601373f, 
    0.07846959f, -0.04871906f, -0.09939541f, -0.04737110f, -0.09277324f, -0.05344615f, 0.11906574f, 0.07155524f, 
    -0.04625496f, -0.04043121f, -0.16184500f, -0.02269169f, -0.01152483f, -0.08216069f, 0.04488987f, -0.03283273f, 
    -0.02978494f, -0.14866012f, 0.05570972f, -0.09137365f, 0.10843414f, -0.07043686f, 0.03993521f, 0.02635458f, 
    -0.09111369f, -0.10093590f, 0.01530704f, -0.06431892f, 0.02922821f, 0.07249417f, 0.12743929f, 0.12103220f, 
    -0.03769220f, -0.02355904f, -0.08636244f, -0.10890821f, 0.02857905f, -0.15110588f, -0.01479956f, -0.02772490f, 
    0.14195149f, 0.24837020f, -0.26435384f, 0.03034526f, -0.06683265f, -0.14635573f, 0.19026157f, -0.05115452f, 
    0.13938701f, 0.09713963f, 0.03933819f, 0.15918601f, 0.08942889f, 0.02757724f, -0.14614315f, 0.08934125f, 
    0.06846004f, -0.19446909f, -0.00484649f, -0.04419851f, -0.04261443f, 0.08629009f, 0.11783469f, 0.11157092f, 
    -0.00589429f, 0.01830016f, 0.07732537f, -0.02149290f, 0.03402169f, 0.13140768f, 0.01845962f, 0.01411925f, 
    0.02045775f, -0.04579312f, 0.11184840f, 0.04842356f, 0.26964003f, 0.19943671f, 0.10089309f, -0.07253598f, 
    0.10478058f, -0.06686324f, 0.16671954f, -0.12095743f, -0.01568887f, -0.04513153f, 0.01264504f, -0.00651110f, 
    -0.34419152f, 0.11626711f, -0.11896515f, 0.08452401f, 0.02289031f, 0.04681855f, 0.06732643f, 0.15462604f, 
    0.19857766f, 0.08885622f, 0.04315759f, 0.02411990f, -0.02507393f, -0.07419331f, 0.09471774f, -0.20426585f, 
    0.20324688f, 0.12837514f, 0.11325456f, 0.10407142f, 0.03142809f, -0.05863257f, 0.02424229f, 0.07542612f, 
    0.15930608f, -0.12937587f, -0.02962971f, -0.16083679f, -0.06902758f, 0.06225829f, -0.00039711f, -0.05963051f, 
    0.21715990f, -0.01562367f, 0.16645826f, 0.01897585f, 0.30407941f, -0.17896150f, 0.16611345f, -0.06684959f, 
    0.02270114f, 0.01026017f, -0.18641643f, -0.06040434f, 0.11645501f, 0.01869892f, 0.03658063f, -0.01950353f, 
    0.00731291f, 0.01665837f, -0.00405721f, 0.00031329f, -0.10930879f, 0.00886674f, -0.09355054f, 0.00034232f, 
    -0.02006769f, 0.02499595f, -0.01837457f, -0.07814930f, 0.04018190f, -0.20425689f, 0.04156072f, -0.08593388f, 
    -0.17515565f, 0.07777163f, -0.06600546f, 0.07287118f, 0.00022205f, 0.19324650f, 0.14557531f, 0.13768303f, 
    -0.23644972f, -0.16398932f, -0.18740559f, -0.07017139f, -0.04881917f, -0.04427699f, 0.05009934f, -0.08976829f, 
    0.04024679f, 0.02243270f, -0.11445410f, 0.03985714f, -0.35930231f, -0.21459077f, 0.03295668f, -0.11079236f, 
    0.00476158f, 0.01928162f, 0.02060813f, 0.03477076f, 0.01052907f, -0.04692313f, 0.11652873f, 0.13450724f, 
    -0.49891183f, 0.11358699f, 0.04010487f, -0.08562618f, 0.18522234f, 0.02110216f, 0.11022397f, -0.01267457f, 
    0.06419089f, 0.06335284f, -0.06212765f, 0.03305840f, -0.00550698f, 0.19271629f, 0.11823393f, 0.11570899f, 
    0.10281119f, -0.01944455f, -0.09427827f, -0.04227987f, -0.12130945f, -0.14781301f, -0.08606415f, 0.03982031f, 
    0.30834308f, 0.37366793f, 0.26069313f, 0.10150211f, 0.31996712f, 0.08122953f, -0.09407924f, -0.09912191f, 
    -0.09804715f, 0.03800003f, -0.00795513f, -0.02713399f, 0.18662417f, 0.04158421f, -0.00230587f, 0.16827478f, 
    0.03848492f, 0.00960172f, -0.04864427f, 0.03672236f, 0.08447332f, 0.19812304f, -0.05914432f, 0.09653254f, 
    -0.04984740f, -0.08465373f, 0.03584111f, 0.18898390f, -0.00108315f, -0.15352772f, -0.11640204f, 0.14061105f, 
    0.09973320f, -0.13306154f, 0.02558549f, -0.01840144f, 0.00548747f, 0.07710081f, -0.15330853f, 0.18585251f, 
    0.09545310f, 0.03632414f, -0.06886326f, 0.01823747f, -0.05191624f, -0.15426287f, -0.01013826f, 0.15130310f, 
    0.24639350f, 0.01898386f, 0.09492122f, -0.15310100f, 0.27166495f, 0.02009058f, 0.08450475f, 0.15148386f, 
    0.02932751f, -0.02940570f, 0.00249040f, -0.03414097f, 0.25064778f, -0.11568782f, -0.32395104f, -0.04984666f, 
    0.01031507f, 0.01650124f, -0.00874664f, 0.27060828f, 0.06791411f, 0.08984445f, 0.08601042f, 0.18496221f, 
    -0.35046893f, -0.01456836f, 0.06471462f, -0.80020833f, 0.00038900f, -0.07082654f, 0.01122630f, 0.13181166f, 
    0.01250188f, -0.08044045f, -0.02777776f, -0.06760260f, -0.09290109f, 0.25680977f, 0.11306304f, 0.10784447f, 
    -0.05439686f, 0.16475728f, 0.03538325f, 0.03108599f, 0.05324963f, -0.07806431f, -0.05009793f, -0.05890336f, 
    -0.00814879f, 0.02774648f, -0.15955785f, 0.01317110f, 0.21906526f, -0.13913217f, -0.02362174f, -0.10541762f, 
    0.03419441f, -0.10842456f, -0.01771976f, 0.06171808f, 0.32013610f, 0.27483812f, 0.09460164f, 0.26085573f, 
    -0.04096665f, 0.06048395f, -0.05849959f, 0.09498385f, -0.06818992f, 0.00632512f, -0.11587567f, 0.13866049f, 
    0.31099603f, 0.07944385f, 0.04950059f, 0.21541832f, -0.03343524f, 0.01536352f, 0.00916775f, 0.04169390f, 
    -0.01263852f, 0.01867614f, 0.03603267f, 0.04182220f, -0.09061387f, 0.00267296f, 0.13658008f, 0.21794315f, 
    -0.11968031f, 0.03731132f, -0.07867029f, -0.13322414f, -0.09314699f, -0.11248583f, -0.08291192f, 0.00439485f, 
    -0.45937046f, 0.07821222f, -0.55228424f, -0.25128192f, -0.10046974f, 0.07032824f, -0.02698461f, -0.00879483f, 
    0.04677383f, 0.09113377f, 0.01906720f, 0.02050586f, -0.69702911f, -0.10613643f, 0.20808706f, -0.15366685f, 
    -0.18855523f, 0.09666997f, 0.02072395f, 0.09167871f, 0.00859472f, 0.14622875f, -0.16103049f, 0.07882924f, 
    -0.29604259f, -0.14946382f, -0.25828305f, 0.10470314f, 0.09470614f, 0.07024059f, 0.11096509f, 0.00802153f, 
    0.04700466f, 0.21872610f, 0.00691658f, 0.14640233f, 0.29192668f, 0.15710607f, 0.06385324f, 0.06574551f, 
    -0.00756555f, -0.06068841f, 0.02357083f, -0.05932234f, -0.09588099f, 0.07706483f, -0.05044815f, 0.05633532f, 
    -0.13676259f, 0.13460198f, 0.01161764f, 0.23280583f, -0.06895624f, -0.00982371f, -0.00216234f, 0.09344281f, 
    -0.09676374f, -0.11744122f, 0.06124040f, 0.02825234f, 0.10250809f, 0.00159538f, 0.15078598f, 0.08589458f, 
    -0.03584772f, -0.00101101f, -0.13543373f, 0.06851862f, 0.15630516f, 0.30078235f, 0.16730404f, 0.23201428f, 
    -0.06889578f, -0.13261978f, 0.02060635f, 0.29797983f, 0.01262621f, 0.14839709f, -0.14438853f, 0.03477301f, 
    0.08541521f, 0.11182783f, 0.06765732f, 0.19504397f, 0.18441421f, 0.10551092f, 0.02694645f, 0.19204681f, 
    0.02456519f, 0.02823310f, -0.03583565f, 0.05627866f, -0.01408803f, -0.09851576f, 0.00179035f, 0.04390877f, 
    0.49629787f, -0.34117097f, -0.37152672f, -0.31089282f, -0.01486854f, 0.08600605f, 0.17648809f, -0.08404120f, 
    -0.13596441f, 0.06384031f, -0.06309596f, -0.07078391f, 0.26468945f, -0.53361398f, -0.15304731f, 0.35552433f, 
    0.37275362f, -0.07061546f, 0.11075127f, 0.01667652f, -0.00785163f, 0.04212660f, 0.02287410f, -0.02809361f, 
    0.22084273f, -0.32528052f, -0.18332087f, -0.22199720f, -0.04983373f, -0.05209691f, 0.06324645f, 0.41387886f, 
    0.24905768f, -0.12372112f, 0.22766709f, -0.07635222f, -0.14938463f, -0.13378343f, -0.88984811f, -0.72790378f, 
    0.12431759f, 0.03407675f, 0.05462145f, -0.00174657f, -0.21083586f, -0.01752851f, -0.05120917f, -0.04880982f, 
    0.02345399f, 0.00498409f, -0.04515618f, 0.06365521f, 0.05126533f, -0.08045578f, -0.05811452f, 0.06222134f, 
    -0.03187064f, -0.01803446f, -0.11970758f, -0.08504366f, 0.39115658f, 0.27439761f, 0.01496092f, 0.15119870f, 
    -0.08964554f, -0.05873504f, 0.06609499f, 0.05634179f, 0.14351240f, -0.00514036f, 0.11465981f, 0.11466453f, 
    0.35326174f, 0.10835822f, 0.17690630f, 0.14723250f, -0.10477616f, -0.01022425f, -0.09106887f, -0.08768217f, 
    -0.07527740f, 0.06753813f, 0.03602787f, 0.00931508f, -0.03805090f, 0.07900241f, 0.08907682f, 0.11763404f, 
    0.01012956f, -0.05118041f, -0.18494116f, -0.06946418f, -0.11784653f, 0.03615964f, -0.03552647f, -0.07080906f, 
    0.48562083f, -0.28247821f, -0.02039866f, -0.14823107f, 0.05870456f, -0.21576853f, -0.12380570f, -0.13076338f, 
    0.05080213f, 0.01454338f, 0.01879333f, 0.07050809f, 0.02499085f, 0.06025588f, -0.01179983f, 0.01174457f, 
    0.05130138f, -0.09112770f, -0.02333995f, 0.06961086f, -0.09531378f, -0.01818381f, -0.17861648f, 0.08794062f, 
    -0.16504021f, -0.12180861f, 0.29670563f, -0.06444789f, 0.04133370f, 0.09170317f, -0.12505884f, 0.13137090f, 
    0.01051239f, 0.06327378f, -0.05812592f, 0.01845715f, -0.23919791f, -0.05758078f, -0.34726620f, 0.10758506f, 
    -0.03771771f, 0.05460773f, -0.05588357f, -0.06125467f, 0.13628887f, -0.03767906f, 0.09171870f, 0.04999844f, 
    0.04789247f, -0.23666270f, -0.27883893f, 0.24326698f, 0.06711710f, 0.11921216f, 0.13866191f, -0.01353824f, 
    -0.02523254f, -0.18232095f, -0.01367928f, -0.03179525f, 0.01843572f, 0.09196496f, 0.09490947f, 0.07037410f, 
    0.01944177f, -0.03911826f, 0.00414877f, -0.21686420f, 0.16076662f, -0.10462981f, 0.03359824f, -0.00755013f, 
    -0.03882357f, 0.04370313f, 0.02706152f, 0.26412630f, 0.12734209f, 0.05445723f, -0.18744229f, 0.03295798f, 
    0.05947313f, 0.06518906f, -0.07390437f, 0.11583571f, 0.08524179f, -0.14212571f, -0.25949740f, 0.11947200f, 
    0.08900281f, -0.03176071f, 0.00911961f, -0.03942739f, -0.06376088f, -0.20054729f, -0.02627766f, -0.02725940f, 
    -0.02440456f, 0.15329199f, -0.22474086f, 0.13267674f, -0.04431320f, 0.22079614f, 0.05925909f, 0.18129027f, 
    -0.10191476f, -0.07106941f, 0.07007242f, 0.01120053f, 0.32491475f, 0.28586978f, 0.16525814f, 0.05047735f, 
    0.21933800f, 0.07250633f, 0.14229681f, 0.20937498f, 0.06398574f, -0.06909846f, -0.01547492f, 0.00397967f, 
    -0.34312990f, 0.36907843f, -0.34008908f, -0.02353577f, -0.04379919f, -0.16788121f, 0.07467157f, -0.06719361f, 
    0.16182992f, 0.03858716f, 0.06610219f, 0.05297305f, -0.06804992f, 0.07377350f, -0.05699877f, -0.14125243f, 
    0.01528240f, 0.20988676f, -0.07313672f, 0.22182082f, 0.08731852f, -0.06035087f, 0.08515935f, 0.00452252f, 
    0.25048742f, -0.40132740f, -0.10558910f, -0.23537531f, 0.04496304f, 0.04838989f, -0.02977192f, 0.09467572f, 
    -0.00928311f, -0.07793394f, 0.02298960f, 0.16419514f, 0.22135492f, -0.27484360f, 0.15974280f, -0.13884382f, 
    -0.02640480f, -0.03975232f, -0.22217162f, -0.02802766f, 0.19554070f, 0.07811049f, -0.04535608f, 0.08223024f, 
    -0.00279406f, -0.15040113f, -0.09607840f, -0.03795611f, 0.09220158f, 0.02770993f, 0.03694005f, 0.05783438f, 
    0.09080212f, -0.08392938f, 0.10258614f, -0.06402196f, 0.21520980f, -0.21385124f, 0.16273776f, -0.06952303f, 
    -0.05589759f, 0.12230492f, -0.02939914f, 0.07986362f, 0.15122548f, 0.14326330f, 0.11701409f, 0.21802178f, 
    0.07883041f, 0.10689950f, 0.29551065f, 0.25974923f, -0.09357616f, -0.11734381f, -0.01151717f, 0.18890853f, 
    -0.05849946f, 0.01579606f, 0.01610729f, 0.05861805f, 0.00123929f, 0.15381017f, 0.15665901f, 0.07615694f, 
    -0.02203809f, 0.01781970f, -0.05705572f, 0.05211857f, -0.00890443f, 0.00813762f, -0.04821187f, 0.05045557f, 
    -0.26502454f, -0.34745663f, 0.21895599f, 0.06880953f, 0.03053571f, 0.10220821f, -0.10975473f, 0.03829992f, 
    0.09009628f, 0.06003002f, 0.06642127f, 0.10182180f, -0.52911699f, -0.23016042f, -0.49320656f, 0.14258318f, 
    -0.00872473f, 0.06733230f, 0.03070386f, -0.00708733f, 0.15594058f, 0.01728526f, 0.02746214f, 0.03204066f, 
    -0.15027718f, 0.07822667f, -0.00044583f, 0.37936696f, 0.05020693f, 0.12127247f, 0.15197350f, 0.12829977f, 
    -0.04777747f, -0.03674355f, -0.10825126f, 0.02525162f, -0.13115871f, -0.19481325f, 0.00948628f, -0.03795230f, 
    0.00347262f, -0.06102998f, 0.01031724f, -0.14844266f, 0.13169724f, -0.02316637f, 0.08198121f, 0.04766951f, 
    0.18173565f, -0.20340930f, 0.11195254f, 0.28669286f, 0.11502270f, 0.13733834f, -0.27713823f, 0.18739273f, 
    -0.06624836f, 0.07819321f, -0.17218903f, -0.06570845f, 0.02929012f, 0.01869224f, -0.41564241f, 0.10748575f, 
    0.08957489f, 0.08728264f, -0.08264513f, 0.13543814f, -0.03142307f, -0.26974568f, 0.00770893f, 0.10241383f, 
    -0.03698875f, 0.18521646f, -0.01749942f, 0.25387734f, 0.07158843f, 0.05171051f, 0.03344607f, 0.12362213f, 
    -0.03748997f, 0.09367926f, 0.01283775f, -0.05939497f, 0.00733598f, 0.24855857f, 0.06101815f, -0.11012643f, 
    0.09402626f, 0.02761973f, 0.08838911f, 0.08880062f, 0.18114686f, -0.03736523f, 0.03435430f, -0.04084037f, 
    -0.02282395f, 0.30820033f, -0.26494482f, 0.12549432f, -0.05635155f, -0.18039238f, -0.06422514f, -0.06777692f, 
    0.00716676f, 0.04883341f, -0.05321388f, 0.16411512f, -0.09841581f, 0.03164137f, 0.08047126f, -0.00008198f, 
    -0.07503800f, 0.08344368f, -0.02752189f, 0.03782959f, 0.10965779f, -0.01743733f, 0.00051232f, -0.06955730f, 
    0.02541603f, -0.38608477f, -0.19557603f, 0.00870890f, 0.18378817f, 0.11318382f, 0.08381270f, 0.16125029f, 
    -0.09301492f, -0.03428037f, -0.14619331f, 0.15623054f, 0.13965777f, -0.16754387f, 0.03921531f, -0.34304234f, 
    -0.00883178f, 0.02513677f, -0.02974902f, 0.11793643f, 0.13865782f, -0.00070145f, -0.15548606f, 0.11261191f, 
    0.06431496f, -0.21272795f, -0.18258403f, -0.10660232f, 0.09948625f, -0.03016192f, -0.00979867f, 0.06636719f, 
    0.14036982f, -0.09324329f, -0.06625512f, -0.04803982f, 0.27377382f, 0.08203272f, -0.04785737f, -0.13157192f, 
    0.08822240f, 0.13095126f, -0.06946067f, 0.08094087f, 0.14961877f, 0.00921588f, 0.08106612f, -0.02728959f, 
    0.23328507f, 0.00335390f, -0.12545742f, 0.01301124f, 0.14562275f, 0.21773262f, 0.12537657f, 0.06963312f, 
    0.07484134f, 0.04037771f, 0.04810512f, 0.10770437f, 0.18753017f, 0.12034442f, -0.05856908f, -0.14069116f, 
    0.16327348f, 0.08021326f, 0.07267032f, -0.00140875f, -0.06234098f, 0.08444376f, 0.10354796f, 0.08666405f, 
    0.34513950f, 0.23083220f, -0.03955110f, 0.07112125f, 0.04783144f, -0.09330069f, 0.06703105f, 0.01563335f, 
    0.01414894f, 0.04729578f, 0.02861451f, 0.00042860f, -0.33699015f, -0.39084819f, 0.18969181f, -0.18520206f, 
    -0.02065169f, 0.18384624f, 0.05632185f, -0.11743867f, -0.02062817f, -0.13098073f, -0.03334829f, -0.03942719f, 
    0.06802960f, 0.11023636f, -0.00070448f, -0.18665405f, 0.02798945f, 0.03011538f, -0.07586534f, 0.06315393f, 
    0.01317912f, 0.02305889f, 0.04214263f, -0.02034089f, -0.24284761f, -0.29488537f, -0.14044748f, 0.03706076f, 
    0.07297837f, 0.03455168f, 0.09107187f, -0.02366452f, -0.01424664f, 0.15810151f, 0.08005865f, 0.08667405f, 
    -0.16120338f, 0.14118868f, -0.09350033f, -0.22079493f, -0.09000546f, -0.13000624f, 0.09590416f, -0.12919438f, 
    -0.02883481f, -0.02935511f, -0.00563344f, 0.08722296f, -0.06584822f, -0.16683578f, 0.12546352f, -0.21883461f, 
    -0.13702025f, -0.06557620f, -0.01873014f, 0.17716205f, -0.07118270f, -0.02997114f, -0.02616066f, -0.20923565f, 
    0.12487791f, 0.10228195f, 0.07573177f, -0.10245482f, -0.02429020f, 0.10648644f, -0.02447989f, 0.02739126f, 
    -0.09422508f, -0.08121791f, -0.05554546f, 0.04500713f, 0.11338444f, 0.00798708f, -0.05295376f, 0.13311686f, 
    -0.02999207f, -0.03639750f, -0.03588952f, 0.09639148f, -0.14867665f, 0.06787263f, 0.05693370f, 0.15007748f, 
    0.21585931f, -0.10384446f, 0.35616997f, 0.21691619f, -0.02778442f, 0.15863599f, -0.16659722f, -0.02780643f, 
    0.02745965f, 0.01792183f, 0.14627653f, 0.06182446f, 0.42671385f, 0.22106379f, 0.00348184f, 0.17858058f, 
    0.05182826f, -0.08669358f, 0.16360795f, -0.06963012f, -0.10645821f, -0.07391596f, -0.02027036f, 0.03309537f, 
    -0.20022239f, 0.07737175f, 0.08467534f, -0.36512899f, 0.04039186f, -0.18585394f, -0.13161334f, -0.18047412f, 
    -0.06035671f, -0.00997063f, -0.04208453f, -0.03657288f, -0.26539510f, -0.24715240f, -0.21035352f, -0.01365153f, 
    -0.02579664f, -0.01723551f, -0.02885886f, -0.20891574f, -0.08086192f, 0.00009484f, -0.06695151f, -0.11692559f, 
    -0.34259462f, -0.32621491f, -0.33888134f, -0.02544750f, -0.07105719f, -0.03274224f, 0.02773750f, -0.04786249f, 
    -0.12019176f, 0.01623611f, -0.14179742f, 0.13264389f, -0.01064051f, 0.00604344f, 0.25474119f, -0.15849200f, 
    0.14600296f, 0.00266909f, 0.09413090f, -0.00907483f, -0.08080376f, -0.01368054f, -0.06986833f, -0.13028620f, 
    -0.02521122f, -0.00678685f, -0.07916328f, -0.10133795f, -0.03531906f, 0.01524254f, 0.08049929f, 0.06496435f, 
    0.04608044f, 0.09576857f, 0.01412762f, 0.08527862f, -0.05121262f, -0.03759768f, -0.08000915f, -0.03728782f, 
    0.09625926f, 0.03941223f, -0.03564755f, 0.01505978f, 0.11452802f, 0.12771186f, 0.13745868f, -0.01518513f, 
    -0.00751832f, -0.01641583f, 0.09739360f, 0.06178027f, 0.01138368f, 0.05867337f, 0.03953307f, 0.05100495f, 
    -0.00118214f, 0.01103100f, 0.13439399f, 0.01762422f, -0.10460784f, -0.08690513f, -0.02828626f, -0.05500545f, 
    -0.04867278f, -0.02168431f, -0.01332605f, -0.07242446f, -0.01801090f, -0.00544852f, 0.04359600f, -0.10319291f, 
    -0.03862604f, -0.08183891f, -0.04227482f, -0.01966144f, -0.05728213f, -0.04650457f, -0.02186557f, -0.03107231f, 
    0.01647012f, -0.01358412f, -0.07415695f, 0.00211871f, -0.07424267f, -0.05752630f, 0.02028610f, 0.00586526f, 
    0.04393304f, 0.05140141f, 0.02968735f, -0.05634930f, -0.01918685f, -0.06762604f, -0.02273228f, -0.00957666f, 
    -0.11264368f, -0.01981026f, -0.07669200f, -0.16201642f, 0.03422051f, -0.06281634f, -0.06300773f, -0.09932410f, 
    -0.10046352f, 0.02471897f, -0.02697599f, -0.01883661f, 0.01656017f, -0.03264776f, -0.16123512f, -0.00307494f, 
    -0.02272096f, -0.14506517f, -0.07367966f, -0.03587360f, -0.00303162f, -0.02489359f, -0.03565988f, -0.06474026f, 
    -0.04108309f, -0.04188977f, -0.07414114f, 0.04489877f, -0.08682337f, 0.01412445f, -0.08352938f, 0.02559690f, 
    0.00491370f, 0.06423905f, -0.01549054f, -0.01039419f, -0.08077038f, -0.03699836f, -0.06835342f, -0.00312026f, 
    -0.08732650f, 0.04679192f, -0.04393549f, -0.11609033f, 0.02494891f, 0.10712989f, 0.05250495f, -0.01462595f, 
    -0.12842245f, -0.11213858f, -0.07573745f, -0.09899522f, 0.04853966f, -0.08279557f, -0.00487846f, -0.12118971f, 
    0.08874586f, -0.03744200f, -0.04873247f, 0.00588994f, -0.14220241f, -0.00364128f, 0.03085156f, -0.03270131f, 
    0.00384772f, 0.00729528f, 0.03859849f, 0.02207930f, 0.04505495f, 0.03854767f, -0.01561074f, 0.06027569f, 
    -0.10118846f, -0.02899789f, -0.04691188f, -0.01853985f, -0.05636362f, -0.14015783f, -0.09338275f, -0.00149449f, 
    -0.03606470f, -0.05090367f, 0.01397446f, -0.01279637f, -0.06726432f, -0.09696500f, -0.00805455f, -0.05811058f, 
    -0.09118171f, -0.08759567f, -0.03696030f, -0.02139952f, -0.00077416f, -0.09515426f, -0.08702360f, -0.06364489f, 
    -0.08059070f, -0.10928330f, -0.08412952f, 0.00905440f, -0.08039730f, 0.03008656f, -0.07895599f, -0.04075019f, 
    0.03862952f, -0.03948678f, -0.05523262f, -0.08785713f, -0.11534824f, -0.12884407f, 0.01891598f, -0.01108191f, 
    -0.08743373f, -0.08838888f, -0.02723315f, -0.05625559f, -0.03642445f, -0.00798856f, 0.02972924f, -0.09667327f, 
    0.25907058f, 0.19813496f, 0.36828759f, 0.02264987f, -0.07656702f, -0.03569343f, -0.05912639f, -0.02636355f, 
    0.04019385f, 0.05737085f, 0.10750078f, 0.06935648f, -0.06201472f, 0.11950368f, 0.11418077f, 0.05428864f, 
    0.08327156f, -0.09163556f, -0.05477529f, -0.04645776f, 0.07769921f, -0.09308743f, -0.07513914f, 0.14320013f, 
    -0.07952627f, -0.09749737f, 0.10138135f, -0.02081418f, 0.09556302f, -0.03264896f, -0.04476784f, 0.02014838f, 
    0.13956602f, -0.03739658f, 0.04422929f, 0.06603011f, -0.10193324f, -0.08679973f, -0.34803110f, 0.06541131f, 
    -0.05623905f, 0.10562256f, 0.12901086f, -0.16329335f, 0.02448835f, -0.10785487f, 0.05327462f, 0.02019237f, 
    -0.09133321f, 0.28233513f, -0.37030599f, -0.08913352f, 0.01722169f, 0.06106700f, 0.08783560f, 0.03865873f, 
    0.02982232f, -0.08919295f, -0.08429871f, -0.12355403f, -0.09960493f, 0.01137635f, 0.13092424f, 0.19840874f, 
    -0.13797005f, -0.00886389f, -0.10385351f, -0.15222484f, 0.07404788f, -0.03407865f, 0.01867701f, -0.00010790f, 
    0.00339172f, -0.38070107f, 0.35145396f, 0.18958256f, 0.03941293f, 0.12399050f, -0.23919798f, 0.25736201f, 
    0.10579799f, -0.08341638f, -0.04783006f, 0.05999609f, -0.10150462f, 0.21645781f, -0.38337371f, 0.26174310f, 
    0.11726939f, 0.03010600f, 0.02034635f, 0.06345768f, -0.00876607f, -0.12422541f, 0.03875439f, -0.01200308f, 
    -0.18673955f, 0.03852731f, -0.19400360f, -0.07539979f, 0.09775727f, -0.05462351f, 0.09076595f, 0.07087786f, 
    0.09112948f, -0.00738600f, -0.05792135f, 0.06582359f, 0.41192147f, -0.00628508f, 0.00117059f, -0.30185628f, 
    -0.04275428f, 0.03919757f, -0.01814821f, 0.31999627f, 0.01150517f, 0.04626990f, 0.05378418f, 0.02425953f, 
    -0.14946811f, 0.20837899f, 0.00923789f, -0.39952251f, 0.04076558f, -0.16844982f, 0.11300068f, 0.12433595f, 
    0.06167971f, -0.03246035f, 0.10346070f, 0.02691496f, 0.01536721f, 0.05012423f, 0.08411793f, -0.06845073f, 
    -0.03860173f, 0.09864028f, -0.07944982f, 0.16872391f, 0.06860563f, -0.07963028f, 0.06569734f, -0.14600649f, 
    0.10031515f, -0.25504971f, -0.03000326f, -0.07279966f, 0.06313732f, 0.21988599f, 0.13753279f, -0.08558523f, 
    0.07162745f, -0.05732361f, 0.14725250f, -0.02419142f, 0.40240049f, -0.19388516f, 0.16188784f, -0.01640080f, 
    -0.07333766f, 0.01813743f, 0.04254606f, 0.02430659f, -0.02049437f, 0.16108246f, 0.04032673f, 0.07659577f, 
    0.37180439f, -0.12739113f, 0.04174848f, -0.08646004f, 0.10092435f, -0.04966296f, 0.03756326f, -0.03132053f, 
    -0.10366654f, 0.07917606f, 0.12494739f, 0.03746355f, -0.15921490f, -0.05342179f, 0.09657193f, 0.01275083f, 
    -0.01869505f, 0.13790233f, -0.03234198f, 0.12428376f, 0.02798859f, 0.06680156f, -0.03134406f, 0.09412780f, 
    0.02879211f, -0.05056670f, -0.03555918f, -0.04938895f, 0.02774506f, 0.00977607f, -0.06880680f, 0.03338287f, 
    0.06068036f, 0.04037064f, 0.00502472f, -0.07262328f, -0.00061149f, -0.07312620f, 0.01211469f, -0.00857400f, 
    0.04147245f, 0.05589567f, 0.05629251f, 0.01016291f, -0.01130713f, 0.01135535f, 0.03234180f, 0.02581594f, 
    -0.05449652f, 0.02316754f, -0.06087304f, 0.05374850f, -0.06929053f, 0.01119396f, -0.06077257f, 0.05121011f, 
    -0.01862078f, -0.02860556f, -0.07236669f, -0.05312502f, 0.04652634f, -0.01925146f, -0.02277388f, 0.04014479f, 
    -0.04607008f, -0.06370014f, -0.05936004f, 0.05009990f, -0.03363181f, 0.04143539f, -0.03095583f, 0.05740147f, 
    -0.06328990f, -0.05555591f, -0.03813096f, -0.00680690f, -0.00146310f, 0.05886235f, -0.02931322f, -0.02710904f, 
    -0.04361181f, -0.00355661f, -0.05325248f, -0.03040009f, 0.03120602f, 0.03004198f, -0.04598487f, 0.02224952f, 
    -0.03836835f, -0.05897208f, -0.02922462f, 0.01016034f, 0.01951092f, -0.03068156f, 0.02645093f, -0.01630027f, 
    -0.04431935f, -0.00955758f, -0.05777714f, 0.02681955f, -0.05880543f, -0.07296006f, -0.04329684f, -0.06409244f, 
    0.00882236f, 0.06124703f, -0.06944731f, -0.05079822f, -0.04853117f, 0.05188101f, -0.07123952f, 0.02412470f, 
    0.03650143f, 0.03814771f, -0.06416366f, 0.05969843f, -0.01493911f, 0.03313252f, 0.02554067f, -0.00694847f, 
    0.06079180f, -0.02101278f, -0.02875679f, 0.02849361f, -0.01168160f, -0.04016785f, -0.02853100f, -0.04011881f, 
    -0.07587010f, -0.03395550f, -0.01689418f, 0.06062152f, -0.07325897f, -0.04222755f, 0.00490319f, -0.02196764f, 
    0.01261166f, -0.04123377f, -0.04077585f, -0.06188915f, -0.07009448f, -0.00558974f, 0.05779354f, -0.07335066f, 
    -0.00558802f, -0.03573380f, -0.01970649f, -0.05000766f, -0.02528798f, 0.00888448f, 0.05046580f, -0.01408679f, 
    -0.06411206f, -0.04696741f, -0.06216820f, -0.06847317f, 0.00006817f, 0.02150404f, -0.06604239f, 0.03159992f, 
    0.06477301f, 0.02785874f, 0.06700757f, -0.01686560f, -0.04609046f, -0.00831221f, -0.04140998f, -0.00062587f, 
    -0.05585774f, 0.06326155f, -0.00178748f, 0.05386905f, 0.00907453f, -0.02613080f, 0.03122412f, -0.07584623f, 
    -0.02745435f, 0.04826060f, -0.02721643f, 0.04598987f, -0.03154289f, 0.01700235f, -0.01966239f, 0.06544375f, 
    0.02558980f, -0.05008779f, -0.06642316f, -0.00364354f, -0.03847278f, 0.02278950f, 0.00033986f, -0.03111747f, 
    -0.03478763f, -0.01524633f, -0.07390064f, -0.00896861f, -0.06729018f, 0.05386085f, 0.03357506f, -0.03940406f, 
    -0.02126432f, -0.06619743f, -0.00037966f, -0.01603509f, 0.00279838f, 0.03282257f, 0.03733416f, -0.07513127f, 
    -0.07057504f, 0.00750407f, 0.01234521f, -0.03715672f, 0.03619066f, 0.05695052f, 0.03595557f, 0.02849214f, 
    0.01585778f, -0.42249367f, -0.06838260f, 0.01776258f, -0.01484361f, -0.17511594f, -0.07754415f, 0.05614010f, 
    0.04393651f, -0.06525347f, 0.02398445f, -0.01581977f, 0.15114361f, -0.21434109f, -0.02486387f, 0.09528903f, 
    -0.07754860f, -0.02734728f, 0.03810820f, -0.01165276f, 0.04147812f, -0.01753794f, -0.01550092f, 0.07590202f, 
    -0.05655208f, -0.09462117f, 0.17400107f, -0.12991223f, -0.05079285f, -0.03692948f, 0.01534383f, -0.00958847f, 
    -0.01809844f, -0.06310809f, -0.09045991f, 0.03320586f, -0.23932111f, 0.19321418f, -0.10455137f, 0.14677338f, 
    0.20328942f, -0.01419740f, -0.09969906f, -0.00130328f, -0.08659294f, -0.02049629f, 0.19455759f, 0.01516687f, 
    0.22945069f, -0.06756213f, 0.35280985f, 0.00485855f, 0.13127686f, 0.11103451f, 0.12406553f, -0.05159374f, 
    -0.06725351f, -0.10834078f, -0.08862478f, -0.17479776f, -0.16328129f, 0.01146616f, -0.05612568f, -0.06540946f, 
    -0.07029840f, -0.08534371f, -0.06368917f, -0.04895170f, 0.15413989f, -0.02692704f, 0.15634672f, 0.17443326f, 
    0.19088723f, -0.10906156f, 0.01790928f, 0.02908383f, -0.08251116f, 0.05796083f, -0.03572024f, -0.00634716f, 
    0.04197055f, -0.12595545f, 0.09569450f, -0.01494634f, -0.08845680f, -0.09506730f, -0.00715079f, 0.35157076f, 
    0.04785734f, 0.08561027f, 0.05690688f, -0.12939575f, -0.01351703f, -0.12339772f, 0.09842483f, 0.07730488f, 
    0.19917287f, 0.34514576f, -0.01765569f, 0.30543017f, 0.15588263f, 0.01962904f, 0.06768022f, 0.10889225f, 
    0.08588345f, -0.08567461f, 0.01639076f, -0.02669110f, 0.27473050f, 0.22973923f, -0.06154908f, -0.05013751f, 
    0.03503618f, 0.02291169f, -0.02087324f, 0.05253448f, 0.01072033f, 0.05994924f, 0.04150110f, -0.08917122f, 
    -0.52500623f, 0.01897632f, -0.13598326f, -0.10226184f, 0.02911115f, -0.05612777f, 0.12013151f, 0.01485998f, 
    0.09528230f, -0.00475453f, 0.04152864f, -0.06833502f, -0.17346074f, -0.09866592f, -0.19271731f, -0.09169442f, 
    0.02192792f, 0.11358871f, -0.03304651f, -0.08543289f, 0.00089341f, -0.06061732f, 0.01496608f, 0.00612043f, 
    0.18232332f, -0.13120767f, -0.01291829f, -0.00994189f, 0.04589673f, 0.11571280f, -0.01799436f, 0.11908224f, 
    0.07201799f, -0.02279864f, -0.08628619f, 0.07728290f, -0.20532453f, -0.09365433f, 0.11769088f, -0.03500658f, 
    0.03805299f, -0.08781233f, -0.01407727f, -0.00532265f, 0.04996672f, -0.00192425f, -0.04947887f, 0.24755023f, 
    -0.23180194f, 0.09730890f, 0.01146698f, -0.00438981f, 0.07302393f, 0.20971768f, 0.05811065f, 0.04599992f, 
    -0.02564472f, -0.02959251f, 0.01521858f, 0.04846735f, 0.08998973f, -0.15057729f, -0.05583765f, 0.10702037f, 
    0.01634514f, 0.04374534f, -0.00641214f, -0.16948704f, 0.16249384f, 0.00684578f, 0.27784649f, 0.14040437f, 
    0.03170949f, -0.13990271f, -0.05896064f, -0.00331389f, 0.00183604f, -0.25645337f, -0.08951242f, 0.06120642f, 
    -0.03318414f, 0.09513140f, 0.03620775f, -0.06748307f, 0.10152218f, 0.05886687f, 0.04828184f, -0.00234211f, 
    -0.02044524f, 0.02263980f, -0.05962285f, 0.11413780f, 0.10087343f, 0.09870515f, -0.09657805f, 0.04112713f, 
    -0.24786615f, 0.00440713f, -0.03503598f, 0.03670786f, 0.03138543f, 0.11473768f, -0.04726003f, 0.02107831f, 
    0.02113867f, 0.04165011f, -0.11354712f, -0.00248335f, -0.01531492f, -0.10313262f, -0.16468310f, -0.17932957f, 
    -0.23207420f, -0.03500069f, -0.06426419f, -0.05869063f, -0.01486366f, 0.05276405f, -0.05783463f, -0.00085157f, 
    0.12748797f, -0.30235696f, -0.17109621f, 0.03018039f, 0.08658240f, 0.04708397f, 0.24207458f, 0.14725134f, 
    0.00900249f, 0.00078141f, -0.01201901f, -0.12085363f, 0.09722808f, 0.20610003f, 0.17619970f, -0.05466313f, 
    -0.01718623f, -0.08916836f, -0.05719683f, -0.09918246f, 0.00061532f, 0.07845464f, -0.05652554f, -0.00554186f, 
    -0.16836670f, 0.42527750f, 0.01980141f, 0.17627653f, 0.16920458f, 0.05581335f, -0.22806442f, 0.02335646f, 
    -0.00789005f, -0.12827419f, 0.09084278f, 0.08092704f, 0.05393645f, -0.00124074f, 0.22258079f, 0.07343695f, 
    0.06536853f, 0.10955275f, 0.09206991f, -0.09034055f, 0.04013124f, -0.09837877f, 0.01550046f, -0.00754786f, 
    0.02007716f, -0.08325565f, 0.00528566f, 0.11666036f, -0.19582877f, 0.01235657f, 0.08283757f, 0.05192873f, 
    0.00076509f, -0.05108208f, 0.09465282f, -0.01419817f, -0.26158702f, -0.11098350f, 0.10786032f, 0.26090476f, 
    -0.00177704f, 0.10803624f, 0.10291333f, 0.17143430f, 0.09020528f, -0.01128468f, -0.04595019f, 0.01705717f, 
    0.26045448f, 0.11368907f, -0.05592546f, 0.23332000f, -0.04418951f, -0.03910446f, 0.04195010f, 0.07622027f, 
    0.04647363f, -0.05084904f, 0.10993817f, -0.03467408f, -0.26391220f, -0.08469184f, -0.03887653f, 0.00571323f, 
    0.07764065f, 0.23028354f, -0.06829141f, 0.21838176f, 0.07728937f, 0.13805155f, 0.03498787f, 0.05315349f, 
    0.02436914f, -0.04686486f, 0.02696441f, -0.11315086f, 0.01035937f, 0.04954750f, -0.05595956f, 0.07336444f, 
    -0.08525553f, 0.06358911f, 0.22534575f, 0.04471501f, -0.04483001f, 0.17843449f, 0.40026021f, -0.19204654f, 
    -0.09631898f, -0.04583872f, -0.18392539f, -0.06019880f, 0.03056396f, 0.07278607f, 0.10437614f, -0.01753180f, 
    -0.29144314f, 0.00343802f, 0.07183714f, -0.19724245f, -0.09162868f, -0.00403151f, -0.05745421f, -0.00510842f, 
    -0.03951497f, -0.03182202f, -0.01160982f, 0.01728334f, 0.13946460f, 0.02408776f, 0.02882363f, -0.02576826f, 
    0.00902179f, -0.10733670f, 0.04235623f, -0.01669500f, 0.04660723f, 0.17727529f, 0.10687772f, 0.30122399f, 
    0.15499215f, 0.16144691f, 0.22424737f, 0.04932819f, 0.03166469f, 0.15169427f, 0.06515990f, 0.08441067f, 
    0.08912282f, 0.15420237f, -0.02680489f, 0.10512298f, 0.24575184f, 0.04795301f, 0.18989339f, 0.05631461f, 
    0.05704804f, -0.03205021f, -0.00299614f, 0.04910923f, 0.09600171f, -0.05082308f, 0.04984973f, -0.01849225f, 
    0.27291334f, 0.23300415f, -0.04711496f, -0.03027126f, -0.00325671f, 0.09836649f, 0.09527458f, -0.01454250f, 
    0.01733179f, 0.09198403f, 0.15683575f, 0.18190120f, 0.06536771f, 0.06118057f, 0.15864958f, 0.22157986f, 
    -0.06685232f, 0.19953570f, 0.11578266f, -0.25416875f, -0.20059109f, -0.22815657f, -0.05484456f, 0.11013088f, 
    -0.04074190f, 0.44453838f, 0.39881954f, -0.02656467f, -0.01529741f, 0.26422897f, 0.08589139f, 0.00547240f, 
    0.04306396f, -0.10404878f, -0.07636195f, 0.07470382f, -0.06055983f, 0.00764457f, -0.23534918f, 0.04524174f, 
    -0.17993274f, -0.08362200f, -0.17392339f, -0.05647414f, -0.02193485f, 0.03764047f, 0.12232965f, 0.18794939f, 
    0.22341435f, -0.14225020f, 0.24225815f, -0.14019318f, -0.07652165f, -0.04007861f, 0.10566720f, -0.01844035f, 
    -0.00462386f, -0.22711983f, -0.12077144f, -0.09026318f, -0.05233753f, 0.02326631f, 0.34024969f, -0.09236260f, 
    0.00348679f, 0.16813761f, -0.06281394f, -0.08570836f, 0.08436152f, -0.08286590f, -0.16029875f, -0.28272557f, 
    0.14399756f, 0.06023279f, -0.02572306f, -0.01225356f, 0.12480751f, 0.13045424f, 0.03277907f, 0.13969985f, 
    0.20689550f, 0.04025281f, -0.09486069f, -0.12375689f, 0.22600307f, -0.08741193f, -0.14867945f, -0.03324157f, 
    0.11196012f, -0.02206698f, -0.00887590f, 0.22937572f, -0.00623012f, 0.09827364f, 0.05390991f, -0.20700036f, 
    0.08865279f, -0.24797525f, 0.26778325f, 0.01258848f, -0.03523956f, 0.02492501f, -0.16013870f, -0.14759718f, 
    0.08765369f, -0.09658515f, 0.08883340f, 0.06467520f, 0.20179592f, 0.09409204f, -0.19808280f, -0.01846862f, 
    0.02971100f, 0.02659683f, -0.04126616f, -0.13137443f, -0.12413058f, -0.03993241f, -0.17388213f, -0.05427663f, 
    -0.01964986f, -0.00103160f, 0.07404378f, -0.27013767f, 0.08195834f, -0.03199380f, 0.00338235f, -0.23982583f, 
    -0.06575773f, 0.04273045f, -0.35719642f, -0.43831024f, -0.36969879f, 0.14391360f, -0.14508303f, 0.22365031f, 
    -0.00553050f, -0.08154843f, 0.37469107f, -0.04615484f, -0.12807944f, -0.18021831f, 0.00842335f, 0.04415279f, 
    0.08138804f, -0.02451552f, -0.08278754f, 0.13944119f, 0.02521085f, 0.09258938f, 0.18802147f, 0.09213442f, 
    -0.26629889f, -0.30175552f, -0.40783584f, -0.08725226f, -0.15649305f, -0.07142875f, 0.00687172f, -0.05350707f, 
    0.23848708f, 0.08122344f, 0.07727478f, -0.34452283f, -0.01541135f, -0.12360351f, -0.24746896f, -0.32498866f, 
    0.45752022f, -0.04994446f, -0.09135554f, 0.08884946f, 0.20114684f, 0.16571994f, 0.11561275f, -0.00838507f, 
    0.00009892f, -0.16159284f, -0.02885128f, 0.09616417f, 0.03832591f, 0.18397057f, 0.04380061f, -0.03042187f, 
    0.12355407f, -0.07446449f, -0.03822898f, 0.04458814f, -0.05595139f, 0.13995951f, 0.09711563f, 0.10226993f, 
    0.19426116f, 0.19654846f, 0.14780469f, 0.11568443f, -0.07568800f, -0.13992205f, 0.21427959f, 0.13618404f, 
    0.02545961f, 0.06165168f, 0.07848159f, 0.03016022f, -0.45445931f, -0.38518542f, -0.41911077f, -0.08000603f, 
    0.04200038f, 0.04879807f, -0.03985413f, -0.08056134f, 0.07911818f, -0.06012435f, 0.02394200f, -0.13129382f, 
    0.18543769f, -0.09258967f, -0.19060278f, 0.06072938f, 0.17855200f, -0.00148248f, -0.09358877f, -0.01436041f, 
    0.11533001f, -0.06009889f, 0.08294738f, 0.14620706f, -0.21254475f, -0.24963047f, -0.18793397f, -0.11483727f, 
    0.04729540f, 0.00683443f, 0.02049157f, 0.02725793f, -0.06864012f, 0.12198035f, 0.02432823f, 0.10815789f, 
    -0.27177238f, 0.23641805f, -0.10709606f, -0.10214792f, 0.05662613f, -0.02599218f, 0.00712373f, -0.00768152f, 
    -0.07822989f, 0.03990847f, 0.02220886f, 0.06663828f, -0.00196364f, -0.24890879f, -0.21425210f, -0.03738272f, 
    -0.05134989f, -0.12369350f, 0.01572239f, 0.07992471f, -0.02040789f, -0.10961755f, -0.03567119f, -0.13993236f, 
    0.09770780f, 0.29778719f, 0.04598038f, 0.06389681f, 0.03140262f, 0.09800874f, 0.08284812f, 0.08167305f, 
    -0.00866952f, -0.09285524f, -0.11996654f, -0.03461979f, 0.39704701f, 0.32905221f, 0.11386687f, 0.07708491f, 
    0.06787179f, 0.09024359f, 0.00926788f, 0.18463878f, -0.00558039f, 0.04802466f, 0.00213068f, 0.07672434f, 
    -0.08580089f, -0.07511581f, 0.20822492f, 0.01957366f, 0.04075669f, 0.01343583f, -0.06984808f, 0.06400853f, 
    -0.01883733f, 0.07632278f, 0.26640797f, 0.17061430f, 0.33002752f, 0.33049908f, 0.15416835f, 0.15454482f, 
    0.09627007f, 0.06728160f, 0.26036134f, 0.17506589f, -0.03062018f, -0.11500943f, 0.00633693f, -0.07828494f, 
    -0.02315011f, -0.21865812f, 0.14001268f, -0.30593616f, -0.09646732f, -0.16025683f, -0.11463711f, 0.03821089f, 
    0.05356959f, -0.15179291f, -0.03675956f, -0.07279854f, -0.05948274f, -0.55847698f, -0.29681930f, -0.09634384f, 
    -0.03412474f, 0.04630920f, -0.13836907f, -0.20487423f, -0.09249873f, -0.07961062f, 0.04638802f, 0.00349404f, 
    -0.06728780f, -0.49601912f, -0.46525192f, -0.09645392f, 0.08620485f, -0.04225060f, 0.00242719f, -0.00232367f, 
    0.03879832f, 0.05746238f, -0.07497455f, 0.07540905f, 0.15861228f, 0.01250740f, 0.13131519f, -0.14043464f, 
    0.11693498f, 0.02916834f, 0.02095836f, -0.05374087f, -0.14022303f, 0.11130926f, -0.19707063f, -0.05995452f, 
    -0.08025905f, -0.02735446f, -0.05585114f, 0.04656633f, 0.05425780f, -0.01837197f, 0.04026540f, -0.01522131f, 
    -0.04543493f, -0.02840195f, -0.05538458f, -0.01484230f, 0.01915723f, -0.01909218f, 0.00826846f, 0.03934846f, 
    -0.03224082f, -0.01702394f, 0.05143119f, 0.01842157f, -0.02037128f, -0.07513750f, 0.01433623f, 0.03955190f, 
    0.01703633f, -0.06025444f, 0.03466101f, -0.01135564f, 0.01293066f, 0.03065337f, -0.01865180f, 0.04599085f, 
    -0.00697728f, 0.04841922f, -0.04556888f, -0.01949181f, 0.00763404f, 0.03010095f, 0.04926370f, -0.02989746f, 
    0.01799919f, -0.01283494f, -0.05592723f, -0.02875909f, -0.06533138f, -0.06371610f, -0.03458674f, 0.03627558f, 
    -0.05726191f, -0.04148690f, -0.01499447f, 0.03128738f, -0.02390794f, 0.05995322f, -0.00635961f, -0.04913120f, 
    0.03745415f, 0.01180966f, -0.00012585f, 0.03953694f, -0.00497123f, -0.04886466f, -0.01443421f, -0.05537586f, 
    -0.07467040f, 0.01005779f, 0.00353698f, 0.05049374f, -0.03352852f, 0.03176524f, -0.00005280f, 0.02548245f, 
    0.03540175f, 0.05063185f, -0.01053061f, 0.05933081f, -0.07867667f, -0.00627589f, -0.00018219f, 0.06613272f, 
    -0.00926558f, -0.04529595f, -0.03369485f, -0.00902669f, -0.04325921f, -0.05227142f, -0.06459483f, -0.05162083f, 
    0.01178021f, -0.05164605f, 0.02099548f, -0.05802199f, 0.02615002f, -0.03175731f, -0.02098482f, -0.02448168f, 
    -0.06734878f, 0.05182113f, 0.01988323f, 0.04152497f, -0.00497259f, -0.07516115f, -0.03258653f, 0.02018351f, 
    -0.04437449f, -0.05243194f, -0.06953439f, -0.04223837f, -0.05230722f, 0.05392285f, -0.02272408f, -0.02303953f, 
    -0.07319073f, 0.00049460f, -0.04860751f, 0.06352697f, 0.03033006f, 0.06075929f, -0.03166281f, -0.06026118f, 
    0.01669121f, -0.07592177f, -0.02082729f, -0.06768952f, -0.02424128f, -0.00845752f, -0.06752699f, -0.02550363f, 
    0.04092406f, -0.04062119f, 0.06365563f, -0.05324375f, -0.01780026f, 0.04328969f, 0.03605070f, -0.02145251f, 
    0.00719452f, -0.01392264f, 0.02520688f, -0.03912889f, 0.01732646f, -0.07440788f, -0.01211793f, -0.00345310f, 
    -0.07376627f, 0.02733460f, -0.01227251f, -0.06773902f, 0.05759715f, -0.01575286f, -0.00203129f, 0.01876751f, 
    -0.04489365f, -0.02071456f, -0.08220319f, -0.03992312f, 0.01666729f, 0.02008301f, -0.02398267f, 0.01795666f, 
    -0.05593118f, -0.05963570f, -0.02026381f, -0.00318494f, -0.00357478f, -0.02378466f, -0.01870426f, 0.02199406f, 
    -0.07662726f, -0.00837881f, 0.03884626f, 0.05398581f, 0.04316030f, 0.04063426f, 0.04894988f, 0.01093901f, 
    -0.03934201f, 0.04456599f, -0.03604124f, -0.05986742f, -0.00706109f, -0.07174084f, 0.03744613f, -0.05066350f, 
    0.02262707f, 0.03633212f, -0.00581412f, -0.04256957f, -0.00036290f, 0.03979989f, -0.05948856f, -0.01638778f, 
    0.09593392f, 0.13009378f, 0.27766538f, 0.03214161f, 0.02486664f, 0.04169322f, 0.04257188f, -0.11322463f, 
    0.11055557f, 0.00503527f, 0.11511333f, -0.08228569f, -0.05632889f, 0.17240657f, 0.13079114f, 0.11185939f, 
    0.02789411f, 0.16740149f, -0.01106396f, 0.01231774f, 0.08082858f, -0.03606940f, -0.09963391f, 0.06279634f, 
    0.10985110f, 0.08364323f, 0.15391375f, -0.06296138f, -0.01459568f, 0.02378657f, -0.01717942f, 0.15055889f, 
    0.01724700f, -0.01977542f, 0.01091443f, -0.14705032f, -0.02304787f, -0.14508361f, -0.32376468f, 0.10150055f, 
    -0.00370212f, -0.05062254f, 0.06603893f, -0.02870418f, -0.05947233f, -0.02337089f, 0.01080687f, -0.11034746f, 
    -0.24857119f, -0.04942788f, -0.07784989f, -0.08278476f, 0.12055723f, 0.00787039f, 0.14998056f, 0.01390079f, 
    -0.10254869f, -0.08741845f, -0.06495745f, -0.06358580f, -0.07982603f, -0.08737323f, -0.03554830f, 0.13423300f, 
    -0.09303650f, -0.09977869f, 0.00853409f, -0.07402103f, 0.02323193f, -0.01275582f, 0.10581771f, 0.15884607f, 
    -0.09960502f, -0.27764744f, 0.12074157f, 0.07236295f, 0.10855476f, -0.05210561f, -0.02807639f, 0.09582714f, 
    0.06885920f, -0.08284844f, 0.06677987f, -0.00292544f, -0.26558205f, -0.03342892f, -0.14896201f, 0.23406002f, 
    0.02271522f, 0.02468058f, 0.02198649f, -0.14578608f, 0.01015895f, -0.15317099f, 0.22260487f, 0.12955293f, 
    0.04962264f, -0.12440235f, -0.20590420f, -0.23961349f, 0.04692382f, 0.10829701f, -0.02677497f, -0.09261931f, 
    -0.02487358f, 0.01275378f, -0.00385757f, 0.08231638f, 0.32206675f, -0.08009709f, -0.05123264f, -0.13486029f, 
    0.10194012f, 0.00424320f, -0.05359463f, 0.09612716f, 0.05739187f, 0.05237598f, -0.12319298f, -0.02830598f, 
    0.08022491f, 0.01746527f, -0.04834181f, -0.21002083f, 0.11039813f, -0.01722852f, -0.01190564f, 0.07736395f, 
    0.14388792f, 0.00164824f, -0.00782858f, 0.01523326f, -0.14502324f, -0.03379103f, -0.06391428f, -0.18486710f, 
    0.01898349f, 0.02932902f, -0.16661993f, -0.02116106f, 0.00234321f, 0.05072949f, -0.07976697f, -0.02604001f, 
    -0.07926183f, -0.22787799f, -0.02008601f, 0.21129967f, 0.08198568f, 0.00281707f, 0.04900071f, 0.04215290f, 
    0.11349840f, 0.00267853f, 0.05746383f, 0.11665188f, 0.02242027f, -0.10903148f, -0.02509269f, 0.09497655f, 
    0.03351943f, -0.10449660f, 0.04888943f, 0.04006133f, 0.02617805f, -0.17582491f, 0.13439985f, 0.07074280f, 
    -0.15583341f, -0.26166102f, -0.11706853f, -0.05268851f, 0.04643880f, 0.11030542f, 0.03604788f, 0.06141721f, 
    -0.01860937f, -0.10594134f, 0.02296055f, 0.05377226f, -0.35300609f, -0.24793869f, -0.02158446f, 0.09540359f, 
    -0.17223816f, -0.07255961f, -0.16861731f, -0.02937583f, 0.05207343f, 0.10249084f, 0.19032426f, 0.12110156f, 
    0.27197871f, -0.36779386f, -0.25388941f, -0.16148122f, -0.00450106f, -0.01176026f, 0.03836885f, -0.10823396f, 
    0.09098783f, -0.18023230f, -0.14254431f, -0.06781644f, -0.50631100f, -0.38270622f, -0.30280077f, -0.34016776f, 
    -0.07940726f, -0.02814789f, 0.01238905f, -0.01766231f, 0.03834894f, -0.07994672f, -0.16096866f, 0.10889412f, 
    -0.07046136f, -0.16246815f, 0.03468017f, -0.04902802f, 0.14501549f, 0.20139979f, -0.07047892f, 0.08101016f, 
    0.12139460f, -0.01290278f, 0.00238272f, 0.14021660f, 0.17017286f, 0.16758783f, 0.13744609f, 0.13653572f, 
    -0.05920293f, -0.02566344f, -0.01925198f, 0.03335520f, -0.04088886f, -0.01250404f, -0.01114301f, 0.01045796f, 
    -0.01674934f, 0.40958980f, -0.00634933f, 0.11330584f, -0.19288726f, -0.20110752f, -0.09783285f, 0.01491622f, 
    -0.12641788f, -0.11880351f, 0.02115406f, 0.00836024f, -0.07565413f, -0.07781859f, 0.14307417f, 0.09179354f, 
    -0.05906688f, -0.05908793f, 0.06372466f, 0.04092396f, 0.22203687f, 0.16570085f, 0.01971724f, 0.03158878f, 
    0.02256935f, -0.23051819f, 0.15231746f, 0.11653695f, -0.07665026f, 0.08768734f, -0.05913122f, -0.04394768f, 
    0.27802935f, 0.10150252f, -0.03745820f, -0.06213627f, 0.25401369f, 0.24928068f, -0.17923243f, 0.12194374f, 
    -0.04382220f, 0.01051322f, -0.07011058f, 0.04666412f, -0.00230295f, 0.06635161f, -0.12388964f, 0.03228567f, 
    0.17184928f, 0.16882285f, -0.25899178f, 0.18760864f, -0.00436681f, -0.11081661f, 0.16785498f, 0.36150450f, 
    -0.07345179f, 0.02969907f, 0.09146608f, -0.08138668f, 0.22332370f, -0.40553522f, -0.30019376f, 0.03712718f, 
    0.30926245f, -0.15372792f, 0.20775439f, 0.25551441f, -0.02385127f, -0.03695156f, -0.06975338f, -0.04798152f, 
    -0.64161390f, 0.16075660f, -0.44740725f, -0.52086848f, -0.01495769f, -0.03770970f, -0.07435778f, 0.11070433f, 
    0.21063420f, -0.17998585f, -0.00932464f, -0.08783164f, 0.08886148f, -0.13090199f, -0.53797936f, -0.43168193f, 
    -0.01274730f, 0.22637406f, -0.21492404f, 0.12169765f, -0.12106465f, -0.10007484f, 0.04365677f, -0.02226380f, 
    0.11631834f, -0.05749885f, -0.14352350f, -0.00314301f, 0.06085160f, 0.09629529f, 0.00189800f, 0.00080385f, 
    0.02569227f, 0.10887410f, 0.02583836f, -0.01226990f, 0.40154773f, 0.21722342f, 0.03821632f, 0.02620922f, 
    -0.09113654f, 0.01735236f, 0.00891687f, 0.12925006f, 0.15515307f, 0.18054384f, 0.05530201f, 0.12862206f, 
    0.35594225f, 0.17981251f, 0.16072758f, 0.10515980f, -0.08780170f, -0.10619061f, 0.01613929f, 0.03582328f, 
    -0.02471808f, 0.06050007f, 0.01789214f, 0.06215934f, 0.08739990f, 0.07661482f, 0.12075727f, 0.00805709f, 
    0.00189455f, 0.15905011f, -0.08681990f, -0.00191357f, 0.11930196f, -0.03993741f, -0.01794631f, -0.00943614f, 
    0.11954017f, 0.17802522f, 0.24511302f, 0.24325690f, 0.00906733f, -0.04396229f, -0.00729660f, 0.04448404f, 
    -0.11774997f, 0.14031532f, 0.02803173f, 0.08145566f, -0.00639193f, 0.12050720f, 0.13919634f, 0.01095116f, 
    -0.05993675f, 0.12832817f, 0.03323922f, 0.05254995f, 0.02285273f, -0.10873190f, -0.00269107f, 0.09204431f, 
    -0.23751585f, -0.00716590f, 0.00723538f, 0.13224341f, 0.12204615f, 0.06440774f, -0.03609829f, -0.14106143f, 
    0.19578606f, 0.08363831f, -0.00946377f, -0.01578667f, -0.25356865f, -0.22309919f, -0.15864807f, -0.03466431f, 
    -0.02813414f, -0.00770204f, -0.01648029f, 0.06074339f, -0.00579985f, -0.05035450f, -0.04829466f, 0.00286146f, 
    0.22404063f, 0.24453089f, -0.09290995f, 0.05926970f, 0.07047876f, 0.08344175f, 0.07672585f, 0.01167145f, 
    -0.03872865f, -0.02011234f, -0.04335599f, -0.00470108f, -0.11041499f, -0.12377942f, -0.07953621f, -0.17689972f, 
    -0.05311319f, -0.05826187f, 0.00713272f, -0.12452270f, -0.09597124f, -0.02057195f, -0.10640808f, -0.04443848f, 
    -0.07288420f, -0.30398309f, 0.16591473f, 0.03090068f, 0.06901821f, -0.00044756f, -0.09150659f, 0.12584417f, 
    0.20174384f, 0.04309288f, -0.03671009f, -0.14570495f, 0.01754807f, 0.16412513f, -0.08867351f, -0.12146921f, 
    0.03680835f, 0.09407830f, -0.03988462f, 0.08579972f, 0.03667537f, -0.03516693f, -0.11686728f, -0.04330778f, 
    -0.03453485f, 0.11879312f, 0.18412812f, 0.25417814f, -0.02277240f, 0.00173693f, 0.02134990f, 0.04883965f, 
    -0.05769746f, 0.09258533f, 0.06748711f, -0.06008624f, -0.14584549f, 0.08707235f, 0.06908413f, 0.09956834f, 
    -0.11953197f, 0.08094445f, 0.02405033f, 0.27390811f, 0.06563681f, 0.03849463f, 0.17066666f, -0.10345493f, 
    0.18346536f, 0.03890234f, 0.20531477f, -0.06490820f, -0.02625300f, -0.00832159f, 0.08529840f, -0.09736867f, 
    -0.05820313f, -0.07244848f, 0.01944536f, 0.06044757f, 0.08247822f, 0.11799064f, 0.26342353f, 0.35541248f, 
    -0.16173838f, -0.03092570f, 0.17787951f, 0.17727092f, 0.05827916f, -0.00899174f, 0.12467508f, -0.03450543f, 
    -0.13965088f, 0.07922946f, -0.15058686f, -0.12798001f, 0.03958431f, -0.15840982f, 0.02508781f, -0.04220394f, 
    0.00134017f, 0.07602351f, -0.04807008f, -0.00524874f, -0.17401944f, 0.06017989f, -0.10982559f, -0.15315636f, 
    -0.09295411f, 0.08764181f, -0.16611657f, 0.08291733f, -0.10891495f, -0.00046310f, -0.15268947f, -0.10906506f, 
    -0.02565472f, -0.04957179f, -0.17035106f, -0.20281506f, -0.04007547f, -0.11878461f, 0.00725588f, 0.02371334f, 
    -0.07049298f, 0.03000189f, -0.02383567f, 0.02364751f, -0.01283952f, 0.09770188f, -0.21183203f, -0.00499492f, 
    0.08228516f, 0.10429230f, 0.10779227f, 0.04720235f, 0.01788682f, -0.03714515f, -0.01053249f, 0.07230730f, 
    -0.02975606f, 0.27340525f, 0.34121844f, 0.05296410f, -0.14230205f, -0.14400925f, 0.07788906f, 0.18865119f, 
    -0.08426730f, 0.10505593f, 0.14767103f, -0.02382540f, -0.20129789f, 0.17177044f, 0.14276591f, -0.11176281f, 
    -0.11782058f, -0.13278161f, -0.10016392f, 0.03810070f, -0.05701946f, 0.04241925f, 0.25339255f, 0.16667525f, 
    0.03829689f, -0.17252910f, 0.05100448f, 0.21245201f, 0.08313272f, 0.10543919f, -0.08021820f, 0.26400387f, 
    0.01049273f, 0.03339217f, 0.15528707f, 0.13047704f, 0.33092400f, 0.01681381f, 0.06704114f, 0.03548551f, 
    -0.21847020f, -0.07065867f, -0.07720404f, -0.06173090f, 0.01933379f, -0.03509437f, -0.02139933f, 0.02747305f, 
    -0.08502535f, 0.12423652f, -0.31400254f, 0.27708521f, -0.19788523f, -0.06947319f, -0.10674152f, 0.00388737f, 
    -0.03541546f, -0.04119376f, 0.00038544f, -0.04443493f, 0.04599816f, 0.01921252f, 0.06766844f, 0.03536751f, 
    -0.04957558f, 0.05960291f, 0.05881321f, 0.02006909f, 0.20134734f, 0.34702200f, 0.19185996f, 0.02597575f, 
    -0.02478066f, 0.15577726f, 0.08735416f, -0.08377032f, 0.26363787f, -0.02212292f, -0.07430888f, 0.09393698f, 
    0.07365005f, 0.13167360f, -0.21065399f, -0.05510630f, 0.03874661f, 0.31706211f, 0.01025992f, -0.09091785f, 
    0.04197039f, -0.14175032f, -0.00303493f, -0.02315615f, 0.12681556f, -0.00242579f, -0.02904493f, -0.03043930f, 
    -0.17944327f, -0.41576242f, -0.14233775f, -0.23707072f, -0.05731401f, -0.08013158f, 0.02631909f, -0.12277155f, 
    -0.01363029f, -0.08470516f, 0.02425406f, 0.03491873f, -0.27548885f, -0.25187704f, 0.09861413f, -0.16872162f, 
    0.18368892f, -0.00354556f, 0.10876747f, 0.03824595f, 0.08137266f, 0.00266663f, 0.12777938f, 0.01918907f, 
    0.32318020f, 0.29349357f, 0.06950150f, 0.06725754f, -0.11788104f, 0.00241295f, 0.13532603f, 0.00131633f, 
    0.01330669f, 0.15871137f, 0.18497542f, 0.24914016f, -0.17448854f, -0.38314226f, 0.25412500f, -0.17155917f, 
    -0.14530683f, -0.15124002f, -0.12792930f, 0.04120230f, -0.16239803f, -0.15163200f, -0.03547053f, -0.14952379f, 
    -0.05144485f, 0.00503714f, -0.05861031f, 0.04035100f, 0.20515594f, -0.13829283f, 0.03839307f, 0.07700067f, 
    -0.11542485f, -0.11840386f, -0.05836767f, -0.07107018f, 0.43514505f, 0.05345345f, -0.04375222f, 0.11734594f, 
    -0.00545292f, 0.07974875f, 0.02181714f, 0.03072116f, 0.05329306f, -0.05836865f, 0.08373296f, -0.00582623f, 
    0.28923756f, -0.01548957f, 0.03589422f, 0.04684479f, -0.14293498f, -0.09193000f, -0.11797155f, -0.10173241f, 
    0.06353469f, 0.03282711f, -0.06055749f, 0.02062756f, -0.07499440f, -0.00705996f, -0.07832811f, 0.01654160f, 
    0.12579422f, 0.11559399f, -0.23203163f, 0.03187450f, 0.07298643f, -0.09665269f, -0.12936825f, -0.23683646f, 
    0.46375811f, -0.04145811f, 0.25654849f, 0.00700277f, -0.23213330f, -0.23566940f, -0.09832700f, -0.01669898f, 
    0.08535785f, 0.02276333f, 0.06146300f, 0.10937753f, 0.13153927f, 0.03033286f, 0.07140753f, 0.12464781f, 
    -0.07725505f, -0.12106197f, -0.07158361f, -0.00602429f, 0.03756616f, 0.01621478f, 0.08443868f, 0.06726971f, 
    0.01545359f, -0.12004642f, 0.16745308f, 0.05841246f, -0.02292496f, -0.03955701f, -0.10722180f, 0.01438711f, 
    0.03076621f, -0.10419070f, -0.02798810f, -0.01469450f, -0.19985139f, -0.03520554f, -0.21049593f, 0.14980605f, 
    -0.03739664f, 0.03987635f, 0.02432931f, 0.03759893f, -0.03137152f, -0.09853276f, 0.05926026f, 0.07338794f, 
    -0.06684445f, 0.17879549f, -0.04734188f, 0.01946839f, -0.04680544f, 0.01598367f, 0.12928553f, -0.16218221f, 
    0.13613379f, 0.06584751f, 0.00711776f, 0.07868672f, 0.04606522f, 0.00536663f, 0.04445859f, 0.12310015f, 
    0.02451524f, -0.04157555f, 0.11921015f, -0.04923982f, 0.08583812f, -0.17076813f, 0.02709575f, 0.01743520f, 
    0.09752704f, -0.07621010f, 0.27383369f, 0.07211402f, 0.01960421f, 0.07025787f, -0.25423539f, 0.08785949f, 
    0.00944111f, -0.13350382f, -0.11883669f, -0.24575794f, 0.05574566f, 0.00747374f, -0.19625732f, 0.15417944f, 
    0.00941011f, -0.03719931f, 0.06734124f, -0.00113841f, -0.01546222f, 0.03348671f, -0.18851353f, -0.08151682f, 
    -0.06708658f, 0.30844721f, -0.08956027f, 0.17037635f, 0.00857557f, 0.00363138f, 0.08332082f, 0.14225304f, 
    0.06630772f, -0.04264564f, 0.01456390f, -0.08366456f, 0.30585885f, 0.10120167f, 0.07112353f, -0.24617997f, 
    0.06225166f, 0.00460989f, 0.00571013f, 0.41469279f, 0.03107661f, -0.07328613f, 0.02707498f, -0.01035744f, 
    -0.20309535f, 0.23701751f, -0.01340228f, -0.31625888f, -0.17017378f, -0.20333356f, 0.18025668f, -0.03221508f, 
    0.08333939f, 0.00858631f, 0.08806620f, 0.13190889f, 0.01372808f, 0.07597897f, -0.06101808f, -0.04251105f, 
    -0.03422559f, 0.08020327f, -0.01983788f, 0.14723919f, 0.08331262f, -0.07505031f, 0.02679352f, -0.10019801f, 
    0.14540944f, -0.26852980f, -0.00988727f, -0.10063933f, 0.09488270f, 0.19160445f, -0.04125511f, -0.14530016f, 
    -0.11634925f, -0.07230681f, -0.10651784f, -0.09008066f, -0.01076687f, -0.21379851f, 0.07831432f, -0.12853971f, 
    0.11725419f, -0.04012983f, -0.02477649f, -0.05199894f, 0.05646851f, 0.15011421f, -0.16750592f, 0.02831380f, 
    0.27156013f, -0.05821785f, -0.03603447f, -0.02469018f, 0.10111052f, -0.05543271f, 0.05497989f, 0.08175553f, 
    -0.00095450f, -0.14264570f, 0.05007616f, 0.05884757f, 0.13500173f, -0.05397020f, 0.01023315f, 0.02939756f, 
    -0.07301072f, -0.07441720f, 0.03257250f, -0.06103274f, -0.01486844f, -0.23575501f, -0.07045966f, -0.13473623f, 
    -0.49235812f, 0.23550436f, 0.05699419f, 0.26677963f, -0.11838159f, -0.06978676f, -0.13731016f, 0.01500753f, 
    -0.09240320f, 0.02223440f, -0.00436775f, -0.11480160f, 0.05091843f, -0.09508918f, 0.12810288f, 0.26603082f, 
    -0.15912159f, 0.05225944f, 0.04817031f, 0.00873419f, 0.09921204f, -0.02774177f, 0.13825795f, -0.11260539f, 
    -0.26511499f, -0.11466476f, 0.00362062f, -0.03624279f, -0.00583468f, 0.08200905f, 0.05522761f, -0.05958812f, 
    0.01754867f, -0.07332130f, -0.06938519f, 0.08971762f, 0.11360766f, 0.04127377f, -0.10405836f, -0.15267383f, 
    0.10974413f, -0.13511744f, 0.02768207f, 0.08606840f, -0.07650805f, 0.09731628f, -0.01782021f, 0.00878247f, 
    0.19054444f, -0.10023870f, 0.08279359f, -0.03337686f, 0.05535822f, 0.09706073f, 0.00336490f, -0.00713745f, 
    -0.09775117f, -0.08359103f, -0.00496643f, -0.06409758f, -0.08005317f, 0.01476968f, -0.20580108f, -0.26954728f, 
    -0.10923143f, -0.04833091f, -0.14355275f, 0.00093599f, 0.06650618f, 0.05103722f, 0.08617806f, 0.10781877f, 
    0.06854977f, -0.20211393f, 0.18963800f, 0.03334238f, -0.07783157f, 0.08371655f, 0.11466470f, 0.03801572f, 
    0.14791347f, 0.04250196f, 0.14429407f, 0.02463230f, -0.01681632f, -0.00397247f, 0.15004809f, 0.08415585f, 
    0.06686050f, 0.26267561f, 0.06820413f, -0.10600214f, -0.00955247f, 0.00557766f, 0.07190014f, 0.12178999f, 
    0.17928186f, -0.00328957f, 0.15946339f, 0.17635949f, 0.17803635f, -0.05167108f, 0.11471367f, -0.02349379f, 
    0.03300736f, -0.03168671f, -0.08048718f, 0.03584338f, -0.30789974f, 0.00022256f, 0.04254521f, 0.29280984f, 
    -0.02567117f, 0.07500955f, -0.07620916f, -0.23406832f, -0.04745747f, -0.14587688f, 0.04363258f, 0.04768531f, 
    0.16056894f, 0.00733480f, 0.15542628f, 0.09795948f, 0.05249086f, -0.03592071f, -0.05475995f, 0.04213583f, 
    0.03422977f, 0.00560526f, 0.04222628f, -0.02654605f, -0.22970262f, 0.04223647f, -0.02863542f, 0.15504099f, 
    -0.11860679f, -0.05790805f, 0.06798530f, -0.05861560f, 0.01334525f, 0.02640310f, -0.04709020f, 0.04448050f, 
    -0.05139782f, 0.17763704f, -0.12517884f, 0.31239155f, 0.11050267f, 0.15218332f, 0.10754952f, 0.17189102f, 
    0.15261388f, 0.09991653f, 0.02271463f, 0.07182386f, -0.19064501f, 0.26464704f, -0.04260160f, 0.14251913f, 
    0.03047360f, 0.01192933f, 0.13953349f, 0.04277972f, 0.03836684f, -0.00011862f, 0.04617636f, 0.22989736f, 
    -0.20623690f, 0.14764793f, 0.05043592f, 0.08323035f, 0.00644224f, 0.09739376f, 0.08629585f, -0.03752829f, 
    -0.05101429f, 0.04560576f, -0.01284292f, -0.09523358f, -0.22634037f, 0.08254624f, -0.14355370f, 0.07458436f, 
    0.02944381f, 0.00839409f, 0.10474049f, -0.18747635f, 0.08376063f, 0.04595886f, 0.20789124f, 0.09471887f, 
    0.18276164f, 0.11681132f, -0.07134449f, 0.07493550f, -0.17047380f, 0.03729320f, -0.06668548f, -0.13019669f, 
    -0.05595622f, -0.02504013f, 0.01181218f, -0.06548340f, 0.03100018f, 0.01920401f, 0.01159382f, 0.12765369f, 
    -0.01380992f, 0.01555464f, -0.08638891f, -0.06737801f, 0.08301261f, -0.02938658f, 0.03556186f, 0.02192449f, 
    0.00505339f, -0.05260443f, 0.16921648f, 0.06426426f, -0.14245477f, 0.00360757f, -0.05072673f, 0.01976484f, 
    0.02525707f, -0.13127059f, -0.01873856f, -0.15745333f, -0.18766031f, -0.34980562f, -0.36594382f, -0.24078354f, 
    0.10596517f, -0.09802997f, 0.14783019f, 0.00243709f, 0.04360736f, 0.02165135f, 0.01120978f, 0.01494600f, 
    0.18277591f, -0.15244836f, -0.59303075f, -0.11615679f, 0.04630328f, -0.05353371f, -0.01791475f, 0.01864243f, 
    -0.14862466f, 0.11179544f, 0.02668058f, 0.05653812f, -0.09702963f, -0.17584890f, -0.04289723f, -0.04341124f, 
    0.10653493f, -0.02785344f, -0.14975761f, -0.29712313f, -0.07871733f, -0.17019342f, -0.00761647f, -0.13401920f, 
    -0.26562220f, -0.31168306f, 0.18607639f, 0.15384130f, -0.06855498f, 0.08247073f, -0.00842040f, 0.05754265f, 
    0.18423174f, 0.11939665f, 0.05375311f, 0.11000757f, -0.01473825f, 0.08387419f, -0.32008511f, 0.06475038f, 
    -0.03074283f, -0.16661535f, 0.03072291f, 0.02985129f, 0.01564415f, 0.17985125f, -0.00383218f, 0.07392517f, 
    -0.03817720f, 0.11313108f, 0.17276700f, 0.07771402f, -0.05495827f, -0.11949797f, 0.04623089f, 0.05567708f, 
    -0.13482055f, -0.04290822f, -0.05762307f, 0.12765656f, 0.34160659f, 0.26539186f, 0.23183231f, 0.07450614f, 
    -0.09102457f, 0.03393530f, -0.05733697f, 0.14426541f, 0.02310935f, -0.02322402f, -0.05444239f, 0.03713341f, 
    -0.18049878f, 0.10931239f, 0.25746474f, -0.19404431f, 0.01748488f, -0.05765961f, 0.11758771f, 0.01456280f, 
    -0.06097360f, 0.02321387f, 0.10577238f, -0.12333552f, 0.21999437f, 0.27960017f, 0.33086464f, 0.24041818f, 
    0.07241379f, 0.12326025f, 0.25451440f, 0.21434748f, 0.09430208f, -0.07782472f, 0.07990000f, 0.00586025f, 
    -0.30507362f, -0.05808688f, 0.09176564f, -0.06254242f, -0.12872316f, 0.06636488f, 0.03288751f, 0.12515704f, 
    0.06968485f, 0.06966145f, 0.23826772f, 0.03141326f, 0.15506361f, -0.30515552f, -0.03655202f, -0.22007726f, 
    -0.05806983f, -0.00850678f, -0.14620878f, -0.09245156f, -0.09464847f, 0.04074342f, -0.06221778f, -0.12009590f, 
    -0.02837862f, -0.19341341f, -0.18602648f, -0.39729989f, 0.11645816f, -0.26895294f, -0.05454719f, -0.03937187f, 
    0.06687555f, 0.04691822f, 0.12492368f, 0.01947545f, -0.14257415f, 0.09973744f, -0.09787409f, 0.02825397f, 
    -0.12932241f, -0.00564901f, 0.16291876f, 0.10221221f, -0.18064892f, 0.11163592f, 0.10153216f, 0.11920074f, 
    -0.05132186f, -0.06018274f, 0.40328041f, 0.18965729f, -0.17735723f, -0.27399701f, -0.09631039f, 0.14912738f, 
    0.08054856f, 0.10778462f, 0.10520145f, 0.12297864f, 0.14128162f, -0.14275204f, 0.17380562f, 0.29023623f, 
    -0.17110755f, -0.21003380f, -0.00383027f, 0.03123714f, 0.08833390f, 0.16213584f, 0.17778662f, -0.09001915f, 
    -0.31151664f, -0.41830042f, 0.11123925f, 0.23039052f, -0.10025635f, -0.00731483f, -0.07687569f, 0.10597020f, 
    0.15857370f, 0.08939072f, 0.15359674f, 0.11526100f, 0.09025730f, 0.07208972f, -0.14665623f, 0.03666213f, 
    0.01196501f, 0.11760227f, -0.02337181f, 0.09398978f, 0.02718653f, 0.07315823f, 0.01502996f, 0.02978390f, 
    0.25300512f, -0.01245442f, -0.09018356f, 0.20985833f, 0.08637404f, 0.16822161f, -0.00535027f, 0.00267795f, 
    0.04789866f, 0.02522648f, 0.06858604f, 0.16443689f, -0.06477714f, -0.15143235f, -0.38917771f, -0.00995791f, 
    -0.02351120f, -0.08974005f, -0.00806463f, 0.03775256f, 0.17665248f, 0.22709155f, 0.16498564f, 0.00088200f, 
    -0.32902619f, 0.10974225f, 0.09277317f, -0.03751645f, 0.11170621f, 0.14357123f, -0.07060517f, 0.08361447f, 
    -0.04631569f, 0.12498474f, -0.10916528f, -0.19125575f, 0.12415881f, -0.14796455f, -0.01818011f, 0.13144882f, 
    0.12872456f, 0.19990167f, -0.05466516f, 0.06466644f, -0.00525723f, -0.02543850f, -0.10863406f, 0.04185512f, 
    0.05314226f, 0.21715964f, 0.05314329f, 0.32128093f, 0.13625345f, 0.00122664f, 0.10776453f, 0.03283685f, 
    -0.06911829f, -0.07028686f, -0.00863459f, -0.07293200f, -0.21982643f, 0.26393896f, 0.29059133f, -0.01050686f, 
    -0.06640141f, 0.09919298f, 0.15689488f, 0.00656799f, 0.14219673f, -0.12294879f, 0.11972138f, -0.03043268f, 
    -0.24050556f, 0.37104243f, -0.19825754f, -0.14084229f, -0.05702105f, -0.12005349f, 0.07134796f, -0.08027799f, 
    0.19950300f, 0.10546710f, 0.06326939f, 0.09727553f, -0.31570801f, -0.08402278f, 0.11913327f, 0.06802914f, 
    -0.16311750f, -0.03337779f, -0.08600450f, 0.09591986f, 0.04358418f, -0.20880087f, -0.03212880f, -0.02243493f, 
    0.19637713f, -0.24462672f, -0.14153582f, 0.06709085f, 0.12253036f, 0.02386651f, 0.13441865f, 0.06425443f, 
    -0.07148994f, -0.02220892f, -0.29234266f, -0.23267609f, -0.10589980f, 0.03662742f, -0.16921535f, -0.04261663f, 
    0.07746591f, -0.02785223f, 0.08855414f, 0.06235706f, -0.01591348f, -0.00420868f, -0.01638517f, 0.21764922f, 
    0.17263846f, 0.12364350f, -0.21339746f, -0.07399753f, 0.04194771f, 0.05453898f, 0.04357664f, 0.08166618f, 
    -0.00211737f, -0.10449263f, 0.06429790f, -0.16650982f, 0.04813711f, -0.01586932f, -0.15613033f, 0.04174583f, 
    -0.03640764f, -0.03061071f, -0.02322692f, -0.30870748f, 0.02107341f, -0.22519673f, -0.06476402f, -0.22247632f, 
    0.28005356f, 0.29726660f, 0.14514455f, -0.02239683f, 0.01863475f, 0.05438011f, 0.14636984f, 0.07166537f, 
    0.09088581f, 0.01838062f, 0.01533852f, 0.03506047f, -0.06975027f, 0.37132958f, 0.03537407f, 0.07007004f, 
    0.07254373f, 0.11926756f, 0.08788215f, -0.04905755f, 0.00465453f, -0.06843786f, -0.07812329f, 0.02472950f, 
    0.15401487f, 0.35921395f, 0.20329013f, -0.04344298f, 0.13917437f, -0.02465177f, 0.02273071f, 0.13108285f, 
    0.07482935f, -0.17540200f, -0.09370548f, -0.13274607f, -0.62204885f, -0.31297964f, 0.14614554f, 0.11341790f, 
    -0.02773415f, -0.11858282f, -0.19471835f, -0.13454793f, 0.20177457f, 0.07875390f, -0.17274646f, 0.09731100f, 
    -0.33616039f, 0.17790014f, 0.29897556f, 0.04718133f, -0.11196353f, -0.10321609f, -0.16010283f, -0.01020541f, 
    0.03748245f, -0.04046834f, -0.21301994f, 0.00484643f, 0.03680543f, -0.28191283f, -0.14509289f, 0.13283342f, 
    -0.05912067f, -0.04012508f, -0.02227152f, -0.18314615f, 0.09268743f, -0.08609906f, -0.15540178f, 0.18053174f, 
    0.16051111f, -0.04806734f, -0.06262445f, 0.12342263f, 0.01109222f, 0.01419479f, 0.06905577f, 0.08599285f, 
    0.22842701f, 0.16345732f, 0.04241933f, 0.13205083f, -0.06621582f, -0.11092559f, -0.15487759f, -0.01407704f, 
    0.11207955f, -0.11334787f, 0.10122240f, 0.08834562f, 0.06605080f, -0.02122803f, 0.04044986f, 0.01709082f, 
    0.18659708f, 0.11977424f, 0.28034270f, -0.06723580f, 0.13152213f, -0.04151836f, -0.05275929f, 0.08647304f, 
    -0.04195184f, 0.01637009f, 0.07442703f, 0.02878827f, 0.25316423f, 0.14442801f, -0.17904243f, -0.07858513f, 
    -0.09010362f, -0.06956051f, 0.15526776f, 0.00887384f, -0.12627676f, -0.01436619f, 0.04652535f, -0.06299865f, 
    0.31696811f, -0.10647898f, 0.05807024f, 0.03650740f, 0.01995235f, 0.02835884f, 0.07102588f, -0.02407571f, 
    0.08991888f, 0.07264192f, -0.02648317f, 0.11492740f, 0.15586483f, 0.25858670f, 0.41146791f, 0.25319111f, 
    0.08469580f, 0.05692885f, 0.06713167f, 0.06175512f, 0.08113830f, -0.15487094f, -0.05322920f, -0.09408545f, 
    -0.30215514f, 0.03197071f, -0.22232476f, 0.06038416f, 0.16571750f, 0.03216607f, 0.07010578f, 0.16303697f, 
    0.25504202f, 0.08580395f, 0.06919994f, 0.20864902f, 0.01088459f, -0.06771536f, -0.19373670f, 0.14213085f, 
    -0.15413144f, -0.11941093f, -0.24710572f, 0.28587976f, 0.04878993f, 0.03307946f, 0.08539098f, -0.14507011f, 
    -0.03034571f, -0.15948878f, -0.28904948f, -0.00773863f, -0.11695355f, -0.08994566f, -0.14730707f, 0.00130239f, 
    -0.07267337f, -0.00894251f, 0.06712460f, -0.00602823f, -0.17080231f, -0.15727054f, -0.01910330f, -0.22170524f, 
    -0.14112042f, -0.00154350f, -0.01893164f, 0.07197993f, -0.12593907f, 0.04047369f, -0.04613281f, -0.04460656f, 
    0.33404881f, 0.10767861f, -0.05238231f, -0.03228471f, 0.11193898f, 0.23320463f, 0.08701541f, 0.02242447f, 
    0.10340441f, 0.07695065f, -0.03987430f, 0.09229548f, 0.08423171f, 0.17599247f, -0.04444597f, -0.03521461f, 
    0.12459426f, -0.04669362f, -0.08565817f, -0.01292071f, -0.01658967f, -0.01414079f, 0.18644951f, 0.09128439f, 
    0.39374948f, 0.38630462f, 0.09659771f, 0.09519278f, 0.00659748f, -0.02525049f, 0.14875834f, 0.16359003f, 
    -0.05791370f, -0.04641904f, -0.00162660f, -0.05148241f, -0.69057006f, -0.79240608f, 0.50110781f, -0.12981455f, 
    0.10636052f, 0.22455315f, 0.12536789f, -0.19498809f, 0.09701525f, -0.20811185f, -0.07402676f, 0.09608837f, 
    -0.09823982f, 0.16028841f, -0.01602469f, -0.04793628f, 0.07275568f, 0.08721206f, -0.04784192f, -0.03213809f, 
    0.03232027f, 0.10007961f, 0.00601021f, 0.08179402f, -0.33704248f, -0.53970683f, -0.33110964f, 0.20956729f, 
    0.21447931f, 0.01183328f, -0.06063503f, -0.34443107f, 0.03606881f, 0.12850845f, 0.07551705f, 0.12266941f, 
    -0.05281472f, 0.10010069f, -0.16946240f, -0.11131438f, -0.15908097f, -0.03240590f, 0.19905968f, -0.00535775f, 
    -0.02215077f, 0.04230927f, -0.00765970f, 0.10804696f, -0.10806103f, -0.05707291f, 0.00596483f, -0.31146407f, 
    -0.24331865f, -0.09771085f, -0.02572131f, 0.13453333f, 0.02285898f, 0.15677167f, -0.04062782f, -0.11232115f, 
    0.12536964f, 0.00465914f, 0.06315020f, -0.25542593f, -0.02104194f, 0.17347610f, -0.08390106f, 0.12499810f, 
    -0.11362487f, 0.01048168f, -0.05522661f, 0.10942327f, 0.22234038f, 0.12003875f, 0.02879601f, -0.01065348f, 
    -0.06826441f, 0.02400275f, -0.04734248f, 0.01699174f, -0.22431168f, 0.10218880f, 0.02799252f, 0.14692743f, 
    0.12457639f, -0.12445588f, 0.39136794f, 0.05135428f, -0.09704649f, 0.18165021f, -0.10943994f, -0.01130095f, 
    -0.06915846f, 0.10990988f, 0.10919643f, -0.07343494f, 0.47589469f, 0.19486007f, 0.21531016f, 0.13544807f, 
    0.12717502f, 0.04036105f, 0.20432572f, 0.02561609f, -0.21888766f, -0.10223962f, -0.02872034f, -0.02279098f, 
    -0.31035551f, 0.08940049f, 0.16527614f, -0.35208783f, -0.07167555f, -0.16732150f, -0.06461298f, -0.10511915f, 
    0.03347087f, -0.14332463f, -0.05267414f, -0.05985816f, -0.13888015f, -0.33989957f, -0.09530190f, -0.01646383f, 
    -0.12468609f, -0.06343768f, -0.12913714f, -0.31282240f, -0.13225801f, -0.02946662f, 0.03287416f, -0.10260251f, 
    -0.10144278f, -0.48464215f, -0.56684673f, -0.14333521f, -0.00200256f, -0.32478294f, -0.05137287f, -0.19784464f, 
    -0.03906015f, 0.04564591f, -0.15492994f, -0.02134047f, -0.02017646f, 0.16805637f, 0.23270766f, -0.20229977f, 
    0.09601202f, -0.05086645f, 0.05716784f, 0.03809988f, -0.13061322f, 0.04559660f, -0.13365899f, -0.03419514f, 
    0.19178140f, -0.24589595f, 0.01694760f, -0.02410356f, 0.10041586f, -0.05058547f, 0.03601692f, 0.13418473f, 
    0.15656699f, -0.10076801f, 0.06548180f, 0.06221085f, 0.35906568f, 0.01430139f, 0.13929044f, 0.23241520f, 
    -0.11742386f, -0.18744022f, -0.01698027f, 0.18614952f, 0.07413249f, 0.18232414f, -0.08942670f, -0.20812106f, 
    -0.09828430f, -0.23378341f, -0.05868403f, 0.13843197f, 0.02921994f, 0.07240723f, -0.07990558f, 0.11896594f, 
    -0.00752110f, 0.14965974f, 0.08703382f, 0.19686149f, 0.00912984f, 0.02900820f, 0.02334174f, -0.06260461f, 
    -0.12946244f, 0.02950981f, 0.04830308f, 0.02397075f, 0.16895464f, 0.00922386f, -0.09996005f, -0.05837294f, 
    -0.11824156f, -0.06802563f, 0.06959045f, 0.20514593f, -0.02989392f, 0.11215769f, 0.21013419f, 0.02183658f, 
    0.03721558f, -0.21363215f, -0.04152443f, 0.22303918f, 0.02896620f, 0.06157003f, -0.18884014f, -0.08581810f, 
    -0.03341362f, -0.20384832f, 0.20171137f, 0.27272010f, 0.23602958f, 0.17639378f, 0.19155149f, 0.10865176f, 
    -0.10389412f, 0.44448638f, -0.08392284f, -0.02935597f, 0.06988446f, 0.01305662f, -0.05431223f, 0.06868590f, 
    -0.12153807f, 0.03597330f, 0.01503702f, -0.06600393f, 0.03533658f, 0.00902079f, 0.00436679f, -0.12960434f, 
    0.09118573f, 0.05619442f, -0.04355730f, 0.04423665f, -0.03207239f, -0.16367061f, 0.11883152f, -0.20870264f, 
    -0.08357961f, 0.08156774f, 0.01378960f, 0.47341788f, -0.11220414f, 0.19336340f, -0.01110602f, 0.00689236f, 
    -0.12663344f, -0.10673072f, -0.14060830f, 0.00282921f, -0.27999055f, 0.20955649f, 0.37024158f, 0.32180119f, 
    0.20367739f, -0.00620220f, 0.17376631f, -0.00925570f, 0.10586603f, -0.15953523f, 0.11681506f, 0.11778000f, 
    0.12111393f, 0.36333495f, -0.22276063f, 0.50623876f, -0.07949165f, -0.03094194f, -0.03460309f, 0.03457270f, 
    0.15555394f, 0.07789493f, 0.07604613f, 0.13108359f, -0.06308411f, -0.14605325f, -0.15363805f, -0.09886089f, 
    0.09319728f, -0.01677387f, -0.03709364f, 0.02221216f, -0.09765797f, -0.12631395f, -0.17524403f, 0.10063118f, 
    0.13500881f, -0.23862241f, 0.08151336f, -0.27875990f, -0.14088865f, 0.19009985f, -0.13221344f, -0.08982992f, 
    -0.34341088f, 0.07982352f, -0.12685204f, -0.16885884f, -0.07163411f, -0.07536127f, 0.06138976f, -0.16055779f, 
    0.08782628f, -0.21737979f, 0.06871519f, -0.07696851f, 0.21150219f, -0.03116864f, 0.14395659f, 0.08499681f, 
    -0.10631347f, 0.00979250f, 0.06074974f, -0.02650033f, 0.02933519f, -0.00339838f, 0.00226496f, 0.15273976f, 
    -0.09463499f, -0.29228345f, -0.07129527f, 0.02561843f, 0.44508278f, -0.07125390f, 0.06840193f, -0.16135253f, 
    -0.08541913f, 0.02970972f, -0.05660545f, -0.29394051f, 0.10708831f, -0.06815960f, -0.16672139f, -0.31226155f, 
    -0.02263365f, 0.10683680f, 0.06173341f, 0.16146941f, -0.04706385f, -0.05783720f, -0.13085435f, 0.04092418f, 
    -0.06658245f, 0.16657364f, 0.09457926f, 0.15332039f, 0.30195001f, 0.22818889f, 0.23056872f, 0.08064343f, 
    -0.06281404f, 0.03848333f, -0.00639674f, 0.13032173f, -0.18769406f, -0.16296463f, 0.00711412f, 0.04051723f, 
    -0.19652712f, -0.16865210f, -0.15250491f, 0.00486326f, -0.16414964f, 0.14031310f, -0.04398538f, -0.03856247f, 
    -0.17435174f, -0.04502085f, -0.00061018f, 0.17771159f, -0.09284917f, -0.12712425f, -0.21108988f, -0.10304528f, 
    -0.04046477f, -0.00163330f, 0.16179883f, -0.05031459f, -0.01008385f, 0.13397905f, 0.00436465f, 0.08714898f, 
    -0.21963879f, 0.15703878f, -0.02028028f, 0.08108047f, -0.36481670f, 0.15208012f, 0.21611139f, -0.05424167f, 
    0.01413706f, -0.05330702f, -0.08185956f, 0.00968776f, -0.07457353f, 0.18419786f, 0.18700747f, -0.17504610f, 
    0.08509164f, -0.01130019f, 0.10170738f, -0.04154849f, -0.07373675f, -0.16748346f, -0.08727538f, -0.14325918f, 
    0.22107776f, -0.26875016f, 0.38913846f, 0.09450458f, -0.12271118f, 0.07962209f, -0.20051855f, 0.11177222f, 
    -0.02747840f, -0.25684872f, 0.09454644f, -0.22210330f, 0.07701601f, 0.35450172f, 0.05532746f, -0.13905041f, 
    0.09212521f, 0.20074801f, 0.09193238f, -0.05318723f, -0.00887031f, 0.00924338f, -0.03135457f, -0.01228105f, 
    -0.03959248f, 0.04078146f, -0.15901697f, 0.10033042f, -0.11426729f, 0.07884951f, 0.07748695f, 0.04993753f, 
    0.03242828f, -0.03300593f, 0.00851305f, 0.03341998f, -0.19435212f, -0.03769289f, -0.01092360f, 0.17638218f, 
    -0.02897443f, 0.06372225f, 0.00581914f, 0.21596406f, -0.07981248f, 0.03346029f, 0.15684503f, -0.03171265f, 
    0.47261259f, 0.05488684f, 0.04561584f, 0.31846583f, -0.08562370f, -0.11198448f, -0.07787884f, -0.08735247f, 
    -0.02297109f, -0.07380369f, 0.15276572f, 0.07210342f, 0.10261710f, -0.00500356f, -0.01619650f, 0.14404766f, 
    -0.24046029f, 0.09089954f, -0.06748381f, 0.01178933f, -0.06075375f, 0.02246910f, 0.02166354f, 0.10859965f, 
    0.06473816f, -0.13618837f, 0.15118764f, 0.04479073f, 0.04664244f, 0.05076679f, -0.13444056f, -0.10623714f, 
    -0.21881904f, -0.09592240f, -0.08520783f, -0.00532197f, -0.23233499f, 0.31201449f, 0.28616118f, -0.19457890f, 
    0.02322520f, -0.01053329f, 0.07875253f, -0.01088014f, -0.07077999f, -0.03470306f, -0.15453500f, -0.05311072f, 
    -0.07666880f, 0.16490267f, 0.20941219f, 0.02679757f, 0.21411404f, 0.10078580f, 0.00567551f, 0.04896537f, 
    0.00043449f, 0.08088574f, 0.02008627f, 0.05730972f, 0.28361085f, 0.08537669f, 0.00220089f, -0.09443928f, 
    0.21573322f, 0.02341656f, 0.03272976f, -0.04967470f, 0.08645016f, -0.06313567f, 0.00123461f, 0.18471757f, 
    0.37726074f, -0.16772385f, -0.21520963f, 0.02711042f, -0.08107010f, 0.16515252f, 0.08615577f, -0.01743355f, 
    0.04289220f, -0.05999919f, -0.23410608f, -0.02186622f, 0.01266371f, -0.09703518f, -0.42923537f, -0.26647139f, 
    -0.03889492f, -0.03134305f, -0.00077057f, -0.04617710f, -0.04381825f, -0.00404886f, 0.04168092f, 0.02387464f, 
    0.32086986f, -0.12500805f, 0.05330421f, -0.16233453f, 0.07859994f, -0.13691415f, 0.10174918f, -0.04077767f, 
    0.14975569f, -0.02005575f, 0.08174604f, 0.10146405f, 0.08364739f, 0.29696888f, 0.23883340f, -0.03245395f, 
    -0.02672970f, 0.03454549f, -0.01405264f, 0.05565472f, 0.00594421f, -0.05821528f, 0.05562552f, 0.04450163f, 
    0.28421834f, 0.17965330f, -0.18567207f, -0.13526316f, 0.15243104f, -0.15013346f, -0.22902587f, 0.01748595f, 
    0.03000490f, -0.09096014f, -0.01589522f, -0.02789174f, -0.04729214f, 0.05650030f, 0.22242562f, -0.15231359f, 
    -0.05034449f, -0.03675588f, -0.01932409f, -0.16532302f, -0.02488825f, 0.05998315f, -0.06054761f, 0.05653111f, 
    0.35149127f, 0.05695118f, -0.26497686f, 0.09403337f, -0.23604511f, -0.14584659f, 0.12845466f, -0.23506191f, 
    0.21335529f, 0.29620355f, -0.09457096f, 0.04304664f, 0.01215719f, 0.30764353f, -0.04029561f, -0.15503661f, 
    0.02451956f, -0.20982069f, -0.12616190f, 0.14580296f, -0.02777297f, 0.14889999f, 0.02440705f, 0.09147477f, 
    -0.07479185f, 0.07710047f, 0.05714716f, -0.00850928f, -0.06053572f, -0.09446586f, 0.01225585f, 0.13592082f, 
    0.00915149f, -0.00897826f, 0.04293163f, -0.00117268f, -0.02881177f, 0.02855373f, 0.07600150f, -0.13327257f, 
    -0.09266656f, -0.11995981f, -0.05087090f, -0.06303300f, -0.08685623f, -0.12199039f, -0.04140415f, 0.05465927f, 
    -0.43489921f, 0.11178612f, 0.05070154f, 0.17506492f, -0.00543549f, 0.02064670f, 0.05883277f, 0.13796055f, 
    0.03965141f, -0.01397065f, 0.13185905f, -0.04609863f, 0.18168272f, -0.10740498f, 0.18042447f, 0.06379911f, 
    -0.04147625f, -0.07443761f, 0.23113292f, -0.05637994f, -0.05889114f, -0.12172577f, -0.00920537f, -0.04912347f, 
    0.00774239f, 0.14412636f, -0.11278620f, -0.12797643f, 0.11270752f, 0.07289746f, 0.07543293f, 0.01097923f, 
    0.16834073f, 0.03535422f, 0.06494135f, -0.01599027f, 0.42121494f, -0.12145773f, 0.25881049f, -0.04651271f, 
    -0.07318710f, 0.10896003f, -0.17243880f, -0.07719478f, -0.05277590f, 0.15616617f, 0.03107793f, 0.05512860f, 
    -0.10332763f, 0.08104834f, 0.12455658f, 0.03307840f, -0.03799940f, -0.15830465f, -0.00669264f, -0.08619844f, 
    -0.05471602f, 0.12897722f, 0.00535083f, 0.04305460f, 0.22292773f, 0.16612829f, 0.04641760f, -0.05307234f, 
    0.02155409f, 0.07103937f, 0.00922299f, 0.14961278f, -0.05401101f, 0.15358433f, 0.07566652f, 0.12122242f, 
    0.39889085f, -0.19248040f, -0.51827884f, -0.49181423f, -0.11886489f, -0.13316667f, -0.06641667f, -0.08335409f, 
    0.19195367f, 0.08486118f, -0.02163137f, 0.05859314f, -0.05178697f, -0.14878806f, -0.34495974f, -0.23951517f, 
    -0.01088945f, 0.05184535f, 0.12659158f, -0.06116511f, 0.10149859f, 0.04845856f, -0.04639979f, -0.03072001f, 
    -0.01521379f, -0.01311853f, 0.11306105f, -0.14152619f, 0.06997193f, -0.00655423f, -0.06821980f, 0.09721716f, 
    0.15436660f, 0.06646432f, 0.05388179f, 0.07315820f, 0.08522401f, 0.01943262f, 0.13149136f, 0.26706418f, 
    0.00844306f, -0.08719652f, -0.08192512f, 0.02960388f, -0.05147139f, 0.01662963f, -0.09906667f, 0.03843587f, 
    -0.30500081f, 0.33243823f, 0.20655335f, 0.10998852f, -0.12359535f, 0.00033924f, -0.06174193f, 0.02715200f, 
    -0.06783843f, -0.06254351f, -0.04398712f, -0.10363283f, 0.26782620f, -0.02041764f, 0.10961339f, 0.10326682f, 
    -0.08472610f, -0.03668453f, 0.00001088f, -0.09051564f, -0.10120730f, -0.09631430f, -0.00679580f, 0.16160408f, 
    0.23626801f, 0.08118659f, -0.03319618f, 0.19846371f, -0.02346242f, -0.09161583f, -0.19744216f, -0.01601286f, 
    -0.00324907f, -0.02792533f, 0.00027822f, -0.01859014f, 0.25603858f, 0.08042974f, -0.12000273f, 0.06225699f, 
    0.02271608f, -0.11763561f, -0.02934431f, 0.05478451f, -0.12321914f, -0.09142915f, -0.03570390f, -0.08448004f, 
    -0.12960564f, -0.05801154f, -0.16941889f, -0.06700033f, -0.03772827f, 0.20194376f, -0.03286639f, -0.06984010f, 
    -0.11230331f, 0.06809648f, -0.00989517f, -0.02103146f, 0.11046722f, 0.16042700f, -0.19042748f, -0.06226106f, 
    0.27976605f, -0.03613923f, 0.20610176f, 0.23804253f, 0.08228032f, 0.02771539f, 0.07048505f, 0.09741488f, 
    0.04273282f, 0.00248632f, -0.42691520f, 0.08486276f, 0.10716072f, 0.00738288f, 0.06578054f, 0.15467787f, 
    0.10028726f, 0.00801114f, 0.01277245f, -0.03190160f, -0.15456903f, -0.26615795f, -0.19578278f, -0.19697031f, 
    0.17504857f, 0.06601401f, -0.03185743f, 0.03870336f, 0.12663203f, 0.04882947f, 0.00360900f, 0.01924365f, 
    -0.05639790f, -0.13803871f, 0.08067711f, -0.06937171f, -0.13993990f, 0.14727443f, -0.07864082f, -0.14682013f, 
    -0.03580504f, -0.02838203f, 0.01296727f, -0.06873947f, 0.23675521f, 0.05801447f, 0.06790535f, 0.02016618f, 
    0.01248122f, -0.01724788f, -0.05255161f, 0.06255167f, -0.01263045f, 0.13422921f, -0.17417444f, -0.00329136f, 
    0.28794602f, 0.12306503f, 0.03175727f, 0.18165806f, -0.09235737f, -0.02683255f, 0.03624645f, 0.08003265f, 
    -0.09487369f, -0.10230790f, 0.01210006f, -0.10984124f, 0.11305323f, -0.15267807f, 0.05696903f, -0.15179344f, 
    -0.07745215f, 0.08153840f, -0.01375417f, 0.00416193f, -0.18897381f, -0.08350324f, -0.00561829f, -0.06231029f, 
    0.00432707f, 0.01934646f, -0.02487311f, -0.02107609f, 0.06344359f, -0.01852686f, 0.04190507f, 0.00975624f, 
    -0.03535370f, -0.02137283f, -0.07156847f, 0.01297065f, 0.05570169f, 0.02756386f, -0.06984098f, 0.05277022f, 
    0.04660894f, -0.01973123f, -0.00520611f, -0.02260905f, -0.06242508f, 0.03319720f, 0.05798579f, -0.03646851f, 
    -0.06770652f, -0.02523425f, -0.06071698f, -0.00383704f, 0.01423726f, 0.01056303f, 0.03527361f, -0.01887516f, 
    0.01812283f, -0.02608658f, -0.04341348f, 0.00987753f, 0.00520338f, 0.04919728f, -0.06363147f, 0.04569454f, 
    0.01182338f, -0.02116066f, 0.01086127f, -0.02959102f, -0.02926032f, 0.03901432f, -0.05860585f, -0.06290038f, 
    0.00477331f, -0.00496291f, -0.01590948f, 0.01538832f, 0.03144749f, 0.02731642f, 0.02780404f, -0.00526844f, 
    0.05430830f, 0.02549393f, 0.01339041f, 0.04662049f, 0.03097038f, -0.07562955f, -0.04700543f, 0.06919792f, 
    0.02393814f, -0.04724896f, 0.03375103f, 0.02402810f, -0.03384649f, 0.05797530f, 0.04536618f, 0.01819371f, 
    -0.05996261f, -0.05392326f, 0.04994502f, -0.05701754f, -0.05718617f, 0.00210575f, -0.06249399f, -0.04131271f, 
    -0.02327597f, -0.06175599f, 0.00169235f, -0.02944248f, 0.03695054f, -0.05210841f, -0.07639966f, -0.03427471f, 
    -0.01643514f, 0.04397164f, -0.04913276f, -0.06087494f, -0.00834775f, -0.06638572f, -0.00039589f, -0.03774102f, 
    -0.04442131f, -0.05662634f, -0.05083767f, -0.06401922f, 0.06266640f, -0.02309639f, 0.02969486f, -0.00100095f, 
    -0.06497298f, 0.02657467f, -0.00314657f, -0.01797983f, -0.01445633f, -0.00650103f, 0.01868649f, -0.07667848f, 
    0.02960429f, -0.05721446f, -0.05062021f, -0.06345788f, -0.06480794f, 0.01789033f, 0.04012401f, -0.03371720f, 
    -0.05899011f, -0.02071126f, -0.00805749f, 0.00127301f, 0.05709526f, -0.03771983f, -0.03028155f, 0.00533786f, 
    -0.07020125f, 0.01480506f, -0.00941400f, 0.01838599f, 0.04655275f, -0.06452327f, 0.01842151f, 0.00493689f, 
    -0.05255178f, 0.05081633f, -0.06500707f, -0.03829002f, 0.03091161f, 0.00332745f, -0.07181928f, -0.06337778f, 
    -0.02498042f, 0.03273050f, 0.06041782f, -0.05576859f, 0.06438616f, 0.06278526f, -0.02422120f, 0.02920370f, 
    -0.02938320f, 0.02436648f, 0.05372001f, 0.03214756f, -0.01539672f, 0.05238623f, -0.06791778f, -0.07538728f, 
    -0.02852700f, -0.01237000f, -0.05639777f, -0.00813597f, 0.06103751f, 0.04441470f, -0.04181059f, -0.04898452f, 
    -0.06726352f, 0.00573161f, 0.06267966f, -0.06135762f, 0.05522757f, 0.06197928f, -0.01679837f, -0.05953424f, 
    -0.06860576f, 0.04163331f, -0.05059007f, 0.06290272f, -0.03551973f, 0.06430611f, -0.07286622f, -0.03335011f, 
    0.01000670f, 0.06650399f, -0.01855771f, -0.07003978f, -0.06860358f, -0.02594561f, 0.04852935f, 0.00744784f, 
    0.02807757f, -0.06621519f, -0.06408703f, 0.00567922f, 0.01287216f, 0.05413891f, -0.00518354f, -0.02873239f, 
    -0.01208562f, -0.06539966f, 0.03804041f, 0.02767101f, 0.01678248f, -0.05671733f, -0.04465422f, 0.05284711f, 
    -0.04870577f, -0.06850207f, -0.03014733f, 0.06082524f, 0.05666647f, 0.05135114f, 0.06996898f, 0.02888149f, 
    0.06760950f, -0.05001076f, 0.05488171f, -0.06634329f, -0.04413929f, -0.04855200f, 0.05773384f, 0.04863652f, 
    0.00631606f, -0.05560808f, -0.03810563f, -0.07115505f, 0.03535303f, 0.03902997f, -0.00534513f, -0.05104957f, 
    0.05519139f, 0.01239376f, 0.03884004f, -0.01529270f, 0.06401929f, -0.01066196f, 0.03387025f, 0.01848325f, 
    -0.01624998f, 0.03312210f, 0.01833414f, 0.03937718f, -0.02505527f, 0.01062646f, -0.06393388f, 0.04636318f, 
    -0.04844157f, -0.03440869f, -0.06973981f, 0.00323828f, -0.06141252f, -0.03860243f, 0.07197775f, -0.06592816f, 
    -0.03242355f, -0.06126198f, 0.07195386f, -0.06240395f, 0.04587131f, -0.07216287f, 0.03284170f, -0.06827084f, 
    -0.07205952f, -0.06960639f, 0.06368049f, -0.05066676f, -0.07053647f, 0.06492949f, -0.03147003f, 0.04587867f, 
    -0.00080380f, -0.05707760f, 0.00198236f, 0.00148365f, -0.06920622f, -0.02553532f, -0.06008763f, 0.05450850f, 
    0.06383551f, 0.00244141f, -0.01392440f, 0.04664387f, -0.02744736f, -0.04922294f, 0.06895408f, -0.02343295f, 
    0.00248714f, -0.01999828f, -0.05235602f, 0.05261916f, 0.06336442f, -0.01675629f, -0.04662684f, 0.00275269f, 
    -0.03322827f, 0.05183208f, 0.00102591f, -0.04733048f, -0.05909761f, 0.06369453f, -0.05349066f, -0.02875821f, 
    -0.04076638f, 0.04518195f, -0.01153247f, 0.05124448f, 0.00293816f, 0.02376422f, -0.02680355f, -0.00112901f, 
    0.05138181f, -0.00308899f, 0.06877024f, -0.04889182f, -0.05100829f, 0.00279130f, -0.00195638f, -0.06709252f, 
    -0.05752448f, 0.04282261f, -0.04831909f, -0.02367636f, 0.00019244f, -0.04434496f, -0.04735367f, 0.03558929f, 
    -0.01619209f, -0.05915269f, -0.04755292f, -0.03846642f, 0.00776907f, -0.01684708f, 0.04634771f, 0.03304193f, 
    -0.02773852f, 0.03043694f, -0.05676600f, -0.00641726f, -0.01180206f, 0.04372429f, -0.00503750f, 0.00879229f, 
    -0.07055194f, -0.04463217f, -0.01353341f, -0.06992462f, -0.02781203f, -0.02514950f, -0.00790098f, -0.04502790f, 
    -0.06064903f, -0.02547033f, -0.05503022f, -0.02281962f, -0.01623403f, -0.04044525f, -0.02088293f, -0.01136917f, 
    -0.00427584f, -0.07203224f, -0.06200362f, -0.00417010f, -0.04818228f, 0.04841170f, -0.06152444f, 0.04250094f, 
    -0.01099294f, -0.05683453f, -0.07052843f, 0.05192514f, -0.03494593f, -0.00573809f, -0.02193855f, 0.06338389f, 
    -0.00041566f, 0.01298398f, 0.05601250f, -0.06816373f, -0.00212310f, -0.05285911f, 0.00948347f, 0.06799660f, 
    -0.00003142f, -0.01713346f, 0.05954509f, -0.07653482f, -0.03932719f, 0.01074946f, 0.03269253f, 0.03078105f, 
    -0.08179929f, 0.01368100f, -0.04395670f, -0.01549192f, 0.02344607f, 0.04515598f, 0.04969974f, -0.00052181f, 
    -0.07134548f, 0.04270079f, 0.06096100f, 0.05633906f, 0.01401171f, 0.04270327f, 0.03222531f, 0.04519119f, 
    -0.01013449f, -0.05285303f, -0.03913544f, -0.02465070f, -0.02358821f, -0.06328744f, -0.05061572f, -0.02825021f, 
    -0.00576138f, -0.07848140f, -0.00875542f, -0.06428196f, 0.04204974f, 0.02498341f, 0.03987539f, -0.03695251f, 
    -0.00440995f, 0.03078348f, -0.05607817f, 0.05476566f, -0.05291551f, -0.06794295f, 0.02884328f, 0.03760855f, 
    0.03298093f, 0.02449691f, -0.07219541f, -0.01167485f, 0.00742221f, 0.03521988f, 0.03189538f, 0.02532650f, 
    -0.00105345f, 0.04625404f, -0.03327642f, -0.04396326f, 0.05078621f, 0.00221833f, 0.03134492f, -0.03170278f, 
    -0.05500216f, -0.04672496f, -0.03597358f, -0.06016696f, 0.01181978f, 0.06081468f, 0.04640068f, -0.04994514f, 
    -0.05336969f, -0.07643075f, -0.06555536f, -0.06348636f, -0.07624638f, -0.00943819f, -0.05245198f, -0.02721391f, 
    -0.04538014f, -0.07406091f, 0.01136711f, -0.03959493f, 0.04221967f, 0.00713498f, 0.03740295f, 0.03426813f, 
    0.05963757f, -0.05731463f, 0.01348129f, -0.04155726f, 0.04366280f, -0.02892404f, 0.03905848f, -0.07995864f, 
    0.00541094f, -0.04542569f, 0.05154761f, 0.02134384f, -0.08082762f, 0.05725973f, -0.02536915f, -0.04384696f, 
    -0.08133286f, -0.08070769f, 0.06153106f, 0.03435270f, -0.02078054f, -0.03975645f, 0.02692690f, 0.02325040f, 
    0.05627673f, 0.00412425f, 0.04434357f, -0.08016969f, 0.02878797f, -0.07149620f, 0.04706290f, -0.05760098f, 
    -0.03031079f, -0.07324822f, -0.04235228f, 0.01453279f, -0.08077794f, 0.03307123f, -0.02944848f, 0.00733336f, 
    0.06104985f, 0.03102363f, 0.05424163f, 0.02324627f, -0.06394759f, -0.06132372f, -0.00604379f, 0.03930472f, 
    0.00681871f, -0.07777803f, -0.05312937f, -0.04526024f, -0.01127078f, -0.03679113f, -0.04385057f, -0.04615558f, 
    0.01439821f, -0.01089873f, 0.00985132f, -0.02799377f, -0.00907559f, -0.00480496f, 0.00872102f, -0.06271924f, 
    0.02101424f, -0.02365314f, 0.06147485f, 0.06029495f, -0.06965095f, -0.07707959f, -0.01049496f, 0.05227423f, 
    -0.08008707f, -0.06733216f, -0.03712688f, 0.01038428f, -0.01373191f, -0.05445915f, -0.00937301f, -0.06259143f, 
    0.04769878f, 0.00568818f, 0.04513522f, 0.02076125f, -0.05774188f, -0.00493913f, -0.06166822f, -0.06816746f, 
    -0.07743020f, -0.04299814f, -0.05750728f, -0.07325525f, -0.08120033f, 0.04070844f, -0.04984052f, -0.03051803f, 
    0.00813793f, -0.01086884f, -0.00034889f, -0.05823815f, -0.05237012f, 0.02901547f, -0.04234239f, 0.03250967f, 
    0.21432145f, -0.04852730f, -0.10702267f, -0.18527764f, 0.03036081f, 0.08299602f, -0.07248949f, -0.11746862f, 
    0.11870176f, -0.00884158f, -0.02189440f, 0.04322005f, 0.01095985f, -0.17619476f, -0.08603201f, -0.13288148f, 
    0.05086246f, 0.16671167f, 0.11965523f, 0.00794609f, -0.01885962f, -0.10149871f, -0.01157305f, -0.00575554f, 
    0.25082979f, 0.41171455f, 0.10855530f, -0.04784147f, 0.07147904f, 0.07175593f, 0.13158314f, -0.01292337f, 
    -0.09402069f, -0.17809990f, -0.08355153f, -0.09077335f, -0.03623370f, 0.10920565f, 0.10227507f, 0.13129164f, 
    0.03175711f, -0.12454288f, -0.17066585f, -0.03487824f, -0.14827743f, -0.07539700f, -0.06331509f, -0.10090984f, 
    0.17249601f, 0.09937239f, 0.27444011f, -0.38412511f, -0.04125028f, -0.01170487f, -0.02323441f, -0.06941446f, 
    -0.12402827f, -0.11244742f, -0.07316903f, -0.21128641f, -0.00418382f, 0.06504334f, -0.17598748f, 0.18639427f, 
    -0.05214046f, -0.08454116f, -0.08111168f, -0.01836733f, -0.07476738f, -0.06661848f, -0.09623559f, 0.11725035f, 
    -0.14722465f, 0.04961430f, -0.04906533f, -0.11173537f, -0.11676484f, 0.07137021f, 0.12603836f, -0.00066803f, 
    0.15324754f, -0.24076994f, 0.17983124f, 0.15671398f, -0.05092664f, -0.06866154f, 0.10074979f, 0.19044687f, 
    -0.14135070f, -0.08245119f, -0.00978955f, -0.06772737f, 0.00246079f, -0.04729163f, 0.12344842f, -0.03171157f, 
    0.27515689f, 0.01739500f, 0.06838807f, -0.08389731f, 0.09018770f, 0.01451432f, -0.01532780f, 0.02910512f, 
    0.02476025f, -0.04308416f, 0.06277794f, 0.04819377f, 0.36150819f, 0.01557855f, -0.06896414f, -0.06544757f, 
    -0.07589058f, -0.07528368f, 0.03662068f, 0.04588215f, -0.10566250f, 0.13121940f, -0.04169536f, -0.00822919f, 
    -0.21699320f, -0.37475049f, 0.08182133f, -0.25875539f, -0.00237201f, 0.05443140f, 0.04896636f, 0.03445154f, 
    0.01740592f, -0.00258878f, -0.17846981f, -0.13452362f, 0.04278135f, 0.12882350f, -0.02791223f, -0.12173938f, 
    0.20680673f, 0.04024283f, -0.05765898f, -0.00044695f, -0.05340308f, 0.00066352f, -0.11420310f, -0.07284477f, 
    0.07302230f, 0.03945359f, -0.00896288f, -0.12589735f, 0.02405624f, 0.02434395f, 0.04118727f, -0.08234812f, 
    0.23074949f, 0.02021194f, 0.10525934f, 0.04935224f, -0.10102393f, -0.01410694f, -0.04903048f, 0.25887999f, 
    -0.18346407f, -0.18391740f, -0.06094039f, 0.06296916f, -0.09494488f, -0.05626554f, -0.01029339f, -0.02367175f, 
    0.04286500f, -0.12817250f, -0.19930203f, 0.03353127f, -0.11754267f, -0.11051539f, -0.07760629f, 0.02741626f, 
    -0.06955118f, -0.03777627f, -0.12087117f, -0.00742246f, -0.23300570f, -0.27760887f, -0.02461784f, 0.06661578f, 
    -0.02766824f, 0.09366650f, -0.08431485f, -0.06225971f, 0.06073584f, 0.05765600f, 0.16174524f, 0.06322810f, 
    -0.04677896f, 0.02636687f, 0.01624394f, 0.00946119f, 0.01541424f, -0.04295546f, 0.04902649f, 0.06155494f, 
    0.00313583f, -0.07082395f, -0.04352563f, -0.05947136f, -0.03677136f, 0.04481820f, -0.02443019f, -0.06537250f, 
    -0.00964247f, 0.05258906f, 0.03395437f, -0.07818900f, 0.05604668f, 0.03351917f, 0.03582544f, -0.06890396f, 
    -0.06839816f, 0.05144215f, 0.00455514f, -0.04859015f, -0.01735660f, -0.05826861f, 0.01380460f, 0.00313507f, 
    -0.05615285f, -0.07493198f, 0.00659378f, 0.03958347f, 0.01709053f, -0.03253289f, 0.03095095f, 0.02607944f, 
    0.01923274f, -0.00737770f, 0.05059380f, -0.04504602f, -0.04224232f, -0.07284812f, 0.02194568f, -0.00332221f, 
    0.04491121f, 0.05925452f, 0.02409342f, -0.03161179f, -0.06953596f, -0.07222482f, -0.02459948f, 0.01436905f, 
    -0.01306884f, 0.05057763f, 0.03406352f, 0.02906186f, 0.04824411f, 0.05615803f, 0.01724324f, -0.05449678f, 
    0.02923609f, 0.03258961f, 0.02885102f, -0.03057875f, -0.02044258f, 0.00411491f, -0.05438055f, 0.03939986f, 
    -0.04960822f, -0.03286778f, 0.02763559f, -0.06150857f, -0.01785172f, -0.05763455f, 0.03471936f, 0.00854453f, 
    0.05110485f, -0.06267951f, 0.01410802f, 0.03294244f, -0.03421967f, 0.03833806f, -0.03571640f, -0.03390665f, 
    -0.00308220f, -0.02607689f, 0.03926790f, -0.02445949f, 0.03108264f, -0.05195909f, 0.04564525f, -0.07781774f, 
    0.02019559f, 0.01850733f, -0.05271960f, 0.02024900f, 0.00929678f, 0.01439483f, 0.03093031f, -0.03748827f, 
    0.06271636f, -0.07195693f, 0.00043023f, -0.05782175f, -0.03999422f, 0.06182643f, -0.06018899f, -0.01930373f, 
    -0.06999806f, -0.05013081f, -0.03209821f, -0.06969672f, -0.07096840f, 0.01208218f, -0.05026874f, 0.04656310f, 
    -0.02060650f, -0.07194559f, 0.05302878f, 0.05752382f, 0.04842865f, 0.03328280f, -0.00803014f, -0.02308454f, 
    0.04323344f, -0.07210726f, -0.04291357f, 0.03600245f, -0.06788723f, -0.02706442f, 0.01555660f, -0.02263575f, 
    -0.04509071f, 0.05898010f, 0.01907947f, 0.01982402f, -0.04821157f, 0.06186608f, -0.03350907f, -0.02390277f, 
    -0.07861849f, 0.00565526f, 0.05636154f, 0.04772851f, -0.05986819f, -0.04900980f, 0.00527024f, -0.06453431f, 
    -0.03871967f, -0.00491655f, -0.06039257f, 0.05963152f, 0.02221158f, 0.00263912f, 0.03503938f, -0.06533863f, 
    -0.07641269f, -0.07661175f, -0.04207906f, -0.00405762f, 0.02497622f, -0.03387344f, 0.02881788f, -0.02688641f, 
    0.01784341f, 0.02324323f, -0.02263698f, -0.05326039f, -0.07710121f, -0.00199720f, -0.07354391f, -0.03949468f, 
    0.01353371f, -0.07393862f, 0.01856661f, -0.02387140f, 0.01062500f, -0.00948320f, 0.00550838f, -0.01811714f, 
    -0.06534128f, -0.02569774f, 0.04660121f, 0.02683939f, 0.04281683f, -0.01076792f, 0.00384910f, 0.00045526f, 
    -0.32492733f, 0.15460809f, 0.05784718f, 0.06381971f, 0.02814450f, -0.06402883f, 0.02689029f, 0.16620444f, 
    -0.01896881f, 0.04613492f, 0.14158016f, 0.07732698f, 0.00577628f, -0.02068669f, 0.01657444f, 0.13413401f, 
    -0.04248943f, 0.09396458f, 0.03887238f, 0.09415638f, 0.09436977f, 0.12762672f, 0.16491432f, 0.04268514f, 
    -0.19284506f, -0.04795716f, -0.08101716f, 0.15529694f, -0.04254432f, -0.04425648f, 0.08375038f, -0.00899479f, 
    0.03839673f, 0.03096975f, -0.00884594f, 0.13318020f, 0.09913214f, 0.06504973f, 0.12235561f, -0.24730480f, 
    -0.10919125f, -0.24394593f, -0.26470670f, 0.05533368f, 0.04154057f, 0.07543510f, -0.14885187f, -0.17621151f, 
    0.10873081f, -0.40429327f, 0.10840221f, 0.07435064f, 0.03534967f, -0.05822568f, -0.03778101f, 0.03752672f, 
    -0.06281892f, 0.05950198f, 0.11430341f, 0.09346130f, 0.03857964f, 0.04901234f, -0.12089032f, -0.14671224f, 
    -0.06169572f, -0.09443534f, -0.01614128f, 0.01644246f, -0.06498307f, 0.12484227f, 0.03350981f, 0.06434825f, 
    -0.28455591f, 0.41855210f, -0.07451320f, -0.14982747f, 0.14122075f, 0.09626064f, 0.06949565f, 0.06941692f, 
    -0.01865975f, 0.07140223f, 0.11163785f, 0.08011511f, 0.01382480f, 0.06734705f, 0.35358009f, -0.04599776f, 
    0.20224854f, 0.13610570f, -0.00474224f, -0.05739478f, 0.10354003f, 0.09925290f, -0.00773663f, 0.09938927f, 
    0.03620541f, -0.24411526f, 0.17132369f, -0.02437920f, 0.08403955f, 0.03486558f, 0.02820673f, -0.04944759f, 
    0.06592291f, -0.11437719f, 0.09063860f, 0.04452945f, -0.37834349f, -0.13860537f, 0.03388172f, 0.15017001f, 
    -0.02932135f, 0.18727882f, 0.02578635f, -0.31178403f, 0.03228502f, -0.08302449f, -0.09580915f, 0.03734346f, 
    0.32571581f, 0.14337401f, 0.05986326f, 0.25690824f, -0.01492023f, 0.09194852f, -0.00855485f, 0.04521793f, 
    0.07087693f, 0.14575502f, -0.03966388f, 0.07516182f, -0.25490943f, -0.08110967f, -0.03018495f, 0.03624628f, 
    0.02115051f, 0.00097106f, 0.01796864f, -0.15397127f, -0.11272070f, 0.02613038f, -0.21630915f, -0.06390338f, 
    -0.15824135f, 0.28602517f, -0.18178648f, 0.28688452f, 0.10101343f, -0.01726787f, 0.08895559f, 0.16393417f, 
    -0.01754915f, -0.00311087f, 0.06892224f, 0.03059166f, -0.08113713f, 0.25452206f, -0.02628491f, 0.09692217f, 
    0.09546907f, -0.02598977f, -0.03324266f, 0.00502268f, 0.09364434f, 0.08900874f, 0.06778505f, 0.09557553f, 
    -0.29692224f, 0.14056730f, 0.08929586f, 0.04508769f, -0.17121725f, -0.01697520f, -0.10446608f, -0.03404520f, 
    -0.01907022f, -0.11489874f, -0.15911783f, -0.07559051f, -0.14768891f, -0.07081264f, -0.11624419f, 0.05227577f, 
    -0.02283988f, -0.15968534f, -0.05097161f, -0.18830924f, 0.02467594f, 0.04667817f, 0.08315848f, -0.07396865f, 
    0.28852764f, -0.07213455f, 0.19411409f, -0.02940618f, 0.04876456f, 0.06794879f, 0.07091190f, 0.14554574f, 
    -0.00235813f, 0.11883512f, 0.09043621f, 0.24238980f, 0.13444053f, -0.12267821f, 0.15917069f, -0.02645081f, 
    0.04871639f, -0.06741787f, 0.04115677f, 0.06767002f, -0.01418977f, 0.08318690f, 0.31962979f, 0.18362340f, 
    0.22269577f, 0.19106849f, -0.09906894f, 0.09834768f, -0.06570516f, 0.00826650f, 0.12826499f, 0.10403515f, 
    -0.02502461f, 0.04669947f, 0.14856842f, 0.18845499f, 0.28742483f, 0.12334914f, 0.04412955f, 0.09075884f, 
    -0.03324392f, 0.20262000f, 0.03086947f, -0.17270151f, -0.14477310f, -0.17000745f, -0.00204467f, -0.04228530f, 
    0.22141211f, 0.40224004f, 0.00426352f, -0.00879749f, 0.07082835f, 0.05738775f, 0.04219441f, 0.00800970f, 
    -0.00102522f, -0.21802738f, -0.06770863f, 0.05738172f, -0.03726749f, 0.08302911f, -0.14076622f, 0.13463415f, 
    -0.11174960f, 0.03452636f, -0.24122635f, 0.10621538f, 0.01636987f, 0.23063719f, 0.17472687f, 0.15851341f, 
    -0.19296756f, 0.00133230f, 0.21573418f, -0.08731187f, 0.00470708f, 0.07411973f, -0.12067952f, -0.01188267f, 
    -0.09546225f, -0.05477557f, -0.10628179f, -0.10230795f, 0.01232530f, 0.08670500f, 0.20436168f, 0.00082454f, 
    -0.16418727f, 0.09705451f, -0.01622501f, -0.02263331f, 0.05162122f, -0.03121212f, -0.13071412f, -0.28410983f, 
    0.10898129f, 0.00054049f, 0.01400286f, -0.00572858f, 0.09840753f, 0.01787902f, 0.01462453f, 0.09306119f, 
    -0.10077093f, 0.03781265f, -0.08139474f, -0.16772395f, 0.12519544f, 0.01017326f, -0.02694933f, 0.02398316f, 
    0.18208310f, 0.07063591f, 0.06676925f, 0.21096121f, -0.09202535f, 0.13344115f, 0.12244631f, -0.05457248f, 
    -0.13212208f, -0.10374198f, 0.10050811f, -0.16585256f, 0.02375924f, -0.03805924f, 0.01110455f, -0.16368762f, 
    -0.03715316f, 0.15042329f, 0.16011728f, 0.11679467f, 0.15223409f, -0.05204755f, -0.28338835f, -0.13763067f, 
    -0.03121561f, 0.01819000f, -0.08633111f, 0.04421209f, -0.17441373f, -0.14019907f, -0.12235741f, 0.03038866f, 
    0.18477151f, -0.05973051f, 0.22336800f, -0.43299258f, 0.15546836f, -0.10759821f, -0.04892077f, -0.08227763f, 
    -0.07748254f, -0.19759865f, -0.09090456f, -0.45269874f, -0.22092684f, -0.00549685f, 0.06312208f, 0.17567575f, 
    -0.05931627f, -0.00245336f, 0.18798368f, -0.31908754f, -0.08318238f, -0.02047945f, 0.04618805f, 0.09704666f, 
    0.38121051f, 0.00092935f, -0.01566473f, -0.10317323f, -0.09329207f, -0.03472074f, -0.00216247f, -0.00356091f, 
    -0.15329942f, -0.09221188f, -0.22183007f, 0.18391857f, 0.05913225f, -0.00597075f, 0.00976841f, -0.17978491f, 
    0.07068298f, 0.03844829f, -0.18311025f, -0.33848786f, -0.03073028f, -0.24499045f, -0.22705977f, -0.28909037f, 
    0.33115646f, 0.20154977f, 0.26095390f, 0.28998083f, 0.02097245f, 0.08528309f, 0.07406273f, -0.03107411f, 
    0.00093351f, 0.13512570f, -0.00033483f, 0.15861976f, 0.01017923f, 0.22459361f, -0.01644575f, -0.05619220f, 
    0.09812391f, -0.03154320f, 0.01145241f, -0.01832802f, -0.04794723f, -0.05735426f, 0.10752431f, 0.06352746f, 
    0.15721220f, -0.06325383f, 0.11377339f, 0.00885910f, -0.05264082f, -0.13866930f, -0.01249901f, 0.04954662f, 
    0.15289298f, 0.01011924f, 0.10165221f, 0.06107070f, -0.67505711f, -0.42425007f, 0.06502666f, -0.09435976f, 
    0.23867650f, 0.23116930f, 0.03523439f, -0.04714102f, 0.05485876f, -0.15111609f, -0.03907144f, 0.11153590f, 
    -0.06411761f, 0.11891466f, -0.24570301f, -0.02236850f, 0.18944050f, -0.03768989f, -0.12378135f, -0.03081975f, 
    0.01785633f, 0.08854627f, 0.08286098f, 0.09985886f, 0.06007135f, -0.33729002f, -0.04417080f, 0.09005226f, 
    -0.00787114f, 0.03698886f, -0.02873151f, -0.06263924f, -0.05263692f, 0.13342355f, -0.01704578f, 0.10482276f, 
    0.04729133f, -0.02332835f, -0.12155628f, 0.04738202f, -0.04858778f, -0.04207284f, 0.05620554f, -0.04170991f, 
    0.13116848f, 0.25083596f, -0.19729444f, 0.02415083f, -0.08629443f, -0.01944070f, -0.30199271f, -0.36139730f, 
    0.03852613f, -0.08628361f, -0.06998060f, 0.13213949f, 0.03719170f, 0.02213825f, -0.12392780f, -0.04167613f, 
    -0.10442743f, 0.14465858f, 0.16386920f, -0.06799866f, 0.11293332f, 0.01951334f, -0.10114506f, 0.14612110f, 
    -0.04539165f, 0.00550294f, -0.03747281f, -0.09609944f, 0.11191424f, 0.20855387f, 0.10579509f, -0.28192556f, 
    -0.16272932f, -0.02202454f, 0.02254084f, 0.19306681f, -0.06002747f, -0.02662375f, 0.02047259f, -0.02665515f, 
    -0.00351019f, 0.25104594f, 0.22431713f, -0.02409340f, -0.05922782f, -0.02657186f, 0.00052238f, -0.04458032f, 
    0.00188446f, 0.06027583f, 0.11138225f, 0.04179229f, 0.28455588f, 0.15016232f, 0.37456551f, 0.18010323f, 
    -0.08582571f, -0.10393412f, 0.23367380f, 0.10102741f, 0.04228327f, -0.16368781f, 0.08318280f, -0.13563418f, 
    -0.32560638f, 0.03125071f, -0.10722881f, -0.14123578f, 0.16458128f, -0.05958365f, 0.09789237f, -0.07591444f, 
    -0.08000208f, -0.02008373f, -0.09578551f, -0.10312624f, 0.13260141f, -0.44235349f, -0.23909536f, -0.11728442f, 
    -0.07722300f, 0.12514970f, -0.05089647f, -0.10727195f, -0.20499459f, -0.03821059f, -0.04537110f, -0.06170587f, 
    -0.03198475f, -0.36063018f, -0.40982673f, -0.22073300f, 0.14395030f, -0.06261368f, 0.04213750f, -0.05318530f, 
    -0.07447666f, -0.01723804f, -0.11532612f, 0.00864630f, 0.09284203f, 0.28025696f, -0.04090099f, -0.11274660f, 
    0.11150647f, 0.01117295f, 0.02893639f, 0.16428834f, -0.18946527f, -0.13063945f, -0.18510826f, -0.19265229f, 
    0.04445528f, 0.05071801f, 0.06353376f, -0.01542849f, 0.00314604f, -0.06601676f, -0.04953597f, -0.05862677f, 
    -0.01562291f, -0.03620510f, -0.00953682f, -0.02276460f, 0.01618088f, 0.06482871f, -0.07718538f, 0.04067024f, 
    -0.03675454f, -0.06257766f, 0.04924271f, -0.06681462f, -0.05431183f, -0.03668627f, -0.04361086f, 0.04635660f, 
    -0.06071940f, -0.04017934f, -0.06457029f, -0.02080735f, -0.07544037f, 0.04344562f, -0.01731730f, 0.03679736f, 
    0.06507801f, 0.02405342f, 0.04997205f, -0.00889490f, 0.01129142f, -0.06442798f, -0.04836999f, 0.01538224f, 
    -0.05153828f, 0.05891461f, 0.02900509f, 0.02598497f, -0.03893176f, -0.07087615f, -0.02185725f, -0.04463234f, 
    0.05602235f, 0.04363738f, 0.00737415f, -0.00327398f, -0.03971851f, -0.05152917f, -0.04145766f, 0.02203574f, 
    -0.03469066f, 0.05445665f, 0.00809609f, -0.04869990f, -0.01793985f, -0.04173465f, -0.03743073f, -0.07274383f, 
    -0.01964216f, -0.04221014f, 0.00268467f, -0.03262851f, 0.04905729f, 0.03887350f, 0.00256225f, 0.03580970f, 
    -0.07250156f, -0.01791374f, 0.00788028f, 0.00895472f, -0.02023137f, 0.05385741f, -0.01035815f, 0.00783495f, 
    -0.03576866f, -0.04194855f, -0.01522069f, 0.03461346f, -0.06725436f, 0.03331703f, -0.05260763f, 0.02730924f, 
    -0.06657267f, -0.03722968f, 0.00166080f, 0.02919637f, 0.03014120f, -0.00477912f, 0.00645594f, -0.04645674f, 
    0.06104172f, 0.00436853f, 0.05350856f, -0.01101281f, 0.01859881f, 0.00782350f, -0.00348858f, -0.04332240f, 
    -0.05472625f, 0.06441357f, -0.05111965f, 0.06373224f, -0.01740638f, -0.07768688f, -0.04429476f, -0.02266547f, 
    -0.05230900f, 0.02610038f, -0.04829413f, -0.02705828f, 0.02382507f, 0.04439693f, -0.00735401f, -0.02425501f, 
    -0.03197169f, -0.02356407f, 0.03510171f, -0.02720850f, -0.06548763f, -0.05472950f, -0.04076665f, 0.05768215f, 
    0.03819920f, -0.03515093f, -0.03399276f, 0.01615735f, -0.05544877f, -0.03865308f, -0.06259720f, 0.01665551f, 
    -0.06937820f, -0.07073463f, -0.03873091f, 0.02960535f, 0.00617204f, -0.05944431f, -0.02363710f, 0.02796466f, 
    0.05147697f, -0.02387226f, 0.05069343f, 0.03111940f, 0.00797454f, 0.02371943f, -0.05237853f, 0.04949417f, 
    -0.07057982f, -0.07191548f, -0.06491908f, 0.02642967f, -0.07077029f, -0.04317844f, 0.05734042f, 0.02483759f, 
    -0.05375853f, -0.06822250f, -0.00347409f, 0.00148522f, -0.07431082f, -0.06986693f, -0.03491587f, -0.04307134f, 
    -0.00777685f, -0.05954211f, -0.05415464f, 0.05481717f, -0.03641367f, -0.06811369f, 0.04210791f, -0.00744207f, 
    0.03018741f, 0.00015582f, 0.03819131f, 0.06056286f, 0.06679990f, -0.02688187f, -0.01110455f, 0.02155939f, 
    0.03508947f, -0.02255796f, 0.05421894f, 0.03664366f, -0.00438232f, 0.03923539f, -0.02629684f, -0.06898411f, 
    -0.24376227f, -0.03087854f, -0.11126284f, 0.01490279f, 0.19398737f, -0.03422517f, 0.03448920f, 0.27290660f, 
    0.00373317f, -0.11139671f, 0.12021197f, 0.08980007f, 0.24548332f, -0.12354911f, 0.22658753f, 0.10141193f, 
    0.05799406f, -0.08187300f, 0.04165204f, 0.20328566f, 0.01400365f, 0.22282827f, 0.18645087f, -0.07463039f, 
    0.02746279f, 0.02282276f, -0.17881031f, 0.04878901f, -0.05930878f, 0.04618716f, 0.17203788f, -0.04428178f, 
    0.01226065f, 0.19206665f, 0.15521280f, 0.18399817f, 0.13113387f, -0.11269425f, -0.13713434f, -0.04818908f, 
    -0.10689072f, -0.05312609f, 0.06965505f, -0.03653130f, 0.00282968f, 0.14527355f, -0.06047252f, -0.12849703f, 
    0.13775307f, -0.19077531f, 0.22366676f, 0.08947313f, 0.02136199f, 0.26246312f, 0.20425543f, 0.05495723f, 
    0.10938902f, 0.03202793f, -0.04351828f, 0.04306198f, 0.13585378f, 0.02424489f, -0.41237396f, -0.21494099f, 
    0.03705877f, -0.16258155f, 0.03705346f, 0.28377944f, 0.00979043f, 0.19472283f, 0.22009419f, 0.16545807f, 
    -0.23474692f, 0.51401979f, 0.07426888f, -0.16995694f, 0.11647532f, 0.20041403f, -0.01767734f, -0.17022868f, 
    -0.24267311f, 0.01497954f, 0.07502379f, -0.03592119f, 0.04882598f, -0.30571333f, 0.44643614f, -0.05749901f, 
    -0.03425431f, 0.15520158f, 0.04137181f, -0.09785391f, 0.02436678f, -0.02004452f, 0.01307677f, -0.14965406f, 
    0.30561972f, 0.02316918f, 0.10773983f, 0.35667956f, 0.05634848f, 0.09470492f, -0.05385649f, -0.05254280f, 
    0.07180627f, -0.01951663f, -0.04179960f, -0.06129945f, -0.23830175f, -0.01330907f, 0.08731115f, 0.33632252f, 
    0.13451156f, 0.00777933f, -0.01885725f, -0.16419275f, -0.00345453f, -0.01137044f, 0.02667176f, -0.06753014f, 
    0.33890259f, -0.07895897f, -0.00068139f, 0.36268163f, -0.02597770f, -0.02613707f, 0.00135000f, 0.12101249f, 
    0.07003436f, 0.01451597f, 0.05014827f, -0.01565364f, -0.02765478f, 0.01790850f, -0.25096539f, -0.08585202f, 
    0.02640435f, -0.13226728f, -0.22803687f, -0.28206503f, -0.07532597f, -0.01410261f, -0.07559693f, 0.16410172f, 
    0.07313362f, 0.05432023f, -0.02455083f, 0.03531120f, 0.09641305f, -0.02225526f, -0.03816506f, 0.09815855f, 
    -0.08022097f, -0.08555970f, -0.21703099f, -0.17455178f, -0.33389774f, 0.16666576f, -0.29249522f, 0.06660231f, 
    0.04832753f, -0.12386965f, 0.17842618f, -0.09422971f, 0.00865379f, -0.14229442f, 0.17864238f, 0.14241238f, 
    -0.14654596f, 0.04195095f, -0.06630101f, 0.00228160f, -0.00317579f, 0.07122766f, -0.03177603f, 0.06023737f, 
    0.03530565f, -0.17218231f, -0.12443721f, -0.17376406f, 0.02990921f, -0.15916131f, -0.00326787f, -0.08985028f, 
    0.08849413f, 0.00503781f, 0.07510580f, -0.27060103f, 0.15232939f, 0.05342071f, 0.01946808f, -0.02747266f, 
    0.02131353f, -0.13279666f, -0.18266883f, -0.08644488f, 0.05713650f, 0.03204972f, 0.06769005f, 0.01075537f, 
    0.03354431f, -0.22291555f, -0.06590246f, -0.01603239f, 0.16880286f, -0.05590075f, -0.14146723f, 0.05157292f, 
    0.05222202f, 0.12686867f, 0.19122782f, 0.04488632f, 0.08269571f, -0.07216477f, -0.11789976f, 0.01227951f, 
    0.09400133f, 0.05820427f, 0.25917974f, -0.17398515f, 0.04706134f, 0.06980354f, -0.02504003f, 0.06030664f, 
    0.03095794f, -0.05139414f, -0.08452940f, -0.09250318f, -0.53428155f, -0.02761003f, 0.10816702f, 0.18234636f, 
    0.17156786f, -0.11153813f, -0.06527900f, 0.03434436f, -0.00762888f, 0.01189664f, 0.02477296f, 0.06947337f, 
    -0.21464828f, 0.09649968f, 0.51757860f, 0.12118641f, -0.03904006f, -0.04856139f, 0.10590213f, -0.06491631f, 
    -0.03641373f, 0.00873483f, -0.07914484f, 0.08469622f, -0.07579309f, -0.07911329f, -0.07358627f, -0.02540075f, 
    0.06553628f, -0.07609346f, 0.03841236f, -0.06378534f, 0.15518665f, -0.21900530f, 0.03404227f, 0.01492591f, 
    0.34059462f, -0.06863694f, -0.01315187f, 0.03155436f, -0.13364521f, -0.18981723f, -0.02522395f, 0.05534988f, 
    0.08153077f, 0.00181927f, -0.02562720f, 0.00895628f, -0.01322020f, -0.04486579f, -0.11262041f, 0.20097773f, 
    -0.03012934f, -0.06152359f, 0.04929020f, -0.05839415f, -0.03460602f, 0.00310934f, 0.10372478f, 0.22396180f, 
    0.15460745f, 0.25148875f, 0.22209938f, 0.31959397f, 0.15244895f, 0.16564208f, -0.06464382f, 0.14123327f, 
    0.02745174f, 0.08876231f, 0.01869358f, 0.01919465f, 0.30595344f, 0.31555203f, -0.01698432f, -0.01872047f, 
    0.15364583f, -0.08670767f, 0.15531051f, -0.01030659f, -0.03866636f, 0.02700986f, 0.10629787f, -0.07185379f, 
    -0.15284237f, 0.09860343f, -0.14342210f, 0.17545894f, 0.04676135f, 0.07709438f, 0.05737748f, 0.04098249f, 
    0.16037065f, -0.00018621f, -0.08185281f, 0.02726058f, 0.13559411f, 0.02495915f, 0.05623170f, 0.05271264f, 
    0.05188331f, 0.09149277f, 0.03373034f, -0.10710391f, 0.09840588f, -0.03692961f, -0.00629643f, 0.00947495f, 
    -0.00694405f, -0.22298354f, 0.01803455f, 0.04460490f, 0.06811523f, 0.02381874f, -0.11251079f, -0.02767778f, 
    0.06383090f, -0.07291850f, -0.01591938f, 0.08617479f, 0.00010223f, -0.10055149f, 0.11299931f, -0.15342844f, 
    -0.06092176f, 0.00649743f, 0.05415647f, 0.16276981f, 0.01070231f, 0.08873614f, -0.05401869f, 0.04441350f, 
    -0.15219690f, 0.00351201f, -0.04398905f, 0.12229205f, 0.06739655f, -0.02126881f, -0.04385665f, -0.00514593f, 
    0.05383904f, -0.04125080f, 0.01661137f, -0.07942508f, 0.09983265f, -0.09835781f, -0.08129267f, 0.00174118f, 
    -0.09459651f, 0.03695238f, -0.03417786f, -0.11516856f, -0.02101174f, 0.08696207f, 0.17771339f, 0.13728301f, 
    0.29420087f, 0.03108250f, 0.57191122f, 0.27680838f, 0.01003145f, -0.12288412f, -0.10018456f, -0.12530378f, 
    0.01367786f, 0.05707818f, 0.26748016f, 0.27410522f, -0.10786764f, 0.12971652f, 0.24898320f, 0.00424585f, 
    -0.00187611f, -0.18380177f, -0.06966395f, -0.03957110f, -0.08930316f, 0.11377353f, 0.03098698f, -0.02359071f, 
    0.08025119f, -0.34967041f, -0.16680329f, 0.20057268f, -0.18328902f, 0.05030239f, -0.01051919f, 0.00507627f, 
    0.05113450f, 0.06914912f, 0.00856978f, -0.09030855f, 0.09028868f, -0.02633451f, -0.27415773f, -0.02689465f, 
    0.06541047f, 0.03167058f, 0.05302255f, 0.01122214f, 0.05778647f, 0.04354908f, -0.04259016f, -0.08105719f, 
    0.22265667f, -0.18298253f, -0.59965235f, 0.09235428f, 0.15033919f, 0.00792275f, 0.08637541f, 0.10015734f, 
    -0.04710495f, 0.00056724f, -0.00457783f, 0.03477645f, 0.03826923f, 0.15519398f, 0.03708149f, -0.03261802f, 
    0.07292377f, -0.05265267f, 0.02957358f, 0.07170427f, 0.23183227f, 0.21795818f, 0.26829046f, 0.07826519f, 
    -0.13002819f, -0.00882886f, 0.18041898f, 0.15834841f, 0.08479809f, 0.18160704f, -0.16094740f, -0.16656546f, 
    0.12049040f, 0.03634050f, 0.08252186f, -0.02078898f, -0.17682105f, -0.00848468f, -0.11067329f, 0.08179553f, 
    0.19248009f, 0.07506938f, 0.01105280f, 0.05514859f, 0.07134066f, 0.01427641f, 0.00987522f, -0.12395611f, 
    -0.19271705f, -0.01443775f, -0.59073710f, -0.27458096f, -0.12379742f, -0.00021704f, 0.09896001f, 0.03485248f, 
    0.02016342f, -0.00309105f, -0.10867457f, 0.03958974f, 0.12768432f, -0.06559218f, -0.09402394f, -0.34984395f, 
    0.07415367f, 0.02020890f, -0.10750420f, 0.12836529f, -0.03549475f, -0.01210515f, -0.03402385f, 0.02692336f, 
    -0.00429218f, 0.49310577f, 0.13754588f, -0.11492680f, -0.11277299f, -0.16061996f, -0.01833836f, 0.14820552f, 
    0.04677733f, 0.04776309f, 0.33267075f, 0.04887455f, -0.13013203f, -0.18030497f, -0.23595010f, -0.36040851f, 
    -0.35091490f, -0.05501765f, -0.23783289f, 0.07225484f, -0.01114770f, -0.03222484f, -0.03925776f, -0.03840077f, 
    0.12325150f, -0.18406792f, -0.05156384f, -0.09544519f, 0.07779206f, 0.21774249f, 0.10131753f, 0.27821308f, 
    -0.10066719f, -0.04740750f, 0.06958944f, -0.00024352f, 0.08331217f, -0.10502485f, 0.02132501f, -0.04762911f, 
    0.04109162f, 0.08113954f, 0.03226567f, -0.16667616f, 0.12664707f, -0.03737455f, 0.11534491f, 0.09735160f, 
    0.02692986f, -0.05664944f, -0.03644498f, -0.04362779f, 0.21405418f, 0.08839940f, 0.06593782f, -0.03379777f, 
    0.10869142f, -0.02577175f, -0.02004686f, 0.08479708f, 0.17710702f, 0.01642305f, 0.02829052f, 0.04399470f, 
    0.12465410f, -0.06914289f, 0.02224542f, 0.05398957f, 0.10114735f, 0.14045745f, -0.24892825f, -0.08253489f, 
    -0.05493134f, 0.02094652f, -0.04474384f, -0.04287997f, 0.00114082f, -0.00152594f, -0.06205847f, -0.00319382f, 
    -0.07835516f, 0.00761450f, -0.08051205f, -0.09172221f, 0.01570101f, -0.08529318f, -0.01114563f, 0.00832612f, 
    -0.04707804f, 0.02459380f, 0.04085024f, 0.07609007f, 0.04071731f, -0.05596347f, -0.01487812f, -0.05843417f, 
    -0.01242780f, -0.07999499f, -0.02314858f, -0.07449853f, -0.09034731f, -0.02689297f, -0.08592935f, -0.05533667f, 
    -0.05711997f, 0.04561198f, -0.05587030f, -0.02259354f, -0.00732535f, -0.00788704f, 0.03736080f, 0.02145106f, 
    -0.00120779f, -0.04347913f, -0.02392025f, 0.02645693f, 0.07436492f, 0.01374488f, -0.06777111f, -0.06599618f, 
    0.02434361f, -0.06063927f, 0.01796272f, 0.02799570f, -0.07694945f, 0.05954201f, 0.04251698f, -0.00163553f, 
    0.03557160f, -0.06922730f, -0.05533646f, -0.07514682f, 0.00828343f, 0.01201608f, -0.03501474f, -0.01886723f, 
    -0.00459861f, -0.04160617f, -0.02867627f, 0.03290896f, -0.02821463f, 0.01225862f, 0.00498117f, -0.05668055f, 
    0.04028169f, -0.05772030f, 0.06818815f, -0.00490908f, 0.01798466f, -0.05347327f, 0.01685447f, -0.05582156f, 
    -0.03196689f, 0.05532836f, -0.03784664f, -0.02613928f, 0.03878222f, -0.04714348f, -0.05722799f, -0.04729407f, 
    -0.03890913f, 0.06072620f, -0.03119347f, 0.01782984f, -0.02964012f, -0.06741068f, -0.00971972f, -0.06700258f, 
    0.01120880f, -0.00486828f, -0.01101516f, -0.08941574f, -0.00665032f, -0.06205759f, 0.03777600f, -0.06124456f, 
    -0.07311174f, 0.03636417f, 0.00929692f, -0.07511266f, 0.00686128f, -0.00738825f, -0.01146969f, 0.02056817f, 
    -0.00689573f, -0.06266697f, -0.09039656f, 0.03442277f, -0.06965214f, -0.03720670f, -0.06056175f, -0.05397590f, 
    -0.04953860f, -0.02425413f, 0.04488920f, -0.04291154f, 0.01267463f, -0.06675617f, -0.02024001f, -0.04354687f, 
    0.03717992f, 0.00737033f, 0.01300624f, 0.05365768f, 0.00128303f, 0.00071936f, -0.07414517f, -0.02286270f, 
    -0.08681016f, -0.06328978f, -0.10628784f, -0.03520123f, -0.07235651f, -0.02629745f, -0.04124540f, -0.05477680f, 
    0.00265888f, 0.06206468f, 0.00274129f, 0.01830407f, 0.06430789f, -0.05508913f, 0.05728688f, -0.05293268f, 
    -0.06096144f, 0.06945176f, 0.07490314f, -0.01592917f, 0.04887726f, -0.00611967f, -0.05526194f, 0.04620605f, 
    -0.07093562f, -0.07495442f, 0.05609928f, -0.04669983f, 0.05391192f, -0.01294375f, -0.03989189f, -0.04187690f, 
    0.06107909f, -0.00090306f, 0.02745027f, 0.06175695f, 0.04738107f, -0.03149888f, -0.07063795f, 0.07318730f, 
    -0.04216182f, 0.02060946f, -0.02324738f, 0.02798491f, -0.02457386f, -0.04104234f, 0.07408355f, -0.02645632f, 
    -0.02465206f, -0.02840406f, 0.05046983f, 0.04609896f, -0.07891748f, -0.05829044f, 0.00460136f, 0.01917029f, 
    0.20571354f, 0.07594884f, 0.15633146f, 0.24514741f, -0.02363029f, -0.04120440f, -0.17221336f, -0.05668837f, 
    0.00484573f, 0.01993810f, 0.03513293f, 0.12525316f, 0.30756417f, 0.13965105f, 0.36012566f, 0.22655171f, 
    -0.25962651f, -0.17728357f, -0.04601581f, 0.10907351f, -0.10951527f, 0.03891677f, -0.03461288f, -0.02465037f, 
    -0.03483229f, -0.02290578f, -0.10064957f, 0.08199367f, -0.02219744f, 0.05240209f, 0.00674262f, -0.06296133f, 
    0.01784434f, 0.23129037f, 0.18427181f, 0.22006522f, -0.00016293f, -0.13715674f, -0.45424625f, -0.00023382f, 
    0.10742716f, 0.20961784f, 0.15979330f, -0.22220609f, -0.04208552f, 0.00937261f, 0.07646531f, -0.02038987f, 
    -0.07500141f, 0.00619727f, 0.08174118f, 0.33225700f, -0.01679913f, 0.28531376f, 0.17363322f, 0.09970390f, 
    0.00818431f, -0.13535859f, 0.09141734f, 0.19775385f, -0.01820113f, 0.06636886f, 0.09655590f, -0.13229583f, 
    -0.01808778f, -0.07854380f, -0.00714263f, 0.11902089f, 0.02513348f, 0.15387607f, 0.19515254f, 0.19770169f, 
    -0.02193218f, 0.08073358f, 0.31514573f, 0.03673823f, 0.01859311f, -0.06605287f, -0.30862013f, -0.08127113f, 
    -0.10897096f, -0.14708456f, -0.07642279f, -0.20784877f, -0.02042466f, -0.16881396f, 0.10411677f, -0.16769940f, 
    0.06432543f, 0.14031407f, -0.12596381f, -0.16578458f, -0.06123536f, -0.24582270f, -0.15596448f, -0.13153759f, 
    0.11427248f, 0.08527719f, -0.11327866f, 0.32155934f, -0.09064782f, 0.15315884f, 0.06818702f, 0.05249683f, 
    -0.05679668f, 0.01033407f, -0.20844500f, -0.24776390f, 0.10081005f, 0.03444074f, 0.08920542f, 0.31245497f, 
    0.16198356f, 0.03290111f, 0.06320179f, 0.19028373f, 0.09683436f, -0.06692054f, 0.16254233f, -0.11210667f, 
    0.16806583f, 0.15167835f, -0.05889611f, 0.28885442f, -0.17993389f, -0.16119288f, -0.04083853f, -0.21241002f, 
    0.11386697f, 0.03383284f, 0.06744003f, 0.17603131f, 0.11349583f, 0.03465443f, -0.10537525f, 0.13222951f, 
    -0.04833414f, 0.03826225f, 0.00268666f, 0.00338582f, -0.17149462f, 0.00555379f, 0.01727918f, 0.08382845f, 
    -0.00780923f, -0.24708946f, 0.11831577f, -0.22514269f, 0.08035063f, -0.06530011f, -0.11352739f, -0.25023848f, 
    -0.30136973f, -0.06014305f, -0.28175518f, -0.28923658f, -0.32020074f, -0.09115510f, -0.04765077f, -0.14328313f, 
    0.09101892f, -0.02898105f, 0.23850855f, -0.16375732f, 0.10222072f, -0.04323832f, -0.07980715f, 0.20209973f, 
    -0.33820385f, -0.26257491f, 0.08895697f, 0.08942698f, 0.17878321f, 0.14709844f, 0.08810188f, -0.01986969f, 
    -0.11911193f, -0.22590946f, -0.13286920f, 0.11106798f, 0.23800829f, 0.15726307f, 0.18738768f, 0.13590445f, 
    0.20885618f, -0.05503162f, 0.06193792f, -0.35539594f, -0.02378519f, -0.12954982f, -0.25069094f, -0.13452891f, 
    -0.00052765f, 0.04929769f, -0.01147896f, 0.05832867f, -0.03946099f, 0.03016201f, -0.06017489f, -0.06860695f, 
    0.05725494f, -0.01378366f, -0.02808416f, -0.04295569f, -0.07605561f, -0.01261415f, 0.01002723f, -0.02813424f, 
    0.01388062f, -0.06951505f, -0.04573768f, -0.02072423f, 0.06070423f, -0.06940521f, 0.04290355f, -0.06812572f, 
    -0.06892637f, -0.07357740f, 0.01862928f, 0.02003077f, 0.00250628f, -0.01717202f, -0.06593465f, -0.04108657f, 
    0.03578310f, -0.04538542f, 0.05584747f, -0.02166425f, -0.02525523f, -0.01011707f, 0.04206218f, 0.04225060f, 
    -0.04985323f, 0.05292928f, 0.02951336f, -0.00647356f, -0.06048049f, 0.05958894f, 0.02586416f, -0.03171478f, 
    -0.04733529f, -0.03647184f, -0.05544670f, 0.03569814f, -0.02570399f, -0.06108973f, 0.05239207f, -0.07497206f, 
    0.02234424f, 0.04625067f, 0.01380802f, 0.04491134f, -0.04503258f, -0.03107969f, -0.02779687f, -0.07309965f, 
    -0.02638518f, 0.03833340f, 0.04353981f, 0.01442612f, -0.04072948f, 0.01245211f, 0.03845499f, -0.01264168f, 
    -0.07360028f, -0.03806183f, -0.03364348f, -0.04039141f, -0.00718293f, 0.01568637f, -0.00615471f, -0.03792193f, 
    0.03836781f, -0.07706828f, 0.06126924f, 0.02706043f, 0.01924361f, -0.04494952f, -0.02358380f, 0.01600227f, 
    -0.01195727f, 0.00960091f, 0.05058975f, 0.03566805f, 0.01236669f, 0.00100020f, 0.05569278f, -0.00657332f, 
    -0.00663293f, -0.00515346f, 0.01848392f, 0.04499741f, -0.03236409f, -0.01702493f, 0.01912189f, -0.00538861f, 
    -0.03523213f, 0.00202213f, 0.04443274f, -0.02069982f, 0.04659834f, -0.06186992f, -0.03728242f, -0.02582931f, 
    -0.00920923f, -0.07370023f, 0.03537677f, 0.05097429f, -0.01153904f, 0.05021776f, 0.00556913f, 0.04341849f, 
    -0.03042017f, 0.01403696f, 0.01520889f, 0.04953792f, 0.06048954f, -0.01213813f, 0.00829975f, -0.04122212f, 
    0.04268280f, 0.00876629f, -0.01282342f, -0.07235990f, 0.02162184f, 0.02694365f, 0.02541978f, 0.03800651f, 
    -0.05219875f, 0.06163303f, -0.03902843f, 0.05239936f, -0.00505491f, 0.02192188f, -0.04252728f, -0.02220817f, 
    0.02248176f, -0.03369141f, 0.01370103f, -0.06672928f, -0.01172632f, 0.04991518f, -0.04438838f, -0.03508456f, 
    -0.07589871f, -0.07795528f, -0.05786170f, -0.08022960f, -0.04390776f, -0.04473936f, -0.08037783f, -0.02645926f, 
    -0.06204643f, -0.02411455f, -0.03424460f, 0.02464642f, -0.02758164f, -0.05687157f, -0.01509807f, 0.04697856f, 
    -0.06933007f, -0.05312389f, -0.00678913f, -0.03785728f, -0.01540778f, 0.03289184f, 0.02997473f, 0.01070418f, 
    0.05382828f, -0.06766164f, -0.07406145f, -0.05821181f, 0.02837105f, -0.03356641f, -0.06309640f, -0.03350965f, 
    0.00947646f, -0.00557277f, -0.07945866f, -0.03105671f, -0.06419630f, 0.00408283f, -0.06115123f, 0.03798955f, 
    -0.31131640f, 0.34311152f, -0.16259295f, 0.20467129f, 0.05818457f, 0.00376079f, -0.12520985f, 0.00725311f, 
    0.06049257f, 0.06173785f, 0.00013168f, -0.06203061f, 0.08520022f, 0.33900037f, -0.03000386f, -0.05822881f, 
    -0.08248261f, 0.23534285f, 0.06597977f, 0.06895077f, 0.07614885f, -0.05387472f, 0.03832221f, 0.08104001f, 
    -0.01177000f, -0.04475544f, -0.08131490f, -0.01630841f, 0.11191470f, -0.00894644f, -0.01525684f, 0.01957590f, 
    -0.03429174f, -0.02403703f, 0.08478563f, 0.04309948f, -0.23686332f, -0.03695297f, 0.17674007f, -0.17324461f, 
    -0.08254605f, -0.19160520f, -0.20067608f, -0.20606682f, -0.06845415f, -0.03060817f, -0.12165505f, 0.12560333f, 
    -0.30942407f, 0.06647051f, 0.17472859f, 0.09551859f, -0.20050783f, -0.06395816f, -0.17673519f, -0.07307869f, 
    -0.10311176f, 0.03013963f, 0.04918314f, 0.00144234f, -0.09876664f, -0.14881089f, 0.11328298f, -0.20187524f, 
    -0.08504450f, -0.03810427f, -0.03018374f, -0.21603179f, -0.05134927f, 0.04626040f, 0.02317601f, 0.02958354f, 
    0.28168875f, -0.14008769f, -0.09581823f, -0.01486959f, 0.00371688f, -0.21307379f, 0.06339234f, -0.06929435f, 
    0.15840977f, 0.05086999f, 0.09530001f, 0.06649293f, 0.18206081f, 0.14120780f, 0.10381734f, -0.10998198f, 
    -0.02056265f, 0.07672845f, 0.04428544f, 0.08462858f, -0.01993768f, -0.02726323f, 0.01914759f, 0.23886119f, 
    -0.19157529f, -0.16912200f, 0.13413671f, -0.08986045f, 0.05861789f, 0.13289943f, 0.04381065f, -0.00046733f, 
    -0.01307193f, -0.06282473f, 0.05335600f, 0.03384487f, -0.39983174f, -0.05886647f, -0.04187375f, 0.16943288f, 
    0.07203609f, 0.12644562f, -0.01334811f, -0.08606580f, 0.07542178f, -0.04096556f, -0.03875123f, 0.13307036f, 
    0.56698447f, 0.02778181f, 0.06870428f, 0.61581898f, -0.07264519f, 0.06286487f, 0.01672325f, 0.01987130f, 
    -0.00550842f, 0.05702068f, 0.01587215f, 0.14358544f, 0.04110868f, -0.15182546f, 0.29206386f, 0.25478351f, 
    0.13344783f, 0.09688652f, 0.23901634f, -0.07182038f, 0.00152811f, 0.08426643f, -0.04501067f, 0.11872601f, 
    -0.30282307f, 0.15569036f, -0.12520280f, 0.19055870f, 0.03892081f, -0.11903468f, -0.13399534f, 0.00410946f, 
    0.10039721f, 0.09335660f, -0.11208064f, 0.10951128f, 0.13435604f, 0.21770471f, 0.13681218f, -0.05064124f, 
    0.00002613f, -0.02258817f, -0.01684156f, 0.03615296f, 0.02375600f, -0.07541370f, -0.08597020f, 0.04731995f, 
    -0.39485675f, 0.06596678f, 0.18259171f, 0.19483568f, -0.09703790f, -0.04374823f, -0.12910005f, -0.24621592f, 
    -0.11127039f, -0.03883376f, -0.04149578f, -0.01512453f, 0.04110223f, 0.01526288f, 0.00730762f, 0.01694527f, 
    0.11320019f, -0.05088872f, 0.05328953f, 0.07394741f, -0.09940108f, 0.01349605f, 0.05382007f, 0.18509999f, 
    0.02742285f, 0.04016591f, 0.18773049f, 0.12482174f, -0.00253484f, -0.02725616f, 0.08814908f, 0.04169576f, 
    -0.01388005f, -0.11306590f, 0.03851448f, -0.03611308f, 0.18018821f, 0.04012801f, 0.24866955f, 0.24776176f, 
    -0.06412637f, -0.00228021f, 0.06851289f, 0.01495033f, -0.01085775f, -0.05831495f, -0.10458937f, -0.05185236f, 
    -0.07970774f, -0.01248252f, 0.28313842f, 0.07566109f, -0.06303238f, 0.09357094f, -0.01522004f, 0.03275777f, 
    0.00355052f, -0.04778348f, -0.13393506f, -0.00422688f, -0.52079797f, -0.48382500f, -0.38303998f, 0.26287684f, 
    0.00446838f, 0.02234033f, 0.01069621f, 0.02893765f, 0.07402934f, 0.06549592f, 0.06945662f, 0.16895236f, 
    -0.36470816f, 0.22406448f, 0.30684790f, 0.16153403f, -0.20153303f, 0.04247490f, 0.08178658f, 0.05449431f, 
    -0.03928274f, -0.01938473f, -0.15455019f, -0.07060923f, -0.18762924f, -0.33885458f, -0.08323383f, 0.05900139f, 
    0.01214792f, -0.02073494f, 0.05851527f, -0.03159100f, 0.12648346f, -0.26344714f, -0.03743108f, 0.13769148f, 
    0.03248324f, -0.18779728f, 0.18489188f, 0.10790459f, 0.08684488f, 0.14145023f, -0.07452863f, 0.23383453f, 
    -0.00522388f, -0.14795959f, -0.01493075f, 0.01485935f, 0.01829382f, -0.05573026f, -0.07557639f, 0.17456405f, 
    0.07940043f, 0.01783564f, 0.06433281f, -0.01688549f, -0.01040644f, -0.11884632f, 0.02313922f, 0.11757504f, 
    0.28009218f, 0.37721133f, 0.14279410f, 0.31491074f, 0.00592118f, 0.11275045f, 0.01111259f, 0.12970890f, 
    0.03456096f, 0.12288883f, 0.04707502f, -0.08256219f, 0.37162977f, 0.30870694f, 0.01663732f, -0.14822297f, 
    0.03849423f, -0.03446868f, 0.10429495f, 0.25078303f, 0.01687331f, -0.03801083f, 0.05633192f, -0.07155959f, 
    0.00642842f, -0.06716134f, -0.06236641f, -0.04051577f, -0.02410130f, -0.00988865f, 0.05286853f, -0.02680106f, 
    0.08703833f, -0.03100432f, -0.11414733f, 0.16639224f, -0.02202892f, 0.24924517f, 0.00643087f, 0.06042925f, 
    -0.03513588f, 0.13300970f, -0.09150272f, 0.00986492f, 0.04905730f, 0.01358547f, 0.02178807f, -0.01529228f, 
    0.06145393f, -0.28031054f, -0.12434546f, -0.02662409f, 0.06436748f, 0.10743655f, 0.16094983f, 0.08207846f, 
    0.01083196f, 0.07698024f, -0.09049910f, -0.03411998f, -0.37220424f, -0.15781410f, -0.06177396f, -0.00333299f, 
    -0.02260572f, -0.19577293f, 0.01876891f, 0.11197191f, 0.05500355f, 0.03177099f, 0.01948608f, 0.05478785f, 
    0.12256619f, -0.16581318f, -0.28785971f, -0.07789356f, 0.09514487f, -0.01378786f, -0.00141315f, 0.15944208f, 
    0.02731022f, -0.01391732f, 0.03808960f, -0.03137812f, 0.07109578f, -0.14968865f, 0.01887820f, -0.13872699f, 
    -0.08472483f, -0.05259000f, -0.00575016f, -0.18663682f, 0.03242305f, 0.04214386f, 0.13261770f, 0.00018545f, 
    0.07179587f, 0.06192788f, -0.04916801f, -0.02358249f, 0.00771861f, -0.03580939f, 0.00175946f, -0.04090233f, 
    -0.06841480f, -0.00526409f, -0.00091691f, -0.03959362f, 0.04704470f, 0.06114177f, -0.05622341f, -0.06710947f, 
    0.04892456f, 0.04192514f, -0.04889969f, 0.01588269f, -0.03398553f, -0.03014651f, -0.06453351f, -0.06948431f, 
    -0.03235686f, -0.05263647f, 0.02199749f, -0.05093528f, -0.05901267f, -0.00686313f, 0.00369942f, -0.00423029f, 
    0.05684755f, -0.04237738f, -0.02050856f, 0.03575276f, -0.02100882f, -0.03956645f, 0.02630423f, -0.06815204f, 
    -0.03396720f, -0.02146821f, 0.01488291f, 0.04006182f, -0.03251599f, 0.04365820f, -0.02513666f, 0.06546352f, 
    0.00926526f, -0.03369308f, -0.04285106f, -0.00584629f, 0.00293367f, -0.02656990f, 0.03418127f, -0.00534877f, 
    0.05527400f, -0.07369549f, -0.00651129f, -0.00129513f, -0.02254834f, 0.01186303f, -0.04719653f, -0.05768392f, 
    0.03454451f, 0.01329035f, -0.02094944f, 0.00900625f, 0.05504510f, 0.02859135f, -0.06438606f, -0.00785076f, 
    0.05394545f, 0.05869078f, -0.03799276f, 0.05598466f, -0.05967713f, -0.04951455f, -0.04655892f, 0.00939315f, 
    0.00027382f, -0.07340902f, 0.03604034f, -0.01550266f, -0.06935441f, -0.06941070f, 0.00518332f, 0.00655603f, 
    -0.00798461f, -0.06023549f, -0.05976718f, 0.02716910f, -0.06622947f, -0.05082571f, 0.06053834f, -0.01967511f, 
    0.02458842f, -0.03951822f, -0.05472236f, 0.05434710f, -0.00369751f, -0.05607544f, 0.06763002f, 0.03632342f, 
    -0.01421077f, 0.00928378f, 0.02776955f, -0.02765124f, 0.06443696f, -0.01511656f, -0.04404973f, 0.02793006f, 
    -0.04568484f, -0.07227500f, 0.02121983f, -0.01599069f, 0.03396300f, -0.05744937f, -0.04665945f, -0.02759586f, 
    -0.00621601f, -0.07101749f, 0.00846763f, -0.03128778f, 0.01821987f, 0.02752432f, 0.05727921f, 0.00081853f, 
    -0.06304199f, -0.05077581f, -0.04447452f, -0.00189699f, -0.06503794f, -0.03538291f, -0.06380354f, 0.03303054f, 
    0.01257688f, -0.07022750f, 0.00975684f, 0.01922962f, 0.03075404f, 0.06432635f, 0.02270894f, -0.02147470f, 
    0.02126103f, -0.03545249f, -0.02001231f, -0.06157865f, -0.06855615f, -0.07533534f, 0.01865439f, -0.02993539f, 
    -0.02126765f, -0.00062685f, 0.01739860f, 0.05291301f, 0.01988844f, 0.05812077f, 0.04448567f, -0.04322167f, 
    -0.06334767f, -0.04570466f, 0.00399080f, -0.05280502f, -0.04292618f, -0.03220000f, 0.04009667f, -0.07302449f, 
    0.01231467f, 0.04139666f, 0.01259623f, -0.03264714f, 0.06136842f, -0.05196441f, 0.01674839f, 0.01529165f, 
    -0.03805656f, -0.00042689f, 0.01999171f, 0.03370138f, -0.07343177f, 0.00691678f, 0.00537175f, 0.05114101f, 
    -0.00197766f, -0.02633292f, 0.06400627f, -0.03761340f, 0.06203815f, -0.05785313f, -0.04471172f, 0.01367798f, 
    0.11037996f, -0.07266164f, -0.16024347f, -0.09974436f, 0.05069916f, 0.05632674f, -0.05712552f, 0.16279091f, 
    -0.02607623f, 0.01324157f, 0.02228072f, -0.10571483f, 0.15928160f, -0.05181624f, -0.00836444f, -0.03630207f, 
    0.13275765f, 0.16204269f, 0.08159536f, 0.09203239f, 0.05189867f, -0.13310790f, -0.16524956f, 0.03403205f, 
    0.13335353f, 0.39343083f, 0.01898015f, -0.11031915f, 0.06480059f, 0.01017046f, 0.03669522f, -0.00681813f, 
    -0.08113545f, -0.10538187f, -0.09150308f, -0.12160479f, -0.24257596f, 0.06077452f, -0.14141102f, -0.10153168f, 
    -0.11098108f, -0.19647795f, -0.11044940f, -0.14325339f, -0.20797238f, -0.04754870f, -0.01215794f, 0.06833980f, 
    0.14985321f, -0.06925073f, 0.24912459f, -0.37999099f, -0.06612793f, -0.00090288f, 0.08423514f, -0.18405657f, 
    -0.15241574f, -0.11606885f, -0.07882981f, -0.00748579f, -0.22337766f, 0.07714310f, -0.04242030f, -0.03653717f, 
    -0.01021450f, 0.04084913f, -0.13833357f, -0.01425657f, 0.07499228f, -0.19942288f, -0.02709141f, 0.06071880f, 
    -0.03017811f, -0.06603540f, 0.03274221f, -0.08240265f, -0.12145893f, 0.02840819f, -0.05055139f, 0.03410315f, 
    -0.06518324f, -0.17122702f, 0.10026785f, 0.06293123f, -0.12749885f, 0.01184854f, 0.13887484f, 0.17126513f, 
    -0.13645782f, 0.09633347f, 0.01676100f, -0.07223983f, 0.10500871f, 0.00570402f, 0.17736864f, 0.02570107f, 
    0.21766055f, 0.07309894f, 0.00960182f, 0.04459964f, 0.06174049f, 0.20952836f, 0.11558881f, 0.02645068f, 
    0.08098177f, 0.10904901f, 0.23151769f, 0.08988839f, 0.17995508f, -0.00905538f, -0.11707100f, 0.25051644f, 
    0.04599661f, 0.11439220f, 0.00632479f, 0.14016387f, -0.00217557f, 0.18188484f, -0.04976593f, -0.11809527f, 
    -0.07906426f, -0.23313208f, 0.06154083f, -0.03824641f, 0.01652252f, 0.06423075f, 0.09669462f, 0.14463884f, 
    0.04094857f, 0.10250314f, -0.15755276f, -0.01009098f, -0.01310004f, 0.14312664f, -0.16787402f, -0.01635582f, 
    0.10352320f, 0.20445266f, 0.02547096f, -0.04482920f, -0.03870799f, 0.09026164f, -0.01911899f, 0.03496786f, 
    0.08538571f, 0.06665044f, -0.01894407f, -0.03298319f, -0.07932162f, 0.04279346f, -0.03628555f, -0.01891078f, 
    -0.00860544f, -0.00017360f, 0.11414208f, 0.10174885f, -0.23708633f, 0.20068899f, 0.22738674f, 0.14358702f, 
    -0.13570526f, -0.16931698f, -0.10817892f, 0.14907581f, 0.03227042f, 0.04865926f, 0.17566736f, 0.16849200f, 
    -0.31647640f, -0.10994032f, 0.07169276f, -0.03762804f, -0.11172745f, -0.03868749f, -0.07451369f, -0.01356226f, 
    0.00628487f, 0.06919002f, 0.07242083f, 0.19000471f, -0.07773920f, -0.21359573f, 0.05054591f, 0.07032931f, 
    -0.06207262f, -0.10713361f, -0.00799218f, -0.07214960f, 0.17285448f, 0.09277167f, 0.30653509f, 0.17126051f, 
    0.04810673f, -0.02603439f, -0.02059991f, -0.03716353f, -0.05529461f, -0.06136642f, 0.05108313f, 0.05737324f, 
    -0.03429180f, 0.02232924f, 0.04685099f, -0.06700420f, 0.04782681f, 0.04802074f, 0.00831470f, 0.05471484f, 
    0.06510912f, -0.03613033f, -0.01661776f, 0.06233183f, -0.06730567f, 0.02079182f, -0.04576473f, 0.05192339f, 
    -0.00030452f, -0.02314729f, -0.06085290f, -0.00948996f, 0.00940910f, 0.04925463f, -0.00606338f, -0.06794763f, 
    -0.04130444f, -0.02085223f, 0.03486219f, -0.01198654f, -0.07711387f, -0.01071757f, -0.05618729f, 0.01002899f, 
    -0.05763223f, -0.06869394f, -0.05325155f, -0.05772823f, 0.02261379f, 0.02875369f, 0.05456464f, -0.04493204f, 
    -0.03378781f, 0.00375997f, -0.05172807f, 0.00774517f, 0.02149446f, -0.00338368f, -0.04087407f, -0.02193985f, 
    -0.02744759f, -0.02172036f, 0.01153424f, 0.03907651f, 0.02150952f, -0.05277365f, -0.05348471f, 0.05242681f, 
    0.00612492f, -0.00238502f, -0.06682351f, 0.00921481f, 0.03366076f, -0.02203931f, -0.00182452f, -0.06901997f, 
    0.03000355f, 0.00466099f, 0.01854133f, -0.06748388f, -0.07592661f, 0.01471410f, -0.02696503f, -0.07193852f, 
    0.00371485f, 0.00080307f, -0.02097282f, 0.00545890f, -0.00850167f, -0.05750261f, 0.04476791f, -0.07411090f, 
    0.00949382f, 0.01413667f, 0.03269768f, -0.00788664f, -0.03705451f, -0.03447309f, -0.05512012f, -0.01096796f, 
    -0.05593510f, 0.04533838f, 0.01240020f, 0.02152140f, -0.03408811f, 0.05504274f, -0.02320632f, -0.06415871f, 
    0.03052862f, -0.02774351f, 0.02662343f, -0.07686953f, 0.04269587f, 0.05705736f, -0.05499609f, -0.03143061f, 
    0.01789056f, 0.04698727f, -0.04010630f, -0.02917341f, 0.00006602f, -0.01952499f, -0.02768358f, 0.03598912f, 
    -0.00583732f, 0.03809790f, -0.03945886f, 0.01261670f, -0.01406435f, -0.03766290f, -0.07940606f, 0.02189196f, 
    0.01616566f, -0.04854659f, -0.02167677f, -0.03196288f, -0.01278147f, -0.03900513f, -0.04689206f, -0.04179730f, 
    -0.00054601f, -0.04744243f, 0.06259580f, -0.06764317f, 0.02135709f, 0.00183234f, -0.01281326f, 0.00968486f, 
    -0.02914557f, 0.04830450f, -0.04774787f, -0.01814870f, 0.02166794f, 0.06121320f, -0.02787773f, -0.07179388f, 
    0.05364399f, 0.04023821f, 0.04116089f, 0.03358498f, -0.01383657f, -0.06205932f, -0.07341058f, -0.06425754f, 
    0.02781284f, -0.01402685f, 0.05098280f, 0.04901236f, 0.05355192f, -0.00756629f, -0.02474152f, -0.07310149f, 
    -0.03869936f, -0.04244330f, -0.01795188f, -0.05213297f, -0.06401508f, 0.01726691f, -0.01011636f, -0.06687254f, 
    -0.02859321f, -0.01965288f, 0.04101145f, -0.02550424f, 0.03112142f, -0.06003273f, 0.02064297f, -0.05847202f, 
    0.04433881f, -0.02157342f, 0.04136033f, 0.01065369f, 0.03208693f, -0.00463748f, 0.05815419f, -0.04158588f, 
    0.27407297f, -0.00869705f, -0.06613979f, -0.08753304f, -0.12209986f, -0.15072443f, -0.12575743f, 0.06340685f, 
    -0.01190886f, 0.04038497f, -0.14186415f, -0.17634100f, 0.02626451f, -0.04834549f, 0.07797562f, 0.15072365f, 
    -0.09214993f, -0.15479931f, -0.09837414f, 0.05376424f, -0.00218993f, -0.11085692f, -0.10630836f, 0.08508157f, 
    -0.22653706f, -0.09571958f, 0.06899928f, 0.06407081f, 0.03965640f, 0.09610712f, -0.15971142f, 0.03952866f, 
    0.03558357f, -0.07952984f, -0.02073794f, -0.05024239f, -0.03476591f, 0.02424240f, -0.05471959f, -0.00424855f, 
    -0.11610867f, -0.07000916f, -0.00829280f, 0.03579231f, -0.05137772f, 0.05302978f, 0.04888243f, 0.02159781f, 
    -0.09900399f, 0.06149752f, -0.38676912f, 0.13393396f, -0.05692137f, -0.09244189f, 0.12653050f, -0.02862858f, 
    -0.02737292f, 0.07243510f, 0.07800629f, -0.00091554f, 0.04704069f, 0.17093234f, 0.24814694f, 0.10191657f, 
    -0.03637206f, -0.05453923f, -0.05174613f, -0.17327408f, -0.02842391f, -0.10170890f, -0.15559885f, -0.19390213f, 
    0.10792856f, -0.02739380f, 0.28062591f, 0.31683213f, 0.03419105f, 0.08351383f, -0.17855059f, -0.04879025f, 
    0.10831130f, 0.06738804f, -0.01019088f, 0.02603739f, 0.29564992f, 0.27401954f, -0.12405299f, 0.08754154f, 
    0.01575184f, 0.07905901f, -0.00639113f, 0.09095710f, 0.02236791f, 0.01333540f, -0.14931270f, -0.04811157f, 
    -0.16172002f, 0.16580835f, 0.08749235f, 0.33189678f, -0.09026341f, -0.03765608f, 0.11235326f, 0.05898953f, 
    0.06584021f, -0.01352374f, -0.07165352f, -0.09461170f, 0.06118239f, 0.14141560f, 0.25878629f, 0.10331605f, 
    -0.02189395f, 0.04706559f, -0.01626675f, 0.40638164f, 0.08883896f, -0.14139405f, -0.05080774f, -0.07506149f, 
    -0.05462311f, 0.17959046f, -0.00530194f, 0.01382485f, -0.14388612f, -0.12157789f, 0.12415949f, 0.09007747f, 
    -0.10408222f, -0.04696111f, 0.04702365f, -0.05904979f, 0.10628623f, 0.10843931f, 0.24353601f, 0.16724907f, 
    0.00414047f, 0.09650794f, 0.02692105f, 0.27819011f, -0.03564128f, 0.12171063f, 0.13623384f, 0.03910975f, 
    -0.02205243f, -0.00805511f, 0.04970828f, -0.09442420f, -0.00161715f, 0.08075498f, 0.03640489f, -0.15199561f, 
    -0.10985077f, 0.12679048f, 0.03964967f, -0.03309023f, 0.25963497f, 0.12971756f, 0.23627791f, -0.10281811f, 
    0.05025547f, 0.05710051f, -0.10730011f, 0.03951631f, 0.03839641f, 0.12477063f, -0.10571578f, -0.11188596f, 
    0.25775179f, 0.01491656f, 0.10774706f, -0.06075648f, -0.06614687f, -0.15216556f, -0.00728011f, 0.06981114f, 
    -0.02632564f, 0.08898524f, 0.02629645f, 0.07783465f, 0.35609025f, 0.14260991f, 0.11552022f, -0.09971696f, 
    -0.01467447f, 0.05682860f, 0.11078148f, 0.04320733f, -0.07398599f, -0.06301654f, 0.01398098f, 0.09075585f, 
    -0.02067567f, -0.06975516f, -0.05028589f, 0.06037239f, -0.07467777f, -0.01007322f, 0.05932535f, 0.02752744f, 
    0.06283232f, 0.04369917f, 0.04445945f, -0.03588579f, 0.06255367f, 0.02119988f, -0.04749986f, 0.00591428f, 
    -0.04379210f, -0.00717376f, -0.05365457f, 0.05058176f, 0.05619776f, -0.05716077f, -0.03527597f, -0.03508528f, 
    -0.02024318f, 0.02748404f, -0.05163370f, -0.00684775f, -0.05018361f, -0.07887298f, -0.00376831f, -0.06423906f, 
    -0.02818372f, -0.06125358f, -0.01991814f, 0.02151607f, -0.04849408f, 0.02669488f, -0.03340499f, -0.01859918f, 
    0.01491308f, -0.08053610f, 0.04128714f, 0.06081277f, -0.05887409f, -0.02685866f, -0.05738622f, -0.08178001f, 
    0.05160585f, 0.01621160f, 0.03970360f, -0.00617624f, 0.01406031f, 0.04591360f, 0.02058421f, 0.05639256f, 
    -0.05427069f, 0.02251287f, -0.06045023f, -0.07945313f, -0.07796952f, -0.07609066f, -0.00939493f, 0.05475733f, 
    -0.00319290f, -0.02854830f, -0.01454662f, 0.04575134f, -0.04702336f, 0.06332638f, 0.01471677f, 0.02547156f, 
    0.05900522f, -0.07971421f, 0.00948531f, -0.05859948f, 0.02669296f, -0.00184264f, -0.08280054f, -0.06862217f, 
    0.00763603f, -0.06422241f, -0.02119689f, 0.03910996f, -0.07319292f, -0.05981783f, 0.02964799f, 0.02098936f, 
    0.00394249f, -0.03729245f, -0.08114471f, 0.00993537f, -0.07220475f, 0.00321967f, -0.02784116f, 0.04733400f, 
    0.06202219f, -0.07272224f, -0.02584605f, 0.05754573f, -0.04712258f, -0.06700784f, -0.01993752f, -0.07497796f, 
    -0.04182721f, 0.04835192f, 0.00864588f, 0.00631505f, 0.02011191f, -0.00250410f, 0.00086597f, 0.04702534f, 
    -0.00870653f, 0.02671875f, -0.06884879f, 0.06088658f, -0.03697222f, 0.05186411f, 0.02577938f, -0.00481386f, 
    0.01295515f, -0.04229248f, -0.00141353f, 0.04284786f, -0.00896325f, 0.00612974f, -0.05719827f, -0.06337402f, 
    -0.07583174f, -0.06936131f, -0.03205185f, -0.00882718f, -0.07088646f, 0.01482134f, -0.06651300f, 0.06001482f, 
    -0.06021915f, 0.00937793f, 0.00058977f, 0.01944009f, 0.01935266f, 0.03150396f, 0.04486754f, 0.00898061f, 
    -0.01405145f, 0.03529844f, -0.07904353f, -0.00358305f, -0.03178193f, -0.03530673f, 0.03863574f, 0.02348300f, 
    -0.07139125f, -0.04198302f, -0.01365492f, 0.04635355f, -0.04490174f, -0.06096079f, 0.05478163f, -0.03973534f, 
    -0.04075137f, 0.04771007f, -0.07503364f, 0.03530367f, -0.07279643f, -0.02269158f, -0.04824427f, -0.03718544f, 
    -0.02410212f, -0.03200855f, 0.01146042f, 0.00218033f, 0.05276755f, 0.04844856f, -0.06544895f, -0.05945082f, 
    0.02329758f, 0.00789097f, -0.02934339f, 0.03077241f, -0.03225519f, 0.05143430f, 0.04215670f, 0.05985821f, 
    0.00455441f, 0.04903359f, 0.04433646f, -0.01350890f, -0.05198225f, 0.05725706f, 0.05646253f, -0.00816732f, 
    0.23790982f, 0.08743874f, -0.12794369f, 0.11062633f, -0.07281362f, -0.06318803f, -0.10182213f, -0.04383697f, 
    0.06680112f, 0.09786160f, -0.01748534f, -0.10178684f, 0.10655427f, 0.11048278f, 0.16921584f, 0.01585148f, 
    -0.01525031f, -0.05601565f, -0.06248194f, 0.04899843f, 0.09697583f, -0.09640468f, -0.09218148f, 0.05474732f, 
    0.12827879f, 0.11237736f, -0.08241684f, -0.03268739f, 0.14655411f, 0.09097949f, 0.02222094f, 0.03816236f, 
    0.08880527f, 0.10023173f, 0.09808211f, 0.11009550f, -0.30277079f, -0.30735040f, -0.46980155f, -0.01572149f, 
    -0.07393511f, 0.04846314f, 0.00762168f, -0.05334746f, -0.06550139f, -0.02278370f, 0.03575229f, 0.05156426f, 
    -0.08978240f, 0.04047933f, -0.01140924f, -0.13867022f, -0.12463846f, 0.02584969f, 0.13127305f, -0.08398499f, 
    -0.03218066f, -0.06548068f, -0.10579678f, -0.02738909f, -0.22656824f, -0.08464411f, -0.00079336f, -0.10229405f, 
    -0.00694070f, 0.02780757f, -0.01062445f, -0.04459582f, -0.10825686f, -0.12996268f, 0.03360085f, -0.11568920f, 
    0.07624081f, -0.21635841f, 0.34704497f, 0.08165309f, -0.08345708f, -0.01856302f, -0.22238219f, -0.00746457f, 
    0.12335476f, -0.30092388f, 0.14032464f, -0.08624914f, -0.15131719f, 0.19265665f, -0.02662115f, 0.14594990f, 
    -0.05336532f, 0.15230131f, 0.13028653f, -0.05965110f, -0.02385692f, -0.05517345f, -0.07522448f, -0.09908724f, 
    0.13298783f, 0.08799326f, -0.06743112f, -0.03315593f, -0.01361595f, 0.07978153f, 0.02773361f, 0.04910785f, 
    0.02755658f, 0.03196039f, 0.05977965f, 0.10151097f, 0.40088105f, -0.03797374f, -0.02885218f, 0.09846338f, 
    0.03958527f, 0.15267630f, -0.03531872f, 0.39484903f, 0.05025174f, 0.05455105f, 0.02121774f, -0.08664517f, 
    0.05102132f, -0.28185508f, 0.10932617f, -0.13092892f, -0.10228663f, -0.10139520f, 0.02904093f, 0.22777615f, 
    -0.00053106f, -0.09464940f, 0.07095749f, -0.02290499f, 0.17569634f, 0.15537558f, -0.23191486f, -0.01466841f, 
    -0.11424083f, 0.04023697f, -0.10481476f, 0.10620770f, -0.00433286f, 0.07926074f, 0.09790585f, 0.10750309f, 
    -0.08612336f, -0.11745092f, 0.09392400f, -0.18035474f, -0.16359226f, 0.11023021f, -0.01192191f, -0.06352779f, 
    -0.06876793f, 0.06131997f, 0.06033372f, -0.03583578f, -0.27186331f, 0.02288852f, 0.11995762f, -0.10365234f, 
    -0.03089777f, -0.11045489f, 0.04224260f, 0.02858121f, 0.00267736f, -0.03294726f, 0.03411028f, -0.06730328f, 
    -0.21376418f, -0.27114600f, -0.07746423f, -0.14759155f, -0.05228077f, -0.08781433f, 0.04917442f, 0.00137614f, 
    -0.07557550f, 0.02563173f, -0.05579274f, 0.02106110f, 0.05961647f, -0.12695029f, 0.03327545f, -0.00908136f, 
    -0.06629777f, -0.02155633f, 0.10882965f, -0.06379316f, -0.09282756f, 0.14841573f, 0.07667375f, 0.22102886f, 
    -0.17287348f, 0.25594291f, -0.30183497f, -0.10761806f, 0.08604874f, 0.21698900f, 0.21471000f, 0.08588738f, 
    0.06898924f, -0.08639738f, -0.24669117f, -0.26235726f, 0.18012337f, -0.02304523f, 0.00629309f, 0.03945559f, 
    -0.04512034f, 0.13397872f, 0.13000923f, 0.06523339f, 0.18572797f, -0.16875213f, 0.01413697f, -0.09144320f, 
    0.09809821f, 0.23286724f, 0.19160183f, -0.07355903f, -0.05360495f, -0.16243570f, 0.00760572f, 0.01948590f, 
    -0.03459137f, -0.07757901f, -0.16310075f, -0.06904799f, -0.36475348f, 0.02182988f, 0.16961464f, 0.08882098f, 
    0.03292022f, -0.10540906f, -0.14344518f, 0.07240859f, -0.09885406f, 0.04810165f, 0.06042805f, 0.08030900f, 
    -0.42811471f, 0.27681750f, 0.76507819f, -0.04919099f, -0.08164993f, -0.13945010f, -0.04042136f, -0.09201644f, 
    0.06108154f, 0.07395569f, -0.05563279f, 0.01543569f, -0.16042162f, -0.11214001f, -0.11952922f, -0.07268205f, 
    0.02032364f, -0.00832575f, 0.07707822f, 0.01512832f, 0.12785104f, -0.17132203f, -0.06429464f, 0.00617710f, 
    0.27782816f, -0.28043413f, 0.05229125f, -0.04402884f, -0.17300273f, -0.14306124f, 0.12598176f, 0.12103371f, 
    0.01939751f, -0.01459251f, 0.04443752f, 0.02889733f, -0.08042172f, 0.27876824f, 0.17046192f, 0.04735915f, 
    0.05377764f, 0.03604184f, 0.03682977f, -0.02890080f, -0.07790634f, 0.00790939f, 0.17188078f, 0.17424880f, 
    0.21761566f, 0.27640212f, 0.35972074f, 0.17756562f, 0.11051098f, 0.09498774f, -0.12003959f, -0.00089365f, 
    0.06089484f, 0.00964448f, -0.03168602f, 0.01916673f, 0.24756362f, 0.25412312f, 0.05247809f, -0.01566649f, 
    0.03897759f, -0.15238638f, 0.13767655f, 0.04800263f, -0.04873355f, 0.08026575f, 0.00323760f, 0.01944206f, 
    0.14708047f, -0.23859772f, 0.05370568f, 0.18613258f, 0.08456367f, 0.08828724f, 0.04927749f, -0.03395047f, 
    0.19114400f, -0.03253432f, -0.18407506f, -0.04021218f, 0.19792826f, 0.23491468f, 0.21176688f, 0.16285472f, 
    0.16349688f, -0.00671314f, 0.19187626f, -0.02834060f, -0.02977057f, -0.00452313f, -0.02792368f, 0.08883672f, 
    -0.01542992f, 0.03646043f, -0.00794143f, 0.16337362f, -0.03402708f, -0.04792417f, -0.15933578f, -0.15052404f, 
    0.25338575f, 0.02168153f, -0.04045194f, 0.03419157f, -0.04727457f, 0.13996182f, -0.01589531f, 0.02262522f, 
    0.06117953f, -0.08035158f, 0.00655196f, 0.17043713f, -0.12121337f, 0.10359155f, 0.03966162f, -0.02388868f, 
    -0.01638617f, 0.18088792f, 0.03996675f, 0.18449743f, -0.08342409f, -0.03051923f, -0.01694313f, 0.03886720f, 
    -0.07545865f, 0.02636273f, 0.09452908f, 0.02307891f, -0.13778923f, 0.00163207f, -0.06739166f, -0.10508905f, 
    -0.23332584f, 0.08307056f, 0.07322809f, -0.02458818f, 0.00461219f, -0.05306068f, 0.20777287f, -0.03407560f, 
    -0.19634184f, 0.13089472f, 0.06166800f, 0.06341045f, -0.18813948f, -0.13281129f, -0.00890397f, 0.04851903f, 
    0.00641885f, 0.09447826f, 0.02585969f, 0.00963690f, -0.16580868f, 0.00282775f, -0.03993991f, 0.15907429f, 
    -0.03146974f, 0.05064795f, -0.08225221f, -0.03889165f, 0.14509311f, -0.05909057f, 0.16110033f, 0.09499039f, 
    -0.14744329f, -0.29640833f, 0.00437478f, 0.16200501f, 0.01323518f, 0.03326483f, 0.04607974f, 0.00801885f, 
    0.01775480f, 0.03076901f, 0.00886013f, 0.02524385f, 0.40969685f, 0.10114406f, 0.02964476f, -0.01437987f, 
    -0.07080740f, -0.09731841f, 0.02654049f, -0.03984747f, 0.02533560f, -0.05511796f, 0.02189741f, -0.05086623f, 
    0.33929479f, -0.00962686f, -0.30840248f, 0.18120894f, -0.02916084f, 0.05834207f, -0.04785478f, 0.07893653f, 
    -0.10869732f, 0.02264841f, -0.02030906f, -0.11495494f, 0.16756648f, 0.05845984f, -0.01757391f, -0.05003401f, 
    -0.05851145f, -0.04855665f, -0.13866065f, -0.10094003f, -0.04298098f, 0.19690417f, 0.11041395f, -0.00041670f, 
    -0.11092589f, -0.08456963f, 0.06975054f, 0.05378128f, -0.01358578f, 0.07525013f, 0.07371742f, 0.05836183f, 
    0.18785428f, 0.29526892f, 0.07568331f, -0.08962838f, 0.21101956f, 0.31300557f, 0.08240586f, -0.15954193f, 
    0.09374564f, 0.04156914f, -0.04996065f, 0.04480544f, 0.00130924f, 0.02347235f, -0.08201475f, -0.00336409f, 
    -0.18803032f, -0.11520326f, 0.07339319f, 0.10449283f, 0.03671539f, -0.10944422f, 0.04659804f, -0.04182733f, 
    -0.05011807f, -0.00383798f, -0.11227614f, -0.05178010f, -0.19511719f, 0.04912437f, 0.21302857f, 0.01617539f, 
    -0.02641676f, 0.13914379f, -0.07668121f, -0.06160534f, 0.07361809f, -0.11614321f, -0.07096240f, -0.00494480f, 
    -0.03987548f, 0.15277088f, -0.01031178f, -0.07547440f, 0.05156362f, -0.04127758f, 0.12562682f, 0.02527326f, 
    0.07343177f, 0.13914302f, 0.16483156f, 0.04108132f, -0.18105766f, -0.13231701f, 0.23544776f, 0.16647899f, 
    -0.05069800f, -0.02111375f, 0.18961646f, 0.16309273f, -0.02497566f, -0.00751257f, -0.06194753f, -0.15499130f, 
    -0.11993512f, 0.03054076f, -0.06641119f, 0.03831008f, 0.09000316f, 0.04257574f, 0.08809737f, 0.01675969f, 
    0.10593442f, 0.11715941f, -0.01117854f, -0.00061925f, 0.44118837f, 0.05626382f, 0.04109976f, 0.06269269f, 
    -0.06676633f, -0.00263986f, 0.02563073f, -0.01886189f, -0.05848933f, -0.01523481f, -0.03712383f, -0.02212234f, 
    0.16056761f, 0.09364251f, 0.16350329f, -0.06037413f, 0.00994197f, -0.09603898f, 0.01000470f, -0.12919380f, 
    0.01787869f, 0.05424089f, 0.02280478f, 0.01459416f, -0.14843373f, 0.08483688f, -0.09993325f, -0.07347864f, 
    0.02101380f, 0.00360243f, -0.12755445f, 0.08085162f, -0.12457802f, -0.12501022f, -0.10009529f, -0.02416718f, 
    -0.09454832f, 0.05114552f, 0.13476583f, 0.15070324f, -0.01883276f, -0.05872892f, -0.10374550f, 0.07709550f, 
    0.10486723f, 0.11997610f, 0.07507009f, 0.13492012f, 0.25958952f, 0.10863829f, 0.13492100f, 0.17273842f, 
    -0.10509077f, 0.04391972f, -0.09249852f, 0.08799254f, 0.07494812f, 0.06153072f, -0.12349464f, -0.08082783f, 
    -0.00129366f, -0.12294884f, -0.06242892f, 0.04513992f, 0.04617951f, 0.01345535f, -0.00590260f, 0.08563300f, 
    0.06269355f, 0.21814683f, 0.08275527f, 0.22277732f, -0.07741779f, -0.28347638f, 0.09316089f, -0.08336203f, 
    -0.14456208f, 0.12704600f, -0.16001911f, 0.08218575f, 0.07925370f, 0.03606858f, -0.12985368f, -0.05121288f, 
    -0.35209247f, -0.15623702f, 0.29187858f, 0.39461422f, -0.13765378f, 0.18155064f, 0.11924180f, -0.04893868f, 
    0.13174930f, -0.09584128f, 0.06517012f, 0.16599680f, 0.08684984f, -0.02953119f, -0.14582063f, -0.30789065f, 
    -0.11735627f, -0.21531473f, 0.05080568f, 0.09739796f, 0.11009702f, 0.14183827f, 0.13291450f, 0.15878166f, 
    0.14132309f, 0.41530520f, -0.16932675f, -0.08398104f, 0.15537474f, -0.04058326f, 0.05423306f, 0.03829907f, 
    -0.09693521f, 0.17292920f, -0.14769578f, -0.13048719f, 0.13027476f, -0.04971552f, 0.05734470f, -0.13774286f, 
    0.15590879f, -0.00963111f, -0.12073293f, -0.01696375f, 0.03139821f, -0.11412553f, -0.08605628f, -0.15181878f, 
    0.00725374f, -0.00287357f, 0.07450735f, 0.32188895f, 0.03364435f, 0.19185299f, -0.05985452f, -0.09533105f, 
    -0.05186880f, -0.10441826f, -0.05119552f, -0.00893916f, -0.26591319f, 0.11612040f, 0.16311173f, 0.15104508f, 
    0.18631461f, 0.01526076f, 0.15550385f, -0.04195001f, 0.12236756f, -0.06781843f, 0.07933398f, -0.02798598f, 
    0.42725384f, 0.22178777f, -0.14014250f, 0.57135230f, -0.18263313f, -0.04127835f, -0.04495669f, -0.12575871f, 
    0.12329888f, -0.00271000f, -0.07623078f, 0.14614204f, -0.01751897f, -0.06586578f, -0.07371800f, 0.11092392f, 
    0.04395264f, -0.00064712f, 0.00280395f, -0.17258655f, -0.06116043f, -0.03605540f, -0.10020959f, 0.00452368f, 
    -0.07031957f, -0.03008169f, -0.04933973f, -0.02895552f, -0.02461221f, 0.07187906f, 0.01973089f, 0.08436855f, 
    -0.23540737f, 0.14014226f, -0.25876701f, -0.28854248f, -0.11589751f, -0.03728097f, 0.02999781f, -0.11163005f, 
    0.04805002f, -0.00927053f, 0.16024223f, -0.04296143f, 0.23351841f, -0.03345616f, -0.05049624f, 0.01935908f, 
    -0.08656731f, -0.04969196f, 0.04499228f, 0.06331493f, -0.02351966f, -0.00756292f, 0.04112689f, 0.13619475f, 
    -0.14838716f, -0.15831386f, -0.27637073f, -0.11562839f, 0.30942917f, -0.21915124f, 0.09994136f, -0.10296934f, 
    0.02865101f, -0.02179687f, -0.05653163f, -0.17701462f, 0.01362344f, -0.14013256f, -0.19589151f, -0.24761386f, 
    -0.33526909f, 0.05293236f, -0.01800033f, 0.15741509f, -0.09175390f, -0.06811538f, -0.08229131f, 0.18488635f, 
    -0.00885724f, -0.05650537f, 0.03887654f, -0.07023589f, 0.08894791f, -0.04022620f, 0.15582341f, 0.23799402f, 
    -0.14396785f, 0.02830034f, 0.00906401f, 0.04219682f, 0.07218131f, -0.00145456f, 0.01106632f, 0.00769736f, 
    -0.17016827f, -0.27247986f, 0.15488108f, -0.00613760f, -0.05241903f, 0.01782933f, 0.06595911f, -0.02611263f, 
    0.05363447f, 0.09555440f, -0.02721662f, 0.08285934f, -0.05169412f, -0.07201409f, -0.20601559f, -0.10004238f, 
    0.07072842f, -0.11898825f, 0.04337933f, 0.12408949f, 0.04187439f, 0.02799931f, 0.09151632f, 0.00404112f, 
    -0.21793100f, -0.31822276f, 0.06127572f, 0.28704953f, 0.00745452f, 0.14055133f, 0.08464386f, 0.01926476f, 
    0.01039462f, 0.01634583f, -0.01532833f, -0.05204446f, 0.00277795f, -0.06612284f, -0.19924226f, -0.34687221f, 
    -0.00334037f, -0.12918115f, -0.08996609f, 0.00399031f, 0.05584192f, -0.02965115f, 0.16824344f, 0.02628856f, 
    0.19365773f, -0.16704717f, 0.00413188f, 0.10384288f, -0.05062876f, -0.05712588f, 0.02878175f, -0.12294240f, 
    -0.04427129f, 0.10359517f, -0.05505158f, -0.03032892f, -0.00817339f, -0.11909138f, 0.05193362f, 0.03739431f, 
    0.11529470f, 0.14753108f, 0.02728680f, -0.10515329f, 0.02259200f, -0.03731805f, 0.14160733f, 0.14832745f, 
    0.08385511f, 0.16047865f, 0.07689970f, 0.21309865f, 0.05501832f, 0.07900231f, 0.08926556f, -0.04163991f, 
    0.02495782f, -0.07355544f, -0.11091921f, 0.04815897f, -0.07105465f, 0.13025354f, 0.20463574f, 0.12051174f, 
    0.00235656f, -0.01724601f, 0.11514549f, -0.18228067f, 0.00722439f, -0.14443885f, -0.01128778f, -0.01696834f, 
    0.10797529f, 0.16240592f, -0.14398000f, 0.20808761f, 0.06384220f, 0.01399799f, 0.00460635f, 0.13739824f, 
    0.09121227f, -0.01184982f, -0.03078277f, 0.11781833f, -0.16755506f, -0.08294176f, 0.03623683f, -0.09520441f, 
    -0.00346909f, -0.02186209f, 0.14923233f, -0.13155217f, -0.04757813f, -0.02364317f, -0.01586772f, 0.08946941f, 
    0.04677754f, -0.22143258f, -0.07051476f, 0.29387218f, 0.07999815f, 0.14028792f, 0.06754053f, 0.17674766f, 
    -0.01051358f, -0.05930076f, -0.07819533f, 0.03460140f, -0.01108416f, -0.05105880f, -0.03841798f, -0.05772030f, 
    0.04190313f, 0.00588492f, 0.15545696f, 0.08635829f, 0.07173008f, -0.10697290f, 0.02277778f, 0.18185063f, 
    -0.27684960f, 0.10291946f, 0.13302694f, -0.01913691f, 0.04477119f, 0.08943821f, 0.07084058f, -0.01137176f, 
    0.05288129f, -0.05004865f, 0.03465448f, -0.06971295f, -0.10885336f, -0.13451073f, -0.09440190f, 0.03515348f, 
    -0.03183328f, -0.06206794f, 0.02700390f, -0.06970661f, 0.05772045f, 0.09738017f, 0.08739862f, 0.05253246f, 
    -0.09831968f, -0.13938114f, -0.19643098f, -0.09920315f, 0.15569350f, -0.06309737f, 0.07573546f, -0.02988981f, 
    0.04503899f, -0.05261239f, 0.25453258f, 0.09764735f, -0.09809870f, -0.04311057f, 0.07511240f, 0.03273730f, 
    0.16842206f, 0.10692676f, -0.02644162f, 0.10219439f, -0.00686120f, 0.25346434f, -0.05426281f, -0.02762960f, 
    -0.03049751f, 0.16905232f, 0.02990021f, -0.04820316f, -0.02766178f, 0.04545471f, 0.01216447f, 0.05825790f, 
    -0.04010120f, 0.14614083f, 0.00934386f, -0.16215688f, 0.06303855f, 0.08060778f, -0.20402943f, 0.07111733f, 
    0.11475534f, -0.08757947f, -0.04791775f, -0.06604836f, -0.09580463f, 0.01521497f, 0.07424639f, -0.13570359f, 
    0.28730556f, -0.46344423f, 0.04963033f, -0.01311205f, 0.25163305f, 0.04842889f, 0.05536832f, 0.02118149f, 
    0.02329549f, -0.10862599f, -0.03889224f, -0.05073871f, -0.15126592f, 0.16767363f, -0.15918338f, -0.04983127f, 
    0.02067968f, -0.02342300f, -0.06930242f, 0.08455250f, 0.05063352f, 0.11851577f, 0.16582158f, 0.19580026f, 
    -0.26029748f, 0.24902858f, -0.05751077f, -0.00702855f, 0.13065268f, 0.01993801f, 0.02693106f, -0.08342755f, 
    -0.12989314f, -0.10616554f, 0.14562266f, 0.14313187f, -0.17982154f, -0.28899306f, 0.22931571f, 0.26898187f, 
    0.08549622f, 0.05810709f, 0.11693864f, -0.27815866f, 0.07994898f, -0.06623695f, 0.21159679f, 0.09597810f, 
    0.11379680f, -0.16234329f, -0.02756747f, -0.00574288f, 0.03240138f, 0.07138447f, 0.06414294f, -0.08641756f, 
    0.01473540f, 0.06137046f, 0.13343756f, 0.16014709f, -0.08455271f, -0.17456433f, -0.01137245f, 0.17163223f, 
    0.00613302f, 0.17117934f, 0.06064421f, -0.15240303f, 0.03989510f, 0.05126440f, 0.00655077f, 0.09791146f, 
    0.09028227f, -0.05170057f, -0.12440620f, 0.06369754f, 0.14821407f, -0.06582168f, -0.03607774f, 0.13496687f, 
    0.04753296f, 0.04278537f, 0.08780602f, -0.03476860f, -0.31541139f, -0.04245002f, -0.34494251f, -0.18873022f, 
    0.06605013f, 0.13414542f, -0.12238193f, -0.08261156f, 0.10491990f, 0.08248840f, -0.10435564f, 0.15375277f, 
    0.00312676f, -0.06378461f, 0.07583162f, 0.07622017f, -0.01612699f, -0.01859820f, -0.05824279f, 0.21452461f, 
    0.07430916f, -0.05868852f, 0.07283083f, 0.07713536f, -0.16518521f, -0.09070782f, 0.13197590f, 0.11192720f, 
    0.06508253f, -0.04876187f, 0.07688870f, -0.15642174f, -0.00995992f, -0.07182231f, 0.21136707f, 0.10981647f, 
    -0.31801152f, -0.11483222f, -0.01296781f, 0.12859018f, 0.01028960f, 0.17854033f, -0.11114508f, -0.06253985f, 
    0.04829265f, -0.00409807f, -0.00810109f, 0.02961309f, -0.09627105f, -0.15522775f, -0.02420290f, 0.18283130f, 
    0.06603079f, -0.08304406f, -0.10687093f, -0.12043778f, 0.16226694f, 0.18082176f, 0.16655214f, 0.25628665f, 
    -0.02337690f, -0.03915116f, 0.06132860f, 0.00658981f, 0.02692336f, 0.03594760f, -0.04499774f, 0.05496716f, 
    -0.05275420f, -0.02779575f, 0.02987690f, -0.07240622f, -0.07411762f, -0.05352502f, 0.04065311f, 0.04850746f, 
    -0.00373134f, -0.05784866f, -0.02047633f, 0.01904036f, 0.00357654f, -0.01221105f, 0.00486153f, 0.00065749f, 
    -0.02869997f, -0.05928741f, 0.02176780f, 0.02132873f, 0.06123713f, 0.05343136f, 0.03369703f, 0.00458213f, 
    -0.05731210f, -0.05063804f, 0.00899360f, 0.01317651f, 0.00356121f, 0.04736837f, -0.06514207f, 0.02640001f, 
    -0.03776935f, -0.04301192f, 0.04825921f, 0.05580900f, -0.07476401f, 0.01367081f, 0.04624074f, 0.03768984f, 
    0.04046964f, -0.01338275f, -0.02078758f, 0.03036451f, 0.02104059f, -0.00215256f, -0.02881493f, -0.05846525f, 
    -0.01199378f, -0.01688392f, 0.01635127f, 0.01101244f, -0.02266365f, -0.05949668f, 0.02932851f, 0.06133448f, 
    0.00623939f, -0.01261383f, -0.07163294f, 0.01777703f, 0.03740446f, -0.04769585f, 0.03188162f, -0.04679738f, 
    -0.00278498f, -0.06744330f, 0.04474628f, -0.01422073f, 0.02503080f, -0.00056150f, -0.01466119f, -0.03331241f, 
    -0.07558856f, 0.04191029f, -0.02794532f, 0.01047032f, -0.01452433f, -0.00118771f, 0.01573825f, -0.00404548f, 
    -0.05979741f, 0.06197289f, 0.03875582f, 0.03569604f, -0.06832161f, -0.01396408f, -0.00118824f, -0.02427091f, 
    0.01932507f, -0.02963824f, -0.05920403f, -0.01869601f, -0.00363345f, 0.01431840f, -0.02316223f, -0.06349948f, 
    -0.05510661f, -0.06755229f, -0.03034169f, -0.03548585f, 0.06411233f, -0.07484972f, -0.02881225f, -0.05627707f, 
    -0.04947899f, 0.03140481f, -0.01830756f, 0.00352292f, -0.07271238f, -0.07365360f, -0.01656792f, 0.04680113f, 
    -0.03748950f, 0.06713324f, -0.04268335f, -0.00524580f, 0.00538705f, 0.04562129f, -0.01643237f, 0.02220330f, 
    -0.05871820f, 0.03435484f, 0.00419587f, 0.06283800f, -0.07040258f, -0.01021915f, 0.06356070f, -0.04332899f, 
    -0.03920143f, -0.06196188f, 0.02795031f, -0.06444272f, -0.02018434f, -0.05607778f, -0.01415900f, -0.05305862f, 
    -0.04622784f, 0.02634383f, -0.05871925f, -0.08030000f, -0.05850720f, 0.02152949f, -0.01868884f, -0.05762844f, 
    -0.08086292f, 0.01535581f, -0.04558447f, 0.06209739f, -0.05837929f, 0.01077404f, 0.01222124f, 0.03349012f, 
    -0.06061562f, 0.03555027f, 0.03869851f, -0.06035805f, -0.02946240f, -0.01716926f, 0.04851903f, 0.00060411f, 
    -0.02990265f, 0.06014440f, -0.03091521f, -0.03905123f, 0.05228860f, 0.06040573f, -0.02277714f, 0.04014439f, 
    0.00505109f, 0.05728951f, -0.01478295f, -0.06234841f, 0.00936920f, -0.04994917f, 0.04238090f, 0.03976880f, 
    -0.04090141f, -0.01178160f, -0.05096253f, -0.04441973f, -0.07400015f, -0.08160022f, -0.02974800f, 0.06318292f, 
    -0.03017151f, 0.14427182f, -0.19157791f, -0.21016054f, -0.20000291f, -0.00338218f, -0.08474495f, -0.06596164f, 
    0.21501856f, 0.08127556f, 0.03509080f, -0.16792665f, -0.02689156f, 0.01286317f, -0.02010119f, 0.02912718f, 
    -0.07954396f, 0.09468350f, -0.02171211f, -0.06085873f, 0.14095774f, -0.01771923f, -0.07154637f, 0.08101318f, 
    0.08333816f, -0.20529149f, 0.10630536f, -0.04702631f, 0.09404812f, -0.04219097f, -0.01003148f, 0.07472214f, 
    0.10365001f, -0.02079149f, -0.01379453f, 0.00586094f, 0.29924840f, 0.03825598f, -0.07354206f, -0.01381168f, 
    -0.00432555f, 0.03021398f, -0.01156011f, -0.07280388f, 0.02126031f, -0.03269901f, 0.08940290f, 0.00443865f, 
    -0.21517748f, -0.09185832f, -0.27012804f, 0.07759308f, 0.14255144f, -0.01217467f, 0.04526499f, 0.15505108f, 
    -0.06692572f, -0.10701656f, -0.08598383f, -0.02269206f, 0.06242204f, 0.12669212f, 0.11547250f, -0.02821939f, 
    -0.13642287f, -0.08212950f, -0.10326905f, -0.05685483f, 0.14753166f, -0.05819695f, 0.10161394f, -0.00651275f, 
    0.17448001f, -0.17516840f, 0.10762287f, 0.24335109f, -0.07677715f, -0.09013501f, -0.00194871f, -0.07176748f, 
    0.01741674f, 0.14856851f, 0.00175194f, -0.03743136f, 0.12455305f, 0.20957853f, -0.19294523f, 0.17489509f, 
    -0.08351566f, -0.05214865f, 0.08852448f, -0.10146197f, -0.06176926f, 0.12911877f, 0.08844214f, -0.05620193f, 
    -0.08666305f, 0.01599398f, -0.07292905f, -0.10606430f, 0.06397782f, 0.11481007f, -0.00131785f, 0.03112215f, 
    0.03026085f, 0.02967955f, 0.01247707f, 0.07399495f, 0.40340877f, 0.10015442f, 0.09322561f, -0.18820575f, 
    0.01404049f, 0.06230186f, 0.09191460f, 0.09008567f, -0.08795408f, -0.10494231f, -0.10658644f, 0.01827115f, 
    -0.21018268f, 0.00305405f, -0.07771333f, -0.20189458f, -0.05043504f, 0.03009320f, 0.11446874f, 0.19858991f, 
    0.04201699f, 0.02284887f, 0.07065883f, -0.11232819f, 0.13962366f, 0.08187023f, 0.07058339f, -0.17687686f, 
    0.05302642f, 0.12788749f, 0.13756658f, 0.16758041f, 0.04908601f, 0.07740393f, 0.13496570f, -0.04608756f, 
    -0.02669613f, -0.27371392f, 0.08110464f, 0.18636100f, 0.07645036f, 0.16675535f, -0.00563673f, -0.00552011f, 
    0.01275518f, 0.03691830f, 0.16559656f, 0.01365906f, 0.46578813f, -0.17796925f, 0.08490569f, 0.00326753f, 
    -0.00314955f, -0.02853730f, 0.03310905f, -0.02275547f, 0.00172224f, 0.10796019f, 0.09149256f, -0.09912270f, 
    0.19061819f, 0.05858346f, 0.11063542f, 0.00631037f, -0.10854934f, 0.02426374f, 0.01175715f, -0.13699588f, 
    -0.06562713f, -0.03937433f, 0.00266836f, 0.01218385f, -0.10078345f, 0.01443759f, 0.02807667f, 0.07458199f, 
    -0.23256998f, -0.01857194f, -0.01220652f, 0.12465601f, 0.02391546f, 0.12866944f, 0.10325021f, 0.18074968f, 
    0.02436691f, 0.04044022f, 0.07295811f, 0.01432405f, 0.00626502f, -0.09360039f, 0.01998489f, 0.03492638f, 
    -0.00276348f, 0.04914466f, 0.02356538f, -0.08201060f, 0.01528405f, -0.08245555f, 0.02151440f, -0.01432748f, 
    -0.08303595f, -0.09025048f, -0.10169099f, -0.00823644f, -0.06340937f, 0.01499532f, -0.07946231f, -0.11910038f, 
    0.00128249f, 0.01769778f, -0.11439431f, -0.03563724f, 0.00532530f, -0.07984291f, -0.00068129f, -0.12272134f, 
    0.03032713f, -0.06723818f, -0.01863721f, -0.08247976f, 0.01305300f, -0.03376591f, -0.01838004f, -0.01291607f, 
    0.01907154f, -0.03004087f, 0.05074408f, -0.07914429f, -0.07040206f, 0.05038524f, -0.07350880f, -0.02031537f, 
    -0.05875878f, -0.05681552f, -0.00293136f, -0.07284232f, -0.06366838f, 0.01301648f, -0.03016851f, -0.04099860f, 
    0.01838730f, -0.01313093f, 0.05662664f, -0.09354226f, -0.02161675f, -0.06699355f, 0.00885198f, 0.02503327f, 
    0.06216941f, 0.03912484f, 0.04255396f, -0.05953737f, -0.06370466f, -0.07700807f, 0.04850629f, 0.04882564f, 
    0.00329970f, 0.05210389f, -0.01974408f, -0.03487179f, 0.02876243f, 0.00412015f, -0.01089980f, 0.02237182f, 
    -0.07352957f, 0.00795837f, 0.00717761f, -0.02770670f, 0.02440738f, -0.06524123f, -0.07512117f, -0.02273278f, 
    -0.06119086f, -0.01656902f, 0.00218070f, -0.08021098f, -0.03964023f, 0.04288002f, -0.08913799f, 0.01538739f, 
    -0.07487907f, 0.03267882f, -0.09562457f, 0.02919425f, -0.00283329f, 0.01222201f, -0.07325362f, -0.06398599f, 
    -0.00855531f, -0.03729863f, -0.00914750f, -0.03402312f, 0.02186156f, -0.09543110f, -0.00989776f, -0.04644438f, 
    0.03842302f, -0.02621167f, -0.08571656f, -0.07587188f, 0.06227782f, 0.04519350f, -0.09556627f, -0.05939347f, 
    -0.01055284f, 0.03965727f, -0.00386203f, -0.06625298f, 0.01515593f, -0.06795227f, -0.05947244f, 0.00351929f, 
    -0.02661673f, 0.01429323f, -0.06494844f, -0.02881606f, -0.08147065f, -0.02005738f, -0.07574283f, -0.07281537f, 
    -0.11106267f, -0.04174777f, -0.04223211f, -0.00001035f, -0.02152892f, 0.00511048f, 0.02104507f, -0.00903172f, 
    -0.06362736f, -0.05687884f, -0.01614793f, -0.01854219f, -0.06213301f, -0.02938944f, 0.01044322f, -0.05155474f, 
    -0.05783258f, 0.01752925f, 0.03105530f, -0.05097901f, -0.03786742f, 0.00155467f, -0.08724678f, 0.04759403f, 
    0.01200438f, -0.01866612f, 0.04086657f, -0.08449091f, -0.05557955f, -0.00805448f, 0.00999091f, -0.10934452f, 
    -0.03128136f, -0.08089391f, -0.02521548f, -0.03746219f, -0.02301930f, -0.04783043f, 0.01766303f, -0.04431721f, 
    -0.02599193f, -0.04724460f, -0.01714505f, -0.01313196f, -0.01298136f, -0.05478658f, -0.00075514f, -0.04838501f, 
    0.02842873f, -0.04658629f, -0.06148277f, -0.01658680f, -0.05080092f, 0.01046362f, 0.03599279f, -0.06700533f, 
    -0.07477355f, -0.15853035f, 0.12425083f, -0.09420431f, -0.13357137f, -0.08949832f, 0.06341780f, 0.05226982f, 
    0.13141622f, -0.07318331f, 0.21145812f, 0.07957467f, -0.00909493f, -0.10018647f, -0.03621458f, 0.25169936f, 
    -0.01319483f, -0.04038912f, 0.03948895f, 0.08192611f, 0.12669627f, 0.21050091f, 0.07578336f, 0.11081549f, 
    -0.25318497f, -0.15078498f, 0.31576717f, -0.01827620f, -0.03101609f, 0.04573485f, 0.01792155f, 0.16856645f, 
    -0.02948818f, -0.01327956f, 0.14196786f, 0.10936919f, 0.08669448f, -0.15020423f, -0.28845996f, 0.13152520f, 
    0.13215363f, -0.00313667f, -0.00821514f, 0.05094256f, 0.09757107f, 0.01600552f, 0.07194938f, -0.06646675f, 
    -0.07159951f, -0.47091565f, -0.01271941f, 0.17314047f, 0.21770573f, 0.11096050f, 0.21075793f, 0.16891901f, 
    -0.01084800f, -0.15638731f, -0.07333270f, 0.00551687f, 0.22498782f, 0.04475136f, -0.25576681f, 0.07856596f, 
    -0.10959759f, -0.02111958f, -0.01072000f, 0.05172957f, 0.04137601f, 0.08940260f, 0.18407443f, 0.10948300f, 
    -0.12778741f, 0.16323809f, -0.16472363f, -0.04960332f, 0.20154290f, -0.00942152f, 0.02724857f, 0.00808864f, 
    -0.00496841f, 0.15951364f, -0.03357030f, 0.10952066f, 0.05146818f, -0.22608830f, -0.20875359f, 0.26274520f, 
    0.15380023f, -0.00504024f, 0.05993718f, -0.08216187f, 0.04530822f, -0.04103177f, 0.04533056f, -0.00756717f, 
    0.02804253f, -0.06899326f, -0.08555923f, 0.11605357f, 0.10746731f, 0.01070596f, 0.00853395f, -0.05726831f, 
    0.00639637f, -0.08446819f, 0.09970856f, 0.13540925f, -0.01382814f, 0.25258011f, 0.09250797f, -0.24977019f, 
    0.02802161f, 0.06825467f, 0.12865177f, -0.30345750f, 0.08527059f, 0.00263884f, 0.02133162f, -0.02930719f, 
    -0.18069425f, 0.21388401f, -0.34073415f, -0.13979992f, 0.07494925f, -0.01936778f, 0.03558582f, 0.00907714f, 
    0.15292284f, 0.12163574f, -0.01278704f, 0.07090510f, -0.24265419f, -0.01384149f, 0.02095069f, -0.14926483f, 
    0.12283712f, 0.10326134f, -0.06387927f, -0.12167147f, 0.11645524f, -0.10496638f, -0.13945410f, -0.09654068f, 
    0.20336659f, -0.19769970f, -0.11883914f, 0.19458909f, 0.09553380f, 0.20771039f, 0.10335831f, 0.15272972f, 
    0.14209864f, -0.13276722f, -0.02768433f, 0.08408735f, 0.15282616f, -0.12177444f, -0.04026466f, 0.02342962f, 
    0.00618501f, -0.10336762f, 0.01851975f, 0.07533363f, 0.15419169f, 0.04397273f, 0.05757412f, 0.13023680f, 
    0.12436684f, -0.22440703f, -0.19701704f, -0.03972586f, 0.01291148f, 0.24748860f, 0.07343373f, 0.04557605f, 
    -0.07334062f, -0.11413860f, 0.07166346f, -0.15476562f, -0.20955978f, -0.26132345f, -0.10565688f, 0.09855183f, 
    -0.09918884f, -0.02399621f, -0.20739742f, -0.15702529f, 0.15187554f, 0.08220760f, 0.08417694f, -0.08001389f, 
    0.24002425f, -0.13659553f, -0.33219191f, -0.21345153f, 0.14369917f, 0.10107200f, 0.14373617f, 0.07634191f, 
    0.08796824f, -0.05532938f, -0.05279130f, 0.13593210f, 0.14467211f, -0.11559262f, -0.23482525f, -0.24536291f, 
    0.04794177f, 0.12021579f, 0.11848623f, -0.05339304f, 0.07727751f, 0.03772020f, 0.05622396f, 0.05097402f, 
    0.33448741f, 0.32382405f, -0.11139841f, -0.11833823f, 0.17618704f, 0.10461125f, 0.16742234f, -0.01153003f, 
    0.04599738f, 0.07476622f, -0.03975052f, 0.02776282f, -0.15032332f, 0.23797843f, 0.47499439f, -0.04640030f, 
    -0.14723836f, -0.14290044f, -0.11601444f, -0.00158443f, -0.11746339f, -0.05620977f, -0.04955994f, 0.01008379f, 
    0.25657177f, 0.15818828f, 0.28720349f, -0.25322938f, 0.04644559f, -0.02765911f, -0.07298862f, -0.16830614f, 
    -0.12579796f, -0.07661165f, -0.05941606f, -0.12833625f, -0.04071151f, 0.08104914f, 0.02711221f, -0.01514495f, 
    -0.13356723f, 0.02539354f, -0.04106901f, -0.12543452f, -0.01918245f, 0.01767594f, -0.13232493f, 0.10837319f, 
    0.19973223f, 0.37357619f, -0.28496358f, -0.23363185f, -0.18356222f, -0.11834045f, 0.17345923f, -0.04841056f, 
    0.18171723f, -0.04184977f, 0.24523886f, 0.19417413f, -0.03432827f, 0.19916421f, 0.35832420f, -0.14467473f, 
    -0.12589930f, -0.18041921f, 0.03795049f, 0.06366313f, -0.01652528f, 0.18738568f, -0.05141243f, 0.03199668f, 
    0.02787806f, -0.09333926f, 0.19139841f, -0.06093910f, 0.06172332f, 0.07725476f, 0.04634744f, 0.03953351f, 
    0.00369580f, 0.01960226f, 0.03582185f, -0.05839801f, -0.06370331f, -0.05532492f, -0.13532132f, 0.23472545f, 
    0.02739548f, 0.00329746f, -0.01615995f, -0.02434079f, -0.08926836f, 0.16575031f, 0.04697837f, 0.02622961f, 
    0.04331702f, -0.14836401f, 0.20809934f, 0.30889148f, 0.01174413f, 0.16202071f, 0.02064163f, 0.13082084f, 
    0.00735469f, 0.04953671f, 0.05449001f, 0.01615502f, 0.09800839f, -0.08557023f, -0.10660623f, 0.01210997f, 
    0.23254983f, 0.02193834f, 0.09405009f, -0.04846620f, -0.12528455f, 0.00630461f, -0.03682471f, 0.05163651f, 
    0.04179230f, 0.15522994f, -0.00449603f, -0.27740556f, -0.05014610f, -0.09750203f, -0.08783546f, -0.02692360f, 
    0.20478435f, 0.15048601f, 0.14829986f, 0.06184421f, -0.13214858f, 0.13076340f, 0.28917432f, 0.11957940f, 
    -0.04578993f, 0.02910186f, -0.13219318f, -0.13686100f, -0.08959451f, 0.01042204f, 0.00524320f, 0.00307230f, 
    -0.22849926f, 0.13502610f, 0.14003545f, 0.15690529f, -0.18182023f, -0.04206620f, -0.05697884f, -0.15492803f, 
    -0.09075933f, 0.08248041f, -0.04571375f, 0.04577469f, -0.01939300f, -0.00709076f, 0.09231897f, -0.03984916f, 
    0.07835075f, 0.02763649f, -0.01101129f, 0.02685529f, 0.05854348f, 0.17583653f, 0.18815213f, 0.28424847f, 
    0.11305557f, -0.02416942f, -0.17240886f, -0.03826430f, 0.00074618f, -0.17118309f, 0.02134798f, 0.23356609f, 
    -0.05183846f, 0.18144843f, 0.07720124f, 0.08242197f, -0.09492650f, -0.14665872f, -0.08615838f, -0.06689247f, 
    0.03200231f, -0.07153869f, -0.10458262f, -0.12242650f, -0.10188115f, 0.26589131f, 0.15909792f, 0.00601767f, 
    0.05946035f, 0.12504542f, -0.26256448f, 0.01747795f, 0.07921004f, 0.07993738f, -0.05219985f, 0.19568647f, 
    -0.11333401f, -0.00267723f, 0.13345042f, 0.10966053f, 0.28091899f, 0.08155844f, 0.13366078f, -0.08919251f, 
    -0.20793231f, 0.00770240f, -0.03780572f, -0.16665903f, -0.00843671f, 0.05346942f, 0.06651718f, -0.03849037f, 
    0.40400037f, -0.12994525f, -0.25609794f, 0.02400829f, -0.24357828f, 0.16209105f, -0.08369436f, 0.14517315f, 
    -0.01902525f, -0.04519053f, 0.12353867f, 0.00322856f, -0.05346573f, 0.21241511f, 0.04564315f, -0.01878100f, 
    -0.02162257f, -0.03339659f, -0.00099464f, -0.02067813f, 0.03440940f, 0.32445788f, 0.14643142f, 0.22389711f, 
    -0.11758082f, 0.59361845f, 0.18716808f, -0.13370840f, 0.14883105f, 0.09636192f, -0.03571702f, 0.00658539f, 
    -0.03904200f, 0.16585368f, -0.01139058f, 0.04728173f, 0.04232785f, 0.05412906f, 0.47546417f, -0.09438805f, 
    0.09628960f, 0.06937482f, 0.15328917f, -0.07802328f, 0.04253275f, 0.14350517f, 0.05337143f, -0.05994258f, 
    -0.12096732f, -0.31236851f, -0.01536185f, -0.16449361f, -0.07825337f, -0.13465811f, 0.09544725f, 0.02695885f, 
    -0.06124837f, 0.00910114f, 0.02872491f, 0.02677434f, -0.39314494f, -0.24292456f, 0.04367365f, 0.18882692f, 
    0.00760241f, 0.06539721f, 0.01709689f, 0.07081690f, 0.01960772f, 0.00901079f, -0.00823336f, 0.02113836f, 
    0.14620887f, -0.02278776f, 0.10908215f, 0.20962113f, -0.13277999f, 0.06801808f, 0.23749229f, 0.07590020f, 
    0.05597787f, 0.03077531f, 0.10100351f, 0.17207712f, -0.18001963f, -0.20654628f, -0.18779090f, -0.09325475f, 
    -0.08637222f, -0.06409998f, -0.16595984f, 0.13590588f, -0.16636775f, 0.11036517f, -0.03173408f, -0.10074773f, 
    -0.06739493f, 0.27251434f, 0.08154362f, -0.02523116f, 0.08766365f, -0.00278151f, -0.03820481f, 0.19988279f, 
    -0.10680933f, 0.06987873f, 0.11514607f, -0.10764974f, 0.01680017f, 0.09302693f, 0.02233656f, 0.24338120f, 
    0.00157036f, -0.02501691f, -0.04128500f, -0.17298616f, 0.10705968f, -0.00163479f, 0.15471525f, 0.21302289f, 
    -0.07603751f, 0.03410529f, 0.02046296f, -0.14234096f, -0.06489021f, -0.05900197f, 0.04752328f, -0.07283500f, 
    -0.06551185f, -0.01339029f, -0.04921424f, 0.05549577f, -0.01390349f, 0.06949668f, 0.09364308f, 0.03555507f, 
    0.18394390f, 0.03429358f, 0.04193681f, -0.01761114f, -0.15437832f, 0.01298588f, 0.08730677f, -0.06676273f, 
    0.06524091f, 0.13472502f, 0.02013380f, 0.18747026f, 0.04287529f, 0.03518761f, -0.01922562f, -0.17517160f, 
    0.07112376f, 0.03494748f, 0.01450839f, 0.07333277f, 0.19208644f, 0.02674447f, 0.10602908f, 0.03784037f, 
    -0.08381066f, -0.11938354f, 0.01728038f, -0.15374619f, -0.03392190f, -0.12119829f, 0.24923494f, 0.02623722f, 
    0.14181027f, -0.12540491f, 0.03315699f, 0.09274102f, -0.08612663f, -0.13348152f, 0.04730085f, 0.03204584f, 
    -0.01174424f, 0.05127633f, -0.00735952f, -0.02639072f, -0.37145704f, -0.42720717f, -0.08958952f, 0.15884925f, 
    0.20558526f, 0.03394271f, 0.09215923f, -0.07936972f, 0.07485487f, -0.10519437f, 0.06539763f, -0.00996695f, 
    0.11481988f, 0.36030206f, -0.06723418f, 0.09745518f, 0.07372454f, 0.16923656f, -0.02671252f, -0.02535520f, 
    0.00054040f, 0.11762688f, -0.01676922f, 0.05754954f, -0.39413387f, -0.43841481f, 0.02306379f, -0.23274989f, 
    -0.08257481f, 0.03613068f, 0.01692613f, -0.13046876f, 0.15358493f, 0.11346482f, 0.16324697f, 0.06611089f, 
    0.11257611f, -0.54998893f, 0.06749984f, -0.00751547f, 0.01837534f, -0.02735294f, 0.10777475f, -0.06793477f, 
    0.01832354f, 0.25825453f, -0.11918776f, -0.16447866f, -0.01182627f, -0.09151082f, -0.28708899f, -0.21376745f, 
    -0.11147220f, -0.06222253f, 0.03351013f, 0.21502982f, -0.09321209f, 0.02256491f, -0.02129958f, -0.03973634f, 
    -0.03513248f, 0.21844386f, 0.06776470f, 0.02435639f, 0.16048290f, 0.00078730f, -0.01433192f, 0.11227295f, 
    0.02523709f, 0.04453279f, -0.10621838f, 0.00968631f, 0.15278171f, 0.15895301f, 0.09672571f, -0.08905307f, 
    0.00239160f, 0.01480250f, -0.10421766f, 0.11824124f, -0.01725522f, -0.02628524f, 0.19164880f, 0.08362362f, 
    -0.10423169f, 0.06980547f, 0.23419292f, -0.00370490f, -0.05708915f, -0.00056759f, -0.05350073f, 0.03954279f, 
    -0.05826486f, 0.02795478f, 0.26903549f, 0.02264502f, 0.25302690f, 0.08234755f, 0.11460685f, 0.11251985f, 
    -0.10027129f, -0.00510850f, 0.29991046f, 0.08755983f, 0.04445548f, -0.14762621f, 0.01907767f, -0.08726378f, 
    -0.29967326f, -0.11510736f, -0.06692683f, -0.23268381f, 0.03490222f, -0.08654179f, 0.15318426f, -0.14193986f, 
    -0.01867254f, -0.08793218f, -0.15177935f, -0.14213881f, 0.07702626f, -0.27582622f, -0.22370799f, -0.25271580f, 
    -0.10721850f, 0.14550993f, 0.04904698f, -0.12504461f, -0.11747725f, -0.03400825f, -0.25718185f, -0.07601175f, 
    0.09309384f, -0.05134483f, -0.22577906f, -0.39164010f, -0.04050140f, -0.08843962f, 0.09456535f, -0.06059621f, 
    0.00930138f, -0.03545025f, -0.07236470f, -0.06964010f, -0.11005282f, 0.34163138f, 0.00583037f, -0.09363087f, 
    0.14676164f, 0.04186602f, 0.25517464f, -0.00135856f, -0.23900573f, -0.11566499f, -0.13733582f, -0.08510184f, 
    -0.14549257f, 0.17558704f, -0.23082055f, -0.03752428f, 0.11153627f, 0.17565161f, 0.02794379f, 0.04968198f, 
    0.12857091f, 0.08002590f, 0.03862908f, -0.16780184f, -0.01417305f, 0.20889606f, 0.02334175f, -0.05407507f, 
    0.06471764f, 0.18392581f, 0.05431700f, 0.02487042f, 0.07345857f, 0.10028352f, -0.05433403f, 0.05252026f, 
    0.19832963f, 0.23786396f, -0.14098944f, -0.04892242f, 0.12603751f, 0.12699921f, -0.07401171f, 0.05746406f, 
    0.03991441f, 0.08721914f, -0.04100782f, -0.04437155f, 0.16018529f, -0.00488990f, 0.06408070f, -0.24847014f, 
    -0.06947460f, -0.03917350f, -0.16411683f, -0.09475834f, 0.01389366f, 0.13058645f, 0.00160441f, 0.01759039f, 
    -0.37855205f, -0.22740406f, -0.11260287f, -0.18103097f, -0.08664739f, -0.00603631f, -0.02846000f, 0.12962867f, 
    -0.09736488f, -0.05777070f, -0.08019886f, -0.10881966f, 0.01030181f, 0.04006404f, 0.12714843f, -0.09326549f, 
    -0.11709258f, -0.09932240f, -0.09197874f, -0.01844588f, -0.18662272f, 0.02103862f, -0.03783013f, 0.04082397f, 
    0.15326676f, 0.09832434f, -0.10898688f, 0.04248607f, -0.07949167f, -0.11293176f, 0.05574479f, -0.09065200f, 
    0.08577336f, 0.02180663f, 0.08758304f, 0.11828610f, -0.02778898f, 0.20629746f, 0.14135286f, -0.10945878f, 
    -0.00027576f, -0.10193878f, -0.06806214f, -0.00281837f, 0.00100786f, 0.14450487f, 0.15521911f, 0.06095125f, 
    -0.05390859f, -0.30957291f, -0.12273045f, -0.33145726f, -0.05934834f, 0.12076675f, -0.00932897f, -0.05738723f, 
    0.07163129f, 0.03410418f, 0.06609629f, 0.17867003f, -0.18533427f, -0.28752246f, 0.00568871f, 0.10851314f, 
    0.10991376f, 0.01011079f, 0.01501539f, -0.14420760f, -0.08538893f, 0.04347911f, -0.00926727f, 0.06162656f, 
    0.55277705f, -0.02527198f, -0.03232712f, 0.34762156f, 0.06449687f, 0.10132430f, -0.01089721f, 0.18881966f, 
    0.02413752f, -0.00108311f, -0.02997084f, 0.03745138f, -0.00829952f, -0.07221314f, 0.07768728f, 0.07077190f, 
    0.20343029f, 0.07291339f, 0.04669775f, 0.00565791f, -0.07298568f, 0.21373782f, 0.01874183f, 0.16466491f, 
    -0.12751304f, 0.09830397f, 0.11834896f, 0.12808694f, -0.10560746f, -0.00003586f, -0.16680345f, -0.05242639f, 
    0.06181153f, 0.13572101f, 0.12543915f, 0.07212787f, 0.20815358f, 0.02748661f, 0.10149703f, 0.07802344f, 
    -0.02091499f, -0.13003001f, -0.02799363f, -0.04209845f, 0.03484403f, -0.00758649f, 0.23892999f, 0.03213163f, 
    -0.26163447f, -0.03409088f, 0.22000131f, 0.02102667f, -0.15655178f, 0.00424492f, -0.10416574f, -0.12783220f, 
    -0.06245123f, 0.03243896f, 0.03726957f, 0.02064743f, -0.10684701f, -0.04051595f, 0.01674535f, -0.02143836f, 
    -0.17750391f, -0.11963087f, -0.02452859f, 0.17441978f, 0.07250123f, 0.21154286f, 0.17389154f, 0.16933964f, 
    -0.01732811f, 0.32311723f, 0.42928252f, 0.27193555f, -0.07775111f, -0.00095715f, -0.01230863f, 0.02800195f, 
    -0.10169237f, 0.10915391f, 0.05680021f, 0.02480016f, -0.17866816f, 0.22643921f, 0.24987069f, 0.05611475f, 
    -0.05830000f, -0.14959885f, -0.03915108f, 0.10517069f, -0.06849630f, 0.10423361f, 0.17595536f, 0.03883953f, 
    -0.17813951f, -0.14016901f, -0.09117800f, 0.26408663f, 0.00323509f, -0.03837818f, 0.07347907f, 0.02029909f, 
    0.02782371f, 0.01754688f, 0.25685710f, 0.15554418f, 0.11806978f, -0.13051061f, -0.27689311f, -0.06715667f, 
    0.00868113f, 0.06249019f, 0.14723100f, -0.00121118f, -0.01828576f, 0.03226659f, -0.00626535f, -0.05852467f, 
    0.18911156f, 0.12853365f, -0.25078416f, 0.20718113f, 0.04420105f, 0.16179565f, -0.03600285f, 0.09953058f, 
    -0.02663026f, -0.07113433f, 0.01976534f, 0.10514152f, -0.00703315f, -0.15366894f, -0.13293083f, -0.04312877f, 
    0.00347642f, 0.01684401f, 0.05759785f, 0.06441820f, 0.06498611f, 0.33677775f, 0.11131140f, 0.11659015f, 
    -0.19751294f, -0.22021598f, 0.23702927f, 0.17233133f, 0.17212163f, 0.20139921f, -0.04535651f, 0.02198059f, 
    -0.03060062f, 0.11214458f, -0.12789540f, 0.06046765f, 0.06139203f, -0.15667880f, -0.01140628f, -0.02838430f, 
    0.01658814f, 0.02605799f, 0.04839790f, 0.10246038f, 0.07000402f, -0.06807528f, -0.03252297f, -0.09713292f, 
    0.03076342f, -0.11593137f, -0.12664172f, -0.07517955f, 0.05171990f, 0.02382120f, 0.10061401f, -0.06555222f, 
    -0.13803194f, -0.10967600f, -0.04865079f, -0.18028690f, -0.05111691f, -0.10344402f, -0.12478522f, -0.08489642f, 
    0.07112040f, 0.04790927f, -0.01085455f, 0.04751110f, 0.00659484f, 0.02545497f, -0.04282235f, -0.03129508f, 
    0.41390160f, 0.15266562f, 0.19780979f, -0.25472885f, -0.11119609f, -0.19898893f, -0.05371521f, 0.00806578f, 
    -0.05903626f, 0.02577919f, 0.17782350f, 0.11027803f, 0.15711498f, 0.06662888f, -0.00126153f, 0.11088241f, 
    -0.13601440f, -0.08832275f, -0.01370941f, 0.03215758f, -0.12622721f, -0.09601997f, -0.03797256f, -0.20649885f, 
    -0.11148324f, 0.04047678f, 0.00636811f, 0.09450879f, 0.21550331f, 0.03281414f, 0.17793162f, 0.07866524f, 
    -0.01845259f, -0.04518401f, -0.11763928f, -0.10367626f, 0.07921888f, 0.06133577f, -0.28475398f, 0.08684539f, 
    -0.00835887f, 0.12825136f, 0.10804655f, 0.03907189f, 0.00276553f, -0.01534507f, 0.02679413f, 0.11700395f, 
    0.24785194f, -0.13031158f, -0.07666685f, -0.04075246f, 0.09212346f, 0.00175684f, 0.11830299f, 0.05974563f, 
    -0.04633264f, -0.00876590f, -0.01993279f, -0.00475809f, -0.11642147f, 0.08944894f, -0.01433954f, 0.04057927f, 
    0.20371875f, 0.06522615f, 0.10478336f, -0.08639387f, -0.02162609f, -0.00074522f, -0.11722501f, -0.14996496f, 
    0.20162483f, 0.02674426f, 0.36798099f, 0.30488214f, -0.09504402f, 0.10098048f, 0.09155804f, -0.01138149f, 
    0.06491157f, -0.10355214f, -0.02358315f, 0.08833982f, -0.15242901f, 0.12474568f, -0.11785354f, -0.02847088f, 
    0.00293048f, -0.09710179f, 0.07709572f, 0.05132516f, 0.06363979f, 0.12704256f, 0.14977351f, 0.19204086f, 
    0.24378152f, -0.10195327f, 0.05492809f, -0.00724946f, -0.00478249f, -0.06752805f, 0.09412146f, 0.13290389f, 
    0.09847612f, 0.02427851f, 0.20824765f, 0.01249697f, 0.21116330f, 0.27651468f, 0.05030586f, 0.00767673f, 
    0.00812696f, 0.13917308f, 0.08627834f, -0.13046257f, 0.21680810f, -0.19585022f, 0.01862554f, 0.00318948f, 
    0.40409791f, 0.11099522f, -0.38366103f, 0.09158828f, 0.10469382f, 0.01702205f, -0.03169068f, 0.03121620f, 
    -0.13162337f, -0.08304065f, -0.08793381f, -0.10421244f, -0.09579848f, -0.10338962f, 0.18426390f, -0.04619225f, 
    -0.11318646f, 0.01471668f, -0.00211183f, -0.16890199f, 0.13776994f, 0.21401346f, 0.08182591f, 0.12338126f, 
    0.08747219f, -0.14411403f, -0.17155851f, -0.01260796f, -0.03001625f, -0.14539339f, 0.07530650f, -0.05797795f, 
    0.21113795f, 0.24654384f, -0.11298823f, 0.01409211f, -0.07201215f, 0.20860639f, -0.28514007f, 0.00213830f, 
    0.15044872f, -0.14763436f, 0.04456909f, -0.02159075f, 0.02928057f, 0.15751980f, 0.01307190f, 0.12318986f, 
    -0.23448311f, -0.01419552f, -0.21843703f, -0.30197781f, 0.14454341f, -0.20833436f, 0.07482608f, 0.08780995f, 
    -0.05625280f, -0.05496276f, -0.05682809f, -0.02225117f, 0.17776357f, 0.01633881f, -0.05052099f, -0.36530182f, 
    -0.01170180f, 0.14137682f, -0.03312305f, -0.13656484f, -0.04701771f, 0.02653191f, -0.04322045f, 0.06106170f, 
    -0.33447316f, 0.38681775f, 0.04230598f, -0.08945186f, 0.07558972f, -0.03591875f, 0.11861474f, 0.00442793f, 
    0.10335012f, 0.19311322f, 0.04466015f, -0.00323267f, 0.12003641f, -0.15429468f, 0.11913863f, -0.03077046f, 
    -0.03358697f, 0.06026454f, 0.01334750f, 0.10574262f, -0.13613410f, -0.24378964f, -0.10751782f, -0.11914897f, 
    0.06781414f, -0.06205515f, -0.08358558f, 0.00191291f, 0.07313499f, 0.01355804f, 0.05616874f, 0.12762387f, 
    0.19453809f, -0.11551892f, 0.22224601f, -0.11547150f, 0.50007975f, -0.24375029f, 0.23495200f, 0.08548335f, 
    -0.03161614f, 0.10925021f, -0.04914657f, -0.12338995f, -0.00326869f, -0.03800416f, 0.00907736f, 0.15503874f, 
    -0.08419299f, -0.07740501f, 0.17422765f, -0.03334129f, 0.00860550f, -0.05788251f, 0.07513335f, -0.15383810f, 
    0.02683319f, -0.05127613f, -0.13570549f, 0.07586309f, -0.15744966f, 0.11376370f, -0.05519275f, 0.13983618f, 
    -0.02744736f, -0.04271822f, -0.19459845f, 0.02318429f, -0.17326449f, -0.08803902f, -0.00415787f, -0.04747787f, 
    -0.07452932f, 0.02198333f, 0.02180908f, -0.06665470f, -0.07280221f, 0.06257450f, 0.01796278f, -0.02069057f, 
    -0.07674538f, -0.00471147f, 0.06161128f, -0.05843581f, -0.01585801f, 0.05607779f, 0.04508818f, -0.03247000f, 
    0.03913383f, 0.02455905f, 0.05020951f, -0.04067525f, 0.00691985f, 0.00460461f, 0.00853610f, 0.02428862f, 
    -0.04731282f, -0.04209312f, 0.04565065f, -0.06373581f, 0.05757886f, -0.07210793f, -0.00149760f, 0.00274359f, 
    -0.00599615f, -0.06007915f, -0.04821819f, -0.01285269f, 0.03043902f, -0.01118164f, -0.04878065f, -0.05487684f, 
    0.05408891f, -0.07593738f, 0.02649103f, -0.05776832f, 0.05486554f, -0.02874985f, -0.06435297f, -0.05255756f, 
    0.04663035f, 0.01174778f, 0.04223797f, -0.00895116f, -0.05850744f, -0.05433132f, -0.01937935f, 0.04330210f, 
    -0.07192790f, 0.05902917f, -0.01591834f, 0.03788836f, 0.03502941f, 0.01747262f, -0.05403768f, -0.04370023f, 
    0.00347280f, -0.06427474f, -0.03423899f, 0.02970191f, 0.06445052f, -0.03290675f, -0.02684111f, -0.02865939f, 
    0.01705022f, 0.01622150f, 0.05262779f, 0.04032660f, 0.00360620f, -0.03869820f, 0.00834074f, -0.02994233f, 
    -0.04286694f, -0.05563832f, 0.00451460f, 0.00011202f, 0.04402924f, -0.01586135f, -0.05845552f, 0.05112946f, 
    -0.00194882f, -0.01006528f, -0.01350738f, 0.03772773f, -0.01335731f, -0.03739976f, 0.00364663f, -0.04887353f, 
    -0.06421778f, 0.04066159f, -0.04190313f, 0.05561054f, -0.05436690f, -0.01262948f, -0.06453287f, 0.03855836f, 
    -0.02115120f, -0.00108905f, -0.01089981f, 0.00875407f, -0.05691209f, -0.00612172f, -0.01656494f, -0.04648179f, 
    0.01983114f, 0.03707847f, 0.05951066f, 0.04828166f, -0.02082428f, -0.00094389f, 0.05447752f, 0.00867093f, 
    0.05613528f, -0.02695278f, 0.03975965f, 0.04930464f, -0.06572676f, -0.06878865f, 0.00925715f, -0.02923553f, 
    -0.07442459f, -0.07701472f, -0.05508216f, -0.04566517f, 0.01120692f, -0.02942235f, 0.01936678f, 0.01246612f, 
    -0.06254647f, -0.03214346f, 0.05553402f, 0.04740218f, 0.04901380f, -0.01754491f, -0.06646730f, -0.06359999f, 
    -0.07471394f, -0.07232632f, -0.00594648f, -0.06614609f, -0.05693127f, -0.07307110f, -0.01179268f, 0.03889634f, 
    0.04147872f, -0.01031149f, -0.06173547f, 0.06496221f, 0.04379239f, -0.02345599f, 0.04846650f, 0.06700381f, 
    -0.05885144f, 0.03918509f, -0.06956054f, -0.04485166f, -0.00382840f, -0.05110911f, -0.05385112f, -0.01485056f, 
    -0.05239388f, 0.03156808f, 0.01414025f, 0.03171489f, 0.02492706f, 0.00746840f, 0.06214668f, -0.06339093f, 
    0.05466421f, -0.06889672f, -0.04470758f, -0.03172777f, 0.03689520f, 0.03547793f, 0.03225556f, -0.00587467f, 
    -0.05809471f, 0.06559900f, 0.01823272f, 0.03828245f, 0.02169977f, 0.01717099f, -0.06653842f, -0.06476192f, 
    -0.15060003f, -0.24004978f, -0.34675190f, -0.25919530f, -0.02908193f, -0.15047650f, -0.12926799f, -0.00447983f, 
    0.09270312f, -0.06240864f, 0.06243353f, -0.06478085f, -0.03429078f, -0.16156650f, -0.03700582f, 0.12340999f, 
    0.05351433f, -0.13547952f, -0.11278009f, 0.07067233f, 0.01207351f, 0.23110080f, -0.05453245f, -0.01520234f, 
    -0.18544585f, 0.03313956f, 0.14436159f, 0.14219275f, -0.09625190f, 0.08388388f, 0.03669918f, -0.00148799f, 
    -0.13428247f, 0.05207139f, 0.01192243f, 0.02840568f, 0.24829836f, 0.04228806f, -0.10414109f, 0.11995316f, 
    -0.05132452f, -0.03802455f, -0.04826933f, -0.05916278f, -0.02844283f, 0.12942910f, 0.08683065f, -0.08967958f, 
    0.13816495f, -0.54600835f, -0.00016460f, 0.22051883f, 0.02304538f, -0.00777001f, 0.10257535f, 0.17862177f, 
    0.10299727f, 0.04796363f, 0.15082043f, 0.05069430f, 0.33026415f, 0.22459489f, -0.06383002f, 0.09798877f, 
    -0.03777997f, -0.03344890f, -0.04119001f, 0.12622431f, 0.00582017f, -0.07723814f, 0.03245565f, -0.23796113f, 
    -0.22368506f, 0.49070519f, -0.03544259f, 0.06695089f, 0.18169028f, 0.01220910f, -0.06603607f, -0.06165156f, 
    -0.19825754f, -0.00530594f, 0.07828033f, 0.04928742f, 0.24476410f, -0.41020012f, 0.20827706f, 0.32349277f, 
    0.06185743f, 0.00028452f, 0.13434817f, -0.09266902f, 0.06649035f, 0.01745426f, -0.00945814f, -0.10498743f, 
    0.26715198f, 0.04072937f, 0.02912045f, 0.32846114f, -0.13946052f, 0.12956059f, 0.04449286f, -0.03353940f, 
    -0.12808520f, -0.00743364f, 0.05636375f, 0.05404781f, -0.04337890f, 0.23594779f, 0.22212523f, 0.33803371f, 
    0.09241816f, 0.02263132f, 0.07986216f, -0.06086258f, -0.02733592f, -0.00028850f, 0.03531437f, -0.00416688f, 
    0.05812462f, -0.00305129f, -0.17486994f, 0.11149774f, -0.00615677f, -0.06484170f, 0.04172010f, 0.05002677f, 
    -0.03540016f, 0.05716459f, 0.11483140f, 0.06983126f, -0.00323857f, 0.16922064f, -0.03189452f, 0.03235164f, 
    0.17110226f, -0.01243246f, -0.03160635f, 0.00845693f, 0.11521352f, 0.11730576f, 0.04966859f, 0.02162891f, 
    0.01008468f, -0.07807408f, 0.05156442f, -0.11142264f, -0.13268636f, -0.00677700f, -0.17122391f, 0.00616988f, 
    -0.11730251f, -0.10132945f, -0.00734861f, 0.03864560f, -0.02558024f, -0.08237529f, -0.02769480f, 0.19148734f, 
    0.06492425f, -0.04666329f, -0.02078506f, -0.08724514f, 0.12611830f, 0.03502674f, -0.03964749f, -0.01976571f, 
    0.28974289f, -0.03831151f, 0.01137336f, 0.10185242f, 0.00319363f, 0.11292999f, -0.14378594f, 0.00819048f, 
    0.06476393f, 0.00974720f, 0.00067598f, -0.06175531f, 0.17382401f, 0.08082317f, 0.19142304f, -0.01169461f, 
    0.03729829f, 0.03596113f, -0.00478594f, 0.05055561f, 0.01001749f, 0.10014383f, -0.05347756f, -0.14979535f, 
    0.02256625f, -0.43214107f, -0.47627816f, -0.44340408f, -0.21727183f, -0.06129620f, -0.00509718f, 0.02289976f, 
    0.24327761f, 0.04083025f, -0.04634572f, -0.07304363f, -0.14780378f, -0.26611939f, 0.01796119f, -0.06680740f, 
    -0.14883994f, -0.15063350f, -0.06045810f, -0.05098288f, 0.07438961f, 0.12114628f, -0.15589273f, 0.05684064f, 
    -0.50776279f, -0.15137661f, -0.13726301f, -0.10415134f, 0.08691208f, -0.05844542f, 0.05541319f, -0.01411583f, 
    0.06923342f, -0.02398513f, 0.02402591f, 0.07605875f, 0.27430877f, 0.02384268f, 0.11618037f, 0.17581969f, 
    0.03233304f, 0.02265573f, -0.00270226f, -0.08434875f, -0.03989925f, 0.00832114f, 0.06496871f, 0.05000769f, 
    -0.15195282f, -0.00363295f, 0.04933109f, 0.19201548f, 0.01195335f, -0.02608160f, 0.18339616f, 0.18070951f, 
    0.04055976f, 0.07417380f, -0.02031526f, 0.05780195f, 0.20114967f, 0.14895594f, 0.17503172f, 0.21569720f, 
    0.04233288f, -0.05995227f, 0.05497331f, 0.06094857f, 0.06534632f, 0.11701962f, 0.09948390f, -0.02120259f, 
    0.06986280f, 0.14194536f, 0.10324379f, 0.23764595f, 0.08022250f, -0.02117818f, -0.14927454f, -0.04825793f, 
    -0.16565126f, 0.05745246f, -0.02258572f, 0.00100701f, 0.15175121f, 0.12280167f, -0.04503102f, 0.35521102f, 
    -0.04587886f, -0.01361233f, -0.04329739f, 0.08994858f, -0.01357982f, -0.00017444f, 0.01464311f, -0.09812170f, 
    0.12367345f, -0.23325001f, -0.32433039f, -0.12365773f, 0.05287103f, 0.24836782f, 0.06395502f, 0.05353008f, 
    -0.03276507f, 0.07479939f, -0.03803861f, -0.06181710f, 0.21917400f, -0.06456769f, -0.20248222f, 0.07827792f, 
    0.28456515f, 0.03530305f, 0.11229031f, 0.23005377f, -0.05803918f, -0.00996830f, -0.01339403f, 0.01501227f, 
    0.02013091f, -0.31565827f, -0.32865569f, -0.30619276f, 0.02653789f, -0.02784423f, -0.00360576f, 0.27270475f, 
    0.12080792f, 0.02982225f, 0.12671325f, -0.02436846f, -0.16397513f, 0.11427314f, -0.56949574f, -0.40733126f, 
    0.12381043f, 0.00405185f, 0.11518013f, 0.08927981f, 0.00464710f, 0.01688099f, 0.08335534f, 0.05803791f, 
    -0.05582470f, 0.01891678f, -0.04338916f, 0.03457727f, -0.05454012f, 0.09590947f, 0.02698666f, -0.04727745f, 
    -0.07878103f, 0.08601957f, -0.04339517f, -0.09972449f, 0.34952277f, 0.21922486f, -0.03744282f, 0.16489661f, 
    0.03633678f, 0.01457246f, -0.04858487f, 0.02263387f, 0.11451714f, 0.09397331f, 0.04230801f, 0.01231656f, 
    0.33080667f, -0.04386013f, 0.06213627f, 0.11027273f, -0.08990823f, -0.06525314f, 0.01564022f, 0.08353110f, 
    -0.05964695f, -0.00309381f, 0.08849902f, 0.02405968f, 0.01131518f, 0.02195470f, 0.14149544f, -0.00155486f, 
    -0.13540204f, 0.02907351f, -0.09055021f, 0.00108555f, 0.02428438f, 0.02240843f, -0.03022590f, -0.09780293f, 
    -0.08464826f, -0.01794272f, -0.03793293f, 0.00222203f, 0.02211928f, 0.01399365f, 0.04423090f, -0.03285027f, 
    -0.02869716f, 0.04145868f, -0.03963368f, 0.00018048f, 0.01958140f, -0.07762781f, -0.05369267f, 0.03754269f, 
    0.03228854f, -0.06007261f, 0.03845284f, -0.06843786f, -0.00528048f, 0.03750713f, -0.06238350f, 0.05239538f, 
    0.00377690f, -0.00931173f, 0.00053920f, -0.00359171f, -0.02465390f, -0.02088906f, 0.05783115f, -0.06360349f, 
    -0.04174951f, 0.05375773f, 0.05073022f, 0.04219001f, -0.07781190f, -0.04086402f, 0.00420895f, 0.00519271f, 
    0.03234515f, -0.07494902f, -0.06321421f, 0.03410693f, -0.04106992f, 0.02681088f, -0.08427060f, 0.00688261f, 
    -0.01108003f, -0.00933984f, -0.02419625f, 0.00458119f, -0.05215693f, -0.01035049f, 0.00983848f, -0.01415226f, 
    -0.01047668f, 0.00889974f, 0.01139599f, -0.07882065f, -0.08094530f, 0.01655478f, -0.06541447f, -0.06488141f, 
    0.04108313f, -0.06716523f, 0.05450499f, -0.06561667f, -0.05105886f, -0.07338002f, -0.03860272f, 0.03517833f, 
    -0.07920644f, -0.03105119f, -0.07033800f, 0.00380808f, 0.01886731f, -0.03285259f, -0.00262078f, 0.03930268f, 
    0.05044915f, 0.02951716f, 0.03298280f, -0.03173148f, -0.05460542f, -0.08377939f, 0.05462621f, 0.00573866f, 
    -0.05927539f, -0.04475083f, -0.03532375f, -0.04121300f, 0.00963649f, -0.06674582f, 0.02702215f, 0.02717764f, 
    -0.03676881f, -0.02448080f, -0.03288576f, -0.04191040f, 0.02160643f, 0.01761249f, 0.00641669f, -0.04438290f, 
    0.04252374f, 0.00964972f, 0.02442529f, -0.05861481f, -0.08182040f, -0.03539120f, -0.01293353f, 0.01313428f, 
    0.00908063f, 0.02804816f, -0.03425283f, -0.01984518f, -0.06152905f, 0.06126235f, 0.06348087f, -0.06388897f, 
    -0.04201894f, -0.00561498f, 0.01930887f, 0.03983235f, -0.01701922f, 0.06450421f, 0.01391707f, -0.03807300f, 
    -0.01537616f, 0.01574750f, -0.04665432f, -0.08412831f, 0.05157886f, 0.01245099f, 0.00373460f, -0.04493951f, 
    0.00097015f, 0.04836419f, -0.00666193f, -0.06147634f, 0.03765231f, -0.01455899f, 0.06205431f, -0.03491863f, 
    -0.00653279f, -0.09583923f, -0.07413966f, -0.01710160f, -0.05477832f, 0.00396354f, 0.00706686f, 0.02278431f, 
    0.02334593f, -0.04250826f, 0.02651424f, -0.07038640f, -0.02133344f, 0.03297624f, 0.03446352f, 0.01180841f, 
    -0.06498113f, -0.07373339f, -0.04537332f, -0.04900810f, -0.05949911f, 0.01980686f, -0.07372544f, 0.00495928f, 
    -0.06112809f, -0.03224804f, 0.00410841f, -0.05491070f, 0.00052364f, -0.08060659f, 0.05180527f, -0.05868568f, 
    0.00531572f, -0.07778030f, -0.01840774f, -0.09448016f, -0.00739240f, 0.04387769f, 0.02385253f, -0.03217164f, 
    0.03742049f, -0.03925297f, -0.03431593f, 0.01602488f, -0.01233637f, 0.01733946f, -0.00250448f, 0.02578758f, 
    0.26934358f, -0.31232023f, -0.04792594f, -0.00514222f, -0.04612547f, -0.13754331f, -0.03957392f, 0.02086223f, 
    0.13330054f, -0.05724028f, 0.07059021f, 0.21401083f, 0.28216261f, -0.22332458f, 0.14928126f, 0.03153491f, 
    0.12738973f, -0.08121505f, 0.00887037f, 0.15100567f, 0.01296802f, 0.14275679f, 0.10553323f, 0.02335666f, 
    0.17018545f, 0.11791294f, 0.02888465f, 0.08906863f, -0.02890525f, 0.05457462f, 0.05630950f, 0.05689106f, 
    -0.12987711f, 0.04588278f, 0.00963190f, 0.10836703f, 0.06644935f, 0.08268351f, -0.19658449f, 0.08247243f, 
    -0.13764095f, 0.12182442f, -0.11810237f, -0.02529715f, -0.03978154f, -0.12411424f, 0.04916857f, -0.08342116f, 
    0.32172760f, 0.09798842f, 0.24803016f, 0.01762177f, 0.09627575f, 0.10691287f, 0.11499094f, 0.04445211f, 
    0.06486178f, -0.10234380f, -0.09300740f, 0.03921432f, -0.10899417f, 0.10998197f, -0.25068796f, 0.21987784f, 
    -0.01923865f, -0.10712099f, -0.09566364f, 0.24326986f, 0.22426504f, 0.13690841f, 0.17734113f, 0.04862023f, 
    -0.17599654f, -0.00331546f, 0.08362823f, -0.14476472f, -0.15830784f, 0.13048539f, -0.16597016f, -0.09906679f, 
    -0.04619446f, -0.14903958f, 0.03261122f, -0.12394524f, -0.08791590f, -0.19393800f, -0.01428635f, 0.20161963f, 
    -0.17126319f, 0.08345502f, -0.06259657f, -0.12171441f, 0.05122555f, -0.20297706f, 0.04112319f, -0.10706781f, 
    0.20975219f, 0.28784424f, -0.06672630f, 0.42662778f, -0.06223880f, 0.09216352f, -0.01015945f, 0.12377424f, 
    -0.06931867f, 0.01406424f, -0.02792777f, -0.05115533f, 0.37654313f, 0.15179461f, 0.09292574f, 0.15182579f, 
    0.14122455f, 0.05054488f, 0.12987913f, 0.21040210f, -0.05883468f, 0.08516508f, 0.00641032f, -0.00241243f, 
    -0.31566960f, 0.03281608f, -0.08984273f, -0.21246494f, -0.08739782f, -0.03546379f, -0.11896989f, -0.08465459f, 
    0.11392022f, -0.01176442f, 0.10150304f, 0.07848098f, 0.05004588f, 0.05679157f, -0.21398643f, -0.20803483f, 
    0.00053436f, 0.13224222f, -0.06010479f, 0.05359596f, -0.13171071f, -0.01852828f, -0.06228254f, 0.08217215f, 
    0.31452870f, -0.42874089f, 0.01945539f, -0.28494188f, -0.02342048f, 0.06058276f, -0.04912701f, -0.12549955f, 
    -0.05034227f, -0.19081232f, -0.11547344f, -0.14175239f, -0.25660151f, -0.06142088f, -0.14510097f, -0.04013970f, 
    -0.06901269f, -0.25936842f, 0.07443584f, -0.00744292f, 0.06737964f, -0.08900288f, 0.13397083f, 0.12193126f, 
    0.21116626f, 0.02082300f, -0.17310157f, -0.03132862f, 0.08147941f, 0.08038156f, 0.06519298f, 0.04048677f, 
    0.14858849f, -0.03776670f, 0.08446915f, 0.10561468f, 0.19834827f, 0.04732782f, 0.18416901f, 0.00785794f, 
    -0.08622797f, 0.10490122f, -0.05100627f, -0.33540341f, 0.16305611f, 0.00341533f, -0.06016875f, -0.15382352f, 
    0.36681792f, 0.16643238f, 0.05556891f, -0.04303431f, 0.12626660f, 0.12510115f, 0.02498367f, -0.09294298f, 
    0.08467946f, 0.06869857f, -0.15331939f, -0.00225951f, -0.17278926f, 0.06991700f, -0.15445895f, -0.16505398f, 
    0.14818899f, -0.02957700f, -0.06524638f, -0.00051631f, -0.01615599f, -0.05500257f, 0.09084474f, -0.00025590f, 
    0.26747122f, 0.28387338f, -0.03402562f, -0.02004241f, 0.10720894f, -0.08796494f, 0.01043551f, 0.02307336f, 
    0.24115506f, 0.01594846f, 0.05522343f, -0.02544819f, 0.00941250f, 0.06497632f, 0.21094145f, -0.04332087f, 
    0.00091386f, 0.07437392f, 0.01674211f, 0.04328012f, -0.04693886f, -0.08304673f, -0.05720711f, 0.03968194f, 
    0.19872727f, 0.16130961f, -0.09702942f, -0.31927127f, 0.20543551f, -0.15392920f, -0.19010349f, -0.01516890f, 
    -0.06667756f, 0.04847399f, 0.07350481f, -0.06616582f, -0.11107758f, -0.12850347f, -0.00861281f, 0.05147368f, 
    -0.09096297f, -0.00788620f, -0.00014308f, -0.10724672f, -0.04761935f, 0.15409669f, -0.12667733f, 0.14101592f, 
    -0.04819429f, -0.00310502f, -0.21637276f, 0.02906371f, -0.00011646f, -0.04993067f, 0.17851998f, 0.04119831f, 
    0.02650568f, 0.23434304f, -0.04060619f, 0.18266462f, -0.13716654f, 0.02656634f, -0.13812558f, -0.21614103f, 
    0.03470179f, -0.07358616f, -0.26347354f, 0.24826999f, 0.03400437f, 0.03835552f, -0.10332388f, -0.06575504f, 
    -0.03609314f, -0.07062455f, -0.05012726f, -0.39879993f, 0.00303960f, -0.10027981f, -0.01507111f, 0.09423652f, 
    -0.01973344f, 0.00267762f, -0.01700012f, 0.03698305f, 0.17629622f, -0.04221949f, -0.22245419f, -0.22881013f, 
    0.03152692f, -0.00271399f, 0.07300392f, 0.08547031f, -0.03174052f, -0.03966065f, -0.10407593f, 0.05670035f, 
    -0.09494592f, -0.11800814f, 0.21666305f, -0.19249646f, -0.04905771f, 0.12827432f, -0.05717944f, 0.04171153f, 
    0.08430677f, 0.06533342f, -0.06964752f, 0.09274574f, 0.23022757f, -0.02408635f, 0.16445625f, 0.05667644f, 
    0.01552521f, -0.02894988f, 0.09238630f, 0.09694884f, -0.14028603f, -0.12543653f, -0.10364939f, -0.07709793f, 
    -0.07122540f, 0.16813894f, -0.08407382f, -0.06410690f, 0.09298371f, -0.09480005f, 0.13950998f, -0.08378007f, 
    0.09718300f, 0.16241349f, 0.06980117f, 0.00567451f, 0.12173635f, -0.12918025f, -0.25765938f, 0.14816776f, 
    -0.06007946f, 0.01213431f, -0.09655800f, -0.02242105f, 0.02583358f, -0.05281607f, 0.09799618f, -0.03298437f, 
    0.11236240f, -0.08042114f, -0.20312266f, -0.03561164f, -0.12794393f, -0.14500114f, -0.02598933f, 0.03106363f, 
    -0.11467342f, -0.00791073f, 0.03344465f, 0.06752770f, -0.12535934f, 0.06405002f, -0.02835601f, 0.01928654f, 
    0.00033450f, 0.12511361f, 0.01107073f, 0.13894695f, -0.10659193f, 0.01598576f, -0.09685417f, -0.23079157f, 
    0.21322244f, 0.30920205f, 0.35715452f, 0.21328770f, -0.07714164f, -0.00982174f, -0.00589056f, 0.01149333f, 
    0.03247949f, 0.13743976f, 0.05243152f, -0.01613229f, -0.17261191f, 0.37175220f, 0.28583026f, -0.01735419f, 
    0.02192002f, -0.02944619f, -0.09276844f, 0.17166167f, 0.04415076f, 0.01910766f, 0.05245709f, 0.16480643f, 
    0.10631926f, -0.13829902f, -0.03961873f, -0.07251224f, 0.01400778f, -0.01578184f, 0.00922890f, 0.16761300f, 
    0.07812428f, 0.19461355f, 0.19070043f, 0.06435426f, 0.10576186f, -0.21521106f, -0.47019345f, -0.00786593f, 
    -0.03617760f, 0.02148602f, 0.11735146f, -0.14919822f, -0.07558741f, -0.13228332f, 0.10011315f, -0.09731842f, 
    -0.15172364f, 0.04803509f, -0.32745764f, 0.17516793f, 0.10633363f, 0.14283912f, 0.13814481f, 0.15116170f, 
    -0.06375760f, -0.07891889f, -0.08826108f, -0.04244179f, -0.01250357f, 0.09006780f, 0.14471260f, -0.08119755f, 
    0.00307137f, -0.02508816f, -0.02667243f, 0.01643288f, 0.05327386f, 0.12751071f, 0.14837746f, 0.08146925f, 
    0.07329360f, -0.38350418f, 0.27553234f, 0.24644907f, -0.02899253f, -0.09624837f, -0.23930337f, -0.03410611f, 
    -0.08186804f, 0.02471619f, -0.07516403f, -0.08269837f, -0.18741158f, 0.03590726f, -0.20814669f, 0.22743663f, 
    0.05205163f, 0.08725429f, 0.01997501f, -0.01134551f, 0.05973322f, -0.07369672f, 0.13270630f, -0.01558310f, 
    -0.05047044f, -0.07567792f, -0.36864507f, -0.28753752f, 0.14968775f, -0.01829896f, 0.11619212f, 0.03822157f, 
    -0.06150530f, 0.00237707f, 0.02485896f, 0.05361992f, 0.34801555f, -0.19691999f, -0.10345919f, -0.27502838f, 
    0.07927735f, 0.08788973f, -0.00860292f, 0.15999925f, -0.03686171f, 0.06237200f, 0.03491201f, 0.12432235f, 
    0.12568466f, -0.01002543f, 0.03914080f, -0.30235475f, -0.09897871f, -0.20433414f, 0.09807288f, 0.15487407f, 
    -0.06989961f, 0.06957082f, 0.19524838f, 0.05215940f, 0.15798981f, 0.09445934f, -0.04183097f, -0.21385045f, 
    -0.06620555f, 0.00830173f, -0.15966745f, 0.12112646f, -0.13517702f, 0.03339005f, 0.01013247f, -0.07689832f, 
    -0.16384092f, -0.17447188f, 0.04516086f, 0.15761577f, 0.12839530f, 0.03718170f, -0.01618412f, 0.01546149f, 
    -0.02892002f, -0.21776664f, 0.06502812f, -0.15172608f, 0.21014979f, -0.01497422f, 0.15375417f, 0.04024335f, 
    0.02656390f, 0.05903416f, 0.07378653f, -0.01342607f, -0.12168764f, -0.10385502f, -0.00445367f, 0.04721138f, 
    -0.08662249f, -0.28956315f, 0.10618188f, 0.02964566f, 0.13921450f, 0.07103454f, 0.05741195f, -0.03282300f, 
    -0.01661557f, 0.02927559f, -0.08869027f, -0.01626393f, -0.19128434f, 0.09933808f, 0.01445473f, 0.20023103f, 
    0.00710024f, -0.05148385f, -0.06155443f, -0.03652168f, 0.00753332f, -0.05404227f, -0.09813602f, 0.05820276f, 
    -0.32856581f, -0.06065754f, 0.27452248f, 0.25506151f, 0.12968799f, -0.02229782f, -0.07418341f, -0.06380618f, 
    -0.11286095f, 0.04805681f, -0.02475545f, 0.24679564f, 0.13280313f, 0.00386590f, 0.20298757f, 0.20062454f, 
    -0.04316173f, -0.09086911f, -0.02876406f, 0.03341318f, 0.04132251f, 0.00044783f, 0.04719875f, 0.05250987f, 
    -0.00682940f, -0.00522028f, -0.06965911f, 0.25237027f, 0.06102869f, -0.01242873f, 0.15659289f, 0.08169975f, 
    0.01375684f, 0.17585182f, 0.00561139f, 0.27077147f, -0.03953509f, 0.06107932f, 0.35283229f, 0.15045702f, 
    0.08367595f, 0.08520701f, -0.09568916f, 0.05019842f, -0.04439104f, -0.07070102f, -0.11197287f, -0.08161519f, 
    0.18423282f, 0.46319845f, 0.53969091f, 0.39758730f, 0.04034733f, 0.18303677f, -0.15766111f, 0.19861589f, 
    0.09328166f, -0.13628377f, 0.01573734f, -0.16647448f, -0.12663111f, -0.22705598f, -0.06587955f, 0.04753702f, 
    -0.18790224f, -0.09987979f, -0.16706288f, -0.29271367f, 0.10153848f, 0.28179687f, 0.13862067f, 0.16689432f, 
    0.01132303f, -0.06525763f, -0.03226809f, -0.08059513f, 0.18995388f, 0.02322288f, 0.09396988f, -0.09383631f, 
    -0.10149007f, -0.03920050f, -0.21760525f, -0.13080579f, 0.18635119f, -0.17182852f, 0.22432221f, -0.18469608f, 
    -0.00350076f, 0.09942989f, -0.12329409f, 0.19096507f, 0.04564307f, -0.07548975f, -0.17852522f, -0.09784167f, 
    -0.05930433f, 0.13036232f, 0.01087310f, 0.13554503f, 0.03465443f, 0.15998441f, 0.07754195f, 0.21975075f, 
    0.10939109f, -0.04559040f, -0.00962829f, -0.22595420f, -0.19467376f, 0.07398771f, -0.07851803f, 0.04231345f, 
    0.17328885f, 0.15005115f, 0.18186779f, 0.22382154f, 0.11496881f, -0.01719584f, 0.13680197f, -0.10712716f, 
    0.18791075f, 0.07364079f, 0.20956239f, 0.38227564f, -0.12406503f, -0.04866032f, -0.31504512f, -0.34953663f, 
    -0.02295231f, -0.08363219f, 0.12742099f, 0.12159226f, 0.09540633f, 0.03592124f, -0.06163988f, 0.06419724f, 
    -0.03341271f, 0.06380300f, 0.09075372f, -0.02018326f, -0.09893415f, -0.10743161f, -0.11590035f, -0.01773933f, 
    -0.04650259f, 0.22756897f, -0.31119987f, -0.33969939f, 0.16353701f, -0.15971395f, 0.16644448f, -0.16086996f, 
    -0.31051630f, 0.11914893f, -0.46862021f, -0.22822452f, -0.33837047f, 0.30607387f, 0.05224154f, 0.12358652f, 
    -0.02034459f, 0.00850075f, -0.08387094f, -0.15646738f, 0.04931064f, -0.04859905f, -0.27181438f, 0.10215232f, 
    -0.03982580f, 0.23955321f, 0.02309691f, 0.12085142f, 0.03008075f, -0.10540248f, -0.04108566f, 0.11504521f, 
    -0.11401118f, -0.21342084f, -0.30184868f, -0.18678431f, -0.02333386f, 0.20399106f, 0.03441564f, -0.16872922f, 
    0.43656901f, -0.23330316f, 0.14069894f, -0.40111148f, -0.14374080f, -0.30164999f, -0.31814724f, -0.28201669f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13358529f, 0.00331271f, -0.06290556f, 0.02167205f, 0.08447041f, -0.03343930f, 0.00567060f, 0.12978996f, 
    -0.09187728f, 0.05120815f, 0.09858623f, 0.07557880f, 0.04600329f, -0.02300511f, 0.02403680f, -0.05433223f, 
    0.00107643f, 0.02495785f, 0.03161313f, -0.02609192f, -0.03354128f, 0.01523692f, 0.00325018f, 0.03810978f, 
    0.03966770f, 0.17909904f, 0.12204517f, 0.03046495f, 0.18384513f, 0.08771123f, -0.07643556f, 0.19948159f, 
    0.05729216f, -0.00145697f, -0.09652353f, 0.15608582f, -0.03608298f, -0.01616273f, 0.05574679f, -0.00366889f, 
    0.00722774f, 0.09518652f, -0.01964465f, -0.04082612f, 0.12064883f, 0.25794107f, -0.00218652f, -0.03738678f, 
    0.24692729f, -0.02162397f, 0.04734305f, -0.03048908f, 0.07959470f, -0.23252101f, 0.10463715f, 0.04854300f, 
    0.28296629f, 0.02540542f, 0.14166163f, -0.09742489f, -0.09564230f, 0.10556815f, -0.04032622f, 0.06337597f, 
    0.06147510f, -0.03467301f, -0.15288900f, 0.01892735f, 0.20634992f, 0.22789374f, 0.06717020f, 0.22669239f, 
    -0.02958059f, 0.12353382f, 0.04944478f, -0.05135041f, 0.14865418f, -0.04746535f, -0.05503923f, -0.11469749f, 
    0.14324816f, 0.05561896f, 0.03081447f, -0.05912742f, -0.01394472f, -0.01582783f, -0.06790589f, 0.17059368f, 
    -0.10405480f, -0.01038431f, 0.06121817f, -0.10727892f, 0.09023045f, 0.11525047f, 0.01057973f, -0.18191232f, 
    0.03495117f, 0.20211290f, 0.07308194f, -0.07588630f, 0.02079908f, 0.02035595f, 0.03286147f, -0.03248281f, 
    -0.05597855f, 0.02317974f, 0.19771743f, -0.08010903f, 0.03253875f, -0.00465194f, -0.04916106f, 0.06142330f, 
    -0.00794497f, 0.11859078f, -0.03563901f, 0.00816913f, 0.01478251f, 0.09310975f, 0.10811652f, 0.20248240f, 
    -0.07464764f, -0.00814960f, -0.03043752f, 0.05759102f, -0.03637361f, 0.06132441f, 0.13626553f, -0.06164242f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10610709f, 0.01714508f, -0.00496127f, -0.00624680f, -0.34307891f, 0.06927243f, 0.02632464f, -0.18472819f, 
    -0.35960764f, 0.13695689f, -0.07765166f, -0.34004837f, -0.01493441f, 0.09883518f, -0.05630822f, -0.20706338f, 
    -0.02305058f, -0.27434978f, 0.01199845f, -0.04210495f, -0.04279670f, 0.05234367f, -0.01843339f, 0.03405095f, 
    -0.06129896f, -0.07096113f, -0.23051356f, 0.12443868f, 0.07642712f, 0.04476062f, 0.07931825f, -0.25207797f, 
    0.11088123f, 0.15599544f, -0.07108084f, -0.27748913f, -0.07269859f, -0.29282197f, 0.00052032f, -0.03900229f, 
    -0.41242316f, -0.43580073f, -0.02791464f, -0.28020641f, -0.22624773f, 0.05067967f, 0.01458228f, 0.03025688f, 
    -0.36882135f, 0.13545059f, 0.12513719f, -0.04817832f, -0.24277470f, 0.09462843f, -0.05921745f, 0.13224462f, 
    -0.17597902f, -0.13690947f, -0.17102183f, 0.24107769f, -0.04151124f, 0.03047067f, 0.02540377f, 0.00126024f, 
    -0.33876389f, 0.40227914f, 0.14641751f, 0.06920163f, 0.11452182f, -0.04307601f, -0.07306022f, 0.03776710f, 
    0.04690918f, -0.27239865f, -0.12720919f, -0.52374935f, 0.15697613f, 0.25683886f, -0.19544220f, -0.01222767f, 
    0.01611638f, -0.08119380f, -0.07900466f, 0.08322132f, 0.03151185f, 0.26279953f, 0.00050300f, -0.39786670f, 
    0.26719007f, 0.14473532f, 0.03016163f, -0.01047088f, 0.09095952f, 0.01748541f, -0.04503448f, 0.04544966f, 
    -0.00320636f, -0.09534908f, 0.09939086f, -0.09204698f, 0.18472365f, 0.09062051f, -0.28294533f, -0.05548791f, 
    0.15517089f, 0.17294610f, -0.31146738f, -0.07587808f, -0.24669304f, -0.11652872f, -0.03799444f, -0.07315376f, 
    -0.03167082f, -0.28547651f, 0.19883625f, -0.32882541f, 0.02419032f, 0.02521816f, 0.03225158f, 0.00797115f, 
    0.07383993f, -0.30296972f, -0.20711014f, -0.04092398f, 0.21960023f, 0.23156570f, 0.14836426f, 0.10152373f, 
    0.12523416f, 0.00031756f, 0.01428182f, 0.06117322f, 0.06034387f, 0.00506641f, -0.01857566f, 0.05728028f, 
    0.05064270f, 0.09644494f, 0.09827159f, 0.04535842f, 0.00545130f, -0.07806794f, -0.03128740f, -0.09052406f, 
    -0.03385553f, 0.28066570f, 0.01436932f, 0.04554567f, -0.03045040f, 0.05264156f, 0.08580635f, -0.00786551f, 
    -0.06402713f, 0.10041342f, 0.15126944f, 0.08238666f, 0.06118005f, 0.12632591f, 0.01098966f, -0.29319012f, 
    -0.04577267f, 0.19147435f, -0.19136852f, 0.07226563f, 0.00126921f, 0.05286971f, 0.03353212f, 0.03843123f, 
    -0.21237236f, -0.10905980f, -0.04339996f, -0.58266044f, 0.03595242f, 0.08127354f, 0.05685445f, 0.01555770f, 
    0.09640572f, 0.01177665f, -0.00851096f, 0.07921391f, 0.08406533f, -0.66106492f, 0.12002032f, 0.22105262f, 
    0.51509804f, 0.03978294f, -0.08239534f, 0.09251044f, -0.07262342f, 0.11731316f, 0.01001734f, -0.22994895f, 
    -0.06120678f, -0.48526672f, 0.18124241f, 0.04930793f, 0.01806870f, 0.22546402f, 0.08462927f, 0.19422410f, 
    -0.07278660f, -0.15531942f, 0.34779018f, -0.50243253f, 0.17280443f, 0.31820947f, -0.63109237f, -0.23842132f, 
    0.09725587f, 0.19993533f, -0.06599784f, 0.07298249f, 0.06936132f, 0.07747258f, -0.06024852f, -0.20856237f, 
    -0.12372465f, 0.34897771f, -0.08022366f, -0.61201555f, -0.03398748f, -0.10585854f, 0.04802249f, -0.64915991f, 
    -0.05198412f, 0.03174169f, -0.08933106f, 0.01051784f, -0.07644953f, 0.07434160f, 0.02759639f, -0.07852472f, 
    -0.03582777f, 0.04854715f, 0.09450120f, -0.64647973f, -0.20758364f, -0.18464543f, -0.06959663f, 0.13094513f, 
    -0.04551515f, -0.12156057f, 0.04017550f, -0.02157065f, 0.24586393f, 0.08884962f, 0.02325699f, 0.11153805f, 
    -0.05607372f, -0.03499162f, 0.15595412f, 0.04686039f, -0.35038790f, 0.19969481f, 0.03030801f, -0.51421237f, 
    0.17660004f, -0.06771371f, -0.06268355f, -0.06806268f, 0.23420556f, 0.02686936f, -0.23334916f, 0.04033535f, 
    -0.10907006f, 0.11676962f, -0.16509674f, -0.10705324f, 0.05212951f, 0.08323671f, 0.01446110f, 0.12983726f, 
    0.03021617f, 0.32693401f, 0.06943361f, 0.05740471f, 0.04762281f, 0.00821914f, -0.07530686f, -0.00744952f, 
    0.04962374f, 0.19470233f, 0.05453771f, 0.13087504f, 0.17362739f, -0.02906836f, 0.05388810f, 0.08613791f, 
    -0.02949273f, -0.08478753f, 0.07595101f, 0.12766382f, -0.31831625f, 0.51779759f, 0.02236398f, -0.00959026f, 
    -0.11390475f, 0.04265727f, 0.07426944f, 0.11586925f, -0.12852313f, 0.02956733f, 0.03688641f, -0.37571812f, 
    0.21622370f, 0.17460553f, 0.11946848f, -0.03894897f, 0.02466109f, -0.15057901f, -0.10167397f, 0.01212219f, 
    -0.86803693f, -0.16286571f, 0.18614030f, -0.50389373f, -0.04317856f, 0.05541793f, -0.09049227f, -0.26800877f, 
    -0.03806318f, -0.12572554f, -0.31096333f, 0.06556933f, 0.07958504f, -0.10449722f, 0.10998029f, 0.29511714f, 
    0.02493989f, 0.04487851f, -0.54393029f, 0.13903944f, 0.18699874f, -0.40044245f, -0.08277318f, 0.04920289f, 
    -0.01046361f, -0.07170406f, 0.02295976f, -0.01865742f, 0.05956426f, -0.28741959f, -0.01877042f, 0.25207111f, 
    -0.16199282f, 0.13719915f, -0.04535832f, -0.27085710f, -0.09529593f, 0.05488080f, 0.05995499f, -0.20458439f, 
    -0.02123027f, 0.28064314f, -0.02916320f, -0.08171403f, -0.27632502f, 0.04992733f, -0.05781220f, -0.07735723f, 
    -0.26546997f, -0.06279594f, 0.09833165f, 0.26072028f, 0.00878307f, -0.14757417f, -0.07592458f, -0.17171256f, 
    -0.01926499f, 0.05532508f, -0.13383333f, -0.08636392f, -0.35573974f, 0.00930215f, 0.15365066f, 0.17665492f, 
    0.05752833f, -0.42856750f, -0.50636858f, 0.05457868f, -0.69364929f, 0.11474580f, -0.03828723f, 0.28328079f, 
    0.01634844f, 0.06906758f, 0.05731797f, -0.00510431f, 0.20409027f, -0.06013101f, -0.03266412f, -0.40566152f, 
    0.18109986f, 0.14045618f, -0.02264386f, -0.35554588f, 0.05462847f, 0.25081930f, -0.09434442f, 0.15552948f, 
    -0.03975451f, 0.05446025f, -0.00917286f, 0.18061195f, -0.07091495f, 0.02788045f, 0.01514633f, 0.06501393f, 
    0.00824320f, -0.26784420f, -0.29492983f, -0.47502625f, -0.00855544f, -0.21033885f, -0.04492405f, -0.08718185f, 
    -0.10964853f, 0.10005829f, 0.19066511f, -0.08151814f, -0.00688995f, -0.11096139f, 0.02596478f, -0.00079705f, 
    0.27010849f, 0.04799306f, 0.01233840f, 0.17817643f, -0.02275354f, -0.52050984f, 0.02898539f, 0.14533088f, 
    0.17667119f, -0.12363534f, -0.30457410f, 0.01767305f, -0.37200335f, 0.30934006f, -0.17008862f, -0.31330964f, 
    -0.25382471f, -0.03738234f, -0.08197487f, 0.10972779f, -0.12013695f, -0.59179980f, -0.03998610f, -0.18485938f, 
    0.16799979f, 0.01431781f, 0.09165388f, -0.03410469f, -0.28926441f, -0.46602586f, 0.06676205f, -0.22902185f, 
    -0.25068578f, 0.00712451f, -0.10486133f, -0.08722912f, 0.02087053f, 0.07879216f, 0.14366135f, 0.03521641f, 
    -0.15864740f, 0.26536053f, -0.05367973f, -0.03933025f, 0.05769252f, -0.10361262f, 0.02433557f, 0.18230334f, 
    -0.03442763f, -0.06457668f, -0.00585459f, 0.24801986f, -0.05366297f, -0.46369526f, 0.06320984f, 0.14192802f, 
    0.07098193f, 0.10792025f, -0.07041526f, -0.08079530f, 0.03800705f, 0.02946022f, -0.06067383f, 0.04362321f, 
    -0.01023764f, -0.04002877f, -0.13080825f, 0.25327647f, -0.05452992f, 0.13806534f, -0.01549858f, -0.53254396f, 
    -0.06024995f, -0.23606953f, 0.20324142f, 0.31186464f, -0.14853141f, 0.10939678f, 0.02520089f, -0.46632898f, 
    0.02231145f, 0.26323423f, -0.12151062f, 0.03486125f, -0.01700182f, -0.20355445f, -0.41692343f, 0.27252287f, 
    -0.14088938f, 0.03681511f, 0.03384153f, -0.00245004f, -0.31605169f, -0.05056724f, 0.02212408f, -0.01537002f, 
    -0.07255521f, -0.01618794f, -0.17322212f, 0.14583965f, 0.07994441f, -0.01808198f, 0.01067925f, -0.05384782f, 
    -0.08243399f, -0.13181154f, -0.04892830f, -0.06854029f, -0.05938990f, -0.00541120f, 0.00284465f, -0.01851060f, 
    0.03402154f, -0.00196942f, 0.05837662f, -0.02391879f, -0.08119390f, 0.05071344f, 0.02043569f, 0.12357228f, 
    -0.20924537f, 0.01624667f, 0.13810682f, -0.02407035f, 0.00632061f, 0.22320823f, 0.03239550f, -0.02276715f, 
    -0.20116113f, -0.04882736f, -0.03614459f, -0.02285996f, -0.25021330f, -0.20876993f, -0.02524940f, 0.14163485f, 
    -0.34179157f, 0.05403056f, 0.00593158f, 0.01786147f, 0.08378815f, 0.05495194f, -0.18097253f, -0.05198823f, 
    -0.15531632f, 0.06369403f, 0.27535555f, -0.07581573f, 0.01841730f, -0.07644130f, 0.03119107f, 0.12984835f, 
    -0.14695145f, 0.09177849f, 0.08382895f, -0.07094362f, -0.15742348f, 0.15037401f, 0.14775655f, -0.28932354f, 
    0.11869997f, 0.05230289f, 0.05493027f, 0.19465551f, 0.00115518f, -0.02463962f, 0.03386248f, 0.11023277f, 
    0.03494193f, -0.25700355f, -0.05559713f, -0.07695085f, 0.00980633f, -0.22161980f, 0.05227019f, -0.23266493f, 
    -0.02239683f, 0.16604741f, 0.05548413f, 0.00343270f, 0.05973991f, -0.08621166f, 0.03847287f, 0.22747025f, 
    -0.02039259f, 0.00245390f, 0.11940835f, -0.05050386f, -0.15785049f, -0.03041006f, 0.13214239f, -0.09077574f, 
    0.01820194f, 0.06019394f, 0.01179474f, 0.13751519f, 0.17798264f, -0.26741153f, -0.06153044f, -0.03146527f, 
    -0.06252462f, -0.08106551f, -0.25497550f, -0.52543032f, 0.33561486f, -0.28466505f, 0.10105124f, -0.09786522f, 
    -0.07717741f, 0.07894994f, 0.12786455f, -0.02206609f, 0.09445348f, -0.23518746f, -0.03364234f, 0.27250329f, 
    0.03455256f, 0.04213701f, -0.06858890f, 0.06467374f, -0.05183100f, 0.06651668f, -0.09916335f, 0.00045061f, 
    -0.25580400f, 0.11455691f, 0.13362999f, 0.21769246f, -0.05001863f, -0.02168282f, 0.04752494f, -0.16143999f, 
    0.04088597f, -0.35035691f, 0.01080164f, -0.05219149f, -0.00753271f, -0.08336429f, -0.01998907f, -0.02687738f, 
    0.04953241f, -0.52420831f, 0.17872979f, 0.07114209f, 0.21518508f, -0.12317622f, -0.01799584f, -0.02877201f, 
    0.10599745f, 0.07947355f, 0.02138321f, -0.26671603f, 0.18472788f, -0.51322633f, 0.04379814f, -0.06242300f, 
    -0.28820601f, -0.10487369f, 0.05247926f, 0.07047880f, 0.19480984f, 0.23183250f, 0.02042118f, -0.10646214f, 
    -0.26748535f, -0.07077778f, 0.17155001f, -0.05892998f, 0.00889071f, -0.21274097f, 0.15107507f, 0.18816045f, 
    -0.20993111f, 0.22455417f, 0.10818192f, -0.29295024f, 0.06803393f, 0.01822163f, 0.08126985f, 0.22791746f, 
    0.00220985f, -0.29644051f, 0.01997323f, -0.03966013f, 0.13562655f, -0.24269335f, -0.05188474f, -0.34128425f, 
    0.00082650f, 0.05211073f, 0.08495065f, 0.04068257f, 0.14031486f, -0.16806045f, -0.05327240f, -0.17799962f, 
    -0.19460350f, 0.22206923f, 0.04382160f, -0.02519644f, 0.07342127f, 0.12876110f, -0.04126909f, -0.04130334f, 
    -0.40372252f, -0.17353910f, 0.07271575f, -0.05192520f, 0.13636094f, -0.19137500f, 0.01698130f, -0.17169581f, 
    -0.01147815f, -0.06566388f, 0.17411013f, 0.03857890f, 0.15112554f, -0.04638194f, -0.04202092f, 0.06709208f, 
    -0.00412344f, 0.10878400f, -0.06169728f, -0.07968445f, 0.15444228f, 0.19683644f, -0.01893049f, 0.07043472f, 
    -0.07433450f, 0.31558236f, -0.08140536f, -0.31097186f, -0.29458857f, 0.02834616f, -0.08969130f, -0.17261589f, 
    -0.03576465f, 0.17523806f, 0.11918217f, 0.00140604f, 0.09715178f, -0.18608262f, -0.05326667f, -0.56567788f, 
    -0.31839523f, 0.00114650f, -0.02819371f, -0.07317255f, -0.09269057f, -0.07391716f, 0.17458963f, 0.17314246f, 
    0.07508657f, -0.49529776f, -0.30974206f, 0.14524020f, 0.00989332f, -0.06059014f, 0.07055663f, 0.01405128f, 
    -0.04836567f, -0.20193532f, 0.01977103f, -0.06856121f, -0.05375175f, -0.06366388f, -0.40979081f, -0.05133104f, 
    -0.07849142f, -0.23167230f, -0.31301793f, 0.00583887f, -0.23585416f, 0.12267867f, -0.01622830f, 0.12080032f, 
    0.00440415f, -0.59813148f, -0.02863055f, 0.13834034f, -0.11174276f, -0.02112005f, 0.05655309f, 0.08084329f, 
    0.19440259f, -0.07188284f, 0.05924331f, -0.05757810f, -0.23574646f, 0.08200629f, -0.03774035f, -0.39613134f, 
    0.20375903f, 0.17205071f, -0.25212041f, -0.09618217f, 0.05189503f, -0.35207582f, -0.10895181f, -0.23961653f, 
    0.18407190f, -0.27946603f, -0.15827985f, -0.21759185f, -0.00632676f, -0.06263321f, -0.07298208f, -0.30649528f, 
    0.03471375f, -0.05862900f, -0.45436502f, -0.05965967f, 0.15449034f, -0.30583516f, -0.26956719f, 0.23499122f, 
    -0.20487976f, 0.19815038f, -0.28123364f, 0.01571430f, -0.55312288f, -0.23783498f, 0.14303720f, -0.02703356f, 
    -0.20076059f, -0.21792668f, -0.06782091f, 0.02106309f, -0.07825053f, -0.36638618f, -0.06690341f, 0.28471953f, 
    -0.01253228f, -0.47049654f, 0.07722617f, 0.32468605f, -0.33157995f, 0.14449902f, 0.03785558f, 0.09011452f, 
    0.04558694f, 0.07469568f, -0.51319605f, -0.01790821f, -0.31528276f, 0.04169768f, -0.19111870f, 0.02595858f, 
    -0.25961903f, -0.20581347f, 0.13482530f, 0.21454869f, 0.29533851f, 0.24164078f, 0.07230744f, 0.11434559f, 
    0.10658055f, 0.15523034f, -0.41373602f, 0.15927817f, -0.21124113f, 0.26336402f, 0.18730208f, 0.16043296f, 
    -0.01849286f, 0.14372814f, -0.05645062f, 0.07398441f, -0.30691466f, -0.10929956f, 0.23311414f, -0.41001323f, 
    0.25909063f, -0.07135431f, 0.02507939f, 0.08066888f, -0.01185773f, -0.03676900f, -0.37821871f, -0.08487708f, 
    0.10435888f, -0.61096787f, -0.24950473f, -0.18581147f, 0.03581323f, 0.03227202f, -0.08010025f, 0.18656099f, 
    -0.03916453f, 0.18670921f, -0.01488467f, -0.48747161f, -0.04007738f, 0.01460669f, 0.09187993f, -0.00813679f, 
    0.05377143f, -0.11495291f, 0.00848195f, -0.06700252f, -0.34645584f, -0.13931948f, -0.00064622f, -0.09729235f, 
    -0.19706456f, -0.37884793f, 0.20687123f, -0.11944910f, 0.15431379f, 0.23939915f, -0.02901570f, -0.01603428f, 
    -0.00405186f, -0.13816760f, 0.02676693f, 0.23235491f, 0.15550831f, -0.09033298f, -0.02685537f, -0.39163107f, 
    -0.15797737f, -0.31952751f, 0.19917746f, -0.01066234f, -0.01046581f, 0.20957668f, 0.20276669f, -0.21864426f, 
    -0.22738105f, 0.21724197f, -0.13740526f, -0.14649320f, 0.00958299f, -0.05075417f, -0.06641077f, -0.00100131f, 
    0.15094659f, -0.25806016f, -0.36843827f, 0.02360250f, -0.20205775f, -0.00874382f, -0.25552768f, -0.02352372f, 
    0.10990871f, -0.29764110f, -0.13999389f, 0.07403817f, -0.53395718f, -0.15571399f, 0.36224532f, -0.04692421f, 
    0.16418935f, 0.16100721f, 0.03937455f, -0.02442773f, -0.06961600f, -0.05583692f, -0.05754782f, -0.10988698f, 
    0.12020366f, -0.45380059f, -0.04272551f, 0.02685587f, -0.02548744f, 0.03837322f, -0.01193773f, -0.05831366f, 
    -0.07271276f, -0.36397320f, -0.28535929f, 0.04822498f, -0.14492422f, -0.09816555f, 0.22474141f, 0.00864769f, 
    -0.12886210f, -0.10054662f, 0.07473611f, 0.08026052f, -0.08601061f, -0.11783449f, -0.02207196f, 0.12102626f, 
    0.01705650f, 0.01390180f, 0.16215558f, 0.14409594f, -0.06449430f, 0.06968622f, -0.31501594f, 0.00812331f, 
    0.04002553f, 0.15730043f, 0.11092185f, -0.06509446f, 0.23111343f, -0.05873863f, -0.37322986f, -0.45047504f, 
    0.17591399f, 0.01122137f, -0.06095668f, -0.01991184f, 0.25684687f, -0.00346194f, -0.16401064f, -0.13485855f, 
    -0.10307808f, -0.30834979f, 0.17019171f, -0.13621730f, 0.03460021f, -0.25528970f, -0.09740909f, 0.12134688f, 
    -0.03830842f, -0.21980877f, -0.09106974f, -0.37799445f, -0.04480128f, -0.03048031f, 0.23375385f, 0.08645380f, 
    -0.01195412f, 0.07616251f, -0.02982536f, -0.17264408f, -0.50179714f, -0.08439731f, -0.09298689f, 0.24371186f, 
    0.19592805f, -0.51938546f, 0.13865609f, -0.07133920f, 0.18497735f, -0.11522273f, -0.04846795f, 0.07423621f, 
    0.10237443f, 0.23780817f, 0.04698187f, -0.35945848f, 0.21870069f, 0.05493553f, -0.00487845f, -0.03869230f, 
    0.21330705f, -0.09650575f, -0.33448863f, 0.06467224f, 0.05078334f, 0.12948391f, 0.16955489f, -0.09229866f, 
    -0.16570707f, -0.03277845f, -0.36808270f, -0.03088935f, 0.07197429f, -0.20354015f, 0.02615944f, 0.28999406f, 
    0.03393292f, -0.56526899f, -0.30343083f, 0.07008401f, -0.01465594f, -0.03083309f, -0.04733475f, -0.16474773f, 
    -0.39114437f, 0.16311499f, -0.14861016f, -0.38227144f, -0.29018739f, -0.25061896f, -0.36424416f, -0.09675653f, 
    0.29523882f, -0.21868016f, 0.04283682f, -0.04231406f, 0.01025422f, 0.12554196f, -0.02787790f, 0.09288665f, 
    -0.61624789f, -0.31529292f, -0.02443621f, -0.20394967f, 0.12336615f, -0.10134586f, -0.08829544f, -0.40152147f, 
    -0.07625991f, 0.24410617f, -0.52288854f, -0.02690492f, 0.30177864f, -0.03666674f, -0.16833457f, -0.02371804f, 
    -0.03495856f, 0.07037273f, 0.07882208f, -0.25417143f, 0.07572544f, 0.21701758f, 0.00377610f, -0.04049543f, 
    -0.02402394f, -0.11435923f, 0.40212053f, 0.09119435f, -0.17612535f, 0.21249072f, -0.53436756f, 0.28082436f, 
    0.03114795f, -0.21067007f, -0.24054201f, -0.03429589f, -0.37833518f, 0.02852873f, -0.17124970f, 0.16760606f, 
    0.03430707f, -0.02611457f, -0.02634909f, -0.07955859f, -0.13774957f, 0.02390151f, -0.08628649f, -0.03591874f, 
    -0.24966013f, -0.17872533f, -0.35576814f, 0.00725274f, 0.06817801f, -0.21817935f, -0.03639869f, -0.02259636f, 
    0.06302612f, -0.25527439f, 0.02212750f, -0.47336659f, 0.03193543f, 0.06452516f, -0.48753926f, 0.07798789f, 
    -0.03875387f, -0.04430435f, -0.03479762f, 0.03292552f, 0.18182619f, -0.01707493f, -0.09840181f, 0.17169312f, 
    -0.23816967f, -0.04195278f, -0.16417697f, 0.08137181f, -0.09290577f, 0.13724110f, 0.07240181f, 0.06620859f, 
    0.05899024f, 0.14548424f, 0.05260372f, 0.13274646f, 0.15714450f, 0.18980634f, -0.01921517f, 0.09746008f, 
    -0.24607456f, 0.23071223f, -0.13982171f, 0.07231900f, -0.23495027f, 0.22272828f, -0.10752600f, 0.16060437f, 
    -0.09941421f, 0.40714574f, 0.26185411f, -0.35753056f, -0.09226989f, 0.34890506f, 0.03856263f, 0.14624061f, 
    0.13809162f, 0.03147512f, 0.19141331f, -0.02642772f, 0.11039145f, 0.12025532f, -0.00033301f, 0.05387758f, 
    0.30198821f, -0.22884457f, 0.01006087f, 0.15985470f, -0.30016267f, -0.24983227f, 0.07016414f, 0.00034992f, 
    -0.08464742f, -0.17811918f, 0.07540274f, -0.08540046f, -0.00901234f, -0.15329015f, -0.06207866f, -0.21572444f, 
    0.28433278f, -0.09108374f, -0.00116330f, -0.17177017f, -0.23952584f, 0.32165414f, 0.01164357f, 0.20928134f, 
    -0.09044909f, -0.46908805f, -0.01472423f, 0.00731249f, -0.01840870f, 0.00482388f, 0.16695738f, 0.06327587f, 
    0.19188093f, -0.51616073f, 0.00622228f, -0.16044657f, -0.18357278f, 0.07083872f, -0.08420438f, -0.05319852f, 
    -0.00425603f, 0.06896634f, -0.40146348f, -0.03199841f, -0.22528599f, -0.39049110f, 0.20718202f, 0.21148561f, 
    0.08280417f, -0.06613287f, -0.04692607f, -0.06727162f, 0.35012150f, -0.07958581f, 0.27170229f, 0.00778029f, 
    -0.45205852f, -0.03584692f, -0.02883208f, 0.06567042f, -0.08320183f, 0.02826278f, 0.26786143f, -0.07774959f, 
    0.42910323f, -0.02035561f, -0.14502585f, -0.28876936f, 0.07529629f, 0.31190702f, -0.08917893f, -0.22859614f, 
    -0.00805684f, 0.38480005f, 0.05934523f, 0.21269698f, 0.06204949f, -0.00875518f, -0.04132592f, -0.07563214f, 
    -0.02997714f, -0.09363075f, 0.33403462f, -0.58018380f, -0.11336228f, -0.25766051f, -0.03119043f, 0.25265414f, 
    0.28235644f, -0.27786171f, -0.26919901f, 0.08791935f, -0.30240670f, -0.52263808f, -0.06927352f, -0.00904079f, 
    0.25429821f, -0.11638948f, 0.04059003f, -0.16934516f, -0.03498250f, 0.08734149f, -0.02108930f, 0.14302559f, 
    0.20034219f, -0.23887387f, 0.02767120f, -0.03061370f, -0.10534898f, 0.03185727f, -0.31628934f, -0.03781662f, 
    0.03206318f, -0.15295717f, -0.04915963f, -0.39802209f, -0.12207052f, 0.09816188f, -0.06314422f, -0.03241628f, 
    0.26859078f, -0.00420328f, -0.37279683f, -0.05916798f, 0.10066000f, -0.55111611f, 0.17530006f, -0.05838229f, 
    -0.04601212f, 0.22445138f, 0.09062113f, -0.32165468f, -0.00806749f, -0.38575375f, -0.30626076f, 0.30937821f, 
    -0.44346091f, -0.18703803f, -0.02228122f, 0.05357562f, -0.06827576f, -0.01729797f, 0.08653591f, 0.01499555f, 
    -0.26015097f, -0.37915188f, 0.01583247f, -0.12828514f, -0.10459197f, -0.32854503f, 0.09366212f, -0.00770015f, 
    -0.04791240f, 0.25198925f, 0.08479246f, -0.05387583f, 0.25395182f, 0.02204729f, 0.31891423f, -0.05622143f, 
    0.28212416f, 0.13971800f, 0.06250820f, -0.30917323f, 0.05157162f, -0.00673578f, 0.01274813f, 0.03869993f, 
    -0.02893541f, -0.37636665f, -0.03382201f, 0.08082711f, -0.30732062f, 0.29602998f, -0.01666129f, -0.47595918f, 
    0.05582962f, -0.02823044f, -0.10060339f, -0.04570909f, -0.25890133f, -0.32427728f, 0.13894521f, -0.54609352f, 
    -0.13118641f, 0.05931474f, -0.05007919f, 0.01734142f, 0.15747824f, -0.01757948f, 0.32916933f, 0.12253959f, 
    0.15801294f, -0.29918867f, 0.34515217f, 0.19656183f, 0.07262969f, -0.15612365f, -0.01341605f, 0.24257039f, 
    -0.06473991f, 0.09663007f, -0.01630999f, 0.56383687f, 0.07525928f, -0.00818230f, 0.13097587f, -0.00875462f, 
    0.03224397f, -0.10923392f, -0.17934220f, -0.19492021f, -0.24657395f, 0.11679428f, -0.02120519f, -0.13993707f, 
    -0.23609160f, -0.14051156f, -0.21959040f, 0.33029240f, 0.20192084f, -0.31537783f, 0.00703201f, -0.07069524f, 
    0.03669767f, 0.10923538f, 0.05087825f, 0.11709009f, -0.00038553f, -0.44801480f, 0.04527917f, 0.45123270f, 
    0.10145691f, -0.13657123f, -0.03540513f, -0.06791322f, 0.21026206f, -0.12103607f, -0.23907545f, 0.21114899f, 
    -0.10460761f, -0.61673266f, -0.52429581f, -0.32552084f, 0.11729121f, -0.13843288f, 0.00805251f, 0.01396274f, 
    -0.08097722f, 0.20441766f, -0.30525932f, -0.05261553f, -0.13370997f, -0.15974407f, 0.09694187f, -0.00714873f, 
    0.00003857f, 0.29108113f, -0.23092146f, 0.25857058f, -0.15156783f, -0.22198166f, -0.26474482f, -0.29296288f, 
    -0.16662669f, -0.20865966f, 0.02121110f, 0.02277137f, 0.03177902f, 0.18778996f, 0.04737127f, 0.21133046f, 
    0.12903333f, -0.32624578f, -0.02789053f, 0.23490074f, -0.37333661f, -0.05980948f, 0.03581591f, -0.39902875f, 
    0.03767442f, -0.57018155f, -0.10910644f, -0.01667761f, -0.07624686f, 0.04074097f, -0.15078138f, 0.03160166f, 
    -0.17243697f, -0.07660385f, 0.16407551f, -0.32914945f, -0.06908443f, 0.02048604f, -0.02821870f, -0.14269942f, 
    -0.03335408f, 0.04483109f, -0.05972040f, 0.19076042f, -0.10156017f, -0.41768241f, 0.17078450f, -0.01852546f, 
    0.00548315f, 0.10115886f, 0.00391122f, -0.02557898f, 0.22745959f, 0.12955554f, -0.27786639f, 0.14740232f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14086592f, 0.07852602f, 0.03780910f, -0.15482184f, -0.13575433f, -0.00721880f, -0.02642000f, -0.09475518f, 
    0.17447677f, 0.05338930f, -0.02070646f, 0.04675087f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
