#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.95153117f, 0.54156697f, -0.17775166f, -0.00497660f, -0.70796722f, 0.31918880f, 0.44328076f, -0.07249539f, 
    -0.22130594f, -0.11364795f, 0.62864017f, -0.26503909f, -0.13581227f, -0.25350899f, 0.59525663f, -0.45555317f, 
    -0.14578222f, -0.68156898f, 0.08926553f, 0.37960929f, 0.43171793f, 0.59742564f, 0.47442293f, 0.52272642f, 
    0.17158721f, -0.46485549f, -0.00441786f, 0.93642443f, 0.83921051f, -0.29156509f, 0.25812998f, 0.32933208f, 
    -0.51488906f, 0.06664170f, -0.24771160f, -0.37251669f, -1.10304654f, 0.44394800f, -0.04598541f, 0.67977083f, 
    0.13626979f, -0.15354444f, 0.27545071f, 0.24554327f, -0.35624665f, -0.83974427f, -0.59321165f, -0.60438806f, 
    -0.29012635f, -0.27920842f, 0.56998372f, -0.33378291f, 0.27500886f, -0.06138420f, 0.70603400f, 0.29309267f, 
    0.37201336f, -0.87649453f, -1.24553311f, -0.36115232f, -0.22187673f, -0.15928139f, 0.51529574f, -0.52792662f, 
    -0.52028692f, -0.82174748f, -0.28830102f, 0.38900116f, -0.16057993f, 0.37917247f, -0.00165768f, 0.13836126f, 
    -0.84673166f, -0.54008305f, -0.04820381f, -0.36989063f, -0.13736816f, 0.39625040f, 0.34894043f, 0.16553721f, 
    0.34518501f, 0.75133336f, 0.15952545f, 0.53360826f, 0.50053483f, -0.46911901f, -0.29943407f, 0.43704528f, 
    0.50484562f, -0.02650190f, 0.77934813f, -0.36888278f, 0.41177562f, 0.79157829f, 0.34033710f, 0.05594930f, 
    -0.18073876f, -0.20087646f, -0.44628626f, -0.64824337f, -0.15822622f, -0.29522505f, 0.12485674f, 0.59080029f, 
    0.38754737f, -0.06469603f, -0.09380259f, -0.70735735f, 0.12000939f, -0.78843021f, -0.16085990f, -0.95614922f, 
    -0.15590176f, -0.01542900f, 0.47153658f, 0.58353901f, 0.28246894f, -0.26577178f, -0.36294812f, -0.70799309f, 
    -0.30642942f, 0.34699896f, 0.66843218f, 0.27838066f, -0.01805013f, 0.57163882f, 1.01394880f, -0.75977832f, 
    -0.56154519f, -0.09160742f, -0.40223807f, 0.05596127f, -0.34220445f, -0.05862382f, -0.00961004f, 0.65909421f, 
    0.45424709f, -0.78024536f, 0.83378333f, 0.36433178f, 0.00821927f, 0.07987812f, 0.26304877f, 0.12072703f, 
    0.55736506f, 0.00798574f, 0.18363163f, -1.00442016f, -0.14467040f, -0.83477378f, 0.09174348f, 0.23145589f, 
    0.10650089f, -0.04786183f, -0.01758525f, -0.26232386f, 0.83727819f, -0.75554067f, 0.09441568f, -0.18745597f, 
    -0.48089814f, 0.66859156f, 0.50664753f, 0.21842003f, -0.33234176f, -0.29798275f, 0.79705226f, 0.43517384f, 
    0.28587568f, 0.27989411f, -0.49681625f, 0.56548327f, -0.90361041f, -0.45276454f, -0.46187380f, -0.39587936f, 
    -0.04626843f, 0.09022418f, 0.20124161f, 0.37410900f, -0.41362137f, -0.92059797f, 0.06032040f, 0.55352914f, 
    -0.08082832f, 0.76878601f, -0.12737024f, -0.11379915f, 0.33279768f, -0.32137695f, -0.47214469f, -0.64842874f, 
    0.23958865f, -0.49900579f, -0.14120269f, -0.33306503f, -0.08608654f, -0.46304929f, 0.56108505f, 0.43595257f, 
    0.33880192f, 0.16276805f, 0.19701304f, 0.42195651f, -0.12779620f, 0.40583313f, 0.38875476f, -0.71178132f, 
    0.20258415f, -0.41376120f, 0.45311862f, 0.74677473f, 0.26106232f, -0.26391295f, -0.47166920f, 0.21163413f, 
    0.17017740f, 0.28766274f, 0.49303111f, -0.55709004f, 0.51528424f, -0.08726027f, 0.16911604f, 0.66754723f, 
    0.09606249f, -0.54671401f, -0.42488512f, -0.63130736f, 0.22771271f, -0.22429526f, 0.48709294f, -0.23034705f, 
    -0.16011065f, -0.20241094f, 0.74656481f, 0.84347987f, 0.92653191f, -0.45461428f, 0.47470850f, -0.23023219f, 
    -0.13209175f, 0.06624342f, 0.01867889f, -0.12555157f, -0.76810253f, -0.29757965f, 0.71168250f, 1.01441109f, 
    0.08505011f, -0.17584868f, -0.13376936f, -0.05185769f, -0.31884998f, 0.17110665f, 0.54499209f, -0.72120601f, 
    -0.19166271f, -0.79356837f, -0.01609250f, -0.25745392f, -0.71332449f, -1.01457000f, 0.16843498f, 0.82806134f, 
    0.44279584f, 0.63342285f, -0.23471022f, 0.24110834f, 0.38640031f, 0.22920133f, -1.07620275f, 0.87748665f, 
    -0.27402961f, -0.35127994f, -0.04254382f, 0.04463968f, 0.23078910f, 0.13250726f, 0.44701731f, 0.11674868f, 
    -0.34871301f, -0.57725400f, -0.22894810f, -0.36462316f, -0.58584625f, -0.62047791f, -0.29210126f, 0.27986223f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.22440401f, 0.04983722f, 0.15773173f, -0.16408020f, -0.02202564f, 0.05094065f, -0.02638674f, 0.09069290f, 
    0.04645769f, -0.19297929f, 0.11168624f, 0.00564525f, 0.08245918f, 0.06729221f, -0.04636896f, -0.01459025f, 
    0.06732772f, -0.35543728f, -0.30482420f, -0.16841973f, -0.11104096f, -0.33505943f, 0.39174122f, -0.20484991f, 
    -0.02954653f, -0.16305345f, 0.06579964f, -0.21359397f, -0.22634223f, -0.26213673f, -0.01090191f, -0.00504860f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05247452f, 0.02412269f, 0.16521312f, -0.05453442f, -0.18646772f, -0.07506970f, -0.06389837f, -0.09769584f, 
    0.01176282f, 0.06588145f, 0.08715085f, 0.13169987f, 0.03877499f, -0.06660080f, -0.13124374f, 0.17612846f, 
    0.03697004f, 0.02131468f, 0.06354309f, 0.14216559f, 0.09744056f, -0.05723426f, 0.03256002f, -0.08280379f, 
    0.10025796f, 0.05162957f, -0.04639244f, -0.10491823f, 0.00744066f, 0.15880980f, -0.16948356f, -0.09024837f, 
    -0.12845014f, 0.04580044f, -0.08314628f, 0.06408773f, -0.04417492f, -0.01916169f, 0.07812321f, 0.05723005f, 
    0.06068910f, -0.05716860f, -0.08889391f, 0.06757697f, 0.04550537f, -0.29231253f, 0.12931949f, -0.20993738f, 
    0.15548156f, 0.16141638f, -0.02613121f, 0.07749207f, 0.08500274f, 0.10518510f, 0.13235717f, 0.08343221f, 
    0.25197572f, -0.17051916f, -0.04089522f, 0.09233991f, -0.38961822f, 0.10849156f, 0.27060252f, -0.20488912f, 
    0.08492863f, 0.18395165f, 0.11422972f, 0.11090039f, 0.01048508f, 0.01755971f, -0.03667590f, -0.16340207f, 
    -0.13647658f, -0.07661343f, -0.06864398f, 0.11465163f, -0.01457847f, 0.09798523f, 0.09738605f, 0.00873135f, 
    -0.00036822f, -0.08106157f, -0.10515656f, 0.07965555f, -0.17572743f, 0.00036189f, 0.05699172f, 0.10689839f, 
    0.00222885f, 0.08976149f, 0.05668532f, 0.12157391f, 0.11044432f, -0.15514298f, -0.11960416f, 0.03612262f, 
    0.12968563f, 0.03108061f, 0.05617728f, 0.24720491f, 0.31375623f, -0.25487691f, 0.02298212f, 0.15315957f, 
    0.01531308f, 0.10191929f, -0.15615678f, 0.10242320f, -0.20334394f, -0.13032581f, 0.02938425f, 0.16401850f, 
    0.01713791f, 0.03221919f, 0.10135367f, -0.02520118f, -0.09090186f, -0.17176691f, 0.03869125f, -0.04440955f, 
    0.02674622f, 0.00750014f, -0.01675093f, 0.12191049f, -0.05465968f, -0.09012306f, 0.27465037f, -0.35141277f, 
    0.15855770f, -0.10291200f, 0.00458850f, -0.04680339f, -0.10722496f, 0.01135315f, 0.16097933f, 0.03771228f, 
    -0.15538540f, -0.19630979f, -0.05008865f, -0.03749971f, -0.06293347f, -0.06343540f, -0.00408804f, 0.04426425f, 
    0.05632702f, -0.05877249f, 0.19293554f, -0.10796285f, 0.04222829f, 0.00340634f, -0.24686520f, 0.05599728f, 
    0.12587023f, -0.05792003f, -0.23736808f, -0.05184597f, 0.16371465f, 0.08491097f, -0.25837010f, -0.05012556f, 
    0.15794557f, -0.09870021f, -0.47385025f, -0.18444873f, -0.13298750f, 0.01325989f, -0.16299258f, -0.35136431f, 
    -0.05853872f, -0.07043995f, 0.01822267f, -0.12112062f, -0.29028124f, 0.22972786f, 0.17806309f, 0.19620979f, 
    0.01366413f, 0.03015965f, -0.01992754f, 0.16482840f, 0.04948465f, 0.07939138f, -0.06900489f, 0.13892825f, 
    0.14948440f, -0.22204085f, -0.02851747f, 0.07084209f, 0.12448011f, 0.03268488f, -0.06659281f, -0.06988943f, 
    0.07849301f, 0.04562872f, -0.03422473f, -0.07012457f, 0.02458598f, 0.06935972f, -0.07643175f, 0.09871726f, 
    -0.07278398f, 0.02520415f, 0.06054561f, -0.07153063f, 0.11484342f, -0.09763815f, 0.00700736f, 0.42269525f, 
    0.15777464f, -0.03136979f, 0.08271690f, 0.07352629f, -0.19457245f, 0.06922206f, -0.05136121f, -0.02264749f, 
    -0.10909993f, -0.18103468f, -0.05294239f, -0.03464249f, -0.15686356f, -0.05492693f, -0.00703794f, -0.07833927f, 
    0.05364420f, 0.08187984f, 0.21726294f, -0.27362978f, 0.10078374f, 0.12205553f, -0.04448199f, -0.02532141f, 
    0.11737593f, 0.09391077f, -0.09317297f, 0.01577055f, 0.02697894f, -0.20653544f, 0.02587483f, -0.03254177f, 
    -0.16035248f, -0.05742466f, 0.15409093f, 0.03666054f, 0.19291747f, -0.23380169f, -0.02104706f, 0.03344695f, 
    -0.06390949f, 0.03505537f, -0.11047699f, -0.00100144f, -0.03763777f, 0.00426872f, 0.07372682f, 0.10439890f, 
    0.20194410f, -0.15966979f, -0.05293549f, 0.17011939f, 0.02786713f, -0.08860222f, -0.04052353f, 0.51875675f, 
    0.07949009f, -0.07816226f, -0.03258973f, -0.15371755f, -0.09660103f, 0.05115940f, -0.16770816f, -0.37508824f, 
    0.07889143f, 0.10990559f, -0.13288906f, 0.01848048f, 0.00098158f, -0.07022953f, -0.00409871f, 0.01133569f, 
    -0.14415038f, -0.06388634f, 0.01113875f, -0.14807527f, 0.19012721f, 0.00186172f, 0.02644866f, 0.11680937f, 
    0.26963788f, -0.27139503f, -0.29831886f, 0.02142229f, 0.05706139f, 0.12878114f, -0.09223686f, 0.01814150f, 
    -0.01266159f, -0.07645384f, -0.20482938f, 0.00848781f, 0.00780004f, 0.17448536f, -0.02020030f, -0.01265819f, 
    -0.19242881f, 0.20087475f, -0.20304768f, -0.05311714f, 0.18898781f, 0.05618504f, -0.02931810f, -0.01110774f, 
    0.03664860f, -0.04578219f, -0.00397237f, 0.17976323f, -0.16342628f, -0.26634675f, 0.03057651f, -0.04270244f, 
    -0.05354037f, -0.17947443f, 0.08041890f, 0.10906484f, 0.23572388f, 0.06931683f, -0.00195140f, -0.06989247f, 
    -0.05885355f, -0.08935991f, -0.01741484f, 0.03518228f, 0.06514838f, -0.14163938f, 0.22438437f, 0.06023285f, 
    -0.16381982f, -0.07218412f, -0.04113752f, -0.03879642f, 0.13363704f, -0.05470582f, 0.24563749f, -0.35017103f, 
    -0.09891894f, 0.01087413f, -0.01557896f, -0.06064941f, 0.08637005f, -0.07465571f, 0.02609003f, 0.00622715f, 
    0.10653304f, -0.14279722f, -0.02461687f, -0.03790777f, 0.04978644f, -0.05554719f, 0.08411876f, -0.10140169f, 
    -0.25473106f, 0.12124363f, -0.02984512f, -0.09893763f, -0.15386656f, -0.10355978f, -0.05663894f, 0.02908945f, 
    0.17033367f, -0.05840982f, -0.42868567f, 0.00462733f, 0.06207753f, 0.03698287f, 0.16638352f, -0.04397825f, 
    -0.00190097f, -0.10354272f, -0.14310291f, -0.07466060f, -0.08570094f, -0.04463074f, 0.09809297f, -0.15650223f, 
    -0.10455593f, -0.00799081f, 0.06072690f, 0.06325195f, 0.17701022f, 0.11017280f, -0.06333291f, -0.01350759f, 
    -0.04329445f, 0.01140110f, 0.01436883f, 0.05283977f, -0.09297784f, 0.08121169f, -0.02252231f, -0.10448758f, 
    -0.01134904f, -0.08374871f, 0.01780587f, -0.06679295f, 0.13084203f, -0.00604949f, 0.02825595f, -0.19210534f, 
    -0.01825284f, -0.08814449f, 0.01118102f, 0.03044809f, 0.13606864f, 0.01471934f, 0.29000080f, 0.26386812f, 
    -0.16819359f, -0.07530819f, 0.05686573f, -0.10937001f, 0.00422442f, 0.08278353f, 0.07101405f, 0.15853277f, 
    0.07763439f, 0.05115410f, 0.09735484f, -0.14620976f, -0.16210833f, -0.22091000f, 0.05018890f, 0.12478786f, 
    -0.02208799f, -0.06546371f, 0.00351907f, 0.05302581f, -0.06279719f, -0.10528424f, 0.08484224f, -0.10632161f, 
    0.02143101f, 0.34869662f, -0.10026496f, -0.02715601f, 0.05201947f, 0.08299770f, 0.17741442f, 0.13044395f, 
    0.07354833f, -0.04211796f, 0.11444002f, -0.21276289f, 0.16597180f, -0.04515523f, -0.20078924f, -0.06380656f, 
    0.03098319f, -0.02001366f, -0.07241298f, 0.27863461f, 0.26250890f, -0.22469172f, -0.10819770f, -0.11574420f, 
    -0.02563526f, 0.05231603f, 0.07244153f, 0.17048901f, 0.22056714f, 0.12403759f, 0.08201349f, 0.07771201f, 
    0.02097510f, -0.05643690f, -0.06557155f, 0.12980901f, -0.01514027f, 0.00150540f, 0.23277543f, -0.02571072f, 
    -0.07889090f, 0.05041295f, -0.07476851f, -0.00821198f, -0.01991289f, -0.05044306f, 0.02508242f, -0.05160394f, 
    0.09145491f, -0.03675693f, 0.02531287f, -0.02984080f, 0.03794557f, 0.11345847f, 0.06147716f, -0.05653869f, 
    0.17459111f, -0.00240778f, 0.04024207f, -0.06389236f, 0.04653526f, -0.03765273f, -0.01722321f, 0.13279459f, 
    -0.12715508f, 0.03138388f, -0.04276552f, 0.06807844f, -0.06932467f, 0.09325022f, -0.09885886f, 0.02155939f, 
    0.07076196f, 0.03016256f, 0.31312579f, 0.13592577f, -0.07890823f, -0.02901257f, 0.21819325f, -0.05400192f, 
    0.17845751f, 0.00165165f, -0.21164998f, -0.31025615f, 0.06799426f, 0.07663463f, -0.06748967f, 0.12860765f, 
    -0.00628419f, 0.06021191f, -0.03302717f, -0.10717127f, 0.10919731f, 0.07941540f, -0.08007381f, -0.04625089f, 
    0.05158137f, -0.12741058f, 0.20530136f, 0.01371335f, -0.14882605f, 0.05123048f, 0.15414724f, 0.19247724f, 
    0.03499146f, 0.05008454f, -0.12428671f, 0.06643852f, 0.12688300f, -0.15083593f, 0.13338652f, 0.18591160f, 
    -0.07916588f, -0.16345222f, 0.08687058f, -0.02738207f, -0.09984283f, -0.00123617f, 0.35678670f, 0.12113798f, 
    0.03315991f, -0.05941178f, -0.01071739f, -0.11115553f, -0.00862727f, 0.02556884f, 0.02236872f, 0.13051525f, 
    0.08513872f, -0.10121159f, -0.12064727f, -0.18092109f, 0.04757696f, 0.08052467f, 0.02456279f, -0.15647735f, 
    0.32424614f, 0.00997912f, -0.04689768f, 0.15995590f, 0.05646705f, -0.05911692f, -0.02794953f, 0.14815257f, 
    0.01856120f, 0.03594218f, 0.16624999f, -0.06605769f, 0.12561852f, 0.19094694f, 0.01155398f, -0.06358873f, 
    -0.13056575f, -0.10953587f, -0.09571463f, -0.42500815f, 0.01646191f, 0.12226800f, 0.15983731f, 0.09404211f, 
    -0.04667911f, 0.05827157f, -0.04487987f, 0.41846406f, 0.14722686f, 0.03760998f, 0.01203907f, 0.11143541f, 
    0.03354449f, 0.00075343f, -0.00479404f, 0.16415946f, -0.39332408f, -0.16959795f, 0.13902767f, -0.04022083f, 
    0.08210743f, 0.13818620f, -0.17878672f, -0.01655549f, 0.02346857f, 0.00832557f, 0.29388252f, -0.20956273f, 
    0.05843392f, 0.02819422f, 0.05004690f, -0.04067466f, 0.02316447f, 0.00170681f, 0.37893808f, 0.37861884f, 
    -0.01538047f, 0.05822585f, -0.17245840f, -0.03872309f, 0.02286172f, 0.05841557f, 0.04099320f, 0.00222998f, 
    0.03107536f, 0.08924212f, -0.13632700f, 0.02824980f, 0.02235457f, -0.19418812f, -0.11692503f, 0.06882296f, 
    -0.29954234f, 0.05666052f, -0.02353465f, 0.03819958f, 0.07953180f, 0.08787525f, -0.01178445f, 0.00784438f, 
    -0.00016791f, 0.38899764f, -0.24720584f, -0.14947769f, 0.25217518f, -0.09509575f, -0.08307449f, 0.11366285f, 
    0.14065558f, 0.10631726f, -0.29532856f, -0.31315857f, -0.22668077f, 0.07655621f, 0.17450845f, -0.03469007f, 
    0.00761990f, -0.00317020f, 0.04054383f, -0.28250477f, 0.10574106f, -0.02761525f, -0.03853559f, -0.05210716f, 
    0.04311370f, -0.20921756f, 0.05598295f, -0.07097733f, -0.25089666f, 0.00383548f, -0.14338697f, 0.00989199f, 
    0.01364702f, 0.10545522f, 0.02606395f, 0.12228249f, -0.12209640f, -0.19050150f, -0.01326667f, 0.06872202f, 
    -0.00740224f, 0.07389122f, 0.11052428f, -0.05277417f, -0.06740054f, 0.00724576f, -0.09308726f, 0.05881890f, 
    -0.01858713f, -0.11861371f, -0.23047753f, -0.08892227f, -0.04198498f, 0.19562247f, 0.07966032f, 0.04590147f, 
    -0.20171425f, 0.15494424f, 0.18469834f, 0.11863430f, -0.10190200f, -0.05946245f, -0.05663654f, -0.02364722f, 
    0.14276445f, 0.18003316f, -0.16195613f, 0.07900853f, -0.09227940f, -0.06453132f, 0.01696145f, 0.00209154f, 
    0.03205119f, 0.05168468f, -0.34443820f, -0.09541657f, 0.03547329f, 0.13584273f, 0.09099531f, -0.04499474f, 
    0.15125212f, -0.15083711f, -0.14926685f, 0.03085761f, -0.03049389f, 0.07899477f, 0.11723212f, -0.09845801f, 
    -0.03119122f, -0.00723342f, 0.14552622f, -0.15457231f, -0.12313379f, 0.04295148f, 0.03756703f, -0.20735228f, 
    -0.16918840f, 0.11160976f, 0.23006807f, -0.06503145f, -0.36013705f, 0.06526890f, -0.03463044f, 0.04849464f, 
    0.07384358f, 0.11250446f, 0.14067999f, -0.06964016f, 0.00781867f, 0.16688141f, 0.05964894f, -0.10780717f, 
    -0.12782405f, -0.06738341f, 0.17302752f, -0.12199254f, 0.11640848f, 0.05662398f, 0.17843208f, -0.01930130f, 
    0.03217122f, 0.13613735f, -0.09533528f, 0.05953007f, -0.02556104f, 0.07316249f, -0.12622374f, -0.08424100f, 
    -0.21021691f, 0.09148132f, 0.05483172f, 0.06721821f, 0.06353988f, -0.13440785f, 0.02502048f, -0.03171340f, 
    0.36159155f, 0.01506114f, -0.14394371f, -0.06273834f, 0.06722736f, 0.17130058f, -0.02472383f, 0.09851516f, 
    0.00214455f, 0.17230029f, 0.24430710f, -0.16595368f, 0.06401990f, 0.00783169f, -0.02087341f, 0.06268742f, 
    0.02932318f, 0.10363463f, 0.55468458f, 0.25760654f, 0.00572351f, -0.06073601f, -0.05475641f, 0.00280107f, 
    0.06168135f, -0.01802764f, 0.07979424f, -0.09021247f, -0.17432898f, -0.08075061f, 0.00649803f, 0.08067185f, 
    0.17068660f, -0.16049650f, 0.02708429f, 0.07082544f, 0.18996218f, -0.12103043f, -0.34391329f, 0.03712623f, 
    0.11550757f, 0.12347355f, 0.01627997f, 0.02643003f, 0.10468825f, 0.08615343f, -0.06944212f, -0.15819909f, 
    -0.05647597f, 0.00815934f, 0.01040721f, -0.04177185f, 0.00613688f, 0.04685269f, -0.34130621f, -0.08309323f, 
    0.19359492f, -0.18331677f, 0.12976587f, -0.01293225f, 0.12712179f, -0.06306264f, -0.11027237f, -0.03469963f, 
    0.01548035f, -0.11106685f, 0.04839013f, 0.13575654f, -0.08292853f, 0.02048179f, 0.06696686f, -0.01849370f, 
    -0.13753998f, -0.13556488f, -0.22914182f, 0.00994728f, 0.08631072f, -0.18628183f, -0.02013648f, 0.01742185f, 
    -0.14695980f, 0.07387425f, -0.01949268f, -0.02816110f, -0.03635563f, 0.16603892f, -0.02957784f, 0.05335128f, 
    -0.09941057f, -0.04931591f, -0.00130877f, -0.07392530f, 0.13528317f, 0.11432763f, 0.03926974f, 0.10439882f, 
    0.02324148f, -0.01223376f, -0.03943830f, -0.07558638f, 0.16401282f, 0.02429231f, 0.11398460f, -0.00449029f, 
    -0.04491207f, -0.00137305f, 0.09752037f, -0.06973712f, 0.19931199f, 0.08337910f, -0.15167668f, -0.05051559f, 
    -0.03867164f, 0.08827432f, 0.04181765f, 0.02995108f, 0.02005211f, -0.01940943f, 0.02500017f, 0.02505925f, 
    0.13836080f, -0.02767894f, 0.03391169f, 0.03924564f, 0.02978705f, 0.00413553f, 0.06854454f, -0.23745640f, 
    0.16369833f, -0.04378696f, -0.02379268f, -0.22988527f, 0.05243506f, 0.19808410f, -0.04077525f, 0.11468993f, 
    -0.04089540f, 0.02755934f, 0.11736991f, -0.04799746f, -0.00945554f, 0.11266851f, -0.08097772f, 0.06601609f, 
    0.10863523f, 0.09094710f, -0.10523511f, 0.04818869f, 0.01152820f, -0.03173432f, 0.13251457f, 0.01746795f, 
    0.06910667f, -0.33972871f, -0.21181764f, 0.04776965f, 0.04650496f, -0.02331365f, 0.03353208f, -0.17707798f, 
    -0.12990636f, -0.06375892f, -0.00269957f, 0.15314794f, -0.22612526f, 0.21733119f, 0.00696279f, -0.04570314f, 
    0.05915771f, 0.00469131f, -0.09199570f, 0.00623668f, 0.05684967f, -0.03166937f, -0.09087557f, -0.01363836f, 
    -0.03600674f, 0.04971696f, 0.13948026f, 0.07674183f, 0.20685643f, -0.08409204f, 0.04202248f, -0.16514957f, 
    0.12648986f, -0.04011533f, 0.13942923f, 0.08242321f, 0.02301239f, 0.16171435f, -0.10927135f, 0.15711707f, 
    0.08776702f, -0.01226197f, -0.04496587f, 0.01488668f, 0.02703736f, -0.09872893f, 0.14709927f, 0.09760918f, 
    -0.07374151f, -0.20081234f, 0.05529827f, -0.04762487f, 0.04258642f, 0.03659397f, -0.02855744f, -0.09278961f, 
    0.04765601f, 0.00955328f, 0.08353232f, -0.06090380f, -0.11608042f, -0.10219719f, -0.10081759f, -0.00647494f, 
    -0.03275707f, -0.10852729f, 0.03226800f, 0.03179971f, 0.02460104f, -0.27569270f, 0.00898287f, 0.04700050f, 
    0.02798176f, 0.20871973f, -0.04807123f, 0.15762451f, 0.05735635f, -0.13066445f, 0.00567787f, -0.28876981f, 
    -0.02194938f, 0.01021955f, -0.17097968f, -0.10140023f, 0.04137873f, 0.07467270f, 0.07686041f, -0.14082378f, 
    0.04434757f, 0.02446065f, -0.10593323f, 0.19023891f, -0.09052373f, 0.02516096f, -0.16061015f, -0.08301523f, 
    -0.06563284f, 0.11757018f, 0.14150453f, -0.06468367f, 0.02757680f, -0.18278192f, -0.11845028f, 0.06833234f, 
    -0.00330402f, -0.02953095f, -0.18675166f, 0.00206204f, -0.11934523f, -0.03728551f, -0.03835338f, 0.06196666f, 
    0.01498895f, -0.04057498f, 0.13741085f, -0.10536911f, -0.00867292f, 0.05977588f, -0.12140071f, -0.03285500f, 
    0.04487288f, 0.17699245f, 0.08547941f, 0.08512718f, -0.01146752f, 0.03041518f, -0.06600843f, -0.30692282f, 
    -0.04245275f, -0.06967042f, 0.06011535f, 0.05469138f, -0.05284680f, -0.06216420f, 0.15392192f, 0.02759481f, 
    -0.16370521f, 0.15510204f, 0.05786376f, -0.05696600f, 0.05827045f, 0.02177584f, 0.13762216f, -0.07850733f, 
    -0.02350350f, -0.04229350f, -0.09735602f, 0.00551476f, 0.03083843f, 0.08612774f, 0.12229813f, -0.10289860f, 
    0.07813605f, 0.02295737f, -0.26330212f, 0.12083801f, 0.08021285f, 0.05667491f, 0.06414504f, 0.03970653f, 
    0.14641239f, 0.03636919f, 0.01823458f, -0.20475830f, -0.10574153f, -0.14363486f, -0.01083438f, 0.00071719f, 
    -0.14684413f, -0.02866447f, 0.23605865f, -0.06290197f, 0.07182941f, 0.00886924f, 0.15757266f, 0.16303256f, 
    -0.06078113f, -0.03025195f, 0.10481729f, -0.07330397f, 0.03886963f, -0.02841510f, 0.20738980f, -0.20118921f, 
    -0.03843852f, -0.07273937f, 0.14237006f, 0.07101731f, 0.04305855f, -0.05299050f, 0.08780040f, 0.07215437f, 
    0.08302520f, 0.05010809f, 0.18590052f, -0.19956252f, 0.01616557f, -0.13474995f, -0.06802119f, 0.13959572f, 
    0.00299261f, 0.16177338f, 0.03242871f, -0.00035118f, 0.05962751f, 0.08773274f, -0.03101515f, 0.20752177f, 
    0.04972288f, -0.04291093f, 0.05684599f, 0.22527348f, 0.03651721f, -0.01833028f, 0.08684262f, 0.05591419f, 
    -0.06402894f, -0.20156915f, -0.02876281f, -0.03244957f, 0.07182804f, 0.01952455f, 0.10962129f, 0.09537353f, 
    0.01797524f, -0.19820000f, -0.22246446f, -0.15866379f, -0.10525151f, 0.18561047f, 0.05455652f, 0.02474023f, 
    0.10989655f, 0.16917785f, -0.09246505f, 0.31249896f, 0.03325264f, 0.08634717f, 0.18161112f, -0.05294415f, 
    0.09089684f, 0.13439141f, 0.03627931f, -0.02279952f, 0.12128530f, -0.01795303f, -0.01892010f, -0.06649828f, 
    0.03884043f, 0.22889930f, -0.02155957f, -0.02466835f, 0.00615960f, -0.04855137f, -0.07479372f, 0.11521530f, 
    -0.18936825f, -0.09809595f, -0.01419130f, -0.02593374f, 0.18243329f, 0.02577534f, 0.02405197f, 0.02805489f, 
    0.18508475f, 0.06185847f, 0.07502820f, 0.06924471f, 0.08811501f, 0.08142635f, -0.00104825f, -0.03450647f, 
    0.13612011f, 0.23792081f, -0.17182110f, -0.06527930f, -0.01877401f, -0.08816536f, -0.05380496f, 0.18000767f, 
    -0.16968529f, 0.10683557f, 0.01221302f, 0.11366340f, -0.11273793f, -0.10859434f, -0.05816432f, 0.12404624f, 
    -0.06437792f, -0.05149832f, -0.24315892f, -0.02665113f, 0.02460453f, 0.11528327f, 0.03546406f, -0.02546363f, 
    -0.02210110f, -0.05643922f, -0.07316896f, -0.09553014f, -0.02759280f, 0.10700797f, 0.11261797f, 0.14797562f, 
    0.11783779f, 0.10062742f, 0.04353884f, -0.39842108f, -0.07835518f, 0.08231249f, -0.06326190f, -0.10518409f, 
    0.19659680f, -0.08827348f, 0.14558512f, 0.04655450f, -0.02527474f, 0.09080318f, 0.07414448f, 0.10639627f, 
    0.04880374f, -0.03020655f, -0.09408960f, 0.10215288f, 0.02043018f, -0.01179113f, 0.08325480f, 0.10016520f, 
    0.04230953f, 0.09870077f, 0.00014664f, -0.01691883f, -0.10139780f, -0.05993744f, 0.01950449f, 0.30123362f, 
    0.21432109f, -0.14248651f, -0.05432357f, 0.18534249f, 0.07493483f, 0.09148688f, 0.04445558f, 0.02169028f, 
    -0.16472152f, 0.05889634f, 0.11800325f, 0.10128139f, -0.00864717f, 0.03664609f, 0.13312232f, -0.04953753f, 
    0.03799307f, 0.06612895f, 0.05516246f, 0.03222185f, -0.08367572f, -0.17002642f, 0.06232308f, 0.12893146f, 
    0.26806733f, -0.05682047f, -0.03538745f, -0.20862970f, 0.01799123f, 0.03535378f, 0.02594455f, -0.03922958f, 
    0.07510798f, -0.15829004f, -0.21529113f, -0.09138596f, -0.06917487f, 0.05203406f, -0.03799679f, 0.11065046f, 
    0.18637516f, 0.00985496f, -0.06923272f, -0.02378483f, 0.11631918f, 0.20165256f, -0.09850716f, -0.14105946f, 
    -0.14455467f, 0.06561738f, 0.05207624f, 0.14558572f, 0.18466440f, -0.15327758f, -0.10196993f, 0.10538469f, 
    0.07997844f, -0.03307831f, -0.03652039f, 0.00296451f, -0.06034465f, -0.03688323f, -0.01607906f, 0.24363399f, 
    -0.29637939f, -0.16201377f, 0.22431454f, -0.11070988f, 0.07765505f, 0.22113028f, -0.01163519f, -0.15962236f, 
    -0.09595735f, 0.15260427f, 0.15927860f, 0.13758230f, 0.09835428f, 0.10871033f, -0.21022901f, -0.11632308f, 
    -0.23342718f, -0.06363634f, 0.00528217f, 0.02374247f, 0.00320976f, -0.15851612f, -0.01287985f, -0.06117851f, 
    0.06230236f, -0.02942690f, -0.06559846f, 0.04517153f, -0.01417461f, 0.12007630f, 0.01267287f, -0.00101380f, 
    -0.12517102f, -0.16447543f, -0.23926757f, 0.10823253f, -0.13335659f, -0.02015472f, 0.13050868f, -0.18108128f, 
    0.10874197f, 0.14440690f, 0.14691986f, 0.05519279f, -0.00646471f, 0.10250410f, 0.05843344f, 0.02636621f, 
    0.11368570f, -0.01502274f, -0.00761918f, -0.21914282f, -0.25838146f, -0.00473714f, 0.03926791f, -0.11704120f, 
    0.12746501f, -0.07128783f, 0.14444745f, -0.01025229f, 0.03704178f, 0.14730667f, 0.02445694f, 0.17620452f, 
    -0.02664116f, -0.08517373f, 0.04297524f, -0.02398196f, 0.17005114f, -0.10447170f, 0.10979974f, -0.18955523f, 
    0.09393224f, 0.01102853f, 0.13039167f, 0.04178393f, -0.02711010f, -0.28447050f, -0.08542386f, 0.32132259f, 
    0.09496778f, -0.14222166f, 0.04779311f, 0.14678991f, 0.13184021f, -0.05144002f, -0.03992146f, 0.17245951f, 
    0.12185017f, 0.19003981f, -0.05228799f, 0.00280611f, -0.09851740f, 0.10190913f, 0.02329530f, 0.18395594f, 
    0.08985095f, 0.00740477f, -0.15362093f, 0.18250713f, -0.16957815f, 0.05319756f, 0.11418229f, 0.06932782f, 
    -0.07977736f, -0.12458812f, -0.01839993f, -0.19229954f, 0.13152739f, -0.01571308f, 0.02525125f, -0.17058913f, 
    0.00470083f, 0.03247210f, -0.15728813f, -0.12761082f, -0.09111967f, 0.06499919f, 0.08126447f, 0.06851359f, 
    0.04250639f, -0.05446504f, 0.16336131f, 0.15011765f, -0.14174123f, -0.23232585f, -0.00719530f, -0.07610515f, 
    -0.10305300f, 0.07791783f, -0.09211364f, 0.19560446f, 0.00925617f, 0.01489704f, 0.04094197f, -0.08203932f, 
    0.09376901f, -0.21722043f, 0.04553856f, 0.01938444f, 0.11271980f, 0.06563576f, 0.28608358f, 0.07038526f, 
    -0.05848593f, -0.06874399f, -0.00648975f, 0.03467094f, 0.12903821f, -0.00930741f, 0.24629325f, -0.20415224f, 
    -0.09442781f, -0.14749017f, -0.00903478f, 0.06583297f, -0.01844805f, -0.03989159f, -0.08547039f, 0.11659437f, 
    0.08059122f, -0.08101586f, 0.09104792f, 0.05490577f, 0.08877528f, -0.01894486f, -0.01406771f, -0.12528513f, 
    -0.23098235f, 0.14409256f, 0.01553319f, 0.08236088f, 0.02161056f, -0.07214689f, -0.11465896f, 0.04026891f, 
    0.11241371f, -0.00816459f, -0.26818445f, -0.11980519f, 0.04805044f, -0.13345273f, 0.08877401f, 0.07858157f, 
    -0.05210243f, -0.04803107f, -0.25277859f, -0.22882548f, -0.10627197f, 0.06303368f, 0.04211325f, -0.07105799f, 
    0.07643887f, -0.07730625f, 0.26847637f, 0.09737695f, 0.09075908f, 0.10181811f, 0.16081984f, 0.01451194f, 
    -0.28521591f, 0.06028100f, 0.01950027f, 0.00659912f, -0.06525607f, 0.14409117f, 0.00340249f, -0.12161870f, 
    -0.26128870f, 0.03004695f, 0.08623224f, 0.07914753f, 0.01377219f, -0.03822933f, 0.08797693f, -0.17898959f, 
    0.01429714f, 0.04089514f, -0.01741960f, 0.08774143f, 0.07751970f, 0.03991134f, 0.12389857f, 0.19969703f, 
    -0.07092332f, -0.02925346f, -0.11338491f, -0.12513921f, -0.18297346f, 0.08532916f, -0.06271624f, 0.04826065f, 
    -0.03205340f, -0.05063373f, -0.02995189f, -0.00810074f, -0.06948750f, 0.15418872f, 0.07777059f, 0.14498237f, 
    0.06092954f, -0.21755700f, 0.10336605f, 0.06928661f, 0.01514908f, 0.04263180f, -0.11143590f, -0.13976881f, 
    -0.10526137f, 0.24497099f, -0.03216435f, 0.06194852f, 0.08952441f, 0.15000388f, 0.07447688f, 0.12913050f, 
    -0.05614231f, -0.14560828f, -0.19950140f, -0.02327570f, 0.06890014f, 0.06550387f, 0.00847674f, -0.18110047f, 
    0.08867275f, -0.00489149f, -0.14807528f, 0.15922762f, 0.17382775f, -0.11681096f, -0.07240061f, -0.25222394f, 
    0.04016106f, -0.03946595f, -0.05793732f, -0.02463495f, 0.19716324f, 0.12133548f, 0.14339185f, 0.09016495f, 
    0.07879769f, -0.09184968f, 0.02751783f, 0.06503589f, 0.12389733f, 0.28572074f, 0.24976401f, 0.00087336f, 
    -0.04638293f, 0.02199859f, -0.00287928f, 0.01055340f, 0.03536905f, 0.01848798f, 0.02211120f, 0.07671110f, 
    -0.00378688f, -0.03172056f, -0.04970857f, -0.06500608f, -0.02244150f, -0.12436339f, 0.14491132f, 0.17106609f, 
    0.01582349f, 0.08284042f, 0.16978544f, 0.02465465f, -0.05870389f, -0.06228947f, 0.06899756f, -0.11662690f, 
    -0.00505320f, -0.00590415f, -0.05243253f, 0.10866794f, -0.10116123f, -0.07792307f, -0.02535608f, -0.03272691f, 
    -0.07382492f, 0.34243616f, 0.31292138f, 0.21894056f, 0.06846635f, 0.08292315f, 0.03341857f, -0.00658457f, 
    0.19938628f, 0.15809178f, -0.03620235f, -0.13536963f, -0.04701419f, 0.10226879f, -0.04548145f, 0.09066810f, 
    -0.02242833f, -0.00862326f, 0.20099834f, 0.19370313f, 0.10615797f, -0.05672855f, -0.02974738f, 0.06250441f, 
    -0.21770200f, 0.04173600f, 0.13496788f, 0.02836962f, 0.09304483f, 0.07747242f, -0.08118347f, 0.07539433f, 
    -0.00302716f, 0.22722095f, -0.14343809f, 0.15533835f, -0.20045887f, 0.05027944f, 0.10312230f, -0.17205752f, 
    -0.02705728f, -0.09642830f, -0.01237726f, 0.00107224f, -0.00271368f, 0.08520890f, -0.10574190f, 0.04320878f, 
    0.17754801f, -0.07341389f, -0.06136797f, 0.02189105f, -0.08598115f, -0.17314975f, -0.14015494f, 0.10414734f, 
    -0.04020309f, -0.12911101f, -0.09737881f, -0.02477642f, -0.02961509f, -0.01566885f, -0.00161838f, -0.23244256f, 
    0.10587053f, -0.11956637f, -0.07270044f, 0.18775390f, 0.05835461f, 0.10833153f, 0.06589048f, -0.00320668f, 
    -0.03655316f, -0.13274682f, -0.01221666f, 0.01023101f, 0.15579021f, 0.11944374f, -0.03212804f, 0.00268688f, 
    0.00187896f, 0.30942529f, 0.02423065f, 0.25761876f, 0.17958058f, -0.01212390f, 0.09444415f, 0.03192661f, 
    0.03707977f, 0.07181432f, 0.08381582f, -0.05963313f, -0.16892852f, 0.00269384f, 0.03788133f, 0.22638807f, 
    -0.05891841f, -0.17163718f, -0.03007569f, 0.03562902f, -0.12986334f, -0.02180126f, -0.15665269f, 0.09503708f, 
    -0.04855060f, 0.06007507f, -0.02791461f, 0.19579802f, 0.07264241f, 0.07477923f, 0.12513846f, -0.08312871f, 
    -0.04233890f, 0.10885940f, -0.04796890f, -0.12351405f, 0.08353314f, 0.05302594f, 0.23717001f, 0.22552778f, 
    -0.06421503f, -0.15067592f, -0.05916417f, 0.17987412f, -0.15558539f, -0.14852828f, 0.12920021f, -0.05083983f, 
    0.00656619f, -0.17165358f, -0.01277031f, 0.14207830f, 0.00809153f, -0.01501609f, 0.05644525f, -0.12704875f, 
    -0.08197008f, 0.12619480f, -0.08680785f, -0.00489375f, 0.12061917f, -0.03415104f, 0.05630343f, -0.08993813f, 
    -0.01253045f, -0.08144135f, -0.02691102f, 0.18758634f, 0.00410084f, 0.12203579f, 0.18661147f, 0.12296050f, 
    0.09620308f, -0.03023766f, -0.25523448f, -0.16709241f, 0.18496828f, 0.06305937f, 0.07482391f, 0.00928712f, 
    -0.00423507f, 0.12659226f, -0.07785676f, -0.15387580f, -0.08516272f, -0.24356996f, 0.05769479f, -0.03888484f, 
    -0.01200796f, -0.06516523f, 0.04604422f, -0.11704773f, -0.01321176f, 0.26232991f, -0.13146642f, 0.07731202f, 
    -0.08792861f, 0.01646264f, 0.19068189f, -0.04126441f, -0.15796502f, -0.14426136f, 0.13228521f, 0.00696851f, 
    -0.03744296f, 0.03086994f, 0.06681607f, 0.22637060f, 0.05591235f, 0.03982795f, -0.05702330f, -0.10748024f, 
    -0.34656402f, -0.02312277f, 0.16891986f, -0.06956245f, 0.10547376f, 0.01423971f, -0.14246814f, -0.08869407f, 
    -0.15988150f, 0.18074593f, -0.05377111f, 0.08075713f, -0.18091451f, 0.16580254f, -0.02324106f, -0.07262820f, 
    0.26970473f, 0.28561789f, -0.02368359f, 0.13781708f, 0.01663304f, 0.03507340f, -0.15100454f, -0.10082328f, 
    -0.13833597f, -0.00077395f, -0.26241335f, 0.05696620f, -0.09714561f, 0.23272774f, -0.05861967f, 0.20900251f, 
    -0.25858739f, 0.04971542f, 0.07569201f, -0.06255988f, 0.14399895f, -0.04620546f, 0.04992618f, -0.06020169f, 
    0.13423926f, 0.13448580f, 0.01428357f, -0.04452480f, 0.09842924f, -0.39563149f, 0.02212075f, -0.01890433f, 
    0.01983723f, 0.07482693f, -0.02731794f, -0.11110147f, -0.26260597f, -0.18013707f, 0.23374194f, -0.01587062f, 
    0.11611745f, 0.06798492f, -0.01417981f, -0.01058484f, 0.01635594f, -0.03575495f, 0.09913151f, -0.50361139f, 
    -0.04827353f, -0.04003541f, -0.10193793f, -0.04703438f, 0.02854170f, -0.12911636f, -0.00333892f, 0.21227610f, 
    0.18946543f, 0.13829836f, 0.03189470f, 0.01383350f, 0.01896038f, 0.00293975f, 0.12089303f, -0.15476899f, 
    -0.06950288f, -0.00529048f, -0.16082935f, 0.07211965f, -0.01538143f, 0.02209166f, -0.02087071f, -0.03307569f, 
    0.29429448f, 0.16559985f, 0.19265753f, -0.01658794f, 0.03525054f, -0.02842170f, 0.03238955f, -0.00361440f, 
    -0.09273022f, 0.05749477f, 0.09707254f, -0.06750915f, -0.10858443f, 0.03597971f, -0.16910902f, -0.13644095f, 
    -0.04638710f, 0.12411091f, 0.16353743f, 0.06744350f, 0.22276010f, 0.03330926f, 0.07459456f, 0.03889808f, 
    0.04751163f, 0.04516579f, 0.12006282f, 0.03831513f, -0.32233220f, -0.11434304f, -0.18292788f, 0.05856666f, 
    0.09797251f, -0.12657420f, -0.02105664f, -0.09555811f, 0.33475032f, 0.11556794f, -0.14091237f, -0.08412319f, 
    0.06191926f, 0.07490887f, -0.31326205f, 0.01878686f, -0.14203115f, -0.22091255f, -0.16866431f, -0.08289917f, 
    -0.01461947f, -0.10147130f, -0.04089988f, 0.11432195f, 0.01864300f, 0.07031500f, 0.02945435f, -0.03744806f, 
    0.13637544f, 0.03274110f, -0.12345923f, 0.03583772f, 0.08192883f, -0.03411077f, -0.03261925f, 0.05610797f, 
    0.02845039f, -0.31200320f, -0.06169273f, 0.09076682f, 0.13964693f, -0.01338926f, -0.04131464f, -0.01228929f, 
    -0.35338989f, -0.04115872f, 0.00218088f, -0.17429657f, 0.29464921f, 0.01204665f, -0.05479357f, 0.09891679f, 
    0.02200018f, 0.02621548f, -0.22335277f, 0.12846403f, 0.00366588f, 0.28872257f, 0.01266104f, -0.03743442f, 
    0.11204429f, 0.05149747f, 0.19419098f, -0.05865612f, -0.14685750f, -0.39986631f, -0.17985001f, 0.02341213f, 
    0.11180235f, 0.06998358f, 0.21641773f, -0.21705061f, 0.16264524f, 0.17751205f, 0.10115574f, -0.12171447f, 
    -0.03389472f, 0.08870577f, -0.00852694f, -0.05494270f, -0.10610552f, 0.02286365f, -0.15484434f, 0.02047564f, 
    0.13580742f, 0.26269555f, 0.04096743f, -0.08875915f, 0.11109360f, -0.22700012f, -0.12669158f, 0.26699403f, 
    0.17640029f, 0.04434488f, -0.00416718f, 0.00378387f, 0.00184701f, 0.08751520f, -0.26155332f, 0.00112204f, 
    0.19551492f, 0.08000965f, 0.08040708f, -0.37507391f, -0.03662058f, 0.08789490f, 0.07109451f, -0.27938110f, 
    0.07907403f, 0.34275389f, 0.10936847f, 0.07365432f, 0.13956325f, 0.09139234f, 0.10232060f, -0.02455630f, 
    -0.22042076f, -0.34254101f, 0.00858940f, 0.14227617f, -0.01806905f, -0.01514423f, -0.00490423f, 0.00168601f, 
    0.12961793f, 0.01418037f, 0.19514920f, -0.12346812f, -0.12758788f, -0.11791306f, -0.03065436f, -0.08536054f, 
    -0.11458065f, 0.09922138f, 0.31761771f, 0.17704140f, -0.15511155f, -0.13342337f, -0.06000328f, 0.08987410f, 
    0.09480432f, -0.05653680f, 0.09696316f, 0.02630715f, -0.15668941f, 0.30004728f, 0.12112194f, 0.03091649f, 
    -0.02860633f, 0.22860406f, -0.11078249f, 0.20583332f, 0.00706868f, -0.00330830f, 0.05366069f, -0.01064053f, 
    0.09017387f, 0.00476460f, -0.06175347f, -0.01224388f, 0.02588633f, 0.03747088f, -0.13919219f, 0.04235602f, 
    -0.06014360f, 0.17666292f, -0.03660031f, -0.03486781f, 0.17687975f, 0.01884852f, 0.05567911f, -0.05994230f, 
    0.10519717f, -0.06284317f, 0.03311218f, 0.11524291f, -0.11040970f, 0.13784403f, -0.02457661f, 0.10124616f, 
    -0.09604277f, 0.19839832f, -0.09224768f, 0.05615976f, -0.04952007f, 0.13034178f, 0.03025784f, 0.17198163f, 
    0.11281916f, 0.09080411f, 0.24431048f, -0.00572761f, 0.07138555f, -0.05058609f, -0.15840386f, -0.01948914f, 
    -0.00992951f, -0.08943830f, 0.21286508f, 0.09752727f, 0.06392325f, 0.12960298f, -0.18297845f, -0.12656315f, 
    -0.05675092f, 0.01181397f, -0.17949054f, -0.01281170f, -0.11965743f, -0.06486928f, 0.09489065f, -0.07743724f, 
    0.34679008f, 0.12426157f, 0.14927302f, 0.04956478f, 0.05373763f, 0.10128102f, -0.11967918f, -0.00919501f, 
    -0.03601871f, 0.08626695f, -0.03458454f, -0.06458124f, -0.05160302f, -0.35197964f, -0.00029596f, -0.07429337f, 
    -0.03369420f, -0.00727063f, 0.13112791f, 0.02916084f, -0.01409246f, -0.06446438f, 0.11923987f, 0.38604435f, 
    0.10598700f, -0.01033869f, 0.09581792f, 0.07843974f, -0.22719726f, 0.08377382f, -0.05551992f, 0.16787249f, 
    -0.11304896f, 0.00298686f, -0.02439625f, 0.01131611f, -0.08500259f, 0.20193547f, 0.12349442f, -0.04343129f, 
    -0.19434156f, 0.02594271f, -0.08031698f, 0.06701571f, -0.03729653f, 0.25483933f, 0.19733112f, 0.04487638f, 
    -0.07077090f, 0.00719462f, -0.01951421f, 0.10036908f, 0.04557272f, -0.15970409f, -0.03663704f, 0.00963253f, 
    0.09410127f, -0.20391332f, -0.15090120f, 0.40831456f, 0.07591493f, 0.00364623f, 0.03582780f, 0.08219827f, 
    -0.13047852f, -0.05814485f, 0.00295819f, 0.19385807f, 0.11626242f, 0.16140342f, -0.07012901f, -0.14029424f, 
    -0.07353022f, 0.16965516f, -0.00648078f, -0.10114504f, -0.15259899f, 0.29336536f, -0.17012635f, 0.00242932f, 
    0.03107791f, 0.12902652f, 0.03627919f, 0.06510530f, -0.21920234f, 0.06920522f, 0.25059667f, 0.17116600f, 
    0.12735361f, 0.01641750f, 0.08195855f, 0.05681545f, 0.07484166f, 0.18703672f, -0.36066610f, -0.46270150f, 
    -0.06586749f, 0.10420084f, -0.00269449f, 0.03915238f, 0.02396464f, 0.00963517f, 0.07332183f, -0.36068782f, 
    -0.15150246f, 0.04190382f, 0.07358088f, 0.13581659f, -0.04317175f, 0.07817379f, -0.01404888f, -0.14598708f, 
    0.24895029f, 0.24526806f, 0.09249385f, -0.05166552f, 0.00354528f, 0.11455800f, 0.06348735f, 0.04571421f, 
    -0.12094861f, 0.08633029f, -0.13686876f, -0.04026760f, -0.09636433f, 0.03234594f, 0.20123881f, 0.02966003f, 
    0.10809171f, -0.16156222f, -0.03674917f, -0.16182055f, -0.04259432f, 0.10016046f, -0.10151657f, -0.04526152f, 
    0.03286824f, 0.06820203f, 0.05379135f, 0.14495929f, -0.03391780f, 0.09513823f, 0.07608037f, -0.03501030f, 
    -0.10084447f, 0.08234687f, 0.09554295f, 0.08654505f, 0.10573193f, 0.00176248f, -0.02524401f, -0.02650606f, 
    0.06856465f, 0.16872913f, 0.12068439f, -0.15738608f, 0.39444751f, -0.01848917f, -0.07055417f, 0.03181164f, 
    0.03481480f, 0.12301839f, 0.01219632f, -0.00684675f, 0.01934242f, 0.28857931f, 0.06936176f, 0.13759498f, 
    -0.07990843f, 0.11460780f, -0.07302397f, -0.13027054f, 0.11647662f, -0.01757709f, -0.32032683f, 0.01368203f, 
    -0.39927661f, -0.07733579f, -0.02451009f, -0.03234981f, -0.24832679f, 0.12769204f, 0.13844194f, 0.22039713f, 
    0.15353884f, 0.03637402f, -0.15041593f, 0.01532342f, 0.02449132f, 0.01302111f, -0.12422954f, -0.02320484f, 
    0.09026386f, -0.05122003f, 0.05008378f, -0.00800549f, -0.00305826f, -0.10406028f, -0.01065366f, 0.05333380f, 
    -0.01099832f, -0.13620959f, 0.07157662f, -0.08173600f, -0.19340417f, -0.11061699f, -0.13798720f, 0.05072821f, 
    0.01800102f, -0.06101333f, -0.10362595f, 0.03816634f, -0.01214818f, 0.02841513f, 0.06404628f, -0.12813993f, 
    -0.03206769f, -0.03301326f, 0.09245297f, 0.22481626f, 0.33174971f, 0.03814881f, -0.01685578f, 0.12444012f, 
    0.16715577f, -0.13195466f, 0.14709659f, 0.09571084f, -0.16790974f, -0.21794973f, 0.02527818f, 0.07452614f, 
    0.05349471f, -0.08405016f, -0.19481428f, -0.01199821f, -0.04695951f, 0.31831077f, -0.08075194f, -0.18040220f, 
    -0.01706310f, 0.08244188f, -0.12043528f, -0.03085667f, -0.13850144f, -0.14840025f, -0.09973314f, 0.12568615f, 
    -0.08323412f, -0.16960414f, 0.16897549f, -0.12818941f, -0.05653059f, -0.08494533f, -0.00813158f, 0.05495721f, 
    0.20846336f, -0.07391834f, -0.03390470f, -0.07504193f, -0.00902501f, 0.06539262f, -0.14316608f, 0.12164173f, 
    -0.39020380f, -0.12843366f, -0.06388420f, -0.15581219f, 0.07133193f, -0.03979646f, -0.13340165f, -0.07610521f, 
    -0.12478384f, -0.08533118f, 0.23608957f, -0.12405250f, 0.05085171f, 0.01071795f, 0.05969511f, -0.10439885f, 
    0.00513739f, -0.07614667f, -0.22172022f, 0.16223262f, -0.08600774f, 0.03126279f, 0.04936095f, 0.00302786f, 
    0.09736752f, -0.00665205f, -0.02397467f, -0.10357558f, -0.02668878f, -0.09368292f, 0.07620887f, 0.16100278f, 
    -0.16541819f, -0.05151558f, 0.03466973f, -0.13547485f, 0.05761154f, 0.22576229f, 0.02847277f, -0.03034772f, 
    -0.07664026f, 0.02280836f, 0.20805022f, -0.23180509f, -0.01050476f, 0.07647594f, 0.15688846f, 0.17599842f, 
    -0.03092006f, -0.05556062f, 0.14027138f, -0.08604787f, -0.09201308f, 0.25874838f, 0.07985567f, 0.14412439f, 
    0.07036028f, -0.04856675f, -0.08785950f, -0.09170336f, 0.02409010f, 0.01304712f, 0.00251301f, 0.26890963f, 
    0.14556132f, 0.14125142f, 0.04163072f, -0.07535706f, 0.06235915f, 0.08892902f, -0.03559454f, 0.10952501f, 
    -0.06503045f, 0.25124520f, 0.01521929f, 0.11342850f, -0.07534332f, -0.10288214f, -0.09329192f, 0.05569192f, 
    -0.18111423f, 0.25881785f, 0.23196499f, 0.23382787f, -0.01974725f, 0.10928395f, 0.17210136f, 0.05688231f, 
    -0.01837544f, 0.10410231f, 0.09294270f, 0.33811358f, -0.07984762f, -0.07774459f, 0.06310894f, -0.03363943f, 
    0.12814659f, 0.14787343f, -0.08628023f, -0.05032135f, 0.27393445f, 0.23903245f, 0.04243694f, 0.19078252f, 
    0.04848953f, 0.08211979f, 0.04764344f, 0.04839421f, -0.17824918f, -0.04950000f, -0.01909804f, 0.03613534f, 
    0.02750368f, -0.15201247f, -0.03282415f, -0.02027384f, 0.02314544f, 0.17523356f, 0.23122437f, 0.06495500f, 
    0.12728265f, 0.00183922f, -0.04519695f, -0.10665207f, -0.02123510f, -0.17746618f, 0.02077322f, -0.08697745f, 
    -0.11997532f, 0.19465750f, -0.02212383f, -0.13943775f, 0.01442405f, -0.02865422f, -0.23489325f, -0.02908239f, 
    -0.02037025f, -0.10699551f, 0.00927136f, -0.10057341f, -0.09580895f, -0.12385161f, 0.11601254f, -0.10636877f, 
    0.23637240f, 0.17501669f, 0.14921571f, -0.08415101f, -0.02773702f, 0.05620745f, 0.08406807f, 0.08696868f, 
    0.17581308f, -0.14957185f, 0.04377032f, 0.01320440f, 0.05700922f, -0.07952858f, -0.16296758f, -0.04334772f, 
    -0.04072048f, 0.00746892f, 0.08922033f, 0.11741538f, -0.01562610f, 0.05993697f, -0.20369616f, -0.13164343f, 
    0.04862646f, 0.11293367f, 0.08132867f, 0.22093108f, -0.09649228f, -0.01413757f, -0.04161209f, 0.08591460f, 
    0.04514474f, -0.05798590f, 0.08040480f, 0.08247382f, -0.02079628f, -0.17533356f, 0.04872372f, -0.01059759f, 
    -0.15221998f, 0.04572670f, -0.03080820f, -0.02924391f, 0.09834934f, 0.13687989f, 0.07197700f, -0.19364481f, 
    -0.00278035f, -0.03957685f, -0.07791525f, -0.00277438f, 0.00091748f, 0.08113395f, 0.31894654f, 0.08572304f, 
    -0.10081337f, 0.06258924f, -0.02743252f, 0.34548992f, -0.10905917f, 0.11559798f, -0.07661257f, 0.23122545f, 
    0.06410752f, 0.16100615f, 0.09865489f, 0.21111351f, 0.07336889f, 0.03003422f, -0.21738200f, -0.13104998f, 
    0.10764612f, 0.20488593f, 0.05194066f, -0.13346726f, -0.01254280f, 0.09456141f, 0.10171743f, -0.05626021f, 
    -0.01144000f, 0.05258296f, 0.03840685f, 0.07709697f, -0.01860703f, 0.09504870f, -0.03050268f, 0.05634253f, 
    0.19741234f, -0.05257755f, 0.06012771f, 0.10770717f, 0.16724238f, -0.05197299f, -0.08228582f, -0.11882339f, 
    -0.03967691f, -0.02614748f, 0.10493483f, 0.12390279f, 0.13208379f, -0.07184219f, 0.00954336f, -0.24366891f, 
    0.02464382f, 0.13681123f, -0.09583093f, -0.16348030f, 0.31033564f, -0.06929927f, -0.08661386f, 0.14778031f, 
    0.09800738f, 0.02443266f, -0.03562915f, 0.03907178f, 0.03908599f, 0.12070148f, 0.21488331f, -0.01917263f, 
    -0.07938852f, 0.05885247f, 0.02334509f, 0.14352237f, -0.07786117f, 0.06054375f, 0.17005260f, -0.20892373f, 
    -0.04208102f, 0.21335070f, 0.06652034f, -0.02674919f, 0.14474776f, -0.04161356f, -0.01335249f, 0.15882140f, 
    -0.17154154f, -0.00448457f, 0.01051777f, -0.05916263f, 0.00178088f, -0.06447391f, 0.09753713f, 0.01854711f, 
    0.28227735f, -0.05731907f, -0.04320048f, 0.01159239f, 0.02416905f, 0.06727720f, -0.04655501f, 0.04869036f, 
    -0.17481218f, -0.34841189f, -0.13108487f, -0.05311196f, 0.08567939f, 0.10986156f, -0.17176728f, -0.11159351f, 
    0.22930829f, -0.07437254f, 0.07752013f, 0.02025811f, -0.02747983f, -0.02745300f, -0.09884649f, -0.24969415f, 
    -0.00266091f, 0.02070741f, 0.14421631f, 0.12241405f, -0.23073295f, -0.08597365f, 0.27706382f, 0.13935952f, 
    0.03247657f, -0.01301842f, -0.05348292f, 0.02573457f, 0.10812733f, 0.22555944f, 0.07999096f, -0.22594734f, 
    0.02679582f, -0.02940540f, -0.05309267f, -0.12764104f, -0.11108007f, -0.02045960f, 0.01620809f, -0.00665106f, 
    0.06076725f, -0.02708983f, 0.06643964f, 0.09500421f, 0.07663643f, -0.08970368f, 0.09608641f, 0.01793169f, 
    -0.04570994f, 0.14741099f, -0.10110088f, -0.11303157f, 0.03050156f, 0.03234608f, 0.08163065f, 0.17924599f, 
    0.04026014f, -0.05042766f, -0.23632510f, 0.08970641f, -0.14544851f, 0.04538996f, -0.01282823f, 0.01605019f, 
    0.13955107f, -0.09636861f, -0.07491126f, 0.12277862f, -0.11661454f, -0.08941977f, 0.02190616f, 0.09939784f, 
    -0.00765639f, 0.09456503f, 0.08289632f, -0.17545271f, 0.03130903f, 0.05870685f, 0.03048648f, 0.03411891f, 
    0.00946778f, -0.01191331f, 0.19445965f, 0.03732834f, 0.00791632f, -0.12797542f, -0.22005108f, -0.03129783f, 
    -0.09829589f, 0.12564108f, 0.08121408f, 0.07443827f, -0.07370401f, -0.03533159f, -0.20282364f, 0.02499077f, 
    0.03594636f, 0.09953059f, -0.10767715f, -0.10310255f, 0.15221536f, -0.11823343f, -0.33313549f, 0.01951356f, 
    0.07698786f, 0.20224491f, 0.14837816f, -0.03195073f, -0.07371394f, 0.02479313f, -0.36107373f, 0.09596899f, 
    -0.18585685f, 0.16707090f, -0.03348838f, 0.04220506f, -0.09002881f, -0.09432922f, -0.02973052f, -0.01698323f, 
    -0.19441587f, 0.03059719f, 0.08669461f, 0.08362728f, -0.03709694f, -0.09129439f, -0.05552049f, -0.07455443f, 
    -0.07608651f, 0.04230746f, 0.17744085f, 0.18766910f, 0.01693114f, -0.04657695f, 0.07348341f, -0.05284391f, 
    -0.44320992f, -0.14081672f, -0.24232046f, 0.07435894f, 0.01978594f, -0.02016190f, -0.00407535f, -0.09973776f, 
    0.04447413f, -0.19533320f, -0.09609404f, -0.09360566f, 0.05335140f, 0.07435177f, -0.10211581f, -0.02184675f, 
    -0.17432973f, -0.12605563f, 0.01398015f, -0.31248927f, -0.14587475f, 0.12962253f, 0.02931469f, 0.03529997f, 
    0.01818183f, 0.03000960f, -0.09133466f, -0.51502466f, 0.03968142f, -0.12050337f, -0.01661966f, 0.04453114f, 
    -0.07457849f, 0.00468312f, 0.01245242f, -0.11746554f, 0.15303403f, 0.09894881f, -0.19681586f, -0.07831252f, 
    -0.00337552f, 0.10353034f, 0.17742969f, -0.07811049f, 0.08819462f, 0.00205402f, 0.05280146f, 0.19587949f, 
    0.13039942f, 0.00527535f, 0.02083441f, -0.04301558f, 0.06946950f, 0.01250924f, 0.10250240f, 0.17289251f, 
    0.07241648f, 0.18525733f, -0.03404539f, -0.06970541f, 0.00255974f, 0.05995412f, 0.07726698f, 0.01718046f, 
    0.04990498f, 0.08662989f, 0.08906672f, -0.01552112f, 0.04499682f, -0.02048974f, 0.10836837f, -0.00495551f, 
    -0.03311246f, 0.01148699f, 0.00670491f, -0.01529216f, -0.00109883f, 0.03616399f, -0.02434709f, 0.02768996f, 
    0.05895619f, -0.32788926f, -0.33335912f, -0.16243832f, 0.15447940f, -0.11104153f, 0.00271453f, -0.09331193f, 
    -0.00261479f, 0.08295494f, -0.12569673f, 0.00703722f, -0.30054080f, -0.05952289f, 0.14742017f, -0.14595565f, 
    0.07522617f, 0.05965332f, -0.00888742f, 0.24539742f, 0.07068309f, -0.04883427f, 0.00134455f, 0.02766865f, 
    -0.14061631f, 0.06723218f, -0.00913655f, 0.10432661f, 0.13749604f, 0.15570238f, 0.00202519f, 0.03644784f, 
    0.00324594f, -0.05023437f, 0.06940618f, 0.05228874f, 0.02540389f, 0.11447439f, -0.07453210f, -0.07982168f, 
    -0.08490362f, 0.07231720f, -0.02426527f, -0.10374636f, 0.12505721f, 0.03399412f, -0.12779143f, -0.00677159f, 
    0.19445023f, 0.04966879f, -0.09169790f, -0.02444361f, -0.00299832f, 0.08691605f, -0.00242760f, -0.04748894f, 
    -0.12845509f, -0.23497118f, -0.07825113f, 0.07141064f, 0.00890486f, 0.13080597f, -0.03365431f, 0.13477319f, 
    -0.12667862f, 0.14620808f, 0.40416074f, 0.10229965f, 0.08652602f, 0.04324081f, -0.04428815f, -0.07874388f, 
    0.06694354f, 0.26889858f, -0.05977519f, -0.21442126f, 0.23454867f, 0.10513441f, 0.21249186f, -0.06458106f, 
    0.17507330f, -0.04517026f, -0.07519105f, -0.23395683f, -0.14597705f, -0.11546975f, -0.03281475f, -0.22234353f, 
    -0.04173248f, 0.04458028f, 0.03228104f, 0.12338541f, 0.13283208f, -0.06433481f, -0.04909331f, -0.01024042f, 
    0.01048818f, -0.07972017f, 0.12362068f, 0.08324275f, 0.23703104f, 0.13448487f, 0.00082805f, -0.04075952f, 
    -0.06844810f, -0.12508219f, -0.03317130f, 0.06682635f, 0.05752846f, 0.13362072f, 0.12917976f, 0.17298375f, 
    0.02669290f, -0.01188309f, 0.21112631f, -0.04740737f, -0.02944917f, -0.21473709f, -0.44466534f, -0.33270311f, 
    -0.02557603f, 0.10725137f, -0.08261476f, 0.04911394f, -0.03643194f, 0.03367645f, 0.13603124f, 0.18563242f, 
    0.04838005f, -0.13529317f, -0.09745300f, 0.03692382f, -0.04769783f, 0.02016453f, 0.04746256f, 0.07192286f, 
    -0.50795037f, 0.04987909f, -0.05573523f, 0.07691600f, 0.00300525f, -0.12565547f, -0.05373937f, -0.02270412f, 
    0.12999405f, 0.14270449f, 0.07664362f, 0.26829726f, 0.01340942f, -0.01933155f, 0.01351509f, -0.05355770f, 
    0.03547049f, -0.12582032f, -0.89443368f, -0.02663006f, -0.07647543f, 0.16841643f, 0.13736019f, 0.06614559f, 
    -0.10418369f, 0.04793698f, 0.03073756f, 0.29966035f, 0.11149823f, -0.18861039f, -0.13024916f, -0.00126289f, 
    -0.08963959f, 0.06164824f, -0.01213258f, 0.01803977f, 0.05859618f, 0.30190897f, 0.30575266f, -0.02852499f, 
    -0.03791444f, 0.11803354f, -0.01808938f, -0.01378726f, -0.02857775f, -0.19959101f, 0.21317904f, -0.29202378f, 
    -0.03978282f, -0.15902078f, -0.10004384f, 0.15471782f, -0.19486897f, -0.00026755f, 0.01761300f, 0.11085158f, 
    -0.11295089f, -0.11510026f, 0.11625635f, -0.01430741f, 0.06193401f, 0.02441984f, 0.01711783f, 0.14193150f, 
    0.06026733f, 0.14061981f, -0.06007925f, -0.10048562f, 0.14272745f, 0.03455691f, 0.04780501f, 0.02949449f, 
    -0.29049760f, -0.08839964f, 0.08714268f, 0.01291249f, 0.08465914f, 0.09149195f, -0.03520861f, -0.04829362f, 
    -0.06026057f, -0.34807929f, 0.07959723f, -0.14770649f, 0.10367246f, 0.12533388f, 0.00540342f, 0.09001509f, 
    -0.12076397f, 0.04988280f, -0.17086144f, 0.13641495f, 0.15386106f, 0.18342738f, -0.05146720f, 0.14082861f, 
    0.14803226f, -0.00723302f, 0.02200278f, -0.13773747f, -0.27206376f, -0.05003113f, -0.10835381f, 0.04412322f, 
    0.17161493f, 0.03361991f, 0.01268505f, -0.13829236f, 0.21855809f, 0.06539096f, -0.26404539f, 0.01973313f, 
    0.08721711f, 0.05127878f, 0.18711096f, 0.02248406f, -0.05768929f, 0.10065050f, -0.17230564f, -0.02011097f, 
    -0.12280421f, 0.02032616f, 0.10999015f, 0.02097187f, 0.02720020f, 0.14159715f, -0.06103412f, 0.04035341f, 
    0.07079664f, 0.12394637f, 0.10264673f, -0.06068748f, -0.08388191f, -0.00653055f, 0.09197068f, 0.26490599f, 
    -0.24456178f, 0.15319134f, 0.03034884f, 0.01103135f, 0.04064776f, 0.08585376f, -0.08033478f, 0.04507988f, 
    0.20402536f, -0.05250218f, -0.01204959f, -0.07500058f, -0.17096955f, -0.07568786f, 0.11556830f, 0.08267885f, 
    0.09748034f, -0.39846820f, -0.08670863f, 0.14072537f, 0.07398465f, -0.03986910f, -0.13184397f, -0.06593520f, 
    -0.03130661f, -0.11465288f, -0.32566413f, -0.09626783f, 0.03189480f, 0.25453025f, 0.02948194f, -0.03145957f, 
    -0.01951644f, 0.15890157f, -0.09379531f, 0.13138798f, 0.05769740f, -0.10449477f, 0.06154829f, -0.05848443f, 
    0.04801018f, -0.02633176f, 0.16601281f, 0.04078094f, -0.21856262f, -0.12962115f, 0.06651133f, -0.05241120f, 
    -0.01274475f, -0.07292166f, -0.04238637f, 0.06291988f, 0.05079670f, 0.36549562f, -0.16564564f, 0.09581118f, 
    -0.02479360f, -0.07443788f, -0.05221908f, 0.07106117f, -0.07216270f, 0.03351019f, -0.53727472f, 0.00591248f, 
    -0.03546098f, 0.07711381f, 0.18034966f, 0.00699704f, -0.08722993f, -0.10852803f, 0.02964875f, -0.21033266f, 
    -0.01893164f, 0.02928319f, 0.07384179f, -0.13631657f, -0.04261490f, 0.01841239f, -0.02273265f, 0.03086676f, 
    0.05162079f, 0.16848549f, -0.02513758f, -0.06606001f, 0.03232323f, 0.07601914f, -0.11775152f, 0.04540471f, 
    -0.00262377f, 0.06301364f, 0.22355969f, 0.03769740f, -0.01223318f, -0.00026789f, -0.10021529f, 0.05992699f, 
    0.15274294f, -0.07210132f, -0.24219246f, 0.00153538f, 0.02071517f, 0.03323598f, -0.07857154f, 0.17058739f, 
    -0.07031538f, 0.10014528f, 0.11548295f, -0.32133609f, -0.01491191f, 0.11949998f, -0.12532213f, 0.06433346f, 
    -0.00094361f, -0.05572049f, -0.04698902f, 0.08452240f, 0.14336292f, 0.06888091f, -0.05501054f, 0.03454843f, 
    0.03604602f, -0.00976147f, 0.19296813f, -0.05713553f, 0.06261575f, -0.31954595f, -0.27516109f, -0.03871625f, 
    -0.01391776f, 0.02402739f, 0.24959703f, -0.00732481f, -0.15341432f, -0.03910569f, -0.08624186f, 0.12089469f, 
    0.12918822f, -0.03904876f, -0.14097939f, -0.04490667f, -0.00268199f, -0.09461286f, 0.12950118f, 0.12309510f, 
    -0.04328053f, 0.00340616f, 0.19311365f, 0.03947068f, -0.01626423f, -0.00736498f, 0.01431526f, 0.04121983f, 
    -0.20741867f, 0.15504386f, -0.00913010f, -0.02994748f, -0.04763042f, 0.10877283f, -0.13647388f, -0.09987886f, 
    -0.05816459f, 0.10186320f, -0.14790417f, -0.09008398f, 0.13174944f, 0.11565491f, 0.02815233f, -0.00187829f, 
    -0.04793938f, 0.15935637f, -0.21187834f, 0.19185057f, 0.05245352f, -0.11998899f, 0.06235256f, 0.10110224f, 
    -0.07799997f, -0.09788866f, -0.02192588f, -0.00891491f, -0.14709757f, 0.10252383f, 0.26963130f, -0.09275115f, 
    0.09586424f, 0.18501672f, 0.11766554f, -0.04541259f, -0.04683925f, 0.03736375f, 0.02271949f, 0.02780928f, 
    0.00930111f, -0.09076994f, -0.28963467f, 0.01879402f, -0.03409570f, -0.28273159f, 0.17294417f, -0.02679194f, 
    -0.18754561f, -0.02683759f, -0.08706283f, 0.12910612f, -0.08839042f, -0.04851281f, 0.17897867f, 0.08460948f, 
    -0.18407641f, 0.08424997f, 0.05405015f, -0.01845770f, -0.03845869f, 0.06095536f, -0.02482236f, -0.08809871f, 
    -0.18632412f, 0.06517322f, -0.03289396f, 0.14879413f, 0.07819720f, 0.03747540f, 0.08670035f, 0.02296087f, 
    -0.12712954f, 0.19646935f, 0.16130829f, -0.04177498f, 0.06624691f, 0.05208493f, 0.11386251f, 0.08525320f, 
    0.04364413f, -0.04657032f, 0.06133493f, -0.05346576f, 0.03876810f, -0.05255254f, 0.07227918f, 0.02463326f, 
    0.06601884f, 0.14008662f, -0.04945970f, -0.09724096f, 0.03908313f, 0.04069854f, 0.19922213f, 0.19098435f, 
    0.03021739f, -0.00563175f, -0.01496010f, -0.14024797f, 0.36305460f, 0.26410228f, 0.12239898f, -0.15318984f, 
    0.04177218f, -0.02127488f, 0.01665117f, -0.02523824f, -0.27407521f, -0.24386416f, -0.07376043f, 0.01078944f, 
    0.09380049f, 0.04346168f, 0.11669794f, -0.03653570f, 0.04192934f, -0.18653303f, -0.16078518f, -0.27499226f, 
    -0.08366545f, 0.02098590f, -0.01817296f, -0.10676523f, 0.05719326f, 0.09139735f, -0.01529660f, 0.07611553f, 
    0.01505109f, -0.13339020f, 0.07012407f, -0.02834143f, 0.04640017f, 0.12169800f, 0.06318010f, -0.09737246f, 
    -0.02108669f, -0.07115541f, 0.09108975f, 0.13311523f, -0.08852041f, 0.02552798f, -0.01240034f, -0.09077734f, 
    -0.16119760f, -0.04873034f, -0.21431081f, 0.13664934f, 0.00974337f, 0.08512310f, -0.05624225f, 0.07415946f, 
    -0.04100996f, 0.40723395f, 0.29628387f, -0.14593656f, -0.23914783f, -0.11464898f, -0.03304990f, -0.03482731f, 
    0.09552078f, 0.02222914f, 0.29073632f, 0.15115164f, -0.12349889f, 0.12940437f, 0.04249102f, 0.07566902f, 
    0.01957698f, -0.04126008f, 0.05989506f, -0.01711765f, -0.39284483f, -0.42548078f, 0.00293717f, 0.08680575f, 
    0.02306007f, -0.04541656f, -0.01258108f, -0.01620763f, 0.00359926f, -0.03074038f, -0.20446144f, -0.01385112f, 
    0.14579763f, -0.11704955f, 0.16387437f, 0.04421025f, -0.11976688f, -0.06170254f, -0.01944830f, -0.15836774f, 
    0.04200408f, 0.02068287f, 0.14073335f, -0.04995104f, -0.02906406f, -0.03790211f, 0.30908403f, -0.04733587f, 
    -0.22939281f, 0.07988098f, -0.02977161f, 0.12187446f, -0.13543257f, -0.03573067f, 0.04726076f, -0.28374034f, 
    0.18748750f, 0.49282116f, 0.10983324f, 0.06484006f, -0.12128539f, 0.05172746f, 0.02759094f, 0.00833941f, 
    0.04621332f, 0.12845008f, -0.06336299f, 0.02242481f, 0.03464667f, 0.00235544f, -0.09813299f, -0.01163670f, 
    0.00536511f, -0.13431796f, -0.21677423f, -0.16155840f, 0.11287802f, 0.10266398f, 0.02052367f, 0.09972329f, 
    0.06642766f, -0.05480270f, -0.01805547f, -0.12880811f, 0.00050131f, -0.01076722f, -0.01682674f, -0.00639549f, 
    0.00234052f, -0.04406817f, 0.07108914f, 0.15254103f, 0.03322535f, -0.31337950f, 0.01675682f, -0.05578590f, 
    -0.10236629f, -0.03684645f, -0.05972365f, -0.06739190f, 0.49028927f, -0.06901138f, -0.22782612f, 0.16209827f, 
    0.08721547f, 0.03650711f, 0.09489811f, 0.08746888f, 0.13857333f, -0.06934689f, 0.16577634f, 0.03590751f, 
    -0.07216739f, 0.06585279f, -0.18278666f, 0.06368645f, -0.00789173f, -0.03238481f, -0.05613837f, 0.01751911f, 
    0.17171934f, 0.00533133f, 0.11226819f, 0.02563631f, -0.04536409f, 0.02130659f, -0.06543281f, 0.27946556f, 
    -0.39575073f, 0.02076013f, 0.08048726f, -0.09241938f, 0.10465094f, 0.06321605f, -0.00744513f, -0.03660274f, 
    -0.07165338f, 0.03692739f, 0.12095176f, -0.07615671f, -0.00597922f, -0.07707480f, -0.04300824f, 0.00728082f, 
    -0.00439124f, 0.08006627f, -0.01743517f, -0.19176854f, 0.01618838f, -0.03238899f, 0.02789451f, -0.04981815f, 
    -0.12428975f, -0.03835369f, 0.01071605f, 0.20086285f, 0.37279218f, 0.02855936f, 0.13757554f, -0.14929499f, 
    -0.17623839f, -0.08694590f, -0.02766188f, 0.02322767f, -0.43831998f, -0.31074724f, 0.20898245f, -0.02162768f, 
    -0.09851552f, 0.11798380f, -0.00031851f, 0.05118653f, -0.08934667f, 0.08270489f, -0.05476398f, -0.02923533f, 
    0.06017547f, -0.16742642f, 0.03023168f, 0.15262552f, 0.17499635f, 0.20806257f, -0.11099050f, -0.10659897f, 
    -0.20378096f, 0.04385146f, -0.00530568f, -0.04362617f, -0.01375294f, -0.08059321f, 0.28674290f, -0.28347874f, 
    0.10405306f, -0.26438090f, 0.03650556f, -0.03900389f, -0.02034468f, -0.04866740f, -0.06864022f, -0.30538923f, 
    0.14132851f, -0.08593339f, 0.08792827f, -0.01070079f, 0.02366793f, -0.08459717f, 0.04950861f, 0.09156294f, 
    0.00563597f, 0.00217890f, 0.01307262f, -0.04288937f, -0.00243527f, 0.05666982f, -0.00124563f, -0.03082447f, 
    0.01264293f, -0.02966821f, -0.00513532f, -0.02945467f, -0.04443994f, -0.06528878f, 0.03352251f, 0.03122443f, 
    -0.00878507f, -0.06208733f, -0.04759351f, 0.00548618f, -0.02479548f, 0.00053350f, 0.02883699f, 0.04753621f, 
    -0.06218234f, 0.01370462f, 0.01913438f, -0.05162795f, -0.02868010f, -0.03556874f, -0.03297404f, 0.04077546f, 
    -0.03440635f, -0.06680269f, -0.06907983f, 0.01952081f, 0.03679779f, 0.01342413f, 0.00378671f, -0.02779642f, 
    -0.00226142f, 0.00787207f, -0.06187579f, 0.03698402f, 0.03320827f, -0.05693291f, -0.03761396f, 0.04363748f, 
    -0.04575531f, -0.05049376f, -0.01824819f, 0.03766120f, -0.01011237f, 0.00690405f, -0.01109665f, -0.02439363f, 
    -0.03586978f, -0.02963094f, -0.02228556f, -0.05124456f, -0.02172522f, -0.02972512f, -0.06811387f, 0.02535646f, 
    0.04248960f, -0.02557974f, -0.05817676f, -0.06038295f, -0.06536436f, -0.05709874f, -0.03430950f, 0.00697662f, 
    -0.03030475f, 0.02603048f, -0.02987918f, -0.02535241f, -0.03975775f, -0.05602103f, 0.04993315f, 0.04517971f, 
    0.01967354f, 0.04365199f, -0.00884524f, -0.01078189f, -0.01320427f, -0.01689699f, -0.04402306f, 0.02274253f, 
    0.02262398f, -0.05394657f, -0.02578091f, 0.00429287f, 0.01834477f, 0.00940757f, -0.02845226f, 0.01775255f, 
    0.03191103f, 0.02226895f, 0.00364341f, -0.01353448f, 0.01674011f, -0.01566190f, -0.01871555f, 0.01210437f, 
    0.05006856f, -0.04434577f, 0.04470186f, 0.02420229f, 0.01148649f, -0.00382313f, 0.01099637f, -0.03995961f, 
    -0.03823042f, -0.05060351f, -0.04837787f, -0.06659647f, -0.01705142f, -0.02236118f, -0.01013940f, -0.02644232f, 
    -0.01811962f, -0.02404122f, 0.01690574f, 0.01127519f, 0.02797715f, -0.05867166f, -0.02536147f, 0.01050578f, 
    -0.00360288f, -0.01983170f, -0.01314211f, 0.04690214f, -0.05386560f, -0.01916552f, -0.00581426f, -0.00125165f, 
    0.00906605f, -0.04012075f, -0.00547672f, 0.04254439f, -0.04482370f, 0.02693998f, 0.02226027f, -0.05249278f, 
    0.00905144f, -0.05221092f, -0.02935789f, 0.01899779f, 0.05029515f, -0.05404470f, -0.00455743f, -0.00415213f, 
    -0.06365803f, 0.03483951f, 0.05385673f, 0.01690423f, 0.01233857f, -0.05028952f, -0.05822876f, 0.01519138f, 
    -0.02764676f, 0.00454291f, -0.03144886f, 0.00232182f, -0.00666074f, -0.03897067f, 0.03085110f, -0.02681663f, 
    0.02346488f, -0.05347670f, 0.01783543f, -0.04107682f, 0.03292316f, 0.01518279f, 0.05554046f, 0.04365470f, 
    -0.04022025f, -0.02884457f, -0.01814355f, 0.04717751f, -0.02614623f, -0.04269731f, 0.03171885f, -0.01705480f, 
    0.00770050f, 0.03371856f, 0.01056219f, -0.01062784f, 0.02429273f, 0.02682959f, -0.03624611f, -0.01303231f, 
    0.04152929f, 0.02185269f, -0.06397716f, -0.02324934f, -0.01402244f, -0.05652368f, 0.02511330f, 0.03559206f, 
    -0.00670913f, 0.02704527f, -0.04621318f, 0.00945161f, 0.03356560f, -0.03478974f, -0.04740535f, 0.02942108f, 
    0.05051873f, -0.05942206f, 0.00520174f, -0.03380308f, 0.03917634f, 0.02061060f, -0.03408636f, -0.05537996f, 
    0.01014105f, 0.00029349f, -0.05374730f, 0.03902037f, -0.03886336f, -0.01163273f, -0.01689266f, 0.01979171f, 
    -0.00310306f, -0.04857557f, -0.06246775f, -0.02132531f, -0.02756373f, 0.03063196f, 0.03102698f, 0.03940128f, 
    -0.02408327f, -0.00104098f, 0.04293309f, 0.03028054f, 0.04712168f, -0.03984378f, -0.03377688f, -0.00766148f, 
    0.02823924f, 0.01857436f, 0.00954449f, 0.03799526f, 0.02155245f, -0.01311773f, 0.00402512f, 0.00346071f, 
    0.00935846f, -0.00604866f, 0.01971735f, -0.00563864f, -0.04558453f, 0.02380438f, 0.02320649f, -0.00719077f, 
    0.03687032f, 0.04833654f, 0.01621115f, -0.05685083f, -0.05127792f, 0.00676263f, 0.05968465f, -0.01331630f, 
    -0.02949572f, -0.03736234f, -0.02754892f, 0.00177585f, 0.04550526f, 0.02892298f, -0.05304880f, -0.00696512f, 
    -0.01464304f, -0.02096004f, 0.04317267f, 0.00186786f, -0.03184642f, 0.02160069f, 0.02616078f, 0.01203430f, 
    0.01064101f, -0.01871541f, 0.02436310f, 0.04561188f, 0.01981981f, -0.01528836f, 0.02768592f, 0.03074146f, 
    0.24721146f, -0.06069891f, 0.08121685f, 0.05961860f, 0.01950691f, 0.02602993f, 0.06961559f, -0.03964804f, 
    0.17058571f, -0.05823832f, 0.10508770f, -0.14655489f, 0.04653152f, -0.01554751f, -0.10156316f, -0.17069417f, 
    0.16954541f, -0.04809139f, -0.00428749f, 0.02459155f, 0.03729701f, 0.10083112f, 0.05252613f, 0.00555659f, 
    -0.00204172f, 0.11178781f, 0.29579213f, -0.01870044f, -0.21998754f, 0.00876681f, -0.04996971f, 0.07507148f, 
    0.18649876f, 0.00217228f, 0.10095081f, -0.03963450f, 0.44244373f, -0.17337249f, 0.19639492f, -0.03337698f, 
    0.04517413f, -0.08975620f, -0.08163495f, 0.16521518f, 0.05953301f, -0.09795053f, -0.00481668f, -0.47094589f, 
    0.05597730f, 0.01885668f, -0.05100881f, 0.01781081f, -0.06809794f, 0.15609139f, 0.32459468f, 0.22987424f, 
    0.10664977f, 0.02646117f, -0.05319366f, 0.10781082f, -0.05061103f, -0.06375085f, 0.11438556f, -0.00080391f, 
    0.21719790f, -0.17260003f, 0.08944561f, 0.13166411f, -0.04278842f, -0.06506252f, -0.01244655f, -0.25413537f, 
    -0.24586508f, 0.10766930f, -0.14323093f, -0.13482285f, -0.09312481f, 0.08150429f, -0.05012547f, 0.05214513f, 
    -0.04896088f, -0.15187810f, -0.19179544f, 0.11413485f, 0.20957118f, 0.01093265f, 0.04287696f, 0.05724883f, 
    0.08471698f, 0.02273175f, 0.11608797f, 0.04407731f, -0.03659219f, -0.09672645f, 0.15207447f, 0.14291508f, 
    -0.11660189f, 0.02610694f, 0.17754389f, 0.19694492f, 0.43049288f, 0.00312873f, 0.09795559f, -0.07273202f, 
    0.02287613f, 0.06492842f, -0.18407598f, -0.04508930f, 0.06589094f, -0.15620625f, 0.00503798f, -0.04536560f, 
    -0.03777643f, -0.17936012f, 0.09789585f, 0.08071268f, 0.07681606f, -0.16170631f, 0.33993730f, -0.35654801f, 
    -0.04983587f, -0.08877293f, 0.04978474f, 0.11990411f, 0.07862689f, 0.05469850f, 0.19212386f, -0.50588608f, 
    0.04282169f, -0.20539939f, 0.06134581f, 0.05206776f, -0.10621551f, 0.07855066f, 0.06972157f, 0.14514898f, 
    -0.22692117f, -0.09607827f, -0.17296235f, 0.12522812f, 0.13992895f, 0.12020961f, -0.02248309f, 0.17678201f, 
    0.26673505f, 0.10085940f, 0.05771810f, -0.05281470f, -0.02667369f, -0.00045412f, 0.03180973f, -0.01752456f, 
    -0.06653082f, -0.25264573f, -0.31328496f, 0.01576229f, -0.08100432f, 0.10635106f, -0.15247490f, 0.04306691f, 
    0.13945545f, -0.19697969f, -0.30771890f, -0.13444418f, -0.20826375f, -0.18505692f, -0.09336358f, 0.08788945f, 
    -0.04971213f, 0.03167852f, 0.04034452f, 0.02383183f, -0.24223106f, -0.00366816f, -0.16929692f, 0.11105105f, 
    -0.03928533f, 0.14506643f, 0.01316535f, 0.01787596f, 0.04504143f, 0.35478851f, -0.18475576f, -0.06103786f, 
    0.00802674f, 0.04221533f, 0.01928607f, -0.06808934f, 0.08436182f, -0.08713708f, -0.34821022f, -0.13915081f, 
    -0.07456199f, -0.00985104f, -0.07979918f, -0.03429346f, -0.11843913f, -0.01786191f, 0.07674012f, 0.02911573f, 
    -0.13685866f, 0.03160971f, 0.03036025f, 0.21526629f, 0.04728159f, 0.05521005f, 0.02985096f, 0.50923032f, 
    0.35408998f, 0.02230195f, -0.06085949f, -0.03402545f, -0.23666577f, -0.07947057f, -0.00704854f, -0.00784501f, 
    0.12808335f, -0.03800835f, -0.29474944f, 0.09595569f, -0.03396923f, -0.05112229f, 0.04292945f, 0.01104210f, 
    -0.07508371f, 0.12607156f, 0.24532372f, -0.25067392f, 0.03451356f, 0.12960353f, -0.10225377f, -0.04115596f, 
    -0.02536933f, 0.17349248f, 0.06914144f, 0.17592853f, -0.36283439f, -0.07547149f, 0.04604004f, 0.03649696f, 
    -0.06711783f, -0.06296288f, 0.00020540f, 0.00529796f, 0.37921834f, -0.00865435f, -0.17188852f, 0.09862114f, 
    -0.10517849f, -0.00281579f, -0.03322947f, -0.09245364f, -0.13798322f, 0.00056820f, -0.44045073f, 0.10228376f, 
    -0.13247451f, 0.07743093f, 0.07465018f, -0.01164117f, -0.16080695f, 0.21581435f, -0.15472643f, 0.26315293f, 
    -0.01306692f, -0.05015223f, 0.04339934f, -0.00276359f, 0.08489411f, 0.02132170f, 0.28098705f, -0.06770268f, 
    -0.26887712f, 0.09159697f, -0.11490450f, 0.16815546f, 0.01556796f, 0.01169404f, -0.01779746f, -0.14023493f, 
    -0.46146941f, -0.01117674f, -0.19164185f, 0.15260743f, 0.07903709f, -0.03712909f, 0.07376926f, -0.21417698f, 
    -0.23391114f, -0.17964910f, -0.04232611f, 0.13831423f, 0.01331104f, 0.13049759f, 0.04650679f, -0.02850425f, 
    -0.06050687f, -0.21182613f, 0.07906311f, 0.10228901f, -0.01670120f, 0.04943843f, 0.11566198f, -0.00725401f, 
    -0.06619173f, -0.07960147f, -0.14287183f, -0.07524367f, -0.00606052f, 0.12971210f, 0.13445978f, -0.00442423f, 
    -0.07914700f, 0.03788628f, -0.05354091f, -0.24204950f, -0.04699722f, -0.01606763f, -0.01184812f, 0.07216261f, 
    0.13149595f, 0.14530168f, 0.01974838f, -0.11435093f, 0.18399327f, -0.09160353f, -0.07917780f, -0.17000394f, 
    0.02392202f, 0.02307763f, 0.13693497f, 0.07149641f, 0.09711960f, -0.08568800f, -0.03988858f, -0.01084739f, 
    -0.16455096f, 0.03174378f, -0.02777457f, -0.10038278f, 0.09780715f, 0.20817970f, 0.11955397f, 0.07687445f, 
    -0.04863340f, 0.16869566f, 0.09446577f, -0.02681699f, -0.01920409f, 0.14021544f, -0.05510090f, -0.05813370f, 
    0.00144717f, 0.07094560f, -0.02826265f, 0.11956687f, 0.03603310f, -0.07619684f, 0.07342667f, 0.05178946f, 
    -0.01889369f, 0.15053773f, 0.01107837f, -0.21426493f, -0.06949602f, -0.12590973f, 0.01723895f, 0.08338904f, 
    -0.07686624f, -0.44736454f, -0.23882939f, -0.08491872f, 0.01965187f, -0.02139721f, 0.05230376f, -0.05561756f, 
    0.02837821f, -0.04175498f, -0.32805401f, -0.06536616f, 0.00224466f, 0.14406793f, 0.15484361f, 0.02948717f, 
    -0.01113732f, 0.07805768f, -0.03320636f, 0.08565160f, 0.15175779f, -0.14613158f, -0.11449088f, 0.12712283f, 
    0.09080479f, -0.03303031f, 0.05816433f, 0.02200679f, 0.14871605f, 0.07926189f, 0.01137482f, 0.04122376f, 
    0.01139560f, -0.12791206f, -0.09002029f, 0.02106478f, -0.06100789f, 0.01444165f, -0.00996710f, -0.05310579f, 
    -0.07827043f, 0.00376615f, -0.10900900f, -0.07841573f, 0.10046846f, -0.13416760f, 0.11326458f, 0.08151519f, 
    -0.09078857f, -0.08168975f, -0.09533787f, 0.09907970f, 0.01508348f, -0.06610736f, -0.11327619f, -0.02597455f, 
    0.01068419f, -0.01880735f, -0.06094566f, -0.03715812f, 0.06044907f, -0.03174237f, -0.06971128f, -0.04098883f, 
    0.18457916f, 0.14863625f, 0.06636044f, 0.10034367f, 0.08374581f, -0.05522280f, 0.00243644f, 0.04502499f, 
    0.12422458f, 0.14562899f, 0.05998918f, -0.04309568f, -0.00877254f, 0.00381405f, -0.08748500f, -0.03494546f, 
    0.06902774f, -0.09687829f, -0.12422299f, -0.01247694f, 0.04827040f, -0.07837548f, -0.13954334f, 0.18245588f, 
    0.07900197f, -0.00002156f, -0.03662068f, 0.14088047f, 0.07182238f, -0.10646193f, 0.07128701f, -0.03007115f, 
    -0.16665624f, -0.02441350f, 0.10937723f, -0.01854834f, 0.16758788f, 0.08765204f, -0.13262834f, -0.06972766f, 
    -0.03490494f, 0.00049532f, 0.08626522f, 0.03458014f, -0.12395307f, -0.06504011f, 0.02112414f, 0.13976625f, 
    -0.26445884f, -0.07559461f, 0.11131571f, -0.05229110f, -0.07152381f, 0.29659984f, -0.27708328f, -0.12004010f, 
    -0.01665420f, 0.06783626f, 0.00635383f, 0.08163781f, 0.00788766f, 0.02054297f, 0.02363561f, 0.22675778f, 
    -0.08893853f, 0.03054883f, -0.02245115f, -0.01007991f, 0.04416727f, 0.00009852f, -0.00299967f, 0.17501153f, 
    0.01767105f, 0.03247379f, -0.03688879f, 0.06483363f, 0.05554088f, 0.09557334f, 0.01096235f, 0.07929951f, 
    -0.01508021f, 0.04920379f, 0.06776855f, 0.02438400f, -0.06252751f, 0.23361637f, 0.13628611f, -0.11774205f, 
    0.00004271f, 0.13934444f, -0.47302186f, -0.18181013f, -0.04090574f, 0.10057709f, 0.15947603f, 0.01381772f, 
    0.05444053f, 0.03974818f, -0.19347879f, 0.11893680f, 0.16093728f, -0.03786204f, -0.05775626f, 0.08862112f, 
    0.12446114f, 0.00284261f, 0.20094384f, 0.00288741f, 0.10092060f, 0.14515166f, 0.16125211f, 0.12035228f, 
    0.04523443f, -0.07420523f, -0.09397245f, -0.22419019f, 0.16238308f, -0.02819337f, 0.14305280f, -0.00204651f, 
    -0.13940422f, 0.15674378f, -0.14866740f, -0.01587425f, -0.19827525f, -0.21935658f, 0.04366823f, 0.20700808f, 
    -0.00731538f, -0.07290240f, 0.00997132f, -0.07992127f, 0.07922548f, 0.02893394f, -0.03395373f, 0.01603646f, 
    0.17510720f, -0.03825898f, 0.01061781f, -0.15585756f, 0.05021521f, 0.12864617f, 0.04015666f, 0.07281213f, 
    -0.11635949f, -0.05165678f, 0.03437183f, -0.21249913f, 0.17084289f, -0.08695941f, -0.02411112f, -0.05373918f, 
    -0.04313584f, 0.11755536f, -0.10927686f, -0.02778759f, -0.00987167f, -0.20968702f, 0.09550732f, 0.14713705f, 
    0.20873080f, -0.07259965f, -0.11745854f, 0.11810261f, -0.01967498f, 0.06679332f, -0.01940198f, 0.04937891f, 
    0.04264065f, 0.11546942f, 0.00950047f, -0.39296070f, 0.04500090f, 0.10043197f, 0.10944031f, -0.01564681f, 
    0.15125039f, 0.12209035f, 0.10685592f, -0.02745968f, -0.16823483f, -0.12477139f, 0.12813924f, 0.01295884f, 
    0.24901269f, 0.00270035f, -0.10008419f, 0.02486965f, 0.01766620f, 0.01523963f, -0.06205556f, -0.08015676f, 
    0.12993526f, 0.12114736f, 0.11333515f, 0.01717750f, 0.00525930f, 0.07833745f, -0.07414183f, 0.02139805f, 
    -0.02518135f, -0.27626899f, -0.10570858f, 0.00808595f, 0.17645542f, 0.07286291f, -0.01090116f, -0.36413905f, 
    0.08808349f, 0.07769119f, 0.15309756f, -0.06060957f, -0.03298239f, -0.18442518f, -0.11030102f, 0.02575149f, 
    -0.26546669f, -0.21095593f, -0.11448190f, 0.21539700f, 0.04793900f, 0.08025976f, 0.07831394f, -0.07383474f, 
    -0.03398661f, -0.19845523f, 0.11163799f, 0.14046025f, -0.10845366f, 0.15745679f, -0.05123271f, 0.08598061f, 
    -0.14321120f, -0.02242034f, 0.14716874f, 0.18247060f, 0.01207027f, 0.05332442f, 0.00033580f, 0.09798614f, 
    -0.02577354f, 0.09417989f, -0.01955193f, 0.27845582f, 0.14912891f, -0.20396812f, 0.10584915f, 0.11111762f, 
    0.23942602f, 0.17627358f, -0.13592146f, -0.00389115f, -0.07320004f, -0.09286129f, 0.02632990f, 0.09207655f, 
    -0.01965494f, 0.01568218f, 0.04678719f, 0.14836293f, -0.01431568f, -0.26407728f, -0.00270571f, -0.20401865f, 
    0.21299034f, 0.05270843f, 0.01286801f, -0.02013777f, -0.06876042f, 0.03336048f, 0.14953776f, -0.26315513f, 
    -0.07758483f, -0.08049338f, 0.01739439f, -0.18999393f, -0.03882237f, 0.05748734f, 0.06428056f, -0.17373119f, 
    0.19168274f, 0.08320072f, 0.19258083f, -0.07052626f, -0.02373597f, -0.00558138f, 0.09838297f, -0.02575582f, 
    0.04114051f, -0.10164835f, 0.00688241f, -0.41309264f, 0.06644645f, 0.03675720f, 0.02010658f, 0.09238393f, 
    0.05152412f, -0.14691396f, -0.16577613f, -0.10148336f, -0.19455698f, -0.05860318f, 0.10062758f, 0.28173497f, 
    0.10685057f, 0.05962846f, -0.27152050f, 0.05070869f, -0.15276267f, 0.06662555f, 0.02871181f, 0.10855427f, 
    0.07565849f, 0.01874487f, -0.07107393f, -0.02895065f, -0.00239120f, 0.07735564f, -0.10764665f, -0.17561047f, 
    -0.14606968f, -0.14049193f, 0.02503647f, -0.04212363f, -0.11854922f, -0.01238273f, -0.41398838f, 0.21426059f, 
    -0.05102487f, 0.14997996f, -0.07251555f, 0.01422062f, 0.09643155f, -0.01663196f, 0.05386194f, 0.08507666f, 
    0.08624897f, 0.18147898f, -0.10143979f, 0.15061747f, -0.13947438f, 0.16683444f, 0.01975485f, 0.14598805f, 
    -0.01589213f, 0.11471348f, 0.07516692f, 0.11037510f, -0.02236754f, -0.10358998f, -0.12206072f, 0.18165912f, 
    0.12159833f, -0.02881054f, -0.05480296f, 0.02596534f, 0.10154770f, 0.15492439f, 0.05053646f, -0.16637100f, 
    0.07790536f, -0.10093383f, 0.20622844f, 0.00981862f, 0.03222843f, 0.01405167f, -0.01712984f, -0.04451448f, 
    0.00431658f, 0.07997794f, 0.12344462f, -0.04226571f, 0.16409338f, 0.20759583f, 0.20406990f, 0.05811369f, 
    -0.01748478f, 0.02489609f, -0.09065884f, -0.04597650f, 0.31944054f, 0.04754485f, 0.19189192f, 0.11393448f, 
    0.07262884f, 0.08024016f, -0.00326169f, -0.08131570f, 0.01616394f, -0.35942492f, 0.21676853f, 0.00841820f, 
    0.00098286f, -0.09939574f, -0.12121794f, -0.04612823f, -0.00373545f, -0.04924901f, 0.20903157f, -0.18063982f, 
    0.04186751f, -0.19040504f, 0.19766818f, 0.08071102f, 0.12271909f, -0.13613318f, -0.25195551f, 0.24088548f, 
    0.09091654f, 0.00990530f, -0.07458439f, -0.11780501f, -0.14716469f, -0.05892707f, 0.02428179f, -0.14529972f, 
    -0.07655683f, -0.08717749f, 0.07299956f, 0.05214235f, -0.08437984f, -0.11803059f, 0.05358190f, -0.09571379f, 
    -0.10697091f, -0.04178885f, -0.06808522f, 0.00543625f, -0.14039201f, 0.21553952f, 0.10956414f, 0.11064571f, 
    -0.00221518f, 0.07642446f, -0.01905775f, 0.04545919f, -0.17322552f, 0.21729356f, -0.05229798f, 0.08720517f, 
    0.08878651f, 0.00562913f, 0.05125671f, -0.08110904f, 0.18326965f, -0.03145789f, -0.00859043f, 0.11024263f, 
    -0.02817769f, 0.08689725f, 0.18236260f, 0.34080213f, 0.06867519f, -0.01604289f, -0.06771392f, -0.14172733f, 
    0.18072803f, 0.05209872f, -0.02616522f, 0.08479922f, -0.08034137f, 0.05123432f, -0.06634346f, 0.07298727f, 
    -0.15518120f, -0.05130671f, -0.05576278f, -0.00546982f, -0.33475876f, -0.18601646f, -0.16559374f, 0.10202171f, 
    0.06848807f, -0.02238943f, 0.06712797f, -0.06380860f, 0.05287522f, -0.36623561f, 0.11022826f, -0.21610366f, 
    0.04212604f, 0.11962184f, 0.09670541f, 0.02504290f, 0.11436237f, -0.04713697f, 0.00263793f, 0.10205366f, 
    0.13765128f, 0.09879839f, -0.19353126f, 0.16350263f, -0.05676629f, 0.10504293f, 0.00657841f, 0.01703504f, 
    -0.12897484f, -0.10194988f, -0.01480191f, 0.13779463f, 0.06212395f, -0.04902207f, -0.00235572f, -0.14371531f, 
    -0.17851642f, 0.24179438f, -0.06649348f, -0.08793944f, 0.12507476f, -0.01908792f, 0.00861511f, -0.06400587f, 
    -0.00652812f, -0.00570066f, 0.21097738f, 0.02556432f, -0.01071879f, -0.02957352f, 0.09862132f, 0.07435399f, 
    -0.01081882f, 0.04807743f, 0.26369354f, -0.01303136f, 0.11728973f, -0.18658413f, 0.12065899f, -0.18105333f, 
    0.09915285f, 0.06070644f, 0.07093914f, 0.15725863f, 0.02853159f, -0.39630410f, 0.03845038f, -0.18997832f, 
    -0.03273845f, 0.18871875f, 0.02327331f, -0.16355793f, -0.14108096f, -0.31152773f, -0.19949044f, 0.03312213f, 
    0.12659797f, 0.11205874f, -0.02221187f, -0.09985299f, 0.12165890f, -0.04952307f, -0.12336904f, -0.16171923f, 
    0.00417014f, 0.00396439f, 0.01927575f, -0.01832375f, 0.01375109f, 0.01267262f, -0.17690055f, -0.29416627f, 
    -0.08849146f, 0.01458463f, 0.03405235f, -0.01315903f, -0.05865645f, -0.01972748f, -0.11046542f, 0.08763898f, 
    -0.27924329f, 0.00197359f, -0.04764701f, 0.04983621f, -0.07757918f, -0.01529327f, -0.02850457f, -0.01323339f, 
    0.02730642f, 0.05270410f, -0.06470013f, -0.00006965f, 0.03975875f, 0.16904338f, 0.00409337f, -0.04808443f, 
    0.06231853f, -0.37330288f, 0.01047299f, 0.09917119f, 0.04968685f, -0.03816838f, 0.12222789f, -0.00125987f, 
    -0.01013939f, -0.07129273f, 0.08241361f, -0.16183832f, -0.16781548f, -0.09645682f, 0.01541129f, -0.01598445f, 
    -0.02362821f, 0.09502838f, 0.01864564f, -0.31948817f, -0.31106010f, 0.11085109f, 0.02707411f, -0.06436133f, 
    0.02959809f, 0.02006384f, 0.07394538f, -0.01828143f, -0.30323282f, 0.03533831f, 0.02330368f, 0.03733699f, 
    0.09819673f, 0.09885383f, 0.03127624f, -0.18193623f, -0.08147189f, -0.11741436f, -0.02188662f, -0.12746307f, 
    0.10588702f, 0.07862287f, 0.09286844f, 0.25295261f, -0.15514822f, -0.10382707f, 0.20250194f, 0.20009588f, 
    0.08415530f, 0.13981096f, 0.01267900f, -0.02672386f, 0.05826423f, 0.09622176f, 0.14404425f, 0.08911336f, 
    0.20727430f, -0.14469299f, 0.01052079f, -0.02786971f, -0.11665995f, -0.01551205f, -0.08018793f, -0.08758419f, 
    0.27844584f, -0.02240752f, -0.07957003f, -0.06403319f, -0.17943995f, -0.06695323f, 0.01881731f, -0.02138109f, 
    0.13497613f, -0.03260214f, 0.33959422f, -0.26148263f, 0.11581825f, -0.04566524f, -0.02197819f, 0.06854235f, 
    -0.05334707f, -0.11954896f, 0.17293537f, 0.06090089f, 0.05690956f, -0.05084927f, -0.06953126f, 0.12018716f, 
    0.11724922f, 0.00873043f, 0.03487116f, 0.15536678f, -0.15067677f, -0.45708671f, -0.04079995f, 0.04134681f, 
    -0.01793974f, 0.04091950f, -0.08843685f, -0.03753985f, -0.03249851f, -0.10477997f, -0.10836450f, 0.17331351f, 
    0.14464919f, 0.22164355f, -0.08658534f, 0.08068372f, -0.03109792f, -0.25111431f, -0.22323871f, 0.07398718f, 
    -0.03421579f, 0.15430388f, -0.02153994f, 0.09437788f, -0.00268412f, 0.11980241f, 0.07022879f, -0.19799958f, 
    -0.34633696f, 0.04758189f, 0.10493889f, 0.01202761f, -0.02895173f, 0.02392786f, 0.02916551f, -0.06356890f, 
    -0.09635173f, 0.06251649f, 0.00224098f, -0.06692347f, 0.03296131f, 0.05276285f, -0.07991003f, -0.01423443f, 
    -0.27937475f, 0.14653163f, 0.09425637f, -0.02355787f, 0.18500732f, 0.02384292f, 0.06456464f, 0.00069656f, 
    -0.01350562f, -0.26041359f, -0.24317983f, -0.08208486f, 0.12586239f, 0.03493005f, -0.07742571f, 0.13569850f, 
    0.25215027f, -0.06766377f, 0.00152796f, 0.14081997f, 0.07436819f, 0.11483222f, -0.02646348f, -0.21132292f, 
    0.07314175f, 0.12808295f, 0.06828111f, 0.05590069f, 0.09831524f, -0.11272968f, 0.01795797f, 0.09337481f, 
    -0.05653330f, 0.04438489f, 0.04779875f, 0.06081100f, -0.30870873f, -0.07318880f, -0.14477396f, 0.03966036f, 
    0.04066011f, 0.04896932f, 0.09157056f, -0.13166244f, 0.08502021f, -0.34744152f, -0.03986830f, 0.25030577f, 
    -0.11328900f, 0.12744558f, -0.21294212f, -0.03842473f, -0.02437037f, 0.03682154f, -0.11119550f, -0.18475194f, 
    -0.37085235f, 0.04194499f, -0.01182651f, -0.03525895f, 0.13802664f, 0.11375454f, 0.14392163f, -0.28037873f, 
    0.07559694f, 0.19054399f, 0.08680883f, -0.03632573f, 0.05929282f, 0.00057348f, 0.00327287f, 0.08131268f, 
    0.19048591f, -0.20282732f, 0.27106991f, -0.06808531f, 0.08961403f, 0.00473847f, -0.09119118f, -0.16750494f, 
    0.25166124f, 0.28979078f, 0.05589131f, 0.04476102f, 0.00391796f, 0.12465521f, 0.01327728f, 0.11803713f, 
    0.12309793f, 0.02180110f, 0.03496189f, 0.07778915f, 0.15272076f, 0.00837940f, 0.06627157f, -0.18114166f, 
    0.07145151f, 0.07377234f, 0.07184634f, -0.03145993f, 0.03188143f, -0.04809718f, -0.03561638f, -0.07199694f, 
    -0.16567819f, 0.11699940f, -0.04196957f, -0.15608329f, -0.29792807f, 0.06608343f, -0.06543040f, 0.01932484f, 
    0.04013039f, 0.12225655f, -0.04991636f, 0.04590829f, 0.04090995f, 0.18668675f, -0.04519264f, 0.03381660f, 
    -0.12474518f, 0.03657828f, 0.06520388f, -0.04095542f, 0.01662933f, 0.02843110f, -0.08731735f, 0.05829855f, 
    0.15203272f, -0.03701665f, -0.01111772f, 0.04695822f, 0.12747198f, -0.03075765f, -0.09108388f, 0.16032830f, 
    0.17812675f, -0.16410081f, 0.00278319f, -0.11022241f, -0.09236677f, 0.08377132f, 0.03494084f, 0.24336003f, 
    -0.24830604f, -0.07645979f, -0.50406075f, 0.21053100f, 0.15918630f, 0.01871431f, -0.03619780f, -0.01031050f, 
    0.03650581f, -0.19668181f, -0.15065648f, -0.30875933f, -0.06166609f, 0.09746325f, 0.03178485f, 0.09768290f, 
    -0.13047627f, 0.06121195f, -0.10287903f, -0.07809711f, -0.20154703f, 0.12986520f, -0.10991603f, -0.15923519f, 
    0.13567507f, -0.12334575f, -0.02300669f, -0.18312195f, 0.17854831f, 0.08504702f, 0.08994851f, -0.08799443f, 
    -0.07004508f, -0.05414454f, 0.06550126f, -0.00848666f, 0.08507859f, -0.19631632f, 0.09906328f, -0.05571178f, 
    0.12868464f, -0.00340694f, -0.18636550f, 0.02565490f, 0.05488363f, 0.38673452f, 0.05935090f, 0.20164520f, 
    0.01930338f, -0.14621946f, 0.04594488f, 0.00212267f, 0.13464302f, 0.02943363f, 0.15693392f, 0.16491015f, 
    0.02780033f, 0.09839106f, -0.09630219f, -0.02327347f, 0.15559182f, 0.02054088f, 0.11680330f, -0.05423289f, 
    -0.04525121f, -0.04342907f, -0.06695148f, -0.06460627f, 0.10925177f, -0.08473909f, 0.06276485f, 0.04204213f, 
    0.04160337f, 0.10183873f, -0.15430109f, 0.00114250f, 0.02918027f, 0.12467276f, 0.02357379f, -0.00495838f, 
    -0.05120379f, -0.07252480f, -0.01239056f, 0.23535886f, 0.13686039f, -0.20425585f, -0.09155947f, -0.08267074f, 
    0.03640283f, -0.04174318f, -0.11284357f, -0.01746946f, -0.03940649f, 0.18858857f, 0.08069334f, -0.01415121f, 
    -0.09203316f, 0.04066757f, -0.01613997f, 0.19347060f, -0.18427607f, 0.01634277f, -0.26958534f, -0.22252294f, 
    -0.00053938f, -0.10131536f, -0.00457411f, -0.15389922f, -0.29016763f, -0.14666826f, -0.37332705f, 0.16424371f, 
    -0.00534916f, 0.23344614f, 0.02863534f, 0.10626452f, 0.41763291f, 0.14942485f, -0.13343370f, -0.08236699f, 
    -0.13561194f, 0.03485418f, 0.05422805f, -0.08969517f, -0.01555972f, 0.20175378f, -0.34826192f, 0.04142933f, 
    -0.05945638f, 0.10468175f, -0.02014262f, -0.00112672f, -0.08773363f, -0.09169588f, 0.04744152f, -0.04479117f, 
    0.00055390f, -0.02812594f, -0.03244699f, -0.19761465f, 0.09721662f, -0.19900775f, -0.00078320f, 0.17341876f, 
    -0.01666954f, -0.09667460f, -0.10986894f, 0.05599452f, -0.09853502f, 0.12627646f, 0.00254216f, 0.04872807f, 
    0.01168941f, -0.01442002f, -0.14973272f, -0.05813660f, -0.01679103f, -0.01516361f, -0.00392706f, -0.20715809f, 
    -0.03015648f, 0.06069899f, 0.01960001f, -0.33524838f, 0.03201816f, -0.11571450f, -0.09177379f, -0.02511804f, 
    -0.05106921f, -0.04416490f, 0.10660304f, -0.04804521f, 0.15329316f, -0.07754563f, -0.13680966f, -0.08240653f, 
    0.00299256f, -0.12506683f, 0.11500160f, 0.02929689f, 0.13191195f, 0.00887714f, 0.05215399f, 0.11769878f, 
    -0.06984586f, 0.03350614f, -0.02113405f, 0.04110474f, -0.02001211f, -0.00461061f, -0.04299149f, 0.24499452f, 
    0.00912716f, -0.07886635f, -0.02058203f, -0.03845218f, 0.07448703f, -0.00696422f, 0.22344911f, -0.27389896f, 
    -0.14956078f, -0.03888044f, -0.16606660f, 0.01980790f, -0.23266724f, 0.01442133f, -0.00072910f, -0.11435758f, 
    0.08790811f, 0.26516721f, 0.10406246f, -0.02130778f, -0.01156192f, -0.01753082f, -0.10167998f, -0.05830342f, 
    -0.00110094f, -0.18839073f, 0.04659458f, -0.02395140f, -0.04294306f, -0.06416275f, -0.03824157f, -0.01037812f, 
    -0.09260005f, -0.18134129f, -0.19505130f, -0.10024402f, 0.00551333f, -0.04143002f, -0.01093770f, -0.02332747f, 
    0.05378656f, -0.10799932f, 0.00219244f, -0.02866932f, -0.42658880f, -0.09671199f, 0.13245378f, -0.14784147f, 
    -0.02613950f, -0.11327734f, -0.07106107f, -0.02000692f, 0.05616153f, 0.05985604f, 0.22514366f, 0.13921534f, 
    0.11218016f, 0.01648375f, -0.04160012f, 0.13663514f, 0.18700226f, -0.00793849f, 0.09920207f, -0.12103534f, 
    -0.00871372f, -0.19804874f, -0.04535636f, -0.13764256f, -0.08225435f, 0.07597083f, -0.09840430f, -0.01382997f, 
    0.01001439f, -0.06470093f, 0.01795364f, 0.00305298f, -0.05600779f, -0.00129837f, 0.28799686f, 0.18750459f, 
    0.15659617f, -0.00373597f, -0.03135013f, 0.00254036f, -0.12049281f, -0.06072925f, -0.04422012f, 0.21152228f, 
    0.23888631f, 0.03407791f, -0.16793059f, -0.19200341f, 0.00055264f, 0.01690082f, -0.08032944f, 0.06488175f, 
    0.25683618f, -0.23476493f, -0.07757595f, -0.03365038f, 0.02621637f, -0.01334958f, -0.06115009f, -0.00917306f, 
    0.01056989f, 0.55116200f, 0.16960254f, 0.21236564f, 0.05277106f, -0.06223683f, 0.02900520f, -0.24192807f, 
    0.14645781f, 0.05503794f, -0.07802237f, 0.02919167f, 0.04928067f, -0.02952440f, 0.01970591f, -0.01351542f, 
    -0.10331734f, 0.05488680f, 0.01869388f, 0.32792598f, 0.31363168f, 0.11694481f, -0.00672521f, 0.02498366f, 
    -0.13780650f, -0.01497342f, -0.04570802f, -0.09696086f, -0.02217299f, -0.12212624f, -0.03358604f, -0.10536943f, 
    0.01075712f, 0.04479572f, -0.04463417f, -0.00416486f, 0.09571701f, 0.14613135f, 0.10969096f, 0.19768326f, 
    0.23295826f, 0.02922151f, 0.10318668f, -0.12010368f, 0.04380307f, -0.12506998f, -0.09443633f, -0.01121046f, 
    -0.02156397f, -0.05020501f, -0.17178687f, -0.05594522f, -0.05254740f, -0.05385917f, -0.06002174f, 0.01346223f, 
    0.10549628f, 0.07060956f, -0.07658508f, 0.13504493f, 0.00517512f, 0.08200257f, 0.03008014f, 0.16206971f, 
    -0.09435643f, -0.06993347f, 0.05542561f, 0.02065667f, 0.14104757f, -0.08207626f, -0.12809579f, -0.00917357f, 
    -0.13680542f, 0.10376847f, 0.12963092f, 0.19153051f, 0.08475368f, 0.07464565f, 0.15913340f, -0.01213457f, 
    0.04680182f, 0.09441727f, -0.14100072f, -0.12803276f, -0.07642198f, -0.09698192f, -0.01915983f, -0.10981829f, 
    -0.01810587f, 0.06184902f, 0.02595623f, -0.10956157f, 0.22809331f, -0.00259611f, -0.04296270f, 0.20366123f, 
    -0.00742594f, 0.01888414f, -0.04533610f, 0.00417991f, 0.02816761f, 0.03678125f, 0.11217944f, -0.00398276f, 
    -0.15430441f, 0.07631900f, 0.06249957f, -0.01759998f, 0.09156365f, 0.29975492f, 0.00481129f, 0.01812038f, 
    -0.09867781f, -0.06999031f, 0.01628169f, 0.09083070f, -0.04222185f, -0.09597699f, 0.20496166f, -0.18295749f, 
    0.09501214f, 0.08029045f, -0.11173595f, 0.03162446f, -0.14897296f, 0.09940064f, -0.11720464f, 0.08241196f, 
    0.07857910f, 0.07951826f, -0.04569723f, -0.02978964f, 0.03166500f, -0.02472571f, -0.09965918f, 0.05132314f, 
    -0.18923721f, -0.02390986f, 0.08774145f, -0.11670638f, 0.04900319f, -0.09066283f, -0.03251681f, 0.03847747f, 
    0.01966546f, 0.03498748f, -0.06442034f, -0.00000493f, 0.03583001f, 0.09954034f, 0.11449670f, -0.00372355f, 
    0.07598452f, 0.01931714f, -0.04216697f, 0.01449194f, 0.05922494f, 0.11478304f, 0.04302018f, 0.24934308f, 
    0.04427125f, -0.05398031f, -0.12287237f, 0.01901288f, 0.23409946f, -0.02826675f, -0.20158736f, -0.32306832f, 
    0.08145134f, -0.07138754f, 0.10135795f, -0.04684140f, -0.04824568f, -0.04718018f, 0.03958355f, -0.08153834f, 
    0.05726117f, 0.03429487f, -0.20059563f, 0.08355232f, -0.13576196f, 0.14560358f, -0.07547504f, 0.00016596f, 
    0.08279421f, 0.04515075f, 0.10578080f, 0.02874115f, -0.07364769f, 0.15537763f, -0.05137439f, 0.06810859f, 
    0.27218476f, -0.12977968f, 0.06813312f, -0.35110098f, 0.03358344f, 0.03442331f, -0.02741225f, 0.01672482f, 
    -0.22647594f, 0.02074370f, 0.14179756f, 0.05532067f, 0.00619816f, 0.00914286f, -0.10876250f, 0.07729895f, 
    -0.03696039f, -0.02621265f, -0.02889108f, 0.04489149f, 0.07106593f, 0.01632793f, 0.09562521f, -0.07970642f, 
    -0.26374036f, -0.06065518f, 0.03608338f, -0.01949967f, -0.15357178f, 0.06305708f, -0.06743786f, 0.01032913f, 
    -0.01748745f, 0.04161340f, 0.26757750f, 0.18966778f, -0.06147306f, 0.09261464f, -0.14360261f, 0.20719968f, 
    0.09480875f, -0.06973141f, -0.05444632f, -0.03899132f, -0.05552441f, 0.05516095f, 0.02945886f, 0.14648643f, 
    0.21085373f, -0.12354008f, -0.11727370f, 0.04680438f, -0.04843167f, -0.11364526f, 0.05712964f, 0.13410810f, 
    0.08547878f, 0.08990310f, 0.01177647f, 0.16993411f, -0.15079331f, 0.14730883f, -0.07154728f, -0.00303473f, 
    -0.08763553f, -0.05444564f, -0.08684369f, -0.02552832f, -0.18035698f, -0.02601224f, 0.25249603f, 0.03671723f, 
    -0.01705337f, -0.03993555f, -0.04995314f, -0.19008690f, -0.01888054f, -0.11358321f, 0.16010801f, -0.02799568f, 
    0.12704477f, 0.08786760f, 0.18559483f, -0.22366883f, 0.00126592f, 0.05855781f, 0.02417513f, -0.06215966f, 
    0.23920262f, 0.13784249f, 0.05366939f, -0.06525793f, 0.05010781f, -0.16932607f, -0.11429488f, -0.09765355f, 
    -0.03356742f, -0.38625422f, -0.13786450f, -0.04800436f, 0.17263517f, 0.02071319f, -0.14093208f, -0.05510584f, 
    -0.08258304f, 0.07377984f, -0.43779406f, 0.02655916f, 0.01366381f, -0.22483528f, 0.04008589f, 0.17600577f, 
    0.13646759f, -0.10404809f, -0.18164366f, 0.07419438f, -0.06485575f, 0.06504440f, 0.12115704f, 0.03035265f, 
    -0.12234361f, 0.13058963f, -0.11073337f, 0.05637511f, 0.35343066f, -0.02644961f, -0.00239225f, 0.01135112f, 
    0.02521602f, -0.01702519f, -0.08425921f, -0.13757160f, 0.01794057f, -0.21839987f, -0.23628676f, 0.13280424f, 
    0.09838452f, 0.07019477f, -0.02280855f, -0.09690394f, -0.23694870f, 0.08616266f, -0.31428304f, 0.03748599f, 
    0.03642628f, 0.08898940f, 0.06781080f, -0.00625305f, -0.01075701f, 0.15464842f, 0.00844886f, 0.30544224f, 
    -0.08033021f, 0.14890487f, 0.24001394f, -0.01499020f, 0.18614811f, -0.05544787f, -0.08626263f, -0.01200997f, 
    -0.12631927f, 0.02376575f, 0.03622451f, -0.10614096f, 0.07976771f, 0.06094392f, 0.03853771f, -0.13195223f, 
    0.01852119f, -0.10792404f, -0.07777164f, 0.12246554f, 0.02721564f, 0.00825157f, 0.04550655f, -0.13912937f, 
    -0.15996136f, 0.04208028f, -0.01480095f, 0.29340783f, 0.22876579f, 0.07639880f, -0.02288491f, 0.06882846f, 
    0.05408759f, -0.01268614f, -0.09575135f, 0.00930164f, 0.10055688f, 0.19560963f, 0.03932150f, -0.09453378f, 
    0.02419358f, 0.08500770f, -0.06322970f, -0.03558844f, 0.15052517f, 0.07047949f, 0.09757342f, 0.05611533f, 
    0.01187429f, -0.17550781f, -0.07549684f, 0.07477365f, 0.13753384f, 0.02732881f, 0.05223094f, -0.10624354f, 
    -0.07638012f, -0.05046395f, -0.14108051f, 0.05469984f, -0.07516459f, -0.06194781f, 0.09880576f, -0.05885863f, 
    -0.11539502f, 0.04492741f, 0.11634389f, -0.12485452f, -0.06995839f, -0.18196979f, -0.06560636f, -0.00598761f, 
    -0.04563576f, 0.02430425f, -0.02035664f, 0.02778906f, -0.17147033f, -0.01869632f, -0.18778308f, 0.01327079f, 
    0.13921463f, 0.22556932f, -0.08524460f, -0.09204877f, 0.02118656f, 0.05896259f, 0.20103171f, 0.04148429f, 
    0.03563156f, -0.28843373f, -0.05231804f, -0.03437044f, -0.06289612f, 0.06210396f, -0.05096427f, 0.14173916f, 
    0.03396650f, 0.13983761f, -0.08248393f, 0.07983196f, 0.05543064f, 0.05264115f, -0.08504684f, 0.03217077f, 
    0.11817840f, -0.00536565f, 0.11805356f, 0.41019973f, -0.24811690f, 0.00619483f, -0.18512246f, -0.01203648f, 
    0.01386066f, -0.00743004f, 0.15177777f, 0.04808618f, 0.34493473f, -0.17530373f, -0.04474568f, -0.09930418f, 
    -0.09731542f, -0.01820140f, -0.07667302f, 0.00112326f, -0.01500480f, 0.09472968f, -0.08183580f, -0.05233410f, 
    -0.16470252f, -0.01890045f, 0.13074839f, 0.04370027f, -0.09373675f, 0.01280919f, -0.11918658f, 0.04407953f, 
    0.12558122f, 0.10689224f, -0.03792569f, -0.05681676f, -0.13588642f, 0.15750018f, 0.03308984f, 0.30425796f, 
    0.05642167f, 0.03272041f, -0.07799719f, -0.01910519f, -0.06739696f, -0.05734765f, -0.06238839f, 0.04365696f, 
    0.23755591f, -0.08665480f, 0.06298544f, -0.18630968f, -0.19130811f, 0.01100854f, -0.01821813f, -0.05147612f, 
    -0.10857087f, -0.17456789f, 0.13849702f, 0.08855943f, -0.03392301f, 0.19748567f, -0.09428579f, -0.10103808f, 
    -0.03571327f, -0.10701042f, -0.15152594f, 0.09449776f, 0.09379925f, 0.00202818f, -0.02949264f, -0.08693621f, 
    -0.03349745f, -0.00027524f, 0.08525735f, 0.06110809f, -0.09575831f, -0.26211277f, -0.10902918f, -0.03760662f, 
    -0.01891705f, 0.04817754f, 0.01744122f, 0.16589357f, 0.35025373f, 0.15155588f, 0.12000927f, 0.06069832f, 
    0.09158746f, -0.04228655f, -0.11916820f, 0.10069599f, -0.08370620f, 0.15327692f, 0.05766631f, -0.09493354f, 
    -0.09013188f, -0.05497970f, -0.07161919f, -0.06019391f, -0.12176638f, 0.03909487f, 0.32567036f, 0.00903565f, 
    -0.25860676f, -0.05879701f, 0.10963328f, 0.25304246f, -0.04486880f, -0.06920815f, 0.10930892f, 0.25337029f, 
    -0.14948310f, 0.06901627f, -0.18031843f, -0.07858955f, -0.05467072f, -0.04397615f, -0.06888450f, 0.02652886f, 
    0.26002532f, 0.26818058f, -0.06443139f, 0.14124008f, -0.07913382f, -0.02639802f, -0.05991313f, 0.07242744f, 
    0.03608522f, -0.44434080f, 0.12061919f, 0.07699757f, 0.08431092f, 0.28096116f, -0.14595830f, -0.14501147f, 
    0.04635273f, 0.16082065f, 0.12442864f, -0.00399169f, 0.11780123f, -0.00277491f, 0.02710060f, 0.09919766f, 
    -0.01301025f, -0.00762487f, 0.07591628f, 0.33282667f, -0.15648039f, -0.06163150f, -0.07183974f, 0.10832090f, 
    0.11884564f, -0.11091835f, 0.02882870f, -0.05697833f, -0.04720542f, 0.01013806f, -0.10153721f, -0.21835218f, 
    -0.10546202f, 0.01344270f, -0.04824895f, -0.01204365f, -0.04602773f, -0.24652025f, 0.04607014f, -0.04240877f, 
    0.12714125f, -0.00915352f, 0.05392719f, 0.07022561f, -0.06646188f, 0.02578171f, -0.16903989f, 0.03845163f, 
    -0.03906661f, -0.12978688f, 0.08526272f, 0.04251413f, -0.08620822f, -0.06110350f, -0.11974321f, 0.08386625f, 
    0.05291779f, -0.10898252f, 0.01915931f, -0.16692822f, -0.08174673f, -0.08834644f, 0.01211083f, 0.12131845f, 
    -0.02096101f, 0.15381072f, -0.14932106f, 0.05560941f, 0.00946052f, -0.02634216f, -0.03969318f, 0.01502041f, 
    0.02819308f, -0.00425165f, -0.05906271f, -0.06170923f, -0.13519637f, -0.03838254f, 0.04774840f, -0.04472382f, 
    -0.00817945f, -0.02287797f, -0.04282855f, 0.24004132f, 0.06706628f, -0.09919453f, 0.12833567f, 0.06725349f, 
    0.03667951f, -0.15457460f, -0.06845334f, 0.04642707f, -0.25863877f, 0.10353235f, -0.00421744f, -0.29032636f, 
    -0.03349967f, 0.10057142f, -0.03987980f, 0.02008416f, 0.23779491f, 0.02268022f, -0.20098633f, 0.09528352f, 
    0.01637831f, 0.01882946f, -0.06388982f, -0.00593466f, 0.15398619f, 0.31641760f, -0.20323284f, -0.27038887f, 
    -0.12458855f, -0.04835947f, -0.06891910f, -0.17237921f, -0.03685095f, -0.17870444f, 0.18189304f, 0.17143492f, 
    -0.12586550f, 0.12595172f, 0.10277535f, -0.03507390f, 0.00349000f, -0.08541730f, -0.09795654f, -0.11873057f, 
    0.12392319f, -0.00479300f, -0.05825856f, 0.13935988f, -0.06588860f, -0.00172146f, 0.14459859f, 0.06892663f, 
    0.04927398f, 0.03427346f, 0.02592176f, 0.01407668f, -0.05606975f, 0.02809460f, 0.03526458f, 0.02267474f, 
    -0.04422839f, -0.01640190f, -0.05587027f, -0.03717101f, 0.04986222f, 0.03799277f, -0.05360203f, 0.02407048f, 
    -0.01867740f, 0.02008089f, 0.00806908f, -0.00530470f, -0.05478039f, 0.03438494f, -0.01767341f, -0.01449035f, 
    -0.04655351f, -0.01887373f, -0.05450067f, 0.01058606f, -0.06358311f, -0.02271053f, 0.01941736f, -0.05176404f, 
    -0.02671839f, -0.01067606f, 0.03821069f, 0.00282369f, 0.02706582f, 0.04742512f, -0.05762503f, -0.03903686f, 
    -0.03192725f, -0.00780654f, 0.02485879f, 0.03040117f, -0.04429427f, -0.05918510f, 0.04427661f, 0.02936409f, 
    0.03777618f, 0.00615662f, -0.02322165f, -0.05013756f, 0.01203695f, -0.01157157f, -0.03773590f, 0.03271390f, 
    -0.01094049f, -0.03306983f, -0.00281662f, -0.05664124f, -0.05615646f, -0.01615104f, 0.03986559f, -0.03054236f, 
    0.02817761f, -0.03893656f, -0.03183325f, 0.02961775f, 0.04494850f, 0.04888736f, -0.04779674f, -0.05741399f, 
    0.04470927f, -0.06403731f, 0.04247429f, 0.01886535f, 0.00182226f, -0.02173215f, -0.00771088f, -0.04528048f, 
    -0.05763109f, 0.02768217f, -0.02680142f, 0.00816479f, 0.00075138f, -0.06512940f, -0.04235860f, -0.03079818f, 
    0.03526683f, 0.05194056f, 0.02735941f, 0.01781534f, -0.04716445f, 0.02099196f, -0.06122489f, -0.06203917f, 
    -0.03854605f, -0.05955426f, -0.00948269f, -0.04504293f, -0.01992998f, 0.02430486f, 0.02787033f, 0.01815619f, 
    0.02704060f, -0.01235110f, -0.04313286f, -0.06821163f, -0.04364089f, -0.04952920f, 0.03644357f, -0.05002526f, 
    -0.00869957f, -0.02302401f, -0.02226274f, -0.04344389f, -0.04315701f, 0.03010170f, -0.06535710f, 0.03097821f, 
    -0.04099021f, 0.02975324f, -0.00615940f, -0.02276016f, -0.03353148f, 0.00846802f, 0.02857164f, -0.05993389f, 
    0.03786945f, 0.01551304f, -0.02469335f, 0.00050656f, -0.01677771f, -0.03689736f, 0.03618642f, 0.00709452f, 
    -0.03448515f, -0.03397853f, 0.00927166f, 0.03913916f, 0.00294490f, -0.00861507f, 0.03174186f, 0.02118353f, 
    -0.05791581f, -0.00932474f, -0.04776785f, -0.05559990f, -0.06326222f, 0.00736641f, -0.05840301f, 0.01130492f, 
    -0.05279873f, -0.02892718f, -0.03089013f, 0.04629790f, -0.00588645f, -0.00674007f, 0.00647401f, -0.05899574f, 
    -0.06772025f, -0.02189164f, -0.01920912f, 0.03589742f, 0.00297263f, -0.01413718f, -0.06203713f, 0.00794139f, 
    0.01706313f, -0.01410910f, 0.00604937f, 0.06385360f, -0.02527255f, -0.01738564f, -0.04730468f, -0.01435953f, 
    0.05617132f, 0.02440564f, 0.04694484f, -0.04585303f, -0.01762047f, -0.02578053f, -0.01547855f, -0.04209897f, 
    -0.05962191f, -0.04398416f, -0.06425394f, -0.03510559f, 0.00655643f, 0.02565460f, -0.01341015f, -0.03529922f, 
    0.02674180f, -0.03832638f, -0.05539391f, -0.04187891f, -0.01215438f, -0.04800628f, -0.00832964f, 0.04392528f, 
    0.01448808f, -0.04834378f, 0.04183010f, -0.00794123f, -0.02638226f, 0.03072986f, -0.05243723f, -0.01414652f, 
    0.04712500f, 0.03824942f, -0.01325729f, -0.03017847f, -0.00227807f, 0.03950175f, -0.05141359f, -0.04446303f, 
    0.03850153f, -0.05226769f, -0.03280678f, -0.01051376f, -0.04488963f, 0.04832044f, 0.01583459f, -0.00121339f, 
    -0.00379399f, -0.01688685f, -0.02550317f, -0.00945260f, 0.03353705f, -0.00058548f, -0.05757742f, -0.02624248f, 
    0.03849154f, 0.03121481f, -0.01702870f, 0.03700759f, 0.01045334f, 0.03982363f, 0.00224362f, 0.01607274f, 
    -0.01879856f, 0.00255840f, -0.03555302f, -0.03547344f, -0.04767565f, 0.03246566f, -0.05523308f, -0.03859441f, 
    0.02312468f, 0.00045980f, 0.02765621f, 0.03465941f, -0.02940880f, 0.00321573f, -0.05828597f, -0.01083373f, 
    0.04862155f, 0.00462035f, -0.00272841f, -0.02701799f, 0.02571008f, -0.03400421f, 0.01046051f, 0.03283595f, 
    0.01816664f, -0.01830694f, 0.03997211f, 0.05131870f, -0.03613887f, -0.01723327f, -0.00800243f, 0.03467026f, 
    -0.02057527f, 0.03999247f, 0.01671772f, 0.04903264f, -0.03865762f, -0.05452350f, 0.04023072f, 0.01932148f, 
    -0.05117451f, 0.03451443f, -0.01575127f, -0.04360348f, 0.01311339f, 0.04568769f, 0.02145805f, 0.05220919f, 
    0.07981136f, 0.03419940f, -0.37346518f, -0.04419311f, 0.02218080f, -0.07493719f, 0.02021398f, 0.02572635f, 
    -0.28393075f, -0.05277276f, 0.15665489f, -0.04657400f, -0.02786818f, 0.04555898f, 0.09897101f, 0.16055669f, 
    -0.07455553f, -0.15648338f, -0.27097663f, -0.12619010f, 0.02719229f, 0.04527641f, -0.07847918f, 0.20966253f, 
    -0.05139715f, -0.06947343f, -0.15299889f, 0.23628345f, 0.16102427f, -0.01162913f, -0.12260819f, 0.02759207f, 
    0.01626246f, 0.02732762f, -0.11426082f, -0.11849619f, 0.24706621f, -0.01612573f, -0.00133433f, -0.14042789f, 
    0.08960298f, 0.03753078f, 0.01478589f, -0.07379242f, -0.10788660f, 0.10645248f, 0.00037439f, 0.16127719f, 
    0.04225450f, -0.02284539f, -0.11033605f, 0.14654848f, 0.01348369f, 0.13326739f, 0.19438058f, 0.02837554f, 
    -0.03248663f, 0.05983692f, 0.06521367f, -0.24491070f, 0.10595173f, -0.06571117f, -0.10864399f, -0.00767107f, 
    0.03501583f, -0.03194232f, 0.02902824f, 0.00061861f, -0.00748439f, -0.07687921f, 0.02461628f, 0.12035542f, 
    -0.01865127f, -0.03608460f, 0.01133548f, -0.07103941f, 0.06583058f, -0.05076063f, 0.05987633f, -0.03555670f, 
    0.00880682f, -0.10471577f, -0.09733408f, 0.04680905f, -0.24303564f, 0.06138575f, -0.01048250f, -0.13982973f, 
    0.09549011f, -0.18855664f, -0.04788956f, 0.07534893f, -0.26158378f, 0.01614317f, -0.06545017f, 0.10699770f, 
    -0.07895011f, -0.00178087f, -0.30875096f, 0.04413646f, 0.20291604f, 0.11492185f, 0.04592993f, 0.10006942f, 
    0.08779973f, -0.15710309f, 0.00800182f, 0.15521277f, -0.04665523f, -0.04283698f, 0.01804951f, 0.06037193f, 
    0.03209271f, -0.04165065f, -0.12352492f, 0.11872472f, -0.06625542f, -0.09850468f, -0.08531493f, 0.02783607f, 
    0.05942462f, 0.08644210f, 0.06890530f, -0.04111696f, -0.12656759f, -0.01576773f, 0.32783103f, 0.17005092f, 
    -0.03728769f, -0.10346717f, -0.07444348f, -0.05238328f, 0.02121123f, 0.06697714f, 0.04610556f, -0.08192625f, 
    -0.05311360f, 0.02806263f, 0.07258623f, -0.22052605f, 0.02301138f, -0.03167923f, -0.10621787f, -0.06322077f, 
    0.00948890f, -0.05716335f, -0.16351679f, -0.06317820f, 0.03738378f, -0.23815727f, -0.06113563f, 0.02365212f, 
    -0.01963908f, 0.29812768f, 0.07688968f, 0.15621519f, -0.11880719f, -0.18021278f, -0.01102073f, -0.14195101f, 
    0.15987019f, -0.10679630f, -0.20261933f, 0.02148398f, 0.06796111f, -0.05456950f, 0.11569417f, 0.10055787f, 
    0.05818842f, 0.04666096f, -0.03788055f, 0.26914173f, 0.02595413f, 0.12744601f, -0.04854768f, -0.08890328f, 
    0.01625358f, 0.00318585f, 0.15588853f, 0.04982502f, 0.02815690f, -0.04814472f, 0.04563627f, 0.02864563f, 
    0.08267436f, -0.05052751f, 0.02183830f, -0.06807870f, 0.02442810f, -0.03250904f, 0.03333396f, 0.12976858f, 
    -0.13538145f, -0.01805142f, 0.04943760f, 0.10667613f, -0.03963622f, 0.11356582f, -0.11916832f, -0.06901199f, 
    -0.03784837f, -0.08702805f, 0.05557133f, 0.03354569f, -0.05351963f, -0.00795505f, -0.12961304f, 0.03325349f, 
    0.16620164f, 0.12689714f, 0.08696373f, 0.01723016f, -0.02069702f, -0.07754365f, 0.00392366f, 0.07714972f, 
    -0.00871561f, 0.14554052f, -0.00816929f, -0.08850112f, -0.05883799f, 0.07623971f, -0.20092244f, 0.15943855f, 
    0.01794128f, 0.03983279f, 0.02585145f, 0.20486315f, 0.03141831f, 0.06707753f, 0.07915982f, -0.00073610f, 
    0.00186085f, 0.13181733f, 0.00577485f, 0.05737040f, 0.08150330f, -0.13556729f, -0.00395824f, 0.07453171f, 
    0.01252193f, -0.01584991f, -0.05591200f, -0.22115918f, 0.20526673f, 0.07041836f, 0.11245953f, -0.07362805f, 
    -0.00526943f, -0.05349538f, 0.15824322f, 0.04763773f, 0.04615787f, -0.03962120f, 0.09195805f, 0.14189781f, 
    -0.05843986f, 0.02224997f, 0.15556271f, -0.11055796f, 0.14574237f, 0.31124011f, -0.06371284f, 0.06786353f, 
    0.02719546f, -0.00286053f, 0.29983586f, 0.13726419f, -0.12990427f, -0.12032495f, 0.03523894f, 0.15361579f, 
    0.08549895f, 0.00997858f, 0.00260101f, -0.18599254f, 0.07555158f, 0.09554701f, 0.04319037f, 0.16788183f, 
    0.01323866f, -0.03146448f, 0.12814376f, -0.09336311f, -0.21803211f, 0.19469446f, -0.01366279f, 0.02273263f, 
    -0.08590361f, 0.07087696f, -0.11788682f, 0.12586513f, -0.06392249f, 0.02032837f, 0.01627781f, 0.00025131f, 
    0.01085217f, -0.21425042f, -0.22888868f, -0.18668105f, -0.08149154f, 0.04432669f, -0.08310383f, 0.05571603f, 
    -0.07405949f, -0.00707012f, 0.25505501f, 0.08648806f, -0.02029468f, 0.03711654f, -0.14903811f, 0.16919817f, 
    0.04397011f, 0.06188251f, 0.12636361f, 0.14734374f, -0.32837725f, -0.10308564f, 0.06527776f, 0.11026803f, 
    0.01611561f, 0.01144489f, 0.16127740f, -0.04248550f, 0.14936326f, -0.03301994f, -0.03322660f, -0.07851999f, 
    -0.06472238f, -0.08458522f, -0.01333659f, 0.07405598f, -0.06373292f, -0.00349700f, -0.05160947f, 0.17977670f, 
    0.03988105f, -0.03341803f, -0.14365152f, -0.03641676f, 0.01951405f, 0.00161152f, -0.50594860f, 0.06315916f, 
    -0.33470684f, 0.07793421f, -0.04437387f, 0.00779619f, -0.11125362f, -0.07066249f, -0.06528817f, 0.12189220f, 
    0.01999346f, 0.08960491f, 0.13664374f, -0.14933813f, -0.06545959f, -0.04883394f, -0.00249422f, 0.06170185f, 
    0.28355661f, -0.11406358f, 0.15385422f, 0.05316410f, -0.02640789f, -0.00778321f, -0.00406148f, 0.14159328f, 
    0.02436176f, -0.00679547f, 0.06074097f, 0.12160274f, 0.06841359f, 0.16999221f, -0.11628496f, -0.03449298f, 
    0.11344951f, -0.04232229f, 0.07715738f, 0.08984363f, 0.12121085f, 0.07493258f, -0.03502517f, 0.00513385f, 
    0.05163606f, 0.11676090f, 0.09821824f, 0.14495769f, 0.03334916f, -0.01900581f, 0.02860270f, -0.03478545f, 
    -0.00883958f, -0.08241493f, -0.00880655f, 0.03068915f, 0.35697189f, 0.13247430f, -0.06672110f, -0.14925803f, 
    -0.05348760f, -0.03354697f, 0.02870005f, 0.11589852f, 0.04007253f, 0.26174176f, 0.12020312f, 0.13746059f, 
    -0.07890848f, -0.05579128f, 0.00215407f, -0.02275385f, -0.03439264f, -0.04402167f, -0.31401804f, -0.08804686f, 
    -0.01447476f, 0.02666491f, -0.07351556f, -0.00323825f, -0.05307971f, 0.02185984f, -0.17385025f, 0.25397214f, 
    -0.00497424f, 0.04944448f, -0.12292822f, 0.00189563f, 0.08115236f, -0.10028992f, -0.03243482f, 0.00401372f, 
    -0.14656389f, 0.23004854f, -0.27881816f, 0.06155858f, 0.08586027f, 0.10000567f, -0.11896217f, 0.02571127f, 
    -0.19780570f, -0.32151288f, 0.08358081f, -0.06570864f, 0.13779736f, -0.08120812f, -0.14754483f, -0.10781711f, 
    0.05702623f, -0.11675839f, -0.00786542f, 0.01314675f, 0.02559263f, -0.05853627f, -0.00870800f, 0.01017702f, 
    0.13693295f, -0.00630852f, -0.05344998f, 0.20623653f, 0.22439209f, -0.04165010f, -0.26125401f, -0.04366339f, 
    -0.13096049f, 0.14681768f, -0.05830406f, 0.01667372f, -0.02449336f, 0.12184091f, 0.24413082f, -0.06481045f, 
    -0.11432242f, 0.02673343f, -0.01251239f, 0.02253806f, 0.00615091f, -0.30921316f, -0.04047896f, 0.10022719f, 
    0.14101374f, 0.01574710f, -0.08737744f, 0.06428596f, 0.07284024f, 0.05743033f, 0.01968133f, -0.02402623f, 
    0.18384010f, 0.12283096f, 0.12403850f, 0.06479007f, -0.04721999f, -0.00926697f, 0.26345387f, 0.22081089f, 
    0.07995538f, 0.13454691f, -0.06047237f, -0.22375692f, -0.05394374f, 0.02677588f, 0.13640219f, 0.05992100f, 
    0.05685068f, 0.17089097f, -0.13275014f, 0.06887327f, 0.14500946f, 0.15370734f, 0.01475002f, -0.00629958f, 
    -0.05090407f, -0.04283575f, 0.00693463f, 0.19857349f, 0.09726142f, -0.03589122f, -0.14224613f, 0.00158234f, 
    -0.02418313f, -0.04028039f, -0.22121374f, 0.06248342f, 0.01820424f, 0.27091020f, 0.07451256f, 0.15742654f, 
    -0.01221576f, -0.00876959f, 0.00727801f, 0.09284645f, 0.05628744f, 0.28323284f, -0.08928300f, -0.15009938f, 
    0.09664054f, 0.02197395f, -0.01973998f, -0.00136229f, -0.14349206f, 0.08214391f, -0.42213020f, 0.05427638f, 
    0.05553431f, 0.04283716f, -0.05511777f, -0.08265643f, -0.10184117f, 0.36704072f, -0.25493130f, -0.13448188f, 
    -0.18750432f, -0.03133976f, 0.22412731f, -0.06172479f, 0.04757309f, 0.06114682f, 0.02787630f, 0.11891785f, 
    -0.04536426f, -0.04390153f, -0.02106826f, -0.14051558f, -0.04820565f, 0.01166749f, 0.03175209f, -0.25233087f, 
    -0.20613068f, 0.04585798f, -0.00586342f, 0.05759365f, -0.13968590f, 0.01804195f, -0.00545637f, 0.00895288f, 
    -0.19896844f, -0.04127426f, 0.06668656f, 0.02959913f, -0.21156240f, 0.16336788f, -0.09871478f, -0.09544051f, 
    0.08813942f, -0.11071611f, -0.10566168f, -0.30989364f, -0.04858340f, -0.00134037f, 0.05498667f, 0.22031820f, 
    -0.02503509f, 0.04600791f, 0.13689724f, 0.13192032f, 0.13585500f, -0.06399284f, 0.10513068f, -0.01011643f, 
    -0.01212975f, 0.03867934f, -0.04489937f, 0.32916582f, -0.39098173f, 0.02054908f, -0.21579778f, 0.06292244f, 
    0.01247077f, -0.07828884f, 0.12950961f, -0.06562712f, -0.17258729f, -0.32238275f, -0.10439391f, 0.06677060f, 
    0.09368947f, -0.05493528f, 0.14929169f, -0.11614691f, 0.00085960f, 0.00450164f, 0.00573762f, 0.16673122f, 
    0.08657540f, -0.19233270f, 0.13358614f, 0.01317277f, 0.11780023f, 0.18730842f, -0.14260229f, -0.19176018f, 
    -0.14699128f, 0.04159313f, -0.02724560f, 0.00386473f, 0.01296131f, -0.12817264f, 0.17866960f, 0.62975347f, 
    0.00774234f, 0.08840170f, 0.03562340f, 0.05109807f, 0.09428473f, -0.00542427f, 0.13953349f, -0.06901212f, 
    0.12877250f, 0.16431789f, 0.05767332f, 0.01623766f, -0.10229138f, -0.14369194f, -0.18031183f, -0.05028066f, 
    -0.03649204f, -0.10499986f, 0.04695031f, 0.02231706f, -0.20054628f, 0.01640106f, 0.03088423f, 0.00109863f, 
    -0.05042525f, 0.15222967f, 0.11007851f, -0.17698297f, -0.02376337f, 0.13036962f, -0.00792492f, -0.03698801f, 
    -0.15058358f, 0.10883097f, 0.07656293f, -0.01438248f, -0.10242842f, -0.18940887f, 0.08185518f, 0.01826615f, 
    -0.00416022f, 0.11969023f, 0.13223080f, -0.00889845f, 0.03797908f, -0.17107144f, -0.06554060f, 0.02274759f, 
    0.12807815f, 0.07694534f, -0.03472649f, 0.10165060f, -0.05709802f, 0.44187474f, 0.00023011f, 0.09753580f, 
    0.04566685f, 0.06679891f, -0.14162338f, -0.03190350f, -0.07966461f, -0.06725383f, -0.42320541f, -0.11873147f, 
    0.04662603f, 0.22082661f, 0.12934349f, -0.09944856f, 0.09938951f, -0.01376902f, 0.19511037f, -0.02885805f, 
    -0.39957821f, 0.15791994f, -0.04608655f, 0.05028621f, -0.12601194f, -0.06161788f, -0.06389936f, -0.08348362f, 
    0.08810576f, -0.13640407f, -0.35287559f, -0.03537432f, -0.02001117f, 0.09496484f, 0.11544005f, 0.04688540f, 
    -0.05217981f, -0.36890650f, 0.04006580f, -0.26941267f, 0.09226062f, -0.11452431f, -0.00692596f, -0.03064875f, 
    0.02632991f, -0.06678322f, 0.06419063f, -0.02834554f, -0.13567786f, -0.00439943f, -0.19093136f, 0.16818500f, 
    0.01198660f, -0.00165049f, -0.02630464f, -0.28471798f, -0.11650671f, 0.15810457f, 0.17018585f, 0.14613308f, 
    -0.04347491f, -0.04434333f, 0.09683299f, -0.11410097f, 0.04737553f, 0.20821229f, -0.07225176f, 0.12156034f, 
    -0.02716866f, -0.02289853f, 0.02850983f, -0.07786139f, 0.04911614f, -0.03261534f, -0.01337299f, -0.31523699f, 
    0.04047879f, 0.11004626f, 0.17103669f, 0.07143889f, 0.12723093f, -0.09023825f, 0.10348998f, 0.17768958f, 
    0.12710249f, -0.03075536f, -0.10734257f, -0.16892987f, 0.00875275f, 0.01400018f, 0.16592544f, 0.03258054f, 
    0.02120133f, 0.04535833f, 0.01598750f, 0.10839823f, -0.13439202f, 0.01535167f, 0.11097262f, 0.10548165f, 
    0.02353793f, 0.04851165f, -0.05790725f, -0.00595552f, 0.03571232f, -0.10788706f, 0.08130904f, 0.11347214f, 
    -0.11599313f, 0.19532658f, 0.22525233f, -0.08203767f, 0.01781758f, -0.12884369f, -0.10156606f, 0.07052664f, 
    0.13366812f, 0.03756458f, 0.30024755f, 0.18106283f, -0.03306555f, -0.13171081f, -0.05597937f, 0.00016996f, 
    -0.06871909f, 0.05563529f, -0.06464391f, 0.24144785f, -0.19997175f, 0.04400589f, 0.11383760f, 0.02174585f, 
    -0.02577144f, 0.00615827f, 0.09880141f, 0.09505365f, -0.19318888f, -0.15344967f, -0.32404736f, 0.05497202f, 
    0.10384063f, 0.05150578f, -0.02139533f, 0.17161445f, 0.05247932f, -0.59211588f, -0.04855234f, -0.01929021f, 
    -0.26317641f, 0.05046339f, 0.04802023f, -0.03127779f, -0.08946265f, -0.02937048f, -0.25204894f, 0.17582799f, 
    -0.32491764f, 0.25005251f, 0.09766608f, 0.03473659f, -0.20918430f, -0.00191471f, -0.10676936f, 0.01214095f, 
    -0.13672782f, -0.16776456f, -0.01592684f, 0.18583600f, 0.21606134f, -0.00841144f, 0.03821504f, 0.02523354f, 
    0.01908030f, -0.00256313f, -0.01249669f, -0.01658626f, -0.03523342f, 0.02669251f, -0.03817318f, -0.02683043f, 
    -0.02204737f, 0.00227424f, 0.03801694f, 0.01155909f, -0.02420064f, -0.03882592f, -0.00057921f, -0.00076089f, 
    -0.03413551f, -0.02024579f, -0.01404254f, 0.03816978f, 0.01053894f, -0.01835874f, 0.01300809f, -0.01898639f, 
    -0.04463441f, 0.03924040f, 0.00708386f, -0.05651492f, 0.03426584f, 0.04109578f, -0.06191133f, -0.03210727f, 
    0.01983401f, 0.01997543f, -0.02134393f, -0.04730879f, -0.02314286f, -0.01785938f, 0.01997118f, -0.06081751f, 
    0.00385333f, 0.00518885f, 0.03062326f, 0.00588441f, 0.01749075f, 0.03472360f, 0.00284261f, 0.03910311f, 
    -0.06021368f, 0.03979438f, -0.03992610f, -0.05896836f, 0.02500426f, 0.01627292f, 0.03681602f, -0.02090924f, 
    0.02007581f, 0.01212708f, -0.02280630f, -0.05498926f, -0.05335746f, -0.00151263f, 0.04230294f, -0.05991619f, 
    0.03347563f, -0.06413440f, -0.01293872f, 0.02057135f, -0.00538108f, 0.03097731f, 0.01620937f, 0.01943934f, 
    0.00250060f, -0.00800285f, -0.06148548f, -0.01557265f, 0.03625968f, 0.02901018f, 0.02797920f, -0.06888200f, 
    0.02888518f, -0.00859977f, -0.01932339f, -0.02569851f, -0.04405195f, 0.02530399f, 0.02800088f, 0.03872259f, 
    -0.04771126f, 0.03322527f, 0.03990499f, 0.03181150f, -0.04115893f, 0.02773961f, -0.04070053f, -0.01972464f, 
    -0.06607164f, -0.02737526f, -0.04277102f, 0.03246513f, -0.05076596f, 0.04079914f, -0.06027443f, 0.01234275f, 
    0.04122200f, 0.03452354f, 0.03269514f, -0.06458216f, 0.00506469f, -0.04698484f, -0.01866203f, 0.00012887f, 
    0.04454252f, -0.05749280f, 0.00468467f, 0.04568688f, 0.01350858f, -0.02749414f, -0.06769522f, 0.00910576f, 
    0.01066500f, -0.03297810f, -0.04993365f, 0.04026888f, -0.05117432f, -0.04444364f, 0.04667994f, 0.02172599f, 
    -0.04728072f, 0.00677338f, 0.00693769f, -0.02970186f, -0.03776731f, 0.03914235f, -0.01369182f, -0.05134094f, 
    -0.01665126f, -0.06073227f, -0.04527961f, -0.00826423f, -0.04309545f, -0.00349012f, -0.01700700f, -0.02829945f, 
    -0.01349091f, -0.00787060f, -0.03147153f, -0.00565900f, -0.02222105f, -0.03403210f, -0.01108902f, -0.05014440f, 
    0.00813240f, -0.06903163f, -0.07550332f, 0.05643485f, -0.05169820f, 0.01034437f, 0.01284447f, 0.02282903f, 
    -0.00825396f, -0.04280625f, -0.02846461f, 0.03445722f, -0.06337609f, -0.01085288f, 0.02860669f, 0.01608464f, 
    0.01803261f, 0.04045148f, 0.03078460f, -0.00868385f, -0.05886906f, -0.03498274f, -0.01002153f, 0.00717068f, 
    0.00870292f, 0.00767769f, 0.04152489f, -0.03250239f, -0.01324324f, 0.02213237f, 0.02903611f, 0.00372959f, 
    0.00074099f, 0.03379843f, 0.00098339f, -0.04364911f, -0.00605671f, -0.00810279f, -0.00583074f, 0.02096515f, 
    -0.00806017f, -0.05424063f, -0.04424037f, -0.00464575f, 0.00472627f, -0.00122351f, -0.06035631f, -0.02501101f, 
    0.02880332f, -0.04749171f, 0.04915376f, -0.05437451f, 0.03408679f, 0.01772634f, 0.04177933f, -0.03228228f, 
    0.04162975f, 0.05259471f, 0.02690965f, -0.00648692f, 0.04434892f, -0.00010584f, 0.01720722f, -0.02538904f, 
    0.02727151f, -0.04526624f, 0.00006979f, -0.01082417f, 0.04490282f, 0.04287099f, 0.01799817f, -0.05166503f, 
    0.02738819f, -0.01926200f, -0.01690865f, 0.02979535f, 0.03469220f, 0.00932062f, 0.04852005f, -0.06167069f, 
    -0.00970013f, 0.04607213f, 0.00779481f, 0.03923555f, -0.04965956f, -0.06471793f, 0.00468991f, 0.00616965f, 
    -0.03942708f, -0.03190872f, -0.05715356f, -0.02068527f, 0.03000899f, 0.04551495f, 0.03057849f, 0.04275605f, 
    0.05120922f, 0.01893969f, -0.01343430f, -0.06241681f, 0.01247469f, -0.01397025f, -0.05294323f, -0.03734812f, 
    0.03651959f, -0.00251629f, 0.05442165f, -0.01176137f, -0.04952116f, 0.00195129f, 0.02698538f, 0.05176253f, 
    0.05531076f, -0.04586721f, -0.01117290f, -0.00866804f, 0.02565151f, -0.05002166f, 0.00756876f, -0.06545299f, 
    0.00805518f, -0.00484706f, -0.04650815f, -0.00041647f, 0.04784303f, -0.06560040f, -0.03990122f, -0.06582268f, 
    -0.01992526f, -0.00425949f, -0.06381475f, -0.02938711f, -0.01970830f, -0.00643081f, 0.00751409f, -0.04596912f, 
    -0.00530476f, -0.01498428f, -0.02354234f, -0.04734519f, -0.07132725f, -0.00119433f, -0.05331573f, -0.07446556f, 
    -0.05011380f, -0.06743881f, 0.00313419f, -0.03649442f, 0.00297035f, 0.01567153f, -0.07300702f, -0.00449579f, 
    -0.05469238f, -0.06604653f, -0.00296232f, -0.05005912f, 0.02420140f, -0.06547668f, -0.04808783f, -0.04606885f, 
    -0.02221113f, -0.05837948f, -0.01243292f, -0.07516446f, 0.00357305f, -0.03466038f, 0.00352781f, -0.00047584f, 
    -0.02998633f, -0.03407035f, -0.01246148f, -0.03997818f, -0.06195541f, -0.05358812f, -0.07238298f, -0.02339340f, 
    -0.08087891f, -0.03780075f, 0.03003004f, -0.05638627f, 0.01219060f, -0.03197505f, -0.06259319f, 0.02383394f, 
    -0.05898496f, -0.02875109f, 0.00353725f, 0.00869679f, -0.00664385f, 0.00501769f, -0.08627624f, -0.07643129f, 
    -0.05313090f, 0.01738534f, 0.00873110f, 0.01897861f, -0.08584204f, -0.00693847f, -0.00705573f, -0.01026775f, 
    -0.05635586f, -0.04719631f, -0.05898691f, -0.01175568f, -0.03468159f, -0.02229453f, 0.00933858f, -0.03544271f, 
    -0.04460931f, -0.07771063f, -0.07750656f, -0.01337274f, -0.03224398f, 0.00604265f, 0.00703327f, 0.01910990f, 
    -0.05434663f, -0.07537034f, -0.07631224f, 0.02458288f, -0.03645004f, 0.02186994f, -0.02772352f, -0.03622981f, 
    -0.05457809f, -0.07740198f, 0.00861115f, -0.02765487f, -0.02660044f, 0.00660782f, -0.05337348f, -0.01189233f, 
    -0.04875249f, -0.06764502f, -0.07075627f, -0.03154110f, 0.00671776f, -0.07600046f, -0.04043487f, 0.02312403f, 
    0.01863492f, -0.06000616f, -0.02009687f, -0.03136783f, 0.02402766f, -0.00149800f, -0.08874650f, -0.00326648f, 
    -0.03802274f, -0.05997847f, -0.06714214f, 0.00574332f, -0.02664912f, -0.03805296f, 0.01770186f, -0.04318954f, 
    -0.02480686f, -0.06879769f, 0.01716594f, -0.00514025f, -0.04450607f, -0.03694144f, 0.00792427f, -0.09055573f, 
    -0.06397998f, -0.00611370f, -0.01506623f, -0.07349662f, 0.01046315f, -0.05265726f, -0.03977621f, -0.04692475f, 
    -0.04081915f, 0.00650403f, -0.02248098f, -0.00107046f, -0.05720847f, -0.07553191f, -0.00102255f, -0.03872529f, 
    -0.04617489f, 0.02644570f, -0.04398367f, -0.01519605f, 0.02199083f, -0.03567078f, 0.00851159f, 0.03179903f, 
    -0.02531382f, -0.05752926f, 0.00079887f, -0.03410655f, -0.05689085f, 0.00866139f, -0.07346166f, -0.08742201f, 
    -0.07411493f, -0.03035858f, -0.04353030f, -0.06075174f, -0.00856960f, -0.01387272f, -0.04141166f, 0.02526184f, 
    -0.05423598f, -0.00262118f, -0.05231302f, -0.00251685f, -0.08116243f, -0.03525261f, -0.03684764f, 0.01605687f, 
    -0.05546620f, -0.04218095f, 0.02642976f, -0.04145474f, 0.04659513f, 0.00089117f, -0.07702032f, 0.02353729f, 
    -0.01533783f, -0.01999231f, -0.01527132f, -0.05137801f, -0.01049713f, 0.00083755f, -0.04056398f, -0.06431401f, 
    -0.08520990f, -0.08275126f, -0.04922351f, -0.00966538f, -0.04675090f, 0.01062750f, -0.07747111f, -0.02151675f, 
    -0.06858404f, -0.06048683f, -0.05658739f, -0.05411597f, -0.01209260f, -0.06554788f, -0.02311227f, -0.07055055f, 
    0.01935215f, 0.02967008f, -0.05591252f, 0.01629129f, -0.00629266f, -0.08352412f, -0.03056273f, 0.02225472f, 
    0.00204655f, -0.08469700f, -0.05879334f, -0.01912173f, -0.01083414f, -0.06447341f, -0.00657390f, -0.04046371f, 
    -0.06461141f, 0.01901001f, -0.04391487f, -0.00047029f, 0.02273940f, -0.07162961f, -0.02969955f, -0.04486537f, 
    0.00053292f, 0.00166004f, 0.00044161f, -0.03935519f, -0.05096419f, -0.00036769f, -0.00390654f, 0.00284094f, 
    -0.07498972f, -0.01542571f, -0.04310857f, 0.01606279f, -0.08602298f, -0.08475503f, -0.01382526f, -0.01247292f, 
    -0.02813698f, 0.02241833f, -0.02777383f, 0.01484974f, -0.07138402f, 0.02030047f, -0.02719082f, -0.05355433f, 
    -0.06455652f, -0.05028311f, 0.01946216f, 0.01464530f, -0.05966658f, -0.00241950f, -0.05695542f, 0.02019994f, 
    -0.06081450f, 0.01862623f, 0.02117470f, -0.07519157f, -0.00134737f, -0.01814065f, -0.08435342f, -0.02796351f, 
    0.02097738f, 0.02191772f, -0.03723221f, -0.00741325f, 0.02217849f, -0.06827071f, -0.03716491f, 0.02212457f, 
    -0.07409127f, -0.04777890f, 0.01605832f, -0.05156322f, 0.02538653f, -0.08275978f, 0.01475426f, 0.01901227f, 
    -0.37995848f, -0.15727796f, -0.10904320f, -0.00817492f, -0.11830059f, -0.00944513f, 0.02752204f, -0.04062426f, 
    -0.11047664f, -0.08040160f, -0.06397844f, -0.03483890f, -0.02288529f, -0.04544207f, -0.15665153f, -0.02900262f, 
    0.00910638f, -0.04631434f, 0.16085407f, 0.25263032f, 0.10949790f, 0.13005315f, -0.03100425f, -0.13202077f, 
    -0.01007265f, 0.12381899f, -0.04923144f, -0.12636572f, -0.17715788f, 0.07495192f, 0.00145327f, 0.00675921f, 
    0.03020713f, -0.12304667f, 0.09343261f, -0.08610579f, 0.13442695f, -0.03909072f, -0.02141221f, 0.21647525f, 
    -0.03356758f, -0.02915969f, 0.07730144f, 0.03013082f, 0.01501765f, 0.03186513f, 0.10902587f, 0.12711118f, 
    0.10426416f, -0.09594572f, 0.09262190f, 0.11479825f, 0.05097599f, 0.09555797f, -0.25455147f, -0.20194855f, 
    -0.10881285f, 0.13319683f, 0.02051075f, 0.16851169f, -0.13774753f, -0.00504310f, -0.15500203f, 0.25366992f, 
    0.04631029f, 0.07279510f, 0.12226357f, -0.12399086f, 0.04262862f, 0.09780619f, -0.00209302f, 0.00334079f, 
    0.05748826f, 0.03226426f, -0.04574495f, -0.01408186f, -0.05614268f, 0.11740024f, 0.05223658f, 0.02146581f, 
    0.07682670f, -0.30276170f, -0.02247944f, -0.00372971f, -0.05938714f, 0.05470400f, -0.10945102f, -0.03730983f, 
    0.00821944f, 0.17819032f, -0.02785463f, 0.09702104f, 0.24035874f, -0.00541583f, 0.05609890f, -0.07830292f, 
    -0.04085487f, 0.00439484f, 0.00411522f, 0.08483383f, 0.14830229f, 0.10831820f, 0.08840132f, -0.17459536f, 
    -0.14432374f, 0.10776985f, 0.02932742f, -0.08491539f, -0.09562491f, -0.13945551f, -0.04991032f, -0.08201502f, 
    -0.04628981f, 0.14790595f, 0.08771989f, 0.02058232f, 0.01365748f, 0.40087017f, 0.02723635f, -0.00626750f, 
    0.00716642f, -0.01959933f, 0.08057310f, 0.12208896f, -0.02794368f, 0.16344236f, -0.46996462f, -0.00984575f, 
    -0.07864705f, 0.14754631f, 0.06590400f, -0.08583549f, -0.16997857f, -0.06902491f, -0.18987598f, 0.05532450f, 
    -0.04167342f, 0.05766085f, 0.03103191f, 0.06388270f, -0.10804567f, 0.13326788f, 0.05653901f, 0.10135602f, 
    -0.05596852f, -0.21348605f, -0.14258978f, -0.01405854f, 0.02937764f, 0.06826434f, -0.07449396f, -0.00356046f, 
    0.00118432f, -0.10462856f, 0.02441820f, -0.29997665f, -0.03157354f, 0.02511162f, 0.06542452f, 0.08169539f, 
    0.00337304f, -0.18521738f, 0.04406606f, -0.18480304f, 0.12463075f, -0.07678240f, 0.09631730f, -0.13742457f, 
    0.16328081f, 0.06669787f, 0.01060074f, -0.32259795f, 0.05530345f, -0.14385161f, 0.00685542f, 0.02006518f, 
    0.15282074f, 0.01535788f, 0.04541543f, -0.03508720f, 0.16154094f, 0.21896949f, 0.13022137f, -0.08347803f, 
    -0.05146532f, -0.01389112f, 0.05874185f, -0.02147057f, 0.07903223f, 0.04556913f, 0.01048874f, -0.14484981f, 
    0.04632223f, 0.08511487f, 0.10342787f, 0.08476096f, 0.00551540f, -0.05173782f, 0.03129272f, 0.10810183f, 
    0.08469238f, 0.07336008f, 0.01431460f, -0.06866221f, -0.00071656f, 0.03160372f, 0.30687478f, 0.02111185f, 
    0.20072904f, 0.02735241f, 0.10401166f, -0.02006717f, -0.03692614f, 0.02351606f, 0.03409796f, -0.08687110f, 
    -0.22996026f, 0.01452079f, -0.14842518f, -0.06106744f, 0.10704184f, 0.02671652f, 0.12696810f, 0.01086888f, 
    0.05552887f, 0.12154916f, 0.20390357f, 0.13033062f, 0.02057754f, 0.04085502f, -0.06932113f, 0.03467404f, 
    -0.00080269f, -0.08399160f, -0.18291809f, 0.06990223f, -0.07551862f, 0.05033693f, -0.04526808f, 0.01887830f, 
    -0.02998277f, -0.01214699f, 0.18253820f, 0.23782820f, 0.05540392f, 0.17815481f, -0.08885235f, -0.03058283f, 
    -0.03782630f, 0.02975996f, -0.00162436f, -0.08975445f, 0.00626797f, 0.11071236f, -0.16082442f, 0.07870419f, 
    -0.03797750f, -0.06608877f, -0.09159199f, 0.09615102f, -0.14231543f, -0.41343802f, 0.05419856f, -0.05784464f, 
    0.02820603f, 0.13508032f, -0.08245434f, 0.11005841f, 0.03754581f, 0.09282356f, 0.08503303f, 0.01132654f, 
    -0.31802270f, 0.04911355f, -0.07965142f, 0.08503470f, 0.05118675f, -0.07071212f, -0.08514772f, 0.07942865f, 
    -0.07409880f, -0.20745631f, 0.02476580f, 0.14259835f, 0.05450530f, -0.10546707f, -0.04999166f, -0.05414658f, 
    0.01361020f, 0.02143345f, 0.04407591f, -0.10816353f, 0.05897613f, -0.12120055f, -0.13989730f, 0.03661827f, 
    -0.11086173f, -0.06262822f, 0.05185344f, 0.09077405f, -0.00788378f, -0.08153133f, -0.01910275f, 0.05896715f, 
    0.10146980f, 0.03777857f, 0.14060324f, 0.09298661f, -0.22253831f, -0.06941366f, -0.02349989f, -0.16018261f, 
    -0.05728371f, 0.00788547f, -0.06979076f, 0.27444273f, 0.16883005f, -0.10171496f, -0.18615289f, 0.02409850f, 
    -0.10218207f, -0.00598927f, -0.01936002f, -0.05410324f, -0.28288585f, -0.23089723f, 0.14998268f, 0.14230153f, 
    0.01047562f, 0.08895587f, -0.00073800f, 0.01143033f, -0.13262981f, -0.25403467f, -0.11070967f, 0.31070587f, 
    0.02072168f, 0.06903142f, -0.00020069f, 0.10188386f, -0.25367782f, 0.10515510f, 0.10415956f, 0.03023019f, 
    -0.24216679f, 0.03646107f, 0.01435291f, -0.04237061f, 0.01507605f, 0.05343216f, 0.00845238f, -0.50587916f, 
    0.12527193f, 0.16342579f, 0.07247713f, -0.03813588f, 0.04763333f, -0.04678211f, 0.04188868f, -0.04411602f, 
    -0.04302680f, 0.00181974f, 0.19878803f, 0.14186211f, 0.03663004f, 0.02972562f, -0.00271658f, -0.08347793f, 
    0.01612412f, 0.30065620f, -0.03354379f, -0.21510020f, -0.05918414f, 0.30529276f, 0.02114143f, 0.16734666f, 
    0.07168048f, -0.10621183f, 0.37238759f, -0.04368212f, 0.08487996f, -0.09662025f, 0.02153962f, -0.08086771f, 
    -0.00117403f, 0.00019801f, 0.01300767f, -0.04483150f, -0.10010379f, 0.07976937f, 0.13052230f, 0.01996677f, 
    -0.00942608f, -0.03696827f, 0.01680652f, -0.13769381f, 0.11753981f, 0.28251365f, -0.06795597f, 0.04395737f, 
    -0.04866762f, 0.09338000f, 0.11394674f, -0.10709517f, 0.00889411f, -0.09773767f, -0.09155969f, 0.17289303f, 
    -0.08384623f, 0.00018774f, 0.14523885f, 0.05493200f, -0.06000415f, -0.06431657f, 0.08072802f, -0.04982474f, 
    0.20998973f, 0.08131311f, -0.10967352f, -0.01944204f, -0.03176730f, 0.06721362f, 0.02820398f, 0.17799886f, 
    0.42233634f, -0.14165711f, 0.02328299f, -0.05153995f, 0.01263412f, 0.13310836f, -0.00610487f, 0.01097480f, 
    0.24291509f, 0.22611977f, -0.39146805f, 0.10426338f, 0.11995957f, 0.00154456f, 0.15117656f, -0.12018201f, 
    0.08893050f, -0.09153920f, 0.13365479f, -0.18773212f, 0.30423680f, 0.02336334f, 0.07094876f, 0.08762390f, 
    -0.04437566f, -0.14070198f, 0.01580328f, -0.11418246f, -0.12554240f, -0.07141945f, -0.21475664f, 0.15514816f, 
    -0.04588884f, 0.01416356f, -0.05293723f, -0.16742705f, -0.02852011f, 0.13966660f, 0.06795938f, -0.09297714f, 
    -0.05998490f, -0.09588645f, -0.14150651f, 0.02214483f, -0.07561439f, -0.04723686f, 0.12112476f, 0.18669827f, 
    -0.02097395f, 0.11049999f, -0.01035123f, 0.13655983f, 0.00419173f, -0.26212141f, 0.10806029f, 0.02941564f, 
    0.16740425f, 0.09119694f, -0.02522335f, -0.11668382f, 0.07087284f, 0.07028724f, -0.08685236f, 0.15732744f, 
    0.07036328f, 0.00548717f, 0.04940078f, -0.09650911f, -0.04377458f, -0.08599880f, 0.12861584f, -0.15187688f, 
    -0.06123196f, 0.07424822f, 0.04156832f, 0.18147339f, 0.11029509f, -0.05820261f, 0.05608104f, 0.05705167f, 
    -0.14978598f, 0.20792173f, -0.07010197f, -0.05225133f, -0.06672956f, 0.10885324f, 0.10818581f, -0.13662529f, 
    0.00227348f, -0.22136319f, -0.13852040f, 0.25370917f, 0.30752215f, 0.13550600f, -0.09111803f, -0.04262381f, 
    -0.00790141f, 0.12908839f, -0.22307631f, 0.23891713f, -0.06681220f, 0.19909923f, -0.00986374f, -0.08037531f, 
    0.03429005f, -0.00955657f, 0.07176472f, 0.09926143f, -0.26900995f, -0.02715641f, 0.14655919f, -0.01439578f, 
    -0.14883415f, -0.20209543f, 0.14846480f, 0.00400477f, -0.16950257f, 0.25198773f, -0.35342649f, 0.02132827f, 
    -0.00050808f, 0.09577737f, -0.07099363f, -0.01820476f, 0.02624532f, -0.27288452f, -0.16703099f, 0.01499150f, 
    0.03257588f, -0.11055750f, -0.00152189f, 0.02009801f, -0.18276803f, 0.09463178f, -0.19799137f, -0.14908126f, 
    -0.03756392f, -0.10094114f, 0.06548890f, 0.08443872f, -0.14207520f, -0.06064871f, 0.05701321f, 0.02963690f, 
    0.06698934f, -0.11374420f, 0.02251385f, 0.01359530f, -0.04466492f, 0.12339377f, -0.13846412f, -0.12144302f, 
    -0.05770477f, -0.03998784f, 0.04132496f, -0.04058607f, -0.05131391f, -0.00321294f, -0.03122899f, -0.04683745f, 
    0.03999934f, -0.00639704f, 0.02845877f, 0.00254323f, -0.04506548f, -0.00450684f, 0.04521665f, 0.04995390f, 
    0.05282621f, 0.00648575f, 0.04988765f, 0.02552292f, -0.05294713f, -0.05090610f, 0.00395751f, -0.02149955f, 
    0.05187462f, -0.00762762f, 0.00673535f, -0.01496624f, 0.05025072f, -0.00029971f, -0.00388286f, -0.03069616f, 
    -0.02822507f, -0.01283984f, -0.02477060f, 0.02420455f, -0.01887585f, 0.01429177f, 0.03963285f, -0.05553243f, 
    0.02749571f, 0.00025441f, -0.00926569f, -0.01524942f, -0.01088037f, -0.05742107f, -0.00434213f, 0.01535851f, 
    0.01101905f, 0.02087107f, -0.02227232f, 0.02367122f, -0.04046842f, -0.03760797f, -0.02249254f, -0.03991673f, 
    -0.05385816f, -0.00044087f, -0.04380878f, -0.00677655f, -0.02286205f, -0.04473493f, 0.04812184f, -0.06328673f, 
    -0.05166052f, -0.02292015f, -0.01849120f, -0.03814135f, -0.01200329f, 0.03590343f, -0.00454712f, 0.03267159f, 
    -0.05817509f, -0.03212241f, 0.03147993f, 0.03724590f, 0.00437013f, -0.06295113f, -0.01318582f, 0.04450145f, 
    -0.01143097f, -0.05793094f, 0.04751289f, -0.04472360f, 0.02294248f, -0.00295315f, -0.03393677f, -0.01153859f, 
    0.01052092f, -0.04414921f, -0.03140378f, -0.03886605f, 0.04334843f, 0.02577666f, -0.05662575f, -0.04511876f, 
    -0.00288763f, -0.05529193f, 0.04413218f, -0.00706526f, -0.02107146f, -0.00029048f, -0.04218733f, -0.00897277f, 
    -0.04318030f, 0.04316225f, -0.03505572f, -0.03443100f, 0.00626694f, 0.03133689f, -0.03540614f, 0.03059031f, 
    -0.00578841f, 0.01321565f, 0.00328685f, 0.00785916f, -0.00837105f, 0.00546146f, -0.01590317f, -0.02832855f, 
    -0.02965772f, -0.06408788f, -0.02397811f, 0.04241722f, -0.05579235f, -0.05389017f, 0.03567906f, 0.01102864f, 
    -0.02553225f, -0.00641662f, 0.01907006f, -0.03490427f, 0.02241014f, -0.00514749f, -0.03168271f, 0.03976516f, 
    0.00524832f, -0.04762055f, -0.05137122f, 0.03001552f, -0.05242505f, -0.05362853f, 0.01722539f, -0.01424997f, 
    -0.04225008f, -0.05142236f, -0.03458559f, 0.05217673f, 0.04958475f, 0.02259399f, -0.01373793f, -0.04835465f, 
    -0.02033911f, -0.00869153f, 0.00084855f, 0.00695288f, 0.02721858f, -0.00621983f, -0.04122914f, -0.01331838f, 
    -0.02759687f, -0.05203770f, -0.02780105f, 0.00438204f, 0.00205844f, 0.03257191f, -0.04533986f, 0.00119440f, 
    0.00239914f, -0.04333214f, 0.00132564f, 0.00039709f, 0.01749364f, -0.06213012f, -0.02122229f, 0.00096898f, 
    -0.05089382f, -0.04405414f, 0.01024595f, 0.00102819f, 0.03603975f, -0.02075628f, 0.02150271f, 0.00319266f, 
    0.01327244f, 0.03998026f, -0.00253010f, -0.04462904f, -0.03731338f, 0.03139462f, -0.05574551f, -0.04075707f, 
    -0.02688292f, 0.03019422f, -0.02276294f, -0.05815653f, -0.02606282f, -0.03190018f, 0.03594210f, 0.01869983f, 
    -0.05034716f, -0.01558169f, -0.03296595f, -0.01349192f, -0.03112116f, -0.05299241f, -0.01007336f, 0.01003419f, 
    -0.01945719f, 0.03601108f, 0.03011383f, 0.04774458f, -0.00135115f, -0.04720456f, -0.01007570f, 0.00601961f, 
    0.01970359f, -0.02023382f, -0.03618835f, -0.04168915f, -0.03572533f, 0.03132676f, -0.01722534f, -0.00819864f, 
    -0.03950679f, 0.01364575f, -0.06074378f, 0.00546251f, 0.03975544f, 0.05064528f, -0.05667980f, -0.02728603f, 
    -0.02975162f, -0.06407090f, 0.02325208f, 0.01203801f, -0.00746682f, -0.02280265f, 0.02399102f, -0.01664208f, 
    -0.00374953f, -0.00546766f, -0.02717311f, -0.04492732f, -0.00449772f, -0.01837731f, 0.01293275f, 0.02011305f, 
    -0.04284999f, 0.01410347f, 0.00176666f, -0.01352647f, 0.03623414f, 0.02775209f, -0.02633528f, -0.00788241f, 
    -0.03389213f, -0.02965032f, 0.00811518f, -0.00260236f, -0.05142437f, -0.01791690f, 0.03268110f, -0.00596245f, 
    0.03411614f, 0.01576343f, 0.03234242f, -0.04192064f, -0.03291217f, -0.02570327f, 0.00423497f, 0.01498080f, 
    -0.06068420f, 0.02376497f, -0.02960131f, 0.03024921f, 0.02503656f, -0.05067045f, 0.00989519f, 0.05453900f, 
    0.03200543f, 0.03877373f, 0.02273337f, 0.03445325f, -0.05711751f, -0.04205141f, 0.00477747f, -0.02531384f, 
    -0.00540012f, -0.04837431f, -0.00604434f, -0.00800112f, -0.06049088f, 0.00786668f, -0.02506574f, -0.01648048f, 
    0.05027847f, -0.04033212f, -0.00372082f, -0.05861767f, 0.01051659f, 0.02025162f, -0.03008524f, 0.02059787f, 
    0.02411126f, 0.02661767f, -0.02555224f, -0.03872265f, 0.02009673f, 0.04652778f, -0.04660194f, -0.03595209f, 
    -0.04267468f, -0.02665023f, 0.03934245f, -0.05056893f, -0.03111508f, 0.00259416f, 0.04278708f, 0.03210424f, 
    -0.05409426f, 0.02835598f, 0.02567037f, -0.03583530f, 0.03080359f, 0.03631436f, 0.00617822f, -0.02022489f, 
    0.00747141f, -0.02921473f, -0.01596844f, 0.04898306f, 0.04090396f, -0.05211169f, -0.04379236f, -0.01667308f, 
    0.04938858f, -0.00568059f, -0.02754396f, -0.03330193f, -0.03439696f, -0.03777559f, -0.01431944f, -0.01226136f, 
    0.05442728f, -0.00381863f, -0.06503229f, -0.02388846f, -0.01274533f, -0.01254671f, -0.00486714f, -0.01774208f, 
    0.01236950f, -0.00800741f, -0.04010862f, -0.04116042f, 0.04395690f, 0.03344603f, 0.02284059f, -0.06041428f, 
    0.01033012f, 0.01841070f, 0.04942499f, -0.05767459f, -0.04061784f, -0.06300136f, 0.03967055f, 0.02543764f, 
    -0.02655112f, -0.00761493f, -0.00578882f, 0.01866808f, -0.05483491f, 0.02988314f, 0.00087244f, 0.02436456f, 
    -0.00929754f, -0.03645446f, 0.04391051f, 0.02033581f, -0.03632772f, 0.02822476f, -0.04415071f, 0.03491189f, 
    0.05104634f, 0.04007928f, -0.04540889f, 0.01949376f, -0.05564778f, -0.02347542f, -0.06112384f, 0.03705195f, 
    -0.04652010f, 0.04613552f, 0.01060618f, 0.05301445f, -0.00602420f, 0.01877945f, -0.01057039f, -0.00020882f, 
    -0.00843648f, 0.02016771f, 0.00470247f, 0.00927916f, -0.00289867f, -0.04243962f, 0.04619144f, -0.00914420f, 
    -0.04935610f, 0.05019569f, -0.00253209f, 0.04345882f, -0.04199942f, -0.02816668f, 0.02902700f, -0.05612466f, 
    -0.00735412f, -0.03721491f, 0.00374968f, 0.05345019f, -0.06264069f, -0.04890421f, 0.05256308f, -0.00119181f, 
    -0.05124781f, -0.01511048f, -0.03585582f, 0.00431303f, 0.02773833f, 0.01739539f, -0.00086358f, -0.04434676f, 
    -0.03091170f, -0.01234887f, -0.02405944f, -0.03803148f, 0.04358507f, 0.04968605f, -0.04374763f, 0.01671692f, 
    -0.00975526f, 0.01805217f, -0.04087924f, -0.05198818f, -0.05826724f, -0.04965257f, -0.04687808f, -0.06383774f, 
    0.01115558f, 0.01615942f, -0.01338825f, -0.00621078f, -0.01281173f, -0.03311133f, -0.04907781f, -0.03836049f, 
    0.01313575f, -0.04184325f, -0.04241559f, -0.00136943f, -0.01014738f, 0.03077647f, -0.03755080f, 0.04977460f, 
    -0.02778763f, 0.03069895f, -0.00369776f, -0.02969971f, -0.03516934f, 0.04087901f, -0.06338707f, -0.00571626f, 
    0.04735331f, 0.02912458f, -0.06713612f, 0.00369102f, -0.01889519f, -0.00132013f, 0.03166100f, 0.01077558f, 
    0.01527994f, 0.03108851f, -0.03298826f, -0.01507689f, -0.06095828f, 0.05502919f, 0.03043257f, -0.03799380f, 
    -0.00477111f, -0.03389458f, -0.03638015f, 0.00177339f, -0.03458733f, 0.04062849f, -0.00626931f, -0.03972754f, 
    -0.02675129f, -0.00729739f, 0.02632685f, 0.02572444f, -0.06362280f, -0.02225127f, -0.03333527f, 0.00765184f, 
    -0.02446503f, 0.01715688f, -0.04649081f, -0.04882761f, -0.00272822f, 0.02313501f, -0.04313878f, -0.03656526f, 
    -0.01956987f, 0.03948308f, -0.02290579f, -0.00035976f, -0.00677102f, -0.03507732f, -0.03116301f, 0.02565471f, 
    -0.02063004f, 0.01791400f, 0.00204142f, 0.02498802f, 0.03663822f, 0.01876247f, 0.05367506f, 0.02829749f, 
    0.04173620f, -0.03073973f, -0.01936328f, -0.06272162f, 0.04987867f, 0.02453107f, -0.02202603f, -0.05127866f, 
    -0.01581277f, 0.03499852f, -0.04779175f, -0.03352417f, 0.03882479f, -0.02994619f, -0.06165366f, 0.02594717f, 
    0.02904783f, -0.06195026f, -0.04114467f, -0.02790587f, 0.01552580f, 0.02380908f, -0.00690232f, -0.05485484f, 
    -0.04070319f, 0.05047267f, -0.00052749f, -0.00082460f, -0.01531477f, -0.04503441f, -0.02034764f, -0.04306212f, 
    0.01265066f, -0.06194052f, -0.01888373f, -0.05170875f, 0.02415542f, 0.00940953f, -0.05862236f, 0.01203388f, 
    -0.03475087f, 0.05186919f, 0.04658324f, -0.05873704f, -0.02598547f, -0.00205721f, 0.02315995f, 0.04886981f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06076729f, -0.04182733f, -0.05790063f, 0.07885598f, 0.07508839f, -0.06434090f, 0.10885976f, 0.12108216f, 
    -0.07676266f, 0.01905566f, 0.06068309f, 0.10959688f, 0.08419833f, 0.01901188f, 0.05024583f, -0.02502905f, 
    0.15179439f, 0.13369930f, 0.13793947f, -0.12100801f, 0.00121022f, 0.01747944f, -0.05700231f, -0.12780213f, 
    -0.00448409f, 0.06456620f, 0.02013983f, -0.08434642f, 0.08159225f, -0.00024231f, -0.02673085f, 0.04711065f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07451923f, -0.07619834f, -0.06245735f, -0.19227473f, 0.02416978f, 0.03439062f, 0.08321366f, -0.15701146f, 
    -0.03324419f, -0.20668611f, -0.10414285f, -0.15146941f, -0.07405818f, 0.11576403f, -0.17251903f, 0.06934438f, 
    -0.06805056f, -0.01064688f, -0.02456148f, 0.15647338f, 0.04284352f, -0.05245771f, 0.10456201f, 0.08316465f, 
    0.03153133f, -0.12842846f, 0.09972448f, -0.08238050f, 0.11155585f, -0.09828495f, 0.11317349f, -0.03419342f, 
    -0.10310330f, 0.21127483f, 0.26172128f, 0.52275503f, 0.22649203f, 0.01585748f, -0.28187886f, -0.07671792f, 
    0.22688515f, -0.06982384f, 0.13243449f, 0.44180396f, -0.28415200f, -0.00392398f, 0.08707725f, 0.34142825f, 
    -0.04699340f, -0.17570320f, -0.26220644f, 0.20515044f, 0.01115615f, -0.03245879f, -0.07227404f, 0.14851840f, 
    0.00652987f, 0.16623116f, -0.08969040f, 0.06143345f, 0.04004413f, -0.39312625f, -0.13414413f, -0.15154567f, 
    -0.05741137f, -0.08725131f, 0.19830661f, -0.06258132f, 0.24298136f, -0.18739699f, 0.21838851f, -0.08578016f, 
    -0.14007816f, 0.06162011f, 0.31762603f, -0.17959198f, -0.03422672f, -0.16972454f, 0.26596490f, 0.28685191f, 
    0.07040633f, -0.00940007f, -0.48079753f, -0.54382199f, 0.00822348f, 0.43026027f, 0.11693959f, 0.00776680f, 
    0.01053906f, -0.19438294f, 0.01573451f, 0.16904818f, -0.26965880f, 0.30862665f, -0.04087401f, -0.15499114f, 
    0.03554602f, -0.16110848f, -0.11566819f, -0.16829240f, -0.14487535f, 0.03537003f, -0.01546479f, -0.03240744f, 
    0.07665621f, -0.01290999f, 0.11701806f, 0.09232525f, -0.19262666f, 0.09246329f, -0.12609076f, 0.16478011f, 
    -0.10299905f, -0.11860647f, 0.05368993f, -0.11028320f, 0.17489243f, 0.04520582f, 0.00693141f, -0.04450534f, 
    -0.17842391f, -0.04095081f, -0.03020178f, 0.01704935f, -0.02668093f, -0.07420251f, -0.00311360f, 0.01236374f, 
    -0.12589353f, -0.32946828f, -0.11414661f, 0.02563381f, -0.19407330f, -0.03255679f, 0.01201237f, 0.34066388f, 
    0.42288023f, 0.04999999f, 0.41655043f, 0.42073220f, -0.36627996f, -0.13224551f, 0.03033997f, 0.10149758f, 
    -0.21803880f, 0.12718116f, -0.01899139f, 0.09876810f, -0.12743402f, 0.12069953f, 0.12435691f, -0.14117651f, 
    0.42533103f, 0.47740889f, -0.08993890f, -0.11071733f, 0.43023270f, -0.21381475f, -0.09923208f, -0.15978621f, 
    0.19836865f, 0.12500174f, -0.06949669f, 0.17707853f, -0.17119387f, -0.13208109f, 0.35198167f, 0.03339176f, 
    0.11389668f, -0.05968950f, 0.06720610f, -0.11334755f, -0.01982901f, 0.07959829f, -0.16268545f, -0.28847429f, 
    0.30197692f, 0.19799370f, 0.09204439f, -0.05649460f, -0.06735209f, 0.23503897f, 0.00824182f, -0.10446395f, 
    0.18184300f, -0.17738308f, -0.15395774f, 0.05844771f, 0.17834277f, -0.17062189f, 0.11591338f, -0.13486823f, 
    -0.13326424f, -0.18203339f, -0.13507028f, -0.05066490f, -0.19431204f, 0.03956831f, -0.06084465f, -0.00368079f, 
    0.08736302f, -0.06783824f, -0.08821643f, -0.11687452f, -0.04235840f, -0.15058073f, -0.05680493f, -0.15702026f, 
    -0.15913509f, 0.00582957f, -0.06382559f, 0.12071829f, -0.10110975f, -0.17484239f, 0.01918788f, 0.01690249f, 
    0.13256723f, 0.09118837f, -0.03561959f, -0.15114981f, 0.11594474f, 0.01896626f, 0.15189266f, 0.14782631f, 
    0.01075657f, -0.28068671f, -0.17120799f, -0.00144607f, -0.02125455f, 0.06649788f, 0.12496122f, 0.25042075f, 
    -0.00499873f, -0.08492737f, 0.04167716f, -0.13850270f, 0.43110973f, 0.04750597f, -0.33758622f, -0.26673937f, 
    0.36723772f, 0.20461673f, 0.12191549f, 0.50436515f, 0.19335960f, 0.03639363f, 0.10956433f, -0.04376539f, 
    -0.05279768f, 0.07884865f, 0.12141401f, -0.01387246f, -0.14622606f, 0.24760993f, -0.15139538f, -0.17919898f, 
    0.14552912f, -0.09857983f, 0.28815413f, 0.17174865f, 0.24506564f, -0.59089965f, -0.17347984f, -0.01115867f, 
    0.14150944f, 0.06066683f, -0.21563263f, -0.15544704f, 0.50162119f, -0.00904995f, 0.01944318f, 0.02793579f, 
    0.21443814f, 0.00300171f, -0.35530716f, -0.41578752f, 0.30343214f, 0.30264544f, 0.02466330f, 0.24881713f, 
    -0.19790116f, 0.29490101f, 0.09737340f, 0.03839095f, -0.30552927f, 0.06376950f, -0.09436212f, 0.15545371f, 
    -0.13492721f, 0.14324144f, 0.24443269f, 0.22540443f, 0.19897921f, 0.26086432f, 0.56551135f, 0.05001819f, 
    -0.24674103f, -0.17444411f, 0.13772748f, 0.22414449f, 0.35053682f, 0.11958281f, 0.09802520f, 0.19494337f, 
    0.16161135f, 0.11244230f, -0.40995255f, 0.36240968f, -0.21791902f, -0.17828237f, 0.01188941f, 0.11707834f, 
    -0.41446793f, 0.03253923f, -0.13428442f, -0.00279485f, -0.06323256f, -0.21195179f, -0.08496282f, 0.13651808f, 
    0.18757309f, -0.21419616f, -0.12822591f, -0.07181225f, 0.11995970f, -0.06570469f, -0.14401463f, 0.10335929f, 
    -0.17006463f, -0.11455143f, -0.04168739f, 0.18320948f, -0.07910029f, 0.10175417f, -0.08710126f, 0.13912980f, 
    -0.03432387f, 0.15560691f, 0.01889689f, -0.08272714f, 0.14827150f, 0.12715562f, -0.04608553f, -0.15724540f, 
    -0.20886938f, -0.03920802f, -0.02866768f, 0.06493483f, 0.04489382f, -0.08291313f, -0.17100449f, 0.09190004f, 
    -0.02506349f, -0.00094323f, 0.32243365f, -0.25083917f, -0.05864000f, -0.01994506f, -0.00875355f, 0.07608709f, 
    0.36902553f, 0.31579351f, -0.42160323f, -0.14260836f, -0.19511142f, -0.15400654f, 0.29923695f, 0.00998890f, 
    -0.27006412f, 0.28742093f, 0.02446359f, 0.32122576f, -0.34139475f, 0.28379449f, 0.15327437f, 0.07921328f, 
    0.12384985f, 0.39464399f, 0.05967252f, 0.15982620f, 0.17740642f, -0.00431465f, 0.01934163f, 0.02282439f, 
    -0.05835897f, -0.03225053f, -0.12377966f, -0.17918266f, -0.07293069f, -0.12277514f, 0.03618232f, -0.03407787f, 
    0.04702996f, -0.04858913f, 0.09371734f, 0.02386792f, -0.17893524f, -0.08708400f, -0.08232663f, -0.02311840f, 
    -0.07361745f, -0.05918107f, 0.12727584f, 0.04959758f, -0.10570905f, 0.03492399f, -0.12117596f, 0.02084392f, 
    -0.11479002f, -0.17413048f, -0.05169973f, 0.04130505f, -0.15795726f, 0.00141318f, 0.01231428f, -0.17525129f, 
    0.11566984f, 0.14986585f, 0.04949380f, -0.09575137f, -0.11873092f, -0.07937712f, -0.12387482f, -0.09366232f, 
    -0.12209554f, -0.09822877f, 0.06721278f, -0.11855234f, 0.01595361f, -0.17043525f, -0.06539206f, 0.06176382f, 
    -0.19344184f, -0.14776410f, 0.03739342f, -0.08103842f, -0.16856717f, -0.11857738f, 0.08934578f, -0.03524932f, 
    0.07512796f, 0.06257752f, 0.04340295f, 0.13387775f, -0.01475450f, -0.04248540f, 0.00222382f, 0.08315814f, 
    -0.13674027f, 0.43233371f, -0.07018895f, -0.16803923f, 0.08946332f, 0.18841967f, 0.02301359f, -0.20994562f, 
    -0.08221231f, 0.08602541f, -0.28758302f, -0.12487641f, 0.14840810f, -0.12504961f, -0.05770262f, 0.00504609f, 
    -0.20572674f, 0.24141511f, 0.51453030f, 0.27367333f, 0.16766085f, 0.14322166f, -0.05118816f, 0.07743672f, 
    0.23847324f, 0.31849182f, -0.16632937f, -0.01097224f, 0.09859415f, 0.32384509f, 0.07715645f, 0.12449861f, 
    0.29175851f, -0.04081807f, 0.19610676f, 0.25475377f, 0.19246350f, 0.08811086f, -0.05410827f, 0.05406639f, 
    0.00089048f, 0.15234673f, -0.19236258f, -0.37859026f, -0.15666427f, -0.00913726f, 0.00308482f, -0.20600997f, 
    0.22440585f, -0.27404186f, 0.08356880f, -0.38436264f, 0.12142154f, 0.04866494f, -0.06144483f, 0.46972370f, 
    0.26322562f, -0.36996007f, 0.14138015f, 0.16556606f, -0.27644339f, 0.23567478f, 0.05316439f, -0.08111707f, 
    -0.16402628f, -0.18811233f, 0.07922483f, -0.14222673f, 0.09704742f, 0.10803629f, -0.08459378f, -0.19181439f, 
    0.02627750f, -0.04511848f, -0.08415924f, -0.15781619f, -0.02748161f, 0.00280068f, -0.11668743f, -0.11942721f, 
    -0.21591567f, -0.01889394f, 0.11990296f, 0.00085293f, -0.04842011f, -0.06035678f, -0.10549512f, -0.20141850f, 
    -0.19449912f, -0.14948405f, -0.07927605f, -0.16437559f, 0.03031545f, -0.18106242f, 0.06111440f, 0.11366653f, 
    0.09743815f, -0.11450950f, 0.07327622f, -0.10388705f, 0.08225736f, 0.11756830f, -0.23344614f, -0.00104356f, 
    0.00263355f, -0.17573960f, 0.07516317f, -0.07461649f, -0.02778697f, 0.11246764f, -0.11176649f, 0.05289915f, 
    -0.20721130f, -0.20167673f, -0.15610217f, -0.13365161f, -0.03585301f, 0.14004412f, -0.03563030f, 0.02387163f, 
    0.03897718f, -0.12408067f, -0.03607769f, -0.10183947f, -0.05579533f, -0.02601026f, 0.06016894f, -0.15322086f, 
    0.16148384f, 0.12486358f, 0.01400415f, 0.19965436f, -0.29960799f, 0.29851118f, 0.10958721f, -0.06312340f, 
    0.28801316f, -0.29346812f, 0.16308720f, -0.24455385f, 0.21087797f, 0.00048993f, -0.07926726f, -0.05250464f, 
    0.30382776f, 0.16158780f, -0.17613137f, 0.66081506f, 0.15726206f, 0.05765256f, 0.14669029f, 0.05549015f, 
    -0.21672976f, -0.02151919f, -0.15571795f, 0.12138221f, -0.01741295f, 0.15945899f, 0.06962647f, -0.05804325f, 
    0.23798683f, 0.30300376f, -0.18808395f, -0.03887759f, -0.14962949f, 0.24911565f, -0.12981397f, 0.30519843f, 
    -0.04400358f, 0.06970290f, 0.39876723f, -0.25368148f, -0.30928209f, -0.14554437f, 0.31323132f, 0.15830296f, 
    -0.09828009f, 0.15022549f, 0.25843537f, -0.05757293f, -0.38668513f, -0.26048088f, 0.06536961f, -0.06853293f, 
    0.28552479f, -0.19187751f, 0.06599488f, 0.04162246f, 0.11650467f, 0.07601864f, 0.16778044f, 0.16420169f, 
    0.13314892f, 0.08617429f, -0.12869610f, 0.12791380f, -0.18237473f, -0.09814047f, 0.01393001f, 0.11687355f, 
    0.10870408f, -0.11384340f, 0.07385969f, -0.15978411f, 0.08422213f, 0.15907016f, 0.07665388f, -0.15862511f, 
    -0.17829940f, -0.08898205f, 0.03545520f, -0.10209939f, -0.11961085f, -0.04572064f, 0.08992487f, -0.11569695f, 
    -0.03512771f, 0.04704178f, 0.06487301f, -0.10906088f, -0.17501673f, -0.16938555f, 0.12084077f, 0.15540525f, 
    -0.01787824f, -0.20574854f, -0.12552825f, 0.06485035f, -0.19798449f, -0.00983272f, -0.16548848f, -0.15131998f, 
    -0.07648721f, 0.10590717f, -0.02254491f, -0.03437607f, -0.02470129f, -0.13434103f, 0.05880684f, -0.04360532f, 
    -0.02887676f, -0.17410798f, -0.13996255f, 0.04994274f, -0.17361328f, -0.06121486f, 0.13743132f, 0.11179774f, 
    -0.16517748f, -0.16744548f, -0.03753322f, -0.04101573f, -0.05893165f, 0.08039303f, -0.10646123f, -0.03112682f, 
    0.46403128f, -0.16621275f, -0.36039442f, -0.27815503f, 0.09674080f, 0.09341570f, -0.14814867f, 0.13327554f, 
    -0.10988200f, 0.36845776f, -0.23671657f, 0.09936922f, 0.32586622f, -0.14722870f, 0.37315488f, -0.25421190f, 
    0.31686908f, 0.02528939f, 0.23494928f, -0.18081653f, 0.34539405f, 0.35862410f, -0.15075661f, -0.09512807f, 
    -0.18338399f, 0.32640249f, -0.01316926f, -0.13315894f, -0.27342623f, 0.40388373f, 0.03453453f, 0.11699434f, 
    -0.23085751f, 0.50206536f, -0.08543278f, -0.10733299f, 0.16393940f, -0.08660812f, 0.19548330f, 0.13568671f, 
    -0.13574880f, -0.04852541f, -0.09847037f, 0.33268213f, -0.05294449f, 0.12994556f, -0.17533214f, -0.00880733f, 
    -0.27640906f, 0.32371926f, 0.06635497f, -0.04442786f, 0.15747409f, 0.37788782f, 0.17686902f, -0.01101860f, 
    -0.06850745f, 0.47803736f, -0.07046025f, -0.07670829f, 0.01887289f, -0.12889917f, 0.01702273f, 0.14487192f, 
    -0.20104975f, -0.68792975f, 0.18779156f, -0.15873642f, 0.21291786f, -0.15170652f, -0.07562451f, 0.24951327f, 
    -0.32788026f, -0.10581856f, -0.30927733f, 0.19111718f, 0.28896591f, -0.00038074f, -0.06318810f, -0.15416749f, 
    0.14632186f, 0.23351263f, 0.42189071f, -0.00348261f, -0.50761729f, -0.13238689f, -0.02011003f, -0.30975837f, 
    0.07800358f, 0.00639610f, -0.03274744f, 0.07298806f, -0.26740673f, 0.12031986f, -0.05021211f, -0.01791347f, 
    -0.34857485f, 0.09097855f, 0.61613548f, 0.14098531f, -0.11350001f, -0.31539884f, 0.34623134f, 0.06253961f, 
    -0.26857302f, 0.18437763f, 0.15217218f, 0.10441500f, -0.20044483f, 0.05764719f, -0.09501458f, 0.34189552f, 
    -0.14132856f, -0.11014298f, -0.39790696f, -0.19053744f, 0.01801218f, 0.54829431f, 0.07104964f, -0.05442765f, 
    0.25412613f, 0.22013913f, 0.10009269f, 0.06253195f, 0.14374141f, -0.20289940f, -0.08193642f, 0.16327688f, 
    -0.07528999f, 0.08184361f, -0.09653208f, 0.40843645f, 0.25291714f, 0.26355362f, -0.00144030f, 0.02988415f, 
    -0.07352244f, -0.08390867f, -0.26691669f, 0.22739354f, 0.13878021f, -0.17731279f, 0.09348661f, -0.17228451f, 
    0.32840234f, 0.06333502f, -0.02130652f, 0.31368878f, 0.31037527f, -0.28462747f, 0.15675129f, 0.28396231f, 
    -0.30140916f, -0.18492450f, -0.06294301f, -0.10347617f, -0.05942652f, 0.09604717f, 0.01070285f, 0.11578910f, 
    0.33944428f, -0.21842134f, 0.35886639f, -0.33417347f, 0.11549896f, 0.29892421f, 0.43617940f, -0.01675572f, 
    -0.30246019f, 0.30162001f, 0.07674351f, -0.41873243f, 0.11339282f, -0.05294815f, 0.02103135f, -0.13247114f, 
    0.19985460f, 0.28603241f, 0.34707880f, -0.14877816f, -0.40521869f, -0.08534420f, 0.04963819f, -0.45667392f, 
    0.06100593f, 0.10411350f, 0.08047899f, 0.14732234f, 0.22891143f, 0.37268737f, -0.04688348f, 0.06661356f, 
    0.01635159f, -0.10763183f, -0.00699250f, 0.07115122f, -0.13680029f, -0.01330944f, 0.03007640f, -0.18089385f, 
    -0.07867238f, -0.07728624f, 0.13374346f, -0.10322334f, -0.06944438f, 0.13366754f, -0.05453704f, -0.08599935f, 
    0.12343622f, 0.15444607f, -0.20796250f, 0.11884570f, -0.13862751f, 0.05038852f, 0.02889370f, 0.08120086f, 
    -0.15495354f, -0.12508841f, 0.11215501f, 0.13882996f, 0.06024570f, -0.00865728f, -0.01703687f, -0.05248273f, 
    -0.18075064f, -0.02519793f, 0.02586216f, -0.08184172f, -0.13368578f, -0.01861128f, -0.14056928f, 0.02770976f, 
    -0.11943441f, -0.02150593f, 0.10697623f, -0.03049472f, -0.16062158f, 0.00521894f, 0.04124816f, -0.08074777f, 
    -0.09324776f, 0.00532097f, -0.12397805f, -0.21226443f, -0.23528436f, -0.03300680f, 0.04523290f, -0.03966415f, 
    -0.11464237f, -0.02951842f, -0.03563527f, 0.14190486f, 0.01471068f, -0.02474154f, -0.08623382f, 0.14234510f, 
    0.63027239f, -0.18816748f, -0.14293475f, -0.30976978f, -0.08218519f, -0.30769545f, -0.24830200f, 0.23449820f, 
    0.34162131f, 0.17706694f, -0.27740800f, -0.02888038f, 0.47087723f, -0.12885346f, -0.00968902f, -0.27483168f, 
    0.46746913f, 0.14833272f, 0.40914845f, -0.14145046f, 0.40293199f, 0.03097750f, -0.02824559f, 0.18197086f, 
    0.12543435f, 0.19548564f, -0.16737147f, 0.04726687f, -0.27698237f, 0.22033560f, -0.12285545f, -0.16212939f, 
    0.03474328f, 0.45577517f, 0.08233094f, -0.08558533f, -0.09334715f, 0.39526191f, 0.25569418f, -0.32142383f, 
    -0.12649700f, 0.00358319f, -0.03445113f, 0.17896830f, -0.10543314f, 0.14821413f, 0.37334538f, 0.14708312f, 
    -0.00675074f, -0.28323430f, 0.09609535f, 0.44415674f, 0.15112938f, 0.25755736f, 0.08990838f, 0.00534505f, 
    -0.21661286f, -0.31012389f, -0.04891589f, 0.02392348f, -0.23613365f, -0.03339767f, 0.00667480f, -0.14855234f, 
    -0.25190476f, 0.41473332f, 0.06441167f, -0.00964609f, 0.00802386f, -0.35196799f, -0.13191670f, 0.11625808f, 
    0.03369741f, -0.13483135f, 0.14038087f, -0.23742974f, 0.22478330f, 0.16942574f, -0.07299340f, 0.05152330f, 
    -0.15915801f, 0.11798601f, 0.11064582f, 0.09849714f, 0.29218629f, 0.09357933f, 0.11831743f, 0.17790750f, 
    0.23509476f, 0.08797836f, 0.01065129f, 0.04008587f, -0.07184386f, 0.13998769f, -0.16560851f, -0.07772774f, 
    0.04193425f, -0.35394654f, -0.18564573f, -0.28275278f, -0.19933751f, 0.00014672f, 0.29838523f, 0.14688455f, 
    0.28257388f, -0.01226516f, 0.14315639f, 0.03773149f, -0.27470052f, -0.01737366f, -0.00157826f, -0.02966703f, 
    0.14576371f, 0.23565598f, 0.12198564f, -0.02514781f, -0.06239184f, 0.29556143f, -0.16076298f, -0.23387934f, 
    0.33875069f, 0.28468335f, -0.07129031f, -0.12168347f, 0.40682015f, 0.12979066f, 0.03334035f, 0.03621299f, 
    -0.17135990f, 0.05117521f, 0.08785550f, -0.17179228f, 0.10966856f, 0.04575496f, -0.19524366f, -0.21654472f, 
    -0.10501578f, -0.20497306f, 0.09447767f, 0.01497429f, 0.08982784f, -0.14276172f, -0.10435459f, 0.09678574f, 
    -0.13250469f, -0.05466899f, 0.01676072f, 0.04109609f, -0.17334810f, -0.13055260f, 0.01252246f, -0.21300645f, 
    -0.11997385f, -0.18698972f, -0.05451383f, 0.01604617f, -0.09193287f, -0.15522039f, -0.03733838f, 0.15930411f, 
    0.07146447f, 0.37762892f, 0.04704981f, 0.17163257f, 0.19540659f, 0.47582480f, -0.15685523f, 0.23423053f, 
    0.04132994f, -0.17609529f, 0.32083568f, 0.06161315f, -0.19156522f, -0.14159399f, -0.11252979f, -0.05764733f, 
    0.12439632f, 0.29233485f, 0.46488073f, 0.36828995f, 0.15825249f, -0.55131334f, 0.12418919f, -0.27866048f, 
    -0.12438838f, 0.17220657f, 0.07016137f, -0.17774592f, 0.42878094f, -0.25477901f, 0.03100886f, 0.09304199f, 
    0.21494293f, -0.11366886f, 0.14718276f, -0.00885725f, 0.09678930f, -0.13615406f, 0.16550811f, -0.05096917f, 
    -0.28853258f, 0.36566561f, 0.32654297f, 0.36712930f, -0.20841333f, 0.00641808f, 0.43504208f, 0.15849155f, 
    -0.00149216f, 0.20341288f, -0.39828625f, -0.37518981f, 0.16051283f, 0.33666134f, 0.04192234f, -0.16965266f, 
    -0.06097681f, 0.27098304f, -0.13983382f, 0.04790686f, 0.16389954f, -0.15517987f, -0.16887589f, 0.15315649f, 
    -0.07006258f, -0.07452305f, -0.06970650f, -0.04542878f, -0.12216455f, 0.19292621f, 0.10242962f, 0.01167434f, 
    -0.14222789f, -0.00607654f, -0.09785710f, 0.15506363f, 0.16921024f, -0.02317145f, -0.12944980f, 0.04449344f, 
    -0.01281012f, -0.06600025f, -0.02290036f, -0.02867089f, 0.00669202f, 0.02368670f, 0.13036445f, -0.14232720f, 
    -0.12134953f, 0.05660453f, 0.11530222f, -0.15970400f, -0.04769952f, 0.00869429f, 0.11751688f, -0.09158604f, 
    0.13619700f, -0.44487700f, 0.16258250f, -0.22019847f, -0.02600217f, -0.09999555f, -0.15455396f, -0.04017104f, 
    0.39512384f, 0.32213938f, -0.25681883f, 0.29055476f, 0.02582842f, 0.16627337f, 0.14318322f, 0.10449573f, 
    0.11595982f, 0.45179582f, -0.08576062f, 0.00800428f, 0.18288341f, 0.17729706f, 0.09890673f, -0.00560999f, 
    -0.14593905f, 0.55314386f, 0.14014342f, -0.01265302f, 0.18698682f, -0.03914062f, -0.01251907f, -0.06759448f, 
    0.11986912f, 0.06267535f, -0.13975309f, -0.07227769f, -0.08712313f, 0.02378729f, -0.12790878f, -0.05624648f, 
    0.07716227f, -0.00412412f, -0.16064478f, -0.18322237f, -0.06412489f, 0.14887346f, -0.06480557f, 0.05305757f, 
    -0.08466382f, -0.08455879f, 0.00584023f, 0.00286678f, -0.07840169f, -0.14858484f, -0.12718341f, -0.13341136f, 
    -0.06276431f, -0.10607629f, 0.17442520f, 0.16112269f, 0.03575400f, 0.08962370f, -0.12569892f, -0.17438000f, 
    0.20483744f, 0.28170472f, -0.22337435f, 0.25608557f, -0.08792039f, 0.09587044f, 0.15830824f, 0.14209136f, 
    0.05710820f, -0.00681564f, 0.07041370f, 0.49559325f, -0.08471606f, 0.07549231f, 0.29096627f, -0.24536505f, 
    0.34353071f, 0.12625369f, -0.13683361f, 0.45824838f, -0.05632253f, -0.25352460f, 0.07294147f, -0.11891447f, 
    -0.24599883f, 0.10199077f, -0.06747258f, -0.04026743f, 0.24269843f, -0.42025948f, -0.03757718f, -0.06903090f, 
    -0.14946184f, 0.27645275f, -0.13372254f, 0.38992599f, 0.25050479f, -0.06908815f, 0.01094829f, 0.35964030f, 
    0.01299140f, -0.17414095f, 0.27356452f, -0.19369593f, 0.15932187f, -0.05056923f, -0.32513005f, 0.11517591f, 
    0.13768685f, -0.40078673f, 0.22346975f, -0.06298770f, 0.29419443f, -0.13220054f, -0.14066803f, 0.27080461f, 
    0.05368387f, -0.46464339f, -0.00819873f, 0.13389276f, -0.19806060f, 0.41757131f, -0.04126681f, 0.09692093f, 
    -0.31077555f, 0.35039359f, -0.22203316f, 0.12377252f, 0.18146157f, 0.00207673f, -0.27713680f, -0.01247610f, 
    0.07207172f, 0.03853633f, 0.31423688f, 0.13698390f, -0.12732767f, -0.07003118f, 0.05056656f, 0.12599999f, 
    -0.37636596f, -0.25609952f, 0.42699578f, -0.08233233f, 0.24821131f, 0.18017264f, 0.11093670f, -0.00636417f, 
    0.43523088f, 0.28305155f, 0.03376963f, -0.09749192f, 0.18536271f, 0.31417325f, 0.08514658f, -0.07507852f, 
    -0.36104506f, 0.36456013f, -0.19233054f, 0.36269343f, 0.01516646f, 0.31088263f, 0.07797521f, 0.21552996f, 
    0.16316709f, -0.26941046f, 0.05684027f, 0.24724334f, -0.43319458f, -0.13771480f, -0.33813947f, 0.07148485f, 
    -0.00587494f, -0.44508633f, 0.09940800f, 0.37955302f, 0.44449556f, 0.03132964f, 0.07508142f, 0.26767606f, 
    0.16844067f, -0.11158683f, 0.06800548f, 0.14098121f, 0.10572863f, -0.20458798f, -0.12989937f, -0.08176645f, 
    0.11113203f, 0.05091112f, -0.28725660f, 0.17498139f, 0.01080347f, -0.01030288f, -0.31096458f, 0.17619075f, 
    0.29956889f, 0.02224826f, 0.21571232f, 0.37629321f, -0.29769138f, -0.04566570f, 0.45864087f, 0.32042378f, 
    0.03077842f, 0.08440997f, -0.15950380f, 0.11577380f, -0.15106568f, -0.20534934f, 0.13827252f, 0.02844665f, 
    -0.00877927f, 0.32909441f, -0.10975488f, -0.02386874f, 0.23269720f, -0.51872206f, -0.13807490f, 0.11180184f, 
    -0.08690243f, -0.00319094f, -0.28154635f, 0.07948990f, 0.07334209f, -0.01308283f, 0.04943483f, 0.28472233f, 
    0.13853905f, 0.05092771f, 0.43324757f, 0.07199710f, 0.12664831f, -0.10715526f, 0.04471977f, 0.32577845f, 
    0.19796079f, -0.22194412f, -0.12252211f, -0.04130994f, 0.00623396f, 0.21140914f, -0.03721938f, 0.18195419f, 
    -0.05159443f, -0.42509413f, 0.05831033f, -0.15727794f, -0.27015793f, -0.09489178f, 0.05899449f, 0.02026081f, 
    -0.11140012f, -0.01341123f, -0.21984747f, 0.03251827f, 0.24327198f, -0.21859255f, -0.31050017f, 0.13417561f, 
    -0.08718701f, -0.03332180f, 0.34152716f, 0.17572697f, 0.21842435f, 0.14479215f, 0.38822821f, 0.38290033f, 
    0.06992706f, -0.40550670f, -0.15122218f, 0.03705924f, -0.04528929f, 0.13131469f, -0.17506313f, 0.11517344f, 
    0.08918660f, -0.31049982f, 0.06237786f, 0.04416419f, -0.22595389f, 0.17220736f, -0.04862981f, 0.06502943f, 
    -0.00057545f, -0.10419805f, -0.05178182f, 0.04983658f, -0.13262618f, 0.07631360f, -0.04112963f, -0.11017022f, 
    -0.13772921f, -0.18135272f, 0.14990860f, 0.06347730f, -0.01308876f, 0.13747095f, -0.16608422f, -0.02777242f, 
    0.09143529f, -0.05162966f, -0.16935280f, 0.11349622f, -0.16294874f, -0.14221494f, -0.03202052f, -0.09346650f, 
    0.11151110f, 0.06944098f, -0.05393361f, -0.17098664f, -0.13836196f, -0.09073798f, -0.16815864f, -0.10014563f, 
    0.11089078f, 0.00099606f, 0.53108269f, 0.32442874f, 0.25074917f, -0.25045997f, 0.31138936f, -0.02762566f, 
    0.16279347f, -0.10234655f, -0.02961734f, 0.01409110f, 0.00822044f, 0.06136594f, -0.02375300f, 0.18239038f, 
    0.15330437f, -0.20216279f, -0.55762279f, -0.45203778f, 0.04044103f, 0.24983487f, 0.01143922f, 0.38953912f, 
    -0.00558669f, -0.42230010f, 0.05614125f, -0.03777132f, -0.23316820f, 0.01336868f, 0.13904621f, -0.04020249f, 
    -0.01429877f, -0.21902697f, -0.06070035f, 0.05249519f, -0.21453458f, -0.03950144f, 0.24035282f, 0.17280850f, 
    0.17941451f, 0.04449761f, 0.20039582f, 0.22212690f, 0.09377313f, 0.13051444f, -0.17152502f, -0.08234657f, 
    0.01139501f, 0.44739851f, -0.24790102f, 0.35976642f, 0.12250589f, 0.07967952f, -0.15745570f, -0.30019173f, 
    -0.09619207f, 0.31408119f, -0.14578293f, 0.03234752f, 0.41604024f, -0.13736656f, -0.09983785f, -0.13183849f, 
    0.05532154f, -0.10642941f, -0.16484019f, -0.18841007f, 0.02597068f, -0.41983914f, -0.13914029f, 0.31810868f, 
    0.00488701f, -0.00313772f, 0.21832052f, -0.12082088f, 0.12702475f, 0.00439446f, 0.05541787f, -0.11598366f, 
    0.08881700f, 0.26605028f, 0.22227140f, -0.36183143f, 0.23542671f, 0.12736022f, -0.04109843f, 0.04424733f, 
    0.08401502f, 0.45806858f, 0.09202591f, -0.09371870f, 0.16937667f, 0.08425876f, -0.05927025f, 0.16838115f, 
    0.43460193f, -0.16676176f, -0.10200863f, -0.00007975f, 0.18130600f, 0.01286009f, -0.40151358f, 0.20403737f, 
    0.44159195f, 0.07856426f, -0.35375547f, -0.30104196f, 0.22409278f, -0.17716725f, 0.17158744f, -0.25382671f, 
    0.33599010f, 0.09012013f, 0.47192502f, 0.26512173f, 0.32848880f, -0.31456584f, 0.02574510f, 0.32657588f, 
    0.05066036f, -0.05153717f, -0.06727070f, 0.00963346f, -0.28372350f, 0.08007328f, 0.01624594f, -0.07200146f, 
    0.08702867f, 0.37948331f, 0.43941945f, 0.05692612f, 0.18706362f, 0.32142997f, 0.49636465f, -0.11299283f, 
    -0.41500354f, 0.21213427f, -0.05453336f, -0.19954868f, -0.08919606f, -0.09956157f, -0.10419448f, -0.07898708f, 
    0.04453960f, 0.38439813f, 0.29219711f, 0.12908772f, -0.36280712f, -0.30194247f, 0.07219329f, -0.17769247f, 
    -0.15937915f, 0.17438202f, -0.12824398f, 0.14436555f, 0.17172301f, -0.06802127f, 0.17173120f, 0.16480857f, 
    0.09674245f, -0.14837137f, -0.03308059f, -0.18740262f, 0.07897592f, 0.03077835f, 0.08402051f, -0.22418036f, 
    -0.21478345f, -0.00451979f, 0.09762709f, -0.06005633f, -0.10377458f, -0.15236573f, 0.06709326f, 0.00316910f, 
    -0.04294847f, -0.11913372f, 0.08780733f, -0.13655065f, -0.12501748f, -0.10645259f, 0.00336577f, -0.18972482f, 
    -0.16514629f, -0.09899439f, 0.09919333f, 0.17252854f, -0.06280570f, 0.03767048f, -0.07260241f, 0.07904878f, 
    -0.00018960f, -0.15306744f, 0.19286515f, -0.02149773f, 0.01333755f, 0.39789814f, -0.04567257f, 0.05607710f, 
    0.17777766f, 0.02927486f, 0.28165725f, 0.13461857f, -0.40983111f, 0.09374444f, 0.23808730f, 0.27576068f, 
    -0.22369523f, -0.08948512f, 0.25070506f, 0.08254085f, -0.33720830f, -0.39077088f, -0.04044053f, -0.16794378f, 
    0.34297004f, -0.02870102f, -0.08410839f, -0.14176841f, 0.42146409f, 0.05217792f, 0.07675929f, -0.10344650f, 
    0.09897927f, -0.08745331f, -0.11824355f, 0.12711890f, -0.00174604f, -0.16017076f, -0.14451684f, -0.02276212f, 
    -0.00877527f, -0.16814238f, -0.10095175f, -0.10666440f, -0.17283379f, 0.14578381f, -0.08531510f, 0.05360360f, 
    -0.15326348f, 0.02600026f, 0.11994974f, 0.17635213f, 0.14007181f, 0.09637222f, -0.06330754f, 0.01104364f, 
    0.16558917f, -0.18890797f, -0.10758772f, 0.09206397f, -0.05189806f, 0.11729437f, -0.08103954f, 0.12174568f, 
    -0.11539716f, 0.14575654f, 0.50708443f, 0.21255673f, 0.15752272f, 0.29108033f, -0.12124423f, -0.27684733f, 
    0.02151811f, 0.08317011f, -0.17050849f, -0.06620585f, -0.49407497f, -0.14959317f, 0.33486757f, -0.07734476f, 
    0.02471702f, -0.28838336f, 0.22213207f, 0.20056164f, -0.14476423f, 0.18271151f, -0.16467689f, 0.06524555f, 
    -0.15881418f, 0.11459845f, 0.08062243f, 0.00854636f, -0.20447341f, 0.05021039f, 0.13799809f, 0.08821975f, 
    0.03219530f, -0.04942776f, -0.04501814f, -0.15251286f, 0.00055639f, 0.02224892f, 0.03581500f, 0.06050288f, 
    -0.15376043f, -0.16757807f, 0.00754601f, 0.00004555f, 0.07473245f, -0.10854191f, -0.15745556f, 0.02260528f, 
    -0.22864251f, -0.13543464f, -0.10073855f, -0.16810302f, 0.11134248f, -0.06285315f, -0.14523235f, -0.12730856f, 
    0.00129323f, 0.10004222f, 0.05737606f, -0.00360745f, -0.03301030f, 0.04317537f, -0.16823633f, 0.11018948f, 
    -0.00676373f, 0.01903958f, 0.08690733f, 0.15481976f, -0.21435033f, 0.04689025f, -0.13177575f, -0.12079263f, 
    0.09013658f, -0.06575888f, -0.15930913f, 0.01759984f, -0.14966345f, -0.15824187f, 0.09234735f, 0.02091300f, 
    0.10594080f, -0.02411176f, 0.09000101f, 0.04422665f, 0.02191867f, -0.06313180f, 0.00395292f, -0.06871399f, 
    0.19596317f, -0.05966567f, 0.05025275f, -0.15766232f, 0.06062519f, -0.23033933f, -0.00652536f, 0.13392550f, 
    -0.00212084f, 0.01319064f, -0.07584364f, -0.17304103f, 0.14929949f, -0.03351987f, -0.05730713f, -0.02668134f, 
    -0.06112591f, -0.18590762f, -0.09077372f, -0.08821024f, 0.06922746f, 0.12748405f, -0.14661036f, 0.07873166f, 
    -0.10062998f, 0.12059523f, -0.12144451f, -0.05784139f, -0.17518179f, -0.10353947f, 0.08475269f, -0.04535334f, 
    0.12243614f, -0.17746064f, -0.02112274f, -0.17622140f, -0.16206890f, -0.05593219f, 0.04558845f, -0.16605322f, 
    -0.34195668f, -0.23268846f, -0.04461587f, -0.07968429f, 0.06017704f, -0.43219143f, 0.19257039f, 0.21305688f, 
    0.06473417f, 0.01163244f, 0.43043095f, 0.40821216f, 0.16224170f, 0.13916713f, -0.18636681f, 0.19529943f, 
    -0.27926517f, -0.04285596f, -0.45940483f, -0.10320228f, 0.05028092f, 0.41860065f, -0.00775076f, -0.09304872f, 
    0.15133077f, 0.24360482f, 0.08723473f, -0.16452116f, 0.13635118f, 0.10872029f, -0.08021712f, 0.00450363f, 
    0.33432102f, 0.29029942f, 0.02552944f, 0.39577448f, 0.12275343f, 0.31063512f, 0.10904647f, -0.03454675f, 
    0.23068835f, -0.01738491f, 0.00325941f, 0.11134505f, -0.26257521f, -0.15293853f, 0.35519600f, -0.00654832f, 
    0.26400727f, 0.26602846f, -0.22214559f, 0.22469397f, 0.03852876f, -0.34009856f, 0.02973851f, 0.24940458f, 
    -0.24665987f, -0.21759158f, -0.12290121f, 0.11925212f, -0.05969538f, -0.42811576f, -0.02784832f, 0.09289094f, 
    -0.30972922f, -0.28984839f, 0.49623066f, 0.13177346f, 0.33386523f, -0.06837687f, 0.36080164f, 0.13258684f, 
    -0.45588174f, 0.01874857f, -0.02014397f, -0.11938599f, 0.19559564f, -0.04366552f, -0.34928536f, -0.03765062f, 
    0.20777643f, -0.26415399f, 0.20320499f, -0.52442437f, 0.25853541f, 0.34385476f, 0.09514311f, -0.00144900f, 
    0.20826460f, 0.04097826f, -0.17466319f, 0.17274986f, -0.09889872f, 0.50032878f, 0.14504789f, -0.01917499f, 
    -0.38531497f, -0.02174550f, 0.55824167f, 0.30917943f, 0.24169657f, -0.09664487f, -0.25430822f, -0.04052454f, 
    0.02368130f, 0.02542140f, -0.25251329f, 0.05445792f, 0.28063571f, -0.10063911f, -0.10153880f, 0.27519745f, 
    0.02318465f, -0.13206844f, -0.50853360f, 0.07764202f, 0.20048654f, 0.23280169f, 0.03086903f, 0.27218226f, 
    0.06929738f, 0.12461375f, 0.00996478f, 0.02535018f, -0.42030418f, -0.00164854f, 0.03018521f, 0.15651827f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18672246f, 0.21047311f, 0.28998503f, -0.15544394f, -0.00737964f, 0.15620695f, 0.07807962f, 0.14151680f, 
    0.09552588f, -0.03133838f, -0.14916646f, -0.09720381f, -0.14876783f, 0.02000671f, 0.06455076f, 0.03188271f, 
    -0.04971506f, -0.11090941f, -0.14886400f, -0.08039415f, 0.12878044f, 0.00699363f, 0.07115424f, -0.18760394f, 
    0.08396985f, -0.11662651f, -0.08642694f, 0.05505331f, 0.07228898f, -0.01570211f, 0.21786827f, 0.14945500f, 
    -0.16437827f, 0.10419668f, 0.08474442f, 0.01467108f, 0.15026878f, -0.11087816f, 0.16904521f, 0.05795826f, 
    0.32283247f, 0.10948844f, -0.18148483f, 0.03191387f, 0.17315273f, 0.18316092f, 0.00994217f, -0.09092537f, 
    0.10473047f, 0.14320946f, -0.06838406f, 0.00265597f, 0.05264900f, -0.20734753f, 0.03486164f, -0.16460268f, 
    0.13619217f, -0.05151786f, -0.01478726f, 0.13602090f, 0.11133429f, 0.09070083f, 0.09677096f, 0.01334689f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01092587f, 0.14351679f, 0.01057698f, -0.04209173f, -0.11042486f, -0.23143046f, -0.08946342f, -0.39532903f, 
    0.12458041f, -0.13625760f, 0.00364676f, 0.14785485f, 0.04885652f, -0.06578796f, -0.21627910f, 0.04660644f, 
    -0.11220734f, -0.12029167f, -0.27576542f, 0.24062823f, 0.01830956f, -0.07435816f, 0.21488994f, -0.26690134f, 
    -0.42499509f, -0.52856326f, 0.03265242f, -0.10969130f, 0.11018026f, 0.01807519f, 0.15982194f, 0.05524389f, 
    -0.14460471f, -0.09998915f, 0.10071925f, -0.01381303f, 0.20280081f, -0.11783339f, 0.19957316f, 0.04604477f, 
    0.19578035f, -0.35681057f, -0.18417905f, -0.66608262f, 0.46942234f, 0.11167501f, 0.28135490f, 0.04089975f, 
    -0.03048846f, -0.19052544f, 0.09371300f, 0.36007380f, -0.28268829f, 0.08743708f, -0.05285776f, -0.11922178f, 
    0.14964958f, -0.00552484f, 0.00944550f, -0.05788530f, -0.35727653f, 0.35047475f, -0.55931431f, -0.06267231f, 
    0.06344413f, 0.07052431f, -0.33809108f, 0.05968668f, 0.32770586f, -0.17971179f, -0.10695588f, 0.11465093f, 
    0.08053106f, 0.05779581f, 0.07413660f, 0.15727556f, 0.06856343f, 0.06760327f, 0.12893127f, -0.75470114f, 
    -0.13930553f, 0.01769717f, 0.03290637f, -0.30809766f, -0.10791031f, -0.06250421f, 0.04682201f, 0.38377962f, 
    -0.04168134f, -0.00021255f, -0.02346852f, 0.05059066f, 0.00528880f, 0.09568337f, 0.03001452f, 0.07062324f, 
    -0.16450545f, 0.21957968f, 0.08879928f, 0.17528763f, 0.08923551f, -0.00284726f, 0.38400251f, 0.06639399f, 
    0.13716193f, -0.61895812f, 0.04990501f, 0.12766145f, 0.10014752f, -0.35393068f, -0.47404647f, -0.02853659f, 
    -0.48069951f, 0.36692420f, 0.23461160f, -0.13553987f, 0.04916154f, 0.01099612f, -0.10478026f, 0.05637429f, 
    -0.24055693f, 0.14161769f, -0.11104754f, 0.00207709f, 0.25539002f, -0.12124961f, -0.09235359f, -0.11496384f, 
    -0.02929533f, -0.09721790f, 0.23582275f, -0.10309558f, 0.42471778f, -0.06584326f, -0.08784792f, -0.21619952f, 
    0.09167018f, -0.38641366f, -0.22430265f, 0.31929094f, 0.06462584f, -0.01759962f, 0.01434167f, 0.08390530f, 
    -0.09647957f, -0.06770783f, -0.75754923f, -0.13698305f, 0.01941704f, -0.02210411f, 0.09928367f, -0.00481275f, 
    -0.20358478f, 0.34676003f, -0.40361720f, -0.15188579f, -0.07330634f, -0.04729036f, 0.10620691f, -0.05779059f, 
    0.02153666f, 0.33074692f, 0.09894912f, -0.90908408f, 0.11848905f, -0.12598753f, 0.23933011f, -0.05633378f, 
    -0.53663200f, -0.29164416f, 0.22953162f, -0.23320374f, -0.11559162f, 0.04637295f, 0.20218211f, 0.03582780f, 
    0.09609517f, -0.13746488f, 0.08116850f, -0.17116410f, -0.83383596f, -0.12380835f, -0.06291187f, 0.09845252f, 
    0.12685484f, 0.02361641f, 0.05434848f, -0.09375020f, 0.32835656f, -0.45379916f, 0.11111116f, 0.25722790f, 
    0.07738470f, 0.17763643f, 0.01566128f, -0.08024859f, -0.29864752f, -0.00606172f, -0.00893450f, -0.25804543f, 
    -0.36551529f, 0.21790257f, 0.05989310f, -0.42433339f, 0.05948433f, 0.03485610f, 0.03888524f, -0.16349714f, 
    0.09005018f, -0.08726849f, -0.18051340f, -0.02757779f, -0.05234395f, 0.07372579f, -0.15627533f, 0.32650355f, 
    -0.49820882f, 0.05875187f, 0.23019291f, -0.33473626f, -0.12256259f, 0.09535589f, -0.78423738f, 0.34035656f, 
    0.09568775f, -0.41599303f, -0.02382993f, 0.04103796f, 0.05714350f, -0.05389502f, -0.63076472f, -0.05425870f, 
    0.16024214f, 0.20932335f, 0.21174572f, 0.33859572f, -0.02183511f, 0.17643704f, 0.23843022f, -0.09401701f, 
    0.10842739f, -0.34462026f, -0.38647294f, -0.59475738f, 0.00829946f, 0.00616957f, -0.19338828f, 0.12459770f, 
    0.26707712f, 0.00971401f, -0.02290926f, 0.08076540f, 0.04550399f, 0.18922204f, -0.00637398f, -0.03902321f, 
    0.09258625f, 0.14461689f, -0.18294503f, -0.10227323f, 0.17588365f, 0.08782963f, -0.04359877f, 0.01427914f, 
    0.06925392f, -0.12860535f, 0.11170126f, -0.29968676f, -0.01023269f, 0.00507178f, -0.18627292f, 0.19024132f, 
    -0.11359498f, -0.08512733f, -0.18834820f, -0.13905518f, 0.10257630f, -0.12674657f, -0.21741165f, 0.04389422f, 
    -0.63586545f, -0.02197636f, 0.11817954f, -0.33350408f, 0.00381028f, -0.06907302f, -0.02529089f, -0.80573857f, 
    0.04839161f, 0.01818487f, 0.05086610f, 0.15659526f, -0.06650293f, 0.12838233f, -0.09875961f, 0.04847416f, 
    -0.04701657f, 0.31886744f, 0.04063277f, 0.38705349f, 0.04213955f, 0.02682787f, -0.08060469f, 0.05886632f, 
    0.23478100f, 0.03905913f, 0.13950545f, 0.08367393f, -0.33781338f, 0.10106942f, -0.10075668f, -0.01548567f, 
    -0.52689463f, -0.05747254f, 0.11714941f, 0.06357171f, 0.19940980f, 0.02719000f, 0.13940120f, 0.13027710f, 
    -0.03143650f, -0.25882772f, -0.13788532f, -0.10430539f, -0.04867437f, 0.25670668f, -0.00596257f, 0.25302279f, 
    -0.24577518f, 0.12776005f, 0.15503240f, -0.11480351f, 0.02495561f, -0.11414949f, -0.14195888f, 0.07121558f, 
    -0.13780425f, -0.06495643f, 0.52821141f, 0.09629364f, 0.11112371f, 0.01356536f, 0.04978627f, -0.26624009f, 
    0.51601404f, -0.37820283f, 0.14496504f, 0.29347891f, -0.04428174f, -0.03260559f, 0.12622696f, 0.24784948f, 
    -0.42682692f, 0.27581635f, 0.07325397f, 0.07794228f, 0.01980567f, -0.10104021f, 0.06217102f, -0.07594533f, 
    0.24128912f, -0.13794872f, -0.62423778f, -0.07576011f, -0.20086646f, -0.08300196f, -0.50473875f, 0.07965542f, 
    0.00077841f, 0.17254026f, -0.06685944f, 0.09257315f, 0.21523120f, 0.11869818f, -0.06796224f, 0.05927594f, 
    -0.17063758f, -0.07202536f, 0.07415015f, -0.05642199f, -0.36193576f, 0.22118630f, 0.02967904f, -0.53012037f, 
    0.06213266f, -0.13999642f, 0.28317809f, -0.11935772f, -0.56306016f, 0.01418339f, -0.07530334f, 0.16290835f, 
    0.34559184f, 0.30541527f, -0.05584883f, -0.07559843f, -0.13081527f, -0.01023212f, -0.11820864f, -0.07149620f, 
    0.01360279f, -0.11433532f, 0.03985493f, -0.28281820f, -0.10222261f, -0.03627334f, -0.03950572f, 0.12967971f, 
    -0.49861851f, 0.29215726f, -0.05321775f, 0.07707563f, 0.06644656f, 0.01678906f, -0.03697002f, -0.18457048f, 
    0.09830170f, -0.11559472f, -0.11025669f, -0.33102974f, 0.06241277f, -0.05197133f, -0.04231000f, 0.08480290f, 
    -0.16976665f, 0.00280687f, -0.56066513f, -0.63015091f, -0.34089044f, 0.14234702f, -0.04846171f, -0.10349414f, 
    0.39068255f, 0.12574887f, 0.05852595f, -0.23061961f, 0.08653134f, -0.08167142f, -0.59245032f, 0.01210963f, 
    -0.45620850f, 0.09222680f, -0.19963610f, -0.02272220f, 0.32330370f, -0.08567845f, 0.20259166f, 0.35520968f, 
    0.00631285f, 0.17827004f, -0.89857537f, -0.04153701f, 0.19014323f, -0.09309378f, 0.07916905f, 0.08088459f, 
    -0.36418906f, 0.12668958f, -0.18006513f, 0.09189116f, -0.03158343f, 0.01156034f, -0.00022984f, -0.20078745f, 
    -0.08977940f, 0.00856318f, 0.28348702f, 0.22954077f, -0.00089111f, -0.09057870f, -0.57380867f, -0.15234186f, 
    -0.12052202f, -0.31931543f, 0.10937370f, -0.30178896f, -0.05213096f, -0.08231648f, 0.02915233f, -0.09045132f, 
    0.24961039f, -0.01297636f, 0.00241102f, 0.20919462f, -0.71198136f, -0.06095053f, -0.24128605f, -0.02180880f, 
    0.10878535f, 0.17748082f, -0.02470089f, 0.29243806f, 0.15627837f, 0.08089903f, 0.00400530f, 0.11182623f, 
    -0.13875782f, 0.12381002f, -0.37345147f, 0.13373837f, -0.10769715f, 0.04799885f, 0.22267276f, 0.04052842f, 
    0.02298258f, 0.12691690f, -0.02391264f, 0.02084724f, -0.19015022f, 0.22209975f, -0.66408938f, 0.10180979f, 
    -0.02971337f, -0.54945207f, -0.16624427f, -0.04102289f, -0.10387648f, 0.12762308f, -0.04217575f, -0.19107911f, 
    -0.32030472f, -0.34711388f, -0.12348188f, 0.22477201f, 0.08334018f, 0.04009516f, 0.31967700f, 0.07908220f, 
    0.00858387f, -0.12580882f, 0.10132518f, 0.46272463f, 0.11067726f, 0.10718746f, 0.05034720f, 0.22175264f, 
    -0.04422716f, -0.08154806f, -0.35152024f, 0.24809794f, 0.04681454f, -0.13475254f, 0.01980328f, -0.21593982f, 
    0.24342194f, 0.15579896f, 0.02847024f, 0.18286125f, -0.10691863f, -0.04617240f, -0.22004308f, -0.10334131f, 
    -0.36857653f, 0.01607169f, 0.38479868f, -0.18309160f, -0.29212648f, -0.36312845f, -0.49161443f, -0.06042910f, 
    -0.58757913f, -0.15882771f, 0.23441650f, -0.00687556f, 0.27070650f, -0.06848051f, 0.14516684f, -0.08234531f, 
    0.11788440f, 0.02463145f, 0.03965640f, 0.09868699f, -0.25643834f, -0.26116666f, 0.12461299f, -0.50669134f, 
    -0.13614103f, -0.21477239f, -0.06885176f, 0.16883981f, -0.81132042f, -0.39919388f, -0.05324817f, 0.31371024f, 
    0.18498389f, -0.09781694f, 0.12391093f, -0.31143916f, -0.07144076f, 0.04511078f, 0.07669602f, 0.16328575f, 
    0.04895814f, -0.02451161f, 0.06208463f, -0.31245288f, -0.04213983f, -0.06529929f, 0.25253686f, -0.31081080f, 
    0.32044303f, -0.75157994f, 0.23112646f, 0.13632537f, -0.07035086f, -0.16682224f, 0.23027742f, 0.29622883f, 
    0.09028977f, -0.28554258f, 0.11196291f, -0.02398061f, -0.18245678f, 0.10610363f, -0.07959072f, 0.07257289f, 
    -0.31908473f, 0.33048663f, 0.01298137f, -0.28304672f, -0.54088879f, 0.05193581f, 0.28439781f, -0.07231877f, 
    -0.05321573f, -0.33665293f, 0.08086752f, 0.38823220f, -0.19113839f, -0.12490492f, -0.30391824f, -0.32815424f, 
    -0.18340649f, 0.01278695f, 0.08268090f, -0.09729397f, -0.17072840f, -0.23457594f, 0.26569551f, 0.11029309f, 
    -0.01008598f, 0.03153390f, 0.09873975f, 0.09006719f, 0.47162914f, -0.42907971f, 0.00574503f, -0.42066967f, 
    -0.58558136f, 0.02904707f, -0.20774354f, -0.18768838f, -0.04959252f, 0.07691562f, -0.30839092f, -0.39267597f, 
    0.04733865f, 0.08664462f, -0.55447906f, 0.36664099f, 0.05878252f, 0.06290309f, -0.30674988f, -0.24838635f, 
    -0.18015233f, 0.14784984f, -0.30334160f, 0.21881191f, 0.03630175f, -0.05609157f, -0.76287353f, -0.23448962f, 
    -0.15969414f, 0.22582357f, -0.03351069f, 0.14110711f, 0.24595936f, 0.06955594f, -0.16291022f, 0.05582098f, 
    -0.10838198f, -0.02178875f, 0.18689454f, -0.12114739f, 0.18626426f, 0.15277539f, 0.25281683f, 0.05401677f, 
    -0.07649148f, 0.18402226f, 0.05439689f, -0.83306026f, 0.01650820f, -0.00021886f, 0.45378304f, -0.03541194f, 
    -0.22374275f, -0.02251120f, -0.11788478f, -0.07761909f, 0.39047235f, -0.03755661f, 0.04399895f, -0.24520856f, 
    -0.04369024f, 0.24646913f, 0.00616531f, -0.14366658f, -0.35330614f, -0.46630982f, -0.02187429f, -0.61834627f, 
    0.05698196f, 0.17196777f, 0.04612802f, 0.21246448f, 0.09336960f, 0.04717964f, 0.04918808f, 0.16484588f, 
    -0.07999933f, 0.04796297f, -0.28637347f, -0.29905862f, 0.10068199f, 0.04078458f, -0.19875391f, -0.15484756f, 
    -0.09323786f, 0.28334025f, 0.17576571f, 0.18199842f, -0.01858604f, 0.07296652f, -0.53470892f, 0.17716280f, 
    -0.25622001f, -0.35252243f, 0.08336220f, 0.03643880f, 0.08509836f, 0.04963986f, 0.06672460f, 0.05290743f, 
    -0.20675930f, -0.23921615f, -0.10550838f, -0.18821156f, -0.20984785f, -0.35025129f, -0.28098327f, 0.01696403f, 
    0.27224287f, -0.40992489f, -0.49111059f, -0.13054033f, 0.38773796f, -0.03850289f, 0.10002194f, -0.06915232f, 
    0.60792810f, 0.07766266f, -0.12223302f, -0.02236047f, -0.37438965f, 0.17147085f, 0.20570448f, 0.39230230f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03735398f, 0.05347963f, -0.02054469f, -0.07236356f, 0.02753617f, 0.12722591f, -0.01470911f, -0.25183454f, 
    -0.22580783f, -0.03026732f, 0.18882960f, -0.03668610f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
