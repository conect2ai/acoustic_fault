#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19101159f, 1.30323994f, 0.84354669f, -0.94232589f, -0.09836546f, -0.72111702f, 0.02658262f, 0.11811685f, 
    -0.03262497f, -0.07135899f, -0.24965507f, 0.32257858f, 0.07313873f, -0.21284728f, -0.31865439f, 0.23228240f, 
    0.05410340f, -0.07929735f, 0.10018127f, 0.11733923f, -0.01646893f, 0.25741515f, -0.13314383f, -0.07143568f, 
    -0.09841625f, 0.02201674f, 0.06785481f, -0.01831570f, 0.24327224f, -0.13374528f, 0.12720904f, -0.13266042f, 
    -0.21906874f, 0.17219003f, -0.26107413f, -0.33813709f, 0.24347959f, 0.10435079f, 0.07701284f, 0.29401848f, 
    -0.37105510f, 0.12654589f, -0.10875732f, -0.22114149f, 0.18211989f, 0.04336799f, -0.05240637f, 0.02410023f, 
    0.12456061f, -0.05486542f, 0.28131536f, -0.45327002f, -0.37758130f, -0.42599571f, 0.01320872f, -0.41032711f, 
    -0.47043347f, -0.65502518f, -0.43935466f, -0.09570887f, 0.19093668f, 0.21574424f, 0.22934954f, -0.07452473f, 
    -0.19350022f, 0.09607139f, -0.03114297f, 0.04389898f, -0.08391703f, 0.03290034f, -0.31699044f, -0.35426128f, 
    -0.13408510f, 0.13821433f, -0.25614473f, 0.42647266f, -0.31683367f, -0.30509859f, 0.03028793f, -0.73817247f, 
    0.13586573f, -0.14014828f, 0.28445509f, -0.10652201f, 0.55673724f, -0.36251828f, 0.13724445f, -0.43128622f, 
    -0.02704328f, -0.11672502f, 0.25882703f, -0.18504375f, -0.08817461f, -0.11323014f, 0.13891444f, -0.03371140f, 
    -0.32148024f, 0.14000772f, -0.10344228f, 0.15226606f, 0.16492093f, -0.14686348f, -0.48331812f, -0.13299841f, 
    -0.04252632f, 0.60685670f, 0.16896583f, -0.11789785f, -0.27953508f, 0.53359020f, -0.08232941f, 0.15098895f, 
    -0.05468678f, -0.06829722f, -0.25259402f, -0.14478928f, -0.05474219f, -0.08018181f, -0.16223501f, -0.35454270f, 
    -0.08420318f, 0.34050977f, 0.32209617f, 0.17172121f, 0.30393186f, 0.67840904f, -0.34924778f, -0.28652683f, 
    0.06992668f, 0.12541112f, 0.25685698f, 0.68711948f, -0.35356361f, -0.59011984f, -0.50418538f, -0.11090107f, 
    0.17539266f, -0.18724236f, 0.08494465f, -0.28693151f, -0.03466970f, 0.15471140f, 0.12675297f, 0.00438886f, 
    0.15686710f, -0.05124571f, -0.20578647f, 0.10924274f, -0.08835409f, -0.00592169f, -1.21388483f, -0.54421943f, 
    0.27950463f, 0.50742567f, 0.29912907f, 0.31440341f, 0.26131719f, -0.08337235f, -0.07972485f, 0.04952702f, 
    -0.11221512f, 0.05104566f, -0.34152371f, 0.29425251f, -0.63471901f, 0.02303922f, 0.11743973f, -0.04379607f, 
    -0.09312487f, -0.08017185f, -0.37979689f, -0.12530454f, -0.13146900f, -0.00732005f, -0.47907993f, -0.95220119f, 
    -0.06530216f, 0.08316674f, -0.18842152f, -0.18880366f, 0.04323975f, -0.21912430f, -0.79930377f, -0.60828614f, 
    -0.12723772f, -0.19369642f, -0.08726863f, -0.28199786f, -0.50957745f, -0.43215686f, -0.08038387f, 0.14037570f, 
    -0.21015935f, -0.05794780f, -0.35457379f, 0.16656202f, -0.27205980f, -0.24615663f, -0.08748459f, 0.00785139f, 
    -0.77174509f, -0.41304979f, -0.46942711f, -0.60316432f, -0.17682280f, 0.61129814f, -0.18907711f, -0.27260980f, 
    0.02544289f, 0.28438610f, -0.13641608f, -0.05140466f, -0.44504288f, -0.11242270f, -0.53195405f, -0.08329685f, 
    -0.40458959f, 0.17802328f, -0.17187859f, -0.49642086f, -0.13806392f, 0.05667704f, -0.02644466f, -0.23604961f, 
    0.16027083f, 0.92988867f, -0.95041287f, -0.89489812f, 0.30949619f, -0.65146685f, 0.74090034f, 0.51559609f, 
    -0.09706922f, -0.29267418f, -0.12981835f, -0.38094935f, -0.10726617f, -0.10354387f, -0.07315712f, 0.48850057f, 
    -0.13152520f, 0.04003000f, 0.07362144f, -0.29771885f, -0.37291923f, 0.03401149f, -0.38687429f, 0.00391521f, 
    0.12859011f, -0.26281598f, 0.04602062f, -0.05539655f, 0.31380761f, -0.27182156f, 0.04035623f, 0.15168256f, 
    0.08508651f, -0.22293760f, 0.06034417f, 0.05437490f, -0.15877487f, 0.39527506f, -0.03742688f, -0.06202885f, 
    -0.17451075f, -0.03110655f, 0.24931516f, -0.26568633f, 0.01680770f, -0.10628130f, -0.24041443f, 0.48434418f, 
    0.20953849f, -0.20872149f, -0.11465896f, 0.05074425f, 0.12641905f, 0.25467500f, -0.04868913f, -0.05620632f, 
    -0.23878956f, -0.09740047f, 0.49651182f, -0.12475124f, -0.45833409f, -0.32032368f, -0.30897138f, 0.02721474f, 
    -0.05054956f, 0.27496728f, -0.12607706f, 0.45541140f, -0.10026836f, -0.10429649f, -0.08897361f, -0.11042367f, 
    -0.14836089f, -0.35946238f, -0.04911337f, 0.32594174f, 0.45081151f, 0.23692308f, -0.01489611f, -0.26630095f, 
    -0.55122155f, -0.16716345f, -0.21558048f, -0.43465057f, -0.22980914f, -0.33521020f, 0.40693274f, 0.35628399f, 
    0.23687017f, 0.29023609f, 0.02559874f, -0.04942160f, 0.01895701f, -0.24782757f, -0.11915941f, -0.15616617f, 
    -0.08969735f, -0.13930462f, -0.12727861f, 0.02825207f, -0.36316249f, -0.00889301f, 0.38975912f, -0.63967258f, 
    -0.78551012f, -0.79675990f, -0.36002448f, -0.09526326f, 0.18619534f, 0.21908957f, 0.47370893f, 0.08871254f, 
    -0.06352010f, 0.02790914f, 0.05902926f, 0.28678018f, -0.03060579f, 0.20638083f, 0.01062663f, -0.39381745f, 
    -0.34243724f, -0.03237909f, 0.15107225f, -0.35779485f, -0.13055080f, 0.46218723f, 0.06735460f, 0.41229883f, 
    0.46347401f, -0.23523672f, -0.65366775f, -0.23559293f, 0.01449514f, -0.24120985f, 0.05425590f, 0.19286671f, 
    0.10345898f, -0.10149608f, -0.24822187f, 0.25994191f, 0.30112889f, -0.03831823f, 0.14559393f, 0.17892788f, 
    -0.27307895f, -0.25494283f, 0.21409918f, 0.21850595f, 0.03462429f, -0.27907687f, -0.03151162f, -0.96015650f, 
    -0.40635914f, -0.62437308f, -0.51960146f, -0.51378423f, 0.53889406f, 0.41515630f, -0.59460646f, -0.43205449f, 
    0.39878765f, 0.18928948f, 0.02751787f, -0.16270883f, -0.19238591f, -0.12785442f, 0.10946498f, 0.41470307f, 
    0.21129133f, -0.01380730f, -0.06031097f, -0.21206076f, -0.17290998f, -0.26103795f, -0.11617684f, -0.05787227f, 
    -0.99962938f, -0.12795132f, 0.39249620f, -0.73796684f, -0.45139414f, 0.37683100f, 0.29065627f, 0.13704206f, 
    0.41976529f, 0.20869313f, -0.10990516f, -0.07604848f, 0.03947328f, 0.07379791f, -0.07821216f, -0.13483872f, 
    -0.18102756f, -0.31982711f, -0.17800869f, -0.22175817f, -0.03997421f, 0.14278981f, 0.24911118f, -0.15810868f, 
    -0.19474776f, -0.31236634f, -0.35977468f, 0.48032230f, 0.37000263f, 0.35186535f, -0.18513586f, -0.25984797f, 
    -0.04762788f, -0.43283105f, -0.33886102f, 0.26667491f, 0.16854629f, 0.10422434f, 0.10973383f, 0.13154384f, 
    0.04855386f, -0.32878083f, -0.00486296f, 0.07903301f, 0.03492814f, -0.07036348f, 0.13441153f, 0.32108146f, 
    0.12556003f, -0.24001107f, -0.14663886f, -0.12807101f, 0.18523619f, 0.23965056f, -0.12661199f, -0.11432638f, 
    -0.15238993f, 0.17421123f, 0.37908253f, -0.30917686f, -0.08528291f, 0.13861869f, -0.01439331f, 0.08313976f, 
    -0.04281984f, 0.25115436f, 0.07064375f, -0.30300695f, -0.31509995f, 0.11953344f, 0.43162373f, -0.41782990f, 
    -0.18148556f, -0.02282788f, 0.19747160f, -0.07775651f, -0.61110991f, 0.08742753f, 0.49119237f, -0.61658525f, 
    0.67015123f, 0.14657027f, -0.25339112f, -0.45110664f, 0.25884232f, -0.18554173f, 0.32730699f, -0.31202555f, 
    0.25134158f, 0.03721160f, -0.25394127f, 0.06008927f, -0.39785329f, -0.20680074f, 0.45579079f, 0.26115072f, 
    -0.32718548f, 0.10943964f, 0.32511041f, -0.20716031f, -0.21726494f, -0.33372968f, -0.59298450f, -0.50881463f, 
    -0.36346564f, -0.05891854f, 0.09906948f, 0.35251182f, -0.36855260f, -0.23554809f, 0.26360515f, 0.53626889f, 
    0.32900429f, 0.16074061f, -0.18005908f, -0.45596564f, -0.16451839f, -0.19568872f, -0.11552530f, 0.14226520f, 
    0.05851430f, -0.32888982f, -0.18706965f, 0.22282290f, 0.41864869f, 0.11936409f, -0.45722702f, 0.38330561f, 
    0.31895986f, -0.20282587f, 0.48299292f, 0.31571135f, -0.52489674f, -0.64519066f, -0.21090779f, -0.08885393f, 
    0.29006681f, -0.15889314f, -0.16257606f, 0.30290982f, 0.05786295f, 0.00688653f, -0.10505767f, 0.24390532f, 
    -0.30722976f, -0.04901951f, -0.10846517f, -0.43802109f, -0.04250713f, -0.61245126f, -1.33485782f, 0.01597156f, 
    0.65330005f, -0.10077415f, 0.07964969f, -0.06788876f, 0.12459221f, -0.20528914f, 0.67856926f, -0.15910521f, 
    -0.44263235f, -0.33137760f, 0.09076311f, 0.00390260f, 0.24322866f, 0.32330236f, -0.09732568f, -0.11341683f, 
    0.06953967f, -0.00456137f, 0.12046996f, 0.03352991f, 0.04046139f, 0.02111261f, -0.11563417f, -0.86911225f, 
    -0.52781367f, -0.12246791f, 0.35377675f, 0.57453114f, -0.10816940f, 0.32795969f, 0.07112134f, 0.13518375f, 
    -0.30749539f, -0.17349300f, 0.37502721f, -0.41561818f, 0.47968832f, -0.53518009f, 0.06897999f, -0.12376682f, 
    -0.13800448f, 0.19915441f, -0.03763717f, 0.15018965f, -0.24653262f, -0.18753767f, 0.09296063f, 0.13887870f, 
    -0.04658033f, -0.49333641f, -0.46091604f, -0.44182241f, -0.48208073f, -0.56543380f, -0.71196878f, -0.59150869f, 
    -0.63117129f, -0.74226391f, 0.22092815f, -0.08170218f, 0.18470359f, 0.55259860f, 0.09889913f, 0.09141754f, 
    -0.14763184f, 0.25250763f, 0.04875878f, 0.06773282f, -0.16487962f, 0.23028013f, -0.05731408f, 0.14635456f, 
    0.13008837f, 1.15084469f, -0.12950248f, -0.44135088f, -0.35607445f, -0.79354584f, -0.06278148f, -0.10561899f, 
    0.24557701f, 0.19681452f, 0.31756961f, 0.14541587f, 0.22282267f, 0.22369885f, -0.23555005f, -0.24276859f, 
    -0.41158268f, -0.03221017f, 0.25946337f, 0.01158407f, -0.09240920f, 0.15768351f, 0.14880469f, -0.06080915f, 
    0.24990326f, -0.01201526f, 0.27989221f, 0.20173946f, 0.03045463f, 0.26416379f, 0.18019131f, 0.40154278f, 
    0.24827747f, 0.27992347f, 0.12798259f, 0.00670830f, -0.16241601f, 0.06960277f, -0.04874650f, 0.11121309f, 
    -0.24779107f, 0.14613158f, 0.03327510f, -0.27637076f, -0.08156136f, -0.24664600f, 0.03973317f, 0.07340362f, 
    0.11044116f, -0.08311575f, -0.12980714f, 0.33943814f, -0.05076794f, 0.20542906f, -0.35839367f, -0.11620935f, 
    -0.26508611f, 0.19308229f, -0.11928651f, 0.19057889f, -0.16323976f, -0.20560892f, -0.02283681f, 0.01994543f, 
    0.08361246f, 0.18274827f, 0.06743672f, 0.10549893f, -0.18127592f, -0.01078541f, 0.16113769f, -0.23589146f, 
    -0.00277878f, -0.22953919f, 0.14707051f, 0.33347747f, 0.44193479f, 0.25490931f, -0.08920965f, -0.28149700f, 
    0.11921107f, 0.02208097f, -0.12854598f, 0.33010337f, 0.07899558f, -0.48082376f, -0.10654253f, -0.19250128f, 
    -0.08375286f, 0.24349940f, -0.01915786f, 0.33783585f, -0.19113207f, 0.04363466f, -0.41310242f, 0.23976052f, 
    0.14663272f, -0.34420505f, -0.28407550f, 0.28153896f, 0.20733213f, 0.33000165f, 0.10812815f, -0.58447212f, 
    -0.47437066f, -0.29136097f, -0.10400285f, -0.01444662f, 0.53153116f, -0.80477762f, -0.69262159f, -0.19224933f, 
    -0.34406555f, -0.38880157f, -0.01172310f, -0.22345836f, -0.46604800f, -0.35772446f, -0.22564027f, -0.24378785f, 
    -0.12125217f, 0.09600068f, -0.04206369f, 0.04768790f, -0.19909687f, -0.26824245f, 0.64054304f, 0.09688863f, 
    0.29200581f, 0.19150169f, 0.10167412f, -0.44504943f, -0.36670518f, 0.03622663f, -0.12062544f, -0.16184705f, 
    0.03427942f, -0.17399161f, -0.17974854f, -0.28062961f, 0.34582704f, -0.23304784f, 0.23825744f, -0.15933612f, 
    0.19929861f, 0.14908998f, -0.07137925f, -0.09141817f, 0.03758723f, -0.17253911f, -0.09393904f, 0.07560347f, 
    -0.43071976f, -0.14013563f, 0.10964216f, 0.40995738f, -0.29046381f, -0.34736317f, -0.40856457f, 0.08686838f, 
    -0.16172643f, -0.02061099f, 0.14503309f, 0.06460309f, 0.01061499f, -0.21124478f, 0.09701029f, 0.24056256f, 
    -0.20094430f, 0.04219344f, 0.12891613f, 0.08678249f, 0.08419388f, 0.06364570f, 0.13709363f, 0.25941572f, 
    -0.51525706f, 0.18779439f, 0.07621208f, 0.24389188f, -0.08168982f, -0.69414604f, -0.50610715f, 0.40640426f, 
    0.43413410f, 0.32440895f, 0.10422312f, -0.00159295f, -0.05569656f, -0.12219990f, -0.22997868f, 0.31907317f, 
    -0.17670226f, -0.07857957f, -0.33201930f, -0.01172567f, -0.13057441f, -0.29999110f, -0.33738431f, 0.11309524f, 
    -0.29420599f, 0.10073911f, -0.37190372f, 0.01832017f, -0.31819874f, -0.59651625f, 0.05783964f, -0.01860713f, 
    0.16066001f, -0.11972573f, 0.26123181f, -0.18487349f, 0.25361270f, 0.32456043f, 0.03759442f, -0.24722707f, 
    0.04155561f, 0.20734179f, -0.23896408f, -0.02845827f, 0.14045057f, -0.24649182f, 0.28540665f, -0.05276014f, 
    -0.25243935f, -0.21372396f, -0.17766555f, 0.39079618f, -0.11325061f, -0.48665547f, 0.15329878f, -0.34869537f, 
    -0.13049558f, 0.25879651f, 0.21267596f, 0.20473222f, -0.12635432f, -0.26426119f, 0.30361059f, 0.03820240f, 
    -0.17553239f, 0.05750198f, -0.18273252f, -0.27654487f, 0.16272864f, 0.06035200f, -0.04556918f, 0.11525849f, 
    -0.04811881f, 0.11159819f, 0.27483535f, 0.57227904f, 0.24345814f, 0.16704363f, -0.23575501f, -0.26389804f, 
    0.15856555f, -0.19962992f, -0.34089223f, -0.30706242f, -0.30716214f, -0.03960418f, -0.00680642f, -0.06207844f, 
    0.32774884f, 0.14834261f, 0.08272677f, 0.28516290f, 0.09645589f, -0.16584840f, -0.22721033f, -0.38050744f, 
    0.29603401f, -0.10897022f, -0.06291285f, -0.06883908f, -0.41378471f, -0.19851498f, 0.33667031f, -0.12218049f, 
    -0.47346887f, -0.70209789f, -0.36738899f, -0.66653454f, -0.31792086f, -0.04416130f, 0.41007945f, -0.08450227f, 
    0.09996833f, -0.34673765f, -0.16982797f, -0.58246940f, 0.11219483f, -0.35215208f, -0.22694123f, -0.46957901f, 
    -0.19223669f, -0.01006315f, -0.01322381f, 0.34338778f, 0.24451166f, -0.31777987f, 0.01688095f, 0.31732365f, 
    -0.27920887f, -0.13421243f, 0.16307034f, 0.21041894f, -0.25794342f, 0.22531308f, 0.39225736f, 0.32880837f, 
    -0.35585177f, -0.14005446f, -0.20638859f, 0.07114466f, -0.08518167f, -0.32939294f, 0.11582164f, 0.26102671f, 
    0.08076704f, 0.08536591f, 0.09459776f, 0.23065996f, -0.05571932f, 0.09634143f, 0.36512974f, -0.01854439f, 
    -0.07225859f, -0.10580521f, 0.16247834f, 0.16078036f, -0.15424272f, -0.13819881f, 0.23834985f, -0.13814078f, 
    0.02406276f, 0.28563780f, -0.13103746f, 0.05677937f, -0.02208653f, -0.22587626f, 0.08530661f, -0.10284501f, 
    -0.01651086f, 0.16050367f, -0.15432401f, 0.11535090f, 0.14146098f, -0.11491553f, 0.05279167f, 0.15813762f, 
    -0.73032427f, -0.66692150f, -0.35719171f, -0.23519927f, 0.19710574f, -0.11904668f, 0.37167981f, 0.48801419f, 
    -0.25685573f, -0.04065774f, 0.18180703f, -0.11042535f, -0.15398082f, 0.20639451f, 0.01174906f, -0.11463489f, 
    0.06824689f, 0.04992620f, 0.19246961f, -0.30392152f, 0.19752140f, 0.18565595f, -0.25275752f, -0.34314984f, 
    -0.39660758f, -0.18376517f, -0.28648007f, 0.37280583f, 0.31321776f, 0.31792787f, 0.43070439f, -0.27744228f, 
    -0.08384235f, -0.44681662f, 0.25747299f, -0.14811090f, 0.23050506f, -0.23678690f, 0.08484519f, 0.08518718f, 
    -0.40904060f, -0.18599556f, 0.14464742f, 0.45688567f, -0.05948318f, -0.00388106f, 0.17788729f, -0.06558269f, 
    -0.23409241f, 0.87740481f, 0.40763810f, -0.31247249f, -0.03062732f, -0.10069440f, -0.01025786f, 0.04517201f, 
    0.24870311f, -0.14545293f, -0.22987442f, -0.24387664f, 0.28029734f, -0.11274672f, -0.18186301f, -0.23056275f, 
    -0.17192662f, 0.15477097f, 0.03898225f, 0.07651972f, -0.28070149f, -0.13176961f, -0.12224116f, 0.15959305f, 
    0.09002145f, -0.04902830f, 0.47052115f, -0.46170488f, -0.14413302f, -0.32341740f, -0.44101653f, 0.02895684f, 
    0.20960955f, 0.23013134f, 0.00873761f, -0.25806808f, 0.09918306f, -0.03932378f, 0.41584462f, 0.29302242f, 
    0.11016953f, 0.02085036f, -0.12570205f, -0.08895466f, -0.48265564f, 0.03920196f, 0.34410566f, 0.15856943f, 
    0.27023199f, 0.05323324f, 0.08996198f, -0.06064890f, -0.68407792f, 0.27297589f, -0.20133203f, -0.21432202f, 
    0.16848232f, 0.21456298f, -0.03331367f, -0.05351914f, 0.14707804f, 0.01924727f, -0.04659487f, 0.01515089f, 
    -0.01366610f, -0.04099851f, -0.23143463f, -0.11339656f, -0.06885541f, -0.21655416f, -0.26812977f, -0.39482567f, 
    -0.40262619f, -0.19359878f, -0.36637932f, -0.39180672f, -0.17763156f, 0.00244126f, -0.13626795f, -0.12900399f, 
    0.47260812f, -0.36079431f, 0.03741978f, 0.38389915f, 0.32346642f, 0.08793366f, -0.40500268f, -0.37861210f, 
    -0.06132238f, 0.65681946f, -0.26182723f, 0.00478789f, 0.23093770f, -0.27119565f, 0.09937095f, -0.11334819f, 
    0.01904218f, -0.00239487f, 0.05584909f, 0.04260880f, -0.24044847f, 0.51556635f, -0.03213139f, -0.63975841f, 
    -0.20932105f, -0.22501633f, 0.03047179f, 0.45313981f, -0.64230359f, -0.76358163f, -0.58909929f, -0.09989259f, 
    0.19222653f, -0.18492594f, -0.13956614f, 0.37952358f, -0.14962518f, -0.55246168f, 0.11945405f, 0.10062916f, 
    -0.36430252f, 0.22529531f, -0.32723200f, 0.03902331f, 0.33686739f, -0.00726401f, -0.39693013f, 0.02933332f, 
    -0.06605722f, 0.23474227f, -0.13685805f, -0.23576319f, -0.16471289f, -0.21856463f, -0.22652000f, 0.27678323f, 
    0.00059516f, 0.27034715f, 0.12651920f, 0.07894867f, 0.06893997f, 0.07815296f, -0.21285726f, 0.10845515f, 
    -0.07232409f, -0.34922510f, -0.31924021f, 0.46677482f, 0.05673510f, 0.00104696f, 0.32492876f, 0.15029515f, 
    0.40951660f, -0.21416758f, -0.54079986f, -0.31165472f, -0.07630809f, -0.21691218f, 0.00480699f, -0.04971780f, 
    -0.15467148f, 0.05197040f, -0.16314504f, -0.27672386f, 0.27499065f, -0.12524708f, -0.11155300f, -0.01139471f, 
    -0.17352666f, 0.07621585f, -0.25669301f, 0.13583948f, 0.17869106f, 0.34150255f, 0.44690964f, -0.00281445f, 
    0.55643952f, -0.16235261f, 0.50635409f, -0.58567774f, -0.67456526f, -0.41239923f, 0.31542307f, -0.16348466f, 
    0.11362775f, -0.16925347f, 0.04064897f, -0.25057048f, -0.01215349f, -0.12603579f, 0.40155891f, -0.16546541f, 
    -0.17836392f, -0.04173674f, 0.21332870f, 0.07047633f, 0.17441088f, -0.01727981f, -0.31605089f, -0.52586460f, 
    -0.33043060f, -0.94019371f, -0.30993408f, -0.49169186f, 0.39955905f, 0.36572447f, -0.17814620f, -0.29151660f, 
    -0.15849435f, 0.70266867f, 0.47955236f, 0.32087752f, 0.19292536f, -0.12081104f, -0.27260470f, -0.08596365f, 
    -0.19369583f, -0.09896070f, 0.38032699f, -0.08843996f, 0.28395140f, 0.03921297f, -0.06483088f, 0.14080732f, 
    -0.20833966f, -0.08719271f, -0.03110686f, -0.87805134f, 0.13915011f, 0.57432449f, 0.25253388f, -0.62878197f, 
    -0.64372569f, 0.09618260f, 0.22860405f, 0.44830826f, -0.10378811f, -0.40744704f, -0.11890788f, 0.00617149f, 
    0.31579620f, -0.25340417f, -0.12115190f, 0.18706158f, -0.00447993f, -0.09356657f, -0.28924477f, -0.02779005f, 
    -0.47267044f, -0.36316442f, -0.02139043f, 0.25511214f, 0.31439519f, 0.24870101f, 0.34100434f, 0.06115396f, 
    0.21098647f, 0.06359021f, 0.15708518f, 0.09087680f, -0.04851783f, -0.02568731f, 0.16763660f, -0.18340604f, 
    -0.00013561f, 0.10261370f, -0.23741344f, -0.06693267f, -0.10667448f, -0.01161073f, -0.20249602f, -0.03420588f, 
    0.14610663f, 0.03353481f, -0.01925551f, 0.06027706f, -0.36799434f, -0.30754858f, 0.02795168f, 0.37923783f, 
    0.00646248f, 0.14387715f, -0.59050030f, -0.20964876f, 0.35576925f, -0.16818202f, 0.31069502f, -0.00612714f, 
    -0.13645323f, 0.28638893f, -0.00061710f, 0.01549449f, 0.14598125f, 0.16216791f, -0.17550801f, 0.12237733f, 
    0.05907491f, -0.07959284f, -0.03647425f, -0.28437391f, -0.07674345f, 0.33797842f, 0.06317647f, 0.17538647f, 
    0.24365811f, -0.25610563f, 0.03661112f, 0.01721425f, 0.15850225f, 0.14771457f, -0.24936363f, 0.17480564f, 
    0.25571233f, -0.20427324f, -0.07222974f, 0.08418642f, -0.16890223f, -0.06450611f, -0.04383940f, -0.10334730f, 
    0.03415231f, 0.14633682f, 0.00446238f, 0.20976904f, -0.13170615f, -0.21984446f, -0.24372362f, 0.34286878f, 
    0.23713166f, 0.62057555f, 0.51501250f, -0.34594047f, -0.46794853f, -0.51533610f, -0.41651556f, -0.43570399f, 
    -0.02845897f, -0.19757876f, -0.05282407f, 0.14039195f, 0.16752203f, -0.05247425f, 0.24503787f, 0.12217636f, 
    -0.12262590f, 0.13687815f, -0.30877054f, -0.09831738f, -0.16849068f, 0.25762311f, -0.02985315f, -0.93208283f, 
    -0.52515578f, -0.66464162f, -0.74792564f, -0.51193917f, 0.17610241f, 0.06872125f, -0.08361274f, -0.02057398f, 
    0.07047270f, -0.14327909f, -0.24930778f, -0.38648406f, -0.13245708f, -0.21687470f, 0.04552709f, -0.13802105f, 
    -0.14558451f, 0.18025224f, -0.17296205f, -0.06521451f, 0.08430173f, 0.04723921f, 0.04003695f, -0.01011346f, 
    -0.34635216f, 0.31727436f, 0.42944035f, 0.26565570f, -0.00415011f, 0.10606799f, -0.12379980f, -0.36804375f, 
    0.17834930f, 0.08393484f, -0.11509051f, -0.09993784f, -0.19489555f, -0.02127047f, -0.19141234f, 0.02662663f, 
    0.16157153f, -0.00506634f, -0.07688701f, 0.18045993f, -0.17580444f, -0.13582921f, -0.09663117f, -0.00251531f, 
    -0.20912743f, 0.51775795f, -0.14109559f, -0.71496123f, -0.48271850f, -0.44891870f, -0.05709177f, 0.09925475f, 
    0.57778776f, 0.19921835f, 0.12229422f, -0.32426438f, -0.09954233f, -0.39732125f, -0.25654459f, -0.00298015f, 
    -0.07156294f, 0.27353567f, 0.30886808f, 0.02036934f, -0.23121610f, 0.09991973f, -0.07549059f, -0.01756768f, 
    0.11705297f, 0.24124262f, -0.85337245f, -0.61543095f, -0.40761140f, -0.49592686f, -0.67944533f, 0.66336745f, 
    0.45911780f, 0.29136467f, 0.28100708f, 0.66481137f, 0.01536601f, 0.22330575f, 0.13884932f, 0.14079288f, 
    -0.21375300f, 0.03672983f, 0.01631478f, 0.11984617f, -0.17459425f, -0.04545750f, -0.08388725f, -0.07607276f, 
    -0.14348042f, 0.00570132f, 0.04683854f, -0.56585068f, -0.52561235f, -0.35603508f, 0.30023950f, 0.56364250f, 
    -0.40046334f, -1.03205538f, -0.58720160f, -0.32448068f, -0.61521590f, 0.27812606f, -0.09259686f, -0.31437072f, 
    -0.05699315f, -0.27416292f, -0.09605094f, -0.25153404f, -0.24680589f, -0.45156878f, 0.00187987f, -0.31561407f, 
    0.25428444f, 0.15435936f, -0.37703583f, -0.12767954f, -0.11395065f, -0.14778115f, -0.01451826f, 0.29878527f, 
    0.18761896f, 0.29375854f, 0.15182883f, -0.12128437f, -0.10091491f, -0.27928597f, -0.12202903f, 0.46045956f, 
    0.07959563f, -0.30371663f, -0.18318012f, -0.05674728f, 0.12713166f, 0.04176345f, 0.16602485f, -0.05634336f, 
    0.09169938f, 0.06267089f, -0.28956240f, -0.27975675f, 0.33296090f, -0.42104289f, -0.66833699f, -0.01509302f, 
    0.51815385f, 0.40119678f, 0.23175466f, -0.29182422f, -0.22152866f, 0.46109676f, 0.36019105f, -0.09043636f, 
    0.01148090f, 0.22464848f, 0.08590636f, -0.31260794f, -0.16780247f, -0.13721508f, -0.20787966f, 0.24063258f, 
    0.13320602f, 0.01337669f, -0.09221530f, -0.29704329f, -0.01059658f, 0.31187895f, -0.83701521f, -0.55948192f, 
    0.34568456f, 0.46160215f, 0.33661139f, 0.42041290f, 0.61832237f, -0.08354963f, -0.30238628f, -0.16147758f, 
    0.08761537f, -0.17364360f, -0.01150046f, 0.23720407f, -0.14609177f, -0.31339258f, 0.08046246f, -0.22812651f, 
    -0.15442899f, 0.23779340f, 0.05555024f, -0.13153201f, 0.19794554f, 0.11267091f, 0.06177719f, -0.09798300f, 
    0.34018186f, 0.36776897f, -0.37613848f, 0.38038239f, -0.55725741f, -0.15696040f, 0.25383219f, 0.03418549f, 
    0.07421402f, -0.27846622f, -0.30886972f, -0.02191044f, -0.04430798f, 0.27375740f, 0.24922724f, 0.03083409f, 
    -0.25664034f, -0.10395514f, 0.16349097f, -0.07971501f, 0.11303056f, -0.13488749f, -0.29511413f, -0.51732242f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28389084f, 0.03904429f, -0.26324594f, -0.03965807f, 0.06170209f, 0.05699436f, -0.09801982f, -0.37092951f, 
    -0.15884271f, 0.06290366f, 0.23341884f, 0.10093274f, -0.05811699f, 0.38761353f, 0.32823446f, 0.03136075f, 
    -0.04718829f, 0.05957528f, 0.18286984f, 0.09703573f, 0.50926965f, -0.09047028f, 0.10992496f, 0.11695916f, 
    -0.17878552f, 0.26266760f, -0.27024269f, 0.27616802f, 0.09305484f, -0.09135235f, 0.12744248f, 0.28558517f, 
    0.17686479f, 0.22011539f, 0.14401649f, 0.07179071f, 0.19786045f, -0.14215378f, -0.15867727f, -0.04158001f, 
    0.14815527f, 0.34630230f, -0.17203961f, 0.11403640f, 0.21276933f, -0.09440512f, 0.22441368f, -0.04178793f, 
    -0.08674397f, 0.12096868f, 0.04919609f, -0.33276337f, 0.02584053f, -0.14150403f, 0.00145790f, -0.23776208f, 
    0.16198662f, -0.14758559f, 0.11006410f, 0.00840076f, 0.12029296f, 0.46344200f, 0.41705784f, -0.01988711f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.60419601f, -0.04277474f, -0.03625399f, 0.18952009f, -0.11241052f, 0.07219923f, -0.11328884f, -0.03912599f, 
    -0.01607583f, 0.01129020f, -0.01782866f, 0.00629374f, -0.07117275f, -0.06675102f, -0.02093625f, 0.03907973f, 
    -0.01685126f, 0.06620393f, -0.08571219f, 0.03319797f, -0.04012690f, 0.01356710f, -0.05573087f, -0.15075000f, 
    0.25548089f, 0.22990170f, -0.13235119f, -0.10634690f, 0.10552488f, -0.07354145f, -0.00677347f, 0.05824498f, 
    -0.07284650f, -0.03709430f, 0.00118960f, 0.05224114f, 0.01996885f, 0.10860034f, 0.00661444f, -0.03759579f, 
    0.08757459f, 0.03018731f, 0.01269085f, -0.07967867f, -0.06245011f, 0.01544930f, 0.01018314f, -0.08413034f, 
    0.05264325f, -0.00520782f, -0.29103011f, 0.09547582f, 0.06751116f, 0.08559085f, -0.01747171f, -0.01831822f, 
    -0.00447647f, -0.00169348f, -0.10535017f, -0.14329092f, 0.19053258f, -0.30263054f, -0.13818274f, 0.06273058f, 
    -0.14990145f, -0.29771325f, -0.03413475f, -0.05641638f, -0.09252111f, 0.02140347f, 0.01731358f, -0.02132730f, 
    0.42751727f, -0.04588764f, -0.09137676f, -0.14639437f, 0.03207122f, -0.04327179f, 0.05604301f, 0.01257261f, 
    0.05998648f, -0.00971489f, -0.10456182f, 0.06425238f, 0.31297857f, 0.36396319f, -0.15462002f, -0.14455706f, 
    0.02286432f, 0.11057811f, 0.12794971f, 0.16953051f, -0.01283609f, -0.04406089f, -0.03495794f, -0.11331739f, 
    0.19564946f, 0.16698873f, 0.03912481f, -0.10049152f, 0.08533338f, 0.22229654f, 0.06746132f, -0.06536163f, 
    0.00397291f, -0.02903244f, -0.06502850f, 0.03259864f, 0.22109701f, 0.02862458f, -0.14520226f, 0.05107359f, 
    0.08886675f, -0.04986459f, -0.15365577f, -0.20623532f, -0.12301276f, -0.07101965f, -0.00896679f, 0.14673641f, 
    -0.00218791f, -0.12242738f, -0.05037368f, 0.00995363f, -0.01818677f, -0.02548128f, 0.01644657f, -0.00662185f, 
    -0.08228578f, -0.00966195f, -0.01157998f, -0.15589534f, -0.22236097f, -0.35458741f, 0.34902683f, -0.17328547f, 
    0.04451636f, -0.03427642f, -0.01263905f, 0.11467633f, 0.03875232f, 0.02212892f, 0.01770571f, -0.01694063f, 
    0.21720469f, 0.01731476f, -0.11233835f, -0.05089611f, -0.04692976f, -0.09863997f, -0.16679965f, 0.07552299f, 
    0.04247345f, 0.09246816f, 0.00417029f, 0.04251126f, 0.10422426f, -0.10713482f, 0.04864226f, -0.01700111f, 
    0.01158537f, 0.06593471f, -0.15034080f, -0.20720690f, -0.11401314f, -0.09191067f, 0.04370148f, -0.03948039f, 
    -0.05183865f, -0.24126489f, -0.03675413f, -0.12485846f, -0.15357707f, -0.09049714f, -0.19142680f, -0.15766159f, 
    -0.06254408f, -0.16697854f, 0.00386477f, -0.09663263f, 0.22706676f, 0.15989435f, -0.15441965f, -0.12045714f, 
    0.15268379f, 0.18475991f, 0.03037564f, -0.03255822f, 0.03970996f, 0.00432347f, 0.05188073f, 0.03585993f, 
    -0.20107254f, -0.21141279f, -0.06159874f, -0.05030022f, 0.00093359f, 0.09033159f, 0.02713354f, 0.11543353f, 
    -0.04302478f, 0.07740668f, -0.14005370f, 0.04596651f, 0.04878747f, 0.12628482f, -0.04674658f, -0.16744113f, 
    -0.03031355f, -0.10883538f, -0.08704652f, -0.04059784f, -0.00703092f, 0.00874438f, 0.02324740f, -0.03695384f, 
    -0.21754035f, -0.07149868f, 0.04426283f, -0.15170923f, -0.05231905f, -0.00737949f, 0.05095910f, 0.09844908f, 
    -0.16283043f, -0.04026994f, -0.00446109f, -0.16833626f, 0.14137153f, -0.32307118f, -0.30201459f, -0.17199831f, 
    -0.01437772f, 0.00692730f, -0.06115196f, -0.10020938f, -0.06441205f, -0.11531562f, -0.00780186f, -0.19323149f, 
    0.16809417f, 0.11134739f, -0.19015239f, -0.09419131f, 0.06744032f, -0.04105511f, -0.04147488f, -0.14379345f, 
    -0.12640120f, -0.13154832f, -0.01629192f, -0.10947759f, 0.07543513f, 0.08485072f, -0.08949312f, -0.01325849f, 
    0.00395078f, -0.03542918f, 0.02260871f, -0.06305894f, -0.12106473f, -0.03239841f, 0.15634903f, 0.05251415f, 
    0.13333908f, 0.17588469f, 0.11076403f, -0.32399094f, -0.16483885f, 0.07966553f, 0.02723083f, 0.03120136f, 
    -0.09905380f, 0.01199767f, 0.01102244f, -0.27564245f, 0.26582730f, 0.05381233f, -0.05239559f, -0.17783265f, 
    0.02152419f, 0.01634289f, 0.13052577f, -0.05341689f, -0.07183088f, -0.08999832f, -0.12889773f, -0.03755315f, 
    0.33289126f, 0.13858679f, -0.12454060f, -0.18212953f, 0.08888391f, 0.02037904f, 0.07391894f, 0.03223521f, 
    -0.01641468f, 0.01148926f, 0.04279928f, -0.01016325f, -0.11996354f, -0.23099189f, -0.38246909f, 0.07552609f, 
    -0.02514260f, -0.06073687f, -0.22511102f, -0.11997669f, -0.00735491f, -0.18528521f, -0.03268012f, 0.13360848f, 
    -0.40900728f, -0.29228696f, -0.15447445f, 0.01294556f, 0.01790850f, 0.01242398f, 0.08235975f, 0.00548168f, 
    0.01289209f, 0.02797576f, -0.02741264f, -0.05086232f, -0.09143709f, -0.08969268f, 0.01555658f, -0.01666304f, 
    -0.21585836f, 0.00538041f, -0.07633993f, -0.08171096f, -0.21775454f, -0.05537950f, -0.01919366f, -0.00911005f, 
    -0.11653896f, -0.22785112f, -0.20161906f, 0.06337238f, -0.02207515f, 0.02816573f, -0.00176250f, 0.03645499f, 
    0.04775890f, 0.02881884f, 0.04278702f, -0.01838924f, 0.23097107f, -0.03222367f, -0.08946220f, -0.00617007f, 
    -0.02624466f, 0.03008631f, -0.04590992f, 0.08483595f, -0.00449797f, -0.10783685f, -0.15266517f, 0.01304435f, 
    -0.52999097f, -0.11043717f, 0.23665264f, -0.40486082f, -0.02373268f, -0.00595319f, 0.03656495f, 0.07559837f, 
    -0.02004442f, 0.01814400f, 0.03175611f, 0.01123584f, 0.07053113f, 0.16048111f, -0.01143350f, -0.10277483f, 
    -0.16259937f, -0.11442183f, -0.11392425f, -0.03212701f, 0.00248489f, -0.00030202f, 0.00908713f, -0.02799970f, 
    -0.39926130f, 0.05551852f, 0.16115998f, -0.00877613f, 0.04441648f, -0.01896069f, 0.05732781f, 0.07617021f, 
    -0.20369941f, -0.18996963f, -0.02474738f, 0.09317704f, 0.20616706f, -0.08095267f, 0.02210514f, -0.07486992f, 
    -0.01358735f, -0.02932186f, -0.15612189f, -0.06824892f, -0.06870766f, 0.08963935f, -0.01393099f, 0.04920160f, 
    -0.16795075f, 0.01641661f, 0.12798998f, -0.00594672f, -0.07560102f, -0.01608730f, -0.01386472f, -0.00939896f, 
    -0.00845477f, -0.05924543f, -0.03436308f, -0.01846260f, 0.02139584f, -0.07696092f, -0.03518685f, -0.07161326f, 
    -0.14825174f, 0.03372663f, 0.00648504f, -0.02084551f, -0.07250486f, 0.03444526f, 0.01882386f, 0.03644532f, 
    0.22756884f, 0.16955790f, -0.03307929f, -0.26983362f, 0.06453671f, 0.01613791f, 0.01975111f, 0.07826733f, 
    -0.07971238f, -0.08708929f, -0.04601803f, -0.05312923f, -0.00156162f, -0.02233408f, 0.04752278f, 0.03502780f, 
    -0.11206907f, -0.02820292f, 0.08600328f, 0.05656224f, 0.03549311f, 0.00495151f, -0.12652650f, -0.12143780f, 
    -0.03336356f, -0.03884539f, -0.03606963f, 0.04086704f, 0.02288287f, 0.01984988f, 0.04104681f, 0.04781591f, 
    -0.05110146f, 0.06024339f, -0.00663269f, -0.09283654f, 0.34579268f, -0.02277211f, -0.10344642f, 0.00275792f, 
    0.05447811f, 0.10991806f, 0.12239378f, 0.05800883f, -0.03984950f, 0.05295908f, 0.03860945f, 0.14798076f, 
    0.13732998f, -0.10138824f, -0.20436281f, -0.02531402f, 0.03894107f, -0.08562326f, 0.05766787f, -0.01394749f, 
    -0.08644062f, -0.08018612f, 0.07902778f, 0.02179990f, -0.58138674f, -0.35400838f, -0.65079123f, -0.05539776f, 
    0.01418056f, 0.03671867f, 0.00689280f, 0.05584677f, -0.03304414f, 0.00226954f, -0.01904334f, -0.02740970f, 
    0.10323615f, 0.09830992f, -0.05366395f, 0.06443916f, 0.07377724f, 0.02698661f, 0.01550350f, -0.24906746f, 
    -0.14731470f, -0.16468351f, -0.07789597f, -0.03482302f, -0.14761102f, -0.15447937f, -0.12727976f, 0.06453560f, 
    -0.01232931f, 0.00653428f, 0.04154158f, 0.01317093f, 0.01820668f, 0.06130436f, 0.02789588f, 0.08916921f, 
    -0.23768383f, -0.02712039f, 0.13938874f, -0.01015160f, 0.01436074f, 0.04152017f, -0.00411510f, -0.01558409f, 
    0.08042274f, 0.07674868f, -0.09387882f, -0.04496010f, 0.25864726f, 0.14055534f, -0.34193987f, 0.06482453f, 
    0.13524149f, -0.08334096f, 0.03287526f, -0.13360998f, -0.00159566f, -0.02271550f, -0.05642992f, 0.00997020f, 
    0.04154191f, 0.12732884f, 0.07827472f, -0.08367322f, -0.11464287f, 0.00876108f, -0.00328974f, -0.37426195f, 
    -0.02445946f, -0.01943879f, -0.00703656f, 0.01418514f, 0.23310699f, 0.00490145f, -0.03363986f, 0.04157505f, 
    0.05869005f, 0.02946933f, -0.09265421f, -0.18485859f, 0.00968879f, -0.03294430f, -0.07767017f, -0.00092876f, 
    -0.02372317f, -0.09440513f, 0.05155558f, 0.00289935f, 0.01761073f, -0.14606042f, 0.03458618f, -0.03542714f, 
    0.05329614f, -0.04612716f, 0.11193080f, 0.04589220f, 0.21713206f, 0.29855311f, 0.16845118f, -0.10924006f, 
    -0.05588506f, 0.02952410f, 0.08841255f, -0.06503966f, 0.03873031f, 0.08607584f, 0.09056524f, 0.00431539f, 
    -0.11079048f, 0.20480168f, 0.31333286f, -0.45808664f, -0.09274880f, 0.01510012f, 0.09849139f, -0.05033473f, 
    -0.11437916f, -0.10096285f, -0.06312826f, -0.02264926f, -0.30895194f, -0.26664552f, -0.30210102f, -0.01731587f, 
    0.07135014f, 0.06899892f, 0.06622075f, 0.06074052f, -0.01368288f, 0.04436805f, 0.04130463f, -0.02771938f, 
    0.11777464f, 0.11786506f, 0.06637017f, -0.10068915f, 0.02923024f, -0.02286501f, -0.05306491f, 0.14662406f, 
    0.08592956f, -0.00845918f, -0.07041236f, -0.02958934f, -0.10959473f, -0.06781051f, 0.00652239f, 0.06246485f, 
    0.07480980f, 0.02032921f, 0.00569887f, 0.07573763f, -0.02167735f, -0.00148791f, 0.06686124f, 0.05687062f, 
    0.07365935f, 0.07911234f, 0.01242333f, -0.14079860f, 0.23314141f, -0.07622951f, -0.06192196f, 0.03206422f, 
    0.05554534f, -0.01863553f, 0.04803578f, 0.00380715f, 0.27912533f, 0.12615214f, -0.03644575f, -0.07357444f, 
    0.14413799f, 0.23007564f, 0.04728319f, 0.14696643f, -0.01709234f, -0.01111404f, 0.02974127f, 0.05184243f, 
    -0.17946586f, -0.01398266f, -0.05699531f, -0.07436179f, -0.00029218f, -0.01237064f, 0.01642815f, 0.03392511f, 
    -0.00370789f, -0.02878471f, -0.01567944f, 0.02183082f, 0.03827280f, 0.05574627f, -0.07256535f, -0.00684446f, 
    -0.00597038f, -0.01202583f, -0.09385289f, 0.00590002f, 0.06995013f, 0.07528582f, 0.07644292f, 0.04510901f, 
    -0.02113846f, -0.08255035f, 0.01852441f, 0.02828112f, 0.07737248f, 0.14558426f, 0.08887479f, 0.03831656f, 
    -0.03333634f, 0.08991861f, -0.01054072f, 0.02557988f, 0.37389198f, 0.18119793f, 0.00900358f, -0.12310072f, 
    0.03572832f, 0.12533370f, 0.00694942f, 0.00377718f, 0.00217421f, 0.02096737f, -0.09887425f, -0.10284840f, 
    -0.02511903f, 0.02780171f, -0.01678991f, 0.00821695f, -0.12115379f, -0.06810044f, -0.01574108f, -0.04277840f, 
    -0.08843538f, -0.06256776f, 0.07611816f, -0.09001499f, 0.18076588f, 0.23711544f, 0.12717450f, -0.29004502f, 
    -0.05497159f, -0.01235349f, 0.12177025f, -0.04061960f, 0.04709383f, -0.03606670f, -0.12444249f, -0.28058606f, 
    0.21278054f, -0.20928542f, -0.01105892f, -0.10895785f, -0.07074019f, -0.03937791f, 0.04473590f, 0.04631792f, 
    -0.08769067f, -0.18509912f, -0.13723513f, -0.09986550f, -0.68821406f, 0.04391509f, 0.24284360f, 0.10982404f, 
    0.04856287f, 0.06976349f, -0.01611535f, -0.00592684f, 0.03193678f, -0.02150910f, 0.02677861f, -0.06095814f, 
    0.13587013f, -0.24009816f, 0.35950005f, -0.05451917f, 0.05555927f, -0.15089121f, -0.11755373f, 0.04425495f, 
    -0.03691066f, -0.02063298f, -0.02628399f, 0.08941109f, -0.06564224f, 0.01428509f, -0.04759784f, 0.01978331f, 
    0.04302377f, -0.03457677f, 0.05194752f, -0.02625618f, -0.01585435f, -0.01951300f, 0.00262572f, 0.05568964f, 
    0.11879444f, 0.07113753f, -0.10394291f, 0.13688840f, -0.04967493f, -0.09559224f, -0.01335454f, -0.01091170f, 
    0.16105118f, -0.05578583f, -0.06933016f, 0.02477784f, 0.43620482f, 0.13542248f, -0.09990893f, -0.30873576f, 
    0.02911569f, 0.07087877f, 0.04941398f, -0.18805556f, 0.09488689f, 0.02939572f, -0.16602136f, -0.08104528f, 
    0.17457391f, -0.00331114f, -0.03789058f, 0.04077519f, -0.01912673f, -0.01244607f, 0.02059259f, 0.03985603f, 
    0.02334833f, 0.06302285f, 0.02467524f, -0.02805492f, 0.28023043f, 0.00865755f, -0.18759537f, -0.02722033f, 
    -0.11470377f, 0.07040816f, -0.03991455f, -0.02924179f, 0.11489279f, 0.05133285f, 0.02736646f, 0.06943256f, 
    0.19167967f, -0.31128463f, -0.04733301f, 0.04457680f, -0.06460928f, 0.02309069f, 0.02070692f, -0.03626469f, 
    0.01172104f, -0.36625358f, -0.35059968f, -0.21702613f, 0.16944158f, -0.04906649f, 0.07867492f, -0.02020094f, 
    0.06030019f, 0.00445235f, -0.23372303f, 0.06083339f, 0.04530841f, 0.02327736f, -0.05421203f, 0.02368413f, 
    0.11839836f, 0.23396045f, -0.12028679f, 0.04350057f, -0.03280164f, -0.04490483f, -0.01328259f, 0.13276692f, 
    0.04315327f, 0.06869378f, -0.09678844f, -0.14498946f, 0.66168851f, -0.26329499f, 0.33758342f, -0.02998896f, 
    0.08691607f, 0.00989110f, 0.01779803f, -0.16411355f, 0.24980859f, -0.02531695f, 0.10966912f, -0.13497160f, 
    0.04288704f, 0.00001018f, 0.07000239f, 0.05042183f, 0.00131630f, -0.03430811f, -0.06562878f, 0.07389165f, 
    -0.11628379f, 0.04945647f, -0.15551060f, 0.07520089f, 0.15565673f, 0.04726352f, -0.04260310f, 0.09679031f, 
    -0.00351595f, -0.00782595f, 0.06168582f, -0.08784532f, 0.07734063f, 0.11637547f, -0.14843918f, -0.00044200f, 
    -0.07382624f, -0.11981610f, -0.06248438f, -0.19816878f, -0.01062003f, -0.00559647f, -0.02787925f, 0.15964544f, 
    0.03009475f, -0.09034196f, -0.04834006f, 0.14754497f, -0.34261927f, -0.18569070f, 0.01881371f, -0.13116282f, 
    0.12853456f, 0.30101907f, -0.08617472f, -0.09294505f, 0.11628166f, 0.11116157f, -0.06406095f, -0.00489132f, 
    0.05447847f, -0.14576378f, 0.01234610f, -0.22307321f, -0.01296964f, 0.11563479f, -0.05185125f, 0.17044321f, 
    -0.02244133f, 0.11302856f, 0.11501289f, -0.04023281f, 0.32258722f, 0.05516376f, 0.02522970f, 0.02632549f, 
    0.10251680f, -0.13254254f, -0.21206476f, -0.17336939f, 0.08225187f, -0.00627897f, -0.07721598f, -0.02224603f, 
    -0.19895837f, -0.06058050f, -0.00268899f, -0.25545368f, -0.00876764f, 0.01194826f, -0.02579928f, 0.02554314f, 
    -0.30092397f, -0.03579181f, -0.02748431f, -0.09446394f, -0.08750430f, 0.01276026f, -0.18454155f, -0.07554339f, 
    -0.16174725f, 0.10186569f, 0.12209114f, 0.21252277f, -0.15534806f, 0.03271405f, 0.11064907f, 0.03446941f, 
    -0.10052997f, 0.04081135f, 0.04080641f, -0.01558539f, 0.03626048f, 0.08576255f, 0.00004945f, -0.07659631f, 
    0.14832407f, -0.14715979f, 0.01229774f, 0.04849014f, 0.18438300f, 0.06425234f, 0.11218863f, -0.37030151f, 
    -0.05513094f, -0.09722547f, 0.12292042f, -0.11352244f, 0.10259789f, -0.11556769f, 0.00497859f, 0.01957055f, 
    -0.27369523f, -0.42491624f, -0.21942593f, -0.03825536f, 0.03999488f, 0.16604982f, 0.21220030f, 0.05508821f, 
    0.20624898f, 0.18879424f, -0.02232311f, 0.06690090f, 0.03116662f, -0.06504297f, -0.03019981f, -0.05330587f, 
    0.02131528f, -0.04004590f, 0.01984350f, 0.03049770f, -0.14534950f, -0.33695269f, 0.18245080f, -0.13304010f, 
    -0.55215085f, -0.20512903f, 0.00050968f, -0.08640572f, 0.10126001f, -0.04181439f, 0.01266703f, 0.02980405f, 
    0.06178914f, 0.04910277f, 0.02711815f, -0.08538631f, -0.22594087f, -0.37808019f, 0.00034754f, -0.04407597f, 
    -0.14468946f, -0.03481316f, 0.17727794f, -0.08055371f, 0.12947945f, -0.06169952f, -0.00220155f, -0.04566185f, 
    0.00379366f, 0.03482855f, 0.21341850f, 0.12077051f, -0.19317429f, -0.08236862f, -0.01368285f, -0.08947024f, 
    -0.02677138f, -0.01243205f, 0.01232670f, -0.01864686f, 0.39133251f, -0.13045995f, 0.09777699f, -0.34358802f, 
    0.07750537f, -0.05222014f, -0.12425014f, 0.10051094f, 0.03049114f, 0.15335621f, 0.03671437f, -0.04355065f, 
    0.22329432f, 0.11750412f, 0.22959705f, 0.16968758f, -0.04529060f, -0.02449036f, -0.02438857f, -0.00413200f, 
    -0.03556962f, 0.06644609f, 0.04786217f, 0.05837794f, 0.15517029f, -0.03598352f, -0.01748830f, 0.02354176f, 
    -0.01353475f, 0.01338162f, 0.05858990f, -0.04708774f, 0.00941190f, 0.12330001f, -0.05825764f, -0.04758880f, 
    0.35457766f, 0.13554102f, 0.07632095f, 0.14896427f, -0.08141818f, 0.00562304f, 0.09549481f, -0.05704695f, 
    0.02774493f, 0.03887634f, -0.08801131f, -0.05804539f, 0.24663724f, -0.01286815f, 0.21839170f, -0.22278056f, 
    -0.02836155f, -0.11366760f, 0.16004133f, 0.06855863f, -0.03695459f, 0.00263906f, -0.07469825f, 0.01051295f, 
    0.12527302f, 0.09358633f, -0.04186284f, 0.07281451f, -0.04259213f, -0.09760103f, 0.03814045f, -0.12904854f, 
    0.00595841f, -0.01630328f, 0.02523203f, 0.00383620f, -0.06407066f, 0.05818975f, -0.13573222f, 0.05851959f, 
    -0.05466109f, -0.07195349f, 0.12762398f, -0.06235275f, -0.10009544f, -0.02336468f, -0.01291576f, 0.07231759f, 
    -0.28822115f, 0.04670022f, 0.03785588f, -0.01635406f, 0.09313821f, -0.00293509f, 0.00953678f, -0.02540430f, 
    -0.05304445f, -0.12380477f, -0.19473854f, -0.03539321f, -0.04894527f, -0.01716644f, -0.03759409f, 0.03216384f, 
    0.02809146f, 0.04997296f, -0.18447745f, -0.08385392f, -0.00161634f, 0.02704024f, 0.06363139f, -0.05539571f, 
    -0.03932220f, 0.01793976f, 0.03882383f, 0.06454828f, 0.02473462f, -0.01583085f, 0.04637785f, 0.01275550f, 
    -0.01650341f, -0.03156399f, -0.02232557f, -0.02422508f, 0.06004504f, -0.00842246f, -0.08054748f, 0.00248572f, 
    0.12874664f, -0.05193073f, -0.09319650f, 0.02135892f, -0.09067595f, 0.11475942f, -0.07562852f, 0.07481444f, 
    -0.12767175f, -0.05309251f, -0.20328926f, -0.14367037f, 0.00536152f, 0.24210027f, -0.16541652f, 0.10000120f, 
    -0.00712962f, -0.03223621f, -0.06989472f, 0.06567647f, 0.00126361f, 0.05527549f, 0.02130664f, -0.04969910f, 
    -0.11169949f, 0.09482756f, -0.00451082f, -0.01708905f, -0.16684295f, 0.02791789f, -0.01249032f, -0.02041268f, 
    0.00975808f, 0.06693946f, 0.00049597f, 0.07340848f, 0.03080671f, -0.03554292f, -0.02912717f, -0.05203070f, 
    -0.03727842f, 0.03746035f, -0.06674957f, 0.01664784f, -0.12551942f, 0.10372043f, -0.12504449f, 0.07880217f, 
    -0.08113839f, 0.02720434f, -0.02054554f, -0.19544905f, -0.01226591f, 0.04634142f, -0.05743900f, -0.04424604f, 
    0.15269774f, -0.07682645f, -0.14827153f, 0.14568441f, -0.00381206f, -0.03514139f, 0.04246326f, 0.03763201f, 
    -0.11066163f, 0.19102292f, 0.03896075f, 0.00370171f, 0.54589593f, 0.02937222f, 0.23054694f, 0.09829793f, 
    -0.10098312f, -0.00275665f, -0.00618005f, -0.04679820f, -0.04988702f, 0.06215481f, 0.02251683f, 0.12407927f, 
    0.08773410f, -0.05515651f, 0.06189137f, -0.06751587f, -0.13001755f, 0.02202519f, 0.03287091f, -0.04191655f, 
    -0.19264403f, -0.16840623f, 0.06210177f, -0.01797160f, 0.06015297f, -0.04554443f, -0.04589579f, -0.01734963f, 
    -0.04426330f, 0.01923928f, -0.01305023f, -0.02505500f, -0.22580580f, -0.19358586f, -0.20096231f, -0.39018381f, 
    -0.21829461f, -0.01693432f, 0.10613973f, 0.15487511f, -0.03781819f, -0.03784766f, 0.01812958f, 0.02170674f, 
    0.09210211f, -0.12606055f, 0.13995460f, 0.00604504f, 0.18555762f, -0.08853851f, 0.23844218f, -0.02136303f, 
    -0.22378540f, 0.09265268f, -0.14369512f, 0.15382309f, 0.00112182f, -0.00748295f, 0.00620503f, 0.07184953f, 
    -0.19025871f, -0.07333563f, 0.01078971f, 0.05193188f, 0.05912899f, 0.14269879f, -0.07266458f, 0.07707465f, 
    -0.08473521f, 0.05919308f, 0.02586804f, 0.02626616f, 0.20953780f, -0.02733532f, 0.22800916f, 0.02861076f, 
    0.08079211f, -0.14065598f, 0.11405923f, 0.18286468f, -0.06817365f, -0.02188236f, 0.02721008f, -0.01661484f, 
    0.04691167f, -0.11396788f, 0.00944412f, -0.20603427f, 0.00569337f, 0.09950635f, -0.20285952f, 0.07277686f, 
    -0.22571371f, -0.13007526f, -0.00179421f, -0.12723966f, -0.33136442f, 0.11580554f, -0.08726160f, -0.02634115f, 
    0.03510533f, 0.01895002f, -0.07579891f, 0.09611680f, -0.04834076f, -0.15596355f, -0.16907783f, 0.15857923f, 
    -0.57276988f, 0.32950225f, -0.21857812f, -0.12048478f, -0.02498238f, 0.06279018f, -0.07556465f, -0.06883758f, 
    -0.02210578f, -0.05823642f, 0.01021271f, -0.16278203f, 0.24224576f, 0.17501746f, 0.20673960f, 0.23168777f, 
    -0.00506582f, -0.00224343f, 0.00234632f, -0.03563244f, -0.01728746f, 0.04599399f, -0.04106882f, 0.05411415f, 
    -0.22640806f, -0.02491612f, -0.04564992f, -0.08188590f, -0.05566009f, -0.24786912f, 0.21051896f, 0.20086581f, 
    -0.01978866f, -0.03729837f, 0.07607979f, 0.03474822f, 0.13169967f, 0.01078099f, 0.06130293f, 0.09036221f, 
    -0.01073204f, -0.05687683f, -0.06056886f, -0.00093305f, -0.06162254f, -0.02605333f, -0.01710843f, 0.00776108f, 
    -0.12146295f, 0.06658964f, -0.29208866f, -0.23829426f, -0.04046671f, -0.08792519f, -0.01830209f, -0.08311730f, 
    0.00688804f, 0.10940420f, -0.03027192f, 0.07180855f, 0.26651657f, 0.29799983f, 0.20955417f, 0.08431990f, 
    0.03898279f, 0.03819605f, -0.01375488f, -0.08587497f, -0.03632858f, 0.00611148f, 0.00609136f, -0.07776161f, 
    0.17448361f, 0.20493522f, 0.04678945f, 0.00330463f, 0.01009467f, -0.01637627f, -0.01521713f, 0.01679702f, 
    0.09316514f, 0.07273442f, -0.00437283f, 0.07070180f, 0.40050241f, 0.27522463f, 0.22311355f, -0.16071039f, 
    0.06802068f, 0.06682251f, 0.08145330f, -0.21433745f, -0.01445544f, -0.04036274f, -0.13781624f, -0.04575447f, 
    0.26960170f, -0.13999632f, -0.28830609f, -0.15192668f, -0.00583587f, 0.02632321f, 0.00688839f, -0.05413148f, 
    -0.09230202f, 0.03602053f, -0.03484176f, -0.02732033f, -0.26741460f, -0.04082671f, -0.31241956f, -0.08657755f, 
    0.05811967f, -0.11455098f, 0.27703500f, 0.09824138f, -0.07108898f, 0.08662903f, -0.06732213f, 0.06403214f, 
    0.06958761f, 0.03048109f, 0.06201699f, 0.04075382f, -0.09007338f, -0.00867735f, -0.00669066f, 0.00458345f, 
    0.15041488f, 0.02403590f, -0.08489208f, 0.02855523f, -0.01729590f, 0.26026493f, -0.09602502f, 0.08486004f, 
    -0.01642327f, 0.03375078f, 0.00141510f, -0.01953018f, 0.04667547f, 0.10211168f, 0.09082409f, -0.00253172f, 
    0.12220442f, -0.09455659f, 0.07565318f, 0.03491225f, -0.00060328f, 0.00417575f, 0.08081900f, -0.06950615f, 
    0.04221527f, 0.08579267f, 0.16066642f, -0.01782893f, -0.00772262f, -0.01811775f, 0.01197557f, 0.07260830f, 
    0.02616845f, 0.01130915f, -0.10411243f, 0.09255182f, -0.01618027f, 0.21234101f, 0.04288484f, -0.13492014f, 
    0.28621048f, -0.24456334f, 0.28610039f, -0.35180762f, -0.07751866f, 0.04212855f, -0.14058955f, 0.22972240f, 
    -0.00552473f, -0.06329516f, -0.09357239f, 0.04925139f, -0.12721519f, 0.05733876f, -0.03359993f, -0.02210430f, 
    -0.03046494f, -0.10612840f, 0.00034164f, 0.04340287f, 0.01665751f, 0.03121363f, -0.01112659f, -0.00904576f, 
    -0.32527119f, -0.22201477f, -0.09823893f, -0.12567686f, 0.07358038f, 0.09079812f, 0.08389848f, -0.18388680f, 
    -0.03432996f, 0.00239892f, 0.11085737f, -0.00019222f, -0.13442315f, 0.31840768f, 0.12291023f, -0.12065260f, 
    -0.10805097f, 0.04354034f, -0.04685431f, -0.00727470f, -0.06701998f, -0.01201836f, -0.13889116f, 0.12176281f, 
    -0.22237991f, -0.28146169f, 0.18877864f, -0.08915247f, -0.01252748f, -0.03783439f, 0.01344157f, 0.00478493f, 
    0.00122565f, -0.10011110f, -0.15896864f, -0.01394903f, -0.13676403f, -0.06688778f, -0.12510318f, -0.24877505f, 
    -0.07542455f, -0.11064211f, 0.04853912f, -0.19928013f, 0.01075036f, -0.04455352f, -0.00075675f, 0.01905189f, 
    0.02288891f, -0.09742778f, 0.02937916f, 0.04457610f, 0.01636918f, -0.01861014f, 0.06497441f, -0.03253308f, 
    0.02045025f, -0.01579573f, 0.05675828f, 0.08049050f, -0.30625024f, -0.37351489f, -0.01195101f, -0.19991243f, 
    -0.02144996f, -0.03269571f, -0.22873221f, -0.04207993f, -0.02752537f, -0.05039939f, -0.04814719f, 0.00589079f, 
    -0.16580330f, 0.26745299f, 0.37210995f, 0.36457610f, -0.04902687f, 0.00234169f, -0.03168587f, 0.05492274f, 
    -0.00950694f, -0.04507068f, -0.02719247f, -0.02080750f, -0.08501026f, 0.14149912f, 0.64360541f, -0.10089985f, 
    -0.12718964f, -0.00478314f, 0.05791858f, -0.18592004f, 0.00646732f, 0.06952580f, -0.07716171f, 0.03713597f, 
    0.05461117f, -0.08087429f, 0.04182116f, -0.03777195f, 0.06989571f, -0.05067424f, 0.00292060f, 0.09161947f, 
    0.06491119f, -0.08142842f, -0.06989603f, 0.13361306f, 0.04709739f, 0.05715647f, -0.30863923f, 0.14662457f, 
    -0.00654591f, 0.06413464f, -0.01740878f, -0.08855893f, 0.05664642f, 0.07291134f, -0.07274146f, -0.01728475f, 
    -0.12559909f, -0.01453002f, 0.00777171f, -0.12215199f, -0.03206990f, -0.10170053f, -0.03103507f, -0.18020174f, 
    0.16816914f, -0.02844258f, -0.12770437f, 0.07171395f, 0.01624966f, 0.22011381f, 0.02179154f, 0.07673228f, 
    0.01121984f, 0.20316507f, -0.02527006f, -0.06198858f, -0.04275387f, 0.07522800f, -0.00352833f, 0.11995946f, 
    0.06373532f, -0.08800277f, 0.05678087f, 0.11148078f, 0.13396268f, -0.03736942f, -0.28556487f, 0.02923989f, 
    0.05158363f, -0.04350646f, -0.04896623f, 0.13685057f, 0.02707375f, -0.09583911f, 0.34178516f, 0.15174533f, 
    0.00120739f, -0.02346722f, -0.04964465f, 0.10104600f, 0.03982284f, 0.03000254f, -0.02257803f, 0.05555309f, 
    0.30007115f, 0.28825811f, 0.31088001f, 0.32961300f, 0.03461630f, 0.01374211f, 0.07797371f, -0.03531741f, 
    -0.01708724f, -0.02539652f, 0.18786734f, -0.06081070f, 0.02512631f, 0.21485054f, -0.19253400f, -0.06142909f, 
    0.04919735f, -0.17592518f, 0.02577281f, -0.03607596f, -0.00177096f, -0.00335427f, 0.04269901f, -0.05158427f, 
    0.06768829f, 0.01536092f, -0.17186785f, 0.04133023f, -0.14725268f, 0.03246655f, -0.03619735f, 0.19630615f, 
    -0.03168736f, 0.03591590f, -0.24942075f, -0.00453908f, 0.08556598f, -0.02104190f, 0.19716738f, -0.13628578f, 
    0.04621525f, -0.18245809f, 0.01279957f, -0.04256937f, 0.05947515f, 0.09280494f, -0.17703371f, 0.08364261f, 
    0.12872875f, 0.08153918f, 0.03039791f, -0.15174897f, -0.04361239f, -0.01967909f, -0.04889939f, 0.00695005f, 
    -0.09984452f, -0.01838664f, -0.03874062f, -0.04713823f, 0.07391509f, 0.00025590f, 0.00932099f, -0.19965325f, 
    0.03940821f, -0.07870739f, -0.03582041f, 0.04301536f, -0.00315056f, 0.11005966f, 0.14271337f, -0.13495407f, 
    0.39455721f, -0.05407266f, -0.26308900f, 0.28896981f, 0.01954906f, -0.24143775f, 0.03383680f, -0.08028039f, 
    0.00686823f, 0.03481203f, -0.02947212f, -0.10322360f, -0.05514759f, -0.11496625f, 0.06955453f, 0.05755701f, 
    -0.13678321f, 0.11981268f, 0.00526812f, 0.20010586f, 0.12258288f, -0.05288962f, -0.05753281f, -0.06428244f, 
    -0.87596136f, -0.59793311f, -0.19334415f, -0.33790183f, 0.00923388f, 0.00268062f, 0.03342481f, -0.05846013f, 
    0.00295076f, -0.01005929f, 0.02359976f, -0.03762104f, -0.47650379f, 0.45388281f, -0.02127504f, 0.02278260f, 
    0.01885123f, 0.12404080f, -0.11858874f, 0.02925264f, 0.07753369f, -0.07611240f, -0.00938470f, 0.06366401f, 
    -0.26553956f, -0.43175846f, -0.30578789f, 0.04153067f, -0.04001656f, 0.02286293f, 0.05655893f, 0.03078586f, 
    -0.05142985f, -0.13512272f, 0.05912004f, 0.16237733f, -0.03939788f, 0.04407515f, 0.06516123f, 0.00536217f, 
    0.05152762f, 0.01334217f, 0.02943946f, -0.02703943f, 0.03868690f, 0.05073979f, 0.03598400f, -0.03773000f, 
    -0.10114796f, -0.00576891f, -0.13060687f, 0.06650723f, -0.06996311f, 0.01150069f, 0.05170113f, 0.05850327f, 
    -0.03821644f, 0.04782474f, -0.06542894f, 0.01595504f, -0.32496136f, -0.08335590f, 0.11485993f, -0.15449111f, 
    0.01679863f, 0.04035043f, 0.01721327f, -0.18605801f, -0.02467053f, 0.00976778f, -0.05927184f, -0.11561733f, 
    -0.39420357f, 0.00772992f, 0.01641054f, 0.18120642f, 0.00388028f, 0.03634955f, 0.02957835f, -0.08168004f, 
    0.03981539f, 0.04068282f, -0.04495539f, 0.09355222f, -0.02906675f, 0.01655389f, -0.02842090f, 0.05319660f, 
    -0.13003598f, 0.04317907f, -0.00423648f, 0.09949160f, -0.02721965f, 0.00406843f, -0.04414904f, 0.03224234f, 
    0.10014381f, 0.10041777f, -0.14078669f, 0.10928725f, -0.00536444f, 0.03369367f, -0.04528893f, -0.01586921f, 
    0.08972780f, 0.08051152f, 0.05007271f, 0.14997080f, 0.02668051f, 0.09835489f, -0.09290717f, 0.19863629f, 
    -0.03438185f, 0.01015350f, 0.15624453f, -0.04410192f, 0.09409828f, -0.04258922f, 0.06349900f, 0.06158455f, 
    0.07057827f, -0.02522799f, -0.02493383f, 0.03175945f, -0.03462147f, 0.08001021f, 0.08213353f, 0.02923017f, 
    -0.04787245f, 0.01219118f, -0.01347850f, -0.03609044f, -0.12454480f, -0.09272492f, 0.10611507f, -0.00618144f, 
    -0.02166894f, -0.08737601f, -0.19925824f, -0.02918768f, 0.02068413f, -0.09702135f, -0.04632217f, 0.04306613f, 
    -0.00177204f, -0.11316945f, -0.07376859f, -0.29092851f, 0.21542935f, 0.07948855f, -0.06575260f, -0.06770440f, 
    0.03283845f, -0.03364904f, -0.03594739f, 0.05284541f, 0.00169348f, -0.00634608f, 0.00924786f, -0.01472551f, 
    0.01222453f, 0.02245994f, -0.06360522f, 0.09908000f, 0.04228418f, 0.13176946f, 0.03719413f, -0.09163305f, 
    -0.12376166f, -0.08073589f, 0.10857359f, -0.05488892f, -0.06908172f, -0.05161568f, 0.01502526f, -0.01351816f, 
    0.02370866f, -0.01881028f, -0.04336684f, 0.01248306f, -0.23985882f, 0.15151872f, 0.08224578f, 0.21235287f, 
    -0.05140320f, -0.02194877f, 0.15819059f, 0.04921947f, 0.05928691f, 0.16953847f, -0.08459690f, 0.02761631f, 
    0.09441837f, 0.01115752f, -0.08135184f, -0.05520033f, -0.00937899f, -0.07236506f, 0.05184331f, 0.10149737f, 
    -0.00287360f, 0.09106965f, 0.07909433f, -0.06504468f, -0.20079745f, -0.03811362f, 0.29429707f, -0.04571959f, 
    0.00890378f, -0.00132532f, -0.01329893f, 0.00202839f, 0.01457738f, -0.06711154f, 0.02350945f, 0.03719524f, 
    -0.12940438f, 0.06311802f, 0.02787678f, -0.00610811f, -0.10242392f, -0.04765661f, 0.05825080f, -0.26002294f, 
    0.06479105f, -0.17818311f, -0.04337506f, 0.00483191f, 0.08645649f, 0.00191092f, 0.08940613f, 0.03684782f, 
    0.00505957f, -0.01730120f, 0.04772352f, -0.03811673f, 0.12240053f, 0.15151319f, 0.20969687f, 0.03227765f, 
    -0.13313220f, -0.28513253f, -0.11128347f, 0.21334738f, -0.01083123f, -0.03632886f, 0.06197802f, 0.00166912f, 
    0.06204030f, -0.19971873f, 0.15293285f, 0.04822010f, -0.57658410f, -0.39559361f, 0.12336661f, -0.40323973f, 
    0.07492584f, 0.00064031f, -0.06889110f, -0.06549824f, -0.02190847f, -0.03087683f, 0.02053882f, -0.04160274f, 
    0.06903404f, -0.10376680f, -0.04534379f, 0.11028101f, 0.01493828f, 0.04905802f, -0.11792190f, -0.02798690f, 
    0.00152881f, -0.12679477f, 0.00545130f, 0.04173717f, -0.15559366f, -0.25463226f, 0.00826840f, -0.18443213f, 
    -0.07135269f, 0.07483427f, -0.05733920f, -0.07116407f, -0.04348202f, -0.07917532f, -0.00986976f, -0.01893866f, 
    -0.04113922f, 0.04868384f, -0.00233716f, -0.06367210f, 0.01026955f, -0.05006658f, -0.14986254f, -0.18214312f, 
    0.19230166f, 0.25980034f, -0.08874335f, 0.12524082f, -0.01182953f, 0.01131940f, -0.07311518f, 0.14201061f, 
    0.12001410f, 0.05101322f, 0.01773544f, 0.01608716f, 0.02541900f, 0.04529793f, -0.14581072f, 0.17515060f, 
    -0.24222906f, 0.01486505f, -0.24000652f, 0.12033571f, -0.04608943f, 0.07242213f, -0.20999783f, -0.01889955f, 
    -0.02795243f, -0.05489762f, -0.15102635f, 0.10736898f, -0.46380475f, -0.39234534f, -0.40613854f, -0.17846663f, 
    -0.03634529f, -0.05842196f, -0.00801418f, 0.01145080f, -0.02111817f, -0.02914681f, -0.02501408f, 0.03184206f, 
    -0.00876588f, -0.03453805f, -0.04994983f, 0.03023131f, 0.11096738f, -0.01724761f, -0.16017337f, 0.11416668f, 
    0.01714991f, 0.10764665f, 0.01510922f, 0.10774447f, -0.09423253f, 0.06085445f, -0.05446886f, -0.02017209f, 
    -0.03154159f, -0.10585827f, 0.05171198f, 0.06024867f, 0.03898062f, 0.04437057f, -0.10734048f, 0.11008748f, 
    -0.24732055f, 0.05668705f, -0.08096430f, -0.05272088f, -0.15505065f, -0.20412551f, -0.13448340f, -0.05975562f, 
    -0.03958623f, 0.03962024f, -0.00889295f, 0.03930472f, -0.35701713f, 0.39410228f, 0.38506463f, 0.34471145f, 
    -0.05005535f, 0.01780233f, 0.06302562f, 0.08491988f, 0.00599346f, -0.00997293f, 0.01281806f, -0.02838195f, 
    -0.08486811f, 0.10867964f, -0.06420400f, -0.08318309f, 0.06583344f, -0.01569917f, 0.03850384f, 0.01650928f, 
    -0.03025391f, -0.00705731f, 0.01539419f, 0.01916545f, -0.21470605f, 0.36269978f, 0.27350029f, 0.01716669f, 
    -0.11084192f, 0.04922114f, -0.12327818f, -0.06769454f, 0.01040801f, 0.04485968f, 0.04317850f, -0.05740878f, 
    0.06120077f, 0.31477922f, 0.31722313f, 0.24069835f, -0.04902954f, 0.05336796f, 0.03959761f, -0.06593546f, 
    0.02899886f, -0.22035864f, 0.08684416f, 0.07472653f, -0.45210618f, -0.04120196f, -0.37004492f, -0.04946874f, 
    0.04642531f, 0.00231052f, -0.05207788f, -0.01004259f, -0.00843050f, -0.00451997f, -0.02650698f, 0.04581982f, 
    0.00932083f, 0.03875456f, -0.13386707f, -0.04704143f, -0.00206039f, 0.04444694f, -0.05416954f, 0.21621948f, 
    0.15136139f, -0.07597732f, 0.00023540f, -0.08593415f, -0.02418032f, 0.19758238f, -0.27026933f, 0.25595942f, 
    0.02219445f, 0.02757633f, 0.01913462f, 0.10580433f, 0.06460712f, -0.02937578f, 0.15230359f, -0.12102616f, 
    0.13580190f, -0.01331836f, 0.07471118f, 0.03515734f, 0.02276425f, -0.01710766f, 0.01977910f, 0.06844085f, 
    -0.11375979f, 0.06453591f, -0.01055653f, -0.04903409f, 0.12218255f, -0.10556448f, -0.19685362f, 0.01487455f, 
    0.00022423f, 0.01535066f, -0.05673686f, -0.02685313f, -0.18426099f, 0.01774554f, -0.23676817f, 0.10336410f, 
    0.42597491f, 0.24623534f, 0.44081032f, -0.56196696f, -0.21650097f, -0.09473675f, -0.08790132f, 0.01006867f, 
    0.01006069f, -0.02714147f, 0.10432120f, 0.11010318f, 0.05772718f, -0.05673186f, 0.10566319f, -0.06521174f, 
    0.10512231f, -0.13518846f, -0.01395751f, 0.08479555f, -0.17726526f, 0.01648092f, -0.20694484f, 0.02643137f, 
    -0.21455437f, -0.11576582f, -0.08012574f, 0.12438301f, -0.00136340f, 0.06879116f, 0.27854267f, -0.02486838f, 
    0.02114206f, 0.08171546f, 0.03197295f, 0.06630841f, -0.19278775f, -0.07172598f, 0.01867630f, 0.00193510f, 
    0.00223066f, 0.05763631f, 0.01176879f, -0.03366353f, -0.11848827f, 0.05661936f, 0.13751113f, 0.08490832f, 
    0.03659487f, -0.08637758f, -0.04069638f, 0.03223431f, 0.22766091f, 0.07176691f, -0.02447813f, -0.16879901f, 
    0.06641885f, 0.16452795f, 0.08011617f, -0.01892631f, -0.10378199f, 0.38131669f, -0.20474647f, 0.48768419f, 
    0.06742257f, -0.11097970f, 0.13590753f, -0.13766530f, 0.10748326f, -0.05230385f, 0.05255680f, -0.00146405f, 
    -0.20041405f, 0.51666743f, -0.15170975f, -0.23860753f, 0.04588728f, 0.22834554f, 0.03186926f, -0.04191044f, 
    -0.20378739f, -0.03006690f, -0.02129902f, -0.05937003f, -0.06435603f, -0.12743068f, -0.05929429f, 0.12267647f, 
    0.12606764f, 0.07895403f, -0.01812912f, -0.02603737f, -0.18946086f, 0.02774366f, -0.13068005f, 0.10388502f, 
    0.05615053f, -0.18424970f, -0.08474740f, 0.10780884f, 0.06477023f, -0.07175978f, 0.00878477f, -0.04608106f, 
    0.02076337f, 0.13807496f, 0.11057006f, 0.06549670f, -0.40659094f, 0.15232961f, -0.01089627f, 0.23811458f, 
    0.08029843f, 0.08047139f, 0.01936159f, -0.08507404f, -0.05904057f, 0.08067802f, 0.01309222f, 0.01047226f, 
    -0.11140694f, 0.02188955f, -0.23349668f, -0.18182682f, -0.23858339f, 0.02933753f, -0.13524447f, 0.09751704f, 
    0.05803531f, -0.11003119f, -0.10318113f, -0.11704774f, 0.22799721f, 0.03039794f, 0.06142567f, -0.03957295f, 
    -0.06426699f, -0.05339620f, -0.09798674f, 0.06761032f, 0.11003365f, 0.02695719f, -0.04881237f, 0.00322782f, 
    -0.01878489f, 0.00697080f, 0.06995659f, 0.11732344f, 0.05257046f, 0.05727261f, 0.09648333f, 0.11265358f, 
    0.05891405f, 0.00624882f, 0.05949847f, 0.07839007f, 0.05341213f, -0.12415517f, -0.04955180f, 0.25363803f, 
    0.03149231f, -0.04364957f, -0.09916598f, 0.01119986f, -0.06525000f, -0.00323509f, -0.03506165f, 0.06006571f, 
    -0.00548529f, -0.04009100f, 0.09181444f, -0.00077230f, -0.02194178f, -0.05385742f, -0.10264329f, -0.05412943f, 
    -0.03113394f, -0.03393024f, -0.16507441f, 0.00472271f, -0.02189717f, -0.13969612f, -0.02537960f, 0.17782776f, 
    0.07698725f, -0.03962378f, -0.02456249f, -0.09037475f, 0.01869347f, 0.04601819f, -0.03896389f, 0.14616688f, 
    0.77046543f, 0.02939354f, 0.19914486f, 0.15600540f, 0.07815439f, 0.15228586f, -0.05324427f, 0.06932458f, 
    -0.12545511f, -0.04582247f, 0.01435402f, -0.01061719f, 0.05582907f, 0.07748559f, -0.04192330f, 0.20342356f, 
    0.13889679f, 0.02046131f, -0.05539141f, -0.00544361f, 0.07796417f, -0.20685193f, 0.13749976f, 0.09105774f, 
    -0.04474488f, -0.17959851f, 0.06393195f, -0.47930771f, 0.03734267f, -0.11468473f, 0.06312595f, 0.02825944f, 
    -0.12629682f, 0.05962166f, -0.12866148f, -0.06577148f, -0.50608581f, 0.35003814f, -0.06245898f, 0.00800231f, 
    -0.00984004f, -0.11545377f, -0.02765195f, -0.09266699f, -0.30176923f, 0.03185001f, -0.07989404f, 0.10017004f, 
    -0.10069446f, -0.01138872f, -0.11331312f, 0.19287571f, 0.06554251f, -0.01196614f, 0.04060575f, -0.02918445f, 
    0.00490934f, 0.00184400f, -0.05032333f, -0.03184872f, -0.25938514f, 0.23589480f, -0.08738458f, 0.39503804f, 
    0.06307933f, 0.03155081f, 0.04559951f, -0.04143736f, 0.02038897f, -0.02613528f, -0.06072220f, 0.10126450f, 
    0.74285561f, 0.44648322f, 0.04805164f, -0.30747792f, -0.08643497f, 0.21569499f, -0.12196013f, -0.07889388f, 
    -0.33535683f, -0.04139381f, -0.07730801f, 0.02312435f, -0.11589123f, 0.23413557f, -0.36903834f, -0.35696408f, 
    0.08226472f, -0.00105961f, -0.01547426f, -0.07993704f, -0.24805301f, -0.00743606f, -0.07988116f, -0.00922959f, 
    -0.07283026f, -0.19842887f, -0.04743288f, 0.17713374f, 0.06529631f, 0.15308081f, 0.02762667f, 0.04196618f, 
    0.08056553f, -0.02953665f, 0.02459668f, -0.11920218f, -0.43484288f, 0.08101313f, -0.02996004f, 0.27601331f, 
    -0.08295902f, -0.05872692f, 0.07088973f, -0.18023704f, -0.13825116f, 0.18165968f, -0.06203796f, 0.02121486f, 
    -0.19299392f, -0.45752066f, -0.19156936f, -0.06819691f, 0.20964129f, 0.25714931f, -0.09608071f, 0.20361798f, 
    -0.12128428f, -0.03969668f, 0.11149789f, 0.02983707f, -0.10293999f, -0.16177760f, -0.01202074f, -0.09512246f, 
    -0.11255362f, -0.21338578f, -0.03656567f, -0.02426093f, -0.10220777f, -0.13988273f, -0.00982345f, -0.08236262f, 
    0.19462231f, -0.37530354f, 0.23562589f, -0.05067989f, 0.12429905f, -0.12161958f, 0.01520989f, 0.07647899f, 
    -0.06877489f, 0.16450526f, 0.15346622f, -0.18805338f, 0.01390703f, -0.01186523f, -0.02612556f, 0.15522459f, 
    0.01563428f, -0.04654543f, 0.02535199f, 0.05041857f, -0.00089587f, -0.06847364f, -0.02335643f, -0.01358437f, 
    -0.48726121f, -0.41486642f, 0.04900515f, 0.17474948f, -0.12955099f, 0.06898489f, -0.09814715f, -0.05869226f, 
    0.14846857f, 0.04631198f, -0.09346116f, 0.04573840f, -0.03618714f, -0.07411015f, -0.05665980f, 0.18053705f, 
    0.14023034f, -0.03488413f, 0.02632963f, -0.15008450f, -0.02448036f, -0.03495871f, -0.07473012f, -0.20834157f, 
    0.18421471f, 0.00632045f, 0.03988562f, -0.38961568f, -0.17394701f, -0.12274884f, -0.03856002f, -0.04807260f, 
    0.08232198f, 0.08207111f, -0.09240510f, -0.10041645f, -0.14770459f, -0.10503466f, -0.01105466f, 0.08395202f, 
    -0.15477581f, -0.16674046f, -0.04076469f, 0.05596520f, -0.01927089f, -0.08932754f, -0.16511899f, 0.10568239f, 
    0.46476507f, 0.06327785f, -0.15979272f, 0.08946708f, 0.03636005f, 0.01711541f, -0.04581000f, -0.05289543f, 
    0.01449101f, -0.01063293f, 0.19481035f, -0.11648589f, -0.30560604f, -0.22521544f, 0.28515053f, 0.29863116f, 
    -0.10942353f, 0.00743595f, -0.05647997f, -0.00147636f, -0.00807119f, 0.12317914f, -0.05614161f, 0.06674384f, 
    0.10418621f, 0.02490968f, -0.01775380f, 0.13369346f, 0.04654736f, 0.06335909f, -0.01468859f, -0.03311590f, 
    -0.04299100f, 0.10261441f, -0.14223875f, 0.02167372f, 0.27386400f, -0.01883565f, -0.23379423f, -0.18732134f, 
    -0.02534221f, 0.11980002f, 0.06257917f, -0.01289159f, 0.09516282f, -0.19294205f, 0.03849379f, -0.25443044f, 
    -0.27597785f, -0.30473867f, -0.22520252f, -0.09725647f, -0.04448396f, -0.02055196f, -0.18399054f, -0.11046147f, 
    -0.04625363f, -0.04045045f, 0.00816293f, 0.01501115f, -0.14649974f, -0.04586918f, -0.00825082f, 0.10810909f, 
    0.13282810f, 0.03370526f, 0.00200497f, -0.05626436f, 0.00605294f, 0.03120502f, 0.01174976f, 0.05466804f, 
    -0.28357419f, 0.35941228f, -0.31014323f, -0.30667719f, -0.07425243f, 0.07930161f, -0.11267292f, 0.01454685f, 
    -0.05100067f, -0.05860647f, 0.00636022f, -0.06402799f, -0.25114039f, 0.01231367f, 0.25586021f, 0.22551316f, 
    -0.09131382f, 0.02539567f, -0.07348144f, -0.13228579f, -0.02501206f, 0.00890240f, -0.07739505f, 0.03544643f, 
    -0.11854311f, 0.03899701f, 0.10900040f, 0.36054507f, 0.01748156f, -0.02899429f, 0.00950598f, 0.04444239f, 
    0.14857717f, 0.19705904f, 0.06664077f, -0.12168159f, -0.16882889f, 0.06997237f, 0.05706877f, 0.12246340f, 
    0.01917006f, 0.03662670f, -0.02712326f, -0.05885013f, 0.01773164f, -0.00350163f, 0.03107527f, -0.05078703f, 
    0.66350532f, -0.35479608f, -0.18730526f, -0.41345155f, -0.09203342f, -0.05983396f, -0.07074772f, 0.10405211f, 
    -0.03098047f, -0.07558354f, 0.02214162f, -0.05527598f, -0.19008143f, -0.03246194f, 0.02321872f, 0.34551948f, 
    -0.02431110f, 0.09891338f, 0.20312643f, -0.00571088f, -0.02960056f, -0.09958623f, 0.13810652f, -0.09920985f, 
    0.12208257f, -0.01234953f, -0.11095512f, -0.01900426f, 0.01539184f, -0.00079419f, -0.08036090f, -0.01980721f, 
    0.03511828f, -0.01708036f, 0.06271850f, -0.19089615f, 0.05583696f, -0.05897128f, 0.09359096f, 0.26914945f, 
    -0.09837409f, -0.02325890f, -0.03959565f, -0.09733635f, 0.00944815f, -0.08448929f, 0.06964503f, 0.09456971f, 
    -0.08857795f, -0.07455312f, 0.21143936f, 0.21756099f, -0.16587518f, 0.10256926f, -0.18902682f, -0.00301488f, 
    0.03739175f, -0.23139122f, 0.05146044f, -0.12358623f, 0.24669163f, 0.03218317f, -0.15779765f, -0.52176404f, 
    0.19733335f, 0.03485210f, -0.03540170f, -0.02540985f, 0.05537403f, 0.14460340f, -0.28730759f, -0.09463886f, 
    -0.15017559f, 0.03298570f, -0.11104648f, -0.02466687f, 0.00643695f, -0.11453520f, -0.17236076f, -0.07213236f, 
    0.03621045f, 0.10818992f, 0.07912903f, 0.03618057f, -0.33819556f, -0.28330922f, -0.08677012f, 0.11867063f, 
    0.04337834f, -0.08172666f, -0.10112939f, 0.04206629f, -0.11938794f, 0.02890679f, -0.08868203f, -0.04602652f, 
    0.05562393f, 0.12413602f, -0.00506146f, 0.02655198f, 0.01571663f, 0.12323114f, -0.01679743f, -0.01627774f, 
    -0.02768128f, 0.09242602f, -0.02897879f, -0.01458209f, -0.19667099f, -0.36067444f, 0.01993922f, 0.04909839f, 
    -0.11466374f, 0.01690748f, -0.11126204f, -0.10982637f, -0.04754156f, -0.02368785f, -0.02189534f, -0.07046854f, 
    0.10123609f, 0.08196647f, 0.09945279f, 0.20934910f, -0.12711769f, 0.08324639f, 0.04323181f, 0.09018216f, 
    0.06783433f, 0.06355820f, -0.00362351f, 0.15550540f, 0.12236390f, -0.14843258f, -0.01990580f, 0.16808251f, 
    0.00039687f, -0.00755143f, -0.09549434f, -0.01890494f, 0.09742597f, 0.01787863f, 0.11386752f, 0.13024393f, 
    0.00747180f, 0.41920823f, 0.16751802f, -0.03525957f, -0.20755439f, -0.02875151f, 0.02173325f, 0.11456661f, 
    0.00855165f, 0.12065818f, 0.02766853f, 0.03585056f, 0.12879525f, -0.00667344f, 0.00516391f, 0.22696564f, 
    0.03530988f, -0.06909370f, 0.02089295f, -0.00054327f, -0.18965292f, 0.10792403f, -0.05503761f, -0.00586814f, 
    0.01822398f, -0.30258048f, 0.06091642f, 0.11865494f, 0.24346849f, 0.16113016f, 0.04427763f, 0.02272831f, 
    -0.07488129f, 0.02184059f, -0.05006636f, 0.00009951f, -0.04765378f, -0.05916965f, -0.13729870f, 0.03433108f, 
    0.07714222f, 0.00248972f, -0.04722075f, 0.26648206f, -0.06651190f, -0.05994010f, -0.03420791f, -0.03256306f, 
    0.10723420f, 0.07404359f, -0.12410553f, -0.14305553f, -0.14682454f, -0.10528256f, -0.07978091f, -0.13431698f, 
    -0.07535598f, -0.07401008f, -0.13419151f, 0.15681024f, -0.37268156f, 0.17509340f, -0.19724324f, -0.57978040f, 
    0.14682141f, -0.01274465f, -0.01354188f, 0.05049317f, -0.23694311f, -0.09146695f, 0.00966488f, -0.13270155f, 
    -0.58263850f, 0.66606694f, -0.29146481f, -0.42284200f, 0.15905662f, 0.10287915f, -0.06243424f, 0.00772983f, 
    -0.18337391f, -0.08825007f, -0.04611957f, 0.02181179f, 0.50903010f, -0.06703292f, 0.16343728f, -0.37043703f, 
    -0.19183268f, -0.05969274f, -0.10899991f, 0.03038226f, 0.01847726f, 0.07879923f, 0.09389365f, -0.00074242f, 
    0.45616555f, -0.11270124f, -0.50120503f, 0.23557287f, 0.08414725f, -0.05551315f, 0.05039246f, -0.15284778f, 
    0.14446315f, -0.04442105f, -0.01408263f, -0.11753297f, 0.02753719f, -0.04597074f, -0.02240539f, 0.03846416f, 
    0.08168709f, 0.03728254f, -0.05325282f, 0.06010114f, 0.01335869f, -0.02990225f, -0.01911243f, -0.08830393f, 
    0.14046422f, 0.09700064f, 0.17221759f, 0.12327596f, -0.07675398f, 0.10316894f, -0.03760215f, -0.02629424f, 
    0.07093979f, 0.09202952f, 0.06801434f, 0.00014658f, -0.22180185f, -0.08996609f, -0.08481377f, 0.07565489f, 
    0.00846865f, -0.12192771f, 0.04847411f, 0.04095836f, 0.00979383f, -0.04285631f, -0.01375782f, 0.02257583f, 
    0.11954547f, 0.14570899f, -0.21825688f, 0.13731216f, -0.00358802f, 0.10589463f, 0.03887293f, 0.02288793f, 
    -0.07218374f, -0.33730412f, 0.09043985f, 0.00880668f, -0.00575497f, 0.07282353f, 0.06952274f, -0.11059605f, 
    0.06587961f, 0.12429965f, 0.00591888f, 0.04110638f, -0.10378128f, -0.08164008f, 0.03041633f, -0.02554028f, 
    -0.10826110f, -0.42250767f, 0.20518208f, -0.04796794f, -0.08729319f, -0.08706725f, 0.05956382f, -0.04240593f, 
    0.01656902f, 0.29551452f, 0.13805126f, 0.20835793f, 0.01828177f, -0.13640200f, 0.03082768f, 0.15518163f, 
    0.03213730f, -0.00976042f, 0.05146203f, -0.09545499f, 0.00268160f, -0.02338974f, 0.07151873f, -0.03002729f, 
    -0.03712698f, -0.01795687f, 0.02177786f, 0.10768181f, -0.12404305f, -0.07698273f, -0.08931786f, -0.08995066f, 
    0.01190803f, -0.11429900f, -0.02801994f, 0.01977463f, 0.03379995f, -0.05722378f, -0.00534083f, -0.01842664f, 
    -0.12975515f, -0.14323430f, 0.00065296f, -0.00633659f, 0.09569676f, -0.00653149f, -0.01577142f, 0.19027947f, 
    0.06878670f, 0.06928048f, -0.13221170f, -0.06950706f, 0.04270026f, 0.03179737f, 0.09538926f, -0.08530255f, 
    -0.01269835f, -0.12325992f, -0.04023141f, -0.22563979f, -0.00054638f, 0.07848349f, -0.24072514f, -0.22244090f, 
    0.00091419f, 0.04237384f, -0.08274706f, 0.01461829f, -0.03445186f, -0.02404205f, 0.09821387f, -0.08340979f, 
    0.04253414f, 0.17832620f, 0.13805453f, 0.22668123f, 0.13140957f, 0.06305197f, -0.05904915f, -0.02966476f, 
    0.12493189f, 0.07279886f, 0.07008988f, -0.00640937f, -0.09211393f, 0.10829729f, 0.17534578f, 0.05958883f, 
    -0.16714418f, -0.11229937f, -0.03058602f, -0.08172014f, -0.08045518f, -0.03786629f, -0.04608776f, -0.04523321f, 
    -0.18058184f, 0.05299734f, -0.22614141f, 0.11241017f, -0.05251918f, -0.09689925f, -0.16317864f, -0.19067821f, 
    0.03702354f, 0.02063184f, -0.04407705f, -0.15245096f, -0.03191124f, 0.01053463f, 0.10211571f, 0.17201224f, 
    -0.07799963f, 0.01476571f, -0.01976342f, -0.11151800f, -0.03002142f, -0.00907354f, 0.02974858f, 0.01650777f, 
    -0.16592456f, 0.10529756f, 0.02556858f, 0.14592457f, -0.08091643f, -0.12244652f, 0.07972494f, 0.02504793f, 
    0.12662804f, -0.20736796f, -0.02077963f, 0.09594028f, -0.14577346f, -0.02199632f, 0.28028479f, 0.17026444f, 
    -0.04073222f, -0.07832583f, -0.05415956f, 0.06031843f, -0.02557596f, 0.01373796f, -0.05364452f, 0.02609763f, 
    0.07617101f, -0.04925733f, -0.05091950f, 0.04256117f, -0.08045898f, 0.00038752f, -0.09715401f, -0.02051710f, 
    -0.15374526f, 0.09059907f, -0.10879400f, -0.17730138f, 0.19903010f, -0.02623407f, -0.16963620f, -0.01164494f, 
    -0.01782266f, 0.05362939f, -0.10301569f, -0.09575769f, -0.05017576f, -0.01970747f, -0.10215791f, 0.09481969f, 
    0.27168754f, 0.16804783f, 0.22825424f, 0.07309040f, -0.05078541f, -0.10473976f, -0.15366355f, -0.13825640f, 
    -0.00212039f, -0.05630545f, 0.02229064f, -0.02253297f, 0.07155295f, -0.06881329f, 0.02761403f, 0.06791938f, 
    -0.00057512f, -0.12041415f, -0.03918082f, -0.02084102f, 0.14874797f, -0.02638754f, -0.09206669f, 0.19768098f, 
    -0.24294940f, -0.46826148f, -0.17571847f, -0.05966468f, 0.06737853f, -0.06791534f, 0.07419196f, -0.20264028f, 
    0.07548165f, 0.02232172f, 0.03774954f, 0.08868531f, -0.04110559f, -0.25496626f, 0.19242108f, 0.10799427f, 
    -0.27398565f, 0.05189515f, -0.28482935f, -0.02244629f, -0.16386907f, 0.06376981f, -0.15830718f, -0.12136352f, 
    0.14292364f, 0.24270882f, 0.27693960f, 0.16702127f, -0.17920597f, -0.01063803f, 0.10350222f, 0.17319125f, 
    0.06935286f, -0.01551498f, 0.03583462f, 0.01065741f, -0.13659187f, -0.02570279f, 0.04533087f, -0.09373912f, 
    0.09873767f, 0.04097760f, 0.01253187f, -0.01407691f, 0.02854644f, -0.23526797f, -0.23918636f, -0.11414189f, 
    0.00710010f, 0.06081313f, -0.02361722f, -0.09854552f, 0.04583813f, 0.05819774f, 0.06214489f, 0.08761171f, 
    0.14136720f, 0.00551561f, -0.06567838f, -0.03948783f, -0.04955447f, 0.03683249f, -0.05148737f, 0.00700287f, 
    0.02559886f, 0.00895482f, -0.12613814f, -0.01845172f, -0.00097004f, -0.01733441f, -0.06426845f, -0.01960268f, 
    -0.30104247f, 0.02059744f, 0.04629955f, -0.10038591f, -0.07774368f, 0.11396631f, -0.12210347f, 0.06496276f, 
    -0.06377441f, -0.02829506f, 0.02834369f, -0.07162531f, -0.09443945f, 0.10618566f, 0.07725721f, 0.01169191f, 
    0.09326479f, 0.08317381f, 0.06701801f, -0.01039985f, -0.04341506f, -0.06053994f, 0.05388141f, 0.11134633f, 
    0.18259946f, 0.18699154f, -0.01112004f, 0.14465532f, -0.03116133f, 0.07646064f, -0.02048931f, 0.08185160f, 
    0.03696948f, 0.01328242f, 0.10314831f, 0.03029809f, 0.04623896f, -0.04620952f, 0.10681763f, 0.03284759f, 
    -0.11619604f, -0.02873989f, -0.11526955f, 0.11660751f, 0.01707713f, -0.03014055f, -0.06100072f, -0.02415338f, 
    0.00097351f, -0.06564959f, -0.14266354f, -0.04427742f, -0.03773722f, -0.01859819f, -0.02867018f, 0.04456412f, 
    0.08813212f, 0.11308946f, 0.17599592f, 0.13787070f, -0.03185265f, -0.00021121f, 0.08887094f, 0.00355567f, 
    0.03796101f, -0.13681875f, 0.03349254f, -0.19706587f, -0.08485889f, -0.21960934f, -0.01106969f, -0.09667736f, 
    0.01032828f, -0.01160074f, -0.09194045f, -0.00420231f, -0.04972291f, -0.01237639f, -0.04246499f, 0.07361612f, 
    0.00994945f, -0.08504350f, -0.12291210f, -0.04608300f, 0.09535208f, 0.22067364f, -0.03540291f, 0.03971113f, 
    0.06473612f, 0.04566144f, -0.06010961f, -0.05041011f, 0.06037764f, 0.09235144f, -0.06722140f, -0.04821534f, 
    -0.08470792f, 0.16858429f, 0.15016021f, 0.18856320f, -0.02706061f, 0.00995421f, -0.01400414f, -0.12842493f, 
    -0.10493481f, -0.00300773f, -0.01501840f, -0.08474123f, 0.14066432f, 0.06675261f, -0.02367063f, -0.04035253f, 
    0.05093609f, -0.02775039f, 0.03801110f, 0.01391018f, -0.02510289f, -0.01951407f, -0.07259891f, -0.07402325f, 
    0.06593125f, 0.03577109f, 0.00320440f, 0.00326035f, 0.05681298f, 0.05398428f, 0.05501325f, -0.01180853f, 
    0.04659061f, 0.02183828f, -0.01487050f, -0.00611208f, -0.09242911f, -0.08555546f, 0.12548183f, 0.04865164f, 
    -0.04501734f, -0.09607926f, -0.22528194f, -0.09118779f, -0.06825697f, -0.09335867f, -0.10431490f, 0.12515672f, 
    0.02357980f, -0.38023552f, 0.29610750f, 0.05406689f, -0.00795339f, -0.06432677f, -0.12806995f, -0.00768107f, 
    -0.16660318f, -0.02003848f, -0.02930917f, 0.20252086f, -0.29031786f, -0.12068909f, -0.61383229f, -0.17806993f, 
    0.08941186f, 0.03208252f, 0.03388580f, 0.05197344f, -0.02514986f, 0.04483919f, -0.03603026f, -0.13838577f, 
    0.13056085f, -0.06131921f, 0.07143328f, 0.02535612f, -0.02638638f, -0.00688194f, 0.02694420f, 0.07995419f, 
    0.05391853f, 0.04012692f, 0.05090800f, 0.02679303f, -0.10114047f, 0.04288150f, -0.01270727f, 0.03384606f, 
    0.00985921f, -0.07491479f, 0.01167424f, -0.00135395f, 0.09792815f, 0.06538335f, 0.07424787f, 0.21271071f, 
    -0.71012026f, -0.01945900f, 0.02345154f, -0.30218792f, 0.02233739f, 0.06172778f, -0.04183570f, 0.10435826f, 
    -0.28238988f, -0.03363168f, -0.14331692f, 0.01601291f, 0.06697153f, 0.09113455f, 0.06181740f, 0.09293476f, 
    0.10963712f, -0.00501266f, 0.04265751f, 0.01744375f, -0.02397024f, 0.05600534f, -0.05432142f, -0.01887590f, 
    0.04424560f, 0.06352969f, -0.00573128f, 0.05426742f, -0.01801214f, -0.10426118f, 0.05566113f, 0.00867952f, 
    0.01633185f, -0.05396272f, 0.02222491f, -0.04999792f, -0.11052492f, 0.15255876f, -0.12545583f, 0.13209559f, 
    -0.02524485f, 0.04116607f, -0.13905093f, -0.01927229f, -0.01031043f, -0.00419877f, -0.01930750f, 0.00098566f, 
    -0.15908986f, 0.13736457f, 0.03071021f, 0.05551928f, 0.00333169f, -0.08519036f, 0.05894356f, -0.19493842f, 
    0.20326699f, 0.15368460f, -0.06127447f, 0.34055933f, 0.03153675f, -0.12889381f, -0.07869609f, 0.09990288f, 
    -0.09415869f, -0.00371077f, 0.00934649f, -0.10942508f, 0.01105848f, -0.00829394f, -0.08704347f, -0.06154697f, 
    0.03077267f, -0.03358455f, -0.12389017f, -0.09871396f, -0.09320467f, -0.03133695f, 0.00779096f, -0.05505186f, 
    -0.12539440f, 0.04247243f, 0.08805848f, 0.11435523f, 0.02453465f, -0.01648972f, 0.06090774f, 0.05451442f, 
    0.08221470f, 0.08952250f, 0.06871074f, 0.03617463f, 0.10692260f, 0.03041576f, 0.02499516f, 0.01590950f, 
    0.10731462f, -0.00012174f, 0.05488113f, 0.10264702f, -0.06126694f, -0.05718735f, -0.18210641f, -0.14099833f, 
    -0.09116918f, -0.03935529f, -0.14650893f, 0.09765261f, -0.03858798f, -0.05344345f, -0.03703242f, -0.03464352f, 
    0.06787334f, 0.07497144f, 0.04261199f, 0.02833968f, 0.09264616f, 0.02538193f, 0.03951834f, -0.06539336f, 
    0.07319468f, 0.19400124f, 0.14586289f, 0.31201631f, 0.08056309f, 0.03670358f, 0.02812492f, 0.19585706f, 
    -0.03077951f, -0.02395435f, -0.02777348f, -0.00906854f, -0.08252996f, -0.02681217f, 0.04428446f, 0.12139010f, 
    -0.09585321f, -0.07592159f, -0.06246893f, -0.06353741f, 0.04775749f, 0.00691690f, -0.00925042f, 0.06128388f, 
    0.26803777f, -0.37931576f, -0.13872337f, 0.20524089f, 0.05796105f, 0.01228640f, 0.03809978f, -0.00148960f, 
    0.05857103f, 0.03133915f, 0.02118336f, 0.05537441f, -0.32830802f, -0.01583573f, -0.07030091f, -0.07374968f, 
    -0.05137407f, -0.01461441f, -0.07946350f, 0.06806795f, -0.00503904f, 0.05006032f, -0.01112496f, -0.05322982f, 
    0.20742247f, 0.19880353f, 0.10697097f, 0.05969854f, -0.05260000f, -0.10168726f, 0.06311260f, 0.13863041f, 
    0.00275293f, -0.10686531f, -0.00988085f, 0.01881783f, 0.02279460f, 0.04089008f, 0.29225963f, 0.09368557f, 
    -0.00264311f, 0.01773858f, -0.08296791f, -0.03783533f, -0.01131654f, -0.06781369f, 0.04808763f, 0.07283548f, 
    0.03037542f, -0.03211828f, 0.06309472f, 0.06547175f, -0.00437313f, 0.09196424f, 0.00213519f, 0.00099742f, 
    -0.19134779f, -0.00655137f, -0.00273320f, -0.07015631f, 0.00162598f, -0.47736937f, -0.03048686f, -0.01263978f, 
    -0.06681805f, 0.07521285f, -0.04759623f, 0.09009145f, -0.29431039f, -0.04589283f, -0.14967278f, -0.00700106f, 
    0.11251196f, -0.31820095f, 0.07829065f, -0.02232775f, 0.00202244f, -0.06798442f, -0.00643977f, -0.08280762f, 
    -0.11488325f, 0.06122744f, -0.14990014f, -0.10811551f, -0.03247864f, 0.11499754f, -0.12338319f, 0.05874010f, 
    0.00144264f, -0.03924255f, 0.03012514f, -0.18384264f, 0.18315433f, -0.17708409f, 0.01649270f, 0.19461532f, 
    -0.57719827f, 0.28544861f, -0.43553776f, 0.33726099f, 0.19273107f, -0.03501702f, -0.04159787f, 0.09499180f, 
    0.03036987f, 0.00396387f, 0.01527045f, -0.03332125f, 0.09484452f, -0.08051344f, -0.14604633f, 0.17669176f, 
    -0.19185780f, 0.06861252f, 0.11366620f, -0.01869194f, -0.06278784f, 0.01683891f, 0.13125585f, -0.07791383f, 
    0.07679188f, 0.02473881f, 0.21648304f, -0.22198617f, 0.04967382f, -0.00002637f, -0.23453693f, -0.12049380f, 
    -0.01923884f, -0.03680024f, -0.04264278f, -0.04218193f, 0.13377652f, -0.09164645f, -0.00597223f, 0.10468745f, 
    0.01113343f, 0.00801725f, -0.17274314f, 0.18116659f, 0.03303421f, -0.07200669f, -0.06986311f, 0.05482151f, 
    -0.05470030f, -0.00110141f, 0.06551232f, -0.21289220f, -0.06164927f, -0.07036940f, -0.12129854f, -0.00647552f, 
    0.09613024f, -0.08122645f, -0.04580080f, 0.04102739f, -0.20801856f, 0.11883542f, -0.21142934f, -0.16977188f, 
    -0.00183670f, -0.05426518f, 0.02520508f, 0.11792410f, 0.06652129f, 0.05168889f, 0.02192067f, -0.07051301f, 
    -0.23207843f, -0.03814621f, 0.06282037f, 0.03636973f, 0.03793546f, -0.05287431f, 0.00271980f, -0.00128205f, 
    -0.07147521f, -0.11854161f, -0.15907651f, -0.24197154f, -0.20532264f, 0.23449741f, 0.27664766f, -0.08169324f, 
    0.03743185f, -0.05059449f, 0.02029651f, 0.13904089f, 0.02654350f, 0.01012420f, 0.15869878f, -0.02275817f, 
    -0.24012394f, -0.04948303f, 0.12384515f, -0.32870081f, -0.01365369f, -0.04371871f, -0.02066113f, -0.04417344f, 
    -0.00229173f, -0.13919170f, 0.04015185f, 0.09268417f, -0.12610236f, 0.08046517f, -0.12285314f, -0.24004480f, 
    0.10694177f, 0.06845708f, -0.07737946f, 0.19127251f, -0.07879291f, 0.04625715f, -0.13630469f, -0.31352916f, 
    -0.07393407f, -0.07278623f, -0.03895526f, 0.05362524f, 0.05902752f, -0.01610097f, 0.09926385f, -0.08537969f, 
    0.21951459f, 0.05983374f, 0.24832535f, 0.15247205f, -0.19667317f, -0.29953799f, -0.09604367f, 0.19321118f, 
    0.07513731f, 0.04294149f, -0.04312089f, 0.05983362f, -0.08490858f, -0.06893954f, 0.07322729f, 0.08997056f, 
    0.02789217f, 0.06450570f, 0.00113050f, -0.06292926f, 0.03020386f, -0.00272501f, -0.05722642f, -0.19305363f, 
    -0.28795096f, -0.09726966f, -0.03937941f, -0.19226585f, 0.21289890f, 0.04671315f, -0.02322562f, -0.01948961f, 
    -0.01892040f, -0.10991766f, -0.00226492f, 0.22972681f, 0.00208453f, -0.08465492f, 0.02364772f, -0.00939236f, 
    -0.01488365f, 0.08711547f, -0.07256595f, 0.15681691f, 0.03999173f, -0.05120198f, 0.14474244f, 0.17167492f, 
    -0.11750738f, -0.03343071f, -0.06535438f, 0.01773602f, -0.27264860f, 0.19980061f, 0.03824351f, -0.36263949f, 
    -0.02312766f, 0.01194650f, 0.05077298f, 0.15809055f, -0.03250380f, -0.09360252f, 0.03494211f, -0.00248148f, 
    -0.51458395f, -0.21223131f, -0.37547538f, -0.07489871f, 0.04951661f, -0.05195239f, 0.03258035f, -0.06353355f, 
    0.20292641f, 0.15979791f, -0.03453967f, -0.07677884f, 0.13291056f, -0.06618517f, 0.11641701f, -0.05273294f, 
    0.01254952f, -0.08200914f, 0.23101418f, -0.20646894f, 0.17104486f, -0.01626193f, -0.14875992f, -0.04504485f, 
    0.16414419f, -0.22257400f, -0.04000906f, 0.08889557f, 0.10506865f, -0.06621207f, -0.07424761f, -0.00208381f, 
    0.03082080f, -0.05117859f, 0.03026899f, 0.18027215f, -0.17143446f, -0.28790429f, -0.22905926f, 0.40468925f, 
    0.05493306f, 0.10683726f, -0.14142546f, 0.21721572f, 0.26691461f, 0.23204978f, 0.00700233f, -0.18077441f, 
    0.22670230f, 0.09462430f, -0.08250118f, 0.00473543f, -0.00088969f, 0.07896549f, -0.03101015f, 0.09819372f, 
    0.00051396f, 0.02640664f, -0.04753128f, 0.06068419f, 0.05781731f, 0.00211210f, 0.07125734f, -0.20639153f, 
    -0.06536762f, 0.13903415f, -0.10951860f, -0.04905310f, -0.03445403f, 0.04482106f, -0.21640719f, -0.20361741f, 
    -0.40480322f, -0.08677645f, 0.19587915f, 0.26752082f, 0.05266661f, -0.13257961f, -0.15047364f, 0.24140917f, 
    -0.05936069f, -0.06500158f, -0.09455832f, 0.08592784f, 0.08831397f, 0.14813961f, 0.17312314f, 0.06161040f, 
    0.18502469f, 0.02988192f, 0.08600378f, -0.03563245f, -0.04867012f, 0.03925912f, 0.14372288f, 0.07981127f, 
    0.09807806f, 0.15812150f, 0.03453427f, -0.07500731f, 0.34230214f, 0.17715520f, 0.03330225f, -0.18629009f, 
    0.03398474f, 0.01279743f, 0.02494782f, 0.07443871f, 0.13675222f, -0.21336241f, -0.21026655f, 0.07748951f, 
    -0.14955279f, 0.11752068f, -0.19074774f, -0.07424224f, 0.15539640f, -0.12039428f, 0.07801765f, -0.09140729f, 
    -0.07697454f, -0.13006967f, -0.14437018f, 0.03904485f, -0.03774041f, -0.00275538f, 0.00220483f, -0.00922009f, 
    -0.01715758f, -0.05867942f, -0.07466365f, -0.12320784f, -0.11106816f, -0.10662725f, -0.03959060f, -0.03204724f, 
    0.01684803f, -0.01659941f, -0.14846279f, 0.03069817f, 0.15185781f, -0.04095734f, 0.01205218f, 0.18483679f, 
    -0.20505477f, -0.05491066f, -0.27695668f, -0.05002628f, 0.00792736f, 0.00134951f, -0.05404773f, -0.00719666f, 
    0.08874882f, -0.07766131f, 0.09040339f, 0.28380916f, 0.10484031f, 0.28390944f, -0.16041110f, 0.01237615f, 
    -0.04180821f, -0.13178509f, -0.17229521f, 0.04383129f, 0.01615746f, 0.08646664f, 0.01326336f, -0.12891312f, 
    -0.07210585f, -0.36434519f, -0.01025644f, 0.01808790f, 0.17058422f, 0.03664402f, -0.00277960f, 0.15195774f, 
    -0.02018908f, 0.00979622f, -0.04096336f, -0.04364619f, 0.05691653f, 0.01526570f, 0.16043063f, -0.09240565f, 
    0.12250065f, 0.20736010f, 0.09020387f, 0.11148373f, 0.12563071f, 0.07541958f, 0.04317785f, 0.04417159f, 
    0.04057183f, -0.15477069f, 0.04486669f, 0.20089808f, 0.02393861f, -0.03392074f, 0.04988697f, -0.00538636f, 
    -0.10005549f, -0.20856945f, -0.04595148f, -0.09035468f, 0.05979421f, -0.10352283f, -0.07805881f, -0.01316014f, 
    0.09591879f, 0.01081765f, 0.10983860f, 0.23948973f, -0.03447177f, 0.13158570f, -0.01868602f, -0.02792697f, 
    -0.14216785f, 0.05365801f, 0.07228800f, 0.03001802f, 0.06640367f, 0.03111111f, -0.04100550f, -0.04621801f, 
    0.13210776f, 0.06661267f, -0.02822338f, 0.20531279f, -0.07114907f, -0.07318502f, 0.00356232f, -0.08094677f, 
    -0.07118335f, 0.07022702f, 0.31642589f, -0.05232429f, 0.13465331f, -0.16501477f, 0.10959093f, -0.08263748f, 
    0.14310326f, 0.09199695f, 0.23329978f, -0.00026772f, 0.01171490f, -0.04353656f, 0.08898059f, -0.00037009f, 
    0.07100756f, 0.00177986f, 0.04807402f, -0.02675561f, -0.11009352f, -0.11664764f, -0.04252510f, 0.09563106f, 
    0.14064912f, -0.13705699f, 0.00636145f, -0.05911821f, 0.04202757f, 0.05974032f, 0.02694522f, 0.15646966f, 
    -0.05754797f, -0.09687974f, 0.00643058f, -0.04904780f, 0.00571629f, 0.08457232f, -0.06059512f, -0.06609917f, 
    0.08219307f, -0.09043800f, 0.08350672f, 0.03561489f, 0.25476357f, -0.03035034f, -0.16996564f, -0.20279616f, 
    0.01586954f, 0.00676757f, 0.02818814f, 0.09047423f, 0.03447077f, -0.03256286f, 0.10398506f, -0.27833518f, 
    -0.10049254f, 0.17412883f, -0.06600484f, -0.00016013f, 0.06085801f, 0.01525928f, -0.00366401f, 0.04778385f, 
    0.17157330f, -0.11008616f, -0.13967168f, -0.07565803f, 0.22905990f, 0.04000688f, -0.26280230f, -0.06282355f, 
    0.12091051f, 0.06076713f, -0.05233125f, 0.09744377f, 0.15041189f, -0.07082688f, 0.00543543f, -0.01878930f, 
    -0.05183480f, -0.11640847f, -0.12920320f, -0.09231906f, 0.19157661f, -0.00538966f, -0.07645939f, 0.05021147f, 
    0.17622524f, 0.23109658f, 0.00979414f, -0.05832542f, 0.12948759f, -0.06079147f, -0.06235743f, -0.07433590f, 
    0.04899573f, 0.04069850f, 0.03209026f, 0.00729009f, -0.00565373f, -0.12035084f, -0.09644683f, -0.19633172f, 
    0.05447895f, -0.06805360f, 0.15693390f, -0.01360250f, 0.03565315f, 0.01761480f, 0.00698490f, -0.11902332f, 
    0.03533398f, 0.25270361f, -0.17298017f, -0.06347001f, 0.01334138f, 0.21898466f, -0.05405316f, -0.34472492f, 
    0.19177447f, 0.07553267f, 0.06293073f, 0.10968723f, 0.06338033f, 0.07859729f, 0.04674638f, 0.02557457f, 
    0.03371254f, 0.04400848f, 0.03491254f, -0.09962235f, 0.03493869f, -0.04150121f, 0.09250251f, 0.19249007f, 
    0.19861619f, -0.03207108f, -0.04127344f, 0.04684946f, -0.10309543f, 0.10074846f, -0.01918153f, -0.14724456f, 
    -0.04046040f, 0.16334638f, -0.17059040f, -0.13905664f, 0.04240355f, 0.09687784f, -0.03946465f, -0.02656770f, 
    0.03420377f, -0.02628022f, -0.20792089f, 0.11343712f, -0.02330323f, -0.01311446f, 0.03797724f, 0.15902838f, 
    -0.09431034f, -0.11831698f, 0.03173885f, -0.19522865f, -0.11267952f, -0.23258473f, 0.10787545f, 0.09061117f, 
    -0.24980293f, -0.15228912f, 0.07164347f, 0.03940613f, -0.13679227f, -0.10265438f, 0.24977921f, -0.08032852f, 
    0.36692950f, -0.44535217f, 0.19387215f, 0.19107632f, 0.11349292f, -0.05819551f, 0.02067817f, 0.02280696f, 
    0.05060366f, 0.10023987f, -0.32713354f, -0.24226373f, -0.29378369f, -0.24407370f, -0.00116858f, 0.07289340f, 
    0.06861525f, 0.00244124f, -0.04033079f, -0.00931969f, 0.03428153f, -0.05778870f, 0.03221031f, 0.17391743f, 
    0.12725022f, -0.09553631f, 0.04198768f, 0.01573749f, -0.06963546f, 0.03698899f, -0.02421997f, -0.11686026f, 
    0.08219503f, -0.06080668f, 0.10996170f, -0.02697415f, -0.09133934f, -0.14702946f, -0.15878662f, 0.12210379f, 
    0.07962959f, -0.00474315f, -0.09028310f, -0.00622403f, -0.01692961f, -0.00228745f, -0.00207942f, 0.03275318f, 
    -0.04522640f, -0.26215833f, 0.24332008f, 0.02735158f, -0.13468334f, 0.08056528f, 0.00196656f, -0.07495259f, 
    0.00670377f, -0.06326505f, 0.05094551f, 0.03043084f, -0.22878456f, -0.01835177f, -0.09495301f, -0.15770957f, 
    0.05964989f, 0.03900400f, 0.11399943f, -0.09227370f, 0.07435366f, 0.03191049f, -0.03234814f, 0.03115242f, 
    -0.31523439f, -0.32127863f, 0.12357780f, 0.13017841f, 0.03604753f, -0.01724239f, 0.02759941f, -0.05977961f, 
    -0.08284424f, -0.10673896f, -0.00667659f, -0.03672455f, 0.03095649f, -0.23755153f, -0.12365585f, -0.16382624f, 
    0.05406542f, -0.02678974f, -0.19242783f, 0.18272693f, -0.02196722f, -0.06338350f, 0.10501654f, 0.09841651f, 
    -0.70216560f, -0.41088718f, -0.22829382f, -0.18057446f, 0.06308696f, 0.02013285f, -0.09832255f, 0.06338914f, 
    0.03949071f, -0.09186833f, 0.09212459f, -0.03032015f, 0.16693842f, 0.22525288f, 0.32029554f, 0.00827769f, 
    -0.03183287f, -0.01075866f, 0.02989154f, -0.10816585f, 0.12850356f, -0.00875397f, -0.08637915f, 0.02488742f, 
    -0.06031021f, -0.10444077f, -0.13739190f, 0.05078946f, 0.18121013f, -0.04334148f, 0.02816720f, 0.06950665f, 
    -0.00389860f, 0.12365857f, 0.18261211f, 0.11942077f, -0.16823970f, -0.36695462f, 0.34641141f, 0.10018907f, 
    -0.08534335f, -0.02876810f, -0.04778307f, -0.00389352f, 0.12122288f, -0.02309906f, 0.02880333f, 0.16316149f, 
    -0.07427060f, 0.05023174f, -0.07965136f, 0.24524520f, -0.01425557f, -0.03926644f, 0.00444727f, 0.06085169f, 
    0.18316071f, -0.00628029f, -0.09484405f, 0.04182697f, -0.29264247f, -0.11404596f, -0.01258149f, 0.09330770f, 
    -0.01798362f, -0.00308669f, -0.00807382f, 0.04359050f, -0.02496372f, 0.01430763f, -0.03686150f, -0.24690340f, 
    0.10097179f, -0.26135015f, -0.28337425f, -0.39153355f, -0.10555414f, 0.19543426f, 0.16516449f, -0.12659724f, 
    0.02010090f, 0.12017455f, 0.01502109f, -0.06527928f, -0.09747642f, 0.01167968f, 0.10733694f, 0.02223804f, 
    0.06451195f, -0.01739473f, 0.02162069f, 0.04034300f, -0.04498617f, -0.10128871f, 0.00723477f, 0.14982791f, 
    -0.47928894f, -0.27507380f, -0.38085389f, -0.07882705f, -0.09743142f, 0.10516126f, -0.11462175f, -0.03259136f, 
    0.04648245f, -0.03594234f, -0.05623043f, -0.02713289f, 0.04751036f, -0.20526482f, -0.16563283f, 0.51588869f, 
    -0.05004730f, 0.01106089f, 0.01778268f, 0.07565612f, 0.01758176f, 0.01652507f, 0.09979222f, -0.07802293f, 
    -0.02825918f, -0.20841499f, 0.12292420f, -0.04923366f, -0.04062138f, -0.16385978f, 0.00833117f, 0.09117401f, 
    0.01958457f, 0.12772115f, -0.03514990f, 0.03532386f, -0.29682013f, -0.29885340f, 0.08326007f, 0.20828407f, 
    0.24255006f, 0.12035620f, 0.02351283f, -0.28452569f, 0.02347885f, -0.05527886f, -0.02827805f, 0.01862791f, 
    -0.00865932f, -0.00374968f, 0.22335897f, -0.12734056f, 0.01248113f, 0.00685150f, -0.04398508f, 0.07869617f, 
    0.11727744f, 0.15140027f, 0.17317496f, 0.13667326f, -0.31478947f, -0.45473823f, -0.49254477f, -0.02669305f, 
    -0.06449885f, -0.08184233f, 0.06679960f, -0.13467796f, -0.04312272f, 0.02546670f, -0.00282081f, -0.02134650f, 
    -0.17369658f, -0.49060425f, 0.10298828f, 0.05843201f, -0.03577783f, -0.10268706f, 0.09284972f, -0.03706660f, 
    -0.04217892f, 0.04529648f, 0.01010059f, -0.00864640f, -0.43579078f, 0.37301293f, -0.12985805f, -0.02589779f, 
    0.01627043f, -0.00381423f, 0.03719802f, -0.12544124f, 0.00607166f, -0.02990800f, 0.17692080f, 0.08044970f, 
    0.08419821f, 0.03873397f, 0.07973028f, -0.05208838f, 0.02544531f, 0.06035190f, -0.06826993f, 0.03501697f, 
    -0.03699747f, -0.09455625f, 0.07598690f, -0.05432419f, -0.15403976f, 0.05259689f, 0.06447002f, -0.13479920f, 
    0.06684210f, 0.04631948f, 0.05450374f, -0.04363359f, -0.02842670f, -0.06642552f, 0.03026222f, 0.14233568f, 
    0.22497663f, 0.04575611f, 0.00351735f, -0.17656054f, 0.03515298f, -0.04088461f, 0.04267449f, -0.05811302f, 
    0.20810120f, -0.07262284f, -0.03403016f, 0.06192477f, 0.55266291f, 0.27267703f, -0.20883200f, 0.21033977f, 
    -0.06080199f, -0.16057324f, 0.31212294f, 0.14654714f, 0.10795928f, 0.00935986f, 0.06014314f, -0.06827646f, 
    0.37606519f, -0.20133655f, -0.09014361f, 0.02067447f, 0.01604390f, -0.00889255f, 0.12169758f, -0.05254209f, 
    0.07547653f, -0.05195124f, 0.09922357f, -0.13602874f, -0.57186717f, -0.29063261f, 0.18313552f, -0.10731447f, 
    -0.17876120f, -0.03095975f, 0.18957736f, 0.03667384f, -0.01817915f, 0.01117259f, 0.01984763f, -0.04886634f, 
    -0.20776694f, -0.08830165f, 0.29436687f, 0.00915545f, -0.04863708f, 0.01924873f, -0.02399195f, 0.02095624f, 
    0.06059391f, 0.10112903f, 0.09572276f, 0.10844253f, -0.56756711f, -0.27045411f, -0.20828767f, 0.22983634f, 
    0.08417655f, 0.07833570f, -0.03752261f, -0.18385313f, -0.03519369f, -0.01311105f, 0.02893530f, 0.07533534f, 
    0.08175186f, 0.08249443f, 0.04236025f, -0.00482649f, -0.03975204f, 0.03573433f, 0.03765682f, -0.07875169f, 
    -0.00801641f, -0.03394665f, 0.15162088f, -0.07776672f, -0.15152383f, -0.24192214f, 0.14889577f, 0.45327529f, 
    0.03559525f, 0.06171099f, -0.01752194f, -0.03678032f, -0.10234970f, -0.05886339f, 0.09410069f, 0.02938182f, 
    -0.27886522f, 0.30090043f, 0.40961352f, 0.03340111f, -0.16718368f, -0.09278409f, -0.09192971f, -0.12838873f, 
    -0.07831398f, -0.07480055f, -0.07081385f, 0.04852647f, 0.00020545f, -0.13098845f, 0.01282258f, 0.16454214f, 
    0.00736743f, 0.06376183f, 0.00688782f, -0.01883952f, 0.13646480f, -0.03242601f, 0.06815322f, 0.01081687f, 
    -0.35592538f, -0.32879749f, 0.02783050f, -0.02817920f, 0.01140183f, 0.13307297f, -0.01620165f, -0.15486313f, 
    0.07334204f, -0.02010872f, -0.01461485f, 0.18054132f, -0.01527648f, -0.04250717f, 0.43246487f, 0.17346056f, 
    -0.09584520f, -0.28026024f, 0.11482769f, -0.01130285f, -0.14500150f, 0.17437287f, -0.08622404f, -0.16660464f, 
    -0.49819252f, -0.50233567f, -0.50913680f, -0.16100144f, -0.00094995f, -0.21789262f, -0.19077291f, -0.29717219f, 
    0.01603937f, -0.05285130f, 0.00261247f, -0.00117601f, 0.44192636f, 0.27678689f, -0.37506962f, 0.23253649f, 
    -0.02945544f, -0.11836453f, 0.07036990f, -0.01692983f, 0.11182060f, 0.15965988f, -0.29606465f, -0.10828248f, 
    0.01233747f, 0.03364301f, 0.00593556f, -0.15878892f, 0.01163757f, 0.02157851f, -0.07539437f, -0.02006814f, 
    -0.04543823f, 0.02346475f, -0.11357267f, -0.06745756f, 0.08084978f, 0.09979201f, 0.00304157f, 0.06417114f, 
    0.03603259f, 0.05009258f, 0.16195385f, -0.01845753f, 0.07414488f, -0.10938028f, -0.01261484f, 0.06815410f, 
    -0.07747999f, 0.04454171f, 0.06690031f, -0.19917193f, 0.05648622f, 0.03884138f, 0.03885633f, -0.05146528f, 
    0.02258104f, -0.00224586f, 0.10605973f, 0.07007145f, -0.70394850f, -0.60984123f, 0.20444453f, -0.57547498f, 
    -0.05161940f, 0.00865426f, -0.00603042f, -0.06624302f, 0.02585482f, 0.05574179f, 0.08900775f, 0.06541061f, 
    -0.02183345f, -0.16216710f, -0.08014213f, 0.00197073f, 0.04340054f, 0.09741519f, 0.09271433f, -0.02282359f, 
    -0.03806515f, -0.07970331f, 0.07454376f, 0.00785737f, -0.08650827f, -0.17545423f, -0.13546194f, 0.01965142f, 
    -0.00407455f, -0.01119708f, -0.07680029f, -0.05573570f, -0.00382997f, -0.06161694f, -0.03673560f, -0.04309724f, 
    0.12960258f, 0.09287743f, -0.11182056f, -0.01747146f, -0.07180250f, 0.04552216f, 0.07278831f, 0.13000527f, 
    0.04961714f, 0.18172869f, 0.10240557f, -0.09802104f, 0.15653503f, 0.15544096f, 0.05627597f, -0.13083868f, 
    0.04264759f, -0.01779699f, 0.01573307f, -0.00724100f, 0.01146182f, -0.03901908f, 0.02288696f, 0.10569511f, 
    0.03896947f, 0.01392219f, -0.13780099f, 0.11491916f, 0.06170574f, -0.09851845f, 0.02556073f, 0.04984853f, 
    -0.04894297f, 0.00618619f, 0.01329507f, -0.01810152f, 0.22896995f, -0.13178603f, -0.13051613f, -0.10917703f, 
    0.03336803f, 0.11805123f, 0.10547743f, -0.10670224f, 0.06602069f, -0.16160932f, 0.03518684f, 0.00849733f, 
    -0.41310486f, -0.53738594f, -0.13433571f, -0.58659369f, -0.14324160f, -0.20972003f, -0.04425155f, -0.21760786f, 
    0.04386489f, 0.08636337f, -0.01986048f, -0.12729281f, 0.03951050f, -0.00856893f, 0.03332670f, 0.27085462f, 
    -0.01398169f, -0.06979585f, -0.05599531f, 0.01386860f, -0.01248010f, -0.07897746f, 0.06436731f, -0.04289408f, 
    -0.06311042f, 0.00116763f, 0.02291077f, 0.05550508f, 0.04397383f, 0.02437428f, 0.07998303f, -0.02243410f, 
    -0.02809483f, -0.07481340f, 0.00841076f, -0.05591773f, -0.30434594f, 0.31138664f, 0.02084530f, -0.06556542f, 
    -0.09699100f, 0.17207290f, -0.10754912f, -0.00727757f, 0.07680473f, -0.05825258f, 0.12330778f, 0.09043527f, 
    -0.29691449f, 0.00868785f, 0.10226171f, 0.16269743f, 0.04731806f, 0.08861936f, -0.00832155f, -0.02660717f, 
    -0.00344064f, -0.02880030f, 0.21167707f, 0.06158732f, -0.12049707f, -0.07705625f, 0.06776942f, -0.43781820f, 
    0.02265105f, -0.00132975f, 0.03790401f, 0.00232636f, 0.01881859f, 0.00841415f, -0.04892989f, 0.03908192f, 
    0.18299930f, 0.39946863f, 0.02893540f, -0.06179684f, 0.02102508f, -0.16465476f, -0.16536288f, 0.06837213f, 
    -0.06942926f, -0.12408149f, 0.01183895f, 0.03678838f, -0.06249977f, 0.17207502f, 0.11308283f, -0.04047618f, 
    -0.02930976f, 0.05588814f, -0.00369911f, 0.06429872f, 0.14456740f, 0.09186082f, 0.19064097f, 0.21490751f, 
    0.04483174f, 0.05619895f, -0.04388532f, -0.11785425f, -0.09982451f, 0.03094168f, -0.15228994f, 0.11526347f, 
    0.05045610f, 0.12356769f, 0.00588767f, 0.10127182f, -0.25806582f, -0.44423082f, -0.21036741f, 0.06011622f, 
    -0.00371552f, -0.30733979f, -0.09375668f, -0.37414497f, -0.04393861f, -0.01463924f, -0.01020107f, -0.01932414f, 
    -0.06142031f, -0.10290046f, -0.02238421f, 0.01603967f, -0.10386741f, -0.22215763f, 0.08735764f, -0.02931283f, 
    0.00376709f, 0.02969702f, -0.03926110f, -0.08808751f, -0.11886404f, -0.11753730f, -0.27503422f, -0.50667626f, 
    -0.00355860f, -0.19575463f, -0.09923665f, 0.13825780f, -0.01453123f, -0.05191431f, -0.01573197f, -0.12555130f, 
    0.23667461f, 0.00430581f, -0.10626601f, 0.03182702f, -0.09774059f, 0.09224667f, 0.17325267f, -0.12661010f, 
    0.05767665f, 0.04848475f, -0.03749421f, 0.09527976f, -0.25277612f, 0.05862385f, 0.08129101f, 0.17018521f, 
    -0.11576454f, 0.12039513f, -0.09501442f, 0.06472949f, 0.06881874f, 0.07595973f, 0.13977952f, -0.00957498f, 
    -0.02819553f, -0.05606680f, -0.25287023f, 0.20390023f, -0.02486003f, 0.01904142f, 0.09506559f, 0.17618746f, 
    -0.00052214f, -0.06048566f, 0.14107089f, 0.25298294f, -0.05251985f, -0.04157392f, -0.09432664f, -0.06531525f, 
    -0.00868373f, 0.03837246f, -0.00910580f, -0.01221440f, -0.02804729f, -0.12796804f, -0.05790313f, -0.15544707f, 
    -0.14206962f, -0.04166069f, -0.07024474f, 0.07865886f, 0.05411304f, 0.09200703f, 0.00413621f, 0.00306604f, 
    0.05572456f, -0.02406990f, 0.09735285f, 0.01011316f, 0.07025353f, 0.03444036f, 0.00153837f, -0.08740500f, 
    0.00207106f, 0.06946196f, 0.02079400f, -0.05318021f, -0.01042688f, -0.09531245f, -0.01013807f, -0.05557814f, 
    -0.48278090f, -0.38733509f, -0.36271566f, 0.21547008f, 0.07956683f, 0.25912091f, 0.04357422f, -0.04332184f, 
    0.00718459f, -0.04943507f, -0.00144221f, 0.12373662f, -0.49511105f, -0.71039587f, -0.19602560f, -0.02636660f, 
    -0.04422437f, -0.04522390f, -0.06520058f, -0.13570425f, 0.00302401f, -0.02108557f, -0.00812949f, -0.00905063f, 
    0.00924947f, 0.05599776f, -0.04729423f, 0.02203151f, 0.05278021f, 0.11409729f, -0.04477639f, 0.05054240f, 
    -0.04555146f, 0.02307672f, -0.01238886f, 0.01636840f, -0.15957090f, 0.00654195f, -0.45256072f, 0.23967145f, 
    -0.11083947f, 0.04331601f, 0.17181963f, 0.08411305f, 0.07307502f, 0.03186190f, 0.05593692f, -0.09243110f, 
    -0.39121330f, 0.17008725f, 0.33448923f, 0.15862177f, -0.03156338f, -0.06546710f, 0.03386490f, -0.07285661f, 
    -0.17275991f, 0.13026646f, -0.05889039f, 0.05400467f, -0.65539205f, -0.62967700f, -0.29641148f, 0.10034431f, 
    -0.04793788f, -0.01396071f, -0.18787313f, -0.14603700f, -0.03863642f, -0.02954093f, 0.12144169f, -0.06407930f, 
    -0.03498755f, -0.05453434f, -0.02229078f, 0.01675602f, 0.17431325f, -0.02212962f, 0.06393009f, -0.12717763f, 
    0.01458510f, -0.13084094f, -0.01432445f, 0.03881309f, -0.01818433f, 0.01800499f, 0.10052612f, 0.12841181f, 
    -0.00581513f, -0.02322797f, -0.02700478f, 0.05528626f, 0.08455714f, -0.00000350f, 0.04789415f, 0.17899127f, 
    -0.26154703f, -0.09234995f, 0.15763471f, 0.00205800f, 0.05761746f, 0.04135285f, -0.05327195f, 0.00778384f, 
    0.02046990f, 0.07470538f, 0.07314786f, 0.08707909f, 0.18320824f, -0.02379519f, -0.14425588f, -0.04705441f, 
    -0.05923519f, 0.00379388f, 0.22313827f, 0.08883680f, -0.06970778f, -0.09815076f, 0.18635377f, -0.01288234f, 
    -0.13220884f, 0.21659124f, -0.28228894f, 0.06943888f, 0.02480684f, 0.10181133f, -0.09427962f, -0.13420315f, 
    0.02334135f, 0.11508690f, 0.05278740f, 0.02285002f, -0.03574451f, 0.00459193f, 0.11198111f, -0.06326757f, 
    -0.04795862f, -0.04749447f, -0.00348017f, 0.05080160f, 0.00572160f, -0.04538071f, 0.08172249f, -0.09698500f, 
    -0.35502902f, -0.37299502f, 0.18709335f, -0.00441126f, -0.04564795f, 0.08278063f, 0.11509583f, 0.13824397f, 
    -0.09901960f, -0.06763737f, -0.00516744f, 0.00090568f, -0.12834087f, -0.23361102f, -0.01521423f, -0.10159700f, 
    0.00222408f, 0.15468922f, 0.01446749f, -0.05563726f, -0.05302342f, -0.02075318f, 0.00199735f, 0.01129201f, 
    0.18010744f, -0.06078632f, 0.15690519f, -0.16809624f, 0.10321871f, 0.10721081f, 0.09100088f, 0.00835447f, 
    0.06927672f, -0.08177155f, 0.07766140f, -0.04668534f, -0.03730989f, 0.10345145f, 0.14547516f, 0.00634690f, 
    -0.00196292f, -0.21807931f, 0.08187635f, 0.01825134f, -0.11925206f, 0.03157472f, 0.07339010f, 0.05480789f, 
    0.36729705f, 0.22636777f, -0.14416608f, -0.18088800f, -0.01119675f, -0.05283733f, -0.09125657f, -0.02406712f, 
    0.11177662f, 0.19307899f, 0.00605652f, -0.04998309f, -0.14761163f, -0.29821888f, 0.27219495f, 0.04846343f, 
    -0.05174614f, 0.02272838f, -0.01630163f, 0.12383854f, -0.00614458f, -0.09069443f, -0.03209644f, 0.06643766f, 
    0.14858802f, -0.43289325f, -0.02924507f, -0.39934343f, 0.05315800f, 0.07532484f, -0.11013188f, 0.13295111f, 
    0.06662951f, -0.09477474f, 0.06267759f, 0.06916957f, -0.21670556f, -0.43628588f, 0.23890805f, -0.30128303f, 
    -0.05354308f, -0.11834981f, 0.17496756f, -0.01368294f, -0.06863058f, -0.00662905f, 0.05260452f, -0.00166293f, 
    -0.02497765f, 0.03864570f, 0.07084764f, -0.00059696f, -0.04723304f, 0.00748149f, 0.02131521f, -0.01013437f, 
    0.00581475f, -0.07361334f, 0.03003620f, -0.12402832f, 0.04076236f, 0.05126222f, -0.05811588f, 0.03070085f, 
    -0.02403015f, 0.02520174f, 0.00643635f, -0.05954265f, 0.01431773f, 0.04437291f, 0.05761325f, -0.09627525f, 
    -0.18843345f, -0.02906290f, -0.08654971f, 0.11403315f, 0.07115814f, 0.01317929f, 0.10200526f, 0.08855072f, 
    0.14234066f, 0.04504624f, 0.11917637f, -0.00384074f, -0.53419065f, -0.46345365f, -0.37601012f, -0.11205772f, 
    -0.10114219f, -0.02907608f, 0.11102825f, -0.22599751f, -0.04693010f, 0.01763869f, -0.04313815f, -0.03450829f, 
    -0.14738816f, 0.05381921f, 0.14321518f, 0.08722237f, -0.08724065f, 0.04896917f, 0.00494246f, -0.03498330f, 
    -0.03845962f, -0.01961505f, -0.05745491f, -0.07549801f, -0.02655682f, -0.46337071f, -0.11374492f, -0.11659696f, 
    -0.03976597f, 0.03057051f, 0.00307506f, 0.11364734f, 0.05079399f, -0.01196436f, 0.00620230f, -0.00470955f, 
    0.32515660f, -0.00832860f, -0.30059996f, -0.27582157f, -0.03013320f, 0.02491882f, -0.14357284f, 0.01114468f, 
    0.13366188f, -0.02395012f, -0.08796567f, 0.07232083f, -0.16143058f, -0.02583831f, -0.01137501f, 0.09021332f, 
    -0.04344145f, -0.13361879f, 0.08217841f, 0.13333113f, 0.06736320f, 0.07187951f, -0.02316712f, 0.01659980f, 
    0.05562973f, 0.07004742f, 0.00834544f, 0.02156333f, 0.05713090f, 0.00866558f, -0.05328429f, -0.04383473f, 
    -0.23354174f, 0.06043659f, -0.19930194f, 0.09746542f, 0.19111273f, -0.13116427f, 0.24114837f, -0.19190201f, 
    -0.11832698f, 0.03833887f, -0.12706694f, 0.08773264f, -0.08557110f, 0.05509816f, 0.01976156f, -0.02596783f, 
    -0.46177962f, -0.02606193f, -0.50196475f, -0.01626389f, 0.05326350f, -0.11350586f, -0.00957726f, -0.02087970f, 
    -0.07472162f, -0.00743586f, 0.05478911f, 0.05901462f, -0.04850038f, -0.09632429f, 0.03962182f, -0.07048941f, 
    -0.00921283f, -0.03114020f, 0.01835456f, 0.01546050f, -0.00648709f, 0.19111250f, 0.11158650f, -0.04421932f, 
    0.54731613f, 0.37774962f, -0.41086653f, -0.11748191f, -0.22031072f, 0.18373823f, -0.13690530f, -0.11021405f, 
    -0.05012882f, 0.08849110f, 0.06929830f, -0.01370357f, 0.24786435f, 0.23552777f, -0.24181254f, -0.25813580f, 
    -0.03776832f, -0.04549751f, 0.05194512f, 0.05962083f, -0.01539920f, -0.01411786f, -0.17091177f, 0.01105624f, 
    -0.31097296f, -0.26291978f, -0.11094740f, 0.04488203f, 0.05627970f, -0.06320590f, 0.05573192f, 0.11983147f, 
    -0.00732222f, 0.02261144f, -0.04875825f, -0.00444750f, -0.19402385f, -0.28382668f, -0.08451962f, 0.14697701f, 
    -0.00818636f, -0.04871224f, 0.07971781f, -0.08624430f, -0.04757227f, -0.02797915f, 0.12017595f, -0.00061911f, 
    0.06430198f, 0.02116469f, 0.02137377f, -0.03241672f, 0.01584538f, -0.02754717f, -0.00498059f, -0.03417352f, 
    0.11494441f, -0.05211623f, -0.09397869f, -0.06539997f, -0.02915498f, 0.07021399f, -0.08882190f, -0.05247778f, 
    -0.06395355f, 0.05809595f, -0.03461544f, -0.14962538f, -0.11054725f, 0.05652074f, 0.01852222f, 0.01433218f, 
    -0.05802479f, 0.07244291f, -0.09467301f, 0.02658266f, -0.07474566f, 0.02205169f, 0.07001057f, -0.02174916f, 
    0.02779701f, 0.01534964f, 0.00166056f, -0.05520216f, -0.53194386f, 0.69734991f, -0.18680824f, 0.27834904f, 
    0.08936428f, -0.16099091f, 0.14852445f, -0.00501257f, -0.05449921f, -0.06138913f, -0.05090888f, 0.02233808f, 
    0.10625786f, 0.05444144f, -0.01276648f, -0.11944309f, -0.07345307f, -0.03362298f, -0.04600017f, -0.05624210f, 
    0.08978354f, 0.07750467f, 0.06777922f, 0.00831572f, -0.05612864f, -0.07154264f, 0.13079090f, -0.00143724f, 
    0.02125433f, -0.18752302f, -0.15329468f, -0.10373219f, 0.00664812f, 0.00173413f, -0.00101606f, 0.02858034f, 
    0.14217573f, -0.00617582f, -0.04214167f, 0.01236712f, -0.08012491f, 0.03046371f, 0.01782973f, -0.04453460f, 
    0.02072191f, -0.05162102f, -0.10943557f, -0.03422388f, -0.29553020f, -0.22703935f, -0.07012819f, -0.05601455f, 
    -0.13985218f, 0.04369406f, -0.04572045f, -0.11807264f, 0.10434462f, -0.10260130f, 0.03355661f, -0.04827208f, 
    0.05972451f, -0.06194747f, -0.08109001f, 0.01833259f, -0.08480869f, 0.07723372f, 0.07848792f, 0.00934696f, 
    -0.01021518f, 0.04419218f, 0.03910639f, -0.00985252f, 0.00642789f, 0.08727513f, 0.04128749f, -0.02935697f, 
    -0.10472196f, -0.04824854f, -0.01248857f, 0.00817031f, 0.01830657f, -0.04188559f, 0.08025981f, -0.02770103f, 
    -0.53640968f, -0.36863354f, 0.13533039f, 0.47182071f, -0.11816454f, -0.00038022f, -0.05287734f, 0.05306960f, 
    -0.02930632f, -0.08847963f, -0.07583562f, -0.01420340f, 0.12307094f, -0.04491859f, 0.06218666f, -0.15326864f, 
    0.05051541f, 0.10527229f, -0.04976279f, 0.02838322f, -0.00124894f, 0.03010507f, -0.00238279f, -0.01788433f, 
    0.03142390f, -0.05101773f, 0.06876837f, -0.10579819f, 0.00985090f, -0.03558254f, -0.01373045f, -0.04229341f, 
    0.09472872f, 0.01535017f, 0.06066522f, -0.07406215f, -0.23807515f, -0.19820283f, -0.02196704f, -0.17244485f, 
    -0.02605419f, -0.15715967f, 0.08984467f, -0.05369742f, 0.01560985f, -0.12404975f, 0.08366631f, -0.03531085f, 
    0.15384029f, 0.10326122f, -0.06930150f, -0.25976357f, 0.01194074f, 0.04163016f, 0.04547095f, -0.00612061f, 
    0.03359480f, -0.00618944f, 0.03564921f, -0.01752390f, -0.05756374f, 0.10862076f, -0.04433174f, -0.08979905f, 
    0.02483213f, 0.01650875f, 0.07544008f, -0.02172271f, 0.08342646f, 0.05766704f, 0.05252589f, -0.02115518f, 
    -0.00561989f, 0.04949193f, 0.04325856f, 0.07123055f, -0.00327543f, 0.00731585f, 0.02434863f, 0.03310847f, 
    -0.02278501f, 0.05978807f, 0.05264690f, 0.09750538f, 0.15086870f, -0.12390751f, -0.03282612f, -0.09103176f, 
    -0.01422763f, 0.00268589f, 0.00096078f, 0.02432361f, 0.15617083f, 0.11607333f, 0.02248459f, 0.02175835f, 
    0.10326391f, 0.12261219f, -0.06569487f, 0.00559372f, 0.00062957f, 0.03117649f, -0.02980740f, -0.04207353f, 
    -0.18057233f, -0.10680083f, -0.25111711f, -0.08994178f, -0.58380491f, 0.34467736f, 0.42665488f, -0.05839957f, 
    0.05129377f, -0.14407316f, 0.02922060f, -0.03502700f, -0.00900815f, -0.02476941f, -0.07386227f, -0.03695369f, 
    0.00044507f, -0.06730638f, 0.09333333f, 0.00202155f, -0.05564735f, -0.12619537f, 0.03135526f, -0.28515121f, 
    -0.03582811f, 0.02586667f, 0.06885254f, 0.00267333f, -0.43845308f, 0.10585445f, -0.05882718f, 0.41105559f, 
    -0.10017117f, 0.02234895f, 0.20355956f, 0.02651897f, 0.02770741f, -0.01179560f, 0.01252742f, 0.04014353f, 
    -0.05916921f, 0.05708699f, -0.16852769f, 0.06982120f, -0.01602040f, 0.09286690f, 0.13556987f, -0.10587951f, 
    0.00657091f, 0.13544749f, 0.04030256f, 0.04378612f, 0.61582345f, -0.15292725f, 0.03249052f, -0.20062834f, 
    0.04510909f, 0.06385104f, -0.07696342f, -0.06690583f, -0.11511222f, 0.03757729f, -0.08017223f, -0.05891352f, 
    0.26033700f, -0.53887105f, 0.14830816f, -0.08705758f, -0.03811315f, -0.00617336f, 0.03998146f, -0.08081289f, 
    0.11326258f, -0.01550787f, 0.06452919f, 0.22408482f, 0.03639192f, -0.00603031f, 0.03173142f, -0.11274310f, 
    0.02491005f, -0.00609354f, -0.01863557f, 0.01047111f, 0.06595642f, 0.04278284f, 0.02299622f, -0.08733275f, 
    0.15312403f, -0.12221421f, 0.08748394f, -0.02398706f, 0.06054310f, 0.11740857f, -0.06583461f, -0.05328401f, 
    -0.12330996f, 0.01887286f, -0.07165267f, -0.03245057f, 0.03495349f, 0.05855952f, 0.03885279f, -0.04973673f, 
    -0.03240901f, 0.05056423f, 0.00776163f, 0.00968777f, 0.05112457f, 0.00145965f, -0.00455401f, -0.04415620f, 
    -0.02962413f, -0.07687780f, 0.01196971f, -0.05190717f, -0.12657638f, -0.09767355f, 0.04740526f, 0.04467023f, 
    0.02937296f, -0.02321267f, 0.05773709f, -0.02465893f, -0.06494135f, -0.30216917f, -0.25474191f, -0.27723894f, 
    0.05908457f, -0.14805834f, -0.06641102f, 0.06168655f, 0.04858126f, -0.00120616f, -0.06344595f, 0.07315669f, 
    0.14559352f, 0.00079333f, -0.00648592f, -0.11863106f, -0.03237048f, 0.01216062f, -0.08134010f, -0.01113100f, 
    0.03064432f, 0.06104296f, 0.00948083f, -0.04243198f, -0.49316835f, -0.35469544f, -0.19250259f, -0.07557777f, 
    0.00512615f, 0.16347629f, 0.23726740f, 0.04677181f, -0.00342739f, 0.03477415f, 0.00491793f, 0.00116379f, 
    0.37348759f, -0.15562057f, -0.10854813f, -0.19142704f, -0.10150418f, -0.01117872f, -0.09151761f, 0.02989978f, 
    0.06746019f, -0.02662268f, 0.06058520f, 0.01463032f, -0.11085835f, -0.28507379f, 0.28328553f, 0.22435525f, 
    -0.02560956f, -0.00965232f, 0.03477513f, 0.05481053f, 0.01145816f, -0.07908230f, -0.09034306f, -0.08667834f, 
    0.09341386f, 0.12648833f, 0.06020779f, -0.07186326f, 0.05946653f, -0.04319088f, -0.03280941f, -0.02522864f, 
    -0.07924651f, -0.03137180f, -0.00388242f, -0.03640540f, 0.24244669f, 0.01866012f, 0.01656580f, -0.37072587f, 
    0.07687896f, -0.00001118f, 0.01437447f, -0.04395387f, -0.11534727f, 0.03170506f, -0.20570265f, -0.14943776f, 
    0.11088133f, 0.16209458f, -0.06156906f, -0.19392741f, 0.03568407f, 0.04489719f, 0.00996648f, 0.02818656f, 
    -0.14187303f, 0.01194003f, -0.14428696f, -0.14760734f, 0.05309805f, 0.00348680f, -0.09126259f, 0.08017042f, 
    -0.00590091f, -0.00458146f, 0.00664624f, -0.09975857f, 0.01809927f, 0.10502392f, -0.07279590f, 0.09435323f, 
    -0.09575734f, 0.25600821f, 0.12092204f, 0.04776962f, 0.03301431f, 0.02938240f, 0.01863960f, 0.13793887f, 
    -0.19390713f, -0.04437994f, -0.05573585f, -0.03350840f, -0.07880818f, 0.01145661f, 0.00309654f, -0.11563640f, 
    -0.03044889f, 0.06226565f, -0.02552918f, 0.01525001f, 0.15375000f, 0.07820038f, 0.04643787f, 0.10104831f, 
    0.08757439f, -0.11068720f, -0.01354298f, 0.08664244f, 0.09192163f, -0.02545957f, 0.07733489f, -0.05087610f, 
    0.01916381f, -0.09499292f, -0.02298163f, -0.06490383f, -0.06797563f, -0.14959751f, 0.10703180f, 0.37121376f, 
    -0.07594245f, -0.03848181f, -0.05645564f, -0.01891523f, -0.00604174f, 0.09546703f, 0.11273213f, 0.00375297f, 
    -0.31018603f, -0.16958164f, 0.12750007f, 0.23477358f, -0.02895082f, -0.01641696f, 0.00597850f, -0.01869804f, 
    -0.01081242f, 0.23111792f, 0.12735283f, 0.21127033f, -0.19065119f, -0.05738891f, 0.10125122f, 0.13912590f, 
    0.02548207f, 0.03244879f, -0.08082242f, -0.10979373f, -0.01963719f, -0.07827757f, -0.08317941f, 0.03711288f, 
    0.07141242f, 0.14189823f, -0.27535483f, -0.04284810f, -0.03580448f, -0.07580996f, 0.05416223f, 0.08180539f, 
    -0.10028389f, -0.08364357f, -0.08269501f, -0.06632634f, 0.13279496f, 0.14908189f, -0.29143813f, -0.39373422f, 
    -0.14150485f, -0.11768821f, 0.01642931f, -0.20733339f, 0.05753711f, 0.00062746f, 0.01787242f, -0.02942652f, 
    0.03015777f, -0.30085564f, -0.28525150f, 0.06860022f, 0.16456302f, 0.05821143f, 0.07258939f, 0.08327854f, 
    0.01134573f, 0.09331252f, -0.03976268f, -0.14071736f, -0.24158768f, -0.72366852f, -0.25386405f, 0.09632382f, 
    -0.09259990f, 0.16971551f, 0.14574653f, 0.07976163f, 0.07196055f, -0.13864997f, -0.01146886f, 0.02419749f, 
    -0.02031100f, 0.01371560f, 0.10898802f, 0.00647377f, 0.04473426f, -0.00269244f, -0.09395516f, 0.00593652f, 
    0.00437793f, 0.16660674f, -0.01478795f, 0.11825323f, -0.23695114f, 0.10336564f, 0.13401654f, 0.13724470f, 
    0.01822462f, -0.02837500f, -0.01743451f, 0.04343447f, -0.01299497f, -0.13807984f, -0.05567902f, -0.15736634f, 
    -0.23875368f, -0.10727019f, -0.08991967f, 0.01084080f, 0.03549830f, 0.00566011f, -0.06699420f, 0.10546733f, 
    -0.13042518f, 0.03197655f, -0.08608860f, -0.18245599f, -0.33170223f, -0.18886450f, -0.20520559f, 0.06520864f, 
    0.29140756f, 0.15774374f, 0.06158713f, 0.10594141f, -0.07661700f, -0.00757351f, 0.00588256f, -0.01371956f, 
    -0.35999757f, 0.01203265f, 0.00864486f, 0.11719126f, 0.16738915f, -0.03826450f, -0.05751564f, 0.04315504f, 
    -0.00361767f, 0.11125646f, 0.15120365f, 0.14183092f, -0.15591602f, -0.16363099f, -0.32658523f, 0.18972808f, 
    0.09359755f, 0.02183691f, 0.17916243f, 0.07678858f, -0.15456258f, -0.08140341f, -0.11364270f, -0.09827695f, 
    -0.37360135f, -0.27677837f, -0.15655421f, 0.01199870f, -0.02969284f, 0.07675294f, -0.02407803f, 0.01050700f, 
    0.04468136f, 0.14256532f, -0.02382994f, -0.08131682f, 0.28331709f, 0.03840763f, -0.15460199f, -0.15568905f, 
    -0.06543329f, -0.08735052f, -0.25639692f, -0.14995150f, 0.01597775f, 0.12988167f, 0.06418897f, 0.09597417f, 
    0.05319081f, 0.03533823f, 0.04659033f, -0.03857077f, 0.00953208f, -0.00298417f, 0.06227199f, 0.00125937f, 
    0.00198964f, 0.02893157f, 0.06211599f, 0.09904388f, -0.02148015f, -0.18788892f, 0.09069762f, -0.05302556f, 
    -0.09788261f, 0.12459151f, 0.19719878f, -0.00491546f, 0.07770452f, -0.14441870f, 0.11531463f, -0.10665772f, 
    -0.13206621f, -0.27469012f, -0.04583051f, 0.05698916f, -0.09658319f, 0.12722912f, 0.20367230f, 0.07463077f, 
    0.01948933f, 0.02478875f, 0.10074539f, 0.04210011f, -0.03563813f, -0.10815791f, 0.02084499f, 0.00741835f, 
    0.01317853f, -0.01337792f, -0.07749337f, 0.03277105f, -0.10750051f, -0.08229399f, -0.37411502f, -0.30391815f, 
    0.22782519f, 0.14603870f, -0.23124129f, -0.13785028f, 0.01358379f, -0.10558552f, 0.08770901f, 0.16582516f, 
    0.05927710f, -0.02427115f, 0.04660406f, -0.00881025f, 0.22892646f, 0.02839452f, -0.20999669f, -0.10981233f, 
    -0.03472970f, 0.04305868f, 0.05884033f, 0.04395445f, 0.03858831f, -0.07735894f, 0.10459508f, 0.07460020f, 
    -0.35387737f, -0.45496953f, -0.17574672f, -0.02048736f, 0.04336498f, 0.00847782f, 0.01412807f, -0.00090146f, 
    -0.04109168f, 0.03850247f, 0.01309922f, 0.09653354f, -0.35070455f, 0.11008706f, -0.03467827f, 0.22008695f, 
    0.11889566f, -0.02115348f, 0.11373618f, 0.00987129f, -0.03591536f, 0.08021107f, 0.14603643f, 0.25474414f, 
    -0.40216169f, 0.05176359f, 0.00999064f, -0.24282807f, -0.08588915f, -0.06534266f, -0.02579584f, -0.03422468f, 
    -0.05756436f, -0.02007613f, -0.02129621f, 0.07025525f, -0.04924089f, 0.08577667f, 0.09740166f, 0.06349909f, 
    0.08055242f, -0.03427178f, 0.02279096f, -0.00692094f, 0.14157066f, -0.04682973f, 0.13143077f, 0.07641756f, 
    -0.34981716f, 0.03657957f, 0.24667397f, 0.08655843f, 0.09104457f, -0.17665470f, 0.00358536f, -0.02710783f, 
    -0.04064640f, -0.08050201f, 0.02808630f, -0.09607325f, -0.33249211f, -0.28421286f, -0.35517722f, -0.07019446f, 
    -0.01896331f, 0.07975591f, 0.04797162f, -0.01206345f, 0.05843662f, 0.03751739f, 0.10730565f, -0.02145536f, 
    -0.19835214f, 0.14067253f, 0.09042141f, 0.05346592f, 0.02985786f, 0.02769525f, -0.12793423f, -0.08477649f, 
    -0.03454068f, -0.11202269f, -0.04184982f, -0.07329529f, 0.13819891f, -0.00123547f, 0.04979141f, -0.00952107f, 
    0.03810489f, -0.08414763f, -0.05261832f, -0.08064771f, 0.09775785f, 0.17609331f, 0.08122935f, 0.07290121f, 
    0.30629969f, 0.02399477f, -0.15278292f, -0.10210428f, 0.03789666f, -0.03998507f, -0.02962611f, -0.03964493f, 
    0.08419579f, -0.03543949f, -0.06247085f, -0.00542126f, 0.02217716f, -0.02416231f, -0.03499586f, 0.30507442f, 
    0.15796112f, 0.21364842f, 0.00512595f, 0.02246813f, -0.11784120f, 0.07654740f, -0.14743435f, -0.09358426f, 
    0.04938787f, 0.01631483f, -0.04335528f, 0.06087051f, 0.07054232f, -0.10704779f, -0.00657754f, -0.02033289f, 
    0.05271638f, 0.09006771f, 0.13940260f, 0.13660754f, -0.30615747f, -0.02235841f, 0.12561300f, 0.05167279f, 
    -0.03858521f, -0.05012945f, -0.12588960f, -0.00306412f, 0.08433200f, 0.06544396f, -0.04301535f, 0.00571457f, 
    0.16561238f, -0.21693555f, -0.29263866f, -0.12633905f, 0.12183145f, -0.09657707f, 0.07234772f, 0.12078723f, 
    0.14455581f, 0.13586405f, 0.17254865f, 0.06888209f, -0.03026104f, -0.02464452f, -0.01522902f, -0.00416610f, 
    0.04262179f, -0.01253961f, -0.05874168f, 0.05195368f, 0.06365965f, 0.06508815f, 0.10476214f, 0.07538950f, 
    -0.06480329f, -0.00284023f, -0.00089050f, -0.11771484f, -0.02885199f, -0.05265293f, -0.00883932f, -0.03893645f, 
    0.04855904f, 0.06184275f, -0.00631493f, 0.10288510f, 0.13208735f, -0.28621426f, -0.02985597f, 0.05558844f, 
    0.02867277f, 0.16790715f, 0.13735275f, 0.11186294f, -0.16488717f, -0.10676260f, -0.04503713f, -0.06513017f, 
    0.12669699f, -0.10204780f, -0.04830449f, -0.12651408f, -0.10992142f, -0.09456056f, 0.03186702f, -0.04989041f, 
    0.01086759f, 0.01823018f, -0.13003449f, -0.13695604f, -0.66508317f, 0.12049082f, 0.12066081f, 0.12131800f, 
    -0.05444285f, -0.07564475f, -0.11823674f, -0.06623992f, 0.02600537f, 0.01105901f, 0.01423284f, 0.08263689f, 
    -0.30125573f, -0.21369185f, -0.17926283f, -0.05658331f, 0.11699948f, 0.14648780f, 0.07352375f, -0.04708383f, 
    -0.03469721f, 0.16008358f, -0.01292223f, 0.12952626f, -0.01833354f, -0.00032650f, -0.02347762f, 0.01633579f, 
    -0.04198126f, -0.00887084f, -0.01099386f, -0.00510525f, -0.06885967f, -0.13139634f, -0.10363527f, -0.27820292f, 
    0.12967703f, 0.04411536f, -0.01703058f, -0.20579137f, -0.00302378f, -0.00419275f, -0.00612047f, 0.05920791f, 
    0.04923831f, -0.01139844f, 0.09566628f, 0.09764212f, -0.44704580f, -0.36342153f, -0.18795119f, -0.07799992f, 
    -0.07438461f, 0.13663310f, 0.10085979f, -0.16764665f, 0.00714135f, 0.00375731f, 0.10263592f, 0.08858786f, 
    0.11762863f, -0.13493612f, -0.06056830f, -0.00652050f, 0.10498171f, 0.03226510f, -0.05803578f, 0.10346857f, 
    0.04535518f, 0.14790082f, 0.03301561f, 0.09886569f, -0.67286259f, -0.15586233f, -0.00603414f, 0.21714170f, 
    0.19993110f, 0.01216804f, -0.10450623f, 0.09058201f, -0.02346095f, 0.02713723f, 0.15182514f, 0.13697428f, 
    -0.22835337f, -0.14025329f, 0.06061205f, 0.15801148f, 0.10829739f, 0.07269420f, -0.16540459f, -0.01064244f, 
    -0.26115915f, -0.05747683f, -0.13610588f, -0.39823130f, 0.07967647f, -0.02662402f, -0.28169698f, -0.28807393f, 
    0.11852179f, -0.11660983f, 0.17743939f, 0.03368349f, 0.08187205f, -0.07627285f, -0.01789796f, -0.01123781f, 
    0.40694651f, 0.14187790f, 0.06521599f, -0.09774105f, 0.06553129f, 0.00818150f, 0.07433310f, 0.00188230f, 
    0.12029693f, 0.03740142f, -0.01472193f, -0.24845652f, -0.23960027f, 0.06181423f, -0.01079534f, -0.21357818f, 
    -0.05998860f, -0.09399095f, -0.04934914f, -0.05857632f, -0.00719509f, -0.00305270f, 0.01585003f, 0.03562512f, 
    -0.13444184f, 0.01599967f, -0.09476160f, -0.15300353f, 0.13345940f, 0.02833718f, 0.06561761f, -0.00639161f, 
    -0.04554430f, -0.17371204f, -0.07427877f, -0.05804481f, -0.22535047f, 0.07657629f, 0.06835784f, -0.14459717f, 
    -0.06754146f, -0.07499810f, -0.09163471f, -0.06367235f, -0.04007455f, 0.03687360f, 0.00700360f, 0.05880167f, 
    0.06091066f, 0.20431802f, 0.02670380f, -0.08384942f, 0.11476416f, -0.09450388f, 0.04072342f, -0.24310565f, 
    0.05711457f, -0.02774444f, -0.03155480f, -0.01635206f, -0.09382241f, -0.39499581f, -0.44106799f, 0.03097535f, 
    0.02077855f, 0.10448858f, 0.07041639f, 0.01222635f, -0.06064310f, -0.01277632f, 0.02882664f, 0.03694050f, 
    0.11939409f, 0.18505371f, 0.06027859f, -0.20534195f, -0.03231095f, -0.07806943f, -0.09352710f, -0.02371350f, 
    -0.09062868f, -0.08413378f, -0.11009903f, -0.08312568f, -0.31455034f, -0.26743549f, 0.08704714f, 0.34267241f, 
    -0.00112140f, 0.02459888f, 0.00372916f, -0.07421001f, 0.02704263f, -0.02467464f, 0.00902258f, 0.13865101f, 
    -0.44590867f, -0.33143207f, -0.24151416f, 0.11209372f, -0.04350213f, 0.12546346f, 0.10423005f, 0.12949808f, 
    0.11925724f, 0.04012658f, -0.07911932f, -0.04882590f, 0.31943735f, -0.18147172f, -0.25507337f, -0.28929785f, 
    -0.09069266f, -0.29642102f, -0.03584345f, -0.11001174f, 0.00885361f, 0.03144345f, 0.07324213f, 0.10279039f, 
    -0.01249703f, 0.05613034f, -0.02473907f, -0.05044891f, -0.06946641f, -0.04779070f, 0.09782857f, -0.02848433f, 
    0.04044618f, 0.02309180f, 0.06958738f, 0.05928348f, 0.27047631f, -0.05826361f, -0.05298623f, -0.17995209f, 
    -0.00087739f, -0.08272936f, 0.02925697f, -0.06156344f, 0.15539117f, 0.04997442f, 0.12325384f, 0.05501027f, 
    -0.01834431f, 0.02429338f, -0.04804095f, -0.16945389f, -0.15935653f, -0.01863872f, 0.03175071f, 0.04123645f, 
    0.14427879f, 0.03043941f, 0.09610191f, 0.13157691f, -0.17366834f, -0.01108394f, 0.05487405f, 0.02412256f, 
    -0.03776088f, -0.02968123f, -0.07598191f, -0.03999750f, -0.11960687f, -0.12315976f, -0.00951759f, -0.11326054f, 
    -0.62262493f, 0.37854823f, -0.78801733f, -0.05951142f, 0.07255881f, -0.07529020f, 0.18390267f, -0.07960083f, 
    0.11992548f, -0.05504471f, -0.07270151f, -0.03842787f, 0.15651733f, -0.05071224f, -0.09323221f, -0.07292613f, 
    -0.00997357f, 0.00169236f, -0.04937977f, -0.01262262f, 0.07733154f, -0.22760075f, -0.03989216f, -0.04098329f, 
    0.04743373f, -0.01110523f, 0.27249300f, -0.06531329f, -0.06053634f, -0.08817455f, 0.06635576f, 0.13431104f, 
    -0.07671930f, 0.11180960f, 0.01424423f, 0.02280285f, -0.05525237f, -0.11159808f, 0.03661823f, -0.40174526f, 
    0.10020532f, -0.09896319f, 0.01375720f, -0.00581814f, -0.07150324f, 0.03042118f, 0.09030071f, -0.08937719f, 
    0.19979517f, -0.05818661f, 0.21043611f, -0.20773561f, -0.02855737f, -0.00062365f, -0.02377458f, -0.04832143f, 
    -0.12626798f, 0.15388088f, -0.04328642f, -0.19488990f, 0.20170470f, -0.42209613f, 0.06740320f, -0.52176481f, 
    0.12253550f, 0.12736312f, -0.17027053f, 0.15377024f, 0.11382915f, -0.05789205f, -0.12643836f, -0.04984640f, 
    -0.20686771f, 0.01489448f, -0.05120422f, 0.41377610f, 0.04730232f, -0.00424167f, -0.08541507f, -0.06528207f, 
    0.11352037f, 0.04206306f, 0.00641132f, 0.03466505f, -0.35846481f, 0.02511057f, 0.12385242f, 0.07900099f, 
    -0.03720351f, 0.02250918f, 0.02923578f, -0.07312266f, 0.13547303f, 0.09775179f, 0.01165059f, 0.05166093f, 
    0.24516341f, -0.11056063f, 0.13186637f, -0.12727894f, -0.02389815f, 0.07119159f, -0.06916597f, -0.11526349f, 
    0.07420148f, 0.10014496f, -0.07907107f, 0.06995612f, 0.14180042f, -0.44475153f, -0.22665122f, -0.17883427f, 
    -0.14922655f, -0.08638191f, -0.16709676f, 0.12353680f, -0.08495267f, 0.02958271f, -0.01800569f, 0.10954556f, 
    -0.09590266f, 0.04829980f, -0.10693131f, 0.05246309f, 0.09966215f, 0.13668288f, -0.04445207f, 0.00157500f, 
    0.19964747f, -0.11190245f, -0.19681634f, -0.10958771f, -0.07437576f, -0.00046445f, -0.11468539f, 0.06863385f, 
    0.06543217f, -0.07418738f, 0.07780065f, 0.05243073f, -0.05359951f, -0.02152811f, -0.01191085f, 0.03055143f, 
    0.15690240f, 0.28522998f, 0.01586032f, -0.18480271f, -0.08454099f, 0.05758950f, 0.16532782f, 0.11303703f, 
    0.01299210f, 0.08519213f, 0.02799412f, 0.02597718f, -0.00503716f, 0.25022256f, 0.14244618f, -0.38749713f, 
    -0.09048431f, -0.34282485f, 0.00209918f, -0.18132220f, -0.01715096f, 0.03843875f, 0.00254034f, 0.05699054f, 
    0.01497451f, 0.44993529f, -0.39726463f, -0.28300658f, -0.13796528f, -0.03723394f, 0.11360774f, -0.11061131f, 
    0.09173974f, 0.08047504f, -0.04768711f, 0.03511640f, 0.07811436f, -0.10170354f, 0.03294234f, -0.13788180f, 
    -0.03974378f, 0.00379480f, 0.00754703f, -0.00630528f, 0.11079402f, 0.03140339f, -0.03961520f, 0.05372767f, 
    -0.09658021f, 0.31381902f, -0.09375660f, 0.14188041f, -0.05441285f, -0.09787854f, -0.10710508f, -0.04027464f, 
    -0.01864453f, -0.01343383f, -0.02628251f, 0.15430982f, 0.16881366f, -0.35239768f, -0.03345732f, -0.03753614f, 
    0.17975394f, 0.15321641f, -0.20004842f, 0.12602685f, -0.05314699f, -0.12151244f, -0.04710394f, -0.07402190f, 
    -0.06479669f, 0.01692884f, -0.18240200f, 0.10873571f, 0.00068191f, -0.04864338f, 0.03774706f, -0.03239012f, 
    0.09196987f, -0.00257822f, 0.04057515f, -0.06908132f, 0.13457228f, -0.18463495f, -0.07193015f, -0.44271213f, 
    -0.23353693f, -0.06567723f, -0.24148525f, -0.09093970f, -0.15938917f, -0.28931600f, -0.02443902f, 0.05656527f, 
    -0.11407997f, 0.28689399f, 0.14197060f, -0.25504735f, 0.04112009f, -0.25390136f, -0.05190619f, 0.05690321f, 
    -0.17194071f, -0.09435807f, 0.10418328f, 0.06526694f, 0.09358978f, -0.18590276f, 0.05304043f, -0.12382466f, 
    -0.11944006f, 0.12903640f, -0.03313040f, 0.08601362f, 0.06887837f, 0.09085635f, 0.06108912f, 0.24314882f, 
    -0.86161286f, 0.30464235f, -0.32870424f, 0.40855679f, -0.14469638f, 0.05809376f, -0.24021152f, 0.09747873f, 
    0.12712590f, -0.17042749f, 0.04650861f, -0.02172868f, -0.26820859f, -0.04520835f, -0.17426147f, 0.26844513f, 
    0.13664700f, -0.08356418f, -0.19714600f, 0.11724208f, -0.02630415f, -0.14882125f, -0.04721053f, 0.01377766f, 
    -0.08867209f, 0.07364907f, -0.05769115f, -0.12447295f, -0.23999453f, -0.00550483f, 0.12745202f, 0.21942258f, 
    -0.04938830f, 0.06782433f, -0.01524867f, -0.00519703f, -0.01123383f, 0.28427196f, 0.67941046f, -0.55875713f, 
    0.09847210f, -0.08771541f, 0.11226707f, -0.13385586f, -0.10173372f, -0.00726633f, -0.01029402f, 0.05497998f, 
    -0.13534212f, 0.02494816f, 0.08980492f, 0.15637033f, 0.13648695f, -0.01860805f, 0.00256021f, -0.00174295f, 
    0.12802915f, 0.10686632f, 0.21842848f, 0.02734173f, -0.14059880f, 0.06007444f, -0.11735210f, -0.21757397f, 
    0.07983056f, -0.03468841f, 0.06687219f, 0.08510303f, -0.16085185f, 0.01578782f, 0.09066873f, -0.03730782f, 
    -0.27357024f, 0.06711109f, -0.17701624f, 0.14924917f, 0.18126513f, -0.08186488f, 0.03602452f, -0.15071194f, 
    0.02821418f, -0.05733554f, -0.06203736f, -0.20005156f, -0.09395671f, -0.11767561f, -0.05705492f, -0.04645512f, 
    0.05275004f, 0.07531837f, 0.07168738f, 0.02173172f, 0.12429114f, 0.09009947f, 0.11806466f, 0.08553313f, 
    0.16573133f, -0.35920456f, -0.48977020f, -0.21199287f, 0.01025129f, 0.11184935f, 0.14867947f, 0.08861542f, 
    -0.06006165f, -0.04811320f, 0.02894478f, -0.01574990f, -0.02931977f, -0.16765586f, -0.11677908f, -0.07989050f, 
    0.10120492f, -0.03694385f, 0.04445933f, 0.09160820f, -0.03690149f, -0.06414661f, -0.01747368f, -0.07929634f, 
    -0.14010827f, 0.13370693f, 0.00351672f, 0.16947792f, 0.00609812f, -0.03269296f, -0.06349920f, -0.21481846f, 
    0.13825363f, 0.15086095f, 0.07358424f, -0.01736860f, -0.04158393f, 0.24643612f, 0.15156551f, -0.36150220f, 
    -0.12976211f, -0.11698674f, -0.11584102f, 0.01398653f, 0.14809217f, 0.01964631f, 0.04681183f, -0.01015728f, 
    -0.20852606f, 0.07451343f, -0.08573498f, -0.07449344f, -0.02886878f, -0.19429964f, 0.12363146f, -0.09922020f, 
    -0.06283076f, -0.02645379f, -0.06201315f, -0.08213449f, 0.16323122f, 0.11163233f, -0.13575368f, -0.11209884f, 
    0.05968296f, 0.08939672f, 0.07938617f, 0.23800652f, 0.05642327f, 0.03157414f, -0.05812231f, -0.11887781f, 
    -0.11805661f, 0.08529177f, -0.13381621f, 0.09594694f, -0.10288806f, -0.09910277f, 0.07865590f, 0.12740882f, 
    -0.02289440f, 0.02318548f, -0.00671627f, 0.00943593f, 0.03951694f, -0.01154955f, 0.06802945f, -0.05763829f, 
    -0.03932200f, 0.10674024f, 0.03518926f, -0.14210300f, 0.11689021f, -0.15022536f, -0.08145055f, -0.02893031f, 
    0.05224363f, -0.25938007f, -0.24469166f, -0.12051469f, 0.12904747f, -0.05725528f, 0.09913155f, 0.12151630f, 
    0.02749290f, -0.00011563f, 0.00775008f, -0.09947151f, 0.08000507f, -0.12847139f, 0.25428468f, -0.10744248f, 
    0.14976162f, -0.28858820f, -0.04511344f, 0.05414430f, 0.01587825f, -0.04305964f, 0.03567176f, 0.15532249f, 
    0.05378700f, -0.14618886f, 0.18132952f, 0.03280388f, 0.07634076f, 0.06805229f, -0.19534093f, -0.03485453f, 
    0.10962739f, -0.02819019f, 0.05310559f, 0.06209025f, -0.13042095f, -0.16630302f, -0.05972875f, 0.04677294f, 
    0.06485456f, 0.04706362f, 0.03434978f, 0.06342031f, 0.01109403f, -0.14850421f, -0.04381705f, -0.09101415f, 
    0.17267534f, 0.27353871f, 0.03403015f, -0.21409233f, 0.07401352f, -0.01623069f, -0.16325566f, -0.17995150f, 
    0.22774620f, 0.01785443f, 0.05958032f, -0.06823605f, 0.09350304f, 0.08376992f, 0.15585405f, 0.20960525f, 
    -0.06463402f, -0.03482171f, -0.12383444f, 0.00055733f, 0.00706579f, 0.12813753f, 0.04098140f, 0.13185310f, 
    0.10628963f, 0.07224784f, -0.18744847f, 0.35565636f, 0.16427802f, -0.19260287f, -0.00769772f, -0.09405495f, 
    0.08493683f, -0.11745764f, 0.02864249f, 0.09986207f, 0.08223539f, -0.41724655f, 0.08638326f, -0.65460581f, 
    -0.18191466f, -0.03041927f, -0.08783370f, 0.10309903f, 0.02677824f, -0.00475914f, -0.12004383f, 0.05650403f, 
    0.14005752f, -0.06002763f, 0.07915092f, -0.09693435f, -0.01591688f, -0.17260803f, -0.02676764f, -0.01215632f, 
    0.03312220f, -0.00687285f, -0.06206091f, 0.00505237f, -0.11028875f, 0.11177432f, -0.33583343f, -0.20167756f, 
    -0.14963447f, -0.27449381f, 0.20694256f, 0.02197930f, 0.05613512f, -0.08425244f, -0.05862194f, -0.06566148f, 
    -0.03358303f, 0.20817143f, -0.06892396f, -0.31353483f, 0.10193137f, -0.08529791f, 0.09637164f, -0.02254496f, 
    0.05998503f, -0.13899462f, 0.04832004f, 0.20458776f, -0.16101149f, -0.25891164f, 0.52837265f, 0.22667067f, 
    0.10233414f, -0.09491664f, -0.07058083f, -0.22211315f, 0.19406128f, -0.04286461f, -0.09699018f, 0.10163102f, 
    0.14786211f, -0.16329375f, -0.00734708f, 0.13086300f, -0.00812257f, -0.03671194f, 0.16092415f, -0.04085448f, 
    0.10706222f, 0.07949852f, 0.04503230f, -0.06640023f, -0.12457652f, -0.19770822f, -0.08507577f, -0.04992917f, 
    -0.00684169f, 0.14557454f, 0.02168296f, -0.00045908f, 0.06637693f, 0.03215758f, 0.08826621f, -0.05617708f, 
    0.13629922f, -0.03296104f, 0.01745134f, 0.06792957f, -0.13803253f, -0.03693116f, 0.07269340f, 0.03835811f, 
    -0.04154027f, 0.02080129f, -0.02668446f, 0.04123622f, -0.08359582f, -0.21603750f, -0.21634190f, 0.07546368f, 
    0.06769540f, 0.20005675f, 0.09190188f, 0.08147998f, 0.12533170f, -0.01873196f, 0.05208504f, 0.01995298f, 
    0.23030633f, -0.35108885f, -0.20966525f, -0.11790532f, 0.13034521f, 0.07659563f, 0.20683378f, 0.08219288f, 
    -0.12358118f, -0.04625364f, -0.03431824f, -0.08741093f, -0.15725935f, -0.20756492f, 0.04913095f, -0.02686396f, 
    -0.13120413f, -0.06971404f, -0.00847896f, 0.03209453f, 0.03926818f, -0.00739346f, 0.06905853f, 0.01601639f, 
    -0.10285360f, -0.20807035f, -0.09486561f, 0.11845648f, 0.08042414f, 0.04269332f, 0.08001308f, 0.06153719f, 
    -0.11179964f, -0.08939187f, 0.01687029f, 0.06130530f, 0.26220742f, -0.20898603f, 0.19785234f, -0.45860055f, 
    0.10123109f, -0.23936075f, 0.04995578f, -0.03795831f, -0.06573378f, 0.06367942f, -0.03978980f, -0.02134325f, 
    0.36235625f, 0.18084593f, 0.13008042f, -0.01214905f, -0.12217836f, -0.12399090f, -0.18365870f, -0.13267906f, 
    0.07971875f, 0.06252891f, -0.00165814f, 0.10094201f, -0.18227451f, -0.42952412f, 0.03901575f, -0.06202887f, 
    0.04207961f, 0.01068202f, 0.09696683f, 0.08747972f, -0.01945326f, 0.05410193f, 0.06290820f, -0.10271367f, 
    -0.08754349f, -0.25014994f, 0.14271671f, -0.03956354f, 0.15119821f, 0.14485869f, -0.05912390f, -0.02898650f, 
    0.08016635f, 0.11680555f, -0.02907055f, 0.00872934f, -0.04672023f, -0.21513680f, 0.21096712f, 0.18764198f, 
    0.10047484f, -0.04363519f, -0.04747988f, -0.05389759f, 0.01587017f, 0.10285535f, -0.04407476f, 0.06557991f, 
    -0.05949621f, -0.11928746f, 0.11559381f, 0.42977732f, 0.05603972f, 0.13251530f, -0.26012653f, 0.05801282f, 
    -0.12761684f, -0.18324146f, 0.03208787f, -0.05579493f, -0.24596170f, 0.01963300f, -0.36855641f, -0.00384096f, 
    0.11041909f, 0.02306766f, 0.01892175f, -0.06768171f, 0.10863137f, -0.00216785f, 0.15342659f, 0.17254344f, 
    0.25142732f, -0.39858311f, 0.09055116f, 0.19276178f, -0.31509918f, -0.15226263f, 0.25964710f, 0.02155490f, 
    -0.07786015f, 0.09310580f, -0.03206334f, 0.03003704f, -0.24658385f, 0.15014359f, 0.10027532f, -0.06247285f, 
    0.00116856f, 0.07805978f, -0.02127463f, -0.11114850f, 0.00085978f, 0.15569770f, 0.20889680f, 0.07627729f, 
    -0.17616776f, -0.00078678f, -0.24596024f, 0.05412925f, 0.08179719f, -0.09230765f, -0.17790084f, 0.05699949f, 
    0.02052587f, 0.01236843f, -0.02960283f, -0.09300251f, -0.22856389f, 0.20530912f, 0.26904878f, 0.12251738f, 
    0.02278139f, 0.03466336f, 0.00161665f, 0.01399723f, 0.07829803f, -0.11617235f, -0.09439331f, -0.16245747f, 
    0.10565357f, 0.35504875f, -0.06281757f, 0.16552493f, 0.04414273f, -0.03547060f, 0.05330557f, -0.16083755f, 
    -0.05334971f, 0.19596235f, 0.01975300f, 0.24391091f, -0.12251492f, -0.12654968f, 0.35524637f, 0.07650103f, 
    0.02096019f, -0.10324436f, -0.14352399f, 0.06232110f, -0.02358173f, -0.04370441f, -0.02184288f, -0.08786959f, 
    -0.15348870f, 0.46105498f, 0.17214295f, -0.22863820f, 0.03658432f, 0.06956595f, -0.05795498f, -0.01812296f, 
    -0.09820491f, -0.11003383f, -0.13834502f, -0.22644129f, -0.01026833f, -0.45834953f, -0.17585088f, -0.03340437f, 
    -0.04152489f, 0.06658596f, -0.02251311f, 0.08668991f, 0.08354095f, -0.00369867f, 0.05085861f, -0.04189207f, 
    -0.01141384f, 0.05194049f, -0.21277948f, 0.09418702f, -0.00278459f, 0.04069917f, 0.05871540f, 0.07655913f, 
    -0.00250558f, -0.06867620f, -0.10282191f, -0.20995176f, -0.40058571f, 0.56522936f, -0.19207670f, 0.26031145f, 
    0.11134926f, 0.16517201f, -0.07079936f, 0.16456373f, -0.17686698f, -0.00378204f, -0.17497113f, 0.00324391f, 
    0.01282012f, 0.05881795f, 0.04164004f, 0.17294529f, -0.08579392f, -0.17117457f, 0.11770342f, -0.01130641f, 
    -0.14767286f, 0.13497059f, 0.12887196f, 0.11904228f, 0.00879043f, -0.15522917f, 0.15937687f, -0.14148596f, 
    -0.06250659f, 0.02083264f, 0.00864893f, -0.08092757f, 0.01714364f, -0.05857357f, 0.07114861f, 0.09259070f, 
    -0.10901120f, -0.18550779f, 0.03461920f, 0.03405875f, -0.04885098f, 0.00537463f, -0.00162036f, -0.04306425f, 
    -0.27929914f, -0.07855410f, -0.13936411f, -0.18191653f, 0.00967674f, -0.05454453f, 0.03121477f, 0.04396043f, 
    -0.02031822f, -0.00212353f, 0.15119079f, 0.02359980f, 0.11081040f, -0.15001184f, 0.11588039f, -0.05683225f, 
    0.04416642f, -0.07488133f, 0.02672660f, -0.14482994f, 0.06084258f, -0.13949497f, 0.07811405f, 0.03862002f, 
    -0.14880159f, -0.07370025f, -0.08367705f, 0.13309553f, -0.07717589f, -0.20113185f, -0.05607242f, 0.07099613f, 
    0.08969607f, -0.10911812f, -0.16591708f, 0.08160651f, -0.09861674f, -0.03005620f, -0.00275217f, -0.10809317f, 
    0.55092973f, 0.11570129f, 0.15075119f, -0.30160907f, 0.04746861f, -0.01804247f, 0.01498651f, -0.02026656f, 
    -0.12298270f, -0.04453955f, -0.30608359f, -0.14007813f, -0.30155000f, -0.29146734f, -0.10896677f, -0.01830270f, 
    -0.04418517f, 0.16282800f, 0.08505408f, 0.24157745f, 0.07571941f, 0.07861783f, -0.03536893f, 0.11756159f, 
    -0.07138973f, 0.15738043f, 0.00577767f, -0.08112033f, -0.04672324f, 0.08789989f, -0.27871886f, 0.02655746f, 
    0.02664747f, -0.00519590f, 0.16353066f, -0.10723206f, -0.29263622f, 0.31293622f, 0.10987575f, 0.10489102f, 
    0.12432421f, 0.28728741f, -0.14335258f, 0.08234362f, -0.02367008f, 0.23961709f, 0.25548932f, 0.02024887f, 
    0.13542803f, -0.24900787f, 0.22981115f, 0.04447733f, -0.06442228f, 0.13836981f, -0.07641933f, -0.04340472f, 
    0.20655052f, -0.05923806f, 0.04891458f, -0.15573174f, -0.00722632f, 0.15111528f, 0.07290071f, -0.14171426f, 
    -0.17343925f, 0.14012688f, 0.05765818f, -0.01255411f, -0.07552493f, -0.09466448f, -0.17704152f, -0.28467762f, 
    0.46191359f, 0.09606878f, 0.36329690f, -0.15543701f, -0.18529136f, -0.00300869f, 0.09688223f, 0.11917197f, 
    -0.00708780f, 0.06100246f, -0.05754027f, 0.07048352f, -0.15405324f, 0.43449441f, 0.28201458f, 0.15643601f, 
    0.03822318f, 0.01487927f, -0.33290207f, -0.02082848f, 0.01124787f, 0.06001527f, 0.15531585f, 0.02209865f, 
    -0.22649412f, 0.00749518f, -0.30944040f, 0.14285003f, 0.04307659f, 0.02828142f, -0.13414548f, 0.05947492f, 
    0.08783441f, 0.11170364f, 0.01214129f, 0.04933203f, -0.01055184f, 0.12021746f, -0.06066579f, 0.10699335f, 
    -0.20010576f, 0.11463960f, 0.10463874f, 0.04015675f, -0.03202161f, -0.14235504f, 0.17857091f, -0.02002953f, 
    -0.12644082f, -0.04997185f, -0.31087962f, -0.32965836f, -0.05364961f, -0.05205429f, 0.00813693f, -0.10622193f, 
    -0.01585941f, 0.10278663f, -0.08725744f, 0.06260934f, 0.00572611f, 0.05732495f, 0.12900297f, 0.08399662f, 
    0.03637946f, -0.00892297f, 0.10240110f, 0.25637212f, -0.02043781f, 0.04502955f, 0.18155254f, -0.08208916f, 
    0.07421134f, -0.07790875f, -0.04458897f, -0.04364714f, -0.04358665f, 0.06495132f, -0.16168924f, -0.08074703f, 
    0.13359493f, -0.02702890f, 0.03984742f, -0.03426806f, -0.06673586f, -0.52483422f, -0.12983873f, 0.22870237f, 
    0.06108181f, 0.02738792f, -0.00207467f, 0.03661743f, 0.05450911f, -0.03333528f, -0.20902854f, 0.00162450f, 
    -0.08608267f, 0.10389113f, -0.02367324f, -0.05801247f, -0.09219866f, -0.22537732f, -0.06803769f, 0.10815730f, 
    -0.16688468f, 0.10636958f, 0.10536539f, -0.08773772f, -0.21439202f, 0.08385139f, -0.07412472f, 0.16174740f, 
    -0.07337404f, 0.06956092f, 0.08094540f, 0.07358778f, -0.04563200f, 0.11563602f, 0.10880887f, 0.06543832f, 
    -0.20134723f, 0.06239987f, 0.15874207f, -0.18022472f, -0.07879560f, 0.04837998f, -0.07040266f, 0.08168170f, 
    -0.10568787f, -0.19429603f, -0.20731001f, -0.09858464f, -0.12736875f, 0.05009672f, 0.12694193f, 0.01791091f, 
    0.13879214f, -0.09137931f, 0.05229836f, 0.10356998f, -0.03695738f, 0.07617949f, -0.19023313f, -0.01998235f, 
    0.09105691f, 0.03298114f, 0.05808900f, -0.09679125f, -0.15453918f, 0.09431074f, 0.13208054f, 0.01638161f, 
    0.07055813f, 0.04025117f, 0.10774928f, 0.13115881f, -0.16372457f, -0.11617765f, -0.15521865f, 0.03970784f, 
    0.06525441f, -0.16877550f, 0.06000237f, 0.09114078f, -0.28396749f, 0.01339168f, -0.08254179f, -0.09662294f, 
    -0.11893284f, -0.19947201f, 0.18714321f, 0.09550349f, -0.08704977f, -0.01846526f, 0.04822665f, -0.08003817f, 
    -0.00639633f, 0.09065532f, 0.03510403f, 0.08569963f, -0.02721592f, 0.02942711f, 0.19172569f, 0.01640167f, 
    -0.06171702f, -0.22053273f, 0.10474031f, -0.07909470f, -0.06446425f, -0.01468747f, -0.09084891f, 0.07948449f, 
    -0.08202635f, 0.07608099f, -0.00723340f, -0.03536289f, -0.22971690f, -0.22103757f, -0.02881293f, 0.21364321f, 
    -0.03972568f, 0.15887153f, 0.17199306f, 0.04364965f, -0.24328308f, 0.16188119f, -0.13850410f, 0.10584936f, 
    0.02622190f, -0.19017006f, -0.02854282f, 0.06316275f, -0.06112817f, 0.09235100f, -0.16021211f, -0.22995253f, 
    -0.08546722f, 0.02462061f, 0.22979110f, 0.20501043f, -0.00094933f, 0.15987273f, -0.11181007f, -0.07432916f, 
    -0.05793890f, -0.19089656f, -0.17332225f, -0.03496624f, -0.09690878f, 0.02007142f, 0.13102156f, -0.05247851f, 
    -0.03625570f, -0.00715653f, -0.04735719f, 0.02986828f, -0.12244764f, 0.12674035f, 0.12518531f, 0.06591592f, 
    -0.14821392f, 0.04974936f, 0.09761304f, 0.04222126f, -0.02557204f, -0.05420063f, -0.11850782f, 0.19528015f, 
    0.04051875f, 0.07676724f, 0.03145028f, 0.07964835f, -0.11280566f, 0.14464912f, -0.03224993f, -0.10476812f, 
    -0.04403498f, -0.06473986f, -0.01135068f, 0.09960197f, -0.09790841f, -0.21264955f, -0.42090514f, -0.28798884f, 
    -0.21204811f, 0.37838525f, 0.00682383f, -0.14422148f, -0.16138469f, 0.09313457f, -0.11449327f, 0.03343519f, 
    0.09819735f, 0.07034984f, -0.26053959f, -0.07547688f, -0.03964445f, 0.22726427f, 0.31039837f, 0.23869145f, 
    0.06698104f, 0.13099219f, -0.06877772f, 0.06105981f, 0.11352909f, 0.05866153f, 0.06083673f, 0.04202090f, 
    -0.18047222f, 0.12733062f, 0.05770100f, -0.11292107f, -0.05462576f, 0.06927630f, 0.07886957f, 0.00914704f, 
    -0.07430219f, 0.14873661f, 0.09568851f, 0.11309050f, 0.15102471f, -0.06233562f, 0.17067161f, -0.01275738f, 
    -0.02816751f, 0.10794875f, 0.24682380f, -0.00696115f, 0.06891192f, 0.18320407f, 0.06861059f, 0.15340833f, 
    0.10178341f, 0.11215763f, 0.35324845f, 0.12290927f, -0.03457747f, -0.37554643f, 0.14951831f, 0.10879303f, 
    -0.23350848f, 0.01191168f, -0.11136135f, -0.34512353f, -0.46931621f, 0.15229444f, -0.32116634f, -0.17508689f, 
    -0.01077932f, 0.03373148f, -0.01717117f, 0.16451032f, -0.16551165f, -0.13024871f, 0.09363189f, 0.06154501f, 
    -0.46203402f, 0.20203842f, 0.11730938f, -0.07485937f, -0.10124216f, 0.03358824f, 0.01324627f, 0.08086146f, 
    -0.14657262f, -0.10211488f, -0.09613850f, -0.13171497f, -0.09150909f, -0.36350241f, -0.34808573f, -0.33943990f, 
    -0.14467928f, 0.02644234f, 0.01778386f, -0.04107201f, -0.05037640f, 0.07648186f, 0.00918665f, -0.05594875f, 
    -0.20898873f, 0.20313647f, -0.41359386f, 0.00051608f, -0.02979682f, 0.13006780f, 0.07153353f, 0.00640959f, 
    -0.32355925f, 0.00396618f, -0.18058290f, 0.05976116f, -0.15121578f, -0.16664363f, -0.26597479f, -0.35357392f, 
    -0.25642937f, 0.00807261f, 0.03785646f, 0.06541261f, -0.11946518f, 0.02482544f, 0.06491935f, -0.08424340f, 
    -0.24615003f, -0.10454452f, -0.19246595f, -0.08868407f, -0.02107328f, 0.12127886f, 0.11667501f, -0.20523989f, 
    0.04607105f, 0.01402654f, 0.02078602f, -0.14867952f, -0.09445501f, -0.16322744f, -0.08229800f, -0.05565768f, 
    -0.10029231f, -0.06414413f, -0.06242944f, 0.14354305f, 0.06393565f, 0.07650479f, -0.04557093f, -0.14339375f, 
    -0.00389481f, -0.00114565f, -0.04691715f, -0.06344660f, -0.05873471f, 0.06956273f, -0.07408835f, -0.13319366f, 
    -0.02092085f, -0.02454709f, -0.09995537f, -0.12690254f, -0.09344979f, -0.00449463f, 0.03067416f, 0.14698450f, 
    0.03254276f, 0.04954563f, 0.12150387f, -0.00654591f, 0.09394223f, -0.04194245f, 0.02225854f, -0.04807637f, 
    0.12066359f, 0.05041794f, 0.03304914f, -0.08497482f, 0.04563552f, -0.10621590f, -0.17062546f, -0.03213216f, 
    -0.03877196f, 0.00807714f, 0.03943149f, -0.15212792f, -0.32763711f, -0.02809726f, -0.48005915f, 0.15310703f, 
    -0.04335844f, 0.00752136f, -0.08568485f, 0.04632930f, 0.02946914f, 0.16754599f, 0.02399155f, 0.00424945f, 
    -0.12096155f, -0.03636322f, 0.03572346f, 0.01037975f, -0.02200615f, 0.03347531f, -0.11881061f, 0.05254307f, 
    -0.03348041f, -0.04778939f, -0.00279632f, -0.11736536f, -0.36169672f, 0.24463101f, -0.11437109f, -0.08470196f, 
    -0.05150624f, 0.06103161f, -0.04053210f, -0.11283550f, 0.08474794f, -0.06807195f, -0.00489313f, -0.13573195f, 
    -0.09195665f, 0.17042014f, 0.01018668f, -0.12071639f, -0.00038202f, 0.00391114f, 0.00091407f, 0.11414346f, 
    0.02576409f, 0.10308534f, 0.12124581f, 0.08437064f, 0.10308269f, 0.01235044f, 0.16448557f, -0.14533795f, 
    -0.13760649f, -0.04985791f, 0.04754115f, -0.04283065f, -0.15672785f, -0.04221344f, -0.36987084f, -0.20152318f, 
    0.26546508f, -0.09979860f, 0.48153651f, -0.11192945f, 0.07311656f, 0.13879281f, 0.01084179f, -0.06357336f, 
    -0.18827209f, 0.01624523f, 0.00839921f, 0.03728686f, 0.19419263f, 0.05886406f, 0.06096765f, 0.00002945f, 
    0.09064600f, -0.00415100f, -0.05333814f, -0.08483714f, 0.02191350f, 0.03485717f, -0.18204750f, 0.11549438f, 
    -0.25756150f, -0.25967526f, -0.02516675f, 0.00003571f, -0.05423618f, -0.17333035f, 0.06284638f, -0.13337566f, 
    -0.03796660f, 0.08732292f, -0.02506633f, -0.00019792f, -0.13751392f, 0.28325459f, 0.04046328f, -0.12098597f, 
    0.07424321f, 0.01026402f, 0.04997446f, 0.05430358f, -0.04895366f, 0.10200438f, 0.05509042f, 0.06327681f, 
    -0.44822422f, 0.28853554f, -0.36116716f, -0.11025356f, 0.01100805f, -0.01290622f, -0.01647374f, -0.03375436f, 
    -0.29346052f, -0.25310966f, -0.14342591f, -0.23988865f, -0.12102165f, 0.31579709f, 0.00557843f, 0.07324027f, 
    -0.14799593f, 0.15506311f, -0.01189841f, 0.18985599f, -0.10886306f, 0.07734124f, -0.03933642f, 0.06593335f, 
    -0.28319073f, -0.13575020f, -0.18589786f, 0.07120244f, 0.22116828f, 0.13916788f, 0.05201623f, -0.08702350f, 
    -0.06392838f, 0.01847717f, 0.28714281f, 0.18386337f, -0.28921375f, -0.18551083f, -0.17647344f, 0.11446170f, 
    -0.10778321f, 0.01173814f, 0.01412993f, -0.21250883f, -0.02189918f, 0.06965319f, -0.10348410f, -0.04441465f, 
    -0.16891105f, 0.06804566f, -0.32757786f, -0.08505059f, 0.00348146f, 0.00515244f, -0.00882773f, -0.02836902f, 
    -0.09421287f, 0.05799716f, 0.10650165f, 0.02600203f, -0.90720755f, 0.06506666f, -0.18525372f, 0.25143290f, 
    -0.08922470f, -0.05865787f, 0.12369686f, 0.23331875f, -0.14973511f, 0.02303500f, -0.05901569f, 0.13566731f, 
    -0.14507781f, 0.09583493f, -0.03272667f, -0.02618520f, 0.02686723f, 0.11895642f, 0.08813872f, -0.13439000f, 
    -0.07834290f, -0.10540184f, 0.10050964f, -0.07394411f, 0.30519733f, 0.11691725f, 0.16023038f, -0.28226975f, 
    -0.01115233f, 0.00479177f, -0.12313502f, 0.06124924f, -0.01042273f, 0.04051968f, -0.00226192f, 0.03267584f, 
    -0.03595317f, -0.24550153f, 0.11548790f, -0.06181932f, -0.09170177f, 0.00429690f, 0.03309457f, -0.11798836f, 
    -0.21839903f, 0.07105277f, 0.06106175f, 0.13161449f, -0.07377417f, 0.02604116f, 0.03727906f, -0.46168712f, 
    -0.08754158f, -0.17192085f, -0.04659003f, 0.10335007f, -0.03159022f, -0.06345411f, -0.01887266f, -0.03373042f, 
    -0.07149468f, 0.06842171f, 0.32674661f, 0.07541241f, 0.07530137f, 0.08611937f, 0.22049677f, -0.15652922f, 
    -0.01539446f, -0.00885159f, 0.03319144f, -0.04731365f, -0.15033264f, 0.33998641f, -0.23866035f, 0.14263175f, 
    -0.19223483f, -0.07002612f, 0.09141170f, 0.00476433f, -0.03486769f, 0.08508147f, 0.03108609f, -0.08716951f, 
    -0.15614727f, -0.38060004f, -0.05795621f, -0.19661294f, 0.06724712f, -0.09346933f, 0.11066721f, -0.13259366f, 
    -0.10767517f, -0.03567425f, 0.05163646f, -0.04106246f, 0.17660286f, 0.33402807f, 0.23227511f, -0.15861104f, 
    -0.06979235f, 0.05765656f, -0.09343020f, -0.16734572f, -0.06277798f, -0.03888869f, 0.02856494f, 0.03918623f, 
    0.05042164f, -0.09650168f, 0.08412433f, 0.02609517f, 0.08705530f, -0.06437550f, 0.17486283f, 0.11416044f, 
    0.16182819f, 0.01135357f, 0.13336980f, 0.07611592f, -0.50081652f, 0.33158544f, -0.23715386f, 0.26670989f, 
    0.21040878f, -0.20818351f, 0.11951934f, 0.20888513f, -0.07551304f, -0.12042464f, -0.11508204f, 0.26919532f, 
    -0.12656394f, -0.17014882f, 0.00564867f, -0.06420808f, 0.01378108f, -0.13607709f, -0.08256399f, 0.01000582f, 
    -0.06131092f, 0.05103777f, -0.05518820f, -0.06597973f, -0.32870275f, 0.29742038f, -0.18504508f, 0.01743843f, 
    0.00200247f, -0.02083850f, 0.24926001f, 0.10559452f, 0.08364499f, 0.07034072f, 0.04997713f, 0.12798242f, 
    -0.06251018f, -0.52026540f, 0.34557727f, -0.05572158f, 0.15499130f, 0.12409294f, 0.36748007f, -0.13667732f, 
    0.01417309f, -0.04997442f, 0.10656530f, 0.02146067f, -0.17101224f, -0.05980341f, -0.21093187f, 0.09052338f, 
    0.26418793f, 0.10118117f, -0.10750680f, 0.05935036f, 0.05630877f, 0.04446291f, 0.07616687f, 0.08141840f, 
    -0.02308672f, -0.14862293f, -0.01697296f, -0.18988150f, -0.07332036f, -0.24179739f, -0.23364919f, -0.15419064f, 
    0.02444749f, -0.05063635f, -0.09513954f, -0.08518211f, 0.09827700f, -0.31464782f, 0.30680415f, 0.18084665f, 
    -0.00317201f, 0.07287611f, 0.11186200f, 0.15189108f, -0.15360408f, 0.02110450f, -0.03402176f, -0.04941054f, 
    -0.00322688f, -0.03648123f, -0.16374829f, -0.10186405f, 0.00123984f, -0.01287712f, -0.10938911f, 0.10531823f, 
    -0.06193366f, -0.04084659f, 0.10782967f, -0.11284030f, 0.14358321f, -0.08682057f, 0.05349177f, 0.04291151f, 
    0.02539380f, 0.04956609f, 0.06970125f, 0.07526797f, -0.03526784f, -0.08783811f, -0.07706458f, -0.08398629f, 
    0.39568642f, -0.10111049f, 0.14317188f, -0.15446936f, 0.02673530f, 0.12824090f, -0.04660242f, 0.08945767f, 
    -0.07034702f, 0.02170146f, 0.03179827f, 0.11739074f, -0.42983454f, -0.29980266f, 0.29694754f, -0.34356958f, 
    -0.04712969f, 0.08931048f, -0.13717839f, -0.15967242f, -0.00031295f, 0.01671089f, 0.05622011f, 0.01972772f, 
    0.42957044f, 0.29633391f, 0.18909481f, -0.03207799f, -0.06003160f, -0.07826855f, -0.13897036f, 0.06279851f, 
    -0.03674790f, -0.04665364f, -0.04476512f, 0.00335620f, 0.12500426f, 0.09220420f, 0.11239991f, 0.06043790f, 
    -0.00704021f, 0.05727624f, -0.09413594f, 0.05820247f, -0.09416603f, -0.11445724f, -0.10539893f, -0.13608618f, 
    0.10649318f, -0.21626200f, 0.14182979f, -0.16758612f, 0.06123620f, -0.04545767f, 0.07370791f, 0.05108074f, 
    -0.03209670f, 0.22969900f, 0.15844285f, 0.11694571f, 0.08808275f, 0.07209400f, -0.04840045f, -0.18842937f, 
    -0.03219863f, 0.02594859f, 0.10308649f, -0.07454236f, 0.06602308f, 0.00151440f, 0.08379833f, -0.01416997f, 
    0.27877036f, -0.17315793f, 0.25308535f, -0.23892972f, 0.08855777f, 0.13550693f, -0.08353619f, 0.07179842f, 
    -0.08984823f, -0.01207399f, -0.05651559f, -0.11897548f, 0.16683009f, 0.07120077f, 0.24317344f, 0.03890324f, 
    0.09408952f, 0.01852579f, -0.07963324f, -0.01131611f, -0.03303168f, 0.02308553f, 0.13301344f, 0.03557253f, 
    -0.12975089f, -0.23913673f, -0.05991589f, 0.17950533f, -0.10709677f, -0.19141413f, 0.06264700f, -0.23405896f, 
    -0.02758001f, 0.04952074f, -0.02779995f, 0.03305280f, -0.23254982f, -0.01680947f, -0.11192889f, 0.02494407f, 
    0.08516579f, 0.01669310f, 0.04089922f, -0.13179988f, -0.07164212f, -0.01371970f, 0.04890151f, -0.00001042f, 
    0.30135119f, 0.12619568f, 0.03227592f, 0.13814117f, -0.06591326f, 0.20398515f, -0.11079817f, 0.15281667f, 
    -0.02767621f, 0.01178461f, -0.00129211f, -0.01093562f, 0.13605979f, -0.19984150f, 0.25220558f, 0.11791083f, 
    -0.01725671f, -0.01039122f, -0.09282418f, 0.02241926f, 0.00330367f, 0.08952174f, 0.11403637f, -0.00595057f, 
    -0.38634089f, 0.05901961f, -0.04283200f, 0.07973628f, -0.06876624f, 0.06975579f, 0.00146728f, 0.05406488f, 
    -0.07128081f, 0.01689950f, 0.09713946f, -0.08120919f, 0.36677289f, 0.01331110f, 0.05944394f, 0.21032315f, 
    -0.03006856f, 0.01718580f, -0.12957387f, 0.06721340f, -0.17199366f, 0.02540792f, 0.06525346f, -0.06994934f, 
    -0.23494181f, -0.25017881f, 0.20345092f, 0.07900822f, -0.09723771f, -0.01721323f, 0.15978852f, 0.10358162f, 
    -0.08994766f, -0.01578385f, -0.15785652f, -0.11261780f, -0.18716484f, 0.01055896f, -0.13212642f, 0.00173121f, 
    0.03693269f, -0.02604295f, 0.04793027f, 0.00612546f, -0.02938735f, 0.04095038f, 0.02354380f, 0.13445835f, 
    0.19834585f, -0.21090306f, -0.07986698f, 0.02163115f, -0.00812897f, 0.07739091f, 0.06193316f, 0.04954790f, 
    -0.01186164f, 0.10125481f, 0.13275291f, 0.02171143f, -0.25735182f, -0.02126497f, -0.46937889f, 0.23115605f, 
    -0.28141147f, 0.10201877f, -0.08658852f, 0.01602523f, -0.05410655f, 0.03738151f, -0.01354702f, -0.01185679f, 
    -0.00454617f, 0.09787128f, -0.19855186f, 0.09670945f, 0.10878168f, 0.06805645f, -0.04802579f, -0.06583866f, 
    -0.06302229f, -0.04723468f, -0.05653996f, -0.17868902f, 0.25464693f, -0.26551566f, 0.30768603f, -0.37619171f, 
    0.09375113f, 0.05954549f, -0.10831209f, 0.09779251f, -0.10800777f, -0.05691608f, -0.15448381f, -0.11394686f, 
    -0.05145879f, 0.02273709f, 0.08840861f, 0.04069699f, 0.04644559f, 0.00827335f, 0.00517283f, -0.01467822f, 
    0.06378841f, 0.12024503f, 0.02299579f, 0.01418666f, -0.09075329f, -0.19760521f, -0.18693291f, 0.11292598f, 
    0.08114248f, 0.08053292f, 0.09225141f, 0.02412826f, 0.02482555f, 0.05452948f, 0.16013476f, -0.16308208f, 
    0.09895463f, -0.08768312f, -0.00820371f, 0.03047189f, 0.14360958f, 0.00130062f, 0.07368588f, 0.19692612f, 
    0.12018469f, 0.07968089f, 0.19191597f, 0.08861698f, 0.13757776f, 0.11247639f, -0.18385102f, -0.06353314f, 
    0.01592033f, -0.02098976f, -0.03529996f, 0.03999291f, -0.03382456f, -0.04466103f, -0.03762558f, -0.13589895f, 
    0.07224455f, -0.11091477f, 0.22457522f, 0.38411012f, 0.10403664f, -0.12003167f, 0.06990012f, -0.11514013f, 
    0.15102406f, -0.06363489f, 0.14180170f, -0.07313021f, 0.11058715f, 0.12625171f, 0.06782597f, 0.08472916f, 
    -0.09514622f, -0.01274068f, 0.05313676f, 0.09558132f, -0.01366716f, -0.05638545f, 0.09107877f, -0.03256318f, 
    0.42310947f, 0.24299562f, 0.19281182f, -0.13741982f, 0.04513721f, -0.06668493f, -0.16440174f, 0.08787943f, 
    -0.01226282f, 0.06076186f, -0.00199173f, -0.00274309f, 0.08319533f, -0.09004331f, -0.08003021f, -0.38873297f, 
    -0.04995988f, -0.01836033f, 0.11233959f, 0.02660444f, -0.00024176f, 0.08387458f, 0.09047554f, 0.00829923f, 
    0.01833718f, -0.07632367f, 0.04719393f, 0.00008680f, 0.02848517f, -0.10707150f, 0.02237065f, -0.01246758f, 
    0.03948172f, 0.04020216f, -0.00118952f, -0.02793258f, 0.09124988f, -0.02503425f, 0.03770043f, 0.04663246f, 
    0.02865977f, 0.03650603f, -0.08825615f, 0.05056844f, -0.12040135f, -0.06349189f, -0.01289141f, -0.07866719f, 
    -0.33966058f, 0.18629336f, -0.30468130f, -0.10946468f, 0.00474102f, -0.02785276f, 0.07092148f, 0.02828366f, 
    -0.08191119f, 0.05068493f, -0.06773426f, -0.13069591f, -0.17274427f, -0.22059497f, 0.17122637f, 0.10505152f, 
    -0.24555546f, 0.07802559f, -0.18473506f, -0.12686910f, -0.00239840f, -0.01776622f, 0.09988158f, -0.02906739f, 
    -0.06193062f, 0.09761755f, -0.12318816f, -0.02120265f, -0.02891272f, 0.10233475f, 0.01919472f, 0.01512496f, 
    -0.01203395f, 0.06722323f, -0.06851745f, -0.05179367f, -0.11830576f, -0.10998137f, -0.21161376f, 0.24146347f, 
    0.13459264f, -0.09198419f, 0.05180866f, -0.01907983f, 0.03183309f, -0.04192293f, -0.05259707f, 0.03728482f, 
    -0.44936916f, 0.02220530f, -0.27691314f, 0.08907200f, 0.08349045f, 0.06871282f, 0.04863231f, -0.08356941f, 
    -0.00939100f, -0.11738610f, -0.00033491f, 0.02737122f, 0.30622551f, 0.02129730f, 0.17106031f, -0.27360439f, 
    -0.08566270f, 0.10372170f, -0.03230869f, 0.04204546f, 0.02098032f, 0.00247049f, 0.03186868f, 0.00816141f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12541559f, 0.07278976f, 0.08183092f, -0.03497939f, -0.06986469f, 0.04103247f, 0.05900151f, -0.08275425f, 
    0.02696836f, 0.02289549f, 0.00842019f, -0.01924579f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
