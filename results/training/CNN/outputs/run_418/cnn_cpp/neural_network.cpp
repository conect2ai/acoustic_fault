#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28722224f, -0.65250540f, 0.23350899f, 0.30202904f, -0.03129202f, -0.04151233f, -0.16357031f, -0.41593650f, 
    -0.19994962f, 0.22508301f, 0.24188848f, 0.05285150f, -0.37508568f, 0.02463900f, -0.22778280f, -0.04053845f, 
    0.19489342f, 0.22421494f, -0.32554090f, 0.31630343f, 0.36126837f, 0.39555028f, 0.36130932f, 0.60363561f, 
    -0.19505182f, 0.89796239f, 0.30076656f, -0.66715389f, -0.05340059f, -0.77911747f, 0.35349619f, 0.33126932f, 
    0.44997999f, 0.79264241f, 0.32225299f, -0.20994042f, -0.07912822f, -0.36040580f, -0.03380127f, 0.28509644f, 
    0.05966325f, -0.32455209f, -0.27330512f, 0.12710635f, -0.02181125f, -0.05095961f, 0.01950782f, -0.07270059f, 
    -0.12488967f, -0.09887252f, 0.64955777f, 0.43999609f, 0.65898180f, 0.65966409f, -0.09267869f, 0.19175774f, 
    -0.40974915f, 0.18341303f, 0.21271965f, 0.69952708f, 0.09760328f, 0.21709454f, -0.30292904f, -0.28353745f, 
    -0.19775864f, -0.21468772f, -0.07842983f, 0.00548308f, -0.29211867f, 0.19166464f, 0.15540253f, 0.05548193f, 
    0.10469054f, -0.31883422f, -0.18356654f, 0.66933125f, -0.24122016f, -0.60430694f, -0.82052332f, -0.21439829f, 
    -0.21463813f, -0.16300908f, -0.42798147f, -0.52697200f, 0.22224721f, 0.12290016f, 0.26596719f, -0.09453107f, 
    0.28319827f, -0.34886160f, 0.13570131f, 0.11811194f, -0.22936852f, -0.26288646f, -0.01180007f, -0.00324344f, 
    0.18756430f, 0.41968563f, 0.28144410f, 0.05901621f, 0.75388122f, 0.84574586f, 0.18837702f, -0.61981571f, 
    -0.34816945f, -0.24014877f, 0.45527232f, -0.28911915f, -0.33812016f, 0.33915338f, 0.45811209f, 0.00135314f, 
    -0.33633503f, -0.29062849f, -0.15074636f, 0.30053714f, 0.08275726f, -0.14697663f, 0.04471619f, -0.14001337f, 
    0.36226183f, 0.47947672f, -0.20400117f, 0.05954275f, 0.39117146f, 0.53064829f, -0.28404853f, -0.62641621f, 
    0.32856390f, 0.91761214f, 0.06467922f, -0.57865286f, -0.32999542f, -0.24132152f, 0.35616714f, -0.04513669f, 
    0.32504204f, -0.16992800f, -0.04406641f, 0.24056277f, 0.14918843f, -0.22736488f, 0.08046950f, 0.12680514f, 
    -0.20750092f, 0.01486397f, -0.28137082f, -0.16157897f, -0.01901245f, -0.22197281f, 0.63386160f, 0.00631850f, 
    0.92239058f, 0.53324628f, 0.40544400f, 0.12943421f, -0.28810340f, -0.47949970f, -0.55792975f, -0.28758830f, 
    0.32120869f, 0.26619667f, 0.00667641f, 0.02254212f, -0.02001740f, 0.05519760f, 0.28655952f, -0.16351154f, 
    -0.08976953f, 0.23094463f, 0.13363773f, 0.02401932f, -0.12228374f, 0.18163215f, 0.33236387f, 0.60592091f, 
    0.40383834f, -0.47294715f, -0.50543344f, -0.64316356f, 0.36284733f, 0.22969414f, 0.32282612f, 0.57015711f, 
    0.77947646f, -0.00219440f, -0.25822958f, -0.01238108f, -0.26186281f, -0.33375919f, -0.09364140f, 0.35065287f, 
    -0.04535087f, 0.16192231f, -0.13193326f, -0.04448456f, -0.23338732f, -0.00619710f, -0.42435434f, 0.35806587f, 
    -0.18323788f, -0.86184078f, -0.65110302f, -0.23936081f, -0.46976370f, -0.02977086f, 0.50296819f, 0.12435298f, 
    0.37656769f, 0.50985664f, -0.05511262f, 0.01301038f, -0.06137841f, -0.05680102f, -0.17569761f, -0.16263205f, 
    0.34354055f, -0.10793000f, 0.15425096f, 0.05724904f, -0.20519243f, -0.00762992f, -0.13123578f, 0.05912311f, 
    0.11957119f, -1.10215926f, 0.51672947f, 1.14316726f, -0.65284002f, -0.69570351f, 0.15202387f, 0.42069998f, 
    0.11243234f, 0.25026608f, -0.12043997f, -0.07217018f, 0.23875168f, -0.27744243f, -0.04728534f, 0.01352664f, 
    -0.00194943f, 0.04144799f, -0.11469234f, -0.24775755f, -0.19124889f, 0.13342024f, 0.27249330f, 0.07083391f, 
    0.28833064f, 0.12223326f, 0.45372880f, -0.67114103f, 0.05512414f, -0.60285825f, -0.01260827f, -0.01491038f, 
    0.37053782f, -0.24199422f, -0.25857839f, -0.09141653f, -0.19679435f, 0.18713842f, -0.27980065f, 0.10454252f, 
    0.30189127f, -0.07469651f, 0.07904236f, 0.39222905f, 0.00337050f, 0.20616156f, -0.26491633f, -0.30529478f, 
    -0.21282896f, -0.21117696f, -0.17496464f, 0.84601563f, 0.57436359f, 0.77294016f, -0.62017328f, -0.63808948f, 
    0.16202109f, -0.57400972f, 0.20681292f, -0.53571618f, 0.52228963f, 0.35622123f, 0.20267802f, 0.07975250f, 
    -0.08336729f, 0.03200641f, -0.23472869f, 0.04541431f, -0.01823271f, 0.06423622f, 0.05515749f, 0.16706765f, 
    0.06070560f, 0.19687621f, 0.06356317f, -0.03216083f, -0.54865080f, -0.73093647f, -0.63438541f, -0.10266680f, 
    -0.47365785f, 0.49420312f, 0.91886801f, -0.14419532f, -0.23553289f, 0.46639070f, -0.17192483f, 0.11746899f, 
    -0.17853527f, -0.11713573f, 0.04196402f, -0.02332015f, 0.06015715f, 0.24120751f, -0.03251012f, -0.18966170f, 
    0.06680013f, -0.12235007f, -0.22822085f, -0.40586764f, -0.18127513f, -0.31094614f, -0.62062156f, -0.26401281f, 
    0.61475593f, 0.42065433f, 0.63205570f, 0.97121805f, -0.04407983f, 0.39441624f, 0.28031796f, -0.35858655f, 
    -0.35563388f, -0.24861249f, -0.06813782f, -0.15827444f, -0.06164530f, -0.15065227f, 0.03112170f, -0.38317358f, 
    -0.23115525f, 0.18914229f, -0.04213898f, 0.11621336f, 0.05619552f, 0.00864272f, 0.34136835f, 0.36756417f, 
    -0.28444910f, -0.48605692f, 0.72693199f, 0.20922351f, -0.64096159f, 0.16178504f, -0.27657294f, 0.11613948f, 
    0.14531040f, 0.41417384f, -0.23114684f, 0.04768012f, 0.15964076f, 0.07119983f, -0.31510532f, 0.31897444f, 
    0.24521269f, 0.25356013f, 0.17519407f, -0.20610398f, -0.13806356f, -0.07681819f, -0.20210329f, -0.96065855f, 
    0.44041923f, 0.28046402f, 0.08434919f, 0.05639400f, 0.30617967f, 0.39700237f, 0.26180431f, 0.75522333f, 
    0.48543754f, 0.31050673f, -0.26196563f, 0.01150595f, 0.05088273f, -0.42074659f, -0.12418681f, -0.40222406f, 
    -0.08066096f, 0.19871601f, -0.09086053f, -0.03985677f, -0.22985448f, -0.02395789f, -0.10154524f, 0.08805513f, 
    0.69417989f, -0.71856815f, 0.70922154f, 0.34487361f, -0.15262547f, 0.10530786f, -0.43469369f, 0.48078519f, 
    0.19553301f, 0.10056125f, 0.05403950f, -0.43031788f, -0.42248371f, 0.18087313f, -0.47469899f, 0.03759723f, 
    0.23357925f, -0.11646484f, -0.28628689f, 0.08039877f, -0.25692171f, -0.09494781f, 0.40860415f, -0.23041257f, 
    -0.14426798f, -0.41709343f, -0.04405328f, -0.32172999f, 0.20961457f, -0.51578724f, -0.07829425f, -0.56447762f, 
    0.21667954f, -0.02456567f, -0.25100020f, -0.07751126f, 0.11349007f, -0.22048943f, -0.09309556f, -0.28471741f, 
    0.32928497f, 0.40601030f, 0.52147120f, -0.22800973f, -0.45274335f, -0.13333099f, 0.04214976f, 0.09314144f, 
    0.44819850f, 0.43024844f, -0.70941573f, -0.37889516f, 0.13333854f, 0.47757870f, -0.62259513f, 0.35191005f, 
    1.01264715f, -0.08466759f, 0.19631968f, 0.16017824f, -0.13616003f, -0.15992099f, -0.56618607f, -0.41585797f, 
    0.13274297f, 0.09293402f, -0.05955905f, 0.02913307f, -0.21400146f, 0.02967705f, -0.37064672f, 0.19378725f, 
    0.25465864f, 0.37444288f, -0.16749017f, 0.53805178f, 0.57074571f, -0.70885223f, -0.29934749f, -0.36643174f, 
    0.01199103f, -0.19665430f, -0.00894450f, 0.10021723f, -0.34808969f, -0.27451915f, -0.44418302f, -0.05714763f, 
    -0.08623712f, 0.13462965f, 0.00662654f, 0.25206974f, -0.06759979f, 0.35950926f, 0.32644042f, -0.10622062f, 
    -0.40215942f, -0.48248711f, -0.39689946f, 0.16239378f, -0.94261003f, 1.41127527f, -0.23599172f, -0.66459936f, 
    0.28270319f, -0.25280854f, 0.53774464f, -0.44625768f, -0.11201391f, -0.35679370f, -0.22914580f, -0.18292917f, 
    -0.01891049f, -0.06297054f, 0.03418211f, -0.15339130f, 0.06121138f, -0.20843217f, -0.14845642f, -0.42919865f, 
    0.12158137f, 0.02459312f, 0.05760084f, 0.17678632f, 0.21833248f, 0.37029445f, -0.32562557f, -0.87514889f, 
    0.36912388f, 0.10614780f, -0.22830673f, 0.23529673f, -0.47934967f, 0.32048640f, 0.07234966f, -0.32123962f, 
    -0.26096553f, 0.22301880f, -0.15854706f, 0.16185530f, -0.27128950f, 0.30761215f, 0.21146417f, -0.23360667f, 
    -0.27677548f, 0.12802723f, 0.35552973f, -0.11411762f, -0.04977952f, 0.29314125f, 0.32827184f, -0.72158372f, 
    -0.21708204f, 0.87791449f, 0.65283746f, -0.91060776f, -0.32381821f, 0.12198022f, -0.57581717f, 0.14920013f, 
    0.51805592f, 0.38027713f, 0.03655538f, 0.03293062f, 0.17774501f, -0.09480755f, 0.03781987f, 0.02717358f, 
    -0.06654281f, 0.27531424f, 0.08883917f, -0.02765198f, 0.20347320f, -0.17175044f, 0.12471416f, 0.53375155f, 
    0.72111452f, 0.58699489f, 0.56178927f, -0.26464626f, -0.42655665f, 0.02963301f, 0.16937876f, 0.03988037f, 
    0.22036843f, 0.44411674f, -0.07408912f, -0.51276255f, -0.21519202f, -0.52589971f, -0.34318215f, -0.12194034f, 
    0.19196953f, -0.19746418f, -0.39905885f, 0.19535466f, 0.43474784f, -0.15060446f, -0.03311919f, -0.17884040f, 
    0.86706370f, 0.61137450f, -0.29143149f, 0.62021279f, 0.67107642f, 0.02880500f, 0.59445214f, 0.67453045f, 
    0.34753269f, 0.13549499f, -0.38800842f, -0.03946054f, 0.03931263f, -0.36549130f, -0.04429832f, 0.14331725f, 
    0.15207019f, 0.06205161f, 0.08459425f, 0.04581305f, 0.11538540f, -0.07693955f, 0.08493713f, 0.18433957f, 
    0.11357475f, 0.71783322f, -0.02350588f, -0.65145665f, -0.66249555f, 0.11497779f, -0.24954863f, 0.54342693f, 
    -0.34462762f, 0.22195338f, -0.51880538f, -0.39282492f, -0.17455891f, -0.32432938f, 0.38521722f, -0.19649872f, 
    -0.24758664f, 0.33810496f, -0.30931553f, -0.01641494f, 0.31454310f, 0.24994382f, -0.19633372f, 0.33315185f, 
    0.04589311f, -0.01723010f, -0.07250477f, -0.35685918f, -0.52138817f, -0.06125277f, -0.62865764f, 0.06442332f, 
    -0.47574052f, 0.10558236f, 0.07552239f, -0.46434847f, -0.29743418f, -0.43288243f, -0.06694687f, -0.40501383f, 
    0.22607803f, -0.01343825f, -0.30565956f, 0.16710407f, -0.40780640f, 0.11851119f, 0.36317730f, 0.43014449f, 
    -0.12173033f, 0.19643472f, -0.45840234f, -0.41703683f, -1.04229653f, -0.59835970f, -0.38394955f, -0.32274485f, 
    -0.57037497f, 0.72474366f, 0.57149613f, -0.08255144f, 0.08233838f, -0.10154267f, -0.23415782f, -0.06555738f, 
    0.12879053f, -0.11207824f, -0.08276621f, -0.02997839f, -0.19756134f, -0.16528949f, -0.17022102f, -0.09940983f, 
    0.14410190f, 0.24993952f, -0.06911986f, 0.09676137f, 0.60859144f, -0.15366758f, -0.56472647f, -0.08695731f, 
    -0.01930819f, -0.39775869f, 0.04799572f, 0.44962683f, -0.30349571f, 0.39979827f, 0.34314582f, 0.41211668f, 
    0.18512645f, -0.45337078f, -0.29422122f, -0.33163914f, -0.04249026f, 0.13196571f, 0.21166579f, -0.30083352f, 
    -0.14745419f, 0.14600676f, -0.45853356f, 0.11303640f, -0.09189466f, 0.55243891f, -0.53396839f, 0.30694115f, 
    -0.29357076f, -0.17465790f, -0.43219513f, -0.02782546f, 0.32101309f, 0.31999999f, -0.10179389f, 0.00757082f, 
    0.46858174f, 0.12667318f, 0.02172802f, -0.43497023f, 0.12047523f, -0.30588514f, -0.39752632f, -0.36314142f, 
    -0.35777122f, -0.10922182f, -0.03147497f, 0.03666719f, 0.15342596f, 0.12977627f, -0.26906908f, -0.35634768f, 
    -0.06959407f, -0.19842803f, 0.13433123f, -0.04371685f, -0.60525084f, -0.92633468f, -0.63724512f, -0.65612096f, 
    0.36366719f, 0.29741618f, -0.17625362f, -0.16747148f, 0.10381345f, 0.41884834f, -0.45542282f, -0.44740525f, 
    -0.36127418f, 0.02062123f, -0.05835876f, 0.37184617f, 0.37450355f, -0.04247259f, 0.15902457f, -0.17993513f, 
    0.91559571f, 0.79126137f, 0.05748173f, 0.40012851f, 0.48453191f, 0.19049618f, 0.43438533f, -0.49174660f, 
    -0.35061240f, 0.12751606f, -0.04172448f, 0.40649596f, -0.14647995f, -0.32500023f, 0.09884429f, 0.04062230f, 
    0.07419479f, -0.21069959f, 0.21986273f, 0.04954296f, -0.05961354f, 0.13037853f, 0.02576996f, 0.23186341f, 
    -0.00943427f, 0.75382316f, -0.11925611f, -0.52364945f, -0.27758679f, -0.61101502f, 0.49843863f, 0.53119832f, 
    -0.17874207f, 0.37336621f, -0.32041225f, -0.06307865f, 0.08174655f, -0.55398762f, -0.24411924f, -0.42217621f, 
    -0.37481606f, -0.18798992f, -0.38777098f, -0.04106006f, -0.02721868f, -0.07905558f, -0.00710931f, 0.12640859f, 
    -0.13750963f, 0.90464151f, 0.83410323f, -0.97148979f, -0.40685096f, -0.37374392f, -0.11718839f, 0.01717619f, 
    -0.41329044f, 0.14141859f, -0.31172800f, 0.24085906f, 0.00347516f, 0.30011904f, -0.00858625f, -0.12983400f, 
    0.06616952f, -0.46520036f, -0.14077587f, -0.02540248f, 0.19596189f, 0.15690799f, -0.02117307f, 0.01810844f, 
    -0.09676606f, -0.17731707f, -0.41604653f, -0.56068933f, -0.63039619f, -0.23186101f, -0.35142353f, 0.17710203f, 
    0.39151245f, 0.50621670f, 0.00531034f, 0.04692101f, -0.20558979f, 0.01099358f, -0.43631250f, -0.05739813f, 
    -0.53116715f, 0.10954513f, -0.00941119f, 0.32779726f, -0.18902653f, 0.03663104f, 0.19913462f, -0.13280505f, 
    -0.17536499f, -0.18296474f, 0.23821156f, 0.63993180f, 0.17733376f, -0.70301461f, -0.57338977f, -0.22220685f, 
    0.09495103f, 0.10306620f, -0.27671048f, -0.29701605f, 0.41295257f, 0.24380767f, -0.21813457f, 0.36169779f, 
    0.20436665f, 0.09351792f, 0.14379610f, 0.34510875f, -0.32435986f, 0.13591400f, 0.60227853f, 0.02556691f, 
    -0.17338142f, 0.32180673f, 0.21695749f, -0.13542500f, 0.27262491f, 0.45202455f, 0.70100814f, 0.71852189f, 
    -0.71450073f, -0.88307333f, 0.05260441f, -0.31699789f, 0.03575721f, -0.17668995f, 0.46420181f, 0.10572251f, 
    -0.35447004f, 0.23538062f, 0.28540117f, -0.05343005f, 0.12544471f, -0.03026016f, 0.21160097f, 0.28198555f, 
    -0.42103657f, 0.12962390f, 0.25572869f, 0.34367335f, -0.11284431f, 0.13418721f, 0.95882291f, 0.46991715f, 
    0.42458662f, 0.45654005f, 0.69796318f, -0.23480237f, -0.79494458f, 0.04594485f, -0.43482214f, -0.18974578f, 
    0.14486778f, 0.17834258f, 0.40663755f, 0.11653820f, 0.13459949f, 0.17224631f, 0.07892654f, -0.12473236f, 
    -0.05786208f, -0.00224644f, 0.07703298f, 0.09871425f, -0.36766204f, -0.15531309f, -0.45644113f, 0.45092711f, 
    0.47425333f, 0.35332999f, 0.52735221f, -0.90101314f, 0.00971889f, 0.02877788f, -0.65089434f, 0.17050381f, 
    0.38892075f, 0.00678281f, -0.10740718f, 0.22496900f, 0.17365719f, 0.21706669f, -0.06545630f, 0.11609725f, 
    0.08236378f, 0.08743197f, 0.43264273f, -0.28084320f, 0.24615064f, -0.20470899f, -0.12845486f, 1.07151890f, 
    0.35779864f, -0.40581349f, 0.33343473f, 0.77752149f, 0.60033321f, 0.12455746f, 0.03854289f, -0.05185483f, 
    -0.52985758f, -0.52991456f, -0.08531009f, 0.11939473f, -0.21237266f, -0.35444406f, -0.20313106f, -0.16745548f, 
    0.21291852f, 0.01850612f, -0.15734418f, 0.08067281f, -0.04670934f, 0.04534532f, 0.28644940f, 0.23681724f, 
    -0.45979950f, 0.76103663f, 0.25387257f, -0.59903681f, 0.80489624f, -0.47632128f, 0.43361062f, 0.41826728f, 
    -0.18302478f, 0.51632690f, -0.27016208f, 0.05086518f, -0.36044666f, -0.35517162f, -0.34741434f, -0.18417870f, 
    -0.04993178f, -0.35496920f, -0.14159794f, 0.05260133f, 0.13139449f, 0.21935774f, -0.07578114f, -0.26581952f, 
    -0.00183400f, 0.75479066f, 0.11540960f, 0.01914330f, 0.86921167f, 0.51730287f, 0.53908736f, 0.16402195f, 
    -0.54585969f, -0.00502033f, 0.12396883f, -0.31974936f, -0.09564140f, 0.13486104f, 0.18882133f, -0.10167144f, 
    0.05823230f, 0.20659648f, 0.31796333f, 0.07947239f, 0.26845959f, 0.41272369f, -0.12550716f, 0.17501698f, 
    -0.12625687f, 0.02936508f, 0.85651946f, 0.66100574f, 0.64702111f, -0.13637601f, 0.47440246f, 0.08470986f, 
    0.35755739f, 0.30941349f, 0.36906314f, 0.41348240f, -0.27891397f, 0.40060136f, 0.17369734f, 0.09976059f, 
    0.21309890f, 0.35664210f, 0.13190034f, -0.27784657f, -0.01874384f, -0.21708633f, -0.18604629f, -0.35012528f, 
    0.24674466f, -0.21005131f, -0.30960718f, -0.04649816f, 0.44337606f, 0.71591377f, 0.76880527f, 0.27933306f, 
    0.38597280f, 0.27813232f, 0.33368352f, -0.36015731f, 0.37010148f, -0.07541247f, -0.14677680f, -0.06120602f, 
    -0.35005391f, 0.16549735f, -0.12976822f, -0.49440518f, -0.22551958f, 0.15293948f, -0.01528708f, 0.39337263f, 
    0.11135139f, 0.12239246f, 0.33737969f, 0.00496730f, -0.77121544f, 0.00407595f, -0.94547433f, -0.55728370f, 
    0.18941507f, -0.60594451f, 0.62657112f, 0.32440308f, 0.29065391f, 0.67166775f, 0.44459423f, -0.10451955f, 
    0.46535957f, -0.30339187f, 0.23171255f, -0.04880088f, 0.23050588f, -0.06337376f, 0.09198973f, -0.04239714f, 
    0.03517614f, 0.19674881f, -0.12026148f, 0.36821976f, -0.15853867f, 0.45470241f, 0.19182166f, 0.46447134f, 
    0.23228726f, 0.75207978f, 0.85064662f, -0.07739257f, -0.56233168f, -0.07170816f, -0.25927049f, 0.27490857f, 
    0.29149392f, -0.31120706f, 0.32546663f, -0.18269297f, -0.22158900f, -0.08315640f, 0.32326296f, 0.54716653f, 
    0.15643618f, 0.30498007f, 0.06450897f, -0.15441765f, -0.17340235f, 0.03835357f, 0.03206987f, 0.17650864f, 
    0.68605518f, -0.38923186f, 0.01587523f, -0.41270339f, 0.43472248f, 0.16858228f, 0.25544226f, -0.51645565f, 
    0.08378759f, 0.11157379f, 0.49370536f, 0.34143463f, -0.19295312f, 0.20569931f, -0.50899208f, -0.25124875f, 
    -0.16472697f, 0.11625154f, 0.09071767f, -0.10025072f, -0.20587553f, 0.02644721f, 0.42522606f, 0.25446010f, 
    -0.70588893f, -0.40384921f, -0.57661724f, 0.10351355f, 0.84932941f, -0.63938290f, 0.24123292f, 0.19391823f, 
    -0.06345057f, -0.01041723f, -0.08142669f, -0.00535936f, 0.23779564f, 0.02750280f, -0.01135711f, 0.05670985f, 
    -0.25376767f, -0.04595944f, -0.33466855f, 0.07085154f, 0.19527984f, 0.11881885f, -0.07436998f, 0.11136581f, 
    0.48651534f, 0.53809673f, 0.55643737f, 0.58635008f, -0.14436758f, -0.78005272f, -0.54821885f, -0.44322169f, 
    0.06697415f, -0.05514472f, 0.33690932f, -0.18606377f, 0.17178869f, 0.11372428f, -0.51646256f, -0.35000053f, 
    0.18634565f, -0.11776735f, -0.28177759f, -0.23036465f, -0.03556190f, -0.16843267f, 0.16074850f, -0.05931019f, 
    0.23900002f, -0.19593997f, -0.09789078f, 0.32145053f, 0.16441205f, 0.30814594f, -0.87642634f, 0.40172416f, 
    -0.49392810f, -0.58575976f, 0.24503547f, 0.35069731f, 0.22313491f, 0.04064124f, -0.08246589f, -0.46702567f, 
    0.29143015f, 0.17493092f, -0.00582622f, 0.34582084f, 0.40775323f, 0.16416593f, -0.04077016f, 0.11807761f, 
    0.12088207f, 0.00815611f, -0.02958087f, -0.60852367f, 0.27608261f, 0.89352947f, -0.55819547f, -0.68672168f, 
    0.42698351f, 0.51959383f, -0.53999174f, 0.03028825f, -0.01775381f, 0.06366389f, -0.33453897f, 0.09405582f, 
    0.06050942f, -0.49407053f, -0.15672992f, 0.11569370f, 0.12378646f, -0.66933990f, 0.09395415f, -0.34677988f, 
    -0.43256089f, -0.02264469f, -0.11890879f, -0.81005043f, 0.66931540f, -0.60935372f, -0.61235929f, -0.76037014f, 
    0.50588173f, 0.13490464f, -0.39106441f, 0.60123456f, -0.02326750f, -0.17784174f, 0.19029665f, -0.08802143f, 
    0.03245526f, -0.23817767f, 0.05885576f, 0.15398575f, 0.12642598f, 0.16851427f, -0.25637951f, -0.13883279f, 
    -0.22583370f, 0.13435359f, -0.06854214f, 0.30375221f, -0.66937625f, 0.24750206f, 0.53641003f, -0.52526206f, 
    -0.07747000f, -0.54251963f, -0.30060509f, 0.28565645f, 0.17655221f, 0.24281569f, -0.10572987f, 0.25072885f, 
    0.26660505f, -0.44814849f, 0.26473424f, 0.40933973f, -0.04317509f, -0.00807029f, 0.23319794f, 0.38599563f, 
    0.25543162f, 0.25448376f, -0.11422605f, -0.29195505f, 0.51381046f, 0.89139330f, 0.41989911f, -0.08391267f, 
    0.79640734f, 0.58626568f, 0.06513960f, 0.09365139f, -0.65363789f, 0.47502556f, -0.16432101f, 0.15663937f, 
    -0.37266710f, -0.20927149f, 0.09449993f, -0.47242141f, 0.43278971f, 0.13653201f, -0.16057590f, -0.10883441f, 
    0.30827138f, -0.15824197f, 0.16391370f, 0.12270612f, -0.26937333f, 0.16871794f, -0.55359119f, 0.66945434f, 
    0.41686091f, 0.05175384f, 0.61720401f, 0.37115780f, -0.36972269f, -0.81394857f, -0.55029666f, -0.50500190f, 
    0.07953236f, 0.00100331f, 0.49829844f, 0.25563726f, -0.16636901f, -0.34621698f, -0.40634587f, 0.20756999f, 
    -0.30701828f, 0.20378137f, -0.01680126f, -0.00054918f, -0.17487107f, 0.06453191f, -0.16102912f, -0.14175992f, 
    0.63308007f, -0.40973037f, -0.05276956f, -0.18760136f, -0.82139772f, -0.86426336f, -0.21986422f, -0.05538959f, 
    -0.42431447f, 0.02296331f, -0.13205408f, 0.19863388f, -0.04864073f, -0.28460819f, 0.06995311f, -0.23532441f, 
    0.12567653f, 0.03567717f, -0.30953687f, 0.38147771f, 0.19543664f, 0.07721099f, -0.14924546f, 0.17513667f, 
    0.04701572f, 0.66580993f, 0.74377882f, -1.22051632f, 0.26363322f, -0.27604288f, -0.01535141f, 0.38771906f, 
    0.38227892f, -0.17887163f, 0.30047002f, 0.45976961f, -0.37686554f, 0.25565439f, 0.10012420f, 0.19159169f, 
    0.06063114f, 0.08743532f, -0.10773716f, 0.16348729f, 0.00735391f, 0.06680893f, -0.03122839f, -0.07981533f, 
    0.20821422f, -0.73461479f, 0.13049036f, 0.04520711f, -0.62889695f, 0.01777645f, 0.20656702f, -0.52579010f, 
    -0.12190237f, -0.14432238f, -0.61738640f, -0.08399485f, -0.28199765f, 0.12212238f, 0.51212192f, -0.35267365f, 
    0.14834945f, 0.05942762f, -0.16359898f, 0.02204988f, 0.39957884f, -0.20029625f, 0.14440244f, 0.22301026f, 
    -0.08992993f, -0.29926923f, -0.51839697f, -0.78673834f, -0.63832265f, 0.06306626f, -0.24807303f, -0.69017720f, 
    -0.04770483f, 0.71241945f, -0.20349951f, 0.31433848f, 0.38878632f, 0.02797167f, 0.26401606f, -0.35283139f, 
    -0.28895104f, -0.12447136f, 0.23689508f, 0.18382879f, 0.18040922f, -0.51000249f, 0.05875758f, -0.34082970f, 
    0.17715426f, 0.00726370f, 0.26759160f, 0.90714544f, 0.53781426f, 0.72184306f, 0.55843723f, 0.41459969f, 
    0.04312527f, -0.59426504f, -0.45373547f, 0.06859267f, -0.30956161f, 0.22318187f, 0.07468253f, -0.08579021f, 
    0.16136879f, 0.01519751f, 0.15131210f, 0.10509051f, -0.08915045f, -0.16704676f, 0.14605066f, -0.41144365f, 
    0.20823821f, 0.26275420f, 0.33803573f, 0.51932496f, -0.65819728f, -0.36975175f, 0.16576338f, -0.54150468f, 
    -0.68580765f, 0.34490365f, -0.81616867f, -0.21261334f, -0.32753775f, -0.14559612f, -0.02107771f, -0.09044947f, 
    -0.08061594f, 0.50395346f, 0.23271416f, -0.10479156f, 0.04445912f, 0.09517306f, -0.09623376f, -0.19279510f, 
    0.11204337f, 0.39132258f, -0.02850150f, 0.33017138f, 0.13425857f, -0.47357646f, -0.54003716f, 0.52799386f, 
    0.46330711f, -0.13937920f, -0.86831802f, 0.57448691f, 0.44044471f, -0.34312615f, 0.08316508f, -0.32415140f, 
    0.00060155f, 0.13137054f, -0.13624054f, 0.22206952f, 0.08981556f, 0.34493637f, 0.28589728f, -0.30104402f, 
    -0.01464789f, -0.20616472f, -0.04374298f, -0.37206811f, 0.05894416f, -0.07092929f, 0.25642273f, 0.23713566f, 
    -0.39675689f, -0.37994561f, 0.74016988f, 0.47794321f, -0.72416449f, 0.44775152f, 0.39585382f, 0.22758660f, 
    -0.23627776f, -0.11292036f, -0.38218454f, -0.29083106f, 0.27962101f, 0.33601376f, -0.03534697f, -0.00312842f, 
    0.08318816f, 0.29171884f, -0.51111954f, -0.05867311f, -0.01728694f, 0.22715940f, -0.49049827f, -0.67641693f, 
    0.48641220f, -0.27403376f, -0.67003947f, -0.15204518f, 0.57082802f, 0.38860232f, -0.07817966f, -0.05763941f, 
    0.11235013f, -0.28366864f, 0.13837858f, 0.17485748f, -0.14078817f, -0.16949759f, 0.22320515f, -0.37659630f, 
    -0.06933645f, -0.34240651f, 0.05350982f, -0.15970361f, -0.34159020f, 0.32257816f, 0.31097859f, 0.06762028f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25938803f, 0.18172383f, 0.33947033f, 0.21814859f, 0.11647811f, 0.18222810f, -0.10413113f, 0.20576234f, 
    0.28209442f, 0.24931060f, 0.17718743f, 0.10547222f, 0.14595594f, 0.09233076f, 0.15078554f, 0.18294573f, 
    0.14229263f, 0.07040578f, -0.02040380f, 0.08533239f, 0.13478146f, 0.10973150f, 0.03961413f, 0.17767288f, 
    0.08291920f, 0.02088008f, 0.17277673f, 0.09415476f, 0.01661738f, 0.09166063f, -0.01980831f, 0.16508290f, 
    -0.02510776f, 0.12132488f, 0.01369614f, 0.33511174f, 0.13123566f, -0.07479284f, 0.04357203f, -0.12471466f, 
    0.11010385f, 0.17592572f, 0.28282803f, 0.19337399f, 0.08767390f, -0.12930028f, 0.08606007f, 0.21711019f, 
    0.09594513f, 0.10368416f, -0.04522348f, 0.32243210f, 0.18182462f, 0.13644168f, 0.28501877f, 0.30713373f, 
    0.19313687f, 0.25243425f, 0.13696505f, 0.13566144f, 0.18434708f, 0.08895352f, 0.08906271f, -0.05834205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14517821f, -0.13115834f, -0.10798914f, 0.01831277f, -0.02378115f, -0.04965027f, -0.03666227f, 0.10388163f, 
    0.01660062f, 0.01941511f, 0.03081291f, -0.03288427f, 0.14737132f, -0.08253889f, -0.23903504f, -0.18954989f, 
    -0.05039128f, -0.10291043f, -0.01171989f, -0.04932578f, 0.00898138f, -0.02241002f, 0.06615940f, 0.00253016f, 
    0.06159485f, -0.03470930f, -0.11015473f, 0.18752062f, -0.08824919f, -0.06608739f, -0.05426814f, 0.01202844f, 
    -0.04996180f, 0.01968106f, 0.01034414f, -0.05197557f, -0.29389077f, -0.04705381f, 0.14760947f, -0.14499590f, 
    -0.08209430f, -0.05780288f, -0.02693336f, 0.10669182f, -0.15619756f, -0.00651947f, 0.04046433f, -0.08094466f, 
    -0.09257302f, 0.14051494f, 0.10273544f, -0.22832505f, -0.04048813f, 0.04350561f, 0.05777956f, 0.00361558f, 
    0.00180320f, 0.00268797f, 0.00835676f, -0.00717560f, 0.23704462f, -0.30097985f, 0.15692440f, 0.11452155f, 
    -0.06218590f, 0.12765086f, 0.08241150f, 0.04618760f, -0.06988203f, -0.02907632f, 0.05560291f, -0.08008128f, 
    0.18753465f, 0.05865652f, -0.04235289f, 0.03746623f, -0.11805546f, -0.18316446f, 0.11557811f, 0.05452128f, 
    0.04814173f, -0.04147207f, -0.02684849f, 0.06195292f, 0.09788103f, 0.02744863f, -0.03296287f, -0.27824104f, 
    0.16354418f, -0.06691062f, -0.01242790f, -0.01213706f, 0.01543073f, 0.03585870f, 0.01627601f, -0.05291385f, 
    0.08353354f, 0.11180441f, -0.08738348f, -0.23526582f, -0.00082067f, -0.00003062f, 0.05504953f, -0.01954403f, 
    -0.04144512f, -0.02199504f, 0.02624259f, 0.01317744f, -0.01843457f, 0.11477069f, 0.22327778f, 0.13240923f, 
    -0.05839361f, 0.09458902f, -0.07361288f, 0.02742216f, 0.06345159f, 0.03511633f, -0.08454587f, 0.00377978f, 
    -0.15830117f, -0.05605013f, 0.08252201f, -0.29841745f, -0.07140967f, -0.02142145f, -0.01485993f, -0.00327602f, 
    0.04626882f, -0.07728474f, -0.06451512f, 0.04271821f, -0.26255935f, 0.11524829f, -0.00737701f, -0.21106015f, 
    0.02940599f, -0.08129052f, 0.09134988f, -0.00396499f, -0.07600781f, -0.11209038f, -0.01479658f, 0.10383075f, 
    0.17765155f, 0.08109412f, 0.19255583f, -0.22272287f, 0.00204141f, -0.02713697f, -0.04184261f, 0.03046072f, 
    0.13310003f, -0.02812953f, 0.05123919f, 0.07559260f, -0.03036665f, 0.20407820f, 0.12826465f, 0.14515308f, 
    0.04661167f, 0.04018284f, 0.07201190f, -0.00857399f, -0.00745252f, 0.04104421f, -0.00122795f, -0.01730627f, 
    0.12483517f, -0.02403201f, 0.20899110f, -0.22408611f, -0.07697427f, 0.13781843f, 0.05048092f, -0.08239765f, 
    0.08307341f, -0.05425457f, 0.00498109f, -0.01623509f, 0.27581072f, 0.09578057f, 0.02898132f, 0.03066745f, 
    0.00513420f, -0.00024952f, -0.01195548f, -0.04331276f, -0.00752003f, -0.06384847f, -0.05348568f, 0.00004044f, 
    0.18169741f, -0.03685021f, 0.02295202f, 0.18966284f, -0.14070274f, -0.05550086f, 0.04534716f, 0.03050217f, 
    -0.13362440f, 0.05033321f, -0.05991407f, -0.11324951f, -0.08410551f, -0.05303483f, -0.15428706f, 0.15276286f, 
    0.07499205f, 0.02126949f, -0.05256103f, 0.04375162f, 0.00927647f, 0.07850634f, -0.10046081f, -0.04034986f, 
    0.24485731f, 0.18317182f, 0.16471361f, 0.01392974f, 0.08174111f, 0.12691760f, -0.06620582f, 0.07907986f, 
    -0.04462345f, 0.05525978f, 0.09565061f, -0.05087560f, -0.01929598f, 0.00271021f, 0.07974058f, -0.18383680f, 
    -0.11873865f, -0.06915262f, -0.00189405f, 0.14384820f, -0.08781906f, -0.03178159f, 0.05376096f, 0.12157750f, 
    0.11415201f, -0.05636685f, 0.10790425f, -0.15211892f, 0.04848250f, -0.04002860f, 0.05746632f, -0.06013396f, 
    -0.00791120f, -0.09609424f, -0.09483883f, -0.04842251f, -0.09884390f, 0.11270133f, 0.02973473f, 0.16883476f, 
    0.03381372f, 0.02419247f, 0.12039363f, -0.04673755f, 0.02896385f, 0.06495821f, 0.01961938f, 0.09456582f, 
    0.25776780f, -0.22824061f, -0.06173246f, 0.23165852f, -0.13989642f, 0.01892170f, -0.01457126f, -0.09538431f, 
    -0.02702546f, -0.02140505f, -0.05028925f, -0.04526451f, 0.08238318f, 0.09446628f, -0.10543452f, 0.04985598f, 
    -0.10412706f, -0.08710284f, -0.03411237f, -0.15845649f, -0.09053491f, -0.02459126f, 0.00285656f, -0.05457835f, 
    0.05904206f, 0.03064315f, -0.01263795f, 0.12906395f, -0.24237981f, 0.02226268f, -0.00569406f, 0.08828370f, 
    -0.07601479f, 0.07036868f, 0.11381264f, -0.02970112f, -0.16395769f, 0.05014503f, 0.00938659f, -0.29322213f, 
    -0.13473511f, 0.05462249f, 0.06565678f, -0.01956661f, -0.03326845f, 0.00111455f, 0.10696577f, -0.07383455f, 
    0.02628564f, -0.03855493f, -0.16484269f, 0.03998669f, 0.00591987f, 0.14282665f, 0.06989840f, -0.03804982f, 
    -0.13271351f, -0.02928247f, 0.00656942f, 0.01017667f, -0.25954908f, 0.13143647f, -0.07761876f, -0.26221970f, 
    0.03583700f, 0.04623801f, 0.02331351f, 0.02803937f, 0.04966705f, 0.04898940f, -0.01859686f, 0.12412157f, 
    -0.13102567f, -0.05613332f, -0.12598342f, -0.09897135f, 0.01933405f, -0.07541148f, 0.01836694f, 0.03284775f, 
    0.03261914f, 0.09282140f, -0.04756719f, 0.02907533f, 0.08602578f, -0.03343420f, 0.03077563f, -0.02069134f, 
    -0.07229465f, 0.00254210f, -0.04285982f, -0.03821655f, 0.10557966f, 0.04830246f, 0.14764115f, -0.05387693f, 
    -0.33650091f, -0.33383140f, 0.16334447f, 0.05179451f, 0.02680807f, 0.00440156f, 0.02059487f, 0.07032491f, 
    -0.01744683f, -0.05040422f, 0.08926847f, -0.00801708f, -0.13645373f, -0.00810996f, 0.07312638f, -0.13616948f, 
    -0.00350086f, -0.15192132f, 0.05323087f, -0.00302016f, -0.08852164f, -0.10986409f, -0.04816561f, 0.00169686f, 
    -0.04061716f, -0.07180464f, 0.04341858f, -0.00620837f, -0.10073940f, 0.05968612f, -0.10650261f, -0.03253340f, 
    0.11462270f, 0.06245613f, 0.08986560f, 0.08267877f, -0.24804221f, 0.08773004f, 0.07441232f, -0.23164263f, 
    -0.22227311f, 0.05052948f, 0.01553497f, 0.12765223f, 0.01781444f, -0.13287559f, 0.06670553f, 0.08442660f, 
    -0.00223608f, 0.06446052f, -0.00513247f, -0.32170290f, 0.07619506f, 0.11110494f, 0.04284668f, 0.03591907f, 
    -0.03103524f, -0.02818921f, -0.05874951f, 0.00201909f, -0.12562163f, -0.04489930f, 0.10593990f, -0.12046441f, 
    -0.06608577f, 0.05507548f, 0.04868896f, 0.02569047f, -0.15731138f, -0.02477353f, 0.07652882f, 0.06766780f, 
    0.03337249f, -0.01483027f, -0.26503572f, 0.28960532f, -0.08628505f, 0.03100335f, -0.10768238f, 0.01859068f, 
    0.06143294f, -0.00340703f, -0.02530083f, -0.04052138f, -0.07120878f, 0.12242512f, -0.00032128f, -0.08015231f, 
    -0.08304541f, -0.09023755f, 0.05438454f, 0.01674797f, -0.04943670f, 0.05806691f, -0.08687701f, -0.01616300f, 
    -0.06807926f, 0.09953541f, 0.05303673f, 0.01123059f, -0.00525810f, -0.03743254f, 0.07150643f, -0.14143278f, 
    0.06037372f, -0.07897974f, -0.04658995f, -0.06040084f, 0.18414685f, -0.00301550f, -0.02603988f, 0.04001657f, 
    -0.00031299f, 0.00220465f, -0.07252834f, 0.07752075f, -0.13073717f, 0.05586551f, 0.02142932f, 0.05081606f, 
    -0.15960018f, 0.04345838f, 0.19628981f, -0.30175355f, -0.00047495f, 0.05341065f, 0.04871226f, -0.16459250f, 
    -0.03061602f, -0.05785101f, -0.01296979f, 0.07646256f, 0.09816121f, -0.06263074f, -0.07815449f, 0.28684744f, 
    -0.06784375f, -0.06895948f, -0.05102075f, 0.03101313f, -0.02878232f, 0.08900301f, -0.02652011f, 0.06456729f, 
    0.09867141f, -0.12315685f, -0.04974820f, -0.19743413f, -0.16152447f, -0.02565210f, -0.04510029f, 0.06606691f, 
    0.06780968f, 0.00622986f, 0.03594644f, -0.12190719f, -0.02440808f, 0.12078951f, 0.04597137f, 0.08330594f, 
    0.01494498f, -0.06455364f, 0.06637660f, -0.12828788f, -0.01602534f, 0.00551651f, -0.03693633f, -0.01111015f, 
    0.07088934f, 0.22928597f, -0.07464979f, -0.06913106f, 0.05133948f, 0.11267641f, -0.06342109f, -0.02474361f, 
    -0.05832254f, -0.02304953f, -0.01531372f, 0.08251152f, 0.10690732f, -0.11107702f, 0.11059432f, -0.03896583f, 
    -0.16983080f, -0.01908371f, 0.05858841f, -0.03088978f, 0.07783920f, 0.07257146f, -0.05152720f, 0.01941620f, 
    -0.06079660f, -0.03027877f, 0.08597666f, -0.08960245f, -0.13579769f, -0.02653539f, -0.01920095f, 0.02900114f, 
    0.07338966f, 0.02878008f, -0.00324163f, -0.02473552f, 0.24917623f, -0.17372553f, 0.09270224f, -0.19612961f, 
    0.02726260f, -0.01192461f, 0.05521545f, -0.07815856f, -0.07791439f, 0.01663464f, 0.07526124f, -0.06143170f, 
    0.13831921f, 0.00332625f, -0.07213822f, 0.14942726f, -0.11899851f, -0.07637343f, -0.06161532f, -0.06883677f, 
    -0.03691476f, -0.04581254f, -0.00002937f, -0.08864698f, 0.06973436f, -0.19723171f, 0.10269724f, 0.10881056f, 
    -0.06980616f, 0.01384001f, -0.03130872f, 0.09769453f, 0.08077069f, 0.09265333f, -0.03518949f, 0.03915979f, 
    -0.24307089f, 0.00097452f, -0.17021145f, 0.09722058f, 0.01198404f, 0.00056557f, 0.10952585f, -0.11399116f, 
    -0.00587234f, 0.06912160f, 0.00758931f, 0.02175852f, 0.46592090f, 0.08121069f, -0.04889577f, -0.29037657f, 
    0.03593844f, -0.02686424f, -0.00598074f, -0.05860319f, 0.02784053f, -0.06681798f, -0.06983040f, -0.03692224f, 
    -0.09412232f, 0.11113721f, -0.00544680f, 0.03077474f, 0.00283949f, 0.03734798f, -0.17847688f, 0.05350386f, 
    -0.02107542f, -0.09061322f, 0.04675346f, -0.02633553f, 0.05455993f, -0.00588658f, -0.07966306f, 0.23986238f, 
    -0.06925136f, 0.01859558f, -0.01723154f, 0.07873487f, 0.05223275f, 0.03079886f, -0.06212783f, -0.18477909f, 
    -0.14899658f, 0.04552148f, 0.08020568f, -0.10035883f, -0.11112828f, -0.18224835f, 0.08595860f, 0.00167402f, 
    0.06155698f, -0.08362647f, -0.08013548f, -0.01700597f, 0.03466156f, 0.05591378f, 0.07657739f, -0.05399496f, 
    -0.03878180f, -0.03465052f, -0.05539079f, 0.02996837f, -0.10963388f, -0.02919926f, 0.09704081f, -0.00231077f, 
    -0.30209222f, 0.17364244f, 0.04583799f, -0.19197220f, -0.09040084f, 0.01454921f, -0.06145675f, -0.03642699f, 
    0.03306548f, -0.00784828f, 0.02538594f, 0.03531218f, -0.25113487f, 0.01276737f, 0.01050783f, -0.03483613f, 
    -0.01463552f, 0.05063507f, -0.09724404f, 0.05390130f, 0.05672503f, -0.11062910f, -0.00333647f, -0.06854664f, 
    -0.40750816f, 0.05654830f, -0.11474625f, -0.07730602f, 0.07389700f, -0.06131347f, -0.08360925f, 0.07988342f, 
    0.07166775f, 0.12705185f, -0.17931733f, 0.06507562f, 0.16204788f, -0.06035892f, 0.02450779f, 0.07498665f, 
    -0.03539750f, -0.17060547f, -0.06586750f, 0.06529040f, 0.08159035f, -0.03062699f, -0.15842408f, 0.00314526f, 
    -0.30376047f, -0.08369861f, -0.06672154f, -0.09220169f, -0.03511659f, 0.07111484f, 0.02897003f, -0.11813699f, 
    -0.01015033f, 0.09525168f, -0.05774568f, 0.08518159f, -0.18028028f, 0.03595951f, -0.10228998f, 0.31738240f, 
    0.01141036f, 0.02366278f, 0.06749527f, 0.01010902f, 0.00926155f, -0.00616946f, 0.01264656f, -0.04373621f, 
    0.25542024f, -0.07375844f, 0.22955556f, -0.04066217f, -0.12344599f, 0.08691317f, 0.07588506f, 0.03643247f, 
    -0.11845189f, -0.09397922f, -0.02619250f, 0.06527412f, 0.30869538f, -0.01895230f, 0.07626195f, -0.14261796f, 
    0.06089754f, -0.06731945f, -0.00156844f, 0.02729703f, 0.00166890f, -0.06179705f, -0.09107303f, 0.00521618f, 
    -0.07939052f, 0.00445564f, 0.03655979f, 0.08182047f, 0.08488755f, 0.04000422f, -0.00020175f, 0.02507651f, 
    0.12909907f, -0.04484920f, 0.03732286f, 0.03813530f, 0.24873865f, -0.20269777f, 0.13944685f, -0.08638317f, 
    0.07219387f, -0.10115983f, -0.04611747f, 0.03126335f, -0.09190702f, 0.05469389f, -0.08310187f, 0.01910956f, 
    0.07801348f, 0.08941672f, 0.21427624f, 0.16530077f, -0.07393920f, -0.13434361f, 0.06052668f, -0.00572976f, 
    0.03118629f, -0.07320274f, 0.07460526f, 0.03619346f, 0.19035622f, -0.06190326f, -0.02733777f, -0.22885011f, 
    0.11627904f, 0.01391210f, 0.01351222f, -0.02093331f, -0.05004179f, 0.00792042f, 0.05135770f, -0.00705100f, 
    0.15432011f, 0.05901900f, -0.12627700f, -0.14413768f, -0.23076898f, -0.05126245f, -0.08768382f, 0.00952428f, 
    -0.00747316f, -0.01543313f, -0.04768759f, 0.00511228f, -0.00980613f, -0.02450668f, 0.07835156f, -0.02158452f, 
    0.00648244f, -0.01078910f, -0.18914539f, 0.01140455f, 0.00994411f, -0.02463351f, -0.14296393f, 0.15230842f, 
    -0.10174454f, -0.05414429f, 0.18595457f, 0.00410016f, -0.05381582f, 0.08413900f, -0.01108991f, 0.01238006f, 
    -0.04529195f, 0.07573405f, 0.00031638f, -0.01420815f, 0.10348716f, -0.11211883f, 0.09448303f, -0.11050262f, 
    -0.02409173f, -0.16978011f, -0.02733630f, 0.04560616f, -0.03440724f, -0.05560400f, 0.03028519f, -0.01568429f, 
    0.14288297f, -0.19328505f, -0.08570738f, -0.08506964f, 0.10703821f, -0.04449048f, 0.04828048f, 0.01197969f, 
    -0.00865079f, 0.00144616f, -0.03930284f, 0.04316354f, -0.58093458f, 0.11337879f, -0.22884569f, -0.08916616f, 
    -0.01761938f, 0.02449220f, 0.00175500f, 0.03077862f, 0.03337298f, -0.03673571f, 0.08785637f, -0.13847555f, 
    0.26648593f, -0.03629353f, 0.00168335f, 0.11984501f, 0.19613083f, 0.03432805f, -0.04731398f, -0.09368204f, 
    -0.11332716f, 0.11714526f, 0.03155436f, -0.00785097f, 0.05054882f, 0.14024325f, 0.08900210f, -0.02130282f, 
    -0.03291776f, 0.00019912f, 0.02770884f, 0.00548017f, -0.01192941f, 0.02266201f, 0.17539328f, -0.04525448f, 
    0.06239016f, 0.05899647f, -0.16046457f, 0.02065309f, 0.00890729f, -0.17307849f, -0.02887625f, -0.04376403f, 
    -0.06838826f, 0.10666174f, 0.00114138f, -0.04459923f, 0.16004789f, -0.05711688f, -0.01432514f, 0.04941269f, 
    0.00359945f, 0.03664305f, -0.02428877f, 0.03916801f, 0.04601834f, 0.13460135f, -0.01483667f, -0.03255618f, 
    -0.01349563f, -0.06573064f, 0.08767211f, -0.10222650f, 0.02811870f, -0.13207284f, -0.12822546f, 0.12265136f, 
    0.07503308f, 0.07930723f, -0.01852029f, 0.09235333f, -0.21080619f, 0.05257577f, -0.01372566f, 0.05548999f, 
    0.08152067f, 0.12700583f, 0.00729364f, 0.09768901f, -0.02451775f, 0.03673191f, 0.03248001f, 0.06500163f, 
    0.05918455f, 0.10988202f, 0.00207814f, 0.10544698f, -0.02191474f, -0.03171876f, -0.05151728f, -0.04126233f, 
    -0.00570538f, 0.03096445f, 0.09757429f, -0.12517090f, -0.13659538f, -0.01115474f, -0.04978605f, -0.03521172f, 
    0.07258657f, 0.01563082f, 0.05005961f, -0.01277504f, 0.01853803f, -0.05239006f, 0.04856676f, 0.02533989f, 
    -0.13247623f, -0.12495248f, -0.12186550f, 0.08278000f, -0.02623598f, -0.00159556f, 0.01781272f, -0.18372850f, 
    0.00874199f, -0.01229586f, -0.08436345f, 0.10879159f, 0.07816934f, -0.26173294f, -0.06671520f, -0.11134294f, 
    0.03423405f, 0.04149836f, -0.07213038f, -0.00870311f, -0.09801594f, -0.06055773f, -0.12541513f, -0.06777938f, 
    -0.37058276f, 0.14211322f, -0.23160237f, -0.55395108f, -0.07485216f, 0.13809012f, 0.10704117f, -0.00604274f, 
    0.07742899f, 0.04634276f, -0.01244022f, 0.01877595f, 0.21555065f, -0.30907452f, -0.11173663f, -0.15101330f, 
    -0.00395767f, 0.02876445f, -0.13110989f, 0.01095828f, -0.11633672f, -0.11151313f, 0.10550527f, -0.15903175f, 
    -0.32107514f, -0.23588572f, 0.08127661f, 0.08004740f, 0.01758798f, -0.03573812f, -0.09491993f, 0.05731152f, 
    0.01967662f, 0.08004920f, 0.05884653f, 0.04195005f, 0.05820175f, 0.02149992f, 0.10199867f, 0.27353817f, 
    -0.07474733f, 0.04112019f, 0.06910630f, 0.06721766f, 0.04654241f, -0.12216450f, -0.13028951f, 0.05534116f, 
    0.28415975f, 0.11226183f, 0.07020214f, 0.20709045f, -0.04091449f, 0.04115850f, -0.13890366f, -0.02092195f, 
    0.01611994f, 0.00802430f, -0.03888912f, -0.00111939f, 0.31159168f, -0.25355104f, -0.02071719f, -0.12702876f, 
    0.05356888f, -0.09666546f, 0.06277484f, 0.06928122f, -0.03713050f, -0.02952098f, -0.02528763f, 0.03879859f, 
    -0.14909112f, 0.02461016f, 0.06686603f, 0.11028159f, -0.02920925f, -0.22088014f, -0.06187823f, 0.00275251f, 
    0.14600459f, 0.04609267f, -0.14363615f, 0.10895493f, 0.16604362f, -0.16291104f, -0.12785558f, 0.03796368f, 
    -0.15472133f, -0.08082162f, -0.00030085f, -0.03230366f, 0.01152076f, -0.09421487f, -0.15178593f, -0.10019834f, 
    0.30176523f, -0.26436210f, 0.15049000f, -0.06309417f, -0.05452865f, 0.00161468f, -0.01399192f, 0.11317497f, 
    0.06595694f, -0.16669708f, -0.04810559f, 0.10525995f, 0.01062644f, -0.05517984f, -0.00151182f, -0.06056143f, 
    0.09822812f, 0.02136852f, 0.05059102f, -0.01421924f, -0.11183769f, -0.19788963f, -0.18005081f, -0.14679419f, 
    -0.04277085f, 0.06000174f, -0.12123954f, -0.26973593f, 0.04291559f, 0.01288151f, 0.03529346f, 0.00393435f, 
    0.07116044f, 0.01234892f, -0.15186805f, 0.01391014f, 0.22596869f, 0.13372286f, 0.02915501f, 0.08112583f, 
    -0.05512344f, 0.06828977f, 0.03694913f, -0.10531903f, 0.00628418f, 0.05440325f, 0.02176021f, -0.07176241f, 
    0.16822509f, 0.11937049f, 0.06474133f, -0.26493457f, 0.01591124f, 0.04349512f, 0.03365772f, -0.02751545f, 
    -0.09884705f, -0.15660878f, -0.08796827f, -0.11371343f, 0.29386479f, -0.17385320f, 0.04404283f, -0.11336259f, 
    -0.03716766f, -0.16189103f, 0.11800148f, 0.03821568f, -0.10134266f, 0.06607890f, -0.06144422f, -0.00527111f, 
    0.00015992f, -0.14843099f, -0.10988694f, 0.00174541f, 0.02035432f, -0.05120144f, -0.02638258f, 0.02807383f, 
    0.06831452f, -0.01850551f, -0.05712717f, 0.04962359f, 0.22723775f, -0.19616923f, 0.05038387f, -0.13579154f, 
    -0.01662387f, -0.10360600f, 0.05831155f, -0.10044915f, -0.03450396f, 0.07204885f, 0.06205732f, 0.00030848f, 
    -0.02789815f, 0.03159897f, -0.25691110f, -0.00901638f, -0.02608865f, -0.09844928f, 0.03421231f, -0.06179071f, 
    0.07841364f, 0.07676725f, -0.03081569f, 0.17515755f, 0.08301124f, -0.03816611f, 0.09429682f, -0.00120233f, 
    -0.13536142f, -0.07563743f, -0.00016996f, 0.02408163f, 0.08375283f, 0.01177009f, 0.01119763f, 0.03591265f, 
    -0.05499834f, -0.03405102f, -0.16625629f, -0.08708525f, 0.07872682f, -0.01355731f, -0.06275234f, -0.06181138f, 
    -0.04366758f, 0.07822122f, 0.02179497f, 0.13706437f, 0.05427317f, -0.09886446f, 0.16198449f, 0.12995149f, 
    -0.12152877f, -0.02392628f, -0.10399665f, 0.00228281f, -0.04048538f, 0.00716998f, -0.05879592f, 0.12364823f, 
    -0.07123228f, 0.13038616f, -0.01094653f, -0.16085973f, 0.07768624f, -0.02609594f, 0.04242615f, 0.10383786f, 
    0.06874759f, 0.02535823f, 0.00696537f, -0.14824051f, 0.15810661f, -0.04640654f, 0.04967008f, 0.00772166f, 
    -0.16559941f, -0.04970514f, -0.02627598f, 0.01169650f, 0.04450801f, 0.09321260f, 0.06011504f, -0.01332380f, 
    0.28777960f, 0.24726158f, 0.07872768f, 0.15211393f, -0.04755523f, -0.10962258f, 0.06926358f, -0.04260969f, 
    0.03916634f, 0.02680217f, -0.02252463f, 0.02539390f, 0.12956831f, 0.13003005f, 0.01900718f, 0.25802660f, 
    -0.02587528f, 0.08110314f, 0.03496743f, 0.02269934f, -0.08193775f, 0.04491884f, 0.06948151f, 0.09767795f, 
    0.37719446f, -0.06279249f, -0.10451455f, -0.12063422f, 0.07371028f, -0.04182522f, -0.00759654f, -0.00793315f, 
    0.04156036f, -0.00435241f, 0.09456729f, 0.09948797f, 0.10865707f, -0.14213377f, 0.17607467f, 0.08959258f, 
    -0.04327463f, -0.08440646f, -0.15584809f, 0.07685926f, -0.24723937f, -0.00317652f, 0.02141792f, -0.01213435f, 
    -0.18212232f, 0.04111741f, 0.01042750f, 0.09876101f, -0.03195906f, -0.08103712f, -0.01955330f, 0.05275078f, 
    0.04684388f, -0.15394130f, -0.14293906f, -0.00613663f, 0.02159860f, -0.08463835f, 0.03839906f, -0.17533347f, 
    -0.04388373f, 0.03962945f, 0.02513309f, 0.03088058f, -0.00282628f, 0.02561438f, -0.03114212f, 0.00909073f, 
    0.03538644f, -0.02676089f, -0.00948074f, 0.06237313f, 0.07657244f, 0.01124936f, 0.05437016f, 0.02998194f, 
    -0.07935190f, -0.02348122f, 0.11103971f, -0.08036545f, -0.11126921f, -0.06057952f, -0.15620083f, -0.03377794f, 
    -0.02235046f, 0.04786147f, -0.02629903f, -0.04280576f, 0.06432674f, 0.04573778f, 0.08343413f, 0.02083920f, 
    -0.19063282f, -0.03048747f, -0.09910548f, 0.35181925f, -0.11167873f, -0.02189501f, -0.16867268f, -0.10209925f, 
    -0.03891946f, -0.17795651f, -0.00040185f, 0.12166639f, -0.44219941f, -0.12847018f, 0.00852330f, -0.25181848f, 
    0.04388616f, -0.05650612f, 0.03732445f, 0.12227290f, 0.10838728f, -0.02075156f, 0.04912591f, -0.05366759f, 
    -0.19046330f, -0.01549757f, -0.12133480f, -0.09544731f, 0.00630782f, -0.08601766f, -0.00127219f, 0.05523675f, 
    -0.01894734f, 0.11748834f, 0.08096672f, 0.03407595f, 0.28982997f, -0.19060801f, 0.11129189f, 0.08629979f, 
    -0.06889400f, 0.00242638f, 0.02950454f, -0.00716408f, -0.10548450f, 0.06668468f, 0.00475298f, -0.07029465f, 
    0.06236091f, -0.02700564f, -0.04584891f, -0.17139903f, 0.01082537f, 0.09396255f, 0.02547222f, -0.10657211f, 
    -0.12038215f, -0.00688044f, 0.10659282f, -0.05798904f, -0.21391645f, -0.20668319f, -0.09624787f, -0.28523964f, 
    0.00350660f, 0.08188853f, 0.07134961f, 0.11903017f, 0.01374113f, 0.07824846f, -0.03144654f, 0.04396128f, 
    -0.28193367f, 0.11839169f, -0.09338655f, -0.10384372f, -0.00244833f, 0.02422601f, -0.05234703f, 0.05976307f, 
    0.02844064f, -0.00107465f, -0.07046462f, -0.02075931f, -0.02222706f, 0.01004864f, 0.00747269f, -0.18829812f, 
    0.06471809f, -0.02141834f, 0.15732822f, -0.07854628f, 0.02153808f, 0.18183015f, -0.00476768f, 0.03725882f, 
    0.25410122f, -0.06266254f, -0.12852673f, 0.05503578f, -0.04372237f, -0.04019170f, -0.16695893f, 0.03071317f, 
    -0.01755666f, -0.21497014f, 0.02304234f, -0.02568725f, 0.08667888f, 0.00731184f, 0.19161680f, 0.13730091f, 
    0.05093957f, 0.00641519f, 0.04050867f, 0.00929852f, -0.00543789f, 0.10578066f, 0.10233948f, -0.04331291f, 
    -0.22239904f, 0.12990372f, 0.05119381f, 0.03566335f, -0.00933803f, -0.12620960f, 0.01169027f, 0.07801873f, 
    0.01763072f, 0.01262014f, -0.08932404f, 0.09365453f, -0.18247245f, -0.05504145f, -0.00390718f, 0.05194968f, 
    -0.10290591f, 0.07031161f, -0.15553449f, -0.12202533f, -0.02276705f, 0.00529878f, 0.02323099f, 0.00099675f, 
    -0.15977548f, 0.02973096f, 0.09048225f, 0.03235922f, 0.07911797f, -0.01950354f, 0.01707229f, 0.07141101f, 
    0.18014181f, 0.04750679f, -0.07517929f, 0.03920350f, -0.34994620f, -0.11226211f, 0.06217497f, -0.33002543f, 
    0.02748626f, 0.03256614f, 0.01801857f, -0.07061179f, 0.03836863f, -0.02046099f, 0.05144873f, -0.01491788f, 
    0.00373562f, -0.11876716f, 0.07756209f, -0.04782219f, -0.18620752f, 0.04233918f, -0.08502883f, -0.07285263f, 
    0.05619133f, -0.06697156f, 0.10782263f, -0.02026172f, 0.11064391f, 0.11472687f, 0.00925793f, 0.23082125f, 
    -0.01699019f, -0.10260073f, 0.11871814f, 0.08003910f, -0.09011120f, -0.05797632f, 0.11824750f, -0.08244666f, 
    0.02300071f, 0.09967793f, -0.03017885f, -0.04539482f, -0.03980006f, 0.00155833f, 0.02892010f, 0.01345950f, 
    0.01043534f, 0.07686938f, 0.03160532f, 0.02826484f, -0.29790410f, -0.04354903f, -0.01469107f, -0.21890472f, 
    0.00059619f, -0.00089740f, 0.06401083f, -0.07485642f, -0.11516352f, 0.03546074f, 0.00943294f, -0.00284808f, 
    0.01345630f, 0.01677697f, 0.17870653f, -0.16421077f, 0.03497833f, -0.06754325f, 0.08850518f, -0.07178637f, 
    -0.01768025f, -0.10078368f, 0.03013552f, -0.06144546f, 0.00830586f, -0.18669258f, 0.11634506f, -0.18965939f, 
    0.03184194f, 0.12351031f, -0.03730872f, 0.02386209f, 0.00009456f, -0.00909363f, 0.02714495f, -0.12498228f, 
    -0.06090152f, 0.08236592f, -0.11755927f, 0.06904083f, 0.05739655f, 0.07177856f, 0.00625571f, -0.03787037f, 
    0.11703692f, -0.01271911f, -0.05863336f, -0.09355593f, 0.03083095f, 0.01883083f, 0.06434608f, 0.16592781f, 
    -0.01561464f, -0.05148583f, 0.11868887f, -0.02824855f, -0.11310089f, 0.03524071f, 0.03041202f, -0.03280168f, 
    0.14060944f, -0.02670715f, 0.13967203f, 0.14517534f, -0.14437808f, -0.14666313f, 0.02159014f, 0.06493204f, 
    -0.03135210f, 0.00538855f, -0.00138438f, -0.04073834f, 0.35505429f, -0.08063345f, -0.19874765f, -0.15725884f, 
    -0.17805697f, 0.03087087f, 0.07039946f, 0.03439812f, 0.04206477f, 0.00292689f, 0.08207723f, -0.02506653f, 
    -0.04941538f, 0.03384118f, 0.06113391f, -0.10462596f, 0.06252219f, -0.00124221f, -0.01553063f, 0.10385130f, 
    -0.03596583f, -0.08690454f, -0.02871254f, -0.03494979f, -0.14470865f, 0.03984514f, 0.18537687f, -0.17724161f, 
    -0.08519331f, 0.04470364f, 0.07939292f, 0.03873856f, -0.08958292f, -0.05702563f, -0.00626194f, -0.04121815f, 
    0.27458254f, -0.07923107f, 0.15626164f, 0.04357947f, -0.12607943f, -0.08846963f, 0.05252593f, 0.09317501f, 
    0.07990213f, -0.03934772f, 0.05825787f, -0.08242016f, 0.07082190f, -0.25043789f, 0.11030499f, 0.10523198f, 
    -0.04131909f, -0.01555132f, -0.01484137f, -0.00920574f, 0.07410866f, -0.00851352f, 0.01724531f, 0.02915761f, 
    -0.04320733f, -0.07636300f, 0.04645178f, 0.00894357f, -0.00495340f, -0.03776620f, 0.10627310f, -0.05938119f, 
    -0.07978703f, -0.05891035f, 0.03152011f, -0.02669281f, 0.21961918f, 0.04169656f, -0.02496679f, 0.03143534f, 
    -0.02132527f, -0.01429910f, 0.03531023f, -0.00993274f, -0.15560250f, -0.00775248f, 0.04571705f, -0.07568470f, 
    -0.36486632f, 0.04690346f, -0.12561420f, 0.00121922f, -0.02036828f, 0.03011785f, -0.02247785f, 0.07203516f, 
    -0.03547570f, 0.04563069f, -0.06697197f, -0.08747144f, -0.26935494f, -0.17520803f, 0.02868048f, 0.03897524f, 
    -0.02359744f, -0.13596575f, -0.07376891f, -0.00529568f, -0.07338598f, 0.04259395f, -0.05132852f, -0.05813795f, 
    0.23927219f, -0.19131063f, 0.11679862f, -0.10486250f, -0.00774924f, -0.08968497f, -0.06135486f, 0.10612626f, 
    0.00016664f, 0.04939201f, 0.04252465f, -0.07202978f, -0.14641188f, -0.16316423f, -0.13233137f, -0.02735586f, 
    0.00162067f, -0.09364050f, 0.07080920f, -0.03828241f, 0.03014681f, -0.02464309f, 0.04014031f, -0.04480879f, 
    0.02005559f, -0.07620526f, -0.24885805f, -0.27576759f, 0.04544513f, 0.04276007f, -0.04919255f, -0.14796333f, 
    0.08928743f, 0.03339148f, 0.00502907f, 0.04749797f, 0.09868751f, -0.13946965f, -0.08655819f, 0.06948261f, 
    0.01942500f, -0.09736183f, 0.00653983f, -0.07335182f, 0.00235707f, -0.00874543f, -0.15857725f, 0.04092400f, 
    0.38810164f, -0.01880264f, -0.05686884f, 0.03171345f, 0.08943372f, 0.10453497f, 0.06354496f, 0.02130657f, 
    -0.05131770f, -0.02742705f, 0.01538888f, -0.15034644f, -0.13462479f, 0.03247216f, 0.02452258f, -0.11791955f, 
    0.05638880f, -0.04558366f, 0.00564995f, -0.03071395f, -0.04911119f, 0.03550356f, 0.05902596f, 0.07018591f, 
    0.10068318f, 0.01059344f, -0.03603958f, -0.07983923f, 0.10199273f, -0.12106520f, 0.04712759f, 0.07644464f, 
    0.00949905f, -0.02619806f, 0.01665105f, -0.00265223f, -0.36211741f, -0.07100911f, -0.17776890f, -0.11217512f, 
    0.03483223f, -0.14177397f, 0.08571655f, -0.01964923f, 0.01749322f, 0.03455504f, -0.00549291f, 0.04794348f, 
    -0.16857055f, -0.11860355f, -0.05827452f, 0.07803869f, -0.13861471f, 0.02074171f, 0.02671022f, -0.00146607f, 
    0.01211911f, -0.04559904f, -0.02530967f, 0.07648890f, 0.29433841f, 0.03650311f, -0.01098707f, 0.28894266f, 
    -0.16038442f, -0.10211419f, -0.10372405f, 0.04915714f, 0.03738643f, 0.02725111f, 0.01002317f, 0.01029046f, 
    0.11274742f, 0.07361441f, 0.06033531f, 0.08405123f, -0.01044523f, -0.05998106f, 0.11732360f, 0.04153485f, 
    -0.00229791f, 0.03448950f, 0.01845528f, -0.07220996f, -0.04464446f, 0.11738806f, -0.05481253f, -0.00333598f, 
    -0.03697957f, -0.02464598f, -0.05500772f, -0.04117856f, 0.01294273f, -0.02139527f, 0.00332812f, -0.02780554f, 
    -0.00390534f, -0.19988161f, -0.13952221f, -0.25038776f, -0.07439412f, 0.03972894f, -0.00878140f, -0.07599040f, 
    0.01505867f, -0.01699394f, 0.05793863f, -0.13612644f, 0.07388127f, 0.01544517f, -0.07579408f, 0.18995184f, 
    0.04927655f, -0.01435266f, 0.00603777f, -0.05967926f, -0.01440923f, 0.02733617f, -0.03578167f, 0.09070369f, 
    0.12189218f, 0.04154310f, -0.14607798f, 0.04147138f, -0.02287151f, 0.06433797f, 0.03187108f, 0.03199008f, 
    -0.04887030f, 0.04388967f, 0.04756892f, 0.01453097f, 0.01121877f, -0.01938716f, -0.03588156f, -0.18548517f, 
    -0.01126940f, -0.03060455f, 0.09767782f, -0.11642740f, 0.02954255f, 0.10678081f, 0.07923748f, -0.11830545f, 
    0.10001856f, 0.11565655f, 0.03957133f, 0.16103150f, -0.12412520f, -0.13833833f, -0.00512342f, -0.00206316f, 
    0.02238883f, -0.01298487f, 0.03198060f, -0.05829862f, -0.06044903f, 0.04632003f, 0.09705184f, -0.03458745f, 
    -0.12684776f, 0.03198290f, 0.13291052f, -0.00632231f, -0.08665708f, 0.00296987f, 0.03831553f, -0.02533842f, 
    -0.04003443f, 0.03580783f, -0.15993239f, -0.09795709f, -0.05181700f, 0.03194176f, -0.03943386f, 0.07770836f, 
    -0.10536546f, -0.01973442f, -0.02502456f, 0.01700779f, 0.18737473f, -0.13279681f, -0.03382983f, -0.03770106f, 
    0.15039855f, 0.00074876f, -0.02153972f, -0.14148937f, -0.03914161f, 0.04918232f, -0.13292167f, 0.00461923f, 
    0.18233135f, 0.08216441f, -0.28220683f, 0.02230600f, 0.08833081f, 0.09705313f, -0.03412956f, -0.11362970f, 
    -0.07962937f, -0.05429760f, 0.03916779f, -0.02106661f, -0.15124750f, -0.09466431f, 0.08130513f, -0.07442129f, 
    0.14493001f, -0.09995154f, -0.02313969f, 0.02132005f, -0.04055202f, 0.03684555f, -0.02633412f, 0.05539173f, 
    0.30409279f, -0.06605225f, -0.11879956f, -0.03294228f, -0.00484822f, 0.02971360f, 0.05253825f, -0.13643202f, 
    0.00076502f, 0.04505205f, -0.01598070f, 0.08471785f, 0.00279103f, -0.19744460f, 0.08720962f, -0.06441689f, 
    0.11172532f, -0.00238565f, -0.02374083f, 0.00491802f, 0.01869251f, -0.03773497f, -0.03255801f, 0.01020222f, 
    -0.00016796f, -0.00903902f, -0.04451020f, -0.04072535f, 0.09766694f, -0.01203936f, 0.08762208f, -0.00559901f, 
    -0.07604292f, -0.03125636f, 0.02162331f, -0.05128758f, 0.04088081f, 0.00854230f, -0.05852358f, -0.06331309f, 
    -0.00892863f, -0.00135303f, -0.03390908f, -0.10416332f, 0.04842972f, 0.05492870f, 0.01902361f, -0.02064114f, 
    0.11207465f, -0.04520489f, 0.15827493f, 0.16739869f, -0.06178538f, 0.02583932f, -0.12878858f, 0.07328552f, 
    -0.07344893f, 0.00116172f, 0.01010719f, -0.07256178f, 0.03247857f, -0.05819449f, 0.03490479f, 0.05454130f, 
    0.08581199f, 0.11223588f, 0.07717900f, -0.05823478f, 0.04547399f, -0.10847978f, -0.02508321f, -0.02542315f, 
    0.08444640f, 0.11424673f, -0.22462036f, -0.03794149f, 0.03232564f, 0.05501824f, -0.00948190f, -0.09258690f, 
    -0.07739622f, -0.01165172f, -0.02181098f, -0.06581840f, -0.33696041f, 0.11264858f, 0.02071014f, 0.10044357f, 
    0.02461919f, -0.08132301f, -0.00859370f, -0.00412428f, -0.02879438f, -0.00147597f, -0.08446344f, -0.04204319f, 
    -0.15880319f, 0.08165991f, -0.22242258f, 0.06117421f, -0.03292982f, 0.07534481f, -0.00295406f, -0.07299785f, 
    0.00414074f, 0.16154602f, -0.02336870f, -0.09747162f, 0.27116033f, 0.06816660f, 0.01312219f, 0.04543310f, 
    -0.02045162f, 0.03082854f, -0.01617813f, -0.09297097f, -0.07191977f, -0.13076235f, 0.01155774f, -0.03210224f, 
    0.36163285f, -0.02890881f, -0.20930617f, -0.01075433f, 0.00917295f, 0.08730900f, 0.19246337f, -0.03826384f, 
    0.04734731f, 0.06988285f, 0.01032073f, -0.09040730f, 0.08079652f, 0.16421312f, -0.06044837f, 0.06391278f, 
    0.03907933f, -0.09567170f, 0.00350547f, -0.03261900f, -0.11156320f, 0.03349720f, -0.02884057f, 0.00789689f, 
    0.14616920f, -0.03039639f, -0.09975445f, 0.05656099f, -0.05509764f, -0.02308201f, 0.06524894f, -0.02164893f, 
    -0.05819451f, -0.06842716f, -0.06302662f, 0.01412509f, 0.08863796f, -0.15437411f, -0.10978558f, -0.00882973f, 
    0.06465373f, -0.06290610f, -0.02948452f, 0.03087024f, -0.08231750f, 0.05249717f, -0.06285860f, -0.04449580f, 
    0.03059796f, 0.07502308f, -0.09722021f, -0.07867773f, 0.10605581f, -0.04172157f, 0.03298319f, -0.02277460f, 
    -0.02242781f, 0.03868474f, -0.11019818f, 0.02500248f, -0.29304254f, -0.10276055f, -0.11058272f, -0.23021652f, 
    0.05706069f, 0.01787823f, 0.00819992f, -0.14241704f, -0.02952844f, 0.04622008f, -0.01062123f, -0.04554831f, 
    -0.04354509f, -0.07813130f, -0.12711802f, -0.02246748f, 0.00330870f, 0.00727776f, 0.08116558f, -0.07206799f, 
    -0.01556680f, -0.06181978f, -0.01743372f, -0.00419124f, -0.20674479f, 0.08975615f, -0.10154738f, -0.07824449f, 
    0.09268314f, 0.07658318f, -0.00281286f, -0.09228839f, -0.03555714f, -0.03627756f, -0.09938648f, -0.01847651f, 
    0.35118771f, -0.11680155f, 0.03002082f, 0.19841403f, -0.15970266f, 0.00322346f, 0.03010503f, -0.02561199f, 
    -0.06022058f, 0.02204008f, 0.00488665f, 0.00419952f, 0.00050859f, 0.10066086f, -0.15273763f, 0.02282954f, 
    0.07854383f, 0.10193802f, 0.02322648f, -0.03880024f, -0.07102416f, 0.03951050f, 0.04275162f, -0.10493237f, 
    -0.37773091f, 0.12781879f, -0.15712211f, -0.27807555f, -0.06511565f, -0.01203865f, -0.11982900f, -0.07594939f, 
    -0.00131007f, -0.11745940f, -0.07430044f, 0.05007106f, 0.42740956f, -0.00926314f, -0.20205022f, 0.03539035f, 
    0.00729647f, 0.05724394f, 0.01289435f, 0.08114908f, 0.12551668f, -0.00978712f, -0.06830182f, -0.08058214f, 
    -0.07869749f, 0.05652430f, -0.02264422f, 0.14457925f, 0.00062850f, -0.00475657f, 0.04157685f, -0.02661977f, 
    -0.01114371f, -0.06764277f, 0.00483408f, 0.03298368f, 0.21925442f, 0.08252825f, -0.03653740f, 0.02130976f, 
    0.01450163f, 0.04432801f, -0.12296339f, 0.07054798f, -0.05907208f, 0.10827647f, 0.04869805f, -0.00942948f, 
    0.00919407f, -0.01636325f, 0.08018390f, 0.09036673f, 0.06837963f, -0.01098880f, 0.02746147f, 0.06667275f, 
    -0.12367787f, 0.02835256f, -0.01954216f, -0.06440903f, 0.09940279f, -0.26858261f, -0.03153538f, -0.06102554f, 
    -0.01446748f, 0.10183494f, -0.05268222f, -0.04542742f, -0.07136423f, -0.04555797f, 0.04890963f, -0.04296631f, 
    -0.21958455f, -0.24042460f, -0.35418966f, 0.16633238f, -0.00964442f, -0.04089559f, 0.04470269f, -0.05470718f, 
    -0.05930451f, 0.04127740f, 0.00499277f, 0.03782525f, -0.03974589f, -0.00762792f, 0.08448415f, 0.07560311f, 
    0.00776536f, -0.01043023f, -0.03838466f, 0.06660891f, -0.03909262f, 0.09534569f, 0.00256320f, 0.05748730f, 
    -0.32302082f, -0.05187738f, -0.05366029f, 0.05783522f, -0.02454878f, 0.03909177f, -0.07620169f, 0.02134674f, 
    -0.09119221f, 0.08397289f, 0.04179755f, -0.12654504f, 0.14660555f, 0.08404988f, 0.04625111f, 0.14181565f, 
    -0.00965675f, 0.15012634f, 0.07104318f, -0.09010148f, 0.00552326f, -0.01428344f, 0.02918566f, -0.02623808f, 
    -0.31739980f, -0.35445857f, -0.07891747f, 0.22650507f, -0.02551715f, -0.00053271f, 0.03677055f, -0.00717155f, 
    -0.10282225f, -0.06986781f, -0.00618623f, -0.11894544f, -0.13170160f, -0.01595566f, -0.10277884f, -0.10239021f, 
    -0.02645892f, 0.07129268f, -0.15243965f, -0.00635575f, -0.04443247f, 0.04982495f, -0.15559508f, 0.02139927f, 
    0.01956748f, -0.05156655f, -0.07411125f, -0.09581900f, -0.09391159f, 0.01180498f, -0.02334278f, 0.01558060f, 
    -0.02606741f, -0.09685388f, 0.07587714f, 0.00373560f, -0.12403654f, 0.21761738f, 0.16955219f, -0.13594496f, 
    -0.00106433f, 0.02548848f, -0.02216840f, 0.09366135f, 0.02082182f, -0.05717243f, -0.01120970f, -0.06726380f, 
    -0.04851334f, 0.04789169f, 0.00447468f, 0.05892763f, -0.02882054f, -0.05271380f, 0.02517713f, 0.07318125f, 
    0.04445773f, 0.00465965f, 0.01457250f, 0.11694386f, 0.02237852f, -0.27279219f, -0.13161692f, 0.13883230f, 
    -0.06250645f, -0.04098791f, 0.03373735f, 0.01016296f, -0.03358565f, -0.03513194f, -0.01895764f, -0.05695825f, 
    -0.12735228f, -0.05354021f, -0.03909381f, -0.11375625f, -0.10048365f, -0.08697049f, 0.07980494f, 0.03299133f, 
    -0.05836637f, -0.06296544f, -0.00522012f, 0.02663989f, -0.03813465f, -0.05922984f, -0.04078684f, 0.05317986f, 
    0.00346508f, -0.09399891f, 0.05040168f, -0.02231346f, -0.00154293f, -0.02534629f, 0.05141630f, -0.06981976f, 
    -0.03965500f, 0.11975911f, -0.14699888f, 0.10103340f, 0.01277310f, 0.10969028f, 0.00916694f, -0.00660262f, 
    0.00715931f, 0.01412413f, -0.03413216f, -0.03436975f, -0.05239370f, 0.21563743f, -0.08139093f, -0.20718524f, 
    -0.00204620f, -0.10036532f, 0.04143153f, -0.00776388f, -0.00981511f, -0.02954761f, 0.05689333f, -0.00450475f, 
    0.12433875f, -0.18599291f, 0.02561672f, 0.02098734f, -0.08284874f, 0.10558218f, -0.05126907f, 0.12168070f, 
    0.00117527f, 0.09272045f, -0.02866876f, 0.03227260f, 0.16714749f, 0.01582136f, 0.00941135f, 0.00257626f, 
    -0.13689964f, -0.11792935f, 0.00932016f, 0.06034264f, 0.00525598f, -0.02185514f, -0.06365372f, 0.01598110f, 
    -0.11718182f, -0.05266413f, 0.04799791f, 0.00831115f, -0.06289653f, 0.00959312f, 0.09354515f, 0.13386732f, 
    0.02942142f, -0.11347816f, 0.11404443f, -0.05731851f, 0.11228776f, -0.03959829f, 0.12554359f, -0.04247946f, 
    -0.03105147f, 0.00942112f, 0.07895438f, 0.05410041f, 0.04651240f, 0.01940503f, 0.04773243f, 0.06054748f, 
    0.41121414f, 0.29573515f, 0.15438841f, -0.03972884f, -0.05043260f, -0.02347407f, 0.05895343f, 0.05897300f, 
    -0.07568647f, 0.02803903f, -0.04498723f, -0.02905408f, 0.26559526f, 0.00138484f, 0.07504112f, -0.01160538f, 
    -0.06847113f, -0.08698550f, 0.04140901f, -0.11048125f, 0.00951178f, -0.03769745f, -0.08532578f, 0.01489743f, 
    0.09761916f, -0.02428222f, 0.19070326f, 0.16352716f, 0.05816005f, 0.12392566f, -0.01521705f, -0.09773017f, 
    -0.02202832f, -0.06475516f, 0.01317779f, -0.14142355f, -0.18040849f, -0.27057475f, -0.18084124f, 0.15533407f, 
    -0.00438054f, 0.07445150f, -0.01862132f, -0.01301163f, -0.05898816f, 0.06239728f, -0.00583209f, -0.02734969f, 
    -0.23601714f, -0.38094088f, -0.13222185f, -0.13352917f, -0.10704779f, -0.09639259f, 0.01849050f, -0.03898033f, 
    -0.03063784f, -0.01546825f, 0.05796112f, 0.03607437f, 0.08579146f, 0.04945252f, 0.14152700f, 0.05044946f, 
    0.02926406f, 0.00078940f, -0.02028354f, -0.00743699f, -0.05270024f, -0.00304518f, 0.02031274f, 0.13024966f, 
    0.21751316f, 0.00008334f, -0.03642173f, 0.00422758f, -0.12458000f, -0.00108709f, 0.03739948f, 0.06294654f, 
    -0.06270913f, 0.00078242f, -0.05675322f, 0.04241825f, 0.06878649f, 0.00611678f, 0.00615579f, 0.02536018f, 
    -0.09010974f, -0.06198772f, 0.09671033f, -0.00669922f, -0.06978573f, 0.08787369f, -0.01231369f, 0.03122943f, 
    0.14856102f, 0.00351755f, 0.03633586f, 0.16908091f, -0.02998954f, 0.00796971f, -0.07360040f, -0.01097022f, 
    -0.10169198f, 0.04637101f, -0.05375358f, -0.01160831f, 0.07002066f, 0.07650058f, -0.05744271f, 0.12865219f, 
    -0.00796109f, -0.03491674f, -0.02062823f, 0.01851880f, 0.03391421f, 0.05990289f, 0.06863232f, 0.05362036f, 
    0.20108849f, 0.10759718f, 0.07745640f, 0.11391060f, -0.01534165f, -0.00721298f, -0.10425723f, 0.01008301f, 
    0.06546713f, 0.02613998f, 0.04688799f, -0.15843502f, -0.14860427f, -0.30487117f, 0.06630777f, 0.00988420f, 
    -0.07321791f, -0.07055312f, 0.01183254f, 0.04735029f, 0.11007124f, 0.00594769f, -0.06030050f, 0.00306608f, 
    -0.19750296f, -0.02198600f, 0.07015974f, -0.00622889f, 0.06981688f, 0.05924158f, -0.07945786f, 0.01966683f, 
    -0.09607058f, 0.07037041f, 0.06689329f, 0.09325998f, 0.23458730f, 0.02492024f, 0.02433408f, -0.03146271f, 
    -0.00881737f, 0.07081494f, 0.06379482f, 0.03209418f, 0.00100764f, -0.01240003f, -0.00589137f, 0.01142885f, 
    -0.06892127f, -0.09658193f, 0.01020199f, -0.13974470f, -0.08385514f, -0.06403077f, 0.05523533f, -0.00913385f, 
    -0.07978607f, 0.07381500f, 0.04264278f, 0.02425909f, -0.09116872f, -0.03295537f, -0.04392289f, -0.09132424f, 
    0.01729841f, 0.00054210f, -0.05421553f, 0.04379116f, 0.04157908f, -0.09332178f, 0.09921967f, -0.03313758f, 
    -0.55756462f, -0.07532177f, -0.11823276f, -0.04738244f, -0.09596763f, -0.00573457f, -0.00695602f, 0.07849257f, 
    0.01939420f, -0.15070505f, 0.04070621f, -0.05983082f, 0.57654989f, -0.28810641f, -0.15125839f, 0.27690703f, 
    -0.00585535f, -0.00172722f, -0.06114130f, 0.02263289f, -0.01470679f, -0.02078636f, -0.06102673f, -0.01064195f, 
    -0.44325295f, 0.15286677f, 0.30826151f, 0.19780964f, 0.06063602f, 0.10363953f, 0.01263467f, 0.04092347f, 
    -0.02098572f, -0.00887259f, -0.07568663f, -0.05558523f, -0.16799776f, -0.17443986f, -0.10447958f, -0.02347887f, 
    -0.00018660f, 0.00396002f, 0.06030666f, 0.11917569f, 0.12029839f, -0.06685502f, 0.06949575f, 0.11300036f, 
    -0.22965308f, 0.06240510f, 0.06379685f, -0.11404886f, 0.08509590f, 0.00042734f, -0.14459436f, 0.01428804f, 
    -0.00283388f, 0.13494696f, -0.02345079f, 0.05535723f, 0.01604283f, -0.35016537f, -0.04625969f, 0.12251222f, 
    0.04831565f, -0.04263063f, 0.06315736f, -0.13556507f, 0.02171269f, -0.11916669f, -0.07152245f, 0.05293515f, 
    -0.35904801f, -0.39258799f, -0.18050429f, -0.08700445f, -0.10492662f, -0.09060786f, 0.10768615f, 0.00423238f, 
    -0.08375639f, 0.05907429f, -0.07691431f, 0.02421660f, -0.48351985f, -0.18004520f, -0.02689389f, -0.01548410f, 
    -0.05195282f, -0.15251867f, -0.01530246f, -0.07393177f, -0.01919900f, -0.05605207f, 0.15642941f, -0.05100685f, 
    -0.19082899f, 0.07376487f, -0.07095896f, -0.06663816f, -0.11993310f, 0.01605398f, -0.04799806f, 0.07035506f, 
    -0.09338319f, -0.06407759f, -0.07172566f, 0.12611879f, 0.19163440f, -0.25762588f, -0.04934941f, 0.18809640f, 
    0.03422730f, -0.01134713f, -0.05417339f, -0.15756613f, 0.05009683f, -0.06205270f, -0.02448064f, -0.08687754f, 
    -0.12061998f, 0.17072859f, 0.01242284f, 0.03072395f, -0.02987093f, 0.01633751f, 0.07183832f, -0.02133861f, 
    0.03049920f, 0.11133348f, 0.08035125f, 0.10347269f, 0.04080458f, 0.07839709f, -0.16038281f, 0.09128148f, 
    -0.08045158f, 0.11951177f, -0.06926633f, -0.03755089f, 0.04875458f, 0.01303513f, -0.01886316f, 0.01687723f, 
    -0.03095446f, -0.14538488f, -0.29861572f, 0.22339094f, -0.01707014f, 0.03629588f, 0.07400361f, -0.01925831f, 
    -0.00155083f, 0.05123619f, -0.00062443f, -0.06459985f, -0.38435397f, 0.27536163f, 0.23596255f, 0.18690324f, 
    0.14740264f, 0.01653940f, -0.04617406f, -0.00671842f, -0.10827657f, -0.00801020f, -0.06600767f, -0.00088247f, 
    -0.08120371f, 0.17949657f, 0.15900786f, -0.05290148f, -0.02983194f, 0.06654508f, -0.01571085f, 0.01518234f, 
    -0.02465924f, -0.00434337f, -0.01855983f, 0.03459911f, 0.07560058f, 0.17208967f, -0.01749779f, -0.05095655f, 
    -0.08639727f, 0.03063122f, 0.01307383f, -0.02036664f, -0.04502790f, -0.04687852f, -0.04750214f, 0.05988245f, 
    -0.17704141f, 0.10097248f, 0.13552809f, 0.02594011f, 0.12053789f, 0.01165209f, -0.00196079f, -0.03298992f, 
    0.04474263f, -0.12617546f, -0.05520742f, 0.01575037f, 0.19927105f, -0.11668925f, -0.09546409f, -0.06907407f, 
    -0.07757469f, 0.06359556f, 0.06794902f, -0.01718466f, -0.06488404f, -0.05510448f, 0.11308485f, 0.00454788f, 
    0.27101389f, 0.04816512f, 0.10634769f, 0.12708716f, 0.07727395f, 0.01763809f, -0.02281210f, 0.07731290f, 
    0.05763333f, 0.01894870f, -0.13200377f, -0.02771629f, 0.21522932f, 0.08876402f, -0.05948117f, 0.03706661f, 
    0.02931236f, 0.03065708f, -0.04029821f, -0.00887284f, 0.02067480f, 0.07148736f, -0.05327813f, -0.05833327f, 
    -0.05525856f, -0.06805895f, 0.07088380f, -0.08448476f, 0.07708993f, -0.05459900f, 0.05635405f, -0.04495712f, 
    0.04869505f, -0.01343153f, 0.05937911f, -0.13351464f, 0.16219050f, 0.03436558f, 0.02122626f, 0.04709364f, 
    0.00672299f, -0.04968703f, -0.04412024f, 0.01545224f, 0.05910245f, -0.08514574f, 0.00045753f, -0.05942944f, 
    0.10524671f, -0.08284828f, 0.12689815f, -0.08963595f, 0.00067850f, -0.03332734f, 0.04116469f, -0.07592195f, 
    -0.14541562f, 0.05173133f, -0.12743278f, -0.04941619f, -0.12120314f, -0.34877086f, -0.26468751f, 0.10944381f, 
    -0.06411947f, -0.07384932f, -0.00331020f, -0.04163767f, -0.04663338f, -0.06953301f, 0.03872481f, -0.09459691f, 
    0.27927294f, 0.08370533f, 0.03594715f, -0.13759348f, 0.00511818f, -0.12022606f, -0.01692352f, 0.05502466f, 
    -0.01959672f, 0.04392667f, 0.00246493f, 0.00445564f, -0.07219192f, 0.12215029f, 0.14516757f, -0.04790386f, 
    0.06999950f, 0.00168008f, -0.00163412f, 0.09489354f, -0.06336740f, -0.08856307f, -0.08557156f, 0.06313519f, 
    -0.21613100f, 0.09087636f, -0.15612146f, 0.12580925f, -0.10153391f, 0.04057737f, -0.05008568f, -0.08285154f, 
    -0.03220659f, 0.02747265f, 0.03796234f, 0.03897602f, 0.02777857f, 0.22511710f, 0.03415590f, -0.00076837f, 
    -0.04929148f, -0.07732803f, 0.02764592f, 0.04880458f, -0.00981621f, -0.05331820f, -0.04000792f, -0.03926127f, 
    -0.07998469f, 0.10000984f, 0.07218076f, -0.13775894f, -0.03593687f, 0.03272704f, -0.12332783f, 0.09072622f, 
    -0.02201994f, -0.03658836f, -0.01532449f, 0.08420360f, -0.26775873f, 0.03031482f, 0.05740179f, 0.08662052f, 
    0.01376214f, 0.07063767f, 0.11646408f, -0.08503598f, 0.01383260f, -0.06938408f, 0.01078642f, 0.05922581f, 
    -0.08335847f, -0.06382693f, 0.10206270f, -0.04183808f, -0.03499402f, 0.09595264f, -0.01478360f, -0.00464065f, 
    0.06198384f, -0.06724048f, -0.01551055f, -0.03152099f, -0.08577707f, -0.01057116f, -0.02609468f, 0.05988858f, 
    0.04249440f, 0.06991263f, 0.18756895f, 0.09939411f, 0.04585437f, 0.16929521f, -0.09917168f, -0.09215109f, 
    -0.33744010f, -0.17179468f, 0.08905923f, -0.02909027f, -0.03622969f, -0.08125503f, 0.00162298f, -0.03682243f, 
    0.02671048f, -0.08863387f, -0.07948618f, -0.16491228f, -0.03284146f, -0.06812321f, -0.11437196f, 0.17936876f, 
    -0.06292704f, -0.11355606f, 0.10483111f, 0.06531742f, 0.05866853f, -0.09552956f, -0.01170415f, 0.01059861f, 
    -0.23873527f, 0.03551120f, 0.16398244f, -0.00271195f, 0.03805313f, 0.01713781f, -0.07532268f, -0.06019828f, 
    0.07340615f, -0.02112933f, -0.07315326f, -0.18043387f, -0.29070690f, -0.19126834f, 0.07836552f, 0.16736121f, 
    -0.12736891f, -0.04843938f, 0.09125846f, -0.06662180f, -0.02971389f, 0.03009625f, 0.10378144f, 0.01694796f, 
    -0.28519571f, 0.14604451f, 0.08931013f, 0.32520127f, 0.01454543f, 0.02051536f, -0.04078262f, 0.03784101f, 
    -0.07539894f, 0.08721042f, 0.04794629f, -0.03398072f, 0.41033465f, 0.13226794f, -0.09745881f, -0.28710657f, 
    0.00071013f, -0.06135121f, 0.07237594f, -0.02543487f, -0.03034231f, -0.01047886f, -0.04445949f, 0.01991838f, 
    -0.19368897f, 0.00760248f, 0.28146851f, 0.00943194f, 0.08919989f, 0.04848494f, -0.02963908f, 0.08266040f, 
    0.07634305f, -0.00694874f, 0.04203565f, 0.03336704f, -0.22810489f, -0.27833739f, 0.00280735f, -0.21426314f, 
    -0.01648444f, 0.03735355f, -0.19844395f, -0.10400918f, 0.04714179f, -0.04421927f, -0.13452749f, -0.03613023f, 
    -0.57565236f, 0.04546510f, 0.17245048f, 0.19614020f, 0.08759143f, -0.07827629f, 0.10634070f, 0.09431020f, 
    -0.00824931f, 0.15070972f, -0.02081512f, 0.14210148f, -0.32069370f, 0.05322703f, -0.17382266f, -0.01730386f, 
    -0.00946352f, 0.04835120f, -0.04859855f, -0.01663626f, -0.01516819f, -0.02285501f, 0.01468827f, 0.08606196f, 
    -0.06053729f, -0.15058629f, -0.28024498f, 0.00864693f, -0.05261176f, -0.02350290f, -0.01901467f, -0.09120069f, 
    -0.02633907f, -0.11517085f, 0.03767903f, -0.10290898f, 0.06151797f, 0.25660193f, 0.00016282f, 0.01625548f, 
    0.07734036f, 0.08891498f, 0.02813101f, 0.11934575f, -0.02612871f, -0.03162986f, 0.04783042f, -0.06154834f, 
    -0.12528215f, 0.02580032f, -0.00429922f, -0.12428623f, 0.11461877f, 0.10373233f, 0.00766774f, 0.00103323f, 
    0.02648321f, -0.05709710f, -0.02444969f, 0.07904273f, 0.12582587f, -0.12509121f, -0.07126153f, -0.04698678f, 
    0.01457202f, 0.01777289f, 0.11396663f, 0.07013649f, -0.01918798f, 0.03282905f, 0.08605554f, 0.12609768f, 
    -0.34378922f, 0.00506776f, -0.06072003f, -0.05799751f, -0.03440402f, 0.05631038f, -0.14587930f, -0.00463392f, 
    -0.08599868f, 0.00134890f, -0.02463644f, 0.06913385f, 0.04568959f, 0.13173909f, 0.06411104f, 0.07091903f, 
    -0.09514462f, 0.14188986f, 0.09096637f, 0.02330862f, -0.02565254f, 0.01462040f, 0.13295835f, 0.02995478f, 
    0.08943907f, 0.15276836f, 0.07505236f, -0.10206701f, -0.01346241f, -0.04779525f, 0.02851245f, 0.00338104f, 
    0.12730646f, 0.01773723f, -0.00666333f, -0.01590996f, -0.03463704f, 0.05347864f, -0.15233727f, 0.04579544f, 
    -0.11635429f, 0.00783579f, -0.06882354f, 0.02966655f, -0.01520904f, -0.02038135f, -0.03739399f, 0.09076208f, 
    -0.39700523f, -0.21173370f, 0.00291640f, 0.14993910f, -0.00848748f, -0.06544412f, 0.00659918f, -0.05490970f, 
    0.09418502f, -0.08183777f, -0.05837345f, -0.03501617f, -0.19985288f, -0.12502129f, 0.19738978f, -0.01004057f, 
    -0.08755455f, 0.06776426f, 0.08993805f, 0.04424576f, 0.11755799f, 0.01747485f, 0.00111904f, -0.02304829f, 
    0.35606706f, -0.13311814f, 0.03964881f, -0.04558603f, -0.07690793f, -0.10575519f, 0.04992617f, -0.02697021f, 
    0.01989406f, 0.00420230f, -0.06740248f, -0.09331194f, 0.17180179f, 0.09567248f, 0.17691402f, -0.00274351f, 
    0.05163839f, -0.26552913f, -0.19172755f, -0.03783590f, 0.04643077f, -0.05405194f, 0.00340131f, -0.01026018f, 
    0.08929709f, 0.01848048f, -0.02433086f, -0.03864221f, 0.05726611f, 0.04184178f, 0.03225204f, 0.01518408f, 
    -0.15175182f, -0.06166065f, 0.14622754f, -0.01588160f, -0.52840710f, -0.08060090f, 0.06622159f, 0.09735429f, 
    0.06271667f, 0.04709176f, 0.05705708f, 0.12020373f, 0.00800296f, -0.11695354f, 0.03007288f, 0.00626828f, 
    -0.22715940f, -0.15763921f, -0.02955692f, -0.07342201f, 0.00305372f, -0.02853001f, -0.01076283f, -0.17264040f, 
    0.00939799f, -0.05434684f, -0.02537907f, -0.09375601f, -0.05991910f, -0.02038996f, -0.02141391f, -0.13275944f, 
    -0.01375128f, 0.07342523f, 0.00472663f, 0.01477255f, -0.12781261f, 0.10673413f, 0.08614831f, -0.01239908f, 
    -0.22212571f, 0.03136090f, 0.23878852f, 0.02323952f, 0.06643277f, -0.07112068f, -0.11055528f, 0.04198013f, 
    -0.06263117f, -0.03781923f, 0.17641377f, 0.04496084f, 0.12041980f, 0.21271336f, -0.09629904f, -0.04630344f, 
    -0.06987794f, -0.04607742f, 0.04297161f, 0.13164121f, -0.02984316f, 0.00082523f, 0.06461217f, -0.03554903f, 
    -0.21529634f, -0.05659458f, 0.10790241f, 0.08719435f, 0.00653847f, -0.01320634f, 0.00115815f, -0.05741348f, 
    0.01026805f, -0.00464088f, 0.04353343f, 0.09104700f, 0.04297914f, -0.14338361f, -0.12466630f, 0.04220002f, 
    -0.08848074f, -0.02554790f, -0.10506310f, -0.11890089f, -0.09569417f, -0.03432091f, -0.06573226f, -0.05504068f, 
    -0.26523575f, -0.06901085f, 0.01887321f, 0.14608347f, 0.13415812f, -0.03144504f, 0.06657216f, 0.01682049f, 
    -0.00806303f, 0.07089249f, 0.10409089f, 0.01068557f, 0.10454610f, -0.10831804f, -0.05948834f, 0.17746902f, 
    0.04579735f, -0.00234707f, 0.13133313f, 0.02961839f, 0.05749005f, 0.00324501f, -0.18250734f, -0.08015656f, 
    -0.30320871f, -0.16366291f, 0.11853690f, 0.02186140f, -0.08803136f, 0.10826206f, -0.01430553f, -0.05013147f, 
    0.00149466f, -0.00614039f, -0.00380083f, -0.15911624f, -0.22076346f, 0.14364824f, 0.03110978f, -0.00136652f, 
    0.01259480f, 0.04277523f, 0.01738773f, 0.06907745f, -0.00936973f, -0.05545684f, 0.08935672f, 0.04734058f, 
    -0.24352415f, -0.03440278f, 0.06578715f, 0.24828196f, -0.15421852f, -0.06528418f, -0.04584510f, 0.00723351f, 
    -0.05691766f, 0.00265183f, -0.08066522f, -0.00832716f, 0.46064886f, 0.01101952f, -0.14259113f, -0.09095153f, 
    -0.07352536f, -0.05403989f, -0.03381990f, -0.01469193f, -0.08408407f, -0.04713333f, 0.03696195f, 0.09126796f, 
    -0.00582866f, 0.16398616f, -0.08835862f, 0.18464203f, -0.10971203f, 0.08534341f, 0.03302676f, -0.03224875f, 
    -0.07316829f, -0.12947936f, 0.13106772f, -0.00942095f, 0.14320756f, 0.12696029f, -0.04987461f, 0.01625965f, 
    0.00353812f, 0.05342750f, 0.02579112f, -0.03384963f, -0.15349919f, -0.02133477f, -0.05055831f, 0.03215222f, 
    -0.08806798f, -0.11777747f, 0.01586360f, -0.06275132f, -0.01260571f, 0.05865350f, -0.04500569f, 0.15017183f, 
    0.07816023f, 0.14757569f, 0.06938491f, 0.14935735f, -0.04355246f, 0.13486192f, 0.00742478f, -0.00335959f, 
    0.01292356f, -0.05018313f, -0.02804338f, 0.14242551f, 0.06883363f, -0.09711068f, 0.03674570f, -0.01286228f, 
    -0.02715953f, 0.05282745f, -0.09793828f, 0.17588933f, -0.02259381f, 0.13711098f, 0.01155300f, -0.03199264f, 
    0.04561319f, -0.00584439f, 0.01808415f, -0.04868995f, -0.23418841f, 0.08298484f, -0.10003921f, -0.08127828f, 
    0.08262488f, -0.10790779f, 0.07644239f, 0.10946127f, 0.05747795f, -0.05375830f, -0.02534452f, 0.02832465f, 
    0.03461055f, 0.05788876f, -0.09154894f, -0.14487036f, 0.09298517f, -0.05698227f, 0.00412797f, -0.01789305f, 
    -0.08354028f, 0.00830795f, 0.03838936f, -0.09881280f, -0.13922901f, -0.08586084f, -0.20060293f, 0.08788241f, 
    0.06799470f, 0.05352066f, 0.05279660f, 0.01243569f, 0.00259066f, -0.09628043f, -0.07366602f, -0.05294708f, 
    -0.19076510f, -0.16616622f, 0.14420098f, 0.13167995f, -0.13811998f, 0.06188832f, -0.05775726f, -0.10801222f, 
    0.09542163f, 0.12824528f, -0.08574823f, 0.02710319f, -0.09948516f, -0.08748986f, 0.02066013f, 0.00057183f, 
    -0.09253150f, -0.14893807f, -0.00128780f, -0.00128304f, 0.03738216f, 0.03685716f, 0.04145493f, -0.13423730f, 
    -0.34758836f, -0.02805108f, 0.08495215f, -0.28770652f, 0.16594490f, 0.12133120f, 0.00991893f, 0.01870639f, 
    -0.01022760f, 0.00521676f, -0.00360767f, 0.01387747f, 0.21470448f, -0.04400313f, 0.01902020f, -0.00559564f, 
    -0.03466859f, 0.01250612f, 0.01829438f, 0.09798821f, 0.08117075f, 0.09841522f, -0.01145533f, 0.09406250f, 
    0.14144561f, -0.11918673f, -0.15868925f, -0.07798176f, -0.12752850f, -0.06724648f, 0.08105833f, 0.09516663f, 
    0.00981709f, -0.02258554f, 0.00299840f, 0.03548788f, 0.20233867f, 0.20518570f, 0.00721153f, -0.02205269f, 
    0.03253962f, -0.01587371f, 0.04165992f, 0.07033495f, 0.09447756f, -0.09423394f, -0.02048461f, 0.07732955f, 
    -0.33204600f, 0.18804348f, 0.05938991f, -0.08653863f, -0.00868694f, 0.10468296f, -0.09148470f, 0.01875164f, 
    -0.04013404f, -0.04189193f, -0.05488707f, 0.04125535f, 0.02764612f, -0.08929458f, -0.02983001f, 0.08906785f, 
    -0.03031549f, -0.01559396f, 0.07207654f, 0.00947812f, 0.11040927f, 0.02891511f, -0.04336439f, 0.01817289f, 
    0.19194581f, 0.01171397f, -0.09842335f, -0.15359831f, -0.16209880f, -0.09391510f, 0.02961680f, -0.09056499f, 
    0.01823500f, -0.03141967f, 0.03343136f, -0.08417387f, 0.19206290f, 0.14683905f, 0.04870564f, 0.00866533f, 
    -0.00390114f, -0.10449342f, 0.09742814f, 0.02690467f, 0.06506623f, -0.11155889f, 0.10773367f, 0.07641934f, 
    -0.02809669f, 0.00254238f, -0.05070095f, 0.06262933f, 0.14207704f, -0.05283275f, 0.08880952f, 0.10177304f, 
    -0.08221835f, 0.16651209f, 0.05408753f, -0.01879117f, -0.03002043f, 0.11517329f, 0.24717741f, 0.16967571f, 
    -0.17562518f, -0.00901572f, -0.08136936f, 0.02482712f, 0.04266079f, -0.01471791f, -0.01047069f, -0.03523841f, 
    0.28867644f, -0.07127333f, 0.20859961f, -0.15027586f, 0.07441417f, 0.12336019f, 0.03027295f, 0.04112759f, 
    -0.00889798f, -0.12706739f, -0.07426707f, -0.02734908f, -0.20579883f, 0.05241768f, 0.03122036f, -0.16801943f, 
    -0.09421200f, 0.10279014f, -0.06269322f, 0.09237467f, 0.02481001f, -0.03899579f, -0.02428352f, 0.09812424f, 
    0.15603666f, -0.17245397f, -0.34405950f, -0.04130934f, 0.02336953f, 0.03722396f, 0.06853840f, -0.07745442f, 
    0.02138837f, -0.09951690f, 0.10835778f, -0.02289272f, -0.00227227f, -0.02385510f, -0.12985176f, 0.15319671f, 
    -0.01045519f, 0.01418726f, 0.01195567f, 0.05161892f, -0.03726154f, 0.05964001f, -0.13795838f, -0.03232739f, 
    -0.09755171f, 0.00396186f, -0.16028014f, 0.07600590f, 0.09015779f, 0.03185774f, 0.20042986f, -0.06739876f, 
    0.01379954f, 0.15451287f, -0.04153274f, 0.01848596f, 0.35461891f, 0.06780554f, -0.19423164f, -0.13285697f, 
    -0.03139119f, -0.08695802f, -0.08790769f, -0.19094211f, -0.08555505f, 0.08134871f, -0.08933621f, -0.01998198f, 
    0.09559800f, -0.01873042f, -0.07738841f, 0.06973388f, 0.06388765f, -0.03851235f, -0.10806589f, 0.11275288f, 
    0.01136831f, 0.00844560f, -0.03787676f, -0.03401772f, -0.03181839f, -0.07787661f, 0.09890247f, 0.13012731f, 
    -0.04886672f, -0.00418330f, 0.04253010f, 0.07319018f, 0.15646812f, -0.11280255f, -0.09843744f, 0.01973322f, 
    -0.02609272f, -0.11997160f, 0.04209900f, 0.08999769f, 0.05294701f, 0.06396946f, 0.02527589f, 0.10548349f, 
    0.04038652f, 0.14895052f, 0.01907723f, 0.10477504f, -0.09613152f, -0.00790707f, -0.06910184f, -0.24646716f, 
    0.02837648f, -0.07174452f, -0.13560189f, -0.01859305f, -0.03925273f, 0.06886086f, -0.02220646f, 0.03564019f, 
    0.07068154f, 0.01032436f, 0.12572765f, 0.17604208f, -0.07361861f, 0.08154641f, 0.05238258f, -0.00544803f, 
    -0.08630610f, 0.02033345f, 0.09364694f, 0.19795899f, 0.34420216f, 0.05033546f, -0.16920112f, -0.07594653f, 
    -0.09616537f, 0.08721536f, -0.11492977f, -0.11587846f, 0.01281468f, -0.10175466f, -0.01742888f, 0.06759980f, 
    -0.17573462f, -0.00709015f, -0.31395549f, -0.04302932f, 0.07212733f, 0.04840713f, -0.08051233f, -0.05092170f, 
    -0.01048233f, -0.02274017f, -0.06835353f, 0.01129522f, -0.29031065f, -0.18913800f, 0.00237776f, 0.18817873f, 
    -0.08511257f, -0.20015223f, -0.03159748f, 0.00900325f, 0.07174889f, -0.01976350f, -0.08257029f, 0.06304744f, 
    -0.23677309f, 0.02772702f, -0.09837123f, -0.00223895f, -0.06395347f, -0.03346811f, -0.05044420f, -0.11634786f, 
    0.04364554f, 0.00634536f, 0.09939414f, -0.02066227f, -0.06715691f, 0.00377881f, 0.00093365f, 0.04452768f, 
    -0.06752617f, -0.09520156f, 0.02448805f, 0.03345303f, 0.15969259f, -0.03940911f, -0.01894411f, -0.09637835f, 
    -0.38015360f, 0.01322655f, -0.38118005f, -0.10810757f, 0.14698830f, 0.17159718f, -0.10716759f, -0.05030073f, 
    0.02773271f, -0.23579994f, 0.07227543f, -0.09365219f, -0.17105018f, 0.14015977f, 0.10949215f, -0.21695369f, 
    -0.04759090f, 0.06782001f, 0.04843172f, 0.03812970f, 0.08597904f, -0.09442467f, -0.10179744f, -0.20749737f, 
    -0.11829583f, 0.06728456f, 0.01110825f, -0.06077188f, -0.11908736f, -0.07856376f, -0.07517628f, 0.04378067f, 
    -0.16251500f, 0.02702759f, -0.03990862f, 0.04394563f, 0.02194272f, -0.09213641f, 0.07020561f, -0.07272621f, 
    0.00046639f, -0.11463664f, 0.00551124f, -0.17867462f, 0.02767648f, -0.11057259f, -0.04854748f, -0.05728062f, 
    -0.15399711f, -0.04622026f, -0.06998868f, 0.05816587f, 0.00586902f, -0.12655513f, 0.07245176f, -0.08688552f, 
    0.03201785f, -0.05364024f, 0.08424518f, 0.11526246f, -0.00272787f, 0.15441832f, 0.02528495f, -0.02224353f, 
    0.20337598f, 0.14045693f, -0.00488202f, 0.00368798f, 0.21274868f, -0.12097022f, 0.09143315f, 0.10563699f, 
    -0.17919432f, 0.30867782f, -0.10404088f, 0.02782726f, 0.05347252f, -0.04198533f, 0.16810928f, -0.04902697f, 
    0.06635170f, -0.04235099f, -0.06843533f, -0.08301774f, 0.04940409f, 0.11917794f, -0.05626107f, -0.00160176f, 
    -0.03939613f, -0.03188611f, -0.14394100f, -0.14733770f, -0.15223645f, 0.11920026f, 0.01735401f, 0.03836881f, 
    -0.17739508f, -0.17054710f, 0.21625614f, 0.43599385f, -0.12228248f, -0.02049770f, 0.05870175f, -0.00413232f, 
    0.15039100f, 0.04305192f, 0.10747867f, -0.14888798f, -0.01269043f, -0.03303500f, 0.03267851f, -0.13337506f, 
    -0.11989459f, 0.10206204f, -0.12610644f, 0.13349473f, 0.06392770f, -0.03828524f, 0.01720776f, -0.02615269f, 
    -0.12142645f, -0.06124870f, 0.04201454f, -0.25744215f, -0.03383394f, -0.01868904f, -0.06151053f, 0.01685245f, 
    0.04654357f, -0.07780712f, 0.03696721f, 0.19119833f, -0.11511399f, -0.03082567f, 0.01387601f, 0.04925973f, 
    -0.02750305f, -0.13695721f, -0.16505444f, 0.19888163f, 0.07059011f, 0.00687195f, 0.08020560f, -0.05484786f, 
    0.07669850f, 0.09982605f, 0.22547545f, -0.27058291f, -0.05229943f, 0.01317686f, -0.03490154f, -0.08052898f, 
    0.06281161f, -0.04724753f, 0.00147152f, -0.04925619f, 0.09251351f, -0.03061620f, -0.00875845f, 0.05963927f, 
    0.02498941f, 0.15070097f, 0.22925495f, -0.03894444f, 0.04123186f, 0.08236261f, -0.08952496f, -0.08678509f, 
    0.02757110f, -0.11603326f, -0.09324069f, -0.16752860f, 0.03967487f, 0.10752591f, -0.02510233f, 0.08251825f, 
    0.01431506f, 0.04563047f, 0.01551735f, -0.22170249f, -0.42816579f, -0.19743371f, -0.38016683f, -0.08804651f, 
    0.21738578f, 0.09764132f, 0.02572280f, -0.02964508f, 0.01246401f, 0.03817563f, -0.01166066f, 0.04222915f, 
    -0.10149127f, 0.08877911f, 0.04212378f, 0.07100940f, -0.04961155f, 0.05057932f, -0.14429748f, -0.02872007f, 
    0.02947401f, -0.17256263f, 0.08920150f, -0.15395680f, -0.21306600f, 0.05804799f, 0.06128451f, 0.08435437f, 
    -0.04413677f, -0.01570629f, 0.12454304f, -0.09395083f, 0.02950238f, -0.18924130f, -0.23720749f, 0.10510883f, 
    0.03800487f, 0.02784299f, 0.02966489f, 0.25291181f, -0.08036227f, 0.13622823f, -0.04080203f, 0.07099336f, 
    -0.07088865f, 0.09617568f, -0.06533094f, 0.22673747f, -0.27179265f, -0.24468035f, 0.18116744f, 0.18547432f, 
    0.05075207f, 0.01164640f, 0.02886698f, -0.05965707f, 0.04864746f, 0.04071726f, 0.05146141f, 0.03921146f, 
    -0.03719677f, -0.14113680f, -0.24808027f, 0.02597683f, 0.05795094f, -0.04555437f, 0.07362711f, 0.05648094f, 
    0.05487924f, 0.06703531f, -0.09625353f, -0.15943661f, -0.06451347f, 0.05716560f, 0.02204211f, 0.22389190f, 
    0.05648860f, -0.09015823f, 0.03463800f, -0.03669324f, 0.00931536f, 0.00615334f, -0.06882259f, -0.08610205f, 
    0.10187495f, 0.08939232f, -0.24517076f, -0.00874573f, 0.10658924f, 0.07867990f, -0.09841686f, -0.06614869f, 
    0.16385454f, -0.01683190f, -0.05813233f, 0.00312377f, -0.09544481f, 0.05354721f, -0.02395974f, -0.01809477f, 
    -0.01529471f, -0.15006711f, -0.05814469f, 0.06894580f, 0.11953583f, 0.06583416f, -0.00256655f, 0.01749443f, 
    0.08032800f, 0.07864869f, 0.07302807f, -0.06332614f, 0.00706948f, 0.06092452f, -0.01135827f, 0.11926431f, 
    -0.16119565f, 0.09640769f, 0.06346472f, 0.01727125f, 0.11470941f, -0.05665869f, 0.20726246f, 0.06005589f, 
    -0.08730298f, 0.06088169f, 0.06164363f, 0.01442995f, -0.05821281f, 0.14742818f, 0.05078941f, 0.11315741f, 
    0.19131574f, -0.06054573f, -0.01731510f, -0.11368392f, -0.12438156f, -0.13315101f, 0.05167864f, 0.01989028f, 
    0.11280857f, -0.05655814f, 0.00479166f, 0.00621689f, 0.07969295f, 0.15063706f, 0.18383698f, -0.05387583f, 
    -0.05126640f, 0.11702117f, 0.02612281f, -0.06055056f, 0.16745755f, -0.12804356f, 0.03206073f, -0.13591459f, 
    0.12813795f, -0.08226463f, 0.05609971f, -0.10140746f, -0.12780432f, -0.11826868f, -0.02937436f, 0.05002095f, 
    0.02424610f, 0.06914175f, -0.07776942f, -0.13483791f, -0.03016527f, 0.04639159f, 0.18738158f, -0.14180730f, 
    0.03206423f, -0.04063381f, 0.03574234f, 0.05280101f, 0.06471374f, 0.05949920f, 0.02680942f, 0.11684527f, 
    0.21798989f, 0.00896131f, 0.15367155f, 0.00258562f, -0.02017034f, 0.04611948f, -0.00494388f, -0.15119673f, 
    0.00685290f, -0.03391808f, -0.07536333f, 0.01659520f, -0.11674843f, -0.00730701f, 0.10902306f, -0.12451828f, 
    -0.07193404f, 0.02173803f, 0.05764719f, 0.15174541f, -0.03029628f, 0.01604935f, -0.07557102f, -0.09689394f, 
    -0.45952943f, -0.11283434f, -0.01428628f, -0.19458885f, 0.03483912f, -0.09938423f, 0.04325762f, -0.17760035f, 
    -0.00046669f, 0.10563298f, -0.04876867f, 0.07133152f, -0.00593445f, -0.01215678f, 0.07546578f, -0.00555671f, 
    -0.03023565f, 0.19589171f, 0.00120827f, -0.01507847f, 0.08043846f, 0.10433903f, 0.08932386f, 0.12315349f, 
    -0.00378687f, 0.07266062f, 0.09150701f, 0.16055219f, 0.06037270f, 0.10650161f, -0.00170484f, -0.02661757f, 
    -0.07399388f, 0.08327897f, 0.05964293f, 0.03926121f, -0.24123420f, -0.15899476f, -0.10169592f, 0.05815645f, 
    0.03328084f, -0.02760322f, 0.00899067f, 0.09916940f, 0.13700406f, 0.02842457f, 0.00310537f, 0.08075815f, 
    0.03320298f, 0.12400270f, 0.09830439f, 0.10922085f, -0.09469029f, 0.03768205f, 0.04364293f, 0.07128616f, 
    -0.11204174f, -0.27551356f, -0.06646212f, 0.16907886f, 0.03970617f, -0.08010364f, 0.02709367f, -0.17394191f, 
    -0.03226190f, -0.10510457f, 0.16047025f, -0.07442185f, 0.03965301f, 0.06400881f, 0.05454174f, 0.18729773f, 
    0.06118840f, 0.25081244f, -0.08746600f, -0.08485931f, 0.02848816f, -0.07768629f, -0.18403666f, 0.18781772f, 
    -0.12734915f, -0.03744698f, -0.09872907f, -0.33502808f, -0.08889659f, -0.20938496f, -0.12698103f, 0.03926441f, 
    0.14248127f, 0.10161217f, -0.09854947f, -0.16288143f, -0.08342682f, -0.05981220f, 0.11887834f, 0.00489170f, 
    -0.05426019f, -0.10594232f, 0.08268119f, -0.06876081f, 0.05984438f, -0.06270986f, -0.03982273f, -0.12485062f, 
    -0.07152000f, 0.02294024f, 0.02983763f, 0.12418036f, -0.06158778f, 0.09459585f, -0.02093503f, -0.12081505f, 
    -0.02488077f, -0.01386708f, 0.05298346f, -0.16913097f, 0.13401572f, -0.02968060f, -0.08643287f, 0.22667845f, 
    -0.02506513f, -0.25196168f, 0.07636116f, 0.21472941f, -0.15956460f, -0.03245703f, 0.05490811f, 0.02274623f, 
    -0.17250325f, 0.12472927f, 0.00375202f, -0.00866238f, 0.02423514f, 0.08904453f, 0.07789551f, 0.25299671f, 
    -0.03679374f, -0.02200015f, -0.00621007f, 0.00453358f, -0.03522569f, -0.10333176f, -0.00712156f, 0.09412086f, 
    0.14430217f, 0.01023778f, 0.13887702f, 0.04900575f, -0.09829259f, -0.04444251f, 0.01522514f, -0.00917599f, 
    -0.16504183f, 0.02281935f, 0.01726250f, 0.12898400f, -0.16110422f, -0.35594162f, 0.05900704f, 0.17623273f, 
    -0.00186288f, 0.07924570f, 0.01046870f, -0.09332910f, -0.00039223f, 0.04500614f, -0.03585130f, 0.00694317f, 
    -0.20225629f, -0.09495446f, -0.07959925f, -0.04500084f, 0.05697608f, 0.13555124f, 0.03315239f, -0.03376278f, 
    0.13752055f, -0.10364051f, 0.05348265f, 0.02872454f, 0.00949673f, 0.09341414f, -0.04774017f, 0.11943162f, 
    -0.14079320f, 0.00913631f, 0.06298318f, -0.07616918f, -0.10481779f, -0.07474142f, 0.02034887f, 0.20292792f, 
    -0.24364562f, -0.09406517f, -0.11038962f, 0.25026879f, 0.06550016f, 0.06059425f, 0.02384622f, 0.05346252f, 
    0.13206853f, 0.03216384f, 0.12998094f, -0.15657048f, -0.03408344f, 0.08096758f, -0.12575239f, -0.10564534f, 
    0.02200403f, -0.09814763f, 0.07378402f, 0.04817861f, 0.02351671f, -0.04967431f, -0.00693127f, -0.01555638f, 
    0.12307727f, 0.07207856f, 0.19213985f, -0.04003989f, 0.06478849f, -0.05570358f, -0.05792363f, -0.19347303f, 
    -0.09145708f, 0.01041420f, -0.03586029f, -0.08318838f, -0.10114037f, -0.16891851f, 0.04163066f, 0.03515679f, 
    -0.05586257f, 0.03251197f, 0.08501899f, -0.05099765f, 0.05910720f, 0.00888581f, 0.06580107f, -0.08327987f, 
    0.15668337f, 0.07953869f, -0.12857945f, -0.14936911f, -0.03535353f, 0.03782777f, 0.03175539f, -0.05304650f, 
    -0.09202944f, -0.07477325f, -0.05653213f, -0.13322479f, -0.44933832f, 0.02166851f, -0.01440561f, 0.22844186f, 
    0.05779884f, -0.01960612f, 0.00846330f, 0.06315804f, 0.01581463f, -0.09231507f, 0.11564709f, -0.02235692f, 
    -0.03390951f, 0.26299819f, 0.01482463f, -0.08128296f, -0.23377807f, 0.00475094f, 0.01196140f, 0.00513614f, 
    -0.06576528f, -0.00075902f, 0.04361351f, 0.06494858f, -0.00665508f, 0.02791483f, -0.23453264f, 0.00621165f, 
    -0.06331668f, 0.08531978f, -0.27267882f, -0.06461550f, 0.02058244f, -0.03931398f, -0.09072472f, -0.00869631f, 
    -0.17403564f, 0.08973990f, -0.14355360f, 0.19096783f, 0.04188078f, -0.00567605f, 0.02404051f, 0.03277781f, 
    -0.08703519f, -0.15954827f, 0.03469376f, -0.10463504f, 0.21290499f, 0.06209209f, -0.03620500f, -0.30187476f, 
    -0.07621749f, 0.02930722f, 0.05446722f, 0.03278681f, 0.04835647f, -0.01942773f, 0.02201207f, -0.00526591f, 
    0.16030774f, 0.06156664f, 0.02898681f, -0.27669266f, -0.02311548f, -0.02540399f, 0.05238027f, -0.05329209f, 
    0.05561702f, -0.08964058f, 0.00962780f, -0.15942280f, -0.29581174f, -0.00619818f, -0.04964581f, 0.19915615f, 
    0.11241146f, 0.09470359f, 0.09852474f, -0.01575585f, 0.11915538f, -0.00943260f, 0.05446175f, -0.05954454f, 
    -0.10010014f, -0.08308610f, 0.04221858f, -0.22712058f, -0.03901273f, 0.04689048f, -0.03676341f, -0.07358456f, 
    0.00924567f, 0.02939776f, 0.08835576f, 0.11112741f, 0.23835692f, -0.03364135f, -0.06856019f, 0.14925268f, 
    0.01380950f, -0.00126172f, -0.00417507f, -0.06227404f, -0.04153343f, -0.04239134f, 0.04233467f, -0.07594353f, 
    0.03599441f, 0.01486599f, -0.07749894f, 0.13237661f, -0.00721508f, -0.01626354f, 0.12295750f, 0.13334654f, 
    -0.05135790f, 0.07275436f, -0.08342108f, -0.01846741f, -0.18532132f, 0.15573162f, -0.06947279f, 0.35732505f, 
    0.10275208f, 0.18759882f, -0.08848929f, 0.08034988f, -0.04790517f, 0.01136583f, -0.15730411f, -0.03948652f, 
    -0.05595733f, -0.38345206f, -0.09216163f, -0.14044410f, -0.12389103f, -0.00586860f, 0.03518028f, 0.02808631f, 
    0.03102269f, 0.11688986f, 0.04292282f, 0.12830478f, 0.19587220f, -0.29675233f, 0.06468257f, -0.07415511f, 
    -0.00056615f, 0.00887965f, -0.06594778f, 0.01547197f, -0.06758494f, 0.02613443f, 0.09282157f, 0.14971523f, 
    0.06514588f, 0.06035074f, 0.06078819f, -0.01965516f, 0.06532723f, 0.11319823f, 0.08362883f, -0.00048966f, 
    0.13720559f, -0.12435391f, -0.01531374f, 0.03463934f, 0.11537560f, -0.24711360f, 0.09078858f, 0.00882744f, 
    -0.13113384f, -0.09642799f, -0.00965549f, 0.02697275f, -0.03794442f, -0.02433045f, -0.01303770f, 0.03426122f, 
    0.02557581f, 0.04304843f, 0.04862733f, -0.03939955f, 0.02404015f, 0.13033359f, 0.10943938f, 0.00274140f, 
    -0.10870096f, -0.03175874f, -0.11704551f, 0.12825538f, -0.03044684f, 0.05720529f, -0.05057533f, -0.06152250f, 
    -0.18642490f, -0.27092364f, -0.07370056f, -0.10592050f, 0.08126966f, -0.08346188f, -0.12323213f, -0.07384023f, 
    0.48143834f, -0.35962334f, 0.11874960f, -0.12678294f, -0.02660711f, 0.03134284f, 0.00484412f, -0.06491639f, 
    -0.02704608f, -0.03857055f, 0.15302297f, -0.01786489f, 0.03765554f, -0.07397985f, -0.16276410f, 0.23499095f, 
    0.09976102f, -0.06621862f, 0.10864868f, 0.01663325f, 0.19013624f, -0.12609982f, 0.05849824f, -0.02717814f, 
    -0.07735153f, -0.06492611f, 0.01133936f, 0.17407098f, 0.11557195f, -0.03971588f, -0.14847246f, 0.02146324f, 
    -0.21737035f, 0.01677182f, -0.15252522f, 0.06113687f, -0.12636043f, 0.00791247f, 0.00736804f, -0.06915876f, 
    0.04402295f, 0.06107791f, 0.04202657f, 0.04453138f, -0.05005909f, 0.01425652f, -0.01654189f, -0.01821796f, 
    0.35426727f, 0.20596181f, 0.13621601f, -0.10312961f, -0.15446934f, 0.04704376f, 0.11231522f, 0.00900183f, 
    -0.00042707f, -0.03023939f, 0.03293836f, -0.10617948f, 0.05904259f, 0.11461507f, 0.07133757f, -0.06242432f, 
    0.02249114f, 0.03345450f, -0.04721151f, 0.07059987f, -0.08735359f, 0.06239524f, 0.04385816f, 0.16095810f, 
    -0.34667489f, 0.10032433f, 0.07234089f, -0.04103823f, -0.02309925f, -0.05456503f, 0.01123384f, 0.07337611f, 
    -0.06333750f, -0.00443150f, -0.01415582f, 0.00911787f, -0.18208008f, -0.15535833f, -0.08263236f, 0.03286117f, 
    0.05581634f, -0.11591787f, -0.11668210f, -0.07409091f, -0.01371688f, -0.04953450f, 0.12097935f, 0.04316867f, 
    -0.09345184f, 0.03641770f, -0.06186182f, -0.00401993f, 0.01783417f, -0.15606400f, -0.00521716f, -0.11849140f, 
    0.07331661f, -0.09910428f, 0.11304629f, 0.09252308f, 0.08807936f, -0.16539320f, -0.08161133f, -0.29093665f, 
    0.03513773f, -0.07279766f, 0.05402703f, -0.16830948f, 0.01757454f, -0.14155976f, 0.14853056f, 0.07934096f, 
    0.08947667f, 0.04693670f, -0.01709686f, -0.03505189f, 0.03294831f, 0.00312452f, -0.00852686f, 0.07019587f, 
    0.00015499f, 0.08041294f, -0.06026684f, 0.07755978f, 0.12323666f, -0.01448265f, -0.01849737f, 0.14025994f, 
    0.04045894f, -0.03763065f, -0.12820290f, 0.07462641f, 0.05904417f, 0.08733814f, 0.16650437f, 0.02994925f, 
    -0.13010971f, -0.03413863f, -0.26811281f, -0.27158985f, -0.05285718f, 0.04869985f, -0.01628418f, -0.09195840f, 
    -0.18718462f, -0.06520154f, 0.08713369f, -0.07375640f, 0.17191814f, 0.07276551f, 0.05712216f, 0.01174478f, 
    -0.03685894f, -0.06112124f, 0.11178479f, 0.02531013f, 0.09413266f, -0.00721522f, 0.06107980f, -0.03175427f, 
    -0.32571092f, 0.04686607f, -0.04102806f, 0.04747915f, 0.02410174f, -0.02106753f, 0.00785734f, 0.04232420f, 
    0.01229673f, -0.02186387f, 0.04902463f, 0.05806123f, -0.18395121f, -0.13558665f, -0.13895118f, 0.24328583f, 
    0.15644059f, 0.13520102f, -0.04777749f, 0.09454267f, 0.03734443f, -0.03558174f, -0.00934400f, 0.10817681f, 
    -0.09108172f, -0.20607564f, -0.15717661f, -0.16071180f, -0.03993801f, -0.03846025f, 0.03063752f, 0.02904716f, 
    -0.06587008f, 0.01627751f, 0.08725073f, 0.08453028f, -0.16056129f, -0.06196376f, -0.11053967f, -0.02935723f, 
    0.17398036f, 0.06836838f, -0.03144830f, 0.07591737f, -0.01471870f, -0.10194033f, 0.06622683f, -0.14241171f, 
    -0.08628809f, 0.11572126f, 0.17335373f, -0.10565220f, 0.03615468f, -0.01965709f, 0.07997849f, -0.03770022f, 
    0.01279326f, 0.02786613f, -0.17628589f, -0.16737990f, 0.07029612f, 0.16242939f, -0.00020607f, -0.06931312f, 
    -0.05341816f, -0.00295914f, -0.03461826f, 0.02090479f, -0.00871219f, -0.00828420f, -0.00757804f, -0.14111888f, 
    0.10254869f, 0.08748323f, 0.04560598f, -0.22754312f, 0.01481225f, 0.10222826f, 0.13107061f, 0.03589034f, 
    -0.01684077f, 0.06731711f, 0.03605735f, -0.04057749f, -0.22460249f, -0.12172768f, -0.15943505f, -0.08331402f, 
    -0.08263726f, -0.07201665f, 0.04833476f, 0.04857853f, 0.06821746f, 0.10367572f, 0.01149681f, 0.08574797f, 
    -0.24008404f, -0.06648432f, 0.01929570f, 0.18685003f, 0.07281266f, 0.05600191f, 0.11056867f, -0.02619392f, 
    -0.04808322f, -0.16591738f, 0.01232394f, 0.18427467f, -0.01180642f, 0.07388246f, 0.01688800f, -0.21959382f, 
    -0.03709103f, 0.02153166f, 0.04321822f, -0.04106179f, -0.03418991f, -0.06980895f, 0.01905435f, -0.19638626f, 
    -0.44862488f, 0.18570922f, 0.18269204f, 0.21645552f, -0.08246348f, -0.09270187f, 0.00607002f, 0.14869705f, 
    -0.03896505f, 0.04033766f, 0.05690784f, 0.02700999f, 0.26031366f, 0.03482315f, 0.00818924f, -0.04106802f, 
    -0.03233442f, -0.03339797f, -0.05463288f, -0.00166989f, -0.01164287f, 0.00044142f, 0.03797787f, 0.04761638f, 
    -0.60806572f, -0.11681075f, -0.03907301f, -0.08515726f, 0.04397270f, 0.05550624f, 0.09283938f, -0.00991295f, 
    0.02614199f, -0.05625188f, 0.01708370f, -0.06275281f, 0.13864410f, 0.03141535f, -0.00370362f, -0.23708966f, 
    -0.13626713f, 0.02911298f, 0.05405641f, 0.04870069f, 0.07895502f, -0.10001994f, -0.08733618f, 0.00487992f, 
    0.17033044f, -0.01208470f, 0.04181091f, 0.07611368f, 0.02329679f, 0.02821303f, -0.04205984f, 0.06280269f, 
    0.04749069f, -0.07938866f, 0.03626587f, -0.09516909f, -0.13311967f, -0.04842237f, -0.12859005f, -0.11645889f, 
    -0.11027882f, 0.02272820f, -0.06171024f, -0.06932557f, -0.22469951f, 0.05171941f, 0.03521341f, -0.01628505f, 
    -0.02930898f, 0.11739181f, 0.01267824f, -0.29145664f, 0.11125243f, -0.05092430f, 0.04409184f, 0.04215699f, 
    0.11222625f, 0.06278408f, 0.01598711f, 0.13424040f, 0.07500196f, 0.04961240f, -0.01667191f, 0.03536946f, 
    0.15414906f, 0.05775862f, 0.00103254f, -0.10782303f, -0.17942731f, -0.10395261f, -0.10851754f, -0.10666478f, 
    0.37593880f, -0.13746567f, 0.13990401f, -0.36663458f, -0.05840123f, -0.00551995f, 0.12412995f, 0.08131770f, 
    0.10244635f, 0.16073655f, 0.00075601f, 0.20635383f, 0.00681601f, -0.06952971f, -0.03818478f, 0.24725987f, 
    -0.06693036f, 0.03820498f, 0.09248661f, 0.00211807f, -0.01877638f, 0.07102499f, -0.04735684f, 0.04813567f, 
    0.01497573f, -0.14231561f, 0.02895935f, 0.15331519f, -0.05257877f, 0.11434779f, 0.08621603f, -0.03986682f, 
    0.04316944f, -0.06672399f, -0.00228907f, -0.24841772f, -0.17057037f, 0.28733206f, -0.02060908f, -0.20795651f, 
    -0.05280244f, 0.05349469f, -0.10079776f, 0.09794694f, 0.01321765f, -0.05389510f, 0.06972850f, -0.14242315f, 
    0.22231458f, 0.04829498f, -0.00680370f, -0.03139543f, 0.07593250f, -0.02236004f, -0.03767784f, 0.04100396f, 
    0.10572266f, -0.10509648f, -0.11294390f, 0.06335413f, -0.07954954f, -0.05282177f, 0.04790765f, 0.06738433f, 
    0.05893803f, 0.06345318f, -0.09748930f, -0.10177284f, -0.01210385f, 0.01901807f, 0.02097906f, 0.04086681f, 
    -0.23467274f, 0.03979233f, -0.00016259f, 0.39278060f, 0.05047568f, 0.10125005f, 0.07169589f, -0.02636606f, 
    0.07118066f, -0.05280260f, -0.06938538f, -0.10735590f, 0.13351987f, -0.01501550f, -0.02854173f, -0.14479341f, 
    -0.08234651f, -0.03420796f, 0.01344370f, 0.03031380f, 0.02926834f, 0.02637902f, -0.00059017f, 0.00253021f, 
    -0.19473739f, -0.04333596f, 0.00483087f, -0.28660867f, -0.00506845f, -0.02603063f, 0.00566286f, -0.13785997f, 
    -0.00336447f, 0.02100642f, -0.01840826f, 0.01978665f, -0.14812042f, 0.22345477f, 0.01069301f, -0.33659446f, 
    -0.14404120f, -0.04384763f, 0.05559852f, 0.03383094f, 0.10215386f, 0.06681979f, -0.04831114f, -0.08505797f, 
    -0.19253260f, 0.04082553f, -0.02855054f, 0.04275775f, -0.11835054f, -0.09019642f, 0.05337482f, -0.14476615f, 
    -0.18308559f, 0.04585039f, 0.03723654f, -0.02773513f, 0.11614432f, -0.25909394f, 0.06480640f, -0.12638979f, 
    -0.01421448f, -0.00615014f, 0.12221013f, 0.06475880f, 0.00495329f, -0.00877213f, 0.08467637f, -0.06273139f, 
    -0.36885744f, -0.04612476f, 0.07979471f, -0.13922743f, 0.02490656f, 0.12888879f, 0.07916451f, 0.09593750f, 
    0.05750019f, 0.06450985f, -0.03626814f, 0.08233086f, 0.13330010f, -0.04740233f, -0.20669691f, 0.14023203f, 
    -0.12534325f, 0.03736568f, 0.02276535f, -0.11590798f, 0.00327482f, 0.07377271f, -0.03330950f, 0.18564025f, 
    0.06454983f, -0.01770647f, 0.10772427f, 0.01418941f, -0.06616899f, 0.01224846f, -0.02070473f, -0.03780818f, 
    -0.06733164f, 0.00299479f, 0.00145053f, -0.06856391f, -0.14759773f, 0.07943626f, -0.14954029f, -0.06822777f, 
    -0.10848427f, 0.08050031f, -0.00320916f, -0.02755398f, 0.09772497f, 0.01780658f, 0.00968118f, -0.06950022f, 
    -0.15006335f, -0.04263259f, -0.06987512f, -0.26246876f, -0.02728910f, 0.06430337f, 0.00163240f, -0.07332314f, 
    -0.03594711f, -0.01220704f, -0.10000436f, -0.10935102f, -0.08462192f, 0.10295543f, 0.03476675f, 0.09316387f, 
    -0.05599664f, -0.01481525f, -0.06709719f, -0.04233681f, 0.02728044f, 0.01993044f, -0.05665164f, -0.00809267f, 
    -0.18128960f, -0.09164587f, -0.13893442f, -0.05275802f, 0.02267576f, -0.04870734f, -0.06624987f, -0.03173897f, 
    0.01605828f, -0.07547505f, -0.00026594f, -0.07235171f, -0.20207199f, 0.08294983f, -0.02000054f, -0.02518554f, 
    -0.03363220f, -0.05527670f, 0.05512554f, -0.07641734f, -0.02624618f, -0.06720236f, -0.11249162f, -0.09117957f, 
    -0.12501541f, -0.06464274f, -0.14571002f, 0.04740825f, -0.00137726f, -0.03390546f, -0.01818794f, -0.02101555f, 
    0.06814557f, -0.02705874f, 0.00525444f, 0.00384814f, -0.04633608f, 0.05349918f, -0.06361416f, -0.06961773f, 
    -0.01458203f, 0.01993509f, -0.02856561f, -0.02605793f, 0.01900239f, 0.02551804f, -0.05923743f, -0.08412814f, 
    0.05639355f, 0.13349637f, 0.11562333f, 0.07663605f, 0.05450058f, 0.02635800f, 0.03141597f, -0.03456849f, 
    0.00256101f, 0.05187215f, -0.04294119f, -0.08030784f, 0.23970747f, -0.03088806f, 0.03085477f, 0.08045472f, 
    0.17180493f, 0.05818392f, 0.04539656f, -0.03504274f, -0.00543193f, -0.04744725f, -0.05040036f, -0.04527563f, 
    -0.03652448f, 0.04987061f, 0.03576732f, 0.02994443f, -0.01979467f, -0.01325211f, -0.00830798f, 0.01671540f, 
    -0.05239749f, -0.04233090f, -0.08507286f, -0.05037305f, -0.23094118f, -0.11275421f, -0.08048182f, -0.13729826f, 
    0.08290549f, -0.07442891f, -0.00996604f, -0.02299468f, -0.07112436f, 0.00292248f, -0.02655287f, -0.01783169f, 
    0.14324160f, 0.16443954f, 0.19091770f, 0.13513948f, 0.08240310f, 0.14890298f, 0.06232542f, 0.00266804f, 
    -0.12521695f, -0.01745651f, -0.00505893f, -0.06112748f, -0.27613690f, 0.07929900f, 0.12823395f, -0.09611784f, 
    -0.08451294f, 0.00694242f, -0.06329107f, 0.01059749f, -0.07730561f, 0.01094715f, 0.01246746f, -0.00839620f, 
    -0.10103539f, 0.00220572f, -0.18961006f, 0.08145924f, 0.03675904f, -0.03306971f, -0.04056805f, -0.06151493f, 
    -0.02682105f, -0.06059976f, -0.02732068f, -0.08012837f, -0.24095342f, -0.00234144f, -0.01133385f, -0.09673507f, 
    0.03133661f, -0.03364483f, 0.00874469f, -0.02697071f, -0.01577244f, -0.01753577f, 0.03658743f, -0.04097203f, 
    0.05238561f, -0.00185028f, -0.07394061f, -0.09358896f, -0.09301686f, -0.00459468f, -0.06904464f, -0.01461407f, 
    -0.01549920f, 0.03210485f, -0.06786565f, -0.03157457f, 0.02089606f, 0.04840097f, 0.01319515f, 0.11718969f, 
    0.09936765f, 0.05558239f, 0.00224075f, 0.00284704f, -0.04921890f, 0.08095172f, 0.08559621f, -0.03104028f, 
    -0.00605750f, 0.23912926f, 0.14715010f, -0.00773386f, 0.07592237f, 0.01075533f, 0.01874972f, 0.12887332f, 
    -0.08071765f, 0.03318234f, 0.09393071f, 0.07387754f, 0.07596149f, 0.16346711f, -0.00647778f, 0.07899732f, 
    0.00913708f, 0.04741808f, 0.03313906f, 0.05878857f, -0.01650858f, 0.04677506f, -0.01413026f, -0.01933756f, 
    0.00152175f, -0.08124902f, 0.11416936f, 0.18097661f, 0.06669033f, -0.08799522f, -0.11484846f, 0.00362341f, 
    -0.10035686f, -0.09851895f, -0.04515095f, 0.05300621f, -0.09026156f, 0.14469902f, 0.09574368f, -0.03884561f, 
    -0.02146753f, 0.03887839f, -0.00967965f, -0.01259765f, -0.06772019f, 0.01168430f, -0.03849017f, -0.03416159f, 
    0.19392031f, 0.18270601f, -0.10850641f, -0.12063976f, -0.11064586f, 0.00397964f, 0.01287355f, -0.07435082f, 
    -0.07653704f, -0.07717656f, -0.05920735f, 0.04563631f, 0.01822207f, -0.13706903f, -0.11991584f, -0.17560071f, 
    -0.03539610f, 0.01423834f, 0.01957698f, -0.13074359f, -0.06462063f, -0.07771690f, -0.02986300f, -0.03351257f, 
    -0.12359437f, 0.12254776f, 0.06462452f, -0.06173770f, -0.00033810f, 0.05536735f, -0.02320433f, -0.02641558f, 
    -0.01872496f, 0.01810732f, -0.04537673f, -0.03821931f, 0.02464620f, 0.07328851f, -0.14744289f, -0.00012180f, 
    0.04991182f, 0.08630732f, 0.00435158f, 0.00422910f, 0.02470518f, -0.01181637f, -0.04933821f, 0.02397571f, 
    0.10564688f, 0.12088253f, 0.11937975f, 0.10202442f, 0.01590518f, 0.04348544f, -0.00215775f, -0.00385897f, 
    -0.07326105f, -0.04457642f, -0.01865040f, -0.01428047f, 0.13934135f, 0.17995667f, 0.17790140f, 0.10861250f, 
    0.02271939f, 0.16335724f, -0.00107827f, -0.03044983f, -0.06708997f, 0.03633193f, -0.06902281f, 0.04605048f, 
    0.03062732f, 0.04210063f, 0.01880863f, -0.03001531f, -0.05129605f, -0.02991683f, -0.02248848f, -0.03602017f, 
    -0.06315041f, 0.12352350f, -0.04910463f, -0.02173202f, 0.10421421f, -0.04653870f, -0.02912862f, -0.00026744f, 
    -0.14939427f, 0.03264915f, -0.03383362f, 0.01865325f, -0.01514977f, 0.00227471f, 0.04598799f, 0.04290685f, 
    0.02695793f, -0.03892058f, 0.03461342f, 0.20673665f, -0.13338633f, -0.02586037f, -0.03558460f, -0.03096935f, 
    -0.04251297f, -0.00776485f, -0.00641684f, 0.01269169f, -0.05454560f, -0.08111446f, 0.01992231f, -0.01538354f, 
    -0.01705772f, 0.00073847f, 0.01321090f, -0.01933621f, 0.01624083f, -0.01581817f, -0.01337242f, -0.07079980f, 
    0.12232062f, -0.05553887f, 0.04079084f, 0.02726150f, 0.03953030f, 0.00084851f, -0.10238923f, -0.06503931f, 
    0.03971504f, -0.04966751f, -0.05710952f, -0.05530382f, -0.08840094f, 0.08310613f, -0.04995489f, 0.06148477f, 
    -0.01046835f, 0.01805426f, -0.09625613f, 0.08089343f, 0.04396602f, -0.01805185f, 0.05410504f, -0.04260987f, 
    0.13856278f, 0.12559260f, 0.17178640f, 0.17091885f, 0.09189393f, 0.09703542f, 0.05212955f, 0.01702487f, 
    -0.05885604f, 0.04036435f, -0.03165614f, -0.06794115f, -0.26607683f, 0.11200050f, -0.05290856f, -0.08429334f, 
    -0.04435883f, -0.04231999f, -0.14193571f, -0.00639952f, 0.02672480f, -0.00483155f, -0.07318453f, -0.07017127f, 
    0.25728387f, -0.05699863f, -0.05050112f, -0.03875798f, -0.03323474f, 0.05345641f, -0.05332379f, -0.00868686f, 
    -0.03356143f, -0.01516431f, 0.01358364f, -0.07680366f, -0.39289778f, 0.23738970f, -0.05992550f, -0.03725201f, 
    0.01274065f, -0.02501194f, 0.05844553f, -0.00630526f, -0.12162124f, 0.04610895f, 0.07063998f, -0.04684560f, 
    0.11564599f, -0.34113020f, 0.00124845f, 0.04390196f, -0.00490337f, 0.03152107f, -0.02057292f, -0.05794865f, 
    -0.05332807f, -0.00843011f, -0.01918086f, -0.01795361f, 0.13105567f, 0.10922020f, 0.07002164f, -0.06012242f, 
    -0.03850292f, -0.01690433f, -0.02152565f, -0.07521770f, -0.01682459f, 0.07445932f, -0.01728352f, -0.02246195f, 
    0.13745919f, -0.09794914f, 0.11701294f, 0.15107183f, 0.02634568f, -0.04218671f, -0.06111242f, -0.01740871f, 
    -0.01544691f, -0.10865869f, -0.03023568f, 0.00057497f, -0.32030815f, 0.22642061f, -0.13408038f, -0.15388007f, 
    -0.07119207f, -0.02023306f, 0.02449566f, -0.02760078f, -0.05872616f, -0.00157224f, -0.05969893f, -0.05656580f, 
    -0.09224750f, 0.02916020f, -0.04421686f, -0.04063272f, -0.05146035f, -0.00821065f, 0.02728756f, 0.01902600f, 
    -0.03315600f, -0.08686171f, 0.00097679f, -0.07128260f, -0.06081246f, -0.13462086f, -0.03608516f, -0.21651168f, 
    0.04792276f, 0.01803270f, 0.02295334f, -0.06336657f, -0.02020919f, 0.00869832f, -0.02137663f, 0.01252443f, 
    -0.16553046f, 0.10431337f, 0.15322411f, 0.07466655f, 0.03264167f, -0.03899569f, 0.02823825f, 0.01844996f, 
    -0.01437280f, -0.00060712f, 0.03423112f, -0.05134943f, -0.26994902f, 0.13284038f, -0.18059056f, -0.05599803f, 
    0.01198769f, 0.00778237f, 0.04661175f, -0.10521310f, -0.09382074f, -0.00496584f, -0.01422530f, 0.00150126f, 
    0.09220020f, -0.33149305f, 0.06366954f, -0.00816578f, -0.03065314f, 0.01652065f, -0.01822558f, 0.01401299f, 
    -0.06760102f, -0.13174261f, 0.03409798f, -0.02270793f, 0.07212943f, 0.19408190f, 0.00275569f, 0.08954738f, 
    0.01747395f, -0.00105154f, 0.04004619f, 0.02057680f, -0.05532802f, -0.02417027f, -0.07590427f, -0.06219174f, 
    -0.06947944f, -0.13128941f, -0.11778326f, -0.07824914f, -0.05830463f, 0.00576390f, -0.05754118f, -0.06989084f, 
    -0.09816153f, 0.05629923f, 0.04849527f, -0.06064836f, 0.16359906f, -0.17771968f, 0.06992362f, -0.01633889f, 
    -0.04788021f, 0.00397023f, -0.06976804f, 0.06913333f, 0.00996991f, 0.03383520f, -0.04555807f, -0.03423915f, 
    0.28173050f, 0.03433281f, 0.10107736f, -0.04993491f, 0.00073701f, -0.01904651f, 0.07532274f, -0.03820746f, 
    0.01829913f, 0.03147598f, -0.02464169f, -0.08522394f, 0.07991125f, 0.15057921f, -0.06342112f, 0.16668101f, 
    0.08599517f, -0.12970640f, 0.04345779f, -0.00881396f, 0.01913712f, 0.04469530f, 0.00974524f, -0.02113375f, 
    0.18004648f, -0.06255954f, -0.02614259f, 0.07653654f, 0.04897916f, 0.00509508f, -0.11496259f, -0.02157634f, 
    0.01791503f, -0.01964189f, 0.00218023f, -0.06652055f, -0.35333401f, 0.11301151f, -0.04513540f, -0.02081960f, 
    -0.09166360f, -0.02530942f, -0.01583607f, -0.00948327f, -0.06454442f, 0.01191032f, 0.03915130f, -0.07054169f, 
    -0.13529323f, -0.07517389f, 0.03981862f, 0.12190625f, 0.01192129f, -0.08339588f, -0.01582027f, -0.01382477f, 
    -0.04933044f, 0.00747065f, -0.05878748f, -0.02919747f, 0.03464319f, 0.04761582f, -0.02231426f, 0.07825655f, 
    -0.00381916f, -0.10599831f, -0.11000042f, -0.03163816f, -0.08711109f, -0.06374134f, -0.02609899f, -0.03474743f, 
    0.03649164f, -0.20677482f, 0.01872786f, 0.07550572f, 0.05177616f, -0.02996485f, 0.01570328f, -0.01322353f, 
    0.00097158f, -0.10432659f, -0.08628671f, -0.05459353f, -0.00053212f, 0.21934226f, 0.04243530f, 0.16510630f, 
    0.03309320f, 0.02621590f, -0.09238930f, -0.04924599f, -0.06394742f, -0.05922711f, -0.00042745f, -0.11642866f, 
    0.23458758f, -0.00597995f, 0.17003006f, -0.01900930f, -0.00375472f, -0.00556405f, -0.01308579f, -0.08660925f, 
    -0.02957205f, 0.08635006f, -0.01296636f, -0.04644247f, -0.31780306f, -0.04255575f, -0.20607410f, -0.07880205f, 
    -0.03598766f, -0.06645950f, -0.03137740f, -0.01460198f, -0.10455105f, 0.07393268f, -0.03056357f, 0.01563055f, 
    0.11691573f, 0.13611414f, 0.01637352f, 0.24985792f, 0.10480265f, -0.01378826f, 0.03461225f, -0.06120406f, 
    -0.07941450f, 0.01142898f, 0.00909596f, -0.13043965f, 0.25277889f, -0.08232195f, 0.07761943f, -0.19601594f, 
    0.02559646f, -0.00654581f, -0.00470236f, -0.04563276f, -0.03719328f, 0.08104090f, -0.03172560f, 0.04549013f, 
    0.22531848f, 0.06674556f, -0.10572390f, -0.09592077f, -0.01673491f, -0.02847541f, -0.03586372f, -0.02418830f, 
    -0.01030083f, 0.05187532f, -0.02586077f, -0.03599707f, 0.03229792f, 0.05272687f, 0.10681252f, 0.11993384f, 
    0.05666465f, -0.05205769f, 0.06305212f, 0.03031276f, 0.03322988f, -0.01105944f, -0.03969419f, 0.02325968f, 
    -0.15817794f, -0.15328139f, 0.07162219f, -0.09219541f, -0.02102506f, -0.04308480f, 0.16001308f, 0.01155359f, 
    0.00664352f, 0.00451808f, -0.04488987f, 0.05253276f, 0.08870136f, 0.15612933f, -0.05919553f, 0.03807701f, 
    -0.04601844f, 0.00468852f, -0.13789225f, 0.06218169f, 0.07954533f, -0.03990348f, -0.06873120f, -0.11666581f, 
    0.07640619f, -0.08632313f, -0.01801067f, 0.08236680f, 0.14201598f, -0.05416463f, -0.05421841f, -0.03611325f, 
    -0.06722802f, 0.09884875f, -0.12899442f, -0.07221884f, -0.05155315f, 0.15596658f, -0.15858097f, -0.17997979f, 
    -0.03871180f, -0.06190955f, 0.07015393f, 0.00457178f, 0.09393962f, -0.08358191f, 0.06208568f, 0.12927356f, 
    0.14479139f, 0.14235966f, -0.27079701f, 0.01511214f, -0.01280412f, 0.02628910f, 0.07336160f, -0.00579446f, 
    -0.02951288f, -0.09267733f, -0.02908606f, 0.09084399f, -0.23876005f, 0.15385094f, -0.12914711f, 0.02497261f, 
    -0.09862868f, -0.08399229f, 0.02947254f, 0.00399162f, -0.02556085f, -0.00341230f, -0.02089342f, -0.00740622f, 
    -0.12165862f, -0.01876940f, -0.01673334f, 0.10561969f, 0.03715193f, 0.03728491f, -0.02419743f, -0.05496351f, 
    0.03821182f, 0.07679493f, 0.08072444f, 0.09013105f, 0.09334176f, 0.19853766f, -0.10242813f, 0.12910426f, 
    -0.04270199f, 0.08287206f, -0.11850003f, 0.01340590f, -0.01755683f, -0.01976784f, -0.04503550f, 0.02836084f, 
    -0.02202597f, 0.09069595f, 0.14861962f, 0.11253192f, -0.07247430f, 0.02386645f, -0.08019813f, 0.01621877f, 
    0.05545563f, -0.05277504f, -0.05193704f, 0.02828180f, 0.21503428f, -0.06732264f, 0.09806588f, -0.20077239f, 
    -0.00187621f, 0.04203943f, 0.06334438f, -0.01940871f, 0.03243474f, -0.06285679f, -0.09680305f, 0.03641323f, 
    -0.07806072f, 0.08752289f, -0.16746184f, -0.30226773f, -0.17561932f, 0.05843025f, 0.04216517f, -0.18381615f, 
    0.06892643f, 0.01791390f, -0.02032158f, -0.01779059f, 0.23784225f, 0.14759223f, -0.20698737f, -0.09022255f, 
    0.02896121f, -0.04391246f, -0.00271834f, -0.04305679f, 0.04787110f, 0.03174881f, 0.05851609f, 0.06476217f, 
    -0.06855524f, -0.05782759f, 0.14353797f, -0.02673319f, -0.16816533f, 0.02238990f, -0.07817712f, -0.03898690f, 
    0.02959603f, -0.00303431f, -0.07052302f, -0.01391068f, 0.19012119f, -0.02770655f, 0.08390860f, 0.07549292f, 
    -0.01754266f, -0.07015843f, 0.01336338f, 0.03081257f, 0.03281683f, -0.04819493f, -0.11544824f, -0.06941977f, 
    -0.09226118f, 0.14017157f, -0.10655855f, -0.00168500f, -0.07809007f, -0.01271420f, -0.14388974f, 0.05369126f, 
    -0.04795659f, 0.02640711f, 0.00006099f, 0.10132404f, 0.10767619f, -0.10489903f, -0.01108999f, 0.14007695f, 
    -0.04092705f, 0.01935717f, -0.10092892f, -0.08727196f, 0.09584782f, -0.02928416f, 0.02361070f, 0.00394842f, 
    -0.02701062f, 0.02485747f, 0.08777978f, 0.01932095f, 0.03118672f, -0.11736458f, -0.00054558f, -0.09657345f, 
    0.04738426f, -0.02154093f, -0.02778798f, 0.03181838f, -0.19109264f, -0.06173844f, 0.14505085f, -0.17278072f, 
    -0.10883985f, 0.00288015f, 0.00584321f, -0.00788752f, -0.05045745f, -0.08535822f, 0.02722713f, 0.01048314f, 
    0.11059727f, -0.18303056f, -0.01245171f, -0.03461953f, -0.09017515f, -0.09995054f, 0.04172954f, -0.08455891f, 
    0.02554618f, -0.06189987f, -0.24725887f, 0.07589703f, -0.10530079f, 0.08213700f, -0.18460694f, -0.23813941f, 
    0.07231346f, 0.05687012f, -0.10201529f, -0.05060835f, 0.07394720f, 0.01303462f, 0.04957477f, -0.03902747f, 
    -0.04895496f, 0.13166107f, -0.19410458f, 0.00732069f, 0.02597374f, -0.02675746f, -0.10816552f, -0.01750454f, 
    0.00732804f, -0.00863928f, 0.01711988f, 0.00761884f, -0.05017977f, 0.15811116f, 0.04683469f, -0.02691126f, 
    0.08667512f, 0.06792713f, -0.01709390f, 0.07550111f, 0.06103542f, 0.02933050f, -0.08155237f, -0.01954652f, 
    -0.07078408f, 0.08040043f, -0.10242703f, -0.11645050f, -0.05045787f, -0.08769505f, 0.01687987f, -0.01627364f, 
    -0.02903141f, 0.14529653f, -0.01147328f, 0.07456250f, 0.05662397f, -0.18369697f, -0.07251290f, 0.02452116f, 
    0.12287243f, -0.06357145f, -0.02102431f, 0.05334052f, -0.01221400f, -0.03200161f, -0.06493459f, -0.13978519f, 
    0.27271432f, -0.01580517f, -0.01058133f, 0.09150365f, 0.06391846f, -0.04398093f, 0.03381766f, -0.08423093f, 
    -0.04529756f, 0.05896059f, 0.05475960f, 0.10071322f, -0.08170606f, 0.00265764f, -0.09579765f, -0.18222868f, 
    -0.02175129f, -0.04576754f, 0.03010244f, 0.03127892f, 0.07282534f, 0.04462511f, -0.01180368f, -0.18007073f, 
    -0.22809041f, 0.04036930f, 0.02530081f, -0.27885485f, 0.04011135f, -0.10370477f, 0.02099900f, 0.12380864f, 
    0.04081452f, 0.03017374f, -0.14734329f, -0.18814944f, -0.13299045f, -0.02144873f, 0.19437174f, -0.11450525f, 
    0.04853749f, -0.02951419f, 0.04312430f, -0.00890578f, 0.00476886f, -0.08540841f, -0.11273751f, -0.02520658f, 
    -0.03984386f, 0.11928800f, -0.20847838f, -0.02763291f, 0.02710978f, -0.03373383f, -0.07011743f, -0.00160960f, 
    0.07512975f, -0.06974439f, 0.03813791f, 0.12566912f, -0.01463767f, -0.11328609f, -0.07467104f, -0.08535711f, 
    0.09283182f, -0.04229048f, -0.02247672f, -0.05719713f, 0.01471335f, 0.02964113f, 0.02329919f, 0.16086286f, 
    -0.14160985f, -0.04071177f, -0.14891282f, -0.21644180f, 0.00623137f, 0.08129615f, 0.04652784f, 0.00330159f, 
    0.05432657f, 0.04023444f, -0.10790668f, 0.08423439f, 0.18707879f, 0.10487101f, 0.10576438f, 0.08137991f, 
    0.07850503f, -0.00510267f, -0.10108872f, -0.04793933f, 0.00113596f, 0.01964240f, 0.06095088f, 0.00353256f, 
    0.14029995f, 0.11508234f, -0.06794013f, -0.07946081f, 0.00218153f, -0.03338227f, 0.02365215f, -0.05428765f, 
    -0.10890137f, 0.08107767f, -0.07390128f, -0.09507781f, -0.09860004f, 0.22297999f, -0.30186647f, -0.08612668f, 
    0.03711423f, -0.14483976f, -0.13708058f, -0.02694311f, 0.03586463f, 0.02704209f, 0.00791022f, 0.05721834f, 
    -0.19738780f, -0.09767146f, 0.09471291f, -0.08285725f, -0.15573758f, 0.06958114f, -0.12266061f, -0.05682324f, 
    -0.06905535f, -0.07483941f, -0.03106017f, -0.01329461f, 0.00731183f, 0.14498708f, -0.11061923f, 0.03127201f, 
    -0.05316007f, -0.00806938f, -0.02987162f, -0.05191409f, 0.00034281f, 0.02255531f, 0.00226396f, 0.05719211f, 
    0.16770898f, -0.32222006f, -0.14244324f, -0.03779738f, 0.11465552f, -0.16425902f, 0.05579516f, -0.11569908f, 
    0.05288993f, 0.00911656f, -0.03650337f, 0.01453988f, 0.04129969f, -0.25454408f, -0.10863405f, 0.15171224f, 
    0.04194501f, -0.01017758f, -0.07800868f, 0.02042883f, 0.19263674f, 0.01608597f, 0.07871573f, -0.13438138f, 
    -0.02798359f, -0.01160551f, -0.01139012f, 0.03715065f, 0.00743420f, -0.06051749f, -0.03010652f, 0.05176249f, 
    0.00458969f, 0.08482717f, 0.09910297f, -0.11146172f, 0.06591152f, -0.08377740f, 0.12409963f, 0.11161042f, 
    0.00797665f, 0.07254078f, 0.09572649f, -0.14866313f, 0.09042772f, -0.00139176f, 0.11146900f, -0.12378557f, 
    0.19874376f, 0.06671244f, -0.05473087f, 0.12180740f, -0.04235172f, -0.10625298f, -0.15610564f, -0.07524163f, 
    0.00032206f, 0.05058735f, -0.17626084f, -0.06811062f, 0.09095968f, -0.08888947f, 0.05467919f, 0.13682434f, 
    0.01810502f, -0.05198919f, 0.00505390f, -0.08004536f, 0.05072988f, 0.03652692f, 0.10740838f, -0.00340964f, 
    0.09826809f, 0.03671313f, -0.03685522f, 0.12687714f, 0.08595777f, -0.02705044f, -0.02407240f, -0.06408983f, 
    -0.13854942f, 0.00498594f, 0.00249679f, -0.03809731f, 0.13058528f, -0.04394295f, -0.03655833f, 0.07550691f, 
    0.01696004f, -0.03803995f, -0.02349200f, -0.04558586f, -0.05266430f, 0.01757999f, -0.04065950f, -0.05914751f, 
    -0.04142972f, 0.17200945f, 0.04558625f, 0.14916295f, -0.05290784f, -0.02728974f, 0.03974383f, -0.05321277f, 
    0.06405585f, 0.00884075f, 0.01266285f, 0.02366333f, 0.04335567f, 0.04965534f, 0.04789542f, 0.13356957f, 
    -0.01937701f, -0.01897931f, -0.03878778f, -0.03398893f, 0.05368624f, 0.01068856f, 0.09317482f, 0.04280687f, 
    0.07370036f, -0.11786105f, -0.05105818f, -0.04698879f, 0.09617338f, 0.00681492f, -0.10695980f, 0.02817801f, 
    0.00621642f, 0.12400054f, 0.03587066f, 0.08247163f, -0.17960097f, 0.21950836f, 0.16513032f, -0.05204825f, 
    -0.07235668f, -0.00301806f, -0.04101147f, -0.01341836f, 0.03432014f, 0.02291691f, 0.00155460f, 0.05596638f, 
    -0.16026175f, -0.10831181f, 0.03648877f, -0.01403570f, 0.08764314f, -0.01389774f, 0.02093613f, 0.02985009f, 
    0.07529435f, -0.03376529f, 0.07959978f, -0.01192683f, -0.16530149f, 0.00945853f, -0.15017529f, -0.02190334f, 
    -0.03959197f, -0.04703018f, 0.06340647f, -0.02666557f, -0.00077984f, 0.04360389f, 0.04541888f, 0.13337785f, 
    0.04016529f, -0.17492244f, -0.06173695f, -0.12687837f, -0.00204688f, -0.10743893f, -0.03285835f, 0.05496351f, 
    0.00830119f, -0.03456403f, -0.01705878f, 0.06249902f, 0.01858410f, 0.11599629f, -0.15595725f, 0.02357876f, 
    -0.03044984f, -0.07390353f, -0.07619618f, -0.03599906f, -0.00017000f, -0.12974606f, 0.07767112f, -0.02275408f, 
    0.07586302f, -0.04538319f, 0.07912137f, -0.03649405f, -0.10323383f, 0.02634365f, -0.11529092f, 0.06229168f, 
    0.10764180f, 0.06669287f, -0.01502733f, 0.03623130f, -0.04623248f, -0.14964534f, 0.09039680f, 0.28319588f, 
    0.03113583f, 0.00406302f, -0.02037557f, -0.03444779f, -0.09649312f, 0.00132577f, 0.06174433f, 0.06913920f, 
    -0.04865042f, -0.19244544f, -0.14451250f, 0.05756037f, 0.04177386f, -0.02179623f, -0.06746335f, 0.06726290f, 
    0.05113261f, 0.05506512f, 0.03204919f, -0.09418658f, -0.13115047f, 0.06465163f, -0.15818106f, -0.29699495f, 
    -0.04536495f, -0.04077581f, -0.10323015f, 0.08189625f, 0.08817537f, -0.03769835f, 0.08612783f, -0.08018513f, 
    0.16812196f, 0.09269234f, -0.18925111f, -0.01700333f, 0.00938262f, 0.03370699f, -0.06854265f, 0.01538004f, 
    -0.02270005f, 0.01530347f, 0.02471950f, 0.13111274f, -0.22042313f, -0.03297910f, -0.02185411f, -0.26837844f, 
    0.03486239f, -0.11174182f, -0.11179745f, 0.04832363f, -0.09605069f, 0.07247941f, 0.03598775f, -0.07251670f, 
    -0.08740171f, -0.05755344f, 0.15421426f, 0.03290074f, -0.11207009f, -0.02767898f, -0.07192834f, -0.08362912f, 
    -0.04817868f, -0.11793923f, 0.04286274f, 0.11311350f, -0.26089689f, -0.14365542f, 0.06863799f, 0.22717695f, 
    0.16245812f, 0.08667053f, 0.00079362f, -0.12828799f, -0.00949106f, 0.06194809f, 0.04604638f, 0.04097750f, 
    -0.10127759f, -0.09765647f, 0.10065459f, -0.25095710f, -0.08422375f, -0.07806291f, -0.01657947f, 0.05244637f, 
    0.00075432f, 0.11701543f, 0.09814762f, -0.01319392f, 0.14221455f, -0.20635320f, 0.06926284f, -0.02639697f, 
    0.04211680f, -0.10711297f, -0.00508010f, -0.13992819f, 0.07731558f, 0.04220681f, -0.12376665f, -0.01013184f, 
    -0.09307171f, 0.11440302f, -0.04926532f, 0.09335462f, -0.05270436f, -0.11179973f, -0.08821315f, 0.00619808f, 
    -0.01983970f, 0.05788007f, -0.08187422f, 0.05222149f, -0.08356621f, 0.08213206f, -0.05158372f, 0.04488546f, 
    0.06934281f, 0.00694043f, 0.06460767f, -0.00615514f, -0.00435593f, -0.05361819f, -0.01353282f, 0.05495403f, 
    0.07469266f, -0.04607950f, -0.05926437f, -0.11115059f, 0.00759213f, -0.00261373f, -0.09846298f, -0.07848681f, 
    0.04282987f, 0.07459720f, -0.13166548f, -0.08727697f, -0.21872792f, 0.25836116f, 0.27258009f, -0.02309606f, 
    -0.04998773f, 0.05989674f, 0.03456791f, 0.05066052f, 0.20455492f, 0.01295644f, 0.02267317f, 0.06544440f, 
    0.04781090f, 0.10248985f, 0.01749157f, -0.12486689f, 0.05567804f, 0.08069184f, 0.09262263f, -0.03883776f, 
    -0.02658987f, -0.01178453f, -0.04191856f, 0.01420684f, -0.02107269f, 0.12012181f, 0.08341529f, 0.22458427f, 
    0.03018085f, 0.06743283f, -0.06903354f, -0.04554062f, -0.08192168f, -0.04999296f, 0.03926769f, -0.00518194f, 
    0.21261385f, 0.01823135f, 0.14555907f, 0.04840200f, 0.11261438f, 0.03844882f, -0.10340204f, -0.04768371f, 
    -0.05473060f, 0.08599419f, 0.05288053f, 0.00307438f, -0.22781438f, 0.20033455f, -0.03725766f, 0.06251257f, 
    0.02109954f, 0.03561956f, 0.05538319f, -0.12471640f, 0.03664893f, 0.07153510f, 0.11362976f, 0.01501814f, 
    -0.00325916f, 0.18375942f, -0.24753019f, -0.35905108f, 0.08748192f, 0.01974322f, -0.05744233f, 0.12010100f, 
    -0.14511114f, -0.11890271f, 0.09712124f, -0.06252857f, 0.04711929f, 0.03157282f, 0.17226228f, -0.05753071f, 
    0.00018285f, -0.02576869f, 0.01225939f, 0.16326781f, 0.06518155f, 0.06210101f, -0.08390760f, 0.07499377f, 
    -0.11426346f, -0.41266459f, -0.01270616f, -0.05702794f, 0.11756631f, 0.04891169f, -0.02879467f, 0.10803580f, 
    -0.01470306f, 0.06659976f, -0.03410091f, -0.06517950f, 0.04384930f, -0.06958395f, 0.21202765f, 0.01329651f, 
    0.13873225f, 0.02962102f, -0.13800852f, -0.07088589f, -0.13888249f, 0.04848145f, 0.08229092f, 0.19399230f, 
    0.10767046f, -0.03757171f, -0.24711250f, 0.00727845f, -0.03321765f, -0.04019440f, 0.00256552f, 0.05987466f, 
    0.00148278f, -0.09101108f, -0.00934035f, 0.05541463f, 0.31522799f, 0.06715340f, 0.14103815f, 0.02428016f, 
    -0.08030818f, 0.06231872f, 0.08573606f, -0.02933472f, -0.10510532f, 0.04200308f, -0.00556180f, 0.09370801f, 
    -0.25005937f, -0.19579634f, -0.07549374f, -0.00913618f, -0.02224438f, 0.07477882f, -0.05259770f, -0.07050521f, 
    0.04335743f, 0.05831787f, -0.02350232f, -0.08260955f, -0.07280516f, 0.03297954f, -0.02140048f, 0.05332307f, 
    0.13210998f, -0.01393786f, -0.08329731f, 0.01431066f, -0.02929679f, 0.01904424f, 0.06385073f, 0.05332847f, 
    -0.01618877f, 0.03622004f, 0.05174040f, 0.04213531f, -0.06932810f, 0.03625688f, 0.08819640f, -0.04109583f, 
    0.02275016f, 0.05035685f, 0.08303446f, -0.11107710f, -0.07181591f, -0.22040568f, -0.01222541f, 0.06291689f, 
    0.04875599f, -0.09848930f, 0.10584883f, -0.05840246f, -0.00512426f, 0.03583116f, -0.02458358f, 0.03310866f, 
    0.42854741f, 0.04763323f, 0.12912625f, -0.02912336f, 0.02154064f, 0.05816040f, 0.14303291f, 0.06684285f, 
    0.16266827f, 0.00004582f, 0.07463188f, -0.05468079f, -0.05514039f, -0.01232707f, 0.09472782f, 0.07926028f, 
    -0.10490178f, 0.08491468f, -0.05159805f, -0.15869290f, -0.18992954f, 0.01608227f, -0.03557949f, -0.00841371f, 
    -0.04338095f, 0.05576075f, -0.04687560f, 0.11911730f, 0.08684983f, 0.06515860f, -0.15503436f, -0.04745827f, 
    0.06242980f, 0.00290237f, 0.09898677f, 0.06167877f, -0.16316637f, 0.03413765f, 0.16043505f, -0.09234970f, 
    -0.01492312f, -0.10713192f, -0.00456885f, 0.02612851f, 0.07517195f, -0.02226270f, -0.10754844f, 0.02598079f, 
    0.27528092f, -0.42966408f, -0.03504135f, -0.16475730f, -0.07228154f, -0.01643476f, -0.05996449f, 0.04146850f, 
    -0.15918167f, -0.08190463f, 0.11484551f, 0.04426282f, -0.32534558f, 0.04710518f, 0.05754558f, 0.00965147f, 
    0.06142644f, -0.08036732f, 0.04841237f, -0.22468859f, -0.05548893f, 0.06742530f, -0.06524630f, 0.10475678f, 
    -0.21764950f, 0.06192208f, -0.04420521f, -0.14535704f, 0.09412786f, -0.06828558f, 0.07714964f, -0.03446096f, 
    0.08038684f, 0.00190030f, 0.02354208f, -0.10249790f, 0.06659524f, 0.19133218f, 0.05964561f, -0.06549684f, 
    0.02732290f, -0.03071261f, 0.06551760f, -0.09393429f, -0.01435979f, 0.03295704f, 0.03525691f, -0.04400222f, 
    -0.18732095f, 0.04836092f, -0.33934245f, 0.10529479f, 0.11867118f, 0.01462411f, 0.00943738f, -0.05196140f, 
    0.03412962f, -0.00954515f, 0.04927793f, 0.00896688f, -0.44856924f, 0.21717943f, -0.03541822f, 0.15480778f, 
    -0.06809452f, 0.16877602f, -0.24772090f, 0.04274305f, -0.04534689f, -0.04661359f, 0.04264116f, 0.03886890f, 
    -0.22142830f, 0.06066176f, 0.03145721f, 0.05713733f, -0.08318782f, 0.00538764f, -0.03705455f, -0.04370089f, 
    0.03613710f, 0.06480052f, 0.02872231f, 0.05150396f, 0.01673393f, -0.08979826f, -0.01363091f, 0.14782327f, 
    -0.12777625f, 0.02089531f, -0.10565128f, 0.00237667f, -0.14560477f, 0.14636363f, -0.01934894f, -0.03029587f, 
    -0.12627339f, 0.02552957f, 0.00279785f, 0.06434821f, 0.01678114f, 0.03297048f, 0.12746544f, -0.01232247f, 
    -0.10501680f, 0.13111363f, 0.04002584f, -0.01751170f, 0.25282854f, -0.07515695f, -0.04342252f, 0.07822032f, 
    -0.05602830f, -0.05481963f, -0.02721506f, -0.01820362f, -0.04082948f, 0.02726065f, -0.04386827f, -0.01626203f, 
    -0.03402332f, 0.01141373f, -0.09749646f, 0.12794842f, 0.01304975f, 0.03062230f, 0.10967104f, -0.09699460f, 
    0.03392276f, 0.08399555f, -0.02930781f, -0.06024281f, -0.01214509f, 0.05700889f, -0.11990368f, -0.22267723f, 
    -0.02148539f, 0.06721317f, -0.03432266f, 0.05275580f, 0.02511741f, -0.01581752f, -0.17516363f, -0.00328438f, 
    0.40431571f, -0.13928537f, 0.05851393f, 0.07250215f, -0.03764102f, -0.04264647f, 0.01967182f, 0.02718350f, 
    -0.09273987f, 0.15349148f, 0.07248319f, 0.10979567f, -0.23544373f, 0.12744112f, 0.37822452f, -0.09977604f, 
    0.02916254f, 0.11312791f, 0.00304227f, -0.03972861f, -0.02189872f, -0.03353740f, 0.04422624f, -0.04260920f, 
    -0.04899456f, 0.02969519f, 0.04573258f, 0.08124539f, 0.00998808f, 0.04708499f, 0.06926907f, 0.03430811f, 
    -0.08002405f, -0.02960438f, -0.01691355f, 0.00060064f, -0.18150537f, 0.15716526f, 0.15908670f, 0.07246671f, 
    -0.09590979f, 0.14637762f, -0.08378108f, 0.09987791f, -0.00731119f, -0.01801639f, -0.07148019f, 0.01051260f, 
    -0.04563159f, 0.11462637f, 0.05531335f, -0.06310911f, 0.04935369f, 0.00357216f, -0.10741264f, -0.04658940f, 
    0.10338904f, -0.20595379f, 0.12122903f, -0.01215911f, -0.24691081f, 0.18466744f, -0.11343713f, -0.38165033f, 
    0.08848307f, 0.17522904f, -0.01788444f, -0.01261994f, -0.11227246f, -0.12283021f, -0.17513818f, -0.01533194f, 
    0.02503814f, -0.19500180f, 0.05993386f, -0.20829341f, -0.00618226f, -0.00609171f, -0.05094615f, -0.01460552f, 
    0.12109741f, -0.01411486f, 0.00075788f, -0.00446115f, -0.53157240f, 0.37470645f, -0.23560739f, 0.05817533f, 
    0.16492538f, -0.05419523f, -0.04206002f, 0.00633797f, -0.09476191f, 0.03100774f, -0.04565228f, -0.04821040f, 
    0.23585398f, -0.49899399f, -0.03165972f, -0.04620859f, 0.05639814f, 0.03353385f, -0.04342975f, -0.03226138f, 
    -0.07942925f, 0.07359359f, 0.16056181f, 0.06301575f, -0.37973574f, 0.31053761f, -0.09923464f, -0.17178409f, 
    0.14400706f, 0.12059632f, 0.06365161f, 0.08332901f, 0.04452575f, -0.09655230f, -0.13735433f, -0.01004864f, 
    0.00814788f, -0.04628090f, 0.10732155f, -0.04754207f, 0.10383356f, 0.10834850f, -0.13559802f, -0.02315049f, 
    0.05886865f, -0.01131560f, -0.00037691f, -0.11335299f, -0.05134190f, 0.04272765f, -0.05360503f, -0.12337478f, 
    0.13683951f, 0.12410200f, -0.09119140f, -0.22089030f, -0.03337280f, -0.05198500f, -0.07212517f, 0.12398174f, 
    0.22690631f, -0.66742611f, 0.06063689f, -0.01608835f, -0.07631531f, -0.06730430f, -0.14180519f, 0.20117533f, 
    -0.09561170f, -0.01583485f, 0.00673423f, -0.03302222f, -0.13287543f, 0.38301155f, -0.23346710f, -0.18170799f, 
    0.09347973f, -0.09055414f, 0.00788804f, -0.02541210f, -0.11900499f, 0.03619999f, -0.00308387f, -0.13268368f, 
    0.09139027f, -0.11377776f, 0.04253880f, -0.04727216f, -0.03796712f, -0.03200573f, 0.05544215f, -0.12845670f, 
    -0.03347299f, 0.07435292f, -0.03540612f, 0.14320786f, 0.24185762f, 0.21801049f, 0.14328313f, 0.07724883f, 
    0.05260058f, 0.01719200f, 0.02837635f, 0.11106855f, 0.10245758f, -0.07809917f, 0.05855443f, 0.12137880f, 
    -0.17654721f, 0.06100982f, 0.13719794f, -0.16371673f, -0.06351171f, -0.10174237f, -0.03645305f, -0.01373542f, 
    0.02219314f, 0.09895381f, 0.01452264f, -0.04952694f, -0.10647345f, -0.05986045f, 0.04313154f, -0.05268156f, 
    0.03165790f, 0.00988106f, -0.04645699f, 0.06109759f, 0.11471780f, 0.01482335f, -0.18872650f, -0.19319597f, 
    -0.18867747f, -0.16805415f, -0.00408542f, 0.08535583f, -0.04723496f, -0.04745074f, 0.13592383f, -0.05764936f, 
    0.01701890f, -0.02369508f, 0.08400676f, 0.03539152f, -0.43466064f, -0.23242432f, 0.28789049f, 0.00657319f, 
    -0.00506936f, -0.00910657f, -0.00278180f, 0.08464739f, -0.01956551f, -0.04279266f, -0.04281609f, 0.04972657f, 
    0.08811857f, -0.21153100f, 0.12426665f, -0.03365174f, 0.10141569f, -0.03151176f, 0.04798979f, -0.10294062f, 
    -0.10335959f, -0.12047311f, 0.00455011f, -0.06399475f, -0.38448068f, 0.06372061f, 0.13069172f, -0.17865583f, 
    0.02331267f, 0.06630493f, 0.05692291f, 0.01588472f, -0.06411333f, -0.04112303f, -0.10985576f, 0.00807956f, 
    -0.11322725f, 0.03814090f, -0.16263242f, -0.28958583f, 0.04199553f, -0.02117264f, -0.02992814f, 0.00572007f, 
    0.07309715f, 0.03266736f, 0.07797429f, -0.02755825f, -0.00889407f, -0.25714687f, 0.10907735f, -0.03919280f, 
    -0.09280623f, -0.10103937f, 0.01768341f, 0.05541094f, 0.01750036f, 0.03177336f, -0.09091835f, -0.05788368f, 
    0.12335319f, -0.19913696f, 0.08577947f, -0.23343797f, 0.02197388f, 0.04908633f, -0.03872529f, 0.12378319f, 
    -0.05501391f, 0.02791027f, 0.08347647f, -0.08657935f, -0.05723476f, -0.24969661f, -0.08771553f, 0.05251663f, 
    -0.05593594f, 0.01980337f, -0.10615124f, 0.09585361f, 0.06710427f, -0.02505369f, -0.07107144f, 0.10368853f, 
    0.04396134f, -0.10975529f, -0.07950673f, 0.07006481f, 0.00253389f, 0.00412974f, 0.04805527f, 0.07112287f, 
    -0.13715313f, 0.07556018f, -0.04483299f, -0.00994571f, 0.01672929f, 0.02902730f, -0.04064288f, -0.44051117f, 
    0.17666778f, 0.04977438f, -0.14155522f, -0.06382039f, -0.04372635f, -0.12787470f, 0.02738757f, -0.11776001f, 
    0.00305736f, -0.19201986f, -0.04226499f, -0.01537129f, 0.04136175f, -0.03635618f, -0.01735880f, -0.07341033f, 
    -0.03178924f, -0.15325299f, -0.09698893f, 0.04112430f, 0.19282971f, -0.06954623f, 0.05333984f, 0.11914223f, 
    0.07437710f, -0.05224172f, 0.05402564f, -0.01308300f, -0.04956108f, -0.02315489f, 0.10541302f, 0.00022535f, 
    0.04756787f, 0.04802123f, -0.11703774f, -0.03575414f, -0.11265784f, -0.05554663f, -0.07670218f, 0.13932160f, 
    0.02921544f, -0.00624380f, 0.13430415f, -0.02960161f, -0.02263536f, -0.20828253f, 0.11639833f, -0.00655314f, 
    0.06522463f, -0.06443499f, -0.07945219f, 0.05471680f, 0.09734694f, -0.05476555f, 0.14512701f, 0.00322283f, 
    0.13397308f, 0.13789213f, 0.08386081f, 0.18025768f, -0.03431752f, -0.05590539f, 0.09681790f, -0.00662393f, 
    0.14581299f, 0.07168641f, 0.16110434f, 0.17456700f, -0.15061402f, -0.16861954f, 0.01533817f, 0.02304755f, 
    -0.04242557f, 0.04617499f, 0.07509949f, -0.03685877f, 0.15737262f, -0.11397421f, -0.22649461f, -0.08573572f, 
    -0.42697018f, -0.22587737f, -0.12491274f, -0.09654813f, 0.16414037f, -0.06791668f, -0.07985435f, -0.01566389f, 
    -0.06843576f, -0.06321336f, -0.08855572f, 0.09119564f, 0.00320713f, -0.11994096f, -0.04426172f, 0.02508415f, 
    0.12873687f, 0.11549897f, 0.08472660f, -0.07309876f, 0.08274584f, -0.07365669f, 0.02949575f, -0.04722742f, 
    -0.26664209f, -0.12996034f, 0.01807272f, 0.10803637f, 0.13417171f, 0.01687806f, 0.01173383f, 0.04779393f, 
    0.02863820f, -0.00927065f, 0.02487086f, 0.17258993f, 0.13396971f, -0.06936229f, -0.01932123f, 0.06158710f, 
    0.02412196f, -0.08722223f, 0.04241035f, 0.08406688f, -0.04692955f, -0.02674259f, 0.01347778f, 0.06986385f, 
    -0.12037371f, 0.05135139f, -0.08392774f, -0.24768002f, 0.05120682f, 0.04091176f, -0.05049255f, 0.00489722f, 
    0.04218282f, 0.09198410f, 0.06955565f, 0.05860811f, -0.16511199f, -0.10946668f, -0.01605891f, 0.04336534f, 
    0.00718841f, 0.02886869f, 0.03963451f, -0.04137013f, 0.06917810f, -0.10763723f, -0.02381155f, 0.05483201f, 
    0.16292632f, 0.04622487f, 0.02831991f, 0.01216688f, -0.11389370f, 0.01461030f, 0.06601959f, -0.13206533f, 
    0.05859610f, -0.01724428f, -0.02243086f, 0.04809938f, -0.41583031f, 0.10742860f, -0.10724767f, -0.02438703f, 
    0.00857729f, 0.14469865f, 0.01742514f, -0.03748187f, -0.01187650f, 0.01021718f, -0.02812519f, 0.00297804f, 
    0.13636702f, -0.04215957f, 0.03637413f, 0.00076847f, -0.04073557f, 0.01112959f, 0.04901440f, -0.09784196f, 
    0.02699616f, -0.04746309f, -0.00309579f, -0.07935091f, -0.47682995f, -0.07801770f, 0.08586559f, 0.25665456f, 
    0.20317464f, 0.00663035f, 0.04388234f, 0.07360480f, 0.06579062f, 0.07232907f, 0.01935134f, 0.10743739f, 
    0.22998531f, 0.16673586f, -0.15798908f, 0.01843189f, -0.18087931f, -0.14388566f, -0.06634807f, -0.04146655f, 
    -0.03205251f, -0.07145186f, -0.02100653f, -0.04284322f, 0.31723234f, 0.06190256f, -0.21481998f, 0.04621121f, 
    -0.09413926f, -0.04613012f, -0.02111337f, 0.05536995f, -0.01331451f, -0.00415977f, 0.01471631f, -0.07045542f, 
    0.08716120f, -0.07748204f, 0.08183648f, -0.06913722f, 0.10575153f, 0.02161725f, -0.07245702f, 0.06052241f, 
    0.05218839f, 0.08714483f, 0.07498130f, 0.11960842f, 0.02917376f, -0.01948372f, -0.07792605f, -0.04770974f, 
    0.07035434f, 0.07908279f, -0.18674868f, 0.05116506f, 0.01461121f, 0.03285611f, -0.08218582f, -0.01973284f, 
    -0.27871317f, -0.09738591f, 0.07140309f, -0.03572372f, 0.06772087f, -0.01648903f, -0.01554368f, -0.09802791f, 
    0.05114227f, -0.01617449f, -0.01881310f, -0.01191253f, -0.02518107f, 0.04427173f, 0.07536784f, -0.04985466f, 
    0.12463191f, 0.15548941f, -0.01585729f, -0.05231500f, 0.03158826f, 0.00244550f, 0.03674843f, 0.04687747f, 
    0.22759525f, 0.08261313f, -0.12777765f, 0.04099138f, -0.01081198f, -0.08225448f, 0.01395736f, -0.00285197f, 
    0.07962265f, 0.06652650f, -0.11694452f, 0.09536126f, -0.25255516f, -0.17033541f, 0.03286340f, -0.06824061f, 
    0.05757732f, 0.05801470f, -0.16598976f, -0.14101702f, 0.05772491f, -0.02216453f, -0.12406697f, -0.05727249f, 
    -0.32677367f, 0.06671494f, -0.11514536f, 0.04307060f, 0.06826645f, 0.06354854f, -0.03600621f, -0.05509448f, 
    0.03877586f, 0.02600733f, -0.02781122f, -0.09635605f, -0.15086129f, -0.18605293f, 0.07146922f, 0.17651349f, 
    0.06348815f, 0.05075976f, 0.02378338f, 0.08781276f, 0.01875579f, 0.01964607f, 0.14557649f, 0.02349768f, 
    0.12097485f, 0.02262331f, -0.10969415f, -0.08235322f, 0.04559882f, -0.00379316f, 0.02642420f, 0.11003394f, 
    -0.07077214f, 0.11169302f, -0.05383736f, 0.11491957f, -0.35489684f, -0.02372689f, -0.05196810f, -0.12441717f, 
    0.05853721f, -0.03199222f, -0.04068415f, -0.02979568f, -0.04777341f, -0.05940929f, -0.00355745f, 0.00824802f, 
    -0.30045390f, -0.25810236f, -0.22246785f, -0.09209060f, 0.00035459f, 0.02543851f, 0.04717239f, -0.04270873f, 
    0.01085139f, 0.04197167f, 0.01482238f, -0.02166653f, -0.12684523f, -0.11177015f, 0.05355535f, 0.13645852f, 
    -0.10768651f, 0.05831768f, 0.02734233f, 0.06816764f, 0.06552762f, 0.00818323f, -0.05538582f, -0.15272427f, 
    0.07440236f, -0.08960868f, 0.06468001f, 0.05887818f, -0.04120815f, 0.00457712f, -0.01206122f, -0.02417223f, 
    -0.02110380f, 0.09927500f, 0.02867922f, 0.08638906f, 0.33616045f, -0.03542679f, 0.02469169f, -0.12560785f, 
    -0.12536040f, 0.05671733f, -0.01784754f, -0.10027025f, 0.00099860f, -0.01420005f, -0.12266885f, -0.14099148f, 
    -0.14376880f, -0.03625311f, -0.11666331f, -0.05111406f, 0.04807680f, 0.06922095f, 0.00410459f, -0.01394686f, 
    0.06193259f, -0.13764453f, 0.05571966f, -0.09756761f, -0.06485681f, -0.04648310f, 0.05647371f, 0.01006887f, 
    0.06860810f, 0.10624713f, 0.06013931f, 0.00713414f, 0.04629927f, -0.14151578f, -0.21344702f, 0.03116477f, 
    0.37287322f, 0.24200533f, 0.00005615f, -0.11172204f, 0.07848336f, -0.07081531f, 0.07525988f, 0.00150280f, 
    0.01153184f, -0.06147011f, -0.10729856f, 0.01315867f, -0.34884727f, -0.02102017f, -0.19110864f, -0.34424555f, 
    0.12110969f, -0.01153745f, -0.09633054f, 0.03702073f, -0.03403901f, -0.03323097f, 0.06576867f, 0.00713629f, 
    -0.03394517f, 0.09397791f, -0.13474080f, -0.01975517f, -0.09203535f, 0.01222382f, 0.05358500f, 0.00777745f, 
    0.10393778f, -0.11368854f, -0.13967101f, -0.16895594f, -0.22139479f, -0.27514812f, 0.10696225f, 0.00386808f, 
    0.02515945f, -0.00397687f, -0.09034283f, 0.03517684f, 0.03926210f, -0.04442639f, -0.06559328f, 0.00380814f, 
    0.16599895f, 0.02935050f, 0.07051668f, -0.09007365f, -0.11824816f, -0.04830207f, -0.14864707f, -0.02263524f, 
    0.06143721f, -0.05009900f, -0.04915166f, -0.02328945f, -0.01907771f, -0.01369999f, -0.09509828f, 0.04242038f, 
    0.07298639f, 0.08787947f, 0.04388093f, -0.01155179f, 0.05544646f, 0.08734307f, 0.02888155f, 0.08741678f, 
    -0.23734924f, 0.11729785f, 0.21356316f, 0.09378821f, 0.08776620f, -0.09397767f, 0.04579121f, -0.09424695f, 
    -0.07139785f, 0.12791187f, 0.04287446f, 0.12715112f, -0.58986825f, -0.31861338f, -0.18173096f, -0.23986658f, 
    0.12454382f, -0.13779354f, -0.10385253f, -0.03124022f, 0.02369259f, -0.06360947f, 0.07600363f, -0.11158760f, 
    -0.05410492f, 0.26180601f, -0.12232389f, -0.14353387f, 0.00813068f, -0.02059333f, -0.04278482f, 0.12353767f, 
    -0.00493123f, 0.02008299f, 0.15566656f, 0.08499593f, -0.32237002f, -0.26196766f, 0.08731938f, -0.11499520f, 
    -0.05487318f, 0.05997081f, -0.03235109f, -0.07239472f, -0.01682347f, 0.00829571f, -0.01193288f, -0.06825505f, 
    -0.14481868f, 0.15828308f, -0.10382332f, -0.00668368f, 0.03012288f, 0.00308560f, -0.09993824f, 0.02756901f, 
    0.04192538f, 0.04179158f, -0.15139215f, 0.01673248f, -0.23902538f, -0.17208159f, -0.05478920f, -0.02874274f, 
    -0.02985132f, -0.05379467f, 0.00286258f, 0.06548486f, -0.02442881f, 0.10653432f, 0.17865619f, 0.02422003f, 
    -0.36437732f, -0.23594573f, -0.10954966f, -0.04535468f, 0.09689524f, -0.02256809f, -0.14813094f, -0.11526048f, 
    -0.05341152f, -0.08539376f, 0.06555401f, 0.03413576f, -0.20714222f, 0.06132667f, -0.01733538f, -0.14284879f, 
    0.05370757f, 0.00624095f, -0.05513161f, 0.03428751f, 0.05013625f, 0.01761181f, -0.03588633f, 0.04016023f, 
    0.10353854f, -0.06555008f, 0.02897041f, -0.01173804f, -0.03959608f, 0.04109170f, 0.02504992f, -0.03812497f, 
    0.00758717f, 0.09700415f, 0.07710309f, 0.01919664f, -0.39117822f, -0.01711805f, -0.06232540f, -0.18846029f, 
    0.00538955f, 0.00618246f, 0.01228758f, 0.06763220f, 0.04508166f, 0.09673449f, 0.13937192f, 0.08954339f, 
    -0.14830871f, -0.16557403f, -0.02225565f, -0.18512142f, -0.07350282f, 0.01812364f, -0.02325864f, 0.00756554f, 
    -0.02960120f, -0.06015740f, -0.06214733f, 0.04089564f, -0.01648692f, 0.03138544f, 0.15224250f, -0.05283149f, 
    0.01741790f, -0.00243374f, 0.09775487f, 0.02804270f, 0.00529385f, 0.05981901f, -0.04588630f, 0.00885643f, 
    0.12665634f, 0.01318602f, 0.20873381f, -0.12643996f, 0.11406430f, -0.00959120f, -0.02985122f, 0.02787641f, 
    -0.01865243f, -0.00460642f, -0.02577400f, -0.01739293f, 0.21180621f, -0.00128329f, 0.07284097f, -0.09166900f, 
    -0.00595070f, 0.11414430f, 0.00845108f, 0.03064702f, 0.07319475f, -0.02121505f, 0.01519532f, 0.03349312f, 
    -0.09949654f, -0.08872151f, 0.02787610f, 0.16681394f, 0.00297000f, 0.04932069f, -0.17936875f, -0.05922063f, 
    -0.08960032f, -0.03785970f, -0.11040337f, -0.07341467f, -0.01079802f, 0.01375419f, 0.02312876f, 0.00028954f, 
    -0.11258946f, 0.04238056f, 0.02151941f, 0.08152219f, -0.03628747f, -0.02828397f, 0.06909704f, -0.05224163f, 
    0.09768273f, 0.29958120f, 0.03352496f, 0.02096705f, 0.04585335f, -0.03737766f, -0.01999842f, 0.05633126f, 
    -0.02291779f, 0.15190592f, 0.10860473f, 0.12402907f, -0.26254177f, -0.36141086f, 0.00278203f, 0.02348312f, 
    0.09096435f, -0.04024469f, 0.04660533f, 0.03276640f, 0.04078508f, 0.05232847f, -0.02818039f, 0.10815890f, 
    0.10778448f, 0.16195227f, -0.05521580f, -0.03636931f, 0.08504091f, -0.03620269f, -0.04808864f, 0.07160942f, 
    0.07111911f, 0.01593919f, 0.07219316f, -0.05601135f, 0.10729592f, 0.18286936f, 0.15493149f, 0.10169272f, 
    0.03690883f, 0.04445067f, 0.02153652f, 0.09499216f, -0.04941328f, 0.00681221f, 0.12334048f, 0.05740316f, 
    -0.18322718f, 0.06663341f, 0.08508208f, -0.09579124f, 0.07192526f, 0.05133095f, -0.01793689f, -0.01472481f, 
    0.00260529f, 0.05668801f, -0.10294841f, 0.11559102f, 0.04624009f, 0.00505917f, -0.01013285f, -0.11934860f, 
    0.02931163f, 0.02661769f, 0.10001255f, 0.00862515f, -0.01866482f, 0.16366018f, -0.01467860f, 0.01996878f, 
    0.07500032f, 0.17629571f, 0.12577979f, -0.08624087f, -0.01522187f, 0.11949652f, 0.03220075f, 0.03500942f, 
    0.07112003f, -0.09248495f, 0.04756288f, 0.03184732f, -0.29567599f, -0.20742567f, -0.06718428f, -0.23632754f, 
    0.11115668f, 0.06427246f, 0.04295941f, 0.03679957f, 0.09469293f, 0.14967446f, -0.06626678f, 0.08263546f, 
    0.05892676f, -0.03744521f, -0.11485149f, 0.01967037f, 0.06819462f, 0.16100536f, -0.03619267f, -0.09978004f, 
    -0.00951123f, 0.09030499f, 0.06717461f, -0.04390070f, -0.30391309f, -0.05506999f, -0.11430252f, 0.10780679f, 
    0.02283834f, 0.06265205f, -0.04212888f, -0.04909030f, -0.05097017f, 0.07477774f, 0.05314478f, 0.00744256f, 
    -0.13709602f, -0.14855273f, 0.06027856f, -0.15364616f, 0.08152191f, -0.03617668f, 0.00694261f, 0.02328569f, 
    0.02766676f, 0.04617244f, -0.07506199f, -0.00632783f, -0.00356080f, 0.06919315f, -0.06061756f, -0.05336615f, 
    -0.08969738f, -0.02360128f, -0.04348942f, -0.06928078f, 0.01988739f, 0.00527549f, 0.04501781f, -0.08444879f, 
    0.04235037f, -0.03173597f, 0.01981025f, 0.05148490f, -0.06195126f, -0.06907655f, -0.04254254f, -0.03483563f, 
    -0.07397829f, -0.06748434f, 0.00489783f, -0.06228788f, -0.33759797f, 0.06627899f, -0.00484672f, 0.02651277f, 
    0.04535334f, 0.00144803f, -0.05725851f, 0.08645735f, -0.03885693f, 0.03747200f, 0.03436337f, -0.00912592f, 
    0.25460839f, -0.11051821f, -0.04333219f, -0.35310432f, 0.02397912f, 0.02168960f, -0.02119602f, 0.11501907f, 
    0.03995799f, -0.00692512f, 0.13911094f, 0.08563271f, 0.20965594f, -0.00828222f, -0.17969628f, -0.04284586f, 
    -0.01762569f, -0.19807087f, -0.02426553f, -0.00305104f, -0.02424636f, 0.08213756f, 0.03577973f, 0.00688582f, 
    0.48831502f, 0.12485912f, -0.08668157f, 0.08601046f, -0.05448623f, 0.03564181f, 0.09212850f, -0.10741355f, 
    0.02479708f, 0.10093121f, 0.04599863f, -0.07881694f, 0.01759014f, 0.08023004f, -0.13629727f, 0.10692211f, 
    0.15365738f, -0.02812020f, -0.00258020f, -0.00708671f, 0.06322587f, 0.04988454f, -0.00189141f, -0.03844572f, 
    0.28673968f, -0.21186610f, -0.08472522f, 0.12041033f, -0.05513978f, -0.10468529f, -0.07431678f, -0.03797288f, 
    0.02504522f, 0.02344494f, -0.02871202f, -0.05203766f, -0.06421178f, 0.08354612f, -0.01099037f, -0.01103960f, 
    -0.02856883f, 0.00192050f, 0.03141169f, 0.00839863f, 0.00588466f, 0.05503665f, -0.00375624f, -0.06817909f, 
    0.06916149f, 0.06268696f, 0.04030591f, 0.01543485f, -0.01975186f, -0.09761296f, 0.01351512f, -0.00728724f, 
    -0.01335114f, -0.00842993f, -0.01813095f, -0.16278902f, -0.01671657f, -0.07665750f, 0.09619140f, 0.10795873f, 
    -0.14402902f, 0.06147483f, -0.00036128f, 0.01414686f, 0.00341215f, 0.08660968f, 0.04066320f, -0.00347531f, 
    0.03120460f, -0.11797856f, -0.09371326f, 0.05191157f, -0.00147243f, 0.01521245f, 0.07077020f, -0.00384113f, 
    -0.15062225f, 0.03807748f, 0.02291072f, 0.01395584f, 0.41677168f, -0.06045290f, -0.01978554f, -0.03178789f, 
    -0.00662163f, -0.08609323f, -0.16902786f, 0.08611099f, 0.00059992f, 0.06403576f, 0.04335061f, 0.04983511f, 
    0.16831478f, -0.02142852f, -0.09124153f, -0.02458189f, -0.02504426f, 0.10482267f, 0.07086366f, -0.08476046f, 
    -0.09982678f, -0.09241118f, -0.03473938f, -0.00301538f, -0.06766468f, -0.15822281f, 0.00355089f, -0.15330824f, 
    -0.02487012f, -0.00135290f, 0.07734676f, 0.01151001f, -0.09446831f, -0.06305192f, -0.02630533f, 0.10976685f, 
    0.10845935f, 0.03162352f, -0.04772013f, 0.24463853f, 0.15968701f, 0.02700770f, -0.01441708f, 0.00536413f, 
    0.00261805f, 0.05526018f, -0.09002768f, -0.05847153f, -0.29018274f, -0.11060988f, 0.00929872f, -0.20138758f, 
    -0.08319086f, 0.12746580f, 0.06768468f, 0.11329472f, 0.01781810f, 0.05003487f, -0.11615486f, 0.04864211f, 
    -0.10149038f, 0.04574173f, -0.06494337f, -0.22995868f, 0.08605838f, -0.07632571f, -0.10225955f, 0.10315830f, 
    -0.03349644f, -0.00452190f, 0.04657476f, 0.01732659f, 0.10506563f, 0.13802697f, 0.04615519f, -0.14718573f, 
    -0.14416775f, -0.10366910f, 0.00654585f, -0.04880616f, -0.17920329f, 0.09569554f, -0.01886947f, -0.24269520f, 
    -0.17796443f, -0.14295413f, -0.00655723f, -0.11787727f, -0.03592908f, 0.00066549f, -0.02597219f, 0.14572586f, 
    -0.14529559f, 0.03822655f, -0.08804237f, -0.11000890f, -0.04733035f, 0.12525101f, -0.02270552f, 0.21239839f, 
    0.05072005f, 0.00875088f, 0.01739757f, -0.01572651f, -0.03688268f, 0.05157972f, -0.00556058f, 0.01852915f, 
    -0.04362559f, -0.02967444f, -0.06488923f, 0.22482656f, -0.09643299f, 0.02383431f, -0.06140416f, 0.03681174f, 
    0.00318185f, -0.03490419f, 0.14554583f, 0.16887712f, 0.11002316f, 0.09535836f, 0.02560561f, 0.05175801f, 
    0.11252905f, -0.07553073f, 0.10075007f, -0.02498762f, 0.09000201f, 0.00750968f, 0.09097596f, -0.05550244f, 
    -0.37751102f, 0.16174163f, -0.13849048f, -0.04148766f, 0.13773867f, -0.04614859f, 0.01951419f, 0.00075273f, 
    -0.05885571f, -0.05676628f, 0.01370601f, -0.02845371f, 0.45323449f, 0.03193269f, -0.15170185f, -0.28604582f, 
    0.04363990f, 0.00842545f, -0.02882536f, -0.10103638f, 0.06318276f, 0.09220418f, 0.00725343f, 0.04550761f, 
    -0.43306646f, -0.01095373f, -0.16533537f, -0.02818844f, 0.12526125f, 0.03972156f, 0.04411545f, 0.05242182f, 
    -0.01479919f, -0.09003702f, -0.07227155f, -0.04429576f, 0.03139121f, 0.08914757f, -0.14667642f, 0.14181200f, 
    0.02478980f, -0.00430826f, 0.01067176f, -0.01814108f, 0.00323456f, 0.04330721f, 0.00792569f, 0.04136089f, 
    -0.00384483f, 0.01521164f, 0.05384168f, 0.04852943f, 0.02787000f, 0.01725660f, -0.09605204f, -0.10367959f, 
    0.08236048f, -0.06538607f, 0.06031710f, 0.03244791f, -0.16541006f, 0.28071201f, 0.00744903f, -0.03024717f, 
    0.01075570f, -0.16018651f, -0.06305766f, -0.02515335f, 0.08116015f, 0.07983214f, 0.12347918f, -0.10889708f, 
    -0.21114469f, 0.13787702f, -0.11894112f, 0.03750035f, 0.05674952f, -0.08805858f, 0.10560994f, -0.01615252f, 
    0.00656630f, 0.05685652f, 0.02189370f, 0.07272467f, -0.22661430f, 0.13464583f, -0.00419295f, -0.14935082f, 
    0.01117800f, -0.07540085f, -0.09133775f, 0.05234748f, -0.10833611f, 0.17454429f, 0.09892206f, -0.05736371f, 
    0.13726330f, -0.18573424f, -0.16897929f, 0.13350776f, 0.02696436f, -0.06726388f, 0.10277210f, -0.00143419f, 
    0.09808326f, -0.08422399f, 0.03517695f, -0.07696847f, -0.05530705f, -0.15747079f, -0.10936137f, -0.03018202f, 
    -0.04904019f, 0.02538092f, -0.01067279f, -0.03465608f, -0.12693101f, -0.00655430f, -0.02094667f, -0.02172583f, 
    -0.31692848f, -0.00672796f, 0.04794962f, -0.01854738f, -0.00367928f, 0.01631630f, -0.07666384f, 0.08638121f, 
    0.02577451f, -0.07112764f, 0.09372983f, -0.02849139f, 0.15187925f, 0.04463195f, -0.11742721f, 0.08438900f, 
    0.02252972f, 0.09515897f, -0.09452181f, -0.09804478f, 0.05302297f, 0.08268549f, 0.03790135f, 0.02320977f, 
    -0.06125217f, 0.05264730f, 0.01280825f, -0.00200246f, -0.17655014f, -0.00975190f, -0.04100641f, -0.19775559f, 
    -0.09856747f, -0.01667666f, 0.06160606f, -0.14690529f, 0.20501484f, 0.00670493f, -0.02950941f, 0.09861089f, 
    0.06257693f, -0.09970708f, -0.14217213f, 0.00624364f, -0.01194426f, 0.00717782f, -0.08716334f, 0.04160488f, 
    0.45266315f, -0.07506701f, 0.03819556f, -0.04845506f, 0.11562264f, -0.02737438f, -0.04580318f, 0.04888263f, 
    -0.01368395f, -0.02346745f, -0.01733854f, 0.04851538f, 0.13866174f, -0.18675306f, -0.04242669f, 0.12319858f, 
    -0.02254577f, -0.01027693f, 0.06087368f, -0.04810911f, 0.08688593f, -0.06275538f, -0.01537692f, 0.06261186f, 
    0.02444763f, 0.04608278f, -0.12592810f, 0.02768615f, -0.00759126f, 0.06628814f, 0.01137847f, 0.11803591f, 
    -0.10839564f, -0.02668780f, -0.03004281f, -0.00516075f, -0.17013255f, -0.15926248f, -0.02378164f, 0.02562926f, 
    0.16309033f, 0.04751941f, -0.05315886f, -0.12105330f, -0.01522414f, -0.01970830f, -0.11478730f, -0.03337153f, 
    -0.40874332f, 0.00043230f, -0.26101652f, 0.10181335f, 0.02992865f, 0.02402018f, 0.10254692f, 0.12595548f, 
    0.07533889f, -0.03826970f, 0.12125223f, -0.07434330f, 0.12827680f, -0.12866445f, -0.01673442f, 0.00854257f, 
    0.08734491f, 0.05425372f, 0.05935043f, -0.05877509f, -0.04642520f, -0.02054229f, -0.03311158f, -0.04685540f, 
    -0.04312351f, -0.07084890f, -0.23179454f, -0.08957868f, 0.01087516f, 0.00401066f, 0.03535527f, -0.02251364f, 
    0.06014425f, -0.01040454f, -0.02883118f, -0.05511037f, 0.09746720f, -0.26464400f, -0.06671268f, -0.14155012f, 
    -0.09417174f, -0.05929955f, 0.00807043f, -0.04499023f, -0.01426254f, 0.02905761f, 0.01306471f, -0.02863762f, 
    -0.02565498f, 0.10756519f, 0.00664805f, -0.01312849f, -0.01548005f, 0.00808006f, 0.03833458f, -0.00656756f, 
    -0.03414734f, 0.02377182f, 0.04084814f, -0.14972207f, 0.17897481f, -0.18339144f, -0.05997958f, 0.25068140f, 
    -0.01617702f, 0.03910682f, -0.05177421f, -0.05192432f, -0.05916056f, -0.01949350f, -0.14815736f, -0.05660170f, 
    -0.07150759f, 0.02476682f, 0.05893967f, -0.02119886f, 0.03250773f, -0.04979424f, -0.00124410f, 0.09035538f, 
    0.01819977f, 0.04543917f, -0.05509495f, -0.07175754f, 0.11968650f, -0.22457793f, -0.06698004f, 0.02794382f, 
    -0.01640451f, -0.03646714f, -0.07018865f, 0.02433637f, -0.08580738f, 0.00529106f, 0.08088168f, -0.03474642f, 
    0.36428136f, 0.11956296f, -0.12893000f, -0.20052059f, 0.03164041f, 0.02465289f, -0.01297509f, 0.05586173f, 
    0.07049407f, 0.09086078f, 0.04683952f, 0.05440530f, 0.06550945f, 0.13869159f, -0.22303922f, 0.08683681f, 
    0.02283878f, 0.03978444f, -0.02887316f, 0.05606902f, -0.12594920f, -0.09090646f, 0.05468014f, -0.01895704f, 
    -0.09285283f, 0.19375636f, -0.07485975f, 0.06460444f, 0.01451381f, -0.05226873f, -0.00507769f, -0.07210808f, 
    0.02007604f, 0.03497489f, 0.00379406f, 0.09914075f, -0.01069664f, -0.02349108f, -0.06368522f, 0.03149712f, 
    -0.11759787f, 0.01801241f, -0.11888792f, -0.11548781f, -0.01299677f, 0.01111292f, -0.03640772f, -0.08823267f, 
    -0.11513185f, 0.30928105f, -0.05575194f, 0.03946109f, -0.13185631f, 0.22245459f, 0.04452487f, -0.04988096f, 
    0.05083640f, -0.02974351f, -0.17066796f, -0.05783381f, 0.09432619f, -0.04785404f, 0.03415446f, -0.22443554f, 
    0.02134236f, -0.02182281f, 0.00449389f, 0.03203804f, -0.01847929f, -0.01659152f, 0.04753919f, -0.02505461f, 
    0.08986748f, -0.14654192f, -0.05819393f, 0.21360831f, 0.01278407f, 0.01118306f, 0.06240466f, -0.08833055f, 
    0.10090135f, -0.05564231f, 0.09083239f, 0.10411271f, 0.08736331f, 0.13446036f, -0.09236838f, -0.05340297f, 
    -0.00999381f, 0.03853453f, 0.02701556f, -0.11444730f, 0.06279904f, -0.02255773f, -0.01700055f, -0.06742173f, 
    0.12836190f, -0.16149935f, 0.03086517f, 0.23524897f, -0.01143268f, 0.01289875f, 0.03804853f, 0.10044365f, 
    0.01561595f, -0.07462506f, 0.05663390f, 0.04850100f, 0.05161162f, 0.09473444f, 0.00546867f, 0.19720510f, 
    -0.00146628f, -0.02155605f, -0.06648441f, 0.06171324f, -0.03318881f, -0.18515591f, 0.00000930f, 0.02590480f, 
    -0.21261421f, 0.27376780f, -0.13833643f, 0.03978094f, -0.13638471f, -0.06936272f, 0.01843458f, -0.05915417f, 
    -0.03067683f, 0.05999576f, 0.02228259f, -0.06987672f, 0.28287029f, -0.07687382f, -0.16879718f, -0.04541980f, 
    0.00426628f, -0.08115626f, -0.04810639f, 0.05689053f, -0.02422572f, 0.04097533f, 0.02047575f, 0.01159616f, 
    0.03009766f, -0.11077994f, -0.11815003f, -0.03950062f, -0.20875199f, 0.05160013f, -0.07344701f, 0.04582128f, 
    0.07774533f, -0.05604806f, -0.02555901f, -0.03696325f, -0.31293461f, 0.20963456f, -0.01575395f, -0.06689620f, 
    -0.02802259f, -0.08915105f, -0.11002760f, -0.02073671f, -0.04923815f, 0.00727219f, -0.05874237f, -0.06418922f, 
    0.03373634f, 0.01253721f, -0.04175869f, 0.08180025f, 0.05519457f, 0.03850375f, -0.04141176f, 0.06080948f, 
    -0.07841337f, -0.04323312f, -0.05516362f, -0.04952551f, -0.09146605f, -0.01964331f, -0.12019639f, 0.07722565f, 
    0.10878362f, 0.08723302f, -0.12367345f, -0.03348856f, -0.07295906f, 0.00263234f, -0.10484315f, 0.05675633f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01115135f, 0.01862342f, -0.04985993f, 0.00962898f, -0.01955016f, -0.02492115f, -0.02174993f, -0.02905322f, 
    -0.04662908f, 0.03643235f, 0.09630143f, 0.03442498f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
