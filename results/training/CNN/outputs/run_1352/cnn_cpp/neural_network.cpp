#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.72403884f, -0.38440087f, -0.67232889f, 0.33454353f, 0.58017278f, 0.17657799f, 0.44176105f, 0.35450438f, 
    -0.47750551f, -0.51612526f, -0.44223040f, -0.35103536f, 0.41349000f, -0.16172570f, 0.01639263f, -0.04334768f, 
    0.10247996f, 0.36159623f, 0.17185239f, 0.07147832f, 0.12895702f, -0.27807501f, -0.42602530f, -0.31523246f, 
    -0.07613839f, -0.02643165f, 0.38032702f, 0.12715915f, -0.17842881f, 0.13415311f, 0.05232068f, 0.31548220f, 
    0.11231274f, 0.21720552f, 0.35978496f, 0.20378736f, 0.33254972f, -0.00611307f, -0.43586856f, -0.04569009f, 
    0.15298140f, -0.18293399f, -0.20711254f, -0.05742328f, 0.06226715f, 0.37177706f, 0.11280891f, 0.00096076f, 
    -0.25417158f, -0.00302412f, -0.48523411f, -0.30415604f, 0.24102856f, 0.70148569f, 0.27180240f, 0.42017296f, 
    0.00353129f, 0.50303727f, 0.10610079f, -0.31031340f, -0.02425589f, 0.54794478f, 0.07726146f, -0.32322943f, 
    -0.18695678f, -0.13719173f, -0.01406184f, -0.11879105f, -0.62599391f, -0.10797608f, -0.07963727f, 0.57760072f, 
    -0.13298449f, -0.02186340f, 0.20271322f, -0.88719910f, -0.22592087f, -0.49181482f, -0.26953897f, -0.05757865f, 
    -0.46650410f, -0.19990765f, -0.69407523f, -1.07375789f, -0.82946002f, -0.32478246f, 0.21144345f, -0.26957384f, 
    -0.33485493f, -0.56448931f, -0.11090935f, -0.54265088f, -0.15444137f, -0.14642030f, -0.44313672f, -0.18270934f, 
    0.18294485f, -0.12323528f, 0.18705659f, -0.10055127f, 1.08152783f, 0.95269513f, 0.36939275f, -0.38166320f, 
    -1.23557925f, 0.20533749f, 0.00698504f, -0.07503414f, -0.22479120f, -0.37742713f, 0.18540837f, -0.32794032f, 
    0.00165591f, 0.20903672f, 0.02035887f, -0.06483715f, 0.22812377f, 0.29718992f, -0.12377427f, -0.26410300f, 
    0.01230007f, 0.15983522f, 0.04902613f, -0.31039712f, 0.00727997f, 0.40853572f, 0.28733966f, -0.09545861f, 
    -0.18025595f, 0.05098709f, -1.49963164f, -0.76242197f, -0.77666593f, -0.70334160f, -0.61442614f, 0.03495518f, 
    -0.36880487f, 0.03806104f, 0.52107453f, 0.17410541f, 0.26758641f, -0.03425955f, 0.17836642f, 0.06395819f, 
    -0.61851293f, -0.19736418f, 0.05325020f, -0.00431783f, -0.00243286f, 0.09472695f, 0.21079451f, -0.28601149f, 
    -0.08469318f, 0.91918510f, 0.78862435f, -0.10105763f, 0.28902578f, -0.67896432f, -0.76387972f, -0.57927573f, 
    -0.00573043f, 0.15224922f, 0.25295269f, 0.25208655f, -0.18561590f, -0.26939929f, -0.19976783f, -0.06086591f, 
    0.09213875f, 0.29679066f, -0.05503167f, -0.06898592f, 0.18633649f, 0.15660112f, -0.29061508f, -0.50011224f, 
    -0.32501823f, -0.10736831f, 0.04883792f, -0.40376320f, 0.47827035f, -0.56923741f, -0.45352677f, 0.63337076f, 
    -0.39366862f, -0.19810732f, 0.21429093f, 0.20023142f, -0.35507259f, -0.09836601f, -0.00484965f, 0.23490581f, 
    -0.13795592f, -0.11234318f, 0.15763836f, 0.05129441f, 0.36203220f, -0.05365447f, 0.10218614f, 0.42313024f, 
    -0.31797212f, 0.82369739f, -0.48982903f, -1.54427707f, -0.88619435f, 0.09778985f, -0.28170967f, 0.07257414f, 
    -0.07597952f, 0.66931731f, -0.29979107f, 0.22270581f, 0.07799169f, 0.04240161f, 0.43499932f, -0.05479766f, 
    -0.03723514f, -0.35569030f, -0.47522464f, 0.19165505f, 0.07707593f, 0.21152145f, -0.38421112f, 0.14177142f, 
    -0.18656804f, -0.07912304f, -0.37111136f, -0.96728212f, -0.36634549f, -0.86073852f, -0.11529300f, 0.21913388f, 
    0.26843998f, 0.08898040f, 0.33967504f, 0.09443372f, 0.37802967f, 0.25571829f, 0.03671163f, 0.17211714f, 
    -0.17435998f, 0.07745952f, 0.10584634f, -0.25764462f, -0.09784388f, -0.07485078f, -0.33214146f, -0.04728680f, 
    -0.14610748f, 0.22307143f, -0.47791189f, 0.24722207f, 0.28843015f, -0.14447567f, 0.13952075f, -0.29331529f, 
    0.28873602f, 0.55622989f, -0.05659854f, -0.38616487f, -0.08802500f, 0.24866587f, -0.02066445f, 0.05763481f, 
    0.01717781f, -0.11758817f, -0.38218197f, 0.09124205f, -0.18506995f, 0.22708502f, -0.08587077f, 0.10584628f, 
    0.38988349f, -0.16577443f, -0.22418217f, -0.05569565f, 0.10297090f, 0.08455356f, 0.18879454f, -0.25335228f, 
    -0.39574718f, -0.30263177f, 0.27769357f, 0.52847022f, 0.27925566f, 0.15547177f, -0.21190831f, -0.41121760f, 
    -0.16038698f, 0.19330278f, -0.01333390f, -0.11499821f, -0.35854787f, 0.00386158f, 0.08177007f, -0.03991140f, 
    0.16978535f, -0.16590112f, 0.23585914f, -0.06573386f, -1.55021858f, -0.37005371f, -0.12972006f, 0.55878794f, 
    0.70593810f, -0.07769280f, -1.35019660f, -0.79872596f, -0.23321399f, 0.68020195f, 0.43851632f, 0.40273532f, 
    0.25781965f, 0.11895180f, 0.01227707f, -0.32939106f, -0.32525101f, -0.06407283f, -0.57698572f, -0.21379155f, 
    -0.07719957f, 0.09659981f, 0.24306059f, -0.10651813f, 0.03486339f, 0.57569355f, -0.13931945f, -0.10348839f, 
    0.24010450f, -0.28245887f, -0.28219250f, -0.14163101f, 0.57851046f, 0.32589006f, 0.18247180f, 0.10413417f, 
    0.20181552f, 0.09344829f, -0.05033484f, -0.36314672f, 0.05118047f, 0.13554808f, 0.21852373f, -0.26368171f, 
    0.10729318f, 0.29036629f, -0.09414011f, -0.38689321f, 0.04951318f, 0.02715377f, 0.09739718f, 0.22836465f, 
    -0.27225584f, 0.22679137f, 0.02651724f, 0.02894273f, -0.27139571f, -0.19647825f, 0.07414939f, 0.27766502f, 
    -0.24217501f, 0.12192382f, -0.02389542f, -0.31005949f, -0.08882861f, -0.12163854f, 0.01559838f, -0.32945257f, 
    -0.03551813f, -0.23791197f, -0.44989476f, -0.46250808f, -0.33196428f, -0.64731497f, -0.70017815f, -0.96027905f, 
    -0.10416015f, 0.39576033f, -0.98765785f, -0.77719223f, -0.20938347f, 0.30991367f, 0.62881112f, 0.72674155f, 
    0.30481434f, 0.10240981f, -0.25444454f, 0.10075007f, -0.34662059f, 0.04354176f, 0.12260521f, 0.17617039f, 
    0.10414208f, 0.21719232f, 0.14392874f, -0.08711353f, 0.03741574f, -0.05407258f, -0.12619936f, 0.05021512f, 
    -1.36111486f, 0.01435704f, -0.78229076f, -1.21417809f, -0.95067281f, 0.46614423f, 0.15429898f, -0.17299937f, 
    -0.16387504f, 0.18413962f, -0.34632182f, -0.57224166f, -0.40233481f, -0.36471012f, -0.05916661f, 0.46527699f, 
    0.04647853f, 0.04317963f, 0.18304650f, -0.18534648f, -0.02735877f, -0.11360873f, -0.06082197f, -0.14562596f, 
    -0.11133767f, 0.89533615f, -0.80824548f, -0.46521491f, 0.32891196f, -0.10458093f, 0.85328412f, 0.85221952f, 
    -0.00239117f, -0.65446359f, -0.44943619f, 0.36048836f, 0.02440248f, -0.12989250f, -0.44331807f, 0.50737780f, 
    0.18400314f, -0.22347869f, -0.24129759f, -0.12867326f, -0.08132259f, 0.26038620f, -0.23655108f, -0.08464449f, 
    0.19197209f, -0.11413426f, -0.75837511f, -0.62062788f, -0.67014337f, -0.68122673f, -0.59406334f, 1.00124609f, 
    0.34609219f, -0.10089602f, 0.15215705f, 1.02631760f, 0.20048632f, -0.07462069f, -0.40188950f, 0.05493744f, 
    -0.21217518f, -0.39416981f, -0.08594175f, 0.02431596f, 0.05695424f, -0.31168327f, 0.24764138f, -0.07617454f, 
    0.21144792f, 0.43601981f, 0.25205758f, -0.15044624f, 0.13893458f, 0.17341463f, -0.21062107f, 0.26347396f, 
    0.05234315f, 0.00791219f, -0.23970275f, 0.54767537f, -0.50602919f, 0.09386752f, -0.25464195f, 0.02312788f, 
    -0.07937198f, 0.13841295f, 0.22741278f, 0.01398352f, -0.43725955f, -0.22314826f, 0.37064448f, 0.06634670f, 
    0.18278566f, 0.05246086f, -0.26433614f, 0.04592822f, -0.35612977f, -0.64328963f, 0.22416109f, 1.24029183f, 
    -0.51460099f, -0.37099695f, -0.59504610f, -0.01166433f, 0.60583973f, -0.03264733f, 0.14530799f, -0.33626476f, 
    -0.20778236f, 0.28649852f, 0.15466470f, -0.02923091f, -0.11672039f, -0.15398487f, -0.19718537f, -0.35686830f, 
    -0.28453529f, -0.39989102f, -0.21583106f, -0.27407774f, -0.51492500f, 0.08944702f, 0.06304333f, -0.08316238f, 
    -0.11630291f, -0.03821183f, 0.09944807f, 0.06077998f, -0.02980059f, 0.04713097f, -0.22685294f, -0.11813509f, 
    0.41574058f, -0.02819853f, -0.43914607f, 0.24068604f, -0.38370642f, -0.03454772f, 0.08143011f, 0.44123450f, 
    -0.32906327f, 0.18878466f, 0.28157261f, -0.11209761f, -0.19951294f, 0.58201104f, -0.82769537f, -0.84322506f, 
    -0.42803621f, 0.11577964f, 0.56800610f, -0.35855371f, -0.44785005f, -0.19199753f, -0.82883054f, -0.86560839f, 
    0.01320784f, -0.02052877f, -0.03386486f, -0.14247443f, -0.47833973f, -0.00527165f, -0.37656766f, -0.05460423f, 
    0.20522296f, 0.13891730f, 0.01059977f, -0.48989344f, -0.43069232f, 0.02880332f, 0.02349808f, -0.18955699f, 
    -0.71282858f, -0.78046918f, -0.61922228f, 0.00032762f, 0.17062649f, 0.05792568f, -0.02791792f, 0.33038217f, 
    -0.20786479f, -0.04244499f, -0.21874602f, -0.17571434f, -0.25384313f, 0.29658061f, -0.52791244f, -0.16897264f, 
    -0.29639223f, -0.18083939f, -0.54216361f, 0.22462046f, 0.31399122f, 0.40953970f, 0.15837418f, 0.31493339f, 
    0.08799022f, 0.24893239f, -0.40576780f, -0.43108773f, -0.41655943f, 0.27534333f, 0.05461012f, 0.21613337f, 
    -0.03522033f, -0.02194957f, 0.40744168f, 0.10779180f, 0.19221520f, 0.25201967f, -0.19475016f, -0.55100137f, 
    0.16012721f, -0.35892537f, 0.17462821f, -0.39958984f, -0.06676020f, 0.22543222f, 0.50766969f, 0.40356022f, 
    0.11249425f, -0.95038116f, -0.36168003f, -0.71031570f, 0.35447100f, 0.67652649f, 0.27684429f, 0.67132539f, 
    -0.61015576f, -0.30952632f, 0.19649102f, -0.54844022f, 0.40290621f, -0.92312944f, -0.43191174f, 0.27298024f, 
    -0.05521867f, -0.02210998f, -0.14519216f, 0.34704006f, -0.09839577f, 0.27309239f, -0.33871123f, -0.09280011f, 
    -0.26545408f, 0.07028235f, 0.88956660f, 1.12619305f, 0.61176842f, -0.40815562f, -0.30680472f, -0.50825554f, 
    -0.62992632f, 0.20238684f, 0.31400684f, -0.81152534f, -0.11993732f, -0.02194004f, 0.15261629f, -0.26925489f, 
    -0.31842259f, -0.03438606f, 0.42336151f, 0.00853062f, 0.01938343f, -0.05712486f, -0.17556694f, 0.23160620f, 
    -0.01326392f, 0.04866295f, -0.32701176f, 0.40613940f, 0.34568563f, -0.36319041f, 0.11497360f, 0.25527883f, 
    -0.22767030f, -0.18569425f, 0.28841916f, 0.00494743f, -0.69755059f, -0.27697232f, -0.23025626f, 0.03008384f, 
    -0.11393559f, -0.20344055f, -0.06604016f, 0.04095409f, -0.21004765f, -0.25011301f, 0.22505930f, 0.06097005f, 
    0.16623890f, -0.02460452f, -0.45209846f, 0.39185119f, 0.48162907f, 0.13016815f, 0.30692944f, -0.29951036f, 
    -0.43791455f, 0.16123246f, 0.15114595f, -0.01124319f, 0.15750293f, 0.13306536f, 0.11970486f, -0.14392453f, 
    -0.26484707f, 0.23164725f, -0.04004586f, -0.05905022f, -0.02680144f, -0.04613823f, 0.02397989f, 0.00752969f, 
    0.03400254f, -0.14494777f, -0.13742760f, -0.02265985f, 0.32249692f, -0.94081002f, -1.01129460f, -0.44761103f, 
    0.06482094f, 0.13193224f, -0.54196948f, -0.60681295f, 0.09549533f, 0.74715996f, 0.34000412f, -0.31801814f, 
    -0.27911592f, 0.35163379f, -0.32484919f, -0.18243274f, -0.08261192f, -0.24451467f, -0.64040601f, -0.18032812f, 
    -0.04413550f, -0.40477243f, -0.41153833f, -0.41681799f, -0.09469731f, -0.30938223f, 0.12094183f, 0.45696363f, 
    0.27358842f, -0.50131577f, 0.25449252f, 0.24203262f, 0.09387147f, 0.34808770f, -0.28067103f, -0.24832335f, 
    -0.47207659f, 0.34924400f, -0.42288941f, 0.27883184f, -0.10155090f, 0.28906998f, -0.10244278f, -0.36523679f, 
    -0.11064371f, 0.01500845f, -0.13831177f, -0.24082303f, 0.00617213f, 0.28819409f, -0.20357431f, -0.51858097f, 
    -0.53489649f, -0.20566078f, -0.28251377f, -0.87254751f, 0.66802812f, 0.32053003f, 0.24756496f, 0.02205584f, 
    0.33677176f, 0.22220960f, 0.02666638f, -0.12797600f, 0.11357489f, 0.28033310f, -0.19362354f, -0.16083039f, 
    -0.33353361f, -0.36528081f, -0.02225144f, -0.26457027f, -0.42491168f, 0.22611000f, -0.25067332f, -0.35596886f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05450216f, 0.26295811f, 0.41060138f, -0.39333084f, 0.60234386f, 0.22171399f, 0.10674726f, 0.15213282f, 
    0.59932357f, 0.37433460f, 0.42890787f, 0.35830885f, 0.29333553f, 0.14749591f, -0.20474146f, -0.05725559f, 
    -0.30039486f, 0.61160254f, 0.46929756f, 0.29423952f, 0.09105264f, 0.26866290f, -0.03267019f, -0.39080364f, 
    -0.06922257f, 0.31349638f, 0.50649983f, 0.09230037f, 0.01036407f, -0.13444176f, 0.05126980f, -0.16766351f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11534434f, -0.68713593f, 0.04260842f, 0.20417643f, -0.05853386f, 0.01029620f, -0.00127594f, -0.10728770f, 
    0.01693856f, -0.01244666f, 0.01308574f, 0.04767787f, -0.04344481f, -0.08988865f, -0.01644698f, 0.01089297f, 
    -0.00639634f, 0.02499373f, -0.01467601f, 0.05130965f, -0.14908731f, -0.02803425f, 0.05705782f, -0.22236805f, 
    -0.28851172f, -0.15604764f, 0.30608064f, -0.11891288f, 0.02571462f, 0.01231748f, 0.06724317f, 0.04864314f, 
    -0.01469368f, 0.03043136f, 0.17491674f, -0.49247283f, 0.43991214f, 0.32060951f, -0.19715309f, -0.22273876f, 
    0.16309652f, 0.12969708f, -0.00745028f, 0.09540770f, -0.07683726f, -0.11335727f, -0.09163096f, -0.07930719f, 
    -0.06836985f, -0.83423001f, -0.43323201f, -0.07453776f, -0.08506602f, 0.26106998f, -0.09949930f, -0.11378638f, 
    -0.14614932f, 0.03706405f, 0.03430884f, 0.08538494f, 0.16237821f, 0.20091563f, 0.02328932f, -0.27719244f, 
    -0.08342591f, -0.05203750f, 0.02897063f, -0.01750598f, -0.01621472f, 0.06381105f, -0.00060784f, 0.05444806f, 
    -0.08867136f, -0.04745146f, -0.09683020f, -0.07920570f, -0.05970393f, -0.31606820f, -0.03736954f, -0.11510024f, 
    -0.00842067f, 0.00538879f, 0.04734112f, 0.04892306f, 0.21781816f, 0.23906878f, -0.01804224f, -0.15770371f, 
    -0.17883174f, -0.02544707f, -0.03137131f, -0.04812780f, 0.10553717f, 0.00314878f, 0.10863369f, -0.02889430f, 
    0.24210282f, -0.11949210f, -0.08713426f, -0.09616515f, -0.00665325f, -0.00179979f, -0.19231036f, -0.28725687f, 
    -0.27657095f, -0.20179312f, -0.10723804f, 0.02691411f, 0.23973615f, 0.08841303f, -0.04769015f, 0.03430215f, 
    0.14582288f, 0.06922784f, 0.02252855f, -0.25013754f, -0.12805045f, -0.03287609f, -0.01556843f, 0.08550202f, 
    -0.68724459f, -0.41842583f, -0.12293996f, -0.23600161f, -0.02993354f, -0.13945609f, 0.08378657f, 0.09042665f, 
    -0.03584421f, -0.07017278f, 0.08761518f, 0.10869016f, -0.69082779f, -0.23198076f, 0.37208053f, -0.23793960f, 
    0.03883916f, -0.02225256f, 0.06994168f, 0.02262267f, 0.03935808f, -0.08088912f, 0.00221064f, -0.05487623f, 
    0.42483634f, 0.44899824f, 0.48180258f, -0.56178117f, -0.23762698f, 0.27087370f, 0.05019149f, -0.11654564f, 
    -0.01081917f, -0.11526714f, -0.22271903f, -0.08464786f, -0.02348145f, -0.01908294f, -0.02498028f, -0.00879193f, 
    -0.06491174f, 0.12479598f, 0.03194721f, 0.01573293f, -0.41925061f, -0.22961813f, -0.14181413f, -0.01927144f, 
    -0.47694221f, -0.03536031f, -0.01984739f, 0.12440752f, -0.00673230f, -0.00152917f, 0.05817441f, 0.06991688f, 
    -0.17572394f, -0.05747561f, 0.19636092f, 0.23984875f, -0.02729167f, 0.00029063f, 0.18017860f, -0.07271823f, 
    0.15027843f, 0.19097501f, 0.07535826f, 0.14743119f, 0.00397077f, 0.01785094f, 0.04540676f, -0.01526298f, 
    0.15922152f, 0.29776201f, -0.04134148f, -0.18008646f, 0.09348447f, 0.42728746f, 0.07540056f, 0.22728485f, 
    0.03516713f, 0.02463994f, 0.13052110f, 0.04926177f, -0.00964351f, -0.54529792f, -0.69014812f, -0.26388338f, 
    -0.02207973f, -0.06935512f, -0.05718183f, -0.21347973f, -0.14995189f, -0.25217324f, -0.02990925f, -0.18775992f, 
    0.09151216f, -0.15987793f, -0.23050816f, -0.03863017f, 0.08937789f, 0.12295149f, -0.06341763f, -0.14313349f, 
    -0.05761695f, 0.02964385f, 0.00768139f, -0.08294625f, -0.15916064f, 0.07036456f, -0.02061567f, -0.09569963f, 
    -0.06864932f, -0.05497351f, 0.00987138f, 0.08847439f, -0.03771650f, 0.03836918f, 0.01987587f, -0.12906526f, 
    0.03879778f, -0.15945415f, 0.31248349f, -0.50645739f, -0.01847724f, -0.10609265f, -0.05153469f, 0.14997114f, 
    0.00287639f, -0.14347433f, -0.03201698f, -0.00892375f, -0.05766119f, -0.06505811f, 0.03799735f, 0.07590545f, 
    0.00916041f, -0.28792313f, -0.11512673f, -0.04549317f, -0.07665459f, -0.05442346f, -0.07051763f, -0.06173348f, 
    0.54078346f, 0.10524844f, -0.20652665f, -0.18485837f, 0.22088775f, 0.06182124f, 0.20997098f, 0.10454814f, 
    -0.01378851f, -0.09633584f, -0.09230510f, -0.04259275f, 0.30328929f, -0.01263408f, -0.22401309f, -0.08885673f, 
    0.24313377f, 0.22485465f, -0.04213981f, -0.41567731f, -0.08055950f, -0.13461488f, -0.14600033f, -0.00707772f, 
    0.17838794f, -0.26823202f, -0.10140584f, 0.04160397f, 0.14214471f, 0.08573348f, -0.13497703f, -0.22147678f, 
    -0.33739468f, -0.23607939f, -0.16516626f, -0.07506274f, 0.40730762f, 0.36858296f, -0.00062706f, -0.13383788f, 
    0.00365920f, -0.03558291f, 0.09026532f, -0.25208968f, -0.14756362f, 0.06889737f, -0.14901163f, -0.11182553f, 
    -0.65211821f, -0.24226131f, -0.17366621f, 0.35138366f, 0.03704231f, -0.02516372f, -0.09089987f, 0.06692643f, 
    0.04858623f, -0.01048286f, 0.00791723f, 0.08179190f, -0.30034143f, -0.43376938f, 0.08370442f, 0.09300624f, 
    -0.00598244f, 0.03921442f, -0.00965464f, 0.11915199f, 0.04976449f, -0.01195337f, 0.05470016f, -0.03119654f, 
    -0.08315185f, -0.08136860f, -0.06000895f, -0.01512045f, 0.00108613f, 0.09454866f, 0.00044310f, -0.01703268f, 
    -0.09585334f, 0.06018636f, -0.03046164f, -0.13017079f, 0.29223666f, 0.30737332f, 0.16768986f, -0.14681949f, 
    0.03853371f, 0.06132385f, 0.02865589f, -0.23922716f, -0.12699130f, -0.14956072f, 0.07423876f, 0.17839031f, 
    -0.23779070f, -0.10024433f, -0.27254879f, 0.40211114f, 0.05223273f, 0.04069600f, 0.12841849f, 0.05050983f, 
    0.04320415f, 0.00368250f, 0.00791488f, -0.05756314f, -0.01270064f, -0.35359544f, -0.22601905f, 0.06828165f, 
    0.02288162f, 0.06860694f, -0.02134668f, 0.10072028f, 0.12909813f, -0.06437405f, 0.00308258f, 0.16062364f, 
    0.38083383f, 0.04620919f, -0.08179389f, 0.09312125f, 0.00201268f, -0.02649214f, 0.00948029f, 0.09790953f, 
    0.21852368f, -0.14350672f, 0.00319546f, -0.03076552f, 0.06105009f, 0.03806572f, 0.16347499f, 0.15626360f, 
    0.01391489f, -0.05470142f, -0.02713217f, 0.02890734f, -0.04363953f, -0.06937572f, -0.00352620f, 0.04021481f, 
    0.12228090f, 0.05323639f, 0.08610857f, 0.47924370f, -0.04956945f, -0.03593044f, -0.09160014f, 0.16324012f, 
    -0.05565330f, 0.03457527f, -0.31036696f, 0.43579566f, 0.07612819f, 0.04360094f, 0.15787938f, 0.16557927f, 
    -0.19291721f, 0.09952538f, -0.15386197f, 0.01923529f, -0.01265801f, 0.08054984f, -0.05632049f, 0.12084035f, 
    0.41869602f, -0.18125099f, -0.03697025f, -0.44130856f, 0.03584737f, -0.12343657f, -0.02525186f, 0.05712339f, 
    -0.07233795f, -0.00389470f, -0.03191243f, -0.00677377f, 0.05021454f, 0.11587791f, -0.40846637f, -0.49912119f, 
    -0.20929645f, -0.13374558f, 0.03158451f, 0.00841059f, -0.04782729f, 0.00340041f, 0.06835167f, 0.02223624f, 
    0.21255472f, 0.20474714f, -0.07443894f, -0.03822763f, -0.01061469f, -0.04680627f, 0.05009253f, -0.05107408f, 
    -0.14777437f, 0.00747155f, 0.03292821f, 0.09582366f, -0.08384674f, 0.18515912f, -0.12967221f, 0.15685962f, 
    -0.01779738f, 0.03283346f, -0.05241042f, 0.24014328f, -0.12558405f, -0.00570163f, 0.05528334f, -0.07824386f, 
    -0.33526218f, -0.29177704f, -0.07774663f, -0.05781189f, 0.23089010f, 0.28520206f, -0.15142402f, 0.08917675f, 
    -0.06540012f, 0.09901545f, -0.03960778f, -0.06176508f, -0.00056776f, -0.30172464f, -0.07447247f, -0.05589192f, 
    0.06225074f, 0.08629569f, 0.00227235f, -0.28803280f, 0.37395659f, 0.08388845f, -0.01220093f, -0.02046151f, 
    0.11998090f, -0.09363817f, 0.20151706f, -0.03517325f, 0.00481048f, -0.08382335f, 0.11059774f, 0.08831422f, 
    0.07292490f, 0.04908799f, 0.06768190f, -0.13103558f, -0.30621204f, 0.38477400f, 0.25064421f, 0.17434950f, 
    0.02627284f, -0.01274863f, 0.04167302f, -0.01597544f, 0.07072733f, -0.07035664f, 0.07702249f, 0.02838401f, 
    -0.96720552f, -0.18364137f, -0.68737316f, 0.26453438f, 0.02448380f, 0.07220010f, 0.08785814f, 0.20645924f, 
    -0.02939294f, -0.01084896f, -0.00545928f, 0.04611827f, 0.09444864f, -0.00052502f, 0.19942801f, -0.01227029f, 
    0.00578198f, 0.09329080f, -0.04629421f, -0.05031370f, 0.15010881f, -0.06924616f, -0.10081933f, 0.15841049f, 
    -0.01160244f, 0.12708004f, 0.03913270f, 0.05168398f, -0.02792687f, 0.04829396f, -0.00132469f, -0.04275306f, 
    -0.59621525f, -0.16963591f, -0.24419180f, -0.29286417f, -0.19869652f, -0.04025472f, -0.00238558f, -0.01067295f, 
    -0.03745975f, 0.04848263f, -0.34765166f, -0.44576669f, -0.11313315f, -0.04741177f, -0.23111209f, -0.00061393f, 
    0.40132385f, 0.54009920f, 0.44494712f, 0.14617568f, 0.23799953f, 0.20659579f, -0.27688661f, -0.27660474f, 
    -0.04333540f, -0.03634451f, -0.10426960f, -0.17776525f, 0.96660262f, -0.43273833f, 0.38259479f, 0.25524575f, 
    -0.18392789f, 0.04439974f, -0.00719121f, -0.04649914f, 0.03108356f, 0.20323156f, 0.24341811f, 0.16933943f, 
    0.25513446f, 0.04208648f, -0.27178216f, -0.55429614f, -0.04508092f, 0.03482678f, 0.05481101f, -0.02155565f, 
    -0.04782468f, -0.06971458f, 0.00336368f, -0.13745300f, 0.10046475f, -0.04837209f, -0.00154303f, 0.11316512f, 
    0.05092430f, -0.12915325f, -0.07079393f, 0.08219858f, -0.11045153f, 0.11406928f, 0.06557339f, -0.05203012f, 
    -0.42170659f, 0.03594724f, -0.07452700f, -0.26961032f, 0.03263858f, -0.05669196f, -0.01506461f, 0.00880657f, 
    -0.10603585f, -0.11346276f, -0.23639196f, -0.51551598f, 0.07512969f, 0.04186932f, -0.01117573f, 0.08006924f, 
    0.12209544f, 0.17396110f, -0.05601339f, 0.00027823f, -0.15017949f, 0.10361979f, -0.10589304f, 0.01472606f, 
    -0.12405684f, -0.06135675f, 0.00541751f, 0.12905844f, -0.02339165f, -0.08456609f, 0.17361687f, -0.30219483f, 
    0.13154663f, -0.00501145f, -0.04523198f, 0.03503380f, 0.01421886f, 0.30325222f, 0.29932857f, -0.04365025f, 
    0.18443525f, 0.16109145f, 0.08222716f, 0.23840149f, 0.00285971f, 0.01579708f, -0.00984317f, -0.29419193f, 
    -0.06441819f, -0.18547638f, 0.00110503f, -0.03193749f, -0.05408045f, -0.01981379f, 0.08769540f, 0.30055609f, 
    -0.16926816f, 0.02820410f, -0.11346567f, -0.03935757f, 0.11161791f, -0.23096380f, -0.08429253f, -0.27961609f, 
    -0.14029220f, 0.12004386f, -0.08949029f, 0.10561067f, 0.29358792f, -0.02762984f, -0.29882485f, -0.07932171f, 
    0.38766366f, -0.15078683f, 0.34559450f, -0.10070387f, 0.09091312f, -0.13879156f, -0.02341348f, -0.12782256f, 
    -0.12599109f, 0.07560605f, -0.03733603f, 0.05816573f, 0.20363082f, 0.11689567f, -0.33083138f, 0.00377382f, 
    0.01777200f, -0.04979471f, -0.04283073f, -0.03318098f, -0.06728268f, 0.05725888f, -0.06250647f, -0.02313071f, 
    0.23051338f, 0.06188679f, 0.06730936f, 0.12921159f, -0.03100148f, 0.03225032f, 0.03610307f, -0.02297822f, 
    0.15819763f, -0.02012688f, -0.05871374f, -0.14576156f, -0.12925097f, 0.26069459f, -0.43470398f, 0.23008864f, 
    0.09558340f, 0.01959405f, 0.07081614f, -0.18909951f, 0.00256320f, 0.04965901f, -0.04428344f, -0.09696019f, 
    0.49712989f, -0.23004423f, 0.25977969f, 0.13799858f, -0.00634475f, -0.07181970f, 0.00956886f, -0.01193968f, 
    0.03856526f, 0.05732781f, 0.11931102f, -0.06379027f, 0.12178013f, -0.06175778f, -0.06553412f, -0.09011286f, 
    -0.06174606f, 0.01863158f, -0.04546110f, -0.00019903f, -0.21947673f, -0.13599738f, -0.05868711f, -0.20706427f, 
    -0.03488009f, -0.01789827f, -0.13726763f, -0.04181875f, 0.00688643f, -0.08458610f, -0.09407887f, 0.21894492f, 
    0.24467610f, 0.17210513f, -0.05244976f, -0.31038511f, 0.07936564f, -0.08785901f, 0.05189410f, -0.01810595f, 
    0.00093950f, -0.06995478f, 0.10008457f, 0.08611459f, -0.05640109f, -0.18579505f, -0.10556436f, 0.18502134f, 
    0.19084030f, 0.03352680f, -0.67895156f, -0.26179424f, 0.05830849f, 0.00376533f, 0.03639978f, 0.03759419f, 
    0.01825252f, -0.04536547f, -0.21897966f, -0.04568126f, -0.96625900f, -0.62958938f, -0.28626764f, -0.74496329f, 
    0.05943240f, -0.14764042f, 0.04306212f, -0.07629404f, -0.02844348f, -0.08992431f, 0.01488841f, -0.00811937f, 
    -0.19699499f, 0.11566977f, 0.10674283f, -0.48916638f, 0.07852148f, -0.32477102f, -0.31834161f, 0.06891546f, 
    0.05408467f, 0.03800306f, -0.00907478f, 0.07081586f, -1.30396283f, -0.92127949f, 0.28128788f, -0.19164369f, 
    -0.09033320f, -0.11467995f, -0.19479316f, -0.27632657f, 0.08071685f, -0.00181213f, 0.03594577f, -0.03795628f, 
    -0.08680962f, 0.41062751f, -0.46326229f, -0.21489248f, 0.06177489f, -0.28600058f, 0.06371219f, 0.17322834f, 
    -0.03978095f, 0.04274003f, 0.03728753f, -0.09222067f, -0.05855908f, -0.00080576f, -0.04746873f, -0.03067803f, 
    0.02825656f, 0.19841154f, 0.08083142f, 0.16344672f, -0.03274332f, 0.02657413f, -0.03511386f, 0.02948928f, 
    0.59296632f, 0.00442210f, 0.04321072f, 0.40412694f, 0.02358830f, 0.05973338f, 0.03105912f, -0.02654154f, 
    0.03608339f, 0.03113130f, -0.18465689f, 0.09690256f, 0.10481885f, 0.28091875f, 0.25142980f, 0.11139348f, 
    -0.15102702f, -0.00149426f, 0.01422773f, -0.20853427f, -0.12169798f, 0.12224636f, 0.02235612f, 0.10109962f, 
    0.31151459f, 0.06476653f, -0.18326624f, -0.16912101f, -0.02767680f, -0.00566087f, 0.13674410f, 0.01572548f, 
    -0.05126542f, 0.01719651f, -0.02776393f, -0.06220010f, -0.13487749f, 0.00300288f, -0.00921641f, -0.08241612f, 
    0.01727881f, 0.02323271f, 0.03851463f, 0.08119863f, -0.03829039f, -0.00804635f, -0.14185736f, 0.14966814f, 
    0.04463243f, -0.42786840f, -0.39103067f, 0.13278109f, 0.23432064f, -0.16990426f, -0.12826923f, -0.03185480f, 
    -0.03951381f, -0.04393325f, -0.11176023f, -0.00912670f, -0.17792803f, 0.06776003f, -0.05918338f, 0.03210600f, 
    -0.02352413f, -0.00833676f, -0.04062252f, 0.05489760f, -0.07217163f, 0.14818279f, 0.10177410f, 0.12039375f, 
    -0.03705178f, -0.03651913f, -0.04384296f, 0.07365490f, -0.03155900f, -0.01252930f, -0.02451269f, -0.01926155f, 
    0.13166076f, 0.20620999f, 0.25643489f, 0.11841802f, 0.27897838f, 0.54812133f, -0.04035785f, 0.14675094f, 
    -0.16556616f, 0.11372283f, 0.04836313f, -0.06154232f, 0.01017462f, 0.08287452f, 0.04710105f, 0.11122549f, 
    -0.09003238f, 0.25535214f, 0.46901375f, 0.49501923f, -0.10049909f, -0.01029438f, 0.00831275f, -0.10156322f, 
    0.01831682f, 0.04019194f, 0.01332639f, 0.08232496f, -0.18307373f, -0.19698201f, 0.31139731f, -0.14665733f, 
    -0.06749948f, -0.05582178f, -0.00595197f, 0.14543536f, -0.03109867f, 0.09342170f, 0.04120401f, 0.10051142f, 
    -0.06887058f, 0.26586267f, 0.46133453f, 0.10460418f, 0.00501831f, 0.09108692f, -0.09522329f, -0.00333997f, 
    0.03078948f, -0.01387466f, -0.05578058f, 0.11981332f, 0.10365536f, -0.08647145f, -0.09495080f, -0.01741609f, 
    -0.01455125f, 0.05748973f, 0.11573357f, -0.01821308f, 0.01350915f, 0.07272461f, -0.08974282f, 0.12300315f, 
    -0.12460500f, 0.09460714f, -0.13820034f, 0.22421329f, -0.16319887f, 0.03017379f, -0.02521972f, -0.05161509f, 
    -0.01818559f, 0.16274893f, 0.20499696f, 0.04514465f, -0.03907095f, 0.05300455f, -0.01619306f, -0.03827055f, 
    -0.04527002f, 0.17041415f, -0.27266032f, 0.20211706f, 0.06963907f, -0.04602980f, 0.07338367f, -0.08873668f, 
    -0.37271115f, -0.18456948f, -0.26695934f, -0.11996067f, 0.05518942f, 0.03997827f, 0.16177143f, -0.02144744f, 
    -0.05203179f, 0.01735175f, 0.02377263f, -0.04518986f, -0.35626456f, -0.02422123f, 0.34526619f, 0.09134185f, 
    -0.08874130f, 0.13124341f, -0.04474388f, 0.07612029f, -0.04714957f, -0.02646451f, -0.15942511f, -0.14000534f, 
    -0.27663019f, -0.24265489f, -0.12631369f, -0.11859515f, 0.03150123f, -0.09057177f, 0.01426761f, -0.08345870f, 
    0.05116573f, -0.65143186f, -0.09503235f, 0.03323472f, 0.01575473f, -0.44132051f, 0.53931379f, -0.01459108f, 
    0.02954046f, 0.09170116f, -0.10604135f, 0.11295474f, 0.04373724f, 0.09104935f, -0.14450508f, -0.06532343f, 
    -0.42547616f, -0.26826248f, 0.59636945f, -0.33007383f, 0.01310438f, -0.04500936f, 0.02554545f, 0.05468653f, 
    0.02328292f, -0.08425084f, -0.02722784f, 0.03261108f, 0.10156122f, 0.26107872f, 0.01271747f, 0.25569767f, 
    -0.00453283f, 0.10748346f, 0.05776127f, 0.06120688f, -0.01285475f, -0.00143144f, -0.06816104f, 0.07573965f, 
    -0.28181604f, 0.17219503f, 0.00941445f, -0.13011362f, 0.00495843f, -0.00748266f, -0.03407417f, 0.06700875f, 
    -0.14964350f, -0.13551331f, 0.01788709f, 0.06897050f, -0.09367548f, -0.08949031f, -0.12310189f, 0.41844872f, 
    -0.10240534f, 0.01407815f, 0.04772176f, 0.05749125f, -0.12534021f, -0.02186205f, 0.02799849f, 0.07748713f, 
    0.17115761f, -0.46211979f, -0.29668644f, -0.21326946f, 0.00661422f, -0.02834794f, -0.00044072f, 0.02606396f, 
    -0.05486192f, -0.02196077f, -0.31752557f, 0.18414359f, 0.13640060f, 0.06568778f, 0.43659958f, 0.10833147f, 
    -0.02885722f, -0.00311801f, 0.07770670f, -0.05843042f, 0.09649006f, 0.19082643f, -0.03919050f, 0.05768417f, 
    0.45364597f, 1.20528197f, -0.37700200f, 0.55662572f, 0.19602558f, -0.10377931f, 0.12450179f, -0.03936566f, 
    0.11609729f, 0.09167715f, -0.04027476f, -0.11542628f, -0.37275136f, -0.29579630f, -0.41325352f, 0.03868474f, 
    -0.06159701f, 0.03795419f, -0.20430885f, -0.13344988f, -0.10466982f, 0.01702489f, -0.18262969f, -0.12932807f, 
    -0.12990235f, 0.35202140f, -0.04711191f, -0.64162666f, 0.06729951f, -0.21712051f, -0.03322034f, 0.26312885f, 
    -0.29218501f, 0.09007163f, -0.14010859f, 0.15122439f, 0.03591965f, -0.14332762f, -0.16698608f, 0.13031554f, 
    0.07182179f, 0.14688635f, 0.15752932f, 0.11847041f, -0.10240703f, -0.06231864f, -0.02122696f, -0.01612129f, 
    -0.61343282f, -0.43206051f, 0.47436503f, 0.32090750f, -0.15454581f, -0.02312574f, -0.21387064f, 0.06509921f, 
    0.09408960f, 0.04561650f, -0.10101786f, 0.08722067f, 0.02091995f, -0.29717958f, 0.00937037f, 0.18355849f, 
    -0.05447781f, 0.11500733f, 0.01594162f, 0.25730801f, -0.05099752f, 0.02660927f, 0.16577367f, -0.12523000f, 
    -0.10448593f, 0.26629660f, -0.35545495f, 0.48867756f, -0.02345167f, -0.11002193f, 0.07397585f, -0.06493112f, 
    0.07574092f, -0.10265514f, 0.15964831f, 0.14578629f, 0.03463541f, -0.25094464f, 0.06412327f, -0.02248273f, 
    -0.05962856f, -0.04079197f, -0.06596628f, 0.13378598f, -0.11740979f, 0.21207751f, -0.21809961f, 0.09406125f, 
    0.20044400f, -0.09014013f, -0.12967142f, 0.34193018f, -0.01515572f, -0.11844521f, 0.08884080f, -0.05721401f, 
    -0.11470675f, -0.11978947f, -0.00282211f, 0.19092138f, -0.21937624f, -0.32876655f, -0.14609273f, 0.24964647f, 
    0.10189553f, 0.06511073f, -0.03015190f, 0.13132359f, -0.03845517f, 0.12588292f, -0.02382872f, -0.02467642f, 
    0.41562536f, 0.14745031f, -0.10247746f, -0.42377654f, -0.03707139f, -0.00177578f, -0.35746217f, -0.01312586f, 
    -0.08356834f, -0.15052526f, 0.11690366f, -0.18716942f, 0.33275187f, 0.02435078f, 0.17409316f, -0.33800593f, 
    -0.16556615f, -0.05813298f, 0.07552379f, -0.17146271f, -0.12944223f, -0.10265320f, -0.04563347f, -0.10481033f, 
    0.23089524f, 0.10249050f, -0.41278735f, -0.53533888f, 0.12938344f, 0.08582707f, 0.02346546f, 0.03881975f, 
    -0.07220071f, -0.07690667f, -0.25440750f, -0.03825564f, 0.03889569f, -0.42818210f, -0.17735724f, -0.22731245f, 
    -0.17214409f, -0.14379108f, -0.04798089f, -0.10826109f, 0.04754164f, 0.29711956f, -0.44813457f, -0.20632412f, 
    -0.13200353f, 0.10944152f, -0.10125373f, -0.05130040f, -0.17751241f, 0.10029390f, -0.11300810f, 0.07197046f, 
    0.25933728f, 0.15862784f, -0.07403249f, 0.06532798f, 1.27545297f, -0.27716470f, 0.16168247f, 0.16286129f, 
    0.19952665f, -0.02657696f, -0.04964039f, 0.01266800f, -0.24304907f, 0.04091606f, 0.07598774f, -0.03962610f, 
    0.47836360f, -0.43062946f, -0.01072194f, 0.37661859f, -0.03431685f, -0.18947981f, -0.04349622f, -0.03847287f, 
    0.04365538f, 0.13388664f, 0.18619549f, 0.27310732f, -0.87479842f, 0.74206144f, -0.46763372f, 0.27949125f, 
    0.02662936f, -0.00590636f, 0.01168953f, -0.06522746f, -0.20458698f, -0.14251316f, 0.10130432f, -0.21993344f, 
    0.07291539f, -0.20327368f, -0.15745178f, 0.17714672f, 0.27412647f, 0.06243395f, 0.02561003f, -0.08971675f, 
    -0.17577031f, -0.05437128f, -0.03024124f, 0.09962292f, 0.18955497f, -0.58627510f, 0.14096926f, -0.55211383f, 
    -0.30226126f, 0.06210918f, -0.15325968f, 0.05500860f, -0.00785147f, -0.11892541f, -0.05865886f, -0.39129454f, 
    -0.15911557f, 0.34318760f, -0.15170805f, 0.09929425f, -0.15178728f, -0.10270824f, -0.19501653f, -0.04203120f, 
    -0.10510358f, 0.14906390f, 0.16505705f, -0.00777677f, -0.10647543f, 0.05059296f, 0.20271532f, 0.17590684f, 
    -0.26052776f, -0.03997419f, -0.13955569f, -0.20301932f, -0.02156507f, -0.22486107f, 0.15820079f, -0.12753093f, 
    -0.25128639f, 0.07482766f, -0.18233171f, 0.17368890f, 0.05653348f, 0.11714551f, 0.05287713f, 0.18666503f, 
    -0.00598194f, -0.00615648f, -0.02985436f, 0.06856546f, 0.08079942f, 0.20129898f, 0.05003222f, 0.37418693f, 
    0.07039105f, -0.02231987f, 0.02935362f, -0.07633076f, -0.00154243f, 0.06004760f, -0.02844347f, 0.25433877f, 
    -0.01628923f, -0.27858993f, 0.24885049f, 0.42721045f, 0.07884616f, 0.03938359f, -0.05687612f, -0.17468362f, 
    0.18700682f, 0.06675812f, 0.00199125f, 0.14571770f, 0.20046203f, 0.11859321f, -0.48182565f, -0.05657240f, 
    0.08475892f, -0.09425544f, 0.05919195f, -0.12238701f, -0.42252022f, -0.21086769f, 0.03723069f, 0.11419110f, 
    0.01630783f, -0.55322802f, 0.50638235f, -0.10559741f, -0.40865529f, -0.22005565f, -0.28787157f, 0.09649466f, 
    -0.05443644f, 0.20993529f, -0.10077114f, 0.12472971f, 0.18432447f, -0.04299350f, 0.25211689f, 0.35046342f, 
    0.12414265f, 0.00949158f, -0.34640321f, 0.04708745f, 0.03154413f, -0.11626770f, -0.03479456f, -0.15990987f, 
    -0.67194229f, -0.10596408f, -0.56640780f, 0.26781282f, 0.35421312f, -0.04423551f, -0.02740395f, -0.03408642f, 
    -0.12085101f, 0.06436555f, 0.03497892f, -0.02329923f, -0.01165599f, -0.04934322f, -0.18429728f, -0.18065596f, 
    -0.00549803f, -0.04613764f, -0.07075703f, -0.18210888f, -0.05792741f, 0.11168156f, 0.10817616f, 0.06263549f, 
    0.06714882f, 0.48386976f, 0.04106921f, -0.69532061f, -0.28051737f, -0.09231117f, -0.08229514f, 0.31192532f, 
    0.08708404f, -0.21725497f, 0.19952567f, 0.25942749f, -0.25506827f, -0.20296665f, 0.14104997f, 0.16895264f, 
    0.26731431f, 0.19192967f, 0.15199357f, -0.02880310f, -0.14075513f, 0.14834665f, -0.00324618f, 0.00275612f, 
    -0.14281550f, -0.18228687f, 0.44249678f, -0.25773877f, 0.14101344f, 0.13973267f, -0.08014350f, -0.11765610f, 
    0.04910510f, -0.35035446f, 0.16468066f, 0.09975976f, 0.18678819f, 0.09603691f, -0.08284452f, -0.14250231f, 
    0.05495370f, 0.07352347f, 0.09748434f, 0.08038234f, 0.00605376f, 0.08477273f, -0.07344548f, -0.08064791f, 
    0.35355181f, -0.71648604f, 0.03019571f, -0.29301471f, 0.03337855f, 0.01950737f, 0.05299847f, -0.01142929f, 
    -0.02251751f, 0.01822623f, -0.12417368f, -0.21962456f, -0.03274341f, -0.10959169f, 0.28827539f, 0.30911690f, 
    -0.02015183f, 0.05334627f, -0.03488166f, 0.08074610f, -0.08816108f, -0.06417717f, 0.08889381f, 0.07742728f, 
    -0.04179417f, 0.32354903f, -0.51732564f, 0.20051508f, 0.12275805f, -0.17959568f, -0.16472863f, -0.25617620f, 
    0.10778666f, 0.09959526f, -0.05779398f, -0.05569567f, 0.17114104f, 0.47580308f, 0.44108957f, 0.43088239f, 
    -0.00768519f, 0.18345886f, 0.06189916f, 0.18543781f, 0.04020580f, -0.09037200f, -0.13867731f, -0.04719492f, 
    -0.21313256f, -0.16726907f, 0.53170139f, 0.16305186f, -0.01707835f, 0.05699202f, -0.19812192f, 0.15880367f, 
    0.01591066f, 0.02817302f, -0.04108348f, 0.09102564f, 0.04115438f, -0.11442484f, 0.07382359f, -0.08602119f, 
    -0.02001905f, -0.18326280f, 0.06235126f, -0.34186122f, 0.10481979f, 0.01048013f, -0.01528569f, -0.01823248f, 
    -0.13142464f, 0.20950098f, -0.00828009f, 0.17564213f, -0.19799030f, -0.12782496f, -0.26969475f, -0.09161761f, 
    -0.02201171f, -0.17575119f, -0.04435938f, -0.03700143f, 0.07059047f, 0.05401850f, 0.07847813f, 0.07825217f, 
    0.02494980f, -0.09165435f, 0.06330074f, -0.07104398f, -0.05605970f, -0.19516611f, -0.00277542f, 0.01859881f, 
    -0.31339812f, -0.53784436f, -0.09049628f, -0.10335916f, 0.12838973f, -0.01217054f, -0.05846346f, -0.06027547f, 
    -0.05684032f, -0.11567925f, -0.03693905f, 0.05439789f, -0.36606815f, -0.25025833f, -0.29611844f, -0.43282872f, 
    0.09200106f, 0.00740151f, 0.08949637f, 0.11343189f, -0.01670890f, -0.00763979f, -0.13903642f, -0.16126011f, 
    -0.08469214f, 0.47312936f, 0.01174085f, 0.28975916f, 0.09599914f, -0.17128873f, -0.19475840f, -0.19470003f, 
    -0.24598812f, -0.10727742f, 0.01471767f, 0.00567644f, 0.12592541f, -0.05344659f, 0.00970818f, 0.00767180f, 
    0.08327533f, 0.01281907f, 0.04543980f, 0.10431511f, 0.02643849f, -0.00591855f, -0.04035423f, -0.29262164f, 
    0.13360700f, -0.12566443f, -0.04785902f, 0.06199232f, 0.00231176f, -0.06569932f, 0.02268923f, -0.00483156f, 
    0.13297176f, 0.22576414f, 0.31555745f, 0.43904597f, -0.29558507f, -0.00959758f, -0.02186128f, 0.09687761f, 
    -0.17644699f, -0.25217098f, 0.07599035f, 0.04184610f, 0.03281712f, 0.09497920f, 0.13027337f, 0.02689048f, 
    -0.18220580f, -0.09021734f, -0.03290235f, 0.12726897f, -0.01661671f, -0.08586381f, -0.13022731f, -0.06132028f, 
    0.03821551f, 0.07144252f, 0.04032829f, 0.15943365f, 0.08736879f, -0.28919536f, -0.34232470f, -0.40903732f, 
    0.09679944f, -0.07245010f, -0.07385364f, -0.14348146f, -0.19038279f, -0.23000337f, -0.37481058f, 0.10510293f, 
    0.03590105f, 0.47018361f, -0.09258990f, 0.12163512f, -0.09741972f, -0.17043079f, 0.03299981f, 0.06929649f, 
    -0.10271738f, -0.03654098f, -0.12693709f, 0.10225197f, 0.07282391f, -0.06541946f, -0.06016717f, 0.06551377f, 
    0.09798662f, -0.08377701f, -0.06241067f, -0.05752524f, 0.12860705f, -0.07664690f, -0.06339871f, 0.04669039f, 
    0.26349542f, -0.20791033f, -0.14254452f, -0.15323633f, -0.22523189f, -0.02743439f, 0.07049029f, -0.07567933f, 
    -0.00426152f, 0.20085762f, -0.06433322f, 0.26180238f, 0.11125320f, 0.12723202f, 0.02247784f, -0.02330322f, 
    0.20642981f, -0.19554605f, 0.10644677f, 0.00793825f, -0.14935277f, -0.04334843f, -0.23406509f, -0.25924388f, 
    -0.11915892f, -0.04022292f, 0.18972994f, 0.09826694f, -0.15739547f, -0.10798833f, -0.29082197f, -0.03412355f, 
    -0.11766281f, 0.01271879f, 0.01809363f, 0.03785966f, -0.06817342f, -0.09400769f, 0.09490020f, 0.17898758f, 
    0.04117987f, 0.16197886f, -0.10566341f, -0.07114065f, 0.10446768f, 0.03248325f, -0.01604580f, 0.13000424f, 
    0.16482177f, 0.22666566f, -0.04045069f, 0.05262603f, 0.08336649f, 0.07673848f, -0.06218506f, -0.07984184f, 
    -0.10505782f, -0.33198047f, 0.03821096f, 0.00784460f, -0.28054327f, -0.46900007f, -0.09293698f, 0.07989211f, 
    -0.13948232f, 0.08230826f, -0.09663738f, 0.03063581f, -0.25587463f, 0.01803122f, -0.06356611f, -0.12155263f, 
    0.39929453f, 0.17308384f, -0.40635920f, 0.07783560f, -0.07139359f, 0.04648842f, 0.14901736f, -0.05066916f, 
    0.14713173f, -0.04553327f, 0.07381228f, -0.08048644f, -0.34663653f, 0.12073039f, -0.03940194f, -0.32234746f, 
    -0.04788966f, 0.02649842f, 0.03688056f, 0.08090021f, 0.03374700f, -0.08934984f, 0.04421333f, 0.06304897f, 
    0.04225756f, -0.09357198f, -0.03624585f, -0.02278092f, 0.14096229f, 0.03944213f, -0.01560099f, 0.09286115f, 
    0.04992944f, 0.11545388f, -0.21167478f, 0.01577807f, -0.05569455f, -0.03014739f, -0.05881291f, 0.21017176f, 
    -0.18735589f, 0.07522459f, 0.08419573f, 0.15463260f, 0.05181502f, 0.15344138f, -0.02901394f, 0.09885950f, 
    0.04265340f, -0.33534959f, -0.48065674f, 0.02579273f, 0.17115502f, 0.14215089f, 0.00207641f, 0.04918393f, 
    -0.07766978f, 0.04027504f, -0.14031000f, -0.16272683f, 0.19785108f, 0.36365125f, 0.03990717f, 0.08810642f, 
    0.07050193f, -0.05290853f, 0.07378866f, 0.04112768f, 0.14430305f, -0.05765089f, -0.12587488f, 0.19030790f, 
    -0.18447343f, -0.01648417f, -0.16693899f, -0.25364920f, -0.20519644f, -0.16206253f, -0.08509628f, -0.08870251f, 
    -0.35401100f, 0.05562906f, 0.00675317f, -0.22499257f, -0.13620010f, -0.11290283f, -0.29853937f, 0.15375277f, 
    0.05607798f, -0.13467471f, -0.11234666f, -0.04264205f, 0.11889030f, 0.05777416f, 0.26688382f, 0.21945457f, 
    0.05981259f, -0.56487221f, 0.14718123f, 0.15080760f, -0.04381940f, 0.00246057f, 0.10638119f, -0.11429330f, 
    0.21562706f, -0.26648712f, 0.41003785f, 0.01214340f, -0.03003702f, 0.43156603f, 0.17555140f, -0.11237263f, 
    0.22780588f, 0.04313878f, 0.27706358f, -0.19303265f, 0.11073186f, 0.02940550f, 0.04018692f, -0.03905111f, 
    -0.00917233f, -0.00679873f, -0.57730442f, 0.08843296f, 0.08150203f, 0.27102074f, 0.06039212f, 0.12622954f, 
    0.04066526f, -0.03866234f, 0.08956142f, -0.08355415f, 0.01321094f, -0.00137692f, 0.13636741f, 0.01964962f, 
    0.25830293f, 0.06186436f, -0.13130125f, -0.01731681f, 0.05166451f, 0.05678786f, 0.05593845f, -0.00607871f, 
    0.10240540f, -0.11569759f, -0.01850342f, -0.13820067f, -0.17063081f, -0.10776918f, 0.20425400f, 0.09574880f, 
    0.13407314f, -0.03336269f, -0.13382022f, 0.01983898f, 0.00546407f, -0.13536140f, 0.03684245f, -0.03797621f, 
    0.32655376f, 0.24299587f, 0.21137491f, -0.09459373f, 0.12356351f, 0.05401373f, 0.04953443f, 0.12817098f, 
    -0.12988064f, 0.13473974f, 0.04226207f, -0.16563472f, 0.14044721f, -0.04675198f, 0.02933542f, 0.07196987f, 
    0.07933310f, 0.06914013f, 0.04281940f, -0.16527604f, -0.00484602f, -0.10383372f, -0.17262979f, -0.11371751f, 
    -0.00312143f, 0.06412460f, -0.00295607f, 0.20578666f, -0.03025222f, -0.11962379f, -0.08748074f, 0.00240541f, 
    -0.24837901f, 0.04848814f, -0.21932325f, 0.42925951f, -0.09369348f, -0.04017893f, -0.12607019f, -0.08318000f, 
    0.09512553f, 0.08692639f, -0.00745686f, -0.09939290f, 0.40148529f, -0.37233865f, -0.04253918f, 0.21027650f, 
    0.04935578f, -0.00643035f, 0.05284466f, 0.02613154f, -0.02929113f, 0.08063845f, 0.03816137f, 0.17194213f, 
    0.05394514f, -0.00736866f, 0.71567827f, -0.19465746f, -0.37762976f, 0.02652324f, 0.14838375f, 0.01332645f, 
    0.16121295f, -0.04045724f, -0.05050061f, 0.04456292f, 0.04834336f, -0.12399781f, -0.13638972f, 0.05872369f, 
    0.14423151f, -0.18076627f, 0.00279868f, -0.02664637f, 0.07815164f, -0.26151520f, 0.15811892f, 0.13093591f, 
    0.19060411f, -0.16634855f, -0.05387433f, -0.02636514f, 0.06295114f, 0.04419292f, 0.04221589f, 0.09138993f, 
    0.11909976f, -0.41884434f, -0.21193215f, -0.70906204f, -0.38058990f, -0.34471551f, -0.39356497f, -0.01666571f, 
    0.15410711f, -0.19320343f, -0.02541110f, 0.18003343f, -0.13140656f, -0.03441526f, -0.11844666f, 0.13691534f, 
    -0.44395149f, 0.22502549f, -0.09467959f, -0.39436111f, 0.01573155f, -0.16135605f, 0.11510260f, 0.09806897f, 
    -0.07023363f, -0.08708967f, -0.00351007f, 0.05455813f, -0.07604697f, 0.05436791f, -0.28752139f, -0.51400179f, 
    0.25386792f, -0.05955541f, 0.01922705f, 0.18078984f, 0.14102356f, 0.09698591f, -0.22278985f, -0.09271327f, 
    -0.65287942f, -0.47962964f, 0.07440259f, -0.17329229f, -0.06630336f, 0.02936295f, -0.10439658f, -0.01378588f, 
    0.26852411f, -0.03962416f, 0.06646576f, 0.01016905f, -0.26862046f, -0.01989531f, 0.02542332f, 0.27695453f, 
    0.11827245f, 0.02317235f, 0.17916268f, -0.05612417f, 0.13068068f, 0.01713697f, 0.03681525f, 0.18057957f, 
    0.07006074f, -0.33235973f, 0.08777298f, 0.23056930f, 0.15209375f, -0.01182443f, -0.02819531f, 0.02563388f, 
    0.11056871f, -0.24035971f, -0.26768771f, -0.15981466f, -0.03448131f, -0.21903338f, -0.11866982f, 0.05536931f, 
    -0.12274566f, 0.09364202f, 0.10778970f, -0.06979220f, 0.18012190f, -0.02713309f, 0.15400076f, 0.29473668f, 
    0.17312703f, 0.30171397f, 0.22700439f, -0.07295594f, 0.07879345f, 0.08117873f, -0.04338256f, -0.07834591f, 
    -0.02710375f, -0.00402164f, -0.01918678f, 0.03917443f, 0.14824012f, -0.05140833f, -0.05364992f, -0.19154969f, 
    -0.20383243f, -0.13156494f, -0.00505501f, -0.20437504f, 0.14836325f, 0.04183498f, -0.00620334f, 0.02816606f, 
    0.00041724f, 0.04843061f, -0.14573325f, -0.16458754f, -0.07311801f, 0.15410320f, -0.11846464f, -0.20031409f, 
    0.22411428f, 0.23467869f, 0.13979961f, -0.25013340f, -0.40077728f, 0.39747444f, 0.33685505f, -0.12770462f, 
    0.04128672f, -0.22193114f, 0.13314731f, 0.05062627f, 0.03170063f, -0.06545258f, -0.03953473f, 0.05864484f, 
    -0.02379413f, -0.03993110f, -0.52672082f, 0.10236136f, 0.09135125f, 0.26280499f, -0.04599865f, 0.07844879f, 
    0.09428212f, -0.06102320f, 0.08189191f, -0.11115094f, 0.29067698f, -0.08534440f, 0.00849847f, 0.21101035f, 
    -0.00684829f, 0.12134416f, 0.09841662f, 0.01489858f, 0.07081661f, 0.02984809f, 0.03235211f, 0.12595437f, 
    -0.18876685f, -0.24180855f, -0.20190845f, 0.03663247f, -0.00449132f, -0.03940788f, -0.08457053f, -0.03807144f, 
    0.05020564f, -0.06977537f, 0.07163145f, 0.31094605f, -0.07189394f, -0.20991111f, 0.42757252f, -0.13642740f, 
    0.05155747f, -0.11124250f, -0.10644780f, 0.07635510f, 0.06318063f, -0.29976296f, -0.22718382f, -0.21133108f, 
    -0.66671968f, 0.25300035f, -0.35035750f, 0.20290241f, -0.04700876f, 0.02411128f, -0.08006071f, -0.10268218f, 
    0.03578394f, -0.00453020f, -0.04197159f, 0.14725326f, -0.20587404f, -0.15437903f, -0.61365575f, -0.15999873f, 
    0.09101668f, 0.10391541f, -0.02456432f, 0.03855088f, 0.13745870f, 0.11250568f, 0.06487837f, -0.17588031f, 
    -0.32326779f, 0.07661378f, -0.01471601f, 0.04502951f, 0.03424263f, -0.02410810f, 0.09287628f, -0.10226823f, 
    0.05567126f, 0.20364627f, -0.00769714f, 0.10193799f, 0.13732824f, -0.07875869f, -0.02379947f, -0.05479924f, 
    0.06084870f, -0.06625308f, -0.01207447f, 0.00432602f, -0.07455701f, -0.10910458f, -0.12974571f, -0.12318294f, 
    -0.15704945f, -0.01775346f, 0.08928613f, -0.21717861f, 0.01482461f, 0.04168703f, -0.02775563f, 0.00353642f, 
    0.01755562f, -0.03956442f, 0.18223284f, -0.06011461f, -0.57162458f, -0.97345847f, -0.47517717f, -0.01447259f, 
    -0.10585377f, -0.19893140f, -0.23723318f, -0.41221052f, -0.07272109f, 0.02705674f, -0.01738616f, -0.14035894f, 
    0.51244611f, -0.17371725f, 0.08133564f, -0.24733917f, -0.06722704f, 0.09940643f, 0.34329799f, -0.17856289f, 
    0.05325603f, 0.08799155f, -0.13519880f, 0.06054063f, -0.22392002f, -1.48380518f, -1.46868324f, -0.35837317f, 
    -0.22418168f, -0.07167274f, 0.19535293f, -0.37159738f, 0.01153867f, -0.06520589f, -0.01637653f, 0.05526675f, 
    -0.89668661f, -0.52651674f, -0.11019371f, 0.33755884f, 0.26394871f, 0.24722163f, 0.04133812f, -0.06504258f, 
    0.02590369f, -0.01761483f, 0.02387629f, 0.06012363f, -0.18948036f, -0.19975354f, -0.17462710f, -0.16737141f, 
    0.01580272f, -0.36953059f, 0.02233047f, -0.36073419f, -0.03651122f, -0.11164320f, -0.05938523f, -0.11929825f, 
    0.89049298f, 0.13251853f, -0.21668914f, 0.42607707f, 0.03562003f, -0.03080297f, -0.02720432f, 0.23241931f, 
    0.12329704f, -0.07883504f, 0.18362500f, 0.09349963f, 0.05455510f, 0.36478418f, 0.15170835f, 0.01754892f, 
    -0.13820077f, -0.08892867f, -0.06225851f, -0.05632462f, 0.04132891f, 0.11348477f, -0.02533960f, 0.11037855f, 
    -0.12675847f, 0.12760416f, 0.02832460f, -0.02868475f, 0.13001312f, 0.16247869f, -0.00428427f, 0.02577916f, 
    0.08881865f, -0.06457622f, 0.10535903f, 0.06421998f, 0.08415229f, 0.08262721f, -0.43238419f, 0.26215172f, 
    -0.05322881f, -0.04998884f, -0.02224184f, -0.00109012f, -0.08871482f, -0.03784504f, 0.17198782f, -0.33519372f, 
    -0.81560498f, -0.92316592f, -0.01338633f, 0.49033189f, 0.01365341f, -0.14669652f, -0.10011615f, 0.20393634f, 
    0.11429650f, 0.10085037f, 0.05138375f, -0.05318398f, 0.18633285f, 0.07373770f, -0.18319672f, -0.11097960f, 
    -0.07049815f, -0.07116589f, 0.16602539f, 0.00031674f, 0.04884595f, -0.01683818f, -0.26138213f, -0.15444294f, 
    0.06290989f, 0.03367267f, -0.01154397f, -0.02635124f, -0.05378097f, 0.02406912f, 0.06336068f, 0.06719671f, 
    0.07422718f, 0.18243907f, 0.07120746f, 0.14432985f, -0.28524041f, 0.00178160f, 0.17344505f, 0.37174267f, 
    -0.19613694f, -0.04668845f, 0.15160955f, 0.18234110f, 0.02548284f, 0.01018720f, 0.02973181f, -0.02879262f, 
    -1.26279056f, -1.07460201f, -0.39724752f, 0.02629822f, -0.15130414f, -0.11992116f, -0.05591279f, -0.26765922f, 
    0.01592075f, 0.00562411f, 0.01339031f, 0.03545931f, -0.09649971f, 0.26496348f, 0.12097659f, 0.09370168f, 
    0.08996274f, 0.11097966f, 0.03506882f, -0.13673158f, 0.19697337f, -0.03521789f, 0.28826618f, -0.10392112f, 
    -0.44929901f, 0.14584936f, 0.37705797f, 0.49815485f, 0.02632033f, -0.31730306f, 0.22058766f, 0.13665433f, 
    -0.09643531f, 0.19839649f, 0.07017122f, -0.11488253f, 0.05947604f, 0.04889600f, 0.15656631f, 0.06264004f, 
    -0.00302553f, 0.07368739f, -0.05199977f, -0.13982348f, 0.03088757f, -0.19896214f, 0.29284939f, -0.21725714f, 
    -0.18463923f, 0.10419164f, -0.28963432f, -0.11087897f, -0.02684286f, 0.16570324f, -0.04985740f, 0.10372340f, 
    0.18734579f, 0.14196256f, 0.20361429f, 0.00989069f, -0.12870699f, -0.06941760f, 0.02809029f, -0.03496431f, 
    -0.02320886f, -0.25697979f, 0.23937495f, -0.16914183f, 0.03996894f, -0.15141200f, -0.08709397f, 0.13828932f, 
    -0.97988367f, -0.74795640f, -0.46860245f, 0.18676594f, -0.03762412f, -0.34717163f, 0.05193995f, -0.21881953f, 
    -0.08170382f, 0.07722753f, 0.01825668f, -0.00258366f, -0.67209327f, -0.56748849f, -0.41194370f, -0.45076814f, 
    -0.14372641f, -0.33075610f, 0.01854360f, 0.22107185f, 0.01772049f, -0.07227143f, 0.10623342f, -0.01901455f, 
    0.00115876f, 0.25931686f, 0.10974488f, -0.24746002f, -0.03541774f, -0.16704904f, -0.22798374f, 0.11390588f, 
    0.11635857f, 0.15435973f, -0.07765456f, -0.04089330f, -0.08904341f, -0.17636493f, -0.13192469f, 0.35995919f, 
    0.06095294f, -0.08361775f, 0.17136502f, 0.05131053f, 0.03066201f, 0.17985891f, 0.40544498f, 0.09443060f, 
    0.26665333f, -0.02899763f, 0.03614057f, -0.76242089f, -0.02778201f, 0.18994042f, 0.07817262f, -0.09517159f, 
    -0.01728610f, 0.04732507f, -0.06785083f, 0.03516103f, -1.12844276f, -0.02643650f, 0.10795835f, -0.34842515f, 
    0.06260397f, -0.02405966f, 0.06774176f, 0.02016853f, 0.06162948f, -0.07893568f, 0.06038653f, -0.03831650f, 
    0.25785187f, 0.11557715f, -0.01659433f, 0.02021303f, -0.00711224f, -0.04968052f, 0.00020392f, -0.01799619f, 
    0.08349916f, -0.06084495f, -0.08481517f, -0.00231969f, -0.07122630f, 0.14537859f, -0.14356759f, -0.22262083f, 
    -0.15740794f, -0.04154838f, 0.00996630f, 0.19517893f, -0.04883445f, 0.05560997f, 0.30227092f, 0.11452097f, 
    -0.12577942f, -0.03694281f, 0.13883127f, -0.12024081f, 0.06412072f, 0.11798401f, -0.05945391f, 0.02578259f, 
    -0.10742459f, -0.00591148f, 0.00117810f, -0.16265388f, -0.24259190f, 0.15105449f, 0.12569216f, 0.07902892f, 
    -0.09094398f, 0.00867853f, -0.08422173f, -0.00968155f, 0.01872298f, -0.13492592f, 0.18926035f, 0.13963352f, 
    -0.01817147f, 0.01748933f, 0.14489952f, 0.14303000f, -0.00747809f, -0.08715105f, 0.02603166f, -0.18017344f, 
    -0.15696390f, 0.07264692f, 0.21478753f, 0.12795696f, 0.05042282f, 0.02928800f, -0.00496461f, -0.12507512f, 
    -0.00880523f, -0.00937396f, 0.02048603f, -0.01435074f, 0.02271519f, 0.05994816f, -0.11357225f, -0.18889242f, 
    0.28516519f, 0.10984435f, -0.10008872f, -0.39858463f, -0.04242997f, -0.00048605f, 0.09476509f, 0.03106734f, 
    0.02781009f, 0.09090966f, -0.26932099f, -0.50507498f, -0.59637767f, 0.06199531f, 0.10716376f, 0.43861115f, 
    0.11786705f, -0.37932804f, -0.14292191f, 0.13384326f, -0.04237342f, -0.06722029f, -0.07136303f, -0.03124978f, 
    -0.22033036f, 0.33869380f, 0.05461631f, -0.01299631f, -0.12915598f, -0.03280801f, 0.04317547f, 0.17952795f, 
    0.01009232f, -0.23156017f, 0.14745180f, 0.01127885f, -1.13363957f, 0.18422055f, -0.21057683f, 0.45903334f, 
    0.04967205f, 0.00973586f, 0.01906784f, -0.05585644f, -0.01664055f, -0.01241350f, -0.03583797f, 0.05031686f, 
    -0.13286223f, -0.10023399f, 0.14570755f, -0.18795708f, 0.00696467f, 0.04985055f, 0.15166499f, -0.03335826f, 
    0.05583036f, 0.11750838f, 0.02210000f, -0.09067461f, 0.12109735f, -0.04094077f, 0.25924665f, -0.11156879f, 
    -0.25504288f, 0.08395450f, -0.16247459f, -0.03093215f, 0.08436111f, -0.00535830f, 0.05203709f, -0.05607146f, 
    -0.10931194f, -0.17318957f, -0.90119970f, 0.01222045f, -0.13348779f, 0.00047962f, 0.24515335f, -0.05701344f, 
    -0.08761998f, -0.08467355f, 0.07120249f, 0.02200407f, -0.03813469f, -0.44779959f, -0.19625331f, -0.21529150f, 
    -0.03192643f, -0.02493820f, -0.05216832f, 0.14309157f, -0.08274944f, 0.04384685f, 0.14475429f, -0.02461763f, 
    0.07987284f, 0.15225664f, -0.39736277f, 0.08822463f, -0.01714247f, -0.09830052f, 0.05100423f, -0.06867172f, 
    -0.02620217f, 0.08713520f, -0.08913046f, -0.10869141f, 0.04057891f, 0.05404724f, 0.06037171f, -0.10654654f, 
    0.02178753f, 0.08481475f, -0.03790952f, -0.05490678f, -0.01306889f, 0.06318609f, -0.04891226f, -0.04585318f, 
    0.83875674f, -1.44178271f, 0.71817237f, 0.21324401f, 0.04716244f, 0.28342897f, 0.09868906f, -0.08566172f, 
    -0.04455006f, 0.01552392f, 0.21520935f, -0.12750778f, 0.00520826f, 0.05376268f, -0.04330987f, -0.04737985f, 
    -0.01031089f, -0.06160242f, 0.01872559f, -0.10423270f, -0.43085921f, -0.24715783f, -0.10570322f, 0.16786067f, 
    0.10888796f, -0.02233649f, 0.06061983f, -0.14239025f, 0.02636079f, -0.07334726f, -0.03049099f, 0.01492812f, 
    0.19201027f, 0.09596091f, 0.25870836f, 0.16178903f, 0.35956690f, -0.05725105f, -0.07100202f, -0.01623695f, 
    -0.12199718f, -0.02388044f, -0.14121851f, -0.21215020f, -0.04576065f, -0.00111368f, 0.00492008f, 0.10330071f, 
    -0.47254157f, -0.50446767f, -0.56839991f, -0.45518669f, 0.03592710f, 0.05625136f, 0.17282492f, 0.18116134f, 
    0.12015446f, -0.05283182f, -0.08658695f, -0.05057688f, -0.20646760f, 0.11745627f, 0.13980047f, 0.09769556f, 
    -0.01940324f, 0.08505487f, 0.07886229f, -0.04110833f, 0.04029241f, -0.00247253f, -0.10830420f, -0.06034102f, 
    0.72965270f, -0.87860185f, -0.78876394f, -0.77275872f, -0.07038840f, 0.14135833f, 0.00342911f, 0.20826295f, 
    0.04404876f, 0.15637222f, -0.02142850f, 0.01858954f, -0.01128020f, 0.14125250f, 0.02168044f, -0.04518007f, 
    -0.02996031f, -0.03443625f, -0.12527083f, -0.01626805f, 0.02852452f, 0.05929383f, -0.05607544f, -0.07533349f, 
    0.55106825f, -0.54716504f, 0.26880366f, -0.11178271f, -0.07328774f, -0.01708708f, -0.02860501f, -0.06495420f, 
    0.03952425f, -0.03161725f, -0.09459608f, 0.17283483f, 0.10364747f, 0.05202403f, 0.01339471f, -0.09413711f, 
    -0.11993741f, -0.00488694f, 0.01123307f, 0.01942817f, 0.08024885f, -0.05189520f, -0.02156238f, -0.08301199f, 
    -0.17811222f, 0.18582325f, 0.15555014f, -0.01112014f, -0.11322377f, -0.20686820f, -0.04044417f, 0.34870130f, 
    -0.07681981f, -0.12898864f, -0.14626230f, 0.09167939f, -0.35656449f, -0.66508842f, -0.29665676f, -0.18310946f, 
    -0.09990953f, -0.01201107f, 0.14621916f, -0.06488772f, -0.05452510f, 0.05874220f, 0.03305421f, 0.18132295f, 
    -0.05669216f, 0.14389180f, 0.10883680f, 0.10071795f, -0.02284455f, -0.06187305f, 0.11419361f, -0.04519368f, 
    -0.01579989f, -0.11846759f, 0.09723031f, 0.07129295f, 0.28682458f, -0.79564464f, -0.01910604f, -0.28024268f, 
    0.10722443f, -0.04551996f, -0.18190518f, 0.14421543f, -0.17776024f, -0.04927545f, 0.18918760f, -0.16693257f, 
    -0.36133039f, 0.36954337f, -0.27983496f, 0.08730885f, -0.03421395f, -0.02698399f, -0.11491475f, -0.06986573f, 
    0.06726392f, -0.00386955f, 0.07567911f, 0.04256139f, 0.04034140f, 0.28209767f, -0.09525979f, -0.18539503f, 
    0.01919714f, -0.04020635f, 0.07798789f, -0.12319588f, 0.04378250f, 0.07848793f, -0.00778609f, -0.04978464f, 
    0.02469379f, -0.00282138f, 0.00689362f, -0.07764541f, 0.01313843f, 0.05461234f, -0.01148281f, -0.04969439f, 
    -0.01388782f, 0.08992650f, -0.01121656f, -0.13808236f, 0.53068334f, -0.68170768f, -0.18282062f, -0.27023342f, 
    -0.04805652f, -0.09408505f, -0.10654161f, -0.05878396f, 0.06665389f, -0.03686604f, -0.15683568f, -0.02026044f, 
    -0.02860412f, 0.15902111f, -0.18058152f, 0.13168779f, -0.02558822f, -0.02208618f, 0.10830042f, -0.06154731f, 
    0.01724010f, 0.07109518f, -0.15114285f, -0.16512854f, 0.42499936f, -0.57627332f, -0.19153246f, -0.20253348f, 
    -0.00575890f, -0.04705424f, -0.04560886f, 0.05702574f, 0.19839349f, 0.06796322f, 0.11389261f, 0.11086684f, 
    -0.19679734f, -0.32996783f, -0.04593481f, 0.08938146f, -0.07317282f, 0.02828209f, -0.00385418f, -0.25784683f, 
    -0.18107879f, -0.12177502f, -0.18094482f, -0.04538899f, -0.14385647f, 0.15555215f, 0.15269968f, -0.13322966f, 
    -0.02369603f, 0.05119162f, 0.05745706f, -0.03523832f, -0.05505043f, 0.11282785f, 0.05904404f, 0.13627572f, 
    -0.12089749f, 0.09728936f, -0.18239434f, -0.30143705f, -0.07717693f, -0.02409191f, 0.01793990f, -0.07887905f, 
    0.01689668f, 0.23625784f, 0.03498359f, 0.39937472f, 0.30526552f, -0.47804081f, -0.63699579f, -0.67186219f, 
    -0.33351034f, -0.10556998f, 0.08021663f, -0.03213644f, 0.05204722f, 0.05083647f, -0.02872382f, 0.05671936f, 
    -0.79048693f, 0.14021665f, 0.20672034f, 0.30188224f, -0.01615323f, -0.06586503f, -0.31611693f, 0.15610947f, 
    -0.09456638f, 0.03269499f, 0.03999365f, -0.05240910f, 0.11029738f, -0.08368141f, 0.30631658f, -0.11742234f, 
    0.12786703f, -0.05082956f, 0.14172366f, -0.01813036f, 0.00365271f, 0.07194612f, 0.08701643f, 0.06425893f, 
    0.20696658f, 0.19130175f, 0.10645757f, -0.19012780f, -0.11071287f, -0.03759269f, -0.09017233f, -0.38914967f, 
    0.03139760f, 0.04124313f, -0.01968491f, 0.04735732f, -0.07076719f, -0.05645809f, -0.14672638f, 0.09415454f, 
    -0.07732657f, -0.25944796f, -0.22681606f, 0.02821729f, -0.04834937f, 0.12061888f, 0.14742030f, 0.10225977f, 
    -0.46438852f, -0.56946218f, -0.09112232f, 0.34345454f, 0.09122855f, 0.17995639f, 0.04451469f, 0.22047943f, 
    -0.21704079f, 0.12249400f, 0.13634823f, -0.04304105f, -0.38471115f, -0.36708239f, -0.19389990f, 0.01918964f, 
    -0.00792061f, 0.06013051f, 0.07539075f, 0.22106647f, 0.04872007f, -0.32086784f, -0.08952720f, 0.02633245f, 
    0.11697111f, 0.13284864f, 0.12611023f, -0.14024985f, -0.19784661f, 0.04855504f, 0.00242207f, -0.02366718f, 
    -0.04547581f, 0.07450692f, -0.10837487f, 0.28445485f, 0.13539830f, 0.21566516f, 0.08998171f, -0.00113461f, 
    -0.05240114f, -0.12691441f, -0.10867379f, -0.09764404f, 0.05360863f, 0.01647563f, 0.10641678f, 0.11343590f, 
    0.71676207f, -0.44849870f, -0.56728673f, -0.55154729f, 0.20073965f, -0.16320851f, 0.13008924f, -0.13873051f, 
    0.02967696f, 0.24738647f, 0.18155788f, 0.09966458f, -0.17576380f, 0.03521762f, -0.02937248f, -0.01966783f, 
    0.00753907f, 0.00624237f, 0.04546899f, -0.07979631f, 0.03580635f, 0.03605594f, 0.10368136f, 0.13165499f, 
    -0.15366930f, -0.01225594f, -0.08804069f, -0.06419089f, -0.01212309f, -0.04305899f, -0.03143631f, -0.05384667f, 
    -0.17639124f, -0.16438994f, -0.49357498f, -0.36950663f, -0.23031895f, -0.28975487f, -0.42172214f, -0.15375830f, 
    -0.02067151f, 0.23485956f, 0.03856876f, 0.33156061f, 0.06307276f, -0.09600008f, 0.05058785f, -0.10812716f, 
    -0.22920159f, -0.84671485f, -0.83049685f, 0.20899050f, -0.10414542f, 0.13871014f, 0.14660200f, 0.00652673f, 
    -0.18593967f, -0.02884767f, -0.10405646f, -0.04975774f, -0.22457585f, -0.22220656f, 0.16324595f, -0.04817374f, 
    -0.16688275f, 0.00741485f, 0.05823711f, 0.03005549f, 0.06780743f, -0.00134937f, 0.12446060f, -0.05717364f, 
    -0.39731586f, -0.58945698f, 0.04614088f, 0.39658955f, -0.07246101f, 0.03635587f, 0.08482437f, 0.02652301f, 
    0.13794181f, -0.03330568f, 0.21428299f, 0.11204228f, -0.02183307f, 0.06203643f, 0.13124260f, -0.29458880f, 
    0.01721228f, -0.11970369f, 0.20044740f, 0.04590043f, -0.10170660f, 0.04997045f, 0.14156201f, 0.18033044f, 
    0.31897116f, 0.15788460f, 0.01271443f, -0.13129804f, 0.19816439f, -0.00464803f, 0.10146644f, -0.03247822f, 
    0.11651252f, 0.06228347f, -0.08212607f, -0.37998357f, -0.07203500f, 0.04472938f, -0.00916850f, -0.02443190f, 
    -0.07009894f, -0.07703608f, 0.09156381f, 0.03598687f, 0.11194678f, 0.08462471f, 0.11789452f, 0.17512850f, 
    0.40280280f, 0.18950047f, -0.67609620f, -0.31540093f, -0.23727231f, -0.04979948f, 0.12228410f, -0.21891688f, 
    0.02135247f, -0.00741065f, -0.00994652f, -0.01482547f, -0.38754490f, -0.55941164f, -0.50062710f, -0.12223192f, 
    0.05167003f, 0.15876742f, 0.06192308f, 0.06472502f, -0.01189152f, 0.01342531f, 0.04305140f, 0.21060298f, 
    -0.21724059f, -0.04488484f, -0.17796889f, -0.01930125f, -0.00719218f, 0.03383189f, 0.07057633f, 0.08805910f, 
    0.13983151f, 0.27428272f, 0.09545659f, 0.18946007f, 0.43311673f, 0.21907534f, 0.02814217f, -0.15401010f, 
    -0.07402582f, -0.02342292f, 0.18385264f, 0.02729423f, -0.01569739f, 0.08000481f, 0.32915658f, 0.01790359f, 
    -0.68095708f, 0.32890806f, 0.22248602f, 0.25681388f, 0.10820189f, -0.04496730f, -0.17477246f, 0.06068873f, 
    -0.08112761f, -0.05076348f, -0.09744785f, 0.01376159f, -0.30879569f, 0.16017085f, 0.33331695f, 0.11481538f, 
    -0.07834906f, -0.11827444f, -0.10833395f, -0.14529683f, -0.10747549f, -0.06886706f, 0.03331342f, -0.00591344f, 
    -0.25112328f, 0.07175925f, 0.06166100f, -0.04348256f, -0.03307742f, -0.05770862f, -0.10723154f, 0.03703027f, 
    0.04130145f, 0.01993685f, 0.21378839f, 0.15096478f, 0.08033829f, -0.31871113f, -0.20132920f, -0.02423582f, 
    0.22124945f, 0.06890938f, 0.21340454f, 0.07319680f, -0.00179559f, -0.13317409f, -0.08956604f, -0.39359498f, 
    -0.37682003f, -0.00246479f, 0.08170550f, -0.07627751f, -0.02991175f, -0.21197361f, -0.11023262f, 0.08765385f, 
    -0.08387528f, -0.13493749f, 0.04346887f, -0.16038574f, -0.38154045f, -0.20199682f, 0.18622556f, 0.08511135f, 
    -0.01465981f, 0.05797715f, -0.02912531f, 0.01215461f, -0.11927147f, -0.03810453f, -0.10035312f, -0.38470459f, 
    -0.21949951f, -0.52346456f, 0.05124465f, -0.23012696f, 0.16423127f, -0.01463268f, 0.18381973f, 0.18851565f, 
    -0.01964508f, 0.07093362f, -0.28607270f, 0.26411608f, -0.18014434f, 0.07434822f, 0.18198858f, 0.21697760f, 
    0.11490678f, 0.23155846f, 0.04940610f, -0.04463674f, 0.23333794f, 0.25878981f, -0.02697976f, -0.16367161f, 
    -0.38013348f, 0.20079549f, 0.08236247f, 0.52131003f, 0.12232327f, 0.05829284f, -0.40711975f, -0.10090130f, 
    0.02605171f, 0.09523598f, -0.02876128f, -0.18977338f, -0.61562002f, -0.03588006f, 0.19247913f, -0.28076053f, 
    -0.07852789f, -0.02711229f, -0.04194126f, 0.14993462f, 0.02560215f, 0.04801774f, 0.11256197f, 0.04017830f, 
    -0.01287631f, 0.40680349f, -0.23832645f, -0.18144663f, 0.01614016f, -0.03552545f, 0.17215383f, 0.08985086f, 
    0.07685821f, -0.07756019f, -0.16938046f, 0.02146343f, 0.10812954f, 0.11394005f, -0.65208185f, -0.06685895f, 
    0.11013120f, -0.16460891f, 0.00101879f, 0.10756054f, -0.06050902f, 0.05317778f, -0.01243418f, -0.00860133f, 
    0.48497456f, -0.98223001f, 0.41107151f, -0.35021678f, 0.32749292f, 0.06013316f, -0.32015577f, 0.22084965f, 
    0.04519892f, -0.06175938f, -0.04211191f, -0.10318313f, -0.18757699f, -0.02961970f, -0.31544855f, -0.20725380f, 
    -0.24713284f, -0.12546980f, -0.18460871f, 0.11046526f, -0.01188921f, -0.20814194f, -0.10425216f, -0.11139515f, 
    -0.47614667f, 0.43347555f, 0.19511577f, -1.13935769f, -0.32437500f, -0.25972846f, 0.00541595f, -0.36769730f, 
    0.04364257f, -0.03795231f, 0.04114821f, 0.00328097f, 0.20963840f, 0.44832394f, 0.45672312f, -0.24423611f, 
    -0.03249846f, -0.44119778f, -0.31303206f, -0.15048139f, -0.14865692f, 0.04727723f, 0.09204951f, 0.10327215f, 
    -0.56306428f, 0.11606780f, 0.07156419f, 0.33534479f, 0.08382104f, 0.14689879f, -0.09980255f, -0.06346040f, 
    0.15990621f, -0.01760022f, 0.06170254f, 0.17710114f, -0.16911118f, -0.27324983f, -0.42737859f, 0.08458225f, 
    -0.11463629f, 0.06760207f, 0.10498118f, -0.10604899f, 0.06791605f, 0.00697525f, -0.02023700f, -0.06010617f, 
    0.08049461f, -0.93635851f, 0.28336945f, 0.15421605f, -0.02920271f, -0.03570889f, -0.22670703f, -0.24793968f, 
    -0.00782489f, 0.04886471f, -0.13158178f, -0.03328730f, -0.26276606f, 0.21992676f, 0.23306698f, 0.04982221f, 
    0.03470298f, 0.20529903f, 0.18223317f, -0.05195013f, 0.00272924f, 0.17748839f, -0.00954053f, -0.14654575f, 
    0.15319966f, -0.19277567f, 0.16508104f, 0.15109679f, 0.01166296f, 0.14062265f, 0.04016776f, 0.06718390f, 
    0.12265476f, 0.06862867f, 0.15032941f, 0.26240575f, -0.31258881f, 0.26432613f, 0.21552008f, -0.28952491f, 
    -0.03312163f, -0.33102417f, -0.12543567f, -0.25123337f, 0.15453349f, -0.08989155f, 0.18127903f, 0.01313211f, 
    -0.14427631f, -0.23508298f, 0.00304751f, -0.26703328f, -0.10883345f, -0.06453646f, 0.12593198f, -0.01399441f, 
    0.13608132f, 0.05273623f, 0.05359126f, -0.04229148f, 0.13905296f, -0.52671736f, 0.14376004f, -0.22659600f, 
    0.05369107f, -0.01504395f, -0.20612019f, 0.07167026f, -0.16485722f, -0.13805912f, -0.10382050f, -0.02087788f, 
    0.47450402f, 0.04326570f, 0.41920272f, -0.07415567f, 0.05877920f, -0.07337289f, -0.01991815f, -0.25536051f, 
    -0.07630518f, 0.00087550f, -0.07869104f, 0.07907774f, -0.20134786f, -0.05561158f, -0.28966299f, 0.11737303f, 
    0.06560450f, 0.15542521f, 0.04524830f, 0.15051620f, -0.00326527f, -0.07136381f, -0.13302952f, -0.01833983f, 
    0.37027663f, 0.02894083f, -0.05688424f, 0.32110280f, -0.03588052f, -0.07725333f, 0.00018077f, 0.05297975f, 
    -0.03911198f, 0.10434895f, 0.19931518f, 0.15999326f, 0.20436189f, -0.06894635f, -0.00081967f, -0.10790963f, 
    0.08601494f, -0.09507924f, 0.01643727f, 0.04214715f, 0.20808603f, 0.08039325f, -0.25942251f, 0.00187499f, 
    -0.66087341f, 0.07820183f, 0.19011973f, -0.19340333f, 0.02263102f, -0.08593325f, -0.13802011f, 0.26229334f, 
    -0.05797961f, 0.10407378f, 0.21169977f, -0.03417911f, 0.08939569f, -0.24464551f, 0.41902944f, -0.06938626f, 
    0.10587336f, -0.40504918f, -0.00692845f, -0.02778333f, -0.08803129f, -0.05403228f, 0.06564609f, -0.01660295f, 
    0.28712165f, 0.25025836f, 0.21013893f, -0.17222038f, 0.28459245f, -0.25811410f, 0.07483792f, 0.04034140f, 
    0.11435478f, -0.11983346f, 0.06697154f, 0.00180716f, -0.00095595f, -0.24154638f, 0.24377260f, 0.04836034f, 
    -0.07895599f, -0.06107403f, -0.31826925f, -0.06455624f, 0.02514528f, -0.06425221f, 0.00050121f, -0.01319011f, 
    -0.42119530f, 0.09542514f, -1.06185508f, 0.42745671f, 0.15635258f, 0.02619366f, 0.28294826f, 0.10026961f, 
    0.10757708f, -0.03742988f, -0.06242125f, -0.04748027f, 0.02330895f, -0.50741184f, -0.25613725f, 0.26998675f, 
    0.11677420f, 0.02989210f, 0.09830109f, 0.10617927f, -0.04043704f, 0.05730381f, -0.03070959f, 0.04082101f, 
    -0.00393537f, -0.10490128f, -0.17608367f, -0.07028970f, -0.02498872f, 0.04405072f, 0.07063536f, -0.06496918f, 
    -0.08281253f, 0.12672111f, 0.08315451f, -0.13830855f, -0.39398530f, 0.13072863f, 0.23458542f, 0.29847082f, 
    0.03211503f, -0.02530996f, -0.07375737f, -0.21418275f, 0.04780987f, 0.05341101f, -0.07783035f, 0.18696025f, 
    -0.18456230f, 0.30133504f, -0.07888878f, -0.10036933f, 0.11668502f, -0.09873842f, -0.10667954f, -0.10180076f, 
    0.17494990f, 0.01343077f, 0.03810193f, -0.13512158f, 0.25371465f, 0.34819940f, 0.26675445f, 0.18468972f, 
    -0.12867126f, -0.14030907f, -0.12888381f, -0.12734693f, 0.01513300f, 0.00919004f, 0.10548566f, -0.00518363f, 
    -0.30213311f, -0.00418632f, -0.06957451f, -0.36195984f, -0.18848449f, 0.14741087f, -0.27929536f, 0.00852994f, 
    -0.00641054f, -0.28787825f, 0.13940388f, -0.04575664f, -0.07036953f, -0.14149015f, 0.12004238f, -0.42994595f, 
    -0.22815815f, -0.24306406f, 0.14962649f, -0.03052763f, -0.15333112f, -0.14971472f, 0.16017199f, 0.05826573f, 
    0.01498817f, 0.02822091f, 0.21420041f, 0.13548049f, -0.14952949f, 0.10695532f, 0.09250276f, -0.14131092f, 
    0.14384608f, -0.11739717f, 0.10106290f, 0.19728851f, -0.06965756f, -0.61202788f, 0.02412295f, 0.13260038f, 
    -0.07978982f, -0.00519177f, -0.06673314f, 0.27624273f, 0.07594106f, 0.11453697f, 0.02271938f, -0.03019223f, 
    0.08830224f, -0.41590998f, 0.04923590f, 0.50536871f, -0.05452835f, -0.16717371f, 0.05915095f, -0.12204187f, 
    -0.16743597f, -0.11805067f, -0.18436289f, -0.01991771f, -0.26196188f, -0.20290664f, -0.18947239f, 0.12347621f, 
    0.04513872f, 0.11885459f, -0.07030752f, -0.22368985f, 0.02920075f, 0.05072128f, -0.09126399f, 0.03572741f, 
    -0.62194473f, -0.26700214f, -0.12340396f, 0.13604778f, -0.08162680f, 0.26490152f, -0.36634418f, 0.02864600f, 
    0.11893704f, -0.05411546f, -0.05965177f, -0.09789883f, 0.01467431f, 0.28699574f, 0.11722392f, 0.22617555f, 
    -0.15220964f, 0.18709448f, 0.28637239f, -0.03367547f, -0.02766496f, 0.10696152f, 0.17356351f, 0.10153025f, 
    0.22542834f, 0.09220044f, 0.57560211f, 0.07855784f, -0.08439597f, 0.06396116f, 0.28867280f, -0.07945994f, 
    0.18397847f, 0.09618646f, 0.11712343f, -0.00538997f, -0.34652686f, 0.15944560f, -0.02068228f, 0.04360293f, 
    -0.02497149f, 0.03961303f, -0.04021123f, 0.21801645f, 0.07664744f, -0.02601001f, -0.00959171f, -0.13959190f, 
    0.37750971f, -0.37003520f, 0.28114039f, -0.04814885f, -0.16346610f, 0.15394697f, 0.14535342f, 0.21538942f, 
    -0.05692481f, -0.01892998f, -0.10622455f, 0.19905390f, -0.03252216f, 0.16609642f, -0.09958947f, -0.48108310f, 
    -0.14563809f, 0.02028166f, 0.03613883f, -0.10541426f, 0.21875760f, -0.03630483f, 0.03258610f, 0.06087681f, 
    -0.67584836f, 0.40677491f, -0.50340229f, -0.06326616f, -0.07360809f, 0.08151568f, 0.16105904f, 0.05954340f, 
    -0.12822418f, 0.20855814f, 0.13419512f, 0.21813317f, -0.29243204f, -0.05933931f, -0.15202697f, -0.00618397f, 
    -0.12809180f, -0.03933964f, -0.41895714f, 0.01157686f, 0.02175335f, -0.02423634f, 0.12812440f, -0.15400341f, 
    -0.24572054f, 0.44581887f, -0.09146441f, -0.23345579f, -0.03796391f, 0.02462774f, -0.03261341f, -0.05151434f, 
    -0.04802322f, -0.17080458f, -0.34683087f, -0.41449636f, 0.46450278f, -0.11003280f, 0.38317651f, -0.12142407f, 
    -0.15167196f, -0.08164914f, -0.00794104f, -0.01002691f, -0.00059013f, 0.17512511f, 0.04290754f, 0.03070452f, 
    0.29337719f, -0.61583591f, -0.19719511f, 0.06075815f, -0.05931033f, -0.04081073f, 0.21612437f, 0.23808129f, 
    -0.06381867f, 0.00236313f, -0.04655936f, -0.22815755f, -0.07356515f, 0.85590065f, 0.08555180f, 0.47025070f, 
    0.02597909f, 0.17818333f, -0.37220952f, 0.12254249f, 0.07119063f, -0.05926987f, -0.09211334f, 0.07589141f, 
    -0.05189520f, 0.26246262f, 0.05604865f, 0.18638657f, 0.00688775f, -0.19448504f, -0.04190202f, -0.12846150f, 
    0.04602889f, 0.17871578f, -0.15407741f, -0.09091617f, 0.10181105f, 0.43968514f, 0.08576655f, -0.11785565f, 
    -0.27082288f, 0.03696229f, 0.17352186f, -0.09906495f, -0.01692174f, -0.04183187f, 0.01944153f, 0.10642228f, 
    -0.62763900f, 0.49048856f, -0.22831237f, -0.14472602f, -0.05393024f, 0.33994895f, 0.13298857f, 0.11567447f, 
    -0.34912339f, -0.40564346f, -0.59532213f, -0.44754001f, -0.19300871f, 0.13192040f, 0.33266500f, 0.07579537f, 
    -0.04147301f, 0.02341902f, 0.15584838f, 0.13957402f, 0.11184286f, 0.04855938f, 0.22017166f, 0.11013441f, 
    -0.05168324f, -0.50184023f, -0.11503954f, 0.07709997f, 0.09478924f, 0.13988376f, -0.49167991f, -0.08069292f, 
    0.03099011f, 0.01147444f, 0.10869551f, -0.13652875f, -0.14529714f, 0.22590797f, -0.31148040f, 0.13709483f, 
    -0.19399765f, -0.17699853f, 0.10165697f, 0.12146197f, 0.08613179f, 0.26045984f, 0.06819917f, 0.11110245f, 
    0.12188843f, -0.00858506f, -0.02623037f, 0.19679697f, -0.36465383f, 0.06179317f, 0.06536887f, -0.03561810f, 
    -0.04744379f, 0.23320159f, 0.14130698f, 0.36380932f, -0.24271478f, 0.15449776f, 0.25979698f, 0.23059468f, 
    0.08161981f, 0.07053376f, 0.01365530f, 0.13995168f, -0.00285627f, 0.02884384f, 0.01854170f, -0.16092159f, 
    -0.01294628f, 0.15212964f, -0.44524133f, 0.11369829f, -0.29136905f, -0.28081539f, -0.02838131f, 0.06846205f, 
    -0.21822295f, 0.07317095f, -0.13806884f, -0.04751416f, -0.22362576f, -0.03532060f, -0.22275634f, -0.12558275f, 
    -0.24787048f, -0.04361491f, 0.06998624f, -0.07066067f, 0.04866594f, -0.02447125f, 0.01351100f, 0.15991834f, 
    -0.07516757f, -0.15698236f, -0.26192966f, -0.13582458f, -0.24623060f, -0.29010028f, -0.04297194f, -0.01926449f, 
    -0.00492799f, 0.08031756f, -0.07712901f, -0.04871193f, -0.24339952f, 0.17123406f, 0.10086711f, -0.28055733f, 
    0.02726810f, 0.00027683f, 0.00703666f, 0.06799538f, -0.07922322f, -0.14993112f, -0.37533715f, -0.68330902f, 
    0.28699583f, 0.02930908f, 0.83217824f, 0.06633715f, -0.18344811f, 0.15870005f, 0.11599269f, -0.04257125f, 
    0.00454070f, 0.06310455f, -0.03803796f, 0.22869252f, -0.08801246f, 0.07152499f, -0.05336745f, -0.08209246f, 
    0.06245307f, -0.04466467f, -0.11582558f, 0.04521052f, -0.26474375f, -0.00839379f, -0.48182082f, -0.60008574f, 
    -0.23740992f, 0.12203976f, -0.02967606f, -0.04226869f, -0.18324971f, 0.22328466f, 0.08252593f, 0.16684458f, 
    -0.13377130f, 0.18876567f, -0.03568790f, -0.10558173f, -0.09847931f, 0.06224479f, -0.14773205f, -0.06527290f, 
    -0.14271007f, 0.16315655f, -0.10429121f, 0.08721194f, -0.08834463f, -0.00386916f, -0.05523476f, -0.11356343f, 
    -0.26050270f, 0.08042221f, -0.35364008f, -0.01751295f, 0.04850214f, 0.03188105f, 0.04774148f, 0.08816051f, 
    0.08207551f, -0.02176236f, 0.16696312f, -0.27515775f, -0.24339518f, -0.63741076f, -0.08776847f, 0.09121888f, 
    -0.29535058f, -0.06179486f, -0.25244972f, -0.22537488f, 0.04388819f, 0.06557500f, 0.02348620f, -0.06322381f, 
    0.03016758f, 0.00518931f, 0.63074654f, 0.11286572f, 0.04197127f, 0.13340503f, 0.09725531f, -0.09814853f, 
    0.06105187f, -0.03517667f, 0.15920894f, 0.03632307f, 0.59727925f, -0.37211108f, 0.25302923f, -0.20483561f, 
    -0.07517236f, -0.18841378f, -0.27291730f, -0.07537921f, -0.07442059f, 0.01882172f, 0.11440937f, -0.03564439f, 
    0.40315968f, 0.52776903f, -0.23320371f, -0.09739479f, -0.11793720f, 0.12415553f, 0.09651689f, -0.01541239f, 
    -0.02698860f, -0.12475633f, -0.01840472f, -0.00765656f, -0.06222497f, -0.17785320f, 0.54510301f, 0.32890329f, 
    0.20115256f, 0.12530860f, -0.07611974f, 0.15602516f, 0.01718376f, -0.17473476f, -0.25718847f, -0.22397053f, 
    -0.80465817f, -0.08925815f, 0.39743826f, -0.70605874f, -0.16747409f, -0.09729683f, 0.12621105f, 0.11928830f, 
    0.20101033f, 0.11775095f, -0.15901265f, 0.06275796f, -0.42206216f, -0.00660490f, -0.31146988f, 0.02729611f, 
    -0.09522458f, -0.20349903f, 0.03525016f, -0.02505606f, 0.02018872f, 0.09153423f, -0.15173784f, -0.13255303f, 
    0.22053264f, 0.02696770f, 0.12759741f, -0.07630774f, 0.00507577f, 0.16595320f, -0.05396561f, -0.03415069f, 
    0.06168959f, 0.04918236f, 0.06492940f, 0.03351896f, 0.35805610f, -0.04737554f, 0.05374517f, 0.17018032f, 
    0.00438484f, -0.09994012f, -0.06536012f, -0.06377425f, -0.12612630f, 0.08941136f, -0.06566289f, -0.03021943f, 
    -0.37976995f, -0.11406982f, -0.71511722f, 0.25657314f, -0.02913401f, -0.11249156f, 0.02349227f, 0.02734428f, 
    0.04046509f, 0.01920829f, 0.10864262f, -0.11999553f, 0.04465764f, -0.21151981f, 0.15054497f, 0.04976708f, 
    0.00189953f, -0.06463533f, 0.22293854f, 0.24599342f, -0.05706507f, 0.16944167f, 0.10935988f, -0.15702860f, 
    0.09673462f, 0.14107096f, -0.16227636f, 0.01854494f, -0.01819175f, -0.03699789f, -0.00193167f, 0.00344781f, 
    0.04064460f, 0.14567237f, -0.19143131f, 0.04326390f, 0.11068194f, -0.16664688f, 0.10893628f, -0.29008314f, 
    0.08480286f, -0.06371015f, 0.28404188f, -0.14334616f, 0.05561329f, 0.13017257f, 0.08765342f, -0.18522823f, 
    0.02756640f, -0.02728225f, -0.02826014f, -0.54293311f, -0.19808120f, 0.09497837f, 0.18493950f, 0.06872775f, 
    0.03471882f, 0.10783865f, 0.03725055f, 0.03109015f, -1.01476610f, 0.37076432f, -0.27561641f, 0.41563377f, 
    -0.09478748f, -0.04089340f, 0.25713089f, 0.23078467f, -0.14377251f, -0.01996096f, 0.17282677f, 0.08649972f, 
    -0.64068419f, 0.51868761f, -0.32436293f, 0.10958000f, 0.24353610f, -0.16449447f, 0.08964619f, 0.15644936f, 
    -0.27091178f, -0.00621021f, -0.04398877f, -0.08674137f, 0.09342948f, -0.16910592f, 0.20871383f, -0.17593640f, 
    -0.01785996f, 0.17174248f, -0.08444981f, -0.15106001f, 0.07764683f, -0.21399690f, -0.02566357f, -0.20958997f, 
    -0.18519694f, -0.46057945f, 0.20109040f, 0.53238463f, 0.18133041f, -0.27254581f, 0.16459903f, 0.18736631f, 
    0.22812168f, 0.02380997f, 0.24563305f, 0.19581856f, -0.06479008f, 0.10334730f, -0.25007221f, 0.03622736f, 
    0.08917797f, 0.09765922f, -0.11073978f, -0.05345440f, -0.11119357f, -0.02326241f, 0.01224331f, -0.33675185f, 
    -0.17839357f, -0.91448611f, 0.30224806f, 0.18969111f, -0.24136901f, 0.03671244f, 0.00130881f, -0.07095709f, 
    -0.00657668f, 0.02332499f, -0.01980188f, 0.02038155f, -0.15055393f, -0.23498587f, 0.06017746f, -0.48179334f, 
    0.02079682f, 0.00508701f, -0.19247274f, -0.16770908f, -0.13348293f, -0.06303621f, 0.05642420f, -0.08971662f, 
    -0.09979858f, -0.20815465f, 0.06859006f, 0.07525327f, -0.01810133f, 0.08451820f, 0.01809993f, 0.34381565f, 
    -0.18674263f, -0.14850514f, -0.15460216f, -0.03864238f, -0.33399853f, 0.31268546f, -0.70457816f, 0.63115698f, 
    0.12276843f, 0.19273491f, 0.27693903f, -0.14019713f, 0.05368823f, 0.17222749f, 0.22447851f, 0.23918189f, 
    0.60400921f, -0.16422102f, 0.45798710f, -0.20488825f, 0.02422730f, 0.02898393f, -0.21047448f, 0.07625708f, 
    -0.11191854f, 0.05014827f, 0.03255445f, -0.05680021f, 0.53905380f, -0.07113811f, 0.07371205f, -0.36440641f, 
    -0.08271076f, 0.09954183f, -0.20705958f, 0.04058561f, -0.02704233f, -0.04979078f, -0.08462061f, -0.10189378f, 
    0.02337860f, -0.25149104f, 0.32900396f, 0.02837806f, -0.03343417f, -0.01774103f, 0.25074863f, -0.06587426f, 
    -0.25606892f, -0.11330363f, 0.02345478f, 0.02962462f, -0.00333573f, -0.53976440f, 0.15774921f, -0.40407813f, 
    0.11714715f, -0.09117091f, -0.00787621f, -0.05382576f, 0.07776871f, 0.13443580f, 0.27753377f, 0.01561298f, 
    0.26908869f, -0.11254071f, 0.02378290f, -0.18341154f, -0.07381523f, 0.17499052f, 0.06523404f, 0.01969333f, 
    -0.11164712f, 0.00591282f, 0.14421295f, 0.30085552f, -0.57073653f, -0.02537620f, -0.23514555f, 0.05490740f, 
    -0.05942483f, -0.24009120f, 0.03805759f, -0.10479659f, -0.20144865f, -0.16687916f, -0.14509167f, 0.09905583f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14486736f, 0.17926955f, 0.06068852f, -0.14465187f, -0.11140686f, 0.07429202f, 0.06059452f, -0.19622825f, 
    0.14738782f, -0.00365676f, 0.03700309f, -0.01750411f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
